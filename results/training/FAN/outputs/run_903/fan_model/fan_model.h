/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.22069448e-01f, 3.14988457e-02f, -1.55205622e-01f, -4.53758352e-02f, 6.70017675e-02f, -7.34359547e-02f, -1.08458623e-01f, 3.11953928e-02f, 9.77983773e-02f, 1.85990147e-02f,
  -3.93631682e-02f, 1.80210754e-01f, 6.09794520e-02f, 1.47943139e-01f, 3.61086652e-02f, -6.41250908e-02f, -1.24423943e-01f, -6.17569895e-04f, 2.11061276e-02f, 1.27843142e-01f,
  1.14553906e-01f, -8.51287693e-03f, 3.55594270e-02f, 5.73586784e-02f, -7.92954490e-02f, 4.40285504e-02f, -4.31219451e-02f, -9.07977000e-02f, 3.46828364e-02f, -6.68043718e-02f,
  -1.30415842e-01f, -5.85995056e-02f, 7.38389343e-02f, 1.86706424e-01f, -3.40685882e-02f, -1.97137473e-03f, -3.33745331e-02f, 7.07615465e-02f, 1.07112065e-01f, 2.85415612e-02f,
  3.97327952e-02f, 3.56778651e-02f, 5.29006869e-02f, -1.22767501e-01f, -2.74568778e-02f, -2.03719400e-02f, -6.09167740e-02f, -1.11460332e-02f, -2.16294695e-02f, -5.53384721e-02f,
  -2.21617352e-02f, 3.58038838e-03f, -1.12193078e-01f, 9.77214351e-02f, 5.17977066e-02f, 6.46965951e-02f, -5.44570386e-02f, 3.96011490e-03f, -2.79208925e-02f, -8.76979232e-02f,
  -2.93846428e-03f, 5.32467291e-02f, -3.23590077e-02f, -1.13651119e-01f, -6.99736997e-02f, -6.91417381e-02f, -1.84275918e-02f, 1.80423073e-03f, 3.35938558e-02f, -6.13933876e-02f,
  -5.16255060e-03f, 2.26679146e-02f, -1.11100113e-03f, -7.67911449e-02f, -3.49219074e-03f, -4.94188257e-02f, -5.50861582e-02f, 8.99380352e-03f, -8.42529908e-02f, 1.09871216e-02f,
  5.19948043e-02f, 5.38119040e-02f, 6.91510923e-03f, -2.59657148e-02f, 8.28303844e-02f, 1.61937382e-02f, 1.62154939e-02f, -2.92578638e-02f, -6.63591456e-03f, 2.01844126e-02f,
  -6.82364404e-02f, 1.23977937e-01f, -4.83766384e-02f, 2.14034878e-02f, 2.64109168e-02f, -6.39593974e-02f, -3.50817330e-02f, 5.09124175e-02f, 4.71783988e-02f, -6.78781196e-02f,
  5.10307811e-02f, -7.65900388e-02f, 8.42863601e-03f, -2.35151108e-02f, -1.23673998e-01f, -5.90071417e-02f, 9.72424746e-02f, 6.93246275e-02f, 2.41617486e-02f, 9.13614593e-03f,
  3.65984663e-02f, -6.04139939e-02f, 3.76083590e-02f, 6.81418553e-02f, -9.92826521e-02f, 6.77081794e-02f, 5.12930714e-02f, -3.85284983e-02f, -4.83010598e-02f, -1.19899452e-01f,
  5.23801208e-01f, -4.80658822e-02f, -1.11133708e-02f, 3.34385969e-02f, -3.16833728e-03f, 4.71815318e-02f, 4.04552408e-02f, 3.12064383e-02f, 1.66152179e-01f, 5.51829375e-02f,
  -1.28677234e-01f, -1.48586512e-01f, -1.57896355e-02f, -1.21331923e-01f, 1.27585471e-01f, 1.20422523e-02f, -3.62493806e-02f, 1.00795008e-01f, 2.15786044e-02f, -1.15823820e-01f,
  -2.76516695e-02f, 6.99395537e-02f, 1.03070371e-01f, 8.00868869e-02f, -7.07371766e-03f, -2.77714487e-02f, 7.05843493e-02f, -8.09502900e-02f, -3.73363905e-02f, -1.29447892e-01f,
  -3.09192687e-01f, 7.39956424e-02f, 6.30479679e-02f, -2.92071998e-02f, -3.03155798e-02f, 7.62712210e-02f, -7.08430484e-02f, 5.77046126e-02f, -1.15401065e-02f, 4.66492660e-02f,
  -5.84238432e-02f, -6.69361092e-03f, 4.51335078e-03f, -1.02519609e-01f, 7.26939142e-02f, 1.33784870e-02f, 9.18301195e-02f, -2.46992372e-02f, 4.00435328e-02f, -4.67471592e-02f,
  -1.00281715e-01f, -5.52486256e-02f, -8.68607759e-02f, 6.11403100e-02f, -3.85359526e-02f, -2.55319569e-02f, -1.91224401e-03f, 2.68511269e-02f, -6.69065267e-02f, -2.19898112e-02f,
  7.28084669e-02f, 2.13569123e-02f, 5.93130924e-02f, -6.29910976e-02f, -1.57351848e-02f, -4.42305915e-02f, 3.96497659e-02f, -4.81103621e-02f, 5.23064919e-02f, -1.20555004e-02f,
  -1.08988553e-01f, -6.28109872e-02f, -6.72379807e-02f, 3.87501307e-02f, 1.99655313e-02f, 2.07573771e-02f, 2.81730872e-02f, 6.48932345e-03f, -2.73702238e-02f, 8.39825198e-02f,
  9.20797349e-04f, -9.80129279e-03f, -7.33029246e-02f, -1.23083787e-02f, -2.61614174e-02f, -4.13279273e-02f, -1.19002173e-02f, -7.02018440e-02f, 1.24167399e-02f, -7.38723949e-03f,
  3.72635457e-03f, -3.54053043e-02f, -5.77480681e-02f, 1.07222423e-01f, -5.25911972e-02f, -2.78230174e-03f, -8.57982635e-02f, -4.53295000e-02f, -6.77460805e-02f, -1.90725736e-02f,
  3.14754173e-02f, 8.59552175e-02f, -1.59382389e-03f, -6.62422627e-02f, 3.79456319e-02f, 1.57001324e-03f, -4.75677215e-02f, -6.31112605e-03f, 4.17117439e-02f, 3.17827566e-03f,
  6.75307587e-02f, -3.60178389e-02f, 9.59753841e-02f, 7.35032707e-02f, -6.56161159e-02f, -1.90912690e-02f, -9.19388533e-02f, 1.95787624e-02f, -2.26524323e-02f, 1.44572467e-01f,
  2.35601887e-03f, 3.90681066e-02f, 2.34570369e-01f, -8.50100517e-02f, 3.37048434e-02f, 2.35568300e-01f, 7.52431825e-02f, 1.96269229e-01f, 2.09058505e-02f, 3.52772214e-02f,
  -8.82210955e-02f, -1.23106942e-01f, 2.46785153e-02f, -4.48575951e-02f, 1.33440077e-01f, 2.44392511e-02f, 4.39974628e-02f, 7.02960417e-02f, 1.64100856e-01f, 7.76067004e-02f,
  -2.09477544e-02f, 1.46672025e-01f, 1.55536935e-01f, 5.64587414e-02f, -5.68155907e-02f, 6.21272288e-02f, 6.57899398e-03f, 1.05662964e-01f, 5.69805838e-02f, 2.46446151e-02f,
  1.57868192e-01f, 1.71261877e-01f, -3.72959115e-02f, -2.55060401e-02f, 1.43341459e-02f, -2.62931716e-02f, 8.61122552e-03f, -2.67981086e-02f, -9.11417007e-02f, 8.28440208e-03f,
  -6.18728437e-02f, 3.99844907e-02f, 5.85563853e-02f, 6.96022362e-02f, -1.19150069e-03f, -6.46604747e-02f, -3.56125422e-02f, 1.09595794e-03f, 7.10874647e-02f, 4.17960361e-02f,
  -1.59871504e-01f, -7.01895803e-02f, 8.13265666e-02f, 5.09328172e-02f, 4.44369465e-02f, -5.59740625e-02f, -1.77117344e-02f, -1.22431284e-02f, 7.75069445e-02f, 1.28501713e-01f,
  2.28764843e-02f, -2.73811799e-02f, -4.60748449e-02f, 1.11334614e-01f, 1.16035175e-02f, 3.76990661e-02f, -7.05791786e-02f, 2.17536353e-02f, -4.81951796e-02f, 2.70038061e-02f,
  -8.18822831e-02f, -1.06631266e-02f, 3.97024229e-02f, 1.27961375e-02f, -5.16130961e-02f, -2.92295180e-02f, 7.01090321e-02f, 5.32149244e-03f, -5.76635916e-03f, 1.17052523e-02f,
  -2.93371100e-02f, 6.49951305e-03f, -7.03384653e-02f, 4.43304181e-02f, -4.54353355e-02f, -2.24391073e-02f, -3.16964462e-02f, 9.62596945e-03f, -9.58334878e-02f, 5.94329461e-02f,
  1.67358499e-02f, -9.33530778e-02f, -1.47584165e-02f, -5.01643755e-02f, -9.27838776e-03f, -8.85210484e-02f, -2.08276906e-03f, 3.22616175e-02f, -3.39522772e-03f, 8.85879099e-02f,
  5.35222441e-02f, 5.69523200e-02f, -2.32442971e-02f, 2.40817890e-02f, -3.15833767e-03f, 7.02612251e-02f, -4.07423116e-02f, 4.54891846e-02f, 3.93283665e-02f, -5.40060066e-02f,
  1.53894993e-02f, 8.94103423e-02f, 5.27311582e-03f, 1.81443822e-02f, 1.19940616e-01f, 8.01891554e-03f, 2.01653108e-01f, 7.62347654e-02f, 8.91410187e-02f, 4.50746827e-02f,
  -1.75886620e-02f, 1.28526568e-01f, 2.19603941e-01f, -5.28934002e-02f, -4.79800776e-02f, -2.83831358e-02f, 8.28278437e-02f, -3.34650613e-02f, 1.73678473e-02f, 6.33436665e-02f,
  -2.03864146e-02f, -2.52873302e-01f, -1.13352783e-01f, -1.52051896e-01f, -1.00839511e-01f, 1.54039204e-01f, 7.83596262e-02f, -6.65931255e-02f, -9.52896662e-03f, -9.20379236e-02f,
  -3.05189360e-02f, -2.14617588e-02f, -6.10191710e-02f, -5.15281549e-03f, 1.37228027e-01f, -7.87936673e-02f, 5.57914265e-02f, 1.17892385e-01f, 2.34373529e-02f, 1.22254811e-01f,
  -2.90541053e-02f, 7.15117604e-02f, -3.19644134e-03f, -1.41348680e-02f, 3.90077233e-02f, 3.40464991e-03f, -3.08968183e-02f, 9.06193331e-02f, -6.86673075e-02f, 3.02541908e-02f,
  -7.62351081e-02f, -1.06531769e-01f, -9.72415134e-03f, 7.57525787e-02f, 1.01516344e-01f, -8.74459296e-02f, 1.20273776e-01f, 4.20790985e-02f, 6.78057820e-02f, -8.54861271e-03f,
  7.43516386e-02f, -8.36349372e-03f, -1.65019222e-02f, -4.02142541e-05f, -1.29235424e-02f, -5.23704812e-02f, 1.76407844e-02f, 3.87483425e-02f, -6.35771528e-02f, 1.39212325e-01f,
  -1.81458462e-02f, 1.61694698e-02f, -3.64752574e-04f, 2.63486039e-02f, -2.71868706e-02f, 4.87175211e-02f, 2.46029962e-02f, 2.65123490e-02f, 9.86638479e-03f, -1.70791037e-02f,
  2.08791369e-03f, 1.32194519e-01f, -7.61685371e-02f, -5.43469973e-02f, 3.32864337e-02f, 5.35805859e-02f, -1.99050847e-02f, -9.13571194e-03f, 1.12449406e-02f, -5.36359986e-03f,
  1.03439748e-01f, 1.43975392e-02f, 2.60819774e-02f, 7.65849799e-02f, -5.04022976e-03f, -7.69441351e-02f, -7.67677501e-02f, -4.81799990e-03f, -1.45970453e-02f, -9.09137353e-02f,
  8.92622769e-03f, -1.10409290e-01f, -5.54655865e-02f, -3.66863422e-02f, 6.95976764e-02f, -9.95321870e-02f, -2.53843935e-03f, -1.72314644e-02f, -4.79856655e-02f, 4.66768965e-02f,
  -2.74045356e-02f, -1.70632601e-01f, -2.00392734e-02f, -3.81520726e-02f, -8.82827491e-03f, -2.56991317e-03f, -1.14910780e-02f, 1.51328202e-02f, -8.40638429e-02f, -1.35845887e-02f,
  4.80694696e-02f, -7.29198148e-03f, -3.65326740e-02f, -5.75840846e-02f, -3.76156084e-02f, -4.20500673e-02f, 5.36543317e-02f, 5.45607209e-02f, -1.37804702e-01f, 5.75284474e-02f,
  -4.70463187e-01f, 1.51018173e-01f, -2.34872803e-01f, -3.39878798e-01f, -4.24467087e-01f, -2.79478207e-02f, 1.37935653e-01f, 3.43658142e-02f, -1.07889496e-01f, 1.08109668e-01f,
  1.28055021e-01f, -1.79959956e-04f, 9.76000279e-02f, 1.79595292e-01f, 4.44757752e-02f, 7.26618841e-02f, -2.20265672e-01f, -2.34609291e-01f, -2.26204857e-01f, -2.03617290e-01f,
  -6.57102987e-02f, -3.65063906e-01f, -3.84734660e-01f, -6.76596686e-02f, -8.98806900e-02f, 3.74652632e-03f, 4.69858386e-02f, -2.10748702e-01f, 9.62128341e-02f, -4.03488666e-01f,
  -8.82200152e-02f, -1.52481392e-01f, -2.28018463e-02f, -3.96286584e-02f, 2.67477334e-03f, -1.14724110e-03f, -6.22842386e-02f, -7.80997053e-02f, 1.29732534e-01f, -7.85467401e-02f,
  -5.31345084e-02f, -4.84068282e-02f, -1.10869609e-01f, -7.28728250e-02f, -4.76535148e-04f, 1.22537538e-02f, 2.34019645e-02f, -6.27609789e-02f, 7.30272103e-03f, 7.09936246e-02f,
  -5.63151166e-02f, -1.59338847e-01f, -1.56018466e-01f, 5.20016067e-02f, 9.06835347e-02f, -3.34227756e-02f, 7.84359872e-03f, -7.75521994e-02f, 3.04956306e-02f, 7.01143742e-02f,
  2.67380308e-02f, 3.71540990e-03f, -3.01982299e-03f, 1.65074617e-02f, 4.06057090e-02f, 1.23989591e-02f, 1.68689117e-02f, -5.00484183e-02f, 6.61984971e-03f, -3.33783813e-02f,
  4.55579571e-02f, -5.40036010e-03f, 2.43352987e-02f, -2.63377707e-02f, 2.77784299e-02f, -3.80305201e-02f, 2.59656203e-03f, -4.20724228e-02f, 7.72312982e-03f, -7.35099707e-03f,
  -2.29022894e-02f, 6.24384265e-03f, -9.82634276e-02f, 7.57925734e-02f, -2.62162872e-02f, 1.93947516e-02f, -2.05558147e-02f, 8.93416442e-03f, 6.41668364e-02f, -1.31462906e-02f,
  1.71530426e-01f, 1.37517145e-02f, -5.43476781e-03f, 6.32358417e-02f, -6.58065975e-02f, 6.95429817e-02f, 3.30182537e-02f, 6.77419081e-02f, 4.46645601e-04f, -1.91571712e-02f,
  -4.06821296e-02f, 6.37237877e-02f, -9.96869151e-03f, 1.26284242e-01f, -2.07515713e-02f, -3.56819592e-02f, 9.05733556e-02f, 2.44952738e-02f, 1.70093812e-02f, 1.60636175e-02f,
  7.22956210e-02f, 5.41342832e-02f, 5.64764738e-02f, 8.12996998e-02f, 2.19962932e-02f, -5.13128238e-03f, 8.89135972e-02f, -6.30524382e-02f, 1.03411138e-01f, 3.15903962e-01f,
  -2.17362776e-01f, -1.99123651e-01f, -2.09189206e-02f, -8.61397851e-03f, -2.80597862e-02f, 1.89415395e-01f, 5.83236925e-02f, 9.25234705e-02f, 2.18328506e-01f, -1.01547199e-03f,
  -2.91342959e-02f, 3.85819934e-02f, 4.16787118e-02f, 4.78288101e-04f, -6.81558996e-02f, 7.66915921e-03f, -1.16106160e-02f, -1.13803670e-01f, 1.58348575e-01f, -5.31676672e-02f,
  -8.42350200e-02f, -3.27282995e-02f, -6.55362606e-02f, 2.39378065e-02f, -4.08943743e-02f, 2.30267271e-01f, 2.86669582e-02f, -1.01437673e-01f, -8.71620234e-03f, -2.91931719e-01f,
  -9.48163215e-03f, -2.00766131e-01f, 7.90246055e-02f, -6.19481225e-03f, -5.31065203e-02f, -8.28589872e-02f, -1.14416168e-03f, -2.30010338e-02f, -7.44833723e-02f, -1.68154966e-02f,
  -3.15547548e-02f, 2.09521689e-03f, -7.03315735e-02f, -6.26368448e-02f, 4.63180207e-02f, -5.19448966e-02f, -5.28206155e-02f, -1.28602441e-02f, -1.60090327e-02f, -3.44776586e-02f,
  -1.28618300e-01f, -3.60583961e-02f, 7.75255710e-02f, 5.83096929e-02f, -1.24958321e-01f, 1.71589442e-02f, -5.21423742e-02f, -1.08767994e-01f, -8.08932702e-04f, -8.51179734e-02f,
  2.02102363e-02f, 4.99042124e-02f, -5.78156160e-03f, 8.97548534e-03f, 1.16577847e-02f, 4.10476588e-02f, 1.42150633e-02f, 7.62806907e-02f, -3.80759537e-02f, 2.69172303e-02f,
  -2.59335320e-02f, -2.17040014e-02f, 1.40024843e-02f, 3.88447568e-03f, 8.07909891e-02f, -5.80063881e-03f, -3.35983820e-02f, 1.49800684e-02f, -4.69047651e-02f, 2.13631839e-02f,
  7.34559968e-02f, -8.18369538e-02f, 1.30245043e-02f, 3.76353338e-02f, -4.94385287e-02f, -1.25274621e-02f, -1.22853005e-02f, -3.38060185e-02f, -3.71584035e-02f, -1.77014396e-02f,
  2.78716654e-01f, -2.07305625e-02f, 1.31871074e-01f, -1.72224212e-02f, 3.52570042e-02f, 1.12894084e-02f, 3.26857698e-04f, 2.36440636e-02f, 7.03076506e-03f, 5.73413819e-02f,
  -2.21553389e-02f, -2.92399526e-02f, 2.27830261e-02f, -2.67096572e-02f, 4.88116452e-03f, 8.25639218e-02f, 2.45909113e-02f, 2.10646875e-02f, 2.99228989e-02f, 7.18576983e-02f,
  9.59302578e-03f, 1.40806839e-01f, 1.28334433e-01f, 1.70441456e-02f, 8.90989900e-02f, 2.21725613e-01f, 1.23599805e-01f, 5.64993806e-02f, 1.22988008e-01f, 3.00703645e-01f,
  2.19028577e-01f, -1.75592184e-01f, 2.04594117e-02f, 7.14952573e-02f, -9.88792852e-02f, -8.11191723e-02f, -3.63317281e-02f, 1.60934225e-01f, 1.27507299e-01f, -7.08504468e-02f,
  1.01115257e-01f, 1.12324409e-01f, 1.39309272e-01f, -1.45243304e-02f, 4.28711176e-02f, -1.18610617e-02f, -7.35105947e-02f, 5.40959127e-02f, 1.75765783e-01f, 3.54977474e-02f,
  -1.01039007e-01f, 4.19449918e-02f, 1.35053307e-01f, 4.13586013e-02f, -1.13177508e-01f, -3.05307265e-02f, -1.02698505e-01f, -1.34602681e-01f, -7.81376362e-02f, -3.06338042e-01f,
  -6.33096844e-02f, -6.22262396e-02f, 1.19898096e-01f, 3.01167127e-02f, -4.85229716e-02f, 1.77338123e-02f, -1.25783170e-02f, -6.62750378e-02f, 6.45042062e-02f, -2.84828097e-02f,
  6.22524740e-03f, 6.86548725e-02f, 2.11569089e-02f, 4.34375927e-02f, 6.81287050e-02f, -5.31430952e-02f, 1.04094408e-01f, 8.53812248e-02f, -2.37749200e-02f, -1.63491778e-02f,
  -6.62651882e-02f, -3.52983922e-02f, 5.12027293e-02f, 2.74706399e-04f, -1.25187458e-02f, -1.10608921e-03f, 2.64592841e-03f, -1.37050506e-02f, -4.38370043e-04f, -1.61087573e-01f,
  5.91131719e-03f, 2.10233275e-02f, 6.18921360e-03f, -7.67048821e-02f, 1.20459944e-02f, 6.53919578e-02f, -9.22039822e-02f, -6.66313916e-02f, 5.87393083e-02f, -4.75294366e-02f,
  6.06692284e-02f, 6.32796809e-02f, -3.20311636e-03f, -9.37285461e-03f, -3.65178175e-02f, 1.99953727e-02f, 4.91903163e-02f, -6.64294958e-02f, -5.94326891e-02f, -6.82365224e-02f,
  3.83024104e-02f, -8.65315124e-02f, -1.35314921e-02f, -2.67047752e-02f, -3.12566422e-02f, 2.73403265e-02f, 7.43944123e-02f, 2.02104673e-02f, 8.76505896e-02f, 1.10572092e-01f,
  6.56092167e-02f, 6.36662766e-02f, 6.55809417e-02f, 2.11224742e-02f, -6.04687855e-02f, -5.19401729e-02f, 2.93393712e-02f, -2.95964777e-02f, 5.06986724e-03f, -4.85474104e-03f,
  6.30573705e-02f, -3.74006443e-02f, -6.48334324e-02f, -5.61574735e-02f, 5.37101005e-04f, 9.32648331e-02f, 3.63889858e-02f, -7.79958665e-02f, 1.74717456e-02f, -8.89218971e-02f,
  3.30007598e-02f, 1.14935525e-01f, 7.98914433e-02f, -9.16286558e-02f, -9.40181781e-03f, 2.15755552e-02f, -1.16112858e-01f, -9.73236747e-03f, -2.63977498e-02f, 1.01105072e-01f,
  3.50190490e-01f, -2.64333766e-02f, 5.15878722e-02f, 8.26713890e-02f, 3.99267813e-03f, -1.91232711e-01f, -1.66858230e-02f, -8.73962045e-02f, -2.16310453e-02f, 9.07865837e-02f,
  -6.26550615e-02f, -5.94578832e-02f, -3.98125686e-02f, 1.13446917e-02f, -6.38184771e-02f, 1.14396363e-01f, 8.14218670e-02f, 1.37462661e-01f, -1.97115932e-02f, -1.66488513e-01f,
  1.60277747e-02f, -1.71026285e-03f, 1.63275242e-01f, 5.22839278e-02f, 9.00014013e-04f, -8.96497220e-02f, 3.30073833e-02f, 2.78994851e-02f, 1.56642422e-02f, 3.38303223e-02f,
  4.61085215e-02f, 7.84029290e-02f, -6.73063844e-02f, 6.69225957e-03f, -1.16109499e-03f, 8.89760107e-02f, -4.40505594e-02f, -2.31120512e-02f, 8.62389430e-02f, -5.52181751e-02f,
  7.25691095e-02f, -7.76160232e-05f, 8.11892673e-02f, -2.53611989e-02f, 9.38035548e-02f, -4.39271703e-02f, 1.81635041e-02f, 1.21959627e-01f, 1.15934908e-01f, -1.19837606e-02f,
  -8.16601962e-02f, -3.70369591e-02f, -9.87331495e-02f, -1.19276538e-01f, -1.45769853e-03f, -5.92577085e-02f, -8.57497472e-03f, 6.44483417e-02f, -9.70718488e-02f, -3.94346863e-02f,
  1.61301848e-02f, -4.67799194e-02f, -4.30807769e-02f, 6.76633269e-02f, 7.07014725e-02f, -4.35792878e-02f, 3.54512483e-02f, -8.18004534e-02f, 1.64020546e-02f, 4.65542600e-02f,
  -1.31911887e-02f, -4.51220199e-02f, -3.61988554e-03f, 8.36470127e-02f, 3.75775918e-02f, -2.58009490e-02f, -1.82033367e-02f, 6.14808872e-02f, -1.05303533e-01f, -7.49348011e-03f,
  1.97096802e-02f, -1.01850197e-01f, 4.00218926e-02f, -6.81852996e-02f, 4.47833911e-03f, 4.28774059e-02f, -7.30884448e-02f, 2.53916346e-02f, 4.19407338e-02f, -7.96933547e-02f,
  2.49735601e-02f, -1.04466602e-02f, 6.26355261e-02f, -5.25734536e-02f, -1.82838682e-02f, 4.00708131e-02f, 2.76512690e-02f, 6.04726607e-03f, 1.00547872e-01f, -2.33085472e-02f,
  -2.62597650e-02f, -4.12430875e-02f, 1.11277327e-01f, -8.70112479e-02f, -3.21374424e-02f, 2.13243179e-02f, 4.87311594e-02f, -3.50716747e-02f, -1.29606519e-02f, -1.06804036e-01f,
  -4.13129032e-02f, 2.80596856e-02f, -7.45729730e-02f, -8.87769982e-02f, -2.34739967e-02f, 1.19189639e-02f, -2.86855064e-02f, 5.37251569e-02f, 1.69619545e-02f, -8.21866021e-02f,
  -1.24141984e-01f, -2.62471978e-02f, -9.50227752e-02f, 2.03851815e-02f, 1.26767218e-01f, 6.95989132e-02f, -1.63521975e-01f, 8.69727656e-02f, 1.57995015e-01f, -9.47173461e-02f,
  1.84162855e-01f, 2.78912961e-01f, 1.98186144e-01f, 5.60285933e-02f, 8.94744620e-02f, -2.03551322e-01f, -1.58521175e-01f, -9.38798708e-04f, 4.96620014e-02f, 1.37049397e-02f,
  1.96845103e-02f, 3.96196060e-02f, -2.10705772e-02f, 8.05685520e-02f, -1.51668817e-01f, 5.60967065e-02f, -1.11629322e-01f, -1.31367519e-01f, 5.36300391e-02f, -1.53307736e-01f,
  -1.22581139e-01f, -7.95270950e-02f, -4.63759862e-02f, -6.03131577e-03f, -2.70115361e-02f, 4.86052744e-02f, 7.04991212e-03f, 3.44741791e-02f, -5.17845377e-02f, -4.29169610e-02f,
  9.41662714e-02f, 3.62006314e-02f, 6.45113736e-02f, 8.88882726e-02f, 4.58879992e-02f, 8.64897855e-03f, -1.13073267e-01f, -3.76024731e-02f, -1.66039392e-02f, 9.82911512e-03f,
  4.35632020e-02f, 5.01531400e-02f, -8.95610973e-02f, -3.85466963e-02f, -5.63782081e-02f, 6.88600168e-02f, -1.01806320e-01f, 3.94262746e-02f, -9.07291472e-02f, -1.99256837e-01f,
  1.57418642e-02f, -1.81134176e-02f, 1.58243775e-02f, 9.38809663e-02f, 1.10662114e-02f, 4.10204194e-02f, 6.13315254e-02f, -4.37555164e-02f, 1.80632584e-02f, -1.37075568e-02f,
  5.27331494e-02f, 2.30540577e-02f, 7.77839124e-03f, 2.59115789e-02f, 2.62871329e-02f, -4.00117263e-02f, -4.02138345e-02f, 3.81776802e-02f, 3.01585887e-02f, 5.69461063e-02f,
  2.53688861e-02f, 7.96508789e-02f, -2.27224976e-02f, -4.09680046e-02f, 5.35245379e-03f, -4.08687778e-02f, -7.78446868e-02f, 5.36253527e-02f, -5.77779897e-02f, -1.27263889e-01f,
  5.73990569e-02f, 1.01741426e-01f, -6.54168427e-02f, -2.03018561e-02f, 2.15389915e-02f, 4.11061868e-02f, 8.94321054e-02f, 1.44795068e-02f, -8.27625841e-02f, 5.68152070e-02f,
  2.47704051e-02f, -6.82007447e-02f, -1.44550335e-02f, -4.15772721e-02f, 2.74120811e-02f, -3.57350297e-02f, 9.96783469e-03f, 1.11539420e-02f, 8.75350833e-02f, 1.08572572e-01f,
  -6.70091212e-02f, 5.20911589e-02f, 2.93963235e-02f, -4.77538221e-02f, 1.65158603e-02f, 1.78200472e-02f, -5.68410531e-02f, -2.23451238e-02f, 8.67007524e-02f, -1.72062173e-01f,
  -3.57277513e-01f, -7.48978481e-02f, 1.40172288e-01f, -1.92508548e-02f, 1.10158222e-02f, 5.62739894e-02f, -6.80065379e-02f, 1.04123771e-01f, 7.62608945e-02f, -1.32209025e-02f,
  6.23245947e-02f, -3.08880229e-02f, -7.66022783e-03f, -2.13823393e-02f, -1.18493043e-01f, 9.62423459e-02f, 8.27431381e-02f, 2.68415045e-02f, 8.06231499e-02f, -2.58709081e-02f,
  -8.24350640e-02f, -4.13499735e-02f, -2.79577216e-03f, 5.23182787e-02f, -7.54628418e-05f, -5.94680198e-03f, -4.65306342e-02f, -8.22429284e-02f, 7.07230195e-02f, 3.43643781e-03f,
  1.42136842e-01f, -1.06491968e-01f, 8.32858533e-02f, 1.69799719e-02f, -4.10506316e-02f, 1.98745839e-02f, -6.43290486e-03f, -8.09984580e-02f, -4.07323427e-02f, 3.60076949e-02f,
  -1.02354906e-01f, -3.63951474e-02f, -4.41779532e-02f, -5.62322699e-02f, -9.00036991e-02f, 6.91918507e-02f, -4.11944650e-02f, -3.63987591e-03f, -4.00015861e-02f, 3.91366053e-03f,
  3.35092805e-02f, 9.72365960e-03f, -3.34398784e-02f, 7.68189412e-03f, -1.69895440e-02f, 3.55815291e-02f, 3.37164756e-03f, 5.60072362e-02f, 5.12236683e-03f, 6.32370031e-03f,
  4.12924886e-02f, 6.00353889e-02f, 1.59711819e-02f, 1.12774819e-01f, -2.77085304e-02f, -6.52253404e-02f, -6.77600801e-02f, 1.17652575e-02f, 5.87968715e-02f, -8.40194710e-03f,
  4.13199002e-03f, 4.57858257e-02f, -3.44450697e-02f, -3.95240448e-02f, 3.86215262e-02f, 1.08905444e-02f, -5.27657047e-02f, 3.69272120e-02f, -8.52552205e-02f, 1.27047496e-02f,
  -6.54406175e-02f, -3.00861802e-02f, 2.32406128e-02f, 2.19119526e-02f, -5.94301075e-02f, -5.24673089e-02f, 6.40019104e-02f, 1.62098706e-02f, 3.84548609e-03f, -6.43393351e-03f,
  6.13359995e-02f, -1.41581193e-01f, 7.50128254e-02f, -3.76029909e-02f, -3.34910452e-02f, -6.06740229e-02f, -6.97910786e-02f, -9.91477259e-03f, -1.15775103e-02f, 2.87524164e-02f,
  -7.97467828e-02f, -6.42694673e-03f, -7.08554462e-02f, -8.64712223e-02f, 4.04154025e-02f, 6.36351556e-02f, -5.73692732e-02f, -7.85587505e-02f, -6.24690065e-03f, -3.71141136e-02f,
  2.30783713e-03f, 9.74809676e-02f, 3.36724222e-02f, 1.01997577e-01f, -4.26304713e-02f, 7.55069628e-02f, 5.94991557e-02f, 7.80081749e-02f, 4.06548008e-02f, 1.27590120e-01f,
  -4.20392491e-02f, -4.35247272e-03f, -1.81956187e-01f, 9.26118791e-02f, 9.69271213e-02f, -7.66699165e-02f, -8.80139843e-02f, -1.22320227e-01f, 3.55126895e-02f, -7.30640143e-02f,
  4.30422015e-02f, 2.58460939e-02f, 6.13647588e-02f, 4.99831932e-03f, -8.08502361e-02f, -7.92679563e-02f, 4.99826185e-02f, 9.00552571e-02f, -6.66619912e-02f, 1.08226247e-01f,
  1.51450351e-01f, -4.18122001e-02f, 3.27863321e-02f, -4.63548191e-02f, 4.84831072e-02f, 6.33982718e-02f, -4.71549444e-02f, 5.20212501e-02f, 8.14058185e-02f, -2.07181405e-02f,
  -8.53703916e-02f, -4.24853452e-02f, 5.86513504e-02f, 1.04867227e-01f, 1.17678665e-01f, -3.77280079e-02f, 5.00581935e-02f, -5.33121489e-02f, -5.14631346e-02f, -3.53238359e-02f,
  -5.16554154e-03f, -3.33061181e-02f, 5.09824343e-02f, 9.13567003e-03f, -7.11961240e-02f, -6.20261393e-02f, 6.51851892e-02f, -3.10930777e-02f, -1.88196227e-02f, -5.05893938e-02f,
  -4.10524718e-02f, 7.93522410e-03f, -1.00338250e-01f, -1.06719350e-02f, -2.81860977e-02f, 3.78999114e-02f, 3.83894406e-02f, -4.00339030e-02f, 3.71468887e-02f, -8.20418149e-02f,
  4.45281081e-02f, 4.90231737e-02f, 4.29736711e-02f, 7.53024651e-04f, 8.84978995e-02f, 2.34023877e-03f, 4.46543694e-02f, 2.71176770e-02f, 3.74708697e-02f, -8.07641447e-02f,
  -6.93680020e-03f, -1.04803741e-01f, -5.93351685e-02f, -2.92877033e-02f, 3.50643438e-03f, 5.51581308e-02f, 6.01045380e-04f, 1.75373424e-02f, 1.60892271e-02f, 3.80323157e-02f,
  -6.76890612e-02f, -6.34967238e-02f, -7.08301067e-02f, 7.71462917e-03f, 4.22246903e-02f, 4.46415395e-02f, 4.23580483e-02f, -2.76955087e-02f, -5.42134270e-02f, -2.45434232e-02f,
  -1.20091677e-01f, 7.81214908e-02f, -7.04997182e-02f, 5.46102645e-03f, -6.20930977e-02f, 1.02654755e-01f, -3.33263390e-02f, -5.31020723e-02f, 2.10704729e-02f, -4.77135964e-02f,
  8.51245411e-03f, 3.24001946e-02f, 4.15018313e-02f, -6.71741413e-03f, -9.31085832e-03f, -7.89451748e-02f, 1.72886103e-02f, -5.99360205e-02f, -2.74259374e-02f, -4.31156158e-02f,
  6.67560175e-02f, 1.47799877e-02f, 1.77238155e-02f, -1.24768808e-01f, 3.58485058e-02f, -2.41898391e-02f, -1.39627635e-01f, -4.13891338e-02f, 4.55122150e-04f, 1.27085729e-03f,
  1.06222786e-01f, -4.20955531e-02f, 1.28658086e-01f, 1.44472539e-01f, 1.39334515e-01f, 6.12954311e-02f, 1.13542221e-01f, 3.58328074e-02f, 6.98441043e-02f, -5.16497493e-02f,
  -4.20228802e-02f, 5.25889508e-02f, -7.96097070e-02f, 2.85286848e-02f, -5.27506992e-02f, -3.89070958e-02f, -6.58834204e-02f, -3.81176881e-02f, -3.14313849e-03f, 6.11323044e-02f,
  -1.41156271e-01f, -1.60283878e-01f, -6.07022196e-02f, -1.47825986e-01f, -6.63042888e-02f, -1.54976234e-01f, -1.42268047e-01f, -1.50036737e-01f, -2.10286349e-01f, -1.32216841e-01f,
  -2.61666588e-02f, -6.87621087e-02f, 9.35266539e-02f, -1.84477586e-02f, 1.59967821e-02f, 6.20909557e-02f, 2.60807667e-02f, 4.80435677e-02f, -5.81635348e-02f, -3.90571095e-02f,
  9.41779763e-02f, 5.95143028e-02f, 7.95113966e-02f, 4.42477986e-02f, -6.15617409e-02f, 1.08948406e-02f, -2.48932093e-02f, -5.91803230e-02f, -9.21220034e-02f, -1.06138416e-01f,
  1.58700086e-02f, -8.31840038e-02f, -3.90980579e-02f, -1.11623101e-01f, -9.60753337e-02f, -1.32499948e-01f, -8.63416865e-02f, -1.24662496e-01f, -3.53107937e-02f, -1.13287769e-01f,
  -5.10149710e-02f, 8.89933780e-02f, 1.56907062e-03f, -1.92151044e-03f, 7.07229227e-02f, -1.16325459e-02f, -4.94476184e-02f, 6.39306977e-02f, 3.84025946e-02f, 8.24404284e-02f,
  3.41539010e-02f, -1.80136506e-02f, -8.36849362e-02f, -6.24429472e-02f, -6.48180097e-02f, -2.05266252e-02f, 2.26028438e-04f, -8.69750455e-02f, -8.78802240e-02f, -1.80930924e-02f,
  1.39746228e-02f, 5.28371781e-02f, 8.47445056e-02f, -4.28215712e-02f, -5.76081276e-02f, 2.88476273e-02f, 5.18625528e-02f, 3.23506743e-02f, 6.81595737e-03f, 7.24222958e-02f,
  8.61051455e-02f, -9.70763341e-02f, 1.48142083e-02f, -1.35100065e-02f, 1.08683277e-02f, -2.13706940e-02f, 3.08581758e-02f, 7.90963415e-03f, 6.94388896e-02f, 4.66989055e-02f,
  5.52319586e-02f, 9.93952528e-02f, -1.42828086e-02f, 8.64274800e-02f, 7.29526207e-02f, 9.77461338e-02f, 9.22548398e-02f, 1.02985185e-02f, -2.23445110e-02f, 6.53741509e-02f,
  1.71141908e-01f, 7.60451658e-03f, 1.17587425e-01f, 6.34523332e-02f, 4.32872847e-02f, 2.72386316e-02f, 4.29247916e-02f, -2.41029207e-02f, 7.53748044e-02f, 1.08386293e-01f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.15081139e-01f, -8.30876604e-02f, -1.61189631e-01f, -7.16750473e-02f, -8.37430581e-02f, -8.27805549e-02f, -9.19496417e-02f, -6.00564703e-02f, -9.35045853e-02f, -1.11705467e-01f,
  -3.34537663e-02f, -1.36734145e-02f, 6.23144805e-02f, 3.23863737e-02f, 5.76812439e-02f, -8.76577757e-03f, 1.95252546e-03f, -5.49896359e-02f, -1.21086128e-02f, 3.99509929e-02f,
  -1.18807964e-02f, 5.46748675e-02f, 3.27934958e-02f, 3.59110199e-02f, -3.21808979e-02f, 4.37722616e-02f, -6.95028231e-02f, -1.33530125e-01f, -1.21704802e-01f, -1.42542496e-01f,
  -1.92934096e-01f, 8.73342827e-02f, -1.49031505e-02f, -1.24253118e-02f, 2.54932996e-02f, -3.36330049e-02f, -2.74217036e-02f, -3.74829359e-02f, 7.66544640e-02f, -6.49614558e-02f,
  7.70590901e-02f, -6.57501444e-02f, 4.49989699e-02f, -8.41576979e-02f, -6.88988790e-02f, -6.01429865e-02f, 5.99420909e-03f, 5.76555803e-02f, -6.04411140e-02f, 6.17176387e-03f,
  -8.46026838e-02f, 5.29498905e-02f, -5.78336082e-02f, -7.68333301e-02f, 1.87529866e-02f, 5.33124506e-02f, 2.63049491e-02f, -1.04655154e-01f, -5.86732291e-02f, -6.91144392e-02f,
  4.34729591e-04f, 8.46209303e-02f, 5.17287590e-02f, 6.65342137e-02f, -3.15961838e-02f, 6.31008968e-02f, 2.66792830e-02f, -1.21188611e-02f, -6.43432364e-02f, 7.50008821e-02f,
  -7.13603199e-03f, 5.14345877e-02f, -5.45386337e-02f, -6.26562536e-02f, 1.92424934e-02f, 8.17697272e-02f, -5.37514947e-02f, -6.87642992e-02f, 4.56002019e-02f, 1.19700124e-02f,
  -8.60255882e-02f, -4.81680222e-02f, 1.38469990e-02f, 1.06187545e-01f, 3.80380005e-02f, -3.89407203e-02f, -5.90962246e-02f, 2.37881280e-02f, 6.50153086e-02f, 5.02562188e-02f,
  -4.43833359e-02f, -1.08587081e-02f, 8.67656246e-02f, -3.38777080e-02f, 4.47621383e-02f, -4.28922176e-02f, -3.10811494e-02f, -1.00899795e-02f, -6.95344880e-02f, -7.74274617e-02f,
  3.66394548e-03f, 4.50423956e-02f, -5.21889590e-02f, -6.39075264e-02f, -6.00514151e-02f, 9.87289399e-02f, 1.01956511e-02f, 7.22384974e-02f, -6.23925030e-03f, 8.50398391e-02f,
  4.25646119e-02f, -6.26516789e-02f, -5.79142086e-02f, 8.68447684e-03f, 4.65808921e-02f, -1.98635310e-02f, 6.39146660e-03f, 3.09214573e-02f, 8.11157599e-02f, -9.98485461e-02f,
  -2.44135976e-01f, -6.97007552e-02f, -1.95822611e-01f, -2.07423627e-01f, 4.82029840e-02f, 1.34748310e-01f, -7.38076493e-02f, 3.09192669e-02f, 9.04323719e-03f, -1.56055748e-01f,
  -8.92691240e-02f, -9.40950885e-02f, -1.42213911e-01f, -1.02124631e-01f, -4.07512598e-02f, -2.60456443e-01f, -2.03049332e-01f, -2.00233474e-01f, -1.54940281e-02f, 9.84689370e-02f,
  1.52523499e-02f, -1.83197081e-01f, -2.57982444e-02f, 4.33270298e-02f, 5.40126190e-02f, 8.73786211e-02f, -1.90335691e-01f, -7.34315021e-03f, 9.33209658e-02f, -1.04947306e-01f,
  -2.04740077e-01f, 1.11312382e-01f, 7.79857486e-02f, -9.69724804e-02f, -8.12171921e-02f, -2.22422611e-02f, 9.93304104e-02f, 3.22699584e-02f, 2.14322731e-02f, 3.62885930e-02f,
  -7.41305426e-02f, 4.11097938e-03f, -1.54703297e-02f, 2.88458783e-02f, 8.99199694e-02f, 5.87289361e-03f, -2.04124786e-02f, 2.75358022e-03f, 6.25975132e-02f, 3.44823264e-02f,
  -1.87511109e-02f, 7.80084170e-03f, -1.28860967e-02f, -4.66303062e-03f, -2.04549171e-02f, -3.42193581e-02f, -7.23872520e-03f, 1.41631231e-01f, 1.43233910e-01f, -1.04228057e-01f,
  -2.72250418e-02f, -3.49933803e-02f, -7.49341212e-03f, -1.95566309e-03f, -3.73936817e-02f, -4.32406925e-03f, 5.34664690e-02f, 8.84051900e-03f, 5.83203100e-02f, -5.63219488e-02f,
  7.96900131e-03f, 1.95663664e-02f, -1.67369079e-02f, -3.62971649e-02f, 6.24376175e-04f, -3.85246053e-02f, 5.64054362e-02f, -1.09298818e-01f, 2.18994543e-02f, -2.65631881e-02f,
  -7.18156695e-02f, -6.38154428e-03f, -4.32805829e-02f, -1.40540190e-02f, -1.68052819e-02f, -1.41207632e-02f, -5.92492633e-02f, 3.12471706e-02f, -5.83562888e-02f, 3.07398383e-02f,
  -1.59092665e-01f, 2.75746658e-02f, 4.25277790e-03f, 9.84045770e-03f, 2.25813705e-02f, -1.00723570e-02f, -1.78329181e-02f, -1.48834083e-02f, -5.63660488e-02f, -7.04330206e-02f,
  -7.81865790e-03f, -2.76643457e-03f, -8.16713199e-02f, 4.41428795e-02f, 4.70253415e-02f, 8.21047053e-02f, -7.46425390e-02f, -7.08228201e-02f, -4.60107774e-02f, -3.17049176e-02f,
  -9.81607586e-02f, -1.19578190e-01f, -9.49389637e-02f, -3.86963859e-02f, 3.78257297e-02f, -8.59590322e-02f, 4.04044474e-03f, 5.97134978e-02f, 2.61694286e-02f, -1.14700317e-01f,
  -8.85447562e-02f, 5.21065760e-03f, 9.78091434e-02f, 9.51094031e-02f, -7.50994235e-02f, 3.93219478e-03f, -1.66416820e-02f, -9.25545543e-02f, -5.02505563e-02f, -5.03069647e-02f,
  5.93079701e-02f, -6.02736510e-02f, -2.98624523e-02f, 8.57418217e-03f, 5.21272905e-02f, -3.94974798e-02f, -3.32379676e-02f, 1.07461922e-01f, 7.29116425e-02f, 9.06099528e-02f,
  -5.57645708e-02f, -4.01343666e-02f, 9.94070023e-02f, 8.17831010e-02f, 9.21200886e-02f, -2.26038061e-02f, 8.31680931e-03f, -3.11900093e-03f, 2.35311072e-02f, 1.95454862e-02f,
  -8.60744789e-02f, 4.65214178e-02f, 7.54475072e-02f, -3.50338668e-02f, 9.75945592e-02f, -2.72342227e-02f, 3.78039330e-02f, 5.69465384e-02f, -2.91065555e-02f, 6.68855160e-02f,
  -1.40000298e-03f, 2.19704397e-02f, 6.98238537e-02f, -4.61687557e-02f, -4.26409841e-02f, -4.25539725e-02f, 1.03922918e-01f, 4.50314879e-02f, 6.08130284e-02f, -7.88446423e-03f,
  7.75290132e-02f, 5.39677441e-02f, 1.20389890e-02f, -9.61466655e-02f, -3.25544924e-02f, 1.56302489e-02f, 9.27698158e-04f, -5.12480095e-04f, 5.24207279e-02f, -1.33069074e-02f,
  6.76142648e-02f, 4.70111445e-02f, 7.75453299e-02f, 9.00665149e-02f, 1.09151930e-01f, -5.74142188e-02f, 5.69669679e-02f, -4.93846908e-02f, 4.19096425e-02f, 4.88984026e-02f,
  7.32308850e-02f, -2.19104216e-02f, -3.46042477e-02f, 5.08656017e-02f, 5.76399751e-02f, 2.95025203e-02f, 8.83201063e-02f, -3.09701953e-02f, -7.62872845e-02f, -1.92710070e-03f,
  2.52396185e-02f, 9.08791199e-02f, -5.42706251e-02f, -7.53964484e-02f, 1.60256103e-02f, 1.13901153e-01f, 6.28558025e-02f, 7.03208297e-02f, -6.37507886e-02f, 4.48842049e-02f,
  -3.28397602e-02f, -6.69847354e-02f, -2.38400139e-02f, -6.12511039e-02f, -6.14461713e-02f, 5.24774492e-02f, 4.38215882e-02f, -1.39049869e-02f, 1.63780823e-02f, -5.19803688e-02f,
  6.34991974e-02f, 7.63911456e-02f, 1.60638505e-04f, 1.04469880e-01f, -7.11101517e-02f, -1.89006925e-02f, 6.78479150e-02f, -1.37476781e-02f, 7.04602301e-02f, 5.30502573e-02f,
  -1.79843009e-02f, 1.96152981e-02f, -1.16535544e-01f, 2.60394365e-02f, 4.53509055e-02f, -2.67969072e-02f, -7.19980225e-02f, -9.41999629e-03f, -1.01521380e-01f, 1.18379435e-02f,
  -1.14737377e-02f, 4.14260896e-04f, -2.86588278e-02f, 5.97946867e-02f, 2.45792978e-02f, -1.92247033e-02f, 5.64976260e-02f, -8.01629350e-02f, 3.26575413e-02f, 5.02051376e-02f,
  -4.18535545e-02f, 5.96199650e-04f, -5.67800403e-02f, -6.35013580e-02f, -7.61685669e-02f, -9.81823131e-02f, -1.43030351e-02f, -1.19146913e-01f, 6.53934386e-03f, -7.74479285e-02f,
  6.68142065e-02f, -3.59838940e-02f, -3.79082630e-03f, 7.36268656e-03f, -3.22580454e-03f, -8.74057934e-02f, -6.28698841e-02f, 5.03256992e-02f, 4.89645861e-02f, 3.97055708e-02f,
  8.41935948e-02f, -1.95538811e-02f, 5.96173666e-03f, -3.84286456e-02f, 5.06728813e-02f, -1.27700521e-02f, -1.48936454e-02f, -9.35166553e-02f, 8.53808597e-02f, -4.11061049e-02f,
  7.36984238e-02f, -1.66786499e-02f, -4.69935499e-03f, -5.58324233e-02f, -5.86948656e-02f, -6.15616143e-02f, -3.71736549e-02f, 6.17592447e-02f, 2.79360097e-02f, 2.69319210e-02f,
  4.31169942e-02f, -5.65410033e-02f, 6.33088350e-02f, -2.32358053e-02f, -9.84326676e-02f, -8.44274461e-02f, -6.31223470e-02f, -3.35792080e-02f, 2.97863018e-02f, -8.79774913e-02f,
  4.79961261e-02f, 8.82939808e-03f, -8.23379755e-02f, 3.51219764e-03f, -5.11498898e-02f, 7.06772134e-02f, -5.04529700e-02f, 3.31191160e-02f, -7.59744272e-02f, -8.13016843e-04f,
  -4.51365151e-02f, 2.52299737e-02f, -2.71764887e-03f, 2.28993315e-02f, -8.12792704e-02f, -3.83006968e-02f, 6.88119084e-02f, 6.80315346e-02f, 1.58325639e-02f, 4.08710688e-02f,
  -6.74844459e-02f, 5.63912578e-02f, 2.86056604e-02f, 6.98884279e-02f, -3.93310785e-02f, -7.10861012e-03f, -1.00394093e-01f, -3.12194619e-02f, -3.99723537e-02f, 7.01358467e-02f,
  -1.03356272e-01f, -1.47030288e-02f, -1.31825428e-03f, -3.82009037e-02f, -5.75292744e-02f, -8.44596792e-03f, 8.79267231e-02f, -3.60627286e-02f, 8.68248846e-03f, -7.32286721e-02f,
  -8.00147578e-02f, 1.21867908e-02f, -5.98865710e-02f, 5.76356146e-03f, -9.33125541e-02f, 5.29661402e-02f, -7.65145244e-03f, -4.48383503e-02f, -5.90964481e-02f, 3.50068882e-02f,
  -2.81914771e-02f, -3.44776995e-02f, -1.16798691e-02f, -1.23395152e-01f, -2.22939029e-02f, 2.78510079e-02f, 5.84051420e-04f, -2.65398994e-02f, -6.64205030e-02f, -2.08184030e-02f,
  1.50850229e-02f, -7.21987560e-02f, -7.30043650e-02f, 9.04306397e-02f, -3.14381085e-02f, -7.96593800e-02f, -4.17365879e-02f, -8.13058317e-02f, 4.78265285e-02f, -1.02718771e-01f,
  5.79688288e-02f, 9.62071121e-03f, -3.41618620e-02f, 5.68992868e-02f, 7.39895478e-02f, -1.07630298e-01f, 4.86937985e-02f, -4.02386300e-03f, 6.63591400e-02f, -4.15702304e-03f,
  -5.46967573e-02f, 3.22520849e-04f, 7.28344033e-03f, 5.17512150e-02f, 2.98061296e-02f, -5.38480692e-02f, 5.95262833e-02f, 8.07516798e-02f, -9.30231884e-02f, -1.32342026e-01f,
  6.07276848e-03f, -2.38612704e-02f, -1.70700457e-02f, 2.16888115e-02f, -1.53527102e-02f, -6.68662135e-03f, -9.85524058e-02f, 7.29040727e-02f, -2.87776124e-02f, 1.20221311e-02f,
  -5.37261181e-02f, -5.07687964e-02f, 6.76927269e-02f, 6.76337853e-02f, -8.28545839e-02f, 4.27103825e-02f, 1.27800917e-02f, -2.27977037e-02f, -3.87069322e-02f, -3.87191363e-02f,
  3.52118956e-03f, 5.91325760e-02f, -1.35519262e-02f, -1.41268326e-02f, 2.09348071e-02f, -8.72412249e-02f, -8.14043637e-03f, -6.37373049e-03f, -1.01233378e-01f, 5.79794273e-02f,
  6.38691559e-02f, -7.95748755e-02f, 1.47888185e-02f, -9.24935788e-02f, -6.12074584e-02f, -8.12176242e-02f, -2.85593774e-02f, -1.51123907e-02f, 9.98416394e-02f, -6.24806955e-02f,
  -1.78475492e-02f, 6.65592551e-02f, 9.38478038e-02f, 6.03624657e-02f, 3.71345803e-02f, 1.20700717e-01f, 2.82603689e-02f, 9.70306322e-02f, -3.51266749e-02f, -5.56305684e-02f,
  5.27999774e-02f, 3.30188349e-02f, -6.50017895e-03f, -3.67199481e-02f, 9.39630494e-02f, -6.00820705e-02f, -1.11788996e-02f, 7.95270354e-02f, -1.86573714e-02f, 9.39645320e-02f,
  -5.98360039e-02f, 2.24226078e-05f, -5.07128164e-02f, 9.74014029e-02f, 5.78324832e-02f, -1.66510008e-02f, -3.53160501e-02f, -6.10280707e-02f, -6.87419698e-02f, -6.25664219e-02f,
  -9.60022360e-02f, 7.24280328e-02f, -6.76080808e-02f, -2.46089734e-02f, 8.02173615e-02f, 1.89963914e-02f, -5.60660772e-02f, -4.37560230e-02f, -1.38460444e-02f, -1.58799235e-02f,
  5.32997847e-02f, -6.32395223e-02f, -7.28293732e-02f, 7.22141713e-02f, -4.42611538e-02f, 2.68470626e-02f, -2.17731372e-02f, -3.00565958e-02f, -5.27092852e-02f, -1.10656492e-01f,
  -3.52656213e-03f, -7.39173889e-02f, -4.10903953e-02f, -1.07489666e-03f, -9.15363058e-02f, 1.07217982e-01f, -1.02807768e-01f, 6.48049936e-02f, -1.74704790e-02f, -1.47475258e-01f,
  1.05851600e-02f, -7.61811202e-03f, 6.99990168e-02f, 9.88760963e-02f, 6.60074130e-02f, -1.03902116e-01f, -7.13112801e-02f, 5.36812022e-02f, 1.31916270e-01f, 4.28174734e-02f,
  -3.51607651e-02f, -4.23734821e-02f, 5.23333251e-02f, 5.77920377e-02f, -1.47898927e-01f, -9.42762196e-02f, -1.79684222e-01f, -3.35283093e-02f, -1.11442126e-01f, -1.53895363e-01f,
  -7.29060844e-02f, -2.05072220e-02f, 1.01800963e-01f, 5.93782961e-02f, -4.78138514e-02f, 4.65837196e-02f, -6.08959049e-02f, 7.48800999e-03f, -2.53401566e-02f, -5.91805018e-02f,
  -7.26185367e-02f, 2.54962128e-04f, 4.66665998e-02f, 5.28234988e-02f, 4.04605409e-03f, -5.40009290e-02f, 1.66226120e-03f, -1.99577622e-02f, 2.12355722e-02f, -5.17021678e-02f,
  7.06356540e-02f, 7.91142434e-02f, 2.76194438e-02f, 2.27442235e-02f, 2.68294048e-02f, 3.75918951e-03f, -2.52112970e-02f, 1.84613951e-02f, -8.33451822e-02f, -6.96326271e-02f,
  2.75826044e-02f, -1.43971872e-02f, -5.86811788e-02f, 3.54039781e-02f, 5.00937365e-02f, -6.05913252e-02f, -2.06069369e-02f, -2.91269775e-02f, 5.91695160e-02f, -8.73869378e-03f,
  6.43342659e-02f, -1.92762055e-02f, -2.87041087e-02f, 4.04065922e-02f, -1.63866207e-02f, -1.01073748e-02f, -1.39253102e-02f, 2.11564284e-02f, -2.28855424e-02f, 4.58158217e-02f,
  4.49344777e-02f, 3.50441933e-02f, -5.94428144e-02f, 8.41807202e-02f, -9.07004327e-02f, -1.45210896e-03f, 2.05045398e-02f, 3.14579494e-02f, 4.31176759e-02f, 2.81698238e-02f,
  -1.30130604e-01f, 4.92967889e-02f, -1.33088022e-01f, 2.17774436e-02f, -3.39552313e-02f, 5.71462102e-02f, -4.27621081e-02f, -7.41011500e-02f, 2.14740876e-02f, -3.11646108e-02f,
  -9.49347205e-03f, -3.00531276e-03f, 2.77309585e-02f, -2.29437649e-02f, -8.44980776e-02f, 4.03993391e-02f, -1.08855879e-02f, -5.99053428e-02f, 7.78359035e-03f, 5.51847229e-03f,
  1.63639989e-02f, 8.89591426e-02f, -2.81003863e-02f, -1.10912472e-01f, -1.93669032e-02f, 1.46385210e-04f, -1.00267470e-01f, -1.06103361e-01f, 4.49140631e-02f, -1.52837336e-01f,
  -9.05828997e-02f, -3.78394802e-03f, -3.59676816e-02f, 1.37466550e-01f, 1.07627049e-01f, 6.86699823e-02f, 9.93585680e-03f, -5.40797636e-02f, 4.12845612e-02f, -4.87222197e-03f,
  9.72979888e-02f, 1.09937839e-01f, 1.15715772e-01f, 1.15491964e-01f, -3.80650572e-02f, 4.25693095e-02f, 1.38534322e-01f, -1.05938371e-02f, -1.00793280e-01f, -4.74035367e-03f,
  3.48462164e-02f, -2.88982037e-02f, -1.03084100e-02f, -8.86732563e-02f, 7.94263650e-03f, -2.67647319e-02f, -3.58738303e-02f, 4.96696681e-02f, -1.01781739e-02f, 8.14851001e-02f,
  9.11138132e-02f, 7.62755126e-02f, -2.78115012e-02f, 6.83343932e-02f, 1.01231905e-02f, -8.46858099e-02f, 5.12411036e-02f, -5.35862008e-03f, 7.92315826e-02f, 6.40433878e-02f,
  6.99881539e-02f, 3.28609832e-02f, -4.52660955e-02f, -3.27050090e-02f, -1.03506623e-02f, 2.38426197e-02f, 4.14498523e-02f, -2.86048204e-02f, 6.26551639e-03f, 3.71826882e-03f,
  1.28222868e-01f, 5.49039356e-02f, -6.75347522e-02f, 7.96168298e-02f, -6.51662722e-02f, 4.04454656e-02f, -7.91396797e-02f, 8.13176855e-02f, 1.75422858e-02f, -2.92216782e-02f,
  8.31014477e-03f, 1.04579225e-01f, -1.75882634e-02f, 3.53024788e-02f, 3.96585949e-02f, 4.13420647e-02f, 3.94226089e-02f, -5.51804192e-02f, 3.93990166e-02f, -1.15227923e-01f,
  -2.00125501e-02f, -2.79721717e-04f, -4.54488099e-02f, 1.00866305e-02f, 7.98999295e-02f, -6.90486729e-02f, 8.54063109e-02f, 7.66528323e-02f, -1.36646889e-02f, 4.58782166e-02f,
  6.44219741e-02f, -6.80969432e-02f, -6.31379187e-02f, 1.14647955e-01f, -8.80372245e-03f, 8.39170441e-02f, 4.60096411e-02f, 6.53167395e-03f, -7.19307065e-02f, -5.44241518e-02f,
  1.15811257e-02f, 4.17078510e-02f, -3.84711474e-02f, -1.19145922e-02f, -7.07374886e-02f, -6.92466050e-02f, 5.11084944e-02f, -7.39578903e-02f, 6.99178725e-02f, -1.33588241e-04f,
  5.36065437e-02f, -1.62271187e-02f, -5.44259325e-02f, -1.78279970e-02f, -4.07823734e-03f, 3.43901515e-02f, 6.59425333e-02f, 3.04329079e-02f, -8.33422318e-02f, -6.43843412e-02f,
  1.43775076e-03f, -1.11475177e-01f, -6.18424341e-02f, -1.03237525e-01f, -1.54882483e-02f, 8.74789581e-02f, -8.53952244e-02f, -4.09074090e-02f, -7.72357285e-02f, 2.31421292e-02f,
  -5.96981533e-02f, 1.45979628e-01f, -6.22307137e-02f, -4.59231390e-03f, -4.18196805e-02f, -8.68582577e-02f, -7.43189231e-02f, -7.17956200e-03f, 3.55688073e-02f, -1.61909044e-01f,
  -9.68162715e-02f, 8.28544647e-02f, 5.81432506e-02f, -4.44796048e-02f, -1.10377766e-01f, -1.48074821e-01f, -4.97525707e-02f, -1.57004967e-01f, -5.83496131e-02f, 9.41875577e-03f,
  -1.05295256e-01f, -1.40916571e-01f, -8.18729103e-02f, 6.34142384e-02f, -2.48796139e-02f, -3.95456329e-02f, -9.01208594e-02f, -5.68063110e-02f, 2.86256969e-02f, -1.56769544e-01f,
  -1.58643469e-01f, 1.42194793e-01f, -6.94383159e-02f, 5.97752333e-02f, 7.59995505e-02f, 7.63227940e-02f, 4.80332784e-03f, -6.21711388e-02f, -1.54384496e-02f, 3.99531536e-02f,
  7.55673721e-02f, -1.13321459e-02f, -8.58199298e-02f, 4.18151356e-02f, -6.23642188e-03f, 7.94102475e-02f, -1.33717321e-02f, -2.13837419e-02f, -2.05362309e-02f, 1.69532597e-02f,
  -2.68516261e-02f, -1.28759533e-01f, -1.58176273e-02f, 1.39219845e-02f, 4.99305874e-03f, 2.94766556e-02f, 9.37772170e-03f, -2.72471923e-03f, 1.08916230e-01f, 4.35214825e-02f,
  -3.48251984e-02f, -9.10644904e-02f, 5.54451011e-02f, 5.58069348e-02f, -6.40350878e-02f, -2.23990567e-02f, 3.22956443e-02f, -7.46173337e-02f, -7.99006596e-02f, -1.80293026e-03f,
  4.60592564e-03f, -8.16536695e-02f, -1.03243113e-01f, 2.39353478e-02f, -9.60032046e-02f, 3.28235105e-02f, 2.47455295e-02f, -3.36902402e-02f, -3.23534012e-02f, -1.82300806e-02f,
  8.64526629e-02f, -4.91486266e-02f, -5.76475225e-02f, 9.09895748e-02f, 7.51864538e-02f, -2.90600341e-02f, 1.60616972e-02f, 2.16270946e-02f, 1.01114169e-01f, 7.73782283e-02f,
  2.16408446e-02f, -1.81048978e-02f, -2.84066163e-02f, -3.86355519e-02f, 3.45317014e-02f, 1.42410463e-02f, 5.59086874e-02f, 9.30978134e-02f, 3.90782058e-02f, 2.00944990e-02f,
  3.23835723e-02f, -3.35937515e-02f, 4.17529158e-02f, -6.65142247e-03f, 5.99034838e-02f, 5.58118075e-02f, -4.75616343e-02f, 7.50091299e-02f, -3.99927124e-02f, -6.84335977e-02f,
  -9.45227742e-02f, 3.05134133e-02f, 1.89206414e-02f, 2.02489588e-02f, -8.31633359e-02f, -1.01493299e-02f, -6.71965182e-02f, -3.04086064e-03f, 1.13531940e-01f, 7.08561689e-02f,
  -6.91712499e-02f, 9.92309451e-02f, -1.64525397e-02f, 6.60312325e-02f, -8.75689536e-02f, 5.49046183e-03f, 3.83647084e-02f, 6.29967749e-02f, -6.15924560e-02f, -6.88761771e-02f,
  3.31608355e-02f, 1.94946863e-02f, 1.01494238e-01f, 1.04321025e-01f, 5.59750199e-02f, 4.82333824e-02f, -3.80478241e-02f, -3.98861207e-02f, -6.37055859e-02f, 4.06000167e-02f,
  -3.62937115e-02f, 8.39803144e-02f, 8.50298479e-02f, -4.04541334e-03f, 1.87525004e-02f, 5.20705171e-02f, -3.94188315e-02f, -4.98314090e-02f, -3.61910313e-02f, -2.60855909e-02f,
  1.63832940e-02f, 8.39407668e-02f, -4.02756706e-02f, -3.97858322e-02f, -4.20182943e-02f, 3.67656127e-02f, -8.69137421e-02f, 4.15637642e-02f, 1.86938271e-02f, -2.01043431e-02f,
  3.28890197e-02f, 4.64537442e-02f, -3.19174863e-02f, 7.92322680e-02f, 7.37932473e-02f, 9.82823689e-03f, -2.29203720e-02f, -9.90474410e-03f, 9.54888538e-02f, 4.04388346e-02f,
  4.22636606e-03f, 8.88265483e-03f, 5.57309240e-02f, 1.57247931e-02f, 3.65712941e-02f, -9.17466208e-02f, 6.31569549e-02f, -5.68965413e-02f, -6.06943155e-03f, 4.96852323e-02f,
  2.75524948e-02f, -8.28991830e-02f, 2.85257865e-02f, -3.24494615e-02f, -7.77414888e-02f, 7.82971904e-02f, -5.13652489e-02f, 7.67046362e-02f, 3.58283408e-02f, -7.76496995e-03f,
  3.63066308e-02f, -3.37156542e-02f, 6.67087883e-02f, -5.08792475e-02f, -4.44271415e-02f, 4.57400084e-03f, -8.48479383e-03f, 2.66902279e-02f, -3.98218222e-02f, -6.18605688e-02f,
  1.95358824e-02f, -5.64044490e-02f, -1.99069269e-02f, 2.70452164e-02f, -5.56442142e-02f, 6.65830150e-02f, 3.96620519e-02f, -3.87619883e-02f, 4.38162871e-03f, 7.22957179e-02f,
  3.11202519e-02f, -5.92870414e-02f, -4.08813469e-02f, -7.40650371e-02f, 3.78765687e-02f, -6.98801279e-02f, -6.02486730e-02f, -4.54313168e-03f, -6.22546971e-02f, 9.16324705e-02f,
  -7.58456215e-02f, -7.75613412e-02f, -7.00920224e-02f, 7.78438896e-02f, -9.00265649e-02f, 1.23754786e-02f, 1.72770917e-02f, -8.51973668e-02f, -7.88520202e-02f, -7.26940259e-02f,
  -8.98603871e-02f, -1.37407491e-02f, -8.01433716e-03f, -9.38964784e-02f, -3.98949683e-02f, -1.85025260e-02f, 4.30842154e-02f, -9.21756700e-02f, -1.07571604e-02f, -8.94889515e-03f,
  -1.92674905e-01f, -1.33664891e-01f, 4.23486270e-02f, 1.74612015e-01f, 6.38382807e-02f, 9.13961008e-02f, -1.54285878e-01f, -4.44398187e-02f, 3.84261012e-02f, -4.27167825e-02f,
  7.75005817e-02f, 2.76294574e-02f, -1.35524303e-03f, -5.39624179e-03f, -6.56121224e-02f, -1.65217429e-01f, -9.30520520e-02f, -4.19416800e-02f, 5.13469875e-02f, 3.57340202e-02f,
  9.97970998e-02f, 1.47354931e-01f, 2.55155936e-02f, -1.53880939e-02f, 9.49512329e-03f, 9.87873599e-02f, -3.25357430e-02f, 4.12948839e-02f, -4.53069899e-03f, -1.53469831e-01f,
  -1.87476277e-01f, -1.12788156e-01f, -2.96163969e-02f, -8.56320336e-02f, 9.55463946e-02f, -5.98026626e-02f, -9.20600668e-02f, -1.88363940e-02f, 1.73225030e-02f, -5.94433304e-03f,
  -6.48542121e-02f, -4.95038107e-02f, -9.22528058e-02f, 8.44867714e-03f, -3.82015258e-02f, -1.37569159e-02f, -2.08721310e-02f, -1.90718323e-02f, -1.14218600e-01f, 3.48111875e-02f,
  2.66589168e-02f, -7.24364817e-02f, -1.27601296e-01f, -2.37335847e-03f, -7.59735554e-02f, -3.02640051e-02f, -1.00170664e-01f, -1.66463286e-01f, -1.52109668e-01f, -1.18216790e-01f,
  -4.99487333e-02f, -1.33471871e-02f, -4.02422324e-02f, -3.92433442e-02f, 3.28722689e-03f, 4.97957915e-02f, -5.39662018e-02f, -7.74176233e-03f, 7.42141008e-02f, -7.39860982e-02f,
  1.21168554e-01f, -1.88716047e-03f, 7.49350786e-02f, 9.71077848e-03f, 3.77662393e-04f, -2.76028346e-02f, 1.17315538e-02f, -6.51181862e-02f, -3.58959399e-02f, -5.11040948e-02f,
  -8.12439620e-02f, -8.74928851e-03f, 6.35161400e-02f, 2.11969651e-02f, -1.28503561e-01f, 1.35643696e-02f, -2.75618602e-02f, -2.47215765e-04f, 6.20977534e-03f, 1.09672975e-02f,
  7.60924965e-02f, 6.39163032e-02f, -5.39852530e-02f, 9.59205534e-03f, -2.48933639e-02f, 4.13496010e-02f, -3.94995138e-02f, 6.92806020e-02f, 2.06471048e-02f, 2.53160149e-02f,
  -5.62383085e-02f, 1.19383549e-02f, 1.40552046e-02f, 7.64922351e-02f, 4.33196947e-02f, -5.89895733e-02f, -6.53463509e-03f, -1.71831623e-02f, -5.48003428e-02f, -5.01973778e-02f,
  -2.99180821e-02f, -1.53454244e-01f, -2.10528374e-01f, -1.71128482e-01f, -1.16762184e-01f, -2.22971272e-02f, -1.00123584e-01f, -1.49254024e-01f, -2.42783979e-01f, -2.15841874e-01f,
  -2.55936831e-01f, -2.45634448e-02f, -1.73093051e-01f, -1.85273111e-01f, -1.40852004e-01f, -2.44079530e-02f, -1.50525749e-01f, 6.55673370e-02f, 1.19132914e-01f, -2.54225880e-01f,
  1.49962911e-02f, 5.96697778e-02f, -1.33251473e-01f, -6.50834516e-02f, -1.17345266e-01f, -1.91165924e-01f, -1.98906481e-01f, -6.81409463e-02f, 1.16421424e-01f, 4.78873514e-02f,
  -2.41508130e-02f, -2.01629013e-01f, -2.48458423e-02f, 1.75206084e-02f, 9.43717360e-03f, 9.81306732e-02f, -9.38697904e-02f, -1.10603698e-01f, 1.67478863e-02f, -2.48254195e-01f,
  -3.83336805e-02f, 1.40466556e-01f, 7.52510410e-03f, 5.43448143e-02f, -1.06236853e-01f, -3.49322632e-02f, -8.31701308e-02f, -5.08885570e-02f, 7.11787194e-02f, 3.93827260e-02f,
  -4.99119014e-02f, -2.03341711e-02f, -1.01824015e-01f, -1.74561155e-03f, -1.06108105e-02f, 3.50791588e-02f, 1.73965320e-01f, 3.43604423e-02f, 2.71183271e-02f, 7.19114840e-02f,
  3.76946181e-02f, 1.07567966e-01f, 5.50026000e-02f, 1.27909213e-01f, 1.57749787e-01f, -1.99471600e-03f, 3.97181101e-02f, 1.98543414e-01f, 1.12475358e-01f, 3.76317166e-02f,
  4.14359383e-02f, 4.19668145e-02f, 3.44733261e-02f, -1.52652534e-02f, 2.89932005e-02f, 2.55925003e-02f, 6.69633795e-04f, -8.05467144e-02f, 1.32079506e-02f, 7.02200504e-03f,
  -3.40225063e-02f, -5.30779101e-02f, 1.48465647e-03f, -1.57697573e-02f, -1.19067570e-02f, 2.80015934e-02f, 6.78368807e-02f, 2.59605367e-02f, 3.93009223e-02f, -4.48733456e-02f,
  2.78011188e-02f, 1.95678193e-02f, 3.61292288e-02f, 9.66917053e-02f, -4.10459787e-02f, 6.19915174e-03f, -1.23830531e-02f, -1.01249595e-03f, 4.51827571e-02f, -7.82711953e-02f,
  -8.45980942e-02f, -6.78652152e-02f, -1.92020997e-01f, 4.71376888e-02f, -2.06909589e-02f, 5.14187524e-03f, -3.76515910e-02f, 8.79649818e-03f, 5.23445895e-03f, -1.17193453e-03f,
  7.59953260e-02f, 3.65692638e-02f, -2.06382945e-02f, 1.19318729e-02f, 7.24415341e-03f, 9.67458263e-03f, -2.42189765e-02f, 8.35569296e-03f, 8.38822722e-02f, 5.92615195e-02f,
  8.40453897e-03f, -6.15721755e-02f, -5.29556870e-02f, -2.32027355e-03f, 1.17162652e-01f, -8.84806886e-02f, 2.48421226e-02f, 6.56481013e-02f, -5.01800925e-02f, -2.47774959e-01f,
  4.26208824e-02f, -6.84846267e-02f, 5.17338924e-02f, -9.86405462e-02f, 2.36435309e-02f, -5.42012230e-02f, 7.41106719e-02f, -7.02951103e-02f, -6.16486371e-02f, 3.07961497e-02f,
  -5.35793230e-03f, 6.92669600e-02f, 4.74206768e-02f, 3.47249135e-02f, 5.82236424e-02f, 3.95800965e-03f, -8.90362635e-03f, 5.90683892e-02f, 6.80328980e-02f, 1.56992283e-02f,
  -6.88382238e-02f, 5.23909964e-02f, -4.49974611e-02f, 7.46624917e-02f, 6.02938570e-02f, -4.96010780e-02f, -6.92395195e-02f, 4.07387279e-02f, -8.84507224e-02f, -5.47451787e-02f,
  2.55268509e-03f, -6.86129406e-02f, 3.67597751e-02f, 1.52425375e-02f, 2.99233478e-02f, 7.64860734e-02f, 4.04005833e-02f, 8.61880258e-02f, 5.54249398e-02f, 1.21389151e-01f,
  -6.22819327e-02f, -1.05388789e-02f, 1.77118070e-02f, -5.58771193e-02f, 3.08161993e-02f, 5.46661802e-02f, -2.04707328e-02f, 7.65004903e-02f, 6.79443497e-03f, 4.87647802e-02f,
  7.91566148e-02f, -2.60293973e-03f, -2.90389098e-02f, -1.82153881e-02f, -4.78845183e-03f, 2.06520483e-02f, -1.06477756e-02f, 6.13991879e-02f, 7.00424537e-02f, 1.90586578e-02f,
  -9.66697410e-02f, -5.36244959e-02f, -8.33600238e-02f, -8.96463096e-02f, 8.19372386e-03f, -9.10162330e-02f, -4.55068685e-02f, -3.90615687e-02f, 7.85598345e-03f, -3.45650688e-02f,
  -2.98738503e-03f, -1.38879204e-02f, 8.36662129e-02f, -6.22443529e-03f, 7.81704485e-02f, 5.68800978e-02f, 7.27854744e-02f, 2.37824093e-03f, 1.37690715e-02f, 6.39623404e-02f,
  4.28486094e-02f, -3.20547521e-02f, 3.36834230e-02f, -6.28480017e-02f, -4.68830466e-02f, -2.73655206e-02f, -8.27050284e-02f, -8.05106834e-02f, 3.55083570e-02f, 2.98781991e-02f,
  -6.07893839e-02f, -2.86741480e-02f, -7.25767687e-02f, 6.12428114e-02f, 9.90031362e-02f, 7.99832791e-02f, 6.98626926e-03f, 7.82414749e-02f, 7.61643052e-02f, 5.97731099e-02f,
  9.44886636e-03f, 9.33550373e-02f, -2.02699229e-02f, 4.90175560e-02f, 1.05385527e-01f, 6.58325702e-02f, 3.77553850e-02f, -5.33311628e-03f, 6.76557496e-02f, 8.68499354e-02f,
  4.09764145e-03f, 3.81429531e-02f, -6.30379617e-02f, -5.98722473e-02f, 7.60461688e-02f, -6.17772229e-02f, 6.96791112e-02f, 9.65783298e-02f, -6.57162666e-02f, -2.08936278e-02f,
  -9.12461579e-02f, -2.96711596e-03f, -3.48794420e-04f, 4.05575968e-02f, 1.21187102e-02f, 1.31750628e-01f, 1.31944299e-01f, 3.90342921e-02f, 9.47622582e-02f, 7.47940019e-02f,
  1.26993537e-01f, -2.19675992e-02f, -3.50291692e-02f, -5.25699630e-02f, 1.06158219e-01f, -4.72196341e-02f, 7.77636394e-02f, -1.35071669e-02f, -1.24462042e-02f, 1.87126652e-03f,
  8.65120366e-02f, 3.85608524e-02f, -3.65636572e-02f, -1.80970263e-02f, 6.46594539e-02f, 8.39535818e-02f, 1.58496313e-02f, 3.28596272e-02f, -3.42792831e-02f, 3.23851081e-03f,
  1.01977766e-01f, 1.62880328e-02f, -5.76224960e-02f, -1.19134024e-01f, 3.84111106e-02f, -3.63492817e-02f, -4.63609537e-03f, 2.77211741e-02f, 5.43337427e-02f, -5.36678247e-02f,
  -3.46962027e-02f, 4.30469448e-03f, -8.51279348e-02f, -1.25994468e-02f, -7.16826767e-02f, 4.16594232e-03f, -9.16745737e-02f, 7.91055262e-02f, 9.00806859e-02f, 4.88461591e-02f,
  3.03009953e-02f, 2.15515736e-02f, -6.07556887e-02f, -4.28893678e-02f, -5.29726706e-02f, 4.94158710e-04f, 7.11771622e-02f, 1.62336323e-02f, -1.04846349e-02f, 1.92274954e-02f,
  5.82987852e-02f, -6.25073165e-02f, 1.89913791e-02f, 4.50588651e-02f, -3.65001298e-02f, 8.58056247e-02f, 8.92618224e-02f, 1.81299299e-02f, -3.20501216e-02f, 9.37410165e-03f,
  -5.96726611e-02f, -1.05756205e-02f, 1.57494936e-02f, 1.12517990e-01f, -5.95467389e-02f, -7.38636926e-02f, -3.14476341e-02f, -3.28212269e-02f, -1.45629942e-02f, 1.29533187e-02f,
  6.54539615e-02f, 3.52780707e-02f, 6.24962598e-02f, -1.30331172e-02f, -5.39655946e-02f, 2.94950884e-03f, 3.60331163e-02f, -7.42462464e-03f, -7.13201091e-02f, 1.67961456e-02f,
  9.16770399e-02f, -3.57230529e-02f, 4.81483750e-02f, 4.04659212e-02f, -8.94072130e-02f, -7.02057183e-02f, 7.95345567e-03f, 7.47168884e-02f, -8.49608853e-02f, 2.77078021e-02f,
  5.28412797e-02f, -5.17716259e-02f, 7.17056394e-02f, -2.48311926e-02f, -1.44303255e-02f, 4.19379771e-02f, 1.24682738e-02f, 3.92218493e-02f, 9.70032532e-03f, 9.85482559e-02f,
  -7.84327164e-02f, 2.78609470e-02f, 8.31702426e-02f, 2.88086291e-02f, -1.04559108e-03f, -1.79401785e-02f, 5.87561578e-02f, 5.18363751e-02f, 8.69135782e-02f, 9.46644023e-02f,
  2.28747964e-01f, -1.04208365e-01f, 1.10480413e-01f, 1.48692384e-01f, 1.39574856e-01f, 3.58983986e-02f, 2.10130792e-02f, 4.68829945e-02f, 1.67267751e-02f, 6.13604952e-03f,
  7.69226486e-03f, -4.61231768e-02f, -1.19704291e-01f, -5.91611266e-02f, -7.85761401e-02f, -4.98062111e-02f, -3.43697108e-02f, 4.32265475e-02f, -6.28264323e-02f, 7.12942630e-02f,
  -1.15135677e-01f, 3.03782597e-02f, -6.26321733e-02f, -7.94288665e-02f, 2.67087314e-02f, -4.96009625e-02f, -2.22705561e-03f, 5.96371703e-02f, -6.07908294e-02f, -5.43988459e-02f,
  5.70585541e-02f, -5.23665594e-03f, 6.92249089e-03f, 1.19686266e-02f, -4.12105061e-02f, -7.52519593e-02f, 2.26727333e-02f, 5.96986562e-02f, -9.20598581e-02f, 5.51095493e-02f,
  6.18891045e-03f, -8.60298946e-02f, 4.40527648e-02f, 5.28970063e-02f, 1.81598607e-02f, -5.15365042e-02f, -4.19694223e-02f, 1.86618418e-02f, -8.20901617e-02f, -4.94767949e-02f,
  -9.08154696e-02f, -4.53234315e-02f, 4.61131781e-02f, -4.74448800e-02f, -8.23678225e-02f, 7.17193112e-02f, 1.13771446e-02f, -4.24153246e-02f, -5.93025871e-02f, -3.78284492e-02f,
  4.12489176e-02f, 5.05661368e-02f, -4.28273268e-02f, -1.57130640e-02f, -6.82766587e-02f, -5.45949815e-03f, 5.67616783e-02f, -3.93524952e-02f, 1.35957235e-02f, -3.11465114e-02f,
  -5.94555214e-03f, -6.82684705e-02f, 2.58144103e-02f, -3.73105370e-02f, -1.81097221e-02f, -1.01569362e-01f, 4.36148047e-02f, -5.00090308e-02f, -2.72749327e-02f, -4.29800563e-02f,
  -7.46221989e-02f, 2.87515670e-02f, 8.25416967e-02f, 1.44956913e-02f, -2.72911824e-02f, -3.12187169e-02f, 4.84432317e-02f, -7.92745426e-02f, 5.23244590e-02f, 7.79976621e-02f,
  -1.37088224e-01f, 1.01641417e-01f, -3.46188694e-02f, -8.87027308e-02f, 2.92231853e-04f, 6.93385229e-02f, 1.86429676e-02f, 9.56816226e-03f, -6.74665123e-02f, 3.41077219e-03f,
  -4.81844991e-02f, -2.97466088e-02f, 5.52201606e-02f, -1.21299382e-02f, 4.58598789e-03f, 5.08776084e-02f, 4.46750857e-02f, 2.25533582e-02f, 5.90869412e-02f, -3.85272829e-03f,
  2.62568370e-02f, 9.30140465e-02f, -4.57142992e-03f, 4.49857116e-03f, 5.37334755e-02f, 3.96815091e-02f, 8.19720626e-02f, 5.51579334e-02f, 7.90780634e-02f, -1.96369085e-02f,
  2.57394224e-01f, 4.05067950e-02f, -8.60540569e-02f, 5.24526685e-02f, -1.61821432e-02f, 1.94488466e-02f, 8.95821005e-02f, -6.67655617e-02f, -1.06271924e-02f, -1.75467823e-02f,
  -8.57301652e-02f, -5.52502684e-02f, 9.45527572e-05f, -5.09137325e-02f, 9.05699804e-02f, -4.11479324e-02f, -1.58222523e-02f, -1.62333883e-02f, -3.73647772e-02f, -7.86437690e-02f,
  -1.18184783e-01f, 9.90228355e-02f, 3.93313169e-02f, -4.27452698e-02f, -7.50151509e-03f, -1.24147711e-02f, 7.18934685e-02f, -5.70520721e-02f, -6.03735857e-02f, -3.97607535e-02f,
  -1.33082151e-01f, -6.82214797e-02f, -7.16231540e-02f, 6.44138455e-02f, 2.08022129e-02f, 5.85544854e-03f, 4.87994887e-02f, -8.75438377e-02f, 2.68187430e-02f, 2.58016251e-02f,
  1.56881602e-03f, -1.09768026e-01f, -4.98482659e-02f, -5.03654107e-02f, 5.68008982e-02f, -1.73872225e-02f, -4.48467098e-02f, -1.11667207e-02f, -3.39802913e-02f, 1.72879081e-02f,
  3.31036537e-03f, -9.41559374e-02f, 7.95606077e-02f, -2.52071172e-02f, -3.72135863e-02f, 7.10795894e-02f, -5.78800365e-02f, -3.20877694e-02f, -6.39217719e-02f, 3.13736014e-02f,
  5.20964116e-02f, 1.85977537e-02f, -3.38918492e-02f, 2.18711905e-02f, 3.49580497e-02f, -6.84321597e-02f, 8.33102129e-03f, -6.68807328e-02f, -2.94303894e-02f, -3.86223756e-02f,
  -2.63787573e-03f, 1.55557673e-02f, 3.40195708e-02f, -4.30566519e-02f, -6.61730766e-02f, 6.51339069e-04f, 1.25625385e-02f, 7.05241710e-02f, 5.13680875e-02f, 2.01684330e-02f,
  4.18721773e-02f, 2.33679116e-02f, 3.28466631e-02f, 5.01193926e-02f, -5.95725514e-02f, -1.05467075e-02f, 3.44727598e-02f, -1.04756933e-03f, -6.38610274e-02f, 6.54481128e-02f,
  -1.23811975e-01f, -1.10849574e-01f, 1.61962342e-02f, 1.90438405e-02f, 1.79182794e-02f, -1.98773462e-02f, 2.70969904e-04f, 5.57871088e-02f, -6.92505464e-02f, -1.15809562e-02f,
  3.48939411e-02f, 4.18580920e-02f, -7.66540766e-02f, -7.86505491e-02f, 2.61348113e-02f, -2.60172598e-02f, 7.15422705e-02f, -2.53681978e-03f, 1.99912209e-02f, -5.79937845e-02f,
  -2.34649908e-02f, 2.16027293e-02f, 1.24914490e-01f, -2.58738957e-02f, -1.33881560e-02f, -3.61345857e-02f, 1.66539028e-02f, 3.68895126e-03f, 1.13395408e-01f, 3.20019200e-02f,
  -2.79880725e-02f, -5.83831407e-02f, -4.91356105e-02f, 7.32185021e-02f, 8.73242915e-02f, 1.07973568e-01f, -3.74503210e-02f, 2.47801133e-02f, -4.41821516e-02f, 4.89358790e-02f,
  8.50793347e-02f, 1.22895807e-01f, 6.43831268e-02f, 8.47601444e-02f, -3.72331031e-02f, 1.03854783e-01f, 8.04357827e-02f, -1.86939165e-02f, 6.25527501e-02f, 5.11745363e-02f,
  1.20111935e-01f, -8.12714249e-02f, 1.99607406e-02f, -4.84525412e-02f, 4.94432114e-02f, 3.62970419e-02f, 1.84846055e-02f, -1.28273722e-02f, 7.66487494e-02f, -4.43853959e-02f,
  7.65791163e-03f, -6.05929010e-02f, -6.22622967e-02f, 2.65285037e-02f, -2.93573309e-02f, 2.38781571e-02f, -3.08580939e-02f, -1.25899211e-01f, -1.11082532e-01f, -1.28676891e-01f,
  4.73368913e-02f, -2.35945825e-02f, -2.87261643e-02f, -3.00331023e-02f, 2.59886216e-02f, 6.09754398e-02f, -1.15476288e-01f, -9.79836956e-02f, 1.56567544e-02f, 4.19601165e-02f,
  -2.53367163e-02f, -7.16062561e-02f, -8.28793943e-02f, -4.58044261e-02f, -4.08092253e-02f, 4.69711684e-02f, -1.91460196e-02f, 3.12735438e-02f, -1.20974500e-02f, -9.17751491e-02f,
  7.90467262e-02f, 3.65156820e-03f, -8.59479085e-02f, 6.58143684e-02f, -7.82883018e-02f, -8.08894560e-02f, 6.44577220e-02f, 6.38605729e-02f, -7.71142319e-02f, -2.40488220e-02f,
  -5.57301082e-02f, -1.20416237e-02f, -8.51983950e-02f, 4.04336751e-02f, -8.93909708e-02f, -5.49750291e-02f, 4.12004180e-02f, -8.57155845e-02f, -8.70575830e-02f, 1.37568405e-02f,
  6.39027283e-02f, -4.90998151e-03f, 3.93549167e-02f, -9.16636363e-02f, -5.97510580e-03f, 3.64519209e-02f, 5.76274935e-03f, -5.93995415e-02f, -2.66685244e-02f, -6.64620399e-02f,
  4.88003902e-02f, -8.21264759e-02f, 5.80067672e-02f, 4.45120881e-04f, 8.55695158e-02f, 3.87653187e-02f, 1.69520930e-03f, 3.78571115e-02f, -4.08804081e-02f, 1.67414139e-03f,
  7.30292574e-02f, 5.90289049e-02f, 5.13265934e-03f, -6.82732910e-02f, -1.62422657e-02f, 3.26285101e-02f, 2.22429931e-02f, 1.39948903e-02f, -4.90667224e-02f, 7.23288730e-02f,
  -5.12615964e-02f, -5.08128144e-02f, -5.55511862e-02f, -1.20721124e-02f, 1.54601410e-02f, -1.38234356e-02f, 5.95481461e-03f, 3.54081020e-02f, -1.27100842e-02f, -3.84072065e-02f,
  -4.09575105e-01f, -2.25147996e-02f, 1.47451116e-02f, -2.37148106e-01f, -2.13795267e-02f, 1.40380144e-01f, 2.81128794e-01f, 7.08985748e-03f, -6.42979816e-02f, 1.88296959e-02f,
  4.83815186e-02f, -3.58449072e-02f, -8.60638171e-02f, -5.24675213e-02f, 1.32882267e-01f, 8.14939141e-02f, 1.26184836e-01f, -1.38953459e-02f, -6.32170513e-02f, -5.98986410e-02f,
  4.49658819e-02f, -1.22917302e-01f, -2.36754477e-01f, -8.87191221e-02f, -1.03473574e-01f, -1.33215502e-01f, -1.27009014e-02f, -6.80266842e-02f, 4.19192687e-02f, -4.82721068e-02f,
  -4.12479788e-02f, 5.02273217e-02f, 7.17165843e-02f, -9.50624347e-02f, 6.48045167e-02f, -4.58913110e-02f, -1.07976004e-01f, -3.26688960e-02f, -1.17456391e-01f, 3.41673658e-05f,
  -8.46612081e-02f, 6.36953861e-02f, -9.02151912e-02f, 5.86621277e-02f, -5.00610657e-02f, -4.51140329e-02f, -6.08314946e-02f, -1.09455194e-02f, 4.81628999e-03f, -2.88165975e-02f,
  1.43479094e-01f, -1.42762568e-02f, -7.31882006e-02f, 1.34683773e-01f, 6.21131994e-02f, -1.61379855e-02f, -3.29684615e-02f, -2.98075695e-02f, 9.54527780e-03f, -7.16723502e-02f,
  1.44935464e-02f, -3.28285359e-02f, 4.28554341e-02f, -4.22785543e-02f, 5.04159778e-02f, -2.61875391e-02f, 1.19120004e-02f, -4.20229770e-02f, 1.55640729e-02f, -2.66973786e-02f,
  -4.88434322e-02f, 4.82685864e-02f, 2.96925437e-02f, -4.16877009e-02f, 4.45092283e-03f, 1.28533291e-02f, 2.46707024e-03f, -2.62166280e-02f, -1.79000031e-02f, -3.48447710e-02f,
  4.66633514e-02f, -5.02911843e-02f, -4.11889628e-02f, 4.29226235e-02f, -7.45779276e-03f, 9.46639031e-02f, 2.24874001e-02f, -2.23731585e-02f, 3.21996100e-02f, -3.59498593e-03f,
  -1.58214867e-01f, 2.20479697e-01f, 8.95488542e-03f, -6.42987639e-02f, -3.59808281e-02f, -8.85251984e-02f, 3.07512414e-02f, 2.23099440e-02f, -5.20359054e-02f, 2.97275670e-02f,
  -5.20530567e-02f, 7.79680759e-02f, 1.17713613e-02f, 7.46551976e-02f, 5.22300135e-03f, 6.43765554e-02f, 7.76806101e-02f, -6.93537220e-02f, 1.25897080e-01f, -5.55698462e-02f,
  1.19896382e-02f, 5.25929227e-06f, -2.68854294e-02f, -7.19014602e-03f, -2.40611229e-02f, 7.12349862e-02f, 1.83251221e-02f, 8.38356912e-02f, 9.37091485e-02f, -2.95985881e-02f,
  1.16511015e-02f, -7.01049566e-02f, 4.29405645e-03f, -6.10223301e-02f, 5.41048273e-02f, -8.45080391e-02f, -1.12757273e-02f, -7.62769207e-02f, 1.70280188e-02f, -6.97708055e-02f,
  7.20788240e-02f, 6.09277794e-03f, 5.01554310e-02f, -7.40161762e-02f, 7.14563206e-02f, 3.10472380e-02f, 2.42779572e-02f, -2.82084942e-02f, -8.36027265e-02f, -1.21147290e-01f,
  -5.93479201e-02f, 3.32908817e-02f, 9.29164439e-02f, 2.17711311e-02f, -1.10046871e-01f, 2.45526358e-02f, -2.29123514e-02f, -1.68912136e-03f, -3.92275676e-02f, 9.94999427e-03f,
  -2.57832929e-02f, 6.85077086e-02f, 3.29374596e-02f, 3.41509879e-02f, 2.97733247e-02f, -2.70515215e-04f, -4.84903753e-02f, 6.67345151e-02f, -3.41343172e-02f, 9.64261740e-02f,
  3.71260643e-02f, -6.81528822e-02f, -1.84292905e-02f, 1.03420287e-03f, 6.57649785e-02f, -3.65846492e-02f, 4.89072911e-02f, -6.56326711e-02f, 1.35633384e-03f, 2.16989759e-02f,
  -1.09576277e-01f, -7.05732182e-02f, -2.83201989e-02f, 9.98327658e-02f, 2.55505778e-02f, 1.04638696e-01f, 8.11962113e-02f, 6.76058382e-02f, 8.25819448e-02f, 8.40357468e-02f,
  4.82153939e-03f, -7.05720931e-02f, 6.88134357e-02f, 7.50981495e-02f, 3.86756808e-02f, 6.82714507e-02f, 5.31306975e-02f, -8.64176452e-03f, 8.46304279e-03f, 4.04945798e-02f,
  -6.90153092e-02f, 9.19411145e-03f, -3.67307924e-02f, 6.98019117e-02f, -7.06142709e-02f, 5.06954230e-02f, -7.19386190e-02f, -8.66485089e-02f, -6.91627264e-02f, 5.93614317e-02f,
  -2.58053355e-02f, 5.77641502e-02f, -4.50705364e-02f, -8.18989575e-02f, -9.33100507e-02f, -6.54190108e-02f, 1.03532821e-02f, -7.80681819e-02f, 3.96406604e-03f, -2.79467297e-03f,
  9.16240513e-02f, -1.09316288e-02f, 5.99573962e-02f, -5.55290915e-02f, 9.14401561e-02f, 9.06968396e-03f, -1.46232150e-03f, -6.86551929e-02f, -5.18287756e-02f, 8.04528669e-02f,
  -5.55461906e-02f, 8.59652981e-02f, -8.03496465e-02f, -2.37225592e-02f, 3.86920497e-02f, 1.58352556e-03f, 4.45758551e-02f, -1.44401798e-02f, -6.37380630e-02f, -1.23889148e-02f,
  1.90739837e-02f, -2.69238856e-02f, 8.57058764e-02f, 1.12381920e-01f, -1.48046333e-02f, 7.57662505e-02f, 8.75916034e-02f, -6.68102317e-03f, -4.66376022e-02f, 3.22841667e-02f,
  5.62257431e-02f, 8.43258053e-02f, 1.10478267e-01f, 2.58218408e-01f, 2.37142548e-01f, 2.90403664e-01f, 2.64380604e-01f, 2.73583859e-01f, 7.19950646e-02f, 1.03099741e-01f,
  1.64357275e-01f, 2.23266166e-02f, 4.72402982e-02f, -3.33922133e-02f, 6.85904846e-02f, 1.15023509e-01f, 1.26624748e-01f, 2.09937952e-02f, 5.43495268e-02f, 1.67038053e-01f,
  -2.59444565e-02f, -4.52904962e-02f, 1.38009097e-02f, 3.51683944e-02f, -6.94408938e-02f, -4.87467609e-02f, 1.15759864e-01f, 6.65899217e-02f, 1.02985986e-02f, -9.66911539e-02f,
  -5.15455939e-02f, 1.32110819e-01f, 4.75017503e-02f, -1.00211412e-01f, 2.12499350e-02f, -3.19712013e-02f, -1.42497495e-02f, -7.03775212e-02f, 4.14384417e-02f, -4.14933041e-02f,
  -1.52683798e-02f, -6.16044626e-02f, 2.48969495e-02f, -1.49856070e-02f, -6.91875517e-02f, 1.82795487e-02f, -9.45473835e-02f, 2.25090533e-02f, 7.06249699e-02f, 5.12390397e-02f,
  -2.39166785e-02f, 3.93229723e-03f, 2.02140044e-02f, 3.61071830e-03f, 1.16400257e-01f, 9.40858796e-02f, 4.48895171e-02f, -8.99369568e-02f, 3.52807832e-03f, -8.30804855e-02f,
  -4.80197865e-04f, 1.72930155e-02f, 9.00387466e-02f, 1.13550192e-02f, -5.56584969e-02f, 4.22967859e-02f, 2.13950872e-02f, 1.29415188e-02f, 7.63697848e-02f, -1.20116919e-01f,
  -5.97242042e-02f, 1.29221991e-01f, 4.04115245e-02f, 1.49805015e-02f, 5.48899882e-02f, 6.80300668e-02f, -1.20467551e-01f, 1.18716825e-02f, -4.91247624e-02f, -2.03596719e-04f,
  -1.03461884e-01f, 6.56335205e-02f, -4.87134457e-02f, -2.48414185e-02f, 5.26124947e-02f, 2.23610830e-02f, 1.59974024e-02f, 1.81677733e-02f, 3.88385430e-02f, -1.12603195e-01f,
  -4.07638447e-03f, 1.09331332e-01f, -1.00094765e-01f, -4.60705422e-02f, -2.14851219e-02f, -1.16664678e-01f, 3.92713994e-02f, -5.54971024e-02f, -8.62915535e-03f, 5.96214086e-02f,
  1.28945441e-03f, -5.22325863e-04f, 6.78832456e-03f, -5.16098440e-02f, 6.32415107e-03f, 5.26746139e-02f, -4.47857194e-03f, 7.74458870e-02f, -6.86154142e-02f, -7.07376078e-02f,
  -3.49494889e-02f, 1.91908386e-02f, 2.25705188e-02f, 1.08536556e-01f, 4.64414321e-02f, 4.55856733e-02f, 2.63528898e-04f, -3.15195918e-02f, 1.21771179e-01f, -8.42998698e-02f,
  -1.53132349e-01f, 1.15286961e-01f, -1.05114192e-01f, -1.06668353e-01f, 6.72935545e-02f, -3.64987068e-02f, -4.63566855e-02f, -3.59457284e-02f, -3.40335891e-02f, -4.24782448e-02f,
  -3.01297866e-02f, -1.02756962e-01f, -2.32634787e-02f, 3.64514440e-02f, -1.53169513e-01f, 2.31916923e-02f, 3.57045494e-02f, -3.23967338e-02f, 2.53681056e-02f, -1.13047762e-02f,
  1.45069376e-01f, -3.55470506e-03f, -9.67377350e-02f, -4.49963994e-02f, 1.16823912e-01f, 2.43192073e-02f, -1.21176712e-01f, 2.29812600e-02f, 1.53443009e-01f, 2.77420640e-01f,
  4.75625396e-02f, 4.22454178e-02f, -4.45385128e-02f, 9.93927568e-02f, -3.05648390e-02f, -1.83135197e-02f, -6.32286957e-03f, -4.45464961e-02f, 1.80891529e-02f, -1.36583834e-03f,
  8.68267119e-02f, 1.72933564e-02f, -7.28844106e-02f, -4.50914055e-02f, -5.91626391e-02f, 2.33309660e-02f, -1.48493694e-02f, -5.12743741e-02f, -3.54929757e-03f, 5.15040867e-02f,
  1.36000633e-01f, 1.89185828e-01f, -7.59361265e-03f, -3.19965184e-02f, -4.74640168e-02f, 2.61905920e-02f, -1.84527095e-02f, 2.92058885e-02f, -4.21711653e-02f, -2.05808561e-02f,
  5.20763323e-02f, 1.16048887e-01f, 8.91086236e-02f, -1.07549401e-02f, 4.55257893e-02f, -2.66146008e-03f, -4.02465090e-02f, -4.51121293e-02f, -3.27589773e-02f, 1.59481857e-02f,
  -2.70339325e-02f, 1.41261062e-02f, -1.20934788e-02f, -1.06562413e-01f, 5.68423793e-03f, 4.13920991e-02f, -2.54422124e-03f, -4.88003790e-02f, -5.36391996e-02f, -3.00919916e-02f,
  4.59576771e-02f, -6.06878623e-02f, -8.28339458e-02f, -4.13523428e-03f, -2.41078902e-02f, -1.62174515e-02f, 8.09306093e-03f, 4.68538888e-02f, 3.85126658e-02f, 1.35187432e-01f,
  -2.28478819e-01f, -3.96416634e-02f, 4.59148223e-03f, -5.93299270e-02f, -5.82155883e-02f, 1.30235460e-02f, -5.45194792e-03f, 5.62236197e-02f, 2.66585220e-02f, 1.00997664e-01f,
  -2.60438267e-02f, 1.79634187e-02f, 4.84797684e-03f, -4.97880615e-02f, 6.02697581e-02f, 7.05277771e-02f, 1.05486512e-02f, -2.17719879e-02f, 4.79119197e-02f, 2.37650964e-02f,
  -4.97600622e-02f, -4.27703746e-02f, 1.22942431e-02f, -9.67495441e-02f, -9.19265226e-02f, 2.96017639e-02f, -2.62385886e-02f, -1.25326365e-01f, -1.17734998e-01f, -1.42023355e-01f,
  -4.98559207e-01f, 1.05090402e-02f, -2.34969616e-01f, -1.60254002e-01f, 1.59824029e-01f, 1.67148247e-01f, 2.60576934e-01f, 6.17663302e-02f, 3.29284407e-02f, 1.08982138e-01f,
  -4.67242934e-02f, 7.16408268e-02f, 6.49361163e-02f, 1.51188761e-01f, 1.48419052e-01f, 1.27721846e-01f, 2.22028688e-01f, -5.71909025e-02f, -8.77147540e-03f, 4.09172028e-02f,
  2.02490445e-02f, -1.10101081e-01f, -3.51993650e-01f, -5.90104610e-02f, -9.68285743e-03f, -1.12069897e-01f, -1.11532167e-01f, -4.70182933e-02f, 6.40871450e-02f, 8.43645111e-02f,
  -4.95510586e-02f, -1.65195405e-01f, 4.65314873e-02f, 9.31371655e-03f, -1.02465697e-01f, -1.82253160e-02f, -2.82803196e-02f, -1.94594469e-02f, -5.00505082e-02f, -5.72887585e-02f,
  6.68237954e-02f, 1.06646335e-02f, 4.98248264e-02f, -7.09607378e-02f, 1.10876998e-02f, 2.53363736e-02f, -8.27131942e-02f, -3.06333229e-02f, -9.12979841e-02f, -5.54127656e-02f,
  5.89557998e-02f, 7.63893640e-03f, -1.10348240e-01f, 9.12294462e-02f, -4.00108695e-02f, -2.22845264e-02f, 7.42455339e-03f, 3.40495221e-02f, -9.88308117e-02f, -1.10032290e-01f,
  7.29757547e-02f, -4.15211879e-02f, 5.43691143e-02f, 1.33394832e-02f, -4.03549224e-02f, 1.25438161e-02f, 1.01876318e-01f, 7.06990883e-02f, -5.20580634e-02f, 3.62191088e-02f,
  -5.87674277e-03f, -2.90525500e-02f, -5.54330796e-02f, 2.48391740e-03f, -1.47105101e-03f, 5.07518761e-02f, -2.67178975e-02f, 3.65395024e-02f, -3.95260155e-02f, -3.45714279e-02f,
  1.72154524e-03f, 8.45380593e-03f, -4.82821278e-02f, 6.86205411e-03f, -4.36007138e-03f, 5.49806505e-02f, -4.06178869e-02f, 6.63187951e-02f, -3.68090495e-02f, -2.06317827e-02f,
  -1.66084588e-01f, 3.94940451e-02f, -4.22227941e-02f, 8.50815028e-02f, -2.95903068e-03f, -6.80229291e-02f, -9.09698829e-02f, -4.62930687e-02f, 5.68541102e-02f, -2.24004909e-02f,
  -2.97505371e-02f, -4.50590216e-02f, 3.69970351e-02f, -2.94700209e-02f, -5.58540924e-03f, -5.36874533e-02f, 1.01231160e-02f, 5.10828756e-02f, 9.86716747e-02f, -1.08213522e-01f,
  1.01225423e-02f, -1.18788490e-02f, -3.57962921e-02f, -1.10291019e-02f, 5.82028329e-02f, -2.21403837e-02f, -7.38807395e-02f, -4.84930761e-02f, -4.43272330e-02f, -8.12454820e-02f,
  -8.61531273e-02f, 2.71424592e-01f, 4.62614894e-02f, 2.51686543e-01f, 2.80372918e-01f, 1.58597469e-01f, 3.63042027e-01f, 1.52153417e-01f, -1.43084541e-01f, 2.29754150e-02f,
  2.27555141e-01f, -8.73257872e-03f, 2.49685836e-03f, -2.47584539e-03f, 8.86656865e-02f, 2.11188719e-02f, 7.16099665e-02f, -8.77228975e-02f, -1.73424348e-01f, 3.91023606e-02f,
  1.58299714e-01f, -7.49118160e-03f, -1.06587939e-01f, -1.22694157e-01f, 1.09960996e-01f, -4.34469506e-02f, -4.42816541e-02f, 4.47692844e-04f, 5.40753454e-02f, 1.92337222e-02f,
  5.31423092e-02f, 2.24191353e-01f, -1.31230816e-01f, -1.21346265e-01f, 7.10376725e-02f, -1.64563268e-01f, -2.38935277e-02f, -7.23851472e-02f, -6.36644736e-02f, -8.92989561e-02f,
  5.71302548e-02f, -9.12070796e-02f, 8.59120563e-02f, 5.58177568e-02f, -1.39895342e-02f, 1.90072805e-02f, -9.30606648e-02f, -1.85751973e-03f, -6.90037459e-02f, 7.35770389e-02f,
  1.76997691e-01f, 1.23608969e-01f, 1.59067616e-01f, 4.98430803e-02f, 1.04301609e-01f, 5.12370840e-02f, 1.39390767e-01f, 3.45103932e-03f, 1.98632721e-02f, -8.38319063e-02f,
  -1.24364272e-01f, 1.31000178e-02f, 1.40760839e-03f, -3.16731371e-02f, -6.03787936e-02f, -1.35030709e-02f, -2.51502972e-02f, 8.17192197e-02f, 2.22023446e-02f, -8.47989228e-03f,
  4.55043055e-02f, -4.61519696e-02f, 5.34316748e-02f, -6.01272061e-02f, -3.10384277e-02f, 6.76028244e-03f, 6.88072667e-02f, -4.19390015e-02f, 3.43580730e-02f, -1.56805012e-02f,
  2.10654223e-03f, 1.26940951e-01f, -5.83738927e-03f, 1.18517064e-01f, -8.53060856e-02f, -4.42606583e-02f, -4.60991450e-02f, 4.66966396e-03f, -6.82682469e-02f, -1.66566018e-02f,
  -1.71502739e-01f, 1.82913393e-02f, -9.51265767e-02f, -3.90018773e-04f, 1.25928526e-03f, -7.27568418e-02f, 1.13666199e-01f, 3.41907814e-02f, -3.85353621e-03f, 2.64569204e-02f,
  6.84145838e-02f, -2.87009180e-02f, 9.47832689e-02f, -1.02070332e-01f, 6.68476820e-02f, -7.76470676e-02f, -8.82577151e-02f, 4.43821438e-02f, -5.32453433e-02f, -4.17050719e-02f,
  1.98349971e-02f, -1.35047346e-01f, -1.50724962e-01f, -7.30585714e-04f, 6.54654130e-02f, -9.35016945e-02f, -7.79417008e-02f, -6.35232925e-02f, -7.94026107e-02f, -2.72611916e-01f,
  9.42145754e-03f, 1.31757215e-01f, 1.42894566e-01f, 1.63614831e-03f, -5.62741887e-03f, 4.09677699e-02f, 9.47854575e-03f, -6.87972410e-03f, 5.68670705e-02f, 2.54328046e-02f,
  -7.10835755e-02f, 6.04620427e-02f, -8.36388022e-02f, 2.33307462e-02f, 5.75608648e-02f, -1.00886459e-02f, -1.17667369e-03f, -4.14441265e-02f, 1.09456040e-01f, 4.93958257e-02f,
  -5.56286946e-02f, -7.70456297e-03f, 1.07326977e-01f, -2.01066602e-02f, 6.14377633e-02f, -6.21409491e-02f, 1.05843566e-01f, 1.04320720e-02f, 3.21622305e-02f, 1.47003308e-01f,
  -6.02377243e-02f, 2.11715251e-02f, -5.48164994e-02f, -3.41131724e-02f, -6.15387447e-02f, -5.10908067e-02f, 7.70231634e-02f, -1.04689784e-02f, -1.40427770e-02f, 6.22321218e-02f,
  3.83046046e-02f, 1.09910250e-01f, 7.39285648e-02f, 2.19976418e-02f, -2.48536170e-02f, -4.59130183e-02f, 7.17759579e-02f, 6.05702512e-02f, 6.37191162e-02f, -3.70468311e-02f,
  -4.75608222e-02f, -7.10343271e-02f, 1.75225213e-02f, -9.17984918e-02f, -7.27161095e-02f, 5.23931272e-02f, -4.25506197e-02f, 2.00339723e-02f, 5.32234982e-02f, -1.40332105e-02f,
  -9.11828354e-02f, 5.01638725e-02f, -1.12018210e-03f, 2.27097012e-02f, 3.03675942e-02f, 7.57373869e-02f, 3.48952748e-02f, 2.40453873e-02f, 2.02480592e-02f, -2.05725804e-02f,
  2.05402263e-02f, 4.99013327e-02f, 3.99607643e-02f, 4.66768853e-02f, -1.62425265e-02f, -2.76771523e-02f, -5.70667945e-02f, -2.49095075e-02f, 7.99366608e-02f, 3.17374840e-02f,
  -5.43721579e-02f, -6.26031905e-02f, 1.10621108e-02f, 9.27219167e-02f, 5.29318899e-02f, 2.53421050e-02f, 4.88895737e-02f, -3.13665196e-02f, -6.76289350e-02f, -5.25476504e-03f,
  -1.25940666e-01f, 3.95476706e-02f, -4.14332598e-02f, 6.09683692e-02f, -1.12121999e-02f, -8.77644345e-02f, 5.04206419e-02f, 5.24653532e-02f, -5.81117868e-02f, -1.44894924e-02f,
  -8.20896029e-02f, 5.32557862e-03f, 8.30885097e-02f, -2.60860287e-02f, -8.37576482e-03f, -9.19773057e-02f, -7.22594708e-02f, 8.48039165e-02f, -6.03520162e-02f, 1.33967753e-02f,
  2.14289408e-02f, -3.59157589e-03f, -1.11836821e-01f, -1.09232895e-01f, 1.64879635e-02f, -1.35007471e-01f, 5.49382642e-02f, -1.02208920e-01f, -1.04222046e-02f, -3.32591198e-02f,
  9.95015204e-02f, -8.29211995e-03f, -1.48134455e-02f, -3.88440005e-02f, 3.68883670e-03f, -1.08680762e-01f, -2.04285979e-02f, 8.61763302e-03f, -9.92516801e-02f, -3.77224013e-02f,
  -7.76949227e-02f, -9.87396613e-02f, -1.08428458e-02f, -3.89106125e-02f, 6.30887896e-02f, -1.05764695e-01f, -7.15340450e-02f, -9.64685604e-02f, -5.15520945e-02f, 4.31505032e-02f,
  -6.18696697e-02f, -5.51784337e-02f, 5.96419312e-02f, -1.13423429e-01f, 3.46306115e-02f, -5.92306815e-02f, -8.60814601e-02f, -6.24593981e-02f, 4.76504397e-03f, 5.15595786e-02f,
  -5.22857755e-02f, -4.65261610e-03f, -7.53780734e-03f, -6.39711693e-02f, 3.87010165e-02f, -5.75407408e-02f, 4.98517156e-02f, 6.21841177e-02f, 1.73182599e-02f, 5.59998043e-02f,
  -9.82104149e-03f, 7.23057985e-02f, 1.14941234e-02f, -6.83763484e-03f, 3.83513868e-02f, -6.98314235e-02f, -6.58434704e-02f, -5.81059940e-02f, 7.84982741e-03f, -7.96073228e-02f,
  1.80669669e-02f, 1.21228471e-01f, -1.21262681e-03f, -6.75978884e-02f, 3.19750234e-02f, 3.79150994e-02f, -7.34342784e-02f, 4.39948812e-02f, 2.18405630e-02f, -8.48134458e-02f,
  1.00229427e-01f, 5.04971948e-03f, 7.12372437e-02f, 2.00801045e-02f, -3.36496113e-03f, 2.16911417e-02f, -1.69929266e-02f, 2.20306944e-02f, -2.21882295e-02f, 7.35989437e-02f,
  -1.58946458e-02f, -2.57366318e-02f, 6.64381683e-02f, 5.33893518e-02f, -6.55402616e-02f, 2.13782992e-02f, 6.92547709e-02f, 7.39684477e-02f, 2.76537463e-02f, 5.82170933e-02f,
  4.01504189e-02f, -6.84561878e-02f, 7.61644244e-02f, -3.09197977e-02f, -7.08011016e-02f, -9.19487402e-02f, 7.90359173e-03f, -3.04518491e-02f, 7.75211230e-02f, 3.99094224e-02f,
  -1.27714053e-01f, -5.98031208e-02f, -8.73262286e-02f, 3.96594852e-02f, 3.03627886e-02f, -5.32718711e-02f, 6.27503917e-02f, -2.65627559e-02f, 3.28129977e-02f, -6.89334720e-02f,
  -5.08752726e-02f, 1.21643236e-02f, -5.41397557e-02f, 4.00491171e-02f, 4.51622754e-02f, 5.79795279e-02f, 6.83709979e-02f, 3.67990099e-02f, 9.92252529e-02f, 9.00347233e-02f,
  7.92661458e-02f, 9.75113362e-02f, 5.87889850e-02f, -5.10479957e-02f, 8.64415690e-02f, 1.39358744e-01f, 2.22423635e-02f, -5.92530891e-02f, -2.08620541e-02f, 2.27367152e-02f,
  1.92203671e-01f, -8.30667391e-02f, 3.06535438e-02f, 1.18721485e-01f, 5.45912683e-02f, 1.06334761e-01f, 1.60957247e-01f, 1.33662000e-01f, 4.69308048e-02f, -2.82888412e-02f,
  5.89708462e-02f, -7.87393525e-02f, -7.85867572e-02f, 5.97442240e-02f, 3.46344635e-02f, 6.37484714e-02f, 5.77254519e-02f, -3.57100442e-02f, 1.31511554e-01f, 1.23540655e-01f,
  -5.80137670e-02f, -6.51281551e-02f, 1.16609387e-01f, -6.79626912e-02f, -8.90764147e-02f, -1.10654095e-02f, -1.20610377e-04f, 2.00516675e-02f, -1.20946057e-02f, 7.96377473e-03f,
  8.19872320e-03f, 5.65907173e-02f, -6.72133565e-02f, -8.36585928e-03f, -7.24053681e-02f, -3.02157253e-02f, 4.83381599e-02f, 1.60268284e-02f, -5.36861382e-02f, -5.17155901e-02f,
  5.25878854e-02f, 2.03241967e-03f, 3.00540328e-02f, -2.93824263e-02f, -2.81748809e-02f, 1.02628030e-01f, -9.44327563e-02f, 1.87796596e-02f, 7.54099488e-02f, 7.46744946e-02f,
  -1.10424839e-01f, 5.17713418e-03f, -2.03671269e-02f, 3.30047570e-02f, -2.32174955e-02f, -2.99777780e-02f, 7.77258575e-02f, -1.81524288e-02f, 4.01333068e-03f, 4.67920564e-02f,
  2.36874204e-02f, 4.68607731e-02f, -3.34670581e-02f, -2.71563977e-02f, -5.41491155e-03f, -8.51900727e-02f, -4.90555391e-02f, 2.13649403e-02f, 7.47723058e-02f, -5.39106224e-03f,
  5.91241010e-02f, 2.07677986e-02f, -1.53658409e-02f, -5.14117181e-02f, 5.74727952e-02f, -7.19476193e-02f, 5.00136651e-02f, 8.63254890e-02f, -1.20658043e-03f, -3.96797732e-02f,
  -3.55433002e-02f, 1.17484936e-02f, -5.63969128e-02f, -5.60407266e-02f, 1.61162708e-02f, 4.58780937e-02f, -5.36145568e-02f, 6.85782507e-02f, -4.88854833e-02f, -2.61472426e-02f,
  -1.22143120e-01f, -4.02828818e-03f, -4.19860706e-02f, 3.90611477e-02f, 5.49603179e-02f, -5.44703752e-02f, 2.34454498e-02f, 3.60609144e-02f, -9.47772339e-03f, 6.43083081e-03f,
  8.58127177e-02f, 2.24147774e-02f, -6.77718297e-02f, 1.32761896e-02f, -3.50512303e-02f, 1.09163122e-02f, -1.21220544e-01f, -1.61648039e-02f, -1.50307063e-02f, -1.69159789e-02f,
  -4.76567149e-02f, 7.14185387e-02f, 6.06372394e-02f, 2.51502916e-02f, -4.95103896e-02f, 2.39525847e-02f, 1.58820935e-02f, -6.61164597e-02f, 4.91249263e-02f, 8.73055588e-03f,
  -1.21265098e-01f, -5.09109981e-02f, -8.73168930e-02f, 1.65806077e-02f, 1.13421544e-01f, 9.07083377e-02f, -4.32877056e-02f, -6.56336173e-02f, 1.19937427e-01f, 8.15604776e-02f,
  1.94732531e-03f, 1.22552730e-01f, 8.02296102e-02f, 1.49009869e-01f, 1.24309890e-01f, 3.32539575e-03f, 1.76591456e-01f, 1.03969745e-01f, -3.97348627e-02f, 8.40289518e-02f,
  8.16718563e-02f, -2.62491833e-02f, -1.12512998e-01f, 5.62499426e-02f, 1.30155370e-01f, -2.04180484e-03f, -3.41577232e-02f, 1.14934165e-02f, 1.02959886e-01f, 1.02265656e-01f,
  4.37176973e-02f, -2.37485324e-03f, 8.42119753e-02f, -5.25443070e-02f, 5.50465398e-02f, -4.62622605e-02f, -6.85483143e-02f, -1.14178322e-01f, -8.28603357e-02f, -5.81694916e-02f,
  -7.60725141e-02f, 4.58680764e-02f, 3.68847325e-02f, 5.16178235e-02f, -3.73633169e-02f, -4.21367697e-02f, -2.10545920e-02f, 1.19316150e-02f, 9.27588344e-02f, 7.67201334e-02f,
  2.86544301e-02f, -9.22019780e-02f, 5.57521284e-02f, -6.74706399e-02f, -2.93818060e-02f, 1.61752570e-02f, 9.97626111e-02f, -6.77537620e-02f, 6.52377144e-04f, 2.67288759e-02f,
  1.22734800e-01f, -4.46715020e-03f, 6.45138547e-02f, 5.99150080e-04f, 1.02463000e-01f, 4.71352562e-02f, -2.20806506e-02f, -3.59553434e-02f, 6.26038983e-02f, 8.07944161e-04f,
  -3.82587425e-02f, 8.20886493e-02f, 6.32621124e-02f, 4.70644198e-02f, 3.86326686e-02f, 7.85144418e-02f, 5.05884849e-02f, 9.07772966e-03f, -6.56720102e-02f, 1.44708417e-02f,
  -1.13695808e-01f, 4.45083901e-02f, -6.28318870e-03f, 1.15446143e-01f, 2.46481132e-02f, 5.27467625e-03f, -5.05391099e-02f, 8.51499364e-02f, -4.66016755e-02f, -1.59446131e-02f,
  9.85863730e-02f, -1.06860310e-01f, 1.02834955e-01f, 4.78908271e-02f, -5.16362973e-02f, 7.69644082e-02f, -3.63386609e-02f, -4.11247537e-02f, 8.30676654e-05f, -3.35313939e-02f,
  6.42045215e-02f, 1.10145155e-02f, -3.50544341e-02f, 3.91773693e-02f, -9.38230604e-02f, 3.05448435e-02f, -4.32372987e-02f, 1.69696901e-02f, -2.35498324e-02f, -2.72734594e-02f,
  6.47780672e-02f, -2.33669188e-02f, -4.59622592e-02f, -7.58428648e-02f, -6.22659409e-03f, 1.43873081e-01f, -4.89429235e-02f, 4.96430844e-02f, 4.89645936e-02f, -3.47273871e-02f,
  1.27649773e-03f, 1.44243941e-01f, 6.84723109e-02f, -9.94839072e-02f, -7.94383213e-02f, -2.95307711e-02f, -5.00931963e-02f, -4.28816071e-03f, 5.23328483e-02f, -6.56767515e-04f,
  -9.20571163e-02f, -8.45387727e-02f, 3.65568362e-02f, 1.23871699e-01f, 2.47952417e-02f, 1.00224532e-01f, 1.15498737e-01f, 6.81681633e-02f, 7.55354716e-03f, 2.29829606e-02f,
  9.15727988e-02f, 4.09496389e-02f, 1.50498837e-01f, -2.80390121e-02f, -3.60660697e-03f, -1.74050815e-02f, 7.66017959e-02f, 1.22325607e-01f, 2.68151369e-02f, 1.09650880e-01f,
  9.83696803e-02f, -9.90686007e-03f, -3.58689539e-02f, -5.15966117e-02f, 1.20615996e-01f, -5.09775057e-02f, 6.42281622e-02f, 1.17681742e-01f, 7.68823922e-02f, -3.97760384e-02f,
  3.71680968e-02f, -2.79265866e-02f, -1.58093702e-02f, 5.56340963e-02f, -6.23325296e-02f, 2.51614098e-02f, 4.35551777e-02f, 1.04572892e-01f, 3.48633081e-02f, 4.60398905e-02f,
  7.39029348e-02f, -2.78306063e-02f, 9.32305772e-03f, -8.48737955e-02f, 4.49029030e-03f, 1.41575933e-02f, -3.78062390e-02f, 2.80268234e-03f, -3.56511809e-02f, -5.02694100e-02f,
  -5.26550561e-02f, 4.55354601e-02f, -2.18706876e-02f, -3.36870216e-02f, -9.00545716e-03f, -8.77747014e-02f, 5.28007373e-02f, -1.69465505e-02f, -3.10552735e-02f, 8.54898915e-02f,
  -6.57957867e-02f, -1.85726434e-02f, -3.78421880e-02f, -6.98846066e-04f, -4.12003435e-02f, 4.99330238e-02f, -2.60695908e-02f, -5.70281558e-02f, 2.70404071e-02f, 5.30164540e-02f,
  -2.29604822e-02f, 4.90092747e-02f, -2.55863275e-02f, 4.02496010e-02f, 4.87479977e-02f, -6.88942000e-02f, 8.47856626e-02f, -8.84942561e-02f, 7.61054382e-02f, 6.18808111e-03f,
  -9.56041813e-02f, 1.25693372e-02f, 2.88515855e-02f, -1.09805036e-02f, 4.31107394e-02f, 8.13218951e-02f, -2.02973355e-02f, -3.59466262e-02f, 6.52382001e-02f, 2.09327023e-02f,
  5.18906442e-03f, 5.31548858e-02f, -4.92772684e-02f, -1.96151603e-02f, -4.08583656e-02f, -6.39837906e-02f, 6.27233014e-02f, 2.37510782e-02f, -5.47471866e-02f, -9.24207121e-02f,
  6.17064275e-02f, -1.03034243e-01f, -1.30436227e-01f, -7.56509751e-02f, -6.24439716e-02f, -3.81634478e-03f, -1.00612663e-01f, -9.49880015e-03f, -1.47013208e-02f, -1.19982779e-01f,
  6.27290159e-02f, -1.27079366e-02f, -3.83228026e-02f, 4.82324250e-02f, -1.23792522e-01f, 2.24439520e-02f, 3.55896242e-02f, 5.45390323e-02f, 6.56151026e-02f, -6.94824457e-02f,
  -7.57788271e-02f, -1.05996430e-01f, 1.77113358e-02f, -6.72367588e-02f, 8.37787464e-02f, 5.30815087e-02f, 4.18558605e-02f, 3.27722635e-03f, 4.27190820e-03f, 3.60038355e-02f,
  -9.82946977e-02f, -3.65558900e-02f, -5.28558381e-02f, 5.13549596e-02f, 7.91367795e-03f, -3.75061445e-02f, -3.08940560e-02f, 7.35982880e-02f, -7.81368092e-02f, 8.01047534e-02f,
  -5.67405000e-02f, 1.13391012e-01f, 3.14443186e-02f, 4.64722030e-02f, -6.71897158e-02f, 7.09697530e-02f, -6.63998798e-02f, 4.93577048e-02f, -7.93683622e-03f, 7.59434700e-02f,
  -5.66105694e-02f, 4.69749719e-02f, -1.29527994e-03f, -3.23298499e-02f, -9.27158818e-02f, -1.55891795e-02f, 1.14923865e-02f, 8.68289471e-02f, -6.92242682e-02f, 6.16218522e-02f,
  -5.49386367e-02f, -5.15980646e-02f, -8.74248799e-03f, 5.23776449e-02f, -8.07587132e-02f, 4.34408225e-02f, 6.20016083e-03f, 6.38948902e-02f, -1.02602961e-02f, 1.04588725e-01f,
  5.72088473e-02f, 1.84067851e-03f, -7.31669506e-03f, 4.23798226e-02f, 1.67320427e-02f, -6.09342940e-02f, 7.12973028e-02f, 7.54813924e-02f, -7.36649260e-02f, -4.50375080e-02f,
  4.38797362e-02f, 2.50383168e-02f, 8.48225355e-02f, -4.76561114e-03f, -6.14157915e-02f, 3.72399911e-02f, -1.62219349e-02f, 4.79418933e-02f, -7.04903081e-02f, 4.58244868e-02f,
  -2.47868709e-02f, 5.46791255e-02f, 2.86870729e-02f, 1.82132870e-02f, 7.08658695e-02f, -5.40704560e-03f, -3.61345634e-02f, -8.91583487e-02f, -1.05000667e-01f, -6.21591089e-03f,
  -3.96384411e-02f, 3.70806716e-02f, -1.00701921e-01f, 5.71341291e-02f, -8.26727301e-02f, 4.79386821e-02f, 3.34748663e-02f, 2.18872484e-02f, -4.11698259e-02f, -2.55069751e-02f,
  -7.92325288e-02f, 4.79711965e-02f, -6.87186047e-02f, -3.20738554e-02f, -9.32503417e-02f, -7.50256702e-02f, -2.21744515e-02f, -1.14996533e-03f, -2.41043735e-02f, 4.67087217e-02f,
  -1.30762728e-02f, 2.80655567e-02f, -6.61314428e-02f, 2.50563845e-02f, 8.04194529e-03f, 1.81461833e-02f, 1.48366680e-02f, -1.00940555e-01f, 4.95574698e-02f, -9.15819779e-02f,
  2.21601516e-01f, -5.17916270e-02f, -1.93098024e-01f, -7.83332624e-03f, -1.54657751e-01f, -7.23696351e-02f, -2.84724478e-02f, -6.85317814e-02f, -6.78865761e-02f, -9.65005010e-02f,
  -3.90426628e-02f, 1.57674029e-02f, 9.58947539e-02f, 5.74686639e-02f, 4.11669314e-02f, 1.33540854e-03f, -8.10468569e-02f, 6.30242527e-02f, 6.33857772e-02f, -1.53856069e-01f,
  -1.35830879e-01f, -2.24122666e-02f, 7.63340890e-02f, -6.71456829e-02f, -1.50165409e-01f, -8.82704034e-02f, -1.44658655e-01f, 4.09075581e-02f, 3.95652428e-02f, -4.24237773e-02f,
  6.80428697e-03f, -5.44290803e-02f, 3.61833349e-02f, 3.76774482e-02f, -1.65718868e-02f, 5.46906218e-02f, -1.53875565e-02f, -5.76453935e-03f, 5.19780517e-02f, -6.98071122e-02f,
  -1.83995776e-02f, -5.56616746e-02f, -4.23389208e-03f, -9.21649188e-02f, 3.10638417e-02f, -8.86817873e-02f, 2.73213219e-02f, 6.00979803e-03f, -6.13649711e-02f, -3.64585295e-02f,
  2.09066626e-02f, -4.79471460e-02f, -1.07990555e-01f, -6.86879605e-02f, -9.76648703e-02f, -4.44406159e-02f, -1.48728676e-02f, -3.53565719e-03f, 1.29228318e-02f, 3.90157327e-02f,
  -9.96018350e-02f, 7.55534321e-02f, -2.20611133e-02f, 8.51380602e-02f, 2.86922902e-02f, 9.59310383e-02f, -3.38495448e-02f, 1.03649199e-01f, -6.46498427e-02f, 3.69704030e-02f,
  -2.30936781e-02f, -7.44969677e-03f, -6.20124228e-02f, -2.68221498e-02f, 1.91757269e-02f, 4.74615023e-02f, -8.22716877e-02f, 5.95921604e-03f, 1.87742300e-02f, -2.62125414e-02f,
  -2.12297626e-02f, 2.18205731e-02f, -6.52450249e-02f, -7.73478001e-02f, -1.73001904e-02f, 2.78358199e-02f, -3.28656882e-02f, 9.26551074e-02f, -7.12334067e-02f, 1.20158400e-02f,
  8.15008134e-02f, -6.85507879e-02f, -1.68760866e-02f, -3.89503911e-02f, -1.97536387e-02f, -4.91569079e-02f, -5.27635887e-02f, 7.05397502e-02f, 1.25031937e-02f, -8.28287676e-02f,
  -5.48036657e-02f, 1.71922017e-02f, 9.29821059e-02f, 1.42031051e-02f, -2.58795414e-02f, -1.12947244e-02f, 1.95890870e-02f, 8.95144343e-02f, 8.96316245e-02f, -9.81884003e-02f,
  4.76577431e-02f, 1.11916333e-01f, 1.20347319e-02f, 1.23793148e-01f, 3.83981168e-02f, 7.19171017e-02f, 6.22262806e-03f, 7.29888752e-02f, 8.54311734e-02f, 1.05480850e-01f,
  -1.03320844e-01f, 9.75726768e-02f, -1.45519711e-02f, 3.55011448e-02f, -4.72975522e-02f, -1.89550370e-02f, -4.66419272e-02f, 3.81729528e-02f, 7.81963244e-02f, 1.72860902e-02f,
  1.42695485e-02f, -7.44324103e-02f, -5.22185788e-02f, 9.98381823e-02f, -1.01482280e-01f, -1.23896770e-01f, -1.00788334e-03f, -1.38646364e-01f, -1.12752222e-01f, -6.83654845e-02f,
  -2.52218321e-02f, -1.37923092e-01f, -5.67690618e-02f, -9.98099670e-02f, -3.70146893e-02f, -2.98960209e-02f, 3.01323682e-02f, -4.55423445e-02f, 7.36333206e-02f, -1.93961821e-02f,
  1.89865917e-01f, 2.46272568e-04f, -1.00463368e-01f, -4.15975004e-02f, -1.12099107e-02f, -9.69078243e-02f, -7.53767490e-02f, -6.51545301e-02f, -1.06766960e-02f, -6.95711896e-02f,
  -3.27980239e-03f, -5.79573475e-02f, 7.14721829e-02f, 8.71114526e-03f, -3.84958722e-02f, 1.73911136e-02f, -7.13789761e-02f, 4.44158316e-02f, 2.29466893e-02f, -1.00235306e-01f,
  -7.44331628e-03f, -9.02508944e-02f, -9.26982835e-02f, -5.10941772e-03f, 8.06521177e-02f, -8.69382396e-02f, 4.11936790e-02f, 4.69309390e-02f, -4.15462889e-02f, 2.50522345e-02f,
  6.23426624e-02f, -3.13549638e-02f, -1.06489267e-02f, -1.43399974e-02f, 7.06319660e-02f, 4.79589514e-02f, 3.33396643e-02f, 9.15143937e-02f, -4.49212790e-02f, 8.68786946e-02f,
  -7.86382481e-02f, 4.00180928e-02f, 5.22778668e-02f, -4.69512977e-02f, 7.76018128e-02f, -6.42980859e-02f, -4.64107208e-02f, -4.38412912e-02f, 7.85724893e-02f, -4.35522459e-02f,
  -2.87980810e-02f, 1.79824419e-02f, 6.20537549e-02f, 4.13588732e-02f, 6.38953745e-02f, 7.86875635e-02f, -3.90500389e-02f, -5.79681173e-02f, 8.59072208e-02f, -1.20621078e-01f,
  2.06835434e-01f, -1.99275047e-01f, -4.99998368e-02f, -3.79785895e-02f, -3.64568867e-02f, 3.67853120e-02f, -2.47256011e-02f, -4.09832522e-02f, 7.09398910e-02f, -2.52050422e-02f,
  8.53097364e-02f, -2.40650196e-02f, -2.77729984e-02f, 7.25980103e-03f, 5.08891456e-02f, -1.54171903e-02f, 1.86982527e-02f, -4.67175022e-02f, 2.07857136e-02f, -2.80170254e-02f,
  6.95028380e-02f, -1.10164851e-01f, 4.17277627e-02f, 2.22303104e-02f, -1.84609108e-02f, 1.07304752e-02f, -5.06392084e-02f, 1.05377614e-01f, 3.21221836e-02f, 3.50701809e-02f,
  -1.23982824e-01f, 9.70686972e-03f, 1.24614775e-01f, -8.33694115e-02f, -9.65830907e-02f, 2.66620275e-02f, -4.91305701e-02f, -9.81910229e-02f, -5.92661463e-02f, -1.45414872e-02f,
  8.34568813e-02f, 8.05262551e-02f, -2.52585039e-02f, -7.61157051e-02f, -3.11918352e-02f, 1.09121688e-01f, 9.61049199e-02f, -2.77818739e-02f, 8.03676546e-02f, -6.10671341e-02f,
  1.66189838e-02f, -3.42590548e-02f, -7.12225437e-02f, -2.84363888e-02f, 2.60595642e-02f, 8.30422565e-02f, -5.30320965e-02f, 1.00931875e-01f, 1.13443330e-01f, 1.53982103e-01f,
  2.37811983e-01f, -7.89598078e-02f, 9.43474397e-02f, -5.30692600e-02f, 8.96522999e-02f, 5.19796647e-02f, -6.60801679e-02f, -4.70559113e-02f, -1.98908281e-02f, -4.04208549e-04f,
  8.65561217e-02f, -3.51550691e-02f, -3.03483009e-02f, 3.48536037e-02f, -4.42132279e-02f, -4.08122018e-02f, -8.33771154e-02f, 4.10666466e-02f, -1.51601909e-02f, 1.62759665e-02f,
  3.37014757e-02f, -6.86849281e-02f, 1.51650654e-02f, -1.08058721e-01f, -8.23327973e-02f, -6.25657737e-02f, -2.59287306e-03f, -9.53379727e-04f, -1.17680937e-01f, 9.85340327e-02f,
  1.79600008e-02f, -1.41716860e-02f, 2.07573995e-02f, -1.01027682e-01f, 1.99335460e-02f, 2.71937493e-02f, -8.23345408e-02f, 1.39350779e-02f, -8.82001892e-02f, -1.08859381e-02f,
  2.63422448e-02f, 1.32566309e-02f, 9.61985905e-03f, -3.75342742e-02f, -1.00938007e-01f, 5.35697527e-02f, -3.05347927e-02f, -5.18309511e-02f, -2.99139470e-02f, 9.15622804e-03f,
  -7.92858452e-02f, -5.37245534e-02f, 3.02145984e-02f, 5.95333464e-02f, -1.21421523e-01f, 1.14067094e-02f, -5.78900650e-02f, -1.11024052e-01f, 1.72777046e-02f, -2.69709108e-03f,
  1.28866866e-01f, -1.26148283e-01f, 1.17712818e-01f, 1.43445849e-01f, 2.92377602e-02f, -1.67238191e-02f, -1.36527847e-02f, -7.62460381e-02f, 6.19154656e-04f, 7.75288790e-02f,
  7.26070777e-02f, -6.80829361e-02f, 3.27386707e-02f, 8.48679096e-02f, -1.15656322e-02f, 1.52028697e-02f, 8.84293392e-02f, -5.45803532e-02f, -5.74926212e-02f, 3.77388895e-02f,
  -2.13190541e-02f, 3.42820026e-02f, 8.96275192e-02f, -2.25504227e-02f, -6.93787709e-02f, -3.63378339e-02f, 1.20814368e-01f, 3.47400755e-02f, 7.04957619e-02f, 1.52978953e-02f,
  2.98970461e-01f, -1.30487263e-01f, -1.57174766e-01f, -3.66664380e-02f, 1.35557037e-02f, 5.15980087e-02f, -1.38711154e-01f, -5.69174029e-02f, -1.39181251e-02f, -1.33268520e-01f,
  -9.45415571e-02f, 6.78618550e-02f, 1.74008065e-03f, 6.28579259e-02f, -1.66571680e-02f, 3.29418816e-02f, 3.21436487e-02f, 5.54327369e-02f, 1.24004126e-01f, 4.87820432e-02f,
  -5.52263297e-02f, -1.53458053e-02f, 4.36290875e-02f, 1.70287918e-02f, -1.23887248e-01f, -8.94359574e-02f, -1.04003526e-01f, -7.05045834e-02f, -5.67069054e-02f, -5.59327193e-02f,
  -1.68062169e-02f, 9.60411131e-02f, 6.20641448e-02f, 4.76226248e-02f, 3.64238620e-02f, 5.31110279e-02f, 7.13648349e-02f, -3.13900858e-02f, -6.28804341e-02f, 5.13736419e-02f,
  -3.49025093e-02f, -9.61815491e-02f, -4.37156595e-02f, 4.74070124e-02f, -5.15293553e-02f, 8.46450627e-02f, 2.15216931e-02f, -4.07706387e-02f, -8.74600038e-02f, -3.59095982e-03f,
  -1.24246858e-01f, 6.89869896e-02f, 5.44901863e-02f, 1.56944562e-02f, 7.14735091e-02f, 6.32557133e-03f, 1.52351605e-02f, -5.38724624e-02f, 4.68640737e-02f, -4.20191549e-02f,
  -1.58435740e-02f, -3.66365165e-02f, 1.02051226e-02f, -1.58058908e-02f, 8.46532285e-02f, 8.08161497e-03f, 1.42770745e-02f, 2.52665821e-02f, 8.14854284e-04f, 2.13983618e-02f,
  -9.30230657e-04f, 4.99073882e-04f, -1.60805676e-02f, 1.10121660e-01f, -5.17508090e-02f, -1.16489619e-01f, 5.00882305e-02f, 6.43737465e-02f, -4.71743867e-02f, -2.94564776e-02f,
  -9.98835564e-02f, -5.62070683e-02f, -7.50264153e-02f, -7.28374496e-02f, 5.79785183e-02f, -5.32900123e-03f, 7.62081519e-02f, 2.73450091e-02f, -3.21262442e-02f, -6.14591166e-02f,
  2.87279207e-02f, 5.30804731e-02f, 5.69941103e-02f, 4.27157730e-02f, 2.43137428e-03f, -5.04987082e-03f, 4.90129218e-02f, -7.29764849e-02f, 8.42086002e-02f, -3.96308005e-02f,
  -4.87178117e-02f, -5.41731678e-02f, -3.87288630e-02f, -4.50324267e-02f, 1.25075430e-01f, 3.39441351e-03f, -1.07157819e-01f, 7.66413584e-02f, 2.14929320e-02f, -1.25258550e-01f,
  -9.50646326e-02f, 6.06209747e-02f, 6.66004941e-02f, 7.22531304e-02f, 5.59455249e-03f, 1.34385318e-01f, 2.66606417e-02f, -6.42447025e-02f, -4.98327008e-03f, 6.73104748e-02f,
  1.61758468e-01f, -9.94801745e-02f, -2.14277878e-02f, 2.68942695e-02f, -7.81100914e-02f, -6.42872378e-02f, -9.92318839e-02f, -3.54978925e-04f, 2.39284383e-03f, -7.08589703e-02f,
  1.11865541e-02f, 3.27502824e-02f, 9.09104049e-02f, 1.13290071e-01f, 8.05636048e-02f, -3.15150991e-02f, 1.79256964e-02f, 3.65399607e-02f, 1.14042774e-01f, -2.79547516e-02f,
  -3.38725373e-02f, -2.32832134e-02f, 1.67379212e-02f, 6.78171813e-02f, -5.00991680e-02f, 1.49437590e-02f, -6.65668994e-02f, 4.77109440e-02f, -6.82686120e-02f, -6.24133535e-02f,
  -3.34759131e-02f, 7.82658160e-02f, 5.70427924e-02f, 1.28699541e-01f, -3.25142369e-02f, 7.89224505e-02f, 7.45207295e-02f, -1.14972787e-02f, -1.14358580e-02f, 7.27336947e-03f,
  -2.24593859e-02f, 8.75829533e-03f, 7.77860880e-02f, -3.67287360e-02f, -6.68705702e-02f, -5.22125736e-02f, 2.34472379e-03f, -5.34563549e-02f, 3.14196497e-02f, -5.89122921e-02f,
  2.62509976e-02f, -4.25617956e-02f, -2.51559746e-02f, -2.00788733e-02f, -3.16575468e-02f, 9.83812660e-02f, 6.86026588e-02f, 2.86922343e-02f, 1.06701173e-03f, 5.95698431e-02f,
  -3.63038629e-02f, -8.38294923e-02f, -2.36389861e-02f, 5.20292968e-02f, -2.41402369e-02f, -5.17119479e-04f, 1.11657307e-01f, 2.55364794e-02f, -2.30813934e-03f, -8.47164989e-02f,
  -1.31947938e-02f, 2.36904360e-02f, 3.46569270e-02f, -5.84604032e-02f, 2.53044516e-02f, -1.08694006e-02f, 4.82758470e-02f, -8.53814855e-02f, 1.15216479e-01f, 7.28861317e-02f,
  -1.94610991e-02f, -7.28772655e-02f, 7.89565742e-02f, 8.07190835e-02f, 1.25736391e-04f, 9.77910683e-02f, -5.88902645e-02f, -5.54260388e-02f, -2.86271721e-02f, 6.71553984e-02f,
  -1.00433148e-01f, 9.73429978e-02f, 6.10818416e-02f, -9.91544649e-02f, -7.82101601e-02f, -9.75487009e-02f, -8.71090367e-02f, -2.11337022e-02f, -1.32858958e-02f, 4.97271866e-02f,
  -7.34872147e-02f, -6.88550696e-02f, 1.72160461e-03f, 3.59489135e-02f, 2.94841342e-02f, 8.12937021e-02f, 4.40867953e-02f, 9.98756811e-02f, 1.85983442e-02f, -8.47254395e-02f,
  -7.53856972e-02f, 5.68835996e-02f, 5.99541813e-02f, 1.46137457e-02f, 3.69815268e-02f, 8.74609500e-03f, -7.52951484e-03f, -4.38394360e-02f, 1.48264930e-01f, -6.74746558e-02f,
  2.58929908e-01f, -1.87746547e-02f, -5.90971559e-02f, -5.64586148e-02f, 5.06327562e-02f, 3.14104743e-02f, -7.24804401e-02f, -3.46482433e-02f, -8.08140114e-02f, -1.06064439e-01f,
  2.88184732e-02f, 1.25383409e-02f, -3.44189033e-02f, -7.05347136e-02f, 8.93718228e-02f, 3.68033051e-02f, -6.75143674e-02f, 1.17964737e-01f, 1.49028912e-01f, -2.53575072e-02f,
  -1.28022581e-01f, 8.08421373e-02f, -2.64130551e-02f, 1.44425267e-02f, -2.26496030e-02f, -1.53956898e-02f, -9.17405859e-02f, 3.11265811e-02f, 5.92410602e-02f, 6.93388982e-03f,
  -8.38641524e-02f, 9.77545008e-02f, -3.76815237e-02f, -7.24529428e-03f, -2.31429953e-02f, -4.35702689e-02f, 7.64261633e-02f, 3.47453319e-02f, -3.76409665e-02f, -4.73365635e-02f,
  1.21563906e-02f, 5.10225892e-02f, -6.85560256e-02f, -8.29707831e-02f, -4.40099835e-02f, 7.88694024e-02f, 9.07283127e-02f, 1.45594180e-01f, 1.17509641e-01f, 3.83648500e-02f,
  -8.28978196e-02f, 4.07259800e-02f, 6.11965507e-02f, 5.65194674e-02f, 5.10786772e-02f, -2.71438644e-03f, -6.47007823e-02f, 3.60660702e-02f, 8.02539214e-02f, 3.31424586e-02f,
  2.82514049e-03f, -4.60832641e-02f, 6.24239296e-02f, -5.37665151e-02f, 4.50952202e-02f, -2.15943065e-02f, 2.72567496e-02f, -5.18561229e-02f, -5.66816330e-02f, 2.33923662e-02f,
  1.55835329e-02f, -3.39435227e-02f, -6.25565499e-02f, -5.58642186e-02f, -7.10288808e-02f, 1.37390429e-02f, 7.41643086e-02f, -6.73793778e-02f, 8.33646432e-02f, -4.90057096e-02f,
  1.03508048e-01f, 8.04998353e-02f, 2.66132969e-02f, 6.00024201e-02f, -9.12372116e-03f, 9.87155661e-02f, 1.86115336e-02f, -5.76966405e-02f, 4.92260903e-02f, 7.72817060e-02f,
  -1.19553126e-01f, 7.85001889e-02f, -6.38332516e-02f, 3.15228500e-03f, -1.97467096e-02f, 2.39323489e-02f, -1.20089188e-01f, -3.55729610e-02f, 3.98173183e-02f, -4.39046212e-02f,
  -5.95519468e-02f, 6.29622862e-02f, 8.17557275e-02f, 8.63149986e-02f, -2.47976091e-02f, 6.58989102e-02f, -9.23656486e-03f, -1.80449411e-02f, 7.39342049e-02f, -5.49515858e-02f,
  -1.14860490e-01f, -6.14811257e-02f, 1.29214436e-01f, -1.38980504e-02f, -1.13058984e-02f, 8.75772610e-02f, -6.16233144e-03f, 5.52086681e-02f, 6.05526045e-02f, -4.85810898e-02f,
  -3.65465619e-02f, -4.30208072e-02f, -6.21931776e-02f, 1.27612753e-03f, -1.33106932e-01f, -9.39229354e-02f, -5.27362451e-02f, 2.91753337e-02f, -7.67682539e-03f, 1.96826793e-02f,
  -3.61285172e-02f, 2.44193114e-02f, -4.54841033e-02f, -8.00244957e-02f, -5.33620901e-02f, -5.76747730e-02f, -1.25586763e-01f, -7.70204440e-02f, -6.43447861e-02f, -7.31216893e-02f,
  -4.50273566e-02f, -8.12753588e-02f, -2.96205934e-03f, -5.15631475e-02f, -4.14157398e-02f, 1.93446651e-02f, -5.41619845e-02f, 4.64186184e-02f, -7.45163336e-02f, -1.31365046e-01f,
  -6.48399591e-02f, 4.38034385e-02f, -1.28070265e-02f, 5.62915439e-03f, 7.70164058e-02f, 6.54957518e-02f, 1.25070894e-02f, 5.19470312e-02f, 7.71222636e-02f, -6.54950738e-02f,
  5.08006811e-02f, 8.01399946e-02f, 1.04368508e-01f, -4.74739894e-02f, -9.50893313e-02f, 7.61119574e-02f, 3.42748277e-02f, 7.97014758e-02f, 1.99354421e-02f, 7.63556436e-02f,
  -2.30643377e-02f, -5.62544651e-02f, -2.81905234e-02f, -7.02027902e-02f, -3.36254458e-03f, 5.70597537e-02f, -5.18893972e-02f, 9.39385742e-02f, 7.60465488e-02f, 2.09359918e-02f,
  -9.58514661e-02f, -3.18063647e-02f, -7.98790157e-02f, 8.46545398e-02f, 4.25588377e-02f, -8.53899959e-03f, 2.15971619e-02f, 1.05152845e-01f, -2.09291149e-02f, -8.67760405e-02f,
  -1.56039950e-02f, -1.05605945e-02f, 5.31308390e-02f, -1.98581219e-02f, -8.93734843e-02f, 1.79414079e-02f, 4.61891778e-02f, -3.11995856e-02f, 6.92650229e-02f, -3.08340546e-02f,
  7.25486502e-02f, -2.15171166e-02f, -4.91034314e-02f, 5.71398027e-02f, -8.84070396e-02f, -7.40215555e-02f, -8.24954286e-02f, -6.30398840e-03f, 7.41645768e-02f, 1.58214793e-02f,
  -1.05253868e-02f, -1.21794723e-01f, -8.91875476e-02f, 5.92562035e-02f, -8.11555237e-02f, -3.23455743e-02f, 2.45112125e-02f, 4.49621156e-02f, -1.27134314e-02f, 2.50532962e-02f,
  -7.08463266e-02f, 3.24900225e-02f, -2.67593842e-02f, -3.48722562e-02f, 6.84895087e-03f, -8.38897377e-02f, 5.88007644e-02f, -5.29245734e-02f, -2.29616854e-02f, -6.69845864e-02f,
  2.33387854e-02f, -1.01741970e-01f, 3.62521765e-04f, -4.25273143e-02f, -1.00603187e-02f, -4.66573723e-02f, 7.63341831e-03f, 1.30984560e-02f, 1.90571696e-02f, 4.86869067e-02f,
  1.01685338e-02f, -1.14982940e-01f, -4.24803905e-02f, -1.71732306e-02f, -1.06817093e-02f, 2.08666106e-03f, 6.76656365e-02f, -3.54679897e-02f, 3.15406593e-03f, 4.66510542e-02f,
  7.99586251e-02f, 7.38498718e-02f, 6.29975274e-02f, -3.25755030e-02f, 5.93284406e-02f, 4.77010608e-02f, 9.47145224e-02f, 9.38285589e-02f, 3.90974358e-02f, 5.39372908e-04f,
  4.18623677e-04f, 8.23798776e-03f, 4.03005455e-04f, 3.54260094e-02f, -1.13856360e-01f, -8.74069184e-02f, -6.52019009e-02f, 7.61534879e-03f, 3.71833295e-02f, -1.00690112e-01f,
  8.74959156e-02f, 2.19483189e-02f, 5.84403202e-02f, 3.09944022e-02f, 1.50950952e-02f, -7.47410059e-02f, 3.06737963e-02f, -5.10187484e-02f, 1.93011183e-02f, 2.44478602e-03f,
  -2.15442330e-02f, 6.80752972e-04f, -1.08579114e-01f, 1.81400049e-02f, -1.04372136e-01f, -3.33089232e-02f, 1.56265462e-03f, 8.34930092e-02f, -4.01390232e-02f, -2.91678775e-02f,
  -4.03947569e-02f, 5.68799069e-03f, 2.16216091e-02f, -5.85466512e-02f, -1.05914837e-02f, 1.19429961e-01f, 5.81593253e-02f, 4.23957705e-02f, -4.32043709e-03f, -8.31837803e-02f,
  9.03084278e-02f, 7.98555277e-03f, 6.43097386e-02f, -5.46968207e-02f, 6.42161891e-02f, -7.02400208e-02f, 8.20439830e-02f, -3.65401432e-02f, -3.01256068e-02f, -1.23775806e-02f,
  -6.58710778e-04f, -4.25942987e-02f, -4.14282940e-02f, -4.50387634e-02f, 4.35951948e-02f, -2.87078433e-02f, -2.58092699e-03f, 4.68038954e-02f, 7.72392973e-02f, -5.67675568e-02f,
  -5.50740846e-02f, -8.56824778e-03f, -4.00875956e-02f, 6.38039261e-02f, -3.46847288e-02f, 8.07566475e-03f, -4.79746237e-02f, -7.03227147e-02f, 7.49916285e-02f, -3.35849561e-02f,
  2.95840278e-02f, 1.51393875e-01f, 8.81208405e-02f, -2.11763643e-02f, -2.96428264e-03f, -3.84521820e-02f, -4.36571660e-03f, -1.14062391e-01f, 6.93753362e-02f, 6.02063835e-02f,
  6.04132935e-03f, -5.46057671e-02f, 3.91448140e-02f, -1.11835405e-01f, -2.73576789e-02f, -7.65755028e-02f, 2.40910426e-03f, 5.63980564e-02f, -6.74151406e-02f, -9.02280062e-02f,
  -5.42363264e-02f, 8.96778256e-02f, 3.10656670e-02f, -4.22675274e-02f, 1.14412203e-01f, 7.92757645e-02f, 1.28192618e-01f, 7.82921631e-03f, 1.17035143e-01f, -3.50250187e-03f,
  1.33968845e-01f, -9.71232802e-02f, -1.39319763e-01f, 7.64794126e-02f, -5.83849736e-02f, 2.70476216e-03f, -4.97504920e-02f, 8.25641081e-02f, -2.64465716e-02f, 2.84953862e-02f,
  1.62032638e-02f, -2.63371300e-02f, -2.09284872e-02f, -3.95082161e-02f, 3.07645393e-03f, -7.48909637e-02f, 3.25210392e-02f, 2.48391125e-02f, -1.42544331e-02f, 8.70738178e-02f,
  3.70170400e-02f, -5.45236990e-02f, 5.02159148e-02f, 9.44508016e-02f, 2.80425251e-02f, 5.08852601e-02f, 1.05768896e-03f, -1.17944576e-01f, 1.46043282e-02f, -3.95112075e-02f,
  1.51456660e-02f, -3.77128758e-02f, 5.17506413e-02f, -6.14533499e-02f, -4.69498476e-03f, -8.42666402e-02f, 8.06105509e-02f, -4.17924002e-02f, -4.00362238e-02f, 5.17045297e-02f,
  -1.29969502e-02f, 3.08748204e-02f, 2.88676415e-02f, -8.30465406e-02f, -9.08235535e-02f, -3.06052389e-03f, -1.08594798e-01f, -3.95505391e-02f, 3.99844814e-03f, 8.92103557e-03f,
  -1.06231175e-01f, -7.88814053e-02f, -2.17737304e-03f, 6.40325844e-02f, -4.16464135e-02f, -3.54193896e-02f, 1.29384864e-02f, 8.72760415e-02f, 9.85493734e-02f, -6.79898262e-02f,
  -2.86208969e-02f, 1.22263841e-01f, 1.06990002e-01f, -9.61282477e-02f, -1.65161993e-02f, -1.04555018e-01f, -6.67740256e-02f, -6.53628856e-02f, 5.64840948e-03f, 6.96057901e-02f,
  7.92600214e-02f, -5.04825935e-02f, -3.08892317e-02f, -1.21694682e-02f, 1.04501918e-01f, 1.82640692e-03f, 7.28087276e-02f, 4.43925001e-02f, -4.67082225e-02f, 4.47757319e-02f,
  1.83547419e-02f, -1.49210300e-02f, 4.86649908e-02f, -2.03125104e-02f, 2.66209394e-02f, -6.15043491e-02f, -3.83272208e-02f, 2.60843001e-02f, -1.30444551e-02f, 2.74276137e-02f,
  8.97154287e-02f, 1.72316387e-01f, 1.14110775e-01f, 8.64713416e-02f, -2.28486173e-02f, 2.05116868e-02f, 6.92075044e-02f, -4.02315743e-02f, -8.94366726e-02f, 3.81908529e-02f,
  -8.09965208e-02f, -7.24237487e-02f, -1.41961901e-02f, 5.63944131e-02f, 3.35509926e-02f, -9.70066059e-03f, -1.04456447e-01f, -4.11015749e-02f, 9.66581143e-03f, -4.41440418e-02f,
  3.33304554e-02f, 3.05422917e-02f, 2.23747641e-02f, -5.28315827e-02f, 6.14117272e-02f, 3.56474370e-02f, 1.20762065e-01f, -6.22273646e-02f, 2.72392984e-02f, -4.21997011e-02f,
  9.04258266e-02f, -9.26928222e-02f, -1.70864895e-01f, 4.54814471e-02f, -9.76246782e-03f, 7.15744719e-02f, 9.39493626e-02f, -2.00836323e-02f, 8.48457068e-02f, -3.96161079e-02f,
  -1.63373165e-02f, 6.40872717e-02f, 1.41575262e-01f, 1.43338457e-01f, 1.06910005e-01f, 5.73403314e-02f, -3.49797495e-02f, 2.13207081e-02f, 1.18404806e-01f, -9.73652583e-03f,
  4.38615978e-02f, 2.68083904e-02f, -6.49109334e-02f, 3.99713702e-02f, 6.24693173e-04f, 6.24309592e-02f, -9.09205452e-02f, -1.09170966e-01f, 2.59258766e-02f, -1.87442731e-02f,
  -1.37239997e-03f, -4.53804433e-02f, 3.50971594e-02f, 1.04854301e-01f, -2.87787169e-02f, -9.57295746e-02f, 4.96889837e-02f, -1.10272191e-01f, -3.81499678e-02f, 1.44837070e-02f,
  -1.03553757e-02f, -6.98975325e-02f, 4.17955928e-02f, -9.89795476e-02f, 3.56252454e-02f, -5.96056134e-02f, 5.75218871e-02f, 2.58158967e-02f, -4.84716929e-02f, -8.57064575e-02f,
  6.20113350e-02f, -5.12240604e-02f, -1.07222699e-01f, 7.12331608e-02f, -6.56979010e-02f, -3.54414321e-02f, 3.29353251e-02f, -1.07367873e-01f, -7.86542147e-02f, 4.52121050e-04f,
  1.66336894e-02f, -2.51604170e-02f, -1.06442034e-01f, 3.44618200e-03f, 8.64303187e-02f, -6.64267614e-02f, -2.15018410e-02f, 7.76743097e-03f, -7.07105696e-02f, 5.57539538e-02f,
  1.26008773e-02f, 2.46661506e-03f, 5.85538670e-02f, 3.89018431e-02f, -1.53095955e-02f, -6.45744130e-02f, 9.57669597e-03f, -1.04172796e-01f, 5.76146394e-02f, 1.12450728e-02f,
  2.90647782e-02f, -4.45215032e-02f, -4.02687564e-02f, 6.40016794e-02f, 2.94067319e-02f, -3.37689184e-02f, -2.30674911e-02f, -4.74782847e-03f, 3.47222725e-04f, -7.76322260e-02f,
  -7.07623437e-02f, 1.10154256e-01f, 5.31385168e-02f, 7.58992136e-02f, -1.33769857e-02f, 6.10203408e-02f, 2.45567448e-02f, -4.22717147e-02f, -5.02324253e-02f, -6.94585145e-02f,
  -7.45461807e-02f, -2.48411689e-02f, 3.76617685e-02f, 1.39982132e-02f, 9.14920196e-02f, -5.07634841e-02f, -7.27326646e-02f, 2.41010878e-02f, -4.85463999e-02f, -3.17396931e-02f,
  -7.35453591e-02f, 3.26494798e-02f, 7.63407722e-02f, -4.19331081e-02f, -7.34762326e-02f, 5.27511910e-02f, 4.73435633e-02f, -5.47960363e-02f, -5.05585223e-02f, -4.67048697e-02f,
  -7.87042230e-02f, 3.72644584e-03f, 1.10741854e-01f, -7.55195916e-02f, -1.08579457e-01f, -1.04309693e-02f, 4.76905890e-02f, 3.01557165e-02f, -5.02404198e-02f, -7.56681189e-02f,
  -1.69544630e-02f, -5.54948896e-02f, -4.00046632e-02f, 2.26696134e-02f, 1.18948758e-01f, 8.42350721e-02f, 7.27535486e-02f, 1.96657684e-02f, 6.42066523e-02f, 1.17131263e-01f,
  -2.77558751e-02f, 1.51852639e-02f, 1.12989068e-01f, 8.73201489e-02f, -2.20682211e-02f, 5.60327480e-03f, 1.91123355e-02f, -3.70903611e-02f, 9.90186036e-02f, 1.02685049e-01f,
  1.79430604e-01f, 8.24304298e-03f, -7.40425428e-03f, -1.02514170e-01f, -7.12794885e-02f, 6.44665351e-03f, 1.13551877e-01f, 5.35297766e-02f, 4.30947654e-02f, 1.38219997e-01f,
  5.85914105e-02f, 1.26043791e-02f, -2.98552793e-02f, 8.57555568e-02f, -6.17172495e-02f, 5.93453087e-02f, 5.12106232e-02f, -1.55526530e-02f, -1.52801145e-02f, -3.24562714e-02f,
  -6.62527978e-02f, -7.27366805e-02f, 1.63483818e-03f, 7.77368322e-02f, -6.32679090e-02f, -2.53213162e-04f, -8.14099424e-03f, 9.87191051e-02f, -6.80126846e-02f, 2.38066982e-03f,
  1.82281751e-02f, 8.09036102e-03f, 7.14398548e-02f, -9.91452485e-02f, -8.33175797e-03f, -5.95648326e-02f, -3.42684984e-02f, -4.51642722e-02f, -7.10962340e-03f, -8.62264931e-02f,
  -1.03293926e-01f, -7.68431947e-02f, 9.81239602e-02f, -2.12338790e-02f, 6.11774027e-02f, -3.48970294e-02f, -6.39898586e-04f, 1.91205386e-02f, 5.94530161e-03f, 1.18940212e-02f,
  -1.01820424e-01f, -1.19593423e-02f, 2.52989754e-02f, 1.34842913e-03f, -5.21632023e-02f, 4.12631109e-02f, 1.11835636e-02f, 1.15227532e-02f, 6.84825927e-02f, 2.79941922e-03f,
  7.11943284e-02f, -9.00003687e-02f, 5.00216223e-02f, -4.71461155e-02f, -7.63406754e-02f, -1.18653877e-02f, -6.23927638e-03f, -7.63956457e-02f, -6.75511453e-03f, -4.75266390e-02f,
  4.86946702e-02f, 1.62452571e-02f, 2.73919236e-02f, 4.81153540e-02f, 6.46175966e-02f, -5.81567525e-04f, 1.79913994e-02f, -8.56320187e-02f, 8.98806006e-02f, 5.93892336e-02f,
  -4.58569638e-02f, 4.38061990e-02f, -7.85970613e-02f, -8.01717266e-02f, -9.39499140e-02f, 9.56244115e-03f, -4.59255464e-02f, -5.59726395e-02f, -6.08257391e-02f, 1.00341626e-01f,
  7.84940049e-02f, -9.18094888e-02f, -5.96524987e-05f, 4.46107462e-02f, -1.74673647e-03f, -7.19894306e-04f, -1.31273851e-01f, -7.52513185e-02f, -8.88895541e-02f, -7.08314544e-03f,
  -7.99068063e-02f, -3.48513909e-02f, -3.12541798e-02f, -6.59592301e-02f, -4.53553908e-02f, -1.47089094e-01f, -1.05960332e-01f, 1.47351390e-03f, -5.35235666e-02f, -7.67296106e-02f,
  5.10965362e-02f, 1.36818029e-02f, -6.55559078e-02f, -4.35697623e-02f, 2.80979574e-02f, -2.41203122e-02f, -2.37675500e-03f, 9.45490524e-02f, 9.27504525e-02f, 8.91323164e-02f,
  3.12127899e-02f, 1.90195777e-02f, 3.20362253e-03f, 1.14850909e-01f, -3.54882865e-03f, 8.68581384e-02f, 1.29087633e-02f, -5.96824661e-02f, 9.47721004e-02f, -1.13765039e-02f,
  3.66603769e-02f, -8.02214593e-02f, 1.39992582e-02f, 8.69088918e-02f, 5.56399226e-02f, -5.78928962e-02f, 7.44246691e-02f, -5.21196984e-02f, -3.22402380e-02f, -9.78054181e-02f,
  6.42009899e-02f, -2.85701803e-03f, 7.90785924e-02f, 1.06675856e-01f, 5.92720956e-02f, 8.51475671e-02f, 4.07160819e-02f, 7.98235461e-02f, 2.22188849e-02f, 2.83399355e-02f,
  -9.33808014e-02f, -1.91561207e-02f, 2.60124709e-02f, -2.46829130e-02f, -5.07693477e-02f, -1.31769078e-02f, -5.40481396e-02f, 4.13790643e-02f, -7.33621791e-02f, -8.58727768e-02f,
  -9.35316682e-02f, -4.80356999e-02f, 8.58393013e-02f, -9.72850397e-02f, -2.53603719e-02f, 1.62244104e-02f, -8.83295685e-02f, 1.55364331e-02f, -8.34377930e-02f, 3.44965830e-02f,
  2.33924128e-02f, 6.22062199e-02f, -9.56834406e-02f, 4.80097681e-02f, -4.98004369e-02f, 6.94700405e-02f, 2.30426472e-02f, 3.39216590e-02f, -4.89193127e-02f, 1.58133507e-02f,
  3.25349532e-02f, 4.58134189e-02f, 5.61320260e-02f, -3.61972898e-02f, 2.69465689e-02f, -4.34251092e-02f, -8.61058012e-03f, 7.73257390e-02f, -2.59148944e-02f, 3.03478166e-02f,
  6.89726770e-02f, -1.17349140e-02f, 4.24627960e-03f, -1.06659709e-02f, -2.57027824e-03f, -6.63926527e-02f, -6.83725029e-02f, -2.27884203e-02f, 1.50649557e-02f, -7.24544749e-02f,
  3.34194787e-02f, -6.23673536e-02f, 3.79022467e-03f, 9.67865661e-02f, 1.58116613e-02f, 1.23290464e-01f, -5.67781515e-02f, -3.75258084e-03f, 4.45437357e-02f, -2.59166099e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  7.87431076e-02f, 4.15497161e-02f, -4.49370891e-02f, 8.43188688e-02f, -6.11976385e-02f, 8.49507749e-02f, 4.06871289e-02f, 3.36258821e-02f, 9.62327141e-03f, 2.24214286e-01f,
  1.50843123e-02f, 7.89624900e-02f, -3.61700244e-02f, 7.59216473e-02f, 1.30726740e-01f, -8.07134062e-03f, -6.91165105e-02f, 7.34324902e-02f, 5.68811931e-02f, 1.42674461e-01f,
  1.40748369e-02f, -3.44997384e-02f, -1.91783216e-02f, 2.14749668e-02f, -5.15282759e-03f, -6.60894364e-02f, -1.31678889e-02f, 2.72289626e-02f, 1.11875392e-01f, -6.37031198e-02f,
  8.94521400e-02f, 9.81513262e-02f, 3.70400702e-03f, 1.20706044e-01f, 7.84962922e-02f, 1.25915989e-01f, -1.18387258e-02f, -1.13805067e-02f, 3.49482708e-02f, 4.60204817e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.02860956e-02f, -5.93962660e-03f, 1.55382808e-02f, -9.38541815e-02f, 4.76236418e-02f, -4.23819534e-02f, 3.98754291e-02f, -2.08255768e-01f, -1.22693017e-01f, -2.32164990e-02f,
  -1.78869888e-01f, -2.56397128e-01f, -2.19575372e-02f, -8.01921412e-02f, 6.49215877e-02f, 1.33120537e-01f, 2.95067523e-02f, -2.02861249e-01f, -6.44273907e-02f, -1.54194474e-01f,
  9.34541300e-02f, -7.36265481e-02f, 9.54926088e-02f, -1.31082043e-01f, -7.42247850e-02f, 1.87267616e-01f, -2.46807095e-02f, 1.11914478e-01f, 8.38867724e-02f, 1.13616481e-01f,
  -2.85574161e-02f, 1.33203223e-01f, 9.98258367e-02f, 9.94943380e-02f, 1.31519958e-01f, 2.25088894e-02f, -1.21907271e-01f, 1.76650882e-02f, 2.19770502e-02f, -2.03994773e-02f,
  6.77167252e-02f, -3.16881500e-02f, -2.64758021e-01f, 1.13593467e-01f, 7.53965974e-02f, -1.36669338e-01f, 1.42274261e-01f, -1.00718774e-01f, 4.54028659e-02f, -2.96969470e-02f,
  -3.15207802e-02f, -7.18713999e-02f, -1.47257730e-01f, 5.42718321e-02f, -7.27583990e-02f, -5.64491712e-02f, -1.01297975e-01f, 1.18847052e-02f, 3.41138840e-02f, -7.81887174e-02f,
  5.55004328e-02f, -1.29826833e-02f, 1.22632697e-01f, -1.06141821e-01f, 4.07515354e-02f, -5.31653874e-02f, 1.60158083e-01f, 6.88587874e-02f, -1.71102688e-01f, -7.70200267e-02f,
  -1.07731611e-01f, -1.22239389e-01f, -6.33731410e-02f, 6.21823519e-02f, 4.22116518e-02f, -1.06359698e-01f, 7.73618892e-02f, -7.84066990e-02f, 1.78010777e-01f, -1.42703727e-01f,
  2.56473541e-01f, 1.64434254e-01f, 5.91002777e-02f, -1.74311996e-01f, 1.93872079e-01f, 4.77621555e-02f, -1.41828358e-01f, -1.78960264e-02f, -4.57430333e-02f, 7.37023950e-02f,
  -3.67446779e-03f, -1.27681017e-01f, -1.80872232e-02f, -6.13075532e-02f, -9.21387151e-02f, 1.15576595e-01f, 8.14374536e-02f, -2.95301192e-02f, 1.96200266e-01f, 3.09229475e-02f,
  1.64833590e-01f, 1.01431407e-01f, -1.45522803e-01f, -9.26343426e-02f, -1.89440206e-01f, -6.92311153e-02f, -2.62281466e-02f, -7.97229111e-02f, -1.39641255e-01f, -1.58511192e-01f,
  2.71329843e-02f, 9.45579540e-03f, 5.94146922e-02f, 4.39859405e-02f, -1.40605181e-01f, 1.01583555e-01f, -1.44924885e-02f, 1.28566727e-01f, 1.24235414e-01f, -3.73181254e-02f,
  9.84390974e-02f, -8.95179287e-02f, 3.42325158e-02f, 1.44952834e-01f, 1.16746448e-01f, 9.37529095e-03f, 1.35164469e-01f, 5.79998717e-02f, 6.89491406e-02f, -8.10643062e-02f,
  -6.98072985e-02f, 4.28975187e-02f, 2.28101060e-01f, 9.25046206e-02f, -1.14582375e-01f, -1.15940697e-01f, -1.72543302e-01f, 1.05246551e-01f, -8.52185562e-02f, -7.11460188e-02f,
  6.58534691e-02f, -5.18603288e-02f, -2.35237226e-01f, -4.95073088e-02f, -2.03300774e-01f, -1.97046205e-01f, -3.77673879e-02f, 8.76091048e-02f, 1.55321583e-01f, -1.39650673e-01f,
  -1.15801385e-02f, -2.10945830e-01f, 9.17035341e-02f, 1.63071454e-01f, 1.65795431e-01f, 8.40647221e-02f, 1.05877928e-01f, 1.34357780e-01f, 1.78534806e-01f, 2.68386062e-02f,
  1.05635859e-01f, 1.27184749e-01f, 1.99838981e-01f, 1.36517012e-03f, -6.07847609e-02f, -1.24990776e-01f, -9.13968235e-02f, -6.89334869e-02f, 1.91935167e-01f, -1.55500174e-01f,
  6.24639466e-02f, 1.57307386e-01f, -2.23115552e-02f, 9.47235674e-02f, 2.59915553e-02f, 4.02049571e-02f, 1.41305346e-02f, 9.73954424e-02f, 5.87541014e-02f, 7.17154741e-02f,
  -1.61547914e-01f, -2.02860430e-01f, -1.14787102e-01f, -4.85043824e-02f, 1.62389085e-01f, 4.28069197e-02f, -1.09922281e-02f, -8.55306908e-02f, -1.11641139e-02f, 6.83579743e-02f,
  -5.19842468e-02f, 1.39866427e-01f, -6.30946606e-02f, 2.66015548e-02f, -1.55370766e-02f, -3.69515046e-02f, 1.85229644e-01f, 1.57608557e-02f, -1.72091858e-03f, 8.46433043e-02f,
  1.12593018e-01f, -8.60922188e-02f, -1.02516310e-02f, 8.34959522e-02f, 9.02031511e-02f, 1.08046406e-04f, -1.77816704e-01f, -1.80843100e-01f, -2.54577667e-01f, 7.31860697e-02f,
  3.00921686e-02f, -8.67981836e-02f, 1.70457050e-01f, -9.73233283e-02f, -5.13807051e-02f, -1.00869695e-02f, 1.99622512e-02f, 1.40312761e-01f, -6.40153512e-02f, 1.03116639e-01f,
  -1.30622670e-01f, -3.79429236e-02f, 3.86265442e-02f, -8.77128690e-02f, -6.36136085e-02f, -3.73142995e-02f, -5.09405276e-03f, 1.47599593e-01f, 6.64360747e-02f, 8.05554613e-02f,
  -3.06206546e-03f, 8.13107267e-02f, 1.26383886e-01f, 1.28062233e-01f, 5.13039045e-02f, 1.26637593e-01f, 7.40112513e-02f, 1.54521376e-01f, -6.66563883e-02f, 1.40452296e-01f,
  -2.02014446e-02f, 1.46038225e-02f, -1.11857608e-01f, -6.58695251e-02f, -1.12874851e-01f, -9.44472179e-02f, -7.62634650e-02f, 8.37948620e-02f, 4.94628921e-02f, 8.06297213e-02f,
  3.25200297e-02f, 9.87345502e-02f, -7.66858459e-02f, 1.30073160e-01f, -1.32422224e-01f, 4.69555371e-02f, -1.56670448e-03f, 8.74553025e-02f, -8.39755535e-02f, -1.37064680e-01f,
  -1.62377164e-01f, 1.17333174e-01f, -3.00486777e-02f, -1.05880044e-01f, 1.25162881e-02f, 4.33834791e-02f, -1.18124999e-01f, -1.13758869e-01f, 1.61391437e-01f, -2.57534832e-02f,
  -6.05789647e-02f, 4.72432375e-02f, 4.15753275e-02f, 1.84970379e-01f, -3.76560427e-02f, -2.29707837e-01f, -2.48663537e-02f, 5.24042733e-02f, -7.32233003e-02f, -5.09322733e-02f,
  -4.24985737e-02f, 1.07532427e-01f, -8.30382183e-02f, -3.14043760e-02f, -1.60822533e-02f, 4.30564396e-02f, -7.74474815e-02f, 7.70531520e-02f, -8.80044326e-02f, -1.34320289e-01f,
  2.59539783e-01f, -6.10364377e-02f, -1.07542828e-01f, -2.50987280e-02f, -1.72347620e-01f, -7.04572275e-02f, 7.41948187e-02f, -5.91991320e-02f, -1.16987050e-01f, 4.37709913e-02f,
  5.82862683e-02f, -1.58502147e-01f, 1.11521073e-02f, 9.49721187e-02f, 2.83599067e-02f, -7.99277574e-02f, -7.95725137e-02f, 3.66175249e-02f, -4.31081541e-02f, -1.20442055e-01f,
  -1.18360765e-01f, -1.11807331e-01f, -1.05893739e-01f, -1.38620539e-02f, -8.12649056e-02f, 1.37379020e-01f, 1.09132610e-01f, 3.24118547e-02f, 1.25981316e-01f, -1.09470472e-01f,
  1.59280792e-01f, 6.29714364e-03f, 5.32558337e-02f, 5.46471886e-02f, 4.46851850e-02f, 1.68800458e-01f, 1.56631842e-01f, 6.60753697e-02f, 4.24674563e-02f, 1.24061339e-01f,
  1.05598411e-02f, -3.09629887e-02f, 6.60551488e-02f, -1.94354400e-01f, -9.76966619e-02f, 1.62995569e-02f, 1.64369285e-01f, 1.96260083e-02f, -1.91614419e-01f, 2.12904699e-02f,
  3.85583229e-02f, 1.34268954e-01f, -6.39509037e-02f, 9.65800434e-02f, -2.46579312e-02f, 1.61466584e-01f, 2.21772660e-02f, 1.26182958e-01f, -3.72563563e-02f, 4.61125411e-02f,
  3.90340574e-02f, 1.66956812e-01f, 9.52473562e-03f, 2.36927986e-01f, 1.57932371e-01f, -8.83023161e-03f, -2.42829733e-02f, -1.53828427e-01f, -1.46464556e-01f, -5.99785075e-02f,
  -6.80239797e-02f, 1.70138702e-01f, -1.65914133e-01f, 1.08554244e-01f, -2.33217096e-03f, -1.36515826e-01f, 1.20531008e-01f, -9.46999416e-02f, -1.43205822e-01f, -2.24861950e-02f,
  2.68118642e-03f, -3.03346943e-02f, -4.78770817e-03f, 8.18876401e-02f, 1.60935000e-01f, -1.76048875e-01f, -5.17316349e-02f, -1.55813828e-01f, -5.09645827e-02f, 7.63111422e-03f,
  3.05549968e-02f, -1.55484855e-01f, -5.73806167e-02f, 8.15912429e-03f, -9.45764259e-02f, 1.60689559e-02f, 1.20067008e-01f, 2.45501995e-02f, -1.19105257e-01f, 5.52430302e-02f,
  -1.18536338e-01f, -1.90714955e-01f, -6.26671985e-02f, 9.77664292e-02f, 5.43853976e-02f, -1.40108109e-01f, 2.16289088e-01f, -1.80696711e-01f, 6.87084869e-02f, -1.37204109e-02f,
  1.30912825e-03f, -1.03022262e-01f, -9.97201130e-02f, -2.10954949e-01f, 1.51918635e-01f, 2.06134334e-01f, 5.14114909e-02f, -1.32525712e-01f, -1.18939951e-01f, -1.56735182e-02f,
  1.02353826e-01f, -1.15183093e-01f, 1.75350588e-02f, 3.08044371e-03f, -1.60691943e-02f, 9.12733078e-02f, 6.70697391e-02f, -4.67319153e-02f, 1.59357563e-01f, -1.68548718e-01f,
  -7.26555064e-02f, -1.15241997e-01f, -1.30231291e-01f, -3.10948840e-03f, 2.05059364e-01f, -7.26078078e-02f, -1.70915857e-01f, 1.11915931e-01f, 2.81635255e-01f, -8.85079876e-02f,
  7.76189491e-02f, -1.06444210e-01f, -2.03581095e-01f, 8.35964829e-02f, 1.46015301e-01f, -4.98674102e-02f, -8.90600085e-02f, 6.81883395e-02f, 4.42274623e-02f, 4.48498540e-02f,
  2.99318489e-02f, -1.39328450e-01f, -9.67319384e-02f, 9.60574001e-02f, -4.93022390e-02f, 8.64024907e-02f, 9.61407833e-03f, -9.19271857e-02f, -5.35441041e-02f, 9.71365198e-02f,
  -8.30345005e-02f, 3.84940319e-02f, 4.27933708e-02f, 1.11990422e-02f, -1.00735664e-01f, -1.39825940e-02f, 1.35641217e-01f, -1.15375663e-03f, -1.15967333e-01f, 5.76447211e-02f,
  1.35345310e-01f, -2.15777308e-01f, 4.12138402e-02f, -1.31871372e-01f, -8.99549648e-02f, -6.17517196e-02f, -8.50411877e-02f, -1.84253767e-01f, 1.79865748e-01f, -6.37744972e-03f,
  1.47559986e-01f, -8.37051347e-02f, -8.86615291e-02f, 1.54361248e-01f, 7.58400485e-02f, -4.39225547e-02f, 7.74202868e-02f, -9.67640132e-02f, 1.48920387e-01f, -2.51139030e-02f,
  -1.29231408e-01f, 1.35093639e-02f, -5.23270248e-03f, -3.77966538e-02f, 8.57500583e-02f, -1.12233281e-01f, 1.05818927e-01f, 1.49211800e-02f, 1.23095572e-01f, 2.57947631e-02f,
  -1.08167052e-01f, 3.15748528e-02f, 1.52216032e-01f, 1.81165151e-02f, -1.36297658e-01f, 1.47497207e-01f, -1.17898375e-01f, 9.35238376e-02f, -6.56481609e-02f, -6.79854006e-02f,
  2.16905270e-02f, 2.86179073e-02f, 1.11831255e-01f, -3.79268192e-02f, -8.00130963e-02f, -1.42407849e-01f, -3.31464522e-02f, -7.33229890e-02f, 6.69097602e-02f, -3.92785408e-02f,
  -1.34637997e-01f, 7.60901794e-02f, 3.18561494e-02f, -1.44785240e-01f, 7.11728036e-02f, 2.08485827e-01f, -1.72612935e-01f, -5.36227562e-02f, 1.10617831e-01f, 6.18708134e-02f,
  -2.60126349e-02f, -6.05315231e-02f, 4.58582938e-02f, 9.74365920e-02f, -7.23028779e-02f, -1.91950232e-01f, -2.37586610e-02f, 1.84592903e-01f, -4.38667834e-02f, -2.20034808e-01f,
  -1.88326478e-01f, 2.52566021e-02f, -5.29542156e-02f, 1.20105445e-01f, -9.23380330e-02f, -3.02845961e-04f, -1.48252591e-01f, -1.19302548e-01f, 6.30004704e-02f, 3.27081792e-02f,
  -1.28368422e-01f, -1.21008530e-01f, 3.20216231e-02f, -9.73201618e-02f, 5.87712303e-02f, -1.69511750e-01f, 1.68801900e-02f, 1.00054853e-01f, -3.43154147e-02f, -1.04620546e-01f,
  9.87166837e-02f, -6.27138615e-02f, 2.43263319e-01f, 5.95427901e-02f, -1.73174560e-01f, 1.79154769e-01f, 9.98745710e-02f, 8.19530338e-02f, 7.74432868e-02f, 1.60095457e-03f,
  -9.54467282e-02f, -1.30159631e-02f, 1.47370160e-01f, 4.67775017e-02f, 3.56586389e-02f, 1.19129598e-01f, 1.58392429e-01f, -7.58411363e-02f, -1.28055215e-01f, 3.74824256e-02f,
  6.86912471e-03f, -9.89605263e-02f, -1.71602264e-01f, -9.07504037e-02f, 1.32698596e-01f, 4.62221280e-02f, 2.35425979e-02f, -1.09074891e-01f, 1.14983402e-01f, -1.06900990e-01f,
  7.94209838e-02f, 1.47045076e-01f, -1.81690767e-01f, -3.17199491e-02f, 2.31173020e-02f, -8.02652724e-03f, 4.12213523e-03f, -5.09379022e-02f, 2.09341403e-02f, 1.00046881e-01f,
  4.82629277e-02f, 4.88183573e-02f, 2.84593496e-02f, 1.25054792e-01f, 1.43413171e-01f, -9.85744298e-02f, 1.12861648e-01f, -9.10681188e-02f, 2.82275751e-02f, 5.56889139e-02f,
  9.05261282e-03f, -4.19758670e-02f, -3.90015058e-02f, -9.28482413e-02f, 4.42795530e-02f, 1.16883695e-01f, 5.23065813e-02f, 1.92995295e-01f, -5.93901500e-02f, 1.81515530e-01f,
  -6.90665916e-02f, -5.21510877e-02f, -9.14130360e-02f, 1.11640617e-01f, -1.08058333e-01f, 5.93266487e-02f, -6.59583807e-02f, -6.57857507e-02f, -9.74663496e-02f, -4.18855809e-02f,
  -8.93272161e-02f, -4.83846106e-02f, -2.51833946e-02f, 9.19339508e-02f, 1.78591721e-02f, -7.29936436e-02f, -4.36633267e-02f, 4.62507978e-02f, -4.59543131e-02f, -3.18461917e-02f,
  6.55330494e-02f, -9.51948017e-02f, 5.01671582e-02f, -3.05523295e-02f, 1.72350377e-01f, -1.69850454e-01f, -4.35887948e-02f, 5.83163090e-02f, -9.90816653e-02f, 1.11144826e-01f,
  -1.35698527e-01f, 2.67501976e-02f, -5.28223850e-02f, 1.48509830e-01f, -1.06994621e-01f, 3.27944010e-02f, -7.32617602e-02f, -1.20062299e-01f, -8.44841748e-02f, -1.24853015e-01f,
  9.83546600e-02f, -4.55281287e-02f, -8.98491649e-04f, -7.80687407e-02f, 5.93111590e-02f, 2.05233190e-02f, -1.55066088e-01f, -2.11983204e-01f, 3.65425944e-02f, 8.76334757e-02f,
  -2.43089169e-01f, 1.40870260e-02f, -4.13714498e-02f, 5.32058738e-02f, 2.79509015e-02f, -1.13250166e-01f, -2.48384420e-02f, 8.99917167e-03f, -8.85277465e-02f, -7.69016668e-02f,
  -7.54411295e-02f, -7.11315498e-02f, -3.45256552e-02f, -5.65125458e-02f, -1.03583895e-01f, 4.00032066e-02f, -1.09119892e-01f, -5.15273213e-02f, 2.33072676e-02f, -1.50844112e-01f,
  -3.71810943e-02f, 6.48212135e-02f, -1.33056581e-01f, 1.24197751e-01f, 4.58830260e-02f, 3.22903283e-02f, 9.37973112e-02f, 1.19419590e-01f, -8.18778574e-02f, -1.19333252e-01f,
  1.75908372e-01f, 1.16302066e-01f, -7.83963427e-02f, -1.09653726e-01f, 1.51218027e-02f, -2.62002684e-02f, -1.40587687e-01f, -7.94304982e-02f, 4.81428541e-02f, 4.83243428e-02f,
  -7.98704326e-02f, 2.37381905e-02f, 1.43750608e-01f, -1.17194280e-01f, -1.13935815e-02f, 4.01750877e-02f, 6.78820834e-02f, 1.29797265e-01f, 1.58617437e-01f, -5.85017614e-02f,
  3.14704739e-02f, 1.76555570e-02f, 4.57924493e-02f, 1.37992995e-02f, 8.80547464e-02f, -2.29050238e-02f, 8.59583355e-03f, -1.79177651e-03f, -5.78116737e-02f, 7.63879046e-02f,
  -1.04733787e-01f, -1.54049128e-01f, -8.38552937e-02f, -2.24571191e-02f, -1.31483674e-01f, -9.15811881e-02f, -6.72035441e-02f, -9.78364721e-02f, 8.81472230e-02f, -3.82742919e-02f,
  -6.92195371e-02f, 1.04867399e-01f, 2.83202715e-02f, -1.66722166e-04f, 1.53132703e-03f, -1.33813292e-01f, 4.22995016e-02f, 3.90055735e-04f, -8.91690403e-02f, 1.47207472e-02f,
  -6.62203282e-02f, 1.06801547e-01f, 9.57853720e-03f, -7.99969360e-02f, -4.23792899e-02f, 8.65425467e-02f, -8.84583294e-02f, 7.70486221e-02f, 5.95051534e-02f, -8.87893736e-02f,
  5.56420162e-02f, 1.27179846e-01f, -6.64442778e-03f, -8.49178731e-02f, 1.33340463e-01f, 9.44303423e-02f, -2.43961066e-02f, -1.51587814e-01f, 8.27906728e-02f, 8.57147127e-02f,
  -1.02027535e-01f, 1.43694580e-01f, -1.49267733e-01f, 6.30696714e-02f, -1.30321041e-01f, 2.15179771e-02f, 6.76802471e-02f, 4.69212271e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.29549234e-02f, -1.38629591e-02f, 1.42827585e-01f, -1.00394025e-01f, 5.25279716e-02f, 9.05515999e-02f, -1.08873975e-02f, 7.22335558e-03f, -6.24072254e-02f, 5.74769937e-02f,
  9.59454626e-02f, -1.07933685e-01f, 4.86695534e-03f, 1.38845846e-01f, -8.98734927e-02f, -9.84463021e-02f, 2.55458690e-02f, 4.44758013e-02f, 2.94983275e-02f, 3.57283503e-02f,
  8.89526829e-02f, -6.33431077e-02f, -7.66022578e-02f, 1.32287219e-01f, 1.00012414e-01f, -7.35234097e-02f, 1.72949377e-02f, 7.66070411e-02f, 1.13867059e-01f, 9.08372551e-02f,
  -2.87330933e-02f, 1.31093666e-01f, -6.59544067e-03f, 6.45011365e-02f, 8.45544115e-02f, 1.47480369e-01f, -8.72724727e-02f, -6.26525134e-02f, -7.67451301e-02f, -7.79084042e-02f,
  -8.75104666e-02f, 7.92770535e-02f, 1.94670066e-01f, 5.46297207e-02f, -1.49438515e-01f, -1.41367200e-04f, -4.98732477e-02f, 3.71123180e-02f, 2.28687748e-02f, -1.20849110e-01f,
  -1.31019220e-01f, 8.04334804e-02f, 1.70982167e-01f, 1.45327598e-01f, -1.76798385e-02f, 6.63210303e-02f, -7.85711557e-02f, 4.11083805e-04f, 7.76088014e-02f, -7.99291283e-02f,
  1.43724903e-01f, -3.43280546e-02f, -1.04926363e-01f, 1.20859161e-01f, 7.22160712e-02f, 3.80417556e-02f, 9.59579200e-02f, -1.10414716e-04f, 1.13473304e-01f, -2.39735916e-02f,
  -2.67926585e-02f, 1.38467684e-01f, -3.54596935e-02f, 1.03131101e-01f, 8.11399370e-02f, -4.16993834e-02f, 4.96725664e-02f, -3.80163826e-02f, -7.66302422e-02f, 1.03676930e-01f,
  8.68367329e-02f, 8.19000229e-02f, 8.05987045e-02f, -1.23458624e-01f, 1.24489600e-02f, -1.24613330e-01f, 1.09029911e-01f, 9.04528126e-02f, -8.39104205e-02f, 3.06644421e-02f,
  4.43786494e-02f, -2.86804121e-02f, 2.65433919e-02f, -5.77164441e-02f, -3.51727195e-02f, 1.58537909e-01f, 1.10310338e-01f, 1.39292359e-01f, 7.15733990e-02f, -1.65290441e-02f,
  -1.18506573e-01f, 4.52497788e-02f, -1.13323934e-01f, 8.58613551e-02f, -1.18843965e-01f, -1.18614636e-01f, 8.05870146e-02f, -6.74009547e-02f, 3.08861155e-02f, -9.66839343e-02f,
  -9.18331146e-02f, 1.42439147e-02f, 3.70843969e-02f, 9.41259935e-02f, 5.66221178e-02f, -2.03443188e-02f, 6.98351301e-03f, 4.85504679e-02f, 1.13247864e-01f, -5.85357621e-02f,
  5.07192351e-02f, -2.59287972e-02f, 1.50191739e-01f, -9.87953618e-02f, -6.49635941e-02f, 4.61261570e-02f, 6.26715943e-02f, -5.42587712e-02f, 1.27055228e-01f, 6.97544739e-02f,
  9.54808146e-02f, 3.86362337e-02f, -3.96814384e-02f, -8.30088928e-03f, -7.18679205e-02f, 1.03601262e-01f, -3.89946252e-02f, 1.42993882e-01f, 1.06017396e-01f, -9.24813375e-02f,
  -9.34767711e-04f, -8.67211148e-02f, 5.90036400e-02f, -1.02148391e-01f, 1.95550382e-01f, 6.72554970e-02f, 8.14245492e-02f, -5.91852143e-02f, 9.57414135e-02f, 8.04253295e-02f,
  6.17867373e-02f, -1.23774864e-01f, -6.00058623e-02f, 5.64695336e-02f, -1.31081184e-02f, -5.20942509e-02f, 1.10032968e-01f, 4.55573387e-02f, 8.42960402e-02f, -3.04025095e-02f,
  3.43966447e-02f, 1.21856704e-01f, 1.99619174e-01f, 1.03542045e-01f, 7.16275070e-03f, -5.39808907e-02f, -5.78289703e-02f, -2.39675790e-02f, -3.75556387e-02f, 1.09611452e-01f,
  -8.88242796e-02f, -1.10355154e-01f, -2.09986325e-02f, -1.67590089e-03f, -1.59395430e-02f, -7.32322559e-02f, -4.89571728e-02f, 4.34421897e-02f, 1.62833668e-02f, 6.72994256e-02f,
  -2.37824004e-02f, 4.13734578e-02f, -1.32430241e-01f, 3.51161063e-02f, 9.65886042e-02f, 1.71680786e-02f, 9.58407223e-02f, -3.41016352e-02f, -5.93811646e-03f, 2.04268005e-02f,
  -3.70710567e-02f, 1.01851579e-02f, -4.02474329e-02f, -2.20167153e-02f, 1.25539765e-01f, -3.21796201e-02f, 1.42488226e-01f, -1.71652921e-02f, 6.69375956e-02f, -8.54928046e-03f,
  -3.15194987e-02f, -1.81250069e-02f, -1.26727792e-02f, 1.69428721e-01f, 4.67384346e-02f, 1.41520172e-01f, 9.63706449e-02f, 4.32533299e-04f, -7.48891532e-02f, 7.09676519e-02f,
  -5.53407557e-02f, -7.09195854e-03f, -3.18777002e-02f, 2.28612050e-02f, -1.12899520e-01f, 9.50796530e-02f, 8.53587613e-02f, -7.78627545e-02f, 5.37711056e-03f, 1.98759064e-02f,
  9.26391110e-02f, 9.15901288e-02f, 4.59716842e-02f, 4.42193821e-02f, 7.56673664e-02f, -9.03189406e-02f, 9.74654406e-03f, -7.17688948e-02f, 1.54907003e-01f, 8.90780538e-02f,
  5.39979003e-02f, 5.89087307e-02f, 3.65480930e-02f, -1.03301890e-01f, 1.83363602e-01f, -1.10291325e-01f, 4.33512591e-02f, 2.62502372e-01f, 6.10794127e-02f, 1.26991093e-01f,
  1.38521045e-01f, 2.72045750e-03f, 6.68225512e-02f, 2.94817109e-02f, 4.28392226e-03f, -1.03534363e-01f, -8.06432590e-02f, 3.29311118e-02f, 1.48059189e-01f, 1.17269620e-01f,
  -5.77454679e-02f, 7.78027698e-02f, 1.23614535e-01f, 1.11788169e-01f, -1.09515429e-01f, 1.35679254e-02f, -1.03167705e-01f, -4.65356819e-02f, -1.07870840e-01f, -6.45824298e-02f,
  8.02964624e-03f, -9.32367817e-02f, 1.25409245e-01f, -3.59108299e-02f, 5.43047674e-02f, -7.51976967e-02f, 7.99828991e-02f, 1.17182238e-02f, 1.14846036e-01f, -9.18082669e-02f,
  5.79577498e-02f, -1.00822724e-01f, -6.30768612e-02f, 5.69896512e-02f, -1.15310565e-01f, 8.67548659e-02f, -4.06018980e-02f, -2.73028668e-02f, 1.24342583e-01f, -7.88370818e-02f,
  1.91501975e-02f, -2.75409035e-03f, -2.17627902e-02f, 6.84238374e-02f, 5.12233377e-02f, -5.79531901e-02f, -6.57826290e-02f, 1.17336050e-01f, -2.17424463e-02f, 5.89757413e-03f,
  -1.12839609e-01f, -7.83241354e-03f, 6.37234934e-03f, -7.39795268e-02f, 6.17011152e-02f, 5.08179665e-02f, 3.31790261e-02f, 3.25571708e-02f, 1.19651735e-01f, -8.96754712e-02f,
  2.93569956e-02f, 1.36841834e-01f, -1.16760112e-01f, 6.89520389e-02f, 3.96969728e-02f, 8.89435485e-02f, -9.25483704e-02f, 5.60615845e-02f, -9.84638482e-02f, -1.40345851e-02f,
  6.35897517e-02f, -4.90198620e-02f, 8.44954550e-02f, 7.67145008e-02f, -9.75091755e-02f, 3.59230414e-02f, 1.41496807e-02f, 7.24742562e-02f, 7.08353221e-02f, -3.27453986e-02f,
  1.72491282e-01f, 7.16964900e-02f, 9.82511938e-02f, 1.60037354e-02f, 1.25543490e-01f, 2.71937679e-02f, 3.46278436e-02f, 2.15211779e-01f, 3.40935476e-02f, 1.60683215e-01f,
  6.35665879e-02f, 2.00125411e-01f, -8.42605904e-02f, 1.63397923e-01f, 4.25585173e-02f, 9.22605991e-02f, 1.98962674e-01f, 4.62080948e-02f, 1.84377849e-01f, 4.18231227e-02f,
  3.14306505e-02f, -8.13604519e-02f, -2.87841391e-02f, 1.64784878e-01f, 8.64296854e-02f, 3.03908847e-02f, -4.10780907e-02f, -1.03605196e-01f, 1.17543545e-02f, -5.91595508e-02f,
  -1.05673239e-01f, 3.65814418e-02f, -9.99458879e-03f, 1.56163260e-01f, -6.94916919e-02f, -5.07938229e-02f, -1.24363061e-02f, 6.38697967e-02f, -3.43655534e-02f, -2.37693284e-02f,
  -6.40621930e-02f, 1.06586456e-01f, -4.17338451e-03f, -1.55135393e-01f, -1.15846008e-01f, -5.58531843e-02f, 1.29284086e-02f, -5.26191816e-02f, 1.07883230e-01f, -1.23059608e-01f,
  -8.73554796e-02f, 1.61950383e-03f, 1.26778305e-01f, 8.92297626e-02f, -1.30032808e-01f, 8.68369713e-02f, 1.08944513e-01f, 1.19211823e-01f, 2.44017001e-02f, 9.41654760e-03f,
  -1.16340732e-02f, 9.38646421e-02f, -3.92431580e-02f, 1.27101645e-01f, -8.04191306e-02f, 1.80442184e-02f, -6.61263242e-02f, -5.22812866e-02f, 1.59911737e-01f, 7.26233795e-02f,
  4.51181903e-02f, 3.34846526e-02f, 1.05549186e-01f, -4.61489111e-02f, -3.57275382e-02f, 7.43450299e-02f, 1.42827868e-01f, 3.87971383e-03f, -1.12078242e-01f, -1.15004005e-02f,
  1.44139558e-01f, -6.24556467e-02f, 1.81540251e-02f, 1.00944582e-02f, 1.18523560e-01f, 5.13303727e-02f, 3.92693579e-02f, -1.16996191e-01f, 5.66695910e-03f, 5.36343567e-02f,
  9.01246145e-02f, -6.53192922e-02f, -5.04784994e-02f, 1.71447307e-01f, -9.68846902e-02f, -8.81864398e-04f, 6.17993698e-02f, 1.12863727e-01f, 2.05133185e-01f, 1.33435458e-01f,
  8.19283649e-02f, -9.38184410e-02f, -1.16464578e-01f, -1.24424137e-01f, 1.15307663e-02f, -1.07275188e-01f, -5.94221838e-02f, -7.72547573e-05f, -4.65446934e-02f, -1.22779042e-01f,
  -9.14824978e-02f, -8.28024670e-02f, 2.44104560e-03f, 7.02164620e-02f, -2.31974497e-02f, -2.35280693e-02f, 5.22729680e-02f, 4.23322618e-02f, -1.18001290e-01f, -6.29281625e-02f,
  -8.88030827e-02f, 8.18962306e-02f, 2.83711981e-02f, -9.19494107e-02f, -1.55790588e-02f, 2.02007173e-03f, 3.89097072e-02f, 4.12163697e-02f, -6.93123490e-02f, 1.05528504e-01f,
  8.02676603e-02f, 9.91475806e-02f, -3.22716832e-02f, -2.16612555e-02f, 6.00850768e-02f, 1.18881226e-01f, 8.31456408e-02f, -3.52099910e-02f, 3.86295356e-02f, -9.60109755e-02f,
  1.04645476e-01f, 7.44604617e-02f, -7.79477060e-02f, 4.11282703e-02f, -8.01423565e-02f, -1.66477099e-01f, -1.03065938e-01f, 1.39469966e-01f, -1.31902248e-01f, 3.93077470e-02f,
  6.83448166e-02f, -7.69977197e-02f, 1.12289533e-01f, 3.62980813e-02f, 6.24554344e-02f, 7.65015036e-02f, 1.00100869e-02f, 5.79184406e-02f, 3.37056741e-02f, -4.70113456e-02f,
  1.07365459e-01f, 8.40795413e-02f, -1.09615497e-01f, 1.07841976e-01f, 3.79032791e-02f, -2.69977637e-02f, 1.69091783e-02f, 6.36741072e-02f, 3.20354626e-02f, -2.77365595e-02f,
  -1.18226156e-01f, 3.15002128e-02f, 1.10014006e-01f, -8.84457082e-02f, 1.46459803e-01f, -4.22192737e-02f, 6.73583299e-02f, -7.88169801e-02f, 1.51712790e-01f, 1.14203729e-01f,
  2.30799057e-02f, -1.32541461e-02f, 5.89311160e-02f, -1.31365061e-02f, 1.56742353e-02f, 1.38640925e-01f, 3.53473574e-02f, -1.17333040e-01f, 3.55782174e-02f, -1.16199471e-01f,
  -1.11803748e-02f, -9.18354243e-02f, 1.23904109e-01f, 9.75008681e-02f, 9.28843543e-02f, 1.51342571e-01f, -8.76780658e-04f, 4.69253510e-02f, -3.20183896e-02f, -2.59732362e-02f,
  1.25765741e-01f, 1.51619926e-01f, 2.84645390e-02f, 9.37007293e-02f, 1.91028655e-01f, -2.42752343e-01f, -1.99385032e-01f, 1.59726273e-02f, -7.20467344e-02f, 3.55624557e-02f,
  -1.24369547e-01f, -1.20846249e-01f, 1.00764565e-01f, 1.50177896e-01f, 1.23269230e-01f, 1.76800255e-04f, 4.85043507e-03f, 2.54170764e-02f, -1.51936784e-01f, 1.64743233e-02f,
  6.29540458e-02f, -2.14179847e-02f, 3.35663594e-02f, 1.15604222e-01f, -1.22923739e-01f, 1.26637891e-01f, 7.96207339e-02f, -8.04624408e-02f, 8.26696604e-02f, -7.75920525e-02f,
  -1.20073572e-01f, 2.50015464e-02f, 1.95058763e-01f, -5.29382378e-02f, 8.75297338e-02f, 1.90851256e-01f, 3.18983734e-01f, 1.27436697e-01f, -1.11025520e-01f, 1.05390668e-01f,
  -7.99257457e-02f, 1.66242898e-01f, 5.77315353e-02f, -7.00311456e-03f, -1.02769293e-01f, -8.55647586e-03f, -1.23430742e-03f, -4.52953130e-02f, 1.46277156e-02f, -5.92393726e-02f,
  -2.00729650e-02f, 1.20664611e-01f, -1.20583408e-01f, 2.60207355e-02f, -2.38012671e-02f, 1.00518532e-01f, -2.30468996e-02f, -3.94625776e-02f, 8.01121891e-02f, 7.00065270e-02f,
  -4.77420688e-02f, 4.74288948e-02f, 9.00733098e-02f, -8.82010628e-03f, 5.84872887e-02f, -4.42467965e-02f, -6.61652312e-02f, -8.51773769e-02f, 4.69145738e-02f, -7.60549828e-02f,
  -4.41594906e-02f, -3.97664541e-03f, 1.34905964e-01f, -3.88265625e-02f, -2.01101601e-02f, -2.64435112e-02f, -3.33033912e-02f, -3.85609381e-02f, 1.33282468e-01f, 5.48794381e-02f,
  -4.59545515e-02f, -1.09292351e-01f, 1.12997331e-01f, 8.06189850e-02f, -1.12252280e-01f, -4.39025015e-02f, 7.51902163e-02f, 9.80310813e-02f, 1.20635539e-01f, 1.14417942e-02f,
  4.29904200e-02f, 2.64775567e-03f, -1.28561825e-01f, 1.22320894e-02f, 8.28004852e-02f, 1.01586193e-01f, 9.80876014e-02f, -9.71077085e-02f, 7.26447324e-04f, 1.39662689e-02f,
  -5.86675778e-02f, -1.05126463e-01f, -1.09372206e-01f, -2.00627577e-02f, -1.29162744e-01f, -5.25229573e-02f, 6.69791251e-02f, -2.01929193e-02f, -1.13625474e-01f, 4.10061097e-03f,
  -7.10610822e-02f, -9.54229571e-03f, 6.11064211e-02f, -4.71558794e-02f, 1.80350465e-03f, -4.20545340e-02f, 7.19351396e-02f, -3.25908139e-02f, 2.76060938e-03f, -8.25471431e-02f,
  6.07049316e-02f, 2.01639473e-01f, 5.02163060e-02f, -6.33189082e-02f, 1.82154760e-01f, 1.57380506e-01f, 4.07472812e-03f, 5.62698506e-02f, -4.85446341e-02f, 1.24785975e-01f,
  1.67935506e-01f, 5.27341329e-02f, 4.46212664e-02f, 1.34011760e-01f, 1.14665903e-01f, -3.84271145e-02f, -2.64005214e-01f, -2.36077514e-02f, 3.53544466e-02f, -3.16141881e-02f,
  3.90872732e-02f, 5.50745018e-02f, -9.57603231e-02f, 2.07157269e-01f, 9.41881537e-03f, -5.30431755e-02f, 4.33869064e-02f, -4.72731888e-02f, -4.41012792e-02f, 5.63733317e-02f,
  -6.64732009e-02f, -1.05543457e-01f, 1.87900048e-02f, -1.30267486e-01f, -1.42537445e-01f, -3.27162147e-02f, 7.54218847e-02f, 1.06542327e-01f, 1.03516348e-01f, 7.65963346e-02f,
  -5.72963320e-02f, 4.88206483e-02f, 2.86559612e-01f, -8.47835019e-02f, -1.55932680e-02f, 2.90236026e-01f, -9.11518484e-02f, 7.33837336e-02f, 1.81083381e-01f, -3.97147164e-02f,
  -1.62708610e-01f, 6.74948422e-03f, 3.17060612e-02f, -1.60002373e-02f, -1.99059904e-01f, 9.49586928e-02f, 8.54398981e-02f, 1.48784176e-01f, 9.64147002e-02f, -3.64121981e-02f,
  1.34139776e-01f, -5.24767339e-02f, -1.29934043e-01f, -1.18071109e-01f, -3.59853506e-02f, 1.79578960e-02f, -8.94000232e-02f, -1.82156060e-02f, -4.21500728e-02f, 1.16132177e-01f,
  1.75687313e-01f, 1.65926442e-01f, 7.39583075e-02f, -8.83131940e-03f, 1.70506582e-01f, 1.12830810e-01f, -1.33825287e-01f, 2.16604158e-01f, -1.03871971e-01f, 7.96720460e-02f,
  5.77259399e-02f, -8.78939405e-02f, -4.59492318e-02f, 1.41912168e-02f, -1.58348382e-01f, 5.55426814e-02f, -1.15775466e-01f, 1.31580427e-01f, 1.13370419e-01f, 4.20648009e-02f,
  8.01654458e-02f, 8.94424319e-02f, 7.58253559e-02f, -1.80115048e-02f, 3.09900176e-02f, 7.06957877e-02f, -2.51134927e-03f, 1.66888423e-02f, -6.10313937e-02f, -1.08549967e-02f,
  -9.47769079e-03f, 1.08735621e-01f, 1.60792127e-01f, -1.41412050e-01f, -1.01222627e-01f, 2.36929487e-02f, 5.93551360e-02f, -7.98477829e-02f, -1.49129257e-01f, 9.57942009e-02f,
  -4.09646630e-02f, 7.76776373e-02f, -1.98175618e-03f, 3.70275229e-02f, 4.28425074e-02f, 5.23421429e-02f, 8.93886983e-02f, 1.22742601e-01f, -1.55557096e-01f, 9.11599323e-02f,
  8.96563604e-02f, -2.68737860e-02f, 4.20921519e-02f, -6.30185157e-02f, 3.44409384e-02f, -1.07398778e-01f, -1.12601131e-01f, -1.37562141e-01f, 1.96064413e-01f, 1.31426439e-01f,
  1.74057439e-01f, 1.05135225e-01f, -1.17588229e-01f, 1.35505512e-01f, -2.71107126e-02f, 2.17661873e-01f, -2.76198275e-02f, 1.95299640e-01f, 2.16776863e-01f, 1.10333599e-01f,
  -2.20474694e-02f, 5.76394424e-02f, 1.74198404e-01f, -1.48264319e-01f, 1.64035842e-01f, 2.32959673e-01f, 1.53295651e-01f, -7.87678584e-02f, 7.50964433e-02f, 1.50227189e-01f,
  7.19394460e-02f, 1.62997037e-01f, 6.95581436e-02f, 1.91769287e-01f, 1.75978206e-02f, 1.45241767e-01f, 1.07457545e-02f, 1.13247603e-01f, -1.15630955e-01f, -2.91981101e-02f,
  3.77318375e-02f, 1.02613181e-01f, 7.59236664e-02f, -1.01649053e-01f, 1.15100436e-01f, -2.21945941e-02f, -4.41944040e-02f, 5.40029965e-02f, -1.93391666e-01f, -3.39037254e-02f,
  1.56102240e-01f, -1.78591326e-01f, -1.11937657e-01f, -1.27330422e-01f, -1.38566792e-01f, 2.10486595e-02f, -5.02628908e-02f, -4.17581536e-02f, -1.07440710e-01f, 9.09672156e-02f,
  1.41521499e-01f, 3.11615113e-02f, 1.14565410e-01f, 3.21361609e-03f, -3.12416553e-02f, -9.96200293e-02f, 1.53319120e-01f, 8.43232274e-02f, 1.22638375e-01f, 9.50606242e-02f,
  1.23681195e-01f, 1.02498010e-01f, 5.34599759e-02f, 1.15926683e-01f, -2.97510047e-02f, -5.23544801e-03f, 1.20902434e-01f, 1.20073847e-01f, -1.14002377e-01f, 1.33173525e-01f,
  -9.46573019e-02f, 5.71970362e-03f, 1.14800811e-01f, -2.11502332e-02f, -4.32973579e-02f, -2.11624056e-02f, -8.82906094e-02f, -1.31503716e-01f, 1.86464205e-01f, 3.74033079e-02f,
  5.68749979e-02f, 8.42532292e-02f, 1.26111314e-01f, -8.69081467e-02f, 5.81012294e-02f, -2.90278066e-02f, -5.34144156e-02f, 8.50626156e-02f, 3.65848094e-02f, 1.15326732e-01f,
  6.89416900e-02f, -7.04440325e-02f, 1.88618917e-02f, 1.40985608e-01f, 9.42092612e-02f, 6.15466051e-02f, 1.19115025e-01f, -9.48817506e-02f, 3.94452214e-02f, 9.44960341e-02f,
  1.32445306e-01f, 5.23696374e-03f, -7.00567290e-02f, 4.88653965e-02f, -3.27100162e-03f, -1.23825125e-01f, -2.79457122e-02f, -1.11827468e-02f, 4.14240845e-02f, 5.01304641e-02f,
  -4.82264608e-02f, -2.81055477e-02f, 1.96402501e-02f, 7.68955126e-02f, 1.39541358e-01f, 1.28011152e-01f, 4.66870219e-02f, 1.33810744e-01f, -3.41163911e-02f, 1.21539012e-01f,
  1.05938479e-01f, 1.69296007e-04f, -7.69465640e-02f, -7.98586830e-02f, -4.85923663e-02f, -4.24317494e-02f, -8.38167500e-03f, 1.42721096e-02f, 2.82458570e-02f, -2.80362405e-02f,
  -3.25884782e-02f, 1.07403494e-01f, 9.64090899e-02f, -4.92238775e-02f, -1.14168182e-01f, 1.06928423e-01f, -7.02652335e-02f, -5.30393273e-02f, 7.34437928e-02f, -7.28404224e-02f,
  -3.40209380e-02f, 2.36631818e-02f, 9.34425890e-02f, -1.37435058e-02f, -2.27791187e-03f, -7.69766346e-02f, -1.10514231e-01f, -6.86569214e-02f, -5.66907413e-02f, 1.14268281e-01f,
  -1.52447736e-02f, 4.68240902e-02f, 1.11769319e-01f, -5.34356311e-02f, 1.23211630e-01f, -1.01687215e-01f, -1.04533821e-01f, 3.18081155e-02f, 5.86799383e-02f, -7.98541158e-02f,
  -1.08680017e-01f, 1.51796071e-02f, -3.44820544e-02f, -6.62071481e-02f, 9.00864378e-02f, -1.02110565e-01f, -5.60850725e-02f, -4.31061257e-03f, 5.34465387e-02f, 3.63725908e-02f,
  2.35882141e-02f, -9.30264965e-02f, -3.14090401e-02f, 1.28958404e-01f, -6.93217218e-02f, -1.14254184e-01f, 1.15804821e-01f, 4.26578037e-02f, 1.33368611e-01f, -3.53654549e-02f,
  -6.54771253e-02f, 1.25116268e-02f, 3.93078253e-02f, -9.67833549e-02f, 5.65249436e-02f, 9.92005095e-02f, -8.12642276e-02f, -9.09324810e-02f, 1.24036819e-02f, -5.03530577e-02f,
  -8.57101474e-03f, -3.33392136e-02f, -7.67427385e-02f, 9.53996256e-02f, 1.14311557e-03f, -7.63894990e-02f, 6.97808936e-02f, 8.61811042e-02f, -8.38458985e-02f, 5.06106727e-02f,
  4.39781360e-02f, -1.21581100e-01f, -1.66559592e-02f, -8.77479017e-02f, 5.17417789e-02f, 4.64077406e-02f, -1.29399896e-02f, -9.83748212e-02f, 1.32523580e-02f, -6.64399862e-02f,
  -1.18081570e-01f, 5.97942546e-02f, 4.62118462e-02f, -1.83430489e-03f, 6.02789633e-02f, 2.92713717e-02f, -5.82757071e-02f, 5.37542999e-02f, -7.77138844e-02f, 5.90555072e-02f,
  3.52463573e-02f, -2.32089143e-02f, -1.13031968e-01f, 5.82560450e-02f, -6.68901997e-03f, 5.56254983e-02f, 5.55061288e-02f, -7.91093409e-02f, -1.01410203e-01f, 2.18621790e-02f,
  9.63278264e-02f, -1.23268656e-01f, 7.50259031e-03f, -9.18842182e-02f, -3.34648639e-02f, -5.99486046e-02f, 1.15094937e-01f, 8.86097997e-02f, 1.11499585e-01f, -1.27755225e-01f,
  -1.46676702e-02f, -1.24795035e-01f, 9.48107317e-02f, -3.57614756e-02f, 3.77707620e-04f, -1.31245404e-01f, -6.01341128e-02f, -1.11927941e-01f, -6.57427087e-02f, 1.48181226e-02f,
  5.67049570e-02f, 7.63358176e-02f, -4.50342037e-02f, 7.85494223e-02f, 6.69089332e-02f, -5.60345268e-03f, 1.12848312e-01f, -5.78215346e-02f, -7.00016692e-02f, -9.04884376e-03f,
  -6.50740713e-02f, 7.77028501e-03f, -6.29617721e-02f, 9.39653516e-02f, 2.61086877e-02f, 1.26245484e-01f, 1.72760621e-01f, 2.86053196e-02f, 8.38495493e-02f, -6.03721775e-02f,
  2.83672847e-02f, 8.18870217e-02f, 1.10312492e-01f, 1.09967627e-02f, 1.55372486e-01f, -6.78705499e-02f, 1.15753502e-01f, -1.85241438e-02f, 6.36545420e-02f, 1.68693423e-01f,
  -8.77692699e-02f, -8.75391215e-02f, -5.28354570e-02f, -4.43466008e-02f, -6.25824183e-02f, -8.24572593e-02f, -5.09037040e-02f, 9.73526016e-02f, 1.07072189e-01f, -6.91563338e-02f,
  -1.13465205e-01f, -1.04302123e-01f, -8.75738915e-03f, -1.15034856e-01f, -1.33011594e-01f, 8.35011676e-02f, -7.94354901e-02f, 2.50643771e-02f, -4.02214229e-02f, -2.34711040e-02f,
  -5.60980663e-02f, 5.67206629e-02f, -7.73385679e-03f, 3.68863568e-02f, 7.92750865e-02f, 1.01626972e-02f, 9.82052311e-02f, -1.17566653e-01f, -7.84177333e-02f, 2.07966700e-01f,
  1.14590101e-01f, 1.00273445e-01f, 4.77126427e-02f, 7.05855489e-02f, 5.57728261e-02f, 6.55930191e-02f, 7.71450400e-02f, 1.10621624e-01f, 9.27496850e-02f, 2.78127138e-02f,
  1.45744085e-01f, 2.29397222e-01f, 8.71562809e-02f, 8.33714902e-02f, 6.10939637e-02f, 2.30983496e-02f, 1.18157677e-01f, 2.09128693e-01f, 1.42054528e-01f, 5.38944006e-02f,
  -2.13200990e-02f, -1.65340632e-01f, -2.16215998e-01f, 4.34274264e-02f, 6.33059070e-02f, -7.28777125e-02f, -1.50827974e-01f, 8.47066343e-02f, 2.06775200e-02f, 1.68353319e-02f,
  8.66218433e-02f, -7.52317235e-02f, 3.92370485e-02f, 1.11926310e-01f, 1.10297762e-01f, 5.70046939e-02f, 9.49080214e-02f, -4.12872527e-03f, 9.19057205e-02f, 3.06824204e-02f,
  -9.10521299e-02f, 1.97541952e-01f, -3.01469862e-02f, 6.55287281e-02f, -1.02887884e-01f, -7.52733722e-02f, -7.96126276e-02f, 5.73143549e-02f, 6.13252670e-02f, 1.04151741e-01f,
  -1.08426377e-01f, 1.81555077e-01f, 4.22615092e-03f, 2.73283888e-02f, -6.50961976e-03f, 1.67172682e-02f, -4.57990654e-02f, 1.84826832e-02f, 6.85211718e-02f, 9.46393237e-02f,
  -8.28087032e-02f, -9.16866958e-02f, -6.21012179e-03f, -1.01006858e-01f, 1.50672570e-02f, -2.47741416e-02f, -5.22872508e-02f, -8.05256739e-02f, -2.91943997e-02f, 9.33767185e-02f,
  6.78831637e-02f, 1.21024564e-01f, -5.18356916e-03f, 1.42193675e-01f, 1.40987664e-01f, 1.19184637e-02f, 2.44930968e-01f, 1.27298221e-01f, 1.25059351e-01f, 5.30772097e-02f,
  1.96562827e-01f, 4.79292125e-02f, 6.58518029e-03f, 2.22576141e-01f, 7.70758912e-02f, -1.68291673e-01f, -2.80066520e-01f, -1.97038129e-01f, -3.09748292e-01f, -7.28990138e-02f,
  -5.57506643e-02f, -3.53940018e-03f, 1.10409744e-01f, -1.29540592e-01f, 1.63642138e-01f, 1.47616282e-01f, 7.51617998e-02f, 6.33226261e-02f, -7.95001313e-02f, 9.35438201e-02f,
  -1.36179447e-01f, -4.21623066e-02f, 2.03544095e-01f, 2.05132905e-02f, -6.39636517e-02f, 9.81822014e-02f, -1.33902594e-01f, -1.02633148e-01f, 9.09527764e-03f, 1.07948042e-01f,
  2.47609429e-03f, 1.74293295e-01f, -6.18477445e-03f, -1.93643570e-02f, 2.03847900e-01f, -1.10303812e-01f, 2.45096207e-01f, 4.47293997e-01f, -7.34404102e-02f, 3.08132898e-02f,
  2.62033734e-02f, 2.43509486e-01f, -1.41063333e-01f, 2.46184692e-02f, 1.04259096e-01f, -1.42655924e-01f, -1.19418204e-01f, 1.45308552e-02f, 9.77442116e-02f, -2.91681234e-02f,
  -4.27765325e-02f, 5.68878688e-02f, 5.79295456e-02f, 7.35763311e-02f, -2.30368689e-01f, 5.39604500e-02f, 1.20218009e-01f, -5.33899628e-02f, -7.61560351e-02f, 6.89063966e-02f,
  1.08778462e-01f, 3.22986171e-02f, 2.14282945e-02f, 4.58207987e-02f, 1.47481009e-01f, 8.03776905e-02f, 2.67691575e-02f, 2.06035361e-01f, 5.41841388e-02f, -5.99710010e-02f,
  -9.73382369e-02f, -9.65649337e-02f, -2.13686958e-01f, -5.45754842e-02f, 4.81077805e-02f, 1.55560970e-01f, -1.22704012e-02f, -6.04413375e-02f, 1.50718749e-01f, -9.33420882e-02f,
  7.19829127e-02f, -2.32269410e-02f, -3.04331053e-02f, -1.03729464e-01f, -3.24399956e-02f, 3.49998698e-02f, 1.53003246e-01f, -4.49420474e-02f, -4.33803489e-03f, 9.92080867e-02f,
  -4.60546836e-02f, -5.31558841e-02f, -9.33245718e-02f, 9.47372913e-02f, 1.52868822e-01f, -1.25889732e-02f, 8.99744034e-02f, 8.68429691e-02f, 1.24292023e-01f, 1.46425024e-01f,
  1.51741728e-01f, 2.32209504e-01f, -2.72514503e-02f, 3.72184180e-02f, -6.10957183e-02f, 2.23041475e-01f, -9.17054415e-02f, 1.50579577e-02f, 4.03112397e-02f, 2.11733785e-02f,
  -3.67563330e-02f, 1.05290204e-01f, 2.02839822e-02f, 1.87346309e-01f, -6.12450019e-02f, 1.34004816e-01f, 2.63025463e-02f, 1.34451926e-01f, -5.85042685e-02f, 1.35349765e-01f,
  -8.55336257e-04f, -1.91173218e-02f, -3.05600762e-02f, 1.32598449e-02f, 9.35825333e-02f, 2.48219329e-03f, 1.15769655e-01f, 6.80469871e-02f, -8.47699642e-02f, -6.63831905e-02f,
  -4.84595373e-02f, -6.40510991e-02f, -1.03932492e-01f, -7.14579523e-02f, -1.14824370e-01f, 7.35277683e-02f, 9.82647985e-02f, 4.71200272e-02f, 1.43370792e-01f, -1.25251323e-01f,
  -4.26707417e-02f, -2.16064192e-02f, -3.88328149e-03f, -2.70229429e-02f, 7.06147254e-02f, 1.01890527e-01f, -5.56777865e-02f, -5.48068807e-02f, 5.76851405e-02f, 1.16876038e-02f,
  -1.19070217e-01f, -8.72877315e-02f, -1.06338926e-01f, -6.81557581e-02f, -9.42169428e-02f, 6.43129125e-02f, -1.30358025e-01f, -1.35908732e-02f, 7.43922815e-02f, 2.42639231e-04f,
  8.56832340e-02f, 6.18062355e-02f, 1.15497284e-01f, -5.71923330e-02f, -9.67169926e-02f, 7.33945072e-02f, -5.34810573e-02f, 1.35230832e-02f, -9.25902203e-02f, -6.39417842e-02f,
  1.41830854e-02f, -4.89219166e-02f, -6.68651611e-02f, 6.61410391e-03f, -1.54900830e-02f, 3.00184768e-02f, -7.04050884e-02f, 1.17144212e-02f, 1.20936170e-01f, -7.17799366e-02f,
  3.60040031e-02f, -1.22982152e-01f, 8.74547660e-02f, -1.12784401e-01f, 1.17992312e-02f, 1.50477901e-01f, 1.18122421e-01f, 1.89715236e-01f, 6.57167360e-02f, -2.19396353e-02f,
  3.40257771e-02f, 1.37945622e-01f, 4.45908420e-02f, -4.65655662e-02f, -3.56108248e-02f, 1.38443246e-01f, -1.94052029e-02f, 1.64931327e-01f, 4.38328311e-02f, 8.84869471e-02f,
  -1.82348922e-01f, -1.23167917e-01f, 8.92604589e-02f, -8.87602568e-03f, -6.07492328e-02f, -1.57363862e-01f, -1.12284780e-01f, 8.02301988e-02f, 9.44671333e-02f, -1.26952231e-01f,
  5.43004721e-02f, -3.52882482e-02f, 1.05771810e-01f, 1.11329898e-01f, -2.61936411e-02f, 9.08815935e-02f, 6.40498325e-02f, -1.08462009e-04f, -1.18733600e-01f, 9.99132991e-02f,
  -3.74650136e-02f, 1.39480114e-01f, -3.93952429e-02f, -1.12576850e-01f, -4.74991240e-02f, 8.97226036e-02f, -5.05378004e-03f, -8.14639255e-02f, 7.60912821e-02f, 1.23633116e-01f,
  -1.31392311e-02f, 6.58088103e-02f, 1.11051045e-01f, -1.30983919e-01f, -7.47639686e-02f, 1.40294656e-01f, -9.17818621e-02f, -7.53128380e-02f, -9.68725309e-02f, 1.23375922e-01f,
  -1.65894013e-02f, -1.42821800e-02f, -1.21045634e-01f, 4.77854460e-02f, -5.79414256e-02f, -4.94548380e-02f, -7.53990635e-02f, 5.84217981e-02f, -4.15280312e-02f, 2.49936506e-01f,
  1.94433436e-01f, -1.16579905e-01f, 2.73430616e-01f, 3.47125709e-01f, -5.30339554e-02f, 5.89054264e-02f, -1.37754366e-01f, 2.09822014e-01f, 1.37921482e-01f, -4.90883030e-02f,
  3.28029990e-01f, 3.56773771e-02f, -1.39483675e-01f, -2.67582387e-01f, 2.57931590e-01f, 6.62888810e-02f, 2.74222374e-01f, 4.75535691e-02f, 3.47621322e-01f, -1.43592238e-01f,
  -2.31892988e-02f, -7.60427043e-02f, 1.94443092e-01f, 3.40791270e-02f, -8.49108621e-02f, 5.76915219e-02f, 1.80479586e-01f, 2.91838199e-01f, 1.23898357e-01f, 1.31541193e-01f,
  2.89584734e-02f, 1.27044097e-01f, 1.89492002e-01f, 1.98542345e-02f, -8.75248462e-02f, -1.23298779e-01f, 1.22464843e-01f, -7.67946243e-02f, -6.68321550e-02f, 1.28057241e-01f,
  1.11221097e-01f, -2.13322207e-01f, -1.39235735e-01f, -1.62230417e-01f, 6.93429932e-02f, 1.65177453e-02f, 4.66639325e-02f, -1.23218976e-01f, 9.52225877e-04f, 1.49698019e-01f,
  1.45003989e-01f, 5.70798069e-02f, -2.01560616e-01f, 7.73514211e-02f, 2.15495989e-01f, 1.50181532e-01f, 1.10088736e-01f, 7.86904022e-02f, 1.73163936e-01f, 2.18033001e-01f,
  -1.13122590e-01f, 1.40954301e-01f, 1.13612249e-01f, 2.04495758e-01f, 9.81386825e-02f, 2.21033305e-01f, 2.81566411e-01f, 2.70028651e-01f, 2.21733242e-01f, 2.39879355e-01f,
  9.53469872e-02f, 1.70043290e-01f, 2.50877291e-01f, 1.33318335e-01f, -2.94355042e-02f, 1.02147534e-01f, -2.56719351e-01f, 1.54976934e-01f, -2.60009408e-01f, -2.15018898e-01f,
  2.79278625e-02f, 1.03210621e-01f, -1.87668845e-01f, -1.74005911e-01f, 1.17865406e-01f, -1.05790012e-01f, 2.89273392e-02f, -5.53907419e-04f, 9.01831314e-02f, 6.54435009e-02f,
  7.42707923e-02f, -2.22094245e-02f, -5.35617508e-02f, -1.04945891e-01f, -1.34985954e-01f, 1.07891984e-01f, 9.45144054e-03f, 5.48493750e-02f, -3.23832850e-03f, 8.03931355e-02f,
  8.71530026e-02f, -9.96483043e-02f, 7.11598992e-02f, -2.45101228e-02f, 3.22206244e-02f, 9.50248018e-02f, 3.10928691e-02f, 2.53781937e-02f, 7.42166340e-02f, 5.66952936e-02f,
  -1.06800281e-01f, 6.63745552e-02f, -4.67038788e-02f, 1.40654832e-01f, -2.50503677e-03f, -1.78811550e-01f, 4.09833863e-02f, -4.90021631e-02f, 1.23716518e-03f, 8.06947574e-02f,
  6.22678883e-02f, -9.33688655e-02f, -7.39736333e-02f, -1.20973296e-01f, -7.80027881e-02f, 9.09011886e-02f, 3.36189829e-02f, 7.06458166e-02f, -4.28700335e-02f, -2.41745589e-03f,
  -8.13625231e-02f, 6.62755743e-02f, 1.17704011e-01f, 1.37282997e-01f, 1.68791234e-01f, 1.65020511e-01f, -3.50484625e-02f, 1.05693065e-01f, 4.71662283e-02f, -8.70264892e-04f,
  3.22391801e-02f, 8.81023705e-03f, -4.47093919e-02f, -5.19106463e-02f, -3.05033326e-02f, 1.28546372e-01f, -1.44542918e-01f, -6.56678677e-02f, -9.58091617e-02f, -8.17860886e-02f,
  -7.41533563e-02f, -1.19052880e-01f, -5.30182645e-02f, 1.95968971e-02f, -1.17940627e-01f, 1.18582971e-01f, -1.31720096e-01f, -7.53369089e-03f, -1.07704744e-01f, 7.98006281e-02f,
  1.64214615e-02f, -8.25953856e-02f, 6.97200149e-02f, 9.74383205e-03f, 1.17410533e-01f, -1.21080622e-01f, 8.94007012e-02f, -1.16566874e-01f, -6.90327631e-03f, -8.24585408e-02f,
  -1.57572657e-01f, 5.85836768e-02f, 1.04756840e-01f, 3.67455073e-02f, 2.74167527e-02f, -2.03828663e-02f, -1.05208650e-01f, 3.66486274e-02f, -5.42599149e-02f, -6.66140169e-02f,
  -1.35581970e-01f, 1.74980948e-03f, 1.37514248e-02f, 1.20894291e-01f, 5.11619374e-02f, -2.24578641e-02f, -8.21203273e-03f, 6.37969077e-02f, -5.43442518e-02f, 1.09007813e-01f,
  1.09710604e-01f, 6.74677501e-03f, 1.03455074e-01f, 1.42419517e-01f, 6.57561645e-02f, 5.70132099e-02f, 5.98098384e-03f, -5.12637245e-03f, 3.51911634e-02f, 1.29345655e-01f,
  1.17917828e-01f, 1.37231350e-01f, 4.73517785e-03f, -1.81818485e-01f, -2.35160664e-01f, -2.52066571e-02f, -2.96383709e-01f, -1.59159154e-01f, -1.60323218e-01f, -1.07234739e-01f,
  9.08835009e-02f, -1.15169123e-01f, 2.02956237e-02f, -9.89524573e-02f, -8.44671726e-02f, 6.66045025e-02f, -9.45117474e-02f, 7.43611082e-02f, -8.16995203e-02f, -9.60664228e-02f,
  1.92726582e-01f, 1.46026149e-01f, -2.97417045e-02f, 9.18239728e-02f, -1.66316126e-02f, 7.11133778e-02f, 2.74854563e-02f, -5.15415929e-02f, -3.23075876e-02f, 1.36014491e-01f,
  3.11861426e-01f, -6.64475635e-02f, 1.59977585e-01f, 1.62687212e-01f, 4.33409393e-01f, 3.74398887e-01f, -8.75683352e-02f, 1.03181824e-01f, -5.79800680e-02f, 9.29168519e-03f,
  -7.60548934e-02f, -1.27856106e-01f, -1.06465034e-01f, -2.87291873e-02f, 8.07414278e-02f, -7.78790712e-02f, -1.03419974e-01f, -5.28555363e-02f, 6.42682686e-02f, 1.29310772e-01f,
  2.52949297e-02f, 8.08191672e-02f, -3.12858336e-02f, 1.32663369e-01f, 2.87450175e-03f, 4.49223854e-02f, -6.02206886e-02f, -8.03700984e-02f, 1.45605393e-02f, -2.77491324e-02f,
  2.23700572e-02f, 3.25876959e-02f, 5.56464829e-02f, 1.23723343e-01f, 1.04693353e-01f, 3.20230499e-02f, -7.52116367e-02f, -9.37095284e-02f, -6.90484717e-02f, -4.80329581e-02f,
  -2.19746139e-02f, 7.40487799e-02f, 6.46476522e-02f, 1.06843337e-01f, -1.18643135e-01f, 7.31883496e-02f, -7.12118819e-02f, 7.82756060e-02f, 1.75774079e-02f, -9.01738107e-02f,
  9.69506949e-02f, -7.91042969e-02f, 5.92257269e-02f, 3.94654945e-02f, 3.72177474e-02f, 3.59027684e-02f, 6.04839064e-02f, -6.69516549e-02f, 1.45466840e-02f, -4.97513190e-02f,
  -4.33147475e-02f, -2.50172578e-02f, 8.52854699e-02f, -1.37066888e-02f, 2.93788817e-02f, -8.34598988e-02f, -3.57274562e-02f, 2.77135111e-02f, -1.09773055e-01f, -8.05383399e-02f,
  -1.53692374e-02f, -9.43464190e-02f, 4.66006957e-02f, -2.80779023e-02f, 5.56777008e-02f, 3.59836891e-02f, 7.46671259e-02f, -2.69626882e-02f, 8.56283307e-02f, -3.05993464e-02f,
  1.09239481e-03f, 4.47767042e-02f, -1.01356149e-01f, 1.72426377e-03f, 4.18375842e-02f, -7.45485127e-02f, -1.33988410e-02f, -5.90912178e-02f, 4.35806699e-02f, -1.13186814e-01f,
  -5.83869629e-02f, 1.03367992e-01f, -5.47952242e-02f, -1.18253613e-02f, -5.04326001e-02f, 1.76241563e-03f, 4.78750505e-02f, 8.91581830e-03f, 8.52539167e-02f, 9.07640606e-02f,
  -1.78747587e-02f, 1.32807419e-01f, 1.15020297e-01f, -5.43664172e-02f, -1.16442688e-01f, 1.08724393e-01f, 1.32623672e-01f, 9.05680880e-02f, 4.49795425e-02f, 7.79620484e-02f,
  1.08868517e-01f, 1.19314760e-01f, 1.30184203e-01f, 3.68804336e-02f, -2.52502784e-02f, -8.59452114e-02f, 1.49682716e-01f, -2.25592889e-02f, 3.35065909e-02f, 2.12924276e-02f,
  1.16074979e-01f, 1.00195594e-01f, 2.05565666e-04f, -1.07526302e-01f, -6.82126656e-02f, -1.82543148e-03f, -7.44832866e-03f, 2.84690820e-02f, -9.18316245e-02f, -1.37557432e-01f,
  5.18715680e-02f, -2.51665097e-02f, -9.54531133e-02f, -9.24169719e-02f, 3.34336460e-02f, -1.11082152e-01f, 3.58395651e-02f, -5.33674955e-02f, -8.23102668e-02f, -2.35969312e-02f,
  -7.72627816e-02f, 2.97588557e-02f, -1.23192772e-01f, 1.35498166e-01f, 1.32596672e-01f, 3.83907184e-02f, 8.54294971e-02f, -1.17707059e-01f, 4.93006874e-03f, -3.96949984e-02f,
  -1.28314458e-02f, -7.83897117e-02f, -3.17955576e-02f, -6.69492558e-02f, 1.27597693e-02f, -8.69166180e-02f, 1.43142864e-01f, -7.40778372e-02f, -3.93375047e-02f, -7.62658380e-03f,
  1.02837756e-01f, 6.99025989e-02f, 1.16172403e-01f, -2.75533032e-02f, 8.09445754e-02f, 1.01996519e-01f, -9.28074121e-02f, -4.04900163e-02f, 7.37568662e-02f, 3.13739665e-02f,
  -1.74686536e-02f, 3.59625695e-03f, -8.95711966e-03f, -7.61688054e-02f, 8.53174329e-02f, 1.28105925e-02f, -3.88876647e-02f, -7.97110796e-02f, -5.26293628e-02f, -1.11918971e-01f,
  -6.50836974e-02f, -4.97338437e-02f, -5.43516688e-02f, 1.02955438e-01f, 1.17104277e-01f, 1.32924139e-01f, 8.06812048e-02f, -9.01436061e-02f, 1.11445682e-02f, 1.19474858e-01f,
  2.03124993e-02f, 6.55671358e-02f, -2.23195869e-02f, 3.88885774e-02f, 4.38735262e-02f, -9.65850241e-03f, 1.56641379e-02f, -9.06282291e-02f, -6.38126582e-02f, -7.94590116e-02f,
  -4.52378578e-02f, 8.46703947e-02f, -3.53849009e-02f, 8.86634514e-02f, 4.71725129e-02f, -9.31492522e-02f, -8.85661971e-03f, 4.30066213e-02f, -9.51073915e-02f, 9.41585600e-02f,
  -2.78240144e-02f, -8.39666799e-02f, 1.25414923e-01f, 3.22466791e-02f, 1.02365538e-01f, -2.88646389e-02f, 5.62726706e-02f, 4.17095348e-02f, 1.54228583e-01f, 5.13918623e-02f,
  1.35937303e-01f, 2.66909897e-02f, -4.69510667e-02f, 1.77336723e-01f, -5.33573441e-02f, 1.58963069e-01f, 1.79538041e-01f, 8.02586228e-03f, -5.18013723e-02f, 1.66471988e-01f,
  -1.00709304e-01f, -1.78877935e-01f, 1.01737276e-01f, 6.79544061e-02f, -1.52660813e-02f, 3.45738307e-02f, 8.49959329e-02f, -1.79330736e-01f, 8.47459286e-02f, 1.09249644e-01f,
  -1.36679709e-02f, 4.62958105e-02f, -1.74750239e-02f, -1.22390911e-01f, -4.24059443e-02f, -5.91777042e-02f, -7.13907480e-02f, 9.04216170e-02f, -1.31116986e-01f, -8.00489262e-02f,
  1.14513330e-01f, 5.67415683e-03f, -4.97891707e-03f, -3.91594395e-02f, 9.33667123e-02f, 1.01367638e-01f, -1.00668363e-01f, 2.59859860e-02f, 1.16694935e-01f, -1.86340749e-01f,
  -1.83467180e-01f, -7.38872141e-02f, -4.95726392e-02f, 1.23688489e-01f, 6.04352020e-02f, -8.43515620e-02f, -5.09575978e-02f, 2.29760054e-02f, 1.90720022e-01f, -1.19049408e-01f,
  -1.71801299e-01f, 2.29362160e-01f, 1.53787091e-01f, 1.41993225e-01f, -3.99132781e-02f, 1.11127868e-01f, 6.42439127e-02f, -4.40197140e-02f, -8.10419302e-03f, 1.16661869e-01f,
  -9.10790041e-02f, 1.05440177e-01f, -2.23023631e-02f, 1.91707388e-02f, 4.83588129e-02f, -7.19908848e-02f, 3.95588428e-02f, -3.31819355e-02f, -4.33660597e-02f, -3.13385502e-02f,
  -7.11977258e-02f, -8.75681564e-02f, -2.29922421e-02f, -6.86452957e-03f, -3.40443812e-02f, -2.39027422e-02f, -5.26861437e-02f, 1.42296582e-01f, -1.90726072e-02f, -5.59973195e-02f,
  6.21344149e-02f, 1.18566319e-01f, 2.60845665e-02f, 4.26264666e-02f, -2.05951463e-02f, -1.20436184e-01f, -1.02258757e-01f, 1.67067144e-02f, -1.07065640e-01f, 4.42852527e-02f,
  -8.86573493e-02f, -4.63833436e-02f, -9.36716273e-02f, -2.32452266e-02f, -4.56524901e-02f, 1.50026575e-01f, -1.42478039e-02f, 3.65446769e-02f, -5.87151013e-02f, 5.79049699e-02f,
  7.53311962e-02f, 1.27389669e-01f, 8.54770243e-02f, -4.41589318e-02f, -5.62501773e-02f, -2.99271289e-02f, -9.50964242e-02f, -9.01042074e-02f, -2.97668669e-03f, 4.40223031e-02f,
  -1.88074242e-02f, 8.28322396e-03f, 3.02268732e-02f, 4.47619073e-02f, 1.42082781e-01f, -6.12418226e-04f, 3.71491835e-02f, 2.36516283e-03f, -5.22445887e-03f, -8.84051993e-02f,
  -5.56923300e-02f, 7.04466477e-02f, 1.22725002e-01f, -2.93155015e-02f, -5.64872734e-02f, 5.27652800e-02f, 6.91436529e-02f, 1.02006994e-01f, -1.27511933e-01f, -6.73358142e-02f,
  5.99936843e-02f, -3.40455510e-02f, -5.86906299e-02f, 8.80950391e-02f, 7.92829394e-02f, -4.54714410e-02f, 2.92741992e-02f, 8.52110535e-02f, 1.63358480e-01f, -3.19778025e-02f,
  1.58239976e-01f, 1.70945317e-01f, 1.55072868e-01f, -6.96402043e-02f, 8.09422880e-02f, 1.21450216e-01f, -8.60264003e-02f, 8.65072478e-03f, 5.03789745e-02f, -5.51410057e-02f,
  -4.61137593e-02f, -9.32225510e-02f, 1.16990738e-01f, -5.55133037e-02f, 1.28900528e-01f, 6.07389323e-02f, -9.13839713e-02f, 6.28130659e-02f, -1.00219719e-01f, 1.13141336e-01f,
  1.60491660e-01f, -1.02669626e-01f, 4.21274416e-02f, -5.13112210e-02f, -1.27691984e-01f, 6.13766350e-02f, 1.04401536e-01f, 1.35250520e-02f, 5.35872355e-02f, -1.10837959e-01f,
  6.27461970e-02f, -8.13208595e-02f, -7.73014501e-02f, 7.74496561e-03f, -1.75545048e-02f, 4.08504158e-02f, 1.30316615e-01f, 2.57752035e-02f, -3.89795713e-02f, -3.87651660e-02f,
  -9.47076827e-02f, -1.01999089e-01f, -8.91217589e-02f, 1.07415959e-01f, -8.72490183e-02f, -2.07355805e-02f, 6.42485991e-02f, 5.36219813e-02f, 1.78657815e-01f, 2.01919928e-01f,
  2.18950793e-01f, 1.85663756e-02f, 6.56453567e-03f, 2.52076566e-01f, -1.11090234e-02f, -4.00567204e-02f, -8.80445316e-02f, 1.46275330e-02f, -4.07381989e-02f, 5.27150296e-02f,
  2.61064410e-01f, -1.14120357e-01f, 2.96939965e-02f, -2.08179161e-01f, 5.16456813e-02f, -1.01788295e-03f, 1.51062623e-01f, 2.44386904e-02f, 1.38747677e-01f, -4.42639031e-02f,
  -1.29943639e-02f, -4.11493927e-02f, 9.63068530e-02f, 2.88888037e-01f, -7.54190087e-02f, -9.35168006e-03f, 3.35466638e-02f, 1.87353089e-01f, 3.49241350e-06f, 5.00025414e-02f,
  -1.14708245e-01f, 1.51722431e-01f, 2.33559504e-01f, 1.16904721e-01f, 1.65266041e-02f, -8.69183056e-03f, -1.34760350e-01f, -1.17886752e-01f, 2.63548642e-02f, 1.09877422e-01f,
  -8.54206756e-02f, 9.77521464e-02f, 1.60031915e-01f, -6.09101877e-02f, -3.88772376e-02f, 1.24621347e-01f, -6.85749725e-02f, -1.04582280e-01f, -1.21787697e-01f, -1.19989589e-01f,
  -1.62925571e-02f, -9.56576988e-02f, -1.21543199e-01f, 1.70824409e-01f, 1.14741907e-01f, 7.23124966e-02f, -3.61572169e-02f, 1.41029924e-01f, -6.73943982e-02f, 1.48630545e-01f,
  9.61183757e-02f, -4.54420745e-02f, -8.96567330e-02f, 1.44571081e-01f, -7.19776526e-02f, 1.97072253e-02f, -2.62800027e-02f, 1.34406984e-01f, -2.13399455e-02f, 1.37247797e-02f,
  6.12460785e-02f, -2.23338287e-02f, 1.37649119e-01f, -5.86912259e-02f, 1.44379824e-01f, -1.13093734e-01f, 2.42602192e-02f, 7.75579363e-02f, 8.35253000e-02f, -2.22573355e-02f,
  -4.56306711e-03f, -1.08876497e-01f, 2.11346567e-01f, -8.01183060e-02f, -4.76913974e-02f, -3.23167928e-02f, 1.30302981e-01f, 1.71893090e-01f, 7.92369992e-02f, 1.18461043e-01f,
  8.47031698e-02f, 1.29671052e-01f, 2.16094889e-02f, 1.77550942e-01f, 1.18178479e-01f, 2.48442680e-01f, 2.04060420e-01f, 8.27742964e-02f, -8.65616873e-02f, 2.10092813e-02f,
  -3.21761891e-02f, 5.93516305e-02f, -1.00147717e-01f, -4.24023010e-02f, 3.81609355e-03f, 1.56154372e-02f, -5.75241521e-02f, -2.67754979e-02f, 1.09107010e-01f, 6.36069477e-02f,
  -5.53737991e-02f, -1.05806448e-01f, -7.71756023e-02f, -1.00957491e-01f, 3.07553690e-02f, 2.30541034e-03f, -2.06323043e-02f, -1.61278937e-02f, 3.02819591e-02f, -4.07043956e-02f,
  6.52514845e-02f, -6.47259578e-02f, -3.26852724e-02f, 8.94438196e-03f, -1.29750147e-01f, 7.04673007e-02f, -9.40645859e-02f, 6.96221590e-02f, 7.12439343e-02f, -5.55037297e-02f,
  2.62684524e-02f, 1.09532870e-01f, -7.94009306e-03f, -4.34092693e-02f, 4.28589657e-02f, 6.79988414e-02f, 9.77101475e-02f, 8.34824890e-02f, 6.08762018e-02f, 5.61810471e-02f,
  2.69663567e-03f, -4.70960774e-02f, 5.14791673e-03f, -5.25295399e-02f, 1.51314169e-01f, -6.72405288e-02f, 1.09403811e-01f, -1.24190174e-01f, -7.90671166e-03f, 2.07506516e-03f,
  1.52308643e-01f, 1.60182878e-01f, -6.50039241e-02f, -6.42108768e-02f, -3.44550610e-02f, -7.28145242e-02f, 9.81377903e-03f, 5.43862246e-02f, 4.36119176e-02f, 9.12861824e-02f,
  -7.03977868e-02f, 3.66337746e-02f, 3.35877873e-02f, 3.38650830e-02f, -3.41600291e-02f, 7.80682871e-03f, -5.93629107e-02f, 7.60539016e-03f, -2.30334923e-02f, 9.08094570e-02f,
  -4.42768596e-02f, -1.06943414e-01f, -2.99896877e-02f, 5.39103113e-02f, 8.30120668e-02f, 1.36826456e-01f, -7.67457113e-02f, -8.73407125e-02f, -2.76094675e-02f, -8.63942802e-02f,
  6.81503117e-02f, 1.65651515e-01f, 9.31680873e-02f, -3.09991408e-02f, -4.35920022e-02f, 4.74316739e-02f, 1.47630535e-02f, 8.57290477e-02f, -1.45263015e-03f, 1.20604426e-01f,
  -2.50928756e-02f, 3.29159424e-02f, 7.17560761e-03f, -7.83211142e-02f, -4.36971374e-02f, -2.27566506e-03f, -1.22410715e-01f, 9.99621674e-02f, 5.64447641e-02f, -2.98696607e-02f,
  1.82412807e-02f, -4.79830541e-02f, -5.37305996e-02f, 8.32034647e-02f, 2.85762902e-02f, 8.37808028e-02f, -1.35950651e-02f, -2.00422816e-02f, -5.68704866e-02f, -1.10910006e-01f,
  9.95856673e-02f, -7.19406232e-02f, -1.07971981e-01f, 1.15261123e-01f, 1.11082934e-01f, 3.41247916e-02f, -1.22794688e-01f, -7.20309392e-02f, 7.89589658e-02f, -1.99110378e-02f,
  -5.38557284e-02f, 1.43773491e-02f, -4.75339554e-02f, 1.21553302e-01f, -5.85075393e-02f, -9.68212932e-02f, 1.30640864e-01f, 9.78756696e-02f, 1.00905836e-01f, 8.86577219e-02f,
  9.57435220e-02f, 3.68855596e-02f, -5.45011200e-02f, -1.44654550e-02f, 1.19739715e-02f, -1.09762708e-02f, -5.75787909e-02f, -7.70849138e-02f, 1.30931795e-01f, 9.80861112e-02f,
  -5.90609349e-02f, -8.70876759e-02f, -3.24896351e-02f, -3.05020083e-02f, 7.94469565e-02f, 4.69055213e-02f, 2.16058362e-02f, -3.92978080e-02f, -1.19907975e-01f, 5.91073222e-02f,
  5.38823009e-02f, 8.87069255e-02f, 2.84980573e-02f, -3.86818089e-02f, 9.16059837e-02f, 1.23482443e-01f, -4.50572595e-02f, -1.98059548e-02f, 1.70038640e-02f, -7.55803660e-02f,
  2.06661075e-02f, 8.91620666e-02f, 9.33156163e-02f, -7.15748817e-02f, 1.41598597e-01f, 6.97976276e-02f, -4.93196324e-02f, -2.10783154e-01f, -1.13520719e-01f, -1.19768344e-01f,
  7.10161552e-02f, -5.19939736e-02f, -3.69059704e-02f, -5.56626879e-02f, 8.86551663e-02f, -7.41392421e-03f, 5.73656000e-02f, -3.61573324e-02f, 5.54888062e-02f, 1.79250479e-01f,
  1.19909845e-01f, -5.58699295e-02f, -8.71566311e-02f, -1.45022413e-02f, -7.53725395e-02f, 6.70847148e-02f, 1.08205639e-01f, -8.61965790e-02f, 4.14379761e-02f, 6.58361753e-03f,
  -8.51487964e-02f, 1.59037998e-03f, -1.61695272e-01f, 7.69203529e-02f, 1.46731719e-01f, -1.04285717e-01f, -1.10380925e-01f, 3.34407128e-02f, 8.77269208e-02f, 4.83672554e-03f,
  -6.69258786e-03f, -6.67011067e-02f, -4.42956984e-02f, 1.22056440e-01f, 1.18838988e-01f, 6.99178874e-02f, -1.08354732e-01f, 4.46118712e-02f, -2.93993577e-02f, -9.38340649e-02f,
  -9.44170728e-02f, -1.17344819e-01f, -2.41017863e-02f, -1.88961048e-02f, 7.57036805e-02f, -9.06403288e-02f, 3.73377502e-02f, -4.39089723e-04f, -3.54173593e-02f, 1.00862108e-01f,
  7.31716678e-02f, 5.28990664e-02f, 3.97114754e-02f, 1.18370406e-01f, 6.20007664e-02f, -2.82076448e-02f, -3.25115286e-02f, -5.30837141e-02f, -3.70028839e-02f, -6.74890652e-02f,
  -5.33115081e-02f, -5.48983514e-02f, 4.33045104e-02f, 3.84243652e-02f, 1.58928856e-02f, 9.11230519e-02f, -9.60823819e-02f, -1.13724144e-02f, -3.89516316e-02f, -9.03795809e-02f,
  -3.23386416e-02f, -6.02733046e-02f, -4.41786684e-02f, -9.85581055e-02f, -4.31934223e-02f, 6.03176281e-02f, 9.55522954e-02f, 2.96758395e-02f, -9.12942514e-02f, -4.21004258e-02f,
  1.03640780e-01f, 1.08527176e-01f, -1.31454781e-01f, -5.39066680e-02f, -1.05320528e-01f, 1.21006012e-01f, 1.25964075e-01f, -1.10758580e-01f, 5.17571345e-02f, -7.81851113e-02f,
  -8.30393881e-02f, 8.56982693e-02f, 2.10113171e-02f, -8.56954753e-02f, -1.52320154e-02f, -4.82544256e-03f, 1.12970158e-01f, -1.32851392e-01f, 6.31806105e-02f, -1.46615142e-02f,
  1.90827437e-02f, -1.08249053e-01f, -1.17046900e-01f, -8.21146090e-03f, 8.55123848e-02f, -3.33368480e-02f, -6.40039146e-02f, 1.39424927e-03f, -8.36862847e-02f, -9.79832187e-02f,
  -4.70689572e-02f, -1.28258213e-01f, 1.69105455e-02f, 5.63299470e-02f, 6.44382834e-02f, 1.07723117e-01f, 1.29064322e-01f, 1.80313334e-01f, 9.98387039e-02f, 1.09580621e-01f,
  -1.01931229e-01f, 2.22262532e-01f, 1.09891966e-01f, 9.58300978e-02f, 6.59770146e-02f, -2.05479011e-01f, -2.19978839e-01f, 3.92435752e-02f, 8.55727792e-02f, -1.50506780e-01f,
  -7.91496113e-02f, -1.85395494e-01f, 7.98347294e-02f, 1.15431800e-01f, 1.99969903e-01f, 3.90981808e-02f, 1.15622833e-01f, 3.73191655e-01f, 5.02168238e-02f, 1.03877127e-01f,
  -6.31179214e-02f, 1.89424843e-01f, -9.03819427e-02f, 5.30038103e-02f, -1.35618122e-02f, 2.98783898e-01f, 2.88559824e-01f, -2.55856495e-02f, 1.10584669e-01f, -1.09908633e-01f,
  3.95040959e-02f, 5.18818386e-02f, 6.07745117e-03f, 3.85830440e-02f, -1.68968081e-01f, -3.10121197e-02f, 7.21683651e-02f, -8.10147077e-02f, -8.15334469e-02f, -6.71767518e-02f,
  -9.00508314e-02f, -1.14968851e-01f, -5.25279902e-02f, 1.19264811e-01f, -1.17825516e-01f, 6.01163991e-02f, -4.65178788e-02f, -1.10138148e-01f, -5.30879945e-02f, 7.03504980e-02f,
  4.89763692e-02f, 9.34098810e-02f, 3.18570808e-02f, -6.88768029e-02f, 1.19309910e-02f, 2.89879479e-02f, 8.69011953e-02f, 6.01156354e-02f, 8.58143941e-02f, 6.87899143e-02f,
  2.35479727e-01f, 2.18879074e-01f, 2.84469277e-02f, 3.62793319e-02f, 1.48711488e-01f, 6.56436756e-02f, 1.34458929e-01f, 1.48400709e-01f, 2.06855461e-01f, 1.63007811e-01f,
  -8.25213548e-03f, -1.66442737e-01f, -4.60343026e-02f, 5.33675402e-02f, 2.17953667e-01f, -5.70593029e-02f, 1.23230278e-01f, -1.70544744e-01f, 1.69147119e-01f, 2.71650177e-04f,
  1.20959625e-01f, 9.35769081e-02f, 1.37493521e-01f, -5.10025136e-02f, 1.88046098e-02f, 9.75857750e-02f, 2.77818833e-02f, 1.86132446e-01f, -4.10220437e-02f, 2.07171887e-01f,
  -3.55171449e-02f, -3.00779510e-02f, -4.36055809e-02f, -1.57404796e-03f, 1.23014469e-02f, 2.67499946e-02f, -8.59391317e-02f, 8.07225481e-02f, 4.75713648e-02f, -1.37171134e-01f,
  -1.56814024e-01f, -3.84227484e-02f, -1.14905825e-02f, -9.63090137e-02f, 4.56557656e-03f, -5.01275957e-02f, 5.81848025e-02f, -6.25478476e-02f, 1.39001876e-01f, 1.03523582e-01f,
  -1.27451971e-01f, 1.00914747e-01f, -8.68343934e-03f, -9.93123204e-02f, 1.35782689e-01f, -8.24227035e-02f, -6.09472021e-02f, 4.68350090e-02f, -9.42529142e-02f, -3.43935005e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  6.40999749e-02f, 5.62676825e-02f, 5.36852032e-02f, 1.10379159e-01f, 4.86951694e-02f, 4.42850813e-02f, 1.18438259e-01f, 5.17579839e-02f, -1.01963861e-03f, 3.96573804e-02f,
  1.79464389e-02f, 1.54774636e-01f, 3.47642936e-02f, -7.36780986e-02f, -2.27859020e-02f, -5.88023663e-02f, -3.88267450e-02f, 4.41890359e-02f, 7.21555874e-02f, 1.57729432e-01f,
  8.84015858e-02f, 1.82875916e-01f, 1.56949043e-01f, 2.64047474e-01f, 1.73419770e-02f, -2.63630506e-02f, -4.83951345e-02f, 9.19563770e-02f, 4.56866510e-02f, -4.06461321e-02f,
  -6.06216788e-02f, 1.77735373e-01f, 1.61763638e-01f, 8.47251788e-02f, 5.48094027e-02f, -5.91847375e-02f, 1.01745576e-01f, 1.54777437e-01f, 1.69533230e-02f, 1.21097248e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  5.30855022e-02f, 1.65361688e-02f, -1.40736982e-01f, 9.04186070e-02f, 6.73524961e-02f, -3.94873098e-02f, -6.97413683e-02f, -4.57896739e-02f, -2.45978199e-02f, -1.18638827e-02f,
  -1.39193341e-01f, 7.00204968e-02f, 2.74655018e-02f, 2.94321179e-01f, -1.41112000e-01f, -1.63023070e-01f, 1.00075096e-01f, -1.33240014e-01f, -1.38644040e-01f, -1.31045505e-01f,
  -2.28536367e-01f, 5.47686145e-02f, -1.81107447e-01f, -6.75243735e-02f, 1.15448862e-01f, 4.61676084e-02f, 5.56317419e-02f, -5.85844591e-02f, -5.17080650e-02f, 6.19623847e-02f,
  8.61166120e-02f, 6.79186657e-02f, -1.55126378e-01f, -9.38632563e-02f, 1.35391444e-01f, 5.74855171e-02f, 2.43896171e-01f, 6.20061473e-04f, -8.27676058e-02f, 1.08833555e-02f,
  1.67431906e-01f, -1.49595290e-01f, -2.65673220e-01f, 1.03785442e-02f, 3.21426094e-02f, -7.42846802e-02f, 2.48201802e-01f, -2.89645821e-01f, 6.96607754e-02f, -2.56344736e-01f,
  6.77749291e-02f, 1.71201006e-01f, 7.53846914e-02f, 1.71345189e-01f, 1.54926348e-02f, 1.03957266e-01f, 4.38857302e-02f, 1.54656813e-01f, 9.17896479e-02f, -3.34064886e-02f,
  -1.87598933e-02f, 4.84553650e-02f, -1.67155527e-02f, 9.70066860e-02f, -1.02035545e-01f, -6.00431189e-02f, 1.37596801e-01f, -1.93289727e-01f, 1.92755237e-02f, 1.02831773e-01f,
  -8.87599662e-02f, -5.54001480e-02f, 3.30359749e-02f, -1.65450975e-01f, -5.14424630e-02f, 2.77506951e-02f, -1.81220949e-01f, -3.34854051e-02f, -7.56676123e-02f, 7.00531304e-02f,
  -3.27906967e-03f, -3.16097081e-01f, -2.29926109e-01f, -1.98927626e-01f, -1.58977747e-01f, -3.31738032e-02f, 1.12172835e-01f, -5.08104898e-02f, 7.64579400e-02f, -1.63925186e-01f,
  -1.03702828e-01f, 2.56379217e-01f, 4.67626192e-02f, 1.49664551e-01f, -1.25415623e-01f, -9.79976058e-02f, -1.54973671e-01f, 7.15261772e-02f, 2.59016067e-01f, 6.03833087e-02f,
  -8.26165546e-03f, 1.35094464e-01f, -1.30694243e-03f, -7.54322931e-02f, 1.23059452e-01f, -1.84738129e-01f, 1.70115322e-01f, 1.14831641e-01f, -2.38965861e-02f, 1.38174906e-01f,
  1.35078607e-03f, -3.63196284e-02f, 9.62079316e-02f, 1.15001753e-01f, 7.84727186e-02f, -6.00226298e-02f, -5.62071195e-03f, 2.18694806e-01f, 1.11348271e-01f, 8.29021737e-04f,
  -3.97755727e-02f, -1.06427096e-01f, 5.96800186e-02f, -3.43882665e-02f, -2.82880403e-02f, -6.11381717e-02f, -7.33762458e-02f, -1.90319121e-02f, 1.28473923e-01f, 1.46493331e-01f,
  1.26863599e-01f, -2.34874468e-02f, 1.08417533e-01f, 7.55482242e-02f, -9.82394889e-02f, 8.96987617e-02f, 1.05890676e-01f, 7.78593570e-02f, 7.93216825e-02f, 6.24972619e-02f,
  1.19434278e-02f, -6.02657571e-02f, 1.57314330e-01f, -1.56771526e-01f, -3.84734906e-02f, 2.77982317e-02f, -3.96015458e-02f, -1.82863712e-01f, 1.69384018e-01f, -1.18870802e-01f,
  1.64537027e-01f, 6.67220205e-02f, -1.01401702e-01f, -8.77352729e-02f, -4.23507169e-02f, -4.90427427e-02f, 9.36072245e-02f, 3.49372043e-03f, -1.09561637e-01f, 3.58233973e-02f,
  -7.86985978e-02f, 7.99109563e-02f, -7.84607157e-02f, -1.07485503e-02f, -2.04354212e-01f, 8.73814672e-02f, 1.26398727e-01f, -3.59972455e-02f, 1.09248951e-01f, 1.58106908e-01f,
  -5.62469773e-02f, 2.39526276e-02f, 1.77334286e-02f, 3.79023328e-02f, -9.63634849e-02f, 1.55985013e-01f, 7.89426342e-02f, 3.85039649e-03f, 1.07108980e-01f, 7.71343634e-02f,
  4.33482006e-02f, -7.03313798e-02f, -1.22679986e-01f, 8.16072822e-02f, 2.02576183e-02f, -1.34046245e-02f, 2.99935099e-02f, 3.44703235e-02f, -7.86477104e-02f, -8.71476755e-02f,
  1.25132993e-01f, -6.03982285e-02f, -9.53552723e-02f, -1.28897414e-01f, 7.09447116e-02f, -2.18300343e-01f, -1.56204343e-01f, 1.21131219e-01f, -9.77389738e-02f, -1.17050819e-01f,
  -2.84415092e-02f, -1.43157095e-01f, -1.15981072e-01f, -5.37880771e-02f, 1.07869893e-01f, -2.49288842e-01f, 1.98556155e-01f, 2.16474906e-01f, 7.07487613e-02f, -1.74245223e-01f,
  1.34246781e-01f, 1.18652679e-01f, -2.14589052e-02f, -2.23318161e-03f, 5.99283688e-02f, 3.33164707e-02f, 8.42010453e-02f, -3.39731686e-02f, -1.22160196e-01f, 1.52994409e-01f,
  1.46794200e-01f, -1.17186517e-01f, -1.03521980e-01f, 1.21556707e-01f, 1.19256526e-01f, -7.67173152e-03f, -1.69877941e-03f, -4.88445014e-02f, -1.51059777e-01f, -1.05433553e-01f,
  -8.80514979e-02f, 5.33688702e-02f, -3.68702896e-02f, -7.87515044e-02f, 1.59674242e-01f, 1.80686072e-01f, -7.44321123e-02f, 9.97888818e-02f, 1.30918890e-01f, 6.03835192e-03f,
  -1.05097428e-01f, 1.68819696e-01f, -7.36246184e-02f, 9.00238976e-02f, -1.49209360e-02f, 1.06077947e-01f, -1.05617344e-01f, -1.12027146e-01f, 3.71825062e-02f, -1.37571797e-01f,
  1.32042080e-01f, 3.42710316e-02f, 6.39870912e-02f, 1.31338472e-02f, -6.83547780e-02f, -8.58807117e-02f, -6.88196346e-02f, -1.42058998e-01f, 1.14946216e-01f, -1.54807570e-03f,
  7.94415176e-02f, 3.51858884e-02f, 4.32164595e-02f, -3.51610184e-02f, -8.85649119e-03f, 2.60575265e-02f, 3.14710662e-02f, 9.55595970e-02f, -8.22412372e-02f, -2.85811685e-02f,
  -1.21800266e-01f, 9.05945152e-02f, -1.25503791e-02f, -1.30553454e-01f, 2.07262244e-02f, 1.32216126e-01f, 5.67290653e-03f, -2.15693831e-01f, -7.00631514e-02f, 1.20816432e-01f,
  -6.69904873e-02f, -4.48842123e-02f, 4.14162315e-02f, 1.49961337e-01f, -8.56643096e-02f, 3.93410064e-02f, -1.59209535e-01f, 6.29138872e-02f, 1.33909374e-01f, -1.41784370e-01f,
  4.57312986e-02f, -7.89479837e-02f, -3.19151878e-02f, 9.07538012e-02f, -1.24531813e-01f, -1.25597000e-01f, 5.96486479e-02f, 1.84809994e-02f, 6.17164411e-02f, 1.96956158e-01f,
  -9.75158662e-02f, 1.18653990e-01f, -8.40744451e-02f, -4.92452197e-02f, 3.54656801e-02f, 1.53517276e-01f, -4.49961349e-02f, -1.15351811e-01f, 3.13089672e-03f, 6.64404929e-02f,
  -3.37065198e-02f, -2.55718157e-02f, 7.41711855e-02f, -3.76123972e-02f, 9.14325006e-03f, 6.13627695e-02f, 9.99866500e-02f, -1.46541253e-01f, -4.23706463e-03f, -1.88065067e-01f,
  8.99733976e-02f, -9.35769305e-02f, 1.04388567e-02f, -1.05840392e-01f, -9.04537216e-02f, -9.69218090e-02f, -4.64255661e-02f, 4.73826490e-02f, 1.56016827e-01f, 6.87334090e-02f,
  1.56885937e-01f, -7.77982697e-02f, -1.23135179e-01f, -3.20898145e-01f, -5.33338822e-03f, -1.01441573e-02f, -1.35429606e-01f, 8.80759507e-02f, 1.74353290e-02f, 1.06340580e-01f,
  1.24693625e-01f, -3.84571515e-02f, 1.56262398e-01f, -1.36688892e-02f, -4.55790944e-02f, 4.54602838e-02f, -2.23731518e-01f, -1.24118580e-02f, -6.07074937e-03f, -1.10729642e-01f,
  -1.31702289e-01f, 1.05161712e-01f, 1.81927487e-01f, 1.02698050e-01f, -4.31664735e-02f, 5.34857810e-02f, -2.58992821e-01f, -7.11355209e-02f, 9.45418477e-02f, 6.99725747e-02f,
  -6.23653419e-02f, 1.57378897e-01f, 1.67564735e-01f, 1.31356437e-02f, -1.21988310e-02f, 1.26990363e-01f, -3.34894300e-01f, 2.42357269e-01f, -8.72025080e-03f, 2.94189692e-01f,
  6.01007268e-02f, -1.80583030e-01f, 3.23576219e-02f, -1.62034944e-01f, 4.95555922e-02f, -1.55209586e-01f, -1.22227609e-01f, -1.30318150e-01f, 5.47097549e-02f, 3.38517409e-03f,
  -5.48357889e-02f, 5.03887273e-02f, -5.16270958e-02f, -1.70082580e-02f, 1.31132975e-01f, -1.31643033e-02f, 7.07997233e-02f, 3.80198006e-03f, 1.64129771e-02f, -1.02830771e-02f,
  4.92575020e-02f, 3.45121585e-02f, 1.01356670e-01f, 1.21252753e-01f, 3.08245774e-02f, 8.78241137e-02f, 3.14148143e-02f, 1.80259556e-01f, -1.15632690e-01f, -1.16295042e-02f,
  -6.35550544e-02f, 1.29360244e-01f, 3.23750004e-02f, 1.45319819e-01f, 1.15754552e-01f, -5.23331203e-03f, 5.65291680e-02f, -1.18799947e-01f, -1.19971395e-01f, 1.01811081e-01f,
  1.24248132e-01f, -4.11021449e-02f, -4.48583998e-02f, -5.93629479e-02f, 6.29222915e-02f, 4.70987260e-02f, 8.40338394e-02f, 1.20259739e-01f, -7.34846517e-02f, 1.57068390e-02f,
  1.20943300e-01f, 4.91205370e-03f, 9.86123458e-02f, 1.06889149e-03f, -5.59382513e-02f, 4.98234928e-02f, -2.97597229e-01f, -2.18193799e-01f, 6.81209890e-03f, 9.75939725e-03f,
  -1.63342431e-02f, -6.95620058e-03f, 1.16603546e-01f, -2.35381708e-01f, -7.95275867e-02f, -5.58453947e-02f, -8.97402093e-02f, -8.12080279e-02f, -1.34164989e-01f, 6.92047318e-03f,
  -3.09489649e-02f, 3.97056639e-02f, -1.15498807e-02f, -6.65641651e-02f, 7.35650137e-02f, 1.27677590e-01f, 1.89261422e-01f, 1.37141004e-01f, 7.06214160e-02f, 1.02738123e-02f,
  -1.26740187e-01f, 1.38702109e-01f, 1.33398116e-01f, -1.39452815e-01f, 9.46283042e-02f, -7.70027637e-02f, -3.25702503e-02f, -8.78246315e-03f, 1.25262216e-02f, -5.67449853e-02f,
  9.08276290e-02f, 1.34418190e-01f, -2.12435454e-01f, -2.08612397e-01f, -6.29183948e-02f, 1.04388058e-01f, -8.65660533e-02f, -1.69260666e-01f, 9.93441511e-03f, 7.81460032e-02f,
  4.56454745e-03f, -1.71151027e-01f, 5.41465655e-02f, -4.20314930e-02f, 9.94431004e-02f, 3.01686325e-03f, 5.76831028e-02f, 6.79085031e-02f, 3.55529301e-02f, 7.99267218e-02f,
  -1.02425711e-02f, 6.18750341e-02f, -4.82068807e-02f, 1.47550389e-01f, 1.60370260e-01f, 7.26850703e-02f, 9.81393270e-03f, 9.76967812e-02f, -1.32395208e-01f, -1.11314673e-02f,
  -2.66496092e-01f, -1.71667367e-01f, 4.74918447e-02f, 7.99737051e-02f, -2.19846323e-01f, -5.99721298e-02f, -4.51528914e-02f, -5.26874617e-04f, -4.41854335e-02f, 1.47266775e-01f,
  -1.15635142e-01f, -1.34320557e-01f, 2.14161947e-02f, 1.47341222e-01f, -1.86596423e-01f, 5.25770895e-02f, -1.82235725e-02f, 1.09969862e-01f, -6.89201280e-02f, -6.74777180e-02f,
  6.45715445e-02f, -1.77682117e-01f, 7.37629011e-02f, 1.12386495e-02f, -7.56312460e-02f, 6.18594326e-03f, 1.22521490e-01f, -8.19020718e-02f, 1.67904228e-01f, 4.11356539e-02f,
  -1.02878228e-01f, 6.07570633e-02f, -6.23693056e-02f, -5.42891882e-02f, 4.67681997e-02f, 7.41215795e-02f, 6.86987340e-02f, -1.88714162e-01f, 1.15723267e-01f, 1.01344153e-01f,
  -6.01311326e-02f, -8.14621374e-02f, -1.44212648e-01f, 6.94814846e-02f, 1.60746444e-02f, -5.93512878e-02f, 1.74382731e-01f, -6.14600852e-02f, 1.25868693e-01f, -1.32129744e-01f,
  5.72958626e-02f, 3.71339656e-02f, 3.58586535e-02f, -5.37728518e-02f, 2.61547789e-02f, 2.21532956e-02f, -1.77506879e-02f, -5.52019849e-03f, 6.18392639e-02f, 1.56649664e-01f,
  1.32704899e-01f, -1.13452964e-01f, -8.16906244e-02f, 3.67480377e-03f, -1.71477750e-01f, -1.80537865e-01f, -8.17373544e-02f, -1.67121701e-02f, 2.74518281e-01f, -7.36487359e-02f,
  -1.25678375e-01f, -2.39229739e-01f, 7.55252540e-02f, -2.40115393e-02f, 9.54260305e-02f, 1.98108107e-01f, 7.69479871e-02f, 9.88320634e-02f, 1.07510179e-01f, 4.50225435e-02f,
  4.38280217e-03f, -1.15330569e-01f, 9.85995531e-02f, -4.33023460e-02f, 1.04705408e-01f, 1.93366483e-02f, -1.16708860e-01f, 1.16283409e-01f, 1.72183916e-01f, 1.21911414e-01f,
  4.12670895e-02f, 1.79121986e-01f, -1.14009947e-01f, -3.94321373e-03f, 1.67187974e-01f, 1.50304571e-01f, -3.68068665e-02f, -6.65917844e-02f, -7.81399608e-02f, -2.31935024e-01f,
  6.60157949e-02f, 2.10840955e-01f, -6.96272254e-02f, -7.68055692e-02f, -1.74265772e-01f, 3.19431648e-02f, 5.66294752e-02f, -4.72907238e-02f, -5.43832891e-02f, 2.25315280e-02f,
  -1.15831882e-01f, -1.19248284e-02f, -2.33865544e-01f, -7.74921849e-02f, 1.14697978e-01f, -4.77631427e-02f, -1.96025923e-01f, 2.04684734e-02f, 1.81368351e-01f, -5.61430007e-02f,
  1.32937580e-01f, 4.66957465e-02f, 2.39154585e-02f, -1.06837288e-01f, -8.03610533e-02f, 6.44393116e-02f, -8.78087506e-02f, 1.17501676e-01f, 2.02291697e-01f, 1.79019272e-01f,
  9.11321715e-02f, 1.34908989e-01f, -3.51648927e-01f, 2.55435836e-02f, -3.16978656e-02f, 2.16612265e-01f, -1.03502020e-01f, -2.91671101e-02f, -1.28173709e-01f, -1.03662141e-01f,
  -4.39819992e-02f, -9.26786140e-02f, -2.78715163e-01f, 2.66845822e-02f, -3.58040980e-03f, -8.61724690e-02f, 1.78996436e-02f, -8.90698656e-03f, -1.77902311e-01f, -9.88160446e-02f,
  -9.92247686e-02f, 1.26705021e-01f, -3.34363207e-02f, 1.16075642e-01f, 5.90161122e-02f, -1.07520603e-01f, 3.50576267e-02f, -5.09107187e-02f, 7.19324276e-02f, -4.64080051e-02f,
  -8.94415826e-02f, -1.33266877e-02f, 1.60783365e-01f, 2.83985287e-01f, 1.85182095e-02f, -9.65850204e-02f, 1.92344859e-01f, 1.24320544e-01f, 5.11769950e-02f, 1.46333978e-01f,
  1.00823477e-01f, -3.17961723e-02f, -1.10032327e-01f, -4.55235168e-02f, -1.85251515e-02f, 1.53255150e-01f, 2.44660731e-02f, -4.89308033e-03f, -1.00858659e-01f, -5.50973602e-02f,
  2.09606178e-02f, -6.10834360e-02f, 1.20238155e-01f, 4.56571439e-03f, -1.02739386e-01f, -1.38676211e-01f, 1.88899755e-01f, 1.79328956e-02f, 1.03833474e-01f, -3.36070582e-02f,
  1.16514526e-01f, 7.65670612e-02f, -2.54046917e-02f, -1.10059328e-01f, -4.73670885e-02f, -6.86387792e-02f, 2.18538687e-01f, -1.91098332e-01f, 7.43193328e-02f, 6.03830665e-02f,
  -4.96497266e-02f, -4.56298962e-02f, -8.05197209e-02f, 4.17186916e-02f, -1.96619723e-02f, 8.49881098e-02f, 1.46909878e-01f, 4.55327965e-02f, 9.66232792e-02f, -5.09220101e-02f,
  1.25791416e-01f, -1.55009115e-02f, 4.53394018e-02f, 1.02337740e-01f, -1.07333958e-02f, 9.79406387e-02f, -7.71659464e-02f, 4.27632332e-02f, 8.78362730e-02f, -4.99006547e-02f,
  5.22326753e-02f, -5.17857820e-02f, 1.23598516e-01f, -3.56564894e-02f, 1.08282000e-01f, 2.80468892e-02f, -1.78009421e-01f, -8.62041339e-02f, -9.23551023e-02f, 1.12229204e-02f,
  -9.61224958e-02f, -1.08245812e-01f, -4.82895821e-02f, -2.50569116e-02f, -3.13400812e-02f, 5.77115305e-02f, -1.34562496e-02f, 1.19320914e-01f, -2.61109397e-02f, 5.40359458e-03f,
  -7.33019784e-02f, 5.01295477e-02f, 3.82872857e-02f, -5.76604041e-04f, 4.13694046e-02f, 5.21705374e-02f, -1.77875310e-01f, 1.18206069e-01f, -9.68387723e-02f, 8.63457993e-02f,
  -7.25256801e-02f, -1.15821600e-01f, 4.12002131e-02f, 1.00272715e-01f, -1.02589309e-01f, -2.94016674e-02f, -7.22883642e-02f, 4.95614111e-03f, -5.66559210e-02f, 1.97258256e-02f,
  6.39989451e-02f, 4.01433744e-02f, 9.56863314e-02f, -1.88678667e-01f, 3.17763798e-02f, -7.21062496e-02f, -7.43146986e-02f, 1.13353871e-01f, -3.42283994e-02f, -6.70291260e-02f,
  -1.63278505e-01f, 5.06799854e-02f, 4.42467667e-02f, 1.29612163e-02f, -1.37072220e-01f, 1.24843910e-01f, -1.89626038e-01f, -1.20714024e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -4.19175886e-02f, 1.71250075e-01f, 2.60751128e-01f, 1.56834751e-01f, 9.33524743e-02f, -1.95934534e-01f, 8.67060944e-02f, 1.10925008e-02f, 2.81643737e-02f, 1.93337947e-01f,
  2.67845076e-02f, 1.70828953e-01f, 1.97878346e-01f, 8.77793208e-02f, 2.55652547e-01f, 4.08565924e-02f, 1.33404046e-01f, 2.33407423e-01f, 9.53784585e-02f, 1.77331686e-01f,
  -2.78653532e-01f, 3.11653584e-01f, -1.19323678e-01f, -4.06042486e-03f, 7.09492490e-02f, 1.43795744e-01f, 1.23736098e-01f, -6.81010187e-02f, -7.33563770e-03f, 1.52718976e-01f,
  1.20689511e-01f, 4.06381823e-02f, 3.26636918e-02f, 1.04808338e-01f, -7.30673224e-02f, -2.17205491e-02f, 1.97095558e-01f, 1.86763018e-01f, 6.64304793e-02f, 6.23174347e-02f,
  1.51239514e-01f, 2.28412509e-01f, 3.55122946e-02f, 7.28128925e-02f, 2.02507246e-02f, 3.95612195e-02f, 6.26686633e-01f, 1.49153948e-01f, 4.45016958e-02f, 3.85373533e-02f,
  6.18447969e-03f, 1.37921199e-01f, 6.29966259e-02f, 1.98612541e-01f, -1.19791761e-01f, -9.03189853e-02f, 3.72148395e-01f, 2.66357422e-01f, 7.44659230e-02f, 1.57867167e-02f,
  -1.01232780e-02f, -7.95389563e-02f, 4.17404205e-01f, 3.52985263e-01f, 3.62557545e-03f, 9.92215574e-02f, 1.28271058e-01f, 4.35538739e-02f, 3.18293199e-02f, -1.07354193e-03f,
  -9.07484367e-02f, 1.00943521e-01f, 2.30448935e-02f, -8.90537072e-03f, -3.29750925e-02f, 1.08872406e-01f, 1.68432608e-01f, -8.48574191e-02f, 1.49510249e-01f, 1.03843905e-01f,
  1.51127130e-01f, 1.06436148e-01f, 1.23207159e-01f, 1.52238056e-01f, -9.94528681e-02f, -9.47303474e-02f, 4.24052216e-02f, -6.58227727e-02f, 8.67203064e-03f, -1.22392967e-01f,
  -2.71481760e-02f, -1.22372672e-01f, 4.93996330e-02f, 6.65968359e-02f, -2.96608768e-02f, 4.07861508e-02f, 1.03087820e-01f, -6.03732727e-02f, -2.73233559e-02f, -7.44224265e-02f,
  -9.17190984e-02f, -1.27461195e-01f, 1.38688227e-02f, -6.36128038e-02f, 1.09498128e-01f, 7.08576068e-02f, 7.86601827e-02f, 1.77249201e-02f, -4.28617448e-02f, 1.41209438e-02f,
  -1.37359221e-02f, 1.87522352e-01f, 9.10233185e-02f, 1.26291931e-01f, 6.39359131e-02f, 9.18212235e-02f, -7.50208423e-02f, -4.14581783e-02f, 2.45698038e-02f, -1.21023960e-01f,
  2.24440843e-01f, 1.19685546e-01f, 8.99114460e-02f, -1.34764299e-01f, -8.06760937e-02f, 1.06067851e-01f, 1.27059951e-01f, 1.30510673e-01f, -8.14678743e-02f, -4.00032327e-02f,
  -8.37614462e-02f, 1.12437293e-01f, 4.52970862e-02f, 3.43671208e-03f, -2.95568164e-02f, -1.71808188e-03f, 1.05613023e-01f, -7.22044855e-02f, -2.02445164e-02f, -6.73704892e-02f,
  -8.92150924e-02f, 5.70936203e-02f, 7.04275072e-02f, 1.11939475e-01f, 3.12298499e-02f, -1.12769650e-02f, 8.41246620e-02f, 1.11425854e-01f, -9.15333480e-02f, 6.86952053e-03f,
  5.07852063e-02f, -1.11511685e-01f, -1.10981733e-01f, -8.23520944e-02f, -5.71187586e-02f, -3.04872133e-02f, 5.67899272e-02f, -1.16365522e-01f, 1.19334161e-01f, -4.38926630e-02f,
  1.22871466e-01f, 1.36499787e-02f, -9.80764925e-02f, -1.46796601e-02f, 3.12535278e-02f, -2.61009801e-02f, -1.15111411e-01f, -4.18913849e-02f, -1.98239218e-02f, 4.50753421e-02f,
  5.22831827e-02f, 2.20887344e-02f, -1.20218240e-01f, -1.13359705e-01f, 1.37098283e-01f, 2.99446154e-02f, 6.26255721e-02f, -5.97159304e-02f, -8.28651786e-02f, -1.16355315e-01f,
  -2.40084417e-02f, -3.96118127e-02f, 8.61961469e-02f, 1.82027370e-02f, 7.44195562e-03f, 3.34948786e-02f, 6.27278239e-02f, 1.34576038e-02f, -4.75641638e-02f, -5.03490567e-02f,
  7.42173335e-03f, 1.93383396e-02f, -6.54295757e-02f, -1.87779777e-02f, 3.94898281e-02f, 1.55922294e-01f, 1.08186945e-01f, -5.88060431e-02f, 1.36462292e-02f, 1.67546552e-02f,
  9.77135822e-02f, 1.18546292e-01f, 7.04526901e-02f, 2.99348589e-02f, 9.09985136e-03f, -1.24162741e-01f, -1.91801284e-02f, 6.35405406e-02f, 3.92965712e-02f, -1.31115094e-02f,
  -3.34093794e-02f, 1.63610697e-01f, 1.94135338e-01f, -7.61821866e-02f, 5.01202047e-02f, 4.40193154e-02f, -8.21789652e-02f, -9.95915383e-03f, 1.22873057e-02f, -6.61119521e-02f,
  6.08347766e-02f, 2.93535348e-02f, -6.44998625e-03f, -9.78620127e-02f, 4.23156321e-02f, -1.09282374e-01f, -1.46341771e-01f, -2.26971954e-02f, 3.03212291e-04f, -1.04989009e-02f,
  1.93940029e-02f, -6.87594293e-03f, 7.47980997e-02f, 1.77774236e-01f, 8.52004811e-02f, -7.61078671e-02f, -9.42452252e-02f, -5.79217188e-02f, -1.17859259e-01f, 8.23335126e-02f,
  8.20172057e-02f, 1.45846844e-01f, 1.03393368e-01f, -1.18524618e-01f, 4.98941280e-02f, -4.40991260e-02f, -2.99847033e-02f, -1.07594036e-01f, 3.24823260e-02f, -2.76195928e-02f,
  -1.06314920e-01f, 8.88577476e-02f, 1.00303702e-01f, 3.54858600e-02f, 1.38377128e-02f, -3.95834967e-02f, -2.97372825e-02f, -8.90491083e-02f, -8.00969079e-02f, -1.04243822e-01f,
  -1.17685534e-01f, 4.00173441e-02f, 2.26835012e-02f, -2.90458556e-02f, -1.32764444e-01f, -1.49247706e-01f, -3.21029127e-02f, 2.01137736e-02f, 2.73713074e-03f, 5.46041615e-02f,
  5.21102697e-02f, 1.87138654e-02f, 7.36031914e-03f, -3.40946652e-02f, -1.32982321e-02f, -1.30304977e-01f, -5.08647040e-02f, 9.64544639e-02f, -5.50437160e-02f, 5.26405424e-02f,
  -7.53091946e-02f, 1.09554790e-01f, -1.15591496e-01f, 1.36624798e-01f, 9.48759913e-02f, 3.65537740e-02f, 1.07811339e-01f, -2.55694930e-02f, -1.15778884e-02f, 8.44271854e-02f,
  1.25897359e-02f, 1.12760440e-01f, 4.60570417e-02f, -9.16941985e-02f, -3.60878296e-02f, -6.79044351e-02f, -7.70409554e-02f, 5.46334088e-02f, 1.31128162e-01f, -9.40592960e-03f,
  5.85938767e-02f, 4.22819890e-02f, -7.03565702e-02f, -7.08237439e-02f, 8.85733664e-02f, 8.50998703e-03f, -1.19404318e-02f, -1.06831878e-01f, 7.44051766e-03f, 1.20480128e-01f,
  -1.14506081e-01f, 4.48545702e-02f, -3.76635715e-02f, 5.63158691e-02f, -3.59220803e-02f, 9.88908485e-02f, -8.25322345e-02f, 3.73527477e-03f, -1.11050569e-01f, -1.07021958e-01f,
  -6.07768595e-02f, -3.01627303e-03f, -4.22017276e-02f, -2.80307364e-02f, 9.14380327e-02f, -4.94142249e-02f, -6.01235405e-02f, -8.19725692e-02f, -8.44383985e-02f, -1.13946959e-01f,
  -8.57127681e-02f, 1.19821787e-01f, 3.84493731e-02f, 2.82053258e-02f, 1.01926774e-01f, 1.34504989e-01f, 1.14743084e-01f, -1.16928574e-02f, -1.87669992e-02f, -4.82542627e-02f,
  -6.53090850e-02f, -7.41747543e-02f, -3.99644487e-02f, -1.12090126e-01f, 6.99832067e-02f, -9.48231071e-02f, 3.07521820e-02f, -8.57531354e-02f, -1.36499517e-02f, -6.83920681e-02f,
  -7.02613294e-02f, 3.57868187e-02f, 2.44278889e-02f, -2.84783598e-02f, -9.49989557e-02f, -1.00028358e-01f, 5.31385504e-02f, 1.02546751e-01f, 6.41848100e-03f, -5.97472265e-02f,
  7.57520348e-02f, 4.51864824e-02f, -3.92420329e-02f, 8.10368583e-02f, -1.48389852e-02f, 8.27691481e-02f, 4.83805798e-02f, 3.03645041e-02f, 3.81545313e-02f, -1.16608525e-02f,
  5.52414656e-02f, -4.39362898e-02f, -7.91272745e-02f, -4.32537943e-02f, -3.96163762e-02f, 7.30919167e-02f, 3.21037173e-02f, -1.96737442e-02f, 1.10096022e-01f, -1.22199409e-01f,
  -1.29221797e-01f, -1.24218054e-01f, 1.00171730e-01f, -6.36181459e-02f, 1.25663280e-02f, -6.56515211e-02f, 4.63864505e-02f, -7.84981102e-02f, 7.46976212e-02f, 1.08764082e-01f,
  -1.48995280e-01f, -8.34248308e-03f, -6.01339713e-02f, 5.48137538e-02f, -1.07715903e-02f, -1.00774407e-01f, -1.61263183e-01f, -7.71598667e-02f, 1.29040346e-01f, 1.63092464e-02f,
  4.29586284e-02f, -4.61170822e-03f, -1.06379442e-01f, -5.63921258e-02f, 1.90798081e-02f, -1.16664432e-01f, -1.25955297e-02f, 2.59307344e-02f, 2.73761922e-03f, -9.24200341e-02f,
  6.45112768e-02f, 7.02408701e-02f, 1.35301888e-01f, 7.50228465e-02f, 1.09006308e-01f, 3.16959880e-02f, 6.40156865e-02f, 1.00242876e-01f, 7.76255131e-02f, -1.11839302e-01f,
  -1.17370382e-01f, 8.86325389e-02f, 4.40849289e-02f, 8.59923661e-03f, 1.15311027e-01f, -5.58851883e-02f, 3.49753231e-01f, 1.00471504e-01f, 7.00427070e-02f, 7.82902911e-02f,
  1.10843971e-01f, 1.57777648e-02f, 9.92127135e-02f, 2.58358955e-01f, -5.92778735e-02f, 4.00244892e-02f, -2.78515499e-02f, -2.90324949e-02f, -1.42233625e-01f, -1.40446737e-01f,
  -3.60557809e-02f, -1.80183593e-02f, -4.33703279e-03f, 9.48691592e-02f, -3.09381392e-02f, 4.23700437e-02f, -5.96000478e-02f, 9.74080637e-02f, -1.15749352e-01f, 5.00284657e-02f,
  -4.42576967e-02f, 2.80742813e-03f, -4.43499424e-02f, 1.64571777e-02f, 1.25235990e-01f, -4.55811508e-02f, -6.42304868e-02f, -7.13868216e-02f, 6.08068332e-02f, -9.77181420e-02f,
  -1.23149931e-01f, 1.42972590e-02f, 6.59693629e-02f, 1.46741956e-01f, -4.37192656e-02f, 6.94929510e-02f, 4.45651822e-02f, -8.09604451e-02f, -9.54799429e-02f, 1.01507522e-01f,
  -1.32217869e-01f, -9.00757909e-02f, -8.40768665e-02f, 4.31769004e-04f, 1.09602347e-01f, 7.36437142e-02f, 7.74970502e-02f, 5.41768484e-02f, 5.44172153e-02f, -1.03309236e-01f,
  1.50327077e-02f, 6.82797581e-02f, 6.19403683e-02f, -3.78793739e-02f, -3.36236991e-02f, -2.70269550e-02f, 6.94263577e-02f, -4.44675945e-02f, -3.39176059e-02f, -8.61652475e-03f,
  1.46241263e-01f, 1.40285075e-01f, -5.57318032e-02f, 1.49743352e-02f, 1.10773653e-01f, 1.58936977e-01f, 1.16732076e-01f, -4.09071334e-02f, -6.37886301e-02f, -8.57594609e-02f,
  1.13643752e-02f, 2.66344845e-03f, 7.33899772e-02f, 4.19797609e-03f, 5.68551496e-02f, -4.20387089e-02f, 1.28441095e-01f, 6.50160387e-03f, 9.29364469e-03f, 7.07695633e-02f,
  1.31305546e-01f, 1.48009956e-01f, 1.55681027e-02f, 1.64952442e-01f, 4.93701287e-02f, 1.58306748e-01f, 1.56609848e-01f, 1.36956468e-01f, -5.12308292e-02f, 4.86264415e-02f,
  1.01669215e-01f, 8.86678696e-02f, 7.97570497e-03f, 1.12519693e-02f, 9.74255055e-03f, -9.80164185e-02f, -1.76281184e-01f, -1.12047672e-01f, 5.78991249e-02f, -1.12135485e-01f,
  -1.25195682e-01f, 8.54976997e-02f, 7.55509064e-02f, 1.37340575e-01f, -8.79019052e-02f, -1.13607086e-01f, 9.71774757e-03f, 4.09954526e-02f, -8.24518129e-02f, 4.51993011e-02f,
  -5.31184673e-03f, 1.76068664e-01f, -7.89049342e-02f, -3.32227349e-02f, -6.12410977e-02f, -2.92195920e-02f, 1.18200302e-01f, -1.17306709e-02f, 2.39434645e-01f, 1.43603981e-01f,
  -3.30050141e-02f, -1.31711677e-01f, 1.18030123e-01f, -1.05069861e-01f, 1.06255420e-01f, -1.06284201e-01f, -1.09542504e-01f, -3.22279241e-03f, -2.17691213e-02f, -4.57128957e-02f,
  -2.80360729e-02f, -1.27624929e-01f, 1.49864014e-02f, 5.85771985e-02f, -3.76218781e-02f, 2.08588392e-02f, 4.78462502e-02f, 1.51447028e-01f, 4.57889214e-02f, 5.60087040e-02f,
  1.15302809e-01f, -8.95271897e-02f, -1.36889234e-01f, 5.12797460e-02f, -7.76236579e-02f, 1.53477520e-01f, -3.48739163e-03f, 3.46831940e-02f, -4.01850194e-02f, 2.16124076e-02f,
  -8.85614529e-02f, 1.41834825e-01f, 4.31803465e-02f, -7.89388362e-03f, -5.38718402e-02f, 1.14214662e-02f, 2.29668040e-02f, -4.92001064e-02f, 4.91186716e-02f, 1.03761189e-01f,
  1.24793261e-01f, 4.54868637e-02f, -1.00133687e-01f, -1.41118523e-02f, -1.41865462e-01f, 7.79053196e-04f, -9.95636880e-02f, -7.03559369e-02f, 2.19061021e-02f, 7.46173561e-02f,
  4.85091880e-02f, -1.69081520e-02f, -5.92529252e-02f, 3.16832289e-02f, 9.29244831e-02f, -6.09903708e-02f, 5.33722267e-02f, -6.82480186e-02f, 1.03336453e-01f, -7.97572285e-02f,
  1.55376509e-01f, -3.61281931e-02f, 5.94806336e-02f, 1.16794724e-02f, 1.02634087e-01f, -8.71588886e-02f, 1.40562937e-01f, -8.57146084e-02f, 1.73227504e-01f, -6.30513057e-02f,
  1.10382936e-03f, 4.41917703e-02f, 1.88813046e-01f, 1.39270663e-01f, 3.33511718e-02f, 4.31813262e-02f, 5.49545810e-02f, 8.44889507e-02f, 1.98809430e-02f, 1.52543694e-01f,
  -4.29766215e-02f, -2.73594819e-02f, 1.42871112e-01f, -1.94884315e-02f, 1.20948799e-01f, 8.16328079e-02f, -8.64799842e-02f, -4.12918516e-02f, 5.35410121e-02f, 1.13124296e-01f,
  1.63447693e-01f, 1.05825387e-01f, 1.34822190e-01f, 1.92924723e-01f, -2.99105328e-02f, 8.51426274e-02f, 1.37633756e-01f, 1.15988925e-02f, 1.06492832e-01f, 1.42663926e-01f,
  1.75376579e-01f, 1.28899425e-01f, 7.68601373e-02f, -1.45482525e-01f, 1.68536469e-01f, 1.02787323e-01f, -5.07728904e-02f, 2.25911304e-01f, 1.22120701e-01f, 2.16052905e-02f,
  2.81624794e-01f, -1.40342012e-01f, -7.07380772e-02f, 1.80278957e-01f, -1.44443557e-01f, -1.75668411e-02f, -4.29802835e-02f, -3.60596739e-02f, -9.09812078e-02f, -1.36305183e-01f,
  -9.40234140e-02f, 1.85246646e-01f, 1.65533707e-01f, -1.06783777e-01f, -1.65709779e-01f, -5.35454899e-02f, -3.50002572e-02f, -2.64418740e-02f, 8.04086402e-02f, -9.59907919e-02f,
  -6.89439401e-02f, 2.43910491e-01f, -3.08087673e-02f, 1.17105484e-01f, -3.50373313e-02f, 1.06008574e-01f, -1.90036908e-01f, 1.30200744e-01f, 2.61406153e-02f, 1.63856104e-01f,
  3.23084556e-02f, -9.87549350e-02f, 5.64229675e-04f, -1.31236672e-01f, -8.34596064e-03f, -9.87263471e-02f, 1.46065047e-02f, -2.16769837e-02f, -2.11596657e-02f, -1.34591222e-01f,
  1.40432894e-01f, 6.44892752e-02f, 1.11489683e-01f, 3.13505195e-02f, -5.31038456e-02f, -6.37870282e-02f, 1.00521460e-01f, -2.18312908e-02f, -1.76651273e-02f, 4.26868275e-02f,
  -8.80278572e-02f, -1.23386264e-01f, -5.69632836e-02f, 1.03704063e-02f, -9.93083790e-02f, -8.53951573e-02f, 3.47155817e-02f, 1.08507395e-01f, 1.31999835e-01f, 9.09425840e-02f,
  8.59163404e-02f, 1.26648456e-01f, 8.41837563e-03f, 5.47818057e-02f, -3.76963206e-02f, 5.23787625e-02f, 9.72094238e-02f, -6.38788566e-02f, 1.08967587e-01f, 3.30169797e-02f,
  1.03878111e-01f, 1.22102037e-01f, 1.07999146e-01f, -9.52539742e-02f, -3.46113890e-02f, 5.17016761e-02f, -5.60342260e-02f, -4.18062322e-02f, 1.16435863e-01f, 7.51909614e-02f,
  2.64223246e-03f, -9.54557508e-02f, 1.23997159e-01f, 4.57541868e-02f, 3.98555137e-02f, -9.37294811e-02f, 7.14531913e-03f, 1.39468312e-01f, 6.76631778e-02f, 1.27631174e-02f,
  3.10869757e-02f, -6.83981478e-02f, -2.13927981e-02f, 6.36479780e-02f, 8.33850913e-03f, -3.30674835e-02f, -9.19864103e-02f, 1.31565742e-02f, 1.24444231e-01f, 6.24505207e-02f,
  -8.41658637e-02f, 1.29366964e-01f, -2.40870100e-02f, -9.94622782e-02f, 2.75673140e-02f, 9.14764702e-02f, 1.49365142e-02f, 1.01219825e-01f, 7.96988308e-02f, -6.73147291e-02f,
  6.68097883e-02f, 1.92750636e-02f, 2.08969153e-02f, -4.77279574e-02f, -7.16722235e-02f, 1.45233065e-01f, -7.15637654e-02f, 6.23858571e-02f, 1.15015231e-01f, 1.42217800e-02f,
  -1.07853599e-01f, -1.01003423e-01f, -9.31797549e-02f, -4.91856709e-02f, -9.48192924e-02f, -5.18119670e-02f, 6.14832416e-02f, 1.05264606e-02f, -4.65795696e-02f, 5.06269075e-02f,
  5.43084927e-02f, -1.27355261e-02f, 2.03762352e-02f, -9.47745368e-02f, -1.15777396e-01f, -7.44985491e-02f, 3.96938212e-02f, -1.56517811e-02f, 7.77712166e-02f, 7.91969746e-02f,
  -1.10744067e-01f, 5.10802828e-02f, -1.68780256e-02f, -6.10584579e-02f, 6.83101593e-03f, 1.02928609e-01f, -7.23902956e-02f, -1.01795286e-01f, -4.31410484e-02f, -9.38194171e-02f,
  -1.24283908e-02f, -4.80150208e-02f, -1.22304112e-01f, 4.68205055e-03f, -1.83408130e-02f, 1.55189648e-01f, 1.19122855e-01f, -1.20147534e-01f, 1.19878866e-01f, -8.38713273e-02f,
  4.05675061e-02f, 3.73000391e-02f, 9.10624638e-02f, 4.89476435e-02f, 8.24028626e-02f, 6.00623824e-02f, 1.13579333e-01f, 9.76977944e-02f, -7.01381117e-02f, 6.61216378e-02f,
  -4.75748144e-02f, 1.36337802e-01f, -1.54121835e-02f, 3.61776398e-03f, 4.94802482e-02f, 5.83056249e-02f, -1.63528696e-02f, 9.13889110e-02f, -9.91996080e-02f, -7.17092678e-02f,
  2.47330889e-02f, 1.21381342e-01f, -4.71116640e-02f, 2.36028433e-02f, -2.32757732e-01f, 1.33282645e-02f, -1.61203951e-01f, 1.28127038e-01f, -1.60281822e-01f, -2.15160735e-02f,
  -1.75682470e-01f, 3.09120752e-02f, 4.80424642e-04f, -8.18749815e-02f, -1.34195030e-01f, 9.37353373e-02f, -7.54475370e-02f, 8.29759091e-02f, -1.28050566e-01f, 1.61656737e-02f,
  -3.10772993e-02f, 1.58925459e-01f, -1.39586121e-01f, -2.73348540e-02f, -3.02068200e-02f, -1.47421241e-01f, 1.65621743e-01f, 1.31056249e-01f, 7.16748089e-02f, 6.85811192e-02f,
  4.75661680e-02f, -1.24029800e-01f, 1.01817518e-01f, -1.37725189e-01f, 1.63359091e-01f, 1.43183321e-01f, 2.57652928e-03f, 1.06190436e-01f, 1.36009261e-01f, 1.41537711e-01f,
  8.56108442e-02f, 7.76713341e-02f, 1.68887898e-02f, 1.25797819e-02f, 1.03528187e-01f, 9.01710019e-02f, -1.21828601e-01f, -9.37921181e-02f, -1.38492703e-01f, 1.65364090e-02f,
  1.16440855e-01f, -1.02693029e-01f, 2.40714308e-02f, -3.23558063e-03f, -1.15670688e-01f, 3.62751149e-02f, -9.00646746e-02f, 4.47404385e-02f, 4.81273234e-02f, 7.37872571e-02f,
  1.68832734e-01f, 5.55315102e-03f, 9.53182429e-02f, -4.08223234e-02f, 3.95019948e-02f, 1.85566917e-01f, -1.34818507e-02f, 8.02370608e-02f, -2.24445924e-01f, -3.08417808e-02f,
  -2.25016877e-01f, 1.42799959e-01f, -2.51406152e-02f, 7.56079331e-02f, 1.69325955e-02f, 2.74626426e-02f, -1.85108751e-01f, 5.47278151e-02f, 4.82473932e-02f, -1.68512195e-01f,
  1.36010274e-01f, -7.24401549e-02f, -4.51691896e-02f, 1.59994781e-01f, -3.48641090e-02f, 1.45604506e-01f, -4.43045087e-02f, -8.30829740e-02f, -6.35844246e-02f, 1.26104690e-02f,
  2.14126945e-01f, 1.20573372e-01f, 2.53206998e-01f, 7.47595727e-03f, -4.59512845e-02f, 1.70504469e-02f, 4.07686532e-02f, -8.29919130e-02f, 1.27251416e-01f, -6.66814968e-02f,
  9.67164859e-02f, -3.45278122e-02f, 5.29965013e-02f, -1.33105814e-01f, 7.74430260e-02f, -1.27623111e-01f, 7.62914866e-02f, 3.99413779e-02f, 4.26505320e-02f, 5.51138893e-02f,
  -1.28001589e-02f, 9.29547846e-02f, 5.07028401e-02f, -1.10456415e-01f, -4.35151532e-02f, 1.34797424e-01f, 3.48445661e-02f, -5.54528199e-02f, 4.46096472e-02f, -5.09526990e-02f,
  1.37261510e-01f, 2.15881065e-01f, 1.69441407e-03f, 2.34600738e-01f, 2.14594021e-01f, 7.93986917e-02f, 9.25889611e-02f, 2.08129823e-01f, 1.70303807e-01f, 2.27114275e-01f,
  2.38531724e-01f, 8.77860002e-03f, -1.31241679e-01f, -2.61378251e-02f, -9.87984054e-03f, -1.20356396e-01f, -1.07578523e-01f, 1.50236562e-01f, -8.14472884e-02f, -2.10976660e-01f,
  1.54677048e-01f, -1.61885723e-01f, 1.25967309e-01f, 2.10126132e-01f, -1.47819906e-01f, -7.27400482e-02f, -6.89157173e-02f, -1.39370903e-01f, 4.58234623e-02f, 9.18612406e-02f,
  1.03907973e-01f, 1.96672708e-01f, -7.40933418e-02f, 5.55769205e-02f, -2.82947049e-02f, 1.92245424e-01f, 1.36572167e-01f, -9.76361781e-02f, -1.20087139e-01f, -2.56538223e-02f,
  -1.16923392e-01f, 2.05305949e-01f, -1.89342663e-01f, -4.56765667e-03f, -6.28044382e-02f, 8.99140090e-02f, -2.27978393e-01f, 2.46466786e-01f, 1.65572584e-01f, -1.06014609e-01f,
  6.81305975e-02f, 1.14956377e-02f, -1.17986485e-01f, -4.78776358e-02f, -3.46183889e-02f, -7.97786638e-02f, -1.04958110e-01f, 4.89385054e-02f, -1.42053068e-01f, -2.75413925e-03f,
  1.54482782e-01f, 2.25252416e-02f, 4.28037755e-02f, -8.98489431e-02f, -6.86957985e-02f, -1.36944115e-01f, 5.58102429e-02f, 9.89206508e-02f, -1.10178031e-01f, -6.22041970e-02f,
  -8.09805468e-02f, 1.14369094e-01f, 4.54419926e-02f, -4.95432094e-02f, -9.54061188e-03f, 1.19118961e-02f, -9.48886946e-02f, -8.03554654e-02f, 1.77540511e-01f, 1.11095637e-01f,
  -9.92797241e-02f, -1.16382733e-01f, 5.33319777e-03f, 4.62924764e-02f, -8.93344954e-02f, 8.33244920e-02f, -1.11910719e-02f, -5.23635596e-02f, -4.14589643e-02f, 6.16320483e-02f,
  9.29112956e-02f, -2.68130079e-02f, 4.12992993e-03f, -1.29109442e-01f, -9.96604934e-02f, -2.23598760e-02f, 9.70694348e-02f, -5.88900745e-02f, 5.61262853e-02f, -9.58182737e-02f,
  -7.65977353e-02f, -8.11972097e-02f, -1.02598943e-01f, -3.61103937e-02f, 1.27844959e-01f, 6.31996021e-02f, 1.03246242e-01f, -2.42538135e-02f, -9.49691907e-02f, 4.34302818e-03f,
  -1.04857823e-02f, 1.49478748e-01f, 7.80342370e-02f, 4.32936028e-02f, -1.26466393e-01f, -2.66527012e-02f, 1.02163345e-01f, 8.61436948e-02f, 5.62340245e-02f, -6.62996247e-02f,
  7.29284659e-02f, 1.13232538e-01f, 8.26352555e-03f, 6.62921667e-02f, 1.01823241e-01f, -2.05019694e-02f, 3.95877473e-02f, 1.49903446e-01f, -5.99862747e-02f, 1.72008842e-01f,
  1.39058158e-01f, 7.97891021e-02f, 8.94443765e-02f, 2.16631085e-01f, -1.08975038e-01f, 1.76520824e-01f, 2.04940394e-01f, 6.16216548e-02f, 1.50546104e-01f, 1.82694662e-02f,
  -2.20204279e-01f, -3.38016659e-01f, -5.60726635e-02f, 1.33485511e-01f, -2.60438323e-01f, -1.40024021e-01f, -2.69285798e-01f, 2.39226571e-03f, -1.41535148e-01f, -5.96285537e-02f,
  -1.12470321e-01f, 1.39403358e-01f, 6.94737285e-02f, 5.37575632e-02f, -1.59163103e-02f, 1.91574261e-01f, 1.86702479e-02f, 6.57378659e-02f, -9.86866653e-02f, -7.75598809e-02f,
  -1.08835272e-01f, 3.36368792e-02f, 3.24777216e-01f, 1.88272506e-01f, 1.40598817e-02f, -1.07912742e-01f, 9.80317965e-02f, 9.38454419e-02f, -1.25009790e-02f, 9.18672234e-03f,
  3.15615982e-01f, 2.88588047e-01f, 2.90693082e-02f, 1.41930804e-01f, -2.42866315e-02f, 3.33351225e-01f, 1.61364987e-01f, -1.63618531e-02f, -2.72733215e-02f, 2.05517421e-03f,
  4.70215492e-02f, 1.84230104e-01f, -8.18560496e-02f, -3.23616453e-02f, -1.90642774e-01f, -7.20471963e-02f, -2.03130748e-02f, 8.87716115e-02f, -1.16712667e-01f, 1.16727084e-01f,
  -8.12056810e-02f, 2.25947201e-01f, 8.09901729e-02f, 4.39818874e-02f, 6.66792272e-03f, 2.28367224e-02f, 6.91232681e-02f, -1.38824396e-02f, 6.98424578e-02f, 1.28761321e-01f,
  9.30951349e-03f, 1.42228842e-01f, 1.19166169e-02f, -3.56880352e-02f, 1.68086048e-02f, 1.02439575e-01f, 1.16999775e-01f, -9.27674696e-02f, -7.82300159e-02f, 1.51789889e-01f,
  1.38445115e-02f, 1.03063926e-01f, 1.76339876e-02f, -7.17641711e-02f, -3.36915627e-02f, 1.37270219e-03f, 4.25249003e-02f, 6.73098713e-02f, -8.47604647e-02f, -1.22923411e-01f,
  4.19526622e-02f, -3.23499441e-02f, 1.81914456e-02f, 1.29283369e-01f, -7.03308284e-02f, -1.99434627e-02f, -4.92244549e-02f, 8.20584148e-02f, 1.81479212e-02f, -1.00434735e-01f,
  9.39948261e-02f, 1.00456432e-01f, 5.80457710e-02f, -8.32851510e-03f, -7.08178058e-02f, 1.18443020e-01f, -1.49000920e-02f, -7.45420903e-02f, 1.06656283e-01f, 1.60328269e-01f,
  -2.41927877e-02f, -3.00831180e-02f, -1.09765708e-01f, -3.24422307e-02f, 1.11187905e-01f, 1.22318380e-01f, 1.88759882e-02f, -9.99588743e-02f, 9.92741212e-02f, -8.93637445e-03f,
  6.31263778e-02f, -1.06975622e-01f, -5.35079883e-03f, 2.84362882e-02f, 1.11169033e-01f, -1.09013654e-01f, 1.04717158e-01f, 1.24117464e-01f, 2.60838941e-02f, 3.22676413e-02f,
  1.48982227e-01f, -4.35185358e-02f, -1.02995466e-02f, 1.59329902e-02f, 1.30971238e-01f, -4.95099016e-02f, 2.74038799e-02f, 1.41104273e-02f, -9.78146270e-02f, -7.42935911e-02f,
  8.06425735e-02f, -1.10451989e-01f, -1.20678172e-01f, -5.07871471e-02f, -1.56836569e-01f, -4.34092898e-03f, -2.22789437e-01f, 7.40640387e-02f, -9.53534916e-02f, 6.96590617e-02f,
  1.17333323e-01f, 1.04834847e-01f, -8.26610997e-02f, 2.42209490e-02f, -1.34812728e-01f, 1.79204434e-01f, 1.43486977e-01f, -2.39672642e-02f, -2.10931614e-01f, 4.31196056e-02f,
  6.72756657e-02f, 1.84069470e-01f, 3.40483524e-03f, 1.01943403e-01f, -5.53678460e-02f, 6.22586645e-02f, -2.15619542e-02f, 1.08589761e-01f, -4.54239361e-02f, -9.65125635e-02f,
  1.32266372e-01f, 1.56262338e-01f, 2.48966217e-01f, 2.58502513e-01f, 2.72072311e-02f, -1.76928654e-01f, 1.19341806e-01f, 1.07560039e-01f, 8.14426318e-02f, 4.41280715e-02f,
  5.40754460e-02f, 5.54716326e-02f, -2.07314510e-02f, 1.66976616e-01f, -6.47539087e-03f, 2.00100914e-02f, -9.94353071e-02f, 9.40097868e-02f, 1.46059379e-01f, 1.64456874e-01f,
  2.60887370e-02f, 3.56434211e-02f, 5.21526374e-02f, 4.66469303e-03f, -6.22094609e-02f, -3.87107618e-02f, 1.10699251e-01f, -6.79218695e-02f, 1.11947097e-01f, 1.20967098e-01f,
  -5.41700572e-02f, 7.13166781e-04f, 6.69888854e-02f, 1.43736359e-02f, 3.37935500e-02f, 4.23232019e-02f, -4.00418006e-02f, 1.16606094e-01f, 7.00403228e-02f, -7.28938207e-02f,
  3.91562805e-02f, 1.09176286e-01f, -4.85795625e-02f, -5.35757691e-02f, -7.76748033e-03f, 3.97891030e-02f, 1.80518590e-02f, 7.80542344e-02f, -9.46304202e-02f, 1.40998363e-01f,
  -6.95702247e-03f, -2.11463310e-02f, -6.66045584e-03f, 3.70950496e-04f, 2.50627659e-02f, -6.11206777e-02f, 1.93444818e-01f, 2.29842309e-02f, -3.90961505e-02f, -3.55765373e-02f,
  -3.81916091e-02f, 1.83440130e-02f, -6.29903302e-02f, 3.13388035e-02f, -2.62549017e-02f, -1.05446398e-01f, 9.23889205e-02f, -2.58097658e-04f, 8.59721601e-02f, -1.08956225e-01f,
  -2.01856308e-02f, 1.13864280e-01f, 2.70045679e-02f, 1.33884549e-01f, 8.91362578e-02f, -2.60004140e-02f, 6.69253170e-02f, 1.27688855e-01f, 1.01088189e-01f, -5.75350737e-03f,
  1.07959144e-01f, -1.15207516e-01f, -8.73422623e-02f, 7.20421318e-03f, 1.65254995e-01f, 5.99047774e-03f, 1.49680063e-01f, 4.35716137e-02f, 8.06038752e-02f, -7.04272985e-02f,
  1.59982726e-01f, 1.14932418e-01f, 7.41652697e-02f, 1.68483965e-02f, -8.40237290e-02f, 1.11159980e-01f, 1.69959903e-01f, -2.59751524e-03f, 3.36440653e-01f, 1.59772471e-01f,
  1.26079038e-01f, 1.17614772e-02f, 1.73631936e-01f, 7.93853775e-02f, 1.56430662e-01f, 1.37442793e-03f, 8.78134072e-02f, 6.49621040e-02f, -1.09939002e-01f, -3.68813090e-02f,
  -1.02193700e-02f, -1.70540079e-01f, -9.26711317e-03f, -2.26162329e-01f, 1.25026524e-01f, 5.92329688e-02f, 3.00940633e-01f, -5.52893244e-02f, -1.24066822e-01f, -4.14026305e-02f,
  -6.80382401e-02f, -3.69008780e-02f, -1.13353267e-01f, 8.54996666e-02f, -4.56735305e-02f, 1.25639588e-01f, 1.76430449e-01f, 8.67794268e-03f, 1.19707897e-01f, -4.66220155e-02f,
  4.17360179e-02f, 1.52659386e-01f, -1.89575776e-02f, 2.01693460e-01f, -4.94756959e-02f, -2.79965773e-02f, -9.73711982e-02f, -8.13221335e-02f, -6.66993037e-02f, -9.82414410e-02f,
  1.68602780e-01f, 1.01756759e-01f, 1.43339917e-01f, 1.02760263e-01f, 1.83444768e-01f, 3.56662995e-03f, 3.48700762e-01f, -1.33885026e-01f, -5.86678125e-02f, 2.22190574e-01f,
  2.11864989e-03f, -1.22315148e-02f, 2.00557575e-01f, 4.71985154e-02f, -6.65393695e-02f, 8.04578140e-02f, 1.07618198e-01f, 5.51581047e-02f, -2.41337027e-02f, 7.19405860e-02f,
  -2.33638749e-01f, -8.24602321e-02f, -1.84961900e-01f, 1.94650274e-02f, -1.72891930e-01f, -1.09076835e-01f, -1.70659781e-01f, -1.70313388e-01f, -1.73959807e-01f, -1.05630010e-01f,
  -8.53884406e-03f, 9.00801420e-02f, 2.54845023e-02f, 1.52220540e-02f, 2.92905029e-02f, 7.46600479e-02f, 1.31984858e-03f, 1.80566072e-01f, -1.92708243e-02f, 2.19981987e-02f,
  -5.45119271e-02f, -3.83008011e-02f, 2.29449365e-02f, -1.82845374e-03f, 9.68825445e-02f, 8.40853006e-02f, 1.64524559e-02f, -7.96397924e-02f, 7.47716278e-02f, 9.77728367e-02f,
  8.79480913e-02f, 2.13507675e-02f, 5.11108451e-02f, 1.39105827e-01f, 2.71106213e-02f, 1.48499817e-01f, 1.35640830e-01f, -3.75596918e-02f, 1.03165835e-01f, -7.81906117e-03f,
  -1.07064843e-01f, -1.57489954e-03f, -3.21928225e-02f, 9.92226303e-02f, -2.35651694e-02f, -6.32532611e-02f, -3.18754986e-02f, 3.04539986e-02f, -1.62391290e-01f, -8.96124169e-03f,
  -6.47851080e-02f, 1.85951620e-01f, 2.56432351e-02f, -4.27538864e-02f, -2.61599813e-02f, 3.92620489e-02f, -1.25402018e-01f, -5.84965609e-02f, -9.60157514e-02f, -7.16635510e-02f,
  -9.99384001e-03f, -1.25968546e-01f, -1.08736314e-01f, -6.63791671e-02f, 5.84095567e-02f, 1.18355332e-04f, 8.84842500e-02f, 9.46005583e-02f, -4.05437388e-02f, 1.63195264e-02f,
  9.91110504e-02f, 6.73817918e-02f, -4.46992703e-02f, -9.84883010e-02f, -5.53754345e-02f, -1.05975255e-01f, -9.40538421e-02f, -5.64751811e-02f, 6.81568608e-02f, 1.68804675e-02f,
  7.49216601e-02f, -6.59205019e-02f, -2.91635562e-02f, -4.45945114e-02f, -1.06217436e-01f, 1.33249136e-02f, -1.81163903e-02f, -1.11122392e-01f, -5.04061654e-02f, -8.94708037e-02f,
  7.75670707e-02f, -1.19208589e-01f, -3.32320631e-02f, 5.26689626e-02f, -5.12682647e-02f, -5.01685739e-02f, -1.69744082e-02f, 2.78961211e-02f, -1.03540152e-01f, 3.66217121e-02f,
  -7.80074373e-02f, -7.49816149e-02f, -3.22712660e-02f, 4.50548492e-02f, -5.22418283e-02f, -8.25100616e-02f, 7.36544952e-02f, -7.17216954e-02f, 6.79137558e-02f, -1.14408176e-04f,
  -7.15845227e-02f, -3.65905743e-03f, -1.24779247e-01f, -1.20790087e-01f, 7.39600360e-02f, 7.87901226e-03f, -1.10584073e-01f, -1.15870558e-01f, -8.94266833e-03f, -8.31244588e-02f,
  4.70033959e-02f, 1.31672204e-01f, 1.58135239e-02f, 7.37346411e-02f, 6.02045394e-02f, -6.89149424e-02f, -6.53450042e-02f, 1.23336099e-01f, 1.70329344e-02f, -7.15872347e-02f,
  -1.18466668e-01f, -5.25940545e-02f, -1.48016280e-02f, 7.48929083e-02f, 1.04979336e-01f, 1.17175303e-01f, 1.35597050e-01f, 7.97244832e-02f, -3.35844979e-02f, 4.39963639e-02f,
  -1.23514436e-01f, -8.18382725e-02f, -1.22280493e-01f, 2.10077558e-02f, 5.95166907e-03f, -5.24145141e-02f, 9.32665989e-02f, -5.44971414e-02f, 1.21691152e-01f, -5.47019131e-02f,
  7.45970160e-02f, 1.17364088e-02f, -1.20102484e-02f, -9.93661489e-03f, -5.71711138e-02f, 9.75085944e-02f, -1.21300302e-01f, 3.07808593e-02f, -6.88294172e-02f, -6.00797758e-02f,
  -8.49021897e-02f, 6.58335090e-02f, 5.71012981e-02f, 5.89466505e-02f, -1.15657553e-01f, 8.61293823e-02f, 8.77311155e-02f, 5.60406595e-02f, -1.15185216e-01f, -5.90835214e-02f,
  1.06604531e-01f, -4.55593541e-02f, 2.99586225e-02f, -1.08242102e-01f, 4.85050716e-02f, -6.73217922e-02f, -8.04813579e-02f, -5.84809184e-02f, 1.14043593e-01f, -8.94279927e-02f,
  5.38352542e-02f, 9.53931585e-02f, -6.94349632e-02f, -1.09712638e-01f, 5.57717644e-02f, 4.85639200e-02f, -8.97457451e-02f, 5.05535603e-02f, 1.35892987e-01f, -9.27005112e-02f,
  -5.97685240e-02f, 2.49901079e-02f, 3.93182151e-02f, -1.79065868e-01f, 6.05934933e-02f, 1.40202180e-01f, 6.42033443e-02f, 4.00813110e-02f, 6.47698343e-03f, -1.00005120e-01f,
  -1.55080125e-01f, 4.70953174e-02f, -1.24022707e-01f, 9.91424732e-03f, 7.57034719e-02f, -7.78661296e-02f, 4.90995236e-02f, 7.44058415e-02f, 1.55316010e-01f, -8.30783918e-02f,
  -3.50739136e-02f, -1.37338951e-01f, 1.62467316e-01f, 2.88058240e-02f, 1.65579125e-01f, 7.24329334e-03f, -7.17009827e-02f, 7.32306167e-02f, -2.47289538e-02f, -1.28303736e-01f,
  -1.11226887e-01f, 1.22118354e-01f, 2.85417706e-01f, 2.15314910e-01f, -1.21288203e-01f, -6.75394088e-02f, -2.40793768e-02f, 1.69575572e-01f, 4.77883443e-02f, 1.78482309e-01f,
  -5.99348992e-02f, -5.23834564e-02f, 4.24966812e-02f, -9.64633152e-02f, -8.63655880e-02f, -3.04419156e-02f, 6.05213679e-02f, -6.40777871e-02f, -6.72280876e-05f, -4.25246917e-02f,
  -1.32280529e-01f, 9.92835388e-02f, -1.71154067e-02f, 5.79667985e-02f, -3.63658667e-02f, 5.18507697e-02f, 4.64626290e-02f, -9.50684249e-02f, -5.36556058e-02f, -7.91661143e-02f,
  -7.60701299e-02f, -4.10010293e-02f, -3.49784642e-02f, 1.38747273e-02f, 8.00010338e-02f, -9.04125813e-03f, 1.97674707e-02f, 1.06404684e-01f, 1.26153931e-01f, 5.76079711e-02f,
  8.12644437e-02f, -5.59345484e-02f, 4.30733971e-02f, 2.37915106e-03f, 1.01680271e-01f, 2.93090916e-03f, -3.03831156e-02f, -7.02939406e-02f, -5.78390583e-02f, -7.24099055e-02f,
  1.14538163e-01f, 9.17026326e-02f, -4.34404947e-02f, -5.46266250e-02f, 1.27728179e-01f, 1.24828368e-01f, 3.96185555e-02f, 8.61841440e-02f, 5.40549457e-02f, 3.71020436e-02f,
  4.06363159e-02f, 1.14060909e-01f, 9.55567956e-02f, 3.71220335e-02f, -7.91996643e-02f, -4.26080301e-02f, -2.51405947e-02f, -5.12886047e-02f, -1.24642616e-02f, 1.30812153e-01f,
  -2.64868550e-02f, 1.13013804e-01f, 8.39805678e-02f, 1.50374338e-01f, -1.88152101e-02f, 9.56394672e-02f, -3.85121331e-02f, 1.20452438e-02f, 1.59092844e-02f, -7.57265016e-02f,
  1.33186162e-01f, 8.11020210e-02f, 5.37673458e-02f, 6.19295239e-02f, -6.27161637e-02f, 1.14209447e-02f, -4.51997668e-02f, -1.14549063e-01f, 1.38832599e-01f, -1.55122047e-02f,
  1.46153942e-01f, -7.26523101e-02f, 1.19023748e-01f, -1.58201810e-02f, 1.27466977e-01f, -7.38546625e-02f, 5.31000383e-02f, -6.21844307e-02f, 8.74244869e-02f, 9.98188853e-02f,
  -1.11213349e-01f, 9.47145522e-02f, 1.08106213e-03f, 4.76910472e-02f, -7.79186562e-02f, 2.23788191e-02f, -5.76043949e-02f, -8.26714709e-02f, -3.36826257e-02f, 1.73948288e-01f,
  -1.48137033e-01f, 9.34762433e-02f, 1.67383760e-01f, 5.49779907e-02f, 9.44546312e-02f, 9.65100015e-04f, 6.50826246e-02f, 1.89275965e-01f, -1.07695937e-01f, -1.01941347e-01f,
  1.05001770e-01f, 1.14933327e-01f, -1.29267266e-02f, 7.16576278e-02f, 8.14334676e-02f, 1.42365903e-01f, -1.08522043e-01f, 5.40788621e-02f, -1.04471363e-01f, -2.68831458e-02f,
  3.52142602e-02f, 8.35666433e-02f, 1.03731388e-02f, 8.17630142e-02f, 1.51586130e-01f, -1.98505707e-02f, -8.07278231e-02f, -4.25130799e-02f, 1.12532871e-02f, -7.33245462e-02f,
  1.08865194e-01f, 1.45317540e-01f, -5.79668805e-02f, 6.05078712e-02f, 9.36896950e-02f, 1.01460464e-01f, -2.88029853e-02f, -3.22533259e-03f, 2.55350284e-02f, 1.00281276e-01f,
  6.14816435e-02f, 1.82444140e-01f, 1.17769614e-01f, 1.13567919e-01f, -5.77796176e-02f, -8.50794837e-03f, -8.85029361e-02f, -5.70990741e-02f, -6.90841451e-02f, 2.97607444e-02f,
  6.41280413e-02f, 6.48680255e-02f, -7.14581236e-02f, -1.04279555e-02f, 7.98019022e-03f, -9.59021673e-02f, -3.99712734e-02f, -9.97173339e-02f, 3.51913460e-02f, 2.67150979e-02f,
  7.66882375e-02f, -1.14061505e-01f, 4.48481040e-03f, 6.30578101e-02f, -9.35287550e-02f, -5.33869490e-02f, -1.91795640e-02f, 3.00676990e-02f, -1.13331884e-01f, -2.10838038e-02f,
  -1.13245957e-01f, -1.21670114e-02f, 9.68544707e-02f, 7.16626197e-02f, -5.70912734e-02f, 5.47126047e-02f, 7.12018535e-02f, -1.08256869e-01f, 1.33528799e-01f, 1.05436459e-01f,
  -8.45267996e-02f, 9.74114388e-02f, 3.06605920e-02f, -1.97719242e-02f, -3.21389660e-02f, 1.68803763e-02f, -4.02286947e-02f, 1.32757485e-01f, 9.21912864e-02f, -7.13800788e-02f,
  2.08461843e-02f, -1.05454296e-01f, -7.63716698e-02f, 3.05872541e-02f, -5.32256104e-02f, 4.87573147e-02f, -9.54948664e-02f, 6.80669323e-02f, 4.91070226e-02f, -9.11445022e-02f,
  -8.86756778e-02f, -2.34597474e-02f, 1.08046062e-01f, -7.21261427e-02f, 2.95009445e-02f, -9.94749889e-02f, -5.53831495e-02f, 6.41767262e-03f, 1.61383748e-01f, 3.08318553e-03f,
  4.79472615e-02f, -1.42519325e-01f, 7.32293800e-02f, 1.11159600e-01f, 1.19127117e-01f, -3.07508111e-02f, -6.55577034e-02f, 2.20643878e-01f, -1.05892606e-02f, 1.40935227e-01f,
  3.29194143e-02f, 1.49214804e-01f, -4.73906100e-02f, 1.93921462e-01f, 1.74096957e-01f, 2.33863696e-01f, -1.30369216e-01f, 9.48141911e-04f, -2.17252821e-01f, -1.32750526e-01f,
  -3.51062156e-02f, 1.30843982e-01f, 7.20416242e-03f, 8.53284076e-03f, 7.10740387e-02f, -2.98377108e-02f, 1.43418700e-01f, -1.42922074e-01f, 3.16180587e-01f, 1.65736140e-03f,
  -1.09462127e-01f, -1.15156010e-01f, 2.36049369e-01f, -8.46987963e-02f, -1.45470882e-02f, 8.21161792e-02f, -4.53369226e-04f, 1.53497130e-01f, 3.64546895e-01f, 1.23122364e-01f,
  -3.03814467e-03f, -1.11562781e-01f, 2.09316704e-02f, 8.30536857e-02f, -1.63814232e-01f, 3.43735069e-01f, -6.56066090e-02f, -7.82105699e-02f, 2.12444272e-02f, -9.37203020e-02f,
  -1.16843343e-01f, 7.77480006e-03f, 5.67366667e-02f, 1.62734106e-01f, 2.90225856e-02f, 5.63447597e-03f, 1.26143456e-01f, 2.32195165e-02f, 2.90093869e-01f, -6.04565665e-02f,
  1.11465201e-01f, -5.97089007e-02f, -6.72864094e-02f, 6.32194337e-03f, -1.33500934e-01f, -4.95329052e-02f, -7.92848319e-02f, 4.50016651e-03f, 3.33113521e-02f, -2.61711963e-02f,
  -7.73463249e-02f, -6.19315654e-02f, -7.59801269e-02f, 5.47184795e-02f, 7.58582577e-02f, 1.41889796e-01f, -9.15678442e-02f, 8.01544115e-02f, 1.30595788e-01f, 1.17682092e-01f,
  -1.14024235e-02f, -6.35072291e-02f, -2.56838766e-03f, 7.76022300e-02f, -2.09228676e-02f, 3.72644365e-02f, 1.01159804e-01f, -3.29267569e-02f, 1.10936806e-01f, -1.61632262e-02f,
  -1.25187784e-02f, 3.56981345e-02f, 5.37589714e-02f, 5.37852459e-02f, 8.85839313e-02f, -2.39195880e-02f, 2.69151721e-02f, -1.22025952e-01f, 1.20057188e-01f, 1.21280007e-01f,
  2.62141768e-02f, -3.62474993e-02f, -2.67276261e-02f, -9.43932533e-02f, -1.18420601e-01f, -3.00416555e-02f, -4.46092337e-02f, 7.04627950e-03f, -1.68877039e-02f, 3.36335860e-02f,
  9.51153487e-02f, 5.51700313e-03f, 4.82966490e-02f, -2.24125218e-02f, -1.15727149e-01f, -3.70892510e-03f, 1.32774428e-01f, -4.38035317e-02f, 2.17650784e-03f, 7.69168511e-02f,
  1.20170228e-01f, -1.21539749e-01f, -9.61253718e-02f, -9.67331789e-03f, 4.41479906e-02f, 5.52615374e-02f, 1.11539811e-02f, -1.04947917e-01f, 1.12137176e-01f, 4.50869277e-02f,
  1.13772362e-01f, 1.39236413e-02f, -4.51597124e-02f, -8.56885463e-02f, -6.61084279e-02f, -3.49391811e-03f, -6.89992756e-02f, -7.78770596e-02f, 1.20250069e-01f, -1.39172092e-01f,
  8.11147168e-02f, 9.29656401e-02f, 2.29337777e-04f, 1.18784197e-01f, 1.45896915e-02f, -6.23859465e-02f, 2.09256075e-02f, -5.71610816e-02f, 1.20746173e-01f, 2.28199502e-03f,
  -4.41824272e-02f, -4.92077544e-02f, 9.83561948e-02f, 3.05759422e-02f, 1.37147829e-01f, -6.70426860e-02f, 7.86369964e-02f, 3.37045081e-02f, -8.72920901e-02f, -3.73497643e-02f,
  4.43761088e-02f, 9.20004994e-02f, -3.52199972e-02f, 6.12150319e-02f, 9.07575339e-02f, -9.14130509e-02f, -2.23943517e-02f, 3.80095392e-02f, -3.88219138e-03f, -6.24349043e-02f,
  9.53495875e-03f, 1.56441748e-01f, -1.04216188e-01f, -1.12849757e-01f, -6.62981942e-02f, -7.11814389e-02f, -2.48767696e-02f, 3.57002206e-02f, -2.57130573e-03f, -1.00363061e-01f,
  -6.89253435e-02f, 1.94729399e-03f, -2.25388054e-02f, -1.11344814e-01f, -2.01272592e-02f, 1.27450094e-01f, 8.93913805e-02f, 1.33898899e-01f, 1.95336919e-02f, -7.58254454e-02f,
  1.30317882e-01f, -3.22935246e-02f, 6.93237260e-02f, -1.98888392e-05f, 9.23932195e-02f, 7.00477511e-02f, -3.19558121e-02f, -1.80740133e-02f, -6.45932481e-02f, 1.19886890e-01f,
  -4.60452447e-03f, -1.55036766e-02f, 2.28646100e-01f, 1.68962374e-01f, -1.81813259e-02f, -1.67929139e-02f, 1.39649928e-01f, 5.44152409e-02f, -7.20346421e-02f, 1.32060200e-01f,
  -1.71580017e-01f, -1.14306644e-01f, -9.24528227e-04f, 2.69828476e-02f, 1.35276705e-01f, 4.36266698e-02f, -6.02629557e-02f, -1.80683676e-02f, -4.91499230e-02f, 2.78759114e-02f,
  9.60560963e-02f, 5.07193841e-02f, -1.56682096e-02f, 5.62704839e-02f, 1.49791390e-01f, 1.84107378e-01f, -1.13817289e-01f, 4.84346561e-02f, 1.27184197e-01f, 9.75356027e-02f,
  2.37581432e-01f, 1.37801409e-01f, 5.80045283e-02f, -6.25045523e-02f, 3.33795875e-01f, -4.66833301e-02f, -5.67472391e-02f, 1.39192179e-01f, 9.37901437e-02f, -8.07188973e-02f,
  1.06876642e-01f, 2.52790633e-03f, 7.36928359e-03f, -9.03391838e-02f, 2.23480165e-01f, 2.34404966e-01f, 1.20418094e-01f, 3.10613564e-03f, 1.20250933e-01f, -1.16212301e-01f,
  2.23833948e-01f, 1.07613377e-01f, -3.20666209e-02f, 1.27938047e-01f, -5.34024797e-02f, 4.47579920e-02f, 1.41093716e-01f, 1.52068228e-01f, -5.17852455e-02f, -8.49074125e-02f,
  1.60215553e-02f, -1.91083904e-02f, -1.63709577e-02f, 5.40848561e-02f, -1.19451761e-01f, -7.29690716e-02f, -9.32094827e-02f, -1.10163130e-01f, 1.18871331e-01f, -1.40849695e-01f,
  -1.19489968e-01f, -8.28609522e-03f, 7.99840614e-02f, 2.06185468e-02f, 1.76867656e-02f, -6.92141205e-02f, -7.07696453e-02f, 4.05039042e-02f, 3.74080613e-02f, -8.01630467e-02f,
  6.66185468e-02f, -4.36320230e-02f, 1.19608194e-01f, 6.99119493e-02f, -8.12984705e-02f, -7.71067217e-02f, 1.49159834e-01f, 1.54768592e-02f, -4.05712519e-03f, -1.14363551e-01f,
  -6.20324314e-02f, 6.41399398e-02f, 7.91896731e-02f, -2.51061898e-02f, 4.06877254e-04f, 4.80797142e-02f, 4.07521911e-02f, -1.39804818e-02f, 2.72580702e-02f, 1.79539651e-01f,
  -6.92684203e-02f, 3.28859612e-02f, 3.05455597e-03f, -6.31925389e-02f, -8.32866058e-02f, -9.60151628e-02f, -1.39122792e-02f, -9.52053517e-02f, -5.51972911e-02f, -3.86182666e-02f,
  -8.57399032e-03f, 3.83409448e-02f, 3.70120816e-02f, 3.71656090e-04f, -1.29391506e-01f, 3.50816697e-02f, 1.95854977e-01f, 8.96722777e-04f, 1.55549347e-01f, 2.06085473e-01f,
  -8.43829382e-03f, 1.72526807e-01f, 2.57542372e-01f, 7.78437033e-03f, 3.38755660e-02f, 9.23066959e-02f, 2.55680948e-01f, 9.91450101e-02f, -1.49087813e-02f, -2.57618338e-01f,
  1.80233166e-01f, -1.07920192e-01f, -2.14055032e-01f, 9.97303501e-02f, 9.68382508e-02f, 4.33923997e-05f, 1.75485864e-01f, -1.18955843e-01f, 7.29233846e-02f, 1.35345981e-01f,
  -6.36377707e-02f, -6.04840778e-02f, 7.15763792e-02f, 6.52958602e-02f, 3.73122208e-02f, 7.22200517e-03f, 2.99293250e-02f, 8.03887770e-02f, -1.31511977e-02f, 7.55985966e-03f,
  -1.68283045e-01f, -6.99152946e-02f, -1.20514825e-01f, 8.03193375e-02f, -1.05049700e-01f, -3.73432366e-03f, -1.21886902e-01f, 1.07452847e-01f, 4.65970375e-02f, 2.00600788e-01f,
  -1.15363270e-01f, 5.27085364e-02f, -1.59189358e-01f, 2.98291862e-01f, 1.20954998e-01f, 2.58263171e-01f, 7.17286393e-02f, -7.60804415e-02f, 6.16111271e-02f, -4.75202268e-03f,
  8.58646706e-02f, -2.61341874e-02f, 1.39354365e-02f, -9.91460830e-02f, -1.07409254e-01f, 5.20043559e-02f, -4.76500019e-02f, -3.58929969e-02f, -1.38763133e-02f, -2.23247930e-02f,
  1.57815456e-01f, -2.55141966e-02f, 1.24703825e-01f, 2.67217718e-02f, 2.55047753e-02f, -2.18489319e-02f, -4.54986580e-02f, 1.80293009e-01f, 5.72216511e-02f, 1.25039428e-01f,
  1.55555502e-01f, 1.32839996e-02f, -7.83167258e-02f, 8.19375645e-03f, -2.07594052e-01f, 2.08281837e-02f, -1.88361093e-01f, -1.05126612e-01f, -2.85936773e-01f, -1.55010417e-01f,
  5.14748394e-02f, 6.83142021e-02f, 4.13279310e-02f, 4.74707633e-02f, 5.70114292e-02f, 3.94379795e-02f, -1.19224293e-02f, 9.33275297e-02f, -8.48277360e-02f, 1.38611734e-01f,
  2.60326583e-02f, -7.14019313e-02f, -1.07765673e-02f, -1.37295827e-01f, 1.03769109e-01f, 2.62099743e-01f, 2.25115176e-02f, 6.36155382e-02f, 1.16650090e-01f, 9.20113847e-02f,
  3.93599086e-02f, -1.10063739e-01f, 6.63810596e-02f, -1.03283696e-01f, 1.11935273e-01f, 1.67229638e-01f, 2.00246498e-02f, 1.66256979e-01f, 1.26993909e-01f, -2.83621047e-02f,
  -9.18860137e-02f, -3.49943079e-02f, 5.51968478e-02f, 2.02253491e-01f, -5.73268905e-02f, -8.39294940e-02f, -1.03217632e-01f, 1.07067518e-01f, 5.20112403e-02f, -7.13269114e-02f,
  -1.61967874e-01f, 9.93008092e-02f, -6.11826256e-02f, 6.50575086e-02f, 2.65748054e-02f, 3.65873724e-02f, -1.02957010e-01f, 1.15774781e-01f, -4.17034067e-02f, 7.87717253e-02f,
  -1.16465762e-01f, -1.17303655e-01f, 1.82202924e-02f, -4.78482582e-02f, 1.29351035e-01f, -2.92153489e-02f, 6.43412098e-02f, 8.83606449e-03f, 4.40169536e-02f, -5.85954636e-02f,
  -1.35173008e-01f, 4.15752381e-02f, -1.60672665e-01f, -1.34679601e-01f, -1.00843519e-01f, -9.71211717e-02f, -3.03476583e-02f, 1.17465407e-01f, -6.46277368e-02f, -2.41043624e-02f,
  -5.32106459e-02f, -4.69728746e-03f, -3.76019739e-02f, -6.73387572e-02f, 4.97155041e-02f, 1.33363143e-01f, 3.01738810e-02f, -4.77969721e-02f, 1.88914031e-01f, 5.14004454e-02f,
  -2.19862983e-02f, -4.55485284e-02f, 5.68746515e-02f, 6.35573417e-02f, -1.15596848e-02f, 7.85788745e-02f, 1.25446856e-01f, 4.47280072e-02f, 1.40296221e-02f, 1.75514773e-01f,
  -2.68901922e-02f, 1.85122997e-01f, -3.73437703e-02f, -1.47331404e-02f, 4.11965661e-02f, 1.22008011e-01f, -2.94572618e-02f, 3.24108079e-02f, -1.81036685e-02f, -4.62294854e-02f,
  -7.35612661e-02f, 6.20047748e-02f, -7.88527578e-02f, -9.70482826e-03f, 9.09603611e-02f, 9.23323035e-02f, 6.15280904e-02f, -7.97349215e-02f, -8.32651630e-02f, 8.84061903e-02f,
  -1.06359506e-02f, 3.67999673e-02f, 1.09129384e-01f, -1.92141235e-02f, -1.10020787e-01f, -4.03724350e-02f, -3.84647846e-02f, 6.52800947e-02f, -1.00945421e-01f, -1.01378247e-01f,
  -2.42822785e-02f, 1.38220396e-02f, -6.67514876e-02f, -1.09522648e-01f, -1.14950314e-01f, 4.28097248e-02f, 2.64031310e-02f, 1.04697406e-01f, 5.99003471e-02f, -6.46242872e-02f,
  -2.84152050e-02f, 7.34154647e-03f, 1.79138519e-02f, -1.77169591e-02f, 2.67873686e-02f, 4.92702499e-02f, 8.08823779e-02f, -4.48208563e-02f, -1.09940797e-01f, -1.16097815e-01f,
  -4.54268679e-02f, 3.02757937e-02f, -7.40365982e-02f, -2.87396205e-03f, -6.55671656e-02f, -1.31372828e-02f, -3.71105969e-02f, -1.00554887e-03f, -4.81100008e-03f, 9.64395353e-04f,
  -4.78322245e-02f, -3.58301215e-02f, 1.04072474e-01f, -2.03256290e-02f, -4.43057455e-02f, -3.91097292e-02f, -8.37838948e-02f, -6.21728646e-03f, 3.19632515e-02f, -8.02550316e-02f,
  -9.66181420e-03f, 3.30705345e-02f, -1.05308905e-01f, 2.86417175e-02f, 6.32375851e-02f, -1.02326281e-01f, 8.93725306e-02f, 1.16933741e-01f, 1.06335662e-01f, -9.35082510e-02f,
  -8.87809917e-02f, 6.45491928e-02f, 1.76459029e-02f, -8.22406933e-02f, -8.66778493e-02f, -6.96336403e-02f, -7.93750212e-02f, 6.63342103e-02f, -2.88742613e-02f, -6.44211173e-02f,
  -1.03328913e-01f, 1.03048012e-01f, -3.72127667e-02f, -2.21904237e-02f, -2.88527168e-04f, -8.85414258e-02f, -6.46292269e-02f, 8.96862447e-02f, 9.87720639e-02f, 9.70852748e-02f,
  4.71677966e-02f, 2.41429955e-02f, 4.14334983e-02f, 2.60855760e-02f, 1.92410201e-02f, -1.00014403e-01f, -7.11623803e-02f, -1.61151756e-02f, -6.06159307e-02f, 8.04826468e-02f,
  -1.85968038e-02f, -7.44565502e-02f, -8.13824385e-02f, 5.77523336e-02f, 1.17325403e-01f, -1.09528370e-01f, -4.03581187e-02f, -5.90091310e-02f, 5.80636486e-02f, -5.02160192e-02f,
  1.05172835e-01f, -8.59367028e-02f, -8.03396329e-02f, 1.84968766e-02f, -1.08458906e-01f, 1.00487359e-01f, 7.77833834e-02f, -3.23921591e-02f, 9.31364372e-02f, -2.13222913e-02f,
  -7.70263821e-02f, 1.58984065e-02f, 5.97597137e-02f, 2.05451734e-02f, -1.30975414e-02f, 9.28261280e-02f, 3.04473285e-02f, -1.24779977e-01f, 4.85945791e-02f, 5.62944077e-02f,
  -1.88953932e-02f, 2.17854269e-02f, -1.07072838e-01f, -1.03005618e-01f, -8.67154151e-02f, -2.43411213e-02f, 1.11214794e-01f, 3.93413473e-03f, 1.27789393e-01f, 7.61235207e-02f,
  2.81308144e-02f, 5.78510836e-02f, 7.43439794e-02f, 6.01819791e-02f, -1.22531056e-01f, -9.22457799e-02f, 4.90127839e-02f, 2.96368059e-02f, 1.17552690e-01f, 1.61854967e-01f,
  3.19228284e-02f, -1.08940706e-01f, 4.16104123e-03f, -6.37732297e-02f, 4.81684767e-02f, 2.34625936e-02f, -1.08651720e-01f, 1.16244100e-01f, 6.75882818e-03f, -7.65631273e-02f,
  6.16651364e-02f, -4.31388915e-02f, 4.03970368e-02f, -2.89359912e-02f, -1.26447752e-01f, 7.45520145e-02f, -6.17138632e-02f, 3.38049829e-02f, 2.56674718e-02f, -2.40869168e-02f,
  -6.52112812e-02f, -8.59240964e-02f, 1.25373481e-04f, 9.35186669e-02f, 9.42147747e-02f, -7.15325177e-02f, 1.51356444e-01f, -6.27299249e-02f, -4.51025777e-02f, 1.06572859e-01f,
  7.29970858e-02f, 1.00156583e-01f, 1.66359201e-01f, 1.35601610e-01f, -4.84790839e-02f, -1.15374126e-01f, -6.86246082e-02f, -9.62608978e-02f, 9.16544273e-02f, 1.51055589e-01f,
  5.51801212e-02f, 9.48203821e-03f, 1.60867229e-01f, 1.26850992e-01f, -4.68745874e-03f, -4.32009585e-02f, -3.42362449e-02f, -4.43542190e-02f, 1.11946367e-01f, 2.97896173e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  -1.56316962e-02f, 7.34991729e-02f, 1.43697690e-02f, 1.13186017e-01f, -8.63467902e-02f, -3.53947654e-02f, 8.00592527e-02f, 1.01777665e-01f, -1.93344206e-02f, -8.84709135e-02f,
  1.22546792e-01f, -5.26529066e-02f, -9.13559869e-02f, 1.19423330e-01f, 1.13951959e-01f, 6.22488521e-02f, 1.52117848e-01f, 5.62274568e-02f, -2.12812349e-02f, 8.26059561e-03f,
  -9.97650549e-02f, 1.28426552e-01f, 1.52928367e-01f, -5.40953241e-02f, 4.42677550e-02f, -4.42158133e-02f, -1.70839578e-02f, 1.20736934e-01f, -5.72714731e-02f, 2.03069985e-01f,
  1.61634274e-02f, 1.43071637e-02f, 1.33529857e-01f, 1.41967118e-01f, 6.96703270e-02f, 1.78207815e-01f, -9.27085653e-02f, -7.70277679e-02f, -7.72921443e-02f, 1.12806030e-01f
};

// L3_fan_Wp (Shape: 12 x 64)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -3.36520463e-01f, 9.29128379e-02f, -2.18550302e-02f, 1.80259615e-01f, -6.00917973e-02f, -8.60975683e-02f, -6.11570105e-03f, -1.45336732e-01f, -1.22347124e-01f, -6.40198290e-02f,
  -1.11336365e-01f, -3.68800983e-02f, -1.79386660e-01f, -1.59806877e-01f, 3.73268537e-02f, 1.98021770e-01f, 8.65884125e-02f, 2.17582151e-01f, -7.44961575e-02f, -1.22570775e-01f,
  -1.35479979e-02f, -4.92206514e-02f, -4.19901684e-02f, -5.35236597e-02f, 3.95316407e-02f, 3.47457491e-02f, 1.21886864e-01f, 7.90378451e-02f, -3.43685150e-02f, 6.82875961e-02f,
  -6.56807274e-02f, -7.39651769e-02f, -4.98045459e-02f, 8.49725306e-02f, 1.01620629e-01f, -5.47078103e-02f, -2.77370550e-02f, 2.09872741e-02f, -7.13442340e-02f, -1.09164178e-01f,
  1.51687905e-01f, -1.47215351e-01f, 1.40993312e-01f, -1.49199620e-01f, 8.12499598e-03f, 1.07937105e-01f, -1.48734406e-01f, -1.76468287e-02f, -7.05352500e-02f, -5.43419421e-02f,
  -6.86528236e-02f, 1.82966422e-03f, -6.49469346e-02f, 2.43168920e-01f, 1.26590744e-01f, -3.46005596e-02f, 1.64832681e-01f, -1.29874989e-01f, 1.40889362e-01f, -1.37681946e-01f,
  -1.42737269e-01f, -6.69715032e-02f, 7.92906880e-02f, 1.39934614e-01f, -6.67127520e-02f, -1.86511233e-01f, -4.94661294e-02f, 1.65686838e-03f, -1.20370664e-01f, -2.27016389e-01f,
  -1.34171322e-01f, -7.96990171e-02f, -2.37005144e-01f, -8.32251161e-02f, 9.61598009e-03f, 1.75268650e-02f, 4.86173220e-02f, -1.44537821e-01f, -1.69657975e-01f, 7.81978518e-02f,
  -7.93871507e-02f, -4.97656129e-02f, 4.20799805e-03f, -3.81176919e-02f, 4.56869155e-02f, 3.60886231e-02f, 1.01957088e-02f, 6.44742846e-02f, 1.55205876e-01f, -4.24961373e-02f,
  -2.54583135e-02f, -1.01096258e-01f, 2.69051865e-02f, 5.25464676e-02f, -4.36643437e-02f, 1.77522972e-01f, -3.46395932e-02f, 1.07931077e-01f, -6.11727834e-02f, 5.75146312e-03f,
  -7.96346441e-02f, 1.22411937e-01f, 1.06801771e-01f, -1.93065003e-01f, 1.62335545e-01f, -2.08729226e-02f, -6.69726878e-02f, 7.17257783e-02f, -8.67071524e-02f, 9.93335545e-02f,
  -1.31024718e-01f, 8.49005133e-02f, -8.01391751e-02f, -2.98107099e-02f, 2.97613721e-02f, 1.66717380e-01f, -6.69082850e-02f, 1.33743882e-01f, 5.20438738e-02f, 1.07777573e-01f,
  1.95606768e-01f, -8.03324804e-02f, -7.74373114e-02f, -6.06156103e-02f, -1.20959967e-01f, 2.72770580e-02f, 1.13070816e-01f, -2.99551412e-02f, -6.62402660e-02f, 9.37138945e-02f,
  -5.45266550e-04f, 8.87020603e-02f, 6.10565357e-02f, 3.59667279e-02f, 1.67891994e-01f, 1.89941879e-02f, 1.57345012e-01f, 1.60888210e-01f, 7.81291202e-02f, 9.31589678e-02f,
  -1.59992233e-01f, 3.41855399e-02f, 1.45762697e-01f, -1.79583773e-01f, 7.71425217e-02f, 1.32167757e-01f, 1.19793177e-01f, -1.44034848e-01f, 3.98021005e-02f, 2.07365584e-02f,
  -2.32997432e-01f, 7.55834505e-02f, -1.64355919e-01f, 5.85764684e-02f, -4.92984317e-02f, 8.23386237e-02f, -1.57691296e-02f, 8.12951103e-02f, -1.42559800e-02f, -5.74452691e-02f,
  -8.03706050e-02f, -1.05790794e-01f, 1.37526482e-01f, 6.14182390e-02f, 1.57154016e-02f, 1.13001034e-01f, 4.76110652e-02f, 1.37450829e-01f, -2.30503585e-02f, 1.28570013e-02f,
  4.76762326e-03f, 1.09174684e-01f, -3.88745032e-02f, -1.16570197e-01f, 7.58062527e-02f, 2.19864920e-02f, 7.10939169e-02f, -2.73595061e-02f, -1.66530926e-02f, -4.12451588e-02f,
  3.40192579e-02f, -2.13315934e-01f, -3.12636197e-02f, 4.99234051e-02f, -2.20163375e-01f, 1.11758360e-03f, 9.88877937e-02f, 1.29653573e-01f, 6.86965212e-02f, 1.75422654e-02f,
  1.02790445e-01f, -3.30269188e-02f, -1.88004300e-01f, 6.22126125e-02f, 3.88526022e-02f, 2.03859899e-02f, 1.33691326e-01f, -1.43622965e-01f, 2.02298467e-03f, 2.89721414e-02f,
  -1.08494073e-01f, 5.34194000e-02f, 3.31894271e-02f, 5.00229560e-02f, 1.39522925e-01f, 2.35852644e-01f, -9.23905969e-02f, 1.40062347e-01f, 2.33180523e-01f, -1.30311608e-01f,
  -1.55238271e-01f, -5.89247718e-02f, 1.08594969e-02f, 2.28503700e-02f, -2.14925379e-01f, 1.34749055e-01f, -2.39171922e-01f, -1.56019822e-01f, -1.15973949e-01f, -2.07865778e-02f,
  -1.12550810e-01f, 1.93688795e-02f, 1.14524454e-01f, 7.09473565e-02f, 4.23269719e-02f, 2.93935137e-03f, 8.64648595e-02f, -1.76017284e-01f, -9.44740847e-02f, 2.29121715e-01f,
  2.08085507e-01f, -5.44978958e-03f, -3.98368835e-02f, 4.56377082e-02f, -1.78544134e-01f, -1.02457128e-01f, -6.04216047e-02f, -1.65316135e-01f, 7.94154257e-02f, 3.97273619e-03f,
  7.08665028e-02f, -9.01049078e-02f, -1.15937330e-01f, 1.04233688e-02f, 6.83707297e-02f, -5.42093702e-02f, -6.77057728e-02f, -1.51185498e-01f, 3.22507396e-02f, -5.08964509e-02f,
  1.92524381e-02f, 1.74634695e-01f, 6.76042885e-02f, 4.97679561e-02f, -8.21353421e-02f, -1.23878308e-01f, -3.87008116e-02f, 1.34855509e-01f, -5.56374416e-02f, 6.27084598e-02f,
  -1.12652883e-01f, -5.08006215e-02f, 2.07962263e-02f, 4.60424647e-02f, 3.96745875e-02f, -5.32040093e-03f, -1.12042308e-01f, 1.01300888e-01f, 5.10920994e-02f, 2.04388261e-01f,
  1.44124314e-01f, 4.19237129e-02f, 6.26492053e-02f, 1.18719712e-01f, -1.62040263e-01f, 3.32197286e-02f, -3.47371362e-02f, 1.70431942e-01f, -1.99186072e-01f, 9.43236426e-02f,
  -3.05784613e-01f, -1.91555023e-01f, -3.57984677e-02f, -6.38530701e-02f, -1.22093320e-01f, -1.32309228e-01f, 7.28079155e-02f, -3.13293487e-02f, 6.45189360e-02f, -2.20903121e-02f,
  -3.62278372e-02f, -1.36416957e-01f, -4.24164198e-02f, 1.07088700e-01f, 7.70014478e-03f, 1.85472772e-01f, -6.25004917e-02f, 1.25783265e-01f, -6.85884729e-02f, -1.11106656e-01f,
  -3.51241864e-02f, 3.59626338e-02f, 1.05456673e-01f, 4.70555425e-02f, -1.54885501e-02f, -1.39867980e-02f, -1.16844356e-01f, -2.86510233e-02f, -8.68136249e-03f, -8.80983621e-02f,
  1.39292739e-02f, 8.01779702e-02f, -1.24725200e-01f, 1.58687055e-01f, 1.50125116e-01f, -9.91606340e-03f, -1.75496060e-02f, -3.97464782e-02f, 9.40979943e-02f, 1.23027638e-02f,
  4.64124121e-02f, -9.16011408e-02f, 9.29827392e-02f, 2.48954613e-02f, 4.28099409e-02f, -9.32021439e-02f, 8.47112164e-02f, 7.83859417e-02f, 5.06559163e-02f, 1.18215896e-01f,
  -3.84181109e-03f, -4.31542099e-02f, 2.44517252e-01f, -1.43431261e-01f, -5.87049313e-02f, -5.64129651e-02f, -2.22092360e-01f, -2.08893880e-01f, 2.17918247e-01f, -9.78341550e-02f,
  1.68106243e-01f, -5.69407381e-02f, 2.94628322e-01f, 3.56543693e-03f, 3.46815437e-01f, -1.40957907e-01f, 8.34987387e-02f, 4.04198579e-02f, -1.29379481e-01f, 3.37027647e-02f,
  -1.37464598e-01f, 3.38792824e-03f, 7.35694766e-02f, 4.99652065e-02f, -1.17348127e-01f, -1.21916562e-01f, 3.16014886e-02f, -5.87331578e-02f, -2.25432105e-02f, 3.34524140e-02f,
  -9.93980840e-02f, -2.52737701e-01f, -1.74251646e-02f, 1.31744012e-01f, 1.38497323e-01f, -2.97034532e-02f, -9.23639759e-02f, -1.98223200e-02f, -6.25088662e-02f, -2.32219040e-01f,
  4.29672785e-02f, 1.02593206e-01f, 1.76505111e-02f, -8.65845680e-02f, -3.46550941e-02f, -8.81378278e-02f, 1.43151507e-01f, -4.38092202e-02f, -9.94064808e-02f, 6.28051907e-02f,
  -1.60682023e-01f, -2.53326427e-02f, -1.17341787e-01f, 1.62262678e-01f, -2.66693756e-02f, 5.31335943e-04f, 1.61305398e-01f, 5.76056950e-02f, 9.25050303e-03f, -5.63517846e-02f,
  1.18296491e-02f, 6.64250031e-02f, 4.40184996e-02f, 1.93844154e-01f, -1.34006832e-02f, 2.65204459e-02f, 1.72848076e-01f, -1.11760311e-01f, 2.93979384e-02f, -1.31655976e-01f,
  3.06796730e-02f, -9.58495513e-02f, 1.33655712e-01f, 1.00699142e-01f, 1.23464786e-01f, -2.05915511e-01f, 1.57157883e-01f, -1.02403015e-01f, 3.04828405e-01f, 7.92199224e-02f,
  -2.24615838e-02f, -1.03610195e-01f, -3.63487639e-02f, 1.16528131e-01f, -2.21787766e-01f, -6.48036674e-02f, -7.66439736e-02f, -5.10083698e-02f, -1.14930891e-01f, -1.14879057e-01f,
  1.06226525e-03f, -1.76094890e-01f, 1.23308711e-01f, -1.04146101e-01f, 3.81999761e-02f, -2.90855914e-01f, 1.44293875e-01f, -4.14989367e-02f, 1.52851343e-01f, 2.38648541e-02f,
  5.86988553e-02f, 8.71223062e-02f, 5.81261888e-02f, -2.24849448e-01f, -5.19544668e-02f, 1.19659662e-01f, 1.26629695e-01f, -8.42120051e-02f, -1.13892742e-02f, -1.10021839e-03f,
  7.57403225e-02f, -1.20260216e-01f, -9.27266479e-02f, -2.43634172e-02f, -9.82354283e-02f, -7.00156391e-02f, 6.58708736e-02f, 1.87300935e-01f, -2.66097009e-01f, 7.63671771e-02f,
  1.01056367e-01f, 1.04282908e-01f, -6.27921745e-02f, -5.97292408e-02f, -8.96867216e-02f, -1.78454846e-01f, -1.10601567e-01f, -1.92421243e-01f, -1.37232468e-01f, -1.38912588e-01f,
  -7.28247389e-02f, 1.04176112e-01f, -1.75191030e-01f, 2.03350782e-01f, 1.46949872e-01f, 7.77234808e-02f, -1.22677714e-01f, 9.87573806e-03f, -1.64188650e-02f, -3.11723426e-02f,
  -2.34026965e-02f, -1.22518264e-01f, 1.44875377e-01f, 5.88786453e-02f, -6.65075183e-02f, 3.79958116e-02f, -1.34800553e-01f, -4.24163677e-02f, 9.56709608e-02f, 3.08800880e-02f,
  -3.20828669e-02f, 6.91494048e-02f, -2.30990872e-02f, -6.34920001e-02f, 1.08183883e-01f, 9.08460170e-02f, -6.81731254e-02f, -1.90543666e-01f, 1.28340432e-02f, 6.02002740e-02f,
  -7.82600939e-02f, -5.50858192e-02f, 8.58778283e-02f, 9.70528796e-02f, 7.16297701e-02f, -5.29966764e-02f, -7.68319285e-03f, -7.57954940e-02f, -6.22900501e-02f, -2.72931121e-02f,
  4.89536002e-02f, 1.03944063e-01f, 1.25439689e-01f, 1.78532489e-02f, -7.10343868e-02f, -1.38910681e-01f, 3.25809978e-02f, -2.29598209e-02f, 5.91862947e-03f, -6.21287003e-02f,
  1.31221861e-01f, 8.77402425e-02f, 1.87572628e-01f, 7.51151587e-04f, -4.30282094e-02f, 1.66709214e-01f, 1.37038352e-02f, -2.83061471e-02f, -5.73638268e-02f, 1.65385008e-01f,
  -8.14043544e-03f, 6.71663582e-02f, -8.73267427e-02f, 4.36418988e-02f, -1.30500823e-01f, -1.42488748e-01f, 1.37794688e-01f, -3.60117182e-02f, -7.93743506e-03f, 3.32499184e-02f,
  3.11732665e-03f, 9.40878764e-02f, -4.93118204e-02f, 3.23069543e-02f, 1.82913572e-01f, 2.84112394e-02f, 1.01345494e-01f, 1.20466672e-01f, -1.16430130e-02f, -9.46938768e-02f,
  6.54066280e-02f, 2.98567079e-02f, -6.11469755e-03f, 7.05291852e-02f, -2.35822853e-02f, 1.80576369e-02f, 6.68821335e-02f, 4.58849482e-02f, -2.49547921e-02f, -1.79401234e-01f,
  -1.46556094e-01f, 1.56763375e-01f, 2.16914155e-02f, -1.56101704e-01f, -2.85321195e-02f, 6.17835037e-02f, 5.53633599e-03f, 6.09451011e-02f, -4.10739370e-02f, 1.09857298e-01f,
  -9.20037851e-02f, -1.25279399e-02f, 1.24069721e-01f, -1.11387089e-01f, 4.67315018e-02f, -6.60409331e-02f, -2.94233039e-02f, 9.51855332e-02f, 1.24768227e-01f, 6.97606876e-02f,
  -1.40206248e-01f, -7.36572519e-02f, 8.09183568e-02f, -9.22118500e-02f, -8.25361758e-02f, -2.90138740e-02f, -1.09479809e-03f, 1.15623556e-01f, 2.25655567e-02f, 1.73686426e-02f,
  -1.24404013e-01f, -1.66907668e-01f, 3.85932773e-02f, 1.18012831e-01f, -1.34256959e-01f, 1.35348707e-01f, 8.30547363e-02f, 6.98054284e-02f, 1.89356089e-01f, 7.70687032e-03f,
  -4.60011698e-03f, -9.16793495e-02f, -2.25791439e-01f, -1.47078827e-01f, 3.25560756e-02f, 6.63315728e-02f, 2.26113081e-01f, -2.39377499e-01f, 3.01164150e-01f, 8.58892202e-02f,
  3.27390015e-01f, -4.83229533e-02f, -1.78897229e-03f, 8.60328376e-02f, 3.26070450e-02f, -8.59590024e-02f, -1.72786027e-01f, -7.37091079e-02f, 1.53555721e-01f, -9.04031098e-02f,
  3.27630118e-02f, -8.39208364e-02f, -5.00396267e-02f, -4.13296605e-03f, -6.20257892e-02f, -3.67914215e-02f, 5.23761660e-02f, -2.06633314e-01f, 1.50319517e-01f, 1.86564445e-01f,
  1.14176571e-01f, 4.13135812e-02f, -5.64537868e-02f, 5.61583154e-02f, -8.28926265e-02f, -2.27532178e-01f, 8.25352669e-02f, 1.35027900e-01f, -4.82993312e-02f, -2.06217155e-01f,
  1.76107250e-02f, 4.13876772e-02f, 6.77887723e-02f, -5.20950966e-02f, -2.11652666e-01f, 8.70500728e-02f, -9.42207053e-02f, -1.30080655e-01f, 4.36722785e-02f, 1.26881659e-01f,
  -2.78404176e-01f, -2.48323083e-01f, -7.56134018e-02f, -7.39766657e-02f, -2.06638619e-01f, -2.12480694e-01f, 1.24064293e-02f, -2.73946106e-01f, -2.14950874e-01f, -2.78286964e-01f,
  -1.66352823e-01f, -2.24060535e-01f, 1.06636591e-01f, -1.87494397e-01f, -1.77743211e-02f, 1.49264663e-01f, -7.10156560e-02f, -3.30855139e-02f, -4.83251698e-02f, 5.55679500e-02f,
  1.25865832e-01f, -2.16012716e-01f, 2.47988895e-01f, -2.34638587e-01f, -3.91141288e-02f, 5.09821847e-02f, 1.34471267e-01f, -9.08224359e-02f, -8.27644393e-02f, -2.26841886e-02f,
  -3.12147066e-02f, 7.58968815e-02f, -5.96325248e-02f, 7.87106752e-02f, -1.03987150e-01f, 1.23509549e-01f, -3.80979404e-02f, -4.87594418e-02f, 2.80797184e-02f, -1.02107339e-01f,
  1.62549362e-01f, -2.79494464e-01f, -1.48963099e-02f, -7.81096965e-02f, -6.13910481e-02f, 1.02109060e-01f, -1.78800538e-01f, -9.02017504e-02f, 1.45183399e-01f, 4.20874655e-02f,
  1.34005830e-01f, 1.60835439e-03f, 2.20036600e-02f, 1.05210699e-01f, 9.10279602e-02f, -1.05370224e-01f, 1.78633288e-01f, -1.26534887e-02f, -7.16525242e-02f, -1.02772273e-01f,
  4.46187854e-02f, -4.42130156e-02f, -9.72111523e-02f, 4.95773889e-02f, 2.03548089e-01f, 2.39821315e-01f, 1.43649444e-01f, -8.39008242e-02f, 1.73373237e-01f, 1.20515846e-01f,
  5.06784171e-02f, -2.35953405e-02f, 1.93917863e-02f, 9.34004188e-02f, 7.33982697e-02f, 2.12096423e-01f, 1.93341240e-01f, -1.58973900e-03f, 5.91163803e-03f, -2.36746177e-01f,
  -8.94388482e-02f, -2.31640756e-01f, 1.56256273e-01f, 1.72428250e-01f, 1.18147336e-01f, -1.43303767e-01f, 8.17100778e-02f, 5.00007048e-02f, 1.68131053e-01f, 8.12647957e-03f,
  -7.77644515e-02f, -5.72681613e-02f, -1.51066244e-01f, 7.27367923e-02f, -1.75348803e-01f, -1.58681810e-01f, 5.91826215e-02f, 6.96478188e-02f, -9.63748991e-02f, -8.38586837e-02f,
  1.04980424e-01f, -1.81178248e-03f, 5.50622568e-02f, 1.59223095e-01f, -2.81836838e-02f, -3.37742822e-04f, 3.96616906e-02f, -1.35336220e-02f, -2.86547784e-02f, -1.28559411e-01f,
  1.00535996e-01f, 6.90717027e-02f, -1.95279382e-02f, -1.91456914e-01f, -9.10244435e-02f, 9.65698361e-02f, 3.68543454e-02f, -1.75452366e-01f, -1.15640964e-02f, 4.40878682e-02f,
  -2.16845889e-02f, 7.88223650e-03f, 2.89512314e-02f, 5.84848151e-02f, -1.02504022e-01f, -1.08696237e-01f, -1.09590866e-01f, 9.56647173e-02f
};

// L3_fan_Wp_bar (Shape: 40 x 64)
const int L3_fan_Wp_bar_rows = 40;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  5.02535515e-02f, -6.34954646e-02f, 6.55165464e-02f, 8.75503123e-02f, 8.88657570e-02f, 3.20860445e-02f, 1.14111289e-01f, 2.98036672e-02f, -6.39815032e-02f, 1.77729741e-01f,
  7.30522424e-02f, -4.68958691e-02f, 2.95935661e-01f, 5.62705658e-02f, -3.93137289e-03f, -1.78388178e-01f, 3.74109894e-02f, -2.99205929e-01f, 4.51766141e-02f, -7.57539123e-02f,
  1.95245624e-01f, -2.78576702e-01f, 3.47262651e-01f, 4.91300374e-02f, 4.06454146e-01f, -1.95774734e-02f, 2.02622954e-02f, -1.48987055e-01f, 8.81445110e-02f, -9.49368551e-02f,
  -4.43470329e-02f, -5.51675335e-02f, 2.19601952e-02f, 1.04370147e-01f, -2.12576881e-01f, 2.07229555e-02f, -1.69802308e-02f, 6.73626224e-03f, 7.12581947e-02f, -2.43977606e-01f,
  1.00544460e-01f, 5.28141297e-02f, -3.40314806e-02f, 4.01535109e-02f, -5.52965738e-02f, 8.12295973e-02f, -4.55587022e-02f, -1.33318216e-01f, -4.59898189e-02f, 2.78380886e-02f,
  2.25664638e-02f, 7.43366405e-02f, -1.97044648e-02f, 2.09968597e-01f, -9.19795483e-02f, -8.12613070e-02f, 2.67094046e-01f, 3.79203893e-02f, -1.83294475e-01f, -1.13795891e-01f,
  -3.48088406e-02f, 3.86906392e-03f, -5.93527108e-02f, 9.75309983e-02f, -3.27083677e-01f, 4.87833694e-02f, 1.12286188e-01f, 8.41499716e-02f, -4.80631292e-02f, -3.02922577e-01f,
  4.30789031e-02f, -1.77424066e-02f, -9.03685540e-02f, -3.34734201e-01f, -6.17577955e-02f, 1.40048712e-01f, -1.18872803e-02f, 2.65164733e-01f, -4.81105708e-02f, 1.34548962e-01f,
  1.76143140e-01f, 1.03447467e-01f, -2.01067612e-01f, -2.31337607e-01f, -1.84011951e-01f, 9.57902968e-02f, -1.79376438e-01f, -6.04491048e-02f, -1.53384581e-01f, -3.21537890e-02f,
  1.12102978e-01f, 1.06484316e-01f, -1.18896648e-01f, -1.87870059e-02f, 1.74681842e-01f, -8.49865004e-02f, -3.36620025e-03f, 1.88328102e-02f, 8.62086341e-02f, -3.28904316e-02f,
  4.70186723e-03f, 1.73989460e-01f, 5.13275713e-02f, -2.20427960e-01f, 1.80575356e-01f, 2.71934152e-01f, -1.60710126e-01f, -1.75296620e-01f, 8.05974156e-02f, 7.76764825e-02f,
  1.36331573e-01f, -7.49401143e-03f, 1.34490281e-01f, 1.39510632e-01f, 5.77268042e-02f, 1.14636645e-01f, 9.55798775e-02f, 2.72732526e-01f, -2.54751220e-02f, -1.26788899e-01f,
  1.99360594e-01f, -1.04377098e-01f, 1.29091814e-01f, 5.37725724e-02f, -1.02171175e-01f, 4.69097942e-02f, -7.08452761e-02f, -1.35184288e-01f, -1.59632370e-01f, -1.04590051e-01f,
  9.03801247e-02f, -6.60945475e-02f, 5.97946979e-02f, -2.07623258e-01f, -5.70835210e-02f, -9.72035527e-02f, -2.35561542e-02f, -1.86231628e-01f, -6.38832897e-02f, -1.59264710e-02f,
  1.49305090e-01f, 7.66990632e-02f, -9.20516774e-02f, -4.52395342e-02f, -4.96936589e-02f, -9.71749723e-02f, -7.81907737e-02f, 3.29724047e-03f, 4.75051589e-02f, -1.11498691e-01f,
  -5.73487058e-02f, -3.29224765e-02f, 6.73071444e-02f, 1.26785547e-01f, -9.02573485e-03f, -3.99486311e-02f, -2.22722720e-02f, 1.07546844e-01f, -4.52719210e-03f, -4.50417176e-02f,
  -5.24153747e-02f, 1.60092235e-01f, -1.26684785e-01f, 7.41775474e-03f, -1.17543206e-01f, -6.85383901e-02f, 1.48962438e-01f, -1.91318050e-01f, 6.04874752e-02f, -1.23690933e-01f,
  -3.72477174e-02f, -9.78158694e-03f, 1.46721318e-01f, 8.68816227e-02f, 1.17283374e-01f, 5.34589924e-02f, -1.12527557e-01f, -1.31189048e-01f, -1.17431015e-01f, -2.27486156e-02f,
  1.07761426e-02f, 1.20613374e-01f, 5.88485487e-02f, 1.14699908e-01f, 1.66990191e-01f, 4.02735248e-02f, -2.21749041e-02f, -5.18762805e-02f, 8.48096237e-02f, -1.26077801e-01f,
  7.60349333e-02f, 1.63613319e-01f, -5.34375757e-03f, -1.41696140e-01f, -1.06217861e-01f, -8.54878724e-02f, 5.83345741e-02f, -1.65038511e-01f, 3.21011357e-02f, -3.26551534e-02f,
  2.16991622e-02f, -1.11696951e-01f, -6.63721785e-02f, 5.24721220e-02f, 9.97122973e-02f, 2.54240092e-02f, 9.84042790e-03f, 9.16892961e-02f, 6.23865463e-02f, 9.50779766e-02f,
  2.28269883e-02f, 8.29691440e-02f, -5.06538972e-02f, 6.09189160e-02f, 1.57711445e-03f, 5.07910252e-02f, 4.75006327e-02f, 9.70255136e-02f, -2.42493115e-02f, -1.26854539e-01f,
  -4.12657717e-03f, -4.53964584e-02f, 7.40601569e-02f, 4.09001820e-02f, -9.41514969e-02f, 1.51774855e-02f, 8.97838399e-02f, 3.74118648e-02f, -5.15038148e-02f, -1.10746622e-02f,
  5.03860787e-02f, 6.66549057e-02f, 6.77307695e-02f, -6.98814541e-03f, -9.08371340e-03f, 9.87358838e-02f, 3.13815512e-02f, -1.54502308e-02f, 2.29064580e-02f, 7.55264834e-02f,
  -1.19368359e-02f, 1.09882854e-01f, -2.13188771e-02f, -2.82865837e-02f, 1.27842620e-01f, 1.15806229e-01f, 6.76220506e-02f, 9.98070240e-02f, 2.68647932e-02f, -8.18485767e-02f,
  -1.21458523e-01f, 5.48125990e-02f, -1.10206351e-01f, -7.69048855e-02f, -8.04862455e-02f, 9.21121538e-02f, 1.97610199e-01f, 2.89723184e-02f, 6.01682924e-02f, 8.18613097e-02f,
  1.06308922e-01f, 1.00721024e-01f, 2.01894194e-01f, 2.53505081e-01f, 1.37146816e-01f, -4.74791303e-02f, 3.72109637e-02f, 1.76213309e-01f, -8.24127644e-02f, 1.78905949e-01f,
  1.87154964e-01f, -1.65142506e-01f, 8.80089030e-02f, 1.25018120e-01f, -5.37639596e-02f, 6.89661577e-02f, -1.35128975e-01f, 3.15445721e-01f, -3.55479181e-01f, 1.35028511e-01f,
  -1.80680439e-01f, 3.05259358e-02f, -1.29037693e-01f, -7.01486468e-02f, -9.17521566e-02f, -1.77323539e-02f, -1.03639722e-01f, -1.41842961e-01f, 1.75995350e-01f, 1.02957241e-01f,
  1.50216734e-02f, 3.88012789e-02f, -8.31174722e-04f, 2.46104777e-01f, -8.41003377e-03f, 2.55705357e-01f, 2.90359203e-02f, 3.29918474e-01f, -3.58566269e-02f, 3.37758213e-02f,
  -4.29766905e-03f, 5.23240045e-02f, 2.86051631e-01f, 5.82873523e-02f, -2.20985916e-02f, -6.17114864e-02f, 9.74934250e-02f, -3.80243827e-03f, -7.64457658e-02f, -1.55722886e-01f,
  -1.02535784e-01f, -1.11726619e-01f, -2.13867396e-01f, 3.78085747e-02f, 1.37926862e-01f, 3.06915790e-01f, 8.72468501e-02f, -2.73480471e-02f, -3.06802951e-02f, 2.74697021e-02f,
  7.06295371e-02f, 1.06187522e-01f, 2.31132973e-02f, 3.36228833e-02f, 1.20043993e-01f, -4.09145691e-02f, -9.22805592e-02f, -5.83216250e-02f, 2.14142930e-02f, 1.13986298e-01f,
  8.20034221e-02f, 2.38686986e-03f, -1.37456521e-01f, -2.30726093e-01f, 1.71887323e-01f, -1.30591497e-01f, 3.73811759e-02f, 1.52562752e-01f, 1.27926588e-01f, -1.06873378e-01f,
  9.65018477e-03f, 6.40179589e-02f, 4.41193357e-02f, 1.90360248e-02f, 1.00558072e-01f, 1.23739786e-01f, -1.09905258e-01f, 6.35897964e-02f, -1.00080125e-01f, -2.76584718e-02f,
  -9.22055542e-02f, -4.59057167e-02f, -1.16395161e-01f, 1.55384010e-02f, 2.25066692e-02f, 8.81528482e-02f, -7.50859231e-02f, -7.78023005e-02f, -4.08036709e-02f, 9.39660668e-02f,
  2.72041149e-02f, 4.95871268e-02f, 7.64168520e-03f, -3.25121805e-02f, 1.21621368e-03f, 9.42204669e-02f, -1.43638492e-01f, 6.47604242e-02f, 3.44347171e-02f, 2.57001743e-02f,
  7.24536926e-02f, 4.72379327e-02f, -4.46990617e-02f, 2.41673309e-02f, 2.57656518e-02f, 2.29297783e-02f, 3.42423469e-02f, 7.78664276e-02f, 2.19989762e-01f, 2.35283785e-02f,
  1.13473296e-01f, -4.73971106e-02f, -2.69197673e-03f, 3.80103327e-02f, 1.04515450e-02f, 3.49384099e-02f, -1.45828873e-02f, -4.35573654e-03f, 4.81218994e-02f, -1.53793842e-01f,
  -1.04036167e-01f, 1.63373500e-02f, -1.44334286e-01f, 1.15933735e-02f, 3.25275138e-02f, -8.04139301e-02f, -1.55533582e-01f, -2.06159413e-01f, -2.73062736e-02f, -1.78821944e-02f,
  3.23621766e-03f, -5.29500879e-02f, -1.99434124e-02f, -1.13090031e-01f, 4.91370857e-02f, 3.19758281e-02f, 2.07901090e-01f, -1.91482052e-01f, 3.04058462e-01f, 2.12742940e-01f,
  5.96977174e-02f, 2.78310366e-02f, -3.98333883e-03f, -6.59244657e-02f, 5.27163334e-02f, -4.09362540e-02f, -1.22355446e-01f, -3.14214900e-02f, 1.72094613e-01f, 5.33656869e-03f,
  -2.83140410e-02f, -1.04567342e-01f, -2.72132475e-02f, -1.17916204e-01f, -4.33783233e-02f, 1.54074840e-02f, -2.86887325e-02f, -1.64426956e-02f, 2.22237315e-02f, 3.04304719e-01f,
  -1.71452656e-01f, 8.49914476e-02f, 6.23330399e-02f, -5.14217243e-02f, -5.04056476e-02f, -3.01013459e-02f, -1.81802213e-02f, 1.10458389e-01f, 9.76118296e-02f, 1.17228352e-01f,
  9.81957987e-02f, 7.82524422e-02f, -6.72063008e-02f, -1.07205240e-02f, 2.39701453e-03f, -1.15389697e-01f, 5.32151274e-02f, 3.56472246e-02f, 3.12299907e-01f, 2.10738465e-01f,
  5.89394532e-02f, -6.22267649e-02f, 1.11666709e-01f, 3.37846756e-01f, 8.00271407e-02f, 8.23185146e-02f, 1.27849370e-01f, 3.17897081e-01f, 2.48915359e-01f, 1.43229306e-01f,
  3.10368091e-01f, -1.53759375e-01f, -2.00173073e-02f, -2.08166987e-01f, -1.22254491e-01f, -3.30763489e-01f, 2.50875384e-01f, 1.32517070e-01f, 2.49907985e-01f, -1.85460687e-01f,
  2.40589619e-01f, -1.51201067e-02f, 9.34355855e-02f, -7.97724351e-02f, -1.16064847e-01f, -6.91326484e-02f, -9.23043042e-02f, -1.41824946e-01f, -7.58149996e-02f, 1.10584788e-01f,
  6.99324459e-02f, 3.32413521e-03f, -1.10162072e-01f, -9.20930505e-02f, 9.10203829e-02f, 1.43320307e-01f, 3.06602428e-03f, -7.78679028e-02f, -6.44477010e-02f, 1.82269469e-01f,
  3.30919623e-02f, 2.07632437e-01f, 3.85944406e-03f, -5.36652617e-02f, 1.77842006e-01f, 4.56768041e-03f, 1.01660825e-01f, -2.68858578e-02f, -1.62400231e-02f, 1.97069645e-01f,
  -6.26374735e-04f, 1.09413117e-01f, -1.04816377e-01f, 5.06757013e-02f, 7.12582767e-02f, 2.26015486e-02f, -1.63356781e-01f, 1.85066611e-01f, -9.75606292e-02f, -3.82954627e-02f,
  -9.98258218e-02f, -9.99122709e-02f, 8.25579688e-02f, -1.22991269e-02f, -6.65457472e-02f, 1.01133592e-01f, -8.07397440e-02f, -1.16559841e-01f, 8.64152610e-02f, -1.17788509e-01f,
  -9.19621363e-02f, 3.51263769e-02f, -7.53125399e-02f, -1.15727047e-02f, 6.88183010e-02f, 3.64631601e-02f, 6.14020191e-02f, 6.01926260e-02f, 6.42846227e-02f, 9.69982818e-02f,
  -1.28317997e-02f, 1.20792396e-01f, -1.14944398e-01f, -1.18687898e-01f, -6.31604120e-02f, 5.98411672e-02f, -4.31050956e-02f, 6.04471825e-02f, 1.01493172e-01f, -8.58398899e-02f,
  -5.79933375e-02f, 4.52127727e-03f, 4.11972515e-02f, -7.93266818e-02f, -1.15216538e-01f, -1.03409000e-01f, 3.78433131e-02f, -8.61086249e-02f, -1.23852372e-01f, -1.38576021e-02f,
  -4.89101093e-03f, -8.87512863e-02f, -9.54902619e-02f, 1.08624599e-03f, -3.25117167e-03f, -4.00294997e-02f, 1.44533953e-02f, -4.01368253e-02f, -6.10959455e-02f, 1.84352398e-02f,
  9.93092880e-02f, -9.22432765e-02f, -1.00545727e-01f, -5.46729602e-02f, -7.35324919e-02f, -6.06597308e-03f, 1.09162509e-01f, 7.03881085e-02f, -1.27420044e-02f, -5.83357029e-02f,
  6.81213215e-02f, 1.24734104e-01f, 1.19346522e-01f, -2.84591429e-02f, -9.86065567e-02f, 1.10426135e-01f, 1.24589559e-02f, 2.02853590e-01f, -8.11213553e-02f, 1.54058352e-01f,
  1.17605664e-01f, 1.36299476e-01f, 1.67174473e-01f, 5.43961935e-02f, 1.32713452e-01f, -8.91179740e-02f, 1.27025917e-01f, 5.59662469e-02f, -1.55229777e-01f, 6.74846172e-02f,
  2.79337484e-02f, -7.47297145e-03f, -1.73547845e-02f, 1.56760573e-01f, 1.37398001e-02f, 5.86699210e-02f, -3.62453684e-02f, 2.74225026e-01f, -2.77587235e-01f, 1.16391689e-01f,
  -1.51575431e-01f, -1.60104763e-02f, 4.07362655e-02f, 8.16914737e-02f, -3.91603410e-02f, 8.28037690e-03f, -7.84372687e-02f, -3.79240625e-02f, -3.38414237e-02f, -3.13450210e-02f,
  1.84634715e-01f, 8.04616660e-02f, 7.06850067e-02f, 1.54647619e-01f, -1.42574413e-02f, 2.60116011e-01f, -1.03240153e-02f, 3.53722870e-01f, 9.28214788e-02f, 1.95489675e-02f,
  -1.13034748e-01f, -9.11552086e-02f, 1.20701037e-01f, -1.11894578e-01f, -3.04854731e-03f, -1.25409216e-02f, -5.60694337e-02f, -2.09009107e-02f, -3.58175933e-02f, -1.26019150e-01f,
  -1.37628481e-01f, -6.38558939e-02f, -8.41255933e-02f, 5.52789904e-02f, 2.99386889e-01f, 2.58482963e-01f, 1.84017539e-01f, -6.80481717e-02f, 4.79304306e-02f, 4.16433774e-02f,
  1.30541012e-01f, 1.72529206e-01f, 1.69149056e-01f, -8.66965204e-02f, 1.26916260e-01f, 1.44491211e-01f, 1.50439933e-01f, 9.14909691e-02f, 1.79431662e-01f, 1.80735007e-01f,
  8.95991102e-02f, 4.07878309e-02f, -1.68329611e-01f, -3.56870800e-01f, 1.63057670e-01f, 5.00805723e-03f, 1.40865713e-01f, 1.38712451e-01f, 2.10795358e-01f, -8.87865350e-02f,
  8.33593383e-02f, -2.70426348e-02f, 2.80622333e-01f, -4.77605052e-02f, 1.35400087e-01f, 1.47196591e-01f, 1.33105621e-01f, 1.31729946e-01f, -1.20280884e-01f, -9.28363577e-02f,
  -2.29314044e-02f, 5.06235845e-02f, -2.87031941e-02f, -1.62026525e-01f, 3.86095881e-01f, -4.14027534e-02f, -4.72369455e-02f, -6.61192238e-02f, -1.27840161e-01f, 1.94686458e-01f,
  -9.47839394e-02f, -1.56163871e-01f, 1.06826991e-01f, -2.45135635e-01f, 1.16843164e-01f, 3.83694321e-01f, -5.81440888e-02f, 2.93480288e-02f, 2.13692430e-02f, -6.05271049e-02f,
  -3.67984548e-02f, 4.73010801e-02f, -9.21204537e-02f, 3.91906440e-01f, 3.00101265e-02f, -7.26975352e-02f, 1.34921342e-01f, 6.41067401e-02f, 1.70777649e-01f, -2.37106279e-01f,
  -4.00755890e-02f, 1.05810590e-01f, -8.87290016e-02f, -1.10722825e-01f, 1.40224278e-01f, -4.53958437e-02f, -7.17305392e-03f, -8.80270451e-03f, 9.77167115e-02f, 1.32197216e-01f,
  1.26782611e-01f, 4.01049033e-02f, 4.28610407e-02f, 7.28086829e-02f, 1.12799287e-01f, -1.13479197e-02f, -3.24033201e-02f, -1.72616273e-01f, -6.77610114e-02f, -1.83497921e-01f,
  -5.12250187e-03f, -5.65766543e-02f, 1.98786139e-01f, 1.83725908e-01f, 8.27486813e-03f, -6.01616912e-02f, 1.40072435e-01f, -8.49247277e-02f, -1.96750686e-02f, -1.13025084e-01f,
  1.01984525e-02f, 8.08813795e-02f, -1.36097118e-01f, 6.81235567e-02f, -3.92427808e-03f, 3.54130678e-02f, 3.51907089e-02f, 6.79537803e-02f, 4.12711762e-02f, 1.22130647e-01f,
  -3.28168012e-02f, -4.07169573e-02f, -1.84647329e-02f, 2.85502686e-03f, 1.97733603e-02f, -4.46157381e-02f, -3.07672564e-02f, -6.60054088e-02f, -3.85702699e-02f, -5.05641848e-02f,
  -9.90264192e-02f, 2.76773255e-02f, -1.10431932e-01f, 5.58150606e-03f, 6.81828111e-02f, 3.13589871e-02f, -5.36316484e-02f, 1.71541557e-01f, -1.05563171e-01f, 1.23339660e-01f,
  -7.48624466e-03f, -1.05862491e-04f, 1.00897849e-01f, 1.54639175e-02f, -6.31421059e-02f, 4.59355004e-02f, 2.50489451e-02f, 3.41363437e-02f, 1.50110096e-01f, 3.43698449e-02f,
  1.42746970e-01f, -3.79176177e-02f, 3.17371711e-02f, 1.61611289e-01f, -8.21218342e-02f, 1.79232687e-01f, 6.23270543e-03f, -1.82337966e-02f, 1.47987768e-01f, 6.44848272e-02f,
  1.82645544e-01f, -5.65377958e-02f, 3.29467617e-02f, 1.61557849e-02f, -2.03073904e-01f, 2.67466772e-02f, -2.95541864e-02f, -1.34842545e-01f, 1.30835563e-01f, 5.44122644e-02f,
  -6.09558541e-03f, 1.40082672e-01f, 1.90832436e-01f, -8.23339224e-02f, 7.81483874e-02f, -1.69542551e-01f, 3.79417390e-02f, -1.06431367e-02f, 6.65714592e-02f, 5.69191538e-02f,
  9.19486880e-02f, 1.54494196e-02f, -1.12645134e-01f, 5.31516746e-02f, 1.95982475e-02f, 9.66515243e-02f, -1.18974214e-02f, -2.87011322e-02f, -1.32448465e-01f, 1.84870809e-01f,
  -4.27682847e-02f, 2.75135398e-01f, -9.93897542e-02f, 1.11717535e-02f, 1.41115010e-01f, 3.04753575e-02f, 2.38805972e-02f, -2.37443298e-02f, -2.63849851e-02f, 1.46203190e-01f,
  6.15053065e-02f, -1.21452957e-01f, -6.99148700e-02f, -5.65153398e-02f, 8.71285722e-02f, -3.88254710e-02f, -1.55216884e-02f, 2.02462420e-01f, 9.76711139e-02f, 1.09492414e-01f,
  -1.62612938e-03f, -4.52403240e-02f, 4.15727636e-03f, -1.70794129e-01f, 1.42115563e-01f, -1.29336312e-01f, -6.33854046e-02f, 7.05927657e-03f, -4.46719564e-02f, 1.16055645e-01f,
  -9.81849968e-04f, -1.59452222e-02f, 3.50838564e-02f, 8.56453106e-02f, 1.52001008e-01f, -1.21564656e-01f, 3.08698565e-02f, 6.54855296e-02f, -1.82417426e-02f, -9.33107510e-02f,
  1.31827518e-01f, 6.99218139e-02f, -5.92727810e-02f, -5.95051125e-02f, 1.93595409e-01f, -4.57529947e-02f, 2.06749752e-01f, 1.29760489e-01f, -8.46487582e-02f, -3.81819066e-03f,
  -4.50353418e-03f, 5.03550209e-02f, -9.29641128e-02f, -6.76845387e-02f, -5.44909984e-02f, -3.28081287e-02f, 5.92583306e-02f, 7.69448876e-02f, -7.95880556e-02f, 1.96232628e-02f,
  1.24473207e-01f, 3.41287553e-02f, 7.08539411e-03f, -1.55589834e-01f, 5.74516617e-02f, -1.01257727e-01f, -9.14870203e-02f, 1.86517946e-02f, -3.43880765e-02f, -8.88791159e-02f,
  3.52383554e-02f, -8.32586065e-02f, 9.09718648e-02f, 1.00215217e-02f, -1.75803073e-03f, 1.98783383e-01f, -7.70907849e-02f, 1.51926524e-03f, 1.44329384e-01f, -1.29927710e-01f,
  -1.58352196e-01f, -8.17502812e-02f, 1.02970883e-01f, 1.18079325e-02f, 4.90496382e-02f, -7.89467245e-03f, -2.16331091e-02f, -4.48584221e-02f, -8.10583215e-03f, -8.20867270e-02f,
  7.05984384e-02f, 1.34276852e-01f, 3.59329581e-02f, -6.27976432e-02f, 5.90671264e-02f, 1.15311511e-01f, -1.03099585e-01f, -1.05461076e-01f, -6.01645783e-02f, 1.87641550e-02f,
  -2.61930302e-02f, -3.78520638e-02f, 3.97398882e-02f, -1.19199008e-01f, 1.81874409e-02f, -1.43345028e-01f, 1.62502393e-01f, -1.92591503e-01f, 1.43640414e-01f, -9.35946703e-02f,
  1.63352400e-01f, 1.32992834e-01f, 2.64315736e-02f, -1.41914919e-01f, 1.76780615e-02f, -1.09015040e-01f, 1.23940706e-01f, 3.32875364e-02f, -1.56932160e-01f, 9.03951079e-02f,
  9.13568512e-02f, -8.12800974e-02f, -4.34215786e-03f, -1.34098083e-01f, -1.44819185e-01f, -1.25348017e-01f, -6.47343323e-02f, -7.09699839e-02f, 5.19833006e-02f, 1.88852802e-01f,
  9.15195495e-02f, 7.78979585e-02f, 5.18222665e-03f, 4.49520126e-02f, 1.61187875e-03f, 4.56258915e-02f, 7.58815333e-02f, 1.33793220e-01f, 1.21386655e-01f, 1.23269759e-01f,
  1.03388920e-01f, -1.00668333e-02f, 9.45076868e-02f, -5.70611656e-02f, 6.19344553e-03f, -5.43690426e-03f, -3.57811004e-02f, -1.32339314e-01f, 7.90271834e-02f, 1.79085843e-02f,
  2.94093648e-03f, 8.78308490e-02f, -4.98365574e-02f, 4.31849957e-02f, -6.71266317e-02f, -5.60135320e-02f, 6.66967109e-02f, 1.43203497e-01f, 1.45418733e-01f, 8.94761384e-02f,
  -5.75343221e-02f, -1.23023940e-02f, -1.57805249e-01f, -7.68584609e-02f, 1.22323707e-02f, 1.21869750e-01f, -6.52391091e-03f, 1.52480185e-01f, -1.08111352e-01f, -1.51280716e-01f,
  -1.63517684e-01f, 4.73575890e-02f, 9.74963829e-02f, -2.85611153e-02f, 8.45246837e-02f, -3.00138276e-02f, -2.67657582e-02f, 3.76752438e-03f, -8.51856843e-02f, 8.51159021e-02f,
  1.31104350e-01f, 8.21168825e-04f, -1.26376346e-01f, -8.58704671e-02f, 2.80865759e-01f, -1.64775569e-02f, -1.22089066e-01f, -1.22540928e-01f, -5.88770993e-02f, 9.37724039e-02f,
  -6.30813511e-03f, -3.03445086e-02f, 1.07947141e-02f, -1.40579909e-01f, -1.16027817e-01f, 3.09983343e-01f, -1.02361724e-01f, -5.38749211e-02f, 1.17285915e-01f, 2.05223728e-02f,
  6.76142648e-02f, -7.37521285e-03f, 1.11823156e-01f, 1.56643152e-01f, -3.78408246e-02f, 8.42273161e-02f, 6.42354265e-02f, 6.57895133e-02f, 2.67776310e-01f, 2.65733507e-02f,
  -2.41579139e-03f, 1.00005142e-01f, 4.79144976e-02f, 1.06290087e-01f, 1.36727184e-01f, -7.35991746e-02f, -1.16921693e-01f, 6.36358410e-02f, -6.88662827e-02f, 3.14468034e-02f,
  -6.85595497e-02f, -2.24192534e-02f, -3.70180383e-02f, -4.38268408e-02f, -1.40127584e-01f, 3.39686237e-02f, 6.15683869e-02f, 6.49972111e-02f, 6.70549050e-02f, 6.65790066e-02f,
  6.16019368e-02f, 6.44831583e-02f, -5.02823759e-03f, 1.38613489e-03f, -1.90836415e-02f, -3.99375856e-02f, 1.04815677e-01f, -4.32376890e-03f, 3.19573581e-02f, 1.28640920e-01f,
  -9.07515287e-02f, 1.17463805e-01f, -3.88194397e-02f, -5.66574596e-02f, -7.90599585e-02f, 1.25054838e-02f, -1.10500321e-01f, -2.89489515e-02f, 1.48184439e-02f, 9.78872702e-02f,
  8.53799284e-05f, 4.96971011e-02f, -1.11909293e-01f, 1.46272868e-01f, 1.10047333e-01f, 9.54289362e-02f, 1.07549265e-01f, 1.27312783e-02f, -7.83881769e-02f, 1.56035811e-01f,
  -6.91300258e-02f, -5.46680018e-02f, -8.49110931e-02f, -8.80634412e-02f, -3.19578946e-02f, 2.12334841e-02f, -1.18821440e-02f, -7.43394792e-02f, -9.87039506e-02f, -6.19473793e-02f,
  -7.41272047e-02f, 3.87080126e-02f, 1.25830010e-01f, -3.95297706e-02f, 6.74093515e-02f, 6.86710179e-02f, -1.17956735e-01f, -1.04691414e-02f, -4.01457120e-03f, 1.03065625e-01f,
  -2.38199439e-02f, 1.65565118e-01f, 1.29425555e-01f, 4.85453829e-02f, 9.74740162e-02f, 7.22672567e-02f, 7.73639232e-02f, 3.55103239e-03f, 1.00116096e-01f, 4.60489877e-02f,
  -3.23243774e-02f, 1.56843603e-01f, -4.18891162e-02f, -6.77722842e-02f, -1.49706402e-03f, -6.08851984e-02f, -6.29405724e-03f, -1.51582256e-01f, -5.36465235e-02f, -6.84060305e-02f,
  1.43207228e-02f, -2.68925149e-02f, 2.27901608e-01f, 9.67164487e-02f, 6.00400455e-02f, -1.50706097e-01f, -2.25284323e-02f, 6.87227324e-02f, -1.30917743e-01f, 1.18100554e-01f,
  -4.87486459e-02f, -2.40848362e-02f, -8.36109295e-02f, 1.14211351e-01f, 8.22376683e-02f, 1.63237214e-01f, 3.65160294e-02f, 4.32239063e-02f, 3.25649083e-02f, 9.64276269e-02f,
  9.24170464e-02f, 1.69611722e-01f, 1.10072814e-01f, -5.35600521e-02f, 2.93074735e-02f, 2.38209721e-02f, -1.93463324e-03f, -4.89716120e-02f, 4.04275768e-02f, 1.11158766e-01f,
  1.35955699e-02f, -1.09212793e-01f, -1.84866786e-02f, -1.07556693e-01f, 2.72065923e-02f, 1.15254954e-01f, -9.98743698e-02f, -9.06310976e-02f, 3.07061672e-02f, 6.96774870e-02f,
  -3.44768278e-02f, 1.38684005e-01f, 1.06019378e-01f, -1.24490440e-01f, 5.23912869e-02f, 1.06123418e-01f, -1.04886800e-01f, 4.70929891e-02f, -8.31131190e-02f, -1.88674405e-02f,
  -2.39519626e-02f, -3.79785034e-03f, 1.52479000e-02f, -4.07862812e-02f, 7.30196685e-02f, -1.29648060e-01f, -4.86229919e-02f, 8.98465365e-02f, -1.05416685e-01f, 4.96380366e-02f,
  1.04546472e-02f, -1.18863538e-01f, -1.04305640e-01f, 5.21730743e-02f, 3.65603007e-02f, -1.19047411e-01f, -8.22894741e-03f, -1.10506654e-01f, -4.18016762e-02f, 8.68440196e-02f,
  -1.32746613e-02f, -8.93969089e-02f, -4.83401082e-02f, -1.13720842e-01f, 1.12489983e-01f, 7.92143345e-02f, -8.60168412e-02f, 2.81717489e-03f, -3.05286404e-02f, -4.25628610e-02f,
  8.24983865e-02f, 1.99826546e-02f, -4.81815748e-02f, -6.76950887e-02f, -1.12695090e-01f, 1.88728068e-02f, 9.19741839e-02f, -1.02703810e-01f, -2.94068009e-02f, -1.64640360e-02f,
  -2.65634675e-02f, -1.19696073e-01f, 2.33815201e-02f, -1.21612027e-01f, -7.36527666e-02f, -2.55751852e-02f, 2.33772919e-02f, 2.44849306e-02f, -1.30583327e-02f, -5.00987321e-02f,
  -8.47130790e-02f, -1.32057801e-01f, -9.93435085e-02f, 4.09880430e-02f, -6.24519438e-02f, 2.73237862e-02f, -1.50415123e-01f, -2.76297852e-02f, 8.68928805e-02f, 9.19520855e-02f,
  -1.47273183e-01f, -1.50806323e-01f, 9.52607393e-02f, 6.44626915e-02f, -9.53082833e-03f, -9.55574512e-02f, -1.67357419e-02f, -6.23575039e-02f, -1.55231627e-02f, 1.21790007e-01f,
  1.02227852e-01f, -3.46394925e-04f, -5.31198531e-02f, 7.35916868e-02f, -8.96368921e-03f, -1.93184125e-03f, 1.06232956e-01f, -8.94822702e-02f, -1.11792840e-01f, -4.59812023e-02f,
  -8.61047208e-02f, 1.28289521e-01f, -5.30469120e-02f, -6.72609955e-02f, 7.03895018e-02f, -5.67234978e-02f, 1.55524030e-01f, 1.28907058e-02f, -8.74682423e-03f, 1.26769155e-01f,
  1.64063238e-02f, -9.78943929e-02f, 1.08899653e-01f, -8.21027681e-02f, -1.13731138e-01f, -2.57328954e-02f, 1.11944690e-01f, -4.17697839e-02f, 2.90205255e-02f, -1.32506445e-01f,
  -1.02451414e-01f, 1.02007709e-01f, -7.44640529e-02f, -1.45613253e-02f, -2.37516742e-02f, 1.20254964e-01f, -8.10811110e-03f, 5.76162897e-02f, -2.93149818e-02f, 8.05868879e-02f,
  4.15959768e-02f, 1.15381829e-01f, -7.06615334e-04f, -1.23771593e-01f, 4.33087125e-02f, 6.69557303e-02f, 3.71716134e-02f, 6.98459744e-02f, 6.88350275e-02f, 3.18239592e-02f,
  -2.23284420e-02f, -1.54742487e-02f, 2.29225252e-02f, 8.86061937e-02f, -1.14012547e-01f, 7.14663342e-02f, 3.93442288e-02f, 4.99131121e-02f, -7.23132491e-02f, -9.61766317e-02f,
  -3.04463450e-02f, 1.24957792e-01f, 3.61885899e-03f, -1.10802203e-01f, 1.33210659e-01f, 2.04881020e-02f, -1.38709573e-02f, 2.55900547e-02f, 3.09742726e-02f, 8.98136199e-02f,
  3.60897859e-03f, -3.99854332e-02f, -9.71893668e-02f, -1.02481946e-01f, 7.34029859e-02f, 6.11787103e-02f, -1.14210665e-01f, 1.14310347e-02f, -3.07618249e-02f, 2.59269984e-03f,
  1.30904600e-01f, 7.52758384e-02f, -1.25992909e-01f, -9.17229727e-02f, -2.54568905e-02f, -7.65286908e-02f, 1.08257033e-01f, -3.98653150e-02f, 8.54802877e-02f, -2.14105137e-02f,
  -7.13603795e-02f, -4.63193730e-02f, 2.18899809e-02f, 8.00672099e-02f, -9.55013484e-02f, -6.07309490e-02f, -6.38045510e-03f, 5.19359186e-02f, -9.94883776e-02f, -4.61088642e-02f,
  1.08704343e-01f, 9.05013904e-02f, -8.95582736e-02f, -9.27407891e-02f, -1.28535733e-01f, -8.57275501e-02f, -9.48583856e-02f, 8.46817121e-02f, -2.23583225e-02f, 3.53583172e-02f,
  1.09014615e-01f, 3.07245944e-02f, -6.20769709e-02f, -1.20014280e-01f, 2.57175654e-01f, 5.86721003e-02f, 2.55189985e-01f, -2.02027261e-01f, 2.10639492e-01f, 2.83725411e-01f,
  -4.81755286e-02f, 2.30813384e-01f, 4.88145500e-02f, 2.38242954e-01f, 9.03223306e-02f, 6.15918636e-02f, 2.80314445e-01f, -1.83121383e-01f, -1.56901360e-01f, -2.84208626e-01f,
  2.91095232e-03f, -3.24418783e-01f, 1.78018481e-01f, 1.06763221e-01f, 2.42886990e-01f, -1.77743033e-01f, 1.19616732e-01f, -1.21930033e-01f, 3.32439065e-01f, -5.41201457e-02f,
  6.23596571e-02f, 5.74337095e-02f, -4.05147523e-02f, -1.10653657e-02f, -2.43247394e-02f, 9.48832631e-02f, 3.68879884e-02f, 9.30255428e-02f, -5.55031039e-02f, 1.16762966e-02f,
  4.49414104e-02f, 8.90968442e-02f, 2.19721869e-01f, 5.83775192e-02f, -7.10178018e-02f, 3.88715900e-02f, -1.81836896e-02f, 1.75383538e-01f, 1.53665453e-01f, -8.47944543e-02f,
  8.32397640e-02f, 9.79614723e-03f, -1.01228505e-01f, -4.05659229e-02f, -5.06335534e-02f, 2.42109835e-01f, -2.39857826e-02f, 2.09270522e-01f, 3.28412675e-03f, 5.69287222e-03f,
  9.55156460e-02f, -9.38714370e-02f, -3.95479389e-02f, 3.05289645e-02f, 8.64590108e-02f, -1.03232220e-01f, 1.15975952e-02f, -4.02064286e-02f, -5.97890057e-02f, 8.92777517e-02f,
  6.36904389e-02f, -2.13131192e-03f, 1.14271715e-02f, -8.94773975e-02f, -9.34488773e-02f, 8.60990956e-02f, 1.25132650e-01f, 1.93530284e-02f, -2.99688764e-02f, 8.15240294e-02f,
  -2.87950300e-02f, -5.29718846e-02f, 1.83562636e-02f, -3.58297005e-02f, 5.41776605e-02f, 1.37859419e-01f, 3.31564508e-02f, 2.04718299e-02f, 7.79691339e-02f, -1.07014298e-01f,
  -3.76807861e-02f, 5.07275723e-02f, 1.46417007e-01f, 1.47406116e-01f, -1.88729651e-02f, 8.83355141e-02f, 7.57073611e-02f, 3.94160040e-02f, 8.57806355e-02f, 4.51753177e-02f,
  -1.36832908e-01f, 3.57340127e-02f, 1.36710182e-01f, 7.84590542e-02f, -8.28918964e-02f, 6.22381121e-02f, -1.12162389e-01f, -7.49410987e-02f, 1.04192019e-01f, -9.72515568e-02f,
  1.56180352e-01f, -6.99300319e-02f, 2.72100829e-02f, 1.34833857e-01f, -1.29247308e-01f, -1.19036250e-01f, 7.42472112e-02f, -1.14449613e-01f, -8.10389891e-02f, 9.04459357e-02f,
  7.97161907e-02f, -2.53527425e-02f, -4.70634699e-02f, 4.96358424e-02f, 8.34435746e-02f, -1.31174430e-01f, 5.43943085e-02f, -1.35059403e-02f, 8.38447362e-02f, -2.66661253e-02f,
  -1.23399653e-01f, -1.44263254e-02f, -2.28096396e-01f, 2.79075895e-02f, 1.03605114e-01f, 8.50059539e-02f, 1.75929610e-02f, -1.82971030e-01f, 7.86699653e-02f, -1.54335544e-01f,
  3.83613594e-02f, -1.14036091e-01f, 5.35473339e-02f, 1.08456686e-01f, -4.77373935e-02f, -5.99672683e-02f, -3.02116293e-02f, 6.58549368e-04f, -1.16715215e-01f, 9.71303955e-02f,
  5.93044329e-03f, -2.99699907e-03f, -5.90762217e-03f, -1.90829605e-01f, 1.84268877e-01f, -5.10521755e-02f, 5.65469980e-01f, 2.12522447e-01f, 1.26974732e-01f, -1.05409376e-01f,
  1.01958558e-01f, 1.07655130e-01f, 1.65788144e-01f, 1.84271380e-01f, -1.20510980e-01f, 1.25544459e-01f, -6.43689558e-02f, -1.02954835e-01f, 6.82999790e-02f, 1.78087484e-02f,
  -2.96307635e-02f, -2.43236676e-01f, 8.26062635e-02f, 5.31690232e-02f, 6.00820109e-02f, 1.45607203e-01f, -3.19812410e-02f, 2.37959459e-01f, -6.36428818e-02f, 5.94853349e-02f,
  5.03780991e-02f, 1.55975059e-01f, -3.62410098e-02f, 6.58444017e-02f, -1.11830659e-01f, 1.87630072e-01f, 2.51346510e-02f, 1.18340842e-01f, 3.15224469e-01f, -1.59510463e-01f,
  -1.13750890e-01f, -1.02812625e-01f, 6.89533502e-02f, 5.26477396e-02f, -2.38039549e-02f, 1.92860201e-01f, -1.06311575e-01f, -8.65590274e-02f, 1.19330265e-01f, 1.45538813e-02f,
  2.53118686e-02f, -2.06639215e-01f, 7.82702789e-02f, -1.53804988e-01f, -1.85688604e-02f, -1.99159399e-01f, 1.38483727e-02f, -1.10168777e-01f, -2.52462421e-02f, 3.34598646e-02f,
  -1.66553542e-01f, 1.10795408e-01f, 1.55057877e-01f, -7.56541342e-02f, 1.27141373e-02f, -1.02276444e-01f, -1.38032153e-01f, 6.41757920e-02f, -1.07785083e-01f, -7.58418739e-02f,
  2.59796917e-01f, 6.45356551e-02f, -5.76866977e-02f, 1.84093397e-02f, -2.38641426e-02f, 4.45699506e-02f, 4.62336913e-02f, 1.36405930e-01f, 2.30105873e-02f, 1.38947666e-01f,
  -6.57790080e-02f, -1.08802943e-02f, -7.40049109e-02f, 1.92241654e-01f, -8.30875151e-03f, -2.09312350e-01f, -1.66589096e-02f, 2.66701162e-01f, 7.80877918e-02f, -1.93974823e-02f,
  -4.99422103e-02f, 7.75732622e-02f, 1.50999546e-01f, -4.36645560e-02f, 2.68411487e-02f, 2.07915708e-01f, -1.18742146e-01f, 1.78525429e-02f, -7.73847029e-02f, 2.25795154e-02f,
  -4.82866690e-02f, -8.94259736e-02f, 1.70030504e-01f, 4.39511845e-03f, -3.92711274e-02f, -5.34998551e-02f, -5.16168028e-03f, -2.39910074e-02f, 1.27902046e-01f, 9.49570015e-02f,
  -2.13243440e-01f, 8.02585408e-02f, 6.53105304e-02f, 1.47820368e-01f, -5.24495021e-02f, -5.83262593e-02f, 6.17075637e-02f, 3.39967497e-02f, -1.07710272e-01f, -1.62281245e-01f,
  -5.46744801e-02f, 1.50309384e-01f, -1.27473399e-01f, 1.06441855e-01f, -2.89719161e-02f, 1.46600544e-01f, 1.73034713e-01f, 1.42181382e-01f, -1.00500971e-01f, -1.43261671e-01f,
  -2.03027338e-01f, 7.12605491e-02f, -1.68856651e-01f, -5.08677661e-02f, 1.65859219e-02f, 9.32995901e-02f, -9.87613723e-02f, 4.16274332e-02f, -1.11845456e-01f, -4.84724529e-02f,
  1.27159372e-01f, 2.27459185e-02f, -8.44183844e-03f, 7.58009553e-02f, 8.87357369e-02f, 8.63771439e-02f, 7.74807036e-02f, 9.96745154e-02f, -4.16237023e-03f, 7.15438975e-03f,
  9.34396237e-02f, 2.91253746e-01f, 9.55475345e-02f, 3.96970995e-02f, -1.66913848e-02f, -1.19091734e-01f, 1.70742497e-02f, 4.17596512e-02f, -4.87764291e-02f, 1.93021577e-02f,
  5.07468320e-02f, -6.45936206e-02f, -5.83491242e-03f, 7.96558429e-03f, 2.79642604e-02f, -8.22391659e-02f, 1.11031890e-01f, 4.76442091e-02f, 1.46397933e-01f, -1.65146701e-02f,
  -1.17333159e-02f, 5.77017255e-02f, -4.36797813e-02f, -2.88032424e-02f, 1.04316466e-01f, -1.16683822e-02f, -9.81643796e-02f, -4.34998535e-02f, -7.69059286e-02f, 8.72244239e-02f,
  -1.77210737e-02f, 8.34483951e-02f, -1.13747954e-01f, -1.02161564e-01f, -1.25890255e-01f, 1.15950853e-01f, -1.05899826e-01f, 7.75908828e-02f, 9.26920325e-02f, 2.95601226e-02f,
  1.06087565e-01f, -3.55608352e-02f, -8.58672485e-02f, 9.81356651e-02f, 5.70332408e-02f, 7.22620590e-03f, 2.78941710e-02f, -1.01399720e-01f, 6.74659535e-02f, -8.75011608e-02f,
  -1.05823919e-01f, -8.96281973e-02f, 3.38973515e-02f, -1.19778499e-01f, 1.64005235e-01f, 7.64329508e-02f, -1.38404565e-02f, 2.02637948e-02f, 1.21199861e-01f, -1.01026095e-01f,
  -3.55076641e-02f, 6.09278046e-02f, -1.13514222e-01f, 2.80962940e-02f, -8.65181535e-02f, 9.18718129e-02f, -1.16769910e-01f, 1.55614138e-01f, 6.39856905e-02f, -1.03147730e-01f,
  1.26952112e-01f, 8.15875828e-02f, -6.77991137e-02f, -1.15666455e-02f, -4.72958982e-02f, -1.07436962e-02f, 1.21310964e-01f, -4.81076464e-02f, -1.27901837e-01f, 9.64929983e-02f,
  1.39750764e-01f, 2.14177882e-03f, 9.15959775e-02f, 1.45559907e-01f, 1.35482252e-01f, 1.73231773e-02f, -5.33968434e-02f, 6.22112378e-02f, -1.39209136e-01f, -5.81913739e-02f,
  1.30954474e-01f, 5.35569452e-02f, 2.94538587e-02f, -2.22546980e-02f, -3.18530202e-02f, -8.20573717e-02f, 2.07293616e-03f, 3.01726745e-04f, 1.78954341e-02f, 5.68609126e-02f,
  -2.02421825e-02f, 1.13379218e-01f, 6.28763437e-02f, -7.43414164e-02f, 9.61182714e-02f, -9.41915438e-02f, -7.27287233e-02f, -1.22548513e-01f, 1.19988479e-01f, -1.49380192e-02f,
  3.06587256e-02f, 9.80952233e-02f, 2.59551823e-01f, 4.05258685e-02f, 8.16510320e-02f, 6.20487379e-03f, 1.05119690e-01f, 6.36479585e-03f, 4.16017994e-02f, 1.27694458e-01f,
  1.25595316e-01f, -5.25865592e-02f, -8.01114216e-02f, 4.99974415e-02f, -1.77145600e-02f, -5.60035221e-02f, -6.57212064e-02f, -1.72032729e-01f, 4.00768034e-02f, -6.99009448e-02f,
  3.45572196e-02f, 5.67145534e-02f, 1.24932572e-01f, 6.14575297e-03f, 8.92144442e-03f, -8.44406188e-02f, 8.23923573e-02f, -9.02078599e-02f, 1.06976144e-01f, 3.75124067e-03f,
  1.76379383e-02f, -4.92842756e-02f, -3.22922505e-02f, 7.80023485e-02f, -1.08044054e-02f, 1.10308059e-01f, -2.54467074e-02f, 5.77827431e-02f, 3.96417566e-02f, 6.69194460e-02f,
  1.12129636e-01f, 5.87422661e-02f, -1.40309453e-01f, -1.91096403e-02f, 4.62095886e-02f, 3.24863940e-02f, -8.48286077e-02f, -1.14048664e-02f, -8.57504457e-02f, 3.97878960e-02f,
  2.02851947e-02f, -3.31994928e-02f, -8.62054229e-02f, -8.34729746e-02f, -2.03059446e-02f, 1.09463178e-01f, -7.51107261e-02f, -1.52639421e-02f, -3.46898846e-02f, 8.31640139e-02f,
  -2.17399262e-02f, 7.12549686e-02f, -6.47256225e-02f, -8.09275657e-02f, 2.34200209e-02f, 6.05020067e-03f, 3.05005480e-02f, 2.75593344e-02f, -9.70056728e-02f, 4.84640636e-02f,
  -6.23353422e-02f, 7.53202587e-02f, 1.46688400e-02f, 1.67058446e-02f, 4.67022508e-02f, 7.86442235e-02f, 6.42467365e-02f, 1.02248967e-01f, -8.37019756e-02f, 4.42517400e-02f,
  -2.93327402e-03f, -1.25339419e-01f, -6.42706752e-02f, 1.35326773e-01f, 1.64231509e-02f, 8.16668123e-02f, -4.78367247e-02f, 1.10260271e-01f, -7.83675089e-02f, -2.46348213e-02f,
  -2.68697105e-02f, 1.34712309e-01f, 8.10471624e-02f, -5.75267151e-02f, -1.35892713e-02f, 6.06233925e-02f, 8.44901279e-02f, 2.77410187e-02f, 3.40495296e-02f, 9.14128274e-02f,
  1.01516135e-01f, -7.55372345e-02f, -8.52534734e-03f, -5.73475994e-02f, 1.03268877e-01f, -1.00812554e-01f, 1.65020123e-01f, 1.08253337e-01f, 2.52266601e-02f, 1.33863360e-01f,
  -1.66008808e-02f, 2.57369548e-01f, 7.55595341e-02f, 1.22437730e-01f, 2.12050565e-02f, 2.15605587e-01f, 1.89274922e-01f, 1.89536348e-01f, -9.60055068e-02f, -2.41367802e-01f,
  1.68514639e-01f, -3.93586382e-02f, 2.07018293e-02f, -4.35498618e-02f, 1.18760005e-01f, -9.58825573e-02f, 4.28851880e-02f, 4.68125194e-02f, 1.30699500e-01f, 3.24872434e-02f,
  2.51939327e-01f, 4.99014221e-02f, 7.02364221e-02f, 3.21824774e-02f, -3.26678157e-02f, 5.38053066e-02f, -3.72483432e-02f, -2.21278314e-02f, -1.65671736e-01f, 4.19146419e-02f,
  3.06332260e-01f, -1.69575086e-03f, 1.18362613e-01f, -1.62878349e-01f, -1.90019086e-01f, 1.99591517e-01f, 6.85245246e-02f, -5.89588322e-02f, 1.26473412e-01f, -2.14398969e-02f,
  -1.20097995e-01f, 2.92888671e-01f, -3.89442556e-02f, -1.27537027e-01f, 4.13989834e-02f, 7.48363212e-02f, -3.44035104e-02f, -1.26873879e-02f, -1.28825992e-01f, 1.06477328e-01f,
  8.90886113e-02f, 2.78508291e-02f, 6.45026490e-02f, -6.69442639e-02f, 3.34518045e-01f, -1.49928346e-01f, -1.24246418e-01f, -7.76513964e-02f, 1.12996399e-01f, 9.64906886e-02f,
  1.98047608e-02f, -1.34436889e-02f, -4.44369912e-02f, 5.77866174e-02f, -7.23110139e-02f, -8.77605900e-02f, -1.26971513e-01f, 7.72446990e-02f, -8.06126297e-02f, -4.83094119e-02f,
  5.86070819e-03f, -3.14534199e-03f, -8.36948305e-03f, -2.16631815e-02f, -7.04919249e-02f, 9.40166935e-02f, 7.07138628e-02f, 3.82934958e-02f, 6.47566244e-02f, 2.96579245e-02f,
  1.27269089e-01f, 2.29004938e-02f, -1.58378184e-02f, -4.50876430e-02f, 9.33643058e-03f, 9.79347751e-02f, -1.26905516e-02f, 5.66774346e-02f, -2.05836166e-02f, -2.21324787e-02f,
  1.21564277e-01f, 2.82878596e-02f, 6.64227232e-02f, 7.89861903e-02f, -5.55245280e-02f, -3.77278328e-02f, 5.12056723e-02f, -6.93167746e-02f, -7.55965561e-02f, -1.45390809e-01f,
  -6.58632293e-02f, 9.99945998e-02f, -6.82339538e-03f, 4.86033922e-03f, 9.61858332e-02f, 1.30423322e-01f, 1.18523493e-01f, 1.19021386e-01f, 1.06927134e-01f, 1.01153418e-01f,
  1.09032035e-01f, 9.27083101e-03f, 5.14154285e-02f, 5.77984080e-02f, 3.31657641e-02f, 9.57060307e-02f, 1.30969286e-01f, -7.33228326e-02f, 1.07609197e-01f, -1.22851059e-01f,
  -5.48535362e-02f, 1.17614046e-01f, 3.82417068e-02f, -6.19639978e-02f, 8.44410807e-02f, 7.95666650e-02f, -9.81514230e-02f, 1.41340837e-01f, 2.99298912e-02f, 3.47454458e-01f,
  2.19856612e-02f, 4.24223691e-02f, 1.70326054e-01f, 3.20896745e-01f, 2.08850592e-01f, 1.51166946e-01f, -1.36520937e-01f, -1.49414554e-01f, 3.26373987e-02f, -1.83895722e-01f,
  8.14099982e-02f, 1.35854751e-01f, 2.06573784e-01f, -5.06907748e-03f, 1.47616237e-01f, 1.54106423e-01f, 1.01920187e-01f, 1.61208527e-03f, -7.59714888e-03f, 9.52093303e-02f,
  -5.11515252e-02f, 8.21542516e-02f, 9.20452699e-02f, 5.05270064e-02f, -1.95213482e-01f, 2.88010314e-02f, -1.18589438e-01f, -6.55228645e-02f, 2.48059243e-01f, -1.21211270e-02f,
  6.30160645e-02f, -3.55587415e-02f, -1.70600787e-01f, 2.94922858e-01f, 3.50545123e-02f, 1.03039347e-01f, 5.50710075e-02f, 9.93712991e-02f, 8.07314813e-02f, 1.58760116e-01f,
  -1.06929593e-01f, -6.62718117e-02f, 4.08989675e-02f, -9.05774012e-02f, -2.10852083e-02f, 1.45544577e-02f, 5.29722199e-02f, 8.81551281e-02f, 4.48668748e-02f, 7.12845847e-02f,
  -1.33898836e-02f, 3.70738618e-02f, 1.49217203e-01f, -1.56854868e-01f, -9.68233272e-02f, 3.44232246e-02f, -1.42515695e-03f, 4.66343835e-02f, 1.34456396e-01f, -1.43119261e-01f,
  1.22362360e-01f, 1.19682997e-01f, -1.82590112e-02f, -8.02637711e-02f, -2.50723083e-02f, -5.85275516e-02f, -3.50637175e-02f, -1.37254372e-01f, -8.13975036e-02f, -5.42254038e-02f,
  1.04189828e-01f, 1.64791077e-01f, -6.44138409e-03f, -1.66586842e-02f, -9.20266062e-02f, 7.27413744e-02f, -1.07245512e-01f, -1.15978509e-01f, 8.11981037e-02f, 4.98493090e-02f,
  -4.46397625e-02f, -1.93914808e-02f, -1.01549089e-01f, 1.02218911e-02f, 7.95289204e-02f, -8.36545080e-02f, -4.84974533e-02f, -7.25746248e-03f, 1.54505849e-01f, 1.26601338e-01f,
  -6.66426420e-02f, -6.57917699e-03f, -7.17246383e-02f, -1.03092887e-01f, 5.26266173e-03f, 7.85717294e-02f, 1.56553328e-01f, 8.06916356e-02f, 1.86279770e-02f, 2.41359025e-01f,
  8.48820247e-03f, 1.01777866e-01f, -8.60048160e-02f, -1.36941627e-01f, -4.00381237e-02f, -1.05246790e-02f, 6.41556308e-02f, 4.10086587e-02f, 6.84778094e-02f, -1.05363373e-02f,
  -4.52226475e-02f, 6.56636953e-02f, 5.93699701e-02f, 1.09226093e-01f, 4.10577580e-02f, 1.37100488e-01f, 8.52872338e-03f, 3.63329425e-02f, 3.92779596e-02f, 2.82500461e-02f,
  -9.99841839e-02f, -1.08424991e-01f, 7.78301135e-02f, 1.19033642e-01f, 2.04371929e-01f, -1.46655992e-01f, 1.47830352e-01f, -4.70163301e-02f, 6.58107772e-02f, 1.88169062e-01f,
  7.74153322e-02f, -1.98803581e-02f, 3.06698624e-02f, 2.03045607e-02f, 3.53793383e-01f, -5.80544360e-02f, 3.03432755e-02f, -1.21161938e-01f, 7.11894408e-02f, -1.19448505e-01f,
  1.69936940e-01f, 1.04306638e-01f, 1.34950921e-01f, -2.43332647e-02f, 1.73814058e-01f, 5.08144125e-02f, 1.12306133e-01f, -1.50761709e-01f, -3.87650612e-03f, -4.05694880e-02f,
  -4.06641811e-02f, 7.49554858e-02f, -8.63241777e-02f, 6.45220727e-02f, 1.91346899e-01f, 5.37784323e-02f, -1.93183646e-01f, -2.37902272e-02f, -2.94379443e-02f, 9.81955156e-02f,
  2.84878522e-01f, -1.29302204e-01f, -1.52511835e-01f, 2.61954784e-01f, 7.92382509e-02f, 1.26441881e-01f, 1.66218847e-01f, -2.69188851e-01f, 2.02059492e-01f, -7.30059519e-02f,
  -3.47472914e-02f, 1.29560709e-01f, -2.70198509e-02f, 4.18637991e-02f, 6.37621805e-02f, 1.66053101e-01f, -9.61944181e-03f, -5.18888086e-02f, 2.65911184e-02f, 1.94142628e-02f,
  -2.53070563e-01f, 1.31065771e-01f, -1.00739025e-01f, 9.30084735e-02f, -6.18279949e-02f, 1.10094100e-01f, 1.37402490e-02f, -1.35369644e-01f, 1.40825391e-01f, 1.14075802e-01f,
  -1.44842397e-02f, -1.18736841e-01f, -1.92059372e-02f, -1.21261686e-01f, 1.06663883e-01f, 7.71477968e-02f, 4.77247909e-02f, 3.06118112e-02f, 1.11859934e-02f, 3.26030888e-02f,
  2.60848012e-02f, 6.55582873e-04f, -9.37049314e-02f, 1.28996223e-01f, 1.62009746e-02f, -1.11434653e-01f, -8.62731412e-02f, -1.24071024e-01f, 6.31061802e-03f, -6.42430037e-02f,
  2.65979588e-01f, 6.91940486e-02f, 7.55347535e-02f, 7.53933415e-02f, -6.33653905e-03f, -5.95541298e-03f, -8.20684358e-02f, -7.08558485e-02f, 1.50042800e-02f, 4.73036766e-02f,
  1.35176048e-01f, 4.56681699e-02f, -1.25880465e-01f, 5.90571202e-03f, -1.52748913e-01f, -4.89565507e-02f, -4.25431915e-02f, -1.47177219e-01f, -7.78539330e-02f, -7.54272118e-02f,
  -4.74742539e-02f, 2.89050072e-01f, -6.33784682e-02f, 6.04257695e-02f, -5.26013076e-02f, 1.47996753e-01f, 1.14751063e-01f, -7.56064430e-02f, 5.96374981e-02f, 2.40524694e-01f,
  -1.15094393e-01f, 1.13597579e-01f, -9.82625317e-03f, -1.05974779e-01f, -3.02330051e-02f, -1.43022925e-01f, -7.81675393e-04f, -2.35069785e-02f, 7.60541111e-02f, 6.00645086e-03f,
  1.37092039e-01f, 1.93836838e-01f, -8.68402570e-02f, 1.69168875e-01f, 1.06051944e-01f, 1.18685327e-01f, 9.03468207e-02f, 2.32791919e-02f, 4.62052273e-03f, 1.29955977e-01f,
  1.46031052e-01f, 1.82201251e-01f, -1.36146441e-01f, 2.57456140e-03f, 4.55711856e-02f, 4.63021956e-02f, -1.50349244e-01f, 1.00208268e-01f, 3.98619436e-02f, -2.11051963e-02f,
  -8.47127736e-02f, 5.83900064e-02f, 5.18699884e-02f, 5.01141977e-03f, 1.72802359e-01f, -1.54558598e-04f, -6.64881393e-02f, 6.99791387e-02f, -3.13173942e-02f, 6.13126047e-02f,
  2.29762960e-02f, 5.62486872e-02f, 7.14436993e-02f, 4.20010313e-02f, -4.55420613e-02f, 7.32976273e-02f, 1.89943463e-02f, -8.21580589e-02f, -1.15177289e-01f, 9.07069072e-02f,
  5.52343950e-02f, -2.95823644e-04f, -3.04356068e-02f, 4.17444110e-02f, -1.29190274e-02f, -7.38330781e-02f, 1.41687945e-01f, -4.03436013e-02f, -8.62240642e-02f, 1.10188909e-01f,
  1.51638710e-03f, -2.53732335e-02f, 1.09038703e-01f, -7.60321394e-02f, 1.30009931e-02f, 7.90290758e-02f, -7.55167529e-02f, -1.03083879e-01f, 6.04136437e-02f, -8.87514949e-02f,
  -9.93997380e-02f, 1.36393635e-02f, 8.86399820e-02f, 9.10871103e-02f, -1.64148644e-01f, -1.22154549e-01f, -4.23994251e-02f, 1.03810810e-01f, 6.04103580e-02f, -8.92062560e-02f,
  -6.43087402e-02f, 8.48920201e-04f, -2.52330750e-02f, -6.32972941e-02f, 1.10624533e-03f, -7.40784630e-02f, -4.05234545e-02f, -9.36655253e-02f, 2.60905437e-02f, 9.22701433e-02f,
  8.95808190e-02f, -1.28406417e-02f, -9.33122560e-02f, 8.84104986e-03f, 1.01924337e-01f, -1.41907156e-01f, 5.17160147e-02f, -9.89527162e-03f, 1.09302916e-01f, -4.10066471e-02f,
  -1.02122694e-01f, 6.39599860e-02f, -7.61578903e-02f, 9.88888592e-02f, 2.60107107e-02f, 1.21462546e-01f, 7.78071880e-02f, 1.05484977e-01f, -4.11844179e-02f, -9.03032273e-02f,
  -3.52651700e-02f, 1.12124652e-01f, -8.61065090e-02f, 4.08546478e-02f, 8.67151767e-02f, -8.09231400e-02f, -4.36743023e-04f, -5.77968135e-02f, 9.23682377e-02f, 1.02684669e-01f,
  5.08974493e-02f, 2.05145162e-02f, -7.97299296e-02f, -4.12840880e-02f, -4.13008295e-02f, -6.58775344e-02f, -3.16283815e-02f, 1.56143919e-01f, 5.16770259e-02f, -4.72358987e-02f,
  2.08161324e-01f, 8.76098778e-03f, 2.51799952e-02f, -1.03972629e-01f, -1.33778376e-03f, -1.08418595e-02f, 6.94461539e-02f, -6.39132187e-02f, -5.69258779e-02f, 1.00581668e-01f,
  1.68241084e-01f, -1.66663259e-01f, 5.67968227e-02f, -1.29846945e-01f, 6.60977811e-02f, 8.70195627e-02f, -1.03849478e-01f, 1.00525199e-02f, -7.64014423e-02f, -8.71225446e-02f,
  2.65900344e-01f, -1.80729702e-01f, -6.81564584e-02f, -1.95227563e-02f, 2.59538218e-02f, -1.78635329e-01f, -1.78424045e-02f, 9.46134627e-02f, 8.62973109e-02f, 8.26785713e-03f,
  2.16148142e-02f, 7.25551769e-02f, 2.42190272e-01f, -5.21859229e-02f, 2.07015444e-02f, -1.62455812e-01f, 3.70876119e-02f, 1.29468301e-02f, -1.33603826e-01f, -8.65381509e-02f,
  1.52950957e-01f, 1.10529989e-01f, -1.02754489e-01f, 7.70016294e-03f, -1.02753965e-02f, 7.14550167e-03f, -5.97817115e-02f, -1.28424317e-01f, 6.88961595e-02f, -1.80230081e-01f,
  -4.70635444e-02f, 1.74870357e-01f, 9.33880955e-02f, 9.22454405e-04f, -4.11847904e-02f, -6.98187426e-02f, 7.29453638e-02f, -7.09405318e-02f, -1.30513310e-01f, 3.47185619e-02f,
  6.85768947e-02f, -1.14279920e-02f, 1.14367299e-01f, -6.55420050e-02f, 7.24553317e-02f, 6.28167614e-02f, 4.52525429e-02f, 2.22757701e-02f, -1.66518928e-03f, -3.99515294e-02f,
  4.23107343e-03f, 1.11136757e-01f, 1.92989916e-01f, 1.73418939e-01f, 1.73097223e-01f, -1.15605332e-01f, 3.44959348e-02f, 1.87935174e-01f, 1.48320720e-02f, 1.79441065e-01f,
  1.88599527e-01f, 2.76775360e-01f, 1.28725633e-01f, 2.29042768e-01f, 2.58203566e-01f, -1.92723840e-01f, -3.46026570e-02f, -1.09623909e-01f, -3.38430852e-02f, -2.02774316e-01f,
  1.09233178e-01f, 2.91274130e-01f, 8.31311941e-02f, -7.36773200e-03f, 3.17951322e-01f, -1.64540648e-01f, 2.77963188e-03f, -1.56167462e-01f, -1.07946388e-01f, 5.42121716e-02f,
  -1.22056492e-01f, -1.49582475e-02f, -1.01064585e-01f, 6.62309378e-02f, 1.91801356e-03f, -1.88751876e-01f, 1.16232589e-01f, 1.51264155e-02f, -1.51386932e-01f, -1.19656421e-01f,
  5.76276071e-02f, 1.58711016e-01f, -5.91302589e-02f, -1.55698121e-01f, 1.20332055e-01f, -5.55931143e-02f, -5.20171262e-02f, 7.78229460e-02f, -6.25400618e-03f, -7.26153478e-02f,
  4.49522100e-02f, -1.19996004e-01f, -4.61227745e-02f, 6.82395473e-02f, 3.87049764e-02f, 2.92985708e-01f, -1.14956476e-01f, -5.57170101e-02f, -6.36697486e-02f, 1.81438663e-04f,
  8.17904398e-02f, -2.78936978e-02f, -1.51739195e-01f, 1.46735711e-02f, 6.72842860e-02f, 6.22988157e-02f, -1.66753173e-01f, -1.27576962e-01f, 1.36473164e-01f, 1.53534234e-01f,
  -8.55871215e-02f, -1.04275364e-02f, 9.81406029e-03f, -1.53275654e-01f, -7.31917396e-02f, -5.07531129e-02f, 7.84479156e-02f, -3.05792559e-02f, -6.27495497e-02f, 9.52595100e-02f,
  1.51060566e-01f, 2.16030274e-02f, -1.42183751e-01f, 1.00976057e-01f, -9.10655931e-02f, -1.77676439e-01f, 8.02306682e-02f, -2.70482572e-03f, -1.52729854e-01f, -2.26332955e-02f,
  2.19900951e-01f, -4.33897413e-02f, -2.64549498e-02f, -1.06333062e-01f, 2.48101875e-02f, -5.53673366e-03f, 2.00463071e-01f, 1.75641775e-01f, 3.45515124e-02f, 1.41714349e-01f,
  -4.18820530e-02f, -1.07498296e-01f, -1.72484685e-02f, 7.95972124e-02f, 8.87218211e-03f, -9.92739871e-02f, 1.49023756e-01f, 3.53489161e-01f, 1.00569747e-01f, 2.04154685e-01f,
  1.31335884e-01f, -7.86995329e-03f, 7.60305822e-02f, 5.19663058e-02f, -1.07253931e-01f, 1.78088605e-01f, 1.81263983e-02f, 1.51916370e-01f, 7.27791637e-02f, 1.11672580e-01f,
  4.92726639e-02f, -1.15701845e-02f, 1.02585144e-01f, 8.00228789e-02f, 8.23368654e-02f, 1.95496619e-01f, 1.23034179e-01f, 6.62059933e-02f, -9.42840204e-02f, -1.20706651e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 40)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 40;
const float L3_fan_Bp_bar_data[] = {
  7.95326084e-02f, 8.45892057e-02f, -6.81384206e-02f, -2.00586226e-02f, 1.31002456e-01f, 4.02883813e-02f, -1.56672150e-02f, 9.65749323e-02f, -1.11965323e-02f, 1.24961361e-01f,
  1.73377931e-01f, 1.36303037e-01f, -7.93234557e-02f, 1.09391771e-02f, -3.05854622e-03f, 1.15940921e-01f, 5.99346608e-02f, 3.45690697e-02f, -1.07181802e-01f, -9.80407894e-02f,
  7.16497973e-02f, 1.04610205e-01f, -8.78640637e-02f, 5.78862354e-02f, 5.67807071e-02f, 8.90525654e-02f, -6.75395206e-02f, 3.41577977e-02f, -8.56948420e-02f, 1.94090866e-02f,
  -9.78546739e-02f, 1.48094714e-01f, 8.16294830e-03f, 1.81978896e-01f, 7.07377568e-02f, 1.64949030e-01f, 1.05136916e-01f, 8.80924091e-02f, 9.83449891e-02f, -3.63416374e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -2.26288512e-01f, -2.56736100e-01f, -2.99323499e-01f, -2.91589469e-01f, -1.34208724e-01f, 2.73601450e-02f, -2.36343652e-01f, -2.35686645e-01f, -1.40544519e-01f, -2.16681197e-01f,
  -2.45520994e-02f, 1.25556543e-01f, 1.77201495e-01f, -2.62382179e-01f, 1.40689716e-01f, 1.88154094e-02f, -4.77661006e-02f, -1.79448836e-02f, 1.63203441e-02f, 8.93296674e-02f,
  1.12230048e-01f, 3.43127958e-02f, 7.66724050e-01f, -6.06325530e-02f, 3.06725085e-01f, -2.45721415e-01f, 4.03519541e-01f, 1.45433143e-01f, -1.88851058e-01f, -7.51035064e-02f,
  2.58249402e-01f, -1.76939547e-01f, 4.00208496e-02f, -3.18312868e-02f, -1.27336383e-01f, 6.14018254e-02f, 7.26898089e-02f, 2.18691155e-01f, 1.15912296e-01f, -1.07627109e-01f,
  7.97636360e-02f, 7.11718574e-02f, 2.33267192e-02f, 1.20944805e-01f, -5.16481623e-02f, 9.04982537e-02f, 1.72855571e-01f, 4.33129340e-01f, 4.68543209e-02f, -9.79174376e-02f,
  -8.87335092e-02f, 1.35426641e-01f, 3.85044678e-03f, -1.06036365e-01f, 4.75421995e-02f, -4.20620590e-01f, 5.28030610e-03f, 1.20225564e-01f, 1.73874915e-01f, -4.31379862e-02f,
  1.37370944e-01f, 3.92265737e-01f, -1.06654234e-01f, -1.27531946e-01f, 3.34535569e-01f, -9.39888433e-02f, 1.27963290e-01f, 2.54003346e-01f, 9.23519880e-02f, -3.93857002e-01f,
  -1.99563503e-01f, -1.87973864e-02f, 1.15679272e-01f, -2.25007623e-01f, 6.75776824e-02f, -1.13252088e-01f, -8.91906768e-02f, 2.39665478e-01f, -3.02429020e-01f, 1.48196980e-01f,
  -1.84759334e-01f, -1.59343462e-02f, 1.64304093e-01f, 1.88255399e-01f, -1.46578938e-01f, 5.50090615e-03f, -3.29478264e-01f, -2.71050073e-02f, 4.15975034e-01f, 3.01665008e-01f,
  1.56443104e-01f, 7.75410235e-03f, -2.70968527e-01f, -2.10939929e-01f, -9.73734111e-02f, 2.23273411e-02f, -1.38017476e-01f, -2.65219539e-01f, -5.54179728e-01f, -2.06663460e-01f,
  2.40220185e-02f, -7.37889037e-02f, 6.17881007e-02f, -3.53342652e-01f, -1.20496817e-01f, 2.25645840e-01f, 2.10285839e-02f, 3.85387316e-02f, -7.61050582e-02f, 6.69811741e-02f,
  -1.42582893e-01f, 3.64133656e-01f, 3.66114080e-01f, 1.73572361e-01f, 4.73199338e-02f, 2.26716325e-01f, -7.09704682e-02f, -4.31138515e-01f, 6.82445392e-02f, -3.25244784e-01f,
  1.82765841e-01f, 3.88331592e-01f, -1.13428578e-01f, -3.06118093e-02f, 4.27906252e-02f, 8.26046765e-02f, -2.90207565e-01f, 2.32420743e-01f, 2.88332760e-01f, 1.33447126e-01f,
  8.95009637e-02f, -3.54283452e-02f, -1.93960313e-02f, 6.21299624e-01f, 5.02925396e-01f, 2.11137324e-03f, 9.53008384e-02f, 5.30552387e-01f, -2.24229172e-01f, 2.27510750e-01f,
  7.89479911e-02f, 5.60068861e-02f, 1.70443565e-01f, -3.45630854e-01f, -2.14398384e-01f, 3.38999510e-01f, 2.59656087e-02f, 2.56820433e-02f, 5.52227423e-02f, 2.83556610e-01f,
  -7.69837648e-02f, 2.36836120e-01f, -1.75080702e-01f, -4.48728651e-01f, -3.15483473e-02f, -2.25707758e-02f, -2.05194458e-01f, 2.14429274e-01f, -4.94491756e-02f, 1.20970063e-01f,
  -7.55742192e-02f, 2.72771772e-02f, 8.29430968e-02f, -9.14578810e-02f, 2.37407833e-01f, -1.16952874e-01f, 2.23357126e-01f, -3.40922959e-02f, -6.42198743e-03f, 1.94484890e-01f,
  -7.62137258e-03f, 6.64509041e-03f, 3.94408144e-02f, 1.89100876e-01f, 4.27833498e-02f, 2.43319333e-01f, -4.27887961e-02f, -9.54866260e-02f, 1.02383956e-01f, 6.14094324e-02f,
  -2.29736175e-02f, 3.64431173e-01f, 9.69510467e-04f, 2.56023943e-01f, -4.72498909e-02f, -1.43643647e-01f, 4.76135500e-02f, 2.39377692e-01f, -6.49658442e-02f, -1.78809196e-01f,
  -2.22351193e-01f, 2.09647238e-01f, -2.59790689e-01f, 9.75219067e-03f, -6.04705326e-02f, -1.78178236e-01f, -1.13718510e-01f, -1.64269298e-01f, 1.07135149e-02f, -2.32138392e-02f,
  -2.06292689e-01f, 1.64504908e-02f, 4.02586818e-01f, 2.39116237e-01f, 1.04707643e-01f, 1.18160464e-01f, -2.76110888e-01f, -2.47812763e-01f, -9.09306929e-02f, 2.62550592e-01f,
  4.07780886e-01f, -8.99923518e-02f, 2.38748774e-01f, 3.20249110e-01f, 9.17111561e-02f, -2.65566677e-01f, 1.65351614e-01f, -1.33719727e-01f, -8.82823914e-02f, -1.14529558e-01f,
  -3.01419854e-01f, 1.68834925e-01f, 2.98737794e-01f, -1.63127989e-01f, 9.21786800e-02f, -3.35678101e-01f, 4.10926044e-01f, 3.00301835e-02f, -2.53345609e-01f, 1.33719474e-01f,
  2.40295857e-01f, 2.76625574e-01f, 1.04571745e-01f, -8.19299221e-02f, 1.13226444e-01f, -4.32212651e-03f, 5.87815829e-02f, -1.30930379e-01f, 6.97311237e-02f, 3.84255983e-02f,
  -4.35160808e-02f, -1.87228516e-01f, -1.09783716e-01f, 1.37057044e-02f, 8.47399756e-02f, 3.35727811e-01f, 7.03647733e-02f, 2.87394881e-01f, 3.70923765e-02f, -3.58098537e-01f,
  3.17292362e-01f, -3.86982225e-02f, 1.19371293e-02f, -1.85664579e-01f, 9.44778845e-02f, -2.12000266e-01f, 1.75042734e-01f, -2.08202228e-01f, -2.91692942e-01f, -4.90310401e-01f,
  -1.54120222e-01f, -3.45392764e-01f, -2.76978999e-01f, 1.09979466e-01f, -1.65251404e-01f, -5.38425148e-01f, 4.89451975e-01f, -9.58738029e-02f, 3.67095441e-01f, 2.50992537e-01f,
  -1.39658391e-01f, -1.26546457e-01f, -1.14233114e-01f, -2.34863814e-02f, 2.24570036e-01f, -1.53982505e-01f, 5.02643958e-02f, 2.45578140e-02f, 1.30064070e-01f, 1.79241389e-01f,
  1.70035362e-01f, -2.02166498e-01f, -1.47106200e-01f, 5.02493046e-03f, -3.50672364e-01f, 1.09157175e-01f, 1.71508029e-01f, 2.64839321e-01f, 1.31354451e-01f, -2.87643194e-01f,
  8.05534497e-02f, 1.67793348e-01f, 8.02226737e-02f, 1.05473585e-01f, 2.31623143e-01f, -6.36673793e-02f, -1.12897968e-02f, -1.37072593e-01f, 5.13986945e-02f, 7.97085613e-02f,
  1.03120670e-01f, 3.42098922e-01f, 1.68243200e-02f, 1.26498356e-01f, -1.70783296e-01f, -9.75821465e-02f, 1.50880054e-01f, -8.06513131e-02f, -5.51819764e-02f, 1.17057540e-01f,
  4.84187044e-02f, 1.12835318e-01f, -1.01289786e-01f, 1.13947704e-01f, 7.10560009e-02f, -8.09213147e-02f, 1.37784136e-02f, 1.44269094e-01f, 4.02777314e-01f, -5.51772565e-02f,
  5.89393899e-02f, 2.49823853e-01f, 7.08361715e-02f, 2.36260042e-01f, 1.32416248e-01f, -2.31609210e-01f, 2.02658445e-01f, 1.66762531e-01f, 1.40455708e-01f, -2.02438623e-01f,
  -2.43709147e-01f, -2.30656698e-01f, -1.77961320e-01f, 1.95905477e-01f, -1.18152179e-01f, -2.48178869e-01f, -2.06984714e-01f, 4.12283659e-01f, 2.72928178e-01f, -1.86261997e-01f,
  -1.26695499e-01f, 4.27752256e-01f, -2.55796015e-02f, 4.48347107e-02f, 2.93244332e-01f, -1.86129481e-01f, -1.55979797e-01f, -5.77096306e-02f, -1.87056847e-02f, -2.16788445e-02f,
  -1.96374729e-01f, 5.59523880e-01f, -6.75539449e-02f, -1.17385909e-02f, -2.74648160e-01f, -1.21574290e-01f, 3.98136407e-01f, -6.13832697e-02f, -3.81356701e-02f, -1.45512760e-01f,
  -1.57335848e-01f, 8.33586976e-02f, 5.63869104e-02f, -1.00731850e-01f, 2.21362747e-02f, 4.18693364e-01f, -1.45736292e-01f, -1.78978257e-02f, -6.08353727e-02f, -1.43169761e-01f,
  -9.88795832e-02f, 5.43229766e-02f, -1.53654099e-01f, -1.75169278e-02f, -1.31800985e-02f, -4.31600101e-02f, 1.87172238e-02f, 3.58543754e-01f, -1.29719526e-01f, 1.40652269e-01f,
  -1.75735846e-01f, 8.66396278e-02f, 4.26318534e-02f, 7.63395205e-02f, 3.22371155e-01f, -2.07415178e-01f, -2.89185822e-01f, 3.58070970e-01f, -1.68609619e-01f, 1.95760075e-02f,
  -1.61342174e-01f, 2.48664767e-02f, 7.17357695e-02f, 1.27887577e-01f, -2.85791904e-01f, 3.13458502e-01f, 1.98504440e-02f, -3.55979413e-01f, 2.47257173e-01f, 1.34909123e-01f,
  3.61621916e-01f, -7.38068342e-01f, -2.93423444e-01f, -1.62452787e-01f, 1.65000632e-01f, -4.87236023e-01f, 2.17776492e-01f, -5.33283912e-02f, -1.59596130e-01f, -1.04935288e-01f,
  1.11263752e-01f, -8.45950097e-02f, 4.53359425e-01f, 9.85332131e-02f, -1.88057706e-01f, -3.42697084e-01f, -2.39846278e-02f, 4.64354575e-01f, -7.32154585e-03f, 2.66175456e-02f,
  -1.49579411e-02f, -7.38324001e-02f, -1.82865616e-02f, 1.44503683e-01f, 9.03007984e-02f, 1.44902244e-02f, 4.60104421e-02f, -9.08761378e-03f, 1.00223683e-01f, -4.42275286e-01f,
  -1.20790325e-01f, -4.71876979e-01f, -2.86862493e-01f, 1.19594596e-01f, 4.51533683e-02f, 4.91974950e-02f, -4.04323712e-02f, 2.40191594e-01f, -2.45469976e-02f, 3.12304705e-01f,
  -7.47930184e-02f, -2.46085480e-01f, -1.14341997e-01f, 1.92126751e-01f, -8.49006623e-02f, -2.99352184e-02f, -1.74309716e-01f, -2.60827512e-01f, -2.99607724e-01f, -5.27387150e-02f,
  -1.11536972e-01f, -2.41162941e-01f, -1.68364853e-01f, -2.83219874e-01f, -2.79019952e-01f, -4.03194994e-01f, -7.08065853e-02f, -3.05680931e-01f, 2.59081244e-01f, -4.31377143e-01f,
  4.16907877e-01f, 9.57557708e-02f, -2.20504060e-01f, 2.08790854e-01f, 3.33814397e-02f, -1.84511587e-01f, 3.46403830e-02f, 8.77435133e-02f, -2.67498821e-01f, -2.23463744e-01f,
  -5.89590743e-02f, -2.69191593e-01f, -2.12524578e-01f, 5.70611537e-01f, 2.82205343e-02f, 6.27009943e-02f, -3.87507349e-01f, -5.81939565e-03f, 6.44033626e-02f, -2.32285514e-01f,
  -2.85790823e-02f, -1.46329105e-01f, 1.32609621e-01f, -2.46769004e-02f, -2.15877488e-01f, -3.55514325e-02f, 5.18979393e-02f, 1.98693007e-01f, -9.61842537e-02f, -2.82704115e-01f,
  -7.34501407e-02f, 2.87925303e-01f, -1.26952678e-01f, -2.18716472e-01f, -2.46139728e-02f, 2.31604040e-01f, 2.90668249e-01f, 1.67915568e-01f, -5.30816093e-02f, -3.56767848e-02f,
  1.51548594e-01f, 9.83208790e-02f, 1.68324858e-01f, -2.43487582e-01f, -4.14782129e-02f, -1.33246422e-01f, 1.95968688e-01f, -2.57641762e-01f, 1.44246221e-01f, -1.30258188e-01f,
  -2.10936472e-01f, 1.51971310e-01f, -2.21537516e-01f, 1.34899557e-01f, -3.67716923e-02f, 6.89131543e-02f, 2.93782391e-02f, 4.17601913e-01f, 2.61176825e-01f, 1.42448559e-01f,
  -3.98325771e-02f, 4.95573372e-01f, -2.08149135e-01f, 9.58113000e-02f, -3.59819472e-01f, -1.05237797e-01f, 1.09031364e-01f, 2.33768135e-01f, 2.88577378e-01f, -1.12999149e-01f,
  -2.78856933e-01f, 5.08648437e-03f, -9.16950032e-02f, -2.48613998e-01f, 9.18440893e-02f, 3.94788772e-01f, -2.34880686e-01f, -2.73889545e-02f, -3.75302769e-02f, 2.11484786e-02f,
  5.56920409e-01f, -1.54777035e-01f, -1.96688488e-01f, 9.39512700e-02f, 1.06030107e-02f, 3.27978343e-01f, -4.23975974e-01f, -4.51871194e-02f, 2.16993943e-01f, -2.21411586e-01f,
  -2.03060567e-01f, -2.04104900e-01f, -8.73208418e-02f, 9.32175964e-02f, -8.29721838e-02f, -8.35872218e-02f, -3.23691480e-02f, 1.57940239e-01f, -3.78087983e-02f, -3.65506679e-01f,
  1.41812742e-01f, -6.11749403e-02f, -3.45764197e-02f, -1.59448311e-01f, 3.05684330e-03f, -3.56866032e-01f, 4.51403223e-02f, -3.11836693e-02f, 1.33199677e-01f, 3.58787805e-01f,
  -1.39306083e-01f, -1.36048511e-01f, -6.64063022e-02f, -7.39341974e-02f, -1.72271654e-01f, 2.31086705e-02f, -1.58088654e-01f, 1.84474528e-01f, 4.20340523e-02f, 1.64683953e-01f,
  2.49771833e-01f, 1.64004281e-01f, 7.24863857e-02f, -6.09495081e-02f, 1.45726979e-01f, 2.46011943e-01f, -1.47732064e-01f, 2.77466238e-01f, 4.33928937e-01f, -3.50870416e-02f,
  2.33781457e-01f, -2.62240440e-01f, 2.89802384e-02f, -4.32621092e-01f, -4.41179395e-01f, 1.45050496e-01f, 8.58928934e-02f, -3.04695159e-01f, -3.57055068e-01f, -3.83712947e-01f,
  -4.20993418e-01f, 2.43216828e-01f, 9.29092802e-03f, -1.12731919e-01f, -5.47746904e-02f, 2.49185011e-01f, 8.11956152e-02f, -4.26538199e-01f, -2.88059376e-02f, 2.34217778e-01f,
  2.90113181e-01f, -6.96612000e-02f, -1.27555028e-01f, -2.14687899e-01f, -1.52457714e-01f, 2.07849041e-01f, -4.25193198e-02f, -7.12352991e-02f, -2.84856800e-02f, -7.77129233e-02f,
  -1.44003242e-01f, -2.74258792e-01f, 1.68053135e-01f, 1.88545749e-01f, 8.64159837e-02f, 1.30870447e-01f, -2.08270580e-01f, -6.48171231e-02f, -1.09714866e-01f, 1.87151626e-01f,
  1.87543631e-02f, 2.99365044e-01f, -1.90213427e-01f, -1.03576526e-01f, 8.21176320e-02f, 9.27572325e-02f, 1.79177616e-02f, -9.06397179e-02f, -5.19083366e-02f, 3.57381515e-02f,
  2.09836751e-01f, 2.45023534e-01f, 3.07125241e-01f, 3.04533124e-01f, 3.28582048e-01f, 1.23023361e-01f, 1.36793107e-01f, 2.03862801e-01f, 1.17345132e-01f, 3.12717110e-01f,
  -1.51337385e-02f, -1.95207044e-01f, -2.82207698e-01f, -1.06792092e-01f, -2.08630157e-03f, 1.87533181e-02f, -1.87097609e-01f, 6.02315426e-01f, 4.44741637e-01f, -2.85927743e-01f,
  -2.53892113e-02f, 3.69282812e-01f, -5.02810836e-01f, 1.82091609e-01f, 4.04337719e-02f, -2.94161618e-01f, -8.45740288e-02f, -5.65991662e-02f, -1.66264981e-01f, -4.73412797e-02f,
  -2.08650678e-01f, 3.76860499e-01f, -6.42607212e-02f, -1.51300982e-01f, 3.52996141e-01f, 2.42307454e-01f, -1.74466208e-01f, 7.86361024e-02f, -1.76196396e-01f, -1.48143411e-01f,
  -6.09830655e-02f, -1.73565850e-01f, -1.04113959e-01f, 5.83126545e-02f, -9.20585096e-02f, 4.55306053e-01f, 6.08313419e-02f, -2.50530303e-01f, -3.05915087e-01f, -2.94092894e-01f,
  -8.22064355e-02f, -1.36256963e-01f, -1.58210382e-01f, 1.16433948e-01f, -1.26350760e-01f, 6.69111684e-02f, -1.30250648e-01f, 2.87482411e-01f, -7.19418302e-02f, 7.32967863e-03f,
  -1.67306110e-01f, 8.14349204e-02f, 6.43824637e-01f, -4.85385865e-01f, 1.83523983e-01f, 9.88105536e-02f, -2.98560951e-02f, 1.63705845e-03f, -1.81676134e-01f, -1.18512720e-01f,
  -5.06389886e-02f, 7.25214556e-02f, -3.80547494e-02f, -2.92285413e-01f, -3.30872446e-01f, 1.38362765e-01f, -2.23884746e-01f, -1.21168606e-01f, 2.42373690e-01f, 2.32845724e-01f,
  1.77512661e-01f, -2.46401966e-01f, 3.09342295e-02f, 2.73340464e-01f, 2.03937422e-02f, -1.06489308e-01f, -2.32822578e-02f, -3.85031164e-01f, -2.88301140e-01f, 4.39071178e-01f,
  -1.21589512e-01f, 5.59040643e-02f, 3.29242617e-01f, -4.50517051e-02f, -1.65259778e-01f, -3.93415153e-01f, 4.22809422e-02f, 3.27730596e-01f, -4.86944705e-01f, -1.48619249e-01f,
  -5.16733117e-02f, -1.13214746e-01f, -5.26891276e-02f, -2.51212530e-02f, 8.33192021e-02f, -1.31952554e-01f, 4.82397899e-02f, 8.68438333e-02f, 7.12989643e-02f, -4.31561738e-01f,
  -7.69646466e-02f, -1.59545720e-01f, 8.31046328e-02f, 3.96554410e-01f, 1.99281618e-01f, -7.51442239e-02f, 1.33889019e-01f, -3.04469347e-01f, -3.88907716e-02f, -2.77648449e-01f,
  2.41213158e-01f, -2.72919476e-01f, -3.75425927e-02f, -9.29450914e-02f, -1.23088107e-01f, -1.13797896e-01f, -6.20357245e-02f, 3.17243278e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.75521493e-01f, -3.26568186e-02f, 3.10278172e-03f, -6.19976744e-02f, -1.63990766e-01f, 4.81956638e-03f, -4.94865663e-02f, -9.91268605e-02f, 1.38706818e-01f, -5.41855693e-02f,
  1.49170503e-01f, -5.27993143e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    