/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.90649474e-01f, -2.39598960e-01f, -1.81202829e-01f, 3.59444469e-01f, -2.05255702e-01f, -1.98011234e-01f, -3.52852136e-01f, -1.76153615e-01f, 1.28539473e-01f, -9.78292376e-02f,
  1.57506578e-02f, 1.92443877e-01f, 9.51594785e-02f, -6.11906499e-02f, -4.35622446e-02f, -9.85124782e-02f, -1.61341086e-01f, 2.10152864e-01f, 1.60436824e-01f, 6.57603890e-02f,
  -3.89500447e-02f, 1.94316179e-01f, 2.09666103e-01f, 7.59837478e-02f, -5.05031496e-02f, 1.83075201e-02f, -4.40662019e-02f, 2.02668924e-02f, -5.19232936e-02f, 2.58424506e-03f,
  1.33802354e-01f, -9.76080075e-03f, -1.72289107e-02f, 6.37443960e-02f, 1.09752156e-02f, 5.71642183e-02f, 4.75123785e-02f, -8.69951472e-02f, -7.49175251e-02f, -5.56359207e-03f,
  5.74603342e-02f, -8.15093070e-02f, -4.15676311e-02f, -2.98350155e-02f, -2.07434706e-02f, 5.72060347e-02f, -7.12809712e-02f, 9.10357684e-02f, 2.81605739e-02f, -8.56676772e-02f,
  -1.00196525e-02f, 9.39494222e-02f, 1.59592405e-01f, -1.33366555e-01f, -1.27209172e-01f, 1.08202361e-01f, -5.40473200e-02f, -8.96099675e-03f, 3.18668857e-02f, 1.31429777e-01f,
  1.74603853e-02f, -4.46015745e-02f, -4.76479419e-02f, 4.76987883e-02f, -3.43152927e-03f, -7.35012889e-02f, -4.96380031e-02f, -4.11489047e-03f, -1.15623558e-02f, -5.92583716e-02f,
  -3.84173729e-03f, 3.22861746e-02f, -4.74726483e-02f, 7.26773888e-02f, 1.09009752e-02f, -4.31788117e-02f, -1.73134618e-02f, 2.80767959e-02f, -1.26537643e-02f, -1.96029674e-02f,
  9.71013233e-02f, 5.15770242e-02f, 5.93574392e-03f, -7.26482272e-02f, 6.91617979e-03f, 1.54766282e-02f, 8.97539183e-02f, 4.79954062e-03f, 4.12351750e-02f, 1.34585947e-01f,
  1.94798157e-01f, -1.38167128e-01f, 1.76582441e-01f, 2.76838485e-02f, 3.20769986e-03f, 8.92213918e-03f, -4.79552615e-03f, 2.60700285e-02f, 9.54552516e-02f, 5.25235431e-03f,
  -1.22617576e-02f, 3.44674080e-03f, -5.71255162e-02f, -1.36105329e-01f, 6.39855042e-02f, -5.51954135e-02f, -6.07896633e-02f, 6.19265400e-02f, -1.64801273e-02f, 3.01147345e-03f,
  -8.20054784e-02f, 1.37222871e-01f, 2.64740825e-01f, -3.13712866e-03f, 9.65247396e-03f, 3.06887835e-01f, 1.08665891e-01f, 1.88049763e-01f, 1.77600443e-01f, 1.76434442e-01f,
  -1.49630070e-01f, -4.94223759e-02f, -3.14691633e-01f, -3.98832232e-01f, -2.88076222e-01f, -6.11433126e-02f, 8.37594196e-02f, 7.29329586e-02f, -2.08959226e-02f, -1.96438983e-01f,
  -3.15585248e-02f, -5.68811297e-02f, -1.11390859e-01f, -1.62099555e-01f, -5.94314598e-02f, -1.10924564e-01f, -1.88675329e-01f, -2.22175241e-01f, -1.94601454e-02f, -6.83675483e-02f,
  -1.74647361e-01f, -2.34416634e-01f, -2.03740135e-01f, -2.51371041e-02f, -6.58556595e-02f, -1.19151317e-01f, -1.01573564e-01f, -1.53129980e-01f, -8.80845934e-02f, -2.60691464e-01f,
  -3.83938223e-01f, -2.45912671e-02f, 5.17270342e-02f, -2.17350647e-02f, -1.50650993e-01f, 4.37048962e-03f, -9.09027755e-02f, 5.82178496e-02f, 1.08706728e-01f, -6.38379902e-02f,
  -1.23831794e-01f, -4.81901616e-02f, -1.39984153e-02f, -5.34801595e-02f, -8.68813619e-02f, -7.04209879e-02f, 8.10140595e-02f, -1.09674685e-01f, -7.82347023e-02f, 7.31566502e-03f,
  -6.65609911e-02f, 7.78834373e-02f, 1.69469967e-01f, 1.14537269e-01f, 1.00801878e-01f, 8.74125212e-02f, 3.34100649e-02f, 9.90085453e-02f, 7.59682879e-02f, -7.09944218e-02f,
  -6.48174807e-03f, -2.79627256e-02f, 4.09380235e-02f, 4.56448570e-02f, -3.16033028e-02f, 1.09165207e-01f, 5.15410490e-02f, 3.67220724e-04f, 9.82548669e-03f, 5.84356338e-02f,
  -2.07100753e-02f, -2.23263502e-02f, -1.47154974e-02f, -1.77454203e-02f, -1.02488231e-02f, 3.79709713e-02f, 3.32312621e-02f, -2.80485451e-02f, 5.05219661e-02f, 1.39835589e-02f,
  5.15120067e-02f, 9.33916420e-02f, -9.75987762e-02f, 5.13238683e-02f, -1.93850975e-02f, -3.41227166e-02f, -2.72072703e-02f, 3.02165560e-02f, 1.88778397e-02f, -3.58320959e-02f,
  -2.71584373e-03f, 1.04182146e-01f, -1.13085248e-01f, 9.77393836e-02f, 3.77370939e-02f, 2.35737069e-03f, 6.56892871e-03f, 7.55455494e-02f, -9.74833220e-02f, -1.11862473e-01f,
  9.13892612e-02f, -4.36229352e-03f, -6.41982257e-02f, 3.68835032e-02f, -3.98128070e-02f, 7.95920044e-02f, 7.59248901e-03f, 4.71452959e-02f, 1.50477201e-01f, 6.13225400e-02f,
  -2.97612641e-02f, 1.43229216e-01f, 8.96626413e-02f, 7.12077990e-02f, 1.35495618e-01f, 1.06848255e-01f, 1.19123265e-01f, 1.08728111e-01f, 1.00876033e-01f, -1.34624675e-01f,
  2.92392612e-01f, -7.25104630e-01f, 3.51330400e-01f, -7.67036006e-02f, -1.40681326e-01f, -1.23392999e-01f, -4.27535832e-01f, -2.38953933e-01f, -2.85774488e-02f, -2.31321007e-01f,
  -1.32636875e-01f, 1.57948270e-01f, 1.91238940e-01f, 1.82420805e-01f, 8.33617002e-02f, -2.16932565e-01f, -6.39598072e-02f, 4.40937608e-01f, 5.16701937e-01f, 2.65751034e-01f,
  -1.41003029e-02f, 3.87902036e-02f, 2.04844385e-01f, 2.70106606e-02f, -2.17459798e-01f, 2.73823999e-02f, -1.55684561e-01f, -1.56330794e-01f, -6.18049279e-02f, -1.54804438e-01f,
  3.27850908e-01f, -2.26131782e-01f, 2.34856740e-01f, -4.62244824e-02f, -7.02315988e-03f, 1.19088041e-02f, -1.50128184e-02f, 3.89183275e-02f, -7.42481947e-02f, -2.47558337e-02f,
  -2.98161972e-02f, 4.56754379e-02f, 3.74072418e-03f, 1.01029938e-02f, -1.39838845e-01f, -5.67266485e-03f, -1.52877730e-03f, 1.63148493e-01f, 2.57414971e-02f, -6.00338653e-02f,
  -1.94777757e-01f, -1.23540927e-02f, 6.72583133e-02f, -8.92216340e-03f, 8.85257050e-02f, 1.98321521e-01f, -1.02500163e-01f, 7.17356727e-02f, 1.64609507e-01f, -1.54482111e-01f,
  6.76253513e-02f, -2.55029593e-02f, 5.81296943e-02f, -1.37665821e-02f, 7.54502043e-02f, -1.75757781e-02f, -1.65129174e-02f, -7.47377845e-03f, 4.91365865e-02f, -3.32150199e-02f,
  2.80178748e-02f, 5.15376311e-03f, 2.66067367e-02f, -3.24417651e-02f, 1.92516185e-02f, -5.12463506e-03f, 7.86880497e-03f, -5.30642979e-02f, 2.16422062e-02f, 1.60902608e-02f,
  9.59962606e-02f, 5.19214533e-02f, -2.34183446e-02f, -1.55328428e-02f, 1.20387999e-02f, -6.45729974e-02f, 2.98974756e-02f, -5.58371730e-02f, 1.42443944e-02f, -1.49845649e-02f,
  -8.34298208e-02f, 1.82698146e-01f, -2.00046711e-02f, 4.82902303e-02f, 4.83179186e-03f, -8.53953231e-03f, -2.08598142e-03f, -1.77213065e-02f, 1.26119377e-02f, 1.97793767e-02f,
  -3.43163498e-02f, 3.52072939e-02f, -1.71183292e-02f, -3.36759500e-02f, 8.03330243e-02f, 9.38291289e-03f, -1.42701223e-01f, 6.12369739e-02f, -5.23866639e-02f, -8.25445876e-02f,
  -7.73744509e-02f, -4.66672778e-02f, 1.27027303e-01f, -1.59614328e-02f, 6.04608171e-02f, 1.10664368e-01f, 5.99898025e-02f, 3.38879302e-02f, 7.63261616e-02f, -1.62271217e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.54006809e-01f, 7.09358752e-01f, 4.02687728e-01f, -4.33043122e-01f, -4.20603529e-03f, 3.42487872e-01f, 5.36460698e-01f, 1.36474311e-01f, -2.50909120e-01f, 2.13742524e-01f,
  2.10894987e-01f, -4.65672344e-01f, -2.36400500e-01f, -1.95740044e-01f, 7.69434869e-02f, 3.54520887e-01f, 9.32342485e-02f, -1.93206280e-01f, -4.12246525e-01f, -2.70105451e-01f,
  -2.34762296e-01f, -3.64938855e-01f, -2.75749356e-01f, -2.83674389e-01f, -2.10852981e-01f, -3.54730070e-01f, 3.12017854e-02f, 8.86034742e-02f, 1.33398175e-01f, -1.07657760e-01f,
  2.49593496e-01f, 4.26664531e-01f, -3.22976977e-01f, -1.21397234e-01f, 4.09784429e-02f, -6.09727018e-02f, -1.96370464e-02f, -1.01021051e-01f, -3.06467861e-02f, 7.87958503e-02f,
  -5.47658131e-02f, -9.67483744e-02f, -7.24186823e-02f, 1.73431188e-02f, -5.63097633e-02f, 1.09465690e-02f, 3.81767973e-02f, 2.93469317e-02f, -4.22789082e-02f, 1.16377026e-01f,
  4.50179204e-02f, 2.32966125e-01f, 2.32158393e-01f, 6.39256835e-02f, 1.42896712e-01f, -8.14114809e-02f, 1.75752848e-01f, 9.68721807e-02f, 1.26502797e-01f, -5.01446007e-03f,
  6.56521693e-02f, -2.01558061e-02f, -3.97180356e-02f, -2.95030121e-02f, -2.75243800e-02f, -6.00603484e-02f, -3.57125029e-02f, 1.08493287e-02f, -7.31241331e-03f, -1.09819947e-02f,
  -2.92660147e-02f, 7.60008097e-02f, 3.17432880e-02f, 6.69389069e-02f, -7.53465481e-03f, -2.56295521e-02f, 7.08936155e-02f, -6.25020731e-03f, 8.12904611e-02f, -9.00156237e-03f,
  2.60255970e-02f, 7.64210150e-02f, -3.84833738e-02f, -5.95203266e-02f, 1.28256083e-01f, 2.70987172e-02f, 1.75966136e-02f, -4.69528213e-02f, -8.20341706e-03f, 1.04839064e-01f,
  -4.35084999e-01f, 2.49545351e-01f, -8.76131430e-02f, -1.69541314e-01f, 9.93171856e-02f, 6.61961287e-02f, 6.15901081e-03f, 1.02463840e-02f, 4.97057475e-02f, 1.58701614e-02f,
  6.46519810e-02f, -4.06110436e-02f, 1.34865597e-01f, -6.13560192e-02f, -8.84099156e-02f, -5.23080677e-02f, 4.61178310e-02f, -1.55003324e-01f, -4.99183424e-02f, 2.07247864e-02f,
  5.59791774e-02f, -7.25537017e-02f, -8.59549120e-02f, -2.54975148e-02f, 6.41485630e-03f, -2.40132064e-01f, -3.39364447e-02f, -1.17749155e-01f, -7.31463283e-02f, -5.94975334e-03f,
  -3.98000091e-01f, -2.28650719e-01f, -9.53309834e-02f, 3.19709837e-01f, 4.86521393e-01f, 4.53100711e-01f, 4.02472258e-01f, 3.59045148e-01f, 4.05462980e-01f, 1.18443362e-01f,
  -6.25196323e-02f, 6.00457937e-02f, 2.07326978e-01f, 4.52252254e-02f, 6.84621558e-02f, 2.58169651e-01f, 4.05028075e-01f, 2.20829509e-02f, 9.09274071e-02f, 1.27477631e-01f,
  1.49562076e-01f, 8.30134656e-03f, -1.69920757e-01f, -7.90423378e-02f, 1.17907412e-01f, 1.42216012e-01f, -4.27722819e-02f, -1.45058140e-01f, 2.20196992e-02f, 3.23268846e-02f,
  -3.66151839e-01f, -3.78825039e-01f, 2.30270922e-01f, 4.93817292e-02f, -1.44671619e-01f, -1.99908897e-01f, -1.22005828e-02f, -2.68366337e-01f, -8.05047229e-02f, 4.54132892e-02f,
  -6.50588572e-02f, -9.29054469e-02f, -3.39887701e-02f, -5.29002026e-02f, -8.46098065e-02f, -2.75084525e-02f, -2.08401933e-01f, -1.25372916e-01f, 2.54546925e-02f, -1.43141121e-01f,
  5.23132421e-02f, -1.21662602e-01f, -4.76270393e-02f, 6.66768178e-02f, 6.99095353e-02f, -3.39870416e-02f, -2.04057693e-01f, -3.11446209e-02f, -4.18625064e-02f, -5.10046706e-02f,
  1.14765383e-01f, 3.68746603e-03f, -2.75955927e-02f, 1.60566941e-02f, 4.37375829e-02f, -1.18939830e-02f, 3.52136008e-02f, 5.65734431e-02f, 7.09986268e-03f, -1.58277396e-02f,
  2.75748093e-02f, 2.23851390e-03f, 4.77022715e-02f, 1.76157225e-02f, 7.83866718e-02f, 4.79206070e-02f, -3.74039486e-02f, -7.05925166e-04f, -2.98562497e-02f, 5.30756265e-03f,
  -4.36007120e-02f, -6.74786558e-03f, -1.24371313e-01f, -2.64212606e-03f, 8.62608254e-02f, 1.97814610e-02f, 5.28871501e-03f, 2.33408958e-02f, 1.86661519e-02f, -3.55671421e-02f,
  9.90562290e-02f, 1.31054491e-01f, 1.16740502e-01f, -1.38429463e-01f, -4.38698940e-02f, -3.73770967e-02f, 1.20584816e-01f, -2.97971945e-02f, -4.45307083e-02f, 5.01723737e-02f,
  -1.65084347e-01f, -9.14455280e-02f, -5.40617667e-02f, -9.18061510e-02f, -4.21654619e-02f, 4.66390550e-02f, -4.93439473e-02f, 1.11762576e-01f, -1.04880137e-02f, -8.39043334e-02f,
  1.20879173e-01f, 1.07960321e-01f, 6.77754730e-02f, 2.48656794e-01f, 1.62557021e-01f, 1.98660702e-01f, -2.73641571e-02f, -4.18180972e-02f, 5.17317131e-02f, 1.03697218e-01f,
  6.47455513e-01f, 4.73033011e-01f, 3.44623953e-01f, 2.47936711e-01f, 1.76140621e-01f, 1.93395361e-01f, 3.04569751e-01f, 2.23835960e-01f, -6.33864105e-02f, 1.18179016e-01f,
  1.28076553e-01f, 1.51527505e-02f, 3.70536037e-02f, 1.33655891e-01f, 1.66344434e-01f, 7.32915998e-02f, 6.58985525e-02f, 9.99415219e-02f, 1.55610383e-01f, 1.21236928e-01f,
  -9.84660685e-02f, 8.94463584e-02f, 2.17871502e-01f, 5.69861196e-03f, 4.91603129e-02f, -5.69310561e-02f, 3.87445986e-02f, 8.59989896e-02f, 1.67061966e-02f, -4.37451974e-02f,
  4.33031879e-02f, 5.66912711e-01f, -1.81971878e-01f, -7.23741353e-02f, 2.19136216e-02f, -3.29141729e-02f, 7.45847672e-02f, -2.47248821e-02f, 1.84371993e-02f, -8.77336189e-02f,
  -6.84428662e-02f, 1.10054919e-02f, 6.29669502e-02f, -2.71630753e-02f, 1.34702642e-02f, -8.61264765e-02f, -5.13923541e-02f, 1.59902841e-01f, -2.53522652e-03f, -4.89037298e-03f,
  -1.39000058e-01f, 4.33232822e-02f, 5.76329306e-02f, -3.20134824e-03f, 1.71161339e-01f, -2.73263566e-02f, 9.70012173e-02f, -5.34323752e-02f, 3.83489137e-03f, -9.48326364e-02f,
  -2.65695378e-02f, 2.13842988e-02f, 7.36654103e-02f, -1.32708913e-02f, 9.73337591e-02f, -3.81413549e-02f, 7.74962408e-03f, 3.48681654e-03f, 1.22873755e-02f, 4.56180982e-02f,
  -3.78285646e-02f, 9.46100727e-02f, 1.32931154e-02f, 1.15813032e-01f, -4.77719354e-03f, 7.51730576e-02f, -7.52417036e-05f, 5.39150126e-02f, 6.55839667e-02f, 3.71177308e-02f,
  1.74834151e-02f, -4.29730453e-02f, -1.49324359e-02f, 3.82769406e-02f, 2.99605560e-02f, -1.22435531e-02f, 1.01728365e-02f, -1.32976109e-02f, -8.35331716e-03f, -3.60959917e-02f,
  -4.04126823e-01f, 2.30320901e-01f, -1.56426981e-01f, -6.15629777e-02f, -4.48280647e-02f, -1.10173792e-01f, -1.08863981e-02f, -8.71322528e-02f, -2.42477395e-02f, -3.77066061e-02f,
  8.76884349e-03f, 9.95026994e-03f, 5.97314304e-03f, -8.07347819e-02f, -6.09112717e-02f, -1.43741876e-01f, -2.05481350e-01f, -6.30788282e-02f, -1.13945261e-01f, -5.76753616e-02f,
  -1.34615466e-01f, -1.62666023e-01f, -7.16034025e-02f, -9.87655073e-02f, -3.38447243e-02f, -2.21117452e-01f, -1.64380595e-01f, -1.72168463e-01f, -7.48602524e-02f, -2.57828265e-01f,
  -4.45696652e-01f, 3.33046585e-01f, -1.52794138e-01f, 1.38523981e-01f, 5.00897348e-01f, 8.20522532e-02f, 2.42027454e-02f, -3.94872129e-01f, -1.06880240e-01f, 2.34562084e-01f,
  3.68165284e-01f, 1.46312296e-01f, -1.08719729e-01f, -2.53742814e-01f, -3.50017548e-01f, -3.46822999e-02f, 1.79262146e-01f, -2.96676487e-01f, -4.67311054e-01f, -1.46386579e-01f,
  3.18724960e-01f, 6.80436715e-02f, -2.07289681e-01f, -1.21714868e-01f, 2.83632547e-01f, 1.87823936e-01f, 1.45579040e-01f, 2.05714151e-01f, 2.86669314e-01f, 5.82324803e-01f,
  2.58743346e-01f, -1.57402325e-02f, -2.64319748e-01f, 2.13868901e-01f, 2.01531947e-01f, -1.65616021e-01f, 9.29070357e-03f, -2.13483319e-01f, 3.21837328e-02f, -4.09224816e-02f,
  2.50742257e-01f, 4.75282148e-02f, 5.34592234e-02f, -6.03064336e-02f, -1.51621148e-01f, -2.35455617e-01f, -2.96535343e-01f, -3.90718311e-01f, -2.73781359e-01f, -6.73539564e-02f,
  3.38309377e-01f, 3.16016763e-01f, -6.25135377e-02f, -2.29313731e-01f, -2.64321446e-01f, -9.87691619e-03f, -1.36108518e-01f, -1.52322829e-01f, -3.15500945e-01f, -1.86748445e-01f,
  2.47018412e-03f, 3.93402167e-02f, 1.46431588e-02f, -2.89580179e-03f, 1.51604572e-02f, 6.69270828e-02f, 5.44038378e-02f, 7.59161264e-02f, -2.99507901e-02f, 6.25877902e-02f,
  -8.07201713e-02f, 5.37474751e-02f, -6.13699667e-02f, -5.30697331e-02f, 7.70303383e-02f, 6.21974953e-02f, 4.91206236e-02f, -4.88643162e-02f, -5.32149300e-02f, 9.88794863e-03f,
  -2.41695885e-02f, 5.10038668e-03f, 6.48103952e-02f, -8.51747245e-02f, 5.98164536e-02f, -1.66146141e-02f, 3.39575969e-02f, 2.08143536e-02f, -8.41099173e-02f, 8.14416558e-02f,
  -2.24065825e-01f, -1.55993670e-01f, 1.74745289e-03f, -1.76840290e-01f, 8.81132036e-02f, -3.37093994e-02f, 1.30611196e-01f, -1.56715456e-02f, 1.25038564e-01f, -1.64606646e-01f,
  -6.40064105e-02f, -1.79066390e-01f, 1.99517957e-03f, -5.04107215e-02f, -6.13138564e-02f, -9.94580835e-02f, 1.32698596e-01f, -7.83130585e-04f, -1.99042454e-01f, 1.48304773e-03f,
  -2.18490101e-02f, -1.70086280e-01f, -2.86633521e-01f, -2.68565416e-01f, -8.46204311e-02f, -1.11818194e-01f, -1.86846957e-01f, -1.84048057e-01f, -4.74349141e-01f, -4.37244415e-01f,
  -4.98593301e-01f, -5.12875974e-01f, -1.72708593e-02f, -4.97993290e-01f, -2.02192172e-01f, -9.14450586e-02f, -2.42400348e-01f, -1.82350561e-01f, -2.25229740e-01f, -4.02961910e-01f,
  -2.40320355e-01f, -1.19698439e-02f, 6.99353889e-02f, 2.19216481e-01f, 2.28300840e-01f, -3.30449641e-02f, 1.21971674e-01f, 3.44086379e-01f, 3.43353122e-01f, 9.91411805e-02f,
  1.82198733e-02f, -1.74298305e-02f, 1.62775859e-01f, 1.53331431e-02f, -2.91881979e-01f, -7.53213018e-02f, -9.46051851e-02f, -1.41412362e-01f, 1.07779771e-01f, -3.11743200e-01f,
  -4.29950297e-01f, -3.63649607e-01f, 1.73320591e-01f, 6.87634349e-02f, -1.30246773e-01f, 2.48505268e-02f, -1.35652125e-01f, -1.02264613e-01f, -2.54988242e-02f, -1.75547183e-01f,
  -4.75337803e-02f, -9.76100340e-02f, -8.91207159e-02f, -7.57910311e-02f, -1.13702916e-01f, -5.81284128e-02f, 3.80046666e-02f, 8.51368904e-02f, 1.05186045e-01f, -1.33525617e-02f,
  -4.72067595e-02f, -1.67445838e-01f, -9.73473787e-02f, 7.53650293e-02f, -5.15168440e-03f, 1.02632247e-01f, -9.97063667e-02f, -2.40757186e-02f, 7.84581229e-02f, -3.59219134e-01f,
  5.20510748e-02f, -2.13529374e-02f, 6.80477843e-02f, -6.61791116e-02f, -2.50402000e-02f, -3.36919762e-02f, -1.82902087e-02f, -3.05105913e-02f, 6.13432080e-02f, -6.14296086e-02f,
  4.69943695e-02f, 8.26278701e-02f, -6.56948909e-02f, -1.00642867e-01f, -2.87978705e-02f, 8.96696746e-03f, 7.57140899e-03f, 1.64176710e-02f, 6.16889894e-02f, 9.95755382e-03f,
  4.82270159e-02f, 3.60816568e-02f, 1.40383095e-02f, 3.36393937e-02f, 6.95971027e-02f, 6.35283589e-02f, 2.27536801e-02f, 9.33344811e-02f, -1.36245349e-02f, -4.84559238e-02f,
  -4.70023990e-01f, 6.20442450e-01f, -3.54294211e-01f, 1.03517268e-02f, -9.35144275e-02f, 9.87681001e-03f, -1.20862328e-01f, 2.04200298e-02f, -4.46151458e-02f, -1.56985566e-01f,
  -1.13511235e-01f, -1.19028397e-01f, -1.57646492e-01f, 2.76137926e-02f, 3.31079438e-02f, -7.03280494e-02f, -8.39602724e-02f, -2.79018134e-02f, 1.37417570e-01f, -1.45325094e-01f,
  -6.91930810e-03f, -4.35397364e-02f, -1.82216868e-01f, -9.71381590e-02f, -9.30407047e-02f, 2.79725753e-02f, -8.81593600e-02f, -1.51948541e-01f, -1.92401092e-02f, -3.21533531e-01f,
  6.32054448e-01f, -1.26161277e-01f, -8.00580680e-01f, -9.13764313e-02f, -3.16749454e-01f, -3.74737382e-01f, -1.96265712e-01f, -1.58396754e-02f, 7.66288415e-02f, -9.64372754e-02f,
  -4.75823600e-03f, 1.61322206e-01f, 9.55865625e-03f, -8.35995600e-02f, 3.65069509e-02f, -2.87661701e-01f, -3.34251136e-01f, -2.13605553e-01f, -4.41309698e-02f, -2.00163554e-02f,
  -1.45099759e-01f, -3.23681235e-02f, 8.22202563e-02f, -1.34884566e-01f, -1.70534730e-01f, -2.27749541e-01f, -3.80067796e-01f, -3.36443394e-01f, -4.27685291e-01f, -4.18897003e-01f,
  -2.48087853e-01f, -1.63706273e-01f, -7.66270682e-02f, 1.61173880e-01f, -2.25113347e-01f, -1.76794939e-02f, -2.07530782e-02f, -1.40184969e-01f, 4.88297828e-02f, -1.84730336e-03f,
  -1.49056152e-01f, -5.46821617e-02f, -7.31688663e-02f, -1.34243205e-01f, -6.40247241e-02f, -1.10035658e-01f, -8.57190564e-02f, -2.27921903e-01f, -1.76575005e-01f, -2.13440269e-01f,
  -2.91897655e-01f, -2.11034685e-01f, -5.81528097e-02f, -1.43291101e-01f, -1.45609617e-01f, -1.42909840e-01f, -1.51706263e-01f, -1.95385128e-01f, -2.32161984e-01f, -1.05369575e-01f,
  -2.33804639e-02f, -3.03819198e-02f, -1.65328123e-02f, 2.27229036e-02f, 1.23328455e-01f, 2.22161766e-02f, -1.04219886e-02f, 5.12497984e-02f, 2.45303405e-03f, 1.11597456e-01f,
  -1.44227967e-02f, -1.59937143e-02f, 4.57116067e-02f, 6.23414479e-02f, 1.43496832e-02f, -1.09226674e-01f, 7.67855793e-02f, 4.56490777e-02f, 3.07659223e-03f, 4.14792150e-02f,
  3.86047140e-02f, -6.47833571e-02f, -3.43479440e-02f, -1.32070594e-02f, -1.26959950e-01f, -7.96563085e-03f, -1.27644353e-02f, 5.83629161e-02f, 4.46159579e-02f, -3.90583426e-02f,
  6.26203775e-01f, -2.99663879e-02f, 1.20102577e-01f, 1.21375836e-01f, -9.85710248e-02f, -4.87338454e-02f, 9.86570842e-04f, 9.00729559e-03f, 4.33134362e-02f, -4.39590290e-02f,
  -5.51080815e-02f, 2.18414422e-02f, 6.60270527e-02f, -2.72825677e-02f, 1.76797975e-02f, 3.53967771e-02f, 2.22408734e-02f, -3.39443944e-02f, -1.51764322e-02f, -4.41371724e-02f,
  -5.40963784e-02f, 2.53968686e-01f, 4.95065033e-01f, 1.57695413e-01f, -1.74540486e-02f, 1.76947296e-01f, 8.98862556e-02f, -8.61147977e-03f, 1.98648706e-01f, 4.52585816e-01f,
  5.56816101e-01f, 3.82449329e-01f, 6.63024858e-02f, 3.96808296e-01f, -4.89746541e-01f, -5.50818503e-01f, -5.69599330e-01f, -1.72693312e-01f, 2.19985664e-01f, 1.69695958e-01f,
  -2.30924278e-01f, -2.46323884e-01f, -1.37547031e-01f, -2.10398510e-01f, -1.68296054e-01f, 1.94072142e-01f, 3.01318198e-01f, -6.22196496e-02f, -4.51632589e-01f, -5.16923189e-01f,
  -8.15625116e-02f, 8.25575590e-02f, 2.34958425e-01f, 9.85613465e-02f, 2.73583740e-01f, 2.13183910e-02f, 3.39541107e-01f, 8.39065462e-02f, -2.61421204e-02f, 4.33522910e-01f,
  -2.75000464e-02f, -5.13344363e-04f, -2.22784489e-01f, -4.76149619e-02f, -1.16608292e-01f, -5.25946205e-04f, -1.27191469e-01f, 4.65477072e-02f, -7.01495931e-02f, 9.57187414e-02f,
  -1.17876545e-01f, -8.62894431e-02f, -8.64991993e-02f, -1.93318054e-02f, -1.00439668e-01f, -1.31214395e-01f, 1.96394086e-01f, 1.62351236e-01f, 4.30389196e-02f, -6.80008009e-02f,
  -1.56328559e-01f, -2.20501393e-01f, -1.97737813e-01f, -1.85573533e-01f, -7.26397336e-02f, -1.88318551e-01f, -1.24293916e-01f, -6.03962466e-02f, -1.62842736e-01f, 3.34350705e-01f,
  3.03797256e-02f, -4.71066721e-02f, -4.11096625e-02f, 2.26766206e-02f, 6.43800199e-03f, -1.33773210e-02f, 3.47833633e-02f, -2.41480209e-03f, 4.21318077e-02f, 5.10261208e-02f,
  -1.35535384e-02f, -6.94194669e-03f, 4.62271925e-03f, 2.28162445e-02f, 6.49618879e-02f, 2.77447198e-02f, -7.05777630e-02f, 8.75270963e-02f, -2.07143445e-02f, 1.11155286e-01f,
  -3.80428359e-02f, -2.08422858e-02f, 5.50382771e-02f, 1.98719352e-02f, -1.44418562e-02f, 4.46776003e-02f, 1.56007903e-02f, -9.29701999e-02f, 9.54082906e-02f, -1.17182801e-03f,
  1.91808179e-01f, -4.19181615e-01f, 1.18118361e-01f, 1.07867466e-02f, 8.14793482e-02f, 3.98745276e-02f, 2.35485137e-02f, 7.76455849e-02f, -5.06379902e-02f, -5.26302233e-02f,
  -2.18860701e-01f, -7.45720640e-02f, -2.58262642e-02f, -3.94048579e-02f, -1.29943803e-01f, -6.89905137e-02f, 7.80388340e-02f, -4.61131036e-02f, -1.25248402e-01f, 7.86002278e-02f,
  1.23945892e-01f, -5.39907888e-02f, -1.50738850e-01f, -2.40598023e-02f, -1.57486051e-02f, -2.45125845e-01f, -1.35354117e-01f, -9.20638889e-02f, -2.22786441e-01f, 4.21035141e-01f,
  -1.00289154e+00f, 7.54062086e-02f, 3.33354175e-01f, -5.36346495e-01f, -1.21299960e-01f, 1.36333466e-01f, 2.14846671e-01f, -1.91603899e-01f, -3.66736174e-01f, 2.56756321e-02f,
  6.71736225e-02f, -5.50711602e-02f, 2.86350306e-02f, 3.08981314e-02f, 1.05389446e-01f, 3.03766549e-01f, 5.29085696e-02f, -1.10951342e-01f, -2.95144394e-02f, -1.25576317e-01f,
  -1.52449319e-02f, -3.71093541e-01f, -4.07092214e-01f, -1.88656151e-01f, -1.22635707e-01f, -6.71463534e-02f, -3.90537158e-02f, -9.22740027e-02f, 2.70680748e-02f, 8.47334638e-02f,
  8.56530547e-01f, -4.77492750e-01f, 1.17693983e-01f, -2.11560994e-01f, 1.02263382e-02f, -1.49714947e-01f, -7.10432157e-02f, -6.79136813e-02f, -6.68624938e-02f, 3.48126441e-02f,
  -1.46604508e-01f, -1.63915515e-01f, -1.17589414e-01f, 4.89441194e-02f, -1.04771212e-01f, -1.05710095e-02f, -8.88058394e-02f, -1.50603190e-01f, -1.25592500e-01f, 1.00732103e-01f,
  -2.26874370e-02f, -1.16548419e-01f, -9.57392454e-02f, 6.75395411e-03f, -5.97433373e-02f, -9.67639610e-02f, 1.19091853e-01f, -9.21278447e-02f, -7.72757530e-02f, 6.78477511e-02f,
  3.03372517e-02f, 5.13415560e-02f, 8.92987847e-03f, -5.31723499e-02f, 2.87136920e-02f, 2.52749529e-02f, 9.26970318e-02f, 2.26070173e-02f, -5.33188321e-02f, 6.48393929e-02f,
  6.12597866e-03f, 4.29603420e-02f, 9.34589505e-02f, 1.62853375e-02f, 6.98778033e-02f, -3.88354063e-02f, 4.18059006e-02f, 4.12395522e-02f, -2.06665285e-02f, -8.52178112e-02f,
  -5.79015389e-02f, 1.12457760e-02f, -1.02858774e-01f, 1.14809580e-01f, -1.47700831e-02f, -1.05323372e-02f, 9.00270045e-03f, -5.66723496e-02f, -1.56511497e-02f, -1.03029832e-01f,
  3.88363272e-01f, -1.64751038e-01f, 8.01994577e-02f, -9.57975909e-02f, -7.25238025e-02f, -1.21030867e-01f, 5.57662360e-02f, -8.11090469e-02f, -3.28988694e-02f, 1.89414271e-03f,
  -2.63854899e-02f, 6.62218593e-03f, 9.17910337e-02f, -1.42781093e-04f, -1.03613511e-02f, -4.80372682e-02f, -1.01356581e-01f, -5.00727259e-02f, 1.29780145e-02f, 3.78526151e-02f,
  -2.52796616e-02f, 3.84699879e-03f, 7.79849738e-02f, 2.01243162e-01f, 3.38764153e-02f, -3.10115423e-02f, 2.96420246e-01f, 1.58679247e-01f, 1.06048524e-01f, 2.41057023e-01f,
  -4.56232101e-01f, -3.52110803e-01f, -2.55985707e-01f, -1.18414417e-01f, 4.64555658e-02f, -1.84702694e-01f, -5.68558097e-01f, -3.28651905e-01f, 2.22083856e-03f, -1.77843466e-01f,
  9.35754701e-02f, -3.70719172e-02f, -1.31467938e-01f, -3.00105035e-01f, -6.26964569e-01f, -5.99934995e-01f, -5.62571406e-01f, -5.23090065e-01f, -3.14174563e-01f, -3.96096036e-02f,
  -1.12753682e-01f, -1.09797388e-01f, -2.35868216e-01f, -6.13636598e-02f, 1.86901927e-01f, 3.23087759e-02f, 2.82210521e-02f, 2.88177766e-02f, 1.93056632e-02f, -8.20178688e-02f,
  1.06580034e-01f, 5.96767962e-02f, 6.62142336e-02f, 3.08590718e-02f, 1.16543069e-01f, -1.56963861e-03f, -8.13941732e-02f, -8.54169717e-04f, 6.27108514e-02f, -1.01872332e-01f,
  8.85636210e-02f, 4.37114313e-02f, 6.52532801e-02f, 3.34857753e-03f, -4.57954593e-02f, -6.32628202e-02f, -1.79371223e-01f, -2.04354286e-01f, -1.53144166e-01f, -3.74397822e-02f,
  8.59119892e-02f, -1.17046900e-01f, -3.26456308e-01f, -1.65041983e-01f, -4.11227979e-02f, -4.21500243e-02f, -5.18746190e-02f, 4.52745557e-02f, -4.23248559e-02f, -1.22491360e-01f,
  3.04257106e-02f, -4.22310978e-02f, 9.16476920e-02f, -3.59521396e-02f, -2.46601030e-02f, 8.86443481e-02f, -3.98695879e-02f, -2.28642412e-02f, -5.89275993e-02f, -2.13174359e-03f,
  4.46521677e-02f, 2.57660113e-02f, 7.68949017e-02f, -1.81393945e-04f, -1.18995681e-02f, 4.53748694e-03f, -5.82850203e-02f, -9.46410298e-02f, -5.95399141e-02f, -2.63682194e-03f,
  -2.15896834e-02f, 1.07572682e-01f, 4.36681286e-02f, 3.15244123e-03f, 7.26292515e-03f, -4.14673425e-02f, 7.14584216e-02f, 6.75866380e-02f, 2.75285244e-02f, 4.62562144e-02f,
  3.52259278e-02f, -1.33407012e-01f, -1.47490770e-01f, -4.83058691e-02f, -1.74364243e-02f, 3.36479247e-02f, 1.17428139e-01f, 2.34428290e-02f, 1.47053048e-01f, -1.11238182e-01f,
  2.42026672e-02f, -7.71129206e-02f, -4.34064455e-02f, -4.06349450e-02f, -4.11963128e-02f, -8.84801447e-02f, -1.98997438e-01f, -1.89284801e-01f, -1.85312256e-01f, 1.08380809e-01f,
  -1.91258088e-01f, -3.64054739e-01f, -5.26036620e-01f, -2.11591035e-01f, -5.49802035e-02f, -2.49614775e-01f, -2.41850302e-01f, -7.59487078e-02f, -3.55044037e-01f, -4.96907651e-01f,
  2.92932361e-01f, -2.02411249e-01f, 7.16041684e-01f, 1.96130142e-01f, 3.71693373e-01f, 5.37042141e-01f, 3.94417465e-01f, 1.99154362e-01f, -3.25104706e-02f, -7.39613995e-02f,
  -2.79637039e-01f, -5.61341882e-01f, -5.05219102e-01f, -4.57294971e-01f, -2.61610836e-01f, 1.63558692e-01f, 1.52342066e-01f, 2.48730928e-01f, 2.77245879e-01f, 1.55829534e-01f,
  -1.28459543e-01f, 1.14113197e-01f, 1.43521681e-01f, -2.11589560e-02f, -5.46006300e-02f, -8.04305002e-02f, 1.11162476e-02f, 7.54948426e-03f, -9.11469460e-02f, 2.96996557e-03f,
  1.62811995e-01f, 1.11750916e-01f, -5.54473558e-03f, -3.73489380e-01f, -1.20529190e-01f, -1.16515025e-01f, 8.26817155e-02f, -3.08990125e-02f, -2.30897609e-02f, 1.07051224e-01f,
  -1.11518912e-01f, -5.70726134e-02f, -8.66847932e-02f, -2.09444761e-02f, 1.25677794e-01f, 3.67779918e-02f, -7.14270771e-02f, 1.94089673e-02f, -2.39107862e-01f, -1.61245421e-01f,
  -3.58762980e-01f, 7.98473358e-02f, 1.92453563e-01f, -5.60438856e-02f, -8.45965669e-02f, -6.47660494e-02f, -1.27204970e-01f, -8.13628808e-02f, -5.16272783e-02f, 4.17009555e-02f,
  -4.12843302e-02f, -1.49884149e-02f, 8.98907613e-03f, -4.39826660e-02f, -8.41116253e-03f, 2.32105656e-03f, 1.36836588e-01f, -2.61939447e-02f, 8.87844786e-02f, 1.67370409e-01f,
  -1.61349904e-02f, 1.80726647e-02f, 4.93347533e-02f, 2.93393638e-02f, -7.35389292e-02f, 4.09756899e-02f, 1.11852087e-01f, -5.15151583e-02f, -2.37976611e-02f, 9.82144848e-02f,
  2.75593586e-02f, 5.04211336e-02f, -1.05942087e-02f, -2.31945384e-02f, -3.63412648e-02f, -3.17694806e-02f, 3.67409885e-02f, -9.24976394e-02f, -4.00082022e-02f, 2.47657765e-02f,
  -1.25384748e-01f, -1.62710503e-01f, -3.78716104e-02f, -1.08290546e-01f, 9.25899968e-02f, -7.13938475e-02f, -1.12283014e-01f, -1.90842561e-02f, -2.99111363e-02f, 1.10124618e-01f,
  -7.49451891e-02f, -1.20765798e-01f, -2.72851624e-02f, 4.84984182e-02f, 2.23269045e-01f, 1.84747294e-01f, -1.65700257e-01f, 4.15693596e-02f, -1.46269351e-01f, -2.22928151e-02f,
  -1.01641722e-01f, 2.77266920e-01f, 3.31009209e-01f, 1.78543359e-01f, -1.57903358e-02f, -3.49618960e-04f, 1.75770923e-01f, 8.58755112e-02f, 1.53974801e-01f, 1.27059788e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.46118605e-01f, 2.33750895e-01f, 3.16467702e-01f, 3.39241982e-01f, 5.54028094e-01f, 4.78953630e-01f, 7.91632771e-01f, 3.02417159e-01f, 2.55832076e-01f, 4.22136217e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  1.09840184e-03f, -4.64437455e-01f, 3.52981947e-02f, -3.09978694e-01f, 1.97392702e-01f, 3.04430783e-01f, -7.06124961e-01f, -1.22829117e-01f, -2.35891223e-01f, -6.88347578e-01f,
  3.70062530e-01f, 5.96786797e-01f, -6.97522163e-01f, -6.93751395e-01f, 1.10859573e+00f, -3.34722817e-01f, -4.96531665e-01f, -6.36163831e-01f, -2.45187417e-01f, 6.78381503e-01f,
  2.48291671e-01f, 8.07266474e-01f, -4.94282812e-01f, 4.67754394e-01f, 7.26769507e-01f, -6.88757539e-01f, 3.60162824e-01f, 1.23201931e+00f, -5.32451153e-01f, -4.92553771e-01f,
  -3.57233912e-01f, -3.72128516e-01f, 4.40508962e-01f, 6.77709222e-01f, -2.33342826e-01f, -2.47386336e-01f, -5.02153397e-01f, 9.11620438e-01f, -3.28689903e-01f, -3.69150221e-01f,
  -5.79951257e-02f, -4.57147479e-01f, 1.34451139e+00f, -5.81593633e-01f, 3.23516965e-01f, -8.98409560e-02f, 1.55191600e-01f, -2.83893108e-01f, -7.82715082e-01f, -3.40294391e-01f,
  -3.35726552e-02f, -3.45511921e-02f, 5.20378172e-01f, -3.74119759e-01f, 1.16811454e+00f, -1.69034451e-01f, -3.90755028e-01f, 2.45866999e-01f, 7.44282782e-01f, -5.73914647e-01f,
  -6.73208416e-01f, 7.56058633e-01f, 2.98453212e-01f, -1.48125932e-01f, 8.75293557e-03f, 5.31521216e-02f, -1.68891892e-01f, -7.38894701e-01f, 9.83510613e-01f, -2.15919495e-01f,
  2.95204848e-01f, 5.95467910e-02f, -4.07054454e-01f, 1.33357393e-02f, -5.00834286e-01f, -1.95932284e-01f, 7.81826019e-01f, 9.94871780e-02f, 1.12434161e+00f, -4.00657982e-01f,
  2.21947819e-01f, 3.24327946e-01f, 4.80346173e-01f, 3.95717978e-01f, 6.37231410e-01f, -9.24752593e-01f, -3.02533954e-02f, 3.86121780e-01f, -1.30346864e-01f, -2.40929425e-01f,
  -4.97185439e-01f, 1.16420126e+00f, 8.30261469e-01f, -2.20252857e-01f, -2.97467083e-01f, -1.06142133e-01f, 3.71244758e-01f, -4.04731125e-01f, 6.58779562e-01f, 1.36860818e-01f,
  -9.10669148e-01f, -3.59535627e-02f, -1.01632938e-01f, -6.81185901e-01f, 6.29509687e-01f, -2.06485227e-01f, -2.74208844e-01f, -3.97826374e-01f, 1.27267611e+00f, -2.58571237e-01f,
  -8.25424552e-01f, 5.00371829e-02f, -6.24099314e-01f, -9.21867043e-02f, -6.30895376e-01f, -5.90814471e-01f, -4.02435213e-01f, -4.98325676e-01f, -4.52496111e-01f, 9.05028403e-01f,
  -2.64289677e-01f, 8.74590158e-01f, 1.75619557e-01f, -9.93109494e-02f, 4.34776135e-02f, 1.51497811e-01f, -3.34511787e-01f, -3.23583156e-01f, -9.55117121e-02f, 3.45183969e-01f,
  -1.25969768e-01f, 3.41431111e-01f, -7.19188973e-02f, 3.52393776e-01f, -3.85568321e-01f, 3.66673768e-01f, -4.08205688e-01f, -3.82715762e-01f, -1.47974730e-01f, 1.08263204e-02f,
  -5.71512356e-02f, -6.71807968e-04f, -4.62706506e-01f, 1.69733727e+00f, 4.91197467e-01f, 7.78196007e-02f, 5.19890547e-01f, 3.49270344e-01f, -3.60158712e-01f, 7.53966272e-02f,
  -5.43734014e-01f, -3.44094515e-01f, -2.17933252e-01f, 1.52994490e+00f, -3.39912951e-01f, -4.30156767e-01f, 2.88776070e-01f, -2.98984110e-01f, 5.38025260e-01f, -3.58197600e-01f,
  2.49745384e-01f, 1.60067350e-01f, -7.21325204e-02f, 1.21354155e-01f, -8.58176425e-02f, 1.70067415e-01f, -5.94755933e-02f, -2.94080704e-01f, -4.57590789e-01f, -3.15655977e-01f,
  -4.41908598e-01f, 2.84371346e-01f, -4.65038747e-01f, 1.52284634e+00f, -2.60481060e-01f, 7.92014226e-02f, 3.14245999e-01f, 2.93533295e-01f, -2.94964105e-01f, -2.33418018e-01f,
  -1.38614997e-01f, -3.92998964e-01f, 1.18437338e+00f, -6.20013177e-01f, 8.01226676e-01f, 2.71564662e-01f, -4.34867322e-01f, -1.57141119e-01f, -4.94314164e-01f, -9.54179615e-02f,
  -3.49552423e-01f, 5.11465371e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.61655563e-01f, 4.59556967e-01f, 3.29351634e-01f, -3.18201303e-01f, -2.44572908e-01f, 3.03107679e-01f, 2.53758878e-01f, -3.34292531e-01f, -1.71863943e-01f, -8.76014829e-02f,
  1.64657906e-02f, -1.57118082e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    