/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.45241804e-02f, 2.39245594e-01f, 1.21744119e-01f, 3.20281059e-01f, -2.75285035e-01f, -2.53271431e-01f, 1.03086881e-01f, -1.04649022e-01f, -8.04889947e-02f, 5.69749884e-02f,
  8.05932749e-03f, 2.55073309e-01f, 3.18719208e-01f, 8.41978714e-02f, 2.86458641e-01f, 2.56981105e-01f, 1.74949199e-01f, 2.56307013e-02f, -1.86588503e-02f, 2.96841823e-02f,
  1.16727844e-01f, -1.06977103e-02f, 2.50258803e-01f, -2.52983183e-01f, -1.69667408e-01f, 1.11436681e-03f, 1.49178728e-01f, -3.28984261e-02f, -9.41716805e-02f, 1.10405259e-01f,
  -8.34483057e-02f, -5.56162037e-02f, 5.42001985e-02f, 3.55101936e-02f, 4.34625819e-02f, -4.30253781e-02f, 1.13881730e-01f, -3.50899585e-02f, -1.21724844e-01f, -1.75563863e-03f,
  3.31820510e-02f, -3.86999436e-02f, 8.11278224e-02f, -1.21939406e-01f, -1.55836120e-01f, 1.15742851e-02f, -1.15514763e-01f, -6.21625297e-02f, -4.12601307e-02f, -5.62942661e-02f,
  -1.89032962e-05f, 1.40515253e-01f, 1.01164624e-01f, 1.62749872e-01f, -1.71072222e-02f, 1.83631759e-02f, 2.48886328e-02f, 1.13523535e-01f, 1.21679939e-02f, 8.25236663e-02f,
  3.72881666e-02f, 8.46870095e-02f, -5.76820550e-03f, -2.96024270e-02f, -1.02720670e-01f, -8.68369490e-02f, -3.90675813e-02f, -9.81752668e-03f, 6.46079034e-02f, 7.82994330e-02f,
  3.72126438e-02f, 4.62698191e-02f, 3.06801815e-02f, -8.37310776e-02f, 1.16490982e-01f, 3.43627520e-02f, -5.98492566e-03f, 1.58391725e-02f, 9.18050185e-02f, -7.50612095e-02f,
  -1.19555392e-03f, -4.89750206e-02f, 6.89336807e-02f, 3.91867869e-02f, -2.01035757e-02f, 3.49548645e-02f, -2.89626811e-02f, -1.58739716e-01f, -7.77126476e-02f, 7.15493411e-02f,
  1.07645407e-01f, 1.77498862e-01f, 7.96686336e-02f, -1.46741644e-02f, -2.53917184e-02f, -7.09074661e-02f, -3.92364152e-02f, -8.15175176e-02f, 2.02960260e-02f, -8.70404541e-02f,
  1.31838322e-02f, -8.02473426e-02f, -7.50852898e-02f, -7.88202733e-02f, 8.16331338e-03f, -6.36268184e-02f, 6.30299598e-02f, 6.21054359e-02f, 2.66859978e-01f, 7.00560457e-04f,
  8.17656890e-03f, -1.26678988e-01f, 3.53129096e-02f, -3.25485989e-02f, -1.17283344e-01f, 9.60284844e-02f, -7.40832761e-02f, -5.94817363e-02f, -2.96033099e-02f, 3.79762501e-02f,
  7.78576359e-02f, 9.51770768e-02f, 5.30568175e-02f, 2.71611184e-01f, 1.18963979e-01f, -4.63429183e-01f, -3.69779289e-01f, 7.87548572e-02f, 4.48718481e-02f, -3.76871042e-02f,
  -1.10755369e-01f, 3.20481628e-01f, -2.59933472e-01f, -6.34135231e-02f, -3.54933470e-01f, -2.40323946e-01f, -1.69929191e-01f, -5.96819483e-02f, 4.97642681e-02f, 1.87291317e-02f,
  1.36958538e-02f, -3.26131545e-02f, -6.53975233e-02f, 1.34893432e-01f, 2.04462737e-01f, 2.93973267e-01f, 1.38676181e-01f, 4.31964062e-02f, 2.55015731e-01f, -4.50768508e-03f,
  -1.32141694e-01f, 9.14180428e-02f, 1.41312510e-01f, -1.93411652e-02f, 1.73462778e-02f, -1.87536068e-02f, -3.28105912e-02f, 7.85600860e-03f, -4.25201692e-02f, -9.09528974e-03f,
  2.02431772e-02f, -8.21504444e-02f, 3.58642377e-02f, 1.11819245e-01f, -2.52715293e-02f, 1.32546082e-01f, -3.91392261e-02f, -9.01810080e-02f, 8.89735296e-02f, 8.28447193e-02f,
  -1.90181844e-02f, -5.49671091e-02f, -7.44976401e-02f, -1.46306725e-02f, 1.84575915e-02f, 2.53136344e-02f, -1.89750325e-02f, -2.69076470e-02f, -2.09384337e-02f, 1.50397852e-01f,
  -3.47745679e-02f, 5.65363728e-02f, 3.47124189e-02f, 7.83051699e-02f, -2.61097103e-02f, 6.49056062e-02f, -1.36720892e-02f, -1.16076926e-02f, -4.12023440e-03f, -5.54396883e-02f,
  -1.81415677e-02f, -7.82789197e-04f, 7.57075846e-02f, 8.98918435e-02f, 1.05064129e-02f, 1.07633933e-01f, -6.53339103e-02f, 6.55336380e-02f, -4.30210084e-02f, 9.27630141e-02f,
  1.59435929e-03f, -7.92549551e-02f, 5.34162223e-02f, -1.00029662e-01f, -1.51379660e-01f, 4.65124473e-02f, 5.04690744e-02f, 2.20242236e-02f, -4.17307280e-02f, -7.40514249e-02f,
  -2.10885018e-01f, 1.51319474e-01f, 1.64605454e-02f, -3.71463993e-03f, -2.78630853e-02f, -3.61578986e-02f, 3.63273639e-03f, 3.44079435e-02f, -9.12863109e-03f, -1.17695855e-03f,
  -4.23843181e-03f, -3.40537503e-02f, 1.79731566e-02f, -4.74860631e-02f, -5.70893474e-02f, -6.87178746e-02f, -9.78212152e-03f, 5.43803573e-02f, -1.89574957e-02f, -9.39784478e-03f,
  -2.19531842e-02f, -3.18643488e-02f, -5.39529920e-02f, -1.34239504e-02f, -1.08022109e-01f, -4.95095388e-04f, 9.56706926e-02f, 6.34841695e-02f, 4.30868492e-02f, -3.90956998e-02f,
  -1.61821783e-01f, -4.03534621e-01f, -9.86633897e-02f, 1.43915027e-01f, 2.36858621e-01f, -1.32938027e-01f, -2.41841108e-01f, 1.53520539e-01f, -8.40178281e-02f, -2.02245623e-01f,
  7.99401626e-02f, -4.76910830e-01f, -2.07166687e-01f, 2.23451611e-02f, -6.75294548e-02f, -2.44061574e-01f, 1.42533958e-01f, -4.26481329e-02f, 2.13650838e-02f, 6.92051426e-02f,
  2.09515452e-01f, 1.74102843e-01f, 1.72981948e-01f, 2.12476045e-01f, 2.71635950e-01f, 7.57322982e-02f, 2.82237023e-01f, -5.30088693e-02f, 1.23195492e-01f, -6.80530071e-02f,
  -6.74301982e-02f, -5.25840595e-02f, 6.35135919e-02f, 4.78497967e-02f, 1.36906683e-01f, 4.11981121e-02f, 9.03014243e-02f, -1.34432584e-01f, 3.82551225e-03f, -8.86207148e-02f,
  5.61384484e-03f, 3.99377458e-02f, -2.06206273e-02f, -7.90795013e-02f, 6.68301061e-02f, 5.16794510e-02f, 7.58491307e-02f, 2.26659313e-01f, -3.75945121e-02f, 5.46732992e-02f,
  -5.26205078e-02f, 9.22062900e-03f, 1.92990992e-02f, 3.64636891e-02f, -8.62189755e-03f, 1.41543932e-02f, -7.26674944e-02f, -4.10403162e-02f, 6.98645711e-02f, -4.41073300e-03f,
  6.20741099e-02f, 1.21619916e-02f, -5.25027551e-02f, -5.31181805e-02f, -8.37028995e-02f, 8.15996006e-02f, -9.98345688e-02f, -3.85568738e-02f, 4.29319330e-02f, 2.43172375e-03f,
  8.01990554e-03f, -2.65119858e-02f, 5.97638525e-02f, 4.99082915e-02f, 8.96344855e-02f, -7.65797496e-02f, -1.03500627e-01f, -3.38095687e-02f, 9.69011262e-02f, 3.30870003e-02f,
  -5.01767993e-02f, 1.07937537e-01f, -4.07198481e-02f, 1.59276336e-01f, -5.44847623e-02f, -6.35859743e-02f, 1.45454526e-01f, 5.26849516e-02f, 8.94385055e-02f, 2.26882324e-02f,
  -1.48182334e-02f, -6.20117038e-02f, -5.93461171e-02f, -1.61082447e-02f, -1.06068157e-01f, -2.08247323e-02f, -6.73542768e-02f, 1.67166814e-02f, -6.01354390e-02f, 3.61236669e-02f,
  1.77704677e-01f, 4.23535518e-02f, -5.92062585e-02f, 1.96854938e-02f, 7.26014376e-02f, 6.88443631e-02f, 8.16684961e-03f, 1.32585643e-02f, 1.98283512e-02f, 5.41125014e-02f,
  6.11395054e-02f, -1.30754104e-03f, 4.01888508e-03f, 1.69935614e-01f, 1.01028882e-01f, -1.46178044e-02f, -8.53307471e-02f, -5.26887588e-02f, 3.16255353e-02f, -5.01168668e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.17121696e-01f, -3.70495953e-02f, -2.06434295e-01f, 3.28356951e-01f, 1.28221333e-01f, 2.27740675e-01f, -2.18064815e-01f, 1.44665405e-01f, -1.16921805e-01f, -3.09299678e-01f,
  -1.04852073e-01f, -5.39040044e-02f, -5.99485636e-01f, 3.81625265e-01f, 5.63671529e-01f, -2.65219450e-01f, 6.38867199e-01f, 1.80928811e-01f, 1.15369193e-01f, 3.46864998e-01f,
  3.69683713e-01f, 6.16865873e-01f, 8.19709823e-02f, 4.49927896e-01f, 3.62179786e-01f, -1.62873734e-02f, 1.82246804e-01f, -2.09020674e-01f, 2.12590784e-01f, 2.28956550e-01f,
  2.87568662e-02f, -2.75073182e-02f, 9.09402370e-02f, 6.39018193e-02f, 3.60290557e-02f, 4.30577919e-02f, -8.59412849e-02f, -1.10880010e-01f, 1.21900695e-04f, -1.72766298e-01f,
  -4.44667740e-03f, 8.97162557e-02f, 2.08069623e-01f, -5.19604795e-02f, 1.96929783e-01f, 8.59623551e-02f, -5.49172610e-02f, -5.47959022e-02f, -1.12537600e-01f, -4.79579158e-02f,
  -8.38342239e-04f, -5.59946820e-02f, 1.43484801e-01f, -3.11378874e-02f, -3.04319635e-02f, 4.19113971e-02f, -9.87261310e-02f, -2.15954453e-01f, -5.93223833e-02f, 1.88258454e-01f,
  4.92339283e-02f, -9.97551605e-02f, 8.21171999e-02f, -9.25744846e-02f, 1.02939755e-01f, -5.86215220e-02f, 7.90809244e-02f, -7.22470284e-02f, 8.47641826e-02f, -7.90276937e-03f,
  4.21819650e-02f, 4.65209894e-02f, 3.81778963e-02f, -1.98841449e-02f, 1.79238096e-01f, 1.18241526e-01f, -7.71976933e-02f, -3.64593901e-02f, 6.30350113e-02f, -3.77919860e-02f,
  -1.61902830e-02f, 1.45305499e-01f, -4.32558469e-02f, -5.12288995e-02f, 9.44487005e-02f, -1.11295670e-01f, -3.42324451e-02f, -1.72197185e-02f, -1.64911464e-01f, 4.89327200e-02f,
  -3.59709747e-02f, 1.62693590e-01f, -6.87000081e-02f, -3.23902182e-02f, -3.80742699e-02f, 2.00244546e-01f, 9.90967005e-02f, 1.38258055e-01f, 1.19541854e-01f, 5.76170348e-02f,
  5.77302687e-02f, -8.13875161e-03f, -6.35893419e-02f, 2.57259533e-02f, 8.63250196e-02f, 3.28332745e-02f, -8.08328167e-02f, 2.30662879e-02f, 8.55535716e-02f, -3.75364833e-02f,
  -6.01914106e-03f, -1.41528603e-02f, 7.82438517e-02f, 2.95268483e-02f, 4.76327278e-02f, -1.59980595e-01f, 5.80666214e-02f, -6.33012056e-02f, -7.59819150e-02f, -9.63803660e-03f,
  -9.04238641e-01f, 3.41198325e-01f, -5.84026098e-01f, -4.09877837e-01f, -9.44658592e-02f, -6.00423932e-01f, -1.90603212e-01f, -1.95914969e-01f, -1.46162674e-01f, 3.83827955e-01f,
  3.00291538e-01f, -2.18614072e-01f, 4.47900146e-01f, -1.93831742e-01f, -6.29839122e-01f, 2.13477835e-01f, -3.04401040e-01f, -9.62080210e-02f, -8.98533240e-02f, -2.04389319e-01f,
  -2.60847181e-01f, -7.94334617e-03f, -2.35310748e-01f, 2.87317961e-01f, -3.42615008e-01f, -8.69080573e-02f, 3.21691006e-01f, 1.69185236e-01f, -1.16328448e-01f, -2.23752670e-02f,
  -2.49669760e-01f, -4.81976420e-02f, 3.32550406e-02f, -1.16261020e-01f, -1.65463865e-01f, 3.62013094e-02f, -1.38847865e-02f, 4.94442619e-02f, -2.23353375e-02f, -1.41323447e-01f,
  -7.22648948e-02f, -4.88599092e-02f, -5.18534854e-02f, 7.28589520e-02f, -4.12877835e-02f, -7.27722049e-02f, -1.27727568e-01f, -1.49154961e-01f, -2.47169100e-02f, -1.30424142e-01f,
  -1.08687431e-01f, -1.51666611e-01f, -7.31538162e-02f, 7.00482503e-02f, -1.46625340e-01f, -7.22451368e-03f, -6.59714937e-02f, -1.73989404e-02f, -1.33305624e-01f, -9.41026732e-02f,
  9.08331294e-03f, 4.98349220e-02f, 2.41624601e-02f, -3.82754914e-02f, -3.74345370e-02f, 5.36508858e-02f, 3.74596491e-02f, 1.81922708e-02f, 3.18492390e-02f, -7.23996684e-02f,
  -3.89152057e-02f, -5.13085984e-02f, 7.84677416e-02f, -3.12706195e-02f, -5.62303737e-02f, 1.17065553e-02f, -1.07312482e-02f, 5.98264262e-02f, -4.72398475e-02f, 3.57539244e-02f,
  8.20713565e-02f, -2.96178907e-02f, -5.21183060e-03f, -6.63323654e-03f, -3.50496499e-03f, 1.84929289e-03f, -1.65507961e-02f, 4.51766066e-02f, 7.18537718e-02f, -4.30274606e-02f,
  -2.96567112e-01f, -2.20113933e-01f, 6.10387512e-02f, -4.61849160e-02f, 6.77304640e-02f, 7.68665271e-03f, 1.73124764e-02f, -2.37062667e-02f, -1.07885255e-02f, -4.78190221e-02f,
  -6.52885344e-03f, 4.91168536e-02f, -9.23185199e-02f, 4.75499816e-02f, -1.76423013e-01f, -5.06896200e-03f, 7.50916675e-02f, 1.58424377e-02f, -8.47364962e-02f, -4.04186025e-02f,
  7.15158284e-02f, 6.28762990e-02f, 7.48894992e-04f, -1.78094935e-02f, 4.93018180e-02f, 2.12881099e-02f, -1.10159226e-01f, 5.67980595e-02f, -6.10134304e-02f, -8.11290636e-04f,
  -3.08286995e-02f, 5.09744406e-01f, 5.89072526e-01f, 1.57690495e-01f, -6.07572496e-01f, 5.30564845e-01f, 4.61820483e-01f, -3.79817225e-02f, 4.02188957e-01f, 1.93603858e-01f,
  -4.21552896e-01f, 4.60866123e-01f, -1.65069883e-03f, 3.89221162e-02f, -1.47433840e-02f, 2.18620181e-01f, 2.21298605e-01f, 2.79495150e-01f, -4.30995189e-02f, 7.47989193e-02f,
  -1.20180041e-01f, -4.84818578e-01f, -8.78098160e-02f, -3.85534495e-01f, -1.60822645e-01f, -5.18230721e-02f, -4.30238992e-01f, -3.61016057e-02f, -1.71437964e-01f, -2.33791828e-01f,
  -1.51130110e-01f, -2.00427517e-01f, 5.79619147e-02f, 2.82496661e-01f, -1.52897965e-02f, 4.88055013e-02f, 8.74476954e-02f, -3.13438326e-02f, -1.04097642e-01f, 7.57974461e-02f,
  1.38716400e-01f, -1.71935484e-02f, -3.24146375e-02f, 1.59846395e-02f, 6.04396909e-02f, 3.60493399e-02f, -3.81071283e-03f, 6.92948997e-02f, 7.88936764e-02f, 6.00030981e-02f,
  2.85660774e-01f, 1.56926781e-01f, 1.08867206e-01f, 4.45609428e-02f, 5.89404777e-02f, 1.85714364e-02f, 2.39409551e-01f, 2.76657157e-02f, 1.38731241e-01f, -2.94318181e-02f,
  -3.07419039e-02f, -3.84419151e-02f, 6.55225515e-02f, -1.46418400e-02f, 2.65854318e-03f, -1.42469555e-01f, 5.45329526e-02f, -1.59143642e-01f, 3.89798582e-02f, 1.67020485e-02f,
  -1.04131564e-01f, -8.98571089e-02f, -4.02226932e-02f, 9.30819660e-02f, -1.05169274e-01f, 1.38310537e-01f, 7.04919547e-02f, 2.90164165e-02f, 4.66483533e-02f, -1.13248400e-01f,
  6.02760576e-02f, 1.03380248e-01f, -1.60991415e-01f, -1.86222568e-01f, 1.97570771e-01f, -9.09949932e-03f, -9.20903534e-02f, 1.41717255e-01f, -5.60151115e-02f, -1.90441236e-01f,
  -3.79943699e-02f, -2.98602339e-02f, 1.61969122e-02f, 1.38727073e-02f, 1.58386417e-02f, 5.69198141e-03f, 2.10615643e-03f, 1.31010383e-01f, -3.45668197e-02f, 3.34802978e-02f,
  1.96303204e-02f, -6.68460503e-03f, 2.30456656e-03f, -6.66492283e-02f, 4.95618694e-02f, 1.90846212e-02f, 9.14050266e-02f, -3.06314416e-02f, -1.16997629e-01f, -1.25398695e-01f,
  4.78213243e-02f, -1.05669267e-01f, 1.98415164e-02f, -1.54737443e-01f, -4.96638156e-02f, -1.23476885e-01f, -1.09259493e-03f, 1.62068605e-02f, -1.48849219e-01f, 9.54543240e-03f,
  -5.28378725e-01f, 3.04459304e-01f, -1.59135401e-01f, 6.56298220e-01f, -5.03412127e-01f, -1.58871766e-02f, 3.91406804e-01f, -1.49951681e-01f, 2.58821309e-01f, 5.27733982e-01f,
  2.00410664e-01f, 8.06710646e-02f, -6.63632601e-02f, 6.81250274e-01f, -1.57796368e-01f, 3.65554214e-01f, 6.97243035e-01f, 4.90760386e-01f, -8.25615823e-02f, -1.16180517e-02f,
  -4.89681624e-02f, 3.78545552e-01f, 1.44508585e-01f, -2.26820469e-01f, -7.38281608e-02f, -1.66907459e-01f, 1.45762339e-01f, -4.22564179e-01f, 3.92500788e-01f, -9.06798989e-02f,
  -2.39331290e-01f, -1.49557553e-02f, 3.21132527e-03f, -5.68983704e-02f, -1.10939711e-01f, -6.96248338e-02f, -5.95216192e-02f, -9.94810089e-02f, -2.00891700e-02f, 5.90150431e-02f,
  -3.86369228e-02f, -1.81259010e-02f, 8.60799477e-02f, 3.55342552e-02f, -2.81515531e-02f, -4.12448086e-02f, -2.53619719e-03f, 1.18531972e-01f, 8.83625299e-02f, -4.56423201e-02f,
  -2.92988103e-02f, 7.29829445e-02f, 3.10583375e-02f, 5.51124737e-02f, -7.34122023e-02f, 5.50672784e-03f, 7.83735439e-02f, -8.56537148e-02f, 2.27015410e-02f, -3.02373543e-02f,
  3.80249210e-02f, 2.26900633e-02f, 4.49657775e-02f, 3.90609317e-02f, -6.71282634e-02f, -5.14632389e-02f, 7.83728510e-02f, 5.56003414e-02f, -4.27539833e-02f, -4.30910066e-02f,
  -1.25096068e-01f, -9.25825536e-03f, -4.99126501e-02f, 5.61654009e-02f, 1.41971171e-01f, 8.09355080e-02f, -7.25956559e-02f, -1.23182848e-01f, -4.20957841e-02f, -7.27853701e-02f,
  4.49605733e-02f, 4.56917472e-02f, -9.02845804e-03f, -9.04971212e-02f, 5.22774607e-02f, -9.09736007e-02f, 2.60461681e-02f, -2.74528400e-03f, 4.77482155e-02f, -1.05898462e-01f,
  -1.71532594e-02f, 1.26882359e-01f, 4.98064235e-02f, -7.77579471e-02f, 6.48421347e-02f, 4.28649709e-02f, 9.42155719e-02f, -6.69952780e-02f, 6.88372552e-02f, -5.44628240e-02f,
  -4.17399742e-02f, 9.17984098e-02f, -1.22113466e-01f, 3.72574814e-02f, 2.83759683e-02f, 2.83713285e-02f, 1.10816933e-01f, 8.56261179e-02f, 3.29329632e-03f, 1.32903131e-02f,
  8.84071812e-02f, -4.68745045e-02f, -3.51479873e-02f, -2.68625207e-02f, 2.10497960e-01f, -8.60617235e-02f, -4.71453778e-02f, -6.82397038e-02f, -1.40302286e-01f, 1.30127475e-01f,
  -2.85765380e-01f, 2.00806290e-01f, 5.87339438e-02f, 2.38590389e-01f, 2.68800199e-01f, 2.84883857e-01f, 2.08986893e-01f, 5.27154468e-02f, 1.49251148e-01f, -2.61372775e-02f,
  -1.27737066e-02f, -3.33470218e-02f, -2.87869602e-01f, 6.68840781e-02f, 3.63878936e-01f, -9.57687106e-03f, 3.04007858e-01f, 2.24273145e-01f, 1.15730740e-01f, -3.38845216e-02f,
  -1.79271400e-01f, 9.92252901e-02f, -2.83351541e-01f, 3.44186500e-02f, 2.08947480e-01f, 9.17362198e-02f, 3.79425615e-01f, 3.04109961e-01f, 2.91014910e-01f, 4.47803169e-01f,
  -1.25101089e-01f, -2.01783907e-02f, -1.79837614e-01f, -1.54212877e-01f, 6.45712316e-02f, 3.91799100e-02f, 2.03841940e-01f, 1.09746076e-01f, 1.79614797e-02f, -1.28274754e-01f,
  -4.88069206e-02f, -2.34064683e-02f, -4.48109545e-02f, 1.90849051e-01f, -1.27116174e-01f, -1.65145714e-02f, -6.21979870e-02f, 2.73340344e-02f, -4.84781936e-02f, -1.87947720e-01f,
  -2.74330139e-01f, -1.40748665e-01f, 4.87053022e-02f, 2.39257619e-01f, -1.21999374e-02f, 1.01550901e-02f, 1.68871079e-02f, 2.15962646e-04f, 1.91251412e-01f, 6.35649487e-02f,
  4.80469614e-02f, 1.81262225e-01f, -2.72113949e-01f, -8.32486376e-02f, 1.81170683e-02f, 8.76802877e-02f, -1.16463378e-01f, -1.20956944e-02f, -4.74318750e-02f, 5.80233932e-02f,
  -1.03464469e-01f, -4.64263782e-02f, 4.45650220e-02f, -6.91556633e-02f, -5.74877821e-02f, -1.16163000e-01f, -4.96398099e-02f, 5.30012213e-02f, -1.02037385e-01f, -1.39178127e-01f,
  5.13663553e-02f, 2.62328573e-02f, -1.11605145e-01f, -7.54529536e-02f, 2.13392340e-02f, -1.70858964e-01f, 7.96138868e-02f, -5.35981245e-02f, 2.69025080e-02f, 2.18126047e-02f,
  3.13870966e-01f, 7.00146973e-01f, -4.13583405e-02f, -1.94013476e-01f, -6.32815342e-03f, -1.20875724e-02f, 1.57465473e-01f, -6.71757013e-03f, 2.55983621e-01f, 2.07957923e-02f,
  -9.49599594e-02f, -2.53308993e-02f, 7.34144524e-02f, -1.27698220e-02f, 5.17456569e-02f, -1.21214889e-01f, 7.00436309e-02f, 2.43044823e-01f, 1.29170880e-01f, 5.14416769e-02f,
  8.88704062e-02f, 5.39076887e-03f, -1.02205373e-01f, -1.68751329e-02f, -9.09791216e-02f, 5.72604984e-02f, 1.24795146e-01f, 2.57902825e-03f, 2.06816243e-03f, 1.60937980e-01f,
  -5.19232035e-01f, -1.52787194e-01f, -5.36813676e-01f, -6.11869633e-01f, 2.25561976e-01f, -6.92628264e-01f, -5.20752668e-01f, 5.77575490e-02f, -1.10715136e-01f, 2.40148708e-01f,
  -1.53827462e-02f, -2.98513919e-01f, 2.42956147e-01f, -7.27884412e-01f, -6.64658010e-01f, -3.40802133e-01f, -6.67827666e-01f, -5.56929171e-01f, -9.55090672e-02f, -8.62853751e-02f,
  -2.18500540e-01f, -1.26370907e-01f, -4.80666190e-01f, 4.46472019e-01f, -1.89218298e-01f, 1.86170429e-01f, 3.90176773e-01f, 3.00716907e-01f, -1.89826310e-01f, -8.38942602e-02f,
  -2.54232228e-01f, 1.83129519e-01f, -1.03883617e-01f, -5.07443324e-02f, -2.48333085e-02f, 1.12610884e-01f, -5.72046898e-02f, -1.25204816e-01f, 5.71024697e-03f, -4.70143631e-02f,
  1.20279826e-01f, 9.77001339e-02f, -9.44448113e-02f, 5.76161370e-02f, 1.80858254e-01f, -4.58658077e-02f, -1.14609450e-01f, -1.16635077e-01f, -4.97275832e-05f, -8.09423104e-02f,
  -1.70207053e-01f, -1.29743190e-02f, 6.75713643e-02f, 2.34734900e-02f, 1.78771261e-02f, 9.59500577e-03f, -1.20847158e-01f, 3.61315347e-02f, 2.89832205e-02f, 3.97648476e-03f,
  1.29980668e-01f, 5.72742522e-02f, -6.01709150e-02f, -2.91620530e-02f, -2.74634399e-02f, 3.71347778e-02f, -2.96691749e-02f, -6.47279853e-03f, 8.64694864e-02f, 6.85243532e-02f,
  2.62501603e-03f, -7.39040300e-02f, -1.77282896e-02f, -7.13800937e-02f, -1.94915961e-02f, -2.27542371e-02f, -3.58346738e-02f, 3.93464267e-02f, -1.03166863e-01f, -1.53556883e-01f,
  9.17722285e-02f, -3.20261307e-02f, -2.79441453e-03f, 1.05853111e-01f, -9.90781784e-02f, 1.26716524e-01f, 1.39848411e-01f, -8.52280185e-02f, -4.86395434e-02f, 5.03611797e-03f,
  1.44118005e-02f, 3.63531440e-01f, 4.07451801e-02f, 5.60646318e-02f, -8.84998124e-03f, -2.14107744e-02f, -1.00754991e-01f, -1.48859441e-01f, 4.22396436e-02f, 7.50356168e-02f,
  6.17974624e-02f, 2.83874013e-02f, 1.52136788e-01f, -8.01709443e-02f, -1.60182249e-02f, 1.07233273e-02f, 1.09426126e-01f, 8.76758918e-02f, 1.07770868e-01f, 1.34779453e-01f,
  2.05429867e-01f, 1.92370132e-01f, 4.08867449e-02f, -4.91726492e-03f, 9.33160707e-02f, 9.88569781e-02f, 1.04745269e-01f, 1.57002360e-02f, 6.86159655e-02f, -6.18393021e-03f,
  -1.17449069e+00f, 7.15452850e-01f, 5.66216946e-01f, -1.99881926e-01f, 4.18178067e-02f, -9.84316692e-02f, -9.89427343e-02f, 3.23539287e-01f, 2.20509335e-01f, 4.87675667e-01f,
  8.64533335e-02f, 2.72998571e-01f, 4.60654378e-01f, 2.86228627e-01f, -6.41133964e-01f, 2.91861326e-01f, -3.28655899e-01f, 2.41279472e-02f, 6.93808869e-03f, -1.44058555e-01f,
  -1.13981865e-01f, -1.45188019e-01f, 2.10892349e-01f, 2.08765060e-01f, 1.05478972e-01f, 1.56850386e-02f, -4.81949627e-01f, 3.63439560e-01f, -7.70663843e-02f, 1.05586536e-01f,
  -4.01388913e-01f, 3.66670310e-01f, -1.18981101e-01f, 5.99949695e-02f, -1.60933062e-01f, -6.10788055e-02f, -9.58355218e-02f, -1.22012936e-01f, 3.48440260e-02f, 6.60243705e-02f,
  -4.43146974e-02f, 4.89842854e-02f, -8.61709565e-02f, 8.63544270e-02f, 6.19623140e-02f, 1.12683825e-01f, 1.48451969e-01f, -6.42482042e-02f, 1.82811841e-01f, 1.89517155e-01f,
  1.91616476e-01f, 1.09539613e-01f, 1.03255399e-01f, 9.28124338e-02f, 3.04563902e-02f, 1.78708896e-01f, -4.28676896e-04f, -6.25828132e-02f, -5.39363548e-02f, -9.70659927e-02f,
  3.90205905e-02f, -1.07331611e-01f, 2.25659292e-02f, 5.65561056e-02f, 9.01358873e-02f, 3.46527919e-02f, 3.05255204e-02f, -9.83028114e-02f, 1.72620062e-02f, -2.86274422e-02f,
  -6.50647208e-02f, 3.98000851e-02f, 6.67239353e-02f, -1.22083731e-01f, -1.13534844e-02f, 1.04404511e-02f, -1.14771761e-01f, 4.15693782e-02f, -1.58463657e-01f, -1.40131995e-01f,
  1.12366110e-01f, -4.56734113e-02f, 1.05167173e-01f, -6.84725493e-02f, 4.57910001e-02f, -3.90600562e-02f, 1.65743977e-02f, 1.23358496e-01f, -1.69632003e-01f, -1.60422295e-01f,
  -6.95671678e-01f, -1.24350712e-01f, -7.57681057e-02f, -1.08090546e-02f, -1.12459503e-01f, -7.34853595e-02f, 1.82872824e-02f, -1.15336426e-01f, -5.64357862e-02f, -8.44155550e-02f,
  -1.10634826e-01f, -2.92638000e-02f, -2.31912762e-01f, -7.45394453e-02f, -2.55681332e-02f, -1.47332668e-01f, -1.34435102e-01f, -1.06498234e-01f, -2.67164588e-01f, -4.45216745e-02f,
  -1.14796974e-01f, -1.03555016e-01f, -2.73523778e-02f, -1.07219629e-01f, -8.45830068e-02f, -8.06149840e-02f, -1.84838638e-01f, 2.96336040e-02f, -5.77090420e-02f, 1.06805518e-01f,
  -5.66345274e-01f, 8.77167135e-02f, -3.34592819e-01f, 9.93827954e-02f, -1.47468045e-01f, 1.27001077e-01f, -3.63504998e-02f, 1.54921681e-01f, -5.44027328e-01f, 4.94422317e-01f,
  4.46201205e-01f, -6.87650025e-01f, 2.60139316e-01f, 3.91882867e-01f, -1.31549463e-01f, 1.07968584e-01f, 5.39285362e-01f, 2.75297433e-01f, -1.56326339e-01f, 2.88185090e-01f,
  6.08422346e-02f, 3.31768692e-01f, 3.65291864e-01f, 3.82618546e-01f, 1.86469764e-01f, -1.26008820e-02f, 6.60359204e-01f, 5.90294898e-02f, 5.88682473e-01f, -2.50246730e-02f,
  1.02827251e-01f, -1.22008964e-01f, -4.21697162e-02f, -2.07963333e-01f, 2.98152298e-01f, 1.65713102e-01f, 5.99121302e-02f, -1.53324053e-01f, -2.18449503e-01f, -8.42035469e-03f,
  -1.41783834e-01f, -9.04663131e-02f, -6.61132783e-02f, -1.36480257e-01f, -1.54318690e-01f, -7.95570984e-02f, -1.07515208e-01f, 6.28081039e-02f, -1.57942012e-01f, -1.43181443e-01f,
  -1.28457740e-01f, 3.16613466e-02f, 6.24691993e-02f, 1.58803724e-02f, -1.76580176e-01f, -9.40117911e-02f, -6.55455142e-02f, 7.06069637e-03f, 5.00357524e-02f, -1.03273913e-01f,
  1.27522666e-02f, 2.65065338e-02f, 2.79745217e-02f, -1.82677824e-02f, -7.95835108e-02f, 1.17924355e-01f, 1.26484796e-01f, -4.37090881e-02f, -1.31132677e-01f, 1.40533954e-01f,
  -2.07734318e-03f, -9.88692865e-02f, 6.67213202e-02f, -3.99467833e-02f, -9.55028459e-03f, -3.34108295e-03f, 3.84627059e-02f, -2.96335667e-03f, -3.34023647e-02f, 7.76382387e-02f,
  5.24513535e-02f, -2.19970122e-02f, 8.06808751e-03f, 1.73619419e-01f, 4.52722609e-02f, -7.51895830e-02f, -1.75061785e-02f, 2.90801730e-02f, 5.43285385e-02f, 5.44219054e-02f,
  3.50900859e-01f, 2.96244144e-01f, -4.35310267e-02f, -1.14508435e-01f, 6.54237270e-02f, 2.31277179e-02f, 2.08650753e-02f, -7.95324817e-02f, 4.46974523e-02f, 5.61904311e-02f,
  6.73365444e-02f, 6.37466162e-02f, 1.46037146e-01f, -1.33987159e-01f, 4.70743962e-02f, 1.60692945e-01f, 7.91842639e-02f, -9.30764303e-02f, 1.11682944e-01f, 2.12931335e-01f,
  1.35299683e-01f, 4.17808490e-03f, -3.49565372e-02f, 3.72308753e-02f, 5.25137372e-02f, 1.58399105e-01f, -4.46373262e-02f, -2.70441417e-02f, 2.79927403e-01f, 5.64287081e-02f,
  -6.88330054e-01f, 8.25202346e-01f, 2.94862330e-01f, -4.31263894e-01f, 2.56672144e-01f, 1.02840200e-01f, -1.88512012e-01f, 1.98052675e-01f, -1.62276715e-01f, 1.69998571e-01f,
  -3.13176066e-01f, 1.61311805e-01f, 3.86612117e-02f, -3.03045541e-01f, -7.39781797e-01f, -3.41197789e-01f, -4.19507742e-01f, -3.27347785e-01f, -2.01998446e-02f, -9.15177837e-02f,
  -2.13864520e-01f, -2.89201140e-01f, -1.14599600e-01f, 4.55921024e-01f, 2.65973538e-01f, 3.01522523e-01f, -3.57558787e-01f, 3.35374296e-01f, 5.77291939e-03f, 7.18660951e-02f,
  6.15341179e-02f, -9.36396122e-02f, 2.13025555e-01f, 1.05581664e-01f, -7.99981579e-02f, -1.58030819e-02f, -1.45968786e-02f, 1.03425384e-01f, 2.29330659e-02f, 3.09459474e-02f,
  4.51271050e-02f, 1.07792884e-01f, -4.26746719e-02f, 6.05009720e-02f, 2.16206193e-01f, 1.19294256e-01f, 1.19282879e-01f, 9.14798751e-02f, 1.60459131e-01f, 5.99335544e-02f,
  4.06509191e-02f, 4.03468050e-02f, -5.38755842e-02f, -1.14988126e-01f, 4.73466367e-02f, 2.57442333e-02f, -4.78610508e-02f, 3.49369831e-02f, 6.69335723e-02f, 2.78896792e-03f,
  -1.50874332e-02f, 9.16978251e-03f, 4.97460477e-02f, 7.76104555e-02f, -9.91188437e-02f, 5.78822568e-02f, -4.78901416e-02f, 3.46130878e-03f, 5.32699674e-02f, -4.46761325e-02f,
  -6.19575642e-02f, 4.52029333e-02f, 4.21684496e-02f, -2.65155956e-02f, -7.93775842e-02f, -7.01975226e-02f, 5.68352500e-03f, -8.45836774e-02f, -9.61724296e-02f, 8.45804363e-02f,
  -5.10594100e-02f, -1.26758575e-01f, -7.18753508e-05f, 1.08696006e-01f, 4.39822711e-02f, 1.83030721e-02f, 8.63382593e-02f, 3.62433940e-02f, 5.16376132e-03f, -2.74682045e-02f,
  -3.14051807e-01f, -4.19678181e-01f, 3.39820869e-02f, 1.32667914e-01f, 4.84872889e-03f, 3.61005496e-03f, -1.09029384e-02f, 8.61456692e-02f, 3.40180062e-02f, -7.07738847e-02f,
  4.57089022e-02f, -2.49458160e-02f, -4.31525372e-02f, -1.31741092e-01f, -6.50891587e-02f, -8.87751430e-02f, -1.72323033e-01f, -7.49011189e-02f, 5.68524562e-03f, 3.19138579e-02f,
  8.13210160e-02f, -1.49429794e-02f, -5.63467331e-02f, 4.37259078e-02f, -4.24398556e-02f, -3.63540612e-02f, -9.97184217e-02f, 1.62294865e-01f, -8.29993039e-02f, 1.48710776e-02f,
  -5.23407221e-01f, 3.14211339e-01f, -2.46472627e-01f, -3.10340077e-01f, -5.91723859e-01f, 1.00180469e-01f, -1.67524636e-01f, -4.92079370e-02f, 1.36474445e-01f, 3.89115781e-01f,
  -2.91743428e-01f, 8.36209282e-02f, 3.91495049e-01f, -2.36449778e-01f, 1.68478429e-01f, 5.71288824e-01f, -1.16440700e-02f, -1.91845465e-02f, 5.05625568e-02f, -2.01499075e-01f,
  -1.00947984e-01f, -3.02394569e-01f, -2.38532379e-01f, -4.00746688e-02f, -5.15333951e-01f, -2.24542469e-01f, -2.67575383e-01f, -1.77107155e-01f, -3.90342146e-01f, -3.17209959e-01f,
  -2.98815846e-01f, -4.33758497e-01f, -4.33230370e-01f, -2.46632807e-02f, -8.21494609e-02f, -4.66541685e-02f, 1.59672089e-02f, -1.21782333e-01f, -1.25756472e-01f, -5.10506425e-03f,
  1.35939866e-01f, 9.65260863e-02f, -3.86001845e-03f, 1.22546516e-01f, -1.90616995e-01f, -1.59313858e-01f, -2.07695421e-02f, -2.05320582e-01f, -2.38835514e-01f, -5.16121462e-02f,
  -4.90022749e-02f, 2.15254910e-02f, -1.47331849e-01f, -5.67059852e-02f, -2.84602106e-01f, -1.66318253e-01f, 8.63318145e-02f, -1.20571576e-01f, -1.98239997e-01f, 1.98163791e-03f,
  -5.33988141e-02f, -4.79164980e-02f, -7.86053985e-02f, -2.71251053e-02f, 5.56145124e-02f, -8.89137462e-02f, 7.06010461e-02f, 5.68244234e-02f, 3.95950265e-02f, 6.74462039e-03f,
  4.18442003e-02f, -1.58675596e-01f, -1.94655210e-02f, 4.05963399e-02f, 7.24283904e-02f, 7.63880387e-02f, -1.09843044e-02f, -9.04352739e-02f, 2.16750056e-01f, -4.17676941e-03f,
  -3.16001736e-02f, -3.53791825e-02f, -5.09519950e-02f, -3.87725700e-03f, -1.92230474e-02f, 2.82026753e-02f, -2.33028103e-02f, -3.13935652e-02f, -1.18266288e-02f, -1.32476196e-01f,
  -7.29793012e-02f, -1.03688344e-01f, -1.54411063e-01f, -1.90022349e-01f, 1.84546728e-02f, -1.39454743e-02f, 6.37898520e-02f, 3.39879915e-02f, 4.96908762e-02f, 3.32144126e-02f,
  1.76360771e-01f, 6.77256063e-02f, 5.77185676e-02f, 2.37527452e-02f, 2.81481445e-01f, -4.18031178e-02f, -7.13467970e-02f, 4.59545255e-02f, -1.15005903e-01f, -9.02194530e-02f,
  -8.58659223e-02f, 9.96847153e-02f, 2.17411786e-01f, -5.82111254e-03f, -7.09188655e-02f, -9.18715373e-02f, -4.46830615e-02f, -5.82572445e-02f, -1.73021272e-01f, 2.10186187e-02f,
  2.36418962e-01f, 4.76473337e-03f, -3.66495937e-01f, -3.04184735e-01f, -4.67019379e-01f, -2.21617416e-01f, -2.58314788e-01f, -3.09924066e-01f, 3.47702056e-02f, 2.10077956e-01f,
  9.86131504e-02f, -9.45912972e-02f, 2.85108030e-01f, 2.45703887e-02f, 1.10558674e-01f, 5.49974978e-01f, -1.50469959e-01f, 7.38240778e-02f, 2.54081666e-01f, -1.94844902e-01f,
  -2.65540648e-02f, 1.43969193e-01f, -7.89103732e-02f, -1.29573166e-01f, -1.96533352e-01f, -2.04458654e-01f, 3.22999395e-02f, -2.25417674e-01f, -2.09393337e-01f, -9.55129266e-02f,
  2.27837428e-01f, 2.50847489e-01f, -1.96411442e-02f, 1.53905749e-01f, 1.78095073e-01f, 4.64204140e-02f, -1.20363951e-01f, -4.00506184e-02f, 8.52483958e-02f, 4.76472229e-02f,
  7.22959085e-05f, 1.34578258e-01f, -3.33328880e-02f, -2.77076904e-02f, -8.59360248e-02f, -2.46315952e-02f, 9.38460976e-02f, -2.94656958e-02f, -1.37441501e-01f, 4.53594290e-02f,
  -8.24730098e-02f, 1.23780936e-01f, -1.40873030e-01f, 5.18008433e-02f, -6.63533732e-02f, 9.24464967e-03f, -9.22635347e-02f, -8.32174271e-02f, 1.82198416e-02f, -3.93775553e-02f,
  -1.38224274e-01f, 2.30293050e-01f, 1.26934841e-01f, 1.24991603e-01f, 5.42909093e-02f, 4.73914742e-02f, -5.12083843e-02f, -3.76451798e-02f, 3.38830091e-02f, 6.79228157e-02f,
  -6.90269694e-02f, -5.46885058e-02f, 1.49663463e-01f, -1.41215865e-02f, -3.68146449e-02f, -2.27983743e-02f, -1.16781957e-01f, 1.58301704e-02f, -1.49712175e-01f, 2.78999303e-02f,
  -8.22066702e-03f, -1.01176307e-01f, 5.91330528e-02f, -1.13058805e-01f, 5.76313734e-02f, -6.96274415e-02f, 3.97298075e-02f, -6.79506138e-02f, 1.08834647e-01f, -1.73032075e-01f,
  3.07675544e-02f, 6.54685590e-03f, 8.02896842e-02f, 6.08989932e-02f, 3.84767428e-02f, 7.79274106e-02f, -2.23376192e-02f, 6.47376291e-03f, 3.35692205e-02f, -4.88181598e-02f,
  3.07200849e-02f, -9.85279158e-02f, -3.40071954e-02f, -7.49911219e-02f, -9.43409130e-02f, -3.23421694e-02f, -3.27938907e-02f, 1.56506728e-02f, -2.53273308e-01f, -1.29541427e-01f,
  -1.36249363e-01f, 9.15913805e-02f, -1.25114364e-03f, 3.41401584e-02f, -1.56485766e-01f, 9.02766362e-03f, -8.79361406e-02f, 7.41215274e-02f, -7.13285878e-02f, 8.62626359e-02f,
  -2.33726114e-01f, -8.41780126e-01f, -1.15818679e-02f, -1.94668904e-01f, 2.46825770e-01f, 3.05540860e-01f, 1.92076653e-01f, -3.90513182e-01f, -7.11493433e-01f, -4.32304174e-01f,
  7.02661052e-02f, -1.53560996e-01f, -1.91623077e-01f, -3.51148248e-01f, 4.12823230e-01f, -4.44451541e-01f, -1.47138610e-01f, 4.15421352e-02f, -3.97686660e-01f, 8.74500256e-04f,
  3.95034961e-02f, 6.93029538e-02f, 1.15136676e-01f, -1.80908926e-02f, -2.98507158e-02f, 1.15086198e-01f, 2.26788342e-01f, 2.28179023e-01f, 3.19816262e-01f, 2.28244528e-01f,
  5.67887165e-02f, -3.24133396e-01f, 1.48055917e-02f, 7.76580423e-02f, -3.06018107e-02f, 1.75956652e-01f, 2.27525577e-01f, 3.08815598e-01f, 1.76989272e-01f, -1.14223123e-01f,
  -3.92988510e-02f, 1.17132552e-02f, -1.23018846e-01f, 1.88321203e-01f, -5.98399080e-02f, 1.30770141e-02f, -6.05904832e-02f, -8.28668848e-02f, -2.34926958e-02f, -1.34296134e-01f,
  -1.38930783e-01f, -1.31720468e-01f, -1.37970865e-01f, -3.31637152e-02f, 2.98304185e-02f, -1.45849302e-01f, 2.96360236e-02f, 4.16087210e-02f, -1.36464328e-01f, 4.73301373e-02f,
  -1.11792304e-01f, -1.92251299e-02f, -1.04080401e-01f, -5.69686927e-02f, -2.03940067e-02f, 8.57253894e-02f, -5.26517294e-02f, -3.39014642e-02f, 5.58183528e-02f, -3.14095989e-02f,
  5.57370074e-02f, -1.91741958e-02f, -1.41614348e-01f, 6.22092597e-02f, -5.66754304e-02f, -6.18429333e-02f, 2.08987534e-01f, 8.92900676e-02f, -4.22284864e-02f, 3.08465753e-02f,
  2.65833363e-02f, 1.68042302e-01f, 5.15038632e-02f, -3.30672115e-02f, -7.90419132e-02f, 3.46792303e-03f, -1.78406779e-02f, -5.81142604e-02f, 4.77328077e-02f, 6.77400753e-02f,
  8.38394836e-02f, -3.33821058e-01f, -8.80957488e-03f, 1.40618920e-01f, 1.18328393e-01f, -6.51012510e-02f, -1.28527835e-01f, -1.55860201e-01f, 9.66678560e-02f, -5.67997843e-02f,
  1.18598528e-01f, 1.38777345e-01f, -1.71953231e-01f, 7.67939240e-02f, 1.92371964e-01f, -8.30532163e-02f, 1.05177410e-01f, 1.93485975e-01f, 1.45635292e-01f, 1.26695976e-01f,
  6.76366016e-02f, 1.67022459e-02f, -3.81390415e-02f, -9.89764184e-02f, -6.93497881e-02f, 5.99534623e-02f, 9.77836102e-02f, -1.31744757e-01f, 1.70239080e-02f, 1.37041127e-02f,
  -4.12073761e-01f, -5.54740429e-01f, 4.81494546e-01f, -5.24025917e-01f, 1.56329170e-01f, 5.26513040e-01f, 1.17056392e-01f, -1.03957959e-01f, -4.96537864e-01f, -4.19689476e-01f,
  -1.01450033e-01f, -1.96100339e-01f, 9.58770365e-02f, -5.64542472e-01f, 7.52087414e-01f, -6.12869486e-02f, -3.06670994e-01f, -3.22153300e-01f, -3.08935761e-01f, -3.00095201e-01f,
  -1.23421267e-01f, -3.27653617e-01f, 2.36629665e-01f, -1.79821759e-01f, -1.83528021e-01f, -2.33592927e-01f, 1.13321647e-01f, 3.69815677e-01f, -4.92947921e-02f, 2.16499984e-01f,
  -1.58447623e-01f, -4.08164203e-01f, -1.59540176e-01f, 3.19661275e-02f, 9.55862924e-02f, 8.53738263e-02f, 1.57343939e-01f, 1.85920224e-01f, 8.17636680e-03f, 7.83760324e-02f,
  1.68872718e-02f, 1.43852169e-02f, -1.06394969e-01f, 4.63228412e-02f, -1.24327123e-01f, -4.39514071e-02f, 6.73046485e-02f, 3.32244858e-03f, -8.57355744e-02f, 1.94750026e-01f,
  8.52702111e-02f, 1.00410052e-01f, 7.71656111e-02f, 4.32731621e-02f, 7.76688457e-02f, 1.15234461e-02f, 2.27836277e-02f, 2.81481415e-01f, -6.75365627e-02f, 7.44212493e-02f,
  1.12062484e-01f, 1.11448444e-01f, 6.14234619e-03f, -9.35468823e-02f, -1.41988834e-02f, -3.34965587e-02f, -6.04669675e-02f, -1.34091387e-02f, 3.90598997e-02f, 7.88266286e-02f,
  -4.19624522e-02f, -1.06200119e-02f, -1.07326053e-01f, 9.84800718e-05f, -1.76821873e-02f, -1.05104178e-01f, -3.91430873e-03f, -6.49641082e-02f, -5.29172607e-02f, 6.31014779e-02f,
  -6.98360950e-02f, -3.25490534e-02f, -1.07928058e-02f, -5.35991155e-02f, -2.05986984e-02f, 1.68004379e-01f, -6.33418635e-02f, 5.27464636e-02f, 4.23290916e-02f, 7.50591755e-02f,
  -2.89297581e-01f, -3.97099853e-01f, -1.57596990e-01f, -8.08502585e-02f, -1.47466987e-01f, 3.24410461e-02f, -1.67991310e-01f, -9.19060558e-02f, 3.83038409e-02f, -2.90549006e-02f,
  1.02645487e-01f, -4.96254154e-02f, -7.59840161e-02f, -7.99685642e-02f, -2.44809296e-02f, 2.73304041e-02f, -7.93337915e-03f, -2.09840648e-02f, 3.16532403e-02f, -4.29604650e-02f,
  -4.00545746e-02f, 1.91866551e-02f, 9.88275632e-02f, -1.01016119e-01f, -1.73995405e-01f, 1.24675170e-01f, -1.22573480e-01f, 2.04210058e-02f, 2.72434037e-02f, -9.13228020e-02f,
  4.04286742e-01f, -4.99500960e-01f, -2.67990440e-01f, 1.37183845e-01f, -7.09933117e-02f, 1.98214129e-01f, 5.29911757e-01f, -2.93184310e-01f, -4.80805546e-01f, -1.51961362e-02f,
  3.53454769e-01f, -1.83885992e-02f, 3.94895464e-01f, 2.03669444e-01f, 4.26121056e-01f, 1.99388564e-01f, 2.17397004e-01f, 3.28623801e-01f, -2.29361042e-01f, -3.69648859e-02f,
  4.70147394e-02f, 3.10525298e-01f, 2.89087474e-01f, -3.30235481e-01f, 2.01993167e-01f, -2.96315461e-01f, 1.58465311e-01f, 1.11441510e-02f, 1.43083513e-01f, 2.21379027e-01f,
  6.52634129e-02f, -1.16615072e-01f, -1.69500336e-02f, -8.59869644e-02f, -6.04241826e-02f, 5.67663833e-02f, 1.73038065e-01f, 2.85691053e-01f, -6.85961097e-02f, -9.22635496e-02f,
  4.65143621e-02f, 1.41346501e-02f, -1.35492116e-01f, 2.23634355e-02f, -5.44153042e-02f, -1.46888182e-01f, -2.49147028e-01f, -2.65110545e-02f, -1.04187466e-01f, 1.39991909e-01f,
  8.60980712e-03f, -4.34772074e-02f, 8.42452794e-02f, -4.62888740e-02f, -4.70044948e-02f, -8.20517316e-02f, 2.80296598e-02f, 1.21922836e-01f, -1.38067096e-01f, -1.70277104e-01f,
  4.29593995e-02f, 7.34247267e-02f, 4.52365093e-02f, 3.05311438e-02f, 7.49417916e-02f, 6.86210692e-02f, 6.55240715e-02f, 1.23814963e-01f, 1.97348325e-03f, 9.19189304e-03f,
  -1.51749421e-02f, -7.69197643e-02f, -4.02619243e-02f, -3.20942308e-05f, 1.24955617e-01f, -6.73006848e-02f, 1.73729002e-01f, -2.21250160e-03f, -1.62638620e-01f, -4.64095501e-03f,
  8.45216364e-02f, -7.29422867e-02f, -8.35913420e-02f, 1.17312580e-01f, 6.82911351e-02f, 6.82041794e-02f, -2.81762891e-02f, -7.54590109e-02f, -9.42486003e-02f, 1.13344356e-01f,
  -1.27213240e-01f, -2.01314464e-01f, -7.49393702e-02f, -6.59515336e-02f, -3.20502967e-02f, -6.07812069e-02f, 5.59255555e-02f, -1.96255416e-01f, -1.10773988e-01f, -4.96512242e-02f,
  -1.49854198e-02f, -5.45663014e-02f, -8.81277472e-02f, -3.65482755e-02f, 3.34758312e-02f, -1.20087311e-01f, 8.18661526e-02f, -2.79804934e-02f, 6.20844327e-02f, -1.27680972e-01f,
  2.84164976e-02f, -1.15823776e-01f, 2.06684902e-01f, -8.95956755e-02f, -6.63981512e-02f, 1.40638381e-01f, -7.83383772e-02f, 1.88264623e-02f, 6.38220012e-02f, -3.31972875e-02f,
  4.06732917e-01f, -2.55696118e-01f, -2.44854048e-01f, 5.62844463e-02f, -1.83025256e-01f, -2.27356464e-01f, 1.41167700e-01f, -8.46357793e-02f, 3.30016375e-01f, -2.30283841e-01f,
  -3.38213295e-01f, 4.67742264e-01f, 4.76555109e-01f, -3.84641647e-01f, 6.10828996e-01f, 4.74483222e-01f, -1.65027976e-01f, -7.61010647e-02f, 1.03931390e-01f, 9.27969366e-02f,
  2.70077497e-01f, -1.26021221e-01f, -1.40888467e-01f, -3.08184177e-01f, -4.00317967e-01f, -3.09839576e-01f, -1.60524800e-01f, -1.75228730e-01f, -5.84479570e-01f, -3.26005332e-02f,
  -2.10777193e-01f, 1.05489075e-01f, -1.20815933e-01f, 8.59109908e-02f, -8.93401802e-02f, 2.22482067e-02f, -4.80006896e-02f, 9.24263522e-02f, 1.27010152e-01f, 7.94022828e-02f,
  2.03445494e-01f, 8.08090791e-02f, 1.41036790e-02f, 6.48010597e-02f, -3.50604840e-02f, -1.97029337e-01f, -8.15086626e-03f, -1.99123383e-01f, -1.15205841e-02f, -5.60074933e-02f,
  -7.44070858e-02f, -9.17417780e-02f, -5.12546413e-02f, 1.05701052e-01f, 1.33824363e-01f, 2.37749089e-02f, 6.38036104e-03f, 9.49285999e-02f, -7.97332004e-02f, 1.57009378e-01f,
  3.47673371e-02f, 7.87435547e-02f, 4.59203683e-02f, -1.54627502e-01f, -6.57662237e-03f, -1.22371890e-01f, 7.10431263e-02f, -1.96141247e-02f, 2.64297798e-02f, -1.43190054e-02f,
  -5.12629636e-02f, 1.23125069e-01f, -1.78179946e-02f, 2.91278046e-02f, 1.06328703e-01f, 1.51551098e-01f, 1.03682406e-01f, -2.12813970e-02f, 6.27268031e-02f, 6.02045953e-02f,
  1.08028715e-02f, 4.82482016e-02f, 7.44071975e-02f, -8.71059448e-02f, -3.56947705e-02f, 6.36190251e-02f, -1.33316383e-01f, 5.90684637e-02f, -6.16125576e-02f, 1.44664153e-01f,
  -2.07897034e-02f, 2.47623608e-01f, 5.03899381e-02f, 1.56562522e-01f, -4.47929613e-02f, 1.55937113e-02f, -4.40830626e-02f, -6.40390888e-02f, -3.13024893e-02f, 1.93545341e-01f,
  -9.90451425e-02f, 9.12080407e-02f, -1.01642706e-01f, -1.63898110e-01f, 6.14880770e-02f, -1.05621435e-01f, 1.50926456e-01f, 8.31272528e-02f, 1.75594330e-01f, 1.00274831e-02f,
  -1.34834638e-02f, 1.25872687e-01f, 1.28658280e-01f, 3.35364752e-02f, 1.06783867e-01f, 1.06029242e-01f, 1.93701684e-02f, -6.03734925e-02f, 1.80947617e-01f, 7.72572830e-02f,
  7.41029918e-01f, -3.95545721e-01f, 2.46894002e-01f, 7.28963912e-01f, 2.77823865e-01f, 2.50819862e-01f, 8.19498241e-01f, -1.58388436e-01f, 4.79708821e-01f, -4.72336501e-01f,
  -9.33202058e-02f, 1.91296816e-01f, 2.67118543e-01f, -2.10523024e-01f, 5.22756875e-01f, 1.82196990e-01f, 1.40696093e-01f, 2.77978092e-01f, 1.09731980e-01f, 1.21531129e-01f,
  9.00848806e-02f, -2.37338468e-01f, 9.25183073e-02f, -4.48336035e-01f, 1.92839295e-01f, -2.21233949e-01f, -3.06629092e-01f, 1.83758706e-01f, -5.58440745e-01f, 3.73073332e-02f,
  -5.64235672e-02f, 4.14574854e-02f, -1.21885777e-01f, -2.30166972e-01f, 2.35452391e-02f, 1.12130940e-01f, 5.16545065e-02f, 1.81168035e-01f, 2.05444872e-01f, -5.17367497e-02f,
  1.09364307e-02f, -1.03798233e-01f, -1.30989596e-01f, 1.14940196e-01f, 6.10612929e-02f, -1.03364713e-01f, 1.00619532e-02f, -1.30005345e-01f, -5.76483756e-02f, 5.32802530e-02f,
  8.87957811e-02f, -3.65622453e-02f, -3.46396938e-02f, -1.49007827e-01f, -7.35682100e-02f, -9.62819438e-03f, -4.45914315e-03f, 5.19261062e-02f, -1.06401309e-01f, 1.06422100e-02f,
  -1.51019648e-01f, 5.51962629e-02f, 7.48623386e-02f, 4.39705402e-02f, 9.65544134e-02f, -4.52695638e-02f, 1.49475858e-02f, -8.81692171e-02f, 6.30740076e-03f, 3.44781540e-02f,
  2.52188332e-02f, -5.47528975e-02f, -2.57565193e-02f, 1.34333521e-01f, 2.26083305e-03f, -3.05054020e-02f, 5.15429899e-02f, -1.03127770e-01f, -2.73846649e-02f, -4.81519699e-02f,
  6.23767227e-02f, 1.80850457e-02f, -1.25121500e-03f, 8.38155299e-02f, 4.14857715e-02f, 4.38411683e-02f, -6.19995818e-02f, 3.58733535e-02f, 8.76162350e-02f, 9.37399715e-02f,
  4.08930220e-02f, -9.75939408e-02f, -9.53617990e-02f, -3.00684839e-01f, 1.47963734e-02f, -2.83324420e-02f, 5.78509718e-02f, -2.00483575e-01f, 7.67398626e-02f, -1.98503118e-02f,
  -1.86625287e-01f, 1.07325524e-01f, -6.85419480e-04f, 8.89651254e-02f, -1.14646353e-01f, -2.67482325e-02f, 5.45363389e-02f, -1.14030026e-01f, -9.27416682e-02f, -1.10057451e-01f,
  6.89004129e-03f, 1.41510740e-01f, -4.51324321e-03f, -9.81588066e-02f, -1.53035954e-01f, -5.14620915e-02f, 9.03423578e-02f, -1.22551225e-01f, 2.61431579e-02f, -7.22365007e-02f,
  5.79768538e-01f, -3.20037872e-01f, 3.81442845e-01f, 8.59301746e-01f, 1.01365313e-01f, -6.29949868e-01f, -3.83685261e-01f, 2.25429818e-01f, 5.22885919e-01f, -6.07288063e-01f,
  -9.25086960e-02f, 1.98288411e-01f, -6.73888266e-01f, 3.53201985e-01f, -8.38843733e-03f, -4.95628595e-01f, 3.32046837e-01f, 4.05136310e-02f, 2.07607493e-01f, 1.98839381e-01f,
  5.48207164e-01f, -1.77643495e-03f, 3.24068964e-01f, -3.30662392e-02f, 2.67876476e-01f, 4.77603883e-01f, 7.27889389e-02f, -1.62667155e-01f, 2.66540438e-01f, -1.91195890e-01f,
  -1.83596864e-01f, 3.55513006e-01f, 1.92055464e-01f, -1.22903407e-01f, 8.50114971e-02f, -9.73982066e-02f, -9.05096978e-02f, -1.80050418e-01f, 1.20757751e-01f, 5.32004125e-02f,
  -9.34892595e-02f, 5.58658913e-02f, 1.28181994e-01f, -3.20980023e-03f, 9.52055957e-03f, 7.75647089e-02f, 9.84979272e-02f, 9.23683308e-03f, 7.08955601e-02f, 4.95907618e-03f,
  -1.05525674e-02f, 7.55266100e-02f, 1.45949677e-01f, -6.51163682e-02f, 1.21035703e-01f, 1.02479689e-01f, 3.19994837e-02f, -1.96991791e-03f, 4.96294945e-02f, 1.28894180e-01f,
  1.31227747e-01f, -9.24951956e-02f, -1.68735092e-03f, -6.37955889e-02f, 4.56206799e-02f, 1.19807236e-01f, -5.83584271e-02f, -4.52687703e-02f, -7.76710361e-03f, -4.82400097e-02f,
  -4.52382024e-03f, 1.55756503e-01f, 1.12789005e-01f, -4.58215550e-02f, 7.11850896e-02f, 1.52850971e-01f, -5.31800799e-02f, -1.09897591e-01f, 1.07674755e-01f, 8.05370435e-02f,
  -1.60660539e-02f, -1.35754645e-01f, -1.05314679e-01f, -1.08323991e-01f, -1.45917227e-02f, 4.41002706e-03f, 4.43090908e-02f, 1.43213505e-02f, 5.82677983e-02f, -1.91767290e-02f,
  -7.26792574e-01f, -1.91974506e-01f, -9.12258998e-02f, -8.36659744e-02f, -9.48394760e-02f, -6.33020997e-02f, 4.61364761e-02f, 8.40526745e-02f, -1.70996681e-01f, 1.08131636e-02f,
  2.34929193e-03f, -1.86322369e-02f, -7.41930231e-02f, -6.60639033e-02f, -4.35679480e-02f, -6.37799548e-03f, -2.69692093e-02f, 1.01216249e-02f, 2.38202289e-02f, 8.45085457e-02f,
  5.38267381e-02f, -1.23469785e-01f, 8.71498659e-02f, 1.04639202e-01f, -3.85075808e-02f, 5.24965674e-02f, 5.98032661e-02f, -1.03952328e-03f, -3.06730419e-02f, -5.35204411e-02f,
  5.12184322e-01f, 4.73691434e-01f, 4.14995849e-01f, 2.05831751e-01f, -2.93085366e-01f, -5.89902341e-01f, -5.89109421e-01f, -1.15673393e-01f, -4.55228001e-01f, -2.74501480e-02f,
  -4.14989322e-01f, 4.87842798e-01f, -8.09051692e-02f, 8.81952513e-03f, -3.50997567e-01f, -3.83270204e-01f, -1.10756941e-01f, 3.87174785e-02f, -1.34224556e-02f, 1.86699867e-01f,
  -2.56789252e-02f, -6.04270160e-01f, 1.54924974e-01f, -2.75809348e-01f, 2.53167838e-01f, 6.04246378e-01f, 2.44531184e-01f, 4.97527383e-02f, 1.45442486e-01f, -1.33136973e-01f,
  -1.04763098e-01f, -8.36204663e-02f, 1.15379795e-01f, -4.28186776e-03f, 3.77536416e-02f, 9.71520096e-02f, 2.80472577e-01f, -2.84032337e-02f, -1.22191206e-01f, 4.88214046e-02f,
  1.67566374e-01f, 5.54542020e-02f, 7.22541299e-05f, -1.15970716e-01f, 2.90506948e-02f, 9.34556276e-02f, 5.66769578e-02f, 2.19516158e-01f, -6.92584068e-02f, 2.06738189e-01f,
  7.30750486e-02f, 2.60880172e-01f, 8.94367620e-02f, 6.06677234e-02f, 7.59509057e-02f, -3.71868312e-02f, 6.81620315e-02f, 2.76592225e-01f, 6.95667341e-02f, 5.23572490e-02f,
  9.73999426e-02f, -1.06796317e-01f, -8.29690322e-02f, 2.52964683e-02f, -5.42494729e-02f, -1.71308011e-01f, -5.60086258e-02f, 4.25564013e-02f, -2.36036461e-02f, -1.99691746e-02f,
  -3.74202952e-02f, 1.38884142e-01f, -1.63207054e-01f, -1.00276828e-01f, 3.32101099e-02f, 5.96325472e-02f, 7.83755630e-02f, 7.93214887e-02f, 1.65371969e-02f, -3.03273499e-02f,
  -1.78142339e-01f, 3.35754757e-03f, -1.04465358e-01f, 5.93304597e-02f, -1.21476486e-01f, -6.22282252e-02f, 2.99420729e-02f, 1.44281700e-01f, 2.72420757e-02f, -6.28641173e-02f,
  -5.40965348e-02f, -1.63432807e-02f, -8.21409747e-02f, -1.51081886e-02f, -9.65797901e-02f, 9.93983373e-02f, -1.43699259e-01f, 1.88916065e-02f, 6.93633184e-02f, -1.58947811e-01f,
  2.25188419e-01f, 1.24987001e-02f, -1.01771811e-02f, 1.37125567e-01f, -1.05866261e-01f, -1.07936256e-01f, -5.02983220e-02f, 5.61872870e-02f, 7.78944651e-03f, 1.90381229e-01f,
  5.62877171e-02f, 1.16155967e-01f, -6.18025400e-02f, -1.34688139e-01f, 2.59522293e-02f, 2.07015164e-02f, 1.74062699e-02f, 5.69641404e-02f, 5.05279079e-02f, 4.52450588e-02f,
  7.05384985e-02f, -3.23459208e-01f, 4.64181036e-01f, 3.59224111e-01f, 4.97066379e-01f, 4.27087337e-01f, 4.01918173e-01f, 4.20878708e-01f, 8.13195288e-01f, -4.45688903e-01f,
  -3.17977488e-01f, -4.35992151e-01f, -5.09437025e-01f, 1.39622271e-01f, 3.48330259e-01f, -6.17260411e-02f, 3.78776073e-01f, 6.18538680e-03f, 3.74130696e-01f, -1.25751138e-01f,
  1.58560559e-01f, -8.60579088e-02f, -2.53188312e-01f, -1.37057453e-01f, -1.14347391e-01f, 7.47077391e-02f, -4.56612408e-01f, 1.10151373e-01f, -1.89479932e-01f, 2.21784100e-01f,
  -3.13837491e-02f, 1.63990799e-02f, -1.72243237e-01f, -8.42690617e-02f, -4.04352807e-02f, 3.29420157e-02f, 6.76220730e-02f, -1.16823018e-01f, 2.15144411e-01f, 3.17581743e-02f,
  -1.91015661e-01f, 3.60397995e-02f, 7.12308660e-02f, 1.36905527e-02f, 1.97988197e-01f, 1.97204147e-02f, -2.89124567e-02f, -5.52772023e-02f, -2.03821110e-03f, 3.22358236e-02f,
  -1.47520199e-01f, -3.30666974e-02f, 1.22990170e-02f, 6.41836300e-02f, -4.79661152e-02f, 1.52072221e-01f, 7.18234703e-02f, -1.35966651e-02f, 2.66542584e-02f, 1.50480852e-01f,
  1.39644369e-01f, 9.27244276e-02f, -1.39664367e-01f, -5.56590082e-03f, -2.39676004e-03f, 2.59484425e-02f, -9.03382376e-02f, 4.64026770e-03f, 6.39410242e-02f, -1.16069317e-01f,
  1.58531070e-01f, -5.54324239e-02f, 1.10126570e-01f, -3.15108076e-02f, -6.15723729e-02f, 1.28871828e-01f, -2.37202439e-02f, 4.89714108e-02f, -5.64591400e-02f, -3.48753557e-02f,
  6.78445101e-02f, 9.92009416e-02f, -1.82779610e-01f, 5.19013107e-02f, 4.07690071e-02f, -5.39415590e-02f, -5.20040244e-02f, 1.04637496e-01f, -3.90143171e-02f, -1.10173367e-01f,
  -1.12909287e-01f, -6.65444732e-02f, -1.60697341e-01f, -1.33876815e-01f, -1.22249490e-02f, -1.19892202e-01f, 6.90840259e-02f, 1.60349775e-02f, 3.72158438e-02f, 6.65388852e-02f,
  -1.82602704e-02f, -4.30922769e-02f, -6.95271865e-02f, 8.49617762e-04f, -8.19734707e-02f, -1.33440316e-01f, -7.96531141e-02f, -1.26943871e-01f, -9.85451937e-02f, -3.15110087e-02f,
  -2.91991264e-01f, -8.07832628e-02f, 6.51717708e-02f, -7.77770653e-02f, -3.22143845e-02f, -7.81949908e-02f, 1.68009754e-02f, 8.23271573e-02f, 2.37410441e-02f, 5.09928130e-02f,
  5.25327623e-01f, -5.79159483e-02f, -4.38394099e-01f, 1.70418285e-02f, 2.03326240e-01f, 8.01447034e-02f, -3.10471654e-01f, 2.08998844e-01f, -2.83692449e-01f, 5.47396168e-02f,
  2.78843910e-01f, 6.78608641e-02f, -3.37798536e-01f, 5.37037432e-01f, 7.10735500e-01f, -3.28980684e-01f, 3.22888017e-01f, 8.91960934e-02f, -9.01058093e-02f, 4.33126926e-01f,
  2.25721404e-01f, 7.87461162e-01f, 2.81936117e-02f, 4.11713272e-01f, 3.27101916e-01f, -9.41550061e-02f, 2.53938228e-01f, -1.70633852e-01f, 3.20659101e-01f, 2.13110656e-01f,
  -6.98785335e-02f, 6.90901801e-02f, -9.04413611e-02f, -6.18863627e-02f, 9.39487666e-03f, 3.11087593e-02f, -1.43433109e-01f, 3.93167231e-03f, -9.33716446e-02f, -5.75676151e-02f,
  9.90905706e-03f, 1.72138467e-01f, 9.07495320e-02f, 2.39979960e-02f, 4.57292795e-02f, -5.40341362e-02f, -2.55171005e-02f, -2.02280208e-01f, -8.63529146e-02f, 1.73620641e-01f,
  -8.86415541e-02f, -7.68290311e-02f, 4.62812334e-02f, -8.89028534e-02f, -4.04051617e-02f, 2.42278855e-02f, -1.32768899e-01f, -8.06753635e-02f, -1.51525224e-02f, 5.54062314e-02f,
  1.91939190e-01f, -2.00061910e-02f, 4.15900759e-02f, -1.90165453e-02f, -1.25202686e-02f, -1.64295509e-02f, 1.16851695e-01f, 2.79149078e-02f, -1.02443390e-01f, 2.22731195e-02f,
  2.25260314e-02f, 3.35370935e-02f, 5.02177775e-02f, 2.04793047e-02f, 3.79418954e-02f, -2.06097346e-02f, -6.73420802e-02f, 1.08416587e-01f, -1.42243188e-02f, -7.80571997e-02f,
  -1.59287795e-01f, 4.74463701e-02f, -5.82285114e-02f, -9.70313400e-02f, -4.29353267e-02f, 5.96344620e-02f, 1.84502274e-01f, 7.74204135e-02f, -9.60406959e-02f, 1.67751014e-02f,
  -6.04211213e-03f, 4.33868885e-01f, -1.13282852e-01f, -4.43955511e-02f, -9.88223180e-02f, 1.65077314e-01f, -9.96898413e-02f, 1.11445792e-01f, 4.81317565e-02f, 1.57787532e-01f,
  1.44551098e-01f, -7.12046102e-02f, -5.35625545e-03f, 3.79883200e-02f, -1.31453052e-02f, 1.59066290e-01f, 4.19945531e-02f, -1.50477603e-01f, -4.49187495e-02f, 9.18991119e-02f,
  8.18381906e-02f, 6.70329779e-02f, -7.22182542e-02f, -4.04951610e-02f, -3.59683707e-02f, 9.29388963e-03f, 8.27568769e-02f, -7.19974115e-02f, 5.17822318e-02f, -1.79985642e-01f,
  1.07124679e-01f, 4.48684871e-01f, 5.61942458e-01f, 3.41873467e-01f, -3.15337747e-01f, -1.98138773e-01f, -5.27291223e-02f, 1.48215041e-01f, 3.25979859e-01f, -3.91841643e-02f,
  -3.49564672e-01f, 3.67599964e-01f, -1.47886395e-01f, -8.09741914e-02f, -9.81405899e-02f, -1.79680660e-01f, 3.09478819e-01f, 3.38432938e-02f, -1.36538129e-03f, 4.51226622e-01f,
  3.00744921e-01f, -4.14492100e-01f, 6.03224114e-02f, -2.30231658e-02f, 7.14990273e-02f, 4.47503179e-01f, -9.97545347e-02f, 8.92549828e-02f, 1.02132641e-01f, -6.73221201e-02f,
  -9.66682881e-02f, 6.63539022e-02f, 7.67899305e-02f, 2.13840082e-02f, 2.04107970e-01f, -7.68095478e-02f, -5.05177043e-02f, -1.39227867e-01f, -4.92694266e-02f, -3.24900150e-02f,
  1.87623233e-01f, 3.03780362e-02f, -1.23446956e-02f, -1.93066165e-01f, 1.86626241e-02f, 6.25332445e-02f, 1.21764153e-01f, 9.07222927e-02f, 8.00558254e-02f, 7.28451312e-02f,
  2.28546008e-01f, 1.46007761e-01f, 1.28828242e-01f, 1.40270799e-01f, 1.22852556e-01f, 1.57208696e-01f, 1.34495020e-01f, 1.03096940e-01f, 2.76441853e-02f, 1.06882036e-01f,
  -6.13781437e-02f, 5.60449958e-02f, -6.48295879e-02f, -1.34718254e-01f, -1.22404888e-01f, 1.81724709e-02f, 3.48082483e-02f, -9.37396809e-02f, 1.51303932e-01f, 8.84926319e-02f,
  8.86212736e-02f, 1.31814316e-01f, -9.13106352e-02f, 1.57588646e-01f, 3.55040245e-02f, -1.55050159e-01f, -1.12539448e-01f, -4.43192385e-02f, 1.65138721e-01f, 1.28824338e-01f,
  -2.90961087e-01f, -1.74311310e-01f, 2.91029327e-02f, 9.25549120e-03f, -2.15483591e-01f, 1.50800319e-02f, 2.48573832e-02f, -4.39675674e-02f, -8.50959942e-02f, 1.25904456e-01f,
  1.56906456e-01f, 5.08509696e-01f, 2.60283291e-01f, 6.23504780e-02f, 1.39458515e-02f, -1.04576610e-01f, -5.02615459e-02f, 2.05747187e-01f, 2.67176330e-01f, -3.19770463e-02f,
  7.95773491e-02f, 6.17956594e-02f, 1.11403121e-02f, -1.93447307e-01f, 1.15830954e-02f, 1.21677689e-01f, 1.06841296e-01f, 1.35928035e-01f, 2.24791586e-01f, 8.50921199e-02f,
  6.37998357e-02f, -3.07435598e-02f, 1.46414042e-01f, 1.38240978e-01f, 5.13949506e-02f, 1.51685938e-01f, -9.64594558e-02f, 1.25330329e-01f, 9.83382910e-02f, 1.20531462e-01f,
  -5.47131002e-01f, 5.00654638e-01f, -4.02930051e-01f, -2.35145912e-02f, 3.61710131e-01f, 8.79303396e-01f, 5.01469493e-01f, 3.01176876e-01f, 1.30970385e-02f, 3.44074547e-01f,
  5.50848246e-01f, -6.71246350e-02f, 7.10872710e-02f, 6.14695489e-01f, 3.80377948e-01f, 4.61748928e-01f, 4.49136853e-01f, 2.00642884e-01f, -1.61557764e-01f, -8.14045519e-02f,
  -7.01229721e-02f, 3.82664859e-01f, 7.99825042e-02f, -9.66395214e-02f, 1.79689929e-01f, -5.93647718e-01f, -2.14331269e-01f, -4.01551306e-01f, 3.40882093e-01f, 2.28980809e-01f,
  -2.75025866e-03f, -4.61105376e-01f, -1.57281607e-01f, -2.41378233e-01f, -7.12590441e-02f, -2.13210076e-01f, -1.12039357e-01f, -1.25246465e-01f, -1.13278851e-01f, -1.87257472e-02f,
  5.09696864e-02f, -3.17917541e-02f, -1.28182536e-02f, -8.81763175e-02f, -1.79940369e-02f, 7.13476352e-03f, 2.28706986e-01f, 1.44991338e-01f, 1.76185399e-01f, 1.18311577e-01f,
  1.44131050e-01f, 1.93850830e-01f, 9.76866186e-02f, 8.25913399e-02f, 9.52200517e-02f, 1.23704262e-01f, 4.93693948e-02f, 8.01961198e-02f, 2.28194758e-01f, 1.33950859e-01f,
  -8.11826885e-02f, -4.69519496e-02f, 9.09563503e-04f, -1.37661779e-02f, 3.22236829e-02f, 9.30628777e-02f, -3.99414072e-04f, 5.10414988e-02f, -1.14060923e-01f, 2.18859032e-01f,
  1.14212349e-01f, 1.49849793e-02f, -3.30829509e-02f, 1.18076757e-01f, 4.55517089e-03f, -5.28130420e-02f, -1.21113755e-01f, -6.78057522e-02f, 9.85130295e-02f, 1.38491854e-01f,
  -1.93175241e-01f, -2.60426309e-02f, 1.04239002e-01f, -5.96542507e-02f, 1.54506965e-02f, -2.92340256e-02f, -1.60314277e-01f, 1.30204469e-01f, -4.82759587e-02f, 4.82933186e-02f,
  1.06972858e-01f, -4.13902014e-01f, 1.42585402e-02f, 6.67828992e-02f, -1.11370295e-01f, 8.60302523e-02f, -1.08147927e-01f, 2.87524294e-02f, -9.62831452e-03f, 1.15503895e-03f,
  -8.45613107e-02f, 2.28612069e-02f, -1.33569300e-01f, -4.37736250e-02f, 2.43577473e-02f, 1.64856449e-01f, -6.06000051e-02f, -1.54533058e-01f, 1.08964011e-01f, -8.29844996e-02f,
  2.49542166e-02f, -1.24801020e-03f, -1.31639391e-01f, 9.30050611e-02f, 4.74141398e-03f, 1.50262520e-01f, -1.18885413e-01f, -8.60516056e-02f, 7.10608959e-02f, 9.71717387e-02f,
  -6.79367483e-01f, -6.85353160e-01f, 2.56079733e-01f, -5.05541027e-01f, 6.72065839e-02f, 1.94953710e-01f, -2.42539361e-01f, -4.02981699e-01f, -6.20000899e-01f, -4.63773310e-01f,
  -4.56941485e-01f, 2.21101701e-01f, -3.17369580e-01f, 1.10362656e-01f, 6.37995005e-01f, 1.49222091e-01f, -6.68860748e-02f, 1.36560351e-01f, 1.32731870e-01f, -2.18103915e-01f,
  4.54209410e-02f, -7.14924652e-03f, 3.51736128e-01f, 1.02436908e-01f, -1.16845161e-01f, -1.41545469e-02f, 1.98957324e-01f, 7.75455758e-02f, 2.03066379e-01f, 3.40334803e-01f,
  -3.43360722e-01f, -4.36325192e-01f, -5.04297726e-02f, 2.11513899e-02f, -1.36298552e-01f, 3.98276486e-02f, 9.18135196e-02f, 1.59271508e-01f, -3.96770500e-02f, 1.95923373e-02f,
  -1.35849034e-02f, 5.00036553e-02f, 8.63118246e-02f, 6.00766763e-02f, -1.56090319e-01f, -5.04537299e-02f, 2.79793832e-02f, -1.07176267e-01f, -7.45135695e-02f, -9.55718104e-03f,
  -1.63314678e-02f, 5.73566891e-02f, -9.69163403e-02f, 8.62647444e-02f, 1.06466897e-01f, -1.62675232e-01f, 1.56790227e-01f, 1.34099051e-01f, 8.98287296e-02f, -6.54482841e-02f,
  1.22616693e-01f, 2.67676506e-02f, -2.33717486e-02f, 1.73060074e-02f, -6.21402115e-02f, -7.43730813e-02f, 1.12818450e-01f, 6.28202781e-02f, 5.44834100e-02f, -1.24309242e-01f,
  -7.05433190e-02f, 5.53044230e-02f, -8.64195377e-02f, -9.38381776e-02f, -7.71178380e-02f, -3.39357704e-02f, 1.29736066e-01f, -3.10840597e-03f, 1.19170733e-02f, 1.19958252e-01f,
  -6.34870008e-02f, -2.67447270e-02f, -1.11608401e-01f, 1.19068682e-01f, -7.14799017e-02f, -2.41735075e-02f, -9.70962420e-02f, -6.94321021e-02f, -4.97770086e-02f, 7.73819610e-02f,
  -6.01995826e-01f, -6.47633255e-01f, -8.80911201e-03f, -2.22270221e-01f, 1.27270460e-01f, -1.62942102e-03f, 1.15200467e-01f, -4.98954691e-02f, -1.79426238e-01f, -8.26977491e-02f,
  -1.02466382e-01f, 4.01694402e-02f, -3.95073602e-03f, 1.97699144e-02f, 1.31145790e-01f, -8.54230598e-02f, -1.29383639e-01f, -7.67978281e-02f, -1.95160396e-02f, -1.95701960e-02f,
  -8.26606005e-02f, -1.33500040e-01f, 1.84592992e-01f, -5.43728434e-02f, 7.91771933e-02f, -1.05697222e-01f, -2.23372504e-02f, 1.80167332e-02f, 1.34885326e-01f, 8.57391506e-02f,
  6.11293793e-01f, -4.82786894e-01f, 3.18517804e-01f, 3.51418674e-01f, 4.73402113e-01f, -1.61317617e-01f, 1.59714654e-01f, 6.27295822e-02f, 4.42291826e-01f, -5.94776034e-01f,
  -6.56207278e-02f, -2.01591834e-01f, -3.00681163e-02f, -3.73424172e-01f, 3.19868416e-01f, -1.29879579e-01f, -1.97284043e-01f, -4.43985969e-01f, 1.79542989e-01f, -2.19845474e-01f,
  2.12193817e-01f, -5.63815951e-01f, 1.38796508e-01f, -5.05845368e-01f, -3.29074473e-03f, -7.10480958e-02f, -2.23854244e-01f, -1.02960572e-01f, -4.49818105e-01f, -1.40097663e-01f,
  -9.28816870e-02f, 9.14462283e-02f, 1.88791066e-01f, -6.54739365e-02f, 1.36558056e-01f, 1.11631982e-01f, 4.80976328e-02f, -1.05538815e-01f, 1.13482490e-01f, 5.91396634e-03f,
  -4.20217365e-02f, -3.75834666e-03f, -7.36719072e-02f, -1.23311609e-01f, 1.94882184e-01f, 4.14538383e-03f, 9.22954753e-02f, 1.61184758e-01f, 5.10990573e-03f, 1.57220706e-01f,
  1.96092516e-01f, 3.26031856e-02f, 2.25851953e-01f, -9.51685160e-02f, 1.78945214e-01f, 5.12350686e-02f, 4.60687093e-02f, -3.18495780e-02f, -1.95376948e-02f, 8.43010992e-02f,
  -1.86016262e-01f, 1.68457776e-02f, 2.97451243e-02f, 2.67922296e-03f, -9.71314237e-02f, 3.05815674e-02f, -3.87635864e-02f, -9.24723372e-02f, -2.31441241e-02f, -4.59822267e-02f,
  -2.67395824e-02f, 4.88437861e-02f, 7.68508241e-02f, 4.04725596e-03f, -3.57486047e-02f, 6.65136948e-02f, -6.81161731e-02f, -1.42874226e-01f, 1.59310684e-01f, 9.95502397e-02f,
  -6.94542229e-02f, 5.08017428e-02f, -3.02072484e-02f, 1.00692816e-01f, -1.37025192e-01f, 2.32653953e-02f, -1.47200674e-02f, -2.40583718e-02f, 1.13570888e-03f, -1.01930201e-01f,
  -4.82276529e-01f, -8.37312043e-01f, -1.50360148e-02f, -5.03502563e-02f, -3.29918206e-01f, -1.61863845e-02f, -6.18979055e-03f, 4.82063517e-02f, -1.27900928e-01f, -4.58168946e-02f,
  6.40582740e-02f, -3.13950852e-02f, -8.63725692e-02f, 3.88006717e-02f, -5.10963127e-02f, 9.81900543e-02f, -1.11710168e-01f, -9.88663957e-02f, 7.24188052e-03f, -9.12496075e-02f,
  -1.07991353e-01f, -9.21226144e-02f, -1.19001471e-01f, 8.04596692e-02f, 2.18167193e-02f, -3.10254600e-02f, -3.40708904e-02f, -8.51323232e-02f, -1.31942302e-01f, -3.04908492e-02f,
  -3.08677703e-01f, 3.37120503e-01f, 5.40665746e-01f, -4.72307742e-01f, -4.32584584e-02f, 9.82000232e-02f, -5.50191402e-01f, 2.11331889e-01f, -2.35728532e-01f, -5.44320166e-01f,
  -2.97082514e-01f, -2.95535594e-01f, 3.26884478e-01f, -3.89710516e-01f, 5.60744762e-01f, 4.40560132e-01f, 6.09398410e-02f, -2.02283755e-01f, 4.06143457e-01f, 1.68218046e-01f,
  1.91635683e-01f, -3.12401354e-01f, 5.05089521e-01f, 2.50727266e-01f, -6.39239550e-02f, 4.32449095e-02f, 4.72336216e-03f, 1.27146438e-01f, -2.21209571e-01f, 1.29007488e-01f,
  -1.08465970e-01f, 4.49955976e-03f, 2.02777162e-02f, 8.50012377e-02f, 4.31413054e-02f, -1.58208132e-01f, -8.59958082e-02f, 1.14732139e-01f, -7.19633549e-02f, -8.94546434e-02f,
  -2.86968440e-01f, -6.00202642e-02f, -7.95185640e-02f, 1.07866377e-01f, -2.65051991e-01f, -1.92356125e-01f, 8.01233128e-02f, -3.99812823e-03f, 7.28494069e-03f, 1.40796810e-01f,
  4.57588322e-02f, -2.04899232e-03f, -1.44282013e-01f, -3.68271731e-02f, 9.99098420e-02f, -1.87159240e-01f, 2.48898380e-03f, -1.02070076e-02f, -8.49819705e-02f, -7.19929487e-02f,
  1.13132216e-01f, -2.67292839e-02f, 1.96940191e-02f, -9.00775939e-02f, 2.31404025e-02f, 3.39808105e-03f, -1.38839677e-01f, -1.22873695e-03f, 1.54537866e-02f, -6.68118820e-02f,
  -1.60463691e-01f, -7.02421367e-03f, -4.23184782e-02f, -1.03811465e-01f, -2.69539151e-02f, -3.98494378e-02f, 5.34934141e-02f, 8.95493552e-02f, -9.84797105e-02f, 7.85819590e-02f,
  2.32665334e-02f, 6.58147484e-02f, 1.20947137e-02f, -5.21124750e-02f, -9.36802253e-02f, 2.29012463e-02f, -6.35273755e-02f, 3.85393128e-02f, 1.73515439e-01f, 9.69816670e-02f,
  1.66926771e-01f, 4.45222288e-01f, 1.64537743e-01f, -1.65532619e-01f, 2.20518753e-01f, 7.96908140e-02f, 1.31983832e-01f, 1.12636670e-01f, 2.05985289e-02f, 1.23017453e-01f,
  -2.29098186e-01f, -6.30031005e-02f, -1.62342474e-01f, -6.37998513e-04f, 3.70032862e-02f, 1.59005061e-01f, -2.67977268e-03f, -2.65595387e-03f, 9.03537273e-02f, 1.49224520e-01f,
  4.90833595e-02f, -1.88124478e-01f, 2.25018449e-02f, -1.14788890e-01f, -6.29223883e-02f, -1.72613636e-01f, 8.60563144e-02f, -4.71949726e-02f, 1.17409393e-01f, -4.13861647e-02f,
  2.96094686e-01f, 9.51288417e-02f, -2.77059138e-01f, -2.98499256e-01f, 1.85655937e-01f, 7.79385448e-01f, 8.29451084e-02f, 4.15042415e-02f, -3.25011402e-01f, 4.59845334e-01f,
  -5.18489815e-02f, 2.53550205e-02f, -2.93407232e-01f, -1.21119887e-01f, -3.67704958e-01f, -3.90849590e-01f, 2.61503816e-01f, 2.07451925e-01f, -2.72073805e-01f, 3.16045761e-01f,
  -1.01420745e-01f, 1.66476145e-01f, -6.00009859e-01f, 1.91506207e-01f, 2.36530989e-01f, -1.07596852e-02f, -2.65196040e-02f, -3.04177195e-01f, 1.75415903e-01f, -1.86963186e-01f,
  -1.24596156e-01f, -1.22950256e-01f, -1.26749771e-02f, 3.93506885e-02f, 1.93907961e-01f, 2.27426887e-01f, 2.15769112e-01f, -1.72111332e-01f, -1.94227248e-01f, -1.19785324e-01f,
  1.60058409e-01f, -1.38980240e-01f, 8.57534707e-02f, -2.08152920e-01f, 1.07557021e-01f, 1.43113965e-02f, -6.95139095e-02f, -5.79262264e-02f, -1.13141038e-01f, 8.51679360e-04f,
  -1.28889069e-01f, -6.67369366e-02f, 5.58192320e-02f, -5.04775234e-02f, -1.14090323e-01f, -2.72276960e-02f, 1.13277987e-01f, -1.53247258e-02f, 1.31285742e-01f, 5.00635579e-02f,
  1.24456316e-01f, 2.25316063e-01f, 1.27913818e-01f, -1.04292214e-01f, -1.10435687e-01f, -3.39094587e-02f, 2.33147144e-02f, -9.70468223e-02f, -2.04207841e-02f, -1.72771998e-02f,
  -1.28894476e-02f, -6.72422200e-02f, 4.80589382e-02f, 8.00603554e-02f, 7.94147998e-02f, -9.69397184e-03f, 2.17379052e-02f, 3.38131264e-02f, 5.12586385e-02f, -7.66927376e-02f,
  -2.04395518e-01f, 5.24507128e-02f, 1.44310435e-02f, -3.99535634e-02f, -3.35442871e-02f, 2.59196367e-02f, 1.40481517e-01f, -4.49360162e-02f, -1.37652948e-01f, 4.12217118e-02f,
  1.05575606e-01f, 3.87397289e-01f, -1.12059772e-01f, -3.27587090e-02f, -1.28543926e-02f, 1.55105501e-01f, -3.84880626e-03f, 7.48984367e-02f, -8.33250731e-02f, 1.71513319e-01f,
  2.24252492e-01f, 2.07044836e-02f, 4.05721426e-01f, -1.51907757e-01f, -1.14795841e-01f, 1.32214949e-01f, 3.58951427e-02f, -2.86751557e-02f, 5.98595068e-02f, 6.12282157e-02f,
  4.87310812e-02f, 1.76545203e-01f, 9.35913473e-02f, 1.13178089e-01f, 8.35021287e-02f, -7.04766884e-02f, 2.26961076e-01f, -1.14611074e-01f, -6.72533438e-02f, -1.76874995e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.46301430e-01f, 4.29866016e-01f, 7.57308722e-01f, 3.52521926e-01f, 4.68499064e-01f, 4.63302016e-01f, 6.71927214e-01f, 5.74874282e-01f, 6.86443090e-01f, 4.73119467e-01f,
  1.58219606e-01f, 5.43762982e-01f, 6.79132164e-01f, 3.95756006e-01f, 5.69222331e-01f, 4.88913029e-01f, 5.58451176e-01f, 5.72916389e-01f, 6.01672053e-01f, 3.76411110e-01f,
  6.39216721e-01f, 6.03587091e-01f, 5.79910934e-01f, 3.92310083e-01f, 7.04639137e-01f, 8.27885807e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  5.73060289e-03f, -2.67679244e-01f, 1.67095378e-01f, 3.89792621e-01f, -2.66858011e-01f, -2.21697181e-01f, -6.93845391e-01f, 3.30511630e-01f, 9.28078741e-02f, 8.67839038e-01f,
  -3.81290793e-01f, -6.30560100e-01f, 2.89551198e-01f, 7.82539248e-01f, -5.55379748e-01f, 2.94944614e-01f, 4.70711559e-01f, -2.15371147e-01f, -4.84854341e-01f, 2.88096786e-01f,
  -7.42175519e-01f, -5.78086197e-01f, -1.66793913e-01f, -4.35249269e-01f, -5.57322383e-01f, -8.01470578e-01f, -4.20461953e-01f, 4.55619633e-01f, -1.48913071e-01f, -3.84803891e-01f,
  -6.06811106e-01f, -2.44381294e-01f, 2.22458035e-01f, 3.33617389e-01f, 4.01660591e-01f, -1.25074387e-01f, -7.48663843e-01f, -2.33934686e-01f, 5.75970888e-01f, -8.28040242e-01f,
  -5.80930948e-01f, 1.42724216e-01f, 3.51955652e-01f, -3.11300009e-01f, -7.70788968e-01f, 1.74864739e-01f, -4.56285954e-01f, -9.49802577e-01f, 9.21400264e-02f, -4.53199476e-01f,
  -4.61500645e-01f, 6.26743555e-01f, -8.80376026e-02f, -2.50312090e-01f, -1.09087658e+00f, 1.30666986e-01f, -3.80605042e-01f, 7.77549803e-01f, -8.17922354e-01f, 8.23257923e-01f,
  -1.00270641e+00f, -4.15684819e-01f, -3.03849936e-01f, 5.87292135e-01f, -7.50859901e-02f, -1.75124258e-01f, -5.30534804e-01f, -3.13323736e-01f, 1.71573505e-01f, 1.81811437e-01f,
  6.55075729e-01f, -3.74477923e-01f, -4.60830450e-01f, -8.67336467e-02f, 2.08284959e-01f, -2.54729509e-01f, -4.46741760e-01f, -9.98927429e-02f, -7.88262486e-03f, -2.85923749e-01f,
  -3.53282541e-01f, 6.56742036e-01f, 1.44333467e-01f, 1.31414324e-01f, -3.90870422e-01f, -7.73982227e-01f, 4.88501757e-01f, -3.59612107e-01f, 2.14621544e-01f, 3.25798929e-01f,
  -5.12772799e-01f, -1.06212929e-01f, 6.44545794e-01f, -6.18831575e-01f, -8.24928641e-01f, -3.40979248e-01f, -4.74342369e-02f, -1.40175402e-01f, -6.32908493e-02f, -2.45441929e-01f,
  5.77713490e-01f, -3.93528610e-01f, -2.35697672e-01f, 7.17406631e-01f, -6.34950995e-01f, -3.47723633e-01f, -4.24838394e-01f, 5.76099813e-01f, 9.74404871e-01f, -6.50077224e-01f,
  7.34647155e-01f, 4.92015481e-02f, -4.21656594e-02f, -7.03555644e-01f, -7.04533279e-01f, -3.13003927e-01f, -4.13496867e-02f, -3.52516294e-01f, -1.04310662e-01f, -6.41304255e-01f,
  -6.78871155e-01f, -1.83356583e-01f, -2.99751043e-01f, -6.52925968e-01f, -1.66563749e-01f, -4.63117331e-01f, -8.66150558e-02f, -6.02878571e-01f, 2.16742605e-01f, 2.12472439e-01f,
  -1.61033094e-01f, -3.82132649e-01f, -7.11860538e-01f, 1.46565810e-01f, -3.69999371e-02f, -3.25297534e-01f, 1.95829988e-01f, -8.45157206e-01f, -3.97325575e-01f, -6.29405677e-01f,
  7.09077597e-01f, 5.40485233e-02f, 4.31159854e-01f, 3.28982204e-01f, 6.06547259e-02f, 4.50086631e-02f, 7.41382957e-01f, -7.13454247e-01f, -7.68926561e-01f, -7.68513978e-01f,
  -5.87285161e-01f, -3.36958349e-01f, 1.53773040e-01f, -4.31803703e-01f, -9.68079492e-02f, 3.48853737e-01f, 6.11135364e-01f, -1.68842860e-02f, 9.52514648e-01f, -1.76808134e-01f,
  2.14748979e-01f, 9.65845436e-02f, -1.23535119e-01f, 5.34102738e-01f, -1.23349212e-01f, -4.48278666e-01f, 5.67454211e-02f, -6.42733872e-01f, 7.33858407e-01f, 1.62401989e-01f,
  7.38265693e-01f, -6.30543590e-01f, -8.46007019e-02f, -9.60365653e-01f, -8.43471944e-01f, 7.32182741e-01f, 7.78711140e-02f, -4.02411938e-01f, -8.11780155e-01f, -5.15725076e-01f,
  5.32893360e-01f, 2.87602127e-01f, -5.83974004e-01f, -5.93005657e-01f, 6.96744561e-01f, -4.01699871e-01f, 7.24211454e-01f, -1.14178225e-01f, -6.84787273e-01f, -8.25405240e-01f,
  1.25348553e-01f, 3.57277393e-01f, -2.64447331e-01f, 3.48926395e-01f, -2.84357399e-01f, -6.32570028e-01f, 2.44535021e-02f, 7.62687206e-01f, 3.08797687e-01f, -3.24763149e-01f,
  -1.28412127e-01f, -4.44847375e-01f, -6.00078940e-01f, -2.03732386e-01f, -6.96173489e-01f, -4.85331267e-01f, -1.51666075e-01f, -6.15230262e-01f, 2.29111671e-01f, -3.85950625e-01f,
  -3.07027757e-01f, -3.31615418e-01f, 5.74025698e-02f, 5.48270524e-01f, 9.22487795e-01f, -5.67935109e-01f, 6.98262215e-01f, -3.46053481e-01f, -8.19269288e-03f, -8.70984495e-02f,
  -8.69522154e-01f, 8.71174574e-01f, -4.10156101e-01f, -4.49602276e-01f, -9.84625295e-02f, -8.85219127e-02f, -3.62143487e-01f, 1.59252763e-01f, 1.76831037e-01f, -7.25204870e-02f,
  -4.05184686e-01f, 3.40188920e-01f, -3.34901690e-01f, -6.45655543e-02f, -2.76023537e-01f, 3.31991106e-01f, -6.51038229e-01f, -6.13883913e-01f, -4.92827356e-01f, 5.85919499e-01f,
  4.28193331e-01f, -4.22436893e-01f, 2.06609696e-01f, -3.67029190e-01f, 5.79127789e-01f, -3.93395483e-01f, 1.38808906e-01f, 2.70755589e-01f, -2.96445996e-01f, -2.47371927e-01f,
  -4.62531328e-01f, -5.33628047e-01f, 3.04642826e-01f, 2.94697672e-01f, 2.60326266e-01f, -4.32796776e-01f, -4.85455394e-01f, -2.94269085e-01f, -2.96760350e-01f, 4.83736306e-01f,
  5.05560815e-01f, 2.94612467e-01f, 2.67626971e-01f, -2.77300388e-01f, -5.62808931e-01f, 2.80476630e-01f, 2.43508443e-01f, -1.90044850e-01f, 1.02549680e-01f, 4.54729497e-01f,
  -5.64618289e-01f, -3.00447464e-01f, -4.19642419e-01f, -5.06088555e-01f, -2.82150269e-01f, -2.31632628e-02f, 3.35790180e-02f, -1.53886244e-01f, 5.98628223e-01f, 4.49381381e-01f,
  -6.81082070e-01f, 3.96877974e-01f, 5.38593292e-01f, -7.53052711e-01f, -6.91324890e-01f, -2.86319673e-01f, 5.05594969e-01f, -4.45288658e-01f, -4.32584807e-02f, 2.77285669e-02f,
  2.81026214e-01f, 3.06946963e-01f, -1.76105678e-01f, -4.48317707e-01f, -6.95418775e-01f, -5.14168739e-01f, 7.37262070e-02f, -6.50305808e-01f, 6.18441999e-02f, -4.56435293e-01f,
  -4.13052559e-01f, -4.54756439e-01f, -6.42059028e-01f, -5.75296581e-01f, -5.39620042e-01f, 6.11064672e-01f, 8.12110901e-01f, 7.96669424e-01f, 5.95062673e-01f, 6.30942345e-01f,
  -7.14478493e-01f, 9.08251405e-02f, -1.67123988e-01f, -3.36382896e-01f, -5.39012849e-01f, -2.25132927e-01f, 5.40878594e-01f, 1.15443662e-01f, -8.76170248e-02f, -5.76755106e-01f,
  5.43954670e-02f, 3.84072721e-01f, 1.86718833e-02f, -4.75436926e-01f, 2.85173565e-01f, 6.72135949e-01f, -7.69529164e-01f, 1.76808998e-01f, -5.80437899e-01f, -3.04740846e-01f,
  2.86129355e-01f, 7.18372047e-01f, -1.05415499e+00f, 5.81290245e-01f, 2.02785656e-01f, -3.11287373e-01f, -6.40220940e-01f, 4.93148446e-01f, 3.55591655e-01f, -7.34785199e-02f,
  -4.13884461e-01f, -4.51196045e-01f, -3.78485948e-01f, 1.80663899e-01f, -3.90280306e-01f, -1.53699800e-01f, 1.26034245e-01f, -5.23616850e-01f, -4.58860755e-01f, -4.02456820e-01f,
  -4.77691263e-01f, 8.36768270e-01f, 3.07347625e-01f, -1.14449196e-01f, 1.65546745e-01f, -2.68808883e-02f, 5.63324034e-01f, -3.81898224e-01f, -4.81600672e-01f, -5.26350975e-01f,
  5.78652620e-01f, 1.75145581e-01f, -5.07781744e-01f, -6.84507072e-01f, 4.32016581e-01f, -5.09221911e-01f, 4.95268106e-01f, -4.78952229e-01f, -3.18435460e-01f, -3.08016419e-01f,
  -5.13839483e-01f, -4.01934117e-01f, -3.63377631e-01f, -1.39657319e-01f, 4.17819142e-01f, 9.54249740e-01f, -3.43968898e-01f, -4.80977118e-01f, 5.74541032e-01f, -5.47982514e-01f,
  -7.55839720e-02f, 1.04040958e-01f, -8.13126504e-01f, 2.75919408e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.70549241e-03f, 9.73570421e-02f, -9.91530269e-02f, -9.63279977e-02f, 2.59692762e-02f, 3.12924564e-01f, 2.57250011e-01f, -1.52920097e-01f, -2.06958339e-01f, -1.51545003e-01f,
  5.05837193e-03f, 1.58547968e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    