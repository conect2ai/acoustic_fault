/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.50103354e-01f, 1.23199433e-01f, 1.97922140e-01f, -1.06502526e-01f, 2.96669871e-01f, 2.91394413e-01f, 1.49880826e-01f, 9.70398262e-02f, 3.06839645e-01f, -1.22348092e-01f,
  1.04132906e-01f, 1.36464299e-03f, 4.60531078e-02f, -4.79713455e-02f, -1.68916792e-01f, 1.60786256e-01f, -1.70861676e-01f, -4.22148220e-02f, 1.66717023e-01f, -7.74410442e-02f,
  1.42581444e-02f, -1.38140708e-01f, -1.45474941e-01f, 2.03172937e-02f, 4.34305854e-02f, 1.65464189e-02f, -4.04631287e-01f, 1.14327975e-01f, -1.89765692e-01f, -1.32974132e-03f,
  1.31001353e-01f, 2.00058937e-01f, 5.15815876e-02f, -5.41169271e-02f, 9.84083209e-03f, 4.97119129e-02f, -2.28137933e-02f, -4.24772827e-03f, 6.67460337e-02f, 7.32801184e-02f,
  -1.95166003e-02f, -5.40581122e-02f, -2.38245483e-02f, 4.49682213e-02f, 1.95530877e-02f, -1.69795528e-02f, 5.62917767e-03f, 7.06022754e-02f, 5.93768321e-02f, 7.92440027e-02f,
  1.06665373e-01f, 5.77194616e-02f, 8.28004349e-03f, -3.68532017e-02f, 1.95071343e-02f, 1.87894013e-02f, -1.65029778e-05f, 8.77571572e-03f, -1.91708561e-02f, -3.29478607e-02f,
  -4.77033947e-03f, 2.60874839e-03f, -1.13123422e-02f, 1.18304342e-02f, -1.72437318e-02f, -4.06996626e-03f, -3.23048085e-02f, -5.54284593e-03f, 2.97850538e-02f, 8.09498318e-03f,
  2.69261859e-02f, 8.82772729e-03f, 1.14858802e-02f, 5.73963299e-02f, -2.22011306e-03f, -3.56904268e-02f, -1.18004009e-02f, -4.83489782e-02f, 1.52021153e-02f, -3.74792586e-03f,
  5.14646173e-02f, -2.38627233e-02f, -2.70825578e-03f, -6.33998401e-03f, 7.01461956e-02f, 1.56432297e-02f, -4.38486226e-02f, 1.10764606e-02f, 5.48063442e-02f, -4.44228062e-03f,
  -1.69818282e-01f, -2.56131381e-01f, -2.35197712e-02f, 4.86872271e-02f, -7.20022768e-02f, -2.58764364e-02f, 3.01865712e-02f, -3.35634761e-02f, -4.79855463e-02f, -2.43545789e-02f,
  -2.81781908e-02f, -2.13418808e-02f, 6.99146315e-02f, -1.25950146e-02f, -2.17990559e-02f, -4.39027362e-02f, -4.98585738e-02f, -6.43981025e-02f, -1.22791275e-01f, -8.10398459e-02f,
  -1.00718111e-01f, -2.74630450e-02f, -2.66323518e-02f, 5.16987294e-02f, -4.76661213e-02f, 4.81535401e-03f, 2.00756360e-02f, -1.21510224e-02f, -2.99093616e-03f, 4.66054231e-02f,
  1.67120293e-01f, 9.92894396e-02f, -4.07066830e-02f, -1.23909786e-01f, 5.54801263e-02f, 2.24498749e-01f, 1.06951162e-01f, -1.32877991e-01f, 2.46548638e-01f, 1.27216764e-02f,
  2.78490745e-02f, 4.60311724e-03f, 2.39806697e-01f, -1.16898164e-01f, 1.14659995e-01f, 3.98390561e-01f, -7.07700998e-02f, 8.94911960e-02f, 7.56905004e-02f, -1.21744880e-02f,
  -5.18724620e-02f, 4.62796688e-02f, -2.02107266e-01f, -1.45995662e-01f, -2.09852047e-02f, -2.10531384e-01f, -2.26161361e-01f, 4.31947857e-02f, -2.96935230e-01f, -6.89996704e-02f,
  3.35331671e-02f, 8.00588503e-02f, -1.05613925e-01f, -3.42863873e-02f, -4.65102755e-02f, -5.42814238e-03f, 1.21602543e-01f, -4.37895283e-02f, -2.13083066e-02f, -5.56991100e-02f,
  1.17873505e-01f, 3.95707749e-02f, -4.76830713e-02f, -4.70914207e-02f, -2.91447695e-02f, -4.04843800e-02f, -4.04562764e-02f, 1.92816947e-02f, -3.91900130e-02f, -5.80275021e-02f,
  -4.75561619e-02f, -1.56435315e-02f, -3.08574352e-04f, 9.29157585e-02f, -6.47690594e-02f, -1.14644945e-01f, -2.71129720e-02f, -6.10442534e-02f, -4.74797674e-02f, -6.22758567e-02f,
  6.84332624e-02f, 5.73390573e-02f, -3.42151523e-02f, -4.45825309e-02f, -7.90442452e-02f, -4.55511734e-02f, 2.99428869e-02f, -3.27294543e-02f, -4.45555896e-02f, 4.41224165e-02f,
  -5.59286326e-02f, -1.38037493e-02f, 9.66574438e-03f, 2.79152673e-02f, 9.62933153e-02f, -3.82621065e-02f, 1.04427869e-02f, 1.41767142e-02f, 1.61943317e-03f, 6.70233667e-02f,
  6.45310804e-02f, 9.43222363e-03f, -3.62642892e-02f, -1.07521461e-02f, 6.91646570e-03f, -3.59498262e-02f, 6.28627837e-02f, -4.44011251e-03f, -5.23060858e-02f, 6.41029328e-02f,
  8.85144249e-02f, -5.22957072e-02f, 3.92301613e-03f, -6.79277629e-02f, 6.82977214e-02f, -1.13573587e-02f, -2.96094157e-02f, 6.50130510e-02f, 1.11522757e-04f, 1.21909082e-02f,
  -5.04296944e-02f, -5.39197922e-02f, -3.35144661e-02f, -1.70903618e-03f, -1.53048662e-02f, -2.76586358e-02f, 7.92328641e-02f, -4.68207002e-02f, -6.24955595e-02f, 5.61077264e-04f,
  2.04670336e-02f, 1.19238980e-01f, -3.27751227e-02f, -1.03139482e-01f, 2.15567481e-02f, 8.76511559e-02f, -4.15875241e-02f, 4.82398039e-03f, -3.76567477e-03f, 1.00940667e-01f,
  -6.98698342e-01f, -2.76578397e-01f, -7.89321661e-02f, -3.71845037e-01f, -3.87466252e-02f, -1.10635340e-01f, -9.74631160e-02f, -1.12888850e-01f, -3.76441807e-01f, -1.37111805e-02f,
  5.55199534e-02f, -9.26445499e-02f, 1.21380828e-01f, -1.25321105e-01f, 1.46522676e-03f, 7.16252625e-02f, -2.13577971e-01f, -1.20439701e-01f, -7.07373396e-02f, -1.60881028e-01f,
  -7.53717124e-02f, -4.84108750e-04f, 9.40291062e-02f, 7.35852793e-02f, -1.07887469e-01f, -1.31250858e-01f, 5.83625250e-02f, 6.79010600e-02f, -5.68074100e-02f, 8.58313814e-02f,
  1.50633484e-01f, -1.07692555e-02f, -4.62001599e-02f, -5.84497415e-02f, -1.63428281e-02f, 1.37143079e-02f, 7.77451098e-02f, 8.86829868e-02f, 1.19630899e-02f, -4.44705337e-02f,
  4.56469394e-02f, 1.18704699e-02f, 2.71941330e-02f, 4.95244190e-02f, -1.27180517e-01f, -7.63982311e-02f, -3.73857319e-02f, -3.64781283e-02f, 2.23568678e-02f, -2.27156724e-03f,
  5.02068829e-03f, 8.16486403e-03f, -6.56852499e-02f, 3.89757045e-02f, -4.34003361e-02f, -7.49223679e-02f, 6.08038306e-02f, 3.60177201e-03f, -4.92366813e-02f, -2.89992224e-02f,
  -1.69735495e-02f, 1.92492772e-02f, 4.14647795e-02f, 3.19197550e-02f, -9.83408745e-03f, 2.69840248e-02f, 9.64504015e-03f, 3.51690650e-02f, -3.61148454e-02f, -2.21396261e-03f,
  -3.00411899e-02f, -2.49294043e-02f, -7.85797089e-03f, -7.14173615e-02f, -1.52369984e-03f, -2.19240109e-03f, 8.90044589e-03f, 3.96240642e-03f, -8.22817236e-02f, 2.73240241e-03f,
  -2.01590955e-02f, -1.02437260e-02f, 3.17623354e-02f, 2.12539043e-02f, 1.41493175e-02f, 2.08137650e-02f, -2.93273423e-02f, 1.59284845e-02f, 1.71504971e-02f, 5.07911555e-02f,
  -2.82816845e-03f, -3.12778741e-01f, -1.34513050e-03f, 1.20206259e-03f, 2.28140820e-02f, -2.04864908e-02f, -6.45516440e-02f, -4.68728915e-02f, -3.52412611e-02f, -2.16042623e-02f,
  -1.65237542e-02f, 1.07342349e-02f, -5.81892813e-03f, 1.63754914e-02f, 6.56004548e-02f, -4.93301405e-03f, 4.37600389e-02f, 1.15372790e-02f, -4.99662384e-02f, -8.90283007e-03f,
  9.50147305e-03f, -1.01309232e-02f, 3.54593098e-02f, -1.39652807e-02f, 1.27363475e-02f, 1.46379024e-02f, -8.40067863e-02f, -2.65595242e-02f, 5.91487922e-02f, 1.66040976e-02f,
  -7.76400447e-01f, 3.96312140e-02f, -1.71095982e-01f, -2.94450611e-01f, -1.05128199e-01f, 1.53683543e-01f, 2.10197251e-02f, 2.17258781e-02f, -1.13060251e-02f, 1.68777928e-01f,
  4.07290179e-03f, -9.53232646e-02f, 2.76238136e-02f, 8.43106210e-03f, -1.46023080e-01f, 1.37593940e-01f, 2.33016312e-02f, -6.09585233e-02f, 1.55261939e-03f, -7.41476491e-02f,
  -8.19686577e-02f, -6.12460263e-02f, -1.37614220e-01f, 5.37673272e-02f, -3.24181058e-02f, -6.79145083e-02f, -1.56940776e-03f, -6.27026483e-02f, 5.90678528e-02f, -4.50596996e-02f,
  -9.86573007e-03f, -8.67687818e-03f, -4.69530001e-02f, 4.13214825e-02f, 5.38692363e-02f, -1.58701576e-02f, -1.49881700e-02f, -6.39298037e-02f, -5.36892638e-02f, -7.91690964e-03f,
  -6.18546344e-02f, -8.70048255e-02f, -2.71379631e-02f, -1.92910582e-02f, 4.09583328e-03f, -1.71062872e-02f, -4.27646972e-02f, 1.07409735e-03f, 6.87650964e-03f, -3.16650569e-02f,
  -3.70174460e-02f, -1.99580658e-02f, -5.33116190e-03f, -3.74918208e-02f, -4.14735116e-02f, 1.03089027e-02f, -5.27839400e-02f, -1.07752346e-02f, -1.50824189e-02f, -2.26514637e-02f,
  -2.30256058e-02f, -1.38580520e-02f, 1.11884149e-02f, 6.56691473e-03f, -1.97733272e-04f, 3.60085140e-03f, -2.57283207e-02f, 2.29339674e-02f, -3.68590653e-02f, -7.20450096e-03f,
  -2.97473334e-02f, -5.32472469e-02f, 2.56452635e-02f, -2.04125121e-02f, -8.69677402e-03f, 3.37575795e-03f, -9.90496576e-03f, 9.60355997e-03f, 3.72258667e-03f, -3.46329659e-02f,
  7.07693538e-03f, -1.58659241e-03f, 8.42169952e-03f, 2.92845797e-02f, 8.64151679e-03f, -2.71359123e-02f, 1.40553610e-02f, -3.41594070e-02f, 6.06483035e-03f, -3.58286537e-02f,
  1.41938403e-01f, 2.26833418e-01f, 6.16525114e-02f, -1.70344524e-02f, 1.51061593e-02f, 2.05140952e-02f, 2.08828319e-02f, 3.45123671e-02f, 2.99056470e-02f, 3.60638760e-02f,
  -1.38002252e-02f, 4.34708670e-02f, 3.31669934e-02f, -3.59621458e-02f, -4.89514209e-02f, 3.96596044e-02f, -2.36496776e-02f, 3.84505442e-03f, -2.07963604e-02f, 3.92447133e-03f,
  -3.77914798e-03f, -8.44281632e-03f, -7.57957920e-02f, 1.60249439e-03f, 2.34467629e-02f, 5.08599021e-02f, 7.18138739e-02f, -4.61169258e-02f, 2.32845219e-03f, -1.02701541e-02f,
  2.76829712e-02f, -1.87381878e-01f, -7.53473192e-02f, -5.97608760e-02f, -9.70757157e-02f, 1.95145607e-01f, 2.14590713e-01f, -1.20164506e-01f, -1.29458040e-01f, 1.00113608e-01f,
  1.92729115e-01f, -1.71317056e-01f, 1.11905821e-01f, -3.72059122e-02f, 1.65613055e-01f, 9.41561013e-02f, 5.30165136e-02f, 8.08197772e-04f, -1.29894719e-01f, 3.99146602e-02f,
  -5.79538941e-02f, 2.29206514e-02f, 1.58554539e-01f, -2.29835674e-01f, -6.95552230e-02f, -1.02141291e-01f, 2.42879227e-01f, -7.41886348e-02f, 2.40706448e-02f, 2.54324246e-02f,
  1.31085396e-01f, -6.09480068e-02f, 2.56910957e-02f, -9.28015728e-03f, 2.08484769e-01f, 2.67800987e-02f, 1.89725570e-02f, 2.84901424e-03f, 9.06448737e-02f, -4.98226145e-03f,
  2.82878685e-03f, 9.84812621e-03f, 3.47112007e-02f, 3.44772674e-02f, -9.64252278e-02f, -1.38763571e-03f, -4.25739177e-02f, -3.64136733e-02f, -1.19397780e-02f, -2.34391540e-02f,
  -3.81831639e-02f, -2.54119672e-02f, -2.49932986e-02f, 4.85514365e-02f, -1.44196153e-02f, -3.02727818e-02f, 1.06078535e-01f, 7.66790286e-02f, 1.17047094e-02f, 4.14844789e-03f,
  -6.11971021e-02f, -2.03746036e-02f, -4.04554233e-02f, -1.20018767e-02f, -1.46346148e-02f, 7.23319873e-02f, -2.07229517e-02f, 1.00891307e-01f, 6.84161205e-03f, 3.03764306e-02f,
  3.80726270e-02f, -4.64429744e-02f, 1.96636971e-02f, -5.03988750e-02f, -9.74148065e-02f, 6.46155514e-03f, 2.21869536e-02f, -2.26135142e-02f, -8.38891640e-02f, 1.36448694e-02f,
  -2.34801639e-02f, -2.14742240e-03f, -4.07514758e-02f, 4.87568416e-03f, 1.77078079e-02f, -1.31610120e-02f, -8.34230706e-02f, -7.28279203e-02f, 1.44410124e-02f, 2.14138795e-02f,
  1.04480512e-01f, -2.27522422e-02f, 4.14860509e-02f, 8.55760090e-03f, -4.73600812e-02f, 1.63012110e-02f, -7.31229857e-02f, -4.42653596e-02f, -6.46275282e-02f, 1.04855495e-02f,
  -1.41145079e-03f, 1.66041460e-02f, 4.29839715e-02f, -6.31056493e-04f, 3.68070453e-02f, -8.63661245e-03f, 1.16342809e-02f, 1.33518860e-01f, 3.32741886e-02f, 8.90898146e-03f,
  -1.33836251e-02f, -4.52890992e-02f, -6.72366768e-02f, -2.19570342e-02f, 5.77922426e-02f, 7.49025941e-02f, -9.99865867e-03f, 5.83658833e-03f, 2.90549900e-02f, 3.28032821e-02f,
  3.38256389e-01f, 1.87713042e-01f, 4.82325815e-02f, -1.31997466e-01f, -5.42025566e-02f, -3.16127449e-01f, -1.92845002e-01f, -1.85298473e-02f, -1.06906824e-01f, 2.38527474e-03f,
  -8.26873407e-02f, 8.22864845e-02f, 6.36152849e-02f, -1.29996672e-01f, -4.56529707e-01f, -1.48512632e-01f, -3.39778215e-01f, 4.18139435e-03f, -7.35854357e-02f, 6.26031728e-03f,
  -1.27302542e-01f, -9.93868709e-02f, -1.39302626e-01f, 3.98051329e-02f, -7.93179423e-02f, 1.52321592e-01f, 8.80926922e-02f, 4.87781540e-02f, -3.07996329e-02f, -1.91480306e-03f,
  -7.48274624e-02f, 1.50571942e-01f, 1.75265744e-01f, 6.46475554e-02f, 2.51370501e-02f, 3.67316715e-02f, 2.14450285e-02f, 1.21632367e-01f, -1.18078841e-02f, 4.40540537e-03f,
  3.75959165e-02f, 7.23123178e-02f, -2.97556520e-02f, -4.35433351e-02f, -5.89961261e-02f, 5.12711413e-04f, -9.82575025e-03f, -1.70998147e-03f, -1.73864942e-02f, -9.62272733e-02f,
  -1.05437510e-01f, -1.30451769e-01f, -3.96186598e-02f, -1.04307890e-01f, 1.81855839e-02f, -2.83380300e-02f, -2.65706964e-02f, 3.84041034e-02f, -3.92524861e-02f, 3.29260491e-02f,
  2.30297316e-02f, -5.39861880e-02f, 7.45481998e-02f, -3.36568314e-03f, 5.63591272e-02f, 3.41130421e-02f, -3.64349261e-02f, 4.73980904e-02f, 5.01762889e-03f, -4.15025093e-02f,
  -1.56485587e-02f, 8.22140183e-03f, -1.08926492e-02f, -1.04254209e-01f, -1.80886444e-02f, 2.01645438e-02f, 5.04360273e-02f, 1.21194012e-02f, -2.64215749e-02f, -4.76758778e-02f,
  -3.73635478e-02f, -4.62910570e-02f, 2.42436547e-02f, -1.07396161e-03f, -6.69818968e-02f, -1.95653588e-02f, -4.72483821e-02f, 7.05166440e-03f, -2.56593619e-03f, 6.72796881e-03f,
  1.46773174e-01f, 3.38198841e-01f, -5.75964488e-02f, -1.26363263e-01f, 3.57083194e-02f, -5.54227568e-02f, -4.16988581e-02f, -8.26063454e-02f, 3.66199389e-03f, -8.54407772e-02f,
  2.21725237e-02f, 2.46238485e-02f, -5.56719769e-03f, -3.28498408e-02f, -1.24238981e-02f, 4.74929251e-02f, 5.97075224e-02f, 4.60451320e-02f, 2.14701574e-02f, 7.84425884e-02f,
  8.84593129e-02f, 4.58510630e-02f, 4.98578995e-02f, 5.29964045e-02f, 4.44329344e-03f, -4.43509370e-02f, 4.37576361e-02f, 3.46028805e-02f, -2.73773205e-02f, -6.04217052e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.21065640e-01f, 2.15078413e-01f, -2.83969730e-01f, -1.52054712e-01f, 2.07450837e-01f, -6.38429224e-02f, -2.94651926e-01f, -2.58645718e-03f, -2.58547962e-01f, 2.31116816e-01f,
  -3.20231497e-01f, -2.01203659e-01f, -3.70231539e-01f, -3.67575467e-01f, -7.42152631e-01f, -3.26014727e-01f, -2.64646351e-01f, -1.63311511e-01f, -1.25733003e-01f, 7.31479451e-02f,
  -1.41358495e-01f, -1.98902071e-01f, -4.38411713e-01f, 1.53288826e-01f, 2.20740259e-01f, 2.36381605e-01f, 1.78611934e-01f, 5.00397347e-02f, 3.06668907e-01f, -1.54297367e-01f,
  -1.38297737e-01f, -3.31116430e-02f, 4.79328865e-03f, -4.48113456e-02f, -5.99010028e-02f, 1.13646194e-01f, 1.76560596e-01f, -1.45958439e-01f, -5.26564680e-02f, -5.44328578e-02f,
  7.19765350e-02f, -5.34188747e-02f, -6.28644675e-02f, -3.74350324e-02f, 7.60965273e-02f, -9.77530517e-03f, 4.02697809e-02f, 4.55394872e-02f, -2.27711312e-02f, -2.20358521e-02f,
  -6.73231930e-02f, 1.40383570e-02f, 1.25668168e-01f, 6.49753660e-02f, -7.28776902e-02f, -3.67117748e-02f, -4.43308242e-02f, 4.77468446e-02f, 5.03237210e-02f, 2.02848595e-02f,
  1.17205732e-01f, 1.12318821e-01f, -1.97143783e-03f, 3.62448469e-02f, -7.72533268e-02f, 8.20898451e-04f, -2.96718664e-02f, 1.85804870e-02f, -5.74475480e-03f, 3.13658044e-02f,
  9.61337835e-02f, -2.82614678e-02f, 6.47060759e-03f, 1.04124844e-01f, 9.09969509e-02f, 1.30655281e-02f, -5.69500215e-03f, 2.49959007e-02f, 1.76805444e-02f, -4.82962802e-02f,
  4.33174660e-03f, 8.12281668e-02f, -2.72404123e-02f, 1.00921683e-01f, -2.09283400e-02f, 1.74357947e-02f, 1.97931342e-02f, 4.87728976e-02f, 2.25072838e-02f, 1.48188099e-02f,
  1.71598420e-02f, 2.37106547e-01f, -2.39598528e-02f, 1.46263791e-02f, -7.78280124e-02f, 2.27104519e-02f, -1.95080608e-01f, 2.59453300e-02f, 5.94551191e-02f, 1.27708197e-01f,
  7.55754784e-02f, 1.75347961e-02f, 1.51738852e-01f, -6.63946792e-02f, -4.63380888e-02f, -6.59002215e-02f, 4.96159447e-03f, 3.63677032e-02f, 9.76785831e-03f, 1.81221943e-02f,
  1.28703371e-01f, 1.66066781e-01f, -2.56585926e-02f, -2.21347976e-02f, 7.35915378e-02f, 1.42369255e-01f, 1.21895514e-01f, -9.29551199e-02f, 1.92480132e-01f, 1.64109711e-02f,
  5.04929543e-01f, -6.90906122e-02f, -4.35533166e-01f, 2.83942372e-01f, 2.85564482e-01f, 4.50519294e-01f, 8.87305513e-02f, 2.55465657e-01f, 1.18242592e-01f, 1.88622981e-01f,
  1.37833402e-01f, -1.20397262e-01f, -3.25412661e-01f, 2.89009929e-01f, 2.82158732e-01f, -2.22006351e-01f, 3.74958426e-01f, 1.21099047e-01f, -1.50423055e-03f, 6.24301285e-03f,
  1.72857463e-01f, 6.51574552e-01f, -3.12414706e-01f, 4.66176361e-01f, 1.83397576e-01f, -7.26884678e-02f, 2.92705577e-02f, -2.29569554e-01f, 2.08971664e-01f, 6.04249537e-02f,
  1.92299843e-01f, -1.01574017e-02f, -2.65409350e-02f, -8.53246152e-02f, -3.66321835e-03f, -2.69934535e-02f, -1.17112771e-01f, -5.86748030e-03f, -8.58146548e-02f, -4.09419201e-02f,
  5.53101068e-03f, -2.52919551e-02f, 4.51316647e-02f, -3.79972607e-02f, 1.85091943e-01f, -2.77626291e-02f, -3.12390849e-02f, -6.86504990e-02f, -9.88397449e-02f, -7.84359500e-02f,
  -5.91279380e-02f, -4.17019017e-02f, 1.66055709e-02f, -4.52064946e-02f, -9.03833508e-02f, 1.40224043e-02f, -5.17015532e-02f, -1.22313626e-01f, 1.33796409e-02f, 1.03597276e-01f,
  2.49862187e-02f, 2.66618282e-02f, 3.62680736e-03f, 8.49234778e-03f, 4.56494018e-02f, -3.79710109e-04f, 7.11403638e-02f, -6.54349104e-02f, -2.64407564e-02f, -3.73214073e-02f,
  1.23490673e-02f, 3.72145288e-02f, 3.45704332e-03f, 4.73603271e-02f, 1.11526653e-01f, 2.90054139e-02f, 1.38125997e-02f, 5.00614978e-02f, 1.33730518e-02f, 3.47212376e-03f,
  -4.89235371e-02f, 6.96690828e-02f, -5.86494952e-02f, 7.08765015e-02f, 4.44206856e-02f, -2.71208864e-02f, 9.77617800e-02f, 2.11506966e-03f, 3.40510905e-02f, 1.40002035e-02f,
  1.47166355e-02f, 7.83665180e-02f, -2.85688322e-02f, 4.30840999e-02f, -6.44700676e-02f, 1.92364063e-02f, 1.14005692e-01f, 1.04554124e-01f, 5.22755906e-02f, 3.91626880e-02f,
  -1.88870281e-02f, 3.13049704e-02f, 1.06189951e-01f, 3.59265953e-02f, -6.29158616e-02f, 6.35945573e-02f, -3.59533466e-02f, -8.10360983e-02f, 7.70154297e-02f, 3.43041681e-02f,
  6.31550923e-02f, 8.17017779e-02f, 5.13280705e-02f, 1.04481213e-01f, 9.65417251e-02f, -2.82140560e-02f, -2.59861574e-02f, -6.22430928e-02f, 2.35596504e-02f, -8.05045441e-02f,
  -2.00446963e-01f, -1.05503395e-01f, -3.53301108e-01f, 2.50421576e-02f, -2.59564936e-01f, -3.53279442e-01f, -2.93888956e-01f, -1.82607487e-01f, 1.90994248e-01f, 1.37367368e-01f,
  -2.90070981e-01f, 2.88459301e-01f, 6.22609667e-02f, -4.03021216e-01f, 4.57290560e-01f, 3.05045009e-01f, -1.45950057e-02f, 4.58095372e-02f, -2.18474623e-02f, -1.03937864e-01f,
  -4.78761680e-02f, -1.49970084e-01f, -3.94133091e-01f, -2.14850903e-01f, -6.19726360e-01f, 7.74323642e-02f, 2.25251436e-01f, -2.40637362e-01f, -1.84188694e-01f, 5.76660000e-02f,
  -1.27491340e-01f, 5.17255394e-03f, -1.29671350e-01f, 4.95396964e-02f, -7.97388852e-02f, -5.24890050e-02f, -4.51906025e-02f, -2.99701523e-02f, 1.53773716e-02f, -9.31052273e-05f,
  1.13317095e-01f, 1.09976850e-01f, 5.34625985e-02f, -8.49356409e-03f, -2.59723123e-02f, -2.19420660e-02f, 1.69163756e-02f, -9.87068787e-02f, -3.23572755e-02f, -1.27123356e-01f,
  -1.25551820e-01f, -1.06171593e-01f, -1.88656792e-01f, 1.94544196e-01f, -2.76781190e-02f, -9.44081172e-02f, 1.33704007e-01f, -8.67744721e-03f, 4.20054831e-02f, 1.44886419e-01f,
  -1.31203728e-02f, 6.40248582e-02f, -7.62311416e-03f, -1.66251455e-02f, -7.87529871e-02f, -2.20909752e-02f, 7.04864115e-02f, -9.81021300e-02f, 4.26242575e-02f, -4.85693291e-02f,
  3.27158645e-02f, -1.15653999e-01f, -4.73787338e-02f, 5.49572594e-02f, -1.14439473e-01f, 8.14744160e-02f, -9.11981165e-02f, 5.30505776e-02f, -7.65217021e-02f, -4.55079824e-02f,
  -1.45109147e-01f, 2.45373156e-02f, -9.11283046e-02f, -9.78045687e-02f, -9.42854770e-03f, 1.03440702e-01f, -2.48161773e-03f, 7.33651146e-02f, -2.96210703e-02f, -9.18011833e-03f,
  6.81548119e-02f, 2.78425306e-01f, 6.00760467e-02f, 4.21196669e-02f, 4.32099216e-02f, 3.26025188e-02f, 6.55702874e-03f, 5.91903110e-04f, 7.79795554e-03f, -2.26942319e-02f,
  -8.50347057e-02f, 5.01141399e-02f, 3.80421914e-02f, -4.10458222e-02f, 6.45274147e-02f, -2.10370198e-02f, 6.57576248e-02f, 1.60111919e-01f, 6.75474927e-02f, 1.50998915e-02f,
  -6.26230845e-03f, 1.08851328e-01f, 1.14993520e-01f, -4.83247824e-02f, 2.11789701e-02f, 1.10950470e-01f, -7.72321643e-03f, 2.18880344e-02f, 7.37011880e-02f, 4.29042336e-03f,
  -6.59761429e-02f, -1.23444438e-01f, 3.45217139e-01f, 4.66719121e-01f, 1.61349654e-01f, -3.69277745e-01f, -2.82677978e-01f, 7.37862140e-02f, 1.87810123e-01f, -4.23160493e-01f,
  1.30482480e-01f, -2.35082075e-01f, -3.62247199e-01f, 2.52874315e-01f, 4.89314705e-01f, -1.23860486e-01f, 4.32631582e-01f, -8.59954804e-02f, 4.96050976e-02f, 6.90143630e-02f,
  2.55526245e-01f, 1.65393233e-01f, 3.50643128e-01f, 1.96474016e-01f, 1.20532051e-01f, 4.22790945e-02f, 3.45481068e-01f, 5.35151176e-02f, 1.59991339e-01f, 8.69493708e-02f,
  -5.01792207e-02f, -6.79944679e-02f, 2.61497386e-02f, -2.97316797e-02f, -2.97028013e-02f, -1.47382617e-01f, -1.06412865e-01f, -3.46410945e-02f, 5.18300794e-02f, -6.77030757e-02f,
  -1.07111827e-01f, -7.63046890e-02f, 1.87130142e-02f, 7.64706135e-02f, -5.26171662e-02f, 5.76596707e-02f, 2.21908819e-02f, -6.88143745e-02f, -1.04887001e-01f, -7.97175914e-02f,
  8.86647329e-02f, -5.45081608e-02f, -4.35700715e-02f, -1.03253402e-01f, 5.81907965e-02f, -6.66843075e-03f, 1.95122119e-02f, 2.03564391e-02f, -6.17344379e-02f, 5.78051023e-02f,
  1.73490886e-02f, -2.67505832e-02f, -7.10792765e-02f, 2.61596148e-03f, -9.35072303e-02f, 2.03161277e-02f, 4.31946889e-02f, -1.02820709e-01f, -3.72654684e-02f, -3.04271486e-02f,
  -2.63754954e-03f, 2.74298750e-02f, 9.69849080e-02f, -7.46702403e-02f, 8.87073874e-02f, -1.30861551e-01f, 9.50072519e-03f, -7.01245964e-02f, 1.02796126e-02f, 6.97765723e-02f,
  7.89276585e-02f, 9.94844288e-02f, -2.92391032e-02f, 3.22192498e-02f, 9.49018747e-02f, -8.41494873e-02f, 6.21005967e-02f, -2.65084982e-01f, 6.02352917e-02f, 1.67657975e-02f,
  1.07996978e-01f, 3.67090851e-01f, 1.36594260e-02f, -6.46472275e-02f, -1.73126962e-02f, 2.42536119e-03f, 5.37898839e-02f, 4.06098515e-02f, 1.17727108e-01f, -5.06148972e-02f,
  -5.79367466e-02f, 3.99797373e-02f, 3.83782410e-03f, -3.19647486e-03f, 6.53312579e-02f, -1.46479115e-01f, -6.65392634e-03f, 3.89531478e-02f, 1.52519330e-01f, 6.69938922e-02f,
  -8.21258426e-02f, -4.41349819e-02f, -9.01895761e-03f, 1.61912516e-02f, 6.39895573e-02f, -3.68934460e-02f, -1.49888061e-02f, -6.29187599e-02f, 1.39416521e-02f, 5.09391576e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.08763292e-01f, 1.96936011e-01f, 1.04798347e-01f, 1.77634537e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  9.37261432e-02f, -2.97240227e-01f, 2.69990712e-01f, -5.34652174e-01f, -1.34993240e-01f, -2.53555596e-01f, -8.79901588e-01f, 4.21003066e-02f, 1.71763673e-01f, 1.59370732e-02f,
  6.06075406e-01f, -5.55093065e-02f, 2.73384362e-01f, 4.79809880e-01f, -3.06110650e-01f, -2.36515343e-01f, -1.25825167e-01f, 1.45914122e-01f, 2.15756789e-01f, -5.56179509e-02f,
  -6.98755160e-02f, 7.16896541e-03f, -3.67545873e-01f, 4.21092939e-03f, 1.65154070e-01f, 6.82937622e-01f, 1.36465564e-01f, -4.15397674e-01f, -1.18061759e-01f, 4.27215368e-01f,
  9.01502557e-03f, -1.49544477e-01f, -1.13954917e-01f, -6.39048815e-02f, -1.88585207e-01f, 2.07151532e-01f, 2.40813438e-02f, 2.14082077e-01f, -1.85414925e-01f, -6.67105392e-02f,
  1.17558032e-01f, 1.19437873e+00f, -2.09426343e-01f, -2.76354611e-01f, -5.17601013e-01f, -1.94650874e-01f, 3.70815575e-01f, 2.50629219e-03f, 1.46245569e-01f, 1.10817619e-01f,
  1.38935655e-01f, -2.21123472e-02f, 9.66147110e-02f, -1.98497221e-01f, -6.88823164e-02f, 4.16846350e-02f, 6.60827339e-01f, 8.42662811e-01f, -7.16943979e-01f, -3.06737632e-01f,
  -1.99031066e-02f, -3.99557650e-01f, 1.68149993e-01f, 1.07712090e-01f, 3.00056506e-02f, -4.68051106e-01f, 1.87789455e-01f, 2.56938022e-02f, 1.38500720e-01f, 1.45294502e-01f,
  -3.74357998e-01f, 1.24772789e-03f, -7.40920007e-01f, -6.48584843e-01f, 5.66351831e-01f, -8.56025517e-02f, 1.19980901e-01f, 3.48137170e-01f, 2.11816162e-01f, -1.36201069e-01f,
  -2.56428093e-01f, -4.82300043e-01f, -1.89580888e-01f, 8.83283392e-02f, 4.31242548e-02f, 2.02448249e-01f, 5.66771738e-02f, 7.15883225e-02f, -8.38632584e-01f, 1.99245244e-01f,
  8.25780705e-02f, -1.30465806e-01f, -5.35724342e-01f, 5.02543688e-01f, 7.55684823e-02f, 4.39731181e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.10505831e-01f, 2.29776353e-01f, 8.95439148e-01f, 2.28939503e-01f, 6.44176006e-01f, 5.92540979e-01f, 3.96395683e-01f, 7.93677926e-01f, -2.66245514e-01f, -2.60613859e-01f,
  9.61310983e-01f, -1.25283647e+00f, -6.65016353e-01f, 9.31965649e-01f, -1.32664919e-01f, 2.65140414e-01f, -7.88140774e-01f, -7.49638081e-01f, 2.96903253e-01f, 2.46344835e-01f,
  6.65483177e-02f, -2.22416475e-01f, -1.08562088e+00f, -4.75503176e-01f, 1.87412836e-02f, -6.70285821e-01f, 1.90005183e-01f, -6.66105673e-02f, -3.64312120e-02f, 3.27555358e-01f,
  -1.96087822e-01f, 7.36175060e-01f, 4.58084464e-01f, 4.78157729e-01f, 7.98684120e-01f, 1.39254600e-01f, 3.36785346e-01f, 1.30783632e-01f, -7.19265163e-01f, 7.32829511e-01f,
  8.86123955e-01f, 6.34150326e-01f, 7.78017759e-01f, -4.90575284e-01f, 1.64501160e-01f, 2.73358494e-01f, -2.25504637e-01f, -1.70828700e-01f, 3.53829265e-01f, -3.96153331e-01f,
  1.99371234e-01f, 5.03503561e-01f, 5.96868634e-01f, -3.47325504e-02f, -5.27960122e-01f, -2.38041475e-01f, 7.91913390e-01f, -3.72138098e-02f, 3.93961631e-02f, 7.30764091e-01f,
  4.71733868e-01f, -1.01950571e-01f, 9.71100032e-01f, 5.87982416e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  8.78953993e-01f, -1.97756410e-01f, 8.06832612e-01f, 5.92019677e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  6.70594335e-01f, 6.87535703e-01f, 4.10597116e-01f, -6.23140298e-02f, -2.64856786e-01f, 9.92152691e-02f, -1.00614977e+00f, 2.68530771e-02f, -4.70801651e-01f, -2.79767185e-01f,
  -3.98211777e-01f, -2.28247672e-01f, 7.84665197e-02f, -3.99432123e-01f, -1.50265083e-01f, -2.39959136e-01f, 4.39150371e-02f, 8.73489957e-03f, 1.77394450e-01f, 4.37822580e-01f,
  -2.06610426e-01f, -5.51202178e-01f, 9.63440984e-02f, -3.92797112e-01f, -6.02344394e-01f, -5.11044383e-01f, 3.39945316e-01f, 5.55947781e-01f, -2.47198015e-01f, 5.85067570e-01f,
  -2.56600499e-01f, -1.03730887e-01f, -2.39007697e-01f, -2.36858904e-01f, -5.10998428e-01f, 3.75873208e-01f, 2.61564434e-01f, -5.98706640e-02f, 7.20060885e-01f, 3.21475357e-01f,
  4.89171803e-01f, -2.58290052e-01f, 1.34250805e-01f, 3.06308866e-01f, 3.78793150e-01f, -3.56626213e-02f, 4.27336246e-01f, -3.75224471e-01f, 6.99187815e-02f, 2.14852616e-01f,
  -1.34717703e-01f, -4.28185791e-01f, -1.85749844e-01f, -3.65329869e-02f, -9.07081485e-01f, 3.55932444e-01f, 6.56297326e-01f, -3.74516934e-01f, 1.24853387e-01f, 5.99591553e-01f,
  1.62677974e-01f, 2.86801308e-02f, -4.51369554e-01f, -1.44125506e-01f, -1.06056556e-01f, -8.71009678e-02f, -4.32425365e-02f, 6.67851269e-02f, -4.24954355e-01f, 2.17383116e-01f,
  8.10462475e-01f, -2.02381790e-01f, -6.94208980e-01f, 3.65071952e-01f, -4.19134974e-01f, -5.57588160e-01f, 7.00980648e-02f, 7.54492497e-03f, 4.18292969e-01f, -1.98968068e-01f,
  -8.50145444e-02f, -6.34379983e-01f, -2.44279101e-01f, -2.07102999e-01f, 4.57048267e-01f, 2.47272044e-01f, 6.64800048e-01f, -4.48512733e-01f, -8.08764398e-01f, -3.52243692e-01f,
  2.79975813e-02f, -4.04139370e-01f, -2.02532150e-02f, -2.96394765e-01f, 3.91245186e-01f, -2.37317666e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -3.11676145e-01f, 9.16811377e-02f, 1.49164703e-02f, 7.01310515e-01f, 5.09694397e-01f, -6.88716829e-01f, 1.38003004e+00f, 5.68301141e-01f, -6.93549439e-02f, -7.46696413e-01f,
  1.21534908e+00f, 1.62518120e+00f, 1.11708879e+00f, 1.27193964e+00f, 6.11465752e-01f, 4.55260277e-01f, 2.03466341e-01f, 7.31449425e-01f, 2.26259187e-01f, 1.35539532e-01f,
  4.93724793e-01f, 6.64265275e-01f, -2.94685155e-01f, 8.21604788e-01f, 2.16507256e-01f, -6.81882620e-01f, 3.94919008e-01f, 7.14057565e-01f, 1.47121477e+00f, -9.15482759e-01f,
  8.08445930e-01f, -8.54639113e-01f, 7.81414747e-01f, 7.49015093e-01f, 7.36572862e-01f, 7.29745030e-01f, 1.05992055e+00f, 6.12793326e-01f, -5.74145138e-01f, 5.43281376e-01f,
  1.32961071e+00f, 1.58536804e+00f, -1.27700293e+00f, -7.42487907e-01f, 1.67154461e-01f, -1.36583412e+00f, 1.06822109e+00f, 1.47398865e+00f, 1.04501784e+00f, 4.36001509e-01f,
  3.27695727e-01f, 9.64872777e-01f, 1.20308781e+00f, 1.02154064e+00f, -1.46818137e+00f, -1.28529739e+00f, -1.29618001e+00f, -1.52644598e+00f, 9.12642837e-01f, -5.77054806e-02f,
  4.03609157e-01f, 6.75703228e-01f, -5.50244570e-01f, 6.74043238e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  -7.82144605e-04f, 8.30057323e-01f, 5.55733144e-01f, 6.66490614e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -5.19907661e-02f, -5.22730529e-01f, -5.93797147e-01f, -9.08962250e-01f, -8.55286956e-01f, -3.79717916e-01f, -9.51629460e-01f, 1.01301682e+00f, -6.95635140e-01f, -5.01199484e-01f,
  3.12897861e-01f, 8.91644597e-01f, 2.71935821e-01f, 2.06049740e-01f, 3.48678082e-01f, -2.08637953e+00f, 3.46320331e-01f, 8.99022937e-01f, 1.07960977e-01f, 9.95746106e-02f,
  -5.48144639e-01f, 2.23594382e-01f, -1.15391171e+00f, -7.25973487e-01f, -5.47537506e-01f, -3.37315530e-01f, 7.66768932e-01f, 1.15140474e+00f, 6.38256550e-01f, 5.94848812e-01f,
  -1.04553664e+00f, -1.15189767e+00f, -6.51976228e-01f, -2.75779903e-01f, -4.36926991e-01f, 4.41825747e-01f, 1.85350880e-01f, -7.46533424e-02f, -6.28061116e-01f, 9.35965717e-01f,
  1.07719457e+00f, -4.46246684e-01f, 9.84956741e-01f, -9.78327334e-01f, 8.68238211e-01f, -4.47659492e-01f, -8.80797267e-01f, -2.56173164e-01f, 3.69662583e-01f, 7.31764555e-01f,
  -1.11854625e+00f, -2.99191117e-01f, 1.09850669e+00f, 5.46482503e-01f, 1.56947696e+00f, -1.14894640e+00f, -1.30193305e+00f, -1.03693652e+00f, 1.10794377e+00f, -1.21013927e+00f,
  -1.49813890e+00f, -1.77036107e+00f, 7.93567538e-01f, -8.98130774e-01f, -1.60771564e-01f, -7.19216168e-01f, 1.02451670e+00f, 8.42524529e-01f, 5.94600081e-01f, 3.59154403e-01f,
  9.64444876e-01f, 3.59616488e-01f, 1.12508440e+00f, -1.53837726e-01f, 5.71487367e-01f, -8.77260208e-01f, -1.15927935e+00f, 3.82683814e-01f, 6.06337905e-01f, -1.10001576e+00f,
  8.31434369e-01f, 2.94337630e-01f, -3.40013146e-01f, 2.78084487e-01f, -1.42831430e-01f, -1.05271029e+00f, 4.14346516e-01f, -8.43368173e-01f, 4.74901557e-01f, 1.46490562e+00f,
  -2.01541948e+00f, -1.40946591e+00f, 4.09876555e-01f, 1.73480853e-01f, 1.03580251e-01f, -6.48233712e-01f, -5.90920001e-02f, 3.88500065e-01f, 6.76369488e-01f, -5.14793336e-01f,
  2.42873371e-01f, 3.67126286e-01f, 7.33682692e-01f, 7.23172247e-01f, 3.00973535e-01f, 1.10767484e+00f, -8.00025463e-01f, -5.11637554e-02f, 1.18434794e-01f, 5.62447965e-01f,
  -1.85938632e+00f, 2.68837482e-01f, 8.40237066e-02f, -6.21896625e-01f, -1.76339567e-01f, 6.00929379e-01f, -1.03615308e+00f, -1.27493310e+00f, -1.08776867e+00f, -3.28778297e-01f,
  -3.89464676e-01f, -6.48764312e-01f, -1.37663746e+00f, -2.32377902e-01f, -5.00553548e-01f, -1.10065281e+00f, 6.42755985e-01f, 3.95867564e-02f, -1.25611629e-02f, -7.14070976e-01f,
  -1.68283671e-01f, 1.93873242e-01f, -8.15305531e-01f, -4.92982298e-01f, -6.23825371e-01f, 2.06825480e-01f, -8.77239347e-01f, 4.99526143e-01f, -1.02247798e+00f, -7.08806276e-01f,
  2.10235700e-01f, -1.44162762e+00f, -6.14368796e-01f, 8.23602200e-01f, -2.97299355e-01f, -4.72160578e-01f, -7.53835380e-01f, 2.26520952e-02f, 2.90482081e-02f, 2.79701144e-01f,
  9.24483299e-01f, -8.61041009e-01f, 8.54375601e-01f, -9.74983096e-01f, 1.26266754e+00f, 1.41761720e+00f, -9.13349167e-02f, 2.61294276e-01f, -1.23048320e-01f, 1.46501616e-01f,
  -1.29010275e-01f, 5.19665062e-01f, 8.69110823e-01f, -9.17039990e-01f, 2.36089692e-01f, 4.61128026e-01f, -8.01346719e-01f, -2.27300286e-01f, -4.60838169e-01f, 9.69928920e-01f,
  9.36508954e-01f, 1.22345483e+00f, 5.89273691e-01f, -1.19149518e+00f, 4.92929369e-01f, -7.10238159e-01f, 2.36250937e-01f, 6.22913837e-01f, 3.30832064e-01f, 5.59433043e-01f,
  4.03894037e-01f, 5.31620145e-01f, 2.59331077e-01f, 9.80722725e-01f, -1.07295370e+00f, -5.21531284e-01f, -2.51076758e-01f, 1.14287484e+00f, -1.48329270e+00f, -5.50474763e-01f,
  -2.63420999e-01f, 1.15956330e+00f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.58998984e-01f, 2.33582422e-01f, 4.36342284e-02f, 3.83565515e-01f, 3.26594003e-02f, -2.64626142e-04f, -8.29726532e-02f, -2.71802157e-01f, -1.16482191e-01f, -4.94222105e-01f,
  1.75020799e-01f, 5.45678735e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    