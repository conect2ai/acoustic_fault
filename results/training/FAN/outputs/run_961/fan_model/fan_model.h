/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.21648449e-01f, -1.76622406e-01f, -1.49126247e-01f, 2.73472637e-01f, -4.21383977e-02f, -2.57538080e-01f, -4.06314939e-01f, -7.02053010e-02f, 2.30426222e-01f, 2.46378735e-01f,
  1.08115174e-01f, 1.78220868e-01f, 1.99477017e-01f, -6.94670975e-02f, -2.65936673e-01f, -1.35484368e-01f, -1.54209077e-01f, -1.88096449e-01f, -1.98731974e-01f, -2.22382039e-01f,
  -6.83087781e-02f, 1.39548341e-02f, 5.76699078e-02f, -1.20113464e-02f, 2.74401516e-01f, 9.51697528e-02f, 4.11337167e-02f, -5.15156286e-03f, -9.68787521e-02f, -6.52065799e-02f,
  3.83700192e-01f, -7.12268203e-02f, -6.84092343e-02f, 1.99906826e-02f, 6.90077841e-02f, -6.28338335e-03f, -2.04661414e-02f, 1.59032401e-02f, 8.43815058e-02f, 8.54560286e-02f,
  5.06615378e-02f, 3.60102542e-02f, -4.75503579e-02f, -6.72865659e-02f, -2.60043908e-02f, 1.72218420e-02f, -7.43808001e-02f, -2.32192993e-01f, -1.23732671e-01f, 2.91298684e-02f,
  -1.34357244e-01f, -9.96421725e-02f, -6.82989955e-02f, -7.10397139e-02f, -2.00711668e-01f, -1.05721153e-01f, -3.05516236e-02f, -1.86794162e-01f, -1.46201700e-01f, 1.14171490e-01f,
  -2.23859176e-02f, 6.87443018e-02f, 9.15106684e-02f, -2.91231927e-02f, -5.39877405e-03f, 3.00195292e-02f, -1.77553520e-02f, -6.14599092e-03f, 5.69578670e-02f, 4.43906449e-02f,
  -7.44259804e-02f, -2.91293245e-02f, -9.07931477e-02f, 5.44081256e-02f, 1.18160181e-01f, -6.20559268e-02f, -4.94792350e-02f, 1.17502324e-01f, 2.69575156e-02f, 5.14168516e-02f,
  2.74318904e-02f, 1.27696916e-02f, 4.21276912e-02f, 1.48496106e-02f, -1.00991309e-01f, 2.49490682e-02f, 7.35054910e-02f, 3.07808556e-02f, 9.10526589e-02f, 3.66619527e-02f,
  4.18652892e-01f, -2.26309270e-01f, 1.50866598e-01f, -3.18678692e-02f, 5.77600785e-02f, 1.38201416e-01f, 1.20643996e-01f, 1.87641140e-02f, 2.00576452e-03f, 2.40620859e-02f,
  -2.84651984e-02f, 1.32367807e-02f, 3.15537788e-02f, -2.15204945e-03f, -3.15369666e-02f, 5.92014231e-02f, 8.66758451e-02f, 2.83965077e-02f, -7.27423420e-03f, 5.96651919e-02f,
  2.63212863e-02f, 1.93687975e-02f, 2.19837040e-01f, 9.59036201e-02f, 2.70606130e-02f, 1.38504654e-02f, 5.55610955e-02f, 7.16185570e-02f, 5.39680161e-02f, 2.98158795e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.23166001e+00f, 2.20882341e-01f, 5.55882335e-01f, -1.08116753e-01f, -7.38754451e-01f, -4.41348314e-01f, -1.84929773e-01f, -4.53951657e-02f, -1.53298378e-01f, -1.85960576e-01f,
  -3.15749586e-01f, -1.76053524e-01f, 1.57121941e-01f, 1.46427095e-01f, 5.92874467e-01f, 1.40025124e-01f, 1.59604087e-01f, 8.13312352e-01f, 5.19944906e-01f, -2.05292523e-01f,
  -3.39988023e-01f, 1.01584271e-01f, 6.98231995e-01f, 3.21171522e-01f, -3.09525430e-01f, -2.69742429e-01f, 1.17616564e-01f, 9.71270576e-02f, -1.15509614e-01f, -8.39694287e-04f,
  -1.52208120e-01f, 3.25575262e-01f, -1.12034023e-01f, -1.23936489e-01f, -3.73380743e-02f, 1.76907077e-01f, -1.09174728e-01f, 6.23289086e-02f, -5.66706546e-02f, -1.85291350e-01f,
  -1.94154337e-01f, 5.20060323e-02f, 1.47763684e-01f, -1.34220302e-01f, -3.84512753e-03f, -1.16928570e-01f, 1.79240331e-01f, 1.97552845e-01f, 4.39372770e-02f, 6.44740090e-02f,
  -2.06230089e-01f, -2.26903602e-01f, -1.11627422e-01f, -1.61583424e-02f, 9.21111554e-02f, -6.64242357e-02f, 1.14091374e-01f, 2.30108164e-02f, 4.27594371e-02f, -1.14587732e-01f,
  4.64909300e-02f, 7.12702200e-02f, 7.84385577e-02f, -8.94419923e-02f, 9.50211659e-02f, -7.04222322e-02f, -1.65013999e-01f, -1.42479807e-01f, 1.56616390e-01f, 9.05991942e-02f,
  -1.70447111e-01f, 8.94016866e-03f, -2.57220049e-03f, -9.56480801e-02f, 2.97713224e-02f, -4.15389775e-04f, -2.09202208e-02f, -3.96507755e-02f, 1.36338443e-01f, 2.07471382e-02f,
  2.04542905e-01f, 7.68054798e-02f, 1.29866049e-01f, 4.59505506e-02f, -1.76455244e-01f, -3.67678031e-02f, -4.65016179e-02f, -1.27611846e-01f, 5.97182401e-02f, -3.79530378e-02f,
  -3.86377096e-01f, 3.89407873e-01f, -1.16756395e-01f, 2.58859068e-01f, -5.18920273e-02f, 2.12379649e-01f, 3.27204838e-02f, -1.01289861e-01f, -9.67355222e-02f, -9.71501917e-02f,
  -5.32699376e-02f, 2.92117268e-01f, 2.45208189e-01f, 1.78882241e-01f, -2.28012353e-02f, -2.96628829e-02f, -5.70466109e-02f, -1.43590361e-01f, 4.45320085e-02f, -2.67244056e-02f,
  1.45227974e-02f, -2.29551345e-01f, -1.18137926e-01f, -1.13839552e-01f, -7.12927878e-02f, -6.23887815e-02f, -1.08453639e-01f, -5.53511828e-02f, 1.31673336e-01f, -2.17395931e-01f,
  1.01592171e+00f, 1.55602008e-01f, 1.24266736e-01f, 1.27015054e-01f, 1.11340031e-01f, 1.89156473e-01f, 6.32278085e-01f, 5.32886446e-01f, 1.56767011e-01f, 1.18922085e-01f,
  -4.59938824e-01f, -9.44586158e-01f, -7.64606595e-01f, -6.80527627e-01f, -2.03969330e-01f, 2.57692993e-01f, 2.83168137e-01f, -2.29065567e-01f, -1.34618446e-01f, -9.25399959e-02f,
  -1.32301077e-01f, 4.09246236e-01f, 4.70264584e-01f, 5.57230562e-02f, 8.47714469e-02f, -1.05730608e-01f, 3.00227851e-01f, 2.65076607e-01f, -2.07711622e-01f, -1.44275188e-01f,
  -3.70394379e-01f, 4.31804478e-01f, -1.98722616e-01f, -2.27805793e-01f, -1.08322285e-01f, -4.06446680e-02f, -3.30818407e-02f, 6.72061518e-02f, -1.78391226e-02f, 1.64412111e-01f,
  -1.30412146e-01f, -1.31655052e-01f, -1.75986260e-01f, -2.78692972e-02f, 1.49890274e-01f, 1.14290349e-01f, 3.60968336e-02f, -2.45474037e-02f, -3.50827098e-01f, -1.52584493e-01f,
  -4.63439375e-01f, -1.31795034e-01f, 8.65582004e-02f, -6.70219064e-02f, -1.66829631e-01f, -1.42209575e-01f, 3.02336514e-02f, -1.45064120e-03f, -4.23557917e-03f, 3.65983337e-01f,
  1.05652642e-02f, 3.44551764e-02f, -7.06460252e-02f, -3.68658863e-02f, 1.58568323e-02f, 4.21136729e-02f, -1.00215822e-01f, -2.36081295e-02f, -9.26785171e-02f, 1.50243908e-01f,
  -1.10930465e-01f, -1.53070599e-01f, -2.39371940e-01f, 4.30685803e-02f, -3.24773967e-01f, -3.07138562e-02f, 9.71047394e-03f, 1.22966049e-02f, -3.80443595e-02f, 1.10278994e-01f,
  -5.90626486e-02f, 7.10283592e-02f, 8.33481252e-02f, -5.67715615e-02f, -4.39402368e-03f, -1.03899375e-01f, -7.92971998e-02f, -1.27635062e-01f, 8.98391530e-02f, 6.70061484e-02f,
  4.57242094e-02f, -4.31200832e-01f, -1.00104406e-01f, -1.18939824e-01f, 1.00769177e-01f, -1.85462877e-01f, -3.20547253e-01f, -5.98782562e-02f, -7.96598867e-02f, 1.38370274e-02f,
  -1.13259703e-01f, -1.72661737e-01f, -2.03461379e-01f, 2.90672183e-02f, 1.34174496e-01f, 7.98854008e-02f, -1.24896787e-01f, -1.45237610e-01f, -1.53456539e-01f, 1.20206829e-02f,
  -4.01659636e-03f, 8.43162239e-02f, 1.66394144e-01f, 1.18750455e-02f, -7.95474797e-02f, -8.13564286e-02f, 7.27727488e-02f, 6.29374161e-02f, 2.16950759e-01f, 5.67818582e-01f,
  8.34195912e-01f, -8.50685000e-01f, -6.47835340e-03f, -1.78325728e-01f, 1.32448198e-02f, 1.34049043e-01f, 1.47247851e-01f, -1.23163452e-03f, 4.71096151e-02f, 3.22680473e-02f,
  8.90332907e-02f, 3.81317437e-01f, 4.72750187e-01f, 2.82182038e-01f, 1.39943585e-01f, -2.36100778e-01f, -3.39800686e-01f, 2.43551970e-01f, 5.87718785e-01f, 2.26125300e-01f,
  -1.04085080e-01f, -1.31931528e-01f, -1.91862546e-02f, -3.14020514e-02f, -5.70134759e-01f, 2.39302039e-01f, -2.81009227e-01f, -3.91548306e-01f, -2.63934553e-01f, -7.45454609e-01f,
  5.21885693e-01f, -6.48319960e-01f, 5.65940402e-02f, -1.51314467e-01f, -2.57831931e-01f, -1.98539882e-03f, 9.29213241e-02f, -2.21722543e-01f, -1.08073317e-01f, -1.62671208e-01f,
  -1.34198770e-01f, -1.16508007e-01f, 2.73142895e-03f, -1.37138590e-01f, -1.45014683e-02f, 5.66957444e-02f, -2.15162441e-01f, -1.76257014e-01f, -3.40307564e-01f, -9.32898000e-02f,
  -2.15801418e-01f, -1.72186121e-01f, 1.00676594e-02f, -6.18969500e-02f, -1.02453023e-01f, 1.54977888e-01f, -2.45420307e-01f, -2.68553734e-01f, -2.18167361e-02f, -4.14321184e-01f,
  9.44469590e-03f, -8.94898251e-02f, -4.45730574e-02f, 2.12040737e-01f, 1.34867996e-01f, 1.73712239e-01f, 9.09485295e-02f, -3.07192113e-02f, -4.01588827e-02f, -8.58790241e-03f,
  -7.56693259e-02f, -9.67035349e-03f, -4.25395779e-02f, 2.08965689e-02f, -8.70894343e-02f, -2.05855325e-01f, -6.62714764e-02f, 6.35164464e-03f, -9.97529551e-02f, -3.47408243e-02f,
  -6.37799948e-02f, -8.54486004e-02f, -1.58495396e-01f, -1.45111874e-01f, -2.06285998e-01f, -2.01907437e-02f, -5.46283722e-02f, -3.46713699e-02f, -4.26320806e-02f, -1.67292684e-01f,
  3.65954250e-01f, 5.86094335e-02f, 7.36279562e-02f, -7.71628693e-02f, -2.86941111e-01f, -1.83533743e-01f, 6.79395944e-02f, -2.62635916e-01f, -1.19513385e-01f, -7.71188783e-03f,
  -9.65311825e-02f, 7.86517337e-02f, 7.27188215e-02f, -1.53732985e-01f, 3.41422349e-01f, 2.13704571e-01f, -1.02608263e-01f, 1.90760568e-01f, -1.22045591e-01f, -1.60181731e-01f,
  -1.62496522e-01f, 1.81745917e-01f, 4.84719366e-01f, 2.42370158e-01f, -5.81339858e-02f, 4.04582947e-01f, 2.58690834e-01f, 1.52669460e-01f, 2.87896276e-01f, 2.93582886e-01f,
  6.76148176e-01f, 4.28305596e-01f, -8.52070302e-02f, 4.47456270e-01f, 4.09545936e-02f, 2.13488594e-01f, 2.65270799e-01f, 2.95875758e-01f, 5.23093939e-01f, 4.12599713e-01f,
  2.72702247e-01f, 5.29917717e-01f, 4.74586904e-01f, 3.55322152e-01f, 3.22363526e-01f, 2.69528508e-01f, 1.39513060e-01f, -4.41854261e-02f, 9.28986445e-02f, 2.33717397e-01f,
  4.51837063e-01f, 3.14036846e-01f, 6.14911504e-02f, 1.37368828e-01f, 1.92298070e-01f, 3.27543885e-01f, 7.95089826e-02f, 1.08701415e-01f, 1.35694370e-01f, 2.50387460e-01f,
  -2.16532886e-01f, 2.30158102e-02f, 9.90713015e-02f, -5.61701991e-02f, -1.23935379e-01f, -1.09562203e-01f, -3.17470022e-02f, -1.58511966e-01f, -2.25555092e-01f, -3.76908854e-02f,
  -2.04859868e-01f, -1.81656316e-01f, -1.99493870e-01f, -1.68003470e-01f, -2.30244234e-01f, -1.91394642e-01f, -1.77522883e-01f, 6.77839443e-02f, 3.11224051e-02f, 5.71655706e-02f,
  7.75876492e-02f, -6.28643781e-02f, -2.69347101e-01f, -1.91242378e-02f, 9.22145769e-02f, -8.10851529e-02f, -2.07590252e-01f, -2.70580072e-02f, -9.63166058e-02f, 1.20587990e-01f,
  2.96618044e-01f, 2.72089899e-01f, -2.99506839e-02f, 4.68460992e-02f, 7.65846483e-03f, -1.66356079e-02f, -4.88045253e-02f, 2.95150410e-02f, -5.53357676e-02f, -9.09031183e-02f,
  -1.82118163e-01f, -2.58106515e-02f, -5.26599027e-02f, 1.76226482e-01f, 1.39004752e-01f, -9.08406451e-02f, -1.11125320e-01f, 1.66672450e-02f, -2.83379376e-01f, -1.79218113e-01f,
  -1.33193254e-01f, -1.12906724e-01f, -1.76863566e-01f, -1.98669881e-01f, 4.59134206e-03f, 8.04305077e-03f, -6.38088305e-03f, 5.07915951e-02f, 6.14771880e-02f, -8.09456706e-02f,
  2.17393979e-01f, -8.80258009e-02f, 6.15813434e-02f, 8.28112513e-02f, -5.86723164e-03f, -1.95863634e-01f, 1.34135216e-01f, -1.10543832e-01f, -3.17423970e-01f, -9.92603134e-04f,
  -7.13894293e-02f, -4.43421341e-02f, -3.98439169e-02f, -5.28468788e-02f, -2.04122379e-01f, -4.60547768e-02f, 3.86960320e-02f, 1.52841166e-01f, 4.09342013e-02f, -5.27567882e-03f,
  -1.87181588e-02f, 1.34387597e-01f, -1.40273035e-01f, 5.15480526e-02f, 1.82570294e-01f, 3.49220634e-02f, -1.01002425e-01f, 5.30365705e-02f, 2.89592613e-02f, 1.74340215e-02f,
  -5.46855748e-01f, -9.73834217e-01f, 5.28328478e-01f, 6.88376009e-01f, 1.03587079e+00f, 5.00846624e-01f, 1.37687460e-01f, -5.29040620e-02f, 3.85302901e-02f, -7.20030740e-02f,
  -2.25928381e-01f, -1.97215274e-01f, -1.63644046e-01f, -2.59566933e-01f, -2.08789364e-01f, 1.31800532e-01f, 5.90571463e-01f, 3.81759375e-01f, 4.40808088e-01f, 2.30277777e-01f,
  1.34210631e-01f, 7.79383481e-02f, 2.20223088e-02f, 1.87915191e-01f, 1.57161191e-01f, 3.64806652e-01f, 2.67175347e-01f, 3.88231575e-01f, 2.20008567e-01f, 2.09057257e-01f,
  -1.58240914e-01f, -1.58824861e-01f, 2.91775584e-01f, -6.51266724e-02f, 8.89093243e-03f, -3.78371984e-01f, -2.97249053e-02f, -1.87399313e-01f, -2.41397426e-01f, -1.07105657e-01f,
  8.99332389e-02f, -9.53570679e-02f, 2.85152867e-02f, 1.20952039e-03f, 4.34529688e-03f, -1.15514271e-01f, -2.76121765e-01f, -1.41164556e-01f, -8.98149833e-02f, -1.22865707e-01f,
  -2.51773670e-02f, 3.85984570e-01f, 4.94189531e-01f, 1.20532051e-01f, -1.84816241e-01f, 2.69025147e-01f, -5.05219102e-02f, -3.40255834e-02f, 4.40221652e-02f, -2.03527555e-01f,
  3.38632524e-01f, 8.43093619e-02f, 6.89367428e-02f, 5.23397932e-03f, -1.23896323e-01f, 4.54410091e-02f, 1.13468528e-01f, 1.22812949e-01f, 1.34908140e-01f, 3.79187688e-02f,
  1.68150499e-01f, 1.68759093e-01f, 8.07061121e-02f, -1.02731489e-01f, 1.17143400e-01f, 1.45089343e-01f, 3.51117551e-03f, 1.50351925e-02f, 1.16233423e-01f, 6.85886741e-02f,
  1.06689855e-01f, 5.78485057e-02f, -2.04884149e-02f, -1.68540791e-01f, 1.36597842e-01f, 1.71647936e-01f, 1.66392013e-01f, -3.37544605e-02f, 1.08960038e-03f, -9.95249078e-02f,
  -2.26567596e-01f, 4.50895995e-01f, 1.30300552e-01f, -6.72966093e-02f, 1.79063335e-01f, -1.21153787e-01f, 5.29098557e-03f, -2.38190684e-02f, -3.77451368e-02f, -1.42730564e-01f,
  -2.95346025e-02f, -2.38009483e-01f, -1.86464250e-01f, -1.10326089e-01f, 6.27692640e-02f, 7.98901096e-02f, -4.07744907e-02f, 6.69600889e-02f, -1.61364317e-01f, 3.52864666e-03f,
  -2.32086629e-01f, 2.74614900e-01f, 3.64709586e-01f, 9.55231339e-02f, -1.26964459e-02f, 3.81780624e-01f, -1.00332778e-02f, -8.49356130e-02f, 1.01243861e-01f, -2.38069549e-01f,
  1.43870163e+00f, 6.92295790e-01f, 3.19627881e-01f, 4.35134351e-01f, 8.15657005e-02f, -1.92791909e-01f, -2.43327782e-01f, -3.62625986e-01f, -2.40465686e-01f, 2.46000022e-01f,
  4.11109388e-01f, 3.01274449e-01f, 2.83156615e-02f, -1.02561243e-01f, -1.07388176e-01f, -2.11080566e-01f, -2.24804223e-01f, 1.96590915e-01f, 3.13406624e-02f, 2.03251988e-01f,
  2.61893570e-01f, 2.56216496e-01f, 4.49770927e-01f, 1.06985651e-01f, 2.34455496e-01f, 1.15781175e-02f, -3.34406048e-02f, 2.68833518e-01f, 3.41453850e-01f, 4.40666050e-01f,
  7.85569966e-01f, 5.48501194e-01f, -5.03920555e-01f, 4.00749873e-03f, 1.61409557e-01f, -6.41063675e-02f, -2.65213270e-02f, -7.09210634e-02f, -5.59317917e-02f, -1.13547370e-01f,
  2.49307510e-02f, 7.70167485e-02f, 4.70230319e-02f, -1.32230952e-01f, -2.80108768e-02f, -5.67215644e-02f, -2.00686336e-01f, -1.48383707e-01f, -1.49293497e-01f, 4.56764288e-02f,
  1.28502483e-02f, 2.48670310e-01f, 1.68597661e-02f, -2.91106701e-01f, -2.35260259e-02f, -5.29857837e-02f, -7.22031444e-02f, 7.13039264e-02f, -8.75367969e-02f, 9.61577967e-02f,
  -9.04817432e-02f, 3.02902132e-01f, 3.50723386e-01f, 1.05934083e-01f, 1.58595920e-01f, -9.73902196e-02f, -7.18371645e-02f, 4.79493961e-02f, -1.06327325e-01f, 3.50579023e-02f,
  -1.96769744e-01f, 6.81558326e-02f, -1.02516495e-01f, -1.80403106e-02f, 8.54020640e-02f, 2.06624076e-01f, 7.71101490e-02f, 8.66896883e-02f, 5.56518920e-02f, -1.19201884e-01f,
  1.81016162e-01f, -2.65034497e-01f, -1.48414060e-01f, -1.91463500e-01f, -2.66886532e-01f, 1.92947820e-01f, 1.27330765e-01f, 1.29162982e-01f, 1.26717716e-01f, 1.45397842e-01f,
  -6.03446305e-01f, -2.45576486e-01f, 6.19856268e-02f, -1.12477593e-01f, 2.37608820e-01f, 3.90149578e-02f, 5.58246598e-02f, -8.66240710e-02f, -5.06517924e-02f, -8.89401510e-02f,
  8.14336911e-02f, 1.97665911e-04f, -4.96441051e-02f, -1.97470903e-01f, -1.91819713e-01f, -2.49955907e-01f, 4.10624954e-04f, -1.21131562e-01f, -2.57070988e-01f, -1.02697231e-01f,
  -1.41349763e-01f, -8.32068920e-02f, -1.11519635e-01f, -2.45256856e-01f, -1.67953625e-01f, -2.16885909e-01f, -1.62803978e-01f, -1.85057804e-01f, -2.39050806e-01f, -3.47921759e-01f,
  -6.43894911e-01f, 7.91838706e-01f, 2.82126933e-01f, -4.30953205e-01f, 1.20860174e-01f, 9.90784019e-02f, 6.67882860e-01f, 5.01899719e-02f, -1.75387144e-01f, 7.07849622e-01f,
  8.06460083e-01f, -5.02250850e-01f, -3.55326474e-01f, -5.48436522e-01f, -4.62466776e-01f, 1.48232132e-01f, -1.69232219e-01f, -8.97544801e-01f, -1.53264356e+00f, -1.04427433e+00f,
  -5.56898355e-01f, -5.79195380e-01f, -6.78125143e-01f, -5.47417939e-01f, 5.64076677e-02f, -6.64843976e-01f, 3.83664936e-01f, 1.59836575e-01f, -5.75227216e-02f, -1.47451773e-01f,
  5.91493249e-01f, 3.21741641e-01f, -6.83326364e-01f, -3.83881211e-01f, 2.76882559e-01f, -1.50244102e-01f, -1.01617709e-01f, 7.12725706e-03f, 1.08971335e-02f, 6.26430986e-03f,
  -1.84521619e-02f, -4.11096513e-02f, -1.48399845e-01f, 8.59392658e-02f, 1.45126686e-01f, 1.06730066e-01f, 1.01648413e-01f, -2.87156940e-01f, -1.60127193e-01f, 3.37334633e-01f,
  3.18693697e-01f, 3.23525220e-01f, 2.37335771e-01f, 8.62441212e-02f, 5.76059036e-02f, -2.48948485e-01f, 3.36302698e-01f, -2.94244103e-02f, -9.62616205e-02f, 8.47320631e-02f,
  -2.31663063e-02f, -8.79192725e-02f, -9.82049108e-02f, 1.20395176e-01f, 4.84711714e-02f, -9.05970186e-02f, 5.54915927e-02f, 1.30563900e-01f, -3.03126853e-02f, 4.20744717e-03f,
  7.62874410e-02f, 1.28061220e-01f, 1.86464012e-01f, 2.22272068e-01f, -1.36473522e-01f, -8.44583511e-02f, -1.57902259e-02f, -3.61148119e-02f, 7.55395889e-02f, -1.17282078e-01f,
  -1.03089109e-01f, 2.00558692e-01f, 8.09281096e-02f, -1.27404055e-04f, 3.12350094e-01f, 3.37662287e-02f, 6.98361993e-02f, 3.46282907e-02f, -6.55769929e-02f, 3.29024792e-02f,
  -8.74160379e-02f, -2.03053892e-01f, -2.52902433e-02f, -1.42607227e-01f, 1.52167112e-01f, 1.76110975e-02f, 1.54163927e-01f, -4.70570214e-02f, -2.36924700e-02f, -9.96667445e-02f,
  -6.08912297e-02f, -7.52921700e-02f, 2.72754222e-01f, 1.55348957e-01f, -1.22805305e-01f, 4.74155284e-02f, 6.43440932e-02f, -3.58984619e-02f, -1.47760272e-01f, 3.25113654e-01f,
  1.86732247e-01f, -8.75243992e-02f, -1.66959152e-01f, 3.79671045e-02f, 1.93402782e-01f, -2.73813099e-01f, 1.25179008e-01f, 1.82457902e-02f, -1.98768198e-01f, 8.63690823e-02f,
  -3.22836548e-01f, 3.64376038e-01f, -2.97779262e-01f, 6.46486998e-01f, -3.66258025e-01f, -8.66941452e-01f, -8.49860191e-01f, -3.64176899e-01f, 2.07729489e-01f, -1.88347682e-01f,
  -4.61263031e-01f, -2.19305769e-01f, 5.30254170e-02f, -1.83362253e-02f, -2.84024626e-01f, 3.89867097e-01f, 7.27664709e-01f, 6.44007027e-02f, -6.63927138e-01f, -6.10202372e-01f,
  2.63550103e-01f, 5.18540800e-01f, 5.69430627e-02f, 6.52102157e-02f, 7.64281571e-01f, 2.86380380e-01f, 5.18426299e-01f, 3.80058646e-01f, 3.49185336e-03f, 9.69534636e-01f,
  -3.67038131e-01f, -2.69787610e-01f, -2.89551228e-01f, -1.73719246e-02f, -1.51208490e-01f, 3.05690058e-02f, -2.05737025e-01f, 2.18048796e-01f, -3.17116559e-01f, -7.75275799e-03f,
  -1.36921272e-01f, -1.60798848e-01f, -7.64260069e-02f, -2.13602200e-01f, -5.45199923e-02f, -4.80578661e-01f, 2.51933426e-01f, -2.82958537e-01f, -1.77133292e-01f, -4.06311989e-01f,
  1.80659033e-02f, -1.63233206e-01f, -7.00619817e-01f, -2.70105571e-01f, -3.91526341e-01f, -1.75874084e-01f, -4.60382134e-01f, -4.64994073e-01f, -5.98077714e-01f, 3.20894122e-01f,
  -5.40583953e-02f, -6.34747371e-02f, 1.06924683e-01f, 7.75522441e-02f, -4.66004051e-02f, -6.82910755e-02f, 2.27617055e-01f, 5.40892519e-02f, -3.75609472e-02f, -2.94340961e-02f,
  -6.56493232e-02f, -1.63078666e-01f, -4.71731238e-02f, -1.05995148e-01f, -4.56990190e-02f, 6.93017170e-02f, 1.45516694e-02f, 2.02569008e-01f, 1.37776494e-01f, 1.99007933e-04f,
  -1.32539704e-01f, -1.33641019e-01f, 1.08511820e-01f, -1.68903370e-03f, -1.31794080e-01f, 2.03831028e-02f, 3.06937099e-01f, 8.19358695e-03f, 1.65562034e-01f, -1.10618077e-01f,
  4.63993907e-01f, -2.47429818e-01f, 2.04968125e-01f, 1.84727401e-01f, 7.20702931e-02f, 2.56252065e-02f, 5.76842949e-03f, -5.58153577e-02f, -9.52689573e-02f, -1.67381346e-01f,
  -5.10003388e-01f, -3.13706845e-01f, 7.24490434e-02f, -3.21462043e-02f, -2.40168661e-01f, 3.12941335e-02f, 2.09933788e-01f, -4.43103118e-03f, 4.17408422e-02f, 2.36892551e-02f,
  3.40651453e-01f, -7.29916617e-02f, -3.80901277e-01f, -2.37251028e-01f, -7.63110816e-02f, -3.61606330e-01f, -2.80639559e-01f, -2.58475512e-01f, -4.63648856e-01f, -7.81107985e-04f,
  -1.18048489e-01f, -4.36822414e-01f, -1.08092844e+00f, -1.09888530e+00f, -7.15302646e-01f, 6.00286108e-03f, 3.88701797e-01f, -5.66887818e-02f, -4.61725324e-01f, -2.66479671e-01f,
  1.22570023e-02f, 2.33920023e-01f, -1.87164277e-01f, 2.12668344e-01f, 6.59144461e-01f, 3.94580252e-02f, -4.60953355e-01f, 8.46218839e-02f, 5.68265557e-01f, 5.70127368e-01f,
  2.55590767e-01f, -2.33318120e-01f, -1.10737525e-01f, -1.65215552e-01f, -7.18403816e-01f, -2.13151112e-01f, -8.86255026e-01f, -7.00069070e-01f, -1.09475873e-01f, -9.02109146e-01f,
  -1.29804596e-01f, -7.65008807e-01f, 8.78544822e-02f, 9.17656943e-02f, -2.30460092e-01f, 1.43010944e-01f, 1.38475476e-02f, -3.63374680e-01f, -1.14314750e-01f, -1.91240475e-01f,
  -4.95838195e-01f, 4.64838557e-03f, -2.56060123e-01f, -9.71458256e-02f, -2.34693021e-01f, -1.85878664e-01f, -2.09928632e-01f, -3.22401524e-01f, -1.62552088e-01f, -8.81167352e-02f,
  -1.95605252e-02f, -1.82976007e-01f, -2.75791496e-01f, -5.23584560e-02f, -1.77600905e-01f, -1.70792192e-01f, -7.46608675e-02f, -9.56894234e-02f, -2.03797430e-01f, -2.85610378e-01f,
  3.14937830e-02f, -8.53148028e-02f, 1.67947952e-02f, -2.03735158e-02f, 1.64352342e-01f, -1.04005389e-01f, -3.17385346e-02f, 1.94636419e-01f, 9.96693447e-02f, 1.00566447e-01f,
  -7.69964010e-02f, -8.51341039e-02f, -1.80980638e-02f, -2.22335681e-02f, -5.80573417e-02f, -1.67125642e-01f, 1.49565026e-01f, 2.10800394e-01f, -1.32686809e-01f, -9.50469449e-02f,
  7.51079945e-03f, 1.29189566e-01f, -1.06394693e-01f, 2.56780863e-01f, 1.25387400e-01f, 4.46316935e-02f, 1.15541872e-02f, 3.79055440e-01f, 1.02302849e-01f, 1.46016702e-01f,
  3.47472340e-01f, 2.29838476e-01f, -4.07216772e-02f, 1.54822156e-01f, -1.68017000e-01f, -2.08284289e-01f, -1.84107468e-01f, 1.00707009e-01f, -2.65162379e-01f, 1.33019447e-01f,
  -2.10763384e-02f, -1.39220466e-03f, -2.52672493e-01f, 1.65006742e-01f, 2.87859291e-01f, -2.44470127e-03f, 3.65311921e-01f, 6.73170313e-02f, 8.86529014e-02f, 3.04901681e-04f,
  1.68537393e-01f, 5.90026796e-01f, 6.02688551e-01f, 3.44393879e-01f, 1.11692242e-01f, 4.66421634e-01f, 2.65220672e-01f, 3.04048121e-01f, 5.39425313e-01f, 6.35956407e-01f,
  -1.27167118e+00f, 1.12580693e+00f, 3.28996390e-01f, -5.67485869e-01f, 5.35246670e-01f, 9.16785240e-01f, 1.31882334e+00f, 4.39831078e-01f, -4.63282138e-01f, 3.12799633e-01f,
  4.47634846e-01f, -5.29619038e-01f, -2.65094310e-01f, 3.57789919e-02f, 2.02990577e-01f, 8.26082528e-01f, 6.39083326e-01f, -2.86549360e-01f, -5.91141999e-01f, -1.44802421e-01f,
  1.62590563e-01f, -3.46305251e-01f, -8.55920911e-01f, -4.06325579e-01f, -1.71834715e-02f, -3.39001060e-01f, 8.62621963e-02f, -6.44794106e-02f, 6.07119143e-01f, 6.55574352e-02f,
  -2.82152027e-01f, -1.30046278e-01f, -2.37285003e-01f, -1.99274495e-01f, -1.22954145e-01f, -3.85995060e-01f, -4.79538552e-02f, -3.64950806e-01f, 1.03089146e-01f, -1.11741222e-01f,
  -3.38659100e-02f, -8.53806213e-02f, 1.77487254e-01f, 9.84088331e-02f, -8.24815184e-02f, -1.12642609e-02f, -2.13338718e-01f, -3.36084932e-01f, -8.80641714e-02f, 4.28910255e-02f,
  4.63359237e-01f, 9.13106836e-03f, 3.84449437e-02f, 3.26889455e-01f, 2.51148999e-01f, -3.81110579e-01f, 2.84087092e-01f, -2.18392104e-01f, 3.16035524e-02f, -6.23577774e-01f,
  -7.28998631e-02f, 7.00877905e-02f, 2.40736589e-01f, -1.87789023e-01f, 2.99635716e-02f, -5.19662397e-03f, -6.76418096e-02f, 8.82107839e-02f, 9.04412568e-02f, -1.84112549e-01f,
  4.03399803e-02f, -1.10355005e-01f, -2.29179412e-01f, -8.89472738e-02f, -1.13066502e-01f, 4.13189195e-02f, 1.68627128e-01f, 5.44203678e-03f, -1.45020417e-03f, 1.09231854e-02f,
  -1.79569423e-02f, 8.27308148e-02f, -2.14353755e-01f, -1.01549678e-01f, 1.84578095e-02f, -1.19883366e-01f, -2.89815784e-01f, -7.70565569e-02f, -2.07334295e-01f, -4.16077720e-03f,
  -5.85639298e-01f, 4.41785425e-01f, -5.35052955e-01f, 6.83886558e-02f, -4.06197794e-02f, 1.02444604e-01f, 1.30408746e-03f, 1.23772688e-01f, -8.34657624e-02f, -2.88653135e-01f,
  1.60491735e-01f, -2.03788444e-01f, 1.04570583e-01f, -4.00835089e-02f, -2.86277026e-01f, -1.32667854e-01f, 3.49687666e-01f, -2.03017384e-01f, 1.31318480e-01f, -1.26411170e-01f,
  9.85140055e-02f, -1.27864897e-01f, -5.72532058e-01f, -2.26166412e-01f, -2.97283918e-01f, -6.86347187e-01f, -1.29482850e-01f, -3.82659346e-01f, 1.11264177e-02f, -3.64234805e-01f,
  -1.24894202e+00f, -8.53071585e-02f, 9.97934163e-01f, -9.32452023e-01f, -2.24490482e-02f, -3.99435788e-01f, -9.19181645e-01f, -1.09316421e+00f, -5.98160744e-01f, -3.57569270e-02f,
  4.67290908e-01f, 5.89689851e-01f, 7.02674031e-01f, 3.59508157e-01f, -5.70596457e-01f, -2.77674361e-03f, 2.35163588e-02f, 6.73590004e-02f, -2.87239701e-01f, -6.80941939e-01f,
  -3.23152214e-01f, -4.81136620e-01f, -3.74107778e-01f, -1.95583120e-01f, 1.04369871e-01f, 3.00319642e-01f, 4.60197598e-01f, 4.41598669e-02f, 3.69411141e-01f, 6.19622529e-01f,
  7.36194134e-01f, -5.05053401e-01f, 8.18566754e-02f, -4.26893383e-02f, 2.49685869e-01f, -1.37656212e-01f, -1.59624174e-01f, 2.63712183e-02f, -5.70940115e-02f, -2.21117530e-02f,
  1.85810793e-02f, 4.95503806e-02f, -9.98876914e-02f, 3.11185420e-02f, -3.53069603e-01f, -5.36522269e-01f, -3.40417087e-01f, -4.82369244e-01f, -1.16468504e-01f, 9.36291516e-02f,
  1.14883244e-01f, -7.99506009e-02f, 4.07740444e-01f, -6.01509549e-02f, -1.03742324e-01f, 2.27958977e-01f, 8.46368521e-02f, -1.26505598e-01f, -8.01508129e-03f, -2.36319184e-01f,
  -7.69627318e-02f, 4.33146507e-01f, -3.06627201e-03f, -1.00774162e-01f, -1.09457962e-01f, 2.26791427e-01f, 1.60349280e-01f, -1.09295875e-01f, -1.16023868e-02f, 1.29106464e-02f,
  -3.24242195e-04f, -3.87884527e-02f, -2.23087490e-01f, -1.09069265e-01f, 1.93005323e-01f, -4.36863536e-03f, 1.29566357e-01f, -1.23464756e-01f, -9.62579325e-02f, -1.04807138e-01f,
  -1.74002978e-03f, 1.50946021e-01f, 1.77644834e-01f, -1.13540329e-01f, -2.27127671e-02f, -1.39243558e-01f, -5.01190275e-02f, 9.12652612e-02f, 1.73729528e-02f, 6.49411008e-02f,
  1.25696763e-01f, 2.49920905e-01f, 1.08802646e-01f, -3.07097584e-01f, -1.28920078e-01f, 6.85256794e-02f, 1.61735773e-01f, -1.30805522e-01f, 9.33011100e-02f, -8.59146863e-02f,
  3.03726066e-02f, -1.79424912e-01f, 7.72262663e-02f, 2.58709371e-01f, -2.21518531e-01f, 9.47448313e-02f, -2.23137155e-01f, 3.09013367e-01f, -2.07326617e-02f, -9.11406577e-02f,
  -3.50663811e-01f, -4.93477046e-01f, -1.95752978e-01f, 1.03745230e-01f, -2.29199126e-01f, -1.14625707e-01f, 3.12233984e-01f, 2.20208496e-01f, -1.08613901e-01f, -4.16609108e-01f,
  -1.00726926e+00f, -8.09107304e-01f, 1.51261138e-02f, -1.01731169e+00f, -2.99072891e-01f, -1.52334899e-01f, -9.91238236e-01f, -8.15846249e-02f, 1.05161034e-01f, -1.00972950e+00f,
  -1.90209374e-01f, 5.12888491e-01f, 4.11056466e-02f, 2.09327415e-01f, -1.62696004e-01f, -1.03767002e+00f, -7.87636340e-01f, 5.02133109e-02f, 6.76271200e-01f, 2.23359674e-01f,
  -5.98413229e-01f, -3.78281683e-01f, 8.73704404e-02f, 1.14667960e-01f, -7.12815881e-01f, -1.72244892e-01f, -5.28150320e-01f, -6.17489815e-01f, -3.59641463e-01f, -1.07781839e+00f,
  -7.50100672e-01f, 3.33282441e-01f, 4.45229709e-01f, 3.64957392e-01f, -2.36464843e-01f, -9.20811668e-02f, -3.53078023e-02f, 1.30937984e-02f, 5.57606295e-02f, -1.44032791e-01f,
  -1.39664903e-01f, 1.09342799e-01f, -1.28857911e-01f, 1.52025804e-01f, -1.41295016e-01f, 2.23082136e-02f, 7.96669126e-02f, 2.21349910e-01f, -6.50564581e-02f, -1.90408260e-01f,
  -3.98718268e-01f, -1.16535388e-01f, 1.68070421e-01f, 2.12207079e-01f, 2.18923911e-01f, 3.63903463e-01f, 1.30464062e-01f, 3.62490028e-01f, 4.56827641e-01f, -1.36233318e+00f,
  -8.87273476e-02f, -1.33210048e-01f, 2.15713717e-02f, 1.04492649e-01f, 1.41143205e-03f, 2.99270693e-02f, -1.53748661e-01f, -1.90032035e-01f, 1.07613161e-01f, -2.29003564e-01f,
  -7.43796234e-04f, 1.74844246e-02f, 1.82718262e-01f, -2.11951733e-01f, -9.25472304e-02f, -1.26974002e-01f, -6.08493686e-02f, -5.10783792e-02f, 4.84710187e-02f, -6.49366230e-02f,
  2.69325674e-02f, 3.86352427e-02f, 4.61439751e-02f, -9.72677022e-02f, 5.78704327e-02f, 2.02470589e-02f, 4.94515039e-02f, 3.18063527e-01f, -3.55248549e-03f, 1.14639252e-01f,
  -4.34795588e-01f, 7.04556525e-01f, -6.52572811e-01f, 2.22632840e-01f, -4.79263887e-02f, 1.23771735e-01f, -1.14156939e-01f, 9.41524431e-02f, 9.44281463e-03f, -1.90419078e-01f,
  1.98523760e-01f, -3.14279646e-01f, -1.29382595e-01f, 4.85601760e-02f, 9.09785330e-02f, 1.97803512e-01f, -2.61198938e-01f, -2.18217656e-01f, 1.34029299e-01f, -3.03262144e-01f,
  -2.29376391e-01f, -2.77698100e-01f, -4.71123397e-01f, -3.41493219e-01f, -1.33282676e-01f, -4.61240485e-02f, -1.87345937e-01f, -2.15498686e-01f, -4.31079268e-02f, -1.44031799e+00f,
  1.99237093e-01f, -1.76937550e-01f, -1.28533864e+00f, 3.49376649e-01f, 2.95756996e-01f, -3.61046225e-01f, -2.88068205e-01f, -9.75952223e-02f, 1.32145137e-01f, 5.32724485e-02f,
  4.73621607e-01f, 5.13027191e-01f, -5.20479620e-01f, -3.61082017e-01f, -1.26471531e+00f, -1.18685007e+00f, -1.12934446e+00f, -9.80507433e-01f, -4.75800902e-01f, 1.09133482e+00f,
  8.74341905e-01f, 2.53809154e-01f, -1.79172792e-02f, -9.69013348e-02f, 4.69968826e-01f, -1.13166124e-01f, -2.50980526e-01f, -1.08570615e-02f, -3.67224634e-01f, -3.57149959e-01f,
  -5.72664618e-01f, -4.26803619e-01f, -1.16453702e-02f, 1.80836514e-01f, -1.72986779e-02f, -2.20120877e-01f, -4.07171659e-02f, -9.58561450e-02f, -3.91470864e-02f, -1.00422740e-01f,
  2.08383873e-01f, 1.51536793e-01f, 1.76526397e-01f, -1.57560125e-01f, 5.73826991e-02f, -1.16580464e-01f, -2.14440897e-01f, -4.88772303e-01f, -5.73905349e-01f, -1.24847390e-01f,
  4.39561576e-01f, -9.65213701e-02f, -7.25448191e-01f, -2.79119879e-01f, -6.43816113e-01f, -1.00227334e-01f, 1.31110474e-01f, -1.55991748e-01f, -9.61038232e-01f, -9.74268690e-02f,
  6.93948045e-02f, 1.40455231e-01f, -1.92170620e-01f, -1.51483253e-01f, 4.05291259e-01f, 4.94551249e-02f, -1.56851664e-01f, 3.53125781e-02f, 1.64892882e-01f, -1.21566817e-01f,
  -1.72092859e-03f, -9.84806642e-02f, -9.67580751e-02f, -2.09649697e-01f, -6.11654185e-02f, -2.45840505e-01f, -9.03857872e-02f, -1.53642491e-01f, -8.91796201e-02f, -1.59886241e-01f,
  2.92859208e-02f, 6.28856719e-02f, 2.46845812e-01f, 1.06274113e-02f, -4.27225977e-01f, -4.37326282e-01f, -2.82308664e-02f, 1.13007531e-01f, 1.90898478e-01f, -2.76933014e-02f,
  2.77681082e-01f, -1.27039820e-01f, -1.70071349e-01f, -7.81044960e-02f, -1.70841128e-01f, 2.00480461e-01f, -5.43904006e-02f, -7.91180599e-03f, 1.97928458e-01f, 8.74977261e-02f,
  7.98614547e-02f, 4.72790338e-02f, 2.01545477e-01f, 2.54927784e-01f, 2.28851795e-01f, 1.71334296e-02f, 2.34848753e-01f, -3.67693275e-01f, -2.99154352e-02f, 3.83704841e-01f,
  4.75309528e-02f, -4.97950077e-01f, -4.06605184e-01f, -1.87943399e-01f, 1.62091494e-01f, -2.80754507e-01f, -3.29296559e-01f, -9.52898115e-02f, -7.83097446e-01f, -1.00367755e-01f,
  1.21577883e+00f, 4.73744929e-01f, -1.24761057e+00f, 7.27663994e-01f, -8.40986788e-01f, -8.78765881e-01f, -6.17724478e-01f, 3.30571860e-01f, 6.03757977e-01f, 1.06827527e-01f,
  1.01772852e-01f, 1.62765265e-01f, 4.01973337e-01f, -7.50689507e-02f, -1.43888593e-01f, -3.44352096e-01f, -5.87892830e-01f, -7.05253184e-01f, -9.70132887e-01f, -9.48102415e-01f,
  -4.96966183e-01f, -2.80664682e-01f, -2.40592003e-01f, -2.60900527e-01f, -1.59246445e-01f, -7.88393617e-02f, -1.00591429e-01f, -5.25752962e-01f, -7.23175883e-01f, -4.94262189e-01f,
  -9.50540662e-01f, 2.31370311e-02f, -9.69788805e-02f, 1.20711997e-01f, 2.92463209e-02f, 3.02126944e-01f, 8.96327347e-02f, 2.48958036e-01f, 3.90302360e-01f, 1.26463145e-01f,
  -8.91636610e-02f, -3.19792479e-02f, 1.10421143e-01f, -1.21795669e-01f, -1.28007784e-01f, -1.53105900e-01f, 1.20577417e-01f, 2.92435903e-02f, 9.47755948e-02f, 3.01100500e-02f,
  -1.06553376e-01f, -2.51175374e-01f, -9.66451913e-02f, 1.72128111e-01f, 1.06756963e-01f, 2.09454000e-02f, -1.83735833e-01f, -2.96263061e-02f, -9.00191441e-02f, 2.08920076e-01f,
  -8.16968083e-02f, 2.18074694e-01f, -7.43342713e-02f, -3.47643252e-03f, 1.76629052e-01f, 7.48558193e-02f, -5.54828420e-02f, -1.85078885e-02f, -7.81043991e-02f, 4.51471768e-02f,
  1.11921802e-01f, 6.12828359e-02f, -8.76834542e-02f, 8.09102729e-02f, -1.02988802e-01f, -9.89887342e-02f, 7.12671876e-02f, -5.91557287e-03f, -6.49176836e-02f, 3.51151377e-02f,
  6.46246411e-03f, -9.11070779e-02f, -5.73599041e-02f, -1.04510687e-01f, -1.12069964e-01f, 4.29239087e-02f, 2.15813406e-02f, -3.05799004e-02f, 8.27604439e-04f, 5.87202571e-02f,
  3.68154198e-01f, 5.79736121e-02f, 2.18323052e-01f, 1.31930739e-01f, -1.63359530e-02f, 2.95317471e-02f, 2.04117279e-02f, 9.25298184e-02f, 4.82111461e-02f, -5.83821461e-02f,
  -2.57653773e-01f, 1.86064467e-02f, 3.93963829e-02f, -1.16406955e-01f, -1.91797927e-01f, -1.70757785e-01f, 1.37268499e-01f, -9.68709886e-02f, -9.31674987e-02f, -6.06945604e-02f,
  1.30567893e-01f, 1.96640044e-01f, 2.49568194e-01f, 1.82737976e-01f, 6.69356436e-04f, 6.97540492e-02f, -1.55723795e-01f, -3.77275832e-02f, -1.40000395e-02f, 4.42487448e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.13459694e+00f, 1.32681942e+00f, 1.36675656e+00f, 2.95611113e-01f, 5.06414354e-01f, 7.45683491e-01f, 1.32627964e+00f, 1.35172606e+00f, 9.94438052e-01f, 4.63638514e-01f,
  1.07884109e+00f, 4.50230896e-01f, 5.60076177e-01f, 7.05152273e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  1.69354841e-01f, -1.70795307e-01f, -4.21168089e-01f, -1.06019807e+00f, -4.67628121e-01f, -6.46973193e-01f, -1.87524185e-01f, -8.35001528e-01f, -6.53619766e-01f, -8.42703760e-01f,
  2.78893858e-01f, -1.28120363e+00f, -1.15139556e+00f, 8.16642880e-01f, 7.83387959e-01f, -1.26612216e-01f, 1.12723991e-01f, 2.47735366e-01f, 4.60370600e-01f, -7.87059844e-01f,
  5.56826413e-01f, 3.23299766e-01f, -1.19914792e-01f, 4.67386156e-01f, -2.07690072e+00f, -1.77717471e+00f, 6.52797401e-01f, -8.61212015e-01f, -6.13195240e-01f, 7.11124480e-01f,
  -1.11757052e+00f, 5.83117962e-01f, 3.78837168e-01f, -5.15259564e-01f, 9.29646552e-01f, -1.40867960e+00f, -1.10553972e-01f, -1.02037454e+00f, 3.91893536e-01f, -1.00578797e+00f,
  -1.47824502e+00f, 8.35819364e-01f, -6.23255134e-01f, -6.64238870e-01f, 5.64410985e-01f, 8.38165998e-01f, -8.89546394e-01f, -6.29025877e-01f, -6.45298213e-02f, -1.12359285e+00f,
  -1.15221941e+00f, -5.68055511e-01f, -1.30062997e+00f, -7.29675472e-01f, -3.26603055e-01f, -9.97708738e-01f, 4.92407262e-01f, -1.22326338e+00f, 6.15150809e-01f, 1.42739379e+00f,
  3.58748853e-01f, 2.38593176e-01f, -3.10794204e-01f, -7.42694855e-01f, -2.51718253e-01f, 5.79232156e-01f, -7.21202135e-01f, -4.78967130e-02f, -1.03255045e+00f, 2.61673808e-01f,
  6.42170161e-02f, -1.02438807e+00f, 8.46247911e-01f, 4.69983548e-01f, -1.48456430e+00f, -7.32117236e-01f, 6.37053013e-01f, 1.18815310e-01f, 1.14292815e-01f, 4.02981043e-01f,
  -3.30233216e-01f, 5.55315554e-01f, -7.82418311e-01f, 6.66060925e-01f, 1.10972986e-01f, 4.02839988e-01f, -9.02454972e-01f, -4.64386940e-01f, -2.33678833e-01f, 4.58877832e-01f,
  3.55548143e-01f, -5.50663829e-01f, -1.51658583e+00f, -1.30148947e+00f, 4.70109344e-01f, 8.13405335e-01f, 2.67892987e-01f, -1.55653596e-01f, 9.42498028e-01f, 4.48086411e-01f,
  -1.23651814e+00f, 2.15413466e-01f, -1.51691675e+00f, 7.60844350e-01f, -1.34598494e+00f, 4.55353379e-01f, -4.43141341e-01f, -1.50736976e+00f, -5.64923108e-01f, -1.09137988e+00f,
  -1.64091027e+00f, -9.20661509e-01f, -3.65818113e-01f, 1.51694730e-01f, -1.17603612e+00f, -8.32379699e-01f, -4.72842813e-01f, 1.91503584e-01f, 2.62293547e-01f, -1.05470502e+00f,
  -7.65223086e-01f, 7.52359748e-01f, -8.39664340e-01f, 1.23379183e+00f, -4.25580293e-01f, -8.72499824e-01f, 1.30691692e-01f, -9.63510573e-01f, 1.49318919e-01f, 6.35811761e-02f,
  -7.84261227e-01f, 1.39894605e+00f, 7.67146528e-01f, -5.75064242e-01f, 7.79892325e-01f, -8.48273098e-01f, -1.26555502e+00f, -4.53528464e-01f, 1.39741480e-01f, -6.57282099e-02f,
  -6.42964959e-01f, -5.28222501e-01f, -1.06927633e+00f, -1.17557347e+00f, -1.53141484e-01f, 3.46460223e-01f, -5.38721979e-01f, -1.59110725e+00f, -1.06334507e+00f, -3.04298311e-01f,
  1.17382325e-01f, 8.39168847e-01f, -1.71427786e-01f, 7.68404245e-01f, -1.57053351e+00f, -7.48308301e-01f, 4.39212739e-01f, -1.25803316e+00f, 1.18904829e+00f, -1.42887831e-01f,
  -7.57039413e-02f, 4.32412386e-01f, -1.29026139e+00f, -9.25754368e-01f, 7.66510248e-01f, -5.23285449e-01f, -1.15593338e+00f, -3.62768650e-01f, 3.85033816e-01f, -4.78325337e-01f,
  6.40621185e-01f, -4.68887419e-01f, 1.26360965e+00f, -1.20411932e+00f, -8.44032943e-01f, -1.26977432e+00f, 8.05601012e-03f, -7.50542283e-01f, 3.63278270e-01f, 7.56312668e-01f,
  -5.03589094e-01f, -2.21547738e-01f, -3.69875818e-01f, 4.98495936e-01f, 1.14915156e+00f, -1.50600672e+00f, -1.37222135e+00f, 8.82647693e-01f, -1.05603683e+00f, -4.02602881e-01f,
  -6.05157316e-01f, -1.03060007e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  5.79284370e-01f, -6.34223819e-02f, 3.31641853e-01f, -8.90021086e-01f, -5.08655608e-01f, -2.10790306e-01f, -2.51381278e-01f, -3.42616946e-01f, -2.51751214e-01f, 1.71561971e-01f,
  -6.21184528e-01f, -7.28199542e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    