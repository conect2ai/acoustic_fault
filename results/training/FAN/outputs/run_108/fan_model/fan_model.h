/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.03786692e-03f, -2.89153010e-01f, -1.65599480e-01f, 1.88420132e-01f, 1.29246563e-01f, -4.09454405e-02f, -7.68721551e-02f, -1.46024048e-01f, -1.74430668e-01f, -1.33455962e-01f,
  5.20443991e-02f, -1.32909954e-01f, -9.96137038e-02f, 2.17378184e-01f, 1.79388225e-01f, 6.72489684e-03f, 6.42971843e-02f, 9.98501107e-03f, -2.15268508e-01f, -9.35925767e-02f,
  3.61527801e-02f, 2.13205740e-01f, 1.34578407e-01f, -1.03556208e-01f, -4.59941886e-02f, -3.31527323e-01f, 1.97449580e-01f, -1.61641538e-01f, 9.69787389e-02f, 8.84504691e-02f,
  5.60481064e-02f, -5.40385582e-02f, 2.83153988e-02f, -6.79768920e-02f, -1.40461978e-02f, 2.63244305e-02f, -1.17496764e-02f, 1.06484797e-02f, -1.92088798e-01f, -1.63146496e-01f,
  6.25213515e-03f, -6.40389174e-02f, -5.84655888e-02f, 1.12858593e-01f, 6.10459484e-02f, -5.45965359e-02f, 1.45587185e-03f, 7.92467073e-02f, 5.06753512e-02f, 1.26157135e-01f,
  1.26115112e-02f, 8.98102596e-02f, 5.36722913e-02f, 7.00933412e-02f, -9.92247090e-03f, -5.10549471e-02f, -2.68969852e-02f, 1.03763547e-02f, -2.14901008e-02f, 3.39011624e-02f,
  -3.28777395e-02f, 1.77590884e-02f, -1.13587022e-01f, 9.16829929e-02f, -3.07359193e-02f, -4.31779884e-02f, -1.01637214e-01f, -2.54286285e-02f, -1.25024557e-01f, 5.18516079e-02f,
  7.45260343e-02f, 8.77276734e-02f, 1.00494474e-01f, 3.20891142e-02f, 7.68038481e-02f, 1.52988821e-01f, -6.29941374e-02f, -6.34416379e-03f, -5.11436053e-02f, 3.80074955e-03f,
  6.72363564e-02f, 3.45698670e-02f, 1.03034489e-02f, 9.57759470e-02f, -1.27230808e-01f, -6.98134750e-02f, -2.08803117e-02f, -3.95073183e-02f, 2.00675856e-02f, 1.57623719e-02f,
  6.46573901e-02f, -5.01458161e-03f, -3.90580781e-02f, 9.57518891e-02f, -8.09169263e-02f, 6.73156558e-03f, -6.48646057e-02f, -1.99986622e-02f, -1.84425071e-01f, 6.39899895e-02f,
  3.26363184e-02f, -1.16202645e-02f, 2.29711849e-02f, 1.04655132e-01f, 2.84408871e-02f, 2.96570417e-02f, -3.43270935e-02f, -5.13334423e-02f, 1.42085239e-01f, 2.72897016e-02f,
  5.53514101e-02f, -1.34064078e-01f, -6.05637617e-02f, -3.06366328e-02f, 1.05737291e-01f, 2.67569814e-03f, -1.85330972e-01f, 5.56054972e-02f, -2.28961669e-02f, -5.15897833e-02f,
  -3.08727175e-01f, -2.37122341e-03f, 2.27752119e-01f, -3.31653059e-02f, -1.89297006e-01f, 8.82689953e-02f, 9.96493697e-02f, -2.01140642e-01f, -2.13016868e-01f, 3.01637687e-02f,
  -1.18932188e-01f, 1.31634563e-01f, -7.47071281e-02f, 7.26079047e-02f, -1.33795338e-02f, 4.74760309e-02f, -5.06506190e-02f, -7.97839984e-02f, -7.17316419e-02f, -1.59755945e-02f,
  -1.43735155e-01f, -3.12818326e-02f, 1.62881091e-01f, -1.83161035e-01f, -4.36583459e-02f, -2.91887484e-02f, -1.95861291e-02f, 8.63038078e-02f, 8.88697505e-02f, 6.57314062e-02f,
  -1.07720625e-02f, -1.15394212e-01f, 1.60405532e-01f, 1.08952805e-01f, -2.49174610e-02f, 6.31840155e-02f, 4.20847721e-02f, 1.06845498e-01f, 1.08371660e-01f, 5.56851970e-04f,
  -2.93121822e-02f, -7.68187791e-02f, -9.10742357e-02f, 1.16235502e-02f, -3.14789042e-02f, 7.67458528e-02f, 5.26221208e-02f, 8.27752277e-02f, -6.16355464e-02f, -8.74944925e-02f,
  4.35233414e-02f, -1.27707804e-02f, 8.81666616e-02f, -3.79182622e-02f, -3.22551057e-02f, -5.32741798e-03f, 9.55308378e-02f, 3.42228375e-02f, -1.87173020e-02f, 3.40591371e-02f,
  -1.19929060e-01f, -2.76269726e-02f, -2.44684704e-02f, 1.02636576e-01f, 3.91783267e-02f, -3.66141610e-02f, 6.25795275e-02f, 8.15171450e-02f, 2.20781609e-01f, 1.24351773e-02f,
  6.81263581e-02f, 4.05775383e-02f, 5.41697219e-02f, 1.81942116e-02f, -4.55509871e-02f, -8.31172317e-02f, 1.14903830e-01f, 4.76468615e-02f, 2.99996678e-02f, 8.02180078e-03f,
  -1.16920702e-01f, 1.58127308e-01f, 5.99797703e-02f, 8.54274035e-02f, -5.35748452e-02f, 6.08428232e-02f, -1.19595993e-02f, 7.04928264e-02f, 4.92005832e-02f, 4.06342708e-02f,
  -5.58889881e-02f, -1.50865063e-01f, 9.87133682e-02f, 1.72592346e-02f, 1.62528574e-01f, 1.24572136e-01f, -1.32348780e-02f, -2.26168670e-02f, 2.11917870e-02f, 9.06851329e-03f,
  -5.71747869e-02f, 3.28415670e-02f, 4.95280698e-02f, 7.75439367e-02f, 1.85163647e-01f, 5.85703366e-02f, -2.82843187e-02f, 1.47015914e-01f, -3.97005416e-02f, -8.41130167e-02f,
  -9.85310972e-02f, -1.01550348e-01f, 6.49462417e-02f, -9.81767848e-02f, -3.56779732e-02f, -1.55798504e-02f, -2.37050168e-02f, 7.70307481e-02f, 3.66471261e-02f, 1.35555882e-02f,
  -3.48469734e-01f, 2.89223850e-01f, 7.85777718e-02f, -1.68932587e-01f, -6.12535253e-02f, -8.43024477e-02f, -1.27458930e-01f, 9.27015543e-02f, -1.77638739e-01f, 2.29136944e-01f,
  -4.41589765e-02f, 1.05563506e-01f, 8.88992473e-02f, 4.01613256e-03f, -2.68994451e-01f, 2.17050072e-02f, -8.20186436e-02f, 5.11467718e-02f, -1.02862723e-01f, -1.10523226e-02f,
  -1.01316243e-01f, -7.95214400e-02f, 7.11563081e-02f, 2.86402944e-02f, 1.48403486e-02f, 3.54885235e-02f, 1.51729062e-01f, 1.31807476e-02f, 1.10247517e-02f, 9.86041427e-02f,
  1.24752671e-02f, 5.17976191e-03f, -1.72060654e-02f, -9.52040870e-03f, -9.44712106e-03f, 3.25601026e-02f, 6.42708838e-02f, 6.30268678e-02f, -6.80599660e-02f, 2.91618463e-02f,
  6.58487305e-02f, 9.38689522e-03f, -2.92077232e-02f, -1.02557836e-03f, -3.88390236e-02f, 5.90447616e-03f, -5.81008382e-03f, 1.86457336e-02f, 7.11215958e-02f, -2.75084246e-02f,
  6.88394308e-02f, 7.51524568e-02f, -7.39217028e-02f, 3.46919633e-02f, 9.03030951e-03f, -1.51772089e-02f, 3.41820903e-02f, 7.74301589e-02f, -1.43481670e-02f, 9.72800422e-03f,
  -2.96198912e-02f, -2.95151342e-02f, -9.07815769e-02f, 3.09380721e-02f, -1.02541395e-01f, -1.18787875e-02f, -3.68292294e-02f, 9.38320607e-02f, 1.95161067e-02f, 7.74856210e-02f,
  4.23268490e-02f, -5.66447154e-02f, -1.61941797e-02f, 1.28180003e-02f, -5.70766516e-02f, -3.67397745e-03f, 1.99773815e-02f, 8.24845508e-02f, -5.00706322e-02f, -5.10528237e-02f,
  9.18372050e-02f, -1.33079872e-03f, 3.90726589e-02f, 1.09499112e-01f, -6.30857721e-02f, 1.00361370e-01f, 2.11589877e-02f, -9.14925896e-03f, 1.56641100e-02f, -7.84503296e-02f,
  1.21722165e-02f, 2.14487508e-01f, 5.24411723e-02f, 3.57702784e-02f, 8.91105738e-04f, 1.53585905e-02f, 5.75297065e-02f, -1.36298491e-02f, 1.68073270e-02f, -3.03373137e-03f,
  5.00672832e-02f, 2.62433905e-02f, 7.43505061e-02f, 7.89236929e-03f, 5.96515834e-02f, 4.28858818e-03f, 7.03752413e-02f, 1.12364389e-01f, 7.47417286e-02f, 1.46733206e-02f,
  5.91730094e-03f, -2.98543591e-02f, -2.35158801e-02f, -5.73991202e-02f, 7.60315880e-02f, 9.25415456e-02f, 1.42492466e-02f, 4.61770520e-02f, 1.17557354e-01f, 5.98476753e-02f,
  -4.27128464e-01f, 2.06627429e-01f, -1.33012474e-01f, -1.02380358e-01f, 5.49197681e-02f, -2.31311336e-01f, -2.01372251e-01f, 1.83346242e-01f, -9.23173949e-02f, 1.27873495e-01f,
  2.25194413e-02f, -1.12784050e-01f, -6.05858921e-04f, -6.95182830e-02f, -2.70508260e-01f, -1.41143963e-01f, -1.19269416e-01f, -1.14239842e-01f, -5.28109521e-02f, -3.25336047e-02f,
  -2.70786211e-02f, 2.46380717e-02f, 7.58990720e-02f, 2.33388364e-01f, -3.63289453e-02f, 2.38603968e-02f, 2.27946475e-01f, 3.06937285e-02f, 7.47899041e-02f, -8.70243553e-03f,
  -6.04415797e-02f, 2.90861707e-02f, 2.93855760e-02f, 5.64324334e-02f, -3.37938108e-02f, 5.03768288e-02f, 7.23461853e-03f, -4.83903848e-03f, -7.85160437e-02f, -1.55822709e-02f,
  -4.15380485e-02f, -3.69431339e-02f, -5.78514375e-02f, 2.54018083e-02f, -1.71743352e-02f, -5.75929321e-02f, 3.93222179e-03f, 3.88038121e-02f, 5.45825474e-02f, -6.38783500e-02f,
  1.58467870e-02f, -4.72655669e-02f, -1.18105777e-01f, 4.29954287e-03f, -5.47070168e-02f, -8.22777525e-02f, -5.84319755e-02f, -2.70351041e-02f, -6.69391155e-02f, 6.01491937e-03f,
  8.63306969e-03f, -3.06463931e-02f, -6.15244992e-02f, 5.82531048e-03f, -1.58509299e-01f, -5.20037785e-02f, -1.12891532e-01f, 1.16177145e-02f, -4.41251285e-02f, -2.62772068e-02f,
  2.08856873e-02f, 7.01416507e-02f, 7.80628994e-02f, 1.00921638e-01f, 1.74088422e-02f, 6.49963766e-02f, 1.35282651e-02f, -3.88429388e-02f, -7.92237893e-02f, 2.38991994e-02f,
  2.97124661e-03f, 1.68985333e-02f, -4.99926247e-02f, 6.53176010e-02f, -6.55848682e-02f, 5.26771694e-02f, 4.67497073e-02f, -3.43945064e-02f, -7.89833069e-03f, -9.24986601e-02f,
  7.42772818e-02f, 1.11301526e-01f, 4.29027118e-02f, -3.26221250e-02f, -5.94359934e-02f, -5.32809226e-03f, -2.28415951e-02f, 2.31441706e-02f, -2.89700367e-03f, 1.10403992e-01f,
  5.56669123e-02f, -3.54271233e-02f, 1.47481542e-02f, -2.75234738e-03f, -3.74729000e-02f, -2.30051689e-02f, -5.79046719e-02f, 7.30706751e-02f, 4.42617722e-02f, 3.29733975e-02f,
  -2.32994054e-02f, -5.36246262e-02f, -1.16753727e-01f, -2.83374097e-02f, 2.50793938e-02f, 1.29345777e-02f, -5.61598651e-02f, 9.91765130e-03f, 4.52385433e-02f, 1.03830406e-02f,
  -1.84398308e-01f, 1.63122073e-01f, 2.04855070e-01f, 1.14766769e-01f, 2.95586549e-02f, -2.16724798e-01f, -1.25421241e-01f, 1.78077146e-01f, -1.18701324e-01f, 1.26689598e-01f,
  -1.35859922e-01f, 3.55651304e-02f, -2.02025026e-02f, -4.56524268e-03f, -3.24722737e-01f, -8.85596201e-02f, -6.83268383e-02f, -1.95689443e-02f, 4.17057276e-02f, 9.97601822e-02f,
  9.77939460e-03f, 9.49038006e-03f, 1.38284862e-01f, 2.17161223e-01f, 1.08533598e-01f, 2.09514335e-01f, 9.80723724e-02f, 1.27704695e-01f, 1.92866355e-01f, -1.35909736e-01f,
  -1.05408989e-01f, 4.93783783e-03f, 8.34971443e-02f, 5.68969063e-02f, -5.56857847e-02f, -4.09618579e-02f, -1.23787718e-02f, -2.85318168e-03f, -3.36590633e-02f, -1.00632139e-01f,
  -3.62443700e-02f, -7.77815282e-02f, 6.96920902e-02f, -5.73731959e-03f, 2.99611762e-02f, -2.38549244e-02f, 5.10011008e-03f, -9.88709629e-02f, 6.67985454e-02f, 6.11662902e-02f,
  4.30809259e-02f, 4.76357294e-03f, -2.73567252e-02f, 1.07543476e-01f, -1.14381481e-02f, -3.57289128e-02f, 1.17350340e-01f, -2.67241374e-02f, -5.91871440e-02f, -1.73424073e-02f,
  -4.17409129e-02f, 8.60373229e-02f, 5.23506850e-02f, 2.58737635e-02f, -1.39061958e-02f, 1.08410209e-01f, 4.32403013e-02f, 6.37762472e-02f, -4.68982421e-02f, -2.83934940e-02f,
  7.06998585e-03f, -4.93258126e-02f, -8.96947552e-03f, 1.39805228e-01f, 3.47195119e-02f, 3.65148187e-02f, -2.65859626e-02f, 3.34554352e-02f, 3.82766477e-03f, 6.56980872e-02f,
  2.19185688e-02f, -7.62115493e-02f, -3.18440348e-02f, -6.04936890e-02f, -1.94302108e-02f, 2.32348610e-02f, 6.78943470e-02f, 7.58724287e-02f, 4.25308682e-02f, -5.59798628e-02f,
  -1.31590083e-01f, 1.26165450e-01f, 1.23108877e-02f, -1.75857521e-03f, -1.33489743e-02f, -4.27201279e-02f, 1.56054981e-02f, 2.34149676e-02f, -2.01882962e-02f, -1.01392314e-01f,
  -4.34706658e-02f, 1.72058064e-02f, -3.38656679e-02f, -9.17975977e-02f, -7.25683197e-02f, -5.61526753e-02f, -6.85347542e-02f, -1.27507195e-01f, -2.92686801e-02f, -1.54894851e-02f,
  6.41544396e-03f, 2.98438258e-02f, -1.88463856e-03f, -4.67015132e-02f, 8.71197321e-03f, -4.92331944e-02f, -1.74297970e-02f, -1.19208228e-02f, 1.01475306e-01f, -5.71046211e-02f,
  -1.18412443e-01f, 3.85816574e-01f, -2.48725340e-01f, 2.41650850e-01f, -8.73678625e-02f, 1.43335313e-01f, 2.42381394e-01f, 1.77435592e-01f, 2.06916675e-01f, 3.60040694e-01f,
  1.25591934e-01f, -1.60487499e-02f, 7.36846104e-02f, 3.56032759e-01f, -1.27818674e-01f, 1.80633649e-01f, 3.09556365e-01f, 1.79589227e-01f, 9.16162133e-02f, 1.07113101e-01f,
  -1.89586990e-02f, 2.36078292e-01f, 3.99218872e-02f, 1.93577066e-01f, 1.54875010e-01f, 1.53269563e-02f, -6.56731427e-03f, -1.56388745e-01f, 2.36300364e-01f, -9.78371575e-02f,
  4.69081029e-02f, 3.73431295e-02f, 4.30512950e-02f, -6.46651685e-02f, -3.67311686e-02f, -6.14845641e-02f, 1.44221336e-02f, -1.40728787e-01f, -6.96610138e-02f, -5.99483736e-02f,
  -7.85247087e-02f, -3.30209658e-02f, 6.81833625e-02f, -2.99951620e-02f, 7.66252503e-02f, -6.55881967e-03f, 4.61446531e-02f, -1.48776313e-02f, 4.86802086e-02f, 7.19114393e-02f,
  -1.40886242e-02f, 4.46687452e-02f, -1.12914797e-02f, 8.08295459e-02f, 1.63270699e-04f, -5.13016107e-03f, 2.42116991e-02f, -1.31957263e-01f, -3.45841907e-02f, 8.20444599e-02f,
  3.98129188e-02f, 6.61290661e-02f, -2.29583983e-03f, -6.93668425e-02f, 3.64219025e-02f, 6.66629598e-02f, 1.25807136e-01f, 4.48556319e-02f, -7.65859634e-02f, -1.10075176e-02f,
  3.06159500e-02f, -2.39592362e-02f, -9.12552327e-03f, 6.60035759e-02f, 3.84717807e-02f, 5.10124154e-02f, -8.91487226e-02f, 5.35676219e-02f, 3.63175571e-02f, 3.30971117e-04f,
  5.24812900e-02f, -2.77851522e-02f, 7.46991038e-02f, -6.69718310e-02f, 6.73751608e-02f, -1.36688977e-01f, -3.18452134e-03f, -6.69525489e-02f, -6.14645239e-03f, -8.48212168e-02f,
  2.07964614e-01f, 2.35326022e-01f, 8.33102316e-03f, 5.07717468e-02f, 4.36476246e-02f, -1.25896245e-01f, 1.11069707e-02f, 9.93866697e-02f, 1.15990816e-02f, -7.50950351e-02f,
  -5.91162071e-02f, -7.29205608e-02f, -1.19926140e-01f, -4.74521704e-02f, 8.50709621e-03f, 3.64493765e-02f, 7.21982569e-02f, -6.26495928e-02f, -1.04295947e-01f, 3.96923311e-02f,
  7.82471672e-02f, -1.33540027e-03f, -3.01755611e-02f, 8.09522644e-02f, 9.28441286e-02f, -6.18876517e-03f, 3.67291225e-03f, -6.42378032e-02f, 3.64060663e-02f, 3.94223705e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.25489712e-01f, 3.71593088e-01f, 6.71290159e-02f, -1.01035230e-01f, -2.65880860e-02f, -1.11969754e-01f, -1.02530353e-01f, 1.80777580e-01f, 1.29861534e-01f, 1.80616409e-01f,
  -3.50469463e-02f, 1.52538225e-01f, 2.98737306e-02f, -1.07443340e-01f, -3.83422375e-01f, -2.63838887e-01f, -3.28170240e-01f, -9.68461931e-02f, -1.78666189e-01f, -2.26177252e-03f,
  -1.83368430e-01f, -2.61908859e-01f, -2.11566746e-01f, -1.88563801e-02f, 9.94830206e-02f, 2.11234942e-01f, -2.23073348e-01f, 5.98915368e-02f, -1.80262346e-02f, -4.48802812e-03f,
  6.19457774e-02f, 1.46873519e-01f, 1.86775699e-01f, 8.89250040e-02f, -8.06865096e-02f, -1.10529371e-01f, -7.88073707e-03f, 3.23030949e-02f, -1.13162838e-01f, 5.97872511e-02f,
  -4.51535638e-03f, -1.72448400e-02f, -7.62613863e-02f, 1.30561357e-02f, 8.75061154e-02f, 3.56820156e-03f, 5.96862398e-02f, 9.07476619e-02f, 1.65494502e-01f, -4.22466025e-02f,
  1.82802288e-03f, 2.83395275e-02f, -9.72575471e-02f, -5.48177250e-02f, -6.29393086e-02f, 2.74630580e-02f, -1.54224753e-01f, 3.06653101e-02f, 2.39030272e-02f, -8.81102160e-02f,
  -1.03487693e-01f, -1.80254012e-01f, -8.03871453e-02f, 4.72303964e-02f, -7.61968270e-02f, -3.44571322e-02f, -6.99424893e-02f, -6.75980002e-04f, -3.05255298e-02f, 1.40067590e-02f,
  4.65940274e-02f, 4.62518558e-02f, -1.46707678e-02f, -8.16870248e-04f, -7.86098614e-02f, -3.40425819e-02f, -2.47117803e-02f, 9.12075862e-02f, -1.23569369e-01f, 7.31863361e-03f,
  7.98070356e-02f, -2.12877896e-02f, 3.51418145e-02f, -3.48014645e-02f, -1.04553349e-01f, -3.57030667e-02f, -5.45379110e-02f, 4.72604670e-02f, 5.97583987e-02f, -1.11440413e-01f,
  4.20700153e-03f, -1.38665522e-02f, 4.54882644e-02f, 1.29015565e-01f, -4.81071975e-03f, 1.33774355e-02f, -7.10700378e-02f, 5.46496101e-02f, -1.23452274e-02f, 4.23301347e-02f,
  3.44755203e-02f, -2.31774617e-02f, 1.50011182e-02f, 1.23322289e-02f, 2.77574509e-02f, -1.39811486e-01f, -1.29990056e-01f, 1.28422556e-02f, 7.89397433e-02f, 8.21396038e-02f,
  3.25550176e-02f, -7.37640113e-02f, -7.14410171e-02f, -1.56458706e-01f, 8.22813064e-02f, 8.54321718e-02f, -6.35875091e-02f, 1.28184855e-01f, -5.28816991e-02f, -1.33414581e-01f,
  -2.34106407e-01f, -1.62117973e-01f, 4.56517376e-02f, 2.10774258e-01f, 1.95406936e-02f, -2.22361982e-01f, -2.05434591e-01f, -8.46942794e-03f, -1.46707967e-01f, -2.23223358e-01f,
  -1.08330615e-01f, -8.12981464e-03f, -2.09932685e-01f, 9.65132006e-03f, 1.29468814e-01f, -2.49688655e-01f, 9.90944728e-02f, 5.25112823e-02f, -8.05520788e-02f, 6.27079755e-02f,
  1.08664230e-01f, 1.26434326e-01f, 2.58736342e-01f, 2.42431983e-01f, 2.37996727e-02f, 2.19529122e-01f, 4.11628515e-01f, 2.40223289e-01f, 3.86766911e-01f, 1.62218228e-01f,
  -1.33848011e-01f, -1.19621553e-01f, -2.56266166e-02f, 2.29788609e-02f, 3.59117873e-02f, -6.51049335e-03f, 1.11730061e-01f, 7.23426342e-02f, -1.61436386e-02f, 4.15849164e-02f,
  1.47358784e-02f, 6.59991354e-02f, -5.62565252e-02f, 5.50532676e-02f, -8.33498128e-03f, 1.31502179e-02f, 1.82182454e-02f, 2.47525070e-02f, 1.20632281e-03f, -9.45635587e-02f,
  -3.25912610e-02f, -3.97312865e-02f, -5.16737178e-02f, 5.15136495e-02f, -4.42981124e-02f, -4.65858169e-03f, 6.65947348e-02f, 7.57673532e-02f, -3.51956710e-02f, 9.35649872e-03f,
  -1.09807260e-01f, 1.05553903e-01f, 6.17212988e-03f, -2.51127072e-02f, 3.47265378e-02f, 9.40818246e-03f, -3.81406769e-02f, 4.62803664e-03f, 8.75395834e-02f, 1.54441511e-02f,
  9.12418067e-02f, 4.40362953e-02f, -2.32241582e-02f, 9.37070400e-02f, 8.95862207e-02f, -5.81193715e-02f, 9.72033441e-02f, 6.34810850e-02f, -2.70558652e-02f, -1.97495483e-02f,
  -1.19766422e-01f, 1.07718483e-01f, 6.96099252e-02f, -2.79068053e-02f, -1.22902252e-01f, 3.11845634e-02f, -7.60417804e-03f, 3.56564857e-02f, 6.81485906e-02f, 8.44780207e-02f,
  2.22779047e-02f, 9.16618779e-02f, -3.79382446e-02f, 7.31546134e-02f, -4.35601324e-02f, -2.20186803e-02f, -2.74591558e-02f, -3.84070762e-02f, -1.28208064e-02f, -5.06037800e-03f,
  8.02198797e-02f, 9.94268060e-02f, 2.08330192e-02f, 4.72341850e-02f, 1.11392252e-01f, -4.23211083e-02f, 2.60779029e-03f, 1.02618195e-01f, 1.32256493e-01f, 2.45236736e-02f,
  4.27776948e-02f, -8.15817118e-02f, -5.01253568e-02f, 4.19569714e-03f, -4.41029668e-03f, -5.08355312e-02f, -1.03581853e-01f, -6.98476806e-02f, -3.22166830e-02f, -8.45562108e-03f,
  1.66552559e-01f, 1.01702511e-01f, 1.10497758e-01f, 4.89128754e-02f, -2.43012309e-01f, 9.69137922e-02f, 2.95927413e-02f, -5.17788269e-02f, 2.37797812e-01f, 1.05852783e-01f,
  -2.06462979e-01f, 3.15194517e-01f, -7.26820752e-02f, -7.54443184e-02f, 5.93047626e-02f, 1.80847213e-01f, -1.58476818e-03f, 9.64562893e-02f, 4.90795188e-02f, 6.79333359e-02f,
  1.22716296e-02f, -1.52595937e-01f, -1.60521448e-01f, -1.72146097e-01f, -1.80537626e-01f, 4.93702069e-02f, -1.98024198e-01f, -1.42858967e-01f, -2.91702338e-02f, -4.59510125e-02f,
  -9.21005011e-02f, -5.50660416e-02f, -1.30173182e-02f, 4.33248580e-02f, -1.36718461e-02f, 5.29202856e-02f, -8.41757376e-03f, 7.03262985e-02f, -6.76442012e-02f, 8.14157650e-02f,
  1.49145305e-01f, 2.72351466e-02f, 8.67208019e-02f, 1.30597046e-02f, -6.38138410e-03f, 6.68739602e-02f, -4.38739872e-03f, -1.09556094e-01f, 1.75557286e-02f, 3.52279171e-02f,
  -2.02660449e-02f, -3.37220952e-02f, -3.92146669e-02f, 5.26660271e-02f, 1.96476188e-02f, -7.48819262e-02f, 1.24614194e-01f, -1.40455859e-02f, -1.90643314e-02f, 8.41968730e-02f,
  3.26304622e-02f, 1.46925962e-02f, -1.28915044e-03f, -1.12950645e-01f, -5.55865988e-02f, -7.11419899e-03f, 6.81327209e-02f, -3.35969366e-02f, -1.50819942e-01f, -1.37164444e-01f,
  -9.66695771e-02f, -9.74757373e-02f, -3.86322998e-02f, -2.67265756e-02f, -7.45358989e-02f, 2.76258960e-02f, -2.48737130e-02f, 3.95844784e-03f, -5.12707159e-02f, -3.41313779e-02f,
  5.97098656e-02f, 2.18218546e-02f, 1.56210009e-02f, -2.28561717e-03f, -5.15442155e-02f, -8.04532319e-02f, 5.18975593e-02f, 2.96869315e-02f, 4.84812865e-03f, -5.59445657e-02f,
  -7.41277784e-02f, 1.20213859e-01f, 3.95201556e-02f, 6.37556950e-04f, 7.87426829e-02f, -6.61550164e-02f, 7.51072094e-02f, 1.13722615e-01f, 2.29437854e-02f, 8.06232076e-03f,
  8.59724656e-02f, -6.73600733e-02f, -3.35203893e-02f, -9.01878253e-02f, -4.31753026e-04f, -9.84390173e-03f, 5.48325852e-02f, 1.23864152e-01f, -5.90314269e-02f, 2.26412937e-02f,
  -8.44942406e-03f, 3.27915847e-02f, -1.73766352e-02f, -2.90203672e-02f, -3.86950374e-02f, -3.87221016e-02f, 1.05636910e-01f, -7.61348531e-02f, -3.52033004e-02f, 1.22496165e-01f,
  -2.87705902e-02f, 1.86862409e-01f, 1.53842401e-02f, -2.50984013e-01f, -1.16863482e-01f, 2.56221563e-01f, 1.62691519e-01f, -1.39692396e-01f, -2.59019375e-01f, 1.03643619e-01f,
  -5.48001332e-03f, -9.79710743e-02f, 1.35862783e-01f, 8.11552182e-02f, 2.38061827e-02f, 2.71156073e-01f, 1.73522025e-01f, 3.84194888e-02f, 6.08352087e-02f, -7.98894837e-02f,
  6.43859208e-02f, 3.79946530e-02f, 2.24650219e-01f, 1.24878272e-01f, 6.92137051e-03f, -8.93610120e-02f, -1.30768210e-01f, -9.39648896e-02f, -1.25443665e-02f, -2.23700050e-02f,
  9.18845236e-02f, -1.19219221e-01f, 9.70292464e-02f, 2.00996473e-02f, 6.94577098e-02f, 7.62864016e-03f, 8.39149877e-02f, 1.40858740e-01f, -1.13953933e-01f, -4.54690568e-02f,
  -5.08376956e-02f, -2.30577681e-02f, 9.93221030e-02f, -1.63294524e-01f, -3.26242149e-01f, -1.15205392e-01f, 7.24822748e-03f, -5.01917973e-02f, 2.62954123e-02f, 6.66337535e-02f,
  -5.35753779e-02f, 6.26394339e-03f, -1.00994982e-01f, -4.17524651e-02f, -1.96481794e-02f, 1.93842780e-02f, 3.84522118e-02f, -8.92138854e-02f, 3.12845153e-03f, 2.55095401e-05f,
  -1.06489239e-02f, -6.38437793e-02f, 1.73068449e-01f, -1.13004319e-01f, 1.00454986e-02f, -2.69555207e-03f, -2.81100832e-02f, -5.64149842e-02f, -1.15724549e-01f, 6.00334145e-02f,
  -9.94826946e-03f, -1.06024489e-01f, 1.80533305e-02f, 7.24968538e-02f, -3.17686819e-03f, 1.56450681e-02f, 3.05519048e-02f, -3.07337753e-02f, 1.94623712e-02f, 2.58898698e-02f,
  -1.04042543e-02f, -1.23332692e-02f, -7.29170814e-02f, -7.47435018e-02f, 3.19592915e-02f, -1.32382482e-01f, 6.11952245e-02f, 2.51825433e-02f, 1.31940916e-01f, -3.94105949e-02f,
  -1.73033103e-02f, -2.82664038e-02f, 5.61686009e-02f, 8.54698718e-02f, 8.17159638e-02f, -6.89617395e-02f, 4.45180126e-02f, 1.02197573e-01f, -9.63014923e-03f, -5.68374107e-03f,
  -7.03603402e-02f, -1.00783437e-01f, 1.84831619e-02f, -1.24143593e-01f, -2.74108469e-01f, 5.61207123e-02f, 1.10059179e-01f, -1.06035821e-01f, -1.41606867e-01f, -4.95135672e-02f,
  7.65107721e-02f, 7.39496276e-02f, -2.05945428e-02f, 2.01269779e-02f, -1.40444875e-01f, 1.74666513e-02f, 9.12580546e-03f, -5.19570187e-02f, -2.62178946e-02f, -2.22798493e-02f,
  -2.22119600e-01f, -3.47691268e-01f, 1.33701414e-01f, -2.27756605e-01f, -3.38218398e-02f, 7.28329644e-02f, 1.32540479e-01f, -2.58240253e-01f, -3.36507171e-01f, -3.10402274e-01f,
  -2.08778549e-02f, 6.35943040e-02f, 2.38683715e-01f, -2.14700341e-01f, 3.53377312e-01f, 3.02324921e-01f, -4.13136333e-02f, 4.20902818e-02f, 1.37453489e-02f, -9.74816531e-02f,
  9.05076787e-02f, -3.17701348e-03f, 3.13613117e-01f, -1.11536130e-01f, -1.74425930e-01f, -1.55313060e-01f, 1.07063025e-01f, 3.09736252e-01f, -1.10684730e-01f, -2.71620601e-03f,
  -1.48053080e-01f, -2.29395464e-01f, -1.83487181e-02f, 1.32261105e-02f, -6.39380217e-02f, 4.62167114e-02f, 1.61750972e-01f, 2.67235309e-01f, -2.74962094e-02f, -1.86043617e-04f,
  6.93797842e-02f, -5.77448197e-02f, -1.63166985e-01f, 1.26460409e-02f, -9.78589505e-02f, -7.76040256e-02f, -4.28885035e-02f, 4.86824522e-03f, 1.35932388e-02f, 5.83039410e-02f,
  9.25774202e-02f, -3.86575703e-03f, 3.67645286e-02f, 4.60624881e-02f, 8.90503302e-02f, -1.02574669e-01f, 1.43566236e-01f, 2.31785715e-01f, 3.85339521e-02f, -4.77752127e-02f,
  2.69873906e-02f, 8.78708065e-02f, -5.13389148e-02f, -1.11484535e-01f, 3.41653302e-02f, -5.57082221e-02f, 8.82211253e-02f, 1.23703316e-01f, -6.45103445e-03f, -1.81231737e-01f,
  -1.25848845e-01f, 1.07375272e-02f, -6.87393323e-02f, -1.38717338e-01f, -8.42617378e-02f, -1.01887666e-01f, 2.34669149e-02f, 3.35326344e-02f, -9.16692093e-02f, 6.29275516e-02f,
  -4.42965738e-02f, -4.55657616e-02f, 1.90016930e-04f, 7.12568462e-02f, 8.61754939e-02f, 1.30308330e-01f, -3.74741666e-02f, -3.13898623e-02f, -2.08734423e-02f, 6.67668208e-02f,
  -2.01693624e-01f, -2.44694486e-01f, -4.61404845e-02f, -7.43566230e-02f, 3.32177430e-02f, -3.70735265e-02f, -6.85325414e-02f, -6.14488386e-02f, -1.94838792e-02f, -8.30391645e-02f,
  -1.42029673e-01f, 4.44216803e-02f, 7.93044269e-03f, -6.63943682e-03f, 3.09874509e-02f, -6.43440560e-02f, 4.27634120e-02f, -4.40914184e-02f, -2.09033545e-02f, -9.39553156e-02f,
  -4.78487723e-02f, -1.25909606e-02f, 6.60947710e-02f, 3.74655426e-02f, 1.10916093e-01f, -1.11139290e-01f, 2.75621265e-02f, -1.22280240e-01f, 1.50306243e-02f, -7.12771490e-02f,
  1.55587971e-01f, 1.10455200e-01f, 1.59237146e-01f, 3.10867190e-01f, 2.28671998e-01f, 1.08610906e-01f, 2.57385164e-01f, 3.02544355e-01f, 5.86510718e-01f, -3.17449868e-01f,
  -5.57287820e-02f, -1.38378009e-01f, -7.14093745e-02f, 2.52769608e-02f, -6.92541227e-02f, 1.43164650e-01f, 2.17194274e-01f, 2.14150906e-01f, 4.54252809e-01f, 5.35044372e-02f,
  2.05908909e-01f, -1.16126038e-01f, -2.34076511e-02f, 2.11946629e-02f, 1.17595054e-01f, -1.24801677e-02f, -1.79398268e-01f, 1.55331194e-01f, -1.14744402e-01f, -1.56359300e-02f,
  6.64141700e-02f, 1.11618467e-01f, -4.84284870e-02f, -5.94216846e-02f, 3.92236747e-02f, -1.71938110e-02f, -6.22109212e-02f, -7.29104504e-02f, 8.66236314e-02f, -7.82071203e-02f,
  -1.14252992e-01f, -1.27719343e-01f, 5.67405894e-02f, -5.96330427e-02f, 7.67738745e-02f, -7.05280155e-02f, 5.91554120e-02f, 7.48059899e-02f, -6.26499578e-02f, 6.24722578e-02f,
  6.48535341e-02f, 5.14331609e-02f, -1.85930508e-03f, -1.24466330e-01f, -1.55543257e-02f, -1.00073498e-02f, 1.40178939e-02f, -1.15476958e-01f, -1.05224080e-01f, -2.78194947e-03f,
  1.16524622e-01f, 5.93627356e-02f, -3.93388420e-02f, -5.61545417e-02f, -1.44347399e-02f, 6.39818236e-03f, 3.05204242e-02f, -8.67201611e-02f, -1.53859137e-02f, -1.04800172e-01f,
  -9.26598087e-02f, -6.26887605e-02f, 7.39657581e-02f, 6.71945661e-02f, -3.03670838e-02f, 3.81463990e-02f, -1.20140143e-01f, -1.40241191e-01f, 1.75043941e-02f, 6.52237236e-02f,
  5.68052717e-02f, -3.87593322e-02f, 1.34704774e-02f, -7.80354487e-03f, 4.94787097e-02f, -4.70713265e-02f, -7.33666942e-02f, -6.73288777e-02f, 1.26627773e-01f, -9.92427990e-02f,
  5.93244135e-02f, 2.25065485e-01f, 6.12399988e-02f, -1.67781860e-01f, 2.88650617e-02f, -1.20742835e-01f, 3.14155519e-02f, -3.39328535e-02f, 2.13392779e-01f, -7.00769201e-02f,
  -3.75443138e-02f, -1.37449756e-01f, -5.94340004e-02f, -1.04508929e-01f, -1.33100256e-01f, -5.38021438e-02f, -4.38030288e-02f, 8.00027475e-02f, -2.20208596e-02f, -4.29475643e-02f,
  6.27346709e-02f, -1.97862647e-03f, -1.49914742e-01f, -6.90580308e-02f, -9.87622589e-02f, -1.10372074e-01f, 8.95860344e-02f, -1.25978217e-02f, 1.42066218e-02f, 8.60318542e-02f,
  -7.34763891e-02f, 1.00182548e-01f, -1.79383278e-01f, -1.39045000e-01f, 1.23809233e-01f, -2.76765823e-01f, -9.02797133e-02f, 3.27929817e-02f, 6.55096099e-02f, 1.70629352e-01f,
  -1.31183222e-01f, 2.44014859e-02f, 4.16968241e-02f, -3.32904100e-01f, -4.38912779e-01f, -1.90773323e-01f, -3.31876665e-01f, -1.58061177e-01f, 1.81947872e-02f, -8.76145139e-02f,
  -9.73214395e-03f, -1.50780072e-02f, -3.59522179e-02f, 3.04100901e-01f, 1.09765135e-01f, 2.36887112e-01f, 2.45614886e-01f, 1.77315831e-01f, -1.43862590e-02f, 9.28812474e-02f,
  -1.37272611e-01f, -2.40414571e-02f, 3.30681838e-02f, -1.01839565e-01f, -2.72195823e-02f, 3.87503579e-02f, -2.04208568e-02f, 1.00689381e-02f, -4.93982956e-02f, -1.48191884e-01f,
  2.06124894e-02f, -3.93442288e-02f, -1.58320423e-02f, 4.93958108e-02f, 3.49167660e-02f, -6.63000792e-02f, -8.00567642e-02f, -1.30599206e-02f, -1.44534305e-01f, -9.16287526e-02f,
  -2.00107880e-02f, -8.41710716e-02f, -2.43344344e-02f, 7.09821507e-02f, 8.70235078e-03f, -2.70964541e-02f, 8.84131715e-03f, -8.85597430e-03f, -5.95310815e-02f, 1.81861036e-02f,
  6.63205534e-02f, 5.62761463e-02f, -4.10463959e-02f, 4.59920578e-02f, -7.21846968e-02f, 4.70843837e-02f, 4.82474528e-02f, 2.40383539e-02f, 9.71571263e-03f, -3.35237570e-03f,
  2.97355764e-02f, -4.73457575e-03f, 8.04768875e-03f, -1.22732548e-02f, -6.67118058e-02f, 5.69810271e-02f, -7.14558829e-03f, 3.14543657e-02f, -1.98341049e-02f, -1.35660656e-02f,
  -3.51227112e-02f, -4.56634313e-02f, 4.27333005e-02f, 2.24586464e-02f, -6.78742304e-02f, 6.10871892e-03f, -3.55569385e-02f, -1.25367939e-01f, -1.15697216e-02f, 6.03392683e-02f,
  -5.61245196e-02f, 3.11066937e-02f, 2.33679153e-02f, -1.92684345e-02f, 1.49594191e-02f, -6.53536990e-02f, -8.87461007e-02f, 5.17084375e-02f, -1.00082107e-01f, 1.41159948e-02f,
  4.50206585e-02f, 4.54585664e-02f, 1.20943293e-01f, -9.09060389e-02f, 6.87776580e-02f, -5.90840504e-02f, -3.86993513e-02f, 6.82297796e-02f, 3.58694158e-02f, -6.33615442e-03f,
  6.67258352e-02f, 8.52115918e-03f, -1.10318223e-02f, -1.88159232e-03f, 6.61247447e-02f, 4.74100597e-02f, 6.55534267e-02f, -2.68520042e-02f, -1.83816776e-02f, -1.20287836e-02f,
  2.26508096e-01f, -2.05134172e-02f, -2.17874289e-01f, -6.35824651e-02f, 9.23889354e-02f, 1.80567861e-01f, 1.08544812e-01f, -6.69220984e-02f, -9.64209884e-02f, 1.38126895e-01f,
  1.36047050e-01f, -2.99178716e-02f, -6.69912249e-02f, 2.62571275e-01f, 6.71289936e-02f, -8.69521350e-02f, 2.11007386e-01f, 1.34119928e-01f, -4.35460098e-02f, 8.57396796e-02f,
  -1.71831213e-02f, 3.25881839e-01f, -1.48749381e-01f, 1.84015676e-01f, 1.82540461e-01f, -1.46738797e-01f, -6.75613582e-02f, -1.39040843e-01f, 5.49521744e-02f, 1.56954825e-01f,
  6.71559647e-02f, 3.89510430e-02f, -6.59926236e-02f, -1.83459129e-02f, 1.58004873e-02f, 1.59990564e-01f, 4.48072422e-03f, -3.88259478e-02f, -4.86013815e-02f, -5.51189706e-02f,
  3.21511738e-02f, 5.89846773e-03f, 6.03510141e-02f, -8.73630270e-02f, 6.62337542e-02f, -1.82388518e-02f, -1.11226320e-01f, -6.46645427e-02f, -5.63486852e-02f, 1.05461285e-01f,
  -3.65784541e-02f, 6.88072992e-03f, -4.23182994e-02f, -1.97914392e-02f, -2.20837481e-02f, 1.89370420e-02f, -2.42289752e-02f, -1.25469461e-01f, -1.35308623e-01f, 4.35654372e-02f,
  7.73323327e-02f, 8.79266560e-02f, 5.93378693e-02f, -1.19122490e-01f, 4.32719029e-02f, -7.75849726e-03f, -7.39171542e-03f, -2.08511930e-02f, -1.22787289e-01f, 4.33112821e-03f,
  -5.03582284e-02f, 2.12586708e-02f, 2.22855937e-02f, 2.67734900e-02f, 1.21052645e-01f, 1.03632419e-03f, -3.66811566e-02f, -2.72952914e-02f, -3.35690007e-02f, -1.35406747e-01f,
  1.06076807e-01f, 5.23101799e-02f, 4.38136142e-03f, -4.69208285e-02f, 9.69612598e-03f, 5.13307527e-02f, 1.36798158e-01f, 5.02900630e-02f, -1.39586553e-01f, -2.03964803e-02f,
  -1.85917094e-02f, -3.61615308e-02f, -1.38726942e-02f, -8.68269503e-02f, -6.38796389e-02f, 1.45347610e-01f, 8.79981965e-02f, -3.68070416e-02f, 1.36149197e-03f, 2.03018170e-02f,
  4.45763282e-02f, -1.32669985e-01f, -4.73291650e-02f, -2.14158352e-02f, -1.43073454e-01f, 7.57503808e-02f, 2.35912818e-02f, -1.33858457e-01f, -4.50324900e-02f, -5.11516333e-02f,
  2.97491532e-02f, 4.22366746e-02f, 2.00069975e-02f, -5.51087782e-02f, -6.77177459e-02f, -6.75921701e-03f, 1.08095342e-02f, -1.72778852e-02f, 1.42082367e-02f, -1.04824185e-01f,
  1.92936897e-01f, -1.91599950e-01f, -9.92024988e-02f, 2.07371637e-01f, 1.86191022e-01f, -7.30173988e-03f, 3.56243365e-02f, 1.42633505e-02f, -1.02034517e-01f, -1.20088100e-01f,
  1.61219686e-01f, 7.05698133e-02f, -1.36775047e-01f, 2.36414164e-01f, 3.33270311e-01f, -1.64768234e-01f, 2.26125270e-01f, 1.17280573e-01f, 4.90231141e-02f, 3.83206923e-03f,
  5.47410734e-02f, 2.90911287e-01f, 9.11849663e-02f, 1.03623956e-01f, 9.25424024e-02f, -4.70270440e-02f, 4.69556302e-02f, -1.89886428e-02f, 1.62081495e-01f, 1.44892350e-01f,
  1.16579952e-02f, 9.12436470e-03f, 6.21188655e-02f, 3.19607630e-02f, 2.61563458e-03f, 1.34097356e-02f, 1.82803959e-01f, 7.33192042e-02f, 5.19495420e-02f, -1.11751653e-01f,
  -2.23551653e-02f, 7.45019913e-02f, 4.48961854e-02f, -3.06628607e-02f, -4.41136397e-02f, 3.85280401e-02f, -6.45263633e-03f, -3.46517004e-02f, -3.50986458e-02f, -3.01966369e-02f,
  -8.13470334e-02f, -1.16115414e-01f, -1.80533770e-02f, 4.00673300e-02f, 6.45391643e-02f, -8.67756009e-02f, -4.64731231e-02f, -4.80194427e-02f, -8.15837085e-02f, 6.08942024e-02f,
  -6.80587720e-03f, -3.77939194e-02f, -6.16998114e-02f, -3.15172225e-02f, -1.85439587e-02f, 5.85539080e-02f, -9.58899036e-02f, 2.61138706e-03f, -6.95316344e-02f, 1.57440472e-02f,
  -1.13934584e-01f, -6.90464675e-02f, 2.35918388e-02f, 5.16744256e-02f, 2.09218152e-02f, -2.80874521e-02f, -9.77106914e-02f, 4.20951992e-02f, -6.73945947e-03f, 1.96506456e-02f,
  7.02440590e-02f, -3.12772840e-02f, -8.02639313e-03f, -1.28808692e-01f, 4.43145521e-02f, 5.71477180e-03f, 1.16842641e-02f, 4.52582492e-03f, -6.52912110e-02f, -7.06434920e-02f,
  -1.59626193e-02f, -2.83930618e-02f, -2.03215871e-02f, -1.09554101e-02f, -3.02469544e-03f, 4.72367788e-03f, 1.04099840e-01f, 3.05475183e-02f, 6.72443807e-02f, -8.84805769e-02f,
  -1.61707066e-02f, -4.11258265e-02f, -4.32162471e-02f, -1.16806971e-02f, 1.03456238e-02f, -4.17222530e-02f, 6.23618327e-02f, 1.31182140e-02f, 4.59494554e-02f, 5.24435518e-03f,
  5.30255921e-02f, -1.33435518e-01f, 1.79022811e-02f, -1.65297054e-02f, 5.44451065e-02f, -1.00956075e-01f, 6.83196560e-02f, -2.36968901e-02f, -1.11306705e-01f, 2.57184152e-02f,
  -5.39276361e-01f, 4.26808268e-01f, 4.02204916e-02f, -2.03894421e-01f, 3.25250463e-03f, 1.60685778e-02f, -1.26250247e-02f, 9.86055844e-03f, -6.65819049e-02f, 3.22573073e-02f,
  -1.19771257e-01f, -1.96262095e-02f, 1.08368911e-01f, 4.12268713e-02f, -2.90167212e-01f, 8.66203681e-02f, -2.12856308e-01f, -3.69698144e-02f, -5.34970388e-02f, -8.39336589e-02f,
  -1.21118829e-01f, 1.47991683e-02f, 4.83466759e-02f, 1.61443740e-01f, 2.64103767e-02f, -2.58474424e-02f, -3.23181599e-02f, 1.45721048e-01f, 3.02455239e-02f, -1.34336865e-02f,
  -1.36170730e-01f, -1.34229258e-01f, -4.46045697e-02f, -1.00132428e-01f, -1.32856652e-01f, -3.95886563e-02f, -3.84119339e-02f, 6.63142428e-02f, -5.29404506e-02f, -1.24654569e-01f,
  -8.15159306e-02f, 2.95730866e-03f, -6.89793304e-02f, -7.83807859e-02f, -7.22896904e-02f, -5.42352162e-03f, 7.07105845e-02f, 7.17082322e-02f, 2.39750240e-02f, 1.96346808e-02f,
  1.37579039e-01f, 1.21288663e-02f, 3.10774613e-03f, 8.40903893e-02f, 9.85289272e-03f, 4.72258925e-02f, -4.56831120e-02f, 9.83189419e-02f, -6.54945243e-03f, -2.22653523e-02f,
  2.46377978e-02f, -1.21437393e-01f, 9.92115960e-02f, -1.16466984e-01f, -3.54074799e-02f, 4.66556959e-02f, 9.29966941e-03f, 4.30695713e-02f, -2.54480764e-02f, -1.43287450e-01f,
  -8.19549412e-02f, 1.08188555e-01f, -2.00367048e-02f, -1.48635745e-01f, 4.51139696e-02f, -4.62010168e-02f, 3.41977477e-02f, -4.74705845e-02f, -2.36929189e-02f, -3.65817994e-02f,
  -1.52597735e-02f, 7.09580183e-02f, 1.67159475e-02f, -7.38133714e-02f, 9.47755948e-03f, 4.89929207e-02f, -4.34853621e-02f, 2.60261819e-02f, -9.12918523e-02f, -5.18041067e-02f,
  -3.14908683e-01f, -2.84028202e-01f, -3.61129493e-02f, -1.03830487e-01f, -6.14968799e-02f, -5.18738367e-02f, 1.73089076e-02f, 7.58477002e-02f, -1.26648366e-01f, -1.07475191e-01f,
  -1.35406047e-01f, -4.72737402e-02f, -5.20081148e-02f, -1.40620798e-01f, 3.66506279e-02f, -1.13417115e-02f, -1.84037052e-02f, -9.89334509e-02f, -1.40458152e-01f, -3.47364247e-02f,
  2.55971611e-03f, 9.52756871e-03f, -9.89907421e-04f, 1.61140095e-02f, -1.96364895e-02f, -7.52483979e-02f, -6.17024899e-02f, 6.11817315e-02f, -5.32424375e-02f, -7.50308437e-03f,
  2.58424193e-01f, 8.22435319e-02f, -2.26278845e-02f, -2.95003271e-03f, -1.81556240e-01f, -1.29636511e-01f, -1.80615902e-01f, -9.88708362e-02f, 1.33320719e-01f, -8.47529620e-03f,
  -2.49340996e-01f, 1.92513734e-01f, -6.78822026e-02f, -9.15623456e-02f, 1.65739302e-02f, 2.57329326e-02f, -1.81866825e-01f, -1.26555815e-01f, -6.07596040e-02f, -1.11214407e-01f,
  -3.07981912e-02f, -1.99737936e-01f, -9.57144052e-02f, -1.79873720e-01f, -1.68650985e-01f, 1.07536636e-01f, -5.59404381e-02f, -1.80100635e-01f, -1.37694061e-01f, -5.72705381e-02f,
  -1.75216254e-02f, 2.36259438e-02f, 9.26907659e-02f, 6.52705040e-03f, 3.44942883e-02f, -5.37787452e-02f, -1.01170540e-01f, -3.90006527e-02f, -4.60501797e-02f, 2.34306291e-01f,
  7.61932358e-02f, 1.63456023e-01f, 3.22456509e-02f, 6.70122355e-03f, 4.45248410e-02f, 9.17044953e-02f, 5.38269356e-02f, -5.19356057e-02f, -1.81617979e-02f, -5.56875244e-02f,
  5.34037985e-02f, 7.19428062e-02f, 4.18987162e-02f, -2.29202788e-02f, 3.23565584e-03f, -3.79115418e-02f, 7.79037103e-02f, -3.81162651e-02f, 6.33837879e-02f, 7.44168684e-02f,
  -4.86512557e-02f, -1.12995822e-02f, 6.06624177e-03f, 7.72579238e-02f, 2.76139788e-02f, 3.41043249e-03f, -3.14029455e-02f, -5.80599755e-02f, 1.78835005e-01f, 3.20874639e-02f,
  2.86326874e-02f, -5.21647744e-02f, 6.44486165e-03f, -3.11678182e-03f, 5.06321900e-02f, 2.00250521e-01f, 2.71004345e-02f, -7.54325688e-02f, 3.02273990e-03f, -2.11192807e-03f,
  -3.60580273e-02f, -5.40791787e-02f, -3.60487439e-02f, -1.85846221e-02f, -2.07119480e-01f, 1.04528673e-01f, 2.71446630e-02f, -3.81270121e-03f, -4.17385995e-02f, -9.71703678e-02f,
  -1.04962580e-01f, -1.27216294e-01f, 8.13660845e-02f, -2.39291415e-02f, -3.34338360e-02f, 4.01215851e-02f, -7.30353519e-02f, -6.02189563e-02f, -7.58591890e-02f, 7.90905952e-02f,
  7.83291757e-02f, 4.56374511e-02f, 8.02252591e-02f, 5.46917096e-02f, 4.91865426e-02f, 2.34817043e-02f, -7.73512945e-02f, 1.12334207e-01f, -2.52872482e-02f, -4.39405069e-03f,
  2.80926973e-02f, -6.55848384e-02f, 4.60251532e-02f, 6.86340556e-02f, -3.22743505e-02f, 1.37704760e-02f, 3.40952426e-02f, 1.84808560e-02f, -3.83670591e-02f, -5.39625250e-03f,
  2.07623705e-01f, 3.23138796e-02f, -3.03134918e-01f, -1.74056113e-01f, -4.62252162e-02f, 2.18223810e-01f, 1.87350154e-01f, 1.45527124e-02f, -1.72647119e-01f, 2.58872718e-01f,
  2.64668137e-01f, 9.04599652e-02f, 4.03958634e-02f, 2.84946680e-01f, 4.10427749e-02f, -2.10333932e-02f, 1.43622547e-01f, 1.73011795e-01f, -7.59808719e-02f, 2.09641844e-01f,
  6.04577921e-02f, 2.91296065e-01f, -6.31886423e-02f, 9.39850062e-02f, 1.83479607e-01f, -6.57349303e-02f, 8.28192979e-02f, -2.63424087e-02f, 8.87342319e-02f, 3.38267908e-02f,
  -3.26594636e-02f, -2.30692569e-02f, 4.73615266e-02f, -8.61010700e-03f, 4.70968671e-02f, 6.65188730e-02f, -5.67800961e-02f, -4.55013365e-02f, -6.04442246e-02f, 2.50943899e-02f,
  1.10288477e-02f, -5.70660941e-02f, 8.89174044e-02f, -8.83114040e-02f, -6.26561716e-02f, -4.36624363e-02f, -6.37418777e-02f, -3.95530574e-02f, -2.45309882e-02f, 8.84983093e-02f,
  -2.08651107e-02f, 6.08442398e-03f, -1.71747636e-02f, -7.61898234e-02f, -5.86532839e-02f, -1.71249937e-02f, -2.08780561e-02f, 4.06267419e-02f, -8.99426788e-02f, 1.00154113e-02f,
  1.44258782e-01f, 6.04267605e-03f, 1.03992082e-01f, -2.08568759e-02f, -2.96810828e-02f, -8.15000087e-02f, 2.16003507e-02f, 2.06313860e-02f, -5.61205819e-02f, 2.53716074e-02f,
  -6.11451454e-02f, -5.12916073e-02f, 2.07317714e-02f, 6.74230233e-02f, 8.14764798e-02f, 2.91138720e-02f, -7.97402812e-04f, 5.23560643e-02f, -4.91652600e-02f, -2.43509058e-02f,
  8.94962251e-02f, -5.72658740e-02f, 1.71814505e-02f, 5.81047172e-03f, -2.40923595e-02f, -7.39659276e-03f, 4.93005700e-02f, 6.13599420e-02f, -1.62716761e-01f, -9.74142030e-02f,
  9.15340930e-02f, 8.84482265e-02f, -7.70353712e-03f, -7.09828958e-02f, -1.26752019e-01f, 1.06905453e-01f, -5.04453992e-03f, 6.75740689e-02f, 2.03185733e-02f, 7.68908113e-02f,
  4.27180715e-02f, -8.59026834e-02f, 7.32580712e-03f, -8.65390375e-02f, -1.61528870e-01f, 5.51008172e-02f, 1.53573319e-01f, -9.65218097e-02f, -1.55624390e-01f, 3.41521539e-02f,
  -4.27772105e-02f, 6.15803897e-02f, -1.36336032e-02f, -3.22895199e-02f, -1.27631083e-01f, 5.99257164e-02f, 2.96543222e-02f, 5.37482265e-04f, 3.27566117e-02f, -4.65260409e-02f,
  -9.15786996e-02f, 6.48376346e-02f, -1.32097095e-01f, -2.30113909e-01f, -1.00016996e-01f, -2.53776848e-01f, -1.41931981e-01f, 1.68197513e-01f, 1.79726034e-01f, 2.07825616e-01f,
  3.59262410e-03f, 6.30133413e-03f, 8.47023353e-02f, -1.00655891e-01f, -8.41627195e-02f, 9.91341919e-02f, -3.05440158e-01f, -5.98916635e-02f, 8.83881301e-02f, -1.27766952e-01f,
  -6.37276024e-02f, -6.90458491e-02f, -1.53731495e-01f, -1.04500279e-02f, -1.55243754e-01f, 9.53493640e-02f, -7.03327805e-02f, 1.18787242e-02f, -1.96704671e-01f, 2.61751283e-02f,
  -1.69444263e-01f, 1.16657943e-01f, -1.19948871e-02f, -3.10859531e-02f, -1.73878893e-01f, -5.26782423e-02f, -3.78997959e-02f, 7.54284859e-02f, -1.80948880e-02f, 9.84220952e-02f,
  6.70171529e-02f, 8.21663812e-02f, 6.83301538e-02f, 9.79468524e-02f, 2.14091968e-02f, 9.98405069e-02f, -5.89550436e-02f, -1.60607323e-01f, -1.25838711e-03f, 2.05822084e-02f,
  -1.71223804e-02f, -9.43844169e-02f, -4.23939154e-03f, 1.60610303e-02f, 1.73311550e-02f, -1.36554852e-01f, 7.90398568e-03f, 2.29515694e-02f, 5.77217061e-03f, -7.50751495e-02f,
  4.16673608e-02f, -9.86294001e-02f, 3.98602784e-02f, -1.82915200e-02f, -7.89125115e-02f, 4.24332023e-02f, 1.45294607e-01f, 8.64303112e-02f, -2.51877550e-02f, 2.34074388e-02f,
  6.47513717e-02f, -1.91455074e-02f, 1.58808067e-01f, -4.62957509e-02f, -6.25517890e-02f, -4.17448506e-02f, -1.83932297e-02f, 1.78441793e-01f, -9.33364965e-03f, -1.28296420e-01f,
  5.51926084e-02f, -2.59317942e-02f, -9.06431526e-02f, -5.31567596e-02f, 8.73414576e-02f, -2.21616682e-02f, 1.59025018e-03f, -3.19654606e-02f, -4.55787629e-02f, -9.78466645e-02f,
  -3.27450514e-01f, -8.91805366e-02f, 6.52271062e-02f, -8.66432488e-02f, -7.59984320e-03f, 8.30524862e-02f, 4.97587919e-02f, 8.33420679e-02f, -1.10510528e-01f, 1.72559127e-01f,
  -3.33913579e-03f, -1.51464995e-03f, -4.86007147e-02f, -1.88655080e-03f, -1.70073900e-02f, -1.38260439e-01f, -4.83529456e-02f, -4.39878814e-02f, -1.33564755e-01f, -1.12501815e-01f,
  -2.53236163e-02f, -7.47291371e-02f, -1.53309805e-02f, 8.51407356e-04f, 4.59396206e-02f, 4.01320122e-02f, 1.00183994e-01f, -2.11262517e-02f, -4.63203974e-02f, -1.02499202e-02f,
  -4.51275140e-01f, 7.49166682e-02f, 3.45858815e-03f, 1.04613222e-01f, -1.92289710e-01f, 3.04565784e-02f, 2.10304230e-01f, -1.54866353e-01f, -1.76388696e-01f, 1.96802303e-01f,
  8.92837439e-03f, 8.10044184e-02f, 1.10696241e-01f, 2.23055348e-01f, -3.65068972e-01f, 1.79791287e-01f, 6.93281293e-02f, 1.53680205e-01f, -5.49165048e-02f, 3.61849554e-02f,
  -3.02790944e-02f, 3.88439298e-02f, 1.20176710e-01f, -1.06359078e-02f, -7.15929046e-02f, -3.44845690e-02f, 1.36587871e-02f, 3.66232288e-03f, -2.03946494e-02f, -2.53562957e-01f,
  -2.22082138e-01f, -1.71393752e-01f, -3.91983017e-02f, -1.32015198e-01f, -9.95659158e-02f, 2.75086635e-03f, -8.37610140e-02f, -3.47330123e-02f, -9.47799683e-02f, -7.76595622e-02f,
  6.20240197e-02f, -5.07885590e-02f, 1.35675609e-01f, 1.07214935e-01f, 4.64450801e-03f, -1.04275420e-01f, -1.07296512e-01f, 6.25390261e-02f, -1.58748571e-02f, -6.96521252e-02f,
  -8.26556142e-03f, 4.36704494e-02f, 5.95552474e-02f, 7.72970915e-02f, -1.05514832e-01f, -4.89344895e-02f, 1.64273947e-01f, -3.94238941e-02f, 3.69166248e-02f, -1.35812029e-01f,
  -2.73799133e-02f, -2.96914987e-02f, 1.75461117e-02f, -6.72928058e-03f, 4.03170809e-02f, 4.34162393e-02f, 4.62545939e-02f, -4.57479320e-02f, -2.20328085e-02f, -5.22690155e-02f,
  3.37174977e-04f, -8.48093480e-02f, -3.96216474e-02f, 6.10201769e-02f, 6.67469129e-02f, 1.17484041e-01f, -5.10861203e-02f, -1.07948504e-01f, 1.54932365e-01f, 5.40546328e-02f,
  1.18809920e-02f, 1.61470007e-02f, 1.00300657e-02f, 5.73494546e-02f, -3.76267582e-02f, -7.66088441e-02f, 5.95996603e-02f, 5.43706566e-02f, 8.13013092e-02f, -1.34413436e-01f,
  -3.69626641e-01f, -2.58811533e-01f, -6.90494329e-02f, -1.00349300e-01f, 7.98827410e-03f, -5.03846481e-02f, 2.04792023e-02f, 2.30378266e-02f, -2.22467668e-02f, -4.03248519e-02f,
  -8.98682028e-02f, 1.36099178e-02f, -1.86234489e-02f, 5.46205714e-02f, 5.50534092e-02f, 1.78279132e-02f, -1.52451871e-02f, -8.86907876e-02f, -4.70257550e-02f, -3.90418731e-02f,
  -5.69241680e-02f, -3.05361394e-02f, 1.33935109e-01f, -2.06515174e-02f, 4.40958180e-02f, -1.01060487e-01f, -8.27263109e-04f, 2.37826332e-02f, -1.17067672e-01f, 8.05260837e-02f,
  -1.53237954e-01f, -6.97065964e-02f, -2.37073034e-01f, -1.80523142e-01f, 2.48147100e-01f, 8.72450545e-02f, 5.61389551e-02f, 1.67296901e-01f, -1.39966473e-01f, 1.82820410e-01f,
  7.48877227e-02f, -2.69870311e-01f, -8.87373164e-02f, -2.31106609e-01f, -1.31503731e-01f, -3.10997277e-01f, 7.69458041e-02f, -6.09557480e-02f, -1.27362311e-01f, 9.64554846e-02f,
  -1.65392518e-01f, 5.19520566e-02f, -6.46181777e-02f, 2.47872010e-01f, 1.38789982e-01f, 6.48581460e-02f, 3.36626559e-01f, 4.77336533e-02f, 2.07867071e-01f, 1.07348906e-02f,
  -8.61661807e-02f, -1.65297255e-01f, -1.78364813e-02f, -4.82500792e-02f, 1.46488115e-01f, 1.23532712e-01f, 6.17744103e-02f, -1.12058744e-02f, -2.31906269e-02f, -1.41065121e-01f,
  4.06876057e-02f, -1.27558142e-01f, 8.73692892e-03f, -5.89083917e-02f, -4.14355360e-02f, 6.32914156e-02f, 1.86431408e-02f, 7.15925843e-02f, -5.63569553e-02f, -1.86292320e-01f,
  2.07507890e-02f, -5.50021715e-02f, -5.14655141e-03f, 5.08729145e-02f, -8.29012543e-02f, 1.47862053e-02f, 4.95577678e-02f, 1.16353117e-01f, 5.26957922e-02f, 5.25438674e-02f,
  1.07740477e-01f, 2.20304262e-02f, -5.94625622e-02f, -6.42469749e-02f, -1.68167762e-02f, 6.28582910e-02f, -5.83745167e-02f, 6.18946441e-02f, 7.04645924e-03f, 6.94155321e-02f,
  7.38014132e-02f, 9.62016266e-03f, -4.95183133e-02f, 5.39998189e-02f, 1.55748613e-02f, -5.10510243e-02f, 5.22215152e-03f, 7.90895373e-02f, 7.56727606e-02f, 3.84073481e-02f,
  -1.84266016e-01f, -2.92126890e-02f, 3.48495618e-02f, -6.53708214e-03f, -1.15142375e-01f, 5.33150434e-02f, 1.41760511e-02f, -7.72306547e-02f, -3.74208651e-02f, 7.11816624e-02f,
  9.07828212e-02f, 1.75348714e-01f, 2.36872192e-02f, -4.83126193e-02f, -3.51276621e-02f, 6.41676113e-02f, -2.31632926e-02f, -2.14600340e-02f, -9.47961882e-02f, -3.19668986e-02f,
  9.18847769e-02f, 4.32135984e-02f, 1.58427551e-01f, -1.28546869e-02f, 2.94676125e-02f, 1.48366004e-01f, -4.37452495e-02f, 2.14478723e-03f, 1.36447161e-01f, 5.69444755e-03f,
  1.71731502e-01f, 1.08596928e-01f, -6.41844273e-02f, 8.63897055e-02f, 1.24598168e-01f, 8.50473046e-02f, 6.55358434e-02f, -7.08529204e-02f, 8.17523450e-02f, 1.79159716e-02f,
  -1.03098609e-01f, -1.77038118e-01f, -1.03533208e-01f, -1.94460958e-01f, -1.25022903e-01f, -9.12970155e-02f, 1.21563496e-02f, -1.76637352e-01f, -7.67605528e-02f, 1.75306108e-02f,
  -6.56468496e-02f, 9.79282185e-02f, 1.45249188e-01f, -3.12637389e-02f, 3.18567932e-01f, 3.14606398e-01f, -1.23808712e-01f, 2.08776072e-02f, -6.85346425e-02f, -1.27233371e-01f,
  -8.34381953e-02f, -1.81997240e-01f, 1.76498085e-01f, -1.83769211e-01f, -2.19164819e-01f, -1.03971772e-01f, 1.40496954e-01f, 5.88345490e-02f, -1.12330176e-01f, 8.82520340e-03f,
  -1.04071736e-01f, -1.85332134e-01f, -1.58495784e-01f, -1.13913761e-02f, -1.30124250e-02f, 2.84175351e-02f, -7.70092197e-03f, 8.60982761e-02f, -8.18278119e-02f, -9.79437083e-02f,
  1.90499112e-01f, -7.03041404e-02f, -1.63509011e-01f, 1.03936404e-01f, -8.83209184e-02f, -1.09902583e-01f, 9.79280770e-02f, -1.70405865e-01f, -3.73054631e-02f, 6.72661066e-02f,
  -3.47045623e-02f, -1.63283587e-01f, -5.14334515e-02f, 5.35735004e-02f, 3.85697335e-02f, 1.98729970e-02f, 2.55337358e-02f, 1.35501996e-01f, 1.79755948e-02f, -8.36161710e-03f,
  1.18592069e-01f, 2.32852787e-01f, -4.06511053e-02f, -1.88919567e-02f, 1.65882073e-02f, 7.59210018e-03f, -7.76467770e-02f, 5.66065498e-02f, 1.25945024e-02f, -8.20179880e-02f,
  -5.31634912e-02f, 5.35830222e-02f, -1.59821168e-01f, 5.32632656e-02f, 1.42027169e-01f, 2.51813177e-02f, 9.03134570e-02f, 8.73204470e-02f, -6.67780489e-02f, 3.09496950e-02f,
  1.68915384e-03f, 5.98075939e-03f, 8.61166194e-02f, 8.46367404e-02f, -5.45321852e-02f, 2.33696457e-02f, -4.59866505e-03f, 1.20237969e-01f, -2.37076860e-02f, 2.28811316e-02f,
  -9.30772573e-02f, -1.52045175e-01f, -8.65861773e-02f, -5.52843846e-02f, 5.84965311e-02f, -5.25858179e-02f, -9.44288075e-02f, 9.60026402e-03f, -7.58201852e-02f, -8.06540698e-02f,
  -2.57634502e-02f, -5.06374612e-02f, -8.03384334e-02f, 1.14635721e-01f, 1.36861488e-01f, 1.33013912e-02f, 5.57259582e-02f, -1.57941356e-01f, -5.73739000e-02f, 1.20251745e-01f,
  -3.94970775e-02f, -1.43039182e-01f, 2.47330233e-01f, 1.66219499e-04f, 1.68393493e-01f, 3.70093212e-02f, -1.06426045e-01f, 8.77704397e-02f, -5.55258393e-02f, -2.55871043e-02f,
  1.85587123e-01f, 1.92804545e-01f, 1.65087700e-01f, 2.21983254e-01f, -2.01716185e-01f, -3.03006887e-01f, -3.70598674e-01f, 1.35916650e-01f, 4.59778123e-03f, -9.63113829e-02f,
  -1.20059744e-01f, 2.31828734e-01f, -7.57772401e-02f, 1.50172606e-01f, 1.31391212e-01f, -1.56491980e-01f, 2.36986548e-01f, 1.44276824e-02f, 2.88197417e-02f, 2.11656690e-01f,
  1.01427317e-01f, 1.20293938e-01f, 2.21320242e-01f, 9.80107784e-02f, 4.82380874e-02f, 1.15774781e-01f, 1.25284195e-01f, -1.51687026e-01f, 1.73822075e-01f, -8.30842853e-02f,
  -1.98982991e-02f, -2.45478805e-02f, 2.53779031e-02f, -9.02545527e-02f, 3.13738286e-02f, -1.09898932e-01f, -4.03238721e-02f, -6.90173879e-02f, -4.56057712e-02f, -1.18537983e-02f,
  -2.16538291e-02f, 2.04693582e-02f, 1.11877779e-02f, -3.66424210e-03f, 1.67371072e-02f, 1.36826420e-02f, 1.31274521e-01f, 1.95607971e-02f, -2.29384191e-02f, 6.05567992e-02f,
  9.60160494e-02f, -4.63524014e-02f, 7.64885917e-02f, -1.69660710e-02f, 7.90285319e-02f, 5.60821816e-02f, -7.13410845e-04f, 1.76627375e-02f, 4.69689630e-02f, 5.06630614e-02f,
  9.48922858e-02f, -7.26940334e-02f, -4.70649339e-02f, -6.30511642e-02f, -2.18447130e-02f, -6.96091279e-02f, -5.36240339e-02f, -2.89460719e-02f, -1.75655186e-02f, 2.87323128e-02f,
  1.74560007e-02f, 1.26569753e-03f, -2.97158360e-02f, -9.66789275e-02f, 2.15357188e-02f, 1.72662344e-02f, 2.21457742e-02f, -3.96715626e-02f, -4.13713828e-02f, -4.44921926e-02f,
  -1.98845640e-01f, -5.31949755e-03f, -6.36216104e-02f, 8.04531202e-03f, -2.69310456e-03f, 5.59638515e-02f, -5.48412427e-02f, -6.99170399e-03f, -5.84925245e-03f, 4.16872129e-02f,
  7.66485631e-02f, 2.23991200e-01f, -3.89571115e-02f, -7.14179128e-02f, -2.23279977e-03f, 3.80754378e-03f, -5.09160273e-02f, 4.05501314e-02f, 4.33443971e-02f, 6.88930834e-03f,
  8.93284976e-02f, -9.32278391e-03f, 3.86785204e-03f, 2.61326157e-03f, 2.49876156e-02f, 1.27216727e-01f, 9.27808695e-03f, 7.65774548e-02f, 9.42469463e-02f, 1.08118206e-01f,
  7.01846555e-03f, -1.51989117e-01f, -3.99877727e-02f, -1.48313458e-03f, 1.32755607e-01f, -2.36600656e-02f, 8.90118128e-04f, 1.20752351e-02f, -2.48646624e-02f, -8.28252267e-03f,
  2.80936003e-01f, -4.74332534e-02f, 2.06200138e-01f, 2.45915517e-01f, 1.84344113e-01f, 1.29944742e-01f, 8.21904019e-02f, 2.21439540e-01f, 5.19889474e-01f, -1.12745978e-01f,
  -6.94556460e-02f, -5.17536514e-02f, -9.43505242e-02f, 9.54478383e-02f, -1.45206183e-01f, -6.91849068e-02f, 2.11516246e-02f, -2.08646897e-03f, -3.56321665e-03f, 1.11064702e-01f,
  1.11521564e-01f, -1.76975787e-01f, -2.20217928e-01f, -2.47734517e-01f, 4.26474698e-02f, 1.44961312e-01f, -2.70073861e-01f, -1.95630878e-01f, -3.77877504e-02f, 1.59705449e-02f,
  -2.01511830e-02f, 9.98185575e-02f, -1.79225579e-02f, 5.64285666e-02f, -1.49041265e-02f, -7.73765221e-02f, 3.49286944e-02f, -9.97318104e-02f, -4.69943434e-02f, 1.66035190e-01f,
  6.13586381e-02f, 1.13436677e-01f, 2.76476797e-02f, -4.61788382e-03f, 7.64362440e-02f, 4.28116210e-02f, 1.42687395e-01f, 1.19023107e-01f, 7.97697976e-02f, 9.12142619e-02f,
  -3.65829282e-02f, 4.67314459e-02f, 5.21444790e-02f, -7.47691188e-03f, 9.92326736e-02f, 7.83419833e-02f, 5.35637960e-02f, -2.93621887e-03f, -3.20630781e-02f, 4.77003157e-02f,
  -7.86017850e-02f, 2.76616216e-02f, -5.37860766e-02f, -1.52384385e-03f, -2.44638864e-02f, 9.92174447e-03f, -5.30218612e-03f, -1.16937272e-01f, 9.08256099e-02f, 5.78674860e-02f,
  -2.66749244e-02f, -1.84185635e-02f, 5.93075640e-02f, -6.83518127e-02f, 6.48549423e-02f, 1.54347450e-01f, -8.69819988e-03f, -8.81464779e-02f, 1.37684792e-01f, -1.82855219e-01f,
  -4.59414609e-02f, 7.23101571e-02f, -5.83157800e-02f, 5.06002083e-02f, -4.95688356e-02f, 3.93583141e-02f, 1.12737834e-01f, 1.45096583e-02f, -3.92752839e-03f, -7.30871484e-02f,
  -1.52512088e-01f, -5.27650081e-02f, 1.16117746e-02f, 3.95208485e-02f, -4.27871980e-02f, 1.29810825e-01f, 1.86230391e-02f, 2.48390976e-02f, -3.07613779e-02f, 9.01876539e-02f,
  2.04752013e-01f, 1.42543942e-01f, 2.80517861e-02f, -8.61452594e-02f, -1.33684590e-01f, 1.32792965e-02f, 5.75374253e-02f, -3.77457589e-02f, 3.73547487e-02f, -6.40061498e-02f,
  -4.01285365e-02f, -1.75840985e-02f, 3.63770090e-02f, 6.60944730e-02f, -3.74490172e-02f, -2.19407901e-02f, -3.46007347e-02f, 2.12403759e-02f, -1.23468317e-01f, 4.96231280e-02f,
  -6.00199521e-01f, 2.97562897e-01f, 4.83301878e-01f, -2.93716848e-01f, 2.39305228e-01f, 5.75485945e-01f, 7.47857392e-02f, 1.93098247e-01f, 9.43482146e-02f, -1.81707785e-01f,
  -1.95866093e-01f, -1.58102706e-01f, 1.21074811e-01f, -1.70764834e-01f, 3.50920200e-01f, 2.66960263e-01f, 1.89742707e-02f, -1.29917994e-01f, 1.21708542e-01f, -9.87487137e-02f,
  4.01334800e-02f, -1.87437654e-01f, 6.34564087e-02f, 5.00956029e-02f, -1.58159211e-01f, -8.86522681e-02f, -1.61848336e-01f, 8.16081539e-02f, -2.69746524e-03f, 2.05534473e-02f,
  3.59654729e-03f, -1.78080186e-01f, -1.70093980e-02f, 1.11301631e-01f, 2.42101625e-02f, -1.50229195e-02f, -3.50048356e-02f, 5.57762757e-02f, -2.93532312e-02f, 5.23615954e-03f,
  -9.98226181e-02f, 6.79472461e-03f, -1.59298107e-01f, 8.21331590e-02f, -5.54944761e-03f, 5.20785376e-02f, 1.03400752e-01f, -3.64264064e-02f, 4.15694527e-02f, 1.36577725e-01f,
  1.32000208e-01f, 1.26264393e-01f, -1.16804978e-02f, 8.09574947e-02f, 8.31993520e-02f, 1.81740988e-02f, 3.99953313e-02f, 6.01711385e-02f, 3.67278568e-02f, 3.85485142e-02f,
  8.73509049e-03f, 1.71679258e-01f, -6.33455217e-02f, -5.82955927e-02f, -6.58010095e-02f, 2.41977032e-02f, -5.00179175e-03f, -9.16753411e-02f, -4.91254032e-02f, -8.10079202e-02f,
  -7.88951591e-02f, 9.57184657e-03f, -5.64075932e-02f, 1.61903747e-03f, -1.10218056e-01f, -9.04400051e-02f, 1.10350594e-01f, -1.10721245e-01f, -8.48602802e-02f, 1.84006933e-02f,
  -4.25395090e-03f, 1.63096318e-03f, -1.75821528e-01f, -6.26796782e-02f, 4.46642488e-02f, 4.56187464e-02f, -3.89316352e-03f, 4.66596112e-02f, 1.12645719e-02f, -4.78840694e-02f,
  5.24457209e-02f, 2.50046831e-02f, 7.33385980e-03f, -7.37886727e-02f, -3.89145650e-02f, -6.51280209e-02f, 1.19885117e-01f, 1.97072830e-02f, 3.57408226e-02f, -9.70269367e-03f,
  -2.48573478e-02f, -1.86636597e-01f, 5.96727757e-03f, -2.96989381e-02f, 5.63313589e-02f, 6.92282338e-03f, -9.36379433e-02f, -2.05693617e-02f, -8.80806744e-02f, -2.03123186e-02f,
  -8.75564441e-02f, -9.58315805e-02f, 2.29929015e-02f, -9.27619934e-02f, -1.52397066e-01f, -5.27612120e-02f, -4.72536571e-02f, -3.66418064e-02f, -3.33741866e-03f, 3.31125542e-04f,
  1.77834138e-01f, -1.74513549e-01f, -1.16278298e-01f, -1.09757431e-01f, 5.18890247e-02f, -1.09020911e-01f, -2.44199425e-01f, -1.44672245e-01f, 2.84957170e-01f, -9.02125798e-03f,
  -1.16714366e-01f, 1.30688444e-01f, -2.19832044e-02f, -2.22612083e-01f, 2.65175372e-01f, 1.54952183e-01f, 4.10532905e-03f, -6.21344484e-02f, 1.72218502e-01f, -2.96353307e-02f,
  -4.64400165e-02f, -1.62001267e-01f, -2.42883846e-01f, -2.42560655e-01f, -3.56617332e-01f, -1.87637836e-01f, -2.24998221e-01f, -2.35717446e-01f, -2.98963785e-01f, -7.14832544e-02f,
  -1.02443628e-01f, -7.78727755e-02f, -1.73237950e-01f, -5.80140203e-02f, -1.25045665e-02f, -4.27813567e-02f, -5.90872541e-02f, -6.58521429e-02f, 2.94277202e-02f, 5.55537194e-02f,
  -1.15861662e-03f, 1.27556384e-01f, 4.00124528e-02f, -3.09211742e-02f, 8.74859616e-02f, 1.00076042e-01f, 6.05066381e-02f, -7.00411946e-02f, -3.40719894e-02f, -9.29170921e-02f,
  -4.94425073e-02f, 2.42018001e-03f, 7.62725696e-02f, 1.03739224e-01f, 5.31964414e-02f, -7.75580108e-03f, 1.83042476e-03f, 4.41050110e-03f, 1.11832127e-01f, 1.06656753e-01f,
  -1.22747168e-01f, 2.83457395e-02f, -7.07242414e-02f, 8.90404545e-03f, 6.31963760e-02f, 3.85085307e-02f, 5.48698977e-02f, -2.40725540e-02f, 6.02591150e-02f, -8.43857452e-02f,
  2.21848139e-03f, -9.68785137e-02f, 6.44566789e-02f, -8.11420903e-02f, -4.99923974e-02f, 5.71541861e-02f, 1.23475650e-02f, 4.59109470e-02f, 8.25071409e-02f, 3.29420380e-02f,
  -4.53874730e-02f, 6.27372190e-02f, -3.14458497e-02f, 1.04770914e-01f, 5.23150526e-02f, 3.06141991e-02f, 3.57049182e-02f, 2.59532649e-02f, 2.61388905e-02f, 4.42268550e-02f,
  9.87116173e-02f, 1.05568379e-01f, -9.55280960e-02f, -5.33320121e-02f, 8.43525380e-02f, 6.00803755e-02f, 3.20713669e-02f, 1.33880358e-02f, 8.87416229e-02f, -2.50458196e-02f,
  1.60300918e-02f, -4.87141870e-02f, 1.37251779e-01f, 4.88421135e-02f, 1.57397203e-02f, 2.12926436e-02f, 3.02543100e-02f, -2.14702240e-03f, 1.97223142e-01f, 1.53406551e-02f,
  -7.71802291e-02f, 1.14083029e-01f, 1.89367980e-01f, 1.08027890e-01f, -5.85434698e-02f, 1.41171422e-02f, 1.23882838e-01f, -1.07331723e-02f, -8.98706764e-02f, 1.92027807e-01f,
  -4.13832337e-01f, 2.08618328e-01f, -1.87737063e-01f, 7.56268650e-02f, -1.70592323e-01f, -3.83023500e-01f, -2.17181537e-02f, -3.11159855e-03f, 1.57323718e-01f, 2.00987294e-01f,
  1.03327714e-01f, 9.91064757e-02f, 2.65592188e-01f, 3.53461325e-01f, -4.46537226e-01f, 9.59434211e-02f, -1.87821999e-01f, 5.98476864e-02f, 8.00601542e-02f, -1.38787568e-01f,
  -8.89804289e-02f, 2.37598464e-01f, 1.45636629e-02f, 1.22798391e-01f, 1.82618946e-02f, 5.06548211e-02f, 1.51149154e-01f, 1.01341121e-01f, 3.78422588e-02f, -7.20386952e-02f,
  -1.73097685e-01f, 1.52621403e-01f, 3.11380229e-03f, -1.16435096e-01f, -8.39886144e-02f, -6.98763505e-02f, -9.01374668e-02f, 4.50364798e-02f, 1.36653855e-01f, -2.19348464e-02f,
  -7.92135522e-02f, 1.36198020e-02f, 7.91284516e-02f, 4.82583009e-02f, -1.10087104e-01f, 3.31276432e-02f, -6.48536459e-02f, 5.60854152e-02f, -3.24139744e-02f, -5.37387095e-02f,
  6.45047948e-02f, 1.43259503e-02f, -6.63878769e-02f, 3.70111279e-02f, 5.56448067e-04f, 2.20836718e-02f, -8.52703080e-02f, -1.72995970e-01f, -6.20938018e-02f, -6.08880930e-02f,
  1.40930787e-01f, -4.79279794e-02f, 5.85414022e-02f, -3.51281613e-02f, -3.66754271e-02f, -4.73577306e-02f, 2.78662350e-02f, 7.86324665e-02f, 5.77277057e-02f, -1.19033337e-01f,
  -9.51731205e-02f, -3.11860424e-02f, -7.25198351e-03f, -4.43196930e-02f, 2.04423089e-02f, -4.75406693e-03f, -8.54132473e-02f, 1.63424965e-02f, -1.65630177e-01f, -1.11652268e-02f,
  1.26703680e-01f, -3.74103040e-02f, -3.17887850e-02f, -1.68238819e-01f, 7.50366598e-02f, -5.90083487e-02f, -5.32815047e-02f, -8.62060860e-02f, -6.34490401e-02f, -1.80113703e-01f,
  -3.73774499e-01f, -5.46909161e-02f, -5.26584219e-03f, -9.52288955e-02f, 6.24871477e-02f, -1.46429345e-01f, 9.44404751e-02f, -7.11337402e-02f, 6.97579086e-02f, -7.18529001e-02f,
  -1.54739797e-01f, -2.88130138e-02f, -8.86873752e-02f, -5.45996428e-02f, 1.70340203e-02f, -4.40948009e-02f, 9.43088084e-02f, 6.71617538e-02f, -6.90058991e-02f, 1.27381068e-02f,
  7.75372013e-02f, 8.68274271e-02f, -1.18132129e-01f, -9.44749173e-03f, -1.28946919e-02f, 3.79538648e-02f, -2.43648351e-03f, 3.12902294e-02f, 1.19052259e-02f, 1.61477514e-02f,
  2.04945907e-01f, -2.45384783e-01f, -3.92735571e-01f, -8.81863311e-02f, 2.63499469e-01f, 2.56368250e-01f, 7.06037208e-02f, 8.91409665e-02f, -2.11008310e-01f, 2.34500363e-01f,
  2.85191953e-01f, -8.84825662e-02f, -1.86335772e-01f, 3.48193854e-01f, 1.83880702e-01f, -1.32995486e-01f, 2.69291401e-01f, 1.34643435e-01f, 1.27918711e-02f, -1.25025613e-02f,
  1.19859949e-02f, 3.90626132e-01f, -4.58316319e-02f, 1.60046741e-01f, 2.07853317e-01f, -4.90972325e-02f, 8.23773295e-02f, -7.26388916e-02f, 2.02007934e-01f, 6.32711649e-02f,
  -6.33152425e-02f, -2.27024909e-02f, -4.95711677e-02f, -6.63204640e-02f, 4.98430431e-02f, 7.20355585e-02f, -9.89066288e-02f, 2.62212195e-02f, -3.49720977e-02f, -1.87467933e-02f,
  -6.59879446e-02f, -4.76285592e-02f, 1.60272092e-01f, -3.89776491e-02f, 7.57095516e-02f, 1.23860696e-02f, 4.13688365e-04f, -2.44063474e-02f, -3.72019000e-02f, 3.28939781e-03f,
  -4.92800325e-02f, 1.36576099e-02f, -9.77306664e-02f, 2.91416571e-02f, 6.03898987e-02f, 1.51121784e-02f, -9.74212810e-02f, -3.36921141e-02f, -6.58998266e-02f, 8.53925012e-03f,
  1.48292691e-01f, -7.73904426e-03f, 4.71374318e-02f, -2.91062687e-02f, -7.20158592e-03f, -2.16989908e-02f, 5.98715916e-02f, 4.32761274e-02f, -7.75090382e-02f, -8.08850210e-03f,
  2.45551430e-02f, -2.06191503e-02f, -8.43065456e-02f, -2.81612631e-02f, 7.62465298e-02f, -1.42631009e-01f, -1.04413122e-01f, 6.11988120e-02f, 2.55793594e-02f, 1.25552090e-02f,
  -3.77372615e-02f, 1.24265943e-02f, 6.55302107e-02f, -6.15436509e-02f, -2.13659350e-02f, 7.76525736e-02f, 1.09133475e-01f, 2.56194063e-02f, 2.73043551e-02f, -1.39565289e-01f,
  1.60619505e-02f, -6.09511398e-02f, -8.15392584e-02f, 4.63775620e-02f, -2.99712960e-02f, 5.02228923e-03f, -6.18391447e-02f, -1.62699334e-02f, -7.56357312e-02f, -5.52795492e-02f,
  3.02003175e-02f, -2.60095540e-02f, 3.55620272e-02f, 3.90266962e-02f, -7.38841444e-02f, 1.43832058e-01f, 9.00718570e-02f, -8.18675756e-02f, 2.51438171e-02f, 1.46615684e-01f,
  6.90375045e-02f, 1.64991051e-01f, -3.30703743e-02f, 3.23098432e-03f, -5.79638220e-03f, 4.02098037e-02f, 1.51743134e-02f, 1.70625374e-02f, -7.66219106e-03f, -8.79185721e-02f,
  -2.55313981e-02f, -1.85498565e-01f, -1.42764077e-01f, -1.10020503e-01f, 7.97992945e-02f, 2.71752208e-01f, -8.62587020e-02f, -1.14778221e-01f, -3.40999633e-01f, 5.66013716e-03f,
  1.51420027e-01f, -2.21112162e-01f, -8.63802359e-02f, 5.89177236e-02f, -4.55183443e-03f, -5.95550984e-02f, 1.73693150e-01f, 1.53995082e-01f, 1.18864544e-01f, -7.32559189e-02f,
  4.96066362e-02f, 2.54842639e-01f, -3.35366139e-03f, 2.04861060e-01f, 6.02426007e-02f, 7.75044858e-02f, 5.76801077e-02f, -4.68674265e-02f, 2.25209236e-01f, 9.26348194e-03f,
  1.23011969e-01f, -1.11256003e-01f, -1.94159504e-02f, -1.05070639e-02f, -2.42992919e-02f, 4.61728461e-02f, 6.81997985e-02f, 1.26904413e-01f, -9.07179900e-03f, -6.48373812e-02f,
  3.48151624e-02f, 6.47296607e-02f, 1.06898427e-01f, -2.50521414e-02f, 6.88902363e-02f, -1.10251494e-01f, -7.77417868e-02f, -4.52444404e-02f, -1.19383156e-01f, 5.04372641e-02f,
  -5.83668239e-02f, 3.44329923e-02f, 4.51633371e-02f, -2.19702125e-02f, -2.03711931e-02f, -5.05845109e-03f, -4.18796614e-02f, -1.75330579e-01f, 9.81167033e-02f, -1.67092472e-01f,
  2.43707411e-02f, 7.07245916e-02f, 1.17628030e-01f, 1.19581081e-01f, -1.75061990e-02f, 7.02196658e-02f, 1.69857070e-01f, 7.94642940e-02f, -1.16407059e-01f, -1.15607500e-01f,
  -1.38324965e-02f, -2.89350916e-02f, -2.97649018e-02f, 8.46235305e-02f, 1.72356870e-02f, 1.91972955e-04f, 6.19182400e-02f, -2.19326280e-02f, -1.11938439e-01f, 4.13363986e-02f,
  1.00685790e-01f, -8.93305521e-03f, -1.40909299e-01f, -4.03090678e-02f, 1.05605103e-01f, -2.37966672e-01f, -4.23580110e-02f, -1.56818330e-02f, -2.31548063e-02f, 4.22602743e-02f,
  1.18774110e-02f, -8.81722718e-02f, -4.99954484e-02f, -6.86922530e-03f, 2.64824387e-02f, 1.06627494e-03f, 4.97286618e-02f, 4.54841480e-02f, -1.53863698e-03f, -6.03746176e-02f,
  -4.04556049e-04f, -4.80170595e-03f, 1.27774507e-01f, 2.60445066e-02f, -2.50337906e-02f, -4.89975028e-02f, 1.33357689e-01f, -8.18590894e-02f, -1.79035738e-01f, 8.88807401e-02f,
  2.04756148e-02f, 6.34755120e-02f, -1.16195887e-01f, 6.62665069e-02f, -2.06427667e-02f, -9.98645201e-02f, 7.32016638e-02f, -9.95666757e-02f, 1.48669407e-01f, -1.13268837e-01f,
  -4.59263951e-01f, 2.98835218e-01f, -1.27576381e-01f, 2.87489910e-02f, -9.20697823e-02f, 2.67856091e-01f, 1.28183424e-01f, 5.24283387e-02f, -5.37985303e-02f, 1.39772281e-01f,
  2.32102592e-02f, -7.84081519e-02f, 1.36212170e-01f, 2.08492681e-01f, -1.67023078e-01f, 1.72638893e-01f, 8.18933547e-02f, 5.56238666e-02f, -8.62027034e-02f, 1.91882662e-02f,
  6.78343838e-03f, 7.42214248e-02f, -2.47088429e-02f, 1.66789815e-01f, -4.82304171e-02f, -2.07847223e-01f, -7.64515251e-02f, -4.53292504e-02f, 9.51621383e-02f, -5.91080151e-02f,
  -9.25673395e-02f, -2.61799246e-01f, -4.97767702e-02f, -1.07543118e-01f, -8.87290388e-02f, -1.52992513e-02f, -6.45599291e-02f, -1.49789214e-01f, -4.82690744e-02f, 6.04391797e-04f,
  -4.31479961e-02f, -5.94163798e-02f, 3.70803736e-02f, -8.83105323e-02f, 4.23078835e-02f, -2.04266421e-02f, 1.54658437e-01f, 4.98184972e-02f, 1.70607626e-01f, 6.51397705e-02f,
  -5.06003685e-02f, 2.11937837e-02f, 1.49484158e-01f, 1.46115348e-02f, 2.61070002e-02f, 4.00216058e-02f, 3.05993445e-02f, 3.47310081e-02f, -2.14940328e-02f, 3.29841417e-03f,
  -5.23535088e-02f, 1.23629635e-02f, -7.25367218e-02f, 3.42510156e-02f, 2.31207870e-02f, -1.69113111e-02f, 6.00792579e-02f, -9.11217779e-02f, 1.12031563e-03f, 7.30092525e-02f,
  3.86741906e-02f, -2.86017880e-02f, 3.00459960e-03f, 4.51897010e-02f, -1.49869462e-02f, 5.15922867e-02f, -3.30903307e-02f, -2.00253502e-02f, 7.68492296e-02f, 6.24575764e-02f,
  -1.86252333e-02f, 2.01263395e-03f, -7.32500106e-03f, 6.69066384e-02f, -5.55502065e-02f, 1.55994706e-02f, -5.04192710e-03f, -1.61714815e-02f, 3.91773209e-02f, 4.76626642e-02f,
  -3.89477164e-02f, -2.16082424e-01f, -1.11474775e-01f, 4.40989807e-03f, -5.36969416e-02f, -2.86186556e-03f, -7.58211985e-02f, -8.75341892e-02f, -4.23223712e-02f, 8.27325450e-04f,
  -3.55925448e-02f, 7.86746852e-03f, -2.23639514e-02f, 1.01944422e-02f, 3.18699405e-02f, 6.65506646e-02f, 9.11636055e-02f, -2.42349114e-02f, -6.05023513e-03f, 8.81074071e-02f,
  -4.97954823e-02f, -8.35646689e-02f, 8.23481008e-02f, 7.42990710e-03f, 1.60050869e-01f, -2.54329480e-03f, -4.11192253e-02f, 2.03974843e-02f, -4.41544093e-02f, -6.04623370e-02f,
  -2.33646095e-01f, 9.24101844e-02f, 2.61877716e-01f, 3.68540078e-01f, -1.52196273e-01f, -3.15931439e-01f, -1.17057793e-01f, 7.94032663e-02f, -1.72526732e-01f, -1.40490234e-01f,
  9.54701379e-02f, 2.21710488e-01f, 5.22794388e-03f, 1.81649193e-01f, 3.16575140e-01f, -2.60410947e-03f, 3.33731622e-02f, -1.20215034e-02f, 8.14061537e-02f, 1.16745666e-01f,
  7.63219520e-02f, -1.54052423e-02f, 3.52283329e-01f, -5.64274704e-03f, 4.63130549e-02f, 1.40764371e-01f, 3.17580044e-01f, 2.16848820e-01f, 2.32451841e-01f, 1.19707741e-01f,
  -1.26240879e-01f, -7.26105925e-03f, -2.45206393e-02f, -8.62891003e-02f, 3.45614590e-02f, -8.07049200e-02f, -1.70740914e-02f, 1.17675275e-01f, 7.84100518e-02f, 1.08919300e-01f,
  -5.31805493e-02f, -1.09973680e-02f, -1.98587701e-02f, -3.57269458e-02f, -5.10552749e-02f, -1.21846739e-02f, -1.92671493e-02f, -1.85429510e-02f, -6.43813983e-02f, -1.24572683e-02f,
  7.85757750e-02f, -5.75974490e-03f, 3.23797874e-02f, -5.30825788e-03f, 4.41979058e-02f, -3.46533023e-02f, 8.36687163e-02f, -5.60397096e-02f, 4.39333729e-02f, 8.44769403e-02f,
  -1.73732251e-01f, 2.37220936e-02f, -7.02587441e-02f, 6.56594262e-02f, 1.06170401e-02f, 4.68887128e-02f, -3.29295248e-02f, 6.99525103e-02f, 1.32447258e-01f, 4.65895608e-02f,
  1.09531224e-01f, 1.10420197e-01f, -5.05172014e-02f, 2.72013526e-02f, 4.86649461e-02f, -6.02343120e-02f, 1.21953525e-01f, 1.41352341e-02f, -6.68645278e-02f, 1.23657016e-02f,
  2.53100228e-02f, 7.62987360e-02f, 2.79144645e-02f, -1.67320222e-02f, -1.64087072e-01f, -8.78252927e-03f, 1.82601064e-02f, 3.14562395e-02f, 4.86982428e-02f, 5.93255050e-02f,
  -2.03358736e-02f, 1.95843741e-01f, 3.84040475e-02f, -8.00353140e-02f, 1.58565107e-03f, 4.02302761e-03f, -4.24300581e-02f, -7.34161735e-02f, 7.37961940e-03f, 5.85348792e-02f,
  2.05793902e-02f, 7.36959800e-02f, -3.25197191e-03f, 2.54890919e-02f, 1.43852644e-02f, 9.18646529e-03f, -2.97061466e-02f, 9.46605727e-02f, 7.48504177e-02f, 5.60461022e-02f,
  4.52665389e-02f, -4.43264358e-02f, -4.70837578e-02f, -1.33163810e-01f, 1.85954124e-02f, -1.02866516e-02f, -1.00860350e-01f, -1.31393954e-01f, 3.28163765e-02f, -5.11891721e-03f,
  3.12883317e-01f, 3.91530633e-01f, 1.96943581e-01f, 2.11562049e-02f, -2.02257052e-01f, -2.94946611e-01f, -1.75495803e-01f, -3.89577374e-02f, -2.71191876e-02f, 6.97262883e-02f,
  -2.50658125e-01f, 4.87123698e-01f, -8.91563520e-02f, 7.65705630e-02f, -3.40920597e-01f, -1.85541347e-01f, -3.92867662e-02f, 2.17786521e-01f, 1.21730603e-01f, 7.75390342e-02f,
  1.44565636e-02f, -2.18521997e-01f, 1.81029160e-02f, -8.91168714e-02f, 9.41427723e-02f, 2.31029540e-01f, -1.00995108e-01f, -9.90238190e-02f, 1.61684886e-01f, -9.14924815e-02f,
  -1.37370536e-02f, 1.78263739e-01f, 1.03795610e-01f, -4.37057428e-02f, -3.40428390e-02f, -3.28755751e-02f, 5.96280582e-02f, -4.48810086e-02f, -2.58796755e-02f, 2.09996896e-03f,
  3.14435400e-02f, -7.60070756e-02f, 7.14826584e-02f, 2.30591651e-03f, -4.83590029e-02f, 6.00266233e-02f, 1.40754227e-02f, 2.90652327e-02f, 5.84524684e-02f, 1.79765597e-02f,
  7.55231380e-02f, 3.96154821e-02f, -9.92107093e-02f, -1.39312372e-02f, 3.72814946e-03f, 1.39009941e-03f, -2.60267667e-02f, 1.96761880e-02f, 1.46136470e-02f, 3.54056545e-02f,
  5.44173345e-02f, -1.90716147e-01f, -7.79461116e-02f, -6.69038743e-02f, -7.20886290e-02f, 4.01340537e-02f, 4.85287122e-02f, 1.43872023e-01f, -6.15689121e-02f, -9.11031142e-02f,
  -4.37790230e-02f, 7.60392621e-02f, -1.17792398e-01f, -1.60434678e-01f, -2.52693538e-02f, 3.67054506e-03f, -3.57835367e-02f, -8.70898739e-02f, -4.99563627e-02f, -3.09657604e-02f,
  -3.77646759e-02f, -1.21132910e-01f, 5.45574464e-02f, -1.15545489e-01f, 1.44536346e-02f, 8.05997476e-02f, 4.39311415e-02f, 3.66989966e-03f, -1.63933169e-02f, -6.25248775e-02f,
  -4.74444889e-02f, 2.81237904e-02f, 5.82381934e-02f, 4.54650931e-02f, 1.14426404e-01f, -2.67808903e-02f, 3.70723344e-02f, 1.02287326e-02f, 6.33476228e-02f, -4.59693260e-02f,
  -1.29349157e-01f, -3.14148590e-02f, 1.07523277e-02f, -4.71185371e-02f, -6.83650896e-02f, -5.91440052e-02f, -2.17078812e-03f, 2.88331900e-02f, -6.49700835e-02f, 2.61636879e-02f,
  -1.39057804e-02f, 4.76104803e-02f, -1.06761664e-01f, 1.14710378e-02f, -1.11086413e-01f, 1.43545622e-03f, 1.42992839e-01f, -6.76097022e-03f, -5.14672250e-02f, 1.72523204e-02f,
  2.89666384e-01f, -5.56660593e-02f, 3.05215657e-01f, 3.17672938e-01f, -8.14765133e-03f, -3.15045774e-01f, -6.47822469e-02f, 1.60554573e-02f, 1.84358601e-02f, -1.42282948e-01f,
  6.74069151e-02f, 1.40566781e-01f, -5.49608916e-02f, 1.23669885e-01f, -1.66101560e-01f, -5.03958575e-02f, -2.26334054e-02f, 2.56836899e-02f, 2.65061241e-02f, 1.53968334e-01f,
  8.51846486e-02f, -1.51965469e-01f, 1.85308710e-01f, -1.92015007e-01f, 1.49752408e-01f, 1.37178615e-01f, -2.83586755e-02f, -3.25642601e-02f, -2.82350015e-02f, -1.90641329e-01f,
  -1.00038707e-01f, 2.09369525e-01f, 1.30847376e-02f, -2.38224156e-02f, -2.41098162e-02f, -1.38806179e-01f, 1.45859197e-01f, -6.63430318e-02f, 5.33070900e-02f, 6.98628835e-03f,
  -9.31883082e-02f, 1.08262999e-02f, -2.67412458e-02f, -7.40563646e-02f, -3.10069472e-02f, 6.01077899e-02f, -1.81695018e-02f, -2.00892426e-02f, 5.06549589e-02f, 8.62027556e-02f,
  1.39720753e-01f, -6.50532246e-02f, 1.13060914e-01f, -1.65040568e-02f, 9.11761224e-02f, -8.53323266e-02f, 4.85485457e-02f, -5.75633124e-02f, 4.00808379e-02f, -4.26014028e-02f,
  1.05915442e-01f, -1.24373630e-01f, 6.19524010e-02f, -6.73648641e-02f, 8.50820355e-03f, 6.50225729e-02f, -3.00611239e-02f, 3.64057273e-02f, -1.27571374e-01f, -3.56041989e-03f,
  -1.03973389e-01f, -1.57894846e-02f, -3.89471613e-02f, 1.76779721e-02f, -2.66262032e-02f, 3.95847484e-02f, -4.36265431e-02f, -4.70064357e-02f, 2.18881387e-02f, 1.34222806e-01f,
  8.38667527e-02f, -1.20715491e-01f, 1.65548529e-02f, -4.00773808e-02f, 6.35688752e-02f, -3.01381536e-02f, 1.03596821e-01f, 1.17738537e-01f, 1.11943126e-01f, -4.60206792e-02f,
  -2.70965010e-01f, -6.06306717e-02f, -8.05391371e-02f, -1.27696827e-01f, -8.91652778e-02f, -5.57390749e-02f, 6.62932768e-02f, -3.74574810e-02f, -2.40313150e-02f, 3.85180954e-03f,
  -1.44445643e-01f, 4.86035645e-02f, -5.48326299e-02f, -3.95615771e-02f, -1.23715796e-01f, 3.63069624e-02f, -4.32771035e-02f, -1.14661366e-01f, -2.34435927e-02f, -3.66792530e-02f,
  3.42678018e-02f, -2.04910268e-03f, -2.25664154e-02f, 2.98573151e-02f, -4.73398864e-02f, -8.14278722e-02f, 1.54992074e-01f, -5.04110605e-02f, 1.15050236e-02f, -1.05529644e-01f,
  2.70271242e-01f, 2.16175646e-01f, -4.36840653e-02f, -1.13895321e-02f, -8.81767347e-02f, 3.68685946e-02f, -1.30341932e-01f, -8.73507112e-02f, -8.32208320e-02f, 6.49804249e-02f,
  -2.00833470e-01f, 2.44865075e-01f, -1.17959529e-01f, 1.65028572e-01f, 1.28112450e-01f, -6.28270805e-02f, 2.11228296e-01f, 7.24768341e-02f, -1.16120456e-02f, 1.40001550e-01f,
  6.30134121e-02f, 2.14868173e-01f, -9.98295844e-02f, -3.42094563e-02f, 5.20275868e-02f, -1.59978986e-01f, -4.92983758e-02f, -2.24014983e-01f, 2.20929179e-02f, 9.50792804e-02f,
  7.07888603e-03f, 3.40502299e-02f, -1.92436595e-02f, 4.23999317e-02f, 1.57706477e-02f, 1.93212014e-02f, -4.36682105e-02f, 2.08804291e-02f, -1.28671462e-02f, 5.60741052e-02f,
  1.39375275e-03f, 5.74655570e-02f, 7.54254684e-02f, 1.42512666e-02f, 8.44703913e-02f, 4.07937076e-03f, 2.35364512e-02f, -1.41989309e-02f, 9.15463865e-02f, 3.21616195e-02f,
  -1.28536820e-01f, 5.62625006e-02f, 3.56779471e-02f, 6.81206211e-02f, 3.23851481e-02f, 4.64550499e-03f, 1.53106362e-01f, 4.17426266e-02f, 9.44381505e-02f, 6.42014593e-02f,
  1.11685246e-01f, 5.87724261e-02f, 2.27561221e-02f, 1.14720846e-02f, -4.52985130e-02f, -8.18865001e-02f, 2.65107304e-02f, -4.30427380e-02f, 9.72993672e-02f, -9.48790088e-03f,
  -6.92274421e-02f, -4.18009907e-02f, 2.35349666e-02f, 4.94967960e-02f, 1.21392064e-01f, 9.14020985e-02f, 6.12932481e-02f, 1.75579898e-02f, -2.13725567e-02f, -8.53589997e-02f,
  4.02054824e-02f, 5.77967577e-02f, -5.63896857e-02f, -4.54232730e-02f, -8.55127648e-02f, 2.60874256e-03f, 1.41592801e-01f, -3.72049073e-03f, -2.88161784e-01f, 2.50416845e-02f,
  8.60524271e-03f, 3.37783873e-01f, 1.99021846e-02f, -9.72637255e-03f, 1.69229954e-02f, 1.01149440e-01f, 8.84204805e-02f, 1.00492150e-01f, 1.09865047e-01f, 1.09581560e-01f,
  4.76642027e-02f, -2.23299842e-02f, 4.65105027e-02f, -4.54272442e-02f, 1.70096569e-03f, 1.16911903e-01f, 9.06054303e-02f, -2.14874148e-02f, -3.80107947e-02f, 4.91906814e-02f,
  -8.58976096e-02f, 4.67890464e-02f, 1.48361564e-01f, 5.85739128e-02f, 7.52810687e-02f, 1.43798172e-01f, 1.08982353e-02f, 9.81377531e-03f, 4.24301066e-02f, 6.41862974e-02f,
  -2.74648607e-01f, 3.51525359e-02f, 1.49619758e-01f, -1.09581225e-01f, 1.17709078e-01f, 1.94891274e-01f, -7.13646486e-02f, -1.06603382e-02f, -7.72085711e-02f, -4.84337322e-02f,
  -1.71203747e-01f, -1.58898354e-01f, -8.26959610e-02f, -4.77652736e-02f, 9.92733762e-02f, 7.43616447e-02f, -4.26263958e-02f, -1.66570395e-01f, 3.64270359e-02f, -1.16475806e-01f,
  2.80975457e-02f, -8.97865742e-03f, 2.02653840e-01f, 2.19679788e-01f, 5.22458218e-02f, -5.65702952e-02f, -8.13774839e-02f, 1.81381032e-02f, 9.45203155e-02f, 1.29225314e-01f,
  -1.17422543e-01f, -2.50826478e-01f, -1.80245295e-01f, 3.58511582e-02f, 3.82678621e-02f, -2.76382208e-01f, -8.92622571e-04f, 2.41538063e-02f, -1.15282133e-01f, -1.33310765e-01f,
  -5.82308657e-02f, 1.81404930e-02f, 2.48115472e-02f, -7.76063204e-02f, 5.65944351e-02f, 8.17588046e-02f, 1.69529557e-01f, 2.60146279e-02f, 5.34735881e-02f, 7.14231730e-02f,
  1.59286559e-02f, 1.47012658e-02f, 8.08531195e-02f, 1.01555213e-01f, 7.41290152e-02f, 1.56439990e-01f, 2.95450371e-02f, -1.29558204e-03f, 1.30006537e-01f, 1.07502192e-01f,
  1.94737513e-03f, -7.76220709e-02f, 1.06952712e-01f, -3.24418880e-02f, -1.96133871e-02f, -6.59719994e-03f, -9.82545130e-03f, -7.59240100e-03f, 6.94736317e-02f, 1.02616541e-01f,
  2.60995012e-02f, 4.73269597e-02f, 1.95189361e-02f, 2.94769853e-02f, 1.74202910e-03f, 5.38841449e-03f, 1.50017980e-02f, -5.28243370e-02f, 1.26758069e-01f, -2.41923220e-02f,
  -5.66251166e-02f, 4.43021134e-02f, 3.76281403e-02f, 4.61198436e-03f, -7.53769428e-02f, 1.41983656e-02f, 3.09771579e-02f, 7.77725726e-02f, 3.12516629e-03f, -1.92556884e-02f,
  -2.64643610e-01f, -3.26977700e-01f, -1.96167603e-02f, 6.77944422e-02f, -9.77454707e-02f, -1.35099918e-01f, -6.65055737e-02f, 4.36644070e-02f, -1.14617996e-01f, -3.25755626e-02f,
  -2.35652104e-02f, 3.98271568e-02f, -2.73274048e-03f, -5.72680496e-02f, 8.03702772e-02f, 2.10904125e-02f, -8.32439512e-02f, -5.27972355e-02f, -9.48482752e-02f, 5.49994931e-02f,
  5.22028375e-03f, -7.49955773e-02f, 1.23632647e-01f, 8.13204795e-02f, 7.40445703e-02f, 9.06127021e-02f, -8.18373635e-02f, -3.21159475e-02f, 7.18420669e-02f, -6.08281344e-02f,
  -1.49926752e-01f, -8.23103338e-02f, -1.78836331e-01f, -2.51736850e-01f, 1.40053574e-02f, -1.73435062e-01f, -2.16336861e-01f, -1.14295460e-01f, -1.09960556e-01f, 9.27565172e-02f,
  -4.64095511e-02f, -1.67715922e-01f, 5.82642220e-02f, -4.40354437e-01f, -4.20637190e-01f, -1.64744869e-01f, -3.20225447e-01f, -2.03465819e-01f, -6.77140877e-02f, -9.48494598e-02f,
  -5.93355112e-02f, -2.59582460e-01f, -2.34490350e-01f, 1.06294118e-01f, -1.65871918e-01f, 7.74405226e-02f, 2.05060869e-01f, 1.16666399e-01f, -2.05397364e-02f, -3.52813005e-02f,
  -7.88247213e-02f, -1.48330266e-02f, -2.99751610e-02f, -9.88781005e-02f, -1.08063612e-02f, 5.94156384e-02f, 3.81417386e-02f, -9.08272788e-02f, 2.86712237e-02f, -7.16565251e-02f,
  -6.75209612e-02f, -3.44930217e-02f, -1.75098907e-02f, 8.10169876e-02f, 3.06459535e-02f, 2.35570781e-02f, -1.32863775e-01f, 5.80711029e-02f, -6.46965429e-02f, -9.74780396e-02f,
  -7.55919144e-02f, 9.41983610e-03f, 7.30944648e-02f, 4.09022905e-02f, -2.86689531e-02f, -1.74679980e-03f, 5.70219941e-02f, 1.09298751e-01f, -6.60213307e-02f, 4.72407155e-02f,
  4.77786995e-02f, 1.69555575e-01f, -3.50728743e-02f, -4.88522984e-02f, 2.03522593e-02f, 4.73988727e-02f, 3.74127529e-03f, -3.82506326e-02f, 4.66593355e-02f, 3.50662246e-02f,
  4.21374701e-02f, -1.10781528e-01f, 5.51699568e-03f, 3.82318385e-02f, -5.79492077e-02f, 6.34187609e-02f, -3.33627537e-02f, -1.45359244e-03f, -1.01541832e-01f, -5.13792075e-02f,
  6.33287281e-02f, 4.01302129e-02f, 6.77080452e-02f, 8.47325996e-02f, -9.49290320e-02f, 5.95921837e-02f, 7.36927539e-02f, -4.75969501e-02f, 7.20070601e-02f, 4.88496535e-02f,
  2.31007561e-02f, 6.32949620e-02f, -8.02586526e-02f, -7.61434883e-02f, -6.01064339e-02f, -4.59765047e-02f, -9.03774351e-02f, -4.40012887e-02f, -7.50779137e-02f, 4.46658442e-03f,
  2.41558105e-02f, 3.41322720e-02f, 2.14073539e-01f, 6.11136369e-02f, 4.23225015e-02f, 1.21306907e-02f, -8.23837519e-02f, 6.46172538e-02f, 2.20347457e-02f, 1.75581425e-02f,
  8.65820721e-02f, 4.02554609e-02f, 2.05610134e-02f, -9.67971794e-03f, -1.09734386e-03f, 2.42452789e-02f, 1.07992418e-01f, -9.49738547e-03f, 1.92065202e-02f, 6.97174855e-03f,
  -4.84510273e-01f, 1.65342778e-01f, 1.85250804e-01f, 1.12624869e-01f, -1.66846588e-01f, 3.64065498e-01f, 4.91394699e-01f, -6.13004267e-02f, 2.60444880e-01f, 2.36651704e-01f,
  -3.77912708e-02f, 1.69895187e-01f, 1.25585273e-01f, 1.39572874e-01f, 2.08941519e-01f, 2.61978596e-01f, 1.90119565e-01f, 1.99486181e-01f, -1.09714709e-01f, -2.41346881e-02f,
  -5.54677623e-04f, -1.15711754e-02f, -5.02080508e-02f, -2.22557440e-01f, -2.10658908e-01f, -2.82679856e-01f, -7.93491006e-02f, 2.64222808e-02f, 3.38635258e-02f, 7.59856552e-02f,
  -8.79922882e-02f, -1.98791832e-01f, -1.59480482e-01f, -2.29968019e-02f, -1.01712048e-01f, 3.01490985e-02f, -3.26122828e-02f, 4.41442020e-02f, -4.91773337e-02f, 5.23067713e-02f,
  -5.39946416e-03f, -1.03941068e-01f, -1.96435750e-02f, 1.04077347e-01f, 9.35984701e-02f, 1.58956572e-02f, 3.35399695e-02f, -1.09598273e-02f, 3.35304923e-02f, -6.54744580e-02f,
  -8.18699822e-02f, 1.68243926e-02f, 2.71768402e-02f, 1.26141496e-02f, -7.09770545e-02f, -5.84991835e-02f, 1.39057800e-01f, 8.46962258e-03f, -2.17514113e-02f, 2.32790094e-02f,
  5.57077192e-02f, 7.04444051e-02f, -6.32394776e-02f, 4.85665053e-02f, 8.61815214e-02f, -7.09255636e-02f, 6.69489726e-02f, -8.07898212e-03f, 5.94154513e-03f, -4.21659872e-02f,
  4.40155193e-02f, -8.19250494e-02f, -1.43142223e-01f, 9.98536050e-02f, -2.54499186e-02f, 3.36146802e-02f, 3.47670577e-02f, -1.31347910e-01f, -8.39036703e-03f, 7.64447972e-02f,
  7.28037432e-02f, -2.35946756e-02f, -9.56515130e-03f, 5.33093065e-02f, -1.54792133e-03f, 1.16378225e-01f, -4.89552915e-02f, -5.89579009e-02f, -5.83624244e-02f, 6.91225054e-03f,
  1.60525545e-01f, 1.99200198e-01f, -5.32333702e-02f, -9.74101722e-02f, 2.06584129e-02f, -4.06485759e-02f, 1.56254750e-02f, -5.45122102e-02f, 9.84961540e-02f, 5.26529104e-02f,
  1.13662314e-02f, 1.61156990e-02f, -6.15956448e-02f, -1.48247946e-02f, 1.18426442e-01f, 3.29674557e-02f, 1.30082015e-02f, 5.43066822e-02f, 6.56433254e-02f, -2.19016317e-02f,
  -3.32071371e-02f, -5.59991933e-02f, 8.07984397e-02f, -5.30750975e-02f, 4.91664419e-03f, 3.35842520e-02f, -4.05380949e-02f, -2.52996422e-02f, -3.14875916e-02f, 6.87409490e-02f,
  -1.19976038e-02f, 7.58891255e-02f, -9.77892503e-02f, 7.18421936e-02f, 3.06881778e-02f, 2.71041036e-01f, 2.49519393e-01f, 2.64261961e-02f, 8.51160139e-02f, 2.95567751e-01f,
  1.25678569e-01f, 6.47476763e-02f, -5.56662865e-03f, 1.93044201e-01f, -3.03304672e-01f, 2.04006713e-02f, 2.13558391e-01f, 3.44082534e-01f, -1.80087462e-02f, 9.20510888e-02f,
  -2.65921699e-03f, 8.73040035e-02f, -1.66394591e-01f, -5.90484999e-02f, 9.54645425e-02f, -8.32182392e-02f, -1.16799943e-01f, -2.02359617e-01f, 8.30644667e-02f, -6.86073080e-02f,
  -9.74467676e-03f, 4.95868698e-02f, 5.74293882e-02f, 2.33876575e-02f, 6.01429306e-02f, 1.59109190e-01f, 3.37408446e-02f, -4.30051945e-02f, -1.58098921e-01f, 2.38826834e-02f,
  9.55410972e-02f, -2.96330382e-03f, 8.72212648e-02f, -1.41775250e-01f, -1.60747189e-02f, 1.32209351e-02f, -4.14467556e-03f, 3.14736180e-02f, -1.34185161e-02f, -2.35038865e-02f,
  1.09646149e-01f, 2.23116875e-02f, 5.48055880e-02f, -6.19725809e-02f, -2.12614145e-03f, 1.70512907e-02f, 5.82447536e-02f, -1.25544414e-01f, 1.73207354e-02f, -7.75087923e-02f,
  -1.21559603e-02f, 1.94198396e-02f, 3.28675769e-02f, 2.40124762e-02f, -5.92004396e-02f, 1.68447830e-02f, 4.37880754e-02f, -2.25776620e-02f, -5.53247519e-02f, -1.60883218e-02f,
  -7.02208802e-02f, 1.41710863e-02f, -1.92935653e-02f, -4.34608199e-02f, -1.60458591e-02f, -6.24833209e-03f, -8.01582932e-02f, -4.49381955e-02f, 5.91969453e-02f, -8.29997007e-03f,
  4.49719802e-02f, 3.52133512e-02f, 1.33389132e-02f, 3.62690352e-02f, 1.94157846e-02f, -4.11797836e-02f, 2.53447555e-02f, -1.01899486e-02f, 1.40340542e-02f, -1.29541913e-02f,
  1.09065920e-01f, 5.62734790e-02f, 4.88679335e-02f, -5.64559251e-02f, -6.49101064e-02f, 1.32698342e-02f, 4.85440493e-02f, -1.78465119e-03f, -2.66408045e-02f, 1.38262948e-02f,
  3.43625471e-02f, 1.14021100e-01f, 2.53378227e-02f, -1.32157311e-01f, -6.62519708e-02f, 1.82394926e-02f, 1.16117693e-01f, -2.61990540e-02f, -9.02951807e-02f, -7.39627331e-02f,
  9.50262323e-02f, 1.40261799e-01f, 5.95058277e-02f, 7.77054653e-02f, 1.76856704e-02f, -2.53414828e-03f, 4.53074425e-02f, -7.44017065e-02f, 6.07689545e-02f, 2.78800931e-02f,
  1.19762838e-01f, -1.91586867e-01f, 1.43211961e-01f, 4.64562953e-01f, 1.86993778e-01f, -3.27671826e-01f, -4.55828570e-02f, 9.98115540e-02f, 3.70294392e-01f, -4.25104231e-01f,
  -5.95663190e-02f, -2.09555328e-01f, -2.97420710e-01f, 1.86991632e-01f, 1.27554879e-01f, -2.24414557e-01f, 2.13136747e-01f, -1.28108874e-01f, 6.78523257e-02f, 3.59880291e-02f,
  8.22496563e-02f, -5.74221043e-03f, 1.05260141e-01f, 2.59020086e-02f, 7.99915288e-03f, 9.73865539e-02f, 5.15444726e-02f, -3.44530828e-02f, 1.99289117e-02f, -7.87719991e-03f,
  3.67052481e-02f, 3.25047672e-02f, 1.07968189e-01f, 8.11865777e-02f, -9.44218846e-05f, -9.80298147e-02f, -7.35345557e-02f, -1.02210306e-01f, 1.38511688e-01f, -5.10457419e-02f,
  -1.14645846e-01f, -2.40983386e-02f, -2.70081535e-02f, -3.99112441e-02f, 2.38675922e-01f, 1.23126060e-01f, 1.65102750e-01f, 7.62206018e-02f, 7.19198510e-02f, -1.11240081e-01f,
  -1.55829880e-02f, 9.57817119e-03f, 1.56351238e-01f, 4.51803170e-02f, 1.68353632e-01f, 2.10621119e-01f, -2.59478968e-02f, 1.51564542e-03f, 5.19531742e-02f, 1.26757652e-01f,
  -5.33156805e-02f, 1.48271816e-03f, -4.89024147e-02f, -1.00608515e-02f, -4.58568148e-02f, -5.87637397e-03f, -3.81447487e-02f, 5.38380537e-03f, 1.15807764e-01f, -5.00466162e-03f,
  4.55793478e-02f, 1.18871011e-01f, 6.07209280e-02f, 2.02570781e-02f, -3.10872607e-02f, 7.90713355e-02f, 4.65456918e-02f, -1.51128367e-01f, 6.64821714e-02f, -2.36924980e-02f,
  -8.38605836e-02f, 8.86806920e-02f, -5.55013027e-03f, -4.85147303e-03f, 5.77471070e-02f, -9.51124914e-03f, -5.55039383e-02f, -2.65934248e-03f, 5.37227057e-02f, -1.35470899e-02f,
  5.83283231e-02f, 7.28976121e-03f, 2.52523320e-03f, 2.05948930e-02f, 3.94856557e-02f, 3.39067504e-02f, -5.42853735e-02f, 4.69848467e-03f, 6.35597706e-02f, -9.89688709e-02f,
  6.77380860e-02f, 7.49426261e-02f, 9.34987329e-03f, 2.01628208e-02f, 5.52213937e-02f, -1.51057187e-02f, -1.21856019e-01f, 5.57239577e-02f, 1.78971782e-01f, -2.98608243e-02f,
  -8.84455219e-02f, -7.30393529e-02f, 1.14433333e-01f, 6.82672337e-02f, 2.94281952e-02f, 3.63776162e-02f, -1.49463624e-01f, 1.38684437e-01f, 5.21182502e-03f, 3.22718248e-02f,
  -9.94574372e-03f, -2.96314031e-01f, -1.13979243e-01f, 2.12885618e-01f, 1.20963678e-01f, 5.31422347e-02f, -3.66726965e-02f, 6.41604438e-02f, 6.19079992e-02f, -1.81490690e-01f,
  6.32463396e-02f, -1.72005057e-01f, -2.85507411e-01f, 1.47541612e-01f, 2.09968016e-01f, -2.20894471e-01f, 2.36837998e-01f, 7.98095539e-02f, 1.52153643e-02f, -1.62147656e-01f,
  7.95331202e-04f, 2.23699912e-01f, -6.83253184e-02f, 7.18957633e-02f, 1.35855824e-02f, -5.20454608e-02f, 4.73657101e-02f, -1.39153212e-01f, 1.72225296e-01f, 8.76060594e-03f,
  7.64790326e-02f, -1.23519987e-01f, 1.05812296e-03f, 4.37451527e-02f, -7.26379529e-02f, -2.20732912e-02f, 7.09018782e-02f, -4.17731218e-02f, 8.97280052e-02f, -3.73224691e-02f,
  -2.89244056e-02f, 5.05069532e-02f, 9.48072895e-02f, 6.44612685e-02f, 7.54831778e-03f, 1.29390702e-01f, 7.18730967e-03f, 4.64183688e-02f, 2.44204942e-02f, -1.28518537e-01f,
  -8.49029869e-02f, -9.75888409e-03f, 2.89806984e-02f, 4.71079461e-02f, -4.61320058e-02f, -4.03254330e-02f, -2.37519033e-02f, -1.24264389e-01f, 9.49910954e-02f, -7.60600343e-02f,
  -2.70467177e-02f, -1.50796279e-01f, -9.03089121e-02f, -3.10894977e-02f, 7.44660273e-02f, 7.56832361e-02f, 1.74258314e-02f, 1.86607838e-02f, -4.91657220e-02f, 2.01120023e-02f,
  6.08359557e-03f, 3.31090949e-03f, 2.88285278e-02f, 6.11053891e-02f, -1.41640976e-02f, -1.19434884e-02f, -6.07989952e-02f, 8.27547684e-02f, 5.07358694e-03f, 6.35131598e-02f,
  8.85869041e-02f, -5.98426685e-02f, -3.39239798e-02f, -1.63202044e-02f, 6.63772300e-02f, -7.24003240e-02f, 1.13236941e-02f, 5.00979871e-02f, -3.92118692e-02f, -9.50465649e-02f,
  -1.73361041e-02f, -1.94444671e-01f, -6.68447763e-02f, 6.96496591e-02f, -7.81660201e-04f, 3.33313993e-03f, 8.42803046e-02f, -3.55455205e-02f, 6.10724203e-02f, -8.55725184e-02f,
  -5.74701503e-02f, 2.08202880e-02f, 3.87510061e-02f, 1.31781802e-01f, 3.12628411e-02f, -1.01907067e-01f, -8.56914669e-02f, 2.08024252e-02f, 1.50718123e-01f, 2.48122923e-02f,
  -1.01989862e-02f, 6.69323206e-02f, -1.03220278e-02f, -3.97707894e-03f, 3.52976732e-02f, -1.29505068e-01f, 7.52944499e-02f, -1.17466994e-01f, -7.70631013e-03f, 1.19127342e-02f,
  2.01136470e-01f, -1.75087154e-01f, -3.96319687e-01f, -2.50860423e-01f, 6.96686357e-02f, 2.14723185e-01f, -1.52165875e-01f, -1.51836589e-01f, -2.98086017e-01f, -1.53198922e-02f,
  8.12001824e-02f, -1.00815818e-02f, -2.95967489e-01f, 2.04113990e-01f, 1.93036690e-01f, -5.20645641e-02f, 1.54034883e-01f, 1.92363575e-01f, 8.19485188e-02f, -1.69833496e-01f,
  8.57066661e-02f, 2.91475326e-01f, -7.96887055e-02f, 2.34910771e-01f, 1.11708313e-01f, -9.35571734e-03f, 9.18955058e-02f, -3.62995416e-02f, 2.26502299e-01f, 1.67332590e-01f,
  5.25949849e-03f, -4.10578363e-02f, -8.66055191e-02f, -5.81586407e-03f, -5.81641570e-02f, 1.84941143e-02f, 1.23296723e-01f, 8.59177336e-02f, -9.52603482e-03f, -9.01678503e-02f,
  3.11342441e-02f, 2.11895090e-02f, 6.77946135e-02f, 3.06056235e-02f, -3.82493064e-02f, 1.84838250e-02f, -6.24715947e-02f, -3.65950018e-02f, -1.78112969e-01f, 3.79329026e-02f,
  -1.68240130e-01f, -1.45982429e-02f, 1.91426687e-02f, -9.15860683e-02f, -1.69572309e-01f, -5.88895148e-03f, -9.52137113e-02f, -9.51779336e-02f, 7.17821643e-02f, -6.63859993e-02f,
  4.05903254e-03f, 8.68950635e-02f, 8.38372577e-03f, -5.57619184e-02f, -6.70303926e-02f, -3.67863402e-02f, 1.68873340e-01f, -1.14973029e-02f, -7.62522891e-02f, -4.29769456e-02f,
  -1.53608188e-01f, -6.88200891e-02f, 3.85784060e-02f, -6.76947683e-02f, 4.22508493e-02f, 1.35219425e-01f, 1.22800479e-02f, -1.41155710e-02f, -2.05189690e-01f, -9.84720793e-03f,
  1.33896157e-01f, 5.54917147e-03f, -4.78380546e-02f, 2.99525969e-02f, 5.67656420e-02f, -1.29027396e-01f, 3.50636034e-03f, -2.12515779e-02f, -9.24663544e-02f, 1.02726724e-02f,
  -1.69400275e-02f, -1.34374112e-01f, -1.16298936e-01f, 1.31672118e-02f, -8.50417614e-02f, -5.12714200e-02f, 7.71936700e-02f, 2.04562768e-02f, -4.44548465e-02f, -6.14126101e-02f,
  -5.35787605e-02f, 1.51584214e-02f, 4.40883934e-02f, -1.01686522e-01f, -4.88350801e-02f, -5.20830341e-02f, 1.23240752e-03f, -2.48355791e-02f, -1.68187231e-01f, -4.49756905e-03f,
  -9.46235731e-02f, -3.42256390e-02f, 3.65330046e-03f, -5.92577308e-02f, -2.77589336e-02f, -4.77771275e-02f, 3.14754173e-02f, 7.68436305e-03f, 1.06069453e-01f, -1.18086852e-01f,
  -1.50081376e-02f, -3.56811255e-01f, 5.48287220e-02f, -7.45389909e-02f, -1.09291011e-02f, -2.10413337e-01f, -5.93211874e-02f, -1.94528475e-01f, -1.05426125e-01f, -2.86165744e-01f,
  -9.71334204e-02f, 1.23764731e-01f, 8.33848789e-02f, -1.53364614e-01f, 4.32598084e-01f, 1.83943942e-01f, -7.31248185e-02f, -5.33799417e-02f, -8.69268610e-04f, -1.42758325e-01f,
  6.99152127e-02f, -8.91441330e-02f, 2.08287481e-02f, -2.94580907e-01f, -2.88247466e-01f, -1.27942100e-01f, 6.45236894e-02f, 9.24502760e-02f, -2.25556031e-01f, 1.05609067e-01f,
  -1.62408233e-01f, -2.49026313e-01f, -1.78413123e-01f, -7.83825219e-02f, -1.26073077e-01f, -1.74792372e-02f, 2.99207252e-02f, 1.95837349e-01f, -6.40465692e-02f, -7.12072626e-02f,
  6.52058572e-02f, 6.91929981e-02f, -2.93532200e-02f, 2.43767221e-02f, -4.18596528e-02f, -7.65167698e-02f, -1.67939812e-02f, -6.92454651e-02f, -1.85759980e-02f, 4.45250645e-02f,
  8.09079856e-02f, -5.86501285e-02f, -3.73218507e-02f, -1.15804961e-02f, 4.49970923e-02f, -7.68976733e-02f, 9.79541466e-02f, 1.92757130e-01f, 1.27430167e-02f, 8.01471174e-02f,
  4.27582003e-02f, -3.03241201e-02f, -1.08424045e-01f, -1.46787763e-02f, -6.04051054e-02f, 1.06208185e-02f, -2.47582123e-02f, -5.70762083e-02f, -3.22886705e-02f, -3.15490253e-02f,
  -8.77853408e-02f, 9.38930269e-03f, -3.21066529e-02f, -1.27011880e-01f, -2.24956423e-02f, -1.51413068e-01f, -5.01953438e-02f, -3.71106528e-02f, 9.24528344e-04f, 3.64911519e-02f,
  5.71016632e-02f, 6.97024073e-03f, -3.05400230e-02f, 8.25894699e-02f, -1.26447412e-04f, 5.98765761e-02f, -2.98662297e-02f, -5.17021827e-02f, -1.65734757e-02f, 5.24651026e-03f,
  -1.74519435e-01f, -2.16355532e-01f, -3.03655602e-02f, -6.95683211e-02f, 4.19587269e-02f, -1.88485663e-02f, -5.27073592e-02f, -2.85279695e-02f, -9.93471220e-02f, 1.73788723e-02f,
  -1.23359539e-01f, 2.07302328e-02f, 4.02353704e-02f, 1.03876807e-01f, 7.57763674e-03f, 1.79491527e-02f, 3.87359895e-02f, 7.81170651e-02f, 2.43577287e-02f, 3.29127647e-02f,
  4.79831509e-02f, -4.97274622e-02f, 9.98166353e-02f, -1.28474459e-01f, -6.46165013e-02f, -3.52754034e-02f, 7.27554858e-02f, -7.24393502e-02f, 4.13136967e-02f, 3.47587503e-02f,
  -1.58535495e-01f, 8.00065175e-02f, -1.85977235e-01f, -2.77323633e-01f, 8.05604085e-02f, -1.81099668e-01f, -8.35797936e-02f, 1.36058077e-01f, 1.53157458e-01f, 1.16689123e-01f,
  -2.09810026e-02f, -2.30354443e-02f, 2.18758747e-01f, -1.89029574e-01f, -2.66493410e-01f, 9.77671891e-02f, -3.87668729e-01f, -1.42261192e-01f, 5.96442409e-02f, -2.15884671e-01f,
  -5.86290509e-02f, -5.74275255e-02f, -4.48075049e-02f, 1.95833117e-01f, -5.49473092e-02f, 5.07738292e-02f, 4.27274667e-02f, 1.20502830e-01f, -1.25095338e-01f, 1.54156491e-01f,
  -9.21950489e-02f, 1.99847311e-01f, 4.06732708e-02f, 5.41067831e-02f, -5.31580895e-02f, -8.98529813e-02f, -6.65138885e-02f, 4.80778404e-02f, 2.77982443e-03f, -4.69207205e-02f,
  -7.81771988e-02f, 2.46399511e-02f, -1.05424039e-02f, 7.47832730e-02f, 5.32215573e-02f, 5.59273809e-02f, 2.93504782e-02f, -5.44196554e-02f, -2.62640591e-04f, 5.26973493e-02f,
  4.97605056e-02f, -4.69633341e-02f, -3.19586955e-02f, 9.48042348e-02f, 8.01662635e-03f, -3.28418761e-02f, -6.48409724e-02f, -5.54442033e-02f, -1.69097129e-02f, 5.47153279e-02f,
  -8.47339723e-03f, -3.81396115e-02f, -2.71039773e-02f, 1.23449797e-02f, 1.23429531e-02f, 2.81587504e-02f, 1.34124070e-01f, 4.55677100e-02f, -4.35987301e-02f, -7.12094307e-02f,
  -7.82113075e-02f, -9.54780281e-02f, -2.68938802e-02f, -1.09442897e-01f, -8.58994648e-02f, -1.44527992e-02f, -2.52885520e-02f, 1.22436397e-01f, -1.63663477e-01f, 7.82487076e-03f,
  1.32244155e-01f, -1.37544081e-01f, 7.60658234e-02f, -1.24971069e-01f, 8.18945393e-02f, 7.68766403e-02f, -8.06468576e-02f, 3.12633961e-02f, -1.99025869e-02f, -1.56189322e-01f,
  -1.15688570e-01f, 3.01814042e-02f, 4.25585620e-02f, -5.27742840e-02f, 2.68602613e-02f, -1.13444664e-01f, 2.07650810e-02f, 2.36416403e-02f, 2.36200970e-02f, 1.94358341e-02f,
  -1.18460365e-01f, -9.39145237e-02f, -3.82411033e-02f, -4.20692451e-02f, -4.68242131e-02f, -1.58036321e-01f, -7.82002881e-02f, -3.56851853e-02f, -9.23566893e-03f, -3.57116908e-02f,
  4.08679321e-02f, 1.35445024e-03f, -7.25965872e-02f, 6.65976927e-02f, 5.38114458e-02f, -6.46778801e-03f, 8.61977562e-02f, 3.12664919e-02f, 4.20606993e-02f, -1.76248085e-02f,
  3.53102624e-01f, 1.05734043e-01f, 1.43312469e-01f, 1.52548805e-01f, -9.96480212e-02f, -2.33220458e-01f, -2.44157627e-01f, -1.24845266e-01f, -8.60153511e-02f, -7.93768540e-02f,
  -9.68040451e-02f, 3.58021855e-01f, -2.19065510e-02f, -1.10868491e-01f, -1.37933359e-01f, -9.29881930e-02f, -9.41059068e-02f, 9.67842191e-02f, -4.33091745e-02f, -1.12811483e-01f,
  -6.66959584e-02f, -3.01039726e-01f, 1.12926416e-01f, -2.72735745e-01f, -5.88103198e-02f, 1.26774520e-01f, -8.22468027e-02f, -3.13824229e-02f, -1.07443139e-01f, -2.53817569e-02f,
  -1.48517108e-02f, -7.48806372e-02f, 6.55611828e-02f, -3.92993167e-03f, -1.75848734e-02f, -4.87164408e-03f, 8.39814022e-02f, -2.34710164e-02f, 7.91269019e-02f, -3.56083550e-02f,
  -4.79633734e-03f, -1.25961183e-02f, -7.37686679e-02f, -3.14587988e-02f, 3.03197652e-02f, 2.28443742e-02f, -6.26073256e-02f, 6.63686469e-02f, 9.38786007e-03f, 1.13179326e-01f,
  2.83675641e-02f, 1.38983279e-01f, 9.02845114e-02f, 1.09541126e-01f, 7.54472464e-02f, 3.27428840e-02f, 2.01932844e-02f, 2.15301767e-01f, 8.37579146e-02f, 2.78869551e-02f,
  1.26810789e-01f, -7.73750842e-02f, -4.12460491e-02f, -2.41673663e-02f, -6.79721236e-02f, -2.98530366e-02f, -8.20877030e-02f, 6.74654096e-02f, -1.47832066e-01f, -7.48492405e-02f,
  -8.74601584e-03f, 8.37941021e-02f, -6.93389699e-02f, -1.62957340e-01f, -3.52263823e-02f, -1.00588994e-02f, -4.12943885e-02f, 8.21193606e-02f, -6.98051602e-02f, 1.77717227e-02f,
  -3.90980355e-02f, 1.30453948e-02f, 5.87590560e-02f, 6.77640885e-02f, -4.84820232e-02f, 1.51247019e-03f, -5.30298688e-02f, 1.26456335e-01f, 3.72667424e-03f, 9.61028785e-03f,
  -2.13948146e-01f, -3.19292814e-01f, -3.59467305e-02f, 3.12145092e-02f, 1.25531238e-02f, 5.10020601e-03f, -7.43477792e-02f, -2.13715676e-02f, 2.11476721e-03f, -1.68967396e-01f,
  -1.74443439e-01f, 4.86808755e-02f, -2.44144704e-02f, 4.04153839e-02f, 1.43052610e-02f, 2.30869073e-02f, -2.07118993e-03f, -1.96141633e-03f, 1.07728250e-01f, 5.52600399e-02f,
  4.61908407e-04f, 5.61429821e-02f, 7.07085105e-03f, 1.11575127e-02f, -2.35694535e-02f, 3.44277136e-02f, 3.18352468e-02f, 1.21563114e-01f, -5.92684431e-04f, -7.14344382e-02f,
  -6.63647413e-01f, 2.64555216e-01f, 2.67362416e-01f, -3.93413335e-01f, 1.29697010e-01f, 2.67596424e-01f, -2.46325120e-01f, 1.14851534e-01f, -1.48904985e-02f, -1.04838736e-01f,
  3.52973603e-02f, -1.35357782e-01f, 1.51995271e-01f, -2.31911898e-01f, -3.07680275e-02f, 5.42152449e-02f, -2.28549019e-01f, -1.77238882e-01f, 4.64810207e-02f, -1.98632985e-01f,
  -1.00094728e-01f, -1.04962356e-01f, -2.69263219e-02f, 2.45958254e-01f, -5.77317737e-03f, -1.48002192e-01f, -1.27945304e-01f, 1.71652824e-01f, -2.25787368e-02f, 1.17363304e-01f,
  -2.15173692e-01f, -3.02726448e-01f, -7.01959208e-02f, 8.53350908e-02f, -7.47934356e-03f, -8.15476477e-02f, -8.42182934e-02f, -7.48115256e-02f, -6.66937679e-02f, 4.03532237e-02f,
  -1.42926639e-02f, 5.72563298e-02f, 3.01828682e-02f, 4.79686595e-02f, 1.92239508e-03f, 9.16291103e-02f, -1.53122768e-02f, -6.46495745e-02f, 7.20984787e-02f, 1.20181464e-01f,
  9.28173959e-02f, 1.53646758e-02f, 1.45898862e-02f, -7.64856711e-02f, 1.26266584e-01f, -3.55574228e-02f, -2.23177448e-02f, -7.34081417e-02f, -2.45815367e-02f, -1.31738065e-02f,
  -6.68458119e-02f, -7.84586295e-02f, -6.11190088e-02f, 3.36253978e-02f, -1.47523349e-02f, 9.65782478e-02f, 7.52493069e-02f, -1.31255668e-02f, -1.35817714e-02f, -6.73244372e-02f,
  -1.02447994e-01f, -4.67208251e-02f, 8.98803249e-02f, -3.92632447e-02f, 1.94954546e-03f, 1.93304066e-02f, -1.36427984e-01f, -4.67244126e-02f, 6.28336146e-02f, -7.08775297e-02f,
  5.86627610e-02f, 8.02019536e-02f, -3.77789028e-02f, -1.06629767e-02f, -3.95103171e-02f, -7.14341318e-03f, 6.68786243e-02f, -2.31382363e-02f, -2.80086398e-02f, -5.81619591e-02f,
  -3.18600148e-01f, -3.50507468e-01f, -1.08174145e-01f, 6.49121776e-02f, -3.65738086e-02f, 2.83246711e-02f, -8.77247974e-02f, 8.89829919e-02f, 1.84885096e-02f, -1.82059929e-02f,
  -4.86663617e-02f, -6.45043477e-02f, 1.07227191e-01f, -2.17486471e-02f, -8.53668153e-03f, -3.44275497e-03f, -1.28613681e-01f, -1.38867095e-01f, -1.74063668e-01f, -1.31280841e-02f,
  -2.78170686e-02f, -1.78201403e-02f, -9.92283691e-03f, 3.20814624e-02f, 2.72978134e-02f, -3.40424590e-02f, -9.19838324e-02f, -5.09472489e-02f, -1.39243871e-01f, 2.63299840e-03f,
  -4.02578562e-01f, 2.19424397e-01f, -1.21367797e-01f, -2.64959000e-02f, -1.06751293e-01f, 3.51824164e-01f, 3.84065270e-01f, 4.81338166e-02f, 1.71716988e-01f, 3.46158564e-01f,
  2.64799237e-01f, 3.03859171e-02f, 1.76942170e-01f, 2.71663487e-01f, -1.43475935e-01f, 2.49819204e-01f, 1.89168334e-01f, 2.22126245e-01f, 1.17466711e-02f, -9.31978226e-02f,
  -4.44315933e-02f, 2.13023573e-01f, -7.59995058e-02f, 4.04471979e-02f, -6.78955168e-02f, -1.86535388e-01f, -4.33852337e-02f, -1.12424605e-01f, 1.18647292e-01f, -1.55933304e-02f,
  -8.38377886e-03f, 7.61637688e-02f, -7.88220391e-03f, 7.68466517e-02f, 5.41278301e-03f, -1.14059962e-01f, 4.65026572e-02f, 7.17697153e-03f, -9.30798203e-02f, 1.93958357e-02f,
  1.68327242e-02f, 3.31625452e-05f, 8.21128637e-02f, -7.05901757e-02f, -1.11113243e-01f, -1.57737564e-02f, -1.76493041e-02f, -3.84831689e-02f, 9.41026062e-02f, 3.95963341e-02f,
  -2.73332447e-02f, -2.75551006e-02f, -1.86522715e-02f, 8.67699087e-02f, 2.57962272e-02f, 7.42045417e-02f, 1.20189257e-01f, -1.13076143e-01f, 6.21293336e-02f, 1.22351265e-02f,
  3.20262648e-02f, 4.49460186e-02f, 5.72042391e-02f, -5.83496578e-02f, 1.40424967e-02f, 6.58426657e-02f, 2.28672707e-03f, 9.66818556e-02f, -1.13987371e-01f, -1.86943468e-02f,
  4.92777787e-02f, -8.81923456e-03f, -1.30770966e-01f, 2.96068639e-02f, -1.75967906e-02f, -4.43306975e-02f, -1.48597568e-01f, -2.22363118e-02f, 8.64407420e-03f, 4.37933113e-03f,
  6.23147972e-02f, -1.02020755e-01f, 6.23223223e-02f, 2.84663867e-02f, 7.83444643e-02f, -9.31725055e-02f, -3.11591575e-04f, 3.70869674e-02f, 8.59796554e-02f, -1.07632816e-01f,
  2.33827829e-01f, 2.06322417e-01f, 8.77348334e-02f, 4.74589355e-02f, 2.49817478e-03f, -1.25609398e-01f, 5.96580356e-02f, 2.21554451e-02f, 8.39232132e-02f, 1.85778718e-02f,
  -9.36068818e-02f, 2.86605973e-02f, -5.08995727e-02f, -1.11875601e-01f, -4.44165692e-02f, 1.19859256e-01f, 9.06552970e-02f, -3.03412378e-02f, 3.71090844e-02f, 2.57608388e-03f,
  -3.41663957e-02f, 9.64089036e-02f, -1.04897581e-02f, 1.19615823e-01f, 3.07273623e-02f, 6.00681119e-02f, -4.93452922e-02f, -8.29674006e-02f, 3.45674604e-02f, 3.28436941e-02f,
  -3.16496402e-01f, -4.06631678e-02f, -6.17716946e-02f, 8.45065266e-02f, -1.10639095e-01f, -1.58997744e-01f, -3.99327427e-02f, -3.21085304e-01f, -5.27608842e-02f, 1.50028780e-01f,
  2.35259414e-01f, -4.20146063e-02f, 8.91836360e-03f, 2.87803620e-01f, -2.44190961e-01f, 1.06271602e-01f, -9.48182195e-02f, 1.05826683e-01f, -5.22286147e-02f, -1.03729777e-01f,
  -4.92935814e-02f, 1.46705538e-01f, -6.31268253e-04f, -1.15937935e-02f, -7.79931396e-02f, -1.00859478e-01f, 4.39069234e-02f, -6.01964854e-02f, 3.49601023e-02f, -5.17732948e-02f,
  -1.02198914e-01f, -1.34239346e-01f, 2.19445080e-02f, -8.33539143e-02f, -1.24760337e-01f, -5.68172941e-03f, -3.68209742e-03f, 1.60304867e-02f, 4.11659256e-02f, -1.51966894e-02f,
  7.98603669e-02f, -1.64454300e-02f, 2.02822071e-02f, 1.12013035e-01f, 8.99035484e-03f, 3.01456638e-02f, -5.21578416e-02f, 5.14408853e-03f, -7.90119842e-02f, -3.27970535e-02f,
  9.05932561e-02f, -6.56463653e-02f, 4.99036163e-02f, 1.03778884e-01f, -9.13637653e-02f, -2.57723294e-02f, -4.03383933e-02f, -1.43289134e-01f, -8.17113817e-02f, -7.05911219e-02f,
  5.36198094e-02f, 1.04819782e-01f, 3.64462938e-03f, 9.18963477e-02f, -3.27724740e-02f, 6.11474691e-03f, -3.93122993e-02f, 6.75056549e-03f, 4.50651348e-02f, -1.35932818e-01f,
  -1.62299164e-02f, -5.72114103e-02f, -1.28098875e-02f, -2.32493822e-02f, -5.10454038e-03f, -8.67534336e-03f, -7.77221192e-03f, 5.19776382e-02f, -1.55307278e-02f, -6.44576177e-02f,
  1.01913333e-01f, -1.23371938e-02f, -6.92674071e-02f, 1.31089827e-02f, -1.28693730e-01f, -5.77636249e-02f, 5.22093959e-02f, -3.48013220e-03f, 1.68829560e-02f, -7.60652050e-02f,
  -3.45837414e-01f, -3.33166301e-01f, -7.24849924e-02f, 3.50803050e-04f, -6.72396421e-02f, -4.68854085e-02f, 7.64181018e-02f, 8.32334533e-03f, -1.16663001e-01f, -2.63114665e-02f,
  -4.90361266e-02f, 2.09647045e-02f, 1.80969073e-03f, 2.72207838e-02f, 1.01284601e-01f, 9.18972269e-02f, 1.01763539e-01f, 5.49964830e-02f, -1.95465330e-02f, -4.97900136e-02f,
  -1.09935217e-02f, -2.29445770e-02f, 2.90400255e-02f, 2.16377061e-02f, 5.01035415e-02f, 7.50435574e-04f, -4.99246493e-02f, 1.61144063e-02f, -2.53410581e-02f, 1.30176857e-01f,
  -3.17062348e-01f, 1.94805309e-01f, -2.87081003e-01f, -1.07106216e-01f, 1.46447077e-01f, -3.11618835e-01f, -1.96916625e-01f, 3.72805074e-02f, 1.72008388e-02f, 8.06958526e-02f,
  1.09552331e-02f, -4.58180672e-03f, 1.56941310e-01f, -3.08278263e-01f, -3.55185717e-01f, 1.04842030e-01f, -3.86086434e-01f, -1.58600226e-01f, 9.16700810e-02f, -1.43958345e-01f,
  -1.43730789e-01f, -2.41505392e-02f, -8.36594701e-02f, 1.70567125e-01f, -1.34847000e-01f, -4.85432409e-02f, 6.57679811e-02f, 1.87775940e-01f, -1.83174074e-01f, 1.54607341e-01f,
  1.65210869e-02f, 4.77522165e-02f, -3.61317545e-02f, 5.12427185e-04f, -1.32572994e-01f, -7.23877624e-02f, -1.65312782e-01f, 3.14146988e-02f, 2.12105513e-02f, 7.95646384e-03f,
  -3.35756913e-02f, -8.39404110e-03f, -5.76993115e-02f, 1.46660954e-01f, 8.90118554e-02f, 6.98619261e-02f, 5.40821962e-02f, -3.76613289e-02f, 2.15494316e-02f, -1.08218774e-01f,
  -5.71646541e-02f, 4.82227392e-02f, -8.13979730e-02f, 1.10647204e-06f, 8.13994836e-03f, -1.28094817e-03f, -5.73541038e-02f, 1.13035582e-01f, -1.71281770e-02f, -2.98774820e-02f,
  -1.05653867e-01f, -4.68674302e-02f, -9.97794196e-02f, 1.25849813e-01f, -4.39395085e-02f, 1.90646350e-02f, -5.68480566e-02f, 4.12388407e-02f, 4.42222320e-02f, 4.67209145e-02f,
  4.15006541e-02f, -1.39015308e-02f, 8.98312107e-02f, -4.49919626e-02f, -9.02246460e-02f, -4.92494144e-02f, -2.11809315e-02f, 4.04147021e-02f, -9.36321244e-02f, 9.97882430e-03f,
  3.74049656e-02f, -1.90564487e-02f, 1.19768113e-01f, 4.05312739e-02f, 5.31334989e-02f, 1.21232704e-03f, -1.09373450e-01f, 4.70117964e-02f, 9.49200019e-02f, -2.39147581e-02f,
  5.25630936e-02f, -7.72461593e-02f, -3.89955193e-02f, 7.64230713e-02f, -1.59279089e-02f, 1.42436968e-02f, -4.19838876e-02f, -6.68514967e-02f, -1.73729267e-02f, 2.29287148e-02f,
  -9.14715603e-02f, -6.69691116e-02f, 9.81219858e-02f, 4.63628434e-02f, 1.15320280e-01f, -5.76644056e-02f, -1.70772180e-01f, 1.11346006e-01f, 7.20167458e-02f, -2.37238128e-03f,
  -6.28345385e-02f, 2.08405480e-02f, -2.58651059e-02f, 1.36737749e-02f, -2.33431496e-02f, 6.22359142e-02f, -1.32016698e-02f, 8.64359885e-02f, 2.46975962e-02f, 5.92161641e-02f,
  8.21544006e-02f, -2.03507338e-02f, 1.64860174e-01f, -5.33897690e-02f, 2.05051582e-02f, 1.91882983e-01f, 3.12976807e-01f, -1.57243252e-01f, -2.08220676e-01f, -2.22689688e-01f,
  -3.59942280e-02f, 1.85334057e-01f, 2.36700833e-01f, -1.48745328e-01f, 1.43186837e-01f, 1.31048739e-01f, -5.13079949e-02f, 2.91950479e-02f, -8.10790658e-02f, -7.87170529e-02f,
  -3.11311837e-02f, -2.15458259e-01f, 9.20153931e-02f, -1.74922511e-01f, 2.37043556e-02f, -1.49681509e-01f, -2.14731097e-01f, 1.78009883e-01f, -2.41771057e-01f, 9.36831459e-02f,
  7.64397234e-02f, 6.38379306e-02f, 9.25666839e-02f, 9.99668520e-03f, 3.00093386e-02f, 4.52138186e-02f, 1.01672381e-01f, 1.68933466e-01f, 7.01794997e-02f, 2.29284838e-02f,
  -1.34279588e-02f, 1.70607155e-03f, -6.06180262e-03f, -6.27800450e-02f, -2.02315226e-01f, -9.13346186e-02f, 5.29165566e-02f, 8.47934410e-02f, 4.29644249e-02f, 9.86183733e-02f,
  1.62952989e-01f, 9.96202454e-02f, 5.12899460e-05f, -1.09030016e-01f, -4.24928702e-02f, -6.44105440e-03f, 4.26195636e-02f, 5.30418381e-02f, -1.49196889e-02f, 5.79890655e-03f,
  -1.54374363e-02f, -9.60691795e-02f, 4.82362248e-02f, -5.64107411e-02f, -7.09525123e-02f, -1.44027308e-01f, -3.19214202e-02f, 6.65960982e-02f, -8.22933540e-02f, -9.58780646e-02f,
  -9.88708660e-02f, 2.25512404e-03f, 5.69797494e-02f, -1.85080916e-01f, -2.49906123e-01f, -1.02674954e-01f, -5.55749983e-02f, -3.14332992e-02f, -1.07197188e-01f, -1.99455079e-02f,
  2.51938514e-02f, -5.74475490e-02f, -1.18190698e-01f, -8.33693743e-02f, 4.16866168e-02f, 5.56253316e-03f, -9.27394107e-02f, -5.48779108e-02f, 1.21931136e-02f, 1.92790180e-02f,
  9.54922885e-02f, -5.28615266e-02f, 4.34014276e-02f, -1.70675740e-02f, 1.16552107e-01f, 2.29201633e-02f, 4.64335792e-02f, -5.82380854e-02f, 4.08007093e-02f, -7.04526305e-02f,
  -1.81635305e-01f, -1.63836200e-02f, -1.16084889e-01f, -1.32960469e-01f, -1.35491446e-01f, -2.55880803e-02f, 1.20917961e-01f, 2.34174747e-02f, -2.86924988e-02f, -5.28196953e-02f,
  3.96701060e-02f, 7.62727037e-02f, -2.50585862e-02f, -6.84686303e-02f, -1.27511904e-01f, -2.79407855e-02f, 3.77089195e-02f, -1.94585021e-03f, -6.27501458e-02f, -5.04892990e-02f,
  -1.57044902e-01f, 2.08337586e-02f, -1.30837888e-01f, -1.88287094e-01f, 1.00570008e-01f, -2.30985656e-02f, -8.64084736e-02f, -1.45125361e-02f, -1.34755433e-01f, 1.93967655e-01f,
  -4.86558937e-02f, -1.64399996e-01f, -2.30100565e-02f, -3.86291414e-01f, -5.25431514e-01f, -3.26251566e-01f, -1.40136600e-01f, -7.12592676e-02f, -1.80804968e-01f, -2.64790654e-02f,
  -1.17516249e-01f, -2.84172386e-01f, -1.91077247e-01f, 9.85914841e-02f, 8.93371031e-02f, 2.46163175e-01f, 2.68235236e-01f, 1.09692439e-01f, 1.39946327e-01f, 1.19995987e-02f,
  -2.11989209e-01f, -1.60565630e-01f, -1.70347802e-02f, -8.00603256e-02f, 1.43463433e-01f, 1.95682272e-01f, 2.15849966e-01f, -8.61608014e-02f, -4.59057018e-02f, -1.12780333e-01f,
  7.85843730e-02f, -6.87004104e-02f, -1.77154839e-01f, -1.15348585e-01f, 1.30952597e-01f, 2.01768279e-02f, -1.05509363e-01f, 5.94955012e-02f, -5.93805574e-02f, -1.60239577e-01f,
  -9.68703255e-02f, 3.61304870e-03f, 8.36303979e-02f, -2.33056135e-02f, -6.53938055e-02f, 4.64122146e-02f, 9.47127044e-02f, 1.01832904e-01f, 3.37787010e-02f, 7.05092400e-03f,
  8.08660612e-02f, 1.32564992e-01f, -2.19546054e-02f, -9.14567411e-02f, -7.09103942e-02f, 8.58066827e-02f, -1.10450692e-01f, 4.91476245e-03f, 7.21310824e-02f, 8.13688263e-02f,
  4.74362187e-02f, -2.42747385e-02f, -1.05897121e-01f, 2.42708400e-02f, -2.49186121e-02f, 1.28410673e-02f, 2.24879552e-02f, 2.79143006e-02f, 1.56705994e-02f, -9.73277166e-03f,
  -9.84231755e-02f, 3.62545662e-02f, 2.34979186e-02f, 2.01397855e-02f, -9.15213078e-02f, 1.57085229e-02f, 6.18802123e-02f, -3.58438790e-02f, 4.93124947e-02f, 1.03831388e-01f,
  4.77473028e-02f, 3.85395624e-02f, -6.62440658e-02f, -5.16383387e-02f, -2.36907415e-02f, 4.08331193e-02f, -1.73481926e-02f, -5.67334779e-02f, -1.18361071e-01f, -6.77416325e-02f,
  1.44900233e-01f, 1.35315284e-01f, 1.67697132e-01f, -5.62427975e-02f, 9.24727470e-02f, 6.63199648e-02f, 1.19402725e-02f, 4.87132668e-02f, 1.54872432e-01f, 3.57244760e-02f,
  8.09714496e-02f, 9.36496910e-03f, 4.48381826e-02f, 5.08445539e-02f, 4.14514169e-02f, 5.26172295e-02f, 3.11699919e-02f, 8.35544989e-02f, 9.69609171e-02f, 1.03215866e-01f,
  2.64780730e-01f, -5.09657502e-01f, 1.72958061e-01f, 1.29650578e-01f, 3.19210291e-01f, 1.11527564e-02f, 3.23985070e-01f, 4.41850134e-05f, 4.91034836e-02f, -2.45366171e-01f,
  -5.47580570e-02f, -7.64191821e-02f, 1.30957201e-01f, -1.03685811e-01f, 2.91697532e-01f, 5.43743819e-02f, -5.26571870e-02f, -1.66584119e-01f, 1.70220563e-03f, 2.81394627e-02f,
  4.71922681e-02f, -3.46979685e-02f, 1.41237348e-01f, -2.38705590e-01f, 5.48666297e-03f, -2.96441745e-02f, -1.10939890e-01f, 1.97834507e-01f, -2.41551906e-01f, 1.23833455e-01f,
  -6.38022050e-02f, -5.59055619e-02f, -5.69225661e-02f, -8.26667845e-02f, -1.67944282e-01f, -4.36191112e-02f, 9.61451605e-02f, 1.21372320e-01f, 3.11569478e-02f, -5.73559701e-02f,
  -2.43184157e-02f, 1.74303853e-03f, -4.34667394e-02f, 6.40589297e-02f, 7.47585250e-03f, 4.47190367e-02f, 5.34103960e-02f, -4.82554287e-02f, -9.09390580e-03f, 1.00189753e-01f,
  2.73941550e-02f, -6.33951500e-02f, 4.07772288e-02f, -2.52274368e-02f, 7.00349286e-02f, 1.46982051e-03f, 2.22852640e-02f, 9.35610831e-02f, 1.31955557e-02f, 6.70511499e-02f,
  1.52114658e-02f, -3.27665545e-02f, 1.14099737e-02f, 3.87048088e-02f, 2.20981371e-02f, 4.42626327e-03f, -3.97933871e-02f, -5.51613607e-02f, -8.34761187e-02f, 1.71948746e-02f,
  1.38804521e-02f, -1.73633697e-03f, 1.72874723e-02f, 3.51037718e-02f, 9.68273077e-03f, -1.03485361e-01f, 5.09418407e-03f, 9.36685279e-02f, 2.61997636e-02f, 1.30148977e-02f,
  4.14085761e-02f, 1.40057271e-02f, 4.43237498e-02f, 2.92417016e-02f, 6.76657306e-03f, 1.10370563e-02f, -2.21864730e-02f, 6.92087784e-02f, -3.03157736e-02f, 6.50922060e-02f,
  -3.24814200e-01f, -4.66783136e-01f, -6.83129504e-02f, -1.94041282e-02f, -1.31120935e-01f, -1.57152042e-01f, -3.13814580e-02f, -3.52948974e-03f, -1.69732973e-01f, 4.10517724e-03f,
  -8.90268236e-02f, 6.79473057e-02f, -2.90820934e-02f, 6.10484704e-02f, -1.22771353e-01f, 2.79233903e-02f, -2.75775101e-02f, -1.17489062e-01f, 2.21748576e-02f, -6.81161359e-02f,
  1.38821704e-02f, -5.36696464e-02f, 8.42393860e-02f, -7.48335989e-03f, -9.93860364e-02f, -1.61964316e-02f, -3.30762491e-02f, 2.67027821e-02f, -1.46749709e-02f, -6.54400289e-02f,
  2.54195213e-01f, 1.73193514e-01f, 1.12170748e-01f, 1.71159610e-01f, -1.87107064e-02f, -2.03838143e-02f, 1.05050221e-01f, -5.73892035e-02f, 1.85970902e-01f, -5.83138363e-03f,
  -1.34351715e-01f, 2.90133446e-01f, 1.05308101e-01f, -1.73794534e-02f, -2.82723665e-01f, -1.60193622e-01f, -2.54340563e-02f, 1.21799573e-01f, 2.65581757e-01f, -7.84683600e-02f,
  -6.63847402e-02f, -2.74096906e-01f, 3.97445215e-03f, -9.91528016e-03f, 1.37382552e-01f, 1.40372008e-01f, -1.96474761e-01f, 7.00548887e-02f, 7.09176250e-03f, 2.41927896e-02f,
  -1.04451701e-01f, 2.90114693e-02f, 6.89102039e-02f, -9.81876254e-02f, 3.23118642e-02f, 2.28250846e-02f, -1.22989632e-01f, -8.18319842e-02f, 1.26587361e-01f, -4.00470234e-02f,
  1.95881017e-02f, -6.16844893e-02f, 3.77154094e-03f, -1.03464596e-01f, 1.33685440e-01f, -4.60923426e-02f, 1.06478427e-02f, 3.96084078e-02f, -1.02854613e-02f, 6.33067116e-02f,
  -7.90944323e-02f, 7.70511031e-02f, 1.97392260e-03f, 2.39807293e-02f, 4.54153083e-02f, 1.11809045e-01f, -5.50082512e-02f, -5.52846342e-02f, -4.16663624e-02f, 1.09813642e-02f,
  2.55739987e-01f, -4.12164889e-02f, 8.24498832e-02f, -6.88784346e-02f, 5.37774712e-02f, -9.18039680e-02f, 2.88873371e-02f, -1.38413310e-01f, -8.76385272e-02f, -3.56472693e-02f,
  -1.99570805e-02f, 8.42493922e-02f, 9.44844708e-02f, -4.58788918e-03f, 1.12679012e-01f, -4.33471389e-02f, -1.35795057e-01f, 2.90040765e-02f, 7.37567618e-02f, 1.09368645e-01f,
  -2.96862163e-02f, -1.25172898e-01f, -2.36367770e-02f, -9.40988362e-02f, 1.47385210e-01f, -2.00989731e-02f, -8.66097361e-02f, 2.24710926e-02f, 1.05084479e-01f, -1.68598210e-03f,
  -3.02829891e-01f, -2.76813120e-01f, -3.34299952e-02f, -7.87604898e-02f, 6.44777622e-03f, -9.60284844e-02f, -7.06278160e-02f, -4.16443236e-02f, 6.94827363e-02f, -2.65489668e-02f,
  1.05082346e-02f, 1.54272569e-02f, 4.92338464e-02f, -4.52097990e-02f, 1.50333121e-02f, -1.85045883e-01f, -3.64712859e-03f, -9.22157802e-03f, -6.97724475e-03f, 3.22106550e-03f,
  2.95503233e-02f, -2.25073081e-02f, -1.50054455e-01f, 1.07433265e-02f, -3.72753665e-02f, 3.24905850e-02f, -2.89240871e-02f, -2.70482134e-02f, -9.08449367e-02f, -1.40150875e-01f,
  3.75874132e-01f, -5.53070247e-01f, 6.50301650e-02f, 4.26342070e-01f, 2.54789531e-01f, 2.41630320e-02f, 3.51178080e-01f, -1.38088940e-02f, 2.89763361e-01f, -3.45616460e-01f,
  3.89225110e-02f, -1.58452988e-01f, -1.66005403e-01f, -2.44459976e-02f, 1.93359002e-01f, -1.03951178e-01f, -9.61129181e-03f, -8.16893801e-02f, 5.59928566e-02f, 2.01816820e-02f,
  1.75027847e-01f, 1.13193743e-01f, 3.91980261e-02f, -1.02016427e-01f, 8.17393661e-02f, 2.34547444e-02f, -3.07817888e-02f, -3.02628335e-02f, -2.30169091e-02f, -3.66199203e-02f,
  -4.67785262e-02f, 2.14613825e-02f, 3.72035406e-03f, -1.31688267e-01f, 1.21301450e-02f, -5.05179390e-02f, 6.48917034e-02f, -9.00858955e-04f, 5.62500134e-02f, -3.85568514e-02f,
  3.72378491e-02f, 9.51370317e-03f, -3.26666273e-02f, 1.61924139e-02f, 3.40261124e-02f, -7.79769197e-03f, 7.17858970e-02f, -6.74105734e-02f, -4.24008481e-02f, 4.60101366e-02f,
  8.52037668e-02f, -1.18039586e-01f, 1.07079400e-02f, -7.77043104e-02f, 4.91751283e-02f, 8.44965316e-03f, 4.00447883e-02f, -1.48366811e-02f, 6.15826771e-02f, 7.50729740e-02f,
  -3.33392248e-02f, -4.08139527e-02f, 1.08325914e-01f, 2.55579296e-02f, 1.36935428e-01f, 1.15590461e-01f, -6.61672652e-03f, -3.10600293e-03f, -3.99977379e-02f, -4.28164676e-02f,
  -7.58364648e-02f, -5.75236417e-02f, -3.06808972e-03f, 6.65792599e-02f, 2.63407063e-02f, 9.11786705e-02f, -6.55960739e-02f, -5.19449916e-03f, -2.28986777e-02f, -4.11767364e-02f,
  1.62868854e-02f, -3.81587930e-02f, -1.72858298e-01f, 4.80543189e-02f, -1.58240944e-02f, 7.07330042e-03f, -1.72346178e-02f, 4.91940603e-02f, 1.17117107e-01f, -4.03239578e-03f,
  -3.65080565e-01f, -4.49833423e-01f, -1.11707166e-01f, -9.91971269e-02f, -7.46240169e-02f, -8.93654898e-02f, -2.12787348e-03f, -5.74054867e-02f, -1.40962586e-01f, -4.87018041e-02f,
  -6.83939457e-02f, 5.47727384e-02f, -2.89759561e-02f, -1.98677619e-04f, -9.33451205e-02f, -2.22535953e-02f, 2.60925237e-02f, -1.76636517e-01f, -3.14150266e-02f, -1.26291513e-01f,
  1.08479094e-02f, 3.79221030e-02f, 5.65989576e-02f, 3.72541025e-02f, -5.44007793e-02f, -2.99137924e-02f, 6.95462376e-02f, -1.16167992e-01f, -4.04679477e-02f, -2.00876147e-02f,
  3.67067337e-01f, 1.20534800e-01f, 1.70417741e-01f, 6.69812933e-02f, -8.22623074e-02f, 3.87120731e-02f, -1.02786366e-02f, -1.36495531e-01f, -7.94144273e-02f, 1.02928787e-01f,
  -7.94259533e-02f, 1.35872543e-01f, -7.00383633e-02f, 1.24187015e-01f, -1.80618942e-01f, -6.67961165e-02f, 6.08091392e-02f, 1.60341769e-01f, -6.35336041e-02f, 8.44595879e-02f,
  6.50857389e-02f, -6.92918971e-02f, -8.16036835e-02f, -2.22941563e-02f, 2.28857443e-01f, 2.06059128e-01f, -9.08630043e-02f, -1.01966478e-01f, 7.66234398e-02f, -7.02493638e-02f,
  3.15198936e-02f, 1.04698241e-02f, 1.43683460e-02f, 5.33081032e-02f, 3.17871310e-02f, 1.22130908e-01f, 6.09220788e-02f, 1.50806624e-02f, -1.00862131e-01f, 1.41132306e-02f,
  8.34741741e-02f, -2.68126149e-02f, 1.25593826e-01f, -2.24786773e-02f, 7.14512914e-02f, 3.58674303e-02f, -2.23167911e-02f, -3.45415585e-02f, 5.72733954e-02f, 7.64698237e-02f,
  8.26048777e-02f, 2.58477945e-02f, -5.28981946e-02f, 2.20768638e-02f, 3.14786052e-03f, 2.60851346e-02f, -7.39140883e-02f, -3.13178189e-02f, -2.35659834e-02f, -6.08048588e-02f,
  1.40279561e-01f, -2.47546863e-02f, 2.76190732e-02f, -1.24230357e-02f, -6.59400448e-02f, -6.05134778e-02f, -2.91700680e-02f, -5.25684506e-02f, -6.34602904e-02f, 1.30467890e-02f,
  -7.68930390e-02f, 1.88539759e-03f, -6.88643232e-02f, -3.06109767e-02f, -6.27876595e-02f, 1.57074183e-01f, 2.43181586e-02f, -4.04117480e-02f, -2.81096958e-02f, -1.22111708e-01f,
  1.06931053e-01f, -6.31516194e-03f, -9.40261036e-02f, 1.89922992e-02f, -7.59920627e-02f, -5.00582643e-02f, 4.38030213e-02f, 7.67682046e-02f, -4.91897054e-02f, -4.58440781e-02f,
  -1.21947289e-01f, -7.83312842e-02f, -5.18014245e-02f, 3.12656611e-02f, -4.85163182e-03f, 2.57269442e-02f, 5.77451661e-02f, 4.89454493e-02f, -5.80363050e-02f, -3.47598940e-02f,
  3.60579900e-02f, -4.97305840e-02f, 3.40313837e-02f, 2.03112178e-02f, -6.17104322e-02f, -8.93645659e-02f, 6.84900060e-02f, -6.66182861e-02f, -7.28105530e-02f, 5.54195866e-02f,
  5.81269935e-02f, 1.47123663e-02f, -4.70180772e-02f, 7.33883753e-02f, -3.79083417e-02f, 2.75363568e-02f, 3.00932284e-02f, 2.20836382e-02f, 5.68720177e-02f, -7.10222200e-02f,
  -1.79884449e-01f, -3.53028327e-01f, -1.62358563e-02f, 6.31708354e-02f, 1.16050072e-01f, 1.23942226e-01f, -1.15651384e-01f, -2.87029203e-02f, -1.47628665e-01f, -2.43389472e-01f,
  -1.66206434e-01f, -1.34158239e-01f, -3.00176471e-01f, 1.04096644e-02f, 8.63706991e-02f, -8.46031755e-02f, 2.27618162e-02f, -9.27696284e-03f, 1.28759146e-01f, -9.58675072e-02f,
  3.32375690e-02f, 1.89297944e-01f, 1.05921283e-01f, 2.54013956e-01f, 5.87395253e-03f, 8.81095380e-02f, 5.07918932e-02f, 7.64079168e-02f, 2.52501488e-01f, 9.28915814e-02f,
  -6.22990169e-02f, -1.98151588e-01f, -1.67156046e-03f, 3.42776105e-02f, -1.25672752e-02f, -6.25306070e-02f, 1.79750919e-02f, 3.71534862e-02f, 1.06806634e-03f, -6.16957201e-03f,
  -3.52035835e-02f, 8.20269659e-02f, 1.31433383e-01f, 9.75502655e-02f, -1.47056766e-02f, 1.65590364e-02f, 4.81678061e-02f, -6.57628402e-02f, -1.40135381e-02f, 3.78596373e-02f,
  -5.63762076e-02f, -1.67211574e-02f, -9.20130536e-02f, 7.66558275e-02f, -5.43737188e-02f, -5.70120383e-03f, 9.60815549e-02f, -1.78057160e-02f, 1.27819004e-02f, 1.36718914e-01f,
  7.94484839e-02f, -1.32185267e-02f, -5.52787259e-02f, -2.44666915e-02f, 8.74837302e-03f, 4.17507626e-02f, 3.68679054e-02f, -2.82048900e-02f, -1.05817690e-01f, -4.89652269e-02f,
  -1.29632512e-02f, -1.78348664e-02f, -7.58247077e-02f, -1.68444086e-02f, -8.44852719e-03f, 4.39763907e-03f, -8.84983689e-02f, 4.10504118e-02f, 1.45958941e-02f, 6.00941405e-02f,
  5.55606931e-02f, -9.11291130e-03f, -4.44685481e-02f, 5.26165180e-02f, 6.04236424e-02f, -1.21117599e-01f, -4.10802253e-02f, -5.84415793e-02f, 4.00683507e-02f, -7.17471242e-02f,
  -3.12367946e-01f, -3.10741872e-01f, 5.33162951e-02f, 3.21786627e-02f, 2.82831229e-02f, -7.10883960e-02f, 8.13688263e-02f, 6.99179098e-02f, -9.94282588e-02f, -1.16233798e-02f,
  -1.27741456e-01f, 3.09312176e-02f, -1.73107423e-02f, 7.43377283e-02f, -7.78705925e-02f, 5.94660640e-03f, -1.34929955e-01f, -1.30382642e-01f, -5.68450354e-02f, 3.03941853e-02f,
  -6.03337251e-02f, 9.03294329e-03f, 7.64727741e-02f, 3.33637819e-02f, 4.59153838e-02f, -5.50268143e-02f, 3.13329585e-02f, 4.90190042e-03f, 1.98634136e-02f, 8.54382962e-02f,
  2.84730345e-01f, 2.18528345e-01f, 2.74857312e-01f, 2.09789783e-01f, -1.32008314e-01f, -7.20055401e-02f, 6.74464330e-02f, -8.90278667e-02f, 1.21986516e-01f, 1.62236467e-01f,
  -1.43286005e-01f, 2.78041869e-01f, -9.28621963e-02f, 1.39021784e-01f, -1.99237928e-01f, -2.13041946e-01f, -1.05509207e-01f, 1.76120862e-01f, -9.58760157e-02f, 1.37575403e-01f,
  -4.93697524e-02f, -3.03911895e-01f, 5.14847562e-02f, -1.47895679e-01f, 1.68438599e-01f, 2.51912743e-01f, -1.20165475e-01f, -5.39829284e-02f, 2.70793527e-01f, -4.16508503e-02f,
  5.83186783e-02f, 9.53041948e-03f, 1.17495306e-01f, -4.48805094e-02f, -2.26736674e-03f, 2.98639368e-02f, 5.04269525e-02f, -1.18171861e-02f, -7.56713152e-02f, -5.37904799e-02f,
  6.85026348e-02f, -6.19863383e-02f, 4.24393043e-02f, 2.97487993e-02f, 1.54461518e-01f, 1.11841001e-02f, 1.16027571e-01f, 8.24792311e-02f, 5.52171059e-02f, 9.86618400e-02f,
  1.96898475e-01f, 1.35761544e-01f, 4.59482782e-02f, 1.09229214e-01f, 4.69846018e-02f, -8.60231556e-03f, -3.25197689e-02f, 1.47029951e-01f, 5.62552437e-02f, 3.04195117e-02f,
  -5.68367578e-02f, -1.10181622e-01f, -3.02043481e-04f, -3.40761505e-02f, -4.72713858e-02f, 9.50828951e-04f, 5.50671555e-02f, 5.08135650e-03f, 3.57219204e-02f, 9.38020460e-03f,
  -2.16242000e-02f, 8.40606913e-03f, -3.07321232e-02f, 1.15664508e-02f, -7.94402212e-02f, 4.19386476e-02f, 2.02648751e-02f, 3.37522514e-02f, 4.53464314e-02f, -6.72155246e-02f,
  -1.12345023e-02f, 5.87113723e-02f, -3.14051919e-02f, -3.33327167e-02f, -4.12250161e-02f, -2.30071582e-02f, -1.57993540e-01f, 1.40778452e-01f, -2.95965672e-02f, -1.35008737e-01f,
  -9.17430222e-02f, -1.70564026e-01f, -3.77430245e-02f, 7.61316484e-03f, 1.17315063e-02f, -5.68279438e-02f, -2.12624073e-02f, 5.52897006e-02f, -3.82711086e-03f, -1.21433347e-01f,
  -9.16018430e-03f, 1.09685250e-02f, 8.11547711e-02f, -2.29234602e-02f, 7.26235732e-02f, -6.58345073e-02f, 2.25632843e-02f, -6.65738508e-02f, 5.35950027e-02f, -4.86054905e-02f,
  4.61393707e-02f, -2.45686490e-02f, -6.31633848e-02f, 2.56379452e-02f, -1.68846715e-02f, -1.58772133e-02f, 6.92036841e-03f, 4.09490392e-02f, -4.18501161e-02f, -4.63818908e-02f,
  7.40491226e-02f, 2.94322103e-01f, 1.85579360e-01f, 2.05377325e-01f, -2.56475776e-01f, -3.04598004e-01f, -2.41279095e-01f, 1.22577190e-01f, -1.16388947e-01f, -1.56583026e-01f,
  -4.15879115e-02f, -5.28057329e-02f, 1.45626619e-01f, 8.27369243e-02f, 1.42877653e-01f, 1.94518268e-02f, 2.33181834e-01f, -9.97489467e-02f, 9.70977172e-02f, 2.64307082e-01f,
  1.56116769e-01f, 7.75959566e-02f, 2.62842894e-01f, 1.64849356e-01f, 7.46016204e-02f, 8.88216048e-02f, 2.39174634e-01f, -1.47092808e-02f, 2.30995435e-02f, -1.15116671e-01f,
  -9.31343213e-02f, 5.46219833e-02f, 5.18236347e-02f, -4.71948013e-02f, 1.29468545e-01f, -6.67209104e-02f, -5.44581227e-02f, -8.81092995e-02f, -8.47079828e-02f, -3.26914862e-02f,
  -3.17151882e-02f, -1.80583633e-02f, 3.34714465e-02f, -9.52270161e-03f, -1.10020310e-01f, -8.38666484e-02f, -4.41687703e-02f, -1.19840108e-01f, -1.12903118e-01f, 1.17077760e-01f,
  2.25612186e-02f, 5.05262278e-02f, -1.63213238e-02f, 1.93742309e-02f, 6.31683022e-02f, 1.95074966e-03f, 1.91411991e-02f, -2.13205721e-02f, -4.00178581e-02f, -1.93782002e-02f,
  4.95168902e-02f, -5.47301956e-02f, -2.98192967e-02f, -9.88227725e-02f, -3.63715552e-02f, -3.43612805e-02f, -4.70364317e-02f, -3.94886583e-02f, 5.08078411e-02f, 2.52391100e-02f,
  -7.28653185e-03f, 1.30643308e-01f, -2.22618300e-02f, -5.75241335e-02f, 1.38100356e-01f, 2.23574471e-02f, 2.77629662e-02f, -5.53935356e-02f, -8.43068305e-03f, 2.32553165e-02f,
  -1.72527596e-01f, 1.99445407e-03f, -4.72849049e-02f, 5.59198409e-02f, -1.24443367e-01f, 6.53154477e-02f, 5.75863831e-02f, -1.28341392e-02f, 4.19716090e-02f, 1.08059295e-01f,
  6.93344176e-02f, 2.48912290e-01f, 2.33726334e-02f, -1.16992675e-01f, 7.72648957e-03f, 9.02040079e-02f, -4.72805388e-02f, 6.05344288e-02f, 3.95905711e-02f, 9.54892784e-02f,
  5.72549663e-02f, -1.36391008e-02f, -2.10547093e-02f, 4.09018248e-02f, 3.50721851e-02f, 1.56762406e-01f, -5.41710705e-02f, -1.82551481e-02f, 5.42010255e-02f, 7.94951469e-02f,
  4.24791947e-02f, -1.58707257e-02f, -3.86696942e-02f, -2.18708012e-02f, 1.11364923e-01f, -3.97481211e-02f, -3.06736398e-02f, -9.68662873e-02f, 3.06147407e-03f, -3.56821492e-02f,
  6.15317859e-02f, -1.31145209e-01f, -1.34584963e-01f, -7.90874436e-02f, -3.34343940e-01f, -3.21032554e-02f, 1.24378264e-01f, -1.03393137e-01f, -3.76720056e-02f, 1.19624034e-01f,
  -7.04969317e-02f, 1.32260740e-01f, 3.39434981e-01f, -1.46511286e-01f, 1.41190752e-01f, 3.19905132e-01f, -3.50624043e-03f, 1.21975377e-01f, 2.75891442e-02f, 3.58494744e-02f,
  -6.56488761e-02f, -5.86171076e-02f, -2.97648571e-02f, -1.43300742e-01f, -2.98824728e-01f, -1.09620765e-01f, -1.42832264e-01f, -1.43981695e-01f, -1.92968830e-01f, -2.23289713e-01f,
  -6.52245656e-02f, -2.49612704e-02f, -3.37594599e-02f, 1.38074979e-01f, -5.84545061e-02f, 4.58388515e-02f, -1.26332352e-02f, 1.16362080e-01f, 3.24902609e-02f, 9.22103673e-02f,
  8.92070830e-02f, 2.05825970e-01f, 7.57412761e-02f, -9.14201234e-03f, -1.09645307e-01f, -6.40928969e-02f, 4.23525870e-02f, -5.34020662e-02f, 1.51468933e-01f, 1.67381540e-02f,
  -1.12122856e-02f, -3.71311270e-02f, -2.22868603e-02f, 2.22097412e-02f, -1.52527133e-03f, 6.42204434e-02f, 5.81808500e-02f, -4.04305048e-02f, -4.95544970e-02f, -2.50126962e-02f,
  -7.26367310e-02f, 9.13866013e-02f, 7.76786730e-02f, -1.19836092e-01f, -1.33526605e-02f, -2.75039505e-02f, -2.95606591e-02f, 5.35203367e-02f, -4.30616513e-02f, -1.19658206e-02f,
  -4.73981164e-02f, -8.76475126e-02f, -4.84091602e-02f, 1.69904102e-02f, 8.76888558e-02f, 2.64821351e-02f, -6.53086826e-02f, -8.59550834e-02f, -3.14044021e-02f, 4.70076166e-02f,
  1.20867871e-01f, 9.25398692e-02f, -1.29889045e-02f, -4.03649434e-02f, -4.15208638e-02f, -1.96951609e-02f, -7.00509129e-03f, -5.56448996e-02f, 3.48417610e-02f, -1.99721437e-02f,
  1.12240284e-03f, -2.63097528e-02f, 4.09871303e-02f, 1.38506159e-01f, -1.15924943e-02f, -7.64872506e-02f, 4.27231342e-02f, -2.96352841e-02f, 4.72990125e-02f, -1.51261790e-02f,
  -3.84349711e-02f, 4.99736816e-02f, -5.10273986e-02f, -1.46141529e-01f, -1.28644216e-03f, -4.15748283e-02f, 1.66415855e-01f, 1.08901039e-02f, -6.42102212e-02f, 8.88287369e-03f,
  1.31006718e-01f, 9.96082127e-02f, 1.91532239e-01f, 1.44623756e-01f, 2.39799842e-02f, 8.14917907e-02f, -5.08353077e-02f, -7.21539333e-02f, 5.50396834e-03f, 7.91465268e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  1.97051316e-01f, 1.78229675e-01f, 2.66369224e-01f, 1.16071388e-01f, 1.94218129e-01f, 2.33583480e-01f, 2.58064479e-01f, 1.36581540e-01f, 1.40575215e-01f, 1.71376362e-01f,
  1.60311684e-01f, 1.75941095e-01f, 1.14261582e-01f, -7.01510161e-03f, 2.69329131e-01f, 2.16852561e-01f, 1.95199937e-01f, 1.31108731e-01f, 2.08277687e-01f, 2.58478761e-01f,
  9.87167805e-02f, 2.10458636e-01f, 1.51400834e-01f, 1.97845966e-01f, 1.39095053e-01f, 2.03758463e-01f, 2.14113951e-01f, 2.22331256e-01f, 1.30467772e-01f, 1.44658118e-01f,
  2.85476774e-01f, 3.17725480e-01f, 1.35741159e-01f, 1.18825734e-01f, 1.93498999e-01f, 2.49464661e-01f, 9.93263423e-02f, 2.22865909e-01f, 8.13245401e-02f, 2.82487959e-01f,
  4.98025194e-02f, 1.52621970e-01f, 1.54505372e-01f, 2.16882512e-01f, 2.15883955e-01f, 2.36949235e-01f, 2.31093004e-01f, 1.49128422e-01f, 1.33976310e-01f, 2.00071961e-01f,
  5.58328442e-02f, 1.41602397e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -2.24852725e-03f, 8.90087336e-02f, -1.31152757e-02f, 1.87995704e-03f, -1.99170858e-02f, -2.91928817e-02f, -3.92139070e-02f, 5.06858006e-02f, -2.48398893e-02f, -1.05117317e-02f,
  5.76619897e-03f, 2.55936314e-03f, 2.03804716e-01f, -1.44160897e-01f, -2.20318474e-02f, -2.20399238e-02f, 3.17209028e-02f, -9.21510458e-02f, 3.44006568e-02f, 2.53009070e-02f,
  -9.43144113e-02f, 1.38963193e-01f, 4.13338989e-02f, 3.80148217e-02f, 1.28699780e-01f, -1.21107690e-01f, -6.24245778e-02f, 4.64166561e-03f, -7.25442767e-02f, 1.41522866e-02f,
  2.02084389e-02f, -9.76438969e-02f, 7.48988017e-02f, -7.12907501e-03f, 3.12063247e-02f, 5.07408455e-02f, -2.13300571e-01f, 1.89552769e-01f, -3.36370841e-02f, -9.48613510e-02f,
  7.88070336e-02f, 1.37175396e-01f, -2.07260802e-01f, -5.50730154e-02f, -1.37231693e-01f, -8.84674489e-02f, 8.71970356e-02f, -1.21371321e-01f, 1.78459495e-01f, 3.28633375e-02f,
  1.44682989e-01f, -5.15559316e-02f, 7.40031078e-02f, 1.43385112e-01f, 2.04765256e-02f, 1.23205356e-01f, -1.53581247e-01f, 4.67993133e-02f, -1.67729452e-01f, -1.62154119e-02f,
  9.47050527e-02f, -4.20889352e-03f, -1.64256677e-01f, -1.22854128e-01f, 1.17308632e-01f, 2.22759396e-02f, -1.32516976e-02f, -2.41295956e-02f, -4.02526334e-02f, -1.28116593e-01f,
  1.78324599e-02f, 3.56425382e-02f, 3.29652652e-02f, -6.68004975e-02f, -1.09941401e-01f, -7.26308152e-02f, -2.11517401e-02f, -1.99576944e-01f, 7.12020472e-02f, 3.04959081e-02f,
  1.14833556e-01f, -5.43777831e-02f, -3.98542769e-02f, 2.12831376e-03f, -9.29940417e-02f, 5.20450473e-02f, 1.00964494e-01f, 1.02027200e-01f, -1.07535981e-02f, 5.91264963e-02f,
  -1.32221967e-01f, 1.02931403e-01f, -3.61387692e-02f, -5.48841134e-02f, 1.04470454e-01f, -6.73354566e-02f, -1.37855718e-03f, 1.69114377e-02f, -6.54260302e-03f, 6.74975803e-03f,
  -1.25218436e-01f, 1.61243975e-01f, 1.37657478e-01f, -5.92525005e-02f, 1.01791665e-01f, -5.97787015e-02f, 2.20615440e-03f, 1.03949122e-01f, -1.50708631e-01f, -7.07072392e-02f,
  3.78198992e-03f, 1.34129256e-01f, -6.29568398e-02f, 1.70426950e-01f, -5.28522506e-02f, 1.95376482e-02f, 6.31469563e-02f, -1.03542052e-01f, 1.38701826e-01f, -9.32584554e-02f,
  1.22098714e-01f, 7.50699192e-02f, 5.86234443e-02f, 6.42709881e-02f, -5.85824624e-02f, 1.50309786e-01f, -1.15804672e-01f, 4.13125083e-02f, -1.68624327e-01f, -4.31972779e-02f,
  -2.10582107e-01f, -8.82117152e-02f, -6.05373047e-02f, 2.62693074e-02f, 3.23160291e-02f, -1.03172801e-01f, -6.20007254e-02f, 8.11998248e-02f, 2.73634028e-03f, -2.81346023e-01f,
  -1.00635588e-01f, 1.67000547e-01f, 5.94052859e-03f, -1.55286178e-01f, 5.63024245e-02f, -1.08894289e-01f, 1.95984207e-02f, -1.62120666e-02f, 1.07079983e-01f, -1.39709458e-01f,
  5.35158329e-02f, -1.27238289e-01f, 7.81598389e-02f, -2.25770995e-01f, 4.84123453e-02f, 6.65024519e-02f, 3.11449785e-02f, -8.85609090e-02f, -1.30017579e-01f, 1.83090881e-01f,
  -5.46022020e-02f, 7.03749582e-02f, -1.03638759e-02f, -1.60966247e-01f, 8.44977275e-02f, -7.29752854e-02f, 1.75630662e-03f, -6.09912276e-02f, -3.62790748e-02f, 4.59887385e-02f,
  -1.66336864e-01f, -1.45730570e-01f, 1.26186937e-01f, 1.41474143e-01f, 6.85405880e-02f, 1.60979494e-01f, 7.56684467e-02f, 6.65947497e-02f, -1.46420635e-02f, -2.68180341e-01f,
  -1.58989802e-02f, 7.43694603e-02f, -2.03537326e-02f, 4.65327837e-02f, 1.13960266e-01f, -4.55390140e-02f, 1.88439786e-01f, -1.66596189e-01f, 1.50559485e-01f, -9.26948860e-02f,
  -9.81366858e-02f, 1.58737805e-02f, -6.20045066e-02f, 3.47600207e-02f, 4.11368906e-02f, -1.49681177e-02f, -1.24560222e-01f, 3.43803056e-02f, 1.71206600e-03f, 1.72169864e-01f,
  8.58778507e-02f, -1.08743981e-02f, -7.34127760e-02f, -1.23176333e-02f, 1.88927755e-01f, -1.36707220e-02f, -5.70954718e-02f, 1.28113493e-01f, 3.05044770e-01f, -1.86180443e-01f,
  -9.29536447e-02f, -1.09429955e-01f, -1.08394034e-01f, 1.14656575e-01f, -1.48310959e-02f, -9.23616365e-02f, 1.81347936e-01f, 8.36199000e-02f, -2.02713490e-01f, 1.48099661e-01f,
  -1.84031561e-01f, -9.46973860e-02f, 1.27097949e-01f, -9.89802480e-02f, 4.45063002e-02f, -1.10150911e-01f, 6.21151030e-02f, 1.40865240e-02f, -9.91356000e-03f, -4.48604999e-03f,
  -4.04180065e-02f, -9.32551920e-02f, 1.02983363e-01f, -1.06692528e-02f, -2.75555309e-02f, -3.46367992e-02f, -1.38601348e-01f, -7.83924609e-02f, 1.80399120e-02f, 1.50575906e-01f,
  1.11097574e-01f, 6.05756380e-02f, 2.21026197e-01f, 9.81722549e-02f, 1.06614269e-01f, 1.21202141e-01f, 7.13960007e-02f, -1.03348993e-01f, 2.61744838e-02f, -1.40885981e-02f,
  -7.73032606e-02f, -1.30041793e-01f, 6.40830025e-02f, -1.25814572e-01f, -7.26791769e-02f, 1.01461761e-01f, 1.43930107e-01f, 4.65497235e-03f, 5.13598621e-02f, -1.74712613e-02f,
  9.45117548e-02f, -7.10915253e-02f, 1.54586747e-01f, 8.40677917e-02f, 4.59928345e-03f, 3.24329659e-02f, -1.18943460e-01f, 1.14797637e-01f, -1.03276864e-01f, 9.10503492e-02f,
  -1.30369663e-01f, 7.32987225e-02f, 1.94788594e-02f, -1.84655860e-01f, 1.55112604e-02f, 2.70905383e-02f, 2.63627097e-02f, 2.95617301e-02f, -1.17277905e-01f, 1.08758546e-01f,
  -1.19496346e-01f, 6.79685250e-02f, 1.76399305e-01f, 2.78526731e-02f, -8.37741792e-02f, -1.23077206e-01f, -1.22745231e-01f, -1.14466816e-01f, -4.45601903e-02f, 1.42638490e-01f,
  1.69783354e-01f, 1.44244447e-01f, 1.28624355e-02f, -2.62905329e-01f, -2.37120420e-01f, -5.72775584e-03f, -1.82580911e-02f, 1.87249649e-02f, 1.77437514e-01f, 8.59520286e-02f,
  -6.35030046e-02f, 5.53714111e-02f, 1.20163232e-01f, -4.06781361e-02f, -1.23909153e-01f, -1.13520965e-01f, -2.10832834e-01f, 1.40760019e-01f, 2.82045249e-02f, -7.67829120e-02f,
  -1.67529285e-02f, 2.01025188e-01f, 2.68384665e-02f, -1.71980381e-01f, -7.58553222e-02f, -2.18066927e-02f, 4.22184989e-02f, -1.11839019e-01f, -3.58330496e-02f, 1.53537132e-02f,
  2.92405416e-03f, -5.86859137e-02f, 6.46929294e-02f, 4.96088751e-02f, 1.93930464e-03f, -1.49132907e-01f, 6.65074065e-02f, 1.11172646e-01f, 5.56078926e-02f, -9.64599401e-02f,
  -5.57132326e-02f, 1.51429743e-01f, 1.32119387e-01f, -2.29514644e-01f, 2.92927725e-03f, 1.79529756e-01f, 1.19650453e-01f, -2.20971964e-02f, -5.95006607e-02f, -2.65074894e-02f,
  -8.59146938e-02f, 1.79952413e-01f, 6.24679923e-02f, 1.16604064e-02f, 1.24378413e-01f, 1.47530407e-01f, -1.52279750e-01f, 8.12288225e-02f, -8.74803737e-02f, -2.84439102e-02f,
  2.11816594e-01f, -1.20626636e-01f, 1.47254333e-01f, -1.13532096e-01f, -1.14670619e-02f, 1.72943190e-01f, -1.26211017e-01f, -1.93784870e-02f, -8.04356262e-02f, 8.05333331e-02f,
  5.62114827e-02f, 9.28968266e-02f, 8.43201131e-02f, -5.06814048e-02f, -1.02051973e-01f, -8.66469443e-02f, 7.47636892e-04f, 5.69297820e-02f, 1.79510817e-01f, -3.85550223e-02f,
  1.98830932e-01f, 1.79817840e-01f, 5.41990697e-02f, 8.31586868e-02f, 1.07454985e-01f, -1.57232538e-01f, -9.92007926e-02f, -2.99015287e-02f, -2.00315759e-01f, -3.47741358e-02f,
  2.02044481e-04f, -4.61576879e-02f, -3.33127342e-02f, 7.62834027e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.13205105e-01f, 1.27273843e-01f, 4.09698579e-03f, 1.51591664e-02f, -3.95198017e-02f, 2.59662956e-01f, -1.60074994e-01f, -1.73107177e-01f, -6.12042844e-02f, -9.08439159e-02f,
  -5.17843328e-02f, 1.19990744e-01f, 1.51904792e-01f, -5.13064712e-02f, 2.71161944e-01f, -3.51362899e-02f, -2.76191831e-01f, 2.93811977e-01f, 2.03757837e-01f, 5.30646518e-02f,
  -6.08113641e-03f, -5.87803908e-02f, 2.00914800e-01f, -1.47549994e-02f, 2.44148403e-01f, 3.48276906e-02f, -1.76032539e-02f, -1.68102153e-04f, 6.52406961e-02f, 2.69724220e-01f,
  -9.74270403e-02f, 2.65963435e-01f, -1.09524019e-01f, -6.88539669e-02f, -7.58462325e-02f, 3.15423012e-02f, -2.66412288e-01f, 1.57834798e-01f, 4.10260893e-02f, 6.48889095e-02f,
  -1.34995393e-02f, 1.26913279e-01f, -1.87963396e-02f, 1.03354111e-01f, 2.38687977e-01f, 1.02647737e-01f, 1.48787992e-02f, 4.60818559e-02f, 1.03569381e-01f, 7.88201317e-02f,
  1.98963266e-02f, -6.29717410e-02f, 7.00975806e-02f, 8.78439546e-02f, -6.09976389e-02f, 8.31993967e-02f, -6.74155578e-02f, 2.06128120e-01f, 1.12753987e-01f, 6.78445920e-02f,
  1.39834300e-01f, 1.23063676e-01f, -2.02832356e-01f, 1.72334254e-01f, 3.86077464e-02f, 1.11515455e-01f, 1.56640336e-01f, 1.30537957e-01f, 2.06477553e-01f, -3.20412591e-02f,
  -6.76204115e-02f, 1.14892170e-01f, 1.24132611e-01f, -3.22802663e-02f, 2.96174753e-02f, 1.23669252e-01f, 3.09796482e-02f, 2.28371751e-02f, 1.54730275e-01f, 1.29105926e-01f,
  2.06240505e-01f, 1.01783432e-01f, -3.67417373e-02f, -1.00452907e-01f, -1.16135038e-01f, 1.89623535e-02f, 9.12794545e-02f, -4.57996316e-02f, 6.17092140e-02f, 2.28891850e-01f,
  -1.08828686e-01f, 2.09002167e-01f, 3.01656798e-02f, -7.78288245e-02f, 1.02616645e-01f, 4.61252555e-02f, 1.11285985e-01f, -2.21705854e-01f, -1.29334882e-01f, -7.60914700e-04f,
  1.19681627e-01f, 1.30951732e-01f, 3.48186307e-02f, 8.26499835e-02f, -7.83016831e-02f, -3.23530473e-02f, 2.65640140e-01f, 2.04314142e-02f, 6.65975315e-03f, -1.09746270e-01f,
  -1.04637958e-01f, 2.04426348e-01f, -7.39419367e-03f, 7.40954876e-02f, -4.66714464e-02f, 1.23287953e-01f, 9.07307193e-02f, 5.47202379e-02f, 1.37994573e-01f, -1.64057314e-01f,
  -6.40191138e-02f, 1.02786697e-01f, -3.74914594e-02f, 7.35580251e-02f, 2.75243516e-03f, 1.96695417e-01f, -1.55752404e-02f, 2.28203014e-01f, 3.76664363e-02f, -2.74667405e-02f,
  6.14849366e-02f, -6.12617582e-02f, 7.71718323e-02f, 1.22476190e-01f, -4.49690931e-02f, 1.73080981e-01f, 2.43577197e-01f, 2.50522852e-01f, 1.20436586e-01f, 5.01978137e-02f,
  2.28851661e-01f, -1.24781020e-02f, -9.72652286e-02f, 9.44165513e-02f, -2.07201261e-02f, -1.29049942e-01f, 1.61422387e-01f, 1.02874385e-02f, -2.18791306e-01f, 1.89377904e-01f,
  -1.94887191e-01f, 2.77429260e-02f, 1.11547215e-02f, 2.74510860e-01f, 1.67621478e-01f, -2.61403304e-02f, -1.98494419e-01f, -4.00326811e-02f, -1.53239980e-01f, -2.75005311e-01f,
  2.06144199e-01f, -1.46392494e-01f, 7.98392221e-02f, 2.07634881e-01f, -5.93916699e-02f, 5.90759739e-02f, 9.98119358e-03f, -1.52555645e-01f, 4.03551161e-02f, 8.08877945e-02f,
  1.01303039e-02f, 1.51200876e-01f, -7.18997195e-02f, -5.37847765e-02f, -1.28121436e-01f, -2.13986814e-01f, 1.44882128e-01f, -1.03853218e-01f, 1.00782298e-01f, 2.28887856e-01f,
  1.22367300e-01f, 1.66719109e-01f, -8.70288722e-03f, 2.51089990e-01f, -2.07286969e-01f, 9.22795236e-02f, -1.01052739e-01f, -6.76316917e-02f, -6.07537292e-02f, -3.76551636e-02f,
  -1.07134365e-01f, -2.34610140e-02f, 5.17084599e-02f, 7.72668864e-04f, 1.40571874e-02f, 4.74277176e-02f, -3.70160826e-02f, -1.59766838e-01f, -1.12959854e-02f, 6.85165077e-02f,
  2.99272500e-02f, -8.98229554e-02f, -1.44006968e-01f, -2.43072733e-01f, 4.58607711e-02f, -3.18058282e-02f, 1.27013162e-01f, -1.13049671e-02f, 3.46082687e-01f, -2.09335536e-01f,
  -5.67899011e-02f, -1.07324511e-01f, -4.48058061e-02f, -3.50020155e-02f, 2.73588479e-01f, -4.64035906e-02f, 2.75329947e-02f, -6.13250695e-02f, -1.80464357e-01f, 2.40697205e-01f,
  3.88799906e-02f, -3.48197594e-02f, 1.24611944e-01f, 2.19619796e-01f, -5.34204580e-02f, -4.02849540e-02f, -5.34537286e-02f, -1.23841099e-01f, -7.71139096e-03f, 1.77427828e-01f,
  1.15386732e-01f, 3.04794889e-02f, -3.31123685e-03f, 9.72508565e-02f, -6.96244789e-03f, -1.48473039e-01f, -1.57202825e-01f, -2.18231067e-01f, 7.50208274e-02f, 2.24050090e-01f,
  7.21382024e-03f, 3.33124012e-01f, 1.34579968e-02f, -2.65221953e-01f, 4.33801040e-02f, 2.27902327e-02f, 2.71177411e-01f, 6.10305741e-02f, 1.30986631e-01f, 1.50715634e-01f,
  3.18345577e-02f, 1.38165548e-01f, -1.11939646e-01f, 1.89435124e-01f, -2.09871065e-02f, 1.17600873e-01f, 9.42337885e-02f, 3.87035087e-02f, 3.25406843e-04f, 1.46069407e-01f,
  -1.95910353e-02f, 1.15609668e-01f, 1.29133075e-01f, -1.71586320e-01f, -1.42862588e-01f, 1.54182557e-02f, -5.92846647e-02f, -5.31124324e-02f, -1.54346481e-01f, 1.11402079e-01f,
  -7.49963447e-02f, -1.63544379e-02f, -2.37030938e-01f, -2.72485204e-02f, 1.46906912e-01f, 2.64533341e-01f, 1.79978773e-01f, -1.49724007e-01f, 6.09631417e-03f, 1.33698642e-01f,
  -2.11913228e-01f, -2.50327379e-01f, 2.97130436e-01f, -1.81026205e-01f, 8.35527778e-02f, 1.15593866e-01f, -1.54093206e-01f, 1.01072334e-01f, -1.69580862e-01f, 3.78719062e-01f,
  3.09471965e-01f, 9.26537532e-03f, -9.13028046e-02f, -9.11298618e-02f, -4.73454501e-03f, 5.94719276e-02f, 8.83106217e-02f, 1.36543885e-01f, -1.49466649e-01f, 1.00078158e-01f,
  1.06187075e-01f, 2.65945792e-01f, 3.65113139e-01f, -1.59525245e-01f, -1.05690248e-01f, 2.60960869e-03f, -1.51121810e-01f, -9.15563777e-02f, -1.91021010e-01f, -5.03810272e-02f,
  -7.22778663e-02f, 3.39860052e-01f, 4.25048843e-02f, -8.67028311e-02f, 1.14413723e-01f, 5.37130274e-02f, 1.46237880e-01f, -1.30169481e-01f, 6.53285459e-02f, -2.00374216e-01f,
  4.49265018e-02f, 6.72945306e-02f, -2.73369700e-02f, -6.22485876e-02f, -4.05386044e-03f, 1.58601962e-02f, -9.27335322e-02f, 2.20964625e-02f, 3.96626294e-02f, -2.04253215e-02f,
  -7.33847916e-02f, -5.75448498e-02f, 1.18862197e-01f, -4.82019708e-02f, 2.16410067e-02f, 1.08193204e-01f, 9.20044035e-02f, -7.24390745e-02f, 1.24778196e-01f, 1.70652624e-02f,
  -6.76935315e-02f, 8.85837525e-02f, 1.35491103e-01f, 3.23742479e-02f, 1.25579819e-01f, -5.84193170e-02f, -7.46887131e-03f, 8.66045654e-02f, -4.41029258e-02f, -4.18506637e-02f,
  1.88966542e-01f, 6.34288192e-02f, -9.57152434e-03f, -3.29088196e-02f, 6.93051219e-02f, 2.46974789e-02f, -1.86901599e-01f, 4.35034074e-02f, -3.53191160e-02f, -9.73170847e-02f,
  3.99940871e-02f, 2.93693721e-01f, -1.23234563e-01f, -1.58665970e-01f, -9.58051905e-02f, -1.53245568e-01f, 9.49266553e-02f, 3.05419117e-02f, 1.98876128e-01f, 7.67796561e-02f,
  2.56279409e-01f, -8.65947977e-02f, 3.46650444e-02f, 1.83658808e-01f, 6.31407350e-02f, 1.54273659e-01f, -7.01457933e-02f, 1.17666237e-02f, -1.05777383e-01f, 1.14529510e-03f,
  3.40767903e-03f, -7.22479671e-02f, -5.27443215e-02f, 9.35195461e-02f, 6.09097704e-02f, 9.49668512e-02f, 5.21036461e-02f, 5.98487258e-02f, 8.81449133e-02f, 4.84636985e-02f,
  -8.63927528e-02f, 2.76478529e-01f, 1.46728471e-01f, -1.90792456e-02f, 1.21587880e-01f, 1.30559221e-01f, 3.36042136e-01f, -1.70830905e-01f, 8.23541805e-02f, 1.33073777e-01f,
  1.92953311e-02f, 1.04595639e-01f, -1.18634123e-02f, -7.06924722e-02f, -1.16665684e-01f, 2.01163024e-01f, -5.40901311e-02f, -7.88378790e-02f, 1.43221125e-01f, 2.57021636e-01f,
  -1.49760440e-01f, -9.08822694e-04f, -9.82870013e-02f, 9.30300951e-02f, 2.04762623e-01f, -1.26629710e-01f, 2.65484542e-01f, -2.62646258e-01f, -2.06584185e-02f, 2.11940393e-01f,
  -7.05583170e-02f, 1.49350420e-01f, 6.76210076e-02f, -6.33149743e-02f, 6.21922873e-02f, -2.58637359e-03f, 1.37717068e-01f, 5.75865917e-02f, 3.50958742e-02f, -5.76741807e-02f,
  -9.82426554e-02f, -7.11739734e-02f, 2.25371018e-01f, -1.04053967e-01f, 2.60435432e-01f, 1.82163075e-01f, 2.06847548e-01f, 1.32863343e-01f, 2.80946977e-02f, -1.82108879e-01f,
  -1.84716076e-01f, 1.80407554e-01f, -1.07007079e-01f, -2.49026716e-02f, 1.47312075e-01f, 1.53105959e-01f, -1.04739361e-01f, 4.26659025e-02f, 1.36634722e-01f, 1.25143111e-01f,
  8.48914310e-02f, 1.44742310e-01f, 3.08874995e-02f, 9.46657583e-02f, -8.14971402e-02f, -1.91751048e-01f, -1.67489290e-01f, -1.85469434e-01f, -1.95961580e-01f, 2.73838252e-01f,
  -1.54989809e-02f, -2.29732901e-01f, 1.27214029e-01f, -1.70973223e-02f, -3.22750151e-01f, 3.00602555e-01f, 1.66622996e-02f, 9.75333899e-02f, 7.24715218e-02f, -1.51143998e-01f,
  2.28150129e-01f, 1.58863649e-01f, 3.57302167e-02f, -5.27467765e-02f, -2.05630790e-02f, -5.73837459e-02f, 3.73777077e-02f, 1.91058755e-01f, 9.40618441e-02f, 9.14937705e-02f,
  -1.47243842e-01f, 3.64980139e-02f, -9.87683311e-02f, -3.20574492e-02f, -2.53880143e-01f, 3.50438692e-02f, -5.63578913e-03f, 1.89206451e-01f, -3.73745821e-02f, 2.19990239e-02f,
  1.01215437e-01f, 1.78763345e-01f, 1.16862826e-01f, -2.76367571e-02f, -2.42684479e-03f, -1.30948737e-01f, -4.40767333e-02f, 3.34908254e-02f, -1.22552022e-01f, 3.22757550e-02f,
  -1.43254325e-01f, -1.58753812e-01f, 9.36955307e-03f, -4.55327369e-02f, 6.53226376e-02f, 1.42299414e-01f, 1.09757915e-01f, 1.84306040e-01f, -1.17240943e-01f, 1.31253287e-01f,
  -4.47069928e-02f, 1.50838599e-01f, 2.15362996e-01f, 1.28758922e-01f, 2.06160650e-01f, 1.04072303e-01f, 1.30140156e-01f, -1.08544035e-02f, -9.63409021e-02f, -9.08979177e-02f,
  3.40772793e-02f, -1.95859089e-01f, -2.09762473e-02f, 1.67259201e-01f, -3.51950875e-04f, 8.68160278e-02f, 2.18368828e-01f, -7.54585192e-02f, 5.25884181e-02f, 1.50387421e-01f,
  6.78202361e-02f, 5.22756483e-03f, -2.12109429e-04f, -9.94366556e-02f, 1.09040223e-01f, -3.13438661e-02f, 7.18892291e-02f, -5.21173421e-03f, -5.24814315e-02f, 1.89144611e-01f,
  7.75769055e-02f, -4.71289717e-02f, 8.65787640e-02f, 2.46794418e-01f, -4.86143790e-02f, -1.58010870e-01f, -1.88214898e-01f, -9.86493006e-02f, 1.03162080e-01f, 1.53235897e-01f,
  -7.85333961e-02f, 1.92167610e-01f, -1.76956981e-01f, 6.82097226e-02f, 2.05020890e-01f, 9.20207947e-02f, 8.75058956e-03f, -3.03799100e-02f, -1.63844079e-02f, 2.28293255e-01f,
  -1.30911255e-02f, 1.26574546e-01f, -1.38260230e-01f, 6.37571588e-02f, -1.62138492e-02f, -2.95981988e-02f, 6.31693890e-03f, -3.99313346e-02f, -5.60964867e-02f, 6.02386631e-02f,
  -8.19420815e-02f, 1.00348786e-01f, -5.07911667e-02f, 1.62888631e-01f, -9.16171521e-02f, 2.76505023e-01f, -1.61267847e-01f, 9.32678208e-02f, 8.45020730e-03f, 7.66003039e-03f,
  1.35885086e-02f, 1.37620457e-02f, -8.22259262e-02f, -5.44365719e-02f, 9.14371684e-02f, 1.94593370e-01f, 3.34052086e-01f, -8.39153007e-02f, 1.97391793e-01f, 2.19259053e-01f,
  1.33641377e-01f, -5.16568199e-02f, -3.76024060e-02f, 2.05040246e-01f, 7.03817904e-02f, -6.71511069e-02f, 9.93545428e-02f, 1.34467065e-01f, 1.66868851e-01f, -7.94537887e-02f,
  2.17727736e-01f, 1.90993939e-02f, -4.04252224e-02f, -5.29138856e-02f, 2.80224353e-01f, 7.01306015e-02f, 7.41272420e-02f, 1.41419128e-01f, 1.91452965e-01f, -5.11050373e-02f,
  -9.28888395e-02f, -6.83122948e-02f, 2.60257512e-01f, 3.02105695e-01f, 3.08301181e-01f, 6.01569712e-02f, 2.33125333e-02f, 9.65771303e-02f, -1.87990919e-01f, -1.27526760e-01f,
  1.97192580e-01f, 1.85800679e-02f, -7.75900558e-02f, 6.35342821e-02f, 2.08778545e-01f, 1.87914535e-01f, 3.53507459e-01f, -1.05118871e-01f, 7.60436878e-02f, 2.35768244e-01f,
  -6.21137768e-02f, -4.39144969e-02f, -1.22426130e-01f, 1.21020578e-01f, -4.71059605e-02f, 2.91719027e-02f, 2.74339914e-02f, 4.23252769e-02f, 3.10517311e-01f, 1.62131581e-02f,
  2.41478130e-01f, 8.81295353e-02f, 1.18308365e-01f, 9.56921652e-02f, 2.19453603e-01f, -1.10091113e-01f, -6.13181442e-02f, -4.67958190e-02f, 6.30999655e-02f, 1.23340581e-02f,
  1.02799781e-01f, 2.39588901e-01f, -6.98117465e-02f, 1.84789021e-02f, 5.81106059e-02f, 2.24986244e-02f, -5.24334945e-02f, 1.59931988e-01f, 7.25991130e-02f, 1.29190430e-01f,
  5.49009116e-03f, -9.84085426e-02f, 6.95628487e-03f, 2.48922706e-01f, -1.91056147e-01f, 1.45070761e-01f, 1.44666478e-01f, -4.90959436e-02f, 2.43775085e-01f, 5.17290682e-02f,
  -7.21253157e-02f, -6.45648986e-02f, 1.24241836e-01f, 8.28804523e-02f, -9.21311229e-02f, 5.80480993e-02f, 2.51180410e-01f, 1.51136160e-01f, 9.79614332e-02f, 2.19195932e-01f,
  -1.43485844e-01f, 1.88240279e-02f, 2.52158493e-01f, 2.72711307e-01f, -1.16706252e-01f, -8.04186761e-02f, -8.35507065e-02f, -1.22339576e-01f, -1.31085753e-01f, 9.69410911e-02f,
  -2.42407918e-01f, 2.78514892e-01f, -5.26066609e-02f, -1.74731717e-01f, -1.83711778e-02f, 1.03098296e-01f, -1.66280583e-01f, 2.82999277e-02f, -2.34605908e-01f, 1.85067564e-01f,
  -2.91696638e-01f, 2.29635552e-01f, 2.42642090e-01f, -5.84032387e-03f, 2.95169931e-02f, -9.51945037e-02f, 1.90663282e-02f, 5.64727262e-02f, -1.41808782e-02f, -4.38463129e-02f,
  -2.41803937e-02f, 1.16423316e-01f, 2.23208815e-02f, -1.48382142e-01f, -1.03789585e-04f, -9.53465998e-02f, 2.75628030e-01f, -1.82409674e-01f, 1.28599107e-01f, 8.26867074e-02f,
  2.10739091e-01f, -1.72277749e-01f, -2.04326082e-02f, -5.17834770e-03f, -3.78423668e-02f, 2.25065127e-01f, 1.63547367e-01f, -4.56541255e-02f, 1.16878606e-01f, 4.57841670e-03f,
  -2.46097431e-01f, 1.26079917e-01f, 9.23666637e-03f, 1.82921644e-02f, 1.33058846e-01f, -8.55820104e-02f, 1.59118757e-01f, -5.34085184e-02f, 4.33873907e-02f, 4.66821343e-02f,
  -1.06023148e-01f, 2.48446047e-01f, 8.42186883e-02f, -3.51660922e-02f, 1.05384335e-01f, 1.08239301e-01f, -1.72683939e-01f, -1.26939923e-01f, -1.35192856e-01f, -1.71290383e-01f,
  1.30385131e-01f, 4.38522827e-03f, 7.91277736e-02f, 2.36524954e-01f, 2.41223812e-01f, -1.58737943e-01f, 1.13037162e-01f, 7.92092904e-02f, 2.10769027e-01f, 2.89039835e-02f,
  4.62430194e-02f, 1.83804572e-01f, -5.73342144e-02f, 1.78133160e-01f, 7.75783975e-03f, 2.29110077e-01f, -4.82981466e-02f, -2.37294454e-02f, 7.71302506e-02f, 2.24350542e-01f,
  1.42428383e-01f, 5.03652021e-02f, 1.39853090e-01f, 2.05563486e-01f, -1.65490314e-01f, 1.08401202e-01f, -1.02656059e-01f, -6.54154569e-02f, -3.49609517e-02f, -1.52793020e-01f,
  -4.23342139e-02f, 2.62261569e-01f, 1.05410196e-01f, 7.44369924e-02f, 1.19998679e-01f, 2.51958013e-01f, -1.06303915e-01f, -1.62042037e-01f, 5.17038815e-02f, -2.97380835e-02f,
  3.97752412e-03f, -2.37649098e-01f, 2.30557770e-02f, 7.58181885e-02f, -5.20063378e-02f, 1.27689198e-01f, -1.09562710e-01f, 1.40389621e-01f, 3.04321289e-01f, 1.18949786e-01f,
  -2.25351274e-01f, -8.50288719e-02f, 3.77214402e-02f, 6.22088537e-02f, 5.64696006e-02f, -2.02485830e-01f, -1.46738403e-02f, -1.38876423e-01f, 1.95057198e-01f, -2.19064280e-01f,
  1.45565927e-01f, -1.08038418e-01f, 2.04929605e-01f, 1.18825406e-01f, -6.54466897e-02f, 1.69950232e-01f, -6.68051690e-02f, -8.86861086e-02f, 1.69823259e-01f, -2.47689076e-02f,
  6.13043979e-02f, -7.69231245e-02f, 1.44659325e-01f, -1.49685323e-01f, 2.95207351e-01f, 4.26287539e-02f, 3.05142313e-01f, -1.14659637e-01f, 2.55159020e-01f, 1.06511153e-02f,
  -7.13472068e-02f, 1.77416623e-01f, 4.05730419e-02f, 1.37746483e-01f, 9.02173817e-02f, 4.63164877e-03f, 1.89083278e-01f, 3.64982411e-02f, -1.68981627e-01f, 1.40745506e-01f,
  2.93163598e-01f, 3.07564408e-01f, 1.59479380e-01f, -8.26971307e-02f, 1.80724487e-01f, 1.24059990e-01f, -1.97364893e-02f, 1.26212090e-01f, 7.87519962e-02f, -6.99993223e-02f,
  1.48433596e-01f, -1.23687796e-01f, -1.45891741e-01f, 2.35025033e-01f, -1.11979460e-02f, -8.53931904e-02f, 1.56301975e-01f, 1.52075052e-01f, 2.06434190e-01f, 1.10530816e-01f,
  -1.71378240e-01f, -1.07021891e-01f, 2.37929329e-01f, 5.45219183e-02f, 4.39395010e-02f, -1.32134438e-01f, 1.06613092e-01f, 1.70776621e-01f, -5.92965744e-02f, -3.30188721e-02f,
  -8.35503116e-02f, -2.07972988e-01f, 1.64321229e-01f, 2.49353111e-01f, -5.74976392e-03f, 2.40264870e-02f, -6.39163926e-02f, -6.97912946e-02f, -2.51046196e-02f, 1.55786769e-02f,
  2.32906342e-01f, -1.20884396e-01f, 3.77127260e-01f, 1.63998559e-01f, 9.96817425e-02f, 3.34889472e-01f, -6.00946462e-03f, 2.00480938e-01f, -1.76300690e-01f, -6.62706122e-02f,
  -1.98934510e-01f, -2.10420832e-01f, 8.81319046e-02f, -1.58830568e-01f, -8.17418620e-02f, 4.68218178e-02f, -6.54317662e-02f, 8.88405144e-02f, 1.11157320e-01f, 1.08077444e-01f,
  5.97082525e-02f, -5.67051023e-02f, 5.92147745e-02f, -8.05893855e-04f, 2.02798601e-02f, 1.13419197e-01f, 8.35288838e-02f, 1.81036461e-02f, -1.34016946e-01f, 2.81289786e-01f,
  -8.11570138e-02f, -2.64932495e-02f, 2.39005648e-02f, -7.37740919e-02f, 6.02819026e-02f, 4.36062366e-02f, 1.26036495e-01f, -4.94276397e-02f, -9.92418677e-02f, 1.01017803e-01f,
  -1.85160741e-01f, -5.50834127e-02f, 1.49645731e-01f, -1.07180566e-01f, 1.96902961e-01f, -6.10806718e-02f, -2.21184075e-01f, 7.20772669e-02f, 1.17788389e-01f, 2.30411559e-01f,
  1.26308069e-01f, -5.72953857e-02f, 3.42789680e-01f, 1.88984647e-02f, 4.26751263e-02f, 1.35707542e-01f, -1.45464674e-01f, -5.44896256e-03f, 2.22620256e-02f, 3.47830802e-02f,
  6.59551173e-02f, 2.17160121e-01f, 1.85689837e-01f, -3.98505330e-02f, -1.00020900e-01f, 2.35114880e-02f, -2.08607346e-01f, 3.43661904e-02f, -5.91400601e-02f, -8.30111001e-03f,
  -1.49140686e-01f, 1.51831627e-01f, -1.97555587e-01f, -1.04114592e-01f, -9.60814282e-02f, 5.98938065e-03f, -2.29030140e-02f, -9.89389420e-02f, 2.25913271e-01f, -1.52710482e-01f,
  -6.61628246e-02f, 1.09528648e-02f, -8.77131522e-02f, -1.31012395e-01f, 9.19936877e-03f, 1.04027621e-01f, 2.99491771e-02f, 9.01839137e-02f, -1.63065884e-02f, 1.97499041e-02f,
  6.89312965e-02f, -1.00258090e-01f, 1.63551122e-01f, -1.96004033e-01f, 4.04434279e-02f, -4.03360799e-02f, -8.46186653e-02f, 1.65720120e-01f, 2.37622447e-02f, 4.24160361e-02f,
  -1.19894944e-01f, 1.25042930e-01f, -3.71898487e-02f, -2.83904630e-03f, 5.07734716e-02f, 2.61204869e-01f, -1.30928352e-01f, -8.95497799e-02f, -6.21519089e-02f, 1.92970842e-01f,
  -2.23449618e-01f, -1.02449499e-01f, 3.92283410e-01f, -7.88336024e-02f, -4.85435203e-02f, 6.32959157e-02f, -1.04193009e-01f, 1.66091427e-01f, 3.05316389e-01f, -1.19888581e-01f,
  4.58814315e-02f, -7.33021870e-02f, -4.66537699e-02f, 1.57050401e-01f, 1.34387627e-01f, -8.36456660e-03f, -2.02608570e-01f, -8.91273618e-02f, 1.01257198e-01f, 1.22899108e-01f,
  -6.81036413e-02f, 1.04526974e-01f, 2.46117756e-01f, 1.67094260e-01f, 9.94847193e-02f, -3.76658179e-02f, 1.69117674e-01f, 2.40153387e-01f, 3.58468026e-01f, 1.96672939e-02f,
  4.13869061e-02f, 1.93381697e-01f, -7.16292113e-02f, -4.20470461e-02f, 6.92419037e-02f, -3.44741568e-02f, 3.57429846e-04f, -5.48464656e-02f, -1.54838264e-02f, -1.75766408e-01f,
  2.11454064e-01f, -5.93900755e-02f, 5.12069389e-02f, 9.40169767e-02f, -1.37569562e-01f, 1.79482639e-01f, -2.80394591e-02f, -1.81328982e-01f, -2.86823381e-02f, 7.04829469e-02f,
  3.42418416e-03f, -1.16214722e-01f, 1.94197461e-01f, 6.17300048e-02f, -1.66763160e-02f, 7.50198811e-02f, 3.89271043e-02f, 1.15619726e-01f, 7.50823244e-02f, 1.35151386e-01f,
  7.83224329e-02f, 1.26607314e-01f, -8.90720263e-02f, -9.00613740e-02f, -1.96576163e-01f, 9.96493697e-02f, 2.16546595e-01f, 1.36561140e-01f, 8.26304927e-02f, 9.74675566e-02f,
  -1.02676898e-01f, -6.46378845e-02f, -9.43914056e-02f, 1.09124705e-01f, -5.76225333e-02f, 1.97374701e-01f, 9.80595350e-02f, 1.99496672e-01f, -7.00167641e-02f, -1.55930892e-02f,
  5.40622734e-02f, 3.06135342e-02f, 1.57217458e-01f, 2.61515379e-02f, -4.84663732e-02f, 2.45272622e-01f, 1.49167612e-01f, 1.84709847e-01f, -2.52465680e-02f, 1.89919710e-01f,
  -1.68872848e-01f, -1.20367929e-01f, -1.34609148e-01f, -8.74941498e-02f, -1.10302903e-01f, -8.06950480e-02f, -1.03083432e-01f, 1.53819159e-01f, 1.48265705e-01f, -1.23576187e-01f,
  1.13593765e-01f, 8.54959711e-02f, -9.89883207e-03f, -2.29990229e-01f, 3.00313145e-01f, 2.00511026e-03f, -7.88064897e-02f, -1.76007167e-01f, -1.84703395e-01f, 4.90206443e-02f,
  -1.46617189e-01f, 4.83882651e-02f, -1.38513386e-01f, 4.73547690e-02f, 3.00775230e-01f, -1.70234889e-01f, -1.29294142e-01f, 2.13716611e-01f, 3.07784945e-01f, -4.32439595e-02f,
  -3.74506712e-02f, 1.43846080e-01f, -1.58110946e-01f, -8.18262249e-02f, 8.12194124e-03f, 9.57308859e-02f, 2.04945311e-01f, -1.44947886e-01f, -7.39040002e-02f, -5.85809313e-02f,
  1.67431459e-01f, 3.22615355e-01f, 1.18642129e-01f, 1.93123035e-02f, 3.19824934e-01f, -8.98245722e-02f, -1.86466649e-02f, 2.59669542e-01f, 3.13754417e-02f, -7.87191838e-03f,
  1.13345377e-01f, -5.43361604e-02f, -2.86554191e-02f, 1.04682297e-01f, 2.07320184e-01f, 9.98938605e-02f, -6.97874352e-02f, 2.92198509e-02f, -2.29776174e-01f, 8.86550769e-02f,
  -7.09656626e-02f, -1.37865946e-01f, 2.27728501e-01f, -1.44086286e-01f, 1.76527739e-01f, -1.09687813e-01f, 6.85338601e-02f, 8.43439549e-02f, -7.82310739e-02f, -7.39441365e-02f,
  2.88790792e-01f, 3.58540416e-02f, 9.55282226e-02f, 1.54332221e-01f, 1.68542668e-01f, 4.45015170e-02f, 1.96672544e-01f, 2.95464724e-01f, -2.29977325e-01f, -3.51049639e-02f,
  -2.56583560e-02f, -9.06109288e-02f, 1.25002235e-01f, -4.62717302e-02f, 1.12823777e-01f, 2.76711017e-01f, 1.09211482e-01f, -6.58338144e-02f, 4.64378111e-02f, 3.28851253e-01f,
  -1.87468659e-02f, -4.34670970e-02f, 4.40447144e-02f, -1.19373314e-01f, 6.71698824e-02f, -8.86093751e-02f, 9.57288779e-03f, -7.42192799e-03f, 2.92782746e-02f, 3.62365395e-02f,
  1.39829859e-01f, 1.23630814e-01f, 1.66170731e-01f, 1.36339217e-01f, -7.90391937e-02f, -1.36643380e-01f, -1.62478045e-01f, -1.46274343e-01f, 2.31684387e-01f, 1.44859150e-01f,
  1.89038858e-01f, 1.30707696e-01f, -5.82529977e-02f, -1.69212326e-01f, 9.36390087e-02f, 2.89783441e-02f, 1.94058999e-01f, 5.04752919e-02f, -1.67576626e-01f, 9.28685293e-02f,
  -1.51712209e-01f, 7.95191452e-02f, -1.47643453e-02f, -8.25449675e-02f, 5.79385832e-03f, -1.33896679e-01f, 6.80717304e-02f, -3.55137363e-02f, 1.89689636e-01f, 2.03668490e-01f,
  2.28625715e-01f, 8.45664069e-02f, -1.21892914e-02f, 2.02047080e-01f, 1.25415415e-01f, 2.74548363e-02f, -6.55419230e-02f, 2.30068713e-02f, -1.00570973e-02f, -1.29472777e-01f,
  -4.58543822e-02f, -1.53632537e-01f, 3.05382878e-01f, 4.18644538e-03f, 5.07451780e-02f, 2.44807662e-03f, -1.74349695e-01f, -1.70729145e-01f, 9.55185760e-03f, -9.72225741e-02f,
  1.00490358e-02f, -7.69461244e-02f, 4.16748732e-01f, -1.61824510e-01f, 9.18520316e-02f, -7.71969184e-02f, -2.61872225e-02f, 4.06545550e-02f, -7.94945359e-02f, -9.90349203e-02f,
  1.33483812e-01f, 2.21315563e-01f, -1.50304049e-01f, 3.02279741e-01f, -1.60129473e-01f, -1.65847242e-01f, -2.10544825e-01f, 1.33626536e-01f, 3.85288447e-01f, -6.58136159e-02f,
  -4.15150821e-02f, -2.19633002e-02f, 1.46188825e-01f, -5.71647007e-03f, 7.14809224e-02f, -2.97466423e-02f, -2.17290804e-01f, 3.87374498e-02f, 9.24981534e-02f, 5.18458486e-02f,
  -2.80009657e-02f, 5.46830939e-04f, -7.03150034e-02f, 4.09916550e-01f, 1.62966371e-01f, 1.52011171e-01f, -1.14832379e-01f, 1.83545947e-01f, 2.75651574e-01f, 2.92975992e-01f,
  1.42505750e-01f, -1.41392872e-01f, 2.17643470e-01f, 5.83143570e-02f, 1.44652471e-01f, -1.82543755e-01f, -8.74945968e-02f, -5.58231920e-02f, -1.46430090e-01f, 2.02902794e-01f,
  2.13137865e-01f, 9.86862257e-02f, 2.25291207e-01f, 1.85918480e-01f, 9.67054740e-02f, -2.50099320e-02f, 2.62807403e-02f, -7.56925717e-02f, -4.41206470e-02f, -8.13327208e-02f,
  -1.53415546e-01f, 6.47412464e-02f, -3.14615853e-02f, 4.19981331e-02f, 4.77845035e-02f, 1.03055492e-01f, -2.11484600e-02f, -8.71591121e-02f, 9.90528315e-02f, 1.54384479e-01f,
  1.07694127e-01f, -3.92732695e-02f, 1.54940039e-01f, 9.04290378e-02f, -1.51188318e-02f, -2.13574618e-01f, 1.23742767e-01f, 1.56999975e-01f, 1.34238703e-02f, -2.44626105e-02f,
  2.37308607e-01f, 2.03060061e-01f, -3.07715744e-01f, 2.52253920e-01f, 1.57624766e-01f, 6.87596649e-02f, -1.07968606e-01f, -3.16957533e-02f, -2.07051575e-01f, 1.49427533e-01f,
  1.07009232e-01f, 2.36145124e-01f, 1.44231930e-01f, -5.38003817e-03f, -1.81709990e-01f, 3.09111271e-02f, 3.48105371e-01f, 1.46389350e-01f, -5.78348823e-02f, 7.48940706e-02f,
  -9.81846172e-03f, -2.56135128e-02f, -1.57668427e-01f, -8.70378390e-02f, 1.07750949e-02f, 2.26106048e-01f, -8.50340053e-02f, -7.32686818e-02f, -1.74993277e-01f, 8.09248388e-02f,
  1.51950911e-01f, 3.37027870e-02f, -1.52593762e-01f, 1.37722194e-01f, 6.85797855e-02f, 4.18836065e-02f, 4.69679497e-02f, 2.40343399e-02f, 1.02174707e-01f, 9.60394070e-02f,
  9.60390121e-02f, 3.27014714e-01f, 1.36171266e-01f, -1.44922631e-02f, -4.83468883e-02f, -1.20714419e-01f, 2.64625311e-01f, -2.25030836e-02f, -6.91607073e-02f, 1.49414390e-01f,
  3.52935165e-01f, -9.18609574e-02f, -6.29770458e-02f, -9.71781909e-02f, -1.22651920e-01f, 2.30991483e-01f, -1.70692176e-01f, -3.20558697e-02f, -2.49035973e-02f, 2.36727580e-01f,
  -7.62486160e-02f, 1.51531011e-01f, -2.28913337e-01f, -8.36372226e-02f, 1.14718862e-01f, -2.31772512e-01f, 2.57511169e-01f, -1.49821058e-01f, 7.47695705e-03f, 1.49414286e-01f,
  1.89770311e-01f, -4.46529090e-02f, 5.56661524e-02f, -1.76797748e-01f, 1.07738845e-01f, -6.98407292e-02f, 2.09649727e-01f, 6.54936060e-02f, -1.03332102e-01f, -2.62585636e-02f,
  -9.69940275e-02f, 1.04679197e-01f, 1.08081214e-01f, -9.49650407e-02f, 7.78425261e-02f, 2.14327782e-01f, 2.10329950e-01f, 6.89441636e-02f, 2.04833075e-01f, -1.61842719e-01f,
  2.14731395e-01f, 9.97794122e-02f, 1.87346920e-01f, -1.01001337e-01f, 1.41396672e-01f, 5.75190373e-02f, -5.20036221e-02f, 4.55326699e-02f, 1.10126518e-01f, 1.16283968e-01f,
  7.65590323e-03f, -1.64042860e-02f, -3.75116989e-02f, 2.64092207e-01f, -1.17289811e-01f, 9.94826108e-03f, -8.59989896e-02f, 4.38313175e-04f, -4.67077158e-02f, -3.75543326e-01f,
  1.80633262e-01f, -1.60476111e-03f, 1.61387492e-02f, -7.00776419e-03f, 6.70255497e-02f, -1.97314750e-02f, 1.68742061e-01f, 1.58790983e-02f, -2.79080030e-02f, 1.29571363e-01f,
  5.64418063e-02f, 6.93146093e-03f, 1.15198061e-01f, -3.45218964e-02f, 1.53626055e-01f, 6.01429455e-02f, -9.98036265e-02f, 2.09672898e-01f, 1.94285661e-02f, 8.01043510e-02f,
  -8.36579949e-02f, 1.22085296e-01f, 1.12064593e-01f, 2.82095708e-02f, -2.15648085e-01f, 1.28978387e-01f, 1.02055199e-01f, -1.91148832e-01f, 2.38631144e-01f, 1.99628025e-01f,
  -2.18394905e-01f, -2.77482923e-02f, 3.60089466e-02f, 2.10960507e-02f, 7.74463266e-02f, 6.32477552e-02f, 1.36601195e-01f, 1.70384407e-01f, 2.15343595e-01f, -1.26693174e-01f,
  9.42552742e-03f, 8.17568079e-02f, 1.63082540e-01f, 3.07523966e-01f, 3.47777545e-01f, 2.07736135e-01f, 3.38937074e-01f, 3.97584699e-02f, 1.07414067e-01f, 9.25981626e-02f,
  -1.45879164e-01f, -1.41055346e-01f, 2.29126900e-01f, 1.32487297e-01f, 2.20410734e-01f, 1.68781340e-01f, 1.98223442e-01f, 2.08938364e-02f, 4.42265607e-02f, -2.29111746e-01f,
  -2.92024501e-02f, -1.88722264e-03f, -1.08575977e-01f, 1.42825454e-01f, -6.12565614e-02f, 4.48401682e-02f, -4.75368276e-02f, 5.57200871e-02f, -1.19400971e-01f, 9.18583199e-02f,
  9.08620059e-02f, 2.54285365e-01f, 1.50526091e-01f, -1.00464933e-01f, 3.25635336e-02f, 2.51410037e-01f, -1.96166590e-01f, -1.48762286e-01f, 3.13018709e-01f, -5.03055491e-02f,
  8.43729973e-02f, 3.00224964e-02f, 1.67801395e-01f, 1.43047780e-01f, -2.16272369e-01f, 2.24391982e-01f, 8.34528729e-02f, -3.16316299e-02f, 6.27331212e-02f, -1.45225093e-01f,
  -1.67876929e-01f, 2.10274771e-01f, -5.91198914e-03f, 1.61769316e-01f, 1.05880246e-01f, 1.29937291e-01f, -7.46469349e-02f, 2.12758072e-02f, 1.72151178e-01f, -1.26923472e-01f,
  -1.01045065e-01f, -8.99372473e-02f, -1.27224222e-01f, 1.12845279e-01f, -2.60216415e-01f, -3.92732732e-02f, 8.21746327e-03f, 1.64320827e-01f, -9.76627395e-02f, -1.49501070e-01f,
  -2.41441041e-01f, 7.34591931e-02f, -1.49852931e-01f, -9.40320417e-02f, 1.45083576e-01f, -2.10044943e-02f, 1.02994904e-01f, 1.60537228e-01f, 1.93352610e-01f, 9.45718512e-02f,
  1.85708031e-01f, 1.21262476e-01f, -2.81619504e-02f, 1.71745241e-01f, 1.56357646e-01f, 8.56701843e-03f, -8.05080235e-02f, -1.23934537e-01f, 1.42145082e-01f, 1.46545783e-01f,
  5.78850098e-02f, 1.40759617e-01f, 3.31258923e-01f, -8.93194973e-02f, -2.52142195e-02f, -7.35083148e-02f, -8.43153968e-02f, 1.54616669e-01f, -4.29290067e-03f, -5.58404215e-02f,
  1.33340612e-01f, 6.74618483e-02f, 4.98690344e-02f, 2.38296807e-01f, -1.51366860e-01f, -9.38823894e-02f, 3.02866936e-01f, 4.98777144e-02f, -7.25195557e-02f, -1.11119151e-01f,
  4.90340963e-02f, 7.58499950e-02f, 1.32208943e-01f, -4.78376076e-02f, -8.93068537e-02f, -1.00476369e-01f, 1.03026211e-01f, 1.17436856e-01f, 1.18456177e-01f, -1.96058899e-02f,
  -8.85227025e-02f, -5.28124087e-02f, 2.00456195e-02f, 2.60680079e-01f, 9.09932479e-02f, -6.68765530e-02f, 2.00231642e-01f, 1.27586842e-01f, 4.13930006e-02f, 1.82820961e-01f,
  5.94124533e-02f, 5.25877587e-02f, 1.21111199e-01f, 6.83526415e-03f, -3.29282470e-02f, -1.77911952e-01f, 1.26042441e-01f, -1.00792527e-01f, -2.73072310e-02f, 1.60936698e-01f,
  1.68086872e-01f, 9.04440787e-03f, 1.31508246e-01f, 1.25427902e-01f, 7.73069933e-02f, 8.81544687e-03f, 8.84758756e-02f, 2.95018882e-01f, 1.73875801e-02f, 7.62285218e-02f,
  -1.14670455e-01f, -1.67605668e-01f, 3.00784465e-02f, 8.98725986e-02f, -1.07206896e-01f, 1.30290702e-01f, 3.09885055e-01f, -3.01303476e-01f, -1.59420252e-01f, -3.82076837e-02f,
  4.52183932e-02f, 1.55117065e-01f, -6.33998364e-02f, 9.97043848e-02f, -1.49390563e-01f, 8.55361149e-02f, 1.55731380e-01f, 1.86124235e-01f, -1.70680165e-01f, -6.55720308e-02f,
  2.35792562e-01f, -1.47160903e-01f, -1.22245185e-01f, 2.20802963e-01f, 3.04376125e-01f, 1.80841967e-01f, 3.27994339e-02f, -1.16818376e-01f, -6.68941438e-02f, -1.37109965e-01f,
  3.05406809e-01f, -2.74212137e-02f, 1.62708446e-01f, 3.90593559e-02f, -2.28502303e-01f, 4.11527678e-02f, 2.51888931e-01f, 8.90337601e-02f, -1.20814323e-01f, 3.89021747e-02f,
  1.22333542e-01f, 1.25470236e-01f, -3.65355760e-02f, -1.29592210e-01f, 1.89708337e-01f, 2.12233141e-01f, 1.34400517e-01f, -6.62492588e-02f, -2.61882767e-02f, -4.69746813e-02f,
  1.08073540e-01f, -5.54357097e-02f, -7.65066072e-02f, -5.27775958e-02f, 2.02554822e-01f, 1.68001242e-02f, 4.47408296e-02f, 9.33034495e-02f, 6.46750629e-02f, 9.56242234e-02f,
  2.16502741e-01f, -3.02174576e-02f, -1.07473888e-01f, -9.83194634e-02f, -2.99309373e-01f, 6.35970831e-02f, -1.60016641e-01f, -1.00494258e-01f, -7.29024643e-03f, 1.05102032e-01f,
  -9.49441120e-02f, 1.13213427e-01f, -3.64926606e-02f, 1.70806482e-01f, 3.91699038e-02f, -7.44886175e-02f, 1.21527137e-02f, 5.48414625e-02f, -6.90258443e-02f, 5.82011677e-02f,
  -6.44015521e-03f, 6.07347302e-02f, -1.27617687e-01f, 1.51954919e-01f, -6.57522157e-02f, 4.98294495e-02f, -7.31042400e-02f, 1.18960254e-01f, 1.35395467e-01f, 1.45448163e-01f,
  -1.53672069e-01f, -2.82899618e-01f, -8.43316615e-02f, -1.96116423e-04f, 1.38653859e-01f, -1.87289074e-01f, 1.98016360e-01f, 1.85078532e-01f, 2.10994601e-01f, 1.59499288e-01f,
  5.63145168e-02f, 6.69526234e-02f, -1.22963265e-01f, -1.41900167e-01f, -1.67767495e-01f, 1.52383268e-01f, 4.63059470e-02f, -9.10465717e-02f, 1.09908126e-01f, -4.70895171e-02f,
  2.90039867e-01f, -4.10852721e-03f, 2.96875745e-01f, 9.06089041e-03f, 1.16741307e-01f, -4.01861817e-02f, -6.85236380e-02f, 2.18973964e-01f, -4.18406213e-03f, 7.52988085e-02f,
  -9.91500691e-02f, -7.44837224e-02f, -6.36305138e-02f, 3.01151663e-01f, -8.60790387e-02f, -4.80339900e-02f, -1.19372401e-02f, 5.11474460e-02f, 2.33326778e-02f, -6.34885728e-02f,
  1.64937183e-01f, -1.39547721e-03f, 9.33001786e-02f, -1.49167776e-01f, -3.04114133e-01f, 1.57951936e-01f, 2.47142538e-01f, 8.92254114e-02f, 5.18196262e-03f, 4.96467352e-02f,
  8.11779425e-02f, -2.02330835e-02f, 1.21688560e-01f, 4.37624082e-02f, 1.24448262e-01f, -1.46637172e-01f, -5.16719818e-02f, 2.69396156e-01f, -2.92263806e-01f, 4.87963371e-02f,
  1.18731307e-02f, 6.58279136e-02f, 5.66823296e-02f, 6.03753068e-02f, -2.73918003e-01f, 1.98822498e-01f, 1.35199890e-01f, -1.02762312e-01f, 5.01804650e-02f, 1.36499345e-01f,
  -2.45512947e-01f, 1.50564089e-01f, 1.74245059e-01f, 1.39398441e-01f, 2.39727572e-02f, -1.19319208e-01f, 1.10581838e-01f, 1.54998422e-01f, 3.71988816e-03f, -1.20140538e-01f,
  7.66196027e-02f, 1.20953768e-01f, -1.16916947e-01f, 3.29821497e-01f, 2.42613014e-02f, 2.24715322e-01f, 2.66318232e-01f, 7.80943781e-02f, 1.64324388e-01f, 1.42678469e-01f,
  -2.46565700e-01f, -1.13073200e-01f, 2.10464727e-02f, -2.66611576e-02f, 4.47354540e-02f, 1.26356659e-02f, 5.59520088e-02f, -1.22237742e-01f, 1.41191587e-01f, -5.10008782e-02f,
  8.91941860e-02f, -2.47329031e-03f, -7.35274777e-02f, 1.20408982e-01f, -6.70449138e-02f, -8.52547064e-02f, 4.04111966e-02f, 8.24492127e-02f, 4.50004563e-02f, 4.59892163e-03f,
  7.23209605e-02f, -8.50479305e-02f, -5.80929928e-02f, 2.51233019e-02f, 8.74141902e-02f, 9.01163742e-03f, 8.86370763e-02f, 1.70021340e-01f, -5.54386191e-02f, 1.76285744e-01f,
  -3.22675556e-02f, -9.27003995e-02f, -3.18415426e-02f, 1.46112472e-01f, 9.44423079e-02f, -9.45523605e-02f, -1.29972305e-02f, 5.68705164e-02f, -2.35604327e-02f, -4.81241234e-02f,
  -8.59609693e-02f, 1.21450394e-01f, -1.34567216e-01f, 1.27714261e-01f, 2.15154693e-01f, 9.60513130e-02f, 4.82663997e-02f, -7.34543502e-02f, -1.09582860e-02f, 1.64440036e-01f,
  1.01044141e-01f, -2.41214987e-02f, -7.16743320e-02f, 1.99841902e-01f, 1.54932827e-01f, 1.20988391e-01f, 3.92653048e-02f, -5.78564070e-02f, -1.32131293e-01f, -7.50928223e-02f,
  -9.97442529e-02f, -6.68714121e-02f, -1.62641406e-02f, -5.60802929e-02f, -1.05917659e-02f, 2.24266022e-01f, 2.10614219e-01f, 6.98644221e-02f, 2.82410622e-01f, 2.17151210e-01f,
  2.13098481e-01f, -6.17426634e-02f, 1.41647190e-01f, 1.84789166e-01f, -3.65625583e-02f, -2.01649010e-01f, -1.52896404e-01f, 1.79552272e-01f, 2.46964232e-03f, 6.34389669e-02f,
  -4.31807898e-03f, 1.88367113e-01f, 2.17310533e-01f, -5.89032955e-02f, -1.46908984e-01f, 8.05287138e-02f, 1.57826245e-01f, 1.19663768e-01f, -3.60912755e-02f, 8.18894878e-02f,
  -5.30495346e-02f, 8.87097716e-02f, -6.60031065e-02f, 1.76412821e-01f, -4.39681858e-02f, -8.18753466e-02f, 2.60852426e-01f, -8.19954053e-02f, -4.16286588e-02f, 1.69043720e-01f,
  1.40659824e-01f, 2.50484675e-01f, 1.34147510e-01f, -1.58660382e-01f, -2.73303449e-01f, 1.22431360e-01f, 7.95042366e-02f, -1.41910568e-01f, 4.25021738e-01f, 1.12033356e-03f,
  -1.18843332e-01f, 9.27301049e-02f, 2.65217990e-01f, 1.34498179e-01f, -8.78595859e-02f, -1.20463267e-01f, -1.44208467e-03f, 2.83806145e-01f, 1.78429857e-02f, -1.49521366e-01f,
  1.00771144e-01f, -1.45203605e-01f, -9.59540904e-03f, -9.34619904e-02f, -1.35499105e-01f, 4.89316210e-02f, 1.50738463e-01f, -4.44500819e-02f, -7.56486459e-03f, 1.67639717e-01f,
  7.62957484e-02f, 1.33676857e-01f, 7.83845335e-02f, 6.50378615e-02f, 1.50489107e-01f, 1.74261510e-01f, 1.05612643e-01f, 1.97256744e-01f, 1.26516744e-01f, 1.68775931e-01f,
  -2.42863819e-02f, 1.27978362e-02f, 1.98288485e-01f, 5.65951429e-02f, -1.45611838e-01f, 8.66887122e-02f, -2.79637072e-02f, -2.61093080e-01f, 1.09259844e-01f, 1.08408630e-01f,
  6.16449164e-03f, 2.21884087e-01f, -1.43002495e-01f, 5.73021472e-02f, 8.22284073e-02f, 1.45280242e-01f, 2.32422739e-01f, -9.10119992e-03f, -1.25002801e-01f, 6.20190911e-02f,
  -1.61002204e-02f, -1.87838271e-01f, 9.54601541e-02f, 1.72692761e-01f, 2.50830382e-01f, 3.01983118e-01f, -1.11250490e-01f, -3.32599916e-02f, -9.61295739e-02f, -7.60821030e-02f,
  1.56250030e-01f, 9.79588404e-02f, 1.27106588e-02f, 1.28711835e-01f, -3.50396596e-02f, 1.80223048e-01f, 1.46849811e-01f, -2.08963424e-01f, 1.23697199e-01f, -1.29967138e-01f,
  1.55564174e-01f, 1.83302402e-01f, 1.22972250e-01f, 1.02339946e-01f, -5.78345396e-02f, 3.28542203e-01f, -1.43992126e-01f, -6.42258152e-02f, -6.45359904e-02f, -1.04655705e-01f,
  2.25345239e-01f, -1.30050048e-01f, -1.29083514e-01f, -1.01483203e-01f, -8.25205073e-02f, 1.37572452e-01f, -3.24290362e-04f, 5.30362613e-02f, 5.26658678e-03f, 1.47683069e-01f,
  -1.12001680e-01f, 2.13721082e-01f, 7.35407770e-02f, 1.26566142e-01f, 2.75100797e-01f, -2.55293190e-01f, 3.14565629e-01f, 3.11176300e-01f, 8.27367380e-02f, -4.45837826e-02f,
  2.37141147e-01f, -8.67134705e-02f, -6.16291314e-02f, -1.02223426e-01f, 1.62954852e-01f, 1.76653653e-01f, -2.68830471e-02f, -1.44764006e-01f, 1.04443967e-01f, -6.49838150e-03f,
  -9.46531910e-03f, -4.06075530e-02f, 1.75701931e-01f, 3.29408869e-02f, 2.27645651e-01f, -4.86273207e-02f, 1.15217693e-01f, -5.87445460e-02f, 5.57283126e-02f, -3.25850248e-02f,
  2.96288341e-01f, 2.61909157e-01f, 2.75786340e-01f, 2.12669093e-02f, 2.07592472e-01f, -1.41520098e-01f, -1.55074894e-01f, -1.81124225e-01f, 1.01740450e-01f, 1.66741550e-01f,
  9.86004770e-02f, 4.47281078e-02f, 4.40672003e-02f, 1.24812707e-01f, 3.09711069e-01f, -2.11629614e-01f, 1.82896089e-02f, 4.63869460e-02f, 9.23350602e-02f, -6.63888529e-02f,
  1.02381445e-01f, 2.17078015e-01f, 1.34433135e-01f, 3.10129412e-02f, 2.54207730e-01f, 1.27441391e-01f, 1.37384146e-01f, -1.22549035e-01f, 1.46721810e-01f, 1.90961286e-01f,
  1.08514026e-01f, 1.59674242e-01f, 1.84046522e-01f, 2.12201715e-01f, -2.40192413e-01f, 2.06512243e-01f, 1.22281529e-01f, 7.15590268e-02f, 2.32770711e-01f, -6.82640746e-02f,
  1.66515112e-01f, 3.43955010e-01f, 1.70125037e-01f, 9.41841491e-03f, 1.13708332e-01f, -1.00581544e-02f, 5.75449020e-02f, -6.23078048e-02f, 4.04082090e-02f, 2.46390477e-02f,
  -4.32620794e-02f, -2.68421080e-02f, -1.46941721e-01f, 2.43202113e-02f, 2.02548444e-01f, 2.98078880e-02f, 1.85979098e-01f, 4.84103113e-02f, 1.00880690e-01f, 1.23159066e-01f,
  -2.20720530e-01f, 4.04228456e-02f, 1.33401707e-01f, -7.12019876e-02f, 3.08879584e-01f, 3.04924369e-01f, 5.77664897e-02f, 5.81785887e-02f, 3.73421386e-02f, 6.38551638e-02f,
  4.62427400e-02f, 1.02439463e-01f, 2.25691088e-02f, 1.42001435e-01f, 1.77972585e-01f, -3.57710384e-02f, -1.94493204e-01f, 1.17187522e-01f, 5.44999130e-02f, -8.70578066e-02f,
  -1.04107611e-01f, -1.36983946e-01f, -1.83911756e-01f, 2.57478774e-01f, -1.46226987e-01f, 8.63464400e-02f, -1.67268157e-01f, 7.13020340e-02f, 2.04115748e-01f, 2.66152978e-01f,
  -4.06328356e-03f, -1.24536768e-01f, 1.08217493e-01f, 5.04919179e-02f, 1.30355045e-01f, 1.01574980e-01f, 1.97190732e-01f, -4.36560735e-02f, -5.92665151e-02f, 8.91102776e-02f,
  1.69418588e-01f, 2.22161904e-01f, 1.79745987e-01f, 1.12143360e-01f, 5.00388257e-02f, -7.39104534e-03f, -1.21359281e-01f, 3.20487916e-01f, 1.26027212e-01f, 2.76310602e-03f,
  1.83358453e-02f, 6.09313659e-02f, -6.01344742e-02f, 2.35046864e-01f, -7.52984136e-02f, 1.47172451e-01f, -8.33623335e-02f, 1.27331212e-01f, 1.94971114e-01f, -1.20900355e-01f,
  9.76881608e-02f, -6.38115704e-02f, 2.14349896e-01f, -1.86207607e-01f, 1.63676977e-01f, 8.37645903e-02f, 1.66428939e-01f, 1.76323026e-01f, 1.67087048e-01f, -8.01804960e-02f,
  8.09678435e-02f, -9.94349644e-02f, 1.93975866e-01f, 8.53301585e-02f, 2.56375801e-02f, 1.33589119e-01f, -1.10280789e-01f, -9.14352089e-02f, -2.59127766e-02f, -1.95493445e-01f,
  1.12252086e-01f, -1.35945424e-01f, 2.15450436e-01f, 3.23944598e-01f, -1.54714659e-03f, 8.63937810e-02f, 8.85474980e-02f, 8.49686265e-02f, -1.41350046e-01f, -6.83419332e-02f,
  -2.09803730e-01f, -1.03749866e-02f, -9.09649059e-02f, -1.00620419e-01f, 3.29340667e-01f, -5.25141507e-02f, 1.60968304e-01f, 1.97187215e-01f, 9.67701524e-02f, 2.78480332e-02f,
  1.93230957e-01f, 1.11821651e-01f, -1.14462502e-01f, 1.46353059e-02f, -7.05763325e-02f, -1.33414119e-01f, -1.62089244e-01f, -1.97661921e-01f, -6.24251552e-02f, -6.25136197e-02f,
  7.10648820e-02f, 4.41714823e-02f, 2.91403592e-01f, 3.11825603e-01f, -1.05545253e-01f, -1.15881689e-01f, -6.50694370e-02f, -6.47494122e-02f, 5.60226776e-02f, -1.06672041e-01f,
  4.40808274e-02f, -8.16324502e-02f, -3.73209193e-02f, 2.16167897e-01f, -1.34162560e-01f, 8.21526721e-02f, 3.78466219e-01f, 1.51986390e-01f, -1.42778113e-01f, -1.83431387e-01f,
  -1.32298186e-01f, -4.90888320e-02f, -1.49708334e-02f, -1.75007388e-01f, 3.49944644e-02f, -1.01520821e-01f, 6.14110380e-02f, -7.03995973e-02f, 2.12580487e-01f, -1.63851939e-02f,
  4.37904336e-02f, -1.65727049e-01f, -1.96519196e-01f, 2.10885152e-01f, 4.52992925e-03f, -3.26715708e-02f, 9.99296978e-02f, -4.31220457e-02f, -5.51093146e-02f, -6.92510232e-02f,
  2.35678971e-01f, -1.82963938e-01f, 4.47555155e-01f, 9.03622806e-02f, 3.10692877e-01f, -7.52142370e-02f, -3.31405876e-03f, 2.67094523e-02f, 4.12178747e-02f, 2.03321755e-01f,
  6.01847880e-02f, 8.61074328e-02f, 9.25499350e-02f, 3.49346176e-02f, 4.03483920e-02f, 2.23683938e-01f, -1.82618588e-01f, -1.04649119e-01f, -5.73253892e-02f, -1.72516685e-02f,
  2.72672892e-01f, 5.69480807e-02f, 2.29026571e-01f, 7.08848462e-02f, 1.41317368e-01f, 6.18191324e-02f, -1.16475493e-01f, 4.71592426e-01f, -1.07682068e-02f, 2.29062587e-02f,
  3.31066130e-03f, 1.94512811e-02f, 1.23321809e-01f, 7.32012317e-02f, 8.79767463e-02f, 5.85523546e-02f, -1.03506796e-01f, -1.74505740e-01f, 2.98128247e-01f, 1.85634464e-01f,
  1.03468493e-01f, 1.27789862e-02f, 1.99592322e-01f, -1.76436543e-01f, -1.69216841e-01f, -8.19854066e-02f, 1.55807242e-01f, 2.24374026e-01f, 3.42424721e-01f, 8.28064233e-02f,
  1.33482618e-02f, -1.23525210e-01f, -3.87679487e-02f, 6.44300506e-02f, 2.88495064e-01f, -7.77119771e-02f, -2.90663421e-01f, -1.44099742e-01f, 9.38377827e-02f, -5.95014077e-03f,
  1.73500851e-01f, 6.03076331e-02f, 5.08737825e-02f, 9.96190030e-03f, 7.64520690e-02f, -1.75972387e-01f, 8.42951238e-02f, 1.81962565e-01f, 1.10635512e-01f, 1.57957673e-01f,
  -1.25227615e-01f, 1.33044690e-01f, 3.42761517e-01f, -5.57563677e-02f, 6.50608316e-02f, 2.36448050e-01f, 9.48707908e-02f, 1.21304534e-01f, 2.01907769e-01f, 2.18653008e-01f,
  -2.78146595e-01f, -1.90445911e-02f, -1.93325728e-02f, -1.08053096e-01f, 2.05586478e-03f, 4.62151021e-02f, 1.65799305e-01f, -1.18183330e-01f, 2.35633284e-01f, 3.35891396e-02f,
  -5.26176579e-02f, 4.38534051e-01f, 6.79009110e-02f, -1.11811578e-01f, -1.08007096e-01f, -1.05242440e-02f, 2.38707677e-01f, -1.04368553e-01f, 2.23671451e-01f, -5.69585748e-02f,
  -5.15739582e-02f, 2.41801273e-02f, 7.22406730e-02f, 1.92428395e-01f, 3.52733999e-01f, 2.08857670e-01f, -9.62409899e-02f, -2.35193610e-01f, -1.85580492e-01f, -8.47213492e-02f,
  -1.80103436e-01f, 1.54379979e-01f, 1.42777845e-01f, 1.70829464e-02f, 5.33029586e-02f, 4.59280685e-02f, 1.46628525e-02f, -1.07355714e-02f, 2.10297212e-01f, -7.96462446e-02f,
  -1.83171868e-01f, 7.32568577e-02f, 1.43042520e-01f, -5.04271016e-02f, 2.27269351e-01f, -3.03441156e-02f, -7.54864048e-03f, 7.67081007e-02f, 5.83952256e-02f, -1.28230438e-01f,
  7.67525425e-03f, 2.04521388e-01f, 1.21610135e-01f, 4.04289588e-02f, 8.32014680e-02f, 1.72669873e-01f, 1.26359053e-02f, 1.18145004e-01f, -8.54096413e-02f, 9.20057818e-02f,
  -1.04096696e-01f, -4.04456072e-02f, -7.50471130e-02f, 1.30537540e-01f, 7.30127543e-02f, -1.54280573e-01f, -1.23506740e-01f, 1.23405740e-01f, 3.76480483e-02f, -3.43168914e-01f,
  -1.76398128e-01f, 2.18415514e-01f, -1.33830495e-02f, -5.36651574e-02f, 1.04453951e-01f, 7.87361041e-02f, 8.21350664e-02f, 1.98837202e-02f, 1.71405643e-01f, -2.59122290e-02f,
  9.32724550e-02f, -8.28292593e-02f, 1.37801707e-01f, -6.39208108e-02f, 5.97005114e-02f, 4.82030306e-03f, 1.01564705e-01f, 1.77362689e-03f, -2.50072796e-02f, 2.33300298e-01f,
  7.50359818e-02f, 1.30603880e-01f, 5.04195467e-02f, -1.14816472e-01f, 1.29132897e-01f, -1.22414187e-01f, 1.61184147e-01f, -1.41065028e-02f, 1.30482033e-01f, 1.33040935e-01f,
  -2.19404668e-01f, -7.20336959e-02f, 1.91289902e-01f, 1.59973860e-01f, 9.44887325e-02f, 2.17548966e-01f, 1.35417968e-01f, -1.19964648e-02f, 1.36661038e-01f, -1.36363491e-01f,
  6.12454712e-02f, 2.21159056e-01f, 7.38336146e-02f, -2.52653230e-02f, 2.49048784e-01f, -2.58598495e-02f, 2.99477458e-01f, -1.41844705e-01f, 2.21000582e-01f, -1.69254735e-01f,
  1.13395445e-01f, 1.18743107e-02f, 7.25471377e-02f, 1.49396315e-01f, 1.74329311e-01f, 9.44798738e-02f, 1.62746593e-01f, 1.85352415e-02f, -1.50374249e-01f, 1.91423908e-01f,
  1.91876426e-01f, 1.21065579e-01f, 6.98986873e-02f, 5.38943931e-02f, 1.15984432e-01f, 3.00761200e-02f, 5.27300648e-02f, 2.15001673e-01f, 8.08647200e-02f, 1.49355963e-01f,
  -5.68173677e-02f, -1.52792901e-01f, -1.80726200e-01f, 1.56679720e-01f, -3.34440395e-02f, -1.63862795e-01f, 1.19252652e-01f, 2.38173246e-01f, -7.95085803e-02f, 3.65186371e-02f,
  -1.30073145e-01f, -5.03835035e-03f, 2.99443215e-01f, -2.66340002e-02f, 8.90631974e-02f, -3.05991620e-01f, 6.44171564e-03f, 1.32465452e-01f, 7.53981769e-02f, -1.58661216e-01f,
  -8.71032402e-02f, -9.28134769e-02f, 2.04164073e-01f, 2.81992592e-02f, 2.23642960e-01f, 4.17648293e-02f, 1.19147375e-01f, -6.79538399e-02f, -1.42503113e-01f, -2.97220647e-02f,
  1.19602732e-01f, -2.55677193e-01f, 2.64701337e-01f, 2.47093275e-01f, 9.31221917e-02f, 1.84677586e-01f, 6.27912804e-02f, -2.10283101e-01f, -9.77170467e-02f, -3.72883901e-02f,
  -1.18303262e-01f, -1.57683268e-01f, 1.60346970e-01f, -7.70496801e-02f, 3.96900475e-02f, 1.97945952e-01f, 1.01432882e-01f, 1.36535436e-01f, 2.04998493e-01f, 2.23079324e-01f,
  6.55996203e-02f, 1.08008914e-01f, 4.33865935e-02f, 1.78983375e-01f, -5.67968469e-03f, -1.26808360e-01f, -1.70123905e-01f, -5.56209199e-02f, 6.40331581e-02f, 3.75996195e-02f,
  1.49663175e-02f, 2.03151405e-01f, 1.47985622e-01f, -1.15277089e-01f, -2.23114207e-01f, -3.44933309e-02f, 1.13932230e-01f, 1.42695487e-01f, -2.77456809e-02f, -7.15798698e-04f,
  3.66855860e-02f, -1.63812935e-02f, -6.43059760e-02f, 2.15635657e-01f, -9.46417004e-02f, -6.55770954e-03f, 3.13975185e-01f, -4.85291891e-03f, -1.90771177e-01f, 6.20695092e-02f,
  1.34988844e-01f, 1.62274137e-01f, 1.85337272e-02f, -1.08882844e-01f, -1.90261692e-01f, 1.32019026e-02f, 1.67529568e-01f, -1.15209542e-01f, 1.50625601e-01f, -1.43972948e-01f,
  -7.99528062e-02f, 1.09300166e-01f, 2.75615513e-01f, 1.42449841e-01f, -1.13105573e-01f, -1.27147689e-01f, 2.25337237e-01f, 3.19085568e-02f, -1.80497058e-02f, -9.64277536e-02f,
  9.31500942e-02f, -1.17017545e-01f, 2.24696547e-02f, -7.02928975e-02f, -4.61137705e-02f, -1.05019130e-01f, 2.87461787e-01f, -1.23570263e-01f, -1.13885365e-01f, 7.43706152e-02f,
  1.22470535e-01f, 9.46823135e-02f, 2.15637460e-01f, 2.48146802e-01f, 1.38617441e-01f, -1.15966119e-01f, -2.01227404e-02f, 2.05783159e-01f, 7.42413178e-02f, -6.74779117e-02f,
  6.06201403e-02f, 3.07617515e-01f, 9.61003304e-02f, 3.76562178e-02f, 7.80912042e-02f, 1.94573492e-01f, -1.01400148e-02f, 4.10485500e-03f, -2.05554873e-01f, 8.83089006e-02f,
  1.25922129e-01f, 1.79285616e-01f, 4.56286073e-02f, 9.70763564e-02f, -1.34299845e-01f, 2.31550187e-01f, -1.12016551e-01f, -6.68668970e-02f, 2.08056077e-01f, 7.20066950e-02f,
  1.99447259e-01f, -1.04901791e-01f, 7.32174441e-02f, 1.16973221e-01f, 1.16003439e-01f, 2.27725834e-01f, 1.59253925e-01f, 1.44948870e-01f, 7.15102553e-02f, 1.49852917e-01f,
  1.53435096e-01f, -1.24576181e-01f, 2.68092960e-01f, 8.31697807e-02f, -3.09540611e-02f, 8.72415900e-02f, 1.72776058e-01f, -1.01417214e-01f, -1.76193044e-01f, 1.02809124e-01f,
  4.95428815e-02f, 1.70331120e-01f, 3.48669514e-02f, -1.91045895e-01f, 1.65276509e-02f, -1.14647850e-01f, -2.28248194e-01f, 3.17335967e-03f, -2.89001167e-01f, 1.68158233e-01f,
  3.60530093e-02f, 2.15629056e-01f, 1.64800972e-01f, -3.22130956e-02f, 2.52681851e-01f, 7.66304135e-02f, 1.16607055e-01f, 2.15119839e-01f, 1.07219711e-01f, 1.90582722e-02f,
  7.58821517e-02f, -7.54412636e-02f, -1.48831069e-01f, -1.29032761e-01f, -2.68101513e-01f, -5.58278486e-02f, -1.43063962e-01f, -1.15301013e-01f, 1.54993264e-02f, 2.33672947e-01f,
  2.98324134e-02f, 1.37963474e-01f, -1.34315714e-01f, 7.50535727e-02f, 9.91318971e-02f, 3.99083048e-02f, 2.01628670e-01f, 5.50205223e-02f, 7.66169280e-02f, -4.44287211e-02f,
  -2.77664606e-02f, 1.47716731e-01f, -9.65453312e-02f, 1.41101345e-01f, 3.54061902e-01f, 1.07211627e-01f, -1.81896076e-01f, 1.37990400e-01f, 1.02601610e-01f, 1.18740015e-01f,
  -1.66628301e-01f, -2.53683478e-01f, -1.13806516e-01f, 3.06346416e-02f, 2.36635208e-01f, -7.00703040e-02f, 2.27286965e-01f, -2.75175702e-02f, 9.43188444e-02f, 4.46048155e-02f,
  1.50793016e-01f, 1.61745027e-01f, -3.63746732e-02f, -4.55877520e-02f, 1.18028492e-01f, 1.18791401e-01f, 4.22876421e-03f, -4.53954488e-02f, 2.78777599e-01f, -2.02975482e-01f,
  3.37154686e-01f, -3.93307135e-02f, 2.34435931e-01f, -5.82602397e-02f, 1.71588346e-01f, -1.16771206e-01f, -6.34011775e-02f, 2.32211396e-01f, 2.21589029e-01f, 3.28702927e-02f,
  1.53991967e-01f, 1.95684358e-01f, 9.25405696e-02f, -7.32477307e-02f, 3.35410126e-02f, 1.14822932e-01f, -6.55268971e-03f, -1.30155042e-01f, -1.16939098e-01f, 1.41882256e-01f,
  5.80817054e-04f, -1.44389048e-01f, 2.95136571e-02f, 1.88004375e-01f, 2.03416944e-01f, -5.08046113e-02f, -1.67984053e-01f, -1.83530711e-02f, -6.28466159e-02f, 9.69023183e-02f,
  1.72131151e-01f, 1.67034894e-01f, -2.19240915e-02f, 1.38738230e-01f, -1.32926017e-01f, 1.61830500e-01f, -3.44805792e-02f, 4.03373912e-02f, 2.70209312e-01f, -5.61740361e-02f,
  -2.79256254e-02f, 5.38011789e-02f, 5.61010726e-02f, 1.46267802e-01f, -6.76772669e-02f, 9.93349254e-02f, -3.47051695e-02f, 8.81765187e-02f, 1.55043110e-01f, -3.36984880e-02f,
  1.76812097e-01f, 5.36999367e-02f, -1.66639328e-01f, -1.35124356e-01f, 6.34437278e-02f, 8.28593895e-02f, -1.00759782e-01f, 1.96495011e-01f, 3.47406641e-02f, 1.60062075e-01f,
  4.09330316e-02f, -1.29179820e-01f, 2.28997856e-01f, -1.31551012e-01f, 5.88676743e-02f, 8.96327794e-02f, -8.61575082e-02f, 9.84771103e-02f, -8.90389383e-02f, 1.84283003e-01f,
  1.93015952e-02f, 1.21108286e-01f, -2.79762875e-02f, -8.31363425e-02f, -1.43689681e-02f, 8.73961020e-03f, -5.61528839e-02f, -1.30381420e-01f, 3.20950478e-01f, 7.39468308e-03f,
  4.50183302e-02f, 4.93018106e-02f, -1.13061480e-01f, 1.30475044e-01f, 8.66108537e-02f, -7.23271891e-02f, -7.93742314e-02f, 1.86553933e-02f, -5.53568974e-02f, -2.25797221e-01f,
  1.51810899e-01f, 1.70207709e-01f, 1.67364731e-01f, 1.11076355e-01f, -7.52731115e-02f, 1.18333839e-01f, 8.17536563e-02f, 1.15916587e-01f, -2.87834611e-02f, 2.06485018e-02f,
  -3.00032720e-02f, -1.00065547e-03f, -2.63724297e-01f, 1.74126483e-03f, 2.38756910e-01f, 2.50143051e-01f, 9.77926776e-02f, 2.47570336e-01f, -7.92125389e-02f, -1.01895537e-02f,
  -8.95416737e-02f, 6.77914098e-02f, -1.98016632e-02f, 7.39662200e-02f, 9.86050144e-02f, 1.21926544e-02f, 5.27473614e-02f, 2.00365037e-01f, 2.28347048e-01f, 1.27247104e-03f,
  1.69417590e-01f, 4.68277782e-02f, 2.66690757e-02f, 1.93139344e-01f, 1.77000105e-01f, 2.09950790e-01f, -1.00271240e-01f, 1.09376945e-02f, -1.72086298e-01f, -6.16314970e-02f,
  -1.51741989e-02f, -5.54915108e-02f, 1.69631034e-01f, -9.90076512e-02f, -1.49836019e-01f, 1.86434034e-02f, 2.22226366e-01f, 1.66174900e-02f, 1.24692224e-01f, 1.78713828e-01f,
  5.02613485e-02f, -1.40283704e-01f, 3.85892317e-02f, -1.40209198e-02f, -7.01062009e-02f, -2.03340739e-01f, -1.55009702e-01f, 3.55077684e-01f, -6.84031518e-03f, -2.69253194e-01f,
  4.29387875e-02f, 1.45827711e-01f, -1.76829979e-01f, 1.14098541e-01f, -5.22811264e-02f, 1.49779364e-01f, 2.39192732e-02f, 1.75200868e-02f, 1.11500479e-01f, 2.54543453e-01f,
  -1.27155781e-01f, 1.27882510e-01f, -4.91388440e-02f, -3.93283591e-02f, 7.14393854e-02f, 1.27499685e-01f, 3.74141857e-02f, -4.53199409e-02f, -4.40741144e-02f, 1.81053936e-01f,
  2.99992505e-02f, 2.20382437e-01f, -1.59705967e-01f, 1.20879889e-01f, -4.90582082e-03f, 1.49548784e-01f, 6.28375411e-02f, 1.40010342e-02f, 1.99725837e-01f, 2.64939070e-01f,
  -1.68789804e-01f, -1.12315804e-01f, 1.40170380e-01f, -1.57586768e-01f, -1.50732040e-01f, 1.93818465e-01f, -1.70835376e-01f, 2.94928759e-01f, -1.33483363e-02f, -1.62968904e-01f,
  1.16943531e-01f, 1.10556940e-02f, -9.56877321e-02f, 1.01401396e-01f, -1.37161970e-01f, 2.49752060e-01f, -2.26482108e-01f, 2.28985503e-01f, 2.28971522e-02f, 4.88549434e-02f,
  -1.39104888e-01f, 1.51477367e-01f, -4.06177640e-02f, -1.83101088e-01f, 1.73635893e-02f, 1.61926925e-01f, 5.73956817e-02f, -9.03525501e-02f, 6.28228253e-03f, 2.51837466e-02f,
  8.09703469e-02f, -3.04152280e-01f, 1.09668851e-01f, 3.86435747e-01f, 6.86729550e-02f, -2.51287252e-01f, 1.93478256e-01f, -7.03849345e-02f, 2.76898503e-01f, -5.05155511e-02f,
  2.34222203e-01f, -6.06275722e-02f, -1.29037187e-01f, -1.55236319e-01f, 1.56976894e-01f, -1.07249849e-01f, 1.78041056e-01f, 1.91857696e-01f, 4.84182015e-02f, -1.31889552e-01f,
  -2.04507023e-01f, 2.01856762e-01f, 1.52025163e-01f, 2.10140981e-02f, -2.41462328e-02f, -2.45668814e-01f, 2.82654196e-01f, 5.43376394e-02f, 5.87055385e-02f, 7.43884966e-02f,
  -1.09995991e-01f, 1.69723302e-01f, -3.96208242e-02f, -1.44424856e-01f, 2.53514647e-01f, 2.49304369e-01f, 5.06825484e-02f, 2.54528999e-01f, 1.74028903e-01f, 5.39272428e-02f,
  -6.24914728e-02f, -2.05117032e-01f, 6.29301444e-02f, 2.40610465e-01f, 2.47532967e-02f, 1.53096363e-01f, 2.29398578e-01f, 2.42443886e-02f, 3.41312110e-01f, -1.34501383e-01f,
  1.94649220e-01f, -5.89301996e-02f, -9.26141515e-02f, 9.85423401e-02f, 1.70254335e-01f, 5.42290173e-02f, -1.19275443e-01f, -1.32978827e-01f, 4.50312793e-02f, 1.46678254e-01f,
  -7.23873684e-03f, -5.69141321e-02f, -6.22849762e-02f, 7.20974058e-03f, -9.28141624e-02f, -2.72663146e-01f, 3.43146436e-02f, -1.57280322e-02f, 9.92748886e-03f, -1.72652885e-01f,
  1.52422220e-01f, 5.65847792e-02f, 2.91997015e-01f, 3.05904006e-03f, -1.06124468e-01f, -4.53022495e-02f, 3.94879393e-02f, -3.70356068e-02f, -5.42494329e-03f, -1.31888643e-01f,
  1.98667780e-01f, 9.18292478e-02f, -7.41224512e-02f, 7.51653016e-02f, -1.40154779e-01f, 1.52330115e-01f, 5.50866164e-02f, -5.31080272e-03f, -6.97855055e-02f, -2.04820424e-01f,
  -6.29635230e-02f, 1.71856821e-01f, 2.16805577e-01f, -9.35358331e-02f, -4.54902500e-02f, 2.62288243e-01f, -1.69168860e-01f, 1.11101329e-01f, -9.55373514e-03f, -7.37216175e-02f,
  -1.14646003e-01f, 1.04946010e-01f, 1.13017619e-01f, 2.93028593e-01f, -1.54403150e-01f, -2.48568505e-01f, -4.22041491e-02f, 1.39528617e-01f, 1.58422291e-01f, 3.95054251e-01f,
  3.62666100e-01f, 2.48096898e-01f, 3.60817492e-01f, 3.67716402e-02f, -2.06080392e-01f, 2.11064726e-01f, -1.73518240e-01f, -5.97796999e-02f, 1.59475416e-01f, 2.09377646e-01f,
  2.16946170e-01f, 1.29056513e-01f, 2.11803213e-01f, 3.55640575e-02f, -2.88793564e-01f, -1.01946115e-01f, 1.47878826e-01f, 7.62131885e-02f, 1.71178758e-01f, 1.20024607e-01f,
  1.41141847e-01f, 2.34517157e-01f, 1.48839533e-01f, -5.44608645e-02f, 9.24120098e-02f, 2.58448005e-01f, 1.70495838e-01f, -1.04737714e-01f, -1.21957706e-02f, -4.96910810e-02f,
  8.75247642e-02f, -1.21646691e-02f, 1.08159937e-01f, -5.65230101e-02f, 2.00678915e-01f, 7.42287487e-02f, 1.76308364e-01f, -2.59981304e-02f, 2.28530660e-01f, 2.08683982e-01f,
  -6.21329695e-02f, -1.73896372e-01f, -1.38167143e-01f, -8.71771052e-02f, 2.23786488e-01f, 1.62754849e-01f, 1.86679047e-02f, 1.58920482e-01f, -1.35857150e-01f, 3.18586707e-01f,
  9.46808457e-02f, 1.30076883e-02f, -2.11334620e-02f, -1.34787127e-01f, -1.04711547e-01f, 6.38430789e-02f, 1.52685300e-01f, -7.26953670e-02f, 1.21368378e-01f, 9.62254405e-02f,
  -1.11200854e-01f, 1.62903830e-01f, -1.18591994e-01f, 1.89271867e-01f, -1.71111852e-01f, 3.16010579e-03f, -2.00787187e-01f, -2.17750389e-02f, -1.00673929e-01f, 3.62896807e-02f,
  2.30806783e-01f, 1.45721436e-01f, -6.05584383e-02f, 1.43736765e-01f, 4.34460379e-02f, -2.27744002e-02f, 4.09963615e-02f, 6.77163377e-02f, -1.03999056e-01f, 7.32176453e-02f,
  1.40224546e-01f, 4.36802804e-02f, 1.90792024e-01f, -1.14748158e-01f, 2.49317214e-01f, 2.33600140e-01f, 1.42471731e-01f, -1.18024886e-01f, 1.97825655e-01f, -7.82584772e-02f,
  1.80268392e-01f, -7.49020129e-02f, -2.15482078e-02f, 8.66688043e-02f, -5.74585944e-02f, 3.50956880e-02f, 7.18445182e-02f, -1.57606625e-03f, 1.36606991e-01f, 3.55589688e-02f,
  6.28775880e-02f, -4.48302552e-02f, -7.85142705e-02f, 5.47637716e-02f, 1.88034996e-01f, -2.03987043e-02f, -1.01130411e-01f, -1.06175542e-01f, 2.73566544e-01f, 3.32261562e-01f,
  1.65515631e-01f, 8.72940347e-02f, -1.49220869e-01f, 1.74649417e-01f, -1.28135979e-01f, -1.63571499e-02f, -3.23809199e-02f, -5.40013202e-02f, -1.88191719e-02f, 1.33643001e-01f,
  1.51306912e-01f, 2.23296389e-01f, 4.43408005e-02f, -1.32541806e-01f, 3.49219888e-02f, 1.43524945e-01f, -4.66628782e-02f, 2.25437135e-01f, -7.61668570e-03f, 1.86605155e-01f,
  2.81125307e-02f, 3.87052670e-02f, -1.21906176e-01f, 1.86895192e-01f, 7.19923005e-02f, -1.37992457e-01f, -1.56738877e-01f, 9.34599340e-02f, -1.43750936e-01f, -8.16225410e-02f,
  -1.35930767e-03f, 3.10850680e-01f, -2.72281142e-03f, -8.01018551e-02f, -1.24903888e-01f, -1.47459581e-02f, 4.69749346e-02f, 4.92686033e-02f, 1.16197444e-01f, 6.85706437e-02f,
  1.45739317e-01f, -1.49691150e-01f, -2.77235955e-01f, 2.16746569e-01f, 1.82904631e-01f, 8.28656182e-02f, 1.23945571e-01f, 2.52577271e-02f, 5.72021008e-02f, -1.73399359e-01f,
  1.80375218e-01f, 1.99200541e-01f, -6.09616823e-02f, -1.17856659e-01f, 1.55514125e-02f, 2.54098177e-01f, -2.89264470e-01f, 1.04001597e-01f, 1.24586754e-01f, -4.58956286e-02f,
  1.54627152e-02f, 7.99957067e-02f, -1.78157017e-01f, 5.95647469e-02f, 1.09286502e-01f, 6.64265528e-02f, 1.29341148e-02f, 1.01409880e-02f, -5.40721826e-02f, 9.45703462e-02f,
  4.05071318e-01f, 2.68450141e-01f, -1.50764985e-02f, -4.58012708e-02f, 1.76473722e-01f, -3.97434123e-02f, 1.29476367e-02f, -1.15149669e-01f, 2.51483500e-01f, 2.44903132e-01f,
  -1.02775112e-01f, -3.01763671e-03f, -7.01202750e-02f, 2.10847825e-01f, 3.24948490e-01f, -5.37229422e-03f, 3.16033930e-01f, 1.09194748e-01f, -2.91142762e-01f, 1.13807656e-01f,
  3.96479256e-02f, 2.14603499e-01f, 7.91170821e-02f, 7.18490779e-02f, 5.21719120e-02f, 7.54885972e-02f, -6.90788776e-02f, -1.53160421e-02f, 8.11174661e-02f, 1.96882546e-01f,
  6.38846233e-02f, -5.02445474e-02f, -2.90052835e-02f, 2.86668837e-01f, -4.42491435e-02f, -1.97344329e-02f, -4.23796996e-02f, -8.96050259e-02f, 1.64652079e-01f, 3.20263579e-02f,
  1.80104941e-01f, 6.45279586e-02f, -6.28781319e-03f, 3.84351499e-02f, 8.34968612e-02f, -1.61557034e-01f, 2.75266916e-01f, 1.16862180e-02f, 1.50217146e-01f, -7.61904567e-02f,
  9.62156653e-02f, 2.23362491e-01f, -7.73061663e-02f, 2.28184432e-01f, 8.58416483e-02f, 2.67114844e-02f, 1.22154966e-01f, -2.50996407e-02f, -5.53863756e-02f, 2.26517636e-02f,
  9.35078114e-02f, 3.07267427e-01f, -5.85148297e-02f, -7.00152740e-02f, -1.27961049e-02f, 1.71075299e-01f, 1.86590716e-01f, 8.44915118e-03f, 1.50067240e-01f, 2.10922421e-03f,
  2.40960568e-01f, -1.46760559e-02f, -7.69452229e-02f, 1.74020782e-01f, -2.39436820e-01f, 1.58020213e-01f, -2.01650783e-01f, -1.00854188e-01f, -1.78811610e-01f, -1.13264352e-01f,
  1.01535276e-01f, -2.16678455e-01f, 9.26424190e-02f, -1.36139914e-01f, 1.97987314e-02f, 5.27111143e-02f, 9.43192393e-02f, 3.68685164e-02f, 3.91775556e-02f, -9.47028175e-02f,
  1.39474466e-01f, -2.54896879e-01f, -5.63996751e-03f, 8.25088620e-02f, 7.75832385e-02f, 1.30949244e-01f, -1.27047628e-01f, 1.94930866e-01f, 2.94455644e-02f, -3.75891328e-02f,
  -8.13058838e-02f, 2.02802822e-01f, 2.09327310e-01f, 1.55009612e-01f, 2.45353416e-01f, -6.28962368e-02f, 4.96660434e-02f, 8.09932426e-02f, 7.68094882e-02f, -2.39439122e-02f,
  1.76605880e-01f, -8.83281883e-03f, 2.17867389e-01f, -4.93894629e-02f, -6.34620041e-02f, 2.42167652e-01f, 1.56045660e-01f, 7.85506144e-02f, -5.02682365e-02f, -3.24295424e-02f,
  2.55378485e-01f, -2.45842915e-02f, 5.52990511e-02f, 2.97880054e-01f, -2.31707022e-01f, 2.20732048e-01f, 1.10952362e-01f, 9.05865729e-02f, 2.00914264e-01f, 9.55321342e-02f,
  4.99512404e-02f, 5.21419123e-02f, 1.73044264e-01f, -9.69249532e-02f, -1.00717850e-01f, 1.44319087e-01f, 3.21864802e-03f, 2.15223640e-01f, -1.46235168e-01f, -1.95283629e-02f,
  -1.38913348e-01f, -1.06606849e-01f, -5.40461391e-02f, -2.38270704e-02f, -4.21350524e-02f, -1.09899797e-01f, 2.05626011e-01f, 2.02107593e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  9.28438529e-02f, -2.00298987e-03f, 1.22006781e-01f, -1.84361078e-03f, 7.78580084e-02f, 2.82005481e-02f, -8.93000141e-03f, 1.55981556e-01f, 4.09878232e-02f, 5.90735860e-02f,
  8.80780593e-02f, 3.73008922e-02f, 1.43118292e-01f, 3.25846411e-02f, 9.17039986e-04f, 1.39539009e-02f, 9.32394937e-02f, 1.01912744e-01f, 8.07054341e-02f, 2.10507140e-02f,
  1.43968493e-01f, 1.59970447e-02f, 1.78905547e-01f, 1.70790792e-01f, 8.22421536e-02f, 1.34867027e-01f, 1.70762196e-01f, 1.34909734e-01f, 1.85175315e-02f, 6.42746314e-02f,
  1.16081826e-01f, 4.27852646e-02f, 4.87700477e-02f, 1.28892690e-01f, 1.38868824e-01f, 1.14521883e-01f, 8.64868015e-02f, 1.07769683e-01f, 2.14417055e-02f, 6.98062256e-02f,
  3.39940041e-02f, 2.10542530e-01f, 5.49939424e-02f, -1.22229429e-02f, 1.41221434e-01f, 9.96360406e-02f, 1.30767927e-01f, 6.44722283e-02f, 7.57864118e-02f, -7.24953366e-03f,
  9.89763439e-02f, 6.85331896e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.22459404e-01f, -1.40213342e-02f, -1.49615586e-01f, 7.31331035e-02f, -2.38297909e-01f, -1.37482479e-01f, -1.40350372e-01f, 9.06224772e-02f, 2.65351776e-02f, 1.93397388e-01f,
  1.91033751e-01f, 1.74694762e-01f, -4.54561085e-01f, 2.68534482e-01f, 3.64162087e-01f, -2.07009628e-01f, -2.77183294e-01f, -1.30629420e-01f, 1.93188116e-01f, -3.29331905e-01f,
  -1.37967825e-01f, -4.28572357e-01f, 1.32460430e-01f, -1.05095044e-01f, -5.59128560e-02f, 6.49586320e-02f, -1.04809925e-02f, 2.77395189e-01f, 3.55523676e-01f, 4.77503166e-02f,
  -4.49843436e-01f, 4.18736249e-01f, -2.02133715e-01f, 4.00480360e-01f, -4.85317498e-01f, -2.28426650e-01f, 9.63887498e-02f, 2.26915792e-01f, 2.15156585e-01f, -2.58906603e-01f,
  2.79766560e-01f, 2.41197005e-01f, 2.55251169e-01f, -4.24041599e-01f, -3.35547119e-01f, 2.37197578e-01f, -2.57730275e-01f, -2.36391529e-01f, -4.35063154e-01f, -3.35582554e-01f,
  2.76186556e-01f, -1.09180221e-02f, 2.20372453e-01f, 2.23407280e-02f, 2.28798941e-01f, 3.06150496e-01f, 1.68133259e-01f, -7.61904120e-02f, -1.06142938e-01f, -3.60646784e-01f,
  -3.06896091e-01f, -3.11618205e-02f, -4.83367473e-01f, -7.90269449e-02f, 8.04024190e-02f, 9.08155069e-02f, 2.06413686e-01f, -9.07047838e-02f, -3.61275636e-02f, 1.39728591e-01f,
  -1.26130015e-01f, -2.62055725e-01f, -2.18223333e-01f, -3.24113786e-01f, 2.06563249e-01f, 1.19000152e-02f, -1.30867258e-01f, -1.86728477e-01f, -2.45784998e-01f, 4.18277271e-02f,
  3.68679851e-01f, 5.91566693e-03f, -3.23195636e-01f, 1.33567587e-01f, -9.71852913e-02f, -3.78248006e-01f, 2.37244621e-01f, 3.00409105e-02f, -2.59800047e-01f, -4.18921411e-01f,
  1.68018147e-01f, -3.09027135e-01f, 1.37396693e-01f, 3.25673372e-01f, -3.04477960e-01f, -2.54895568e-01f, 3.19488853e-01f, -3.58760059e-01f, -9.42067727e-02f, 3.83611798e-01f,
  -2.34222099e-01f, 1.13072075e-01f, 1.44516766e-01f, -1.42792746e-01f, -7.89216533e-02f, 2.89875507e-01f, 6.34360909e-02f, -4.58384812e-01f, -1.66311041e-01f, 3.63965482e-02f,
  -3.00207883e-01f, -2.71920592e-01f, -4.16348398e-01f, -9.91000757e-02f, -3.97877634e-01f, 4.68405895e-02f, 1.70434877e-01f, 2.13929132e-01f, 9.83042866e-02f, 2.66860902e-01f,
  4.10295963e-01f, -5.52542806e-01f, -1.12990819e-01f, -2.20617339e-01f, -3.24333340e-01f, -2.82808930e-01f, 8.91425610e-02f, 1.85800090e-01f, 2.84333806e-02f, -9.53095779e-02f,
  -2.12773100e-01f, -2.15616412e-02f, 1.49411075e-02f, -1.45811141e-01f, -1.05330668e-01f, -1.28493011e-01f, 2.24454567e-01f, -1.40068740e-01f, 1.48162708e-01f, -1.30844405e-02f,
  1.56431887e-02f, -1.71607122e-01f, -1.98466495e-01f, -1.96825936e-01f, 3.54643166e-01f, -1.92498103e-01f, -1.01576641e-01f, -3.06747437e-01f, -9.53007638e-02f, -1.30440980e-01f,
  -3.68614942e-01f, -2.32514337e-01f, 2.38399610e-01f, -2.06090271e-01f, 2.31160343e-01f, -3.08906108e-01f, -2.66634673e-01f, 1.13497935e-01f, 4.86812592e-02f, -8.81645828e-03f,
  1.41829193e-01f, -1.11360423e-01f, 3.57860588e-02f, -4.99665663e-02f, -9.06207785e-02f, 9.81537104e-02f, 9.28986520e-02f, 9.13622528e-02f, -1.51176572e-01f, 1.88502535e-01f,
  1.55442908e-01f, 2.86509991e-01f, 2.87409186e-01f, -4.87708867e-01f, -2.92717904e-01f, -3.95086110e-01f, -2.70265549e-01f, 2.45738223e-01f, -1.10820025e-01f, 2.11335540e-01f,
  2.06779949e-02f, 3.98333883e-03f, -3.88442308e-01f, 2.20148921e-01f, -4.15055037e-01f, 4.62019831e-01f, -3.64783466e-01f, -3.93209189e-01f, -7.64101446e-02f, 3.58008265e-01f,
  2.00431243e-01f, 1.10822275e-01f, -2.12672070e-01f, 9.93356183e-02f, 1.20263644e-01f, -6.41299412e-02f, -9.02668312e-02f, -1.68304920e-01f, -1.94054052e-01f, -6.00167625e-02f,
  -1.73674807e-01f, 3.07236105e-01f, -2.16280162e-01f, 2.97671437e-01f, 4.59112376e-02f, -9.77150053e-02f, 3.46726507e-01f, -3.53021830e-01f, -5.48974752e-01f, 2.09053665e-01f,
  3.61245722e-01f, -1.64870173e-01f, -2.88272738e-01f, 2.04049140e-01f, -3.28823626e-01f, 1.80018321e-01f, -4.79603916e-01f, 2.35971928e-01f, -4.64835793e-01f, 3.61286700e-01f,
  1.97784454e-01f, -4.67838794e-02f, -4.15233195e-01f, 2.09253266e-01f, -4.15873200e-01f, 2.09125757e-01f, 1.46228015e-01f, -3.90238434e-01f, 1.35266855e-01f, -3.53235364e-01f,
  -2.00093403e-01f, 1.92062333e-01f, 2.53420155e-02f, -3.69473249e-01f, 2.74421841e-01f, 6.61378130e-02f, -4.58215773e-01f, 1.03977829e-01f, -4.94023234e-01f, 1.10067822e-01f,
  5.91067970e-02f, 8.59652907e-02f, 1.32021323e-01f, -1.23768516e-01f, -3.85809153e-01f, -2.95405358e-01f, -2.09330156e-01f, 3.24485421e-01f, -3.23677808e-01f, 1.75513014e-01f,
  1.67718362e-02f, 8.73859674e-02f, 1.91227868e-01f, 3.65324974e-01f, -1.53576648e-02f, 2.21355222e-02f, 1.00332849e-01f, -5.82976937e-02f, 3.10535710e-02f, -1.61350682e-01f,
  1.00139126e-01f, -1.36897685e-02f, 3.92639101e-01f, 5.45563288e-02f, -2.81739980e-01f, 2.77726024e-01f, -1.69940174e-01f, 3.40474904e-01f, -2.55996615e-01f, 5.44399954e-02f,
  -1.09500124e-03f, 3.36554423e-02f, 1.00520507e-01f, 1.94917127e-01f, 1.58811077e-01f, -1.98758394e-01f, -2.83286840e-01f, 9.51480567e-02f, -3.71614397e-01f, 1.71866715e-01f,
  2.74211437e-01f, 2.88718790e-01f, -1.40143737e-01f, -1.38593540e-01f, -3.18144977e-01f, -2.05960602e-01f, -8.24342743e-02f, -5.27619421e-01f, 8.67405385e-02f, 1.73484057e-01f,
  1.53990820e-01f, -6.14602380e-02f, 2.98912376e-01f, 3.38237911e-01f, -2.08221093e-01f, -2.98243135e-01f, -1.75324231e-01f, 5.37231192e-02f, 9.79186818e-02f, 3.37276995e-01f,
  1.48943469e-01f, 3.04003358e-01f, 7.34031722e-02f, 8.78215060e-02f, 1.68286845e-01f, -4.33623238e-04f, 3.47859502e-01f, 3.43545139e-01f, 1.68502539e-01f, 2.37893686e-01f,
  2.14031711e-01f, -2.65938014e-01f, -1.66899636e-01f, -5.30795753e-01f, -4.17279810e-01f, 6.34284690e-02f, -1.64207056e-01f, -3.66557449e-01f, 9.45604369e-02f, -4.43434685e-01f,
  1.23187929e-01f, -3.49186808e-02f, -9.75392014e-03f, 6.65975437e-02f, 2.33146131e-01f, 1.93010077e-01f, -2.34289482e-01f, -1.45803019e-01f, -2.79907852e-01f, -4.29120176e-02f,
  -1.24677215e-02f, 1.40340179e-01f, 2.52005488e-01f, 3.29888821e-01f, -2.00807929e-01f, -2.09670827e-01f, -3.58616799e-01f, -1.34153605e-01f, 8.71260688e-02f, 3.40056032e-01f,
  4.53495562e-01f, -2.51128227e-01f, 2.01118320e-01f, -3.53850126e-01f, 2.69097954e-01f, -1.74976915e-01f, -2.08593294e-01f, -1.56225637e-01f, -1.18389413e-01f, -2.02133581e-01f,
  3.16560596e-01f, -2.42655233e-01f, 9.27785560e-02f, -2.99587455e-02f, -4.92070585e-01f, 1.33358523e-01f, 7.77379647e-02f, -3.89144123e-01f, 1.14750065e-01f, -2.22523913e-01f,
  1.22435249e-01f, 2.38221392e-01f, -3.96523833e-01f, -5.07068932e-01f, -2.74811517e-02f, -2.37705186e-01f, 2.02492476e-01f, 2.11439639e-01f, 3.44688833e-01f, -4.28868175e-01f,
  2.58656889e-01f, 6.39231876e-02f, 8.11337307e-02f, 1.98266312e-01f, 1.47308514e-01f, -2.30765209e-01f, 1.85200453e-01f, -2.66216785e-01f, -4.76926506e-01f, 3.49384040e-01f,
  -3.29413652e-01f, 6.62659630e-02f, -3.37785751e-01f, 1.43610448e-01f, 9.98491347e-02f, 8.83466750e-02f, 1.50049835e-01f, -4.11817729e-02f, -1.24564460e-02f, -6.03471845e-02f,
  -1.60625666e-01f, 9.01152380e-03f, 2.41973981e-01f, -2.63335913e-01f, -2.75844127e-01f, -2.37935305e-01f, 3.19078386e-01f, -9.95706916e-02f, -8.78855065e-02f, -1.73452303e-01f,
  2.19870269e-01f, -2.64505684e-01f, -3.28742981e-01f, 2.71570683e-01f, -1.36633500e-01f, -2.68767849e-02f, -2.97910661e-01f, -3.38989586e-01f, 3.08281302e-01f, -1.51795715e-01f,
  -2.81850964e-01f, 3.36877406e-01f, -8.26017186e-02f, -2.73971885e-01f, 2.43116274e-01f, -1.28749639e-01f, -1.87383100e-01f, -2.94805199e-01f, 3.62215191e-01f, -1.85200587e-01f,
  -4.06412929e-01f, -3.27875495e-01f, 2.85063803e-01f, 3.53072196e-01f, -1.56087056e-01f, -5.07024169e-01f, -4.00708057e-02f, -1.73039898e-01f, -4.14738685e-01f, -2.28127450e-01f,
  2.04175189e-01f, 2.73256749e-01f, 2.71981835e-01f, 3.33919257e-01f, -2.06051663e-01f, -2.51256555e-01f, -4.77444321e-01f, 2.74250507e-01f, -1.17298439e-01f, -1.46279514e-01f,
  -1.07712246e-01f, 9.16159898e-02f, 2.97722042e-01f, -3.00497800e-01f, -2.73355156e-01f, 4.79284167e-01f, -2.25111395e-01f, -2.93765794e-02f, 1.25833396e-02f, -1.30769357e-01f,
  -2.15891942e-01f, -9.08874199e-02f, -1.09757990e-01f, 1.27127459e-02f, 7.23233670e-02f, 1.84053093e-01f, 2.96267062e-01f, 6.87170178e-02f, -1.66726857e-01f, 1.68774977e-01f,
  1.14549652e-01f, 2.23827705e-01f, -4.25077617e-01f, 4.40113276e-01f, -1.99846327e-01f, 2.42075950e-01f, -2.01670140e-01f, -3.85524556e-02f, 2.93818027e-01f, 2.54738092e-01f,
  -2.56195813e-01f, 1.00589290e-01f, -1.25103325e-01f, 9.99673977e-02f, -6.64242059e-02f, -2.35884935e-01f, 2.47499496e-01f, -6.19741194e-02f, -2.12511986e-01f, 4.72441584e-01f,
  1.98667407e-01f, -2.96140641e-01f, -4.53270674e-02f, -2.11990893e-01f, 1.89950570e-01f, -3.53129447e-01f, -2.82527804e-01f, -2.46590123e-01f, 3.13126028e-01f, -2.06291705e-01f,
  -3.42292309e-01f, -1.86046109e-01f, -4.18857932e-01f, -4.21023071e-01f, -4.38237600e-02f, -2.61655897e-01f, 1.09062895e-01f, 2.88315386e-01f, -4.39523943e-02f, -1.40279520e-03f,
  -2.82048792e-01f, 8.25595334e-02f, 9.08010900e-02f, 1.05843380e-01f, -1.66616291e-01f, 2.88880199e-01f, 1.17875859e-01f, 2.19440639e-01f, 5.50734363e-02f, -4.80619594e-02f,
  1.34821430e-01f, 2.16835365e-01f, -4.71001044e-02f, -5.72580360e-02f, 8.79718438e-02f, -9.41177532e-02f, 7.03775585e-02f, -1.06920063e-01f, -2.03939989e-01f, -5.73265404e-02f,
  -2.10270081e-02f, -6.66309968e-02f, -7.10484535e-02f, -5.64249903e-02f, -2.66120285e-01f, -6.56417385e-02f, -2.05914617e-01f, -3.70043516e-02f, 5.59234656e-02f, -1.31860718e-01f,
  -2.18713269e-01f, -1.99150488e-01f, -7.61088431e-02f, 4.01300251e-01f, 3.16170067e-01f, -1.38601109e-01f, -1.59631878e-01f, -2.73655832e-01f, 3.22140962e-01f, -1.32934108e-01f,
  -1.92161798e-01f, 2.37981334e-01f, 2.18340039e-01f, -4.03278098e-02f, -2.66877562e-01f, -1.67119905e-01f, -3.47458720e-01f, 1.16038650e-01f, -3.05606097e-01f, -2.45611131e-01f,
  -3.54096442e-01f, -2.93808550e-01f, -9.93977338e-02f, -7.53047764e-02f, -3.13214451e-01f, 2.75276035e-01f, 1.85117826e-01f, 1.63593739e-01f, -1.54509306e-01f, 3.79869461e-01f,
  -9.87707973e-02f, 1.40122429e-01f, -1.67038083e-01f, -3.90322238e-01f, 1.58995613e-01f, -3.45553458e-01f, -1.77574515e-01f, -9.18859392e-02f, -1.63649499e-01f, 9.66384560e-02f,
  -2.51597404e-01f, 2.52085656e-01f, 2.13514477e-01f, -2.93599427e-01f, 1.19690880e-01f, 2.66518891e-01f, 1.02152526e-01f, -7.68181533e-02f, 5.89190312e-02f, 8.48721862e-02f,
  1.30767331e-01f, 9.51934699e-03f, -1.51409134e-01f, 2.00893134e-01f, 2.51296431e-01f, 9.84894708e-02f, -4.39469106e-02f, -1.40654087e-01f, -3.90205920e-01f, 6.36954829e-02f,
  -1.40790567e-01f, 3.69924217e-01f, -2.39290714e-01f, -1.02235347e-01f, -4.32801723e-01f, -2.13276953e-01f, -2.91620903e-02f, -4.31647241e-01f, -1.06768318e-01f, 1.01191588e-01f,
  1.89168826e-01f, -5.42362511e-01f, -2.90308118e-01f, -4.45900038e-02f, -3.02756906e-01f, 3.91183138e-01f, 1.52082101e-01f, 4.45867449e-01f, -6.21498078e-02f, 2.57239580e-01f,
  2.41659090e-01f, -2.31950268e-01f, 1.74063772e-01f, 3.10872287e-01f, 1.06353387e-01f, -4.37102497e-01f, -1.48062959e-01f, 1.37482479e-01f, -3.58006477e-01f, 1.44607231e-01f,
  -2.40673155e-01f, -4.50289905e-01f, 3.00796658e-01f, -2.25901231e-01f, -1.64977208e-01f, 1.14807092e-01f, -2.88265854e-01f, 1.85595810e-01f, -3.98408234e-01f, 2.16700181e-01f,
  1.43957853e-01f, -3.78018826e-01f, -2.55778432e-01f, 3.42902958e-01f, 3.86205256e-01f, -3.57484639e-01f, 1.49241224e-01f, -5.16464889e-01f, -4.19003367e-01f, -3.99950862e-01f,
  4.50413674e-02f, 1.28813565e-01f, 9.93858352e-02f, 1.77472576e-01f, -6.35372177e-02f, 7.22686201e-02f, 3.43845069e-01f, -1.96623355e-01f, -8.17483440e-02f, -2.04780072e-01f,
  2.15784341e-01f, -1.69010371e-01f, 5.57903340e-03f, -3.18312794e-01f, 2.86570579e-01f, -2.06160650e-01f, 2.39932433e-01f, 1.42676145e-01f, -2.58666933e-01f, -1.34648919e-01f,
  -2.68006809e-02f, -1.86385915e-01f, 1.11437522e-01f, -3.43593836e-01f, -3.04816365e-01f, 2.87120432e-01f, 6.81980178e-02f, -2.54039854e-01f, 1.61803797e-01f, -5.08499980e-01f,
  -8.16997886e-02f, -2.97909051e-01f, 1.87712014e-01f, -3.27894092e-01f, 2.89450079e-01f, 3.09717625e-01f, 1.21523790e-01f, 1.80642307e-01f, -2.30285987e-01f, 2.13118076e-01f,
  -6.70542344e-02f, -2.20376879e-01f, 3.31128150e-01f, -2.81697720e-01f, 3.54385406e-01f, 1.07141837e-01f, -1.94918200e-01f, -3.82603645e-01f, -1.92265823e-01f, -9.63575691e-02f,
  -2.44407684e-01f, -2.28416964e-01f, -2.88726270e-01f, -4.32915598e-01f, -3.58537436e-01f, -7.71806762e-02f, -1.51978299e-01f, 1.67741165e-01f, 3.90732318e-01f, 3.38062823e-01f,
  2.25224659e-01f, -2.03368992e-01f, 2.73112446e-01f, 3.68900225e-02f, 3.09483465e-02f, -4.46662260e-03f, 4.17288095e-02f, 2.66332719e-02f, -1.44372225e-01f, 9.77346450e-02f,
  2.89579660e-01f, 2.56841362e-01f, -1.13706768e-01f, -3.21212374e-02f, -6.69395477e-02f, -7.73152709e-02f, 2.21517727e-01f, 1.64787933e-01f, -2.99910363e-02f, 2.20374018e-01f,
  -2.54607588e-01f, -7.25075230e-02f, 9.60313976e-02f, 1.71338290e-01f, 1.78184971e-01f, 1.34662926e-01f, 2.08427966e-01f, 3.14783514e-01f, -2.32363790e-01f, -2.82125652e-01f,
  -3.24039400e-01f, 2.57685214e-01f, -2.04592571e-01f, -3.07963252e-01f, 2.20274150e-01f, -2.32969791e-01f, -4.44704257e-02f, -1.12182893e-01f, 1.52131513e-01f, -3.22027266e-01f,
  -2.56965876e-01f, -1.39363989e-01f, -4.38064545e-01f, 2.53854811e-01f, -2.83498794e-01f, -2.70604879e-01f, -2.29570776e-01f, 2.04734057e-01f, 3.19732934e-01f, -2.65263885e-01f,
  -2.83775598e-01f, 2.26498410e-01f, 1.48131862e-01f, -4.29358542e-01f, -3.52703929e-01f, -3.02371830e-01f, 1.67909414e-01f, -4.32601452e-01f, 1.89111248e-01f, -1.20483227e-01f,
  2.77841210e-01f, -2.66365111e-01f, 2.45338649e-01f, 6.17049960e-03f, 3.05436581e-01f, 1.47781298e-01f, -3.31991822e-01f, -3.90714258e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.22377284e-02f, -7.83994887e-03f, 1.99328419e-02f, -9.17013967e-04f, -5.63074788e-03f, -5.59400171e-02f, 1.89937837e-02f, -3.33328210e-02f, 2.86914594e-02f, -1.57437772e-02f,
  1.20282091e-01f, 5.34613132e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    