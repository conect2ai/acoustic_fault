/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.80943692e-01f, 1.31561324e-01f, 2.36807689e-01f, -4.22270596e-01f, 5.58731072e-02f, 1.55635193e-01f, 1.96980655e-01f, -7.36706555e-02f, -2.19626158e-01f, 3.53973769e-02f,
  9.49522555e-02f, 4.81103659e-02f, 3.96789350e-02f, 1.04169205e-01f, -8.06978047e-02f, 8.73373598e-02f, 6.02494255e-02f, 8.56480598e-02f, -6.34872541e-03f, -2.19673812e-02f,
  7.71888345e-02f, -8.89066756e-02f, -1.35305256e-01f, -2.03955784e-01f, 8.13976899e-02f, -2.91199423e-02f, 1.20341063e-01f, -6.49892166e-02f, 8.64561275e-02f, 1.59601629e-01f,
  3.20304453e-01f, -6.66343719e-02f, 1.04544625e-01f, -7.24219382e-02f, 1.84277706e-02f, -7.13963583e-02f, 3.46450694e-02f, 1.66567490e-02f, 2.08764989e-03f, -4.63435287e-03f,
  6.11387044e-02f, 2.46939342e-02f, -5.96518964e-02f, 1.26231713e-02f, -9.88141075e-02f, -3.14329565e-02f, -1.15303062e-01f, -2.75880955e-02f, -1.55786397e-02f, 3.49719003e-02f,
  9.09046084e-03f, 1.14251807e-01f, 1.50851049e-02f, 3.87006663e-02f, -5.29572070e-02f, 1.81864481e-02f, 4.71036695e-02f, 1.53071517e-02f, -2.39908206e-03f, -4.34163399e-02f,
  -2.64644586e-02f, -6.35901233e-03f, 8.37607011e-02f, -5.91089092e-02f, 1.44842721e-03f, -2.06849594e-02f, -2.02458445e-03f, 2.38591526e-02f, -4.53679636e-02f, -5.13373427e-02f,
  6.19550198e-02f, 7.94836041e-03f, 9.25299823e-02f, -6.83692470e-02f, 2.45745573e-02f, -1.38248913e-02f, -2.88275890e-02f, -3.56144109e-03f, 1.00696860e-02f, -5.71817048e-02f,
  4.43461575e-02f, -1.16964160e-02f, 5.74686639e-02f, -1.01466496e-02f, 5.28924912e-02f, -6.93471357e-02f, -1.52737601e-02f, 5.36686443e-02f, -5.58345951e-03f, 1.03204232e-02f,
  -7.25684240e-02f, 1.30369261e-01f, -4.00939956e-02f, -2.43209433e-02f, 4.04103473e-02f, -2.51366273e-02f, 3.49585712e-03f, -4.38419953e-02f, 3.99822555e-03f, 4.58493046e-02f,
  -2.71680187e-02f, -2.67272685e-02f, 1.05095108e-03f, 3.20962407e-02f, -1.29129197e-02f, 3.35369483e-02f, 7.73060042e-03f, 4.00012592e-03f, 1.62699306e-03f, -2.98002418e-02f,
  -1.05304904e-01f, -1.41948178e-01f, -5.90348616e-02f, 3.84690315e-02f, 1.33806048e-02f, 2.79540010e-02f, 1.24951795e-01f, 8.35484192e-02f, 1.50266085e-02f, -3.63359340e-02f,
  -6.91442430e-01f, -1.17901489e-01f, 3.50929908e-02f, -2.16077894e-01f, 1.59561262e-01f, 3.52176055e-02f, 1.48244843e-01f, 7.92744681e-02f, 4.61971499e-02f, -4.34331931e-02f,
  7.03493431e-02f, 6.40294850e-02f, 1.04659994e-03f, 2.00584784e-01f, -1.65427513e-02f, 1.06870472e-01f, 9.03836042e-02f, 3.42236087e-02f, 4.39572744e-02f, 3.39289047e-02f,
  -4.25751247e-02f, -1.76357523e-01f, -1.83104679e-01f, -6.33533671e-02f, 2.92232241e-02f, 1.20839104e-01f, 1.04665421e-01f, -1.89177524e-02f, 1.14168664e-02f, -1.59395803e-02f,
  -1.05699129e-01f, -2.40624696e-01f, 1.46097600e-01f, -5.56850880e-02f, -4.98723751e-03f, -5.32112084e-02f, -3.12527046e-02f, 8.14708136e-03f, -4.84868512e-02f, -1.56444255e-02f,
  -4.25539725e-02f, -9.08914283e-02f, 4.84661236e-02f, 5.24726696e-02f, -4.95374128e-02f, -7.67653957e-02f, -2.99566481e-02f, -7.10712820e-02f, -1.22431871e-02f, 1.73433609e-02f,
  4.51148599e-02f, -7.36813322e-02f, -7.40961172e-03f, 6.00707438e-03f, -4.25812742e-03f, -1.00603834e-01f, -1.59076359e-02f, -7.14099035e-02f, 6.39234036e-02f, -5.96022718e-02f,
  -4.50767465e-02f, -3.94594185e-02f, -1.98633131e-02f, 6.27328828e-03f, -1.74309481e-02f, 7.06839561e-02f, 2.08259355e-02f, -6.80395495e-03f, 7.38154426e-02f, -1.03410296e-02f,
  -8.20845738e-03f, -6.98775146e-03f, 1.56664988e-03f, -4.47752737e-02f, 6.09920323e-02f, 2.13943236e-02f, 7.09875003e-02f, -6.27549961e-02f, -1.87909920e-02f, 7.73492083e-03f,
  2.33699963e-03f, 2.49871630e-02f, -3.15976180e-02f, -2.16875654e-02f, 5.45976050e-02f, 6.65397290e-03f, 5.00051863e-02f, 4.49728556e-02f, -5.93163557e-02f, -5.10207675e-02f,
  -2.18925327e-02f, 1.49377659e-01f, -9.86498781e-03f, 1.21918330e-02f, -2.63447072e-02f, 3.90324779e-02f, -1.18101556e-02f, 9.80211236e-03f, -5.52403443e-02f, -1.28091499e-02f,
  -5.52997328e-02f, -7.76204094e-02f, 4.53194492e-02f, 2.25117672e-02f, 6.78818347e-03f, -4.15900052e-02f, 3.96447293e-02f, 3.96005288e-02f, 1.19932562e-01f, -8.90262499e-02f,
  3.64314020e-02f, -6.75229123e-03f, 3.20345573e-02f, 5.96036501e-02f, 9.81758162e-03f, 1.67471971e-02f, -9.14954208e-03f, 5.28096706e-02f, 4.24023392e-03f, -4.03469652e-02f,
  -5.61980680e-02f, 1.13137387e-01f, 8.43798891e-02f, 1.66295636e-02f, 2.24459648e-01f, 2.58374155e-01f, 4.23320144e-01f, 1.77167401e-01f, 2.59029474e-02f, 8.24074447e-02f,
  -1.48630198e-02f, -2.15928361e-01f, -5.28068133e-02f, -1.82647720e-01f, -1.30614499e-02f, 1.25794291e-01f, 1.28096029e-01f, -8.18926767e-02f, -2.07494304e-01f, -3.97476293e-02f,
  -5.91064170e-02f, -6.57152906e-02f, -2.17591792e-01f, -2.08601207e-02f, 4.19545546e-02f, -4.62026894e-02f, 7.53210858e-02f, 5.00442535e-02f, -3.20154540e-02f, -7.50058740e-02f,
  -1.36400983e-01f, -2.74396483e-02f, -8.37723818e-03f, 4.01757769e-02f, -5.53065389e-02f, 3.55100036e-02f, -2.69431435e-03f, -7.19989985e-02f, 5.43717705e-02f, -3.79501879e-02f,
  4.79073897e-02f, -5.85810617e-02f, 4.19352092e-02f, -1.09081991e-01f, 5.04372120e-02f, -4.33533490e-02f, -1.76241959e-03f, -3.56705822e-02f, -6.23045824e-02f, -1.99281424e-02f,
  -3.51553061e-03f, -5.12510054e-02f, 2.65933815e-02f, 3.96576896e-02f, 2.96054166e-02f, 6.35153102e-03f, 1.83227379e-02f, 1.04936043e-04f, 4.76545431e-02f, -7.42998570e-02f,
  -3.22436751e-03f, 4.97415401e-02f, 5.99850528e-02f, -4.44247611e-02f, 5.70338499e-03f, 4.34326977e-02f, -2.48132590e-02f, 1.85911562e-02f, -7.57302940e-02f, -2.16734726e-02f,
  -1.61882192e-02f, -7.68595710e-02f, 6.98426319e-03f, 1.10648095e-03f, 4.45014164e-02f, 8.14977959e-02f, -6.71402458e-03f, 3.05020623e-02f, -6.13703988e-02f, 2.06655599e-02f,
  1.82543062e-02f, 9.90202557e-03f, 5.09738922e-02f, 3.84960957e-02f, -2.15464644e-02f, -7.70516098e-02f, -3.07069924e-02f, -9.36977286e-03f, -1.06852185e-02f, -4.29052413e-02f,
  -1.25439353e-02f, 1.91370063e-02f, -2.74541527e-02f, -1.03467219e-02f, 6.52777851e-02f, -2.82345470e-02f, 4.94748645e-04f, -1.00304477e-01f, -5.37691312e-03f, 4.33064438e-02f,
  1.67818051e-02f, 9.67529230e-03f, 8.36845487e-02f, 4.97154184e-02f, -4.63731214e-02f, -2.16677357e-02f, -8.28574039e-03f, -7.67565742e-02f, 4.43510227e-02f, 5.88066988e-02f,
  -6.52796705e-04f, 1.58208795e-02f, -1.29044550e-02f, 3.52470130e-02f, 2.39044726e-02f, -8.57857987e-02f, -2.08586850e-03f, 5.67707382e-02f, -1.76305901e-02f, 1.64255068e-01f,
  -2.51089424e-01f, 7.18069151e-02f, -2.58186430e-01f, 3.06189209e-02f, 2.51458764e-01f, 9.52533334e-02f, -1.78173762e-02f, 6.42593130e-02f, 3.03441174e-02f, 7.47672021e-02f,
  1.90606177e-01f, 9.39383656e-02f, -6.25165999e-02f, -8.10615420e-02f, -2.55547643e-01f, -9.95939746e-02f, -6.22972250e-02f, -2.16937050e-01f, -2.03411236e-01f, 1.77686289e-03f,
  1.32310942e-01f, 3.67914140e-02f, -9.14120525e-02f, -1.61826789e-01f, 1.30675286e-01f, 2.28201933e-02f, 2.14383472e-02f, 9.01368819e-03f, 4.32526283e-02f, 1.28309399e-01f,
  -1.75109297e-01f, 9.31490809e-02f, -1.37386844e-01f, -2.38319635e-02f, -2.25057229e-02f, -6.89533427e-02f, -8.85004774e-02f, -4.69195470e-02f, 6.87580258e-02f, -2.10730396e-02f,
  9.59589556e-02f, -2.45568827e-02f, 4.63289768e-02f, 2.30503245e-03f, 4.10911208e-03f, 4.83170971e-02f, -2.50741094e-03f, -1.34724185e-01f, -1.39480427e-01f, 1.36596030e-02f,
  9.45581198e-02f, 1.51475042e-01f, 6.26498275e-03f, -3.80555503e-02f, 1.06717311e-02f, 3.76666784e-02f, 8.18812996e-02f, 2.20358483e-02f, 9.34923813e-03f, -5.70210740e-02f,
  1.17022470e-02f, 1.88944694e-02f, 6.38488233e-02f, 5.09723574e-02f, -4.58025597e-02f, -5.78665000e-04f, 7.66443321e-03f, -9.64763854e-03f, 3.86300962e-03f, 9.36801825e-03f,
  6.67235777e-02f, 2.43229419e-03f, -3.50582302e-02f, -5.20109758e-02f, 4.12766486e-02f, -2.01472156e-02f, -3.13192792e-03f, -7.16794580e-02f, -3.93695384e-02f, 1.83408279e-02f,
  -4.87748580e-03f, 5.56830391e-02f, -5.62340356e-02f, -5.89492312e-03f, 1.67940708e-03f, -1.28125651e-02f, 4.51915562e-02f, -1.02068279e-02f, -7.12414226e-03f, -8.26193579e-03f,
  -1.97346866e-01f, 2.69596837e-02f, -9.95345786e-02f, -7.11906925e-02f, 7.94552546e-03f, 1.40729230e-02f, 6.22117259e-02f, 2.49104500e-02f, 7.53407180e-02f, -2.49123666e-02f,
  9.30409431e-02f, 1.55847808e-02f, -9.68605373e-03f, -4.05832529e-02f, 5.58823980e-02f, 1.17119364e-02f, 2.81960052e-02f, 1.19796526e-02f, 8.52966856e-04f, 3.81215177e-02f,
  5.90679757e-02f, -4.77502495e-02f, 8.55196863e-02f, -1.41676255e-02f, 6.02257363e-02f, -5.70917204e-02f, -2.97635943e-02f, 4.07486372e-02f, -1.14278272e-01f, -1.86619371e-01f,
  -1.60094008e-01f, -1.74101844e-01f, -2.12365594e-02f, -9.90451574e-02f, -3.24182808e-02f, 4.95181680e-02f, -5.83698601e-02f, -6.88392520e-02f, 1.22045964e-01f, -1.01618640e-01f,
  1.90281365e-02f, 2.10480332e-01f, 2.22741187e-01f, 1.79992884e-01f, 1.04418345e-01f, -5.81326187e-02f, -7.47043639e-02f, -2.15117019e-02f, -1.38232121e-02f, 6.86408207e-02f,
  4.61053140e-02f, -9.62674990e-02f, -5.62170036e-02f, 1.81158315e-02f, -7.10491613e-02f, 6.58913776e-02f, -6.89773411e-02f, 4.14010277e-03f, -3.03205512e-02f, -8.72652009e-02f,
  -2.14243885e-02f, -9.28870067e-02f, 4.46416847e-02f, -1.93196554e-02f, 1.57172214e-02f, -7.27046207e-02f, -5.88642769e-02f, -1.23841248e-01f, 4.64376286e-02f, -1.67530440e-02f,
  -4.05576304e-02f, -6.22629859e-02f, -3.21695060e-02f, -3.79260890e-02f, -9.37702432e-02f, 2.63085738e-02f, -1.07400715e-01f, 5.48090506e-03f, -4.29005437e-02f, -6.33065253e-02f,
  1.74809174e-04f, -7.64993653e-02f, -4.92959991e-02f, 7.24297091e-02f, 3.55673842e-02f, 6.04024455e-02f, -1.18976630e-01f, -2.37249141e-03f, -4.10582386e-02f, -5.96419685e-02f,
  1.53472070e-02f, 6.35631084e-02f, -3.91004533e-02f, -2.27006786e-02f, -7.74402693e-02f, -7.07373349e-03f, 8.53420570e-02f, 9.35640652e-03f, 7.46861799e-03f, -7.31516555e-02f,
  5.75467236e-02f, -3.96768227e-02f, -3.80957425e-02f, 1.54848322e-02f, 5.43049537e-02f, -7.90152103e-02f, 3.22363786e-02f, -2.07203813e-02f, 4.21358161e-02f, -8.02793726e-02f,
  2.19830256e-02f, 1.35506485e-02f, 3.35413776e-02f, 9.93210822e-02f, 4.14509512e-02f, -7.31723569e-03f, 5.81266405e-03f, -1.78491184e-03f, -3.74864489e-02f, -6.05579466e-02f,
  -2.77830623e-02f, 1.68835908e-01f, 1.11217862e-02f, 2.31903568e-02f, 1.33253355e-02f, 5.64274900e-02f, -3.46910930e-03f, -6.54852912e-02f, 6.81624189e-02f, -4.35665846e-02f,
  7.18137696e-02f, 7.34552070e-02f, -3.58848386e-02f, 3.77580896e-02f, 1.03163041e-01f, -1.30242556e-02f, -6.82053640e-02f, -4.75292988e-02f, 2.18698885e-02f, -9.39250663e-02f,
  -1.11948818e-01f, -9.80458111e-02f, -6.14537112e-02f, -3.11630522e-03f, -2.91531514e-02f, 1.39558539e-01f, -9.84243900e-02f, -5.82037084e-02f, -3.86056304e-02f, -4.88134511e-02f,
  1.54353365e-01f, -3.23393226e-01f, -1.59139797e-01f, 2.13287950e-01f, -7.26875886e-02f, 1.32105440e-01f, 1.15453579e-01f, 1.06980249e-01f, 2.64540702e-01f, -9.74119753e-02f,
  -8.38785246e-02f, 1.11284927e-01f, 9.26471949e-02f, 5.50467968e-02f, 7.50753433e-02f, -7.86826313e-02f, -1.03352636e-01f, -3.69615760e-03f, 3.61469686e-01f, 1.25853762e-01f,
  -3.95069504e-03f, 4.07888740e-02f, 1.13871545e-01f, 1.10515840e-01f, -1.46274552e-01f, 1.71705466e-02f, -1.31277174e-01f, -1.92257896e-01f, -2.26489186e-01f, -4.88552779e-01f,
  -1.31334320e-01f, -3.15992892e-01f, 2.13848874e-01f, 2.48073786e-02f, -4.34624031e-02f, 4.32867706e-02f, 2.43337583e-02f, -3.12170256e-02f, -3.29565927e-02f, -6.05835207e-02f,
  -6.21392429e-02f, -1.28818378e-02f, 4.33156081e-02f, -2.86681745e-02f, -1.12145327e-01f, 6.29218519e-02f, -2.21648533e-02f, -1.02573700e-01f, -2.40947679e-02f, 7.83795863e-03f,
  -1.49259120e-01f, -1.92273721e-01f, -1.95108116e-01f, -6.85877874e-02f, -5.92875713e-03f, 9.41261277e-03f, -1.17891468e-01f, -1.33079559e-01f, -8.37237760e-02f, -6.22184649e-02f,
  5.97048178e-02f, -2.87298169e-02f, -2.67269202e-02f, -2.74006519e-02f, -1.93055905e-02f, 5.19024096e-02f, -7.70281330e-02f, -3.45371244e-03f, 1.40324309e-02f, -1.64598729e-02f,
  -1.54604353e-02f, 7.84858912e-02f, 2.26810891e-02f, -3.51712778e-02f, 3.51064466e-02f, -5.15291207e-02f, -4.51541913e-04f, -3.32226679e-02f, -7.06853569e-02f, -3.02821640e-02f,
  2.48845667e-02f, -5.64773791e-02f, 4.32510115e-03f, 2.86376569e-02f, -6.95954338e-02f, -5.46384007e-02f, 5.58385625e-02f, -5.59130348e-02f, 8.96926150e-02f, 3.16576101e-02f,
  3.64088535e-01f, -1.46437764e-01f, 3.41248326e-02f, 7.51147652e-03f, 3.03020030e-02f, -4.01703268e-02f, -2.03514006e-02f, -6.81024119e-02f, -3.75371776e-03f, 1.71536636e-02f,
  5.72530180e-02f, 1.84922908e-02f, -7.51200840e-02f, 6.14674017e-03f, 9.78897139e-02f, 9.80498791e-02f, -1.53265325e-02f, 2.76626591e-02f, 3.26972641e-02f, 1.04500413e-01f,
  1.02864273e-01f, 1.65790573e-01f, 1.85295507e-01f, 9.50759798e-02f, 6.30817413e-02f, 1.92398354e-01f, 9.80393887e-02f, 1.06028438e-01f, 1.60307795e-01f, 3.33638012e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.79087010e-03f, -7.32052103e-02f, 9.11037251e-02f, -8.27303305e-02f, 3.02731674e-02f, -1.50256725e-02f, 1.59499824e-01f, 4.81135808e-02f, -7.87197053e-02f, 2.01971154e-03f,
  -7.49691501e-02f, -1.09662838e-01f, -6.49845600e-02f, -2.30195038e-02f, -3.80902290e-02f, -3.14622037e-02f, 6.25853986e-02f, -1.91212632e-02f, 1.20757110e-01f, -1.03611331e-02f,
  -7.14443205e-03f, -1.02999978e-01f, -1.30227774e-01f, 1.09252194e-02f, -1.20052919e-02f, -2.27294676e-02f, 7.59768561e-02f, -8.61155614e-02f, -9.04495716e-02f, -1.14629738e-01f,
  2.33755425e-01f, -1.16214249e-03f, 9.00626406e-02f, -1.32973596e-01f, 5.19565586e-03f, -7.34753832e-02f, 1.29642868e-02f, -1.21652549e-02f, 4.79466878e-02f, 1.09692952e-02f,
  -1.04207061e-01f, 1.20809150e-03f, -7.77758285e-02f, -9.87981558e-02f, -5.77201024e-02f, -7.68140107e-02f, -3.94217856e-02f, -7.56282285e-02f, -1.22870944e-01f, -7.03697419e-03f,
  -3.41589451e-02f, -2.52083875e-02f, 1.32312328e-01f, -8.41132775e-02f, 1.54950172e-02f, 3.93000618e-02f, 9.59117431e-03f, -7.12115616e-02f, -3.50907631e-02f, 4.44331300e-03f,
  -1.41947018e-02f, 7.10497722e-02f, -2.43442599e-02f, -2.66422257e-02f, 5.66245578e-02f, -1.93392430e-02f, 1.00265034e-02f, 1.05049163e-01f, -6.52109692e-03f, -6.10131435e-02f,
  -5.58401160e-02f, 1.20070400e-02f, -2.12761573e-02f, -2.31405944e-02f, -2.49690120e-03f, 4.74907793e-02f, 1.28479162e-02f, 7.28815272e-02f, -5.93054593e-02f, -7.76601806e-02f,
  -4.19535711e-02f, 6.79944009e-02f, 1.95382126e-02f, 9.96219646e-03f, -2.51069646e-02f, -2.96447929e-02f, 6.01562895e-02f, 1.02456026e-02f, 1.80182867e-02f, 1.97381917e-02f,
  1.26479894e-01f, 1.99486054e-02f, -5.24489172e-02f, -2.52151233e-03f, 8.70184973e-02f, 2.26644916e-03f, 2.48170849e-02f, 1.14400629e-02f, -5.32079302e-02f, -2.47435868e-02f,
  -4.24360521e-02f, -1.27629582e-02f, -3.20924334e-02f, -6.64492622e-02f, 1.62277110e-02f, -1.05704172e-02f, -8.84314924e-02f, -9.33322385e-02f, -1.51551794e-03f, -8.69152024e-02f,
  7.06371665e-03f, 1.40807301e-01f, 1.49371639e-01f, 1.02062471e-01f, 2.23340504e-02f, 9.37958956e-02f, 1.03318222e-01f, -3.07594836e-02f, 1.00504689e-01f, 9.43470299e-02f,
  3.60018425e-02f, -1.18360810e-01f, -2.63963521e-01f, -1.32460639e-01f, -1.33948028e-01f, -8.16601887e-02f, 4.97061200e-02f, 7.86391869e-02f, 9.12658423e-02f, -6.35417318e-03f,
  -1.01855792e-01f, -4.86185551e-02f, -5.45625873e-02f, 1.73870679e-02f, -3.70221063e-02f, -1.51804864e-01f, -4.20162939e-02f, -1.13298289e-01f, -6.31299615e-02f, -6.63270503e-02f,
  -2.24244315e-02f, -5.82217015e-02f, -1.16074778e-01f, -1.30233839e-02f, -8.44273195e-02f, -5.90077452e-02f, -1.85921535e-01f, -1.71228141e-01f, -1.10288143e-01f, -5.80620244e-02f,
  -4.51158658e-02f, -8.93938169e-02f, -1.77837592e-02f, 4.82667610e-02f, 1.27597628e-02f, 6.90472499e-02f, 3.45816347e-03f, -8.02874938e-02f, -3.78037021e-02f, -7.30528757e-02f,
  -4.06479873e-02f, 1.00203253e-01f, -1.75498147e-02f, -4.76468988e-02f, -4.58446257e-02f, -1.83132812e-02f, -5.56827299e-02f, -2.81556174e-02f, 5.07300049e-02f, -4.90681343e-02f,
  -9.72762518e-03f, -8.13458040e-02f, 7.58177321e-03f, -2.84316670e-02f, 6.82513043e-02f, 2.34506535e-03f, 5.48628569e-02f, -7.08644018e-02f, -2.19035745e-02f, -1.88674871e-03f,
  6.31376505e-02f, -7.81849027e-03f, 4.23725732e-02f, -5.03566526e-02f, 4.18278687e-02f, -5.42430691e-02f, 7.83910677e-02f, 6.75524622e-02f, 1.17372327e-01f, -7.78776780e-02f,
  -5.70810810e-02f, -9.33751836e-02f, -1.22500844e-02f, -5.36994450e-02f, -1.18240034e-02f, -8.62956718e-02f, 7.78543726e-02f, 5.17640710e-02f, 3.06186359e-02f, -7.11435676e-02f,
  7.03125671e-02f, -5.05927242e-02f, -1.17513396e-01f, -3.63065079e-02f, -1.20986581e-01f, -7.67424479e-02f, -5.54690547e-02f, 8.91812369e-02f, 5.68601899e-02f, -5.55774085e-02f,
  -4.78899898e-03f, 5.01035638e-02f, -1.56445876e-02f, 5.67633833e-04f, -1.10495165e-01f, 2.98750512e-02f, 2.47283513e-03f, 8.20049420e-02f, 3.91705446e-02f, 8.83776397e-02f,
  -6.43262193e-02f, -4.98408973e-02f, 9.77311060e-02f, 6.70350567e-02f, 1.29794478e-01f, -7.51988147e-04f, 8.17817748e-02f, -5.25186174e-02f, 9.36884508e-02f, -5.71676157e-02f,
  -9.43466835e-03f, 6.00185245e-02f, 1.01939969e-01f, 9.98596847e-02f, 6.37789965e-02f, 1.61667988e-01f, 8.55294243e-02f, 1.23993926e-01f, 3.41296904e-02f, 5.20967431e-02f,
  -4.48207557e-02f, 1.00332357e-01f, -9.10579786e-02f, 1.03136264e-01f, 1.35341957e-01f, 9.78352651e-02f, 6.61516190e-02f, 6.92931563e-02f, 1.06738612e-01f, 1.89491548e-02f,
  1.96796469e-02f, -6.25067353e-02f, -6.38091341e-02f, 8.00874531e-02f, 7.55623356e-02f, 1.12156928e-01f, 1.36646517e-02f, 2.88432334e-02f, -9.73871574e-02f, 5.37304468e-02f,
  -6.33663908e-02f, 2.98650842e-02f, -7.31411949e-02f, -9.03257914e-03f, 7.01242834e-02f, -7.23134875e-02f, 5.59545830e-02f, -6.97892383e-02f, -3.47679891e-02f, 6.09331168e-02f,
  -1.83493048e-01f, -2.41835769e-02f, -5.31860292e-02f, 4.44116741e-02f, -9.13956575e-03f, 3.60481590e-02f, -2.21067034e-02f, 4.76731546e-02f, -2.33710594e-02f, 4.78223935e-02f,
  4.73992415e-02f, 5.47554083e-02f, -6.23365864e-02f, 3.30115110e-02f, 5.29227965e-02f, -4.07957621e-02f, 9.08442121e-03f, -5.62459491e-02f, -8.34448114e-02f, -8.09696019e-02f,
  7.19341729e-03f, 3.08490805e-02f, 8.34880769e-02f, -2.40018964e-02f, 1.10143811e-01f, 7.86323920e-02f, 7.46483356e-02f, -1.44252283e-02f, 4.74773115e-03f, 4.50364202e-02f,
  -6.91551864e-02f, -2.21861862e-02f, -1.61112230e-02f, -7.33461753e-02f, 1.95085909e-02f, -3.26951332e-02f, -3.07530575e-02f, 5.74987084e-02f, -4.33713086e-02f, -5.29570878e-02f,
  -9.77062248e-03f, -9.06753987e-02f, -7.25140199e-02f, 4.45770025e-02f, 6.11893795e-02f, 7.63394833e-02f, -7.10413456e-02f, -9.00156423e-02f, -9.71312374e-02f, 3.44539061e-02f,
  -7.64844418e-02f, -4.44602259e-02f, 2.89689470e-02f, -5.61241526e-03f, -6.81557059e-02f, 5.97893670e-02f, 7.02040121e-02f, -1.46995327e-02f, 1.74761266e-02f, -3.99770178e-02f,
  -1.04424812e-01f, -2.56577283e-02f, -3.86303663e-02f, 4.79534194e-02f, 3.45152989e-02f, -6.98133186e-02f, 6.63352758e-02f, -5.72271273e-02f, 4.18376625e-02f, -5.25719933e-02f,
  1.56740732e-02f, -2.78064376e-03f, 5.02451099e-02f, 3.72522660e-02f, -1.39743099e-02f, -6.73487037e-02f, 9.05402750e-02f, -1.06165610e-01f, 1.08770281e-03f, 9.74838883e-02f,
  7.95445740e-02f, -5.19157536e-02f, 9.58699174e-03f, 5.38473874e-02f, 9.98838246e-02f, -9.17871967e-02f, 6.94874898e-02f, -4.68014628e-02f, -6.62819594e-02f, 7.23464563e-02f,
  -3.25879715e-02f, -2.63795376e-01f, -2.69622296e-01f, -1.36352465e-01f, -1.85426205e-01f, -1.30947426e-01f, -3.41375917e-01f, -2.80384738e-02f, 9.52364281e-02f, -2.85399765e-01f,
  1.79389841e-03f, 2.07183614e-01f, 1.64651439e-01f, 1.12986438e-01f, -8.95471945e-02f, -2.59572089e-01f, -3.41839164e-01f, -1.92976877e-01f, 8.13617483e-02f, -4.45030928e-02f,
  9.96761257e-04f, -1.36762727e-02f, -3.86188328e-02f, 2.67330427e-02f, -5.98563254e-02f, 1.82813808e-01f, -1.66466147e-01f, 6.57528057e-04f, -6.24913499e-02f, -2.57307231e-01f,
  -2.36374244e-01f, 9.14807096e-02f, -4.54133973e-02f, 6.22701570e-02f, -6.75659478e-02f, 1.44881951e-02f, -7.70131201e-02f, 7.12676793e-02f, 5.19661158e-02f, -1.59947798e-02f,
  -2.67892536e-02f, 4.16057482e-02f, -2.85586379e-02f, -2.46118964e-03f, 5.00027463e-02f, 7.77005255e-02f, -3.39670223e-03f, 3.20651568e-02f, 2.82887388e-02f, 3.03629525e-02f,
  -4.65213843e-02f, 2.67706681e-02f, 6.10637590e-02f, 1.34198248e-01f, 1.14966542e-01f, 6.93800822e-02f, 1.60357267e-01f, 8.81632790e-02f, 1.30525216e-01f, 1.03665046e-01f,
  -6.97940886e-02f, -2.00534053e-02f, 6.82982877e-02f, 4.81538512e-02f, 8.00577775e-02f, 8.39240849e-02f, 2.72247307e-02f, -1.03079215e-01f, 6.35387152e-02f, -8.47131887e-04f,
  1.72416195e-02f, -4.77391072e-02f, 1.04836235e-02f, -7.94400126e-02f, -1.29905269e-01f, 1.53259039e-02f, 3.81748229e-02f, 5.19856587e-02f, -4.64680865e-02f, -3.36631085e-03f,
  3.23981158e-02f, 5.20131700e-02f, 7.06311222e-03f, 1.02402754e-01f, -5.69385700e-02f, -6.46752566e-02f, 1.53074795e-02f, -3.63265090e-02f, -2.54424848e-03f, -2.35884804e-02f,
  7.95360804e-02f, 1.06882746e-03f, -1.66847214e-01f, 7.11800009e-02f, -4.62567061e-02f, -2.90614069e-02f, -1.01044001e-02f, 1.46413054e-02f, 1.09935068e-02f, -8.99620913e-03f,
  1.28547892e-01f, -3.62001942e-03f, 3.25119905e-02f, 4.09270782e-04f, 4.80122827e-02f, -4.51355800e-03f, 1.62073737e-03f, -9.50664505e-02f, 8.35089535e-02f, 2.96882521e-02f,
  -8.51151571e-02f, -5.72477141e-03f, 1.48074399e-03f, 1.14709340e-01f, 7.05954209e-02f, 8.01567826e-03f, 1.46329012e-02f, -7.29754893e-03f, 1.09928012e-01f, -1.23342454e-01f,
  -2.07773075e-01f, -9.58683342e-02f, -6.84566200e-02f, 2.22073812e-02f, 1.27524972e-01f, -2.23072376e-02f, -2.16407314e-01f, -3.51195410e-02f, -8.02794378e-03f, -1.09298239e-02f,
  9.95540917e-02f, 1.01130992e-01f, 9.47997198e-02f, 1.20919815e-03f, -5.56048267e-02f, 3.26931104e-02f, 1.73746068e-02f, 8.38560797e-03f, -4.74492013e-02f, -5.12590334e-02f,
  4.50471677e-02f, -7.42950588e-02f, -7.03177601e-02f, 4.34551798e-02f, 1.03078835e-01f, -3.05469688e-02f, 1.01100340e-01f, 1.98459439e-02f, 1.44307867e-01f, 1.00677580e-01f,
  1.12693325e-01f, 5.36670946e-02f, 3.49785686e-02f, 3.92092280e-02f, 1.32870197e-01f, 1.44321122e-03f, -1.10272542e-01f, 7.49369338e-02f, 5.06078266e-02f, -8.58000666e-02f,
  9.03769284e-02f, 6.63420856e-02f, -2.85109133e-02f, -1.48722427e-02f, -7.15280771e-02f, -5.69221098e-03f, -6.15549227e-03f, -8.69242400e-02f, 3.48917916e-02f, -1.07697904e-01f,
  5.51812798e-02f, -6.32624477e-02f, -1.46991447e-01f, -4.95727360e-02f, -9.34191868e-02f, 8.05157498e-02f, -1.85323041e-02f, -6.74324408e-02f, -8.94792601e-02f, -5.89508489e-02f,
  9.84146371e-02f, 1.21628687e-01f, -8.49483348e-03f, 6.62914887e-02f, -1.45005733e-02f, 2.07472835e-02f, 6.06324412e-02f, 1.20571062e-01f, 7.36124143e-02f, 3.94045226e-02f,
  7.24463463e-02f, 5.29442467e-02f, -3.72780720e-03f, -1.68760354e-03f, 1.46174338e-03f, 8.68128687e-02f, -3.86007540e-02f, 5.11534028e-02f, -1.63947064e-02f, -6.23290949e-02f,
  -4.18718345e-02f, 6.26062453e-02f, 7.83081129e-02f, 5.61955497e-02f, -2.25727521e-02f, 8.90598521e-02f, 7.31361508e-02f, -2.27713585e-02f, 4.92539145e-02f, 9.72836167e-02f,
  1.44833345e-02f, 1.39724702e-01f, -1.16723385e-02f, 3.66174639e-03f, 1.27474695e-01f, -3.55220307e-03f, 2.38896720e-03f, 7.96776637e-02f, 8.03628266e-02f, -2.02362239e-02f,
  2.39939522e-02f, 4.99848872e-02f, -4.89358380e-02f, 6.63321931e-03f, -3.81109528e-02f, -3.08164395e-03f, 3.30275577e-03f, 3.37273143e-02f, -8.08971375e-02f, -2.90501341e-02f,
  -1.01531386e-01f, -1.21655472e-01f, -1.39089793e-01f, -1.89532369e-01f, -1.07005484e-01f, -6.43038750e-02f, -1.29628569e-01f, -3.75466421e-02f, -5.97168058e-02f, -1.48853824e-01f,
  -3.39038968e-02f, -1.92990452e-02f, -4.63332050e-02f, -1.22882858e-01f, 1.71447415e-02f, 4.13293801e-02f, -1.41323905e-03f, -7.89605603e-02f, -1.05849698e-01f, 4.49367650e-02f,
  2.64473315e-02f, -8.33345428e-02f, 7.14921653e-02f, 2.49904878e-02f, -6.90818131e-02f, 2.89783981e-02f, -1.02778398e-01f, -2.78705508e-02f, 4.40312289e-02f, -4.13101949e-02f,
  7.15362951e-02f, 1.22963879e-02f, -3.06632333e-02f, 1.02704056e-02f, -1.52166253e-02f, 1.26355831e-02f, -5.09929247e-02f, -2.67604366e-02f, 6.58025220e-02f, -8.35342184e-02f,
  1.00537367e-01f, -7.69689158e-02f, -2.65919473e-02f, -1.22146187e-02f, -1.68397538e-02f, -2.30389163e-02f, -4.88414727e-02f, -4.39349897e-02f, -7.09074512e-02f, -3.19790002e-03f,
  3.28430682e-02f, -5.14215976e-02f, -4.31063809e-02f, 9.26821586e-03f, -5.35580441e-02f, 3.78324129e-02f, -6.76502362e-02f, -7.31155416e-03f, -4.38490473e-02f, 9.45012793e-02f,
  7.34552294e-02f, 4.33864705e-02f, -9.16213840e-02f, -7.04272464e-02f, -3.07472274e-02f, 6.87601417e-02f, 6.25285879e-02f, 6.63688108e-02f, 6.30644262e-02f, 4.64615300e-02f,
  2.73189731e-02f, 3.94127481e-02f, 5.69758713e-02f, 5.89368567e-02f, 1.74037553e-02f, 1.16886082e-03f, -6.15340695e-02f, -2.37891916e-02f, 8.34915861e-02f, 3.27426493e-02f,
  3.34066376e-02f, -1.62519682e-02f, 4.31231447e-02f, -2.80499496e-02f, 5.75444624e-02f, 5.16350530e-02f, -3.69722247e-02f, -8.51734281e-02f, 5.26636140e-03f, 1.69783495e-02f,
  -3.89473140e-02f, -8.45002085e-02f, 2.43285727e-02f, -9.25097149e-03f, -8.05020183e-02f, 4.87526245e-02f, -7.50121698e-02f, -6.49770647e-02f, -9.41484235e-03f, 4.26501296e-02f,
  1.68819755e-01f, -8.48954171e-02f, -5.14598116e-02f, -9.25297104e-03f, -5.29208668e-02f, -1.34320837e-02f, 2.98515353e-02f, -3.82364658e-03f, 3.51805822e-03f, 6.72098845e-02f,
  5.94267547e-02f, -1.71427405e-03f, -7.48898163e-02f, 1.45066436e-02f, -3.20143020e-03f, -4.58800653e-03f, -8.06537345e-02f, -4.90049657e-04f, 2.28847545e-02f, -5.22227325e-02f,
  7.86071736e-03f, -3.42240706e-02f, 4.87576751e-03f, 7.29192346e-02f, 7.16369040e-03f, 7.29252547e-02f, -7.03111477e-03f, 7.10415989e-02f, 2.93158880e-03f, 1.11569569e-01f,
  1.34469986e-01f, -1.61903784e-01f, -7.43251517e-02f, -2.86549125e-02f, 2.09703296e-03f, -1.36395574e-01f, -1.43849865e-01f, -6.68464378e-02f, -4.18509841e-02f, -9.28499475e-02f,
  1.69564076e-02f, 1.74028173e-01f, 3.56194526e-02f, 4.95432913e-02f, 7.63729736e-02f, -3.11695356e-02f, -8.52051228e-02f, -4.88224439e-02f, 8.53076670e-03f, 3.42255421e-02f,
  -1.05874836e-01f, 6.60777325e-03f, 1.48991883e-01f, 5.02194511e-03f, -2.50927676e-02f, -1.63613316e-02f, -1.26945987e-01f, -1.50350630e-02f, -1.09468691e-01f, -1.66004896e-01f,
  -1.21265613e-02f, -5.18756162e-04f, -9.66020953e-03f, 1.37712155e-02f, -8.00637156e-02f, -6.65871501e-02f, 4.05771919e-02f, 1.00254714e-01f, -4.98331971e-02f, 1.43331932e-02f,
  -2.76127551e-02f, 4.89009060e-02f, 2.92112469e-03f, -1.33504411e-02f, 1.03140878e-03f, -2.44708136e-02f, 4.65329662e-02f, 5.29304259e-02f, 8.43788311e-02f, -1.00577688e-02f,
  -1.02059551e-01f, 1.98108647e-02f, 5.92823513e-02f, -4.39100452e-02f, 2.12781895e-02f, 6.65290579e-02f, -5.30358814e-02f, 6.11000136e-03f, 6.93729669e-02f, -7.94998035e-02f,
  2.59875762e-03f, 3.18509713e-02f, 5.36785088e-02f, -3.39404047e-02f, 1.88021529e-02f, 6.79993108e-02f, -8.47837627e-02f, -7.77402967e-02f, -6.22829422e-02f, -4.61046286e-02f,
  4.46407981e-02f, 1.77151859e-02f, 1.64564662e-02f, 4.65966314e-02f, 7.32937008e-02f, 1.02866426e-01f, 2.60223225e-02f, -5.78622445e-02f, 1.07803777e-01f, 8.40388760e-02f,
  7.60421902e-03f, 3.67341284e-03f, 6.09284081e-02f, 6.20817691e-02f, -7.84707591e-02f, -3.09385434e-02f, -5.13907224e-02f, 2.37121503e-03f, -7.41416886e-02f, -5.58362268e-02f,
  1.38660930e-02f, 1.54420927e-01f, -9.99134779e-02f, 1.57448426e-02f, 7.73649663e-02f, 5.23241870e-02f, -3.19057405e-02f, -2.17261948e-02f, 1.09511934e-01f, -8.71421471e-02f,
  -6.03208542e-02f, -2.87502799e-02f, 8.83504003e-03f, -6.67436719e-02f, -3.17930579e-02f, -3.83067504e-02f, -3.33989225e-02f, 1.04101198e-02f, -5.82013987e-02f, -9.09660533e-02f,
  -4.22264896e-02f, -3.62090841e-02f, 9.62734893e-02f, 1.60395876e-02f, 1.01090958e-02f, 5.28996112e-03f, -2.42903121e-02f, -6.34368658e-02f, -3.30665633e-02f, -9.48021412e-02f,
  3.40456337e-01f, -2.34156609e-01f, -3.89758274e-02f, -3.05105913e-02f, -5.61534427e-02f, 8.08557346e-02f, -1.42583862e-01f, 1.32646135e-04f, 1.32435575e-01f, -1.06629327e-01f,
  3.72112207e-02f, 2.12070718e-01f, 2.00829700e-01f, 1.35778174e-01f, 1.07498117e-01f, -1.34989560e-01f, -9.44570377e-02f, 1.12833418e-01f, 1.82600707e-01f, 5.53808268e-03f,
  -1.27862632e-01f, -1.52389584e-02f, 2.60055140e-02f, -5.96508533e-02f, -2.20477521e-01f, 4.07510474e-02f, -7.08132386e-02f, 2.26610876e-03f, -8.97728950e-02f, -9.46371108e-02f,
  -4.77404557e-02f, 1.17375508e-01f, 5.35485856e-02f, 1.50603712e-01f, -1.06818654e-01f, -1.81075856e-02f, 4.21428308e-02f, -4.21451591e-02f, -3.42363156e-02f, -4.89687994e-02f,
  1.12016112e-01f, 7.64461979e-03f, 1.31794680e-02f, 5.94994891e-03f, -1.08366035e-01f, -1.85561124e-02f, -8.84772837e-02f, 1.08658113e-01f, 6.56486526e-02f, -7.78774023e-02f,
  -3.15143936e-03f, 6.99938461e-02f, 4.88457363e-03f, 4.15900610e-02f, 4.45633009e-02f, 8.52649733e-02f, -7.90946484e-02f, 1.32071236e-02f, -3.51521634e-02f, -1.06861137e-01f,
  -3.28033864e-02f, 8.53003711e-02f, -5.91656892e-03f, -1.81045607e-02f, -4.93996255e-02f, -6.42638877e-02f, 4.47082929e-02f, 8.31065476e-02f, -5.89007661e-02f, 2.02666949e-02f,
  1.88774168e-02f, -5.29834256e-02f, -5.86003810e-02f, 6.37442544e-02f, -3.50584425e-02f, 1.06770933e-01f, -5.73264360e-02f, -6.12325780e-02f, 5.09373769e-02f, 8.56146291e-02f,
  1.78715196e-02f, 7.30460286e-02f, -7.30648637e-02f, -7.69089907e-02f, 7.62369633e-02f, -3.88109498e-03f, -2.19046492e-02f, 9.76641998e-02f, -5.08920029e-02f, -1.78099461e-02f,
  -6.46973774e-02f, 1.75758034e-01f, 1.28143102e-01f, -5.98101644e-03f, -2.72301212e-02f, -8.46123099e-02f, 1.11576989e-01f, -7.75813535e-02f, -3.29921283e-02f, -1.16081811e-01f,
  -2.06479300e-02f, 1.02236411e-02f, 5.17683513e-02f, -4.91576828e-02f, -8.67082030e-02f, -4.63379314e-03f, -2.71963198e-02f, 8.65041837e-02f, 8.49074721e-02f, 9.87914205e-03f,
  -4.32850868e-02f, 1.13904841e-01f, 1.09180667e-01f, 1.69444438e-02f, 2.03267746e-02f, 1.39992073e-01f, 6.03410183e-03f, 3.76737341e-02f, 6.94694519e-02f, -1.61974788e-01f,
  -2.43922561e-01f, 1.81876402e-02f, 5.00640236e-02f, 3.28171551e-02f, 1.90918550e-01f, 1.46021694e-01f, 1.45775825e-01f, 9.88057777e-02f, 1.24607645e-02f, 6.02886900e-02f,
  3.55110839e-02f, 9.54846367e-02f, 5.66785187e-02f, 6.25690669e-02f, 1.50207222e-01f, 1.49517162e-02f, 6.31015226e-02f, 9.93386582e-02f, 3.75113674e-02f, 8.76830774e-04f,
  1.35196090e-01f, -2.87825242e-02f, -1.52366117e-01f, -8.31361935e-02f, 1.35876104e-01f, 6.60098344e-02f, 5.21398149e-02f, 2.75503024e-02f, 4.00305837e-02f, 1.63181394e-01f,
  -2.11628731e-02f, -8.47735256e-02f, 6.00130446e-02f, -1.81815811e-02f, -8.10845271e-02f, -3.72837968e-02f, 1.29178641e-02f, 4.01588390e-03f, -4.76071797e-02f, -5.82215637e-02f,
  3.77745219e-02f, 1.73714980e-02f, 4.47363779e-03f, 5.31088673e-02f, -5.35539128e-02f, -4.92945947e-02f, 4.31008544e-03f, -9.44605190e-03f, -1.24691129e-02f, 2.73579694e-02f,
  2.58188490e-02f, 2.69871801e-02f, -9.45850238e-02f, 1.34967295e-02f, 1.72062218e-02f, -8.30279589e-02f, -4.61996943e-02f, -1.11467456e-02f, -9.21992809e-02f, 2.62724254e-02f,
  -3.02342158e-02f, 5.58960885e-02f, 3.68828215e-02f, -6.34729788e-02f, 5.22362664e-02f, 5.45154586e-02f, 1.40553653e-01f, -3.55099365e-02f, 7.71049634e-02f, -3.74158174e-02f,
  -5.81683479e-02f, -6.95135891e-02f, 4.85727796e-03f, 3.87765504e-02f, 6.80140406e-02f, -2.46016458e-02f, 7.83593282e-02f, 4.86264117e-02f, -1.09922454e-01f, -9.80047211e-02f,
  1.10840099e-02f, -3.97321209e-02f, -2.82750670e-02f, 4.45423163e-02f, 4.61104251e-02f, 4.16489914e-02f, 7.70889819e-02f, -8.49725753e-02f, -8.95444676e-02f, 2.42344514e-02f,
  -8.72012004e-02f, -1.24474736e-02f, -4.46128957e-02f, -5.29921465e-02f, 1.95373073e-02f, -1.03519008e-01f, 3.61908562e-02f, -1.17577827e-02f, -4.46378738e-02f, -2.17279792e-02f,
  2.40584761e-02f, -4.61081341e-02f, -4.60284390e-02f, 3.92529368e-03f, -2.80854176e-03f, -3.12811658e-02f, -5.43821789e-02f, 1.08968457e-02f, 3.71984877e-02f, -5.21862730e-02f,
  3.96196842e-02f, -9.55231860e-02f, -8.96911323e-02f, -1.28506646e-01f, 8.51692036e-02f, 4.28482108e-02f, 1.65701378e-02f, -6.59929067e-02f, -1.19699635e-01f, -5.30403294e-02f,
  -3.15517485e-02f, -2.30190098e-01f, -1.71068549e-01f, 8.69038180e-02f, -9.19733793e-02f, -9.70060453e-02f, -1.53726846e-01f, 2.00638198e-03f, 5.32830060e-02f, -1.02059931e-01f,
  -5.53993834e-03f, 9.63781998e-02f, -1.19953882e-02f, 3.22494209e-02f, 1.70170590e-02f, -2.22027659e-01f, -5.95846102e-02f, 7.62644559e-02f, -1.95847303e-02f, 7.33044883e-03f,
  6.04361296e-03f, 6.78713918e-02f, 1.47510618e-01f, 8.95280764e-02f, -1.51336414e-03f, 1.08651325e-01f, -3.29069756e-02f, 2.16204207e-02f, -6.73869699e-02f, 7.61666447e-02f,
  -5.15067577e-02f, -6.72235042e-02f, 3.51393297e-02f, -4.54932824e-02f, -8.61958191e-02f, -5.38818203e-02f, 5.88122755e-02f, -5.31687960e-02f, -4.05238271e-02f, -4.05817814e-02f,
  6.71974346e-02f, -3.77723463e-02f, 8.21923837e-02f, 1.39782066e-02f, -5.87058142e-02f, 1.07813841e-02f, 2.76834164e-02f, -3.29838991e-02f, -3.09351515e-02f, 7.19654188e-02f,
  -4.20312025e-03f, 3.06444112e-02f, -4.52562347e-02f, -6.91027418e-02f, 2.32584160e-02f, 1.10086709e-01f, 3.61161456e-02f, 1.10830083e-01f, 1.72376726e-02f, -4.46914509e-02f,
  -9.13181007e-02f, 8.27334970e-02f, -4.83597964e-02f, -6.72949152e-03f, -3.18974117e-03f, -6.39852956e-02f, -5.61464615e-02f, 8.63089859e-02f, -4.70937230e-02f, -7.07484484e-02f,
  -2.79944437e-03f, -1.03834510e-01f, -2.00175662e-02f, -4.38436717e-02f, 8.62163529e-02f, 1.63158681e-02f, -6.31248653e-02f, 2.38773208e-02f, -2.88045574e-02f, 1.03606202e-01f,
  -3.69057991e-02f, 8.76895264e-02f, -6.65258914e-02f, 4.77935486e-02f, -3.88020463e-02f, -4.81787100e-02f, -3.60194668e-02f, 2.48460602e-02f, 7.22987056e-02f, -5.72948940e-02f,
  -8.80029239e-03f, 9.76300836e-02f, -1.11998864e-01f, 4.41527218e-02f, -1.93012897e-02f, -4.19997908e-02f, -7.22776279e-02f, 7.90795013e-02f, 9.43857655e-02f, 2.96763144e-03f,
  6.76636323e-02f, 3.76455262e-02f, -2.27456819e-02f, 9.36651696e-03f, 4.93821763e-02f, -5.83930465e-04f, -8.72376412e-02f, -2.26365845e-03f, 3.23327035e-02f, 5.80888763e-02f,
  -4.55794893e-02f, -7.99450725e-02f, -8.08352605e-02f, -8.66831690e-02f, 4.25784476e-02f, -3.10831852e-02f, 3.40164825e-02f, 1.09308888e-03f, -1.15091152e-01f, -2.46629909e-01f,
  5.92949726e-02f, -1.00252301e-01f, -1.70600027e-01f, 1.13736570e-01f, 9.83238742e-02f, -2.19201416e-01f, -2.78372049e-01f, -2.07978472e-01f, 3.28300744e-02f, -1.11200567e-02f,
  -3.59998085e-02f, 7.49138445e-02f, 2.68533546e-02f, 2.56980374e-03f, -2.03317478e-01f, -3.61095592e-02f, 1.12124775e-02f, -8.92209262e-02f, -8.21581259e-02f, -3.43699567e-02f,
  1.17549352e-01f, 1.09506086e-01f, -5.55859283e-02f, 5.11047877e-02f, 3.92966084e-02f, 1.20352812e-01f, -5.71131036e-02f, 6.34617135e-02f, 7.51723945e-02f, 8.48960802e-02f,
  1.33619204e-01f, 4.52710018e-02f, -4.44590598e-02f, 6.70424253e-02f, 7.66817480e-02f, -8.01528394e-02f, -4.55977321e-02f, 2.96097845e-02f, 6.52300268e-02f, 6.38822094e-02f,
  6.49662837e-02f, -7.27264807e-02f, 1.60813681e-03f, -5.86991049e-02f, -3.60036418e-02f, -6.16604723e-02f, -6.76821545e-02f, -5.82674891e-02f, -7.21853152e-02f, -1.12720579e-02f,
  -2.46340455e-03f, -4.27525900e-02f, -2.39740144e-02f, -8.61024112e-02f, 2.83989916e-03f, -5.55421598e-02f, 4.34676036e-02f, 7.32636154e-02f, -1.51334986e-01f, -9.18835327e-02f,
  -3.38264592e-02f, -8.24377835e-02f, -6.80702797e-04f, 2.40176897e-02f, -3.27927731e-02f, 5.70795946e-02f, -6.06275722e-02f, -4.34518047e-02f, -9.19997990e-02f, -6.32267445e-02f,
  -1.45102302e-02f, -7.19889849e-02f, 8.65065083e-02f, 3.13029848e-02f, -4.69408184e-02f, -7.84478635e-02f, -1.14844237e-02f, -1.03573710e-01f, -4.37914357e-02f, -2.67885569e-02f,
  3.97480018e-02f, -6.38850853e-02f, 5.50566986e-02f, -6.97514489e-02f, -8.23822394e-02f, -9.29625109e-02f, -8.83953646e-02f, -1.14523873e-01f, 3.63161461e-03f, -7.44762942e-02f,
  2.37704054e-01f, -9.61051956e-02f, 3.78894024e-02f, -4.33770008e-02f, -4.47221175e-02f, -1.97334029e-02f, -6.10689856e-02f, -1.18146483e-02f, -3.65197882e-02f, -6.43670335e-02f,
  -3.73947471e-02f, -9.11312923e-02f, 4.27044481e-02f, -3.96737158e-02f, 4.33374569e-02f, -2.39504371e-02f, -9.57952589e-02f, -7.92342573e-02f, -7.34645948e-02f, 3.25927436e-02f,
  -8.07910040e-02f, -8.76785889e-02f, -8.56398419e-02f, -2.73690745e-02f, 4.74702157e-02f, -1.17216185e-01f, -1.33564368e-01f, -6.80434704e-02f, -1.31226778e-01f, -3.85215171e-02f,
  6.72927648e-02f, 5.79336211e-02f, 2.98611354e-02f, 8.69778618e-02f, 1.38345465e-01f, 1.10529214e-01f, 1.11318426e-02f, 3.39505845e-04f, 1.18524447e-01f, 1.57822013e-01f,
  1.01038456e-01f, 9.52404886e-02f, 1.25893205e-01f, -2.41431314e-02f, 6.87654689e-02f, 7.85150826e-02f, 2.65541170e-02f, 7.68325180e-02f, -3.26100811e-02f, 9.22388211e-02f,
  9.10341293e-02f, 9.48127061e-02f, -1.58779826e-02f, 8.75837132e-02f, -7.03293085e-02f, 9.12126154e-02f, -1.49689000e-02f, -2.55224872e-02f, 7.06105307e-02f, 4.19266522e-02f,
  7.49206841e-02f, -6.45791590e-02f, 3.33552435e-02f, 4.89674471e-02f, 1.21621368e-02f, -4.22303751e-02f, 8.03049803e-02f, 1.33205485e-02f, -1.52512426e-02f, -1.17876735e-02f,
  -1.27611645e-02f, -1.09468818e-01f, -7.01294243e-02f, 4.04070430e-02f, -6.62687123e-02f, -9.99095142e-02f, -5.78708500e-02f, -3.72435898e-02f, 1.26330974e-03f, 3.32453921e-02f,
  2.58999001e-02f, -8.49751160e-02f, 4.48961183e-03f, -7.26596862e-02f, 3.21176834e-02f, 9.43089351e-02f, 7.09031373e-02f, -1.00384474e-01f, -4.29979265e-02f, 3.25670615e-02f,
  -6.31207775e-04f, 6.76963031e-02f, 7.43336752e-02f, 6.58935457e-02f, -5.53497188e-02f, 8.94021839e-02f, -4.36312556e-02f, -8.99447054e-02f, 5.33441417e-02f, -2.81655975e-02f,
  3.26700993e-02f, 1.07039236e-01f, -5.96443787e-02f, 7.76298866e-02f, -7.57826865e-02f, -5.96716143e-02f, -3.82040143e-02f, 2.04818603e-02f, -5.59228566e-03f, -2.75156535e-02f,
  7.28989393e-02f, 4.27892990e-02f, -9.43882838e-02f, -8.87213051e-02f, -6.86079487e-02f, 2.52047312e-02f, 6.76517002e-03f, -1.80010814e-02f, 3.27026881e-02f, -1.90254431e-02f,
  9.49254483e-02f, 1.14156157e-01f, -3.87677290e-02f, -9.10059437e-02f, 1.72238238e-02f, -5.14327437e-02f, 7.76861310e-02f, -3.40776481e-02f, -6.05637804e-02f, 6.00414574e-02f,
  5.43260872e-02f, -1.06591053e-01f, -5.53577170e-02f, -6.32585883e-02f, -6.06438033e-02f, 6.42136559e-02f, -5.81691004e-02f, 8.35315287e-02f, -5.26687503e-02f, 2.22633723e-02f,
  -1.27162440e-02f, 1.30044501e-02f, 3.22148055e-02f, 6.93303049e-02f, -2.85932552e-02f, 2.89373025e-02f, -6.64454997e-02f, 5.64252473e-02f, -8.05174261e-02f, 1.84708666e-02f,
  4.35955968e-04f, -5.49877547e-02f, 1.51982665e-01f, 9.33636427e-02f, 7.39498436e-02f, 1.08155631e-01f, 1.73339128e-01f, 8.82219002e-02f, 2.03178599e-02f, 7.57817132e-03f,
  4.05154191e-03f, -1.19185954e-01f, -9.49606374e-02f, 8.16930458e-03f, 7.93750361e-02f, 8.43186304e-02f, 5.67226857e-02f, 8.10796916e-02f, 2.63116024e-02f, 7.41744065e-04f,
  5.43813454e-03f, -7.20221782e-03f, -3.56718078e-02f, -6.53016120e-02f, 4.30181175e-02f, -9.99063551e-02f, 8.74763131e-02f, -3.13889561e-03f, -3.74217033e-02f, -5.12112081e-02f,
  6.00855686e-02f, 6.21775612e-02f, 7.34969899e-02f, 3.36040631e-02f, 5.69787323e-02f, 2.91315839e-02f, -4.50333208e-02f, -3.72406468e-02f, -7.26116896e-02f, 2.09346507e-02f,
  7.88804144e-02f, -2.45454591e-02f, -3.47299725e-02f, 7.74311200e-02f, 1.44657502e-02f, 7.07886070e-02f, -6.61008954e-02f, 6.76159039e-02f, 2.25569773e-02f, -4.86649834e-02f,
  -7.13864937e-02f, 1.03167459e-01f, -3.29297408e-03f, 2.30635516e-03f, 8.89221728e-02f, -6.93123341e-02f, -3.12377270e-02f, 5.35191409e-02f, 2.47603264e-02f, -1.78041290e-02f,
  2.81049460e-02f, -7.84815624e-02f, -6.20643944e-02f, 2.51450930e-02f, -5.65967336e-03f, 4.08604555e-02f, 2.40489747e-03f, 8.36309865e-02f, 5.89091368e-02f, -5.98042235e-02f,
  -3.25241759e-02f, -9.00165737e-03f, 3.81261786e-03f, 3.57196257e-02f, -6.27962351e-02f, -7.06591234e-02f, 5.76935289e-03f, 6.40950575e-02f, -9.71784368e-02f, -2.52324790e-02f,
  5.80690475e-03f, -7.74916112e-02f, -1.96798742e-02f, -4.19843681e-02f, 4.11324129e-02f, 7.15886941e-03f, -6.11482300e-02f, 4.50741500e-02f, -2.13788450e-02f, 2.85868905e-02f,
  2.46720314e-02f, 1.01999687e-02f, 6.82558585e-03f, 3.53025459e-02f, 7.74881840e-02f, 3.30621190e-02f, 8.49052072e-02f, 8.13024119e-02f, -2.04993617e-02f, -5.04379645e-02f,
  -3.50557640e-02f, 8.20679963e-02f, -4.61674221e-02f, -6.61661401e-02f, 6.39398545e-02f, 6.51842654e-02f, -1.12259291e-01f, -3.00329998e-02f, -1.12282727e-02f, -8.68768170e-02f,
  3.29338061e-03f, 8.19486529e-02f, 5.08625545e-02f, 6.91952333e-02f, 2.67078057e-02f, 8.40680227e-02f, -1.56723280e-02f, 5.51980454e-03f, 1.01866446e-01f, -7.14917341e-03f,
  -3.00618917e-01f, -2.05893442e-02f, -1.87641814e-01f, -1.01223327e-01f, 1.63587958e-01f, -2.52429564e-02f, -8.24750811e-02f, -1.59746427e-02f, 2.72039641e-02f, 8.47821161e-02f,
  7.50131831e-02f, 6.68152720e-02f, -3.43931466e-02f, 2.75261570e-02f, -3.85538489e-02f, -3.07883844e-02f, 5.32084592e-02f, -1.22359999e-01f, -1.39681071e-01f, -7.05709085e-02f,
  1.23577870e-01f, -9.50853750e-02f, -7.90277496e-02f, 2.64068414e-02f, 7.47138709e-02f, 1.99488532e-02f, 4.53238711e-02f, -2.93129999e-02f, -4.78919521e-02f, 7.35887140e-02f,
  -3.24311778e-02f, 4.16547656e-02f, 6.91569448e-02f, -8.16145167e-02f, -1.73963178e-02f, -2.91799940e-03f, 2.04081051e-02f, -1.07632019e-01f, -5.19615747e-02f, -9.34031084e-02f,
  2.82587055e-02f, 6.77024052e-02f, 1.65270697e-02f, 4.47040834e-02f, -1.32612094e-01f, -1.20658278e-01f, -1.26462400e-01f, -3.17114517e-02f, -5.96128628e-02f, -1.19336553e-01f,
  -2.74586733e-02f, -6.61893934e-02f, -1.34073570e-01f, 7.54089281e-03f, -3.49497385e-02f, 2.79282946e-02f, 1.95025597e-02f, -1.75990351e-02f, -2.29427777e-02f, -6.67396337e-02f,
  1.14601359e-01f, 1.41548321e-01f, -2.59381942e-02f, -7.53210261e-02f, -3.12891640e-02f, 1.16736740e-01f, 5.85392416e-02f, 5.93791343e-02f, -6.87480718e-02f, 4.51292731e-02f,
  4.38850150e-02f, 4.09819335e-02f, 1.59438904e-02f, 7.05018863e-02f, 2.75695417e-03f, -4.52893898e-02f, -9.25392061e-02f, 3.00271553e-03f, 6.18729293e-02f, -7.18903914e-02f,
  -3.37890424e-02f, -8.10433179e-02f, 5.91096841e-02f, -4.29527387e-02f, -1.72909647e-02f, -9.30567831e-02f, -3.94907482e-02f, -4.67208996e-02f, -7.93958306e-02f, -4.60295938e-02f,
  -4.14507203e-02f, 6.33418262e-02f, 1.71526000e-02f, -1.11525536e-01f, 3.43046635e-02f, 3.42786498e-02f, -4.91393581e-02f, -1.29064858e-01f, 2.50158925e-02f, -5.50038069e-02f,
  -9.60040689e-02f, -1.32420855e-02f, 2.50594243e-02f, -3.22077386e-02f, -5.32768182e-02f, 4.51151468e-03f, -8.11031312e-02f, -1.01438679e-01f, -4.49031219e-03f, 2.70002577e-02f,
  -1.53659880e-01f, -6.68451339e-02f, -1.09981887e-01f, -1.11108549e-01f, 3.04972474e-03f, -4.62937541e-02f, -3.33175324e-02f, -8.31252038e-02f, -1.53528988e-01f, -1.25382766e-01f,
  1.55864745e-01f, 4.41805273e-02f, 5.51791228e-02f, 1.37487486e-01f, 1.44631088e-01f, 7.22076595e-02f, 1.26879349e-01f, 3.23918485e-03f, 5.81824481e-02f, 1.22942835e-01f,
  3.13854702e-02f, 4.97843660e-02f, -6.08772598e-02f, -2.89680287e-02f, 1.53115075e-02f, 1.24952056e-01f, 1.44695505e-01f, 8.71501043e-02f, 6.25906438e-02f, 2.47194935e-02f,
  1.26717061e-01f, 3.24514844e-02f, 5.02620041e-02f, -3.31466496e-02f, 1.36911586e-01f, -3.85807380e-02f, 8.84472355e-02f, 6.26420826e-02f, -4.67988849e-02f, 2.09572747e-01f,
  -1.23869888e-01f, 1.03140436e-02f, -6.32244945e-02f, -1.60694215e-02f, 1.01870543e-03f, 3.01661007e-02f, -9.85150188e-02f, -9.82533768e-02f, -5.70547283e-02f, 3.02088205e-02f,
  -8.30276161e-02f, -8.24597627e-02f, 6.01416491e-02f, -9.18918699e-02f, -6.89964890e-02f, 4.62363847e-02f, 1.33989118e-02f, 2.32559666e-02f, 3.06208599e-02f, -3.60343680e-02f,
  4.47374955e-02f, 4.42470349e-02f, -6.19699806e-02f, -1.06456473e-01f, 5.98272197e-02f, 4.70435284e-02f, -7.36768916e-03f, 2.56816362e-04f, -5.28667681e-02f, -2.64635179e-02f,
  -7.71822874e-03f, -4.03565504e-02f, -5.34130484e-02f, 2.79892627e-02f, -2.73696035e-02f, -7.05479681e-02f, 3.55194025e-02f, -3.88785601e-02f, 9.51239765e-02f, -7.15653300e-02f,
  -1.28643885e-02f, 5.30229099e-02f, 5.18901013e-02f, -6.44299537e-02f, -2.05857325e-02f, -8.37752223e-02f, -7.10299388e-02f, -6.17105234e-03f, 3.63293514e-02f, -4.31514643e-02f,
  7.96449631e-02f, 1.96824353e-02f, 1.50751946e-02f, 2.84184905e-04f, 6.19834401e-02f, 5.55239022e-02f, -5.80374412e-02f, 6.22241423e-02f, -3.53211500e-02f, -3.98020521e-02f,
  -4.05845232e-02f, -1.31503522e-01f, -2.25690920e-02f, 7.98832178e-02f, -3.44035514e-02f, -1.00929946e-01f, -3.61287370e-02f, -9.57463011e-02f, -6.19029300e-03f, 5.53561710e-02f,
  2.30976492e-02f, -1.04470449e-02f, 5.56842797e-03f, 1.18682710e-02f, 2.08656918e-02f, 4.12073843e-02f, 2.92613469e-02f, -7.04401955e-02f, -8.97830278e-02f, -1.12875231e-01f,
  -9.70056206e-02f, -4.98290621e-02f, 2.53122374e-02f, -3.39851640e-02f, -4.86940481e-02f, 5.21649681e-02f, -7.01482920e-03f, -3.03773228e-02f, -1.04451254e-01f, -7.89934397e-02f,
  -2.44508594e-01f, -1.99984193e-01f, -2.03654557e-01f, 8.08275491e-02f, 1.66471899e-01f, 8.56708214e-02f, 4.78428602e-02f, 9.45477784e-02f, 3.47746052e-02f, -7.32901022e-02f,
  7.32994378e-02f, 1.07761882e-01f, 1.38815328e-01f, -1.82991417e-03f, 2.31045182e-03f, -6.06378317e-02f, -5.28277569e-02f, -6.29519636e-04f, 7.26720169e-02f, 4.68803309e-02f,
  8.69300142e-02f, 6.35249242e-02f, -9.27812234e-02f, -8.96121487e-02f, -2.06896948e-04f, 6.97934180e-02f, -5.53839132e-02f, -2.96085794e-02f, -1.13548841e-02f, 1.79327130e-02f,
  -1.24522351e-01f, -7.43696168e-02f, 5.91966063e-02f, 6.40308633e-02f, 1.55894477e-02f, -2.31772661e-03f, 5.96836070e-03f, -1.83386402e-03f, 2.30107363e-02f, 2.39263033e-03f,
  -1.39642954e-02f, -1.91774536e-02f, 9.78554338e-02f, 3.86355743e-02f, -4.72593382e-02f, 1.04339132e-02f, -1.39356405e-02f, 1.92879513e-02f, -5.79172410e-02f, -7.19814003e-02f,
  6.98827803e-02f, 9.49730501e-02f, -5.24530374e-02f, 1.75697058e-02f, -1.61367096e-02f, 7.63199702e-02f, -8.15540552e-02f, -6.15237430e-02f, -1.53324857e-01f, -1.31234393e-01f,
  4.17703688e-02f, -5.57171218e-02f, -4.30062003e-02f, -4.05954942e-02f, -7.56945238e-02f, -7.01188436e-03f, -1.74154304e-02f, -3.52140330e-02f, 7.90515915e-03f, -9.47897583e-02f,
  7.33670220e-02f, 3.44422576e-03f, 3.90661620e-02f, -3.49643379e-02f, -8.48819241e-02f, -6.48985729e-02f, 2.76601594e-02f, -1.06015109e-01f, -1.48300556e-02f, 3.05642653e-02f,
  5.23666963e-02f, -7.13215098e-02f, -1.13917373e-01f, -4.07623388e-02f, -1.37345549e-02f, 4.12004218e-02f, 5.00558177e-03f, -5.65054454e-03f, -6.24629222e-02f, 3.99644002e-02f,
  -1.11393124e-01f, 1.27214953e-01f, 1.64808072e-02f, 3.36194858e-02f, 2.74901222e-02f, -4.20605676e-04f, 2.16907281e-02f, 7.19620362e-02f, 1.00126220e-02f, -3.65190096e-02f,
  5.63024841e-02f, -3.62839475e-02f, -4.73976284e-02f, -3.55598964e-02f, 8.18120502e-03f, -6.82132244e-02f, -4.26357053e-02f, 1.81314908e-02f, -8.79925191e-02f, -7.72939399e-02f,
  6.35234360e-03f, -1.53251648e-01f, -1.53011173e-01f, -1.64533138e-01f, -1.31378293e-01f, 2.08191779e-02f, -9.22405645e-02f, -1.02203764e-01f, -1.60888180e-01f, -2.26008922e-01f,
  5.91603965e-02f, 4.44047749e-02f, 5.60749285e-02f, -9.39609297e-03f, 8.09007809e-02f, 5.87414503e-02f, 8.42346922e-02f, -6.39636144e-02f, -3.57976649e-03f, -7.20908493e-02f,
  -4.33041528e-02f, -6.53504729e-02f, -9.32504386e-02f, -2.37949155e-02f, 4.71434668e-02f, -2.35124137e-02f, -1.55955479e-02f, -8.31881687e-02f, -1.29493162e-01f, 5.93437403e-02f,
  -3.21192145e-02f, -2.87277084e-02f, 1.77898947e-02f, 3.20193730e-02f, 1.13288850e-01f, 4.56413478e-02f, 6.47326708e-02f, 1.22088894e-01f, 2.66180839e-02f, 2.59420201e-02f,
  4.33175750e-02f, 1.11199066e-01f, 1.95088554e-02f, 8.01895037e-02f, -5.41407876e-02f, 4.15012687e-02f, -8.10763910e-02f, -6.98563270e-03f, -8.69657323e-02f, -7.36568943e-02f,
  -5.16582169e-02f, -1.73549000e-02f, 7.73743959e-03f, -9.01815966e-02f, -8.42532218e-02f, -1.03058085e-01f, 7.25165382e-02f, -8.26117694e-02f, 5.45832813e-02f, -5.73682226e-02f,
  9.81749445e-02f, 2.52586678e-02f, 7.71653205e-02f, -5.30392826e-02f, -4.97783720e-02f, 9.55743268e-02f, 6.88667148e-02f, 4.54406813e-03f, -2.57598571e-02f, -3.11780851e-02f,
  -7.22036809e-02f, -6.94211423e-02f, 6.90546334e-02f, -4.47863899e-02f, -2.87924875e-02f, 7.84171820e-02f, 3.19606699e-02f, 4.17130701e-02f, 1.50655610e-02f, 6.86192960e-02f,
  -5.12509048e-02f, -3.39388177e-02f, 5.67703098e-02f, -3.11467368e-02f, -8.94058421e-02f, -5.59737673e-03f, 1.51714198e-02f, -7.98658803e-02f, -9.10071954e-02f, 5.29519469e-02f,
  -6.84393570e-02f, -3.49885523e-02f, -7.08697364e-02f, -8.52777734e-02f, -1.72835458e-02f, 4.03481759e-02f, -7.36368224e-02f, -7.45531768e-02f, -2.77232826e-02f, 9.46004167e-02f,
  5.16547151e-02f, -2.64665578e-02f, -5.27527183e-02f, -1.30623747e-02f, 1.40403867e-01f, 8.12508091e-02f, 8.29979554e-02f, -3.70815806e-02f, -5.48585691e-02f, -5.84779633e-03f,
  -4.38555852e-02f, -6.52495995e-02f, 6.60921186e-02f, -1.16546405e-02f, -1.76758114e-02f, -4.13958356e-02f, -8.28093663e-03f, -6.85458407e-02f, 8.71632248e-02f, 1.88042112e-02f,
  9.48143005e-03f, -8.37256834e-02f, -5.40202707e-02f, 1.43051464e-02f, 5.43514900e-02f, 1.75260622e-02f, 7.88072944e-02f, 5.88042438e-02f, -7.05106556e-02f, 7.75532275e-02f,
  -1.80911217e-02f, -1.16214916e-01f, -7.10893497e-02f, -7.33795315e-02f, -2.38033943e-02f, 4.64637838e-02f, -1.45150676e-01f, -1.28921643e-02f, 8.48645493e-02f, -7.55635127e-02f,
  -4.64697033e-02f, 7.16474801e-02f, -4.64685299e-02f, 1.26056671e-01f, -2.78270878e-02f, -3.78852990e-03f, -3.49249318e-02f, 4.76207361e-02f, 1.92882549e-02f, -6.27430901e-02f,
  -4.23766114e-02f, 1.93803757e-02f, -5.41396849e-02f, -2.34095026e-02f, -1.23433240e-01f, -9.63444114e-02f, 2.87254807e-02f, 3.89863774e-02f, -5.51265404e-02f, -7.85907581e-02f,
  -3.78210433e-02f, 9.33908895e-02f, 1.24118492e-01f, -5.19730337e-02f, 2.58179149e-03f, -5.16046397e-02f, -5.11847585e-02f, 1.49856294e-02f, 4.36488688e-02f, -4.74153236e-02f,
  1.47812096e-02f, 9.67460275e-02f, -2.31926851e-02f, -4.93184552e-02f, -7.20981732e-02f, -4.43666205e-02f, -5.35913184e-02f, -5.51121263e-03f, 2.25132592e-02f, -4.77445573e-02f,
  -5.55600673e-02f, 6.33013842e-04f, -1.18503813e-02f, -8.00068602e-02f, -6.38134778e-02f, -2.85632294e-02f, -7.88611770e-02f, 3.38717252e-02f, 5.84381185e-02f, -5.48905954e-02f,
  9.77031440e-02f, 1.93364744e-03f, 6.65825307e-02f, 2.74225101e-02f, 2.38473509e-02f, 5.31789474e-02f, 1.49180591e-02f, 9.41958651e-03f, -7.91563168e-02f, 7.52715990e-02f,
  4.73869145e-02f, -4.22435887e-02f, -8.42843726e-02f, 6.04624078e-02f, 2.01154687e-02f, 3.42779160e-02f, -4.76164594e-02f, -1.09046102e-02f, 1.02485776e-01f, 4.97363470e-02f,
  -5.64744174e-02f, -3.43649983e-02f, 4.22066189e-02f, 2.19879188e-02f, 9.44060907e-02f, 7.57341683e-02f, 5.28422818e-02f, 5.40422164e-02f, 8.88105631e-02f, 4.44646291e-02f,
  -5.91109544e-02f, 6.23256117e-02f, 1.49922697e-02f, 7.12332055e-02f, 2.62937602e-02f, -8.37641489e-03f, 3.61351892e-02f, 6.13356084e-02f, 6.55070618e-02f, -8.64045098e-02f,
  3.71600385e-03f, 4.18126322e-02f, -5.41466326e-02f, -2.24163327e-02f, -1.09955557e-02f, -4.12057415e-02f, 5.54184057e-02f, 3.12519469e-03f, 6.36618212e-02f, -4.21227999e-02f,
  -1.26548903e-02f, -4.61207256e-02f, -4.20817062e-02f, -3.11239287e-02f, -2.10820772e-02f, 6.49344623e-02f, -2.58029606e-02f, -4.06914242e-02f, -3.69238714e-03f, -3.22428532e-02f,
  -4.37790275e-01f, 5.61112389e-02f, -1.70816611e-02f, -3.18800837e-01f, 3.76308709e-02f, 1.23488866e-01f, 1.53809592e-01f, 1.75305177e-02f, -1.25589699e-01f, -9.90293268e-03f,
  -4.74858098e-02f, -1.36752293e-01f, 7.98485428e-03f, 8.55108723e-02f, 1.15937814e-01f, -9.05320421e-03f, 6.24425672e-02f, -5.92823252e-02f, -3.68949212e-02f, -7.98465088e-02f,
  -7.45709389e-02f, -1.30438671e-01f, -2.62515187e-01f, -4.27248962e-02f, -7.39497468e-02f, -1.66788623e-01f, -6.32754667e-03f, -1.03804052e-01f, -3.46752219e-02f, -6.67470992e-02f,
  9.14191976e-02f, 5.67597635e-02f, 8.22819471e-02f, -5.07887155e-02f, -7.14041442e-02f, -6.88935220e-02f, -2.01295931e-02f, 6.45525157e-02f, 5.44025935e-03f, -5.47493249e-02f,
  2.10651811e-02f, 4.24957536e-02f, -4.84967493e-02f, 4.20931876e-02f, -1.28679469e-01f, 1.64408679e-03f, -2.37873457e-02f, -3.58133279e-02f, 9.18022543e-02f, 1.37471691e-01f,
  5.31294607e-02f, 4.85251695e-02f, 4.43553515e-02f, -1.10934163e-02f, 9.79533866e-02f, -4.14566509e-03f, 6.36183396e-02f, -6.89339787e-02f, 5.95822781e-02f, -8.03473890e-02f,
  4.12341096e-02f, 6.54892400e-02f, 2.83757746e-02f, -1.19491788e-02f, -6.53002709e-02f, -2.64094993e-02f, 1.86534934e-02f, -8.39853063e-02f, 3.53534631e-02f, -9.80300754e-02f,
  -8.45567416e-03f, 6.30124509e-02f, -6.88046739e-02f, -1.08690513e-03f, -4.33189012e-02f, -2.25787833e-02f, -4.27641720e-02f, 7.03613013e-02f, 5.76317124e-02f, -5.63115552e-02f,
  -2.75542717e-02f, -6.62142560e-02f, -1.00122534e-01f, -2.42914185e-02f, 4.81109843e-02f, 6.67160302e-02f, 1.08667323e-02f, -4.62460369e-02f, 7.93948993e-02f, 5.96511411e-03f,
  -8.11130926e-02f, 9.63442177e-02f, 9.57190394e-02f, 7.04874173e-02f, -7.39694238e-02f, -4.09802161e-02f, 1.59948692e-02f, -1.42651591e-02f, -5.15202284e-02f, 7.68814981e-02f,
  5.31165600e-02f, -6.64881766e-02f, -9.72075537e-02f, -3.28887366e-02f, 4.32659835e-02f, -3.39356600e-03f, 8.95446353e-03f, -8.30222666e-02f, 1.35956079e-01f, 1.25456244e-01f,
  1.17786780e-01f, 4.01023924e-02f, 6.22119084e-02f, 4.62772548e-02f, -3.04158148e-03f, -2.71905586e-02f, 4.68965471e-02f, 5.21646999e-03f, 8.03929716e-02f, -1.45010334e-02f,
  -1.83211207e-01f, 1.60206050e-01f, -2.10632876e-01f, 1.16182648e-01f, 1.43866956e-01f, 5.66807538e-02f, 5.41721098e-02f, 2.65798252e-02f, 4.98018041e-02f, -1.09857097e-02f,
  -4.56113042e-03f, 1.10379539e-01f, 1.05595171e-01f, 1.37216464e-01f, 6.34236932e-02f, 1.93543926e-01f, 2.61743784e-01f, -6.53900877e-02f, -1.23929411e-01f, 7.77092278e-02f,
  5.29524162e-02f, 9.39544365e-02f, -2.02973947e-01f, -1.02555290e-01f, 9.55237001e-02f, -3.29222344e-02f, 5.65005764e-02f, 8.49098936e-02f, 1.78987123e-02f, 3.21474105e-01f,
  -7.53472745e-02f, -7.10820705e-02f, -7.35768750e-02f, -3.87621894e-02f, -6.73715249e-02f, -4.09354642e-02f, 2.99605411e-02f, 2.01900117e-03f, -4.70899567e-02f, -6.29530028e-02f,
  4.32115905e-02f, 5.36409393e-02f, 6.00347966e-02f, 5.82236424e-02f, 1.50096603e-02f, -5.76107875e-02f, 3.31682004e-02f, -8.34536552e-02f, -2.44390732e-03f, -2.35235523e-02f,
  1.85470194e-01f, -7.95132015e-03f, -3.98482978e-02f, -2.91693714e-02f, -9.16282386e-02f, -2.70321779e-03f, -1.27318263e-01f, -7.65615478e-02f, -3.81751917e-02f, -8.71825218e-02f,
  2.15197839e-02f, 7.59034827e-02f, -2.63324548e-02f, 8.59941915e-02f, -6.45442456e-02f, -2.61065178e-02f, -9.33854282e-03f, 8.99065435e-02f, 5.53376973e-02f, 2.33078394e-02f,
  -8.99428204e-02f, -7.83786550e-02f, -7.19201341e-02f, -8.00616443e-02f, -2.98272143e-03f, -1.50347902e-02f, 3.76587920e-02f, 2.72687920e-03f, -2.51891445e-02f, -8.40090122e-03f,
  -1.59673970e-02f, 4.27473849e-03f, 4.78629060e-02f, 7.55125210e-02f, -7.12125152e-02f, -7.23967031e-02f, -7.23474100e-02f, -1.39217526e-01f, 2.25857757e-02f, 6.35772124e-02f,
  -1.34388387e-01f, -1.41804725e-01f, 4.64243479e-02f, -1.09342057e-02f, -3.55558284e-02f, 9.19740926e-03f, 4.40960079e-02f, -2.69507375e-02f, 1.43126547e-02f, 3.66370007e-02f,
  -1.34582162e-01f, -6.17315173e-02f, 6.75436780e-02f, -8.88669416e-02f, -9.49605256e-02f, -7.49633461e-02f, -3.03114727e-02f, 5.99820241e-02f, 1.14329234e-02f, -1.33460045e-01f,
  -8.29498023e-02f, -5.84004298e-02f, -1.58294544e-01f, 2.32363259e-03f, -6.03103358e-03f, -3.77014540e-02f, -6.36598989e-02f, -1.50384605e-01f, -7.74182156e-02f, -2.12392718e-01f,
  1.09840952e-01f, 4.55152430e-02f, -2.89028714e-04f, 7.05689117e-02f, 5.44253998e-02f, 3.64459530e-02f, -5.53430691e-02f, 1.22703426e-01f, 9.62148327e-03f, 3.40397283e-02f,
  8.77031237e-02f, 7.40156695e-02f, -1.68785769e-02f, -1.28334370e-02f, -1.69785153e-02f, -5.59862964e-02f, 2.31756419e-02f, 3.14085111e-02f, 2.12500747e-02f, 6.75183088e-02f,
  6.36225492e-02f, 5.96288927e-02f, -4.27862257e-02f, 3.34246717e-02f, -4.53982782e-03f, 2.38356348e-02f, -5.81042282e-02f, 8.85422379e-02f, -4.66073751e-02f, -5.51377051e-02f,
  -3.10850497e-02f, 1.04092069e-01f, 5.27840927e-02f, -8.34006816e-02f, 3.00029553e-02f, 4.46720161e-02f, 3.48312669e-02f, -3.24842297e-02f, -7.15153199e-03f, 6.35210052e-02f,
  4.74520549e-02f, 6.88023865e-02f, -2.43276078e-02f, 8.63705054e-02f, -7.40206689e-02f, -6.80734292e-02f, -4.72784881e-03f, 1.06023908e-01f, -3.71788032e-02f, 2.96766963e-02f,
  -5.08488342e-03f, -2.05615424e-02f, 1.02785371e-01f, 9.32557657e-02f, 9.58869681e-02f, 7.41692632e-02f, 6.25609979e-02f, -7.19852522e-02f, 9.43672359e-02f, 8.63741711e-03f,
  7.29909837e-02f, 4.17718291e-02f, -4.70841117e-02f, -3.01993135e-02f, 6.05407842e-02f, 9.29324422e-03f, 7.37435892e-02f, 4.59781438e-02f, -7.67888278e-02f, -7.38724470e-02f,
  8.10475573e-02f, 1.06115438e-01f, -6.49284646e-02f, 6.73271120e-02f, 5.68985641e-02f, -5.99012561e-02f, 2.57011713e-03f, 2.71341205e-02f, 1.52129279e-02f, 1.03506483e-02f,
  -4.23978381e-02f, 3.54640819e-02f, -6.85313670e-03f, -7.51843501e-04f, 1.43743502e-02f, -9.33026802e-03f, -3.06313056e-02f, 1.68565151e-04f, -2.20151339e-02f, -7.69270137e-02f,
  6.14022948e-02f, 1.30940080e-02f, -4.76831831e-02f, 4.60420959e-02f, -1.03016973e-01f, -1.76556371e-02f, -7.84623343e-03f, -8.17673504e-02f, -3.70142534e-02f, -5.73966764e-02f,
  -2.32082028e-02f, 5.59476838e-02f, -2.81899646e-02f, -8.98760650e-03f, -4.84098829e-02f, 1.19366981e-02f, -9.11272019e-02f, 3.55052426e-02f, 3.44319940e-02f, -3.13700810e-02f,
  -5.53830620e-03f, 9.47686359e-02f, 2.27228831e-02f, 8.03297851e-03f, -1.40288370e-02f, 1.03678837e-01f, 5.20695001e-02f, 4.92574126e-02f, 1.04868405e-01f, -8.91720131e-02f,
  -8.80881101e-02f, 1.30621299e-01f, -1.09709008e-02f, 6.11232854e-02f, 1.09928332e-01f, 7.63970092e-02f, 1.39192536e-01f, 1.19134754e-01f, -6.07192377e-03f, -5.12182415e-02f,
  2.04764716e-02f, -6.73974827e-02f, 2.76984274e-02f, -9.65053290e-02f, 6.64575323e-02f, 7.81735927e-02f, -1.46369673e-02f, 9.94377881e-02f, -1.50418878e-02f, -6.90877344e-03f,
  -2.95640249e-02f, 2.33201543e-03f, 8.90671760e-02f, 1.55789107e-02f, 8.68020356e-02f, -1.09177515e-01f, -4.52077501e-02f, 5.25171794e-02f, 3.76339555e-02f, -4.63142917e-02f,
  -2.85078622e-02f, 1.21580288e-01f, -7.96355084e-02f, -1.07582301e-01f, 3.28252502e-02f, -2.26609781e-02f, -2.49909721e-02f, -5.07037453e-02f, 1.43568665e-02f, -8.73707682e-02f,
  6.70666397e-02f, 3.26696523e-02f, 6.76896945e-02f, -2.17469106e-03f, -3.31359170e-03f, 9.81477648e-02f, 7.48476163e-02f, 1.16368771e-01f, 5.02533317e-02f, -2.73253601e-02f,
  -1.93798281e-02f, -4.84620258e-02f, 8.98482278e-02f, 9.03381407e-02f, 2.36167498e-02f, 7.43247122e-02f, -7.94510990e-02f, -7.63147324e-02f, 3.75821851e-02f, -7.97759071e-02f,
  1.39299575e-02f, 9.13344696e-02f, 5.98736182e-02f, 7.35348240e-02f, 3.45815234e-02f, 6.16766736e-02f, -7.80991614e-02f, -4.90985624e-02f, 9.04189572e-02f, -4.05288562e-02f,
  -7.45678395e-02f, -2.42520720e-02f, 5.16653899e-03f, 2.82828864e-02f, -2.28766445e-02f, -2.01704130e-02f, 7.40922838e-02f, -4.59874943e-02f, -1.56012373e-02f, 3.70014943e-02f,
  1.34167876e-02f, -2.22446471e-02f, 6.23597540e-02f, -2.72048805e-02f, -2.08274629e-02f, 1.76969748e-02f, 7.54170120e-02f, 3.86663154e-02f, 9.79660004e-02f, -6.70688078e-02f,
  -8.06386173e-02f, -3.05961538e-02f, 3.19808684e-02f, -3.58683765e-02f, -2.77731306e-04f, 3.87625843e-02f, -7.78867677e-02f, 5.81123754e-02f, -7.88295176e-03f, -1.01917058e-01f,
  6.01489395e-02f, -9.05014127e-02f, 7.26180011e-03f, 3.54038626e-02f, 6.29991516e-02f, 7.13602901e-02f, 1.16565768e-02f, 3.04980669e-02f, -1.94983594e-02f, -6.26391768e-02f,
  -3.86043675e-02f, 5.82889728e-02f, 2.76908539e-02f, 1.17021753e-02f, 3.19711417e-02f, -1.21152159e-02f, 1.68440025e-02f, -7.40235746e-02f, -9.21082050e-02f, -2.19384674e-02f,
  -2.10476473e-01f, -2.76242256e-01f, -1.33504614e-01f, -8.57845917e-02f, -5.49851321e-02f, -1.36846423e-01f, -2.62225449e-01f, -5.93346469e-02f, 4.76330426e-03f, -1.07306592e-01f,
  -2.01115310e-02f, 9.39689353e-02f, 3.65395136e-02f, 3.15372869e-02f, -1.56070828e-01f, -3.02225232e-01f, -1.71037883e-01f, -1.19161397e-01f, 1.12437969e-02f, 3.34072672e-02f,
  -4.70725521e-02f, -5.84962666e-02f, -8.23971480e-02f, 2.03086082e-02f, -1.54077351e-01f, -1.28925562e-01f, -1.91855371e-01f, -1.25901207e-01f, -6.28558993e-02f, -2.15550110e-01f,
  -2.68235475e-01f, 1.22909278e-01f, 1.49853870e-01f, 9.93093662e-03f, -5.12763113e-03f, 1.07951954e-01f, -2.09724344e-02f, -1.89153031e-02f, 6.28955513e-02f, -1.07588116e-02f,
  -7.06746653e-02f, 1.06756784e-01f, -1.36533920e-02f, -2.16591638e-02f, 9.66794118e-02f, -4.04332802e-02f, -5.96484914e-02f, -1.12173073e-02f, -4.53981645e-02f, -2.76861079e-02f,
  -1.15892868e-02f, -3.38665061e-02f, 9.65505652e-03f, 5.12958085e-03f, -4.64181490e-02f, -1.41689954e-02f, -1.18213043e-01f, 3.45048010e-02f, -1.06743939e-01f, -2.15397984e-01f,
  -9.54815224e-02f, -9.57844183e-02f, 1.18889390e-02f, -1.07011303e-01f, -1.43486401e-03f, -8.15510079e-02f, -7.61675537e-02f, -9.72194299e-02f, 1.06529549e-01f, -6.18468113e-02f,
  8.36590398e-03f, 2.56016850e-02f, 3.67699750e-02f, -1.20853879e-01f, -1.02538921e-01f, -7.42026269e-02f, -5.05580232e-02f, -5.11967577e-02f, -1.07090883e-01f, -7.22441599e-02f,
  9.96405333e-02f, -4.72916178e-02f, -6.60105348e-02f, -2.44041886e-02f, -9.98539180e-02f, -8.37337691e-04f, 6.18202277e-02f, 3.44327465e-03f, 4.26519476e-02f, -1.87832378e-02f,
  -9.71180052e-02f, 9.03925076e-02f, -2.93667428e-02f, -1.56025391e-03f, 9.27450415e-03f, -4.27480564e-02f, 6.14947826e-02f, 3.53815109e-02f, 6.51777387e-02f, 5.69479316e-02f,
  5.20858774e-03f, -5.67739122e-02f, -6.07591532e-02f, 1.20960422e-01f, 5.25072850e-02f, 1.66956093e-02f, -1.01353787e-01f, -5.17095588e-02f, -1.32660139e-02f, -5.82778901e-02f,
  -1.91760901e-02f, -6.01576678e-02f, -7.28990361e-02f, -1.18293844e-01f, 7.58660436e-02f, -1.63654070e-02f, -1.18404133e-02f, -1.06428586e-01f, -1.42172232e-01f, -2.73991793e-01f,
  -2.71708280e-01f, 3.93384285e-02f, 1.33672535e-01f, -5.39053902e-02f, -1.17626160e-01f, 5.50451912e-02f, 1.28505109e-02f, -3.53960842e-02f, -2.82817464e-02f, 4.42596246e-03f,
  -1.00478463e-01f, -1.06281094e-01f, -6.45697415e-02f, 6.46420047e-02f, 4.14349250e-02f, 6.04139939e-02f, 2.65441872e-02f, 5.81115596e-02f, -4.42493632e-02f, 5.72780520e-02f,
  -5.77390864e-02f, -4.51644994e-02f, -2.21582390e-02f, 5.55194402e-03f, 9.12798718e-02f, 9.58959237e-02f, -4.48707566e-02f, 4.45058048e-02f, 6.24332251e-03f, -4.37949114e-02f,
  1.89439937e-01f, -6.17056079e-02f, -4.14478146e-02f, -3.34601328e-02f, 8.77367854e-02f, -6.77677393e-02f, 1.88969485e-02f, 1.00099975e-02f, -1.01866268e-01f, 6.49655312e-02f,
  4.72943932e-02f, -5.16284257e-02f, -5.38355857e-02f, 4.97982614e-02f, -2.47023744e-03f, 4.64539751e-02f, -3.12078483e-02f, -4.07796167e-02f, 9.76779684e-02f, 1.32335246e-01f,
  -8.72550383e-02f, -5.60497195e-02f, 3.91582586e-02f, 7.20365644e-02f, 1.52085656e-02f, -5.84667400e-02f, 7.00977594e-02f, -4.01982740e-02f, 1.37463156e-02f, 5.18534593e-02f,
  -1.05934329e-01f, 5.83881512e-02f, 4.29784022e-02f, -6.90808296e-02f, 2.93828398e-02f, 9.84300021e-03f, 4.05904874e-02f, -3.47126164e-02f, 6.44986611e-03f, -4.53180037e-02f,
  -1.32439774e-03f, -1.50340814e-02f, -3.24457996e-02f, -6.76854625e-02f, 2.60065286e-03f, 2.46502254e-02f, -4.19517159e-02f, -2.03168038e-02f, 4.14110906e-02f, 1.96338315e-02f,
  2.19661351e-02f, 3.11875604e-02f, 3.34123746e-02f, -8.68384540e-03f, 4.56320010e-02f, 1.07414052e-02f, -4.14083004e-02f, -4.49663997e-02f, -3.11473086e-02f, 4.56618220e-02f,
  1.26168549e-01f, -3.65328826e-02f, 2.78587602e-02f, -2.27600336e-02f, -3.77833024e-02f, -1.93175022e-02f, -8.91283453e-02f, 1.03345355e-02f, 6.60701543e-02f, 1.09904639e-01f,
  -9.75170918e-03f, -7.66533464e-02f, 4.72767167e-02f, 9.12803710e-02f, -9.54736676e-03f, 8.50865319e-02f, 1.35642821e-02f, -2.43887100e-02f, 1.30334020e-01f, 7.55170658e-02f,
  5.65903261e-02f, -3.19478065e-02f, 1.08034434e-02f, 1.23754531e-01f, 8.68385136e-02f, 1.52909697e-03f, 1.77585762e-02f, 1.31511614e-01f, 6.24385662e-02f, 1.22323327e-01f,
  -1.00186400e-01f, 1.03602476e-01f, 2.25993991e-02f, 1.99274160e-02f, 4.49345000e-02f, -1.32147714e-01f, -1.27571657e-01f, 3.56237330e-02f, -3.31361629e-02f, -7.90232606e-03f,
  -1.07146911e-01f, -7.99649134e-02f, 1.36836460e-02f, -2.48092394e-02f, 1.07547529e-02f, 1.81260388e-02f, 8.86791423e-02f, 3.82451713e-02f, -4.31272089e-02f, -5.00634536e-02f,
  4.42683175e-02f, 5.58712594e-02f, -5.68839237e-02f, 5.71837313e-02f, 9.98692680e-03f, 4.58182916e-02f, 7.67637230e-03f, 5.30017093e-02f, 1.02603428e-01f, 1.42892525e-01f,
  1.95685532e-02f, -3.80393043e-02f, 7.01808676e-05f, -5.67052364e-02f, 3.46300788e-02f, -6.03463575e-02f, -7.44358823e-02f, 4.12789844e-02f, 2.91350707e-02f, 1.00029968e-01f,
  2.71695834e-02f, -3.36388238e-02f, 4.79886718e-02f, 8.69061500e-02f, 9.45025980e-02f, -4.66015525e-02f, -3.91689688e-02f, 4.78903316e-02f, -2.18805410e-02f, 7.62468874e-02f,
  -3.99658084e-02f, 3.66575196e-02f, 6.25877976e-02f, 5.99288940e-02f, -5.66004775e-03f, -9.12630484e-02f, 3.84961292e-02f, -4.90368307e-02f, 6.19144402e-02f, 1.84638500e-02f,
  -1.07158266e-01f, 1.82575863e-02f, -1.69884770e-05f, 7.95837864e-02f, -5.64725250e-02f, -2.85360180e-02f, 1.87032633e-02f, 7.62344748e-02f, -8.25181007e-02f, -3.48517373e-02f,
  5.07149883e-02f, 9.77163315e-02f, 1.75122693e-02f, 5.83182983e-02f, -8.14088136e-02f, -9.68404207e-03f, -7.44442595e-03f, 7.97784328e-02f, -6.08677752e-02f, 7.51869529e-02f,
  6.78852350e-02f, -6.77246554e-03f, 6.45776913e-02f, 8.40353668e-02f, -4.19262244e-04f, -1.99388433e-02f, 2.63239630e-02f, 2.58197580e-02f, 3.51130702e-02f, 3.24870385e-02f,
  2.06425302e-02f, -1.12172447e-01f, 1.05335504e-01f, 9.63743106e-02f, 1.68701001e-02f, 3.86247970e-02f, 7.30434507e-02f, 3.46076563e-02f, 8.02142993e-02f, -3.31348367e-02f,
  -2.36509759e-02f, 9.46025848e-02f, 5.17225713e-02f, 8.15834850e-03f, 2.69537047e-02f, -5.29196188e-02f, -4.73843440e-02f, -1.70982070e-02f, -7.33139664e-02f, 2.76774690e-02f,
  6.87242672e-02f, 3.98877226e-02f, -8.99022371e-02f, -8.22339207e-02f, 8.08977187e-02f, -6.93789497e-02f, -3.18468325e-02f, -8.49116221e-02f, -9.91263166e-02f, -9.78801101e-02f,
  -5.58135547e-02f, -1.84122957e-02f, 9.22284573e-02f, 9.18427296e-03f, 2.17288136e-01f, 1.15144379e-01f, 1.83129221e-01f, 9.36363414e-02f, 2.38087568e-02f, 4.44644615e-02f,
  -2.98718009e-02f, -2.54289787e-02f, -5.67727722e-02f, 9.86468866e-02f, 2.13403367e-02f, 6.98434114e-02f, 1.99448600e-01f, 1.51247844e-01f, 6.37136698e-02f, 5.36709614e-02f,
  1.80943962e-02f, -5.19881956e-02f, 6.36868039e-03f, 4.17817645e-02f, -1.30654527e-02f, -2.28570495e-02f, -4.82414216e-02f, 1.16675526e-01f, 8.43873993e-02f, -2.42798869e-02f,
  -8.39277264e-03f, -5.64138554e-02f, -2.58968957e-03f, -5.30191064e-02f, -2.01862901e-02f, -1.07913621e-01f, 7.94716831e-03f, -9.99232456e-02f, 2.50609759e-02f, 1.81284710e-03f,
  -4.60373797e-02f, -7.09919333e-02f, 4.17423854e-03f, 6.32023998e-03f, 1.88678689e-02f, -2.45761517e-02f, -3.91832218e-02f, -5.42466529e-03f, 4.32813577e-02f, -1.01881489e-01f,
  6.50366768e-02f, 8.35923594e-04f, -5.42227067e-02f, 6.01294041e-02f, -6.91497177e-02f, -4.66387235e-02f, 6.39935434e-02f, -7.43273422e-02f, -8.92338250e-03f, -4.83528562e-02f,
  -1.64170787e-02f, 7.73753002e-02f, 8.68964642e-02f, 3.28137130e-02f, 7.77473152e-02f, -6.63340762e-02f, 1.73580628e-02f, -4.01711464e-02f, 3.59793119e-02f, -5.84333092e-02f,
  -5.14695793e-02f, -6.30390793e-02f, -2.29422264e-02f, 4.93215322e-02f, -3.53183337e-02f, 1.04883008e-01f, 1.51426150e-02f, 1.10996896e-02f, 9.28099528e-02f, 8.08802322e-02f,
  3.41590196e-02f, -4.17286381e-02f, -1.80201381e-02f, 4.30152193e-02f, 6.66201720e-03f, 7.59247839e-02f, -5.09828515e-02f, -3.48804146e-02f, -2.08850317e-02f, -1.03284242e-02f,
  -7.49644712e-02f, 3.22146006e-02f, -3.27872187e-02f, -2.82440539e-02f, 5.13209850e-02f, -6.66542202e-02f, -6.84499666e-02f, -1.88955013e-02f, -1.09807551e-01f, -2.70293886e-03f,
  -4.53284942e-02f, -2.33050585e-02f, -8.66782367e-02f, -9.99987870e-02f, -2.61720177e-02f, -6.52242899e-02f, 2.11927365e-03f, 8.29919502e-02f, -2.24378128e-02f, 4.62514348e-02f,
  4.30813879e-02f, 7.88167343e-02f, 5.92783391e-02f, 6.00752123e-02f, -9.63142738e-02f, 5.64997606e-02f, -8.58888403e-02f, 5.93009666e-02f, -1.07929975e-01f, -1.13634489e-01f,
  -8.63513798e-02f, 1.02668211e-01f, 1.21217892e-01f, 1.37256188e-02f, 3.40146162e-02f, 1.59715135e-02f, 5.27506359e-02f, 1.22603765e-02f, -1.32388249e-01f, -3.97420209e-03f,
  -3.24284732e-02f, -1.73639938e-01f, -2.38933302e-02f, -1.27949178e-01f, -6.56088218e-02f, -2.59670615e-02f, 6.46705106e-02f, -5.88109307e-02f, -1.41683936e-01f, 1.30007211e-02f,
  3.77692766e-02f, -8.19858443e-03f, 1.07719684e-02f, -5.97381294e-02f, 5.16647287e-02f, 2.83731949e-02f, 4.46276320e-03f, -7.11741969e-02f, 5.36278486e-02f, -2.05009431e-02f,
  1.20708250e-01f, 1.40178399e-02f, -5.98209128e-02f, -9.34465677e-02f, 3.72315897e-03f, 4.27679718e-02f, -9.98956859e-02f, -9.78136286e-02f, -3.44547369e-02f, -6.62339255e-02f,
  -1.18239194e-01f, 3.04692145e-02f, -4.74492647e-02f, -8.00357759e-02f, -5.24768680e-02f, -7.48813674e-02f, 6.09393306e-02f, 5.76557405e-02f, 1.10651813e-02f, 7.37280622e-02f,
  -8.52561668e-02f, 8.55735168e-02f, -2.85217762e-02f, 1.09926492e-01f, 1.19861275e-01f, -4.61756159e-03f, 1.26143381e-01f, 8.88492763e-02f, 8.49923417e-02f, 1.11534037e-01f,
  -3.69454883e-02f, 1.33121032e-02f, -1.21277841e-02f, 2.15597395e-02f, -4.68550958e-02f, 4.43967432e-02f, -9.19403508e-03f, -8.81608939e-05f, 8.03781748e-02f, 8.34533200e-03f,
  9.27014872e-02f, 1.37494117e-01f, 5.10727614e-03f, 2.69466341e-02f, -4.11091819e-02f, 5.01369871e-02f, 2.67115422e-02f, 1.61208876e-03f, -9.72848386e-03f, -8.34082216e-02f,
  5.22002392e-02f, 7.21620992e-02f, 6.13736138e-02f, -1.14060314e-02f, 2.81255096e-02f, 5.15735932e-02f, 7.86004663e-02f, 4.18001004e-02f, 6.61119744e-02f, -4.00742330e-02f,
  1.20822266e-01f, 5.73218800e-03f, -6.36163503e-02f, 7.36983167e-03f, -1.04984958e-02f, 8.63784105e-02f, -3.74001935e-02f, 2.14846507e-02f, -2.80105341e-02f, 4.85916287e-02f,
  -6.53870702e-02f, -2.31983420e-02f, 6.07957281e-02f, -4.84928451e-02f, -3.21556479e-02f, 3.75755578e-02f, -4.56102304e-02f, -4.69699549e-03f, 3.42242233e-02f, 9.61395130e-02f,
  -9.50960792e-04f, 1.08934008e-01f, 5.16070612e-02f, -2.39730533e-02f, 6.02448434e-02f, -2.91304048e-02f, 1.40606975e-02f, 6.71401247e-02f, 1.17096521e-01f, 1.62523519e-02f,
  -2.65388489e-01f, -2.70005651e-02f, 3.62150446e-02f, -9.84783396e-02f, -7.69031607e-03f, 6.42372891e-02f, 1.10813633e-01f, 6.16707914e-02f, 2.19655689e-04f, 2.45017279e-02f,
  5.13458066e-02f, -6.74367091e-03f, -3.59933563e-02f, -5.36070503e-02f, -5.82324974e-02f, 1.17945179e-01f, 2.31624581e-02f, -2.46849656e-02f, -2.85741966e-02f, -1.23320604e-02f,
  -5.95152378e-02f, -1.17064632e-01f, -2.10524276e-01f, -8.83346349e-02f, -1.10207595e-01f, -2.30634920e-02f, 5.44735976e-02f, -5.30033223e-02f, 1.16304727e-03f, -9.45806503e-02f,
  4.76617925e-02f, -7.13469684e-02f, -2.01832186e-02f, 5.49129136e-02f, 7.75092617e-02f, 4.35075490e-03f, -6.75786287e-02f, -4.08159792e-02f, -7.29707479e-02f, -5.04602604e-02f,
  -9.32220072e-02f, 2.60163359e-02f, -3.67036834e-02f, -5.80545738e-02f, 3.35873716e-04f, 3.59485522e-02f, 5.28480522e-02f, 6.17554709e-02f, 1.12668816e-02f, 8.58098455e-03f,
  1.08091436e-01f, -3.33115384e-02f, -3.98220122e-02f, 1.13053113e-01f, 1.28486663e-01f, 4.85397381e-04f, -2.44507883e-02f, 6.59735291e-04f, 4.27773371e-02f, 5.86058237e-02f,
  5.97236082e-02f, -6.75506294e-02f, -1.55478055e-02f, 2.34927926e-02f, -3.58756036e-02f, -2.72198208e-02f, -9.54463333e-02f, -7.69595578e-02f, -1.35646798e-02f, 1.49425628e-04f,
  -2.88419109e-02f, -7.57858679e-02f, 5.31315207e-02f, -5.33433482e-02f, -2.01866701e-02f, -3.33072469e-02f, -7.94078112e-02f, 7.04460219e-02f, -1.95658039e-02f, 7.14630634e-02f,
  -3.51037271e-02f, -3.80901881e-02f, -5.12235239e-02f, -4.32373257e-03f, -2.05083583e-02f, -5.52038066e-02f, -4.55920734e-02f, -6.94908304e-05f, -5.43332174e-02f, -7.52343312e-02f,
  4.42255102e-03f, -4.90653478e-02f, -4.84540574e-02f, 9.39059779e-02f, -5.72264902e-02f, 6.52863979e-02f, 2.85572056e-02f, -4.81100976e-02f, -1.21547654e-02f, -3.05296890e-02f,
  1.00568160e-01f, -7.52787143e-02f, 6.35005757e-02f, 2.11246442e-02f, 8.42990577e-02f, 8.75701606e-02f, 1.15273446e-01f, -8.63224790e-02f, 3.40228155e-02f, 1.36370316e-01f,
  -3.34834121e-02f, 4.07386050e-02f, -1.58084929e-02f, 1.30515531e-01f, 8.26798454e-02f, -3.98732983e-02f, -6.71494519e-03f, -8.05272982e-02f, -1.56190619e-02f, -2.55299080e-02f,
  8.70670080e-02f, 1.07888736e-01f, -2.48023532e-02f, 1.69145659e-01f, 9.00504738e-02f, 1.34951212e-02f, -1.29336104e-01f, -2.13011894e-02f, 1.17028300e-02f, -1.71783715e-02f,
  -1.02731800e-02f, 4.93988320e-02f, 1.38806552e-01f, -5.06121516e-02f, -4.90762740e-02f, -4.18151356e-02f, 2.07702499e-02f, -4.87388298e-02f, 5.08570224e-02f, 1.01892367e-01f,
  1.22510672e-01f, 1.51677325e-01f, 1.09382406e-01f, 4.73857336e-02f, 4.59921360e-02f, 8.90921801e-02f, 3.36109735e-02f, 1.30403578e-01f, -1.83544252e-02f, 2.07248628e-01f,
  1.34522781e-01f, -5.16859852e-02f, 2.57372539e-02f, 1.04470201e-01f, -6.61119297e-02f, 5.90630714e-03f, 5.75694889e-02f, -8.41462687e-02f, -3.64092775e-02f, -4.87495810e-02f,
  -8.39502737e-03f, 5.70588298e-02f, -1.13365641e-02f, 1.60024539e-02f, 2.72055548e-02f, -9.53648984e-02f, -7.44743273e-02f, -6.41397536e-02f, -5.99846356e-02f, -1.16860373e-02f,
  1.06121160e-01f, 3.20110843e-02f, 1.82107612e-02f, -2.84966007e-02f, -1.08799420e-01f, 2.64356309e-03f, 4.20181110e-04f, -4.73844707e-02f, -6.79292306e-02f, 5.18224910e-02f,
  6.51893541e-02f, 5.41957356e-02f, -7.51606971e-02f, 7.91971907e-02f, 5.36194518e-02f, -4.82957512e-02f, 1.68255735e-02f, -6.41246885e-02f, -6.50733933e-02f, -7.85651207e-02f,
  2.32465342e-02f, -1.49009656e-02f, -1.53791215e-02f, -2.92732138e-02f, -2.02246811e-02f, 2.27507148e-02f, 3.90379392e-02f, 3.13047208e-02f, 5.14977090e-02f, -1.43503500e-02f,
  -5.23577519e-02f, -4.08627205e-02f, -5.15430942e-02f, -6.57460690e-02f, 6.77765906e-02f, -4.63820733e-02f, 1.05411150e-01f, 2.19234005e-02f, 4.38526347e-02f, -1.06974551e-02f,
  7.04057738e-02f, -1.06307073e-02f, -1.86201259e-02f, 3.79037745e-02f, 1.71703193e-02f, -4.25064489e-02f, -5.95741607e-02f, -5.03692888e-02f, 8.31339415e-03f, -1.05475541e-02f,
  -2.17312947e-02f, 2.11839937e-02f, -6.68143630e-02f, 4.92249988e-02f, -7.66464025e-02f, -2.46277936e-02f, 4.19896655e-02f, -8.16394836e-02f, 1.83915272e-02f, -1.02417529e-01f,
  3.68526578e-02f, 2.60777511e-02f, -2.73735393e-02f, -1.34232908e-01f, 4.15544026e-02f, 4.74646650e-02f, 3.50442231e-02f, -1.01481639e-01f, -1.55634463e-01f, -9.47005078e-02f,
  -1.24603108e-01f, -6.24908730e-02f, -3.46116394e-01f, -1.35770231e-01f, -1.04846731e-01f, -1.29730240e-01f, -4.06659022e-02f, 4.60385494e-02f, 6.35614097e-02f, 3.64367515e-02f,
  4.65882309e-02f, 9.25314985e-03f, -3.25908512e-02f, -1.15758725e-01f, -4.08473276e-02f, -2.46627003e-01f, -3.47986281e-01f, -2.42874026e-01f, -1.97125897e-01f, 9.62556992e-03f,
  -1.54315948e-01f, -2.10919604e-01f, -2.05991283e-01f, -7.75023773e-02f, -8.68759751e-02f, -9.94274318e-02f, -1.51741043e-01f, -2.03013018e-01f, -1.32446468e-01f, -1.66139334e-01f,
  -8.14883336e-02f, -9.77314189e-02f, -2.22301427e-02f, 2.75371280e-02f, -5.04270382e-02f, 1.86353661e-02f, -9.02134478e-02f, -4.25542444e-02f, 7.84916803e-02f, 2.64991000e-02f,
  2.93663908e-02f, 5.96101694e-02f, -8.95312950e-02f, 6.15548752e-02f, -6.52805492e-02f, -3.19957770e-02f, 5.50965406e-02f, -6.04344085e-02f, -3.32979448e-02f, -1.28659951e-02f,
  -6.87749684e-02f, -1.13688126e-01f, -3.52192223e-02f, -5.44388108e-02f, 2.16644704e-02f, -1.67524703e-02f, -9.26837698e-03f, 5.36370352e-02f, -2.10151933e-02f, -2.71129031e-02f,
  9.97205526e-02f, -3.09670977e-02f, 3.17228138e-02f, 1.03552025e-02f, 3.30703259e-02f, 3.21475752e-02f, -4.91400026e-02f, 7.24772085e-03f, 9.54897783e-04f, 2.87265182e-02f,
  2.07543839e-02f, -4.55659255e-02f, 8.31561834e-02f, -3.37777957e-02f, -7.11028948e-02f, -2.85233930e-02f, -1.34234950e-02f, -7.48823434e-02f, 4.36788723e-02f, -3.10623832e-02f,
  -1.89149454e-02f, 8.17660093e-02f, 2.52478756e-02f, -2.86152512e-02f, 3.96281406e-02f, 6.13273913e-03f, 3.19101140e-02f, 1.50560141e-01f, 1.50391921e-01f, 1.16147183e-01f,
  1.58718482e-01f, -6.97501376e-02f, 3.39721404e-02f, -6.13995641e-02f, -1.26446456e-01f, 3.52420914e-03f, -7.10639358e-02f, -4.54435199e-02f, -2.59780190e-05f, -2.83533204e-02f,
  6.41489550e-02f, -3.46023738e-02f, -9.28944424e-02f, 2.51469817e-02f, -6.93717897e-02f, 8.52018073e-02f, 3.67146432e-02f, -7.09473640e-02f, -1.01586521e-01f, 1.44597992e-01f,
  7.30960742e-02f, 2.32776310e-02f, 2.00103559e-02f, 1.01846725e-01f, 2.45498717e-02f, 1.34495134e-02f, -7.51913190e-02f, 6.55370280e-02f, -8.74115974e-02f, 3.25192474e-02f,
  6.61891922e-02f, 1.85111556e-02f, -1.24164321e-01f, 8.30416381e-02f, 9.32417577e-04f, -3.66061879e-03f, -3.72116007e-02f, 6.65654019e-02f, -7.70669663e-03f, 7.06157833e-02f,
  7.46136485e-03f, -4.34791995e-03f, -5.64163812e-02f, -4.33523627e-03f, -8.97008926e-02f, -1.58409089e-01f, -1.29473478e-01f, -9.35708210e-02f, -8.51001740e-02f, -1.38324713e-02f,
  -2.55349390e-02f, -6.59620762e-02f, 2.65382826e-02f, 7.83508942e-02f, 4.34579048e-03f, 8.26806277e-02f, -2.31837686e-02f, 6.86108693e-02f, -6.25860840e-02f, -1.09647423e-01f,
  -4.82608117e-02f, 7.04505742e-02f, 7.20818043e-02f, 3.07415407e-02f, 1.03248939e-01f, 7.80152604e-02f, 3.68411429e-02f, -4.96806093e-02f, 6.28725216e-02f, 8.63185301e-02f,
  8.66315290e-02f, 3.33712399e-02f, 4.87309918e-02f, 8.94227102e-02f, 4.67021891e-04f, 1.32172137e-01f, 1.17426440e-01f, 4.44351742e-03f, 7.98278116e-03f, 5.48271202e-02f,
  -8.35767351e-05f, 7.11212456e-02f, -3.84747982e-02f, 5.25621101e-02f, 1.03332043e-01f, -3.69415954e-02f, 8.47816747e-03f, 2.95801852e-02f, 5.78161106e-02f, 6.01361804e-02f,
  -3.73651944e-02f, -6.33167922e-02f, -1.07624186e-02f, -2.05557197e-02f, 3.37422378e-02f, 6.81044012e-02f, 8.21088441e-03f, -5.29933497e-02f, -1.22778397e-02f, -3.13423425e-02f,
  -5.99659458e-02f, 5.09378426e-02f, -3.51233855e-02f, -8.91974717e-02f, -5.94107085e-04f, 6.45564720e-02f, 1.33742709e-02f, 1.60595644e-02f, 1.08401991e-01f, 8.56240615e-02f,
  1.87490939e-03f, 7.44346995e-03f, 3.26566957e-02f, -5.40920906e-02f, 3.73910554e-02f, 4.37972210e-02f, 4.18663807e-02f, 7.10398406e-02f, -5.28182797e-02f, 6.26348332e-02f,
  7.31825270e-03f, 8.58911052e-02f, -9.77352858e-02f, 6.58196360e-02f, 9.72859561e-02f, -5.68005145e-02f, 5.45005910e-02f, -5.70228621e-02f, -3.63906622e-02f, 2.12701634e-02f,
  1.14332378e-01f, 2.63117105e-02f, -8.18923563e-02f, -1.30651938e-02f, -7.80417398e-02f, 5.26686162e-02f, -4.84202988e-02f, 2.17467546e-02f, 9.24962480e-03f, -6.37213811e-02f,
  -9.31423716e-03f, -2.32448732e-03f, -5.03773950e-02f, 3.80209610e-02f, -2.85378024e-02f, -3.64787802e-02f, 3.78761888e-02f, 4.74233925e-02f, 5.24387136e-02f, -1.31440610e-01f,
  8.35146829e-02f, -9.06803757e-02f, -1.16860956e-01f, 2.72077501e-01f, 8.54785889e-02f, 4.33855727e-02f, -8.78506750e-02f, 5.16619394e-03f, 1.98992386e-01f, 1.07894979e-01f,
  1.11360624e-01f, 1.60783544e-01f, 1.03390932e-01f, 1.09111980e-01f, 1.20705470e-01f, 2.93783024e-02f, 1.37543669e-02f, -2.09830096e-03f, 6.49229810e-03f, 4.12731618e-02f,
  9.58528146e-02f, 1.54845983e-01f, 7.35287443e-02f, 6.01908416e-02f, 4.42493968e-02f, 3.93669009e-02f, -4.75834534e-02f, 6.44524992e-02f, 8.16192329e-02f, 1.22203641e-01f,
  2.91660544e-03f, -8.25901479e-02f, 5.05104065e-02f, 5.17680012e-02f, 6.18961528e-02f, -3.69485579e-02f, 5.31482883e-02f, -8.57436806e-02f, 2.76337434e-02f, -6.31210655e-02f,
  -5.24122231e-02f, 5.59964888e-02f, -2.07753256e-02f, 1.36000719e-02f, -1.61374416e-02f, 3.95587385e-02f, -5.01514040e-02f, 1.54482238e-02f, -1.01715185e-01f, 2.61579156e-02f,
  4.39547524e-02f, 8.04870054e-02f, -1.36123657e-01f, -5.88665791e-02f, -6.42469600e-02f, -4.47796396e-04f, -4.38839979e-02f, -1.02982223e-01f, -7.26307407e-02f, -8.71973783e-02f,
  4.67996076e-02f, 1.12214364e-01f, 3.39524075e-02f, -1.71017926e-02f, -1.00505743e-02f, 3.34562138e-02f, -5.64252064e-02f, -3.98310274e-02f, 4.12138812e-02f, 7.62732048e-03f,
  6.91033602e-02f, -5.71042858e-02f, 9.63538140e-02f, 1.15687691e-01f, -4.88099381e-02f, -5.81267141e-02f, -3.26658972e-02f, 8.07659584e-04f, -5.01671135e-02f, -4.61211316e-02f,
  -2.83543617e-02f, 2.53513865e-02f, -2.96380185e-02f, 6.41758740e-02f, -1.25323199e-02f, 1.94944581e-03f, 8.98332894e-02f, -2.67785918e-02f, 5.64972237e-02f, -7.08306730e-02f,
  1.70731992e-01f, 8.71273428e-02f, 1.01045460e-01f, 5.47152162e-02f, 1.19914860e-02f, 3.55031155e-03f, 3.85321453e-02f, -7.51900375e-02f, -1.29155740e-01f, -1.32470708e-02f,
  -9.56130773e-02f, -3.15657705e-02f, 8.86699855e-02f, -6.02609403e-02f, -6.88189194e-02f, 3.50031517e-02f, -7.44396150e-02f, 6.04790077e-02f, 5.84462062e-02f, 2.47494616e-02f,
  8.51577520e-03f, -4.84291725e-02f, -7.78598040e-02f, -3.84249724e-02f, -1.03764907e-02f, 8.12090710e-02f, -1.16667733e-01f, -7.92204663e-02f, -3.46987024e-02f, -1.09502003e-01f,
  -7.71991862e-03f, -2.05061540e-01f, -2.11853497e-02f, -1.36501849e-01f, -9.64085907e-02f, 9.18440968e-02f, -5.32005876e-02f, -4.94734868e-02f, -4.74831276e-02f, 5.42032644e-02f,
  -3.18536609e-02f, 7.85154626e-02f, -3.64605486e-02f, 5.92463836e-02f, 2.60966942e-02f, 4.31385823e-02f, -1.07460380e-01f, 6.07886054e-02f, 2.12443441e-01f, 8.67234468e-02f,
  -8.15780982e-02f, -8.42406601e-03f, -4.89358511e-03f, 1.02680782e-02f, 1.75282825e-02f, 1.06245808e-01f, -9.08733439e-03f, -1.66656330e-01f, 5.73591627e-02f, -1.36967957e-01f,
  9.78553444e-02f, -1.45963803e-01f, -1.67953055e-02f, 5.01438137e-03f, 2.02274397e-02f, -3.40016335e-02f, -3.59848165e-03f, 9.80876153e-04f, 4.41980809e-02f, -6.65480793e-02f,
  -7.82732219e-02f, 4.39248979e-02f, -9.49638858e-02f, -4.28908616e-02f, 4.68044095e-02f, -9.98367891e-02f, -2.55654939e-02f, -1.10649668e-01f, -2.06068829e-02f, -9.53504518e-02f,
  -2.20988449e-02f, -6.44196048e-02f, 2.54279394e-02f, 4.52255718e-02f, 4.48794179e-02f, 7.09698945e-02f, -8.32643956e-02f, -9.64524448e-02f, 1.28126349e-02f, 1.68411005e-02f,
  -2.31155176e-02f, -9.49382260e-02f, 6.41510338e-02f, 9.23602059e-02f, 4.89654131e-02f, 3.44991460e-02f, 1.42163634e-01f, 5.19148856e-02f, 7.98008069e-02f, -3.69347781e-02f,
  5.17053641e-02f, 3.61415520e-02f, 3.72490752e-03f, -3.87624875e-02f, -1.12413391e-01f, -1.59063846e-01f, 2.53382865e-02f, -7.83119723e-02f, -1.29972138e-02f, -1.14187233e-01f,
  1.31923137e-02f, -1.34462878e-01f, -9.49879885e-02f, -1.58359073e-02f, -1.11025654e-01f, 4.52509485e-02f, -4.22798172e-02f, 4.92760427e-02f, 1.30000524e-02f, -7.05320314e-02f,
  2.07848236e-01f, -5.61571792e-02f, 6.99025095e-02f, 2.08099168e-02f, -7.93034118e-03f, -2.74322703e-02f, 5.08530922e-02f, 5.00893127e-03f, -2.24354267e-02f, 6.27885908e-02f,
  -6.31956523e-03f, 1.05623998e-01f, -5.60036078e-02f, 2.97037046e-02f, 9.48673189e-02f, 8.21328834e-02f, -8.00350681e-02f, 8.69542137e-02f, -1.06363952e-01f, -1.13372780e-01f,
  1.69590805e-02f, 1.59180120e-01f, 2.24876314e-01f, 2.00541139e-01f, 2.34832149e-02f, 2.20602617e-01f, 2.33642906e-01f, 1.30541384e-01f, 1.97129309e-01f, 1.99190438e-01f,
  1.56012431e-01f, 2.05064058e-01f, 2.12145999e-01f, 1.86158150e-01f, 1.06663778e-01f, 2.46607855e-01f, 1.86505333e-01f, 1.20002456e-01f, -1.49949454e-02f, 1.16462402e-01f,
  1.92759708e-02f, -1.57156121e-02f, 2.13166885e-02f, 2.38042586e-02f, 4.22763377e-02f, 1.91758230e-01f, 1.40061915e-01f, 2.12551951e-02f, 2.84809452e-02f, -2.02623084e-02f,
  -6.02685399e-02f, 5.76918311e-02f, 8.02690834e-02f, 5.14007658e-02f, 1.16297267e-02f, 4.39466834e-02f, 5.84623292e-02f, -1.16020516e-02f, 1.20795136e-02f, -8.51626173e-02f,
  -1.21577077e-01f, 2.22694486e-01f, -7.42878839e-02f, -3.79896536e-02f, -3.04037379e-03f, -1.44336492e-01f, 1.32551724e-02f, -1.59158140e-01f, 3.94693911e-02f, -5.64953610e-02f,
  -1.86261162e-02f, -5.30628785e-02f, 5.47497384e-02f, 2.97617284e-03f, -9.68727618e-02f, -6.75792620e-02f, -8.48909393e-02f, 7.64622763e-02f, 3.24602388e-02f, 3.27702686e-02f,
  -4.58793342e-02f, 4.50151647e-03f, 2.67063361e-02f, 1.14435099e-01f, 5.38802296e-02f, -7.20651671e-02f, -1.41238282e-02f, 8.10090676e-02f, 2.16069911e-02f, -1.43724913e-02f,
  -7.14993179e-02f, 2.09730715e-02f, -1.97077096e-02f, 5.75905405e-02f, -2.31174268e-02f, -1.09172769e-01f, -6.12989627e-02f, -2.60225069e-02f, -9.58406087e-03f, -7.48527721e-02f,
  4.97891419e-02f, -5.89661859e-03f, 2.29395386e-02f, 8.28497577e-03f, -9.41962972e-02f, 1.24869915e-02f, -4.34868485e-02f, 7.15104192e-02f, -6.01562597e-02f, -1.09497510e-01f,
  -8.21747258e-02f, -7.82644898e-02f, -4.40881066e-02f, -2.96698860e-03f, 1.08653018e-02f, 4.51073460e-02f, -1.37245506e-02f, 1.90089103e-02f, -2.37015146e-03f, -8.82295072e-02f,
  -3.06734800e-01f, 3.72912139e-02f, -1.57995820e-01f, -3.31101641e-02f, -9.66289416e-02f, -3.29667702e-02f, 2.81733237e-02f, 5.11440709e-02f, 1.27351396e-02f, -3.70123573e-02f,
  8.24260488e-02f, -2.70826165e-02f, -5.09697460e-02f, -5.61720245e-02f, 6.27867579e-02f, -5.92608526e-02f, -6.97340965e-02f, 4.63650413e-02f, -7.05431998e-02f, -1.02549024e-01f,
  -1.20505011e-02f, -7.53456280e-02f, -1.55086279e-01f, -2.13357229e-02f, 1.30029246e-02f, -1.71403617e-01f, -3.69716547e-02f, -1.36108801e-01f, -2.49226186e-02f, -2.23245144e-01f,
  -1.70930568e-02f, 1.29570886e-01f, -1.66926533e-01f, 6.67064823e-03f, 2.80758683e-02f, -1.61539018e-01f, -4.77944948e-02f, 2.79783625e-02f, 1.04268946e-01f, 1.02007598e-01f,
  -6.86552301e-02f, 1.26423940e-01f, -2.15662103e-02f, 5.07580116e-02f, -6.33572116e-02f, 2.89069563e-02f, 1.04939550e-01f, 8.70406777e-02f, -1.92680076e-01f, -1.08223088e-01f,
  1.93132475e-01f, 8.15190524e-02f, -6.93242401e-02f, -6.85529877e-03f, 8.13506395e-02f, 9.94005948e-02f, 4.68995795e-02f, 2.14597164e-03f, 6.68521449e-02f, 3.12942177e-01f,
  -7.16862604e-02f, -1.10825323e-01f, -4.11721990e-02f, 5.62126078e-02f, 1.92829203e-02f, -3.60618979e-02f, -1.26527511e-02f, -1.05329730e-01f, -2.77251806e-02f, 6.25270838e-03f,
  4.84321602e-02f, 1.74350329e-02f, 2.61951424e-02f, 8.54995660e-03f, -7.76898861e-02f, -3.27292867e-02f, 2.67550908e-02f, -5.14280535e-02f, -6.02868758e-02f, -3.72705571e-02f,
  7.80859217e-02f, 3.86139937e-02f, -1.29144996e-01f, -9.42158177e-02f, -5.16988859e-02f, -2.20467485e-02f, -2.54476853e-02f, -2.88098715e-02f, -5.37881590e-02f, 6.93992451e-02f,
  -2.25322209e-02f, -1.08292311e-01f, 5.08525372e-02f, -7.38821477e-02f, 5.58615699e-02f, 5.45995384e-02f, 7.86204077e-03f, -2.43719630e-02f, -1.90385878e-02f, -1.47831254e-02f,
  -5.28907776e-02f, -1.04466401e-01f, -6.01358898e-02f, 3.39820050e-02f, 1.92036312e-02f, -1.61279235e-02f, -2.42660176e-02f, -7.36462511e-03f, -4.28722054e-02f, -5.50994165e-02f,
  1.65920164e-02f, -1.05782077e-01f, -2.66054254e-02f, 2.81873834e-03f, 4.97198440e-02f, 4.85024415e-02f, -4.50618379e-03f, -5.47091663e-02f, -1.19833492e-01f, -4.79971841e-02f,
  -1.55655993e-02f, -1.80761263e-01f, 1.43727258e-01f, 1.43392891e-01f, -3.28563862e-02f, -7.54714338e-03f, 3.46057452e-02f, -7.44313672e-02f, 3.81151585e-05f, 6.50853217e-02f,
  -6.07743375e-02f, -5.03190123e-02f, -5.54253459e-02f, 5.80578335e-02f, 3.01457401e-02f, 1.69794774e-03f, 1.36460997e-02f, 4.28650193e-02f, 1.12290783e-02f, 7.18323439e-02f,
  1.20042451e-01f, -2.59428751e-02f, 2.04177778e-02f, -5.29030450e-02f, 1.49432151e-02f, 7.27273747e-02f, -7.05136657e-02f, -1.71125941e-02f, -3.99249718e-02f, -5.90228140e-02f,
  -1.27042187e-02f, 2.68548839e-02f, -9.48640332e-03f, -1.72314364e-02f, -2.32616775e-02f, -6.49014190e-02f, 1.28019694e-02f, -2.23712698e-02f, 4.32276428e-02f, 4.74610068e-02f,
  5.29746637e-02f, -7.61590004e-02f, 1.68789888e-03f, -5.00093885e-02f, -7.65048759e-03f, 4.99418266e-02f, 5.26730567e-02f, 1.45667810e-02f, 6.14173710e-03f, 9.45531204e-02f,
  4.78639174e-03f, 7.96559006e-02f, -2.58165170e-02f, 4.67569716e-02f, 5.52235842e-02f, -1.95593163e-02f, 1.65915675e-02f, 1.69241391e-02f, 1.78343784e-02f, 5.01892753e-02f,
  2.02135574e-02f, 1.26556858e-01f, -7.05282092e-02f, -1.28905699e-02f, -4.16165702e-02f, 4.23121415e-02f, 8.41258988e-02f, 3.32854688e-02f, -6.48721233e-02f, -4.13376372e-03f,
  -1.94967892e-02f, 1.36897769e-02f, -5.36266342e-02f, 2.10502166e-02f, 1.25146598e-01f, 2.64720973e-02f, 6.63340911e-02f, 6.83960225e-03f, -5.24752811e-02f, 3.57960016e-02f,
  -6.08400702e-02f, 3.57923321e-02f, 9.85693261e-02f, -8.54010805e-02f, 8.61596987e-02f, 5.21533266e-02f, -2.74038725e-02f, 6.19487651e-02f, -5.94813470e-03f, 7.33555034e-02f,
  -3.64913046e-02f, -8.68544430e-02f, -1.36894395e-03f, 3.81683111e-02f, -3.69917788e-02f, 8.04413036e-02f, 4.90053073e-02f, -7.32053965e-02f, -9.76803228e-02f, 5.14261760e-02f,
  -4.93542245e-03f, -5.71393818e-02f, -3.75225767e-02f, -2.63395216e-02f, -2.38758270e-02f, 7.91542754e-02f, 6.67066425e-02f, 5.05668707e-02f, 1.00006983e-02f, -1.93873271e-02f,
  4.29134332e-02f, 3.67977582e-02f, -4.98648845e-02f, 5.79673797e-02f, -4.53770980e-02f, 2.17872169e-02f, -7.96194747e-02f, -8.02667141e-02f, 1.64234266e-02f, -3.50698642e-02f,
  -9.14593562e-02f, 3.90590951e-02f, 6.87842965e-02f, -1.26034543e-02f, -6.52313754e-02f, 5.35420626e-02f, -7.80500844e-02f, 7.42003694e-02f, -4.24575508e-02f, 6.77758977e-02f,
  -3.30480002e-02f, 5.67660630e-02f, 5.93000688e-02f, 1.60259195e-02f, 8.87520760e-02f, 8.61055106e-02f, 9.01923608e-03f, -1.80077888e-02f, 1.31964888e-02f, 8.18197653e-02f,
  -7.21867532e-02f, -5.68715520e-02f, -6.38460368e-02f, -7.88410008e-03f, -8.37202817e-02f, -3.52059789e-02f, -6.61267936e-02f, 2.07144171e-02f, -6.50350284e-03f, -1.49244408e-03f,
  2.20941920e-02f, 1.93360716e-01f, 1.36474997e-01f, -5.03892228e-02f, 3.22601087e-02f, -4.27062958e-02f, 2.37554405e-03f, -1.23137444e-01f, 1.82998702e-02f, 4.22588214e-02f,
  8.46823081e-02f, -1.17307371e-02f, 2.93473750e-02f, -1.08310044e-01f, -1.13346413e-01f, -1.75795425e-02f, 6.42755907e-03f, -8.27644765e-02f, -7.67714307e-02f, -6.25873916e-03f,
  -8.33757445e-02f, 9.10561010e-02f, 1.22481979e-01f, 2.47945487e-02f, -1.99617781e-02f, -3.79461213e-03f, -2.06458624e-02f, -4.47827652e-02f, 6.90989792e-02f, 1.01197802e-01f,
  8.10170174e-02f, 1.86877638e-01f, -8.25377926e-02f, -1.54330619e-02f, 6.45718351e-02f, 9.51405521e-03f, -7.66461790e-02f, 7.25567946e-03f, 9.06176679e-03f, -5.79742864e-02f,
  5.83928153e-02f, -5.30605055e-02f, 7.09355772e-02f, -9.53163058e-02f, 2.75190398e-02f, -1.89095102e-02f, 2.16056574e-02f, 6.86191544e-02f, -1.14238001e-01f, 7.94089586e-02f,
  -6.82918951e-02f, 1.03074268e-01f, 2.27571689e-02f, -3.45641412e-02f, 6.47014454e-02f, -5.17855324e-02f, 5.09439334e-02f, 3.60138975e-02f, 6.73417225e-02f, 3.94007042e-02f,
  5.03905639e-02f, -4.31934819e-02f, 3.76347229e-02f, 7.05242679e-02f, -1.52661093e-02f, -6.74406020e-03f, -5.96310534e-02f, -8.21946859e-02f, -1.95618030e-02f, -1.42942742e-02f,
  -7.94510916e-03f, -6.43654689e-02f, -9.96510908e-02f, 3.18118073e-02f, -4.77022631e-03f, -3.93886194e-02f, -1.86282862e-02f, -6.78616762e-02f, -7.24583194e-02f, -4.65175211e-02f,
  -2.68909037e-02f, -4.75782232e-04f, 9.70533025e-03f, -8.35930114e-04f, 6.97787330e-02f, -4.46902262e-03f, 6.90118596e-02f, -4.30663452e-02f, 8.57112184e-02f, -4.98982742e-02f,
  -6.09673187e-02f, -8.67369398e-02f, -5.96774817e-02f, -5.38547076e-02f, 7.19483495e-02f, -5.10053262e-02f, -1.03971446e-02f, 9.18084756e-02f, -6.67745247e-02f, -3.49673368e-02f,
  3.98029983e-02f, 3.50085758e-02f, -7.59905502e-02f, -3.47416364e-02f, 2.08395836e-03f, -3.89892608e-02f, 2.69312430e-02f, -5.40851355e-02f, 1.92806404e-02f, 6.75677657e-02f,
  -8.50759521e-02f, 3.46315540e-02f, -1.33946478e-01f, -1.42081663e-01f, 3.55516858e-02f, -9.45224315e-02f, -6.25099465e-02f, -7.65314177e-02f, -1.05542906e-01f, -9.21489671e-02f,
  5.24155945e-02f, 5.97915836e-02f, 1.50730923e-01f, 8.94372910e-02f, 1.12296706e-02f, 3.18033830e-03f, 5.29114492e-02f, 1.29999325e-01f, 7.40141934e-03f, 7.69985840e-02f,
  -7.45235458e-02f, 4.37127650e-02f, 1.14067189e-01f, -4.67022024e-02f, 1.48784220e-01f, 1.46990016e-01f, 1.97504573e-02f, 1.43332109e-01f, 1.44445866e-01f, -2.04994269e-02f,
  -3.76128708e-03f, 6.26526922e-02f, 1.36762649e-01f, -2.19885074e-02f, 1.35680884e-01f, 1.14804149e-01f, -4.07080352e-02f, -3.55992429e-02f, -3.99008766e-02f, -4.88961628e-03f,
  4.48402902e-03f, 1.10010579e-01f, 3.08038965e-02f, 7.32530281e-02f, -8.89387801e-02f, 7.62334745e-03f, -6.78842235e-03f, 4.06835554e-03f, -1.95276644e-02f, -6.46250024e-02f,
  -7.70058334e-02f, 4.21463586e-02f, 1.22290859e-02f, -9.46609750e-02f, 1.81542337e-02f, -9.51584280e-02f, 3.09406202e-02f, -3.54647301e-02f, 8.21107626e-02f, 7.73103684e-02f,
  -8.29478949e-02f, -1.11200020e-01f, -8.36135969e-02f, -5.34399673e-02f, 4.46131490e-02f, 3.75487506e-02f, -9.15515199e-02f, 7.86474049e-02f, 5.94021827e-02f, -5.32031395e-02f,
  2.23136824e-02f, -6.34529069e-03f, 2.10441537e-02f, -6.05768524e-02f, -2.51768567e-02f, 5.31243086e-02f, 2.85026953e-02f, -5.02492003e-02f, -2.60292017e-03f, -1.46565884e-02f,
  -7.34675154e-02f, -1.01097208e-02f, 2.98121516e-02f, -1.19934902e-02f, 7.32524320e-03f, 3.04433797e-02f, -4.02081795e-02f, -6.72642440e-02f, 5.31676076e-02f, -9.42808168e-04f,
  -3.03912628e-02f, 5.26075922e-02f, -6.28687143e-02f, 3.48226205e-02f, -5.43435588e-02f, -3.62434983e-02f, 4.90812957e-02f, -7.66080841e-02f, 4.38006036e-02f, 2.93672662e-02f,
  -1.32856980e-01f, -5.32154888e-02f, -1.95716992e-02f, 2.49269009e-02f, -5.01663573e-02f, -5.99377677e-02f, -3.47637571e-02f, 8.83079600e-03f, 1.83344968e-02f, 9.41947754e-03f,
  -6.37670532e-02f, 2.24909782e-02f, -7.11158067e-02f, 4.31942120e-02f, -5.03775924e-02f, -2.68811323e-02f, -1.71423201e-02f, 8.81090388e-02f, 5.16461171e-02f, -6.10754779e-03f,
  2.96571720e-02f, -1.11566380e-01f, 3.91372517e-02f, 4.47354689e-02f, 6.17990308e-02f, -3.99098545e-02f, -6.78745471e-03f, -1.02582611e-01f, -9.26308855e-02f, 6.05632644e-03f,
  1.10681042e-01f, -3.57428156e-02f, -2.50881344e-01f, 1.61023512e-01f, -6.33581802e-02f, -1.14654928e-01f, -1.75523326e-01f, -9.05814767e-02f, 1.12843350e-01f, 2.36270037e-02f,
  7.99963549e-02f, 4.48097736e-02f, -5.67821227e-02f, -1.04104765e-01f, -6.07285500e-02f, -2.58268356e-01f, -2.45024949e-01f, -1.32161677e-01f, -5.75104430e-02f, -7.66469836e-02f,
  -2.11798660e-02f, -3.54240499e-02f, -7.56544545e-02f, 7.13833782e-04f, 4.01785299e-02f, -5.26512340e-02f, -1.45223707e-01f, -8.29171613e-02f, -1.74517095e-01f, -3.93415131e-02f,
  -9.36933011e-02f, -8.81917551e-02f, -1.00700848e-01f, -8.34906772e-02f, 4.48792018e-02f, 7.64613524e-02f, -9.14689004e-02f, -8.37463439e-02f, -9.32937637e-02f, -2.36177444e-02f,
  -7.62853920e-02f, -3.99903618e-02f, -5.42041054e-03f, 6.40902519e-02f, -5.55116497e-02f, -9.78054181e-02f, -4.45490852e-02f, -5.02601452e-02f, -1.15944348e-01f, 6.39123609e-03f,
  9.82154906e-03f, -2.36877743e-02f, -1.10052988e-01f, -5.19882888e-02f, 3.46214511e-02f, -1.00024953e-01f, -6.62931353e-02f, -1.06448762e-03f, -1.31201237e-01f, 1.01875849e-01f,
  1.16348104e-03f, -1.50300879e-02f, -5.03194220e-02f, 2.17081066e-02f, 8.28609765e-02f, 2.91411951e-02f, 5.26660644e-02f, -4.90377583e-02f, 1.00864537e-01f, 2.59096548e-02f,
  9.61717516e-02f, 5.52474335e-02f, -3.77709940e-02f, 6.28869981e-02f, 6.80178404e-02f, 3.75937968e-02f, -8.70226920e-02f, 4.75579649e-02f, -1.78666115e-02f, -2.09168661e-02f,
  7.85099193e-02f, -2.27921028e-02f, -4.11835909e-02f, 5.17645888e-02f, 4.14142162e-02f, -1.12713138e-02f, -6.79987222e-02f, 4.43946980e-02f, -9.07322019e-02f, 3.68339829e-02f,
  1.40042916e-01f, -1.20112166e-01f, -4.03396413e-02f, -1.06783293e-01f, -1.03005975e-01f, 2.36585215e-02f, 1.44907326e-01f, -8.46142694e-02f, 6.84204996e-02f, -8.01479444e-02f,
  -5.85007221e-02f, -3.81694213e-02f, 4.37531136e-02f, -9.13793296e-02f, -2.04378646e-02f, -8.63349736e-02f, 1.16094230e-02f, -6.93968236e-02f, -5.81295900e-02f, 2.70734690e-02f,
  -1.03300940e-02f, -4.11589723e-03f, 4.71045915e-03f, -3.20096500e-02f, 6.01654947e-02f, -7.96525180e-02f, -2.25778203e-02f, 3.95582616e-02f, -1.68337911e-01f, 9.71642956e-02f,
  1.00709036e-01f, -1.53620496e-01f, -5.48905283e-02f, -2.80447630e-03f, -1.19300649e-01f, -1.91553801e-01f, -2.36061037e-01f, -1.07216292e-04f, 8.35552737e-02f, -1.77926883e-01f,
  -1.00880407e-01f, 5.79711199e-02f, 6.05855808e-02f, -3.32164764e-02f, 1.10381134e-01f, -1.81400105e-01f, -1.52660489e-01f, -8.15007742e-03f, 1.68821648e-01f, 5.63383549e-02f,
  5.08944429e-02f, -9.91438888e-03f, 6.69412538e-02f, 5.31872362e-02f, -8.58606175e-02f, 1.05928957e-01f, 3.78625207e-02f, -1.46350925e-04f, 4.26457785e-02f, -1.11817710e-01f,
  -6.32392764e-02f, -5.06201386e-02f, 9.08180028e-02f, 8.50230306e-02f, -1.28314227e-01f, -6.04197159e-02f, 1.91461332e-02f, 3.33065055e-02f, 7.76245221e-02f, -4.13122401e-02f,
  -4.52390127e-02f, 1.83632746e-02f, 1.82868596e-02f, 8.47088918e-03f, -7.20324740e-02f, -6.41360879e-02f, -5.70045970e-02f, 1.09189432e-02f, -3.77016664e-02f, 3.92883783e-03f,
  2.52005667e-03f, -1.15878984e-01f, 4.66713198e-02f, 4.25909311e-02f, -3.13624851e-02f, 1.62481423e-02f, -8.13912973e-03f, 4.67555635e-02f, -6.12191483e-02f, -1.18933685e-01f,
  -1.19687701e-02f, 9.95706022e-02f, 3.58458459e-02f, -5.60225323e-02f, -6.23682328e-02f, -3.11771389e-02f, 3.14003043e-02f, 6.76047802e-02f, -1.06816925e-02f, 5.27164340e-02f,
  -3.77805755e-02f, -5.54802157e-02f, 1.80391204e-02f, 1.65235922e-02f, 5.28780706e-02f, -1.13630025e-02f, 4.70077619e-02f, 4.26043719e-02f, 3.49699408e-02f, -4.89073955e-02f,
  -1.57630742e-02f, 2.04773396e-02f, 6.24143817e-02f, 4.03730087e-02f, 6.28649220e-02f, 3.25431265e-02f, -1.66373998e-02f, -5.32236621e-02f, 4.63733822e-02f, -2.63375370e-03f,
  1.11784898e-02f, 1.00075997e-01f, -1.42682800e-02f, 7.27975965e-02f, 4.39759940e-02f, 4.59898226e-02f, -4.99051660e-02f, 5.46853691e-02f, -1.09477350e-02f, 3.53939570e-02f,
  3.38565968e-02f, 6.42832220e-02f, -4.65877913e-02f, -4.49007973e-02f, 8.98246840e-02f, -4.28100415e-02f, -4.01449651e-02f, -2.47622151e-02f, 4.30052280e-02f, 9.60786194e-02f,
  4.87036221e-02f, -7.58763105e-02f, -1.66633353e-02f, -7.79644412e-04f, 4.36955206e-02f, -4.96696644e-02f, -2.16774959e-02f, 4.45263982e-02f, 6.27652928e-03f, -1.72277287e-01f,
  -3.54545526e-02f, 5.57730272e-02f, 2.54251603e-02f, -1.53154861e-02f, 1.55749395e-02f, 3.30228172e-02f, -3.04618068e-02f, 1.68902948e-02f, -9.33768973e-03f, 1.42676625e-02f,
  -9.24094580e-03f, -2.13970453e-03f, 1.73602737e-02f, -7.60374516e-02f, -1.04795463e-01f, -6.68890700e-02f, 2.42003519e-02f, -5.71129248e-02f, -1.00755461e-01f, -6.38923869e-02f,
  -3.49169970e-02f, 1.92478430e-02f, 2.39748787e-02f, -1.17185302e-01f, -6.07210025e-02f, -1.01131760e-01f, -1.12794332e-01f, -8.64350870e-02f, 2.05525123e-02f, 5.42059951e-02f,
  -4.08608951e-02f, 2.12541176e-03f, 4.13860679e-02f, 5.46921901e-02f, -3.57601866e-02f, -1.50002902e-02f, 8.58948305e-02f, -5.12466067e-03f, -3.64312381e-02f, 7.03933388e-02f,
  9.14974809e-02f, -4.71091121e-02f, 6.47858977e-02f, 9.79642868e-02f, -6.29444495e-02f, 8.19519162e-02f, 1.52925942e-02f, 6.10898845e-02f, -1.58148725e-02f, 6.76594451e-02f,
  2.69198138e-02f, -6.56864047e-02f, -2.83688977e-02f, 7.24689662e-02f, 1.04590189e-02f, 1.48150866e-04f, -3.89127620e-02f, -2.16393103e-03f, -8.43866840e-02f, 8.00990406e-03f,
  -6.96709566e-03f, -5.99579997e-02f, 4.15016599e-02f, 2.08928641e-02f, 3.64552625e-02f, 7.79795349e-02f, 3.21723446e-02f, -2.12146882e-02f, -1.92286037e-02f, -1.33552700e-02f,
  7.05497786e-02f, 3.94829474e-02f, -2.13087592e-02f, -3.69661599e-02f, 2.59090401e-02f, 4.32790257e-02f, -7.55074173e-02f, -9.65060890e-02f, -8.84267911e-02f, -1.67351421e-02f,
  5.50964326e-02f, -2.46253554e-02f, -5.73467836e-02f, 9.42168408e-04f, -9.80809554e-02f, -4.77697467e-03f, -7.30657205e-02f, -7.15487227e-02f, -3.22413519e-02f, -1.09904245e-01f,
  -1.37068942e-01f, -8.57547373e-02f, -3.58702578e-02f, -9.09920782e-02f, -6.40124306e-02f, -2.28341296e-02f, 5.60142845e-03f, 3.83150503e-02f, 3.39415558e-02f, -4.20995019e-02f,
  1.99376885e-02f, -1.77152641e-02f, -8.32039416e-02f, -3.02481465e-02f, 5.59847662e-03f, 9.01969671e-02f, -1.15340771e-02f, -8.42825770e-02f, 5.01236096e-02f, 4.35957918e-04f,
  6.29182160e-02f, 4.67298515e-02f, 1.11897737e-01f, 1.14309542e-01f, 6.08533658e-02f, 2.26700716e-02f, -6.82406202e-02f, -3.54385786e-02f, -4.85705398e-02f, 1.59733798e-02f,
  3.50427218e-02f, 5.88230602e-02f, -3.03381048e-02f, -3.54507065e-04f, -7.29135573e-02f, -1.06430329e-01f, -1.01685651e-01f, 5.49347810e-02f, -4.54077683e-02f, 2.75039226e-02f,
  9.91965309e-02f, -4.08205502e-02f, 6.05218783e-02f, -4.34215330e-02f, -3.32487077e-02f, -3.22342664e-02f, -6.84159547e-02f, 9.55293477e-02f, 9.75229144e-02f, 8.46915413e-04f,
  2.57757120e-02f, 1.12876095e-01f, 7.96145201e-02f, 4.12665121e-02f, 4.61742170e-02f, 8.40143561e-02f, -3.95612940e-02f, 8.28428864e-02f, -5.41383401e-02f, 1.25606759e-02f,
  6.01193570e-02f, -1.48163214e-02f, 5.14748693e-02f, -4.37536044e-03f, 1.12859681e-02f, 6.51163096e-03f, 9.76968035e-02f, 3.12733725e-02f, 4.18272391e-02f, 4.48000319e-02f,
  -3.88235669e-03f, -2.09873654e-02f, 6.88466430e-02f, 3.38918380e-02f, 4.11926322e-02f, 3.05730989e-03f, 7.48453736e-02f, 6.02617711e-02f, -3.84417437e-02f, -5.31302467e-02f,
  7.89929479e-02f, -6.25268593e-02f, 8.88402946e-03f, -1.89847108e-02f, -5.98342419e-02f, -5.52405007e-02f, 2.42255460e-02f, 8.30295123e-03f, 4.11186814e-02f, -2.70264242e-02f,
  -8.54293704e-02f, 5.32489121e-02f, -5.02846017e-02f, 4.65537868e-02f, -1.34059349e-02f, -7.23376200e-02f, -9.22179520e-02f, -9.63183492e-02f, 1.97384767e-02f, -1.73973071e-03f,
  -1.83100719e-02f, -1.13667287e-01f, -6.37084618e-02f, 3.99180204e-02f, 1.62850730e-02f, -6.60291836e-02f, 1.37127199e-05f, -4.52351607e-02f, -5.09509929e-02f, 2.90705841e-02f,
  -5.01404703e-02f, -7.28695989e-02f, -1.89302098e-02f, -7.58116543e-02f, -7.92097300e-02f, -9.40530896e-02f, -6.55128956e-02f, 4.56746668e-02f, -4.71639335e-02f, 3.49405073e-02f,
  9.69939530e-02f, 4.70045321e-02f, 9.81476977e-02f, 2.03041472e-02f, 6.43492267e-02f, 4.40866910e-02f, -5.95554449e-02f, 6.39924826e-03f, 1.19904866e-02f, 7.02149495e-02f,
  2.03796234e-02f, 9.55451429e-02f, -2.10741237e-02f, 9.10643861e-02f, 3.57498005e-02f, -4.68151867e-02f, 5.63117340e-02f, 9.10366029e-02f, 9.13332701e-02f, -1.06205465e-02f,
  8.73709247e-02f, -4.37674299e-02f, -6.73587024e-02f, -7.31656924e-02f, 8.30403566e-02f, 1.82660017e-02f, 6.51159184e-03f, 3.63548063e-02f, 1.19059281e-02f, 8.37599337e-02f,
  1.68498069e-01f, 6.03224151e-02f, 7.09119141e-02f, 8.26010033e-02f, 9.88000482e-02f, 1.45930439e-01f, 2.00231057e-02f, -1.99238863e-02f, 9.03873369e-02f, 3.26148258e-03f,
  7.46524632e-02f, 1.44525036e-01f, 1.02738895e-01f, -3.08459532e-02f, -1.18607758e-02f, -6.62442297e-02f, 2.87497230e-02f, -3.68974172e-02f, 2.19793073e-04f, 9.08932388e-02f,
  4.56953831e-02f, -2.63553765e-02f, -1.74953677e-02f, -6.67290464e-02f, -7.69747496e-02f, 1.80659276e-02f, -3.31972428e-02f, -2.22195964e-02f, 9.64853466e-02f, 5.00296429e-02f,
  -1.41871506e-02f, 1.18912697e-01f, 6.56258315e-02f, -3.27730854e-03f, -5.70738018e-02f, 1.28938379e-02f, 5.15156016e-02f, -7.91116655e-02f, -3.92293371e-02f, 2.73070857e-02f,
  7.99238384e-02f, 6.25421628e-02f, -8.38679634e-03f, -4.13153619e-02f, 2.41065621e-02f, 6.83883503e-02f, -6.35996237e-02f, -1.89831816e-02f, 6.18807077e-02f, -6.37599602e-02f,
  5.54145761e-02f, 2.50129160e-02f, 6.58955574e-02f, -2.08662711e-02f, 3.02775111e-02f, 6.79960176e-02f, -1.26333386e-02f, 7.07643628e-02f, -3.54790129e-03f, -8.81966278e-02f,
  2.31199563e-02f, 1.38821891e-02f, 5.40561192e-02f, 7.98931047e-02f, -3.70714478e-02f, 3.39479335e-02f, -3.04682124e-02f, 1.62410513e-02f, -3.14522646e-02f, -1.01879135e-01f,
  3.22555937e-02f, 1.21746389e-02f, -7.00106397e-02f, 4.77637723e-02f, 7.77337775e-02f, 5.09165041e-02f, -4.92599793e-02f, 1.65703081e-04f, 8.80323052e-02f, -2.93812919e-02f,
  -5.63698485e-02f, 8.35311636e-02f, -5.10630235e-02f, -7.85279423e-02f, 1.24663683e-02f, -6.28671497e-02f, 7.05863237e-02f, -2.39940174e-02f, 6.61942586e-02f, 8.30799341e-02f,
  3.02446205e-02f, 1.13972038e-01f, 4.70129550e-02f, 7.38749653e-02f, 4.53272201e-02f, 6.35595620e-02f, 1.10978447e-01f, -6.77441806e-02f, 5.99719994e-02f, 8.53090361e-02f,
  8.11266899e-02f, 1.05563007e-01f, 7.96673596e-02f, -2.51157535e-03f, 5.06485477e-02f, 6.21286295e-02f, -6.83413371e-02f, -7.61646703e-02f, -3.46793719e-02f, 7.18876570e-02f,
  6.12193197e-02f, -6.21052869e-02f, 3.94629501e-02f, 1.03886560e-01f, 3.62061523e-02f, 1.51836529e-01f, 8.17101598e-02f, -4.56614606e-02f, 2.40259897e-02f, -4.82378267e-02f,
  3.86999816e-01f, -1.92311466e-01f, 2.58096755e-01f, 1.36203155e-01f, 3.68401349e-01f, 4.59290981e-01f, 3.44172835e-01f, 1.91223130e-01f, 5.59406132e-02f, -1.12487348e-02f,
  1.18572593e-01f, -2.06042543e-01f, -2.47612283e-01f, -2.58984119e-01f, 4.88348156e-02f, 7.78705329e-02f, -6.32609352e-02f, -4.60405555e-03f, 1.23384409e-01f, 5.79354465e-02f,
  -1.30661383e-01f, 5.65761477e-02f, -2.96348389e-02f, -1.05914786e-01f, -1.63729548e-01f, -1.20763198e-01f, 6.10989481e-02f, 1.12448104e-01f, -5.72463758e-02f, -3.09671342e-01f,
  -1.58912893e-02f, 1.50227338e-01f, -8.45897272e-02f, -9.25002247e-02f, 1.06816711e-02f, 9.88478772e-04f, -1.21355597e-02f, -5.83344623e-02f, -8.10415111e-03f, -2.88072811e-03f,
  2.31197216e-02f, -6.88782558e-02f, 3.30036208e-02f, -1.21255174e-01f, 3.98266762e-02f, 4.38614078e-02f, -5.81990518e-02f, -4.90209647e-02f, 6.84001148e-02f, -6.87601715e-02f,
  -1.11836463e-01f, 1.00459188e-01f, 1.43002167e-01f, 1.09733753e-01f, 1.02420568e-01f, -6.96720257e-02f, 4.88901176e-02f, -6.11009588e-03f, 4.94204229e-03f, -5.24222068e-02f,
  -3.45660909e-03f, 2.94691627e-03f, 2.32266225e-02f, -4.56379801e-02f, -2.21419986e-02f, -2.12493315e-02f, 2.14487053e-02f, -3.06524406e-03f, 4.07213606e-02f, 1.34177329e-02f,
  2.75770128e-02f, 1.49440551e-02f, 4.16886508e-02f, -4.14146967e-02f, 3.21938135e-02f, 2.79452000e-02f, 3.31071280e-02f, -8.32405537e-02f, -8.09613392e-02f, -1.97050143e-02f,
  -3.72494422e-02f, 1.13159560e-01f, 5.43403998e-02f, -8.59446973e-02f, 9.62130204e-02f, -6.63783550e-02f, 7.48417899e-02f, -8.79454762e-02f, -9.63270739e-02f, 4.14247438e-03f,
  -2.58810431e-01f, 1.45642221e-01f, -6.92066737e-03f, -1.30289793e-01f, 7.31425807e-02f, -1.28714517e-01f, -4.04197201e-02f, -2.46512387e-02f, 6.66766763e-02f, 7.82464966e-02f,
  1.30955912e-02f, -6.91655576e-02f, 3.50371636e-02f, 6.69828728e-02f, 1.80466827e-02f, 6.52933195e-02f, 1.33286119e-02f, 3.56903374e-02f, -3.68339606e-02f, 4.22912166e-02f,
  -9.96979326e-02f, 3.69227901e-02f, 2.60837618e-02f, 7.96819385e-03f, -4.22300547e-02f, 9.20306295e-02f, 1.59845930e-02f, 9.12066326e-02f, 1.32526994e-01f, 1.30517390e-02f,
  1.06207110e-01f, 1.80719700e-02f, -1.80275049e-02f, 1.20597087e-01f, -3.91976424e-02f, -1.78775966e-01f, -5.79257160e-02f, -7.26364106e-02f, 9.09976885e-02f, -3.90191898e-02f,
  -1.61402803e-02f, 1.16186045e-01f, 3.22783925e-02f, 2.27125622e-02f, -3.77683640e-02f, 1.25860535e-02f, 1.41754411e-02f, -9.86274555e-02f, -1.29038513e-01f, -1.03140004e-01f,
  -5.32402061e-02f, 1.80698521e-02f, -7.72814732e-03f, -1.15122953e-02f, 5.58927981e-03f, 9.30554271e-02f, -3.73503566e-02f, 2.77039055e-02f, -7.64260814e-02f, 1.10721178e-01f,
  -4.59027439e-02f, 3.35103981e-02f, 5.74788079e-03f, 4.96878438e-02f, 3.61640565e-02f, -3.62646505e-02f, 8.81388783e-02f, -3.57101075e-02f, 9.08378139e-02f, 9.95257571e-02f,
  -4.72355224e-02f, 1.00463815e-01f, -7.23649040e-02f, -2.30195560e-02f, -2.90922169e-02f, 5.12812622e-02f, -7.11939037e-02f, 4.98300306e-02f, 5.51209487e-02f, 6.52396232e-02f,
  7.38311140e-03f, -1.84017094e-03f, 9.25241504e-03f, 6.12750947e-02f, -2.81203594e-02f, -4.38364521e-02f, -2.12162640e-02f, -6.92504495e-02f, 3.33173461e-02f, 1.64135709e-01f,
  -1.10721134e-01f, -2.51300912e-02f, -5.62472008e-02f, -4.99132164e-02f, 2.38583107e-02f, 2.21163146e-02f, -9.20331404e-02f, -8.61693695e-02f, -1.07523568e-01f, -1.02136739e-01f,
  7.26165622e-02f, -9.24528111e-03f, -7.53709069e-03f, -3.46984752e-02f, 1.77573860e-02f, 5.24275750e-02f, -6.69233948e-02f, 3.92736495e-02f, -3.06355301e-02f, -1.87238883e-02f,
  3.19227688e-02f, -5.01994155e-02f, -5.07351048e-02f, -2.75668055e-02f, 4.47635241e-02f, 3.47771309e-02f, -1.96586382e-02f, 2.51677018e-02f, -1.36739062e-02f, 4.53097792e-03f,
  1.50430664e-01f, -1.47340238e-01f, 1.12024300e-01f, 2.61778347e-02f, -9.12474841e-02f, 1.08110849e-02f, -4.73415367e-02f, -4.51789945e-02f, 7.09379017e-02f, 8.50949809e-02f,
  4.28895466e-02f, -5.32721356e-02f, 3.56037659e-03f, -3.23658958e-02f, 2.93262303e-02f, -1.82785094e-02f, 1.01833433e-01f, -2.33910605e-02f, -8.39094743e-02f, 2.18854528e-02f,
  -6.34499267e-02f, -6.96761757e-02f, -6.19965196e-02f, 1.09756224e-01f, 3.55587080e-02f, -4.52352054e-02f, -7.94837847e-02f, 2.12893598e-02f, -4.37915586e-02f, 4.63363901e-02f,
  1.09216720e-02f, -7.05900490e-02f, 1.34054527e-01f, 2.17212867e-02f, 1.15139127e-01f, 1.02265291e-01f, -1.58269145e-02f, -4.00492884e-02f, 6.77310452e-02f, -4.68130261e-02f,
  -4.99824136e-02f, -1.28042668e-01f, -5.61841764e-03f, 4.18564379e-02f, 4.92126159e-02f, 1.13747850e-01f, 1.92203388e-01f, 6.70400783e-02f, 1.25155687e-01f, -3.87370437e-02f,
  1.11940861e-01f, 6.87126145e-02f, 1.18158050e-02f, 6.00756109e-02f, 2.69385446e-02f, -2.48217788e-02f, 1.17193833e-01f, 2.31844746e-02f, 7.01320618e-02f, 1.21763878e-01f,
  -2.19265628e-03f, 8.55678990e-02f, 3.77354398e-02f, -2.48994231e-02f, -2.32397188e-02f, -7.52701312e-02f, -7.10356832e-02f, 7.71097280e-03f, -7.96956494e-02f, -7.41834864e-02f,
  -3.26485187e-02f, 9.73686203e-03f, -4.00422513e-02f, -1.05592102e-01f, 8.94274339e-02f, -6.46675453e-02f, 6.14315905e-02f, 1.07760949e-03f, 8.31450969e-02f, 2.79724170e-02f,
  -5.82418740e-02f, 4.62466553e-02f, -4.99397479e-02f, 2.19323318e-02f, 7.10267574e-02f, -3.45457233e-02f, -6.66471422e-02f, -1.32292567e-03f, -4.27814350e-02f, -2.16728859e-02f,
  2.67193671e-02f, -1.50780380e-02f, -5.47418036e-02f, 2.62968205e-02f, 2.22443361e-02f, -5.11357486e-02f, -9.80501249e-02f, -9.10744518e-02f, 2.82985289e-02f, 3.90276425e-02f,
  -9.18589309e-02f, -7.88182393e-02f, 5.97719923e-02f, -7.72417486e-02f, 2.14333367e-02f, 6.91326335e-02f, 7.88599066e-03f, -5.34920546e-05f, -1.04351021e-01f, 2.50378121e-02f,
  3.72652896e-02f, -9.11087021e-02f, 3.46021056e-02f, 8.40043649e-03f, -1.38504775e-02f, -8.13110396e-02f, -2.22320314e-02f, -1.10954039e-01f, -4.26110998e-02f, 4.22772616e-02f,
  -4.67189364e-02f, 2.31932327e-02f, 4.53526042e-02f, 9.83548984e-02f, 1.97128151e-02f, 1.70872472e-02f, -7.18156397e-02f, 7.48991445e-02f, -8.81476328e-02f, -2.21773498e-02f,
  7.91374892e-02f, -4.70535830e-02f, 5.62793911e-02f, -1.73333753e-02f, -4.12155427e-02f, -6.67979941e-02f, 4.28915909e-03f, -4.17831987e-02f, 6.09803312e-02f, -1.46072591e-02f,
  9.21422523e-03f, 3.73076759e-02f, -5.58432639e-02f, 5.51405624e-02f, -9.50131938e-02f, 1.72826275e-02f, -7.26617174e-04f, -9.11722798e-03f, -7.16200396e-02f, -4.90556769e-02f,
  -2.10684203e-02f, 7.28231072e-02f, -1.35552026e-02f, 5.47230951e-02f, -2.33608112e-02f, 1.08670972e-01f, 1.64759010e-01f, 9.89891142e-02f, 5.81706166e-02f, -6.12064749e-02f,
  -6.76511554e-03f, -6.32710606e-02f, 6.16305806e-02f, -1.21673234e-02f, -4.91287932e-02f, 1.39559269e-01f, 5.96183212e-03f, 5.57457330e-03f, 2.63442788e-02f, -7.63501376e-02f,
  7.16238543e-02f, -6.72385693e-02f, -6.57925680e-02f, 4.31739762e-02f, 9.65369269e-02f, -4.12400998e-02f, -2.53984779e-02f, -2.95300502e-02f, 6.86680079e-02f, 2.93001477e-02f,
  3.84545550e-02f, 5.45365438e-02f, 5.36231473e-02f, 7.74740300e-04f, -7.92982876e-02f, -7.43508860e-02f, -4.41129766e-02f, 3.80726568e-02f, -2.48316638e-02f, 2.08761673e-02f,
  2.59518437e-02f, -1.11414470e-01f, 1.11756111e-02f, 4.40797918e-02f, -9.87452567e-02f, 5.35456799e-02f, 4.92793247e-02f, 1.83708372e-03f, 4.66025621e-02f, 5.37240207e-02f,
  1.93274431e-02f, 1.02839870e-02f, -1.35808559e-02f, -5.62328473e-02f, -1.56504363e-02f, 5.61584942e-02f, -9.03400853e-02f, -4.75086980e-02f, 7.15517625e-02f, 2.51714122e-02f,
  2.07749531e-02f, 2.67389175e-02f, -1.22188928e-03f, 1.48491869e-02f, 7.04009905e-02f, -1.38015784e-02f, 9.33907703e-02f, 4.04099151e-02f, 4.63088527e-02f, -3.85359488e-02f,
  6.49542781e-03f, -4.88972897e-03f, 8.64494517e-02f, 9.33704525e-02f, -6.04615584e-02f, 8.83854867e-04f, 4.30506952e-02f, -6.58518821e-02f, -7.24084899e-02f, -9.94910523e-02f,
  5.75782126e-03f, -2.46044453e-02f, -4.11664546e-02f, -5.64555521e-04f, 2.77040862e-02f, 2.13524196e-02f, 7.17608109e-02f, -1.95104498e-02f, 2.81817708e-02f, -7.56640658e-02f,
  3.91225889e-02f, 1.37938410e-02f, -5.64414561e-02f, -5.84897064e-02f, -8.94416682e-03f, -1.18831526e-02f, -5.94418459e-02f, -1.06085360e-01f, -8.42432305e-02f, 4.35742438e-02f,
  -9.90186781e-02f, 1.49550298e-02f, 7.69343153e-02f, -2.70467112e-03f, 5.82055561e-02f, 1.24603964e-03f, -5.96449226e-02f, -4.44685146e-02f, 4.13219184e-02f, 1.98742468e-02f,
  6.47759205e-03f, 4.13104594e-02f, -9.59137827e-02f, -3.56509611e-02f, 5.34122698e-02f, 4.18603234e-02f, -3.26219797e-02f, 9.71890334e-03f, -7.40995854e-02f, -6.19388670e-02f,
  1.74396783e-02f, -9.42204893e-02f, 5.66216223e-02f, -4.21872735e-02f, 5.01127429e-02f, 2.19713911e-01f, 1.68431282e-01f, 3.24745104e-02f, -6.86949193e-02f, -1.09930620e-01f,
  2.13767532e-02f, 1.99248996e-02f, 5.94735183e-02f, -7.44024385e-03f, 5.63656352e-02f, 4.49123941e-02f, -4.18560542e-02f, 1.41393706e-01f, 1.26112372e-01f, -3.90743017e-02f,
  -3.74371582e-03f, 3.80309187e-02f, -4.88467775e-02f, 4.18172106e-02f, -5.40850163e-02f, 1.28792832e-02f, 7.37888813e-02f, 3.29491636e-03f, 2.62612794e-02f, -2.59042028e-02f,
  -5.33147007e-02f, 8.92623886e-02f, -2.83669657e-03f, -1.19320922e-01f, -6.11622520e-02f, 1.08381333e-02f, -1.41106956e-02f, -2.70712581e-02f, -9.17819589e-02f, -1.24941453e-01f,
  -6.11345135e-02f, 3.24612670e-02f, 6.41504750e-02f, -6.40488369e-03f, -3.89269227e-03f, 1.72196086e-02f, 4.82333340e-02f, 5.65126315e-02f, 2.70012375e-02f, -2.49523949e-02f,
  -4.53255363e-02f, 1.68277714e-02f, 1.50620878e-01f, 2.84836218e-02f, 7.72467852e-02f, 2.70505920e-02f, 7.27470443e-02f, -3.21925208e-02f, 8.56561065e-02f, -1.79430962e-01f,
  2.55700270e-05f, 8.16435814e-02f, 1.30065516e-01f, -1.98396109e-03f, -4.71274815e-02f, 3.09570413e-02f, 3.19955051e-02f, 2.24089324e-02f, 2.33740155e-02f, 5.57366423e-02f,
  2.87593529e-02f, 8.49000812e-02f, -1.19502712e-02f, -4.48233299e-02f, 5.42791337e-02f, -6.43795654e-02f, -1.62383895e-02f, 2.31464691e-02f, 4.93263118e-02f, -4.90650944e-02f,
  8.92576389e-03f, 1.11398600e-01f, -8.64217244e-03f, 1.84540171e-02f, -6.55486584e-02f, -1.48571711e-02f, -9.04104412e-02f, -7.86595792e-03f, -4.20558602e-02f, 9.79156122e-02f,
  -1.13175899e-01f, 2.07632661e-01f, 8.33084732e-02f, -1.94256625e-03f, -3.58121395e-02f, -5.37219569e-02f, -7.49550089e-02f, -1.04037113e-01f, -1.41332084e-02f, 1.60802845e-02f,
  4.80640344e-02f, -4.79228348e-02f, -4.64500450e-02f, -3.17360722e-02f, 1.77817773e-02f, -1.13699995e-01f, -8.91266912e-02f, 1.03381112e-01f, 9.06133205e-02f, 3.06269545e-02f,
  -6.13019504e-02f, 1.45231392e-02f, 5.91981038e-02f, 9.63565893e-03f, 5.16177379e-02f, 8.78010020e-02f, 1.03107341e-01f, -4.34451811e-02f, 1.10305458e-01f, -1.56828687e-01f,
  -1.58321727e-02f, -8.11790600e-02f, 1.39061183e-01f, -9.07380953e-02f, 2.90983226e-02f, 2.07984254e-01f, 2.19242856e-01f, 8.83563831e-02f, -1.39917016e-01f, 8.57347716e-03f,
  5.83533291e-03f, -4.68766689e-02f, -1.27579406e-01f, -2.62793154e-04f, 2.37891749e-02f, 1.11541919e-01f, 6.83312044e-02f, 1.12307787e-01f, -1.28931098e-03f, 9.59131196e-02f,
  -1.10264927e-01f, 7.38138007e-03f, 2.05108877e-02f, -9.34577808e-02f, 4.22378369e-02f, -7.22835436e-02f, 6.09490946e-02f, 5.28529435e-02f, 6.93074847e-03f, -4.32086438e-02f,
  1.71924755e-01f, 2.29547024e-02f, -1.54281314e-02f, -1.40477687e-01f, -4.87095155e-02f, -2.06976347e-02f, -6.44253939e-02f, -1.03031874e-01f, -1.86028518e-02f, -8.81908834e-02f,
  -9.96259600e-02f, -4.63149957e-02f, 2.24631615e-02f, -5.37754111e-02f, -5.96732600e-03f, 1.43923080e-02f, -8.76368582e-02f, -1.09957777e-01f, -3.80135663e-02f, 4.03573364e-02f,
  -3.86932753e-02f, -2.42119152e-02f, 9.44640413e-02f, 8.08471665e-02f, -1.39514329e-02f, 5.09424433e-02f, 8.27156287e-03f, -8.53341073e-02f, 5.97598637e-03f, 3.75438854e-02f,
  9.57593881e-03f, 4.63189781e-02f, 4.99202609e-02f, 5.41502759e-02f, -1.27881700e-02f, -1.72496364e-02f, -4.15916629e-02f, -8.39905143e-02f, -8.43100920e-02f, -6.84378017e-03f,
  3.04608252e-02f, 9.45553940e-04f, 5.04482351e-02f, -3.25938947e-02f, -7.62259588e-02f, -1.80329029e-02f, -5.16882725e-02f, -1.78389717e-02f, -1.32736051e-02f, -2.84190127e-03f,
  4.76347581e-02f, -4.63785119e-02f, 6.48570284e-02f, 7.47209415e-02f, -1.09326571e-01f, -4.54444662e-02f, 7.32810423e-02f, -8.23719874e-02f, -1.64663140e-02f, -3.86146083e-02f,
  3.78994122e-02f, 6.60046339e-02f, 4.18460481e-02f, 1.02548879e-02f, -4.76311035e-02f, -9.09690261e-02f, 7.09379539e-02f, 2.50415504e-02f, 5.49501851e-02f, -3.27154808e-02f,
  8.22614208e-02f, 6.55499324e-02f, -2.43679620e-02f, 4.68281321e-02f, 5.91034479e-02f, 9.13669690e-02f, -1.01706525e-02f, 4.86728139e-02f, -3.49448211e-02f, 5.27876392e-02f,
  5.05008250e-02f, 5.28859235e-02f, 2.55879685e-02f, -1.61395743e-02f, 9.76959988e-02f, 3.99767011e-02f, 9.47286710e-02f, 1.16203830e-01f, 7.92882517e-02f, -5.56806773e-02f,
  1.53490871e-01f, 9.77118388e-02f, -1.18258335e-01f, 1.98418856e-01f, 1.24213703e-01f, -2.10617371e-02f, -9.69517156e-02f, -1.29594609e-01f, 1.57181192e-02f, 5.70478588e-02f,
  1.61869712e-02f, 5.07312305e-02f, -6.39359653e-02f, -6.88056797e-02f, -1.40862569e-01f, -1.13650471e-01f, -2.34404039e-02f, -1.41063824e-01f, -2.11716115e-01f, -2.36555878e-02f,
  1.03056215e-01f, 1.24481946e-01f, 2.41940171e-02f, -1.95887014e-02f, 3.94037925e-03f, -4.19079103e-02f, 7.66017064e-02f, -3.39481831e-02f, 6.88849390e-02f, 1.59172252e-01f,
  2.01466251e-02f, 7.99032375e-02f, -7.09306747e-02f, 4.80315983e-02f, 3.63384187e-02f, -6.67837188e-02f, 6.73367083e-02f, -5.18756770e-02f, -3.75602432e-02f, -5.82045205e-02f,
  4.46523987e-02f, -5.31487213e-03f, -4.44031619e-02f, 8.00097883e-02f, -6.03379756e-02f, -3.64772193e-02f, -5.94467968e-02f, -2.46073902e-02f, 2.02808958e-02f, 5.02690207e-03f,
  1.27089843e-01f, 3.05396952e-02f, 4.17366847e-02f, 2.08433531e-02f, -4.55939397e-02f, 1.43280616e-02f, 6.46810234e-02f, 4.72853333e-02f, 2.97386143e-02f, -7.22744362e-03f,
  4.92213815e-02f, -5.16813423e-04f, 5.19636571e-02f, -3.39605398e-02f, 3.87191847e-02f, 8.69125687e-03f, 7.19331354e-02f, 1.02667719e-01f, 9.98603180e-02f, -5.17428070e-02f,
  -7.40156323e-02f, -4.94994447e-02f, 6.95963800e-02f, 8.75407159e-02f, -3.11072618e-02f, 8.61091986e-02f, 6.81683347e-02f, 4.66269180e-02f, 9.66866910e-02f, 7.22241327e-02f,
  -4.91734631e-02f, 6.15327619e-03f, -4.97343158e-03f, 4.81875539e-02f, 3.00271399e-02f, 8.57162252e-02f, 9.15237144e-02f, 5.12822904e-02f, -9.50917602e-02f, 2.98949960e-03f,
  1.60618305e-01f, -4.93855774e-02f, -1.50777809e-02f, -2.19998043e-02f, -7.31296465e-02f, 6.10747300e-02f, -2.50985716e-02f, 3.69412415e-02f, -5.90743460e-02f, 5.21030352e-02f,
  -4.93270941e-02f, -8.29979256e-02f, -1.29262842e-02f, -6.32890239e-02f, -5.92612661e-03f, -6.44323230e-02f, 2.96571814e-02f, -5.54784376e-04f, 3.32430266e-02f, 2.58614519e-03f,
  -3.41309682e-02f, -1.42781110e-02f, -5.72042353e-03f, -7.80723756e-03f, 6.93284795e-02f, 3.23538892e-02f, -5.52679449e-02f, -5.08245155e-02f, -9.59753245e-02f, 4.11803275e-02f,
  9.04591084e-02f, 2.53435206e-02f, 9.61644691e-04f, 4.34342623e-02f, -1.14650525e-01f, -1.82369292e-01f, -1.40528247e-01f, -3.28709674e-03f, 9.14978981e-02f, 1.47995003e-03f,
  6.83305934e-02f, 2.43816599e-02f, 1.05200723e-01f, 6.94100186e-02f, 4.78606299e-02f, -5.90260029e-02f, 2.33475380e-02f, 9.21581984e-02f, 1.31149486e-01f, 3.77797559e-02f,
  2.39024851e-02f, 4.48718853e-02f, 1.67710796e-01f, 5.31844459e-02f, 1.16947360e-01f, 2.75975261e-02f, 9.38924029e-03f, 8.17052722e-02f, 1.01077566e-02f, 1.23503238e-01f,
  4.59404550e-02f, 3.21655311e-02f, 5.99857718e-02f, 3.29393111e-02f, 4.36441116e-02f, -5.31104021e-02f, 1.13052940e-02f, 3.61584313e-02f, -3.94935422e-02f, 2.94054840e-02f,
  -4.82875817e-02f, 7.47285858e-02f, 4.63724323e-02f, -5.09263277e-02f, -8.56305361e-02f, -9.94390026e-02f, 5.82455620e-02f, 7.68076330e-02f, 4.33694525e-03f, -3.23406644e-02f,
  1.91634744e-02f, -6.15798496e-02f, -1.14846565e-01f, -8.70744288e-02f, 1.59046538e-02f, 1.01874232e-01f, 2.66857278e-02f, -1.84896309e-02f, 7.97726214e-02f, 1.02328107e-01f,
  -5.91086261e-02f, -6.02092855e-02f, -1.96732152e-02f, 2.80021504e-02f, 5.05315438e-02f, -8.64044204e-02f, 6.47788644e-02f, -3.14684659e-02f, -3.36259641e-02f, -4.33150418e-02f,
  -4.23358753e-02f, 3.01354248e-02f, 7.02062994e-02f, -7.20576011e-03f, -6.98977262e-02f, 2.75685973e-02f, -4.08506617e-02f, 3.49791050e-02f, -5.04425503e-02f, -1.01805320e-02f,
  4.02231812e-02f, 3.10151838e-02f, -7.95650035e-02f, 5.58433719e-02f, 8.08742493e-02f, -1.20117255e-02f, 3.48345861e-02f, -3.27330008e-02f, 1.62269231e-02f, 6.92515969e-02f,
  -9.42532346e-02f, -6.61369860e-02f, 1.55701518e-01f, -5.37345372e-02f, 9.08743963e-03f, -3.45535353e-02f, 2.82677487e-02f, 4.95171957e-02f, 8.80728364e-02f, -1.40159496e-03f,
  7.30386525e-02f, -3.93972471e-02f, -1.95889082e-02f, 2.92014480e-02f, 3.47085334e-02f, 2.15254407e-02f, 6.15023747e-02f, -6.89537404e-03f, 4.64878604e-02f, -3.71438935e-02f,
  -3.24862339e-02f, -1.32838562e-01f, 5.41941598e-02f, -5.43752275e-02f, 5.48161529e-02f, -6.28830343e-02f, 6.03194013e-02f, -2.58791950e-02f, 2.64107715e-02f, -3.89653854e-02f,
  -1.02948390e-01f, -1.54892996e-01f, -2.33640894e-01f, -1.29624248e-01f, -9.46201533e-02f, -7.08894432e-02f, -1.81143746e-01f, 8.37269500e-02f, 6.90801069e-02f, -6.65381700e-02f,
  -5.25943153e-02f, 1.10097446e-01f, 7.90946633e-02f, 7.35294819e-02f, -7.27202669e-02f, -2.26007223e-01f, -2.44150385e-01f, -5.25988378e-02f, -7.39963874e-02f, -3.92913818e-02f,
  -4.33889814e-02f, -4.25344408e-02f, 3.53183746e-02f, -5.23650385e-02f, -4.54642624e-02f, 1.00617692e-01f, 4.75742966e-02f, 7.94612095e-02f, 3.15475762e-02f, -3.45196016e-02f,
  -1.29615933e-01f, -3.70074343e-03f, -2.84308218e-03f, 5.77251613e-02f, -2.35410128e-02f, -1.80447090e-03f, -8.06228742e-02f, 3.12083401e-02f, 6.03891909e-02f, -9.62063521e-02f,
  -4.74880114e-02f, -7.07572177e-02f, 5.52886119e-03f, 2.77972575e-02f, -5.38011873e-03f, -5.15630208e-02f, -8.98115411e-02f, -6.29858971e-02f, 6.63222671e-02f, 3.35532092e-02f,
  -9.87439752e-02f, -3.47206159e-03f, -8.47804621e-02f, -1.80113800e-02f, 5.63034862e-02f, 1.88593175e-02f, 1.41060367e-01f, 1.31057009e-01f, 2.13412300e-01f, 1.04502045e-01f,
  -6.93094498e-03f, 4.97591011e-02f, 8.01108330e-02f, 6.04687743e-02f, -9.06754360e-02f, 2.20737886e-02f, -1.37399687e-02f, 7.01700300e-02f, -6.12765439e-02f, -4.76064831e-02f,
  -4.63735722e-02f, -8.92214403e-02f, 3.38599421e-02f, 2.62601823e-02f, 2.88282260e-02f, 4.95077334e-02f, 3.87862846e-02f, 4.61200848e-02f, 7.39113986e-03f, 2.53453106e-02f,
  -1.69093125e-02f, 3.11664138e-02f, 3.92594077e-02f, 7.37445131e-02f, -8.97822082e-02f, -4.51186113e-02f, -7.71832168e-02f, 5.31728799e-03f, 5.54176457e-02f, -1.15323076e-02f,
  3.05338874e-02f, -5.65521158e-02f, -1.10171266e-01f, 5.19360136e-03f, -6.82202503e-02f, 5.33583481e-03f, -6.61550388e-02f, -8.20585340e-02f, 3.56040858e-02f, 7.24328086e-02f,
  -1.31222140e-02f, 3.36401463e-02f, 6.69319928e-02f, -6.58950135e-02f, -3.77454013e-02f, 2.15328131e-02f, -1.30063310e-01f, 1.91190820e-02f, -2.15913225e-02f, 2.67663449e-02f,
  8.66136421e-03f, -1.45850433e-02f, 6.98145479e-02f, -5.13658673e-02f, 8.31873864e-02f, -6.45140186e-02f, -1.07192490e-02f, 1.36311665e-01f, -3.88962664e-02f, -2.62279045e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.88505198e-02f, 5.56378104e-02f, 5.02756387e-02f, 1.56285971e-01f, 1.97275758e-01f, 2.18017902e-02f, 7.36128166e-02f, 6.69303238e-02f, 3.71342041e-02f, 1.56753153e-01f,
  8.96576270e-02f, 7.88343791e-03f, 5.44435298e-03f, 1.46382689e-01f, 6.68172240e-02f, 8.51428434e-02f, 3.58485915e-02f, 1.46987978e-02f, 1.80755496e-01f, 1.01891905e-01f,
  6.52223080e-02f, -4.51528132e-02f, 1.66036457e-01f, 1.02465957e-01f, 1.42277777e-01f, 1.55291319e-01f, 1.19706705e-01f, -2.50014989e-03f, -2.60224137e-02f, 3.33032906e-01f,
  -9.95232724e-03f, 7.91156739e-02f, 5.47905639e-02f, 6.83530122e-02f, 1.43513843e-01f, -4.64979485e-02f, 1.43691031e-02f, -3.84065732e-02f, 9.97020155e-02f, 1.18668050e-01f,
  8.82497877e-02f, -2.67732097e-03f, 3.78357284e-02f, 2.33889028e-01f, 2.16087829e-02f, 4.67795245e-02f, -2.41279844e-02f, 1.90026298e-01f, -1.39073133e-02f, 1.17124133e-01f,
  8.46024901e-02f, 6.83451965e-02f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  9.63025242e-02f, 8.69639814e-02f, -8.76063555e-02f, -1.05396278e-01f, 6.72901841e-03f, -3.98949049e-02f, -1.67290926e-01f, -1.57468826e-01f, -3.03670969e-02f, 2.29544058e-01f,
  9.97562408e-02f, -2.27424324e-01f, -8.59426782e-02f, 2.53113583e-02f, 1.97860729e-02f, -1.54725507e-01f, -6.91642845e-03f, -8.60623792e-02f, -8.05523526e-03f, -8.40037316e-02f,
  6.11803010e-02f, 6.13329560e-02f, 8.05301890e-02f, -2.68762186e-02f, -4.15102467e-02f, 1.27645478e-01f, 5.59674427e-02f, 1.83930412e-01f, -1.33329943e-01f, 2.85428874e-02f,
  -1.36946365e-01f, 1.48946330e-01f, -6.55350089e-02f, 9.46223065e-02f, -9.59929749e-02f, -1.10328354e-01f, -2.18313560e-02f, 1.70054883e-02f, -1.88494608e-01f, -4.26030345e-02f,
  1.04861498e-01f, -7.54358340e-03f, -2.85199657e-02f, 1.80759206e-01f, -8.02325755e-02f, -1.72255054e-01f, 1.31954178e-01f, 2.71108281e-02f, -1.16983987e-01f, -1.44141326e-02f,
  1.18369855e-01f, 6.55834004e-02f, -6.31133886e-03f, 2.64755357e-03f, -5.39900213e-02f, -1.68561518e-01f, -9.52916872e-03f, 6.09727912e-02f, -5.50929941e-02f, -1.20641179e-01f,
  -1.76078111e-01f, 1.38884485e-01f, 1.92294661e-02f, -1.11984499e-01f, 3.49105000e-02f, 2.14370146e-01f, -4.43106778e-02f, 1.03811011e-01f, 3.89574729e-02f, 9.85403508e-02f,
  -7.39153475e-02f, -6.58189580e-02f, -1.09390356e-01f, -3.41602296e-01f, -5.68500794e-02f, 3.79666120e-01f, 6.15709797e-02f, -4.84985411e-02f, -1.59788176e-01f, 4.24633212e-02f,
  -1.29977047e-01f, 6.54662922e-02f, 1.02377370e-01f, 1.21090189e-01f, -1.14528947e-01f, 5.98777235e-02f, -1.53371558e-01f, -9.57891718e-02f, 1.55457273e-01f, -1.12453245e-01f,
  -1.13818221e-01f, 3.54843326e-02f, 7.96364844e-02f, 8.27251561e-03f, -1.56025201e-01f, -1.86082914e-01f, 2.74300613e-02f, 5.34617677e-02f, -1.13658480e-01f, 1.73151568e-01f,
  -1.06637575e-01f, -5.08316793e-02f, 5.03564253e-03f, -7.32190907e-02f, -1.12376854e-01f, -9.57976356e-02f, -6.29051998e-02f, -1.44126356e-01f, 2.77558535e-01f, 1.04073822e-01f,
  -2.05724835e-01f, -1.46822631e-01f, 7.02974200e-02f, -1.85316559e-02f, 9.12276134e-02f, 1.23521462e-01f, -2.19390392e-01f, 7.97657818e-02f, 7.40854144e-02f, 2.78570145e-01f,
  -1.50459722e-01f, 1.03565022e-01f, 3.31366174e-02f, 1.16164595e-01f, 1.88597560e-01f, -2.33047843e-01f, 1.05558308e-02f, 1.30962888e-02f, -1.87490761e-01f, -4.40380685e-02f,
  4.35601845e-02f, -3.36992107e-02f, 8.70872661e-02f, -1.07728250e-01f, 2.59090657e-03f, -7.58485496e-02f, 3.04087132e-01f, -1.01309218e-01f, -7.95000419e-03f, 2.49166086e-01f,
  9.72106755e-02f, 4.87475395e-02f, 1.58036798e-01f, 5.62880374e-02f, -2.16558322e-01f, 1.65952859e-03f, 4.38979268e-02f, 9.09268484e-02f, 1.27512515e-01f, -1.57312572e-01f,
  -1.78679466e-01f, 4.77324091e-02f, 1.38764173e-01f, -2.89636441e-02f, 8.69833902e-02f, -1.36628300e-01f, 1.64756924e-02f, -1.56133354e-01f, 4.53962609e-02f, -6.08905964e-02f,
  -1.35005815e-02f, -4.71252240e-02f, -1.85496226e-01f, 1.06863670e-01f, 1.34425389e-03f, -6.69434592e-02f, 3.16091403e-02f, 6.92593008e-02f, -4.38228808e-02f, 1.46874145e-01f,
  5.61487209e-03f, -1.28084779e-01f, 2.53230989e-01f, 1.66701749e-01f, 3.96867059e-02f, -3.41691473e-03f, -6.39140457e-02f, 3.56246382e-02f, -4.50312486e-03f, -7.34047294e-02f,
  -6.78366050e-02f, -2.73448192e-02f, 2.14298636e-01f, 2.87618637e-01f, -2.77307648e-02f, -1.77417397e-02f, 4.64918464e-02f, 8.73781070e-02f, 1.49223074e-01f, -1.35659933e-01f,
  2.54645646e-02f, 9.42347795e-02f, -1.71554610e-01f, -8.55458304e-02f, -4.72934023e-02f, 1.68188974e-01f, -2.65183877e-02f, -1.45353928e-01f, -2.06727162e-01f, -2.01131344e-01f,
  7.34850094e-02f, -2.22135335e-01f, -2.88274568e-02f, 4.07883137e-01f, 1.08636603e-01f, 1.64655611e-01f, -1.99281439e-01f, -8.27371776e-02f, -1.67021364e-01f, 1.43205449e-01f,
  5.59369251e-02f, 3.06158736e-02f, -1.79412529e-01f, -1.76409289e-01f, -3.86128910e-02f, 7.89944828e-02f, 1.04728177e-01f, -2.22906798e-01f, 1.30849645e-01f, -2.71397352e-01f,
  -8.74866247e-02f, 5.58192395e-02f, -5.53833060e-02f, -3.15533169e-02f, 1.09291352e-01f, -5.76143973e-02f, -2.35192664e-02f, 7.51914605e-02f, -8.29917118e-02f, -5.61999381e-02f,
  -3.19314413e-02f, -5.67533337e-02f, 5.34439599e-03f, 1.59665421e-02f, -1.37812823e-01f, -8.08787197e-02f, 2.29289606e-01f, 4.83643860e-02f, -1.43335029e-01f, 3.12897824e-02f,
  -4.23455313e-02f, 1.59588501e-01f, 3.74223776e-02f, 2.81423493e-03f, -1.20288230e-01f, 2.68379189e-02f, 1.79752782e-02f, 1.75716072e-01f, 9.88932028e-02f, 9.90215763e-02f,
  2.30365489e-02f, -1.44265071e-01f, 2.13284139e-02f, -1.34895340e-01f, 9.55699161e-02f, -9.84843299e-02f, -1.16472907e-01f, -7.11725280e-03f, -1.29466340e-01f, -9.04312059e-02f,
  1.03328928e-01f, -1.00618549e-01f, -2.13379711e-01f, 1.40989393e-01f, 4.72278297e-02f, -3.37522745e-01f, 2.42412761e-01f, 5.62162757e-01f, 1.42775983e-01f, 2.58276854e-02f,
  -3.86254974e-02f, 1.07092924e-01f, -7.95870870e-02f, -4.39069793e-02f, 1.37717113e-01f, 2.27569550e-01f, -2.54066307e-02f, -3.44927013e-02f, -2.28976421e-02f, 3.59361544e-02f,
  1.17445424e-01f, -1.26129568e-01f, 1.80438925e-02f, -8.89537558e-02f, -5.91567382e-02f, 1.26423970e-01f, -2.03632921e-01f, -1.05757870e-01f, -4.39291634e-02f, -9.81844366e-02f,
  5.20563871e-02f, -1.33242026e-01f, -1.48986414e-01f, 6.54692426e-02f, -2.21601978e-01f, -1.98663190e-01f, -1.62248373e-01f, -7.38265812e-02f, -1.48778697e-02f, 2.13820599e-02f,
  1.14823222e-01f, 9.01153982e-02f, 3.67558887e-03f, -1.79472268e-01f, -7.28637800e-02f, 1.22738071e-01f, -6.05919771e-02f, 2.37039581e-01f, -1.12950958e-01f, -1.18393913e-01f,
  -4.28745933e-02f, 8.13504681e-02f, -1.24310143e-01f, 1.13110326e-01f, -7.38430694e-02f, 1.44058481e-01f, 6.30772579e-03f, -1.18541040e-01f, -3.79084647e-02f, 2.06019972e-02f,
  -2.20311418e-01f, 4.86375159e-03f, 2.51409523e-02f, -3.29592153e-02f, -1.27215544e-02f, 8.40520859e-02f, 3.76557887e-01f, 3.92135054e-01f, 1.39761209e-01f, 1.11508206e-01f,
  -1.36798233e-01f, -4.12017524e-01f, 6.41178116e-02f, 8.97200480e-02f, 4.74807899e-03f, -2.09196359e-01f, 8.81789476e-02f, 6.36253059e-02f, -1.67781368e-01f, -2.29120746e-01f,
  1.21851526e-01f, -1.27853647e-01f, -2.24244416e-01f, -9.77939442e-02f, 5.39765134e-02f, 9.05243009e-02f, 3.08381449e-02f, 1.67221755e-01f, 3.24073061e-02f, -1.19618289e-02f,
  3.29690307e-01f, 2.79450625e-01f, -8.83801933e-03f, 6.79909214e-02f, -9.88288000e-02f, 7.78878704e-02f, -2.82589793e-02f, 1.59283448e-02f, 6.71929121e-02f, 6.99227452e-02f,
  -7.63493329e-02f, -1.07747592e-01f, -1.13510385e-01f, -8.32659751e-02f, -8.05732459e-02f, -6.07014932e-02f, 1.24825478e-01f, -9.35530365e-02f, -1.06856816e-01f, -5.20493351e-02f,
  -1.58917233e-01f, -1.28962651e-01f, 4.35769558e-02f, 1.28990993e-01f, -1.65080518e-01f, -1.89221129e-01f, -1.44842044e-01f, 5.52652553e-02f, 7.91335404e-02f, -2.78580040e-02f,
  4.06266563e-02f, -1.00865684e-01f, -1.25255793e-01f, -1.14453830e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  3.37965898e-02f, 1.22942284e-01f, 1.39330953e-01f, 2.69398212e-01f, 1.47680581e-01f, 7.86502212e-02f, -1.84519365e-01f, -1.12757899e-01f, 5.70573211e-02f, -1.45105138e-01f,
  -1.55430213e-01f, 3.03863645e-01f, 4.59026918e-02f, 2.46020541e-01f, 1.33917913e-01f, -8.51404443e-02f, -1.61799133e-01f, 1.16178673e-02f, -9.76052359e-02f, -1.06824644e-01f,
  -1.11216977e-01f, -1.28704756e-01f, -9.28392559e-02f, 2.02142615e-02f, -3.45469788e-02f, -1.43442273e-01f, 3.55396941e-02f, -1.28736079e-01f, 1.06014207e-01f, 2.79059969e-02f,
  -1.30882114e-01f, -1.02113433e-01f, -1.70672778e-02f, -4.43653166e-02f, -1.08492449e-01f, -1.60342630e-03f, -9.80587676e-02f, 1.36908785e-01f, 5.83548732e-02f, -2.98752338e-02f,
  -1.09973952e-01f, 9.81562659e-02f, 2.58245543e-02f, 2.29463559e-02f, 1.82505354e-01f, -1.35871321e-01f, 5.38759828e-02f, 1.74415652e-02f, -1.02331951e-01f, -1.13929152e-01f,
  3.71206775e-02f, 5.92635870e-02f, 1.34626970e-01f, -6.11452647e-02f, -7.45739639e-02f, 2.44076148e-01f, 7.18144476e-02f, -2.75128707e-02f, 7.72772729e-02f, -7.85845444e-02f,
  -6.99678510e-02f, 2.81105563e-02f, 7.08144754e-02f, 1.86447892e-03f, -3.17860506e-02f, -5.12717776e-02f, -1.21244490e-01f, -4.07574028e-02f, -1.00309938e-01f, -1.01843104e-01f,
  -1.77473687e-02f, 3.13150696e-02f, -1.12683237e-01f, -8.32262933e-02f, 8.68587121e-02f, -1.86459318e-01f, -6.47024810e-02f, 7.13648796e-02f, -3.37313451e-02f, 2.22704560e-02f,
  1.19188175e-01f, 4.86109480e-02f, -1.71387848e-02f, -2.64136447e-03f, -7.97953904e-02f, -1.60372704e-02f, 6.56334981e-02f, -2.42934264e-02f, 3.74205858e-02f, -1.16487958e-01f,
  1.10133521e-01f, 2.89887805e-02f, 2.57805511e-02f, -5.65014854e-02f, -1.06066622e-01f, -7.94263408e-02f, -2.49011163e-02f, -1.28823265e-01f, -1.25756517e-01f, -1.32146463e-01f,
  6.29337355e-02f, 3.95129509e-02f, -3.23494757e-03f, -4.37114201e-02f, 4.50531170e-02f, -1.17956989e-01f, 1.31252170e-01f, -7.61287808e-02f, -9.41068009e-02f, 1.35470415e-02f,
  4.37272713e-02f, 6.05534613e-02f, -4.20971215e-02f, -1.01262622e-01f, 3.54313920e-03f, 5.86348698e-02f, -1.91368647e-02f, 1.53430790e-01f, 6.31430596e-02f, -3.94948497e-02f,
  2.62087751e-02f, 9.47394967e-02f, 5.91768809e-02f, 2.91749537e-02f, 1.72562189e-02f, -7.45501602e-03f, 6.05703108e-02f, 2.90806964e-02f, 1.63811967e-02f, 6.05043247e-02f,
  2.00797886e-01f, 1.08206503e-01f, 1.43247321e-01f, 7.84305409e-02f, -2.62730837e-01f, -2.43751958e-01f, -1.87688470e-01f, -6.44223616e-02f, -1.39273942e-01f, 2.63095852e-02f,
  -7.06782043e-02f, 1.63862333e-02f, 1.58093292e-02f, -9.95806009e-02f, 5.64513020e-02f, 1.83988083e-02f, -1.03788003e-01f, -8.00655037e-02f, -9.14343148e-02f, -4.77584451e-02f,
  2.14423254e-01f, -5.49351461e-02f, -1.25937045e-01f, -8.82074535e-02f, 6.97593987e-02f, 4.48517390e-02f, 4.02008034e-02f, -7.84191191e-02f, 3.17562209e-03f, 1.49541885e-01f,
  -8.34349021e-02f, -7.92575255e-02f, -4.67372090e-02f, -7.16540813e-02f, 2.25187521e-02f, 8.06325898e-02f, 4.70423736e-02f, 1.73848085e-02f, 7.49889091e-02f, 1.43552050e-01f,
  -4.25023325e-02f, 7.28456974e-02f, -1.45217985e-01f, 5.02119251e-02f, 1.19742148e-01f, -6.23020194e-02f, -2.29838658e-02f, 4.53217030e-02f, 1.68981418e-01f, 1.19261920e-01f,
  -2.59493794e-02f, -4.71224152e-02f, -8.14257413e-02f, -9.46471766e-02f, 1.04974441e-01f, 1.36305302e-01f, -3.94586883e-02f, 1.58047192e-02f, -1.67348862e-01f, 1.67047054e-01f,
  1.31872073e-01f, -2.35800110e-02f, 1.11267582e-01f, -9.36527923e-02f, -5.88747906e-03f, -1.17475823e-01f, -8.84694234e-02f, -7.91853070e-02f, -5.22650182e-02f, -1.62222739e-02f,
  -4.21395861e-02f, 1.75558664e-02f, 4.31329943e-03f, -1.01623719e-03f, -1.50145322e-01f, 9.49570388e-02f, -8.61057639e-03f, 1.09818779e-01f, 5.87895960e-02f, 2.08059810e-02f,
  -8.24230909e-02f, -8.93607661e-02f, -2.17848938e-04f, -8.53623897e-02f, -8.16299170e-02f, 1.45090237e-01f, -5.36500886e-02f, 9.65590775e-02f, -1.23179018e-01f, 1.47394955e-01f,
  -7.26803020e-02f, -1.02273934e-01f, 8.06564614e-02f, 1.64412513e-01f, 7.15987012e-02f, -1.17402256e-01f, -3.78555879e-02f, 7.56605715e-02f, 6.99362298e-03f, -8.79865363e-02f,
  -2.48587169e-02f, 1.10995196e-01f, 1.95027590e-02f, -4.20061126e-02f, 1.34571180e-01f, 2.68435162e-02f, -7.95446560e-02f, 1.13268010e-03f, 9.43069905e-02f, 5.46501912e-02f,
  -1.13340579e-02f, 6.03301264e-02f, 9.32298750e-02f, 2.19269414e-02f, 8.08311626e-02f, -2.63880901e-02f, -1.49036618e-02f, 6.33577630e-02f, 5.91105670e-02f, 3.76390181e-02f,
  4.16752994e-02f, 7.45541379e-02f, -2.29648296e-02f, 9.19727311e-02f, -7.48479292e-02f, 9.46381539e-02f, 1.85986072e-01f, 2.50410706e-01f, 5.13043255e-02f, 8.16096738e-02f,
  6.75347075e-02f, 9.23223123e-02f, -2.54391402e-01f, -1.64038807e-01f, -4.94465465e-03f, 2.12564722e-01f, -5.02465181e-02f, 1.23060785e-01f, -1.56872526e-01f, 1.22091994e-01f,
  1.54963970e-01f, 2.00882316e-01f, -2.95906942e-02f, -5.84553853e-02f, 4.41980287e-02f, -7.71533698e-02f, -8.49613361e-03f, -3.97861749e-02f, 1.88824534e-01f, 5.79798333e-02f,
  -1.23574108e-01f, 1.53563827e-01f, -3.86625044e-02f, 1.95169657e-01f, 4.80364114e-02f, -8.89082626e-02f, -1.46803871e-01f, -6.91485554e-02f, 1.28167167e-01f, -1.12975754e-01f,
  1.17342405e-01f, -1.06245577e-01f, -6.75238371e-02f, -9.85145047e-02f, 3.20459269e-02f, -1.26295075e-01f, 1.23759910e-01f, 3.75423506e-02f, -3.11011206e-02f, 1.96061254e-01f,
  8.29855055e-02f, -1.14370897e-01f, 7.61877000e-02f, -1.82815976e-02f, 1.26790613e-01f, -1.11087285e-01f, 2.22699329e-01f, -1.72472652e-02f, 1.01751551e-01f, 5.68642374e-03f,
  -7.74434730e-02f, -1.48925051e-01f, 1.30170360e-02f, 7.75578618e-02f, 4.18340713e-02f, -1.74134389e-01f, -1.54365271e-01f, 5.99688292e-02f, 6.89105503e-03f, 1.76326856e-01f,
  6.52578175e-02f, 2.13941768e-01f, 7.80910850e-02f, 2.40163416e-01f, -3.13919620e-03f, 9.05021355e-02f, -2.97608823e-01f, 2.80151553e-02f, -7.08377734e-02f, -2.04407990e-01f,
  6.55925870e-02f, 3.99099022e-01f, 1.28877595e-01f, 4.68265899e-02f, 5.13788611e-02f, 1.47223279e-01f, -1.19568348e-01f, 1.33767560e-01f, -8.66280794e-02f, -7.86815882e-02f,
  3.41002345e-02f, 4.29399386e-02f, 2.12766603e-02f, 1.53134391e-01f, 4.18755673e-02f, 1.32522509e-01f, 5.97922206e-02f, -8.94077271e-02f, -1.03716590e-01f, -1.36784047e-01f,
  -1.35568872e-01f, -5.35188764e-02f, 6.81766346e-02f, 8.52208734e-02f, -5.24954647e-02f, -6.43581226e-02f, 1.08647473e-01f, -8.04712251e-02f, -4.99437451e-02f, 7.37080202e-02f,
  1.20183513e-01f, 2.82944202e-01f, -6.02934547e-02f, 1.19911037e-01f, 2.21610799e-01f, -3.58622894e-02f, 1.01282494e-02f, 2.03234237e-02f, -1.06410019e-01f, -7.43474513e-02f,
  2.26139128e-01f, 1.18782997e-01f, 2.01641973e-02f, 1.07719742e-01f, 6.79785153e-03f, 1.33081134e-02f, 1.47535950e-01f, -8.13471600e-02f, -8.50704014e-02f, -1.27948523e-01f,
  -5.31654619e-02f, 4.93506938e-02f, -1.01812378e-01f, -2.45581754e-02f, 1.02512158e-01f, 1.09374830e-02f, -4.68491055e-02f, 8.02268013e-02f, 1.38640031e-01f, -3.39038223e-02f,
  -1.87590539e-01f, -6.90988004e-02f, -6.54500723e-02f, -5.78714944e-02f, 2.29281634e-01f, 1.40836731e-01f, -9.96652842e-02f, 1.14848815e-01f, 1.21705167e-01f, 4.47012531e-03f,
  7.27730542e-02f, 8.53171423e-02f, 1.98430698e-02f, 1.85847759e-01f, 1.87610880e-01f, 1.90432221e-02f, 3.91875654e-02f, 2.11501822e-01f, 2.15701247e-03f, -3.31479087e-02f,
  1.13489710e-01f, 1.21339202e-01f, -3.20938937e-02f, 1.28954962e-01f, 2.20946893e-02f, 1.18611924e-01f, 9.70669240e-02f, 1.20197926e-02f, 1.08001009e-01f, -1.15657791e-01f,
  -5.69173358e-02f, 1.97737575e-01f, -1.77431569e-01f, 2.20558792e-02f, 1.39103666e-01f, 5.85099272e-02f, 4.93910015e-02f, 2.34654278e-01f, 1.48228094e-01f, 1.50885835e-01f,
  5.45942038e-02f, -5.63017267e-04f, -1.69551715e-01f, 7.07360506e-02f, -8.36935416e-02f, -2.82014702e-02f, -4.06677946e-02f, 6.02225177e-02f, 1.57447942e-02f, 1.17516406e-01f,
  1.30880117e-01f, -5.25596067e-02f, 1.21296853e-01f, 1.84912905e-01f, -1.17819890e-01f, 3.20026593e-04f, 1.32258579e-01f, 4.70842086e-02f, -1.26806900e-01f, -1.41701857e-02f,
  -9.53698680e-02f, -4.40627746e-02f, 7.00181536e-03f, -1.17124155e-01f, -7.75053427e-02f, 1.47824377e-01f, -7.92597532e-02f, 1.80615094e-02f, -5.03637502e-03f, 7.69161209e-02f,
  -9.13475305e-02f, 7.62192011e-02f, -1.33578600e-02f, -1.21528618e-01f, -1.00380741e-01f, -7.65555874e-02f, -4.77614105e-02f, 1.74041241e-02f, -8.65472183e-02f, 7.02762045e-04f,
  -6.97753578e-02f, 2.91541498e-02f, -9.05692652e-02f, 1.21245913e-01f, 3.40163000e-02f, -7.65042007e-02f, -9.20205936e-02f, -1.10493258e-01f, -5.94925657e-02f, 7.64131546e-04f,
  4.69339043e-02f, -1.53923919e-03f, 6.56719599e-03f, -5.01971808e-04f, 9.91707742e-02f, 9.52545330e-02f, 7.23071620e-02f, 7.75050446e-02f, -9.70837250e-02f, -1.76213738e-02f,
  2.89669558e-02f, -1.24529652e-01f, 4.39393986e-03f, 5.93957826e-02f, -2.61070020e-02f, 2.54426878e-02f, 4.21856046e-02f, -1.12161189e-01f, -9.59486216e-02f, -2.40010284e-02f,
  1.07359484e-01f, -1.21686235e-02f, 1.00775130e-01f, -1.23139970e-01f, 3.12155820e-02f, -1.16671428e-01f, -3.08788884e-02f, 7.54937809e-03f, 8.28308016e-02f, -1.10727392e-01f,
  9.44378823e-02f, -4.29203082e-03f, 4.83815260e-02f, -5.24059869e-02f, 1.61768869e-01f, 3.87190878e-02f, 9.73985717e-02f, -4.77653034e-02f, 2.25542545e-01f, 4.32988405e-02f,
  1.57660961e-01f, 9.64708179e-02f, -7.12208003e-02f, 5.78746647e-02f, 6.09626547e-02f, 1.85769647e-02f, 1.16849735e-01f, -5.99453375e-02f, 1.17784545e-01f, 8.22745934e-02f,
  7.16307461e-02f, -1.74388677e-01f, -1.06334664e-01f, 4.72733229e-02f, 5.97380102e-02f, 6.54890537e-02f, -3.02361399e-02f, 1.96645051e-01f, -9.86592397e-02f, 8.84666666e-02f,
  1.05666429e-01f, -1.47003727e-02f, 1.63897544e-01f, -6.12665378e-02f, 1.23880774e-01f, -2.68698204e-02f, 1.21050611e-01f, 1.06526509e-01f, 2.33164206e-02f, -8.30563232e-02f,
  2.95913555e-02f, -4.11409959e-02f, 4.60368134e-02f, 2.94054121e-01f, 8.56937468e-02f, 1.60822142e-02f, -4.15960886e-03f, -1.40706912e-01f, 1.78592533e-01f, 3.15521955e-02f,
  -1.10715061e-01f, -6.14381842e-02f, 1.87605634e-01f, -1.43908814e-01f, -5.00302427e-02f, -5.90356346e-03f, 5.08107394e-02f, -8.63013640e-02f, 1.22488834e-01f, -3.77487689e-02f,
  -4.34117317e-02f, -1.25350729e-01f, -1.61481288e-03f, 3.59258950e-02f, 2.45076567e-02f, 1.84304014e-01f, 1.92293487e-02f, 1.25433862e-01f, 1.37149572e-01f, -6.90069571e-02f,
  9.60523635e-02f, 8.61417353e-02f, -1.39117792e-01f, 1.22009531e-01f, 1.66337445e-01f, -1.48953900e-01f, -3.23494934e-02f, 6.02958649e-02f, -3.25680971e-02f, 7.27340877e-02f,
  -1.78951994e-02f, 9.43409353e-02f, -2.50316039e-02f, 1.26066521e-01f, -8.21778402e-02f, -4.02755514e-02f, -9.86642614e-02f, 1.05997305e-02f, 9.75400507e-02f, 1.20772526e-01f,
  -9.49269682e-02f, -5.08552231e-02f, 9.47892442e-02f, -1.39878206e-02f, 1.29783481e-01f, -1.22403102e-02f, 5.46321422e-02f, 1.08186163e-01f, -8.84164646e-02f, -1.74356755e-02f,
  -8.28640535e-02f, 4.75912094e-02f, 8.99774581e-02f, -6.70499057e-02f, 1.17718093e-01f, 7.64944330e-02f, -6.44156411e-02f, 2.19838619e-01f, 3.95597070e-02f, 1.11232094e-01f,
  8.30740631e-02f, -7.23511502e-02f, 1.03720225e-01f, -1.31609246e-01f, 1.02142528e-01f, 7.17398748e-02f, 1.16629578e-01f, -3.93255912e-02f, -9.19427648e-02f, -2.86076292e-02f,
  -1.23941652e-01f, -8.76103193e-02f, -4.33497317e-02f, -1.31222629e-03f, 7.79178068e-02f, -1.70412511e-01f, -5.17368130e-03f, -5.17020449e-02f, -1.18795082e-01f, -4.84527349e-02f,
  -8.18988755e-02f, -1.18020013e-01f, -9.39193740e-02f, -3.56285423e-02f, -7.28657618e-02f, -8.12172294e-02f, 7.57445171e-02f, -4.69712019e-02f, -1.15464859e-01f, 4.12600338e-02f,
  9.65537280e-02f, 2.94221740e-04f, -5.36731593e-02f, -3.92510369e-02f, -5.07145226e-02f, 2.29385849e-02f, 6.16405308e-02f, -6.72127753e-02f, 6.09791428e-02f, 1.16463028e-01f,
  3.12663727e-02f, -3.28973308e-02f, 6.41345382e-02f, 1.59532264e-01f, 9.31697860e-02f, 8.00569430e-02f, -6.57342449e-02f, 9.25870147e-03f, 9.02981684e-02f, 3.92627120e-02f,
  -6.17908388e-02f, 7.95770288e-02f, 5.85113987e-02f, 1.31772190e-01f, -6.24172054e-02f, 8.86978861e-03f, -1.09098889e-01f, 1.01255573e-01f, 1.04852235e-02f, -5.47847375e-02f,
  -1.10676616e-01f, 1.06381595e-01f, -9.52051058e-02f, -1.16776168e-01f, -5.89275137e-02f, 8.87749419e-02f, 6.36085719e-02f, 1.03074007e-01f, 1.04663797e-01f, -1.12321720e-01f,
  5.57586178e-03f, 7.77780116e-02f, -7.47958422e-02f, -2.68780719e-02f, 2.73256339e-02f, 8.79793912e-02f, -5.47430627e-02f, -3.60824428e-02f, -1.17889643e-01f, 4.20211675e-03f,
  -9.91409197e-02f, 7.21818581e-02f, 1.20646454e-01f, -3.37909684e-02f, 1.69582099e-01f, 2.59203161e-03f, 3.39149237e-02f, 1.26032889e-01f, -1.63446050e-02f, 1.54164284e-02f,
  -7.41394237e-02f, -1.53431252e-01f, -1.91737115e-01f, -1.79588664e-02f, -1.16681941e-01f, 9.00685713e-02f, 3.25133763e-02f, 5.32290563e-02f, -9.83940214e-02f, 3.65009531e-02f,
  7.69185498e-02f, 4.21738513e-02f, 1.47100650e-02f, -6.72772974e-02f, 4.78207618e-02f, -4.68260497e-02f, -2.77192686e-02f, 1.02237821e-01f, -1.23073369e-01f, 4.26069237e-02f,
  -7.60166347e-02f, 4.59450409e-02f, -7.94690102e-02f, -8.66482481e-02f, -1.34106919e-01f, -4.95755039e-02f, -5.04756272e-02f, -7.74520412e-02f, -1.03323728e-01f, 4.81406227e-02f,
  1.88022349e-02f, 6.22066408e-02f, 9.37316641e-02f, -4.88117263e-02f, 6.11245632e-02f, -1.02701783e-01f, -1.11075126e-01f, -8.94669071e-02f, 1.44616812e-02f, 6.55753314e-02f,
  1.51925236e-01f, 8.51209983e-02f, -3.15475687e-02f, 1.10344909e-01f, 8.47844332e-02f, 1.32423937e-01f, -6.04225509e-02f, -6.48506964e-03f, -9.76409540e-02f, -4.32397276e-02f,
  -6.09762631e-02f, 7.10720718e-02f, 5.72861023e-02f, -1.59993977e-03f, 4.56565358e-02f, 3.28729935e-02f, 4.18110713e-02f, 4.18483187e-03f, -7.62979761e-02f, 1.21622622e-01f,
  2.19225362e-02f, -7.12841228e-02f, -7.75787756e-02f, -5.12909070e-02f, -1.10031009e-01f, -5.74432779e-03f, 5.35107888e-02f, -8.10870156e-02f, -1.20714940e-01f, -5.59762940e-02f,
  -5.85030429e-02f, 1.12806320e-01f, -6.22812249e-02f, 1.29078731e-01f, 8.66115317e-02f, -6.95396513e-02f, 1.11470148e-01f, 2.45618932e-02f, -9.35830250e-02f, -4.99915630e-02f,
  -8.55623484e-02f, -8.76994282e-02f, 9.88410860e-02f, -6.46905601e-02f, 7.56665617e-02f, 3.79306264e-02f, -8.77043232e-02f, -1.12669924e-02f, -1.06114065e-02f, -6.44563437e-02f,
  4.07936871e-02f, 9.96129364e-02f, 1.29093342e-02f, 1.17886707e-01f, 1.12538211e-01f, 4.47644219e-02f, 4.11822386e-02f, -8.93305913e-02f, -1.13235556e-01f, -1.03507251e-01f,
  -9.81722698e-02f, 9.62071493e-02f, 1.21900462e-01f, 1.27167895e-01f, -4.79140840e-02f, 2.97389552e-02f, 1.10104114e-01f, 6.79240003e-02f, -1.03512250e-01f, -1.08116165e-01f,
  5.83057515e-02f, 2.66558770e-02f, 5.14360853e-02f, 1.12503171e-02f, 4.15297598e-02f, -4.54132212e-03f, -7.64144883e-02f, 9.00621489e-02f, 7.96669945e-02f, -1.00348564e-02f,
  -9.57840160e-02f, 1.79579128e-02f, 1.18590426e-02f, -1.15585484e-01f, 3.28398645e-02f, -2.36233976e-02f, -8.68661329e-03f, -4.83139642e-02f, 2.41815150e-02f, -5.70070930e-02f,
  -1.04694963e-01f, 3.74357012e-04f, -6.51085004e-02f, -3.70597392e-02f, -9.66297910e-02f, 2.15174239e-02f, -8.90253186e-02f, -1.47707267e-02f, -3.31637785e-02f, 5.26532270e-02f,
  -2.75058746e-02f, -9.54791531e-02f, -1.29112288e-01f, -1.21755153e-01f, -1.31688104e-03f, 6.39493242e-02f, -9.61654112e-02f, 6.82894886e-02f, -9.72172320e-02f, 9.02590379e-02f,
  3.28083755e-03f, 6.55408800e-02f, 1.19191511e-02f, -4.61919196e-02f, -9.00358558e-02f, 1.41025418e-02f, 3.00605260e-02f, -5.07177450e-02f, 1.17838886e-02f, -1.26322031e-01f,
  -8.23168084e-02f, -6.02619275e-02f, -1.39303818e-01f, -4.05101068e-02f, -6.82320446e-02f, -2.17685569e-03f, -9.29673947e-03f, -1.09669104e-01f, -6.97801113e-02f, 5.20140231e-02f,
  3.75142097e-02f, -9.84194279e-02f, 7.47545362e-02f, 1.52213089e-02f, -5.06953113e-02f, -1.00064337e-01f, -1.11179478e-01f, 2.23399512e-02f, -4.95951809e-02f, 6.66737044e-03f,
  3.20889689e-02f, -6.26871213e-02f, 1.08744549e-02f, 7.30653703e-02f, 1.03391983e-01f, -7.16166049e-02f, 1.26241744e-01f, 1.42299145e-01f, 3.09316367e-01f, 2.41341740e-01f,
  2.62062371e-01f, 8.47880468e-02f, 1.06694944e-01f, -2.09691122e-01f, 1.24206252e-01f, 1.84836537e-01f, -9.78449360e-03f, -4.46599245e-01f, -1.63736958e-02f, -4.46805768e-02f,
  2.77434569e-02f, -9.88046974e-02f, 7.11841360e-02f, -4.47558947e-02f, 3.20870467e-02f, -5.03417738e-02f, 9.87947509e-02f, 2.72837169e-02f, 2.53629446e-01f, -9.76186618e-02f,
  -3.16025168e-02f, 1.10245541e-01f, 1.27841145e-01f, -1.50031507e-01f, 1.05214283e-01f, 1.29337654e-01f, 1.10514071e-02f, 2.23673075e-01f, -1.00359581e-01f, 1.05439954e-01f,
  6.17206506e-02f, 2.82272268e-02f, 5.09345047e-02f, 7.21513703e-02f, 6.24142252e-02f, 1.14317387e-01f, 2.61082761e-02f, 1.51910201e-01f, 8.84492546e-02f, -1.05568729e-01f,
  -5.14112599e-02f, 1.38931438e-01f, 2.05397811e-02f, -1.05841748e-01f, 2.06577674e-01f, -5.54372109e-02f, 2.17210397e-01f, -1.65948927e-01f, 7.66204670e-02f, -5.73340356e-02f,
  -5.97175285e-02f, -8.73070583e-02f, 1.74920648e-01f, 3.63437412e-03f, -3.38904373e-02f, 3.57584320e-02f, -9.38741416e-02f, 1.90691710e-01f, -1.78176742e-02f, -1.35045469e-01f,
  3.50587577e-01f, -4.71922522e-03f, 2.14784607e-01f, 2.44414255e-01f, 1.26406953e-01f, 1.14404432e-01f, -1.72310054e-01f, -6.23396523e-02f, 2.66210645e-01f, 4.52631665e-03f,
  -2.33814925e-01f, -3.05319250e-01f, 3.74818146e-02f, -1.11616835e-01f, 8.74946564e-02f, -1.75437346e-01f, 7.28058144e-02f, -8.10690224e-02f, -1.14067666e-01f, 1.43123955e-01f,
  1.09461449e-01f, -1.12744391e-01f, -3.58300917e-02f, 7.59784380e-05f, 2.04052851e-01f, 3.40081519e-03f, 1.59418032e-01f, -4.34601232e-02f, 8.70552585e-02f, -1.24258354e-01f,
  -1.63209941e-02f, 1.80829003e-01f, 5.62472641e-02f, 1.40402973e-01f, -5.30482270e-03f, -8.19203332e-02f, 1.27547737e-02f, 2.10104853e-01f, 3.64300911e-03f, -8.50279853e-02f,
  1.08941302e-01f, -2.81154603e-01f, 1.18453324e-01f, 2.24077217e-02f, -1.57382358e-02f, 2.43578777e-01f, 1.06624916e-01f, 7.75566548e-02f, 1.30702332e-01f, 7.82877728e-02f,
  -1.01173766e-01f, -2.03391537e-02f, -3.05787567e-02f, 3.03740520e-02f, -3.96748707e-02f, 3.52046609e-01f, -1.38934582e-01f, 1.70986220e-01f, 7.88375810e-02f, 2.29657128e-01f,
  1.67809382e-01f, 2.23899465e-02f, -4.22918499e-02f, -1.50332913e-01f, 2.68525183e-01f, 1.50561258e-01f, -7.64287487e-02f, -5.61219938e-02f, 1.46629304e-01f, -3.91831659e-02f,
  -3.11201394e-01f, -1.28803074e-01f, -2.63148129e-01f, -7.49681666e-02f, 1.97371960e-01f, 3.79576623e-01f, 9.12677671e-04f, 1.10165395e-01f, -6.93184733e-02f, 3.98962557e-01f,
  -3.73499133e-02f, -1.09574549e-01f, 2.16631666e-01f, 2.38422364e-01f, 4.94707525e-02f, 2.09538922e-01f, -1.18910082e-01f, 7.31221493e-03f, -1.21203020e-01f, -2.19978448e-02f,
  7.56945834e-02f, -2.15630867e-02f, -8.96769539e-02f, -9.14666685e-04f, -2.44578905e-02f, 1.80544741e-02f, 1.26885362e-02f, -1.00235239e-01f, 1.92405835e-01f, -1.50626495e-01f,
  -3.73315066e-02f, -9.34908912e-02f, -7.42826611e-02f, -7.22239017e-02f, -1.27860278e-01f, 3.26214544e-02f, 3.16207334e-02f, 1.90164611e-01f, 5.50658591e-02f, -4.04958278e-02f,
  -1.74319610e-01f, -3.30947787e-02f, -8.77492949e-02f, -3.38494405e-02f, -3.37296538e-02f, 1.41870156e-01f, 5.47384433e-02f, 9.71723646e-02f, 4.51983809e-02f, -4.45991233e-02f,
  -5.02349548e-02f, -3.05543514e-03f, -9.77852568e-02f, 1.13304101e-01f, 7.45212063e-02f, 2.99236383e-02f, 1.37068048e-01f, 7.89373592e-02f, 3.21511775e-01f, 3.33292216e-01f,
  3.75976451e-02f, 1.34592399e-01f, 1.71128586e-01f, 1.42551169e-01f, -1.91177085e-01f, -3.18949930e-02f, -3.55929494e-01f, -2.69983768e-01f, 1.01674922e-01f, 1.18996091e-01f,
  -9.41349491e-02f, -1.48694411e-01f, -1.35483235e-01f, 1.87819704e-01f, 1.61831483e-01f, 8.14417899e-02f, 1.31524026e-01f, 2.16151968e-01f, -2.14976240e-02f, 1.40164271e-01f,
  2.06735089e-01f, 1.17500551e-01f, 8.41565058e-02f, -8.00864547e-02f, 1.22482881e-01f, 4.81082723e-02f, -1.29528284e-01f, -4.65394482e-02f, -1.69422686e-01f, -6.92486987e-02f,
  4.80092205e-02f, -3.14029981e-03f, 2.02082977e-01f, 3.13896202e-02f, 5.66982627e-02f, -1.75255438e-04f, 2.74792239e-02f, -1.77919313e-01f, -3.59733663e-02f, -7.63763636e-02f,
  -1.43951327e-01f, 1.55036598e-01f, -2.99707241e-02f, 1.14976615e-02f, -7.44746402e-02f, 1.03726603e-01f, 5.21193035e-02f, 2.09874392e-01f, 1.36012182e-01f, 4.68758605e-02f,
  -1.60732940e-02f, -9.70855653e-02f, -8.90757814e-02f, -5.11310250e-02f, -8.98389369e-02f, 1.58101723e-01f, -1.06208891e-01f, -3.53915319e-02f, -1.11085854e-01f, -9.23950970e-02f,
  1.79809153e-01f, 7.44826123e-02f, -1.19182065e-01f, -6.09366968e-02f, 2.38212496e-02f, -5.31319305e-02f, -8.84463638e-02f, 5.42391129e-02f, 1.21734120e-01f, -1.24219202e-01f,
  -1.50874391e-01f, 1.20776288e-01f, -4.15300354e-02f, -1.19938865e-01f, 6.67919545e-03f, -8.87903497e-02f, -2.86576543e-02f, -1.18459918e-01f, 8.85803998e-02f, 3.64897028e-02f,
  -8.96867961e-02f, 9.19692814e-02f, -2.24968921e-02f, -1.06493063e-01f, -1.02869183e-01f, -1.62079874e-02f, -7.85411149e-02f, -3.48731613e-04f, 7.73567259e-02f, -1.28206626e-01f,
  5.90633266e-02f, -1.01173528e-01f, 6.35004118e-02f, 8.24112445e-02f, 9.37050804e-02f, 2.62957048e-02f, 6.21081926e-02f, -1.19996063e-01f, 1.09129697e-01f, -6.21598326e-02f,
  -7.87891895e-02f, -9.62695479e-03f, 1.58414301e-02f, -2.01917347e-02f, 3.98156866e-02f, 8.50832090e-02f, -8.17643926e-02f, 1.38601772e-02f, 1.62412561e-02f, 2.94569917e-02f,
  9.62970592e-03f, -3.99005413e-02f, -5.80764897e-02f, 5.47073521e-02f, -9.36756283e-02f, 4.71845530e-02f, 9.79381502e-02f, -1.27194539e-01f, 2.77585313e-02f, 5.46474621e-05f,
  -4.97297421e-02f, -2.37748306e-02f, 8.62611905e-02f, -2.79450938e-02f, 1.41061649e-01f, -1.15386695e-01f, 1.95918992e-01f, 1.28626749e-01f, 5.54786623e-02f, 8.13394189e-02f,
  7.39694014e-02f, -4.24674153e-02f, 1.15562063e-02f, -2.30452776e-01f, -2.63147444e-01f, 2.18208954e-02f, 4.33956049e-02f, -1.69248745e-01f, -1.44837663e-01f, -7.82666579e-02f,
  -9.70785692e-02f, 1.53902605e-01f, 1.10149853e-01f, 9.23277959e-02f, -1.02991059e-01f, 1.35804921e-01f, 5.02952710e-02f, 1.50120005e-01f, 1.47977605e-01f, 8.44024792e-02f,
  -1.36822417e-01f, 5.26803844e-02f, 1.94044396e-01f, 1.25554278e-01f, 1.34792730e-01f, -8.45577121e-02f, -1.00449733e-01f, 1.12676367e-01f, 1.32594667e-02f, -9.56166536e-02f,
  1.29327968e-01f, 2.85392422e-02f, 7.02109002e-03f, 3.28380354e-02f, -1.30029425e-01f, -6.17923774e-02f, 1.93408951e-01f, 9.52961296e-02f, -3.64617482e-02f, 2.17260167e-01f,
  -6.25993237e-02f, -6.80013150e-02f, 1.97793990e-01f, -9.85483974e-02f, 1.17403969e-01f, 3.19802947e-02f, 1.96083393e-02f, 7.95544758e-02f, -6.00361191e-02f, 6.51971176e-02f,
  1.35612056e-01f, -2.32531294e-01f, 6.65044487e-02f, 1.23314798e-01f, 2.85709631e-02f, -1.35825112e-01f, 1.09435152e-03f, 2.43911743e-01f, 1.37840256e-01f, 6.45367578e-02f,
  -2.70087887e-02f, 1.62481144e-01f, 1.45890832e-01f, 1.94647774e-01f, 3.89283709e-02f, -1.00204132e-01f, -1.35793805e-01f, -1.20521709e-01f, -3.83812077e-02f, -1.22209042e-01f,
  -9.55034718e-02f, 1.37627244e-01f, -3.68165225e-02f, 1.41774923e-01f, -9.59278196e-02f, -7.05968589e-02f, -5.50938137e-02f, -6.05150238e-02f, 2.53793993e-03f, 1.46730855e-01f,
  -4.71692998e-03f, 8.93941149e-02f, -3.71765392e-03f, -3.57559249e-02f, -8.35717916e-02f, -4.98961024e-02f, 1.51090637e-01f, 8.86194184e-02f, -1.12279356e-01f, 4.18112101e-03f,
  -1.62680205e-02f, 8.33573341e-02f, 1.15876235e-01f, -7.21765086e-02f, 4.06565852e-02f, -8.54691193e-02f, 7.97768682e-03f, 1.25381919e-02f, -1.20496199e-01f, -6.78110644e-02f,
  5.21557257e-02f, -7.81942531e-02f, -3.29559818e-02f, -3.59038194e-03f, 1.26315802e-01f, 9.99475494e-02f, 2.26537660e-02f, 3.73567604e-02f, 4.06059921e-02f, -1.02955952e-01f,
  8.26151855e-03f, -8.98068920e-02f, 3.79238054e-02f, 3.09157353e-02f, 8.10221285e-02f, -9.75686237e-02f, -3.97716556e-03f, -1.16863161e-01f, -6.69927299e-02f, -8.18271339e-02f,
  5.93776330e-02f, 1.09507166e-01f, 4.94962819e-02f, 5.54534271e-02f, 1.79227386e-02f, 6.55916035e-02f, 7.57339895e-02f, -7.98422173e-02f, -8.48954022e-02f, 1.29287830e-02f,
  -2.14576408e-01f, 1.51699288e-02f, 4.31845104e-03f, 4.89084013e-02f, -6.71985745e-02f, 2.22118556e-01f, 8.46342668e-02f, 6.06742166e-02f, 8.50448012e-03f, 2.40966171e-01f,
  -1.01887882e-02f, 2.41597295e-02f, 2.10669637e-02f, 1.57160863e-01f, 1.39521956e-01f, -3.16810980e-02f, -1.42018097e-02f, 5.76684885e-02f, 4.59886044e-02f, -5.31751849e-02f,
  7.57222474e-02f, -3.39394957e-02f, -1.54462615e-02f, -5.33691682e-02f, -7.19289482e-02f, -3.06492299e-02f, -1.98428258e-02f, 3.13086510e-02f, 4.82325256e-02f, -1.53251007e-01f,
  3.83664034e-02f, -2.06716433e-02f, -5.05801477e-03f, -1.16274282e-01f, -7.21834451e-02f, 1.50750309e-01f, 1.51502952e-01f, -4.27231193e-02f, -9.46152732e-02f, 1.05706871e-01f,
  -7.21845180e-02f, 7.48741999e-02f, 1.03996068e-01f, -5.19223465e-03f, 9.58670527e-02f, 1.67853266e-01f, -3.61052044e-02f, 9.11176205e-03f, -2.29707696e-02f, 1.68186024e-01f,
  5.64481206e-02f, -1.71120260e-02f, -5.76555822e-03f, -4.36380059e-02f, 7.85428435e-02f, -4.73718308e-02f, 8.98713171e-02f, 8.13948810e-02f, 5.35227582e-02f, -9.30086821e-02f,
  -6.24197163e-02f, -1.06135882e-01f, 1.03348449e-01f, -9.15839300e-02f, 1.30389020e-01f, -5.72955571e-02f, -5.38578257e-02f, -6.00369945e-02f, 1.28054647e-02f, -1.69110239e-01f,
  -9.57827494e-02f, 1.97130255e-02f, 1.15573563e-01f, -1.15671881e-01f, -2.87562199e-02f, -2.14401931e-02f, -5.48685715e-02f, 6.77409917e-02f, -6.28269240e-02f, -9.28694904e-02f,
  2.19637379e-02f, 2.95192804e-02f, -1.70141738e-02f, -8.91267210e-02f, 6.42593056e-02f, 4.60964479e-02f, -8.40720758e-02f, 1.01853302e-03f, -2.48148968e-03f, 1.04011662e-01f,
  -8.44661370e-02f, 4.94810306e-02f, -1.13913864e-02f, 1.14992544e-01f, -3.55024189e-02f, -1.32813200e-01f, 1.13026358e-01f, 4.06146012e-02f, -7.41810203e-02f, 9.41926837e-02f,
  1.34236440e-01f, 8.23447928e-02f, -5.54631278e-02f, -2.43749414e-02f, 1.09131290e-02f, 1.36958927e-01f, 1.09184861e-01f, 9.59767401e-02f, -1.66838635e-02f, 3.58290188e-02f,
  -8.56102630e-02f, 9.71561000e-02f, 2.95645511e-03f, -1.12803586e-01f, -1.03396133e-01f, 1.07250541e-01f, 8.62851366e-02f, 7.44846389e-02f, -7.54562691e-02f, 1.17598757e-01f,
  3.98305282e-02f, 2.42604036e-02f, 1.96106024e-02f, 2.19600573e-02f, -2.83393115e-02f, 9.08923671e-02f, 9.22376290e-02f, -4.83492501e-02f, 1.45887956e-01f, 3.03943772e-02f,
  -1.51746660e-01f, -1.16668930e-02f, 8.66671577e-02f, 1.57125518e-01f, 1.33149460e-01f, 7.31771812e-02f, -1.07696399e-01f, 1.91457316e-01f, -7.10566947e-03f, 3.59718278e-02f,
  4.12526391e-02f, -8.72939359e-03f, 9.25707147e-02f, 2.02613741e-01f, 7.51812905e-02f, 8.59998353e-03f, -1.80430757e-03f, 2.54526455e-02f, -1.60526872e-01f, 1.00798070e-01f,
  -2.12256908e-02f, 1.46248698e-01f, -6.17096247e-03f, -4.42549065e-02f, 1.21672362e-01f, 8.69281869e-03f, 2.23622128e-01f, -1.01877123e-01f, -1.26386598e-01f, -3.39200255e-03f,
  -1.13363273e-01f, 6.14234544e-02f, -5.12874350e-02f, 1.40779078e-01f, 1.16297945e-01f, -7.92784318e-02f, 1.43647477e-01f, 6.10008538e-02f, -1.88374206e-01f, -8.24250802e-02f,
  6.91677779e-02f, -1.21965326e-01f, 2.48074029e-02f, 9.32312086e-02f, -1.22438923e-01f, -8.12275782e-02f, 5.78947272e-03f, -9.34065059e-02f, -6.06803000e-02f, -2.05470920e-02f,
  6.91763982e-02f, 1.10758901e-01f, -7.97420442e-02f, -1.53052762e-01f, 3.75213288e-02f, 1.04238488e-01f, 4.18782622e-01f, 4.57678616e-01f, 4.57795322e-01f, 2.09671900e-01f,
  3.35912049e-01f, 2.93434620e-01f, 3.52189720e-01f, 4.86340523e-01f, -8.44932273e-02f, 3.75230312e-01f, 3.15366983e-01f, -8.41968805e-02f, -1.37122646e-01f, 9.60084572e-02f,
  -4.00320776e-02f, 4.70777571e-01f, 2.40813658e-01f, 1.09332716e-02f, 7.40874857e-02f, 1.14278972e-01f, -1.07258350e-01f, 2.00580686e-01f, 9.14750919e-02f, 6.82509989e-02f,
  -7.36880973e-02f, 3.20059061e-01f, -1.90143079e-01f, 2.46697754e-01f, -3.63669731e-02f, 1.08569309e-01f, 2.39353523e-01f, 1.01660043e-01f, 9.30746347e-02f, -7.99614042e-02f,
  5.73004127e-01f, 1.80601597e-01f, 2.69734282e-02f, 1.10239126e-01f, 3.84350074e-03f, 1.46599412e-01f, -5.71034625e-02f, 4.34916347e-01f, 8.59614760e-02f, -2.83341426e-02f,
  6.88636005e-02f, -1.10382460e-01f, -1.03517301e-01f, -7.21004680e-02f, 1.57422703e-02f, -1.50247678e-01f, 9.50774476e-02f, 2.96747833e-01f, 4.38174531e-02f, -3.04330979e-02f,
  -1.88122150e-02f, -1.74870759e-01f, 3.69518064e-02f, -1.61641613e-01f, -1.65349141e-01f, -3.02561987e-02f, -1.60343468e-01f, -3.73098031e-02f, -3.78474779e-03f, 3.33227307e-01f,
  -1.80266313e-02f, 1.62894979e-01f, 2.81832248e-01f, 2.31592938e-01f, 2.52166241e-01f, 1.75572131e-02f, 2.56823570e-01f, 3.28510702e-01f, 6.06102832e-02f, -1.22773372e-01f,
  7.41555318e-02f, 1.89535081e-01f, 2.94233143e-01f, 2.28269964e-01f, -1.13674536e-01f, -6.51875464e-03f, -4.77583371e-02f, 2.57106200e-02f, -1.05641283e-01f, -2.12195933e-01f,
  -1.26471445e-02f, -9.85518917e-02f, 8.48579779e-02f, -2.18254961e-02f, 7.02184290e-02f, 7.53255188e-03f, -1.09591790e-01f, -9.91932538e-05f, -3.13059688e-02f, -3.71473543e-02f,
  2.34092698e-01f, -1.30825177e-01f, -1.74957246e-01f, -8.25231671e-02f, 2.37846356e-02f, 1.20371759e-01f, -1.01842266e-02f, 1.56279251e-01f, 9.34222788e-02f, 1.77833671e-03f,
  -1.38820514e-01f, 1.12194218e-01f, -2.15131164e-01f, -1.34442046e-01f, 2.72425801e-01f, 9.51259062e-02f, -1.61934599e-01f, -3.49077843e-02f, -1.08896820e-02f, -1.51744708e-01f,
  1.85649991e-02f, -9.27022994e-02f, 3.28731798e-02f, -3.33236121e-02f, -2.16620684e-01f, 2.82587588e-01f, -1.43148705e-01f, 1.03379115e-01f, 8.46197903e-02f, 3.27070802e-02f,
  1.79607332e-01f, -5.57097048e-02f, -1.77159026e-01f, 1.33435234e-01f, -2.20461283e-02f, -7.83753693e-02f, -1.11399733e-01f, 6.61468953e-02f, 5.60351200e-02f, -4.88825627e-02f,
  -1.54362582e-02f, -3.41018289e-02f, -5.98811917e-02f, -5.21993404e-03f, -1.35723338e-01f, 1.98023452e-04f, -2.38000825e-02f, 3.04282457e-02f, -6.92579746e-02f, -2.08210014e-02f,
  2.11137310e-02f, 8.55912045e-02f, 3.44093214e-03f, -4.88088429e-02f, 3.35302390e-02f, -1.13534303e-02f, -8.29748958e-02f, -4.62686867e-02f, 9.32129007e-03f, 4.47328351e-02f,
  1.24377437e-01f, -3.92874517e-02f, -7.17288256e-02f, -7.41627887e-02f, 8.49742144e-02f, -8.83319154e-02f, -1.11423679e-01f, -2.93162391e-02f, -7.64035210e-02f, 5.15019372e-02f,
  -6.33799434e-02f, 7.47560114e-02f, -9.28031653e-02f, -3.37552540e-02f, 9.48554724e-02f, -1.89595204e-02f, 5.76946698e-02f, -1.57397650e-02f, 5.73575348e-02f, -7.66965225e-02f,
  7.16904327e-02f, -7.28014857e-03f, -8.85859504e-02f, 1.26746431e-01f, -1.41338885e-01f, 1.00317374e-01f, 4.09804992e-02f, 1.48092940e-01f, -4.61664842e-03f, 1.39853075e-01f,
  8.14759657e-02f, -3.89231592e-02f, -4.87908088e-02f, -5.02550229e-02f, 1.16053589e-01f, 6.17378131e-02f, -1.16293564e-01f, -1.22361384e-01f, 9.63931903e-02f, 1.15635753e-01f,
  -5.41644990e-02f, 7.01289549e-02f, -5.13396375e-02f, 2.73693018e-02f, -9.83632542e-03f, -1.60842419e-01f, 4.85960656e-04f, 2.10059151e-01f, -1.00396566e-01f, -5.97726926e-02f,
  -1.66156441e-02f, 1.28592432e-01f, 7.84364417e-02f, 1.77057549e-01f, 8.84457678e-02f, 9.14686918e-02f, -6.92911223e-02f, 1.61307022e-01f, -1.03395237e-02f, 9.88352001e-02f,
  -1.02303058e-01f, 5.34544513e-02f, 1.05336763e-01f, -2.02611205e-03f, 3.38615067e-02f, 1.11808680e-01f, 1.27855510e-01f, 2.56469175e-02f, 4.26721238e-02f, 9.06917080e-02f,
  6.67388178e-03f, 2.29911674e-02f, 6.13426305e-02f, 2.91012861e-02f, -6.44307733e-02f, -3.19372639e-02f, -9.72994193e-02f, -1.00780405e-01f, 6.61012381e-02f, 5.74383419e-03f,
  1.83486447e-01f, 3.81288342e-02f, -1.26658067e-01f, 5.65709881e-02f, -8.73677433e-02f, 4.04449441e-02f, 5.21825850e-02f, 4.42027338e-02f, 1.06903270e-01f, 5.65893129e-02f,
  8.09372589e-02f, 2.32511219e-02f, 1.06501907e-01f, 1.26975300e-02f, -4.26488854e-02f, 3.30932476e-02f, -4.53063473e-02f, -5.14767878e-02f, 2.81934682e-02f, 1.04999565e-01f,
  -2.02723257e-02f, 6.65568635e-02f, 6.85982481e-02f, -2.24603550e-03f, 5.23936898e-02f, 9.15665403e-02f, 9.87384617e-02f, 7.63349533e-02f, 1.18720122e-02f, -1.44916952e-01f,
  3.64088774e-01f, 1.09719664e-01f, 9.81217548e-02f, 7.84366429e-02f, 4.96365167e-02f, -1.29659185e-02f, 1.17557816e-01f, -1.22444794e-01f, 2.83545591e-02f, -1.11921197e-02f,
  4.62393537e-02f, 1.48862183e-01f, 2.58814901e-01f, -1.33033678e-01f, -1.33157715e-01f, 6.97050393e-02f, 7.10447431e-02f, 3.03259902e-02f, 1.88293129e-01f, 1.59662902e-01f,
  4.46571745e-02f, -1.06639192e-01f, 1.24596857e-01f, 2.03568131e-01f, 7.87718669e-02f, 1.72451243e-01f, -7.63072446e-02f, -3.77677083e-02f, -5.38920835e-02f, 2.80854225e-01f,
  1.21074855e-01f, 1.46909043e-01f, -5.10128550e-02f, -4.23997156e-02f, -1.92644950e-02f, 1.08035102e-01f, -4.04177643e-02f, 3.62229884e-01f, -8.28409865e-02f, -1.40707791e-01f,
  6.76507736e-03f, 1.31368756e-01f, -9.46718231e-02f, -1.76678002e-01f, -6.05642647e-02f, -2.83332348e-01f, 1.09753527e-01f, 4.26144391e-01f, -1.77515775e-01f, 1.27067938e-01f,
  1.26711251e-02f, 1.85535073e-01f, 2.09466800e-01f, -2.07633059e-02f, -2.44822606e-01f, -1.51515514e-01f, -6.72698170e-02f, -1.93573758e-02f, 2.65377127e-02f, 6.81073591e-02f,
  -9.92982462e-02f, -4.48296145e-02f, 1.78978786e-01f, 7.28939846e-02f, 6.39595911e-02f, -1.03884965e-01f, -8.31873789e-02f, -1.35484338e-01f, 1.93042178e-02f, 9.22830552e-02f,
  8.76106843e-02f, 1.97280683e-02f, -9.55173820e-02f, 1.10999122e-01f, -6.75540343e-02f, -2.56348625e-02f, 2.49468796e-02f, -3.82125098e-03f, -1.69869270e-02f, -1.05233274e-01f,
  -8.25346410e-02f, 5.37704378e-02f, 1.26143605e-01f, 8.97814557e-02f, -6.87646642e-02f, 1.20154344e-01f, 4.85164933e-02f, 8.31126934e-04f, 3.06077953e-02f, -1.10987343e-01f,
  -3.63876559e-02f, 1.30659431e-01f, 7.45832101e-02f, 2.80459858e-02f, 5.61571345e-02f, 1.05889067e-01f, 6.19689934e-03f, 8.20614621e-02f, 5.02351001e-02f, -5.74199446e-02f,
  4.33745496e-02f, -1.05973119e-02f, -5.65817486e-03f, 1.11999966e-01f, -2.36100219e-02f, 2.65098941e-02f, -1.35752782e-01f, -1.02462940e-01f, 4.21352610e-02f, -9.41207036e-02f,
  -1.42190099e-01f, 3.21259932e-03f, -8.92727599e-02f, 6.65054694e-02f, 7.70509169e-02f, 7.53373802e-02f, 1.19349480e-01f, -1.48753777e-01f, -1.17371112e-01f, -2.40004882e-02f,
  1.50960594e-01f, 1.94197312e-01f, -5.53090591e-04f, 1.04448982e-01f, 1.79208428e-01f, 1.78268701e-01f, -2.94658076e-03f, 1.21139474e-02f, -3.03128362e-02f, -1.82662115e-01f,
  9.42850560e-02f, 1.80018738e-01f, 5.25669530e-02f, -2.87774149e-02f, 3.85075584e-02f, 2.58082539e-01f, -8.29921290e-02f, 6.08233586e-02f, 1.52700529e-01f, 8.56525749e-02f,
  4.31849919e-02f, 8.51044357e-02f, 4.45030965e-02f, -1.06784023e-01f, -8.97675306e-02f, 2.15509930e-03f, -1.50160611e-01f, -8.39151070e-02f, -7.25586787e-02f, -4.82673608e-02f,
  2.06839535e-02f, -1.46470934e-01f, 1.39074540e-02f, 4.74101342e-02f, 1.40304655e-01f, -4.28027138e-02f, -5.64954318e-02f, 6.76669180e-02f, -6.40842095e-02f, 5.57535142e-02f,
  -5.23415133e-02f, 1.18481547e-01f, -3.33126485e-02f, 5.39831221e-02f, 2.37645246e-02f, 4.39511007e-03f, -2.03458164e-02f, -1.26216887e-02f, -6.33023530e-02f, -3.63860466e-02f,
  9.01623815e-02f, 1.91662222e-01f, -2.99126636e-02f, 5.87990433e-02f, -8.43257234e-02f, 4.83858809e-02f, -5.80330566e-02f, -2.41412669e-02f, -4.69027683e-02f, -2.52887122e-02f,
  4.29449528e-02f, -6.15834855e-02f, 1.05947524e-01f, 5.92734925e-02f, 8.89432356e-02f, -8.17337185e-02f, 5.22968024e-02f, 1.57085180e-01f, 7.72094652e-02f, -3.42482701e-02f,
  4.03949022e-02f, -2.39580527e-01f, -1.37278646e-01f, -1.40398890e-01f, -1.40015900e-01f, -1.27849922e-01f, -2.93785986e-02f, -1.40604630e-01f, 1.23020455e-01f, -7.85957649e-02f,
  1.18097849e-01f, -4.34607044e-02f, 8.08307678e-02f, -8.61607715e-02f, 1.14480861e-01f, 8.39523077e-02f, 4.24011759e-02f, -1.18587784e-01f, 1.82494801e-02f, -2.59890519e-02f,
  -8.01884830e-02f, 4.13466841e-02f, 3.88171934e-02f, 4.39530835e-02f, 3.58696803e-02f, -4.67109457e-02f, -8.29130225e-03f, 1.13120444e-01f, -4.67372499e-02f, -3.76784429e-03f,
  1.88402995e-01f, 1.23889819e-01f, 1.13906741e-01f, 9.48829278e-02f, 4.39258739e-02f, -1.23370282e-01f, 1.56549755e-02f, 7.43498132e-02f, 3.13316137e-02f, 1.50583208e-01f,
  7.09897205e-02f, 2.36656833e-02f, 6.00238368e-02f, 1.16685145e-01f, 4.85193729e-02f, -8.53905827e-02f, 3.09468787e-02f, 1.68484777e-01f, -1.01190753e-01f, -9.92367566e-02f,
  1.13851659e-01f, 7.87820742e-02f, 4.59868833e-02f, -4.61647287e-03f, 7.03873932e-02f, -1.52055891e-02f, 6.77965060e-02f, -9.69362706e-02f, 1.30483657e-01f, -2.26758067e-02f,
  5.33072390e-02f, 1.91138417e-01f, 7.74512514e-02f, 1.74356475e-02f, 2.10022181e-01f, 2.24645406e-01f, 9.69664752e-02f, -1.06663637e-01f, 1.60748139e-01f, -3.60430479e-02f,
  -7.99337476e-02f, 1.30053356e-01f, -7.03803357e-03f, 3.78528633e-03f, 1.75901413e-01f, 5.12236683e-03f, 4.56619374e-02f, 7.49969482e-02f, -1.25114881e-02f, 4.07394068e-03f,
  -3.39478180e-02f, 1.34157255e-01f, -3.43962684e-02f, 9.77336392e-02f, -9.27699655e-02f, -1.90030802e-02f, 6.48286641e-02f, 2.44203005e-02f, 5.87116294e-02f, 1.32855669e-01f,
  5.95089123e-02f, 1.00429066e-01f, 1.26363516e-01f, 8.15835297e-02f, -3.30643915e-03f, 7.47521594e-02f, 1.28825456e-01f, 4.23709340e-02f, 6.01704232e-03f, 1.44146839e-02f,
  -1.23917900e-01f, 1.08889919e-02f, 1.78153425e-01f, -1.63417291e-02f, 8.38612169e-02f, -6.17138483e-02f, -1.52208582e-02f, 1.07690595e-01f, -7.97568783e-02f, -2.53550038e-02f,
  -1.13273159e-01f, -1.08570330e-01f, 5.83685115e-02f, 9.53028202e-02f, -1.25514120e-01f, -2.29745675e-02f, 7.68376216e-02f, 1.53192714e-01f, 1.39544278e-01f, -1.40993549e-02f,
  -7.20808655e-02f, 1.79731250e-02f, 2.25900531e-01f, 5.16536534e-02f, 6.18837960e-02f, 1.37127146e-01f, -7.04620853e-02f, 3.98503616e-02f, -1.24175385e-01f, 3.73421200e-02f,
  5.32433614e-02f, -1.20784519e-02f, 1.30365208e-01f, 1.42344221e-01f, -1.17778458e-01f, 1.71671525e-01f, -3.41539755e-02f, 1.75222859e-01f, 8.66080672e-02f, 2.59449836e-02f,
  1.32801101e-01f, -5.26801758e-02f, -1.22581013e-01f, 3.56265083e-02f, 9.69380364e-02f, -3.72620625e-03f, 2.29116762e-04f, 6.29398646e-03f, -9.20120999e-02f, 1.80796962e-02f,
  -3.28754820e-03f, 2.72452086e-02f, -1.52372062e-01f, -3.83213162e-02f, -8.67519826e-02f, 1.31100491e-02f, 1.59001753e-01f, -3.06314975e-02f, -2.50762552e-02f, 2.49616504e-02f,
  -4.11007507e-03f, -6.59521073e-02f, -4.62408289e-02f, 2.42476955e-01f, 1.35967970e-01f, -8.20425600e-02f, -8.10435880e-03f, -7.60979876e-02f, 1.38700292e-01f, -1.17762975e-01f,
  -1.32277399e-01f, 9.48519036e-02f, 2.41352275e-01f, 8.79796818e-02f, 2.63294540e-02f, 7.11932331e-02f, -3.99099551e-02f, -2.10469533e-02f, 1.37996614e-01f, 3.91049311e-02f,
  -1.26650790e-04f, -8.94191265e-02f, -1.42716229e-01f, 1.65840968e-01f, 1.16552755e-01f, 2.43199855e-01f, 4.95618917e-02f, 1.71374962e-01f, 1.50535375e-01f, 1.01218015e-01f,
  -4.58656028e-02f, 1.09713778e-01f, -1.30249128e-01f, -1.43230096e-01f, -4.08641621e-02f, 1.35251945e-02f, 9.65040550e-02f, -3.45971175e-02f, -1.32811904e-01f, -5.92355877e-02f,
  -4.59364355e-02f, -1.17067657e-01f, -1.15790972e-02f, 4.53470685e-02f, -5.55227064e-02f, -4.39593382e-03f, 1.47498921e-01f, 1.38144970e-01f, 1.30023137e-01f, 8.56393799e-02f,
  8.77157375e-02f, 4.53134626e-02f, 1.89601347e-01f, 1.77647665e-01f, -1.06969383e-02f, -1.05093531e-01f, 5.94095401e-02f, 2.66745627e-01f, -1.06372960e-01f, -8.37322921e-02f,
  1.26692683e-01f, 4.42955308e-02f, -8.12115744e-02f, 5.65020889e-02f, -9.84518901e-02f, 3.76233608e-02f, 1.27840400e-01f, -1.83716957e-02f, 6.27467260e-02f, 1.40771955e-01f,
  -1.13459185e-01f, 1.14850409e-01f, 2.00439081e-01f, 1.20481551e-02f, -7.61575550e-02f, -2.39234883e-02f, -2.50245295e-02f, -8.51973146e-02f, -4.82089520e-02f, -3.07285618e-02f,
  7.84731358e-02f, -8.00053105e-02f, 1.49350554e-01f, 1.24313146e-01f, 3.69136781e-02f, 7.36781880e-02f, -1.68530736e-02f, -1.38129685e-02f, 9.55798328e-02f, -1.29013658e-01f,
  6.24026619e-02f, 2.02286378e-01f, -1.68594311e-03f, 2.82712784e-02f, 3.93971847e-03f, -1.38690516e-01f, -2.75849968e-01f, -1.00823298e-01f, 5.81669845e-02f, 1.37057513e-01f,
  3.90435825e-03f, 2.92538166e-01f, -1.57862425e-01f, 3.09123136e-02f, 2.08813455e-02f, 3.28381062e-01f, 2.31251810e-02f, 1.49279227e-02f, 8.63756388e-02f, 1.16194837e-01f,
  4.12976220e-02f, 1.75767243e-01f, 1.62787154e-01f, -6.34937584e-02f, -6.50751889e-02f, -1.32269099e-01f, 1.21722378e-01f, -2.87555493e-02f, -2.38646232e-02f, 5.74421398e-02f,
  -9.81667414e-02f, 6.08535446e-02f, -7.95074254e-02f, -8.97595733e-02f, 1.56433448e-01f, -9.62181687e-02f, -6.25367388e-02f, -8.15920457e-02f, 8.98484141e-02f, 5.10466881e-02f,
  4.96366732e-02f, 2.79656559e-01f, 5.64075373e-02f, 8.02507401e-02f, 3.11780758e-02f, 8.41392726e-02f, 1.51089787e-01f, -1.43592265e-02f, -4.00015488e-02f, -4.69105467e-02f,
  1.82526097e-01f, 3.13066244e-02f, -6.20922185e-02f, -4.17327173e-02f, 1.45995706e-01f, 1.46349249e-02f, 7.36294910e-02f, -1.30512327e-01f, -1.73697826e-02f, -1.41702816e-01f,
  -1.12968773e-01f, -3.00558750e-02f, -1.16042301e-01f, 8.13695639e-02f, 9.54528525e-02f, -5.76844066e-02f, 6.84773624e-02f, 2.02111989e-01f, 2.45580524e-01f, -3.71085890e-02f,
  -1.74113184e-01f, -7.73966238e-02f, 2.55839467e-01f, 2.40367763e-02f, -2.10081384e-01f, -3.19774628e-01f, -1.42293340e-02f, -1.36916742e-01f, -6.96343482e-02f, -1.46636739e-01f,
  -1.00638554e-01f, -2.44197696e-02f, 5.53930625e-02f, -1.22782253e-01f, -7.86157325e-02f, -1.81765091e-02f, -1.38026804e-01f, -9.38217193e-02f, 6.47931844e-02f, -1.45377517e-02f,
  2.02459902e-01f, -1.25702664e-01f, 4.45321761e-02f, -3.80525514e-02f, -6.22894429e-02f, 1.27206132e-01f, 9.35370550e-02f, -5.07405552e-04f, -2.03521699e-01f, -2.15760618e-02f,
  1.38156325e-01f, 1.83747455e-01f, 7.01707229e-02f, -4.13726345e-02f, -1.01383820e-01f, -1.53657168e-01f, 3.36198844e-02f, -1.71509266e-01f, -5.67787029e-02f, 3.00510913e-01f,
  9.56932753e-02f, 5.01313172e-02f, 1.42512456e-01f, 1.16387151e-01f, -1.28327176e-01f, -9.06996876e-02f, 7.02287778e-02f, -1.45019576e-01f, -8.83030817e-02f, 3.55649382e-01f,
  -1.04829431e-01f, 6.91912994e-02f, 2.30222233e-02f, 8.46883506e-02f, 1.70030128e-02f, 3.84542048e-02f, -8.15598071e-02f, -1.04518563e-01f, -1.05614280e-02f, 3.18911485e-02f,
  1.26426548e-01f, 1.01584189e-01f, 1.09388255e-01f, 6.94126040e-02f, 6.83112517e-02f, 2.15033665e-01f, -1.91026181e-02f, 1.96591336e-02f, -7.97123124e-04f, 5.51380683e-03f,
  8.94004554e-02f, 8.98650065e-02f, -5.22112399e-02f, 1.04339287e-01f, 2.62032002e-02f, 7.95168951e-02f, -1.08135931e-01f, -2.46554464e-02f, -1.15784533e-01f, 3.03445235e-02f,
  1.21140713e-02f, 4.83616851e-02f, -3.97904068e-02f, 9.01335850e-02f, -6.69897422e-02f, -6.31422922e-02f, -4.58152778e-02f, -7.49401972e-02f, 9.91545543e-02f, 6.24097288e-02f,
  2.43742578e-03f, -8.19049180e-02f, 8.37948993e-02f, -7.38692805e-02f, 5.23260385e-02f, -1.32191733e-01f, -2.27422696e-02f, 1.64690897e-01f, -7.32485652e-02f, 2.30691731e-01f,
  8.37860852e-02f, -5.33039682e-02f, 2.81978063e-02f, -1.13224603e-01f, 9.91980806e-02f, -5.95899001e-02f, -8.92598107e-02f, -1.02307592e-02f, 1.06690109e-01f, 3.19303013e-02f,
  6.22079968e-02f, -1.06717274e-01f, -1.52571633e-01f, -2.75804661e-02f, 7.34331384e-02f, -1.48825258e-01f, -1.14586696e-01f, -1.44402549e-01f, 1.34290736e-02f, 6.36710301e-02f,
  -1.75398383e-02f, 2.08170880e-02f, -1.13074891e-01f, 7.16039464e-02f, 2.39037797e-01f, 7.22101182e-02f, 1.13667607e-01f, 1.42439440e-01f, 3.69080901e-01f, 1.47065565e-01f,
  -1.09768726e-01f, -1.56511277e-01f, 3.06465067e-02f, -1.59562096e-01f, 4.48196344e-02f, -1.82931144e-02f, 5.34433760e-02f, -5.90669224e-04f, 1.57862484e-01f, 1.34927958e-01f,
  -4.27584536e-02f, -1.09229177e-01f, 1.37595370e-01f, -4.40536328e-02f, -2.87188888e-02f, 1.90542936e-02f, -7.98700601e-02f, 7.92785808e-02f, 6.81615174e-02f, -1.34945631e-01f,
  6.50439039e-02f, -6.82866871e-02f, 2.42128938e-01f, 1.91329956e-01f, -1.30932882e-01f, -2.14272346e-02f, 1.15281343e-01f, 1.86379388e-01f, 1.85178325e-01f, 8.23906735e-02f,
  1.95047870e-01f, 1.33660227e-01f, -3.47677199e-03f, 1.58585235e-01f, -1.57169551e-01f, 7.61140138e-02f, -7.18649924e-02f, 6.89195096e-02f, 1.79094404e-01f, -4.70931977e-02f,
  7.09944516e-02f, -1.11688755e-01f, 1.40188057e-02f, -5.76138794e-02f, -7.44093284e-02f, 1.06741227e-01f, 1.28078526e-02f, -1.98909894e-01f, 1.07499428e-01f, 1.31246850e-01f,
  1.01196013e-01f, 1.04383320e-01f, -1.40170055e-02f, -6.81696162e-02f, 1.45652369e-01f, 2.00450048e-02f, 2.33075559e-01f, 1.71346143e-01f, 1.13462001e-01f, 1.78807497e-01f,
  -4.28198427e-02f, -1.48975421e-02f, 1.86342485e-02f, 6.91585764e-02f, -4.58609238e-02f, -3.66986506e-02f, -1.89142358e-02f, -4.94211279e-02f, -6.44029900e-02f, 1.42663434e-01f,
  1.09604493e-01f, 1.38022363e-01f, -2.98951138e-02f, 9.83693823e-02f, 1.60821274e-01f, 1.31300122e-01f, -1.42332613e-02f, 7.64849335e-02f, -5.08110784e-02f, -1.37646394e-02f,
  7.27461278e-02f, -5.44347204e-02f, 9.06935409e-02f, 1.96141899e-01f, -2.25567282e-03f, 7.14684501e-02f, 3.52304392e-02f, -3.39865312e-02f, -5.91036752e-02f, 1.40631333e-01f,
  2.80324012e-01f, 4.47422080e-02f, -1.26662761e-01f, 1.84551831e-02f, 6.55477121e-02f, 1.17019331e-02f, -5.36325537e-02f, 9.71073564e-03f, 1.53745413e-01f, 1.52827054e-01f,
  -1.17611825e-01f, 1.97756231e-01f, -1.14811316e-01f, -4.48812917e-02f, -1.17106706e-01f, -6.35168701e-02f, 2.33150627e-02f, -3.41630131e-02f, 2.80772448e-02f, 1.20632211e-03f,
  5.31505123e-02f, 2.63081759e-01f, -1.66952953e-01f, -7.83866793e-02f, 5.78589737e-02f, 1.35980010e-01f, -2.42515262e-02f, 4.85370343e-04f, -5.08083515e-02f, 1.64173543e-01f,
  -1.31283514e-02f, 5.25361253e-03f, 4.53037769e-02f, -1.13783874e-01f, -6.13895580e-02f, 2.82474011e-02f, 1.68087795e-01f, 8.42078775e-02f, 3.37400809e-02f, 1.77131787e-01f,
  9.40071512e-03f, 1.49558149e-02f, -1.30257040e-01f, 1.43236920e-01f, -1.37943523e-02f, 7.34791439e-03f, 1.19963460e-01f, -1.13623284e-01f, -8.99159014e-02f, 4.75236028e-03f,
  -7.74578750e-02f, -2.30220575e-02f, -7.71517605e-02f, -2.39803307e-02f, -3.07887443e-03f, 1.33152217e-01f, 7.18794465e-02f, 2.09984764e-01f, 3.30782891e-03f, 7.73698390e-02f,
  1.88281864e-01f, 1.29369095e-01f, 3.51722389e-02f, -1.00664198e-01f, 1.38240337e-01f, -9.72372591e-02f, -1.04453033e-02f, 1.05833188e-02f, -1.26924932e-01f, 1.51382744e-01f,
  -5.87018169e-02f, 1.03480659e-01f, -5.93640916e-02f, -5.32599762e-02f, -8.07334781e-02f, 5.60413301e-02f, -8.14795867e-02f, 8.40125754e-02f, -8.31933245e-02f, -7.28964210e-02f,
  -1.83908213e-02f, -1.03907481e-01f, -2.49835607e-02f, -4.51611169e-02f, 5.02305590e-02f, -5.52408509e-02f, -1.50422409e-01f, 1.02457367e-01f, -5.43404743e-02f, -1.06907263e-01f,
  -6.88474700e-02f, 1.67105142e-02f, 1.08237103e-01f, -1.09994650e-01f, -4.84394692e-02f, 8.75502005e-02f, 1.30126020e-03f, 3.54492143e-02f, -4.74321470e-02f, -6.62365332e-02f,
  -6.35670451e-03f, 8.79940391e-02f, -5.42607307e-02f, -1.46665484e-01f, 5.84361702e-02f, 1.27100587e-01f, 1.38228431e-01f, -5.94251156e-02f, -8.58444069e-03f, 3.38092819e-02f,
  7.16044661e-03f, 1.20296344e-01f, 2.38019526e-02f, 9.40759927e-02f, -6.02433039e-03f, 9.52906758e-02f, -4.78781536e-02f, 9.93773807e-03f, -5.84813617e-02f, 7.97505602e-02f,
  -8.46712813e-02f, 9.96610001e-02f, -2.33334564e-02f, 9.72020179e-02f, -8.00045878e-02f, -7.01008663e-02f, -3.16612683e-02f, 1.92576591e-02f, -9.04197320e-02f, -7.48692155e-02f,
  -5.27491793e-02f, -1.12011507e-01f, 2.28108782e-02f, -1.03655858e-02f, -1.34341260e-02f, -4.51381616e-02f, -6.31273538e-02f, -2.85437480e-02f, 1.14476338e-01f, 7.26542175e-02f,
  -1.54888213e-01f, 9.06131566e-02f, -2.57284213e-02f, -8.45437199e-02f, 1.96324028e-02f, 1.81681737e-02f, -1.03504524e-01f, 6.05098531e-03f, -1.01833925e-01f, -1.08330958e-01f,
  1.63813471e-03f, 6.61113858e-02f, 9.12760124e-02f, -3.03794388e-02f, 8.80763903e-02f, -1.23791449e-01f, -8.88720229e-02f, -5.74107841e-02f, -7.45731667e-02f, -1.36945710e-01f,
  9.68437120e-02f, 2.33053621e-02f, -1.10028520e-01f, 1.34377815e-02f, 1.92945711e-02f, 1.78596184e-01f, 1.83673307e-01f, 1.59900859e-02f, 1.00932099e-01f, -1.20980129e-01f,
  -1.32217422e-01f, -7.97482878e-02f, 5.38015887e-02f, 2.40247184e-03f, 6.35061339e-02f, 5.35015017e-03f, 6.78042276e-03f, 1.23098679e-01f, 2.16654599e-01f, -9.03639793e-02f,
  -7.77724236e-02f, -4.36871164e-02f, -5.35530858e-02f, 6.03486672e-02f, -4.03188961e-03f, 1.43773139e-01f, 7.22300038e-02f, 9.21090841e-02f, 1.14099998e-02f, 2.06054121e-01f,
  -5.79815172e-02f, 8.53707865e-02f, -1.01413622e-01f, 6.90481346e-03f, -5.34014069e-02f, -1.72365811e-02f, 3.38806733e-02f, 2.59132199e-02f, -1.91471949e-02f, -4.08116076e-03f,
  -4.24804725e-02f, 7.59183764e-02f, -9.42528024e-02f, 1.54351160e-01f, 7.55736530e-02f, 1.84475854e-02f, -5.03153773e-04f, 1.01485007e-01f, -1.32881790e-01f, 6.04247600e-02f,
  7.90026933e-02f, 5.70654087e-02f, 5.78592066e-03f, -1.13714207e-02f, 4.66356892e-03f, -4.24700268e-02f, 1.53915152e-01f, 1.33394793e-01f, -4.95599769e-03f, -1.01992659e-01f,
  1.66380983e-02f, 1.63270393e-03f, -9.43079125e-03f, 6.97704256e-02f, 1.37488246e-01f, -1.29095381e-02f, 9.91440192e-03f, -2.74249334e-02f, -1.47553504e-01f, -8.86104107e-02f,
  -1.14396065e-01f, 2.87233405e-02f, 1.05814740e-01f, 1.24484971e-01f, -9.49055627e-02f, -2.71088611e-02f, -1.28302917e-01f, 1.44610777e-01f, -9.76487026e-02f, -6.64425269e-02f,
  5.83120249e-03f, 4.76096570e-02f, -9.17810798e-02f, 9.46770385e-02f, -1.60936732e-02f, -4.32531089e-02f, 5.43140061e-02f, 1.06267504e-01f, 3.42282541e-02f, 9.81988162e-02f,
  7.64327347e-02f, 1.04019128e-01f, -4.50193994e-02f, 8.60491171e-02f, 6.48628222e-03f, -1.17519811e-01f, 1.80430427e-01f, -1.42654061e-01f, -2.40602512e-02f, -3.94945592e-02f,
  -1.23269513e-01f, -5.89920916e-02f, 6.63773343e-02f, 2.87110712e-02f, 1.25483990e-01f, 1.21810041e-01f, 1.30353153e-01f, -7.76191661e-03f, 4.98959832e-02f, -4.66219299e-02f,
  8.86477996e-03f, 9.88999754e-02f, -5.33877052e-02f, 1.11068390e-01f, 6.69208169e-02f, 1.44520849e-01f, -2.39317142e-03f, 6.51003793e-02f, 3.93599197e-02f, -1.37272850e-01f,
  -1.10799558e-01f, -1.31121874e-01f, -2.30575968e-02f, 9.00548697e-03f, 1.97340343e-02f, -7.44425580e-02f, -2.99852788e-02f, 8.03190097e-02f, -3.85297649e-02f, 1.54118195e-01f,
  4.66328859e-02f, 3.61028546e-03f, -8.50489438e-02f, 3.74098867e-02f, -1.78518280e-01f, -1.08711002e-02f, 1.58425607e-02f, 8.62129852e-02f, -1.35675266e-01f, -1.13716237e-01f,
  1.69506501e-02f, -1.05603285e-01f, 1.69774983e-02f, -6.24980740e-02f, -3.71298147e-03f, 1.67603478e-01f, 1.44777387e-01f, 4.09727469e-02f, 9.59320739e-02f, 1.94936059e-02f,
  9.58720967e-02f, -3.46767679e-02f, -1.10831931e-02f, 5.11365645e-02f, 4.38857563e-02f, 1.24759801e-01f, -1.04757674e-01f, 7.60374293e-02f, 8.86272565e-02f, 1.70304105e-02f,
  -3.33620235e-02f, 1.16754279e-01f, 1.10311128e-01f, 1.47021309e-01f, -1.41047940e-01f, -2.09041755e-03f, 4.34004664e-02f, 1.82666872e-02f, 3.19042467e-02f, 1.07212730e-01f,
  5.39498366e-02f, 3.23269740e-02f, 1.76406145e-01f, -1.15673535e-01f, -1.00911349e-01f, 1.02679886e-01f, -1.52554572e-01f, 1.38988629e-01f, -1.18441947e-01f, -8.34165365e-02f,
  1.00041419e-01f, -1.76289126e-01f, 1.22474268e-01f, 1.65746719e-01f, 8.73136744e-02f, 1.40851319e-01f, -4.72164117e-02f, -7.03306571e-02f, 6.91260472e-02f, -1.01442738e-02f,
  2.21407220e-01f, 2.41142914e-01f, 1.85238540e-01f, 1.99139882e-02f, -3.49788088e-03f, 1.69768125e-01f, -9.77913383e-03f, -6.80676922e-02f, -1.81217149e-01f, -8.94326121e-02f,
  1.41966000e-01f, 1.72975734e-01f, -6.72347769e-02f, 9.63182300e-02f, 4.31495905e-02f, -4.13963795e-02f, 5.62194958e-02f, -1.26167327e-01f, 2.77585126e-02f, 1.70099169e-01f,
  6.98083490e-02f, 1.30348548e-01f, 9.08739045e-02f, 6.84318617e-02f, -4.58812341e-02f, -1.87319908e-02f, 1.63497150e-01f, 7.48993456e-03f, -5.52699678e-02f, 1.39918253e-01f,
  1.62768550e-02f, -8.27781335e-02f, 7.86222294e-02f, 6.85464889e-02f, 4.49565314e-02f, -5.60673922e-02f, -4.73959222e-02f, -6.18758574e-02f, -5.75858355e-02f, -1.47825956e-01f,
  4.84216250e-02f, -7.17094690e-02f, 4.32260372e-02f, 6.59264922e-02f, 1.58195943e-01f, 1.25964517e-02f, -3.02629415e-02f, -3.55977938e-02f, -1.77858204e-01f, 5.91565445e-02f,
  -6.77692667e-02f, 1.01183735e-01f, 4.56665605e-02f, -9.72754657e-02f, 1.20567076e-01f, -3.88621800e-02f, 4.83680591e-02f, 2.23664232e-02f, 6.92011490e-02f, 1.15061656e-01f,
  -5.85464165e-02f, -7.57757053e-02f, 2.16271020e-02f, -4.67618629e-02f, 1.46141589e-01f, 1.67582944e-01f, 4.42635641e-02f, 2.48896959e-03f, -6.75448552e-02f, -7.74937170e-03f,
  2.08088383e-01f, -1.30926985e-02f, -9.33709741e-02f, 1.32245978e-03f, 1.56671807e-01f, -2.08808705e-01f, -7.56227151e-02f, 9.94209722e-02f, -1.40458038e-02f, -2.31104903e-02f,
  1.99305236e-01f, 3.02870497e-02f, -4.90892418e-02f, -9.30349827e-02f, 8.83466303e-02f, 7.37839192e-02f, 1.49076551e-01f, -1.00812510e-01f, 7.79284677e-03f, -8.14764574e-03f,
  -2.42074654e-02f, 1.69421285e-01f, -6.02109544e-02f, -4.89161536e-02f, -3.10312603e-02f, 1.53004616e-01f, -1.42531097e-01f, -1.14887111e-01f, 6.16703294e-02f, 3.16076316e-02f,
  6.94991052e-02f, 1.05348207e-01f, 1.08160421e-01f, 9.92121473e-02f, 1.61158383e-01f, -2.59755254e-02f, 8.75666514e-02f, 9.93374661e-02f, 2.44901180e-02f, -1.61134079e-01f,
  3.81575823e-02f, 1.07711025e-01f, -3.60004529e-02f, -6.70654923e-02f, 2.37627793e-03f, -8.68728757e-02f, -1.06695861e-01f, 1.16552748e-01f, -1.02546416e-01f, -1.90982014e-01f,
  -9.96076688e-02f, -1.72341354e-02f, 8.34872201e-02f, -3.09618041e-02f, 3.74289714e-02f, -2.15438027e-02f, 4.23791222e-02f, 1.53187349e-01f, 6.75458238e-02f, 1.15616128e-01f,
  1.79948285e-01f, 1.51468754e-01f, 1.14835678e-02f, -2.45599486e-02f, 1.04515061e-01f, 8.97657946e-02f, -1.62454084e-01f, 8.44172761e-02f, -1.06194645e-01f, -1.49748072e-01f,
  -8.72545764e-02f, 9.22582671e-03f, 1.44970110e-02f, -3.15773077e-02f, 1.81945339e-01f, 1.28401518e-01f, -4.54211310e-02f, -9.10829604e-02f, 6.98770508e-02f, -8.28920230e-02f,
  1.30543903e-01f, -7.01226220e-02f, -7.16266558e-02f, 1.34112954e-01f, 1.25294598e-03f, -3.57629657e-02f, 1.38878018e-01f, 8.16308782e-02f, -6.22694641e-02f, -9.22249332e-02f,
  -1.28315026e-02f, -1.47132456e-01f, 6.66869655e-02f, -1.07142739e-02f, 7.90606067e-02f, 2.86464691e-02f, 6.67378074e-03f, -1.02876022e-01f, 1.26864135e-01f, 1.25865370e-01f,
  9.82050598e-02f, 1.03333935e-01f, -3.81768234e-02f, 2.16703322e-02f, 1.11139856e-01f, 3.52637507e-02f, 1.02745317e-01f, -1.07397623e-01f, 1.48826584e-01f, 3.27623263e-02f,
  1.51468161e-02f, -3.19091305e-02f, -4.01686598e-03f, -7.28925020e-02f, 8.54479586e-05f, 9.98478010e-03f, 9.02066901e-02f, -1.96886025e-02f, -9.86121446e-02f, -2.00215746e-02f,
  3.91633660e-02f, -8.42933655e-02f, -6.86303293e-03f, -7.80630037e-02f, -8.84275213e-02f, -9.16600004e-02f, 6.36554584e-02f, 1.02656163e-01f, 2.91091111e-02f, 9.77899730e-02f,
  1.21196464e-01f, 1.06303751e-01f, 9.23659652e-02f, 1.27971441e-01f, 5.21125719e-02f, 2.78580189e-03f, -4.96077202e-02f, -6.16347082e-02f, 1.18175395e-01f, 3.55525203e-02f,
  8.40152949e-02f, -9.00223013e-03f, 1.94451198e-01f, -1.49379279e-02f, -5.71968257e-02f, 4.04252000e-02f, 3.20277177e-02f, 1.73505217e-01f, -7.50715798e-03f, 1.09648794e-01f,
  -2.11363994e-02f, 8.75936970e-02f, 2.41162535e-02f, 1.54188752e-01f, -1.86682697e-02f, -4.38851975e-02f, 1.28977284e-01f, -4.91052903e-02f, 9.32655558e-02f, 1.70180872e-01f,
  -2.87998263e-02f, 6.57219291e-02f, 2.11244356e-02f, 1.48508683e-01f, -5.09668933e-03f, 8.76882896e-02f, -1.26489386e-01f, 1.45748571e-01f, 6.14924207e-02f, -1.07159074e-02f,
  -3.72951366e-02f, 1.07854426e-01f, -5.31529728e-03f, 1.16820246e-01f, 1.97627135e-02f, -7.92093948e-02f, 1.31573491e-02f, 8.20738822e-02f, 1.00415118e-01f, -8.46289545e-02f,
  1.55496210e-01f, -4.30444963e-02f, 1.02914348e-01f, 8.83919150e-02f, 1.15949707e-02f, 9.40860212e-02f, 1.87218100e-01f, -2.00538170e-02f, 1.77619308e-01f, 1.88859105e-01f,
  1.50844425e-01f, 1.08482957e-01f, -2.93560065e-02f, -2.07474262e-01f, 3.16851549e-02f, -1.12151742e-01f, -1.40814453e-01f, 1.75090246e-02f, -3.77434194e-02f, 3.44131328e-02f,
  5.99413887e-02f, 6.18039109e-02f, 9.97822136e-02f, -5.44594675e-02f, 5.86223304e-02f, -1.09169096e-01f, -1.47966206e-01f, 1.02451906e-01f, 4.03967872e-02f, 1.08683161e-01f,
  3.62192839e-02f, 5.56522869e-02f, -7.76304528e-02f, 6.43920898e-02f, 1.07369527e-01f, -1.12346830e-02f, -1.25982553e-01f, 1.08774573e-01f, -6.89823180e-02f, -2.94632409e-02f,
  8.89887661e-03f, -1.12013511e-01f, 1.25118881e-01f, -9.64569151e-02f, 1.27258271e-01f, 1.91330966e-02f, 8.89003798e-02f, 3.49542052e-02f, 1.26503631e-01f, 6.69749305e-02f,
  -1.64906800e-01f, 8.87188595e-03f, -9.35042575e-02f, -2.49897037e-02f, 1.62784711e-01f, 7.12475106e-02f, 7.38285109e-02f, 1.01169556e-01f, -9.93412212e-02f, -1.85964461e-02f,
  3.34514938e-02f, -2.92432513e-02f, -8.64216238e-02f, 2.20442321e-02f, 1.22786969e-01f, 5.81759550e-02f, 7.99117163e-02f, 6.44127131e-02f, -8.44446793e-02f, 1.25529811e-01f,
  2.13997036e-01f, 1.53174445e-01f, -3.80153880e-02f, 1.27846465e-01f, 3.87786962e-02f, 8.52905586e-02f, -1.03225343e-01f, -4.59656678e-02f, -5.38575798e-02f, 1.49604097e-01f,
  -1.58550680e-01f, -1.54951632e-01f, 1.12047084e-01f, 3.35948518e-03f, 8.91163945e-02f, -3.27548198e-02f, 1.18030488e-01f, 3.04817799e-02f, -8.13870877e-02f, 6.26812950e-02f,
  -7.27895722e-02f, 1.05632827e-01f, 1.56584889e-01f, 1.81145027e-01f, 6.67467266e-02f, 1.06330834e-01f, 3.54344994e-02f, -7.88141862e-02f, -6.46401122e-02f, 8.07896480e-02f,
  -7.12512434e-02f, 7.92893916e-02f, 1.33209303e-01f, -1.62947811e-02f, -6.54837787e-02f, 5.62547632e-02f, 1.38214365e-01f, -5.38904555e-02f, -5.16004488e-02f, -1.23939663e-01f,
  8.16411003e-02f, -8.65692943e-02f, -2.68319243e-04f, 1.94381058e-01f, -1.59900524e-02f, 1.12692446e-01f, -5.98631687e-02f, 7.15208724e-02f, 1.05031319e-02f, 2.42246445e-02f,
  4.87836543e-03f, -7.95571413e-03f, -9.47122946e-02f, 6.31238371e-02f, 6.59075007e-02f, 6.47122711e-02f, 1.22519374e-01f, -2.60319863e-03f, 7.46771274e-03f, -4.09744121e-02f,
  -5.13339564e-02f, 5.12115695e-02f, -2.47858949e-02f, 2.73742974e-02f, 2.31763929e-01f, 2.98366308e-01f, 1.59730867e-01f, 2.57691175e-01f, 1.56434342e-01f, 1.01448201e-01f,
  -2.06121027e-01f, 1.15935721e-01f, -1.34421110e-01f, -2.39919767e-01f, 2.18462124e-01f, 2.22145721e-01f, 1.39017507e-01f, 9.94412005e-02f, -1.54045269e-01f, 1.12285972e-01f,
  3.14705782e-02f, 5.84326859e-04f, 1.83782652e-01f, 1.70202240e-01f, -7.22507760e-02f, 4.96098511e-02f, -7.41121173e-02f, -6.01891056e-03f, -4.29211892e-02f, -3.62692252e-02f,
  1.29578814e-01f, -1.05342763e-02f, -5.59999309e-02f, 9.56647471e-02f, -4.66276594e-02f, -6.56728745e-02f, -9.23415571e-02f, -1.16938144e-01f, 8.38527530e-02f, 3.94907854e-02f,
  -9.63836312e-02f, 1.59662124e-02f, -8.91641080e-02f, -1.40745357e-01f, -4.28830199e-02f, 6.20322935e-02f, -7.96597973e-02f, -5.58879301e-02f, 2.15961188e-01f, 1.03527494e-01f,
  -2.12452132e-02f, -1.50606006e-01f, -6.00138791e-02f, 1.23685971e-01f, -5.92762306e-02f, 1.92234665e-01f, 4.88900859e-03f, 7.38776922e-02f, -6.06249124e-02f, 2.28578243e-02f,
  -3.67043577e-02f, -6.16318733e-02f, -7.38196373e-02f, 1.03792585e-01f, -8.87701139e-02f, -8.96987468e-02f, -9.06803161e-02f, 2.87301708e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  4.96616326e-02f, 8.80341977e-02f, 1.38385668e-01f, 1.02211475e-01f, 7.23540410e-02f, 1.98833168e-01f, 1.00810513e-01f, 1.80423018e-02f, 2.38716736e-01f, 4.56358604e-02f,
  -2.53517125e-02f, 2.02566534e-01f, 8.10954999e-03f, -7.78442323e-02f, 2.75309205e-01f, 2.88919657e-01f, 1.74786016e-01f, 2.28612304e-01f, -5.84977232e-02f, 1.48079008e-01f,
  8.73977095e-02f, 6.61633387e-02f, 1.13675945e-01f, -1.84690543e-02f, 3.83661598e-01f, 3.36785048e-01f, -9.14048962e-03f, 1.57831699e-01f, 2.30240896e-01f, 1.02878757e-01f,
  -9.16668773e-03f, 1.53036773e-01f, 1.01858698e-01f, -1.36025380e-02f, 1.08425803e-01f, -2.20394024e-04f, 1.52619109e-01f, 5.39397262e-02f, 2.74910718e-01f, 1.17715159e-02f,
  -8.55873078e-02f, -3.48688327e-02f, 2.01270748e-02f, 9.12837908e-02f, 1.59702078e-01f, 1.74782842e-01f, 1.73258603e-01f, -5.96840270e-02f, -8.46338347e-02f, -1.04347188e-02f,
  2.04935610e-01f, 1.42706364e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.56196043e-01f, -3.03400196e-02f, -1.46260440e-01f, -2.31723785e-01f, 2.92763524e-02f, 6.96251318e-02f, 9.27908495e-02f, -1.81956783e-01f, -1.84409410e-01f, -3.07037771e-01f,
  -1.87920675e-01f, 2.85272628e-01f, -2.43113533e-01f, 1.03874050e-01f, -3.45203020e-02f, 4.61163558e-02f, 3.98445763e-02f, -1.65150389e-01f, -8.47609490e-02f, -6.67771623e-02f,
  8.49462748e-02f, -1.41301453e-01f, -3.88657674e-03f, -1.34560037e-02f, -7.82064050e-02f, 3.02983038e-02f, -3.52373160e-02f, -1.78348050e-01f, 2.92045437e-02f, 5.60737364e-02f,
  8.16968158e-02f, 3.73001024e-02f, -2.05965146e-01f, -5.59080653e-02f, 1.03773504e-01f, -5.30246980e-02f, 4.19816911e-01f, -1.47761814e-02f, -8.03349614e-02f, -9.20021236e-02f,
  -1.26051158e-01f, 8.81947204e-02f, 8.36341083e-02f, 3.53747830e-02f, 1.03147306e-01f, -3.89667861e-02f, -9.78304073e-02f, -1.03162654e-01f, -1.47919983e-01f, -5.24909571e-02f,
  7.71427006e-02f, 1.81875788e-02f, -4.92771044e-02f, 1.33019742e-02f, 1.56676784e-01f, -1.25620797e-01f, 3.43343839e-02f, 6.40980899e-02f, 1.74442858e-01f, 1.19626010e-02f,
  1.30040497e-01f, -1.16845675e-01f, -1.32704780e-01f, -1.75998226e-01f, -2.33216155e-02f, 2.10627932e-02f, 5.85389659e-02f, 9.07300785e-02f, 9.85227004e-02f, 1.70946926e-01f,
  -1.26175463e-01f, 1.99461147e-01f, 2.49721020e-01f, 1.98198214e-01f, 9.99085978e-03f, 9.76341441e-02f, 5.85257113e-02f, 1.15960382e-01f, -1.52505830e-01f, -1.29809961e-01f,
  -1.71156496e-01f, -1.60626665e-01f, -4.76026870e-02f, 9.78383645e-02f, 1.95674542e-02f, -1.09548597e-02f, -1.00094318e-01f, 9.66391489e-02f, -3.50109637e-02f, 5.57777360e-02f,
  1.83454663e-01f, 2.07633451e-01f, -2.48427674e-01f, -1.46821365e-01f, 9.92151275e-02f, -1.53615788e-01f, -1.59141749e-01f, -1.29474685e-01f, 4.42991629e-02f, 7.96802342e-02f,
  -5.18315798e-03f, 3.39323133e-01f, 1.31223038e-01f, -8.38174745e-02f, 4.61932421e-02f, 1.95677429e-01f, 6.17267303e-02f, 3.26814353e-02f, 6.64894208e-02f, -1.46317422e-01f,
  -9.00983438e-02f, -1.50247976e-01f, 2.26173311e-01f, 1.31441966e-01f, 2.03277975e-01f, -1.16834201e-01f, -4.70329225e-02f, 3.71688753e-02f, 7.53927380e-02f, -8.25896114e-02f,
  -1.27772778e-01f, -1.22171476e-01f, -9.99708474e-02f, -6.62416965e-02f, 4.65303697e-02f, -6.18248209e-02f, -8.00807849e-02f, -1.80116482e-02f, -8.88678804e-02f, -2.81596929e-01f,
  -2.20780239e-01f, 3.02424524e-02f, -1.64810512e-02f, -4.35574651e-02f, 1.08507268e-01f, -3.96892250e-01f, -7.01659471e-02f, -2.30193585e-01f, -2.73756295e-01f, 3.86088759e-01f,
  1.85860470e-02f, 5.13672046e-02f, -8.00182074e-02f, 6.00703508e-02f, 7.73018748e-02f, -2.00654209e-01f, -1.17863685e-01f, 8.71872902e-02f, 2.06120402e-01f, 3.21946554e-02f,
  8.82241428e-02f, 5.74384769e-03f, -5.18309698e-02f, -6.70026615e-02f, 2.23287359e-01f, -1.62792280e-02f, -2.43307114e-01f, -3.21181387e-01f, 1.18987843e-01f, 1.17006391e-01f,
  -4.90823016e-02f, -8.93940330e-02f, 5.47389276e-02f, -1.61646068e-01f, 1.33893909e-02f, -5.44892401e-02f, -8.48326758e-02f, -4.44025137e-02f, 1.13732234e-01f, 1.24295354e-01f,
  -1.85055822e-01f, -4.16308381e-02f, -4.01673727e-02f, -2.09540129e-02f, 1.35882497e-01f, -5.87900579e-02f, -5.43976463e-02f, 1.24824926e-01f, 1.78865299e-01f, 9.43845231e-03f,
  5.03139012e-02f, -1.10959955e-01f, 1.13703504e-01f, -1.90786883e-01f, -4.23375666e-02f, -1.94982797e-01f, 1.01433262e-01f, 1.07521556e-01f, 1.45587735e-02f, -1.01770423e-01f,
  2.81993579e-02f, -1.97693259e-01f, 2.09930122e-01f, 3.14004362e-01f, 1.56604588e-01f, 1.05875678e-01f, 4.27547731e-02f, -3.42764258e-02f, -9.80577841e-02f, 3.08210492e-01f,
  1.95313960e-01f, 6.74709976e-02f, 1.98722318e-01f, -5.11008240e-02f, -2.13945955e-02f, -2.04962958e-02f, -1.18911818e-01f, 8.71770829e-03f, -1.90795250e-02f, 9.81303528e-02f,
  7.40397424e-02f, -1.08072005e-01f, -8.40391070e-02f, 4.29575890e-02f, -1.35716069e-02f, -5.64817823e-02f, 7.41954446e-02f, -2.12728065e-02f, -1.30994052e-01f, -7.18053654e-02f,
  2.21507654e-01f, -6.63108230e-02f, -8.69973898e-02f, -8.22673514e-02f, 1.21172220e-01f, 1.99550316e-01f, -3.97758633e-02f, 1.70147061e-01f, 1.76932484e-01f, 3.16583104e-02f,
  9.70289633e-02f, 8.00375864e-02f, 3.67505848e-02f, -4.73290049e-02f, 1.68704167e-01f, -1.25251114e-01f, -4.04017270e-02f, -7.27076754e-02f, -4.15883213e-02f, 1.61136091e-01f,
  -7.17106313e-02f, -8.39375257e-02f, -1.78990766e-01f, 2.15164289e-01f, -9.03823003e-02f, 1.41588762e-01f, -7.99317136e-02f, -1.77977830e-02f, 3.16164792e-02f, -2.75913849e-02f,
  -1.57506257e-01f, -1.21126443e-01f, -1.47371702e-02f, 6.68232981e-03f, -8.94199014e-02f, 1.00688092e-01f, 4.71972637e-02f, -2.65622698e-02f, 1.85699731e-01f, 5.02393134e-02f,
  -2.12483838e-01f, -6.96334392e-02f, -1.47160947e-01f, 1.20761894e-01f, 1.29961342e-01f, -4.67993552e-03f, 3.77170146e-02f, 2.13103905e-01f, 7.91341588e-02f, 3.60377878e-02f,
  -1.61713555e-01f, 7.99066052e-02f, 7.07565546e-02f, -9.15681571e-02f, -2.12892294e-01f, 3.32250930e-02f, 1.24366462e-01f, -5.93317226e-02f, 4.44818288e-02f, -7.83852786e-02f,
  4.09643278e-02f, 2.61328742e-02f, -1.54386446e-01f, -2.93374389e-01f, 1.44849300e-01f, -1.65687799e-01f, 4.69279550e-02f, -2.39293315e-02f, 8.81648883e-02f, 1.61059156e-01f,
  3.86507735e-02f, 1.00693941e-01f, 2.55600780e-01f, 8.98248330e-02f, -5.36958538e-02f, 1.51235878e-01f, -1.25705376e-01f, 4.42915410e-02f, 1.42840445e-01f, -6.89631477e-02f,
  -5.99085018e-02f, 9.03297588e-02f, -6.79405779e-02f, 1.97465986e-01f, -5.96498512e-02f, 5.42556122e-02f, -1.63637578e-01f, -1.04404346e-04f, 3.54315713e-02f, 5.67404963e-02f,
  -1.28469408e-01f, 8.13339502e-02f, -9.28690284e-02f, -1.69165805e-01f, 7.43655264e-02f, -5.17729856e-02f, -6.29075766e-02f, -6.40473813e-02f, -1.69874936e-01f, 2.12805662e-02f,
  2.70980626e-01f, 1.48350239e-01f, 1.70424253e-01f, 2.58974612e-01f, 2.82633364e-01f, 8.39505792e-02f, -1.48661315e-01f, 1.86681345e-01f, 2.37745121e-02f, 9.22747143e-03f,
  5.57679497e-02f, -2.02983990e-01f, -3.39271477e-03f, -1.11052051e-01f, -5.14489077e-02f, 9.75357741e-02f, 3.49699147e-02f, 1.33594662e-01f, 8.72180760e-02f, 1.96876265e-02f,
  -1.86376333e-01f, 1.17880605e-01f, -6.86896369e-02f, 4.68394756e-02f, 9.16622654e-02f, 5.06763496e-02f, 2.70000529e-02f, 2.65327364e-01f, 1.13012031e-01f, 9.98916402e-02f,
  3.14861797e-02f, -1.17864810e-01f, 8.82919058e-02f, -3.51311751e-02f, -8.68713763e-03f, -5.43333516e-02f, -1.94090471e-01f, -1.32148206e-01f, 2.35506110e-02f, 5.00893034e-02f,
  2.88596123e-01f, 8.94688517e-02f, -1.45115554e-02f, 1.67694688e-01f, -2.20738873e-02f, 9.01428703e-03f, -1.16042402e-02f, -1.25269014e-02f, 1.70575634e-01f, -1.48492143e-01f,
  2.55864039e-02f, -4.56761308e-02f, -1.06763840e-01f, 1.19592264e-01f, -6.37677964e-03f, -1.09585442e-01f, 1.16230257e-01f, 1.51984524e-02f, -1.37605637e-01f, -1.29639894e-01f,
  5.03602922e-02f, 7.57451504e-02f, 2.64665037e-02f, 7.29096904e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.42382145e-01f, 1.53925955e-01f, -9.46160108e-02f, 1.23457536e-01f, -6.97377771e-02f, 2.50131637e-01f, 1.34046361e-01f, -6.21378720e-02f, -4.18384552e-01f, -3.17072392e-01f,
  -2.58855611e-01f, -1.04519561e-01f, -1.10010773e-01f, 1.22917071e-01f, 9.01640654e-02f, -1.13669753e-01f, 1.69657767e-01f, -1.55768275e-01f, 5.97317405e-02f, -3.39608453e-02f,
  -6.07864372e-02f, -1.74730361e-01f, 6.44877926e-02f, 6.38848469e-02f, 2.32036021e-02f, 1.03912286e-01f, 1.29175782e-01f, -3.84307876e-02f, 1.26599818e-01f, 2.83734381e-01f,
  7.23246783e-02f, 2.05312610e-01f, 7.39717260e-02f, -9.40924957e-02f, -9.39433128e-02f, -7.11589456e-02f, 3.74553919e-01f, -1.88236520e-01f, -1.69091951e-02f, 5.74203692e-02f,
  -1.01372600e-01f, -1.80257663e-01f, 1.41864389e-01f, 7.12266611e-03f, 3.75847071e-02f, 1.04064703e-01f, -1.67946285e-03f, -1.03852741e-01f, -2.15016231e-01f, -2.67279916e-03f,
  -1.52853772e-01f, 2.76447292e-02f, -1.05281966e-02f, 4.11932692e-02f, -1.35897383e-01f, 1.18833095e-01f, -3.59571278e-02f, 1.56639948e-01f, 1.12232134e-01f, 2.12994397e-01f,
  -3.41022648e-02f, 1.85363159e-01f, 1.61950797e-01f, -4.65942733e-02f, 8.77958685e-02f, -1.93380266e-02f, -1.49623558e-01f, -9.42934975e-02f, 6.97798878e-02f, -1.24804646e-01f,
  -2.62977052e-02f, -1.01352155e-01f, 3.44152823e-02f, -3.32982726e-02f, -1.14417940e-01f, 1.23648256e-01f, -1.70234609e-02f, -1.33245707e-01f, 1.40434997e-02f, 1.09178677e-01f,
  6.93818927e-02f, 8.51853192e-02f, 4.10946347e-02f, -7.94426128e-02f, -3.58510688e-02f, 1.20959848e-01f, 6.88073114e-02f, -8.58469605e-02f, 5.41780367e-02f, 1.04027249e-01f,
  7.19192848e-02f, 4.17138115e-02f, -1.10620745e-01f, -1.30610049e-01f, 1.46908052e-02f, 4.72210459e-02f, 1.92616303e-02f, -1.01890758e-01f, -2.15037502e-02f, -9.11592096e-02f,
  2.61102825e-01f, 3.61492042e-03f, 1.22431219e-02f, 1.38141522e-02f, 1.75718412e-01f, 1.09413629e-02f, -7.62837976e-02f, -1.48219630e-01f, -1.81320738e-02f, 1.54397681e-01f,
  2.17201794e-03f, 2.61502825e-02f, 9.30874050e-03f, -9.20507535e-02f, 1.76749509e-02f, 6.81896359e-02f, 1.14375964e-01f, -6.15316890e-02f, 1.03688844e-01f, -4.39241268e-02f,
  2.46649664e-02f, 6.34654239e-02f, -8.38041976e-02f, -6.12555631e-02f, 1.18154220e-01f, 1.20164640e-01f, 1.62663311e-01f, -2.76777949e-02f, 1.11258887e-01f, 5.37376702e-02f,
  -2.28536595e-02f, -8.14690962e-02f, 3.41476984e-02f, 2.88690496e-02f, 1.17739573e-01f, -1.67824283e-01f, -2.32950807e-01f, -2.17207015e-01f, -1.29653662e-01f, 2.75744200e-01f,
  -3.06228381e-02f, -1.61556471e-02f, 3.17913070e-02f, -8.50130916e-02f, -1.12436749e-02f, -5.36537133e-02f, 3.55387703e-02f, 5.94018698e-02f, 1.23432361e-01f, 4.82353084e-02f,
  -9.05603394e-02f, -9.86196101e-02f, 6.14779368e-02f, 8.14397559e-02f, 1.11074829e-02f, 5.92963882e-02f, -1.50885329e-01f, -2.02504024e-01f, 1.22474045e-01f, 3.87764238e-02f,
  -1.27369285e-01f, -1.43666983e-01f, -5.96882068e-02f, 6.82423934e-02f, 1.99860767e-01f, -3.15660089e-02f, -1.08228430e-01f, 1.38031080e-01f, 8.37622955e-02f, 1.08054139e-01f,
  2.79185399e-02f, -1.31670460e-01f, 1.39584199e-01f, -9.35602635e-02f, 1.61361769e-01f, 3.10081895e-03f, -1.01815671e-01f, 9.80107710e-02f, 1.39010735e-02f, -7.43972734e-02f,
  1.56509623e-01f, -1.40837535e-01f, -2.70025320e-02f, 1.11861870e-01f, 9.11729112e-02f, 5.99989900e-03f, 4.71181385e-02f, 3.60545069e-02f, -6.19600751e-02f, -4.87944894e-02f,
  -9.71961990e-02f, -1.49034530e-01f, -1.75849810e-01f, -8.57521221e-02f, -3.11835483e-03f, -1.97858006e-01f, -1.15640499e-01f, -1.92277595e-01f, 2.99479603e-03f, -4.07933630e-02f,
  -1.35701537e-01f, 7.27165937e-02f, 1.63009375e-01f, 1.10114686e-01f, -6.18724488e-02f, -6.43490478e-02f, 5.87708876e-02f, 5.41769750e-02f, -1.02207743e-01f, -4.67914939e-02f,
  1.77367464e-01f, -1.05547704e-01f, 3.02101988e-02f, -9.18051228e-02f, 5.97258918e-02f, 7.61006698e-02f, 5.22237411e-03f, -2.31197737e-02f, 1.64354332e-02f, 1.77541092e-01f,
  4.91368324e-02f, 1.89417284e-02f, -1.30697384e-01f, -1.22724501e-02f, 1.12579949e-01f, 1.11011319e-01f, -1.10831186e-01f, 1.83340441e-02f, 6.41763136e-02f, -1.53215036e-01f,
  -8.19531381e-02f, -6.00407310e-02f, 1.99653536e-01f, -3.52547690e-02f, 1.49181753e-01f, -1.05845004e-01f, 1.38811424e-01f, -5.75083382e-02f, 1.23184830e-01f, 1.21893227e-01f,
  6.95740879e-02f, -6.28388822e-02f, 2.35854611e-01f, -5.09565920e-02f, -9.91783738e-02f, 5.66638298e-02f, -2.50411034e-03f, 6.30496591e-02f, 8.72562677e-02f, 1.59791604e-01f,
  5.58395423e-02f, 8.85009393e-02f, 1.51480988e-01f, -4.92057763e-02f, 1.21099651e-02f, 1.81256965e-01f, 1.29179358e-01f, -6.54178411e-02f, -7.35032037e-02f, 1.02638215e-01f,
  -6.87719211e-02f, 8.55426416e-02f, -1.81261197e-01f, 2.77879268e-01f, 4.22167592e-02f, -6.91720564e-03f, 3.64521116e-01f, -8.59535336e-02f, 5.19564003e-02f, -1.24399848e-01f,
  -2.11735919e-01f, -1.56571403e-01f, -1.34675158e-02f, -2.48327740e-02f, 2.03804076e-02f, 7.39957765e-02f, -8.48945007e-02f, -8.66180584e-02f, -7.67243654e-02f, 1.00138709e-01f,
  6.12079762e-02f, -1.30326197e-01f, -2.57754385e-01f, -9.38425362e-02f, 2.60288954e-01f, 2.73234755e-01f, -1.48043469e-01f, 1.02180960e-02f, -7.07577765e-02f, 1.50935724e-01f,
  -1.17708191e-01f, 2.06511706e-01f, 3.62425536e-01f, 2.89027721e-01f, -2.93824403e-03f, -9.15942639e-02f, 2.54778117e-02f, -3.63531299e-02f, 9.22155008e-02f, 1.02112512e-03f,
  2.13517994e-01f, -2.78652366e-02f, -2.17983406e-02f, 5.99000379e-02f, 3.83676477e-02f, 4.24416140e-02f, 1.42929837e-01f, 1.52646959e-01f, -1.01699397e-01f, 1.18029840e-01f,
  7.36176223e-02f, -4.26097475e-02f, 5.60565665e-02f, 1.91242099e-01f, 3.27039920e-02f, 8.41712430e-02f, -7.43324496e-03f, -6.13537198e-03f, -1.78453862e-03f, 2.81094074e-01f,
  5.48320450e-02f, -1.28230587e-01f, -9.86277759e-02f, -4.52171303e-02f, -1.29646525e-01f, -7.16709420e-02f, -2.30265722e-01f, 1.22969598e-01f, 1.74242690e-01f, 1.84798166e-02f,
  2.55282402e-01f, -1.43667743e-01f, 4.52558249e-02f, -1.36482522e-01f, -2.93359105e-02f, -1.37090176e-01f, -1.50871083e-01f, -9.11835507e-02f, 9.16055143e-02f, -1.18355942e-03f,
  -6.67221174e-02f, -1.43909737e-01f, 1.14861056e-01f, -8.40113908e-02f, 7.25619197e-02f, -9.46026072e-02f, -2.07471801e-03f, 2.60003775e-01f, 2.42850184e-01f, -2.08826233e-02f,
  4.12517637e-02f, -5.23774773e-02f, 7.00107887e-02f, 8.13032538e-02f, -1.40582874e-01f, -3.43846120e-02f, 3.25194076e-02f, 1.23048499e-01f, -9.81087908e-02f, 3.85323204e-02f,
  2.94792295e-01f, 9.27838236e-02f, -1.29458318e-02f, 3.99691984e-02f, 1.03732534e-01f, 4.44379970e-02f, 6.72719106e-02f, 1.35779500e-01f, 2.26533100e-01f, -9.77765620e-02f,
  -1.45816013e-01f, 1.95217192e-01f, -1.20054595e-01f, 9.18538496e-02f, -4.47153486e-02f, 1.64682772e-02f, -1.12422712e-01f, 1.71754390e-01f, -1.13846570e-01f, -1.44922182e-01f,
  1.22418866e-01f, 3.06432676e-02f, 2.14759186e-02f, 1.74070418e-01f, 1.51218235e-01f, 1.40291110e-01f, 1.52008221e-01f, 1.28720686e-01f, 1.63060687e-02f, 4.92195673e-02f,
  4.12815576e-03f, -9.25400387e-03f, 1.87068488e-02f, 1.56919546e-02f, -2.36887291e-01f, 1.51281863e-01f, 7.02893361e-02f, 1.89325977e-02f, 1.30389899e-01f, 4.68950570e-02f,
  -8.84746835e-02f, -1.51936235e-02f, -1.59761518e-01f, 7.82075077e-02f, 1.54232858e-02f, -1.17925173e-02f, -3.62889729e-02f, -5.22718765e-02f, -9.04113054e-02f, 1.08655982e-01f,
  6.32194057e-02f, 1.37861356e-01f, -1.36814564e-01f, -6.18980713e-02f, -9.79989991e-02f, -6.45793453e-02f, 7.82552660e-02f, 8.89439508e-02f, 2.85299271e-02f, 4.00250256e-02f,
  3.91317084e-02f, 1.40134379e-01f, -9.33667719e-02f, 7.82377552e-03f, -5.65952100e-02f, -8.93450156e-02f, 2.67311204e-02f, 6.31880686e-02f, 1.26469448e-01f, -1.36179164e-01f,
  -2.96782404e-02f, 4.33843546e-02f, 1.91865668e-01f, -6.19578063e-02f, 7.59407431e-02f, 7.23598301e-02f, -3.90107334e-02f, -1.19090967e-01f, -1.47677064e-02f, 6.61253259e-02f,
  -3.89791019e-02f, 7.42360801e-02f, 2.90148649e-02f, -5.22458032e-02f, -1.68958753e-02f, 6.83608949e-02f, -4.75282827e-03f, -3.26009430e-02f, 1.08331025e-01f, 1.26590937e-01f,
  1.69312507e-01f, 1.21354327e-01f, 1.70226038e-01f, 4.13141668e-01f, 2.88116068e-01f, -3.74050260e-01f, -3.94844145e-01f, -3.51439327e-01f, -3.99400055e-01f, -4.94162329e-02f,
  -1.06571868e-01f, 6.50283843e-02f, 2.72944450e-01f, -9.02855652e-04f, 1.75512001e-01f, -1.87737584e-01f, -8.58573318e-02f, -1.41740432e-02f, 9.31473225e-02f, -1.52222542e-02f,
  -1.04052693e-01f, 1.10440806e-01f, -2.19758395e-02f, -8.78115371e-02f, 3.24500114e-01f, 1.23144887e-01f, -2.14240104e-01f, 6.86714202e-02f, -7.94906244e-02f, 2.44458809e-01f,
  7.90543333e-02f, -1.05165532e-02f, -4.91588712e-02f, 2.02245805e-02f, 2.83307999e-01f, -2.55440325e-02f, 6.89660236e-02f, 9.40914452e-02f, -1.31457016e-01f, 3.58841848e-03f,
  -1.07920244e-01f, 1.32750988e-01f, 9.77397338e-03f, 9.07343253e-02f, 2.12285131e-01f, 6.09918982e-02f, 1.55690402e-01f, 9.36914831e-02f, 1.53799087e-01f, 1.11069724e-01f,
  8.84584337e-02f, -1.02689177e-01f, -9.63060781e-02f, -1.29994992e-02f, -2.75455154e-02f, 7.89331738e-03f, 1.38677478e-01f, 2.27313980e-01f, 9.60368570e-03f, 1.57231033e-01f,
  2.35858023e-01f, 6.35861680e-02f, 2.25231305e-01f, 2.43692830e-01f, 8.49939361e-02f, 2.98307240e-01f, 6.28539622e-02f, 1.72586054e-01f, 1.34971172e-01f, -3.06782395e-01f,
  -1.91559717e-01f, -3.81110571e-02f, -2.24481925e-01f, -5.56629263e-02f, -6.64121360e-02f, 2.48139799e-02f, 1.32148057e-01f, 1.93445981e-02f, 1.55462027e-02f, -1.39205977e-01f,
  8.97939801e-02f, -8.23203251e-02f, -1.81479380e-02f, 1.34887882e-02f, -3.12399697e-02f, 7.17075691e-02f, -3.16314995e-02f, -1.23985194e-01f, 3.57288837e-01f, 3.15126896e-01f,
  -2.08040676e-03f, 8.56265053e-02f, 2.28133425e-02f, 1.87565401e-01f, 5.80371264e-03f, -8.99903663e-03f, 3.82299162e-02f, -1.65434852e-01f, -3.10587078e-01f, -1.92979708e-01f,
  6.74366429e-02f, 7.39501789e-04f, 5.43952398e-02f, -1.98496785e-02f, 4.02975827e-03f, 2.43930876e-01f, -5.44572771e-02f, -1.45722674e-02f, 2.50759870e-01f, 1.11130871e-01f,
  2.46478960e-01f, -1.61084101e-01f, 1.90647438e-01f, -1.04467474e-01f, -6.83067292e-02f, -7.03849494e-02f, 1.54517978e-01f, 1.97767932e-02f, 1.62854940e-01f, -1.01624943e-01f,
  1.66670624e-02f, -6.76099444e-03f, 5.88276312e-02f, 2.06310704e-01f, 1.47110164e-01f, -1.31323248e-01f, 3.10322568e-02f, -8.46043520e-04f, 7.37213492e-02f, 2.37283926e-03f,
  4.45400253e-02f, 5.79921380e-02f, 3.16630267e-02f, 2.23297507e-01f, -8.86128396e-02f, -1.53464014e-02f, 1.66506752e-01f, -2.32860610e-01f, 7.74590820e-02f, 1.92586835e-02f,
  1.28060251e-01f, -9.70987082e-02f, -7.07630254e-03f, -7.81940296e-02f, 1.37663171e-01f, 1.11370288e-01f, -1.21169657e-01f, -6.77319914e-02f, -3.83763537e-02f, 8.39871615e-02f,
  8.43182951e-02f, 7.68543333e-02f, 3.99007276e-02f, -5.65853454e-02f, 1.91411346e-01f, 1.13123447e-01f, -5.48450835e-02f, 4.87165675e-02f, 3.91015224e-02f, 9.60803777e-02f,
  -5.93274459e-02f, -2.01690625e-02f, 4.75960299e-02f, -1.14282623e-01f, 4.06881049e-02f, -7.66013265e-02f, 1.33479446e-01f, 1.26843583e-02f, 8.61644819e-02f, -8.77067819e-03f,
  -2.25977339e-02f, 6.97295088e-03f, -2.79317573e-02f, -6.32638633e-02f, 1.15373358e-01f, -5.86063713e-02f, 1.25576267e-02f, 1.45583451e-01f, -1.66303164e-03f, 4.94150892e-02f,
  9.55842659e-02f, -4.12092470e-02f, 1.01536680e-02f, 1.55766025e-01f, 1.04899034e-02f, -1.33081913e-01f, 1.13101294e-02f, 1.08124673e-01f, 1.28164059e-02f, 1.07755385e-01f,
  7.21044606e-03f, -2.20323488e-01f, -5.65790161e-02f, -1.71312660e-01f, -4.93329717e-03f, -2.00771824e-01f, 7.94645399e-02f, 1.12231649e-01f, -4.18422781e-02f, 1.34681582e-01f,
  1.71011351e-02f, 1.30969480e-01f, 5.93169890e-02f, -1.31632656e-01f, -7.64350295e-02f, 6.50691148e-03f, 1.04158066e-01f, 7.50469491e-02f, 2.18144611e-01f, 1.29941991e-02f,
  -1.28077343e-01f, 2.77413521e-02f, -1.16498925e-01f, 5.30063473e-02f, -7.40434825e-02f, -1.40432239e-01f, 4.16769795e-02f, 7.20162317e-02f, 2.25959852e-01f, 8.94477740e-02f,
  8.36204514e-02f, 1.06427819e-01f, 1.42916009e-01f, 4.85637598e-02f, -1.48036942e-01f, 1.22672662e-01f, 1.68553382e-01f, 3.38768959e-02f, 2.69296169e-02f, 2.67942180e-03f,
  1.73059240e-01f, 1.17327921e-01f, -1.80718843e-02f, -4.24593166e-02f, 8.27254262e-03f, 9.45623145e-02f, 2.07003832e-01f, 2.41336115e-02f, -9.64033455e-02f, -5.24906144e-02f,
  -8.36716294e-02f, 1.64742067e-01f, 1.17157288e-01f, -6.10605851e-02f, 1.26080541e-02f, 1.67973652e-01f, 1.40218899e-01f, 1.37714088e-01f, 3.35942842e-02f, -6.60210401e-02f,
  1.32948488e-01f, -1.04633242e-01f, -9.76927057e-02f, 6.17108271e-02f, -7.19126090e-02f, -4.10881564e-02f, 3.97807397e-02f, 3.36370356e-02f, -4.19473350e-02f, 2.11991921e-01f,
  -6.33673146e-02f, 8.52634013e-02f, -1.44857705e-01f, -8.90147015e-02f, -1.66458823e-02f, 3.18459645e-02f, 5.38749285e-02f, 5.80780255e-03f, 6.57487214e-02f, 7.53709823e-02f,
  -4.60329391e-02f, 1.60152063e-01f, 1.24871381e-01f, 1.17022939e-01f, 1.08716622e-01f, 1.09255828e-01f, -5.09188464e-03f, 1.13200523e-01f, -8.31340104e-02f, 9.65081081e-02f,
  -8.99113789e-02f, -4.17922297e-03f, -2.45149434e-02f, -9.44463983e-02f, 5.22929877e-02f, 1.46469533e-01f, 7.26007149e-02f, -2.09608451e-02f, 7.61760771e-02f, -9.09348205e-02f,
  1.92954659e-01f, 1.22442834e-01f, 2.21959576e-02f, -1.15410537e-01f, -9.60970074e-02f, -1.08107865e-01f, 9.85789970e-02f, 1.16173938e-01f, 4.23355168e-03f, -6.97844699e-02f,
  3.03460583e-02f, 9.57195908e-02f, -1.15013160e-01f, 9.22392830e-02f, 9.55526680e-02f, 3.10340966e-03f, -1.03518059e-02f, -8.37485641e-02f, -8.29433352e-02f, -3.46703306e-02f,
  -6.59118816e-02f, -1.41803240e-02f, 1.60516620e-01f, 2.30089668e-02f, 6.28840104e-02f, 3.85423377e-02f, 1.25544250e-01f, -4.67971229e-04f, -6.69477731e-02f, -1.66260585e-01f,
  1.12903817e-02f, -1.26912594e-01f, 1.04480637e-02f, -1.43729597e-01f, -3.41176204e-02f, 1.17318325e-01f, -6.18934399e-03f, 2.79454049e-02f, 7.73289725e-02f, -8.46973211e-02f,
  2.48075780e-02f, 6.53918535e-02f, -5.06522646e-03f, 9.08431783e-02f, -1.09561577e-01f, -6.67378008e-02f, -4.80503030e-02f, -1.05607621e-01f, -1.00408439e-02f, 1.32408962e-02f,
  6.50459677e-02f, 7.31962100e-02f, -7.97170326e-02f, -1.21057980e-01f, 4.79822122e-02f, 1.06743522e-01f, 6.35064095e-02f, -8.81650448e-02f, -5.85582145e-02f, -5.94376102e-02f,
  -9.97769460e-02f, -1.22702979e-01f, -1.05428122e-01f, -2.16264720e-03f, -9.40400586e-02f, -7.98105150e-02f, 7.32336715e-02f, 1.85857303e-02f, -6.27504438e-02f, 1.25378028e-01f,
  -2.14867815e-02f, 7.25944117e-02f, -4.00675051e-02f, 2.37666350e-03f, 1.10411197e-01f, -1.22988358e-01f, 1.33698925e-01f, 1.53796552e-02f, 6.26045140e-03f, -2.79967152e-02f,
  9.43270847e-02f, 7.91672990e-02f, -1.07173182e-01f, 2.06990913e-02f, -2.32137949e-03f, -2.20152028e-02f, 8.22272152e-02f, -1.25899762e-01f, 6.40123636e-02f, 2.88242288e-02f,
  -9.47533473e-02f, -5.37138991e-02f, 5.44738173e-02f, -3.88101079e-02f, -9.11565199e-02f, -6.73403069e-02f, -6.65489510e-02f, -1.39816791e-01f, 5.72829992e-02f, -7.49532878e-02f,
  -6.54227361e-02f, -1.34419993e-01f, -2.17945818e-02f, 2.52621084e-01f, -1.85786128e-01f, -1.40230671e-01f, -1.47571862e-01f, 8.11180398e-02f, -9.27303210e-02f, -1.27642840e-01f,
  1.97670624e-01f, 5.88382855e-02f, 1.34058848e-01f, 7.28575215e-02f, 1.10205449e-02f, -1.62127063e-01f, -3.50725800e-02f, 3.41127962e-02f, 7.65904831e-03f, 1.21306755e-01f,
  -5.12775639e-03f, -1.19602606e-01f, -2.01674588e-02f, -1.05935737e-01f, 1.31210182e-02f, 8.55553821e-02f, 3.82542014e-02f, -3.09542064e-02f, 3.77034992e-01f, 1.60098970e-01f,
  -8.64577666e-02f, 9.37278643e-02f, 3.37144643e-01f, -3.33368406e-02f, 3.20157520e-02f, 1.37517136e-02f, 1.66658401e-01f, 8.84192660e-02f, 1.69337004e-01f, -1.00149252e-01f,
  -3.43642868e-02f, 8.57557058e-02f, 5.43530192e-03f, 9.76154432e-02f, -3.59686390e-02f, -1.06107362e-01f, 2.07594365e-01f, 4.80560847e-02f, 1.33456632e-01f, 2.72133928e-02f,
  7.33923614e-02f, -8.38027000e-02f, 1.44377023e-01f, -1.14623584e-01f, 1.89622007e-02f, -3.01777665e-02f, 8.50346759e-02f, 1.35138974e-01f, 1.33811936e-01f, 1.28125146e-01f,
  9.54847708e-02f, 3.89388241e-02f, 5.25957085e-02f, 9.66118500e-02f, -1.22865234e-02f, 7.14164674e-02f, 8.82732123e-03f, 1.65343374e-01f, -1.32371187e-01f, 1.97499972e-02f,
  -1.12905905e-01f, -1.26992287e-02f, -9.74334702e-02f, 1.83846317e-02f, -1.52627169e-03f, -5.34827225e-02f, 9.91371796e-02f, -8.58082622e-02f, 8.99351016e-02f, -6.26387969e-02f,
  -2.63288454e-03f, -9.19231549e-02f, -7.26081654e-02f, -1.47056347e-02f, 8.55084136e-02f, -1.10615147e-02f, -6.38741255e-02f, -3.90608199e-02f, 6.27631396e-02f, -5.14681339e-02f,
  9.79539379e-02f, 1.41615182e-01f, 5.97652122e-02f, 1.17874518e-01f, -3.62294801e-02f, -1.96278766e-02f, -5.79882860e-02f, 1.53859833e-03f, 5.93310818e-02f, -8.32554360e-04f,
  -7.20125735e-02f, -1.20807663e-01f, 7.02083036e-02f, -1.35625497e-01f, 9.51527953e-02f, 1.22068473e-03f, 1.59294218e-01f, 9.31174010e-02f, 3.64443008e-03f, -1.68042630e-02f,
  -3.90120260e-02f, -1.10138193e-01f, -2.92599984e-02f, 7.48689696e-02f, -8.56672004e-02f, 2.45851781e-02f, -1.84703898e-02f, -1.57198459e-02f, -1.47187691e-02f, 8.37163627e-02f,
  -2.92239953e-02f, 1.13953620e-01f, -1.76468398e-02f, 1.27353789e-02f, 3.08544096e-02f, -3.17495093e-02f, 1.12528056e-01f, -1.77097082e-01f, 6.65800273e-03f, -3.37484367e-02f,
  -1.89420193e-01f, -2.30940834e-01f, -7.02291206e-02f, -1.15038194e-01f, 2.01966375e-01f, -2.58237310e-02f, 6.59114346e-02f, 4.02885936e-02f, 1.57441869e-01f, -4.51229326e-02f,
  -4.29961160e-02f, -1.78914256e-02f, -5.05299754e-02f, 1.37858361e-01f, -8.36274400e-02f, 1.72498021e-02f, 3.05698402e-02f, 5.37232868e-02f, 9.32090282e-02f, 1.16121046e-01f,
  1.77388284e-02f, 1.76276818e-01f, 2.35405564e-02f, 3.49389464e-02f, -8.85148197e-02f, 1.99483559e-02f, -3.47661972e-02f, -8.22472051e-02f, -1.22520626e-01f, 1.09727636e-01f,
  -3.26393135e-02f, 1.87030006e-02f, 1.10364012e-01f, 1.82769015e-01f, 7.86787644e-02f, 1.08412452e-01f, 1.62985459e-01f, 1.10663436e-01f, -7.66950995e-02f, 1.14051759e-01f,
  6.66942075e-03f, -2.88871136e-02f, -7.68531859e-02f, -1.04414724e-01f, 9.34545472e-02f, 4.44521829e-02f, 1.04326122e-01f, 9.63610969e-03f, 1.00684706e-02f, -1.71172060e-02f,
  -7.16783777e-02f, -6.40036389e-02f, -5.87798841e-03f, -1.09553546e-01f, 8.77660513e-02f, 2.07168028e-01f, 8.00418481e-02f, 3.50387692e-02f, 1.27859995e-01f, -1.78289577e-01f,
  1.47333905e-01f, 1.85893133e-01f, -5.72714321e-02f, -6.72844797e-02f, 1.54841021e-01f, -3.22773904e-01f, 1.27354801e-01f, -1.39186298e-02f, -4.64988835e-02f, 1.58799756e-02f,
  2.65251130e-01f, 1.55803770e-01f, 1.46463215e-01f, 4.66705747e-02f, 9.91281122e-02f, 1.04145423e-01f, -8.86050165e-02f, -4.71056588e-02f, -6.98909163e-02f, 6.71852455e-02f,
  -3.72938067e-02f, -1.40001908e-01f, 2.64968246e-01f, 1.64096475e-01f, 2.20493115e-02f, 1.09944195e-01f, -2.88737882e-02f, 6.00723997e-02f, -4.42274287e-02f, -6.15079962e-02f,
  1.17984027e-01f, -4.72105527e-03f, -1.44934684e-01f, 1.36555761e-01f, 1.00749619e-01f, -7.18186051e-02f, 2.48099789e-02f, -5.29307239e-02f, -1.61805868e-01f, 5.27483895e-02f,
  4.75814752e-03f, 2.63497382e-01f, -8.49358290e-02f, 1.45437017e-01f, -1.77998185e-01f, 1.05812781e-01f, -1.24069050e-01f, 4.35652733e-02f, 7.21511096e-02f, 9.42481831e-02f,
  -7.20101744e-02f, 4.15590927e-02f, 2.48466861e-02f, -7.73647130e-02f, -1.90944038e-02f, 5.25220260e-02f, 8.11693296e-02f, 8.08020309e-02f, 1.11306787e-01f, -7.86768198e-02f,
  -9.24464166e-02f, -6.97614476e-02f, -1.12448655e-01f, -5.09364717e-02f, 3.71756940e-03f, 4.55275141e-02f, -5.45921884e-02f, 1.25850409e-01f, 1.18517481e-01f, -1.60109892e-01f,
  8.42964463e-03f, 3.15034091e-02f, -9.96655524e-02f, 5.44098504e-02f, 9.42970514e-02f, -7.61081949e-02f, 1.44887373e-01f, 6.94216937e-02f, 5.99683896e-02f, -1.02796415e-02f,
  1.30033836e-01f, 1.02911837e-01f, 1.83402020e-02f, 1.06090724e-01f, -8.44940916e-02f, -6.24286607e-02f, 5.34329228e-02f, 7.98135325e-02f, 3.05182207e-02f, 1.81359366e-01f,
  -6.97031394e-02f, 3.57973054e-02f, 1.33333206e-01f, 7.77596235e-02f, -3.60794589e-02f, -9.35809761e-02f, 1.67771213e-04f, 3.61144021e-02f, -1.29173975e-02f, 2.84009632e-02f,
  4.23913300e-02f, 7.15327710e-02f, 4.64726277e-02f, 1.46048442e-01f, 1.01379909e-01f, 5.40737249e-02f, -3.75033543e-02f, 2.05092374e-02f, -9.71031189e-03f, 1.04453743e-01f,
  1.07865436e-02f, 3.14879604e-02f, 7.92723373e-02f, 1.84335802e-02f, -4.01718840e-02f, -6.61952496e-02f, -1.15263471e-02f, -3.24637815e-02f, 5.19548841e-02f, -8.72381255e-02f,
  8.07539225e-02f, 1.35401875e-01f, -6.78621307e-02f, 2.40714271e-02f, -6.16156012e-02f, 8.29510465e-02f, -5.74193299e-02f, -1.23441935e-01f, -6.08560555e-02f, -8.01679045e-02f,
  -1.08357757e-01f, -8.23613629e-02f, -1.39238894e-01f, 5.95367625e-02f, -1.10579170e-01f, 1.22269183e-01f, 3.74123119e-02f, 1.00036971e-01f, 8.24645720e-03f, 1.54663976e-02f,
  1.14584357e-01f, -8.05833861e-02f, -2.03300677e-02f, 4.96833622e-02f, -1.12317726e-01f, -5.02894931e-02f, 8.79776105e-03f, -4.08487171e-02f, 9.99857858e-02f, 1.29951060e-01f,
  3.50097194e-02f, -2.46705990e-02f, 1.39066011e-01f, 1.19043000e-01f, 1.12820817e-02f, -3.20782177e-02f, 1.07480004e-01f, 4.59949188e-02f, -9.85412523e-02f, -3.35185193e-02f,
  -1.08146705e-01f, -9.80175436e-02f, 8.41130316e-02f, -3.86384851e-03f, -1.28295511e-01f, 2.88237701e-03f, -4.18239320e-03f, -5.31921349e-02f, 3.45404260e-02f, 1.35308104e-02f,
  -6.07671961e-02f, 3.29875364e-03f, 4.75294665e-02f, -3.71887833e-02f, 9.13170651e-02f, -1.35330349e-01f, 1.00294165e-01f, 3.79207395e-02f, 1.07705869e-01f, -1.03497416e-01f,
  -1.16535872e-01f, 1.08859301e-01f, 5.72960125e-03f, 1.03804573e-01f, 1.20401070e-01f, -3.90932783e-02f, 6.66609779e-02f, 2.04692464e-02f, -6.78782463e-02f, 1.03380889e-01f,
  6.46174848e-02f, 2.12535188e-01f, 3.22260521e-02f, -3.97215672e-02f, -2.17662454e-01f, -1.46390870e-01f, -2.80913301e-02f, -4.56711389e-02f, -9.89764258e-02f, -3.93553302e-02f,
  -4.23208438e-02f, -5.84639311e-02f, -5.47394156e-02f, -1.47645235e-01f, -1.27476349e-01f, -2.05509048e-02f, -4.23324518e-02f, -1.39317751e-01f, 6.19731359e-02f, 8.75084251e-02f,
  -9.91092399e-02f, -9.37762856e-02f, 1.50471792e-01f, -2.96475366e-02f, 4.63993028e-02f, 1.79957271e-01f, -5.89123406e-02f, -5.68287745e-02f, 1.94719825e-02f, -4.83547375e-02f,
  -4.41566296e-02f, 7.03166276e-02f, 1.30825102e-01f, -1.02523133e-01f, -1.07301222e-02f, 2.48763282e-02f, -1.80306777e-01f, -1.26644939e-01f, 9.02016163e-02f, 1.27367914e-01f,
  8.07427093e-02f, -1.09080590e-01f, -2.18499955e-02f, -6.59935772e-02f, -4.07515578e-02f, 2.11958550e-02f, 1.45294189e-01f, 9.40409601e-02f, -1.01424314e-01f, 9.44958925e-02f,
  6.81797415e-02f, 3.54058594e-02f, 6.59064725e-02f, -1.94092728e-02f, 1.69709817e-01f, 1.53135210e-01f, -1.32885665e-01f, 1.50467558e-02f, 3.96191664e-02f, 1.49004787e-01f,
  -1.87542625e-02f, -1.30460680e-01f, -6.18970394e-03f, -5.75905181e-02f, -1.43798679e-01f, -1.92592200e-02f, 1.35943100e-01f, -1.86064348e-01f, 7.48225227e-02f, -1.31157085e-01f,
  -9.50430259e-02f, 2.08317339e-01f, -1.31150708e-01f, -3.75850163e-02f, -4.65657860e-02f, 9.92282927e-02f, -1.48835406e-02f, 8.37827940e-03f, 1.08512267e-01f, 7.47597367e-02f,
  1.98648088e-02f, 6.63298443e-02f, -3.77894640e-02f, 6.99039083e-03f, -6.71866536e-02f, -7.16693178e-02f, 8.42132568e-02f, -6.93669766e-02f, -2.79976539e-02f, 2.52621174e-02f,
  -4.99394201e-02f, 1.40780300e-01f, -6.17152378e-02f, -9.47248042e-02f, -4.08377759e-02f, -5.87303890e-03f, 2.96613455e-01f, -1.66991465e-02f, -4.07507457e-02f, 7.67743140e-02f,
  1.89162083e-02f, -6.60614623e-03f, -7.58476406e-02f, -9.79631767e-02f, 1.52608201e-01f, -8.33699033e-02f, 2.22485140e-02f, -3.05507444e-02f, 8.99538994e-02f, 5.93765937e-02f,
  2.28930667e-01f, 2.32515000e-02f, 1.50234073e-01f, -2.37378515e-02f, 4.83564101e-02f, -1.13252230e-01f, 1.53822914e-01f, 6.93767592e-02f, 1.27118183e-02f, 6.58884645e-02f,
  1.56147733e-01f, -1.21117672e-02f, -1.07545435e-01f, -7.21431598e-02f, 2.16712475e-01f, 8.07619244e-02f, 1.89345911e-01f, 2.17598230e-01f, 1.51445463e-01f, 9.60176811e-02f,
  -1.44219905e-01f, 3.73631194e-02f, 2.76321322e-01f, 2.74137519e-02f, -1.37421921e-01f, -1.79196879e-01f, 1.03767188e-02f, -8.06501508e-02f, -3.23768370e-02f, -8.17873031e-02f,
  -1.06737882e-01f, -2.25487024e-01f, -1.40858948e-01f, -9.57637876e-02f, -1.32329255e-01f, -1.23852827e-01f, -2.78155282e-02f, 7.26201534e-02f, 6.90755770e-02f, -7.59626031e-02f,
  2.23642647e-01f, 3.25420856e-01f, -6.83435649e-02f, -1.94568262e-01f, -1.35695497e-02f, -1.74569890e-01f, -1.13638580e-01f, 1.31719008e-01f, 5.93841188e-02f, 2.46105623e-03f,
  -1.70360446e-01f, 5.52118644e-02f, -2.60238573e-02f, 1.59681022e-01f, 3.10316145e-01f, -7.85503238e-02f, -1.48118466e-01f, -2.39143297e-02f, 7.56182522e-02f, -1.54223889e-01f,
  -1.22441538e-01f, -1.51478440e-01f, 3.76372606e-01f, -1.18816264e-01f, -1.10292107e-01f, 1.45488724e-01f, -8.12069401e-02f, -6.20693006e-02f, -1.46102328e-02f, -1.24932289e-01f,
  -1.63251474e-01f, -1.75230280e-01f, -1.22387320e-01f, -4.56767492e-02f, -2.25190092e-02f, 4.52611670e-02f, 4.27701399e-02f, 6.19084015e-02f, -6.52624816e-02f, -1.08865991e-01f,
  8.44134688e-02f, 1.25369862e-01f, 6.89485595e-02f, 1.25073209e-01f, 3.84170152e-02f, -6.29715994e-02f, -6.77090809e-02f, -6.94813058e-02f, -2.17195645e-01f, -5.48461005e-02f,
  -1.65916935e-01f, -5.20369075e-02f, -8.62015113e-02f, 9.86501127e-02f, 2.35412214e-02f, -6.04186393e-02f, -8.53898600e-02f, -3.08962110e-02f, 1.55921251e-01f, -3.89998816e-02f,
  1.01562813e-01f, -1.57656595e-02f, 2.78610904e-02f, -2.74933632e-02f, 3.34325165e-01f, 1.39975384e-01f, -1.10049605e-01f, -1.66711032e-01f, -1.12663314e-01f, 1.47607788e-01f,
  5.73905706e-02f, -3.69074270e-02f, 6.15714453e-02f, -6.19570203e-02f, 1.54610500e-01f, 4.48297150e-02f, -5.63866682e-02f, 1.49230003e-01f, 1.16539933e-01f, -1.14014111e-01f,
  -1.16301753e-01f, 1.93090364e-02f, 2.68571135e-02f, -1.06423631e-01f, 3.57357189e-02f, 8.32127184e-02f, 1.33432344e-01f, -8.82720053e-02f, 1.52497485e-01f, 7.02385455e-02f,
  3.92881334e-02f, -9.04954076e-02f, 1.50898233e-01f, -7.52221746e-03f, -1.79317109e-02f, -1.59819305e-01f, 6.78885803e-02f, 4.08024155e-02f, -2.36816611e-02f, 1.65334076e-01f,
  1.42848685e-01f, -1.57897234e-01f, -3.40988375e-02f, 1.72793999e-01f, 1.01229332e-01f, -7.78472722e-02f, 1.83268432e-02f, 2.27393396e-02f, 1.28048420e-01f, 4.59321290e-02f,
  -3.37649658e-02f, -1.15583487e-01f, -5.01385853e-02f, 1.56824172e-01f, -1.10450715e-01f, -2.01806780e-02f, -1.09691001e-01f, 8.44550952e-02f, 9.26037431e-02f, 1.37308817e-02f,
  -7.87876472e-02f, -1.13678135e-01f, -2.59547923e-02f, 2.68151071e-02f, 4.99013364e-02f, 4.41317335e-02f, -1.05716037e-02f, 3.44376229e-02f, 5.15297335e-03f, 1.45237699e-01f,
  1.14981655e-03f, -1.61702707e-02f, 7.83123225e-02f, -9.20180082e-02f, -1.36278257e-01f, -3.97304334e-02f, -4.67157848e-02f, 1.11220770e-01f, 1.21583134e-01f, 2.59608347e-02f,
  9.14435312e-02f, 7.86248296e-02f, 3.97902057e-02f, -1.59085747e-02f, 1.11296490e-01f, 7.98354521e-02f, 9.18899626e-02f, -6.05033971e-02f, 6.80696294e-02f, 8.25575814e-02f,
  8.22796375e-02f, -1.51209030e-02f, -5.95294535e-02f, 1.54244587e-01f, 1.16840884e-01f, -3.31425406e-02f, 9.61833051e-04f, -1.14453584e-01f, -5.96434139e-02f, -7.08219782e-02f,
  5.92209212e-02f, -3.37626487e-02f, 7.74166882e-02f, -2.87016239e-02f, 2.28125919e-02f, -1.67743955e-02f, -9.72974747e-02f, -1.30917877e-01f, -7.70618990e-02f, 2.63025593e-02f,
  4.48282324e-02f, 4.77792323e-02f, 8.89119282e-02f, -1.48980647e-01f, 6.36692792e-02f, 1.81800444e-02f, 8.95890407e-03f, 6.92124218e-02f, -1.17451556e-01f, -3.63359265e-02f,
  1.12707019e-01f, -6.63838089e-02f, 7.16926306e-02f, 9.42384005e-02f, -7.75056006e-03f, 7.29246438e-02f, 1.07533187e-01f, 1.13748219e-02f, 1.89098585e-02f, -4.05612253e-02f,
  6.52691275e-02f, 7.22911861e-03f, 4.55935486e-02f, -8.09144881e-03f, 2.07045004e-02f, 1.62922852e-02f, 9.82782543e-02f, -2.06280220e-02f, -6.37018913e-03f, -7.84075111e-02f,
  1.14615083e-01f, 8.70389119e-02f, -7.50684217e-02f, -9.30649415e-02f, -5.33275586e-03f, 8.63440428e-03f, 7.34206885e-02f, -9.96747389e-02f, -8.60053226e-02f, -8.31768289e-02f,
  8.03605691e-02f, -9.41412449e-02f, -5.81307113e-02f, -4.59751897e-02f, 2.05734223e-02f, -1.21926978e-01f, 4.71548550e-02f, -1.04170907e-02f, 9.97149199e-02f, -4.40615565e-02f,
  -8.21772218e-02f, 8.56697559e-02f, 1.35127664e-01f, 8.44087601e-02f, 5.50960414e-02f, 1.33084372e-01f, 1.71754044e-02f, 9.97706875e-02f, -5.28666154e-02f, -5.97067848e-02f,
  -1.54536553e-02f, 1.12492345e-01f, -6.64130896e-02f, 1.59784686e-02f, -7.44757280e-02f, -3.49409543e-02f, 1.01743778e-02f, 1.65597111e-01f, 1.20471597e-01f, 4.45017479e-02f,
  -3.18517499e-02f, 3.99786867e-02f, 4.01101559e-02f, -3.21173891e-02f, 6.42389655e-02f, 7.33377784e-02f, -1.83518920e-02f, 3.92085351e-02f, -9.02456194e-02f, 1.05386294e-01f,
  6.14245906e-02f, -8.75168145e-02f, -7.26726428e-02f, -5.88467456e-02f, -6.00283220e-02f, -1.15812242e-01f, -9.70679149e-02f, 1.60311297e-01f, 7.44500235e-02f, 6.77563399e-02f,
  -2.67085992e-02f, -7.89529011e-02f, -8.39141384e-03f, 3.38804163e-02f, -1.44880665e-02f, 1.54247895e-01f, 1.04971148e-01f, 1.82716087e-01f, -6.13706522e-02f, 3.30079608e-02f,
  2.44146530e-02f, 6.06508441e-02f, 3.10785547e-02f, 7.74486139e-02f, -1.77717321e-02f, -7.36506283e-02f, -8.78017917e-02f, 4.18396443e-02f, 1.36772558e-01f, 7.83808082e-02f,
  3.25409174e-02f, 8.04570168e-02f, 1.19365081e-01f, 1.11017451e-01f, 4.51896852e-03f, 7.16079846e-02f, -1.00248635e-01f, -4.89651524e-02f, 1.11104392e-01f, -1.18958637e-01f,
  -1.10925682e-01f, 2.08528582e-02f, 1.06738657e-01f, 1.09750498e-02f, -2.14497894e-02f, 1.96814954e-01f, 1.24701103e-02f, 1.32014975e-01f, 1.93243667e-01f, -2.05688968e-01f,
  1.70174882e-01f, 9.84077454e-02f, -1.02602147e-01f, 1.29652098e-01f, 9.53816324e-02f, -2.72815794e-01f, 1.13549657e-01f, 3.67558822e-02f, 1.03140645e-01f, 1.28598645e-01f,
  3.04897040e-01f, 2.90645748e-01f, 1.63649917e-01f, 2.71209683e-02f, 1.53030768e-01f, 4.56917025e-02f, -7.64870048e-02f, 5.63786253e-02f, -1.19968364e-02f, 7.66103193e-02f,
  -1.19723387e-01f, -1.39144003e-01f, 2.27488056e-01f, 8.27909037e-02f, -7.68111423e-02f, 1.92038015e-01f, 3.03475969e-02f, 2.00401321e-01f, -1.07657216e-01f, 8.30023289e-02f,
  3.18800092e-01f, -2.46694073e-01f, 3.39195551e-03f, -4.92926650e-02f, -1.10724501e-01f, -1.91452384e-01f, 1.88907489e-01f, -1.58503771e-01f, -1.63522959e-02f, 3.51779819e-01f,
  1.67453960e-01f, 3.41791093e-01f, -1.10375084e-01f, 1.04857624e-01f, -2.50988305e-01f, 8.63446966e-02f, -1.00664021e-02f, -6.04574718e-02f, 2.84785079e-03f, 1.74922496e-01f,
  -5.02134971e-02f, 1.12698279e-01f, 1.64674427e-02f, 7.71701941e-03f, 1.23302042e-01f, 9.21315700e-02f, 1.20218970e-01f, 9.05057639e-02f, 2.16017403e-02f, 9.93913934e-02f,
  1.99644610e-01f, -1.28416521e-02f, 8.81122276e-02f, -5.29978834e-02f, -1.06136896e-01f, 1.97833907e-02f, -1.08255155e-01f, -1.32777691e-01f, 9.54529122e-02f, -1.29728183e-01f,
  -1.84388950e-01f, -1.35580927e-01f, -2.51695719e-02f, 6.06053062e-02f, 1.40691370e-01f, 1.79668248e-01f, -5.38692623e-02f, -4.29861881e-02f, 9.41958725e-02f, 2.56667417e-02f,
  -5.29188775e-02f, -9.24471393e-02f, 6.74613100e-03f, -9.46650282e-02f, 4.10615467e-02f, -2.83122867e-01f, 3.03202718e-01f, 2.19144151e-01f, -1.65544599e-01f, 9.58121791e-02f,
  8.48393440e-02f, -8.78063217e-03f, 3.31116877e-02f, 2.46406093e-01f, 5.94464719e-01f, 4.16623764e-02f, -2.82394178e-02f, 7.93048516e-02f, -8.30335692e-02f, -4.35637385e-02f,
  2.29085654e-01f, -1.74496785e-01f, 7.53572881e-02f, 2.15218276e-01f, 3.21354833e-03f, 2.42982674e-02f, -2.56624609e-01f, 1.97843328e-01f, 4.03569490e-02f, 8.83540362e-02f,
  -1.20355591e-01f, 1.22139221e-02f, 9.01836809e-03f, 1.55166686e-01f, 7.30623901e-02f, 8.24129209e-03f, 3.93288583e-02f, 1.04931578e-01f, -4.52491753e-02f, 5.97328320e-02f,
  -9.48012471e-02f, 2.20760018e-01f, 4.86506186e-02f, 6.70417547e-02f, 1.87554002e-01f, -2.85366550e-02f, 9.69888866e-02f, 2.28945948e-02f, 7.26270378e-02f, 3.81824262e-02f,
  1.10903554e-01f, 6.28160387e-02f, 2.23638743e-01f, 3.09616979e-02f, -3.41180339e-02f, 1.03359126e-01f, 6.22681603e-02f, 1.82355363e-02f, -2.69455165e-02f, 1.96614593e-01f,
  3.24371420e-02f, 1.06760308e-01f, 1.03238234e-02f, -6.85269609e-02f, 3.60622108e-02f, 3.91317196e-02f, 9.49437171e-02f, 6.94983453e-02f, 9.86630004e-03f, -1.89897269e-02f,
  -4.67516892e-02f, 6.45024776e-02f, -6.04539178e-02f, -7.19016045e-02f, 2.10950486e-02f, -2.57335082e-02f, -1.23688154e-01f, -1.19307421e-01f, 1.14974864e-01f, 1.30472004e-01f,
  7.32257366e-02f, -1.62968151e-02f, -5.22866435e-02f, 4.57128473e-02f, -6.02338929e-03f, 1.26479596e-01f, 1.25969902e-01f, -6.64111972e-02f, 8.68544206e-02f, -1.15945086e-01f,
  6.72011524e-02f, 9.16126147e-02f, 8.51464346e-02f, -6.08176552e-02f, -3.36119533e-02f, -1.03807516e-01f, -1.20084081e-02f, -5.18930107e-02f, 1.67031080e-01f, 8.97407904e-03f,
  3.18814404e-02f, -7.27655739e-02f, -5.36019392e-02f, 5.24719879e-02f, -6.59319162e-02f, 1.09976515e-01f, 4.15568650e-02f, 4.02736813e-02f, 1.23607583e-01f, -7.07332864e-02f,
  1.64838523e-01f, 2.37058043e-01f, -1.41789287e-01f, 1.18371956e-02f, -4.74283323e-02f, -1.59725785e-01f, -1.47532329e-01f, 1.90631732e-01f, -3.62161510e-02f, -1.03791520e-01f,
  -1.68981478e-01f, 6.33499846e-02f, -1.67037413e-01f, 5.88389225e-02f, -4.70228307e-02f, -6.01028800e-02f, 1.73421398e-01f, -6.02518953e-02f, 9.94209349e-02f, -4.38829474e-02f,
  -2.21106187e-02f, -2.34669968e-02f, 1.38631016e-01f, -1.13806546e-01f, -1.69389725e-01f, -6.99591637e-02f, -1.28071740e-01f, 5.24819009e-02f, -6.64819181e-02f, -1.56616941e-01f,
  -6.83379322e-02f, 3.98950949e-02f, 2.46356174e-01f, 3.03626209e-01f, -1.11786164e-01f, -5.51666692e-03f, 2.35695112e-03f, 2.04273798e-02f, 6.87236860e-02f, -3.76231261e-02f,
  8.70309323e-02f, -1.40085325e-01f, -1.26713514e-01f, -1.90157726e-01f, -1.20917253e-01f, 6.29351288e-02f, 1.53956324e-01f, 9.00354832e-02f, 1.19425192e-01f, 4.02841195e-02f,
  -9.67426524e-02f, 6.65298551e-02f, -4.20003347e-02f, 6.69555441e-02f, 5.02194501e-02f, -4.17868979e-02f, 5.10196574e-02f, -1.49258614e-01f, -9.32789817e-02f, 2.09009647e-02f,
  1.18941359e-01f, 1.01655852e-02f, -2.96824798e-03f, 8.96442682e-02f, 1.05587989e-01f, 5.66862151e-02f, -2.30209902e-02f, -1.46559432e-01f, -1.49996907e-01f, 2.97269616e-02f,
  -7.96656683e-02f, -1.48197366e-02f, -2.65268330e-02f, 4.57489714e-02f, 1.33787259e-01f, 1.26188189e-01f, 3.18551697e-02f, 7.21308962e-02f, -1.11557305e-01f, -1.11657843e-01f,
  1.32175498e-02f, 7.42382929e-02f, -3.58881839e-02f, 1.00636937e-01f, 3.71141285e-02f, -4.22380958e-03f, -5.83531801e-03f, -9.94069204e-02f, -8.07047933e-02f, -1.52572738e-02f,
  7.37877861e-02f, -2.20456310e-02f, -9.59552899e-02f, 1.19719021e-01f, 9.24573615e-02f, -1.24929480e-01f, 7.41841346e-02f, -3.86303514e-02f, -1.30918741e-01f, -9.86616611e-02f,
  -7.65614510e-02f, -1.01819016e-01f, 6.32218421e-02f, -8.34541991e-02f, -1.00193173e-01f, 1.43661365e-01f, 8.62624049e-02f, 9.17982589e-03f, 6.38557225e-02f, 9.53377634e-02f,
  1.23685047e-01f, 8.74585509e-02f, -9.56915021e-02f, -3.63856927e-02f, -8.38777050e-02f, 5.23801334e-02f, -7.64332339e-02f, 6.20134212e-02f, 6.52921200e-02f, 1.20455980e-01f,
  -1.06945634e-01f, -4.44747247e-02f, -8.03034287e-03f, -4.82034236e-02f, 1.80472851e-01f, 1.66336611e-01f, 1.65701717e-01f, 3.28958184e-02f, 1.17498063e-01f, -9.58146974e-02f,
  -9.28727388e-02f, 2.54077524e-01f, 8.97619724e-02f, 2.09147379e-01f, 1.58972427e-01f, -1.14530027e-01f, -8.71922150e-02f, 1.17865168e-01f, -1.53113957e-02f, -1.28718898e-01f,
  -7.25990087e-02f, -9.12602693e-02f, 2.08014160e-01f, -9.47305784e-02f, -1.63674787e-01f, -6.79026395e-02f, 2.41604298e-02f, 2.74338741e-02f, -4.69864048e-02f, 6.85750842e-02f,
  -2.54285574e-01f, 1.12034641e-01f, 2.39977136e-01f, 1.47380248e-01f, 1.02763744e-02f, 1.45617872e-01f, 6.65839240e-02f, 7.91489892e-03f, 5.51191904e-02f, 2.34452501e-01f,
  1.09625250e-01f, -1.57837942e-01f, 7.71728307e-02f, 7.70944124e-03f, 1.72364146e-01f, -1.15171194e-01f, 9.43670422e-02f, -6.45832941e-02f, -8.10862631e-02f, 8.44834521e-02f,
  1.32320017e-01f, 7.93022141e-02f, -9.44313705e-02f, -8.07987079e-02f, -1.21864907e-01f, 1.74319118e-01f, 8.75222608e-02f, -3.52995247e-02f, 1.37620270e-01f, 2.11336613e-01f,
  1.08151853e-01f, 3.15601006e-02f, -8.04540422e-03f, -1.26261413e-01f, 1.24697119e-01f, -6.49240687e-02f, 2.85874726e-03f, 3.38131994e-01f, 4.66674604e-02f, -8.28013849e-03f,
  8.61826390e-02f, 1.61382463e-02f, 9.82329026e-02f, 1.50831416e-01f, 6.91989735e-02f, -5.71344495e-02f, 2.35810429e-02f, 1.41769215e-01f, -6.76810592e-02f, -6.43184111e-02f,
  8.34394246e-03f, 6.82790019e-03f, 1.12471536e-01f, 1.08314283e-01f, 1.56049192e-01f, 1.71211094e-01f, 3.17981541e-02f, -4.42482270e-02f, 3.53473276e-02f, 4.44002002e-02f,
  -1.17916174e-01f, 2.11243890e-02f, -7.83189461e-02f, -4.65643965e-03f, 1.06801623e-02f, -5.01766317e-02f, -6.10422194e-02f, 7.79774636e-02f, 7.05865622e-02f, 1.58350855e-01f,
  6.07872456e-02f, -6.65943744e-03f, 1.60170440e-02f, -4.50651906e-03f, -4.13726754e-02f, 1.24946073e-01f, 4.57516685e-02f, -1.35800898e-01f, -1.02010235e-01f, -1.19174875e-01f,
  -3.09528206e-02f, 4.30086307e-04f, 5.46133965e-02f, 1.17154047e-01f, -5.81095703e-02f, 4.02770080e-02f, -5.69688808e-03f, 6.47949800e-02f, 1.97521839e-02f, -1.74743701e-02f,
  -1.43567011e-01f, 1.31837353e-02f, -8.89156759e-02f, 5.33043146e-02f, -1.06955729e-01f, -7.36267306e-04f, 4.79045138e-02f, 6.69136643e-02f, 1.15436450e-01f, -8.57504979e-02f,
  -4.86595742e-03f, 5.41688018e-02f, 1.08342499e-01f, 9.78743285e-02f, 9.40295961e-03f, 5.17801158e-02f, 1.59922525e-01f, 2.02344984e-01f, -1.50498509e-01f, 1.59454748e-01f,
  8.30635577e-02f, -3.40617937e-03f, 2.19920129e-01f, -1.72527909e-01f, 1.51056021e-01f, -9.57345739e-02f, -1.06697448e-01f, 2.84585673e-02f, -9.62210074e-02f, 1.92877427e-01f,
  -9.00755543e-03f, 1.63678471e-02f, 4.26376536e-02f, 2.38943305e-02f, -3.59103456e-02f, 1.42870516e-01f, -8.51673782e-02f, 2.33864840e-02f, 9.57918838e-02f, -1.01656765e-02f,
  5.93647808e-02f, 1.81978613e-01f, 1.35648949e-02f, -9.33345258e-02f, -6.86601326e-02f, -9.72389057e-02f, -6.27920926e-02f, 8.82707015e-02f, 3.78776640e-02f, 2.62159228e-01f,
  9.32390541e-02f, -4.41591814e-02f, 1.33179218e-01f, -3.09123788e-02f, 1.58510402e-01f, -1.14371486e-01f, 1.33874565e-01f, 9.67759453e-03f, 4.58417237e-02f, -1.31632313e-01f,
  -1.19530655e-01f, -6.22468591e-02f, -6.88229576e-02f, -3.99908796e-03f, -1.43851921e-01f, -6.17409088e-02f, -3.16798910e-02f, -4.74543348e-02f, 1.23132721e-01f, 1.52272999e-01f,
  2.93106735e-02f, -1.21308200e-01f, -2.00931914e-02f, 1.38762891e-01f, -3.69139537e-02f, 2.44753331e-01f, 1.05049387e-01f, -1.50253007e-03f, 4.82348092e-02f, -2.73215380e-02f,
  1.01578556e-01f, 4.78144176e-02f, -1.06406547e-01f, 5.84466346e-02f, -6.98435605e-02f, 1.91516310e-01f, 2.60833114e-01f, -8.67758840e-02f, 1.80693850e-01f, 2.79098824e-02f,
  -6.66124076e-02f, 7.71773905e-02f, -4.47349660e-02f, 1.34373248e-01f, 1.81599826e-01f, 6.23403303e-02f, -1.87487423e-01f, 2.70878244e-02f, -3.34732011e-02f, 2.86480063e-03f,
  -4.77784909e-02f, -1.18346520e-01f, -4.12646122e-02f, 8.78545567e-02f, 1.42971352e-01f, 2.45647550e-01f, -6.63456619e-02f, 9.17909816e-02f, 1.03721887e-01f, -4.53267023e-02f,
  3.26117426e-02f, -7.17569292e-02f, 1.01974547e-01f, -7.88711905e-02f, 6.56989589e-02f, 7.95070007e-02f, 7.30662420e-02f, -8.26748013e-02f, 1.30500674e-01f, 1.69308543e-01f,
  -2.00497378e-02f, -5.15551753e-02f, -1.91833340e-02f, 2.40904856e-02f, 4.56203222e-02f, 6.19355217e-02f, -7.89561868e-02f, 6.39355779e-02f, 5.25413528e-02f, 1.19589388e-01f,
  -8.63810182e-02f, -2.79819639e-03f, 1.84619173e-01f, 1.08837813e-01f, -6.02094270e-02f, -7.62427300e-02f, -1.20972686e-01f, 3.67696248e-02f, 6.20459160e-03f, 2.79304653e-01f,
  1.44616216e-01f, 1.09631114e-01f, 7.75429085e-02f, 1.44137427e-01f, 3.30232494e-02f, 1.02169849e-01f, -7.56690726e-02f, 9.72121954e-02f, 1.90327600e-01f, 1.04407437e-01f,
  1.43489048e-01f, -1.37607187e-01f, 1.95683882e-01f, -2.26079598e-02f, 7.57398829e-02f, -6.44365996e-02f, 1.44340008e-01f, 6.09129295e-02f, 4.68767397e-02f, -2.39236467e-02f,
  -5.41326441e-02f, -3.83759215e-02f, -7.93739874e-03f, -1.08016208e-01f, 2.11500861e-02f, -1.17061054e-02f, -8.61584246e-02f, 1.71488151e-01f, 4.76380531e-03f, -5.65860271e-02f,
  4.45681289e-02f, -1.26980305e-01f, -2.91384049e-02f, 1.06092073e-01f, -1.62966058e-01f, 3.61884199e-02f, 4.74435799e-02f, 1.43886223e-01f, -4.72757705e-02f, 1.43832177e-01f,
  3.38370413e-01f, -7.68543035e-02f, 1.19401053e-01f, -6.26459792e-02f, -7.22227246e-02f, 9.72285643e-02f, -1.17606809e-02f, 1.56312361e-01f, 2.22748861e-01f, 1.92588884e-02f,
  -1.31545573e-01f, 1.39397845e-01f, -1.22306228e-01f, -1.18867613e-01f, 5.75065166e-02f, 6.19805977e-02f, -1.11875191e-01f, 1.21804863e-01f, -1.37132004e-01f, 4.41633910e-03f,
  6.71936646e-02f, 2.76728757e-02f, 1.24582779e-02f, -3.72982174e-02f, 1.39620692e-01f, -8.74744281e-02f, 1.03536308e-01f, 8.65559280e-02f, 7.24129900e-02f, 7.49643967e-02f,
  -1.12520859e-01f, 1.05958998e-01f, 6.59030452e-02f, -3.72677036e-02f, 6.04157597e-02f, 3.24334688e-02f, -7.06172315e-03f, 7.48504251e-02f, 9.02646482e-02f, -4.46435064e-02f,
  -1.55572481e-02f, 7.26007894e-02f, -1.15532957e-01f, -5.54284006e-02f, -1.01893522e-01f, 6.29826561e-02f, 1.01192951e-01f, -5.25095239e-02f, 2.93850489e-02f, -6.31354749e-02f,
  -6.25083316e-03f, -8.23519304e-02f, 6.09793924e-02f, -1.00658666e-02f, -9.58707184e-03f, 1.10264860e-01f, -1.55006079e-02f, -6.22037165e-02f, -7.46561587e-02f, -9.22814533e-02f,
  -3.78424339e-02f, 4.22771126e-02f, 7.18716159e-02f, 8.10455456e-02f, -3.49810719e-02f, -8.71427059e-02f, -6.61170855e-02f, 5.69311343e-02f, -6.42237440e-02f, 1.02607161e-01f,
  6.09795190e-02f, 1.17346287e-01f, -1.29106477e-01f, 1.43390521e-02f, -1.20801196e-01f, 2.54116068e-03f, 9.66943651e-02f, -3.44381817e-02f, 1.10723391e-01f, 2.09258553e-02f,
  -9.21521261e-02f, -1.03297614e-01f, -8.31429735e-02f, -7.27259964e-02f, 1.01689674e-01f, -4.33439612e-02f, 5.95598407e-02f, -6.81554824e-02f, 5.78989126e-02f, 3.49113010e-02f,
  -8.88920277e-02f, -1.58104803e-02f, 9.25606266e-02f, 9.26989391e-02f, 1.17156757e-02f, -7.65131786e-02f, -1.36027232e-01f, -2.29700089e-01f, -4.87783700e-02f, 7.09663555e-02f,
  -5.56643829e-02f, 1.16268871e-02f, -1.15970464e-03f, 7.36399963e-02f, 2.54416261e-02f, -1.22945979e-01f, 1.13600038e-01f, 4.78001460e-02f, 4.31648828e-02f, 2.75167003e-02f,
  -2.75857411e-02f, 1.05046378e-02f, -8.44138786e-02f, -2.65058242e-02f, -1.21688396e-01f, 2.51877867e-02f, 7.47891739e-02f, -8.51133019e-02f, -1.08191900e-01f, -9.55656767e-02f,
  -1.29072055e-01f, -4.39078361e-02f, -5.39418273e-02f, 5.26909484e-03f, 4.65942770e-01f, -7.53405690e-02f, -2.20339485e-02f, -4.15634774e-02f, -6.73826784e-02f, 5.73254749e-02f,
  -5.74251413e-02f, -1.27384484e-01f, 7.60061443e-02f, 1.18900716e-01f, -8.96011591e-02f, 1.03609324e-01f, 5.14039434e-02f, 1.37957126e-01f, -6.63335770e-02f, 1.56837776e-01f,
  1.47351250e-01f, 2.49820743e-02f, 1.46731511e-01f, 1.11568354e-01f, -2.77792588e-02f, 9.55598205e-02f, 6.62736967e-02f, 7.19129592e-02f, 1.44735619e-01f, 4.36287411e-02f,
  -3.78584266e-02f, 1.29459426e-01f, 3.02791316e-02f, -1.68206930e-01f, 5.84541038e-02f, -1.31067306e-01f, -2.67171189e-02f, -1.25516012e-01f, -3.03893406e-02f, 5.93538769e-02f,
  -7.09158182e-02f, 1.09362127e-02f, -8.83495882e-02f, -3.40816565e-02f, -2.16269009e-02f, 1.20382287e-01f, -6.59488067e-02f, 1.22802399e-01f, 1.68998763e-02f, 9.38183162e-03f,
  6.35535941e-02f, -2.77587883e-02f, -1.08760320e-01f, 7.30054155e-02f, 2.58325357e-02f, -7.95820877e-02f, 9.18463320e-02f, 4.51941863e-02f, -3.47021297e-02f, -6.80813752e-03f,
  1.29355788e-01f, -5.47282584e-02f, 1.30038813e-01f, 1.50604442e-01f, 4.42714579e-02f, 9.09944698e-02f, -8.64171144e-03f, -6.78839535e-02f, -5.50356507e-02f, -8.10863823e-02f,
  -6.16647713e-02f, -7.40907248e-03f, 1.43306017e-01f, 1.10760937e-02f, -6.33712932e-02f, -8.93608332e-02f, 6.61856458e-02f, 1.24692403e-01f, 9.40207019e-02f, 7.40387589e-02f,
  -3.60833481e-02f, 8.02379251e-02f, -2.71187015e-02f, -3.93985249e-02f, -1.43462420e-03f, 9.11537334e-02f, 9.14501492e-03f, -1.09535769e-01f, 1.38217822e-01f, 1.10862348e-02f,
  1.06563635e-01f, 1.72225107e-02f, -4.61352654e-02f, -8.23224336e-03f, 3.34934611e-03f, -5.21472376e-03f, -2.60406956e-02f, 5.06401993e-02f, -3.78012247e-02f, -2.52665374e-02f,
  -8.72520059e-02f, 1.87532067e-01f, 6.04111105e-02f, -3.81453000e-02f, -1.61322549e-01f, -1.95660323e-01f, -1.35734424e-01f, -1.68409467e-01f, -6.79911003e-02f, 8.59029293e-02f,
  4.15195636e-02f, 8.40363353e-02f, 2.18052745e-01f, 1.35215446e-01f, 9.14403051e-02f, 7.44139850e-02f, 1.69567183e-01f, 4.72986698e-02f, 2.28475723e-02f, 1.05959877e-01f,
  2.04815697e-02f, -6.36142716e-02f, 1.73238397e-01f, 8.26296508e-02f, 1.29454195e-01f, 9.24426690e-02f, -3.23399641e-02f, 2.33569115e-01f, -9.56502706e-02f, -1.00846924e-02f,
  -8.93132687e-02f, 7.19339177e-02f, 2.98779104e-02f, -1.37752056e-01f, -7.30088726e-02f, 1.71131581e-01f, -1.20798714e-01f, -7.96388760e-02f, -9.66422483e-02f, -1.07359499e-01f,
  -9.99943092e-02f, 1.51835307e-01f, 8.06832165e-02f, 1.66743830e-01f, -1.41073987e-01f, 5.19129932e-02f, -6.50541559e-02f, -8.75973776e-02f, -1.14010148e-01f, 4.60166559e-02f,
  -1.36798531e-01f, -5.41171320e-02f, 7.84388706e-02f, 6.21321909e-02f, -1.24251109e-03f, 6.27135411e-02f, 1.03273399e-01f, 5.02030551e-02f, 1.46032527e-01f, -7.88771585e-02f,
  -1.61010459e-01f, -7.97601342e-02f, -7.50276595e-02f, 4.81132753e-02f, -6.57142466e-03f, -1.53127238e-01f, 6.25338289e-04f, -6.23606853e-02f, 3.50884423e-02f, -5.55416420e-02f,
  -4.81084995e-02f, 1.31897599e-01f, -1.00136153e-01f, -1.80363208e-02f, 8.33366439e-02f, 6.98200017e-02f, 1.45265743e-01f, -7.47083277e-02f, -1.62959360e-02f, -9.82071906e-02f,
  4.34083417e-02f, -1.24501429e-01f, -1.20029688e-01f, -1.91717017e-02f, 1.02840170e-01f, 3.52855623e-02f, -2.95135863e-02f, 4.80019562e-02f, 1.61579400e-01f, -4.95176353e-02f,
  8.86726230e-02f, 1.47561178e-01f, -1.25777319e-01f, -1.82675850e-02f, 3.18860486e-02f, 1.25728071e-01f, 2.72491366e-01f, 1.01407040e-02f, -5.19548580e-02f, 4.84657055e-03f,
  1.69247150e-01f, 1.19805202e-01f, -8.29226524e-02f, 9.80118057e-04f, 1.48374766e-01f, 1.33543432e-01f, 9.15392563e-02f, 2.40381807e-02f, 1.30803406e-01f, -6.00074492e-02f,
  -8.44552442e-02f, 2.64588185e-02f, 8.29513818e-02f, 4.21703085e-02f, 2.64448542e-02f, -6.62017092e-02f, -5.58978580e-02f, -1.07562374e-02f, 5.12822308e-02f, -2.18987279e-02f,
  4.77518281e-03f, -4.50210460e-02f, -2.26043556e-02f, -6.87089562e-02f, 2.38395724e-02f, 2.10623145e-01f, 7.02091679e-03f, 4.45343331e-02f, 1.83058545e-01f, 1.05577454e-01f,
  2.01028176e-02f, 1.02344900e-01f, -8.86117965e-02f, 8.91174003e-02f, 5.32574244e-02f, 3.98726463e-02f, 1.04974121e-01f, -1.34594485e-01f, -1.06725961e-01f, -6.59971498e-03f,
  4.24135365e-02f, -2.19570473e-02f, -1.21235088e-01f, 6.75219819e-02f, 1.36735484e-01f, 4.87251766e-02f, 4.47173119e-02f, 1.22324256e-02f, -6.86696172e-02f, -3.31029519e-02f,
  6.12788759e-02f, -1.96873933e-01f, -1.23811010e-02f, -9.37080085e-02f, -7.81552345e-02f, -1.32882610e-01f, -2.81515680e-02f, 1.02134056e-01f, -1.17913842e-01f, 5.99850491e-02f,
  2.20829248e-01f, 8.18299968e-03f, -3.71038914e-02f, 2.78416630e-02f, -3.33259217e-02f, 9.38822981e-03f, 1.13115400e-01f, -2.35537291e-02f, -1.07810490e-01f, 7.23352060e-02f,
  -1.56664789e-01f, -9.60114673e-02f, 8.74848515e-02f, 1.53233647e-01f, 1.17305011e-01f, 5.08378446e-02f, 8.42284039e-02f, -1.05502196e-02f, -3.99092846e-02f, 2.61529535e-02f,
  4.49116863e-02f, 6.52268529e-02f, 3.25558707e-02f, 1.37943849e-01f, 2.54384913e-02f, -6.35126680e-02f, 8.82626250e-02f, -5.82517721e-02f, 2.65676469e-01f, 1.09778926e-01f,
  2.79624403e-01f, 2.14551046e-01f, 2.54121661e-01f, -1.13475434e-02f, -1.78741738e-01f, 1.93851218e-01f, 1.34721249e-01f, 8.74564573e-02f, 2.15177923e-01f, -2.04924062e-01f,
  2.12304831e-01f, -1.64756849e-01f, 1.55784726e-01f, -6.54217303e-02f, 7.54616335e-02f, 2.39054099e-01f, 4.00856324e-02f, -1.03830576e-01f, 1.40104637e-01f, 1.74649552e-01f,
  6.78772777e-02f, 1.16304420e-01f, 9.00020599e-02f, -7.08129955e-03f, 8.66621435e-02f, -1.51265755e-01f, 1.84141286e-02f, -5.82991317e-02f, -5.82877360e-02f, -9.54510644e-02f,
  -4.71362704e-03f, -6.07764088e-02f, 1.43829631e-02f, -4.35385518e-02f, 1.75688788e-01f, 1.41183749e-01f, 2.29417607e-02f, -1.52810127e-01f, 1.91755705e-02f, -1.26762733e-01f,
  1.96624026e-01f, -1.13255776e-01f, 8.64167586e-02f, 1.67597264e-01f, -7.10330158e-02f, 1.61833167e-01f, -3.99611704e-02f, 1.43727645e-01f, -2.00318508e-02f, -5.87625019e-02f,
  -7.26081571e-03f, 2.03377530e-02f, -6.19771592e-02f, -4.21970412e-02f, -1.16512872e-01f, 1.41549511e-02f, -4.44888361e-02f, 1.20510757e-01f, 3.40351835e-02f, 6.84428513e-02f,
  -1.52793854e-01f, 1.94257259e-01f, 1.12126665e-02f, 2.76746266e-02f, 1.64508834e-01f, 6.08149692e-02f, -6.50189072e-02f, 8.68648142e-02f, 9.08155441e-02f, -2.97251493e-02f,
  -1.80705842e-02f, -1.64371021e-02f, -9.31043550e-02f, 1.40266448e-01f, -3.12287472e-02f, -3.37377377e-02f, -2.81217272e-05f, 1.30818998e-02f, 2.25975141e-02f, -5.77078275e-02f,
  -6.39016926e-02f, -1.41370222e-01f, -5.80291934e-02f, -3.77706140e-02f, 5.37575558e-02f, -1.38595894e-01f, -3.21753658e-02f, -1.36777490e-01f, 1.93374634e-01f, 2.03858808e-01f,
  -4.12425213e-03f, -1.75800532e-01f, -1.39476150e-01f, 6.33360222e-02f, -7.60705117e-03f, -1.53944967e-02f, 4.78658676e-02f, -9.93209630e-02f, -1.37728751e-01f, 3.39747407e-02f,
  6.02057911e-02f, -3.27356532e-03f, 3.17691773e-01f, -1.06689654e-01f, -1.23751536e-01f, 4.61604074e-03f, -7.96295553e-02f, -2.63916831e-02f, -6.61467537e-02f, -7.82044679e-02f,
  1.94182128e-01f, -6.22904897e-02f, 2.08556708e-02f, 1.06489204e-01f, 1.19093813e-01f, -1.23420909e-01f, 1.59846991e-01f, -1.37767822e-01f, -7.92475343e-02f, 1.43764932e-02f,
  -9.28466991e-02f, 3.03236991e-02f, 8.14331546e-02f, -6.15959354e-02f, 8.99856985e-02f, -1.94061585e-02f, 1.35992587e-01f, 6.08318597e-02f, 1.56934530e-01f, 1.74654186e-01f,
  1.49207953e-02f, 9.36040655e-02f, 8.22613165e-02f, 9.75932553e-02f, 2.74427712e-01f, 1.33938164e-01f, 1.91377476e-02f, 3.65619920e-02f, 1.85350329e-01f, 5.61015829e-02f,
  -6.01682030e-02f, -2.42591910e-02f, -6.38909191e-02f, 1.92152873e-01f, -4.87011820e-02f, 9.88001153e-02f, 1.40070766e-01f, 1.05464205e-01f, -1.10288396e-01f, 6.13993816e-02f,
  5.91794997e-02f, 3.58525733e-03f, 1.43773273e-01f, 7.13916868e-02f, -4.93607335e-02f, 3.72567587e-02f, -1.00529499e-01f, -1.92938354e-02f, 2.29444131e-02f, -2.96715945e-02f,
  -3.80217261e-03f, -1.43631071e-01f, -1.08413221e-02f, 2.60433048e-01f, -2.40933765e-02f, 1.06129525e-02f, 2.18463205e-02f, -5.40742017e-02f, 1.12578943e-01f, -3.81461158e-02f,
  1.10853851e-01f, -6.71697035e-02f, 9.09241140e-02f, -4.12624441e-02f, -4.82256375e-02f, -6.15853444e-02f, 1.76517814e-02f, -3.35925184e-02f, 1.70007013e-02f, 8.51965845e-02f,
  8.51037130e-02f, -1.18267789e-01f, 7.31615126e-02f, 5.27599677e-02f, 9.82821360e-03f, -1.87181812e-02f, -8.13590959e-02f, 3.93674932e-02f, 1.36680007e-01f, -4.60521169e-02f,
  -2.84708086e-02f, 6.69628829e-02f, -1.11589089e-01f, 1.19620161e-02f, 5.78967249e-03f, 8.15446228e-02f, -3.90992276e-02f, -1.63340330e-01f, -1.37452871e-01f, -1.48369670e-01f,
  -1.12347826e-01f, -1.65567845e-01f, -1.13569714e-01f, 7.46708289e-02f, 7.89422616e-02f, -4.97820526e-02f, 2.28147969e-01f, 1.03402212e-01f, 8.01350996e-02f, -2.22223569e-02f,
  8.35942179e-02f, 1.92812607e-02f, 8.69080350e-02f, 1.58742890e-02f, -1.48553610e-01f, -1.69645119e-02f, 1.53593644e-01f, 1.58756580e-02f, -3.51368040e-02f, 6.02760501e-02f,
  -9.89317894e-02f, 2.15673268e-01f, 5.21572605e-02f, 4.48562428e-02f, 8.33491981e-02f, -3.78501266e-02f, 1.14973545e-01f, -8.61624181e-02f, -1.18116796e-01f, 1.21364027e-01f,
  -2.93348785e-02f, 1.47439986e-02f, -3.83961238e-02f, 1.12430967e-01f, -1.57534257e-01f, -2.51049399e-02f, 6.97805453e-03f, 1.77993834e-01f, -1.49827625e-03f, -5.25713600e-02f,
  2.73184851e-02f, -9.90690570e-03f, 5.31800976e-03f, -7.76572749e-02f, -8.33448470e-02f, 1.35637254e-01f, -3.03092576e-03f, 1.12043820e-01f, 4.01184596e-02f, 2.93654278e-02f,
  -1.01489983e-01f, 9.36636776e-02f, -4.75222804e-03f, 5.05127981e-02f, 7.14635029e-02f, 5.47270402e-02f, -1.14867240e-01f, -1.31900042e-01f, 2.91745495e-02f, -6.21597543e-02f,
  -1.28928855e-01f, 1.33295909e-01f, 1.56075239e-01f, -5.60862944e-02f, -6.73549697e-02f, -2.08914906e-01f, 5.53511940e-02f, -9.91827399e-02f, -1.78226493e-02f, 1.05868928e-01f,
  -4.44109812e-02f, 1.12415642e-01f, 1.44042835e-01f, -8.05617198e-02f, -6.06045872e-02f, -1.01514846e-01f, 1.03700154e-01f, -4.04870249e-02f, -2.73770243e-02f, 1.02661900e-01f,
  -1.57135874e-02f, 2.07684666e-01f, 7.36013055e-02f, 1.78361160e-03f, -1.28956854e-01f, -8.22945461e-02f, -1.15735501e-01f, 4.07337397e-02f, -8.34577531e-02f, 1.30295172e-01f,
  1.92902565e-01f, 7.91988969e-02f, 3.81604186e-03f, 1.61345407e-01f, 2.83853918e-01f, -1.36043414e-01f, 1.32971227e-01f, 4.54369606e-03f, 2.84659378e-02f, 7.91681856e-02f,
  6.54742122e-02f, 1.25490665e-01f, 1.51047841e-01f, -2.74354033e-02f, -9.64499339e-02f, 2.33234689e-01f, -1.42909199e-01f, 6.36145333e-03f, -9.98139605e-02f, 7.54433498e-02f,
  -1.13167286e-01f, 7.56668253e-03f, -7.22101480e-02f, -2.62769368e-02f, 2.35618018e-02f, 1.58717051e-01f, 2.38101352e-02f, -4.30584215e-02f, 8.81398693e-02f, 2.19123483e-01f,
  -5.15667489e-03f, 3.82194929e-02f, 7.50228064e-03f, 3.28690231e-01f, 1.09451182e-01f, -8.66451487e-02f, -3.83264661e-01f, -9.04035717e-02f, -3.20623249e-01f, -1.62157357e-01f,
  -1.50178879e-01f, 7.28540793e-02f, 2.49578699e-01f, 5.38594741e-03f, -7.95797408e-02f, 2.78968196e-02f, 1.46730198e-02f, -8.65199883e-03f, 4.34113853e-02f, -9.50554609e-02f,
  6.70009255e-02f, 1.71430066e-01f, 8.28068703e-02f, -3.76646891e-02f, 1.43997520e-01f, 9.66877639e-02f, -7.67910806e-03f, 1.76941469e-01f, 1.32470012e-01f, 1.83218837e-01f,
  1.44422776e-03f, -1.58430070e-01f, 7.88647532e-02f, -5.88348359e-02f, 1.42979383e-01f, -1.53846338e-01f, -6.07804134e-02f, 6.57491758e-02f, -2.54270762e-01f, -8.83492753e-02f,
  -4.67097498e-02f, 1.29562899e-01f, -1.46845385e-01f, -1.05832191e-02f, 9.23351049e-02f, -1.95102230e-01f, 6.45974949e-02f, -1.26055762e-01f, 1.46117225e-01f, -1.60663545e-01f,
  -3.73640880e-02f, -1.32194057e-01f, -1.97006911e-01f, 1.16146594e-01f, 1.02949075e-01f, 2.15264544e-01f, 1.67538635e-02f, 9.12305489e-02f, -2.00638190e-01f, 4.16318625e-02f,
  8.09875801e-02f, 4.70370874e-02f, -1.53997585e-01f, 8.14096406e-02f, -1.10009238e-01f, 2.71987617e-02f, -8.12107176e-02f, 1.65376380e-01f, -2.79763013e-01f, -1.00762717e-01f,
  1.88775882e-01f, 1.86151378e-02f, -2.13554457e-01f, 3.11178267e-01f, -5.70579618e-02f, -9.48733240e-02f, -8.26972350e-02f, -9.85249877e-02f, -1.42069608e-01f, 2.39841174e-03f,
  -6.96744844e-02f, 6.66250288e-03f, 2.21498325e-01f, 1.71760783e-01f, -5.06684184e-02f, -4.41871546e-02f, 9.38726366e-02f, 6.82832450e-02f, 1.47137091e-01f, -2.36359045e-01f,
  -1.85447484e-01f, -2.60417104e-01f, 1.68985967e-02f, -1.37471482e-01f, -1.12942114e-01f, -1.53204665e-01f, 5.96385114e-02f, 2.00801909e-01f, 5.64086556e-01f, 3.99221212e-01f,
  5.03278039e-02f, -6.46555200e-02f, -1.37620091e-01f, 1.37453616e-01f, -2.90887263e-02f, -1.18523151e-01f, 2.30225064e-02f, 1.06721774e-01f, -7.67519847e-02f, -3.16543505e-02f,
  -1.61425561e-01f, 2.70685583e-01f, 2.62395889e-01f, -6.06482588e-02f, 6.36116415e-02f, 1.06078215e-01f, -1.18591890e-01f, -1.21033236e-01f, -4.00429927e-02f, -1.56314984e-01f,
  1.20705403e-01f, 1.41483873e-01f, -2.28104796e-02f, -4.02722992e-02f, -1.94415733e-01f, 3.82779795e-03f, -5.80641590e-02f, 6.79507405e-02f, -6.24586679e-02f, -5.99731244e-02f,
  5.26751727e-02f, 1.69089779e-01f, -1.19342752e-01f, 1.09287247e-01f, -5.04652672e-02f, -4.93148379e-02f, 7.58930817e-02f, 9.65605378e-02f, -5.62843084e-02f, -3.04227415e-02f,
  5.73099442e-02f, -1.24120645e-01f, -1.36941627e-01f, -1.15528367e-02f, -1.55386226e-02f, -1.47918472e-02f, 1.23051465e-01f, 1.34903386e-01f, 3.21369767e-02f, -3.20137516e-02f,
  5.48838489e-02f, -1.16690509e-01f, 6.31756932e-02f, -3.39385904e-02f, -1.51491448e-01f, -3.89638767e-02f, 3.15900929e-02f, 9.34902020e-03f, 8.12182799e-02f, 5.04569197e-03f,
  -1.61258914e-02f, 4.68227565e-02f, 1.46361262e-01f, 7.09414035e-02f, -7.87233561e-02f, -8.95019472e-02f, -1.13704905e-01f, 6.82279617e-02f, 2.20376113e-03f, -6.18024729e-02f,
  -6.62597641e-02f, 1.01395302e-01f, 1.49974674e-02f, -4.55040997e-03f, -1.30378470e-01f, -6.77777454e-02f, 3.11258379e-02f, -3.00714895e-02f, -1.38309509e-01f, 4.19685990e-02f,
  -5.62039092e-02f, -2.11200155e-02f, -8.21689665e-02f, -6.10262081e-02f, -8.90341252e-02f, 1.18235283e-01f, 4.90110703e-02f, 6.34418875e-02f, -8.73303711e-02f, 6.74465224e-02f,
  3.32380444e-01f, 6.30626231e-02f, 1.62942216e-01f, 7.36624599e-02f, 3.57832491e-01f, 1.94138244e-01f, -6.25618771e-02f, 2.23870814e-01f, 2.55549014e-01f, 2.57980376e-01f,
  1.14057735e-01f, -2.17502922e-01f, 3.33209842e-01f, -1.53523073e-01f, 2.13801980e-01f, -1.30271703e-01f, 1.66859210e-01f, 1.74747527e-01f, -4.15235497e-02f, -1.39156312e-01f,
  1.09839536e-01f, 6.24063350e-02f, -1.51655942e-01f, 1.56800792e-01f, 6.30689878e-03f, -6.96016774e-02f, 1.35768175e-01f, 2.51251459e-01f, -3.46701518e-02f, 1.59622114e-02f,
  -1.02706276e-01f, -8.96937177e-02f, 1.79061949e-01f, 4.58543301e-02f, -1.71652809e-02f, -6.15202338e-02f, -1.55827045e-01f, 3.43329757e-01f, 2.01230384e-02f, -6.63428828e-02f,
  1.57174483e-01f, 4.33899201e-02f, 1.67140793e-02f, 5.24474159e-02f, 3.89871001e-02f, 7.90194981e-03f, 4.52478901e-02f, -4.16211002e-02f, 1.34366587e-01f, 3.14517654e-02f,
  4.84269038e-02f, 5.02197258e-02f, -1.15728311e-01f, -7.48210400e-02f, -1.30535081e-01f, -9.13775899e-03f, -5.42975925e-02f, 1.12698435e-04f, -7.18179569e-02f, 3.22033348e-03f,
  -1.25925139e-01f, -2.68667601e-02f, 5.20516746e-02f, 1.06150873e-01f, 1.21112414e-01f, 2.72850487e-02f, -8.12557191e-02f, -2.11130995e-02f, -8.29719901e-02f, 1.71594337e-01f,
  1.12465523e-01f, -1.72120184e-01f, -2.40001664e-01f, -3.02969009e-01f, -1.94583267e-01f, 1.59224793e-01f, -6.23728633e-02f, -6.59565926e-02f, -9.02714580e-02f, 9.02871937e-02f,
  8.87475461e-02f, -7.59836063e-02f, 9.14838091e-02f, -8.13966524e-03f, 1.54011130e-01f, -2.73979753e-02f, 5.74075570e-03f, -1.12205379e-01f, -1.15935117e-01f, 7.73208812e-02f,
  3.13947424e-02f, 1.72756426e-02f, -3.21470946e-02f, 2.57681999e-02f, -3.62610933e-03f, 2.32435912e-02f, -1.34432316e-01f, -3.91824506e-02f, -2.52293851e-02f, -9.25488323e-02f,
  5.13312459e-01f, -7.10417479e-02f, -6.78377524e-02f, -5.16855754e-02f, -2.85351034e-02f, 2.49383263e-02f, -1.03689104e-01f, -1.15277907e-02f, 1.74633190e-01f, -1.71104800e-02f,
  1.79106947e-02f, -1.27103493e-01f, -1.60232082e-01f, 1.40315756e-01f, 1.40901268e-01f, 1.32357627e-01f, 9.14389491e-02f, -1.45368844e-01f, -9.85971764e-02f, -6.56187460e-02f,
  4.44352329e-02f, -1.82077177e-02f, 1.63379729e-01f, -6.31137714e-02f, 9.18141603e-02f, 1.15933381e-02f, 9.10419151e-02f, 8.95350650e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.63052306e-01f, -2.23325733e-02f, 1.11337066e-01f, 1.41858175e-01f, 6.08549714e-02f, 8.35591704e-02f, 1.11487083e-01f, 1.93061695e-01f, 1.33213624e-01f, 1.36392474e-01f,
  -1.12012913e-02f, 1.07820958e-01f, -8.62106085e-02f, -6.43405691e-02f, 8.49650204e-02f, 1.61324739e-02f, -5.43328710e-02f, 1.72409620e-02f, 8.59010294e-02f, 4.27295677e-02f,
  -2.43396442e-02f, 1.32647589e-01f, 1.66434750e-01f, 6.80457875e-02f, -3.40331830e-02f, -5.97242899e-02f, 9.60956328e-03f, 8.94785449e-02f, -8.94003175e-03f, 7.30131790e-02f,
  4.72225435e-02f, 7.64117613e-02f, 1.27815574e-01f, 1.54715821e-01f, -3.38141546e-02f, -3.77636366e-02f, -3.41580287e-02f, -6.63361102e-02f, 6.55693114e-02f, 4.35583480e-03f,
  -1.04426712e-01f, 1.83085784e-01f, 2.29773045e-01f, 1.09047061e-02f, 6.40232340e-02f, -8.16854089e-02f, 8.39412138e-02f, 2.06905976e-01f, 6.51165992e-02f, 3.01594753e-02f,
  2.99872071e-01f, 1.23722136e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.94870913e-01f, -4.32674319e-01f, -4.29037005e-01f, -2.12744027e-01f, -1.67182907e-01f, -2.02044189e-01f, 1.78352162e-01f, 2.71884292e-01f, -1.57649830e-01f, -4.23089206e-01f,
  -3.39011252e-01f, -3.01995337e-01f, -3.67206917e-03f, 9.52998102e-02f, -7.06066191e-02f, -1.49815768e-01f, 1.51396200e-01f, -7.34314993e-02f, -9.59111471e-03f, -1.46668598e-01f,
  -2.66610950e-01f, 5.06917574e-02f, 1.95639521e-01f, -6.84268177e-02f, 1.44477859e-01f, 7.16335773e-02f, -4.24263626e-02f, 3.02845966e-02f, 3.04394096e-01f, 1.72880501e-01f,
  -3.24751884e-02f, -3.40390392e-02f, 8.46292302e-02f, -1.74441308e-01f, -1.86680198e-01f, 1.52270868e-01f, -9.92215704e-04f, 2.02258900e-01f, 5.06144524e-01f, 2.82481909e-01f,
  -1.53268084e-01f, -7.40296319e-02f, 2.52942629e-02f, 1.55597970e-01f, -3.97797562e-02f, -2.00205609e-01f, -2.45909300e-02f, 1.29398674e-01f, -1.38636142e-01f, 3.36365819e-01f,
  -8.07465166e-02f, 1.99152768e-01f, 2.11963087e-01f, 1.04913287e-01f, -1.76037252e-01f, 8.10287986e-03f, -1.41142085e-01f, 1.72295183e-01f, 2.08073169e-01f, -2.14180410e-01f,
  2.68742964e-02f, -5.39479889e-02f, -3.33835065e-01f, 2.25779153e-02f, 1.11890920e-01f, 1.66081250e-01f, -2.11966425e-01f, -2.17119336e-01f, -4.87167597e-01f, -1.27870381e-01f,
  -2.81514853e-01f, -3.71709317e-01f, 1.60397634e-01f, -2.05099881e-01f, 2.09692363e-02f, -9.84416306e-02f, -1.18160948e-01f, -1.52581677e-01f, -1.84074312e-01f, 3.78600836e-01f,
  4.46894944e-01f, 3.68175209e-01f, -2.64404982e-01f, -7.97578692e-01f, -7.69089768e-03f, 2.51530588e-01f, 3.34495276e-01f, -1.01656668e-01f, -1.38734085e-02f, 9.82447267e-02f,
  3.67269702e-02f, -2.04734877e-02f, 2.86567658e-01f, 2.06097081e-01f, 9.06474739e-02f, -1.07143708e-01f, -9.36165750e-02f, -3.84296849e-03f, -1.34251535e-01f, -2.06906646e-01f,
  -3.69777456e-02f, -6.59839883e-02f, 3.59408110e-01f, 4.32872683e-01f, 5.46441153e-02f, -2.66581863e-01f, -1.88099608e-01f, 5.65032184e-01f, -1.35576919e-01f, 1.21925492e-03f,
  3.41905475e-01f, 1.31364167e-01f, 6.05705343e-02f, -6.92221224e-02f, 1.74164340e-01f, -2.09552616e-01f, 6.14444613e-02f, -8.08829144e-02f, 1.20325655e-01f, 1.08396038e-02f,
  -2.75153041e-01f, -6.07477576e-02f, 1.48906842e-01f, -2.76671261e-01f, -2.82177031e-01f, -1.01108044e-01f, -2.56039977e-01f, -1.80289090e-01f, 2.99983352e-01f, 1.89028904e-01f,
  9.23846960e-02f, 2.72687346e-01f, 6.43451273e-01f, 1.91334769e-01f, 5.37735701e-01f, -3.71837795e-01f, -5.14806211e-01f, 2.76937783e-01f, -1.20838851e-01f, 3.40328723e-01f,
  5.29014409e-01f, -7.20438361e-02f, 2.29630638e-02f, 6.46112040e-02f, 2.56025404e-01f, -1.48089334e-01f, 1.03026293e-02f, 1.86325416e-01f, -1.70110524e-01f, 2.20974699e-01f,
  -3.49204615e-02f, 1.70108955e-02f, -5.89407422e-02f, -1.01490812e-02f, 6.17275871e-02f, -5.94669282e-02f, 2.55752020e-02f, -4.96276394e-02f, -1.18491888e-01f, 3.77030820e-01f,
  -1.33294582e-01f, -2.86025286e-01f, -1.77387148e-01f, 1.32729262e-01f, 3.22055370e-02f, -4.49754968e-02f, -1.47497188e-02f, 2.44239390e-01f, 6.38481155e-02f, 9.94462743e-02f,
  5.41417524e-02f, 2.29985416e-01f, -1.89882834e-02f, 2.19717816e-01f, 2.42349669e-01f, -1.26603082e-01f, -8.89184698e-02f, 1.35671929e-01f, -1.21940270e-01f, -2.61888262e-02f,
  -1.90715760e-01f, 9.66680422e-02f, -1.18360586e-01f, -7.51931891e-02f, -7.81396106e-02f, -2.51442157e-02f, -8.25530738e-02f, 3.14309895e-01f, -4.30082202e-01f, 6.70498833e-02f,
  -5.79724535e-02f, 2.48579994e-01f, -3.79058003e-01f, 3.72053571e-02f, -3.00533753e-02f, 1.31582633e-01f, -1.97728947e-01f, -2.17998236e-01f, 2.32702538e-01f, 1.17619067e-01f,
  5.11915922e-01f, 1.30375400e-01f, 3.42646599e-01f, -3.80199701e-01f, 3.09198759e-02f, 1.62941486e-01f, 4.00136292e-01f, -1.43119216e-01f, -7.02327788e-02f, -9.63472724e-02f,
  1.45760432e-01f, 1.41986504e-01f, -2.25948408e-01f, -1.42069519e-01f, 8.00559521e-02f, 3.94755751e-02f, 6.74340799e-02f, 4.21287477e-01f, 3.99080589e-02f, -2.55721033e-01f,
  -3.25260341e-01f, -1.07321344e-01f, 3.97231765e-02f, 1.03705764e-01f, 2.43444040e-01f, -1.54382780e-01f, 1.08304359e-01f, 2.61217169e-03f, -7.67893270e-02f, -4.97023091e-02f,
  -2.93528974e-01f, 5.63585460e-02f, -6.45133331e-02f, 4.68889356e-01f, -3.62698771e-02f, -2.62481898e-01f, -1.27599880e-01f, -1.74803793e-01f, -2.22828105e-01f, -4.65752520e-02f,
  -5.17243557e-02f, 3.56426984e-01f, 1.60397608e-02f, -3.04509729e-01f, 8.64322037e-02f, 1.23751797e-01f, -1.68562040e-01f, -1.47803634e-01f, -1.67305872e-01f, -1.63590804e-01f,
  -1.38375029e-01f, -3.41989249e-02f, 5.90113401e-01f, 9.99201238e-02f, -2.37105414e-01f, 4.78719532e-01f, -5.55939794e-01f, -1.04333952e-01f, 3.14213574e-01f, 4.38140146e-03f,
  -2.18592167e-01f, 2.72881296e-02f, 3.87722135e-01f, -3.78782541e-01f, -1.91518769e-01f, 2.58855641e-01f, 6.68200731e-01f, -4.30186093e-01f, 3.01604211e-01f, 1.54925570e-01f,
  -7.01203421e-02f, 3.81621234e-02f, -3.56656127e-02f, -4.63066660e-02f, -1.11927807e-01f, 1.95545226e-01f, -5.47526442e-02f, -1.70031294e-01f, -2.38533050e-01f, 8.60343724e-02f,
  7.04431012e-02f, 9.90652069e-02f, -2.20863506e-01f, 1.28520846e-01f, 7.39401951e-02f, 9.56081599e-02f, 8.83147959e-03f, 1.51912659e-01f, 2.37925071e-02f, -1.75047235e-03f,
  1.80626616e-01f, -1.12832099e-01f, 9.34251547e-02f, -7.42358491e-02f, 1.39367536e-01f, 2.33382508e-01f, -5.54186702e-02f, -1.40502229e-02f, 1.16074830e-01f, -3.84189099e-01f,
  9.80047360e-02f, -4.83030379e-02f, -1.28717974e-01f, -9.99286026e-02f, -4.29812707e-02f, -2.21907743e-03f, 5.76110408e-02f, 2.25161523e-01f, -1.05587870e-01f, 1.16702311e-01f,
  1.20996460e-02f, -6.69913425e-05f, -6.19032606e-02f, 2.05980241e-01f, 1.47772327e-01f, 2.27920502e-01f, 3.65236998e-01f, 1.65742934e-01f, -2.29500040e-01f, 2.89913684e-01f,
  6.84943842e-03f, 3.15461904e-01f, -4.17672306e-01f, -1.67009875e-01f, 1.92403831e-02f, -4.40767333e-02f, -3.55183929e-01f, -2.91321635e-01f, -5.56068599e-01f, 3.01058710e-01f,
  5.32502294e-01f, 6.12015277e-02f, -1.73762530e-01f, -1.64722204e-02f, -1.62328050e-01f, -1.23235069e-01f, -2.18482539e-01f, -1.93320304e-01f, -2.95031387e-02f, -3.24336183e-03f,
  6.79606646e-02f, 2.54983213e-02f, -1.01607470e-02f, 5.24676517e-02f, -1.12636626e-01f, -1.87469169e-01f, -1.29054800e-01f, 3.30027305e-02f, 3.76443744e-01f, -1.11411974e-01f,
  -4.56397096e-03f, -2.17363045e-01f, -2.41122961e-01f, -1.23608142e-01f, 1.72791760e-02f, -6.88429698e-02f, -1.35893494e-01f, -1.36435971e-01f, 5.17336905e-01f, 1.16490029e-01f,
  1.27902180e-01f, -1.60355076e-01f, 1.34561390e-01f, 2.96595749e-02f, 2.61652827e-01f, 7.03398585e-02f, 7.17667565e-02f, 2.51602411e-01f, 9.87864882e-02f, -2.38032881e-02f,
  -6.95161223e-02f, 8.72061849e-02f, -2.07988262e-01f, 2.34880760e-01f, 5.77006161e-01f, 7.63910962e-03f, 1.93644255e-01f, 1.19629540e-01f, 5.55888168e-04f, -2.08080500e-01f,
  -1.97321266e-01f, 1.39752477e-02f, 5.11227608e-01f, -4.39855158e-02f, 1.73443884e-01f, 3.59250247e-01f, 5.20068228e-01f, 3.30973864e-01f, -7.71359131e-02f, -4.25086737e-01f,
  -3.11202735e-01f, -8.70695934e-02f, -1.31164372e-01f, -5.49423277e-01f, -4.60204512e-01f, 3.61967385e-01f, 1.52014354e-02f, -2.16267124e-01f, -1.14894092e-01f, -2.39739075e-01f,
  -2.37797111e-01f, -2.77420938e-01f, 2.10604087e-01f, 3.69380951e-01f, 7.40554392e-01f, 1.15058750e-01f, -1.92739978e-01f, -9.28700864e-02f, -1.14305250e-01f, -4.51538861e-01f,
  6.90470114e-02f, 2.20436752e-01f, -2.31542617e-01f, 6.10449463e-02f, 1.50177643e-01f, 1.05577007e-01f, -1.00549877e-01f, 3.62617488e-04f, 3.47174481e-02f, -1.42566159e-01f,
  3.40215787e-02f, -3.27693488e-05f, -2.78314620e-01f, -4.30055529e-01f, 1.85078066e-02f, -5.00802845e-02f, 4.74113375e-02f, -4.46831696e-02f, 3.77547331e-02f, -2.26262927e-01f,
  1.34677127e-01f, -2.04005480e-01f, -8.77062306e-02f, -2.63483733e-01f, -6.89588413e-02f, -4.08941805e-02f, -2.04567671e-01f, -1.79328725e-01f, -1.98711634e-01f, -5.70360906e-02f,
  -4.69765551e-02f, 7.81554803e-02f, -3.63627672e-01f, 5.39083838e-01f, -1.12096325e-01f, -1.19695142e-02f, 8.54885131e-02f, -3.39484751e-01f, 9.61754918e-02f, -5.08849462e-03f,
  -4.10212040e-01f, -3.46402407e-01f, -2.18428344e-01f, -7.27798557e-03f, 8.26391727e-02f, 4.40582559e-02f, 6.84791446e-01f, -4.77242500e-01f, -8.38510022e-02f, 9.28020179e-02f,
  -3.09395015e-01f, 1.96593970e-01f, 2.35047325e-01f, 3.19752306e-01f, -1.70289636e-01f, -4.28412855e-02f, 1.73978359e-02f, 2.14939922e-01f, 2.99696475e-01f, -1.22591369e-01f,
  1.81235671e-01f, -5.46118282e-02f, 1.13264218e-01f, 3.01218063e-01f, -3.01914513e-02f, 2.75931135e-02f, -2.17485875e-01f, -1.79035336e-01f, 1.28320545e-01f, -1.51658431e-01f,
  3.24694902e-01f, -6.51276484e-02f, 3.16635519e-01f, 1.44219398e-01f, 1.75826669e-01f, -1.05261341e-01f, -1.28776908e-01f, -2.52914965e-01f, 9.93550271e-02f, -6.40115440e-02f,
  -4.73253764e-02f, -1.76612094e-01f, -7.15215728e-02f, -1.75547376e-01f, -2.79039182e-02f, -2.04002023e-01f, -5.83470985e-02f, -8.24295077e-03f, 5.04684262e-02f, -1.31824657e-01f,
  2.01001078e-01f, -2.52067924e-01f, -3.09252620e-01f, 3.28509033e-01f, 7.59740844e-02f, 3.17373965e-03f, -1.62826121e-01f, -2.17103064e-01f, -9.90952253e-02f, -1.26084507e-01f,
  -1.79434896e-01f, 1.06070869e-01f, -3.82524133e-01f, -7.40614161e-02f, -2.06241503e-01f, 1.85186177e-01f, 3.30780625e-01f, 7.38714933e-02f, -4.16243166e-01f, 5.59127092e-01f,
  -3.39919090e-01f, 1.86079815e-01f, 2.72702985e-02f, 3.38124424e-01f, -2.29467273e-01f, -4.26944606e-02f, -8.72038081e-02f, -6.05320148e-02f, 3.20333123e-01f, 4.20359462e-01f,
  -1.45060688e-01f, -4.10006940e-01f, -4.14005607e-01f, 1.26344308e-01f, 1.40046209e-01f, -1.41503990e-01f, 1.11615650e-01f, -1.66840523e-01f, -9.58367214e-02f, -1.98644981e-01f,
  -1.69411987e-01f, 9.06985551e-02f, -2.26026043e-01f, -3.43334302e-02f, -1.61133155e-01f, 2.00611696e-01f, -1.92658156e-01f, -8.68536234e-02f, 1.22980610e-01f, 1.80533350e-01f,
  -4.37552214e-01f, -4.52611238e-01f, 1.67600259e-01f, -4.62556519e-02f, -2.18478829e-01f, 6.66086236e-03f, 4.39966768e-02f, 3.58055264e-01f, 2.95224994e-01f, 3.07899505e-01f,
  -8.88264775e-02f, -3.08377206e-01f, -1.56867187e-02f, -1.54185101e-01f, 3.84119898e-02f, -4.92998622e-02f, 6.11382797e-02f, 1.77172702e-02f, 2.89037347e-01f, -2.39050090e-01f,
  1.18380286e-01f, -1.69292301e-01f, -8.44744965e-02f, 5.72067834e-02f, 6.33045852e-01f, -2.53310412e-01f, 2.69768745e-01f, -3.08873028e-01f, 1.73800752e-01f, 1.06847622e-01f,
  3.50784361e-01f, 3.91790748e-01f, 2.48501688e-01f, -2.61561424e-01f, 6.34607852e-01f, -4.69811499e-01f, -3.82154584e-01f, -1.14050359e-01f, 5.76238751e-01f, -9.25743207e-02f,
  1.56350523e-01f, 5.73999248e-02f, -3.77740592e-01f, -1.28649026e-01f, -1.20641395e-01f, 5.58256626e-01f, 9.88408402e-02f, -1.33900136e-01f, 7.84823671e-02f, 1.13526694e-01f,
  -8.78247991e-02f, -2.16317460e-01f, -2.04880834e-01f, 1.26740769e-01f, 3.25446799e-02f, 1.11682482e-01f, 4.09208722e-02f, 1.71997935e-01f, 9.17328969e-02f, -3.07917386e-01f,
  2.13361979e-01f, -1.24127902e-01f, 1.37499556e-01f, -1.07281528e-01f, 1.22206984e-02f, -1.12085789e-01f, -2.22119227e-01f, -2.66648419e-02f, 1.33264894e-02f, -2.37980902e-01f,
  1.45605251e-01f, -2.17916608e-01f, -2.02088565e-01f, -2.28901476e-01f, -6.11806288e-02f, -1.47633225e-01f, 1.06105879e-01f, 3.45279932e-01f, 9.04365852e-02f, -1.49094518e-02f,
  -3.85240525e-01f, -6.75075352e-02f, -1.09490983e-01f, 3.63745183e-01f, -2.18497366e-01f, 3.49344492e-01f, -1.84959784e-01f, -6.20735697e-02f, -2.40907073e-01f, 1.75869241e-01f,
  2.98464656e-01f, -8.36779550e-02f, 2.91334148e-02f, -1.37888044e-01f, -8.38011056e-02f, 2.72253215e-01f, 4.72551584e-02f, 5.61358094e-01f, -2.77471155e-01f, 2.50242233e-01f,
  4.83207822e-01f, -1.52509466e-01f, -3.74888957e-01f, -1.92276105e-01f, -1.78886563e-01f, -9.80179310e-02f, 3.93515170e-01f, -1.81057543e-01f, 1.21868521e-01f, -3.16983879e-01f,
  -2.74245948e-01f, -1.19195521e-01f, -1.59497216e-01f, 2.64202744e-01f, -6.51151612e-02f, -8.43883455e-02f, 1.53980374e-01f, -1.83168963e-01f, -1.12021580e-01f, -7.05494583e-02f,
  -1.43359512e-01f, 4.22133468e-02f, 7.37660825e-02f, -1.17347576e-01f, -6.12288974e-02f, -5.91299571e-02f, -1.16719827e-01f, 7.47211948e-02f, -2.61821389e-01f, 2.49558121e-01f,
  1.93133488e-01f, 3.77180904e-01f, -1.03988647e-01f, -3.50029208e-02f, 1.84467718e-01f, 1.98688462e-01f, -1.31409869e-01f, -1.44886211e-01f, 2.67983619e-02f, -8.72484222e-02f,
  -4.55429256e-02f, -1.28363684e-01f, -9.26539302e-02f, 2.76170641e-01f, 3.29401076e-01f, -2.51804709e-01f, 1.73689455e-01f, -8.75817686e-02f, -2.07892105e-01f, -1.25705242e-01f,
  6.46999300e-01f, 1.95094705e-01f, 9.16161761e-02f, -1.97743122e-02f, -3.20805237e-02f, -1.86348520e-02f, 3.94999027e-01f, 3.85225743e-01f, 2.17808813e-01f, -1.81789652e-01f,
  -1.59147888e-01f, 2.59841651e-01f, -1.88398406e-01f, 7.58822188e-02f, -3.91657054e-01f, -3.48719060e-02f, -6.26924783e-02f, -7.36664832e-02f, -5.69925569e-02f, -2.60890454e-01f,
  -2.54676551e-01f, 1.72046408e-01f, 2.52508372e-01f, 2.52727047e-02f, 2.17527434e-01f, 1.11999484e-02f, -2.93856144e-01f, -2.50082999e-01f, 4.23432590e-04f, -1.49959356e-01f,
  1.24361821e-01f, -2.13334918e-01f, -1.03760071e-01f, -8.84896815e-02f, -5.74768931e-02f, -5.91969788e-02f, -2.04713121e-01f, 7.80538619e-01f, 3.34193110e-01f, 1.76465794e-01f,
  1.24892192e-02f, 1.28421023e-01f, -3.05498153e-01f, -2.83383936e-01f, -1.67791799e-01f, 8.47139284e-02f, -2.90155318e-02f, -1.66705567e-02f, -1.09534897e-01f, -1.32237285e-01f,
  -1.03102855e-01f, 2.96536416e-01f, 2.87675112e-02f, -1.83779418e-01f, -1.24662966e-01f, -1.88217685e-02f, 1.07756980e-01f, 4.87663187e-02f, -1.02584802e-01f, 3.34595293e-01f,
  9.37188603e-03f, -1.02206618e-02f, 2.10450739e-01f, -2.02059031e-01f, -8.20754245e-02f, -1.07716225e-01f, 2.05300495e-01f, -2.05127016e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.09646180e-01f, -4.24870737e-02f, 1.97619289e-01f, -9.07480046e-02f, -1.59123123e-01f, 1.14747606e-01f, 1.59091696e-01f, -1.77353963e-01f, -2.14274116e-02f, -1.15489140e-02f,
  2.66169235e-02f, 1.08559161e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    