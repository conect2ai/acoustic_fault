/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.60562593e-01f, -8.76114666e-02f, 2.41903260e-01f, -2.85672434e-02f, 7.00501446e-03f, 4.27667677e-01f, 1.03131071e-01f, 7.94706494e-03f, -1.35771856e-01f, -1.24758981e-01f,
  4.79921661e-02f, -5.58135659e-02f, -1.73120931e-01f, 1.16830483e-01f, 1.94900081e-01f, -1.02335230e-01f, 2.47687697e-01f, 8.06069076e-02f, 7.96256289e-02f, -5.64016178e-02f,
  1.14033677e-01f, 7.75468126e-02f, 1.49637565e-01f, -1.01076700e-01f, 1.52861446e-01f, -8.44762027e-02f, -4.84457761e-02f, -7.12216869e-02f, -6.89516589e-02f, 5.05377799e-02f,
  8.36208314e-02f, -7.73039609e-02f, 2.11264919e-02f, 3.13432999e-02f, 6.66329786e-02f, -3.39673869e-02f, 9.02882144e-02f, 1.00058857e-02f, -3.03371008e-02f, 1.31154060e-02f,
  4.81765196e-02f, 1.32234087e-02f, 7.31028542e-02f, -4.19826806e-02f, 3.73156704e-02f, -3.64496298e-02f, 3.09278145e-02f, 4.55280282e-02f, -4.39391797e-03f, 7.42670447e-02f,
  -1.01880375e-02f, 1.16835088e-01f, 9.32513084e-03f, -1.42333535e-02f, -2.33697481e-02f, -1.44679546e-02f, -2.69062314e-02f, -4.12537828e-02f, 1.13695888e-02f, -1.22764427e-02f,
  3.78784165e-02f, -4.20166226e-03f, 2.85448674e-02f, 3.71488817e-02f, -2.53846124e-02f, -1.46827754e-02f, -5.44177368e-03f, -4.82842363e-02f, 1.27859833e-03f, -3.02420184e-03f,
  3.95963294e-03f, 3.36086266e-02f, 8.65922682e-03f, 3.32338992e-03f, -4.35548350e-02f, 3.37253101e-02f, 2.06443691e-03f, -5.59900142e-02f, 4.85375449e-02f, -1.30666792e-03f,
  -4.95097563e-02f, -1.97118521e-02f, -3.49943824e-02f, 4.22490314e-02f, -3.16051804e-02f, -1.40148224e-02f, 3.81104499e-02f, -6.45084381e-02f, -1.95765998e-02f, 5.79221956e-02f,
  -4.94150221e-02f, -1.63960874e-01f, -5.26221395e-02f, 2.41438448e-02f, -5.38628828e-03f, 1.10958740e-01f, -8.00991058e-03f, -4.41727368e-03f, -7.90088102e-02f, 1.52837122e-02f,
  1.53868161e-02f, -1.43360179e-02f, -1.59916822e-02f, 7.23237693e-02f, 2.00666357e-02f, -3.58402021e-02f, -5.07998653e-02f, -8.13639089e-02f, -2.06804201e-02f, 6.74905395e-03f,
  -6.25250190e-02f, -1.82549804e-02f, 4.50207444e-04f, 4.90736589e-03f, 3.36005390e-02f, 2.02784929e-02f, -1.06839521e-03f, 1.59539301e-02f, 6.81330217e-03f, -4.77570072e-02f,
  4.35841791e-02f, 3.42376709e-01f, -3.60533774e-01f, -2.01677024e-01f, -1.11278221e-01f, 9.42691565e-02f, -6.91101700e-02f, -1.32880118e-02f, 1.53945997e-01f, 1.93409786e-01f,
  -8.44422877e-02f, 8.02229568e-02f, 6.67477399e-02f, 6.74537197e-02f, 5.04422225e-02f, 2.39319861e-01f, 6.61071623e-03f, 1.18545242e-01f, 1.36429742e-01f, -5.97049519e-02f,
  -4.91444804e-02f, 1.95536569e-01f, -3.31733823e-01f, -8.72354135e-02f, -2.92045772e-01f, -1.08356096e-01f, -1.08069606e-01f, -1.38158292e-01f, -2.06019029e-01f, 9.81863961e-02f,
  -1.52607786e-03f, -7.63155222e-02f, -2.34836981e-01f, 6.21437840e-02f, -7.81310275e-02f, -3.09182070e-02f, 3.94080319e-02f, 2.93527525e-02f, -1.54842973e-01f, -6.24927469e-02f,
  8.21323693e-02f, -6.27639592e-02f, 3.97427194e-03f, 1.31809060e-02f, -4.87953275e-02f, -7.24005848e-02f, -1.66854281e-02f, -9.11605433e-02f, -3.97024825e-02f, -5.79028316e-02f,
  -1.60210177e-01f, -4.61001024e-02f, -8.08537304e-02f, 4.40172735e-04f, -1.22209072e-01f, 2.62764399e-04f, -5.24238534e-02f, -8.37956667e-02f, -5.94739318e-02f, 3.81678902e-02f,
  9.80712771e-02f, -1.25428382e-02f, 7.92458132e-02f, 5.97333871e-02f, 2.02693809e-02f, 2.00215206e-02f, 9.69873145e-02f, -2.35352535e-02f, -4.90234829e-02f, 3.51126329e-03f,
  3.63044627e-02f, -5.50936125e-02f, 1.07799061e-01f, -4.99751344e-02f, 2.98715569e-02f, -2.23155823e-02f, -1.10726215e-01f, -1.70492046e-02f, -7.89625272e-02f, 5.66359311e-02f,
  -9.46037658e-03f, -3.34438495e-02f, -6.86884392e-03f, -1.83923859e-02f, 6.02308698e-02f, -6.20435812e-02f, -6.04314581e-02f, -6.21642768e-02f, -3.79801355e-02f, -4.09858860e-02f,
  2.64744520e-01f, 4.59102601e-01f, 3.05220317e-02f, -4.97496836e-02f, 1.45865634e-01f, 8.78828466e-02f, 8.67243335e-02f, -4.02670205e-02f, 7.91138634e-02f, 8.58937204e-02f,
  -6.18868917e-02f, -1.45498171e-01f, 8.66547525e-02f, -7.78411627e-02f, 6.71962723e-02f, 1.22451760e-01f, 1.32692931e-02f, 9.12590995e-02f, -1.95808373e-02f, 1.40550255e-03f,
  -1.43594602e-02f, 7.24601746e-02f, -2.03229021e-03f, -8.32585394e-02f, -1.27541460e-02f, 9.86169558e-03f, 8.01937282e-02f, -6.21664114e-02f, 7.14863613e-02f, -3.83495353e-02f,
  -5.51200628e-01f, 7.54905045e-02f, 4.24167395e-01f, -2.31191352e-01f, -1.77917719e-01f, 3.10603172e-01f, 9.79045779e-02f, -1.71853930e-01f, -2.10944414e-01f, -8.27530026e-02f,
  -1.31462336e-01f, 6.76415637e-02f, 1.25093207e-01f, 8.80010575e-02f, 2.52790898e-01f, 2.20176309e-01f, 8.84875879e-02f, -2.56063584e-02f, -6.54494166e-02f, -1.22938439e-01f,
  1.51372068e-02f, -8.07534531e-02f, 2.07642525e-01f, -1.55025721e-01f, -5.86153269e-02f, -1.04420103e-01f, 1.33135855e-01f, 5.06893545e-02f, -3.96997891e-02f, -3.64469960e-02f,
  6.84878305e-02f, -2.55347431e-01f, 5.70456609e-02f, -7.44253024e-02f, 2.09232457e-02f, -1.11407451e-02f, -5.98584004e-02f, 1.76135942e-01f, 4.23555523e-02f, -2.05039550e-02f,
  8.73167999e-03f, -1.78997498e-02f, -9.21496898e-02f, 4.93885949e-03f, -1.95163302e-02f, 3.97607274e-02f, 2.17591450e-02f, 1.97052434e-02f, -3.36553454e-02f, -1.85991805e-02f,
  1.04485445e-01f, -5.67921400e-02f, 3.59631889e-02f, -1.05741257e-02f, -4.44919989e-02f, 1.37192197e-02f, 5.87047637e-02f, 1.45095270e-02f, -3.23257819e-02f, -9.33086500e-02f,
  -1.18111968e-02f, -4.05629026e-03f, -1.34185124e-02f, -6.03723899e-02f, -3.75275202e-02f, -8.02372694e-02f, 3.78175895e-03f, 3.45780179e-02f, 6.02561561e-03f, 1.13107366e-02f,
  -3.91796716e-02f, -2.96665970e-02f, -4.44835797e-02f, 2.67552081e-02f, -2.84453426e-02f, -6.19142316e-02f, 1.50088221e-01f, -6.80038612e-03f, -3.13517079e-02f, -4.43381593e-02f,
  2.83849444e-02f, 2.03809142e-03f, 3.65529656e-02f, -4.96138521e-02f, -8.05413276e-02f, 6.97515160e-02f, -2.73177437e-02f, 5.31664900e-02f, -1.10780662e-02f, 4.55390662e-02f,
  -7.81873986e-02f, -1.18286818e-01f, -5.78162409e-02f, -3.06863543e-02f, -3.27675231e-02f, 3.49325570e-03f, 9.59353000e-02f, -8.29564333e-02f, -3.30179371e-02f, 1.96969751e-02f,
  -1.11006431e-01f, -8.43960326e-03f, -4.23955210e-02f, 1.10998228e-02f, 6.29443154e-02f, -5.56359850e-02f, -4.14552949e-02f, 1.90380849e-02f, 9.03483015e-03f, 2.92892149e-03f,
  -1.19314715e-01f, 2.50854921e-02f, -5.29481657e-02f, -1.95286088e-02f, 5.78767397e-02f, -5.56948446e-02f, -5.03027998e-02f, -4.00700271e-02f, 3.25049981e-02f, -2.37923805e-02f,
  -3.06316525e-01f, -9.06292424e-02f, 1.46124959e-01f, -1.91596061e-01f, -6.43335208e-02f, -9.35634375e-02f, 4.22307849e-01f, -1.41007558e-01f, 3.56090903e-01f, 2.37275213e-02f,
  -2.21240193e-01f, 9.11589861e-02f, 1.23949565e-01f, -1.16757892e-01f, -1.99101761e-01f, 1.13650411e-01f, -2.25385711e-01f, -1.11293674e-01f, 2.00119987e-01f, -2.47134522e-01f,
  -1.32432371e-01f, -3.83778632e-01f, -1.96260467e-01f, -2.59094626e-01f, -9.01296139e-02f, -5.61917340e-03f, -1.39559060e-01f, 7.90976584e-02f, -4.44507807e-01f, -2.43309904e-02f,
  -4.18507308e-03f, -3.93889844e-03f, 4.98809330e-02f, 1.26271844e-02f, 3.84408683e-02f, -2.80113965e-02f, 3.79506149e-03f, 1.28371045e-01f, 9.43294633e-03f, -5.28624021e-02f,
  4.72609662e-02f, -9.42115858e-02f, 1.62208569e-03f, 6.80221319e-02f, 8.03073272e-02f, -3.53993624e-02f, -2.81922915e-03f, 8.72258395e-02f, 3.84736061e-02f, 4.36010025e-03f,
  1.72819325e-03f, -2.09621228e-02f, 5.45879477e-04f, -1.04017509e-02f, 1.02369692e-02f, -1.22021474e-01f, 5.86032718e-02f, 3.61555852e-02f, -1.75789592e-03f, 1.07550353e-01f,
  -5.18488958e-02f, 4.59448062e-02f, -1.04262587e-02f, -6.45592809e-02f, 1.32354768e-02f, -2.26589441e-02f, -3.67964208e-02f, -2.21917760e-02f, 6.53001368e-02f, -4.92521040e-02f,
  -4.03698571e-02f, 2.49725487e-02f, 1.61377632e-03f, -2.92677805e-02f, -5.38883395e-02f, 9.52288508e-02f, -2.30556261e-03f, -5.41734807e-02f, 4.35656160e-02f, -5.29781953e-02f,
  3.40078212e-02f, 3.30424160e-02f, -4.57388163e-02f, -1.26937712e-02f, -1.50054647e-02f, 8.68196320e-03f, -1.48952967e-02f, 3.27351019e-02f, 1.29280940e-01f, 5.85939735e-02f,
  -9.98048037e-02f, -2.11685315e-01f, -2.04070024e-02f, -2.39901096e-02f, -3.38285044e-02f, -9.65242758e-02f, -9.68262460e-03f, -8.40621218e-02f, -1.70599893e-02f, 2.81593371e-02f,
  -3.76956761e-02f, 3.49478163e-02f, -4.86189947e-02f, -6.60507008e-02f, -7.46497661e-02f, -1.32556511e-02f, 1.88040342e-02f, -3.46430466e-02f, -4.15948331e-02f, -4.26603295e-02f,
  -5.36503829e-02f, -4.60596941e-02f, -1.29632941e-02f, -6.52149916e-02f, -7.33824447e-02f, -7.05763651e-03f, 7.23985806e-02f, -1.65289606e-03f, -9.04732496e-02f, 5.80723509e-02f,
  2.32752755e-01f, -1.54514968e-01f, -1.52376264e-01f, 1.22981355e-01f, 4.66992408e-02f, 5.54370135e-02f, 1.22635275e-01f, -1.66658476e-01f, 2.59119928e-01f, -2.38241687e-01f,
  1.40913919e-01f, -6.74269944e-02f, 9.30735096e-02f, 4.27560396e-02f, 4.83018428e-01f, 2.99278319e-01f, 1.94118962e-01f, 8.73156190e-02f, 1.08021408e-01f, -3.55917551e-02f,
  6.98676631e-02f, 1.25160798e-01f, -1.31823391e-01f, -1.28564075e-01f, -2.13559657e-01f, -2.73430258e-01f, -4.81454134e-02f, -1.48141846e-01f, -1.09312467e-01f, 3.76681499e-02f,
  1.46770757e-03f, 4.87841442e-02f, -1.70376897e-01f, 5.66652864e-02f, -2.37330012e-02f, -1.31416460e-02f, 2.07151622e-02f, 5.72335571e-02f, 3.27559300e-02f, -6.18648753e-02f,
  7.51495967e-03f, 5.02794348e-02f, 3.11080236e-02f, 2.98390370e-02f, 3.39325294e-02f, -4.32706252e-02f, 3.85267101e-02f, -1.01820283e-01f, 1.34927211e-02f, 8.65594950e-03f,
  2.37197732e-03f, 1.30972872e-02f, 1.79184768e-02f, 6.19408861e-02f, -3.29315513e-02f, 8.64210576e-02f, -1.08198121e-01f, -5.06692789e-02f, 2.36203484e-02f, -4.20035683e-02f,
  3.21076326e-02f, -2.45474987e-02f, -6.90734014e-02f, 3.69931193e-04f, 1.82537530e-02f, -2.20864429e-03f, 8.18276312e-03f, 1.43868783e-02f, -1.12868715e-02f, 3.74764837e-02f,
  -5.09919366e-04f, 2.39586849e-02f, 6.72640800e-02f, -2.97117326e-02f, -3.73754203e-02f, -7.36371726e-02f, 3.20687108e-02f, -1.61562599e-02f, -1.71002671e-02f, 3.72717977e-02f,
  2.10449304e-02f, 5.19149750e-02f, -8.95376652e-02f, -1.36988712e-02f, 4.28879708e-02f, -3.28239352e-02f, -1.94611792e-02f, -3.50961350e-02f, -6.43588379e-02f, -1.87975215e-03f,
  1.47363216e-01f, -1.53751045e-01f, -5.14006726e-02f, -5.26095182e-02f, 1.10233836e-02f, -9.12592467e-03f, 1.52479429e-02f, -4.47708778e-02f, -3.77315357e-02f, 4.95363846e-02f,
  5.70709724e-03f, -1.90973636e-02f, -6.09192848e-02f, 2.12897807e-02f, -5.71068488e-02f, 3.04436386e-02f, 3.85985337e-03f, -1.18843671e-02f, -6.22995123e-02f, -2.01928169e-02f,
  -4.28731972e-03f, 5.07150181e-02f, -3.45331207e-02f, -3.95733342e-02f, -1.39671629e-02f, -1.79974101e-02f, 6.54885098e-02f, 1.32853026e-03f, 2.65995245e-02f, 6.77421391e-02f,
  -8.79088864e-02f, -9.25289020e-02f, -4.39803563e-02f, -6.82612285e-02f, -3.33538987e-02f, -4.80491072e-01f, -3.14665854e-01f, 2.73033809e-02f, -2.23618627e-01f, 5.82414307e-03f,
  1.08604506e-01f, -8.31935480e-02f, 2.60338962e-01f, -3.76478583e-01f, -7.45662227e-02f, -1.48780616e-02f, -2.53026694e-01f, -1.64384440e-01f, 7.72063658e-02f, 6.31076247e-02f,
  2.95528602e-02f, -4.58461829e-02f, -4.69935425e-02f, 1.03287518e-01f, -6.08354099e-02f, 9.74371731e-02f, 3.19905937e-01f, -4.48209653e-03f, 1.95642654e-02f, -1.37638181e-01f,
  -1.09718457e-01f, 2.38038134e-03f, -9.35349762e-02f, -1.18304417e-02f, -1.60101317e-02f, 4.89301123e-02f, -3.45580168e-02f, -9.52745695e-03f, -1.32950330e-02f, -2.49935798e-02f,
  -3.50487716e-02f, 3.23049501e-02f, -4.48290398e-03f, -2.68349628e-04f, -4.36960869e-02f, 1.42857209e-02f, -1.98634751e-02f, -2.34212466e-02f, -4.01170217e-02f, 1.77450422e-02f,
  -4.35737222e-02f, 2.31733788e-02f, 4.68104333e-03f, 1.12262974e-02f, 6.72616661e-02f, -5.43039553e-02f, -5.53244241e-02f, -5.14914207e-02f, -6.10495172e-03f, -1.61448233e-02f,
  4.70924452e-02f, -1.39276749e-02f, 4.60830294e-02f, -8.65131430e-03f, -8.60829838e-03f, -2.45438870e-02f, 1.33133326e-02f, 1.23495515e-02f, 3.71536426e-02f, -2.28148159e-02f,
  -2.64358148e-02f, 9.19032395e-02f, 3.59162539e-02f, -3.23327370e-02f, 1.68289840e-02f, -1.48651609e-02f, 1.88580807e-03f, -1.99462082e-02f, 1.04585076e-02f, -6.60245344e-02f,
  1.93924755e-02f, 3.66280302e-02f, -6.65485039e-02f, 2.97827478e-02f, 7.94877671e-03f, 1.37180705e-02f, 8.67284834e-02f, 7.84678478e-03f, -4.35308833e-03f, -3.57367918e-02f,
  -2.49233525e-02f, 1.78092927e-01f, 4.62579317e-02f, -3.42499688e-02f, -3.62009406e-02f, -2.22201906e-02f, 2.30947081e-02f, 2.25925795e-03f, 3.30249257e-02f, 4.14873147e-03f,
  8.85950625e-02f, -3.55899855e-02f, 1.55432867e-02f, -1.17793800e-02f, 1.35497015e-03f, 1.89520679e-02f, 8.04621428e-02f, -6.31049648e-02f, 2.71313824e-02f, 4.45022993e-02f,
  5.13471365e-02f, -3.41940820e-02f, -1.06083052e-02f, -2.16919985e-02f, -4.25301082e-02f, 4.29402990e-03f, -1.11169629e-02f, 1.83163323e-02f, 3.69189866e-02f, -3.49256000e-03f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.22601640e-01f, -1.08087271e-01f, 1.66728735e-01f, 5.10699630e-01f, 1.57805458e-01f, -1.95954427e-01f, -2.60214120e-01f, 2.81898975e-01f, 2.54704475e-01f, -3.02060068e-01f,
  1.08060926e-01f, -1.94903031e-01f, -3.47090364e-01f, 3.99052799e-01f, 2.59560257e-01f, -2.32569963e-01f, 4.00188863e-01f, 5.45693301e-02f, -4.76862211e-03f, 9.48878899e-02f,
  3.80345881e-01f, 3.71391237e-01f, 1.93288386e-01f, 2.06711739e-01f, 1.94471464e-01f, 2.08483040e-01f, 6.39282688e-02f, -2.39562497e-01f, 1.70944467e-01f, -6.47986541e-03f,
  -1.41408630e-02f, 1.30713955e-01f, 9.92651507e-02f, -4.41684686e-02f, 2.37573031e-02f, -6.27382770e-02f, -9.49782357e-02f, -9.28643644e-02f, 8.60008318e-03f, -6.19511753e-02f,
  -1.19962163e-01f, -3.91997863e-03f, 4.12889384e-02f, -3.00999694e-02f, -1.76984798e-02f, 7.70110637e-02f, 1.85485005e-01f, -4.76384461e-02f, -6.18069172e-02f, -6.10989258e-02f,
  -4.83198203e-02f, -1.50739180e-03f, 8.04373994e-02f, -9.44765955e-02f, 3.06552723e-02f, 4.11851518e-02f, -9.43458080e-02f, -1.20043084e-01f, -6.02443926e-02f, 8.45999271e-03f,
  3.40816155e-02f, -4.98234890e-02f, 4.59868386e-02f, 3.44643891e-02f, -6.80821016e-02f, 1.19399950e-01f, -1.23218764e-02f, 6.06315304e-03f, -4.63950373e-02f, 3.91933434e-02f,
  4.02759351e-02f, -3.43363709e-03f, 3.83211374e-02f, -3.21074203e-02f, -3.25153247e-02f, -4.00344692e-02f, 1.34161916e-02f, -1.46580478e-02f, 4.00888398e-02f, -4.18842630e-03f,
  4.40625325e-02f, 1.00013018e-01f, -7.75514916e-02f, 1.36874355e-02f, -8.36783946e-02f, 3.28763947e-02f, 4.22162898e-02f, -2.90093776e-02f, 4.66769449e-02f, -4.90255840e-02f,
  1.43600581e-02f, 3.03348303e-02f, -8.67637098e-02f, -3.93715575e-02f, -2.43722070e-02f, -5.78421867e-03f, 1.00645229e-01f, 4.31215800e-02f, 3.26270573e-02f, 8.99402127e-02f,
  9.00737941e-03f, 3.06982920e-02f, 2.91140191e-02f, 1.17329881e-01f, -2.40607318e-02f, 1.40093360e-02f, -7.59171396e-02f, 8.52779113e-03f, 8.29706043e-02f, 7.34002367e-02f,
  -9.15049165e-02f, -9.23821181e-02f, 3.26607097e-03f, 4.21708412e-02f, 3.30730937e-02f, -8.21720362e-02f, 5.74915484e-02f, 1.86428167e-02f, 2.17719153e-02f, -2.99795996e-02f,
  -1.19403899e+00f, 4.90916669e-01f, 1.03780255e-01f, -1.44491315e-01f, -6.18270449e-02f, 8.63259472e-03f, -2.06014961e-01f, 1.66363999e-01f, -9.08421278e-02f, 2.09962338e-01f,
  1.43178110e-03f, -4.53290120e-02f, -8.29521120e-02f, 1.60960868e-01f, -5.41655540e-01f, 4.46754554e-03f, -1.99787900e-01f, 2.66516674e-03f, 1.53852021e-02f, -5.62779605e-03f,
  -1.32002264e-01f, -5.31833768e-02f, -7.09481211e-03f, 2.20674187e-01f, 1.11876994e-01f, 1.67206246e-02f, -2.53313273e-01f, 7.83258826e-02f, -2.81362701e-03f, -8.19642504e-04f,
  2.67789871e-01f, 2.09762365e-01f, 1.11331485e-01f, 7.93718994e-02f, -6.13181628e-02f, -2.37605199e-02f, -3.42808217e-02f, -4.67819236e-02f, 7.66556934e-02f, -9.70268995e-03f,
  1.78937167e-02f, 5.69249839e-02f, 5.22078807e-03f, 4.50973101e-02f, 3.36357988e-02f, 9.70783532e-02f, 6.61694705e-02f, 7.49002770e-02f, 7.04813898e-02f, 1.06025442e-01f,
  1.20652206e-02f, 8.17660317e-02f, -4.31432873e-02f, 1.69177596e-02f, 1.63505264e-02f, 5.26556261e-02f, -3.95284630e-02f, -7.75958896e-02f, -1.91006623e-02f, -4.49508540e-02f,
  -4.78113405e-02f, 1.25341648e-02f, 3.51867490e-02f, 5.03825024e-02f, -6.93905808e-04f, 4.85206619e-02f, 3.83250117e-02f, -1.51594877e-02f, -3.20228562e-02f, 5.39848534e-03f,
  -4.20167204e-03f, -7.11916909e-02f, 4.07493077e-02f, 3.44481021e-02f, -5.12774289e-03f, -1.97837595e-03f, -3.17800455e-02f, -8.29658471e-03f, -1.08817350e-02f, -7.29863346e-02f,
  6.45275926e-03f, -3.22395153e-02f, 2.34644227e-02f, -3.38230245e-02f, 2.57686842e-02f, -2.53434982e-02f, 6.85422271e-02f, 5.53302169e-02f, -8.24470297e-02f, -6.32523894e-02f,
  -3.93575549e-01f, -2.54598260e-01f, 3.03268693e-02f, 2.62981281e-02f, 4.13173027e-02f, -1.08693680e-02f, 1.74878314e-02f, -3.07297651e-02f, -1.23503260e-01f, -8.00085366e-02f,
  2.33465321e-02f, 4.23393445e-03f, -5.81754418e-03f, 1.48185883e-02f, -4.66083139e-02f, -8.22332278e-02f, -8.29637125e-02f, -1.08303607e-01f, -1.06627516e-01f, -1.73289869e-02f,
  -2.58938987e-02f, -4.42518592e-02f, 5.20580634e-02f, -3.48348953e-02f, -1.45835308e-02f, -1.95291899e-02f, -4.64715101e-02f, 5.79551011e-02f, -5.21311350e-02f, 3.85609865e-02f,
  5.86470366e-01f, 2.21299782e-01f, 5.34542382e-01f, 3.64351481e-01f, -1.00007340e-01f, 1.81082916e-02f, 5.09503365e-01f, -1.76218495e-01f, 3.62365127e-01f, -4.85066101e-02f,
  -1.91006675e-01f, 5.44154584e-01f, -8.76262709e-02f, 1.50748476e-01f, -1.14016056e-01f, -2.14478783e-02f, -1.34783071e-02f, 8.88832882e-02f, 4.62484509e-02f, 3.70103717e-02f,
  8.02797228e-02f, -3.05652291e-01f, 3.94711159e-02f, -3.62582117e-01f, 2.87658423e-01f, 4.19602320e-02f, -4.01438802e-01f, 8.50481726e-03f, -1.67148039e-01f, -1.64213225e-01f,
  6.56019151e-02f, 2.00273618e-02f, 8.74559209e-02f, 7.19434256e-03f, 2.07333248e-02f, -6.65797889e-02f, 2.44920310e-02f, -3.68718319e-02f, 3.36177424e-02f, -2.60680951e-02f,
  9.85499248e-02f, -1.52256498e-02f, 1.56701598e-02f, -4.18666787e-02f, -4.47997861e-02f, 5.17930798e-02f, 7.40062669e-02f, 2.45428309e-02f, 1.37550935e-01f, 6.59856796e-02f,
  4.25916538e-02f, 3.98202278e-02f, 2.24847067e-02f, -6.98697269e-02f, 6.28126487e-02f, 4.18353565e-02f, 9.15577486e-02f, 1.20130420e-01f, -3.03835366e-02f, 4.82903980e-02f,
  -3.21129188e-02f, 1.81243960e-02f, -2.72718407e-02f, -6.43025041e-02f, -3.50241438e-02f, -3.02323066e-02f, -2.89558303e-02f, 1.76679567e-02f, -7.12573063e-03f, 4.03118841e-02f,
  2.91025322e-02f, 9.30385105e-03f, -1.95432100e-02f, -1.20812133e-02f, 4.56025116e-02f, 2.45774053e-02f, 1.07730208e-02f, -9.21072662e-02f, 5.02780452e-03f, -2.99865380e-02f,
  2.63147950e-02f, -1.11219965e-01f, -7.49731213e-02f, 4.75220531e-02f, -9.70051115e-05f, -7.50373490e-03f, -3.02902535e-02f, 4.53017205e-02f, 1.54743195e-01f, -3.08453087e-02f,
  -4.00434107e-01f, -1.20252199e-01f, -2.93241870e-02f, 1.86958518e-02f, -7.98439607e-02f, 5.97757958e-02f, -1.02870800e-02f, 7.44613409e-02f, -2.54547317e-02f, -1.25203477e-02f,
  -1.26636075e-02f, 4.22430187e-02f, 4.40351339e-03f, -5.67695536e-02f, -6.03199378e-02f, 2.71944539e-03f, 1.02275066e-01f, -5.21575138e-02f, -7.34804198e-02f, -8.16091523e-02f,
  -4.56057265e-02f, -1.22364737e-01f, 1.97221041e-02f, -4.18730751e-02f, 6.60603121e-02f, 5.16351163e-02f, 6.54764548e-02f, -4.81990762e-02f, -6.68644533e-02f, -5.67458980e-02f,
  -3.07216406e-01f, 4.41784501e-01f, -1.79527804e-01f, 5.81088424e-01f, -3.94755274e-01f, 1.96309820e-01f, 5.65589905e-01f, -5.78558110e-02f, 5.39404191e-02f, 4.49245840e-01f,
  3.39863956e-01f, 4.79068533e-02f, 3.17000300e-01f, 5.82722723e-01f, -8.25871527e-02f, 4.77421314e-01f, 3.00317079e-01f, 2.28174269e-01f, -1.22629441e-01f, 1.22679837e-01f,
  4.78531932e-03f, 3.67365301e-01f, 1.59311190e-01f, -4.24860753e-02f, 1.51472226e-01f, -1.62672386e-01f, 8.22150856e-02f, -1.59712270e-01f, 1.02200307e-01f, -3.88744548e-02f,
  9.88330394e-02f, 7.84394592e-02f, -1.03650250e-01f, -2.19937395e-02f, -1.89159494e-02f, -3.01217698e-02f, -7.44927451e-02f, -1.47462174e-01f, -3.17243226e-02f, -4.95454185e-02f,
  8.40558037e-02f, -8.14987719e-02f, 6.32939488e-02f, 1.50818483e-03f, -1.45346537e-01f, -1.17826998e-01f, 1.67239370e-04f, -3.77075933e-02f, 6.86095469e-03f, 8.71679001e-03f,
  -5.31953722e-02f, 3.55629586e-02f, 1.09550555e-03f, 1.07289374e-01f, -2.94308551e-02f, 9.59620532e-03f, 8.95279199e-02f, -2.36045048e-02f, -3.05751674e-02f, 5.20082228e-02f,
  -2.77490937e-03f, -2.11594324e-03f, 2.76005194e-02f, 3.35441343e-02f, 2.02639494e-03f, -8.36358666e-02f, 6.14445545e-02f, 1.02531863e-02f, -3.84507515e-02f, 4.11446393e-02f,
  2.23509595e-02f, -6.01963513e-03f, -2.88833100e-02f, 4.52858098e-02f, 2.79211476e-02f, 2.65949219e-03f, -2.51588337e-02f, -3.09843943e-02f, 4.41339985e-02f, -8.83749425e-02f,
  -1.44499876e-02f, -4.50693630e-02f, -2.82860585e-02f, 9.79895741e-02f, 4.04309332e-02f, -2.30904389e-02f, 9.09365639e-02f, 1.95730701e-02f, 1.07804857e-01f, -5.00234738e-02f,
  2.38058731e-01f, 2.49435782e-01f, 8.18984285e-02f, -3.39312330e-02f, -6.99563883e-03f, -4.96334508e-02f, 6.53360710e-02f, 1.55394757e-02f, -1.39024565e-02f, -2.19133776e-03f,
  -5.02495542e-02f, 7.07211420e-02f, 2.44079418e-02f, -4.83556688e-02f, -1.59106012e-02f, 1.73346847e-01f, 1.42083749e-01f, -4.78974655e-02f, 6.97136968e-02f, 3.59651707e-02f,
  -1.10681597e-02f, -1.02576256e-01f, -2.94408929e-02f, -3.19668502e-02f, 7.40830079e-02f, 4.17965427e-02f, -4.92217131e-02f, -4.29592878e-02f, -8.39145780e-02f, 2.55364813e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.98029578e-01f, 7.14053750e-01f, 2.96157748e-01f, -7.88867532e-04f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.19746074e-01f, 1.84743002e-01f, 2.19204649e-01f, -5.76475143e-01f, 3.29814553e-01f, -4.51963097e-01f, -2.48718396e-01f, 3.10121119e-01f, 1.61370352e-01f, -3.70076835e-01f,
  -2.07378283e-01f, 6.33453310e-01f, 2.43464887e-01f, 2.15875059e-01f, -4.51676518e-01f, 4.89207119e-01f, 4.87998039e-01f, -2.21670836e-01f, 1.20716751e-01f, 4.12520617e-01f,
  2.98795849e-02f, -1.44950062e-01f, -6.29553497e-01f, 3.27333689e-01f, -1.06934242e-01f, -5.50541747e-03f, 2.83697188e-01f, 1.05892181e-01f, -2.64839232e-01f, 3.73188436e-01f,
  4.23062146e-01f, -2.82711625e-01f, -2.07811773e-01f, -4.78214473e-02f, 1.54652044e-01f, -1.71244651e-01f, 6.62752464e-02f, -3.09715718e-01f, -5.62148631e-01f, 4.58563507e-01f,
  -2.71495700e-01f, 1.49123162e-01f, 4.40119624e-01f, 4.74642128e-01f, -2.42408633e-01f, 5.91779985e-02f, -1.90232635e-01f, 4.97524202e-01f, 5.07406294e-01f, -1.33050829e-01f,
  2.23637640e-01f, 5.43527007e-02f, -2.40140915e-01f, -1.21152468e-01f, -1.85979903e-01f, -2.47156873e-01f, -5.48358738e-01f, -3.11648816e-01f, -5.05661190e-01f, 2.00705037e-01f,
  3.07854682e-01f, -2.81031400e-01f, 3.04844081e-01f, -2.20202595e-01f, 3.26327115e-01f, -2.19305456e-01f, 2.36060679e-01f, 1.37384757e-01f, -1.11713558e-01f, -1.24167211e-01f,
  -1.48048192e-01f, -4.67578061e-02f, -7.24239871e-02f, 1.74999788e-01f, 4.14337009e-01f, 2.15746388e-01f, 7.15570152e-02f, -7.08573937e-01f, 9.38627124e-02f, 3.47623497e-01f,
  -2.31446460e-01f, 6.21768311e-02f, -3.68021935e-01f, 2.42926210e-01f, 9.51987505e-02f, 3.60700577e-01f, -1.04518957e-01f, -5.02660751e-01f, 6.04442418e-01f, 3.01487178e-01f,
  -5.35234630e-01f, 5.91095649e-02f, -5.28286695e-01f, 5.94589174e-01f, -4.24694344e-02f, 1.85326055e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  2.56321132e-01f, 4.04190332e-01f, -1.03909619e-01f, 9.59672213e-01f, -6.29225448e-02f, 7.99402952e-01f, 5.77632308e-01f, -7.05066144e-01f, 3.93200874e-01f, 3.98594320e-01f,
  2.27321550e-01f, -6.12731218e-01f, 4.78541665e-02f, -2.64401019e-01f, 9.32588935e-01f, -2.18578413e-01f, 1.24351144e-01f, 4.09743637e-01f, -2.64243156e-01f, 1.43032730e-01f,
  2.90992022e-01f, 4.46858287e-01f, 1.50862411e-01f, 8.67516361e-03f, 4.16186690e-01f, -1.09540842e-01f, -8.56842875e-01f, 3.94194603e-01f, -5.82978785e-01f, 8.20312321e-01f,
  1.35338277e-01f, -6.05811536e-01f, 5.86172283e-01f, -4.60894331e-02f, -2.69351125e-01f, 2.45697215e-01f, 3.94682139e-01f, 8.13903749e-01f, 1.20184290e+00f, -1.45875081e-01f,
  1.07627106e+00f, 2.70732939e-01f, 6.75354958e-01f, -9.22363281e-01f, 1.48464069e-01f, 1.66832432e-01f, 5.93316555e-01f, 6.37419164e-01f, 6.28008664e-01f, 1.28499255e-01f,
  -7.61469603e-01f, 3.76074433e-01f, 7.54861295e-01f, 5.94363213e-01f, 6.45970404e-01f, 4.15281802e-01f, 1.22521567e+00f, -1.61080420e-01f, 7.94263363e-01f, -7.80782998e-01f,
  -8.11035633e-01f, 3.03590268e-01f, -8.41984823e-02f, 9.42317128e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.89217255e-01f, 6.17586412e-02f, 5.43309867e-01f, 4.98167604e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  1.40875220e-01f, -2.63419330e-01f, 5.88040315e-02f, 2.38371000e-01f, -7.32742101e-02f, 2.42272332e-01f, -5.53327620e-01f, 8.48348618e-01f, 5.88183641e-01f, -3.00738048e-02f,
  4.11213517e-01f, 5.49855173e-01f, 5.69176614e-01f, -3.14157397e-01f, -3.55387218e-02f, -1.17976129e-01f, 2.51155138e-01f, -9.73593816e-02f, -8.41947556e-01f, -1.52752802e-01f,
  -4.69767869e-01f, -4.82549101e-01f, 3.49495620e-01f, -8.12128246e-01f, -2.55058765e-01f, -8.87803972e-01f, -6.19542420e-01f, 4.80139971e-01f, -8.33546072e-02f, 2.40754470e-01f,
  2.59882331e-01f, -5.93028329e-02f, -2.68489182e-01f, 3.20716314e-02f, -1.11026093e-01f, -2.86831558e-01f, -5.45029879e-01f, -8.19698349e-03f, -6.80282176e-01f, 2.77736545e-01f,
  -5.26902914e-01f, -3.36648077e-01f, -5.68848133e-01f, 1.05776393e+00f, 3.02365929e-01f, 1.46044672e-01f, 2.63561338e-01f, 7.93923214e-02f, -1.01704508e-01f, 3.55461597e-01f,
  2.91180789e-01f, 6.49428606e-01f, -2.43220940e-01f, -1.48215324e-01f, 4.33089405e-01f, 5.31418741e-01f, 6.64327085e-01f, -1.05915499e+00f, 5.26114285e-01f, 2.32076403e-02f,
  -2.43083969e-01f, 1.23208590e-01f, -1.94594339e-01f, 4.26311970e-01f, -9.33450818e-01f, -1.38357803e-01f, 3.65804255e-01f, -1.80339351e-01f, -4.41075236e-01f, 1.10154428e-01f,
  -5.95912933e-01f, 4.37954724e-01f, 2.06311066e-02f, 2.17497036e-01f, -1.77267045e-01f, 5.62225759e-01f, 4.27096635e-01f, 1.45042837e-01f, -3.87764215e-01f, -2.80008584e-01f,
  3.60893846e-01f, -1.59241501e-02f, 5.62292300e-02f, 7.66024832e-03f, 4.05053616e-01f, 9.78797302e-02f, 6.81360781e-01f, -9.67979804e-02f, 8.71946812e-02f, 1.61465898e-01f,
  4.84850019e-01f, -6.48470640e-01f, -5.52634358e-01f, -5.38727522e-01f, 2.66590893e-01f, -2.38278229e-03f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.51334381e+00f, 3.41413945e-01f, 3.84067714e-01f, 1.48007405e+00f, 1.32180825e-01f, 7.26426065e-01f, 1.17763579e-01f, 2.00671697e+00f, 1.22577107e+00f, -1.64972227e-02f,
  3.57950836e-01f, -1.48602739e-01f, 4.35101204e-02f, 7.96578586e-01f, -8.18057209e-02f, -1.60724387e-01f, -1.06572115e+00f, 8.24018359e-01f, 1.26215637e-01f, 4.12372053e-02f,
  6.53605938e-01f, 3.12742621e-01f, -7.49777615e-01f, -1.21843028e+00f, -1.02853847e+00f, 1.21116436e+00f, 1.28011751e+00f, -1.42633569e+00f, 9.68689263e-01f, -1.05249619e+00f,
  8.09262574e-01f, -4.06409770e-01f, -6.35166824e-01f, 7.26307869e-01f, 1.15848577e+00f, 9.85844016e-01f, 2.57576674e-01f, 2.64852464e-01f, 3.06937933e-01f, -4.33963299e-01f,
  1.06700969e+00f, -1.30538309e+00f, 1.07197821e+00f, -8.07382286e-01f, -3.72167170e-01f, -4.65366244e-01f, 8.79643619e-01f, 1.48284280e+00f, 6.86073303e-01f, 2.31087014e-01f,
  1.63218126e-01f, 6.45067245e-02f, 7.60017872e-01f, 6.94733441e-01f, -9.98915136e-01f, 1.01777828e+00f, -1.45013738e+00f, 8.68324339e-01f, -5.35540521e-01f, 1.50981593e+00f,
  1.42686367e+00f, 8.13659310e-01f, 9.79263067e-01f, 9.02897358e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  8.01666558e-01f, 6.38761520e-01f, 4.08505946e-01f, -1.57133654e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  3.13337862e-01f, -8.04199755e-01f, -6.93539739e-01f, -2.34590039e-01f, -3.77689064e-01f, 5.77840507e-01f, -2.30659127e-01f, 1.08108914e+00f, 9.45702791e-01f, 3.91180739e-02f,
  3.43754262e-01f, 5.82462072e-01f, -1.87608612e+00f, -1.13400984e+00f, 5.42887807e-01f, -6.31917045e-02f, -9.07868594e-02f, 3.76104444e-01f, -1.14127494e-01f, 6.00150526e-02f,
  -1.19234788e+00f, -4.20781732e-01f, -1.34403229e+00f, -2.01437235e-01f, -8.27669263e-01f, 1.16553688e+00f, 2.31440052e-01f, 1.11684121e-01f, -6.47632420e-01f, 3.70337181e-02f,
  8.26283216e-01f, -1.14036894e+00f, 2.19254836e-01f, 7.65644550e-01f, 8.20308268e-01f, -9.71294165e-01f, -1.90986347e+00f, 6.16630204e-02f, -1.29162014e+00f, 1.64035976e+00f,
  -1.03611362e+00f, -1.03364205e+00f, -4.62385595e-01f, 1.03817761e+00f, -9.28144157e-01f, 7.06857145e-01f, -8.05316389e-01f, -2.46416524e-01f, 4.98615026e-01f, 2.46132731e-01f,
  7.84500659e-01f, -1.68251240e+00f, 6.88851476e-01f, -1.22495043e+00f, 1.71506077e-01f, 1.82412064e+00f, 4.15504158e-01f, 8.14351022e-01f, 8.52631271e-01f, -9.60775852e-01f,
  1.01773083e+00f, -9.45266485e-01f, -7.56643116e-01f, -7.81617522e-01f, 8.11109066e-01f, -1.01641107e+00f, -6.94480360e-01f, 5.04329681e-01f, -1.55462697e-01f, -6.84092104e-01f,
  -7.56965220e-01f, 7.26312339e-01f, 2.54298359e-01f, 4.55369353e-01f, -1.50971758e+00f, -6.76937044e-01f, -5.35489433e-02f, -1.17347682e+00f, -3.73179525e-01f, 4.93114591e-01f,
  -1.01917613e+00f, 4.66952138e-02f, 6.04659975e-01f, 1.30999655e-01f, -7.71155834e-01f, 3.93785268e-01f, 1.20421696e+00f, -1.29307818e+00f, 1.32412052e+00f, 6.91852510e-01f,
  -3.75287533e-01f, 1.04827547e+00f, 2.39843205e-01f, -2.99047649e-01f, 1.45112917e-01f, -7.63453990e-02f, 1.01906985e-01f, 2.65393168e-01f, -7.50605822e-01f, -1.20775425e+00f,
  5.25950730e-01f, 6.25684619e-01f, 6.77862704e-01f, -8.38684201e-01f, 1.52898514e+00f, -3.55573148e-01f, -1.21542169e-02f, -7.41436124e-01f, -4.77808386e-01f, 8.81203592e-01f,
  -1.25975180e+00f, -7.12780803e-02f, 1.40711471e-01f, -6.08176649e-01f, -9.88117516e-01f, -3.11625004e-01f, 2.52713892e-03f, 2.87890911e-01f, 1.13735056e+00f, -8.30010593e-01f,
  -7.81738341e-01f, 6.36284351e-01f, -9.64858592e-01f, 1.36729252e+00f, 1.02937531e+00f, -9.02998328e-01f, 1.48233339e-01f, -1.57640767e+00f, 1.90100178e-01f, -5.80087304e-01f,
  2.68677592e-01f, 1.11530316e+00f, 1.82551146e+00f, 7.52643049e-01f, -5.97656608e-01f, -1.18518984e+00f, -7.52675116e-01f, -1.12044203e+00f, -3.63478929e-01f, 6.61826372e-01f,
  -8.90912473e-01f, 1.02682161e+00f, 1.11440085e-01f, -1.39391875e+00f, -6.83625400e-01f, 3.59851658e-01f, -3.48441243e-01f, 1.32564139e+00f, 5.23168266e-01f, -3.28667229e-03f,
  3.82188931e-02f, 3.79196197e-01f, -1.02009249e+00f, -5.07880569e-01f, 5.55335641e-01f, -1.01439083e+00f, -4.75569993e-01f, 1.53991833e-01f, -1.63729653e-01f, 1.56333938e-01f,
  4.94552851e-01f, 5.80672026e-01f, 7.94261634e-01f, 1.49006605e+00f, 7.54389286e-01f, 8.13147545e-01f, 1.35416061e-01f, -2.09245372e+00f, -2.91390028e-02f, 3.70202869e-01f,
  5.00617325e-02f, -5.43848813e-01f, 6.89652324e-01f, -1.37785280e+00f, -1.52837503e+00f, 2.65998930e-01f, -5.67089379e-01f, -1.96639672e-02f, -3.95999253e-01f, -8.62321436e-01f,
  -4.92374271e-01f, -6.27634227e-01f, 8.04278493e-01f, 5.09504735e-01f, -2.12439448e-01f, -6.02199852e-01f, 1.15086114e+00f, 4.28678811e-01f, -3.56233776e-01f, -4.34187829e-01f,
  -1.79243743e+00f, 8.21285725e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  7.66880903e-03f, 1.50710747e-01f, 3.51751745e-01f, 3.14591169e-01f, 1.59728333e-01f, -6.76775455e-01f, -4.68918562e-01f, 6.63172975e-02f, 5.44832498e-02f, -3.06808710e-01f,
  3.79773766e-01f, -1.38360202e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    