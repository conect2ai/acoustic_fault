/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.03833534e-02f, -4.77562129e-01f, -1.19970441e-01f, -1.92231033e-02f, 3.02292913e-01f, 8.11315328e-02f, 5.94330244e-02f, 4.23036739e-02f, -2.67294884e-01f, -1.65554270e-01f,
  1.71756878e-01f, -2.19478801e-01f, -6.22482672e-02f, 4.68789898e-02f, 3.24204177e-01f, -1.09752767e-01f, 1.33030340e-01f, 8.81213993e-02f, -1.37570649e-02f, 9.92196649e-02f,
  1.61545381e-01f, 1.78940624e-01f, 1.10078789e-01f, 1.33969501e-01f, 1.85425714e-01f, 1.37313036e-02f, 1.89796358e-01f, 6.22435585e-02f, 7.27306753e-02f, 1.99197643e-02f,
  -8.89851004e-02f, -6.04826882e-02f, 3.06498427e-02f, -1.46220684e-01f, 1.35127455e-01f, 4.61233296e-02f, 9.39433128e-02f, 6.33954331e-02f, 9.22860876e-02f, 6.63851351e-02f,
  -3.10608353e-02f, 5.50288260e-02f, -9.33750346e-03f, -4.46298569e-02f, -3.02887578e-02f, -2.84161661e-02f, -1.14503950e-02f, -3.98294777e-02f, -3.25046405e-02f, 6.64507225e-02f,
  5.31586586e-03f, 4.03783955e-02f, -5.42923016e-03f, -1.42947491e-02f, 2.13153865e-02f, 3.73477442e-03f, -1.06472131e-02f, 7.08759278e-02f, -5.48358336e-02f, 2.58588642e-02f,
  4.69455644e-02f, -2.37764530e-02f, -5.75632788e-03f, 2.69536232e-03f, -3.57027203e-02f, 5.40776365e-02f, 1.12037407e-02f, 7.24955872e-02f, 5.27535891e-03f, -1.65488552e-02f,
  -1.51330531e-02f, 9.25469398e-03f, 2.83649713e-02f, -1.65102892e-02f, 6.17034659e-02f, -4.32726219e-02f, 2.27119010e-02f, -3.55492765e-03f, -2.05397531e-02f, 3.76441143e-02f,
  -5.63936494e-02f, -3.86777706e-02f, 3.77363078e-02f, 8.89197085e-03f, -1.61637347e-02f, 1.83927845e-02f, -2.90070474e-02f, -6.78384230e-02f, -2.34606280e-03f, 7.07066879e-02f,
  -1.43200085e-01f, -3.11493706e-02f, 1.62100494e-02f, -3.52005437e-02f, -4.61135507e-02f, 5.22735752e-02f, -4.35966812e-02f, -4.23224308e-02f, -1.01801522e-01f, -4.27924655e-02f,
  5.69473617e-02f, 9.84048378e-03f, -3.41021009e-02f, 8.57928023e-03f, 6.05458580e-03f, 6.71025962e-02f, 7.56560937e-02f, 9.54208837e-04f, 7.65343904e-02f, 2.25202907e-02f,
  -1.89272873e-02f, 5.11806682e-02f, -1.23479031e-02f, 1.09462135e-01f, 4.47268076e-02f, -1.60779469e-02f, 2.18449440e-02f, -4.11851332e-02f, 2.79666949e-02f, -5.06001152e-02f,
  8.65462348e-02f, -6.49589598e-02f, -1.24908090e-01f, 1.67212069e-01f, 1.29648596e-01f, 9.51702415e-04f, -2.88303465e-01f, 1.07860819e-01f, 8.18706676e-02f, -3.35124910e-01f,
  -1.29067153e-01f, -1.02406144e-01f, -2.06001014e-01f, -3.30527290e-03f, 4.54585165e-01f, 3.11467145e-02f, -3.35360654e-02f, -1.53159112e-01f, 1.12543866e-01f, -3.84020545e-02f,
  2.06622034e-01f, 8.23207498e-02f, 6.78074658e-02f, 7.65761063e-02f, -1.60656318e-01f, -2.15982776e-02f, 7.29247257e-02f, -5.07705919e-02f, 2.34321244e-02f, 1.09071262e-01f,
  -4.50628735e-02f, 2.07675882e-02f, -9.68922302e-02f, -6.21998794e-02f, -1.19772423e-02f, -7.07526132e-02f, -6.42229766e-02f, 1.44343423e-02f, 5.73541922e-03f, -2.49582971e-03f,
  -4.36073430e-02f, 5.50367832e-02f, -1.85158867e-02f, 6.09528460e-02f, -8.23585317e-04f, -3.58508043e-02f, 3.81421782e-02f, -1.09501397e-02f, -2.30061356e-02f, 3.72842364e-02f,
  -1.14316553e-01f, 1.82085633e-02f, -8.85253306e-03f, 2.17410401e-02f, 1.01497866e-01f, -2.91308686e-02f, -4.73888181e-02f, -3.20156924e-02f, -3.37284692e-02f, 3.93847600e-02f,
  8.09498355e-02f, 4.27458584e-02f, -8.86047855e-02f, -8.71794764e-03f, 2.19679847e-02f, 1.73318908e-02f, 2.78601293e-02f, -1.67446327e-03f, -3.34001705e-03f, 6.72443304e-04f,
  -3.03058792e-02f, -1.11551741e-02f, -8.42310488e-03f, 2.97864154e-02f, -5.30350804e-02f, -6.17684843e-03f, -9.94158629e-03f, -4.43251431e-03f, 1.08910101e-02f, 4.12890315e-02f,
  2.50554029e-02f, 7.67094567e-02f, -3.16621852e-03f, -4.51754518e-02f, 2.61915494e-02f, 3.21243554e-02f, -1.28728813e-02f, 2.49666981e-02f, 2.27038898e-02f, 2.38754638e-02f,
  3.21440515e-03f, 8.34441483e-02f, 3.14522386e-02f, 2.01036618e-03f, 2.79225465e-02f, 3.68559062e-02f, 7.23863393e-02f, 2.21116953e-02f, 4.08463031e-02f, 2.09229591e-04f,
  -9.12079811e-02f, 1.61148328e-02f, -6.56350143e-03f, 4.80482355e-02f, 5.73981106e-02f, -1.69029497e-02f, -8.21968019e-02f, -9.53952875e-03f, 7.12050498e-02f, -1.62759665e-02f,
  2.26102839e-03f, -6.06838390e-02f, 1.47115579e-02f, -1.74869131e-02f, -1.09250741e-02f, -5.42625561e-02f, 3.71256694e-02f, -3.39558981e-02f, 6.06682226e-02f, -2.90413313e-02f,
  -2.55197614e-01f, 1.75811917e-01f, 3.32925677e-01f, -1.86944857e-01f, -2.57746786e-01f, 8.25208575e-02f, -3.10551710e-02f, -1.33118376e-01f, -2.24427897e-02f, -1.78634208e-02f,
  -3.21121633e-01f, 1.66870475e-01f, 1.94410294e-01f, -1.11871243e-01f, 6.78529590e-02f, 1.83200568e-01f, -5.95523827e-02f, -6.33214265e-02f, -1.36128422e-02f, -1.65204734e-01f,
  -8.44598934e-02f, -2.85915613e-01f, 3.20959575e-02f, -1.69998989e-01f, -1.42995715e-01f, -5.37168495e-02f, -1.24837831e-01f, 1.15212120e-01f, -1.14991501e-01f, 9.77890119e-02f,
  -1.20462634e-01f, -1.50831327e-01f, 1.14664175e-02f, 9.40083116e-02f, 9.62318107e-03f, -1.30865467e-03f, 7.68482313e-02f, 1.85924768e-02f, -6.21864162e-02f, 4.79657724e-02f,
  -8.52534082e-03f, -3.19183953e-02f, -5.01606427e-02f, 8.92851800e-02f, -6.75653070e-02f, 4.14075376e-03f, 3.63722146e-02f, -2.93154977e-02f, -2.29917224e-02f, -5.98518131e-03f,
  4.84686755e-02f, 6.31834790e-02f, 3.22935693e-02f, 4.27804030e-02f, 1.56632178e-02f, -6.08687196e-03f, 6.19756319e-02f, 7.66310692e-02f, 5.77246249e-02f, -2.78856605e-02f,
  3.59006226e-03f, 2.54200213e-03f, 1.72053126e-03f, -3.33009437e-02f, -1.56234289e-02f, -8.13109875e-02f, 6.62808120e-02f, 2.81812623e-03f, -9.12161637e-03f, -3.50968093e-02f,
  -4.31622528e-02f, -4.58631925e-02f, -1.22252693e-02f, 2.82579120e-02f, -4.33132015e-02f, -1.88896526e-02f, 5.83386607e-02f, 5.88969886e-03f, 5.01234736e-03f, -1.91986468e-02f,
  4.28680219e-02f, -1.83260441e-02f, -2.81186886e-02f, -1.54529121e-02f, 6.23764656e-02f, 1.71956215e-02f, -4.09831144e-02f, 2.88320649e-02f, -4.38126661e-02f, -1.11414427e-02f,
  -2.06871368e-02f, -1.39456624e-02f, 2.46703196e-02f, -2.00345479e-02f, 3.89306201e-03f, 3.13048363e-02f, -1.96974371e-02f, 4.28852551e-02f, 1.22139104e-01f, -7.21473061e-03f,
  1.38859693e-02f, 3.59859765e-02f, 6.73493743e-02f, -5.55338673e-02f, 7.69087002e-02f, -3.49695571e-02f, 1.88357122e-02f, -2.72546243e-02f, -4.01627608e-02f, -1.68134719e-02f,
  -8.25477839e-02f, -6.32241741e-02f, 5.77669730e-03f, 1.21438932e-02f, -8.16255212e-02f, 2.37837224e-03f, 6.20588195e-03f, -8.50313157e-03f, -2.21355800e-02f, 9.48058069e-02f,
  2.23788649e-01f, -2.11301267e-01f, -1.50312260e-01f, 8.77252892e-02f, -4.20098901e-02f, 1.47496670e-01f, 2.84823954e-01f, -2.32335299e-01f, 7.61217773e-02f, -8.42253864e-02f,
  9.77893025e-02f, 1.51219621e-01f, 4.17652912e-02f, 1.71120122e-01f, 5.37200034e-01f, 2.17173412e-01f, 2.19588816e-01f, 2.10372359e-01f, 3.22704315e-02f, -3.07261907e-02f,
  8.95690173e-02f, 2.55048610e-02f, -3.23260296e-03f, -3.32737267e-01f, -8.79909918e-02f, -3.13795179e-01f, -1.05856553e-01f, -1.78985313e-01f, -4.63326350e-02f, 9.08128321e-02f,
  6.39807433e-02f, -7.83668645e-03f, -9.05692056e-02f, -1.48633085e-02f, 1.03222346e-02f, 1.33575881e-02f, 4.12054136e-02f, 8.46760720e-02f, -9.52865742e-03f, -3.50904167e-02f,
  8.59998539e-02f, -2.29008328e-02f, -1.16279756e-03f, -4.96340804e-02f, -4.30144854e-02f, -5.21627367e-02f, -4.01825719e-02f, -4.20453958e-02f, -7.56363943e-02f, 2.77327169e-02f,
  1.93471480e-02f, -3.57576460e-02f, 2.45897053e-03f, 4.45957445e-02f, -1.88829061e-02f, 9.43858060e-04f, -1.60559937e-02f, 9.08758771e-03f, 1.80160590e-02f, 5.91825731e-02f,
  -2.50399634e-02f, -5.20988880e-03f, -8.93410761e-03f, 2.87656784e-02f, 5.46156242e-02f, -4.62909937e-02f, 5.56509271e-02f, 9.36681870e-03f, -5.23600765e-02f, 5.27495593e-02f,
  -1.76908765e-02f, -3.27456975e-03f, 2.19524978e-03f, 1.78583488e-02f, 1.75369717e-02f, -3.27361077e-02f, 1.72770601e-02f, 1.64736342e-02f, -1.26576135e-02f, -6.86043426e-02f,
  5.42093478e-02f, 3.65665071e-02f, 1.04782116e-02f, -6.52605714e-03f, -8.97103222e-04f, 4.43109833e-02f, -4.51268405e-02f, -2.52299141e-02f, -5.42272627e-02f, 7.47281462e-02f,
  -9.00946744e-03f, -4.80820164e-02f, -2.03576908e-02f, 1.93156693e-02f, 5.40615581e-02f, -1.71229001e-02f, 2.71795355e-02f, -5.57631217e-02f, -2.77803419e-03f, 5.04287072e-02f,
  -5.86087443e-02f, 1.89668182e-02f, 4.64174077e-02f, 3.01715434e-02f, -3.86516713e-02f, 4.17371392e-02f, 8.45667347e-02f, 3.53237651e-02f, 4.14232202e-02f, -1.73045658e-02f,
  -3.77351493e-02f, 5.27819954e-02f, 3.55817229e-02f, -6.37914836e-02f, 1.37542496e-02f, 5.59342578e-02f, 4.09221612e-02f, -4.03264761e-02f, -2.06707884e-02f, 5.88941798e-02f,
  -1.05385100e-02f, 5.72010167e-02f, 4.84635085e-02f, -1.74270079e-01f, 4.44540083e-02f, 2.35167697e-01f, 3.25200826e-01f, -5.79271913e-02f, 8.00501555e-02f, -2.02361755e-02f,
  1.84707165e-01f, -2.58565962e-01f, 3.39810371e-01f, -1.25020862e-01f, 1.76653519e-01f, 3.01577449e-01f, 1.75687671e-02f, -9.00494680e-02f, 5.15857451e-02f, -8.64639059e-02f,
  -1.17584161e-01f, -3.22624259e-02f, -8.41348991e-02f, -9.79066491e-02f, -1.39005184e-01f, -1.75088525e-01f, -1.69447079e-01f, 8.60329121e-02f, -2.73629338e-01f, 8.02465808e-03f,
  1.19295448e-01f, 1.24684013e-01f, -9.91148204e-02f, 1.39016714e-02f, -6.22630455e-02f, -3.69869880e-02f, -1.13893412e-02f, 7.02856109e-02f, 7.51447901e-02f, -1.61709525e-02f,
  2.33589169e-02f, -5.05494364e-02f, -3.74404788e-02f, 4.34558317e-02f, 5.34628576e-04f, -6.29187748e-02f, -5.47296181e-02f, 2.49378681e-02f, -3.22015472e-02f, 3.78638357e-02f,
  5.06300032e-02f, -3.82283479e-02f, -7.15697706e-02f, -4.79316823e-02f, -1.94324087e-02f, 2.23250221e-02f, 2.74258312e-02f, -3.81986909e-02f, -6.60940558e-02f, -7.25471973e-02f,
  -3.54375467e-02f, 4.04435359e-02f, 4.61359471e-02f, 1.78115442e-02f, 3.10767442e-03f, 2.63624247e-02f, 2.09540501e-02f, -5.76402321e-02f, -2.92082876e-02f, 1.35227051e-02f,
  6.55984320e-03f, -6.35218387e-03f, -2.23347675e-02f, 4.43629920e-02f, -2.97154896e-02f, 3.42058614e-02f, -2.42264625e-02f, -2.54020393e-02f, -6.76208213e-02f, -2.72031538e-02f,
  4.99647371e-02f, 7.50620812e-02f, 2.78368033e-02f, -5.70159778e-02f, 4.80435044e-02f, 4.03929204e-02f, -7.06547052e-02f, 4.22803089e-02f, 2.14892812e-02f, -4.24731430e-03f,
  -6.76660216e-04f, -4.54028174e-02f, 3.00076026e-02f, 7.92214926e-03f, 4.15290222e-02f, 3.59570421e-02f, 3.49164009e-03f, -1.65440477e-02f, 2.13057809e-02f, 7.77556971e-02f,
  -7.17232078e-02f, -1.66303793e-03f, -1.77582912e-02f, -2.20864583e-02f, 1.78344287e-02f, 3.85617986e-02f, -1.91207603e-02f, -2.79669557e-02f, -9.28777922e-03f, -8.04096535e-02f,
  -4.80071083e-03f, 6.33971486e-03f, -1.98207851e-02f, -7.73197636e-02f, -4.34315316e-02f, -6.02138489e-02f, -1.16447777e-01f, 4.21964638e-02f, 2.36069374e-02f, 4.33704853e-02f,
  -5.28393209e-01f, 1.23574331e-01f, -1.13609445e-03f, -3.39647800e-01f, 9.84847024e-02f, 2.60274321e-01f, 9.98204201e-02f, -5.14516123e-02f, -1.31877661e-01f, 9.93284881e-02f,
  6.52704984e-02f, -1.02854021e-01f, 2.85662532e-01f, 1.07050203e-01f, 6.04181774e-02f, 2.55488276e-01f, -2.59134639e-02f, -5.12511516e-03f, -1.30583672e-02f, -1.02401115e-01f,
  -1.52740672e-01f, 8.23792964e-02f, 8.09424222e-02f, 1.23066932e-01f, -4.44621854e-02f, -2.00282127e-01f, -1.10368297e-01f, 5.06182797e-02f, -5.78240678e-03f, 1.30462289e-01f,
  -8.56951773e-02f, -2.71606714e-01f, 2.61044949e-02f, 6.69519901e-02f, -3.50547470e-02f, 3.09459530e-02f, -2.06782855e-02f, 4.04377468e-02f, 1.52658438e-02f, 2.42363792e-02f,
  5.01790829e-02f, -2.38819350e-03f, -1.26987854e-02f, 4.29498181e-02f, 7.37010175e-03f, -1.06156562e-02f, 4.11431305e-02f, -4.81285574e-03f, -3.57247866e-03f, 1.92368254e-02f,
  2.04233802e-03f, -1.27424058e-02f, -3.83489542e-02f, -2.82333456e-02f, -2.88235918e-02f, 3.86226363e-02f, 4.01274562e-02f, -3.95597704e-02f, -4.15620245e-02f, -7.29496703e-02f,
  -4.24328558e-02f, 2.37001665e-02f, 2.20357627e-02f, -1.97168496e-02f, -2.57383892e-03f, -3.24664414e-02f, 7.69020582e-04f, 4.01254222e-02f, -3.72473784e-02f, 3.48400623e-02f,
  -7.47682818e-04f, -5.36598526e-02f, -2.68454221e-03f, 1.15537737e-02f, -8.80117994e-03f, -7.85192922e-02f, 2.06491668e-02f, -6.57330872e-03f, -5.84969670e-02f, -7.98736606e-03f,
  -2.09079329e-02f, 2.88868006e-02f, -1.63490437e-02f, -1.06156692e-02f, 7.81713501e-02f, 1.79168973e-02f, -1.54899051e-02f, -2.23321337e-02f, -3.18364636e-03f, -4.54493612e-03f,
  5.64429164e-03f, -2.82870144e-01f, -1.34074446e-02f, -2.68725622e-02f, 6.66794553e-02f, 6.55058632e-03f, 5.07822670e-02f, -1.60232224e-02f, 3.24799269e-02f, -2.69588660e-02f,
  -3.53605077e-02f, -4.27309722e-02f, -4.55670208e-02f, -9.75467637e-03f, -2.27814121e-03f, 3.43898870e-02f, 8.97439953e-04f, -1.80237857e-03f, -2.52830237e-02f, 3.67085263e-02f,
  -6.33106306e-02f, -5.66261448e-03f, 1.30911497e-02f, -4.51966412e-02f, 2.83464137e-02f, -3.32852229e-02f, -2.29890626e-02f, 2.56776772e-02f, 1.93413626e-02f, 7.52673447e-02f,
  -3.41399103e-01f, 4.46729772e-02f, -3.49291593e-01f, 8.65582675e-02f, 1.44847780e-01f, 1.66862801e-01f, 1.49962202e-01f, 7.24455342e-02f, 1.93589061e-01f, 2.30284348e-01f,
  1.50736764e-01f, -2.47111425e-01f, -7.74724260e-02f, 2.36523792e-01f, -1.60293356e-01f, 4.69333082e-02f, 1.49478719e-01f, 2.67655551e-02f, 2.78971698e-02f, -5.32283224e-02f,
  6.92341626e-02f, 1.96278721e-01f, -1.38440192e-01f, 1.54885843e-01f, 2.69741043e-02f, -9.36765075e-02f, -8.47396702e-02f, -1.53285846e-01f, 3.97936143e-02f, -3.28073353e-02f,
  -3.02302707e-02f, -2.03160807e-01f, -3.53164412e-02f, -1.09225646e-01f, -1.74333788e-02f, -2.63252463e-02f, -3.72931771e-02f, -8.89726356e-02f, -8.99443626e-02f, 5.47309173e-03f,
  -1.08957052e-01f, -1.27916262e-02f, 5.10350503e-02f, 3.81270498e-02f, 1.19342953e-02f, -3.14578302e-02f, 5.26484475e-02f, -3.27813486e-03f, 5.72062796e-03f, -3.17593105e-02f,
  1.04864128e-01f, 6.24804385e-02f, 3.35288867e-02f, -1.37736322e-02f, -3.93074490e-02f, 4.58680801e-02f, -1.70894712e-02f, -3.42801474e-02f, 3.66715668e-03f, 2.43722424e-02f,
  1.92288440e-02f, -7.83190783e-03f, -2.60217823e-02f, -2.01809313e-02f, 1.97831029e-03f, -5.87906837e-02f, 8.93804990e-03f, -4.44158874e-02f, -2.84065790e-02f, -6.14749966e-03f,
  6.26002848e-02f, -2.68520005e-02f, 2.13410463e-02f, -1.11425966e-02f, 4.32661623e-02f, 4.90498496e-03f, -5.00772446e-02f, 2.50746831e-02f, 4.41387780e-02f, 2.96819070e-03f,
  3.40129808e-02f, 5.18337823e-02f, 4.38172519e-02f, -1.06605832e-02f, 4.14814204e-02f, -2.15752535e-02f, 7.04197884e-02f, -1.88534986e-02f, 3.11106164e-02f, -3.33395861e-02f,
  -1.24650575e-01f, -6.46241829e-02f, 1.04348259e-02f, 6.76683933e-02f, -6.73711076e-02f, 6.01484291e-02f, 1.69157255e-02f, 1.35265877e-02f, 2.43905075e-02f, 1.29185589e-02f,
  4.75943908e-02f, 3.08202934e-02f, -1.37113605e-03f, -3.59453410e-02f, -3.24787735e-03f, 2.90451441e-02f, -2.90623773e-02f, -2.53789127e-03f, 2.60139033e-02f, -3.99839543e-02f,
  -4.61481623e-02f, -4.42991853e-02f, 2.79616471e-03f, 6.93605691e-02f, -1.69310253e-02f, 5.64785637e-02f, 4.06781398e-02f, -5.86561300e-02f, -1.08928178e-02f, 6.68661622e-03f,
  1.96888089e-01f, 7.77122602e-02f, -1.02155641e-01f, 1.15444243e-01f, -6.40710518e-02f, 2.46450052e-01f, 9.52376649e-02f, 1.35372713e-01f, 3.57727647e-01f, 1.30235240e-01f,
  -6.80853203e-02f, 5.13556488e-02f, -1.72917768e-01f, 1.88038141e-01f, 2.38024309e-01f, 1.53063402e-01f, 3.22556764e-01f, 1.69600010e-01f, 2.63251457e-02f, 5.06219338e-04f,
  6.44745678e-02f, 1.37484536e-01f, -8.96612331e-02f, 1.39625659e-02f, 2.48395465e-02f, -3.71703245e-02f, -1.58284336e-01f, -2.52777427e-01f, 5.06371679e-03f, -6.45352975e-02f,
  1.15729515e-02f, 2.03236230e-02f, 7.39841489e-03f, 3.79112661e-02f, 7.50177205e-02f, -8.03940073e-02f, -8.88104364e-02f, -1.21750347e-01f, -4.48970459e-02f, 9.41617638e-02f,
  4.32332642e-02f, 4.54045497e-02f, 9.35232341e-02f, -4.70284820e-02f, -1.48129109e-02f, -4.21151929e-02f, -4.48534004e-02f, -2.30537783e-02f, 4.90830876e-02f, -6.31145164e-02f,
  -6.23249747e-02f, -1.57097708e-02f, -1.31031396e-02f, 3.28439847e-02f, -4.89450321e-02f, 5.60018532e-02f, 3.76917534e-02f, -1.17081955e-01f, 1.39956743e-01f, 3.67906727e-02f,
  1.16035081e-02f, 7.31736496e-02f, -3.43796723e-02f, 2.17028428e-02f, -4.37873602e-02f, -3.15574673e-03f, -2.46721844e-04f, -7.31424289e-03f, -1.83922667e-02f, -8.13905429e-03f,
  -9.32887662e-03f, 4.83807549e-02f, 2.68282052e-02f, 2.80825607e-02f, 5.97787164e-02f, -1.54484017e-02f, -1.92276377e-03f, 3.32492664e-02f, 7.06790835e-02f, -3.20061892e-02f,
  -6.02309480e-02f, 7.46432468e-02f, 9.41657275e-03f, -3.40973325e-02f, -3.61874141e-02f, -3.06633841e-02f, 2.20482223e-04f, -2.77507287e-02f, -4.91947532e-02f, -2.73326952e-02f,
  1.73863843e-02f, 1.18771620e-01f, 2.59298384e-02f, -5.01453830e-03f, 2.11032629e-02f, 8.30222443e-02f, 1.17911592e-01f, 4.32708301e-02f, -9.64287668e-03f, 1.42900376e-02f,
  -3.44231091e-02f, -6.72644600e-02f, 3.73511724e-02f, 4.25237529e-02f, 4.63344753e-02f, 5.04254214e-02f, 5.23160659e-02f, 6.98958114e-02f, 1.51600931e-02f, -4.56262194e-02f,
  -2.88495589e-02f, 2.44017541e-02f, 1.20393671e-02f, 6.98689371e-02f, 4.77367863e-02f, -5.85264014e-03f, 2.22257543e-02f, 1.29417460e-02f, -2.21184455e-02f, 4.94868644e-02f,
  9.11265090e-02f, -1.20618515e-01f, -3.45462076e-02f, 8.72262567e-02f, -2.36775652e-01f, -2.04557553e-01f, 4.42616083e-02f, -1.93913385e-01f, -2.66375005e-01f, 8.03432092e-02f,
  -1.25336060e-02f, 1.45626990e-02f, -6.40886575e-02f, 7.93665946e-02f, 2.36743331e-01f, 8.18698779e-02f, 1.09886833e-01f, 2.43661068e-02f, -2.09194928e-01f, 5.44146635e-02f,
  -6.65393705e-03f, 1.56484872e-01f, 2.07431197e-01f, -2.17657592e-02f, 8.76477435e-02f, -4.43427078e-02f, 2.73895025e-01f, -1.27465963e-01f, 1.50317118e-01f, -5.76797035e-03f,
  -1.51097216e-02f, -2.97023579e-02f, -9.67330039e-02f, 1.64557770e-02f, -1.55860069e-03f, 3.93831544e-02f, 4.66002822e-02f, -6.04067445e-02f, -5.09781353e-02f, 2.39467341e-03f,
  -4.53923451e-04f, 6.33199587e-02f, -5.33967428e-02f, -3.90287228e-02f, -6.95647597e-02f, -1.38175616e-04f, 3.24326903e-02f, -8.17921944e-03f, 6.90506995e-02f, -6.52308315e-02f,
  7.09864944e-02f, -3.13711613e-02f, -1.29292617e-02f, 9.51224845e-03f, -2.54884362e-03f, -6.88336790e-03f, 5.46138920e-02f, 3.61289503e-03f, 5.85878268e-02f, -3.09343059e-02f,
  1.69622861e-02f, -1.09871306e-01f, -7.44962483e-04f, 6.43956140e-02f, -1.70261413e-02f, -5.10259494e-02f, 8.65469500e-02f, 3.67402070e-04f, -6.20613340e-03f, -2.63052639e-02f,
  -9.23018064e-03f, 5.86477928e-02f, -6.33838400e-02f, -1.70771200e-02f, 4.75733690e-02f, -4.97268438e-02f, -2.56594159e-02f, -6.99278861e-02f, 5.76730468e-04f, -4.01572511e-03f,
  4.13370058e-02f, -1.33802732e-02f, -1.59394573e-02f, -5.77390492e-02f, 9.73191485e-03f, 4.00249176e-02f, -2.16603894e-02f, -4.23208140e-02f, -6.55539632e-02f, 7.53799570e-04f,
  -5.42559065e-02f, 7.88160339e-02f, 2.73388345e-02f, 4.00896855e-02f, -6.17159270e-02f, -5.34049980e-02f, 2.51127407e-02f, -5.30053340e-02f, 2.35326178e-02f, -5.58625301e-03f,
  1.30559113e-02f, 2.03094780e-02f, 7.76093081e-02f, 7.98400771e-03f, 6.04050830e-02f, -4.94834483e-02f, 3.06215063e-02f, 8.46283138e-03f, 5.86567037e-02f, -5.85358776e-02f,
  1.26470104e-01f, -1.97482921e-04f, 9.86348316e-02f, -9.00674313e-02f, 2.99969763e-02f, 4.16573323e-02f, -1.19250864e-02f, -5.67177264e-03f, -2.05980707e-02f, -4.51156981e-02f,
  2.68905520e-01f, -2.40763232e-01f, 1.61728159e-01f, 1.56218737e-01f, 7.31509849e-02f, -3.36392559e-02f, -3.35084908e-02f, -5.61561100e-02f, 2.04645038e-01f, -3.93196642e-01f,
  -8.26767460e-02f, -2.13664677e-03f, -1.39649585e-01f, -6.66724071e-02f, 2.58284867e-01f, 2.58992687e-02f, -6.39699697e-02f, -7.39179328e-02f, 1.13935724e-01f, -1.49141237e-01f,
  1.05121508e-01f, -1.73001900e-01f, 9.83090699e-02f, -4.87682931e-02f, -2.76992470e-02f, 2.56982148e-02f, -1.73372045e-01f, -1.91445909e-02f, -1.20362654e-01f, 7.31369779e-02f,
  -1.25866368e-01f, -1.29472725e-02f, 4.08622921e-02f, 7.56348819e-02f, -1.62885729e-02f, -2.27507968e-02f, -3.16419415e-02f, 5.24719507e-02f, 1.00799836e-01f, -7.67959515e-03f,
  -5.26606105e-02f, 4.23653796e-02f, 6.34900555e-02f, 6.71227872e-02f, -2.30814535e-02f, 3.77767645e-02f, 2.66735237e-02f, 6.66994452e-02f, 4.53215465e-02f, 7.30708018e-02f,
  2.42042542e-02f, 2.85057332e-02f, 2.29251422e-02f, -2.35708803e-02f, 7.04055950e-02f, 7.51957297e-03f, 3.18146124e-02f, 2.07904577e-02f, -6.04313333e-03f, 2.64076609e-02f,
  -8.65686312e-03f, -1.67671929e-03f, -3.48837744e-03f, 2.53060888e-02f, -1.20397303e-02f, 3.56192999e-02f, -4.07812744e-02f, -3.39808688e-02f, 3.61790769e-02f, -6.27686009e-02f,
  3.13561037e-02f, 1.42959785e-02f, 2.66295802e-02f, -1.12642040e-02f, -1.90974064e-02f, 7.38094328e-03f, 3.55637856e-02f, -3.28351855e-02f, 3.51508544e-03f, 7.20461160e-02f,
  -4.51351888e-03f, -4.04287688e-02f, -2.67156512e-02f, -4.42899428e-02f, 2.59788018e-02f, 6.22567441e-03f, -7.84949958e-02f, -2.06727497e-02f, -2.83594429e-03f, 1.77970417e-02f,
  -4.26208943e-01f, -4.31700259e-01f, -5.06808423e-02f, -6.51161000e-02f, -3.56123894e-02f, -3.86834219e-02f, -4.39844020e-02f, -3.02955750e-02f, -1.20966576e-01f, 8.51379894e-03f,
  -2.96459720e-02f, -2.09711380e-02f, -4.28481698e-02f, 2.38439310e-02f, -1.59224086e-02f, -3.20228972e-02f, -6.98069334e-02f, -1.09139152e-01f, -1.16104327e-01f, -1.05881065e-01f,
  -3.43531780e-02f, -6.63185269e-02f, 1.34117585e-02f, 3.16261984e-02f, -4.72901240e-02f, -1.71621274e-02f, -5.00962920e-02f, 5.03538102e-02f, -7.60959685e-02f, -5.18074818e-02f,
  -2.36521572e-01f, -1.02408960e-01f, 1.50815055e-01f, -1.25300527e-01f, -1.33688882e-01f, 6.70648217e-02f, -8.63981768e-02f, -1.90731376e-01f, -3.58066142e-01f, -1.56062230e-01f,
  -1.61107183e-01f, 2.51739860e-01f, -4.55388539e-02f, -1.19749337e-01f, 2.95353681e-02f, -5.05405441e-02f, -2.50576705e-01f, -1.69021394e-02f, -1.28988490e-01f, -1.40381932e-01f,
  -2.24926807e-02f, -2.97840178e-01f, 2.51809061e-01f, -8.84987488e-02f, -6.20854609e-02f, 4.34307083e-02f, 1.23918839e-02f, 1.25255689e-01f, 1.76184043e-01f, 4.70490977e-02f,
  -4.84895371e-02f, -1.38549119e-01f, 8.15225840e-02f, -3.58146545e-03f, -4.23017219e-02f, 4.38676104e-02f, 8.02901089e-02f, 1.28782421e-01f, 1.36902099e-02f, 2.04799883e-02f,
  1.65723655e-02f, 7.61654368e-03f, 1.17974328e-02f, -3.54799703e-02f, -3.01689040e-02f, 6.28033802e-02f, 8.73611495e-02f, -3.70263942e-02f, 6.03264533e-02f, 6.17436431e-02f,
  5.36659062e-02f, 6.15948811e-02f, 4.58218008e-02f, 1.24702568e-03f, 5.53615838e-02f, 5.81919122e-03f, 7.19843581e-02f, 7.22821131e-02f, 4.34769131e-02f, -4.42266278e-02f,
  5.00936583e-02f, -3.45095359e-02f, 1.52202966e-02f, -8.81379878e-04f, -3.94154489e-02f, 5.43921925e-02f, -2.37737335e-02f, 3.48864570e-02f, 3.73339690e-02f, -6.15320839e-02f,
  -1.62608996e-02f, 5.78265281e-05f, -3.86400297e-02f, -1.43903028e-02f, -4.05406170e-02f, -2.77410001e-02f, 2.90318634e-02f, -3.86760826e-03f, -3.82129923e-02f, 2.32062172e-02f,
  -1.29411705e-02f, -2.21289508e-02f, -2.21165549e-02f, 4.45090309e-02f, -1.15630664e-02f, -1.77867226e-02f, -2.50596069e-02f, 1.97881646e-02f, 2.81244777e-02f, -1.66804101e-02f,
  -3.02072734e-01f, -3.61367762e-01f, 2.01694760e-02f, -1.19193438e-02f, -7.62066850e-03f, 4.08450291e-02f, -9.14627500e-03f, -5.12045138e-02f, -3.32889892e-02f, -3.48754041e-02f,
  -2.95523163e-02f, -3.66993845e-02f, -1.80697106e-02f, 8.10457952e-03f, 3.49380374e-02f, -5.21663986e-02f, 3.23045533e-04f, -1.28270201e-02f, -7.54281580e-02f, -1.13245919e-02f,
  3.57400477e-02f, -2.90676747e-02f, 6.74273968e-02f, -4.61861007e-02f, 2.48030238e-02f, 1.55189745e-02f, 2.77105765e-03f, 5.04488721e-02f, 5.10103591e-02f, -2.58629713e-02f,
  1.91269875e-01f, -1.54448956e-01f, -7.79495090e-02f, 1.63059071e-01f, 4.53003943e-02f, 1.97972953e-01f, 2.10217834e-01f, -7.93351084e-02f, -1.96567222e-01f, 3.95208858e-02f,
  2.19628021e-01f, -2.09656999e-01f, 5.39429449e-02f, 3.10121298e-01f, 3.58573437e-01f, 1.52271315e-01f, 2.84454644e-01f, 6.35146722e-02f, -1.60003468e-01f, -3.30036762e-03f,
  7.25628734e-02f, 3.61021757e-01f, 2.12260380e-01f, 1.92579981e-02f, 9.24143195e-02f, -1.68180838e-01f, 5.95224723e-02f, -4.21687029e-02f, 9.18386281e-02f, 7.84902498e-02f,
  6.63600788e-02f, -5.08822985e-02f, 9.99442302e-03f, -7.80885816e-02f, 4.30623777e-02f, 2.87720095e-02f, 2.48662066e-02f, 6.21463433e-02f, -6.46232292e-02f, -6.05268814e-02f,
  -3.48058380e-02f, 3.17717455e-02f, -2.14699004e-03f, 9.21819173e-03f, -5.15092984e-02f, -5.89412153e-02f, -2.37536579e-02f, -5.41011728e-02f, -6.60285503e-02f, 3.19551341e-02f,
  1.13248760e-02f, 1.58844162e-02f, 9.17460769e-03f, 6.20403886e-03f, -4.13732976e-03f, 3.81236593e-03f, 1.22350156e-02f, 7.11515592e-03f, -2.72305030e-02f, -7.85742793e-03f,
  6.27104491e-02f, 2.78361812e-02f, 3.37616801e-02f, 2.92257573e-02f, 3.14041004e-02f, 3.95378424e-03f, 3.14567462e-02f, 3.59678604e-02f, -2.36002840e-02f, 6.65396750e-02f,
  2.79865656e-02f, 3.50096375e-02f, 1.49314404e-02f, 2.81672645e-02f, 4.35322486e-02f, 2.24277414e-02f, 4.61115986e-02f, -7.78561272e-03f, -2.71577686e-02f, -6.02762913e-03f,
  -1.37056811e-02f, 6.95032626e-02f, -5.01917489e-02f, 7.68921822e-02f, -6.17261417e-03f, -2.29129512e-02f, -5.84392585e-02f, 1.08053079e-02f, -6.69596437e-03f, 7.71721601e-02f,
  2.56006550e-02f, 1.54199032e-03f, -1.08011030e-01f, -2.04179734e-02f, -1.59790348e-02f, 1.23954390e-03f, 2.01573074e-02f, -2.30504349e-02f, 2.30076201e-02f, 2.75491942e-02f,
  3.81071270e-02f, -2.93243509e-02f, 2.12443250e-04f, -3.90523486e-03f, 1.75131317e-02f, 2.37519480e-02f, 1.02253817e-02f, 3.03571802e-02f, 6.45690337e-02f, -2.37209145e-02f,
  2.41528433e-02f, 2.42754933e-03f, -1.49030965e-02f, -4.04215604e-03f, 1.05601922e-02f, 2.08547320e-02f, -4.43836860e-02f, -2.49982923e-02f, 3.29779088e-02f, -4.75159921e-02f,
  -2.14902163e-01f, -1.02218330e-01f, 3.83593410e-01f, -9.71483719e-03f, -4.71147709e-02f, 5.92841730e-02f, 1.46585226e-01f, -5.14813475e-02f, -1.42138705e-01f, -1.39819711e-01f,
  4.73694727e-02f, -4.49727029e-02f, 1.87022418e-01f, -1.16914220e-01f, -1.65614799e-01f, 3.39474007e-02f, -1.67442620e-01f, -9.85547230e-02f, 5.06050214e-02f, -9.74700302e-02f,
  1.85673758e-02f, -2.43613690e-01f, 1.71892419e-01f, 4.82835481e-03f, 2.72391178e-02f, 1.95501260e-02f, -4.94792387e-02f, 2.75232017e-01f, -1.19034806e-02f, -5.74475750e-02f,
  9.32943448e-02f, -3.27911824e-02f, 9.53883827e-02f, 4.31156158e-02f, 2.47683860e-02f, -2.49309000e-02f, 1.33025711e-02f, 6.18424006e-02f, 5.26287109e-02f, -4.84998487e-02f,
  5.86279966e-02f, -2.18983050e-02f, -3.31816971e-02f, -3.19258459e-02f, 2.70361248e-02f, -2.11898461e-02f, 4.29553017e-02f, 6.17402315e-04f, 6.28033131e-02f, 2.80874502e-02f,
  8.58363807e-02f, -3.47505547e-02f, -2.08497997e-02f, -1.09916367e-01f, -3.27411364e-03f, 1.22420201e-02f, 1.06461719e-02f, -2.34609600e-02f, -2.95247491e-02f, -3.00422702e-02f,
  -7.22705349e-02f, -6.59416383e-03f, -8.57440289e-03f, 8.10799077e-02f, -5.09754866e-02f, 8.28542653e-03f, -1.67679116e-02f, -1.48552191e-03f, 6.50435388e-02f, 8.30158032e-03f,
  3.58483940e-02f, 4.15421762e-02f, 5.20910362e-06f, 5.59547804e-02f, -1.90321833e-03f, 1.94441359e-02f, 1.01055928e-01f, 1.22209545e-02f, -1.22714639e-02f, -1.94321503e-03f,
  2.04541776e-02f, -5.10893725e-02f, 3.70473266e-02f, 2.66819429e-02f, -3.04409978e-03f, 7.17392117e-02f, -4.09444459e-02f, 5.08259609e-03f, 6.83917776e-02f, -3.48158814e-02f,
  -1.05449975e-01f, -2.28637069e-01f, 3.07463706e-02f, 2.39061508e-02f, -1.18655954e-02f, -4.67749499e-03f, -3.95001471e-03f, -5.71811944e-02f, -4.06797528e-02f, -4.64750379e-02f,
  -5.73295131e-02f, 1.23986164e-02f, -7.38924146e-02f, 5.47911040e-02f, -4.32442203e-02f, -1.89284189e-03f, -2.19792649e-02f, -2.30787005e-02f, -3.94271016e-02f, -3.87747958e-02f,
  -3.99804078e-02f, 1.20985182e-02f, -4.07437086e-02f, 5.44709340e-02f, -3.11617516e-02f, -1.64406355e-02f, -4.34416980e-02f, -8.80973693e-03f, 3.46498452e-02f, -6.17832951e-02f,
  -2.71476895e-01f, 3.89640212e-01f, -1.05807729e-01f, -1.65560350e-01f, -2.12726638e-01f, -1.31990105e-01f, -1.45110548e-01f, 1.46242110e-02f, -1.62241995e-01f, 4.49457318e-01f,
  1.14908114e-01f, 6.03032671e-02f, 1.48265749e-01f, 1.36727259e-01f, -4.57901567e-01f, 1.62031412e-01f, 5.10754585e-02f, 1.03848808e-01f, -1.17166284e-02f, -1.76512767e-02f,
  -1.64846495e-01f, 1.09000169e-01f, -5.33820204e-02f, 1.68344274e-01f, 9.07277782e-03f, -2.55022105e-02f, 2.37065498e-02f, -4.73553985e-02f, 1.35359749e-01f, -6.22012168e-02f,
  -6.78844079e-02f, 1.25696331e-01f, -3.12649161e-02f, -2.76494841e-03f, 1.01233460e-02f, 4.69810050e-03f, 3.21446694e-02f, -8.12793076e-02f, -7.43689090e-02f, -2.00294163e-02f,
  7.37314671e-02f, 2.08982415e-02f, 8.62120166e-02f, -3.14069055e-02f, -1.12702221e-01f, -5.02957702e-02f, 2.48638038e-02f, -3.43329683e-02f, 2.25047246e-02f, -1.49597917e-02f,
  -2.95299403e-02f, 2.90715657e-02f, -7.94645026e-02f, 5.80016896e-02f, -6.67784885e-02f, -3.55737237e-03f, -1.91389825e-02f, 1.63508616e-02f, 3.87064554e-02f, -1.52144460e-02f,
  -2.35524890e-03f, -5.47168329e-02f, 3.13996300e-02f, -2.13712156e-02f, -2.64368746e-02f, -2.30474696e-02f, 4.89722611e-03f, 1.36012239e-02f, -3.89258265e-02f, -4.59054904e-03f,
  -1.97901018e-02f, 1.65690649e-02f, -2.14608517e-04f, -3.31347249e-02f, 2.29837112e-02f, 2.03754324e-02f, -5.23832999e-03f, 3.93844433e-02f, 1.11831874e-02f, -2.98726410e-02f,
  -8.11674353e-03f, -7.94183612e-02f, 5.49113527e-02f, 1.38944685e-02f, 1.32914940e-02f, -3.86544503e-02f, 3.74371745e-02f, -1.97698530e-02f, -3.68502773e-02f, -7.49667883e-02f,
  8.62682313e-02f, 2.01263815e-01f, 7.89275020e-02f, 2.24287491e-02f, 8.38779062e-02f, 9.03556570e-02f, -1.91680230e-02f, 2.10264120e-02f, -3.61807644e-02f, 2.77922861e-03f,
  1.18131600e-02f, -5.02985343e-02f, -3.22274007e-02f, -2.35574711e-02f, -1.21990079e-02f, 5.75206280e-02f, -6.49101846e-03f, 1.97840240e-02f, -1.27123194e-02f, 1.96939558e-02f,
  4.23531197e-02f, -4.86791274e-03f, 1.36824022e-03f, 1.21532287e-02f, 6.90832362e-02f, 1.79346986e-02f, -4.80088033e-02f, 8.13418347e-03f, -2.07851585e-02f, 1.17572024e-02f,
  2.75230408e-01f, -1.48324866e-03f, -1.70526713e-01f, 1.69066727e-01f, 1.74592361e-01f, -5.06411940e-02f, -2.21391216e-01f, 1.27833396e-01f, 1.07139178e-01f, -3.80085893e-02f,
  -8.45345706e-02f, 5.31645268e-02f, -4.02651936e-01f, -3.21510434e-02f, -2.48244256e-02f, -2.95017630e-01f, 3.82894091e-02f, -5.35282679e-02f, 1.80458538e-02f, 1.97744936e-01f,
  1.10246189e-01f, 1.07089147e-01f, -1.73187807e-01f, 1.13392159e-01f, 8.70872512e-02f, 7.55286962e-02f, 1.54064938e-01f, -2.89040897e-02f, 7.49674365e-02f, 3.55699249e-02f,
  1.08471178e-01f, 1.32556707e-01f, -3.18484753e-02f, -1.15355486e-02f, 3.10854125e-03f, 4.34611226e-03f, 1.47374710e-02f, -1.56955242e-01f, -1.77565627e-02f, -4.22605872e-02f,
  4.77916375e-03f, -1.26273707e-02f, 4.94426712e-02f, -6.55921251e-02f, 1.65513176e-02f, 6.34651929e-02f, 2.31410004e-02f, 1.63684152e-02f, 2.33962089e-02f, 2.35340949e-02f,
  -3.25602526e-03f, -1.22162020e-02f, -2.17314996e-03f, 7.55733699e-02f, -6.90321438e-03f, 4.37651910e-02f, 3.85164917e-02f, 1.21133672e-02f, 8.39523822e-02f, 9.87182558e-02f,
  -1.17204171e-02f, -4.36013602e-02f, -3.00098527e-02f, -2.77823303e-02f, -9.94982105e-03f, 5.00634871e-02f, -6.65326193e-02f, 3.40723805e-03f, -5.53710833e-02f, 1.64317414e-02f,
  -8.82510375e-03f, 2.48324201e-02f, 1.77934784e-02f, -1.19910538e-02f, -2.39026006e-02f, 4.94226180e-02f, -2.68526115e-02f, 1.12653129e-01f, -3.41240643e-03f, 4.86622155e-02f,
  1.49151655e-02f, 1.81224681e-02f, -1.64936297e-02f, -2.40727924e-02f, -5.31563759e-02f, -3.36413912e-04f, -1.22218868e-02f, 1.30125303e-02f, -2.69223657e-02f, -2.54417937e-02f,
  1.75599843e-01f, 3.35193127e-01f, 1.31752314e-02f, 4.81510675e-03f, 9.73209157e-04f, 1.41860526e-02f, -4.72364798e-02f, 7.33345896e-02f, 7.26160482e-02f, 1.41107012e-02f,
  1.54592423e-02f, 3.84002179e-02f, 6.86438754e-02f, -4.49226238e-03f, -4.40361630e-03f, 2.01526843e-03f, 1.79620776e-02f, 2.64642667e-02f, 4.46394794e-02f, 5.43936901e-02f,
  -6.66591898e-02f, 1.87403560e-02f, 6.62733568e-03f, 2.38198843e-02f, 7.93024525e-02f, 2.31283344e-02f, 1.34571478e-01f, 1.16879540e-02f, 4.66878004e-02f, 1.68418624e-02f,
  2.24549323e-02f, 1.18030142e-02f, 3.69296670e-02f, 1.88041344e-01f, -9.84966531e-02f, 2.40709022e-01f, 4.93611604e-01f, -8.36693272e-02f, -1.29840121e-01f, 1.75913602e-01f,
  1.20140590e-01f, 1.54127941e-01f, 7.90925920e-02f, 2.57735252e-01f, 2.21514791e-01f, 1.08233310e-01f, 3.06945443e-01f, 2.33023643e-01f, -1.17505789e-01f, 4.87833470e-02f,
  1.28890742e-02f, 1.53191715e-01f, 1.11770950e-01f, -1.84122443e-01f, 1.48229562e-02f, -1.06554911e-01f, -4.75104786e-02f, -1.52587697e-01f, 7.31311664e-02f, 4.04249132e-02f,
  1.71140119e-01f, -5.21097444e-02f, -4.29696031e-02f, 1.02881659e-02f, 1.92466546e-02f, 2.29236316e-02f, 4.57104333e-02f, -9.07604303e-03f, -2.15065572e-02f, -4.62027453e-02f,
  6.41533807e-02f, -4.73475792e-02f, -2.63638180e-02f, -3.37240510e-02f, -1.69115141e-02f, -7.68588483e-02f, -2.24535186e-02f, 2.79488992e-02f, -2.46107168e-02f, 4.18430008e-02f,
  -4.29395790e-04f, 6.02261163e-02f, 2.69095879e-02f, 9.91201550e-02f, 2.35751420e-02f, -2.91095264e-02f, 7.30951428e-02f, 1.30773047e-02f, 6.73321728e-03f, -3.93176526e-02f,
  -5.12412973e-02f, 9.04729031e-03f, -2.22362988e-02f, -6.47200830e-03f, -1.99745130e-02f, -2.27677003e-02f, -3.03623863e-02f, 2.35158671e-02f, -8.81207660e-02f, -1.41478973e-02f,
  -5.47368266e-02f, -2.05972940e-02f, -4.47701886e-02f, 3.22944038e-02f, -1.44732744e-02f, -9.01205931e-03f, 2.00409777e-02f, -3.72555442e-02f, -2.90289093e-02f, 1.61594972e-02f,
  1.19968345e-02f, 9.05977376e-03f, 3.45531553e-02f, 6.74578501e-03f, 3.53758521e-02f, 2.09893491e-02f, 9.74608003e-04f, -1.85525101e-02f, 1.24118396e-03f, 5.10111749e-02f,
  2.54951697e-02f, 2.79683340e-02f, 1.44635513e-02f, -7.05451798e-03f, 2.87637245e-02f, -1.29979495e-02f, 5.32178581e-02f, 3.08006327e-03f, -1.53306071e-02f, -8.36542994e-03f,
  -1.44029055e-02f, 9.94720589e-03f, -2.01990381e-02f, 1.51906721e-02f, -1.74342357e-02f, 6.74017444e-02f, 5.93994893e-02f, 7.96746276e-03f, 8.87558907e-02f, -3.68343368e-02f,
  -3.00346985e-02f, 4.04458866e-03f, -2.22500172e-02f, -7.92100877e-02f, -1.09297894e-02f, 4.54504229e-03f, 2.10752734e-03f, -9.90088098e-03f, 2.30465122e-02f, -2.14378862e-03f,
  -1.85353488e-01f, 8.54053348e-02f, -3.19712698e-01f, -3.15642267e-01f, -7.40447044e-02f, -7.43184285e-03f, -5.84201775e-02f, 3.11638732e-02f, -1.45669326e-01f, 2.54945010e-01f,
  1.57246143e-01f, -1.97006464e-01f, 1.18523113e-01f, 2.87625231e-02f, -1.36851847e-01f, 2.19254956e-01f, 6.69397339e-02f, 5.20937406e-02f, -1.35643542e-01f, -3.80496867e-02f,
  -6.46550059e-02f, 8.32760185e-02f, -9.44100991e-02f, 7.44978935e-02f, -1.23263493e-01f, -5.74857332e-02f, 4.80925739e-02f, -6.93561435e-02f, 1.46623980e-02f, -1.38291661e-02f,
  -3.88769880e-02f, -9.85332578e-02f, -4.24277550e-03f, 5.44437878e-02f, 4.30377349e-02f, -2.52884720e-02f, 3.63488384e-02f, -6.43196655e-03f, -1.31077141e-01f, -2.52264198e-02f,
  2.32793335e-02f, 1.66176874e-02f, -3.55589353e-02f, -7.50388205e-03f, -5.37158474e-02f, -1.36792269e-02f, -7.14406073e-02f, -4.73855212e-02f, -3.95497903e-02f, -4.55279136e-03f,
  -1.24886192e-01f, -1.34447245e-02f, -7.18216971e-02f, 8.45290422e-02f, -5.94681799e-02f, -3.36076953e-02f, 6.02106042e-02f, -3.10921166e-02f, -2.80430703e-03f, 1.72038469e-02f,
  1.68713834e-02f, -6.03371859e-02f, 4.52845134e-02f, 1.42637584e-02f, -1.38714621e-02f, -1.75490621e-02f, -3.14004831e-02f, 7.74393007e-02f, -1.14169568e-02f, 1.43531710e-02f,
  4.46860492e-03f, -3.72992903e-02f, -2.91834697e-02f, 2.18256079e-02f, -6.36899471e-03f, 6.15239702e-02f, 3.43918987e-02f, 8.72450764e-04f, -2.71979794e-02f, 3.50982286e-02f,
  -9.24205594e-03f, -5.05424887e-02f, 3.71649526e-02f, 4.37274724e-02f, -4.04529162e-02f, 3.66554223e-02f, 3.44639271e-02f, 1.15234335e-03f, -8.80927220e-03f, 1.54304989e-02f,
  8.43660459e-02f, 1.55076325e-01f, 5.66173047e-02f, -2.12775059e-02f, 1.07399225e-02f, 5.68057932e-02f, 2.05496699e-02f, 4.37874570e-02f, 1.89281516e-02f, 7.19164386e-02f,
  -1.99239459e-02f, -3.88532616e-02f, -3.36171389e-02f, -5.30586541e-02f, -1.10651683e-02f, 4.71771546e-02f, -1.18334778e-02f, -2.85794232e-02f, -4.04638313e-02f, 2.31572147e-03f,
  6.39702529e-02f, 6.91327825e-02f, 1.03673013e-02f, -1.56576093e-02f, 7.82136843e-02f, -3.13746445e-02f, -3.93668786e-02f, 1.65570881e-02f, 1.53802410e-02f, 1.84962805e-02f,
  -7.49843940e-02f, -1.94552615e-01f, -4.60833520e-01f, -1.85905427e-01f, 1.33868948e-01f, -1.82089776e-01f, -1.45894334e-01f, -3.21820471e-03f, -1.97941452e-01f, 7.82523528e-02f,
  1.49105743e-01f, -8.09586048e-02f, -9.19773709e-03f, -1.08971395e-01f, 3.07888556e-02f, -1.51142597e-01f, -2.23924309e-01f, -6.96788803e-02f, -1.06372394e-01f, -1.86401512e-02f,
  -1.62072793e-01f, 1.97927535e-01f, -2.47833952e-01f, 9.18041542e-02f, -5.68676814e-02f, -7.53801540e-02f, 3.64055842e-01f, 3.03973630e-02f, 2.42586359e-02f, 1.08944081e-01f,
  4.14849930e-02f, -9.19098631e-02f, -1.21401206e-01f, -6.46428540e-02f, -2.53400784e-02f, 5.03016636e-02f, 1.01038069e-02f, -3.15143615e-02f, -7.65000191e-03f, -8.69363546e-03f,
  -8.38744733e-03f, -1.76133383e-02f, -6.20692037e-02f, -3.56275812e-02f, 2.70356461e-02f, -8.04673228e-03f, -9.16692689e-02f, -8.17161053e-02f, 1.55543871e-02f, -9.85417441e-02f,
  -5.08792028e-02f, -1.17402762e-01f, -2.72774184e-03f, -3.24008763e-02f, -4.75035459e-02f, -8.42687339e-02f, -1.09605297e-01f, 3.38789336e-02f, 7.00659538e-03f, -7.36771226e-02f,
  -1.28068449e-02f, 1.43590979e-02f, 4.34691980e-02f, -1.37481196e-02f, -1.75115876e-02f, 6.82029128e-02f, -5.71696609e-02f, 1.23601921e-01f, 5.24277687e-02f, 8.19062218e-02f,
  -1.98416561e-02f, 3.60243730e-02f, 4.35777232e-02f, -2.09746994e-02f, 2.02296674e-02f, 2.23333505e-03f, -2.44469345e-02f, 5.71014211e-02f, -3.06079928e-02f, -3.84055786e-02f,
  6.46703467e-02f, 2.24302728e-02f, -1.11205187e-02f, 1.11784032e-02f, -5.25223203e-02f, 3.77361570e-03f, -3.71333621e-02f, -4.68457527e-02f, -2.74219774e-02f, 2.95211468e-02f,
  2.25505680e-01f, 4.68936749e-02f, 9.48138759e-02f, -2.76657357e-03f, 2.76070274e-02f, 6.65441081e-02f, -8.34122002e-02f, 2.75378656e-02f, 2.19163392e-02f, -8.09916016e-03f,
  1.93068795e-02f, 2.68913549e-03f, 5.32002822e-02f, 1.62447616e-02f, -8.88437685e-03f, -9.08017717e-03f, 6.25647381e-02f, 3.55309173e-02f, 1.72485020e-02f, -1.62615888e-02f,
  5.00963861e-03f, 6.99890405e-02f, -4.00167219e-02f, 6.81571066e-02f, 1.37623644e-03f, 3.05348802e-02f, 3.43716890e-02f, -5.53037114e-02f, 2.78434567e-02f, 6.29892796e-02f,
  1.41897015e-02f, 5.23365699e-02f, 2.41998993e-02f, -6.42445087e-02f, 2.37790093e-01f, 8.23187381e-02f, -9.99922529e-02f, 2.34821305e-01f, -1.45973668e-01f, -1.20470775e-02f,
  3.66398804e-02f, -8.55484530e-02f, -1.63459241e-01f, 1.31792827e-02f, -3.79199535e-01f, -3.18217814e-01f, -1.59956783e-01f, -1.36923030e-01f, -1.25611097e-01f, 3.65398563e-02f,
  -8.00012127e-02f, 1.51462974e-02f, 1.03189086e-03f, 2.94610322e-01f, 2.96231002e-01f, 1.25378609e-01f, -6.54108897e-02f, 1.08330593e-01f, 1.29780322e-01f, 3.07628233e-02f,
  8.04324970e-02f, 6.77297637e-02f, -8.15190375e-04f, 9.40509699e-03f, -2.40708096e-03f, 6.40357062e-02f, 8.62005912e-03f, 2.07032058e-02f, -3.14002647e-03f, -6.55307388e-03f,
  2.98960786e-02f, -5.47248311e-02f, -6.46773214e-03f, 6.06662072e-02f, 1.20014124e-01f, -2.06184834e-02f, 3.98175158e-02f, 7.88812041e-02f, 2.49619577e-02f, 4.55235392e-02f,
  -1.80064626e-02f, 8.29063728e-02f, -8.93613324e-02f, -7.57068470e-02f, -8.54373425e-02f, -1.80456191e-02f, -1.09485626e-01f, -4.31082584e-02f, -1.41708218e-02f, -3.80140655e-02f,
  -2.50677764e-02f, -6.68285638e-02f, -1.96151845e-02f, 6.20914027e-02f, 6.23327959e-03f, 7.21796677e-02f, -6.23558052e-02f, 3.71909849e-02f, -2.37328727e-02f, 3.45625505e-02f,
  4.01146390e-04f, 5.36154360e-02f, 6.99083367e-03f, -1.10937720e-02f, -8.37224647e-02f, 2.82219090e-02f, -5.07084727e-02f, -1.19127268e-02f, -2.77737621e-02f, 4.29194272e-02f,
  -3.18142660e-02f, 2.90444251e-02f, 3.30060795e-02f, 3.70029397e-02f, 8.05503223e-04f, 2.73787174e-02f, 2.72011161e-02f, 3.50380987e-02f, 1.30679237e-03f, 1.70063395e-02f,
  -8.14782158e-02f, -2.33107388e-01f, 7.55398199e-02f, 4.94903773e-02f, -4.43670005e-02f, -1.43670272e-02f, -4.53821793e-02f, -4.70010117e-02f, -4.82516224e-03f, -3.99544947e-02f,
  4.43008803e-02f, 3.40212099e-02f, -6.20903634e-02f, 1.03711253e-02f, -1.59256794e-02f, 1.52614107e-02f, -7.19073489e-02f, -2.60133818e-02f, 1.39182608e-03f, 2.44210362e-02f,
  3.54807861e-02f, -4.91013117e-02f, -1.60417520e-02f, 1.22032994e-02f, -2.31986213e-02f, -2.72579677e-02f, -3.14762210e-03f, -3.15543986e-03f, -3.38287763e-02f, -6.06351458e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.45951736e-02f, -1.64362639e-01f, -2.02822074e-01f, -2.02060059e-01f, -1.26156464e-01f, -2.22377688e-01f, -1.54053390e-01f, -9.84457582e-02f, -1.17211714e-02f, -1.58581480e-01f,
  -1.86426461e-01f, -2.02728845e-02f, 1.17709391e-01f, -3.15812677e-01f, 1.64715663e-01f, 2.68202275e-01f, -1.84595510e-01f, -1.67748295e-02f, 1.05652409e-02f, -2.12190956e-01f,
  -7.25504309e-02f, -1.31176084e-01f, -1.06026933e-01f, -2.73497492e-01f, -3.22020143e-01f, -1.77393347e-01f, 9.14284512e-02f, -8.75595286e-02f, -1.84432685e-01f, -1.20271057e-01f,
  -1.35984970e-02f, -6.97376132e-02f, -3.06498520e-02f, 1.82678588e-02f, -1.05586730e-01f, 2.01196615e-02f, 1.40173770e-02f, 7.52026141e-02f, -1.00031765e-02f, -8.11248794e-02f,
  2.82455459e-02f, -3.49005722e-02f, -5.74452542e-02f, 5.70004024e-02f, -8.45244452e-02f, 2.72360705e-02f, -4.96252142e-02f, -6.31943392e-03f, -6.92215115e-02f, 4.62005325e-02f,
  -1.09449133e-01f, 1.97761785e-03f, -4.42195544e-03f, 6.10557869e-02f, -3.04568131e-02f, 3.10168159e-03f, 6.45081550e-02f, 1.24555811e-01f, -6.68419451e-02f, -6.24636561e-02f,
  -5.31628095e-02f, 4.69085351e-02f, 9.66453645e-03f, -4.78092395e-02f, -5.77221178e-02f, -7.99784437e-02f, 6.17297133e-03f, -6.68444186e-02f, 9.10868719e-02f, -3.33004855e-02f,
  -1.73413791e-02f, -3.02146077e-02f, -8.26738402e-02f, 3.49248424e-02f, -6.57899678e-02f, 1.19487897e-01f, -6.35039061e-02f, -4.05104123e-02f, -6.71819299e-02f, 4.95101064e-02f,
  2.86672101e-03f, 5.60870320e-02f, -4.86251190e-02f, 5.36732143e-03f, -9.28732939e-03f, 1.10454440e-01f, -8.45724717e-02f, -4.87402789e-02f, 2.18965462e-03f, -4.30328324e-02f,
  -1.25136971e-02f, -1.35790348e-01f, 1.41561981e-02f, -4.24246788e-02f, -6.79536909e-02f, -5.51942475e-02f, 1.12735098e-02f, -1.68591551e-02f, -4.06544246e-02f, -7.08406419e-02f,
  -4.37461957e-02f, 4.97451723e-02f, 1.84307117e-02f, 3.58748883e-02f, -2.15151571e-02f, -6.99066743e-02f, -6.14800639e-02f, 4.96495031e-02f, 6.12039468e-04f, 3.33320647e-02f,
  -1.22102518e-02f, 5.16994074e-02f, 2.05037985e-02f, -4.23040874e-02f, 4.71413732e-02f, -4.26370762e-02f, 3.71388495e-02f, 4.73723151e-02f, -2.97633046e-03f, 6.32128492e-02f,
  -1.03067651e-01f, -3.25935963e-03f, -1.89799637e-01f, -4.38650921e-02f, -4.11908701e-02f, -7.85980448e-02f, -6.17867671e-02f, -1.00184537e-01f, 1.51373759e-01f, 9.06361639e-02f,
  1.36090238e-02f, -3.22168022e-02f, -8.34779069e-03f, -1.20936334e-01f, -1.11764789e-01f, -2.01724414e-02f, -2.10746508e-02f, -4.03056890e-02f, 1.18121937e-01f, -6.93052933e-02f,
  -1.06460981e-01f, -1.04730718e-01f, -1.63081452e-01f, -5.45069538e-02f, -1.83747217e-01f, 2.85688546e-02f, 9.46674570e-02f, -4.84991260e-02f, -1.24931619e-01f, -2.29706038e-02f,
  -8.45447853e-02f, -7.64595270e-02f, -5.98270595e-02f, 6.13823831e-02f, -5.05683981e-02f, -1.07788406e-02f, -9.72818304e-03f, 2.67546959e-02f, -7.10479543e-03f, -4.19187285e-02f,
  -8.97248685e-02f, 2.14761980e-02f, -3.92792895e-02f, 1.18432999e-01f, -1.18516311e-02f, 8.15151483e-02f, 2.99196169e-02f, -1.04374420e-02f, 4.98300791e-02f, -1.40561044e-01f,
  1.20110083e-02f, -3.71735133e-02f, -8.80021900e-02f, 2.91708321e-03f, 3.73492613e-02f, 7.88762718e-02f, -7.79868811e-02f, 4.54436950e-02f, -3.88399772e-02f, -2.30668075e-02f,
  -6.66424632e-02f, -1.60083920e-02f, -4.11945619e-02f, 9.74475034e-03f, 8.73439945e-03f, -3.18773761e-02f, 4.99944054e-02f, -2.62982138e-02f, 2.73544211e-02f, -7.29082599e-02f,
  -8.52247700e-02f, 8.21530074e-02f, -8.09449796e-03f, 6.33093119e-02f, -8.09869319e-02f, -8.02710578e-02f, -4.96949740e-02f, 6.63840622e-02f, 8.28381553e-02f, 5.46733290e-02f,
  2.02102065e-02f, -3.89540158e-02f, -3.71509120e-02f, -7.82654583e-02f, 1.58599224e-02f, -8.08290541e-02f, 9.25482661e-02f, -7.38162622e-02f, 9.11291912e-02f, -3.37722749e-02f,
  2.87192222e-02f, -6.33342937e-03f, 9.80876535e-02f, -1.81969330e-02f, -5.07054888e-02f, -6.80158734e-02f, 7.57728219e-02f, 1.31663792e-02f, 4.67536114e-02f, 3.94450501e-02f,
  -8.64885300e-02f, 3.50179896e-02f, 7.55796256e-03f, 1.00769207e-01f, -4.97326702e-02f, 6.86060265e-02f, 1.62395611e-02f, -5.25690503e-02f, -4.35322374e-02f, 3.62490527e-02f,
  -2.64001861e-02f, -5.43587357e-02f, -2.71607284e-02f, -4.45198603e-02f, -7.66441971e-03f, 3.53212492e-03f, -1.27599323e-02f, -7.80165642e-02f, -3.44926491e-02f, -4.57531959e-02f,
  -4.27674279e-02f, 5.60322171e-03f, -3.16671103e-01f, -2.01270536e-01f, -7.03094825e-02f, -5.21534383e-01f, -3.64634961e-01f, -1.62458465e-01f, 6.58506434e-03f, 1.70014039e-01f,
  1.03953011e-01f, 2.43967976e-02f, 2.13444576e-01f, -2.80716062e-01f, -3.22381139e-01f, 1.32362330e-02f, -4.05219972e-01f, -1.42233029e-01f, -5.75286709e-02f, -1.14479885e-01f,
  -1.32083803e-01f, -6.20725490e-02f, -1.84600592e-01f, 1.60643265e-01f, -1.38594642e-01f, 8.28526262e-03f, 1.00233927e-01f, 1.05975255e-01f, -1.58039972e-01f, -3.31592560e-02f,
  -1.08857848e-01f, 9.10286754e-02f, -2.77625937e-02f, 2.74860747e-02f, -1.39231458e-01f, 8.29676981e-04f, -4.15715910e-02f, -3.24895717e-02f, -5.33039011e-02f, 1.12945016e-03f,
  2.49850024e-02f, 4.94501069e-02f, -4.92407158e-02f, 3.19453627e-02f, -4.51027881e-03f, -6.05449900e-02f, 1.49887027e-02f, -1.74685929e-03f, -7.71773085e-02f, -1.03079595e-01f,
  -2.85312012e-02f, -3.68746445e-02f, -8.54490399e-02f, -3.80137227e-02f, -8.72013643e-02f, 5.04276939e-02f, -8.85843113e-02f, -9.66805667e-02f, -3.63792069e-02f, -4.92779389e-02f,
  -4.50113835e-03f, 4.68024723e-02f, -4.93573397e-02f, 5.98359406e-02f, 3.45335491e-02f, -3.49326655e-02f, -1.18696541e-02f, -4.49980469e-03f, -9.32262093e-03f, -1.31053794e-02f,
  -8.45044628e-02f, -5.79149579e-04f, 1.05384879e-01f, -8.64905119e-02f, -1.75468121e-02f, -2.52461545e-02f, 3.26249115e-02f, 5.13759535e-03f, -1.29183620e-01f, -2.81517021e-02f,
  2.10186536e-03f, 4.71824184e-02f, -1.48032755e-02f, 3.99968363e-02f, 1.86259206e-02f, -6.13482995e-03f, -7.97337480e-03f, -3.15677896e-02f, 5.93809709e-02f, 1.95063390e-02f,
  -9.52025503e-02f, -1.02857061e-01f, -4.33128066e-02f, 5.59819397e-03f, 5.20775206e-02f, -7.65601033e-03f, -4.15640250e-02f, -2.60778945e-02f, -1.09128796e-01f, -3.46623249e-02f,
  -2.86425054e-02f, 4.13003862e-02f, -3.38472798e-02f, 6.98088408e-02f, 2.07279380e-02f, -8.37737694e-02f, -5.24835661e-02f, 2.11241525e-02f, -1.67018734e-02f, 2.33256514e-03f,
  8.47446639e-03f, -4.69213612e-02f, 2.21239636e-03f, 1.11180125e-02f, 5.02404338e-03f, 2.41377912e-02f, 3.90921943e-02f, 9.20831114e-02f, 1.93202787e-03f, -7.24516660e-02f,
  -2.67115515e-02f, -2.60749906e-01f, -3.39373142e-01f, -9.76081565e-02f, 1.47765547e-01f, 1.76334769e-01f, -1.37501061e-01f, -1.25774726e-01f, -3.79324377e-01f, -2.01106295e-02f,
  7.70055801e-02f, 1.50152398e-02f, -3.93312275e-01f, 1.24832481e-01f, 2.15316210e-02f, -3.18451762e-01f, 1.14137426e-01f, 1.14214770e-01f, -1.06680237e-01f, -7.09577277e-02f,
  -2.70077642e-02f, 3.00918669e-01f, -1.42811969e-01f, 1.43920124e-01f, 1.87404290e-01f, 9.06824917e-02f, 1.83131516e-01f, -1.22387618e-01f, 2.86850929e-01f, 1.91401318e-01f,
  -1.74659267e-02f, -1.71492830e-01f, -8.53562206e-02f, -5.83988382e-03f, 2.70965416e-02f, 1.10714592e-01f, 4.17544730e-02f, 1.27614141e-01f, -2.44765338e-02f, -4.86400537e-02f,
  4.02971776e-03f, 7.36917183e-02f, 1.37591928e-01f, -4.28785123e-02f, 4.15742882e-02f, -4.84704785e-02f, 3.02776953e-05f, 5.45229204e-02f, -6.37203008e-02f, -4.08418328e-02f,
  -1.44804195e-01f, 1.78862866e-02f, -3.87293883e-02f, 1.80987194e-02f, -8.12882930e-03f, 9.67832468e-03f, 2.72652076e-04f, -3.26604955e-02f, 6.09530210e-02f, 3.26034613e-02f,
  4.15945612e-02f, 5.38962036e-02f, -3.55441459e-02f, 1.04318917e-01f, -3.35016213e-02f, -1.46137634e-02f, 8.98244083e-02f, -4.36996445e-02f, 1.47828646e-02f, 3.77217047e-02f,
  3.55359763e-02f, 1.64785031e-02f, -1.48332361e-02f, 2.65842453e-02f, 4.50115316e-02f, 6.57837391e-02f, 1.42699443e-02f, 1.81543175e-02f, -1.53256878e-02f, 2.38569174e-02f,
  -6.23081103e-02f, -2.22531911e-02f, -7.28723779e-02f, -5.10114692e-02f, 5.24276197e-02f, -3.48030217e-02f, -2.80675199e-02f, 3.77845764e-02f, -1.89138781e-02f, 9.22703072e-02f,
  2.31989995e-02f, -5.56501634e-02f, -5.76260462e-02f, 8.66890885e-03f, -1.06128529e-02f, 1.37929663e-01f, 4.24790643e-02f, 2.67404523e-02f, -9.26339254e-02f, -5.38673662e-02f,
  5.92282712e-02f, -3.52888480e-02f, 1.39832839e-01f, 7.83969685e-02f, 7.63827786e-02f, 4.88903560e-02f, 2.02436093e-02f, 6.85001165e-02f, 4.92184497e-02f, 9.93934870e-02f,
  -4.12992947e-02f, -3.75987440e-02f, 8.41455460e-02f, 1.61848105e-02f, 7.85971135e-02f, -8.11024681e-02f, -1.23348497e-02f, 6.41474361e-03f, 8.30878541e-02f, -3.21701840e-02f,
  -2.78789140e-02f, 7.06071109e-02f, 3.37508619e-02f, -2.60164998e-02f, -1.43883117e-02f, -3.05162191e-01f, -2.53134578e-01f, -1.40549950e-02f, 7.72711113e-02f, 4.03427817e-02f,
  -7.72415800e-03f, 7.03588186e-04f, 1.76868170e-01f, -7.08682090e-02f, 1.13016956e-01f, 5.42465709e-02f, -1.86294824e-01f, -1.16815314e-01f, 6.38366938e-02f, 1.17468007e-01f,
  1.13786660e-01f, 7.91958869e-02f, 1.93187207e-01f, -5.78532927e-03f, -9.78228301e-02f, 5.62394634e-02f, 2.28998050e-01f, 5.62945120e-02f, -1.51446853e-02f, 5.32309264e-02f,
  -1.46931931e-01f, 5.81714883e-02f, -1.26599278e-02f, -6.04549535e-02f, -4.15351838e-02f, -1.06879152e-01f, 9.43700317e-03f, -3.99473421e-02f, -5.61380154e-03f, -5.89378588e-02f,
  8.68455693e-02f, 4.00155447e-02f, 2.85128970e-02f, 8.67594704e-02f, 1.52700441e-02f, 5.43596633e-02f, 7.40459412e-02f, -4.72531766e-02f, 4.48963270e-02f, -7.47968862e-03f,
  -4.74036224e-02f, 4.01946902e-02f, -6.94096554e-03f, 4.28840965e-02f, 6.68656379e-02f, -2.04546507e-02f, 2.02783830e-02f, 1.03657499e-01f, -1.37020396e-02f, -3.23306099e-02f,
  -8.91120136e-02f, 7.51232356e-02f, 9.25533380e-03f, 8.28914791e-02f, -3.42396870e-02f, 7.73688704e-02f, -5.25313243e-02f, -3.90503071e-02f, -6.39562830e-02f, -3.95889729e-02f,
  1.61209106e-02f, 7.59636611e-02f, 8.69899020e-02f, -9.61629003e-02f, -1.05220467e-01f, 9.25345197e-02f, -2.98140626e-02f, -1.19119138e-03f, 3.20056379e-02f, -4.95970361e-02f,
  -6.25681803e-02f, 5.67678884e-02f, -1.48769270e-03f, 7.56167225e-04f, 2.05369238e-02f, 5.56657091e-02f, -1.20017407e-02f, -5.01590269e-03f, 2.13994831e-02f, 2.73128357e-02f,
  -5.36516979e-02f, 1.77391991e-01f, 5.34163527e-02f, -4.96581532e-02f, 5.78437895e-02f, -9.71507654e-02f, 3.75839393e-03f, 1.66815203e-02f, 3.12731154e-02f, 4.54328805e-02f,
  -9.38375071e-02f, -4.87369411e-02f, 2.50358861e-02f, -2.32795533e-02f, 7.51793608e-02f, 2.43008938e-02f, 1.38762603e-02f, 4.32730466e-02f, 4.49732020e-02f, 1.20349064e-01f,
  6.50891438e-02f, 5.68628870e-02f, 4.06125747e-02f, 7.23746121e-02f, -6.81547299e-02f, -1.07593037e-01f, -7.20892921e-02f, -3.16336416e-02f, -4.07448225e-02f, 3.09413057e-02f,
  -1.55205294e-01f, -1.67325988e-01f, 2.28570387e-01f, -2.43800774e-01f, 2.20013693e-01f, 1.70826197e-01f, 1.26439750e-01f, 5.00876941e-02f, -1.00892432e-01f, -1.51083276e-01f,
  1.26545921e-01f, -1.35335729e-01f, 1.37294620e-01f, 5.10680452e-02f, 1.19871069e-02f, 3.49782445e-02f, -4.72019427e-02f, -6.60590306e-02f, 8.57712352e-04f, -1.37721017e-01f,
  -1.37167349e-01f, 1.00672953e-01f, 1.33686900e-01f, 2.42508519e-02f, 9.88498628e-02f, -1.52750522e-01f, -6.78036064e-02f, 2.41596654e-01f, -3.97427268e-02f, 7.50325918e-02f,
  -8.58615562e-02f, -2.87779812e-02f, 5.12180384e-03f, 9.13216099e-02f, -6.43634424e-02f, -1.03421889e-01f, -6.83238134e-02f, 5.01157250e-03f, -2.30588159e-03f, -1.10927289e-02f,
  3.76218222e-02f, 8.29174146e-02f, -7.57749751e-02f, 2.85780448e-02f, -8.80279467e-02f, -6.01293594e-02f, -3.29151042e-02f, 2.86398754e-02f, 8.95683691e-02f, -5.14768064e-02f,
  4.50933129e-02f, -2.10441630e-02f, 5.21331374e-03f, 1.52315199e-02f, 7.37761706e-02f, 5.33754192e-02f, -5.71381822e-02f, 7.46016279e-02f, 2.99618356e-02f, -4.89313789e-02f,
  -8.16775020e-03f, -4.05187756e-02f, -8.10707919e-03f, -1.78503320e-02f, 6.24757111e-02f, -3.42742726e-02f, 5.32022640e-02f, -6.02688938e-02f, -5.41820191e-02f, 4.44183387e-02f,
  -4.59907502e-02f, -9.16398019e-02f, -1.69949215e-02f, -8.17140639e-02f, 5.42345308e-02f, 2.15438381e-02f, 1.83848068e-02f, 2.25937571e-02f, 2.34458521e-02f, 3.05788983e-02f,
  4.61750738e-02f, 4.13834564e-02f, 1.96920875e-02f, 1.40931848e-02f, -4.46121283e-02f, -2.71956064e-02f, 5.96842170e-02f, -5.06694335e-03f, 2.59580407e-02f, 6.17277920e-02f,
  -2.44673833e-01f, -2.92444259e-01f, -8.70805606e-02f, -7.33039230e-02f, -4.17102650e-02f, -3.02925967e-02f, -4.28486466e-02f, -7.57437572e-03f, -7.87780881e-02f, 2.40206160e-03f,
  -5.52012697e-02f, -3.27877849e-02f, -5.81005737e-02f, -5.43720238e-02f, -2.37146132e-02f, -1.93090532e-02f, -1.10712521e-01f, -4.11224104e-02f, -8.26987028e-02f, 2.82538850e-02f,
  -4.12166901e-02f, 3.16898301e-02f, 1.15935147e-01f, -1.39581468e-02f, -7.60854110e-02f, -9.60105136e-02f, 2.27791816e-02f, 2.77249478e-02f, -5.12263924e-03f, -3.15262377e-02f,
  9.54014659e-02f, 1.37102887e-01f, 8.25736225e-02f, 9.30193216e-02f, -2.09322482e-01f, 1.04269847e-01f, 1.97580159e-01f, -1.03759095e-01f, 1.43614203e-01f, 6.72683539e-03f,
  -1.06719583e-01f, 2.55143702e-01f, 1.44356161e-01f, -1.02289021e-01f, 7.79662952e-02f, 1.54569060e-01f, -4.13763225e-02f, 1.58758044e-01f, -1.03537768e-01f, -8.78013298e-02f,
  -9.08179879e-02f, -1.50661439e-01f, -5.11107184e-02f, -2.27251589e-01f, -2.06475541e-01f, -2.07751580e-02f, -9.27590877e-02f, -4.17470522e-02f, -6.56058453e-03f, 1.83556636e-03f,
  -1.31149337e-01f, -1.29019588e-01f, -2.62632668e-02f, -6.22080341e-02f, -2.67589046e-03f, 9.96935181e-03f, 9.26127806e-02f, 8.58849194e-03f, 3.03785373e-02f, -4.79706941e-04f,
  3.84411775e-02f, -9.42386240e-02f, -6.43086061e-02f, 9.37927961e-02f, -1.45250158e-02f, -8.01575258e-02f, -4.71530557e-02f, -8.00382346e-02f, 7.55566731e-02f, -5.63917160e-02f,
  -4.50469144e-02f, 4.38971585e-03f, -2.37845331e-02f, 2.88058612e-02f, 3.56199816e-02f, -4.05327454e-02f, -1.64006781e-02f, 4.49950621e-02f, -2.74864025e-03f, -4.92151417e-02f,
  5.99838160e-02f, -2.98416652e-02f, -4.37283218e-02f, -6.23561144e-02f, 2.01470684e-03f, -1.87359136e-02f, -2.61926260e-02f, 6.38677552e-02f, 4.32234257e-02f, 1.68948099e-02f,
  -2.83480305e-02f, -2.61828229e-02f, -5.08585311e-02f, -4.16371152e-02f, 6.65775090e-02f, 1.07432254e-01f, 8.43550861e-02f, -1.11526819e-02f, -3.47412266e-02f, 2.02654507e-02f,
  -3.60595174e-02f, 1.61951985e-02f, -2.78036427e-02f, -1.73828304e-02f, 5.82850017e-02f, -2.25272886e-02f, -6.27797171e-02f, -8.58366024e-03f, 4.18058410e-02f, 8.38218480e-02f,
  5.90554588e-02f, 1.50382087e-01f, -7.33870491e-02f, -9.20558199e-02f, 3.55966426e-02f, -5.75170182e-02f, 6.89521506e-02f, -9.23198741e-03f, 6.66861981e-02f, 1.48956785e-02f,
  3.40034580e-03f, 4.81919385e-02f, 7.28295147e-02f, -3.17127779e-02f, -9.47584677e-03f, 5.48755797e-03f, 1.74526684e-02f, 5.21275029e-02f, -2.75016688e-02f, -6.07893765e-02f,
  -1.25671066e-02f, 1.73236355e-02f, -2.46496014e-02f, -2.89196204e-02f, 4.88863420e-03f, -8.21321607e-02f, 2.20177919e-02f, 2.46932171e-02f, -6.83156475e-02f, -4.63434719e-02f,
  1.27260238e-02f, 4.07915115e-01f, 8.60329494e-02f, 1.92531906e-02f, -1.77030608e-01f, -1.38705550e-02f, -7.16214702e-02f, 5.16396351e-02f, 2.27673382e-01f, 1.55600458e-01f,
  -1.24020807e-01f, 3.57077420e-01f, -8.03853199e-03f, 1.16968572e-01f, -2.21551061e-01f, -1.51245549e-01f, -8.82266834e-02f, 8.17277208e-02f, 4.77286763e-02f, 5.04554845e-02f,
  -1.07185453e-01f, 5.52843092e-03f, -4.37410213e-02f, -1.03753917e-02f, -6.69252127e-02f, -8.80719628e-03f, -6.91158772e-02f, 9.57520753e-02f, 1.53309135e-02f, -6.39807954e-02f,
  -7.44167864e-02f, 1.66752920e-01f, -2.29447801e-02f, 2.59439112e-03f, -8.95798504e-02f, -4.74885926e-02f, -5.19699492e-02f, 3.30052376e-02f, 2.27192305e-02f, 1.02425545e-01f,
  -2.17792913e-02f, 2.73574665e-02f, 1.30899921e-01f, 7.47308433e-02f, 1.05889134e-01f, 4.03225608e-02f, -4.30703908e-02f, -1.42025910e-02f, 1.45592719e-01f, -2.92523619e-04f,
  1.62594423e-01f, 1.83289568e-03f, -3.59669179e-02f, 1.11114336e-02f, -1.22043248e-02f, -6.37663081e-02f, 8.03073309e-03f, -7.83927459e-03f, 5.60282543e-02f, 4.16320749e-03f,
  4.02351245e-02f, -1.24085899e-02f, -6.08110055e-02f, -5.78310937e-02f, -5.26229516e-02f, -2.49750502e-02f, 9.91066769e-02f, -1.70020927e-02f, 8.00835788e-02f, 6.64517656e-02f,
  4.73450422e-02f, 8.76357332e-02f, -5.06734625e-02f, -1.71830244e-02f, -7.50374794e-02f, 8.45826045e-02f, -1.16689786e-01f, -2.00313628e-02f, 2.03327108e-02f, 9.53174941e-03f,
  4.39336486e-02f, -9.86551940e-02f, 4.85655218e-02f, -6.03264906e-02f, -3.92933339e-02f, 7.14609325e-02f, 4.04016562e-02f, 4.26880717e-02f, -9.87879634e-02f, 4.28390615e-02f,
  8.57971683e-02f, 1.16019875e-01f, 5.05182371e-02f, 1.07378781e-01f, -1.57572590e-02f, 1.83933638e-02f, 2.41735633e-02f, 1.94006658e-03f, -4.48598526e-03f, -2.84810755e-02f,
  1.59392618e-02f, 2.18066573e-02f, -8.21902975e-02f, 1.46194156e-02f, -5.02770133e-02f, 5.06934859e-02f, 6.52065128e-02f, 6.07293770e-02f, 1.70485564e-02f, 1.03767067e-02f,
  6.39698058e-02f, 5.32445684e-02f, -4.44497988e-02f, -2.87545542e-03f, -7.32827932e-02f, -6.27053082e-02f, 7.68616423e-02f, -4.19523455e-02f, 7.14264736e-02f, -4.83488850e-02f,
  3.72366421e-02f, -4.02686931e-03f, -1.19772218e-01f, -4.03442048e-02f, -1.08627357e-01f, 4.07753587e-02f, -1.52906805e-01f, -8.31179544e-02f, -1.28364220e-01f, -7.98369795e-02f,
  3.66549864e-02f, 2.06105951e-02f, 2.04671044e-02f, 1.55284539e-01f, 8.09876770e-02f, 5.48507906e-02f, 9.22957882e-02f, -5.98253012e-02f, 7.90000893e-03f, -2.45430954e-02f,
  2.70799939e-02f, 4.97121960e-02f, 3.16575505e-02f, 5.00456616e-02f, 6.92608729e-02f, 6.25929385e-02f, 4.56940606e-02f, -3.90249491e-02f, 1.09069467e-01f, -3.89707610e-02f,
  4.75560538e-02f, 2.24855496e-03f, 4.82283011e-02f, -5.22242524e-02f, 5.49262278e-02f, 3.13393325e-02f, -7.90290907e-02f, 4.88693453e-02f, -6.83220327e-02f, 6.67557716e-02f,
  -1.55212069e-02f, 7.41804093e-02f, 6.29595071e-02f, -1.54149607e-02f, -3.86681641e-03f, 5.17993011e-02f, 6.64423732e-03f, -6.74511343e-02f, 5.11794053e-02f, 1.58759747e-02f,
  -6.27928004e-02f, 4.58093099e-02f, -1.04609601e-01f, -4.53059897e-02f, -1.14298882e-02f, 9.99984704e-03f, 2.05255561e-02f, 1.56269539e-02f, 5.04566208e-02f, 7.07786381e-02f,
  -3.05442587e-02f, -3.38842794e-02f, 1.71391189e-03f, -8.11048821e-02f, -1.11468546e-02f, 2.98203602e-02f, -6.31595701e-02f, 7.62642920e-02f, -1.83094591e-02f, -3.82231697e-02f,
  -6.18528165e-02f, 3.17842625e-02f, 1.85635965e-02f, 1.64708443e-04f, 7.56095648e-02f, 3.14263590e-02f, -3.08026443e-03f, 7.81179965e-02f, -1.47728045e-02f, -9.18977633e-02f,
  -6.60803467e-02f, -5.89638427e-02f, 4.70298044e-02f, -1.28269624e-02f, 7.18220249e-02f, 2.15251707e-02f, 4.92569171e-02f, -5.30372635e-02f, -1.59879699e-02f, -8.48940462e-02f,
  -2.53052264e-02f, 7.45848641e-02f, 2.56288089e-02f, -2.09730696e-02f, -1.62680987e-02f, -5.24028651e-02f, 9.61013585e-02f, -8.92714038e-03f, 5.09787612e-02f, 5.72586665e-03f,
  -7.62353539e-02f, -2.45883100e-04f, 4.22616377e-02f, -8.28466788e-02f, -5.82599174e-03f, 7.84781575e-02f, -3.96194495e-02f, -9.46728513e-02f, -7.40201026e-02f, -1.82945561e-02f,
  1.01047894e-02f, -3.15429308e-02f, 9.36065987e-03f, -1.31362758e-03f, 2.01336178e-03f, -8.61261040e-02f, -5.88517962e-03f, -7.97288492e-02f, 1.63878556e-02f, -7.37144053e-02f,
  1.68811250e-02f, 2.14706331e-01f, -6.66169301e-02f, -3.14336866e-02f, 7.19290301e-02f, 2.08333340e-02f, -1.26530588e-01f, 3.45621929e-02f, 1.84573382e-01f, 4.86595277e-03f,
  -3.70181650e-02f, 1.93999246e-01f, -6.76879734e-02f, -1.60216689e-01f, -2.20656455e-01f, -3.51748578e-02f, -1.22647330e-01f, -6.45360947e-02f, -4.10403647e-02f, 3.07701156e-02f,
  -1.20901816e-01f, -9.62469578e-02f, -2.22979665e-01f, 2.84480937e-02f, -2.27501895e-02f, -2.90326793e-02f, -1.05757929e-01f, -1.41835110e-02f, -1.21238209e-01f, -1.84090044e-02f,
  -1.72734633e-02f, -8.55728909e-02f, 2.70548705e-02f, 1.27333058e-02f, -1.33992983e-02f, -6.89485148e-02f, 4.52070497e-02f, -1.34564070e-02f, -5.54032773e-02f, -1.59519352e-02f,
  8.80923793e-02f, 4.95832041e-02f, -1.74069423e-02f, -5.35816588e-02f, 3.56599279e-02f, -1.00752860e-01f, 7.82006755e-02f, 3.04501075e-02f, 7.21609443e-02f, 6.70663863e-02f,
  4.51489277e-02f, 8.41993019e-02f, 6.25358447e-02f, -8.60927105e-02f, 6.74130395e-03f, -1.64053328e-02f, 5.16192876e-02f, -5.66886254e-02f, -2.89406441e-02f, -1.44267827e-02f,
  8.06210842e-03f, -4.93129417e-02f, 4.92986590e-02f, -9.79494229e-02f, -4.34905291e-02f, -8.60583633e-02f, -4.03751768e-02f, -2.02633888e-02f, 8.05441588e-02f, 3.46590839e-02f,
  2.63974559e-03f, -2.31038760e-02f, 9.97127146e-02f, -3.62251177e-02f, 5.44109121e-02f, -1.10630549e-01f, -9.15506333e-02f, -3.53142805e-02f, -5.41775189e-02f, 3.25283185e-02f,
  -7.10473210e-02f, -1.10010374e-02f, 4.17856164e-02f, 3.42341363e-02f, -2.38631456e-03f, -3.78972143e-02f, -1.50204506e-02f, -4.65509258e-02f, 7.47983623e-03f, 3.98157388e-02f,
  8.20131898e-02f, 9.99606997e-02f, 2.14573294e-02f, 6.03290135e-03f, 5.81533015e-02f, -4.10691872e-02f, 5.66335469e-02f, 8.27888250e-02f, 8.86054486e-02f, 1.45213753e-02f,
  -2.81258882e-03f, 6.89532012e-02f, -2.17809305e-02f, -8.06746930e-02f, 3.74869257e-02f, -5.16826957e-02f, 8.86811018e-02f, -1.32310968e-02f, 4.14264128e-02f, 7.18508214e-02f,
  6.08953200e-02f, 1.08622331e-02f, -2.53631473e-02f, 6.93644583e-02f, 4.00407091e-02f, 2.83891056e-02f, -6.82840347e-02f, 5.98244928e-02f, 3.61945406e-02f, -9.06437635e-04f,
  1.71289757e-01f, 1.12416871e-01f, -3.43371672e-03f, 7.20950738e-02f, -5.54427765e-02f, 3.15267816e-02f, -8.16859156e-02f, -9.52397212e-02f, -4.54397798e-02f, 2.00673282e-01f,
  -8.70027766e-02f, 6.57515228e-02f, -2.12147236e-01f, -5.59720360e-02f, -3.86359096e-01f, -3.12726706e-01f, -1.51448045e-02f, 3.38184685e-02f, -7.60962516e-02f, 7.44071752e-02f,
  -1.12215258e-01f, -1.94654956e-01f, -4.65682149e-02f, -1.25215128e-01f, 1.76138595e-01f, 2.17843130e-01f, -2.45661996e-02f, -4.27334793e-02f, 9.14758593e-02f, -1.44483507e-01f,
  -4.39100862e-02f, -1.24180026e-01f, 5.40779606e-02f, 2.42011342e-02f, 7.56364018e-02f, 1.91836536e-01f, 1.41993374e-01f, -1.89254835e-01f, -6.95502982e-02f, 4.65300009e-02f,
  1.38189688e-01f, -4.84896675e-02f, -1.58080719e-02f, -6.02896251e-02f, 7.60919135e-03f, 5.55459224e-02f, -1.70458630e-02f, 1.56614572e-01f, 1.02103852e-01f, 8.77195075e-02f,
  3.33137251e-02f, 7.18397498e-02f, 5.69207631e-02f, 7.62042776e-02f, -3.42606567e-02f, 4.26888727e-02f, -1.44140525e-02f, 4.26678807e-02f, 1.48761109e-01f, 3.50816287e-02f,
  5.10494336e-02f, 6.10918142e-02f, -2.91210245e-02f, -1.89853776e-02f, -1.95112266e-02f, -2.62228549e-02f, 2.95042675e-02f, -6.54143244e-02f, -3.47447582e-02f, 2.90015657e-02f,
  3.60516869e-02f, 6.52150586e-02f, -2.27053948e-02f, 9.76559073e-02f, 4.68460470e-03f, 4.14178409e-02f, 7.75426850e-02f, 4.50987481e-02f, 2.05209777e-02f, 5.75343706e-02f,
  7.25779030e-03f, 6.55675381e-02f, -1.47865191e-02f, 9.83718783e-02f, -6.62438869e-02f, 6.76785735e-03f, -6.44282773e-02f, 3.99961770e-02f, 6.97437450e-02f, 6.88645840e-02f,
  -1.47572276e-03f, 4.68011089e-02f, -1.09283067e-02f, -6.90559670e-02f, 5.35873398e-02f, 9.27576423e-02f, -2.92660277e-02f, 5.79858311e-02f, -1.03446841e-01f, -8.55710581e-02f,
  1.29329622e-01f, 7.80960023e-02f, 1.35603905e-01f, -2.66411137e-02f, -2.31566466e-02f, -5.51677197e-02f, 4.57442785e-03f, 4.24660444e-02f, 4.36451212e-02f, 6.83861226e-02f,
  6.01077117e-02f, 6.63851202e-02f, 1.00723887e-02f, 1.83444223e-04f, 1.05984777e-01f, 6.70603812e-02f, 6.63032010e-02f, 4.75334376e-02f, 3.40541303e-02f, -4.08065878e-02f,
  1.82295933e-01f, -6.10077102e-03f, -5.78115396e-02f, 7.86025152e-02f, 5.08192601e-03f, -2.34389640e-02f, 1.07553443e-02f, -2.69101597e-02f, 1.30163774e-01f, -1.43332973e-01f,
  -5.93591668e-02f, -6.87799305e-02f, 6.36733472e-02f, -8.04771036e-02f, 1.18047774e-01f, -1.37984276e-01f, 1.17222093e-01f, -3.26175056e-02f, -5.17496429e-02f, 1.72942832e-01f,
  8.38434231e-03f, -9.41602364e-02f, -1.28859142e-02f, 5.47092641e-03f, -3.59666348e-02f, 1.44031808e-01f, -2.47234367e-02f, 1.74070783e-02f, -1.16424933e-01f, -1.23568445e-01f,
  -8.63954350e-02f, 4.32907306e-02f, -1.05712712e-02f, -5.78590520e-02f, 6.79909289e-02f, 1.01281457e-01f, 2.77671125e-02f, -2.51690168e-02f, -9.30022374e-02f, -5.07561602e-02f,
  -1.79910138e-02f, 4.66737039e-02f, 9.93356016e-03f, -3.22590172e-02f, -2.18948373e-03f, -1.15235969e-02f, -5.42023890e-02f, 8.29912275e-02f, -3.25383581e-02f, 1.19624403e-03f,
  -2.34039519e-02f, 4.89352420e-02f, 9.32855755e-02f, 3.00767319e-03f, -3.08738668e-02f, 6.39512986e-02f, 7.21515194e-02f, 2.62665395e-02f, 6.96462467e-02f, 9.06134248e-02f,
  -5.43456115e-02f, 1.13364477e-02f, -8.68176743e-02f, -1.29535019e-01f, 4.70869131e-02f, -6.65803105e-02f, 3.76529358e-02f, -8.99836794e-03f, 7.07746670e-02f, 7.93935284e-02f,
  -1.36585906e-02f, -2.90135182e-02f, -6.68835640e-02f, -3.97758521e-02f, -1.79433264e-02f, 2.90826596e-02f, -2.66227536e-02f, -2.44448613e-02f, -1.77343003e-02f, -7.35749155e-02f,
  -1.43172756e-01f, -5.00462838e-02f, -9.40884873e-02f, -8.44666064e-02f, -9.88387764e-02f, 3.45231183e-02f, -7.17273951e-02f, -7.25183785e-02f, 5.25315739e-02f, -1.50297480e-02f,
  5.44980168e-02f, 1.39265284e-01f, -4.24236469e-02f, 3.32543999e-02f, 7.06449375e-02f, 7.51976743e-02f, -3.40977088e-02f, 1.53142195e-02f, 1.45145431e-01f, 7.69041702e-02f,
  3.41631547e-02f, 1.62051972e-02f, 1.06970565e-02f, -2.21213996e-02f, 2.06206529e-03f, 8.78241435e-02f, 8.45410526e-02f, 7.14577362e-02f, 1.88951264e-03f, -2.46764477e-02f,
  6.65559247e-02f, 4.91918512e-02f, 1.04867190e-01f, 1.05834834e-01f, -3.99329178e-02f, 3.10675818e-02f, 8.96712169e-02f, 1.06966153e-01f, 7.09090196e-03f, 1.02343239e-01f,
  1.24572478e-01f, 2.95444438e-03f, -8.27674940e-02f, -2.69851033e-02f, -5.36541939e-02f, 4.66448665e-02f, 1.15166456e-01f, -1.29784510e-01f, -9.01679099e-02f, 2.82618217e-02f,
  1.71510190e-01f, -3.98868881e-02f, 7.83734173e-02f, 3.01200468e-02f, -2.76783090e-02f, -2.35676742e-03f, 6.44441396e-02f, 1.02273442e-01f, -7.30143348e-03f, -3.03786173e-02f,
  -8.52384120e-02f, 6.42728359e-02f, -5.43966815e-02f, -2.09802971e-03f, 1.03971623e-01f, -1.28566355e-01f, 2.65959743e-02f, 7.97033235e-02f, -1.14500374e-01f, 6.41860589e-02f,
  3.89629346e-03f, -4.53286693e-02f, 5.00276685e-02f, -3.78882885e-02f, -5.53441085e-02f, 1.17038637e-01f, 1.42184587e-03f, -1.62778012e-02f, -6.81182146e-02f, 1.88989006e-02f,
  -5.19349687e-02f, 7.06616417e-02f, -4.33321483e-02f, 7.45753646e-02f, 5.29268309e-02f, -4.89449874e-02f, -6.59831017e-02f, 5.30075282e-02f, 4.64041531e-02f, 8.82259086e-02f,
  5.58718666e-02f, -4.30437140e-02f, -1.41936736e-02f, 3.85037921e-02f, -1.02392389e-02f, 2.15705261e-02f, -8.55861455e-02f, 2.65150182e-02f, -6.35514706e-02f, -1.42059838e-02f,
  -7.56745636e-02f, 4.04298939e-02f, -6.20401464e-04f, -8.91383886e-02f, -6.78039668e-03f, 5.71297929e-02f, 7.47608244e-02f, -2.55018957e-02f, -4.72383052e-02f, 1.74179897e-02f,
  1.98753644e-02f, -3.39654014e-02f, 6.78173779e-03f, 3.47861387e-02f, -3.40870931e-03f, 6.16933778e-02f, 3.72246914e-02f, 4.30292040e-02f, 5.58054224e-02f, 3.46778631e-02f,
  -4.07752283e-02f, 3.38402353e-02f, -6.00948744e-02f, -7.95197114e-02f, 3.84911038e-02f, 1.02168679e-01f, -2.37982869e-02f, -8.61570518e-03f, -2.21847389e-02f, -5.29960431e-02f,
  4.58613448e-02f, 4.23425883e-02f, -5.45576885e-02f, -9.42531675e-02f, 1.13792531e-02f, 4.92207259e-02f, -5.89335747e-02f, -9.02897194e-02f, 1.05665447e-02f, -5.59285246e-02f,
  -7.22783655e-02f, 6.28343299e-02f, -2.19889218e-03f, 4.38087657e-02f, 1.11246584e-02f, 1.26008227e-01f, -9.86394733e-02f, -5.04059978e-02f, -2.58142035e-02f, -5.00192419e-02f,
  -6.48302063e-02f, -4.72474396e-02f, 2.72709075e-02f, -5.18878736e-02f, 2.97729447e-02f, 1.46022178e-02f, 7.36752823e-02f, -2.53751520e-02f, -6.99189007e-02f, -1.47623820e-02f,
  -3.86653185e-01f, 3.53061974e-01f, -4.35235947e-02f, -2.85407424e-01f, 3.02625801e-02f, 1.61887035e-01f, -1.06195904e-01f, 1.29957780e-01f, -1.81346744e-01f, -1.27596423e-01f,
  -1.01568595e-01f, -2.07664758e-01f, 1.04719453e-01f, -4.62695546e-02f, -5.73885143e-02f, 1.04773894e-01f, -4.93129119e-02f, -1.29355565e-01f, 1.11677073e-01f, -1.04538992e-01f,
  -1.95336854e-03f, -3.91330495e-02f, 1.50605783e-01f, 2.11252496e-01f, -9.74742845e-02f, -6.13460615e-02f, -1.47981644e-01f, 1.31625816e-01f, -5.89262247e-02f, 7.78364614e-02f,
  5.78188524e-02f, -2.03145489e-01f, -2.47039832e-02f, -7.81247914e-02f, 6.91666231e-02f, -8.81608501e-02f, 2.68098880e-02f, 3.01768370e-02f, -6.56497106e-02f, -2.62623206e-02f,
  -1.12556100e-01f, 1.24597540e-02f, -2.60692108e-02f, 2.75315670e-03f, -1.05009802e-01f, 5.03242053e-02f, 7.11218491e-02f, 1.01494610e-01f, 6.42729364e-03f, 9.18575600e-02f,
  1.58049781e-02f, -1.07992943e-02f, -3.48108783e-02f, -2.08616257e-02f, -4.65207398e-02f, -3.43296654e-03f, 7.75509281e-03f, -2.16758307e-02f, -4.79653180e-02f, 1.91860348e-02f,
  -7.94438645e-02f, -2.47899769e-03f, -3.74193862e-02f, 7.37454370e-02f, -4.71245199e-02f, 5.68726435e-02f, -5.77537715e-02f, 4.74185795e-02f, -7.51710087e-02f, 8.25454816e-02f,
  1.48344338e-02f, -5.14480695e-02f, -1.08748171e-02f, -3.89504656e-02f, -2.93736365e-02f, -9.75634307e-02f, 3.25147137e-02f, -5.19410446e-02f, -4.76458255e-04f, 1.79931149e-02f,
  -4.70903367e-02f, -6.97813928e-02f, -9.31195691e-02f, 4.20229770e-02f, 3.18662114e-02f, -2.29841042e-02f, -9.59471017e-02f, 1.08085588e-01f, -3.73106860e-02f, 6.45275973e-03f,
  1.60993293e-01f, -6.55709654e-02f, -3.55991200e-02f, -2.54788809e-02f, 8.82595927e-02f, 1.09575585e-01f, -8.15130305e-03f, 6.53314311e-03f, -2.42479034e-02f, -1.27144167e-02f,
  -2.85737664e-02f, -7.08102360e-02f, -3.62226591e-02f, -1.75344804e-03f, -1.41301723e-02f, 2.13436838e-02f, -5.23697063e-02f, -5.90027124e-02f, 8.50045122e-03f, 4.08365019e-02f,
  -5.61832003e-02f, -5.44580026e-03f, -8.22415724e-02f, -4.62649018e-02f, 1.41916387e-02f, -9.95689407e-02f, -5.35175428e-02f, 3.47953849e-02f, -3.31695676e-02f, -8.13627325e-04f,
  1.40345991e-02f, 2.35827386e-01f, 2.64594480e-02f, 8.38296637e-02f, -8.45325068e-02f, -7.24293441e-02f, 1.17617078e-01f, 1.51431888e-01f, 8.48535821e-02f, 5.10617904e-02f,
  5.45553900e-02f, 8.67447034e-02f, -8.76797065e-02f, 3.62841412e-03f, 1.80496812e-01f, 9.84206647e-02f, 7.64383748e-02f, -5.74217252e-02f, 4.38727476e-02f, 9.95038301e-02f,
  1.14544317e-01f, 5.98890781e-02f, 1.09701268e-01f, -3.23407277e-02f, 9.63580608e-02f, -4.68698740e-02f, 7.50383735e-02f, -7.25014433e-02f, -2.40993779e-02f, -1.87351927e-02f,
  -1.38137275e-02f, 6.66587660e-03f, 2.68644001e-02f, 3.12120672e-02f, 5.49147576e-02f, -9.16734152e-03f, 9.37555637e-03f, 4.90421988e-02f, -6.70211166e-02f, 4.45387606e-03f,
  5.75279817e-03f, -1.06203847e-01f, 9.02345311e-03f, 3.86025496e-02f, -8.37159343e-03f, -2.76850928e-02f, -6.25815243e-02f, -6.72252327e-02f, -8.28897487e-03f, -3.68149690e-02f,
  -7.21484944e-02f, -2.70614470e-03f, 5.48500083e-02f, 4.48576659e-02f, 8.18320736e-03f, -2.27990393e-02f, -1.87960565e-02f, 1.07130922e-01f, 6.62854835e-02f, 4.58426662e-02f,
  2.65194643e-02f, -8.26261714e-02f, -6.83834329e-02f, 1.81038361e-02f, 1.94463488e-02f, 2.11011972e-02f, -4.79763784e-02f, 2.40964629e-02f, -1.26246363e-02f, -3.35504636e-02f,
  3.40711279e-03f, 4.68503274e-02f, -4.18781303e-02f, -3.13066356e-02f, 5.38891926e-03f, -2.84654852e-02f, 6.77263886e-02f, -6.05814606e-02f, -4.46611457e-02f, -9.35471728e-02f,
  -3.84832956e-02f, 2.53420491e-02f, 8.98956973e-03f, 2.16351543e-02f, -4.62587327e-02f, -7.33500207e-03f, -6.93416893e-02f, 2.69669350e-02f, -2.53326129e-02f, -2.03490220e-02f,
  1.46535009e-01f, 3.94386768e-01f, 1.89206544e-02f, -6.38313070e-02f, -4.94624041e-02f, -6.22866210e-03f, 6.97950125e-02f, 1.14218732e-02f, 7.65290558e-02f, 9.66516659e-02f,
  -1.84693616e-02f, 3.82149965e-02f, -3.57796066e-02f, -8.18076357e-02f, 1.33465370e-02f, 1.12042174e-01f, 2.37378366e-02f, 6.12325035e-02f, -9.84390266e-03f, -4.26430702e-02f,
  -4.57040705e-02f, 1.22688722e-03f, 7.83195049e-02f, 4.24577063e-03f, 1.85865201e-02f, -2.19940115e-02f, 8.78418237e-02f, 7.76626691e-02f, 7.47446716e-02f, -3.37858275e-02f,
  4.95299906e-01f, -4.63217124e-02f, -3.44521016e-01f, -6.57505393e-02f, 1.80145964e-01f, 2.79398173e-01f, -1.23029947e-02f, 1.00695588e-01f, -1.31070182e-01f, -2.90338285e-02f,
  1.50586799e-01f, 4.71874475e-02f, -1.94151446e-01f, 2.73599923e-01f, 1.18031539e-01f, -5.61651327e-02f, 2.71172285e-01f, 1.70449451e-01f, -1.18555948e-01f, 5.71745001e-02f,
  2.31370088e-02f, 2.47206271e-01f, -1.88212737e-01f, 6.14200197e-02f, 1.01779349e-01f, -1.60544291e-01f, 1.97879821e-02f, -1.47031784e-01f, 8.00309852e-02f, 1.52959689e-01f,
  6.36982620e-02f, 5.82480319e-02f, 1.13371797e-02f, -4.29944098e-02f, -4.66427356e-02f, 1.59420900e-03f, -7.51284435e-02f, 3.01960320e-03f, -8.21940824e-02f, -1.27628613e-02f,
  1.64476708e-02f, -6.31538928e-02f, 1.85359530e-02f, 4.33647484e-02f, 1.74810588e-02f, 2.74413843e-02f, -1.35209819e-03f, -8.11277926e-02f, -1.22790083e-01f, -2.22208928e-02f,
  -1.05912194e-01f, 6.18705899e-02f, 6.67723417e-02f, -9.59163830e-02f, -3.87943499e-02f, -2.57098265e-02f, 9.55541246e-03f, -8.04439187e-02f, 9.75678861e-02f, -1.93176349e-03f,
  6.85517862e-02f, -1.07081003e-01f, 4.03070673e-02f, 6.91216765e-03f, 3.02009098e-02f, -2.97539663e-02f, -5.02383858e-02f, -1.62916034e-02f, -9.54238847e-02f, -5.84971607e-02f,
  1.63824167e-02f, -5.64119108e-02f, -2.17479859e-02f, -2.14671399e-02f, -2.62989271e-02f, 7.10764853e-03f, -1.17414407e-02f, -2.65713334e-02f, -8.04492459e-02f, -1.40907317e-02f,
  -1.92678012e-02f, 3.35157327e-02f, 2.23609526e-02f, -1.00918086e-02f, 6.46612346e-02f, -7.08492398e-02f, 9.40588340e-02f, -4.50812802e-02f, -8.26476365e-02f, -2.57235374e-02f,
  2.88326330e-02f, -3.89792882e-02f, -5.22960536e-03f, 6.50598155e-03f, 5.09780459e-03f, 1.68872029e-01f, 5.06974757e-02f, 8.11717659e-02f, 7.47410730e-02f, 1.10368036e-01f,
  6.64070903e-05f, -3.02233770e-02f, 1.46055277e-02f, 5.60938492e-02f, -1.78356785e-02f, 7.08015412e-02f, -2.56403885e-03f, -5.19770123e-02f, -4.54571396e-02f, 1.17601398e-02f,
  -7.47833699e-02f, -2.75360234e-02f, -9.33800414e-02f, -5.76091856e-02f, 2.02153460e-03f, 2.41352012e-03f, 6.47569895e-02f, -2.61628088e-02f, 2.93040033e-02f, -8.84980410e-02f,
  -2.62421250e-01f, -6.37659058e-02f, -2.80927151e-01f, -3.21040392e-01f, 1.59175918e-01f, -8.39283764e-02f, -1.86588839e-01f, -2.47481819e-02f, -7.09798932e-02f, 2.06488758e-01f,
  1.39305100e-01f, -1.46871403e-01f, 1.51674032e-01f, -3.36964786e-01f, -3.96760225e-01f, -1.31524250e-01f, -3.83003443e-01f, -2.46026963e-01f, -9.16546285e-02f, -9.55571011e-02f,
  -1.51424900e-01f, -4.87694070e-02f, -2.16330618e-01f, 1.89197361e-01f, -7.15069287e-03f, 7.48109370e-02f, 2.00163662e-01f, 1.63932562e-01f, -6.07824065e-02f, -2.23029498e-02f,
  -1.45127714e-01f, 6.15299493e-02f, -2.89808717e-02f, -9.60388258e-02f, -2.57197581e-02f, 9.13959835e-03f, -4.47562896e-02f, -1.19589092e-02f, 3.75508443e-02f, -1.10036068e-01f,
  4.20770682e-02f, -5.15612215e-03f, -7.93061331e-02f, 5.07981479e-02f, 5.41623868e-02f, -1.86541025e-02f, -3.33537310e-02f, -1.57676209e-02f, 3.62224616e-02f, -1.47933289e-01f,
  -8.51856172e-02f, -4.77182530e-02f, -4.51857224e-02f, 5.25201578e-03f, 3.28581631e-02f, 1.73088517e-02f, -3.20127718e-02f, 3.45209725e-02f, -1.74168851e-02f, -9.99545977e-02f,
  -1.85175240e-02f, -9.07245278e-03f, -6.96427450e-02f, 9.99948010e-03f, -3.08622122e-02f, -3.58421206e-02f, 1.32834977e-02f, -2.43307278e-02f, -1.96688361e-02f, 5.38674593e-02f,
  4.00046147e-02f, 1.13091655e-02f, -7.26647228e-02f, 3.05277985e-02f, -2.93756593e-02f, -4.49109040e-02f, -3.48851494e-02f, 1.20720454e-02f, -7.81246349e-02f, -8.86715129e-02f,
  5.95849529e-02f, -4.88087349e-02f, -3.69910354e-04f, 7.84774218e-03f, -7.09204152e-02f, 7.19833821e-02f, 1.34726511e-02f, -5.76978587e-02f, -2.04673093e-02f, 5.95493838e-02f,
  4.34849337e-02f, 5.98610863e-02f, -2.69646514e-02f, 1.01210669e-01f, 4.91823815e-02f, -9.45764128e-03f, 2.56221890e-02f, -6.39363676e-02f, 2.22307071e-02f, 6.13856241e-02f,
  1.76999513e-02f, -1.14136888e-02f, 7.99242407e-02f, 3.45265754e-02f, -4.14731391e-02f, -1.57944839e-02f, 3.95742133e-02f, 1.02285119e-02f, 1.30673023e-02f, 3.21677923e-02f,
  9.57063138e-02f, 6.70452043e-02f, 1.05185090e-02f, -1.22299942e-03f, -4.10434864e-02f, 7.34248087e-02f, 6.81580082e-02f, -1.03236651e-02f, 1.72160845e-02f, -3.21204774e-02f,
  3.09162259e-01f, -1.89909682e-01f, 1.65495858e-01f, 3.50633770e-01f, 2.26550892e-01f, 2.59977616e-02f, 3.13484073e-01f, 6.80821389e-02f, 3.37717652e-01f, -3.47733051e-01f,
  6.53093634e-03f, 1.26225322e-01f, -9.40161645e-02f, 1.96275525e-02f, 9.50801447e-02f, -3.13894749e-02f, -8.84679183e-02f, -5.15554138e-02f, 8.05957019e-02f, 2.04239991e-02f,
  7.02839494e-02f, -7.22273812e-02f, -3.26338448e-02f, -3.38211298e-01f, 1.12620562e-01f, -1.50900334e-02f, -2.47746676e-01f, 6.04557022e-02f, -2.43385792e-01f, -1.46201868e-02f,
  1.12759538e-01f, 1.85209643e-02f, 1.92217510e-02f, -8.83831307e-02f, 8.75069760e-03f, 4.57207486e-02f, 1.00542583e-01f, 8.40864927e-02f, 2.31906846e-02f, 7.13199675e-02f,
  2.47829943e-03f, -7.34932348e-02f, -5.52018881e-02f, 3.19685042e-02f, 6.47147298e-02f, 1.16919912e-02f, 1.03282690e-01f, 4.66624685e-02f, -5.83078191e-02f, 5.56568429e-02f,
  2.90402723e-03f, -1.26265781e-02f, 5.71991876e-02f, -1.19485684e-01f, 4.53449078e-02f, -3.64765003e-02f, -1.11330803e-02f, -5.14289401e-02f, -4.09700237e-02f, 9.11797862e-03f,
  1.88731067e-02f, 2.92233098e-02f, 7.21150488e-02f, 2.31976975e-02f, -6.01746514e-02f, -6.34651184e-02f, 2.23465320e-02f, 4.17473949e-02f, -2.85021346e-02f, -5.68400472e-02f,
  1.08044604e-02f, 4.56035435e-02f, 7.79551640e-02f, -1.46413045e-02f, 3.43902484e-02f, 9.70739797e-02f, -2.74396203e-02f, -2.11236645e-02f, 8.88147950e-02f, -6.03868403e-02f,
  -5.13969213e-02f, 2.93808393e-02f, -5.94746508e-02f, 1.48673272e-02f, -1.17210932e-02f, -5.53566637e-03f, -6.63056970e-02f, -5.90827465e-02f, 6.50736392e-02f, 6.78372607e-02f,
  -1.52528912e-01f, -1.88782007e-01f, 5.72491661e-02f, 1.07377255e-02f, 7.45836133e-03f, -8.75075161e-02f, -4.17890809e-02f, 6.18735589e-02f, -5.23706600e-02f, 1.23928720e-02f,
  -4.19187509e-02f, -1.12391561e-02f, -5.50061762e-02f, -5.94116114e-02f, -2.20770165e-02f, -5.53954653e-02f, 2.23354008e-02f, -8.35877508e-02f, 1.14332447e-02f, -1.48396373e-01f,
  -6.28253892e-02f, 4.47179936e-02f, 7.64333159e-02f, 1.08708339e-02f, 3.98794599e-02f, -4.23443317e-02f, 3.09124552e-02f, -3.29263881e-02f, -6.37231842e-02f, -9.77592915e-02f,
  7.35039264e-02f, 2.72637010e-01f, 1.06711209e-01f, 4.78267893e-02f, 1.33598819e-01f, -7.57918553e-03f, 1.17863836e-02f, 6.42115399e-02f, 2.34809309e-01f, -5.33262938e-02f,
  -5.60988896e-02f, 2.93603033e-01f, -1.07032478e-01f, 2.07397342e-02f, -2.94206768e-01f, -2.26803914e-01f, -1.20971508e-01f, 3.61035205e-02f, 1.46328360e-02f, -5.05608767e-02f,
  -8.00222754e-02f, -3.38954590e-02f, -5.09220771e-02f, 5.50789237e-02f, 2.20342521e-02f, 1.06140422e-02f, -2.40152612e-01f, -1.27934098e-01f, 1.24382399e-01f, 1.41787427e-02f,
  5.65069206e-02f, 1.07999772e-01f, -3.31408195e-02f, 2.90126652e-02f, -5.83701022e-02f, 5.79552501e-02f, 1.01980530e-02f, -3.41607258e-02f, 2.56225821e-02f, 1.04654893e-01f,
  -5.43972738e-02f, -3.08946595e-02f, 1.20120168e-01f, -4.67902198e-02f, 9.62854549e-02f, 6.25762856e-04f, 5.35227284e-02f, 9.65066478e-02f, -2.02305336e-03f, 5.20642437e-02f,
  1.52745172e-02f, 2.80123875e-02f, -1.97633803e-02f, 3.80758606e-02f, 8.69071111e-02f, -2.46304926e-02f, 2.96300389e-02f, 3.85921933e-02f, 2.96903774e-02f, 6.08691089e-02f,
  7.46281743e-02f, 2.48099100e-02f, -1.73112676e-02f, -5.34390919e-02f, 1.58923380e-02f, -1.02159120e-02f, -4.74805981e-02f, 5.77776283e-02f, 3.40632983e-02f, -3.52927931e-02f,
  2.16700733e-02f, -8.13704450e-03f, 4.05368023e-02f, -2.06249468e-02f, 5.62513508e-02f, 4.96944003e-02f, 4.25429195e-02f, -8.26692358e-02f, -1.34550715e-02f, -4.94204052e-02f,
  1.15065174e-02f, 2.62367707e-02f, -3.88085246e-02f, -4.77384366e-02f, -5.86017780e-02f, -7.65995728e-03f, -4.53038625e-02f, 6.60240352e-02f, 2.49148980e-02f, -7.37785771e-02f,
  -1.44854262e-01f, -1.48179680e-01f, 9.51800775e-03f, 7.98655376e-02f, -6.19936921e-02f, -9.79883596e-02f, 4.65067513e-02f, -3.88243534e-02f, -2.84360182e-02f, 7.41801262e-02f,
  4.80692694e-03f, 8.24906081e-02f, -2.42787804e-02f, 1.93555839e-02f, 3.22298333e-02f, -5.08945175e-02f, -1.15364857e-01f, 4.55922037e-02f, -6.16180785e-02f, 1.88745726e-02f,
  1.68806408e-02f, 8.99725594e-03f, 4.14382629e-02f, -5.08418195e-02f, -2.90238652e-02f, -3.12804170e-02f, -6.60364628e-02f, 6.20193258e-02f, -2.25708634e-02f, 7.97204152e-02f,
  2.09905431e-02f, 4.35930453e-02f, 2.38671988e-01f, 3.46747786e-01f, -1.68918699e-01f, -3.92291933e-01f, -1.83112621e-01f, 4.68759872e-02f, -7.07664341e-02f, -1.56804979e-01f,
  5.06636910e-02f, -2.06220411e-02f, -1.18401712e-02f, 1.29823849e-01f, 1.96305737e-01f, 2.77288128e-02f, 1.06924072e-01f, -4.09714095e-02f, 4.61676568e-02f, 1.93585724e-01f,
  1.87965885e-01f, 2.48301253e-01f, 3.25079501e-01f, 2.51924098e-01f, 6.76228330e-02f, 2.77624398e-01f, 3.36960554e-01f, 6.89021125e-02f, 2.49322399e-01f, 4.03228216e-02f,
  -1.35508746e-01f, 6.57260492e-02f, 2.35551484e-02f, -1.26629964e-01f, -2.20350772e-02f, -5.01222387e-02f, -2.42234878e-02f, 5.82383834e-02f, 5.53357936e-02f, 2.07772385e-03f,
  1.12807462e-02f, 6.68381574e-03f, 6.01946656e-03f, -3.45924944e-02f, -8.25390741e-02f, 5.01637124e-02f, -3.80376428e-02f, 4.66833301e-02f, -7.95597152e-04f, -1.24102738e-03f,
  8.81713815e-03f, 1.57811362e-02f, -3.21723036e-02f, 7.72370100e-02f, 1.30952829e-02f, -3.16559300e-02f, 3.33308079e-03f, 1.03728687e-02f, -4.96065198e-03f, 2.38898657e-02f,
  7.20040500e-02f, -8.04601908e-02f, -3.86943296e-02f, -5.68353012e-02f, -6.33891113e-03f, -5.12431674e-02f, -3.09650730e-02f, -5.30233830e-02f, -1.30297579e-02f, -4.13746983e-02f,
  7.01841787e-02f, 7.61278793e-02f, -3.50701287e-02f, 2.69130133e-02f, 8.12125206e-02f, -1.20565165e-02f, 3.55673283e-02f, -7.83197209e-03f, -2.20636092e-02f, 6.15739040e-02f,
  4.87587750e-02f, 4.54409793e-02f, -7.96194654e-03f, 6.54349625e-02f, -7.36273900e-02f, -2.30135825e-02f, 9.38021764e-02f, -3.14992368e-02f, -2.16643941e-02f, 6.01258576e-02f,
  1.43783391e-01f, 3.27540338e-01f, 1.11497156e-02f, -5.91530651e-03f, 6.20445274e-02f, 2.10909359e-03f, 1.82471275e-02f, 8.64637047e-02f, 1.00668967e-01f, 8.08308832e-03f,
  -1.69864539e-02f, -5.59494868e-02f, -5.19187599e-02f, 7.54912272e-02f, -1.94607507e-02f, 8.86306763e-02f, 8.10363144e-02f, 2.61768270e-02f, 8.75606667e-03f, 1.44952446e-01f,
  8.03272128e-02f, -1.20065272e-01f, -3.51966242e-03f, -1.09713919e-01f, -1.19927162e-02f, 6.33966550e-02f, 1.01351179e-02f, 7.28437006e-02f, 8.68165717e-02f, 4.54421155e-02f,
  -3.58684361e-01f, 8.77472013e-02f, -2.51255274e-01f, 1.06703967e-01f, -1.58665836e-01f, -1.40631512e-01f, -4.13294472e-02f, -7.60717690e-02f, -1.06487915e-01f, 2.66810417e-01f,
  2.05618143e-01f, -9.87121388e-02f, 1.44761065e-02f, 3.84645313e-01f, -6.04871325e-02f, 1.23947613e-01f, 2.94815063e-01f, 1.03270069e-01f, -4.53733690e-02f, -6.38373792e-02f,
  -1.52669530e-02f, 2.00446501e-01f, 1.44994482e-01f, 1.64480396e-02f, 8.77556503e-02f, -2.88568307e-02f, 1.61657393e-01f, -1.72897846e-01f, 1.02315381e-01f, 4.41881903e-02f,
  -3.51382494e-02f, -7.60919377e-02f, -1.21272936e-01f, -6.14011139e-02f, -1.38400206e-02f, -8.67732093e-02f, -1.05650313e-01f, 1.17435707e-02f, 1.31799430e-02f, -3.82056758e-02f,
  -1.15374081e-01f, -7.95363486e-02f, -5.44077791e-02f, -4.79225889e-02f, 9.42243962e-04f, -2.99298763e-02f, 4.07859907e-02f, -4.40257452e-02f, 1.24501111e-02f, -7.91415125e-02f,
  -6.29279688e-02f, 7.75835589e-02f, 8.86808932e-02f, -9.61760059e-03f, 5.47629148e-02f, 2.00866703e-02f, 7.55179226e-02f, 2.53762258e-03f, -6.74409978e-03f, -5.97657971e-02f,
  3.19404677e-02f, 8.26203031e-04f, -1.65801421e-02f, -4.24863249e-02f, -8.66743699e-02f, 6.00972697e-02f, 8.23100358e-02f, 2.35807020e-02f, -3.14354338e-03f, -1.75505877e-02f,
  -7.33728856e-02f, -5.39670736e-02f, -6.36174977e-02f, 2.56340932e-02f, -2.77801361e-02f, 2.44031772e-02f, -2.76654563e-03f, 4.19134423e-02f, -3.84579599e-02f, 6.99240044e-02f,
  5.68580329e-02f, -9.08483416e-02f, -2.09115390e-02f, 2.82798745e-02f, 5.03205508e-02f, -4.56786007e-02f, -2.83601806e-02f, 2.83937696e-02f, 1.57824103e-02f, 2.64644995e-02f,
  -9.79764387e-02f, -1.05266638e-01f, -8.80325586e-02f, -1.21119330e-02f, -6.33347109e-02f, -1.86954755e-02f, -1.91138461e-02f, 3.16791609e-02f, -5.67412972e-02f, -1.31008640e-01f,
  -7.23622069e-02f, 2.85382867e-02f, 2.66268617e-03f, 7.61125460e-02f, 7.06770411e-03f, -3.79223973e-02f, 3.49950641e-02f, 4.63937223e-02f, -2.25793608e-02f, 3.19188610e-02f,
  -3.91214639e-02f, -6.67762682e-02f, 1.89126916e-02f, 2.82454602e-02f, 3.49539407e-02f, 1.86443073e-03f, -8.73360261e-02f, -8.56516734e-02f, -2.09342744e-02f, 1.42239658e-02f,
  3.24334912e-02f, -2.42134437e-01f, -4.23717685e-02f, -7.48334825e-02f, -2.06907302e-01f, 4.78444528e-03f, 1.95736200e-01f, -2.53812850e-01f, -1.73881769e-01f, -1.74234598e-03f,
  2.59205308e-02f, 6.52316734e-02f, 2.90235937e-01f, -8.17202479e-02f, 1.95853636e-01f, 2.11950272e-01f, -8.77268054e-03f, 2.75104288e-02f, -1.16406403e-01f, -1.70481265e-01f,
  -1.52029458e-03f, -7.20229968e-02f, 5.84281199e-02f, -2.56274581e-01f, -8.87222365e-02f, -1.71429574e-01f, 5.16915135e-02f, 3.82190682e-02f, -1.78336397e-01f, 2.10989341e-02f,
  -1.44058630e-01f, -1.89699426e-01f, -4.09422182e-02f, -1.19074300e-01f, -1.64618846e-02f, -1.08922571e-02f, 7.91735798e-02f, 6.34612069e-02f, 7.15871304e-02f, 1.97350257e-03f,
  6.09691925e-02f, -9.13849548e-02f, -1.52945831e-01f, -7.75875757e-03f, -1.12918124e-01f, -1.45992056e-01f, -5.17487191e-02f, 5.71618974e-02f, -5.27150370e-02f, 3.51850921e-03f,
  -4.11584936e-02f, 5.46076670e-02f, -7.20199943e-02f, 3.64928991e-02f, -3.82571705e-02f, -2.08909307e-02f, 4.02846299e-02f, 1.12675451e-01f, 2.98685618e-02f, -7.99217671e-02f,
  6.17536996e-03f, 9.09607857e-02f, 5.55028245e-02f, -4.76209596e-02f, 5.68787307e-02f, -1.60667580e-02f, -2.70298123e-02f, -5.29571297e-03f, -3.80229391e-02f, 6.02677017e-02f,
  3.79459299e-02f, 6.79792315e-02f, 5.58235049e-02f, -1.85377114e-02f, 4.89781797e-03f, -1.12512084e-02f, -3.74091160e-03f, 2.84579005e-02f, 1.11892959e-02f, 2.74113063e-02f,
  -6.23024739e-02f, 3.20092365e-02f, 7.33917430e-02f, 6.38396712e-03f, -5.05465046e-02f, 3.80675454e-04f, 2.45165713e-02f, 4.77816537e-02f, 2.71582808e-02f, 1.14665955e-01f,
  -1.03676632e-01f, -1.28314018e-01f, -6.19485565e-02f, 2.35545859e-02f, -2.85792481e-02f, -2.37558205e-02f, -2.51979083e-02f, -4.21670973e-02f, 9.40292783e-04f, -1.12297358e-02f,
  -2.42451811e-03f, 1.05741635e-01f, -5.57935499e-02f, 6.48867190e-02f, -1.34151857e-02f, -1.18588647e-02f, -2.78851371e-02f, -4.37664948e-02f, -7.75996372e-02f, -2.62479461e-03f,
  -2.00825930e-02f, -6.19623847e-02f, 1.10739611e-01f, -9.65062436e-03f, -2.24145949e-02f, -3.96360047e-02f, -2.69571915e-02f, -4.04910296e-02f, 5.32184951e-02f, -4.66386676e-02f,
  2.63277572e-02f, 1.01362079e-01f, 4.65056747e-02f, -1.15298428e-01f, -1.34138346e-01f, 1.26202861e-02f, -3.84903979e-03f, -3.58900726e-02f, -9.99461301e-03f, 8.91018659e-02f,
  -7.11216629e-02f, 7.28031099e-02f, 1.01000611e-02f, -9.16715562e-02f, 9.62549970e-02f, 3.89943458e-02f, 1.27378985e-01f, 9.56443101e-02f, -6.67461827e-02f, -7.98086673e-02f,
  -8.42163786e-02f, -6.55204430e-02f, 3.81316803e-02f, -6.89158961e-02f, -1.64240822e-01f, -1.02896377e-01f, -9.54223499e-02f, 4.95539466e-03f, -1.00817330e-01f, -4.80111875e-02f,
  -6.60707578e-02f, -1.18695106e-02f, 7.51789659e-03f, -4.46967036e-02f, -4.28748839e-02f, 2.26527061e-02f, -2.09853575e-02f, -1.03867888e-01f, -2.23468654e-02f, 8.15981776e-02f,
  5.88656254e-02f, 4.09336686e-02f, 6.93246871e-02f, -1.55015104e-02f, 1.69168804e-02f, -7.66699784e-04f, -9.55602750e-02f, 8.65904894e-03f, 1.44161591e-02f, 2.99268179e-02f,
  1.22050270e-02f, 4.34919968e-02f, -8.88874158e-02f, 8.57283473e-02f, -1.51252013e-03f, -7.58554637e-02f, -2.50236858e-02f, -1.94939040e-02f, 7.79421702e-02f, 5.03932610e-02f,
  -5.14090136e-02f, -4.93371710e-02f, -5.34745753e-02f, -1.19337782e-01f, -6.90141972e-03f, -5.88443801e-02f, -3.63422967e-02f, -3.91721949e-02f, -2.80278716e-02f, -1.04764082e-01f,
  -8.75414610e-02f, 4.41133156e-02f, 5.17042018e-02f, 9.94758010e-02f, -4.82424088e-02f, -2.27306294e-03f, -7.75160193e-02f, 5.76555543e-02f, -6.75252452e-02f, 1.97719298e-02f,
  4.94827703e-02f, 7.46024698e-02f, 1.17363837e-02f, 4.94527481e-02f, -7.77174765e-03f, -7.90168270e-02f, -1.53190980e-03f, 6.07440770e-02f, 1.34167038e-02f, 7.32656419e-02f,
  7.69296438e-02f, 4.74873483e-02f, 5.09426333e-02f, -7.58027360e-02f, -9.64445435e-03f, -6.36441112e-02f, -2.93902531e-02f, -4.21512015e-02f, 1.22623019e-01f, -5.04137017e-02f,
  5.64188510e-02f, -6.64457157e-02f, 3.94840119e-03f, 3.54490392e-02f, 4.62574549e-02f, 5.80443554e-02f, 7.54274242e-03f, 3.34208668e-03f, 5.95780183e-03f, -7.82187656e-02f,
  5.59459291e-02f, -8.87392908e-02f, -2.02482417e-02f, -5.97810410e-02f, 4.61800285e-02f, 1.12849381e-03f, 3.16054001e-03f, -7.39311129e-02f, 6.01690710e-02f, 3.15945670e-02f,
  -1.53631344e-01f, 1.63799435e-01f, -1.30511448e-01f, 5.51356748e-02f, 1.21945314e-01f, 2.33619347e-01f, 8.55725706e-02f, 4.59911153e-02f, 2.19675303e-01f, 1.52420789e-01f,
  -3.17120515e-02f, 5.86306453e-02f, 3.71044911e-02f, -4.83600944e-02f, -7.37799555e-02f, 5.55227371e-03f, 1.22200698e-01f, 1.46972805e-01f, 7.26828799e-02f, 5.25378771e-02f,
  -1.25826344e-01f, -6.94223642e-02f, -2.95552790e-01f, 2.74096839e-02f, -4.03121971e-02f, 3.46904136e-02f, -7.97899738e-02f, -3.33204456e-02f, 2.97551770e-02f, 1.01729870e-01f,
  -1.68976767e-04f, 4.27267663e-02f, -1.03169128e-01f, 4.56426069e-02f, 3.04818265e-02f, -2.12651379e-02f, 3.14083397e-02f, -9.11975875e-02f, 4.30288091e-02f, -5.37604280e-02f,
  3.17907631e-02f, -4.70402576e-02f, -4.27562855e-02f, -5.41026480e-02f, 3.24113891e-02f, -2.37122066e-02f, -1.90650877e-02f, -1.15291245e-01f, 2.84723490e-02f, -1.96309462e-02f,
  -6.46571219e-02f, 6.26166314e-02f, -2.11199783e-02f, -3.02901547e-02f, -8.92410949e-02f, 3.62871774e-02f, 1.20579526e-01f, 3.53008583e-02f, -1.53103992e-02f, 1.28739029e-01f,
  1.11882873e-01f, 1.62689403e-01f, 4.71449718e-02f, 1.88301485e-02f, -5.97278103e-02f, -8.60443339e-02f, 1.21667786e-02f, -5.90389483e-02f, 1.99444704e-02f, 1.20514743e-02f,
  3.94466743e-02f, 4.48530540e-02f, 3.65470722e-02f, 1.53631894e-02f, 8.45609456e-02f, -3.41801047e-02f, -2.11974196e-02f, -2.84507256e-02f, -1.06253773e-02f, -1.12383012e-02f,
  5.50587848e-02f, -1.38244387e-02f, -6.48308024e-02f, 4.59694192e-02f, 7.58646205e-02f, -9.18206647e-02f, -1.25075562e-03f, -2.04375722e-02f, -6.62662834e-02f, 6.01353496e-02f,
  1.80456698e-01f, 2.69754022e-01f, -5.45470119e-02f, -5.64585254e-03f, 1.06406845e-02f, -1.67823453e-02f, -7.27769872e-03f, -1.77755430e-02f, 3.57780308e-02f, 9.22007710e-02f,
  3.51901650e-02f, 3.47321369e-02f, -1.62356012e-02f, -5.14190318e-03f, -4.43848968e-02f, 2.37130299e-02f, 3.54503207e-02f, 9.71651375e-02f, 8.60890150e-02f, 6.02725185e-02f,
  -2.10274626e-02f, 1.37019470e-01f, 2.06140801e-02f, -2.88013276e-02f, 4.37935628e-02f, 5.62227555e-02f, 3.02995965e-02f, -4.08027768e-02f, 3.98134962e-02f, -8.79541598e-03f,
  -1.84777141e-01f, -4.06710118e-01f, -2.50520796e-01f, -2.69368701e-02f, 5.60841486e-02f, 1.91712424e-01f, 2.45099030e-02f, -1.17279068e-01f, -4.01522994e-01f, -5.75213730e-02f,
  2.77376603e-02f, -2.19915465e-01f, -2.23028436e-01f, -7.79254213e-02f, 2.96694716e-03f, -2.37647712e-01f, 1.14235610e-01f, 4.94519845e-02f, -2.29277492e-01f, 7.10793713e-04f,
  -2.47696228e-02f, 1.47789076e-01f, -3.34140919e-02f, 2.27912188e-01f, -4.03471896e-03f, 1.12450629e-01f, 3.70492101e-01f, 1.33351237e-01f, 3.87223035e-01f, 1.70077607e-01f,
  -6.51324093e-02f, -1.27068058e-01f, -1.11692563e-01f, 2.32849587e-02f, 1.85793247e-02f, 1.31378919e-01f, 1.31957650e-01f, 1.02424338e-01f, 1.08445197e-01f, -3.44792604e-02f,
  7.98474625e-02f, 1.25593739e-02f, 8.44975933e-03f, -4.89776321e-02f, -4.88502253e-03f, -3.78027372e-02f, 5.32009592e-03f, -7.68290535e-02f, -4.95864600e-02f, -8.13316777e-02f,
  -1.17640451e-01f, 1.07007800e-02f, 4.32453379e-02f, 2.34057643e-02f, -7.93069303e-02f, -5.45555800e-02f, 1.08083941e-01f, 5.29479459e-02f, -4.83843535e-02f, -5.77986911e-02f,
  3.24674509e-02f, 7.44592324e-02f, -1.26056090e-01f, 3.13938484e-02f, -2.43898928e-02f, 5.32556660e-02f, 4.93939221e-02f, 2.18234584e-02f, -7.37570450e-02f, 1.68491919e-02f,
  6.87032267e-02f, -3.47278193e-02f, 1.82540100e-02f, 7.60687701e-03f, 4.36800830e-02f, -4.66154255e-02f, 1.03390031e-01f, -1.03142327e-02f, 4.81947549e-02f, 6.67179003e-03f,
  -4.39925864e-02f, 8.32547769e-02f, 6.89517334e-02f, 1.09218441e-01f, -7.52040744e-02f, -2.57753488e-02f, 5.06310873e-02f, -9.45117399e-02f, 4.23834473e-03f, -1.00543918e-02f,
  8.86531621e-02f, -1.61318367e-05f, -1.02038763e-01f, 3.01001463e-02f, 6.15861907e-04f, -3.76012400e-02f, -5.80818541e-02f, -1.32042011e-02f, 1.43199805e-02f, -7.04125967e-03f,
  1.17763028e-01f, 1.36253223e-01f, -3.49835269e-02f, -4.35429700e-02f, 5.33467978e-02f, 6.94845319e-02f, -8.03763804e-04f, 1.30428433e-01f, 2.19632424e-02f, 7.28502078e-03f,
  5.31499609e-02f, 6.04055710e-02f, -6.81103840e-02f, -2.28877664e-02f, 1.22341476e-01f, 1.17058344e-01f, 6.62289262e-02f, 1.75784659e-02f, 9.84931439e-02f, 6.29436746e-02f,
  -6.17914200e-01f, 2.86457688e-01f, -3.26495059e-02f, -1.39014229e-01f, -1.76070482e-01f, 9.41512957e-02f, 2.93148644e-02f, 7.61603713e-02f, 1.18085211e-02f, 2.91111827e-01f,
  1.11610204e-01f, -1.55083045e-01f, 2.46811867e-01f, 1.43511042e-01f, -3.01735669e-01f, 2.58715242e-01f, 5.90331666e-02f, 9.44256969e-03f, 1.66537128e-02f, -1.63672552e-01f,
  -1.53473347e-01f, -6.77337423e-02f, 7.04383999e-02f, 7.51408413e-02f, -1.92281246e-01f, -1.85906067e-01f, -4.19648886e-02f, 1.04434773e-01f, -5.80799729e-02f, -4.32133153e-02f,
  -1.04055695e-01f, -8.77014995e-02f, -9.41642895e-02f, -8.83127749e-02f, -1.43027604e-01f, -1.03621341e-01f, -5.22995777e-02f, -2.69540772e-02f, -2.56413538e-02f, 4.79641929e-02f,
  -1.18144035e-01f, -6.21344224e-02f, -3.15107107e-02f, -1.56724192e-02f, -7.01197609e-02f, 4.12037633e-02f, -3.42857949e-02f, 7.24453628e-02f, -1.61090437e-02f, 5.54126389e-02f,
  1.61403660e-02f, 1.74177606e-02f, 5.06850667e-02f, 6.61354214e-02f, -9.09024850e-03f, 1.71587151e-02f, -4.92735915e-02f, -1.68472268e-02f, -5.12517579e-02f, -3.22049414e-03f,
  3.33782136e-02f, 3.62181081e-03f, -1.12696234e-02f, 3.67018692e-02f, -4.34649140e-02f, 1.18172355e-02f, 6.25216169e-03f, -2.58336719e-02f, 3.72699872e-02f, -2.74342261e-02f,
  -5.24986275e-02f, 4.01392914e-02f, -7.03074923e-03f, -4.22884002e-02f, -4.32702601e-02f, 5.28549142e-02f, -3.01932134e-02f, -2.37762518e-02f, 3.32013443e-02f, -6.11365288e-02f,
  5.61427027e-02f, 3.42269824e-03f, 6.71181083e-02f, -6.24224357e-02f, -2.00231560e-02f, -2.90268334e-03f, -5.81553802e-02f, -5.31238504e-02f, -3.25830989e-02f, 1.05384849e-02f,
  -1.99565113e-01f, -1.44240499e-01f, 3.00032161e-02f, -1.26094580e-01f, -4.83922996e-02f, -2.17881668e-02f, -4.21890430e-02f, -3.26396041e-02f, -1.24843933e-01f, -2.22661570e-02f,
  1.52287465e-02f, -2.51303986e-02f, -7.04797208e-02f, 3.15371677e-02f, 6.61884695e-02f, 1.60292909e-02f, -1.73987933e-02f, -6.77760839e-02f, -5.42246439e-02f, -7.36216456e-02f,
  -4.80631813e-02f, 4.70998028e-04f, 1.42557779e-03f, -5.72242737e-02f, 4.69357185e-02f, -4.20468897e-02f, -1.62518863e-02f, -2.63115652e-02f, 2.00689808e-02f, 7.45966956e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.80578434e-02f, 2.15680450e-02f, 1.36383444e-01f, 1.96478859e-01f, 4.64144871e-02f, 2.71188736e-01f, 2.69976348e-01f, 1.41071215e-01f, 1.29173964e-01f, 1.44236907e-01f,
  1.58613428e-01f, 2.20096365e-01f, -1.50000528e-02f, 1.97008148e-01f, 1.43923489e-02f, 1.49883360e-01f, 1.96055159e-01f, 2.27017224e-01f, 1.95063248e-01f, 3.02328658e-03f,
  2.04180896e-01f, 1.52367115e-01f, 1.24970436e-01f, 1.05209298e-01f, 2.59856343e-01f, 2.07098231e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  1.52407959e-02f, -1.62338912e-01f, 1.32572889e-01f, 9.01718661e-02f, -3.42027955e-02f, -3.24438065e-01f, -3.32086533e-01f, 3.75048965e-02f, 1.48761824e-01f, 6.29383475e-02f,
  1.40423477e-01f, -1.98222071e-01f, 1.43992245e-01f, -3.52061987e-01f, -4.03394014e-01f, -3.38563353e-01f, -1.42970189e-01f, -2.57222690e-02f, -1.30859643e-01f, -1.22180507e-01f,
  -3.90060365e-01f, 1.09344184e-01f, 3.52057993e-01f, 2.39506841e-01f, 2.51129270e-01f, 3.97046715e-01f, 1.85179412e-01f, 2.70711929e-01f, -3.51125240e-01f, -2.52764486e-02f,
  5.07991314e-01f, 1.37090860e-02f, 5.62306404e-01f, -4.59625542e-01f, 4.10416752e-01f, 4.23201799e-01f, -5.99894710e-02f, -1.64446160e-01f, -7.87203759e-02f, 1.69001818e-02f,
  -1.28821004e-02f, -1.03829294e-01f, -1.89812109e-01f, 2.44330671e-02f, 6.62511587e-02f, -7.26838186e-02f, 1.50759956e-02f, -2.59834260e-01f, -4.75802757e-02f, -2.31999293e-01f,
  9.47633088e-02f, -6.63089333e-04f, -7.78397396e-02f, -2.02693909e-01f, -2.22683236e-01f, -2.98635453e-01f, -1.76252022e-01f, -1.32191598e-01f, 7.06816852e-01f, 2.57667094e-01f,
  8.50175321e-02f, -2.54039895e-02f, 4.08124849e-02f, 6.50580585e-01f, 1.23097688e-01f, 3.33707601e-01f, -2.37294018e-01f, -5.37146740e-02f, 3.44212323e-01f, 8.03626180e-02f,
  -3.07759792e-01f, -1.48264408e-01f, -8.60741884e-02f, 4.49433327e-02f, -3.31930637e-01f, -4.17028099e-01f, -2.18099609e-01f, 3.53345454e-01f, 1.09829627e-01f, -1.69605464e-01f,
  1.47409951e-02f, 6.37140125e-02f, 2.65514284e-01f, 3.70533794e-01f, 1.31634837e-02f, -3.91690254e-01f, 3.01365376e-01f, 1.62087858e-01f, 1.86342642e-01f, 2.94579357e-01f,
  2.59977639e-01f, 5.66518307e-02f, -5.45753062e-01f, -3.97096008e-01f, 4.74695325e-01f, -4.27288741e-01f, 4.83810097e-01f, 2.84978569e-01f, 3.10903460e-01f, 3.49904805e-01f,
  4.41941440e-01f, 1.86723229e-02f, -3.80447656e-02f, -2.04888538e-01f, 1.20107919e-01f, 3.75043005e-01f, -1.80116132e-01f, -8.39441866e-02f, -2.10665852e-01f, -4.11141329e-02f,
  1.50675461e-01f, -2.08057106e-01f, -3.07795908e-02f, 1.66412536e-02f, 1.78802893e-01f, -1.09972380e-01f, 6.37855902e-02f, 8.00145745e-01f, -1.26759648e-01f, -2.55120277e-01f,
  1.34478183e-02f, -9.25106779e-02f, 1.27265111e-01f, -1.25243440e-01f, -1.92512143e-02f, 1.89411476e-01f, 1.36896493e-02f, -2.96593636e-01f, -3.70914787e-01f, -2.02455118e-01f,
  -2.73613960e-01f, -3.72391380e-02f, -2.36982927e-01f, 1.04672782e-01f, 1.48040550e-02f, 6.45177588e-02f, 8.54734797e-03f, 4.35011387e-02f, 6.88026100e-02f, -2.08508670e-01f,
  9.86561999e-02f, -6.04641736e-02f, 1.33858211e-02f, -5.30263111e-02f, 6.06484599e-02f, -4.02709506e-02f, -1.51320174e-01f, 2.02305973e-01f, 3.95767599e-01f, -2.98245639e-01f,
  -3.21873464e-02f, -4.02515501e-01f, -1.37029991e-01f, 2.97753662e-02f, 9.53676328e-02f, 2.38410041e-01f, 3.81093800e-01f, 3.81142139e-01f, 3.80160898e-01f, -1.91208690e-01f,
  -5.71186125e-01f, 3.10665190e-01f, 7.31752254e-03f, -2.19616458e-01f, 1.94951057e-01f, 1.48735583e-01f, -1.50223911e-01f, -9.08885151e-02f, -2.74681747e-01f, 7.89591730e-01f,
  -2.07170501e-01f, 1.07920896e-02f, -2.71731317e-01f, -1.90203175e-01f, 5.76733500e-02f, -1.13229632e-01f, -1.59253240e-01f, -1.71259940e-01f, -1.95913255e-01f, -1.75229445e-01f,
  -2.09234118e-01f, 2.42507622e-01f, -1.80949479e-01f, -1.92544341e-01f, 6.32328764e-02f, 1.33644074e-01f, 1.71472743e-01f, -1.99744359e-01f, -1.46760732e-01f, -1.24759115e-01f,
  6.90231144e-01f, -1.84428796e-01f, -4.04663458e-02f, -1.15200594e-01f, 6.15596287e-02f, -2.95928061e-01f, 1.80893347e-01f, -7.72467926e-02f, -1.20513007e-01f, -1.18973747e-01f,
  -2.67383963e-01f, 1.68488398e-02f, 4.38854583e-02f, -2.81101376e-01f, -2.12178472e-02f, -3.15692902e-01f, 1.05660848e-01f, -2.49938071e-01f, 8.99908468e-02f, 3.39457132e-02f,
  -1.32216945e-01f, -2.98297673e-01f, -1.75477535e-01f, -8.92453417e-02f, -3.07776600e-01f, 1.23019293e-01f, 3.40200424e-01f, 1.66248918e-01f, -3.11149776e-01f, -1.60151660e-01f,
  -1.45977691e-01f, -8.38483274e-02f, -2.08603874e-01f, 2.56677300e-01f, 3.39006364e-01f, -2.04335541e-01f, -4.65217441e-01f, 1.26485974e-01f, 5.05979180e-01f, 4.03753310e-01f,
  -2.72138327e-01f, 1.52461573e-01f, 6.89074695e-01f, -3.40617776e-01f, 1.80234015e-01f, 2.33768120e-01f, -2.27317005e-01f, 2.74033517e-01f, -7.93044195e-02f, 1.54596582e-01f,
  -2.92887181e-01f, -2.99616456e-01f, -1.51540628e-02f, 1.27958640e-01f, -4.94960584e-02f, -1.91563815e-01f, 6.13369226e-01f, -9.95350182e-02f, 2.00113252e-01f, -1.87037423e-01f,
  -5.11973212e-03f, -2.88389295e-01f, -1.69578329e-01f, 1.01659618e-01f, -3.84984344e-01f, 3.98388773e-01f, -2.08741874e-02f, 1.13238208e-01f, -2.28147209e-01f, 3.66455287e-01f,
  -4.01881598e-02f, -3.18248808e-01f, -2.24531218e-02f, 4.03144449e-01f, 6.60292655e-02f, 2.04719573e-01f, 2.12965950e-01f, 2.08899111e-01f, -1.50032908e-01f, 3.63945931e-01f,
  -2.81804632e-02f, 4.75409269e-01f, 2.95456052e-01f, 6.61072955e-02f, 1.76148921e-01f, -2.65918877e-02f, 3.86184864e-02f, 4.49205160e-01f, -3.56246889e-01f, 3.44673783e-01f,
  7.16765940e-01f, 1.29858866e-01f, -2.29756430e-01f, -3.35336059e-01f, 3.27518284e-01f, 4.76359725e-01f, -2.12137789e-01f, 3.35758924e-01f, -1.17301084e-01f, -4.64468598e-01f,
  -3.71814758e-01f, 4.49374206e-02f, -4.13808882e-01f, 2.32126281e-01f, -9.27091688e-02f, -7.87836686e-02f, -2.84667701e-01f, -1.25024334e-01f, 2.15306636e-02f, 4.96829838e-01f,
  -1.13157392e-01f, -9.24000368e-02f, 2.71411333e-02f, 5.63306883e-02f, -2.14741915e-01f, -1.08010948e-01f, -7.15820417e-02f, 7.55607545e-01f, 1.70823876e-02f, -1.00186974e-01f,
  -9.34977084e-02f, -1.99151918e-01f, 7.61899129e-02f, -3.10933851e-02f, -6.88163564e-02f, -1.44142210e-01f, 6.54124394e-02f, -1.36566043e-01f, -8.90274793e-02f, 4.17111188e-01f,
  7.58536682e-02f, 6.32550195e-02f, 1.43133059e-01f, 1.02043524e-01f, 5.46318963e-02f, 1.10004127e-01f, 1.92289144e-01f, -3.37242573e-01f, -1.02559313e-01f, 4.94546145e-01f,
  -1.20611921e-01f, 3.15857828e-01f, 1.33511573e-01f, 3.14528257e-01f, 1.92925092e-02f, 1.00680165e-01f, 1.43583402e-01f, 1.26333565e-01f, -1.54583097e-01f, -5.13499618e-01f,
  7.50947837e-03f, 4.82127577e-01f, 4.67994243e-01f, 3.20526630e-01f, -4.17145304e-02f, 1.67882234e-01f, 6.36333406e-01f, -2.84727514e-01f, -1.43523917e-01f, -5.33478677e-01f,
  -1.07034229e-01f, -3.67596239e-01f, -1.14692472e-01f, 2.41242629e-02f, 4.13556427e-01f, -9.54927653e-02f, -3.90530378e-01f, -5.35870612e-01f, -7.91919790e-03f, 5.81768863e-02f,
  -2.93426275e-01f, -2.51662046e-01f, 3.57323363e-02f, -2.95055568e-01f, 4.61658150e-01f, 2.56306469e-01f, -8.33969787e-02f, 2.01947451e-01f, -9.33094323e-02f, 2.09573567e-01f,
  -9.16728303e-02f, -9.79958698e-02f, 3.04676592e-01f, -1.14414068e-02f, -2.68248707e-01f, 5.17856516e-02f, 2.34956183e-02f, -1.24772809e-01f, -3.09652060e-01f, -7.82649890e-02f,
  2.61285245e-01f, 5.30028999e-01f, -1.89838007e-01f, 4.81650867e-02f, 2.71632999e-01f, 2.38183588e-01f, 1.46577045e-01f, 1.39523223e-01f, 1.33559987e-01f, 8.25903565e-02f,
  2.71154135e-01f, 1.66281119e-01f, 7.84776285e-02f, -4.80852991e-01f, 3.36816669e-01f, 4.06610966e-01f, 2.26518214e-01f, -5.90949893e-01f, 2.99438059e-01f, 1.87752515e-01f,
  -1.01758890e-01f, -1.38152853e-01f, -3.08887251e-02f, 3.38623911e-01f, 2.08348706e-01f, -4.82750803e-01f, -1.04970396e-01f, 1.34161234e-01f, -5.47212064e-01f, 2.42696837e-01f,
  3.23713124e-01f, -2.57270515e-01f, 5.27899683e-01f, -4.75780994e-01f, 2.84629036e-02f, 1.18212081e-01f, -5.60263038e-01f, 2.10376248e-01f, -1.69273064e-01f, -4.76418555e-01f,
  -2.61804372e-01f, 2.49207154e-01f, -1.98571965e-01f, 4.75950837e-02f, -2.23894820e-01f, -2.90063590e-01f, -1.53422475e-01f, 1.29765123e-01f, -1.74204186e-01f, -3.06432813e-01f,
  -1.35045812e-01f, -1.27290070e-01f, -3.34915332e-02f, 2.64863640e-01f, 7.32996389e-02f, -1.71557859e-01f, -7.55635053e-02f, 1.65035799e-01f, -8.71588737e-02f, 7.51419425e-01f,
  1.63714230e-01f, -1.48756132e-01f, -2.65805304e-01f, -1.90526381e-01f, -1.89682141e-01f, -2.06936002e-01f, -2.97825664e-01f, -2.48347074e-01f, -1.61518693e-01f, -6.05039783e-02f,
  -1.51189476e-01f, -2.42075939e-02f, -3.10202122e-01f, 6.23226091e-02f, -1.59705937e-01f, 5.10358475e-02f, -2.41022095e-01f, -8.56754258e-02f, -2.30413936e-02f, -1.62654281e-01f,
  -2.22297654e-01f, -7.23389015e-02f, -1.87438652e-02f, -2.43495882e-01f, -4.45935540e-02f, -9.30258706e-02f, -2.17974633e-01f, -3.14378470e-01f, 2.85097510e-01f, 2.35372990e-01f,
  2.62434185e-01f, -9.92176458e-02f, -8.72571990e-02f, -3.20634812e-01f, 9.88508537e-02f, 5.65037280e-02f, 3.66601586e-01f, 1.41950443e-01f, -3.41482103e-01f, -1.55536860e-01f,
  4.78776209e-02f, 2.85314471e-02f, -3.65013510e-01f, 1.75312266e-01f, 3.70240748e-01f, -3.60847682e-01f, 7.32290089e-01f, 2.05969423e-01f, 6.24796033e-01f, -4.46932167e-02f,
  2.72553384e-01f, -1.82148859e-01f, 1.69429928e-01f, -1.49699926e-01f, 5.38275205e-03f, 1.03613466e-01f, -1.13484025e-01f, 5.51961139e-02f, -1.03296138e-01f, -8.15417394e-02f,
  -1.33780718e-01f, -1.21725291e-01f, 2.00633392e-01f, -3.87012139e-02f, -1.27380446e-01f, -1.97263658e-02f, 4.20723073e-02f, 2.87157089e-01f, 1.04057029e-01f, -2.55887788e-02f,
  -2.19109982e-01f, -1.04309842e-02f, -1.30806580e-01f, 9.51264799e-03f, -1.17609426e-01f, 5.69867529e-02f, -1.82894245e-01f, -2.25611165e-01f, -9.46369022e-02f, 8.19232911e-02f,
  -2.79816478e-01f, -1.45649850e-01f, -8.98134485e-02f, -8.17883834e-02f, -4.41565029e-02f, 7.66987875e-02f, -6.48814365e-02f, 7.50768930e-02f, -4.80586551e-02f, 5.59914559e-02f,
  1.06821232e-01f, 8.86533558e-02f, 3.13290507e-01f, -2.17099160e-01f, -3.36916387e-01f, -2.28798062e-01f, -4.25641894e-01f, -4.40274507e-01f, -1.83487758e-01f, 3.16667795e-01f,
  -4.36292917e-01f, -1.43791288e-01f, 2.34827414e-01f, -6.03853054e-02f, 1.01607427e-01f, 1.89173818e-01f, -9.49151814e-03f, -1.22914508e-01f, -1.78006273e-02f, -2.17097372e-01f,
  -2.34641477e-01f, -2.06679314e-01f, -1.43665209e-01f, -1.46644890e-01f, 4.23217684e-01f, -2.63129354e-01f, -4.77811992e-02f, 7.71047026e-02f, 6.88177049e-02f, -1.45239338e-01f,
  -1.12638503e-01f, 2.43929207e-01f, -1.80477023e-01f, -1.48797080e-01f, 3.31286013e-01f, -2.49803811e-01f, -2.43149415e-01f, -1.81684181e-01f, -1.29422486e-01f, 1.00830901e+00f,
  1.28150865e-01f, -6.10442534e-02f, 1.34196496e-02f, -1.79694697e-01f, 5.77149652e-02f, -1.87755242e-01f, -5.88651076e-02f, 8.33110064e-02f, 2.05791593e-01f, -1.58576831e-01f,
  -1.02926448e-01f, 2.12660164e-01f, 6.75940216e-02f, 1.33241832e-01f, 2.64039069e-01f, -8.36638957e-02f, 8.64996761e-03f, 8.54779556e-02f, -6.70317858e-02f, -3.78059775e-01f,
  -1.19837321e-01f, -2.79684104e-02f, 8.67270753e-02f, 1.89759165e-01f, 1.23465739e-01f, 2.95152277e-01f, -1.68033838e-01f, 3.62120479e-01f, 5.13948619e-01f, 3.42933208e-01f,
  1.92750767e-01f, -5.93471229e-01f, -3.09911042e-01f, 1.85071081e-01f, 2.57942379e-01f, 6.31732821e-01f, 3.88678193e-01f, 4.27028865e-01f, -5.72058439e-01f, -4.31959301e-01f,
  2.99962848e-01f, -3.67345005e-01f, -1.08469455e-02f, -2.49008492e-01f, 1.83223113e-01f, -2.00586468e-01f, -1.88306049e-01f, -1.01983979e-01f, -3.83719779e-03f, 3.33070993e-01f,
  2.18712300e-01f, -2.27850944e-01f, -9.72252637e-02f, -1.66567430e-01f, -1.69434935e-01f, 2.72076577e-02f, 1.83988154e-01f, -2.93190420e-01f, -1.29237741e-01f, -1.88479602e-01f,
  -1.33322820e-01f, 3.20351839e-01f, -2.68807441e-01f, -5.31454310e-02f, -2.30909020e-01f, 5.47959089e-01f, 1.95633583e-02f, -2.17947438e-01f, 1.54224381e-01f, -2.77095258e-01f,
  1.58060685e-01f, 2.82017440e-02f, -4.84639332e-02f, -1.66433766e-01f, 5.15523292e-02f, 1.23469338e-01f, 9.77395028e-02f, -1.12838678e-01f, 5.40606864e-02f, -3.23944181e-01f,
  1.10935584e-01f, 1.66167662e-01f, -6.08748198e-02f, 1.40011981e-01f, 8.27088133e-02f, 4.80004326e-02f, 7.98387453e-02f, -2.40210205e-01f, -9.31013003e-02f, 3.21450561e-01f,
  -3.31712484e-01f, -1.63173407e-01f, -4.23135370e-01f, -3.19308609e-01f, -1.36453956e-01f, 2.12689247e-02f, -2.45058998e-01f, -3.65823023e-02f, -5.82007885e-01f, 3.49263921e-02f,
  -4.44365770e-01f, 2.27940753e-02f, 1.37976155e-01f, 4.06152785e-01f, -3.30454171e-01f, 1.70066878e-01f, 4.96589452e-01f, 1.81560799e-01f, -2.15814933e-01f, 1.82542000e-02f,
  1.17770873e-01f, 3.05832505e-01f, -1.07990101e-01f, -1.24181233e-01f, -1.81411803e-01f, -2.25530982e-01f, -1.84986800e-01f, 1.69609830e-01f, 4.24498379e-01f, 1.25289351e-01f,
  3.91219705e-02f, -1.19540673e-02f, -1.53294012e-01f, -1.54377088e-01f, 6.19044304e-01f, -3.12139064e-01f, -2.01269180e-01f, -2.45675132e-01f, -1.25240937e-01f, -1.36223972e-01f,
  -8.68704841e-02f, 2.38445863e-01f, 6.59287035e-01f, -1.39314115e-01f, -6.29372448e-02f, 8.22651142e-04f, 1.12294041e-01f, 1.19628973e-01f, 6.76644593e-02f, 3.06860264e-02f,
  6.54096752e-02f, 2.49854669e-01f, 3.88603434e-02f, 3.23355377e-01f, -8.38935450e-02f, -8.17359313e-02f, -5.62540591e-02f, 2.05453113e-01f, 1.45195052e-01f, 9.64284688e-02f,
  -1.16046138e-01f, -1.00754142e-01f, -4.31478135e-02f, -5.18927634e-01f, -5.21988451e-01f, 2.55982459e-01f, -4.14944381e-01f, -6.03314042e-01f, -3.93767416e-01f, -4.17819291e-01f,
  -6.05073869e-02f, -1.50200903e-01f, 1.05997682e-01f, 4.49109674e-01f, -5.46923220e-01f, 1.66717798e-01f, 1.36803821e-01f, 6.95211142e-02f, -1.31434491e-02f, -2.70901978e-01f,
  -4.87043023e-01f, 2.92465836e-01f, -1.96743309e-01f, -1.48635656e-01f, -2.91894879e-02f, 7.41288587e-02f, -1.01399355e-01f, -2.15130299e-01f, 1.34250149e-01f, 4.28949207e-01f,
  -5.92428409e-02f, 2.91516751e-01f, 6.26041114e-01f, -1.82789620e-02f, -3.22675668e-02f, -2.53467470e-01f, -1.24174260e-01f, -9.45969447e-02f, -3.30985844e-01f, 1.47211045e-01f,
  5.35345197e-01f, -9.41937193e-02f, -1.21329881e-01f, -1.27325535e-01f, 3.51912342e-02f, 6.15874678e-02f, -2.05063045e-01f, -2.33173504e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.03583960e-02f, 5.53902648e-02f, -4.92780954e-02f, -8.25965032e-02f, 6.62502050e-02f, 1.05035387e-01f, 6.68005943e-02f, -2.16803864e-01f, 9.51215401e-02f, 1.41457021e-01f,
  -2.41086762e-02f, -7.54237920e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    