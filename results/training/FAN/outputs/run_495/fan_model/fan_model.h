/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.71800375e-01f, 2.31395021e-01f, 2.90305525e-01f, -5.74670583e-02f, -3.67554948e-02f, -3.25781219e-02f, 2.75550317e-02f, 1.64484873e-01f, 2.00785145e-01f, -1.31438747e-01f,
  -9.90767404e-02f, -4.36865427e-02f, 4.03632484e-02f, -2.06536889e-01f, -1.21046714e-01f, 6.81735352e-02f, -9.59221572e-02f, -1.01826131e-01f, 2.69607216e-01f, 1.40703954e-02f,
  4.70192358e-02f, -2.20506400e-01f, 1.46120589e-03f, -7.24331103e-03f, -8.02758485e-02f, 1.85617507e-01f, -2.66704381e-01f, 1.68765813e-01f, -5.75833656e-02f, 6.13605529e-02f,
  -5.52450642e-02f, 1.25105292e-01f, -1.73000619e-02f, 8.93201455e-02f, 3.69208455e-02f, -6.02961378e-03f, -8.07276666e-02f, -5.49919158e-02f, 6.60666302e-02f, -3.18011530e-02f,
  -6.68576434e-02f, -1.15222856e-01f, -7.25982934e-02f, 5.03409305e-04f, 5.99193946e-02f, -1.25325425e-02f, 5.86972618e-03f, 2.25638337e-02f, -1.84327476e-02f, 1.71194617e-02f,
  7.68026486e-02f, -4.28076051e-02f, -2.24429723e-02f, 1.44965146e-02f, 1.30624399e-02f, 3.77035551e-02f, -1.97891388e-02f, 1.06190480e-02f, -5.58735281e-02f, 1.42494207e-02f,
  -7.98988789e-02f, 1.10455744e-01f, -3.61575894e-02f, -2.49661822e-02f, 7.23456666e-02f, -2.92736329e-02f, -3.88246439e-02f, -9.87498164e-02f, 6.46180585e-02f, -1.07466646e-01f,
  2.27096658e-02f, 3.86788626e-03f, 8.49940628e-02f, -3.01727671e-02f, -3.03308433e-03f, 1.56950150e-02f, -1.67001057e-02f, 5.35222106e-02f, 7.98825175e-02f, -1.90495711e-03f,
  -6.92372024e-02f, -1.58420075e-02f, 3.67944682e-04f, -1.78547387e-04f, -1.90126244e-02f, -1.87876038e-02f, 5.25766723e-02f, 5.33376299e-02f, 3.06241624e-02f, -1.46398395e-02f,
  1.23283997e-01f, 3.73055749e-02f, 6.63730279e-02f, -3.71152386e-02f, 2.41794568e-02f, -4.62814569e-02f, 5.62979840e-02f, -3.67458425e-02f, 7.27970079e-02f, -5.20576537e-02f,
  -2.53156479e-02f, -5.14782174e-03f, 4.25161086e-02f, -6.10021800e-02f, 1.85109151e-03f, 3.73586230e-02f, 3.55392471e-02f, 1.12515865e-02f, -2.41510477e-02f, 9.53775458e-03f,
  -1.04411505e-01f, -2.56060939e-02f, -4.22147959e-02f, -1.06657960e-01f, -3.92374657e-02f, 3.77721153e-03f, -9.14550107e-03f, 5.53200208e-02f, -1.55021604e-02f, -1.69973765e-02f,
  2.18788281e-01f, -1.66113541e-01f, -1.52518526e-01f, 2.15401679e-01f, -9.93208066e-02f, 3.81980315e-02f, 1.21994540e-01f, -4.85454164e-02f, 1.22716362e-02f, 1.13655487e-03f,
  1.08225293e-01f, -2.29697123e-01f, -3.38318385e-03f, -5.80157153e-02f, 2.45900676e-01f, 2.85995342e-02f, 1.94081470e-01f, 7.40422383e-02f, -4.00053896e-02f, 4.39632162e-02f,
  8.90040994e-02f, 2.17932705e-02f, -1.54743999e-01f, -1.37866005e-01f, -2.53215581e-01f, -5.58718815e-02f, 2.29603499e-01f, -1.23972066e-01f, 6.94304844e-03f, -4.33939099e-02f,
  6.55783042e-02f, -1.23201095e-01f, -3.04150693e-02f, -1.08575501e-01f, 9.82784703e-02f, 3.07448506e-02f, 3.20044495e-02f, -6.93965554e-02f, -2.05305386e-02f, -2.40256321e-02f,
  -2.60174796e-02f, -7.17425793e-02f, 4.58632037e-02f, -2.36019939e-02f, -6.83447495e-02f, -7.57785961e-02f, -8.48074257e-02f, -1.10065732e-02f, -1.38123825e-01f, -9.83997062e-02f,
  -8.72317404e-02f, -9.02473852e-02f, 1.76412221e-02f, 6.95457011e-02f, 1.39000919e-02f, -9.22158652e-04f, -8.62346664e-02f, 2.60075126e-02f, 5.63804433e-02f, -6.72730133e-02f,
  -2.22546943e-02f, 6.20011576e-02f, -6.45755604e-02f, 1.75776239e-02f, -1.00713633e-02f, 4.64892620e-03f, -6.08758815e-02f, 5.92006691e-05f, -3.50582711e-02f, -5.95102534e-02f,
  1.13466717e-01f, -3.18510644e-02f, -3.24850231e-02f, -3.75561081e-02f, 5.35986237e-02f, -5.02997125e-03f, 4.98011671e-02f, -1.18093286e-02f, 5.51944785e-02f, 1.07924570e-03f,
  -8.06189105e-02f, 1.78638697e-02f, 1.51326284e-02f, 4.03956845e-02f, -1.15512479e-02f, -2.04603001e-02f, -8.07765424e-02f, -1.09569468e-01f, 1.06924437e-01f, 1.03583738e-01f,
  1.25914976e-01f, 1.86618015e-01f, -1.59886535e-02f, -2.18428695e-03f, 2.73901597e-02f, -5.25607318e-02f, -9.82944109e-03f, -2.40427703e-02f, -5.33002652e-02f, 8.23043636e-04f,
  4.98841703e-03f, 9.93127842e-03f, 9.27061811e-02f, -1.22668883e-02f, 6.94663376e-02f, 1.58280507e-02f, 1.07502989e-01f, 8.17261562e-02f, 1.27686992e-01f, 1.23297758e-01f,
  4.81680855e-02f, 3.99417058e-02f, 5.68000833e-03f, -5.54714575e-02f, 2.06384137e-02f, -1.61899626e-02f, 8.17243829e-02f, -1.92995407e-02f, -2.93222051e-02f, 1.48828598e-02f,
  2.13098392e-01f, -6.44349456e-02f, 6.34246543e-02f, 1.11471735e-01f, 1.27973706e-01f, -3.00324470e-01f, -2.24297971e-01f, 1.43323287e-01f, 2.58872151e-01f, -9.89577100e-02f,
  -2.50922646e-02f, 3.78017388e-02f, -1.08050980e-01f, -2.43919298e-01f, -1.27994433e-01f, -2.40392193e-01f, -1.68682724e-01f, -3.70471030e-02f, 4.81664166e-02f, 4.54664081e-02f,
  1.42215546e-02f, -2.16605127e-01f, -1.42673746e-01f, 1.12039605e-02f, 7.36873001e-02f, 5.41139580e-02f, -6.94448128e-02f, 6.69446886e-02f, -1.86281651e-01f, -1.30830422e-01f,
  -5.35870418e-02f, 6.76997304e-02f, 8.77958909e-02f, 3.90128270e-02f, -1.88625511e-02f, 1.12364227e-02f, -4.29478027e-02f, -2.40535885e-02f, 8.56814459e-02f, -2.99874879e-02f,
  2.50693527e-03f, -7.84961414e-03f, 2.26321276e-02f, 6.14396820e-04f, 6.48129359e-02f, 6.77884882e-03f, 6.04969636e-03f, 4.65214662e-02f, 2.15768851e-02f, -3.03633623e-02f,
  2.13787332e-02f, 4.45732400e-02f, 6.41004890e-02f, 1.61612127e-02f, 3.88112329e-02f, 2.51846779e-02f, -6.17379099e-02f, -1.14288814e-02f, -7.90466368e-03f, 4.49969061e-02f,
  -3.43059674e-02f, -1.56233134e-02f, -3.70620154e-02f, -5.58321588e-02f, -2.58163475e-02f, 6.75225072e-03f, -3.19918580e-02f, -3.26173217e-03f, 7.37706125e-02f, -6.17302880e-02f,
  1.92018524e-02f, 4.89039756e-02f, 1.25208721e-02f, -1.19395917e-02f, 2.36985479e-02f, 4.31599207e-02f, -7.45787323e-02f, -3.95522602e-02f, 7.11238617e-03f, 7.35679269e-02f,
  -4.35793363e-02f, -1.20677929e-02f, -3.56682278e-02f, -2.31869426e-02f, -5.03455736e-02f, 6.37822151e-02f, 2.51744911e-02f, 6.56533800e-03f, 9.65104178e-02f, -4.03196225e-03f,
  -9.87947360e-02f, -2.88714673e-02f, 8.81800707e-03f, -1.33526018e-02f, -5.44688068e-02f, -5.28495386e-02f, -4.57743295e-02f, -5.01649268e-02f, -8.79829749e-03f, -1.29971541e-02f,
  -3.61845493e-02f, -2.79122707e-03f, -5.33680581e-02f, 5.82420640e-02f, 1.52209755e-02f, -4.63703135e-03f, -3.54912579e-02f, 1.95216388e-02f, -1.53444307e-02f, 3.02792210e-02f,
  8.52108933e-03f, -5.50968349e-02f, 6.05176166e-02f, 2.39801649e-02f, 6.53217314e-03f, 9.27432347e-03f, 8.44556987e-02f, 4.80335206e-02f, -7.77533203e-02f, 1.99570209e-02f,
  2.07513809e-01f, -2.91506052e-01f, 6.78960010e-02f, -1.15367919e-01f, 2.58793775e-02f, -3.29153270e-01f, -1.99985474e-01f, -4.56236117e-02f, -9.65051726e-02f, -2.49253795e-01f,
  -6.45496622e-02f, -7.91576654e-02f, -1.34427786e-01f, -2.02594504e-01f, 1.08769707e-01f, -1.81198895e-01f, -1.46257997e-01f, -9.44753587e-02f, 2.03254726e-02f, -7.26023093e-02f,
  7.48999715e-02f, -1.67185366e-01f, 5.25189610e-03f, -5.61158881e-02f, -9.11526754e-02f, 1.08309753e-01f, 5.38794771e-02f, 4.98609729e-02f, 3.83495763e-02f, 8.00712630e-02f,
  -4.94448654e-02f, -6.10962026e-02f, 9.15462598e-02f, -3.86750400e-02f, -4.61913347e-02f, 2.32540891e-02f, 3.25255878e-02f, 5.66049181e-02f, 6.66446686e-02f, -2.47894563e-02f,
  4.94369566e-02f, -7.19161192e-03f, 4.92079183e-03f, -4.00110036e-02f, 9.32442490e-03f, 6.29134923e-02f, 6.28470629e-03f, -3.75805888e-03f, -7.66664918e-04f, -3.98080312e-02f,
  -6.20088689e-02f, 6.14958107e-02f, 2.69560665e-02f, -6.33682730e-03f, -2.60831378e-02f, -7.57711679e-02f, -5.11561334e-02f, -5.13898507e-02f, -9.21657458e-02f, -5.52020147e-02f,
  4.60621789e-02f, -4.09932882e-02f, -2.07378417e-02f, 8.44948366e-02f, -1.36581697e-02f, 4.94150724e-03f, -5.64025994e-03f, 3.62198092e-02f, 4.80333641e-02f, -2.41938662e-02f,
  7.76381421e-06f, 6.54147146e-03f, 1.48282023e-02f, -6.26495555e-02f, 5.68709299e-02f, -2.59743687e-02f, 8.81517082e-02f, -2.29874924e-02f, 1.26602943e-03f, 4.59973589e-02f,
  5.21331327e-03f, -4.92998995e-02f, -3.96999270e-02f, 1.69759635e-02f, 2.09020879e-02f, 5.75003251e-02f, -3.46029326e-02f, 6.37786761e-02f, -4.45879501e-04f, 9.28199850e-03f,
  -1.26742676e-01f, -2.51258969e-01f, -5.69133312e-02f, 4.26497385e-02f, 3.48821818e-03f, -2.48343199e-02f, -9.88709647e-03f, -1.58949383e-02f, -7.35110557e-03f, 5.57436096e-03f,
  -5.80283888e-02f, 1.21067148e-02f, -1.97921619e-02f, 1.29638752e-02f, 1.14999274e-02f, -3.63625884e-02f, -1.83308907e-02f, 6.99556023e-02f, -2.26500332e-02f, -5.00964113e-02f,
  -5.65715414e-03f, -2.08467878e-02f, 4.55462560e-02f, -7.94676542e-02f, -5.54003008e-02f, 5.70510775e-02f, -2.72219516e-02f, 3.57243232e-02f, 1.13521546e-01f, -2.47863475e-02f,
  -3.53990197e-01f, -8.19338486e-02f, -5.23205753e-03f, -1.32359117e-01f, -1.83497876e-01f, -3.60955810e-03f, 3.10001731e-01f, -2.20842764e-01f, -1.11036509e-01f, 1.03426024e-01f,
  -6.57664835e-02f, 1.01647628e-02f, 2.31156662e-01f, -2.26831794e-01f, 2.69497067e-01f, 2.24906325e-01f, -1.46494463e-01f, 5.82457446e-02f, -8.37963372e-02f, -1.88975647e-01f,
  4.59957123e-02f, -1.76159561e-01f, 9.60811526e-02f, -2.61465222e-01f, -8.88233036e-02f, -7.61985853e-02f, 2.37610447e-03f, 4.44267914e-02f, -1.19178265e-01f, 9.64722037e-03f,
  -1.12248957e-03f, -4.93277721e-02f, 3.87842162e-03f, 2.35014185e-02f, -1.23552643e-02f, 2.06182967e-03f, 1.08275719e-01f, 1.64672166e-01f, 4.61365357e-02f, 1.76205800e-03f,
  7.75895715e-02f, 1.87232457e-02f, -1.06638581e-01f, 5.84135689e-02f, -1.54954670e-02f, -5.09226173e-02f, -3.00979074e-02f, -1.98370572e-02f, -9.12668556e-03f, -3.43229026e-02f,
  -1.06097013e-01f, -1.60714742e-02f, -9.54452455e-02f, 2.56636944e-02f, 2.24358160e-02f, -8.83870721e-02f, 1.01778239e-01f, 9.60084647e-02f, -5.50479023e-03f, -1.37563124e-01f,
  5.02387844e-02f, -4.47535329e-03f, -1.01827243e-02f, -1.07261213e-02f, -7.37695098e-02f, -5.71747869e-03f, -1.53926518e-02f, -5.19060064e-03f, 3.59772751e-03f, 2.58644018e-02f,
  -4.49088700e-02f, -5.10442406e-02f, -6.67009279e-02f, -2.61931550e-02f, -4.02475409e-02f, -3.07400636e-02f, 7.09184110e-02f, 1.55973453e-02f, -3.49060781e-02f, -1.16814040e-02f,
  1.15440123e-01f, 2.63784416e-02f, -2.23875046e-02f, 9.07384902e-02f, -1.24466419e-02f, 5.13440557e-02f, -8.88494551e-02f, -2.23085862e-02f, 3.19363475e-02f, -2.66559441e-02f,
  1.01064265e-01f, 3.50485295e-02f, 8.87248367e-02f, 3.86062674e-02f, 7.39001185e-02f, -4.51310351e-02f, 4.09724703e-03f, -7.42519721e-02f, 3.18267830e-02f, -1.02803864e-01f,
  -7.68420100e-02f, 4.52733561e-02f, 6.44753920e-03f, -4.96732518e-02f, 1.24316122e-02f, 2.62434990e-03f, 9.25680622e-02f, 8.73977691e-02f, -3.16159725e-02f, -5.68700098e-02f,
  3.09263747e-02f, 4.38314192e-02f, 1.01968400e-01f, 1.26061384e-02f, 3.50346453e-02f, 3.25559676e-02f, -4.46649827e-02f, 2.45388644e-03f, 1.17459577e-02f, 2.60287002e-02f,
  5.67009812e-03f, -1.85553834e-01f, 9.49460715e-02f, 2.18222942e-02f, -1.02787957e-01f, -5.98664321e-02f, 7.35649243e-02f, 7.13125989e-02f, 2.08146393e-01f, -9.64929163e-02f,
  3.62895168e-02f, -1.58288702e-01f, 1.09773837e-02f, -2.29335383e-01f, -9.65340808e-02f, 1.86921060e-01f, 2.59888992e-02f, 7.99464434e-03f, 3.09897587e-02f, -2.85191629e-02f,
  1.70443818e-01f, -2.27888331e-01f, 1.27473190e-01f, -6.58807009e-02f, -8.90626460e-02f, -5.09428210e-04f, -1.13342397e-01f, -1.52691856e-01f, -2.58281440e-01f, -2.18683019e-01f,
  1.21477030e-01f, -4.61747721e-02f, 2.71723699e-02f, -9.21859518e-02f, 7.34076323e-03f, -5.47904558e-02f, -1.21855736e-02f, -1.08403698e-01f, 3.14463973e-02f, -3.68837006e-02f,
  -3.63850519e-02f, -1.68376118e-02f, -5.41386455e-02f, -7.70371556e-02f, 7.98903406e-02f, 3.23013514e-02f, -5.09675629e-02f, 6.69595301e-02f, 6.95770979e-02f, -2.98019275e-02f,
  9.22159851e-02f, 9.65771899e-02f, 3.48768570e-02f, -7.37270042e-02f, -4.18715598e-03f, 5.21386117e-02f, -7.75811402e-03f, -8.14435165e-03f, 1.27274795e-02f, -6.26477529e-04f,
  -1.12040192e-02f, 1.32326605e-02f, 1.16425250e-02f, 5.26353717e-02f, 2.81045940e-02f, -3.26507427e-02f, 1.30741308e-02f, -5.14325313e-02f, -3.85554060e-02f, -4.32736538e-02f,
  1.67965740e-02f, 3.02277002e-02f, -6.65157586e-02f, 1.11982152e-02f, -1.92830358e-02f, 5.09878695e-02f, 1.42008476e-02f, -9.41908062e-02f, 5.71973138e-02f, 1.09451137e-01f,
  1.69586169e-03f, 1.24847924e-04f, 4.59242333e-03f, 4.56672423e-02f, 4.04208824e-02f, -6.87906146e-02f, -8.69714171e-02f, -5.04916497e-02f, 2.37722378e-02f, -1.20861949e-02f,
  -1.65763330e-02f, -2.83100545e-01f, 5.07985018e-02f, 8.39484110e-03f, -1.74931008e-02f, -4.16542143e-02f, -6.22991659e-03f, -7.16875121e-02f, -3.40149142e-02f, 4.94280038e-03f,
  -6.14238232e-02f, 8.85935593e-03f, -5.01236580e-02f, -1.67579688e-02f, -3.23255174e-02f, 2.52246410e-02f, 2.41850112e-02f, -3.28847989e-02f, -4.08202736e-03f, -4.00276594e-02f,
  -8.33337009e-02f, -3.36039695e-03f, -5.89519553e-02f, 3.55196744e-02f, 8.97865836e-03f, -9.86753590e-03f, -5.54955415e-02f, 2.08068639e-03f, -9.85590592e-02f, -7.05594313e-04f,
  -3.78052853e-02f, 3.03657144e-01f, 1.89918011e-01f, -2.73930784e-02f, -1.76264346e-01f, -2.38184869e-01f, -1.06740177e-01f, -7.30815232e-02f, 1.30087847e-03f, 5.64662069e-02f,
  -1.89007953e-01f, 2.77352542e-01f, 1.65677115e-01f, -5.56636304e-02f, -2.26664945e-01f, 1.12220064e-01f, -1.12164482e-01f, 8.12556669e-02f, 4.24364619e-02f, 2.04752199e-02f,
  -5.27489707e-02f, -1.71494544e-01f, -2.65904665e-02f, -5.56432866e-02f, 1.20048421e-02f, 1.44505113e-01f, 9.71321855e-03f, 8.50273743e-02f, -9.61795002e-02f, -2.75981594e-02f,
  -8.98100585e-02f, 3.29677612e-02f, 3.53367627e-02f, -3.59579064e-02f, -3.12285572e-02f, 4.19865884e-02f, 5.18697947e-02f, 4.97340932e-02f, -1.74890589e-02f, -4.43039788e-03f,
  2.22308412e-02f, -2.57419460e-02f, 7.52504682e-04f, -3.19378776e-03f, -5.74672334e-02f, -3.06510064e-03f, 2.52750870e-02f, -3.68793271e-02f, 8.82273689e-02f, -7.90955946e-02f,
  2.09181141e-02f, 7.00896606e-03f, -9.48849171e-02f, 9.73124579e-02f, 1.77398883e-03f, -2.19977759e-02f, 3.88278700e-02f, 8.85820463e-02f, 7.06894323e-02f, 5.08279055e-02f,
  1.66447945e-02f, 2.64868010e-02f, -1.43418014e-02f, -9.72623937e-03f, 1.48511957e-03f, -3.97778526e-02f, 2.31343824e-02f, -9.31678433e-03f, 6.24802336e-02f, 7.40004564e-03f,
  -6.40737638e-02f, -1.63544826e-02f, -1.13831451e-02f, -3.34433317e-02f, -7.03997165e-02f, 5.82070276e-02f, -1.49689754e-02f, 4.27114479e-02f, 1.87754503e-03f, -4.83184718e-02f,
  4.71178405e-02f, -3.16348895e-02f, 6.65979162e-02f, 2.47671902e-02f, 1.32957166e-02f, 2.03963686e-02f, 1.29455188e-02f, -2.00728793e-03f, 1.80528257e-02f, 1.51650561e-03f,
  -5.66869378e-02f, 2.06527248e-01f, 1.76263303e-02f, 4.81302962e-02f, 8.22612792e-02f, -2.10212227e-02f, 3.41992006e-02f, -7.46479025e-03f, 3.75184068e-03f, -5.17976880e-02f,
  -3.30247618e-02f, 4.05736975e-02f, -2.56438423e-02f, 1.17744133e-02f, 1.31377473e-03f, -5.33850603e-02f, -1.98872276e-02f, 8.95053800e-03f, -5.80727495e-02f, -1.98855903e-02f,
  -8.57514739e-02f, 2.63476260e-02f, 3.04534528e-02f, -7.69234449e-02f, 6.04329119e-03f, -2.61791293e-02f, -7.42442906e-04f, -3.24017182e-02f, 1.60645097e-02f, 1.17324747e-03f,
  -1.01744786e-01f, 6.55674096e-03f, 1.98339835e-01f, 1.49316147e-01f, -1.67453259e-01f, -7.23186508e-03f, 2.16843605e-01f, -2.30048895e-01f, -9.56376716e-02f, 1.51037825e-02f,
  -7.57222250e-02f, 2.69637227e-01f, 1.33842736e-01f, 1.88186541e-02f, 2.14870229e-01f, 3.29714790e-02f, 1.01078749e-02f, 6.42983094e-02f, -2.20520094e-01f, -9.28376839e-02f,
  -7.46717378e-02f, -1.87956825e-01f, 2.08898574e-01f, -2.24365160e-01f, 5.40713780e-02f, -4.39802222e-02f, -1.01371091e-02f, 1.90290250e-02f, 9.36882123e-02f, -9.40400548e-03f,
  1.04638189e-01f, -7.01112300e-02f, 9.09247249e-02f, 4.76802401e-02f, 2.05242485e-02f, 1.05335400e-03f, 9.21498388e-02f, 1.19878836e-01f, 5.64863160e-02f, -1.34347267e-02f,
  4.55450080e-02f, 5.16084488e-03f, -1.00741088e-02f, -2.21463554e-02f, -6.28536418e-02f, -1.09638842e-02f, -2.96057668e-02f, 4.05889191e-02f, -3.92436236e-03f, 3.22115677e-03f,
  -6.75903410e-02f, -7.28931651e-03f, -5.10397442e-02f, -2.06709411e-02f, -9.05461907e-02f, -3.19043398e-02f, 1.31266862e-01f, 3.05327233e-02f, -3.58456629e-03f, -8.10864419e-02f,
  -1.24794580e-01f, 3.23473476e-02f, 8.57212953e-03f, 6.37147650e-02f, -1.44895483e-02f, 8.37848429e-03f, -4.74002212e-03f, 6.86697057e-03f, 2.18994785e-02f, -1.34633221e-02f,
  -2.62983842e-03f, -5.02291210e-02f, -1.05209529e-01f, 4.83609363e-02f, -7.14056417e-02f, -3.02190650e-02f, 8.03590491e-02f, -1.92301497e-02f, -1.06936261e-01f, -4.02576253e-02f,
  -1.06512930e-03f, -1.77018549e-02f, 1.11878896e-02f, 1.11194672e-02f, 7.07080774e-03f, 2.86115389e-02f, -4.27924357e-02f, -3.63057107e-02f, -1.40526996e-03f, -2.09621135e-02f,
  -1.09722778e-01f, -1.25932679e-01f, 1.69925150e-02f, 7.28239864e-03f, -1.95736289e-02f, -1.79708898e-02f, 1.19781420e-02f, -9.35439244e-02f, -6.16982058e-02f, -5.60130440e-02f,
  -1.01598687e-01f, 1.46960998e-02f, -6.07427731e-02f, -3.80766653e-02f, 1.12534724e-01f, -8.87564477e-03f, 9.73717272e-02f, -4.52302843e-02f, 5.10512525e-03f, -4.86782528e-02f,
  1.76947471e-02f, -4.85414937e-02f, 2.39972826e-02f, -7.42031336e-02f, -5.93284052e-03f, 3.79294828e-02f, -6.87535405e-02f, -2.74012703e-02f, 2.35609990e-02f, 2.54029781e-02f,
  -7.39937127e-02f, 1.70421600e-02f, 1.27717674e-01f, 7.92710260e-02f, 1.50994837e-01f, 3.73465903e-02f, 1.14912957e-01f, 7.07972869e-02f, -1.98320493e-01f, -2.37576547e-03f,
  1.50666818e-01f, 7.57050067e-02f, -7.48790130e-02f, 1.45899698e-01f, -1.08883135e-01f, -9.64451060e-02f, -6.71516778e-03f, -3.78094912e-02f, -9.06699821e-02f, 6.62204847e-02f,
  -1.31165087e-01f, 8.00520629e-02f, 8.52844641e-02f, 5.81214465e-02f, 1.22600116e-01f, -5.65609708e-02f, -9.75155607e-02f, 1.23100013e-01f, 6.46641850e-02f, 1.26387432e-01f,
  1.64997369e-01f, 1.12018241e-02f, 1.02063149e-01f, -1.67436879e-02f, -9.72847939e-02f, -4.06933622e-03f, 9.05356333e-02f, 6.27155378e-02f, 6.65724277e-02f, -6.14456907e-02f,
  -2.97128372e-02f, -4.73209061e-02f, 3.37447710e-02f, -3.70062329e-02f, -3.40760760e-02f, -1.62720177e-02f, 5.47389686e-02f, 5.63706867e-02f, 8.16010591e-03f, 9.00347084e-02f,
  1.38478512e-02f, 2.08666604e-02f, 8.00766945e-02f, -7.60002807e-02f, -4.06055860e-02f, -3.78743224e-02f, 1.19171897e-02f, 8.18261877e-03f, -8.91350880e-02f, -1.01361148e-01f,
  -8.91027376e-02f, -8.19799677e-02f, -1.80374458e-02f, 6.24377578e-02f, 3.01283281e-02f, 6.64742067e-02f, -2.24410314e-02f, 5.32734059e-02f, -3.65028940e-02f, -5.77725917e-02f,
  3.46762240e-02f, 5.21603227e-02f, 1.45004820e-02f, -4.09194641e-02f, -1.80705674e-02f, -6.83494434e-02f, 2.44394224e-02f, 2.21427288e-02f, -5.25920317e-02f, 9.55600664e-02f,
  -3.01955603e-02f, 4.91973199e-02f, 2.38626078e-02f, 5.87462559e-02f, -3.10159717e-02f, -2.68365312e-02f, -6.48341468e-03f, 7.33125508e-02f, 5.91023229e-02f, -3.18228081e-02f,
  -8.81689563e-02f, -2.04949111e-01f, 4.84258011e-02f, 4.68276143e-02f, 2.41814204e-03f, 1.18249347e-02f, -7.20503926e-02f, -1.73922963e-02f, -1.22429825e-01f, -2.92900018e-02f,
  1.98277347e-02f, 7.99926464e-03f, -8.62344503e-02f, -3.78344804e-02f, 7.58246705e-02f, -2.47000791e-02f, -5.31430617e-02f, -9.68215317e-02f, 2.69154087e-02f, -1.19314464e-02f,
  1.48548791e-02f, -4.46127243e-02f, -1.02787755e-01f, 6.20997027e-02f, -3.33441831e-02f, -5.82207888e-02f, 2.03160364e-02f, -4.67485636e-02f, -1.84492636e-02f, -5.90125434e-02f,
  4.22803730e-01f, -1.26231179e-01f, -1.23721771e-01f, 2.08267093e-01f, 8.91218055e-03f, -1.19356990e-01f, 1.07104450e-01f, 7.96374083e-02f, 2.45502710e-01f, -2.58478001e-02f,
  -5.13095334e-02f, 8.25931504e-02f, -1.05478369e-01f, 3.75426635e-02f, 2.63188511e-01f, -3.09384055e-02f, 2.09944725e-01f, 7.64467940e-02f, 4.74756360e-02f, 4.13803682e-02f,
  1.01352908e-01f, 1.56451985e-01f, -1.18988954e-01f, -1.68319955e-01f, 8.65574926e-02f, -5.20660914e-02f, 4.43685502e-02f, -1.79422915e-01f, -1.27736926e-01f, -7.67563209e-02f,
  -1.02908179e-01f, 8.57291222e-02f, -3.52747254e-02f, -5.31636216e-02f, 2.68299468e-02f, -5.94439842e-02f, -5.59579954e-02f, -9.20033157e-02f, 7.70236477e-02f, -4.35513072e-03f,
  -4.09203954e-02f, 6.24089167e-02f, -2.58200131e-02f, 3.37507017e-02f, 4.63894717e-02f, 6.06649555e-02f, -9.37793124e-03f, 1.57897118e-02f, 7.49625324e-04f, -1.88940542e-03f,
  4.18904051e-02f, -5.13394251e-02f, 6.77641779e-02f, -7.92106241e-02f, -2.85976846e-02f, 8.41248129e-03f, -1.72932670e-02f, -4.21640649e-02f, 1.12118386e-02f, 4.24344167e-02f,
  7.68222064e-02f, 1.50055140e-02f, -2.94399038e-02f, 3.77742313e-02f, -3.44762206e-02f, 1.87579226e-02f, 4.12747264e-02f, -5.80047220e-02f, 1.26778102e-02f, -3.17067243e-02f,
  3.87639552e-02f, 2.37522330e-02f, 5.21650016e-02f, 3.66822556e-02f, -1.66558865e-02f, 6.76935613e-02f, -2.91839894e-02f, -2.95283291e-02f, 5.58307283e-02f, -2.53198352e-02f,
  2.77450308e-02f, -2.56996546e-02f, -3.37144844e-02f, 1.16647203e-02f, -2.39100754e-02f, 2.28396337e-02f, 3.04440763e-02f, -1.08932063e-03f, 2.49938499e-02f, 2.56709624e-02f,
  3.17252688e-02f, 4.76837642e-02f, 1.53845344e-02f, -4.24537919e-02f, -9.44591463e-02f, 1.60479154e-02f, 7.99137503e-02f, 1.07529201e-02f, -3.52164283e-02f, -1.47883771e-02f,
  4.65098917e-02f, 2.43172720e-02f, -2.33838079e-03f, 3.66426781e-02f, 4.39390689e-02f, -2.14365441e-02f, -1.35400649e-02f, 1.17855472e-02f, 4.24582623e-02f, -7.25396769e-03f,
  -3.92333604e-02f, 6.09149113e-02f, 5.63347421e-05f, 4.61438335e-02f, 9.14855748e-02f, 3.81252356e-02f, 4.30298783e-03f, -1.69841070e-02f, 1.17769307e-02f, 4.33320962e-02f,
  5.01071848e-02f, -9.18549523e-02f, 8.55272040e-02f, 4.43620607e-02f, 2.95932461e-02f, -1.93043798e-01f, -7.22147971e-02f, -1.97775979e-02f, 1.06725536e-01f, -1.36712104e-01f,
  -1.11734681e-02f, 1.35326952e-01f, -1.20039649e-01f, -7.24321418e-03f, -1.94659352e-01f, -1.78615339e-02f, -1.32458568e-01f, -4.05895058e-03f, 7.08209574e-02f, -8.14837292e-02f,
  8.91975239e-02f, -1.37944236e-01f, -6.88706338e-03f, -6.77935109e-02f, -8.25948119e-02f, 1.89582974e-01f, -1.10656105e-01f, 3.08264773e-02f, -8.16227496e-02f, -3.55233550e-02f,
  -1.43799484e-01f, -2.94060595e-02f, 1.24055795e-01f, 5.21378256e-02f, -6.40770048e-02f, -1.46999201e-02f, -8.13821703e-03f, 6.08755313e-02f, 2.39915051e-03f, -1.75238084e-02f,
  1.35614015e-02f, -7.07017928e-02f, 1.87118165e-02f, 5.47171682e-02f, 2.86508957e-03f, 1.85264777e-02f, 5.71585596e-02f, -1.64262280e-02f, 5.80089651e-02f, 5.09361848e-02f,
  3.20251137e-02f, 1.74239930e-02f, 2.81595867e-02f, -5.84137253e-03f, 7.17480853e-02f, 4.44884561e-02f, 1.26885669e-02f, 2.65192892e-02f, -4.38291319e-02f, 4.39480469e-02f,
  3.04346178e-02f, 2.75356341e-02f, -1.11681260e-02f, -5.39053641e-02f, -4.67263497e-02f, 2.81148852e-04f, -2.56719515e-02f, -7.17470199e-02f, -3.02628125e-03f, -4.72930335e-02f,
  -5.61930686e-02f, 4.32060137e-02f, 5.68454759e-03f, -3.04957852e-02f, 3.11254505e-02f, -1.20151304e-02f, 6.74952008e-03f, -7.06974417e-02f, 8.32944959e-02f, 3.50069255e-02f,
  -2.15124302e-02f, -5.28327413e-02f, -6.81128129e-02f, 5.99466227e-02f, -2.85219420e-02f, -1.86356921e-02f, -3.52546684e-02f, -6.61364943e-02f, 7.20783845e-02f, 3.07303015e-03f,
  -2.36004412e-01f, -2.27713451e-01f, -4.97905947e-02f, -9.90202427e-02f, -1.54347047e-02f, -2.58273724e-02f, 5.18565923e-02f, 8.52120444e-02f, -3.86531129e-02f, -7.47658545e-03f,
  4.34572026e-02f, 4.46004085e-02f, -3.04241516e-02f, -2.54395641e-02f, 3.83195542e-02f, -5.85967535e-03f, -1.05058245e-01f, -5.76472171e-02f, -2.83783823e-02f, -9.55646858e-02f,
  -1.16799787e-01f, -7.95899779e-02f, 8.91576931e-02f, -4.05002050e-02f, 5.03009036e-02f, -3.09697129e-02f, 3.64435539e-02f, 1.06422752e-01f, 2.52534379e-03f, -5.48318885e-02f,
  1.73085377e-01f, -1.33190274e-01f, 9.33948383e-02f, 1.87153757e-01f, 1.13518782e-01f, -8.91720653e-02f, 9.35513303e-02f, 6.32620230e-02f, -3.75920124e-02f, -1.35316432e-01f,
  -1.76850539e-02f, 1.90641046e-01f, -1.33868769e-01f, -1.30530372e-01f, 1.58911496e-01f, -3.19391251e-01f, -3.92481452e-03f, 1.18352741e-01f, -9.06385779e-02f, 1.05628781e-01f,
  1.82323337e-01f, 3.56940590e-02f, 5.56125790e-02f, -8.55292603e-02f, 1.17868096e-01f, 4.01050150e-02f, 1.09386809e-01f, 1.06596321e-01f, 1.85815662e-01f, -3.26388739e-02f,
  -1.30504146e-01f, -1.52979121e-01f, 6.25241622e-02f, -2.72335727e-02f, -1.72318965e-02f, 3.33040468e-02f, 8.65280107e-02f, 1.14697821e-01f, 1.33799598e-01f, -5.73271215e-02f,
  6.29487187e-02f, -5.25445072e-03f, -6.66062459e-02f, 5.60691133e-02f, 4.94946763e-02f, -3.74141857e-02f, -4.58023883e-02f, -1.67119838e-02f, 2.52372138e-02f, 4.79152203e-02f,
  -3.78919803e-02f, -3.64443325e-02f, -5.35886250e-02f, -8.61223787e-02f, 2.85594221e-02f, 4.26489450e-02f, 5.17850406e-02f, 8.64357203e-02f, -1.39515236e-01f, 8.88427272e-02f,
  -4.82655391e-02f, 4.68820073e-02f, -1.49591384e-03f, -5.70471101e-02f, 2.06196168e-03f, 7.35433819e-03f, -4.62405533e-02f, -7.69952834e-02f, 2.73095141e-03f, 3.40679362e-02f,
  4.13850062e-02f, 5.53014725e-02f, -3.18568237e-02f, 5.09602875e-02f, -4.23891935e-03f, -6.02460001e-03f, 6.71896636e-02f, 5.26067130e-02f, 7.06511214e-02f, -3.61083597e-02f,
  1.08768037e-02f, 3.18233818e-02f, 6.88550994e-02f, -3.97471488e-02f, -8.18277746e-02f, 1.22159436e-01f, -1.28630465e-02f, -3.48697081e-02f, -6.85223639e-02f, -2.22561397e-02f,
  -2.91421730e-02f, 3.13506313e-02f, 5.28831687e-03f, 2.20357552e-02f, -6.44801334e-02f, -4.47751433e-02f, -1.21865623e-01f, -6.83719367e-02f, -1.20214242e-02f, -3.65525447e-02f,
  6.87695444e-02f, 5.28982915e-02f, 2.84954477e-02f, 6.16606092e-03f, 2.76262537e-02f, 6.65468425e-02f, 5.42618893e-02f, 1.10313920e-02f, 8.61764606e-03f, -4.80599590e-02f,
  4.40330803e-02f, -3.43347453e-02f, -7.51365125e-02f, -2.18236558e-02f, -1.95795838e-02f, -5.16498908e-02f, 3.64902616e-02f, 4.16127369e-02f, -6.48909360e-02f, -5.65041527e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.64785957e-01f, 1.26140624e-01f, 1.79555774e-01f, -2.86325574e-01f, 1.69830620e-01f, 4.28488970e-01f, 2.06423864e-01f, 1.57923728e-01f, -5.84023520e-02f, 1.23111650e-01f,
  1.35045394e-01f, -2.57715285e-01f, 1.75332293e-01f, 5.48831448e-02f, 1.67791158e-01f, 2.14032412e-01f, 9.02542099e-02f, 8.10295716e-02f, -3.88099812e-02f, -4.22124155e-02f,
  -5.21694981e-02f, -9.28757116e-02f, 2.75495425e-02f, -8.54043011e-03f, 2.64172107e-02f, -2.19690129e-01f, -1.07696891e-01f, 7.22696036e-02f, 3.52265202e-02f, 3.25627550e-02f,
  -4.17359136e-02f, -2.11616188e-01f, -1.09804064e-01f, 1.02077313e-01f, 9.96796638e-02f, -3.87368314e-02f, -4.96370718e-02f, 6.28178120e-02f, 7.23563805e-02f, -1.64025556e-02f,
  7.58362040e-02f, 5.68455458e-02f, 2.28711274e-02f, -5.95888421e-02f, -5.93293346e-02f, 6.19348697e-02f, 1.69067353e-01f, 9.98776928e-02f, 1.18921198e-01f, 1.17816813e-01f,
  7.90838152e-02f, 3.81966718e-02f, 2.38220133e-02f, -4.13821042e-02f, -1.25412759e-03f, -6.34195805e-02f, -7.24449977e-02f, 2.45092716e-02f, 6.60023764e-02f, 1.07225664e-02f,
  -1.04074910e-01f, 5.96352071e-02f, 1.43624861e-02f, 5.92379160e-02f, -1.84735786e-02f, -7.17391372e-02f, -6.74893707e-03f, -2.30882205e-02f, 2.65574642e-02f, 9.88790244e-02f,
  -7.47577921e-02f, 6.63057808e-03f, -1.52605459e-01f, -5.72250299e-02f, 3.65271345e-02f, -8.99045765e-02f, 4.45044087e-03f, -7.86291715e-03f, -5.62763885e-02f, -1.43430913e-02f,
  3.02302428e-02f, -2.37531085e-02f, 2.69998498e-02f, -2.87102312e-02f, 5.89881204e-02f, 3.66331870e-03f, -7.96453133e-02f, -7.24626929e-02f, -4.84225489e-02f, 2.54430007e-02f,
  7.06282929e-02f, -2.64570899e-02f, 2.47057192e-02f, 3.06538977e-02f, -1.02401031e-02f, 2.55690217e-02f, -9.89190042e-02f, 1.33169070e-03f, 1.12012550e-01f, 3.09535861e-02f,
  8.96348655e-02f, -3.02609056e-02f, -4.82587479e-02f, -1.34657040e-01f, 6.12670891e-02f, 1.34302050e-01f, -5.07932380e-02f, 4.71364930e-02f, 5.36067709e-02f, 7.88501203e-02f,
  -9.10242796e-02f, -3.23758423e-02f, 1.04466882e-02f, -3.29575688e-02f, 2.52925102e-02f, 4.35760990e-03f, -6.10988587e-03f, 1.54433930e-02f, -5.36539126e-04f, -3.83072086e-02f,
  1.11624300e-01f, -4.23405766e-01f, -3.08772624e-01f, 8.55240151e-02f, 3.61385912e-01f, 3.90976608e-01f, 1.69130415e-01f, -1.10400431e-01f, -3.07267278e-01f, -2.61979371e-01f,
  2.75977641e-01f, -1.03060953e-01f, -2.34196186e-01f, 2.48021290e-01f, 2.83248544e-01f, -2.53998637e-01f, 8.49110037e-02f, 1.55452028e-01f, -1.37573019e-01f, -1.29424125e-01f,
  3.51542383e-02f, 3.11512291e-01f, -7.38033354e-02f, -3.36163901e-02f, 1.00430131e-01f, -2.52883345e-01f, 4.57031615e-02f, -1.33589104e-01f, 1.51661918e-01f, 9.56184864e-02f,
  1.29063338e-01f, -8.19943622e-02f, -4.23671268e-02f, -4.71772812e-02f, 7.98514783e-02f, 1.09869763e-01f, 1.13444785e-02f, 6.70999959e-02f, 6.13628775e-02f, 3.21645699e-02f,
  4.96104285e-02f, -1.98852774e-02f, 4.44586203e-02f, 1.61532015e-02f, 2.04256885e-02f, -4.59578298e-02f, -1.86902601e-02f, -1.44700427e-02f, -5.33970930e-02f, -6.92485645e-02f,
  -1.57088190e-02f, 1.95255708e-02f, -7.77128199e-03f, -1.02599837e-01f, -2.57193483e-02f, -2.11586654e-02f, -4.59198765e-02f, -1.33203529e-02f, 4.04090993e-02f, 2.73853354e-02f,
  5.24770319e-02f, -4.93312329e-02f, -8.99640378e-03f, 2.40680054e-02f, 1.00237072e-01f, -3.91299576e-02f, 7.95131475e-02f, 2.76664030e-02f, -5.53679504e-02f, 6.98872656e-02f,
  3.09088454e-03f, 2.16308087e-02f, 2.87170578e-02f, 1.61764422e-03f, -1.04671903e-03f, 5.76000549e-02f, 4.70381379e-02f, -8.43324047e-03f, -1.27710830e-02f, 8.47573429e-02f,
  6.33885190e-02f, -7.18057901e-02f, -3.87797109e-03f, -6.48912862e-02f, 2.95028035e-02f, -6.86461255e-02f, -6.35017231e-02f, 8.27318430e-02f, -7.24386051e-02f, 3.47210765e-02f,
  -8.51514097e-03f, -3.74457031e-01f, -1.35134561e-02f, 4.22871262e-02f, 1.21032353e-02f, 1.45624444e-01f, 5.20461388e-02f, 2.87005622e-02f, -1.84452571e-02f, -2.95353867e-02f,
  -1.73750240e-02f, 5.50145432e-02f, -3.87032516e-02f, 1.03057787e-01f, 1.50965586e-01f, 7.44647020e-03f, -1.08157955e-01f, 6.91900849e-02f, 6.17995299e-02f, 2.96956059e-02f,
  -1.05694020e-02f, 1.38087980e-02f, 2.39715856e-02f, 6.84248582e-02f, -6.76359702e-03f, -6.36689784e-03f, -2.64048986e-02f, -1.07740238e-01f, 1.77761316e-02f, -5.23003042e-02f,
  -2.41501361e-01f, -2.60445420e-02f, 8.80515482e-03f, -4.94288579e-02f, 4.61581210e-03f, -1.65531144e-01f, -6.90660253e-02f, -6.46544248e-02f, 2.13976875e-01f, 6.44693989e-03f,
  -1.60873875e-01f, 1.77003235e-01f, -2.13661760e-01f, 9.79251042e-03f, 5.85469464e-03f, -8.79605785e-02f, -7.14885667e-02f, -1.52894929e-01f, 1.41881630e-01f, -1.92230031e-01f,
  -7.10246190e-02f, 1.51540995e-01f, -1.03002064e-01f, 8.89953896e-02f, 9.97890346e-03f, 1.48529470e-01f, 5.97078539e-02f, 1.20546930e-01f, 1.60799935e-01f, 1.61274269e-01f,
  -1.39692888e-01f, -1.88484117e-01f, -2.19810531e-01f, -6.44618943e-02f, -2.27162763e-01f, -6.63873106e-02f, -7.65218660e-02f, 8.74586552e-02f, 1.79568548e-02f, 1.71489678e-02f,
  -5.56287952e-02f, 1.94320858e-01f, 1.34708866e-01f, 9.43578109e-02f, -6.22337908e-02f, 1.41639188e-01f, -5.56742167e-03f, -1.90988302e-01f, -3.25213708e-02f, -2.16170214e-03f,
  -1.63260512e-02f, 1.83549582e-03f, -1.85104162e-01f, 3.11173629e-02f, -6.48021325e-02f, 5.51548880e-03f, 6.27204403e-02f, -4.14666645e-02f, 5.27546108e-02f, 4.68707494e-02f,
  7.95832574e-02f, -1.32964894e-01f, 4.07515429e-02f, 7.54929557e-02f, 2.32392605e-02f, 5.04354481e-03f, -3.05361710e-02f, 2.98135374e-02f, 2.34827548e-02f, -1.04461178e-01f,
  -7.17332289e-02f, -1.00521035e-01f, -1.24101043e-01f, -2.02524289e-01f, -7.00407401e-02f, 6.07389212e-02f, -1.44391297e-03f, -2.94621731e-03f, -5.97245712e-03f, -5.89065850e-02f,
  7.22490028e-02f, 7.33027384e-02f, -5.76459058e-02f, -1.08079247e-01f, 2.34615542e-02f, 1.52873918e-02f, -2.61466159e-03f, -1.13221951e-01f, -9.62684378e-02f, -8.48281756e-02f,
  -3.48074436e-01f, -2.29136631e-01f, -1.05995633e-01f, 4.28792126e-02f, 6.40574284e-03f, -4.63086441e-02f, 7.27800950e-02f, 6.88150898e-02f, -7.87835121e-02f, 5.16185090e-02f,
  -6.83036596e-02f, -1.30001903e-01f, -5.89283649e-03f, 8.80917013e-02f, -7.32161105e-02f, 1.69653483e-02f, -1.94755524e-01f, -5.32009415e-02f, -1.46339899e-02f, -4.69100513e-02f,
  -7.55780414e-02f, -4.96543087e-02f, 7.31453598e-02f, -3.58584635e-02f, -8.59017372e-02f, 6.42109588e-02f, 9.73385945e-03f, 3.48211229e-02f, -9.07396227e-02f, 9.71548483e-02f,
  3.52072209e-01f, -2.74290722e-02f, -3.15162912e-02f, 1.15697272e-01f, 2.95237694e-02f, 1.75528288e-01f, 1.81455985e-01f, 1.05873242e-01f, 1.40806988e-01f, 1.67071112e-02f,
  -5.18367887e-02f, -2.36989632e-01f, -2.17836320e-01f, 1.04002520e-01f, -1.21803939e-01f, -7.20182583e-02f, 1.23058468e-01f, -9.43336934e-02f, 2.11603209e-01f, 5.21719456e-02f,
  1.61739618e-01f, 2.07320169e-01f, -1.05238497e-01f, 2.32528802e-02f, 2.39702821e-01f, -3.10087809e-03f, -2.86588281e-01f, -1.30151063e-01f, -1.81892172e-01f, -1.66335508e-01f,
  7.66773671e-02f, 1.06085606e-01f, 4.34597284e-02f, 4.59860340e-02f, 1.52081698e-01f, 1.15619831e-01f, -3.23069729e-02f, -3.76237929e-02f, 7.83524364e-02f, 2.73982603e-02f,
  3.57652120e-02f, -1.22949995e-01f, 1.21046901e-01f, 4.86290194e-02f, 1.74618170e-01f, -1.81770343e-02f, 4.69781570e-02f, -1.47352917e-02f, -6.45899633e-03f, 1.01495326e-01f,
  -7.92986676e-02f, -6.42572716e-02f, 7.12534860e-02f, -1.49721459e-01f, -3.59256044e-02f, -9.12458226e-02f, -8.55046436e-02f, -2.03743368e-01f, -9.60659534e-02f, -1.00244051e-02f,
  3.81040983e-02f, 1.04116052e-01f, 9.86219272e-02f, 7.19439238e-02f, -9.67657007e-03f, -3.79280336e-02f, 7.09956046e-04f, -1.43071068e-02f, 9.43764150e-02f, -3.83295701e-03f,
  1.74315032e-02f, -2.39941403e-02f, 9.13161933e-02f, -7.57531598e-02f, -5.38600832e-02f, 1.19658493e-01f, 2.31991578e-02f, -6.33109584e-02f, -5.01934662e-02f, -1.27416894e-01f,
  9.18736309e-02f, 3.90026756e-02f, -8.79811049e-02f, -3.97039466e-02f, -1.51036475e-02f, -2.89431885e-02f, 2.54444554e-02f, 1.68510731e-02f, 7.35352337e-02f, -2.78259572e-02f,
  -1.50875542e-02f, -2.36183945e-02f, 3.79982311e-03f, -2.22178306e-02f, -8.06508809e-02f, 4.69982810e-02f, -1.17325578e-02f, 1.09998979e-01f, 3.09400428e-02f, 6.95803985e-02f,
  -7.10736215e-02f, 6.55255690e-02f, 2.84414571e-02f, -7.02937990e-02f, -1.30492747e-02f, -4.11656126e-02f, -1.73465371e-01f, -7.09435493e-02f, -2.20738947e-01f, -5.05529018e-03f,
  2.33428087e-02f, 5.42528182e-02f, 6.90132678e-02f, 2.29429230e-02f, 1.07723184e-01f, -1.29228711e-01f, -4.41928115e-03f, 4.33507934e-03f, 6.08345214e-03f, -6.12739138e-02f,
  -4.90060478e-01f, 1.02278605e-01f, -2.39583969e-01f, -2.04880774e-01f, 1.33945614e-01f, -2.35522076e-01f, -6.52349070e-02f, 1.19446255e-01f, -1.75776720e-01f, 2.85707951e-01f,
  1.95850268e-01f, -2.25122675e-01f, 3.69458437e-01f, -2.79756427e-01f, -3.10062230e-01f, -4.07945663e-02f, -3.57259989e-01f, -1.72010407e-01f, -1.56550646e-01f, -3.05197691e-03f,
  -1.84372172e-01f, -4.08612527e-02f, -1.77226782e-01f, 2.22624287e-01f, -9.55792814e-02f, 8.95753875e-02f, 2.21858278e-01f, 1.35771438e-01f, -1.25310063e-01f, -5.85361496e-02f,
  -4.50950190e-02f, 3.88525017e-02f, -1.27139187e-03f, -2.92545501e-02f, 2.64567137e-02f, 1.02524571e-01f, 2.38244887e-02f, 2.86696311e-02f, -3.72644067e-02f, -4.60440032e-02f,
  -3.95179391e-02f, 1.69003755e-02f, -1.23307161e-01f, -4.61142361e-02f, -3.93277556e-02f, 2.33761556e-02f, -1.21480003e-02f, -1.34596661e-01f, 8.95294920e-02f, -6.04637675e-02f,
  4.66386601e-02f, 1.07223466e-02f, -2.04567742e-02f, 5.39110089e-03f, -7.11693987e-02f, -9.04497318e-03f, -5.44786379e-02f, -4.75271493e-02f, -8.48683417e-02f, -3.61005217e-02f,
  -4.26544473e-02f, 2.37473305e-02f, 1.03293834e-02f, 6.10790066e-02f, -5.49939573e-02f, 7.74399862e-02f, -7.72114620e-02f, -5.55222631e-02f, 8.28841235e-03f, 1.66555420e-02f,
  2.22518239e-02f, 4.42476422e-02f, 5.66058466e-03f, -1.27453646e-02f, -5.10849655e-02f, -1.03113569e-01f, -1.01300202e-01f, 3.78105566e-02f, -1.12377778e-01f, -5.38737848e-02f,
  1.92258041e-02f, 2.87077595e-02f, 5.26837707e-02f, 1.34759322e-01f, 4.00446020e-02f, -3.94659638e-02f, 1.80404391e-02f, -7.66445473e-02f, 3.46748494e-02f, 1.18638733e-02f,
  1.24127001e-01f, 2.09363356e-01f, 1.26268625e-01f, 1.90001465e-02f, 9.38068479e-02f, 5.17801894e-03f, 2.33466942e-02f, -8.55453387e-02f, 3.61192934e-02f, 5.70401363e-02f,
  1.37847392e-02f, 2.72822622e-02f, -2.45152432e-02f, -2.01965254e-02f, -3.35176196e-03f, 7.31713623e-02f, 9.25932676e-02f, -4.01012599e-02f, -3.87856667e-03f, -5.82778007e-02f,
  8.97556990e-02f, -3.98471300e-03f, -7.86907822e-02f, 3.06936614e-02f, -4.63918597e-02f, 5.74495550e-03f, 1.84325464e-02f, 2.68063881e-02f, 3.28786932e-02f, -3.76868621e-02f,
  -6.44435287e-01f, 4.11029160e-01f, -4.13408093e-02f, -6.17231168e-02f, 6.67316094e-02f, -2.68227577e-01f, 1.31869931e-02f, 3.04544307e-02f, -3.16659287e-02f, 2.65203416e-01f,
  1.12230740e-01f, 3.54660228e-02f, 1.76064774e-01f, 1.08698606e-01f, -4.46182579e-01f, 4.17609923e-02f, -2.88405478e-01f, -1.36613607e-01f, 1.58554185e-02f, -4.56983782e-02f,
  -1.56888783e-01f, 9.76816863e-02f, -1.05655909e-01f, 1.39936835e-01f, 4.50190157e-02f, -5.26874661e-02f, 5.36003746e-02f, 1.80691868e-01f, -6.13569915e-02f, -9.75743756e-02f,
  -8.88241753e-02f, 1.37630656e-01f, 3.58515829e-02f, -2.90400404e-02f, -1.13778591e-01f, -7.93230683e-02f, 1.03460634e-02f, 4.18050028e-02f, -4.73085418e-03f, -6.74501359e-02f,
  -4.39228974e-02f, -5.48927896e-02f, -1.48364194e-02f, 1.95864476e-02f, -1.77625604e-02f, 4.58651669e-02f, 1.26347572e-01f, -6.41016290e-02f, 4.49890085e-02f, -2.34415829e-02f,
  1.15294822e-01f, -6.29655197e-02f, -4.40629795e-02f, -6.82818666e-02f, -7.33898431e-02f, 2.72762403e-02f, -4.56388369e-02f, -5.22343488e-03f, -4.65631485e-02f, -7.34407306e-02f,
  7.19923601e-02f, -6.97272420e-02f, 6.35549575e-02f, 3.40135023e-02f, 1.06322644e-02f, 1.02728046e-02f, 5.86996675e-02f, -3.70644629e-02f, -4.02784944e-02f, -2.12766565e-02f,
  -5.32741696e-02f, -2.50454824e-02f, -4.28573135e-03f, -4.54229712e-02f, -2.61635818e-02f, -2.03908999e-02f, -4.34867367e-02f, -1.88256870e-03f, -1.25214830e-01f, -3.33801433e-02f,
  9.34752226e-02f, -3.65762450e-02f, 1.01115908e-02f, -6.20018691e-02f, -3.89512219e-02f, 4.44750711e-02f, 2.69126520e-02f, 1.51490569e-02f, -3.97416577e-02f, -3.15327495e-02f,
  -3.98996502e-01f, -2.51310635e-02f, 1.02220908e-01f, 5.86060844e-02f, 4.66770791e-02f, -1.26362503e-01f, -2.35706288e-02f, -7.17621967e-02f, -1.42645072e-02f, 5.45721576e-02f,
  -5.49234562e-02f, 1.61229894e-02f, -2.34257311e-01f, -6.61820397e-02f, -4.62399088e-02f, -7.66535625e-02f, 9.05214101e-02f, 6.02612756e-02f, -8.42260718e-02f, -1.59855019e-02f,
  2.12640502e-02f, 9.69637409e-02f, 5.77866025e-02f, 6.92575797e-02f, -1.23633193e-02f, -6.74030557e-02f, -1.03207476e-01f, 1.13701738e-01f, 6.67215288e-02f, -2.39785258e-02f,
  2.26600349e-01f, -2.62423661e-02f, -1.94218457e-01f, 8.15372728e-03f, -6.93388209e-02f, -1.99950233e-01f, -8.58999640e-02f, 1.33727744e-01f, -3.32874209e-01f, 3.97509225e-02f,
  1.14168249e-01f, -1.97549343e-01f, 1.26476306e-03f, 1.22168116e-01f, 3.34901325e-02f, -2.60815382e-01f, 2.75422722e-01f, 8.11877698e-02f, -4.48629335e-02f, 3.09642553e-01f,
  1.54775754e-01f, 3.09630245e-01f, 4.74980511e-02f, 2.09877133e-01f, 2.75307596e-01f, 9.50657278e-02f, 3.66448134e-01f, 1.20100006e-02f, 2.60808021e-01f, 2.62862984e-02f,
  1.32789779e-02f, 3.87319662e-02f, -1.89901125e-02f, -1.77891374e-01f, 1.04396731e-01f, 1.15855910e-01f, 3.61989029e-02f, -1.04981912e-02f, 1.25427591e-02f, -1.01041488e-01f,
  7.30859488e-02f, 1.90550089e-02f, -2.05156244e-02f, -4.86850254e-02f, 3.03240158e-02f, -1.32869957e-02f, -7.29333311e-02f, -7.37243965e-02f, -1.78444222e-01f, 1.87641848e-02f,
  -2.06111781e-02f, -2.35355087e-02f, 5.13096601e-02f, -1.70227773e-02f, -1.54430956e-01f, 2.25833245e-02f, -2.61694025e-02f, 4.25078114e-03f, -3.19051296e-02f, -2.77826516e-03f,
  1.26532570e-01f, 4.22332101e-02f, 7.54955970e-03f, -6.39179572e-02f, -3.33716609e-02f, -6.88153729e-02f, -6.93267509e-02f, 1.79653242e-02f, -5.72075211e-02f, -5.23247793e-02f,
  6.11144071e-03f, 2.17635036e-02f, -5.17929271e-02f, -7.48220016e-04f, 1.19838208e-01f, -6.20261393e-02f, 6.00719936e-02f, -5.12935109e-02f, -1.01173587e-01f, -9.52007324e-02f,
  -4.99246977e-02f, 4.68262769e-02f, -4.06907313e-02f, 7.49878064e-02f, -2.17737481e-02f, -5.21349460e-02f, 9.33060050e-02f, -7.16029108e-02f, -4.26373444e-02f, -3.74461822e-02f,
  1.19386591e-01f, 1.38107985e-01f, -9.98835638e-02f, 3.05513991e-03f, -4.35764864e-02f, 2.48114690e-02f, -4.10295943e-05f, 7.24226311e-02f, 6.01699501e-02f, 9.43237841e-02f,
  1.69498205e-01f, 4.97273952e-02f, -1.37230363e-02f, -3.45881209e-02f, -7.91262388e-02f, 2.91390773e-02f, 4.13760208e-02f, -1.17188886e-01f, 1.92268882e-02f, 8.04617479e-02f,
  5.96652292e-02f, 4.92998287e-02f, -8.86682142e-03f, -5.05411997e-02f, -2.83581931e-02f, -5.70150185e-03f, 1.20790228e-02f, 4.50118408e-02f, 7.10461140e-02f, -6.90829158e-02f,
  -1.31814122e-01f, -2.03083053e-01f, 8.51404574e-03f, 1.79400146e-01f, 7.15726316e-02f, -5.49500175e-02f, -1.10611118e-01f, 6.16713846e-03f, -1.48297906e-01f, -2.44906515e-01f,
  -1.09858371e-01f, 6.71075098e-03f, -1.94515422e-01f, 1.88809708e-01f, 3.36176187e-01f, -2.79257111e-02f, 1.03352204e-01f, 5.20608795e-04f, 1.21601231e-01f, 9.16423202e-02f,
  2.60775864e-01f, 2.56613106e-01f, 3.44237149e-01f, 2.60499954e-01f, 9.70507115e-02f, 1.01634428e-01f, 2.09327608e-01f, 1.40396908e-01f, 1.88040584e-01f, 1.22542955e-01f,
  -7.04836771e-02f, 6.66650478e-03f, 4.86619072e-03f, -7.44945258e-02f, 5.63033111e-02f, 4.97773029e-02f, -1.47653325e-02f, 2.81192120e-02f, 1.08795121e-01f, 6.58011511e-02f,
  -1.10578574e-01f, 1.31866440e-01f, 6.53780997e-02f, 4.67721224e-02f, -1.95041914e-02f, 6.15930408e-02f, 6.06808066e-03f, 1.36120897e-02f, -7.57978782e-02f, -1.08411826e-01f,
  3.34828496e-02f, -5.58432341e-02f, 3.61129493e-02f, 1.01156645e-01f, 8.21369439e-02f, -3.35757202e-03f, -3.39206494e-02f, 1.38284899e-02f, 3.16452794e-02f, -8.66832957e-03f,
  -8.69090632e-02f, -4.57682274e-03f, -3.31578456e-04f, 6.31242767e-02f, 1.74313150e-02f, 6.20687529e-02f, -4.62220721e-02f, 4.63883691e-02f, 4.53535318e-02f, -2.44943071e-02f,
  8.29142705e-02f, 4.45010886e-02f, -1.45127699e-02f, -5.68562374e-03f, 3.82650532e-02f, 6.93915505e-03f, -2.22643875e-02f, 1.54323548e-01f, 5.50920283e-03f, 8.63585845e-02f,
  -1.13233097e-01f, 6.47651106e-02f, -4.80871350e-02f, -8.06968659e-03f, 6.37778118e-02f, -1.95647310e-02f, -8.33237078e-03f, -1.38252974e-02f, 7.94947594e-02f, 3.48209776e-02f,
  -1.54415652e-01f, -7.04293251e-02f, 4.95720431e-02f, -6.02656379e-02f, -5.04265958e-03f, 7.78559223e-02f, 2.22043637e-02f, -1.80859081e-02f, 3.63662541e-02f, -2.47727968e-02f,
  1.01257786e-01f, 1.23915054e-01f, -1.27885863e-01f, -4.35759360e-03f, 2.25848332e-02f, -7.27238730e-02f, 3.38602997e-02f, -1.45647619e-02f, -3.74146178e-02f, -4.75445054e-02f,
  -1.78726837e-02f, -6.01472333e-02f, 1.23396747e-01f, 1.92297205e-01f, 4.91623692e-02f, -1.06531270e-01f, 6.86833858e-02f, -7.94769824e-02f, 1.47645429e-01f, 3.37867886e-02f,
  4.92285565e-02f, -5.57061695e-02f, -2.14278400e-01f, -1.99860886e-01f, -1.99282691e-01f, -2.53865600e-01f, -1.65668443e-01f, -1.28149882e-01f, 4.62770388e-02f, 2.84863174e-01f,
  -1.71467558e-01f, 1.24258272e-01f, 1.50061563e-01f, -2.90640533e-01f, -2.03465357e-01f, 1.26385912e-01f, -2.23136336e-01f, -1.57404076e-02f, -2.95429537e-03f, -2.62460187e-02f,
  -1.25726521e-01f, -6.03574440e-02f, -1.16866536e-01f, -1.23512432e-01f, -3.21058720e-01f, -2.40890067e-02f, 9.25371200e-02f, -1.60543263e-01f, -2.38316908e-01f, -8.27838778e-02f,
  -1.80799156e-01f, 2.81407014e-02f, -8.47723484e-02f, -1.52027905e-02f, -7.87442103e-02f, 1.00216623e-02f, -7.40500493e-03f, -1.88094918e-02f, 1.21109411e-02f, 4.32253666e-02f,
  1.94746941e-01f, 3.73365246e-02f, -9.77455638e-03f, 4.21264879e-02f, -8.97311345e-02f, -4.00572978e-02f, -2.93272324e-02f, 2.38118271e-04f, -2.93234154e-03f, -8.45340937e-02f,
  5.29781878e-02f, 6.02683574e-02f, -4.89259660e-02f, 8.53437185e-02f, 8.74393992e-03f, -1.41056716e-01f, -7.82018825e-02f, -4.22784016e-02f, -9.89404414e-03f, -4.68669273e-02f,
  3.96236219e-02f, 2.88655031e-02f, 3.13317776e-03f, -3.72825824e-02f, -4.11462151e-02f, -5.60988411e-02f, 2.11386736e-02f, 2.23980541e-03f, 3.23068015e-02f, 1.55824861e-02f,
  -2.39714049e-02f, -1.87729709e-02f, 5.20492718e-03f, 4.44545411e-02f, -4.37983237e-02f, -4.46173595e-04f, 1.75314900e-02f, -3.68866473e-02f, -6.68165237e-02f, 1.09395115e-02f,
  8.89750794e-02f, 6.84613883e-02f, 3.01432833e-02f, 5.81621099e-03f, -1.08530678e-01f, 2.92762425e-02f, 9.86632407e-02f, -3.42465788e-02f, 3.61842550e-02f, 2.40647476e-02f,
  7.21539953e-04f, 7.60362372e-02f, 5.84260337e-02f, 4.54515778e-02f, 6.77048415e-02f, 5.07799536e-02f, -9.55881551e-02f, -6.36652410e-02f, -1.18136413e-01f, -6.32287487e-02f,
  -1.02940956e-02f, 7.61176497e-02f, 1.23670220e-01f, -3.76220904e-02f, 4.20481665e-03f, -1.68566704e-02f, 2.25368906e-02f, 1.63763165e-01f, 5.32115065e-02f, -2.57511549e-02f,
  9.43168476e-02f, 1.03275590e-01f, 1.28369153e-01f, 1.17652088e-01f, 1.48047164e-01f, -1.89407859e-02f, 3.78183089e-02f, -5.90507686e-03f, 8.51541311e-02f, 1.05508313e-01f,
  -4.92701828e-01f, 9.10877511e-02f, -1.85767666e-01f, 6.19596355e-02f, -2.07707956e-01f, 9.82635766e-02f, 1.66967869e-01f, -1.80196241e-01f, -2.27794647e-01f, 1.64928764e-01f,
  2.10981771e-01f, -1.89613566e-01f, 1.27435282e-01f, 2.32803136e-01f, -3.79687756e-01f, 1.18169211e-01f, 1.87203303e-01f, 1.15761720e-01f, 7.70737976e-02f, 2.01690737e-02f,
  8.38713571e-02f, 1.77632689e-01f, 8.83861706e-02f, 1.86211079e-01f, -6.64979890e-02f, -3.63332313e-03f, 1.97581455e-01f, -1.97540261e-02f, 8.78774226e-02f, -1.06075466e-01f,
  -2.68764734e-01f, -2.91669428e-01f, -1.40404046e-01f, -6.06894344e-02f, -1.38386115e-02f, 5.65577007e-04f, 5.63093238e-02f, -1.72699168e-02f, 5.09653687e-02f, -8.63507856e-03f,
  -2.02099746e-03f, -2.27511693e-02f, 2.45262384e-02f, -1.29415281e-02f, -7.00868219e-02f, -1.52383044e-01f, 2.99023613e-02f, 9.17766020e-02f, 1.69621187e-03f, -1.09401070e-01f,
  -3.10448352e-02f, 1.25027046e-01f, 6.93517253e-02f, 1.48308396e-01f, -4.33841720e-02f, 6.67242110e-02f, -5.82395941e-02f, -2.59521194e-02f, -5.27554937e-02f, 2.14425661e-03f,
  -8.02401379e-02f, 7.01419264e-02f, -1.24141663e-01f, -4.74197492e-02f, 9.18440893e-03f, -1.35988425e-02f, 2.28602644e-02f, 2.77834721e-02f, -2.14038324e-02f, 5.51315583e-02f,
  -3.17481048e-02f, -2.40689330e-02f, -4.29402962e-02f, 5.71531244e-02f, 4.44438756e-02f, -2.46581994e-02f, 3.42238345e-03f, -1.02730013e-01f, 6.34845197e-02f, 1.45373428e-02f,
  -2.77468120e-03f, -1.44939246e-02f, 3.16146277e-02f, -3.33144628e-02f, 6.90993574e-03f, 1.26927234e-02f, 1.11462176e-01f, 2.24301616e-07f, 2.40473580e-02f, 3.85166258e-02f,
  -2.89789319e-01f, -3.10150743e-01f, -5.70435002e-02f, -1.14611812e-01f, -6.96411878e-02f, -4.04570997e-03f, 8.35782066e-02f, -4.85413074e-02f, 3.28044966e-02f, -1.11112900e-01f,
  2.92911232e-02f, 2.83449441e-02f, 7.44718462e-02f, 2.30995361e-02f, -5.80700673e-02f, 3.47913727e-02f, -4.87372950e-02f, -5.00118881e-02f, -4.45207097e-02f, -7.30506927e-02f,
  -2.20453683e-02f, -1.11273587e-01f, 8.96708444e-02f, -5.10509424e-02f, 3.26169655e-02f, 1.28637813e-02f, -5.77353537e-02f, 5.06392233e-02f, 5.77689661e-03f, 8.88736844e-02f,
  -1.82086930e-01f, -1.22651391e-01f, 2.59488106e-01f, 9.80831608e-02f, 2.89188236e-01f, 4.30593669e-01f, 3.52857143e-01f, 1.12182401e-01f, 3.25247854e-01f, -1.54408947e-01f,
  -2.78680682e-01f, -8.57241154e-02f, 4.51012775e-02f, -6.79256618e-02f, 3.38240147e-01f, 2.06588939e-01f, 9.87075046e-02f, 1.45923495e-02f, 7.94906691e-02f, -1.35284111e-01f,
  -6.32920936e-02f, -2.85539657e-01f, 7.41015226e-02f, -3.18965077e-01f, -1.33215517e-01f, -1.62735313e-01f, -2.95652777e-01f, 2.61874497e-01f, -3.09185594e-01f, 9.89755616e-02f,
  -2.72513926e-01f, -4.96645048e-02f, -1.79258347e-01f, -8.45661014e-02f, -7.99135268e-02f, -8.91195517e-03f, 1.94827497e-01f, 1.43354490e-01f, 3.60054635e-02f, 3.24892439e-02f,
  -4.09449041e-02f, -4.64507490e-02f, -9.20860469e-02f, 3.78440544e-02f, 4.95470427e-02f, -6.72113001e-02f, 1.28832972e-02f, 7.03390688e-03f, 8.42422694e-02f, 1.15361594e-01f,
  1.43459454e-01f, 3.67057025e-02f, 4.87637296e-02f, 2.87951231e-02f, 6.63292557e-02f, 5.97563684e-02f, 1.85514167e-02f, 1.37346119e-01f, 4.16316129e-02f, 1.17930897e-01f,
  1.15606084e-01f, 9.20576602e-02f, -3.83211789e-03f, -5.14864735e-02f, 1.36909746e-02f, 3.27279838e-03f, 2.77089179e-02f, -4.70554419e-02f, -1.15271127e-02f, 4.99556623e-02f,
  -8.58241692e-02f, 1.21309236e-02f, 7.37246796e-02f, 7.29771927e-02f, -8.01088139e-02f, -6.97532371e-02f, -7.41713494e-02f, -5.81611134e-02f, -8.65384117e-02f, 2.62709185e-02f,
  -3.56681049e-02f, 6.56537041e-02f, -8.25764462e-02f, -3.41357663e-02f, 8.56657922e-02f, 6.02350309e-02f, -4.20827195e-02f, 1.68104079e-02f, -4.37499210e-02f, 6.86494857e-02f,
  -1.61358386e-01f, -1.09030724e-01f, -1.26456484e-01f, -1.78796828e-01f, -1.13706780e-03f, -1.04435146e-01f, 4.92819101e-02f, -7.78082311e-02f, 4.64834943e-02f, -7.93390647e-02f,
  -1.11939892e-01f, -4.92070056e-02f, -5.46290502e-02f, 3.49254869e-02f, -1.27911447e-02f, -1.44158415e-02f, 4.86997999e-02f, -8.15713629e-02f, -4.53220531e-02f, -1.00286834e-01f,
  -5.07526770e-02f, 1.18735647e-02f, 1.74847338e-02f, -4.35576141e-02f, -1.70278430e-01f, -4.65601943e-02f, -1.52103268e-02f, 5.16835898e-02f, 1.78387035e-02f, 1.38394265e-02f,
  -4.72820163e-01f, 2.53411770e-01f, -5.77197373e-02f, -1.86153650e-01f, -9.50268283e-02f, -4.00264412e-01f, -2.61679590e-01f, -3.63371372e-02f, 5.03583178e-02f, 1.68067336e-01f,
  2.92553958e-02f, 4.49320562e-02f, 2.99050748e-01f, -5.94334267e-02f, -2.61367440e-01f, 2.73369610e-01f, -2.80447870e-01f, -9.66362432e-02f, 1.01007454e-01f, -1.17487736e-01f,
  -1.18454009e-01f, -2.98670866e-02f, -3.27958949e-02f, 1.79588020e-01f, -9.20973569e-02f, -1.35535046e-01f, -3.35736535e-02f, 1.66393697e-01f, -1.16133690e-01f, 9.36749950e-02f,
  -3.67135793e-01f, -9.14892461e-03f, -2.04962149e-01f, -1.81639135e-01f, -2.46417478e-01f, -1.54166415e-01f, -2.08253905e-01f, -3.18871774e-02f, 1.95498914e-02f, -8.16232432e-03f,
  5.53177819e-02f, -5.06640971e-02f, -6.41843230e-02f, 1.30771026e-01f, -1.01334266e-01f, 2.56610252e-02f, 8.36629327e-03f, -4.58947942e-02f, -1.13496922e-01f, 6.68191463e-02f,
  8.53377953e-02f, -3.74651067e-02f, -1.09698117e-01f, -3.43736522e-02f, 1.01164738e-02f, -8.32583290e-03f, -4.77536693e-02f, 1.36142792e-02f, -1.95629716e-01f, -3.12860683e-02f,
  -7.40681356e-03f, -6.41387552e-02f, -6.13368303e-02f, -1.98849682e-02f, 4.49992530e-02f, 8.64489675e-02f, -5.32015339e-02f, 6.54679164e-02f, -1.23122975e-01f, 3.74179818e-02f,
  7.79016735e-03f, -9.81567726e-02f, 8.22120346e-03f, -7.69645795e-02f, -4.30903584e-02f, -5.24634868e-02f, 3.47258858e-02f, -8.21911544e-03f, 3.07275318e-02f, -5.43652885e-02f,
  -2.59660538e-02f, -2.49794237e-02f, -6.52119704e-03f, -1.02440901e-01f, -1.00624099e-01f, 7.50813708e-02f, -5.21726497e-02f, -2.99739484e-02f, 5.97770028e-02f, -2.03733500e-02f,
  -5.28903782e-01f, -2.33003899e-01f, -1.89228743e-01f, -1.66068137e-01f, -6.32466078e-02f, -1.38906956e-01f, -8.01174808e-03f, 6.12700172e-02f, -1.10152565e-01f, -1.14704490e-01f,
  -2.13941094e-02f, -1.23434365e-01f, -8.60310346e-03f, -4.45301943e-02f, 2.15752609e-02f, -3.47136110e-02f, -3.71741764e-02f, -3.63417007e-02f, -1.63446471e-01f, -6.84328154e-02f,
  -1.03473306e-01f, 6.57043457e-02f, -4.37888168e-02f, -8.11723173e-02f, -1.27946764e-01f, -5.68324551e-02f, -3.81070236e-03f, -7.80997947e-02f, -2.05553472e-02f, -4.73691011e-03f,
  1.24996223e-01f, -9.73314270e-02f, 2.74656385e-01f, 2.17034161e-01f, 1.25287417e-02f, 1.70354724e-01f, 3.05293739e-01f, -2.87592173e-01f, 7.35203736e-03f, -6.74347505e-02f,
  -1.36349097e-01f, 1.77969918e-01f, 2.47350894e-03f, -2.64974833e-01f, -1.08739594e-03f, -7.82020986e-02f, 3.39808874e-02f, 1.49207562e-01f, -7.56535158e-02f, 9.60693359e-02f,
  -9.92898718e-02f, -3.45780522e-01f, -2.14684978e-01f, -2.83399403e-01f, 7.90192857e-02f, 1.59412295e-01f, -2.20111031e-02f, 1.59070402e-01f, 5.24410866e-02f, -4.96530607e-02f,
  5.03281355e-02f, 1.15511287e-02f, 9.51832160e-02f, 4.16218899e-02f, 2.86884001e-03f, -4.03519906e-03f, -5.77781796e-02f, -4.64098305e-02f, 1.30082304e-02f, 6.07668608e-03f,
  1.97893471e-01f, -8.30856338e-02f, -6.95743859e-02f, -1.41883008e-02f, 1.02833798e-02f, 5.29205091e-02f, 1.20599335e-02f, -2.99186204e-02f, 3.45915891e-02f, 6.06225990e-03f,
  1.13267452e-01f, 5.97221311e-03f, 8.19152743e-02f, 2.68330183e-02f, 1.00627616e-01f, 1.72160361e-02f, 2.09544450e-01f, 4.37638983e-02f, 4.26160991e-02f, -6.16653338e-02f,
  -1.21080406e-01f, 3.33888792e-02f, -5.24260141e-02f, -2.94287428e-02f, -7.23602548e-02f, -6.52329624e-02f, -1.42383231e-02f, -4.07253765e-02f, 6.96417456e-03f, 8.45611691e-02f,
  -3.47592831e-02f, 4.19817194e-02f, -1.07544474e-01f, 9.02350396e-02f, -9.93237346e-02f, -5.06327376e-02f, -4.81969491e-02f, 2.45018974e-01f, 5.43804318e-02f, -7.85250664e-02f,
  -1.20684147e-01f, -7.34772459e-02f, 4.49665897e-02f, 9.33437645e-02f, 8.50568265e-02f, 7.52022071e-03f, -1.01169288e-01f, 3.14479247e-02f, 2.58961432e-02f, 9.13328826e-02f,
  9.14845690e-02f, 2.64215469e-02f, 6.71066120e-02f, 5.22906780e-02f, 3.54380049e-02f, -7.64056072e-02f, -8.48888308e-02f, 8.85509402e-02f, 1.81508482e-01f, -9.36136097e-02f,
  6.98501170e-02f, -1.61109128e-04f, 3.82063501e-02f, 3.85058597e-02f, -5.40661030e-02f, -3.60129960e-02f, 1.13413490e-01f, 1.38751231e-02f, 7.22048730e-02f, -2.84374971e-02f,
  1.07371457e-01f, 1.28156453e-01f, -5.05843945e-02f, 2.56123058e-02f, 6.37385845e-02f, 6.51404634e-02f, 1.07521966e-01f, 1.27766177e-01f, -2.64890920e-02f, -1.35809565e-02f,
  -4.38549221e-02f, 8.50117728e-02f, -2.08114997e-01f, 1.55717686e-01f, 2.00996876e-01f, 2.96596229e-01f, 3.74250084e-01f, 3.40155840e-01f, 3.52430642e-01f, 2.18135610e-01f,
  1.77940890e-01f, 4.68839258e-02f, 9.87823829e-02f, 1.25289172e-01f, -2.28394076e-01f, -8.74044374e-02f, 3.04338206e-02f, 1.91240847e-01f, 2.63131738e-01f, 5.01214899e-02f,
  1.10296316e-01f, 1.01077169e-01f, -2.21612200e-01f, -3.73412110e-02f, 7.28260577e-02f, -1.36826009e-01f, -1.36572018e-01f, -1.86746828e-02f, -1.04590610e-01f, 1.29038587e-01f,
  6.89658076e-02f, 1.15798257e-01f, 1.28723472e-01f, -3.25237066e-02f, 8.92669242e-03f, 9.87344831e-02f, -1.17861219e-02f, 9.27607939e-02f, 6.01817742e-02f, 1.67451620e-01f,
  2.65177675e-02f, -4.34362926e-02f, 4.52185012e-02f, 7.07952380e-02f, 4.33555953e-02f, -5.27716102e-03f, 3.96683067e-02f, 3.96557525e-02f, 1.23711094e-01f, 8.78457353e-02f,
  -6.92379847e-02f, -6.33822307e-02f, 9.30403918e-02f, 4.86549772e-02f, 8.37908983e-02f, 1.31122336e-01f, 1.45782558e-02f, -9.94623005e-02f, -6.24256488e-03f, 1.16004786e-02f,
  5.14493277e-03f, 1.49107382e-01f, 7.51763433e-02f, 1.61485747e-02f, 9.02670715e-03f, 5.31566888e-03f, -3.41646676e-03f, -1.91971578e-03f, -7.99519494e-02f, 1.01630412e-01f,
  -2.53373366e-02f, 5.84201887e-02f, 1.23068899e-01f, -3.74721959e-02f, 2.97152083e-02f, -5.66673949e-02f, 2.17666831e-02f, -5.67591488e-02f, 1.14049479e-01f, -1.34304091e-01f,
  -4.73379940e-02f, -2.86708474e-02f, 1.89764965e-02f, 8.13715160e-02f, 2.96149831e-02f, 7.40831122e-02f, 4.07001972e-02f, -2.98850480e-02f, 1.27489865e-02f, -2.93028411e-02f,
  1.35068506e-01f, 2.58959532e-01f, 4.41258363e-02f, 3.81417433e-03f, -5.41618466e-02f, 1.91414189e-02f, 1.12566473e-02f, 3.57541554e-02f, 6.27532089e-03f, 4.40901592e-02f,
  -7.05988184e-02f, 3.67721776e-04f, -1.42346680e-01f, -8.45104605e-02f, -1.70293078e-01f, 1.16167948e-01f, -7.41729438e-02f, 4.38680965e-03f, -1.15037404e-01f, -8.98518339e-02f,
  -5.83419055e-02f, -2.77478695e-02f, 1.10521670e-02f, 2.35105194e-02f, 1.12703152e-01f, -6.21393733e-02f, 7.91280791e-02f, -3.81284468e-02f, -4.02279198e-02f, -8.76465887e-02f,
  -2.80126929e-01f, -3.24614614e-01f, -7.66499713e-02f, 3.45207065e-01f, -1.50227193e-02f, -1.55181006e-01f, -3.68601143e-01f, -1.22595839e-01f, -9.90242586e-02f, -1.36100888e-01f,
  -3.60472873e-02f, 5.49356341e-02f, -4.73915368e-01f, 3.65398258e-01f, 2.15530217e-01f, -2.51409888e-01f, 2.08381251e-01f, 1.93040416e-01f, -7.36702606e-02f, -1.64960101e-01f,
  6.72443137e-02f, 2.77957767e-01f, -1.02073476e-02f, 1.94894493e-01f, -1.65632949e-03f, 2.03441069e-01f, 5.54962829e-02f, -6.80953544e-03f, 3.30028176e-01f, 1.47000864e-01f,
  1.19343318e-01f, 1.19248956e-01f, -6.85127964e-03f, 1.71098337e-01f, -6.20732754e-02f, -1.39388945e-02f, 9.95195210e-02f, 4.07588296e-02f, -5.73413027e-03f, 5.47214672e-02f,
  -1.13305487e-01f, 2.12629572e-01f, 2.06339672e-01f, -1.62954610e-02f, 3.22194993e-02f, 1.19301617e-01f, 4.48631123e-02f, -1.16998628e-02f, 2.85304710e-02f, -2.97054462e-02f,
  -5.97746996e-03f, 2.36194301e-02f, -6.27841577e-02f, 1.49346977e-01f, 1.63003895e-02f, 2.09797304e-02f, 5.03913276e-02f, -6.17626198e-02f, 1.81200087e-01f, 1.16867647e-01f,
  -8.15709606e-02f, 9.75061506e-02f, -1.66651323e-01f, 5.24970563e-03f, -9.36492905e-02f, 7.31258392e-02f, 3.65797393e-02f, 4.17587794e-02f, -5.39052747e-02f, -5.60293794e-02f,
  1.01105206e-01f, -6.15363345e-02f, 5.30695803e-02f, -5.67618897e-03f, -4.62999158e-02f, -5.61613105e-02f, -3.35258357e-02f, -6.41680695e-03f, 2.06671166e-03f, -1.03081914e-03f,
  1.33408606e-01f, -2.98443921e-02f, 3.61866876e-02f, 1.43744290e-01f, 5.49230129e-02f, 1.90926343e-02f, 2.31923480e-02f, -3.69109437e-02f, -2.08724793e-02f, 2.37981994e-02f,
  3.53748128e-02f, 8.30716416e-02f, -7.47267902e-02f, 1.10194713e-01f, 3.17616463e-02f, -1.38418943e-01f, 4.09910940e-02f, -4.48664390e-02f, 1.22816965e-01f, -1.07495263e-01f,
  5.33349924e-02f, -1.97579414e-02f, -4.23365086e-02f, 1.44474521e-01f, 2.02596381e-01f, -5.98728023e-02f, -3.60495187e-02f, 1.20644860e-01f, 3.40347514e-02f, 1.09549336e-01f,
  -2.10384633e-02f, -4.09691595e-02f, -1.75449662e-02f, 5.76255098e-02f, 6.45714924e-02f, 1.54729420e-02f, -7.09136501e-02f, 6.19661026e-02f, 3.19818147e-02f, -1.61255822e-02f,
  7.05760494e-02f, -2.07461208e-01f, 2.18167350e-01f, 2.61687905e-01f, -5.30881733e-02f, 4.62368596e-03f, 2.78081805e-01f, -2.05206379e-01f, -2.53612638e-01f, -1.09520234e-01f,
  1.00291729e-01f, 2.30036780e-01f, 2.72973925e-01f, -1.50444821e-01f, 3.89139384e-01f, -5.30846529e-02f, -2.11463049e-01f, -3.54398265e-02f, 1.53968362e-02f, 2.00251028e-01f,
  1.08184628e-01f, -6.53545707e-02f, 2.60498226e-01f, -1.93745494e-01f, 1.21232145e-01f, 1.27459139e-01f, 1.80386916e-01f, 1.55202642e-01f, -6.14894070e-02f, 2.29748916e-02f,
  -1.37137219e-01f, -1.04139894e-01f, -9.98136252e-02f, -1.08750060e-01f, -2.39768624e-02f, -2.34927575e-05f, 5.56176640e-02f, 1.31091639e-01f, -1.64118523e-04f, 1.41785843e-02f,
  4.93554994e-02f, 5.84469847e-02f, -7.48524293e-02f, -4.92776930e-02f, -2.63091289e-02f, -1.99327972e-02f, -1.26250625e-01f, -2.27262340e-02f, 3.11411526e-02f, 6.50173239e-03f,
  3.41111794e-02f, -1.15200244e-01f, -2.05670930e-02f, -1.50661558e-01f, 1.19363442e-01f, -8.60824436e-02f, -1.14807166e-01f, 1.09065317e-01f, -7.48421475e-02f, -2.33765841e-02f,
  4.30920199e-02f, 5.92302792e-02f, 6.41690716e-02f, 4.20233980e-02f, 2.59266440e-02f, -2.15021502e-02f, -1.12213427e-02f, 3.89814228e-02f, -9.29836333e-02f, 7.46107921e-02f,
  -1.80543400e-02f, -3.01576126e-03f, -1.62024766e-01f, -1.31380454e-01f, 5.18632829e-02f, -2.06401516e-02f, 1.10228784e-01f, -1.36029422e-01f, -5.53633012e-02f, -2.29728427e-02f,
  9.90684424e-03f, -6.45234510e-02f, 8.79100859e-02f, 2.56207138e-02f, -7.98514858e-02f, 4.87256646e-02f, 1.47165153e-02f, 5.46331564e-03f, 2.62753628e-02f, 1.07262544e-01f,
  -1.26845092e-01f, 1.68512821e-01f, 7.49626160e-02f, -1.17386475e-01f, -5.34802340e-02f, 8.86797346e-03f, -1.50754843e-02f, -1.19349763e-01f, 9.43594798e-02f, 7.39591792e-02f,
  -1.77853867e-01f, 1.49636686e-01f, -4.34358604e-02f, -1.02516323e-01f, -2.76450031e-02f, 2.36485414e-02f, 8.66426006e-02f, -3.97296548e-02f, -2.63808873e-02f, 4.26069759e-02f,
  7.91557729e-02f, 1.49980098e-01f, 2.16089142e-03f, -7.14374334e-02f, -8.74166414e-02f, 1.62285399e-02f, 2.29323115e-02f, -5.79194352e-02f, -2.05224417e-02f, -1.09687066e-02f,
  1.58679634e-02f, -1.06406271e-01f, -3.31437737e-01f, -1.21716455e-01f, -7.75025263e-02f, 1.85695753e-01f, 2.08592862e-01f, -8.02422538e-02f, -1.25032902e-01f, 2.37595558e-01f,
  2.94955730e-01f, -1.53772920e-01f, 1.28915370e-01f, 3.58364940e-01f, -1.84296945e-03f, 1.67567343e-01f, 1.21189341e-01f, 1.87649548e-01f, -1.07391126e-01f, 1.00794673e-01f,
  -3.59755345e-02f, 3.44182760e-01f, -1.06542647e-01f, -5.17668240e-02f, 2.05290884e-01f, -2.17632234e-01f, -3.66379730e-02f, -1.91651165e-01f, 1.10980138e-01f, 7.39231780e-02f,
  3.73037308e-02f, -4.19228664e-03f, -1.13924062e-02f, 3.58219235e-03f, -3.27317379e-02f, -6.81690574e-02f, 4.37539164e-03f, -1.05987126e-02f, -5.83718084e-02f, -5.59939258e-02f,
  5.86117916e-02f, -4.60748421e-03f, -1.11023746e-02f, -9.48492438e-02f, -1.19446307e-01f, -2.33316105e-02f, -1.17751263e-01f, -4.11174027e-03f, -1.02741838e-01f, -2.28943024e-02f,
  2.22160723e-02f, 4.12059315e-02f, 8.38936120e-02f, -1.28356162e-02f, -5.58734499e-03f, 4.56983000e-02f, -6.86290041e-02f, 7.10388646e-02f, -8.62052198e-03f, -3.46050151e-02f,
  1.78080015e-02f, -3.29346918e-02f, 1.04451617e-02f, -7.65707064e-03f, -6.14871271e-02f, 4.59504500e-02f, 9.33934823e-02f, 4.15693561e-04f, -6.32214323e-02f, -2.27147490e-02f,
  6.89990632e-03f, -6.89080134e-02f, 6.04525693e-02f, -5.04156649e-02f, 8.89696181e-02f, -2.50776447e-02f, 3.41823176e-02f, -1.87425315e-02f, -6.71830326e-02f, -1.33954193e-02f,
  3.62705626e-02f, -1.14894873e-02f, 7.02662952e-03f, 1.38654411e-02f, 6.22212701e-02f, -8.93295035e-02f, 4.54396717e-02f, -7.19132414e-03f, 8.06277096e-02f, 6.95752427e-02f,
  6.63514733e-02f, -1.02163233e-01f, 1.50803421e-02f, -1.41108269e-02f, -8.85296762e-02f, -5.42066842e-02f, -3.56007949e-03f, 7.97592290e-03f, 1.02882767e-02f, -5.75340725e-02f,
  5.41090220e-02f, 8.45283493e-02f, -3.37778069e-02f, -7.88309649e-02f, -1.14432342e-01f, -1.96868498e-02f, 4.90612313e-02f, -1.02063818e-02f, -2.81333998e-02f, -7.62726292e-02f,
  6.83709458e-02f, 3.75260524e-02f, 5.99086769e-02f, -4.74438630e-02f, 4.17015851e-02f, -4.20407131e-02f, -1.83748733e-02f, -2.96934377e-02f, 1.05505131e-01f, 2.69367322e-02f,
  -3.60835791e-01f, -5.54080717e-02f, -1.98867992e-01f, -1.39973372e-01f, 1.89186454e-01f, 5.70980348e-02f, -1.32951245e-01f, 1.10660128e-01f, -2.46089116e-01f, 5.79806939e-02f,
  -3.24238986e-02f, -2.50169337e-01f, -1.61124393e-01f, -2.62672424e-01f, -3.15791517e-01f, -2.23323300e-01f, -2.16078818e-01f, -2.43514553e-01f, -1.64283708e-01f, -1.28658727e-01f,
  -8.75911117e-02f, 6.59186160e-03f, -1.78597525e-01f, 3.03333253e-01f, 4.82095145e-02f, 1.26906395e-01f, 2.17494473e-01f, 2.13540807e-01f, 1.52707085e-01f, -3.22976895e-02f,
  -3.21444832e-02f, -1.09727643e-01f, -1.49937317e-01f, 4.81584202e-03f, 8.48267451e-02f, 1.44059556e-02f, 2.03576330e-02f, -5.42344749e-02f, 2.53094733e-02f, 6.69347355e-03f,
  4.47616018e-02f, -5.83137870e-02f, -7.52098784e-02f, -4.93040197e-02f, 3.69732678e-02f, -2.35582162e-02f, -9.57990736e-02f, 3.37396562e-02f, -5.93128195e-03f, -1.50393829e-01f,
  -1.28927261e-01f, 2.56965421e-02f, 6.31948039e-02f, -1.12707511e-01f, -7.62590319e-02f, 6.54232278e-02f, 7.56951794e-02f, 6.70082793e-02f, 1.00198552e-01f, -2.12495849e-02f,
  3.87403555e-02f, -2.60445885e-02f, -6.89060660e-03f, -7.66610876e-02f, -5.73521778e-02f, 4.14688438e-02f, -5.40505722e-02f, 6.18752316e-02f, 1.13179814e-02f, 7.00579444e-03f,
  1.33710876e-01f, -6.28373325e-02f, -7.86485672e-02f, -4.64394912e-02f, -2.37522796e-02f, -2.14529447e-02f, 4.41028029e-02f, 3.12942378e-02f, 5.15047051e-02f, -5.47711626e-02f,
  3.05942222e-02f, 4.08452116e-02f, -1.88169964e-02f, 9.56837684e-02f, 4.57547978e-03f, -5.81860393e-02f, 8.24279338e-02f, -5.71879037e-02f, -1.83664132e-02f, 1.03499452e-02f,
  -3.30937877e-02f, 3.38567048e-02f, 5.92380278e-02f, 2.03177333e-02f, -3.16886939e-02f, 8.76711383e-02f, -6.68452978e-02f, 4.04880717e-02f, -5.65324612e-02f, -3.17916162e-02f,
  -7.81622832e-04f, 1.39152944e-01f, 9.18918625e-02f, -1.34271473e-01f, 8.25796798e-02f, -6.14769682e-02f, 9.50955525e-02f, 8.75799358e-02f, 1.37301803e-01f, 9.83393639e-02f,
  5.79618923e-02f, 1.29203811e-01f, 6.90845698e-02f, 1.21077999e-01f, 7.80744851e-02f, 1.81479335e-01f, -1.77206360e-02f, -3.27473395e-02f, 6.16290905e-02f, 3.10864132e-02f,
  5.85992858e-02f, 1.77836955e-01f, -1.53883621e-02f, -1.92883879e-01f, -1.71417724e-02f, -3.18696499e-01f, -2.16632217e-01f, -4.16844897e-02f, 1.97728336e-01f, 2.84376889e-02f,
  -1.44862875e-01f, 1.06321357e-01f, 1.12667039e-01f, -2.87404031e-01f, -3.10254306e-01f, -3.62340827e-03f, -3.38479847e-01f, -2.11579323e-01f, 8.33502188e-02f, -2.66360700e-01f,
  -1.08201072e-01f, -2.73955345e-01f, -2.24417031e-01f, -1.14787333e-01f, -8.60120505e-02f, 2.08269488e-02f, -1.42369971e-01f, 6.51560500e-02f, -1.68065786e-01f, 1.17468173e-02f,
  -2.82148868e-02f, -7.82924704e-03f, 5.42330146e-02f, 1.11994028e-01f, -1.15279533e-01f, -3.85996290e-02f, -2.43187360e-02f, 3.22570316e-02f, 1.58207193e-02f, 1.49505645e-01f,
  -3.77295315e-02f, 8.60778987e-02f, 2.42399815e-02f, 1.17339440e-01f, 1.51071340e-01f, 8.89453292e-02f, -4.45286222e-02f, 2.48232223e-02f, 1.29647180e-03f, 1.06780820e-01f,
  -1.10661253e-01f, 2.61347182e-02f, 5.45361871e-03f, 5.85749969e-02f, -1.70556959e-02f, 3.56150866e-02f, 2.95690503e-02f, 2.90159415e-02f, 4.53428328e-02f, -2.44551450e-02f,
  -1.01337954e-01f, -1.76745914e-02f, -4.13598455e-02f, 1.54779062e-01f, -1.58974882e-02f, 8.82384330e-02f, 5.23471721e-02f, -1.51945995e-02f, 1.07585371e-01f, 9.97944828e-03f,
  2.04627141e-02f, 1.36275426e-01f, -1.03050051e-02f, -5.97174875e-02f, -2.32965965e-02f, 7.91328028e-02f, -4.03952897e-02f, 8.90364274e-02f, -5.51813655e-02f, 2.25123260e-02f,
  1.07163027e-01f, -7.02632740e-02f, 7.26994053e-02f, 4.50431965e-02f, 6.16227947e-02f, 4.06635366e-02f, 5.82609586e-02f, 9.51445550e-02f, -3.75589058e-02f, -4.42199335e-02f,
  -1.84387505e-01f, -2.09943086e-01f, 1.82943307e-02f, 7.27224275e-02f, -4.74584065e-02f, 1.79407261e-02f, -1.33606166e-01f, 7.35143796e-02f, -5.92349507e-02f, -5.80355860e-02f,
  -7.27111399e-02f, -7.76994526e-02f, -2.44609714e-02f, 1.53700382e-01f, -3.21926251e-02f, -7.33117387e-02f, -6.71306998e-02f, 1.43810511e-02f, -1.34729341e-01f, 8.16018432e-02f,
  1.48085002e-02f, -8.03150088e-02f, 3.26107815e-02f, -7.39776865e-02f, 5.72430231e-02f, -1.17899636e-02f, -5.81136160e-03f, 1.01596095e-01f, -7.55263492e-02f, 5.80880512e-03f,
  5.20746648e-01f, -4.48600441e-01f, -5.46327420e-02f, 3.91206414e-01f, 3.20120424e-01f, 3.20127398e-01f, 3.56886894e-01f, 2.30008975e-01f, 3.53900224e-01f, -3.02172601e-01f,
  2.58356668e-02f, -2.16312423e-01f, -2.11861625e-01f, 2.05450684e-01f, 3.19357872e-01f, -1.15155265e-01f, 2.26319537e-01f, 5.62135428e-02f, 9.99936387e-02f, -8.97765718e-03f,
  1.98387951e-01f, 2.53091335e-01f, 1.02882441e-02f, -7.26226531e-03f, 1.11288510e-01f, -1.39843645e-02f, -1.57478303e-01f, -2.23041460e-01f, -3.73927467e-02f, 1.66790590e-01f,
  -2.86893100e-02f, 5.31719923e-02f, -1.55468099e-02f, -6.71835914e-02f, -7.05892732e-03f, -7.11980462e-02f, -6.34047985e-02f, 5.13983183e-02f, 9.50924978e-02f, -2.88416445e-02f,
  -1.02448985e-01f, 9.63337943e-02f, 3.93001772e-02f, 1.96443181e-02f, -3.69885601e-02f, 6.17653839e-02f, 8.39049444e-02f, -3.60724404e-02f, 2.83202231e-02f, -4.26242920e-03f,
  -3.44449468e-02f, 1.35401115e-02f, 1.50759239e-02f, 7.21553862e-02f, 1.58370950e-03f, 1.06738828e-01f, 3.29654664e-02f, -8.94238986e-03f, -4.41361591e-02f, 1.07780747e-01f,
  -2.16833223e-02f, -6.76541403e-02f, -9.66242403e-02f, -3.71828787e-02f, 6.80083111e-02f, 6.26129285e-02f, -5.09351715e-02f, -2.89542484e-03f, -5.67603894e-02f, 2.85743661e-02f,
  4.78092916e-02f, 3.52543741e-02f, -5.18899746e-02f, 4.52161692e-02f, 4.76962477e-02f, 5.75184301e-02f, -5.01519255e-02f, 9.68749449e-02f, -1.21940374e-02f, 8.72925967e-02f,
  -2.48448439e-02f, 1.06473461e-01f, -1.04719520e-01f, 9.89425629e-02f, 8.58781636e-02f, -5.18624671e-02f, -7.15347230e-02f, -9.41820145e-02f, -4.10051085e-03f, -1.13682471e-01f,
  -1.79802671e-01f, -3.01208168e-01f, -1.00860298e-01f, 6.97250590e-02f, -1.24605663e-01f, -7.69446939e-02f, -6.07547201e-02f, 4.36106883e-02f, -1.13366611e-01f, 5.52691817e-02f,
  7.77892247e-02f, 9.63319186e-03f, 4.24436070e-02f, -5.98866828e-02f, -1.27484858e-01f, 6.17772080e-02f, 2.45387144e-02f, -9.34117213e-02f, -5.91873890e-03f, -4.53381613e-02f,
  -4.54614796e-02f, -2.17113905e-02f, -8.67043659e-02f, 7.33474195e-02f, 6.12700693e-02f, -9.92560643e-04f, 3.93621698e-02f, -2.06462517e-02f, -4.58112136e-02f, 1.01304874e-02f,
  8.58538821e-02f, -2.68763304e-01f, 4.77970432e-04f, -5.79815432e-02f, -2.75269933e-02f, -1.24664642e-01f, 7.51287788e-02f, -3.31258059e-01f, -7.64515847e-02f, -2.42269918e-01f,
  -6.95854649e-02f, 3.02330345e-01f, 2.60595083e-01f, -2.19835147e-01f, 3.98698092e-01f, 2.05772758e-01f, -2.17580333e-01f, 8.38880986e-02f, 4.44452018e-02f, -1.44002870e-01f,
  -1.41441807e-01f, -2.04388097e-01f, 1.51882872e-01f, -2.80149937e-01f, -2.14280322e-01f, -2.00793803e-01f, 9.74973384e-03f, 3.98483360e-03f, -2.87557453e-01f, 5.46052717e-02f,
  -1.44724488e-01f, -2.37896472e-01f, -2.26147324e-02f, 3.29091251e-02f, -1.17345385e-01f, 8.08698013e-02f, 9.34505239e-02f, 2.07997039e-01f, 3.91326398e-02f, -5.47692291e-02f,
  1.29484192e-01f, -5.70939891e-02f, -1.71169758e-01f, 1.25176743e-01f, -1.89544428e-02f, -8.99931043e-02f, -1.15876999e-02f, 2.27271076e-02f, -3.69732864e-02f, 1.02845542e-01f,
  5.35750985e-02f, 8.72106403e-02f, 1.84911322e-02f, -2.13341527e-02f, 1.00651018e-01f, -8.96774679e-02f, -2.46209744e-02f, 1.60369545e-01f, -4.88733351e-02f, -5.08527569e-02f,
  -3.14398892e-02f, 3.27694975e-02f, -6.78898618e-02f, -1.21814080e-01f, -4.96329144e-02f, -9.71473604e-02f, 5.04386760e-02f, 4.37094718e-02f, 1.52362399e-02f, -7.22786114e-02f,
  -3.97200994e-02f, 3.92136425e-02f, 4.50790748e-02f, -4.53599636e-03f, -8.73130187e-02f, -9.12991464e-02f, 8.82873014e-02f, 2.45380588e-02f, 7.26575358e-03f, -2.13482045e-02f,
  2.52823513e-02f, -1.68493167e-02f, 4.86070402e-02f, -3.61694060e-02f, -4.95010316e-02f, 5.52000403e-02f, -6.01622462e-02f, 7.63761671e-03f, 4.15132456e-02f, 1.21079892e-01f,
  -8.13249778e-03f, -3.06630999e-01f, -1.04586497e-01f, 1.25929303e-02f, 6.85257316e-02f, -4.24392894e-02f, 5.09320498e-02f, -5.42698316e-02f, -1.17289409e-01f, -9.75126475e-02f,
  2.94791106e-02f, 9.01141018e-02f, -4.69718575e-02f, -4.16976996e-02f, -6.89598406e-03f, -3.34542133e-02f, 6.58791736e-02f, 1.42594343e-02f, 1.78639796e-02f, -9.32855438e-03f,
  4.50807102e-02f, 6.12582127e-03f, 3.59797180e-02f, 1.68531586e-03f, -1.79658197e-02f, -3.05755641e-02f, 4.74858880e-02f, 3.44978459e-03f, 1.10525467e-01f, 2.53357217e-02f,
  -5.97757638e-01f, 3.50637317e-01f, 2.91253954e-01f, 1.39642596e-01f, -3.83637071e-01f, 6.07754514e-02f, 2.12895289e-01f, 1.32298991e-01f, -3.26310284e-02f, 3.58080268e-01f,
  -2.73284521e-02f, 1.14193581e-01f, 1.87562052e-02f, 2.57758975e-01f, -3.58672738e-01f, 1.40210455e-02f, 1.54650941e-01f, 1.05976984e-01f, 4.88765202e-02f, -1.29745424e-01f,
  -1.88304812e-01f, -3.08405399e-01f, 1.89251751e-01f, -1.75651178e-01f, 3.57035245e-03f, 1.47624731e-01f, -1.14318572e-01f, -9.62960422e-02f, 1.84204772e-01f, -2.56312471e-02f,
  -3.57066154e-01f, -2.30926350e-02f, 4.19221856e-02f, 3.94694991e-02f, -1.73970405e-02f, 6.56432956e-02f, 7.37013994e-03f, -5.36718555e-02f, -5.82365915e-02f, 6.72613606e-02f,
  -5.45902587e-02f, -1.68620571e-02f, -3.52557860e-02f, -5.89723326e-02f, 1.64368805e-02f, 7.22371712e-02f, 4.72467244e-02f, 4.58225124e-02f, 8.63924548e-02f, 5.53717911e-02f,
  1.68717280e-01f, 1.82692230e-01f, 1.53669730e-01f, 2.73279808e-02f, 7.80249983e-02f, 7.51618743e-02f, 9.46710855e-02f, 5.34718158e-03f, 6.20886087e-02f, 3.14466953e-02f,
  -1.19730374e-02f, -8.33221301e-02f, 2.39533000e-02f, -1.00584723e-01f, -7.58090541e-02f, 1.01435073e-02f, -2.05696397e-03f, -5.85700534e-02f, 1.08490676e-01f, 1.52008152e-02f,
  1.45856244e-03f, 6.29549026e-02f, -6.32983297e-02f, 5.76019771e-02f, 9.38498452e-02f, -1.04725296e-02f, 3.43206227e-02f, 1.05091408e-02f, 1.67586580e-02f, 4.85683307e-02f,
  1.43669406e-02f, 7.42269354e-03f, -1.56304240e-02f, 9.33885109e-03f, 6.74359873e-02f, 2.38784030e-02f, 2.67133545e-02f, 5.79667352e-02f, 3.35850716e-02f, -1.02000587e-01f,
  -3.88303071e-01f, -1.61818713e-01f, -8.54661912e-02f, -7.25201005e-03f, -1.37167601e-02f, -1.88406762e-02f, -5.68760782e-02f, -6.86686486e-02f, -6.24707118e-02f, -8.31182376e-02f,
  -8.97663459e-03f, 6.98390901e-02f, -3.10145039e-03f, -3.15737277e-02f, 8.70818645e-03f, 6.20411895e-02f, 1.39362644e-02f, -5.15596457e-02f, -1.33526832e-01f, -1.97162684e-02f,
  -4.93859313e-03f, -1.77262828e-01f, 9.75640607e-04f, -1.22841331e-03f, 3.85498479e-02f, -4.62953933e-02f, -1.69519559e-01f, 5.65240197e-02f, -1.09196022e-01f, 1.22134887e-01f,
  -3.77979517e-01f, 8.64977837e-02f, -2.49122918e-01f, -7.31153488e-02f, -2.03364447e-01f, -9.65604484e-02f, -6.69558421e-02f, 3.98267899e-03f, 3.15990299e-02f, 1.71001732e-01f,
  -2.78330576e-02f, -6.58960715e-02f, 3.03715646e-01f, -4.15664120e-03f, -9.84250829e-02f, 3.29298794e-01f, -1.85344294e-02f, 6.37192130e-02f, 5.05822897e-02f, -8.84583145e-02f,
  -1.28015071e-01f, 6.04473613e-02f, -5.24115264e-02f, 2.90393699e-02f, -3.65934879e-01f, -6.72608241e-02f, -7.91824684e-02f, -1.37386814e-01f, -1.63867369e-01f, -2.86740333e-01f,
  -4.21601087e-01f, -2.02914953e-01f, -1.85290501e-01f, -2.21129328e-01f, -4.19430882e-02f, 4.76658009e-02f, -9.17478800e-02f, -7.14719146e-02f, -9.02490914e-02f, 5.48821092e-02f,
  2.84508299e-02f, -2.40276959e-02f, -1.14075556e-01f, 1.16348946e-02f, 4.81458269e-02f, -1.50915170e-02f, -9.34941471e-02f, -2.77125221e-02f, -4.28789109e-02f, -3.16941291e-02f,
  -1.54344495e-02f, -6.04047365e-02f, -1.02342125e-02f, 1.69467218e-02f, -8.97700638e-02f, -5.93798421e-02f, 3.09656579e-02f, -1.81379262e-02f, -1.77155048e-01f, -1.87005684e-01f,
  4.70070541e-02f, 1.21988177e-01f, -8.27270374e-02f, 1.21407220e-02f, 2.50689685e-02f, -2.19510105e-02f, -5.05616069e-02f, 9.71092358e-02f, 1.34757347e-02f, -8.73167068e-03f,
  -2.72488743e-02f, -6.48333505e-02f, 6.73204893e-03f, 1.18741987e-03f, 4.69733998e-02f, 1.15654208e-01f, 3.71511690e-02f, -1.12268671e-01f, -5.09519838e-02f, -1.86651587e-01f,
  -5.96224405e-02f, -1.42806634e-01f, 8.56438950e-02f, 3.54299508e-02f, -5.79165854e-02f, -4.19674627e-02f, -4.13993895e-02f, 1.38380468e-01f, -7.58295357e-02f, -1.28919572e-01f,
  -4.04495686e-01f, -2.57793963e-01f, -7.85724372e-02f, -1.20152205e-01f, 2.95910761e-02f, 7.28064822e-03f, 5.95212542e-02f, 1.30469184e-02f, -1.41362369e-01f, 7.32486174e-02f,
  -1.84460990e-02f, 1.27413765e-01f, -1.59656525e-01f, 1.03978634e-01f, 9.60460007e-02f, -7.12762848e-02f, -1.06622046e-02f, 9.28413123e-03f, -6.38491660e-02f, -5.00505865e-02f,
  5.58025576e-02f, -1.34325270e-02f, 4.78321165e-02f, 3.95762771e-02f, 8.11246783e-03f, -1.08583093e-01f, -8.80050585e-02f, -3.68576101e-03f, -1.21291943e-01f, -4.09249514e-02f,
  -1.47800818e-01f, 2.19212875e-01f, -1.39478400e-01f, -8.78321901e-02f, -1.36785507e-01f, 2.84943014e-01f, 1.82153836e-01f, -3.21799219e-02f, -2.25242853e-01f, 2.88227528e-01f,
  2.60484695e-01f, -1.75919846e-01f, 1.55933872e-01f, 3.58998865e-01f, 1.88471749e-02f, 2.66240418e-01f, 2.17941895e-01f, 1.57140657e-01f, -6.76055998e-02f, 1.44372042e-02f,
  -8.09363872e-02f, 3.08585078e-01f, 1.03088602e-01f, -1.91863235e-02f, 1.05554901e-01f, -2.54127413e-01f, -6.31869584e-02f, -8.55048820e-02f, 1.63821697e-01f, 2.74876952e-02f,
  2.31314391e-01f, 4.05789204e-02f, -8.24316218e-02f, -4.56143310e-03f, -4.97237295e-02f, 4.39539626e-02f, -5.96547909e-02f, -9.27899256e-02f, -1.33722201e-01f, -1.95273738e-02f,
  -2.11405708e-03f, -9.26778167e-02f, -9.41026548e-04f, -1.38377324e-01f, -7.57320523e-02f, -3.22982706e-02f, 4.71539646e-02f, 3.31278774e-03f, 2.25400291e-02f, 1.10873766e-01f,
  2.59019379e-02f, 1.05654947e-01f, -3.57649513e-02f, 6.62325621e-02f, -1.23428674e-02f, -6.13407269e-02f, 6.65802360e-02f, -4.82990444e-02f, -7.60058612e-02f, -4.86630686e-02f,
  -9.34454501e-02f, 8.12971964e-02f, 2.94564664e-02f, 9.01660472e-02f, 7.42502511e-02f, 1.30291998e-01f, 2.80752033e-02f, 9.46403816e-02f, -9.35132429e-02f, 5.87932803e-02f,
  -1.95867084e-02f, -6.30301908e-02f, 4.58672866e-02f, -1.18841035e-02f, -4.30735908e-02f, 3.35079618e-02f, -6.45577833e-02f, 1.16630428e-01f, 5.46475090e-02f, 6.48538545e-02f,
  3.04284543e-02f, 6.05609007e-02f, 5.72403185e-02f, 1.92181263e-02f, 1.15322083e-01f, -9.02410969e-03f, 2.68571768e-02f, -7.71608856e-03f, 4.62426171e-02f, 1.06213531e-02f,
  8.38635936e-02f, -1.25443280e-01f, 1.04638793e-01f, 8.35101828e-02f, -7.82220531e-03f, -3.67015339e-02f, -3.42579000e-02f, -1.57728270e-02f, -5.61690368e-02f, 1.01619223e-02f,
  -1.17811747e-01f, -6.89984709e-02f, -1.51373195e-02f, 2.89636403e-02f, -5.54466806e-02f, 9.93180871e-02f, 6.23838902e-02f, -8.47818423e-03f, 2.03178246e-02f, -7.34880159e-04f,
  5.41896410e-02f, -2.37718746e-02f, -1.27293870e-01f, -3.28966528e-02f, -5.09410053e-02f, 7.59032220e-02f, 1.26900524e-02f, -5.82065284e-02f, -3.57390121e-02f, 6.70409277e-02f,
  -1.58086538e-01f, 2.97134817e-01f, 5.71913980e-02f, 6.69804960e-02f, -5.26200607e-02f, 1.42915715e-02f, 3.37310024e-02f, 1.97727054e-01f, 2.92595536e-01f, 1.93932310e-01f,
  -6.26838878e-02f, 3.56281757e-01f, 7.25461990e-02f, -1.57491222e-01f, -2.33705655e-01f, -2.63119321e-02f, -1.96295828e-01f, 1.06595472e-01f, 6.85015917e-02f, -8.60215165e-03f,
  -6.49349317e-02f, -2.39601061e-01f, -2.67233998e-01f, 4.60927226e-02f, -2.23776177e-01f, -4.56573218e-02f, -3.81014377e-01f, -1.44168250e-02f, -1.38647139e-01f, -5.58572635e-02f,
  4.99150977e-02f, 9.06547606e-02f, -1.03628047e-01f, 4.35940996e-02f, -6.54002652e-02f, 2.43199170e-02f, -3.06205023e-02f, -6.42762333e-02f, -2.57327184e-02f, 3.51663232e-02f,
  6.33912161e-02f, -8.38510983e-04f, 1.65157229e-01f, 4.00902331e-03f, -7.22857863e-02f, -7.03056902e-02f, -6.36950880e-02f, -1.50663480e-01f, 6.06458634e-02f, -6.53724447e-02f,
  -6.39161021e-02f, 2.69624572e-02f, -1.43765435e-01f, -2.53191236e-02f, -5.93958646e-02f, 6.96388558e-02f, 6.27146438e-02f, -1.27164736e-01f, -5.09415418e-02f, 8.06831717e-02f,
  -9.52303968e-03f, 1.42858820e-02f, 9.40957759e-03f, -3.82040031e-02f, 4.09478918e-02f, 3.58568057e-02f, -4.89194170e-02f, 6.17722124e-02f, -8.13978463e-02f, -1.17531352e-01f,
  -8.02680943e-03f, -9.22552962e-03f, 8.93359259e-02f, -7.95014873e-02f, -5.33291837e-03f, 9.38699115e-03f, -1.26703009e-01f, 1.06733002e-01f, -7.66073987e-02f, 2.33954564e-02f,
  8.21441859e-02f, 4.89743128e-02f, -6.52507180e-03f, -5.73280342e-02f, 4.76739481e-02f, -1.10120617e-01f, -4.91782799e-02f, -4.81608920e-02f, -9.11500379e-02f, -9.47144032e-02f,
  5.60863838e-02f, 2.74668276e-01f, 7.04953372e-02f, 1.10236458e-01f, 1.25201289e-02f, 4.26155999e-02f, 8.40798244e-02f, -1.07033942e-02f, 1.24893464e-01f, 1.11244898e-02f,
  1.71521865e-03f, 9.84107256e-02f, -8.11671559e-03f, -5.66769503e-02f, 8.97679031e-02f, 4.51914826e-03f, 5.59044369e-02f, -1.21524110e-02f, 8.58965516e-02f, -3.75604145e-02f,
  -1.06975913e-01f, 8.86407793e-02f, 5.01904711e-02f, -6.06795214e-02f, -4.15186398e-02f, 1.72332246e-02f, 1.14949495e-02f, -4.54296023e-02f, -3.31272855e-02f, 7.23185465e-02f,
  1.87633157e-01f, 4.64121699e-02f, -2.46994168e-01f, -3.37875932e-01f, 5.23498096e-02f, 5.17530888e-02f, -1.79478154e-01f, -5.76377995e-02f, -3.27578872e-01f, 1.53079972e-01f,
  2.20068488e-02f, -1.32172808e-01f, -1.51340246e-01f, -9.41302925e-02f, -9.96353924e-02f, -2.01704189e-01f, -3.62271518e-02f, -5.43622896e-02f, -5.63527718e-02f, 7.03062043e-02f,
  -8.15690309e-02f, 2.86085188e-01f, -1.26302794e-01f, 2.13091165e-01f, 2.17770338e-01f, 1.19563036e-01f, 6.93799481e-02f, 7.71290734e-02f, 4.25386764e-02f, 7.11171478e-02f,
  3.89080658e-03f, 2.45913351e-03f, -1.74526379e-01f, -4.73591611e-02f, -3.10445484e-02f, 8.64673555e-02f, -5.90802729e-03f, 3.52980132e-04f, -4.32798676e-02f, -6.89199492e-02f,
  -1.63486134e-02f, -3.45678888e-02f, -7.95999989e-02f, 3.00752409e-02f, 1.93305939e-01f, 3.27063277e-02f, -1.16927601e-01f, -8.63505751e-02f, -1.60936564e-01f, -2.04863846e-02f,
  -8.51524994e-02f, -4.34568413e-02f, 4.07132786e-03f, -1.74387574e-01f, -1.28823981e-01f, 4.71316278e-02f, 6.13240525e-02f, -6.05439581e-03f, 5.92752285e-02f, -2.09306255e-01f,
  9.11516249e-02f, 1.71381280e-01f, 1.08874120e-01f, -6.76123947e-02f, 3.70490476e-02f, -2.07932275e-02f, 2.23457217e-02f, -7.26264790e-02f, -3.34532261e-02f, 7.94451460e-02f,
  -6.88542612e-03f, -1.17374770e-01f, -2.13023350e-02f, 3.50409485e-02f, 1.04367048e-01f, 2.00832076e-02f, 8.46466869e-02f, 3.44729908e-02f, -1.09749183e-01f, -8.76899287e-02f,
  -1.36144266e-01f, 1.16489530e-01f, -6.37348592e-02f, 6.90570027e-02f, 4.40089777e-03f, 5.78828761e-03f, -1.45517886e-02f, 8.49752501e-02f, -4.71536666e-02f, 1.09156355e-01f,
  -3.47812362e-02f, 4.98126559e-02f, -1.37505412e-01f, 4.53257002e-02f, -2.84769367e-02f, 2.25661229e-02f, -1.75082535e-02f, -7.79797360e-02f, -1.29775750e-02f, -4.14646491e-02f,
  1.28547043e-01f, 3.16457264e-02f, 8.22656676e-02f, -6.24097139e-02f, 8.12721401e-02f, 2.70883664e-02f, 1.19977156e-02f, -8.49819407e-02f, 4.12517041e-02f, -2.39857528e-02f,
  1.04715556e-01f, 1.98044181e-01f, -4.32355516e-02f, -1.77702482e-03f, 4.15647030e-02f, 7.49672577e-02f, 1.19724378e-01f, -3.32906656e-02f, 6.41640872e-02f, -4.95367087e-02f,
  2.20717639e-01f, -2.29582086e-01f, -2.71252632e-01f, -1.60411537e-01f, -2.96561956e-01f, -2.21676528e-01f, -3.42702627e-01f, -2.45566323e-01f, -2.49024674e-01f, -1.13364153e-01f,
  -1.89190984e-01f, -1.71287298e-01f, 1.15128905e-01f, -2.77398914e-01f, 2.61726260e-01f, 1.55861214e-01f, -1.71285480e-01f, -1.54910788e-01f, -1.04713969e-01f, -2.50251647e-02f,
  3.08612245e-03f, -1.23468295e-01f, -1.26152560e-01f, -6.05882145e-02f, -2.90187955e-01f, -7.20206425e-02f, 7.33576119e-02f, -2.65117347e-01f, -2.38235980e-01f, -1.91020280e-01f,
  -3.34230214e-02f, 4.42413203e-02f, -4.06899564e-02f, -5.95414825e-02f, 7.59401619e-02f, 7.84094483e-02f, 2.14083381e-02f, -3.49167758e-03f, -5.31767868e-02f, 9.24125835e-02f,
  1.16824538e-01f, 8.24816450e-02f, -1.54694458e-02f, -1.65370665e-02f, -1.10956259e-01f, 1.19612133e-03f, -6.40084893e-02f, -1.01299390e-01f, -3.32905017e-02f, -3.97666320e-02f,
  -1.19313940e-01f, 8.63064267e-03f, -6.07699081e-02f, 6.31997436e-02f, -6.76675811e-02f, -3.61125506e-02f, 2.44903695e-02f, -3.02485880e-02f, 3.85232233e-02f, 6.24409020e-02f,
  1.50803896e-02f, 1.78225145e-01f, 7.44226277e-02f, -6.66538700e-02f, 4.06602956e-02f, 2.80780364e-02f, 1.21284435e-02f, 1.23851299e-02f, -6.47305697e-02f, 9.08398628e-02f,
  -2.69405171e-02f, -6.61251992e-02f, -2.85006985e-02f, 9.81728956e-02f, 4.76505682e-02f, 7.63739794e-02f, -4.99472022e-02f, 3.51053216e-02f, -1.06356882e-01f, -3.02952360e-02f,
  -3.46827172e-02f, -1.59064680e-02f, 3.13815400e-02f, 5.49988486e-02f, 2.89020259e-02f, 2.74558794e-02f, -2.62386701e-03f, -5.96594699e-02f, -2.34276056e-02f, 6.50553629e-02f,
  1.22512970e-03f, 7.60707855e-02f, -2.09976211e-02f, -1.15123903e-02f, -1.97203904e-02f, -1.91970542e-02f, -5.75717017e-02f, -1.69589929e-02f, -2.16811616e-02f, 1.17523596e-01f,
  -7.52338255e-03f, 6.79002255e-02f, 1.06693983e-01f, -2.34782603e-02f, 2.63558608e-02f, -1.08006939e-01f, 1.52813062e-01f, -4.70727496e-02f, -7.79277273e-03f, 7.65875652e-02f,
  5.27197830e-02f, 1.44106627e-01f, 1.09219449e-02f, 2.17036959e-02f, 4.64414470e-02f, 8.35370347e-02f, 6.92133233e-02f, 5.75256068e-04f, 6.44555911e-02f, -3.19130607e-02f,
  -2.53935933e-01f, 1.15956187e-01f, -5.74779809e-02f, 8.34132284e-02f, -2.40132436e-01f, 3.15681458e-01f, 2.45088831e-01f, -5.19632958e-02f, 3.18448305e-01f, 2.85773009e-01f,
  1.14099815e-01f, -4.13305573e-02f, 7.78229982e-02f, 2.33712837e-01f, -1.27303181e-02f, 2.76332021e-01f, 2.42812335e-01f, 2.68995196e-01f, -9.54939052e-02f, -3.51636149e-02f,
  -2.38537174e-02f, 1.66983485e-01f, -5.88818155e-02f, -6.10713698e-02f, -2.43871108e-01f, -7.52838179e-02f, -8.53040442e-02f, -1.97808117e-01f, -8.31491500e-02f, 2.18715407e-02f,
  -1.66909710e-01f, -2.10454106e-01f, -1.10162474e-01f, -5.94058000e-02f, -6.57822415e-02f, -1.92670599e-02f, 2.14797910e-03f, -7.47406036e-02f, -2.77122911e-02f, 8.58341604e-02f,
  -3.52394469e-02f, -9.23252404e-02f, 1.46196112e-01f, 1.99091882e-02f, 1.79025624e-02f, -3.35965566e-02f, 1.15423976e-02f, -4.82598990e-02f, -7.18338266e-02f, -7.77939931e-02f,
  -4.49661762e-02f, 4.19199169e-02f, 4.50034142e-02f, 2.18434073e-02f, -1.68623447e-01f, 1.05954453e-01f, 6.66422248e-02f, -9.86064896e-02f, 7.34442845e-02f, -2.47477461e-02f,
  2.90191676e-02f, -4.06132452e-02f, 4.90871631e-02f, -5.09821102e-02f, 3.58604938e-02f, -2.20809206e-02f, 7.71967173e-02f, -2.74433959e-02f, 2.71178074e-02f, -1.76037718e-02f,
  1.88596249e-02f, -1.02805058e-02f, -8.39508250e-02f, 2.19890326e-02f, 2.51625963e-02f, 9.02109817e-02f, -5.74436709e-02f, 6.58489391e-02f, 9.79055688e-02f, 1.14002027e-01f,
  -9.08590504e-04f, 2.43836239e-05f, 5.70590571e-02f, 6.16258793e-02f, 1.02017010e-02f, 6.96426677e-03f, -2.71785986e-02f, -3.75120044e-02f, 2.77889427e-02f, -9.80019495e-02f,
  1.80533245e-01f, 1.16478302e-01f, -4.00389396e-02f, -2.08418146e-02f, -2.47841142e-02f, -2.63415258e-02f, 2.76322737e-02f, -2.47778483e-02f, 8.82244930e-02f, -2.41625626e-02f,
  7.97140822e-02f, 4.93713170e-02f, -5.09859696e-02f, 3.98285966e-03f, 8.62560198e-02f, 1.04333974e-01f, -6.57106191e-02f, 9.21068788e-02f, 1.00994095e-01f, -1.47708222e-01f,
  -3.95723954e-02f, -1.87658910e-02f, -4.91819046e-02f, 4.67651151e-02f, 2.03840639e-02f, -1.36407111e-02f, 5.05989902e-02f, -1.11362942e-01f, -1.17009066e-01f, 3.36209126e-02f,
  -2.88199455e-01f, -1.33939862e-01f, -2.69388109e-01f, -2.12356970e-01f, 2.94112891e-01f, 6.64111525e-02f, -3.37703116e-02f, 8.20630118e-02f, -2.32623711e-01f, 2.27996558e-01f,
  -4.97426949e-02f, -2.02392176e-01f, -1.74974110e-02f, -3.56039673e-01f, -3.69838357e-01f, -3.30290854e-01f, -1.85624361e-01f, -1.16754942e-01f, -9.02393535e-02f, 4.46661822e-02f,
  -6.77997917e-02f, -5.92313446e-02f, -2.64449835e-01f, 3.14227313e-01f, 1.56579148e-02f, 2.10297987e-01f, 2.79093355e-01f, 1.42623290e-01f, 9.79882479e-02f, -1.68669075e-02f,
  -1.46621123e-01f, -2.11605698e-01f, -9.32539999e-02f, -3.14550959e-02f, 1.16696686e-01f, 1.16150603e-01f, 1.21929131e-01f, -6.47121146e-02f, -9.70692858e-02f, -4.77993162e-03f,
  -2.88184136e-02f, -2.39227824e-02f, 7.93610979e-03f, -3.05773690e-02f, -4.75526974e-02f, -5.28843403e-02f, -4.10623550e-02f, 9.01639387e-02f, 4.07919753e-03f, -8.71661305e-02f,
  -8.63922685e-02f, -3.14234421e-02f, 8.56667385e-02f, 3.58947329e-02f, -1.84900146e-02f, -2.70649325e-02f, 3.81763205e-02f, 2.84909233e-02f, 1.84764266e-02f, -8.57531428e-02f,
  5.24276793e-02f, 8.31827372e-02f, -2.48704739e-02f, -3.19922045e-02f, -1.80391837e-02f, 7.66043812e-02f, -3.25749554e-02f, 2.33239941e-02f, 2.69922595e-02f, 3.86924110e-02f,
  4.62273223e-04f, 4.30287533e-02f, -2.41703074e-02f, 2.59781675e-03f, -2.84131877e-02f, -5.83030470e-02f, 2.47471295e-02f, 3.46350968e-02f, 1.08341069e-03f, -3.14009450e-02f,
  6.98870281e-03f, -7.74072949e-03f, -7.20928907e-02f, 1.39685869e-02f, -7.66630471e-02f, 4.81003076e-02f, 2.79483143e-02f, -1.33665046e-02f, 2.73260493e-02f, 2.84818113e-02f,
  1.35284528e-01f, 4.62926924e-02f, 4.29679602e-02f, -4.05654646e-02f, 5.76293282e-03f, 3.92013974e-02f, 1.43470829e-02f, -4.33644727e-02f, 2.23447811e-02f, 2.10852902e-02f,
  2.04310849e-01f, 1.34368643e-01f, 1.79356441e-01f, 1.45595307e-02f, 5.82286045e-02f, 7.33620748e-02f, 8.51021111e-02f, 1.05097033e-01f, 1.85338020e-01f, -2.51326915e-02f,
  7.60666355e-02f, 5.89284189e-02f, 1.99230090e-02f, 1.10817790e-01f, 3.07667404e-02f, 1.84070561e-02f, 1.34677976e-01f, -8.49886537e-02f, 2.99424473e-02f, 5.74090146e-02f,
  -1.20894514e-01f, 4.19223458e-01f, 1.85188249e-01f, 1.52402326e-01f, -4.78145480e-02f, 4.13768172e-01f, 2.75917381e-01f, 2.11780980e-01f, 3.05330455e-01f, 5.50339296e-02f,
  -1.68209255e-01f, 1.27464041e-01f, -3.99444550e-02f, 4.63917069e-02f, 2.41177753e-01f, 2.14807034e-01f, 2.22666591e-01f, 1.06536984e-01f, 1.02045350e-01f, 4.77859080e-02f,
  6.27087951e-02f, 1.50219694e-01f, -2.02483386e-01f, -3.93809378e-02f, -1.08334370e-01f, -6.30481541e-02f, -2.00046018e-01f, -4.30921987e-02f, -9.01969299e-02f, 1.79930538e-01f,
  -9.19234008e-02f, 3.99396494e-02f, -8.58556181e-02f, 3.84143367e-02f, 1.13829328e-02f, -1.47281274e-01f, -2.41274014e-02f, 3.67502905e-02f, -3.13565433e-02f, -6.68361634e-02f,
  1.80155784e-02f, -1.36527224e-02f, 1.18571162e-01f, -9.36989486e-02f, 4.07448448e-02f, -5.59396669e-02f, -1.90706775e-02f, -1.14156619e-01f, 2.65446119e-02f, -6.34249374e-02f,
  -1.00475483e-01f, 3.32871340e-02f, -2.58804448e-02f, 8.28428343e-02f, -9.20167640e-02f, -1.18962936e-02f, 8.02016035e-02f, -2.83859670e-03f, -6.40614554e-02f, 1.87881544e-01f,
  -5.84150888e-02f, 8.68911855e-03f, -5.59888855e-02f, -4.37686071e-02f, 1.02045022e-01f, -8.83166343e-02f, -8.57866630e-02f, -9.83127877e-02f, -2.91082971e-02f, -7.30478913e-02f,
  4.46810685e-02f, 7.58398743e-03f, 4.12330218e-02f, -2.87005845e-02f, 5.82757331e-02f, -1.12744113e-02f, 6.42344952e-02f, -1.58090498e-02f, 5.27297519e-02f, -9.37934872e-03f,
  1.14013724e-01f, 1.59596145e-01f, -1.49221525e-01f, -1.18926458e-01f, 5.95839061e-02f, 4.08831947e-02f, 8.38820413e-02f, 5.96251003e-02f, -1.08497269e-01f, 7.15953717e-03f,
  1.36288986e-01f, 4.53808099e-01f, -3.58095728e-02f, -4.83492063e-03f, 7.65570775e-02f, 5.38133010e-02f, 1.54693332e-02f, 7.99440369e-02f, 1.30687207e-01f, 1.68589622e-01f,
  3.09453700e-02f, 1.56234987e-02f, 1.11249901e-04f, 9.41544771e-03f, 3.38311829e-02f, 9.99856442e-02f, 3.16533409e-02f, 1.17780037e-01f, 6.60164580e-02f, -2.35589612e-02f,
  -2.17418790e-01f, -7.22614527e-02f, -1.38172889e-02f, 2.82145548e-03f, -7.29951710e-02f, -8.67968649e-02f, -3.24360542e-02f, -8.93522799e-02f, 4.77279201e-02f, 5.58997393e-02f,
  -1.03731625e-01f, -2.52072781e-01f, 2.34754696e-01f, -2.68235952e-01f, 1.15166530e-02f, 2.06018180e-01f, 2.76618272e-01f, -1.52569577e-01f, -2.75504112e-01f, -2.50909060e-01f,
  6.87174918e-03f, 1.56648569e-02f, 3.29974174e-01f, -2.53762335e-01f, 3.60822290e-01f, 2.02589273e-01f, -7.17261136e-02f, -4.16277628e-03f, -1.07680462e-01f, -2.15640068e-01f,
  -1.48318261e-01f, -2.45412245e-01f, 1.86081767e-01f, -2.90763170e-01f, -2.03680024e-01f, -1.21882491e-01f, -8.39983746e-02f, 9.09159109e-02f, -1.71576813e-01f, 1.18518166e-01f,
  -9.26701576e-02f, -2.44616434e-01f, 3.41032036e-02f, -4.10743989e-02f, -9.12034139e-03f, 5.26695922e-02f, 5.05904518e-02f, 1.50174975e-01f, 4.44001630e-02f, 6.64635897e-02f,
  1.21908206e-02f, -3.72582348e-03f, -9.47185531e-02f, 1.23517722e-01f, -1.77787781e-01f, -1.07008398e-01f, 1.58482324e-02f, -2.83292923e-02f, -1.26899913e-01f, 4.01813798e-02f,
  6.67186752e-02f, -3.04423459e-02f, -3.27054667e-03f, 8.77171010e-03f, -8.48684926e-03f, 1.19217578e-03f, 8.64382163e-02f, 9.51493233e-02f, 4.34815213e-02f, -9.11142454e-02f,
  -6.91701025e-02f, -1.90376416e-02f, 4.65473495e-02f, -7.52143711e-02f, 1.45792756e-02f, -8.65267590e-02f, -2.07285527e-02f, 1.71104316e-02f, 6.86328672e-03f, -6.20881431e-02f,
  1.85139067e-02f, 3.02805547e-02f, 2.80560479e-02f, 3.62890847e-02f, 3.52134928e-03f, 2.26654224e-02f, 9.71470848e-02f, -2.20441986e-02f, -5.07484190e-02f, -4.44457792e-02f,
  -1.59237105e-02f, 1.25609055e-01f, -3.17584947e-02f, 3.63484174e-02f, -4.05829810e-02f, 3.87672856e-02f, -8.92643780e-02f, 1.19401263e-02f, -7.25646131e-03f, 6.38901517e-02f,
  -1.73058793e-01f, -2.73358226e-01f, -8.64659622e-02f, -1.31547108e-01f, -5.69766015e-02f, -2.40767933e-02f, -3.21063539e-03f, -1.11903422e-01f, -5.46972454e-02f, 2.07337160e-02f,
  -3.56618017e-02f, -2.82665826e-02f, 1.72147509e-02f, 5.13003729e-02f, 1.09596634e-02f, -3.55048962e-02f, -3.65458839e-02f, -3.34935039e-02f, 5.12506068e-02f, -4.34513688e-02f,
  -8.36433098e-02f, 5.20203542e-03f, 6.58096895e-02f, -5.07725663e-02f, 3.07196956e-02f, 2.57722419e-02f, -9.04143229e-02f, 1.70228176e-03f, -3.11372383e-03f, -5.91345504e-02f,
  2.09613461e-02f, -1.31473079e-01f, -4.98607289e-03f, 3.09559315e-01f, -6.17378429e-02f, -2.37965107e-01f, -3.28799158e-01f, 2.16544628e-01f, -8.22633728e-02f, -8.78783017e-02f,
  1.37438118e-01f, -6.33770153e-02f, -2.29646787e-01f, 3.29276085e-01f, 2.90935457e-01f, -4.46227044e-02f, 2.13019297e-01f, 8.21934119e-02f, -8.75755306e-03f, 2.25099832e-01f,
  1.64118513e-01f, 1.74159214e-01f, 1.17187448e-01f, 1.56386584e-01f, 1.24262609e-01f, 1.30603656e-01f, 1.50506377e-01f, -7.30924010e-02f, 3.37432265e-01f, 6.64072111e-02f,
  -6.74507543e-02f, 1.12059675e-01f, -9.64281484e-02f, -1.57029950e-03f, 5.35846315e-02f, 5.39742829e-03f, -3.38347889e-02f, -4.98072803e-02f, 1.20091187e-02f, 4.88972999e-02f,
  -1.47071898e-01f, -8.71452130e-03f, 1.14447027e-02f, -1.11876488e-01f, -8.36524516e-02f, 4.31409813e-02f, 8.34041834e-02f, -6.83035702e-02f, -3.10060643e-02f, -6.31144419e-02f,
  -7.76902661e-02f, -1.42788803e-02f, 4.59066555e-02f, 2.32774322e-03f, 7.88931027e-02f, -6.05301447e-02f, -7.91286230e-02f, -8.91387686e-02f, 5.54160140e-02f, 7.81073328e-03f,
  1.24645419e-01f, -1.40710443e-01f, -3.67108248e-02f, 1.85527687e-03f, -5.08342646e-02f, 4.37531509e-02f, -6.61391839e-02f, 3.35222185e-02f, -6.87061576e-03f, 8.98928493e-02f,
  2.97678020e-02f, 8.77659693e-02f, -7.22821848e-03f, 8.91358498e-03f, -1.53684318e-02f, -1.71451457e-02f, -5.16410545e-02f, -1.31626045e-02f, -6.49647694e-03f, 7.30869323e-02f,
  -4.87826914e-02f, 1.67990867e-02f, -7.39080831e-03f, -1.01389505e-01f, -1.17736002e-02f, 3.69066335e-02f, 1.70517657e-02f, -6.09627590e-02f, -3.67927290e-02f, 1.49296392e-02f,
  -1.73629187e-02f, 1.95246518e-01f, 1.87702589e-02f, -4.18965518e-02f, 4.04479653e-02f, 7.19430596e-02f, 1.03934677e-02f, 9.52497348e-02f, 1.99656431e-02f, -8.16932097e-02f,
  1.35717794e-01f, -2.53946315e-02f, 2.43347930e-03f, 1.08727634e-01f, 3.19651212e-03f, -3.74437943e-02f, 7.21398219e-02f, -1.03038643e-02f, 1.70618638e-01f, 1.50390267e-01f,
  1.10967875e-01f, 1.92152262e-02f, -3.40702720e-02f, -3.96012291e-02f, 1.05447598e-01f, -3.78480554e-02f, 1.15253811e-03f, -5.31428121e-02f, 7.51254335e-02f, 5.06289862e-02f,
  5.13864160e-01f, 2.81697124e-01f, 2.10074157e-01f, 2.88141131e-01f, -7.12841824e-02f, -2.33575962e-02f, 5.61443642e-02f, -4.10692170e-02f, 2.20255945e-02f, 9.01046097e-02f,
  -2.54748493e-01f, 3.52136314e-01f, -2.61302024e-01f, 6.58406913e-02f, -3.54972482e-01f, -3.48199397e-01f, 2.79354099e-02f, 1.14834815e-01f, -1.39368460e-01f, 2.48759598e-01f,
  -1.05563693e-01f, -1.76068664e-01f, 1.66247621e-01f, -4.15364169e-02f, 3.35834116e-01f, 2.48872980e-01f, -2.11966872e-01f, -1.59457639e-01f, 2.18657464e-01f, -2.33917370e-01f,
  6.64025098e-02f, 9.54293739e-03f, 5.88435419e-02f, -9.35652256e-02f, 7.16631189e-02f, 1.20771118e-01f, 4.35828343e-02f, -8.12448263e-02f, -7.35357255e-02f, 1.07000805e-02f,
  1.08821005e-01f, 2.92149838e-02f, 6.75793663e-02f, -1.03262641e-01f, 1.08721308e-01f, 1.24312453e-01f, 1.01601250e-01f, 1.72679856e-01f, 9.62961614e-02f, 7.08510801e-02f,
  1.69650286e-01f, 4.54465225e-02f, 4.91766036e-02f, 4.37979288e-02f, 4.01860885e-02f, 8.80645029e-03f, -3.00422404e-03f, 5.11050411e-02f, 7.74344131e-02f, 2.84582153e-02f,
  4.66206558e-02f, -3.19881588e-02f, 3.94419841e-02f, 4.20414843e-02f, -1.48128457e-02f, 8.68732855e-03f, -7.47614428e-02f, -8.76812544e-03f, -6.26662821e-02f, -2.63767727e-02f,
  -1.17618524e-01f, -4.21104468e-02f, -3.27864401e-02f, 1.39730116e-02f, 1.53953433e-02f, 1.48237512e-01f, -2.89069097e-02f, -1.88623928e-02f, 2.56434456e-02f, -3.88715379e-02f,
  -1.63173407e-01f, 1.23914499e-02f, -3.51763815e-02f, -2.50067580e-02f, 1.32058403e-02f, -3.74444723e-02f, 6.65028170e-02f, -4.42283647e-03f, -7.09684640e-02f, -1.33873031e-01f,
  -9.08033773e-02f, -5.88989183e-02f, -1.00531150e-02f, 1.97164416e-02f, -5.12143150e-02f, -1.97880417e-02f, -2.63813231e-02f, -4.13407432e-03f, -2.63834409e-02f, -8.06204006e-02f,
  1.12863392e-01f, 1.55061066e-01f, -2.50579640e-02f, -1.05797268e-01f, -1.02669992e-01f, -2.04218309e-02f, -4.53823768e-02f, 9.55417287e-03f, 2.70356587e-03f, 7.20454529e-02f,
  1.46414533e-01f, 2.41032485e-02f, -9.00605991e-02f, -1.95443891e-02f, -3.22840177e-02f, -7.02267960e-02f, 4.03560176e-02f, -4.50179093e-02f, -2.54901946e-02f, -8.91769156e-02f,
  -1.40263848e-02f, 2.19441324e-01f, 2.23037764e-01f, 1.99544877e-01f, -2.30488360e-01f, -3.30318511e-01f, -2.40555614e-01f, 6.65280223e-02f, 2.61218362e-02f, -3.10735293e-02f,
  -2.58845743e-02f, 1.01927802e-01f, -8.90417397e-02f, 1.37701392e-01f, -5.87009713e-02f, -1.71703845e-01f, 5.27007803e-02f, -4.82468270e-02f, 2.80873210e-04f, 1.98869586e-01f,
  1.48967937e-01f, 1.93570238e-02f, 1.94377631e-01f, 1.08241223e-01f, 1.57282338e-01f, 1.83329567e-01f, 2.66466290e-01f, -5.66036766e-03f, 1.33918181e-01f, -9.99452695e-02f,
  -1.71587199e-01f, 9.49523374e-02f, 1.04994103e-01f, -4.50215042e-02f, -3.08171660e-03f, 3.22008543e-02f, 3.05123553e-02f, 7.42598325e-02f, -9.85963941e-02f, -2.82588657e-02f,
  4.60732356e-02f, -9.40530077e-02f, 7.91311115e-02f, -5.21910340e-02f, -3.42869833e-02f, 8.36098045e-02f, 7.46951997e-03f, 3.89380828e-02f, 3.78301553e-02f, 4.91494685e-02f,
  7.64845833e-02f, 5.04476503e-02f, -5.34780733e-02f, 4.06392440e-02f, 1.16170384e-01f, -8.54363292e-02f, 6.15707785e-02f, 1.02918640e-01f, 1.10538471e-02f, -1.13811186e-02f,
  -2.05845991e-03f, -1.11986004e-01f, -5.95189966e-02f, -4.35838588e-02f, -4.84858975e-02f, -3.95410471e-02f, 3.46834101e-02f, -3.99846397e-02f, 6.12792047e-03f, -1.02207504e-01f,
  6.29069805e-02f, -1.17540313e-02f, -4.04677987e-02f, -2.46155243e-02f, 5.02552204e-02f, -3.49202529e-02f, 1.69834811e-02f, 6.03598077e-03f, 6.09909371e-02f, 7.24944472e-02f,
  -4.68016565e-02f, 7.63527164e-03f, 3.48425433e-02f, 7.08598867e-02f, -1.36613190e-01f, -6.33064508e-02f, -5.19408137e-02f, -2.02138051e-02f, -4.77866605e-02f, 7.78434752e-03f,
  4.21033278e-02f, 2.10531175e-01f, 9.98310558e-03f, 1.22036608e-02f, 5.66475000e-03f, -7.43342340e-02f, -3.67064588e-02f, 1.09738737e-01f, 7.78098926e-02f, -2.34739706e-02f,
  -5.67593984e-03f, -1.07629811e-02f, -6.86815977e-02f, -1.45839620e-02f, 6.50909916e-02f, 5.99479005e-02f, -2.28128843e-02f, 1.05669469e-01f, 8.23462605e-02f, 1.55807763e-01f,
  1.46971926e-01f, -8.20915177e-02f, 2.46708095e-02f, -1.10202558e-01f, 7.65995607e-02f, 5.46290947e-04f, -5.85923307e-02f, 5.59658706e-02f, 7.06751943e-02f, 8.58475193e-02f,
  2.22237203e-02f, 2.63292372e-01f, 3.10370624e-01f, 2.77499139e-01f, -2.54155099e-01f, -3.60308796e-01f, -1.85903370e-01f, 1.33251831e-01f, -1.24115376e-02f, 4.59697749e-03f,
  7.91632980e-02f, 2.36327574e-01f, 1.12019658e-01f, 2.30179638e-01f, 8.35201219e-02f, 6.61877543e-03f, 6.06044754e-02f, -1.31734252e-01f, 4.17788252e-02f, 2.21570671e-01f,
  2.06194475e-01f, -1.23586389e-03f, 2.00915337e-01f, 1.19471230e-01f, 1.72085047e-01f, 8.19745138e-02f, 1.83372781e-01f, 4.94106561e-02f, 1.11252621e-01f, 1.33775221e-03f,
  1.79728717e-02f, 1.23749830e-01f, 5.59052778e-03f, 9.75768715e-02f, 1.12331495e-01f, -1.05666779e-01f, -4.96538542e-02f, -5.92531525e-02f, 1.61173958e-02f, 5.04258983e-02f,
  2.51269247e-02f, 6.00308995e-04f, 5.49815670e-02f, 7.85724435e-04f, -5.59812747e-02f, -1.41290110e-02f, -3.43967900e-02f, 7.62242004e-02f, 9.58968624e-02f, 5.18369041e-02f,
  9.37881470e-02f, 1.24224670e-01f, 9.00212228e-02f, 1.16984509e-01f, 1.49750104e-02f, -2.06560101e-02f, 5.26621118e-02f, -7.45240971e-02f, -6.86438289e-03f, 2.68653734e-03f,
  -3.82490866e-02f, 2.81160586e-02f, -6.26337901e-02f, -3.53717133e-02f, 1.33462995e-02f, -1.71495676e-02f, 5.95697016e-02f, 3.68402153e-03f, 1.68583095e-02f, 6.83804750e-02f,
  -4.94004674e-02f, 9.44299102e-02f, -1.38831496e-01f, -7.05115423e-02f, 2.69977879e-02f, -5.50230406e-03f, -1.01999633e-01f, 1.14216493e-03f, 4.27243374e-02f, 1.61377285e-02f,
  2.52700225e-02f, -1.20588660e-01f, 4.17634808e-02f, 3.46816778e-02f, -8.49329904e-02f, -3.31618860e-02f, 8.63959938e-02f, 6.95395842e-02f, 8.66143256e-02f, 9.83177796e-02f,
  1.04137957e-01f, 2.08880156e-01f, 1.51338026e-01f, -4.79579456e-02f, 4.18722592e-02f, 2.97322404e-02f, 7.68035278e-02f, 2.53396071e-02f, 5.67105748e-02f, 3.42444330e-02f,
  5.36302067e-02f, -9.14284959e-02f, -9.74486489e-03f, -4.55870703e-02f, -4.16620411e-02f, 7.66106471e-02f, 1.24728372e-02f, -5.74339507e-03f, 6.13075122e-02f, 3.41274962e-02f,
  7.80377463e-02f, -7.36868978e-02f, 3.17276679e-02f, -6.65912405e-02f, 3.69801782e-02f, 2.33980007e-02f, 6.64021894e-02f, 1.64664332e-02f, 5.80647551e-02f, 7.26057542e-03f,
  -2.27063164e-01f, -1.51272610e-01f, -1.58666626e-01f, -3.82227659e-01f, 1.35447130e-01f, 2.39126936e-01f, -1.26630858e-01f, 1.19574510e-01f, -1.72833517e-01f, 1.93072796e-01f,
  1.29017010e-01f, -2.43305653e-01f, 8.27500597e-03f, -2.27169186e-01f, -2.57155478e-01f, -2.16492549e-01f, -1.15856297e-01f, -3.98859307e-02f, -5.66316880e-02f, 1.13467798e-01f,
  -1.77306741e-01f, 2.26428397e-02f, -2.09142625e-01f, 1.80060491e-01f, 1.65046588e-01f, 1.28026709e-01f, 2.13873789e-01f, 1.19539961e-01f, 1.02621295e-01f, -1.59982666e-02f,
  -1.74930282e-02f, -3.58834565e-02f, 5.22534177e-02f, 5.70860691e-03f, 7.60341212e-02f, 1.50356323e-01f, 4.83251400e-02f, 9.82762594e-03f, -2.48395987e-02f, -6.54541329e-02f,
  7.02765286e-02f, -8.94285366e-02f, 1.43126650e-02f, 3.34391817e-02f, 3.66180274e-03f, -2.29473077e-02f, -8.68309960e-02f, -5.02079390e-02f, -4.67377268e-02f, 1.44745980e-03f,
  -1.52004138e-01f, 1.56514421e-02f, -7.35285413e-03f, -4.70554680e-02f, -1.01583805e-02f, -1.07485346e-01f, 2.28811912e-02f, 5.16576581e-02f, 4.69135717e-02f, -4.15346026e-02f,
  7.07121342e-02f, 7.87290782e-02f, -2.38731261e-02f, -7.07051381e-02f, -1.55892968e-02f, 2.97257975e-02f, 6.71684965e-02f, 8.04755688e-02f, 4.05882597e-02f, 4.71255463e-03f,
  3.52206491e-02f, 1.72740333e-02f, -3.35363597e-02f, 3.18231992e-02f, -5.70157655e-02f, 3.94344237e-03f, 6.25117170e-03f, 1.51178380e-02f, -2.79994309e-02f, 3.87714170e-02f,
  -3.30813639e-02f, -7.20766410e-02f, 1.13818673e-02f, 1.00277206e-02f, 2.86015384e-02f, 1.63727347e-02f, 3.50910760e-02f, -8.17762017e-02f, -8.21284354e-02f, 6.56758621e-02f,
  -4.79845190e-03f, 1.74442872e-01f, -8.01855400e-02f, -2.08376274e-02f, -3.67943980e-02f, 5.46133183e-02f, -4.58868742e-02f, 4.39646915e-02f, -5.97554222e-02f, -4.26593516e-03f,
  1.20191880e-01f, 1.61547586e-02f, 8.39280039e-02f, -3.24089895e-03f, -6.00516982e-02f, 1.63928941e-01f, -2.59329099e-03f, -4.53253090e-03f, 3.38522494e-02f, 5.84388822e-02f,
  5.84244095e-02f, 3.29846442e-02f, -7.51550421e-02f, 6.47052154e-02f, 6.55472502e-02f, 7.02912733e-02f, 7.93808401e-02f, -7.16823013e-03f, -1.62599441e-02f, 8.11781641e-03f,
  -2.47472495e-01f, 1.59779459e-01f, -3.64592999e-01f, 7.23281526e-04f, 6.31696209e-02f, 2.34743401e-01f, 3.29989284e-01f, -2.51043215e-02f, 1.09303236e-01f, 2.80189037e-01f,
  2.04185233e-01f, 2.31214926e-01f, -2.01789774e-02f, 4.06183481e-01f, -1.09455384e-01f, 1.57198355e-01f, 2.50853986e-01f, 2.55817413e-01f, -6.52769729e-02f, 5.93079673e-03f,
  -1.61936268e-01f, 3.01194608e-01f, -1.96363360e-01f, 2.05190238e-02f, 6.73317611e-02f, -2.97449499e-01f, -1.69195104e-02f, -1.78765178e-01f, 1.84025660e-01f, 7.27151260e-02f,
  -9.72509235e-02f, -1.34288892e-01f, -3.91674489e-02f, -7.30610341e-02f, -2.41790507e-02f, -1.61765277e-01f, -2.52855550e-02f, 3.86893786e-02f, -2.23802831e-02f, -3.33727710e-02f,
  4.76556197e-02f, -1.03490233e-01f, 9.01465788e-02f, -9.59417745e-02f, -3.27708460e-02f, -8.49508122e-02f, -4.99669909e-02f, 8.10988024e-02f, 3.29875872e-02f, -1.32796809e-01f,
  3.43292346e-03f, -7.48398677e-02f, 2.42599417e-02f, 7.42050633e-03f, -8.09844583e-02f, 8.19289964e-03f, 2.69855112e-02f, -2.48967614e-02f, 1.73411563e-01f, -3.82550769e-02f,
  -2.68085245e-02f, -8.55591819e-02f, -5.95436839e-04f, -3.41359489e-02f, -6.38861060e-02f, -1.05219916e-01f, 6.18004762e-02f, -4.00613295e-04f, -4.68839370e-02f, 5.11988960e-02f,
  3.64438035e-02f, 7.38561079e-02f, 5.15335007e-03f, 6.22065291e-02f, 9.65194628e-02f, 4.87310775e-02f, -6.38244115e-03f, -2.25913012e-03f, 2.46432354e-03f, -6.44608214e-02f,
  -6.31328374e-02f, 2.32648272e-02f, 7.12376880e-03f, -7.93307126e-02f, 9.35553089e-02f, -2.85883490e-02f, -1.76396947e-02f, -5.27067296e-02f, 5.21778781e-03f, 4.37658094e-02f,
  2.58828551e-01f, 1.00493208e-01f, -3.34137641e-02f, 3.73976817e-03f, -8.15409571e-02f, 6.64678290e-02f, -1.24855526e-02f, -8.20923820e-02f, -4.27762009e-02f, -3.69470045e-02f,
  -1.39265180e-01f, 3.67914364e-02f, 3.35596576e-02f, 7.16371238e-02f, 6.44113719e-02f, 7.20375627e-02f, 1.62107468e-01f, -5.02722189e-02f, 1.52160913e-01f, -3.10948845e-02f,
  -4.97661456e-02f, 6.57454208e-02f, -1.26489764e-02f, -2.10790075e-02f, 5.21715470e-02f, 3.99064384e-02f, -1.23986825e-02f, -4.09483584e-03f, -2.54722848e-03f, 9.83948037e-02f,
  -4.31574434e-02f, -1.82806831e-02f, -3.03226739e-01f, 1.42115310e-01f, -9.55794528e-02f, 1.18362140e-02f, -7.70378634e-02f, 3.88894067e-03f, -5.12731634e-02f, 2.06677809e-01f,
  2.17149734e-01f, 6.44810349e-02f, -1.14571467e-01f, 3.67696702e-01f, 2.91154057e-01f, -1.55015634e-02f, 2.88887173e-01f, 1.32270679e-01f, -3.40486728e-02f, 2.50403702e-01f,
  6.77453279e-02f, 2.20006675e-01f, 2.35496864e-01f, 1.43325657e-01f, 1.72801420e-01f, -3.48889455e-02f, 3.10592532e-01f, -9.50011089e-02f, 2.17559248e-01f, 1.36811361e-01f,
  6.25591958e-03f, -1.48587916e-02f, -4.65349220e-02f, -1.13060325e-01f, -4.39889580e-02f, -1.35809645e-01f, -1.00310057e-01f, -6.79465085e-02f, -2.86528431e-02f, 8.33822705e-04f,
  -1.20001085e-01f, 5.61923385e-02f, -1.95529452e-03f, 4.83109616e-02f, 6.23093061e-02f, -2.82891039e-02f, -4.25020382e-02f, -4.96334061e-02f, -9.42186743e-04f, -7.40421878e-04f,
  -1.80256471e-01f, -5.72619960e-02f, -5.45656048e-02f, 1.54873598e-02f, -5.79141825e-02f, 3.97536829e-02f, -4.59737480e-02f, 4.49668244e-02f, 2.74114925e-02f, 1.27201349e-01f,
  -3.52670699e-02f, -6.25014305e-02f, -2.01984830e-02f, -1.24830641e-01f, -2.12006737e-02f, 3.36755849e-02f, 5.48625328e-02f, 3.15683633e-02f, -5.64847793e-03f, -1.07184313e-02f,
  -8.22371095e-02f, -6.30703345e-02f, 4.54657823e-02f, -1.79992765e-02f, 5.47320619e-02f, -5.89762479e-02f, -6.89407811e-02f, 8.41518119e-02f, -6.81544691e-02f, -2.48522870e-03f,
  3.45098190e-02f, 3.53713036e-02f, 1.45957153e-02f, -8.76195431e-02f, -5.81051446e-02f, 9.25409272e-02f, 1.52594969e-01f, 3.33993137e-02f, -9.55820829e-02f, -6.21396489e-02f,
  1.44585401e-01f, 1.30134687e-01f, 3.32583487e-02f, -4.85437997e-02f, 2.73796748e-02f, -2.81555634e-02f, 5.75287417e-02f, 6.51270077e-02f, 1.45006970e-01f, 6.38824478e-02f,
  5.94559498e-02f, -1.14399623e-02f, -6.08693026e-02f, 2.54946314e-02f, -9.58378892e-03f, 1.46151232e-02f, 1.14046104e-01f, -2.04456113e-02f, -7.45118409e-03f, 6.76675290e-02f,
  5.37076816e-02f, -1.83536354e-02f, -9.66635242e-04f, -1.54546097e-01f, 4.25353833e-02f, 4.07126509e-02f, 7.43307471e-02f, -2.00011656e-02f, 2.05032043e-02f, 6.13675825e-02f,
  -5.58514833e-01f, 2.32331008e-01f, 3.58908117e-01f, -3.54649097e-01f, 2.78952956e-01f, 3.14982355e-01f, -1.09672301e-01f, 1.25760093e-01f, -2.24023938e-01f, -2.24523887e-01f,
  -1.60490051e-01f, -1.32237777e-01f, 1.78681929e-02f, -1.12926401e-02f, 2.58327872e-01f, 1.37484893e-01f, -2.59554237e-02f, -1.87022015e-01f, 6.27069771e-02f, -1.23467617e-01f,
  9.34828147e-02f, -2.67363135e-02f, 2.47185305e-01f, 2.28683785e-01f, 8.42348337e-02f, -9.31056142e-02f, -2.28156820e-01f, 1.57089785e-01f, -1.11117013e-01f, 5.89973554e-02f,
  -1.15295434e-02f, -3.35486174e-01f, 4.58956212e-02f, 8.35772604e-02f, 7.39363879e-02f, -4.73245457e-02f, -7.62116387e-02f, 1.35866888e-02f, -4.29757051e-02f, -6.94678957e-03f,
  -3.87336724e-02f, 6.18115552e-02f, -5.21545745e-02f, 4.75666560e-02f, -3.18758860e-02f, 9.49531719e-02f, 7.32611790e-02f, 1.47564307e-01f, 3.21118310e-02f, 1.36103213e-01f,
  7.28653595e-02f, 9.93713662e-02f, 5.14326524e-03f, -5.26156425e-02f, 1.03252649e-01f, 1.91817377e-02f, -2.96278615e-02f, 9.54668503e-03f, 5.49048632e-02f, 8.41088593e-03f,
  1.16068877e-01f, 4.96395119e-03f, 7.26682320e-02f, -7.55329989e-03f, 3.11738416e-03f, -3.48839327e-03f, 2.48408932e-02f, -2.34288163e-02f, -6.44675642e-02f, 2.20692884e-02f,
  -8.31786096e-02f, -5.47877364e-02f, 1.71027407e-02f, 7.73495622e-03f, -7.82943517e-02f, 3.48934345e-03f, -1.25408336e-03f, 1.21355348e-03f, 7.54805133e-02f, 1.23180356e-03f,
  -9.03675631e-02f, 5.23055196e-02f, -2.00577211e-02f, -3.55867632e-02f, 4.02895883e-02f, 2.21501272e-02f, 5.01251183e-02f, 1.06377721e-01f, 2.58915033e-02f, 4.07897122e-02f,
  -7.72089064e-02f, -1.91739306e-01f, 4.47272956e-02f, 2.54687062e-03f, -3.99760269e-02f, 6.42272681e-02f, 1.79138631e-02f, 4.25123051e-02f, -1.22349896e-01f, -4.28296849e-02f,
  -3.61443125e-02f, 1.79624092e-02f, -4.81304489e-02f, -1.63543038e-02f, 6.58217072e-02f, -5.18887080e-02f, -1.96984425e-01f, -5.72243035e-02f, -3.85073833e-02f, 3.35685462e-02f,
  5.34897149e-02f, -8.10758173e-02f, 2.56675936e-04f, -5.82848908e-03f, 1.18091106e-02f, -1.06284283e-01f, -3.39307962e-03f, 1.05032055e-02f, 7.49614164e-02f, 8.73066392e-03f,
  4.62416530e-01f, 1.71952829e-01f, 2.64365375e-01f, 3.57190013e-01f, -2.83802059e-02f, 2.53881770e-03f, 9.97118875e-02f, -9.04141888e-02f, 3.66648316e-01f, 1.04313688e-02f,
  -1.37080625e-01f, 1.84251785e-01f, -2.48735517e-01f, 2.38943249e-01f, -2.21575141e-01f, -1.14280291e-01f, 6.12303987e-02f, 1.94589332e-01f, 8.79183486e-02f, 9.66282412e-02f,
  1.84881881e-01f, -3.05486202e-01f, -1.94989711e-01f, -3.38629276e-01f, 7.58174062e-02f, 1.45151123e-01f, -3.43255460e-01f, -1.53657809e-01f, -8.33806247e-02f, -1.81122094e-01f,
  -2.02757083e-02f, 3.05496790e-02f, 2.89741475e-02f, 1.12036802e-01f, 7.76822269e-02f, -4.92503867e-02f, 2.24270783e-02f, -1.66273847e-01f, 1.78819597e-02f, 3.05129346e-02f,
  8.99791569e-02f, -1.68647971e-02f, 5.01229502e-02f, -7.34118149e-02f, 1.51732162e-01f, 1.42679121e-02f, 1.69050351e-01f, 1.96700066e-01f, -2.91772056e-02f, 4.42288853e-02f,
  1.93572998e-01f, 1.25954717e-01f, 1.43472910e-01f, 3.71656008e-02f, 1.50546497e-02f, 5.64396661e-03f, 9.04077515e-02f, 5.63550070e-02f, 1.08209327e-01f, 8.62508044e-02f,
  -5.26054204e-02f, -5.73983900e-02f, -2.69345772e-02f, -2.99279578e-03f, 6.97822683e-03f, -2.04600277e-03f, 2.51240134e-02f, 1.58752277e-02f, 9.65626538e-02f, -5.02350368e-03f,
  8.90668407e-02f, 8.30638260e-02f, 3.15489657e-02f, 7.29934126e-02f, 1.09218672e-01f, 7.89622664e-02f, 8.52361172e-02f, 3.88847142e-02f, 1.21928342e-01f, -1.87981557e-02f,
  5.42873889e-02f, 1.70811713e-02f, -9.11181234e-03f, -7.42631257e-02f, -5.23106307e-02f, -4.99964058e-02f, -1.92945432e-02f, 1.43145189e-01f, 6.19051419e-02f, -6.20263293e-02f,
  1.28423469e-02f, -2.24231407e-01f, 1.75299123e-02f, 2.04241145e-02f, 4.38191108e-02f, -2.01622136e-02f, 3.36238779e-02f, 1.16865516e-01f, -1.15507521e-01f, 3.24696861e-02f,
  -3.86664681e-02f, -3.23498249e-02f, 5.71269281e-02f, 9.87074059e-03f, -5.97738028e-02f, -5.24553396e-02f, 4.85425582e-04f, 8.13090126e-04f, -8.10434893e-02f, -6.24394529e-02f,
  -1.84020735e-02f, 5.07144220e-02f, 5.88684455e-02f, 8.71219710e-02f, -7.34222960e-03f, -4.08769771e-02f, -1.02299005e-02f, 7.89131504e-03f, 5.49873617e-03f, -4.23693657e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.69843304e-01f, 2.19853833e-01f, 3.40199798e-01f, 1.92500889e-01f, 2.45066151e-01f, 2.69710600e-01f, 1.47327006e-01f, 1.90376922e-01f, 2.84716696e-01f, 2.06969023e-01f,
  3.58621418e-01f, 2.00896665e-01f, 4.20953751e-01f, 2.54359603e-01f, 1.33168086e-01f, 2.24473536e-01f, 2.35065579e-01f, 3.43531609e-01f, 1.21991806e-01f, 2.15081975e-01f,
  2.53711909e-01f, 1.89005837e-01f, 1.67958304e-01f, 7.27835298e-02f, 2.94503093e-01f, 2.49911293e-01f, 2.63991922e-01f, 2.06694558e-01f, 2.53038138e-01f, 2.32592970e-01f,
  2.02776819e-01f, 2.07507715e-01f, 3.36542368e-01f, 1.08804323e-01f, 1.71565842e-02f, 1.75019652e-01f, 1.33864358e-01f, 2.35354707e-01f, 1.77401096e-01f, 3.28984946e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.54345497e-01f, 2.58308519e-02f, 8.65251757e-03f, 7.77269900e-02f, -7.64673129e-02f, 4.13810536e-02f, -7.82806426e-02f, -2.46102232e-02f, -3.83569933e-02f, 1.16029769e-01f,
  1.37452841e-01f, -1.19673274e-01f, 6.05686158e-02f, 4.23719063e-02f, -7.11835250e-02f, -6.48472905e-02f, 2.61201590e-01f, 7.81519264e-02f, 1.34876609e-01f, 2.60415107e-01f,
  -8.26351997e-03f, 5.67358285e-02f, 2.09783077e-01f, 1.07551754e-01f, 3.65194939e-02f, -1.62835166e-01f, 9.80699342e-03f, -7.14877769e-02f, -1.56145439e-01f, -1.46801129e-01f,
  -1.47559837e-01f, -8.68089497e-02f, 7.92241022e-02f, 1.43868104e-02f, 1.14566028e-01f, -1.56021975e-02f, 1.41742006e-01f, -4.56392653e-02f, -3.92179154e-02f, 6.82657212e-02f,
  -3.63904946e-02f, -1.26768410e-01f, -1.18022515e-02f, -3.69649567e-02f, 1.05100021e-01f, 1.83270171e-01f, 1.33804992e-01f, 9.19738561e-02f, -5.23425825e-02f, -1.98425010e-01f,
  1.91737846e-01f, 1.93426847e-01f, -3.13838989e-01f, 9.11214016e-03f, 2.93325245e-01f, -1.79492518e-01f, 5.01353927e-02f, -8.62433910e-02f, 1.40684217e-01f, -1.78855017e-01f,
  -1.58358440e-01f, -1.20396048e-01f, 7.29861856e-02f, 7.30191395e-02f, 1.48986354e-01f, -3.29774618e-02f, 1.50943063e-02f, 7.61547461e-02f, 1.69699863e-01f, 6.98486045e-02f,
  1.26808003e-01f, 1.39043510e-01f, 1.08407751e-01f, -1.78708076e-01f, 9.53211263e-02f, -4.49181385e-02f, 1.99587941e-01f, -4.48634028e-02f, 2.00085819e-01f, -6.68720901e-02f,
  -1.24481916e-01f, 2.17850670e-01f, 4.06031013e-02f, -1.91765100e-01f, -1.35342136e-01f, 1.66843701e-02f, 2.05501586e-01f, -9.50799063e-02f, 3.22412699e-02f, -2.14681759e-01f,
  4.86089326e-02f, 1.61002174e-01f, 3.07720929e-01f, 2.83709854e-01f, 2.68093031e-02f, -9.41929296e-02f, 2.17311885e-02f, 3.79970931e-02f, 3.30982381e-03f, 1.42358303e-01f,
  -7.81298652e-02f, -3.86861935e-02f, -1.28760323e-01f, -1.59286380e-01f, -1.25652686e-01f, -6.09152094e-02f, 1.74658269e-01f, -1.93042941e-02f, -5.46627454e-02f, -4.24052514e-02f,
  5.47089241e-02f, -1.59011573e-01f, -6.84431046e-02f, 6.29439056e-02f, -4.75103259e-02f, -1.58458397e-01f, 1.18733525e-01f, -1.98064163e-01f, -8.90494436e-02f, 3.84200886e-02f,
  -2.82841045e-02f, 8.20598900e-02f, 4.22368534e-02f, 1.72623366e-01f, -8.29950422e-02f, -1.11305445e-01f, 1.23087242e-01f, 2.16601521e-01f, 1.06609851e-01f, 3.51912491e-02f,
  9.99206677e-02f, -1.94917731e-02f, 2.28171120e-03f, 1.08169653e-01f, 1.40704975e-01f, 1.07841142e-01f, 1.33946046e-01f, 9.50474292e-02f, -6.42647594e-02f, 1.23990349e-01f,
  5.50425611e-02f, 2.22328734e-02f, -2.18455032e-01f, -2.52997071e-01f, 4.45199721e-02f, -2.51991972e-02f, 7.97172915e-03f, 2.88245916e-01f, -5.25646210e-02f, -6.83906823e-02f,
  -2.14624763e-01f, -5.06502427e-02f, 4.17017676e-02f, 3.47379521e-02f, -1.47060856e-01f, 1.01900429e-01f, -2.62325376e-01f, -1.17030740e-01f, 8.34253654e-02f, -2.84166429e-02f,
  -1.26527622e-01f, 3.45078968e-02f, 1.70447484e-01f, -1.73069045e-01f, 1.37883544e-01f, 8.42645112e-03f, -7.24465996e-02f, 1.08515836e-01f, 7.46729970e-02f, -4.88311797e-02f,
  -2.07049489e-01f, -1.04597576e-01f, 1.07461207e-01f, 1.50183201e-01f, 7.01736808e-02f, 2.32701272e-01f, 3.62030379e-02f, 1.18591279e-01f, 1.04830805e-02f, 2.58418500e-01f,
  -1.18818834e-01f, 5.11632673e-02f, 9.68860686e-02f, -7.85532221e-02f, 4.30714153e-02f, 5.13525344e-02f, 1.66714415e-01f, -1.59756005e-01f, 1.77985534e-01f, 8.10255557e-02f,
  -1.25867695e-01f, -2.32655611e-02f, 6.05096761e-03f, 7.10989088e-02f, 3.47493924e-02f, -9.50433612e-02f, -1.43126175e-01f, -4.55450639e-02f, 1.60829239e-02f, -1.15893036e-01f,
  -1.30480617e-01f, 6.05209284e-02f, 2.05204450e-02f, -1.55827031e-01f, -1.16649933e-01f, 2.08806574e-01f, -2.84227520e-01f, -1.38808176e-01f, 1.77915365e-01f, -1.17719389e-01f,
  -5.98494336e-02f, 1.58788845e-01f, -3.17518748e-02f, -1.32083252e-01f, -2.30928004e-01f, -5.23925107e-03f, 1.72714353e-01f, 3.76863480e-02f, 3.22377607e-02f, 3.26232687e-02f,
  6.59455284e-02f, -1.52918160e-01f, 6.99698627e-02f, -1.77266076e-01f, 2.12334301e-02f, 1.65656716e-01f, 8.48871395e-02f, -2.55717307e-01f, 1.39168620e-01f, -1.58208013e-01f,
  -1.35238335e-01f, 8.87829736e-02f, 2.01433107e-01f, 3.29517797e-02f, -2.22958758e-01f, -9.99480393e-03f, 6.56192601e-02f, -1.28609180e-01f, 6.28383411e-03f, 1.56440839e-01f,
  -8.50723535e-02f, 1.73793644e-01f, 1.44793034e-01f, 7.63793290e-02f, 1.35473296e-01f, -8.11853483e-02f, 2.34831069e-02f, -1.96356237e-01f, -1.69067517e-01f, -1.28122821e-01f,
  -2.18836710e-01f, 1.74347505e-01f, 2.18691349e-01f, -2.78315116e-02f, -1.73779681e-01f, -1.18100084e-01f, -7.32906163e-02f, -7.08758011e-02f, 4.18779254e-02f, -2.20460165e-02f,
  2.49424167e-02f, 2.18313523e-02f, -2.52919812e-02f, 8.95272344e-02f, -5.91749176e-02f, -4.84814547e-04f, -1.92365870e-02f, -5.12815639e-02f, -2.07848176e-02f, -4.90084440e-02f,
  -2.96165589e-02f, 4.39593941e-02f, -1.45847593e-02f, -1.41755462e-01f, 1.49278026e-02f, -1.83666617e-01f, 5.58454283e-02f, -2.70586431e-01f, 1.55333400e-01f, -6.35201484e-02f,
  1.63824871e-01f, 2.05320239e-01f, 6.33573309e-02f, -1.01354823e-01f, 9.05136466e-02f, 2.39280403e-01f, -9.90461558e-02f, 1.24114156e-01f, 1.14306264e-01f, 8.04860592e-02f,
  -4.70080674e-02f, 1.87774524e-01f, -1.72135442e-01f, -1.45690246e-02f, 1.21025033e-01f, -2.13749915e-01f, -1.75151795e-01f, 2.34082654e-01f, 1.65075019e-01f, -1.12286275e-02f,
  -5.53185642e-02f, -1.32239595e-01f, -8.07238817e-02f, -8.81227106e-02f, 7.34533742e-02f, 1.53864786e-01f, 1.62690897e-02f, -1.06107779e-01f, 2.33811602e-01f, -2.16453031e-01f,
  -1.26927301e-01f, -5.52727617e-02f, -1.74242049e-01f, -9.70599353e-02f, -9.49153751e-02f, 2.00717941e-01f, -5.31522483e-02f, -2.24597584e-02f, 1.99868813e-01f, -2.58382082e-01f,
  3.64163630e-02f, -7.57411048e-02f, -4.50523011e-02f, 1.71618819e-01f, 8.77903029e-02f, -5.36176749e-02f, 8.83295294e-03f, -1.33185210e-02f, 8.79514068e-02f, -1.28512099e-01f,
  8.80525932e-02f, 1.19880706e-01f, 1.29501045e-01f, -7.39772618e-02f, 2.06729397e-01f, 1.55022889e-01f, -7.44260773e-02f, 1.65487915e-01f, 1.40683958e-03f, -7.92526305e-02f,
  -8.96211639e-02f, 6.32800311e-02f, 1.66169673e-01f, 2.38620296e-01f, 2.38668062e-02f, -1.79602653e-01f, -4.13130634e-02f, -6.29573390e-02f, 2.23190024e-01f, 1.89056818e-03f,
  -1.11307062e-01f, 7.25136772e-02f, 2.31944509e-02f, -1.40453503e-01f, -1.72700025e-02f, -3.70863229e-02f, 4.81877923e-02f, 2.10062712e-02f, -3.54402401e-02f, 1.57753929e-01f,
  -1.54322729e-01f, 7.82567859e-02f, 2.28531420e-01f, -2.05761334e-03f, 9.28802823e-04f, -1.66143268e-01f, -5.47666065e-02f, -2.25817859e-01f, 6.55446649e-02f, -1.34221211e-01f,
  -1.07573709e-02f, -1.99765936e-01f, 1.78204149e-01f, 7.85533413e-02f, 1.04682304e-01f, 7.28086606e-02f, -4.47244272e-02f, 1.80697501e-01f, 1.77628659e-02f, 1.87741235e-01f,
  -1.77157611e-01f, 3.92641686e-02f, -1.04558587e-01f, 1.43582970e-01f, 1.27761140e-01f, 6.48537502e-02f, -3.83793353e-03f, 1.16035804e-01f, 5.77720515e-02f, 5.86359389e-02f,
  8.04833993e-02f, -4.48908359e-02f, 1.23829693e-01f, -6.00606501e-02f, 1.32672880e-02f, -2.17612740e-03f, -9.04301032e-02f, 1.89814493e-01f, 1.44479692e-01f, 1.55475929e-01f,
  -5.16205244e-02f, 1.03736445e-01f, -1.59141317e-01f, -3.82171683e-02f, 4.72035967e-02f, 1.58488020e-01f, -2.72501335e-02f, 1.70627296e-01f, -1.83106139e-01f, 6.73156455e-02f,
  -2.08536789e-01f, 5.13169467e-02f, 9.91414487e-02f, -2.31951158e-02f, 1.17709897e-01f, 1.19862698e-01f, -1.36905059e-01f, -4.25960608e-02f, 1.57035775e-02f, -1.44252151e-01f,
  1.27795130e-01f, -6.87753931e-02f, -2.09232062e-01f, 2.52700508e-01f, 7.07446709e-02f, 1.57437384e-01f, -2.07990393e-01f, 8.99421126e-02f, 1.49311930e-01f, -2.65620530e-01f,
  -1.53839603e-01f, -1.65799007e-01f, -1.95338592e-01f, 1.22576347e-02f, 1.12699352e-01f, -1.38245776e-01f, 2.46424302e-01f, -1.96329594e-01f, 1.23081096e-01f, 8.40960741e-02f,
  1.33669144e-02f, 1.24113299e-01f, 5.20728668e-03f, 9.56974700e-02f, -2.07448676e-01f, -5.14307134e-02f, -1.60443500e-01f, 7.73105770e-02f, 6.54106885e-02f, -9.68915150e-02f,
  1.56255603e-01f, 6.21553250e-02f, 6.46849424e-02f, -4.27410826e-02f, 8.49881545e-02f, 6.21193498e-02f, 8.96907151e-02f, -1.33318335e-01f, -5.95488474e-02f, -6.74641654e-02f,
  2.54717499e-01f, -1.79506183e-01f, 2.40679625e-02f, 4.79479805e-02f, -9.05936584e-02f, -7.95142427e-02f, 9.09234956e-02f, -6.22841381e-02f, 1.85871422e-01f, -2.04009265e-01f,
  1.21544145e-01f, 9.76597816e-02f, -2.14406978e-02f, -5.03712893e-02f, 8.49464908e-02f, -5.47854789e-02f, 7.65675977e-02f, 1.24804959e-01f, 6.59170821e-02f, -2.25228835e-02f,
  -1.75809443e-01f, -1.43717220e-02f, 9.06055793e-02f, -4.86374460e-02f, 9.28014610e-03f, 4.10710350e-02f, 2.33066492e-02f, 1.44757688e-01f, -1.18452735e-01f, 8.70566219e-02f,
  1.40129209e-01f, -1.14565194e-01f, -4.63316105e-02f, 2.24484112e-02f, -1.35323778e-01f, -1.46451592e-01f, 2.09455527e-02f, -4.78713140e-02f, -1.46888852e-01f, -2.41753608e-01f,
  -7.48077333e-02f, 2.47936137e-02f, 8.36036727e-02f, -4.18892354e-02f, 1.08519467e-02f, 2.48870835e-01f, 1.71572715e-01f, -2.60674413e-02f, -9.97142792e-02f, -1.50421590e-01f,
  1.71374932e-01f, -4.45512608e-02f, -4.62232940e-02f, 5.03474809e-02f, 1.10825412e-01f, 4.12946716e-02f, -4.02891524e-02f, 8.89548138e-02f, 1.48580587e-02f, -1.96375395e-03f,
  8.98776352e-02f, 1.25853434e-01f, 5.78852110e-02f, -2.86323875e-02f, -7.65790567e-02f, 7.22901477e-03f, -1.44439965e-01f, 1.57723129e-01f, 3.12986702e-01f, -9.13516432e-02f,
  9.54722315e-02f, 1.21174514e-01f, 1.28856137e-01f, -1.94923803e-01f, 1.55530125e-01f, -1.32537842e-01f, -1.43687967e-02f, 8.32759514e-02f, 1.31212786e-01f, -1.77708760e-01f,
  1.59188673e-01f, 2.32216895e-01f, -8.97576809e-02f, -1.51589587e-01f, 1.65780649e-01f, 1.91803366e-01f, -9.41419601e-02f, 2.78974324e-02f, 8.99049640e-02f, -1.60133764e-01f,
  -1.14220299e-01f, 2.99301110e-02f, 6.41221777e-02f, -5.27058244e-02f, 2.11116642e-01f, -1.33632854e-01f, 2.21370846e-01f, 1.60165280e-01f, 1.76772743e-01f, 3.79904872e-03f,
  -1.82318807e-01f, 8.49890485e-02f, -4.01942879e-02f, -5.43994270e-02f, 1.13208532e-01f, -1.73427686e-01f, 3.03947210e-01f, -1.26414791e-01f, -9.63787287e-02f, -1.78348839e-01f,
  -2.50732273e-01f, 5.47554865e-02f, 6.03978448e-02f, 5.29072694e-02f, -1.11487821e-01f, -1.79823861e-01f, 2.38653719e-02f, 1.14459908e-02f, -1.41557366e-01f, -2.85421275e-02f,
  3.24515738e-02f, -6.31003466e-04f, -2.92778760e-02f, -3.50870155e-02f, 2.34904569e-02f, 2.56807683e-03f, -8.40603113e-02f, 9.83775593e-03f, -1.12237968e-01f, -1.72614798e-01f,
  -9.29973945e-02f, -1.59445703e-01f, -9.41887647e-02f, -3.72509584e-02f, 2.31063506e-03f, 1.94502417e-02f, 2.00185061e-01f, -2.49188747e-02f, 3.27265114e-02f, -2.10419372e-01f,
  -7.00917691e-02f, -3.55745740e-02f, -1.10098615e-01f, 1.31846545e-02f, -2.88605480e-03f, 1.07982837e-01f, 1.74279995e-02f, -2.19351858e-01f, 1.05194204e-01f, 1.68620527e-01f,
  -2.73984104e-01f, -5.13395257e-02f, 2.57009780e-03f, 2.17773274e-01f, -1.22360736e-01f, -1.31463900e-01f, 1.13772511e-01f, -8.47031176e-02f, 1.54968634e-01f, -1.32319435e-01f,
  -1.31621167e-01f, 5.48116751e-02f, 6.24483041e-02f, 1.87678903e-01f, 6.57571033e-02f, 1.05497211e-01f, -1.23859584e-01f, 1.78303659e-01f, -5.06333522e-02f, -2.46506482e-01f,
  -2.83356726e-01f, -1.41844481e-01f, 2.01007053e-01f, -1.87990144e-01f, -6.24502264e-02f, 1.42941549e-01f, 1.75911874e-01f, -5.95730729e-02f, -1.71657965e-01f, 1.11085631e-01f,
  2.11286061e-02f, 2.89621502e-02f, 1.31619513e-01f, 9.17377397e-02f, -2.03658920e-02f, 1.19513132e-01f, 5.27752303e-02f, 1.09462388e-01f, 6.93936348e-02f, -8.31653178e-02f,
  3.54995318e-02f, 1.19884878e-01f, 2.67387837e-01f, 7.86457360e-02f, 2.10214749e-01f, -1.22934058e-02f, 7.10110441e-02f, 1.31032363e-01f, -1.22151218e-01f, -2.40871027e-01f,
  -1.15821220e-01f, 3.98931541e-02f, 1.79100633e-01f, -8.24599713e-02f, -1.32402405e-01f, -1.97324157e-01f, 9.34630483e-02f, -1.64702088e-02f, 2.36683860e-01f, 3.63606177e-02f,
  -8.57935995e-02f, 2.08146814e-02f, 1.49751469e-01f, -7.93750137e-02f, 2.22786907e-02f, 1.60867319e-01f, 8.39772224e-02f, 1.77005872e-01f, -1.28652349e-01f, -6.12187050e-02f,
  -1.23606166e-02f, 1.23207018e-01f, 9.84184518e-02f, 1.13518037e-01f, -4.09919843e-02f, -3.68214548e-01f, 9.09036472e-02f, -2.16549471e-01f, 9.83419195e-02f, 8.96228757e-03f,
  -6.66837990e-02f, -6.82720393e-02f, 4.54361662e-02f, 1.42192096e-01f, -2.43620247e-01f, -1.43634766e-01f, -2.06315964e-01f, -7.47512281e-02f, -8.83669704e-02f, 1.36416376e-01f,
  -9.93642360e-02f, -1.22519314e-01f, 1.54461533e-01f, 3.40976156e-02f, -1.17823832e-01f, 4.77931052e-02f, -1.96208447e-01f, -1.27553660e-02f, 3.10501028e-02f, -1.19399436e-01f,
  1.87885314e-02f, 4.93320785e-02f, 2.38399245e-02f, -1.36097800e-02f, -5.34980297e-02f, -1.04305722e-01f, 1.27413375e-02f, 4.91052978e-02f, -8.12690780e-02f, -1.90375984e-01f,
  8.40926543e-02f, 9.89825726e-02f, -5.79105578e-02f, -2.47753263e-01f, -9.28530097e-02f, -2.46080115e-01f, -1.02615722e-01f, -2.43609935e-01f, 1.88186064e-01f, -1.52850933e-02f,
  -1.24505714e-01f, -8.09785575e-02f, 2.60780483e-01f, 2.95285583e-01f, 6.64298758e-02f, -1.56662360e-01f, 6.96163485e-03f, 5.72723448e-02f, -2.13006601e-01f, 1.75130278e-01f,
  -8.35065693e-02f, 2.46974990e-01f, 2.23644041e-02f, -9.42667872e-02f, 1.99879766e-01f, -8.63531791e-03f, 5.02500590e-03f, -1.54825181e-01f, -1.43699124e-01f, 2.98464913e-02f,
  1.99783504e-01f, 1.97689831e-01f, 1.20135769e-01f, -7.77268186e-02f, 1.33768827e-01f, 1.84714869e-01f, 5.65848947e-02f, 3.51725593e-02f, -3.21685225e-02f, -1.00667529e-01f,
  -2.73946840e-02f, -1.10242061e-01f, -1.81569099e-01f, 1.37894928e-01f, 2.38205474e-02f, -1.41477406e-01f, 6.01866432e-02f, -1.53804645e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -2.72681238e-03f, 1.82996329e-03f, 1.79355145e-01f, 1.22806422e-01f, 1.73588723e-01f, 1.05709858e-01f, 5.85373212e-03f, 3.74756418e-02f, 2.56635159e-01f, 2.00104386e-01f,
  3.86769734e-02f, 1.94631785e-01f, -3.90631557e-02f, -1.79703217e-02f, -1.95543006e-01f, -3.32435101e-01f, -2.60146171e-01f, -3.52866232e-01f, 1.31387442e-01f, -1.55807450e-01f,
  -6.46244437e-02f, -1.54293895e-01f, -3.55625570e-01f, -1.48594812e-01f, 1.16456568e-01f, 7.35150874e-02f, -1.42985418e-01f, 1.00345641e-01f, 1.04732968e-01f, 2.98018306e-01f,
  9.17354375e-02f, -1.49285555e-01f, 2.88666841e-02f, 2.09633604e-01f, -7.18968436e-02f, 1.14767201e-01f, 4.86220084e-02f, 1.30448550e-01f, -1.09773487e-01f, -2.27692589e-01f,
  1.11375600e-01f, 2.26726934e-01f, 1.04335554e-01f, -8.91773775e-02f, -2.75695175e-01f, 4.65049595e-02f, -1.61126256e-02f, 1.50747374e-01f, 1.17140710e-01f, 2.62795538e-01f,
  8.69524404e-02f, 2.02465698e-01f, 2.15107098e-01f, 2.34367326e-01f, -3.48462969e-01f, 5.13618104e-02f, 1.83936179e-01f, -1.08640820e-01f, -8.48208275e-03f, 1.26753986e-01f,
  3.27128589e-01f, 1.97827086e-01f, -8.59195646e-03f, -7.52130300e-02f, 7.76508003e-02f, 2.61218965e-01f, 3.17725360e-01f, 3.13716322e-01f, 1.79124817e-01f, 3.02642584e-01f,
  2.51823545e-01f, 9.92254987e-02f, 2.68636793e-01f, 1.40538976e-01f, 1.94883585e-01f, 1.29101813e-01f, 4.02539045e-01f, -1.86956584e-01f, -1.90288201e-01f, -1.28986701e-01f,
  2.59656549e-01f, -2.97351032e-02f, 8.29803720e-02f, 1.30086824e-01f, -8.76915976e-02f, -2.03994900e-01f, 5.26542701e-02f, 1.20435031e-02f, 3.05121392e-01f, -1.30816787e-01f,
  6.56202585e-02f, -4.53490298e-03f, 2.48939246e-02f, -9.98516977e-02f, -8.35108459e-02f, -1.03110477e-01f, 7.52970651e-02f, -8.66513774e-02f, 3.34831059e-01f, -2.41413683e-01f,
  3.18682700e-01f, -6.84330314e-02f, -1.75332978e-01f, 3.26447010e-01f, -2.10592866e-01f, 1.98627770e-01f, -1.81306452e-01f, -7.64738536e-03f, 1.95176527e-01f, 1.94555987e-02f,
  -7.46828169e-02f, -1.06081128e-01f, 1.47755265e-01f, 3.40907574e-02f, -1.57858953e-02f, 1.71927568e-02f, 2.91779548e-01f, 1.91613644e-01f, 2.81971157e-01f, -1.35792777e-01f,
  -1.66035429e-01f, -5.14785461e-02f, -2.28100084e-02f, 2.53868580e-01f, -1.92565888e-01f, -2.14763194e-01f, 2.82185107e-01f, -4.29721326e-02f, 2.15832800e-01f, 5.28056994e-02f,
  1.72088116e-01f, 1.88211456e-01f, 1.84383914e-01f, 8.15528706e-02f, 1.02097705e-01f, 2.16184810e-01f, 1.91666812e-01f, -9.74426344e-02f, 2.02757731e-01f, 4.34558131e-02f,
  4.80190843e-01f, -2.41963074e-01f, 2.11434305e-01f, -1.37335667e-02f, -8.54656026e-02f, 3.21106791e-01f, -4.82532382e-02f, -2.92928994e-01f, -1.07760608e-01f, 2.59920001e-01f,
  1.62678257e-01f, -2.18535468e-01f, 6.58992082e-02f, -8.02221801e-03f, 2.85857707e-01f, 2.87138253e-01f, 3.00587583e-02f, 1.21435650e-01f, -2.33875170e-01f, 3.33827808e-02f,
  -1.04630232e-01f, -2.63365328e-01f, 3.55208993e-01f, 3.20576251e-01f, 7.37698004e-02f, 3.88942480e-01f, -1.38036981e-01f, -1.06464721e-01f, -1.91194862e-01f, -4.33065332e-02f,
  2.30296969e-01f, 2.57751554e-01f, -1.53216451e-01f, -1.64763659e-01f, 1.88542351e-01f, -7.76552036e-03f, 3.20783556e-01f, -2.41269860e-02f, -9.13945287e-02f, 2.46110968e-02f,
  -1.15872465e-01f, 1.66131794e-01f, -2.19909605e-04f, -2.99766324e-02f, -4.28192541e-02f, -1.97297975e-01f, -4.08427007e-02f, -1.72533453e-01f, -1.99473038e-01f, -4.12985802e-01f,
  2.19909802e-01f, 2.23264620e-01f, -5.64386286e-02f, 1.36265948e-01f, 2.80347139e-01f, -2.28080209e-02f, 3.76737602e-02f, 3.49154919e-02f, 2.13785693e-01f, 2.31112987e-01f,
  -8.53087232e-02f, 2.60514971e-02f, -1.36533320e-01f, 7.75557160e-02f, 1.00742221e-01f, -1.25502944e-01f, -6.73807189e-02f, -3.75960916e-02f, -1.17289208e-01f, -2.34337494e-01f,
  3.35496098e-01f, -3.03511411e-01f, -1.20834835e-01f, 1.82141066e-01f, -1.39734969e-01f, -8.92908871e-02f, 1.25605360e-01f, -2.75701433e-01f, 1.37609124e-01f, 6.50509000e-02f,
  -1.88468341e-02f, 7.82183632e-02f, 2.10236505e-01f, 5.28021306e-02f, 1.62933052e-01f, -1.39821261e-01f, 9.24661160e-02f, 2.85757542e-01f, -1.12171710e-01f, 2.19429716e-01f,
  1.32528082e-01f, 6.73807412e-02f, -1.54233808e-02f, -1.83631599e-01f, 2.25756869e-01f, -2.99397856e-01f, -1.45735731e-02f, -8.17719698e-02f, 2.13698983e-01f, -1.64611742e-01f,
  3.03536505e-01f, 1.02929488e-01f, 2.68896669e-01f, 6.22972995e-02f, -2.43372843e-01f, 4.61082339e-01f, -1.09813735e-01f, 1.64048344e-01f, 5.43000810e-02f, 2.70992309e-01f,
  3.29060853e-01f, -9.40745696e-02f, -8.83655623e-02f, 2.29379058e-01f, 3.49184185e-01f, -4.03224528e-02f, 1.82275385e-01f, 2.28444383e-01f, 6.90466091e-02f, 5.84823601e-02f,
  1.59682155e-01f, 5.57476841e-02f, 5.50073944e-02f, 2.15649515e-01f, 1.04640365e-01f, 1.54024750e-01f, 1.59374893e-01f, 8.31131637e-02f, -9.56717059e-02f, 2.64975131e-01f,
  2.01909840e-01f, 1.06348567e-01f, -3.12634051e-01f, 6.60990402e-02f, -3.13757420e-01f, -1.54225037e-01f, -4.07577939e-02f, 2.18478054e-01f, 1.55369237e-01f, 1.61027789e-01f,
  -9.36657786e-02f, 2.90353626e-01f, 2.14662641e-01f, 1.22924127e-01f, 4.34456319e-02f, -1.56631857e-01f, -6.57888278e-02f, -2.18767626e-03f, -7.49807134e-02f, -2.28842825e-01f,
  1.97273657e-01f, -3.88842851e-01f, 8.88008401e-02f, 4.26326357e-02f, 2.22699702e-01f, 3.95541377e-02f, 2.18569562e-01f, 2.67940611e-01f, -3.61350775e-02f, 4.19737697e-01f,
  -1.39703788e-02f, -4.31963921e-01f, -2.67875314e-01f, -5.22875749e-02f, -1.77163005e-01f, 1.53090715e-01f, -4.54626270e-02f, 2.23642379e-01f, 4.19767231e-01f, 1.88164353e-01f,
  -6.54361024e-02f, 1.02727368e-01f, 9.05622542e-02f, -2.39501566e-01f, -3.09843212e-01f, 2.19997361e-01f, 2.77562827e-01f, -6.41942620e-02f, -1.17113821e-01f, 2.17271626e-01f,
  2.19592333e-01f, 1.17846206e-01f, -2.52430607e-02f, 1.18541270e-01f, 1.29820570e-01f, 9.57481861e-02f, 2.27525100e-01f, 3.64343356e-03f, 1.67590231e-01f, 4.40647937e-02f,
  2.12531939e-01f, 1.76502746e-02f, -1.80234149e-01f, 1.72666296e-01f, -1.70829400e-01f, -4.69672382e-02f, 3.61235976e-01f, 1.39992476e-01f, -5.12465052e-02f, 2.94647336e-01f,
  1.03518091e-01f, -3.47463429e-01f, -1.57831967e-01f, 2.55087689e-02f, 2.30984569e-01f, 3.15055788e-01f, -1.64462149e-01f, -2.01518565e-01f, 1.09538138e-01f, 3.27560194e-02f,
  3.45410675e-01f, 2.88767368e-01f, -2.35364899e-01f, 3.59451145e-01f, 1.63536459e-01f, 2.29682904e-02f, 1.21789247e-01f, -2.25373596e-01f, 2.08223566e-01f, 4.19847429e-01f,
  2.05109492e-01f, 1.60166129e-01f, -2.28542209e-01f, -2.15938032e-01f, 2.44430676e-01f, 3.07564765e-01f, 4.09278050e-02f, 2.45280251e-01f, -2.92888492e-01f, -3.77493654e-03f,
  -1.23568534e-04f, 9.62843597e-02f, 1.69936717e-01f, -2.10540891e-01f, 4.27455038e-01f, 1.93616390e-01f, -1.28637850e-01f, 2.37942994e-01f, 2.55868703e-01f, 2.38277555e-01f,
  -2.77552940e-03f, 2.83094674e-01f, 1.63892418e-01f, -2.59607106e-01f, -1.47090117e-02f, 2.29242057e-01f, 2.24654466e-01f, -8.52901489e-02f, 1.36831403e-01f, 1.65704906e-01f,
  -2.12175660e-02f, 1.05287738e-01f, 6.70430213e-02f, 2.55227894e-01f, 1.34895772e-01f, 9.93606895e-02f, -2.92583644e-01f, 3.93007010e-01f, -1.93444669e-01f, -1.50297046e-01f,
  2.49133557e-02f, -2.19171509e-01f, -1.43560931e-01f, 1.08414218e-02f, -1.97057649e-02f, 1.83975980e-01f, -2.18439683e-01f, 1.09679222e-01f, 2.32972503e-02f, 2.93369830e-01f,
  5.67092150e-02f, 1.16678374e-02f, -3.22674215e-01f, -1.09436437e-01f, 6.13039546e-02f, 2.31977209e-01f, -2.51945816e-02f, -1.81242228e-01f, 4.80319187e-02f, -3.08848947e-01f,
  8.11753571e-02f, 1.80450439e-01f, 3.95574450e-01f, 1.35665193e-01f, 1.72231182e-01f, 9.24454853e-02f, -2.56500125e-01f, 2.52265245e-01f, 4.16719094e-02f, -1.71082675e-01f,
  1.82592608e-02f, 1.12130284e-01f, 1.05652764e-01f, 2.42266178e-01f, 7.34910592e-02f, 3.61904383e-01f, 3.20976190e-02f, 3.25666726e-01f, -2.73472182e-02f, 2.64618993e-01f,
  -4.24446762e-02f, -1.60941094e-01f, -2.15403978e-02f, -1.02376081e-01f, 3.75397295e-01f, 2.66194016e-01f, -2.11157575e-01f, -6.84179813e-02f, 1.14733934e-01f, 7.77661502e-02f,
  2.74997223e-02f, 1.23277888e-01f, 2.26534650e-01f, 1.25488609e-01f, 9.65133980e-02f, 1.13476120e-01f, 2.48032898e-01f, 1.96007609e-01f, 1.25000477e-01f, 1.15843669e-01f,
  1.09221928e-01f, 1.63417742e-01f, 9.07171443e-02f, -3.90872210e-01f, -1.60409704e-01f, 3.20905983e-01f, 1.25801405e-02f, -3.98495272e-02f, 1.10130347e-01f, 1.87762856e-01f,
  -1.90114349e-01f, -7.69166648e-02f, -6.19789623e-02f, -1.35399163e-01f, -8.82020444e-02f, 9.23718363e-02f, 1.55371293e-01f, 1.15490943e-01f, 1.51868120e-01f, -2.22370207e-01f,
  6.66408762e-02f, 1.95364863e-01f, 8.70040134e-02f, -7.36055598e-02f, 2.48770550e-01f, 3.43781203e-01f, -2.25262776e-01f, -1.07418545e-01f, 3.04919034e-01f, 2.53008362e-02f,
  -1.81119874e-01f, 1.17087439e-01f, -2.20055267e-01f, 2.98538536e-01f, 9.74091142e-02f, 2.34438762e-01f, 1.61078095e-01f, -3.61030619e-03f, -7.55904242e-02f, 2.28276685e-01f,
  1.69280767e-01f, 1.32843316e-01f, -3.49530697e-01f, -1.46448001e-01f, 4.84527260e-01f, 4.50976491e-02f, -1.88507922e-02f, 4.75720987e-02f, 2.85205334e-01f, 4.40786853e-02f,
  -3.14100593e-01f, 4.69355345e-01f, 2.00952604e-01f, 1.35811150e-01f, 9.63601992e-02f, -2.86857840e-02f, -1.30317152e-01f, -5.27584329e-02f, -2.79184747e-02f, -6.49125353e-02f,
  -1.34979233e-01f, 3.04643363e-01f, 2.11901516e-01f, 2.45468356e-02f, -1.78004757e-01f, 3.52512896e-01f, -7.84700960e-02f, 3.83820236e-01f, 4.07648236e-01f, -1.14703156e-01f,
  1.20200858e-01f, 3.95237058e-01f, -1.22092105e-01f, 1.21421531e-01f, 1.35146379e-01f, 3.75437766e-01f, -1.10886335e-01f, 1.61556005e-01f, 1.31002501e-01f, -2.85752445e-01f,
  -1.22191839e-01f, -5.02914675e-02f, 1.15365267e-01f, 3.41034085e-01f, 1.88552350e-01f, 4.51230630e-03f, -1.22284228e-02f, 2.37340450e-01f, 1.80805534e-01f, -3.42358857e-01f,
  3.74301136e-01f, 3.28804672e-01f, -1.63495690e-02f, 5.11640646e-02f, 1.93721935e-01f, 1.88438937e-01f, 4.05851394e-01f, 1.48608610e-01f, 2.40072221e-01f, -6.65968135e-02f,
  -1.54628605e-01f, -2.39419639e-01f, 3.29275280e-01f, 4.40343795e-03f, -2.48359561e-01f, -1.01417936e-01f, 2.65715599e-01f, 3.24445665e-01f, -1.24765500e-01f, 1.91649362e-01f,
  2.15072557e-01f, -2.41549268e-01f, -6.99079856e-02f, 1.34606704e-01f, -2.01082096e-01f, -1.00767285e-01f, -9.77705047e-02f, -8.24857596e-03f, -3.53237353e-02f, 1.01431765e-01f,
  -1.03836372e-01f, 1.44892693e-01f, 1.08311847e-01f, -7.30169341e-02f, 1.83443964e-01f, 9.65957269e-02f, 4.95874602e-03f, 1.56955212e-01f, -6.91205114e-02f, -2.72453815e-01f,
  -1.05832100e-01f, -1.98723197e-01f, 2.22060174e-01f, -3.36162388e-01f, 8.06488916e-02f, 1.57395661e-01f, 2.61104047e-01f, -7.79915527e-02f, -1.40065864e-01f, -3.21804971e-01f,
  1.63792476e-01f, 3.50302219e-01f, 3.30678701e-01f, 6.86149439e-03f, 8.62498060e-02f, 3.09492022e-01f, -1.78670868e-01f, 9.88243893e-02f, -4.42539491e-02f, 2.59963483e-01f,
  -2.99542528e-02f, 3.78255039e-01f, 2.38658190e-02f, 3.53858411e-01f, 3.75175655e-01f, -1.29163727e-01f, 3.22809666e-01f, 8.20228551e-03f, -1.56703908e-02f, 1.02603354e-01f,
  9.58758146e-02f, 1.70629039e-01f, 1.38464317e-01f, 3.09434265e-01f, 2.11821645e-01f, -3.90828997e-02f, -1.66070580e-01f, 7.18718842e-02f, -1.15467459e-01f, 1.27241179e-01f,
  -7.05913603e-02f, 1.23819850e-01f, -1.86828494e-01f, -7.62367845e-02f, -2.55225636e-02f, -7.23215491e-02f, 3.65642399e-01f, 9.49613303e-02f, 2.43754193e-01f, -3.27883124e-01f,
  1.45340741e-01f, 4.72524390e-02f, 9.30531621e-02f, 2.56083339e-01f, 2.46262014e-01f, 1.57588080e-01f, 4.10783812e-02f, 1.25079408e-01f, 1.82848141e-01f, 1.50498480e-01f,
  1.88261226e-01f, 1.61002055e-01f, 2.45191544e-01f, -4.07912195e-01f, 5.22464514e-02f, 1.17308259e-01f, 2.99761854e-02f, 3.38991284e-01f, 7.62684494e-02f, 2.78235376e-01f,
  3.60455513e-01f, -3.74520600e-01f, 1.77410528e-01f, 4.08279113e-02f, 7.93327317e-02f, 1.48549214e-01f, 2.59584427e-01f, 1.15623660e-01f, 1.53463082e-02f, 3.19957972e-01f,
  -7.28032738e-02f, -1.02950975e-01f, -2.81089038e-01f, 2.22972602e-01f, 1.99181065e-01f, 1.85745776e-01f, 2.10859254e-01f, -1.15498550e-01f, -1.09811075e-01f, 2.99756899e-02f,
  -9.41362455e-02f, -8.84296745e-02f, 1.85966581e-01f, -2.02187091e-01f, 1.41640175e-02f, 4.97610033e-01f, -6.14272170e-02f, 1.85889021e-01f, 1.47877291e-01f, -1.48681864e-01f,
  -3.05209607e-01f, -2.39306763e-01f, -1.74654379e-01f, -1.18129715e-01f, 1.64923325e-01f, -6.10356703e-02f, 3.86544824e-01f, -3.91369313e-02f, 2.13825535e-02f, -1.57799870e-01f,
  -2.45416179e-01f, -2.59167135e-01f, 3.72152925e-01f, 2.86565393e-01f, 1.14641115e-02f, 1.41657668e-03f, 1.40918002e-01f, 3.13437253e-01f, 1.79161638e-01f, 2.60962546e-01f,
  1.62753180e-01f, 2.84442961e-01f, 2.94865042e-01f, 9.99829844e-02f, 2.72336118e-02f, 1.12843595e-01f, 2.35921383e-01f, -2.81015486e-01f, -1.40036911e-01f, 2.44111001e-01f,
  5.61726242e-02f, 3.83948565e-01f, -1.75301000e-01f, 2.59781837e-01f, 3.45868975e-01f, -5.87141216e-02f, 2.54783541e-01f, -7.00211106e-03f, 2.93998420e-01f, 4.79337007e-01f,
  4.29961085e-02f, 1.97999924e-01f, -1.63096562e-01f, -7.79272243e-02f, 1.06366739e-01f, 2.15790808e-01f, -3.76176000e-01f, 2.50583757e-02f, 3.17068368e-01f, -3.04258149e-02f,
  3.00970882e-01f, -1.29065558e-01f, 5.99850621e-03f, 7.53233582e-02f, 3.76760103e-02f, -1.26364350e-01f, 1.65500380e-02f, 4.32707220e-01f, 3.41417670e-01f, 3.35183948e-01f,
  1.18875742e-01f, 2.74804533e-01f, -5.93819693e-02f, 5.94533607e-02f, 2.65836827e-02f, -1.37795145e-02f, -1.92917913e-01f, -2.27860153e-01f, 3.49404037e-01f, -8.83553848e-02f,
  2.41450146e-01f, -5.50191812e-02f, -1.36145264e-01f, -5.00821173e-02f, -3.46303910e-01f, -2.88835853e-01f, 4.22972709e-01f, 2.17720196e-01f, -5.11481799e-02f, 2.23748744e-01f,
  2.00644284e-01f, 1.09220192e-01f, 1.47975266e-01f, 2.33526155e-01f, 7.13364854e-02f, 2.89763778e-01f, 3.17787796e-01f, -1.55985244e-02f, 6.17556684e-02f, 1.59219831e-01f,
  -2.07396120e-01f, -2.04707012e-01f, -1.15462646e-01f, 1.40444800e-01f, -2.66019851e-01f, -1.77848384e-01f, -2.35212505e-01f, -2.73110032e-01f, 2.58448929e-01f, -1.33256450e-01f,
  -1.20942071e-01f, 3.96078965e-03f, 4.03576821e-01f, 2.45348617e-01f, 2.71556247e-02f, 2.24330574e-01f, 2.53665984e-01f, 2.01959834e-01f, 3.12886685e-01f, 2.04000950e-01f,
  -7.82108605e-02f, 8.27552751e-02f, -1.89022243e-01f, 6.11229911e-02f, -2.19373375e-01f, 2.21856534e-01f, -2.66978778e-02f, -1.84173629e-01f, 2.78575242e-01f, 3.49678576e-01f,
  2.35905558e-01f, 6.51719570e-02f, -3.31802070e-01f, -2.69457757e-01f, -9.37325880e-02f, 1.57344148e-01f, -1.37518704e-01f, 4.73786980e-01f, 1.21735096e-01f, -9.89584625e-02f,
  2.52088100e-01f, -1.49109736e-01f, -1.56093732e-01f, 1.65580250e-02f, 2.68231779e-02f, -1.81058258e-01f, -3.18995059e-01f, 3.19333881e-01f, 1.39995500e-01f, 1.12656265e-01f,
  3.04467231e-01f, -2.88130194e-01f, 4.00572754e-02f, 9.29180905e-02f, 4.95493449e-02f, -1.54711768e-01f, 1.31890208e-01f, -6.49963552e-03f, 1.52947558e-02f, -4.46653478e-02f,
  1.54792190e-01f, 1.37624040e-01f, -1.89852268e-02f, 4.39083166e-02f, 4.24844287e-02f, 3.43388408e-01f, -3.17784607e-01f, -4.27279532e-01f, 1.04237609e-01f, -2.53359050e-01f,
  2.14912415e-01f, -1.66708753e-01f, -1.09694242e-01f, 3.42685848e-01f, -2.87802905e-01f, -2.29983684e-02f, 1.59194842e-01f, -1.73634186e-01f, -1.71755120e-01f, 7.73248672e-02f,
  -2.72858113e-01f, -2.57465154e-01f, 2.08634580e-03f, -1.18202366e-01f, 2.19429746e-01f, -8.23550075e-02f, 1.96088716e-01f, -2.95210063e-01f, 5.63349426e-02f, 1.71283424e-01f,
  1.13966959e-02f, 1.00206072e-02f, 1.46659195e-01f, -3.93155932e-01f, -4.53827858e-01f, 3.09100896e-02f, -1.41172126e-01f, -1.75551355e-01f, 2.97789928e-02f, 2.37861186e-01f,
  2.57416636e-01f, 5.84512837e-02f, 6.41544089e-02f, 2.50287414e-01f, -4.38391827e-02f, 3.24064463e-01f, -1.72787264e-01f, -4.69317809e-02f, 1.00515053e-01f, -2.79997904e-02f,
  8.92777517e-02f, -7.31999502e-02f, 3.83427054e-01f, 8.58307034e-02f, -1.38577208e-01f, 1.05769150e-01f, 1.86661370e-02f, 1.10717930e-01f, 1.16870701e-01f, 1.73816141e-02f,
  -2.38398276e-02f, 5.04033975e-02f, 1.80481568e-01f, -4.38489206e-02f, -1.70986094e-02f, 3.02243382e-01f, 2.80786127e-01f, -5.02742305e-02f, -9.28207561e-02f, 1.26205578e-01f,
  -3.33931804e-01f, -2.86224723e-01f, 4.11767095e-01f, -1.63027868e-01f, -3.89892198e-02f, 3.41261953e-01f, 5.20549715e-02f, -8.37750435e-02f, -1.92605168e-01f, -1.03178613e-01f,
  2.81653732e-01f, 6.65261224e-02f, 7.22274408e-02f, -1.31940886e-01f, 8.77117291e-02f, 1.19921556e-02f, -2.14209542e-01f, -1.47632688e-01f, 5.13583701e-03f, 1.88694805e-01f,
  2.19868794e-01f, 1.36168525e-01f, 2.07044840e-01f, 1.28308117e-01f, 1.52243981e-02f, 2.48918697e-01f, 2.45717034e-01f, -2.48082802e-01f, -4.31173474e-01f, -1.53613314e-01f,
  2.38601759e-01f, 3.27902287e-01f, 2.54398674e-01f, 2.22375184e-01f, 1.13172852e-01f, -3.09484363e-01f, 1.95722118e-01f, 2.28154600e-01f, -3.40609014e-01f, 1.48898572e-01f,
  3.03465962e-01f, -2.02142432e-01f, -1.78102732e-01f, -1.68994933e-01f, -6.80081844e-02f, -2.28495941e-01f, 2.84084767e-01f, -4.42408435e-02f, -1.24530541e-02f, -5.62262498e-02f,
  1.63270399e-01f, 1.44831032e-01f, 1.40783757e-01f, 2.69043863e-01f, 3.06501925e-01f, 2.35728085e-01f, 3.29651862e-01f, 9.48131531e-02f, 1.41809627e-01f, 1.09572850e-01f,
  1.77541539e-01f, 2.34417006e-01f, 4.26536053e-01f, -2.14084387e-01f, 2.22442403e-01f, -1.30914077e-01f, 1.12761937e-01f, 3.03065300e-01f, 5.96958734e-02f, 3.08147490e-01f,
  -4.66373824e-02f, 4.66153137e-02f, 3.55866432e-01f, 2.64852107e-01f, 1.28303126e-01f, -1.50238395e-01f, 1.88205823e-01f, 1.64863825e-01f, -3.67623717e-01f, -1.84161976e-01f,
  -2.93028742e-01f, 2.92440429e-02f, 1.45110384e-01f, -1.91540912e-01f, 3.90634149e-01f, -1.25696778e-01f, 3.17702234e-01f, 2.05301404e-01f, -9.21740532e-02f, 2.11404189e-01f,
  -1.37848124e-01f, -6.41913414e-02f, 9.23036337e-02f, 1.97219014e-01f, 3.33719611e-01f, 1.58897817e-01f, 2.96766926e-02f, -7.83475786e-02f, 1.39713153e-01f, -2.37572402e-01f,
  3.87436673e-02f, 6.41146973e-02f, -3.22250068e-01f, 1.94369078e-01f, 2.28532791e-01f, -2.77502686e-01f, 2.29646161e-01f, 4.70570400e-02f, 1.73437700e-01f, -2.44684532e-01f,
  -2.26525232e-01f, -3.32658887e-01f, 3.42146546e-01f, 4.48312253e-01f, 1.38544664e-01f, 1.83839932e-01f, 1.42089948e-01f, 2.24827617e-01f, 2.75160611e-01f, 3.23312953e-02f,
  4.68972772e-02f, 2.86151528e-01f, 1.40335724e-01f, 8.91679004e-02f, 1.56122237e-01f, 2.58109957e-01f, -1.62512258e-01f, 3.19762647e-01f, 9.60882157e-02f, -5.09950034e-02f,
  -4.36616361e-01f, -1.10314898e-01f, -2.10778758e-01f, -2.46621236e-01f, -1.40249357e-01f, 3.80001277e-01f, -1.98631719e-01f, 2.15152368e-01f, -2.19340026e-01f, 7.93875102e-03f,
  -2.03348137e-02f, 4.10653651e-03f, -9.48479921e-02f, -2.66486973e-01f, 2.34200746e-01f, 1.53595448e-01f, 4.55133282e-02f, -7.68579394e-02f, -9.30225030e-02f, -3.29788119e-01f,
  2.07067236e-01f, 8.98496136e-02f, 1.38069749e-01f, 7.14728609e-02f, -4.10779100e-03f, 3.10950994e-01f, -5.15312888e-02f, 4.07761484e-01f, -2.86268950e-01f, -7.46461228e-02f,
  -2.81446278e-01f, -5.01228236e-02f, -1.81329250e-01f, 2.16227219e-01f, -3.78122665e-02f, -6.14777319e-02f, 3.91975373e-01f, 2.75158614e-01f, -3.76761615e-01f, 3.10955465e-01f,
  2.96987385e-01f, 2.57815510e-01f, 1.25903159e-01f, 2.20710859e-01f, 2.17440516e-01f, 3.32758069e-01f, -8.41825679e-02f, 4.29127872e-01f, 1.25662804e-01f, 8.76510050e-03f,
  -6.02562316e-02f, -9.70671773e-02f, 2.37954944e-01f, 2.72416383e-01f, 1.97676614e-01f, 1.65772259e-01f, 7.80259222e-02f, 2.00445563e-01f, 6.27073348e-02f, -2.50451751e-02f,
  -7.06562251e-02f, 3.94289307e-02f, -1.93392530e-01f, -3.70383739e-01f, 2.01464042e-01f, -1.34155944e-01f, -1.50517980e-02f, -2.74990469e-01f, -1.63144127e-01f, -1.73791528e-01f,
  -1.41048983e-01f, -3.99403632e-01f, 4.38113749e-01f, -1.60237163e-01f, 5.45193069e-02f, 1.36615947e-01f, 4.27341372e-01f, 2.26258025e-01f, 1.00283064e-01f, -7.59866312e-02f,
  1.61908433e-01f, 1.76572204e-01f, -8.02459717e-02f, 2.74094522e-01f, 4.83376086e-02f, 2.91780412e-01f, -1.44935057e-01f, -3.34509254e-01f, 2.64550000e-01f, -3.15396860e-03f,
  1.22173779e-01f, -1.35843858e-01f, -1.07412450e-02f, 1.66207045e-01f, 3.48329395e-01f, 2.40271062e-01f, 1.13337122e-01f, 2.70385325e-01f, 2.77121067e-01f, 3.68098110e-01f,
  -1.70354377e-02f, 6.67284802e-02f, 3.29389377e-03f, 8.01406708e-03f, -1.55306220e-01f, -2.66508669e-01f, -4.48254645e-02f, 1.66321084e-01f, 4.21852201e-01f, 8.14698115e-02f,
  2.44949475e-01f, -1.88422203e-01f, 2.12306008e-01f, -9.01366118e-03f, -4.12656702e-02f, 2.56531864e-01f, -1.05950087e-01f, -1.20687298e-02f, 4.66793999e-02f, 1.50780767e-01f,
  -4.92883213e-02f, 6.81071356e-02f, 2.04896852e-01f, -2.07413007e-02f, -1.26026466e-01f, -5.19164801e-02f, 2.85286427e-01f, 1.56884834e-01f, -9.65632573e-02f, -6.89005107e-02f,
  1.58367619e-01f, -5.78633696e-02f, 3.87884490e-02f, -3.24671976e-02f, 1.80353284e-01f, 2.16284752e-01f, -2.75340766e-01f, 2.11398765e-01f, 1.68370426e-01f, -1.61188349e-01f,
  2.14698017e-01f, 3.15881222e-01f, -1.28048554e-01f, -1.63261667e-01f, 3.79117429e-01f, 2.27858081e-01f, -3.98983359e-01f, 1.34949669e-01f, 1.23763755e-01f, -3.61570269e-02f,
  4.19908881e-01f, -2.23144025e-01f, -3.99835072e-02f, 3.47724289e-01f, 2.82572240e-01f, -1.29081741e-01f, 7.32249767e-02f, -1.36100844e-01f, 1.78200677e-01f, -2.64206439e-01f,
  2.28731260e-01f, 4.02016863e-02f, 8.24767444e-03f, -1.24781378e-01f, 3.26035380e-01f, -2.40154028e-01f, -2.14158714e-01f, 2.19888896e-01f, 2.63521701e-01f, 2.14169428e-01f,
  -1.60089895e-01f, 1.66934058e-01f, 7.13303313e-02f, 8.35388303e-02f, -2.41018429e-01f, 1.28696367e-01f, 1.21300042e-01f, -5.07748760e-02f, -2.38493141e-02f, 1.62557900e-01f,
  1.96176603e-01f, -1.00839604e-02f, 1.48579925e-01f, 2.45472074e-01f, 1.24290166e-02f, 1.73193201e-01f, 1.81216344e-01f, -6.63045049e-02f, -1.90038292e-03f, -7.78171942e-02f,
  -2.66766638e-01f, 5.47007024e-02f, -1.57938302e-02f, 1.30597308e-01f, -3.05660605e-01f, 9.00664702e-02f, 1.41777918e-01f, -2.75581628e-01f, -1.43806800e-01f, -1.93272576e-01f,
  1.76086813e-01f, 2.03124464e-01f, 2.09395334e-01f, 8.48044455e-02f, -1.44894406e-01f, 8.72329623e-02f, 8.24250206e-02f, 4.11853909e-01f, -1.75277248e-01f, 2.84411579e-01f,
  1.99577078e-01f, 5.51783554e-02f, -1.97808281e-01f, -1.50239453e-01f, 2.99375147e-01f, -6.78700879e-02f, -5.65515980e-02f, 9.38298106e-02f, -1.54117107e-01f, 2.26816759e-01f,
  -2.18551114e-01f, 3.42021555e-01f, 1.82208970e-01f, 3.11593413e-01f, -6.52887905e-03f, -3.30588184e-02f, -1.18300328e-02f, 2.11122930e-01f, -1.47971064e-01f, 1.60029143e-01f,
  1.10460989e-01f, 1.41075477e-01f, 4.85468702e-03f, 7.80222192e-02f, 5.63351847e-02f, -2.25534122e-02f, 1.23087041e-01f, 2.39938438e-01f, 3.33510280e-01f, -2.78282706e-02f,
  1.35383248e-01f, 2.46571004e-01f, 3.23370755e-01f, 1.31147549e-01f, 2.95314759e-01f, 1.45029813e-01f, 2.03854069e-01f, 4.91880849e-02f, 2.27441862e-01f, 8.30551609e-02f,
  3.24371666e-01f, 7.19671622e-02f, 4.90251631e-02f, 3.47345263e-01f, 6.18279874e-02f, -2.52593476e-02f, 1.32625490e-01f, 1.44633681e-01f, -2.85703003e-01f, -1.05281137e-01f,
  -1.25581816e-01f, 3.66114438e-01f, -1.33625358e-01f, 3.10277641e-01f, -5.51653579e-02f, 1.80220008e-01f, 6.76604435e-02f, 4.29146253e-02f, -2.39832588e-02f, -2.85722554e-01f,
  -6.64630756e-02f, 1.36377230e-01f, -4.11237963e-02f, -1.98274881e-01f, 3.74017090e-01f, -2.57528365e-01f, 3.43639195e-01f, 4.09773514e-02f, 1.04677804e-01f, 2.61771590e-01f,
  1.66077837e-01f, 2.98081428e-01f, -2.81528264e-01f, 4.64035660e-01f, 1.02359228e-01f, -3.65563571e-01f, -3.90667953e-02f, -1.90953612e-01f, 2.90653184e-02f, 8.29575583e-02f,
  -4.14837636e-02f, 1.74628720e-02f, 4.92151350e-01f, 2.98968166e-01f, 1.86526716e-01f, -2.40712538e-01f, -2.20849197e-02f, -1.81458101e-01f, -3.04875404e-01f, 1.09575115e-01f,
  -6.61460981e-02f, -5.27302502e-03f, -9.67131257e-02f, 7.49493912e-02f, 1.70940399e-01f, 8.36611316e-02f, -9.91073623e-02f, 1.08161367e-01f, 9.14688110e-02f, 5.21224514e-02f,
  2.44995691e-02f, 2.90690720e-01f, 2.12745473e-01f, 1.19650409e-01f, 8.61289129e-02f, 4.51055318e-02f, -8.75629485e-02f, 1.87164381e-01f, 2.09573835e-01f, -1.75154313e-01f,
  -2.09540993e-01f, 2.83523828e-01f, -3.29591423e-01f, -8.89079273e-02f, 1.47718191e-02f, 3.91556442e-01f, -1.46148995e-01f, -1.66195974e-01f, 2.18544230e-02f, 2.91602701e-01f,
  -1.72076344e-01f, 3.07818204e-01f, -1.36919841e-01f, -1.15358748e-01f, 1.14809051e-01f, -1.74032420e-01f, -2.31478419e-02f, 1.83234155e-01f, 1.62796855e-01f, -1.97849602e-01f,
  1.89195424e-02f, 3.69029671e-01f, -6.79806024e-02f, -2.27031112e-01f, 3.96520883e-01f, 1.70350358e-01f, -2.23640084e-01f, 3.56129825e-01f, -1.92166850e-01f, -6.71134591e-02f,
  7.07155317e-02f, 2.65484840e-01f, -1.71066046e-01f, 1.24700800e-01f, 1.02279112e-01f, 2.63749093e-01f, 1.15879089e-01f, -3.45579609e-02f, -3.57289106e-01f, -6.91590533e-02f,
  7.06807971e-02f, -2.13204652e-01f, -1.30373180e-01f, -1.56145422e-02f, 3.71405631e-01f, 1.09647997e-01f, -2.84173459e-01f, 1.52917206e-01f, 6.34902194e-02f, 9.92072672e-02f,
  1.38662681e-01f, -1.05533585e-01f, 2.03336149e-01f, 1.56436175e-01f, 3.39574695e-01f, 1.24516927e-01f, 1.26379669e-01f, 7.65664354e-02f, -5.13776019e-02f, 2.59125113e-01f,
  6.22367524e-02f, 1.87091067e-01f, -2.97270536e-01f, -3.72237772e-01f, -4.15380895e-02f, -2.63343185e-01f, 8.75557885e-02f, -1.38460591e-01f, 2.53708754e-02f, 1.14826351e-01f,
  -3.51060897e-01f, -1.25141054e-01f, 3.89703840e-01f, -7.77943507e-02f, -1.87451422e-01f, 8.19559544e-02f, 3.32456864e-02f, -1.67724892e-01f, 2.44499505e-01f, -9.62601230e-02f,
  1.33837108e-02f, 1.74317896e-01f, -4.81235934e-03f, -2.06178471e-01f, -1.25463441e-01f, 1.68221816e-01f, -2.37745449e-01f, 1.06070720e-01f, 9.00598019e-02f, -4.71058525e-02f,
  -1.44005358e-01f, -2.37703159e-01f, -9.47809145e-02f, -9.34178010e-02f, 9.80671793e-02f, 2.36208275e-01f, 1.35134488e-01f, 1.36591032e-01f, 5.64390905e-02f, 1.94572568e-01f,
  4.85617574e-03f, 3.23418230e-01f, -2.66648471e-01f, 5.64181507e-02f, 3.89321707e-02f, 1.74553528e-01f, 2.33243063e-01f, 4.64750603e-02f, 2.99237996e-01f, 1.73629180e-01f,
  1.35754734e-01f, -6.32767975e-02f, 1.80005938e-01f, 5.42632528e-02f, 2.75320321e-01f, 2.68380493e-01f, 2.53331345e-02f, 1.76136449e-01f, 2.38719448e-01f, 2.18677744e-01f,
  9.74061936e-02f, 7.03519024e-03f, 1.60759419e-01f, 2.51853049e-01f, 1.07111380e-01f, 1.46734685e-01f, 2.83418447e-01f, -1.46993443e-01f, -1.60507306e-01f, -2.50015743e-02f,
  3.34283471e-01f, 1.00843184e-01f, -1.17340803e-01f, 1.32211432e-01f, -1.98206320e-01f, 2.33545288e-01f, -2.48156577e-01f, -3.13279808e-01f, 1.42067848e-02f, 4.00654487e-02f,
  4.56839167e-02f, -1.45918531e-02f, 1.10353015e-01f, -1.59277786e-02f, 4.11126018e-02f, -9.66358706e-02f, 7.14834407e-02f, -3.74678910e-01f, 2.58436710e-01f, -2.62826700e-02f,
  2.30623912e-02f, 2.00136468e-01f, -1.17780142e-01f, -3.36270630e-02f, -8.97015408e-02f, 1.95646007e-02f, -1.75826982e-01f, 9.59978700e-02f, -3.66118439e-02f, -1.53822586e-01f,
  1.86712533e-01f, -2.91814897e-02f, -1.02001466e-01f, 8.71242508e-02f, 2.87734032e-01f, 1.84185117e-01f, -2.26768091e-01f, 1.91281468e-01f, 4.93595183e-01f, 4.03380930e-01f,
  2.97908127e-01f, -9.99553204e-02f, -1.32867247e-02f, 1.28417805e-01f, -2.94757158e-01f, 2.60340989e-01f, 2.33328581e-01f, 1.68454766e-01f, 2.27240637e-01f, 8.38531852e-02f,
  8.06234106e-02f, 1.22806951e-01f, 2.71092564e-01f, 1.89702764e-01f, 9.37443152e-02f, 3.56937833e-02f, 2.16553465e-01f, 2.07049195e-02f, 3.79207909e-01f, -2.14952186e-01f,
  -4.29253727e-02f, -2.89844126e-01f, -4.89666965e-03f, 2.35211267e-03f, 3.17618370e-01f, -4.63222191e-02f, -1.36803225e-01f, -3.70871931e-01f, -1.98909760e-01f, -6.32214593e-03f,
  9.19925943e-02f, -4.12970096e-01f, 2.07200330e-02f, -2.73308512e-02f, 4.04260635e-01f, 4.28342402e-01f, -6.29817694e-02f, -4.62147370e-02f, 1.66916445e-01f, 3.12140793e-01f,
  -1.11991726e-02f, 1.96430996e-01f, 2.67363459e-01f, 1.89125955e-01f, 1.83090225e-01f, -6.47849441e-02f, -1.50024563e-01f, 1.98470518e-01f, -8.96432176e-02f, -3.64745438e-01f,
  -3.21455181e-01f, 4.24029082e-01f, 2.61586219e-01f, -1.14281446e-01f, 3.17824155e-01f, -1.36194333e-01f, -8.49470720e-02f, 1.67391732e-01f, 2.21375063e-01f, 2.80581087e-01f,
  -9.23872963e-02f, 9.06181708e-02f, 1.03102654e-01f, 2.52539426e-01f, 1.41096637e-01f, 2.37483397e-01f, 8.16447660e-02f, -9.31852777e-03f, 2.76689619e-01f, -3.41457804e-03f,
  2.31624216e-01f, 3.26987021e-02f, 2.23589510e-01f, 3.23181242e-01f, 1.00884005e-01f, 1.37251988e-01f, 7.71821514e-02f, 6.54479340e-02f, 2.06026286e-01f, 5.39559722e-02f,
  2.15833157e-01f, 9.71662104e-02f, 1.87600076e-01f, -2.46272087e-02f, 2.17525616e-01f, 2.49312356e-01f, 3.98993231e-02f, -7.70070627e-02f, 1.23618193e-01f, 2.98324265e-02f,
  1.05221599e-01f, -2.63762891e-01f, 1.01726912e-02f, 2.38672346e-01f, 2.20657438e-01f, 9.57139581e-02f, -2.39194129e-02f, -1.82100102e-01f, 4.15744960e-01f, 2.31132090e-01f,
  9.79659483e-02f, -4.15875763e-02f, 6.92345873e-02f, 5.89703508e-02f, 2.12482646e-01f, 1.64660111e-01f, 1.14125319e-01f, -2.51023043e-02f, -2.72603899e-01f, 3.96807522e-01f,
  -1.30311958e-02f, 2.15654537e-01f, 5.71644455e-02f, -2.63163060e-01f, 2.26577893e-01f, -1.71682369e-02f, -9.85886604e-02f, -2.65616626e-01f, 5.47331534e-02f, 1.39558330e-01f,
  -9.76760834e-02f, -2.59711772e-01f, 3.41691136e-01f, -1.91724926e-01f, 3.95928085e-01f, 7.32113123e-02f, 1.59223913e-03f, 1.72305897e-01f, 1.92657113e-01f, 1.96958974e-01f,
  -3.35408658e-01f, 4.44688834e-02f, 6.96886033e-02f, -5.25088273e-02f, 4.56521288e-02f, 1.79099441e-01f, 3.96342516e-01f, 9.40034166e-02f, 2.97054768e-01f, 1.02505021e-01f,
  4.34145659e-01f, 8.83790031e-02f, 1.41248569e-01f, 3.54650229e-01f, 1.54395610e-01f, 2.84691662e-01f, 2.77134180e-01f, 9.77857262e-02f, -1.93318337e-01f, -6.03229813e-02f,
  3.25593978e-01f, 2.22867489e-01f, -1.87127218e-01f, 3.16821374e-02f, -2.98404902e-01f, 1.73235565e-01f, -6.67465478e-02f, -8.43594968e-02f, 1.52412221e-01f, 4.14142534e-02f,
  2.26093650e-01f, 1.99613869e-01f, -1.45421907e-01f, -4.70944583e-01f, -4.08250056e-02f, 2.69685298e-01f, 1.93224296e-01f, -2.19957918e-01f, 5.49996078e-01f, -2.57657934e-02f,
  1.31600723e-01f, -8.97003934e-02f, -3.40958893e-01f, 2.90930182e-01f, -3.57830636e-02f, -1.81221858e-01f, 1.64928839e-01f, 2.47997448e-01f, 4.11432087e-01f, -3.81246537e-01f,
  6.38712198e-02f, -4.94611859e-02f, 2.35353172e-01f, 2.42294759e-01f, 4.20538813e-01f, 3.56501564e-02f, -2.50097930e-01f, 3.80288154e-01f, 3.90077889e-01f, -3.16781789e-01f,
  -3.82750541e-01f, -5.63659258e-02f, -6.70042858e-02f, -6.39907494e-02f, -4.60614376e-02f, 4.29029316e-02f, 2.88830459e-01f, -3.05024516e-02f, 8.60729069e-02f, 4.23684567e-02f,
  -1.98110752e-03f, 8.48989114e-02f, 1.66410625e-01f, 1.43468902e-01f, 4.10059132e-02f, 1.01439446e-01f, 1.48596112e-02f, -2.90735941e-02f, -1.52209150e-02f, -6.13532215e-02f,
  -3.12195837e-01f, 8.92881975e-02f, 2.06062600e-01f, 2.80400157e-01f, -2.24983186e-01f, 2.53934413e-01f, -9.97932926e-02f, -1.65335432e-01f, -7.89661482e-02f, 1.27024233e-01f,
  2.97556251e-01f, -1.18344091e-01f, -2.22784355e-02f, 4.47587848e-01f, 2.80950636e-01f, 1.20349780e-01f, 3.90049309e-01f, 2.11327717e-01f, 9.43619013e-02f, 9.83707011e-02f,
  2.38847867e-01f, 1.28226399e-01f, -1.54004753e-01f, 3.05745780e-01f, -5.84061556e-02f, 7.46467486e-02f, 1.81575671e-01f, -2.83731729e-01f, 1.82788730e-01f, 4.21064258e-01f,
  3.07511806e-01f, 5.13300717e-01f, 6.88081011e-02f, -7.45404214e-02f, 7.74925277e-02f, 1.90166324e-01f, -1.27543554e-01f, 2.19852298e-01f, 2.00522661e-01f, -4.20709960e-02f,
  2.29671165e-01f, -1.69070914e-01f, 1.47412149e-02f, 1.68052971e-01f, -2.29792967e-01f, -2.34059840e-01f, -3.32078338e-01f, 1.60586894e-01f, 2.69527942e-01f, 1.87956586e-01f,
  -1.90658867e-01f, -1.05629198e-03f, 1.83997929e-01f, 1.06576376e-01f, 8.75180513e-02f, 9.02619585e-02f, 1.03097774e-01f, 1.49956852e-01f, 7.78587312e-02f, 1.14815965e-01f,
  -5.46837300e-02f, 2.64606088e-01f, 1.80819333e-01f, 1.08556658e-01f, -5.64637184e-02f, 2.78726339e-01f, 7.34261796e-02f, 1.95065066e-01f, 1.11691497e-01f, -1.58612896e-02f,
  1.64069623e-01f, -4.75037694e-02f, -1.73524931e-01f, 2.92797387e-01f, 1.34128049e-01f, -4.64269742e-02f, -6.97566420e-02f, 5.15733846e-02f, 1.00072496e-01f, 1.69516921e-01f,
  -1.39535442e-01f, -3.12086493e-01f, -1.16070330e-01f, -2.25963131e-01f, 3.17076355e-01f, -2.96663731e-01f, 2.63179421e-01f, 5.05281463e-02f, 2.63783813e-01f, -3.63494344e-02f,
  -2.29906350e-01f, 1.39394775e-01f, -5.49761318e-02f, 2.77491529e-02f, 2.54236281e-01f, 7.07071424e-02f, 3.72504473e-01f, -2.07304016e-01f, 8.63381624e-02f, -1.29097596e-01f,
  2.07741305e-01f, 1.40883118e-01f, 2.48082682e-01f, 1.22324735e-01f, 1.12955175e-01f, 1.74234748e-01f, 1.01680532e-01f, -1.10265374e-01f, 3.10496509e-01f, -1.63012266e-03f,
  2.01984923e-02f, 9.13566872e-02f, 5.18349139e-03f, -5.67852817e-02f, -1.94183066e-01f, 3.49440068e-01f, 1.66389674e-01f, -2.46054847e-02f, 2.46801883e-01f, 2.42345229e-01f,
  6.61338866e-02f, 9.08610895e-02f, 2.74761580e-02f, 1.52787462e-01f, 2.28175044e-01f, 6.69783726e-02f, 7.46069402e-02f, 1.58647045e-01f, 1.81737155e-01f, -3.39716136e-01f,
  3.80826950e-01f, 2.53262460e-01f, -3.10513645e-01f, 4.68415134e-02f, 1.32970169e-01f, -1.26565695e-01f, 2.57011205e-01f, -1.10664181e-01f, 3.17643106e-01f, 1.66404262e-01f,
  -1.73131764e-01f, 4.58230525e-02f, 2.37106606e-01f, 5.11352494e-02f, 3.22235286e-01f, 4.44102287e-01f, 1.03654929e-01f, 3.66860449e-01f, 2.17128828e-01f, -6.10983893e-02f,
  -1.55110091e-01f, 3.48249704e-01f, 2.88449302e-02f, -7.43889064e-02f, 4.10802633e-01f, 8.97702873e-02f, -1.72585741e-01f, 3.62802684e-01f, 3.56890351e-01f, 3.00623715e-01f,
  -1.02391928e-01f, 2.00885430e-01f, 9.83933881e-02f, -2.53618658e-01f, 1.70187905e-01f, 1.00236192e-01f, -1.95262030e-01f, -3.36272031e-01f, 3.14356089e-01f, -8.32470879e-02f,
  -1.31451726e-01f, 1.82981551e-01f, 2.17604071e-01f, 3.37990850e-01f, 9.07632038e-02f, 2.33061478e-01f, -9.73141342e-02f, 1.00249372e-01f, 6.63606375e-02f, 2.38516986e-01f,
  1.01016402e-01f, 6.97225928e-02f, 4.90137823e-02f, 1.55580472e-02f, -7.50916749e-02f, 1.02993697e-01f, 1.71464607e-01f, 2.47939110e-01f, -3.97456950e-03f, 1.31336585e-01f,
  3.59519385e-02f, -8.88076052e-02f, 4.67364401e-01f, -1.67450309e-01f, 8.18147790e-03f, -6.44297823e-02f, 3.02153826e-01f, 5.95489033e-02f, 3.51909012e-01f, -8.03606957e-02f,
  -3.37308757e-02f, -2.23171368e-01f, 5.76271676e-02f, -2.96901673e-01f, 2.82614887e-01f, -4.71757352e-01f, 2.30313882e-01f, 3.09750587e-02f, 2.22340956e-01f, 1.79864779e-01f,
  -1.12789035e-01f, 1.36252776e-01f, 2.91327119e-01f, 1.77571490e-01f, 1.51494816e-01f, 4.61465806e-01f, 8.84169415e-02f, 1.52286306e-01f, 3.07578027e-01f, -1.04070224e-01f,
  -2.60335263e-02f, -2.46194705e-01f, 1.56359375e-01f, -3.87846529e-01f, 1.34163871e-01f, 4.42076594e-01f, 4.40916985e-01f, -6.59422949e-02f, 4.09968287e-01f, -1.97068542e-01f,
  1.92835093e-01f, 2.68698215e-01f, -4.02486414e-01f, 3.43357891e-01f, 1.04810661e-02f, 6.68817833e-02f, -3.47711965e-02f, 2.39732176e-01f, 1.38405710e-01f, 1.56179219e-02f,
  -3.76839028e-03f, -8.96794945e-02f, 3.49560529e-01f, 2.29023695e-02f, 1.97197244e-01f, 1.79192826e-01f, 1.75189316e-01f, 1.67016461e-01f, 1.09482639e-01f, 8.50175042e-03f,
  -2.04139557e-02f, 1.42247200e-01f, 1.39009684e-01f, 1.87213883e-01f, -2.17432640e-02f, 2.55696505e-01f, -1.93992481e-01f, 3.30271006e-01f, 1.19534098e-01f, 7.07082897e-02f,
  -1.54970109e-01f, 2.08251491e-01f, -2.31507510e-01f, 8.70732591e-02f, -1.01686724e-01f, 4.67081726e-01f, 7.83436820e-02f, 2.18213812e-01f, -1.31278515e-01f, 1.73368454e-01f,
  -9.80679095e-02f, 3.12960297e-01f, -2.55834103e-01f, -1.99138910e-01f, 1.79428518e-01f, 1.31362706e-01f, 1.19211175e-01f, -2.77405173e-01f, 2.53157258e-01f, -1.32373825e-01f,
  1.08131766e-01f, 1.40558034e-01f, -1.29604742e-01f, 2.93035626e-01f, 9.49281752e-02f, -1.07331052e-01f, 1.57756358e-01f, 5.08911133e-01f, 2.80852795e-01f, -3.63494575e-01f,
  2.02105828e-02f, 8.56124908e-02f, -3.43284793e-02f, -3.24321650e-02f, 1.45222977e-01f, 1.39481694e-01f, -4.47947308e-02f, 2.66043425e-01f, 2.56247580e-01f, 2.97023445e-01f,
  1.43653005e-01f, 2.20431790e-01f, 2.16784269e-01f, -2.58702427e-01f, 1.62854698e-02f, 1.40831053e-01f, -2.38064423e-01f, 2.46203884e-01f, -3.46241705e-02f, -6.55242503e-02f,
  -3.00850533e-02f, 1.88540131e-01f, 9.58748162e-02f, 3.24848779e-02f, 6.95131794e-02f, 2.29058862e-01f, 9.13153514e-02f, -5.86098619e-03f, 1.29256723e-02f, -1.36108115e-01f,
  1.16041675e-01f, -4.43080552e-02f, -9.71276015e-02f, 3.01285442e-02f, 2.16351792e-01f, 1.77924857e-01f, -1.15849599e-02f, -1.27787692e-02f, -1.36824036e-02f, -2.86933154e-01f,
  4.69978824e-02f, -2.98734963e-01f, 2.04683691e-01f, -1.29956603e-01f, 2.92404205e-01f, 1.20145604e-02f, 4.80129391e-01f, 4.49543744e-01f, -7.42932037e-02f, 7.90948421e-02f,
  1.71225592e-01f, 2.86142319e-01f, 1.30527303e-01f, 3.32210183e-01f, -1.02850236e-01f, 8.70578289e-02f, 1.89900815e-01f, -3.02558780e-01f, -1.33278000e-03f, 2.04104304e-01f,
  1.03787646e-01f, -1.32373199e-01f, -7.98185021e-02f, 2.61004031e-01f, 3.20741236e-01f, 1.20529719e-01f, 1.25731185e-01f, -1.18443258e-01f, 1.59809828e-01f, 1.68352649e-01f,
  1.70669720e-01f, 3.86411813e-03f, 3.01424470e-02f, -3.17506120e-02f, -2.78959215e-01f, -1.91298425e-01f, -8.56434852e-02f, 1.03028394e-01f, -9.87241939e-02f, 4.24172245e-02f,
  3.21260542e-01f, -3.00457984e-01f, 8.44144672e-02f, -5.29706897e-03f, 5.05662933e-02f, 5.67776598e-02f, -2.42602900e-02f, 1.79418609e-01f, 2.05278546e-01f, 4.37079892e-02f,
  1.59577042e-01f, 2.05785245e-01f, 2.45531529e-01f, 8.23763460e-02f, 2.20417872e-01f, 9.06615779e-02f, 1.08313605e-01f, -3.46964031e-01f, -8.10855813e-03f, 1.03276365e-01f,
  1.88495114e-01f, 1.47354856e-01f, -8.89079720e-02f, 1.56148508e-01f, 7.16624409e-02f, -2.48780064e-02f, -1.01328127e-01f, -1.91801459e-01f, 3.83221917e-02f, 1.55674905e-01f,
  -5.16541563e-02f, 1.90533683e-01f, -2.10114181e-01f, -2.67179161e-01f, 4.57955583e-04f, 2.18442827e-01f, 1.11842737e-01f, 1.06439672e-01f, 1.12604216e-01f, 1.82625175e-01f,
  1.35019243e-01f, -8.86007696e-02f, 9.89754200e-02f, -1.83232352e-01f, -3.62958796e-02f, 2.07216181e-02f, -1.39445201e-01f, 1.92788944e-01f, 2.41244480e-01f, 5.88221475e-02f,
  3.10024083e-01f, -2.04884738e-01f, -1.36675209e-01f, 3.18322688e-01f, -1.93305612e-02f, 1.88243344e-01f, -2.96360135e-01f, -6.86363578e-02f, 4.00861055e-01f, 1.37452194e-02f,
  1.85584649e-02f, -1.48634136e-01f, 1.58495903e-01f, -5.30087240e-02f, -5.46140037e-02f, 4.08114702e-01f, 1.38066769e-01f, 2.61104077e-01f, 3.21892761e-02f, 9.05164331e-02f,
  8.78600106e-02f, 1.83312833e-01f, 7.87409469e-02f, 6.72551692e-02f, 5.10121956e-02f, 1.91261500e-01f, 1.49300396e-01f, 1.14215858e-01f, 1.18731096e-01f, 2.00604856e-01f,
  -1.02019884e-01f, -4.45670150e-02f, 9.95284319e-02f, -2.20240757e-01f, 2.84092456e-01f, -9.04817954e-02f, -2.12736741e-01f, -2.18939967e-02f, -2.47025475e-01f, -1.17994780e-02f,
  2.36409351e-01f, -2.23353282e-01f, -1.48471698e-01f, -7.34432712e-02f, 2.51919013e-02f, -7.06746951e-02f, 1.51768178e-01f, -2.67326012e-02f, 3.08355391e-01f, 2.68161986e-02f,
  -2.27228962e-02f, -1.53196320e-01f, 2.17237130e-01f, 7.96289295e-02f, -3.71223241e-02f, 7.50093758e-02f, 6.07186109e-02f, 4.66971174e-02f, 1.09683126e-02f, -3.91974807e-01f,
  9.37913507e-02f, 1.16669722e-01f, 2.61604227e-02f, -9.72856730e-02f, 2.02598393e-01f, 6.29063919e-02f, 3.00556958e-01f, 9.10369605e-02f, 2.34188944e-01f, 2.21462041e-01f,
  1.51929557e-01f, -1.62327513e-02f, 2.54046500e-01f, 1.49806216e-01f, 2.91224450e-01f, 2.20065698e-01f, 1.86436161e-01f, 2.34545738e-01f, -1.05887167e-01f, 7.84141570e-02f,
  1.44365102e-01f, 1.42909354e-02f, 2.02731594e-01f, 2.27106631e-01f, 1.13945179e-01f, 1.88722070e-02f, 2.33342215e-01f, 3.01756412e-02f, 1.89549252e-01f, 1.31501138e-01f,
  1.01269046e-02f, 3.19012433e-01f, 2.19844103e-01f, 1.09217139e-02f, -5.44350035e-02f, -1.83574378e-01f, -2.35295951e-01f, 1.76696442e-02f, 1.59773692e-01f, -4.67984155e-02f,
  -1.12965629e-01f, 2.58978695e-01f, -2.51111627e-01f, -6.91283047e-02f, 4.24814746e-02f, -2.19867930e-01f, 2.47675274e-02f, 1.40206099e-01f, -1.59295455e-01f, 1.57663450e-02f,
  1.31136432e-01f, 1.79643463e-02f, -2.79907100e-02f, -1.77031144e-01f, 3.19382787e-01f, 3.93752102e-03f, 7.14844987e-02f, 1.63435504e-01f, -2.11355701e-01f, 1.81155860e-01f,
  4.79980037e-02f, -1.97657421e-01f, -4.10187617e-02f, 1.00870818e-01f, -2.45402291e-01f, -1.19960740e-01f, -8.67765918e-02f, -1.15628205e-01f, 1.32131845e-01f, 1.33761540e-01f,
  7.95567259e-02f, -9.62480307e-02f, -1.30305648e-01f, 4.14614111e-01f, -1.28453583e-01f, 1.02144562e-01f, 2.15805098e-01f, 2.25248158e-01f, 2.21494764e-01f, 5.66369556e-02f,
  1.13339461e-01f, -5.95869236e-02f, 1.27419487e-01f, 3.17288548e-01f, 1.51644528e-01f, 8.31370708e-03f, -7.25698099e-02f, 4.53175567e-02f, 2.92254053e-02f, 3.98563258e-02f,
  -5.96856251e-02f, 4.55870554e-02f, 2.36924533e-02f, 1.45598918e-01f, 2.39591211e-01f, 1.09636568e-01f, 9.89854932e-02f, 2.47140843e-02f, -6.53866231e-02f, -1.87034443e-01f,
  1.30488038e-01f, -1.22607455e-01f, 4.07143056e-01f, 6.83315471e-02f, -6.40951023e-02f, -2.36342680e-02f, 4.87254113e-02f, -6.55051842e-02f, -3.36324088e-02f, -5.68878949e-01f,
  1.18792638e-01f, 2.48975144e-03f, 2.00506270e-01f, 2.85697520e-01f, -3.47640127e-01f, -4.38020885e-01f, 3.98166150e-01f, 2.71428049e-01f, -1.80634007e-01f, 4.97326143e-02f,
  2.99049705e-01f, 2.59464443e-01f, 2.52403796e-01f, -1.72392905e-01f, 6.99088126e-02f, -1.69749260e-01f, 2.20145676e-02f, -2.01739743e-01f, -6.87259901e-03f, 2.74168491e-01f,
  4.43545014e-01f, 1.10677563e-01f, 2.27749288e-01f, -3.32538784e-01f, 4.33193222e-02f, 2.98427105e-01f, -6.32960871e-02f, 1.17835067e-01f, -1.36254787e-01f, -1.80339962e-01f,
  5.58719099e-01f, 1.38368383e-01f, -3.20952316e-03f, 2.70708054e-02f, 1.61705419e-01f, -7.01216534e-02f, -3.13939244e-01f, 3.14227521e-01f, 2.19899133e-01f, 8.00383464e-02f,
  -1.09197022e-02f, 1.70916826e-01f, -6.64740503e-02f, 4.54494394e-02f, -1.40195519e-01f, 1.06850423e-01f, -6.27612323e-02f, 1.90114155e-01f, 9.60269570e-02f, 9.51377228e-02f,
  -2.81488951e-02f, -5.77799836e-03f, 1.14229403e-01f, 1.74857900e-01f, -6.05368540e-02f, -9.51457098e-02f, 2.97739565e-01f, 1.89863574e-02f, -9.61162448e-02f, 5.15598524e-03f,
  2.86203891e-01f, 5.36690950e-02f, -2.95179695e-01f, -1.07734412e-01f, 8.10259879e-02f, -4.51756120e-02f, 1.53697670e-01f, 1.92053601e-01f, -1.89827114e-01f, -2.87458688e-01f,
  2.81977087e-01f, 9.34292674e-02f, -2.63991624e-01f, 2.54491329e-01f, 2.11062759e-01f, 7.11138919e-02f, 2.07487289e-02f, -1.55600846e-01f, -1.13191299e-01f, 1.03951283e-01f,
  2.19658494e-01f, -3.37431610e-01f, 2.46776626e-01f, -2.24935869e-03f, 1.32710069e-01f, -3.08144510e-01f, 2.60814905e-01f, 1.56740263e-01f, 1.32596865e-01f, -2.73922950e-01f,
  2.19606459e-01f, -2.76251405e-01f, -3.50848697e-02f, -1.78444356e-01f, 3.76991719e-01f, 2.21320853e-01f, -1.04578435e-01f, -2.69446755e-03f, 2.12141536e-02f, -1.20131515e-01f,
  -2.25305334e-01f, 2.71535873e-01f, 1.23918153e-01f, 1.33859441e-01f, 1.50284082e-01f, 6.76379213e-03f, 1.04889341e-01f, 1.37438968e-01f, 1.68962643e-01f, 1.83023348e-01f,
  -5.25086150e-02f, 1.75158292e-01f, 6.89888895e-02f, 4.19325987e-03f, 2.65517950e-01f, -1.10968538e-01f, -5.25396429e-02f, -1.28390398e-02f, 5.33791363e-01f, 2.28527188e-03f,
  2.37700671e-01f, 1.12283058e-01f, -1.75967842e-01f, -3.51669520e-01f, 1.28195174e-02f, -2.22133100e-01f, 3.97824705e-01f, -1.52898625e-01f, 3.24294478e-01f, -9.74532217e-02f,
  2.18640655e-01f, 2.25737527e-01f, -3.16089801e-02f, 3.06663692e-01f, 2.19133005e-01f, 1.77494109e-01f, 2.94398606e-01f, 3.37014109e-01f, 1.77420199e-01f, -6.70012534e-02f,
  3.29455853e-01f, 2.97762960e-01f, -2.20564812e-01f, -2.10227445e-01f, 7.96026438e-02f, -2.40323484e-01f, 3.09964925e-01f, 1.14208877e-01f, 4.06496853e-01f, 9.44546983e-02f,
  1.70261681e-01f, -2.72717804e-01f, 1.69021085e-01f, 1.33071452e-01f, -2.47824490e-01f, 1.96284458e-01f, 4.99117345e-01f, 7.82567561e-02f, -3.51534933e-01f, 9.09577012e-02f,
  2.09170759e-01f, -2.05747813e-01f, -9.63087082e-02f, 3.04531772e-02f, 2.77797133e-01f, -3.08525413e-01f, 6.43647984e-02f, 5.52279688e-02f, -7.45056123e-02f, 6.51485324e-02f,
  7.05461130e-02f, 1.18456604e-02f, 1.53834879e-01f, 3.79843228e-02f, 4.55815112e-03f, 2.29588985e-01f, 6.19788729e-02f, 2.02678025e-01f, -3.44053298e-01f, 2.10068449e-01f,
  -2.46296644e-01f, -1.71540588e-01f, 2.82235211e-03f, -3.90406430e-01f, -2.08148286e-01f, -2.64178552e-02f, 9.30298306e-03f, -2.19889313e-01f, -2.71778703e-01f, -5.52339666e-02f,
  1.90101340e-01f, 3.39431882e-01f, -1.76328614e-01f, -5.73319755e-02f, 1.77974850e-01f, 2.39240080e-01f, 3.56836796e-01f, 2.15437785e-01f, -5.80218770e-02f, 3.36769730e-01f,
  -1.61559850e-01f, 1.27962977e-01f, -1.13136254e-01f, 1.42834336e-01f, 1.66610777e-01f, -6.60632253e-02f, 2.57562786e-01f, 1.41098604e-01f, -9.57553387e-02f, -6.04061559e-02f,
  -2.96078712e-01f, 6.45193607e-02f, 8.24504122e-02f, 2.29862466e-01f, -1.06357619e-01f, 2.13301644e-01f, 2.05464080e-01f, 1.30931735e-01f, 1.32698715e-01f, 1.81042895e-01f,
  -2.52669692e-01f, 3.53611976e-01f, 2.56733727e-02f, 1.91970110e-01f, 2.06182182e-01f, 2.81568974e-01f, 3.55342984e-01f, 4.27640289e-01f, 6.96307793e-02f, -2.99177527e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.31003991e-01f, 2.21040040e-01f, 2.06534013e-01f, 1.82892263e-01f, 2.02767491e-01f, 1.16343662e-01f, 1.84626341e-01f, 2.50008762e-01f, 2.37293124e-01f, -2.86853760e-02f,
  2.42856994e-01f, 1.28677949e-01f, 5.71208708e-02f, 1.79207340e-01f, 1.30858839e-01f, 2.67629057e-01f, 2.00073287e-01f, 1.98958814e-02f, 1.72199383e-01f, 7.32365251e-02f,
  2.48147190e-01f, 7.19592422e-02f, 1.83584914e-01f, 4.26940359e-02f, 1.99290141e-01f, 1.92020208e-01f, 1.23730101e-01f, 9.61947665e-02f, 2.57970244e-02f, 9.17055681e-02f,
  1.05875120e-01f, 9.61510837e-02f, 1.20440438e-01f, 7.06529841e-02f, 5.21644503e-02f, 2.65398294e-01f, 2.71889661e-02f, 1.02974094e-01f, 1.37201905e-01f, 5.58619574e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -6.61818907e-02f, 1.43908292e-01f, -1.39992595e-01f, -1.11950301e-01f, 8.85491446e-02f, -3.10339957e-01f, 2.06397232e-02f, -2.10057899e-01f, -1.63758963e-01f, -2.00662941e-01f,
  -2.63177361e-02f, -3.02533597e-01f, 2.63026595e-01f, 1.49251251e-02f, -9.57559943e-02f, 2.80415148e-01f, -1.18976414e-01f, -7.94151202e-02f, -1.11168571e-01f, -2.25525141e-01f,
  1.93176031e-01f, 2.82010198e-01f, -1.89565971e-01f, -8.26595351e-02f, 4.84107854e-03f, -3.80347818e-01f, -2.60593176e-01f, -3.11073095e-01f, -3.19427520e-01f, 2.69062549e-01f,
  -2.52811946e-02f, 2.56976277e-01f, -2.56701908e-03f, 2.08070785e-01f, -5.66911586e-02f, -2.18925234e-02f, -2.30264187e-01f, -1.88138448e-02f, 3.48456919e-01f, -2.99494982e-01f,
  -3.78754169e-01f, 2.71347225e-01f, -1.03212923e-01f, 2.22641781e-01f, -4.47189152e-01f, 1.76148504e-01f, 3.78043056e-02f, -3.20845515e-01f, 9.96389091e-02f, -4.25573587e-01f,
  -3.33537132e-01f, 8.87562055e-03f, -4.11019981e-01f, -4.32088137e-01f, 1.15820676e-01f, -2.71605730e-01f, 2.93079823e-01f, 2.32111067e-01f, -2.50708051e-02f, -4.54078674e-01f,
  3.58356208e-01f, -2.86690921e-01f, 1.22272968e-01f, 1.58819929e-01f, -6.50043786e-02f, -6.08314872e-02f, -1.97251573e-01f, 1.87748075e-02f, 1.67443722e-01f, -2.10052997e-01f,
  4.83235111e-03f, -1.87152430e-01f, 2.10142478e-01f, 1.70981303e-01f, 6.24724068e-02f, 1.40814200e-01f, -2.64886141e-01f, 8.89520720e-03f, 7.84809738e-02f, 3.53746951e-01f,
  -1.52879655e-01f, -2.89620996e-01f, -5.62543012e-02f, -2.38018721e-01f, -1.33432239e-01f, 2.38511279e-01f, -2.62063593e-01f, 3.27775002e-01f, 3.22880417e-01f, -5.13845146e-01f,
  -2.77876586e-01f, 1.38693243e-01f, 5.27653545e-02f, -7.49475211e-02f, 2.49642849e-01f, 1.01925164e-01f, -4.30247128e-01f, 1.76915497e-01f, -2.53146797e-01f, -1.69861659e-01f,
  2.97508508e-01f, 2.46599048e-01f, -4.99630310e-02f, -5.14041185e-01f, 1.30193055e-01f, 1.49164259e-01f, -3.60580385e-01f, -1.57811996e-02f, -1.19402729e-01f, 3.28263134e-01f,
  3.55112821e-01f, -1.49397075e-01f, -4.11267638e-01f, -3.34854633e-01f, 2.25923471e-02f, 1.09948188e-01f, -4.90004616e-03f, -3.56758565e-01f, -4.13385123e-01f, 1.68067321e-01f,
  -2.35506073e-01f, -1.58404276e-01f, 3.50850672e-02f, 1.26925677e-01f, -4.08387512e-01f, -1.86989680e-01f, -5.92358589e-01f, 2.91296810e-01f, -7.25021809e-02f, -1.43950090e-01f,
  3.40670682e-02f, -4.24712710e-02f, 1.17926542e-02f, 1.63058519e-01f, 2.42612939e-02f, 1.73099397e-04f, 1.27242342e-01f, -2.03299478e-01f, 5.67243025e-02f, -8.59652162e-02f,
  -2.08142757e-01f, -2.29243085e-01f, -3.83932456e-05f, 8.44501704e-03f, 1.71266213e-01f, -1.85330778e-01f, 1.01637132e-01f, -1.67151615e-01f, -1.15240134e-01f, -2.43558154e-01f,
  -2.54200727e-01f, -2.95539409e-01f, -1.26298726e-01f, -3.66894871e-01f, -4.09778714e-01f, -2.73948818e-01f, 3.24869305e-01f, 8.74554068e-02f, 3.20032299e-01f, -5.22361875e-01f,
  2.36614481e-01f, 1.90771982e-01f, -2.39093155e-01f, 7.92306736e-02f, 2.03262433e-01f, -3.05028260e-01f, -3.61059695e-01f, -4.01692122e-01f, 1.69361949e-01f, -4.99787927e-01f,
  1.95513263e-01f, 3.00971240e-01f, 1.44959763e-01f, 1.50593165e-02f, -3.73281866e-01f, -1.28754362e-01f, -4.40216184e-01f, -1.99715391e-01f, -1.17502332e-01f, 3.40152740e-01f,
  -3.60611409e-01f, 2.62423843e-01f, -2.74714023e-01f, 6.29041716e-02f, -2.56757513e-02f, -3.62117976e-01f, -4.19235528e-01f, -3.74410063e-01f, -1.84163451e-02f, -2.20314562e-01f,
  -1.65936798e-01f, 1.09600723e-01f, 1.23701453e-01f, -1.18624151e-01f, -7.07118437e-02f, -5.38976938e-02f, -5.74765541e-02f, -8.71048048e-02f, 1.34080753e-01f, -4.03868221e-03f,
  -6.35548905e-02f, 4.60877419e-02f, -2.56929308e-01f, -7.59844407e-02f, -3.32709312e-01f, -5.70255257e-02f, -2.27751151e-01f, -3.33086014e-01f, 1.73699446e-02f, 7.80407190e-02f,
  -2.66664863e-01f, 2.68276036e-01f, 3.34132910e-02f, 2.01676175e-01f, 4.89949547e-02f, -7.43987933e-02f, 1.51810080e-01f, -1.32743731e-01f, 1.21038884e-01f, 1.76665246e-01f,
  -2.85589039e-01f, -3.60363960e-01f, -8.91462117e-02f, -8.64854455e-02f, -4.03807729e-01f, 3.74556094e-01f, 2.05720086e-02f, -3.50471884e-01f, 1.54066101e-01f, -4.83518839e-02f,
  -2.26075470e-01f, -3.23234081e-01f, -4.77826387e-01f, 1.41252503e-01f, 2.48904407e-01f, -2.07240030e-01f, -4.68599558e-01f, -3.25925916e-01f, -2.37259313e-01f, -1.99038833e-01f,
  1.82805836e-01f, 1.65053427e-01f, -4.43251997e-01f, 1.66022003e-01f, -2.06581041e-01f, 2.72499681e-01f, 1.49089172e-01f, -2.56893456e-01f, 2.33740523e-01f, -4.61573005e-02f,
  -1.16611153e-01f, -1.33248404e-01f, 1.81352630e-01f, 1.18660696e-01f, 1.41092494e-01f, -4.71535623e-02f, 1.97160870e-01f, -7.32217282e-02f, 2.86797076e-01f, -7.78604718e-03f,
  1.38384238e-01f, 3.38309482e-02f, 4.94815670e-02f, 1.55518547e-01f, 1.77814797e-01f, 9.31106880e-02f, 1.93698227e-01f, 1.46630347e-01f, 1.74075291e-01f, 2.99150109e-01f,
  2.84215331e-01f, -7.77481645e-02f, 4.80541915e-01f, -1.01619676e-01f, -1.10194378e-01f, 2.90471345e-01f, 2.95354962e-01f, -1.42679185e-01f, 2.71614373e-01f, 3.60092580e-01f,
  -4.10931110e-02f, 3.41521323e-01f, 1.46992549e-01f, 1.69515267e-01f, -3.70882928e-01f, 1.83310837e-01f, -4.59949970e-01f, -1.54100031e-01f, -4.58956659e-01f, 3.16704437e-02f,
  2.15525329e-01f, 3.36598158e-01f, 1.38601929e-01f, -5.83948791e-01f, 1.32469414e-02f, 1.73857331e-01f, -3.88708442e-01f, 1.13276467e-01f, -5.40711582e-01f, 3.14712375e-01f,
  -2.23289683e-01f, -3.09853762e-01f, 7.97825977e-02f, -3.10909182e-01f, 1.26866862e-01f, 2.65818220e-02f, 1.82952136e-01f, -1.52816802e-01f, -2.21495137e-01f, -1.18070103e-01f,
  2.15488136e-01f, -4.84264851e-01f, 2.85576016e-01f, -1.14604585e-01f, -1.01764202e-02f, 5.24092540e-02f, -4.09699291e-01f, -3.71371955e-01f, 3.22632045e-01f, -5.98822273e-02f,
  7.16177076e-02f, 7.44277239e-02f, -1.95578247e-01f, 1.63900167e-01f, -9.63355997e-04f, 3.83462338e-03f, 8.25226530e-02f, -6.73117861e-02f, 1.09253637e-01f, 4.19251211e-02f,
  1.08548656e-01f, 1.38171315e-01f, 2.10328713e-01f, -7.81785697e-02f, 7.30748996e-02f, 1.19581476e-01f, -2.23663211e-01f, -1.70233458e-01f, -2.82258540e-01f, -6.81690797e-02f,
  -8.62722471e-02f, -1.59398824e-01f, 2.79943973e-01f, 1.65625199e-04f, 4.47990745e-03f, 1.27817988e-01f, 5.84836975e-02f, 2.64463037e-01f, -4.04634252e-02f, -3.78346324e-01f,
  1.48320556e-01f, 9.86307785e-02f, -1.78586289e-01f, -5.06522506e-02f, -3.62127692e-01f, -2.57415384e-01f, -4.89774168e-01f, 4.26400304e-01f, 1.68442816e-01f, 9.94058102e-02f,
  -2.50020176e-02f, 2.89715137e-02f, -2.79120684e-01f, -3.72093320e-02f, 2.01583624e-01f, -5.19169159e-02f, 1.61226586e-01f, 2.07286179e-01f, 1.38809174e-01f, -5.06651282e-01f,
  2.39452854e-01f, -5.73343635e-01f, 9.01073888e-02f, -4.44891632e-01f, 1.86372787e-01f, 5.37757650e-02f, -4.07569818e-02f, 2.69310355e-01f, 1.20804965e-01f, 2.30279028e-01f,
  2.64217764e-01f, -1.84248775e-01f, 1.18498914e-01f, -2.68099695e-01f, 1.81040406e-01f, 2.38123490e-03f, 1.48291916e-01f, 1.30115032e-01f, 6.69422895e-02f, 5.11614978e-02f,
  -1.59688350e-02f, 4.55835834e-02f, 4.48134653e-02f, 3.92502844e-02f, -4.18143906e-02f, 1.01246066e-01f, 7.50990361e-02f, 2.67154515e-01f, 1.64570957e-02f, -3.12460959e-01f,
  -1.49403706e-01f, 2.92333573e-01f, 1.96072936e-01f, -1.82382315e-02f, -3.19501221e-01f, -2.12001830e-01f, 3.86165649e-01f, -2.70511448e-01f, -4.35991287e-01f, -5.42992763e-02f,
  3.54871511e-01f, -3.40016156e-01f, 3.46448451e-01f, -2.61025757e-01f, -4.42348793e-02f, 1.70761019e-01f, -3.02131206e-01f, -5.06173968e-01f, -7.61045702e-03f, 2.08682582e-01f,
  3.71698104e-03f, -1.43225029e-01f, -3.56264591e-01f, 2.55396962e-01f, 1.96453750e-01f, -2.61899322e-01f, -2.18076214e-01f, -4.35417630e-02f, 2.84312218e-01f, 4.21478659e-01f,
  -2.63047457e-01f, 4.30024154e-02f, -4.89037842e-01f, -1.63352594e-01f, 9.73707661e-02f, 2.73119837e-01f, 7.31111839e-02f, 7.31521472e-02f, -3.50775957e-01f, 3.73915225e-01f,
  -1.92050651e-01f, 3.40836421e-02f, -3.94081831e-01f, 1.52216509e-01f, -4.31836098e-01f, -2.72261679e-01f, -4.89989787e-01f, -5.05690336e-01f, -1.86617989e-02f, -9.25798938e-02f,
  1.11601174e-01f, 9.74372961e-03f, 6.84153512e-02f, -1.08582126e-02f, 1.04825713e-01f, -1.21516166e-02f, -5.86078167e-02f, -1.09800615e-03f, -6.33813515e-02f, -3.22053861e-03f,
  2.62060821e-01f, 1.82434887e-01f, -1.99732974e-01f, -1.05474412e-01f, 7.60615468e-02f, 1.59386545e-01f, -1.08364135e-01f, -1.19847357e-01f, 1.44458860e-01f, -1.56252176e-01f,
  1.57095253e-01f, -9.09277052e-02f, -3.43315214e-01f, -2.16603979e-01f, -2.35241987e-02f, 2.77307719e-01f, -1.55878007e-01f, -1.56099781e-01f, -2.09258273e-01f, -3.74711543e-01f,
  3.87179554e-01f, -2.65816361e-01f, -2.97343969e-01f, -1.69341102e-01f, -2.11941585e-01f, -1.04288250e-01f, -9.45890620e-02f, -9.91607178e-03f, -1.59236833e-01f, 1.07552484e-01f,
  1.62649900e-01f, -3.28453064e-01f, -3.56253505e-01f, -2.37028420e-01f, -2.97695994e-01f, -2.42269874e-01f, -2.39071697e-01f, -1.18187509e-01f, 2.75712997e-01f, 3.09389442e-01f,
  2.84059346e-01f, -5.47710992e-02f, 2.22247213e-01f, 1.39024660e-01f, 1.66384608e-01f, -3.03889453e-01f, 1.94963038e-01f, -3.12838227e-01f, 2.57755052e-02f, 2.78986812e-01f,
  3.35323066e-01f, -2.12632433e-01f, 5.32655679e-02f, 3.81905623e-02f, -2.06935015e-02f, -2.07028776e-01f, 7.67103732e-02f, 7.95964673e-02f, -8.74906778e-02f, -2.00680681e-02f,
  -4.28146534e-02f, -1.85512051e-01f, 5.08356467e-02f, -9.61414278e-02f, -1.16336055e-01f, -1.17628025e-02f, 1.20059170e-01f, -2.04447120e-01f, -2.61966884e-01f, 2.04388022e-01f,
  1.64683580e-01f, 1.15429655e-01f, -2.29603857e-01f, -2.58516371e-01f, -2.39329547e-01f, -1.49287298e-01f, -8.07656199e-02f, -2.57705659e-01f, -3.07467461e-01f, 3.77183795e-01f,
  -3.49649251e-01f, 2.09290206e-01f, 3.44932228e-02f, -8.69557783e-02f, 3.08560640e-01f, -3.88264745e-01f, -2.02637762e-01f, -3.29518080e-01f, -1.73805833e-01f, -5.39683970e-03f,
  -3.44224274e-01f, -2.75612205e-01f, 2.55706728e-01f, -3.40298384e-01f, -8.86746421e-02f, 7.88009912e-02f, -3.12159151e-01f, -3.61311018e-01f, 2.12878138e-01f, 3.38748276e-01f,
  1.52276099e-01f, 1.42864749e-01f, -2.24427894e-01f, -3.10010582e-01f, -2.44761765e-01f, 1.99921072e-01f, 3.30646448e-02f, 1.66622013e-01f, -3.07594061e-01f, -1.68586463e-01f,
  1.16362698e-01f, 1.91367492e-01f, -2.38424554e-01f, -2.78968930e-01f, 1.60854563e-01f, 1.81136861e-01f, -1.71244904e-01f, -1.04496889e-02f, -8.34744349e-02f, 1.47949740e-01f,
  1.24143183e-01f, 1.38964489e-01f, -8.35486501e-02f, 7.30101913e-02f, -6.52864426e-02f, -1.07038617e-01f, 7.36196563e-02f, -3.20487134e-02f, 2.00544015e-01f, -2.79151231e-01f,
  1.14394210e-01f, 3.59929085e-01f, -2.61288345e-01f, 7.45817199e-02f, 2.13898122e-01f, 7.62208328e-02f, 3.49077106e-01f, -1.34799108e-01f, -1.42987937e-01f, -3.25408250e-01f,
  -3.15103680e-01f, 3.00882012e-01f, -1.75763071e-01f, -3.58756632e-01f, -6.44839853e-02f, 2.81797737e-01f, 3.47266905e-02f, -5.20702839e-01f, 4.18143183e-01f, -2.27562953e-02f,
  3.46080400e-02f, 2.21475691e-01f, -2.69131511e-01f, -2.45483726e-01f, 3.74838442e-01f, 1.82119742e-01f, -3.55993420e-01f, -3.80389154e-01f, -2.76347518e-01f, -7.18435422e-02f,
  2.90370345e-01f, -3.01263332e-01f, -2.78074145e-01f, -3.35641205e-01f, -4.79926705e-01f, 3.19586337e-01f, 3.10787737e-01f, -1.90790966e-01f, 9.50753912e-02f, -4.08734530e-01f,
  -2.78492004e-01f, 2.29157045e-01f, -3.31241041e-01f, -4.72110868e-01f, -1.01453118e-01f, -8.88409987e-02f, -2.92572767e-01f, -1.51967898e-01f, 2.82225072e-01f, -2.80481309e-01f,
  -6.40471950e-02f, -1.79501817e-01f, 1.79883435e-01f, 1.01138532e-01f, -1.98051348e-01f, -1.18722677e-01f, -1.55720085e-01f, -5.03476262e-02f, 5.38067631e-02f, -1.43638914e-02f,
  -9.42720994e-02f, 1.03089124e-01f, -1.80339471e-01f, 1.70206949e-01f, -2.19017372e-01f, 3.52461398e-01f, 2.45284989e-01f, 2.40068018e-01f, 1.89881727e-01f, 2.47413367e-02f,
  2.32716933e-01f, 4.71971966e-02f, 2.26503551e-01f, 3.38097066e-01f, 1.39528170e-01f, 2.35758722e-01f, -3.57255310e-01f, -4.51577663e-01f, 2.40689278e-01f, 1.55920565e-01f,
  -7.05584213e-02f, 1.16378270e-01f, -4.60638434e-01f, -4.38248426e-01f, -3.43679398e-01f, -3.81645560e-01f, 2.30977029e-01f, -1.97594449e-01f, -2.37438858e-01f, -2.96516001e-01f,
  1.92349285e-01f, -1.07566211e-02f, 2.50411361e-01f, -2.64681667e-01f, 3.10728133e-01f, -3.03174462e-02f, 4.03486192e-02f, 1.27773225e-01f, 2.08972633e-01f, 3.13023716e-01f,
  -2.02377006e-01f, 6.73725680e-02f, 7.93896243e-02f, 1.03062093e-01f, -3.69636893e-01f, -4.69692171e-01f, 3.50723900e-02f, -2.31858522e-01f, 2.27595359e-01f, -1.87436938e-01f,
  -9.71863344e-02f, 5.33089377e-02f, -3.29442769e-01f, 1.04237363e-01f, 7.05760866e-02f, 2.12695412e-02f, 3.98469530e-02f, -1.05790786e-01f, 5.51408380e-02f, 6.26356676e-02f,
  1.25375211e-01f, 1.58485472e-02f, -7.75853768e-02f, 1.40528008e-01f, 1.41444758e-01f, 1.54699042e-01f, 1.74973950e-01f, 1.98982403e-01f, 8.12435150e-02f, -1.45498008e-01f,
  -2.03632221e-01f, 1.66255027e-01f, -1.11329064e-01f, 2.91838586e-01f, 5.05070351e-02f, 2.66588539e-01f, -1.10347256e-01f, -2.43949682e-01f, -3.14693004e-02f, 1.23174973e-02f,
  -1.04817502e-01f, -3.59236635e-02f, -1.82018459e-01f, -1.85275495e-01f, -3.63935560e-01f, 2.44455650e-01f, -1.53306097e-01f, -2.32241407e-01f, 2.52157241e-01f, 1.02720752e-01f,
  -2.25237668e-01f, -1.55641019e-01f, -2.44952664e-01f, 3.02732915e-01f, 1.24347182e-02f, -3.96597862e-01f, 1.94295064e-01f, -1.86888918e-01f, -3.17923427e-01f, -2.73915052e-01f,
  -2.43959054e-01f, 3.55477899e-01f, 1.10952668e-01f, -3.58412080e-02f, -4.01326418e-01f, -2.93748021e-01f, 1.60369575e-01f, 2.20173359e-01f, 3.49835865e-02f, -3.71773839e-02f,
  -4.43916947e-01f, 3.02643061e-01f, 8.89983401e-02f, 1.22835904e-01f, 4.65716749e-01f, 3.02008420e-01f, -3.30772698e-01f, -3.78133774e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  4.04683165e-02f, -2.74509676e-02f, -1.45156868e-02f, -3.37245576e-02f, -4.81531210e-02f, 5.09638973e-02f, -4.49452624e-02f, 4.93358672e-02f, -5.31113259e-02f, 3.51484008e-02f,
  3.31948744e-03f, 4.67407815e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    