/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.18182933e-01f, 1.61860973e-01f, 9.01919231e-02f, 1.35492086e-01f, -4.25881296e-02f, -4.39247817e-01f, -8.58753696e-02f, 4.91532907e-02f, 1.05400503e-01f, -1.56554237e-01f,
  -3.80537882e-02f, 1.30943656e-01f, 1.80968046e-01f, -1.83780611e-01f, -8.43278244e-02f, -9.59995613e-02f, -3.37098688e-01f, -6.69900179e-02f, 1.36931613e-01f, 1.81138784e-01f,
  7.79610351e-02f, -2.22992003e-01f, 5.47019392e-03f, -9.97347832e-02f, 8.84542093e-02f, 1.30825609e-01f, 5.23207784e-02f, 9.77295190e-02f, -1.79369107e-01f, -9.49580446e-02f,
  5.18720262e-02f, 1.90516323e-01f, 4.59462591e-02f, -5.51655777e-02f, -1.00492634e-01f, 3.03199328e-03f, 2.15735473e-02f, 4.94027790e-03f, -3.56340734e-03f, 2.22696066e-02f,
  1.02260169e-02f, 6.47294223e-02f, -6.90394193e-02f, -4.12884280e-02f, 3.14344727e-02f, -3.09786182e-02f, 1.91382342e-03f, -5.65524548e-02f, 1.53343886e-01f, 9.00589526e-02f,
  8.72078724e-03f, -5.66721931e-02f, -9.35151801e-02f, -5.00480793e-02f, -2.38532480e-02f, -3.56969200e-02f, -5.49644232e-02f, 4.26497832e-02f, -9.30621997e-02f, -2.49477811e-02f,
  -4.71122116e-02f, 7.07061291e-02f, 6.85456907e-03f, 2.58697476e-02f, -1.18291611e-02f, 5.81205487e-02f, -4.93803732e-02f, -3.44640538e-02f, 6.59711212e-02f, 3.45883407e-02f,
  -3.47769409e-02f, 7.16733932e-02f, 2.87124570e-02f, -5.38024716e-02f, -2.27102600e-02f, 6.95030019e-03f, 2.09084153e-02f, 4.64482754e-02f, -1.40815731e-02f, -3.21209780e-03f,
  5.94865419e-02f, -2.54769083e-02f, 2.43140534e-02f, 5.04591595e-03f, -1.14759877e-02f, -1.60041545e-02f, -3.32166255e-02f, -1.57919135e-02f, 4.91675921e-02f, -6.11758558e-03f,
  6.86280383e-03f, -1.09156442e-03f, -6.13924041e-02f, -3.16084586e-02f, 2.83669457e-02f, -2.69980319e-02f, -4.94882390e-02f, 1.45717291e-02f, -5.58825321e-02f, -2.87095550e-02f,
  6.41696947e-03f, -2.63088029e-02f, -2.40020044e-02f, 4.66235317e-02f, -7.67295882e-02f, -2.95182113e-02f, 2.42701303e-02f, 3.14874463e-02f, -7.01445043e-02f, -2.24780102e-04f,
  1.03106378e-02f, -1.65020023e-02f, 1.58171859e-02f, 5.17596304e-03f, -2.46218685e-02f, 2.66409628e-02f, -1.63128972e-03f, 8.49878008e-04f, -9.75759886e-03f, -3.68606746e-02f,
  5.56790650e-01f, -2.47771159e-01f, -1.00203082e-01f, 2.18936607e-01f, 2.18808115e-01f, -3.66241902e-01f, -3.40808034e-01f, 5.07272705e-02f, 2.85601318e-01f, -2.74475038e-01f,
  -5.72174527e-02f, 8.65530670e-02f, -1.77627876e-01f, -1.10499665e-01f, 9.31364000e-02f, -2.27344647e-01f, -1.52656242e-01f, -4.82820645e-02f, 7.87551478e-02f, -2.43643168e-02f,
  1.31458625e-01f, -8.67932756e-03f, -1.56095669e-01f, 1.16715916e-02f, -5.07567124e-03f, 6.34851828e-02f, -6.27530664e-02f, 3.14081600e-03f, -4.45472039e-02f, -2.91153528e-02f,
  -1.11512527e-01f, 9.35094804e-02f, -3.29307443e-03f, -3.36005315e-02f, -2.31304727e-02f, -1.90901253e-02f, -4.45227772e-02f, -2.54919101e-03f, 2.91104745e-02f, 1.38327647e-02f,
  -5.54940104e-02f, 4.18805964e-02f, 1.43316644e-03f, 1.34120043e-02f, 8.70832503e-02f, 6.25592098e-02f, 1.17607368e-02f, -5.57578914e-02f, 6.69525340e-02f, -1.82163678e-02f,
  7.06767943e-03f, -4.17492539e-02f, 4.27740179e-02f, -8.45154002e-02f, 4.62524220e-02f, 4.75096889e-02f, -8.69487971e-02f, -4.34702039e-02f, -8.95414315e-03f, 7.09927604e-02f,
  7.07886219e-02f, -2.47822814e-02f, -2.85710972e-02f, -2.14072000e-02f, 1.92035716e-02f, 5.46839386e-02f, -3.84211843e-03f, -6.15748689e-02f, 3.35826203e-02f, -3.42268609e-02f,
  3.27521302e-02f, 5.30971251e-02f, 5.29208854e-02f, -3.65735078e-03f, 2.07044277e-02f, -1.22514628e-02f, -3.00173946e-02f, 7.46124471e-03f, -4.58293874e-03f, 4.23575118e-02f,
  -1.70392990e-02f, 3.61688063e-02f, -6.71068653e-02f, -4.23064977e-02f, -4.21659239e-02f, 2.62051094e-02f, 4.45111282e-02f, 2.00027470e-02f, -4.39312421e-02f, 1.25875277e-02f,
  -1.30072430e-01f, -1.08351037e-01f, 4.10701334e-03f, 3.88837303e-03f, 9.12739150e-03f, 2.84028109e-02f, -4.20752913e-03f, 4.92841080e-02f, 3.75998020e-02f, 2.09049657e-02f,
  9.13133025e-02f, -1.65178336e-03f, -9.31883883e-03f, 1.33682704e-02f, -1.22019267e-02f, -7.48519152e-02f, -4.44052070e-02f, -4.71782405e-03f, -3.27910930e-02f, 2.99742576e-02f,
  -1.19298445e-02f, 2.15315167e-02f, -9.21600964e-03f, 1.11420462e-02f, -4.95849513e-02f, -1.77015886e-02f, 6.21517412e-02f, 3.62219438e-02f, -3.59425880e-02f, 2.41814479e-02f,
  4.52301055e-01f, 1.04071135e-02f, 2.85571218e-01f, 2.64109731e-01f, -2.28045601e-03f, 1.86400101e-01f, 1.04836755e-01f, 7.38571659e-02f, 2.96156973e-01f, -2.22008631e-01f,
  -6.87505454e-02f, -4.52835634e-02f, -1.56171173e-01f, -4.27040569e-02f, 1.33004963e-01f, -3.71478833e-02f, 1.59812734e-01f, -4.78289761e-02f, 4.44791950e-02f, 1.44299880e-01f,
  1.25179797e-01f, -2.27752298e-01f, 1.26451731e-01f, -1.48106679e-01f, 2.42761374e-02f, 1.67343765e-01f, -2.03620806e-01f, -8.09530243e-02f, -1.41320124e-01f, -7.79533684e-02f,
  8.09496418e-02f, -3.31595764e-02f, 3.00481413e-02f, 4.37789410e-02f, 8.29511657e-02f, -2.41374075e-02f, 4.79080193e-02f, -9.34421122e-02f, 7.63539597e-02f, -1.73660403e-03f,
  -2.13162005e-02f, -2.92496663e-02f, -5.50556779e-02f, -4.74771205e-03f, 9.09958333e-02f, 5.21264113e-02f, 7.29410946e-02f, 1.04206130e-01f, 1.91660679e-03f, 3.01581994e-02f,
  8.71212631e-02f, 5.38146868e-02f, 8.13793838e-02f, -4.02825549e-02f, 3.56696695e-02f, 1.44188143e-02f, 1.13249570e-02f, 5.95313776e-03f, -1.56509746e-02f, 4.62173410e-02f,
  2.04108264e-02f, 4.61569242e-02f, -3.80365178e-02f, -9.08609107e-03f, -8.07450712e-02f, -1.43523281e-02f, -2.18409337e-02f, -1.00259691e-01f, 3.41443419e-02f, -3.58680333e-03f,
  -8.71671480e-04f, 2.31672190e-02f, -4.61955108e-02f, 7.94075280e-02f, -3.52092013e-02f, 2.83835363e-03f, -1.34137587e-03f, -5.66369109e-02f, 1.07920773e-01f, 5.28277606e-02f,
  -3.29179056e-02f, 2.16884539e-02f, 9.29933228e-03f, -4.17609662e-02f, 7.73234526e-04f, 6.58752536e-03f, 9.38304048e-03f, 7.53296614e-02f, 1.89195445e-03f, 3.02271568e-03f,
  -3.78423254e-04f, -3.38058360e-02f, 3.13241296e-02f, -8.95595364e-03f, -8.01554248e-02f, -2.26454679e-02f, -4.74700965e-02f, 3.86672169e-02f, 4.06488404e-02f, -3.44119780e-03f,
  3.62373516e-02f, 1.87220275e-02f, 1.14050750e-02f, 8.53346568e-03f, -5.43963211e-03f, -3.47175100e-03f, -3.95218004e-03f, -1.22217834e-02f, -3.60672660e-02f, -1.60991997e-02f,
  -1.86887253e-02f, -2.25754408e-03f, -6.02431372e-02f, 1.50869973e-02f, -1.35690998e-02f, 2.52532354e-03f, 3.97473462e-02f, -1.94170773e-02f, -5.99290840e-02f, -1.93848573e-02f,
  1.02674320e-01f, 2.01634392e-02f, -1.06902279e-01f, -6.65173233e-02f, 3.71155083e-01f, 3.84529047e-02f, 2.35504918e-02f, 2.09119812e-01f, -1.49183273e-01f, -3.89882699e-02f,
  -5.62216789e-02f, -3.22642654e-01f, -6.69718981e-02f, -1.73134610e-01f, -1.79107755e-01f, -3.10861200e-01f, -2.53987521e-01f, -1.86777383e-01f, -7.20466971e-02f, 5.98620102e-02f,
  -4.03464250e-02f, 3.08480471e-01f, 8.57313797e-02f, 3.65143836e-01f, 3.17244947e-01f, 2.07181379e-01f, 2.33159304e-01f, 1.49050787e-01f, 1.44790068e-01f, 6.49192254e-04f,
  -1.43117651e-01f, -5.92957027e-02f, 8.10142532e-02f, -8.60737488e-02f, 8.25328231e-02f, 4.35025897e-03f, -6.18396066e-02f, 3.30539867e-02f, -4.01787348e-02f, -1.71571895e-02f,
  -2.11852882e-02f, 8.47719051e-03f, 2.28465702e-02f, 9.05131400e-02f, 6.80620596e-02f, -3.86929065e-02f, 1.47608817e-02f, -1.33471312e-02f, -3.08890678e-02f, -6.51306659e-02f,
  -9.42575857e-02f, -7.08602890e-02f, -1.13328233e-01f, -2.74573937e-02f, 1.60369053e-02f, -6.03054129e-02f, 7.66151818e-03f, -3.54144163e-02f, -8.19630846e-02f, 5.73419854e-02f,
  3.70524824e-02f, 3.35690975e-02f, 4.93199080e-02f, -2.07100213e-02f, 1.20442444e-02f, -1.50773954e-02f, -6.19819090e-02f, -3.74730751e-02f, -1.34321013e-02f, 6.79179979e-03f,
  3.42904677e-04f, 6.94664940e-02f, 3.70009914e-02f, 4.95491065e-02f, -2.91422177e-02f, 4.27266434e-02f, -2.39365716e-02f, -2.86299679e-02f, 7.88111910e-02f, 1.00151086e-02f,
  2.46283058e-02f, -2.60896198e-02f, 1.08143933e-01f, 9.92658082e-03f, -5.81839941e-02f, 9.55966488e-02f, 6.13307655e-02f, 5.26493192e-02f, -1.86449718e-02f, 5.06060198e-02f,
  -1.39945880e-01f, 1.55090302e-01f, 5.33178784e-02f, 1.07808895e-02f, -9.21800807e-02f, -3.91769782e-02f, -6.62536770e-02f, -1.93975735e-02f, -1.37066972e-02f, 6.19094186e-02f,
  5.34686893e-02f, -4.86726128e-03f, -1.11866016e-02f, 3.59323015e-03f, -1.29254153e-02f, 4.84436192e-02f, -3.89499441e-02f, 2.46924609e-02f, 4.61487286e-02f, 1.14668377e-01f,
  1.19272806e-01f, 3.09490431e-02f, -2.70730387e-02f, 6.13883249e-02f, 8.31433572e-03f, 3.92439701e-02f, 5.10632321e-02f, 6.17847107e-02f, 2.13995557e-02f, -1.22074217e-01f,
  -4.60179120e-01f, -2.33520363e-02f, -2.75100172e-01f, -2.86287069e-01f, 1.61346704e-01f, -7.23094679e-03f, -2.39656642e-01f, 1.34716466e-01f, 1.18011318e-01f, 1.11887828e-01f,
  1.31068885e-01f, -1.93490565e-01f, 1.63691789e-01f, -2.01793775e-01f, -4.48786259e-01f, 9.23936740e-02f, -3.02328646e-01f, -1.40730470e-01f, 1.76809326e-01f, -1.18768007e-01f,
  -3.34395096e-02f, -6.19572923e-02f, -1.60538346e-01f, 2.43425548e-01f, -1.22462951e-01f, 9.40467566e-02f, -1.20652810e-01f, 1.17126524e-01f, -2.68125117e-01f, -8.38515610e-02f,
  6.88009262e-02f, 4.35635783e-02f, -8.52450579e-02f, 2.40779836e-02f, 2.72955932e-03f, -1.93973202e-02f, -3.88994589e-02f, -2.22999193e-02f, 6.17129356e-02f, 2.43298691e-02f,
  -5.10293581e-02f, -1.04309935e-02f, 2.10959353e-02f, 2.38841213e-02f, 4.39538388e-03f, -1.45037798e-02f, 2.41436623e-02f, -3.86919975e-02f, -5.36491862e-03f, -5.93665838e-02f,
  -5.16727604e-02f, -4.28855158e-02f, -4.52891588e-02f, -8.61571729e-02f, -6.75223321e-02f, -2.30730002e-04f, -6.77603036e-02f, -7.73646683e-02f, -9.90771726e-02f, -2.60752458e-02f,
  -2.28633136e-02f, -1.72473385e-03f, 2.48220097e-03f, 1.63301602e-02f, 2.37525217e-02f, -1.26539180e-02f, 1.73959881e-03f, -8.48418195e-03f, -4.67611768e-04f, -2.66999588e-03f,
  9.41359811e-03f, 1.14108482e-02f, 2.89477203e-02f, -2.02504564e-02f, -5.11157401e-02f, 7.47235399e-03f, -6.63303509e-02f, 2.80911513e-02f, 1.05977617e-03f, -2.45356350e-03f,
  1.04833636e-02f, 4.10007732e-03f, -1.41876480e-02f, 1.16014639e-02f, 8.75607207e-02f, -2.88579725e-02f, 7.34902620e-02f, -8.17141682e-02f, 7.39121735e-02f, -5.39346077e-02f,
  -3.00940927e-02f, -1.36882260e-01f, 8.79571587e-02f, -7.42792836e-05f, -3.83683224e-03f, 2.97286958e-02f, -4.17041443e-02f, -2.38189939e-02f, -3.21267992e-02f, -4.05551214e-03f,
  -3.80554907e-02f, 2.45034210e-02f, -4.33849879e-02f, -1.84629522e-02f, -8.58125370e-03f, -5.57873324e-02f, -2.76008211e-02f, 1.80905368e-02f, -5.10521717e-02f, -1.73772639e-03f,
  -3.55823748e-02f, 1.42991738e-02f, 3.00782416e-02f, 8.35121349e-02f, -2.09314353e-03f, -2.39089932e-02f, -1.35133089e-02f, -3.35043785e-03f, -3.62252742e-02f, 1.89441741e-02f,
  8.52249935e-02f, 6.97440654e-02f, -4.10841852e-02f, 8.78236368e-02f, -1.31438822e-01f, -1.12821020e-01f, 1.35442585e-01f, 3.08677480e-02f, -2.52282292e-01f, 2.24061757e-01f,
  3.19418997e-01f, -1.14448622e-01f, 2.09905207e-01f, 2.76767880e-01f, -2.37383246e-01f, -3.81224006e-02f, -6.25493824e-02f, -8.35532919e-02f, -3.10309172e-01f, 1.36487260e-01f,
  6.68016821e-02f, 2.30499297e-01f, 1.15773894e-01f, -2.64120251e-02f, 2.31785059e-01f, 9.76287350e-02f, 2.40296438e-01f, -1.73624113e-01f, 3.55551429e-02f, -1.64581895e-01f,
  6.18312787e-03f, -1.18801035e-02f, 3.60613763e-02f, -7.80349672e-02f, 1.25780970e-01f, 8.00179392e-02f, 6.76848590e-02f, 1.13902967e-02f, -1.33397698e-01f, 4.98552062e-02f,
  1.88504726e-01f, 1.04664797e-02f, 2.08144411e-02f, -1.26478508e-01f, -5.23384549e-02f, -1.63862631e-02f, 8.02373048e-03f, 5.19832149e-02f, 1.55646177e-02f, 5.21554016e-02f,
  7.92907327e-02f, 8.72712862e-03f, 1.15826659e-01f, 3.77348103e-02f, -1.40149016e-02f, -1.11297630e-01f, -1.07839078e-01f, -2.64325347e-02f, -7.46501423e-03f, -3.59527878e-02f,
  6.69026449e-02f, -1.69531986e-01f, 7.27455392e-02f, -8.22669547e-03f, 3.02221961e-02f, 9.09272879e-02f, -4.33028489e-02f, 1.16395481e-01f, -1.20218523e-01f, 4.40496653e-02f,
  2.19489764e-02f, 1.19460770e-03f, -8.29419643e-02f, -4.61857580e-02f, -6.22829981e-03f, 8.44638422e-02f, 7.57531449e-02f, 6.35408389e-04f, 6.15429506e-02f, 9.19645466e-03f,
  6.37438521e-02f, -1.86802391e-02f, -4.16065268e-02f, 3.94921862e-02f, -9.53360498e-02f, 3.61728631e-02f, 8.14854503e-02f, -6.85243635e-03f, 4.95472774e-02f, -1.21928202e-02f,
  -1.39702484e-01f, 2.58429181e-02f, -8.43465403e-02f, -2.99208444e-02f, -9.48276836e-03f, 1.08231798e-01f, -3.09850872e-02f, 2.34034527e-02f, 1.95619389e-02f, 9.65960510e-03f,
  4.66166735e-02f, 9.27383006e-02f, -1.78403221e-02f, 2.47272477e-02f, 2.10556015e-03f, 7.97034353e-02f, 7.13268714e-03f, -5.76635115e-02f, 9.77815241e-02f, -7.13941082e-02f,
  7.84390606e-03f, -1.15931900e-02f, 1.48460884e-02f, 1.13473266e-01f, 1.02148853e-01f, 2.18306407e-02f, 3.29008442e-03f, -1.71212614e-01f, 3.94469462e-02f, -5.77971712e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.07771051e-01f, -3.19837511e-01f, 4.41019386e-01f, -2.58994430e-01f, 1.93747371e-01f, 2.51538843e-01f, 1.80912554e-01f, -4.30419780e-02f, -1.82617158e-01f, -2.71950603e-01f,
  1.78504344e-02f, -9.15160701e-02f, 2.04357833e-01f, -4.40868028e-02f, 2.86922723e-01f, 8.02399442e-02f, -3.12849730e-02f, -9.72102433e-02f, 2.81887911e-02f, -1.87817942e-02f,
  3.63880992e-02f, -8.81459713e-02f, 3.38400275e-01f, -9.48947296e-02f, 1.49031788e-01f, -2.42430404e-01f, -3.51822674e-02f, 2.17605203e-01f, -1.03356786e-01f, 1.43620864e-01f,
  -7.93585926e-02f, -2.17522159e-01f, 5.01185190e-04f, -5.85053395e-03f, -1.76648479e-02f, -1.95508208e-02f, 1.08413041e-01f, 8.39249715e-02f, -4.09180671e-02f, -5.91319837e-02f,
  -1.75687764e-02f, 2.39934586e-02f, -1.00259051e-01f, 1.23543963e-02f, -3.97751592e-02f, -3.79593596e-02f, 1.10635728e-01f, 6.02014549e-03f, 1.03850856e-01f, 1.42062366e-01f,
  1.38289809e-01f, -1.49575835e-02f, 1.63998529e-01f, -3.19021195e-02f, 9.17746648e-02f, 1.73063502e-02f, 9.09647048e-02f, 3.21959481e-02f, -9.34954435e-02f, -1.52174473e-01f,
  3.81186940e-02f, 6.38945997e-02f, 4.52119522e-02f, 8.23163521e-03f, 1.48632824e-02f, -3.15414183e-02f, -5.75853884e-03f, 4.47912179e-02f, -1.86543986e-02f, -1.31002236e-02f,
  2.15717349e-02f, -2.92513110e-02f, 2.53875237e-02f, -1.47768091e-02f, -6.13323338e-02f, 1.47194294e-02f, 4.51022647e-02f, -2.94290073e-02f, 5.76201528e-02f, 5.08269444e-02f,
  4.80753332e-02f, 6.38443306e-02f, 1.02117799e-01f, 7.38946768e-03f, -2.01836284e-02f, 3.03098895e-02f, 3.48845869e-02f, 7.74059668e-02f, -4.57656160e-02f, -4.77069151e-03f,
  -3.23721319e-01f, -4.07591522e-01f, -6.39115795e-02f, -8.56423676e-02f, -7.58136660e-02f, -4.80687134e-02f, -1.77546740e-02f, -1.18417338e-01f, -5.59973009e-02f, -3.72157991e-03f,
  -6.58603460e-02f, 1.28558939e-04f, -9.38962027e-02f, 9.95967421e-04f, -5.75056225e-02f, 3.14769335e-02f, -2.88817696e-02f, -7.51904845e-02f, -5.90894781e-02f, -1.13312550e-01f,
  -8.53379592e-02f, -4.62283604e-02f, 1.25283942e-01f, 3.03347856e-02f, -2.41512451e-02f, -4.43852544e-02f, -1.01025604e-01f, -5.57198785e-02f, -2.44739354e-02f, -4.32657786e-02f,
  -7.14249849e-01f, 7.12452054e-01f, 2.34822392e-01f, -8.27573687e-02f, 4.85033430e-02f, 8.25637057e-02f, -1.77438036e-01f, 7.96406195e-02f, -8.10357928e-02f, 5.49333505e-02f,
  -1.21111378e-01f, 1.24197356e-01f, -1.27265975e-01f, 2.40109816e-01f, -4.11941141e-01f, -4.21389230e-02f, -1.38364032e-01f, -1.03453636e-01f, -4.93843050e-04f, -8.83334577e-02f,
  -6.39178008e-02f, -3.37141268e-02f, -1.72851421e-02f, 2.75036573e-01f, 1.33761063e-01f, 8.82717967e-02f, -3.03650856e-01f, 8.02281946e-02f, 1.83010206e-01f, 1.31314740e-01f,
  -2.93938130e-01f, -2.23026603e-01f, -1.79165170e-01f, -7.83370994e-03f, -1.63503557e-01f, -1.59937754e-01f, -1.30509093e-01f, -2.45422125e-02f, -7.86581859e-02f, 5.35459607e-04f,
  5.32639436e-02f, 9.79486182e-02f, 3.23444530e-02f, 2.07428820e-02f, -9.78315342e-03f, 4.87612411e-02f, 1.53491005e-01f, 8.70917067e-02f, 7.75386691e-02f, 8.71535987e-02f,
  1.46591723e-01f, 8.40052217e-02f, -4.57278825e-02f, 1.23970285e-02f, 5.40003506e-03f, 6.61173612e-02f, 7.28746504e-02f, 2.61620376e-02f, -3.42552876e-03f, -1.98875088e-02f,
  1.03530586e-01f, -7.53982216e-02f, -3.60716283e-02f, -5.30110113e-02f, 2.33515240e-02f, 6.63720667e-02f, -3.56938019e-02f, -6.98563829e-02f, -2.28960071e-05f, -4.42392752e-02f,
  2.13775914e-02f, -5.30873947e-02f, 1.56139082e-03f, -1.61624104e-02f, -4.11507264e-02f, 4.11794707e-02f, -1.48469992e-02f, 1.47450175e-02f, 3.24664987e-03f, 1.53972395e-02f,
  -6.98075965e-02f, -7.56578427e-03f, -8.10392015e-03f, -8.41753781e-02f, -9.32215061e-03f, -7.09754182e-03f, -4.16306518e-02f, 1.28274307e-01f, -8.79874676e-02f, -4.24525477e-02f,
  -6.43830419e-01f, -4.41690356e-01f, -1.49722233e-01f, -1.04939386e-01f, -3.38058732e-02f, 6.00338914e-03f, 1.41939595e-02f, 1.10053997e-02f, -9.58961770e-02f, -7.67455399e-02f,
  -2.90702134e-02f, -1.76156871e-02f, -7.67138749e-02f, -5.25353141e-02f, -7.04223942e-03f, -6.17508367e-02f, -1.55781046e-01f, -1.08528383e-01f, -1.99881583e-01f, -3.54497917e-02f,
  2.17621494e-03f, -2.24482641e-02f, -8.35800990e-02f, -6.65742308e-02f, -4.67668176e-02f, -6.44365400e-02f, -1.04275405e-01f, 3.74269150e-02f, -8.14312696e-02f, 8.95992368e-02f,
  2.90970683e-01f, -1.12593696e-01f, 5.50078228e-02f, 2.48456448e-01f, 5.11629097e-02f, -1.04605108e-01f, -1.01886995e-01f, 2.34538577e-02f, 8.42430741e-02f, -4.38745730e-02f,
  -1.13456063e-01f, -2.81035919e-02f, -4.64437217e-01f, 1.86102241e-01f, -4.28186804e-02f, -4.15529400e-01f, 2.84817547e-01f, 7.16724396e-02f, -1.42883182e-01f, 1.14469677e-01f,
  -1.28655182e-02f, 1.12918526e-01f, 8.37786123e-02f, 2.02168956e-01f, 1.60038814e-01f, 1.32356420e-01f, 8.04787725e-02f, -1.70238018e-01f, 2.59748548e-01f, 2.20863614e-02f,
  5.20385951e-02f, -4.30874936e-02f, 6.30941465e-02f, 1.03705369e-01f, -9.95011069e-03f, 1.11872047e-01f, -2.10136268e-02f, -3.52230109e-02f, -3.69872525e-02f, -2.13308353e-02f,
  -6.12833463e-02f, 4.30126451e-02f, 1.12229794e-01f, -6.09183088e-02f, 1.81469902e-01f, 1.37766629e-01f, 6.91182464e-02f, 3.45342495e-02f, 1.13733180e-01f, -1.18859418e-01f,
  -5.58096506e-02f, 7.99738988e-03f, 8.63401145e-02f, -1.66303862e-03f, -8.03884566e-02f, 1.29237603e-02f, 1.34966837e-03f, -7.52955750e-02f, 5.45425229e-02f, 7.28909895e-02f,
  -5.34290597e-02f, -9.77983177e-02f, -3.95104401e-02f, -1.10648107e-03f, 2.79545877e-02f, -4.74988222e-02f, -1.70401260e-02f, 6.37078984e-03f, 8.47621635e-03f, -6.16448745e-02f,
  1.34552240e-01f, -1.51398210e-02f, -2.99410336e-03f, -4.16742526e-02f, -1.66272260e-02f, 1.04635954e-01f, 5.04314005e-02f, -9.20904577e-02f, 6.75075650e-02f, -2.71059223e-03f,
  -1.07793352e-02f, 2.94864140e-02f, -6.14891239e-02f, 4.81135957e-02f, 1.45148084e-01f, -1.51369840e-01f, -3.60510461e-02f, 4.17696610e-02f, -8.32411200e-02f, 5.02024367e-02f,
  -3.95553894e-02f, -1.18146047e-01f, -5.78093827e-02f, 3.72221693e-02f, -7.55732954e-02f, 1.13616787e-01f, -2.80788983e-03f, 1.28055429e-02f, 8.41519386e-02f, -6.89146901e-03f,
  6.31230548e-02f, -1.88154320e-03f, 3.46468352e-02f, 7.98306614e-02f, 1.00544132e-01f, 3.51550169e-02f, -1.84168890e-02f, -1.61451288e-02f, 1.63735509e-01f, -5.54854050e-02f,
  -6.76132441e-02f, -1.25531420e-01f, 1.85865089e-01f, -1.23184351e-02f, 1.01489820e-01f, -9.30867046e-02f, -6.05499782e-02f, 6.83776513e-02f, -6.07979309e-04f, 3.47852381e-03f,
  4.07905653e-02f, 3.04345429e-01f, -1.12368733e-01f, -1.01674616e-01f, 3.97645719e-02f, -5.19845307e-01f, -1.73763350e-01f, -1.94724686e-02f, -9.64731872e-02f, 2.82805115e-01f,
  -4.64488342e-02f, 2.48861223e-01f, 6.06588162e-02f, -1.92855284e-01f, -5.84503233e-01f, -2.31566057e-01f, -2.89081156e-01f, -6.75153732e-02f, 2.54691448e-02f, 1.10232994e-01f,
  -1.61555350e-01f, -9.07481015e-02f, -1.82824597e-01f, 1.55517802e-01f, 1.99847281e-01f, 2.02729374e-01f, 1.64538682e-01f, 2.19693527e-01f, 5.84755801e-02f, -5.29806176e-03f,
  -9.93902832e-02f, 1.99300796e-01f, 3.34495679e-02f, -4.04658169e-02f, -4.59622443e-02f, 1.18669055e-01f, 6.54755831e-02f, -6.19003773e-02f, 2.50399084e-04f, -8.38768259e-02f,
  4.74759489e-02f, 5.01317158e-02f, -4.00492270e-03f, 2.47981846e-02f, 1.07917689e-01f, 9.12380591e-02f, -2.43713409e-02f, -3.21461558e-02f, 4.63016257e-02f, 7.11238384e-02f,
  -5.78713939e-02f, -6.69357628e-02f, 4.10546660e-02f, 9.66770202e-03f, -1.89668126e-02f, 1.10280570e-02f, -1.20286204e-01f, 3.35889384e-02f, -5.98600209e-02f, -5.36255818e-03f,
  1.04531378e-01f, 8.82270560e-03f, -2.97547169e-02f, 1.90426633e-02f, -4.32211906e-02f, 6.95819920e-03f, 5.97371385e-02f, 2.04494018e-02f, 6.14074506e-02f, 9.68257114e-02f,
  -7.56024942e-02f, -4.55361716e-02f, 5.82448356e-02f, -2.89599691e-02f, 1.48051661e-02f, 8.08683317e-03f, 2.91438904e-02f, 8.19698647e-02f, -6.26738816e-02f, -8.70976374e-02f,
  1.23565577e-01f, -7.71642476e-02f, 6.37030751e-02f, 9.27982405e-02f, -1.07594304e-01f, -1.36443656e-02f, 1.15712300e-01f, 2.65360828e-02f, -2.85734031e-02f, -3.79923917e-02f,
  -9.75142866e-02f, 1.47012353e-01f, 2.60976348e-02f, 3.29540148e-02f, 1.57022234e-02f, -1.36174476e-02f, -1.46621158e-02f, -1.54456317e-01f, 1.81265306e-02f, -9.76168588e-02f,
  5.52177429e-02f, 3.25889215e-02f, 1.73862539e-02f, 5.92091940e-02f, -6.78546354e-02f, -3.46633345e-02f, 5.36833480e-02f, 1.00709893e-01f, 2.29241271e-02f, 1.03410229e-01f,
  1.03586175e-01f, 1.21700250e-01f, 1.07372530e-01f, -5.25644943e-02f, 5.25607951e-02f, 3.06564439e-02f, 7.39092678e-02f, 1.52708562e-02f, 5.98347969e-02f, -8.63489415e-03f,
  -2.22874895e-01f, 5.34058630e-01f, -1.96820637e-03f, -6.09979369e-02f, -1.62804157e-01f, 5.57824373e-01f, 2.10774928e-01f, 5.16195484e-02f, -1.47045732e-01f, 2.38064080e-01f,
  7.40616070e-03f, -1.05870456e-01f, 5.32909334e-02f, 2.45754540e-01f, 1.11681394e-01f, 3.29770744e-01f, 1.76551089e-01f, 8.49657953e-02f, -9.21423584e-02f, -1.99891794e-02f,
  -2.45768838e-02f, 2.15996325e-01f, 6.84906021e-02f, 1.02915481e-01f, -5.77243380e-02f, -1.78774238e-01f, -2.63605118e-01f, -1.15466051e-01f, 1.29027274e-02f, 3.17801312e-02f,
  1.87373728e-01f, -5.53696230e-02f, -8.99718031e-02f, -1.49429487e-02f, 4.37264293e-02f, -6.17927089e-02f, -6.76452518e-02f, 6.94479700e-03f, -1.69250503e-01f, -4.77492474e-02f,
  -8.93553719e-02f, 9.93116572e-03f, 4.35088314e-02f, -9.91122797e-02f, -7.15743899e-02f, -1.30198866e-01f, 1.00011475e-01f, 3.45740803e-02f, -3.71900550e-03f, 1.46212861e-01f,
  3.48967640e-03f, 4.10130881e-02f, -2.76553389e-02f, 4.89852764e-02f, -1.60935134e-01f, -4.02914472e-02f, 9.03281346e-02f, 2.10065413e-02f, 2.78910752e-02f, 7.97742903e-02f,
  -1.03391431e-01f, 1.07408650e-01f, 1.57416776e-01f, -2.32274346e-02f, 6.97757825e-02f, -1.02227526e-02f, -5.92903420e-03f, -1.32002095e-02f, -5.18246293e-02f, 1.09325692e-01f,
  -1.05344228e-01f, -2.75115110e-02f, -2.00826563e-02f, 6.15871027e-02f, 7.79635459e-02f, 6.35107607e-02f, -4.09406275e-02f, -4.99196700e-04f, 1.02920039e-02f, 1.08335055e-01f,
  -7.32660592e-02f, -1.82973724e-02f, 1.55656002e-02f, -2.71079857e-02f, 6.33156151e-02f, -3.52737531e-02f, -9.63826552e-02f, -4.58145961e-02f, -6.34116028e-03f, -1.75532363e-02f,
  2.70020217e-01f, 1.72773406e-01f, -3.24471109e-02f, 2.95729795e-03f, 1.44131435e-02f, 3.14968005e-02f, 3.92289348e-02f, 5.95854297e-02f, 3.72176580e-02f, 1.52168432e-02f,
  -1.47083541e-02f, -9.65993758e-03f, 5.92082739e-03f, -5.49126379e-02f, -2.31841188e-02f, 1.71273500e-01f, 4.12258413e-03f, -1.39233157e-01f, -6.27333894e-02f, -9.36500356e-02f,
  -9.27696526e-02f, -4.61786194e-03f, -8.80715158e-03f, 2.64362376e-02f, -3.32807712e-02f, -2.25493498e-02f, 5.27782738e-02f, -2.03892644e-02f, -3.75024676e-02f, -3.20475213e-02f,
  5.47181293e-02f, 3.72924447e-01f, 4.21523452e-01f, 1.46997318e-01f, -1.77457407e-01f, -3.14746410e-01f, -2.11964980e-01f, 1.54533178e-01f, -5.76648712e-02f, 1.19040467e-01f,
  -1.22727938e-02f, 1.98689044e-01f, 1.18816689e-01f, 1.37813419e-01f, -1.03666514e-01f, -4.21937294e-02f, 2.28459612e-02f, -1.46985166e-02f, 2.08039745e-03f, 2.62468249e-01f,
  2.53655035e-02f, -1.31271854e-01f, 2.18439832e-01f, 9.90247726e-02f, 1.89792439e-01f, 1.93324715e-01f, -1.14407660e-02f, 6.75651804e-02f, 8.30112100e-02f, -7.60552809e-02f,
  -1.67836566e-02f, 7.67166391e-02f, 1.68520644e-01f, 1.40677104e-02f, 9.56386700e-02f, -4.87168543e-02f, 3.14539000e-02f, -4.15696725e-02f, -2.14861035e-02f, -8.59198067e-03f,
  -1.49404500e-02f, -7.78356940e-03f, -4.19872522e-04f, -6.38308674e-02f, -1.02336369e-02f, 5.98872453e-02f, -3.31599377e-02f, -4.95200306e-02f, 6.83072731e-02f, 9.09755602e-02f,
  1.34350568e-01f, 1.70057751e-02f, 2.34189741e-02f, -8.91560540e-02f, 4.82814312e-02f, -9.19180661e-02f, -9.01814997e-02f, 3.75562944e-02f, 6.26486391e-02f, 3.25631537e-02f,
  2.47500204e-02f, -1.63165912e-01f, -6.90808371e-02f, 2.33731084e-02f, 1.94407522e-03f, -8.84509925e-03f, 5.10866083e-02f, 8.79620388e-03f, 6.48975605e-03f, -6.56939223e-02f,
  -1.12008587e-01f, -5.33513501e-02f, -1.15381703e-02f, -8.21878910e-02f, -3.38098444e-02f, 1.95267983e-02f, -6.19344935e-02f, 5.21564521e-02f, 2.63432078e-02f, -9.91743989e-03f,
  -7.68727884e-02f, -7.02299364e-03f, 4.23154756e-02f, 1.46044763e-02f, -1.03973687e-01f, -4.15096097e-02f, 9.91844311e-02f, 1.01736315e-01f, 2.85544060e-02f, 4.84942459e-02f,
  1.06957667e-01f, 2.62055010e-01f, 2.20555365e-02f, -6.09040149e-02f, -1.06496597e-02f, 2.89559225e-03f, -4.37653698e-02f, 9.93421972e-02f, 7.53273666e-02f, -1.20408284e-02f,
  -3.28676142e-02f, -1.10779323e-01f, -6.69696704e-02f, -1.42938476e-02f, -3.21682952e-02f, 8.57559673e-04f, -1.74380857e-02f, -1.10887855e-01f, 1.21305306e-02f, 7.60412291e-02f,
  1.12379380e-01f, -9.69898999e-02f, 5.17043024e-02f, -1.13368616e-01f, 2.79085594e-03f, -4.78120036e-02f, 5.18698134e-02f, -5.27776498e-03f, 5.84132224e-02f, -1.73640475e-02f,
  -4.89726156e-01f, 4.57953438e-02f, 4.04861063e-01f, -3.24072957e-01f, -6.66451305e-02f, 3.79177958e-01f, 2.05227882e-01f, 1.63141321e-02f, -2.62951583e-01f, -1.47706687e-01f,
  -5.71026169e-02f, -1.53582796e-01f, 3.25248003e-01f, -1.88799556e-02f, 3.59826088e-01f, 2.88531423e-01f, -1.90488771e-02f, -6.56732544e-02f, -6.05316237e-02f, -1.07980721e-01f,
  -4.00740169e-02f, -1.36265427e-01f, 4.15574431e-01f, -1.99054450e-01f, -5.27445041e-02f, -1.42695710e-01f, -6.23648278e-02f, 1.68902427e-01f, -1.79012567e-01f, 4.57834005e-02f,
  -6.59305230e-02f, -2.50944853e-01f, 5.93389384e-02f, 9.08643194e-03f, -3.34831476e-02f, 4.24565263e-02f, 8.85879919e-02f, 1.30724818e-01f, 2.40769126e-02f, 6.04404323e-03f,
  -3.65153402e-02f, -2.51180027e-02f, -1.83280453e-01f, 2.42808531e-03f, -1.18402310e-01f, -2.58190800e-02f, 8.90753046e-02f, 6.60299584e-02f, 8.52981508e-02f, 1.29847243e-01f,
  1.97277725e-01f, 1.12976275e-01f, 7.86303356e-02f, -7.21519738e-02f, 6.52650297e-02f, 5.80695383e-02f, 5.65667637e-02f, 9.95841101e-02f, -4.98067923e-02f, -1.79045126e-02f,
  -7.90665206e-03f, 9.97370388e-03f, 7.69541338e-02f, -9.54930950e-03f, 1.31064691e-02f, -1.04955778e-01f, 6.08282313e-02f, 6.34590455e-04f, -9.46110394e-03f, 1.05533050e-02f,
  3.40951942e-02f, -5.70129007e-02f, -1.97447222e-02f, 6.54744431e-02f, -6.47339448e-02f, -1.23459965e-01f, 9.16107893e-02f, -5.70203140e-02f, -6.77254871e-02f, -1.16474973e-02f,
  7.38434913e-03f, 9.89971161e-02f, -6.28218353e-02f, -2.81784665e-02f, 5.20744435e-02f, 9.64038223e-02f, 7.67943822e-03f, 1.01644531e-01f, 2.79448330e-02f, 2.85351072e-02f,
  -1.16006650e-01f, -2.34369740e-01f, -1.10451160e-02f, -3.02572791e-02f, 1.99725199e-02f, 2.13155081e-03f, 3.29641439e-02f, -1.13469854e-01f, -6.98097646e-02f, -5.20379767e-02f,
  -9.87723991e-02f, -1.76647361e-02f, 1.01281740e-02f, 1.74122993e-02f, -1.68999340e-02f, -2.47194152e-03f, -5.32243960e-02f, -1.18326895e-01f, -3.35303247e-02f, -5.77836893e-02f,
  9.16529000e-02f, -8.15552995e-02f, 3.44605111e-02f, -7.22002164e-02f, -9.84621793e-02f, 1.72254499e-02f, -1.65475875e-01f, -7.76017725e-04f, -2.86304429e-02f, 2.50738282e-02f,
  -6.52307225e-03f, 1.03520051e-01f, -3.08897942e-01f, -4.20142487e-02f, -9.77411419e-02f, 1.03131942e-01f, 2.24506743e-02f, -4.58649211e-02f, -2.90831774e-01f, 2.97045380e-01f,
  3.60493183e-01f, -2.46982709e-01f, 1.87877506e-01f, 4.26142812e-01f, -1.21008098e-01f, 2.43279323e-01f, 3.27102542e-01f, 2.76693732e-01f, 5.75324707e-02f, 1.57071143e-01f,
  5.60421795e-02f, 4.10194546e-01f, 1.27901405e-01f, 1.19770981e-01f, 2.76586652e-01f, -1.15860477e-01f, 1.97691724e-01f, -1.43145114e-01f, 1.96495563e-01f, 5.19317342e-03f,
  2.11335734e-01f, 4.85982783e-02f, 6.54034093e-02f, -6.99227527e-02f, 1.02359608e-01f, 6.40881807e-02f, 7.75856944e-03f, -5.01597747e-02f, -1.01762675e-01f, -4.76693437e-02f,
  -9.42319036e-02f, -7.04870671e-02f, -7.98416734e-02f, -6.36696741e-02f, -5.24040610e-02f, -6.98558018e-02f, 2.22264063e-02f, 2.95139011e-02f, -1.28825292e-01f, 7.40439221e-02f,
  -8.64212289e-02f, 3.04835234e-02f, -1.39144165e-02f, -8.06606635e-02f, -1.37019038e-01f, -7.23269731e-02f, -4.66014370e-02f, -3.61832790e-02f, -3.22151557e-02f, -9.74717140e-02f,
  -2.00076122e-02f, 4.33266573e-02f, 1.01440594e-01f, 2.34446749e-02f, 7.47785345e-02f, 6.89882934e-02f, -1.27821164e-02f, 3.37501802e-03f, -6.10231496e-02f, 5.55411763e-02f,
  -2.81260889e-02f, -3.29910703e-02f, -3.68467458e-02f, 5.84278293e-02f, 5.75245023e-02f, -4.49281000e-03f, -3.12134009e-02f, 8.09765309e-02f, 7.91899953e-03f, 8.05245042e-02f,
  4.99786586e-02f, -5.54502271e-02f, 4.28177379e-02f, 4.75740060e-02f, 7.05062784e-03f, -2.61850338e-02f, 1.00447290e-01f, 2.96486821e-02f, -1.80311780e-02f, -3.75198051e-02f,
  1.41075432e-01f, 3.20590436e-02f, -2.62408648e-02f, -1.00993887e-01f, -1.22896163e-02f, 1.07013740e-01f, 7.66385999e-03f, -5.14342561e-02f, 1.38827553e-02f, 4.28518541e-02f,
  1.56649463e-02f, 5.02328500e-02f, -9.83359478e-03f, 5.92299625e-02f, -9.31736305e-02f, 7.36046210e-02f, -3.34180258e-02f, -8.41656476e-02f, -1.08693600e-01f, 9.91488714e-03f,
  -1.02309622e-02f, 4.90974123e-03f, -7.87567496e-02f, -2.33423226e-02f, -3.03587392e-02f, -1.80896872e-03f, -8.76471102e-02f, 7.04501523e-03f, 1.37707489e-02f, -2.51380373e-02f,
  -2.50630945e-01f, -4.93085384e-01f, 1.48957223e-01f, -5.06322272e-02f, 1.42544582e-01f, 1.61940798e-01f, 5.83705381e-02f, -1.33158728e-01f, -4.50538009e-01f, -1.57294363e-01f,
  1.04473509e-01f, -9.47764963e-02f, 1.32563636e-01f, -4.05749828e-01f, 2.20692635e-01f, -2.30724096e-01f, -1.44063324e-01f, 5.02357669e-02f, -7.19347820e-02f, 2.10380793e-01f,
  1.22602440e-01f, -1.23861827e-01f, 2.20065996e-01f, 1.26090810e-01f, 1.54369459e-01f, 2.09170982e-01f, 3.92273813e-01f, 3.40933114e-01f, 2.13227659e-01f, -2.94033419e-02f,
  -1.73859626e-01f, -2.33135968e-01f, -9.53211635e-02f, -7.09173307e-02f, 1.67129382e-01f, 1.17202580e-01f, 1.82921857e-01f, 7.49298707e-02f, -6.56673238e-02f, 1.03103794e-01f,
  6.19841889e-02f, 4.53986302e-02f, -5.32192439e-02f, 1.99273648e-03f, -1.94120873e-02f, -1.76815405e-01f, -4.08053733e-02f, 3.99532989e-02f, -4.94092777e-02f, 4.97643240e-02f,
  3.37729207e-03f, 2.82559581e-02f, 3.89378779e-02f, -7.48060569e-02f, 4.54935282e-02f, 4.66682501e-02f, 4.79835570e-02f, 2.57577896e-01f, -5.73767088e-02f, 2.47795917e-02f,
  -6.09921329e-02f, 7.60425106e-02f, 8.51672590e-02f, -7.66284913e-02f, 3.70297953e-02f, 9.38923936e-03f, -9.15725976e-02f, -9.00253952e-02f, 6.60408512e-02f, -4.82626110e-02f,
  1.73041578e-02f, 2.60043591e-02f, -2.01256618e-01f, -2.42141448e-02f, 1.07905976e-01f, -1.22209124e-01f, 2.80240197e-02f, 2.88481880e-02f, 1.07410019e-02f, 2.10815072e-02f,
  -1.10467315e-01f, 1.01826765e-01f, 1.55017823e-02f, -2.65562963e-02f, -8.77686739e-02f, 4.31884974e-02f, -4.10976820e-02f, -9.92674753e-03f, 9.37175751e-03f, 1.74134180e-01f,
  1.87897712e-01f, 1.51940212e-01f, -1.72298606e-02f, -6.74259588e-02f, -1.16010860e-01f, 2.24011745e-02f, -1.10946499e-01f, -8.53565484e-02f, 1.22432172e-01f, 6.95695961e-03f,
  1.20214395e-01f, 9.33762342e-02f, 7.37859681e-02f, -7.41387233e-02f, 6.01685010e-02f, 3.68002690e-02f, 1.00305334e-01f, 4.05077040e-02f, 5.24799228e-02f, 5.80823496e-02f,
  8.51290375e-02f, 1.49175942e-01f, 1.90203805e-02f, 4.45576794e-02f, -2.09662765e-02f, 1.89800728e-02f, 5.02912067e-02f, 6.27595186e-02f, 5.29274233e-02f, -2.70863995e-02f,
  3.66023242e-01f, -1.37978137e-01f, -5.36377802e-02f, 2.71580070e-01f, 3.36851209e-01f, 2.24876389e-01f, 1.71944603e-01f, 2.34514639e-01f, 3.29193503e-01f, -1.68237820e-01f,
  1.51554555e-01f, -1.45227894e-01f, -1.87292621e-01f, 1.30300805e-01f, 3.01996082e-01f, -4.71437611e-02f, 2.62661040e-01f, 4.91768569e-02f, 1.75808534e-01f, 1.35455981e-01f,
  1.79697484e-01f, 9.53469202e-02f, -7.49543458e-02f, -7.85951316e-02f, 4.75181900e-02f, -4.75618578e-02f, -6.73540216e-03f, -5.16956635e-02f, -4.52885106e-02f, 1.03226550e-01f,
  -2.96431053e-02f, 3.92448939e-02f, -3.66043270e-04f, -1.00222982e-01f, 3.77866924e-02f, -4.43661064e-02f, 2.44470406e-02f, -2.41612308e-02f, 3.94425727e-02f, -6.86304457e-03f,
  -1.19236492e-01f, 1.82019807e-02f, -2.37064511e-02f, -3.27923819e-02f, 6.98254183e-02f, -4.34888192e-02f, -1.00296848e-01f, -1.94248259e-02f, -8.32234044e-03f, -1.32681737e-02f,
  1.64334029e-02f, 1.63820814e-02f, 3.49866487e-02f, 6.77042699e-04f, 3.17918696e-02f, 6.51067402e-03f, 1.17062312e-02f, 9.03128088e-03f, 2.66589373e-02f, 2.79789120e-02f,
  8.53605494e-02f, -3.43612023e-02f, -9.22455192e-02f, -4.26079705e-02f, 7.50833331e-03f, -1.80868246e-02f, 6.16112016e-02f, -4.96251285e-02f, 1.51836714e-02f, 2.37209462e-02f,
  4.15647998e-02f, 7.86890015e-02f, 4.05095704e-02f, 6.97136298e-02f, 1.09594762e-01f, -1.08508272e-02f, -3.06122191e-03f, 4.94176336e-02f, 9.16273519e-02f, 7.29671866e-02f,
  -2.91390941e-02f, 3.97716165e-02f, -7.86117688e-02f, -7.17644021e-02f, -1.25083718e-02f, -6.58510029e-02f, 8.15862976e-03f, -1.41404746e-02f, -3.86421755e-03f, 5.12447432e-02f,
  9.78967473e-02f, 1.49403676e-01f, 2.08862070e-02f, -1.01039052e-01f, -2.92734317e-02f, -2.12619752e-02f, 3.54649834e-02f, 5.30023314e-02f, 9.95483175e-02f, 6.25964580e-03f,
  1.61253996e-02f, 6.40151324e-03f, -4.21974547e-02f, 1.79930571e-02f, -2.59747393e-02f, -5.34131378e-02f, -1.14572629e-01f, 4.96594571e-02f, 9.24588963e-02f, -4.82921908e-03f,
  -1.25559894e-02f, 9.61739570e-02f, -3.17149535e-02f, 8.49427804e-02f, -8.52426514e-02f, 5.44312373e-02f, 4.59418744e-02f, 7.11132598e-05f, -3.39870639e-02f, -1.79619621e-02f,
  3.48750204e-01f, 2.20897928e-01f, 1.15161285e-01f, 3.25733185e-01f, 8.02414417e-02f, 1.52258843e-01f, 4.78479192e-02f, 1.82413161e-01f, 5.03572285e-01f, -3.42208780e-02f,
  -1.64984584e-01f, 2.22334921e-01f, -2.55756319e-01f, 1.14977077e-01f, -2.48763815e-01f, -1.55541614e-01f, 2.39341080e-01f, 1.41346797e-01f, 1.83226690e-01f, 1.29655957e-01f,
  5.70981503e-02f, -1.50108010e-01f, -1.99691251e-01f, -6.94833547e-02f, 6.24094456e-02f, 1.11465320e-01f, -3.72015536e-01f, -1.63742065e-01f, -1.92361951e-01f, -1.38518393e-01f,
  -3.14379260e-02f, 9.76867378e-02f, -7.91716948e-02f, -9.08926353e-02f, 5.68379462e-02f, 9.23680961e-02f, -3.68558764e-02f, -1.33866891e-01f, -5.04817851e-02f, -2.20771860e-02f,
  7.47708976e-02f, -4.37053628e-02f, 1.11604325e-01f, -1.89694002e-01f, 8.14716071e-02f, -2.86282580e-02f, 1.10744433e-02f, 7.47169927e-02f, 5.36812879e-02f, -1.71460789e-02f,
  9.09257233e-02f, 9.30730626e-02f, 7.37463608e-02f, -3.03644799e-02f, 2.61372235e-02f, -4.10610884e-02f, 5.17667830e-03f, -4.14536223e-02f, -5.60420416e-02f, 6.16996363e-02f,
  -3.97673715e-03f, -1.19366264e-03f, -6.50425255e-02f, -1.08673712e-02f, 1.38124377e-02f, 2.93973666e-02f, 2.48875096e-02f, -2.68151350e-02f, 9.23661292e-02f, -7.18603954e-02f,
  4.78686392e-02f, -4.17696089e-02f, 7.75750130e-02f, 9.79610020e-04f, 5.81595227e-02f, 1.46143049e-01f, 4.40992936e-02f, -1.40517717e-03f, 5.46633229e-02f, 9.34720598e-03f,
  -2.12989538e-03f, 4.43141274e-02f, -1.35594144e-01f, 2.88746729e-02f, 5.39988615e-02f, -2.54498590e-02f, -3.42669599e-02f, 7.77328610e-02f, -1.77422687e-02f, -2.34132428e-02f,
  5.42807430e-02f, 1.58542350e-01f, -2.55970377e-02f, -1.18053064e-01f, -3.55022512e-02f, -4.59371787e-03f, 1.00690909e-01f, 6.13281280e-02f, 1.82618015e-02f, 7.08071096e-03f,
  1.75286140e-02f, 1.14288338e-01f, 5.85539378e-02f, -5.19995242e-02f, -5.02744466e-02f, -1.18103847e-01f, -1.11580633e-01f, 8.67709816e-02f, 4.29520942e-02f, -6.48250952e-02f,
  2.01887800e-03f, 1.08797662e-01f, 4.52515446e-02f, 2.96866447e-02f, 2.73312703e-02f, -5.87504245e-02f, 1.10888228e-01f, -5.56808189e-02f, -7.43320510e-02f, -2.09736675e-02f,
  -4.47241366e-01f, 3.07149112e-01f, -1.18416548e-01f, 6.63122982e-02f, -5.10394514e-01f, -3.04666877e-01f, -4.68261279e-02f, -3.89285684e-02f, 1.83261082e-01f, 5.45358717e-01f,
  1.06079774e-02f, 3.49147677e-01f, 2.83815712e-01f, 8.77400711e-02f, -4.38733786e-01f, 3.84375036e-01f, -1.54517069e-01f, 1.32278323e-01f, -5.70094725e-03f, -1.50414139e-01f,
  -2.15364665e-01f, -1.64004445e-01f, -2.10314006e-01f, -5.72489239e-02f, -3.16382885e-01f, -7.67077655e-02f, -2.86940098e-01f, -1.28465652e-01f, -2.29344413e-01f, -2.05443412e-01f,
  -2.71747053e-01f, 1.86847538e-01f, 8.46175402e-02f, 3.35581265e-02f, -1.94838196e-01f, -8.02361220e-02f, -5.99541962e-02f, 4.79279310e-02f, -2.99708862e-02f, 1.06684834e-01f,
  8.00171494e-02f, 6.44719154e-02f, -3.32552083e-02f, 8.45045745e-02f, -2.22129691e-02f, -2.18141321e-02f, -7.15654194e-02f, -9.76030380e-02f, 1.03999991e-02f, -4.22217995e-02f,
  1.01302288e-01f, -3.16384505e-03f, -4.04787697e-02f, -2.75273997e-05f, -1.34886727e-01f, -4.26843874e-02f, -7.39526823e-02f, -4.18754183e-02f, -4.38010246e-02f, -1.64670318e-01f,
  4.54905219e-02f, 9.05918365e-04f, 1.31776601e-01f, 5.47420159e-02f, 5.00946753e-02f, -3.98146845e-02f, 3.72078232e-02f, -7.48564005e-02f, -1.68639533e-02f, -1.04204021e-01f,
  -4.01060171e-02f, -3.80028151e-02f, -6.39203414e-02f, -3.68946306e-02f, 2.20679305e-02f, 7.68289790e-02f, 3.33885178e-02f, 4.17690761e-02f, -2.74509173e-02f, -1.83876716e-02f,
  2.93396581e-02f, -4.47892100e-02f, 1.73875000e-02f, -3.59490775e-02f, 2.80294307e-02f, -6.30797222e-02f, -3.44934538e-02f, 9.97446775e-02f, 3.43698971e-02f, -1.78989023e-01f,
  -4.23401147e-01f, -1.83686391e-01f, 1.02746338e-01f, 1.27585635e-01f, 6.41808510e-02f, 8.57962295e-03f, 1.13106379e-02f, 2.60251784e-03f, -1.43644214e-01f, 1.22853518e-02f,
  -6.97718039e-02f, 1.31207496e-01f, -1.47367209e-01f, 5.38728237e-02f, 5.88761978e-02f, -7.00001568e-02f, -3.24048623e-02f, -4.70089018e-02f, -1.57793924e-01f, -1.23227596e-01f,
  -1.86902862e-02f, -8.11673875e-04f, 5.52352592e-02f, 1.22523950e-02f, 7.24052414e-02f, -1.81661099e-02f, -1.12324722e-01f, 8.74251053e-02f, -1.71368331e-01f, -1.19510042e-02f,
  2.84868032e-01f, -6.98977858e-02f, 1.17310852e-01f, 3.69430244e-01f, 1.57901824e-01f, -1.50943786e-01f, 6.35329783e-02f, 1.08927593e-01f, 2.45074987e-01f, -8.89462009e-02f,
  -7.76500255e-03f, -2.12608412e-01f, -1.36822715e-01f, -1.16157942e-01f, -2.63799757e-01f, -3.27105612e-01f, 4.51232158e-02f, -9.30127352e-02f, 5.52825667e-02f, 2.08435044e-01f,
  1.65878206e-01f, -1.54103026e-01f, -3.01144775e-02f, -6.62785098e-02f, 1.73832282e-01f, 2.97795832e-01f, 2.32729197e-01f, 4.49896604e-03f, 7.11211637e-02f, -2.43241876e-01f,
  -9.12253857e-02f, -5.98222427e-02f, 8.00907984e-02f, -1.33294174e-02f, 1.34117544e-01f, 4.00694320e-03f, -4.01898175e-02f, -1.65724188e-01f, 4.70771361e-03f, -2.76979525e-03f,
  2.88820844e-02f, -1.13143444e-01f, -3.90131883e-02f, -8.01597312e-02f, 5.99754378e-02f, 6.03114590e-02f, -2.88370065e-02f, 1.00082055e-01f, -8.97975117e-02f, -4.42274623e-02f,
  6.52038828e-02f, -2.82622520e-02f, 1.27560839e-01f, -1.10254399e-01f, 1.20013259e-01f, -2.22216058e-03f, 1.59350000e-02f, 3.00992243e-02f, 1.05698705e-01f, -7.19508389e-03f,
  -9.23918188e-02f, 4.99576032e-02f, -3.09024211e-02f, 4.35053778e-04f, -3.16537693e-02f, 2.45476197e-02f, -4.55663055e-02f, -6.44281730e-02f, 1.51055917e-01f, 7.81622808e-03f,
  1.08965799e-01f, 1.36667481e-02f, 3.38022411e-02f, 5.69720678e-02f, 3.67530473e-02f, -1.39066270e-02f, -8.74609724e-02f, -2.15133335e-02f, 1.47135735e-01f, 2.34804954e-02f,
  -9.03510153e-02f, 2.32163109e-02f, -2.82088369e-02f, -1.62465218e-02f, -1.23377154e-02f, 2.61952691e-02f, 3.19158891e-03f, 4.32726890e-02f, 6.39382452e-02f, 3.77789326e-03f,
  5.88745661e-02f, 3.48909721e-02f, 3.70057449e-02f, -6.72293007e-02f, 2.13368679e-03f, 3.94100845e-02f, -1.05261140e-01f, -2.23955270e-02f, -1.04516268e-01f, -1.86770167e-02f,
  9.15682912e-02f, 8.33331645e-02f, 3.01121920e-02f, -3.98234762e-02f, -9.32128727e-02f, 6.49991259e-02f, 4.67718802e-02f, 4.47188988e-02f, 9.23781842e-02f, 1.03014559e-01f,
  1.41547173e-01f, 5.02950065e-02f, 4.41220477e-02f, 9.76461545e-02f, 5.84447011e-02f, -4.82319333e-02f, 2.56795362e-02f, -7.63563532e-03f, 6.58826828e-02f, -9.35946405e-03f,
  -4.60718721e-01f, 1.13288984e-01f, -3.80371451e-01f, -2.85604578e-02f, 7.30354488e-02f, -4.81519431e-01f, 1.67775415e-02f, 5.51997349e-02f, 2.15912890e-02f, 2.81969935e-01f,
  2.35632792e-01f, -6.32694457e-03f, 3.92682761e-01f, -1.93218872e-01f, -5.69516301e-01f, -5.83804063e-02f, -2.74874806e-01f, -1.60474509e-01f, -3.25271226e-02f, 2.13912398e-01f,
  -1.29017100e-01f, 2.05677062e-01f, -2.06714734e-01f, 3.77499998e-01f, -6.58041760e-02f, 5.05891554e-02f, 2.06348300e-01f, 9.60531309e-02f, -1.75608546e-01f, -7.97882900e-02f,
  -1.09430790e-01f, 1.54539779e-01f, -3.32197696e-02f, -5.93813881e-02f, -4.77869213e-02f, 1.12158814e-02f, -4.44091782e-02f, -2.32889969e-02f, -3.16488673e-03f, -1.61331554e-03f,
  4.44561243e-03f, -2.55262759e-03f, 1.37279062e-02f, 5.41467518e-02f, -1.92509219e-02f, -5.05964330e-04f, -1.47138104e-01f, -2.13798717e-01f, 1.03804678e-01f, -1.93403557e-01f,
  -1.40767068e-01f, -2.83157472e-02f, -1.14625014e-01f, 2.55197845e-02f, -1.01016335e-01f, 3.86663079e-02f, -1.14893831e-01f, -9.42352861e-02f, -7.65410289e-02f, -3.45874727e-02f,
  -5.17260320e-02f, 1.31135702e-01f, 5.70319854e-02f, 3.58031504e-02f, 4.31414098e-02f, -1.93114337e-02f, 1.28960963e-02f, 7.32245892e-02f, 7.51652569e-02f, 2.13939492e-02f,
  1.08864471e-01f, 5.18032163e-02f, 2.72913482e-02f, -1.26737162e-01f, 3.82922888e-02f, 1.17311878e-02f, -1.13420943e-02f, -9.42833722e-03f, -4.50047059e-03f, -7.76039064e-02f,
  1.62274063e-01f, -5.78164048e-02f, 3.69969569e-02f, 6.49054721e-02f, -1.60706025e-02f, 3.82341594e-02f, 1.25020057e-01f, -1.04896121e-01f, -2.58685872e-02f, -2.01523546e-02f,
  1.38388248e-02f, 2.40035310e-01f, 9.17108282e-02f, 6.77280948e-02f, 8.95559490e-02f, -4.69160303e-02f, -8.67355093e-02f, -2.17419062e-02f, -8.48358963e-03f, 1.45755410e-01f,
  5.40920626e-03f, -6.50330335e-02f, 2.24243850e-02f, 3.69434878e-02f, -1.79482214e-02f, -9.95732173e-02f, 3.69668789e-02f, 1.05057485e-01f, 1.21659458e-01f, -5.14673349e-03f,
  8.24262276e-02f, 1.85030565e-01f, 1.54601336e-01f, 8.74014497e-02f, 1.83398779e-02f, 4.45900783e-02f, 1.03267571e-02f, -7.12891594e-02f, 2.06073429e-02f, 1.86844505e-02f,
  -3.85098457e-01f, 3.43346149e-01f, -1.38193756e-01f, -4.70062941e-01f, 2.17282120e-02f, -7.27448165e-02f, -4.16985005e-01f, 1.41132120e-02f, -1.49638727e-01f, -1.05685212e-01f,
  -2.01657861e-01f, -6.92295432e-02f, 7.09876344e-02f, -3.62507015e-01f, 1.13152355e-01f, 2.08867073e-01f, -3.12819153e-01f, -3.18983614e-01f, 2.46566236e-01f, -1.31128147e-01f,
  1.03854112e-01f, -1.46500483e-01f, -2.68156808e-02f, 2.30355397e-01f, -1.11106597e-01f, 2.34493669e-02f, 3.94672267e-02f, 1.31793618e-01f, -1.32534310e-01f, 1.10372975e-01f,
  -1.22175142e-01f, -3.27268988e-01f, -2.53860503e-01f, -1.11164182e-01f, -4.12103236e-02f, -2.42930371e-02f, -2.91844122e-02f, -3.85336839e-02f, 1.33779347e-02f, -1.78866982e-02f,
  -2.34103780e-02f, 1.07539378e-01f, 1.83958858e-02f, 4.78191581e-03f, -3.37369144e-02f, 1.01801995e-02f, 9.26295072e-02f, -7.64975175e-02f, 5.83969010e-03f, 1.33374348e-01f,
  2.03671772e-02f, 1.85509641e-02f, -5.22572435e-02f, 1.34689799e-02f, -1.97284352e-02f, 3.89861688e-02f, -1.04668371e-01f, -1.88609567e-02f, 1.02972634e-01f, -7.41672292e-02f,
  6.84079388e-03f, -1.91986542e-02f, -6.38179332e-02f, 2.99203098e-02f, -1.30804062e-01f, -2.97573488e-02f, -6.21813573e-02f, -4.20806035e-02f, 1.09696873e-02f, -1.19916834e-02f,
  -1.35414097e-02f, -4.86082919e-02f, 4.59894985e-02f, -3.60533483e-02f, -8.05194378e-02f, -1.38560474e-01f, -1.43151805e-02f, 5.13286516e-03f, 7.58856088e-02f, -4.94404249e-02f,
  -4.26043086e-02f, 1.92896777e-03f, -4.88999337e-02f, 6.38546795e-02f, -7.98418000e-02f, 9.50094387e-02f, 5.02747968e-02f, 2.92628612e-02f, 5.19408733e-02f, 6.18158504e-02f,
  -1.39293060e-01f, -2.45640412e-01f, -4.72391434e-02f, -7.78970793e-02f, -4.23227623e-02f, -3.68649047e-03f, -3.87754403e-02f, 8.89878422e-02f, -5.65733872e-02f, -4.33813594e-02f,
  2.13137064e-02f, -7.63048828e-02f, 9.37234685e-02f, 2.40729167e-03f, -1.23287085e-02f, 5.18214814e-02f, -1.16879411e-01f, -7.06884935e-02f, -8.30366164e-02f, 8.82955492e-02f,
  -1.45219788e-02f, 1.31773958e-02f, -1.08904522e-02f, 4.40028757e-02f, -5.10215648e-02f, -3.19784135e-02f, -4.48107980e-02f, 3.05911582e-02f, 9.00548622e-02f, 5.31195961e-02f,
  -5.93272857e-02f, 4.21183437e-01f, -1.72421619e-01f, 1.85477763e-01f, -2.80488402e-01f, -4.77788150e-02f, 2.27020591e-01f, 6.39012903e-02f, 2.40915939e-01f, 3.51178110e-01f,
  3.90133224e-02f, 2.53658205e-01f, 1.94497228e-01f, 2.13547722e-01f, -3.83950882e-02f, 1.31277427e-01f, 2.60957599e-01f, 1.54035866e-01f, 1.02807730e-01f, 1.04669489e-01f,
  5.86720780e-02f, 3.42466146e-01f, -4.67268657e-03f, 2.48156190e-02f, 8.69120704e-04f, -6.97615370e-02f, 9.51327458e-02f, -1.69137999e-01f, -5.84173203e-02f, -5.89352548e-02f,
  1.18208872e-02f, 1.41519949e-01f, -1.05369531e-01f, -4.19420563e-03f, -1.32114738e-02f, -1.73118815e-01f, -6.35016263e-02f, -9.28466097e-02f, -1.00520484e-01f, 1.84515733e-02f,
  2.93449890e-02f, -2.11061407e-02f, 1.36337057e-01f, 2.79590674e-02f, -1.36809256e-02f, -7.40145519e-02f, -1.17716761e-02f, -1.14744790e-01f, 8.08021650e-02f, -2.98614856e-02f,
  -6.05040938e-02f, -4.52851020e-02f, -9.52393785e-02f, 1.03364684e-01f, -5.78826368e-02f, 5.32312244e-02f, 2.02141814e-02f, -3.58091667e-02f, 3.79950106e-02f, 5.43295331e-02f,
  6.22742251e-02f, 2.74755452e-02f, 2.12585498e-02f, -3.73523571e-02f, -5.03407698e-03f, -1.07130252e-01f, 6.17107712e-02f, 2.91787181e-02f, -9.82414372e-03f, -1.94203912e-03f,
  -6.68994710e-02f, 1.71288429e-03f, 8.71159229e-03f, 8.85148644e-02f, 5.94627187e-02f, 8.26953948e-02f, -9.96592045e-02f, 8.33024979e-02f, -7.08394721e-02f, -7.93977007e-02f,
  8.04296881e-02f, 4.57155518e-02f, 1.95105579e-02f, -1.40261978e-01f, 3.50115374e-02f, 7.24640191e-02f, 1.27651453e-01f, 4.84936498e-03f, -4.11315039e-02f, -3.75086330e-02f,
  2.20730752e-01f, 3.98178548e-01f, 1.70437489e-02f, -2.48978510e-02f, -1.91560667e-02f, -3.42525467e-02f, 5.26027344e-02f, -4.75260876e-02f, 1.35083780e-01f, 4.33414094e-02f,
  2.77033467e-02f, -5.33010066e-02f, -4.40182760e-02f, -4.32714932e-02f, -4.72641252e-02f, 1.24935955e-01f, 1.67499527e-01f, 3.08773620e-03f, 4.73328754e-02f, 8.07643309e-02f,
  -4.16466733e-03f, 1.02622613e-01f, -4.23915721e-02f, 1.00077027e-02f, 1.44144772e-02f, 3.91840450e-02f, 4.41315882e-02f, -4.95861694e-02f, 4.19482961e-02f, 8.77319574e-02f,
  5.25036514e-01f, -4.89921086e-02f, 2.53335506e-01f, 4.08032864e-01f, 8.79802555e-02f, 6.61110645e-03f, 2.78474867e-01f, -3.99320945e-02f, 3.91317606e-01f, -1.96954727e-01f,
  -1.93374425e-01f, 3.52817416e-01f, -1.00716904e-01f, -1.03067504e-02f, -1.16828337e-01f, -1.36445254e-01f, 1.03891708e-01f, 2.11964443e-01f, 1.11793406e-01f, 9.36651230e-02f,
  9.96046141e-02f, -3.19086373e-01f, -1.49106723e-03f, -2.92283297e-01f, 1.67145371e-01f, 1.28225729e-01f, -3.46699089e-01f, -3.29761170e-02f, -1.18508138e-01f, -4.86121736e-02f,
  3.85307558e-02f, 2.66770329e-02f, 8.62901881e-02f, -2.46668495e-02f, 6.83405250e-02f, 2.75555346e-02f, 4.21423763e-02f, 1.04901120e-02f, 3.49433646e-02f, 2.78830510e-02f,
  8.14458430e-02f, -3.41668874e-02f, -5.86620606e-02f, -4.33253981e-02f, 1.17709018e-01f, 3.77907194e-02f, 5.08479588e-02f, 1.07375719e-01f, 2.11390834e-02f, 1.56425506e-01f,
  1.49679467e-01f, 1.39402285e-01f, -2.12448798e-02f, -6.30530119e-02f, -5.50918980e-03f, 1.40641471e-02f, 5.72537929e-02f, 1.15962594e-03f, 4.82046828e-02f, 1.00793689e-01f,
  -8.87466669e-02f, -2.88029499e-02f, -5.61133623e-02f, 3.28777209e-02f, -2.43203808e-02f, -2.55945679e-02f, 1.52104050e-02f, -6.34549782e-02f, -3.28659788e-02f, -3.55939679e-02f,
  7.15322210e-04f, 4.95920330e-02f, -1.41365360e-02f, 1.46873698e-01f, 9.65591520e-03f, 9.30599570e-02f, -1.85497329e-02f, 8.83996580e-03f, 8.13506469e-02f, 8.74256939e-02f,
  -5.30891344e-02f, -6.53523766e-03f, 3.00296675e-02f, 5.27594276e-02f, -3.13755535e-02f, -1.44406976e-02f, -3.12299095e-02f, 8.94028619e-02f, 2.17012987e-02f, -1.12595335e-01f,
  -2.06052780e-01f, -3.04808110e-01f, -8.16829652e-02f, 2.61070561e-02f, -3.50128151e-02f, -3.77221666e-02f, -4.44753058e-02f, 5.59890717e-02f, -6.02812953e-02f, -4.75063697e-02f,
  2.68861763e-02f, 8.72316882e-02f, -6.20355597e-03f, 2.92907506e-02f, -9.75421220e-02f, -8.64247307e-02f, 7.33767897e-02f, -4.35810760e-02f, -6.07631877e-02f, -1.28258497e-01f,
  1.81975812e-02f, -4.31631207e-02f, -1.15785919e-01f, 3.48946154e-02f, -2.24259347e-02f, -4.85863449e-04f, 4.64693159e-02f, -1.72648076e-02f, -2.65832506e-02f, -7.71426223e-03f,
  2.76162803e-01f, 1.57871693e-01f, -1.05817609e-01f, 4.06953484e-01f, -5.58949374e-02f, -2.31400996e-01f, 2.51004770e-02f, -5.43934777e-02f, 1.01072252e-01f, 9.26968008e-02f,
  4.68668640e-01f, -3.71740997e-01f, 1.76600024e-01f, 5.11131227e-01f, -1.87030137e-02f, 3.47997248e-01f, 2.33956456e-01f, 3.98819186e-02f, -1.05413303e-01f, 1.66717142e-01f,
  6.06143363e-02f, 3.68078679e-01f, 2.42470548e-01f, -1.42873004e-01f, 1.87666282e-01f, -1.03355885e-01f, 1.21120714e-01f, -3.06008309e-01f, -1.29706478e-02f, -2.08578870e-01f,
  1.68912798e-01f, 3.38589221e-01f, 7.21109360e-02f, -9.39662829e-02f, 1.57616362e-01f, 4.01211753e-02f, -1.36200204e-01f, -1.62603870e-01f, -1.31226197e-01f, -2.42928863e-02f,
  -3.27864476e-02f, -3.76196653e-02f, -3.30840014e-02f, -5.21782227e-02f, 3.38686071e-02f, -4.19666395e-02f, 1.03613555e-01f, -1.50452731e-02f, -6.92781359e-02f, 9.34400484e-02f,
  1.34520054e-01f, 1.03935502e-01f, 1.14908859e-01f, 4.93674055e-02f, -9.49116051e-03f, 3.86799015e-02f, -8.09155181e-02f, -8.50246176e-02f, -1.00965528e-02f, -2.18477044e-02f,
  1.38903897e-05f, -4.92477641e-02f, 9.04096961e-02f, 5.36535047e-02f, 6.86920509e-02f, 1.52649447e-01f, -2.27355305e-02f, -6.72189817e-02f, -2.58800983e-02f, 7.02156201e-02f,
  -2.35096030e-02f, 2.17637867e-02f, 9.54747945e-02f, -1.05618507e-01f, 5.34008518e-02f, -6.09741732e-03f, -7.97138065e-02f, 3.31650414e-02f, 4.92440350e-02f, 5.76876849e-03f,
  -6.40804917e-02f, 2.19748951e-02f, 7.05874488e-02f, -4.86423597e-02f, -5.33055216e-02f, -3.69326398e-03f, 6.80556148e-02f, 8.73077437e-02f, -3.08682374e-03f, 6.27668016e-03f,
  3.48191475e-03f, 1.54988587e-01f, -1.03558553e-02f, -1.69714734e-01f, 6.71381503e-03f, 7.42221549e-02f, -3.16561386e-02f, -2.87732501e-02f, -9.39271748e-02f, 2.22461647e-03f,
  -4.16803174e-02f, -5.01217134e-02f, -1.94081757e-03f, -1.47580793e-02f, -7.39613548e-02f, 1.10026151e-01f, 4.38184850e-02f, -5.85427396e-02f, -4.07528579e-02f, -1.82907674e-02f,
  8.80981144e-03f, 4.04238254e-02f, -4.28640805e-02f, -5.06153479e-02f, -2.42780186e-02f, 4.33693528e-02f, -1.41374066e-01f, 4.95665781e-02f, 3.89158390e-02f, 1.07599599e-02f,
  -7.09609315e-02f, 3.22858602e-01f, 3.45940441e-01f, 1.19649768e-01f, -3.33907872e-01f, -3.71462435e-01f, -3.77366722e-01f, 9.77667645e-02f, 1.22298382e-01f, -1.48776606e-01f,
  -2.69345373e-01f, 3.16322654e-01f, -6.64707040e-03f, 3.25288028e-02f, 9.57324132e-02f, 7.51613900e-02f, 1.99109197e-01f, 7.52484575e-02f, 1.05605997e-01f, 1.51478991e-01f,
  2.20624864e-01f, -2.64864713e-01f, 2.96462864e-01f, -1.10711277e-01f, 5.82826212e-02f, 2.51459628e-01f, 9.85032097e-02f, 5.07710129e-02f, 9.34175402e-02f, -1.08282737e-01f,
  -5.82388565e-02f, 3.77493501e-02f, 5.55428416e-02f, 1.98034212e-01f, 1.13100216e-01f, -6.29346967e-02f, 6.45301342e-02f, -4.10767309e-02f, -5.32890223e-02f, 3.39964889e-02f,
  -1.82005558e-02f, 9.22136307e-02f, 9.99463815e-03f, -1.10886939e-01f, -8.70733336e-02f, 1.15610786e-01f, 2.14041039e-01f, 1.28410071e-01f, 1.33326381e-01f, 9.56994854e-03f,
  1.50866762e-01f, 1.12153895e-01f, 6.75468966e-02f, 2.65284121e-01f, 2.30169654e-01f, -3.08423257e-03f, -4.08107452e-02f, 1.16899185e-01f, 3.64510156e-02f, 4.01855260e-03f,
  -4.79371063e-02f, -4.61346097e-02f, -7.72784352e-02f, -6.38568848e-02f, -8.96048024e-02f, -1.28903449e-01f, -4.29874882e-02f, -1.25650391e-01f, 3.47199142e-02f, -6.66377619e-02f,
  4.65274490e-02f, 2.63625253e-02f, -8.81744474e-02f, -6.96593570e-03f, -1.85103372e-01f, -1.09400608e-01f, 8.58840942e-02f, -2.08893493e-02f, 7.89920241e-02f, 4.05181833e-02f,
  -7.09007680e-03f, -7.48325437e-02f, -4.51387577e-02f, -7.54398033e-02f, -1.20449483e-01f, 6.57926127e-02f, 1.74384192e-01f, -5.95915094e-02f, -7.88266808e-02f, 8.62048194e-02f,
  9.96747836e-02f, 3.20614815e-01f, 1.29414991e-01f, 3.28877941e-02f, 8.32279846e-02f, -3.67228575e-02f, 4.91113588e-02f, 7.69053623e-02f, 1.17839381e-01f, -3.00879627e-02f,
  -1.31179215e-02f, 9.92863029e-02f, 3.78280915e-02f, -9.32632536e-02f, 5.71538210e-02f, 8.92321393e-02f, 9.06025842e-02f, 1.42032534e-01f, 1.19557150e-01f, 1.15024880e-01f,
  3.26493522e-03f, -9.48074982e-02f, -3.53273824e-02f, 1.58976585e-01f, -2.75237691e-02f, 5.54385595e-02f, -2.82291174e-02f, 1.38425797e-01f, -2.69676070e-03f, 7.13347346e-02f,
  5.89950234e-02f, 8.58422369e-02f, 5.30522205e-02f, 3.45996946e-01f, 7.10634515e-02f, -3.90813231e-01f, -1.07013350e-02f, 1.81878641e-01f, 2.49474570e-01f, 6.99233916e-03f,
  4.92203608e-02f, -3.32048774e-01f, -2.11298075e-02f, -4.47080024e-02f, -3.82687658e-01f, -1.93941668e-01f, -2.85181850e-01f, -2.84211367e-01f, -5.25607057e-02f, -1.10370830e-01f,
  -3.17324176e-02f, 1.97412133e-01f, 7.86862150e-02f, 3.05776089e-01f, 2.74935275e-01f, 2.00518444e-01f, 1.86597779e-01f, 1.15507551e-01f, -1.98922288e-02f, -1.83932543e-01f,
  -1.88153818e-01f, 2.70782501e-01f, 9.98408869e-02f, -4.28416170e-02f, 1.31092127e-02f, -8.57399926e-02f, -9.08577591e-02f, 6.08085133e-02f, 9.71103832e-03f, -2.40370501e-02f,
  -9.42184255e-02f, 5.58290519e-02f, -1.07500851e-02f, 6.19381927e-02f, 3.39819537e-03f, -1.05033899e-02f, 3.27094197e-02f, 8.75677913e-02f, -6.88952133e-02f, -2.60400809e-02f,
  9.61441174e-02f, -9.41250771e-02f, -7.56494701e-02f, -1.02480769e-01f, -3.02884802e-02f, -1.69644821e-02f, -3.61921936e-02f, -6.09008670e-02f, -8.33286345e-03f, 6.81366101e-02f,
  1.52323127e-01f, 2.52028294e-02f, 2.20302120e-03f, 6.70155063e-02f, 1.62643399e-02f, 1.42386286e-02f, 5.64231575e-02f, -1.20005250e-01f, -6.95351437e-02f, -1.33035973e-01f,
  9.72167309e-03f, 2.63705552e-02f, -7.65374047e-04f, 1.87933519e-02f, -1.09731988e-03f, 1.25156298e-01f, 2.17703637e-02f, -6.35504201e-02f, -1.36525296e-02f, 8.27834606e-02f,
  3.05931736e-02f, -1.11171365e-01f, 4.36734930e-02f, -1.16310701e-01f, -5.97531162e-02f, 1.46092027e-01f, 3.57507472e-03f, -3.74761969e-02f, -5.20932078e-02f, -1.24088630e-01f,
  -2.52130628e-01f, 7.03863502e-02f, 4.70565632e-02f, -2.67856698e-02f, -9.76622570e-03f, -1.20234199e-01f, -1.22346189e-02f, -5.43180965e-02f, -7.26527488e-03f, 4.77394368e-03f,
  -9.39564928e-02f, -7.07633747e-03f, -7.20288754e-02f, -5.83301410e-02f, -1.38793560e-03f, 2.34020278e-02f, 1.10934041e-02f, 5.66431470e-02f, 1.67516712e-02f, 2.90724225e-02f,
  1.07483149e-01f, -3.89515050e-02f, 1.40871983e-02f, 5.93740232e-02f, -2.36921236e-02f, -6.15122309e-03f, -1.81536023e-02f, 2.26563346e-02f, 3.72372791e-02f, -1.34905711e-01f,
  -3.03079724e-01f, -2.14496076e-01f, -1.31953567e-01f, 3.74180973e-02f, -2.06785835e-02f, -2.51701772e-01f, -2.32533306e-01f, -3.30689967e-01f, 8.05510860e-03f, -7.52364621e-02f,
  -2.33896762e-01f, -1.29335225e-02f, -4.32727218e-01f, -1.42360792e-01f, 8.43325704e-02f, -1.76677004e-01f, 2.01822251e-01f, 7.00941368e-04f, -1.46145988e-02f, 3.78214754e-02f,
  1.57169119e-01f, 5.33147007e-02f, -1.64750531e-01f, 8.70496407e-02f, -1.56138957e-01f, 2.12936550e-01f, 4.31856573e-01f, -6.03722222e-02f, 2.24641666e-01f, 1.40224561e-01f,
  -1.54689401e-01f, -1.73765078e-01f, -7.28819286e-03f, 1.41865268e-01f, 7.16184974e-02f, -7.04345803e-05f, 8.99023563e-02f, -1.17931906e-02f, -4.78693284e-02f, 6.83288835e-03f,
  1.69756059e-02f, 1.07316978e-01f, 5.41528054e-02f, 4.57418598e-02f, -3.97265963e-02f, 3.37595381e-02f, 6.91981241e-02f, -2.03639865e-02f, -9.34957415e-02f, -3.25397812e-02f,
  -4.81450632e-02f, -5.89689240e-02f, 4.63450179e-02f, 1.29569322e-01f, 5.11245988e-02f, 7.58474469e-02f, 1.28474832e-01f, 2.66704708e-02f, 1.59966305e-01f, -1.66120343e-02f,
  7.14204237e-02f, -4.07558791e-02f, -3.89542244e-02f, -1.72366537e-02f, 2.50727795e-02f, 5.54722175e-02f, 8.90309587e-02f, 2.36137025e-02f, 4.28749658e-02f, 9.35776457e-02f,
  1.37300491e-01f, -1.18133903e-01f, 6.42013252e-02f, 2.33265534e-02f, -7.57086650e-02f, -2.36538406e-02f, -4.83121723e-02f, -6.14789722e-04f, 1.29779294e-01f, -1.24457359e-01f,
  -1.97721779e-01f, 1.96302086e-02f, -2.97291446e-02f, -1.50279418e-01f, -1.65641204e-01f, -5.53199537e-02f, -6.00473620e-02f, -1.29612043e-01f, -4.24026437e-02f, -3.24842557e-02f,
  1.72956303e-01f, 3.34953547e-01f, -3.55096022e-03f, 9.57948565e-02f, 2.57651391e-03f, -1.10809959e-01f, -2.73268577e-02f, 4.30476815e-02f, 5.65660521e-02f, -3.91629823e-02f,
  8.42161998e-02f, 1.18927501e-01f, 8.19676295e-02f, 4.64430563e-02f, 1.17557943e-01f, -2.61022970e-02f, 1.82735816e-01f, 1.09233662e-01f, 1.81670919e-01f, 2.59702490e-03f,
  2.45825537e-02f, -2.45494526e-02f, 6.87002167e-02f, 1.01936616e-01f, 5.18747866e-02f, 1.78793650e-02f, -5.31798527e-02f, -3.62362638e-02f, 1.26339957e-01f, 5.85892089e-02f,
  -2.81197339e-01f, 4.46393460e-01f, 3.38101447e-01f, -3.59397173e-01f, 2.12425575e-01f, 8.99836943e-02f, -1.00129463e-01f, 2.08310470e-01f, 1.46785975e-02f, 1.39570996e-01f,
  -3.23319167e-01f, 5.23025282e-02f, 6.59208745e-02f, -1.70153692e-01f, -3.60733658e-01f, -2.43266329e-01f, -3.04829121e-01f, -2.32249469e-01f, 1.00293942e-01f, -1.50352910e-01f,
  -1.66869581e-01f, -3.09632063e-01f, 4.36508581e-02f, 2.34774128e-01f, 1.57413334e-01f, 2.32971773e-01f, -2.64627069e-01f, 3.43122780e-01f, -3.62021551e-02f, 4.22780327e-02f,
  4.43714075e-02f, 1.39770173e-02f, 2.31186628e-01f, 1.62422940e-01f, -4.58071642e-02f, 2.52067465e-02f, 9.41044278e-03f, 8.69225264e-02f, -2.89917272e-02f, 9.84593704e-02f,
  4.12942432e-02f, 1.81598544e-01f, -2.42690388e-02f, 5.53059354e-02f, 1.49636105e-01f, 1.03194371e-01f, 7.63355047e-02f, 5.93181364e-02f, 1.80387169e-01f, 5.09667173e-02f,
  -1.32276947e-02f, 1.00833349e-01f, -1.42246578e-02f, -8.90031159e-02f, 5.32156341e-02f, 1.69636179e-02f, -2.10489538e-02f, -2.87157274e-03f, 3.98616157e-02f, 8.33083838e-02f,
  -1.72736589e-02f, -1.21019132e-01f, 1.18666515e-02f, 8.51421133e-02f, -3.98140885e-02f, 7.84838572e-02f, -4.21140902e-02f, 7.20338523e-03f, 3.52068804e-02f, 2.02225707e-02f,
  -8.75359327e-02f, 1.98707394e-02f, 1.84671418e-03f, -4.55611199e-02f, -6.80694357e-02f, -8.11051484e-03f, 1.88609399e-02f, -2.54251203e-03f, -4.62819263e-02f, 4.54007153e-04f,
  -3.77536081e-02f, -1.67064711e-01f, -2.93159634e-02f, 1.04515783e-01f, 7.19949678e-02f, 1.44862294e-01f, 2.22468562e-02f, 1.18232638e-01f, 1.41349975e-02f, -5.95636964e-02f,
  -2.76177317e-01f, -2.30270311e-01f, 2.05028988e-02f, 1.06344901e-01f, 7.22692907e-03f, -8.72209147e-02f, -2.23698411e-02f, -1.81137342e-02f, 6.94867894e-02f, 2.28095204e-02f,
  5.00886962e-02f, 1.53597603e-02f, -5.10511436e-02f, 6.11240882e-03f, -6.54187202e-02f, -3.06372866e-02f, -7.52531067e-02f, -7.84950703e-02f, -4.70741056e-02f, -4.12320979e-02f,
  1.59746222e-02f, -1.65490527e-02f, -2.31257100e-02f, 1.28678307e-01f, -4.93177958e-02f, -4.43875119e-02f, -1.05371691e-01f, 9.74083543e-02f, -3.21353460e-03f, -3.84396464e-02f,
  -5.53046882e-01f, 8.07610229e-02f, -2.20719442e-01f, 1.23561092e-01f, -1.12526208e-01f, 1.14476532e-01f, 1.08232029e-01f, -1.01345047e-01f, -1.50599107e-01f, 3.39164764e-01f,
  2.29251623e-01f, -2.48469591e-01f, -5.15661500e-02f, 3.25999469e-01f, -3.80296052e-01f, -5.02351765e-03f, 3.13741654e-01f, 2.28962287e-01f, -9.58625898e-02f, -6.35086298e-02f,
  -2.87166368e-02f, 3.60993035e-02f, 7.78077170e-02f, 8.84836353e-03f, 1.39016762e-01f, 4.57883766e-03f, 1.94168940e-01f, -1.98897153e-01f, 3.23594540e-01f, -8.02597031e-02f,
  -6.03462197e-02f, -1.87782973e-01f, 8.39232374e-03f, -1.23202339e-01f, -1.97753999e-02f, 3.78664918e-02f, 2.34036408e-02f, -1.34993866e-01f, -1.01207539e-01f, -7.28442222e-02f,
  -6.45642877e-02f, -1.33964673e-01f, -5.81862926e-02f, -1.32320911e-01f, -7.36441538e-02f, -8.90161097e-02f, -2.88350023e-02f, 1.95073515e-01f, 4.88683656e-02f, -3.50772068e-02f,
  -1.35931252e-02f, 6.59838691e-02f, 1.40604064e-01f, 8.79964419e-03f, -1.67439748e-02f, -1.88321304e-02f, 3.61623280e-02f, 2.07126886e-02f, 1.31524667e-01f, -9.95537192e-02f,
  4.69886437e-02f, -8.33062157e-02f, 6.86821565e-02f, -6.04307912e-02f, -7.46011660e-02f, 6.19256608e-02f, 6.49090558e-02f, 8.48089904e-02f, -1.25440165e-01f, -6.09143227e-02f,
  5.93284965e-02f, 6.26217341e-03f, -4.65794243e-02f, 3.53248455e-02f, 3.47898975e-02f, -2.77511477e-02f, -3.57793085e-02f, -2.40445901e-02f, -7.18432665e-02f, 1.10845365e-01f,
  -4.04414572e-02f, -3.52244191e-02f, -5.68576390e-03f, 1.45105809e-01f, -1.24557205e-02f, -9.23695266e-02f, -2.63512451e-02f, -1.32334037e-02f, 4.72412864e-03f, -5.09837009e-02f,
  -2.97779649e-01f, -3.78065407e-01f, -6.59685433e-02f, -8.15586224e-02f, -4.49290276e-02f, -8.92752316e-03f, -2.43778732e-02f, -2.02041790e-02f, -3.89780141e-02f, -5.35640195e-02f,
  -5.60298674e-02f, 1.42216757e-01f, -7.13157803e-02f, -1.07248940e-01f, -2.53733583e-02f, -2.99045909e-02f, -9.86194983e-02f, -8.72310549e-02f, -3.80723812e-02f, -2.97078770e-02f,
  1.62459128e-02f, -4.48288359e-02f, 6.23756647e-02f, -9.03843436e-03f, 1.00733504e-01f, 8.40458870e-02f, -7.46941194e-02f, -3.49737853e-02f, 1.33440331e-01f, 8.83133635e-02f,
  -2.82804370e-01f, 5.39110526e-02f, -8.76958203e-03f, -2.01839045e-01f, -5.55818558e-01f, 4.24444862e-02f, -1.07225187e-01f, -5.66180386e-02f, 1.37433633e-01f, 1.03805728e-01f,
  -2.17887595e-01f, -1.44037485e-01f, 2.15156689e-01f, -1.93206385e-01f, 3.30741525e-01f, 4.98785853e-01f, 1.39113203e-01f, 1.25513270e-01f, -2.82907113e-02f, -2.24960044e-01f,
  -1.24950096e-01f, -3.10043395e-01f, 5.07380255e-02f, -1.54787883e-01f, -3.14206570e-01f, -2.25125849e-01f, -9.23618004e-02f, -1.65485486e-01f, -2.85853565e-01f, -1.97912142e-01f,
  -1.56386599e-01f, -2.08068848e-01f, -2.58300483e-01f, 3.44064571e-02f, -3.09736915e-02f, -1.82499865e-03f, 7.12382421e-02f, -9.33819935e-02f, -1.42192438e-01f, -5.05119413e-02f,
  5.60110994e-02f, -7.01282397e-02f, -7.30894208e-02f, 5.88327553e-03f, -6.16034232e-02f, -5.37716076e-02f, -4.93165962e-02f, 2.19094139e-02f, -2.11603940e-01f, -5.22002764e-02f,
  -6.60628304e-02f, 9.11877826e-02f, -4.00622040e-02f, 9.13585722e-02f, -1.74193963e-01f, -8.87505487e-02f, 1.20018139e-01f, -3.90981324e-02f, -4.99985106e-02f, 7.76068959e-03f,
  9.51031297e-02f, -2.39634123e-02f, -1.69907860e-03f, -3.21437791e-02f, 1.63616166e-02f, -1.69602986e-02f, 5.35490252e-02f, -7.88133293e-02f, 9.50291604e-02f, -3.80932614e-02f,
  -7.80467838e-02f, -5.94611727e-02f, 5.97274937e-02f, 4.07308154e-02f, 4.78294399e-03f, 1.32976323e-01f, 3.31664234e-02f, -5.13727143e-02f, 1.50325716e-01f, 7.02204555e-02f,
  -2.66034398e-02f, 4.01288308e-02f, -6.05646931e-02f, 3.60305123e-02f, 8.63883197e-02f, 1.04102559e-01f, 5.57656884e-02f, 9.11579803e-02f, -5.02893478e-02f, -8.84093121e-02f,
  -9.65841338e-02f, 3.80178802e-02f, -1.28064409e-01f, -2.05629319e-01f, 1.10303678e-01f, -2.22427994e-02f, 5.76428100e-02f, -9.51892212e-02f, 1.09785758e-01f, 8.92116502e-02f,
  8.84690210e-02f, 5.96041381e-02f, -2.84043374e-03f, 3.06400321e-02f, 1.15356274e-01f, 9.69153196e-02f, -5.47162630e-02f, 3.96684259e-02f, -4.11789073e-03f, -3.39770652e-02f,
  -2.14917120e-02f, -3.99119295e-02f, 2.01232597e-01f, 1.20807365e-02f, 1.09873988e-01f, -4.89074253e-02f, -4.48965393e-02f, -1.84524339e-02f, 1.86717249e-02f, -2.17931592e-04f,
  1.39049351e-01f, 1.68238699e-01f, 2.21441820e-01f, 1.54326573e-01f, 4.62621868e-01f, 4.44676608e-01f, 8.76032338e-02f, 4.80630755e-01f, 6.10266447e-01f, -9.31772888e-02f,
  3.50136831e-02f, 1.13715664e-01f, -2.36530364e-01f, 8.59766230e-02f, -1.22862302e-01f, -7.40050375e-02f, 1.22005813e-01f, 3.98890004e-02f, 2.09270790e-01f, -9.20369774e-02f,
  4.96389195e-02f, -9.24438611e-02f, -3.39270979e-01f, -1.56265020e-01f, 1.19177848e-01f, -9.27703679e-02f, -4.23543483e-01f, -1.21159703e-01f, -1.14643134e-01f, 1.42134666e-01f,
  3.36571177e-03f, 1.77593723e-01f, 3.13387811e-02f, 2.07217433e-03f, -5.04538417e-03f, 1.39065627e-02f, -8.06115419e-02f, -4.83134156e-03f, 3.67425606e-02f, 1.29046917e-01f,
  -7.45158568e-02f, -4.11446318e-02f, 7.35644251e-02f, 5.35360090e-02f, 3.88528891e-02f, 1.20748170e-01f, 1.46069108e-02f, 1.33536041e-01f, 4.09632213e-02f, 5.83540648e-02f,
  -8.21362287e-02f, 8.86380672e-02f, 9.64847207e-02f, 1.24462850e-01f, 6.52009249e-02f, 1.31011978e-01f, 2.37051561e-03f, 2.33035572e-02f, 3.19723859e-02f, 1.26065731e-01f,
  6.92139240e-03f, 1.12696066e-01f, 7.36813173e-02f, 3.86300609e-02f, 3.89857367e-02f, 6.59379140e-02f, -5.97079806e-02f, -2.39939857e-02f, 6.14732765e-02f, -2.81719211e-02f,
  3.76865119e-02f, 7.20987618e-02f, 5.29994853e-02f, -9.31445602e-03f, -9.85914692e-02f, 3.73262949e-02f, 3.88548635e-02f, 2.93376260e-02f, 3.85944522e-03f, -8.40287879e-02f,
  -3.62392440e-02f, -6.70614094e-02f, 9.88705270e-03f, -7.02510849e-02f, -4.37332764e-02f, 4.85657379e-02f, 2.26168316e-02f, 5.32463901e-02f, -8.53345990e-02f, -4.38048057e-02f,
  2.09470406e-01f, 1.71605557e-01f, -6.07169196e-02f, 2.33379398e-02f, -1.00359403e-01f, 7.96058252e-02f, -1.22957863e-02f, 1.83348238e-01f, 4.68106009e-03f, 1.58840820e-01f,
  3.93363908e-02f, -9.34964791e-03f, -1.88666154e-02f, 4.54294495e-02f, -8.70072469e-02f, 1.27181545e-01f, -1.07602373e-01f, 2.45258678e-02f, -1.00654505e-01f, -3.58587913e-02f,
  -1.11164182e-01f, -5.68806343e-02f, -7.91447014e-02f, 9.92472842e-02f, 5.76856993e-02f, -7.94402063e-02f, 1.52582082e-03f, -5.48999272e-02f, -1.04009762e-01f, -4.54954756e-03f,
  2.94875093e-02f, 4.47114229e-01f, -2.12146640e-01f, -1.00033842e-02f, 5.18981218e-02f, 5.72323322e-01f, 2.91696817e-01f, 1.97705194e-01f, 2.28206456e-01f, 2.99406052e-01f,
  2.61962377e-02f, 1.36938542e-01f, 3.98436338e-02f, 2.05067739e-01f, 2.93193877e-01f, 1.13716327e-01f, 2.32095972e-01f, 2.37513527e-01f, -4.67246808e-02f, 1.64073423e-01f,
  3.87764201e-02f, 2.35632241e-01f, -2.44865865e-01f, 8.49105977e-03f, -4.59840801e-03f, -2.58980393e-01f, -1.66332111e-01f, -2.14013070e-01f, 1.32103888e-02f, 1.06464148e-01f,
  -1.06982090e-01f, -1.08349882e-01f, -1.13259383e-01f, -6.11415096e-02f, -1.18652239e-01f, -1.36626169e-01f, -5.54002523e-02f, -3.17619517e-02f, -7.76331648e-02f, -2.49558091e-02f,
  1.64396584e-03f, -3.13573820e-03f, 3.52350399e-02f, -4.78566217e-04f, 7.51768064e-04f, -2.55855061e-02f, -7.72026107e-02f, -5.62205687e-02f, 5.91831356e-02f, -8.94267336e-02f,
  -4.39078622e-02f, -6.44161329e-02f, -6.45501092e-02f, 8.83689499e-04f, 1.92419149e-03f, 2.49552950e-02f, 3.83965857e-02f, -1.17563130e-02f, 1.68547750e-01f, 5.39245941e-02f,
  6.26935437e-02f, 9.41056833e-02f, -2.64056809e-02f, -2.01883800e-02f, 3.47440859e-04f, -1.42890334e-01f, 9.39551145e-02f, -7.39625543e-02f, -9.00238007e-02f, 4.67658006e-02f,
  -3.48755419e-02f, -1.37742758e-02f, -5.89820445e-02f, 1.60197504e-02f, 4.95610014e-02f, 2.59753456e-03f, 1.45477336e-02f, 1.95153616e-02f, -1.38841709e-02f, -2.62488215e-03f,
  -2.88194194e-02f, 1.24650709e-01f, 1.83266401e-02f, -5.77765666e-02f, 7.25063682e-02f, -4.02462035e-02f, -2.35868022e-02f, 2.55932789e-02f, -1.08460002e-01f, 5.77026308e-02f,
  2.86084592e-01f, 3.54166269e-01f, 1.05905227e-01f, 2.23860610e-02f, -4.73562628e-02f, -1.61356721e-02f, 2.94578983e-03f, 3.85295562e-02f, 7.96149448e-02f, 7.21350461e-02f,
  -2.11012028e-02f, 1.51898246e-02f, -5.49534429e-03f, -2.14729868e-02f, 7.07158893e-02f, 9.33966935e-02f, 3.69108506e-02f, 2.51879939e-03f, 6.81027845e-02f, 1.39427008e-02f,
  -1.23630492e-02f, 4.81247567e-02f, 6.75217360e-02f, -2.04885397e-02f, 2.94917088e-04f, -4.40570861e-02f, 6.83425665e-02f, -7.09043145e-02f, 5.67255467e-02f, 5.99668641e-03f,
  3.55987430e-01f, 1.29069448e-01f, 1.77502394e-01f, -2.86706269e-01f, -9.43077430e-02f, 2.83119828e-01f, -1.65846601e-01f, 1.91477649e-02f, -3.58376235e-01f, 2.28527963e-01f,
  -1.33104503e-01f, 8.51890072e-02f, -3.12938839e-01f, -5.82538880e-02f, -2.23219723e-01f, -3.11925352e-01f, 4.37725633e-02f, -8.96335542e-02f, -2.28889689e-01f, 1.39959410e-01f,
  -1.50939718e-01f, -2.55360752e-01f, -1.66412771e-01f, 4.61361744e-03f, 1.88091606e-01f, 2.21505597e-01f, -4.19222564e-02f, -1.76653832e-01f, 2.22747967e-01f, -2.13906318e-01f,
  -5.22382818e-02f, -1.09254636e-01f, 1.66567221e-01f, 1.12433486e-01f, 1.98207751e-01f, 7.58754015e-02f, 1.95287749e-01f, -7.95389041e-02f, -2.10131302e-01f, -6.99464828e-02f,
  1.25250131e-01f, -5.36539359e-03f, -2.07628496e-02f, -1.46204427e-01f, 2.41833925e-02f, 2.54237838e-03f, 3.54232662e-03f, 6.13674894e-02f, -3.89090963e-02f, 1.80001017e-02f,
  -6.81852549e-02f, 6.84136748e-02f, 7.35471323e-02f, -1.06639482e-01f, -1.63234785e-01f, -1.95678361e-02f, 1.08553320e-01f, 3.48921567e-02f, 4.89062518e-02f, 8.17851946e-02f,
  6.98442832e-02f, 3.10980026e-02f, 9.75765958e-02f, -3.56660262e-02f, 1.78952483e-04f, -1.22494921e-01f, -2.28208955e-02f, -2.05718279e-02f, -6.51198477e-02f, 2.10218038e-02f,
  2.60565076e-02f, 1.14345795e-03f, -3.38940881e-02f, 3.73257417e-03f, 8.50551799e-02f, 2.76463013e-02f, 3.04846186e-02f, 4.34220769e-02f, 1.70294456e-02f, 3.44421677e-02f,
  -1.41733930e-01f, -3.48736695e-03f, -1.00468479e-01f, 6.78068176e-02f, -1.23947561e-02f, -5.55455834e-02f, 2.98882816e-02f, 3.55573036e-02f, 1.78802740e-02f, -5.60374260e-02f,
  8.10976978e-03f, 1.16229832e-01f, -6.54512197e-02f, -6.75757378e-02f, 3.46283726e-02f, 1.47817716e-01f, 6.14117645e-02f, 1.17224418e-01f, -2.93716565e-02f, -1.52675044e-02f,
  1.55547380e-01f, -1.74447447e-02f, 1.83759108e-01f, -5.76301776e-02f, -3.74321714e-02f, 8.99057612e-02f, -2.06434727e-02f, -7.69045949e-02f, 4.11736108e-02f, 9.97155067e-03f,
  3.41305807e-02f, 7.21550174e-03f, -7.98265114e-02f, -3.74768041e-02f, -6.93571242e-03f, 2.12343019e-02f, 1.09958299e-01f, -2.97734644e-02f, -5.06770499e-02f, -1.05099782e-01f,
  5.11123180e-01f, -2.06381634e-01f, -2.56733298e-01f, -8.69796872e-02f, -2.55120900e-02f, 1.92606866e-01f, 2.00518087e-01f, -1.31719679e-01f, 2.25853950e-01f, -2.22964287e-01f,
  -1.39458179e-01f, -6.42444268e-02f, 9.26824063e-02f, -2.29757935e-01f, 4.03378129e-01f, 2.08454534e-01f, -9.01764110e-02f, -9.73862782e-02f, 3.62407193e-02f, -1.15340434e-01f,
  3.59256081e-02f, -8.26878995e-02f, -1.02415211e-01f, -2.01093003e-01f, -1.64850727e-01f, -1.58030018e-01f, -2.67812312e-01f, -1.26968667e-01f, -3.68201375e-01f, -7.80476704e-02f,
  -5.37792966e-02f, 1.50010169e-01f, -4.02986817e-03f, -5.92812547e-04f, 6.83652833e-02f, 5.42708375e-02f, -1.50427133e-01f, -2.84648463e-02f, 1.46212161e-01f, 4.87683862e-02f,
  9.26029235e-02f, 1.27978578e-01f, -5.39976247e-02f, -1.86109822e-02f, 1.58469398e-02f, -7.30255842e-02f, -5.39160334e-02f, -5.21184579e-02f, -7.42334202e-02f, -2.91181356e-02f,
  -6.48022955e-03f, -2.54626740e-02f, 6.90897927e-02f, -7.52471760e-02f, -5.45893312e-02f, -1.19822860e-01f, 7.99078941e-02f, 1.59887585e-03f, -2.48052292e-02f, 1.12801053e-01f,
  -1.36571035e-01f, 1.26104161e-01f, 1.60010979e-01f, 6.64142817e-02f, 1.32451192e-01f, 3.33961286e-02f, -2.80385856e-02f, -1.15777455e-01f, 6.28635883e-02f, -4.92518805e-02f,
  1.04192812e-02f, 1.55365346e-02f, 1.61216035e-02f, 7.75621682e-02f, 6.91094669e-03f, 5.36709242e-02f, -6.27409220e-02f, -6.71479478e-02f, 6.61885366e-02f, 5.10012396e-02f,
  2.34941356e-02f, 6.22736104e-02f, -7.26226494e-02f, -8.82939771e-02f, -5.82941622e-03f, 4.14882228e-02f, -5.54993153e-02f, 1.53792650e-02f, -6.90823197e-02f, 5.02520986e-02f,
  -6.58454075e-02f, -3.00701838e-02f, -5.46496622e-02f, -1.57556787e-01f, -4.73335758e-02f, 2.66722273e-02f, -2.01851856e-02f, -8.37397650e-02f, 5.96663989e-02f, 5.22750430e-02f,
  -1.40994906e-01f, 1.61015019e-02f, -2.95389872e-02f, 7.22695142e-04f, -1.80443488e-02f, -8.43815953e-02f, -9.79436040e-02f, -8.27684551e-02f, -4.99283373e-02f, -8.07773769e-02f,
  -1.53255641e-01f, 1.27113014e-01f, 1.30258322e-01f, 3.71731035e-02f, -1.43337205e-01f, -2.60288399e-02f, 8.92687812e-02f, -8.06038976e-02f, -9.20759439e-02f, -6.36500195e-02f,
  1.95920870e-01f, -4.10846561e-01f, -4.62751359e-01f, -7.34897032e-02f, 2.67597139e-02f, 1.22233704e-01f, -5.77169806e-02f, -8.18111971e-02f, -1.44988805e-01f, 7.79159889e-02f,
  2.91338325e-01f, 7.68198967e-02f, -6.54655322e-02f, 5.08503735e-01f, 2.74334222e-01f, 1.82610273e-01f, 1.70665175e-01f, 2.59068489e-01f, 7.25801475e-03f, -1.14860736e-01f,
  1.54411003e-01f, 4.01756704e-01f, 9.41322818e-02f, -3.81582417e-02f, 2.32667327e-01f, -1.76443622e-01f, 1.88088581e-01f, -1.07036389e-01f, 2.11638406e-01f, 3.05413842e-01f,
  1.54554248e-01f, -2.57964469e-02f, -2.59218067e-02f, -4.50581387e-02f, -8.01217034e-02f, -3.60365398e-02f, -1.16634078e-03f, 2.37249695e-02f, 1.80922560e-02f, -3.79703715e-02f,
  -2.89563593e-02f, -1.50549412e-02f, 1.40661672e-02f, 5.48719708e-03f, -3.83583307e-02f, -5.34692220e-02f, 4.96880710e-02f, 2.75081713e-02f, -9.35882609e-03f, -7.73882901e-04f,
  -1.97027594e-01f, 4.56524380e-02f, 4.64888550e-02f, 3.43093313e-02f, -3.05052549e-02f, -1.02274694e-01f, -3.72850969e-02f, -8.45871493e-02f, -2.66611297e-02f, 5.16283046e-03f,
  -5.25174923e-02f, 7.16913044e-02f, -5.68601564e-02f, 7.10395798e-02f, -1.01087160e-01f, 4.74739969e-02f, 3.98344211e-02f, 3.81423905e-02f, -1.66326718e-04f, 5.16399555e-02f,
  -4.60903114e-03f, -5.95088564e-02f, 5.01365885e-02f, -3.54155013e-03f, 2.19224505e-02f, 1.68422163e-02f, 4.40213308e-02f, 9.08371806e-02f, 5.24334684e-02f, 1.12544499e-01f,
  2.50452925e-02f, 1.29553666e-02f, 6.58298731e-02f, 1.28528088e-01f, -6.74131326e-03f, 7.35126249e-03f, 8.44234899e-02f, 5.70658669e-02f, 3.09837423e-03f, -4.80453558e-02f,
  -8.66297483e-02f, -1.86850503e-01f, -1.14863127e-01f, 2.10303739e-02f, 6.91119861e-03f, -4.80146110e-02f, -5.61434252e-04f, -5.85413128e-02f, -1.83573626e-02f, -8.92509613e-03f,
  -1.27320802e-02f, -3.07149906e-02f, 1.84348784e-02f, 1.45335719e-01f, -4.49096337e-02f, -4.19876389e-02f, 2.58230586e-02f, 7.44459853e-02f, 2.52973381e-02f, -4.55488078e-02f,
  -2.10178383e-02f, 1.96488537e-02f, 4.65885587e-02f, -4.37272601e-02f, -5.26723713e-02f, 7.96225592e-02f, -3.49209644e-02f, -9.67576280e-02f, -9.56191123e-03f, -1.84708685e-02f,
  8.42320267e-03f, -1.66081846e-01f, 7.70484358e-02f, 2.26395592e-01f, -4.30514514e-02f, 1.76687315e-01f, 3.90707284e-01f, -3.54976505e-01f, -2.77745575e-01f, -8.84775370e-02f,
  -7.95047656e-02f, 1.97865054e-01f, -2.27533132e-01f, 2.41153650e-02f, -6.88194409e-02f, -2.50466943e-01f, -1.06284268e-01f, 2.26139978e-01f, -1.41476706e-01f, -1.05558380e-01f,
  -1.80826500e-01f, -3.82147133e-02f, -1.02977745e-01f, -2.22578377e-01f, 1.20629020e-01f, 2.32553169e-01f, 6.30037040e-02f, 9.14418846e-02f, 3.04777682e-01f, 1.74297705e-01f,
  1.66920513e-01f, -1.58503115e-01f, 1.90597944e-04f, 2.41026860e-02f, 1.74649421e-03f, 1.41593769e-01f, 2.36287162e-01f, 1.88691661e-01f, 1.63717285e-01f, -6.01836704e-02f,
  8.30799192e-02f, 1.35668680e-01f, -6.87627355e-03f, -1.01220692e-02f, 1.41115105e-02f, 2.05643401e-02f, 3.94618604e-03f, -9.20927599e-02f, 2.85282265e-02f, 1.91375669e-02f,
  9.36395824e-02f, -1.36087304e-02f, -8.20191391e-03f, 8.47764760e-02f, 7.07262680e-02f, -5.16249500e-02f, 3.86900380e-02f, 9.21988413e-02f, 6.92223310e-02f, -4.26214412e-02f,
  -1.29949644e-01f, 2.07492467e-02f, -5.97601756e-02f, 1.61373448e-02f, -1.33102508e-02f, 9.25417542e-02f, -5.51342070e-02f, -7.54392967e-02f, 7.41701201e-02f, -1.00389786e-01f,
  3.79301794e-02f, -8.44374672e-03f, -3.79307643e-02f, 1.76150911e-02f, -8.66382197e-02f, -9.26476845e-04f, 4.78449389e-02f, 1.21909268e-01f, 4.46822084e-02f, -3.63801792e-02f,
  -8.43255371e-02f, 1.19756244e-01f, 1.16878636e-01f, -2.77948622e-02f, 5.24085201e-03f, -1.13671999e-02f, -3.35436352e-02f, -6.12373911e-02f, -1.55288838e-02f, 5.45471497e-02f,
  7.76070952e-02f, -2.32427165e-01f, -1.88852064e-02f, 2.00247064e-01f, 9.92077217e-02f, -1.01955727e-01f, -1.97179103e-03f, -7.60435387e-02f, 3.06507833e-02f, -1.42352432e-01f,
  4.50500101e-02f, 5.08559644e-02f, 4.84510250e-02f, 6.97963238e-02f, 1.11245766e-01f, -4.63953428e-02f, 1.32234767e-01f, 2.35259272e-02f, -3.75447124e-02f, 6.53643953e-03f,
  1.03056937e-01f, 1.78843006e-01f, 1.08901091e-01f, 5.25758080e-02f, 6.49334490e-02f, -7.66576733e-04f, 2.50371732e-02f, 9.16714519e-02f, 5.57678491e-02f, 1.64630890e-01f,
  -3.52760017e-01f, 3.85314107e-01f, 2.61330992e-01f, -1.84101641e-01f, 2.18969919e-02f, 1.09899215e-01f, -3.29665840e-02f, 1.40658930e-01f, 2.04244122e-01f, 1.36269748e-01f,
  -9.97826234e-02f, 2.60694653e-01f, -1.67775471e-02f, 1.79130137e-02f, -4.87279296e-01f, -1.94902092e-01f, -1.82249144e-01f, -5.64290360e-02f, 5.29262237e-02f, 3.35353576e-02f,
  -1.69334278e-01f, -2.23085001e-01f, -2.76082575e-01f, 2.29471494e-02f, 6.40604179e-03f, 1.71384409e-01f, -3.06230545e-01f, 2.05809444e-01f, -4.63557653e-02f, -9.04597566e-02f,
  -3.12646143e-02f, 1.46249861e-01f, -2.41603870e-02f, 8.31433162e-02f, -6.32147789e-02f, -1.33064818e-02f, -2.71558594e-02f, -5.49186021e-02f, 1.01677943e-02f, 4.58299927e-02f,
  -8.10102224e-02f, -1.32618919e-01f, 2.49836203e-02f, 1.41450344e-02f, 1.11570224e-01f, 1.72711518e-02f, 6.79071397e-02f, 6.27217889e-02f, 5.32627366e-02f, 3.14958207e-02f,
  3.25430110e-02f, 1.49290431e-02f, 5.87758161e-02f, 8.08196589e-02f, -2.68687699e-02f, 8.16524997e-02f, 1.09537514e-02f, 9.66847241e-02f, 4.28016819e-02f, -6.99050054e-02f,
  -3.77370007e-02f, 8.76764730e-02f, 8.70616212e-02f, 4.94879894e-02f, -1.68110561e-02f, -9.19763464e-04f, -8.22350681e-02f, -6.73006922e-02f, -5.12357242e-02f, 6.54173689e-03f,
  9.38964263e-03f, 9.88905355e-02f, -8.17381963e-02f, 3.32143381e-02f, 5.06308349e-03f, 4.47852425e-02f, -1.62410773e-02f, 8.38124305e-02f, -8.34459588e-02f, -7.96410292e-02f,
  1.43001586e-01f, -4.29829732e-02f, 2.61542592e-02f, -8.59157369e-02f, -9.09332559e-02f, -8.39153305e-03f, 5.36488853e-02f, -9.33224484e-02f, -6.69126138e-02f, -1.31723797e-03f,
  8.61664563e-02f, 1.66591704e-01f, -5.05349152e-02f, -1.25900125e-02f, -1.48633681e-02f, -1.15984166e-02f, 2.12372895e-02f, -4.15310822e-02f, 2.69789924e-03f, 3.40266130e-03f,
  1.47319380e-02f, -1.81465354e-02f, 2.86216289e-02f, 6.71406686e-02f, -5.83354831e-02f, -1.06721364e-01f, -6.46921247e-02f, 3.35409790e-02f, 6.43028272e-03f, 5.93929924e-02f,
  -2.89973002e-02f, 4.64338101e-02f, 5.69289215e-02f, -2.62520555e-02f, -7.64065003e-03f, -1.02545489e-02f, 8.72681290e-02f, 1.25007732e-02f, -2.35002618e-02f, -4.18797396e-02f,
  -5.70258319e-01f, 4.42060590e-01f, 4.25901748e-02f, -2.60680318e-01f, 1.31226078e-01f, 5.55779397e-01f, 1.46022618e-01f, 2.08677903e-01f, 1.18738160e-01f, 2.30665043e-01f,
  6.68673292e-02f, -3.00465226e-02f, 2.12132737e-01f, 1.36964247e-01f, -2.50361413e-02f, 2.15255097e-01f, 2.20179930e-01f, 2.58910414e-02f, 1.94099918e-01f, -1.11610349e-02f,
  -5.95773235e-02f, 6.58682659e-02f, -1.76654279e-01f, 2.07487479e-01f, -5.39609268e-02f, -1.31125495e-01f, -2.18497321e-01f, 5.01713753e-02f, -3.62840332e-02f, 1.20066814e-01f,
  -9.37898234e-02f, -1.24998786e-01f, -3.52755971e-02f, 4.38419916e-02f, -3.95616628e-02f, -1.02068372e-01f, -2.36949399e-02f, -2.74813902e-02f, -8.77164453e-02f, 5.52581325e-02f,
  -1.99226420e-02f, 2.68400647e-02f, 1.59425586e-02f, 3.88356335e-02f, 6.53419346e-02f, 5.21345511e-02f, 2.39852853e-02f, -2.53937375e-02f, 9.61589217e-02f, -2.84886155e-02f,
  2.70546321e-03f, 1.33248614e-02f, -1.57484729e-02f, 3.57962330e-03f, 4.95795906e-02f, 3.42196301e-02f, -4.82655043e-04f, -7.81661123e-02f, 8.12659785e-02f, 3.58654708e-02f,
  1.60078295e-02f, 1.59577522e-02f, 7.26596359e-03f, 9.55560524e-03f, 2.25856211e-02f, -1.14831608e-02f, 1.80799402e-02f, -6.50621578e-02f, -7.11401878e-03f, -7.98022281e-03f,
  -3.84298414e-02f, -5.40243126e-02f, 3.80622447e-02f, -1.30458549e-02f, -7.02499673e-02f, -7.67240152e-02f, -4.95494194e-02f, -8.71773660e-02f, -4.47173975e-03f, -9.44452286e-02f,
  1.01801343e-02f, 5.01557812e-03f, 1.82269365e-02f, -9.87073779e-03f, 7.58689046e-02f, -3.19454782e-02f, 5.94500899e-02f, -5.71581200e-02f, 2.71420903e-03f, -7.92136509e-03f,
  2.23607674e-01f, 1.11777857e-01f, 1.04714975e-01f, 2.78799795e-02f, 4.84486632e-02f, 6.12456016e-02f, 6.31311014e-02f, -3.71974224e-04f, 1.34626374e-01f, 1.07326984e-01f,
  -7.97871724e-02f, 1.51429772e-02f, -9.76822805e-03f, -4.32147011e-02f, 1.78995132e-02f, 6.86403513e-02f, 1.96656231e-02f, 2.66694613e-02f, 7.78420344e-02f, 5.09604290e-02f,
  -3.04223076e-02f, -1.74979847e-02f, -1.67965647e-02f, -3.84056605e-02f, 9.50611662e-03f, -5.64383529e-02f, -1.76094249e-02f, -2.42793858e-02f, -6.12895004e-02f, 5.81555180e-02f,
  -2.49391899e-01f, -3.21111381e-01f, 7.32860565e-02f, 3.17496568e-01f, 8.23035687e-02f, -2.89506227e-01f, -4.23124313e-01f, 1.05096556e-01f, -8.19667652e-02f, -3.49541277e-01f,
  -1.01431258e-01f, -1.41054824e-01f, -2.98392355e-01f, 1.93620741e-01f, 1.48707271e-01f, -1.85394570e-01f, 2.90565312e-01f, 9.94900148e-03f, 1.65587813e-01f, 1.16337955e-01f,
  2.58048147e-01f, 3.15599173e-01f, 3.57474208e-01f, 3.50972056e-01f, 1.64035693e-01f, 1.38407692e-01f, 1.32041901e-01f, 6.32240623e-02f, 2.39901319e-01f, -4.22868785e-03f,
  -9.12659094e-02f, -3.46360058e-02f, -1.32401669e-02f, 9.27635431e-02f, -1.05314897e-02f, -9.22558978e-02f, -1.23159014e-01f, -1.23977818e-01f, 3.75726074e-02f, 1.63132921e-02f,
  -1.00842305e-01f, 7.83568025e-02f, 1.83435455e-01f, 3.42033319e-02f, -4.12653061e-03f, 1.30892709e-01f, 4.08200771e-02f, -9.92648490e-03f, 4.35499065e-02f, -5.34764528e-02f,
  -5.01187071e-02f, 2.38357577e-02f, 2.60651913e-02f, 7.45156258e-02f, -2.38377880e-02f, -2.82398053e-02f, 9.62955281e-02f, -8.02679434e-02f, -4.20473143e-02f, 1.94944795e-02f,
  -9.90061089e-02f, 1.24008730e-02f, 5.99551089e-02f, -8.26392509e-03f, 3.85507606e-02f, -7.61801302e-02f, -2.46414896e-02f, 4.99658696e-02f, 3.25256772e-02f, -5.17439507e-02f,
  4.04335968e-02f, 2.30575702e-03f, 3.74757610e-02f, -5.21605648e-02f, 8.76208618e-02f, 8.73150006e-02f, -3.37964706e-02f, -1.26900757e-03f, 1.07047848e-01f, 8.10147673e-02f,
  5.03717922e-02f, 3.83052528e-02f, 8.94923054e-04f, 5.30826300e-02f, 2.41270829e-02f, -8.77688974e-02f, 3.72300260e-02f, 8.68596956e-02f, 6.13441952e-02f, 6.47692159e-02f,
  -1.85333610e-01f, 2.04029102e-02f, 5.14448732e-02f, 6.15876243e-02f, -7.43921474e-03f, 8.88141096e-02f, 6.41704500e-02f, -1.73243228e-02f, 6.70376327e-03f, 2.48125177e-02f,
  3.74896899e-02f, 6.15194328e-02f, 1.60343423e-02f, 1.83465555e-02f, 1.15830973e-01f, 1.83392353e-02f, -7.75153860e-02f, 3.59326042e-02f, 6.10087365e-02f, -1.59846656e-02f,
  7.65805645e-03f, -7.52895251e-02f, 1.27671316e-01f, 1.19032577e-01f, 5.65830618e-02f, -6.03218637e-02f, 1.01371296e-02f, 5.17536178e-02f, 6.82447180e-02f, 2.21941061e-03f,
  -7.66247749e-01f, 3.19355398e-01f, -7.80803934e-02f, -2.79518306e-01f, -9.39238816e-02f, -9.85909849e-02f, -2.55233329e-02f, 7.47213215e-02f, 8.52747336e-02f, 2.89277583e-01f,
  9.46843103e-02f, -4.86343168e-02f, 4.28060561e-01f, 1.02082044e-01f, -2.76296288e-01f, 3.46498281e-01f, -1.28691524e-01f, -5.62162884e-02f, 1.38261780e-01f, -1.26983792e-01f,
  -1.45439789e-01f, -1.26245869e-02f, -1.44355092e-02f, 6.11210912e-02f, -3.18014264e-01f, -1.72693908e-01f, -1.99499831e-01f, 4.91497442e-02f, -2.06505686e-01f, -6.45543784e-02f,
  -3.16835850e-01f, -1.95423543e-01f, -1.98324502e-01f, -1.93849653e-01f, -1.85271889e-01f, -6.15105890e-02f, -1.40713692e-01f, 1.58700123e-02f, -3.99302430e-02f, 8.16400070e-03f,
  -4.06002663e-02f, 7.60906329e-03f, 3.94358626e-03f, 4.62772921e-02f, -5.50473034e-02f, -3.29126194e-02f, 3.67515646e-02f, -4.01515514e-02f, 1.64293610e-02f, 1.88538376e-02f,
  3.44153568e-02f, 7.41449976e-03f, -1.09283373e-01f, -3.00187729e-02f, -1.12230077e-01f, -2.56365761e-02f, -2.13105883e-03f, -9.82502773e-02f, -1.11442506e-01f, -4.77386862e-02f,
  9.42503754e-03f, 3.28659341e-02f, -2.18462832e-02f, -4.18842817e-03f, 5.81705607e-02f, -5.46227694e-02f, 2.10543419e-03f, 2.59957910e-02f, 2.31368188e-02f, 4.84904237e-02f,
  -2.29983125e-02f, -2.33265925e-02f, -1.10375941e-01f, -2.68869847e-02f, 3.40529643e-02f, -3.96646783e-02f, -4.21014018e-02f, -9.50109214e-02f, 2.42339540e-02f, -4.44399901e-02f,
  -2.20314972e-02f, 6.48254901e-02f, 5.25437705e-02f, -1.47643769e-02f, -5.08692376e-02f, -2.34608594e-02f, 2.18255110e-02f, -3.80734950e-02f, 1.70458779e-02f, -8.09625257e-03f,
  -4.22241032e-01f, -3.89011443e-01f, -2.22428236e-02f, -1.37374729e-01f, -7.97961503e-02f, 1.44590074e-02f, 8.79672617e-02f, -7.29877651e-02f, -6.74597919e-02f, -2.13702917e-02f,
  -5.07068224e-02f, -3.30685787e-02f, -6.91952929e-02f, -8.03899718e-04f, 6.38926476e-02f, 4.42992616e-03f, 3.05663468e-03f, -7.56438747e-02f, -1.64330065e-01f, -5.83108626e-02f,
  -9.39880498e-03f, 8.63975063e-02f, 7.24913329e-02f, -6.61279857e-02f, -1.31857041e-02f, -1.46146759e-01f, -6.04155436e-02f, 2.55758762e-02f, -1.14255197e-01f, 1.16515607e-01f,
  -5.06632626e-01f, -7.76752383e-02f, -3.17559749e-01f, -2.16770947e-01f, 3.57327044e-01f, 4.06349838e-01f, -6.31361529e-02f, 6.50486052e-02f, -3.38624865e-01f, 2.69845426e-01f,
  2.83149064e-01f, -3.63727063e-01f, -1.89135119e-01f, 2.46157229e-01f, -1.26416292e-02f, -1.66005507e-01f, 2.08167732e-01f, 8.06210935e-02f, -2.65920013e-01f, -5.87312616e-02f,
  -1.52219385e-01f, 3.33179414e-01f, -2.85816379e-02f, 1.81737497e-01f, 1.89105898e-01f, -1.52829319e-01f, 1.61835760e-01f, -2.22130850e-01f, 3.61419111e-01f, 1.56955630e-01f,
  2.54322421e-02f, -1.97151214e-01f, -3.44598591e-02f, -6.00105114e-02f, 9.67487842e-02f, 6.06908556e-03f, -1.25682261e-02f, -1.92561280e-02f, -9.58656743e-02f, -2.33761407e-02f,
  -8.65182579e-02f, -4.07383926e-02f, 3.53444330e-02f, -1.39882758e-01f, -3.37848836e-03f, 3.41436751e-02f, -4.11139801e-03f, 1.47787794e-01f, -1.87759455e-02f, -6.16198741e-02f,
  -3.81367728e-02f, 1.22003913e-01f, 2.91574951e-02f, 1.01299629e-01f, 1.53991692e-02f, 2.14737430e-02f, -3.66803892e-02f, 1.77469421e-02f, 1.38570696e-01f, 1.02504551e-01f,
  3.70211923e-03f, 5.81474043e-03f, -6.76908437e-03f, 5.19687906e-02f, 1.80660747e-02f, 5.57113737e-02f, -1.14298621e-02f, 8.52191001e-02f, -3.78349833e-02f, 3.42705809e-02f,
  6.87852129e-02f, -1.07958773e-02f, -1.07673086e-01f, -2.79348474e-02f, -4.57099080e-03f, -5.43918880e-03f, -4.33045514e-02f, 2.68899016e-02f, -1.20765176e-02f, 1.53022602e-01f,
  -6.42714202e-02f, -7.10223168e-02f, -3.03529557e-02f, 3.36793438e-02f, 6.18024766e-02f, -4.96772006e-02f, 1.53671363e-02f, 1.50134228e-02f, -2.71400250e-02f, -1.10615706e-02f,
  1.14830822e-01f, -1.12044498e-01f, -2.74621323e-02f, 3.79706770e-02f, 4.98800650e-02f, 9.91876721e-02f, -3.72686386e-02f, 1.25316560e-01f, -7.24715590e-02f, -4.29318249e-02f,
  4.61530276e-02f, 3.27216163e-02f, 2.56563965e-02f, 2.13867296e-02f, 4.16248143e-02f, 1.17121778e-01f, -6.99266279e-03f, -7.06959441e-02f, 1.34030879e-01f, 1.23732947e-01f,
  4.57693264e-02f, -1.63457599e-02f, 3.31341960e-02f, 1.45748243e-01f, 6.77432045e-02f, 8.55465233e-02f, 1.51917487e-02f, -5.12820110e-02f, 1.22268461e-01f, 1.89686082e-02f,
  3.32621187e-01f, -6.40618503e-01f, 9.00310203e-02f, 2.58212239e-01f, 3.32491010e-01f, 1.14556417e-01f, 1.82426468e-01f, -3.42859365e-02f, -3.18760425e-03f, -4.78506058e-01f,
  -4.58324738e-02f, -1.37823641e-01f, -3.04654151e-01f, 3.38989720e-02f, 3.37794006e-01f, -1.76530093e-01f, 7.82581270e-02f, -5.55563569e-02f, 5.77262901e-02f, -7.42823035e-02f,
  2.41546616e-01f, 1.20559707e-01f, 1.33432880e-01f, -1.10378906e-01f, 4.13125344e-02f, -1.92228239e-02f, -7.07292333e-02f, -1.41497597e-01f, -6.98267063e-03f, 1.01909190e-01f,
  -1.29904523e-01f, -4.09448845e-03f, 3.64529574e-03f, -4.70888168e-02f, -1.85318533e-02f, -9.93528664e-02f, 2.94880923e-02f, 7.98371360e-02f, 6.75899759e-02f, 6.81704059e-02f,
  -3.85848843e-02f, 3.18565965e-02f, 3.17622051e-02f, 1.40586710e-02f, -1.06796287e-02f, 1.18173202e-02f, -7.37682043e-04f, 1.19148875e-02f, 1.17953215e-02f, 4.01732661e-02f,
  -1.93144679e-02f, 7.19069168e-02f, 8.50858167e-02f, -1.69242211e-02f, 6.09853268e-02f, 6.32229298e-02f, 8.73270482e-02f, 5.73856104e-03f, -5.32895066e-02f, 2.76610777e-02f,
  3.95964831e-02f, -4.39349823e-02f, -2.79437732e-02f, -7.17918649e-02f, -2.13314202e-02f, 6.91008493e-02f, -3.05425692e-02f, 8.36083665e-03f, -1.30928410e-02f, -1.00209512e-01f,
  3.21538970e-02f, 1.22962398e-02f, 4.14289534e-02f, 5.34024555e-03f, 2.49493867e-02f, 4.85125631e-02f, 7.27724507e-02f, -3.77602242e-02f, -1.92096643e-02f, 1.90436617e-02f,
  1.19141070e-02f, 1.99292079e-02f, -6.95689842e-02f, 6.00424632e-02f, -6.01083711e-02f, 4.16611731e-02f, -1.61010474e-02f, -3.08201797e-02f, 3.33643369e-02f, 2.13214522e-03f,
  -5.35391867e-01f, -5.40942729e-01f, -4.15642448e-02f, -1.05576934e-02f, -1.22792192e-01f, -4.94241677e-02f, 2.09219707e-03f, -9.94503871e-03f, -1.91071346e-01f, 3.39708477e-02f,
  -3.52671370e-02f, 1.99031308e-02f, -7.16912225e-02f, 3.44754197e-02f, 2.45206822e-02f, -2.61780643e-03f, -6.87630624e-02f, -4.98890243e-02f, -1.90193914e-02f, -9.13159102e-02f,
  -4.89618778e-02f, -1.20420931e-02f, 5.20666800e-02f, 2.81906743e-02f, 6.44765571e-02f, -1.21524213e-02f, -1.74899977e-02f, 3.79393296e-03f, -2.39857333e-03f, -5.84670231e-02f,
  -2.97028273e-01f, -5.54960184e-02f, -4.87317108e-02f, 2.54804492e-01f, -2.54079491e-01f, 2.78354108e-01f, 5.48780143e-01f, -2.66263276e-01f, -3.12120188e-02f, 2.71455765e-01f,
  1.68847814e-01f, 1.01657100e-01f, 2.58974642e-01f, 2.01119110e-01f, 2.07148612e-01f, 2.79972225e-01f, 2.76477575e-01f, 2.87021250e-01f, -2.45037407e-01f, -1.20324090e-01f,
  -1.53379813e-01f, 8.72597843e-02f, 1.53418347e-01f, -2.67291188e-01f, -5.84789515e-02f, -1.73952654e-01f, 1.72451749e-01f, -1.79913137e-02f, 5.80935702e-02f, 9.53514129e-02f,
  -1.40996665e-01f, -2.59073138e-01f, -1.21125400e-01f, -4.34204973e-02f, -2.95205340e-02f, 1.30850509e-01f, 1.71697140e-01f, 1.16825379e-01f, 8.59149080e-03f, -4.16403823e-02f,
  3.77706923e-02f, -1.66248068e-01f, -1.07643843e-01f, 3.40827294e-02f, -1.17035411e-01f, -1.50468975e-01f, -1.68956429e-01f, 4.43761051e-02f, -4.07766737e-02f, -9.90829170e-02f,
  -1.23353638e-01f, -1.31225154e-01f, 4.20485884e-02f, 3.64468433e-02f, -1.05113760e-01f, -4.68849242e-02f, 5.84018342e-02f, 2.44073011e-02f, -3.66868116e-02f, -1.45623311e-01f,
  9.79768857e-02f, 4.03277809e-03f, -1.00988396e-01f, -2.60770638e-02f, -1.03500243e-02f, -5.36358692e-02f, 2.97297779e-02f, 5.80904335e-02f, 8.17474574e-02f, 5.42746000e-02f,
  -6.42265081e-02f, -9.83471051e-02f, -1.24312676e-02f, 1.41776828e-02f, -1.39580742e-01f, 9.90192369e-02f, 2.47196145e-02f, -9.33554396e-02f, -7.83978868e-03f, -3.68042327e-02f,
  1.10083707e-02f, -6.05158471e-02f, -3.72909866e-02f, 6.82139397e-02f, 3.21808755e-02f, 3.99185605e-02f, 1.28384940e-02f, -8.44549090e-02f, 1.57887802e-01f, 1.09275870e-01f,
  2.11439952e-01f, 1.55716330e-01f, -2.25828625e-02f, -1.12934284e-01f, 1.25740409e-01f, -6.18744530e-02f, -4.06418229e-03f, -1.24413908e-01f, 9.46618393e-02f, 4.89466302e-02f,
  -1.16785228e-01f, 1.69588346e-02f, -7.01319948e-02f, 6.66750446e-02f, -4.44170013e-02f, -7.04723373e-02f, 7.87593797e-02f, 1.02868758e-01f, 1.47573814e-01f, -3.83359566e-02f,
  7.96387643e-02f, 9.41327587e-02f, -7.74863288e-02f, 1.60808098e-02f, -4.07106839e-02f, 4.37775552e-02f, -3.57267000e-02f, -2.99530178e-02f, -1.08892582e-01f, 4.31544594e-02f,
  1.16005912e-02f, -1.45541504e-01f, 3.68036240e-01f, 1.65618300e-01f, 3.95673454e-01f, 4.69540447e-01f, 3.70996088e-01f, 2.34646901e-01f, 4.64444488e-01f, -9.39311609e-02f,
  1.69405360e-02f, -1.62905619e-01f, 1.09341405e-01f, -5.03395721e-02f, 1.90678746e-01f, 1.58113405e-01f, 1.14917316e-01f, -2.11189874e-03f, 8.87595788e-02f, -6.73426315e-03f,
  6.92613050e-02f, 1.72012616e-02f, -1.56408399e-02f, -2.35935256e-01f, -3.97353321e-02f, -2.61833489e-01f, -2.90284753e-01f, 3.16756852e-02f, -2.39546925e-01f, 9.83598605e-02f,
  -3.32551897e-02f, -3.00415549e-02f, -1.36892051e-01f, -3.43164871e-03f, 1.38842734e-03f, 1.43763481e-03f, 6.98933378e-03f, 5.54114692e-02f, -1.01370821e-02f, 6.55690730e-02f,
  -9.08844173e-03f, 6.35472080e-03f, -3.73150222e-02f, 1.50024062e-02f, 8.70577171e-02f, 2.80809328e-02f, 1.54176168e-02f, 4.87026535e-02f, 9.01841298e-02f, 6.34479001e-02f,
  7.95960277e-02f, 2.95329429e-02f, 1.17508648e-02f, -5.58080748e-02f, 5.96993193e-02f, -6.61350116e-02f, 1.94107536e-02f, 1.69529300e-02f, 4.20830473e-02f, -2.68237516e-02f,
  2.31992290e-03f, 3.53611028e-03f, -3.95365097e-02f, -3.37789170e-02f, 2.05387920e-02f, -4.79566343e-02f, -2.66971048e-02f, -3.38434465e-02f, -1.45699400e-02f, 1.20259505e-02f,
  -7.84983160e-04f, -8.40318762e-03f, 3.61967012e-02f, -1.14558935e-02f, -1.60264131e-02f, -1.12834072e-03f, -1.14717605e-02f, -5.15592769e-02f, 1.06203100e-02f, 9.57274716e-03f,
  6.97139204e-02f, 5.66709414e-02f, -1.29700638e-02f, 4.22697328e-02f, 3.54953557e-02f, 2.03309823e-02f, -4.81408611e-02f, 6.31652772e-02f, 2.84422841e-02f, 3.23306061e-02f,
  4.27062884e-02f, -6.50327504e-02f, -1.01164766e-01f, -2.59958170e-02f, -8.01072791e-02f, -5.23262843e-02f, 2.64638066e-02f, -3.71238403e-03f, 3.69698629e-02f, 4.02834602e-02f,
  1.81105826e-02f, -3.60371470e-02f, 2.36420166e-02f, -3.39657515e-02f, -2.02714019e-02f, 1.33779749e-01f, 1.49936518e-02f, 9.49858595e-03f, 9.46015492e-03f, -8.73814821e-02f,
  3.22238752e-03f, -6.19013198e-02f, -2.71919444e-02f, -4.48893309e-02f, -3.49093713e-02f, -3.97014730e-02f, -9.82288420e-02f, -3.22487801e-02f, 4.87825684e-02f, 1.19946431e-03f,
  9.66082513e-02f, -2.71002620e-01f, 8.19428489e-02f, -3.65033776e-01f, 9.36567411e-02f, 8.25859234e-02f, 1.67948917e-01f, -2.90368885e-01f, -3.22521836e-01f, -2.87914306e-01f,
  -2.61722684e-01f, 1.36368617e-01f, 3.99382174e-01f, -3.71608883e-01f, 6.03002667e-01f, 3.49092513e-01f, -3.75571847e-01f, -2.27406934e-01f, -7.53136724e-02f, -2.77717143e-01f,
  -1.23884931e-01f, -2.95613408e-01f, 1.37024388e-01f, -3.50811124e-01f, -1.90071195e-01f, -2.47908711e-01f, -4.30699736e-02f, 2.79961884e-01f, -3.88610482e-01f, 8.67788419e-02f,
  3.61942016e-02f, -1.99291576e-02f, 1.97523870e-02f, 2.23686397e-02f, -9.33009014e-03f, 1.02018729e-01f, -9.34266150e-02f, 2.27010414e-01f, 4.52537611e-02f, -4.78541031e-02f,
  1.14870733e-02f, -7.75074726e-03f, -1.09576344e-01f, 1.05014928e-01f, -7.85552710e-02f, -1.56878844e-01f, -1.25898421e-02f, -9.05806497e-02f, -2.84603797e-02f, 8.74724239e-03f,
  -2.21192222e-02f, -4.56325375e-02f, -1.06124483e-01f, -1.07556641e-01f, -3.91622968e-02f, -1.81324258e-01f, 4.34646383e-02f, 1.63181484e-01f, -4.17340882e-02f, -1.00678526e-01f,
  5.87315597e-02f, -3.84683372e-03f, 6.14520647e-02f, -7.81070162e-03f, 1.17669739e-01f, -1.01949140e-01f, -1.62629429e-02f, -1.30428262e-02f, 4.97874841e-02f, 8.40623304e-02f,
  -1.59702450e-02f, -3.16125005e-02f, -7.24739730e-02f, -1.00314006e-01f, -5.00620976e-02f, -3.83479297e-02f, 1.14047237e-01f, 3.20104621e-02f, -7.78668746e-02f, -3.40853743e-02f,
  4.74414555e-03f, -8.60322118e-02f, 9.66752470e-02f, -6.17289953e-02f, -4.37011663e-03f, 7.24008828e-02f, -1.68069676e-01f, 4.24886495e-02f, -4.57020812e-02f, 1.68737799e-01f,
  -4.62271832e-02f, -1.23829946e-01f, 1.23338643e-02f, -6.73457235e-02f, 2.65926048e-02f, -6.32766215e-03f, 2.18486711e-02f, -1.55194238e-01f, -4.96383645e-02f, 5.90582937e-02f,
  -2.13502213e-01f, 6.24642102e-03f, -9.74275246e-02f, -3.53093706e-02f, 1.75962877e-02f, -9.74612087e-02f, 7.92709645e-03f, -1.66453198e-02f, 1.88501738e-02f, -7.14745149e-02f,
  -6.00161776e-02f, -3.42880934e-02f, 1.08778238e-01f, -1.29523784e-01f, -6.14415109e-02f, 1.39782615e-02f, 3.14705856e-02f, -8.55598748e-02f, 9.34109241e-02f, -3.52167673e-02f,
  2.42064223e-01f, -1.84163243e-01f, -3.62793535e-01f, -1.15639023e-01f, 1.30937979e-01f, 9.62607712e-02f, -2.02704385e-01f, 1.28697023e-01f, -3.42597216e-01f, 1.19997792e-01f,
  1.69081822e-01f, -1.38182864e-02f, -3.33686173e-01f, 2.33839884e-01f, 2.12599590e-01f, -3.70126069e-01f, 3.05351824e-01f, 1.20166108e-01f, -1.54430985e-01f, 2.79655367e-01f,
  6.33756891e-02f, 4.84388292e-01f, -2.68166345e-02f, 3.72416049e-01f, 2.23598734e-01f, 5.39118089e-02f, 3.92640412e-01f, -5.67994826e-02f, 3.54447603e-01f, 2.16316298e-01f,
  -6.99020475e-02f, -5.49879707e-02f, -1.03643745e-01f, -1.38114944e-01f, 4.73266430e-02f, 9.56909060e-02f, 7.10955411e-02f, -2.60224827e-02f, -5.00613414e-02f, 5.73926140e-03f,
  -2.37011798e-02f, -3.35724629e-03f, 9.27290618e-02f, -7.11349323e-02f, 3.55427116e-02f, 6.13735523e-03f, -1.18468935e-02f, -4.12537344e-02f, -5.77581264e-02f, 6.42208988e-03f,
  -1.13104090e-01f, 1.49731366e-02f, 5.32826521e-02f, -7.07077608e-02f, -5.54842427e-02f, 3.10424455e-02f, -1.57178566e-02f, 3.18216085e-02f, -3.33314054e-02f, 1.12510674e-01f,
  1.31823540e-01f, 1.89918242e-02f, 6.18826300e-02f, -1.22651234e-01f, -1.87180918e-02f, -6.02068081e-02f, 3.36495712e-02f, -4.02259752e-02f, -3.74926701e-02f, 4.89002876e-02f,
  -2.07881462e-02f, -1.03726033e-02f, 4.12033610e-02f, 5.91243692e-02f, 1.40451267e-01f, -1.16019817e-02f, 3.51504073e-04f, 8.11713561e-02f, -8.32529590e-02f, -2.48983297e-02f,
  -7.30154142e-02f, 5.77986576e-02f, 1.18344361e-02f, 1.73994489e-02f, -1.33617222e-02f, 6.77296370e-02f, 7.07462355e-02f, 7.60213733e-02f, -4.32745554e-02f, -1.55881932e-02f,
  9.68911573e-02f, 2.90377170e-01f, -4.61618081e-02f, -4.03950587e-02f, -8.61297771e-02f, 6.77752793e-02f, -5.58321513e-02f, 8.71657878e-02f, 8.09980482e-02f, 1.07225709e-01f,
  1.43780082e-01f, 4.62024994e-02f, 9.65273157e-02f, -6.17820350e-03f, -3.63177285e-02f, 8.77621174e-02f, 2.77076159e-02f, -2.11662631e-02f, 4.89453822e-02f, 1.76895157e-01f,
  7.22036213e-02f, 3.49897221e-02f, -4.64576390e-03f, -1.11347102e-01f, 4.15127799e-02f, 6.22952394e-02f, 6.47813752e-02f, -9.02821682e-03f, 2.26995684e-02f, -7.65329897e-02f,
  3.51894796e-01f, -2.96701401e-01f, -2.97521383e-01f, 1.71453819e-01f, -2.09730402e-01f, 4.25279289e-01f, 6.23884857e-01f, -1.87606633e-01f, 1.83210135e-01f, 1.73438445e-01f,
  1.27366930e-01f, 1.28428191e-01f, 1.62721440e-01f, 4.30086792e-01f, 2.79116958e-01f, 3.18729490e-01f, 3.42767000e-01f, 4.26351130e-01f, -1.07499370e-02f, 8.63548815e-02f,
  5.61631359e-02f, 3.00979882e-01f, -1.08759239e-01f, -3.36483568e-01f, -1.34072274e-01f, -2.99915791e-01f, -2.68434674e-01f, -2.26521805e-01f, -5.51295727e-02f, 1.78267956e-02f,
  1.17785186e-01f, -1.41875874e-02f, -5.29886931e-02f, 1.06928624e-01f, -8.10062811e-02f, 4.54645716e-02f, 6.93938434e-02f, -2.01141760e-02f, 5.05006723e-02f, -1.56773010e-03f,
  5.34054823e-02f, -1.61491204e-02f, 1.47004142e-01f, -6.16349392e-02f, 6.27070963e-02f, -2.67878063e-02f, -2.28574537e-02f, 1.64570957e-02f, -5.31301796e-02f, -1.27050951e-01f,
  -6.73051784e-03f, -6.70372248e-02f, 6.87331408e-02f, 6.66667745e-02f, -3.11618298e-02f, 8.50973651e-02f, 7.12589081e-03f, -9.52244550e-02f, -7.16743395e-02f, 1.19350683e-02f,
  -5.23315892e-02f, 7.32215941e-02f, 1.03482224e-01f, -1.42533155e-02f, 3.89982797e-02f, -8.17487687e-02f, 4.02016304e-02f, -3.18545550e-02f, -2.39414442e-03f, 9.56277829e-03f,
  3.37391458e-02f, -8.07381049e-02f, 6.21286966e-02f, 4.85080443e-02f, 6.36301935e-02f, 1.01670483e-02f, 8.73553157e-02f, -1.84602924e-02f, 2.41098944e-02f, -1.35732934e-01f,
  -1.64811835e-02f, 1.15001768e-01f, 1.70714762e-02f, -9.32754502e-02f, -1.46863936e-02f, -1.32895624e-02f, 9.06813741e-02f, -3.52131762e-02f, -3.88937779e-02f, -1.28253605e-02f,
  -4.73509878e-02f, -9.78593081e-02f, 5.22227138e-02f, 1.03106461e-01f, -6.99929297e-02f, -1.06536355e-02f, 1.98990759e-02f, -7.99393747e-04f, -6.97954968e-02f, 9.19226557e-03f,
  -1.61158387e-03f, -1.06250383e-02f, -1.17203901e-02f, -1.08935423e-01f, -1.79198070e-03f, -1.34757943e-02f, 1.30741134e-01f, 3.52134444e-02f, 2.16841567e-02f, -1.57704905e-01f,
  -4.98998575e-02f, 3.44043449e-02f, 2.63836216e-02f, -4.08685133e-02f, 6.02570474e-02f, -6.30667107e-03f, -6.60512075e-02f, -3.87162194e-02f, 1.80912334e-02f, -3.95066477e-02f,
  2.48084784e-01f, 5.95525742e-01f, 3.78591239e-01f, 4.00041312e-01f, -2.88538128e-01f, -1.03237957e-01f, -1.40597075e-02f, -3.02449036e-02f, -1.32456692e-02f, 1.86985970e-01f,
  -1.71499938e-01f, 4.14330870e-01f, -1.05761401e-01f, 2.12432697e-01f, 3.52088399e-02f, -1.74260795e-01f, 2.12250680e-01f, 1.05940312e-01f, 2.99285296e-02f, 2.45127037e-01f,
  -1.15577310e-01f, -1.70723498e-02f, 5.14439791e-02f, -2.83592232e-02f, 2.43707642e-01f, 1.89467162e-01f, 1.52560351e-02f, -1.00807905e-01f, 3.16651702e-01f, 7.07447678e-02f,
  -4.48150374e-02f, 6.69056848e-02f, 7.31206238e-02f, 5.95897064e-02f, 1.88992918e-03f, -3.38067440e-03f, 4.33545895e-02f, 1.23828724e-02f, -6.16106987e-02f, -1.27860047e-02f,
  8.07959959e-02f, -9.33208677e-04f, 6.85570836e-02f, -5.65559082e-02f, -3.04203201e-02f, 2.78905127e-02f, 1.02969846e-02f, 3.53385359e-02f, 1.36291564e-01f, 7.63501674e-02f,
  5.63037097e-02f, 2.05640122e-02f, 4.70857303e-05f, 1.14166796e-01f, 9.34696943e-03f, 5.49204461e-02f, 1.15785554e-01f, 4.31959704e-02f, 1.13656975e-01f, 1.20487683e-01f,
  3.31224129e-02f, -3.06269675e-02f, 2.41881460e-02f, -7.82352909e-02f, 8.56656432e-02f, 6.26766030e-03f, 3.21744233e-02f, -9.03331637e-02f, 4.16034423e-02f, 2.33966839e-02f,
  -2.43174061e-02f, 5.10095581e-02f, -1.02515714e-02f, -3.80071588e-02f, 1.19741969e-02f, -4.25017811e-03f, -5.79666495e-02f, 9.78164561e-03f, 8.47802684e-02f, -4.76337038e-02f,
  8.25390406e-03f, -1.25835359e-03f, -4.57955338e-03f, -4.45055477e-02f, -6.98388517e-02f, -3.24590355e-02f, 3.87273170e-02f, 1.15145475e-01f, -7.99355432e-02f, -1.14920633e-02f,
  1.32069468e-01f, 4.39806968e-01f, 3.22117819e-03f, -5.57637550e-02f, -2.44877897e-02f, 4.18366976e-02f, 2.97442451e-02f, 8.67892355e-02f, 1.86001331e-01f, 1.97213627e-02f,
  2.10816618e-02f, -2.52783801e-02f, -4.83928174e-02f, 1.37434457e-03f, 5.48529625e-02f, 8.61022696e-02f, -1.99618377e-02f, 3.64789739e-02f, -1.14475086e-03f, 7.35872611e-02f,
  8.02793056e-02f, -1.99355856e-02f, 8.59233364e-02f, -8.85619596e-02f, 1.39677559e-03f, 3.43750827e-02f, 2.91740685e-03f, 1.26956345e-03f, 1.10602602e-01f, 1.90237053e-02f,
  -1.26225263e-01f, -3.64841312e-01f, 1.98916301e-01f, -8.25406611e-02f, 3.35371085e-02f, -4.43756208e-03f, -7.48177022e-02f, -2.26207465e-01f, -4.54086751e-01f, -4.12348658e-01f,
  -3.09861358e-02f, -9.85050499e-02f, -5.48510207e-03f, 9.36027765e-02f, 4.53954846e-01f, 9.38890204e-02f, 9.21579003e-02f, 1.51311442e-01f, 4.12120903e-03f, 1.54349297e-01f,
  8.06353018e-02f, 2.18450308e-01f, 3.89903724e-01f, 1.94287837e-01f, 4.59646881e-02f, -9.41969827e-03f, 7.33428448e-02f, 1.61850557e-01f, 1.57245114e-01f, 1.79841071e-01f,
  1.66158348e-01f, -1.14692740e-01f, 1.13545777e-02f, -2.18094885e-03f, 3.99577096e-02f, 4.10788991e-02f, 7.67356753e-02f, 1.88399956e-01f, -1.68609805e-03f, 6.24996331e-03f,
  1.22862989e-02f, 3.66886258e-02f, -9.79301613e-03f, 1.16463184e-01f, -1.39672235e-01f, -9.61883739e-02f, -1.38543054e-01f, -1.77747291e-02f, 6.52254093e-05f, -6.62389845e-02f,
  -1.04311191e-01f, -4.56778035e-02f, -1.36927351e-01f, 3.68040577e-02f, -6.98103383e-02f, -1.73134699e-01f, -5.93921877e-02f, -7.79868104e-03f, -3.34945098e-02f, -9.33689028e-02f,
  1.63959637e-02f, 5.58656314e-03f, -6.31554276e-02f, 1.69547256e-02f, -5.37533425e-02f, 2.09032595e-02f, -7.69726979e-03f, 6.46288171e-02f, 5.96818514e-03f, -3.78795899e-02f,
  1.25017418e-02f, 8.97444505e-03f, -9.40699279e-02f, -1.09186374e-01f, -2.51411684e-02f, 2.40426976e-02f, 8.80755186e-02f, -3.03478912e-02f, -4.23542447e-02f, 1.46369042e-03f,
  8.23413730e-02f, -3.38753462e-02f, -4.49143872e-02f, 8.13258439e-02f, 2.65496671e-02f, -1.17059790e-01f, -5.42351864e-02f, -6.56597465e-02f, -1.98299140e-02f, 9.87814665e-02f,
  1.46857500e-01f, -5.60162812e-02f, 4.64501344e-02f, -6.83892816e-02f, 1.00446478e-01f, 3.94420959e-02f, 6.78911805e-02f, -1.87535696e-02f, -1.80998202e-02f, 1.22529035e-02f,
  5.11326529e-02f, 3.33438888e-02f, -6.60094293e-03f, 4.40235995e-02f, 1.45449668e-01f, -1.23977378e-01f, 1.69711877e-02f, -2.35054884e-02f, 4.11509648e-02f, -5.85425161e-02f,
  2.00484470e-02f, -6.57420531e-02f, 2.75513390e-03f, -3.49332951e-02f, -3.00372094e-02f, -8.84074420e-02f, 2.17512413e-03f, -1.12563305e-01f, 3.38071659e-02f, -1.04979482e-02f,
  -3.07222039e-01f, -4.18783687e-02f, -2.23183602e-01f, -4.23069477e-01f, 9.34012234e-02f, -2.14538962e-01f, -2.68194050e-01f, 9.87726822e-02f, -7.68190995e-03f, 1.86680421e-01f,
  8.22946429e-02f, -1.70318410e-01f, 2.08428398e-01f, -3.98347259e-01f, -3.75412822e-01f, -1.18198618e-01f, -4.21937644e-01f, -2.78564304e-01f, -9.81025398e-02f, -2.65728563e-01f,
  -2.63732791e-01f, -2.87274033e-01f, -2.10434288e-01f, 7.80364200e-02f, -2.43659943e-01f, 6.27244413e-02f, 2.19756067e-01f, 1.59575418e-01f, -1.42878816e-01f, -8.93002376e-03f,
  5.19991629e-02f, 1.39670312e-01f, 2.26998725e-03f, 2.03059651e-02f, -1.80730235e-03f, 7.83857249e-04f, -3.11486889e-02f, -3.09333205e-02f, 7.42306113e-02f, -7.39940628e-02f,
  -9.52597894e-03f, -3.35271545e-02f, -1.57068849e-01f, 4.98799048e-02f, 2.33860370e-02f, -1.20769218e-02f, -1.76577028e-02f, 8.05864707e-02f, -6.50159735e-03f, -1.87035486e-01f,
  -1.14223488e-01f, -1.80307664e-02f, -1.31478190e-01f, -3.37539203e-02f, 1.69870034e-02f, 2.56199408e-02f, -8.46988857e-02f, 4.24246304e-02f, -3.79359610e-02f, -6.19971342e-02f,
  -7.27634206e-02f, -1.05304569e-01f, -1.25215098e-01f, 2.08997615e-02f, 3.73139940e-02f, 4.57766876e-02f, -4.98294905e-02f, 1.09288460e-02f, -6.06934354e-03f, 5.30202687e-03f,
  2.70279143e-02f, -6.84705153e-02f, 5.64662134e-03f, -4.72490564e-02f, -6.45114854e-02f, 1.50520005e-03f, -1.76461190e-02f, 1.50336549e-02f, -3.45069282e-02f, 4.54845801e-02f,
  8.76159221e-02f, -1.62771493e-02f, -1.27908830e-02f, 5.11073507e-02f, -7.27702454e-02f, 2.33907737e-02f, -4.80617583e-02f, -8.60932656e-03f, 6.39963746e-02f, -6.23077676e-02f,
  2.24291146e-01f, 9.88076925e-02f, 7.31706172e-02f, 1.23783097e-01f, 4.57829013e-02f, 3.02003529e-02f, -1.55905792e-02f, -6.68434277e-02f, -5.17392438e-03f, -6.30631074e-02f,
  -3.10013480e-02f, -1.66851170e-02f, 5.87166585e-02f, 8.90420191e-03f, 4.67515960e-02f, 2.98120473e-02f, 2.86742933e-02f, 1.20094746e-01f, -2.33112704e-02f, 4.02598046e-02f,
  1.11323688e-02f, 2.19755173e-02f, -9.15979445e-02f, -9.37285423e-02f, -2.58135740e-02f, 6.44439012e-02f, 5.85197136e-02f, 6.42602593e-02f, -9.02251229e-02f, 3.68660688e-02f,
  6.82841241e-01f, -2.23609805e-01f, -3.22671026e-01f, 1.42998025e-01f, 4.24615413e-01f, 1.48540512e-01f, -1.18179783e-01f, 1.18262745e-01f, -2.10643768e-01f, -2.99359769e-01f,
  7.60255158e-02f, -1.55068144e-01f, -4.22173411e-01f, 3.56497049e-01f, 5.11408627e-01f, -2.29697287e-01f, 4.09826398e-01f, 5.44985496e-02f, 7.60378242e-02f, 2.66204387e-01f,
  2.50448525e-01f, 4.50882435e-01f, 1.23528421e-01f, 1.93018481e-01f, 3.53402108e-01f, -1.10797785e-01f, 3.53272706e-02f, -2.61876911e-01f, 4.54152897e-02f, 1.31385222e-01f,
  8.37215930e-02f, 3.28053944e-02f, 3.78307104e-02f, -3.71288806e-02f, 5.70502020e-02f, 1.67175904e-02f, -5.20645231e-02f, -2.62830276e-02f, -3.53657943e-03f, -9.92786214e-02f,
  -3.97459827e-02f, 6.72603101e-02f, 5.24245761e-02f, 1.31308082e-02f, 1.08187765e-01f, 1.70053001e-02f, 3.24298851e-02f, -3.44741419e-02f, -1.09197229e-01f, 8.53198245e-02f,
  -8.65387032e-04f, -1.28464833e-01f, 1.38328522e-01f, -2.18371172e-02f, -4.79012216e-03f, -3.39622237e-02f, -1.68090016e-01f, -1.17197737e-01f, -7.72180548e-03f, 5.52025437e-02f,
  1.13845445e-01f, 1.09854965e-02f, 1.14960708e-02f, 3.77990231e-02f, 3.93014438e-02f, -8.54122713e-02f, 4.11265679e-02f, 1.72698703e-02f, -2.20684595e-02f, -1.47343175e-02f,
  -5.40038981e-02f, 1.16269514e-02f, -6.82215579e-03f, -7.13295415e-02f, 7.66010359e-02f, 3.93286953e-03f, -4.35202084e-02f, -1.35956733e-02f, -1.82792339e-02f, -2.32211780e-02f,
  -6.34733215e-02f, 2.76935883e-02f, -3.25066294e-03f, -5.80268167e-02f, -7.51392543e-02f, 1.01180375e-02f, 1.57121755e-02f, -7.69929737e-02f, 1.81860346e-02f, 2.01085173e-02f,
  -6.43581375e-02f, -8.97753164e-02f, -1.35737374e-01f, -8.87683406e-02f, -4.89614829e-02f, 1.55547097e-01f, 5.95253855e-02f, 5.19790240e-02f, -2.33862251e-02f, 5.86202480e-02f,
  5.56551525e-03f, -9.85030457e-02f, -8.67160037e-02f, 5.05253561e-02f, 1.57279782e-02f, -4.87213247e-02f, -8.16958249e-02f, -1.13023736e-01f, -2.16622534e-03f, 4.39004079e-02f,
  3.61426175e-02f, 1.28731532e-02f, -4.01829258e-02f, 6.03486896e-02f, -2.84139346e-03f, -1.02309480e-01f, 1.47011504e-01f, -5.26147522e-02f, -3.98733746e-03f, -7.75758028e-02f,
  9.96790901e-02f, 1.86255097e-01f, 2.16949716e-01f, -1.52389586e-01f, -6.14849105e-02f, -3.28041434e-01f, -1.98832244e-01f, -2.24737123e-01f, -1.58094108e-01f, -1.39218599e-01f,
  -1.98815823e-01f, 4.40807998e-01f, 8.55222344e-02f, -3.29545170e-01f, -2.08818957e-01f, -1.57544315e-02f, -3.22720855e-01f, -1.75983042e-01f, 9.42239631e-03f, -1.74373418e-01f,
  -1.09113239e-01f, -4.58524764e-01f, -7.00775683e-02f, -3.19488466e-01f, -1.81545675e-01f, 6.45731166e-02f, -1.71691805e-01f, 1.66111570e-02f, -1.42983258e-01f, -2.83401348e-02f,
  -1.38670698e-01f, -1.58248007e-01f, 1.15337931e-01f, -2.55184434e-02f, -1.77461877e-01f, -1.28447972e-02f, 1.48254722e-01f, -2.38854578e-03f, 1.96466949e-02f, 2.32887920e-02f,
  1.46120964e-02f, -1.40287921e-01f, -1.78320929e-02f, 8.96939784e-02f, -3.57040763e-02f, 4.70454805e-02f, 1.20374188e-02f, 1.85993150e-01f, -4.07547131e-03f, 6.37468174e-02f,
  3.65088768e-02f, 1.72570825e-01f, -6.42682845e-03f, 3.32906842e-02f, -2.26091649e-02f, -3.73921022e-02f, 7.81211108e-02f, 2.40490809e-01f, 1.00774601e-01f, -3.78721878e-02f,
  -1.38332158e-01f, 2.37496253e-02f, 9.76992324e-02f, -4.43226732e-02f, -9.66511369e-02f, 3.53050195e-02f, 5.78341633e-02f, 7.30121657e-02f, 7.91040715e-03f, -6.58571944e-02f,
  -4.33135033e-02f, 1.50641263e-01f, -8.34727213e-02f, -1.29922688e-01f, -4.49089557e-02f, 2.39727236e-02f, -7.59428972e-03f, -4.86733951e-02f, -4.30656075e-02f, 1.96638722e-02f,
  1.83441006e-02f, -3.56983952e-02f, -7.39453956e-02f, -2.81152986e-02f, -2.77782641e-02f, 8.14391598e-02f, -7.45120943e-02f, -1.15241492e-02f, -9.34031010e-02f, -5.31191239e-03f,
  -3.21107596e-01f, -3.98123741e-01f, -1.17916308e-01f, 1.29913882e-04f, -6.38056844e-02f, 6.57321140e-02f, 8.01170059e-03f, -4.16819006e-03f, -9.77703854e-02f, -9.19384509e-02f,
  -2.72105094e-02f, -4.18360755e-02f, -5.87484390e-02f, -1.24270618e-02f, -7.36793801e-02f, -1.79821346e-02f, -9.17604864e-02f, 1.53526187e-01f, 7.36427447e-03f, -2.79791784e-02f,
  -2.37360820e-02f, -4.06232551e-02f, 5.63766994e-02f, -9.00720432e-02f, 4.71638553e-02f, -3.77929583e-02f, -6.14420744e-03f, 4.50118743e-02f, 1.79668013e-02f, -2.98622996e-03f,
  2.83332616e-01f, -1.40983507e-01f, -1.94577426e-01f, -8.08258131e-02f, -2.55515665e-01f, -2.52936870e-01f, -3.70998174e-01f, -1.84254631e-01f, -2.53655892e-02f, 2.44085398e-02f,
  -3.34866136e-01f, 1.88395768e-01f, 7.05023035e-02f, -4.04200405e-01f, 2.01632574e-01f, -2.95536816e-02f, -1.80700123e-01f, -7.67568052e-02f, -7.10255802e-02f, -8.90100598e-02f,
  -1.07188389e-01f, -2.53866494e-01f, -1.42084703e-01f, -1.30229086e-01f, -2.20129967e-01f, -6.71772137e-02f, 5.85120358e-02f, -2.85732061e-01f, -2.71535069e-01f, -1.81906268e-01f,
  -1.23155981e-01f, -1.52692884e-01f, -3.07637062e-02f, -1.91301126e-02f, 6.82453066e-02f, 6.01284206e-02f, 7.71933352e-04f, -1.16403811e-01f, -9.54092741e-02f, 1.35509782e-02f,
  1.88878730e-01f, 1.04375176e-01f, -3.14821638e-02f, 3.57216373e-02f, -8.16963017e-02f, -6.18473925e-02f, -5.51233953e-03f, 4.33236919e-02f, -6.66801259e-02f, 3.73312980e-02f,
  4.04620841e-02f, 1.14447206e-01f, -3.46806161e-02f, 9.08885151e-02f, -4.23028832e-03f, -6.09718896e-02f, -1.26516549e-02f, -7.28948414e-02f, 3.41113806e-02f, 9.87083837e-02f,
  8.18314180e-02f, 1.20165810e-01f, -2.74586584e-03f, -1.04483925e-01f, -6.60908520e-02f, -7.93180987e-02f, 1.18234372e-02f, 6.13184972e-03f, -3.55298594e-02f, -5.01665398e-02f,
  5.94198331e-02f, -7.17050920e-04f, -4.21532728e-02f, 3.92452627e-02f, 5.16615883e-02f, 1.40132576e-01f, -1.69639289e-02f, 2.79060639e-02f, -1.03219002e-02f, 9.97396335e-02f,
  -4.28036042e-02f, 2.20010318e-02f, -8.91598091e-02f, 5.02272360e-02f, -6.48467243e-02f, 1.13754086e-01f, 3.15678082e-02f, 3.28786485e-02f, 5.11409938e-02f, 7.47239292e-02f,
  3.73555981e-02f, 8.90948102e-02f, -2.70830318e-02f, -8.68547857e-02f, -1.43404668e-02f, 5.39335832e-02f, -1.09921820e-01f, -7.38817900e-02f, -8.22126400e-04f, 7.70267695e-02f,
  1.10575631e-01f, 1.19950704e-03f, 2.11685076e-01f, -6.04551286e-02f, 3.71179804e-02f, -8.15950111e-02f, -7.10833236e-04f, 3.99455801e-02f, 1.12540379e-01f, 1.00877605e-01f,
  6.97297230e-02f, 1.23666234e-01f, 1.05098546e-01f, 5.64393252e-02f, 1.69623584e-01f, 1.17520966e-01f, 1.35280699e-01f, -7.49842450e-02f, 9.33388025e-02f, 2.98153758e-02f,
  5.14300287e-01f, -2.57456928e-01f, 2.54619747e-01f, 3.50744426e-01f, 2.20774814e-01f, 1.52321011e-01f, 3.27986866e-01f, -3.28751020e-02f, 2.52357215e-01f, -2.59873778e-01f,
  -1.90758616e-01f, 2.44312048e-01f, -2.13651657e-01f, -2.31342725e-02f, -1.62535682e-02f, -1.51532397e-01f, 5.35912886e-02f, 1.91014651e-02f, -6.72323480e-02f, 6.73263669e-02f,
  6.77194372e-02f, -2.21518159e-01f, 7.51631483e-02f, -2.85473675e-01f, 1.80494353e-01f, 6.76143542e-02f, -2.64514446e-01f, -7.24619180e-02f, -6.10166863e-02f, 4.57107499e-02f,
  -7.06695542e-02f, 3.60522494e-02f, 6.40639067e-02f, -4.97780927e-02f, 8.14288855e-03f, 2.51755491e-03f, 4.74298410e-02f, 1.23491297e-02f, 5.24556451e-02f, 4.88502979e-02f,
  1.47247771e-02f, -2.54121292e-02f, -2.59444769e-02f, 4.80198674e-02f, 5.30027300e-02f, 5.39960973e-02f, 1.13086171e-01f, 1.38869265e-03f, 1.61782429e-02f, 9.23567638e-02f,
  3.38664986e-02f, 3.59542184e-02f, -1.05255470e-02f, -1.37131223e-02f, 4.12206128e-02f, 4.86752503e-02f, 6.50359765e-02f, 9.95766670e-02f, 1.07985456e-02f, 5.94669245e-02f,
  5.93165569e-02f, -6.44159764e-02f, 3.75410691e-02f, 1.62292589e-02f, -2.05853907e-03f, 5.63758845e-03f, 2.93107554e-02f, -5.51957116e-02f, -1.72554106e-02f, 1.06677664e-02f,
  3.86718288e-02f, 1.55749647e-02f, -4.32597063e-02f, 5.01269847e-02f, 4.04291861e-02f, 5.21087907e-02f, -2.16070823e-02f, -2.95464080e-02f, -7.29869530e-02f, 3.98063101e-02f,
  2.21455302e-02f, -8.68610069e-02f, -3.98123488e-02f, 8.12341198e-02f, -3.98841053e-02f, -1.73600242e-02f, -1.14421897e-01f, 4.18990813e-02f, -1.88696366e-02f, -2.57792696e-02f,
  -3.54797632e-01f, -2.67596960e-01f, -4.20874506e-02f, -9.83233303e-02f, -7.58679137e-02f, -1.29885182e-01f, -3.20202038e-02f, -9.30337817e-04f, -6.61160648e-02f, 1.72273663e-03f,
  -7.28655532e-02f, 3.60758677e-02f, 4.03862521e-02f, 3.42393741e-02f, -8.41968954e-02f, -1.88501347e-02f, 5.11748046e-02f, -7.77572766e-02f, -5.21432385e-02f, -7.58805722e-02f,
  -1.31514817e-02f, 2.24402118e-02f, -2.20882893e-02f, 4.26584780e-02f, -5.79512753e-02f, 3.05250380e-02f, 1.03955260e-02f, 3.17117781e-03f, -4.09403741e-02f, -4.11596037e-02f,
  2.93396175e-01f, -1.40698671e-01f, -3.76683295e-01f, -1.68139622e-01f, 1.75008819e-01f, 3.14443201e-01f, 6.41911328e-02f, -7.28911208e-03f, -2.72421390e-01f, 1.17095664e-01f,
  1.50779247e-01f, -3.10891457e-02f, -1.39297411e-01f, -1.14292890e-01f, -2.35700421e-02f, -2.70359933e-01f, 7.50732049e-02f, 1.06368117e-01f, -1.25594839e-01f, 2.33935907e-01f,
  4.20720549e-04f, 2.76580006e-01f, -2.20314130e-01f, 2.91828722e-01f, 1.50106564e-01f, -3.22463526e-03f, 4.51757237e-02f, -3.30155529e-02f, 7.07666427e-02f, 5.48395328e-02f,
  -4.39357460e-02f, -1.20625898e-01f, -4.42684516e-02f, -2.02132482e-02f, 6.03654310e-02f, 1.86721116e-01f, 1.08179115e-01f, -6.54377267e-02f, -8.70016664e-02f, -1.34930059e-01f,
  -2.01585107e-02f, -2.09330227e-02f, -9.23874676e-02f, -4.96756770e-02f, 1.25874400e-01f, -1.72558408e-02f, -1.01130202e-01f, -9.85598788e-02f, -8.35609064e-02f, 3.79598141e-02f,
  -7.29860812e-02f, -9.51845050e-02f, 1.95387788e-02f, -1.18849188e-01f, -3.31387669e-02f, -1.90719683e-02f, -6.60644546e-02f, -1.77355707e-02f, -5.27050607e-02f, 1.14537030e-01f,
  7.37648383e-02f, 1.32961884e-01f, 1.01608537e-01f, -1.52950555e-01f, -9.83929634e-03f, -8.56025964e-02f, -6.57237619e-02f, -5.44583015e-02f, 1.60023142e-02f, 7.23142028e-02f,
  -3.76523808e-02f, -3.92431729e-02f, -8.86352137e-02f, 7.02459663e-02f, 6.80769905e-02f, -6.14865460e-02f, -1.12190247e-02f, 1.13264129e-01f, 7.51472935e-02f, -1.63482368e-01f,
  -1.13052323e-01f, 8.69821161e-02f, -2.00705859e-03f, -1.06895402e-01f, -8.63024965e-02f, 5.03741279e-02f, 9.87674147e-02f, 3.52841876e-02f, -1.01070963e-01f, 1.15467303e-01f,
  -1.68992318e-02f, 1.54273614e-01f, -3.30068693e-02f, 7.90443458e-03f, -1.01402827e-01f, 1.18654683e-01f, -3.00836004e-02f, 4.83923918e-03f, 7.68792862e-03f, 6.68794513e-02f,
  1.16476707e-01f, 3.73306796e-02f, -1.27862245e-02f, -1.74065977e-02f, -9.81098190e-02f, 1.25889704e-01f, 1.58026302e-03f, 3.57207768e-02f, -4.86084335e-02f, 1.20703212e-03f,
  1.60083711e-01f, 7.65058473e-02f, -3.80271202e-04f, 1.93171352e-02f, 1.09898716e-01f, -1.00605749e-02f, -5.26728481e-03f, 4.16649655e-02f, -4.14740816e-02f, -1.14673071e-01f,
  -4.23160613e-01f, 1.57151446e-02f, -4.99485850e-01f, -2.38063663e-01f, 3.64628553e-01f, 2.55009905e-02f, -3.88987735e-02f, 1.03999063e-01f, -2.07631916e-01f, 2.97854960e-01f,
  7.50557557e-02f, -2.91525632e-01f, -8.31686109e-02f, -2.84603268e-01f, -4.45560247e-01f, -3.47725689e-01f, -1.27986521e-01f, -1.26692519e-01f, -2.56404668e-01f, -5.40623777e-02f,
  -2.52217799e-01f, 1.27017319e-01f, -3.20351541e-01f, 2.33323097e-01f, 1.31935418e-01f, -5.23983093e-04f, 2.72338212e-01f, 8.70461091e-02f, 5.63677475e-02f, 3.07148900e-02f,
  -1.41959429e-01f, -1.38472840e-01f, -3.84598767e-04f, -2.37057284e-02f, 4.31322120e-02f, 1.31067321e-01f, 5.27537577e-02f, -1.50621347e-02f, -3.02870739e-02f, -7.04857707e-02f,
  6.67802319e-02f, -3.89218666e-02f, -7.43401870e-02f, -7.18377950e-03f, 7.58696673e-03f, 3.37148644e-02f, -1.42079368e-01f, 2.57019792e-03f, -7.01532140e-02f, -1.65096864e-01f,
  -1.15403429e-01f, -4.67540547e-02f, 2.76440196e-02f, -6.09353483e-02f, -7.11860731e-02f, -1.51447244e-02f, -9.56808180e-02f, 2.39831433e-02f, -3.96880228e-03f, -3.95217240e-02f,
  4.80239205e-02f, 9.44898054e-02f, -5.48898801e-02f, -9.91939679e-02f, -1.98812280e-02f, 1.07126206e-01f, 4.95242849e-02f, -5.53224701e-03f, -3.27015072e-02f, 4.25680205e-02f,
  -1.36400471e-02f, -5.86668402e-02f, 4.40451168e-02f, 8.46269261e-03f, -3.58652957e-02f, -1.00261047e-02f, -1.43729234e-02f, -1.49212619e-02f, -5.79299740e-02f, -5.80965839e-02f,
  5.62209077e-02f, -3.02680600e-02f, -2.76409592e-02f, 1.21092044e-01f, 3.07604801e-02f, -5.48463427e-02f, 8.26461799e-03f, -6.43687174e-02f, -2.68519968e-02f, 6.25802428e-02f,
  3.40555832e-02f, 9.84964147e-02f, -1.66673195e-02f, 3.14950012e-02f, -1.19985780e-02f, 1.26098230e-01f, -2.82000154e-02f, -3.75779755e-02f, 6.13859557e-02f, 4.28532772e-02f,
  7.62855858e-02f, 1.11107118e-01f, 1.68828472e-01f, -4.48621847e-02f, 1.10860039e-02f, 1.02238394e-01f, 6.91833645e-02f, 4.31680046e-02f, 1.32809877e-01f, 2.13998780e-02f,
  1.07623331e-01f, 5.03145941e-02f, -5.20546781e-03f, 8.54107663e-02f, 2.76600327e-02f, 1.52189419e-01f, 9.75088403e-02f, -1.54209370e-02f, -3.96700762e-02f, -5.81726991e-03f,
  -4.28298907e-03f, 1.80596292e-01f, 3.85538846e-01f, 2.71067828e-01f, 1.26736639e-02f, 3.62620763e-02f, 3.33324447e-02f, 4.02804911e-01f, 4.67200547e-01f, -2.29415983e-01f,
  -1.27579778e-01f, -2.92789936e-01f, 1.71391405e-02f, -8.87271836e-02f, 6.67738616e-02f, 1.61761463e-01f, 1.60459682e-01f, 3.96277942e-03f, 3.00449789e-01f, 8.34424496e-02f,
  2.07916588e-01f, -3.33003283e-01f, 3.35915238e-02f, -1.09662749e-01f, -5.10431454e-02f, 2.08649233e-01f, -1.76797733e-01f, 8.44800398e-02f, -1.79451019e-01f, -5.48770055e-02f,
  7.53088901e-03f, 3.26330098e-03f, -4.00983915e-02f, 3.59511189e-02f, 1.65915892e-01f, -1.02790274e-01f, -7.15107098e-02f, -9.55953375e-02f, 7.68239573e-02f, -3.22118998e-02f,
  -6.05677478e-02f, -2.13575989e-01f, -5.63512333e-02f, 2.30766684e-02f, -1.12640690e-02f, -5.35112694e-02f, 7.56192580e-03f, 1.34309188e-01f, -1.08650886e-02f, -4.05678600e-02f,
  -4.41977270e-02f, 3.67017761e-02f, 6.93191811e-02f, -9.29242745e-02f, -9.65023190e-02f, 9.54763070e-02f, 5.01732938e-02f, -4.20002304e-02f, -8.15547034e-02f, 8.98058489e-02f,
  -7.20972046e-02f, 2.09989443e-01f, -3.46493088e-02f, 2.76121888e-02f, -9.36415344e-02f, 9.22109112e-02f, -1.75871868e-02f, -3.83343585e-02f, 8.44656676e-02f, -1.04774192e-01f,
  1.20240368e-01f, -4.26813327e-02f, 4.25927229e-02f, -6.34323731e-02f, 9.51863751e-02f, -6.12341845e-03f, -1.09593488e-01f, 2.50412375e-02f, 3.50170806e-02f, 3.24542932e-02f,
  -5.19324206e-02f, -3.17768827e-02f, 6.39563426e-02f, -5.82045279e-02f, -8.07171017e-02f, -5.97462691e-02f, -1.01087436e-01f, -5.20677194e-02f, 1.50083989e-01f, -1.15290202e-01f,
  2.17709780e-01f, 3.29726279e-01f, 8.90992507e-02f, -2.29339115e-02f, 1.58952475e-01f, -5.87114170e-02f, -6.62854910e-02f, 8.10748860e-02f, 1.09856114e-01f, -6.44606277e-02f,
  -1.16742834e-01f, -1.17893308e-01f, -8.67587253e-02f, -7.69582577e-03f, -8.13955516e-02f, -1.63923725e-02f, -1.83217432e-02f, 1.32081226e-01f, 5.09522930e-02f, -9.88757145e-03f,
  -2.03352839e-01f, -1.01291761e-02f, 4.43716533e-02f, -6.78569674e-02f, -8.97387192e-02f, -1.27378076e-01f, -7.97876343e-02f, -2.27041431e-02f, -6.92723915e-02f, 1.62795812e-01f,
  -1.85100049e-01f, -2.60673106e-01f, 2.28375152e-01f, 3.72500181e-01f, 5.52225001e-02f, -2.87823826e-01f, 4.31921985e-03f, -1.65703818e-01f, -6.86954707e-02f, -3.79889131e-01f,
  -1.70782894e-01f, 3.87531221e-02f, -2.50483900e-01f, 1.57594830e-01f, 4.71229821e-01f, -1.75444797e-01f, 1.21270239e-01f, -3.32182869e-02f, 1.95411608e-01f, -5.38981892e-02f,
  1.50059938e-01f, 8.45007971e-02f, 2.98178315e-01f, 1.17777683e-01f, 2.23297849e-02f, 2.92715132e-01f, 3.61424893e-01f, 2.67722160e-01f, 4.13946509e-01f, 2.14994431e-01f,
  -1.20972209e-01f, -1.04438439e-01f, -6.66914210e-02f, -6.47177026e-02f, -4.54708748e-02f, -6.83466671e-03f, 5.63878119e-02f, 1.37232155e-01f, 1.90381661e-01f, 1.66165922e-02f,
  -1.56435251e-01f, 1.13602296e-01f, 1.42352805e-02f, 6.02623224e-02f, 3.84149179e-02f, 1.24275915e-01f, -2.59729428e-03f, -1.96434587e-01f, -1.04257472e-01f, -6.48162514e-02f,
  -4.34529893e-02f, -1.43577144e-01f, -6.04340695e-02f, 1.91674121e-02f, 1.07138120e-01f, -3.90696824e-02f, 6.92748576e-02f, 1.30160615e-01f, -4.94419746e-02f, 8.67639706e-02f,
  -9.07368436e-02f, 8.49030092e-02f, 1.83162745e-03f, 7.79553428e-02f, -4.04642671e-02f, 6.88388571e-02f, 1.03195207e-02f, 1.57426693e-03f, 4.78970930e-02f, -1.73687473e-01f,
  -1.38644688e-02f, -6.32498460e-03f, 2.17005275e-02f, 6.92208931e-02f, -3.89986858e-02f, -1.24698982e-01f, 8.03060457e-02f, 1.00154661e-01f, -5.08932173e-02f, -3.43844644e-03f,
  -7.72412773e-03f, 4.78807688e-02f, -2.87335424e-04f, 6.64087683e-02f, -1.12799801e-01f, 1.42404055e-02f, 1.42161343e-02f, -6.22469606e-03f, -6.27277792e-02f, -4.26959945e-03f,
  -7.27259815e-02f, 3.45816851e-01f, -3.50841992e-02f, -1.59713909e-01f, -6.07481338e-02f, -6.48203194e-02f, 1.28737792e-01f, -1.44123174e-02f, 5.82264364e-02f, -5.09531163e-02f,
  -6.77953884e-02f, 4.70858142e-02f, -1.36453241e-01f, 3.02773807e-02f, 2.67583062e-03f, -8.00756679e-04f, 5.00596911e-02f, 4.34639640e-02f, 4.12289537e-02f, 7.92708993e-02f,
  -1.38984239e-02f, -2.30683815e-02f, -1.43415900e-02f, 1.40754431e-02f, -7.97882900e-02f, 3.21518257e-02f, -8.16879869e-02f, -7.15343934e-03f, 1.13215491e-01f, 4.89862915e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.54321599e-01f, 3.52143139e-01f, 3.61978978e-01f, 3.57747525e-01f, 3.38647187e-01f, 3.43903154e-01f, 3.17642301e-01f, 1.75526798e-01f, 4.84856099e-01f, 3.53688657e-01f,
  3.00512761e-01f, 3.36589903e-01f, 3.02168131e-01f, 2.20029831e-01f, 3.37779582e-01f, 3.89487356e-01f, 3.96144390e-01f, 3.28671515e-01f, 3.47197086e-01f, 3.32514882e-01f,
  3.43750656e-01f, 3.64173859e-01f, 1.99352324e-01f, 2.97314107e-01f, 3.11785579e-01f, 2.62183905e-01f, 3.98920208e-01f, 4.18527246e-01f, 2.37924337e-01f, 4.20385033e-01f,
  3.83697599e-01f, 4.83546406e-01f, 9.96194035e-02f, 2.88871050e-01f, 3.73937696e-01f, 2.74390787e-01f, 3.71337384e-01f, 3.78062129e-01f, 4.17885780e-01f, 2.89869636e-01f,
  4.45846707e-01f, 3.30807924e-01f, 2.10259691e-01f, 3.42328221e-01f, 3.69034618e-01f, 3.55463594e-01f, 2.92933136e-01f, 4.48590100e-01f, 2.89233744e-01f, 3.65467757e-01f,
  3.56038302e-01f, 2.90635556e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -3.72021288e-01f, -6.30451560e-01f, -7.01950192e-02f, -3.20530415e-01f, 8.00652653e-02f, 7.68074617e-02f, -1.93501934e-01f, -1.78259611e-01f, -2.32074052e-01f, -3.31511289e-01f,
  1.68932810e-01f, 4.58551943e-01f, -3.38962637e-02f, 1.60445243e-01f, -1.79218009e-01f, -1.52658269e-01f, 3.33218694e-01f, -1.63253993e-01f, 1.51011646e-01f, 4.39228505e-01f,
  -3.46215904e-01f, -4.55848426e-01f, -4.27213848e-01f, 4.80485529e-01f, -1.87072411e-01f, 1.96262881e-01f, -4.84799266e-01f, 1.91661969e-01f, -2.97033191e-01f, 3.81561786e-01f,
  -1.49780452e-01f, -1.08896881e-01f, -3.96186002e-02f, -5.33192635e-01f, 6.42914951e-01f, 3.08536649e-01f, -6.54998481e-01f, -8.69181752e-02f, -2.54865021e-01f, -3.29145849e-01f,
  2.52764851e-01f, 2.30223492e-01f, -3.30539763e-01f, 1.75312683e-01f, -1.71855077e-01f, 3.61216694e-01f, 2.91574806e-01f, -1.38023198e-01f, 4.82479006e-01f, -1.24718912e-01f,
  -5.72823286e-01f, -3.78387362e-01f, 2.40621507e-01f, -2.27545068e-01f, -4.00198624e-02f, -5.82746938e-02f, -7.79287338e-01f, -2.55965412e-01f, -5.00471830e-01f, -2.22990170e-01f,
  -3.87260914e-01f, -1.15144327e-01f, -2.09123775e-01f, -3.21883112e-01f, -2.74492800e-02f, 1.30329460e-01f, 1.68791860e-01f, 2.94021666e-01f, -2.23359056e-02f, -8.57823640e-02f,
  2.54846960e-02f, -2.39118338e-01f, -1.86395064e-01f, 2.20042974e-01f, -4.00883734e-01f, 4.36883271e-01f, -4.48862791e-01f, -4.41837370e-01f, 3.14362086e-02f, 7.63064027e-02f,
  3.13400000e-01f, -1.02208339e-01f, -4.23773199e-01f, 3.52139711e-01f, -2.53051460e-01f, 2.13000134e-01f, -9.40302387e-02f, -7.95959651e-01f, -2.58818567e-01f, -4.39210057e-01f,
  5.45820268e-03f, 2.35077441e-01f, -3.46322119e-01f, 2.42937580e-01f, -7.10712135e-01f, -3.78630757e-01f, -3.44492197e-01f, -2.42929846e-01f, 3.92388413e-03f, -7.36356914e-01f,
  3.53981495e-01f, 5.12915850e-01f, 1.78346366e-01f, 1.04320943e-01f, 4.94923800e-01f, -2.10284501e-01f, -4.13661331e-01f, 2.78682023e-01f, -3.90386820e-01f, -6.30108476e-01f,
  4.75805342e-01f, -4.06717151e-01f, 5.58430105e-02f, 9.77850705e-02f, 5.46349632e-03f, 4.95484263e-01f, 3.04242760e-01f, 6.33566007e-02f, -5.38899750e-02f, -5.01461446e-01f,
  6.06972158e-01f, -2.17942104e-01f, -1.08905263e-01f, -3.01178396e-01f, 4.48696315e-01f, 4.83343042e-02f, -6.48723006e-01f, -8.53399277e-01f, -1.94668308e-01f, 7.16172904e-03f,
  -6.17028847e-02f, -1.62840337e-01f, -7.84527212e-02f, 6.86156601e-02f, -4.37148422e-01f, 3.78395587e-01f, -1.03301011e-01f, -1.93527058e-01f, -3.05906776e-02f, -2.69921243e-01f,
  -1.28015280e-01f, 1.67451739e-01f, 4.53996718e-01f, -3.67594481e-01f, -3.98620903e-01f, -5.35369754e-01f, -3.72988880e-01f, -2.08067462e-01f, 2.92891711e-02f, 1.52160212e-01f,
  -2.04218239e-01f, -1.51555508e-01f, -8.57387558e-02f, -4.18424189e-01f, -2.20463812e-01f, -4.50740099e-01f, -3.06727707e-01f, -4.51999426e-01f, -3.21622968e-01f, 7.54023492e-02f,
  3.60285759e-01f, -2.59653717e-01f, 1.31173611e-01f, -1.95523128e-01f, -3.10220540e-01f, -2.30439410e-01f, -1.70324951e-01f, -3.09954971e-01f, 3.62669617e-01f, 3.44765693e-01f,
  -1.34520993e-01f, -4.51945037e-01f, 5.07735908e-01f, -2.35544249e-01f, 3.13452333e-01f, 4.44246680e-01f, -1.81810901e-01f, -4.57280815e-01f, -4.86689806e-01f, 3.37363243e-01f,
  7.28201494e-02f, -2.72343993e-01f, 3.98657203e-01f, -1.02073535e-01f, 4.41513658e-01f, -1.80795625e-01f, -2.76239038e-01f, -2.49473955e-02f, 2.04998460e-02f, 2.54161246e-02f,
  -3.99100214e-01f, 3.61857653e-01f, 2.09466778e-02f, -1.07143363e-02f, -2.88768649e-01f, 1.47176981e-01f, -3.86429220e-01f, -2.34086681e-02f, 3.08219910e-01f, 2.06580937e-01f,
  -3.87178481e-01f, 4.37130064e-01f, 3.67195867e-02f, 3.49226594e-02f, -9.48432609e-02f, 4.39337909e-01f, -3.95770431e-01f, 4.76675421e-01f, -4.63212490e-01f, 1.13499798e-01f,
  -3.43705237e-01f, -2.60103554e-01f, -7.71978915e-01f, -2.30480373e-01f, -2.69086748e-01f, 4.66891646e-01f, -3.95139307e-01f, 6.04369402e-01f, 2.58326918e-01f, 1.70148492e-01f,
  -2.96582997e-01f, 1.30858943e-01f, -3.60897273e-01f, 4.65158910e-01f, -3.90989721e-01f, 3.93873155e-01f, -1.06017523e-01f, -4.20836121e-01f, -5.41371517e-02f, -4.07680601e-01f,
  -5.14155447e-01f, -3.38284582e-01f, -2.23714381e-01f, -2.84028649e-01f, 3.23957831e-01f, 2.16405585e-01f, -9.79781896e-02f, 4.29979205e-01f, -3.73145610e-01f, -1.92159370e-01f,
  -3.93853784e-01f, -6.14916682e-01f, -7.89628252e-02f, -4.56537724e-01f, -1.19210191e-01f, -2.55124390e-01f, -2.18121633e-01f, 4.11890179e-01f, -1.42117739e-01f, 1.14607222e-01f,
  -4.73051161e-01f, -3.16300601e-01f, -2.86341786e-01f, 2.53921479e-01f, -2.69258022e-01f, -2.49734193e-01f, 3.83685306e-02f, 5.02864423e-04f, 2.45830879e-01f, 2.25669399e-01f,
  2.99700469e-01f, 1.78237751e-01f, -5.16127229e-01f, -5.21685600e-01f, 6.86837956e-02f, -1.22269414e-01f, 6.64231598e-01f, -3.51478666e-01f, 4.90722001e-01f, 5.61985672e-01f,
  -3.67351532e-01f, -6.38329744e-01f, 3.95910144e-01f, 1.64780423e-01f, 6.11245275e-01f, 8.06440562e-02f, 1.47856936e-01f, -4.52010930e-01f, -2.08752915e-01f, -1.73297018e-01f,
  -3.25890571e-01f, -6.27462685e-01f, 4.70879912e-01f, -5.82751215e-01f, -3.16732347e-01f, -2.48448417e-01f, 2.72103250e-01f, -4.66457427e-01f, -3.45233619e-01f, 4.00890291e-01f,
  1.77094911e-03f, 1.24915577e-01f, 2.50517547e-01f, -1.93556145e-01f, 2.55857736e-01f, -1.05449982e-01f, -2.37817898e-01f, -5.66476822e-01f, 1.87088206e-01f, 4.10840929e-01f,
  2.46592715e-01f, 2.53091663e-01f, 1.87684432e-01f, -7.03874007e-02f, -4.90970492e-01f, 1.80139571e-01f, 2.14789584e-01f, -1.46631345e-01f, -8.85119379e-01f, -2.18290403e-01f,
  3.86985123e-01f, 9.91443545e-02f, 1.16580322e-01f, 1.45548554e-02f, -3.66148621e-01f, -2.18376040e-01f, -1.71754479e-01f, -3.46791267e-01f, 2.12224886e-01f, -5.48473671e-02f,
  2.27179006e-01f, 2.52528250e-01f, 1.11597620e-01f, -1.02738747e-02f, -8.89904648e-02f, -1.26991451e-01f, -3.81712675e-01f, -2.13379726e-01f, 3.14233840e-01f, -4.62115854e-01f,
  2.15772097e-03f, -4.66985673e-01f, -5.42110860e-01f, -4.40602750e-01f, 1.62634905e-02f, -4.89777476e-01f, 2.53019243e-01f, -1.22947395e-01f, -8.22838098e-02f, -5.01664579e-01f,
  -3.21171641e-01f, 1.26548424e-01f, 4.22671854e-01f, 2.52231538e-01f, -5.00464626e-02f, 1.36613548e-01f, -3.98955911e-01f, 3.59038770e-01f, 6.57028109e-02f, -2.16307387e-01f,
  2.62214541e-01f, -3.89645427e-01f, 4.31538939e-01f, -6.32497787e-01f, -6.84562266e-01f, 4.59082246e-01f, 3.78296763e-01f, 4.53108460e-01f, 9.55790877e-02f, 2.17933625e-01f,
  -5.34143686e-01f, 1.99992597e-01f, 2.49999881e-01f, 3.98018599e-01f, -2.97302097e-01f, 4.75927480e-02f, -6.89578772e-01f, -6.51514769e-01f, 2.10694194e-01f, 2.73305506e-01f,
  -1.12198807e-01f, -2.98131227e-01f, 3.65120441e-01f, 3.54085743e-01f, -4.50450510e-01f, -5.57551384e-01f, -5.43458641e-01f, -6.90372288e-01f, 2.31965959e-01f, 3.36968265e-02f,
  -3.03554218e-02f, -6.11547947e-01f, 4.93668377e-01f, 3.24142218e-01f, 1.55437052e-01f, -1.69336706e-01f, -4.98391688e-01f, -2.40215793e-01f, 2.02896386e-01f, -5.86487651e-02f,
  2.99451232e-01f, 5.14187813e-01f, 2.89283812e-01f, 3.73083442e-01f, 3.93817574e-02f, 2.02957317e-02f, 3.52841578e-02f, -3.37351233e-01f, 3.29903424e-01f, -2.78863162e-01f,
  -3.97647560e-01f, -3.15338552e-01f, -2.66203731e-01f, -6.63746893e-02f, -2.95172364e-01f, 4.44537163e-01f, 3.99850368e-01f, -1.83042690e-01f, 5.18782675e-01f, -1.20576844e-01f,
  -2.55205203e-02f, -3.95958304e-01f, 4.94127631e-01f, 4.99510735e-01f, -2.22045183e-01f, 4.83544677e-01f, -2.39883944e-01f, 1.99678719e-01f, -1.17375985e-01f, -3.69808495e-01f,
  4.58216250e-01f, -2.37921819e-01f, -4.43669915e-01f, 3.67941260e-01f, -1.22698218e-01f, -2.13286832e-01f, -5.52102268e-01f, -4.81077939e-01f, 1.48723826e-01f, -4.27203834e-01f,
  -3.33450556e-01f, 5.08945942e-01f, -6.21892691e-01f, 3.99692625e-01f, -3.04219067e-01f, -5.02875984e-01f, 2.28743479e-01f, -6.16179705e-01f, -5.43636799e-01f, -1.51007012e-01f,
  3.11140567e-01f, -5.66959977e-01f, -2.07910717e-01f, 4.97895926e-01f, 1.29668806e-02f, -7.14247674e-02f, 3.83276254e-01f, -1.60334989e-01f, -2.02249005e-01f, -1.47435099e-01f,
  -4.35964912e-02f, 2.15123612e-02f, -1.07212421e-02f, -1.21530056e-01f, 2.70351291e-01f, 2.65537500e-01f, -1.49297431e-01f, -2.68639743e-01f, 1.66426405e-01f, -3.31499368e-01f,
  -2.75977194e-01f, -4.25302953e-01f, -1.82419702e-01f, -3.52775183e-04f, -3.48174214e-01f, -2.55972832e-01f, -7.19486177e-02f, -2.23656401e-01f, -1.62364721e-01f, -1.82073593e-01f,
  -2.14742839e-01f, 2.32973307e-01f, -2.42655873e-01f, -3.45650651e-02f, 4.32004809e-01f, 7.04735518e-02f, -7.59368092e-02f, -1.57201573e-01f, 2.50067949e-01f, -2.64948398e-01f,
  3.32306504e-01f, -2.60890245e-01f, -2.92897195e-01f, 4.62043554e-01f, -2.45232254e-01f, -2.86539793e-01f, -2.80743003e-01f, 3.26085031e-01f, 1.74968675e-01f, -3.67435694e-01f,
  -3.34920228e-01f, -3.83467108e-01f, 7.10560381e-02f, 1.37577012e-01f, -2.60266662e-01f, -1.15532570e-01f, -3.25807691e-01f, -1.80253670e-01f, 4.17721778e-01f, -9.78319719e-02f,
  -2.12376550e-01f, -2.43481264e-01f, -1.82885587e-01f, 3.95417124e-01f, -2.58340031e-01f, 4.26322132e-01f, 5.51059246e-01f, -1.68803722e-01f, -2.83631802e-01f, -1.67063341e-01f,
  -6.84246942e-02f, 1.96147487e-02f, -9.40997601e-02f, -4.49534170e-02f, -1.46328080e-02f, -1.42094016e-01f, -3.80404770e-01f, -6.55070841e-02f, 3.22375685e-01f, 2.41505399e-01f,
  1.16551658e-02f, 1.48851559e-01f, -2.96110749e-01f, 3.55492443e-01f, -1.32316440e-01f, -2.20934838e-01f, 1.77429318e-01f, 4.26894501e-02f, -2.84558207e-01f, 4.34797287e-01f,
  -5.74746057e-02f, -4.51362208e-02f, 2.41018727e-01f, 1.00499377e-01f, -4.53816615e-02f, -2.56811619e-01f, 2.08234817e-01f, 9.06863138e-02f, -3.26783746e-01f, 3.20599496e-01f,
  -2.96721667e-01f, 2.83022821e-01f, 4.67813849e-01f, 3.18946660e-01f, 2.39447922e-01f, -3.18874925e-01f, -3.09059441e-01f, -8.78972262e-02f, -3.64745677e-01f, -3.02809086e-02f,
  -1.25812367e-01f, -5.10526657e-01f, -1.78992912e-01f, -5.71490109e-01f, -2.42586747e-01f, -2.49010026e-01f, 4.28595811e-01f, -1.27717257e-01f, -2.89165437e-01f, -3.75341862e-01f,
  -3.03375665e-02f, -2.35605612e-01f, -2.07700655e-01f, 2.61756122e-01f, -6.74594700e-01f, 4.40856576e-01f, 2.15856448e-01f, -3.27091932e-01f, 7.81353489e-02f, -1.85000166e-01f,
  2.82553788e-02f, -4.42394882e-01f, -2.07277700e-01f, -3.34764272e-01f, 2.63550997e-01f, 3.74986172e-01f, 1.95816204e-01f, 2.53248513e-01f, 2.18134940e-01f, 1.68375954e-01f,
  3.82415438e-03f, 1.37030646e-01f, 5.27486987e-02f, -1.60052598e-01f, 1.08505011e-01f, -3.09629977e-01f, -3.97908956e-01f, 5.42445900e-03f, 4.86773610e-01f, -4.54420894e-01f,
  -5.61496675e-01f, -2.76149176e-02f, -3.12024444e-01f, -2.25185856e-01f, 5.11465013e-01f, -4.30920422e-01f, 4.99523431e-01f, -6.91333711e-02f, -5.12960494e-01f, -4.24769610e-01f,
  -3.06747854e-01f, -9.54635143e-02f, -4.61993665e-01f, -3.28310370e-01f, 1.43702999e-01f, -5.50509334e-01f, -3.33695531e-01f, -4.89589661e-01f, -4.20265287e-01f, -3.94327134e-01f,
  -3.64295423e-01f, -3.00689344e-03f, -5.37862360e-01f, -2.65313447e-01f, -4.40998346e-01f, 2.78385073e-01f, 1.56322122e-01f, 4.73163873e-01f, -3.53997171e-01f, -5.00928879e-01f,
  -5.35313904e-01f, -3.11267018e-01f, -3.49298567e-01f, 3.57498825e-01f, 4.49847907e-01f, 2.77614117e-01f, 7.32346058e-01f, -2.73532361e-01f, 2.41922081e-01f, -1.45984888e-01f,
  3.90142024e-01f, -3.01345199e-01f, -1.02013484e-01f, 2.75775135e-01f, 2.91965771e-02f, 3.89716566e-01f, -1.96291387e-01f, -1.45048201e-01f, -3.24344605e-01f, 2.17523307e-01f,
  2.17789695e-01f, 2.32343972e-01f, 9.97959599e-02f, -1.48221031e-01f, 7.89280534e-02f, 6.18826747e-02f, -1.64403349e-01f, -9.17439982e-02f, -2.43927673e-01f, 1.88236073e-01f,
  5.39222717e-01f, 2.79563874e-01f, -1.95941493e-01f, -6.15470409e-01f, 6.57538930e-03f, 3.23518276e-01f, -1.93455547e-01f, -1.13986745e-01f, -2.15982273e-01f, -1.02142133e-01f,
  6.79732382e-01f, -5.62379882e-02f, 1.17104582e-01f, -6.47774279e-01f, 3.52611959e-01f, 2.34702706e-01f, 5.07380851e-02f, -2.94115871e-01f, -3.53404939e-01f, -5.29908478e-01f,
  -1.62827104e-01f, 4.23817113e-02f, 4.07784522e-01f, 2.22099554e-02f, 1.69911042e-01f, -2.19453871e-02f, -1.89125627e-01f, -1.79482654e-01f, 4.42003369e-01f, -2.52763569e-01f,
  -4.34559703e-01f, 1.33785516e-01f, 1.46786138e-01f, -9.45520997e-02f, -2.87284076e-01f, -5.61639428e-01f, 3.68308395e-01f, -3.79883975e-01f, 1.22884922e-02f, -2.20875636e-01f,
  -3.33783269e-01f, 2.76193380e-01f, -3.16998601e-01f, -4.79303956e-01f, -3.30152959e-01f, 3.73931557e-01f, -5.40245712e-01f, -2.07888409e-01f, 2.16275796e-01f, -3.16742361e-01f,
  4.77696151e-01f, 6.82898343e-01f, -7.76995718e-02f, -9.16730613e-02f, 3.35302539e-02f, 5.34198955e-02f, -5.49507998e-02f, 1.51855707e-01f, 1.55123249e-01f, 8.94457772e-02f,
  3.24765116e-01f, 1.61814675e-01f, 2.92243540e-01f, -2.27417290e-01f, -2.94604868e-01f, 4.64885682e-02f, -3.25639158e-01f, 3.67996097e-01f, 2.56883562e-01f, 3.33946854e-01f,
  -2.60213315e-01f, 4.14160669e-01f, -2.99512714e-01f, -1.31748453e-01f, -2.65133411e-01f, -3.63961995e-01f, 4.22029138e-01f, 3.03339601e-01f, 2.00427473e-01f, -4.40384477e-01f,
  -4.26024139e-01f, -7.40885064e-02f, 5.41309416e-01f, -3.00747693e-01f, 3.57754022e-01f, -2.73310915e-02f, -3.97978425e-01f, 3.68375510e-01f, 2.18320459e-01f, -2.71138668e-01f,
  1.97290272e-01f, -3.66223991e-01f, 4.04004276e-01f, -4.50586647e-01f, -2.48768806e-01f, 3.41739208e-01f, 3.69231015e-01f, -2.90724516e-01f, -3.03020865e-01f, -3.53058815e-01f,
  -1.33386761e-01f, -2.03795165e-01f, -3.58035475e-01f, -3.68112028e-01f, -3.74206215e-01f, -2.07238972e-01f, -3.05111676e-01f, 4.30504620e-01f, -3.32036972e-01f, -2.54410774e-01f,
  -3.07115704e-01f, 4.22554076e-01f, 7.49227852e-02f, 4.01374519e-01f, -2.14689463e-01f, -4.00773376e-01f, -8.28967169e-02f, -3.51791143e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.00249031e-02f, -4.29813676e-02f, -3.05708610e-02f, -5.73967658e-02f, 3.76511104e-02f, 8.70098770e-02f, 3.25305276e-02f, 6.46630824e-02f, -1.15719214e-01f, 5.91712259e-02f,
  1.23240046e-01f, -1.03204489e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    