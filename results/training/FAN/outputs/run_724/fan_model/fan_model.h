/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.54022974e-01f, -3.08690433e-05f, -3.67213003e-02f, 2.56885737e-01f, -2.27853179e-01f, -2.89996505e-01f, -3.11259955e-01f, 7.56884553e-03f, 1.93347916e-01f, -1.67251192e-02f,
  -8.77924338e-02f, 2.36158725e-02f, 7.25808088e-03f, -3.46450247e-02f, 1.11362599e-02f, -8.95744935e-02f, -1.17461011e-02f, 1.79421514e-01f, 5.53003997e-02f, -3.33317108e-02f,
  -1.38560429e-01f, 1.46780431e-01f, 2.68000424e-01f, 4.98668179e-02f, 3.16765420e-02f, -1.51100848e-02f, 3.46961841e-02f, -3.92880775e-02f, -2.24324521e-02f, 5.81393279e-02f,
  -6.77374601e-02f, 2.61586189e-01f, -7.61771575e-02f, -1.45871975e-02f, -2.03157626e-02f, 3.14975828e-02f, 1.00187495e-01f, 7.03238100e-02f, 1.01260215e-01f, 1.00221582e-01f,
  6.42138645e-02f, 2.09414456e-02f, 7.36646950e-02f, 1.13940619e-01f, 4.34860177e-02f, 7.93487057e-02f, 1.45941570e-01f, 7.24561512e-02f, 6.44626841e-02f, 4.23618294e-02f,
  -4.30960320e-02f, 9.87815931e-02f, -3.36507633e-02f, -9.24125388e-02f, 1.32586686e-02f, 5.51307835e-02f, 7.39277666e-03f, 1.29660487e-01f, 1.07977211e-01f, 2.38074288e-01f,
  -5.01579009e-02f, 4.33059521e-02f, -1.24009639e-01f, -2.22343989e-02f, -6.16115369e-02f, -4.68966626e-02f, -4.63166796e-02f, -1.19221568e-01f, -7.27249458e-02f, 2.28652544e-02f,
  -7.00332522e-02f, -4.89851809e-04f, -8.19016770e-02f, -3.39122936e-02f, -2.29968317e-02f, -4.81523350e-02f, -1.09736426e-02f, -8.43391865e-02f, -2.39998829e-02f, 6.41734675e-02f,
  1.19898131e-03f, 2.92811710e-02f, -2.07736362e-02f, -9.62165371e-02f, -6.82831779e-02f, 2.70180628e-02f, 1.45694613e-02f, -1.00418299e-01f, 5.01364330e-03f, 1.02954982e-02f,
  -4.12237495e-02f, -1.32401705e-01f, 2.06364989e-01f, 1.77641377e-01f, 6.64336383e-02f, 1.00594334e-01f, 1.17486995e-02f, -2.98900902e-02f, 7.38977641e-02f, 1.07116506e-01f,
  -7.99353719e-02f, 1.01299413e-01f, 5.39511032e-02f, -3.21861021e-02f, 2.15880685e-02f, 5.56355417e-02f, 6.56499267e-02f, 6.43912181e-02f, -2.66026277e-02f, 3.90684269e-02f,
  5.14683314e-02f, -5.28049059e-02f, 1.44356132e-01f, -7.82868415e-02f, -1.87999122e-02f, 1.27148807e-01f, -1.06271401e-01f, 2.50334125e-02f, -9.55147147e-02f, 6.72469065e-02f,
  -6.61436766e-02f, -9.65710357e-03f, 1.87176131e-02f, 9.89879072e-02f, 1.75748169e-01f, 2.58642621e-02f, 3.64641845e-02f, 2.40035336e-02f, 3.67563516e-02f, 9.53369886e-02f,
  -4.61157858e-02f, -8.36901180e-03f, 2.38920492e-03f, 7.26092905e-02f, 8.05323645e-02f, 4.21755053e-02f, 9.06069279e-02f, 3.35938968e-02f, 3.98816690e-02f, 1.46848485e-01f,
  1.68366998e-01f, 7.70435780e-02f, -3.44907492e-02f, 7.45864734e-02f, -4.72571759e-04f, 5.61858304e-02f, -2.81633530e-02f, -3.12754908e-03f, -1.85422413e-02f, 1.15289338e-01f,
  1.93327293e-01f, -3.90860364e-02f, -1.78526491e-01f, -5.01904562e-02f, -6.50230348e-02f, -1.37237936e-01f, -4.24616002e-02f, -1.06245264e-01f, -4.38708737e-02f, -3.73326316e-02f,
  -7.08216056e-03f, -8.42715427e-03f, -7.57521614e-02f, -1.08335860e-01f, 2.10078317e-03f, -1.08454354e-01f, -1.64527178e-01f, -9.13107097e-02f, -1.12487048e-01f, -5.03531434e-02f,
  -5.02624214e-02f, 6.91581191e-03f, -1.53576314e-01f, -2.12615848e-01f, -5.59504777e-02f, -6.83824942e-02f, -6.08638637e-02f, -1.43319771e-01f, -5.25985099e-02f, -5.27696684e-02f,
  5.82417659e-02f, -3.35176364e-02f, 2.78218184e-02f, -7.28464052e-02f, -3.28157060e-02f, -7.43923569e-03f, 5.73501177e-02f, 3.32538225e-02f, -1.22105712e-02f, -1.06150685e-02f,
  3.43252271e-02f, 1.14539489e-01f, -1.40142450e-02f, 1.88226059e-01f, 8.01600367e-02f, 1.48015954e-02f, -8.36744998e-03f, 1.34996429e-01f, 1.53729125e-04f, 3.76220345e-02f,
  7.86381885e-02f, 2.24785656e-02f, 1.22949503e-01f, 3.53398845e-02f, 8.10890943e-02f, 9.74509045e-02f, 5.93621954e-02f, 8.05288926e-02f, 1.75672118e-03f, 1.56348068e-02f,
  -1.40788391e-01f, -1.91293284e-01f, -2.87556536e-02f, -1.45725906e-01f, -1.70784611e-02f, -6.83888867e-02f, -1.22983739e-01f, -1.73754796e-01f, -8.87903199e-02f, -4.46622213e-03f,
  -7.83226416e-02f, -5.85538559e-02f, -5.96214086e-02f, -9.23220292e-02f, -4.85526733e-02f, -6.81778118e-02f, -4.04610224e-02f, -9.92304310e-02f, -5.96463159e-02f, -5.09781949e-03f,
  -1.37479350e-01f, -5.94558828e-02f, -8.27391595e-02f, -2.10618302e-01f, -8.68733078e-02f, -1.51669636e-01f, -1.86626136e-01f, -1.26820698e-01f, -1.07347026e-01f, -9.45322439e-02f,
  -3.30282599e-02f, -1.21516265e-01f, -1.19100131e-01f, -1.02789246e-01f, -9.17432234e-02f, -1.67384014e-01f, -1.09835297e-01f, -6.14827760e-02f, -1.47303883e-02f, -9.77880955e-02f,
  -7.40748346e-02f, 3.39896493e-02f, 9.37659368e-02f, 3.13406698e-02f, -8.04096013e-02f, -7.76423290e-02f, -1.82423860e-01f, -3.76650542e-02f, -7.62822255e-02f, 1.12973982e-02f,
  7.25687444e-02f, -7.38766268e-02f, -6.05858751e-02f, -1.17190741e-01f, -3.79381031e-02f, 1.27206251e-01f, -1.54127657e-01f, -4.63748910e-02f, -8.17695186e-02f, -4.29538935e-02f,
  -2.51011979e-02f, -9.75425169e-02f, 1.35029703e-01f, 1.08114883e-01f, -6.06167503e-02f, 3.13545428e-02f, -3.86666693e-02f, 5.27821034e-02f, 7.88401738e-02f, -2.08889078e-02f,
  7.65018612e-02f, 5.53722233e-02f, -1.43871633e-02f, 9.30863544e-02f, -4.46133725e-02f, -3.03817056e-02f, -6.10600747e-02f, 4.01852513e-03f, 7.94458315e-02f, -5.56492666e-03f,
  7.05382004e-02f, 1.07131973e-01f, -5.97411059e-02f, 2.57805432e-03f, 7.86294341e-02f, 1.52109593e-01f, -6.96527166e-03f, 1.27635062e-01f, -1.58298761e-02f, 1.29332185e-01f,
  3.69791202e-02f, -2.34829132e-02f, 5.52288108e-02f, -3.29877734e-02f, -2.71249078e-02f, 1.05936237e-01f, 1.77711863e-02f, -7.86935017e-02f, 6.56240582e-02f, -6.24122024e-02f,
  7.96298031e-03f, -1.07204407e-01f, 3.04127447e-02f, -1.16583467e-01f, -2.04030294e-02f, -4.82717715e-02f, 1.85067952e-02f, -7.55046904e-02f, -3.21526490e-02f, 5.26996851e-02f,
  -5.04247285e-02f, 8.47827345e-02f, -5.86558655e-02f, -5.23589663e-02f, -1.09272502e-01f, -9.93413106e-02f, 4.23210114e-03f, 4.06231582e-02f, -5.26477285e-02f, 2.24507730e-02f,
  9.52622518e-02f, -8.87682736e-02f, 2.01633722e-02f, 9.45604593e-02f, 4.89575006e-02f, 1.48571715e-01f, 5.49944211e-03f, 2.30895076e-02f, 9.78971422e-02f, 2.01830128e-03f,
  6.35034740e-02f, 3.95781137e-02f, 1.95333757e-03f, 9.77060422e-02f, 1.13068245e-01f, 2.34972266e-03f, 7.63463927e-03f, 3.20607759e-02f, 1.38733864e-01f, 7.06555545e-02f,
  7.42059946e-02f, 3.27390246e-02f, 1.79116219e-01f, 8.48937258e-02f, 1.09060265e-01f, 1.61856711e-01f, 8.63555893e-02f, 1.51771992e-01f, 9.69109759e-02f, 1.54217184e-02f,
  -3.45525980e-01f, 2.12935254e-01f, 5.53718582e-02f, 3.90701182e-02f, 1.16960183e-01f, -1.22254752e-01f, -1.77111558e-03f, -1.28752992e-01f, 8.93322080e-02f, 2.05689177e-01f,
  1.75768971e-01f, 7.97286853e-02f, 1.44771188e-01f, 3.50322947e-02f, -4.92655002e-02f, 3.90556604e-02f, 7.50188306e-02f, -1.59557998e-01f, -2.56077260e-01f, -4.46501821e-02f,
  1.74653783e-01f, 1.71862002e-02f, -9.06487554e-02f, 5.23281284e-02f, 2.69884467e-01f, 2.05964983e-01f, 1.04169711e-01f, 1.81947321e-01f, 1.51814729e-01f, 3.27176630e-01f,
  2.03841925e-01f, 8.13166425e-03f, -4.97480109e-02f, 7.27514997e-02f, 1.91189542e-01f, 1.03655253e-02f, 7.50596449e-02f, 9.23046097e-02f, 5.50936759e-02f, 9.10791308e-02f,
  1.38755813e-01f, 1.08844854e-01f, 9.01090875e-02f, 1.44821569e-01f, 6.04551770e-02f, 1.24842459e-02f, 9.38762873e-02f, -2.92339046e-02f, 2.98775621e-02f, 1.47194475e-01f,
  2.51521349e-01f, 1.68484583e-01f, 8.45496170e-03f, 7.03173783e-03f, 2.56711785e-02f, 1.22819394e-01f, 7.72726834e-02f, 1.77091151e-01f, 9.06620361e-03f, 8.68980438e-02f,
  -4.73965146e-02f, -2.21349392e-02f, -6.03811890e-02f, -6.54416382e-02f, -5.27382493e-02f, 2.54584495e-02f, 7.54452404e-03f, 3.77675071e-02f, -9.10429880e-02f, -5.57873063e-02f,
  -8.48285947e-03f, -4.52819699e-03f, -2.26538815e-02f, -2.78943591e-02f, -6.18322678e-02f, 5.01107350e-02f, 2.51809433e-02f, 2.89190914e-02f, 4.12203558e-02f, -7.79844448e-02f,
  -5.61841987e-02f, 1.69108883e-02f, -2.95690075e-02f, -2.63904035e-03f, -4.42014560e-02f, -3.56849805e-02f, -9.11003053e-02f, -2.50983275e-02f, -5.96591942e-02f, 1.59895718e-02f,
  6.42798617e-02f, -1.55457497e-01f, 5.39650209e-03f, 4.90591163e-03f, 1.13790017e-03f, 5.49780093e-02f, 5.71045987e-02f, 7.41915554e-02f, 4.16679978e-02f, 3.10626123e-02f,
  8.12037140e-02f, 3.47453617e-02f, 1.01842172e-01f, 1.24607263e-02f, -9.87160392e-03f, -7.85314827e-04f, 7.81998336e-02f, 3.76305729e-02f, 4.41657938e-02f, 9.98538956e-02f,
  1.56848446e-01f, -6.73516020e-02f, 5.84616959e-02f, 1.22125084e-02f, 1.01099439e-01f, -9.71593801e-03f, 9.31821540e-02f, 1.80808958e-02f, -1.56711563e-01f, 1.80521514e-03f,
  3.14085752e-01f, 3.14285219e-01f, -2.87826490e-02f, 1.71182364e-01f, 1.65287077e-01f, 1.54568166e-01f, 2.29747221e-01f, 1.38810962e-01f, 1.04853712e-01f, 2.30792746e-01f,
  -2.76609566e-02f, -1.75717101e-01f, 1.98890397e-04f, -5.50777055e-02f, 3.33937146e-02f, 2.06966624e-01f, 1.82344660e-01f, 1.08274259e-01f, -3.77111733e-02f, 7.17194229e-02f,
  1.62245736e-01f, 3.89998890e-02f, 2.83221733e-02f, 1.62607908e-01f, 1.55714765e-01f, 1.44361779e-01f, 1.35714427e-01f, 1.51240051e-01f, 1.54313460e-01f, 2.53805935e-01f,
  -1.44448459e-01f, 1.24304101e-01f, 8.20612013e-02f, 7.38024712e-02f, 5.52032590e-02f, 6.10634834e-02f, 4.91922833e-02f, 1.26003370e-01f, 2.81427037e-02f, 7.28594735e-02f,
  -1.24988928e-02f, 4.42535942e-03f, 2.62035560e-02f, -5.27557218e-03f, 1.04600668e-01f, 1.34059370e-01f, 8.93694311e-02f, 9.39654708e-02f, 1.14984423e-01f, 6.66371286e-02f,
  7.63439164e-02f, 1.92469612e-01f, 2.00116530e-01f, 2.08752453e-01f, 3.11974101e-02f, 4.99658808e-02f, 7.91058689e-02f, 5.91783226e-02f, 2.16557220e-01f, 2.55739719e-01f,
  3.14979069e-02f, -8.44545588e-02f, -6.06036140e-03f, -1.97921060e-02f, -4.38965671e-02f, -9.08037834e-03f, -2.71575451e-02f, -1.75450221e-02f, -2.77182944e-02f, -6.45744428e-02f,
  -1.69464306e-03f, -7.61527717e-02f, -8.84068608e-02f, -4.82897228e-03f, -2.59084161e-02f, -2.47114282e-02f, 2.83961021e-03f, -3.09234951e-03f, -3.56104448e-02f, -7.35794976e-02f,
  -9.38084275e-02f, -9.59361196e-02f, -2.56067142e-02f, -9.06348899e-02f, -8.17880109e-02f, 2.70543178e-03f, -2.83510499e-02f, -1.41081259e-01f, -3.11106890e-02f, -3.92792374e-02f,
  -7.93293491e-02f, 4.42487793e-03f, 7.46297836e-02f, 2.74870843e-02f, 1.24965839e-01f, 3.91064174e-02f, 5.91088012e-02f, -1.08059468e-02f, 4.04506661e-02f, 9.76969376e-02f,
  -3.21963690e-02f, 1.13376781e-01f, 5.09264395e-02f, 1.13199517e-01f, 4.25743796e-02f, 4.89017926e-02f, 1.94251522e-01f, 3.49588096e-02f, 3.22691910e-03f, 1.19359270e-01f,
  5.20086288e-02f, 1.63426951e-01f, 1.57970428e-01f, 7.35773146e-02f, 1.26451984e-01f, 1.74722031e-01f, 1.69585481e-01f, 2.02682063e-01f, 9.37663466e-02f, 3.23644340e-01f,
  -9.17736366e-02f, -2.03229561e-02f, -2.88081728e-02f, -1.27848655e-01f, 5.04465960e-02f, 1.27240852e-01f, -1.54888323e-02f, 1.16045184e-01f, 2.13338435e-03f, -7.97845274e-02f,
  1.06465794e-01f, 2.59462118e-01f, 1.15567155e-01f, 1.79882318e-01f, -1.32908793e-02f, -1.34788781e-01f, -2.51647949e-01f, -1.45034596e-01f, 4.94137704e-02f, 1.07803509e-01f,
  5.92417456e-02f, -2.06268936e-01f, -1.80238038e-01f, -5.54678962e-02f, -1.57834202e-01f, -1.14819277e-02f, -1.48067981e-01f, -1.84254840e-01f, -1.02560908e-01f, -2.81229734e-01f,
  5.36783412e-02f, -1.58784494e-01f, 8.32515359e-02f, -1.03277154e-01f, -3.44520546e-02f, -1.51745424e-01f, -1.99653246e-02f, -1.92252189e-01f, -4.42835726e-02f, -2.45095585e-02f,
  -4.20021228e-02f, -6.50640056e-02f, -1.90644842e-02f, 2.19100434e-02f, -5.13545051e-02f, -7.90649280e-02f, -1.25148728e-01f, -2.07638919e-01f, -1.16843678e-01f, 1.79617703e-02f,
  9.40301828e-03f, -6.58643469e-02f, -4.01090533e-02f, -9.33296010e-02f, -6.78188130e-02f, -1.27460346e-01f, -1.35788083e-01f, -1.31323323e-01f, -1.99888781e-01f, -1.77996606e-01f,
  -1.75975189e-01f, 4.25009765e-02f, 7.26969098e-04f, 6.46935403e-02f, 1.21293239e-01f, 6.01009205e-02f, 9.43066850e-02f, -8.51528719e-03f, -1.10050915e-02f, -2.63000838e-02f,
  9.41544771e-02f, 6.83125779e-02f, 7.95880705e-02f, 6.76690182e-03f, 2.59069037e-02f, -7.78695047e-02f, 8.82396996e-02f, 2.50363201e-02f, -4.42990921e-02f, -2.86009139e-03f,
  3.70902978e-02f, 1.38434591e-02f, -1.64885074e-02f, -3.41762640e-02f, 6.41954364e-03f, 3.60268690e-02f, 1.41701087e-01f, 1.64029852e-01f, 1.46909714e-01f, 1.07785454e-02f,
  -8.10917392e-02f, -7.16278851e-02f, -1.69527847e-02f, -6.66889325e-02f, -1.67220026e-01f, -1.52163863e-01f, -4.22766916e-02f, -1.39966905e-01f, -2.77730245e-02f, -9.61472020e-02f,
  2.14025564e-02f, -1.27486929e-01f, -8.28673840e-02f, -8.17658976e-02f, -8.97205174e-02f, -6.75784498e-02f, -1.95071578e-01f, -4.48755361e-02f, -8.38698447e-02f, -5.07753193e-02f,
  -1.27801508e-01f, -1.07379980e-01f, 1.16175832e-02f, 1.39330113e-02f, 2.50792969e-02f, 5.41749187e-02f, 3.29677761e-02f, -1.15426309e-01f, -9.29094478e-02f, -2.12491900e-01f,
  -1.83529988e-01f, -7.06075206e-02f, 2.47710884e-01f, -8.61190483e-02f, 1.44096911e-01f, 1.22978851e-01f, 1.63784191e-01f, 8.58088955e-02f, -1.62109926e-01f, 6.56694546e-02f,
  -1.25615224e-01f, -2.33917251e-01f, -2.54620910e-01f, -2.14848235e-01f, -7.90425092e-02f, 1.92536145e-01f, 1.05868138e-01f, 4.00748663e-02f, -4.35876381e-03f, 5.55445347e-03f,
  -1.21483624e-01f, -6.82102069e-02f, -4.91899326e-02f, -3.53393964e-02f, -2.64544282e-02f, -9.81639624e-02f, 2.61566043e-03f, 2.09895931e-02f, -7.96110108e-02f, -2.56946473e-03f,
  -1.21757410e-01f, -1.28378004e-01f, -7.06789345e-02f, -2.56904632e-01f, -8.14209878e-02f, -9.31491032e-02f, -3.29649225e-02f, -6.13255464e-02f, -1.79086596e-01f, -1.31775975e-01f,
  -1.36549428e-01f, -1.99460745e-01f, -1.01584703e-01f, -3.05507854e-02f, -4.62753549e-02f, -1.44893974e-01f, -7.26885647e-02f, -4.63549942e-02f, -1.16400048e-01f, -9.22240764e-02f,
  -1.15251623e-01f, -8.80850777e-02f, -6.73464760e-02f, -7.52220303e-02f, -1.28289625e-01f, -1.33309633e-01f, -1.47706226e-01f, -3.02759390e-02f, 4.69715655e-04f, -1.21917836e-01f,
  8.23057517e-02f, 1.42242596e-01f, 4.35178494e-03f, -9.16559831e-04f, -1.80806518e-02f, -3.90255190e-02f, 2.47974209e-02f, -4.16198187e-02f, 2.08946299e-02f, -1.74279530e-02f,
  -1.54956896e-02f, -1.16561167e-02f, 9.16670542e-03f, 1.04739346e-01f, -1.36403192e-03f, 8.36634412e-02f, -4.95060496e-02f, -1.33281248e-02f, 9.26052965e-03f, 5.88600375e-02f,
  -2.06834730e-02f, 6.15169704e-02f, -5.01479581e-02f, -7.97585398e-02f, -3.35104428e-02f, 5.96004762e-02f, 4.79144454e-02f, 7.69710466e-02f, 7.78196901e-02f, 2.68786661e-02f,
  -3.21432561e-01f, -6.00367151e-02f, -1.44451454e-01f, -1.24345519e-01f, -1.60064343e-02f, -1.53929874e-01f, -1.50846586e-01f, -1.01985283e-01f, -6.56696409e-02f, -6.25561848e-02f,
  -6.95324689e-02f, -6.48601800e-02f, -8.30854252e-02f, -5.15257604e-02f, -1.05007686e-01f, -1.27929181e-01f, -7.62723461e-02f, -8.36408362e-02f, -1.35995951e-02f, 6.56863162e-03f,
  -5.95031418e-02f, 1.11669756e-03f, -2.13507675e-02f, -2.58285590e-02f, -7.81594291e-02f, -1.67991877e-01f, -1.35040447e-01f, -7.89124221e-02f, -1.19227447e-01f, -4.24898677e-02f,
  -4.66590941e-01f, 4.78333943e-02f, 2.41144910e-01f, -7.15605989e-02f, -2.85828877e-02f, -3.79998460e-02f, -1.57435670e-01f, -9.87239704e-02f, -1.41709253e-01f, 6.01008721e-02f,
  -4.05030325e-03f, 9.16459486e-02f, 2.37215936e-01f, 2.24233001e-01f, 1.10141054e-01f, 1.72826022e-01f, 2.86614776e-01f, 2.56452262e-01f, 1.37959749e-01f, -3.41007225e-02f,
  1.13772482e-01f, 6.88297972e-02f, 4.22193669e-02f, 9.78084728e-02f, 3.96084301e-02f, 1.74428776e-01f, 1.67564139e-01f, 8.57927278e-02f, 1.16258644e-01f, 3.14618498e-01f,
  1.98476672e-01f, -1.21074535e-01f, 6.89186677e-02f, 4.42973748e-02f, 8.19619969e-02f, 6.20877631e-02f, 2.48662792e-02f, 4.81097810e-02f, 4.60488349e-02f, 1.09404840e-01f,
  8.71772841e-02f, 3.74571234e-02f, 1.34653941e-01f, 1.51804581e-01f, 1.28400818e-01f, -5.78170037e-03f, 1.30259022e-01f, 9.36170816e-02f, 1.42853945e-01f, 6.68230206e-02f,
  4.78489213e-02f, 8.15695673e-02f, -1.15636466e-02f, 1.38432518e-01f, 1.20568268e-01f, 8.94548967e-02f, 9.91499797e-02f, 7.72541836e-02f, -1.10333143e-02f, 7.57622942e-02f,
  -2.89530531e-02f, 4.94533405e-02f, -2.51445305e-02f, 2.26055942e-02f, -2.16096407e-03f, -7.16272146e-02f, -4.63533178e-02f, -7.33672082e-03f, -6.22931197e-02f, -3.07354983e-02f,
  3.28649022e-02f, -2.33025267e-03f, -4.61991318e-02f, -3.89029123e-02f, 7.47772530e-02f, -8.79283808e-03f, -3.46842147e-02f, 3.94622087e-02f, 1.02641922e-03f, 5.31232636e-03f,
  -4.19065244e-02f, -2.59816498e-02f, 6.97212992e-03f, -1.39250457e-02f, -3.01253162e-02f, -3.09039056e-02f, 5.88055775e-02f, -6.08204640e-02f, -1.94273479e-02f, -8.35162550e-02f,
  5.46046086e-02f, 1.75104126e-01f, 7.19358250e-02f, -5.74178342e-03f, 3.20064910e-02f, 1.16412960e-01f, 1.08383194e-01f, 8.92162696e-02f, 1.05860002e-01f, -1.47675555e-02f,
  2.83273179e-02f, 1.37778018e-02f, 1.13383599e-01f, 2.08174642e-02f, -4.43429947e-02f, 6.72289804e-02f, -8.34860094e-03f, 1.27657011e-01f, 4.95151132e-02f, 6.52162507e-02f,
  4.38884608e-02f, -9.14067701e-02f, -4.74978909e-02f, -2.42959782e-02f, -5.82797714e-02f, -6.75727651e-02f, -1.56874955e-02f, -4.62917332e-03f, -8.36834684e-02f, -5.36541641e-02f,
  -1.99966177e-01f, 8.37518424e-02f, -1.56057924e-01f, 9.32941958e-02f, -2.96493731e-02f, -2.54563779e-01f, -1.28874347e-01f, -1.23376735e-01f, -4.02132310e-02f, -1.08765662e-02f,
  3.33013795e-02f, -6.91958815e-02f, -7.06645325e-02f, -1.58357069e-01f, -2.17117280e-01f, -1.19912714e-01f, -2.38243621e-02f, -2.03313813e-01f, -2.65215486e-01f, -1.36827484e-01f,
  1.12344980e-01f, 8.91464800e-02f, 2.88961343e-02f, -1.38337286e-02f, 1.49054956e-02f, -9.82438102e-02f, 1.64700318e-02f, -7.59731159e-02f, -6.56134486e-02f, 1.49642050e-01f,
  -2.96250790e-01f, -1.01996601e-01f, -2.05207333e-01f, -1.05277136e-01f, -6.38020262e-02f, -1.23938091e-01f, -6.88550100e-02f, -1.24028116e-01f, -1.82551052e-03f, -7.77136162e-02f,
  -4.19779532e-02f, -1.59355719e-02f, -1.19446941e-01f, -3.62599306e-02f, -1.23443425e-01f, -1.48791298e-01f, -5.73386103e-02f, -6.52616099e-02f, -1.78264663e-01f, -1.68539703e-01f,
  -7.59699717e-02f, -1.27609447e-01f, -1.35603234e-01f, -1.94506913e-01f, -1.33120626e-01f, -2.36982748e-01f, -2.19002828e-01f, -2.43545830e-01f, -2.90060729e-01f, -1.28979102e-01f,
  -2.22484432e-02f, 1.20470650e-01f, 6.37970120e-02f, 1.96280986e-01f, 1.84681296e-01f, 7.33233467e-02f, 1.05091065e-01f, 3.51960324e-02f, 1.06752239e-01f, 8.89149383e-02f,
  8.74864683e-02f, 1.25524253e-01f, 2.19008535e-01f, 8.31597075e-02f, 7.90698528e-02f, 7.84552768e-02f, 1.24907441e-01f, 1.54168174e-01f, 1.39346898e-01f, 1.78958356e-01f,
  6.24286085e-02f, 8.00502393e-03f, 1.39401034e-01f, 1.62950590e-01f, 1.63208008e-01f, 5.99638000e-02f, 9.75498632e-02f, 1.16579168e-01f, 1.81110352e-02f, 6.62785247e-02f,
  -6.51647449e-02f, -1.64429158e-01f, -1.69418842e-01f, -9.21498612e-02f, -1.54939696e-01f, -9.37539265e-02f, -1.34960413e-01f, -3.67189012e-02f, -3.93668376e-02f, -1.18805826e-01f,
  -1.05283529e-01f, -1.90842494e-01f, -1.01845033e-01f, -6.80828914e-02f, -1.45830050e-01f, -1.94834217e-01f, -1.15126804e-01f, -1.14741996e-01f, -1.29964605e-01f, -2.43765898e-02f,
  -9.32644308e-02f, -2.05320194e-01f, -2.58000195e-01f, -2.39041075e-01f, -1.20009355e-01f, -2.51386553e-01f, -1.68734178e-01f, -1.42302573e-01f, -2.01678082e-01f, -1.16685845e-01f,
  5.31831197e-02f, -6.67573139e-02f, -2.10851207e-01f, 9.60893556e-02f, 4.56474498e-02f, -8.02764669e-02f, -1.98720396e-01f, -5.57607822e-02f, 2.22229153e-01f, 7.65137300e-02f,
  5.95206432e-02f, 2.07967460e-01f, 3.12978588e-02f, 8.02202597e-02f, -3.95878889e-02f, -9.77382660e-02f, -1.74791142e-01f, -1.49831861e-01f, 1.72285754e-02f, 6.62575141e-02f,
  9.76641029e-02f, 1.52757153e-01f, 1.58010930e-01f, 7.57078603e-02f, 6.05997704e-02f, 8.58319551e-02f, -1.06741756e-01f, -8.67608115e-02f, -1.60709307e-01f, -1.52513981e-01f,
  -1.63158581e-01f, -1.71591550e-01f, -5.26716076e-02f, 1.80381849e-01f, 3.27755995e-02f, 3.49805988e-02f, -1.02903888e-01f, 2.82816272e-02f, 8.05550441e-02f, -3.06305867e-02f,
  -5.01268022e-02f, 6.28070086e-02f, -3.73416357e-02f, 9.04177129e-02f, -5.41538838e-03f, -1.89230144e-02f, 7.46159554e-02f, -6.31743390e-03f, 7.54868239e-02f, -4.81763147e-02f,
  9.14883614e-02f, -3.70952003e-02f, -5.58250472e-02f, 7.35038072e-02f, -6.63103610e-02f, 7.37518370e-02f, 8.79555847e-03f, -1.10328257e-01f, -1.16688371e-01f, -9.54983234e-02f,
  -4.11087424e-02f, -3.55167538e-02f, -3.70376259e-02f, -2.98500657e-02f, 4.93738763e-02f, -5.75754838e-03f, -1.00085191e-01f, -6.38303384e-02f, -3.74015123e-02f, -5.31138927e-02f,
  2.01826729e-02f, -1.54631399e-02f, -5.14363125e-02f, -3.96387875e-02f, -5.35805942e-03f, -5.05624525e-02f, -9.74283144e-02f, 8.94314051e-03f, -1.01067245e-01f, -8.18849355e-02f,
  -3.90336365e-02f, -1.01459987e-01f, -9.17399302e-03f, -1.08743116e-01f, -2.76303608e-02f, -4.15734239e-02f, -2.23631579e-02f, 4.16232571e-02f, 7.30963945e-02f, -1.44212767e-01f,
  1.95569366e-01f, 1.29901409e-01f, -6.20425791e-02f, 2.29246281e-02f, -5.98467402e-02f, 2.79531088e-02f, 2.82409061e-02f, -8.74456298e-03f, 5.86047955e-02f, 3.32940482e-02f,
  1.41152469e-02f, -4.10472937e-02f, 6.35264814e-02f, -4.75014709e-02f, 3.20145302e-03f, 2.53691301e-02f, 4.74064052e-02f, -8.86827409e-02f, 6.71950430e-02f, 7.28726089e-02f,
  4.65817191e-02f, 3.21245939e-02f, -4.82165329e-02f, 6.37577241e-03f, -9.62344743e-03f, -6.63258284e-02f, -1.65267885e-01f, -5.22055216e-02f, -1.35243863e-01f, -1.32843912e-01f,
  -7.58051351e-02f, -6.71276301e-02f, 1.34035721e-01f, 1.23050334e-02f, 2.64566708e-02f, 3.20929922e-02f, 1.09612286e-01f, 1.72741562e-01f, 1.13034494e-01f, -4.30458672e-02f,
  6.23514429e-02f, 5.21109141e-02f, 2.23894864e-02f, 5.40927462e-02f, 1.91641018e-01f, -3.73198092e-02f, -1.95087828e-02f, -3.69982445e-03f, -7.04213828e-02f, -1.26444250e-01f,
  -1.54303595e-01f, -1.03405595e-01f, -4.41440232e-02f, -1.03738070e-01f, -2.45829433e-01f, -2.05003321e-01f, -1.41165376e-01f, -2.01453954e-01f, -2.08808899e-01f, -2.71499693e-01f,
  -1.65199026e-01f, 1.15450010e-01f, 4.19947021e-02f, -2.33855844e-02f, 5.62875196e-02f, 7.49606118e-02f, 1.14814816e-02f, 5.21730147e-02f, 2.19401475e-02f, 5.28740287e-02f,
  -4.08600457e-03f, 7.49714114e-03f, 9.09655616e-02f, -5.15668504e-02f, 2.48067044e-02f, 9.90784541e-02f, 7.60405138e-03f, 1.71170160e-01f, 8.26840252e-02f, -3.26818302e-02f,
  -3.60576771e-02f, -1.13969967e-01f, 2.24290881e-02f, 3.67998220e-02f, 9.77385864e-02f, 9.22859833e-02f, -6.87017068e-02f, -1.39610633e-01f, 5.70765920e-02f, -1.54632673e-01f,
  -1.08516812e-01f, -3.56557146e-02f, 2.96888165e-02f, -1.03985788e-02f, -3.65580693e-02f, 1.16524927e-01f, 4.64073680e-02f, -5.02848066e-02f, -8.33966583e-03f, -6.01127893e-02f,
  -4.84333485e-02f, 4.17112410e-02f, 2.20988858e-02f, -4.58587473e-03f, -6.61570281e-02f, -4.66081873e-02f, -1.05292030e-01f, -2.00665370e-02f, -6.98428005e-02f, 2.86400449e-02f,
  3.25946026e-02f, -7.89782330e-02f, -5.54206073e-02f, -4.28388678e-02f, -6.12610616e-02f, 3.66806574e-02f, -2.21645664e-02f, -1.02807134e-01f, -5.22898212e-02f, 1.76438678e-03f,
  -1.18491709e-01f, 3.06170374e-01f, -9.01590884e-02f, 1.61551815e-02f, 6.03812449e-02f, -2.57450398e-02f, -2.07238588e-02f, 3.10181845e-02f, 8.43881667e-02f, -3.82245481e-02f,
  1.80805176e-02f, 6.92450926e-02f, 3.40557918e-02f, 8.35933685e-02f, 2.53511351e-02f, 1.56419557e-02f, 1.12316161e-01f, -2.00668387e-02f, 4.54009883e-02f, -3.43072414e-02f,
  5.30501269e-02f, -1.64665915e-02f, -9.81116742e-02f, -9.81142744e-02f, -3.19405235e-02f, 3.90554778e-03f, -1.35640264e-01f, -4.29252721e-02f, -8.72876421e-02f, -1.24712542e-01f,
  -3.64320636e-01f, -1.81463599e-01f, -2.07263872e-01f, -2.49600291e-01f, 8.76773298e-02f, 1.55559108e-01f, 1.71349198e-01f, -4.77423370e-02f, -1.48490399e-01f, 4.05773036e-02f,
  -2.22175140e-02f, -2.79168808e-03f, -7.94498399e-02f, -1.24009587e-01f, -9.63193849e-02f, -5.55892773e-02f, -9.77103263e-02f, -1.28676325e-01f, -6.84197433e-03f, 1.69533074e-01f,
  1.42892331e-01f, -1.81965128e-01f, -1.15511961e-01f, -9.59522352e-02f, -1.05587929e-01f, -7.28770271e-02f, -1.79093331e-01f, -1.46550417e-01f, 2.41233278e-02f, -1.07361719e-01f,
  2.09313959e-01f, -5.82503155e-03f, 6.82163835e-02f, 4.29037735e-02f, 1.08466670e-01f, -2.07497329e-02f, 7.54247904e-02f, -2.10400554e-03f, 7.13664293e-02f, 8.86327624e-02f,
  1.70909315e-02f, -2.29704636e-03f, -3.22619267e-02f, -4.90904273e-03f, 3.80790122e-02f, 9.23205614e-02f, 2.56815390e-03f, -1.27279893e-01f, -7.24095628e-02f, 4.79288734e-02f,
  1.49131894e-01f, 1.56378180e-01f, -7.24703521e-02f, -6.80536553e-02f, -6.90553188e-02f, -2.84841247e-02f, -5.56043200e-02f, -2.60455012e-02f, 4.32160012e-02f, -1.41058750e-02f,
  -1.04405899e-02f, 1.53954504e-02f, -6.89519243e-03f, -1.25206351e-01f, -5.16549237e-02f, -5.21349944e-02f, -6.61511868e-02f, -3.21972813e-03f, -3.23556662e-02f, 1.51225850e-02f,
  2.25812308e-02f, -6.02402911e-02f, -5.41533530e-02f, -5.41576631e-02f, 9.74328890e-02f, -1.07710905e-01f, -5.12816608e-02f, -3.09740119e-02f, 8.83871596e-03f, -2.54748110e-03f,
  -1.11541413e-02f, -8.34208801e-02f, -7.70163164e-02f, -5.95954210e-02f, -1.13282152e-01f, -8.70625973e-02f, -5.99620193e-02f, -1.07852253e-03f, -4.09737378e-02f, -3.89099121e-02f,
  3.93611938e-02f, 2.16138493e-02f, 1.39405012e-01f, 2.87212115e-02f, 5.40373437e-02f, 3.63364033e-02f, 1.18774951e-01f, 9.33540836e-02f, -4.92251068e-02f, 1.26183912e-01f,
  1.58821672e-01f, 4.48917747e-02f, 5.83019555e-02f, 7.72747025e-02f, 5.09300604e-02f, 1.27152547e-01f, 1.32653713e-01f, 2.72391587e-02f, 5.91882728e-02f, 7.95697495e-02f,
  -1.33397831e-02f, 1.17340215e-01f, 1.79777876e-01f, 6.82360083e-02f, -2.20594350e-02f, 1.19113371e-01f, 1.15047164e-01f, 4.07341942e-02f, 1.13056883e-01f, 4.44987714e-02f,
  -2.56688446e-01f, 2.73531288e-01f, 3.93768966e-01f, 2.87352838e-02f, 5.85345738e-02f, 7.31794611e-02f, 9.57392380e-02f, 1.26436567e-02f, -1.80337131e-02f, 7.69208372e-02f,
  1.79264277e-01f, 1.78358883e-01f, 1.69861838e-01f, 1.54377654e-01f, 2.74015844e-01f, 2.04673514e-01f, 1.38834164e-01f, 1.82871282e-01f, 9.94765088e-02f, 2.45595444e-02f,
  6.31003305e-02f, 1.05907112e-01f, 1.47005171e-01f, 1.33653566e-01f, 4.72238176e-02f, 6.49166256e-02f, 1.62577018e-01f, 1.46363124e-01f, 1.21310890e-01f, 7.26325288e-02f,
  3.37148339e-01f, -5.44069968e-02f, -5.88924508e-04f, 1.61173325e-02f, 1.08435608e-01f, -6.71208203e-02f, 2.04819944e-02f, -5.79611398e-02f, -9.51252133e-02f, -3.27039994e-02f,
  3.02119348e-02f, 1.98809393e-02f, -7.13932328e-03f, 9.10736471e-02f, -4.34364378e-02f, 2.27238629e-02f, -2.16143187e-02f, 9.71504301e-02f, -2.26962771e-02f, 5.82036451e-02f,
  1.01898864e-01f, 1.70943774e-02f, 3.78954075e-02f, 2.09703557e-02f, 7.18457475e-02f, 8.86390544e-03f, 8.95091966e-02f, 4.24071029e-02f, 4.88127358e-02f, 6.45240024e-02f,
  -7.87738115e-02f, 7.43136778e-02f, -2.61594336e-02f, -9.10726637e-02f, -9.35903192e-02f, 3.44915166e-02f, 2.15980224e-02f, 2.45480472e-03f, -6.30064402e-03f, 1.54571072e-03f,
  7.84611423e-03f, -4.58417907e-02f, 3.10154874e-02f, -3.60985361e-02f, -7.40788784e-03f, 2.20922939e-02f, -4.67678625e-03f, 3.94660123e-02f, -5.51404012e-03f, -4.52731140e-02f,
  -7.81860575e-02f, 3.96772381e-03f, 3.48554477e-02f, -5.30223921e-02f, 6.89819381e-02f, -3.53162810e-02f, -7.10128248e-03f, -6.99756145e-02f, -5.00358492e-02f, -2.40772497e-02f,
  1.47125676e-01f, 8.58540908e-02f, 1.53943421e-02f, 2.23939642e-02f, 7.33238980e-02f, -5.19258752e-02f, 1.88242476e-02f, -9.78966132e-02f, -4.07957006e-03f, -4.11796570e-02f,
  2.65347194e-02f, -4.13265713e-02f, 1.69629768e-01f, 3.58272977e-02f, 8.15479085e-02f, -2.86979396e-02f, 9.49289501e-02f, 8.25367048e-02f, -5.48769301e-03f, -1.93790030e-02f,
  -2.93922867e-03f, 6.81584924e-02f, 6.21888787e-02f, -1.08104069e-02f, 4.23881225e-02f, 8.46096128e-02f, 1.68390453e-01f, 7.50061870e-02f, 5.10830544e-02f, -1.13753630e-02f,
  4.88163270e-02f, 3.13938707e-01f, 3.37475508e-01f, 2.08942834e-02f, -9.41971391e-02f, -3.75119746e-02f, 1.89667389e-01f, 4.40922752e-02f, -7.72748515e-02f, 1.85462907e-01f,
  -6.32164702e-02f, -1.21678308e-01f, -2.08180696e-02f, -4.72066365e-02f, 8.37445557e-02f, 1.57844201e-01f, 2.26794466e-01f, -2.37538312e-02f, -9.40342993e-02f, -2.51041561e-01f,
  -1.05745085e-01f, 4.85418411e-03f, -5.76075818e-03f, 6.14171140e-02f, 5.77525720e-02f, -8.75806883e-02f, 1.88238353e-01f, 7.05887228e-02f, 1.87486932e-01f, 1.73984855e-01f,
  -1.27901044e-02f, 1.80515930e-01f, -1.06721791e-02f, -3.45680639e-02f, 6.57919794e-02f, 4.09230404e-02f, 1.09146975e-01f, 2.20004376e-02f, 9.69803855e-02f, 9.42204967e-02f,
  6.85248375e-02f, 1.04757898e-01f, 1.38815418e-01f, 6.86048269e-02f, -2.23494088e-03f, 7.96559453e-02f, 1.04962029e-01f, 1.22783758e-01f, 4.59281579e-02f, 6.68641627e-02f,
  2.99075525e-02f, 9.24228728e-02f, -5.31708263e-03f, 5.55366129e-02f, 1.05827801e-01f, -2.21927390e-02f, 5.97401336e-02f, 9.47813094e-02f, 7.04011470e-02f, 8.85633454e-02f,
  -6.33800179e-02f, -1.69107039e-02f, -6.72003925e-02f, -4.73842397e-02f, 1.56482179e-02f, -9.68618970e-03f, 3.70869250e-03f, -7.85637721e-02f, -4.77310680e-02f, -8.41828138e-02f,
  1.65646076e-02f, -6.29304647e-02f, 3.11364103e-02f, -7.08897561e-02f, -3.72693278e-02f, -9.77349356e-02f, -9.60625410e-02f, 5.47437854e-02f, -9.92418379e-02f, 1.86691666e-03f,
  -1.21388044e-02f, -6.80671036e-02f, 4.91141304e-02f, -3.92119549e-02f, -2.83899792e-02f, -4.14576866e-02f, -6.20917156e-02f, -5.38432710e-02f, 4.34988597e-03f, -9.10796076e-02f,
  -1.54685304e-01f, 5.77879027e-02f, -2.98450459e-02f, 1.31096346e-02f, 3.30799110e-02f, 6.37632906e-02f, -4.77726851e-03f, 3.05903740e-02f, -2.25068033e-02f, 1.29116122e-02f,
  -1.59512386e-02f, 5.86277023e-02f, -1.17673781e-02f, 1.03387125e-01f, -6.24907017e-02f, 3.14794891e-02f, -4.29422334e-02f, 5.64719513e-02f, -6.21304521e-03f, 9.10226032e-02f,
  7.87307173e-02f, 1.79011095e-02f, -2.53184624e-02f, -9.41878706e-02f, -5.00691570e-02f, -1.76326618e-01f, -1.20619744e-01f, -1.19967274e-01f, -6.81770071e-02f, -1.11413166e-01f,
  1.29857838e-01f, -9.54933465e-02f, 1.30312443e-01f, 1.75536335e-01f, 2.55602986e-01f, 2.46728346e-01f, 1.18889265e-01f, 1.82751343e-01f, 1.61050603e-01f, 1.25742843e-03f,
  1.45906806e-01f, 1.10661916e-01f, 1.67754024e-01f, 1.17486119e-01f, 6.22890927e-02f, -4.91676629e-02f, -1.78134572e-02f, 9.19454172e-02f, 2.11854473e-01f, 1.99787781e-01f,
  1.04084380e-01f, 7.82080516e-02f, 1.07923143e-01f, 1.45883188e-01f, 1.20364420e-01f, 1.42421752e-01f, 4.68021147e-02f, 7.72350132e-02f, 6.30846918e-02f, -7.65091181e-02f,
  3.72381955e-02f, 1.14868350e-01f, 2.60394096e-01f, 1.50240093e-01f, 2.21112266e-01f, 1.61664262e-01f, 1.95465237e-01f, 1.99057013e-01f, 1.67730376e-01f, 6.95494264e-02f,
  6.77817091e-02f, 1.58009097e-01f, 8.43452737e-02f, 6.95065036e-02f, 1.44766122e-01f, 1.93464175e-01f, 2.09970906e-01f, 1.30076766e-01f, 1.20507412e-01f, 1.86673164e-01f,
  8.83375555e-02f, 2.35896900e-01f, 2.90039748e-01f, 2.37993553e-01f, 2.45054424e-01f, 2.45457321e-01f, 1.13824479e-01f, 1.52783662e-01f, 1.54701382e-01f, 1.39513388e-01f,
  2.56648697e-02f, -2.06024088e-02f, -8.45596567e-02f, -1.55434757e-01f, -1.87984779e-01f, -1.46872967e-01f, -9.83347669e-02f, -1.95616499e-01f, -1.50075465e-01f, -9.69738513e-02f,
  -1.24775365e-01f, -5.84585853e-02f, -8.95998552e-02f, -1.00276425e-01f, -8.05291906e-02f, -1.36372969e-01f, -1.58260405e-01f, -1.55566633e-01f, -9.79689434e-02f, -1.54961169e-01f,
  -2.24557340e-01f, -4.41241674e-02f, -8.16036463e-02f, -1.26780033e-01f, -1.65900081e-01f, -9.52737704e-02f, -2.40020290e-01f, -8.58831704e-02f, -1.88395515e-01f, -9.95129645e-02f,
  2.29414314e-01f, 1.28789172e-01f, -1.48936426e-02f, 1.68066263e-01f, 2.02402070e-01f, 1.79053038e-01f, 1.86543435e-01f, 1.42376825e-01f, 9.40874591e-02f, 6.88307583e-02f,
  1.92679033e-01f, 2.07999364e-01f, 1.64930239e-01f, 8.95134136e-02f, 2.29821905e-01f, 1.51447311e-01f, 1.13057218e-01f, 2.11030424e-01f, 2.09552273e-01f, 1.49780229e-01f,
  1.30993843e-01f, 1.38891309e-01f, 2.89116025e-01f, 1.52367204e-01f, 1.22020878e-01f, 2.05860034e-01f, 1.96895063e-01f, 2.64820099e-01f, 2.43950695e-01f, 2.37475336e-01f,
  1.41714871e-01f, -4.40870337e-02f, -9.29355845e-02f, 1.88266840e-02f, -1.45482153e-01f, -1.80208772e-01f, -7.03409016e-02f, -9.26438794e-02f, -1.22799560e-01f, 5.81117682e-02f,
  -3.40049118e-02f, -1.12122454e-01f, -2.75810570e-01f, -1.39712468e-01f, -2.43000358e-01f, -2.14353085e-01f, -2.51212567e-01f, -1.53145373e-01f, -1.35322407e-01f, -3.56493443e-02f,
  -8.01057369e-02f, 1.23574026e-01f, 9.35406890e-03f, 1.98051557e-02f, 1.24493569e-01f, 2.45795753e-02f, 2.74000689e-02f, 5.07861301e-02f, 4.17232774e-02f, 5.46758696e-02f,
  7.76546225e-02f, 8.12366530e-02f, -8.34300071e-02f, -2.11718112e-01f, -1.40884325e-01f, -4.52110171e-02f, -1.13831304e-01f, -1.42980486e-01f, -1.16075851e-01f, -2.23462936e-02f,
  -2.22096682e-01f, -1.49207398e-01f, -9.33965817e-02f, -1.14729315e-01f, -9.18017924e-02f, -8.75180364e-02f, -1.59970731e-01f, -3.51607539e-02f, -2.26235002e-01f, -1.97636023e-01f,
  -8.33598077e-02f, -1.52581828e-02f, -1.16774373e-01f, -1.78955242e-01f, -5.68089895e-02f, -1.76609442e-01f, -2.53341813e-02f, -4.34142351e-02f, -1.72165148e-02f, 1.58583298e-01f,
  1.72009960e-01f, 1.06726408e-01f, 6.33475855e-02f, 1.76707491e-01f, 1.16692692e-01f, 6.95778951e-02f, 1.07277013e-01f, 1.49664134e-01f, 4.05814052e-02f, 8.77825022e-02f,
  4.39862050e-02f, 9.93888229e-02f, 9.12757404e-03f, 1.02928571e-01f, 1.30138993e-01f, 2.08371077e-02f, 8.79108235e-02f, 1.08008191e-01f, 8.74686614e-02f, 1.38622895e-01f,
  1.60775781e-01f, 2.38461662e-02f, 4.46282029e-02f, 9.47117209e-02f, -1.66438259e-02f, 1.01667777e-01f, 1.01527870e-01f, 5.13048582e-02f, 9.93060693e-02f, 7.81857669e-02f,
  4.74581085e-02f, -3.27166915e-01f, -2.08823644e-02f, -2.98514236e-02f, -4.62933397e-03f, -1.40059710e-01f, -1.05065972e-01f, -1.20458886e-01f, -1.76937282e-01f, -6.13522194e-02f,
  -1.67865783e-01f, -9.71144885e-02f, -1.57193825e-01f, -1.15418047e-01f, -1.10886030e-01f, -4.83406559e-02f, -1.98170602e-01f, -1.62243560e-01f, -2.37433434e-01f, -7.50345066e-02f,
  -1.34130463e-01f, -1.24022610e-01f, -4.25508283e-02f, -6.04398847e-02f, -1.22242711e-01f, -1.01872995e-01f, -5.28578088e-02f, 3.97819951e-02f, -1.37591705e-01f, 2.54650693e-02f,
  -5.64352162e-02f, 5.52963950e-02f, 1.80039451e-01f, 1.93646580e-01f, 1.15163811e-01f, 8.45601410e-03f, 1.14826843e-01f, -5.73142543e-02f, 2.94826571e-02f, 1.24822788e-01f,
  2.02036381e-01f, 2.03538492e-01f, 1.97838947e-01f, 1.40667394e-01f, 5.74781187e-02f, 1.01336755e-01f, 5.48508205e-03f, 9.13067460e-02f, 1.88279580e-02f, 1.21419579e-01f,
  9.82168615e-02f, 1.56590957e-02f, 4.85486872e-02f, 3.54939774e-02f, 7.06875473e-02f, 4.92263623e-02f, 1.34024590e-01f, 6.45557791e-02f, 1.09731071e-01f, 1.44271165e-01f,
  2.34819710e-01f, 3.83879021e-02f, 7.59933665e-02f, 6.62635639e-02f, 1.55684724e-01f, 3.02856173e-02f, 1.45207960e-02f, 7.78345913e-02f, 9.01140571e-02f, 1.33990020e-01f,
  1.43281594e-01f, -2.27443851e-03f, 1.00466058e-01f, 1.74033135e-01f, 2.68295202e-02f, 1.25163943e-01f, 4.53916527e-02f, -2.76547950e-03f, 6.26703203e-02f, -2.53204294e-02f,
  1.44893751e-01f, 1.54719159e-01f, 1.08938487e-02f, 6.86569884e-02f, 9.20074899e-03f, 4.41048071e-02f, -8.57002288e-03f, 8.66370052e-02f, 2.78121624e-02f, 6.69884458e-02f,
  -1.44797534e-01f, -7.97687843e-02f, -6.16884865e-02f, -4.00406756e-02f, -9.16923732e-02f, 3.67194228e-02f, -4.95950021e-02f, -6.71133995e-02f, -6.23151055e-03f, -2.53375294e-03f,
  -8.79586488e-02f, -1.55386105e-02f, 3.58526856e-02f, -4.44202945e-02f, -1.70849841e-02f, -2.99179405e-02f, -8.37605968e-02f, 2.97550025e-04f, -9.09837708e-02f, -9.18676481e-02f,
  1.75073817e-02f, -6.19994849e-02f, -9.83238518e-02f, -2.27339789e-02f, 9.50962957e-03f, -3.50984104e-04f, -8.69963840e-02f, -8.03732499e-02f, -1.16626047e-01f, -1.03684114e-02f,
  1.81321993e-01f, -6.09245151e-02f, 1.57088600e-02f, -1.01241194e-01f, 6.55956864e-02f, -2.48871874e-02f, 3.67035307e-02f, -4.06309366e-02f, 1.07645042e-01f, 3.68068554e-02f,
  1.56248838e-01f, 2.40194723e-02f, 9.70526189e-02f, 4.98292632e-02f, 7.26303533e-02f, -2.43119039e-02f, -2.33108774e-02f, 3.70122232e-02f, 8.38652924e-02f, 2.60400474e-02f,
  -1.74895732e-03f, -6.56182170e-02f, -5.28660826e-02f, 2.07864661e-02f, -7.60220690e-03f, -6.79502711e-02f, 8.40563923e-02f, -2.43114978e-02f, 1.41987288e-02f, -1.54656591e-02f,
  -2.94308215e-01f, -2.60201454e-01f, -1.54378816e-01f, -2.53266245e-01f, -4.00229655e-02f, 1.60360262e-01f, 2.09363595e-01f, 1.47265434e-01f, -5.33796288e-02f, -2.17116103e-02f,
  8.24289024e-02f, 1.28807276e-01f, 3.95896733e-02f, 1.86529905e-01f, 1.76534608e-01f, 1.69971120e-02f, -1.60038829e-01f, 8.23215842e-02f, 1.94750428e-01f, 1.80308640e-01f,
  -6.45969063e-03f, -2.06185073e-01f, -9.51824337e-02f, -1.10029355e-01f, -1.71720847e-01f, 1.94612555e-02f, -2.10028842e-01f, -1.42992720e-01f, -6.62686080e-02f, -3.84853005e-01f,
  -1.29724154e-02f, -8.63801315e-03f, 1.59716204e-01f, 2.24698037e-02f, -1.59078520e-02f, 7.59362057e-02f, 1.42027780e-01f, -6.04729317e-02f, 5.81488945e-02f, 2.62619890e-02f,
  1.25494851e-02f, 7.59418085e-02f, 3.57122533e-02f, 5.88688478e-02f, 8.58645588e-02f, 1.57539755e-01f, -3.01752221e-02f, -3.61449756e-02f, 3.31761735e-03f, 1.77078061e-02f,
  -5.52978851e-02f, -2.23518573e-02f, 2.67635044e-02f, 1.09610550e-01f, 1.36404559e-01f, 9.25898030e-02f, 1.55971259e-01f, -2.97215376e-02f, 2.00888261e-01f, -2.37795804e-02f,
  -4.00257930e-02f, -1.15056299e-01f, -7.95121118e-02f, 1.33094742e-04f, -6.53612539e-02f, -2.64964383e-02f, -2.09724574e-04f, 3.03195342e-02f, -7.87570179e-02f, -7.70737752e-02f,
  -5.46378270e-03f, -3.86876687e-02f, 3.38891372e-02f, -3.23725455e-02f, 8.45544785e-03f, 3.32940333e-02f, -7.24243745e-02f, 6.74388707e-02f, 3.26564834e-02f, -3.34624611e-02f,
  2.78066900e-02f, 3.19182798e-02f, 3.69344577e-02f, 4.73539485e-03f, 6.56300634e-02f, -8.25264864e-03f, 3.31391469e-02f, -6.81429543e-03f, 2.31454931e-02f, -1.90754402e-02f,
  4.06612530e-02f, 2.28319436e-01f, -5.80578633e-02f, 6.96795657e-02f, -3.31041776e-02f, 1.25777982e-02f, -1.67062953e-02f, 4.54303473e-02f, -3.75373028e-02f, 1.80679262e-02f,
  1.41241893e-01f, 4.46047373e-02f, 1.92735065e-02f, -4.69223969e-02f, 2.66313367e-02f, 1.51831778e-02f, -4.73839641e-02f, 1.11371703e-01f, 4.18489091e-02f, -5.01466282e-02f,
  2.56644785e-02f, 5.09349667e-02f, 7.51859322e-02f, 7.44450539e-02f, 5.82935959e-02f, 2.42825270e-01f, 3.16607282e-02f, 4.76986374e-04f, 1.95873365e-01f, 2.39840727e-02f,
  2.65022337e-01f, -9.08544511e-02f, -6.36150017e-02f, 1.61265031e-01f, -1.63553879e-01f, -2.12146431e-01f, -1.22284494e-01f, 9.85365510e-02f, 9.05267745e-02f, -1.49456337e-01f,
  -3.03961664e-01f, -1.61757126e-01f, -1.04609229e-01f, -1.33503890e-02f, 1.39351070e-01f, -5.97682260e-02f, 1.42834142e-01f, 9.35460925e-02f, 3.49695608e-02f, -3.57036740e-02f,
  3.51619199e-02f, 1.26291752e-01f, 2.23279342e-01f, 1.44361228e-01f, -1.77268777e-02f, -2.11315579e-03f, -3.76681387e-02f, -6.69555292e-02f, -1.19082846e-01f, -6.72491714e-02f,
  -2.15318143e-01f, 3.98786739e-02f, 1.65033769e-02f, 3.86652350e-02f, -1.49293929e-01f, 7.84934908e-02f, -1.06295988e-01f, 3.27834254e-03f, 2.41717771e-02f, -3.22759431e-03f,
  -1.27351508e-01f, -4.21512872e-02f, -1.03892073e-01f, -3.77089716e-02f, -9.90566313e-02f, 6.12916844e-03f, 6.27295300e-02f, 3.15537006e-02f, 5.84570095e-02f, -9.44653451e-02f,
  -3.86987207e-03f, 5.02225384e-02f, 8.88778567e-02f, 4.68891021e-03f, -1.08658308e-02f, -7.95359462e-02f, -3.06708347e-02f, -4.51324359e-02f, 3.37291975e-03f, -6.10813424e-02f,
  -1.66908856e-02f, -7.19074607e-02f, -1.55065563e-02f, 1.28710531e-02f, 4.56732176e-02f, -8.38030130e-02f, -1.02578990e-01f, -9.38823670e-02f, 5.22093941e-03f, -1.81130897e-02f,
  8.30446370e-03f, -3.20641361e-02f, -9.14692413e-03f, -1.12258270e-01f, -1.03555635e-01f, -5.12255467e-02f, 3.89905535e-02f, 5.79142086e-02f, 7.97744393e-02f, -3.35836932e-02f,
  7.22564682e-02f, 1.88879482e-02f, 1.70390066e-02f, -8.05337057e-02f, -4.99287620e-02f, 1.15156546e-02f, 5.93057387e-02f, -2.99194339e-03f, -1.11039206e-02f, -5.12035042e-02f,
  -9.01599647e-04f, -5.01834042e-02f, -4.33638208e-02f, -1.77499056e-02f, -6.44527823e-02f, -7.70230368e-02f, -9.45415273e-02f, -9.65164229e-02f, -9.09129381e-02f, -5.38543649e-02f,
  -7.61041790e-02f, -1.12994947e-01f, -5.20476475e-02f, -1.54156471e-02f, -6.69994801e-02f, -1.14527121e-01f, 3.65556255e-02f, -1.63986776e-02f, 6.98521128e-03f, -6.77221566e-02f,
  2.64487565e-02f, 1.30285189e-01f, 1.25468999e-01f, -6.27074093e-02f, -2.02428009e-02f, -6.32487461e-02f, 3.09434137e-04f, -9.90845729e-03f, -8.30730498e-02f, -1.60553530e-02f,
  -2.92881727e-01f, 2.50732806e-02f, -2.12722912e-01f, -2.67021544e-02f, 1.23906888e-01f, 6.13780282e-02f, 8.47209394e-02f, 9.30163264e-02f, 2.92397719e-02f, 9.58811641e-02f,
  -5.97548001e-02f, 1.19017109e-01f, 3.26303467e-02f, 7.41994381e-02f, 5.39024035e-03f, 6.50141388e-02f, 1.74664736e-01f, -1.55156041e-02f, 1.09507870e-02f, 1.55641809e-01f,
  1.80696711e-01f, 7.64449015e-02f, 8.82010683e-02f, 2.09612846e-02f, 1.55584142e-01f, 1.63818449e-01f, 4.20338288e-03f, 9.36257765e-02f, 1.91594139e-01f, 1.21105395e-01f,
  -1.96566895e-01f, -1.47239000e-01f, 1.43152148e-01f, 2.31954493e-02f, 2.59118099e-02f, -8.15699436e-03f, -5.30780107e-02f, -1.12826871e-02f, -1.96573380e-02f, 2.35061496e-02f,
  -2.03827322e-02f, 8.04350004e-02f, -3.71745266e-02f, 1.49629638e-01f, 1.98826492e-02f, 7.76463076e-02f, 4.21334133e-02f, -4.85126115e-02f, -4.82376525e-03f, 3.70256491e-02f,
  2.57038265e-01f, 8.69005173e-02f, -1.18734375e-01f, 8.75587538e-02f, 5.37861399e-02f, -3.29984203e-02f, -8.93491507e-02f, -2.55843718e-02f, -6.67367950e-02f, -6.10420592e-02f,
  1.20166816e-01f, 5.44502772e-02f, 2.13080011e-02f, 1.08346395e-01f, 6.48763925e-02f, -6.75643682e-02f, 1.02528088e-01f, 5.03226295e-02f, 1.09088697e-01f, -4.46136370e-02f,
  -8.01722240e-03f, 2.21345737e-03f, -4.94859144e-02f, -2.11373456e-02f, 8.67021009e-02f, 5.36286607e-02f, 9.54598188e-02f, -4.53050155e-03f, -5.80779314e-02f, -7.38328919e-02f,
  4.85390276e-02f, 4.08925638e-02f, -2.62209470e-03f, 8.17536786e-02f, 7.84149766e-02f, 1.30707473e-01f, 3.59958857e-02f, 1.26157150e-01f, 2.50728652e-02f, -1.11476798e-02f,
  -2.35393062e-01f, -1.66100264e-01f, -1.04984477e-01f, 9.83086647e-04f, -3.85602303e-02f, 2.18931269e-02f, -4.48064990e-02f, 4.00651321e-02f, -8.30191001e-03f, 6.68188035e-02f,
  -2.50086039e-02f, 1.60517041e-02f, -7.34393448e-02f, -3.29787098e-02f, -8.38350877e-02f, 4.83979136e-02f, 6.55294815e-03f, 2.68292334e-02f, 4.65416089e-02f, 2.14379523e-02f,
  2.95166634e-02f, 5.87368459e-02f, -2.17420124e-02f, -6.37903530e-03f, 5.25098145e-02f, -1.00206889e-01f, 2.66392808e-02f, -7.35565349e-02f, -5.09067066e-02f, 3.38393152e-02f,
  2.13093698e-01f, -4.90174331e-02f, -3.02064031e-01f, 6.21141829e-02f, -6.39296025e-02f, -1.59207031e-01f, -2.07945064e-01f, -3.98263410e-02f, 2.77581327e-02f, 6.41973764e-02f,
  1.83674499e-01f, 1.27154633e-01f, 1.54407889e-01f, 1.42505586e-01f, -4.03241850e-02f, -1.16007872e-01f, -1.51734397e-01f, -6.49334863e-02f, -9.61139873e-02f, 3.82993482e-02f,
  1.19609563e-02f, 9.08753425e-02f, 1.45172670e-01f, -3.91281918e-02f, -1.12066492e-01f, 1.21011510e-02f, -1.04258962e-01f, -2.77573243e-02f, -2.21537668e-02f, -1.77335992e-01f,
  1.63682133e-01f, 1.19931526e-01f, 1.72194347e-01f, 2.41825745e-01f, 1.63011387e-01f, 5.36949337e-02f, 8.65830258e-02f, 1.00020915e-01f, 1.87130392e-01f, 4.08936925e-02f,
  6.70539811e-02f, 1.73473939e-01f, 6.94135576e-02f, 7.19480664e-02f, 3.08401491e-02f, 5.97608909e-02f, 3.33663635e-02f, -3.34840380e-02f, 7.93993771e-02f, 9.60783437e-02f,
  1.08714789e-01f, 6.26551034e-03f, -3.87821645e-02f, 1.11189917e-01f, -1.86006930e-02f, 2.73515750e-02f, -4.38312851e-02f, -7.11034313e-02f, 5.99881113e-02f, 5.28322421e-02f,
  -1.31140620e-01f, -1.05426557e-01f, -1.40764922e-01f, -1.71900868e-01f, -1.25143975e-01f, -8.17887485e-02f, -8.75562280e-02f, -1.61695093e-01f, -4.39145118e-02f, -6.13051616e-02f,
  -1.20353185e-01f, -1.03337727e-01f, -1.22896507e-01f, -4.87038605e-02f, -8.64777714e-02f, -1.07115038e-01f, -6.41462952e-02f, -5.15047349e-02f, -3.94526944e-02f, -1.75398976e-01f,
  -1.46453977e-01f, -1.04786694e-01f, -7.52194971e-02f, -1.12834394e-01f, -1.80366129e-01f, -1.68844655e-01f, -8.82639140e-02f, -9.81502235e-02f, -4.88449400e-03f, -7.53931180e-02f,
  3.08507144e-01f, 7.25959688e-02f, 1.01755142e-01f, 1.80801317e-01f, 8.85616429e-03f, 1.49999410e-01f, 1.05580673e-01f, 9.13566872e-02f, 5.43784723e-02f, 6.41770437e-02f,
  1.43155092e-02f, 3.77082527e-02f, 1.34933352e-01f, 3.54482979e-02f, 6.77204654e-02f, 9.63444188e-02f, 1.71179231e-02f, 9.12868753e-02f, 7.88746923e-02f, -2.75226566e-03f,
  2.74913479e-02f, -9.14216321e-03f, 1.40673414e-01f, 2.88104638e-02f, 8.63817781e-02f, 9.93388668e-02f, 8.53592530e-02f, -1.14840707e-02f, -9.48354881e-03f, 1.41009048e-01f,
  -1.40520662e-01f, -2.82274008e-01f, 8.07649642e-02f, -1.00465536e-01f, 4.71595600e-02f, 1.91096589e-01f, 8.13430771e-02f, -2.01615430e-02f, -2.11772323e-02f, -7.18492493e-02f,
  -6.71763718e-02f, 1.57008648e-01f, 1.64428800e-01f, 1.09895982e-01f, 1.95076108e-01f, -1.03885025e-01f, -8.79440606e-02f, 1.88004538e-01f, 2.29029283e-01f, 3.45973705e-04f,
  -3.15057999e-03f, -1.27052322e-01f, -2.31307864e-01f, -1.38950586e-01f, -2.81449437e-01f, -6.60840720e-02f, -2.39569113e-01f, -8.25607106e-02f, -8.81609842e-02f, -1.88512817e-01f,
  -8.27564970e-02f, -1.73914254e-01f, 8.34619775e-02f, -2.07544304e-02f, -1.47489026e-01f, -1.70518368e-01f, -6.69772401e-02f, -1.30757853e-01f, -1.28232047e-01f, -2.44381905e-01f,
  -5.78288324e-02f, -9.71587747e-02f, -7.37308413e-02f, -2.43705094e-01f, -1.32057667e-01f, -1.50988057e-01f, -1.66630238e-01f, -1.55754298e-01f, 7.61738140e-03f, -1.66223019e-01f,
  -5.85348159e-02f, -8.27546269e-02f, -3.17170285e-02f, -8.45068470e-02f, -1.18099682e-01f, -1.02850795e-03f, -1.11704089e-01f, -1.94669127e-01f, -4.55227196e-02f, -2.41821542e-01f,
  1.60285458e-02f, 1.60691753e-01f, 1.16443232e-01f, 4.58454229e-02f, 5.02207875e-02f, 1.60648227e-01f, 3.33010703e-02f, 1.20434001e-01f, 3.14432196e-02f, -8.59161187e-03f,
  1.61786348e-01f, 1.09745979e-01f, 1.07626125e-01f, 4.02200036e-02f, 6.67551905e-02f, 1.09644391e-01f, 1.30604848e-01f, 4.14984375e-02f, 1.40586704e-01f, 1.99013557e-02f,
  5.00606783e-02f, 1.32221386e-01f, -7.01835845e-03f, 1.45476952e-01f, 4.80597541e-02f, 5.49615100e-02f, 1.66808553e-02f, 1.33562505e-01f, 6.76950812e-02f, 4.29600105e-02f,
  -2.92982638e-01f, 6.83142245e-02f, -1.17625125e-01f, -5.27373254e-02f, -1.40327856e-01f, -4.84184995e-02f, -1.04527108e-01f, -1.25653952e-01f, -4.28608339e-03f, -8.98003280e-02f,
  -1.06860094e-01f, -4.63642441e-02f, -1.21542580e-01f, -1.04592994e-01f, -7.78702945e-02f, -6.05807416e-02f, -1.85758635e-01f, -8.89930129e-02f, -1.13992661e-01f, -1.10723063e-01f,
  -1.06672063e-01f, -8.42490420e-02f, 3.51226740e-02f, -6.22359179e-02f, -3.09042558e-02f, 6.32753074e-02f, -2.65990850e-02f, -1.17523067e-01f, 3.46766114e-02f, -2.18327954e-01f,
  1.46916449e-01f, 4.02811855e-01f, 1.87797874e-01f, 3.32696736e-02f, -2.70622931e-02f, -1.07314393e-01f, -7.38085881e-02f, -1.21041574e-01f, -5.60589544e-02f, 6.32595494e-02f,
  1.00067653e-01f, 6.09703213e-02f, 1.86723620e-01f, 6.99109137e-02f, 9.91452634e-02f, 2.02951029e-01f, 1.52571023e-01f, 8.18785131e-02f, -1.90354921e-02f, -9.43974182e-02f,
  1.60451710e-01f, 1.83561161e-01f, 1.53372124e-01f, 1.32904664e-01f, 2.35887229e-01f, 2.23235846e-01f, 1.56442955e-01f, 7.55501315e-02f, 1.84176221e-01f, 2.38782942e-01f,
  2.74512976e-01f, -2.64272373e-02f, -7.75424689e-02f, 8.76879543e-02f, -3.73006277e-02f, 2.48701740e-02f, 5.02391979e-02f, 8.26805532e-02f, 9.74656045e-02f, 1.39677580e-02f,
  1.10087425e-01f, 6.17833761e-03f, -8.96199141e-03f, 4.37327214e-02f, 4.76782918e-02f, 1.23575829e-01f, -4.34012264e-02f, 1.44176215e-01f, 8.35463498e-03f, -4.78393584e-03f,
  1.60203382e-01f, 1.63778841e-01f, 1.56160548e-01f, -5.84214963e-02f, -2.29370613e-02f, -1.70676969e-02f, 1.32512704e-01f, -5.57113551e-02f, -1.62114520e-02f, 1.19383372e-01f,
  -8.72796401e-02f, -6.74772486e-02f, -1.40930474e-01f, -4.31431048e-02f, 1.54821295e-02f, -1.13615043e-01f, -2.25629043e-02f, -2.84301266e-02f, -3.93605828e-02f, -5.03325015e-02f,
  -2.91671231e-02f, -1.38621777e-01f, -2.26594303e-02f, 1.49857225e-02f, 3.11572780e-03f, -7.61735141e-02f, -5.82106598e-02f, 2.45859772e-02f, -4.63912264e-02f, -9.43341851e-02f,
  -1.07945658e-01f, -1.02826305e-01f, -9.09628347e-02f, -9.01600495e-02f, -1.49132878e-01f, -1.79947205e-02f, -2.38151103e-03f, -7.26513639e-02f, -6.66342154e-02f, -2.18830612e-02f,
  2.08706886e-01f, -1.80464402e-01f, 6.78633600e-02f, 5.09760939e-02f, 2.58793365e-02f, 8.37592930e-02f, 5.40643260e-02f, 8.49533230e-02f, 8.49755034e-02f, 1.02883287e-01f,
  7.12382495e-02f, 4.30462994e-02f, 6.95658177e-02f, -2.48282636e-03f, 2.01352239e-02f, -5.47785088e-02f, -2.23348085e-02f, 1.37704581e-01f, 3.63319255e-02f, 5.65686971e-02f,
  9.25092995e-02f, 3.33995260e-02f, 6.24962002e-02f, 7.52946883e-02f, -4.52453904e-02f, 1.42855957e-01f, 1.18555762e-01f, 9.22549050e-03f, 1.05268084e-01f, 3.80599871e-02f,
  -2.19141860e-02f, 4.43546735e-02f, -7.33999908e-02f, -1.90295830e-01f, -3.66359055e-02f, 2.17415199e-01f, 9.58190635e-02f, 1.11266356e-02f, -6.71844259e-02f, 6.63679317e-02f,
  1.59104452e-01f, 8.35444406e-02f, 6.25452325e-02f, 8.28356389e-03f, 4.14336510e-02f, -1.52878258e-02f, -2.51741886e-01f, -1.02845989e-01f, -7.39076687e-03f, 2.25594826e-02f,
  -9.24089700e-02f, -9.65429917e-02f, -1.56769171e-01f, -1.23333931e-01f, -9.07048732e-02f, -9.30090919e-02f, -2.84844767e-02f, -9.48408768e-02f, 1.52424306e-01f, -1.35674015e-01f,
  9.44253802e-02f, 7.52535015e-02f, 4.01339531e-02f, 4.52852026e-02f, 5.51820919e-02f, 9.23948362e-03f, 9.30927694e-03f, -9.66365933e-02f, 1.08538806e-01f, 4.57711145e-02f,
  1.52799338e-01f, 8.91396403e-03f, 1.45779371e-01f, 3.37406918e-02f, 3.58682796e-02f, 1.15316592e-01f, -1.27946854e-01f, -1.02961570e-01f, -2.85587534e-02f, 1.35400191e-01f,
  8.79605040e-02f, 1.23379976e-01f, 9.88755003e-02f, 1.67711060e-02f, 1.45690038e-03f, 3.36438566e-02f, 1.11582428e-01f, 6.65326118e-02f, -1.02601927e-02f, -1.28961012e-01f,
  -5.38075007e-02f, -2.55449694e-02f, -2.69653294e-02f, -1.56734828e-02f, -1.13023736e-01f, -2.94699036e-02f, -9.14426297e-02f, -9.64255184e-02f, -1.29691377e-01f, -7.01506361e-02f,
  -2.18798202e-02f, 1.37428101e-03f, -4.47888337e-02f, -1.38057768e-02f, -1.59698967e-02f, -1.38290957e-01f, 2.86117308e-02f, -1.00848503e-01f, -6.23021685e-02f, -8.99053141e-02f,
  -2.95425430e-02f, -1.62033774e-02f, -7.09888339e-02f, -1.29882857e-01f, -3.23482938e-02f, 2.86859181e-02f, 2.05187909e-02f, -6.40164390e-02f, -8.55198130e-02f, 1.34401936e-02f,
  -2.37395734e-01f, 1.49811804e-01f, 7.20176622e-02f, 3.85986902e-02f, 8.82997457e-03f, 1.12813510e-01f, 1.08233623e-01f, -4.31835093e-02f, 1.61640406e-01f, 8.04746002e-02f,
  1.08683579e-01f, 1.00178070e-01f, 1.56318828e-01f, 1.94885153e-02f, 7.01796934e-02f, 5.04183993e-02f, -6.56354502e-02f, 1.89682599e-02f, 1.55895397e-01f, 3.38341706e-02f,
  -4.84731458e-02f, 5.58832437e-02f, -2.70217042e-02f, 5.52002564e-02f, 8.92015845e-02f, 1.28182381e-01f, -3.94044854e-02f, 8.39909315e-02f, 1.87630299e-02f, -1.46527663e-01f,
  1.14106059e-01f, -3.72929722e-01f, -1.44787773e-01f, -5.74355423e-02f, -1.95867479e-01f, -2.06716850e-01f, -3.43077391e-01f, -7.45204790e-03f, -7.56965950e-02f, -1.90797657e-01f,
  2.03300659e-02f, 1.86139703e-01f, 9.49943066e-02f, 5.18293865e-02f, 1.02001697e-01f, -2.58338183e-01f, -1.46213129e-01f, 8.87086689e-02f, 2.48907760e-01f, 4.12785336e-02f,
  -1.19473100e-01f, 1.06536970e-02f, 1.69018358e-01f, 2.48061921e-02f, -2.74821490e-01f, 5.73486947e-02f, -1.57242060e-01f, -1.14903040e-01f, -2.35789165e-01f, -2.89074451e-01f,
  -2.32082307e-02f, -2.69264281e-01f, 9.54692513e-02f, -3.94225344e-02f, -1.25181630e-01f, -1.63438413e-02f, -2.46364754e-02f, -1.20713882e-01f, -1.41531616e-01f, -1.25926048e-01f,
  -2.02487499e-01f, -1.57103196e-01f, -4.27619927e-02f, -1.47994325e-01f, -1.08801164e-01f, -1.52300909e-01f, -8.84350166e-02f, -3.33565986e-03f, 3.01197562e-02f, -1.38320848e-01f,
  -1.88394576e-01f, -1.99673712e-01f, -1.74768507e-01f, -3.58909257e-02f, -1.44119784e-01f, -8.35253298e-02f, -1.89083278e-01f, -7.70667195e-02f, -1.18435234e-01f, -2.63692349e-01f,
  1.36704937e-01f, 2.36702152e-02f, -3.53147499e-02f, 1.13053814e-01f, 4.45525907e-02f, -1.99841447e-02f, 1.00050479e-01f, 6.49464354e-02f, 5.84976859e-02f, 7.17752650e-02f,
  4.71528247e-02f, 7.47951418e-02f, 7.56737664e-02f, 5.33812568e-02f, 9.07756537e-02f, -1.33683886e-02f, 3.01856268e-02f, 7.52839074e-03f, 6.60061166e-02f, 2.54782708e-03f,
  8.73387307e-02f, 7.34465569e-02f, 1.21359795e-01f, 8.82681906e-02f, 7.40284398e-02f, 1.24390423e-02f, -1.85304228e-02f, 1.81819394e-03f, -1.52186472e-02f, -4.53847982e-02f,
  7.63728470e-02f, 2.64894925e-02f, -1.12402979e-02f, -1.08295366e-01f, -1.63051188e-01f, -5.10692224e-02f, -6.76146820e-02f, -1.38433680e-01f, -3.61836627e-02f, -6.44092858e-02f,
  -5.69154955e-02f, -5.46429604e-02f, -1.85844436e-01f, -8.18727314e-02f, -7.54430741e-02f, -5.06984070e-02f, -1.65590480e-01f, -8.56346339e-02f, -5.71434125e-02f, -1.99322835e-01f,
  -1.30768538e-01f, -5.43138757e-02f, 1.43674612e-02f, -5.33912294e-02f, -1.42816588e-01f, -3.47011052e-02f, -9.28269401e-02f, -8.26349705e-02f, 6.17969595e-02f, -9.61123966e-03f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  5.27862132e-01f, 2.72588253e-01f, 1.03215113e-01f, 1.33550316e-01f, 1.26803473e-01f, 1.46386996e-01f, 3.51312220e-01f, 2.72445112e-01f, 7.44443834e-02f, 1.68990910e-01f,
  1.93301424e-01f, -2.08297577e-02f, -3.43153328e-02f, -1.08965300e-01f, 1.41936904e-02f, -3.72703634e-02f, -1.13772132e-01f, -3.33088301e-02f, -9.95270386e-02f, -2.36414932e-03f,
  -6.67155255e-03f, 1.73061207e-01f, 2.28867814e-01f, 6.45093843e-02f, -3.94917279e-02f, -1.03400007e-01f, 1.24128722e-01f, -3.44978981e-02f, -1.58141673e-01f, -2.27208629e-01f,
  -2.46740043e-01f, 2.77852833e-01f, -1.07075773e-01f, -1.82286412e-01f, -7.43928701e-02f, 2.11305777e-03f, -5.36068678e-02f, 5.62176034e-02f, 3.74627896e-02f, -9.92496684e-02f,
  -2.31595263e-01f, -5.21668345e-02f, -4.27543856e-02f, 3.07818339e-03f, 7.63965771e-02f, -2.47388612e-02f, 4.59967479e-02f, -7.09637776e-02f, -7.66154304e-02f, -1.35312364e-01f,
  -4.84060422e-02f, 8.50968435e-02f, 6.99848831e-02f, -3.14531736e-02f, -3.04037351e-02f, -6.49668872e-02f, 6.20242432e-02f, -1.56584218e-01f, 1.80422533e-02f, 7.19236210e-02f,
  3.90599295e-02f, -4.33601663e-02f, -7.00885206e-02f, 1.51852757e-01f, 7.63279712e-03f, -2.43057720e-02f, 4.77600098e-02f, -4.25234810e-02f, 2.27599703e-02f, 1.28172368e-01f,
  8.43435675e-02f, 4.54031639e-02f, 1.81882873e-01f, 9.83073637e-02f, 2.28647739e-02f, 4.65967022e-02f, 1.06411792e-01f, 9.16360319e-02f, 8.32241550e-02f, 6.88515753e-02f,
  -1.09888494e-01f, 1.25335321e-01f, 1.28939375e-01f, 6.45106211e-02f, 1.15695380e-01f, 8.72364864e-02f, -3.44749987e-02f, 1.20186910e-01f, 1.40145764e-01f, 1.16004199e-01f,
  -1.86263546e-01f, 5.23906723e-02f, -7.32996613e-02f, -8.40411484e-02f, -5.41332290e-02f, -1.04901986e-02f, 2.14967469e-04f, 3.23006860e-03f, 3.14394310e-02f, 1.19443526e-02f,
  -1.40634805e-01f, 3.31868343e-02f, 6.46690875e-02f, 2.87466049e-02f, 1.07415266e-01f, -8.68763924e-02f, -1.90730896e-02f, 2.58559212e-02f, -8.71637240e-02f, -1.24530531e-01f,
  -7.39408657e-02f, 4.25848104e-02f, -2.57330332e-02f, -1.24584734e-01f, -1.89453512e-01f, -2.37903967e-02f, -4.12049256e-02f, -3.88734415e-02f, -7.30331391e-02f, 2.36121282e-01f,
  -3.74408603e-01f, 3.39443326e-01f, -4.07209814e-01f, -9.36691016e-02f, 4.32812572e-02f, 9.71890334e-03f, 2.25636825e-01f, 1.64028127e-02f, 1.69611610e-02f, 1.72662452e-01f,
  9.36819538e-02f, -6.22839741e-02f, -9.82874483e-02f, 2.79756598e-02f, -2.74220910e-02f, 3.19010109e-01f, 3.22944731e-01f, -2.18866050e-01f, -3.78661156e-01f, 2.79311487e-03f,
  3.03504467e-01f, -2.76179463e-02f, -2.07688883e-01f, -8.09130594e-02f, 1.60646677e-01f, 5.58263548e-02f, 1.00945616e-02f, 3.28818411e-02f, 2.08585456e-01f, 1.87961131e-01f,
  -1.91387013e-01f, -2.75992662e-01f, -1.83098689e-01f, -1.88791335e-01f, -4.94704321e-02f, -8.05818290e-03f, 3.58073995e-03f, -1.15899742e-01f, 5.78086749e-02f, -4.25828621e-02f,
  -1.11599557e-01f, -5.42899370e-02f, -6.24038577e-02f, -5.18395156e-02f, -1.03546530e-01f, -7.55501613e-02f, 5.76905161e-02f, -1.48889586e-01f, -1.92100599e-01f, -1.83802605e-01f,
  1.46521449e-01f, 2.30414234e-02f, -2.92501032e-01f, -1.37803676e-02f, -1.62039205e-01f, -8.75642225e-02f, -1.80074230e-01f, -1.16189957e-01f, -1.83348015e-01f, -1.22087728e-02f,
  5.95876053e-02f, -1.28718801e-02f, 7.87538514e-02f, 1.14567056e-01f, 5.33448234e-02f, 3.16443890e-02f, 1.72372200e-02f, 8.92473310e-02f, -5.11236079e-02f, -4.86810170e-02f,
  -1.02924712e-01f, -2.71166340e-02f, -1.28346533e-01f, -4.61319052e-02f, 2.49179527e-02f, 2.91298218e-02f, -3.35513391e-02f, 1.10175766e-01f, 1.00522213e-01f, -4.26074751e-02f,
  -2.05920804e-02f, -6.82909638e-02f, -3.52282599e-02f, -7.26111978e-02f, 1.16784371e-01f, 1.78440139e-02f, 9.90502909e-02f, -7.00991899e-02f, -1.36347800e-01f, -1.08739369e-01f,
  -4.12849151e-02f, 1.19590476e-01f, -1.30769005e-02f, -1.76674668e-02f, -1.48072243e-02f, 2.88663991e-02f, 2.03301072e-01f, 7.80419707e-02f, 4.27360050e-02f, -1.94667920e-01f,
  -7.75430305e-03f, 5.73149994e-02f, 5.64268790e-02f, -2.90746223e-02f, -1.46631807e-01f, 3.70095335e-02f, 2.74748206e-01f, -2.56681945e-02f, -1.28349792e-02f, -8.82973447e-02f,
  9.00288075e-02f, 2.95767952e-02f, -7.50919208e-02f, 1.14272209e-02f, -4.90365289e-02f, 2.16045175e-02f, -1.85067281e-01f, -5.34864552e-02f, -1.03401452e-01f, 1.62906408e-01f,
  2.30141819e-01f, 4.66352493e-01f, -2.14420065e-01f, -9.76660401e-02f, -1.66612014e-01f, -1.16946302e-01f, 7.33552203e-02f, 9.58836153e-02f, 6.45884138e-04f, 1.09317027e-01f,
  1.22008972e-01f, 9.70827490e-02f, 1.05387375e-01f, 1.02263927e-01f, 1.53357029e-01f, 1.22546963e-02f, -1.85581043e-01f, -1.72027677e-01f, -1.97868273e-01f, -1.85821652e-02f,
  -1.13382548e-01f, -1.25934467e-01f, -1.61457390e-01f, -8.68498683e-02f, -1.11164093e-01f, -2.23905027e-01f, -1.60224095e-01f, -1.76491991e-01f, -2.04220533e-01f, -2.56920785e-01f,
  -1.84692994e-01f, -3.34557027e-01f, 5.83676621e-02f, -4.22124378e-02f, 1.49580359e-01f, 1.73221305e-01f, 2.26918666e-04f, 4.46375236e-02f, 5.24032637e-02f, -2.09128037e-02f,
  -8.16031322e-02f, 5.33609204e-02f, -1.15400009e-01f, 3.01579293e-02f, 3.55076566e-02f, 9.37942490e-02f, 6.02877289e-02f, -5.46571724e-02f, -4.27783355e-02f, 4.12893519e-02f,
  1.69927359e-01f, -2.74307895e-02f, -3.03923916e-02f, 7.50009567e-02f, 5.26438989e-02f, -3.20459940e-02f, 1.23823188e-01f, -9.78537276e-02f, 3.68737541e-02f, 1.83421537e-01f,
  1.06986560e-01f, 1.08315468e-01f, -5.84817380e-02f, -4.85231653e-02f, 9.86840725e-02f, 1.82639241e-01f, 8.84077027e-02f, 1.53399520e-02f, -3.00644357e-02f, 9.88605544e-02f,
  9.11153853e-02f, -1.33726820e-01f, -8.86864588e-03f, -1.94049794e-02f, -4.59489791e-04f, 5.39713353e-03f, -6.21176921e-02f, -1.40212127e-03f, -1.01928100e-01f, -1.46731272e-01f,
  -1.02643207e-01f, -4.77530509e-02f, 6.89182356e-02f, -9.02169868e-02f, -2.87112165e-02f, 7.27196410e-02f, -2.00220048e-02f, 7.33697191e-02f, -4.58461046e-03f, -4.53542694e-02f,
  -3.90891507e-02f, -3.59299600e-01f, -1.15149774e-01f, -7.91286230e-02f, -1.23659275e-01f, 1.41612694e-01f, -8.37959126e-02f, -5.57471663e-02f, 3.39782573e-02f, -7.09814802e-02f,
  -6.16472773e-03f, -4.31492627e-02f, 9.04992670e-02f, 4.48592231e-02f, 7.68869817e-02f, 9.66959074e-02f, 1.69838101e-01f, 6.96613779e-03f, -9.51169729e-02f, 2.59568579e-02f,
  2.59100676e-01f, 2.14586779e-01f, 1.21669583e-01f, 1.32264018e-01f, 1.10436484e-01f, 2.60242727e-02f, 6.30347505e-02f, 1.05072759e-01f, -2.11538766e-02f, 2.92302430e-01f,
  -4.02127773e-01f, -2.11013719e-01f, -2.40948766e-01f, -1.38720125e-01f, 9.00940597e-02f, -6.18943647e-02f, -3.08285922e-01f, -1.08715035e-01f, 7.09819943e-02f, -1.33845016e-01f,
  8.57400894e-02f, 1.69367313e-01f, -1.11478463e-01f, -6.34711087e-02f, -3.18143785e-01f, -2.96973586e-01f, -2.84633905e-01f, -2.51787126e-01f, -6.39695022e-03f, 2.70910889e-01f,
  1.79302379e-01f, -6.35558441e-02f, -1.22159533e-01f, -1.15886489e-02f, 1.46335110e-01f, 8.87821540e-02f, -4.87980358e-02f, 1.06852641e-02f, 1.78691428e-02f, 6.73147440e-02f,
  -1.89395070e-01f, -9.80604906e-03f, 1.27848312e-01f, 1.66833639e-01f, 4.96574678e-02f, -6.87760413e-02f, -8.20552632e-02f, -7.75372386e-02f, 1.41273681e-02f, -8.71153623e-02f,
  5.95097132e-02f, 6.81203529e-02f, 3.32899690e-02f, 6.82008639e-02f, 2.13376107e-03f, -5.03761396e-02f, -1.81254029e-01f, -1.27105981e-01f, -5.31311333e-02f, 1.02397010e-01f,
  2.55211681e-01f, 8.73366967e-02f, -1.69458658e-01f, -4.03714254e-02f, -1.05916083e-01f, -8.88792500e-02f, -1.27082923e-02f, 8.42627212e-02f, -2.00070649e-01f, -1.47611037e-01f,
  2.28839498e-02f, 5.54060843e-03f, -3.33978049e-02f, -1.09559752e-01f, -2.76792478e-02f, -3.08899358e-02f, -7.60401413e-02f, 1.54620139e-02f, -1.57739297e-02f, -2.61519533e-02f,
  -1.56846959e-02f, -6.31933287e-02f, 2.58600730e-02f, 6.66513145e-02f, 4.87288460e-02f, -4.88198213e-02f, 1.24639980e-01f, -4.13254052e-02f, -3.88945974e-02f, -5.26414253e-03f,
  -7.04294369e-02f, -4.78838719e-02f, 5.90933673e-02f, -5.31658381e-02f, -7.65996128e-02f, 2.08338257e-02f, 2.72018649e-02f, -1.88772194e-02f, 4.42269165e-03f, 3.56304981e-02f,
  -2.18285754e-01f, 2.82376334e-02f, -1.89860120e-01f, -6.33803010e-02f, -1.26754850e-01f, 1.71634555e-01f, 8.65230057e-03f, -4.64916490e-02f, -1.34146541e-01f, -5.62499948e-02f,
  4.06628884e-02f, -7.51961023e-02f, -2.13276241e-02f, 5.38942069e-02f, -4.88915071e-02f, -9.51762963e-03f, -2.59523541e-01f, -1.35501385e-01f, 4.67846021e-02f, 1.00744724e-01f,
  -1.55934781e-01f, -2.28236288e-01f, -3.35864007e-01f, -2.73205817e-01f, -9.62405875e-02f, -2.35843137e-01f, -2.08792761e-01f, -6.30715936e-02f, -3.57024699e-01f, -4.75073993e-01f,
  -4.67855811e-01f, -2.36914188e-01f, -4.69212145e-01f, -5.60681522e-01f, -4.04971510e-01f, -7.87607059e-02f, 8.63710195e-02f, 3.07221208e-02f, -2.67248660e-01f, -2.57768124e-01f,
  1.06105134e-01f, 1.15845256e-01f, -1.81504227e-02f, 1.24900766e-01f, 1.49251863e-01f, -1.96619257e-01f, -4.20439750e-01f, -2.48314634e-01f, 1.20302312e-01f, 2.04157546e-01f,
  3.51674780e-02f, -3.21351826e-01f, -1.99507594e-01f, -1.66822687e-01f, -2.44551942e-01f, -1.35899901e-01f, -3.29903424e-01f, -2.96284288e-01f, 8.71007738e-04f, -3.33466381e-01f,
  -2.30624434e-02f, -2.52777398e-01f, -3.76664591e-03f, 5.93618564e-02f, -1.52385771e-01f, -6.58613220e-02f, -8.74901190e-02f, -9.35861692e-02f, -8.97255633e-03f, -2.01924458e-01f,
  -6.46232069e-02f, 1.14544839e-01f, -6.76698312e-02f, -4.36293148e-02f, -2.10655555e-01f, 3.18606198e-02f, -1.79628178e-01f, -2.89607700e-02f, -7.32045025e-02f, 8.32075179e-02f,
  1.47981271e-01f, 5.77627085e-02f, -1.24759078e-02f, 1.08759843e-01f, 6.82201684e-02f, -8.91216546e-02f, 9.75988135e-02f, 1.45108178e-01f, 1.76462401e-02f, -1.36410579e-01f,
  -7.09907115e-02f, -3.17431688e-02f, 2.25580931e-02f, 3.61234359e-02f, 1.97764337e-01f, 9.25181359e-02f, -6.12758212e-02f, 5.92418239e-02f, 1.24204159e-01f, 8.20704997e-02f,
  -7.70509392e-02f, -4.84345555e-02f, -1.53530017e-03f, 6.95348978e-02f, 5.51739484e-02f, -2.19976120e-02f, 9.15491357e-02f, 5.08140624e-02f, -1.50716724e-02f, 6.21717200e-02f,
  7.29864538e-02f, 9.31278467e-02f, -7.88922980e-02f, 1.56524956e-01f, 9.45683867e-02f, -8.64806101e-02f, -1.98251028e-02f, 1.52620077e-01f, -5.33092730e-02f, -1.34712467e-02f,
  -1.19518973e-01f, 9.93263423e-02f, -6.92055672e-02f, 3.28324437e-02f, -1.33424699e-01f, 1.18688829e-02f, -5.85063882e-02f, -1.07497051e-01f, -1.53152630e-01f, -1.20585769e-01f,
  1.96637765e-01f, 2.85211112e-03f, -6.63598208e-03f, 5.39644770e-02f, -3.98142710e-02f, 5.60928211e-02f, 5.26426248e-02f, 1.44327627e-02f, 9.02152359e-02f, 6.37634248e-02f,
  1.32592497e-02f, 1.06780753e-01f, 1.08523943e-01f, 3.23582180e-02f, 1.38114676e-01f, -4.57676221e-03f, 7.61126447e-03f, 1.91179872e-01f, 1.24464266e-01f, -1.00859664e-01f,
  -5.25500000e-01f, -3.86594012e-02f, 4.27184075e-01f, -4.60476637e-01f, 2.02307910e-01f, 3.79391998e-01f, 5.56460261e-01f, -5.65560572e-02f, -1.95909292e-01f, -1.77885890e-02f,
  2.00691428e-02f, -3.23271662e-01f, -4.40538347e-01f, -1.70275867e-01f, 2.70958636e-02f, 2.96687275e-01f, 2.33788982e-01f, 1.28490940e-01f, 1.97621748e-01f, 2.12831318e-01f,
  -6.23690449e-02f, -2.37188637e-01f, -1.41686827e-01f, -6.56645074e-02f, -3.01811665e-01f, -2.41015404e-01f, -5.80986440e-02f, -4.42363359e-02f, 2.30062291e-01f, -2.20322132e-01f,
  2.03227520e-01f, -1.12103701e-01f, 3.97769697e-02f, -9.37648639e-02f, 2.79543828e-02f, -1.36181399e-01f, 1.02760129e-01f, -1.29815042e-01f, -3.28690186e-02f, -5.33781238e-02f,
  -6.33121235e-03f, -7.26387724e-02f, 9.65899602e-03f, -3.53190191e-02f, -5.16332537e-02f, 9.79927853e-02f, -1.65582567e-01f, -8.75485986e-02f, -7.97276199e-02f, -1.85384117e-02f,
  -1.41236037e-01f, 9.72497910e-02f, 2.73632593e-02f, 1.16083942e-01f, 9.53350291e-02f, -4.07435521e-02f, -7.51666278e-02f, 4.99126799e-02f, 8.41222629e-02f, -8.03280696e-02f,
  4.97705080e-02f, -1.08263984e-01f, -4.03957330e-02f, 1.70873608e-02f, -5.54276221e-02f, 9.72909853e-02f, -1.02682672e-01f, 8.35472271e-02f, -5.78549467e-02f, -6.55440539e-02f,
  -1.28196776e-02f, 1.79084353e-02f, -5.52252419e-02f, -5.96864894e-02f, -4.85613868e-02f, -1.56452134e-01f, 2.59658024e-02f, -3.84464450e-02f, 1.14191242e-01f, -7.09918281e-03f,
  2.32152902e-02f, -5.45020103e-02f, -1.54470112e-02f, 6.29944280e-02f, 1.56037742e-02f, 3.86309773e-02f, 3.77398767e-02f, -9.16288942e-02f, -1.55887306e-01f, -5.36056347e-02f,
  -4.47435707e-01f, 3.04312766e-01f, -1.07190214e-01f, -1.47518724e-01f, 7.60432631e-02f, 1.49521679e-02f, -9.94859729e-03f, 1.73543960e-01f, -4.08506282e-02f, 2.42908802e-02f,
  5.40868752e-02f, -1.59444772e-02f, -5.63675053e-02f, -9.08965990e-02f, 1.30753383e-01f, 8.89158100e-02f, 1.06456503e-03f, -1.12983547e-01f, 6.69409800e-03f, 1.70939807e-02f,
  -5.98574467e-02f, 6.16546273e-02f, -8.29342678e-02f, -4.30836417e-02f, 9.86648649e-02f, -5.95266838e-03f, 5.70436455e-02f, 5.89560829e-02f, 1.81022331e-01f, 9.92097184e-02f,
  -4.24417108e-01f, -2.56333262e-01f, 6.30227209e-04f, 1.56157836e-01f, 3.04758072e-01f, 1.94479167e-01f, 1.70489714e-01f, 1.45945236e-01f, 1.34372622e-01f, 8.16666782e-02f,
  -1.57582283e-01f, -1.74137741e-01f, -1.53608739e-01f, -5.05718477e-02f, -4.79751676e-02f, 1.17093615e-01f, 2.97070861e-01f, -4.84386720e-02f, 6.08096644e-02f, 8.24594349e-02f,
  5.81849441e-02f, 9.80341993e-03f, -1.33995444e-01f, 6.89533576e-02f, 1.13386154e-01f, -2.18224828e-03f, 5.44200800e-02f, 7.05540832e-03f, 8.97949412e-02f, 9.18176174e-02f,
  -2.77585715e-01f, -2.07476929e-01f, 4.23490591e-02f, -7.18183815e-02f, -1.69463947e-01f, -1.17057160e-01f, -1.00570127e-01f, 4.72719409e-02f, 9.35301408e-02f, 2.11216375e-01f,
  4.77969609e-02f, -1.34781897e-01f, -7.58983719e-04f, 3.64593007e-02f, 4.27024700e-02f, 8.49231482e-02f, -2.43647117e-02f, 1.44770861e-01f, 8.83763433e-02f, -3.39400768e-02f,
  2.86126677e-02f, 1.42660260e-01f, 1.33805186e-01f, 9.68840271e-02f, -6.96271583e-02f, -6.47278829e-03f, -8.23534057e-02f, 4.93225567e-02f, 6.04710430e-02f, -1.35481618e-02f,
  -8.87824818e-02f, -6.81173103e-03f, -1.25987187e-01f, -1.67273618e-02f, 2.47346126e-02f, 5.50710075e-02f, 3.48549969e-02f, 5.01336791e-02f, -1.67141631e-01f, -4.60682437e-02f,
  1.88956156e-01f, 5.57219014e-02f, -9.65976864e-02f, 2.76543368e-02f, -1.79821983e-01f, -1.44726997e-02f, -6.97669536e-02f, -1.00467429e-01f, -1.03033304e-01f, -5.64033203e-02f,
  -8.90891552e-02f, 8.28405395e-02f, 3.12972404e-02f, -4.97604422e-02f, 1.66362241e-01f, 5.24102189e-02f, 3.70088145e-02f, -1.23116165e-01f, 2.27767490e-02f, 2.64939442e-02f,
  1.45944908e-01f, -3.56799781e-01f, -4.54190448e-02f, -1.49229646e-01f, 3.29622291e-02f, -1.02879465e-01f, -1.41180813e-01f, 4.19197790e-02f, 1.58458263e-01f, 1.48587063e-01f,
  -3.44471708e-02f, -1.63348824e-01f, -4.69742604e-02f, -7.98027813e-02f, 1.02367111e-01f, -3.81032713e-02f, -1.77721027e-02f, 1.30580142e-01f, -4.33992520e-02f, 4.95049059e-02f,
  4.55300137e-02f, 7.93767199e-02f, 7.47619346e-02f, 5.19767664e-02f, 2.57699210e-02f, 2.33407971e-02f, 6.94619790e-02f, 1.54634714e-01f, 6.36212230e-02f, 2.36083433e-01f,
  3.31220955e-01f, -3.66510600e-01f, 1.64792374e-01f, 2.22985536e-01f, 3.09601218e-01f, 3.00122619e-01f, 7.76181743e-02f, 1.00237750e-01f, 1.40527457e-01f, -3.38176750e-02f,
  1.21127199e-02f, 1.59752369e-02f, 2.25568470e-02f, 2.06430517e-02f, 5.54981157e-02f, -2.39468440e-02f, 1.10920109e-01f, 2.41340756e-01f, 1.74532056e-01f, 4.03795168e-02f,
  -7.04166815e-02f, -3.67535502e-02f, -1.11747188e-02f, -3.72128002e-02f, -8.16635340e-02f, 7.51338005e-02f, -1.98443264e-01f, -9.13294852e-02f, -1.37346566e-01f, -2.14439571e-01f,
  -1.15578219e-01f, -1.55790970e-01f, 1.21844202e-01f, -6.86696097e-02f, -1.33997455e-01f, -9.87115223e-03f, -3.61708701e-02f, -9.67349857e-02f, -8.16230625e-02f, -7.79756382e-02f,
  -1.11623369e-02f, 1.52657675e-02f, 4.10419293e-02f, -1.70138970e-01f, -1.35798631e-02f, -2.47393362e-02f, -8.49684700e-02f, -1.08257890e-01f, -1.09545171e-01f, -4.41837981e-02f,
  -9.38279852e-02f, 1.50876552e-01f, 1.38873369e-01f, -1.23524535e-02f, 5.49953580e-02f, 1.67926282e-01f, -1.15023732e-01f, -7.04696402e-02f, 1.20433874e-01f, -5.48975356e-02f,
  1.02593295e-01f, 1.66767314e-01f, 2.46594831e-01f, 1.64398506e-01f, 1.14127375e-01f, -1.57913435e-02f, 8.31284821e-02f, 1.06250234e-01f, 1.67612836e-01f, -3.37592326e-02f,
  3.90651040e-02f, -4.96592699e-03f, -1.36949597e-02f, -6.02554157e-03f, 1.16784655e-01f, 1.16594188e-01f, 8.59446675e-02f, 1.60979026e-03f, 1.00900024e-01f, -4.66631949e-02f,
  7.95863122e-02f, -1.41318351e-01f, -1.87811360e-01f, -8.55165944e-02f, -1.59848034e-01f, 6.54624775e-02f, -7.95352797e-04f, 2.78187972e-02f, -5.74689806e-02f, -5.57150021e-02f,
  -1.74154267e-01f, 1.41288653e-01f, -5.32417838e-03f, -1.09694712e-02f, -2.28204709e-02f, -1.50622919e-01f, 1.08885534e-01f, -9.30289552e-02f, -2.05402732e-01f, -6.29484430e-02f,
  -8.39238465e-02f, 4.43257168e-02f, -4.48096395e-02f, -1.21478669e-01f, 3.70717496e-02f, 1.20389007e-01f, 2.20742561e-02f, -3.95944938e-02f, -5.09966835e-02f, -9.97729599e-02f,
  -1.16110049e-01f, 1.78116888e-01f, 2.05942050e-01f, 1.95642933e-01f, 1.71523228e-01f, 1.49674922e-01f, 7.26939589e-02f, 8.60525519e-02f, 1.37106672e-01f, 8.80471896e-03f,
  -1.00181393e-01f, -1.95515025e-02f, 8.61155242e-02f, 1.81750312e-01f, 3.09457272e-01f, 2.67456710e-01f, 2.44000211e-01f, 1.55236736e-01f, 3.36919464e-02f, 5.06144501e-02f,
  -1.49857745e-01f, -9.49121565e-02f, -1.53583527e-01f, -9.87227038e-02f, -6.98533580e-02f, 1.17890820e-01f, 1.98282659e-01f, 5.93035258e-02f, 6.50338456e-02f, 1.16901770e-02f,
  9.70413983e-02f, 5.66937588e-02f, -1.15681224e-01f, 3.78219113e-02f, 7.29281902e-02f, 9.63118672e-02f, 1.08885542e-01f, 1.46532327e-01f, -5.71852513e-02f, 3.26784737e-02f,
  -1.98491499e-01f, -1.02092735e-01f, 7.10348487e-02f, -3.68460231e-02f, -8.29334185e-03f, -6.60201013e-02f, 8.83229915e-03f, -3.50341275e-02f, -4.45836857e-02f, -5.73163331e-02f,
  -6.70946315e-02f, -1.10631764e-01f, -4.94477786e-02f, -8.25483128e-02f, -8.72907564e-02f, -5.72918877e-02f, -5.10130897e-02f, -1.11687437e-01f, -1.75714642e-01f, -1.23493873e-01f,
  -3.05327885e-02f, -4.14398685e-02f, 2.88408548e-02f, 4.53645997e-02f, -1.12147227e-01f, -6.04642145e-02f, -1.13266833e-01f, -2.17782985e-02f, -1.74260005e-01f, -1.25051379e-01f,
  1.22212365e-01f, 3.57663520e-02f, -1.24039073e-02f, -9.12891999e-02f, -1.24288321e-01f, -1.22953057e-02f, 9.32332501e-02f, 6.42654020e-03f, 2.99940221e-02f, 1.30261155e-03f,
  3.10747456e-02f, -3.92210297e-02f, -6.79230466e-02f, 1.49798850e-02f, -3.32324915e-02f, 3.24493274e-02f, 4.35146280e-02f, -5.83654121e-02f, -5.90963662e-02f, -2.37666294e-02f,
  -4.08543050e-02f, 5.51458113e-02f, 2.89946422e-02f, -4.68302555e-02f, -5.77728152e-02f, -6.32387623e-02f, 1.75446889e-03f, -2.22456083e-02f, 8.54646787e-02f, 6.64982200e-02f,
  -6.51728883e-02f, -1.62009016e-01f, 4.02470268e-02f, 2.48429552e-02f, 1.08186208e-01f, 5.70504516e-02f, 5.24822436e-03f, -1.63966287e-02f, 2.73635369e-02f, -5.44295050e-02f,
  8.63029622e-03f, -2.42543668e-02f, 2.66172886e-02f, -1.47379236e-03f, 4.47976477e-02f, -3.24875512e-03f, 7.47415349e-02f, 8.53487104e-02f, -9.35133845e-02f, -7.65775815e-02f,
  1.11644827e-02f, 6.83306307e-02f, 1.23019487e-01f, 5.72772026e-02f, -2.80645099e-02f, 4.47775945e-02f, 5.26283979e-02f, 4.74669486e-02f, -4.02643383e-02f, 3.32572721e-02f,
  -4.31204647e-01f, -2.71911800e-01f, 3.10793906e-01f, 2.01870561e-01f, -4.52651307e-02f, -2.64239699e-01f, -4.83960837e-01f, -2.15332583e-01f, -4.79164347e-02f, -1.79092899e-01f,
  -2.09974602e-01f, 4.00717892e-02f, 1.26470834e-01f, 7.13822320e-02f, -6.95437659e-04f, 9.10464749e-02f, 4.69127029e-01f, 3.49754542e-01f, 4.34375592e-02f, -2.79264659e-01f,
  -7.45540336e-02f, 9.68081877e-03f, 1.03590257e-01f, 7.49898627e-02f, 1.26222715e-01f, 6.87209070e-02f, 1.49506912e-01f, 6.44241273e-02f, -5.64784184e-02f, 4.30023998e-01f,
  -6.24481589e-02f, -3.58638018e-01f, 8.71400535e-02f, 1.92631315e-02f, 1.31113857e-01f, -4.87754941e-02f, 8.90698005e-03f, 6.91379234e-02f, -8.13997611e-02f, -7.83209652e-02f,
  -3.68519127e-02f, 1.67094823e-02f, -7.46163959e-03f, 4.12924252e-02f, -1.82551015e-02f, -9.32060853e-02f, 1.67629167e-01f, 8.14366937e-02f, 1.00239575e-01f, -1.59626424e-01f,
  1.63376331e-02f, -6.73631430e-02f, -1.10214077e-01f, -1.36496454e-01f, -6.12422749e-02f, -3.22616808e-02f, -1.62336931e-01f, -1.44187465e-01f, -2.03802168e-01f, -2.13237777e-02f,
  4.87393327e-02f, -9.00684297e-02f, -1.37715312e-02f, 7.99825862e-02f, -7.81146660e-02f, 9.99303814e-03f, 1.27288416e-01f, -2.01097317e-02f, 1.80930927e-01f, 1.76120356e-01f,
  6.73774630e-02f, 3.46913971e-02f, 1.29068673e-01f, -2.53305733e-01f, 4.06242833e-02f, 1.41906384e-02f, 2.84026656e-02f, -5.81502207e-02f, -1.06012290e-02f, -9.56859067e-03f,
  6.16796315e-02f, 1.20658912e-01f, 6.40233979e-02f, 1.26129910e-01f, -7.05698133e-02f, 8.23051408e-02f, 6.10196218e-02f, -1.70525406e-02f, -2.91431639e-02f, -1.48814887e-01f,
  -1.55253410e-01f, -8.37507173e-02f, 6.62740991e-02f, 8.84017944e-02f, -1.49105433e-02f, -1.05806775e-01f, 1.13891780e-01f, -6.75763339e-02f, -1.05431177e-01f, -1.40257716e-01f,
  -2.85490036e-01f, -1.62349910e-01f, -6.70936927e-02f, 1.27526224e-01f, 1.77503955e-02f, -6.62431447e-03f, 5.40285185e-02f, 3.56105417e-02f, 5.05388677e-02f, -9.41621214e-02f,
  2.03291982e-01f, -2.47218966e-01f, -2.58351624e-01f, -1.82849780e-01f, -7.04183951e-02f, -2.23945826e-01f, -2.17001960e-01f, -2.66900361e-01f, -3.29687029e-01f, -3.11238796e-01f,
  -2.19929278e-01f, 2.38645077e-01f, -7.43254244e-01f, -3.70139331e-02f, -2.18096465e-01f, -3.23271640e-02f, 4.61900324e-01f, 2.81456321e-01f, -4.05219235e-02f, 6.06923189e-04f,
  -1.55955583e-01f, -1.95670933e-01f, -2.64293134e-01f, -2.19973575e-04f, 1.10856496e-01f, 1.81229040e-01f, -4.39679623e-02f, -1.54471621e-01f, -5.58447726e-02f, 3.47729862e-01f,
  3.78651589e-01f, 1.81959286e-01f, -3.60142700e-02f, 3.94140221e-02f, -8.53326991e-02f, -4.47917506e-02f, -2.17408642e-01f, -2.01530486e-01f, 1.99404210e-02f, -2.17616066e-01f,
  -4.14137125e-01f, -2.18831256e-01f, -1.44042805e-01f, -6.80986643e-02f, -2.18651429e-01f, -4.91586998e-02f, 6.43411651e-02f, -2.76687324e-01f, -1.14062957e-01f, -9.08717439e-02f,
  -1.93090215e-01f, -7.48578459e-02f, -2.04879865e-01f, 6.85823709e-02f, 1.55819822e-02f, 1.25006869e-01f, -4.72729206e-02f, 4.17061858e-02f, -1.90601066e-01f, -1.01992615e-01f,
  1.23459801e-01f, -1.42131165e-01f, -4.42000836e-01f, 2.96591409e-02f, -5.59318513e-02f, -2.49138728e-01f, -7.59349689e-02f, -2.04232372e-02f, -1.45659029e-01f, -4.91497926e-02f,
  1.73702557e-02f, -5.50831780e-02f, 7.27909133e-02f, 1.28362581e-01f, 2.19711497e-01f, -3.01278941e-02f, -2.51244437e-02f, 1.21106118e-01f, 1.33495480e-02f, 3.94404009e-02f,
  1.50731606e-02f, -1.28515214e-01f, -4.06179056e-02f, 3.18820663e-02f, -1.24355175e-01f, -5.08034080e-02f, 2.16581523e-02f, 1.58427685e-01f, 1.47278123e-02f, 7.75711937e-03f,
  -6.42466396e-02f, -6.42150864e-02f, -1.63203448e-01f, 4.76689488e-02f, -4.00764756e-02f, -2.36925706e-02f, 4.88711074e-02f, -1.72081199e-02f, -4.68257368e-02f, -9.33593065e-02f,
  1.63563371e-01f, 3.34400609e-02f, -1.18570834e-01f, 2.74832278e-01f, -1.16427436e-01f, -1.05680540e-01f, 1.90317445e-02f, -2.16717483e-03f, -2.47211739e-01f, -1.95334218e-02f,
  9.85353291e-02f, 3.61494906e-02f, -9.89746898e-02f, 7.53593519e-02f, -2.44278298e-03f, -8.03552344e-02f, 2.09354445e-01f, -9.69802216e-02f, 7.22494796e-02f, -1.02700882e-01f,
  5.75741678e-02f, 1.92946121e-01f, -7.24426750e-03f, -5.53944707e-02f, 3.28909010e-02f, -2.44359877e-02f, -1.42146751e-01f, -4.51695099e-02f, -2.63877138e-02f, 3.69505703e-01f,
  5.65113842e-01f, 1.18536077e-01f, 2.33638078e-01f, 1.36469394e-01f, -3.24640661e-01f, -2.78870374e-01f, -3.09307635e-01f, -8.78955796e-02f, 1.17602032e-02f, 1.21346517e-02f,
  -1.41516671e-01f, -5.81288002e-02f, 6.32767454e-02f, 9.52551812e-02f, 1.44094586e-01f, 3.49808000e-02f, 1.77559957e-01f, 4.13238078e-01f, 1.97575212e-01f, 3.29259895e-02f,
  1.45182073e-01f, 2.50623763e-01f, 4.33094978e-01f, 2.82697171e-01f, 9.21083689e-02f, 5.11391461e-02f, -8.45706239e-02f, -1.97151327e-04f, -8.11524317e-02f, 3.21411163e-01f,
  -7.16412673e-03f, -3.40998778e-03f, 4.49595824e-02f, 4.35888246e-02f, -9.60410461e-02f, 1.36545271e-01f, 6.51565045e-02f, 1.02559999e-01f, -1.35301836e-02f, -1.27100321e-02f,
  -4.27995324e-02f, -9.31728631e-03f, -6.13321215e-02f, -9.99950543e-02f, -6.26395419e-02f, -4.29000854e-02f, 2.01356132e-02f, -4.22502048e-02f, -1.04975477e-01f, -1.82047244e-02f,
  -9.04384330e-02f, -2.03607053e-01f, -2.21323714e-01f, -1.69447303e-01f, -8.81432444e-02f, -4.90219593e-02f, -1.58279493e-01f, -2.54958365e-02f, -3.33085582e-02f, 7.15338141e-02f,
  -2.68066585e-01f, -1.22736782e-01f, -1.61261097e-01f, -2.23716632e-01f, -2.68358946e-01f, -1.66854650e-01f, -1.36463076e-01f, -1.90345213e-01f, -7.65350685e-02f, -9.54496935e-02f,
  -1.73574045e-01f, -1.34289265e-01f, -2.01945111e-01f, -8.94194189e-03f, 6.44721463e-02f, -1.62233189e-01f, -5.65517470e-02f, -1.32603452e-01f, -2.52037108e-01f, -1.34464815e-01f,
  -2.27668032e-01f, -1.90527603e-01f, 2.43399143e-02f, -5.05341925e-02f, -1.48618981e-01f, -9.83440951e-02f, -1.60820931e-01f, -1.50987476e-01f, 2.64864787e-02f, -1.68639456e-03f,
  -2.46675581e-01f, -1.69951096e-01f, 1.13439336e-01f, 1.43891409e-01f, 5.06511889e-02f, 6.34366348e-02f, 1.44013658e-03f, 1.13374807e-01f, 1.74446199e-02f, 4.41035293e-02f,
  -4.82910685e-02f, 2.04003230e-01f, 7.04940110e-02f, -4.66797464e-02f, -5.56525066e-02f, -9.52475369e-02f, -6.39090911e-02f, -5.24507230e-03f, -3.41168419e-03f, -1.22070685e-01f,
  9.44545865e-02f, 5.98357804e-03f, -1.87730305e-02f, -2.73688808e-02f, -2.52766050e-02f, 4.38735671e-02f, 1.07849967e-02f, -8.46476108e-02f, -5.43603525e-02f, 9.90809575e-02f,
  8.22378844e-02f, 1.62955746e-01f, -3.23377326e-02f, 1.59174338e-01f, 2.33424187e-01f, 2.74690717e-01f, 2.39148825e-01f, 2.39538550e-01f, 2.76532412e-01f, 2.53585428e-01f,
  3.08107674e-01f, 2.84304768e-01f, 2.66209096e-01f, 1.31314293e-01f, 2.31810346e-01f, 5.15150577e-02f, 1.41380087e-01f, 2.23939400e-02f, 1.11116067e-01f, 1.73168883e-01f,
  1.46701038e-01f, 4.27406467e-02f, -5.75352982e-02f, -4.21949103e-02f, 8.25138837e-02f, 1.60671398e-01f, 1.26224592e-01f, 1.75882522e-02f, 4.60190624e-02f, -1.27636567e-01f,
  -2.23572388e-01f, -3.10011627e-03f, 5.13521209e-02f, 4.82133403e-02f, -9.32849050e-02f, -1.23027295e-01f, 5.89770218e-03f, -5.28846495e-02f, -1.29905283e-01f, -4.66152653e-02f,
  -1.58995837e-01f, -3.00188269e-02f, -7.24281967e-02f, -1.15379900e-01f, -1.17094219e-01f, -7.83909485e-03f, -8.47353935e-02f, 2.21963245e-02f, -3.52478884e-02f, -4.33729030e-02f,
  5.69690159e-03f, 8.51422474e-02f, 3.90159748e-02f, 1.11868270e-01f, 1.05879515e-01f, 8.93422514e-02f, 6.84535503e-02f, -1.13803402e-01f, 1.86432600e-02f, 1.83306877e-02f,
  2.30319977e-01f, 9.35932621e-03f, 1.41510472e-01f, 1.19950593e-01f, 1.00238159e-01f, -2.10885443e-02f, -2.48489715e-02f, 3.65433246e-02f, 1.34583890e-01f, 2.29029991e-02f,
  4.40199021e-03f, 8.09417963e-02f, 3.02606244e-02f, 7.11925179e-02f, 2.98933666e-02f, 4.72787395e-02f, -5.06273434e-02f, 3.78788076e-03f, -3.06140631e-02f, -1.13732077e-01f,
  -1.10434614e-01f, -1.67023599e-01f, -1.54807881e-01f, -1.40667364e-01f, 3.16343568e-02f, 8.72351043e-03f, 5.25372056e-03f, 8.11287388e-02f, 5.27906343e-02f, -8.65811780e-02f,
  1.37990102e-01f, 7.42482692e-02f, 1.81070305e-02f, -7.89208040e-02f, -1.19449288e-01f, -1.71402827e-01f, -5.95387258e-02f, -1.31884038e-01f, -1.02182999e-01f, -2.80436035e-02f,
  7.02390261e-03f, -1.02125525e-01f, -3.20727425e-03f, -8.18559229e-02f, 4.82110586e-03f, 2.81019136e-02f, 1.60361524e-03f, 1.20729551e-01f, -2.26467997e-02f, -9.17391926e-02f,
  3.21709923e-02f, 1.21820189e-01f, 7.68670067e-02f, 7.23157227e-02f, 7.16259032e-02f, 2.47360393e-02f, 5.76976649e-02f, -6.47566691e-02f, 4.07284237e-02f, 1.01168856e-01f,
  -3.51417422e-01f, 2.52002925e-01f, -4.11473632e-01f, 2.47297194e-02f, 3.21767218e-02f, -1.61197618e-01f, 1.71083614e-01f, -2.50424854e-02f, -9.56245735e-02f, 1.83215421e-02f,
  3.74082625e-02f, 1.21160056e-02f, 7.29614571e-02f, 6.61399662e-02f, -4.22792770e-02f, 1.42463699e-01f, 4.91795912e-02f, -1.86965957e-01f, -8.41714293e-02f, 8.53476897e-02f,
  3.51548046e-01f, 1.35818347e-01f, -4.08894308e-02f, -2.00719386e-02f, 1.22694716e-01f, 1.05292588e-01f, 4.73827124e-02f, 7.74422511e-02f, 6.92817494e-02f, 1.64801598e-01f,
  4.89322990e-02f, -2.92111278e-01f, -1.18168235e-01f, -4.76961024e-02f, -1.12459347e-01f, -1.29776999e-01f, -1.29576281e-01f, -6.61651939e-02f, -1.00612402e-01f, 1.23565346e-02f,
  -2.55480111e-02f, -1.46949708e-01f, -3.80082019e-02f, -1.05236014e-02f, 3.57066728e-02f, -1.45259853e-02f, -8.52238163e-02f, -1.41440034e-01f, -1.23354293e-01f, -1.69545725e-01f,
  2.37303108e-01f, -4.86494377e-02f, -2.35575020e-01f, -4.36166972e-02f, -1.29157886e-01f, -5.34409694e-02f, -9.05308947e-02f, -9.29558650e-02f, -2.54730642e-01f, 3.40152271e-02f,
  -1.39228508e-01f, -4.26759245e-03f, -5.14824130e-02f, -1.02115143e-02f, 8.98351222e-02f, 6.21995591e-02f, 1.28632471e-01f, 1.28672823e-01f, 1.30926603e-02f, 2.60345303e-02f,
  9.07182693e-02f, -1.94813814e-02f, -5.84530160e-02f, -5.75323030e-02f, 1.06702201e-01f, -1.04692847e-01f, -2.11823713e-02f, 6.84338287e-02f, -6.22230917e-02f, -1.84818462e-01f,
  2.11258885e-02f, -5.42730242e-02f, 6.25864193e-02f, 3.22296284e-02f, -4.07543182e-02f, -5.57527840e-02f, 1.35944569e-02f, 3.15868668e-02f, -1.40706841e-02f, 6.37571677e-04f,
  6.05367601e-01f, -1.81892067e-01f, 1.02424569e-01f, 6.39229789e-02f, -1.01205632e-01f, -1.72758643e-02f, -4.77770828e-02f, -2.30308417e-02f, -4.25151410e-03f, -3.87682416e-03f,
  -1.16300270e-01f, -9.25480202e-02f, 1.42060921e-01f, 1.40974864e-01f, 3.90143432e-02f, 1.22925034e-03f, 6.61113784e-02f, 6.04511984e-02f, 1.10714041e-01f, 6.65421039e-02f,
  5.08326516e-02f, 1.09891094e-01f, 8.58764872e-02f, -2.69486643e-02f, 3.50602530e-02f, 5.93524240e-02f, 4.29065078e-02f, 8.70252475e-02f, -6.77622063e-03f, 4.18760449e-01f,
  2.03266162e-02f, -3.74151468e-01f, -1.42193422e-01f, -1.61283538e-01f, -2.40745038e-01f, -1.57121003e-01f, -1.38625026e-01f, -2.95968037e-02f, -4.09986451e-02f, -2.50764966e-01f,
  -1.39308617e-01f, 7.50979036e-02f, -6.42180145e-02f, -1.68149203e-01f, -2.07325429e-01f, -2.64700025e-01f, -3.81970227e-01f, -2.49959677e-01f, 1.50748640e-01f, 6.09165095e-02f,
  -1.14460275e-01f, -4.48716208e-02f, -9.93248001e-02f, -3.05782799e-02f, -4.26256880e-02f, -1.32566988e-01f, -3.05137902e-01f, -2.23887846e-01f, -1.78200334e-01f, -2.71555990e-01f,
  9.80516672e-02f, 1.44326717e-01f, 1.20507948e-01f, 4.32609394e-02f, 5.00240549e-02f, 7.65909627e-02f, 7.09234737e-03f, 3.15782167e-02f, -8.91597662e-03f, 6.05918746e-03f,
  -7.21935630e-02f, -1.00500181e-01f, 4.68070097e-02f, 3.89549844e-02f, 3.62763330e-02f, 7.94171467e-02f, 1.12749897e-01f, 3.77365015e-02f, 6.02326989e-02f, 7.13240430e-02f,
  1.11607000e-01f, 8.12904984e-02f, 6.62779436e-02f, 1.26517609e-01f, 1.76446706e-01f, -2.09846459e-02f, 1.12015367e-01f, 1.64791167e-01f, 1.65403098e-01f, 9.53560770e-02f,
  6.51349174e-03f, 1.37725517e-01f, 1.54519886e-01f, 1.49861917e-01f, 1.32301703e-01f, 2.27653719e-02f, -4.00957689e-02f, 6.62683547e-02f, 4.68273163e-02f, 2.27469131e-02f,
  2.45653037e-02f, -5.63527457e-02f, 9.21300426e-02f, -1.55747995e-01f, -1.56011460e-02f, -1.10555869e-02f, -2.89972033e-02f, 1.24406204e-01f, 1.13205202e-01f, 2.07317621e-02f,
  1.10955745e-01f, -7.98070431e-02f, -1.24031886e-01f, -6.57697814e-03f, -5.04544713e-02f, 8.64529014e-02f, -6.73873872e-02f, 9.12269130e-02f, -7.32619762e-02f, -1.08245343e-01f,
  2.84447253e-01f, 4.50895466e-02f, 1.94511674e-02f, 8.98636431e-02f, -8.30998495e-02f, 4.47538979e-02f, 1.16084710e-01f, -1.66759714e-02f, -1.08920157e-01f, 1.67988643e-01f,
  6.14288189e-02f, -5.42767271e-02f, 1.03392571e-01f, 3.95263061e-02f, 2.18633376e-03f, 7.32885068e-03f, 1.03092499e-01f, 5.82029857e-03f, -4.82358113e-02f, 4.03294414e-02f,
  -1.25616621e-02f, 4.08571325e-02f, 1.06023580e-01f, -2.28552381e-04f, 1.32109761e-01f, 3.95804308e-02f, -8.57467279e-02f, 6.85670376e-02f, -6.19130358e-02f, -4.45243232e-02f,
  6.54141665e-01f, 1.46057513e-02f, 1.39114320e-01f, 1.36415496e-01f, -4.87330407e-02f, -7.76510537e-02f, -2.68540800e-01f, -1.05304956e-01f, -1.04747683e-01f, 2.22786088e-02f,
  9.64885652e-02f, 1.21184595e-01f, 1.28340945e-01f, 8.02786276e-02f, 9.42646787e-02f, -1.09274678e-01f, -8.32308233e-02f, 2.27355480e-01f, 2.01849043e-01f, 2.46312663e-01f,
  1.07692197e-01f, 1.38959080e-01f, 3.08038533e-01f, 1.71851382e-01f, 1.08399510e-01f, 1.50228664e-02f, 4.60914895e-03f, 1.18476547e-01f, 1.77354962e-01f, 1.11282766e-01f,
  2.36415610e-01f, 1.83693796e-01f, -6.88766390e-02f, 1.25229299e-01f, 8.19454342e-02f, -3.12540978e-02f, 6.57852218e-02f, -4.15572375e-02f, 3.90905701e-02f, -1.27397269e-01f,
  1.04674906e-01f, 1.05750099e-01f, 4.65145744e-02f, 2.49993745e-02f, 9.74809155e-02f, 3.67903225e-02f, 1.34146467e-01f, 1.34614900e-01f, 1.15303412e-01f, 1.19344462e-02f,
  6.94415048e-02f, 1.15718991e-01f, 6.67166635e-02f, -1.42022386e-01f, 5.65019734e-02f, 1.74895376e-01f, 9.38708633e-02f, 1.13133967e-01f, 1.46853877e-02f, 3.85478325e-02f,
  1.15364313e-01f, 7.47335628e-02f, 5.17588705e-02f, -2.30908096e-02f, 1.12241089e-01f, 1.98691078e-02f, -4.91170809e-02f, -3.87081578e-02f, 9.12580118e-02f, -3.04280072e-02f,
  -4.59093973e-02f, 5.16670337e-03f, 3.48777585e-02f, 8.26654285e-02f, -8.00232589e-02f, 3.41548324e-02f, 7.58234784e-02f, -3.28210997e-03f, 5.51749803e-02f, 5.01507334e-02f,
  1.92561194e-01f, 1.18086236e-02f, -3.96628380e-02f, -3.79244648e-02f, 3.07842325e-02f, -6.04920974e-03f, 5.35146929e-02f, 8.54395702e-02f, 1.64179042e-01f, 6.98491037e-02f,
  -4.18536097e-01f, -4.05086912e-02f, -9.63786840e-02f, 6.63196668e-02f, -8.50553531e-03f, -9.53384191e-02f, 4.04423848e-02f, 1.53222028e-02f, 2.71081105e-02f, -4.05641943e-02f,
  -3.10693271e-02f, 6.41167387e-02f, 5.36875576e-02f, 4.02930863e-02f, -7.49556348e-02f, -1.20342642e-01f, -2.25202013e-02f, -1.01483434e-01f, -2.07711034e-03f, 5.59932627e-02f,
  -7.03025013e-02f, -1.78287342e-01f, -5.46023026e-02f, -2.10439473e-01f, -1.58466399e-01f, -7.60649517e-02f, -1.01559721e-01f, -1.33930951e-01f, -9.78391171e-02f, -1.68055251e-01f,
  4.63585198e-01f, -4.86675091e-03f, -7.07334101e-01f, 1.08779363e-01f, -3.41724783e-01f, -4.15113062e-01f, -2.19443172e-01f, 1.13132201e-01f, 1.63129508e-01f, -4.87996675e-02f,
  -1.21447966e-01f, 8.96344613e-03f, -1.06055863e-01f, -1.34975255e-01f, -8.93391147e-02f, -2.25966617e-01f, -2.99980938e-01f, -3.30211580e-01f, -2.26691246e-01f, -1.32307475e-02f,
  3.00927069e-02f, 1.19078472e-01f, 1.17581323e-01f, 2.37083901e-02f, -2.24273968e-02f, -1.70602545e-01f, -2.94855595e-01f, -1.56343594e-01f, -2.54163802e-01f, -2.64519840e-01f,
  -4.00088072e-01f, -2.35207938e-02f, -1.31093979e-01f, 1.71403140e-01f, -7.17886239e-02f, 4.44843657e-02f, -4.84268405e-02f, -2.68042926e-02f, 6.95249215e-02f, -1.52491862e-02f,
  -4.97258408e-03f, 1.65740445e-01f, -1.20211337e-02f, -4.69894893e-02f, -4.36469214e-03f, 7.38880504e-03f, -7.39474073e-02f, -6.96024895e-02f, 1.08078551e-04f, 8.56055971e-03f,
  3.95978317e-02f, -1.86812028e-01f, -1.77787349e-01f, -5.83478995e-02f, -9.07900408e-02f, -9.46849734e-02f, -7.97906965e-02f, -8.55213478e-02f, -1.75524876e-01f, 9.01356265e-02f,
  1.05883047e-01f, 4.31876890e-02f, 1.83805469e-02f, 2.38668788e-02f, 2.52230197e-01f, -4.18926366e-02f, 9.17976315e-04f, 3.45552489e-02f, 6.83617499e-03f, -4.94338721e-02f,
  2.41710898e-03f, -7.33419433e-02f, -2.53658276e-03f, -5.49700260e-02f, -9.84773338e-02f, -1.82946157e-02f, -2.28695385e-02f, 1.48159629e-02f, -1.03577241e-01f, 9.08986572e-03f,
  -2.11836379e-02f, -2.90915575e-02f, 1.56693477e-02f, 3.54172699e-02f, -7.67827854e-02f, -6.72911927e-02f, -5.54985441e-02f, 7.75106028e-02f, 2.20584385e-02f, 1.38924434e-03f,
  2.76696742e-01f, -1.32833809e-01f, 6.32976145e-02f, 1.17495872e-01f, -1.63627654e-01f, -1.14682116e-01f, -2.72112768e-02f, 4.51573506e-02f, -8.78151655e-02f, 5.18857874e-02f,
  -4.63766791e-02f, 1.01005971e-01f, -1.07609607e-01f, 9.20954626e-03f, -2.73782108e-02f, -2.54064593e-02f, 4.02333885e-02f, -1.23191088e-01f, 1.49949302e-03f, 7.15158731e-02f,
  7.89313763e-02f, 3.55437286e-02f, 1.01071373e-01f, 1.62135363e-02f, 3.12238764e-02f, 2.25211810e-02f, 2.27799620e-02f, 1.79870543e-03f, 2.17529610e-02f, 3.51904869e-01f,
  7.02201188e-01f, 1.34346932e-01f, 1.84730917e-01f, 8.61797631e-02f, -7.00146407e-02f, -8.07634890e-02f, -7.90136829e-02f, -1.20545074e-01f, -6.92119002e-02f, 1.50279373e-01f,
  1.95060998e-01f, 1.40811220e-01f, 5.90589968e-03f, 5.95437661e-02f, 1.08031288e-01f, -1.23239510e-01f, 8.97259160e-04f, 1.45633623e-01f, 2.11008027e-01f, 1.38396651e-01f,
  3.31775472e-02f, 9.11030173e-02f, 1.87321290e-01f, 4.29629758e-02f, 4.94924150e-02f, 2.67846007e-02f, 9.08395350e-02f, 1.67443454e-01f, 1.40933558e-01f, 1.70644045e-01f,
  3.85954112e-01f, 2.44787082e-01f, -2.38859162e-01f, 2.31190491e-02f, 1.04617193e-01f, 1.98264420e-02f, -8.51804689e-02f, -1.17330037e-01f, -1.44079691e-02f, -7.12899193e-02f,
  6.21251985e-02f, 2.63511408e-02f, 2.88533848e-02f, -4.68517207e-02f, 6.32553885e-04f, -1.03886433e-01f, 7.23970681e-02f, -1.29949544e-02f, 1.32562937e-02f, 2.93296166e-02f,
  -1.12782203e-01f, 1.60276100e-01f, 8.82039443e-02f, -1.85442328e-01f, -8.80000927e-03f, -6.11825176e-02f, 1.44402429e-01f, 5.61308898e-02f, -3.61139253e-02f, 8.62907320e-02f,
  -4.39447956e-03f, -4.57265228e-03f, 5.36025651e-02f, 5.72755709e-02f, 2.08608881e-02f, 2.77548488e-02f, 5.44030666e-02f, 1.45780608e-01f, -9.60017070e-02f, 4.09963727e-02f,
  6.09245524e-02f, 1.78317368e-01f, -8.50051921e-03f, 6.66556805e-02f, 2.35289405e-03f, 2.94784233e-02f, 4.08762768e-02f, 1.24962721e-02f, -2.26860289e-02f, -1.03818916e-01f,
  5.68785891e-02f, -5.09480760e-02f, 1.80620588e-02f, 1.59893315e-02f, 7.50913695e-02f, -1.23813516e-02f, -3.16323601e-02f, 3.60017717e-02f, -5.51425591e-02f, -3.62995192e-02f,
  -4.04420108e-01f, -8.56942385e-02f, 7.27435425e-02f, -7.08176941e-02f, 7.28675872e-02f, -1.05167106e-01f, -8.77011567e-03f, -5.00329547e-02f, -9.25612822e-02f, -8.63232762e-02f,
  4.09074463e-02f, 5.61265424e-02f, -8.26489329e-02f, -1.32061958e-01f, 1.41193601e-03f, -8.17174837e-02f, -6.63003176e-02f, 2.13806778e-02f, -1.77178070e-01f, -6.41142577e-02f,
  -1.37654498e-01f, -2.10107833e-01f, -1.14740312e-01f, -1.97956905e-01f, -1.14377841e-01f, -1.10689357e-01f, -1.60141617e-01f, -7.92261288e-02f, -1.81617826e-01f, -2.75756627e-01f,
  1.21820256e-01f, 2.42771715e-01f, -2.96976924e-01f, 2.74221510e-01f, 2.78864294e-01f, -1.26625150e-01f, -1.65575027e-01f, -1.88990071e-01f, 1.73318610e-01f, 1.29631743e-01f,
  2.96727151e-01f, 1.20766342e-01f, -2.12245956e-02f, -2.61821181e-01f, -4.49843317e-01f, -2.00724706e-01f, -1.99403420e-01f, -4.98244345e-01f, -4.38100725e-01f, -1.62621722e-01f,
  1.22585684e-01f, 1.67100042e-01f, -5.79425879e-02f, -1.76843151e-01f, 1.75942734e-01f, 6.22923346e-03f, 6.69757873e-02f, 1.39189377e-01f, -6.20013438e-02f, -1.18460082e-01f,
  -1.18220367e-01f, 9.74734277e-02f, -1.35245934e-01f, -1.26232700e-02f, 2.60764826e-02f, -1.66666716e-01f, -2.17267629e-02f, -1.46260083e-01f, 2.62498260e-02f, 2.05359291e-02f,
  1.95846513e-01f, -7.36724660e-02f, 1.01394169e-01f, -5.01650833e-02f, 8.83875266e-02f, -1.47911310e-01f, -4.76818718e-02f, -3.00203741e-01f, -1.39685676e-01f, -1.65665239e-01f,
  1.75419554e-01f, 1.74030289e-01f, -8.76851231e-02f, -1.44669414e-01f, -2.03963771e-01f, -4.89284471e-02f, -7.97984973e-02f, -2.04417512e-01f, -2.69731671e-01f, -1.84844375e-01f,
  -7.47639760e-02f, 8.34398270e-02f, 6.10722713e-02f, 7.40080252e-02f, 1.40323648e-02f, 1.03584275e-01f, 4.11297288e-03f, -7.18799978e-02f, 4.62084301e-02f, -4.56426702e-02f,
  7.84290805e-02f, 7.31935650e-02f, 1.05984230e-02f, 1.36694475e-03f, 2.45936699e-02f, -6.09925054e-02f, -1.32558450e-01f, -4.66664955e-02f, -1.07676104e-01f, -5.24546504e-02f,
  -5.88820390e-02f, 7.88996927e-03f, 1.03452280e-01f, -1.34277448e-01f, -7.45713478e-03f, -1.31377801e-01f, 2.91569289e-02f, -1.72700062e-02f, -3.97683308e-03f, 7.17608258e-02f,
  1.26751184e-01f, -8.36670697e-02f, -8.82176682e-03f, -1.36991128e-01f, 7.91430995e-02f, -4.57940027e-02f, 2.53814906e-01f, -1.21430017e-01f, 8.49953964e-02f, -2.88276058e-02f,
  -6.47873878e-02f, -8.78568143e-02f, 1.58455253e-01f, -5.46698198e-02f, 4.49520675e-03f, 5.32672815e-02f, 2.06914023e-02f, -1.35894537e-01f, 1.22546246e-02f, 1.48530066e-01f,
  1.33111209e-01f, -4.07854933e-03f, -8.90562385e-02f, -1.27938747e-01f, 2.02295538e-02f, -2.87661254e-02f, -1.36919931e-01f, -1.77240536e-01f, -2.68639714e-01f, -2.04099610e-01f,
  5.68374582e-02f, 1.62674099e-01f, 1.29492432e-01f, -1.07047148e-03f, 2.32259706e-01f, 1.47497192e-01f, 3.67913336e-01f, 1.89109296e-01f, -3.99638489e-02f, 1.07906304e-01f,
  7.83940107e-02f, -2.25374877e-01f, -1.45642042e-01f, -2.21416906e-01f, -2.03388054e-02f, 1.04635626e-01f, -3.29496451e-02f, -8.05039480e-02f, 9.10435431e-03f, 2.32200012e-01f,
  9.85602736e-02f, 3.30987692e-01f, 1.69000745e-01f, 1.23843616e-02f, -7.67298043e-02f, -5.54916523e-02f, 8.65857005e-02f, 2.00352613e-02f, -6.73990175e-02f, -1.80519044e-01f,
  6.14254512e-02f, 5.70264049e-02f, -7.26009607e-02f, -2.60388196e-01f, -5.06829210e-02f, -3.08669228e-02f, 3.20342625e-03f, -8.08637366e-02f, -9.78976563e-02f, -3.58378440e-02f,
  -8.38985369e-02f, -2.91035846e-02f, -1.01275705e-01f, 2.47196741e-02f, 1.25720039e-01f, 1.28257856e-01f, -1.63742006e-02f, -8.03857148e-02f, -1.76380172e-01f, -1.59204438e-01f,
  -1.49584442e-01f, 3.72728780e-02f, 5.85009642e-02f, 8.10738839e-03f, -1.46629512e-01f, -9.89363045e-02f, -4.63039763e-02f, -7.92366266e-02f, -2.83956602e-02f, -5.07115200e-03f,
  -1.37094781e-01f, -8.75114426e-02f, -7.19607398e-02f, -4.64361794e-02f, 3.47838849e-02f, -5.48741817e-02f, -7.25528076e-02f, 2.54453570e-02f, 9.14613977e-02f, 1.36452377e-01f,
  -9.98805277e-03f, 1.17590703e-01f, 1.35532347e-02f, 1.13547395e-03f, -3.55045795e-02f, 3.15280594e-02f, 8.76006559e-02f, 6.38127467e-03f, 6.50735572e-02f, 1.08377762e-01f,
  1.51629336e-02f, -4.06692512e-02f, 6.53554350e-02f, -3.98976654e-02f, 5.35542220e-02f, -1.08907960e-01f, 6.48542047e-02f, 2.46525574e-02f, -9.14221108e-02f, 7.93000087e-02f,
  3.74456078e-01f, 1.43013373e-01f, -1.39898866e-01f, -2.04618007e-01f, -9.96747911e-02f, -5.82571402e-02f, -5.64752426e-03f, -1.58577278e-01f, 8.87651835e-03f, -3.37854661e-02f,
  3.59392092e-02f, 4.06632349e-02f, 9.18006897e-02f, 9.90638062e-02f, 1.37163177e-01f, 1.84462667e-01f, -8.09539109e-02f, 1.77157652e-02f, -1.06910750e-01f, 5.26046706e-03f,
  -8.93354416e-02f, 2.49855071e-02f, 7.59973899e-02f, 3.91062014e-02f, 7.63890380e-03f, 7.84790590e-02f, 1.66877255e-01f, -2.53714505e-03f, 2.30875658e-03f, 2.38375142e-01f,
  5.71106613e-01f, -4.20814574e-01f, -3.40883464e-01f, 6.02927580e-02f, -1.83317885e-01f, -1.31589368e-01f, -4.89047617e-01f, 9.63023379e-02f, 1.62756726e-01f, -3.63023311e-01f,
  -4.18490097e-02f, 4.93851393e-01f, 3.25756490e-01f, 2.54967242e-01f, 2.38019541e-01f, -5.12891293e-01f, -5.28055668e-01f, 1.02264464e-01f, 3.15135330e-01f, 8.18406045e-02f,
  -1.78047568e-01f, -7.37519562e-02f, 1.17119350e-01f, 9.30764824e-02f, -3.43856633e-01f, 9.54818428e-02f, -4.07160789e-01f, -2.34444439e-01f, -3.36334109e-01f, -4.89249349e-01f,
  -2.04671755e-01f, 9.59551558e-02f, -2.50838846e-02f, 1.76360130e-01f, -1.84768438e-01f, 8.82836878e-02f, 4.27214839e-02f, -1.93578973e-01f, -7.89725631e-02f, -1.78851679e-01f,
  -6.18659612e-03f, 6.51587173e-02f, 7.34724551e-02f, 6.58547282e-02f, -7.69765154e-02f, 6.33368492e-02f, -1.70469403e-01f, -5.87507337e-02f, -5.67793846e-02f, -2.26772428e-01f,
  -2.90511370e-01f, -1.88715696e-01f, 9.20519978e-02f, -2.45086581e-01f, 4.31031774e-04f, 1.56552270e-01f, -1.75928593e-01f, -3.06119374e-03f, -3.70068066e-02f, -3.74143094e-01f,
  -4.03457284e-02f, -4.10700366e-02f, -7.33679608e-02f, -1.34173408e-01f, 3.67319286e-02f, -5.06103374e-02f, 1.02631347e-02f, 1.30806239e-02f, -1.12521693e-01f, -1.74312383e-01f,
  1.70485806e-02f, -1.29327089e-01f, 2.68848380e-03f, -1.62029698e-01f, -1.83291033e-01f, -5.56951538e-02f, 4.18916019e-03f, -1.14053831e-01f, 3.97825763e-02f, -7.52158761e-02f,
  2.07936987e-02f, 2.55164970e-02f, 1.18790604e-01f, 2.98320297e-02f, 2.42911559e-02f, 8.25236216e-02f, 1.03383092e-02f, 6.63108677e-02f, 4.36338186e-02f, -8.50499794e-02f,
  3.79999042e-01f, 1.88569844e-01f, 2.35475935e-02f, 2.09625617e-01f, -1.26980305e-01f, 3.30661461e-02f, -8.08676332e-02f, -1.17793627e-01f, 8.94376356e-03f, 1.65130779e-01f,
  -6.15045018e-02f, 1.67755425e-01f, 3.57430838e-02f, -1.28176376e-01f, -1.91001967e-01f, -5.70287481e-02f, -2.97726505e-02f, -1.45588946e-02f, -1.20850898e-01f, -1.78629503e-01f,
  -2.05107093e-01f, 1.36224646e-02f, 1.89531088e-01f, -4.06164080e-02f, -8.93474817e-02f, 2.97011077e-01f, -2.16548294e-01f, -1.00258522e-01f, 1.36399359e-01f, -3.52925181e-01f,
  2.53172189e-01f, 1.08890198e-01f, 1.02865875e-01f, 2.26220503e-01f, -4.56980392e-02f, -1.38377547e-01f, -2.41654202e-01f, -2.20145091e-01f, 8.43981355e-02f, 1.54572845e-01f,
  1.21508092e-01f, 8.35468844e-02f, 1.12516344e-01f, 1.58545345e-01f, 6.08128384e-02f, -7.27905035e-02f, 6.19411021e-02f, 1.67743355e-01f, -4.74276990e-02f, -1.87861566e-02f,
  9.00703520e-02f, -2.03962368e-03f, 7.88248926e-02f, 1.74068958e-01f, 2.05561265e-01f, 1.17023163e-01f, -1.78667475e-02f, 3.26936785e-03f, 1.60891712e-01f, 2.35309690e-01f,
  3.99978697e-01f, 2.73007810e-01f, -7.37587968e-03f, -2.90697869e-02f, 7.70503730e-02f, 8.99233222e-02f, -4.73876074e-02f, 2.44902130e-02f, -1.84162810e-01f, -3.49026881e-02f,
  5.75139187e-02f, -4.03419361e-02f, 7.93155879e-02f, -2.07351260e-02f, -5.29241562e-02f, 2.04438698e-02f, 7.97966272e-02f, 8.79392847e-02f, 8.43236074e-02f, 1.52895197e-01f,
  8.90621915e-02f, -3.29698622e-02f, -9.14657041e-02f, -1.07312977e-01f, -6.62770867e-02f, 5.52135445e-02f, -3.74905169e-02f, 1.01420350e-01f, -1.88446566e-02f, 7.06911758e-02f,
  3.91608700e-02f, 1.28612459e-01f, 1.62556812e-01f, 4.86673526e-02f, -1.06920891e-01f, -1.17363319e-01f, -6.71823174e-02f, -1.31477892e-01f, -7.73719102e-02f, -9.78305340e-02f,
  -9.30025652e-02f, 5.62740937e-02f, -4.44426984e-02f, -1.24949887e-01f, 1.29705817e-01f, 1.53511450e-01f, 4.99247527e-03f, 1.81437790e-01f, 1.41453043e-01f, 1.01556815e-01f,
  6.23019673e-02f, 2.42156405e-02f, 3.62362862e-02f, 6.18058071e-02f, 8.88865218e-02f, -8.00954830e-03f, -3.28492448e-02f, -6.11726642e-02f, -8.05394799e-02f, -8.61824453e-02f,
  1.21032812e-01f, 1.87829167e-01f, 1.51722834e-01f, 2.50395000e-01f, 1.00601479e-01f, 9.96835530e-02f, 2.99139619e-01f, 4.43903133e-02f, 3.49849686e-02f, 4.29403186e-02f,
  5.61681427e-02f, 1.42749712e-01f, 5.35254478e-02f, 6.89149797e-02f, -6.18789531e-02f, -3.16281989e-02f, 6.11281544e-02f, 1.18067838e-01f, 9.86954570e-02f, 1.82370707e-01f,
  4.60724346e-02f, -1.10555001e-01f, 2.99073365e-02f, -1.23093262e-01f, -1.28638089e-01f, -4.07623127e-02f, -2.14582626e-02f, -7.19405850e-03f, -1.13118179e-02f, -2.25995257e-01f,
  -2.34745055e-01f, 1.20895624e-01f, -3.25195551e-01f, 1.63432527e-02f, 1.44489363e-01f, 1.16021253e-01f, 2.89520383e-01f, 2.22593844e-01f, 3.15132707e-01f, 2.44289130e-01f,
  2.18278736e-01f, 2.75954038e-01f, 2.61771053e-01f, 2.52748132e-01f, 1.59747675e-01f, 2.68678844e-01f, 1.70341656e-01f, -1.30610064e-01f, -4.85028438e-02f, 1.01260087e-02f,
  1.33593097e-01f, 9.12056714e-02f, -1.23735875e-01f, 2.54201610e-02f, 1.86266135e-02f, 1.47989407e-01f, 1.20903969e-01f, 4.42406386e-02f, 1.52166367e-01f, 7.76564144e-03f,
  -2.86104739e-01f, -5.91376759e-02f, -2.13990286e-02f, -4.59708422e-02f, -1.42915174e-01f, -1.87003508e-01f, -1.81105688e-01f, -1.22655995e-01f, 4.31645140e-02f, 3.83814350e-02f,
  -1.66966811e-01f, -7.86000565e-02f, -4.11934666e-02f, -1.36388034e-01f, -1.71952978e-01f, -1.38747811e-01f, 1.43321250e-02f, 1.57238558e-01f, 6.96231425e-02f, -8.13356265e-02f,
  -1.40251312e-02f, -3.66720855e-02f, -1.34727567e-01f, 9.95806083e-02f, 1.24842368e-01f, 4.42478582e-02f, -2.06200425e-02f, -1.34612948e-01f, 2.44193561e-02f, -6.18190272e-03f,
  1.56643853e-01f, -4.27436791e-02f, -1.02155626e-01f, -5.31780720e-03f, 1.13911949e-01f, 4.74224798e-02f, 6.00729100e-02f, 4.84141428e-03f, 1.06195413e-01f, 1.35635734e-02f,
  7.29431957e-02f, 9.26098973e-02f, 1.27871022e-01f, 2.08653733e-02f, -1.01151332e-01f, -1.11999922e-01f, -6.33520186e-02f, -1.17755622e-01f, -1.57054216e-01f, -1.13269826e-02f,
  -6.13863766e-02f, -7.34491721e-02f, -2.10883319e-01f, -2.28718892e-02f, -8.95095542e-02f, -1.42107264e-03f, -5.66086397e-02f, -1.82051770e-02f, 6.72786217e-03f, 1.10958954e-02f,
  2.98489869e-01f, -1.09498978e-01f, 1.30216748e-01f, 8.17374885e-02f, -5.80592901e-02f, -1.78619757e-01f, 5.39643317e-03f, -5.97416684e-02f, -1.57470137e-01f, -1.22894254e-02f,
  -1.76161513e-01f, -2.25783065e-01f, -1.55983999e-01f, -6.63059531e-03f, -1.34739950e-01f, -7.98337832e-02f, -5.42082153e-02f, 9.15342271e-02f, 6.02690615e-02f, -1.16969936e-01f,
  -1.26939833e-01f, -8.20003301e-02f, 2.03732438e-02f, 7.65293315e-02f, 9.22174379e-02f, -5.23926169e-02f, -1.05461545e-01f, -3.40797827e-02f, -1.66632354e-01f, -5.69261089e-02f,
  -7.42104888e-01f, -5.33599198e-01f, 2.75698185e-01f, 7.12435022e-02f, 1.46344051e-01f, 2.76864244e-04f, -6.43032491e-02f, -1.66163370e-01f, -7.23114610e-02f, -6.17868379e-02f,
  -9.94058028e-02f, 1.21266535e-02f, 1.09008504e-02f, 3.11263036e-02f, -8.34152773e-02f, 7.35435411e-02f, 2.06654742e-01f, 2.32677981e-01f, 2.14656353e-01f, 3.38428020e-02f,
  2.45886147e-02f, 7.72107691e-02f, -5.13284951e-02f, 4.37030941e-02f, 5.60610555e-02f, 1.48030907e-01f, 1.22834541e-01f, 9.97981280e-02f, 1.04931414e-01f, 1.78251192e-01f,
  4.98056144e-01f, -1.12846963e-01f, 1.66672289e-01f, 1.96615066e-02f, -7.75262266e-02f, -5.04472703e-02f, 1.09335229e-01f, -4.68489043e-02f, -3.32582779e-02f, 1.19102806e-01f,
  2.68927421e-02f, -3.27265933e-02f, 7.88785443e-02f, -2.38646343e-02f, 1.32947400e-01f, 4.53717746e-02f, -1.12389354e-02f, -1.94560317e-03f, -7.36201601e-03f, 9.21613649e-02f,
  8.02399497e-03f, 6.09719716e-02f, 1.02075130e-01f, 9.82142612e-02f, -1.13147967e-01f, 3.99243534e-02f, 7.28112385e-02f, 2.65437234e-02f, 8.77244547e-02f, 3.51941325e-02f,
  8.44782889e-02f, -1.63301349e-01f, -6.07421473e-02f, 6.95965812e-03f, 2.25845426e-02f, -7.14833364e-02f, -3.05139720e-02f, -7.00077266e-02f, 2.58242115e-02f, -3.41132395e-02f,
  -3.76440138e-02f, 1.29331619e-01f, -3.79928350e-02f, -1.85762923e-02f, -9.87098087e-03f, 3.53928767e-02f, -1.13015123e-01f, 1.36559844e-01f, 5.42523749e-02f, -2.95661427e-02f,
  7.81394094e-02f, -6.18294906e-03f, 4.44634818e-02f, 1.21629834e-01f, 1.96277592e-02f, 1.75394416e-01f, 1.12077162e-01f, 5.59352944e-03f, 3.77185270e-02f, -6.26241639e-02f,
  2.22989857e-01f, 1.55319989e-01f, 4.69093025e-02f, -1.46384209e-01f, 2.98672505e-02f, -1.64537579e-01f, -7.38053992e-02f, 6.58724979e-02f, -3.07371784e-02f, 1.34425029e-01f,
  8.13991055e-02f, -5.93857951e-02f, -1.53347114e-02f, -8.83869380e-02f, 1.38730422e-01f, -8.01854488e-03f, -1.02872171e-01f, -5.37895225e-02f, 8.00187662e-02f, 1.16185591e-01f,
  -1.82472005e-01f, 9.66290534e-02f, 2.55694780e-02f, 6.64468706e-02f, -8.81594568e-02f, -3.23914513e-02f, -1.46385152e-02f, 8.77467319e-02f, 1.01883642e-01f, 4.64315116e-02f,
  2.97045141e-01f, 5.85722744e-01f, 3.29716206e-01f, -1.68200597e-01f, 1.33783087e-01f, 2.72967309e-01f, 3.74217212e-01f, 2.24572331e-01f, -9.75052789e-02f, 7.46399164e-02f,
  1.18966796e-01f, -3.20817977e-01f, -1.36032999e-01f, -2.01792866e-01f, 2.32949127e-02f, -1.50834182e-02f, -1.17605887e-01f, -1.47873059e-01f, -1.88371688e-01f, -2.65825868e-01f,
  -3.26197088e-01f, -4.48593348e-02f, -9.35470089e-02f, -6.64578378e-02f, 8.68111625e-02f, -2.25938916e-01f, 3.03257853e-01f, 1.43299639e-01f, 1.44254401e-01f, -2.00490847e-01f,
  -2.56732907e-02f, 4.65579957e-01f, -4.65758771e-01f, -8.77873823e-02f, 1.68562412e-01f, -2.21184507e-01f, -1.62836701e-01f, 6.42494932e-02f, -2.91845296e-02f, -6.59761578e-02f,
  -2.07627825e-02f, 7.41618797e-02f, 7.60605931e-02f, -7.47063905e-02f, 1.48237646e-01f, -2.44375300e-02f, -3.20422351e-02f, 2.39294842e-02f, -1.33703843e-01f, 8.89429674e-02f,
  -2.35344261e-01f, 9.27124619e-02f, 2.48472303e-01f, 1.39785325e-03f, 1.84358642e-01f, -1.12529866e-01f, 2.62479156e-01f, 7.99597055e-02f, 1.39436185e-01f, 4.68149148e-02f,
  -1.75576910e-01f, 1.91947207e-01f, 8.17535296e-02f, 8.22403189e-03f, -1.41096488e-01f, -1.17070220e-01f, 2.79228501e-02f, -3.81146260e-02f, -5.27298935e-02f, 2.34526098e-02f,
  1.90943591e-02f, -1.47209717e-02f, 7.74119794e-02f, 6.64984286e-02f, -1.47826359e-01f, 4.93536741e-02f, 4.43410426e-02f, 6.46667108e-02f, -2.74420204e-03f, 2.15995647e-02f,
  -6.57467917e-02f, 1.66659802e-02f, 3.59222628e-02f, -1.54863754e-02f, -2.25354545e-02f, -3.21236365e-02f, -1.66038901e-01f, 2.12090369e-02f, 2.14910116e-02f, -8.87023136e-02f,
  -2.58954197e-01f, 2.22886149e-02f, -2.23056763e-01f, 5.57749830e-02f, 1.99015439e-01f, 2.40902323e-02f, -6.51714904e-03f, 2.92412154e-02f, 7.85015523e-02f, 1.13151737e-01f,
  7.57872779e-03f, -6.89191073e-02f, 1.35631219e-01f, -5.14681563e-02f, -1.91781864e-01f, -6.24433942e-02f, -7.40941167e-02f, -1.64806262e-01f, -3.34846005e-02f, 1.18726723e-01f,
  -5.87150902e-02f, -2.38339663e-01f, -2.59325355e-01f, -7.43662268e-02f, -1.20124668e-01f, -4.01095718e-01f, -9.30331945e-02f, 1.01645878e-02f, -3.97261716e-02f, -1.89821765e-01f,
  6.86423719e-01f, 2.43807331e-01f, 2.01160431e-01f, 3.40165824e-01f, 2.50757605e-01f, 3.10250431e-01f, 2.56377190e-01f, 1.52594224e-01f, 1.71214506e-01f, 1.65677294e-01f,
  2.47083351e-01f, 1.05607137e-01f, 2.32551038e-01f, 1.30495608e-01f, 1.56715155e-01f, 8.20826516e-02f, -4.75264899e-02f, -1.86703298e-02f, 1.22417361e-01f, -1.30292419e-02f,
  4.00575101e-02f, 2.30096895e-02f, 6.29948527e-02f, -3.63179222e-02f, -6.24359436e-02f, 1.78912058e-02f, -2.06877589e-02f, -8.32672715e-02f, 3.52222696e-02f, -1.70172319e-01f,
  -1.91327885e-01f, 1.76629603e-01f, -7.48067275e-02f, -1.24140419e-01f, -1.56766772e-02f, -9.10491776e-03f, 1.32990703e-02f, -1.54224172e-01f, 7.14116078e-03f, -6.26759306e-02f,
  -6.08314313e-02f, -9.38705206e-02f, -8.22476000e-02f, -3.31908800e-02f, -5.32196090e-02f, -3.97690721e-02f, -6.12177141e-02f, -1.45742208e-01f, -3.83140519e-02f, 3.17812152e-02f,
  -1.12740442e-01f, -9.17574465e-02f, -2.88305879e-02f, 2.93698832e-02f, 8.18420127e-02f, -5.03250137e-02f, 3.05038802e-02f, -8.15683603e-02f, 3.21141966e-02f, -3.04781217e-02f,
  -3.66094336e-02f, -2.79171150e-02f, -1.97949186e-02f, 4.20996994e-02f, 1.92733780e-01f, -1.00523718e-01f, -1.26159966e-01f, -8.51450413e-02f, -2.28121551e-03f, -5.59678907e-03f,
  -5.04901595e-02f, 7.87979588e-02f, -7.70233572e-02f, 6.61107302e-02f, 1.44543171e-01f, -1.29534379e-01f, -1.86465278e-01f, -4.40046117e-02f, -1.00571299e-02f, -2.70351544e-02f,
  -7.04536960e-02f, -8.11627582e-02f, -1.18252024e-01f, -8.48837495e-02f, -9.87845436e-02f, 6.16456941e-02f, -3.20712179e-02f, 3.36738899e-02f, 1.47783741e-01f, 8.34155083e-02f,
  -2.27984712e-01f, 9.26098824e-02f, -3.41118756e-03f, -1.17583573e-01f, -1.46327749e-01f, 5.06855734e-02f, 1.88060656e-01f, -9.08071399e-02f, -9.31043923e-02f, 5.44317551e-02f,
  4.87054065e-02f, -4.53952327e-02f, -5.23914758e-04f, -8.71470049e-02f, -1.17942967e-01f, -1.02610692e-01f, -2.79280599e-02f, -3.08181103e-02f, -2.40402035e-02f, -8.96225199e-02f,
  -1.34006694e-01f, -2.22933237e-02f, -7.53298551e-02f, -9.43453144e-03f, -6.47862032e-02f, 1.30985165e-02f, -6.73328191e-02f, -1.20678686e-01f, -1.99508090e-02f, -6.96297511e-02f,
  -7.38448620e-01f, 1.16004422e-01f, 4.07188147e-01f, -4.01484787e-01f, 5.72657362e-02f, 3.06357741e-01f, 4.07731593e-01f, 7.97709152e-02f, -2.39175901e-01f, -7.17652142e-02f,
  7.00307041e-02f, -1.74812973e-01f, -6.68943673e-02f, -6.61619976e-02f, -1.58262420e-02f, 1.95670083e-01f, 9.97509509e-02f, -1.46423459e-01f, -5.42197302e-02f, -1.58195309e-02f,
  2.76082139e-02f, -2.29364529e-01f, -3.47047836e-01f, -2.14690179e-01f, -3.23528573e-02f, -1.58782199e-01f, -1.26398932e-02f, -5.48763797e-02f, 1.88316748e-01f, -8.98877382e-02f,
  4.27036583e-01f, -4.73036841e-02f, -8.84981826e-02f, -2.62969941e-01f, 8.76899809e-02f, -3.41279432e-02f, -3.72796208e-02f, 4.67563383e-02f, 1.42438915e-02f, 3.17363441e-02f,
  -5.80901653e-02f, -1.53687522e-01f, -6.37235641e-02f, 7.24672154e-02f, 2.42977478e-02f, -1.85684767e-02f, 4.46655042e-02f, 1.71249621e-02f, -5.78642450e-02f, 1.49189040e-01f,
  8.55667293e-02f, 2.92554758e-02f, 8.35585892e-02f, 1.83971301e-01f, 4.57950197e-02f, -5.65904267e-02f, 1.12056814e-01f, -9.05055329e-02f, 8.23944658e-02f, -1.31157458e-01f,
  -1.40389636e-01f, -1.09710589e-01f, 1.46930963e-02f, 3.04127093e-02f, -1.44051880e-01f, 3.54413129e-02f, 9.04572979e-02f, 1.13500521e-01f, 1.10410966e-01f, 6.44180179e-02f,
  7.37726688e-02f, 2.17336640e-01f, 5.09819463e-02f, 1.09610707e-02f, -1.47669204e-03f, -2.14519892e-02f, 7.04767182e-02f, 2.43127532e-03f, 1.26039900e-03f, -1.26092553e-01f,
  -7.57748485e-02f, 5.98910637e-02f, -3.23068835e-02f, 4.53656539e-02f, -1.41207688e-02f, 1.68148670e-02f, 4.86306772e-02f, 5.34397475e-02f, 4.55283746e-02f, 1.76872802e-03f,
  4.73417714e-02f, 6.50036484e-02f, -1.07419305e-02f, -1.31883115e-01f, 8.61971378e-02f, 8.82001817e-02f, 5.58241690e-03f, 3.28280255e-02f, 1.33005753e-01f, 1.08574487e-01f,
  5.94255701e-02f, -4.47295606e-02f, 1.14095323e-01f, 6.38930127e-02f, -4.30862093e-03f, -1.10832350e-02f, 1.16507066e-02f, 9.57268775e-02f, -1.60457995e-02f, 7.62164891e-02f,
  -2.88897101e-02f, 1.27862602e-01f, 9.35492143e-02f, 1.06854439e-01f, 7.72656724e-02f, -2.93870486e-04f, 1.23043500e-01f, 7.29206428e-02f, 1.13059178e-01f, -5.33229411e-02f,
  -6.47794664e-01f, -2.56278925e-02f, -2.93289065e-01f, -3.06828737e-01f, -1.72877684e-01f, 1.01931058e-01f, 4.62627500e-01f, 1.46510482e-01f, -1.68258950e-01f, -3.76104983e-03f,
  -1.17954109e-02f, -7.55936205e-02f, -1.20827325e-01f, 1.61964998e-01f, 3.64787638e-01f, 2.72310108e-01f, 2.24674240e-01f, 8.35682079e-02f, 1.13543943e-01f, 2.24694163e-01f,
  1.99077532e-01f, -3.09534445e-02f, -7.73226768e-02f, 7.59565458e-02f, -2.29593694e-01f, -3.96080017e-02f, -1.25485778e-01f, -1.12996340e-01f, 2.16272488e-01f, 7.25998031e-03f,
  -4.66357410e-01f, -3.50016117e-01f, 8.09307918e-02f, -6.94796070e-02f, -6.08016439e-02f, 8.92458558e-02f, 7.15949759e-02f, -6.02568388e-02f, -5.71129061e-02f, -3.27112377e-02f,
  -9.63012427e-02f, -1.67105775e-02f, -1.46975353e-01f, 3.35296877e-02f, -1.38019115e-01f, 2.98115090e-02f, 6.18395545e-02f, 1.43885940e-01f, -1.04981646e-01f, -1.56424847e-02f,
  1.36458829e-01f, -5.60287237e-02f, -2.43871421e-01f, 1.44963101e-01f, -3.22155543e-02f, -4.03366685e-02f, -1.37519343e-02f, -3.45113799e-02f, 3.08226589e-02f, -2.00539276e-01f,
  -1.46058919e-02f, -7.04014152e-02f, -1.19807273e-02f, -8.78447890e-02f, 8.83298665e-02f, 9.15637985e-03f, 1.55480383e-02f, 1.12208545e-01f, -1.11881107e-01f, -1.59417674e-01f,
  -4.83945310e-02f, -4.05877419e-02f, 5.97034097e-02f, -2.68860720e-04f, -3.14266421e-02f, -9.02671963e-02f, 2.79029608e-02f, 7.48983100e-02f, -3.36279757e-02f, 7.52900690e-02f,
  -3.57893645e-03f, 4.90319962e-03f, -9.52891558e-02f, 1.35739207e-01f, 4.93321419e-02f, 3.64119597e-02f, -1.53742507e-02f, -2.43003853e-02f, -1.43705234e-01f, -1.66084450e-02f,
  -3.16790193e-01f, 2.67971516e-01f, -2.54259288e-01f, 6.30851164e-02f, -1.06056765e-01f, 6.07762113e-02f, 5.70204929e-02f, 6.29268214e-02f, -1.02214389e-01f, -5.64689524e-02f,
  4.33034189e-02f, 1.25021990e-02f, -8.71336088e-02f, 1.52642831e-01f, -3.30470875e-02f, -6.67965263e-02f, 9.45695713e-02f, -4.05080914e-02f, 4.05500196e-02f, -4.97275069e-02f,
  -8.37414191e-05f, 2.64297016e-02f, -1.61001965e-01f, -2.62688454e-02f, -1.33999482e-01f, -1.16628103e-01f, -9.30843800e-02f, -1.02608055e-01f, 7.71864578e-02f, -6.97403476e-02f,
  -4.13187772e-01f, -3.26742709e-01f, 1.25484625e-02f, -3.25674325e-01f, -2.05655217e-01f, -6.73686787e-02f, -2.98248053e-01f, -5.06058782e-02f, -3.30015793e-02f, -3.17807287e-01f,
  -1.21207625e-01f, 6.61064833e-02f, -8.25549364e-02f, 2.83131488e-02f, -8.31617229e-03f, -3.24429125e-01f, -2.46776387e-01f, -3.84827591e-02f, 2.34675482e-01f, 6.93568140e-02f,
  -1.47389472e-01f, -9.18181986e-02f, 4.59610112e-02f, 1.24963755e-02f, -2.60666072e-01f, -6.16950281e-02f, -1.82910621e-01f, -2.23621190e-01f, -1.74789056e-01f, -3.70904773e-01f,
  -3.22588533e-01f, -1.93340294e-02f, 2.01045677e-01f, 9.40438360e-02f, -3.94609086e-02f, 4.70005237e-02f, -9.46356356e-02f, 8.83281752e-02f, 7.52504468e-02f, -4.10036147e-02f,
  2.70097274e-02f, 7.32122660e-02f, -8.14238563e-02f, 6.90487325e-02f, -5.83844669e-02f, 9.18245241e-02f, 8.28354154e-03f, 1.23281568e-01f, 1.14729004e-02f, -4.92365994e-02f,
  -1.29070908e-01f, -1.04708098e-01f, -6.86613005e-03f, 4.49971408e-02f, 5.82170747e-02f, 4.53016832e-02f, 2.57274173e-02f, 6.00591004e-02f, 1.93255953e-02f, -3.28221470e-01f,
  -3.08317002e-02f, 1.74587071e-02f, 7.33249262e-02f, 8.23570937e-02f, 1.32790327e-01f, 2.81809811e-02f, -4.86304797e-02f, 4.21325257e-03f, 5.79390861e-02f, -9.13982987e-02f,
  8.19920655e-03f, -9.35811847e-02f, -1.59206595e-02f, -9.13253725e-02f, -2.56863981e-02f, -8.32305253e-02f, -1.15805745e-01f, 1.55129377e-02f, 1.24131870e-02f, -5.75215369e-02f,
  2.56323591e-02f, 7.64445213e-05f, 4.90763597e-02f, 9.78138112e-03f, 2.79222969e-02f, 1.10360868e-02f, 1.73992813e-02f, 4.02071849e-02f, -3.32171209e-02f, 5.34178391e-02f,
  -6.18860014e-02f, 2.51572251e-01f, -2.60749519e-01f, 1.16698965e-01f, -1.12926282e-01f, 1.16181754e-01f, -1.07811116e-01f, 7.57853389e-02f, -5.71015738e-02f, -1.29112750e-01f,
  4.60219868e-02f, -8.53812322e-02f, -6.64185286e-02f, 8.87240991e-02f, -1.21671520e-03f, 7.68174753e-02f, -1.23040549e-01f, -7.79534206e-02f, 8.04333910e-02f, 2.39515174e-02f,
  -1.60790011e-01f, -1.21260397e-01f, -2.09117100e-01f, -1.67699352e-01f, -9.27124992e-02f, -7.22983629e-02f, -1.71617582e-01f, -1.32586211e-01f, -9.14211348e-02f, -4.48890299e-01f,
  4.91965353e-01f, 1.67854518e-01f, 2.17518389e-01f, 1.22409861e-03f, 7.57746845e-02f, 6.74206689e-02f, 1.81805059e-01f, 1.53823793e-01f, 3.24610956e-02f, 7.33604953e-02f,
  4.66614328e-02f, -8.09249505e-02f, -2.33661607e-02f, 2.03131922e-02f, -2.69503295e-02f, -7.75386021e-02f, -2.36920174e-02f, -6.01269165e-03f, 9.64402556e-02f, 2.35520881e-02f,
  -1.55869693e-01f, 7.78818056e-02f, 7.80595168e-02f, 1.14884544e-02f, -1.33320987e-01f, -1.31904095e-01f, -5.94992675e-02f, -1.15268594e-02f, -1.41035929e-01f, -3.24272424e-01f,
  -2.44085371e-01f, 2.12568223e-01f, 7.93714356e-03f, -9.09024850e-02f, 6.68820441e-02f, 1.38571006e-04f, -2.35589258e-02f, -1.11486770e-01f, 3.19035202e-02f, -6.99723586e-02f,
  -5.96945779e-03f, 3.66892777e-02f, 1.97899733e-02f, -2.74502989e-02f, 1.29665330e-01f, 7.33689219e-02f, 1.55236840e-01f, -9.27719250e-02f, -2.42218990e-02f, 6.14425400e-03f,
  2.11002920e-02f, 1.68116465e-01f, 2.52133049e-02f, 9.30691808e-02f, 1.08914718e-01f, 9.16913375e-02f, 7.90048093e-02f, 1.16438910e-01f, 7.81203508e-02f, 1.37058571e-01f,
  -5.69289876e-03f, -3.14289629e-02f, -4.79710922e-02f, 3.94166857e-02f, 1.96581647e-01f, -3.14830616e-02f, 1.48956766e-02f, 4.11366895e-02f, 1.67489573e-01f, 7.92450011e-02f,
  -4.47699539e-02f, -5.09970449e-02f, 2.77855564e-02f, -4.59976234e-02f, -6.57593599e-03f, 9.35305059e-02f, -5.41314371e-02f, -1.10390186e-02f, 7.24008260e-03f, 1.06217144e-02f,
  6.42454298e-03f, -8.32625106e-02f, -6.13970682e-02f, -1.45078182e-01f, -8.76842290e-02f, -8.45982209e-02f, -1.28828362e-01f, -4.86365445e-02f, 3.32985111e-02f, -2.45768670e-02f,
  -2.69441128e-01f, 2.43105248e-01f, -1.07846268e-01f, -1.35727048e-01f, -3.40594798e-02f, 3.10829058e-02f, 4.52319570e-02f, -8.37602690e-02f, -2.37360626e-01f, -1.53705463e-01f,
  6.97756484e-02f, 8.08626488e-02f, 1.28670726e-02f, 2.98833214e-02f, 1.91085219e-01f, 1.20259918e-01f, 1.29701011e-02f, -3.80817838e-02f, -1.27694607e-01f, 1.38906168e-03f,
  -1.23174533e-01f, 6.99603856e-02f, 1.17768776e-02f, 2.14967038e-02f, 2.82216873e-02f, 7.02885911e-02f, -3.99516486e-02f, -7.97635168e-02f, 4.28341888e-02f, 1.17069595e-01f,
  -1.96444750e-01f, 2.38038987e-01f, 3.27902846e-02f, 2.50885617e-02f, -1.99496746e-01f, -1.58941746e-01f, 1.02282010e-01f, -2.15244107e-02f, -1.12948127e-01f, 1.06214933e-01f,
  4.93203104e-02f, -5.80731314e-03f, 9.55971628e-02f, 5.20217307e-02f, 3.67597416e-02f, 1.28409237e-01f, 1.58836581e-02f, -2.16939505e-02f, -1.24576874e-01f, -1.08585946e-01f,
  8.65126401e-02f, 1.41942710e-01f, 7.52128586e-02f, 3.86029668e-02f, -3.00866971e-03f, -9.97358002e-03f, 1.75658643e-01f, 4.07973416e-02f, -4.39064503e-02f, 5.60498722e-02f,
  9.67272073e-02f, -3.53018850e-01f, -1.78967193e-02f, -9.89636034e-02f, 1.17959611e-01f, -6.39609396e-02f, 7.28640854e-02f, 8.53973553e-02f, -4.13461216e-02f, 3.82477604e-02f,
  -6.46785051e-02f, 3.37388776e-02f, -2.59522372e-03f, 6.51610792e-02f, -5.15955128e-02f, -8.44606981e-02f, 3.84954847e-02f, 1.26313968e-02f, 3.20194252e-02f, -6.14574365e-02f,
  -5.88766336e-02f, -7.42943361e-02f, -8.33237693e-02f, -1.24242692e-03f, -6.94848225e-02f, -9.05850828e-02f, 2.01242119e-02f, -1.47472918e-01f, -6.68304563e-02f, 2.06315760e-02f,
  -7.43796229e-02f, -6.77381922e-03f, 2.51242984e-02f, 1.50680467e-02f, 1.17661007e-01f, 7.70182982e-02f, 5.84727190e-02f, -1.72504839e-02f, 3.80187295e-02f, 1.03902169e-01f,
  5.46733551e-02f, 8.09890479e-02f, 1.77875653e-01f, 4.31467965e-02f, 3.43876183e-02f, -9.68187824e-02f, -4.46131527e-02f, -2.85920426e-02f, 6.76014693e-03f, 3.23309675e-02f,
  -1.28438309e-01f, -7.50077283e-03f, 2.80494876e-02f, -1.81906000e-02f, -3.54139879e-02f, -1.11841738e-01f, -9.77151841e-02f, 6.87717879e-03f, -1.51809314e-02f, -2.09182099e-01f,
  3.13852996e-01f, -2.77035773e-01f, 3.57086882e-02f, -7.32648522e-02f, -3.71255577e-02f, -3.78459250e-03f, -7.56356791e-02f, -2.11422797e-02f, 2.81111039e-02f, 9.00841579e-02f,
  -2.71253828e-02f, -2.58676335e-02f, 7.58625790e-02f, -8.91492702e-03f, 1.00796200e-01f, 4.87591848e-02f, 8.77481028e-02f, -5.15275169e-03f, -4.28828560e-02f, 3.30191255e-02f,
  4.05701064e-02f, -1.67720392e-02f, 7.11194724e-02f, 9.01253596e-02f, -1.40857659e-02f, 1.46964202e-02f, 1.46871716e-01f, -4.22166400e-02f, 3.37927490e-02f, 2.77749240e-01f,
  1.72738194e-01f, 2.10309252e-01f, 1.21610940e-01f, 1.80468529e-01f, 1.58944190e-01f, 8.91947150e-02f, 3.29570882e-02f, 7.81352147e-02f, 9.06039998e-02f, 1.81138273e-02f,
  8.67059976e-02f, 3.35018858e-02f, -1.90830082e-02f, -1.17578208e-01f, -2.35569224e-01f, -1.50867775e-01f, -1.35326236e-01f, -1.26024917e-01f, -1.15248434e-01f, -7.18096718e-02f,
  -1.78073436e-01f, -1.26684355e-02f, 3.00207697e-02f, -8.48620459e-02f, -4.99604642e-02f, -1.16451018e-01f, -9.77364182e-02f, 7.59565681e-02f, -9.47835743e-02f, -3.00725073e-01f,
  -8.74535292e-02f, 3.01279664e-01f, -8.23983997e-02f, 2.14321492e-03f, 1.01762243e-01f, 6.81544170e-02f, 4.73582484e-02f, 2.43994836e-02f, -4.37757839e-03f, 6.43674284e-02f,
  1.89475939e-02f, 1.02420568e-01f, 7.18514528e-03f, 1.41592726e-01f, 1.47722960e-01f, 2.23312616e-01f, 1.77422702e-01f, 1.62167236e-01f, 1.55705422e-01f, 1.91978216e-01f,
  1.39077932e-01f, 2.04456583e-01f, 1.64247826e-01f, 6.04253300e-02f, 7.87252784e-02f, 1.18660048e-01f, 1.94939032e-01f, 6.45698011e-02f, 8.03427696e-02f, -3.42524028e-03f,
  -7.94749036e-02f, -1.80080369e-01f, -2.51082052e-02f, 9.98909771e-02f, 4.79368716e-02f, -1.08714197e-02f, -4.49897125e-02f, -1.09066568e-01f, -1.14307947e-01f, -5.46809286e-02f,
  9.69052017e-02f, -2.32244264e-02f, 2.35434063e-02f, -1.14857465e-01f, -1.52572498e-01f, 1.07358076e-01f, -3.06476019e-02f, -7.22051039e-02f, 8.27178955e-02f, 4.43786606e-02f,
  -4.27357387e-03f, 6.11775033e-02f, 4.74323817e-02f, -4.60663158e-03f, -1.72849726e-02f, 7.86282122e-02f, 2.32676473e-02f, -2.87155882e-02f, -2.34561749e-02f, -1.87763959e-01f,
  1.21757850e-01f, -7.97942579e-02f, -1.98983520e-01f, -1.50176644e-01f, -2.79674996e-02f, 8.66653994e-02f, 3.84668522e-02f, 2.66795512e-03f, 1.11681193e-01f, -7.52806058e-03f,
  9.80293527e-02f, -5.07566817e-02f, 1.37891799e-01f, 7.08201826e-02f, 2.86217071e-02f, 2.19087768e-02f, 7.01507330e-02f, -5.29924221e-02f, -5.47154918e-02f, 1.79240823e-01f,
  6.50852621e-02f, 7.91820064e-02f, -6.95221964e-03f, -5.47333695e-02f, -6.33979589e-02f, -8.76863524e-02f, 2.65624113e-02f, -4.18764949e-02f, -4.98985350e-02f, 3.42165567e-02f,
  -6.06870413e-01f, -9.99068990e-02f, 2.91152656e-01f, -4.53387409e-01f, 1.02205187e-01f, 3.11712146e-01f, 3.71547729e-01f, -1.46372372e-03f, -2.29561836e-01f, -3.94260511e-02f,
  -8.13705474e-02f, -1.93865478e-01f, -1.77856445e-01f, -3.28671676e-03f, 1.09541982e-01f, 2.34972522e-01f, 2.13885054e-01f, 1.83272526e-01f, 2.19323441e-01f, 2.14867681e-01f,
  5.92422932e-02f, -1.99017674e-01f, -2.42940664e-01f, -1.63514435e-01f, -2.71341830e-01f, -1.17155900e-02f, -3.52200642e-02f, -1.67462632e-01f, 2.20208466e-02f, -1.62558869e-01f,
  3.05935323e-01f, -2.44869903e-01f, -3.64303887e-02f, -1.13224961e-01f, -1.48597836e-01f, -1.88286416e-02f, -5.79643995e-02f, -1.97456032e-01f, -1.35862634e-01f, -1.70506462e-02f,
  -1.64761379e-01f, -2.05596387e-02f, -4.01147939e-02f, 4.38127741e-02f, -4.33064438e-02f, 2.56664604e-02f, -8.39532092e-02f, -3.01101189e-02f, -1.44289061e-01f, 6.57359213e-02f,
  -3.12440097e-03f, 6.16753772e-02f, 8.32783896e-03f, 6.46907315e-02f, -7.92635456e-02f, 9.72727537e-02f, 3.25354263e-02f, 1.32465260e-02f, 1.84739307e-02f, 2.53956523e-02f,
  4.64581186e-03f, 2.07226072e-02f, -1.42330658e-02f, -2.41471678e-02f, 2.20888238e-02f, 3.69429961e-02f, 5.80055965e-03f, -8.86733010e-02f, 1.38212144e-01f, 9.67912599e-02f,
  -2.61736047e-02f, 3.52765732e-02f, 1.21350810e-02f, 7.78802261e-02f, -4.13713343e-02f, -1.63354278e-02f, 1.73994023e-02f, -4.15485241e-02f, -1.14231192e-01f, -7.98219666e-02f,
  -7.89638087e-02f, -7.26188570e-02f, -1.23377346e-01f, 2.55309977e-02f, 7.26644918e-02f, -1.21134840e-01f, -5.25032729e-02f, -1.34110022e-02f, -4.94810529e-02f, -6.75233686e-03f,
  3.88891362e-02f, -7.22733065e-02f, 4.51239385e-02f, -1.07201390e-01f, -1.69206467e-02f, -1.31253749e-01f, -1.31065324e-01f, -1.06635213e-01f, -7.33475164e-02f, 5.83722368e-02f,
  -2.16044337e-02f, 4.09387462e-02f, -2.32703555e-02f, -5.24051953e-03f, 1.74522758e-01f, 5.64595871e-02f, -5.80441542e-02f, 1.29183501e-01f, 1.96504057e-03f, 2.42741778e-02f,
  -1.48454517e-01f, 8.51504579e-02f, 1.68719456e-01f, 1.67317569e-01f, 3.59931774e-02f, 2.14872107e-01f, 2.55270392e-01f, 9.60341766e-02f, 1.41862050e-01f, 2.12962955e-01f,
  -1.62328407e-01f, 1.37168869e-01f, -1.31712377e-01f, -1.36476740e-01f, -1.88475147e-01f, -2.62352437e-01f, -2.70427316e-01f, -7.91459233e-02f, -1.40099347e-01f, 4.98579815e-02f,
  -3.04924101e-02f, 6.81985496e-03f, 1.18000627e-01f, -5.63826934e-02f, -1.42819017e-01f, -1.90994367e-02f, -5.71471900e-02f, -2.02731028e-01f, -4.62641597e-01f, -4.05803263e-01f,
  -2.69266307e-01f, -1.36273474e-01f, -1.96940422e-01f, -1.41129076e-01f, 6.77123591e-02f, 5.62959984e-02f, 1.19117111e-01f, -1.11234680e-01f, -2.16246665e-01f, 2.32595988e-02f,
  2.19741508e-01f, -1.74646184e-01f, 3.54900807e-02f, -6.97305147e-03f, -4.94217733e-03f, -8.24917108e-02f, -8.88680294e-03f, 8.21930319e-02f, -4.33999337e-02f, 4.20597270e-02f,
  -8.46161768e-02f, -1.58349574e-01f, 5.67359366e-02f, 3.92904840e-02f, 8.73609970e-04f, -1.80778518e-01f, 5.09483479e-02f, -1.87062800e-01f, -5.80749698e-02f, 6.80787340e-02f,
  -1.03986733e-01f, -2.47356579e-01f, 3.09424344e-02f, 6.60351887e-02f, 6.94143353e-04f, -1.12800024e-01f, -2.85135652e-03f, -4.91785668e-02f, -3.73725779e-02f, 1.91200405e-01f,
  1.68648839e-03f, 1.95580393e-01f, -8.17649812e-02f, 1.73369970e-03f, 1.00338176e-01f, 3.30945477e-02f, 1.08690985e-01f, -3.52063142e-02f, 2.35906406e-03f, 1.93155725e-02f,
  1.12050280e-01f, 7.63643757e-02f, 6.80040792e-02f, -7.60380849e-02f, 4.63974848e-02f, 5.75256709e-04f, -1.73414387e-02f, 7.95003101e-02f, 6.10088445e-02f, 9.66105089e-02f,
  -2.47937329e-02f, -1.83295216e-02f, -5.78444377e-02f, 1.05636217e-01f, -1.81363612e-01f, 6.22163201e-03f, -1.20304272e-01f, -7.36810341e-02f, 1.68266967e-02f, -6.15330897e-02f,
  3.17617953e-01f, -3.02113831e-01f, 1.93408832e-01f, 6.84621185e-02f, 2.38461159e-02f, -8.78682211e-02f, -6.40156865e-02f, -1.56854074e-02f, -8.13990645e-03f, -1.23190537e-01f,
  -2.14934498e-01f, -2.38335282e-02f, 7.26890489e-02f, 7.01962262e-02f, -6.66651595e-03f, -1.83740750e-01f, 3.77269350e-02f, -3.50488792e-03f, -1.45996466e-01f, -1.01499856e-02f,
  5.08065224e-02f, -2.31554490e-02f, 2.01791853e-01f, 1.92073211e-01f, -3.71904187e-02f, 2.82284785e-02f, 1.25411823e-01f, 1.45923644e-01f, 5.01732640e-02f, 4.00648206e-01f,
  1.61544070e-01f, -3.35490346e-01f, -4.64572199e-02f, 2.50318140e-01f, 1.04964897e-01f, 1.34429842e-01f, 1.57639891e-01f, 2.89272405e-02f, 8.69584605e-02f, -8.29824209e-02f,
  -4.02101427e-01f, -2.71060705e-01f, -2.18850151e-01f, -7.33819902e-02f, -2.84234695e-02f, 1.95609540e-01f, 2.55822301e-01f, 2.13794857e-01f, 1.40684664e-01f, 1.14295725e-02f,
  -8.23762342e-02f, 1.03918403e-01f, 3.89240868e-02f, -7.60562420e-02f, -1.45269752e-01f, -3.92957702e-02f, -7.98660293e-02f, -1.13698900e-01f, -6.98054060e-02f, -3.18557099e-02f,
  -2.47859225e-01f, -3.53207111e-01f, 1.11279577e-01f, -1.63445517e-01f, -1.55183831e-02f, -7.34738261e-02f, -9.76371691e-02f, -1.23385035e-01f, -1.16069019e-01f, 7.77375847e-02f,
  -9.24702436e-02f, -8.99584815e-02f, -7.02116862e-02f, -1.79406270e-01f, -2.40516160e-02f, -1.80430524e-02f, -5.90449832e-02f, -5.69910146e-02f, -1.69254109e-01f, -2.23195881e-01f,
  -1.83250874e-01f, -3.07620130e-02f, -1.00162011e-02f, -1.04677126e-01f, -1.81290016e-01f, -3.20150554e-02f, -1.24603130e-01f, -6.80949911e-02f, -9.39037427e-02f, 8.59771110e-03f,
  -6.82068057e-03f, 8.06991681e-02f, -7.02712778e-03f, 8.80985707e-02f, -5.60244992e-02f, 8.57574120e-02f, 1.31113365e-01f, 3.59987803e-02f, -3.70659940e-02f, 3.43187824e-02f,
  2.80742627e-02f, -9.61905345e-02f, -4.31281850e-02f, 1.41152879e-02f, -1.46450132e-01f, -1.47976846e-01f, -7.27776438e-02f, -8.24280903e-02f, -1.11375041e-01f, -6.92924187e-02f,
  -8.09546486e-02f, 8.46924558e-02f, -3.84813435e-02f, -1.04437381e-01f, -1.05977030e-02f, -1.76160410e-02f, 1.42711578e-02f, -1.99611232e-01f, -2.32325289e-02f, -2.43359543e-02f,
  -9.35931951e-02f, -1.16544470e-01f, 1.67668715e-01f, 1.01111103e-02f, 1.35609508e-01f, -2.59751994e-02f, -2.01579571e-01f, -1.35714775e-02f, 6.98091164e-02f, 7.79930577e-02f,
  4.46649902e-02f, -6.45318404e-02f, -1.32010087e-01f, -4.46787588e-02f, 1.05072796e-01f, 1.67788312e-01f, -6.09587282e-02f, 1.28623024e-01f, 9.65261385e-02f, -1.11486264e-01f,
  4.50995453e-02f, 1.53850332e-01f, 2.41714984e-01f, 5.42402603e-02f, 6.72176555e-02f, 2.01587453e-01f, 2.82403287e-02f, 1.48194477e-01f, 2.25361213e-01f, 3.89519811e-01f,
  -1.26865551e-01f, 2.77731419e-01f, 8.91773552e-02f, -9.36985835e-02f, 5.17448643e-03f, 1.39438048e-01f, 2.61457473e-01f, -9.53653082e-02f, -1.83624387e-01f, 1.13676555e-01f,
  2.04762101e-01f, -3.34269643e-01f, -1.72165424e-01f, -1.21445924e-01f, -1.25972167e-01f, 5.12133241e-02f, 6.22429028e-02f, -1.80457577e-01f, -3.32040608e-01f, -3.42261732e-01f,
  -2.17180327e-01f, -1.97873205e-01f, -1.12209298e-01f, -1.07269689e-01f, -4.11139764e-02f, -3.23420674e-01f, 1.36503428e-01f, -5.68078943e-02f, 4.94952360e-03f, -1.97253928e-01f,
  -9.38210860e-02f, 1.97944552e-01f, -1.23961061e-01f, -1.36251599e-01f, 3.23064737e-02f, 1.90220922e-02f, 1.04498558e-01f, -3.89942601e-02f, 1.35069534e-01f, 6.03521615e-02f,
  2.02542040e-02f, 9.94923636e-02f, 1.63882747e-01f, 6.04746193e-02f, 7.67702982e-02f, 6.61608055e-02f, 5.05533926e-02f, -8.20506588e-02f, -8.26465189e-02f, 7.47337714e-02f,
  8.44782218e-02f, 1.08593993e-01f, 9.98421833e-02f, 2.48237699e-02f, 4.00548987e-02f, -1.27479896e-01f, 2.83003710e-02f, 1.25972293e-02f, -7.75650963e-02f, -7.73474425e-02f,
  1.80929646e-01f, 1.30159661e-01f, 1.08728401e-01f, 5.73364086e-02f, 2.58883014e-02f, 1.43516302e-01f, 1.59887925e-01f, 5.25426641e-02f, 1.51010975e-01f, 7.65071064e-02f,
  1.21831104e-01f, 1.86186597e-01f, 1.62124634e-01f, 5.83990514e-02f, 1.79460242e-01f, 1.33375779e-01f, 2.06512570e-01f, 1.03759564e-01f, 1.53446823e-01f, 1.15285903e-01f,
  5.92822321e-02f, 1.04582749e-01f, 6.57640100e-02f, 7.82468542e-02f, 9.81362984e-02f, 1.10316172e-01f, 1.41790160e-03f, 1.45327345e-01f, 1.30817533e-01f, 1.17125101e-01f,
  -3.48305285e-01f, 2.37322047e-01f, -1.17260836e-01f, -6.78812712e-02f, 1.60085231e-01f, 5.96021712e-02f, -7.58963916e-03f, 5.95165603e-02f, 1.20625064e-01f, 9.74152014e-02f,
  7.39958361e-02f, 8.08769539e-02f, 1.22141585e-01f, 6.44566789e-02f, -6.21964745e-02f, 6.66965023e-02f, 4.64826897e-02f, -8.19417462e-02f, -3.57487947e-02f, -1.40131554e-02f,
  8.72248113e-02f, -7.96293616e-02f, -5.25252558e-02f, -7.81408027e-02f, -6.13104478e-02f, -5.23986071e-02f, 3.26762274e-02f, -7.14251176e-02f, -1.01575412e-01f, -1.67340587e-03f,
  -3.78123730e-01f, -2.48958081e-01f, 1.45658880e-01f, -1.99078843e-01f, 2.47550502e-01f, 4.11728382e-01f, 5.80121040e-01f, 1.87156484e-01f, -1.44841462e-01f, -2.06965692e-02f,
  -5.87457679e-02f, -4.32413012e-01f, -3.28536361e-01f, -1.38024762e-01f, 3.81622612e-02f, 3.22403580e-01f, 2.67740011e-01f, 8.76239315e-03f, 5.88917062e-02f, 2.90252149e-01f,
  4.39663604e-02f, -2.73211077e-02f, -2.20890835e-01f, -5.17577305e-02f, -2.19327495e-01f, -1.83564559e-01f, -5.89373112e-02f, -3.41004245e-02f, 1.89665601e-01f, -7.22632036e-02f,
  2.27148738e-02f, -6.55253828e-02f, 3.38072740e-02f, -9.92946029e-02f, -5.30605903e-03f, -8.78526643e-02f, 5.96380271e-02f, -1.55359834e-01f, 6.36796057e-02f, 1.48895845e-01f,
  8.12501535e-02f, 6.11141622e-02f, -8.36666971e-02f, 4.53404449e-02f, 4.72491756e-02f, 7.26686046e-02f, 7.30543658e-02f, 1.18196391e-01f, -6.74900636e-02f, 1.32273212e-01f,
  -1.57803297e-02f, 1.42894670e-01f, 2.03342244e-01f, 7.75388926e-02f, 1.60886288e-01f, 5.14572300e-02f, 1.32532552e-01f, 8.98896232e-02f, 1.49046138e-01f, -1.00299224e-01f,
  2.42239133e-01f, -5.32786399e-02f, 5.80574423e-02f, -1.02387946e-02f, 1.00429365e-02f, -2.66707167e-02f, -6.82051927e-02f, -1.83349345e-02f, -3.22348513e-02f, -4.95402738e-02f,
  -9.79051366e-02f, 2.84558833e-02f, -1.62437875e-02f, -1.19939990e-01f, -2.02546671e-01f, -6.17919527e-02f, -7.66872475e-03f, -8.87274742e-02f, -2.76579056e-02f, -1.87457968e-02f,
  2.55467594e-02f, 1.31805437e-02f, -9.52962935e-02f, -3.56428735e-02f, 1.21432297e-01f, -1.14629753e-01f, 6.14646031e-03f, -5.92966676e-02f, -2.04882085e-01f, 1.21868271e-02f,
  -1.76939532e-01f, 6.55473247e-02f, -1.80094436e-01f, -1.47194743e-01f, -7.06713572e-02f, -1.60351872e-01f, -2.92616606e-01f, -1.77543864e-01f, 5.20865656e-02f, -6.45544231e-02f,
  7.48647377e-02f, -9.94447619e-02f, -1.66447982e-01f, 6.69337958e-02f, 1.89418327e-02f, 1.53374337e-02f, -7.15015829e-02f, -4.65407707e-02f, 8.69729668e-02f, 2.37630773e-02f,
  1.18617648e-02f, 3.06032524e-02f, 4.49185818e-02f, -1.17842913e-01f, 3.46632600e-02f, 4.94814590e-02f, 9.82430130e-02f, 5.33733889e-02f, 3.90836522e-02f, 6.84506148e-02f,
  -4.68200803e-01f, -4.26600277e-01f, -7.78799951e-02f, -7.11523354e-01f, -3.33311915e-01f, 7.60890692e-02f, -2.28406504e-01f, -1.09374173e-01f, -2.73257673e-01f, -4.83541876e-01f,
  -1.00572720e-01f, 1.21827275e-01f, -1.91027522e-02f, 1.22622870e-01f, 1.59615472e-01f, -4.74550307e-01f, -4.16518450e-01f, 5.53790517e-02f, 4.01804149e-01f, 2.31628075e-01f,
  -1.91019520e-01f, -3.00129950e-01f, -5.58362976e-02f, -5.45109138e-02f, -5.67805767e-01f, -1.40875280e-01f, -2.64841646e-01f, -2.93333709e-01f, 6.64179996e-02f, -4.52194124e-01f,
  -3.57657641e-01f, -1.13122866e-01f, 1.96720853e-01f, 1.11166142e-01f, -1.84884682e-01f, 2.14128848e-02f, -4.50146683e-02f, 3.05771958e-02f, 1.69767559e-01f, -7.86533952e-02f,
  3.00409943e-02f, 1.32879943e-01f, 1.75248217e-02f, 7.72763975e-04f, -1.21054173e-01f, 1.78882834e-02f, -7.97181502e-02f, 1.92953080e-01f, -8.47785734e-03f, -2.92149559e-02f,
  -3.09979878e-02f, 7.46840835e-02f, 1.58117726e-01f, 4.64692116e-02f, 1.12036960e-02f, 1.17043860e-01f, 5.63386455e-02f, 1.12847254e-01f, 1.75288633e-01f, -4.80429649e-01f,
  -9.56009030e-02f, -1.27227396e-01f, 2.00925097e-02f, 4.02009953e-03f, 1.52720824e-01f, 1.31012365e-01f, -5.96456043e-02f, -5.92609085e-02f, 1.72082499e-01f, 1.28756063e-02f,
  7.32671171e-02f, -2.48884279e-02f, 1.36925271e-02f, -1.99414063e-02f, 2.82044318e-02f, -6.41335919e-03f, -3.18816900e-02f, -3.02811004e-02f, -7.60265719e-03f, 9.97634418e-03f,
  6.66574985e-02f, -4.90653329e-02f, -2.41845427e-03f, -1.75851397e-02f, 5.27160913e-02f, -1.01121821e-01f, -5.01752086e-02f, -1.36718117e-02f, -1.58119068e-01f, 6.00200556e-02f,
  -2.61077911e-01f, 3.49589109e-01f, -3.69731992e-01f, 1.44453526e-01f, -8.63758326e-02f, 7.84966052e-02f, -4.77038440e-04f, 6.24629073e-02f, 2.30939547e-03f, -2.45780736e-01f,
  2.63772875e-01f, -9.81314778e-02f, 1.78864598e-02f, 6.66861907e-02f, 6.19180594e-03f, 1.74573973e-01f, -7.72335082e-02f, -9.26136672e-02f, 9.55926403e-02f, 4.70525846e-02f,
  -5.57820536e-02f, -2.67836805e-02f, -1.69729143e-01f, -1.51000723e-01f, -1.19715028e-01f, 5.48135452e-02f, 5.08622965e-03f, 4.50766785e-03f, 1.39181554e-01f, -5.63315511e-01f,
  1.90559238e-01f, 1.41712174e-01f, -1.24109210e-02f, 7.50498623e-02f, -1.11665688e-01f, -1.59228712e-01f, -1.61364585e-01f, -1.37377009e-01f, -7.23157311e-03f, 1.96763482e-02f,
  -1.34241330e-02f, -1.34248137e-01f, -2.34806091e-02f, -2.20447838e-01f, -2.37973824e-01f, 6.04407154e-02f, 6.67463988e-02f, -1.31930754e-01f, -4.88266319e-01f, -4.63486582e-01f,
  -3.15765589e-01f, -2.14257434e-01f, -1.76390141e-01f, -1.81314409e-01f, -2.44643185e-02f, -6.81405440e-02f, 8.24243724e-02f, -1.22944787e-02f, -7.39717260e-02f, 1.70416012e-02f,
  -8.80523622e-02f, 1.56552523e-01f, -8.62768292e-02f, -1.11224785e-01f, 4.71216291e-02f, 1.50843114e-02f, -4.63229790e-02f, 2.19043288e-02f, 7.90237077e-03f, -3.11672445e-02f,
  -3.63194235e-02f, -1.64099202e-01f, -2.64812317e-02f, -1.78146228e-01f, -2.46454664e-02f, -1.45478591e-01f, -5.65404370e-02f, -1.06221683e-01f, 6.10078685e-02f, -2.62007359e-02f,
  -2.42026988e-02f, 3.94904017e-02f, 3.47704776e-02f, 3.49715315e-02f, 5.40578887e-02f, 1.22469603e-04f, -4.99060377e-02f, -7.17052445e-02f, 1.21316470e-01f, 1.05118886e-01f,
  2.64716204e-02f, 9.14750174e-02f, 6.77775145e-02f, 2.26859879e-02f, -1.06092401e-01f, 1.69433936e-01f, 7.47837545e-03f, -1.64888427e-01f, 1.01025617e-02f, -7.28571974e-03f,
  1.28713213e-02f, 9.58318710e-02f, -4.19103950e-02f, 7.94946179e-02f, 1.57596916e-02f, -5.85602643e-03f, 5.16567118e-02f, 1.98074314e-03f, 1.39553780e-02f, 2.31482666e-02f,
  1.77311786e-02f, 8.42457544e-03f, -3.91030824e-03f, 5.43332426e-03f, 9.71654430e-03f, 6.33953065e-02f, 2.41832230e-02f, -4.64360192e-02f, -6.66665584e-02f, -6.52507395e-02f,
  -4.19989675e-02f, 3.56248170e-02f, 7.19718561e-02f, -5.66440150e-02f, 1.00291103e-01f, -5.29803708e-02f, 3.47255617e-02f, -4.36992943e-02f, 7.63252527e-02f, -9.03976262e-02f,
  -1.01102754e-01f, -4.65715788e-02f, 8.28348508e-04f, -3.87114324e-02f, -6.13570884e-02f, -6.11538775e-02f, -3.38439904e-02f, -8.90621841e-02f, 6.97932318e-02f, -6.50825351e-02f,
  3.26650143e-02f, -2.51763109e-02f, 3.14986408e-02f, 7.92927593e-02f, 3.09280548e-02f, -4.41753678e-02f, -3.34119028e-03f, -7.30944425e-02f, 7.99974203e-02f, 9.14000794e-02f,
  2.93790102e-01f, 1.59550905e-01f, 9.27004963e-02f, 1.84312418e-01f, 2.02223375e-01f, -8.17299262e-02f, -1.96082518e-01f, -2.00379983e-01f, 1.06185444e-01f, 1.10383525e-01f,
  -1.47756597e-03f, -1.93378955e-01f, -3.88233699e-02f, -2.98215210e-01f, -4.67746258e-01f, -1.18468404e-01f, -4.78667915e-02f, -2.10480586e-01f, -5.85151732e-01f, -4.39971596e-01f,
  -1.40616506e-01f, -3.94227505e-02f, -1.28851786e-01f, -6.52739555e-02f, 2.67577916e-01f, -4.25245129e-02f, 3.35491627e-01f, 1.76942334e-01f, 2.55955812e-02f, 2.94324428e-01f,
  8.32895413e-02f, 3.22919935e-01f, -5.25288619e-02f, -8.35234746e-02f, 8.87320787e-02f, -1.80314392e-01f, -4.39652242e-02f, 1.80194601e-02f, -1.02072954e-01f, -7.44997663e-03f,
  -2.21996699e-02f, -1.65407792e-01f, 5.62101491e-02f, -1.05348676e-01f, 4.91163395e-02f, -2.28134170e-01f, -4.42886874e-02f, -2.53047317e-01f, -4.90925014e-02f, -4.70162407e-02f,
  -2.07490716e-02f, 5.86999990e-02f, 4.51366566e-02f, -1.59976393e-01f, -9.22142640e-02f, -3.76990922e-02f, 5.08361049e-02f, -5.18178679e-02f, -2.56995484e-02f, 1.80857867e-01f,
  -1.06360346e-01f, -5.36972630e-06f, -3.52132618e-02f, 1.39499381e-01f, -7.97595680e-02f, 2.39632707e-02f, 8.94778967e-02f, -7.97256306e-02f, 2.13044249e-02f, 3.99835035e-02f,
  -2.10923050e-02f, 2.92143878e-02f, 2.73142476e-02f, 1.85916070e-02f, -2.24314500e-02f, 1.08955786e-01f, -3.51817422e-02f, -5.06916689e-03f, -6.79677818e-03f, -3.43839526e-02f,
  -1.20393135e-01f, -4.38676775e-02f, 5.16958870e-02f, -7.18718320e-02f, 1.83413159e-02f, 1.19742565e-01f, -2.62024570e-02f, -5.40860556e-02f, 2.36548074e-02f, 2.51849331e-02f,
  1.23805247e-01f, -1.60591319e-01f, 2.24354804e-01f, -1.42717779e-01f, 1.50100753e-01f, -5.26249669e-02f, 1.75595582e-01f, -7.93679431e-02f, 1.23773247e-01f, -8.88005197e-02f,
  -9.19403359e-02f, -1.53205082e-01f, 1.09309636e-01f, -9.42481533e-02f, -9.47940871e-02f, -1.12026334e-01f, -1.27890289e-01f, -3.19870636e-02f, -1.06885515e-01f, 7.79907107e-02f,
  7.26238266e-02f, -1.33510932e-01f, -4.01652083e-02f, -3.60801965e-02f, 7.26905540e-02f, -1.20054103e-01f, 2.11391449e-02f, -2.71075461e-02f, -1.57923147e-01f, 9.90522802e-02f,
  -2.49751285e-01f, 3.20848554e-01f, 2.66453233e-02f, 4.57433239e-02f, -8.56155809e-03f, -7.05032870e-02f, 1.07411280e-01f, 8.47958028e-02f, 1.35458753e-01f, 2.10657313e-01f,
  -3.94412652e-02f, -2.02348366e-01f, 1.66723356e-01f, 2.41395626e-02f, -2.13059932e-02f, 3.48048121e-01f, 3.94138604e-01f, -1.30237043e-01f, -5.74482322e-01f, -4.79341924e-01f,
  -5.56663685e-02f, -6.29188493e-02f, -2.33439386e-01f, -1.26029611e-01f, 2.72988051e-01f, 6.98557198e-02f, 3.39426905e-01f, 3.94500270e-02f, 7.11496919e-02f, 2.61512280e-01f,
  -1.49321064e-01f, 1.42155052e-03f, -3.20204973e-01f, -3.77338260e-01f, -1.51411027e-01f, -7.04600811e-02f, -7.11593637e-03f, -6.76423684e-02f, 1.32425539e-02f, -1.24475785e-01f,
  -2.00485706e-01f, -1.49570137e-01f, 3.03504001e-02f, -1.90629438e-01f, -1.30824193e-01f, -3.06252956e-01f, -4.88631018e-02f, -1.83628112e-01f, -3.96504477e-02f, -3.16700101e-01f,
  -3.75914611e-02f, -1.40671059e-01f, -5.04163727e-02f, 5.52283134e-03f, 1.12073319e-02f, -6.96089342e-02f, -1.51303625e-02f, -2.26096287e-01f, -1.81983888e-01f, 6.18546680e-02f,
  -9.91015509e-02f, -2.40447387e-01f, 1.29022434e-01f, 1.64712518e-01f, -1.16957486e-01f, -1.70647323e-01f, -1.02433097e-02f, -4.43561003e-02f, 3.25740390e-02f, 1.93200111e-02f,
  -1.39528632e-01f, -1.21651672e-01f, -1.33156061e-01f, 1.24927692e-03f, -1.59425791e-02f, -7.96370208e-02f, -1.19690411e-01f, 1.02226451e-01f, 1.30987838e-01f, 3.21555249e-02f,
  1.70651510e-01f, 7.96436220e-02f, -3.35941440e-05f, 1.80588905e-02f, 5.42208813e-02f, 4.02606949e-02f, -3.77503186e-02f, -1.12111576e-01f, -5.40154614e-03f, 5.18357032e-04f,
  -2.35178880e-02f, -6.79983273e-02f, -7.74519844e-03f, -9.41838771e-02f, 1.11541167e-01f, -5.13741113e-02f, 1.25597775e-01f, -9.50755924e-02f, 5.48005141e-02f, -1.34154767e-01f,
  -8.02134648e-02f, -1.78459078e-01f, 1.71065941e-01f, -1.43350333e-01f, -1.67793170e-01f, -1.14617772e-01f, -2.02639420e-02f, -8.49742964e-02f, 3.31839686e-03f, -1.90931469e-01f,
  7.28727877e-02f, -6.23694137e-02f, 9.73767426e-04f, 1.56020030e-01f, 7.37255141e-02f, -4.40291464e-02f, 4.88858968e-02f, -1.08116135e-01f, -1.38346329e-01f, 1.99781254e-01f,
  -6.12557769e-01f, 2.92173594e-01f, 2.24271625e-01f, -9.57132056e-02f, 4.31416273e-01f, 2.11724028e-01f, 7.54461363e-02f, -2.13660121e-01f, -1.42271174e-02f, 1.34454593e-01f,
  2.63739318e-01f, 3.37501578e-02f, 1.37375206e-01f, 2.93809343e-02f, -2.70894021e-01f, 2.30914697e-01f, 2.88518190e-01f, -2.13503718e-01f, -4.33538407e-01f, -2.76928186e-01f,
  3.96881998e-02f, -2.20482469e-01f, -4.51123953e-01f, -1.93172604e-01f, 2.13216037e-01f, -4.73341875e-04f, 2.38635033e-01f, 5.70432022e-02f, 2.13493153e-01f, 3.60376298e-01f,
  -6.30051969e-03f, -1.61879919e-02f, 8.06342432e-05f, 3.67425457e-02f, 1.98940203e-01f, -2.09733918e-01f, -7.42402375e-02f, -6.26145452e-02f, 3.30614857e-02f, -1.24406233e-01f,
  7.93632194e-02f, -6.42280430e-02f, 1.52931646e-01f, -1.17944814e-01f, -1.36190042e-01f, -1.62148610e-01f, -8.74915272e-02f, -2.48359427e-01f, -1.54362842e-01f, -7.80501589e-02f,
  1.87823251e-01f, 2.64227092e-02f, -1.34169329e-02f, -3.94205414e-02f, -1.06115937e-01f, -1.37877569e-01f, -1.43438637e-01f, -2.05345035e-01f, -3.09373558e-01f, -2.36113966e-01f,
  -6.80413693e-02f, 6.96054101e-02f, 9.49413329e-03f, 6.24595769e-03f, -1.90201193e-01f, 1.01031601e-01f, 8.38153511e-02f, -4.91560027e-02f, -4.55381423e-02f, 4.98187775e-03f,
  1.19540714e-01f, 9.63184312e-02f, -4.67959344e-02f, 2.22764928e-02f, 1.21475002e-02f, -3.08687333e-02f, 4.97861616e-02f, -1.03543878e-01f, -2.13072635e-02f, -6.57291189e-02f,
  -7.17303976e-02f, -4.17927578e-02f, 4.61962633e-02f, -6.28247915e-04f, 4.40483950e-02f, 1.51054543e-02f, 9.36287513e-04f, 4.74772789e-02f, -4.36333641e-02f, -2.40678042e-02f,
  -1.84891328e-01f, -6.66406900e-02f, -8.80877227e-02f, -1.31578267e-01f, 1.31137401e-01f, 3.12940367e-02f, 3.89207415e-02f, 5.33313900e-02f, 2.14761540e-01f, -6.33614734e-02f,
  -7.45174438e-02f, -5.26241586e-02f, 6.82670996e-02f, -4.85673510e-02f, -1.21410757e-01f, 2.35911971e-03f, 1.02399848e-01f, 5.05777746e-02f, -6.87801391e-02f, 1.11436332e-02f,
  8.48485753e-02f, -2.20413923e-01f, -2.58547336e-01f, -7.09774643e-02f, -5.60670383e-02f, -2.16522321e-01f, -1.42296538e-01f, -1.27973706e-01f, -2.95839667e-01f, -3.57602924e-01f,
  1.39920652e-01f, 4.99130040e-01f, 2.01712683e-01f, -9.62544158e-02f, 1.43412292e-01f, 8.77385587e-02f, 1.40237704e-01f, -6.63460121e-02f, -1.34634659e-01f, 2.26474524e-01f,
  1.61527410e-01f, -2.17576981e-01f, -1.12867402e-02f, -1.03150576e-01f, -1.43356889e-01f, 1.98892847e-01f, 1.45924836e-01f, -7.68906921e-02f, -3.92408788e-01f, -2.46760815e-01f,
  -6.66059703e-02f, -1.19079605e-01f, -2.08233669e-01f, -1.15036055e-01f, 1.85527429e-01f, -1.16082914e-01f, 1.47083670e-01f, 1.90897122e-01f, 2.26106942e-01f, 3.67293179e-01f,
  2.21348196e-01f, 3.53818297e-01f, -4.10508871e-01f, -1.79519504e-01f, 1.67779744e-01f, -2.55566109e-02f, -7.48825148e-02f, 1.39540434e-01f, 2.11556982e-02f, 4.45216186e-02f,
  1.58677682e-01f, 2.42135557e-03f, 1.54136598e-01f, -1.43598430e-02f, -4.08424400e-02f, -2.02599898e-01f, 1.48248700e-02f, -8.68379697e-02f, -1.51935771e-01f, 5.89091294e-02f,
  6.62899986e-02f, 5.38320094e-02f, 1.18481427e-01f, -8.46005529e-02f, -4.02008817e-02f, -2.00118735e-01f, -1.83111075e-02f, -7.42280781e-02f, -1.78074315e-01f, 5.36161102e-02f,
  -1.25591278e-01f, 1.96072310e-01f, 1.70557290e-01f, 1.83375895e-01f, -1.83746263e-01f, 4.95349020e-02f, 5.29311784e-02f, 2.16845442e-02f, -9.47656557e-02f, 5.48746809e-02f,
  1.77419931e-02f, 1.31270206e-02f, -5.55706117e-03f, 1.25321299e-01f, -4.97898040e-03f, 4.70756851e-02f, 3.21311672e-05f, 2.34491341e-02f, 4.60254028e-02f, -3.41081582e-02f,
  -2.75165425e-03f, 1.06028104e-02f, 3.59456837e-02f, 5.69402874e-02f, 2.71113683e-02f, 1.04838558e-01f, -6.72962144e-02f, -6.70580715e-02f, -4.78638224e-02f, -4.89045307e-03f,
  -2.52861500e-01f, -2.11287096e-01f, -6.03038669e-02f, -1.44246742e-01f, 1.98375583e-01f, -7.19314069e-02f, 3.49451452e-02f, 5.56477718e-02f, 1.64229661e-01f, 4.91643287e-02f,
  -3.87042575e-02f, -1.46942943e-01f, 3.06709427e-02f, -1.13113821e-01f, -1.78718194e-01f, -4.71047349e-02f, 6.58594891e-02f, -4.61722799e-02f, -2.58652300e-01f, 2.53002741e-03f,
  -6.54926002e-02f, -3.03896517e-01f, -2.59425521e-01f, -8.43875334e-02f, -1.79739565e-01f, -4.72946197e-01f, -2.22542495e-01f, -1.87594607e-01f, -3.71425360e-01f, -2.84189373e-01f,
  -4.57089543e-01f, -4.05701637e-01f, 2.39900663e-01f, -4.03225631e-01f, -3.64088714e-01f, -1.49697796e-01f, -4.52480525e-01f, -2.26098433e-01f, -2.12137640e-01f, -3.06757867e-01f,
  -1.04794495e-01f, 2.19871625e-01f, 3.32985401e-01f, 3.23444843e-01f, 2.76195526e-01f, -2.82388061e-01f, -1.72741532e-01f, 2.45738581e-01f, 2.80291080e-01f, -1.48206323e-01f,
  -2.94106007e-01f, -3.19569558e-01f, -1.12601988e-01f, 4.57755663e-02f, -2.50587881e-01f, -3.52916447e-03f, -5.79342395e-02f, -1.51856378e-01f, 1.68031314e-03f, -3.24044883e-01f,
  1.90191731e-01f, -1.33934304e-01f, 1.96690917e-01f, -1.91552341e-02f, -4.33690962e-04f, 6.62986785e-02f, -6.63408265e-02f, 6.36650547e-02f, -9.71127003e-02f, 4.39722836e-02f,
  -3.65226902e-02f, -8.40423331e-02f, 7.98305348e-02f, 5.48054352e-02f, -1.05725579e-01f, 2.36540288e-02f, 8.69754050e-03f, 1.42109737e-01f, 8.87295604e-02f, 6.54834211e-02f,
  -8.17943513e-02f, -2.28498086e-01f, 1.47964388e-01f, 1.76688254e-01f, 7.70840421e-02f, 1.00334480e-01f, 1.25679448e-01f, -1.07883690e-02f, 1.89331144e-01f, -2.54327267e-01f,
  -5.16473614e-02f, 1.39265344e-01f, 7.76267648e-02f, -9.28525289e-04f, 5.04327230e-02f, -5.42553328e-02f, -6.24867231e-02f, -7.87632763e-02f, 1.12715565e-01f, 2.79012620e-02f,
  -5.56970574e-02f, -6.40606880e-02f, 4.77333702e-02f, -9.24788415e-02f, 3.46516483e-02f, 1.41179119e-03f, -8.63045547e-03f, 1.11721680e-01f, -2.00968375e-03f, -1.22417308e-01f,
  1.32030481e-03f, -4.13427576e-02f, 5.35920970e-02f, -2.37048194e-02f, -4.69281748e-02f, 2.69750003e-02f, 1.85346580e-03f, 8.96700248e-02f, -5.45853488e-02f, -6.21060058e-02f,
  6.46703914e-02f, 2.50787705e-01f, -2.69939274e-01f, 9.20089111e-02f, -1.16145693e-01f, 8.57351944e-02f, 7.66568538e-03f, 1.10827379e-01f, -2.18551303e-03f, -2.00574528e-02f,
  -2.43193284e-02f, -1.19389631e-02f, -7.49931037e-02f, 4.64851595e-03f, -2.88641788e-02f, -3.87518504e-03f, -1.81029752e-01f, -1.55509278e-01f, -1.12527972e-02f, 2.90994477e-02f,
  -1.06637068e-01f, -7.98159912e-02f, -8.09898674e-02f, -4.27039154e-03f, -9.44231674e-02f, 3.59453559e-02f, -1.61091401e-03f, -3.86030413e-02f, 1.31569311e-01f, -2.96779662e-01f,
  6.89463198e-01f, 4.63651704e-05f, 8.11539590e-02f, 1.08299568e-01f, 1.19462628e-02f, -1.36484250e-01f, -1.98248431e-01f, 5.69907613e-02f, 8.01267102e-02f, 8.74844119e-02f,
  2.11836845e-01f, 1.41714975e-01f, 2.57135183e-01f, 2.31482685e-01f, 7.38372058e-02f, 9.48840529e-02f, -5.00130728e-02f, 1.17824316e-01f, 1.89119950e-01f, 9.71465707e-02f,
  1.65183157e-01f, 7.77148753e-02f, 2.11006239e-01f, 1.18460551e-01f, 3.20498645e-02f, 1.92372397e-01f, 5.33593558e-02f, 3.02473530e-02f, 3.46594714e-02f, 2.04743162e-01f,
  2.87708431e-01f, 1.17410228e-01f, 2.38255579e-02f, 4.20414209e-02f, 1.25808665e-03f, 4.65060920e-02f, 4.04926986e-02f, -1.57014672e-02f, 2.93033253e-02f, -7.44074117e-04f,
  -4.51959819e-02f, -4.25986610e-02f, -6.03545830e-02f, -4.14511338e-02f, -1.02585830e-01f, 4.02028523e-02f, -7.01136282e-03f, 8.86132121e-02f, -1.48723861e-02f, 5.16370460e-02f,
  -7.24895997e-03f, 4.71366532e-02f, -1.42703891e-01f, -1.11648530e-01f, 1.13757297e-01f, 7.44247343e-03f, -5.95568903e-02f, 4.71658595e-02f, -8.84724110e-02f, 1.25218676e-02f,
  -4.32113791e-03f, -3.44178155e-02f, 2.01143399e-01f, 9.48179737e-02f, 3.31258804e-01f, 1.35210484e-01f, 8.82794857e-02f, -2.13219989e-02f, 9.15851593e-02f, 4.95552924e-03f,
  2.02446431e-02f, 1.45430401e-01f, 8.16964358e-03f, 1.17495237e-02f, 7.69202486e-02f, -5.84835652e-04f, -1.33254230e-01f, -3.20737846e-02f, 1.80791278e-04f, -9.44050867e-03f,
  8.29526782e-02f, 2.89738644e-02f, -5.92801198e-02f, 3.35231074e-03f, 4.87511642e-02f, -8.80709887e-02f, 4.13516676e-03f, -6.78790137e-02f, -1.00740917e-01f, 3.62528265e-02f,
  -3.33346784e-01f, -3.72485891e-02f, 1.28981397e-01f, -4.73017320e-02f, -7.85385519e-02f, -1.11729363e-02f, -1.18990121e-02f, -5.62175848e-02f, -1.05795018e-01f, 2.26808693e-02f,
  -3.71656343e-02f, -2.16274839e-02f, -1.36633500e-01f, -2.12024022e-02f, -4.37482260e-03f, 8.57231207e-03f, -3.71407345e-02f, -2.67277798e-03f, -1.56253904e-01f, -1.17741704e-01f,
  -1.32525310e-01f, -7.67725259e-02f, -1.18150815e-01f, -1.35533869e-01f, -3.06044761e-02f, -4.63684835e-02f, -3.18880863e-02f, -1.22863479e-01f, -7.59310797e-02f, -6.15136661e-02f,
  -4.80034411e-01f, -2.98959047e-01f, -4.75338221e-01f, 1.46999076e-01f, 4.70003098e-01f, -5.90174906e-02f, -3.07408750e-01f, -2.74452329e-01f, 5.13158105e-02f, -1.63661569e-01f,
  1.55765563e-01f, 3.33666772e-01f, 8.31211507e-02f, 9.08511803e-02f, -2.09058270e-01f, -1.76604792e-01f, 9.34456810e-02f, -4.36503775e-02f, 2.86457706e-02f, 2.71227449e-01f,
  4.39279407e-01f, 3.17645103e-01f, 1.17766529e-01f, 1.69579029e-01f, 2.86818564e-01f, 3.90134484e-01f, 7.05533400e-02f, 1.85010776e-01f, 1.32707134e-01f, 2.02317536e-01f,
  -4.08036768e-01f, -2.92295933e-01f, 2.27359235e-02f, 3.25553477e-01f, 6.86464161e-02f, -1.34394258e-01f, -1.28218219e-01f, -5.40410541e-02f, 8.31784457e-02f, 2.54830252e-02f,
  1.66914836e-01f, -2.31624134e-02f, 1.59517378e-01f, 1.23692453e-01f, 8.33179131e-02f, -1.47257522e-01f, -5.10638207e-02f, -3.02067161e-01f, -3.21114600e-01f, -1.78853095e-01f,
  3.03700477e-01f, 2.44775236e-01f, -2.99513310e-01f, -1.64180890e-01f, -3.20828199e-01f, 1.43884376e-01f, -1.41675487e-01f, -1.90305859e-01f, -3.31586987e-01f, -2.15006441e-01f,
  -9.83596817e-02f, 4.13492247e-02f, 3.60963377e-03f, -2.83944923e-02f, 8.38639662e-02f, 8.17143917e-02f, -3.17232199e-02f, 9.60132256e-02f, 1.06049240e-01f, -1.11292206e-01f,
  -1.00250214e-01f, -7.05463961e-02f, -2.85315830e-02f, -5.18531501e-02f, 2.27340117e-01f, -1.10626332e-02f, 1.58337764e-02f, 2.59358669e-03f, 7.28506222e-02f, -1.30928472e-01f,
  -9.62624401e-02f, -7.04391748e-02f, 1.77379534e-01f, -1.09945528e-01f, -5.46369050e-03f, -2.31982991e-01f, -1.35234995e-02f, 2.87381615e-02f, 6.26616478e-02f, -1.65660940e-02f,
  2.83350907e-02f, 9.72786620e-02f, -1.35369048e-01f, 4.70112339e-02f, 4.17751633e-02f, 2.31716082e-01f, 1.28016854e-02f, -1.44100538e-03f, -6.54606670e-02f, -4.61030304e-02f,
  3.38029000e-03f, -6.45532310e-02f, 8.49578008e-02f, -1.52354743e-02f, 2.51533501e-02f, -1.65180434e-02f, 8.31425861e-02f, -4.64463048e-03f, -7.15311021e-02f, 7.27580022e-03f,
  9.15308576e-03f, 1.40135279e-02f, -8.66261125e-02f, -1.96502998e-01f, -2.66875140e-02f, 9.79479030e-02f, -8.19017887e-02f, -1.06961101e-01f, -1.72301784e-01f, -1.78411871e-01f,
  1.13077927e-02f, -2.09020555e-01f, 3.32561821e-01f, 1.16166919e-01f, 1.58551812e-01f, 1.01038389e-01f, 3.65263410e-02f, 3.00756972e-02f, 3.42870839e-02f, 7.43584558e-02f,
  -4.31770943e-02f, 7.40079805e-02f, 7.67039657e-02f, 9.27132443e-02f, 5.00491112e-02f, 4.26500440e-02f, 3.78279039e-03f, 1.48292631e-01f, 2.45596990e-01f, 1.14241935e-01f,
  -1.02608420e-01f, -1.05452783e-01f, -5.44160940e-02f, -1.57675117e-01f, -1.44747466e-01f, 8.77536759e-02f, -1.66446939e-02f, -1.54682279e-01f, -1.17716722e-01f, -1.34801731e-01f,
  2.84274936e-01f, -2.43096620e-01f, 1.23143695e-01f, -7.99699947e-02f, -8.62180516e-02f, -8.73041898e-02f, 8.83791074e-02f, -2.20926926e-02f, -1.81699261e-01f, -5.19111715e-02f,
  -8.82132947e-02f, -1.65610135e-01f, 7.37078637e-02f, -7.65683800e-02f, -1.12385184e-01f, 3.76760848e-02f, -8.27363953e-02f, -1.60322815e-01f, -9.15271342e-02f, -1.03610456e-01f,
  -4.40953746e-02f, -4.73589189e-02f, -3.39020509e-03f, 4.10350710e-02f, -4.05805036e-02f, 4.50915331e-03f, -5.59773780e-02f, -4.40264717e-02f, 4.57137451e-02f, 8.19245428e-02f,
  -2.41459794e-02f, 1.95578188e-01f, 2.27664188e-02f, 1.67453721e-01f, 3.16885561e-02f, 2.56459210e-02f, 3.56417731e-03f, 2.04501934e-02f, 1.22643905e-02f, -7.95598626e-02f,
  6.94151372e-02f, 6.75215991e-03f, 2.87421495e-02f, -3.47674116e-02f, 1.20936446e-01f, -1.05950050e-02f, 1.02333641e-02f, -7.83235952e-02f, -8.35106522e-02f, -4.43794504e-02f,
  -1.61289722e-02f, 7.84023479e-02f, 7.50396820e-03f, 1.65760610e-02f, -1.38668209e-01f, 9.08986256e-02f, -4.97663245e-02f, -4.64152209e-02f, 9.37747136e-02f, -9.99916196e-02f,
  1.95543945e-01f, -1.00311019e-01f, 2.58917809e-02f, -6.77742362e-02f, -2.71490831e-02f, -1.61296099e-01f, 5.70057817e-02f, -3.74631770e-02f, -1.63352549e-01f, -5.88668101e-02f,
  -1.91382676e-01f, -1.78518833e-03f, 6.03794828e-02f, 1.01650308e-03f, 2.44629588e-02f, -4.37271111e-02f, -5.99739030e-02f, 1.08901754e-01f, -1.43567741e-01f, -5.52634001e-02f,
  -7.51485527e-02f, 1.42342195e-01f, 2.97100991e-01f, 2.01635122e-01f, -7.58589283e-02f, 8.28091130e-02f, 3.59159857e-02f, 1.19494721e-01f, 5.06652407e-02f, 1.28059998e-01f,
  1.15853772e-02f, 2.28888527e-01f, 1.02820046e-01f, 1.57378614e-01f, 2.82354534e-01f, 2.87429333e-01f, 1.89526871e-01f, 1.84279993e-01f, -1.14482185e-02f, 4.70525026e-02f,
  2.16545671e-01f, 1.32480949e-01f, 1.41659155e-01f, 1.73983142e-01f, 1.29861310e-01f, 1.36374593e-01f, 7.63173476e-02f, -3.39179188e-02f, -1.11881932e-02f, -2.18017660e-02f,
  2.14772075e-02f, -7.77072683e-02f, -2.47644544e-01f, -4.46106587e-03f, 3.70625444e-02f, -2.85557378e-03f, 2.88014766e-02f, 8.82673189e-02f, 6.68146163e-02f, -7.10575283e-03f,
  -7.31754303e-02f, -4.00255769e-02f, -1.10966116e-01f, -7.56617337e-02f, -5.45168407e-02f, -2.36067504e-01f, -7.28147700e-02f, -2.65138209e-01f, -3.50477882e-02f, -1.38946891e-01f,
  -6.49540406e-03f, -1.96558863e-01f, 2.70212218e-02f, -1.56762660e-01f, -6.27724007e-02f, -1.67113677e-01f, -1.87214628e-01f, -6.57521486e-02f, -5.49361929e-02f, -7.86799714e-02f,
  2.21026018e-02f, 2.62611676e-02f, -5.17719425e-03f, 7.89268464e-02f, 9.94872525e-02f, -7.57654384e-02f, -5.58034610e-03f, 2.14274917e-02f, 1.81236435e-02f, -1.68666095e-01f,
  -1.67785548e-02f, 1.18895426e-01f, 1.47604063e-01f, -2.04262808e-02f, 2.31435411e-02f, -5.96494153e-02f, 3.18897329e-02f, 6.62683472e-02f, 6.74550310e-02f, 3.78627069e-02f,
  -1.07677341e-01f, 2.20786501e-02f, 7.94500336e-02f, -8.24109837e-03f, 2.26335023e-02f, 4.65605557e-02f, -5.32176197e-02f, 6.03773929e-02f, 4.43896577e-02f, -9.55857802e-03f,
  2.74978671e-02f, -6.98585510e-02f, -5.08277193e-02f, -5.02162650e-02f, -6.03867397e-02f, 5.67416735e-02f, -1.03449803e-02f, 2.78648175e-02f, -8.27397034e-02f, -7.57997632e-02f,
  -1.04653642e-01f, 1.82745859e-01f, 1.83635447e-02f, -6.55818358e-02f, 3.61408032e-02f, -1.48669422e-01f, 4.73515540e-02f, -1.53376892e-01f, -7.77037963e-02f, -1.14969194e-01f,
  4.03284393e-02f, -7.72720575e-02f, -1.83631554e-02f, -3.48490961e-02f, -1.33846030e-01f, -1.53273061e-01f, -5.82053252e-02f, -3.56067047e-02f, -5.07791340e-02f, -1.78979766e-02f,
  -1.27315416e-03f, -4.84813936e-02f, -8.30942094e-02f, 8.23637247e-02f, 4.56328951e-02f, -1.74589362e-02f, -7.66846091e-02f, -1.61033660e-01f, -1.62335727e-02f, -2.69270446e-02f,
  1.29941627e-01f, -2.57719576e-01f, 2.57330507e-01f, -3.85158733e-02f, -3.11041296e-01f, -2.30740860e-01f, -3.90308201e-01f, -6.23023435e-02f, -1.10780142e-01f, -3.23845834e-01f,
  -5.01321197e-01f, -1.63109079e-01f, -6.46803156e-02f, -7.21190423e-02f, 1.05653927e-01f, -8.61330628e-02f, 9.08560604e-02f, 3.88657689e-01f, 3.44358623e-01f, -7.30382875e-02f,
  -2.16691285e-01f, 1.09161258e-01f, 3.84120256e-01f, 3.21811646e-01f, -5.06037921e-02f, 4.20805961e-02f, 1.26212865e-01f, 1.91167444e-02f, -7.57556558e-02f, 5.88914230e-02f,
  -2.33888492e-01f, 1.61841989e-01f, 3.66133265e-02f, 4.11209371e-03f, -1.69361934e-01f, -6.86107427e-02f, -5.78996800e-02f, 4.03674431e-02f, -3.39322425e-02f, 3.69800292e-02f,
  -1.72266185e-01f, -8.93039331e-02f, -9.23414081e-02f, 3.78225297e-02f, -4.21711467e-02f, 8.56180638e-02f, 1.06023274e-01f, 2.68936753e-01f, 9.31835547e-02f, -7.72831440e-02f,
  -1.56355917e-01f, -1.67254612e-01f, 7.03891218e-02f, 7.00099617e-02f, 9.95255560e-02f, 1.07063256e-01f, 9.22877565e-02f, 1.56741858e-01f, 1.51136369e-01f, 6.52694777e-02f,
  6.28307611e-02f, -3.62515375e-02f, -5.17589524e-02f, 9.12533998e-02f, 8.69954601e-02f, -7.53226727e-02f, 1.35462523e-01f, -3.51540884e-03f, 6.02423176e-02f, 3.68067399e-02f,
  1.88572742e-02f, -5.51448576e-03f, 9.82885659e-02f, 8.59519765e-02f, 7.10470676e-02f, -7.88438544e-02f, -1.03605010e-01f, 5.11503927e-02f, -1.01985382e-02f, -1.89352874e-02f,
  1.30320657e-02f, 4.43566926e-02f, 1.05059363e-01f, 1.62805662e-01f, 9.70668420e-02f, 1.19683623e-01f, 2.97234152e-02f, 3.85875851e-02f, 1.82595793e-02f, -6.75556660e-02f,
  -2.99632967e-01f, 6.69686571e-02f, -2.26666495e-01f, 2.19633803e-02f, -1.52955353e-01f, 7.07159750e-03f, -1.74035624e-01f, -8.74528065e-02f, -7.64953792e-02f, 9.38799419e-03f,
  -3.67946438e-02f, -1.29621282e-01f, -9.38142017e-02f, 7.03569278e-02f, -7.83497766e-02f, 4.81465496e-02f, -2.41531551e-01f, -1.31682530e-01f, -4.53988761e-02f, -4.32295576e-02f,
  7.62604102e-02f, -1.17066585e-01f, -2.39621267e-01f, -1.99165821e-01f, -1.48766413e-01f, -1.43372742e-02f, -5.48532140e-03f, -4.64258417e-02f, -1.34568840e-01f, -2.22581327e-01f,
  5.46417058e-01f, -7.82911554e-02f, -2.12148249e-01f, 2.31792312e-02f, -3.33377928e-01f, -2.50043213e-01f, -2.88899630e-01f, -1.40865251e-01f, -4.27060090e-02f, -9.57986489e-02f,
  -1.24386303e-01f, 9.26068574e-02f, 2.35707443e-02f, 1.04763033e-02f, 9.86909419e-02f, -9.73230749e-02f, 2.64260452e-03f, 1.76972911e-01f, 1.18623912e-01f, 3.25420611e-02f,
  9.45677534e-02f, 4.53363582e-02f, 1.31369889e-01f, 1.14360265e-01f, -2.63264328e-02f, 7.76591673e-02f, -6.96079656e-02f, -1.57468721e-01f, -1.62911177e-01f, 1.27666937e-02f,
  -8.27166662e-02f, -6.03838563e-02f, 6.20101206e-02f, 3.78151983e-02f, 1.96585408e-03f, 3.89604978e-02f, 1.17472686e-01f, 4.60111797e-02f, -9.95723531e-02f, 4.82446998e-02f,
  1.09152466e-01f, -2.31612958e-02f, 2.77326268e-04f, -7.95039982e-02f, -6.24156855e-02f, 4.98907268e-02f, -4.16877270e-02f, 2.13907380e-02f, 3.81859206e-02f, -1.45067116e-02f,
  -1.51776761e-01f, -6.51723966e-02f, -2.28647724e-01f, -5.52398898e-02f, 1.25539765e-01f, 1.43022444e-02f, -2.74258237e-02f, -6.73747882e-02f, -1.45561904e-01f, 3.79715636e-02f,
  -8.88024941e-02f, 3.05537377e-02f, 8.42978060e-02f, -2.06685979e-02f, 1.37222469e-01f, 1.00226533e-02f, 1.08312508e-02f, 3.17130871e-02f, 8.89921002e-03f, 1.86275274e-01f,
  -4.14946042e-02f, 2.59115491e-02f, 8.87974538e-03f, 2.10691720e-01f, 9.09580216e-02f, -1.19969971e-01f, -7.93662693e-05f, 2.89386231e-02f, 5.73290177e-02f, -2.87498650e-03f,
  1.57154322e-01f, -5.56202456e-02f, -1.10401236e-01f, 3.90102267e-02f, -7.89412484e-02f, -8.88510793e-02f, 9.79534015e-02f, 6.22661896e-02f, -2.10609790e-02f, 1.55078797e-02f,
  -1.90658644e-01f, -3.57069820e-02f, 1.72594354e-01f, 1.05499707e-01f, -8.23796354e-03f, -1.52415978e-02f, 3.08128982e-03f, -1.65736265e-02f, -4.45575221e-03f, -9.32845548e-02f,
  -9.97484773e-02f, -1.48893483e-02f, -8.94112885e-03f, -1.59601010e-02f, -4.56533432e-02f, 9.07443166e-02f, 1.06494017e-01f, 7.21381162e-04f, -1.25967428e-01f, -1.24232627e-01f,
  -7.33741298e-02f, -1.08467601e-01f, -1.01439536e-01f, -7.35511957e-03f, 1.35907307e-01f, 1.71551723e-02f, 1.06874174e-02f, -3.89923044e-02f, -6.57228008e-02f, 4.66487259e-02f,
  3.77939478e-03f, 9.33015645e-02f, -2.40950584e-01f, 2.82317884e-02f, -3.24939042e-02f, -1.49171233e-01f, -1.54466525e-01f, -6.68358654e-02f, 1.37026701e-02f, 4.70371619e-02f,
  8.79832637e-03f, -5.01402915e-02f, -1.60455376e-01f, -1.93596035e-01f, -3.19523275e-01f, -1.34359837e-01f, -2.11757138e-01f, -3.39606315e-01f, -2.15517297e-01f, 1.93100255e-02f,
  1.18170932e-01f, 5.29415719e-02f, -1.85325760e-02f, -5.72988912e-02f, 1.47573128e-01f, -2.23546959e-02f, -2.29565017e-02f, -4.18315008e-02f, -7.08889812e-02f, -3.22181806e-02f,
  -5.37532009e-02f, -4.59253229e-02f, -3.37693878e-02f, -2.39216536e-02f, 3.73574272e-02f, 1.08034275e-02f, -5.63198924e-02f, -1.40737087e-01f, -1.43983111e-01f, -8.38943496e-02f,
  -3.61839309e-02f, 6.12955075e-03f, -4.03266288e-02f, 8.04108307e-02f, 1.28832087e-03f, -1.07554354e-01f, -4.25829962e-02f, -1.78508237e-01f, -5.41045815e-02f, 2.05161832e-02f,
  6.40838146e-02f, -1.29095808e-01f, -1.93077922e-01f, -6.91647455e-02f, -1.37531608e-01f, -8.96778479e-02f, 3.66503224e-02f, -2.12322716e-02f, -1.65617108e-01f, 9.46143195e-02f,
  1.02118231e-01f, -7.36248726e-03f, -5.11396788e-02f, -9.04458836e-02f, 6.93803057e-02f, -6.65159477e-03f, -5.95953837e-02f, 6.75666565e-03f, -5.54656498e-02f, -1.20328888e-01f,
  9.06583853e-03f, 8.93542990e-02f, -6.44272426e-03f, -1.05159193e-01f, -5.24276029e-03f, 3.48630995e-02f, -6.80873394e-02f, 2.45505553e-02f, -1.83418263e-02f, 1.27368510e-01f,
  -5.47253489e-02f, -1.08376732e-02f, 9.07872915e-02f, -8.95186421e-03f, -8.70763287e-02f, -7.42452890e-02f, -3.41953374e-02f, -6.39857631e-03f, 1.13075256e-01f, -6.94009960e-02f,
  1.75275728e-01f, -5.80513664e-02f, -9.07707866e-03f, -5.96124232e-02f, -7.40355253e-02f, 5.87454736e-02f, -3.19570526e-02f, -5.57316579e-02f, -8.69704485e-02f, 6.49319142e-02f,
  -1.92107633e-01f, 4.58065346e-02f, -8.13641921e-02f, 4.07171473e-02f, -6.37797117e-02f, -5.78298084e-02f, 8.09325129e-02f, 1.98237021e-02f, -6.82283342e-02f, 1.18283339e-01f,
  8.05122182e-02f, -1.37214065e-01f, -1.07358992e-01f, -8.24578945e-03f, -9.53716710e-02f, -7.59137198e-02f, 4.14221659e-02f, 9.59512144e-02f, -1.40697256e-01f, 2.82778293e-01f,
  -2.61874020e-01f, -1.03984557e-01f, 5.33158146e-02f, 1.56416342e-01f, 3.02203953e-01f, -2.26255357e-01f, -5.58242798e-01f, -4.78626072e-01f, 2.22993176e-02f, 1.56119213e-01f,
  3.36057156e-01f, 3.40531975e-01f, 1.55190989e-01f, -1.36236995e-01f, -4.82208878e-01f, -2.81332791e-01f, -2.29479417e-01f, -3.09107065e-01f, -4.47536796e-01f, -2.25093618e-01f,
  7.32629448e-02f, -4.20086272e-02f, -1.36569291e-01f, -1.55520126e-01f, 3.62049699e-01f, 2.27364480e-01f, 2.72964120e-01f, 2.03574389e-01f, 6.66652918e-02f, 3.05775434e-01f,
  4.61582929e-01f, 1.60060991e-02f, -2.79074162e-02f, 9.27664526e-03f, 1.59334004e-01f, -1.16218239e-01f, -3.80281992e-02f, -9.17137191e-02f, -2.60587670e-02f, -1.43569596e-02f,
  2.78749615e-01f, -6.05190769e-02f, -6.41785637e-02f, 4.96746488e-02f, -6.78157434e-02f, -5.44309877e-02f, -1.05349436e-01f, -2.88513422e-01f, -1.26476079e-01f, 5.42226098e-02f,
  2.14503199e-01f, 1.56153977e-01f, 1.06158257e-01f, -1.42510340e-01f, -5.31132966e-02f, 1.89150468e-01f, 8.46497193e-02f, 2.00995542e-02f, -1.13166206e-01f, 5.45028336e-02f,
  3.84188397e-03f, 1.22677185e-01f, -3.54440808e-02f, -1.46451890e-02f, 3.69875431e-02f, 6.25990033e-02f, 8.40834379e-02f, 6.48517162e-02f, -1.00167487e-02f, -7.40622059e-02f,
  3.94342747e-03f, -1.69248078e-02f, -1.39605016e-01f, -1.21666119e-01f, 7.45029673e-02f, 1.31763279e-01f, 9.28204507e-02f, 3.92401591e-03f, 3.99121344e-02f, 1.27098665e-01f,
  1.32430181e-01f, 9.91928950e-02f, 2.21981853e-01f, -3.00026014e-02f, 1.11932091e-01f, 1.39113478e-02f, 2.03661859e-01f, 8.91633555e-02f, 1.56746984e-01f, 1.03326209e-01f,
  2.40629002e-01f, -2.25117117e-01f, 1.10609613e-01f, -1.70295686e-01f, 1.33383259e-01f, 1.56120313e-02f, 1.76820263e-01f, -6.09130077e-02f, 1.58126131e-01f, 4.54950333e-02f,
  4.44615148e-02f, -2.90894918e-02f, -1.66838765e-01f, -5.16264215e-02f, -7.83951730e-02f, 1.32018641e-01f, 6.14692047e-02f, 1.13411650e-01f, -7.09684268e-02f, 1.51089221e-01f,
  -5.66195697e-02f, -1.49576396e-01f, -7.21322000e-02f, -5.77995852e-02f, -2.96095572e-02f, 1.44269960e-02f, 7.93775395e-02f, 2.38669291e-03f, -2.11254761e-01f, -1.98044226e-01f,
  4.74597737e-02f, 1.72245707e-02f, 3.55373740e-01f, 1.61842138e-01f, 7.41980523e-02f, -1.83770001e-01f, -4.58453566e-01f, -1.04002908e-01f, 5.87493069e-02f, -2.76046488e-02f,
  -1.41645208e-01f, -7.01755509e-02f, 4.25944850e-02f, -1.29159853e-01f, -2.68430084e-01f, -7.92562496e-03f, 2.07298219e-01f, 8.83351266e-03f, -2.01938316e-01f, -3.85859519e-01f,
  -2.62729764e-01f, -8.57572779e-02f, 4.10340242e-02f, 1.08328693e-01f, 3.31867397e-01f, 9.25063789e-02f, 3.59634697e-01f, 1.88684106e-01f, 3.94060872e-02f, 3.73849928e-01f,
  7.63972327e-02f, 1.86236575e-01f, -1.44743294e-01f, -6.38394654e-02f, 2.16877256e-02f, -7.65185952e-02f, -1.10056087e-01f, 1.42385095e-01f, -5.18632084e-02f, -6.88584223e-02f,
  -1.60810664e-01f, -7.87706822e-02f, 4.75379899e-02f, -2.14618176e-01f, -1.00670904e-01f, -2.05208123e-01f, 1.07592784e-01f, 8.32139328e-03f, 5.35684526e-02f, -4.64484207e-02f,
  -1.78581253e-01f, -7.51876459e-02f, 1.19615570e-01f, 5.08374013e-02f, 4.98612151e-02f, -2.60907058e-02f, 2.59518344e-02f, 4.46306206e-02f, 3.65924835e-02f, 1.67238072e-01f,
  -2.04802882e-02f, 6.58245198e-03f, -3.42638530e-02f, 9.50943530e-02f, -6.74170554e-02f, -1.26052294e-02f, -3.60993994e-03f, -1.69269338e-01f, 5.71832620e-02f, -4.24219295e-02f,
  4.13255505e-02f, 7.55587146e-02f, 7.73065090e-02f, 1.75383408e-02f, -3.05410866e-02f, -1.97673477e-02f, -8.69940594e-02f, -4.17752713e-02f, 8.69869441e-02f, 5.22440597e-02f,
  -9.24832523e-02f, 4.62370701e-02f, 4.04262990e-02f, -5.12657911e-02f, 3.02779675e-02f, 2.15091463e-02f, 1.65611021e-02f, 1.69462711e-02f, 1.07494704e-01f, 1.36246420e-02f,
  -5.75958863e-02f, -2.28224844e-01f, -4.55128476e-02f, -1.19326949e-01f, 1.26052886e-01f, 5.85699864e-02f, 8.82818848e-02f, -5.71034178e-02f, 9.86835826e-03f, -1.26562893e-01f,
  -8.97540301e-02f, -9.05147567e-02f, 1.48573935e-01f, -1.42520800e-01f, -1.29092544e-01f, -6.84875995e-02f, -1.03044413e-01f, -1.69301659e-01f, -1.19145773e-01f, -6.11449964e-02f,
  -1.72052458e-02f, -2.91578650e-01f, -2.17909604e-01f, -5.41186482e-02f, 3.09522264e-02f, -2.46329740e-01f, -1.08313367e-01f, -4.94716726e-02f, -2.34337896e-01f, -1.73159301e-01f,
  1.57301780e-02f, -2.29680806e-01f, 2.43350551e-01f, 1.82329938e-01f, 3.90046209e-01f, 3.91836554e-01f, 3.18569988e-01f, 1.93607047e-01f, 7.56499991e-02f, -1.44008771e-01f,
  -1.84889063e-01f, -2.11062104e-01f, -2.22208127e-02f, -1.39253005e-01f, 9.05682892e-03f, 2.12440968e-01f, 3.33263963e-01f, 1.95719212e-01f, 1.91322893e-01f, -3.75919007e-02f,
  -7.39880204e-02f, -5.14812255e-03f, 6.77012801e-02f, 7.19484314e-02f, -3.24433520e-02f, 3.03948019e-02f, 2.25307614e-01f, 1.82837531e-01f, 7.08140209e-02f, 3.66274081e-02f,
  5.15598729e-02f, 1.40969127e-01f, 3.60135511e-02f, -1.28210381e-01f, -5.77292815e-02f, -9.59822536e-02f, 6.29813969e-02f, -1.26009658e-01f, -8.47075060e-02f, -3.99709567e-02f,
  2.26253159e-02f, 2.93104053e-02f, 1.66923597e-01f, -3.78823578e-02f, 3.76592241e-02f, 2.79801488e-02f, 5.66315651e-03f, 7.05779120e-02f, 3.85336280e-02f, -3.85672674e-02f,
  -2.09751464e-02f, 1.13334194e-01f, 1.83251828e-01f, 9.81633738e-02f, 7.47624785e-02f, 1.31943613e-01f, -2.88925096e-02f, 4.05522175e-02f, 1.08594954e-01f, -5.27268760e-02f,
  9.42242518e-02f, 3.20509523e-02f, 1.25913620e-01f, 1.92643311e-02f, -7.27017643e-03f, 1.93751361e-02f, 1.01708978e-01f, 7.43610710e-02f, 1.82806581e-01f, 8.49842504e-02f,
  1.36626914e-01f, 8.85393396e-02f, 6.13303334e-02f, 1.33899659e-01f, 1.04101814e-01f, 1.16419226e-01f, 7.19142184e-02f, 3.53637151e-02f, 1.04685634e-01f, 1.71402961e-01f,
  1.98707089e-01f, 1.92736331e-02f, 1.31985053e-01f, 1.05835490e-01f, 4.54071946e-02f, 3.48674841e-02f, 5.94906844e-02f, -8.89797360e-02f, 1.15027361e-01f, 1.38580859e-01f,
  9.45284031e-03f, 2.38846421e-01f, -8.47142041e-02f, -3.80626414e-03f, -7.69982934e-02f, -8.37910846e-02f, 5.15186042e-02f, -1.59387320e-01f, -1.64613783e-01f, -1.68126803e-02f,
  -2.85687950e-03f, -8.31703395e-02f, 2.63863169e-02f, 8.84544849e-02f, 8.72952789e-02f, 5.10712564e-02f, -1.75451338e-01f, -2.34361347e-02f, -1.29359096e-01f, -6.65509701e-02f,
  -1.76720589e-01f, -8.34953412e-02f, 6.63987771e-02f, 1.18553527e-01f, -1.63355693e-02f, 8.41238573e-02f, 1.99717768e-02f, -9.18614492e-02f, 4.62844968e-02f, -5.45631647e-02f,
  -5.95740855e-01f, -3.48254144e-01f, -9.74739939e-02f, -2.32434988e-01f, -1.25799313e-01f, -4.77494188e-02f, -8.16063061e-02f, 8.34548101e-02f, -2.20629014e-02f, -1.81571171e-01f,
  -1.26996607e-01f, -5.59399985e-02f, -1.35476664e-01f, 2.87588127e-02f, 7.42457211e-02f, -1.37014911e-01f, -6.01871014e-02f, 8.90458226e-02f, 2.54476100e-01f, 2.15440437e-01f,
  3.95656899e-02f, 3.95074971e-02f, 7.98834339e-02f, 7.90642127e-02f, -1.39696300e-01f, -8.59249905e-02f, -1.07833505e-01f, -1.68150291e-01f, -1.27081469e-01f, -3.65915030e-01f,
  -2.93968022e-01f, -1.82582945e-01f, 1.89133644e-01f, 5.99308638e-04f, 1.25904009e-02f, 1.29179908e-02f, -3.85391228e-02f, 4.13577408e-02f, -3.08755916e-02f, -2.48301551e-02f,
  2.59195059e-03f, 9.88383964e-02f, -1.02374002e-01f, 7.67865255e-02f, 1.17942803e-02f, 2.93657370e-02f, 1.14527784e-01f, 9.91270617e-02f, 4.36653709e-03f, 2.44817231e-02f,
  -1.10410728e-01f, -2.24468246e-01f, -2.14489087e-01f, 4.42941636e-02f, 7.83801228e-02f, -8.06882884e-03f, 5.08665480e-02f, 5.61837852e-03f, -1.01296417e-02f, -2.97552526e-01f,
  -1.57737592e-03f, 1.13907002e-01f, 1.64079994e-01f, 4.91592148e-03f, 3.93801183e-02f, 1.90455448e-02f, -3.14171687e-02f, 5.53722121e-02f, -1.70435794e-02f, -1.16080113e-01f,
  -6.08530315e-03f, -9.17374492e-02f, 4.89763077e-03f, 1.04503036e-02f, -4.13623974e-02f, -3.53894159e-02f, -6.30177036e-02f, 4.21967283e-02f, -3.13795358e-02f, -5.50101092e-03f,
  -3.12563032e-02f, 5.96266203e-02f, 7.48550892e-02f, 1.26789007e-02f, 1.31947231e-02f, 5.93292564e-02f, -5.20751774e-02f, 1.71225064e-03f, 2.72068717e-02f, -2.38391161e-02f,
  -4.01461050e-02f, 3.47495019e-01f, -2.18106940e-01f, 8.38252231e-02f, -1.37729958e-01f, 1.60560966e-01f, -1.15344875e-01f, 4.25031483e-02f, -2.04896227e-01f, -2.09589545e-02f,
  1.05768241e-01f, -5.07759163e-03f, -4.39328104e-02f, 1.45970315e-01f, 1.92172360e-02f, -3.24544795e-02f, -8.22711065e-02f, -1.52973562e-01f, 3.08916140e-02f, 9.24944319e-03f,
  -8.96575153e-02f, -2.07580820e-01f, -3.30337912e-01f, -2.18926534e-01f, -9.71789658e-02f, -1.77528456e-01f, -1.50123641e-01f, -9.83414724e-02f, -1.08973660e-01f, -4.19955730e-01f,
  -5.83311558e-01f, 3.01030546e-01f, 9.63457227e-02f, -1.89577863e-01f, -1.76964656e-01f, -2.13730589e-01f, 1.38622105e-01f, -1.10333726e-01f, 1.69847086e-02f, 3.44355077e-01f,
  1.43991619e-01f, -3.61633152e-01f, -1.41055450e-01f, -2.26581156e-01f, -2.46320948e-01f, 2.30668679e-01f, -4.13870774e-02f, -3.53078276e-01f, -5.90412080e-01f, -4.22304153e-01f,
  -2.39917532e-01f, -2.95703739e-01f, -4.67799008e-01f, -2.23107010e-01f, 1.00919470e-01f, -2.62255430e-01f, 1.08497411e-01f, -2.27883726e-01f, -2.26084918e-01f, -1.95667688e-02f,
  2.26012573e-01f, -3.66139084e-01f, -1.19487889e-01f, -2.20331132e-01f, 5.55653758e-02f, 5.16499802e-02f, -6.29483834e-02f, 6.96264878e-02f, 4.15160432e-02f, 1.83373243e-01f,
  -9.64946821e-02f, -9.84007195e-02f, -1.06912754e-01f, -5.55341737e-03f, -6.71783686e-02f, 5.15225045e-02f, 6.06717020e-02f, -8.62606466e-02f, -5.21882661e-02f, 9.88967568e-02f,
  6.92940429e-02f, 1.45032229e-02f, 8.44040364e-02f, 1.14361912e-01f, -6.94570169e-02f, -2.42318690e-01f, 1.11112610e-01f, -3.63895372e-02f, -1.38878420e-01f, 2.11331233e-01f,
  2.66826242e-01f, 8.62288624e-02f, -1.09248515e-02f, 6.85894340e-02f, 1.30503312e-01f, -1.55083584e-02f, 8.59635137e-03f, 8.76443274e-03f, 1.97441336e-02f, 7.85009339e-02f,
  6.09561652e-02f, 1.18775681e-01f, 2.90839025e-03f, -1.07587995e-02f, -6.31819293e-02f, -1.38807744e-01f, -8.79797041e-02f, 9.38666165e-02f, 6.27107397e-02f, 1.72796752e-02f,
  -1.42874539e-01f, -1.07635893e-01f, -1.43807940e-02f, 2.79345904e-02f, 3.69245722e-03f, -3.31398705e-03f, -1.24193288e-01f, -6.69116750e-02f, -4.42444086e-02f, -1.35255456e-01f,
  1.24895684e-01f, -4.05602098e-01f, 1.92142457e-01f, -8.14147443e-02f, 3.03135589e-02f, 1.01799428e-01f, 3.33682224e-02f, -2.30453014e-02f, 9.74432603e-02f, 1.31259143e-01f,
  -2.64446139e-02f, -2.61497255e-02f, 7.47847185e-02f, 1.27952620e-01f, 2.94061587e-03f, 6.48785233e-02f, 1.77938953e-01f, -2.23793145e-02f, -5.41487709e-02f, 2.05588356e-01f,
  2.87215143e-01f, 8.74994695e-02f, 8.99915174e-02f, 1.27194121e-01f, -2.11827103e-02f, -1.12489052e-01f, 1.41325057e-01f, 3.87833565e-02f, 3.60271670e-02f, 4.14836973e-01f,
  3.99470359e-01f, -5.15142858e-01f, -1.96649313e-01f, 8.23949948e-02f, -1.97557751e-02f, -2.18919873e-01f, -4.03298616e-01f, -2.76908040e-01f, 3.84671167e-02f, -1.44956186e-02f,
  5.85778356e-02f, 8.15335363e-02f, 1.47455990e-01f, 2.20552105e-02f, -1.40172914e-01f, -2.38310769e-01f, -1.55597642e-01f, 7.05122203e-02f, 6.57164603e-02f, 4.96469811e-02f,
  -6.37736246e-02f, 1.07140824e-01f, 5.56532554e-02f, 6.01133658e-03f, -1.25326635e-02f, 1.63760245e-01f, 1.28227542e-03f, -7.64923450e-03f, -8.46682265e-02f, -1.19137548e-01f,
  -1.02510490e-01f, -5.38105182e-02f, 1.61717430e-01f, 8.27540457e-02f, 9.19721127e-02f, 4.33281511e-02f, -2.09816694e-02f, -2.65973788e-02f, 2.89477669e-02f, -1.43708706e-01f,
  1.12803265e-01f, 4.28978764e-02f, 1.20058775e-01f, 2.93011609e-02f, 6.19276203e-02f, 7.86999539e-02f, -9.62109864e-02f, -1.50306318e-02f, -1.13209225e-02f, -6.67866394e-02f,
  -1.04690194e-02f, 9.07570943e-02f, -2.44590174e-02f, -3.40791382e-02f, -1.75113920e-02f, 4.84737530e-02f, -7.16900453e-03f, -7.97929391e-02f, 5.63114285e-02f, -5.29249609e-02f,
  6.93124253e-03f, -6.05649836e-02f, 2.88953204e-02f, 1.33339241e-01f, 1.35560229e-01f, 5.31420065e-03f, 1.63424906e-04f, -7.49085248e-02f, 8.03851634e-02f, 1.10471092e-01f,
  -6.45504072e-02f, 9.81310233e-02f, -8.15770961e-03f, 1.12251736e-01f, 2.75767483e-02f, -1.31785706e-01f, -1.44867018e-01f, 4.85061184e-02f, 1.84652418e-01f, 2.71665584e-02f,
  1.37302876e-01f, -5.27854376e-02f, 4.87541743e-02f, 6.27140477e-02f, 1.91815812e-02f, 1.19242154e-01f, -8.45008157e-03f, -3.06128692e-02f, 5.45738917e-03f, -1.64249554e-01f,
  -1.02711707e-01f, 3.80327851e-01f, 1.05253860e-01f, -6.11146316e-02f, -3.86701636e-02f, 2.92249918e-02f, -1.14190234e-02f, -2.53971592e-02f, -1.04805991e-01f, -6.32091761e-02f,
  -7.41073862e-02f, -7.94331282e-02f, -1.21797413e-01f, 7.00015575e-02f, 1.88043952e-01f, 1.61252812e-01f, 8.15505460e-02f, -9.88146514e-02f, -5.44343814e-02f, -1.50499389e-01f,
  -1.18076786e-01f, 2.38632248e-03f, -9.89347026e-02f, -2.92255674e-02f, 7.47530814e-03f, 1.49740219e-01f, -1.55262668e-02f, 6.38124347e-02f, 2.70302612e-02f, -4.50505083e-03f,
  1.64901614e-01f, -1.13456868e-01f, -9.61331576e-02f, -2.27282554e-01f, -1.96853697e-01f, -1.21078670e-01f, 1.27813935e-01f, -8.05834159e-02f, -8.68618414e-02f, 1.39990196e-01f,
  1.90030951e-02f, -3.08603495e-02f, 2.47670803e-02f, 7.00099096e-02f, 2.51063019e-01f, 2.33759716e-01f, 1.62526429e-01f, 2.06474334e-01f, 1.66861375e-03f, -1.02651037e-01f,
  -6.17962517e-03f, -1.23396451e-02f, -3.69351469e-02f, -8.06016549e-02f, -3.13559741e-01f, -1.39055043e-01f, -1.38346732e-01f, -1.24936096e-01f, -4.14452292e-02f, -6.76488355e-02f,
  1.99393854e-02f, -2.55669087e-01f, -1.17967479e-01f, 6.62790751e-03f, -2.17830855e-02f, 4.64615375e-02f, -3.99381146e-02f, -6.65150285e-02f, -4.14297655e-02f, -7.71662220e-02f,
  -2.64837623e-01f, -9.21580493e-02f, -6.45075142e-02f, -1.41859010e-01f, -1.96769372e-01f, -8.26696903e-02f, -7.03886226e-02f, 1.10569470e-01f, -3.13076982e-03f, 3.13995555e-02f,
  -9.45522934e-02f, -1.45981449e-03f, -3.30863111e-02f, -1.69772934e-02f, -8.80998671e-02f, -6.79705739e-02f, -1.24585964e-01f, -9.16727409e-02f, -3.22517343e-02f, -1.53116798e-02f,
  -1.88464336e-02f, 5.50203994e-02f, -5.57643734e-03f, 1.48728695e-02f, -2.33922470e-02f, 2.72302572e-02f, -1.29757845e-03f, 7.16592148e-02f, 1.34444805e-02f, -5.65909818e-02f,
  4.03811708e-02f, 1.98000401e-01f, 4.25705984e-02f, 3.23256105e-02f, 4.09798585e-02f, -1.90330148e-02f, 6.27819300e-02f, 2.68189944e-02f, 8.61513391e-02f, 5.63366376e-02f,
  -1.83767043e-02f, 5.75161986e-02f, -2.40825042e-02f, 8.06521475e-02f, 6.33491054e-02f, 6.00113347e-02f, 2.52078753e-02f, 1.29578575e-01f, -9.54491124e-02f, -4.94031189e-03f,
  -2.44489778e-02f, 2.89835632e-01f, 1.82831418e-02f, -1.71014778e-02f, 6.21498143e-03f, -1.20939389e-01f, 1.08765438e-02f, -1.17913736e-02f, -3.82959917e-02f, -1.02627642e-01f,
  -1.62581608e-01f, 9.46347043e-02f, 1.13493148e-02f, -6.07298575e-02f, 2.20173523e-02f, -8.00325647e-02f, 1.27687335e-01f, 1.33052841e-01f, 3.38642336e-02f, 4.02158126e-02f,
  2.17978172e-02f, 2.06129164e-01f, 2.33620092e-01f, 1.32191390e-01f, -6.40883371e-02f, 6.84938133e-02f, 1.93766505e-02f, 2.03346908e-02f, 2.14831054e-01f, 2.91568726e-01f,
  -5.17187774e-01f, 3.67168784e-01f, 2.30756961e-02f, -4.63370800e-01f, 8.09560120e-02f, 3.29598844e-01f, 4.96826947e-01f, 8.06235895e-02f, -2.67977923e-01f, 2.04724446e-01f,
  1.49119973e-01f, -1.85272142e-01f, -1.88275337e-01f, 6.44782782e-02f, 2.14923874e-01f, 2.22589433e-01f, 1.09719057e-02f, -1.15070686e-01f, -1.38473108e-01f, 1.85341388e-01f,
  1.63632452e-01f, -1.69836953e-02f, -2.37243518e-01f, -6.35423958e-02f, -2.10917667e-01f, -1.84935227e-01f, -7.14837387e-02f, 8.23508725e-02f, 1.87453330e-01f, -1.52429372e-01f,
  1.89558104e-01f, 3.05955727e-02f, -6.40039220e-02f, 8.46037176e-03f, 6.15358166e-02f, -4.18674424e-02f, 1.11338250e-01f, -5.61696663e-02f, 1.04171401e-02f, -3.89989130e-02f,
  1.40110523e-01f, -4.24740054e-02f, 6.13612356e-03f, 9.44410823e-03f, -1.02998868e-01f, 1.15854613e-01f, 6.91834465e-02f, -6.59191981e-02f, -4.73023877e-02f, 1.42393589e-01f,
  1.42009899e-01f, 2.30612814e-01f, 3.68699394e-02f, 4.19471366e-03f, 2.88340393e-02f, -3.79273109e-02f, 6.54705167e-02f, -8.63758326e-02f, -8.06512777e-03f, -1.22902185e-01f,
  1.81203000e-02f, -1.25527000e-02f, 1.96874008e-01f, -1.33250859e-02f, -3.13263610e-02f, -1.22902915e-02f, -5.79731576e-02f, 7.73764104e-02f, 1.63789615e-01f, 1.65337399e-01f,
  -2.21573543e-02f, -1.41009256e-01f, -1.52651340e-01f, -4.57153581e-02f, -1.28755897e-01f, -5.94342537e-02f, 5.31696603e-02f, 8.70445073e-02f, 5.18360622e-02f, -4.75524366e-02f,
  -1.12171263e-01f, -1.74278513e-01f, -1.79296657e-01f, 1.35901952e-02f, 6.68815970e-02f, -1.32848352e-01f, -5.82208671e-02f, -5.78718409e-02f, -7.75793642e-02f, 5.36714047e-02f,
  -1.33647770e-01f, 1.83467731e-01f, -1.64815679e-01f, -2.35916749e-02f, -6.48274273e-02f, -1.80051774e-02f, -1.59595478e-02f, -3.01115960e-02f, 1.66946705e-02f, -6.52936846e-02f,
  1.85459018e-01f, -1.23559810e-01f, -5.90888299e-02f, 8.30648094e-02f, 2.60965084e-03f, 5.13151847e-03f, 5.43439239e-02f, -1.26489714e-01f, -1.21359371e-01f, -1.06186800e-01f,
  -1.48459807e-01f, -5.88777401e-02f, -2.64602631e-01f, -2.59915382e-01f, -1.58864126e-01f, -3.09771061e-01f, -1.16908969e-02f, -1.74384221e-01f, 3.68049629e-02f, -1.38375401e-01f,
  5.27291477e-01f, -2.00112507e-01f, 4.87317815e-02f, 1.80477202e-01f, 4.38629687e-02f, 1.11048864e-02f, -4.78660837e-02f, -1.67656429e-02f, 1.38419479e-01f, 5.63051924e-02f,
  7.13115092e-03f, 7.61427060e-02f, 1.91923778e-03f, -5.32083623e-02f, -1.27832191e-02f, -1.22868039e-01f, 2.18106410e-03f, 6.41653389e-02f, 1.10338129e-01f, -2.42545139e-02f,
  -7.29534701e-02f, -3.01213302e-02f, 1.48221552e-01f, -1.03758074e-01f, -1.81024969e-01f, -3.37182321e-02f, -3.36256810e-02f, -8.99936184e-02f, -7.67512843e-02f, -2.71418005e-01f,
  -3.67148161e-01f, 9.10974964e-02f, 8.78567994e-02f, -5.46474457e-02f, -9.78875384e-02f, 6.71576126e-05f, -2.78931931e-02f, -1.38618544e-01f, 3.79241444e-02f, -1.65491551e-01f,
  3.28505225e-02f, -2.87896972e-02f, 3.00153103e-02f, 3.15313274e-03f, 5.54277860e-02f, -4.29079123e-02f, -7.35125989e-02f, -4.09997292e-02f, 1.14709157e-02f, -1.10833697e-01f,
  -1.13397092e-01f, 7.50146583e-02f, -4.36185487e-02f, -1.15274731e-02f, 1.51284739e-01f, 1.77828684e-01f, -4.76380326e-02f, 6.64664656e-02f, 1.01144530e-01f, 4.19102460e-02f,
  -1.13602974e-01f, -5.25568649e-02f, 3.45666595e-02f, 9.11132619e-02f, 1.17170162e-01f, 1.30972207e-01f, 4.94697168e-02f, 1.13115534e-01f, 1.64566904e-01f, 5.54742329e-02f,
  -7.94251710e-02f, -2.97997962e-03f, -4.66546156e-02f, -2.71789394e-02f, -7.40977079e-02f, -1.33935407e-01f, 6.28147833e-03f, -1.86181083e-01f, -6.49982095e-02f, -3.27331834e-02f,
  -5.31130172e-02f, -6.53524101e-02f, -9.10265595e-02f, -1.73659220e-01f, -7.56059289e-02f, -2.58017685e-02f, -1.73756341e-03f, -5.98453544e-02f, -3.25188264e-02f, -4.29901257e-02f,
  -2.99580365e-01f, 1.17669843e-01f, 6.82217628e-02f, 3.88032896e-03f, 5.75259253e-02f, -2.20476035e-02f, 7.97818601e-02f, -7.78854117e-02f, -2.60484517e-01f, -9.90409479e-02f,
  -4.63341065e-02f, 5.07475957e-02f, -3.61828580e-02f, 9.55168158e-02f, 6.13360852e-02f, 3.53524983e-02f, 6.52810261e-02f, 4.76040393e-02f, -3.90311107e-02f, -1.80257618e-01f,
  -1.18268505e-01f, 1.61728337e-01f, 1.12589635e-01f, 6.73845112e-02f, 5.19554131e-02f, 1.80509433e-01f, 7.40390047e-02f, 8.10400993e-02f, 7.96455741e-02f, 1.98387176e-01f,
  -5.92971705e-02f, -2.66410261e-01f, 1.87436119e-01f, -1.92550551e-02f, -2.33648896e-01f, -1.69806123e-01f, -2.74329662e-01f, -1.38044536e-01f, -9.17515382e-02f, -7.10313693e-02f,
  -1.93442583e-01f, -2.76690334e-01f, -9.28586256e-03f, -4.03838046e-02f, 1.16794005e-01f, 1.96620211e-01f, 3.94847423e-01f, 3.26327860e-01f, -3.37490849e-02f, -4.04211223e-01f,
  -2.66328663e-01f, -7.29511604e-02f, 1.14931285e-01f, 5.59099130e-02f, -1.99539930e-01f, -6.72264621e-02f, 1.75766885e-01f, 3.54192569e-03f, 9.62309912e-03f, 1.02045396e-02f,
  -9.42643285e-02f, -1.31612822e-01f, -2.06150152e-02f, -6.07322268e-02f, 2.99721700e-03f, -7.34984279e-02f, -4.53109369e-02f, 1.10394992e-01f, 1.54753716e-03f, 7.00401515e-02f,
  -1.21262312e-01f, -1.73341379e-01f, -7.94970989e-02f, -1.64694294e-01f, -8.80230218e-02f, -8.90710577e-02f, 1.85054466e-01f, -2.07572952e-02f, 9.09141898e-02f, -3.99566814e-02f,
  -1.72491238e-01f, -1.03656217e-01f, 5.98987937e-02f, 7.51333535e-02f, 1.11441184e-02f, 1.05893336e-01f, -5.09099253e-02f, -1.35857925e-01f, 2.11633936e-01f, 1.48703251e-02f,
  -8.90291855e-02f, -4.98661436e-02f, 4.64569442e-02f, 1.23199662e-02f, 1.79882552e-02f, 1.00543022e-01f, -8.90364870e-03f, -4.81912196e-02f, 3.87009010e-02f, -1.43531589e-02f,
  9.89874080e-02f, 1.63142651e-01f, 1.39560690e-02f, -1.29619997e-03f, 2.91985534e-02f, 5.60123362e-02f, -4.34911959e-02f, 4.17392068e-02f, -2.55967118e-02f, -3.60244624e-02f,
  -3.63322273e-02f, -7.32105970e-02f, -8.48031566e-02f, 2.45896298e-02f, -4.15379517e-02f, 1.00533471e-01f, 4.31744866e-02f, -1.20676346e-02f, 9.96300951e-03f, -1.70190129e-02f,
  -7.57873431e-02f, 2.17506036e-01f, -1.20785445e-01f, -4.32483703e-02f, 5.31081147e-02f, 2.19390132e-02f, -2.16570143e-02f, 1.01835109e-01f, 8.91830251e-02f, -3.14916372e-02f,
  -9.98813584e-02f, -1.19563572e-01f, -5.91605669e-04f, -1.06422514e-01f, -5.35861254e-02f, -9.22507495e-02f, 1.71329007e-01f, -1.15083016e-01f, 3.44713144e-02f, -5.77175505e-02f,
  1.91192731e-01f, 1.87820029e-02f, -1.17855575e-02f, 1.35537842e-02f, -6.75285459e-02f, -1.74336042e-02f, -4.34272550e-02f, -1.05291434e-01f, 1.49250716e-01f, 1.15948543e-01f,
  6.99269712e-01f, 9.73469019e-02f, -6.96440339e-01f, 2.14449316e-01f, -2.22633258e-01f, -4.60009038e-01f, -4.15290982e-01f, -5.41809537e-02f, 2.08594352e-01f, -1.07699759e-01f,
  -1.15262359e-01f, 1.65081054e-01f, 2.10690945e-02f, -1.45449191e-01f, -2.75095850e-01f, -3.83645564e-01f, -4.01931673e-01f, -3.69664133e-01f, -3.00894290e-01f, -1.38353258e-01f,
  4.77222726e-02f, 1.45173192e-01f, 9.93898585e-02f, -6.49473965e-02f, 4.79970798e-02f, -6.38438091e-02f, -3.21180403e-01f, -1.48104995e-01f, -2.83231527e-01f, -1.60750791e-01f,
  -4.33818102e-01f, -6.67679757e-02f, -1.43403232e-01f, 1.19936429e-01f, 3.33886407e-02f, 9.42892432e-02f, 3.62003259e-02f, 4.31766286e-02f, 9.63419676e-02f, 1.29062813e-02f,
  6.11003824e-02f, 1.46413118e-01f, 9.51720923e-02f, -3.23968418e-02f, -7.29757920e-02f, -7.08400877e-03f, -3.59324962e-02f, -6.82002902e-02f, 8.65913089e-03f, -8.30112696e-02f,
  1.06472239e-01f, -2.00986862e-02f, -9.77823213e-02f, -1.42924115e-01f, -1.18001148e-01f, 1.19657544e-02f, -1.74269646e-01f, -1.27120867e-01f, -1.53983921e-01f, 1.03277892e-01f,
  -2.82712802e-02f, 2.04415526e-02f, -6.06670603e-02f, -1.44450620e-04f, 2.10475773e-01f, 2.32923012e-02f, 8.50233212e-02f, -7.77443945e-02f, -7.28268595e-03f, -8.26398656e-02f,
  -6.32229745e-02f, -7.49230534e-02f, 1.17546901e-01f, 4.23313603e-02f, -8.31019580e-02f, -4.74775210e-02f, 2.35480443e-02f, -2.31906250e-02f, -3.55393738e-02f, 4.26050611e-02f,
  -6.40417784e-02f, -4.23880927e-02f, 8.73802826e-02f, 5.00536859e-02f, -4.56872806e-02f, -6.39657527e-02f, -6.36849105e-02f, -3.72480080e-02f, 1.93977449e-02f, -1.63188912e-02f,
  2.39618808e-01f, -1.83274016e-01f, 9.25793499e-02f, -1.71738211e-02f, -1.52935132e-01f, -3.17013562e-02f, -9.83162411e-03f, 1.46720082e-01f, 6.91870451e-02f, -1.77149381e-02f,
  -1.27204552e-01f, 3.91688682e-02f, -1.33310026e-02f, -1.39583629e-02f, -2.87711322e-02f, -3.70550752e-02f, -3.07960305e-02f, -3.59680392e-02f, -1.78592801e-02f, 5.01140319e-02f,
  3.73537503e-02f, 2.12553646e-02f, 2.14561671e-01f, 4.39060573e-03f, 3.57929394e-02f, 1.10038400e-01f, -9.51696374e-03f, -1.35000080e-01f, 2.32983120e-02f, 2.55774260e-01f,
  -5.18365145e-01f, -2.71377176e-01f, 1.90600857e-01f, 9.39897522e-02f, 4.11498964e-01f, -1.07926518e-01f, -4.96143728e-01f, -4.92334038e-01f, -2.37926692e-02f, -1.05687536e-01f,
  2.28465706e-01f, 3.74922901e-01f, 2.81758428e-01f, 1.94792166e-01f, -1.72350883e-01f, -1.59840494e-01f, 1.06826335e-01f, 6.62221089e-02f, -1.21503044e-02f, -5.00901975e-02f,
  1.48020580e-01f, 1.05642349e-01f, -1.50896171e-02f, -5.89741915e-02f, 4.07088213e-02f, 1.82098851e-01f, 1.34880245e-01f, 1.25083655e-01f, 8.77647847e-02f, 1.13236256e-01f,
  -1.09230325e-01f, -4.69223768e-01f, 9.69866756e-03f, 1.95699230e-01f, 2.52763450e-01f, -3.13777894e-01f, -2.61927664e-01f, -1.88329518e-01f, -4.76069786e-02f, -2.60349244e-01f,
  9.45319459e-02f, -2.59750132e-02f, 2.15976283e-01f, -2.45909244e-02f, -1.54116645e-01f, -1.87826991e-01f, -1.53723091e-01f, -2.81437814e-01f, -1.33388475e-01f, -2.55979955e-01f,
  1.88574448e-01f, 1.45777360e-01f, -3.84517610e-02f, -1.76548883e-01f, -2.78694630e-01f, 1.81204960e-01f, -2.23981962e-01f, -3.03943872e-01f, -2.74298519e-01f, -4.00667369e-01f,
  2.27817800e-02f, 5.62620685e-02f, -1.74432751e-02f, -6.92911372e-02f, -7.52893761e-02f, -5.11581218e-03f, 7.54627809e-02f, 7.51577094e-02f, 7.18036294e-02f, 1.26475329e-02f,
  1.02575198e-01f, 7.15727359e-02f, -1.89545862e-02f, -1.70232922e-01f, 6.17687069e-02f, -2.44675344e-03f, -3.82933281e-02f, -5.73503003e-02f, 5.54907247e-02f, -1.03551038e-01f,
  -2.50833128e-02f, 3.18071246e-02f, 8.58062655e-02f, -1.36118308e-01f, -8.86373669e-02f, -1.85691528e-02f, -1.34480596e-01f, -5.32862097e-02f, 1.63914356e-02f, -8.80464017e-02f,
  -1.51161939e-01f, 1.77959785e-01f, -1.18185855e-01f, -1.04534455e-01f, 1.16459906e-01f, 3.84619124e-02f, 2.71450281e-02f, 5.07197008e-02f, 4.60271686e-02f, -5.43309078e-02f,
  -2.58692116e-01f, -4.81428728e-02f, 2.99797170e-02f, 1.31381759e-02f, -1.24069735e-01f, -2.03521326e-02f, 1.13855913e-01f, 1.32854953e-01f, 1.66187230e-02f, -2.32627336e-02f,
  -4.11976054e-02f, -2.21396014e-01f, -1.15751155e-01f, -1.06854782e-01f, -8.23597461e-02f, 3.95418555e-02f, -1.72153726e-01f, -1.38374701e-01f, -1.28836006e-01f, -4.44781780e-01f,
  1.17540792e-01f, 2.00176761e-01f, 3.90380800e-01f, -1.01894878e-01f, -5.26421554e-02f, -2.10246637e-01f, -2.92477846e-01f, -1.59444466e-01f, -1.08335866e-02f, 8.78632739e-02f,
  -3.44586708e-02f, -1.87633991e-01f, 4.75969240e-02f, -8.54548067e-02f, -1.94988817e-01f, 2.48896461e-02f, 2.08257928e-01f, 1.19157225e-01f, -2.87152022e-01f, -3.52152139e-01f,
  -2.92335004e-01f, -1.08139060e-01f, 5.46249487e-02f, -3.05108950e-02f, 2.73387581e-01f, -3.15771922e-02f, 3.51248354e-01f, 1.97301254e-01f, 1.65332109e-01f, 4.63717848e-01f,
  3.01709533e-01f, 3.48863095e-01f, -2.18105718e-01f, -1.30654559e-01f, -7.12212995e-02f, 7.16329142e-02f, 7.82145783e-02f, 5.31473756e-02f, -7.42108449e-02f, 1.36818603e-01f,
  -1.08069912e-01f, 6.15999056e-03f, 5.21259084e-02f, -6.32136911e-02f, -7.98401423e-03f, -2.36277267e-01f, 6.92232326e-02f, -6.48668706e-02f, 5.83423749e-02f, 1.12664038e-02f,
  -2.01484904e-01f, -8.22330862e-02f, 1.05923340e-01f, -2.50831898e-02f, 8.21590275e-02f, -1.02954186e-01f, 8.16447139e-02f, 7.83699676e-02f, 2.16508061e-02f, 3.39984357e-01f,
  -4.25678752e-02f, 8.35898146e-03f, 4.81555704e-04f, 1.51607156e-01f, -1.79911479e-01f, 8.73586237e-02f, 1.25339761e-01f, -8.94942656e-02f, 2.20424403e-02f, 1.78388227e-02f,
  3.85569669e-02f, 8.04666206e-02f, 6.28798902e-02f, 4.92117740e-02f, 2.70825792e-02f, 3.31114642e-02f, -5.59902862e-02f, -1.41755752e-02f, 8.35559070e-02f, -1.05896546e-02f,
  -1.20760642e-01f, -1.98579151e-02f, -1.51480790e-02f, -4.90213595e-02f, 6.42734617e-02f, -1.06772489e-03f, -8.75962004e-02f, -1.16001919e-01f, 2.77486313e-02f, 9.23042521e-02f,
  -1.26962990e-01f, -2.62953401e-01f, -1.28583834e-02f, -6.74562454e-02f, 4.41306047e-02f, 1.98789835e-02f, 4.96077649e-02f, -7.15840533e-02f, -1.72638930e-02f, 7.30989650e-02f,
  8.81036802e-04f, -2.85570025e-02f, 1.11397170e-01f, -1.32315710e-01f, -1.26946121e-01f, -6.90190941e-02f, -8.01758617e-02f, -1.80039048e-01f, -1.83351159e-01f, -6.82601631e-02f,
  -1.33883521e-01f, -4.19743121e-01f, -3.54991227e-01f, -1.89533219e-01f, -5.13082519e-02f, -3.02044362e-01f, -8.78491551e-02f, -1.18520826e-01f, -3.37528318e-01f, -1.69050902e-01f,
  7.34871686e-01f, -3.48864645e-01f, -7.84882903e-01f, 3.03973466e-01f, 8.74512941e-02f, -1.12120956e-01f, -3.03294182e-01f, 7.41021782e-02f, 3.46649319e-01f, -1.76211029e-01f,
  -2.87436247e-01f, 9.33910348e-03f, -2.92065829e-01f, -2.91601896e-01f, -3.58195394e-01f, -5.44857502e-01f, -4.16582316e-01f, -3.33427906e-01f, 1.14386208e-01f, 4.09842670e-01f,
  3.64400297e-01f, 4.23801959e-01f, 2.74055779e-01f, -2.38709804e-02f, 6.24011494e-02f, 2.27856301e-02f, -4.47202623e-01f, -6.19986504e-02f, -2.82247692e-01f, -3.62583160e-01f,
  -3.48558515e-01f, -1.66099384e-01f, -1.72233775e-01f, 7.85222575e-02f, -2.65189391e-02f, 7.75044039e-02f, -8.01927522e-02f, 2.43054666e-02f, -3.37451845e-02f, -1.75507650e-01f,
  -1.00953281e-01f, 6.54188357e-03f, -1.28150642e-01f, 6.12951368e-02f, 1.94847286e-02f, 4.13735770e-02f, 2.16989368e-02f, -1.44107237e-01f, -1.04506530e-01f, -7.54548088e-02f,
  -3.97772342e-02f, -7.56090730e-02f, -1.57640040e-01f, -1.70927405e-01f, -1.82113141e-01f, -6.84298798e-02f, -1.69499308e-01f, -3.87875363e-02f, -1.96926668e-01f, 2.16562655e-02f,
  1.36410939e-02f, -2.84423716e-02f, 4.58508767e-02f, 7.99402148e-02f, 2.02932581e-01f, -1.00106195e-01f, -1.02730677e-01f, -2.44081598e-02f, -5.15845884e-03f, -6.56803772e-02f,
  -7.92486891e-02f, -1.43483430e-01f, 3.60599980e-02f, -7.19726533e-02f, -1.29118875e-01f, -2.06933264e-02f, -2.63937023e-02f, -2.78063379e-02f, -1.29666487e-02f, 5.83500117e-02f,
  -1.66243147e-02f, -4.56729792e-02f, 8.74120742e-02f, 3.24589796e-02f, -6.79491088e-02f, -2.14095458e-01f, 3.78904827e-02f, -1.82104460e-03f, 1.05553471e-01f, 3.61720589e-03f,
  2.65931934e-01f, -2.93351889e-01f, -5.16554937e-02f, -7.32196718e-02f, -9.08888429e-02f, -5.35139330e-02f, -1.42584637e-01f, 1.56158535e-02f, -1.55896083e-01f, 3.99273448e-02f,
  -1.55882120e-01f, -1.09622560e-01f, -1.71105072e-01f, 8.07765201e-02f, 1.01797991e-02f, 3.68200801e-02f, 2.19024345e-02f, -8.91582221e-02f, -3.31577729e-03f, 3.25118780e-01f,
  4.97909449e-02f, 1.29950240e-01f, 2.57399023e-01f, 6.40090033e-02f, 9.56364870e-02f, 1.55779466e-01f, -4.43626568e-02f, 6.16632998e-02f, -6.64751083e-02f, 2.46918648e-01f,
  6.97800424e-03f, 9.13823396e-02f, 2.19987631e-01f, -1.73047736e-01f, 1.04896538e-01f, 3.00860733e-01f, 6.70684636e-01f, 1.84326708e-01f, -1.53831184e-01f, 3.60904038e-01f,
  1.80348098e-01f, -4.43972230e-01f, -3.89930695e-01f, -2.68160343e-01f, 2.74198223e-02f, 3.68980139e-01f, 1.46274239e-01f, -5.08178435e-02f, -1.47141784e-01f, 1.49773821e-01f,
  1.12608619e-01f, 5.94064146e-02f, -3.01667955e-02f, -1.34792760e-01f, -1.42320439e-01f, -2.28481337e-01f, 1.00438491e-01f, 5.55617586e-02f, 1.48261771e-01f, -2.11712480e-01f,
  -2.06519455e-01f, 1.29868031e-01f, 7.07079247e-02f, -1.08351074e-01f, 1.53066721e-02f, -5.73234931e-02f, -1.07515650e-02f, -1.69412717e-01f, -1.24025851e-01f, 4.77444287e-03f,
  -1.21750496e-01f, -7.78151304e-02f, -1.38919696e-01f, -8.04762319e-02f, -8.60423446e-02f, -3.04984655e-02f, -7.69749954e-02f, -1.28759056e-01f, -3.58103395e-01f, -1.21169358e-01f,
  -1.58756629e-01f, 5.82458153e-02f, -1.17830141e-03f, 1.16110459e-01f, -1.11282520e-01f, -1.09961659e-01f, -1.45149818e-02f, -1.35023192e-01f, 2.81719472e-02f, -1.53372049e-01f,
  1.82108302e-02f, 1.96155664e-02f, 1.29829012e-02f, 5.41889109e-02f, -6.42709201e-03f, 1.55714089e-02f, -1.95920959e-01f, -1.15675502e-01f, 6.35206103e-02f, 7.28551671e-02f,
  -4.93147485e-02f, 2.84497887e-01f, -1.10654831e-02f, 4.57437448e-02f, -1.11457631e-01f, 1.53779894e-01f, 1.89118430e-01f, -4.73094396e-02f, -5.17759882e-02f, 1.58858255e-01f,
  3.73471193e-02f, 1.96732327e-01f, -4.50216345e-02f, -5.98104149e-02f, 5.62249273e-02f, -7.87403286e-02f, -3.56024317e-02f, -4.26187925e-02f, 1.17539559e-02f, 2.33471870e-01f,
  -2.61734337e-01f, 2.98175216e-01f, -1.73096746e-01f, 2.02433504e-02f, 4.89651114e-02f, -1.76404845e-02f, 2.24863589e-02f, -6.21508388e-03f, 8.88437703e-02f, 3.11782286e-02f,
  5.75620867e-02f, -2.21897423e-01f, -6.69091865e-02f, -3.05526946e-02f, 3.99065353e-02f, -2.73681637e-02f, 1.35721728e-01f, 3.37287523e-02f, -6.27482459e-02f, -8.18258673e-02f,
  -9.91614982e-02f, 2.00274423e-01f, 1.68136388e-01f, 6.41891584e-02f, -1.14961043e-01f, -5.21034375e-02f, 1.30329486e-02f, 5.01040369e-03f, 1.52633056e-01f, 2.02336967e-01f,
  -3.90110612e-01f, 7.99279138e-02f, -1.59209311e-01f, -2.30911270e-01f, -5.99100217e-02f, 8.09586719e-02f, 1.11636616e-01f, 1.37739718e-01f, 1.13224454e-01f, 4.38419655e-02f,
  7.20724612e-02f, -1.51590765e-01f, -2.08839819e-01f, -1.00132167e-01f, -1.39623985e-01f, -6.14955090e-02f, -2.29524389e-01f, -3.31678569e-01f, -1.38101414e-01f, 1.51552677e-01f,
  5.00747897e-02f, -2.05112115e-01f, -2.88868964e-01f, -1.41632155e-01f, -6.26391917e-02f, -2.10975885e-01f, -2.53422320e-01f, -1.95899993e-01f, -1.43866345e-01f, -2.19002500e-01f,
  -2.37981733e-02f, 7.17663905e-03f, 1.59171388e-01f, 4.29803431e-02f, 7.43920952e-02f, 1.60821043e-02f, 4.45460342e-02f, -4.05777507e-02f, 2.53047887e-02f, 3.98544222e-02f,
  9.87085141e-03f, 2.25749388e-01f, -1.80536229e-02f, 7.74526969e-02f, 4.13234606e-02f, 2.34729890e-02f, 1.85838323e-02f, -3.90639156e-03f, -2.49364134e-02f, 1.02891877e-01f,
  2.27570031e-02f, -1.62846312e-01f, -2.95878857e-01f, 9.08343703e-04f, 6.32892773e-02f, -1.75595552e-01f, 5.51797170e-03f, 6.70710579e-02f, -1.41945615e-01f, -1.37141824e-01f,
  8.75154063e-02f, 2.43072566e-02f, 2.16247752e-01f, 1.24288842e-01f, 1.72588639e-02f, 3.60711887e-02f, -9.08252895e-02f, 2.36377586e-02f, -2.39917580e-02f, 9.36846342e-03f,
  -4.87894192e-02f, -5.49912043e-02f, -5.46081550e-02f, 2.16256026e-02f, -1.99809417e-01f, -2.44619176e-02f, -8.56916904e-02f, -3.27254720e-02f, -2.53608823e-01f, -1.36602893e-02f,
  1.18655125e-02f, 2.67980434e-02f, 7.24252090e-02f, -1.73521659e-03f, 7.84209520e-02f, 3.43957283e-02f, 9.69780087e-02f, 1.43767402e-01f, 1.31566003e-01f, 1.24507561e-01f,
  -1.40245035e-01f, 8.02669227e-02f, -1.16528444e-01f, 1.50684163e-01f, -1.52258547e-02f, 1.16376884e-01f, -4.74157780e-02f, 8.18031803e-02f, -9.47595388e-02f, 4.08656187e-02f,
  1.71371713e-01f, 4.95894961e-02f, 3.32771661e-03f, 1.38040632e-01f, 4.00073379e-02f, -2.58087385e-02f, -4.28628922e-02f, -1.70897841e-01f, -6.48022145e-02f, 5.58764972e-02f,
  -1.22257032e-01f, -2.35665590e-01f, -3.21481675e-01f, -2.72308081e-01f, -7.66716599e-02f, -3.63447905e-01f, -2.34576687e-01f, -5.11309206e-02f, -2.81179935e-01f, -2.92807192e-01f,
  3.56485359e-02f, -6.25085771e-01f, 3.08554947e-01f, -1.18162088e-01f, -6.19452372e-02f, -1.00570984e-01f, -2.67987311e-01f, -2.99637377e-01f, -2.01799542e-01f, -3.00572246e-01f,
  -1.52147815e-01f, 1.38432339e-01f, 2.81752467e-01f, 1.15987793e-01f, -4.08609491e-03f, -1.81115538e-01f, 9.84290801e-03f, 3.99012059e-01f, 4.09989357e-01f, 9.30419657e-03f,
  -1.95058659e-01f, -1.41694918e-01f, 8.12252611e-03f, 2.68255007e-02f, -1.89854994e-01f, 7.00544640e-02f, 4.06889468e-02f, -1.13270521e-01f, -1.55266166e-01f, -1.23423144e-01f,
  1.89258233e-01f, -1.63722649e-01f, 9.20377448e-02f, -1.24379702e-01f, -9.37079173e-03f, -2.89403498e-02f, 1.01848214e-03f, 5.04874438e-03f, -6.90324530e-02f, -9.98474285e-02f,
  -6.37747720e-02f, -1.18890395e-02f, 6.42469898e-02f, -6.50775656e-02f, -5.90972602e-02f, -6.66971430e-02f, -7.97299370e-02f, -9.16712731e-02f, -9.95455496e-03f, -1.05726160e-01f,
  -1.63486078e-01f, -3.82874757e-02f, -9.73660685e-03f, -2.07251199e-02f, -9.75923687e-02f, 7.19684213e-02f, 3.28046246e-03f, 9.68177523e-03f, 1.70017462e-02f, -1.90988541e-01f,
  4.60970029e-02f, -1.19690932e-01f, -1.08115179e-02f, 6.21441118e-02f, 6.21207394e-02f, -5.50939664e-02f, 6.02066554e-02f, -3.97505388e-02f, 7.28632603e-03f, -9.04908925e-02f,
  -7.23781884e-02f, 3.15104499e-02f, 5.96387647e-02f, -1.64446279e-01f, -5.26070595e-02f, -5.13986237e-02f, -1.38526792e-02f, -1.10959336e-01f, 1.73858777e-02f, -8.23627040e-02f,
  -7.92191103e-02f, -7.95282237e-03f, -8.93731937e-02f, -2.91600544e-02f, -1.29037395e-01f, -2.68776827e-02f, -3.14239897e-02f, 8.44223611e-03f, -1.42020285e-02f, -7.52585158e-02f,
  -3.27029191e-02f, 2.88871199e-01f, 1.10385694e-01f, 4.65895468e-03f, -2.93342099e-02f, -2.34084390e-02f, 1.26096681e-01f, -7.62538612e-02f, 5.86954691e-02f, 5.93798459e-02f,
  8.54680613e-02f, -2.99537904e-03f, 2.40525324e-02f, 4.70542572e-02f, 1.17450133e-01f, 1.02218859e-01f, -1.26042351e-01f, 6.10006042e-02f, -9.14571167e-04f, -1.73433542e-01f,
  -1.90000072e-01f, -1.30454088e-02f, 1.66047245e-01f, 9.23536941e-02f, -2.14350875e-02f, 3.03649217e-01f, 1.03374436e-01f, 1.56486735e-01f, 1.76321000e-01f, -5.18242642e-02f,
  5.41937292e-01f, 3.64607155e-01f, 1.37658194e-01f, -2.55224388e-02f, -3.56087685e-01f, -2.11256802e-01f, -5.48796728e-02f, -2.93541029e-02f, 3.16136777e-02f, 1.17526859e-01f,
  -1.45439878e-01f, -7.65751377e-02f, 4.01712097e-02f, 3.05402791e-03f, 2.02540651e-01f, 1.33290663e-01f, 1.02123596e-01f, 1.86920226e-01f, 7.39442706e-02f, -4.22696117e-03f,
  6.13350384e-02f, 1.16103403e-01f, 1.35265768e-01f, 1.88467503e-01f, 3.61615345e-02f, -1.20833568e-01f, 2.11930647e-02f, 4.23561707e-02f, 5.46621047e-02f, 2.74325430e-01f,
  7.38986731e-02f, 1.93669587e-01f, -1.21554859e-01f, -1.37171060e-01f, -1.07586328e-02f, 9.43780169e-02f, 5.59250936e-02f, -4.24564928e-02f, -1.48242965e-01f, -2.71062534e-02f,
  -3.29147615e-02f, 2.29101367e-02f, -5.16058784e-03f, -9.24905166e-02f, -1.07734390e-01f, -3.26929800e-02f, -1.39705893e-02f, -4.34753411e-02f, -4.89795431e-02f, -7.72852898e-02f,
  -6.81048185e-02f, -4.73676696e-02f, -7.95674473e-02f, -1.73622102e-01f, 2.08466873e-02f, -1.22971214e-01f, -1.73050940e-01f, -9.92419720e-02f, -1.39224306e-02f, 6.68914840e-02f,
  -6.82103336e-02f, 1.39286011e-01f, 5.95160648e-02f, -9.43071581e-03f, 5.50456941e-02f, 5.58034927e-02f, -6.74917400e-02f, 4.13689613e-02f, 3.50688510e-02f, -1.12059833e-02f,
  -3.83466743e-02f, -7.05267712e-02f, 3.91958840e-02f, -4.12542708e-02f, 4.86449301e-02f, 6.49800226e-02f, 2.86444817e-02f, 8.48511383e-02f, -6.84305802e-02f, -2.62797456e-02f,
  -4.94647957e-02f, 4.40380163e-02f, -7.86580890e-02f, 1.07773602e-01f, -9.89492387e-02f, 6.64348854e-03f, -3.75677533e-02f, -1.17908940e-01f, 8.52074381e-03f, 1.58836953e-02f,
  -3.28485042e-01f, -2.04152137e-01f, 3.94118503e-02f, 1.72488257e-01f, 5.54258078e-02f, -5.08252205e-03f, 9.28688496e-02f, 1.71988923e-02f, -8.77868310e-02f, -4.54405136e-02f,
  4.20387760e-02f, 8.32600892e-02f, 4.32043746e-02f, 4.21206169e-02f, -5.48986681e-02f, -8.21039379e-02f, 5.28596677e-02f, 5.01233675e-02f, 3.46430875e-02f, -4.99141812e-02f,
  -8.87489766e-02f, -1.90543428e-01f, -1.79240525e-01f, -1.43179670e-01f, -6.45236392e-03f, -1.67585835e-01f, -1.17461458e-01f, -9.52012539e-02f, -1.14885412e-01f, -1.56305879e-01f,
  2.97366619e-01f, 2.22352311e-01f, 2.49259934e-01f, 6.80870516e-03f, 3.63544077e-02f, -6.91591203e-02f, -1.70650765e-01f, -1.13717288e-01f, -1.82973042e-01f, -8.68103132e-02f,
  4.22855392e-02f, -1.34473175e-01f, -1.12414300e-01f, -1.60193920e-01f, -1.42957214e-02f, -9.32748094e-02f, 3.87920327e-02f, 2.98362881e-01f, 2.29920268e-01f, 1.13739990e-01f,
  9.18573663e-02f, 3.48452687e-01f, 4.37194347e-01f, 1.98911712e-01f, 7.63000473e-02f, 4.19718660e-02f, 1.97762981e-01f, 2.33772725e-01f, 1.21355064e-01f, 2.35938668e-01f,
  2.53769726e-01f, 1.90408528e-01f, -1.65193722e-01f, 9.19644814e-03f, 1.50399268e-01f, 1.09467441e-02f, 2.17087250e-02f, 7.02916086e-02f, -2.30421517e-02f, -3.60483467e-03f,
  1.36275887e-01f, 9.00269523e-02f, -5.10930605e-02f, 5.65707199e-02f, 5.79587556e-02f, 4.67714742e-02f, 6.18994981e-02f, 2.80278213e-02f, -1.73886865e-01f, -6.24533668e-02f,
  -3.12231723e-02f, 2.14840934e-01f, 1.20511048e-01f, -1.47949561e-01f, -1.46063581e-01f, -1.13347284e-01f, 5.16821668e-02f, -6.71128482e-02f, -7.30048791e-02f, -1.20791130e-01f,
  -1.67295918e-01f, 7.75381178e-02f, 1.15155429e-01f, -5.63147739e-02f, -5.79651296e-02f, -1.66494176e-02f, -1.34938275e-02f, -2.71789953e-02f, -3.14632128e-03f, 8.85154158e-02f,
  -8.61508995e-02f, -9.80263427e-02f, -5.52208908e-02f, -1.55417835e-02f, -8.69994704e-03f, 1.19157687e-01f, 3.66015434e-02f, -2.06275135e-02f, -1.95126031e-02f, -4.87084240e-02f,
  -2.13388354e-02f, -4.22660187e-02f, 6.78420290e-02f, 1.27927575e-03f, -4.21371646e-02f, -7.43671358e-02f, 1.87587109e-03f, -1.42849535e-02f, 1.93362534e-02f, 6.94878325e-02f,
  -6.10693581e-02f, 3.33314836e-02f, -1.71474755e-01f, -4.29570600e-02f, 5.92297725e-02f, 1.74232684e-02f, -1.34536892e-01f, 6.17887639e-03f, -5.97763201e-03f, -7.42690042e-02f,
  1.32871211e-01f, -1.24797568e-01f, 5.72148710e-02f, -9.36733186e-03f, 5.23895137e-02f, -4.34402227e-02f, -7.14020990e-03f, -1.15574181e-01f, -1.14057355e-01f, 8.90640095e-02f,
  -1.17264442e-01f, -8.59149620e-02f, -2.13505968e-01f, -3.83385032e-01f, -3.17531079e-01f, -3.04734319e-01f, -1.59132063e-01f, -1.42805114e-01f, -7.62698352e-02f, -2.58664459e-01f,
  -2.07077861e-01f, -2.22242504e-01f, 2.42166683e-01f, -6.24199323e-02f, 9.15040150e-02f, 1.10934705e-01f, 1.35496512e-01f, 7.79050961e-02f, -2.19115261e-02f, 6.06106631e-02f,
  -2.26425961e-01f, -3.31001490e-01f, -1.53428569e-01f, -2.66166121e-01f, -1.25603572e-01f, 2.75026917e-01f, 1.52894184e-01f, -2.48154327e-02f, 7.19383955e-02f, 1.09036472e-02f,
  -1.84523016e-02f, 2.02537999e-02f, -7.46061802e-02f, -9.56211463e-02f, 6.24301319e-04f, -5.63579053e-02f, 3.50425504e-02f, -6.29532784e-02f, -1.23948708e-01f, 1.18645258e-01f,
  2.46346161e-01f, -3.00175518e-01f, 2.76817884e-02f, -3.00343990e-01f, -4.41750772e-02f, -1.23914313e-02f, -3.74430530e-02f, -1.11413576e-01f, -6.43334091e-02f, 9.71800927e-03f,
  -1.03788182e-01f, -1.43910751e-01f, -4.59455624e-02f, -7.51182139e-02f, 1.18244141e-02f, 3.76178441e-03f, -9.99018326e-02f, -2.38167513e-02f, -6.00985698e-02f, -8.32933038e-02f,
  -1.18304715e-01f, -1.05647564e-01f, -8.39160848e-03f, -5.09513766e-02f, -1.04583502e-01f, -1.56235784e-01f, -8.68906602e-02f, -1.31487295e-01f, -7.08672404e-02f, 2.05267414e-01f,
  1.29842818e-01f, 1.38258532e-01f, -4.41295579e-02f, 6.95131645e-02f, -1.23373447e-02f, 9.79379863e-02f, 2.10548434e-02f, -8.43326524e-02f, 1.06648117e-01f, 1.82470325e-02f,
  -2.83675026e-02f, 6.93318769e-02f, 2.78490148e-02f, 1.11533687e-01f, -1.52309751e-02f, -3.03831398e-02f, -4.14986610e-02f, 1.58187244e-02f, -7.43817240e-02f, -1.55014426e-01f,
  -2.78882626e-02f, 5.63847758e-02f, 2.32857950e-02f, 2.67133042e-02f, -2.56488025e-02f, -8.89094993e-02f, 4.38162610e-02f, 2.09262632e-02f, -5.81853800e-02f, 9.18870419e-02f,
  9.55188870e-02f, -3.34384739e-01f, 1.44532308e-01f, 6.79600565e-03f, 4.11554910e-02f, -2.81017995e-03f, -6.52571246e-02f, 4.34900960e-03f, 4.51280223e-03f, 2.18739398e-02f,
  -1.60262480e-01f, 3.13316099e-02f, -8.04129243e-02f, -2.70032939e-02f, 7.69361556e-02f, -1.27054704e-02f, -7.15054348e-02f, -5.28273731e-02f, -4.34148833e-02f, 1.11367725e-01f,
  1.45653831e-02f, 1.08537272e-01f, 1.27506211e-01f, 1.72099516e-01f, -3.05819754e-02f, 9.91114303e-02f, 2.27742165e-01f, 6.69620931e-02f, 1.38109326e-01f, 4.05804902e-01f,
  6.96595311e-01f, -3.35545063e-01f, -2.08416954e-01f, 2.20098883e-01f, 7.81174153e-02f, -7.55669102e-02f, -2.55078733e-01f, -8.61516893e-02f, 1.36040017e-01f, 1.12718292e-01f,
  1.83361948e-01f, 3.09366941e-01f, 1.67497143e-01f, 4.61091027e-02f, 5.89730516e-02f, -1.62714407e-01f, -5.82678430e-02f, 1.58494383e-01f, 2.28099018e-01f, 7.89493229e-03f,
  2.89847292e-02f, 7.35092089e-02f, 1.71815291e-01f, 4.57382835e-02f, -1.49384394e-01f, 2.14785218e-01f, -8.88845697e-02f, 4.73143905e-02f, -3.73691358e-02f, -8.91627967e-02f,
  -1.38787597e-01f, -4.29939106e-02f, 1.81046709e-01f, 6.33062124e-02f, -6.85600191e-02f, -4.32890244e-02f, -2.26682555e-02f, -1.40633047e-01f, -9.28026214e-02f, -7.76915923e-02f,
  5.21678058e-03f, 1.15668867e-02f, 5.83921000e-02f, -1.09348394e-01f, 2.22285818e-02f, -1.83764729e-03f, 4.81986776e-02f, -6.02576621e-02f, -7.48377517e-02f, -3.88780534e-02f,
  6.27795383e-02f, 3.23395655e-02f, -1.13835730e-01f, -1.05718318e-02f, 8.19248036e-02f, 2.07362249e-01f, -1.09650142e-01f, -2.90393513e-02f, 2.83075683e-02f, 5.83493784e-02f,
  3.11985165e-01f, 1.99167177e-01f, 2.26611584e-01f, 1.42466858e-01f, 1.53473139e-01f, -5.85584342e-02f, 3.00058927e-02f, -1.05481885e-01f, 1.82394013e-01f, 8.23386386e-02f,
  -7.20878839e-02f, 3.86557095e-02f, -1.84333816e-01f, -1.27642520e-03f, 1.46954194e-01f, 9.09571648e-02f, -1.05886571e-01f, -4.61058915e-02f, 9.23103318e-02f, 7.46000558e-02f,
  2.01608300e-01f, -4.82347719e-02f, 1.19421452e-01f, -1.71482280e-01f, -5.87943569e-03f, 5.31436503e-02f, 1.82554364e-01f, 1.46296382e-01f, 9.24534574e-02f, 5.46451584e-02f,
  2.75504366e-02f, 2.99448639e-01f, 1.96002290e-01f, -9.50864106e-02f, 1.31017603e-02f, 7.70290196e-02f, 2.33083945e-02f, -5.55510214e-03f, -2.17678159e-01f, -1.49215892e-01f,
  -3.58940102e-02f, 1.96178555e-02f, -8.05144981e-02f, 4.28087078e-02f, 1.18951701e-01f, -3.55379507e-02f, 1.38851911e-01f, 1.73124857e-02f, -1.36993974e-01f, -1.55156568e-01f,
  -3.07522179e-03f, 4.95597022e-03f, 5.17253950e-02f, 1.22911550e-01f, 4.43912260e-02f, 2.49591872e-01f, 4.41027395e-02f, 3.74319553e-02f, 3.31413373e-02f, 4.03286815e-02f,
  3.53375673e-01f, -1.13808468e-01f, 3.14256817e-01f, 2.55161896e-03f, -2.46600106e-01f, -3.74445140e-01f, -5.05407393e-01f, -2.73834199e-01f, -1.33811265e-01f, -4.25832383e-02f,
  1.00796577e-02f, 3.05652559e-01f, 4.16248560e-01f, 1.57349065e-01f, 1.13525920e-01f, 6.31651804e-02f, 1.16464775e-02f, 1.25952989e-01f, -1.32578641e-01f, -3.65717083e-01f,
  -2.59233326e-01f, -4.87188026e-02f, 4.28795405e-02f, -4.01716083e-02f, -1.46585554e-02f, 3.67738195e-02f, 1.78340986e-01f, -7.92897046e-02f, -6.96431324e-02f, 2.32059747e-01f,
  4.98984843e-01f, -1.81234151e-01f, 8.52259025e-02f, -1.58018708e-01f, -1.11039892e-01f, -5.30519173e-04f, -2.97394618e-02f, 7.93642104e-02f, -1.47762701e-01f, -1.09650098e-01f,
  -3.38150561e-02f, -1.48686439e-01f, -1.02470838e-01f, -4.03826982e-02f, -6.29900694e-02f, -1.17697500e-01f, -4.90989238e-02f, -1.42558545e-01f, -5.88483959e-02f, -2.71309968e-02f,
  -9.96066779e-02f, -1.95300594e-01f, 8.39576200e-02f, -1.10086100e-02f, -1.40271699e-02f, 9.68268365e-02f, -1.71297882e-02f, -1.50190517e-01f, -6.99218689e-03f, 1.36274537e-02f,
  -5.11455461e-02f, 2.19113737e-01f, 3.01835053e-02f, -3.05505972e-02f, -4.39797789e-02f, -3.12822573e-02f, -7.42820054e-02f, -9.09781232e-02f, 7.46314824e-02f, 4.26921286e-02f,
  -6.45365492e-02f, -4.59795110e-02f, -1.03149883e-01f, -1.08340122e-01f, 9.23558250e-02f, 5.06386198e-02f, 3.36473458e-03f, 2.18367688e-02f, 7.21103698e-02f, 3.28608565e-02f,
  4.77599017e-02f, 1.92279369e-02f, 3.97944152e-02f, -5.17031290e-02f, -1.39677078e-02f, -5.25725409e-02f, 3.51987518e-02f, 3.70005965e-02f, 3.10559571e-02f, -1.97494566e-01f,
  3.21124583e-01f, -1.90016568e-01f, 3.47948402e-01f, -8.54775384e-02f, -1.20979510e-01f, -2.20543712e-01f, 8.32976326e-02f, -1.41592607e-01f, -8.00283700e-02f, 3.93776819e-02f,
  -1.01310305e-01f, -1.12845805e-02f, 1.01816364e-01f, -6.35167956e-02f, -1.29837543e-01f, -1.60986871e-01f, -6.93567395e-02f, -3.39248031e-02f, -8.15981850e-02f, -1.10366419e-01f,
  -1.16178244e-02f, -1.96206093e-01f, 2.54633635e-01f, 1.10368848e-01f, -5.15088886e-02f, 1.08612955e-01f, 2.08131656e-01f, 6.88948482e-02f, 8.53519440e-02f, 1.63771976e-02f,
  5.41637182e-01f, -2.66345143e-01f, -3.59138757e-01f, 3.06400098e-02f, -3.15769196e-01f, -2.81515479e-01f, -3.72789204e-01f, -8.06922540e-02f, 1.29029170e-01f, -2.77362335e-02f,
  3.45126204e-02f, 3.61711025e-01f, 1.63880467e-01f, 1.89478323e-01f, 1.87383860e-01f, -1.96810320e-01f, -1.93877205e-01f, 1.68054715e-01f, 2.99089909e-01f, 4.66477722e-02f,
  -1.74576472e-02f, 5.80486953e-02f, 2.07972914e-01f, 1.22255206e-01f, -2.59566724e-01f, 1.20700985e-01f, -2.76204735e-01f, -1.29126266e-01f, -6.24567866e-02f, -1.16073631e-01f,
  4.03027311e-02f, 2.21955385e-02f, 1.15998052e-01f, 9.30599868e-02f, -6.16806298e-02f, 4.61382233e-02f, -5.98752908e-02f, -4.67878245e-02f, 3.28980498e-02f, -8.35489556e-02f,
  8.17441940e-03f, 8.16670731e-02f, 1.47432706e-03f, -3.84236313e-02f, -4.02443856e-02f, -4.45098840e-02f, -6.05353639e-02f, 1.69471148e-02f, 2.54357839e-03f, -1.14627950e-01f,
  -3.47874239e-02f, -9.31268185e-02f, 8.78718775e-03f, -1.17405884e-01f, -3.49407904e-02f, 1.54616356e-01f, -1.03135623e-01f, -9.31456313e-02f, -2.61363443e-02f, -6.99385628e-02f,
  1.54327061e-02f, 1.20233353e-02f, 2.43910756e-02f, -1.82770386e-01f, 1.00865752e-01f, -1.62338819e-02f, 1.91021655e-02f, 1.89116616e-02f, 2.84031611e-02f, -5.63466400e-02f,
  -7.81668723e-02f, 4.54776660e-02f, 4.11805324e-02f, -2.63167899e-02f, 7.08431676e-02f, -5.04310355e-02f, 1.40771307e-02f, 4.84630987e-02f, 4.51786183e-02f, 9.71916616e-02f,
  6.05364330e-02f, -5.48672192e-02f, -3.42881642e-02f, 4.72498164e-02f, 5.16236797e-02f, 2.23473553e-02f, 1.26755480e-02f, 5.58031313e-02f, 1.31637901e-01f, -6.94706663e-03f,
  4.86921184e-02f, 1.21295668e-01f, -3.32639888e-02f, 5.05830124e-02f, -1.45169914e-01f, -5.06980196e-02f, 2.47498006e-02f, -8.47041011e-02f, -7.55624250e-02f, -4.96283062e-02f,
  -8.29373603e-04f, -2.89934129e-02f, -1.22482674e-02f, 1.13351340e-03f, 3.69703732e-02f, 6.66699000e-03f, -3.25452676e-03f, 3.23127545e-02f, 2.48232037e-02f, -1.58352867e-01f,
  -1.61908060e-01f, 2.26576198e-02f, 6.98758755e-03f, -1.30982623e-01f, 3.42301875e-02f, 7.15002343e-02f, -1.79145738e-01f, -9.19597596e-02f, -6.97178300e-03f, -1.37369856e-01f,
  2.56294250e-01f, -1.77295595e-01f, 2.99323112e-01f, 2.93417871e-01f, 3.35128158e-01f, 3.63531470e-01f, 1.80088773e-01f, 1.04328677e-01f, 1.51076749e-01f, 4.83330376e-02f,
  -1.91720918e-01f, -1.93160817e-01f, 1.00823527e-03f, -9.35370252e-02f, -2.26576161e-02f, 2.34260082e-01f, 2.44014993e-01f, 1.63665384e-01f, 9.97835323e-02f, 1.11684598e-01f,
  -6.85297176e-02f, -1.83618702e-02f, -5.11020273e-02f, -7.26572275e-02f, -4.75552715e-02f, -2.70833187e-02f, -3.63530216e-06f, 2.20414763e-03f, -2.51669753e-02f, -8.55555236e-02f,
  -2.74088472e-01f, 3.81446257e-02f, -8.62544775e-02f, -2.32779309e-01f, -1.14427082e-01f, -1.12447210e-01f, -5.25166914e-02f, -1.18029840e-01f, -7.18872920e-02f, -3.08730938e-02f,
  -2.29571629e-02f, -3.34038474e-02f, 5.84235042e-02f, -1.70046668e-02f, 2.85588931e-02f, -1.67126171e-02f, -4.38676141e-02f, -6.81712180e-02f, -6.84573278e-02f, -9.96999666e-02f,
  -3.23985107e-02f, 6.48939982e-02f, 1.08138934e-01f, 1.03477918e-01f, 1.73793927e-01f, -1.75666399e-02f, -6.30010515e-02f, -5.46746925e-02f, -2.38150600e-02f, -1.38244048e-01f,
  -2.24718451e-01f, -1.82195544e-01f, -2.49888897e-02f, 4.01958004e-02f, 8.33983719e-02f, 3.50849219e-02f, 4.62165214e-02f, 1.42224021e-02f, -1.73186883e-02f, -1.26841456e-01f,
  -9.56500694e-02f, 7.20096305e-02f, 9.65752751e-02f, -9.91928652e-02f, -1.17915727e-01f, 1.74231306e-02f, 5.57740107e-02f, -1.35739788e-01f, -5.37395477e-02f, 3.80023010e-02f,
  -1.06433712e-01f, -3.02233212e-02f, -1.41186208e-01f, -1.22969270e-01f, -1.84720322e-01f, -1.46997832e-02f, -1.64697915e-01f, -1.38507545e-01f, -1.63467675e-01f, -1.82839185e-01f,
  -2.43388951e-01f, 1.81538776e-01f, -2.74418034e-02f, 1.93719729e-03f, -2.07158923e-02f, -9.44361687e-02f, 2.85723340e-02f, -9.47619155e-02f, 2.44330950e-02f, 9.73221287e-02f,
  -3.88676077e-02f, -2.71555055e-02f, 7.00898319e-02f, -6.54549375e-02f, 9.92197394e-02f, -4.74933945e-02f, -1.15166552e-01f, 1.20211869e-01f, 6.73610047e-02f, -4.74252887e-02f,
  2.73940153e-02f, 4.41209488e-02f, 2.02537686e-01f, 9.72964317e-02f, 1.34539232e-01f, 1.09525435e-01f, 3.78336920e-03f, 9.25199017e-02f, 8.15580711e-02f, 1.51182711e-02f,
  5.55402398e-01f, 5.34146726e-01f, -4.17916849e-02f, 2.58727446e-02f, 1.44779738e-02f, 2.21987683e-02f, 3.62983793e-01f, 3.11596870e-01f, 1.96688503e-01f, 1.92013845e-01f,
  3.64481449e-01f, 1.54943630e-01f, 2.86196262e-01f, 2.16357261e-01f, 2.22342223e-01f, 1.11999840e-01f, 8.30160007e-02f, -7.57368654e-02f, -6.07406460e-02f, 3.95078659e-02f,
  1.33625522e-01f, 1.03323907e-01f, 1.44050017e-01f, 1.48594812e-01f, -1.52830752e-02f, 7.82463923e-02f, 5.57507724e-02f, 8.96918476e-02f, 9.17077363e-02f, 5.00563309e-02f,
  -3.54002118e-01f, 1.47486001e-01f, -1.13534920e-01f, 9.05538648e-02f, -1.24956081e-02f, 1.12524062e-01f, -2.04191972e-02f, -5.28540947e-02f, 2.56613716e-02f, 2.73027476e-02f,
  -1.76639762e-02f, 1.39799379e-02f, -1.19424775e-01f, 7.18970550e-03f, -6.42982945e-02f, 1.61066446e-02f, 8.74251053e-02f, 2.57262196e-02f, 6.15808070e-02f, 2.94949207e-02f,
  8.43166113e-02f, -1.64797217e-01f, -9.03674662e-02f, -1.74131189e-02f, -6.67590946e-02f, -4.08516750e-02f, -2.24331915e-02f, -2.18123887e-02f, 5.50097898e-02f, 3.97876166e-02f,
  1.09529421e-01f, 1.28170535e-01f, -1.03332587e-01f, -1.21131487e-01f, -1.75522178e-01f, -7.29480460e-02f, 2.05271468e-02f, -3.70379463e-02f, -4.98492084e-03f, 1.51385469e-02f,
  1.86801946e-03f, -1.14312947e-01f, -9.46190879e-02f, -5.39250784e-02f, -7.08422735e-02f, 6.49349689e-02f, -4.67589796e-02f, -6.17671981e-02f, -1.91550940e-01f, -3.12061813e-02f,
  -1.77355528e-01f, 4.24814075e-02f, 1.30668923e-01f, -6.24754503e-02f, -2.38067657e-02f, -3.23941521e-02f, -6.07209560e-03f, 7.29066283e-02f, 7.36709461e-02f, 1.13302484e-01f,
  1.45404249e-01f, -3.27598363e-01f, -2.03448623e-01f, 3.46904062e-02f, -7.03640580e-02f, 8.98326635e-02f, -1.57556713e-01f, -1.47279993e-01f, -5.26846647e-02f, -1.16459332e-01f,
  4.93727093e-05f, -1.58713292e-02f, -1.47525603e-02f, -1.65957790e-02f, -1.58713162e-01f, -5.96031360e-02f, 8.87792408e-02f, -4.63149324e-02f, 1.29477739e-01f, 6.00127839e-02f,
  1.01047911e-01f, 2.30702516e-02f, 1.06431004e-02f, -5.75133227e-02f, -1.34049520e-01f, -2.97674090e-02f, -1.81215387e-02f, -1.22453071e-01f, -2.39139311e-02f, 1.82584479e-01f,
  2.23483741e-01f, -8.68282095e-02f, 2.45460612e-03f, 3.37089598e-01f, -8.88332445e-03f, 1.08306691e-01f, 7.87951425e-02f, 2.16623515e-01f, 1.59955919e-01f, 1.41643047e-01f,
  -1.37231365e-01f, -2.03943234e-02f, 2.53870785e-02f, -1.85683407e-02f, 1.13257706e-01f, 2.48199850e-01f, 2.49171928e-01f, 1.00033626e-01f, 6.90071210e-02f, -3.97355780e-02f,
  1.03176303e-01f, 1.03453785e-01f, 5.76506294e-02f, 6.99129142e-03f, 1.38876453e-01f, 1.61250785e-01f, -2.97768861e-02f, -1.31046340e-01f, -7.21151158e-02f, 2.64302552e-01f,
  -1.07775904e-01f, -3.59056503e-01f, 1.13827132e-01f, -1.52832717e-01f, -1.81836575e-01f, 5.58623709e-02f, 5.98170459e-02f, 1.05892599e-03f, -1.03624025e-02f, 7.46558830e-02f,
  -1.09269276e-01f, -1.57144636e-01f, -9.73803326e-02f, -1.67266443e-01f, -9.54315960e-02f, -4.40238416e-02f, -1.00111939e-01f, 3.04860938e-02f, 6.78678975e-02f, -2.08080366e-01f,
  -3.34578417e-02f, -1.77114353e-01f, -2.14349806e-01f, -6.98120445e-02f, -8.90462175e-02f, -5.93693629e-02f, -1.85045689e-01f, -1.87198594e-01f, -1.45697445e-01f, 8.97280201e-02f,
  4.42658179e-02f, 2.41829213e-02f, 1.70955565e-02f, -5.72663918e-02f, -3.33367921e-02f, 5.51500544e-02f, 5.13814017e-02f, -4.64898627e-03f, 1.81332216e-01f, 1.44790739e-01f,
  -3.82674523e-02f, 5.06506711e-02f, 4.65058163e-02f, 1.12111025e-01f, 5.33228852e-02f, 6.85554221e-02f, 1.15080133e-01f, 2.78775487e-03f, -1.02251276e-01f, 6.70610815e-02f,
  6.24234378e-02f, 1.10572897e-01f, -1.70753188e-02f, 1.16291240e-01f, -2.16896050e-02f, -8.17191899e-02f, 5.17796129e-02f, 5.98037764e-02f, -1.88248064e-02f, 4.66739871e-02f,
  1.70431748e-01f, -9.67647731e-02f, 2.12848842e-01f, 7.51950741e-02f, 7.73322284e-02f, -4.53860909e-02f, 6.29647523e-02f, -8.22158605e-02f, -1.03362918e-01f, 9.80667397e-02f,
  -3.62263247e-02f, 4.76058014e-02f, -3.99147533e-02f, 7.66831338e-02f, 1.86114326e-01f, 4.95682023e-02f, -8.09852313e-03f, 2.03635804e-02f, -1.98291298e-02f, -5.78226559e-02f,
  1.28930092e-01f, 1.16705284e-01f, 5.70110194e-02f, 1.97344393e-01f, 9.93275717e-02f, 5.40322214e-02f, -1.47603052e-02f, 4.51573581e-02f, -5.16466573e-02f, 2.64960736e-01f,
  -4.86731052e-01f, 1.95279643e-01f, 2.07624853e-01f, -2.16732070e-01f, -1.55780977e-02f, -9.80558842e-02f, -2.61481225e-01f, -2.89757192e-01f, -1.32216930e-01f, 1.21990539e-01f,
  3.22632082e-02f, -2.02050745e-01f, -4.39026654e-02f, -1.55282706e-01f, -3.36573511e-01f, 1.07248187e-01f, 8.31810459e-02f, -2.53769308e-01f, -6.39273763e-01f, -4.69969034e-01f,
  -2.61974573e-01f, -2.97850162e-01f, -3.86390895e-01f, -1.55917361e-01f, 8.24255645e-02f, -3.81136639e-03f, 2.58305579e-01f, -9.44441278e-03f, 9.65853706e-02f, 2.68194109e-01f,
  2.40280196e-01f, -1.62801310e-01f, -2.12083146e-01f, -1.41504943e-01f, -4.50594071e-03f, 4.65304963e-02f, -1.67532876e-01f, 5.33317439e-02f, -1.11337481e-02f, -1.64373189e-01f,
  -1.74050421e-01f, -1.11515053e-01f, -1.21913113e-01f, -1.10633768e-01f, -8.93681422e-02f, -1.03849754e-01f, 2.24101320e-02f, -9.66970772e-02f, 1.22567676e-01f, 2.03892007e-01f,
  5.79249933e-02f, 2.57604942e-02f, -1.20149225e-01f, 5.94490999e-03f, -6.55412674e-02f, 3.50698456e-02f, -1.52494321e-02f, -4.81689572e-02f, 5.69593161e-02f, -4.15622890e-02f,
  -6.16717488e-02f, -6.75031170e-02f, -1.18712597e-01f, -3.12217535e-03f, -1.56166360e-01f, -1.46622658e-01f, 3.12543213e-02f, -4.99954782e-02f, -6.39795884e-02f, -1.03071608e-01f,
  -1.03726164e-01f, 1.74617887e-01f, -8.06299895e-02f, -2.53922753e-02f, -3.31909470e-02f, -7.39222318e-02f, -1.71167880e-01f, -8.07837322e-02f, -2.29378492e-02f, -1.30040273e-01f,
  -8.27340484e-02f, 1.80567876e-02f, 5.39215021e-02f, 5.43341897e-02f, 3.50288325e-03f, 2.17868555e-02f, -2.37824079e-02f, -1.20276712e-01f, -1.42427281e-01f, -7.99021125e-02f,
  -2.21097320e-02f, 2.27500126e-02f, 9.63373259e-02f, -4.24399972e-02f, 1.53310254e-01f, 8.86445567e-02f, 1.68887466e-01f, 5.51435091e-02f, 1.03006832e-01f, 3.23376544e-02f,
  -4.63232510e-02f, 4.56073992e-02f, 2.84467563e-02f, -2.79720593e-02f, -1.46701545e-01f, 7.22848251e-03f, 1.61925808e-01f, 4.17212211e-02f, 6.81117475e-02f, 1.90233544e-01f,
  2.22040370e-01f, -2.23619901e-02f, -9.90604162e-02f, 6.15096092e-02f, -5.81829958e-02f, -3.25303078e-02f, 3.92916203e-02f, 3.44904400e-02f, 1.32918237e-02f, 2.89095119e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  3.25452656e-01f, 3.18966419e-01f, 2.21039653e-01f, 1.24893017e-01f, 7.97888413e-02f, 4.98887569e-01f, 2.12513104e-01f, 3.81735384e-01f, 7.56743625e-02f, 4.93262053e-01f,
  3.89549077e-01f, 3.96302760e-01f, 1.29463881e-01f, 4.93683487e-01f, -1.24160595e-01f, 3.88049841e-01f, 3.33343923e-01f, 2.74215460e-01f, 3.56216788e-01f, 3.64800692e-01f,
  1.96174473e-01f, 2.45805427e-01f, 7.29705542e-02f, 3.02257121e-01f, 3.14678937e-01f, 3.55406165e-01f, 3.93091410e-01f, 2.18228474e-01f, 2.97728390e-01f, 3.03613156e-01f,
  3.36570054e-01f, 5.37029840e-02f, 3.94521803e-01f, 3.18440050e-01f, 4.39711094e-01f, 3.31679195e-01f, 4.58381593e-01f, 1.89166248e-01f, 2.28733882e-01f, 2.53536999e-01f,
  3.81614745e-01f, 2.36772835e-01f, 4.01090056e-01f, 5.18774271e-01f, 3.05806339e-01f, 1.95400253e-01f, 3.57106805e-01f, 2.02669531e-01f, 3.30977172e-01f, 4.03214186e-01f,
  3.32066029e-01f, 2.56718636e-01f, 2.26713613e-01f, 2.21818849e-01f, 2.27960944e-01f, 5.29969156e-01f, 4.52117413e-01f, 2.84037888e-01f, 2.49075338e-01f, 4.32630211e-01f,
  3.68701726e-01f, 3.45939159e-01f, 2.25922644e-01f, 2.74192512e-01f, 5.22497118e-01f, 3.93132031e-01f, 1.04138799e-01f, 5.56010783e-01f, 1.57758117e-01f, 3.82175773e-01f,
  5.37789583e-01f, 4.39099044e-01f, 5.25153041e-01f, 5.20764530e-01f, 3.91209930e-01f, 1.56737775e-01f, 4.39823568e-01f, 2.10992903e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  3.33564579e-02f, -7.94826448e-03f, -3.70380469e-02f, 1.07875420e-02f, -4.63067219e-02f, -3.03721368e-01f, -1.23235382e-01f, -1.04821026e-01f, -7.84676149e-02f, -2.46979728e-01f,
  -1.34290069e-01f, 1.19369589e-02f, -1.75911456e-01f, -1.98985159e-01f, -8.50066077e-03f, -7.52031654e-02f, -6.82408139e-02f, -7.21321627e-02f, 4.86804508e-02f, 1.45762193e-03f,
  1.79660472e-03f, 1.66787989e-02f, -9.91298556e-02f, 7.67198578e-03f, -9.51475501e-02f, -1.63765058e-01f, 4.92073745e-02f, 1.72901616e-01f, -5.21932216e-03f, 2.31359750e-02f,
  -1.51547387e-01f, -1.08563684e-01f, -3.04170884e-02f, 1.05219565e-01f, -1.24808498e-01f, 1.06486686e-01f, 1.71789750e-01f, -1.45394266e-01f, -1.29195258e-01f, 2.62228042e-01f,
  8.82020146e-02f, -3.91075127e-02f, 2.61913389e-01f, -5.97317778e-02f, 1.25044599e-01f, 1.35071158e-01f, -1.53727643e-02f, -5.35134934e-02f, 4.29681465e-02f, 9.76854041e-02f,
  -2.65663415e-01f, -1.15313582e-01f, 6.95869401e-02f, 3.55615556e-01f, 3.33225220e-01f, -6.88267797e-02f, 1.12835191e-01f, -2.70037174e-01f, 4.32049017e-03f, -4.25511867e-01f,
  4.60849106e-01f, -4.43399876e-01f, -2.45617375e-01f, -8.05871263e-02f, 3.17777276e-01f, -4.76972647e-02f, 2.33393729e-01f, -1.77260172e-02f, 7.94395134e-02f, -7.26019917e-03f,
  3.95257652e-01f, 7.90384561e-02f, -1.79887682e-01f, 3.99494842e-02f, -2.54740208e-01f, -1.28252313e-01f, -2.64468014e-01f, 2.28814721e-01f, 3.51159990e-01f, 3.41375023e-02f,
  -2.32284069e-01f, 1.92342743e-01f, -1.63241133e-01f, -2.30934680e-01f, -4.32081401e-01f, -4.27960157e-01f, 5.21883257e-02f, 4.46234047e-01f, -2.13032246e-01f, -4.10315067e-01f,
  -8.30688715e-01f, -4.06467348e-01f, -8.59703898e-01f, 1.21333033e-01f, -1.02973931e-01f, 3.37144792e-01f, -1.61685258e-01f, -1.05244532e-01f, 4.62733768e-02f, 5.23524843e-02f,
  1.51479125e-01f, -2.11695582e-01f, -4.15336192e-01f, -1.38389394e-01f, 3.73025566e-01f, -3.13556761e-01f, 7.19762370e-02f, -4.46861088e-01f, -1.54681563e-01f, -1.86896399e-02f,
  -3.29070389e-01f, 1.57705307e-01f, -1.44364193e-01f, -6.63825095e-01f, 6.00689113e-01f, -1.76727489e-01f, 3.12918454e-01f, -1.19277403e-01f, -1.57040060e-01f, -1.88058689e-01f,
  -4.74048197e-01f, -2.86811769e-01f, -6.72459602e-01f, 8.80381688e-02f, -2.55127192e-01f, -1.86762199e-01f, -3.81578386e-01f, -4.20909911e-01f, -9.71597061e-02f, -2.99723506e-01f,
  -8.62401798e-02f, -1.66710243e-01f, 1.40029192e-01f, 1.73524886e-01f, -8.32891315e-02f, 5.87072857e-02f, -8.29071701e-02f, 1.11715242e-01f, 1.20074458e-01f, -2.17092689e-02f,
  2.88723558e-02f, -1.12040259e-01f, -8.37526917e-02f, 1.50813729e-01f, -2.07354248e-01f, -3.84717435e-02f, 7.53898814e-04f, 3.56030688e-02f, 4.28646356e-02f, -6.83665723e-02f,
  1.39093921e-01f, 1.20396540e-01f, -2.29575872e-01f, 6.30458519e-02f, -1.20851800e-01f, 1.18474907e-03f, -2.09617704e-01f, -1.00533552e-01f, 2.07096577e-01f, -1.24922961e-01f,
  -2.26870626e-01f, -1.31256893e-01f, 1.20457960e-02f, 1.58006325e-01f, 6.10910840e-02f, -1.08546510e-01f, -6.48300424e-02f, 1.04885427e-02f, -1.45283043e-01f, -4.02670987e-02f,
  2.76050389e-01f, 1.17834650e-01f, -1.50646627e-01f, 1.55652940e-01f, 2.83188105e-01f, -9.54348892e-02f, 1.68746129e-01f, 2.83542693e-01f, 5.60058579e-02f, -7.17708886e-01f,
  2.20409613e-02f, -6.26682401e-01f, 3.65156323e-01f, -1.52220070e-01f, -1.69765487e-01f, 2.84652919e-01f, -2.76818592e-02f, -4.62168336e-01f, -4.04129416e-01f, -3.82463671e-02f,
  1.58293083e-01f, -1.35115549e-01f, 7.23217428e-02f, 1.72886401e-01f, 6.70723617e-02f, 2.02100545e-01f, -4.26035643e-01f, -1.62274197e-01f, 8.86432052e-01f, -2.35559251e-02f,
  3.88344079e-02f, -1.42454296e-01f, -2.53370792e-01f, 3.98683190e-01f, -3.91982406e-01f, -3.53330642e-01f, 1.40959173e-01f, 8.06163549e-02f, -2.07925454e-01f, -4.86395992e-02f,
  -2.00549826e-01f, -5.66061176e-02f, -7.48237371e-02f, -1.96612105e-01f, -2.48137400e-01f, 6.91533387e-01f, 1.60941482e-01f, -5.95570028e-01f, -6.14295542e-01f, -3.31740499e-01f,
  -3.26749474e-01f, 2.65135467e-01f, 3.46652627e-01f, -4.10095155e-01f, 7.91612864e-02f, 3.02878141e-01f, -2.32487574e-01f, 1.33607447e-01f, -3.50001842e-01f, -4.01911587e-01f,
  -5.14315248e-01f, -4.87256795e-02f, -3.70406538e-01f, -6.14272714e-01f, 1.14867873e-01f, 2.64561385e-01f, -3.23826015e-01f, 2.09545434e-01f, 1.62954375e-01f, 2.85608202e-01f,
  -1.19814612e-01f, -5.14559507e-01f, 4.41393480e-02f, -3.45725507e-01f, -8.83927107e-01f, 1.46535873e-01f, -5.54019772e-03f, -3.71191025e-01f, -3.60562742e-01f, 3.36948574e-01f,
  4.10823613e-01f, 3.83896172e-01f, 1.15804523e-01f, -1.67965721e-02f, 4.75499779e-02f, -2.22498640e-01f, 1.58613294e-01f, 1.27781034e-01f, 7.15328678e-02f, 1.73193827e-01f,
  -7.97012672e-02f, 1.27097026e-01f, 1.08565398e-01f, -1.38447266e-02f, 5.64502552e-02f, 1.88324869e-01f, 1.68225706e-01f, 9.22039151e-03f, 1.75363332e-01f, 7.22650364e-02f,
  8.15479532e-02f, 7.18012452e-02f, 1.92056626e-01f, 1.29315212e-01f, 2.64742523e-02f, -3.92265953e-02f, -2.96023451e-02f, 1.66126192e-01f, 7.59131908e-02f, -1.53386500e-02f,
  -7.57918358e-02f, 7.79467672e-02f, -1.06360190e-01f, 2.73066256e-02f, -6.81024790e-02f, -1.84815094e-01f, 6.97500352e-03f, 3.87464203e-02f, 2.72977889e-01f, -6.71676397e-02f,
  1.72959581e-01f, 2.13901907e-01f, -3.23758364e-01f, 2.70238310e-01f, -2.13465337e-02f, -2.25536488e-02f, -2.76472509e-01f, -3.38834114e-02f, 9.87622216e-02f, 1.15112938e-01f,
  -1.96459014e-02f, -8.70396793e-02f, 1.33031219e-01f, -1.15663216e-01f, -2.16346830e-01f, 3.78267080e-01f, -2.95012087e-01f, -2.39825532e-01f, -6.82264790e-02f, -7.03954399e-02f,
  -5.56222677e-01f, 3.82891158e-04f, -1.33528560e-01f, -8.92835930e-02f, -1.81630343e-01f, 5.39627075e-01f, -3.41067642e-01f, 2.90350746e-02f, -3.26512516e-01f, -2.25568175e-01f,
  8.16926081e-03f, 1.30361794e-02f, -5.35279870e-01f, -2.12441862e-01f, -3.66548389e-01f, -1.38161600e-01f, 8.13346729e-02f, 7.62996450e-02f, -4.89105970e-01f, 1.80978000e-01f,
  -1.53187066e-01f, -2.69807220e-01f, -3.47063303e-01f, 2.73742050e-01f, 4.01351273e-01f, 3.02678738e-02f, 2.25474406e-02f, 4.64670137e-02f, -1.86923128e-02f, -2.60550618e-01f,
  8.31865445e-02f, -1.31340194e-02f, -1.70932755e-01f, 3.12294751e-01f, -3.35704714e-01f, -3.45842570e-01f, -1.25035584e-01f, -2.22566873e-01f, -4.06695098e-01f, 3.08252037e-01f,
  -2.11277097e-01f, 1.34888977e-01f, -1.10071048e-01f, -1.59911588e-01f, 6.37728572e-01f, 1.07868008e-01f, -1.66473970e-01f, -3.69852483e-01f, 2.50374019e-01f, 9.73920599e-02f,
  4.98518646e-01f, -3.08057159e-01f, 1.52825296e-01f, 1.17511734e-01f, -1.21284500e-01f, -1.76167544e-02f, 6.17681921e-01f, -5.67725956e-01f, 5.17423570e-01f, 9.78807546e-03f,
  -3.27461869e-01f, -1.92818984e-01f, -2.81406820e-01f, 2.35619664e-01f, -1.71608895e-01f, 2.19099388e-01f, -1.27836868e-01f, 1.59182623e-01f, 1.42799318e-01f, 1.81725383e-01f,
  -1.72495693e-01f, -2.58273054e-02f, -2.05256760e-01f, -6.57448843e-02f, -3.04675788e-01f, 6.76485598e-02f, -1.48661673e-01f, -8.05493891e-02f, 1.42942909e-02f, -1.08295143e-01f,
  2.24294309e-02f, 1.66281015e-01f, 6.47994578e-02f, 1.46179974e-01f, -1.94997489e-01f, 8.47015679e-02f, 4.25460860e-02f, 6.27328679e-02f, -3.01190466e-02f, -4.68564928e-02f,
  -7.54915327e-02f, -1.02390245e-01f, -2.30052203e-01f, 1.01339765e-01f, -4.20168117e-02f, -6.70100078e-02f, -1.27649188e-01f, -1.46074608e-01f, 5.11738919e-02f, -4.16417807e-01f,
  4.83753271e-02f, -6.31160848e-03f, 8.51213634e-02f, -1.12842340e-02f, 9.31667164e-02f, 2.63239872e-02f, -2.52619628e-02f, 5.58557101e-02f, 1.59923986e-01f, 1.29675940e-01f,
  1.93986222e-01f, -1.43505841e-01f, 4.50767241e-02f, -1.05328687e-01f, -1.73478708e-01f, -1.15684889e-01f, 1.92077979e-01f, -2.50338972e-01f, 1.83909982e-01f, -6.80403486e-02f,
  9.20738131e-02f, -9.80485231e-02f, 1.65621027e-01f, -4.44307476e-02f, -1.96848184e-01f, 3.13584477e-01f, 3.54349054e-02f, 9.81205031e-02f, 3.28236341e-01f, 8.29589069e-01f,
  4.22278605e-02f, -4.95211370e-02f, -1.69821769e-01f, -4.02009785e-01f, 1.84457451e-01f, -3.14984292e-01f, -2.08909512e-01f, -3.19323480e-01f, -2.57171661e-01f, -2.72199035e-01f,
  -3.73917103e-01f, -1.81287542e-01f, -1.57849953e-01f, -6.42428771e-02f, -5.92824221e-01f, -4.43926275e-01f, -2.56320924e-01f, -2.53079832e-01f, 1.00136414e-01f, -2.95297265e-01f,
  5.14464557e-01f, 5.48443079e-01f, 1.38659015e-01f, -2.03315303e-01f, -1.24080323e-01f, -3.11400741e-01f, 4.19884950e-01f, -1.79739833e-01f, -3.02543730e-01f, 3.32943261e-01f,
  6.07733071e-01f, 4.18361068e-01f, 8.41083154e-02f, -2.56068021e-01f, 8.92643109e-02f, 3.70083958e-01f, 1.32718965e-01f, 1.46810353e-01f, -1.28829122e-01f, -2.47612476e-01f,
  -4.02562439e-01f, -1.47209138e-01f, -3.42312694e-01f, -2.54427642e-01f, 1.02406424e-02f, -3.67820352e-01f, -2.19598711e-01f, -2.09143728e-01f, 1.99415788e-01f, 2.56991029e-01f,
  -4.37321305e-01f, 2.18722656e-01f, 7.04625010e-01f, -2.21131042e-01f, 1.80912495e-01f, -6.60026848e-01f, -8.85207579e-02f, 1.90926455e-02f, -1.09469509e+00f, 4.48126405e-01f,
  2.91287839e-01f, -3.52412969e-01f, -9.49191526e-02f, -1.88614175e-01f, -4.19794815e-03f, -3.12527359e-01f, -7.21987367e-01f, -4.47940260e-01f, -3.04746211e-01f, -2.77068466e-01f,
  -3.51305455e-01f, 3.15924317e-01f, 1.15370192e-01f, 6.36474714e-02f, 5.11150621e-02f, 6.52399436e-02f, -1.60834417e-01f, -1.70186788e-01f, -5.32319210e-02f, -4.84904926e-03f,
  -3.59662771e-02f, -2.14274317e-01f, -2.96546798e-02f, -2.15923488e-02f, -8.85091349e-02f, 6.03850521e-02f, 3.36454473e-02f, -1.60053775e-01f, 2.56914571e-02f, 5.73354028e-02f,
  1.93164889e-02f, -2.32082963e-01f, -4.46168520e-02f, 2.48795748e-02f, 4.43216860e-02f, -1.48036033e-01f, -4.10616063e-02f, 8.41719508e-02f, -8.13162029e-02f, 1.74913213e-01f,
  8.40372518e-02f, -1.18369479e-02f, 1.68870389e-01f, 4.11561728e-02f, -4.89169499e-03f, 3.84983085e-02f, 1.29697606e-01f, 1.75671548e-01f, -1.60697237e-01f, -1.46971211e-01f,
  1.40610620e-01f, -8.21815729e-02f, -1.55094236e-01f, -1.20737158e-01f, -2.42940336e-01f, -2.49677047e-01f, -1.67582855e-01f, 5.69995604e-02f, -1.00067414e-01f, -2.01591805e-01f,
  -5.11621609e-02f, -5.79785742e-02f, 9.79585350e-02f, -1.46537140e-01f, -1.51455018e-03f, 1.38370380e-01f, -1.94998339e-01f, -4.14246619e-01f, 8.17309394e-02f, -1.06666751e-01f,
  -1.15647130e-01f, 2.80965805e-01f, -6.00346506e-01f, -1.57396153e-01f, 1.79265648e-01f, -3.62149447e-01f, -8.67691338e-02f, -4.66997534e-01f, -8.83102864e-02f, -3.30076307e-01f,
  2.83033818e-01f, -3.30230683e-01f, -1.00834548e-01f, 5.51684648e-02f, 1.72654837e-01f, 5.05221188e-02f, 3.14212203e-01f, -5.32860234e-02f, -4.95590270e-02f, -6.03724658e-01f,
  4.75539342e-02f, 4.17852867e-03f, -4.54746038e-02f, 1.04269169e-01f, -3.47869635e-01f, 2.11820886e-01f, -4.69191313e-01f, 1.18483320e-01f, -3.43069077e-01f, -2.65788674e-01f,
  3.23169053e-01f, 5.69593012e-01f, 3.53459179e-01f, 3.48730266e-01f, 1.68882474e-01f, 1.05205290e-01f, -2.75153100e-01f, -2.10113361e-01f, 8.57848499e-04f, -1.39611527e-01f,
  -3.60086448e-02f, -1.64963439e-01f, 1.40010595e-01f, 4.54086512e-01f, 5.35466135e-01f, -3.35349850e-02f, -2.22046319e-02f, 3.99864674e-01f, -1.13932006e-01f, -4.75973397e-01f,
  -4.65604424e-01f, -7.03255907e-02f, 8.14239383e-02f, -2.06597093e-02f, 6.71271980e-02f, 4.47609425e-01f, -3.48502547e-01f, -5.07716954e-01f, 8.01843107e-02f, -1.24044180e-01f,
  -1.47464588e-01f, -4.17970926e-01f, -1.60384312e-01f, -1.63691550e-01f, 2.26607978e-01f, -2.84162164e-01f, -9.83888656e-02f, 2.15766117e-01f, -3.03416848e-01f, 4.41895664e-01f,
  1.59730352e-02f, 2.10252237e-02f, 1.00624725e-01f, 9.77616683e-02f, 1.29405007e-01f, 1.75652757e-01f, 9.72824171e-02f, -1.39374677e-02f, 2.01177597e-01f, 4.79972064e-02f,
  1.56157881e-01f, 4.00563143e-03f, -2.50384212e-02f, 2.72550374e-01f, 4.96903807e-02f, 5.83839156e-02f, -1.02635302e-01f, 2.92090684e-01f, -3.93649749e-02f, 2.15105087e-01f,
  -5.03713340e-02f, 1.21964864e-01f, 4.45925854e-02f, 3.07251867e-02f, 1.40665606e-01f, 1.89742446e-01f, -1.87960029e-01f, -7.58998888e-03f, -1.60294890e-01f, 1.48201749e-01f,
  -7.86365867e-02f, -2.17392325e-01f, -2.06873417e-01f, 1.75170034e-01f, 2.84612089e-01f, -5.93395531e-02f, -1.32169262e-01f, -1.92604110e-01f, -1.85384214e-01f, 1.07980147e-01f,
  2.43043557e-01f, -1.32994473e-01f, -1.25430077e-01f, 1.34114698e-01f, -1.21933604e-02f, 8.14391449e-02f, -3.36394280e-01f, -7.47225760e-03f, -3.19400012e-01f, 3.08935773e-02f,
  2.85016686e-01f, 3.81620884e-01f, 2.54882842e-01f, -4.60481405e-01f, -1.86014593e-01f, -2.35818282e-01f, 1.62067309e-01f, -3.52034420e-01f, -1.00008726e-01f, -5.08222282e-01f,
  7.03138053e-01f, 7.28592947e-02f, 4.38350067e-03f, 3.41015905e-01f, -1.24026135e-01f, -3.19121301e-01f, 5.46057999e-01f, -3.87355179e-01f, 4.06654894e-01f, 3.38403016e-01f,
  -2.82074690e-01f, -1.29963517e-01f, 1.22312620e-01f, -1.91785187e-01f, -8.14419687e-01f, 1.56336933e-01f, -5.43785334e-01f, 8.71570222e-03f, -5.02622724e-01f, -4.15192172e-02f,
  2.68649578e-01f, -4.17846739e-02f, -1.68816045e-01f, 3.17920804e-01f, 4.37986888e-02f, 1.93865195e-01f, -9.57210660e-02f, -9.29010451e-01f, 2.52738327e-01f, 1.04591757e-01f,
  2.71612346e-01f, -7.77008593e-01f, -5.83332539e-01f, -5.40251791e-01f, -1.30036369e-01f, 3.18866670e-01f, -1.32604271e-01f, -1.87940970e-01f, -6.77280784e-01f, 1.01693287e-01f,
  3.24925154e-01f, -2.42546231e-01f, -3.55535746e-01f, -3.91830236e-01f, -9.54678953e-02f, 3.05904239e-01f, -7.96371102e-02f, 2.60668457e-01f, 9.55801532e-02f, 1.92646421e-02f,
  1.94401801e-01f, 5.23099959e-01f, -3.96721274e-01f, -5.90191603e-01f, 5.30495465e-01f, 2.69011140e-01f, -1.32454082e-01f, -5.88396132e-01f, -9.17749479e-02f, 7.79758394e-02f,
  1.13344736e-01f, -3.01149897e-02f, -2.50788033e-02f, 2.51905508e-02f, -1.33448929e-01f, 2.01294884e-01f, 1.72199950e-01f, -2.16324776e-01f, -1.85281977e-01f, 2.01562159e-02f,
  -3.13305035e-02f, 5.80303185e-02f, 1.41436428e-01f, -5.96691035e-02f, 2.39982605e-02f, 2.24649701e-02f, 8.06987509e-02f, 9.27653015e-02f, 9.26138908e-02f, -1.05923720e-01f,
  1.20049581e-01f, -1.10537700e-01f, -1.69027627e-01f, 3.98042835e-02f, 5.76121025e-02f, -1.86118618e-01f, -6.83625555e-03f, 3.18737999e-02f, 2.28707399e-03f, -4.77899835e-02f,
  -6.67116269e-02f, 8.18322077e-02f, 8.31757411e-02f, 3.29241991e-01f, 1.45545200e-01f, -1.92383721e-01f, -1.64239318e-03f, 1.42941028e-01f, -2.33038425e-01f, 6.68073520e-02f,
  2.10565880e-01f, -4.08515558e-02f, -2.06770569e-01f, -1.96645513e-01f, -1.08353347e-01f, 1.97325479e-02f, 3.51864278e-01f, -1.48680046e-01f, 3.43757331e-01f, 1.82048395e-01f,
  -1.13114610e-01f, 2.98134834e-01f, -1.21521419e-02f, -1.85786909e-03f, -2.88611889e-01f, 1.34790570e-01f, -1.57715887e-01f, -1.72710314e-01f, 3.60919684e-02f, -2.29660943e-01f,
  -8.31487328e-02f, -2.77834624e-01f, -9.49430913e-02f, -3.63550216e-01f, -2.31145516e-01f, -3.72700840e-01f, -1.84712380e-01f, 2.59865135e-01f, 6.58402666e-02f, 3.70212823e-01f,
  -3.49160254e-01f, -1.80165201e-01f, -1.00588992e-01f, 3.71440411e-01f, -2.22869888e-01f, 4.57377732e-01f, -5.58308125e-01f, -2.34648719e-01f, -4.46939081e-01f, 2.14397371e-01f,
  -7.62793869e-02f, -3.39617550e-01f, 9.05785896e-03f, -1.77522585e-01f, -1.96263924e-01f, -1.07550053e-02f, -4.17703509e-01f, -1.17767043e-01f, 8.68388116e-02f, -2.29122236e-01f,
  -1.12867057e-01f, -1.83116809e-01f, -6.50283694e-02f, -2.07489565e-01f, -4.75876093e-01f, -2.19436243e-01f, -3.11724961e-01f, -1.49722714e-02f, 1.27146199e-01f, -5.44312239e-01f,
  3.28907728e-01f, -2.27342606e-01f, 3.97468805e-01f, -7.68758357e-01f, -3.85955460e-02f, -3.15008402e-01f, 5.74576080e-01f, 2.24774793e-01f, -4.54371989e-01f, -5.60525537e-01f,
  3.40181023e-01f, -2.45958656e-01f, -3.21198314e-01f, -2.51245379e-01f, -1.69841826e-01f, -5.12150712e-02f, -3.10965776e-01f, -6.74200282e-02f, -1.34679284e-02f, -4.24085110e-01f,
  -9.40308511e-01f, 5.75065434e-01f, -2.82591641e-01f, -5.34120679e-01f, -3.15290064e-01f, -2.03768194e-01f, 4.30882275e-01f, 2.72797644e-01f, 1.87934656e-02f, -2.29528457e-01f,
  2.91447282e-01f, 1.23093329e-01f, -1.59852684e-01f, 1.52617186e-01f, 1.80572912e-01f, -1.79642916e-01f, -1.62970722e-01f, -2.26300627e-01f, -5.08043803e-02f, -1.05126388e-01f,
  -1.45541862e-01f, -7.65610114e-02f, -1.32463053e-01f, -1.82800040e-01f, -8.46781582e-02f, -1.50628030e-01f, 3.59274680e-03f, -8.31721798e-02f, 4.20331955e-02f, -1.83635250e-01f,
  -1.95551366e-02f, -1.74474195e-01f, -6.63631335e-02f, -8.12873319e-02f, -6.16114587e-02f, -3.06322813e-01f, -1.31561816e-01f, -5.49279377e-02f, -5.65215759e-02f, 2.21564714e-03f,
  -1.54848963e-01f, -2.10027352e-01f, 1.26824528e-01f, -1.22027807e-01f, 2.44619176e-01f, -4.11480106e-02f, -2.97033172e-02f, -8.07458535e-02f, 9.01048779e-02f, 1.17677517e-01f,
  5.42629696e-02f, 1.05513260e-01f, -6.51335269e-02f, 9.57470238e-02f, -6.11349987e-03f, -2.61851791e-02f, -2.31296524e-01f, 7.45722204e-02f, 4.53412756e-02f, 1.11658260e-01f,
  1.83496132e-01f, -1.97463080e-01f, 1.36021222e-03f, 3.01472656e-02f, 4.17183973e-02f, -1.89590588e-01f, -2.23639920e-01f, 5.76701701e-01f, -4.69307482e-01f, 5.76280877e-02f,
  -2.94553250e-01f, 1.45185844e-03f, 1.43902153e-01f, -9.17000547e-02f, 2.12586626e-01f, 3.02029669e-01f, 4.26533997e-01f, -3.98531646e-01f, 1.20666645e-01f, 2.84147292e-01f,
  -1.90520436e-01f, -3.47074300e-01f, -1.63769469e-01f, -4.25246775e-01f, 1.08526707e-01f, -2.06694856e-01f, -2.83139646e-01f, 1.44143868e-02f, 2.60727406e-01f, 2.33996123e-01f,
  -1.65918648e-01f, -1.71407178e-01f, 1.71015874e-01f, 4.29601014e-01f, -2.35997707e-01f, -2.06562594e-01f, 5.32061346e-02f, -1.07743695e-01f, 5.49482033e-02f, -1.53140664e-01f,
  3.94209363e-02f, -1.63095325e-01f, 1.13659948e-01f, -2.93260008e-01f, -1.28750503e-01f, -8.28912854e-02f, 5.17325521e-01f, 5.97487450e-01f, 1.81113735e-01f, -2.68562734e-01f,
  -2.71795094e-01f, 3.16278160e-01f, -2.25201971e-03f, 1.36067614e-01f, -1.33241877e-01f, -9.31225643e-02f, -2.71180183e-01f, -2.25735813e-01f, -8.24033618e-02f, 4.47921008e-02f,
  -1.49788698e-02f, -2.89003491e-01f, -1.29241630e-01f, -2.90022850e-01f, 6.94924444e-02f, -2.76753932e-01f, -2.20653474e-01f, -1.01736635e-01f, 2.88437575e-01f, -2.66146868e-01f,
  -3.43185335e-01f, -1.06412895e-01f, -1.19318604e-01f, -1.69380352e-01f, -1.93841398e-01f, -4.70772952e-01f, -1.34757152e-02f, -2.23910317e-01f, -3.25280219e-01f, -3.64382803e-01f,
  5.72487377e-02f, -3.31850089e-02f, 1.82845548e-01f, 3.48884948e-02f, 1.01922162e-01f, 6.16949014e-02f, -1.98012926e-02f, 1.50938742e-02f, -2.58724034e-01f, 9.30035189e-02f,
  -7.47485459e-02f, 5.62008545e-02f, 6.64339438e-02f, -2.97403216e-01f, 1.32563174e-01f, 3.12648788e-02f, 1.32375015e-02f, 1.84904207e-02f, 1.64996907e-02f, 7.77931288e-02f,
  -3.60152684e-02f, 1.88754480e-02f, 1.49399355e-01f, 1.19496532e-01f, 1.82093177e-02f, 1.86421141e-01f, 1.08311333e-01f, 6.19666986e-02f, 1.12493329e-01f, -7.41744861e-02f,
  8.17596242e-02f, 1.36467710e-01f, -5.94786294e-02f, 1.42237723e-01f, -3.69157761e-01f, 2.49648333e-01f, -1.02256700e-01f, -9.93869081e-02f, -2.89253443e-01f, -5.36594763e-02f,
  1.56257913e-01f, -2.52349526e-02f, -1.96325213e-01f, 1.50807247e-01f, -1.81541294e-02f, -5.11122867e-02f, 4.80823265e-03f, 1.96450084e-01f, -1.34408195e-02f, -2.58064687e-01f,
  7.81067982e-02f, -3.10725607e-02f, -2.01008737e-01f, -1.72767460e-01f, 1.04932211e-01f, -1.45197779e-01f, -3.86627376e-01f, -1.34060562e-01f, -5.68894088e-01f, 3.43276113e-01f,
  2.59830117e-01f, 3.59997034e-01f, 4.59417015e-01f, -1.37512609e-02f, -1.86294481e-01f, 1.34938017e-01f, -1.15870990e-01f, -2.32157156e-01f, -1.42693087e-01f, -2.55233139e-01f,
  -4.28919196e-01f, -2.83166766e-01f, -3.81787747e-01f, 2.95560300e-01f, -4.20372874e-01f, -3.08810890e-01f, -3.35611910e-01f, 1.04413986e-01f, -4.48478460e-01f, -1.12893082e-01f,
  -7.29333907e-02f, -2.57902652e-01f, -1.72765926e-01f, 5.57927154e-02f, -1.55858770e-01f, -2.14550674e-01f, 2.57125080e-01f, -2.57704675e-01f, 5.41266143e-01f, -1.09063372e-01f,
  4.84245658e-01f, -1.62576556e-01f, -2.33002633e-01f, -2.17989579e-01f, -3.67644638e-01f, -8.40397850e-02f, -2.12567627e-01f, -3.28422546e-01f, -2.24008039e-01f, -1.48045225e-02f,
  3.02864730e-01f, -1.56575307e-01f, 7.81584606e-02f, -6.81269094e-02f, -2.93078572e-01f, -1.35368884e-01f, -1.80060528e-02f, 2.06942797e-01f, -2.16055974e-01f, -2.94797659e-01f,
  2.91009974e-02f, 2.67271399e-02f, -2.24157721e-01f, 2.13915467e-01f, 1.31953135e-01f, -2.92716205e-01f, -1.46215454e-01f, -1.86310723e-01f, 5.12627125e-01f, 5.29570818e-01f,
  -1.05473861e-01f, 3.41733456e-01f, -2.02504128e-01f, 5.58271520e-02f, 5.17602682e-01f, 4.56064157e-02f, -5.51066920e-02f, -2.79791355e-01f, 4.23880875e-01f, -4.28062230e-01f,
  2.68959880e-01f, -4.12296683e-01f, 7.59286880e-02f, 5.34350909e-02f, 1.03027202e-01f, -2.81329185e-01f, 1.98726848e-01f, 8.65438133e-02f, 7.02583566e-02f, -1.15437850e-01f,
  -1.17269255e-01f, -7.57193714e-02f, -1.67677760e-01f, 4.37635519e-02f, -1.20012254e-01f, 2.10993901e-01f, -2.77489214e-03f, -1.49597228e-01f, 4.01555793e-03f, -1.58272713e-01f,
  4.76078168e-02f, -4.45086882e-02f, 2.86803059e-02f, 4.50561382e-02f, -6.50396245e-03f, 4.96450141e-02f, 2.30885353e-02f, 1.14871547e-01f, 5.86566068e-02f, 9.62841064e-02f,
  2.77744770e-01f, -2.64640510e-01f, 6.61389306e-02f, -1.55892134e-01f, -5.03861941e-02f, 8.65993202e-02f, 1.70367181e-01f, -2.37011343e-01f, 7.17742043e-03f, -2.01587871e-01f,
  -5.73216826e-02f, -5.69893373e-03f, 8.28371644e-02f, 4.38872166e-02f, -2.34615043e-01f, -1.00014478e-01f, 4.36231680e-02f, 6.04634359e-02f, -1.93709061e-01f, 2.10963592e-01f,
  6.07226156e-02f, -8.73499438e-02f, -3.72540712e-01f, 1.44700482e-01f, -3.85494143e-01f, 4.68039483e-01f, -4.09852445e-01f, -1.37837663e-01f, -8.27741902e-03f, 2.36486122e-02f,
  9.38485377e-03f, 1.94113463e-01f, -5.16208231e-01f, 1.11540288e-01f, -2.20404044e-01f, 1.06992923e-01f, -9.81924534e-02f, 3.19080383e-01f, -7.04567954e-02f, 2.52426863e-01f,
  4.77592438e-01f, -2.84554839e-01f, -3.99717778e-01f, 2.17168704e-01f, -1.13909952e-01f, 1.46070749e-01f, -4.90763545e-01f, -3.63826782e-01f, -2.82158732e-01f, -4.19044077e-01f,
  -4.01967466e-01f, -4.15346742e-01f, -2.49564603e-01f, -3.09082568e-02f, -1.39535084e-01f, -4.26680148e-01f, -8.80955309e-02f, 7.41800591e-02f, -2.14872822e-01f, -6.30677104e-01f,
  -1.23956442e-01f, 3.36267710e-01f, -1.37091160e-01f, 4.08665270e-01f, 2.21283838e-01f, -6.45915210e-01f, 9.58359763e-02f, 6.11925602e-01f, -1.51108742e-01f, -1.07476644e-01f,
  -3.03143680e-01f, 6.52335212e-02f, 1.88883647e-01f, 8.14905524e-01f, 1.58995345e-01f, -3.84752035e-01f, -5.11936843e-01f, -5.01301944e-01f, 2.10351393e-01f, -2.25231618e-01f,
  -6.86264113e-02f, -7.90350735e-02f, -6.41298532e-01f, 3.79223347e-01f, 7.04807162e-01f, 1.53837085e-01f, 3.60692084e-01f, -4.69608217e-01f, -1.47659525e-01f, 1.09451264e-01f,
  -1.33920357e-01f, 2.20177695e-01f, -1.43356338e-01f, 2.37017646e-01f, 1.75392538e-01f, 1.25451729e-01f, -3.01065028e-01f, -3.63062769e-01f, -2.82729983e-01f, 1.77911356e-01f,
  -8.46790820e-02f, 3.76173034e-02f, -9.72112827e-03f, 3.49060297e-02f, -1.05808871e-02f, -4.18322682e-02f, 2.91640125e-03f, 1.67378917e-01f, 7.81546235e-02f, 1.17330238e-01f,
  4.85825241e-02f, 3.62115763e-02f, 3.93952616e-02f, -1.00976221e-01f, 1.12808123e-01f, 6.30637035e-02f, 1.58533782e-01f, 3.93094085e-02f, -1.04800656e-01f, 2.22307649e-02f,
  1.04428351e-01f, 3.95895727e-02f, 3.01009901e-02f, 1.30107075e-01f, 6.86897337e-02f, -3.31976324e-01f, -1.10511310e-01f, 1.68138534e-01f, 6.15431108e-02f, -2.21894532e-01f,
  2.11923316e-01f, -2.30466072e-02f, 2.23960236e-01f, -1.17286101e-01f, -1.57967135e-01f, -2.22479880e-01f, 1.63361534e-01f, 2.70164847e-01f, -1.85852468e-01f, 5.16102239e-02f,
  1.65804416e-01f, 8.09075125e-03f, 2.88673162e-01f, -2.67376721e-01f, -1.20482050e-01f, 7.92414844e-02f, 1.40991941e-01f, 1.34137020e-01f, -5.73792979e-02f, 8.42686072e-02f,
  -1.39631823e-01f, -2.20130593e-01f, 1.86569826e-03f, -4.16436702e-01f, 1.98350459e-01f, 8.47404525e-02f, -2.13773727e-01f, -2.54109412e-01f, -1.35286078e-01f, -1.97460890e-01f,
  -1.70170758e-02f, -7.28939194e-03f, -1.18640967e-01f, 5.30511260e-01f, 2.77103372e-02f, -6.04254715e-02f, -2.70516515e-01f, -5.56418970e-02f, -4.12943214e-01f, 2.09668890e-01f,
  -1.92302734e-01f, -3.92956853e-01f, 7.44216219e-02f, 2.04001784e-01f, -1.93389654e-01f, -2.08136767e-01f, 4.42821056e-01f, -1.20742552e-01f, -4.33604926e-01f, -2.34210491e-01f,
  4.47202146e-01f, -4.42372799e-01f, 5.00948608e-01f, 4.38972235e-01f, -1.31076828e-01f, -3.58828396e-01f, -1.77007526e-01f, -3.50045741e-01f, -2.75205582e-01f, -1.95201024e-01f,
  -6.56953305e-02f, -8.52349028e-02f, -1.78153232e-01f, 4.34377939e-01f, -7.92578161e-02f, -2.44589135e-01f, 3.84488046e-01f, -1.24949953e-02f, -2.23332509e-01f, -1.15170695e-01f,
  7.26630911e-02f, 2.25604713e-01f, -3.13050330e-01f, -5.55648088e-01f, -2.75966585e-01f, 2.21587420e-01f, -2.68173248e-01f, -5.48640406e-03f, 2.65734941e-01f, -3.15839052e-01f,
  -3.60150039e-01f, -3.06965232e-01f, -1.96571708e-01f, -9.75997746e-02f, -4.50776368e-01f, -1.10836431e-01f, -2.32724354e-01f, 4.31296468e-01f, -8.23643282e-02f, -1.04308426e-01f,
  3.74611825e-01f, -3.49809498e-01f, 4.88223881e-01f, -1.57527894e-01f, -1.84381336e-01f, -1.38897523e-01f, -1.45684496e-01f, 3.08919419e-02f, 1.22627147e-01f, 1.96440175e-01f,
  -7.64184222e-02f, 8.87324288e-03f, 8.99460837e-02f, 3.95949930e-02f, -8.44617933e-02f, 1.50952637e-01f, 4.44767512e-02f, -3.07973933e-05f, 1.58635769e-02f, 4.78432365e-02f,
  2.39525959e-02f, -8.19852725e-02f, 1.17685109e-01f, 8.22723359e-02f, 1.26817107e-01f, 1.89068675e-01f, 1.31006222e-02f, 1.72246955e-02f, 1.01183891e-01f, 3.18184914e-03f,
  1.34856999e-01f, -5.29679516e-03f, -2.01742619e-01f, -1.05387956e-01f, -5.46925329e-02f, -8.93209577e-02f, -3.09720002e-02f, 9.03204530e-02f, -3.40647586e-02f, 1.39502212e-01f,
  -2.13204190e-01f, -3.90025787e-02f, -1.54912531e-01f, 1.74190834e-01f, -6.80290535e-02f, 7.12311193e-02f, 2.43117914e-01f, -3.69960144e-02f, -1.11883312e-01f, 9.42425057e-02f,
  -5.60976900e-02f, 4.26574191e-03f, -1.65530071e-01f, -9.99891311e-02f, -5.89185103e-04f, 6.29816875e-02f, 2.78342843e-01f, -1.97538897e-01f, 3.48213106e-01f, -2.87808061e-01f,
  -3.02450031e-01f, -3.12134743e-01f, -1.27802923e-01f, 2.82514453e-01f, -2.76273727e-01f, -1.20975293e-01f, 3.01354155e-02f, -5.71082354e-01f, -8.75727311e-02f, -3.77228826e-01f,
  -9.17467475e-02f, -1.74807414e-01f, -1.34735093e-01f, 1.22946307e-01f, -2.95133382e-01f, 1.84958503e-01f, 2.38998279e-01f, 3.72218549e-01f, -2.13551670e-01f, -1.19730577e-01f,
  -2.49207020e-01f, -2.83787251e-01f, 8.02040160e-01f, 1.17065445e-01f, 3.21201205e-01f, -3.00288260e-01f, -1.76735669e-01f, 2.82143831e-01f, -8.06837156e-02f, 2.52972394e-01f,
  -1.47424743e-01f, -2.10684374e-01f, -2.72523195e-01f, 3.20841730e-01f, 2.27430329e-01f, -4.00846936e-02f, 8.16522762e-02f, 2.72589564e-01f, 1.92887578e-02f, -2.66432539e-02f,
  4.11743492e-01f, -1.30623579e-01f, -2.66740471e-01f, -4.74055886e-01f, -2.26294875e-01f, 2.06931993e-01f, -1.71946526e-01f, -3.24667454e-01f, -3.39078069e-01f, -1.99315771e-01f,
  -5.14347404e-02f, 1.78065851e-01f, -1.86697334e-01f, -2.77236462e-01f, -2.77577400e-01f, -1.13906167e-01f, 4.89717305e-01f, 3.74151058e-02f, -6.82984665e-02f, -2.95202225e-01f,
  -1.57596380e-01f, -3.19206971e-03f, -2.24682137e-01f, 5.56779742e-01f, -2.41433933e-01f, -1.75798133e-01f, 7.32301027e-02f, 3.03196430e-01f, -4.09018636e-01f, -2.80348092e-01f,
  -2.49280289e-01f, -2.86452442e-01f, 1.72628686e-01f, 4.94209044e-02f, -5.69539011e-01f, -1.10187583e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -5.41593097e-02f, 1.22551978e-01f, 8.84856954e-02f, -4.62515391e-02f, -9.75639299e-02f, -2.36390182e-03f, 9.81086567e-02f, -2.81278454e-02f, 9.51879993e-02f, 4.25313078e-02f,
  3.93241830e-02f, 2.75002159e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    