/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.20448387e-01f, 5.76224864e-01f, 1.82409976e-02f, -5.56116886e-02f, -1.24404855e-01f, -7.40689933e-02f, 2.35358506e-01f, 2.48774681e-02f, -2.24096492e-01f, 1.78990915e-01f,
  2.02325523e-01f, -1.54969111e-01f, -1.07984081e-01f, -2.93628555e-02f, 1.95235208e-01f, 6.20684251e-02f, -1.17750995e-01f, -9.71793830e-02f, -1.68826520e-01f, -9.52858925e-02f,
  -2.33327821e-02f, 2.88821310e-02f, 6.23079017e-04f, -5.02072647e-02f, 1.72767952e-01f, -1.96030140e-01f, 2.13290155e-02f, 1.96871087e-01f, 2.55408794e-01f, 4.82808083e-01f,
  2.23237842e-01f, 4.07986134e-01f, -8.87535512e-03f, 5.74775934e-02f, 1.65583789e-02f, 7.89179206e-02f, 9.13493484e-02f, 5.40071316e-02f, 1.69884190e-02f, -5.02184127e-03f,
  7.05806687e-02f, 1.21805713e-01f, 3.74626294e-02f, 5.84676564e-02f, 1.28069341e-01f, 1.23417713e-01f, 4.75420579e-02f, 1.12626657e-01f, 1.21026680e-01f, 1.34557948e-01f,
  2.30615530e-02f, 1.24956697e-01f, 2.55283892e-01f, 8.43073353e-02f, 2.20796779e-01f, 6.37895763e-02f, 2.74061441e-01f, 3.15005213e-01f, 2.81913191e-01f, 3.84522706e-01f,
  4.81725447e-02f, -6.96185380e-02f, -5.50129497e-03f, 7.52171353e-02f, -1.27291203e-01f, -1.24320976e-01f, -7.45972097e-02f, -7.12328702e-02f, -3.98588739e-03f, -1.21548019e-01f,
  -5.54770827e-02f, -1.50278695e-02f, -4.16926816e-02f, -3.56279127e-02f, -1.02987327e-01f, 2.11197976e-02f, -8.00570846e-02f, -3.29058282e-02f, -4.41546775e-02f, -8.14207196e-02f,
  -3.56980935e-02f, -3.23017463e-02f, -7.12786168e-02f, -4.77066636e-02f, -1.76418945e-02f, -8.04695189e-02f, -4.82787900e-02f, -7.06492141e-02f, -1.84116945e-01f, -5.30702323e-02f,
  -1.61888346e-01f, -2.01276876e-02f, 1.74036860e-01f, 1.36079282e-01f, 3.24711055e-02f, 3.08699887e-02f, 1.33902147e-01f, 1.04015976e-01f, 4.36681882e-02f, 1.21187083e-01f,
  1.18038215e-01f, 2.84594074e-02f, 1.13235913e-01f, 1.08427636e-01f, 7.01030344e-02f, -9.04529006e-04f, 9.06375647e-02f, 8.15152749e-02f, 1.30693793e-01f, 1.79159641e-02f,
  2.35397965e-02f, -7.32902065e-02f, -9.21714157e-02f, 8.82875174e-02f, 8.33813250e-02f, -2.73503065e-02f, 9.57012251e-02f, 5.27940318e-02f, -2.54643848e-03f, 1.33101093e-02f,
  3.77219409e-01f, 1.22054806e-02f, -1.78817183e-01f, 3.10657471e-01f, -2.58236736e-01f, -2.90630251e-01f, -6.25646174e-01f, 8.57443586e-02f, 3.40688139e-01f, -1.33580223e-01f,
  2.33865499e-01f, 2.91149884e-01f, 3.39560211e-01f, 1.65432468e-01f, 1.49282798e-01f, -3.49451035e-01f, -2.53614664e-01f, -1.25777712e-02f, -3.27218920e-02f, -2.37352476e-01f,
  -2.03578204e-01f, -2.37218365e-02f, 3.75206947e-01f, 1.49797618e-01f, -1.87058389e-01f, 1.41299441e-01f, -1.35791674e-01f, 1.04316190e-01f, -6.63590133e-02f, -1.50008723e-01f,
  -1.77365676e-01f, -7.78883416e-03f, -2.97168400e-02f, 2.18743160e-01f, -5.40942699e-02f, 4.20192368e-02f, -9.35095847e-02f, 8.88465419e-02f, 4.29154709e-02f, 1.24548050e-02f,
  5.83106168e-02f, 5.47059476e-02f, -2.94445995e-02f, 3.96370031e-02f, -2.89882645e-02f, -8.77167210e-02f, 1.34743124e-01f, 2.01241560e-02f, 1.19858854e-01f, -1.02838613e-01f,
  -3.32845710e-02f, -4.28824797e-02f, -6.72153151e-03f, -4.38076444e-02f, 4.97234240e-02f, 8.36794227e-02f, -1.63459536e-02f, 9.17285308e-02f, 1.90057322e-01f, 3.44315842e-02f,
  -3.71676125e-02f, 3.58824283e-02f, -7.75167197e-02f, -4.80687879e-02f, 2.11184639e-02f, 2.90531106e-02f, -3.61511037e-02f, 1.21570444e-02f, -4.67990264e-02f, 2.43052114e-02f,
  -3.59474085e-02f, -9.39757004e-03f, 2.93444172e-02f, 1.49510037e-02f, 2.96222866e-02f, 6.71801865e-02f, -3.72138768e-02f, -3.23361345e-03f, 7.24812672e-02f, -1.31197805e-02f,
  3.54868127e-03f, -4.43119816e-02f, 2.27039196e-02f, -5.61474897e-02f, 6.90333173e-03f, 2.42247395e-02f, 2.35855281e-02f, -3.89051391e-03f, 1.31789714e-01f, 2.76592877e-02f,
  -2.47928388e-02f, 7.58256763e-02f, -1.12736374e-01f, -1.81588139e-02f, -2.70020403e-03f, -6.28159195e-02f, -1.07771428e-02f, -1.86857879e-02f, 4.82214466e-02f, -1.80459041e-02f,
  3.34421266e-03f, 4.44389461e-03f, -3.30717936e-02f, -5.48665114e-02f, -8.27073082e-02f, -1.67345703e-02f, 5.74125834e-02f, -2.90969275e-02f, 6.31382922e-03f, -1.78246517e-02f,
  -8.30187369e-03f, 2.25399621e-02f, -1.23638824e-01f, 4.89482768e-02f, 7.63735846e-02f, -3.65599580e-02f, -2.22540572e-01f, -1.45502537e-01f, -1.74745880e-02f, -1.46382853e-01f,
  8.56765881e-02f, 5.04556112e-02f, 4.97320235e-01f, 6.75771385e-02f, 2.04534262e-01f, 1.61562681e-01f, 2.97715157e-01f, -8.21593627e-02f, -1.60893992e-01f, 1.65370360e-01f,
  -3.27804731e-03f, -1.22388467e-01f, 9.07924622e-02f, -1.47030026e-01f, -8.80706087e-02f, 3.69392037e-01f, 3.55565488e-01f, 1.48819357e-01f, -8.27369466e-02f, -1.26838535e-01f,
  -1.42801955e-01f, 3.82381119e-02f, -1.46486998e-01f, -1.65997341e-01f, 1.14592135e-01f, 8.42850655e-02f, 3.39389086e-01f, 6.64005950e-02f, 8.72865170e-02f, 1.20259427e-01f,
  2.30579466e-01f, 1.38571635e-01f, -1.07871190e-01f, -2.76999891e-01f, -3.30384485e-02f, -3.80262248e-02f, -2.69096345e-02f, -2.73762327e-02f, -6.43669516e-02f, -8.01867321e-02f,
  -5.16595840e-02f, -1.28228888e-01f, 1.98838655e-02f, -7.42033869e-02f, -2.56105606e-02f, -7.63072670e-02f, -5.07852770e-02f, -1.02844931e-01f, -9.06557292e-02f, 3.28145362e-02f,
  -5.62715307e-02f, 1.14665128e-01f, 1.44854695e-01f, -3.49331498e-02f, -6.33960366e-02f, -5.04531851e-03f, -5.74459285e-02f, -4.77834940e-02f, -7.87682161e-02f, -1.79643452e-01f,
  4.55233119e-02f, 8.23930129e-02f, 3.25269345e-03f, -3.74368043e-03f, -4.47711870e-02f, -1.41412923e-02f, -3.58544178e-02f, -7.42539614e-02f, -2.38981526e-02f, 6.74037188e-02f,
  -5.69213890e-02f, 1.70270745e-02f, -4.85919453e-02f, 6.56214282e-02f, 2.58656195e-03f, 4.95757274e-02f, 1.66867748e-02f, -2.34194919e-02f, 2.76573431e-02f, 1.20825246e-02f,
  -9.06547755e-02f, -6.83121309e-02f, 2.07165387e-02f, -1.03425331e-01f, 5.63518703e-02f, 4.20343541e-02f, 3.89598422e-02f, -6.02675714e-02f, 1.84609853e-02f, 1.00048028e-01f,
  -2.25808844e-01f, -1.41507924e-01f, -2.02135760e-02f, -4.03276496e-02f, 7.89047256e-02f, -5.57650514e-02f, -7.70519581e-03f, -6.86999559e-02f, 1.76637024e-02f, -6.80210590e-02f,
  -8.13343078e-02f, -4.31226343e-02f, -2.61528641e-02f, -1.09388925e-01f, -7.39272088e-02f, -3.18075307e-02f, -2.74835937e-02f, -3.98230255e-02f, -5.18798754e-02f, -3.27030271e-02f,
  -9.22521204e-02f, 2.80604605e-02f, 9.76635441e-02f, 3.76023799e-02f, -2.09987964e-02f, 1.16792627e-01f, 3.72861587e-02f, -2.84160916e-02f, 7.30765909e-02f, -2.65626684e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.56346783e-01f, 8.37565437e-02f, 4.49686497e-01f, 5.88948369e-01f, 6.11178398e-01f, 3.29415888e-01f, 2.19949171e-01f, 1.01651192e-01f, 4.29204591e-02f, 2.54779786e-01f,
  1.82685614e-01f, 1.04280025e-01f, -2.53298618e-02f, 5.93198836e-02f, 1.47887729e-02f, 1.32641837e-01f, 2.54267752e-01f, 9.85215306e-02f, 1.52725384e-01f, 1.88251346e-01f,
  2.09504113e-01f, 1.43938452e-01f, 1.05937056e-01f, 9.04755518e-02f, 2.72894293e-01f, 1.45652562e-01f, 1.04363345e-01f, 3.14444631e-01f, 2.07704976e-01f, 3.69818747e-01f,
  4.09655064e-01f, 3.08789521e-01f, 2.77887657e-02f, 9.74733159e-02f, 1.10871159e-01f, -2.13083491e-01f, 2.21180059e-02f, -4.46709506e-02f, -2.50918954e-03f, -5.21563590e-02f,
  1.57013789e-01f, 1.22804634e-01f, 7.63355866e-02f, -6.13150094e-03f, -3.83552574e-02f, -1.14230186e-01f, -7.75791854e-02f, 4.09638584e-02f, -9.55205634e-02f, -1.65371373e-01f,
  5.30630648e-02f, 6.88121840e-03f, 1.07411951e-01f, 3.18304822e-02f, 1.12428121e-01f, 9.41149984e-03f, -7.43112043e-02f, -2.76210462e-03f, -7.13992715e-02f, -1.35512248e-01f,
  3.27476323e-01f, 1.50121063e-01f, 1.03471197e-01f, -1.26004964e-01f, 1.45105571e-01f, -1.26158819e-01f, -5.63264228e-02f, 1.21058755e-01f, 1.15600951e-01f, 8.51873308e-03f,
  2.58084107e-02f, 1.50884807e-01f, -7.68596753e-02f, 5.98156340e-02f, 3.94807123e-02f, 4.97448705e-02f, -1.27644306e-02f, 1.29196579e-02f, 8.38283971e-02f, -1.04682647e-01f,
  7.30540454e-02f, 4.96046655e-02f, -4.45079096e-02f, -8.34110901e-02f, -6.52491907e-03f, -1.79649927e-02f, -6.83864355e-02f, 2.40485407e-02f, 1.12426661e-01f, -2.24596262e-02f,
  -1.23718441e-01f, 7.33073503e-02f, 9.09274295e-02f, 3.11326701e-02f, 7.00689480e-02f, -1.40094459e-01f, 1.47218630e-01f, -8.50226060e-02f, 3.68458629e-02f, -2.49646716e-02f,
  -4.93437722e-02f, -5.34899160e-02f, -1.28775522e-01f, -1.05420753e-01f, -1.41173676e-02f, -6.50124922e-02f, 6.50802860e-03f, -3.22556160e-02f, -1.98112890e-01f, -2.36651435e-01f,
  -2.72519048e-02f, -9.57048163e-02f, -2.24500880e-01f, -1.60675541e-01f, -7.61839971e-02f, -1.17729612e-01f, -2.47220889e-01f, -7.69178718e-02f, -1.73982337e-01f, -3.09228778e-01f,
  1.33071914e-01f, 3.81115109e-01f, 2.31309369e-01f, 1.89005107e-01f, 2.16674045e-01f, -4.33637828e-01f, -4.90235716e-01f, -5.08835793e-01f, -3.22598130e-01f, -1.68794721e-01f,
  8.32075253e-02f, 4.34677973e-02f, -4.92088795e-02f, -8.88007853e-05f, -1.76926687e-01f, -3.66340391e-02f, 3.95119578e-01f, 3.52402747e-01f, -2.93703265e-02f, 3.23745497e-02f,
  3.04792434e-01f, 2.71731704e-01f, 2.92414755e-01f, 6.10095337e-02f, 2.18767017e-01f, 3.18518654e-02f, 6.34680763e-02f, 3.79507333e-01f, 9.88194421e-02f, 4.96390939e-01f,
  2.28902444e-01f, -5.00359293e-03f, -1.67359516e-01f, -1.23184742e-02f, 3.33419204e-01f, -1.03025362e-01f, 5.35341864e-03f, 1.84736438e-02f, 4.12029810e-02f, -4.99963872e-02f,
  9.40211639e-02f, 9.38990414e-02f, 7.42371827e-02f, -1.17408238e-01f, 5.01455367e-02f, 2.48316373e-03f, 3.29738064e-03f, -3.76704000e-02f, -1.26821712e-01f, -2.34004334e-01f,
  1.25717580e-01f, 1.33164927e-01f, -4.31281365e-02f, -1.58966556e-01f, -1.95234582e-01f, 1.43170908e-01f, -2.61978619e-02f, -8.10343400e-02f, -1.46709949e-01f, -1.65203735e-01f,
  -4.52074707e-02f, 2.18972698e-01f, 2.04424504e-02f, 1.35118380e-01f, 3.72070633e-02f, -7.83435330e-02f, 6.28048107e-02f, -5.36685847e-02f, 1.14012800e-01f, -3.25202127e-03f,
  -1.57524452e-01f, 6.41155094e-02f, 1.97829632e-03f, 2.96755997e-03f, -4.42934074e-02f, 3.96548882e-02f, -2.59665083e-02f, 5.14562316e-02f, 1.90550268e-01f, -8.42358246e-02f,
  1.12218462e-01f, -4.23950478e-02f, 2.26351414e-02f, -1.09003723e-01f, -2.01587239e-03f, 8.89986753e-02f, 1.56123951e-01f, -3.42319869e-02f, 2.83758957e-02f, 5.69082983e-02f,
  -2.91401774e-01f, 1.10632010e-01f, 1.40349209e-01f, -1.52050704e-01f, 1.83263153e-01f, -5.58305457e-02f, 1.00736141e-01f, -5.26249083e-03f, 9.28495824e-02f, -1.73805222e-01f,
  -1.35529086e-01f, 8.80941376e-02f, -3.12063824e-02f, -1.03382654e-01f, -2.42142111e-01f, -4.04617302e-02f, 1.32482825e-02f, -5.52701280e-02f, -5.16438112e-02f, 2.97108665e-03f,
  -1.07151590e-01f, -1.83958188e-01f, 2.75274441e-02f, -2.91645169e-01f, -9.62537825e-02f, -1.66819687e-03f, -4.49009277e-02f, -1.53758407e-01f, -1.65927365e-01f, -2.47094646e-01f,
  8.21869671e-01f, -9.80758592e-02f, 9.39117610e-01f, 1.70894146e-01f, -2.37127826e-01f, 1.27088696e-01f, -4.22540791e-02f, 2.70086322e-02f, -1.49624094e-01f, -9.59260836e-02f,
  -3.41000199e-01f, -3.10008109e-01f, -2.52265334e-02f, -1.42994374e-01f, 1.95628777e-01f, -4.59206430e-03f, 2.10956261e-01f, 5.45603931e-01f, 4.52311724e-01f, 3.85868847e-02f,
  -1.67384103e-01f, 2.69268185e-01f, 4.89775091e-01f, 2.22877264e-01f, -2.16912199e-02f, -1.15351137e-02f, 2.98676342e-01f, 8.87637287e-02f, -2.32489146e-02f, 1.19651802e-01f,
  4.99497205e-02f, 1.28494650e-01f, -4.15888652e-02f, -1.77411720e-01f, -6.32052273e-02f, -8.74465257e-02f, -1.08663723e-01f, 4.10332344e-02f, -1.26482069e-01f, -3.32908109e-02f,
  -1.20502338e-01f, -9.62877721e-02f, -3.93686667e-02f, -8.72953981e-02f, -6.12422358e-03f, -9.13395435e-02f, 1.29764363e-01f, 3.09269667e-01f, 1.70240149e-01f, -9.20980573e-02f,
  -5.80544360e-02f, -1.13723136e-01f, 8.00624639e-02f, 4.20289710e-02f, 1.56262442e-01f, -4.73022722e-02f, 9.06236321e-02f, 6.34228811e-02f, 1.25769541e-01f, 1.33280337e-01f,
  1.14264846e-01f, 8.12793374e-02f, 7.46958107e-02f, -1.40673630e-02f, 7.31243342e-02f, -3.03494744e-02f, 1.57832447e-02f, -7.64841819e-03f, 2.52071787e-02f, 3.77575755e-02f,
  1.30013704e-01f, 1.00567462e-02f, -2.97492463e-02f, 5.94358221e-02f, -3.24878134e-02f, 1.46394186e-02f, -6.82742745e-02f, -5.20638116e-02f, 4.67895232e-02f, -4.48717475e-02f,
  5.97640350e-02f, 1.00726239e-01f, 5.92854470e-02f, -2.57331561e-02f, 1.48609161e-01f, 1.03463843e-01f, 3.70863429e-03f, -1.14799984e-01f, 4.21199836e-02f, 7.22504454e-03f,
  -5.33541024e-01f, -7.49759078e-02f, -9.78909507e-02f, -1.14175461e-01f, -1.63765643e-02f, 7.83342049e-02f, -8.71561375e-03f, -1.01041824e-01f, -7.36437738e-02f, -3.51884426e-03f,
  2.90112048e-02f, 1.29134804e-01f, 3.04668639e-02f, -1.45790987e-02f, 1.08996145e-01f, -7.63070658e-02f, -1.44154280e-01f, -1.14802361e-01f, -5.45596406e-02f, -1.61324441e-02f,
  1.06526516e-01f, -1.61840901e-01f, -4.11923259e-01f, -4.76002432e-02f, -5.97311296e-02f, -1.73399121e-01f, -1.58599406e-01f, -6.00730553e-02f, -6.05005324e-02f, -2.82663018e-01f,
  -9.40035820e-01f, 1.37390971e-01f, 5.65367937e-01f, -6.51962757e-01f, -5.51151454e-01f, -6.06223166e-01f, -3.01515311e-01f, -3.39010954e-01f, -2.63927430e-01f, 1.08143710e-01f,
  3.53973180e-01f, 2.77969480e-01f, 8.34691465e-01f, 2.59638608e-01f, -2.79351324e-01f, 2.09209532e-01f, 5.90443499e-02f, -1.30364284e-01f, -5.09222209e-01f, -8.28296185e-01f,
  -6.25521660e-01f, -5.36824465e-01f, -4.55229461e-01f, 4.73730862e-02f, 1.99481249e-01f, 1.94685504e-01f, 5.67545116e-01f, -2.58936405e-01f, 8.75957459e-02f, 7.08028227e-02f,
  3.83079052e-01f, -2.05784023e-01f, -8.66689831e-02f, -4.05927956e-01f, 1.38539881e-01f, -1.07398540e-01f, -2.83139409e-03f, 1.35599837e-01f, 6.25624731e-02f, 1.14649646e-01f,
  -5.98845817e-02f, -1.39115438e-01f, 1.30826803e-02f, -3.73149961e-02f, -1.02384984e-01f, -1.22232907e-01f, 4.18967940e-03f, -1.64681271e-01f, 4.89658266e-02f, 2.86460549e-01f,
  6.46917000e-02f, -2.76677370e-01f, 2.34128628e-02f, 2.05560829e-02f, -3.52804214e-02f, -5.25846481e-02f, 1.24283276e-01f, -1.29787289e-02f, -1.07550018e-01f, 1.40645966e-01f,
  -7.51705840e-02f, 2.93792248e-01f, -5.98464459e-02f, 2.11436804e-02f, -1.62581541e-02f, 6.16287701e-02f, 1.11200713e-01f, 3.49671058e-02f, 4.51496020e-02f, 1.35837451e-01f,
  -5.27340919e-02f, 5.49679808e-03f, 4.36103828e-02f, -4.61747125e-03f, 2.91967066e-03f, -2.36468419e-04f, -4.13518772e-02f, -5.24680391e-02f, -3.20807751e-03f, -5.05346470e-02f,
  -1.35739654e-01f, -1.16125897e-01f, 5.71566932e-02f, 1.26067996e-01f, -1.12014145e-01f, -7.32599199e-03f, 9.02514607e-02f, -9.85031016e-03f, -6.56051263e-02f, -4.52812463e-02f,
  3.64696920e-01f, -2.48912752e-01f, 2.30220973e-01f, 8.19838122e-02f, 1.25815153e-01f, 6.47756085e-02f, 1.14549533e-01f, -9.69482772e-03f, 7.46502951e-02f, -9.65688229e-02f,
  -4.98715006e-02f, -8.29298981e-03f, 2.71583229e-01f, 7.06671998e-02f, -1.94732681e-01f, -6.15261197e-02f, -4.38322388e-02f, -7.43223280e-02f, -7.16398656e-02f, -3.18936743e-02f,
  -5.17414659e-02f, -1.61948785e-01f, -4.16180678e-02f, 4.63492144e-03f, -4.56778333e-02f, -3.86673510e-02f, 2.89268970e-01f, 1.08841129e-01f, 2.34129824e-04f, 9.40015167e-02f,
  7.79635385e-02f, 4.67807986e-02f, -4.78376359e-01f, 4.51795936e-01f, 1.00009874e-01f, -2.94520080e-01f, -4.04342562e-01f, -3.50513250e-01f, 1.21296309e-01f, 1.40945911e-02f,
  -1.47073165e-01f, 2.97834635e-01f, 1.73687324e-01f, 2.24973634e-01f, 2.13946421e-02f, 1.79613486e-01f, 3.68834168e-01f, 1.58586621e-01f, -2.26190358e-01f, 9.86883491e-02f,
  3.93833429e-01f, 1.41373932e-01f, -2.72014916e-01f, 2.86743566e-02f, 4.45588171e-01f, 3.05626988e-01f, 3.55404429e-02f, 1.68974161e-01f, 2.14820862e-01f, 1.12155223e+00f,
  3.78983974e-01f, -8.56702030e-02f, 8.56337473e-02f, -1.35703636e-02f, -2.57634073e-02f, -2.57598720e-02f, -9.40876305e-02f, 1.31218061e-01f, 5.91941923e-02f, -1.45404702e-02f,
  8.38765278e-02f, -1.34661674e-01f, 1.29638538e-01f, 9.37139019e-02f, -1.49257287e-01f, -1.80266187e-01f, -9.95894372e-02f, 3.02690361e-03f, -1.05990842e-01f, -2.67190095e-02f,
  6.39525950e-01f, 2.23459467e-01f, -4.00527775e-01f, -2.82190144e-01f, -1.79694533e-01f, 1.53679237e-01f, -1.71751276e-01f, -4.49066609e-02f, -5.38925290e-01f, 1.13772057e-01f,
  -9.75858569e-02f, 6.31872658e-03f, -9.90681257e-03f, 4.61622439e-02f, 3.12918029e-03f, 5.78945875e-02f, 1.62313327e-01f, 1.14428420e-02f, 5.77366799e-02f, 1.70061998e-02f,
  4.93989624e-02f, -1.69513356e-02f, 3.04842554e-02f, -1.06599234e-01f, 8.36787447e-02f, 1.54748365e-01f, -1.01477779e-01f, -2.51537804e-02f, -6.90919310e-02f, -4.55822870e-02f,
  2.00038895e-01f, 7.67136458e-03f, 7.87483752e-02f, 3.85231785e-02f, -2.79170386e-02f, 5.25092147e-02f, 6.24854229e-02f, -1.46886125e-01f, -4.80422471e-03f, 1.23047633e-02f,
  -2.50195742e-01f, -5.26986182e-01f, 3.40287358e-01f, -1.26836091e-01f, -7.41510093e-02f, 9.77574848e-03f, 7.11132959e-02f, -7.85754919e-02f, 3.19535546e-02f, -1.03690485e-02f,
  -1.25778556e-01f, 7.87656158e-02f, -2.77614761e-02f, 1.04971871e-01f, -1.03962710e-02f, -1.74099892e-01f, -6.54460862e-02f, 5.95639944e-02f, -1.10859923e-01f, -8.25668499e-02f,
  1.06006302e-01f, -2.34455675e-01f, -3.06431383e-01f, -8.75419453e-02f, 8.67081955e-02f, -1.19787715e-01f, -1.72551200e-01f, -1.29552335e-01f, -7.26764202e-01f, -5.26736140e-01f,
  -9.01905835e-01f, 5.60015738e-01f, 1.99599452e-02f, -5.03835142e-01f, 3.70033622e-01f, 4.49943870e-01f, 7.39712119e-01f, 1.82348803e-01f, -2.36883268e-01f, 2.11061537e-01f,
  2.64509231e-01f, -2.20784783e-01f, -1.21024147e-01f, 1.60395876e-02f, 3.33880454e-01f, 4.69499141e-01f, 1.60655782e-01f, -1.64528400e-01f, -1.84794322e-01f, 1.90227162e-02f,
  2.36048847e-01f, -3.13914418e-01f, -5.48857391e-01f, -2.06810340e-01f, -9.44860354e-02f, -3.69795322e-01f, -8.57036263e-02f, -8.74123573e-02f, 2.80427158e-01f, -8.21831450e-02f,
  1.07688643e-01f, 7.70915821e-02f, 7.26009458e-02f, -2.56079584e-01f, -1.96960103e-02f, -2.07770273e-01f, 6.94466159e-02f, -6.84664100e-02f, -9.36433382e-04f, -6.68974221e-02f,
  -6.74332157e-02f, -7.43173482e-03f, 3.64619978e-02f, 2.75918692e-02f, 5.02675325e-02f, 8.39084387e-02f, -1.60899311e-01f, -2.11098194e-01f, -2.65180860e-02f, -2.36463770e-02f,
  2.66983628e-01f, 2.32738703e-01f, 1.25964686e-01f, 2.30092555e-01f, 2.26930678e-01f, -2.37360135e-01f, 1.39715984e-01f, -5.56805581e-02f, -3.39324623e-02f, -3.41463625e-01f,
  -5.79975061e-02f, 5.16495779e-02f, 1.42432660e-01f, -9.29950923e-02f, -4.99686599e-02f, 9.81749780e-03f, 9.57897864e-03f, 1.17090931e-02f, 7.87015930e-02f, -6.30746037e-02f,
  1.30491257e-02f, -2.43196380e-03f, 3.93050611e-02f, -6.81290254e-02f, -8.95197913e-02f, 6.47539645e-02f, 7.73558989e-02f, -2.71098968e-02f, 1.01415008e-01f, -5.73140606e-02f,
  -3.09865456e-02f, 3.02853528e-02f, 2.36781705e-02f, 6.12534024e-03f, 1.36799842e-01f, -1.33156121e-01f, -8.76577497e-02f, 4.12426144e-02f, -5.71357384e-02f, -5.20689823e-02f,
  -6.52364016e-01f, 3.42427999e-01f, -1.26876950e-01f, 9.40636024e-02f, 5.94161684e-03f, -4.29446772e-02f, -1.97060406e-02f, -8.44014809e-02f, -1.13059403e-02f, -1.17542937e-01f,
  8.95965025e-02f, -6.74671233e-02f, 1.34363398e-01f, -6.45626336e-02f, -6.39203563e-02f, -3.20306607e-02f, 3.02805752e-02f, -4.94053774e-02f, 5.13697825e-02f, -2.58802503e-01f,
  1.16183124e-02f, -1.09088443e-01f, -2.64337808e-01f, -7.37736002e-02f, -1.75086379e-01f, -1.75231576e-01f, 3.43598090e-02f, -1.72409445e-01f, 2.66966075e-01f, -2.46656835e-01f,
  -9.43611205e-01f, 4.58817124e-01f, 7.11883828e-02f, -1.24529958e-01f, 2.73355603e-01f, 2.21477211e-01f, 3.63212526e-01f, 5.38384989e-02f, -2.57799532e-02f, 2.69601613e-01f,
  2.57083029e-01f, -3.10074598e-01f, -1.62597150e-01f, -2.85747945e-01f, -2.74523318e-01f, 1.58605859e-01f, 1.64682940e-01f, -4.64811206e-01f, -6.45724773e-01f, -3.53045017e-01f,
  -3.14127773e-01f, -3.75514001e-01f, -4.00459677e-01f, -1.30011961e-01f, 2.25261986e-01f, -6.00913092e-02f, 2.20424473e-01f, 1.38624743e-01f, 3.50569367e-01f, 1.18158184e-01f,
  7.03960611e-03f, 2.63709784e-01f, -2.45427132e-01f, -1.10318437e-01f, 1.01625666e-01f, -1.18801497e-01f, -1.07852399e-01f, -3.58033143e-02f, 6.40359893e-02f, 8.47377405e-02f,
  1.49504259e-01f, -4.98151891e-02f, -1.19852871e-01f, 2.30978820e-02f, -4.29583453e-02f, -1.14109758e-02f, 6.86027408e-02f, 1.78781990e-02f, 4.47388291e-02f, 2.06828743e-01f,
  8.33082646e-02f, 9.43940356e-02f, 2.36708581e-01f, 2.31434122e-01f, 1.26562506e-01f, 9.54317302e-02f, 2.24167660e-01f, 1.14672191e-01f, 7.81337395e-02f, 9.66099799e-02f,
  -2.12158393e-02f, -8.85613542e-03f, -2.96100434e-02f, -2.62176245e-02f, -5.28467931e-02f, 1.73856720e-01f, -2.09838268e-03f, -2.20133848e-02f, -1.02485560e-01f, 2.19963845e-02f,
  9.88612920e-02f, 8.93071294e-02f, -5.58899045e-02f, -1.66525450e-02f, -7.77442902e-02f, 8.23876932e-02f, -1.81631241e-02f, 3.74541469e-02f, 2.85145994e-02f, 1.49525538e-01f,
  -8.35923254e-02f, 1.30710959e-01f, -1.12911031e-01f, -7.84524828e-02f, 1.58727422e-01f, 3.84098440e-02f, 1.15853384e-01f, -7.57747190e-03f, -2.99273655e-02f, -4.06881198e-02f,
  -5.03729694e-02f, -9.82868224e-02f, -2.80760258e-01f, -8.31074119e-02f, 6.23655319e-02f, 3.97697948e-02f, -8.23647436e-03f, 8.96432921e-02f, 7.59395733e-02f, 1.46091193e-01f,
  7.47732222e-02f, -7.24058971e-02f, -1.09659205e-03f, 6.30513653e-02f, -1.50253221e-01f, -3.19688022e-02f, 1.61901057e-01f, 4.79890034e-02f, 1.31693989e-01f, 2.20629290e-01f,
  7.92782009e-02f, 6.25377968e-02f, -8.37831125e-02f, 1.05172843e-01f, 4.78256866e-02f, -1.55479714e-01f, 2.01904383e-02f, -3.61827090e-02f, -5.50962538e-02f, -2.11570207e-02f,
  -4.88528430e-01f, -4.57186908e-01f, 9.07187685e-02f, -1.13538496e-01f, 2.05881611e-01f, 1.83960184e-01f, -5.03723741e-01f, 2.26207264e-02f, 2.75704652e-01f, -5.17726481e-01f,
  1.11683188e-02f, 2.54076332e-01f, -1.42142609e-01f, -1.75745904e-01f, -5.12018561e-01f, -7.27221489e-01f, -5.32825291e-01f, -2.11787686e-01f, 3.15904766e-02f, 4.26512241e-01f,
  -1.05723143e-01f, -1.66579902e-01f, 7.61253163e-02f, 1.18272468e-01f, 1.62641317e-01f, 1.19378358e-01f, 5.42406887e-02f, 8.67846236e-02f, -1.34635910e-01f, -3.53397876e-01f,
  -2.03579411e-01f, -1.32724687e-01f, 2.55712360e-01f, -1.17590062e-01f, 1.88698888e-01f, -9.78654325e-02f, -8.85594040e-02f, -9.62126479e-02f, 1.84654184e-02f, -8.24743211e-02f,
  7.07213208e-02f, 5.53850494e-02f, 3.02545309e-01f, 3.50272134e-02f, 9.72615629e-02f, -1.37905777e-01f, 8.62497315e-02f, -7.54776523e-02f, -2.74141818e-01f, -6.56900778e-02f,
  -1.16949439e-01f, 1.09825596e-01f, -2.78992299e-02f, 6.29001036e-02f, 2.57187989e-02f, 1.99618950e-01f, 2.25827694e-01f, 2.09059060e-01f, -2.50411164e-02f, -1.13886379e-01f,
  6.75105155e-02f, 7.01886043e-02f, 5.38480580e-02f, -5.28266914e-02f, -8.71171951e-02f, -4.99327965e-02f, 5.72184399e-02f, -3.40854749e-02f, 1.82109728e-01f, -1.44451767e-01f,
  3.43990922e-02f, 3.89695577e-02f, 3.70297371e-03f, -3.48879173e-02f, -1.85850989e-02f, -2.18930990e-02f, 2.38936651e-03f, -2.14220017e-01f, -1.27954587e-01f, 1.04602210e-01f,
  -2.18098193e-01f, 2.19439596e-01f, -2.63568200e-02f, 1.60791665e-01f, -4.92594019e-03f, -8.20469260e-02f, -4.79347743e-02f, 3.48873399e-02f, -5.58831133e-02f, -1.32501796e-01f,
  -9.15785730e-02f, 1.53968900e-01f, -9.20430869e-02f, -8.94096419e-02f, -5.23886681e-02f, 5.25710033e-03f, 6.29930347e-02f, -5.74914739e-02f, 5.30407727e-02f, -5.41881919e-02f,
  -2.38848720e-02f, -9.24516991e-02f, 6.37585595e-02f, 1.10229999e-01f, 8.01607734e-04f, -4.11253311e-02f, -1.80048048e-01f, -1.52076170e-01f, 2.28262376e-02f, 1.21126063e-01f,
  -1.58551112e-01f, -4.71087247e-01f, -3.84476662e-01f, -2.53050506e-01f, 6.60658395e-03f, -3.40118229e-01f, -1.22160375e-01f, -1.63330603e-02f, -4.35858339e-01f, -7.13839173e-01f,
  4.20448273e-01f, 6.08140647e-01f, 4.03538495e-01f, 6.64339587e-02f, -1.79392844e-01f, -8.39618295e-02f, 1.42699495e-01f, 1.51354656e-01f, -1.40620679e-01f, 1.28918961e-01f,
  5.56238033e-02f, -2.66397834e-01f, -5.68436421e-02f, 4.88815680e-02f, 1.18497387e-01f, 1.12520821e-01f, 4.93789501e-02f, 9.81517583e-02f, 5.02357958e-03f, -1.51414990e-01f,
  -1.16922528e-01f, 4.90828976e-02f, 2.70041168e-01f, 9.51761231e-02f, -3.71265598e-02f, -1.45636171e-01f, 5.26137725e-02f, 1.59081772e-01f, 2.06841484e-01f, 1.76701531e-01f,
  4.65407521e-01f, 4.53548878e-01f, -1.28975078e-01f, -3.25525887e-02f, 9.72982571e-02f, 2.25139469e-01f, 1.94491036e-02f, 1.68236911e-01f, -1.58050228e-02f, 5.11814170e-02f,
  1.24237295e-02f, 3.65062468e-02f, 2.78672129e-02f, 6.89175166e-03f, -7.49332411e-03f, 4.46398370e-02f, 1.75057165e-02f, 1.45814583e-01f, 1.86499655e-01f, 4.67994995e-02f,
  -1.76114008e-01f, 5.53596355e-02f, -1.13336230e-03f, 9.63107962e-03f, -7.10693076e-02f, -7.00483397e-02f, 5.97715452e-02f, 1.24042749e-01f, 7.51106367e-02f, -1.91419572e-02f,
  -1.19967565e-01f, -8.62840638e-02f, 2.75317067e-03f, 1.65664963e-02f, -1.10429324e-01f, -1.75677408e-02f, -5.91531098e-02f, -1.17852457e-01f, -4.98753786e-02f, -6.62286952e-02f,
  -1.11641593e-01f, 1.29358396e-02f, 1.32430837e-01f, -3.08321938e-02f, -1.44243464e-01f, 8.02375935e-03f, 2.13309191e-02f, 8.31822678e-02f, 4.77583520e-02f, 1.00290187e-01f,
  -4.73124087e-02f, 8.33810344e-02f, -2.49312334e-02f, 8.41719359e-02f, 7.35500902e-02f, -3.23997475e-02f, -9.79451016e-02f, -5.58371283e-02f, -1.39785662e-01f, -4.35779803e-02f,
  1.76241577e-01f, -3.93854716e-04f, -3.54615375e-02f, 2.39463151e-02f, 5.36683202e-02f, 1.77662317e-02f, 1.89221315e-02f, 7.63409659e-02f, 1.39139637e-01f, 1.08839177e-01f,
  1.84678249e-02f, 4.84535210e-02f, 7.36788511e-02f, -1.21432021e-01f, -2.62992114e-01f, -5.34703694e-02f, 3.65563408e-02f, 2.77208462e-02f, 1.40067637e-01f, 9.58100483e-02f,
  -3.71213891e-02f, -8.67691934e-02f, -1.12805469e-02f, -1.06761485e-01f, -8.85583311e-02f, -2.10218370e-01f, -1.29061118e-01f, -1.01620853e-01f, -7.08716037e-03f, -1.63097620e-01f,
  9.80889738e-01f, -8.50313842e-01f, 4.40776229e-01f, -4.22463417e-02f, -1.49625033e-01f, 1.95657536e-01f, -2.47293174e-01f, 2.72367038e-02f, -1.14804087e-03f, -2.40610570e-01f,
  -1.94113418e-01f, 2.03952640e-01f, 2.49818355e-01f, 2.10494921e-01f, 2.69234836e-01f, -1.20797656e-01f, -1.50425673e-01f, 4.53250557e-01f, 7.07662284e-01f, 1.61747813e-01f,
  -3.21949184e-01f, -2.69118994e-01f, 1.78571150e-01f, -3.85010913e-02f, -4.91602480e-01f, 1.25367105e-01f, -1.54063433e-01f, -2.32111305e-01f, -1.06357239e-01f, -3.62434119e-01f,
  2.55352825e-01f, 3.98869477e-02f, 3.59474093e-01f, -6.11479394e-02f, -1.43998459e-01f, 6.66675791e-02f, 1.22625917e-01f, 2.41755396e-02f, -1.17175661e-01f, -4.23856378e-02f,
  -8.25906694e-02f, -1.20949140e-02f, 1.33772045e-01f, -1.96872875e-02f, -4.24491763e-02f, 8.10531974e-02f, -1.08111382e-01f, 2.26690397e-02f, 7.04640076e-02f, -3.88973765e-02f,
  -1.30789697e-01f, 5.25789186e-02f, -5.47112944e-03f, 1.29705407e-02f, 9.49980617e-02f, 7.80688748e-02f, -1.22445576e-01f, -2.52488609e-02f, 2.31740043e-01f, -1.22941300e-01f,
  -1.45901263e-01f, 1.09419554e-01f, 1.05514646e-01f, 3.34785320e-02f, 3.16847186e-03f, -3.55532579e-02f, 4.77846935e-02f, 9.14952531e-03f, 7.67651796e-02f, -8.60968977e-02f,
  -1.13290697e-01f, 8.16259310e-02f, -2.70073395e-03f, -9.02079940e-02f, -1.13818450e-02f, 4.10828143e-02f, 1.61926150e-02f, 1.74894352e-02f, 4.66238596e-02f, -5.72659150e-02f,
  4.19292971e-02f, 1.88236069e-02f, 5.21399733e-03f, -9.53346267e-02f, -1.53984487e-01f, 2.82444190e-02f, 1.06109537e-01f, -6.72491118e-02f, -5.48763424e-02f, -1.09092228e-01f,
  -2.40509376e-01f, 4.02310282e-01f, 8.41735527e-02f, 7.68119544e-02f, -4.67669889e-02f, -1.17368557e-01f, 4.24438268e-02f, -1.03275692e-02f, -1.11107819e-01f, -5.34859076e-02f,
  -5.28565608e-02f, 1.48872256e-01f, -5.41366339e-02f, -9.12058651e-02f, 7.69964233e-02f, -5.08263882e-04f, -1.31126210e-01f, 1.39696226e-01f, -1.59566365e-02f, -1.16125382e-01f,
  -1.74180180e-01f, 1.37727469e-01f, 2.64020443e-01f, 1.63782910e-01f, -1.58116706e-02f, 3.95903736e-01f, 7.67244175e-02f, -6.47696182e-02f, 1.38648346e-01f, -3.20702702e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.63058418e-01f, 3.65162678e-02f, 4.29730296e-01f, 5.55721879e-01f, 3.07108432e-01f, 3.23565960e-01f, 2.22078413e-01f, 2.98846006e-01f, -1.98085412e-01f, 4.23184663e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -5.78219630e-03f, 1.76274627e-01f, 1.65231869e-01f, 1.40038937e-01f, -4.28204834e-01f, 5.07019758e-02f, -1.81281045e-01f, 2.18826577e-01f, 1.78527147e-01f, -1.10840879e-01f,
  3.73424962e-02f, 6.29624009e-01f, -8.11851248e-02f, -5.52433431e-01f, 1.47750467e-01f, -3.00240815e-01f, -7.46906698e-02f, -4.56621200e-02f, 1.14712961e-01f, 1.27960548e-01f,
  -1.26732111e-01f, 3.54462832e-01f, 2.95534372e-01f, -4.47447628e-01f, 4.73176427e-02f, 7.00275823e-02f, -3.95019092e-02f, 2.09565356e-01f, -3.56096089e-01f, -4.06913817e-01f,
  -1.62169948e-01f, 1.28368661e-01f, 9.72255990e-02f, 2.71584481e-01f, -2.27721587e-01f, -2.22889096e-01f, 5.01879036e-01f, -1.60550773e-01f, 9.54822153e-02f, 3.22537690e-01f,
  -2.80760348e-01f, -1.07865267e-01f, -2.47562170e-01f, -2.14813594e-02f, 2.95422524e-02f, 3.49247038e-01f, -2.01636299e-01f, -1.42230406e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  9.42186952e-01f, 2.27191985e-01f, 3.76538247e-01f, -3.17964464e-01f, -3.81351084e-01f, -4.28869128e-01f, 6.40960187e-02f, -1.15128529e+00f, -7.01748788e-01f, 6.72049403e-01f,
  -4.08051938e-01f, -4.99871463e-01f, -6.04864717e-01f, -1.21023369e+00f, -5.44127941e-01f, 4.61770236e-01f, 2.49609634e-01f, 8.25856984e-01f, 9.22320724e-01f, -1.09995306e-01f,
  2.14006901e-01f, -8.59458566e-01f, -7.83709764e-01f, -5.68922043e-01f, -1.34457231e+00f, 7.20735729e-01f, -4.02093709e-01f, 5.09973049e-01f, 6.30041063e-01f, -1.35139272e-01f,
  -4.57984537e-01f, -1.58608332e-01f, 2.68505305e-01f, -3.34020555e-01f, 9.05982926e-02f, -5.03801823e-01f, -8.07024479e-01f, 1.78707376e-01f, 2.90157646e-01f, -3.44458669e-01f,
  2.02251375e-01f, 2.92386651e-01f, -6.35334700e-02f, -5.12216687e-01f, -2.34550774e-01f, -4.43729550e-01f, -3.85173798e-01f, 6.53792679e-01f, 9.57827717e-02f, 2.15075359e-01f,
  3.48045796e-01f, 1.91862673e-01f, 8.21092188e-01f, -3.59127253e-01f, 1.34080261e-01f, 8.92076790e-02f, 3.64852965e-01f, 3.34075004e-01f, 3.80883098e-01f, -1.17588747e+00f,
  -4.46884513e-01f, -2.79165357e-01f, 3.69829208e-01f, 5.58974385e-01f, 1.25198305e-01f, 1.10579811e-01f, 3.22856426e-01f, 4.67998028e-01f, -8.11348259e-01f, 1.56756729e-01f,
  3.99503708e-01f, 2.71592677e-01f, 6.18791997e-01f, -3.22238505e-01f, 5.13979614e-01f, 9.34071839e-01f, 1.53018385e-01f, -6.92178085e-02f, -1.91174954e-01f, 1.15496129e-01f,
  3.54869217e-01f, 6.91446364e-01f, 6.13853097e-01f, -5.94051719e-01f, 1.08452570e+00f, -6.72290981e-01f, 6.89506382e-02f, -4.30984050e-01f, 3.54057163e-01f, 4.29285407e-01f,
  -2.02377647e-01f, -5.84752738e-01f, 1.50460154e-01f, -7.62068946e-03f, -2.80615211e-01f, 1.25958189e-01f, 4.59946334e-01f, 3.23103309e-01f, 6.13421023e-01f, -4.25549209e-01f,
  -5.22588253e-01f, -5.41365385e-01f, 7.04159662e-02f, 2.24215597e-01f, -8.20237935e-01f, 7.76374698e-01f, 7.03522205e-01f, 9.45315301e-01f, 4.44317281e-01f, -3.59970003e-01f,
  -7.48764157e-01f, -8.06335092e-01f, -1.29126698e-01f, -2.05849349e-01f, 8.80819485e-02f, -5.81813306e-02f, 4.91168171e-01f, -9.29990411e-02f, -4.80940968e-01f, -7.02378273e-01f,
  -9.27207112e-01f, 5.65351844e-01f, -1.00190409e-01f, -8.10194463e-02f, 5.89568675e-01f, 5.40836990e-01f, 1.22787282e-01f, 5.43688595e-01f, 4.22135860e-01f, 1.11140065e-01f,
  1.92978919e-01f, -1.23083964e-01f, 1.21812381e-01f, -6.45860553e-01f, 2.15447783e-01f, 2.76804924e-01f, -4.93841887e-01f, 5.39389700e-02f, 4.63826984e-01f, 1.10354371e-01f,
  2.36643910e-01f, 8.82838741e-02f, -5.86676955e-01f, -6.75386190e-01f, -1.81416906e-02f, 1.84599340e-01f, -3.47653441e-02f, 3.00067186e-01f, -1.03675306e-01f, -9.79203582e-02f,
  2.74754226e-01f, -1.18631884e-01f, 1.11899525e-01f, -1.16087556e-01f, -5.05909920e-01f, 8.17719042e-01f, 5.72850585e-01f, 5.00318885e-01f, 2.71854937e-01f, -9.96013433e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  1.06021881e+00f, 5.71175218e-01f, 2.42728308e-01f, 2.74014592e-01f, 5.87658405e-01f, 6.28243536e-02f, 6.09747052e-01f, 7.74784610e-02f, 2.52558351e-01f, -4.94300723e-02f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.99509352e-01f, 1.35482401e-01f, 2.74819564e-02f, -1.69879273e-01f, 6.70996785e-01f, 4.01926458e-01f, -1.62661508e-01f, 1.39315231e-02f, 2.02054441e-01f, -1.02838509e-01f,
  -1.80952564e-01f, -3.71983051e-01f, 3.67119133e-01f, 3.64761412e-01f, 2.44813830e-01f, 2.73887783e-01f, 1.83095828e-01f, 2.22116336e-01f, -1.53621256e-01f, -1.62383988e-01f,
  3.52285981e-01f, -6.66636109e-01f, 4.72141922e-01f, 2.92718150e-02f, 2.68585473e-01f, -1.24728687e-01f, -1.87825456e-01f, -3.62403095e-01f, -2.20991611e-01f, 4.43086103e-02f,
  -1.87458828e-01f, -9.91652533e-02f, 8.70600492e-02f, 1.87780127e-01f, 7.90265426e-02f, -7.25096345e-01f, 9.74356905e-02f, -3.38393420e-01f, 3.47897768e-01f, -2.83580959e-01f,
  2.60050833e-01f, 2.35648632e-01f, -1.23491950e-01f, 1.62209049e-01f, -2.45680720e-01f, 8.81247669e-02f, -1.24972135e-01f, 7.72939250e-02f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.72293317e-02f, 5.53565919e-02f, 1.69240415e-01f, 6.10879948e-03f, 4.03687626e-01f, -1.32695782e+00f, 9.28601623e-03f, -1.09972186e-01f, 4.37907130e-01f, -1.58065572e-01f,
  5.76750338e-01f, -8.46124515e-02f, -2.71145076e-01f, 5.68100670e-03f, -8.90240148e-02f, 3.48473974e-02f, -2.90222228e-01f, -3.57210487e-02f, 5.19190371e-01f, 5.10261893e-01f,
  3.86385955e-02f, 4.09401119e-01f, 8.46717298e-01f, 1.36022508e+00f, -2.83041686e-01f, -6.68444753e-01f, -1.24460325e-01f, 4.70426470e-01f, 1.08942389e+00f, 6.31571591e-01f,
  2.28742644e-01f, -7.65812024e-02f, 4.76687104e-02f, -4.99461532e-01f, -7.83016682e-02f, 2.34927952e-01f, -3.81441951e-01f, -1.03161478e+00f, -4.79027301e-01f, -9.06415999e-01f,
  -7.16063976e-01f, 1.83870345e-01f, 4.82167840e-01f, -6.87588990e-01f, 1.47110462e-01f, -3.67076516e-01f, 5.75728714e-01f, 3.08150142e-01f, 4.75540966e-01f, 1.94168523e-01f,
  -7.12361753e-01f, 7.70715177e-01f, 5.70327401e-01f, -1.70757818e+00f, 2.69811183e-01f, -5.44754565e-02f, 4.78213310e-01f, -8.60301480e-02f, 1.13961525e-01f, -2.31491059e-01f,
  6.66662455e-01f, 4.20478076e-01f, -1.16242059e-01f, -8.13621044e-01f, 1.27030361e+00f, 3.76692086e-01f, 1.37352556e-01f, 2.13321298e-01f, 8.75307620e-01f, 2.77385384e-01f,
  7.38675296e-01f, 2.76268661e-01f, 2.61036575e-01f, -3.83782417e-01f, 7.08153769e-02f, -4.90061462e-01f, 9.90921617e-01f, -7.95370281e-01f, 7.69236922e-01f, -3.94142270e-01f,
  7.94622838e-01f, -6.63917735e-02f, 9.39796150e-01f, -1.37619662e+00f, -8.87668848e-01f, 1.36412108e+00f, 9.68419909e-02f, -1.36965634e-02f, 2.91042447e-01f, 3.63759547e-01f,
  1.67541176e-01f, 6.18513107e-01f, 4.24614042e-01f, -1.00065291e+00f, 5.54944932e-01f, -6.24343693e-01f, -2.28867486e-01f, -1.83260083e-01f, 4.72214788e-01f, -8.29677284e-01f,
  7.56505430e-01f, -2.59505451e-01f, 1.32506549e+00f, 8.05316150e-01f, 5.25951743e-01f, 6.18039608e-01f, 2.11238623e-01f, 8.21192026e-01f, -3.72336149e-01f, 1.85145274e-01f,
  -7.13332891e-01f, -6.05606377e-01f, 5.57249784e-01f, 6.24322891e-01f, 9.57396984e-01f, 8.17772746e-01f, 4.57792014e-01f, -7.41815567e-01f, 5.01135826e-01f, 1.50103971e-01f,
  2.70813465e-01f, -7.70091832e-01f, 2.79698044e-01f, -1.49195030e-01f, -5.56629479e-01f, -3.26011598e-01f, -1.27977058e-01f, 4.09579694e-01f, 9.83820021e-01f, 2.26047501e-01f,
  7.07274795e-01f, 1.43057561e+00f, -2.48665720e-01f, -6.01696730e-01f, -1.52197137e-01f, 5.37549734e-01f, -1.09542251e+00f, 2.72769183e-01f, 3.37263495e-01f, -4.16212469e-01f,
  7.83720255e-01f, -1.07412554e-01f, 7.15815723e-01f, -1.75550252e-01f, 8.37681442e-02f, -2.66457528e-01f, 3.05583775e-01f, -2.54796833e-01f, 2.79115558e-01f, -2.15712726e-01f,
  4.19620991e-01f, -2.80436903e-01f, 8.35867643e-01f, -4.81372297e-01f, 4.59187359e-01f, -5.65035343e-01f, 6.73503160e-01f, -2.12537825e-01f, 3.14693004e-01f, 3.96696061e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  4.93655920e-01f, 2.22674251e-01f, 3.46938252e-01f, -4.59359884e-02f, 6.39248669e-01f, 6.34167433e-01f, 2.09337682e-01f, 5.06055355e-01f, 3.68053734e-01f, 1.69911653e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -6.70175493e-01f, -5.65850548e-03f, 2.06035018e+00f, 1.42667544e+00f, -1.73449934e+00f, -1.04264200e+00f, -1.32563365e+00f, 5.06292462e-01f, -1.13069773e+00f, -1.14713264e+00f,
  -8.59714091e-01f, -2.49123931e-01f, -6.09948516e-01f, -9.08064663e-01f, -1.64686537e+00f, -3.95705044e-01f, 4.47184324e-01f, 4.86637980e-01f, -1.08749390e+00f, 1.91985667e-02f,
  5.03364146e-01f, 1.14625067e-01f, 2.47247890e-01f, -1.65925369e-01f, -3.78328818e-03f, -5.92977822e-01f, -1.38342369e+00f, 1.71245769e-01f, 9.09855545e-01f, -3.07203680e-01f,
  -5.43088019e-01f, 4.25657570e-01f, -6.96626604e-01f, -2.45168600e-02f, 2.94594675e-01f, -7.83571601e-01f, -1.00362957e+00f, 8.78080726e-01f, -6.83375955e-01f, -1.23163033e+00f,
  -6.24674797e-01f, -8.85186791e-01f, -1.80020428e+00f, 1.24553609e+00f, 3.17595690e-01f, -6.72737777e-01f, -6.12873018e-01f, -1.17842329e+00f, 3.26212347e-01f, -4.35512751e-01f,
  -7.65484750e-01f, 1.91924423e-01f, 1.05863959e-02f, 5.46168745e-01f, -3.54830861e-01f, 1.59144133e-01f, -9.36821938e-01f, -1.97551370e-01f, 1.15302719e-01f, -1.26869261e+00f,
  -9.48959768e-01f, -1.90597549e-01f, 6.15400910e-01f, 4.46110576e-01f, -6.05030358e-01f, -1.27078068e+00f, -4.90769148e-01f, -5.06430626e-01f, 8.69729638e-01f, -9.06173646e-01f,
  3.08427125e-01f, 5.29175580e-01f, 4.96998787e-01f, -4.11641479e-01f, -6.27318144e-01f, -2.24123061e-01f, 1.30321812e-02f, -1.74724907e-01f, -1.70331746e-01f, -3.78101587e-01f,
  1.05791330e+00f, 1.20370865e+00f, 3.90003860e-01f, 2.78949905e-02f, -5.16689479e-01f, 8.84778142e-01f, 2.55548716e-01f, 5.58438636e-02f, -5.17116547e-01f, -8.96366298e-01f,
  8.28729153e-01f, 3.72795999e-01f, 6.41856119e-02f, 2.04858944e-01f, -1.86298981e-01f, -4.45938110e-01f, -3.84805173e-01f, 2.31681824e-01f, 6.26729012e-01f, -9.16031241e-01f,
  1.77630320e-01f, 2.26907343e-01f, 2.56870776e-01f, -8.96328926e-01f, 1.28388837e-01f, 7.83854127e-01f, -8.26159954e-01f, -6.22029126e-01f, 3.46571475e-01f, -4.17752504e-01f,
  7.86946118e-01f, -9.51969266e-01f, -3.35005015e-01f, 8.96383170e-03f, -1.04336250e+00f, 5.87301731e-01f, 7.22225755e-03f, 3.68684709e-01f, 3.67046535e-01f, -3.02522749e-01f,
  4.62163955e-01f, 5.65279484e-01f, 5.37695169e-01f, -5.43828607e-01f, -3.79623652e-01f, -8.17818761e-01f, -2.54040241e-01f, 4.37573433e-01f, 2.64127851e-01f, -4.36242223e-01f,
  -3.67509991e-01f, 3.44272733e-01f, 9.53093350e-01f, 1.91250563e-01f, 5.16691744e-01f, -9.08508599e-01f, -4.51777130e-01f, 7.73304939e-01f, 5.14429152e-01f, -3.69812429e-01f,
  1.87357098e-01f, 8.24469864e-01f, -8.67973328e-01f, 4.82109755e-01f, 4.14628416e-01f, -1.99190065e-01f, 7.16539562e-01f, 1.98390618e-01f, -4.30194974e-01f, -2.85598785e-01f,
  -3.13899100e-01f, -1.09881699e+00f, 1.96726069e-01f, -8.96157503e-01f, 3.54622811e-01f, 7.29682744e-01f, -9.66844857e-01f, -7.21154809e-01f, 4.78797644e-01f, 2.94967711e-01f,
  -5.75852513e-01f, -4.35495675e-01f, -8.88030883e-03f, 4.88945454e-01f, 8.72867942e-01f, -2.03167684e-02f, -8.09813797e-01f, 6.56826422e-02f, -7.67877698e-01f, 1.32716548e+00f,
  4.11047101e-01f, -3.65667939e-01f, 1.21286940e-02f, -4.39066023e-01f, -5.77384830e-01f, 3.95063460e-01f, 5.51824093e-01f, -8.30398798e-02f, 5.81217468e-01f, -4.62103456e-01f,
  2.84915894e-01f, -7.48493731e-01f, 2.58236885e-01f, -5.60428321e-01f, 1.63862884e-01f, -7.69700170e-01f, -7.60596693e-01f, -6.37752652e-01f, -8.67338240e-01f, 1.04199708e+00f,
  4.44279015e-01f, 2.59144664e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  8.32525373e-01f, -4.52227861e-01f, 4.71346527e-01f, -8.27322483e-01f, -3.22013140e-01f, 2.92391688e-01f, -2.22384483e-01f, -6.79941699e-02f, -1.27197728e-01f, 1.85278013e-01f,
  -7.04908252e-01f, -3.47584516e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    