/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.61559898e-01f, -7.39351436e-02f, 2.31474951e-01f, 4.75409001e-01f, 4.94464487e-02f, -3.35163981e-01f, -2.78679878e-01f, 9.10498500e-02f, 3.23093385e-01f, -3.85955304e-01f,
  -1.95378825e-01f, 2.15065822e-01f, -3.86821777e-01f, 2.05306649e-01f, 3.93442750e-01f, -2.99771547e-01f, 9.39007327e-02f, -2.21180037e-01f, 1.54890507e-01f, -5.79091497e-02f,
  2.64775217e-01f, -1.02115445e-01f, 2.15741485e-01f, 1.68326264e-03f, 2.54030377e-01f, 2.55787700e-01f, 1.72849402e-01f, -8.00287053e-02f, 1.10970758e-01f, 1.09993614e-01f,
  -8.53589699e-02f, -3.24549861e-02f, 1.57104313e-01f, 8.15135799e-03f, 9.78923738e-02f, 1.84282791e-02f, -7.77479336e-02f, -8.32236782e-02f, 1.25147283e-01f, 1.12722069e-02f,
  -1.30925819e-01f, 2.14851671e-03f, 1.09872863e-01f, 2.70247124e-02f, -4.96114511e-03f, 4.19456139e-02f, 8.76729144e-04f, -5.19814938e-02f, 5.76521792e-02f, 1.07463472e-01f,
  2.22754143e-02f, 1.93732157e-02f, -6.90087536e-03f, -6.14942797e-02f, 9.78691578e-02f, 4.19492684e-02f, 6.51987419e-02f, 1.90075561e-02f, 1.05715156e-01f, 1.67119637e-01f,
  -3.43424752e-02f, 9.07546207e-02f, 1.34015316e-02f, 9.08447653e-02f, 8.89832154e-02f, 8.82670954e-02f, 3.88732441e-02f, 5.09744324e-02f, 4.94617373e-02f, 3.73940207e-02f,
  -6.22836947e-02f, -2.22475473e-02f, -7.47558549e-02f, -3.36615779e-02f, 8.20734911e-03f, 1.47603467e-01f, -5.20772897e-02f, -8.84344056e-02f, 4.17890549e-02f, 1.47856073e-02f,
  -1.56152183e-02f, -2.07932107e-02f, -2.28241831e-02f, 5.41447569e-03f, -7.62606710e-02f, 5.70640415e-02f, 6.72240630e-02f, 3.18830758e-02f, 1.42274909e-02f, -2.41223164e-02f,
  -1.65866181e-01f, 1.10167891e-01f, -3.37502472e-02f, -4.22709957e-02f, -1.27177954e-01f, -6.93471208e-02f, -2.19742861e-03f, 1.75567362e-02f, -6.73809415e-03f, -1.14998932e-03f,
  1.84509680e-02f, -7.40132853e-02f, -1.00852080e-01f, -2.05370523e-02f, -6.24587387e-02f, -6.11200668e-02f, -1.20768137e-01f, 1.67156681e-02f, 5.21759540e-02f, 3.04602087e-02f,
  -7.77361467e-02f, -1.00658745e-01f, -2.62649134e-02f, 4.80505377e-02f, -3.56344655e-02f, -3.20958719e-02f, 6.23263828e-02f, 3.95770520e-02f, -1.67433973e-02f, -6.24426790e-02f,
  -1.12171419e-01f, -1.03233740e-01f, 1.51088282e-01f, 3.92191857e-02f, 4.38931324e-02f, 2.93831348e-01f, 8.11518952e-02f, 6.99245408e-02f, -1.72355637e-01f, -1.53382659e-01f,
  4.83167097e-02f, -8.71789679e-02f, -1.79230511e-01f, 3.40087026e-01f, -6.16323538e-02f, -9.39105079e-02f, 2.82714128e-01f, 6.56791180e-02f, -4.28730696e-02f, -5.06105199e-02f,
  7.36923516e-03f, 1.98403429e-02f, 2.16636449e-01f, -7.89801702e-02f, 1.46781877e-01f, -1.62728652e-01f, -3.41359735e-01f, -1.27463907e-01f, 1.87901542e-01f, 9.33380276e-02f,
  3.12155038e-01f, -2.95094103e-02f, 1.23098731e-01f, 1.08616017e-01f, -2.56148092e-02f, -3.96290272e-02f, -4.13353322e-03f, -6.59409687e-02f, 2.41904687e-02f, -4.84867766e-02f,
  -2.39389494e-01f, -4.52426262e-02f, 8.22278559e-02f, -1.64960057e-01f, -2.10888628e-02f, -2.16531511e-02f, 1.10090338e-01f, 1.25328049e-01f, 4.86118607e-02f, 7.48412162e-02f,
  4.54999469e-02f, 3.77271920e-02f, 7.01413155e-02f, -5.72177283e-02f, -7.15355650e-02f, -1.08047329e-01f, 4.18049879e-02f, 5.42374700e-02f, 5.72809484e-03f, -8.66176486e-02f,
  -2.88678873e-02f, -7.47935921e-02f, -7.57591147e-03f, 1.10245883e-01f, -5.58897294e-02f, 7.67878070e-02f, -1.88858937e-02f, 3.80627322e-03f, -7.37510398e-02f, 2.35388819e-02f,
  -2.39212699e-02f, 1.05387911e-01f, -3.88897322e-02f, 7.62233287e-02f, 1.03355730e-02f, 4.95677739e-02f, 1.23095582e-03f, -7.75390044e-02f, 8.55013579e-02f, 1.20062344e-01f,
  -1.60894897e-02f, -9.90368500e-02f, -2.66100448e-02f, 8.44403077e-03f, 5.04538370e-03f, -1.05605356e-01f, -3.04843802e-02f, 7.47400820e-02f, 1.01084918e-01f, -1.17841408e-01f,
  -3.41102332e-02f, -4.90772963e-01f, -3.62028331e-02f, 6.31005131e-03f, -9.16609615e-02f, 5.05585596e-03f, -1.06751196e-01f, 1.13902867e-01f, -8.46239775e-02f, -4.22030594e-03f,
  -3.87952998e-02f, 1.19688045e-02f, -3.51627870e-03f, 7.47261941e-02f, 6.86534718e-02f, -4.89772223e-02f, -1.48495898e-01f, -1.91114813e-01f, -1.09503843e-01f, 3.61053571e-02f,
  -5.42150512e-02f, -2.68016327e-02f, -1.53177857e-01f, 1.55194560e-02f, -1.01277642e-01f, -1.65200025e-01f, 3.84526327e-03f, 5.70975877e-02f, -4.76593487e-02f, -3.02680302e-02f,
  -1.99090019e-01f, 2.43756697e-01f, 3.34711194e-01f, 9.37130079e-02f, -7.44937509e-02f, -1.48611903e-01f, 1.74555019e-01f, 4.56825569e-02f, -2.78527826e-01f, 1.28988728e-01f,
  1.02176405e-02f, 4.24358658e-02f, 1.20018646e-01f, 1.42248347e-01f, -5.56709170e-01f, 6.81190714e-02f, -1.65404260e-01f, 6.69071227e-02f, -7.39017949e-02f, -1.98201999e-01f,
  -1.16816439e-01f, -6.92822412e-02f, 3.59661549e-01f, 1.97707415e-02f, 3.35277885e-01f, 5.75609282e-02f, -3.17915678e-02f, 1.46665126e-01f, -1.60580836e-02f, -5.95071353e-02f,
  5.24097634e-03f, 2.17563584e-01f, 1.68454573e-01f, -3.53784743e-03f, -1.17677957e-01f, -2.78732907e-02f, -1.06352009e-02f, 6.83353916e-02f, 8.58867466e-02f, -3.43991295e-02f,
  -6.62066042e-02f, 3.14885415e-02f, -7.01020434e-02f, -1.62590258e-02f, 8.00926015e-02f, 1.25882834e-01f, 1.79798275e-01f, 2.04020396e-01f, 8.37143660e-02f, 1.29153237e-01f,
  1.02911472e-01f, 7.03422278e-02f, -9.68156755e-03f, -1.20617980e-02f, 8.33671018e-02f, -1.04533425e-02f, 1.15830809e-01f, -9.72623602e-02f, -1.21574953e-01f, 1.89905893e-02f,
  1.09703466e-02f, -1.30507559e-01f, 1.24958813e-01f, 4.98806834e-02f, -5.83420694e-02f, 3.95840257e-02f, 8.03843662e-02f, 1.03331447e-01f, 2.86170989e-02f, 2.64289025e-02f,
  -9.38076824e-02f, 7.77670518e-02f, 2.73173992e-02f, 1.88278165e-02f, -1.03184767e-02f, -1.59531757e-02f, 6.77358955e-02f, -1.24414608e-01f, -7.12887794e-02f, 5.68116270e-02f,
  6.54284656e-02f, -1.84003666e-01f, 1.35940341e-02f, 1.87356479e-03f, -9.66751352e-02f, 1.56793118e-01f, 1.09368991e-02f, 1.37121558e-01f, -1.38619006e-01f, -3.80762406e-02f,
  -3.14802706e-01f, -3.15086901e-01f, -6.97298022e-03f, -2.30412930e-02f, 1.48262661e-02f, -5.87656945e-02f, 3.87376770e-02f, 4.70993258e-02f, 3.83169279e-02f, -9.22334939e-02f,
  -3.14804874e-02f, 3.78739983e-02f, -1.36513114e-01f, 5.32387663e-03f, -2.52661370e-02f, -1.48052238e-02f, -2.60200083e-01f, -3.08202836e-03f, -1.89671695e-01f, -9.31033418e-02f,
  -1.47467971e-01f, -5.46619073e-02f, -4.10407223e-02f, 1.05544198e-02f, -5.78155443e-02f, 3.94547991e-02f, -2.08290905e-01f, 8.93938094e-02f, -3.85979153e-02f, -8.81289504e-03f,
  -5.56961477e-01f, -2.46732429e-01f, 1.54786229e-01f, -3.73152137e-01f, 1.63545117e-01f, 3.17368448e-01f, 2.34984271e-02f, -2.75888354e-01f, -4.39651728e-01f, -2.77527452e-01f,
  -1.68287024e-01f, -6.57785907e-02f, -8.27964023e-02f, -1.55260116e-01f, 2.75857210e-01f, -2.15243563e-01f, -2.11856306e-01f, -1.88701302e-01f, 3.91996512e-03f, 1.19908974e-02f,
  -1.94078296e-01f, -8.07614475e-02f, 9.36110597e-03f, 1.86217308e-01f, -8.17515478e-02f, 1.30263627e-01f, 1.53255805e-01f, 3.15036654e-01f, 4.95349616e-02f, 1.91996321e-01f,
  -9.20689330e-02f, -2.83957422e-01f, -1.85545068e-02f, 1.08617857e-01f, -8.09251443e-02f, 4.33584228e-02f, 1.08798660e-01f, 2.53217399e-01f, -1.27929002e-01f, 3.53186801e-02f,
  -5.43890297e-02f, -7.59040937e-03f, -3.99026088e-02f, 1.04904965e-01f, 4.25481088e-02f, -3.23613696e-02f, -8.37782696e-02f, -1.44191653e-01f, -3.35060395e-02f, 5.54513605e-03f,
  -7.40495175e-02f, 8.84723850e-05f, 2.98281293e-02f, -8.12774524e-04f, 1.03441946e-01f, -1.11121885e-01f, 6.75664619e-02f, 2.16000080e-01f, -2.62479689e-02f, -9.88323241e-02f,
  -1.60762474e-01f, 1.00583136e-01f, -1.72924157e-02f, -7.55112246e-02f, 4.44794707e-02f, 3.90187204e-02f, 1.06651448e-01f, 1.05965240e-02f, -2.83527058e-02f, -4.13815305e-02f,
  3.15161273e-02f, 4.20947261e-02f, -8.12072754e-02f, -4.56235325e-03f, -2.94795446e-02f, -1.53503209e-01f, 2.29272805e-02f, 2.54402999e-02f, -1.15734078e-01f, -4.95588453e-03f,
  3.96616757e-03f, 1.13429232e-02f, 5.28280027e-02f, 8.74667987e-02f, -4.87267636e-02f, -1.37316762e-02f, 1.39557198e-02f, -1.32145360e-01f, 3.94759700e-02f, 8.90945271e-02f,
  -2.50940993e-02f, 8.61308072e-03f, 1.32185221e-01f, 6.94356114e-02f, 1.06527917e-01f, -3.18935290e-02f, -5.89036867e-02f, -6.55653775e-02f, -8.10462087e-02f, -6.11222675e-03f,
  6.16753772e-02f, 4.15473692e-02f, 1.43017828e-01f, 3.62828351e-03f, 2.91932542e-02f, -1.78848252e-01f, -4.90385145e-02f, -2.21103448e-02f, 7.60960728e-02f, 3.52359898e-02f,
  1.91459935e-02f, 5.71819507e-02f, 6.38137981e-02f, -5.40236803e-03f, 9.18619800e-04f, -2.44215298e-02f, -6.48895204e-02f, -7.42488727e-02f, 1.07048996e-01f, 1.99852195e-02f,
  6.17175773e-02f, 3.24872695e-02f, 3.70931417e-01f, -4.09487695e-01f, -3.94566432e-02f, 1.47710172e-02f, -1.18777864e-01f, -1.66386634e-01f, -2.72692710e-01f, -3.61582100e-01f,
  -3.85992497e-01f, 2.59546191e-01f, -1.21423125e-01f, -4.24528748e-01f, 1.21352024e-01f, -3.54161747e-02f, -3.12908441e-01f, -7.50361308e-02f, 4.12859544e-02f, -2.01279640e-01f,
  4.08637077e-02f, -3.53584915e-01f, -2.20349263e-02f, 4.31358889e-02f, -1.89573437e-01f, 2.34197721e-01f, -3.14994961e-01f, 1.58828005e-01f, -1.86023191e-01f, 2.28902251e-01f,
  8.14208984e-02f, -1.36588626e-02f, -6.23460971e-02f, 1.33381918e-01f, -9.33879912e-02f, 9.72626880e-02f, 1.39607145e-02f, 1.59923732e-01f, 3.35884765e-02f, 3.25344726e-02f,
  1.38152674e-01f, 1.26228958e-01f, 1.68471504e-02f, -1.41837578e-02f, 1.81161407e-02f, 1.93979386e-02f, 5.19890785e-02f, -2.04518750e-01f, -1.94620285e-02f, 3.46547551e-02f,
  -1.32230008e-02f, 2.35948749e-02f, -1.84167519e-01f, 1.49262780e-02f, -1.24927415e-02f, -6.59558177e-03f, -2.54649180e-03f, 3.71689945e-02f, 1.58020644e-03f, 1.10100927e-02f,
  1.05963685e-01f, -5.50714955e-02f, 6.36208355e-02f, -5.78869740e-03f, 1.17002688e-02f, 6.90071704e-03f, -1.22434264e-02f, 4.33566011e-02f, 5.56329340e-02f, -1.17600653e-02f,
  1.45528633e-02f, 6.18131831e-02f, -9.39374641e-02f, 1.12816850e-02f, -1.76241249e-01f, -2.86475122e-02f, 4.56490666e-02f, 3.24107558e-02f, -6.21923469e-02f, -8.50751400e-02f,
  2.36549005e-02f, -5.39490543e-02f, -2.48710774e-02f, 5.09000979e-02f, -7.09207505e-02f, 1.05977589e-02f, -4.64642346e-02f, 5.59347123e-02f, -7.83937052e-02f, 7.15261996e-02f,
  -1.95514873e-01f, -1.14783764e-01f, 1.19978683e-02f, 4.87080328e-02f, 5.75228035e-02f, 5.76973706e-02f, -6.44014776e-02f, 5.77076450e-02f, 1.44719109e-01f, -3.60825919e-02f,
  -5.72151020e-02f, -1.13665067e-01f, 2.49133422e-03f, -8.16660449e-02f, 4.13940148e-03f, -2.95618437e-02f, -6.59981146e-02f, 1.42589480e-01f, 2.10814178e-03f, -4.84027416e-02f,
  -5.02884537e-02f, -1.31115001e-02f, 1.40751719e-01f, -7.72348270e-02f, -5.31522594e-02f, 7.74479732e-02f, -1.06275208e-01f, 4.22077551e-02f, 6.92433342e-02f, -8.14355910e-02f,
  -5.90499103e-01f, -2.65422672e-01f, -3.72475833e-01f, -6.30636513e-02f, -1.53650910e-01f, -3.65845650e-01f, -3.16974461e-01f, -1.24592185e-01f, 5.90359122e-02f, 1.64034128e-01f,
  -1.01430252e-01f, -2.22348422e-01f, -1.11796282e-01f, -7.37294555e-02f, -3.92578244e-01f, 5.16390465e-02f, -2.10687384e-01f, -3.47372554e-02f, 4.92445864e-02f, -2.22068802e-01f,
  -1.02311298e-01f, 9.01881903e-02f, -2.73086399e-01f, 9.17900130e-02f, -2.37452969e-01f, 6.17536046e-02f, 1.51010752e-01f, 9.41060111e-02f, 5.11848405e-02f, -3.70363556e-02f,
  -2.19523400e-01f, 1.28770312e-02f, 7.84723088e-02f, -1.86033901e-02f, -1.12753354e-01f, 7.94483200e-02f, -1.29248619e-01f, 6.70038238e-02f, 7.41515830e-02f, -5.22842593e-02f,
  4.93483525e-03f, -1.07700013e-01f, 9.09424424e-02f, 4.66662422e-02f, 1.65829808e-02f, 7.53257349e-02f, -4.97450382e-02f, -1.53876379e-01f, -7.92472437e-02f, -3.39957923e-02f,
  -1.04419746e-01f, -1.32921502e-01f, -5.40992394e-02f, -2.56105866e-02f, -1.01437122e-01f, 2.07404755e-02f, 5.37117757e-02f, -1.21348388e-02f, -5.69082238e-02f, -1.02543503e-01f,
  6.50333613e-02f, 1.44116119e-01f, 1.43345410e-03f, 9.85937268e-02f, 1.40822055e-02f, 7.91797936e-02f, 2.98724268e-02f, 2.90006492e-02f, 2.91992556e-02f, 1.60175818e-03f,
  -6.66748285e-02f, 8.57480764e-02f, 9.41204354e-02f, -1.38215609e-02f, 4.63551395e-02f, 1.52785003e-01f, -3.40767428e-02f, -4.84419661e-03f, -7.42215514e-02f, 5.50343143e-03f,
  -8.47327709e-03f, -5.75362705e-02f, -1.31017435e-02f, -2.45149620e-02f, 3.89589556e-02f, -8.81870743e-03f, -4.98288311e-02f, -2.08467115e-02f, 4.25433367e-02f, -6.54138401e-02f,
  -2.41354153e-01f, 2.45823022e-02f, 9.17322338e-02f, 1.35238247e-03f, 7.04332590e-02f, 4.26284634e-02f, 9.21114609e-02f, 1.07823564e-02f, -6.60588220e-02f, -3.32742482e-02f,
  1.32050714e-03f, 7.83941671e-02f, -6.82220235e-02f, -5.25444224e-02f, -4.46313620e-02f, -1.03287734e-01f, -2.38430593e-02f, 4.33326699e-02f, -5.51003926e-02f, -5.13743609e-02f,
  -4.27994784e-03f, 1.38781555e-02f, 5.11195250e-02f, 7.91083742e-03f, 9.52977389e-02f, -8.96632224e-02f, 1.15976287e-02f, 1.08386934e-01f, -2.93329656e-02f, 5.45107061e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.74827802e-01f, -6.51959538e-01f, 2.31792569e-01f, 4.12823707e-01f, -1.06301218e-01f, -1.30964771e-01f, 6.08773470e-01f, -5.50005078e-01f, 1.35159656e-01f, -5.89202404e-01f,
  -2.96758980e-01f, 4.46810246e-01f, 3.32232803e-01f, -4.30959344e-01f, 9.66598570e-01f, 3.46928388e-01f, -1.31243005e-01f, 3.49042892e-01f, -2.77102794e-02f, -1.80670068e-01f,
  -5.98279051e-02f, -4.54208136e-01f, 3.07314750e-02f, -7.64781773e-01f, -5.50315857e-01f, -3.06357503e-01f, -2.23819260e-02f, 2.16637477e-02f, -4.72634792e-01f, 9.06143785e-02f,
  -4.97812271e-01f, -2.54569829e-01f, -1.58574805e-01f, -8.45912546e-02f, -1.69833466e-01f, 5.33553697e-02f, 2.39465058e-01f, 3.39421272e-01f, 2.28868514e-01f, -7.83851445e-02f,
  1.26596317e-01f, 5.92890009e-02f, -1.32919297e-01f, 2.11844668e-02f, -3.56521122e-02f, -1.02375649e-01f, -3.38113979e-02f, -1.82218939e-01f, -3.80860176e-04f, -4.79332320e-02f,
  -7.18778074e-02f, -1.49311706e-01f, -5.41313924e-03f, 1.32972989e-02f, 7.17438608e-02f, -7.75241293e-03f, 7.64721334e-02f, 1.75187409e-01f, -1.05702639e-01f, 5.45241311e-02f,
  -5.46729155e-02f, 3.42287235e-02f, 5.13834134e-02f, -2.88448632e-02f, 4.87673357e-02f, -1.02472141e-01f, 7.14300498e-02f, -1.27038723e-02f, 7.23913312e-02f, -1.05406091e-01f,
  -5.88055737e-02f, 7.49275014e-02f, -3.55545320e-02f, -6.00321079e-03f, -8.05989951e-02f, 1.33956373e-01f, 2.10269541e-01f, -3.73588018e-02f, -1.24124403e-03f, -1.89152844e-02f,
  1.22400671e-01f, 4.63112704e-02f, -9.36811045e-02f, 5.95421679e-02f, -1.00193471e-01f, 1.27396479e-01f, -2.31608257e-01f, -3.30944397e-02f, 1.64551996e-02f, 6.93434402e-02f,
  -4.28842455e-01f, -2.76335776e-01f, -1.48989007e-01f, -1.41592771e-01f, 3.19046825e-02f, -1.94168568e-01f, 5.59184030e-02f, -6.63389936e-02f, 2.32803505e-02f, 3.79003920e-02f,
  -2.18490332e-01f, -4.51760134e-04f, -3.58165763e-02f, 1.47819832e-01f, 4.03236598e-02f, -3.11269774e-04f, 1.30405262e-01f, 1.61589291e-02f, 1.21470066e-02f, -2.54693657e-01f,
  -7.89213777e-02f, 7.78289661e-02f, 8.07486624e-02f, -2.71915831e-02f, -3.67874913e-02f, 3.39066498e-02f, 9.37552080e-02f, -1.28881365e-01f, 1.89943630e-02f, -6.80517405e-02f,
  6.47610962e-01f, -2.29572877e-01f, 6.20323479e-01f, 4.23063755e-01f, -2.72050388e-02f, -5.91461241e-01f, 1.26399487e-01f, -3.77317399e-01f, 2.96045691e-01f, -5.34885168e-01f,
  -5.17156780e-01f, 5.75655639e-01f, 3.22505541e-04f, -3.53928685e-01f, 1.24625839e-01f, -1.49237007e-01f, -2.48511046e-01f, -3.59125063e-03f, 5.74887507e-02f, -2.37409487e-01f,
  -8.59620422e-02f, -8.21053386e-01f, 1.22365460e-01f, -9.25636709e-01f, 4.39345837e-02f, 1.34473637e-01f, -3.10564667e-01f, -6.62903041e-02f, -3.51753324e-01f, -1.30974203e-01f,
  -2.15735450e-01f, -8.30958188e-02f, 1.10495865e-01f, 6.21463135e-02f, -6.89769685e-02f, 4.90535609e-02f, 1.81949392e-01f, 1.36478066e-01f, 5.23858070e-02f, 1.87429771e-01f,
  1.74110085e-01f, -7.45868217e-03f, -1.07795484e-01f, 1.26612246e-01f, 6.38975129e-02f, 1.51441082e-01f, 7.06256256e-02f, 1.06969766e-01f, 1.15152083e-01f, 4.34722900e-01f,
  2.20921963e-01f, 2.14447528e-01f, 2.45918587e-01f, 2.31025834e-03f, 2.78881043e-01f, -8.54890868e-02f, 1.07909441e-01f, 3.34463865e-01f, 1.12515703e-01f, 8.89552608e-02f,
  -1.89236403e-01f, -1.55657649e-01f, -5.95779680e-02f, -1.77448150e-02f, -2.87578404e-01f, -3.69452611e-02f, -1.69973411e-02f, -3.81818488e-02f, 7.46792853e-02f, -6.41401345e-03f,
  -8.79622623e-02f, 9.63517651e-02f, 4.23692390e-02f, -1.69980545e-02f, -8.56655836e-02f, 1.21030055e-01f, 8.77577215e-02f, 2.17712969e-02f, 2.29737051e-02f, 1.09745771e-01f,
  -5.04804701e-02f, -1.14720417e-02f, 3.21566835e-02f, 1.18553847e-01f, -1.18379489e-01f, -6.60388870e-03f, -8.32997113e-02f, 2.40661412e-01f, 9.80339870e-02f, -1.94025300e-02f,
  -5.85020661e-01f, -9.96802986e-01f, -1.34809360e-01f, 5.73679432e-02f, -7.90954903e-02f, 4.68010828e-02f, -6.96092397e-02f, 8.85593370e-02f, -2.97117293e-01f, -2.19586268e-01f,
  -5.65849170e-02f, 5.66211268e-02f, -1.07890204e-01f, 9.63101164e-02f, -2.91357756e-01f, -7.20987171e-02f, -1.32730648e-01f, -9.10643339e-02f, -2.10657120e-01f, -1.22932099e-01f,
  -3.39465588e-02f, -1.33578941e-01f, 3.91207449e-02f, -3.00002769e-02f, -6.10088930e-02f, -1.15393616e-01f, 2.77279392e-02f, 3.72603349e-02f, 2.75340620e-02f, -1.15735926e-01f,
  1.36735082e-01f, -9.71023679e-01f, -8.38161856e-02f, 8.39634836e-02f, 6.24437392e-01f, 4.03709054e-01f, 3.91997397e-01f, -5.95155805e-02f, -6.38148665e-01f, -4.55574095e-01f,
  5.10692075e-02f, -6.70869708e-01f, -4.27374661e-01f, -8.39988053e-01f, 1.01665772e-01f, -7.09231079e-01f, -1.54161066e-01f, -7.82819539e-02f, -2.64665663e-01f, 2.26672813e-01f,
  8.46184939e-02f, -1.07874513e-01f, -8.50214660e-02f, -8.24620426e-02f, 3.25832129e-01f, 3.98740798e-01f, 6.08403444e-01f, 4.11946118e-01f, 7.97250569e-02f, -2.99457997e-01f,
  -6.79992437e-02f, -3.19562286e-01f, -8.77651423e-02f, -7.31596425e-02f, 2.20472068e-01f, 1.39853105e-01f, 1.80403143e-01f, -8.24524909e-02f, 7.29605183e-02f, -2.42003538e-02f,
  1.87909529e-01f, -1.30491480e-01f, -2.53908366e-01f, -3.66594531e-02f, 5.17012477e-02f, -6.16769586e-03f, -1.62984401e-01f, 3.73592488e-02f, -1.79680690e-01f, -1.37781546e-01f,
  -7.83964768e-02f, 6.79214895e-02f, 1.87470004e-01f, -1.44992664e-01f, 2.85438374e-02f, -3.43391001e-02f, 1.10624574e-01f, 2.43914083e-01f, -1.34045288e-01f, -5.33815147e-03f,
  7.77091533e-02f, 3.93003151e-02f, 7.64962733e-02f, -2.06312805e-01f, -1.63495145e-03f, -1.35316299e-02f, -1.11641563e-01f, 1.11697270e-02f, 9.64753255e-02f, -6.67696074e-02f,
  1.61711022e-01f, -9.96791869e-02f, -2.52501935e-01f, 2.63512786e-02f, 1.07098997e-01f, -1.51759297e-01f, 1.13492109e-01f, -1.07788863e-02f, 3.00693721e-01f, 1.59214556e-01f,
  -2.28339761e-01f, 1.87548622e-01f, 1.71998471e-01f, -3.35140526e-02f, -1.82752937e-01f, 1.58000678e-01f, -5.20938188e-02f, -4.49804924e-02f, -2.83220387e-03f, 2.21093506e-01f,
  1.22055441e-01f, -1.64902821e-01f, -1.09460816e-01f, 3.40958079e-03f, -1.00220174e-01f, 1.04799159e-01f, -2.60691851e-01f, -2.02332735e-01f, 7.20183998e-02f, -6.76681176e-02f,
  3.14858109e-01f, 2.23759085e-01f, 2.16078714e-01f, -4.74074148e-02f, 9.14488137e-02f, 6.98054507e-02f, 9.11799967e-02f, 1.33931130e-01f, 1.41876310e-01f, 1.56030923e-01f,
  2.84547389e-01f, 3.39757442e-01f, -8.28206390e-02f, 1.20802380e-01f, 3.25550511e-02f, 1.85824677e-01f, 2.31537431e-01f, -7.28672966e-02f, -2.19949782e-01f, -6.29805550e-02f,
  8.36920142e-01f, -5.10435045e-01f, -4.10615236e-01f, 5.15856445e-01f, 5.68087518e-01f, 6.53593913e-02f, -2.64762547e-02f, 2.68482953e-01f, 4.37693208e-01f, -3.80627781e-01f,
  2.23566666e-01f, -5.03137350e-01f, -5.53130388e-01f, 4.55692500e-01f, 5.60803413e-01f, -4.00651276e-01f, 4.81361806e-01f, -4.85036075e-02f, 2.01128423e-01f, 3.77502352e-01f,
  4.07387435e-01f, 7.73147643e-01f, -8.55721533e-02f, 1.33008197e-01f, 4.13430572e-01f, -1.87098727e-01f, 3.48517969e-02f, -3.56294125e-01f, -3.91107798e-02f, -4.86368164e-02f,
  2.44290102e-02f, 2.38015503e-01f, 5.04114144e-02f, -1.02600932e-01f, 7.81920627e-02f, -1.58462916e-02f, -2.70757526e-01f, -2.08491594e-01f, 7.54328594e-02f, -8.05759728e-02f,
  -9.93366092e-02f, 8.34147725e-03f, 4.76215370e-02f, -9.99327749e-02f, 3.36942941e-01f, 1.36333451e-01f, 5.52554727e-02f, -1.05176203e-01f, -1.08537182e-01f, -1.02577023e-02f,
  5.06551564e-03f, -6.56521395e-02f, 2.40389600e-01f, -8.06172639e-02f, -7.75272325e-02f, -2.71614967e-03f, -1.96001768e-01f, -2.39024147e-01f, -9.68345478e-02f, 1.15979731e-01f,
  9.98104960e-02f, -2.31988565e-03f, 2.61729714e-02f, 1.02892192e-02f, 1.05090074e-01f, 2.45632958e-02f, 4.45800945e-02f, -1.09076925e-01f, 1.01841325e-02f, -3.51461843e-02f,
  9.05620828e-02f, 1.22049570e-01f, 1.07550792e-01f, -3.45280394e-02f, 1.32439703e-01f, 3.95870507e-02f, -1.30581096e-01f, -1.53241917e-01f, 8.52205455e-02f, 1.62178371e-02f,
  -8.70324075e-02f, 1.36980429e-01f, -2.94439420e-02f, -6.62847757e-02f, -3.68405059e-02f, -3.81701402e-02f, -6.76768869e-02f, 6.15931265e-02f, -3.46024632e-02f, -4.57687490e-02f,
  -8.97817761e-02f, -2.50503242e-01f, -1.32969081e-01f, -1.23911858e-01f, -2.07069710e-01f, 1.51666999e-01f, 1.77137107e-02f, 9.23205614e-02f, -7.77393952e-02f, 6.64678141e-02f,
  3.57287973e-02f, -6.71608448e-02f, -8.19269493e-02f, 1.78436011e-01f, -1.03507586e-01f, 1.29702717e-01f, -1.89888164e-01f, -5.56402169e-02f, -2.70438548e-02f, 1.38381906e-02f,
  2.69053224e-02f, -2.48091854e-03f, -5.02205119e-02f, 1.28385276e-01f, 2.23071640e-03f, -9.51743200e-02f, -2.02689134e-02f, -9.95505527e-02f, 6.16238220e-03f, -1.84861585e-01f,
  -9.53180417e-02f, -2.57711977e-01f, -8.79755735e-01f, -1.68400481e-01f, 1.07842781e-01f, 6.08768940e-01f, 2.71155655e-01f, -1.07694678e-01f, -4.74117994e-01f, 7.20292687e-01f,
  8.06242883e-01f, -7.07223833e-01f, -1.30144075e-01f, 7.26643264e-01f, -4.12908018e-01f, -6.75437152e-02f, 6.54938400e-01f, 4.03984249e-01f, -3.94443244e-01f, -1.22319184e-01f,
  -1.56192854e-01f, 6.71105385e-01f, -1.61616459e-01f, 2.43256271e-01f, 2.49948874e-01f, -3.56849611e-01f, 5.48327029e-01f, -4.46189493e-01f, 6.34189248e-01f, 2.24979267e-01f,
  1.93178326e-01f, -1.58822954e-01f, -1.22720778e-01f, -1.25817418e-01f, 1.32239461e-01f, 2.16573209e-01f, 1.25815317e-01f, -1.07954349e-02f, -2.38689035e-01f, -9.01704431e-02f,
  -2.93761995e-02f, -1.70452341e-01f, -7.60404905e-03f, -2.11119473e-01f, 6.58928975e-02f, -1.04599766e-01f, -9.69233736e-02f, 6.61608996e-03f, -1.43928930e-01f, -1.84185252e-01f,
  -2.70109326e-01f, -1.70990434e-02f, 7.86383748e-02f, 9.69318580e-03f, -6.58968985e-02f, -1.48446873e-01f, -1.22206388e-02f, -7.82006383e-02f, 1.13751814e-01f, 1.70822646e-02f,
  1.54656693e-02f, 4.78862077e-02f, 2.99332999e-02f, 1.23796286e-02f, -2.01224983e-02f, 1.35162950e-01f, 1.32183418e-01f, 1.69012204e-01f, -1.55402541e-01f, 9.93575603e-02f,
  3.64882052e-02f, -5.69604747e-02f, 1.79638654e-01f, 1.56255692e-01f, 6.50915056e-02f, -8.61644074e-02f, -4.97054495e-02f, 7.23418668e-02f, -6.74197227e-02f, -3.46773653e-04f,
  6.34331852e-02f, -1.03896216e-01f, -4.27856892e-02f, 2.04602987e-01f, 6.89685047e-02f, -1.30347997e-01f, 2.40780175e-01f, -1.47412596e-02f, 7.95524120e-02f, 2.89506428e-02f,
  1.37083426e-01f, -7.72828981e-02f, -1.30659848e-01f, -2.35010795e-02f, 6.05192408e-02f, 4.23971452e-02f, 5.91584556e-02f, -1.17110930e-01f, -4.78187129e-02f, -2.95905303e-03f,
  1.27564386e-01f, 9.08637717e-02f, 1.22127950e-01f, -4.71973643e-02f, -4.72045988e-02f, 1.31528243e-01f, 2.16655239e-01f, -4.11033779e-02f, 1.93765819e-01f, 1.28342316e-01f,
  2.20681224e-02f, 1.16542362e-01f, -6.75020367e-02f, 2.41301712e-02f, 1.78838179e-01f, 2.86888242e-01f, -1.14956290e-01f, -1.30309761e-01f, 1.18334189e-01f, 7.26277195e-03f,
  2.81746417e-01f, -2.24817380e-01f, 6.58604354e-02f, -4.48852807e-01f, 2.28841126e-01f, 5.08771360e-01f, 2.50042289e-01f, -2.26279661e-01f, -8.96124423e-01f, -2.90958583e-01f,
  2.45889246e-01f, -2.37373650e-01f, 5.43096781e-01f, 3.67371559e-01f, 5.74696660e-01f, 3.82506937e-01f, 3.39223444e-01f, 2.36909568e-01f, 1.37580380e-01f, 2.58977175e-01f,
  9.25741643e-02f, 5.28079748e-01f, 5.88940918e-01f, 1.85343295e-01f, 4.37701464e-01f, -2.56187558e-01f, 8.12820811e-03f, 2.07237273e-01f, 1.45282224e-01f, 2.04774082e-01f,
  1.70568060e-02f, -1.75567806e-01f, 4.33871970e-02f, -8.12942907e-02f, 1.59795836e-01f, 1.45135015e-01f, 2.61502594e-01f, 2.47752786e-01f, -1.58536315e-01f, 3.66704888e-03f,
  2.06067860e-02f, -1.18746065e-01f, -5.66609614e-02f, 6.09351434e-02f, -2.12919533e-01f, -1.97480142e-01f, -1.12396196e-01f, -1.09301977e-01f, -2.15679884e-01f, 2.37906218e-01f,
  1.81009416e-02f, -1.00245461e-01f, -1.04245372e-01f, -1.22512870e-01f, -1.28376767e-01f, -2.08459467e-01f, 4.81724553e-02f, 1.61448434e-01f, -1.23919979e-01f, -9.77388490e-03f,
  1.52600765e-01f, -3.63523178e-02f, 8.17655027e-02f, 6.96096150e-03f, 1.36856630e-01f, 5.50963283e-02f, -4.32736566e-03f, 1.72149822e-01f, -6.49286285e-02f, 7.36705810e-02f,
  -8.23775530e-02f, 6.57745376e-02f, -1.03197545e-01f, -2.21877068e-01f, 9.54266712e-02f, -1.55588478e-01f, 2.26783216e-01f, 7.26276264e-02f, -1.20363072e-01f, 1.06195740e-01f,
  -3.25058639e-01f, -4.94542681e-02f, 5.29861711e-02f, 4.85992655e-02f, -8.37182160e-03f, 3.08137108e-03f, -1.26418203e-01f, -3.02808043e-02f, 1.75557844e-02f, 1.11976050e-01f,
  7.51259327e-02f, 2.14432310e-02f, -1.09612294e-01f, -1.39586374e-01f, 4.38118763e-02f, 2.31735066e-01f, 4.08473015e-02f, -5.74159510e-02f, -7.46832937e-02f, 4.04310413e-02f,
  1.07311748e-01f, -9.09315571e-02f, -2.48323202e-01f, -8.72094408e-02f, -1.90408640e-02f, 7.24461153e-02f, -9.38302726e-02f, -2.68089294e-01f, -1.82853825e-02f, -4.12584059e-02f,
  -1.14484064e-01f, -1.24901377e-01f, -3.55658936e-04f, 4.64513600e-02f, -4.58883010e-02f, 3.86922993e-02f, 1.36454120e-01f, -2.44065031e-01f, 1.16526902e-01f, -1.20901480e-01f,
  -1.47445261e-01f, 8.38112161e-02f, 2.03422189e-01f, 6.10328972e-01f, -4.39954937e-01f, -4.47896600e-01f, -6.61017001e-01f, -1.60403758e-01f, -1.64777383e-01f, -2.85216540e-01f,
  -3.16615760e-01f, 2.85717636e-01f, -8.64300430e-01f, 6.68738008e-01f, 2.77222067e-01f, -4.90053892e-01f, 5.66293597e-01f, 2.19222769e-01f, -1.41361982e-01f, 1.50825679e-01f,
  2.33018592e-01f, 1.75517946e-01f, 1.82496071e-01f, 2.70813107e-01f, 1.30485252e-01f, 4.32131499e-01f, 4.26559687e-01f, 1.38089880e-01f, 8.65447879e-01f, 1.37168363e-01f,
  -4.63959686e-02f, -1.20093487e-01f, -3.06762196e-02f, 1.84731275e-01f, -7.24702841e-03f, -6.08711429e-02f, 1.22181766e-01f, -1.06394462e-01f, 2.69747134e-02f, 1.78145841e-02f,
  -6.68468699e-02f, 1.88201100e-01f, 1.55383781e-01f, 1.11498587e-01f, 1.94530990e-02f, 2.40177184e-01f, -3.53047326e-02f, -9.36485380e-02f, 7.02953711e-02f, -1.13300614e-01f,
  -1.13456488e-01f, -2.84558851e-02f, 5.84243163e-02f, 8.51031244e-02f, 5.49786948e-02f, 4.87412922e-02f, 1.02964737e-01f, -6.50611222e-02f, 3.48215580e-01f, 1.50244623e-01f,
  5.77577855e-03f, -1.17655858e-01f, -4.47164029e-02f, -9.04526711e-02f, 6.03095703e-02f, 6.61495030e-02f, 3.17508765e-02f, 1.29945530e-02f, 8.65619779e-02f, -6.38898164e-02f,
  7.34432563e-02f, 4.00190204e-02f, 1.64131690e-02f, -2.20627771e-04f, -8.06412250e-02f, -1.50573403e-01f, -1.52202904e-01f, -2.43653618e-02f, 2.15380490e-02f, -2.78023351e-02f,
  -1.13849416e-01f, 3.99710089e-02f, -3.02052684e-02f, -3.24604772e-02f, -6.19287975e-02f, -1.05794862e-01f, 1.23603016e-01f, 1.08526640e-01f, -1.03865422e-01f, -5.62673993e-02f,
  1.52071223e-01f, 2.48516366e-01f, -1.00204796e-01f, -3.03627457e-02f, 1.63269993e-02f, 5.12966104e-02f, 1.23256043e-01f, 2.11040080e-01f, 2.20157474e-01f, -4.25250642e-02f,
  4.87343706e-02f, -5.68327941e-02f, -4.55095060e-02f, 1.06017537e-01f, 1.84478790e-01f, 7.43293809e-03f, 1.49512380e-01f, 1.28852293e-01f, 1.68127105e-01f, 2.93657959e-01f,
  -2.88969427e-02f, -3.47515345e-01f, 7.70484433e-02f, -1.90583929e-01f, 1.05343210e-02f, -6.92676157e-02f, 4.34116274e-03f, -1.56205548e-02f, 7.95471817e-02f, 1.71546400e-01f,
  7.00202584e-01f, -7.03502074e-02f, -5.70196211e-01f, 1.03400029e-01f, 3.41820091e-01f, 9.63312387e-01f, 3.58891785e-01f, 6.16725013e-02f, -1.08948857e-01f, -9.75486413e-02f,
  -1.18231811e-01f, 3.08294475e-01f, -6.55499935e-01f, 5.14746428e-01f, 9.30364490e-01f, -3.36573511e-01f, 6.03893816e-01f, 4.76524740e-01f, -2.77173489e-01f, 1.54490128e-01f,
  -1.57042950e-01f, 6.54264450e-01f, -4.61924851e-01f, 2.06031173e-01f, 3.82806450e-01f, -2.28773832e-01f, 9.50931534e-02f, -3.11467409e-01f, 4.19124484e-01f, 5.15928984e-01f,
  6.31894404e-03f, 4.68303775e-03f, -9.01190415e-02f, -1.46850282e-02f, -1.49232328e-01f, 5.13178110e-03f, -8.55915919e-02f, 1.26545861e-01f, -6.05118228e-03f, -4.71303612e-02f,
  6.94497153e-02f, 1.82251275e-01f, 2.27468044e-01f, 9.26744118e-02f, 2.07877517e-01f, 1.24319427e-01f, -6.10521510e-02f, -1.31448314e-01f, -6.40876293e-02f, -1.80227757e-02f,
  -2.28148386e-01f, -1.32441312e-01f, -6.95479661e-02f, -1.19153981e-03f, -2.89463699e-02f, 3.50253358e-02f, -6.26983941e-02f, -7.44769052e-02f, 1.67715698e-01f, 2.29819730e-01f,
  9.70796272e-02f, 6.76162820e-03f, -7.53735900e-02f, 1.21170459e-02f, 2.09802389e-02f, -1.67843059e-01f, -2.45005032e-03f, -7.46615380e-02f, -1.64480969e-01f, 4.21614246e-03f,
  -2.49802670e-03f, 6.70656189e-02f, 7.38030523e-02f, 7.84163103e-02f, 5.37617952e-02f, -1.65245607e-02f, 3.81490476e-02f, 1.51051760e-01f, -1.96255445e-01f, -8.81570280e-02f,
  -3.58505994e-02f, 1.21018499e-01f, -4.86891577e-03f, -1.51603669e-01f, 7.41363615e-02f, -1.10185556e-01f, -3.36665586e-02f, 2.33438257e-02f, -2.55605549e-01f, 3.30031179e-02f,
  4.25600968e-02f, 3.12148541e-01f, -1.91068143e-01f, 2.10216194e-02f, -7.94770941e-02f, 2.41619602e-01f, 1.14805922e-01f, 1.07402973e-01f, 1.91244125e-01f, 5.39472401e-02f,
  7.78725669e-02f, 3.90036800e-03f, -1.15804030e-02f, -3.60079482e-03f, -2.23882925e-02f, 7.14064837e-02f, -8.82942080e-02f, 1.90809947e-02f, 7.56775960e-02f, 9.39989761e-02f,
  5.57885580e-02f, 7.87347779e-02f, -5.15516214e-02f, 8.64419434e-03f, 3.13141309e-02f, -5.72531521e-02f, 3.01563531e-01f, 1.25950901e-02f, -3.76214869e-02f, -2.03373656e-01f,
  3.97783250e-01f, -2.35751659e-01f, -3.09665799e-01f, -1.33079126e-01f, 3.99840362e-02f, 1.57437384e-01f, 3.62436563e-01f, -3.84538770e-01f, -4.62420762e-01f, 4.57840748e-02f,
  1.62107557e-01f, 2.21017137e-01f, 4.63301688e-01f, 5.93621552e-01f, 7.21575141e-01f, 3.35369706e-01f, 3.19476753e-01f, 1.50541708e-01f, -3.87165666e-01f, -1.02699190e-01f,
  3.99358049e-02f, 5.76545775e-01f, 2.29512006e-01f, -4.30213064e-01f, 3.23411524e-01f, -4.56231982e-01f, 3.76750290e-01f, -2.47132450e-01f, 2.21782044e-01f, 3.26201081e-01f,
  3.42346653e-02f, 1.68325077e-03f, -1.03220075e-01f, -1.29873514e-01f, 9.25304890e-02f, -6.57259226e-02f, 2.25617941e-02f, 2.82298565e-01f, -6.85970532e-03f, -6.98720887e-02f,
  9.96710658e-02f, 9.19947997e-02f, -1.66171752e-02f, 1.28425509e-01f, -1.73414387e-02f, -2.20451578e-01f, -8.30620080e-02f, -6.51526600e-02f, -5.61691001e-02f, 1.72170609e-01f,
  -1.23043954e-01f, -6.17774725e-02f, 1.02940217e-01f, 1.59137286e-02f, -2.05646038e-01f, -6.83015659e-02f, 2.34378837e-02f, 1.49723232e-01f, -4.57804874e-02f, -9.38056335e-02f,
  1.41285464e-01f, -1.09450589e-03f, -5.43242507e-02f, 1.36914492e-01f, 8.28881189e-02f, 5.05393408e-02f, 1.19626991e-01f, 8.83252546e-02f, -9.75678489e-02f, 1.02765374e-01f,
  8.63542221e-03f, -1.18876062e-01f, -8.97367597e-02f, -4.37169187e-02f, 1.18330367e-01f, 1.70022976e-02f, 3.68918106e-02f, 3.91826667e-02f, -1.51771873e-01f, -9.00756121e-02f,
  1.11771248e-01f, -1.40182124e-02f, -1.03238784e-02f, 1.91797744e-02f, -3.91332544e-02f, 2.51497328e-02f, 2.91228760e-02f, 4.79415804e-02f, -1.95552349e-01f, -1.38720497e-02f,
  3.71988378e-02f, 5.99478483e-02f, -8.72571692e-02f, -6.73033223e-02f, -8.50624666e-02f, -4.28307094e-02f, -3.53989229e-02f, -1.01340108e-01f, -2.10760832e-02f, -5.25617152e-02f,
  4.95925266e-03f, -2.41332650e-02f, -1.24611959e-01f, -5.27254166e-03f, -1.13854378e-01f, -2.61860341e-02f, 1.01762727e-01f, -8.23652148e-02f, 7.33643323e-02f, 4.39524874e-02f,
  5.45577221e-02f, 1.07813671e-01f, 1.64595842e-01f, -1.26217052e-01f, -1.26293804e-02f, 1.56157792e-01f, -1.42050520e-01f, -1.27789319e-01f, 5.56611121e-02f, 2.53087468e-02f,
  7.60600790e-02f, -3.66663039e-01f, 2.72964090e-01f, 6.23180151e-01f, 1.77207403e-02f, -9.50240314e-01f, -7.62284279e-01f, 2.32221961e-01f, -2.62979299e-01f, -6.01445735e-01f,
  1.26972035e-01f, -5.87848090e-02f, -1.12892225e-01f, -8.92099552e-03f, 6.48702025e-01f, 1.86046943e-01f, 2.74154712e-02f, -2.77193218e-01f, 2.83902556e-01f, 2.68593699e-01f,
  3.59689981e-01f, 2.64700890e-01f, 6.87493384e-01f, 2.21024856e-01f, 5.71127534e-02f, 3.69843125e-01f, 6.51044130e-01f, 2.98650004e-02f, 4.52722870e-02f, 4.22409549e-02f,
  -1.50643438e-01f, 1.92458704e-01f, -5.87649196e-02f, -1.46608457e-01f, 1.11924499e-01f, -2.31699988e-01f, -1.42801926e-01f, 5.62015809e-02f, 7.79285803e-02f, -6.51991218e-02f,
  -2.33802676e-01f, 6.81056753e-02f, -8.18061680e-02f, 6.22562841e-02f, -2.09540680e-01f, -7.10529685e-02f, -1.86937470e-02f, -9.29690804e-03f, -1.27735525e-01f, 3.94802764e-02f,
  2.48440206e-02f, -1.80626839e-01f, 8.87222067e-02f, 1.67391002e-01f, 2.91657656e-01f, -1.20489761e-01f, 1.91644055e-03f, -1.14000760e-01f, -1.53920159e-01f, 1.14368998e-01f,
  1.20086975e-01f, -1.48087174e-01f, -8.43097791e-02f, -5.83216250e-02f, -1.39511511e-01f, 5.01223356e-02f, -1.69881005e-02f, -7.76368827e-02f, 9.28005278e-02f, -8.84726495e-02f,
  7.02642202e-02f, 2.39013150e-01f, -2.16787122e-02f, -8.98341089e-02f, 1.66206926e-01f, 2.14910861e-02f, -7.76318163e-02f, 2.27693794e-03f, -9.29651782e-02f, 1.45134613e-01f,
  4.71584462e-02f, -9.75724757e-02f, -1.07606776e-01f, 7.71583058e-03f, -1.28318608e-01f, 4.84656543e-02f, -1.74484309e-03f, -9.26130936e-02f, 2.95818709e-02f, 3.42440717e-02f,
  5.65991737e-02f, 3.15614343e-01f, -9.11484286e-02f, -4.33252975e-02f, -2.11884221e-03f, -2.91445962e-04f, -2.15025358e-02f, 8.33886769e-03f, 8.44343454e-02f, 6.96591381e-03f,
  -6.18655235e-03f, 1.15814777e-02f, -5.62193468e-02f, -7.51318708e-02f, -9.39838216e-02f, 1.52159883e-02f, 1.58849075e-01f, -1.85373724e-01f, 1.70382380e-01f, 1.14923783e-01f,
  1.93038285e-01f, -5.13437986e-02f, 2.19746549e-02f, -4.38130051e-02f, 1.89814225e-01f, 3.04139666e-02f, 1.05085813e-01f, -4.64088544e-02f, 2.10184395e-01f, 4.76015583e-02f,
  4.37168963e-02f, 8.37417901e-01f, -7.26070534e-03f, 7.18705416e-01f, -3.64040077e-01f, 2.83373892e-01f, 7.63540983e-01f, 3.16809267e-01f, 7.05238760e-01f, 3.75555873e-01f,
  -3.65075648e-01f, 6.88840568e-01f, 1.42586932e-01f, 3.45041305e-01f, -8.32891464e-02f, 1.82874247e-01f, 5.73741555e-01f, 3.88110995e-01f, 2.05009669e-01f, 5.59116483e-01f,
  8.00618455e-02f, 3.72823626e-01f, -4.32882994e-01f, 1.59523591e-01f, -7.80619681e-02f, 8.71430859e-02f, -3.95551533e-01f, -2.55154580e-01f, -1.86988890e-01f, -1.23533167e-01f,
  -1.86204985e-01f, 3.37415338e-01f, -6.26468807e-02f, 4.93027344e-02f, -3.73517573e-02f, -7.24413991e-02f, -1.32558107e-01f, -2.07520619e-01f, -1.67560518e-01f, 1.19157515e-01f,
  2.24559993e-01f, -2.03912370e-02f, 2.05986112e-01f, -1.21704652e-03f, 4.97208908e-02f, 4.94467514e-03f, -7.49388188e-02f, -3.55040312e-01f, 1.34539917e-01f, -8.29542577e-02f,
  -1.60860091e-01f, -5.80819733e-02f, -1.00628637e-01f, 1.17101386e-01f, -6.09132163e-02f, 1.07387707e-01f, 6.82017282e-02f, -8.24004486e-02f, 4.32707630e-02f, 1.47734240e-01f,
  -4.22985069e-02f, 6.84881583e-02f, 4.55378592e-02f, -9.23504680e-02f, 4.75942865e-02f, -1.15063660e-01f, 6.49062470e-02f, -1.61508203e-01f, 1.06857866e-01f, 8.79031345e-02f,
  2.06699595e-03f, 2.72853058e-02f, 1.04701161e-01f, 3.32461521e-02f, 9.54868793e-02f, 7.38557130e-02f, -1.73378870e-01f, 2.62245592e-02f, 6.62920177e-02f, -1.38024896e-01f,
  -6.40034229e-02f, 7.47387856e-02f, 9.39927176e-02f, -2.53153384e-01f, -2.38346984e-03f, -3.49369198e-02f, 2.34647468e-02f, -5.63397259e-02f, -5.84616996e-02f, -8.34094957e-02f,
  3.24437678e-01f, 7.30413973e-01f, 1.64288715e-01f, 2.66247749e-01f, 7.66849145e-02f, 8.41503441e-02f, -6.93509579e-02f, 9.56127718e-02f, 7.08165169e-02f, 2.05338314e-01f,
  9.94527042e-02f, 1.62335455e-01f, 2.27732267e-02f, -2.69452572e-01f, -6.77162409e-02f, 8.64343420e-02f, 1.11630201e-01f, -2.39715669e-02f, 2.46303119e-02f, 4.96907532e-02f,
  1.08653165e-01f, 2.46934339e-01f, 3.29801850e-02f, 8.18998590e-02f, 7.68669695e-02f, -9.47139487e-02f, 1.29354373e-01f, -3.52842547e-02f, -1.59300655e-01f, 3.68417650e-02f,
  -1.12167023e-01f, -2.43537072e-02f, -4.11563188e-01f, -8.33220303e-01f, -8.86988416e-02f, -3.97321850e-01f, -7.51307368e-01f, -8.56083408e-02f, -2.19707012e-01f, -8.67383555e-02f,
  -4.14502233e-01f, -3.23329717e-01f, 2.40218163e-01f, -6.51168585e-01f, -3.58459115e-01f, 1.98163718e-01f, -7.45983005e-01f, -7.44118571e-01f, 1.34507641e-01f, -5.26292443e-01f,
  -3.42273742e-01f, -3.90939802e-01f, -3.21777612e-01f, 3.36908579e-01f, -5.78898251e-01f, -1.34288058e-01f, 1.94117874e-01f, 2.27816015e-01f, -3.94186497e-01f, 4.88371477e-02f,
  -1.57666534e-01f, 1.13888413e-01f, -1.77253023e-01f, 2.24041473e-02f, 5.19446703e-03f, -2.17728782e-02f, -2.80456722e-01f, -3.28260809e-02f, -1.80154275e-02f, -7.10939318e-02f,
  -1.11334823e-01f, 2.40219146e-01f, -2.81637430e-01f, 2.57712573e-01f, -4.14863899e-02f, 4.56314385e-02f, 1.62522256e-01f, -1.19976111e-01f, -4.28963751e-02f, -1.02750845e-02f,
  -3.13731372e-01f, 5.35393208e-02f, -4.93846275e-02f, -6.29502386e-02f, -9.30873081e-02f, -6.30329037e-03f, -1.42390102e-01f, -1.23602048e-01f, 1.61311647e-03f, 6.06040247e-02f,
  5.20945452e-02f, 1.26099223e-02f, 6.00045323e-02f, 4.17404994e-02f, 4.65129763e-02f, -3.29616317e-03f, -9.71938893e-02f, -7.32393861e-02f, 1.01152919e-01f, -1.26399934e-01f,
  6.09289557e-02f, -9.12744105e-02f, 6.40819222e-02f, -1.24861464e-01f, -3.68689112e-02f, 1.27233177e-01f, 9.41916555e-02f, -4.65023965e-02f, -2.83237934e-01f, 9.49296504e-02f,
  3.31958383e-02f, -7.72072226e-02f, -1.19925767e-01f, 6.81041628e-02f, 3.70611660e-02f, 1.56575724e-01f, -5.76945841e-02f, -6.37240708e-02f, 1.81780219e-01f, -7.79203102e-02f,
  -8.06457549e-02f, 8.81956592e-02f, 1.32437691e-01f, 5.50535247e-02f, -3.47195901e-02f, 8.16029459e-02f, -3.45714390e-02f, -1.61078408e-01f, -1.13428436e-01f, 7.91522413e-02f,
  4.00197878e-02f, -1.30343109e-01f, -1.20359370e-02f, 1.01214774e-01f, -6.73544109e-02f, -1.28414571e-01f, -1.67259023e-01f, -1.22166509e-02f, -1.48147061e-01f, 1.12453505e-01f,
  -7.60310367e-02f, 9.47753042e-02f, 5.67803308e-02f, 1.29292682e-02f, -1.39212027e-01f, 1.75998118e-02f, 9.10158753e-02f, 3.04607470e-02f, 2.53342465e-02f, -1.76960692e-01f,
  8.26645613e-01f, -6.60091698e-01f, 1.64211109e-01f, 7.31249332e-01f, 4.63292032e-01f, 6.20112680e-02f, 2.30223313e-01f, 1.36182994e-01f, 5.04041910e-01f, -6.39352739e-01f,
  -3.49811673e-01f, 1.24631986e-01f, -6.84164703e-01f, 3.10153186e-01f, -8.24120045e-02f, -5.38140118e-01f, 1.99796557e-01f, -6.68950751e-02f, 1.38224781e-01f, -1.07895238e-02f,
  3.02188456e-01f, -1.06625237e-01f, -6.31394312e-02f, 5.79499342e-02f, 3.45352411e-01f, 3.25165927e-01f, -2.68897057e-01f, -1.86478302e-01f, 3.36416870e-01f, 1.28678858e-01f,
  1.32811069e-01f, 2.10010156e-01f, 3.82777639e-02f, -1.16831794e-01f, 8.28878838e-04f, 3.52874137e-02f, -2.76669394e-02f, -2.89580375e-02f, 1.73933759e-01f, 7.73755386e-02f,
  -4.09820639e-02f, 1.72949880e-01f, 1.57366037e-01f, 1.03591785e-01f, 1.18123405e-01f, 2.25664139e-01f, 9.21219960e-02f, -3.51362452e-02f, 1.65516675e-01f, 2.30335500e-02f,
  3.60413343e-02f, 9.86915752e-02f, 6.69671297e-02f, 1.06963381e-01f, -2.78619565e-02f, 2.40950227e-01f, 1.19668700e-01f, -6.97419718e-02f, -5.16122878e-02f, 2.11469293e-01f,
  -4.65480313e-02f, -1.63085863e-01f, -1.25693023e-01f, 6.78778589e-02f, 1.16848238e-01f, 2.10101321e-01f, 6.91213086e-02f, -3.54357697e-02f, 1.09817773e-01f, -8.56778920e-02f,
  4.90972623e-02f, 5.15882447e-02f, 2.80131195e-02f, 2.65180990e-02f, -2.32559163e-02f, 1.67645320e-01f, -2.29720697e-02f, 1.60063848e-01f, -3.37267816e-02f, 8.73806998e-02f,
  3.88748683e-02f, 3.35853994e-02f, -2.20406339e-01f, 1.98471352e-01f, -2.71161534e-02f, -1.39070705e-01f, -3.23398635e-02f, 9.16422680e-02f, 3.29377986e-02f, -1.33463264e-01f,
  -9.03513551e-01f, -9.00733292e-01f, -2.06421614e-01f, 9.64633375e-02f, -6.81010336e-02f, -2.12418765e-01f, 9.52739827e-03f, 1.55509472e-01f, -2.41821721e-01f, 3.98208648e-02f,
  -4.46813963e-02f, 1.83310837e-01f, -3.72614749e-02f, 4.96394224e-02f, -1.41149089e-01f, -1.65011853e-01f, 1.70075335e-02f, -1.64199531e-01f, -1.46611109e-01f, -1.41076565e-01f,
  2.66586300e-02f, -8.60630125e-02f, 8.84999260e-02f, 1.75776765e-01f, 7.11346865e-02f, -4.60354984e-02f, -4.12376858e-02f, 1.44188646e-02f, -4.82501984e-02f, -7.71932527e-02f,
  -1.33619976e+00f, 1.37846872e-01f, 2.05419809e-01f, 2.40438417e-01f, -9.12507832e-01f, 4.52176511e-01f, 4.45541382e-01f, -3.26428503e-01f, 9.77423042e-02f, 2.51540035e-01f,
  -5.71301818e-01f, 1.36651648e-02f, 1.67445894e-02f, 3.81545126e-01f, 4.53068376e-01f, 8.07465374e-01f, 5.16691506e-01f, 3.89283955e-01f, -2.40530148e-02f, -3.70085686e-01f,
  -3.21731418e-01f, -1.12886280e-01f, 2.88110793e-01f, -2.16798663e-01f, -5.77212512e-01f, -1.69162855e-01f, -1.02982454e-01f, -1.12512540e-02f, 2.14484110e-01f, -4.79416251e-02f,
  -6.10898077e-01f, -6.59829676e-01f, -3.33926588e-01f, -1.73454024e-02f, -1.52349904e-01f, -3.51298489e-02f, -1.34961400e-02f, -2.57061943e-02f, -8.06107894e-02f, 1.22820539e-02f,
  -5.47648966e-02f, -7.81999249e-03f, -2.12244585e-01f, 5.37084043e-02f, -1.55766472e-01f, -5.18954583e-02f, -5.77363931e-02f, -1.44313276e-01f, -5.66179752e-02f, -1.42147049e-01f,
  7.58062303e-02f, 7.78752565e-02f, 5.27877733e-03f, 1.84088111e-01f, -9.48633999e-02f, -5.62929176e-02f, 3.28484118e-01f, -8.36965889e-02f, -1.22292507e-02f, -2.37593148e-02f,
  1.49618044e-01f, 1.14149027e-01f, 2.76864544e-02f, -8.91099125e-02f, -8.12505558e-02f, 1.26136644e-02f, 1.08114980e-01f, -1.26328310e-02f, 9.13180038e-02f, -1.33946404e-01f,
  -1.09441079e-01f, -1.21399537e-01f, -1.87592626e-01f, 1.36797547e-01f, -1.55950710e-02f, 1.20592015e-02f, -1.34364171e-02f, -1.56504586e-01f, 7.34456554e-02f, 6.26170412e-02f,
  6.03397228e-02f, 7.35384747e-02f, -1.24514192e-01f, 7.30311051e-02f, 5.83426282e-02f, -7.01389462e-02f, -1.50943547e-01f, 4.84278947e-02f, -4.44943411e-03f, -1.32072493e-01f,
  -4.04809654e-01f, -1.96917266e-01f, -1.19921930e-01f, -2.52431661e-01f, 2.01269343e-01f, -9.93888006e-02f, 2.67050564e-02f, -1.20260529e-01f, 2.74145678e-02f, -1.47587582e-01f,
  -1.67160928e-01f, 7.24179000e-02f, -1.10635124e-01f, 4.17799018e-02f, 1.43865615e-01f, 6.64453860e-03f, 9.26680584e-03f, -3.15014273e-02f, -6.26104251e-02f, -1.14016514e-02f,
  -1.77602828e-01f, -4.54205088e-02f, 2.28113055e-01f, 1.40661048e-02f, -6.29196092e-02f, -7.28798211e-02f, -1.86265945e-01f, 2.45504770e-02f, -6.50791228e-02f, 2.43647117e-02f,
  -1.32698250e+00f, 8.55202258e-01f, 5.92247903e-01f, -7.85054266e-01f, 5.24494529e-01f, 3.48775655e-01f, -3.33788931e-01f, 4.32869315e-01f, -4.78636414e-01f, 1.82979733e-01f,
  -2.39354193e-01f, -3.33697587e-01f, 2.74411261e-01f, -2.96571702e-01f, -6.84778810e-01f, -3.03342253e-01f, -2.08316341e-01f, -3.68202567e-01f, -4.47945558e-02f, -1.15029402e-02f,
  -1.57612905e-01f, -1.23493291e-01f, 2.04391688e-01f, 7.70942628e-01f, 3.16806257e-01f, 1.40581101e-01f, -1.59912929e-01f, 5.79568028e-01f, 2.28343368e-01f, -4.27204147e-02f,
  -3.22757274e-01f, -4.61796485e-02f, -3.74457147e-03f, 7.61604533e-02f, 5.48021644e-02f, 5.12401611e-02f, -2.70648915e-02f, -3.84942666e-02f, -1.19257569e-01f, 1.31597593e-02f,
  -7.88993761e-02f, 1.20253950e-01f, -1.12150967e-01f, 2.91802865e-02f, 1.08392745e-01f, 1.56100675e-01f, 1.27152875e-01f, 6.66705798e-03f, 1.97871700e-01f, 4.42566462e-02f,
  1.09663509e-01f, 1.31195113e-01f, 7.17639402e-02f, -1.09403715e-01f, 5.61569892e-02f, 1.59782842e-01f, 1.51350304e-01f, 1.13030232e-01f, 1.98667757e-02f, -1.65014997e-01f,
  -8.81371088e-03f, -1.01526760e-01f, 9.36063379e-02f, -7.36074299e-02f, -8.45571533e-02f, 4.16337028e-02f, -4.87504154e-02f, -9.12250355e-02f, -7.69727379e-02f, 3.01925931e-02f,
  -3.94365713e-02f, -1.34976506e-01f, 8.63602534e-02f, -2.36556795e-03f, -1.66833252e-01f, -1.96118996e-01f, 9.79830921e-02f, -2.33638510e-02f, -4.56818938e-02f, -1.00030154e-01f,
  -1.18235022e-01f, 1.84560511e-02f, 3.14028971e-02f, 3.62681113e-02f, 1.26787005e-02f, -2.79448181e-02f, 4.32257950e-02f, 1.05069548e-01f, -2.86924317e-02f, 3.36256959e-02f,
  -4.06517804e-01f, -1.98527396e-01f, -6.89535439e-02f, 3.93156335e-02f, -1.09668709e-01f, -2.68146917e-02f, -4.54453155e-02f, 1.15088426e-01f, 8.70796070e-02f, -4.98275571e-02f,
  1.83606759e-01f, 5.83705902e-02f, 1.30213080e-02f, -1.59728602e-01f, -3.69175076e-02f, 5.39463982e-02f, -9.08821523e-02f, -2.27163970e-01f, -8.39449763e-02f, 8.43303502e-02f,
  -1.62489526e-02f, -2.26442087e-02f, 8.52541029e-02f, 1.88084111e-01f, 6.90605268e-02f, -1.26898875e-02f, -5.46809137e-02f, 2.13730242e-02f, 5.64727224e-02f, 1.44339338e-01f,
  -1.03279567e+00f, 8.86991322e-01f, 9.91048664e-02f, -4.01429951e-01f, -2.04117939e-01f, -7.41969407e-01f, -2.48613432e-01f, 4.01774123e-02f, 2.31254458e-01f, 6.13572240e-01f,
  8.58660787e-02f, 5.41102171e-01f, 5.50069571e-01f, 2.47658342e-01f, -6.45477772e-01f, 2.53922313e-01f, -5.32016397e-01f, -1.11801840e-01f, 2.29066666e-02f, -4.05245394e-01f,
  -2.56875902e-01f, -3.75085384e-01f, -7.16720223e-02f, -9.95029211e-02f, -3.25252354e-01f, 3.64589877e-02f, -3.64866585e-01f, 2.63942719e-01f, -3.22992653e-01f, -1.00204617e-01f,
  -8.07463169e-01f, -1.92756876e-01f, 1.52820095e-01f, -1.88564256e-01f, -4.04402107e-01f, -1.99072033e-01f, -2.45259240e-01f, -2.37191282e-03f, -7.12575689e-02f, -9.69369262e-02f,
  4.64507043e-02f, 2.57730708e-02f, -4.05305363e-02f, 1.62203342e-01f, -4.37013060e-02f, 1.54429570e-01f, -1.77255515e-02f, -5.47769591e-02f, 1.39383793e-01f, -3.08394269e-03f,
  2.38247395e-01f, 1.04192913e-01f, -7.92784169e-02f, 8.12689364e-02f, -9.15281698e-02f, 9.36551951e-03f, -1.45322099e-01f, 2.24207547e-02f, -2.15161830e-01f, -1.75082624e-01f,
  -3.75556573e-02f, -2.35598370e-01f, -1.52970493e-01f, 1.28909618e-01f, 4.44378965e-02f, 1.61138047e-02f, 1.56868789e-02f, 1.45433068e-01f, -3.48970592e-02f, -6.82636648e-02f,
  -1.41313508e-01f, -4.91413400e-02f, -3.68394852e-02f, -2.19829798e-01f, -6.47361502e-02f, -1.30367920e-01f, 9.25588757e-02f, -2.44504958e-02f, 2.83636693e-02f, -1.27097473e-01f,
  9.14795697e-02f, -8.11309437e-05f, 2.13753119e-01f, -1.14291281e-01f, -5.12419268e-02f, -1.87726188e-02f, 7.09019378e-02f, 4.29698862e-02f, -4.89064753e-02f, -1.45496160e-01f,
  -1.11664391e+00f, -8.14918697e-01f, -4.05847803e-02f, 2.14801319e-02f, -8.59472305e-02f, -2.81461626e-01f, -1.36163637e-01f, -1.64945260e-01f, -2.98864782e-01f, -1.68649346e-01f,
  -1.80404514e-01f, 8.41717049e-03f, -2.20381975e-01f, 3.90682891e-02f, -4.33522835e-02f, -1.29812390e-01f, -8.00619274e-02f, 7.51125216e-02f, -2.92250156e-01f, -1.18289098e-01f,
  1.04075246e-01f, -3.01496722e-02f, -1.42374367e-01f, -1.69211701e-01f, -2.17788994e-01f, -1.85316920e-01f, -2.18538448e-01f, 2.09463745e-01f, -3.64879876e-01f, 1.21751830e-01f,
  5.68380058e-01f, 5.41417897e-01f, 4.86121446e-01f, 3.73267233e-01f, 1.51248947e-01f, 3.62385660e-01f, -1.03460811e-01f, 5.59901357e-01f, 8.69673073e-01f, -2.05212459e-01f,
  -2.01233521e-01f, -6.80198669e-02f, -4.86880958e-01f, 2.37922370e-02f, -2.47132659e-01f, 6.40245900e-02f, 1.55073702e-01f, -1.53582498e-01f, 4.12604779e-01f, -2.20104277e-01f,
  1.90914124e-01f, -8.38415623e-01f, -5.22347212e-01f, -4.60777462e-01f, 8.74873847e-02f, 1.35082705e-02f, -8.05033386e-01f, -3.63024801e-01f, -3.42904359e-01f, -1.91493437e-01f,
  7.39650577e-02f, 3.52059901e-01f, 8.10412392e-02f, 6.95714206e-02f, 2.52636909e-01f, 4.09980938e-02f, -2.76360326e-02f, -1.34802043e-01f, 4.64842692e-02f, -6.51711971e-02f,
  -7.83879906e-02f, -1.59064189e-01f, 1.37884706e-01f, -1.09351106e-01f, 1.32696494e-01f, 1.42230779e-01f, 6.10535368e-02f, 3.46703678e-01f, -1.16943792e-01f, 8.90201777e-02f,
  -1.60580259e-02f, 2.73060739e-01f, 1.55165896e-01f, -8.35853666e-02f, 3.44818719e-02f, 1.59588039e-01f, 1.03520691e-01f, -8.86071287e-03f, -5.02013462e-03f, 1.64424747e-01f,
  -8.36406089e-03f, 1.17864698e-01f, -1.43511638e-01f, 3.10872942e-02f, -3.88149805e-02f, 1.56093612e-01f, -6.97073117e-02f, -5.29962666e-02f, 8.01065415e-02f, -1.41012281e-01f,
  5.98384738e-02f, 1.03591830e-01f, 2.82215271e-02f, -8.30476917e-03f, 1.02812551e-01f, 1.04686797e-01f, -1.97708815e-01f, 3.72015871e-02f, 1.34019807e-01f, 9.71101075e-02f,
  -1.05554253e-01f, -6.49661273e-02f, -1.60119697e-01f, -1.32977769e-01f, -1.01501331e-01f, -5.29426411e-02f, 1.04818761e-01f, 1.57975346e-01f, 8.88594016e-02f, -2.24406302e-01f,
  1.53734490e-01f, 2.11325064e-01f, 7.96592906e-02f, -1.35025442e-01f, -3.29733752e-02f, 4.37428057e-02f, 2.82021612e-02f, 1.82216108e-01f, 7.05622062e-02f, 9.42773148e-02f,
  -5.95088191e-02f, -2.44102515e-02f, -7.53182396e-02f, -5.03641590e-02f, -3.81822437e-02f, -1.41414581e-02f, -1.92343235e-01f, 1.15541853e-01f, -9.86255407e-02f, -2.31186743e-03f,
  -2.88004518e-01f, 7.65427807e-03f, 3.22304890e-02f, 1.42477164e-02f, 2.86047235e-02f, -8.72516409e-02f, 1.38605490e-01f, -3.61265652e-02f, -1.39235094e-01f, 4.29915674e-02f,
  1.55029386e-01f, 2.06155762e-01f, 4.87215519e-01f, 5.25095761e-01f, -1.79770932e-01f, -5.31812012e-01f, -5.96879184e-01f, 9.25708115e-02f, -9.23779681e-02f, -4.86021675e-02f,
  -5.47679901e-01f, 6.09609902e-01f, -6.59512103e-01f, 1.26519650e-01f, -4.34657186e-01f, -6.96599782e-01f, 1.40821829e-01f, 1.68475166e-01f, -2.00452313e-01f, 3.49480093e-01f,
  2.83549339e-01f, -2.75382936e-01f, 3.28683406e-01f, 1.07059814e-01f, 3.72824639e-01f, 6.19509220e-01f, 3.66159499e-01f, -2.13991273e-02f, 6.34477139e-01f, -1.15090400e-01f,
  -8.10648873e-02f, -1.76911384e-01f, 2.22947612e-01f, 1.17867231e-01f, 1.56096086e-01f, 1.10989444e-01f, 2.32440576e-01f, -1.40155822e-01f, -9.50450450e-02f, 9.28387791e-02f,
  3.12165767e-02f, 9.26596373e-02f, 7.11378977e-02f, -1.23426825e-01f, 6.14154786e-02f, 1.43468410e-01f, 1.01264775e-01f, 2.81680524e-01f, 3.78058329e-02f, 6.15978539e-02f,
  1.73846811e-01f, 1.41029418e-01f, 1.49627194e-01f, 9.41204280e-02f, 6.17861189e-02f, 1.39606660e-02f, 2.09161080e-02f, 2.08356529e-01f, 9.42461491e-02f, 5.44635653e-02f,
  5.44065312e-02f, -1.51999280e-01f, -6.95811808e-02f, -1.27510011e-01f, -1.61420390e-01f, -1.02369934e-01f, -1.27974853e-01f, -1.06528923e-01f, -9.19458047e-02f, -3.92595083e-02f,
  -9.71940625e-03f, 1.52363060e-02f, -1.86777070e-01f, 1.00765616e-01f, -2.56873611e-02f, -6.26962930e-02f, 1.04806863e-01f, 7.70602226e-02f, 2.33376473e-01f, 1.11000441e-01f,
  -2.86132425e-01f, -6.65992200e-02f, 1.72946975e-02f, 2.34179106e-02f, -2.08833590e-01f, 3.72726731e-02f, 5.39418608e-02f, -5.22482470e-02f, -3.83760631e-02f, -4.28858883e-04f,
  1.73468754e-01f, 1.21693492e-01f, 1.13083526e-01f, -5.86499944e-02f, -4.72189523e-02f, -5.19873500e-02f, -1.31713346e-01f, 1.13446936e-01f, 6.84143417e-03f, -2.27580681e-01f,
  2.38960311e-01f, 8.74401927e-02f, 4.36567403e-02f, -1.63601642e-03f, 1.29306000e-02f, -7.47876465e-02f, -3.56544405e-02f, 6.55584633e-02f, 1.37316912e-01f, 1.89423889e-01f,
  1.03509441e-01f, -1.81369960e-01f, -2.70811878e-02f, 2.01190025e-01f, -1.35257840e-02f, -1.87169220e-02f, -2.55210847e-02f, 1.55851822e-02f, -5.35592772e-02f, -7.21833780e-02f,
  -1.06065102e-01f, 7.09922791e-01f, 4.30729389e-02f, 1.82416663e-01f, 1.42662793e-01f, -8.55019569e-01f, -3.86493921e-01f, 1.05327621e-01f, -1.38112590e-01f, 4.42479968e-01f,
  -3.68107408e-02f, 3.10352683e-01f, 3.30488160e-02f, -3.57213140e-01f, -1.12194729e+00f, -5.70481598e-01f, -4.98755008e-01f, -1.90541297e-01f, -1.28089637e-01f, 3.62540364e-01f,
  -3.81356418e-01f, -1.99588686e-01f, -3.67642432e-01f, 3.95240843e-01f, 3.81817639e-01f, 5.51573455e-01f, 4.68825519e-01f, 4.33361411e-01f, 1.73180178e-01f, -1.58496886e-01f,
  -2.45508358e-01f, 2.94498116e-01f, 1.78669095e-01f, -7.19916523e-02f, -2.01017857e-02f, 1.84560612e-01f, 4.11334410e-02f, -2.72973068e-02f, -6.14961497e-02f, -9.78058949e-02f,
  1.84800982e-01f, -1.56032862e-02f, -3.43741737e-02f, 5.54456301e-02f, 2.08130568e-01f, 1.13345772e-01f, -7.06887841e-02f, -8.48382339e-02f, 8.72006565e-02f, -2.28959485e-03f,
  -7.59950206e-02f, 3.67849171e-02f, 1.30750194e-01f, -1.64171238e-03f, -7.52419233e-04f, -1.69560183e-02f, -1.07099816e-01f, -7.36556053e-02f, 7.34027401e-02f, -2.58972775e-02f,
  1.74223334e-01f, 2.62627867e-03f, -4.61906902e-02f, 1.26203625e-02f, -2.64376891e-03f, -2.32518800e-02f, 5.22832945e-02f, -9.68089998e-02f, 4.33712825e-02f, 3.58879603e-02f,
  -1.07987389e-01f, 1.13381281e-01f, 5.21214716e-02f, -2.73458590e-03f, -2.31465697e-02f, 7.31527358e-02f, -5.59503399e-02f, 7.32063055e-02f, -1.43398300e-01f, -1.37388006e-01f,
  1.63235143e-01f, -6.58881441e-02f, -2.90415939e-02f, 1.67988434e-01f, -8.79089162e-02f, -5.65904826e-02f, 6.60548136e-02f, -6.44833818e-02f, -1.14715565e-02f, 2.53574084e-02f,
  -3.23728919e-02f, 4.39367414e-01f, -3.96087877e-02f, 6.00872375e-03f, 5.56064397e-02f, -7.31301755e-02f, -1.67241424e-01f, -9.05396789e-02f, 8.22299942e-02f, -3.73522677e-02f,
  1.06175393e-01f, 1.05551064e-01f, 4.86103334e-02f, 6.10745661e-02f, -8.25671777e-02f, -8.15140158e-02f, 1.15116693e-01f, 6.31303480e-03f, 1.25992417e-01f, 3.03448364e-02f,
  2.06363022e-01f, 6.68464899e-02f, -6.46893010e-02f, 1.14438146e-01f, 6.44450858e-02f, 3.38186398e-02f, 1.67604461e-01f, 5.69848269e-02f, 9.98687223e-02f, -4.93558645e-02f,
  -2.37429425e-01f, -1.02776900e-01f, 6.90460622e-01f, 4.98364158e-02f, 4.89001811e-01f, 7.55027652e-01f, 6.16507113e-01f, 3.17099571e-01f, 5.25192797e-01f, -5.90217471e-01f,
  -4.72400635e-01f, -4.10554916e-01f, 2.18960524e-01f, -3.66106600e-01f, 6.65404618e-01f, 4.66675192e-01f, 1.48788035e-01f, -1.98398098e-01f, 3.26620877e-01f, -2.70942524e-02f,
  3.19243520e-01f, -3.14134449e-01f, 3.27159584e-01f, -3.25559884e-01f, -6.66247979e-02f, -1.51300326e-01f, -4.40443903e-01f, 4.24178809e-01f, -5.49909830e-01f, 2.13509560e-01f,
  1.10361002e-01f, -2.08291277e-01f, 5.45210689e-02f, 3.01230326e-02f, -1.95006351e-03f, -8.57129097e-02f, 6.28746003e-02f, 2.12595552e-01f, 1.76512554e-01f, -5.51268198e-02f,
  -2.11082593e-01f, -6.00338727e-02f, -1.16247743e-01f, 1.08445033e-01f, 1.38872996e-01f, -1.55599117e-02f, 7.00804517e-02f, 1.63099542e-02f, 3.44307609e-02f, 1.40118033e-01f,
  9.16805342e-02f, -8.04153457e-03f, 8.87534767e-02f, -1.58457354e-01f, 9.66667458e-02f, -7.84620084e-03f, 5.41026741e-02f, 1.15977377e-01f, 3.65371332e-02f, 5.03996350e-02f,
  2.54806988e-02f, 1.70746863e-01f, -3.59948836e-02f, -1.20287109e-02f, 6.85248524e-02f, -9.02443472e-03f, -6.49681166e-02f, -7.27604404e-02f, -2.67355088e-02f, -4.04323228e-02f,
  -1.65543575e-02f, -1.25779778e-01f, 1.54738069e-01f, 2.65533142e-02f, -9.76369902e-02f, -5.84042296e-02f, -6.11541094e-03f, -7.10107833e-02f, -6.95587695e-02f, -4.96154763e-02f,
  1.35941133e-02f, 6.60449415e-02f, -1.44073799e-01f, -1.39816795e-02f, 1.23457657e-02f, 7.08059967e-02f, -3.82325286e-03f, 6.97207823e-02f, -7.32436776e-02f, 5.80482073e-02f,
  1.55185713e-02f, -5.83896600e-02f, -2.85806283e-02f, -2.24297494e-01f, -8.80085826e-02f, -1.13669105e-01f, 1.79242283e-01f, -6.73387125e-02f, 1.89389318e-01f, -9.66915563e-02f,
  -7.95832872e-02f, -8.83123502e-02f, -3.32667008e-02f, -6.63782703e-03f, 7.29970038e-02f, 6.71361387e-02f, -9.02998552e-04f, -1.39842257e-01f, 4.33256887e-02f, -9.51896608e-02f,
  -1.17175043e-01f, 1.72808894e-03f, -7.70749198e-03f, -1.52559116e-01f, -3.31352472e-01f, -1.95841581e-01f, -1.76509112e-01f, 3.71430255e-02f, 1.17275808e-02f, 5.74727319e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  6.20045185e-01f, 8.36937666e-01f, 7.91610181e-01f, 4.75313902e-01f, 5.83589971e-01f, 6.10248566e-01f, 4.31897283e-01f, 5.02245009e-01f, 6.28170967e-01f, 3.40384066e-01f,
  9.55208540e-01f, 7.26690352e-01f, 4.75661874e-01f, 8.30936611e-01f, 9.37288344e-01f, 6.98091805e-01f, 7.16121197e-01f, 5.82149565e-01f, 7.59224057e-01f, 9.01977360e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.18235195e-01f, 8.43568444e-02f, 5.54898903e-02f, 1.18075691e-01f, -5.18473446e-01f, 2.14663342e-01f, -3.07692498e-01f, 6.06828988e-01f, 3.98363590e-01f, -7.82352030e-01f,
  -7.07054794e-01f, 8.32480967e-01f, -3.55841279e-01f, -4.35157090e-01f, -3.79347056e-01f, -8.77369285e-01f, 9.44871485e-01f, 3.07828188e-01f, -7.95393661e-02f, -1.12996078e+00f,
  2.70170033e-01f, -7.83384562e-01f, 1.12369813e-01f, -9.56694305e-01f, -3.34980637e-01f, 9.22378719e-01f, -2.34472319e-01f, 3.40122640e-01f, -6.05301201e-01f, -4.62205410e-01f,
  -4.96676773e-01f, -7.45250821e-01f, 9.55033064e-01f, 2.25637555e-01f, 9.45441723e-02f, 4.15569879e-02f, -7.35657454e-01f, 4.18925053e-03f, -5.89142680e-01f, 7.37718269e-02f,
  -5.32739162e-01f, -6.32393122e-01f, -2.82368541e-01f, -9.12013829e-01f, -1.13145518e+00f, -6.59622252e-01f, -2.23726690e-01f, 6.18188322e-01f, 5.61970770e-01f, 5.83080471e-01f,
  -2.16218606e-01f, 7.66930461e-01f, 5.32650888e-01f, -3.71417195e-01f, 6.50158301e-02f, 4.82779071e-02f, -6.10531211e-01f, -6.14029765e-01f, -5.02165079e-01f, -8.49040210e-01f,
  -4.00730789e-01f, -7.43542254e-01f, -1.25237301e-01f, -5.76076508e-01f, -6.02432072e-01f, -4.60149616e-01f, -3.51907283e-01f, -3.15085977e-01f, 2.91556984e-01f, 2.15533152e-02f,
  5.21984935e-01f, 4.10227150e-01f, -4.09981534e-02f, 4.90950793e-01f, 7.13465437e-02f, 6.54322982e-01f, -1.44811213e-01f, -7.94016480e-01f, 2.87590504e-01f, 3.24302644e-01f,
  2.08492577e-01f, -6.38367161e-02f, 6.48876369e-01f, 5.23630857e-01f, -4.77902628e-02f, 1.11631155e-01f, -1.30943489e+00f, -6.45589471e-01f, 7.34529853e-01f, 2.36059874e-01f,
  -1.54468045e-01f, -3.14133346e-01f, -6.15549088e-01f, 2.68844277e-01f, -8.26904833e-01f, -5.82496047e-01f, -2.87020892e-01f, 7.57242665e-02f, 2.78602373e-02f, 1.59680784e-01f,
  9.95111745e-03f, -6.45118356e-01f, -3.39999586e-01f, -2.97455966e-01f, 7.73473024e-01f, -4.03352305e-02f, 1.67482078e-01f, 5.13100743e-01f, -5.18712759e-01f, -5.54051578e-01f,
  -1.27519143e+00f, -2.89442569e-01f, -6.33676827e-01f, -6.02681696e-01f, -3.63412291e-01f, -1.69339582e-01f, -4.01662827e-01f, 9.64290649e-02f, 2.71111935e-01f, 3.91974360e-01f,
  -4.74851787e-01f, -9.83308196e-01f, 6.51818812e-01f, 7.53021181e-01f, -5.28885007e-01f, -9.29606736e-01f, 7.51218140e-01f, -7.02226937e-01f, 4.84038562e-01f, 8.76307786e-02f,
  3.85964245e-01f, 2.00113624e-01f, 3.61483157e-01f, 4.98307139e-01f, -4.64592010e-01f, 6.30794883e-01f, 7.08722234e-01f, 6.66448712e-01f, 7.06994116e-01f, -5.62555432e-01f,
  -8.07866395e-01f, -4.05177996e-02f, -1.61727622e-01f, -5.91880262e-01f, -6.71291709e-01f, 6.83386743e-01f, -3.31042558e-01f, -8.67444336e-01f, -5.45136809e-01f, -9.24843028e-02f,
  -7.03197479e-01f, 1.93378747e-01f, -5.74277520e-01f, 4.41166788e-01f, 9.43716407e-01f, 2.39414364e-01f, 4.38685387e-01f, -3.22393566e-01f, -1.32394838e+00f, 6.26085281e-01f,
  6.74910769e-02f, 4.59956020e-01f, -8.87980908e-02f, 3.40878777e-02f, 6.57298505e-01f, 4.40421373e-01f, -3.09813544e-02f, -5.61366796e-01f, -8.72260451e-01f, -1.72958314e-01f,
  -4.35241640e-01f, -4.08277363e-01f, 4.86020669e-02f, -5.58876336e-01f, -7.59410381e-01f, -8.37910235e-01f, -8.38360727e-01f, -6.23258591e-01f, 3.58061492e-01f, 1.25806734e-01f,
  -3.51852089e-01f, -6.50789440e-01f, 1.06206489e+00f, -5.26737690e-01f, -3.33540022e-01f, 5.87581754e-01f, -9.92709875e-01f, -2.62663007e-01f, 7.07451940e-01f, -1.46568477e-01f,
  -4.98760402e-01f, 5.60295761e-01f, -4.04849201e-01f, -6.79862946e-02f, -1.33872017e-01f, 2.15545848e-01f, 1.71517525e-02f, -4.68351580e-02f, 5.74901581e-01f, 2.36809045e-01f,
  5.50625175e-02f, -7.96805084e-01f, -6.77184701e-01f, -1.66245610e-01f, 1.47248596e-01f, 4.46626991e-01f, 3.25553656e-01f, 1.06980050e+00f, -4.41075891e-01f, -6.72444761e-01f,
  -8.83776367e-01f, -3.81349444e-01f, -6.16967380e-01f, -2.96162385e-02f, -3.09844047e-01f, -2.95425355e-01f, 9.07588601e-01f, -9.06356752e-01f, -2.11122259e-01f, -9.81017590e-01f,
  5.36809087e-01f, -1.84740871e-01f, -5.16348660e-01f, 3.47895563e-01f, -8.96084383e-02f, -4.44297403e-01f, -2.45698750e-01f, -2.22073004e-01f, -2.38281757e-01f, -4.98798490e-01f,
  2.17368677e-01f, -4.94029313e-01f, -5.12471616e-01f, -3.99468213e-01f, 4.55980510e-01f, 3.74425292e-01f, 4.96032953e-01f, 5.82758546e-01f, -4.60114300e-01f, -2.47918516e-01f,
  -4.88876224e-01f, -6.82156563e-01f, -5.05976938e-03f, -3.29971492e-01f, 9.71447378e-02f, 3.98586661e-01f, -6.98149681e-01f, 8.15729618e-01f, -5.37309945e-01f, -8.71744379e-02f,
  -9.20208514e-01f, 3.78653914e-01f, 1.80983976e-01f, -1.28108747e-02f, -4.60622013e-01f, -5.34843087e-01f, -6.49389565e-01f, -7.98905045e-02f, -1.61947906e-01f, 5.32520041e-02f,
  -3.57543319e-01f, -1.89866483e-01f, 4.87231553e-01f, -3.52659941e-01f, 2.62356430e-01f, 2.26541026e-03f, -3.19560736e-01f, -3.10475141e-01f, -6.46445096e-01f, -4.85802889e-01f,
  -2.44934067e-01f, 2.51417700e-02f, -6.03713751e-01f, 8.44193697e-02f, 6.48105621e-01f, -2.53659308e-01f, 1.28910795e-01f, 1.02319694e+00f, 1.58035502e-01f, -5.98545253e-01f,
  -6.71315491e-01f, -6.45063102e-01f, -1.70723811e-01f, -4.72690046e-01f, -2.02864572e-01f, 5.60737669e-01f, 2.60868788e-01f, -1.09914280e-01f, 2.86311746e-01f, 2.28864923e-01f,
  9.80557799e-02f, 1.39689058e-01f, 1.39193550e-01f, -2.23875925e-01f, -1.18518867e-01f, 1.02107532e-01f, 5.46357967e-02f, 7.51347482e-01f, 6.07662618e-01f, -2.79454023e-01f,
  9.48033988e-01f, 5.99458277e-01f, 5.59584141e-01f, -5.90320170e-01f, -3.35431725e-01f, 5.48286378e-01f, -7.86214769e-01f, -2.88063854e-01f, 4.69750911e-01f, 5.45939133e-02f,
  -1.16835928e+00f, -6.53811455e-01f, -1.12745784e-01f, -9.75461453e-02f, -1.02917755e+00f, -3.08818668e-01f, -9.52869475e-01f, -7.03958988e-01f, -2.15103522e-01f, 5.85947752e-01f,
  1.12601779e-01f, 2.06979185e-01f, 2.49317616e-01f, -1.16538137e-01f, 2.61522561e-01f, 1.15470186e-01f, -4.23332959e-01f, -6.20251954e-01f, -5.31016350e-01f, 6.37596965e-01f,
  -2.61382341e-01f, 5.32973647e-01f, -5.76898217e-01f, -4.90363091e-01f, 1.00465095e+00f, -5.93545079e-01f, 6.99781597e-01f, -5.07677913e-01f, -7.54361413e-03f, -4.90663052e-01f,
  -7.26298273e-01f, -5.32356679e-01f, -5.05067289e-01f, 1.15286909e-01f, -7.43618608e-01f, -6.24702632e-01f, 4.90352005e-01f, -8.38303983e-01f, -3.76811773e-01f, 3.50091845e-01f,
  6.12296522e-01f, -6.18285000e-01f, 1.66188553e-01f, 6.55064359e-02f, -2.23325983e-01f, 3.11385337e-02f, -3.55729386e-02f, -6.00649640e-02f, 3.85086596e-01f, 3.54342997e-01f,
  6.21221960e-01f, -2.84056187e-01f, 4.96994644e-01f, -4.12041247e-01f, -2.22039178e-01f, 7.95441329e-01f, -5.34122705e-01f, -7.83555269e-01f, -6.99069321e-01f, -6.15181923e-01f,
  2.88478315e-01f, -5.04455924e-01f, -5.83999753e-01f, -9.74770308e-01f, 7.62316361e-02f, -9.14556682e-01f, 4.42363441e-01f, -3.02660435e-01f, 2.72225570e-02f, 2.22815305e-01f,
  5.11919320e-01f, 8.65221024e-01f, 5.59793711e-01f, -8.85726988e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.42289558e-02f, -2.20458463e-01f, -3.56307775e-01f, -4.20600250e-02f, 2.00141057e-01f, 3.03888083e-01f, -9.46450010e-02f, -2.50950586e-02f, -2.27585092e-01f, -2.86627747e-02f,
  2.10972190e-01f, -8.48882250e-04f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    