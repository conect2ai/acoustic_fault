/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.98895514e-01f, 1.77051634e-01f, 7.37483740e-01f, -1.12998046e-01f, 5.19580618e-02f, 9.09522772e-02f, 3.81646365e-01f, -5.81815876e-02f, -1.88881695e-01f, 1.16004415e-01f,
  -7.51683414e-02f, -3.70406121e-01f, -1.18846364e-01f, -1.59965768e-01f, 7.45967403e-02f, 3.11968446e-01f, 4.01279122e-01f, 2.75513291e-01f, -7.52839893e-02f, -1.03849173e-01f,
  -1.91527098e-01f, -3.56716216e-02f, -1.96522847e-01f, 2.79859900e-02f, -6.20265156e-02f, -1.98696271e-01f, 2.17510536e-01f, 3.75459045e-02f, 5.68601079e-02f, 4.45662498e-01f,
  2.35066995e-01f, 2.59889990e-01f, 5.67311198e-02f, -7.20105171e-02f, 3.02463751e-02f, 1.25548840e-02f, 2.47275047e-02f, 5.21921366e-03f, -3.10410019e-02f, 5.22615388e-04f,
  -2.01965570e-02f, -4.62473482e-02f, 1.03412196e-02f, 1.28479987e-01f, 4.13846709e-02f, 4.75536250e-02f, 4.64724712e-02f, 1.42882884e-01f, 1.41964689e-01f, 1.01989381e-01f,
  1.01313703e-01f, 1.65641814e-01f, 8.37061405e-02f, 6.46606982e-02f, -2.41380390e-02f, 1.12506010e-01f, 6.20741993e-02f, 7.87886679e-02f, 9.03173983e-02f, 2.41318345e-02f,
  3.87721360e-02f, 5.05562080e-03f, 4.38928604e-02f, -1.45943062e-02f, -3.89854796e-02f, 3.31264473e-02f, 4.39485721e-02f, -1.08756915e-01f, -4.94478941e-02f, -2.52191499e-02f,
  5.77982441e-02f, 1.17584780e-01f, -1.20248096e-02f, 5.34245968e-02f, -2.49316692e-02f, 7.33086932e-03f, 3.06023080e-02f, -3.08470428e-02f, 3.00966296e-02f, -1.05029484e-02f,
  -8.81543830e-02f, 4.71458212e-02f, -2.80557722e-02f, -3.63602899e-02f, 7.62417121e-03f, 7.09821805e-02f, 1.70358941e-02f, -5.03671765e-02f, -1.01454675e-01f, 4.91010360e-02f,
  -3.29741567e-01f, 1.55937165e-01f, -1.43439798e-02f, -1.02284312e-01f, 9.75036025e-02f, -2.34375428e-02f, 8.75690859e-03f, 1.12793986e-02f, -2.49883104e-02f, 5.37759997e-03f,
  2.10610703e-02f, -1.06060915e-02f, 2.11264007e-02f, -4.08292003e-02f, 3.60400677e-02f, 1.02104973e-02f, -9.06577632e-02f, 3.09530180e-02f, -1.04403906e-01f, 2.53244676e-02f,
  -8.24284405e-02f, -7.53919408e-02f, -1.21403344e-01f, -4.07076962e-02f, -5.60319163e-02f, -9.69510451e-02f, -4.19116877e-02f, 1.71794929e-02f, 3.97881158e-02f, -4.58329357e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.99020243e-01f, -4.16473210e-01f, 1.28267288e-01f, 4.34356123e-01f, 5.12858510e-01f, 3.28056902e-01f, 4.08634722e-01f, 2.71618694e-01f, 2.19457746e-01f, -8.88446495e-02f,
  -4.71583813e-01f, -1.64946884e-01f, -8.62805024e-02f, -1.28045112e-01f, -2.57508695e-01f, 3.81665140e-01f, 4.59669769e-01f, -5.31691015e-02f, 1.87774420e-01f, 9.94748548e-02f,
  2.19823956e-01f, -3.27159613e-02f, -5.34585178e-01f, -1.12156868e-01f, 1.51873738e-01f, 2.63666153e-01f, -3.00656352e-02f, -2.77721614e-01f, -1.94761664e-01f, 1.76191837e-01f,
  -3.93552125e-01f, -5.07385790e-01f, 2.32564002e-01f, -1.32573023e-01f, -1.92582816e-01f, -1.52522624e-01f, 3.62174697e-02f, -8.83541852e-02f, 7.44945044e-03f, 4.00860533e-02f,
  2.46805325e-03f, -4.05035876e-02f, 1.39268860e-01f, 5.00252247e-02f, -4.72239312e-03f, -7.09433332e-02f, -1.30393311e-01f, -1.89888537e-01f, -6.66875988e-02f, -1.39278889e-01f,
  -5.50521351e-02f, -4.12851311e-02f, -2.69125793e-02f, 1.32748231e-01f, -1.19053170e-01f, 3.37903760e-02f, -1.39930964e-01f, -1.29952848e-01f, 6.69509824e-03f, -1.60548128e-02f,
  -1.08712740e-01f, -8.10031742e-02f, -6.32036328e-02f, 3.44909914e-02f, -5.11123519e-03f, 1.02339596e-01f, 1.33534268e-01f, -3.57874595e-02f, 2.74498537e-02f, -1.91579871e-02f,
  1.16402477e-01f, -1.06264977e-02f, -9.56221204e-03f, -2.98569128e-02f, 3.83440852e-02f, 1.02228979e-02f, 7.19098002e-02f, -1.41050983e-02f, -1.48557901e-01f, 3.87252745e-04f,
  4.63846289e-02f, 1.47092417e-01f, 3.20780091e-02f, 3.28299776e-02f, 1.10785454e-03f, -4.74819727e-02f, 9.59707648e-02f, -1.03216127e-01f, 2.54914276e-02f, -1.97673161e-02f,
  7.15832040e-02f, -5.21496125e-02f, 1.58234969e-01f, 5.74204810e-02f, -6.56409115e-02f, -2.34985009e-01f, 4.86666225e-02f, 5.17845564e-02f, -2.60479786e-02f, 4.54004556e-02f,
  -4.13681492e-02f, -1.45931274e-01f, 1.59692038e-02f, -3.39377522e-02f, 1.13123551e-01f, -1.53302019e-02f, -2.46176869e-01f, 1.37279378e-02f, -2.16387790e-02f, -1.06155034e-02f,
  -4.37387638e-02f, -2.58459933e-02f, 5.96494451e-02f, 1.97958574e-01f, 4.83147800e-02f, 1.61148205e-01f, 1.98051751e-01f, 5.07974066e-02f, 1.04137242e-01f, 1.80211112e-01f,
  2.47235641e-01f, -6.30853891e-01f, -9.59301367e-02f, -2.33076781e-01f, -4.81361657e-01f, -3.42190444e-01f, -3.92630786e-01f, -1.28841355e-01f, -1.13133430e-01f, -2.80307770e-01f,
  9.23826545e-02f, 5.07037818e-01f, 1.52136654e-01f, 8.02488774e-02f, -1.25085935e-01f, -3.42456043e-01f, -6.69600546e-01f, -4.03812043e-02f, 4.62924331e-01f, 2.53576070e-01f,
  -1.12921201e-01f, -2.11413994e-01f, 7.84384012e-02f, -1.19118281e-01f, -3.44941378e-01f, 1.39427841e-01f, -3.27530593e-01f, -2.35101417e-01f, -1.23588599e-01f, -4.61986661e-01f,
  1.56443864e-01f, -1.70538425e-01f, 2.25477871e-02f, -1.75668612e-01f, -2.16419116e-01f, -8.20538327e-02f, 1.04826033e-01f, -7.58312196e-02f, -6.78099170e-02f, -1.35053620e-01f,
  2.09682826e-02f, -1.88682601e-02f, -3.39039676e-02f, 6.25016689e-02f, 4.41490710e-02f, 8.52198228e-02f, -3.41261476e-02f, -8.60141292e-02f, -8.73691589e-02f, -5.77070862e-02f,
  -4.68322448e-02f, 2.34236699e-02f, 9.01493877e-02f, -8.62896889e-02f, 1.59243625e-02f, -1.29998267e-01f, -2.82997459e-01f, -6.90456852e-02f, -9.03131589e-02f, 1.36254653e-02f,
  -5.73245846e-02f, -1.88262723e-02f, 8.86265785e-02f, -6.83837757e-02f, 1.18906371e-01f, 2.36521512e-02f, 2.16989387e-02f, -9.29004773e-02f, 1.65058434e-01f, 4.80824746e-02f,
  2.52821725e-02f, -8.73492584e-02f, 7.75477216e-02f, -1.20219849e-02f, -6.92563131e-02f, 6.45131767e-02f, 2.62199212e-02f, -2.30029840e-02f, -3.61801423e-02f, 3.22066694e-02f,
  -3.38828638e-02f, -1.63803957e-02f, 4.22994383e-02f, -6.29678443e-02f, -1.47655889e-01f, -4.86632735e-02f, 3.74400951e-02f, 4.11057845e-02f, 9.66295749e-02f, 2.34448761e-02f,
  4.05448616e-01f, -3.17731798e-01f, 2.01352667e-02f, 1.10850401e-01f, 4.25646640e-02f, -1.25213698e-01f, -1.00664504e-01f, -8.11797380e-02f, -1.12496935e-01f, 7.25409598e-04f,
  -5.48610324e-03f, 3.86204123e-02f, -9.89359897e-03f, -1.77391886e-03f, 1.28748432e-01f, 1.50630847e-01f, -3.29156518e-02f, 8.70366693e-02f, -6.10198490e-02f, 7.16716424e-02f,
  -6.27929419e-02f, 8.58280435e-02f, 2.76756912e-01f, 5.77349924e-02f, 1.03428587e-01f, 1.54779002e-01f, 6.41304478e-02f, 8.57692435e-02f, 2.49175683e-01f, 1.06174707e-01f,
  -3.05064142e-01f, -1.64470345e-01f, 1.24649987e-01f, 5.34136407e-02f, 1.99880376e-02f, 4.72197644e-02f, 1.71364114e-01f, 2.52120793e-02f, -6.83052242e-02f, 1.85838386e-01f,
  2.53898531e-01f, 3.08195233e-01f, 3.08419347e-01f, 3.06879491e-01f, 1.00409314e-01f, 2.45815665e-01f, 6.18821904e-02f, -2.13470757e-02f, 1.62611514e-01f, 2.55373836e-01f,
  1.87165022e-01f, -1.54844984e-01f, -2.88828611e-01f, 6.72718091e-03f, 9.73966420e-02f, 4.66632187e-01f, 4.24034335e-02f, -3.64473835e-02f, 8.87128040e-02f, 6.40740171e-02f,
  7.88444877e-01f, -2.12323502e-01f, 2.87644327e-01f, -4.41490300e-02f, -7.21509010e-02f, -2.39177451e-01f, 1.22304223e-01f, -1.06616765e-01f, -1.71930149e-01f, 8.45378935e-02f,
  -7.99382627e-02f, -7.34679177e-02f, -7.88075849e-02f, -7.13408813e-02f, -1.70991555e-01f, -1.14868000e-01f, -2.66686112e-01f, -2.62824877e-04f, 1.94719613e-01f, 5.93331680e-02f,
  4.80165891e-02f, -5.84011972e-02f, 1.21407613e-01f, 1.26771316e-01f, 1.05829071e-02f, -8.25827569e-03f, 1.78014413e-02f, 6.17101006e-02f, 1.55127063e-01f, 1.35211930e-01f,
  3.08896452e-01f, 9.40135717e-02f, 4.88633066e-02f, 1.73153609e-01f, 4.66917343e-02f, 1.26316957e-02f, -1.07990727e-01f, 3.89272347e-02f, 5.59580587e-02f, -1.68067083e-01f,
  -5.96251264e-02f, 1.35701910e-01f, 1.22039139e-01f, 6.95713907e-02f, 6.30068183e-02f, -1.31069124e-01f, -8.09894577e-02f, 2.80314069e-02f, 3.16208377e-02f, 4.89827432e-02f,
  5.50212935e-02f, -3.98445092e-02f, -1.02774635e-01f, -4.39350232e-02f, 4.56930250e-02f, 1.27518207e-01f, -3.13732773e-02f, 1.20230522e-02f, -3.90320197e-02f, -1.45182490e-01f,
  9.14351791e-02f, 1.13764174e-01f, 1.96425378e-01f, -4.15296145e-02f, -1.06272861e-01f, -2.48415634e-01f, 1.80535153e-01f, -4.71114740e-02f, -3.28122675e-01f, 4.90616970e-02f,
  -1.37552004e-02f, -8.21746439e-02f, -1.52966142e-01f, -1.85353041e-01f, -1.95032462e-01f, -1.77873537e-01f, -1.06237948e-01f, 9.36011299e-02f, 3.08650155e-02f, -1.41848624e-01f,
  -1.66824132e-01f, 3.65028232e-02f, 2.06717700e-01f, 4.14824709e-02f, 2.90411115e-02f, 1.53288633e-01f, -2.68825702e-02f, 7.47341022e-04f, -6.46670759e-02f, -3.78810205e-02f,
  1.05129409e+00f, 3.24848890e-01f, 1.69278905e-01f, 3.06856602e-01f, 2.56818980e-01f, 1.48109458e-02f, 7.92334601e-02f, -2.31302381e-02f, -1.46726489e-01f, 2.66588748e-01f,
  3.42364699e-01f, 1.52289137e-01f, -1.55717626e-01f, -8.99575129e-02f, -1.39814720e-01f, -1.72148332e-01f, -2.11342216e-01f, -8.54045749e-02f, -2.10545674e-01f, 1.19202688e-01f,
  5.84641732e-02f, 2.03322589e-01f, 4.43689585e-01f, -7.51718879e-02f, 2.16960490e-01f, 1.38019212e-02f, 5.46793155e-02f, 4.55172569e-01f, 2.61526763e-01f, 3.37443113e-01f,
  5.05060792e-01f, 4.46781456e-01f, -2.50912517e-01f, -8.75011757e-02f, 1.27400175e-01f, -1.80831701e-01f, -8.34919289e-02f, -1.39950618e-01f, -9.47595462e-02f, -2.18127578e-01f,
  7.16315806e-02f, 6.75597936e-02f, 1.66130252e-02f, -8.61075073e-02f, 3.19664404e-02f, -9.27749947e-02f, -1.09311052e-01f, -7.20723718e-02f, -1.84022218e-01f, -9.51022878e-02f,
  -9.00569260e-02f, 1.52387291e-01f, 7.77375847e-02f, -1.59758464e-01f, -1.67334124e-01f, -7.12147728e-02f, 9.92418453e-02f, 9.84461308e-02f, 3.53620127e-02f, 1.26340806e-01f,
  -5.33947609e-02f, 7.79972300e-02f, 1.90493748e-01f, 8.56701434e-02f, 2.28369355e-01f, -1.21321101e-02f, 1.64444055e-02f, -9.44685265e-02f, 7.40554705e-02f, 1.00216560e-01f,
  -1.25005201e-01f, -2.59856060e-02f, -8.45385045e-02f, -7.73754045e-02f, 7.25499541e-02f, 1.44897280e-02f, -4.81130220e-02f, -4.39756773e-02f, -2.31630355e-02f, -1.70154832e-02f,
  9.10417065e-02f, -7.95808583e-02f, -9.15304348e-02f, 5.01834974e-02f, -1.42801389e-01f, 2.47322842e-02f, 1.30848587e-01f, -3.42640169e-02f, 6.04133867e-02f, 9.33729187e-02f,
  -3.08037281e-01f, -1.92418844e-01f, 1.95128605e-01f, -9.21696275e-02f, -4.83724428e-03f, -6.17552586e-02f, 4.61051986e-02f, -1.15006573e-01f, -5.08840643e-02f, -1.43564075e-01f,
  7.18681216e-02f, -3.54642905e-02f, -2.70203277e-02f, 3.42866890e-02f, 2.44240444e-02f, -1.28621846e-01f, -3.28613445e-02f, -1.35670394e-01f, -1.30076706e-01f, -7.60478079e-02f,
  -1.07466370e-01f, -1.69202536e-01f, -1.61649078e-01f, -2.74142832e-01f, -1.77988634e-01f, -2.21976638e-01f, -1.52941197e-01f, -1.39944941e-01f, -1.91336364e-01f, -1.67024493e-01f,
  -2.86019832e-01f, -3.45849127e-01f, 1.70538239e-02f, 4.12630171e-01f, 4.49138358e-02f, -4.86597866e-01f, -6.98189855e-01f, -4.85011131e-01f, 1.99112207e-01f, 9.50591937e-02f,
  5.82194189e-03f, 2.88593084e-01f, 2.94762194e-01f, 2.01222733e-01f, -2.45766997e-01f, 2.91843917e-02f, 3.66060466e-01f, 1.89456388e-01f, -1.07988514e-01f, -2.55335957e-01f,
  4.40068454e-01f, 1.26323327e-01f, -5.81354387e-02f, -1.30145252e-01f, 2.36544877e-01f, 9.60175246e-02f, 1.69395134e-02f, 8.16286430e-02f, 5.33802062e-02f, 8.80405784e-01f,
  5.21694303e-01f, -2.35124752e-01f, 1.34047881e-01f, 2.24219766e-02f, 1.65800638e-02f, -5.73350973e-02f, -7.69088492e-02f, -5.32426778e-03f, -6.59964755e-02f, 5.96181601e-02f,
  1.30084559e-01f, -3.58589962e-02f, -2.32903622e-02f, 3.83727774e-02f, -8.90823454e-02f, -1.19932525e-01f, -4.17613015e-02f, 6.15009181e-02f, -5.12914471e-02f, -1.18750140e-01f,
  2.77005881e-01f, 7.59970173e-02f, -1.58491641e-01f, -1.58228382e-01f, -2.62971312e-01f, 2.30786264e-01f, -3.34824741e-01f, -1.59578174e-01f, -3.50313753e-01f, -3.07338256e-02f,
  1.44973889e-01f, 2.95700729e-02f, 1.71672497e-02f, 4.62475680e-02f, -8.94131511e-02f, 7.59127438e-02f, 8.83237645e-02f, 2.10851263e-02f, 1.09636180e-01f, -2.83094756e-02f,
  -1.11343667e-01f, 1.27312746e-02f, 1.29150983e-03f, -1.57584488e-01f, 1.38795152e-01f, 1.17822699e-01f, 3.37958783e-02f, 4.84159067e-02f, 2.03626096e-01f, 6.25928445e-03f,
  4.35750000e-03f, 1.66345891e-02f, -4.00497206e-03f, 9.98979956e-02f, 2.43502930e-02f, 1.33644670e-01f, 1.40893087e-01f, -8.51098597e-02f, -3.98692824e-02f, -8.57236981e-03f,
  -8.45399871e-02f, -1.41983584e-01f, 3.40449363e-01f, 1.23799957e-01f, 1.80729568e-01f, 9.22796130e-03f, 1.29927263e-01f, 6.90483376e-02f, 1.36964247e-01f, 7.04355612e-02f,
  -1.08149402e-01f, -1.44244179e-01f, 1.78377163e-02f, -6.21943846e-02f, -1.35072455e-01f, 6.62796125e-02f, 1.58220112e-01f, 9.17616114e-02f, 5.66753894e-02f, -1.63503923e-03f,
  9.88752022e-03f, -2.31001318e-01f, -2.26613209e-01f, -3.21423113e-02f, -5.74010098e-03f, -4.92877066e-02f, -2.49190375e-01f, -9.82184187e-02f, -3.39543462e-01f, -4.29085791e-01f,
  1.35591999e-01f, 4.52229045e-02f, 9.78896394e-02f, 2.20658571e-01f, -9.82883871e-02f, -5.61788082e-01f, -8.29149723e-01f, -3.64650667e-01f, 1.78669006e-01f, 8.77515152e-02f,
  -1.64659396e-01f, 3.93113755e-02f, 1.59973174e-01f, -6.72769994e-02f, -4.16038454e-01f, -3.11371952e-01f, 7.75133967e-02f, -1.53360544e-02f, -3.66868198e-01f, -4.69250560e-01f,
  1.89771038e-02f, 1.77062929e-01f, 5.99078611e-02f, -9.55132209e-03f, 3.38945121e-01f, 1.24419823e-01f, 3.45382094e-01f, 1.76029220e-01f, -2.38664940e-01f, 5.75401843e-01f,
  9.17777494e-02f, 1.82023659e-01f, -2.57924348e-01f, 1.52008042e-01f, 1.36139929e-01f, 5.24193384e-02f, -1.62644520e-01f, 3.01255912e-01f, 1.09163888e-01f, 9.58256982e-03f,
  1.09217912e-01f, 1.49868215e-02f, 1.43555343e-01f, 6.26613870e-02f, 1.02408295e-02f, 3.44547927e-02f, 1.04848288e-01f, -3.26554142e-02f, 1.03861704e-01f, 5.94845675e-02f,
  1.31096795e-01f, 8.19177702e-02f, -6.04973249e-02f, -3.06895114e-02f, 5.31254411e-02f, 3.05311143e-01f, -1.33169755e-01f, -7.67222140e-03f, -1.50268108e-01f, -6.66440045e-03f,
  8.21851473e-03f, -6.00799061e-02f, 2.98102759e-02f, -5.40781394e-02f, -4.54746597e-02f, 1.50870860e-01f, 1.46912277e-01f, -1.45559207e-01f, -3.14345807e-02f, 2.59826127e-02f,
  7.71408603e-02f, 7.25898817e-02f, 1.01596199e-01f, 8.77656974e-03f, 2.20654234e-02f, -3.70447002e-02f, -2.27998048e-02f, -1.30301416e-01f, -8.96683037e-02f, 8.39719996e-02f,
  -6.41308650e-02f, 5.18642366e-02f, 1.78565338e-01f, -1.23214580e-01f, 1.82559099e-02f, -4.78784889e-02f, 8.88535082e-02f, 5.80954365e-02f, 6.66005164e-02f, 6.88143596e-02f,
  -2.08599836e-01f, -1.48397788e-01f, 5.89180849e-02f, -8.71182755e-02f, -1.62022263e-02f, 9.51533765e-02f, 8.21933225e-02f, -1.21325463e-01f, 1.69635877e-01f, -4.48106304e-02f,
  -1.38209179e-01f, 4.12569717e-02f, 1.90562513e-02f, -2.95116186e-01f, -1.87193945e-01f, -2.50553992e-02f, -1.34219840e-01f, -1.16342664e-01f, -1.77314609e-01f, 7.52400607e-03f,
  -1.52988762e-01f, -4.36005682e-01f, -4.55363631e-01f, -1.91711396e-01f, -3.48627828e-02f, -3.28927666e-01f, -1.79674134e-01f, -2.25238204e-01f, -4.48177874e-01f, -4.73651588e-01f,
  -3.36408973e-01f, 3.39027703e-01f, -2.71722883e-01f, -2.89296448e-01f, -4.16922718e-01f, -4.36916679e-01f, -5.77619433e-01f, -1.37784004e-01f, -1.90594763e-01f, -3.37280333e-01f,
  1.28319651e-01f, 4.51018333e-01f, 2.49425858e-01f, 8.15569237e-02f, -1.80960491e-01f, -7.55259871e-01f, -9.26164567e-01f, -6.54428601e-01f, -2.81056762e-01f, -4.54860747e-01f,
  -5.63531995e-01f, -4.64345157e-01f, -1.63138852e-01f, -1.44361988e-01f, 1.27585158e-01f, 2.55031139e-01f, -5.23173474e-02f, -1.31650969e-01f, -6.45500515e-03f, -2.14923546e-01f,
  2.19186336e-01f, -1.77972943e-01f, -8.22143555e-02f, -1.86922923e-01f, -8.26912699e-04f, 6.59618974e-02f, -2.87320279e-03f, -2.76616495e-03f, -1.25579625e-01f, -2.28519309e-02f,
  -1.11088596e-01f, -1.01525389e-01f, 8.41952115e-02f, 5.88571280e-03f, -2.11897623e-02f, -2.03922138e-01f, -1.26622364e-01f, -8.06929693e-02f, 6.17478155e-02f, 7.25705456e-03f,
  -1.30672827e-01f, -2.92414159e-01f, -1.10337891e-01f, 9.38818529e-02f, 1.07946120e-01f, -6.96031526e-02f, 2.43921936e-01f, 1.50614664e-01f, 2.63590813e-02f, 2.53269434e-01f,
  5.88721875e-03f, 1.38648808e-01f, 1.29860418e-03f, 6.46840110e-02f, -5.00975586e-02f, -4.43106703e-02f, 8.37158877e-03f, -6.23603500e-02f, -8.02315995e-02f, -5.69085241e-04f,
  -7.44755659e-03f, -5.20686023e-02f, 1.91753712e-02f, -4.44378750e-03f, -1.18777312e-01f, -1.29532546e-03f, -7.04340413e-02f, 8.36857930e-02f, 2.71480829e-02f, -4.08376567e-02f,
  -1.08138174e-01f, -5.41488566e-02f, 2.74781734e-02f, 5.91114834e-02f, -1.42718568e-01f, -9.67474505e-02f, 4.03778628e-02f, 4.91455346e-02f, 3.76798436e-02f, -7.38790771e-03f,
  2.90019810e-01f, -2.46564209e-01f, 9.63191092e-02f, 1.17817439e-01f, -2.86382437e-02f, 1.00687981e-01f, 2.58579552e-01f, 2.16754042e-02f, 3.47126648e-02f, 3.00943069e-02f,
  -2.37225760e-02f, 8.77557695e-02f, 4.69530523e-02f, 9.42863896e-03f, -3.54242735e-02f, -1.40708506e-01f, -3.11517753e-02f, -7.77107254e-02f, 2.84920298e-02f, 1.39274478e-01f,
  5.02904644e-03f, -2.84805417e-01f, -8.84428248e-03f, 6.31258935e-02f, 1.00538008e-01f, -3.36219929e-02f, 2.77330399e-01f, 1.77228123e-01f, 1.76087357e-02f, 1.26253903e-01f,
  -7.46290624e-01f, -3.42495114e-01f, -1.93800405e-01f, -3.79508018e-01f, 9.90241766e-02f, 4.00250286e-01f, 1.40903592e-01f, 2.07438067e-01f, 7.16694519e-02f, -1.91817820e-01f,
  4.17025425e-02f, -2.13254690e-01f, -4.99200255e-01f, -1.66564152e-01f, -9.77730379e-02f, -4.05058451e-02f, -2.08986580e-01f, -2.42635936e-01f, 4.51321565e-02f, 5.72061479e-01f,
  1.08858295e-01f, -3.51872265e-01f, -1.82990372e-01f, 1.05898030e-01f, -1.33933157e-01f, -1.15470253e-01f, -4.57426846e-01f, -1.89937994e-01f, 2.94525057e-01f, -3.61789048e-01f,
  -2.36795485e-01f, -2.57692307e-01f, 2.22548708e-01f, -7.36087784e-02f, -6.05266504e-02f, 1.57572672e-01f, 1.75353914e-01f, -2.70678133e-01f, 6.48221299e-02f, 3.92514691e-02f,
  -2.10554406e-01f, 5.79547249e-02f, 4.51771729e-02f, 1.61056951e-01f, -3.84113751e-02f, 2.39452407e-01f, -1.29067048e-01f, -1.44500472e-02f, -1.42167881e-01f, 2.34443709e-01f,
  1.50941417e-01f, 2.10805967e-01f, -1.25111729e-01f, 2.31288314e-01f, 8.13691616e-02f, -6.97889775e-02f, 7.38040283e-02f, 3.49294901e-01f, -3.00379060e-02f, -1.39275149e-01f,
  1.26943588e-01f, -1.30613431e-01f, -2.73907017e-02f, 9.21191648e-02f, 5.45173548e-02f, -5.13834059e-02f, -3.95143554e-02f, -6.45416379e-02f, 4.84722741e-02f, -7.25554153e-02f,
  7.46578947e-02f, 1.34155244e-01f, 5.39580546e-02f, 2.91146114e-02f, 6.80365413e-02f, -5.64951263e-02f, 1.45547315e-02f, -8.37385058e-02f, 5.69720939e-02f, -2.60527749e-02f,
  -3.23545337e-02f, 1.30718470e-01f, -7.01215714e-02f, 1.47017017e-01f, 1.06751792e-01f, -4.65252101e-02f, -5.87911718e-02f, 1.19600005e-01f, -1.51358157e-01f, -6.02169409e-02f,
  -3.16883534e-01f, 9.32844542e-03f, -2.51137257e-01f, -9.31053758e-02f, -5.50520867e-02f, 1.27932616e-02f, -2.10098132e-01f, 1.11530490e-01f, -7.66381249e-02f, 4.80032563e-02f,
  7.44900554e-02f, -1.23026840e-01f, -1.62369579e-01f, 3.67895626e-02f, 6.31592944e-02f, -1.74619327e-03f, -2.79198401e-02f, -8.10291246e-02f, 1.00800537e-01f, 1.41662464e-01f,
  -3.24655906e-03f, -2.65148971e-02f, -2.23515123e-01f, -1.80281997e-01f, 5.11221997e-02f, -2.81849563e-01f, -3.21630478e-01f, -1.53790221e-01f, -2.44414389e-01f, -5.61114311e-01f,
  7.54337966e-01f, -7.25681603e-01f, -3.80603909e-01f, 1.28409475e-01f, 1.36490241e-01f, 5.28850406e-02f, 1.72812656e-01f, -9.19669792e-02f, 6.04780903e-03f, -1.17172077e-01f,
  -2.81704754e-01f, -1.19622931e-01f, -9.99543350e-03f, -4.84155342e-02f, -2.47051590e-03f, 7.26762712e-02f, 1.61098372e-02f, 8.10874104e-02f, 3.87018234e-01f, 1.33722395e-01f,
  -6.41123652e-02f, 7.20216334e-02f, -5.16012078e-03f, 2.70678904e-02f, -2.82186806e-01f, 6.88782781e-02f, -2.21146166e-01f, -2.70151258e-01f, -2.76335448e-01f, -3.89009118e-01f,
  -5.94712123e-02f, -1.98551118e-01f, 1.82989597e-01f, -2.42364351e-02f, -1.74346656e-01f, 8.70871544e-02f, 1.28790870e-01f, -1.55485034e-01f, 3.65830436e-02f, -7.50238895e-02f,
  -8.78907219e-02f, 4.12456803e-02f, -2.00217992e-01f, -1.09554723e-01f, -1.58728175e-02f, -9.76764932e-02f, -2.03183204e-01f, -1.89694911e-01f, -1.69166043e-01f, -2.55825102e-01f,
  -3.76391500e-01f, -2.30084226e-01f, 1.81797463e-02f, -1.96767598e-01f, -3.52804095e-01f, -2.85762511e-02f, -4.06469911e-01f, -2.45413780e-01f, -3.07919025e-01f, -2.31939256e-02f,
  8.78206491e-02f, -1.69194769e-02f, -6.92269066e-03f, -6.24792650e-02f, 1.88918769e-01f, 1.04110755e-01f, -4.62737260e-03f, -6.17558660e-04f, -3.59010585e-02f, 1.22924887e-01f,
  7.05288723e-02f, 2.17581019e-02f, -7.47450516e-02f, 1.19029647e-02f, -1.14353739e-01f, -1.17461555e-01f, 1.78022217e-02f, -1.22123629e-01f, -8.36563855e-02f, -1.70739926e-02f,
  -1.07891694e-01f, 1.27913266e-01f, -5.23800962e-04f, -5.48539450e-03f, -2.30226323e-01f, -8.17763507e-02f, 6.07106127e-02f, -1.23258926e-01f, 9.09402966e-02f, 6.33463040e-02f,
  1.52233809e-01f, -9.08217281e-02f, 2.16883600e-01f, 6.71068951e-02f, 1.22344987e-02f, -4.56252061e-02f, -1.95093051e-01f, -6.50793612e-02f, -6.61337981e-03f, 6.49614558e-02f,
  -6.99865893e-02f, 3.28380167e-02f, -6.84428662e-02f, -1.17403351e-01f, 2.25979075e-01f, -5.17629422e-02f, 7.35370368e-02f, 1.47869334e-01f, -1.95346791e-02f, 5.34751005e-02f,
  -2.26565991e-02f, 2.84852266e-01f, 4.70348448e-01f, 4.16730613e-01f, 1.21355347e-01f, 3.93513232e-01f, 2.27469847e-01f, 9.94233787e-02f, 2.29810134e-01f, 6.92629993e-01f,
  6.80542588e-02f, -7.59644985e-01f, -1.93293124e-01f, -3.15876640e-02f, 3.10159521e-05f, -1.44015521e-01f, -5.12793064e-01f, 1.32436022e-01f, 2.99461693e-01f, -2.71715432e-01f,
  1.27484813e-01f, 3.66394848e-01f, 9.04335752e-02f, 2.56542593e-01f, 1.09378388e-02f, -4.43990111e-01f, -3.63351166e-01f, -3.91771644e-02f, 4.58411157e-01f, 4.66486841e-01f,
  6.87735379e-02f, 3.63205373e-02f, 1.69780135e-01f, 3.01677883e-01f, -1.84978709e-01f, 2.12048963e-02f, -2.57569641e-01f, -2.07111150e-01f, -1.22346088e-01f, -4.69922662e-01f,
  -2.29917869e-01f, -6.23560064e-02f, 3.54019582e-01f, 1.47574604e-01f, -1.20099097e-01f, -1.14572473e-01f, -1.26243576e-01f, -2.51669854e-01f, -3.66391428e-02f, 1.23809405e-01f,
  1.27447784e-01f, 1.12285256e-01f, -3.24315168e-02f, 6.81694672e-02f, 1.17683755e-02f, 1.00062571e-01f, 1.21808648e-01f, -4.00566608e-02f, -1.66215256e-01f, -1.81903556e-01f,
  -1.44886151e-01f, -1.67169005e-01f, -7.23982453e-02f, -1.50659502e-01f, 1.06958495e-02f, 8.71247947e-02f, -1.59500420e-01f, -1.73907772e-01f, -3.25300783e-01f, -4.39375371e-01f,
  3.08966800e-03f, -1.38405234e-01f, -1.23337060e-02f, 8.58066455e-02f, -6.76212534e-02f, -3.41888815e-02f, -6.22422621e-02f, -5.77390343e-02f, -1.24972649e-02f, 7.44786486e-02f,
  3.11111808e-02f, 1.31002972e-02f, 1.02174371e-01f, -1.49119720e-02f, 3.92884016e-02f, 2.76580136e-02f, -8.17284212e-02f, -6.61483854e-02f, 7.22040087e-02f, -2.40161773e-02f,
  -5.92536945e-03f, -1.00897597e-02f, -9.09302442e-04f, -2.54816785e-02f, 2.02657115e-02f, -3.88300158e-02f, -2.39662528e-02f, 1.29092097e-01f, -4.45936173e-02f, 1.19944431e-01f,
  -4.43324633e-03f, 1.43755317e-01f, -1.76854774e-01f, 1.76160425e-01f, 1.13897152e-01f, 1.83461625e-02f, -1.62562475e-01f, 1.85896158e-01f, -1.44767268e-02f, 6.86537102e-02f,
  -9.80641842e-02f, -9.82170328e-02f, -1.97187379e-01f, 1.91574976e-01f, 6.55120686e-02f, 6.47610985e-03f, 9.82207581e-02f, -1.91661060e-01f, -6.99828640e-02f, 1.08230822e-01f,
  -1.20821252e-01f, -6.31986856e-02f, -9.79360566e-02f, -7.42193311e-02f, 9.24646258e-02f, 2.85007572e-03f, -1.06099024e-01f, -1.19851209e-01f, -2.44476750e-01f, -4.29896802e-01f,
  -2.29503512e-01f, -6.08790480e-02f, 1.10118501e-01f, -1.67808637e-01f, 5.34617007e-01f, 2.95277923e-01f, -2.24254608e-01f, -4.03110564e-01f, -1.19382598e-01f, -3.90848555e-02f,
  4.93341029e-01f, 1.46261528e-01f, -2.22798601e-01f, -2.15766445e-01f, -8.00749838e-01f, -4.43400145e-01f, -5.35788774e-01f, -5.89125574e-01f, -3.27246100e-01f, 1.68526873e-01f,
  1.01548634e-01f, -3.22079420e-01f, -4.01923597e-01f, -2.59096444e-01f, 1.82821423e-01f, 1.21837251e-01f, 1.45408362e-01f, 2.32487604e-01f, 5.24287105e-01f, 1.81221977e-01f,
  3.77364784e-01f, 1.73355088e-01f, -1.46949328e-02f, 8.71196389e-04f, 3.46521437e-02f, -1.20747462e-01f, -8.80118012e-02f, -2.20408246e-01f, 7.06952587e-02f, -1.14059329e-01f,
  1.84604257e-01f, 1.86900526e-01f, 2.51369178e-02f, 2.88074780e-02f, -1.23181596e-01f, -3.08379352e-01f, -1.09260283e-01f, -5.27874351e-01f, -3.96975428e-01f, 2.01079957e-02f,
  2.05613896e-01f, 4.82471466e-01f, 2.96844952e-02f, -5.22923544e-02f, -1.03713140e-01f, 2.76957192e-02f, 1.71017721e-01f, 2.58453280e-01f, -1.62219241e-01f, 1.70584247e-02f,
  -1.22712210e-01f, 4.38157283e-03f, -5.98052256e-02f, -7.11798593e-02f, -8.04350078e-02f, 1.67077899e-01f, 4.75325659e-02f, -1.66467130e-02f, -1.01047851e-01f, -9.98035818e-02f,
  -3.85865942e-03f, 5.52262217e-02f, -2.37630568e-02f, -1.41626641e-01f, 5.08290753e-02f, 4.97583337e-02f, 1.14181645e-01f, -1.28281742e-01f, -6.10099807e-02f, -9.85982791e-02f,
  -8.34659636e-02f, 1.44780055e-01f, 5.62620386e-02f, -1.69013128e-01f, -2.37986930e-02f, 3.96532603e-02f, -1.88712794e-02f, 2.59751119e-02f, -4.56597991e-02f, -2.83046234e-02f,
  -2.21390784e-01f, 2.83180811e-02f, -1.24069005e-02f, -3.51299077e-01f, 6.38202531e-03f, 1.53161079e-01f, 2.44285241e-01f, 3.01522668e-02f, 2.27729321e-01f, -5.41477315e-02f,
  -5.38109876e-02f, -5.70424050e-02f, 4.61162180e-02f, -2.63279919e-02f, -4.95787375e-02f, -1.25553221e-01f, -2.21044987e-01f, -4.77076098e-02f, 9.54414345e-03f, 1.18434198e-01f,
  -2.48225704e-01f, -1.20301858e-01f, -2.24675596e-01f, -1.99457198e-01f, -8.05203915e-02f, -9.93217453e-02f, 1.07170139e-02f, 2.62393981e-01f, -3.33662212e-01f, -6.62136555e-01f,
  1.39698163e-01f, -3.62702049e-02f, 3.64528745e-01f, -1.14237823e-01f, -3.63944210e-02f, 4.61138040e-02f, 2.04957202e-01f, 3.78343416e-03f, 3.09125632e-02f, 3.66533667e-01f,
  -2.51416147e-01f, -2.06801653e-01f, -4.35118116e-02f, -3.75929952e-01f, -4.48959023e-01f, 1.92484096e-01f, 2.54731197e-02f, -5.70895746e-02f, -1.09248839e-01f, -3.15985233e-01f,
  -7.11584166e-02f, 1.27122924e-01f, -9.58586931e-02f, -1.97051972e-01f, 2.48784631e-01f, 1.30732208e-01f, 4.33045894e-01f, -5.14584184e-02f, -4.18029606e-01f, 9.17378888e-02f,
  5.77256858e-01f, -5.31518646e-02f, -3.44187737e-01f, -5.41241407e-01f, 9.17081311e-02f, -5.99667467e-02f, 1.01570725e-01f, 2.06917465e-01f, -5.08442298e-02f, 1.06264621e-01f,
  -1.05719402e-01f, -9.65193436e-02f, -1.76703662e-01f, 7.83478916e-02f, 1.59998164e-01f, 9.17663202e-02f, 5.16875573e-02f, -7.57343248e-02f, -8.60808194e-02f, 1.58295169e-01f,
  -1.60709381e-01f, -1.04604602e-01f, 3.11709680e-02f, -1.24380086e-02f, -5.66418953e-02f, -3.74224275e-01f, -8.64083022e-02f, -2.21994579e-01f, -2.77809978e-01f, 2.42402628e-01f,
  -9.62566808e-02f, -4.41460907e-02f, -1.69314183e-02f, -1.48586584e-02f, -1.37024879e-01f, -8.57831016e-02f, -2.31524780e-02f, -4.35933135e-02f, 4.78693955e-02f, 8.59849304e-02f,
  -3.97852026e-02f, -2.01023975e-03f, -4.70647262e-03f, 1.19863220e-01f, 2.14949504e-01f, 2.44440231e-02f, -6.43865094e-02f, 6.56484589e-02f, 5.62651679e-02f, -2.07860004e-02f,
  -6.86545819e-02f, -4.73874435e-02f, 1.38771668e-01f, 1.43511361e-02f, -5.57112470e-02f, -8.88719559e-02f, -1.21510709e-02f, 1.49163259e-02f, -6.16613775e-02f, 7.11993640e-03f,
  3.40883017e-01f, -6.62523508e-01f, 2.23198816e-01f, -5.90687878e-02f, 1.44891605e-01f, -1.20584585e-01f, 4.48691510e-02f, -2.58305073e-01f, -1.25682056e-01f, 7.95483738e-02f,
  -2.41337538e-01f, 2.12263204e-02f, 8.49479809e-02f, 1.27769485e-01f, 1.33347930e-02f, 1.32080168e-01f, -1.50863841e-01f, -3.44169550e-02f, -1.09968051e-01f, 1.91327676e-01f,
  1.51633769e-01f, 8.92857090e-02f, -3.71495634e-03f, 1.00068925e-02f, 1.15870729e-01f, -8.49872008e-02f, 1.49857804e-01f, 1.78439707e-01f, -1.31259754e-01f, 3.92909735e-01f,
  -5.75887144e-01f, -7.41394833e-02f, 5.41559979e-02f, 2.98232753e-02f, -2.16120765e-01f, -2.65596092e-01f, -4.14763033e-01f, -1.72429845e-01f, 5.02437167e-02f, -2.08842203e-01f,
  -4.57577348e-01f, 1.30896857e-02f, 2.06222728e-01f, 1.42670646e-01f, 1.19496673e-01f, 1.53180167e-01f, 6.06630266e-01f, 5.22147655e-01f, 2.04951525e-01f, -1.74135432e-01f,
  3.49164516e-01f, 2.70026565e-01f, 1.66527987e-01f, 3.66607517e-01f, 4.21413183e-01f, 1.84086069e-01f, 2.07970783e-01f, 1.20505415e-01f, 8.13724771e-02f, 5.68842471e-01f,
  -4.07405525e-01f, -3.38250428e-01f, 3.93755734e-02f, -2.41114184e-01f, -1.97826445e-01f, 2.09719405e-01f, -1.00856565e-01f, 2.32139844e-02f, -1.87456340e-01f, 5.62839694e-02f,
  -1.22243620e-01f, -1.34983258e-02f, -7.92123750e-02f, 3.83315384e-02f, -1.99501231e-01f, -1.42039001e-01f, 2.00044110e-01f, 1.40865058e-01f, 1.86155021e-01f, -2.96501428e-01f,
  2.35162616e-01f, -2.12301239e-01f, -5.56992888e-01f, -4.51286063e-02f, -9.38754380e-02f, 2.22243860e-01f, -2.17798248e-01f, -1.96188614e-02f, -1.47767618e-01f, -1.88123912e-01f,
  -1.09623723e-01f, 5.02234101e-02f, -4.18058485e-02f, 1.22819528e-01f, 5.07906973e-02f, -1.87275901e-01f, 1.86565906e-01f, 5.58366328e-02f, 1.05503805e-01f, -1.23496475e-02f,
  -1.32773072e-01f, -6.07301109e-02f, -1.05928585e-01f, -1.55122250e-01f, 7.55614042e-02f, 2.24251058e-02f, -1.03346780e-02f, -3.48353870e-02f, -1.02760829e-01f, -1.30319623e-02f,
  -1.42660722e-01f, -8.75964463e-02f, -1.62163079e-02f, 1.35852113e-01f, -5.81837706e-02f, 1.10180877e-01f, 1.69494480e-01f, -3.65016758e-02f, -1.30767927e-01f, 1.60707235e-02f,
  -1.06279872e-01f, -2.01044176e-02f, -2.24665284e-01f, -1.39965400e-01f, -3.21462750e-02f, -5.74707566e-03f, 3.48196700e-02f, -1.41593277e-01f, -3.03916726e-03f, -1.90137371e-01f,
  -2.51448035e-01f, -1.66972931e-02f, -4.73362058e-02f, 7.67392814e-02f, -1.15437552e-01f, -1.63777083e-01f, -8.87735412e-02f, -6.75654933e-02f, 2.41761468e-02f, -1.01048753e-01f,
  2.69380361e-01f, -2.95369118e-01f, -7.25027978e-01f, -3.16019148e-01f, -2.33212039e-01f, -3.51480007e-01f, -1.89325526e-01f, -1.57895982e-01f, -3.50335002e-01f, -5.39097428e-01f,
  1.22579649e-01f, 2.87746698e-01f, -7.49817371e-01f, -4.14688028e-02f, -3.05873275e-01f, -2.78487563e-01f, 1.19058065e-01f, 4.81211729e-02f, 1.83758005e-01f, 4.29430217e-01f,
  3.94634418e-02f, -2.93960541e-01f, -3.69841218e-01f, -1.84878156e-01f, -8.41511488e-02f, 1.61836445e-01f, 2.36420240e-02f, -5.31983614e-01f, -8.90340269e-01f, 7.80701451e-03f,
  2.22196370e-01f, -2.64780939e-01f, -1.96172178e-01f, 3.43886577e-02f, -1.85895860e-01f, -3.10499698e-01f, -1.37583479e-01f, -2.79392093e-01f, -5.97863318e-03f, -2.41987363e-01f,
  -3.38415712e-01f, -1.97989106e-01f, -1.68918237e-01f, 1.86513245e-01f, -2.08403200e-01f, -7.10171238e-02f, -4.48884889e-02f, -2.47958601e-01f, 6.33881688e-02f, 1.58094347e-01f,
  -2.35668018e-01f, 8.04104730e-02f, -1.80367723e-01f, -1.13797262e-01f, -1.88305244e-01f, -6.17899522e-02f, -9.21541378e-02f, -2.48762652e-01f, -1.82099611e-01f, -5.24865882e-03f,
  -4.91207652e-03f, -2.29382128e-01f, -4.34825838e-01f, 1.26555130e-01f, -3.56650770e-01f, -1.70543998e-01f, -1.38475999e-01f, -1.20278805e-01f, -9.91785005e-02f, 3.23979318e-01f,
  3.30084451e-02f, 1.77474711e-02f, -1.47146899e-02f, 1.55271500e-01f, 1.42293751e-01f, 8.84976685e-02f, 2.11604666e-02f, -9.81780700e-03f, -7.01239854e-02f, 8.57366771e-02f,
  -7.49666393e-02f, 3.52975875e-02f, 2.82812696e-02f, -5.83073124e-02f, -3.19527052e-02f, -2.91071497e-02f, -1.28228348e-02f, 1.11548103e-01f, -1.68781713e-01f, -4.64184694e-02f,
  -1.38863161e-01f, 1.92510821e-02f, -1.94664851e-01f, 1.28395274e-01f, -1.26870215e-01f, -8.69451910e-02f, 1.50746265e-02f, 5.33029251e-02f, 5.33074588e-02f, 1.00591756e-01f,
  3.74606311e-01f, -1.03674963e-01f, 5.72164841e-02f, -6.08671829e-03f, -9.32890326e-02f, -9.84727517e-02f, 2.84112804e-02f, 2.07495317e-01f, -2.02176601e-01f, -6.46624854e-03f,
  -1.26647443e-01f, -6.10606521e-02f, -1.14469707e-03f, 2.27134116e-02f, 6.44102842e-02f, 3.17488424e-02f, 2.36494258e-01f, -8.28154981e-02f, 1.05841219e-01f, -1.66238211e-02f,
  2.50354439e-01f, 2.66248316e-01f, 2.26702899e-01f, 1.33050442e-01f, -1.94062859e-01f, 3.02873738e-02f, -9.56159458e-02f, -2.44435892e-01f, -7.49374926e-02f, 5.73890150e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  -1.72225814e-02f, 3.09739243e-02f, 2.11947262e-01f, 2.58459806e-01f, 2.03598917e-01f, 3.31339121e-01f, 3.99444848e-01f, -1.80674687e-01f, 4.39058840e-01f, 2.69068986e-01f,
  2.48298973e-01f, 7.25467741e-01f, 5.13880312e-01f, 5.48260868e-01f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.58620104e-01f, -5.60442060e-02f, 3.27955127e-01f, 2.34840080e-01f, 3.27663422e-01f, -5.03710687e-01f, -5.15217446e-02f, -1.25924721e-02f, 3.26066703e-01f, -3.77041213e-02f,
  8.72260109e-02f, 4.91838783e-01f, -2.44889796e-01f, -1.73376963e-01f, 7.71179497e-02f, -2.37191692e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.27759320e-01f, 2.29057878e-01f, -4.76960242e-02f, 6.53901935e-01f, -3.46930921e-02f, -5.24989247e-01f, 1.48016840e-01f, 1.77035794e-01f, 5.41212082e-01f, 2.08391204e-01f,
  6.10368609e-01f, 7.68813431e-01f, 3.34262729e-01f, -2.03136817e-01f, 5.94716370e-01f, -2.98620433e-01f, 9.09925774e-02f, -3.04948926e-01f, 9.68238413e-02f, -6.08038783e-01f,
  -1.98124975e-01f, -2.50860136e-02f, 7.38034427e-01f, 5.69032609e-01f, -2.29834482e-01f, -4.81593609e-01f, -5.65282047e-01f, -2.45576456e-01f, -3.18837643e-01f, 9.35376734e-02f,
  8.49417448e-01f, -3.01402807e-01f, 2.54049957e-01f, 3.32173258e-01f, 9.10816073e-01f, 6.72761202e-01f, 5.47597826e-01f, 1.28603563e-01f, 3.03685933e-01f, -2.10443050e-01f,
  4.27921861e-02f, -5.52517533e-01f, 4.26346958e-01f, -2.14268729e-01f, -1.66966408e-01f, -1.93189234e-01f, 8.53700340e-02f, -4.99573886e-01f, -2.46463314e-01f, 1.30354792e-01f,
  -6.34087205e-01f, 5.74493185e-02f, -5.04788518e-01f, 3.46449494e-01f, 5.79337120e-01f, 4.80089158e-01f, 2.83056080e-01f, 5.72462380e-01f, -2.06890076e-01f, 3.22798133e-01f,
  4.25343096e-01f, 6.84401393e-02f, -1.05697960e-01f, 5.70043921e-02f, 6.49372637e-02f, 6.73134387e-01f, 6.57802761e-01f, 1.57986224e-01f, -6.42428815e-01f, -5.07903658e-02f,
  -1.63303003e-01f, 2.29164541e-01f, -5.21058500e-01f, -4.41994779e-02f, 4.05052483e-01f, 7.10416809e-02f, -8.49286914e-01f, 1.36828214e-01f, 6.32939637e-01f, -2.87903130e-01f,
  5.26673853e-01f, -1.46635249e-01f, -1.53965745e-02f, 1.00247040e-01f, 1.22107983e-01f, -2.30286822e-01f, 2.50428826e-01f, 5.64610481e-01f, 6.24020755e-01f, -4.34975326e-01f,
  -1.43531904e-01f, -2.60797292e-01f, 4.29398060e-01f, 5.43608725e-01f, -5.11837065e-01f, -5.41468747e-02f, 8.23357329e-02f, 3.00592463e-02f, -1.11251064e-01f, 1.77265748e-01f,
  -6.42400265e-01f, -3.52339298e-01f, -4.93100405e-01f, -2.73695618e-01f, 2.02668637e-01f, 7.70250201e-01f, 2.65406072e-01f, 3.62822175e-01f, 1.56108126e-01f, -4.17747915e-01f,
  3.40239376e-01f, 6.30278230e-01f, 3.28462049e-02f, -2.86518097e-01f, 5.91901727e-02f, 2.97900558e-01f, -3.56183350e-02f, -5.77642061e-02f, 3.09705794e-01f, -1.68316662e-01f,
  4.94077444e-01f, 5.27156532e-01f, 3.69321369e-02f, 6.28957152e-01f, 2.61973858e-01f, -2.53037084e-02f, 2.38423988e-01f, 4.78040725e-01f, 2.28727788e-01f, 5.69161952e-01f,
  -6.44214928e-01f, -2.45345160e-01f, -3.55822295e-01f, 5.92879176e-01f, -1.82536542e-01f, -8.85073617e-02f, 1.40147910e-01f, 5.52799582e-01f, -3.89350116e-01f, 8.02721828e-02f,
  6.48623228e-01f, 1.98386297e-01f, 1.70057818e-01f, 7.71208853e-02f, 6.57174110e-01f, 3.82303782e-02f, -3.56377929e-01f, -3.85975748e-01f, -2.38665596e-01f, -2.58558482e-01f,
  7.99485028e-01f, 6.39556348e-01f, 1.22836739e-01f, 5.63020334e-02f, -6.02334142e-01f, 2.77168572e-01f, 5.26525863e-02f, 1.63697809e-01f, 3.68401110e-01f, -1.09565929e-01f,
  2.22398922e-01f, 4.62362356e-02f, 4.35618281e-01f, 5.35885155e-01f, -7.07539171e-02f, -2.71581501e-01f, -9.20859277e-02f, -2.19110638e-01f, 2.76038349e-01f, -5.11958897e-01f,
  8.32636535e-01f, 1.77690774e-01f, 5.75793050e-02f, 4.59049791e-01f, -4.84585136e-01f, 5.20240009e-01f, 8.03581625e-02f, -5.14457107e-01f, -1.03905268e-01f, 4.19741780e-01f,
  2.31153145e-01f, 1.41633078e-01f, 5.52135944e-01f, -1.05884029e-02f, 1.87594190e-01f, -3.67833748e-02f, 3.47117275e-01f, 3.91325653e-01f, 2.99312979e-01f, -9.23842728e-01f,
  -2.75902031e-03f, -4.50020790e-01f, 7.39734322e-02f, 2.40124270e-01f, -6.45499229e-02f, -4.21365529e-01f, -3.66545677e-01f, 4.54616040e-01f, 4.80536520e-01f, 5.14819443e-01f,
  4.69003059e-02f, -2.02734768e-01f, 2.75728196e-01f, -2.65907049e-01f, -5.00499383e-02f, 4.75686699e-01f, 1.70354426e-01f, 3.54820669e-01f, -1.45644158e-01f, -3.99597645e-01f,
  2.39793748e-01f, 1.72289580e-01f, 3.39671135e-01f, -8.03095341e-01f, 2.81321228e-01f, 6.20314598e-01f, 1.70005232e-01f, -4.79643017e-01f, -7.64742494e-02f, 1.08073145e-01f,
  1.56076074e-01f, 5.89928091e-01f, 1.52024761e-01f, -6.44241944e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.49795634e-01f, 1.02220036e-01f, 4.16849554e-02f, -1.16542220e-01f, 1.53220505e-01f, 9.71749723e-02f, -1.22005425e-01f, 2.12630883e-01f, 2.12808996e-02f, 3.91861886e-01f,
  3.69765222e-01f, -3.66585795e-03f, 4.21255171e-01f, -1.56942248e-01f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  6.57893360e-01f, -1.42021226e-02f, -1.36414036e-01f, 3.60217899e-01f, -2.23058239e-01f, 3.57195847e-02f, -6.47761106e-01f, -2.75665242e-02f, 4.79521416e-02f, -1.19755477e-01f,
  -1.93955854e-01f, 1.92654356e-01f, 1.86924085e-01f, -1.03909649e-01f, 4.49088901e-01f, -3.43864918e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.69458047e-01f, 5.19188643e-01f, 8.36296156e-02f, -4.15761888e-01f, 3.78199853e-02f, -1.02562256e-01f, -3.83100212e-01f, 5.54003716e-01f, -3.16869795e-01f, 3.87913018e-01f,
  -2.18763918e-01f, 1.87315434e-01f, 3.65198702e-01f, -4.10829961e-01f, 1.86376885e-01f, 3.62526685e-01f, 7.77581483e-02f, -1.15012431e+00f, -9.63717163e-01f, 3.54336262e-01f,
  -6.84142783e-02f, 8.64240050e-01f, -1.47965893e-01f, 2.88673062e-02f, -4.58291918e-01f, -5.19397616e-01f, 6.94330871e-01f, 3.42648298e-01f, -4.22557682e-01f, -8.62165466e-02f,
  5.95472336e-01f, -2.95592099e-02f, 3.78259450e-01f, -4.00532447e-02f, 5.15537798e-01f, -3.08947682e-01f, -4.45905358e-01f, 2.28358909e-01f, -5.63000798e-01f, -3.82778049e-01f,
  5.73573232e-01f, 4.52159017e-01f, 2.27356166e-01f, -1.74381390e-01f, 3.94715637e-01f, -1.14683874e-01f, -3.08217287e-01f, -7.54486918e-01f, -9.50558633e-02f, 2.40242928e-01f,
  5.17748654e-01f, 4.23680604e-01f, -2.16347352e-02f, -5.74589372e-01f, 7.67980397e-01f, -5.03173582e-02f, -4.24164981e-02f, -1.68162614e-01f, -1.01901639e+00f, 1.05046786e-01f,
  5.98688602e-01f, -1.92266285e-01f, -1.32306874e-01f, 2.06783935e-01f, 6.57170057e-01f, 4.10098374e-01f, -3.25782001e-01f, 6.57175541e-01f, 4.71132934e-01f, -1.03405841e-01f,
  7.49168873e-01f, -1.86963841e-01f, 5.49142718e-01f, 3.51986945e-01f, -4.45950508e-01f, -9.17702615e-02f, 5.14363050e-01f, -1.66177854e-01f, 3.16395789e-01f, -5.58963791e-02f,
  -9.70727280e-02f, 4.45731521e-01f, 1.45416185e-01f, 3.40273887e-01f, 3.90772849e-01f, 5.43038130e-01f, -7.43887663e-01f, 7.86798000e-02f, 4.45627689e-01f, 4.26238984e-01f,
  -5.95195666e-02f, 2.73024179e-02f, -2.59034425e-01f, 8.31462383e-01f, -1.57195002e-01f, -4.54710066e-01f, 4.56824720e-01f, 9.91442800e-01f, 2.76242465e-01f, -1.48467213e-01f,
  -6.31342411e-01f, 2.84496188e-01f, -1.05254419e-01f, 6.48815989e-01f, -4.81305048e-02f, 3.53749126e-01f, 1.16372339e-01f, 5.89375257e-01f, 3.58775109e-01f, -3.15783978e-01f,
  1.76671833e-01f, 4.15971607e-01f, -1.17165279e+00f, -7.57003784e-01f, 1.12861795e-02f, 4.25112098e-02f, -1.00893664e+00f, 3.69491428e-01f, 4.69904780e-01f, -1.87017962e-01f,
  6.24107085e-02f, 2.80823588e-01f, -3.03597212e-01f, -4.56039459e-01f, 2.71901209e-02f, 2.64640689e-01f, -6.85015023e-01f, 1.79545790e-01f, -6.48923159e-01f, 5.49599111e-01f,
  6.39394075e-02f, 3.79779011e-01f, 3.47033411e-01f, 5.88403419e-02f, 1.01000094e+00f, 5.67735553e-01f, -1.77076072e-01f, -1.21263102e-01f, -7.11286366e-01f, 7.11051762e-01f,
  2.27648914e-01f, -1.07182950e-01f, 2.68022031e-01f, 7.70704627e-01f, -3.40012573e-02f, 5.56698814e-02f, 2.78097570e-01f, 1.10852785e-01f, 5.97424924e-01f, -5.55031359e-01f,
  2.67381072e-01f, 1.21028367e-02f, -2.71483839e-01f, -6.09460101e-02f, -7.66206086e-01f, -2.71325231e-01f, 5.94671547e-01f, 3.25154096e-01f, 7.88228512e-02f, 1.21175759e-01f,
  9.48756039e-02f, 4.13592249e-01f, 4.41769093e-01f, 5.14242768e-01f, -4.74199891e-01f, -8.31194744e-02f, 8.31742361e-02f, -4.94404882e-01f, -4.07610565e-01f, -2.29933068e-01f,
  3.91806453e-01f, 2.36930758e-01f, -8.98128331e-01f, -8.64802077e-02f, 2.74254590e-01f, 4.52916831e-01f, -2.10564420e-01f, -1.39233410e-01f, 6.22752845e-01f, 8.78625289e-02f,
  -4.40146387e-01f, 2.01478496e-01f, -4.71561611e-01f, 5.10947943e-01f, -1.58234596e-01f, 3.82705748e-01f, -1.02380551e-01f, 5.90954423e-01f, 1.09648297e-03f, 4.73029047e-01f,
  -2.09214702e-01f, 2.42426232e-01f, 3.51943851e-01f, -2.41362751e-01f, -1.19640417e-01f, -2.87684172e-01f, -9.97768700e-01f, 6.91680163e-02f, 2.46065408e-01f, -5.47314584e-02f,
  2.75122851e-01f, 1.83254123e-01f, -6.87266052e-01f, -6.67916000e-01f, 2.33389676e-01f, -6.28542295e-03f, 3.29681575e-01f, 3.66801113e-01f, -7.16153383e-01f, 1.10364169e-01f,
  -3.48333805e-03f, 4.28038627e-01f, -2.57624030e-01f, 7.48902485e-02f, 3.39164466e-01f, -3.87902498e-01f, -2.18193114e-01f, -5.72969355e-02f, -3.54805052e-01f, 6.75168693e-01f,
  -1.70624524e-01f, -4.29952191e-03f, 3.24889332e-01f, 4.62676018e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  4.61524539e-02f, 5.18058002e-01f, 1.37073934e-01f, -1.48909494e-01f, 3.00339311e-01f, 2.47223247e-02f, -5.31202257e-02f, -3.33872676e-01f, 4.44439948e-02f, 7.74050131e-02f,
  5.24426281e-01f, -2.10784182e-01f, 1.71345305e-02f, -3.41420621e-02f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  2.96062201e-01f, -3.49879228e-02f, 2.48041078e-01f, -8.49406719e-02f, -2.28719205e-01f, 1.50076911e-01f, 1.80541113e-01f, 1.07241280e-01f, -2.78066806e-02f, -1.09869748e-01f,
  6.25564083e-02f, 2.36533806e-01f, -7.33249038e-02f, -2.04043493e-01f, -2.68238664e-01f, -2.56711036e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.39725983e+00f, 3.41091037e-01f, 4.58158165e-01f, 3.51937026e-01f, -1.23221517e-01f, -6.34749308e-02f, -1.24900408e-01f, 1.45403922e-01f, -3.16334143e-02f, 1.11653340e+00f,
  3.82903159e-01f, -4.88372631e-02f, -2.37971768e-01f, 5.67820728e-01f, 2.23621994e-01f, 3.40452880e-01f, 5.88492975e-02f, -2.19455987e-01f, 4.15137738e-01f, 3.85894030e-02f,
  -8.24570879e-02f, -4.65065688e-01f, 1.98318437e-01f, 8.57387483e-02f, 2.47592017e-01f, -4.43457544e-01f, 6.39982462e-01f, 1.58928514e-01f, -8.77411246e-01f, 2.43020475e-01f,
  -4.30225790e-01f, -6.27276003e-01f, 1.68030001e-02f, 2.20558450e-01f, 3.75674307e-01f, -1.84694946e-01f, -3.72443259e-01f, 5.18056870e-01f, 2.35559627e-01f, -8.22103024e-01f,
  3.36796492e-01f, 2.87400763e-02f, 2.03009799e-01f, 2.04894945e-01f, -2.98698276e-01f, -2.91280299e-01f, 1.56235024e-01f, -1.06361222e+00f, -5.23116849e-02f, -1.47182167e+00f,
  4.22386900e-02f, -6.14690483e-02f, 3.53499383e-01f, -1.26849443e-01f, -1.49772853e-01f, 6.51372612e-01f, 2.99042106e-01f, -8.59626591e-01f, -1.40555799e-02f, 1.14666231e-01f,
  -2.05461070e-01f, 4.31264997e-01f, -9.85454559e-01f, -6.29143640e-02f, 1.95486113e-01f, 7.82542378e-02f, -3.55911218e-02f, -1.80966705e-01f, 4.40868318e-01f, -1.26018792e-01f,
  4.24135476e-03f, 1.56022519e-01f, 2.66422238e-02f, -1.60786062e-01f, -7.42410183e-01f, -4.08553362e-01f, 5.30757666e-01f, -3.56804729e-02f, 1.58785269e-01f, -4.12219688e-02f,
  -4.31337416e-01f, -1.93514183e-01f, -2.82821417e-01f, 3.26877445e-01f, -3.95641685e-01f, 3.64971280e-01f, 4.56572562e-01f, -2.92490542e-01f, -6.23497307e-01f, 2.67907411e-01f,
  6.89626336e-01f, 2.22360060e-01f, -4.77849804e-02f, -9.36373055e-01f, 2.17502281e-01f, 4.22600448e-01f, 6.82472944e-01f, 6.53767169e-01f, -1.58113122e-01f, 9.06822920e-01f,
  -4.94517118e-01f, -6.28368914e-01f, -1.59356013e-01f, 5.20358086e-01f, -2.54440337e-01f, -7.97842860e-01f, -2.78933704e-01f, 1.46644011e-01f, 1.62623018e-01f, 2.01841652e-01f,
  -3.50406706e-01f, 1.20747037e-01f, 2.00975150e-01f, -3.38759363e-01f, 1.94918528e-01f, -2.29759887e-01f, 4.40739632e-01f, -3.53613459e-02f, 3.47325236e-01f, 4.41419870e-01f,
  3.08985651e-01f, -3.43226016e-01f, -5.04119694e-01f, 6.69083185e-03f, 2.37964541e-01f, 4.47217524e-01f, -3.03183585e-01f, -1.40930722e-02f, -6.36904761e-02f, 7.38953292e-01f,
  1.85060278e-01f, -1.25560805e-01f, -4.57266085e-02f, 3.04377317e-01f, 4.76083457e-01f, -5.76540530e-01f, 2.60255307e-01f, -2.76380271e-01f, 4.35240239e-01f, 9.76467952e-02f,
  4.74255472e-01f, -1.34337023e-01f, 9.39672887e-01f, 2.32546344e-01f, 6.81889534e-01f, 1.92781031e-01f, 2.92395920e-01f, -2.68209457e-01f, 6.00667238e-01f, -5.22585154e-01f,
  6.64490283e-01f, 3.66536140e-01f, 3.25860620e-01f, -7.20656157e-01f, -2.86180168e-01f, -3.08460802e-01f, -8.84033516e-02f, -1.46533502e-02f, 2.82372177e-01f, -2.52979159e-01f,
  -1.02419984e+00f, 9.07705903e-01f, -1.49382830e-01f, 2.40566209e-02f, 2.88133025e-01f, -2.75023520e-01f, 2.03719988e-01f, 3.44903469e-01f, -1.46518886e-01f, 1.07430792e+00f,
  5.36228359e-01f, -2.39675611e-01f, 3.16222280e-01f, 1.62854016e-01f, 1.13663113e+00f, 6.54773057e-01f, 1.61647141e-01f, -7.20866501e-01f, 2.98131108e-02f, -3.91099215e-01f,
  -2.53480375e-01f, 9.20761883e-01f, -1.22760296e-01f, 2.43526958e-02f, 4.59011942e-01f, -7.66300440e-01f, 6.42556667e-01f, 5.13650417e-01f, 2.18551934e-01f, 2.72498280e-01f,
  -2.48379290e-01f, 9.07695889e-02f, 6.35268629e-01f, -2.91363578e-02f, 1.18645253e-02f, -2.19603851e-02f, 5.76582909e-01f, 8.52292001e-01f, 6.46102250e-01f, 2.42916867e-01f,
  -4.10313070e-01f, 2.68922269e-01f, -2.25022614e-01f, 8.01437914e-01f, -1.75779551e-01f, -8.54224637e-02f, 5.82661293e-02f, -1.81254402e-01f, 7.25458145e-01f, 3.92950594e-01f,
  -1.19949237e-01f, 7.32874334e-01f, -4.76469576e-01f, 2.72604972e-01f, -5.08080065e-01f, -3.04176420e-01f, 4.20841902e-01f, -7.63927639e-01f, -1.66897029e-01f, -6.25701964e-01f,
  5.22644937e-01f, 6.19101882e-01f, 1.06460363e-01f, 1.67322814e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -5.81093192e-01f, -1.10127456e-01f, 2.18596473e-01f, -1.37910351e-01f, 2.58801669e-01f, 7.05962926e-02f, 6.96708322e-01f, 3.44094932e-01f, -2.16478053e-02f, 4.49836165e-01f,
  -1.62234366e-01f, -1.78627878e-01f, 4.00087655e-01f, 8.85950029e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  3.70879233e-01f, 5.34198761e-01f, 6.13244414e-01f, -2.84988970e-01f, 2.71904022e-01f, -6.57517090e-03f, 1.00466935e-02f, -7.08238423e-01f, -4.52325314e-01f, 2.11847901e-01f,
  -5.00021100e-01f, 1.19052514e-01f, 3.42393965e-01f, -6.91764474e-01f, 1.75911590e-01f, 1.47013202e-01f, 1.93570480e-01f, 7.39745736e-01f, -2.87858844e-01f, -1.35057112e-02f,
  -6.51510835e-01f, 4.23661590e-01f, -1.10357118e+00f, -3.71742010e-01f, 3.52515787e-01f, 1.95019066e-01f, -4.24934685e-01f, 9.67837423e-02f, -3.79085392e-01f, 2.61769872e-02f,
  6.93794608e-01f, -2.60155112e-01f, 1.41872153e-01f, -2.25737080e-01f, -5.59110880e-01f, -8.96761358e-01f, -6.26260340e-02f, 1.62031710e-01f, 4.87518534e-02f, -9.67398360e-02f,
  -4.21181798e-01f, 7.40662068e-02f, 4.07630891e-01f, 1.05203521e-02f, -2.60155112e-01f, 7.09633291e-01f, -2.03672573e-01f, 4.32814866e-01f, -4.38618034e-01f, -7.07536221e-01f,
  -3.65613550e-01f, -1.43824935e-01f, -4.31247492e-04f, 3.88792336e-01f, 4.42287624e-01f, 4.95492369e-01f, -1.82731903e+00f, 3.50854456e-01f, -5.40831268e-01f, 3.21321070e-01f,
  -2.82611072e-01f, -3.19918036e-01f, 3.18986893e-01f, -6.16097152e-01f, 4.02052760e-01f, -1.44328643e-02f, 6.35112971e-02f, 5.13443887e-01f, -7.84963846e-01f, 2.27028161e-01f,
  -7.71303415e-01f, 8.84260014e-02f, -6.40941918e-01f, 7.10122436e-02f, -3.28867465e-01f, 2.52792299e-01f, -7.10896857e-04f, 1.24856316e-01f, -3.88380021e-01f, 7.28690624e-02f,
  -2.30194125e-02f, 7.56897569e-01f, -2.24496499e-01f, -2.04171970e-01f, 2.12943643e-01f, -5.41571498e-01f, -7.26102173e-01f, -2.69187331e-01f, -9.69327614e-02f, 1.46458641e-01f,
  4.46975827e-01f, 3.18115979e-01f, 4.30489421e-01f, -2.08075270e-01f, 3.12049359e-01f, -4.95030165e-01f, -1.51341520e-02f, -4.21245903e-01f, 2.06522003e-01f, 2.20825374e-01f,
  2.95469105e-01f, -1.04987586e+00f, -2.28972107e-01f, 4.65170532e-01f, 4.01478335e-02f, -6.71322167e-01f, 3.85065317e-01f, 3.88235509e-01f, 3.89094710e-01f, -8.27299356e-01f,
  -6.70715332e-01f, 2.44758159e-01f, -5.58620214e-01f, 1.95755586e-01f, -3.27620536e-01f, -2.76453376e-01f, -9.08247888e-01f, -5.36398888e-02f, 7.47040883e-02f, 4.34013993e-01f,
  -2.40767136e-01f, -6.38307154e-01f, 2.98946530e-01f, -9.04472113e-01f, 2.00501636e-01f, 3.17332000e-01f, 1.60278454e-01f, -7.89654851e-01f, -2.83228867e-02f, -3.02266240e-01f,
  -5.99979341e-01f, 1.01657800e-01f, 5.29467762e-01f, -7.37307250e-01f, 3.24719399e-01f, 4.26960766e-01f, -7.42082059e-01f, -3.97917271e-01f, 2.32978493e-01f, -6.22244477e-01f,
  -5.45060337e-01f, -5.35723604e-02f, 2.40062267e-01f, -7.31388867e-01f, -1.51909934e-02f, 1.06239550e-01f, 4.27382410e-01f, -5.97600341e-01f, -1.26472544e-02f, 3.50837171e-01f,
  2.26046503e-01f, -6.24201819e-02f, 2.10236222e-01f, 9.00194943e-02f, -1.26862317e-01f, -2.68483698e-01f, 1.59935430e-01f, -2.09860831e-01f, -1.67594001e-01f, 1.93686515e-01f,
  -1.36030227e-01f, -5.11151612e-01f, 5.06240010e-01f, 2.48384997e-01f, 4.76675570e-01f, 4.21977304e-02f, -4.06456850e-02f, -9.60064769e-01f, -1.20611572e+00f, -5.12592047e-02f,
  1.80841635e-05f, -4.25883234e-01f, -8.66074264e-01f, 4.10493612e-01f, -1.25885785e-01f, -6.65073693e-01f, 2.30454803e-01f, -7.99852550e-01f, -8.93557549e-01f, -5.96647143e-01f,
  -8.78041208e-01f, -3.87405843e-01f, -5.16048789e-01f, -1.26636162e-01f, 8.18953276e-01f, -5.42863071e-01f, -2.72207379e-01f, -4.98043865e-01f, -7.03686416e-01f, -7.96525300e-01f,
  -3.82121801e-01f, 9.58838701e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  2.06070781e-01f, 1.90827265e-01f, 9.23196003e-02f, 1.43467262e-01f, 8.64967406e-02f, -1.45711973e-01f, 2.94558376e-01f, -3.23672175e-01f, -3.50446612e-01f, -1.70412764e-01f,
  -4.30695206e-01f, 3.88409823e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    