/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.76086324e-01f, 1.77417338e-01f, 1.15492448e-01f, -2.88246989e-01f, -2.51464725e-01f, 1.11355975e-01f, 1.78582653e-01f, -9.12088007e-02f, -2.76805937e-01f, 2.06747800e-01f,
  6.62131608e-03f, 8.25696364e-02f, 2.50938743e-01f, -1.43672213e-01f, -1.03579231e-01f, 1.31504178e-01f, -3.28730978e-02f, 8.65441933e-02f, 3.71230878e-02f, -7.94895515e-02f,
  -9.15047005e-02f, -1.19147487e-01f, 1.16938069e-01f, -5.84572516e-02f, -3.60022224e-02f, -1.26430571e-01f, 1.54147232e-02f, 1.42448485e-01f, -1.40987158e-01f, 2.63462067e-02f,
  1.24891959e-01f, -6.14225902e-02f, -9.56884399e-02f, 2.05901712e-02f, -1.00987986e-01f, -1.00937020e-02f, 7.15453476e-02f, -2.29506195e-02f, -1.27034448e-02f, -2.23453529e-02f,
  7.70073086e-02f, 2.15251725e-02f, -1.07810572e-01f, -3.55727188e-02f, -4.14056554e-02f, 2.52306387e-02f, -4.52082753e-02f, -2.86536738e-02f, -1.16386320e-02f, 1.76067813e-04f,
  -8.68792296e-04f, 5.92487715e-02f, -1.48535129e-02f, -2.03658268e-02f, -2.02721381e-03f, -1.05730899e-01f, 2.05760971e-02f, -6.40256777e-02f, 1.70506481e-02f, -8.79630893e-02f,
  -1.18662352e-02f, -1.00377150e-01f, 9.40222852e-03f, -6.42107353e-02f, -4.98482250e-02f, -5.27328663e-02f, -3.90781611e-02f, 5.24700247e-02f, 1.88116319e-02f, 8.49285424e-02f,
  -1.04042701e-02f, -4.37552817e-02f, 1.01916775e-01f, 3.07660997e-02f, -6.11077901e-03f, 1.59326438e-02f, -2.99738999e-02f, 9.29475278e-02f, -4.22134139e-02f, -3.52548755e-04f,
  4.21905331e-02f, -3.26832607e-02f, 3.94662134e-02f, -2.37843320e-02f, 1.31637510e-02f, 2.10998170e-02f, -6.24314062e-02f, 3.45858522e-02f, 1.94159690e-02f, -7.07324222e-03f,
  1.72107801e-01f, 3.92471775e-02f, -2.41088793e-02f, 4.75114547e-02f, 9.24145244e-03f, -3.10488604e-02f, 1.80209372e-02f, -1.43426610e-03f, 7.42559582e-02f, -4.58627082e-02f,
  -3.73334326e-02f, 6.04108814e-03f, -6.44082651e-02f, 3.34499814e-02f, -3.36542609e-03f, 3.76161821e-02f, 4.96229567e-02f, 1.01368912e-02f, -3.03057488e-04f, -3.72460634e-02f,
  8.97147413e-03f, 3.30087100e-03f, 4.32716422e-02f, 1.18886903e-02f, -2.74840649e-02f, 2.35992353e-02f, -1.07299849e-01f, 4.05540243e-02f, 2.40158085e-02f, -2.14572027e-02f,
  -3.13759536e-01f, -1.15996011e-01f, 5.28873242e-02f, -2.05563188e-01f, 1.29750460e-01f, -3.21112186e-01f, -3.53171319e-01f, 6.29842468e-03f, -1.34123161e-01f, -1.70710534e-01f,
  -1.21962287e-01f, 1.69562384e-01f, 1.10521734e-01f, -1.57241270e-01f, 6.22288696e-02f, -1.06768504e-01f, -3.14155161e-01f, -3.32806967e-02f, -2.28935685e-02f, -4.59459312e-02f,
  -3.96107957e-02f, -1.76883891e-01f, -3.97815928e-02f, -5.17052040e-02f, -6.67541027e-02f, -1.04027115e-01f, 1.30821273e-01f, 8.11021626e-02f, 2.88352501e-02f, -2.28669178e-02f,
  -2.95238737e-02f, 9.83092263e-02f, 1.01883009e-01f, 3.74684818e-02f, -5.77353686e-02f, -3.46886516e-02f, -2.71616243e-02f, 4.56086360e-03f, 2.81808898e-02f, 6.12481833e-02f,
  6.17115498e-02f, 5.65203056e-02f, -1.30466118e-01f, 4.07491392e-03f, 7.49410316e-02f, 1.13599524e-02f, 1.19178452e-01f, -2.43150275e-02f, 1.64393447e-02f, 1.30534008e-01f,
  1.07949704e-01f, 6.98925480e-02f, 5.03962301e-02f, -6.36276901e-02f, 6.48429766e-02f, -7.57670626e-02f, -1.38413450e-02f, 6.88336268e-02f, 7.85286054e-02f, 3.90908495e-02f,
  2.46561784e-02f, -1.21597506e-01f, -1.48856947e-02f, -1.91184077e-02f, 5.99340424e-02f, -2.84154695e-02f, -3.38043384e-02f, -4.09608819e-02f, 3.25391889e-02f, 5.99861564e-03f,
  -5.98292425e-02f, 1.37191201e-02f, 5.84308095e-02f, 8.85767564e-02f, -2.04059314e-02f, -6.79303929e-02f, -7.95044154e-02f, 1.18723765e-01f, -6.44422844e-02f, -5.06573170e-02f,
  -4.73759919e-02f, -6.17267899e-02f, 2.00849362e-02f, 1.70572996e-02f, -4.10394818e-02f, -4.81339125e-03f, 8.80088732e-02f, 1.00366008e-02f, -3.79187823e-03f, 8.47517923e-02f,
  -1.02252461e-01f, -1.45660013e-01f, -8.04210454e-03f, 4.30914611e-02f, -7.86535069e-02f, 6.28853776e-03f, -2.52953488e-02f, -5.51164486e-02f, -1.14227265e-01f, 6.10768981e-02f,
  9.92144942e-02f, -2.33375505e-02f, -5.52036315e-02f, -7.55684674e-02f, -7.05644190e-02f, 3.26826684e-02f, -2.11679295e-01f, -6.97209165e-02f, -6.96597397e-02f, 1.31513640e-01f,
  4.23637629e-02f, -1.23262204e-01f, -9.10609867e-03f, -3.28370109e-02f, -2.28712126e-03f, 2.42451634e-02f, -2.97730323e-02f, 2.54992042e-02f, 1.19619980e-01f, -5.72840422e-02f,
  3.97851855e-01f, -1.71324730e-01f, -1.50123805e-01f, 2.14281440e-01f, 1.32457346e-01f, -2.30605170e-01f, -9.00529623e-02f, 5.88787273e-02f, 7.96286017e-02f, 1.55408174e-01f,
  1.20695103e-02f, 9.00525227e-02f, -1.33784011e-01f, -5.48046231e-02f, -3.24026167e-01f, -2.30866686e-01f, -2.23783821e-01f, -1.26703009e-01f, -8.04939866e-02f, 8.45897123e-02f,
  -1.19429842e-01f, 1.90100685e-01f, -6.81584030e-02f, 1.21237993e-01f, 2.20866233e-01f, 3.90924923e-02f, 1.46599993e-01f, -5.35227656e-02f, 1.74868599e-01f, -2.27373336e-02f,
  8.76624808e-02f, 2.03486741e-01f, 8.91364925e-03f, 2.13452037e-02f, -5.92263564e-02f, -4.08042818e-02f, 1.51643287e-02f, -1.21447314e-02f, -5.47247306e-02f, -3.02985241e-03f,
  -5.71775474e-02f, 4.47577760e-02f, -2.92497445e-02f, 9.00299754e-04f, 7.07880631e-02f, 7.34437481e-02f, 2.91775577e-02f, -6.38929680e-02f, 2.00566910e-02f, -1.48706391e-01f,
  -1.44300669e-01f, -6.48901192e-03f, -1.07530393e-01f, -1.00961171e-01f, -8.41731951e-02f, -5.88360578e-02f, -5.63983619e-02f, -1.27735347e-01f, 5.95122389e-03f, 8.71319845e-02f,
  -2.64592338e-02f, -7.38259405e-02f, 1.44072529e-02f, 5.68904206e-02f, -1.94003638e-02f, 6.23481311e-02f, -4.82574105e-02f, 2.03862898e-02f, -1.49498712e-02f, 3.49374227e-02f,
  5.41829318e-02f, 1.02585018e-01f, -6.98590651e-02f, -4.45757098e-02f, 1.81898680e-02f, 5.79028092e-02f, -2.16322709e-02f, -1.39447987e-01f, -5.94188236e-02f, 4.86141816e-02f,
  3.58893834e-02f, -8.89776871e-02f, 8.95090401e-02f, -7.60049596e-02f, 6.77571632e-03f, 5.96505105e-02f, 3.68055999e-02f, 3.68381143e-02f, 3.96495573e-02f, -2.74691116e-02f,
  -3.52546200e-02f, 2.76713483e-02f, -1.12283742e-02f, 6.73737377e-02f, 1.42947221e-02f, -1.77288279e-02f, -2.53541823e-02f, -5.29067218e-02f, -6.95223287e-02f, -1.04693798e-02f,
  -5.51693849e-02f, 3.38041894e-02f, 3.29090878e-02f, 1.23731280e-03f, -8.81981626e-02f, -5.15123904e-02f, 7.01411143e-02f, 5.89066409e-02f, 6.21694401e-02f, -1.54013652e-02f,
  8.52513909e-02f, 6.59889206e-02f, 5.82561381e-02f, 1.55112341e-01f, 2.86602601e-02f, 2.52824761e-02f, 9.65599087e-04f, -1.25957310e-01f, -5.32529540e-02f, -1.72067478e-01f,
  -7.26530328e-02f, 1.52106017e-01f, 1.65878117e-01f, 7.79140070e-02f, 5.10342978e-02f, -4.01711017e-02f, -9.00921449e-02f, 1.62241191e-01f, 4.38261420e-01f, 1.72559731e-02f,
  -2.94281784e-02f, -1.27181739e-01f, 1.46921761e-02f, 1.23914786e-01f, -4.39044416e-01f, 2.48347921e-03f, -6.87577426e-02f, -5.89290000e-02f, 1.71520427e-01f, -1.57711133e-01f,
  1.04139699e-02f, -2.79603988e-01f, -2.09839374e-01f, -7.96661898e-02f, 2.42042914e-02f, 1.07970633e-01f, -3.83740902e-01f, -4.21644747e-03f, -2.34979421e-01f, -5.81783652e-02f,
  7.73768947e-02f, 2.25036725e-01f, -1.91426445e-02f, 4.48519066e-02f, -2.21216921e-02f, -6.24799654e-02f, -8.56448933e-02f, 5.46727106e-02f, 6.28159642e-02f, 9.77449641e-02f,
  2.23104171e-02f, 7.31307939e-02f, -2.95356605e-02f, -8.46628621e-02f, 1.33915082e-01f, 6.64571971e-02f, 1.08252823e-01f, 2.58113928e-02f, 5.68387099e-02f, 2.09258534e-02f,
  6.25210777e-02f, -3.17158154e-03f, -8.56759772e-03f, -8.47754851e-02f, -6.06738171e-03f, 6.47853175e-03f, -4.01754281e-04f, 1.97275355e-02f, -1.77024566e-02f, 9.10918787e-02f,
  -1.79120582e-02f, -6.21363074e-02f, -1.07748523e-01f, -9.44769233e-02f, 5.19096740e-02f, -4.20387313e-02f, -1.16950147e-01f, -6.04231879e-02f, 5.97066358e-02f, -2.51276847e-02f,
  2.18884237e-02f, -4.35476229e-02f, 5.90428263e-02f, 6.59049749e-02f, -2.56402474e-02f, 3.97692993e-03f, -6.13283105e-02f, 6.07333444e-02f, 1.84213407e-02f, -2.44446993e-02f,
  2.24527046e-02f, 1.49154030e-02f, -8.77182260e-02f, -4.31160629e-02f, -5.61082996e-02f, -9.17001069e-03f, -6.68201223e-03f, 2.81152725e-02f, -1.61082018e-02f, -1.22566991e-01f,
  -2.22754776e-02f, 5.10127060e-02f, 1.14994608e-02f, 5.78190610e-02f, -2.92803738e-02f, -4.77050021e-02f, 2.21294742e-02f, 6.50993362e-03f, 3.12441103e-02f, -7.66888680e-03f,
  4.06693518e-02f, -1.91385783e-02f, -8.23181868e-02f, 4.50070277e-02f, -1.19226627e-01f, -7.20926523e-02f, -2.04765961e-01f, 3.73661108e-02f, -1.39835626e-01f, -1.50589541e-01f,
  -6.67281747e-02f, 3.89203243e-02f, 3.05350614e-03f, -5.22418469e-02f, 1.85842086e-02f, 1.00477459e-02f, -7.03424290e-02f, 9.77697372e-02f, -8.25103081e-04f, 3.35777923e-02f,
  6.38770759e-01f, 1.08557552e-01f, 1.06199659e-01f, 3.99839610e-01f, -7.15160295e-02f, 9.10960734e-02f, -3.05454414e-02f, 1.15172550e-01f, 2.48190045e-01f, -3.74431461e-02f,
  -9.94008407e-02f, 2.94381618e-01f, -9.19133499e-02f, 2.82866329e-01f, 2.07324117e-01f, 1.26608863e-01f, 3.13234150e-01f, 1.62567586e-01f, 9.12491977e-02f, 1.12274028e-01f,
  8.99678394e-02f, -9.99468416e-02f, -4.78635691e-02f, -2.26164833e-01f, 1.48471780e-02f, 3.43631841e-02f, -2.26640224e-01f, -2.07143158e-01f, 1.14333676e-02f, -8.85212272e-02f,
  -1.61951140e-01f, -1.87172089e-02f, -4.07093577e-02f, 1.39825754e-02f, -8.83027837e-02f, -1.14877433e-01f, -3.04292366e-02f, 1.40235405e-02f, 2.10798755e-02f, 2.19305959e-02f,
  1.60966013e-02f, 1.72474552e-02f, 7.30318297e-03f, -4.82175387e-02f, 6.06020018e-02f, 5.07589653e-02f, -7.44046718e-02f, -4.20532338e-02f, -6.50915410e-03f, 8.19220208e-03f,
  6.84537925e-03f, -3.13382782e-02f, -2.22974159e-02f, 3.54305170e-02f, 3.18491161e-02f, -5.93740046e-02f, 2.00223923e-03f, 1.12168845e-02f, 9.50396061e-03f, 6.89698849e-03f,
  4.60773297e-02f, -3.40613723e-02f, -4.13208967e-03f, 1.80039108e-02f, 2.59846952e-02f, -3.30675095e-02f, -2.36262754e-02f, -3.38941179e-02f, 3.46654505e-02f, -3.14790532e-02f,
  1.95275880e-02f, 2.07279418e-02f, 1.52160972e-01f, -3.95288982e-04f, -1.62478480e-02f, -5.24829142e-02f, -2.42530704e-02f, 8.22195318e-03f, 2.28194259e-02f, 4.41625342e-02f,
  1.08764675e-02f, 3.56940404e-02f, -2.90218387e-02f, -2.25972254e-02f, -4.59816568e-02f, 1.24014821e-02f, 7.96185248e-03f, -3.49497609e-02f, -2.65577924e-04f, -7.44637568e-04f,
  9.16921049e-02f, 1.05122544e-01f, 1.67645495e-02f, -4.23472747e-02f, 2.40017120e-02f, -3.06838173e-02f, 8.70151371e-02f, 2.20972374e-02f, 3.51821408e-02f, 3.59939821e-02f,
  -6.75684260e-03f, -2.01416668e-02f, -1.11376429e-02f, 6.32192791e-02f, -6.11350946e-02f, 3.77910472e-02f, -4.28632013e-02f, 1.10530166e-03f, -6.31775847e-03f, 8.29239958e-04f,
  -2.82888412e-02f, -4.09826264e-02f, -8.57984531e-04f, -7.93925449e-02f, -2.31790766e-02f, -2.31453963e-02f, 5.42649291e-02f, 8.51374418e-02f, 7.27959163e-03f, -8.70459434e-03f,
  3.25558931e-01f, -2.83477362e-02f, -6.78404793e-02f, -8.52383301e-02f, 1.12220354e-01f, 3.43862444e-01f, 1.48334637e-01f, -1.31176785e-01f, 2.26179566e-02f, 7.15289339e-02f,
  -6.69070929e-02f, 3.17741394e-01f, -1.22560389e-01f, -8.16666484e-02f, -2.21126750e-02f, 3.17458846e-02f, 8.67347121e-02f, 2.04034552e-01f, -8.20195824e-02f, -6.88924491e-02f,
  -7.48530105e-02f, -1.92184702e-01f, -1.09541282e-01f, -2.58861601e-01f, -9.15632471e-02f, -6.67679608e-02f, -2.90502638e-01f, -1.67800203e-01f, -7.39322901e-02f, 1.72170270e-02f,
  -9.29555297e-03f, -6.47109747e-02f, -3.69198956e-02f, 4.29923832e-02f, 4.25874023e-03f, 1.65642239e-02f, -9.41723399e-03f, 1.11769410e-02f, -6.05797805e-02f, 5.42501248e-02f,
  8.84440765e-02f, 1.43213430e-03f, -3.72526161e-02f, -3.34404819e-02f, 8.85120332e-02f, -5.85647635e-02f, -8.72440711e-02f, 6.57920167e-02f, -6.83049485e-02f, 1.02955446e-01f,
  2.59703901e-02f, 5.65349720e-02f, -2.71209814e-02f, 9.97886732e-02f, -3.93094532e-02f, -5.53065212e-03f, 5.53948060e-02f, 1.13378696e-01f, -2.59998254e-03f, 5.84428348e-02f,
  7.28997365e-02f, 1.56666543e-02f, 2.26424430e-02f, -4.81339358e-02f, -4.76035513e-02f, -8.20237771e-02f, 3.28964368e-02f, 8.50361306e-04f, 7.88795203e-02f, 2.80938335e-02f,
  1.91376656e-02f, 1.51932416e-02f, -4.16547097e-02f, 2.80741025e-02f, 2.12241355e-02f, -5.92633970e-02f, -3.17117609e-02f, -4.47202176e-02f, -4.82770465e-02f, -1.02356024e-01f,
  -4.40294109e-02f, -3.68929170e-02f, -6.16306625e-02f, -5.49674481e-02f, -6.53967783e-02f, 2.60569602e-02f, -1.05370246e-02f, -6.49365708e-02f, -3.54354791e-02f, 1.73116270e-02f,
  1.56515673e-01f, -8.19453374e-02f, -1.79342367e-02f, -6.65215328e-02f, -1.27884401e-02f, 3.06551363e-02f, -6.86926022e-03f, -2.09672973e-02f, 1.14851780e-01f, -3.89869772e-02f,
  1.78263094e-02f, -5.12308031e-02f, -1.13965804e-02f, 1.00690745e-01f, -1.48095891e-01f, 2.81673204e-02f, -6.02652654e-02f, -1.07271522e-01f, 5.59080951e-02f, -5.71179427e-02f,
  4.92180698e-02f, 8.40817466e-02f, 4.65057716e-02f, -4.11833404e-03f, 4.71109226e-02f, 4.87059578e-02f, -7.08769858e-02f, 3.37051079e-02f, 1.41644925e-02f, -3.31856939e-03f,
  4.55740243e-01f, 3.14651370e-01f, -2.60372553e-02f, 7.76519552e-02f, -6.17672340e-04f, 3.32466252e-02f, -1.59720145e-02f, -3.17586213e-03f, -1.70738593e-01f, 1.75884180e-02f,
  -1.18516609e-01f, 5.56483157e-02f, -1.57466456e-01f, 6.16545938e-02f, -1.34861186e-01f, -2.15451702e-01f, 4.44760360e-03f, 2.37483419e-02f, -7.73591325e-02f, 7.88415968e-03f,
  -6.79748692e-03f, -9.48544685e-03f, 1.03885643e-02f, 1.20239509e-02f, 2.64467061e-01f, 2.18920305e-01f, 8.05607289e-02f, -9.48802978e-02f, 1.85973570e-01f, 1.19780608e-01f,
  3.64993177e-02f, -8.37570801e-02f, -1.09195337e-02f, 3.06613594e-02f, 1.69386432e-01f, 5.49921356e-02f, 7.49675184e-02f, 1.37251299e-02f, 2.52520517e-02f, -1.11554891e-01f,
  9.50575545e-02f, 1.93153378e-02f, -2.26281993e-02f, -5.13451211e-02f, -8.14071745e-02f, -4.79358435e-02f, -3.28622274e-02f, 3.57433036e-03f, 1.61156263e-02f, -3.05126747e-03f,
  -6.81422502e-02f, -1.75510645e-02f, -3.53628304e-03f, 6.66797832e-02f, 7.35329688e-02f, -3.88317928e-02f, -2.17326842e-02f, 1.00170463e-01f, 1.03474138e-02f, 1.72903053e-02f,
  -7.13323150e-03f, 1.15294263e-01f, -1.15805166e-02f, -3.86107452e-02f, -1.56205986e-02f, 4.99611534e-02f, -1.47637939e-02f, 2.70297695e-02f, 6.58624917e-02f, -3.02138347e-02f,
  -5.91353625e-02f, -2.30384935e-02f, -1.64791010e-02f, 5.87225240e-03f, 3.35426703e-02f, -5.01735695e-02f, 2.93580350e-02f, -8.66595581e-02f, 1.34573817e-01f, 6.36457130e-02f,
  4.20140028e-02f, 7.43774176e-02f, 1.99277177e-02f, 5.25213256e-02f, 5.44953533e-02f, 3.63634527e-02f, -1.07717983e-01f, -3.20847593e-02f, 2.63270214e-02f, -7.45053217e-02f,
  2.22565353e-01f, 5.31119853e-02f, -3.12792584e-02f, 1.72571931e-02f, -4.65644971e-02f, -1.01774953e-01f, -1.15237311e-01f, 1.16683938e-01f, 9.64606330e-02f, 1.83033664e-03f,
  3.55819091e-02f, 1.10249892e-01f, -1.94909461e-02f, -5.53600676e-02f, -2.72437073e-02f, 9.49133467e-03f, -1.76605675e-02f, 1.88919697e-02f, 4.44174744e-02f, 5.04470058e-02f,
  3.71357575e-02f, -6.58524260e-02f, -1.04847260e-01f, 4.20793630e-02f, 4.01356407e-02f, -1.50182247e-02f, 9.45899487e-02f, -3.46002765e-02f, 2.82426681e-02f, 5.49993850e-02f,
  4.41157848e-01f, 1.52177021e-01f, 3.60913515e-01f, 1.06244817e-01f, -2.15734378e-01f, -3.18987578e-01f, -7.30903670e-02f, -1.14898145e-01f, -2.75342017e-01f, 6.93480745e-02f,
  -1.41529858e-01f, 1.53298229e-02f, 4.63919565e-02f, -7.47520179e-02f, -1.54592782e-01f, -1.31370977e-01f, -1.09161511e-01f, -6.26741275e-02f, -9.54420194e-02f, 6.84290379e-02f,
  -6.54385984e-02f, 5.62747456e-02f, 8.87278765e-02f, 7.01438114e-02f, 2.36621723e-01f, 1.76151171e-01f, 1.30102769e-01f, 6.70358688e-02f, 7.15664402e-02f, -5.66676147e-02f,
  -1.47551283e-01f, -1.56490132e-01f, 5.76478466e-02f, -5.51786833e-03f, -1.24243251e-03f, 6.91474378e-02f, 6.26299381e-02f, 9.27499458e-02f, -6.13993965e-02f, -1.40079102e-02f,
  6.06971830e-02f, 2.99573597e-02f, 4.25351560e-02f, 1.97413862e-02f, 1.05613299e-01f, 2.76574008e-02f, 3.49534377e-02f, -8.08164477e-02f, 4.38269638e-02f, -2.32217405e-02f,
  -7.43922964e-02f, 1.27129629e-01f, 6.23884127e-02f, -4.98056896e-02f, 1.36971986e-02f, -6.66821003e-02f, 8.67823511e-03f, -1.36466259e-02f, -1.52401598e-02f, -2.12210044e-02f,
  9.11600441e-02f, 5.52073233e-02f, 1.00357860e-01f, -9.51143540e-03f, 1.07875519e-01f, 7.15678185e-02f, 1.73361246e-02f, 2.05361620e-02f, 4.07774933e-02f, 6.19085692e-02f,
  5.02663627e-02f, 3.52375507e-02f, -3.22781801e-02f, -3.95041630e-02f, -5.52842952e-03f, 5.63935703e-03f, 1.84795819e-02f, -2.35760212e-02f, -6.89009503e-02f, 2.42779544e-03f,
  3.74222547e-02f, 2.69875731e-02f, -1.84844974e-02f, -1.96280628e-02f, -5.59568219e-02f, -9.73082054e-03f, 4.07850668e-02f, 9.02636573e-02f, -1.80678871e-02f, -5.36185363e-03f,
  -1.30022215e-02f, -4.57825698e-02f, 4.17251373e-03f, 9.83403064e-03f, -6.78769797e-02f, 4.32013273e-02f, -6.42058030e-02f, -7.22724828e-04f, 3.38109471e-02f, -4.30646911e-02f,
  7.92134553e-02f, -4.46676947e-02f, 4.03406881e-02f, 5.46385087e-02f, -6.64071813e-02f, -7.71052763e-02f, 9.61817279e-02f, -6.50332794e-02f, -4.49670404e-02f, 8.45418498e-03f,
  1.06004262e-02f, 3.57086360e-02f, 5.54826260e-02f, -2.52286196e-02f, -5.97432740e-02f, 9.68207642e-02f, -2.41110940e-02f, 1.56045454e-02f, -1.85754299e-02f, 6.88923243e-03f,
  3.17038834e-01f, 4.05135244e-01f, 7.06079006e-02f, 9.74111632e-03f, -1.03744455e-01f, -1.27794266e-01f, -1.70158461e-01f, 7.81047717e-02f, -9.80399828e-03f, 2.18799561e-02f,
  -1.71475366e-01f, 1.99323371e-01f, 1.88254625e-01f, -1.86311737e-01f, -1.63013995e-01f, 5.26572913e-02f, -1.06895477e-01f, 3.15305851e-02f, 7.84967393e-02f, 5.38047515e-02f,
  -3.70040769e-03f, -7.03739077e-02f, -8.73887464e-02f, -1.97927244e-02f, -1.83253754e-02f, 4.98235524e-02f, 2.26256903e-02f, -1.67350564e-02f, -1.23133706e-02f, -1.30727693e-01f,
  5.26959673e-02f, 4.81038950e-02f, -3.43390442e-02f, -5.23660481e-02f, 1.45280510e-01f, -1.38734309e-02f, -2.18310356e-02f, -1.10570468e-01f, -4.58350144e-02f, 1.98984593e-02f,
  5.80820516e-02f, 1.86528824e-02f, -2.15140041e-02f, -1.72232017e-02f, 4.80697900e-02f, -4.60726820e-04f, -9.43390094e-03f, -1.39833316e-02f, 1.48651237e-02f, 7.49911815e-02f,
  -6.33775219e-02f, -1.69169456e-02f, 1.88203491e-02f, -5.46181574e-02f, -1.46761546e-02f, -5.40595651e-02f, -1.21153109e-02f, -1.13844231e-01f, 3.84922661e-02f, 6.74783438e-02f,
  -2.54765917e-02f, 4.78436500e-02f, -8.58235359e-02f, 4.39886451e-02f, -1.40846968e-02f, -3.89936467e-05f, -2.28950214e-02f, -4.23490219e-02f, 6.23972118e-02f, 7.03830943e-02f,
  1.27401426e-01f, 6.10153452e-02f, -2.37682648e-02f, 4.17431109e-02f, 8.38051736e-02f, -1.75292920e-02f, 5.46424389e-02f, 8.46348181e-02f, -4.86962236e-02f, -1.58310346e-02f,
  1.66713055e-02f, -1.96374599e-02f, 6.19703308e-02f, 1.77366994e-02f, -1.14528321e-01f, -4.80650291e-02f, 9.07808989e-02f, 8.03243592e-02f, -4.56565693e-02f, -2.00722720e-02f,
  2.70066589e-01f, 3.33045930e-01f, -8.29558522e-02f, 6.28103018e-02f, -5.46542034e-02f, -5.84679246e-02f, -4.27748077e-03f, -4.84246686e-02f, 8.10094699e-02f, -6.99090287e-02f,
  3.43809165e-02f, 1.62826609e-02f, 8.92461762e-02f, -4.50839065e-02f, -6.95632845e-02f, 1.12614650e-02f, 1.01266652e-01f, 4.31302600e-02f, -1.04356911e-02f, 2.53192638e-03f,
  1.77848920e-01f, 5.42382486e-02f, -1.33380955e-02f, -9.90626216e-02f, -4.95800786e-02f, -3.59186009e-02f, -3.13407763e-05f, -7.31307045e-02f, 2.55507398e-02f, 5.72649240e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.98889250e-01f, -6.28138661e-01f, 1.49118125e-01f, 2.64451560e-02f, 3.64012301e-01f, 9.95090529e-02f, 4.56364006e-01f, -2.51594335e-01f, -7.33812749e-02f, -6.09456778e-01f,
  -1.42339021e-02f, -1.37094796e-01f, -9.69826356e-02f, -2.06946597e-01f, 3.61784399e-01f, -1.43911719e-01f, -1.20896146e-01f, -7.92821422e-02f, -8.04820061e-02f, -1.21451445e-01f,
  2.57849544e-01f, -3.97806615e-02f, 1.28049329e-01f, -3.06683183e-01f, 1.21687539e-01f, -6.01080880e-02f, 6.04339279e-02f, 7.26104081e-02f, -1.46676272e-01f, 8.50718468e-02f,
  4.30055261e-02f, -7.50720426e-02f, 1.66990794e-02f, -6.78492412e-02f, 2.06090230e-02f, 1.44602880e-01f, 2.31696591e-02f, 1.48423761e-01f, 1.35491967e-01f, -7.09873661e-02f,
  -1.60485897e-02f, -2.01384053e-02f, 2.84768753e-02f, 2.81816758e-02f, -9.43134800e-02f, -8.69282112e-02f, -6.20819554e-02f, 3.89839001e-02f, -4.92428020e-02f, -1.59070790e-02f,
  4.16223612e-03f, -2.03956831e-02f, 8.14583376e-02f, -1.09755183e-02f, 6.04792908e-02f, 7.06409616e-03f, 1.21056773e-01f, 9.80890989e-02f, 8.67796224e-03f, 3.60145867e-02f,
  -3.80654726e-03f, -2.34785415e-02f, -1.16703417e-02f, -2.79611629e-02f, -1.69834346e-02f, -1.47643043e-02f, -1.18575372e-01f, -4.32674102e-02f, 3.03588877e-03f, -8.51760805e-02f,
  -1.81921981e-02f, -2.65827053e-03f, -7.52421701e-03f, -6.73018619e-02f, 5.02569750e-02f, -1.37427803e-02f, 2.65142955e-02f, -5.33673819e-03f, -1.27703631e-02f, 7.95028824e-03f,
  -4.55133133e-02f, -6.32660389e-02f, 5.66965528e-03f, 3.14716622e-02f, -2.93996427e-02f, 7.03491420e-02f, -4.80226614e-02f, -5.41877151e-02f, -8.38556215e-02f, 4.91455458e-02f,
  -2.34705091e-01f, -6.33285880e-01f, -6.74052387e-02f, 6.72338717e-03f, -6.29319549e-02f, -7.13533536e-02f, -7.72913694e-02f, -8.91040713e-02f, -1.16391890e-01f, 1.53001025e-02f,
  3.93754244e-02f, 7.73369744e-02f, -2.26050820e-02f, 3.08475252e-02f, 2.55780183e-02f, -2.13388074e-03f, -7.27051869e-03f, -9.67209637e-02f, 4.30780984e-02f, -1.25720426e-01f,
  -2.79417858e-02f, -7.11296126e-02f, 8.09004530e-03f, 5.24314083e-02f, 7.84182474e-02f, 4.80295271e-02f, -6.07020557e-02f, -6.00508414e-02f, -9.60518494e-02f, -1.29666282e-02f,
  1.98230222e-01f, -3.54029834e-01f, 1.32618517e-01f, 3.76377493e-01f, 2.34988198e-01f, -6.13050312e-02f, -4.64565605e-02f, -8.33017603e-02f, 1.77017361e-01f, -2.14104369e-01f,
  -1.36493342e-02f, -2.88542479e-01f, -3.05687249e-01f, 1.12373665e-01f, 2.26015836e-01f, -1.75522029e-01f, 1.39467940e-01f, -6.72355071e-02f, 1.16454318e-01f, 1.05911888e-01f,
  2.61649728e-01f, 7.84170479e-02f, 4.28660028e-02f, 2.92388489e-03f, 1.26719326e-01f, 6.20961078e-02f, 1.14737384e-01f, -1.64270848e-01f, -2.93450281e-02f, -1.42924041e-01f,
  -6.34223223e-02f, 5.49048446e-02f, -5.55927195e-02f, 4.37978879e-02f, 6.75155669e-02f, -5.91039695e-02f, -1.27005041e-01f, -2.60530766e-02f, 1.50777042e-01f, 7.05396459e-02f,
  -1.00461155e-01f, 8.99255872e-02f, 8.05328488e-02f, 6.82391878e-03f, 8.93307254e-02f, 2.59303506e-02f, 1.17456064e-01f, 4.77959365e-02f, -3.55622657e-02f, -1.32459728e-03f,
  4.32141200e-02f, 4.02172431e-02f, 1.03522569e-01f, -4.33837548e-02f, 2.86177769e-02f, -2.66252942e-02f, -7.13204890e-02f, -1.53132707e-01f, -7.92971775e-02f, -5.76079451e-02f,
  -1.08904079e-01f, -3.82048525e-02f, -8.21918715e-03f, 1.01280154e-03f, 1.77035015e-02f, 5.64121753e-02f, 4.33235876e-02f, 1.07889501e-02f, 6.70691580e-02f, 2.44434103e-02f,
  2.35707182e-02f, 1.50743118e-02f, 6.64998870e-03f, 6.84533343e-02f, -1.56656709e-02f, 6.41761646e-02f, 6.75071403e-02f, -8.74817669e-02f, 2.93343384e-02f, 2.89602634e-02f,
  4.38671522e-02f, 3.33934054e-02f, -1.96933612e-01f, 3.60364430e-02f, -7.65080657e-03f, -4.02089767e-02f, 9.52442456e-03f, 9.18149541e-04f, 2.95206439e-02f, 3.66390646e-02f,
  -7.20997751e-02f, -1.92897320e-01f, -1.18564554e-01f, -1.67863686e-02f, -8.10950398e-02f, 2.54442487e-02f, 6.51333109e-02f, -2.01083869e-02f, -1.24026937e-02f, -1.86890587e-02f,
  -9.37036797e-02f, 6.58198968e-02f, -1.06391281e-01f, 9.74188279e-03f, -5.64120943e-03f, -2.46006865e-02f, -3.70596759e-02f, -1.06586866e-01f, -4.14163359e-02f, 2.64036655e-02f,
  -1.37385437e-02f, 5.75354025e-02f, -9.28351209e-02f, 1.96526591e-02f, -1.36594679e-02f, -5.63485362e-03f, -4.03642505e-02f, -7.15489909e-02f, 3.79479267e-02f, 2.34464533e-03f,
  9.44905430e-02f, 1.53050363e-01f, 6.31096289e-02f, 2.38843754e-01f, -1.28231496e-01f, -3.10648978e-01f, -2.67472655e-01f, 4.81541865e-02f, -1.61541507e-01f, -3.80913764e-02f,
  1.65126905e-01f, -9.41549242e-02f, 7.81891122e-02f, 5.23019694e-02f, 2.37496626e-02f, -2.25190759e-01f, 6.51184320e-02f, -1.05471015e-01f, -1.60421833e-01f, 1.23796940e-01f,
  1.24702528e-01f, 1.53159246e-01f, 3.01452339e-01f, 3.53745699e-01f, 6.55526519e-02f, 3.77837330e-01f, 4.28548127e-01f, 4.77338918e-02f, 3.18065554e-01f, 5.07059395e-02f,
  -1.35136083e-01f, -1.85595208e-03f, 3.54475947e-03f, -5.69406673e-02f, 1.08474307e-01f, -8.69560838e-02f, -1.01378128e-01f, -5.55781573e-02f, 5.15905917e-02f, 1.96566824e-02f,
  7.10204169e-02f, 2.01154556e-02f, 1.75800081e-02f, 1.66024931e-03f, -6.23411871e-02f, 3.19459569e-03f, -8.29165578e-02f, -2.19370648e-02f, -7.26482198e-02f, 2.78628897e-02f,
  4.19516675e-02f, -1.74226407e-02f, 3.04425750e-02f, -2.64377855e-02f, 9.55234915e-02f, -5.27753085e-02f, -3.94158624e-02f, 1.76597126e-02f, -2.58801971e-02f, 1.11449666e-01f,
  1.53122902e-01f, -7.18914494e-02f, -4.78597134e-02f, -7.95051083e-02f, -8.42683017e-02f, 3.59338857e-02f, -2.07351111e-02f, -3.31080221e-02f, -6.55884370e-02f, -1.04003876e-01f,
  -4.72180173e-02f, 5.55693768e-02f, -6.29033670e-02f, -6.54845759e-02f, -1.32584618e-02f, -1.31180376e-01f, -4.08796780e-02f, -6.18425347e-02f, -3.95578034e-02f, -6.53201714e-02f,
  -1.62548870e-01f, 4.67537233e-04f, -5.77781945e-02f, 2.83546206e-02f, 1.80120710e-02f, 4.49840389e-02f, 8.07345882e-02f, -3.53133827e-02f, 1.53536210e-03f, -1.07945010e-01f,
  7.04320241e-03f, 1.61620542e-01f, -3.81525680e-02f, -5.01026995e-02f, 1.63679142e-02f, -1.42667502e-01f, -8.63466784e-03f, 2.97140349e-02f, 1.16464496e-01f, -2.36839633e-02f,
  1.55598130e-02f, 4.88478988e-02f, -3.92681323e-02f, 5.20999171e-02f, 1.32749423e-01f, -9.25939344e-03f, -6.62219198e-03f, 2.82634459e-02f, 7.30038956e-02f, -3.30456719e-02f,
  2.54950654e-02f, -1.11336313e-01f, -5.06260134e-02f, -5.73919937e-02f, 8.94239396e-02f, 5.84836453e-02f, 6.15677908e-02f, 1.53696761e-01f, 7.08984360e-02f, -1.26481075e-02f,
  3.00843120e-01f, -2.90569574e-01f, 7.57525116e-02f, 7.91474059e-02f, 3.18147466e-02f, -1.76120237e-01f, 1.83246121e-01f, -2.27005363e-01f, -2.35853672e-01f, -2.35997677e-01f,
  1.67441741e-01f, 1.16529360e-01f, 3.10244411e-01f, 4.95068841e-02f, 5.25957763e-01f, 2.44465191e-02f, -9.61488932e-02f, -6.94055185e-02f, -6.85655177e-02f, 7.47824609e-02f,
  8.38292316e-02f, 7.54250586e-02f, 2.18839869e-01f, -6.98814690e-02f, 3.95728350e-02f, 1.55028161e-02f, 8.63138959e-02f, 2.62657225e-01f, -4.20425273e-02f, 4.70526069e-02f,
  -4.84461859e-02f, -1.29380688e-01f, 8.60419795e-02f, -6.11952208e-02f, -1.48546293e-01f, -9.55740083e-03f, 2.31977981e-02f, 2.71001726e-01f, 1.07081980e-01f, -1.45812273e-01f,
  1.31472312e-02f, -2.53749322e-02f, -1.30366012e-01f, 1.20230123e-01f, 1.02576882e-01f, -2.55917944e-02f, -6.86865598e-02f, -6.97568879e-02f, -6.78948760e-02f, 7.44251013e-02f,
  -1.78521720e-03f, -1.86486710e-02f, -2.79265866e-02f, -4.60581370e-02f, 3.88340876e-02f, -6.93434151e-03f, 1.92858372e-02f, 7.32242689e-02f, -8.44237953e-02f, -8.00976604e-02f,
  -4.01210226e-02f, -2.81631923e-03f, -3.58376391e-02f, -2.08902396e-02f, 1.22250384e-02f, -3.53776515e-02f, 7.37053752e-02f, 5.43805808e-02f, 7.06280395e-02f, 1.29569232e-01f,
  9.00992844e-03f, 1.12487487e-01f, 5.14114574e-02f, 5.09158298e-02f, 3.37252655e-04f, 2.34652683e-02f, 9.61108133e-02f, -3.31205688e-02f, -6.78148568e-02f, 7.54349455e-02f,
  9.77726132e-02f, -8.94737616e-02f, 5.43737151e-02f, -4.50271927e-02f, 6.68433905e-02f, 2.88674608e-02f, -9.80392657e-03f, 1.63558368e-02f, -6.89091161e-02f, 8.87869745e-02f,
  2.07286011e-02f, 4.51394077e-03f, -1.19211882e-01f, -2.13530287e-02f, -1.96501110e-02f, -1.67244673e-01f, -1.04433790e-01f, -9.21609849e-02f, -7.20926896e-02f, 3.15150358e-02f,
  -9.27694440e-02f, -9.37980935e-02f, -8.32082331e-02f, 3.52104753e-02f, 1.05976444e-02f, -1.75401852e-01f, 1.98836029e-02f, 4.10224535e-02f, -3.41144986e-02f, 1.17592085e-02f,
  -5.61343990e-02f, -1.10698305e-02f, -2.30755359e-02f, -1.38287529e-01f, -1.10796876e-01f, -7.45752007e-02f, -2.69703679e-02f, -2.51711421e-02f, 4.07160260e-03f, 2.04660874e-02f,
  -1.10583097e-01f, -1.40674427e-01f, -5.46325780e-02f, 9.30476338e-02f, 1.80770710e-01f, -8.19136649e-02f, 3.34106460e-02f, -1.62048966e-01f, 1.47408396e-01f, -3.61751944e-01f,
  -1.78032666e-01f, -6.60272539e-02f, -2.08164126e-01f, -6.91871494e-02f, 3.83636728e-02f, -6.13949522e-02f, -3.36834490e-02f, -1.78382084e-01f, 1.38830602e-01f, -6.35630265e-02f,
  1.63256213e-01f, 7.16769770e-02f, -4.26690020e-02f, 6.27325848e-02f, -1.01092774e-02f, 1.40368110e-02f, 8.52767080e-02f, 8.68751183e-02f, -5.66409305e-02f, 1.19967848e-01f,
  4.19609100e-02f, 7.86816701e-02f, -1.08918242e-01f, -1.90044671e-01f, -2.56432034e-02f, 2.65633110e-02f, -8.45645368e-02f, -2.14259662e-02f, 9.42771137e-03f, -6.45994092e-04f,
  6.98867440e-02f, -8.06618333e-02f, 6.98502436e-02f, 4.15937928e-03f, 9.00825635e-02f, 5.02100438e-02f, 8.21149722e-02f, -7.97908381e-02f, -8.71951655e-02f, -3.79605778e-02f,
  -9.46222320e-02f, 1.00152241e-02f, 3.73320468e-02f, 2.53049321e-02f, -2.65483614e-02f, 4.43580467e-03f, 1.57307703e-02f, -3.62433381e-02f, -4.36130837e-02f, 9.88006312e-03f,
  1.79391026e-01f, 3.74595150e-02f, -4.31524627e-02f, -5.76302633e-02f, -5.65238809e-03f, -3.67950127e-02f, -5.95378652e-02f, -1.26511067e-01f, 6.12881668e-02f, -2.07298212e-02f,
  5.54647809e-03f, -3.60536613e-02f, 5.42027019e-02f, 2.47916046e-06f, 1.95865892e-02f, -3.42717618e-02f, 4.13646474e-02f, -4.01575565e-02f, -2.78841667e-02f, 3.19756791e-02f,
  -6.08465746e-02f, -4.46437672e-02f, -3.07472632e-03f, 9.19295102e-03f, -2.13695429e-02f, -3.82013828e-03f, -8.39073285e-02f, -4.84053418e-02f, -7.14248046e-02f, 7.26681501e-02f,
  -2.88745731e-01f, -9.99534950e-02f, 1.53032318e-01f, 2.53111720e-02f, 8.70606080e-02f, 3.45292389e-02f, 8.36133361e-02f, 5.97314276e-02f, 8.50972310e-02f, -8.48272741e-02f,
  -6.76889718e-02f, -5.40350145e-03f, 4.07448076e-02f, 3.36079150e-02f, 6.77292496e-02f, -6.92408159e-02f, 5.04078381e-02f, -2.54368968e-02f, 4.76513617e-02f, 1.00699060e-01f,
  -1.14819020e-01f, 4.13732778e-04f, -9.81017798e-02f, 1.82093352e-01f, 1.10774472e-01f, -2.04993524e-02f, -3.74989808e-02f, 4.55746278e-02f, 1.11227974e-01f, -3.28541175e-02f,
  -5.82164586e-01f, 3.18361342e-01f, -2.53789220e-02f, -3.01902473e-01f, 2.04051182e-01f, 1.75254010e-02f, -1.49321482e-01f, 1.70018256e-01f, -9.00105760e-02f, -1.22988164e-01f,
  -8.49067792e-02f, -1.00250766e-01f, -4.10556458e-02f, -1.03513964e-01f, -2.19099328e-01f, -1.22586809e-01f, -2.28336424e-01f, -1.82225853e-01f, 1.11089244e-01f, 3.12559423e-03f,
  -6.16687946e-02f, 3.63397561e-02f, -8.11467171e-02f, 3.76413256e-01f, 5.85622415e-02f, 1.79743797e-01f, -1.46381930e-01f, 2.70995259e-01f, -5.80377914e-02f, 7.87185878e-02f,
  2.44716462e-02f, -2.55150765e-01f, -2.15367079e-01f, -8.16570744e-02f, -1.67985082e-01f, -8.37785304e-02f, -4.70583290e-02f, 2.79441644e-02f, -9.98499896e-03f, -3.39620672e-02f,
  1.17421309e-02f, 1.14768729e-01f, -3.84870619e-02f, 8.24359059e-02f, -9.47994515e-02f, -3.01794950e-02f, -4.68105413e-02f, -4.48947027e-02f, -3.34409103e-02f, -3.80000696e-02f,
  3.04950401e-02f, 1.67447422e-02f, -4.94476818e-02f, -1.35369405e-01f, 2.95500457e-02f, -5.21038026e-02f, -1.82694830e-02f, 1.06374122e-01f, -4.63001616e-02f, 1.73184481e-02f,
  2.18384918e-02f, -9.46382210e-02f, 3.17849629e-02f, -1.10910788e-01f, 4.09090631e-02f, 1.44387817e-03f, 6.05478436e-02f, 2.08373237e-02f, 1.10781424e-01f, 7.66409412e-02f,
  3.46513949e-02f, -6.97552264e-02f, 1.15764238e-01f, 2.72255372e-02f, -1.99434217e-02f, -2.71363207e-03f, 1.21125625e-02f, -8.41782801e-03f, -1.37618771e-02f, 7.30429636e-03f,
  -1.46457776e-01f, -7.55453110e-02f, 7.82585051e-03f, 4.15163599e-02f, 1.66151226e-02f, 2.84493081e-02f, 3.58637758e-02f, 6.36228174e-02f, -4.72845845e-02f, -1.05432391e-01f,
  -2.60706544e-01f, -3.27131212e-01f, -7.92948529e-02f, -2.14387067e-02f, -5.94732128e-02f, 3.23870406e-02f, 3.01982462e-02f, -1.06942477e-02f, 7.33587742e-02f, -5.13126180e-02f,
  4.51419689e-02f, -1.28126517e-01f, 6.86796010e-02f, -7.47372629e-03f, -1.98590904e-02f, -8.94838851e-03f, -1.69547468e-01f, -1.43048957e-01f, -8.91169384e-02f, 3.48520018e-02f,
  1.90064553e-02f, -3.66798230e-02f, -3.10342144e-02f, 9.69480723e-02f, -7.78539106e-02f, -6.40204251e-02f, 1.62762776e-01f, -2.68765353e-02f, -8.15382004e-02f, 4.91914637e-02f,
  -3.94597858e-01f, -2.70233378e-02f, -1.90084711e-01f, -2.00670034e-01f, -3.06180239e-01f, -3.65680754e-01f, -1.63407460e-01f, -2.08799779e-01f, -2.03942209e-02f, 2.53271312e-01f,
  1.01730958e-01f, -6.72099665e-02f, 2.24079847e-01f, 3.94850522e-02f, -1.05874166e-02f, 2.15990379e-01f, -8.80689174e-02f, -8.30827747e-03f, -9.29044336e-02f, -2.92203784e-01f,
  -1.71043426e-01f, -6.28402606e-02f, 1.71466824e-02f, -8.62989575e-02f, -1.07627593e-01f, 2.65722945e-02f, 1.10084869e-01f, -1.37047589e-01f, -2.84710224e-03f, 8.62326995e-02f,
  -1.96720958e-01f, -1.92318261e-01f, -1.06762260e-01f, -3.52644995e-02f, -7.84119517e-02f, -2.20306925e-02f, -5.22978753e-02f, -3.91199552e-02f, 1.45742325e-02f, -2.59300787e-02f,
  -1.30123366e-02f, -3.04296110e-02f, -5.13137393e-02f, 1.74417738e-02f, -1.02403514e-01f, -4.13398705e-02f, 8.14309940e-02f, -3.83525230e-02f, 3.44129875e-02f, -1.05341665e-01f,
  3.34165618e-02f, -5.61987003e-03f, -6.56003058e-02f, 1.03125185e-01f, 3.27612646e-02f, 6.06307797e-02f, 6.05654418e-02f, 1.54334237e-03f, -1.30101666e-01f, -5.87623715e-02f,
  4.27467450e-02f, -1.77198444e-02f, -5.11031263e-02f, -4.54714559e-02f, 2.92998906e-02f, 1.11737419e-02f, 2.70780381e-02f, 7.28702769e-02f, 3.26065980e-02f, 6.32352531e-02f,
  9.63434926e-04f, -6.43928424e-02f, 3.52316350e-02f, 1.27392439e-02f, -3.63449790e-02f, -4.92458530e-02f, 3.87276895e-02f, -1.40681595e-03f, 3.23021486e-02f, -5.57850953e-03f,
  -5.67667931e-02f, -3.65171693e-02f, 7.22907484e-02f, 5.43001899e-03f, -1.10209934e-01f, 2.29624156e-02f, -8.90819822e-03f, 5.29174022e-02f, -5.01192398e-02f, -8.51007104e-02f,
  -4.19378608e-01f, -3.90474498e-01f, -3.84402275e-02f, -5.80757968e-02f, 4.33135517e-02f, -6.59217685e-02f, -2.37955712e-02f, -6.60147816e-02f, -8.60402454e-03f, -8.28028321e-02f,
  4.12554368e-02f, 1.72193646e-02f, -6.45138398e-02f, 6.08215760e-03f, 4.03710715e-02f, 4.08047624e-02f, -2.93979272e-02f, -3.21863741e-02f, -9.22785252e-02f, -1.29183248e-01f,
  -7.47497231e-02f, 1.91846602e-02f, 8.25288445e-02f, 3.84058505e-02f, -3.13066691e-02f, 1.19314017e-02f, -1.69521034e-01f, -7.65712410e-02f, 1.16847334e-02f, 1.08822986e-01f,
  -2.99583435e-01f, 2.25885943e-01f, 5.60425855e-02f, -3.87708008e-01f, 1.81810364e-01f, 1.83399138e-03f, -1.14482872e-01f, 2.59993970e-01f, 2.20421571e-02f, -1.47127481e-02f,
  1.25037760e-01f, -1.53353900e-01f, 3.16393465e-01f, -9.80520174e-02f, -1.29663527e-01f, -3.24420147e-02f, -2.11254865e-01f, -1.87064022e-01f, 1.28271773e-01f, -3.24301980e-02f,
  -2.13055104e-01f, -7.64734522e-02f, -1.19424146e-02f, 2.08213732e-01f, 1.36903226e-02f, 3.90300788e-02f, -2.85861921e-02f, 1.96884736e-01f, -2.46476278e-01f, 2.07780063e-01f,
  1.35967121e-01f, -1.91608313e-02f, 8.16674307e-02f, 9.24364030e-02f, -2.67597171e-03f, -7.50966296e-02f, -9.57181305e-02f, 5.46998940e-02f, 3.98001745e-02f, -4.70190644e-02f,
  -3.36697660e-02f, 5.39316796e-02f, 2.70426702e-02f, -8.95912852e-03f, -4.12515216e-02f, 4.25348282e-02f, 3.62755358e-02f, 2.95535754e-02f, 8.11724886e-02f, -6.22787094e-03f,
  -5.71037829e-02f, -2.56898124e-02f, -2.38332897e-01f, -1.14555635e-01f, -1.85049977e-02f, -9.45373327e-02f, -1.35233983e-01f, -1.71679944e-01f, -1.44934580e-01f, 6.37255087e-02f,
  2.92584505e-02f, 7.06911311e-02f, 6.14278056e-02f, 1.63328499e-01f, 4.99313362e-02f, -7.62952445e-03f, -6.90528080e-02f, -2.80913003e-02f, -9.04203653e-02f, -8.55171308e-02f,
  -6.15146533e-02f, 2.33904249e-03f, 1.54261924e-02f, -7.19309673e-02f, 2.02224329e-02f, -2.51394836e-03f, -8.79023820e-02f, -1.15278885e-01f, -1.22107984e-03f, -6.41279072e-02f,
  5.22797406e-02f, -2.91856565e-02f, -2.71876785e-03f, 1.91922840e-02f, 7.35176280e-02f, 4.26853163e-04f, -3.80981453e-02f, -4.40716334e-02f, 7.17944428e-02f, -8.42842646e-03f,
  -1.18002683e-01f, -1.19994273e-02f, 8.06320980e-02f, -2.52729040e-02f, 6.20748252e-02f, -9.60845873e-02f, -3.11261397e-02f, 1.06177695e-01f, 7.07003921e-02f, 9.21401754e-02f,
  -7.42136836e-02f, -1.10704854e-01f, -3.90154980e-02f, -5.70705906e-02f, -1.47125227e-02f, -9.08451970e-04f, -1.00469500e-01f, -5.56736216e-02f, -9.63096097e-02f, 3.08466813e-04f,
  -3.95830721e-02f, -8.93652365e-02f, 5.39136678e-02f, 6.85566440e-02f, -2.09689319e-01f, -1.16221040e-01f, -6.19719503e-03f, -3.63955088e-02f, -1.55833125e-01f, -3.75522040e-02f,
  3.13466191e-01f, -5.25405770e-03f, -2.82547832e-01f, 3.94167304e-02f, 9.72905234e-02f, -3.85222435e-02f, -1.64759591e-01f, 1.81489080e-01f, -2.52389133e-01f, -4.61240560e-02f,
  2.21784770e-01f, -6.18501455e-02f, -2.53834993e-01f, 2.74978369e-01f, 2.94690341e-01f, -2.63735861e-01f, 3.05074334e-01f, 1.11100897e-01f, -1.32184908e-01f, 1.81505650e-01f,
  -5.33882529e-02f, 4.71298456e-01f, 2.80965418e-02f, 2.41823778e-01f, 1.19954966e-01f, -1.29060403e-01f, 2.81691432e-01f, -1.50901124e-01f, 3.08869809e-01f, 1.07935697e-01f,
  1.09769851e-02f, -2.69197451e-04f, -7.88871348e-02f, -6.32450953e-02f, -1.93486996e-02f, 5.38993105e-02f, -6.75940141e-02f, -5.81399016e-02f, 1.72163080e-02f, -6.96140155e-02f,
  -1.24054499e-01f, 8.79425742e-03f, 5.59132453e-03f, -8.67728069e-02f, 2.78969761e-02f, 5.64319193e-02f, 1.61949806e-02f, -1.23798777e-03f, -2.01388523e-02f, 3.91323194e-02f,
  -3.20362784e-02f, -3.59002315e-02f, -7.05502322e-03f, -6.01994991e-02f, -1.01158530e-01f, -2.48060580e-02f, -2.77682282e-02f, -2.71441583e-02f, -9.80568081e-02f, -3.89818363e-02f,
  4.75104749e-02f, -2.77985819e-02f, 1.12062516e-02f, 2.84377858e-03f, 6.85382932e-02f, -5.44328056e-02f, 2.21785195e-02f, -3.86962630e-02f, -9.37680900e-02f, 6.55945167e-02f,
  7.10512884e-03f, -3.36078405e-02f, 4.60061133e-02f, 4.08568494e-02f, -2.48698108e-02f, 1.60046332e-02f, -5.06598353e-02f, 3.24670710e-02f, -4.23565507e-02f, 7.11569712e-02f,
  -2.68981364e-02f, 5.41970246e-02f, -2.22049970e-02f, -1.20496573e-02f, -9.15842876e-03f, 2.56115105e-02f, 6.67879060e-02f, 1.07008919e-01f, -4.50365841e-02f, -2.13361066e-03f,
  4.87191938e-02f, 1.18862785e-01f, -6.06227331e-02f, 3.42224985e-02f, -5.85274585e-02f, 4.80606928e-02f, 8.41328874e-02f, 7.94540495e-02f, 2.35944167e-02f, 6.05877191e-02f,
  6.65535182e-02f, 6.72205761e-02f, 1.97321642e-02f, 5.09983972e-02f, 4.95946966e-03f, -4.58923448e-03f, -4.14899401e-02f, -6.43268153e-02f, 2.46916935e-02f, 1.25034764e-01f,
  8.62397328e-02f, 8.71577412e-02f, -5.83980456e-02f, -7.52683058e-02f, 4.30553071e-02f, -4.00407091e-02f, -4.75759432e-02f, -4.93042506e-02f, 9.64237973e-02f, -8.63123387e-02f,
  -2.28587940e-01f, -1.76316246e-01f, -2.75780916e-01f, 4.44724597e-02f, 1.54536679e-01f, -5.75674511e-02f, -2.09313482e-01f, 1.18438415e-01f, -2.64983416e-01f, 6.04513884e-02f,
  7.03517571e-02f, -1.36776730e-01f, -1.01757362e-01f, -1.27351329e-01f, -1.33944869e-01f, -4.40610945e-01f, 8.61423090e-02f, -2.11094156e-01f, -2.49263525e-01f, 4.18500714e-02f,
  -1.90676411e-03f, 1.28153160e-01f, -1.54847771e-01f, 1.62138477e-01f, 9.55090392e-03f, 2.50307947e-01f, 2.25575745e-01f, 1.22326665e-01f, 2.66952604e-01f, 1.09624073e-01f,
  -1.27912208e-01f, -1.46966055e-01f, 1.01561643e-01f, -2.81816497e-02f, 5.97099960e-02f, 2.12842211e-01f, 1.07657120e-01f, 6.57761842e-02f, 3.46448421e-02f, -7.06490278e-02f,
  7.86679424e-03f, -5.58493659e-03f, 8.11411589e-02f, 5.15140332e-02f, -7.11628273e-02f, 2.45742574e-02f, -7.70041123e-02f, 2.68276054e-02f, -1.43332869e-01f, -6.61576912e-02f,
  -1.13639966e-01f, 2.41285143e-03f, 7.60012046e-02f, 1.72703832e-01f, -3.46148908e-02f, 5.24298623e-02f, 3.38307931e-03f, 2.07934231e-02f, 9.70995203e-02f, -3.69407609e-02f,
  6.67648613e-02f, 4.83875871e-02f, -1.24725930e-01f, -4.56422195e-02f, -8.85195583e-02f, -4.10752296e-02f, -4.99747135e-02f, 5.74599542e-02f, 1.20909318e-01f, 9.87352803e-02f,
  4.90449183e-02f, -4.84322384e-02f, 1.02433234e-01f, -1.60152972e-01f, -4.19026949e-02f, -9.27212387e-02f, 1.08420104e-02f, 8.03971142e-02f, -4.23919335e-02f, -5.06534837e-02f,
  5.76328337e-02f, -1.60711203e-02f, -6.24969527e-02f, 5.93277775e-02f, 3.88348401e-02f, 5.03798462e-02f, -4.46234494e-02f, -5.55511191e-02f, -4.15202454e-02f, 1.58616062e-02f,
  9.95128527e-02f, 1.61310405e-01f, 5.98393343e-02f, -4.24208306e-02f, 1.18246693e-02f, 3.86026572e-03f, -1.45517522e-02f, -7.64717162e-02f, 4.53571491e-02f, 7.98276626e-03f,
  5.57036363e-02f, 1.39191002e-01f, 1.59365207e-01f, -2.56694965e-02f, 5.46969809e-02f, -5.64630888e-02f, -4.52398583e-02f, 1.39097914e-01f, 1.88487083e-01f, -4.56150211e-02f,
  7.43697062e-02f, -4.17428762e-02f, 1.55807853e-01f, 5.23043796e-02f, 3.06404363e-02f, 9.59999487e-02f, 5.47904111e-02f, -1.47496397e-02f, -6.57659322e-02f, 5.79442754e-02f,
  -3.18687946e-01f, -4.16069999e-02f, -3.02258044e-01f, -2.40300477e-01f, -2.00766444e-01f, -2.92215258e-01f, -3.34038377e-01f, -1.47184268e-01f, -1.42634034e-01f, -3.09011992e-02f,
  -1.78014010e-01f, 8.81421715e-02f, 1.64322227e-01f, -1.83367983e-01f, 1.14961974e-01f, 3.68147671e-01f, -1.48077294e-01f, -1.53774977e-01f, 9.86291915e-02f, -1.09853975e-01f,
  2.24037468e-02f, 3.88507242e-03f, 1.67366579e-01f, -6.51356578e-02f, -2.28237152e-01f, -1.10365942e-01f, 4.77046818e-02f, -7.09381998e-02f, -2.83292532e-02f, -1.39111176e-01f,
  -6.22189566e-02f, -1.65846214e-01f, -1.10122398e-01f, -6.58564270e-02f, -1.21755973e-01f, -8.23737532e-02f, 1.68874878e-02f, -5.36076091e-02f, -3.76879014e-02f, -6.00347258e-02f,
  -3.69376801e-02f, 2.77925958e-03f, -5.31305373e-02f, 5.97048290e-02f, -3.94705012e-02f, -4.91870716e-02f, -3.09013706e-02f, -6.27664430e-03f, 3.06365918e-03f, 8.71967748e-02f,
  -5.90342060e-02f, 1.94886215e-02f, 3.97552699e-02f, 4.19593789e-03f, -2.51268242e-02f, -1.69090610e-02f, 1.18854292e-01f, 5.68339489e-02f, 1.69151109e-02f, -4.12273705e-02f,
  7.81133100e-02f, -1.54662384e-02f, -8.33677202e-02f, -9.83684076e-05f, -8.45543519e-02f, -3.44259106e-02f, -2.21417788e-02f, -9.01669078e-03f, -5.67847900e-02f, -5.03831496e-03f,
  8.49949494e-02f, 3.79151665e-02f, 6.59163157e-03f, -4.38059270e-02f, -1.15526237e-01f, -1.30941421e-02f, 1.27464104e-02f, -8.17655772e-02f, -2.05739103e-02f, 1.89540423e-02f,
  3.86054367e-02f, -4.26259916e-03f, 2.60915067e-02f, 2.98585016e-02f, -2.51051765e-02f, 8.87662992e-02f, 4.56593111e-02f, 4.60873023e-02f, -5.62642664e-02f, -2.91011352e-02f,
  -1.93660676e-01f, -3.40260476e-01f, -3.20123546e-02f, -7.24343210e-02f, 9.01752636e-02f, 2.98139658e-02f, 7.36597031e-02f, -4.91766557e-02f, -6.64286017e-02f, -7.61229172e-02f,
  -1.74814835e-02f, -7.90991541e-03f, -5.51957521e-04f, -2.78255111e-03f, 1.18194118e-01f, 2.61257440e-02f, -2.80865300e-02f, -4.07032482e-02f, -8.02900940e-02f, 1.57767441e-02f,
  5.55835329e-02f, -2.27654520e-02f, 2.42513623e-02f, 1.27035063e-02f, 5.35398088e-02f, -5.96743412e-02f, -2.77682338e-02f, 5.58286645e-02f, -1.22417629e-01f, -3.18238065e-02f,
  2.07076564e-01f, -2.34713331e-02f, -9.25275236e-02f, 2.16231644e-01f, 2.73332484e-02f, -4.86739948e-02f, -1.82989717e-01f, 1.51978806e-01f, -3.51127982e-02f, -2.59059399e-01f,
  1.51129827e-01f, -2.28272062e-02f, -2.49146521e-01f, 2.90626913e-01f, 3.88333350e-01f, -2.10242942e-02f, 3.50710273e-01f, -4.47526388e-02f, -8.54921937e-02f, 1.88336253e-01f,
  2.11545780e-01f, 3.81799430e-01f, 8.19634795e-02f, 7.52473250e-02f, 9.01785046e-02f, 3.31481509e-02f, 1.07280031e-01f, -2.13557839e-01f, 3.28964114e-01f, 3.83673310e-02f,
  1.23122735e-02f, 6.18353598e-02f, 7.60906711e-02f, 3.84192467e-02f, -3.10495170e-03f, -5.37650995e-02f, -1.26223594e-01f, -7.02053383e-02f, -5.29780313e-02f, -9.99960080e-02f,
  -7.87276700e-02f, -2.98279859e-02f, 3.95361371e-02f, -1.88124850e-02f, -1.67983193e-02f, -7.01598031e-03f, 5.58821193e-04f, 1.09524354e-02f, -5.67199737e-02f, 2.36564428e-02f,
  -6.00324236e-02f, 5.31305820e-02f, 4.64950874e-02f, 1.30501268e-02f, 9.84730422e-02f, 6.65807277e-02f, -9.99056175e-02f, -5.67414053e-02f, -5.50865429e-03f, 7.07289129e-02f,
  2.80421376e-02f, -3.32638212e-02f, 2.71662362e-02f, -6.84083160e-03f, 4.20333035e-02f, 1.12452947e-01f, 3.99033166e-02f, -8.58295038e-02f, -5.42836823e-02f, 7.14200288e-02f,
  6.93462510e-03f, -3.62237580e-02f, 4.18221607e-04f, 1.76990554e-02f, 8.09457451e-02f, -5.91837429e-02f, 7.58201256e-03f, 6.44706413e-02f, -3.83308195e-02f, 6.72927946e-02f,
  -1.08805329e-01f, 1.11806626e-02f, 2.96202060e-02f, -8.13965350e-02f, 7.66680576e-03f, -8.58904794e-02f, 5.28732017e-02f, 5.92604838e-03f, 1.46424416e-02f, -8.87313485e-03f,
  -4.67676334e-02f, 1.27244160e-01f, -4.03848253e-02f, 4.00521122e-02f, -7.32681975e-02f, 5.01166768e-02f, -1.32761672e-02f, 6.22533113e-02f, -1.00426555e-01f, 3.64231202e-03f,
  -4.95246463e-02f, -4.87811863e-02f, 2.99653988e-02f, 4.61941324e-02f, 7.23700300e-02f, 8.51966813e-02f, -1.60375889e-02f, -4.71855626e-02f, 5.33578044e-04f, 9.23474729e-02f,
  -1.19557984e-01f, -2.68919356e-02f, -9.29867700e-02f, 4.90739979e-02f, 7.66433962e-03f, -3.09581049e-02f, 3.52146626e-02f, -2.66362843e-03f, -2.83239484e-02f, 1.14198253e-02f,
  2.12864056e-02f, -3.33690256e-01f, -4.04112756e-01f, -4.40542519e-01f, 2.23910715e-02f, -3.47520590e-01f, -3.58240485e-01f, -1.82384793e-02f, -1.70826778e-01f, 2.78647721e-01f,
  3.94602045e-02f, -8.51219445e-02f, -3.86658427e-03f, -3.73481065e-01f, -2.61649072e-01f, -1.34347752e-01f, -4.84457821e-01f, -1.30891353e-01f, -3.22305635e-02f, 1.49674015e-02f,
  -2.05931693e-01f, -2.18081668e-01f, -4.50327635e-01f, 2.83220317e-02f, -2.72376120e-01f, 1.07378431e-01f, 3.80336642e-01f, -8.64422470e-02f, -8.79898444e-02f, -4.83822562e-02f,
  -1.07604660e-01f, 2.23256648e-02f, -2.17940062e-02f, -4.71932590e-02f, -3.62884328e-02f, -1.04107223e-02f, -5.94389215e-02f, -5.60694896e-02f, 3.81528735e-02f, 1.72838233e-02f,
  4.75924388e-02f, -3.25433956e-03f, -7.52616748e-02f, 2.50176061e-02f, -5.28001562e-02f, -5.72363175e-02f, -1.03242852e-01f, 1.17815295e-02f, -1.08507156e-01f, -1.90919608e-01f,
  -2.20266432e-01f, -1.23217665e-01f, 4.67517972e-03f, -8.30785930e-03f, -1.17177151e-01f, 2.70932186e-02f, -3.98637317e-02f, 5.62976822e-02f, -3.71940210e-02f, 2.87434086e-03f,
  -1.72415115e-02f, 7.02814013e-02f, -5.96373640e-02f, -6.81821536e-03f, -6.05299994e-02f, -8.38393271e-02f, -4.30301689e-02f, 8.48449320e-02f, -2.62321178e-02f, -1.00793794e-03f,
  -1.63748562e-02f, -3.63132209e-02f, 4.34317924e-02f, 8.13271105e-03f, -6.38295487e-02f, 2.40213163e-02f, 3.01288944e-02f, 3.63339148e-02f, -1.57269314e-01f, -7.22114295e-02f,
  1.54376158e-03f, -6.68413416e-02f, -2.09149681e-02f, -1.29168686e-02f, -1.05493173e-01f, 1.61950812e-02f, 4.89558317e-02f, -1.70070101e-02f, -6.02436326e-02f, 2.57585496e-02f,
  3.77746113e-02f, 1.80521771e-01f, 2.61804438e-03f, 1.63837653e-02f, 3.69635671e-02f, 7.99207240e-02f, -9.61322114e-02f, -9.82639045e-02f, 3.76477391e-02f, 4.18241601e-03f,
  2.20469665e-02f, 6.33796528e-02f, 9.55909714e-02f, 2.92621497e-02f, 7.19346702e-02f, 1.60417240e-02f, -3.55745032e-02f, 7.51120597e-02f, -6.25259010e-03f, -4.89135496e-02f,
  8.48655105e-02f, 2.00384960e-01f, 7.24828616e-02f, -1.53584145e-02f, 3.45758684e-02f, 2.62962654e-02f, 6.42913207e-02f, -9.92605928e-03f, 5.63123524e-02f, 3.02182185e-03f,
  2.94931829e-01f, 4.92269099e-02f, -3.07523936e-01f, -1.27600595e-01f, -2.50836164e-02f, 4.25226897e-01f, 3.08608383e-01f, -6.45864829e-02f, -6.90444112e-02f, 2.09481865e-01f,
  2.89421737e-01f, -9.00560915e-02f, 6.74668103e-02f, 4.66015249e-01f, 2.37209320e-01f, 1.27929509e-01f, 2.93000132e-01f, 2.77866513e-01f, -7.64276087e-02f, 1.20066047e-01f,
  -6.46729991e-02f, 4.07960504e-01f, -1.53573468e-01f, 7.07873479e-02f, 6.22262806e-02f, -3.12070072e-01f, 1.97774302e-02f, -1.74551070e-01f, 1.89333498e-01f, 1.66441556e-02f,
  1.92370608e-01f, -1.34362146e-01f, -1.25637427e-01f, -6.07006922e-02f, 5.53756729e-02f, -1.24586811e-02f, -8.00349712e-02f, -1.39285680e-02f, -7.18540251e-02f, -1.00686938e-01f,
  6.92670345e-02f, -7.01393113e-02f, 1.21619634e-01f, 1.65831670e-03f, 5.77034242e-03f, -1.03142001e-02f, -4.07939330e-02f, -7.74028897e-02f, -3.09296492e-02f, -6.60229251e-02f,
  -1.39749557e-01f, -1.17848963e-01f, -6.88633472e-02f, 8.21905304e-03f, -1.18024722e-01f, -9.18793976e-02f, -1.57622501e-01f, -5.15883304e-02f, -9.10222232e-02f, -3.66315581e-02f,
  1.24938548e-01f, 2.69894302e-03f, -5.04500978e-03f, 1.30898967e-01f, 9.77704376e-02f, -7.37639889e-02f, 8.39838460e-02f, -4.85527553e-02f, 4.49731946e-02f, 7.24623874e-02f,
  6.38359832e-03f, -8.51710662e-02f, 5.05645536e-02f, -7.30640721e-04f, -3.14530842e-02f, -1.14712141e-01f, 5.50710894e-02f, -5.41469418e-02f, -6.95236633e-03f, 2.67373566e-02f,
  7.16637447e-02f, 3.52911279e-02f, 1.28299758e-01f, 6.66589215e-02f, 3.61948758e-02f, -6.71905372e-03f, 3.05600539e-02f, 9.94301215e-03f, -1.68745909e-02f, -5.42778745e-02f,
  2.79684097e-01f, 4.87606414e-02f, -8.16226676e-02f, 1.08343698e-01f, 9.86185949e-03f, 9.78715643e-02f, 2.66059712e-02f, -3.85402446e-03f, 6.49653375e-02f, 9.24555659e-02f,
  -2.11565346e-02f, -3.93664949e-02f, -7.56838918e-02f, 2.45462973e-02f, -4.59077433e-02f, 8.71150717e-02f, 2.14494001e-02f, 1.99476331e-02f, -1.33471936e-01f, -2.42835246e-02f,
  3.58492769e-02f, -3.23566049e-02f, -3.27009968e-02f, -1.28911585e-01f, -1.47918565e-02f, -3.47612351e-02f, -3.42069343e-02f, -1.29916310e-01f, 1.30907437e-02f, 4.33900990e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.01997089e-02f, -3.19908150e-02f, -1.16265774e-01f, -5.64745925e-02f, 5.00711612e-03f, 1.00566261e-01f, -1.22016147e-02f, -9.54086185e-02f, -1.33850619e-01f, 1.08691277e-02f,
  -1.41129941e-01f, -7.38070384e-02f, 1.73744962e-01f, 2.36767486e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  4.36317101e-02f, -9.01275128e-02f, 1.16591349e-01f, -1.59718618e-02f, -1.38822421e-01f, -1.08926572e-01f, 1.67920813e-01f, 2.87629850e-02f, 7.27884993e-02f, 7.05450550e-02f,
  2.36226335e-01f, 3.89025062e-01f, 2.40679592e-01f, -1.08231306e-01f, -9.38122123e-02f, 3.68490428e-01f, 3.46724421e-01f, 2.24817306e-01f, -4.87816870e-01f, -2.19035849e-01f,
  2.70676792e-01f, -7.86459520e-02f, -1.02081232e-01f, -1.19907267e-01f, 1.48922637e-01f, -7.51677603e-02f, -1.27317846e-01f, 6.48785084e-02f, -1.31001584e-02f, -1.93381533e-02f,
  3.63399416e-01f, -2.16061354e-01f, -2.32299976e-02f, -8.76164660e-02f, -3.12932841e-02f, 2.40288913e-01f, 7.02192560e-02f, -7.25772902e-02f, -2.99227118e-01f, -7.51071125e-02f,
  -1.84721947e-01f, 2.44715944e-01f, 1.77333936e-01f, -1.03247531e-01f, -1.87890500e-01f, -1.17048115e-01f, 1.50967926e-01f, -3.44696757e-03f, -1.46659628e-01f, -8.37192312e-02f,
  1.32099509e-01f, -9.43255648e-02f, -2.70662606e-01f, 8.31639245e-02f, -2.96103563e-02f, -2.51162410e-01f, 2.97564954e-01f, -2.51242191e-01f, 2.35570706e-02f, -1.69136420e-01f,
  3.48570049e-02f, -1.87419862e-01f, -2.21470298e-04f, 9.40754265e-02f, 9.04825553e-02f, 1.39174715e-01f, 2.49285609e-01f, -7.67590702e-02f, 3.17874640e-01f, -1.47343174e-01f,
  5.19602858e-02f, -2.17758238e-01f, 1.02946006e-01f, 2.04350665e-01f, 1.07800014e-01f, -2.16648117e-01f, -1.97654217e-01f, 7.08561763e-02f, 9.42375138e-02f, 1.47124812e-01f,
  2.42015153e-01f, 1.16962813e-01f, 1.32093921e-01f, -2.13857159e-01f, 9.64888334e-02f, 2.34236047e-01f, 7.83736818e-03f, -4.41203326e-01f, 2.75578737e-01f, -4.87738959e-02f,
  -8.69407952e-02f, -3.72262508e-01f, 9.41151455e-02f, -2.17432037e-01f, -1.27341181e-01f, -1.80664174e-05f, -3.09606075e-01f, -1.33790955e-01f, -1.12588331e-01f, -2.22814009e-01f,
  6.03887886e-02f, 1.42398521e-01f, -1.32649556e-01f, 2.24654898e-01f, 6.88609779e-02f, 5.00094518e-02f, -1.30748600e-01f, -3.07508439e-01f, 2.28012279e-02f, -3.47304344e-01f,
  -2.19288617e-01f, -2.76144534e-01f, -1.31482720e-01f, -2.60222435e-01f, 4.62304503e-01f, 1.82063833e-01f, -1.45825714e-01f, 1.74916446e-01f, 3.54841560e-01f, -8.69033635e-02f,
  5.36341190e-01f, 2.29241744e-01f, -2.29133889e-01f, -1.33155525e-01f, 1.52670741e-01f, -1.47947580e-01f, -2.08055779e-01f, 7.22697377e-02f, 1.77705675e-01f, 2.62390729e-02f,
  -7.97147080e-02f, 2.45400481e-02f, -1.93192288e-01f, -4.48464304e-02f, 1.93736568e-01f, -1.47071369e-02f, 1.32806808e-01f, 1.74793750e-01f, 2.29868427e-01f, -1.38696522e-01f,
  -3.93813193e-01f, -3.09232295e-01f, -1.06690653e-01f, 9.71337333e-02f, -6.82825521e-02f, -2.63568219e-02f, -4.02516693e-01f, -2.52843350e-01f, -1.99967369e-01f, -2.01362893e-01f,
  1.49743542e-01f, 1.35630518e-01f, 6.97628409e-02f, 1.19082168e-01f, -2.41836503e-01f, 1.35926366e-01f, 8.45458806e-02f, -1.75162867e-01f, 3.84750426e-01f, -3.28310937e-01f,
  -2.25020438e-01f, -2.06145301e-01f, -2.42520764e-01f, -4.15663421e-02f, 9.36325565e-02f, 8.13981816e-02f, 6.83766752e-02f, 2.67113954e-01f, -2.87396133e-01f, -5.58658689e-02f,
  4.11424078e-02f, -1.04095876e-01f, -3.30402739e-02f, -4.13003594e-01f, -1.36962250e-01f, -2.68173546e-01f, -2.05186456e-01f, -4.11401600e-01f, 8.50732923e-02f, 9.24887732e-02f,
  -1.24572136e-01f, -7.69495964e-02f, 1.71353355e-01f, 2.04860643e-01f, 3.42875123e-01f, 2.49493957e-01f, 1.02014109e-01f, -1.57398298e-01f, 2.26738751e-01f, 1.51284814e-01f,
  -1.13441706e-01f, -2.45393254e-02f, -9.45198312e-02f, 9.41455588e-02f, -1.73055008e-02f, -1.65092051e-01f, 8.04430395e-02f, -1.08133657e-02f, 1.07422866e-01f, 1.75752908e-01f,
  1.12071047e-02f, 2.94126440e-02f, 1.80387288e-01f, -8.73521194e-02f, -1.67621821e-01f, -6.12236559e-01f, -2.93127209e-01f, -2.77832866e-01f, 1.04801744e-01f, -1.14621393e-01f,
  4.19504285e-01f, 3.45666349e-01f, 1.60424873e-01f, 2.40927279e-01f, 2.36325309e-01f, -1.14098296e-01f, 3.41418207e-01f, 2.20554322e-01f, -1.83109611e-01f, -6.97814524e-02f,
  1.51912898e-01f, 1.97280645e-01f, -6.73040897e-02f, -4.02252585e-01f, 2.96282679e-01f, -1.59407347e-01f, -4.93259318e-02f, 5.46532571e-02f, 3.40355188e-02f, 1.67634547e-01f,
  -1.75177991e-01f, 1.76608652e-01f, -1.41734201e-02f, 1.78508550e-01f, -4.96755205e-02f, -1.14503093e-01f, -1.34858266e-01f, 3.36382419e-01f, 2.46708572e-01f, 9.63325277e-02f,
  8.53974968e-02f, -1.73310116e-01f, -1.57157049e-01f, -1.52456880e-01f, -1.86893001e-01f, 1.52908206e-01f, -4.75642905e-02f, -2.16237217e-01f, 2.67578159e-02f, -4.28250879e-02f,
  -1.18903600e-01f, -1.15508616e-01f, 8.60082433e-02f, -2.24464223e-01f, 1.51477084e-01f, 3.28916997e-01f, 9.82401296e-02f, -2.57454693e-01f, 4.94683459e-02f, -1.39976025e-01f,
  9.52614769e-02f, 1.94090661e-02f, 6.35158494e-02f, -2.36953259e-01f, 2.20324442e-01f, -1.99196056e-01f, -2.54064381e-01f, -1.61730036e-01f, 6.01563342e-02f, 2.66238153e-01f,
  2.24425182e-01f, 1.31297469e-01f, -3.79154645e-02f, 3.15414935e-01f, -4.81975645e-01f, -1.49619222e-01f, -1.56397298e-01f, -2.96769023e-01f, 5.31221852e-02f, -3.04578394e-01f,
  7.26054907e-02f, -2.03685626e-01f, 1.36950323e-02f, -2.64578551e-01f, 3.90071690e-01f, 1.40894800e-01f, -2.73187868e-02f, 1.50496796e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.66669145e-01f, 1.91968367e-01f, 2.24302605e-01f, 3.98171581e-02f, 4.01482970e-01f, 2.55982041e-01f, 1.46624446e-01f, 2.34446749e-01f, 1.41115367e-01f, 2.36879334e-01f,
  -1.30794570e-01f, -1.56620100e-01f, -1.49070621e-01f, -3.58927280e-01f, -1.62071303e-01f, 9.42988321e-02f, 2.26641104e-01f, -2.54753828e-01f, 2.00286165e-01f, -2.25863934e-01f,
  -1.19070031e-01f, 2.70943642e-01f, -1.37437925e-01f, 5.32161482e-02f, 2.69146889e-01f, -1.87970459e-01f, 6.42243307e-03f, -1.25468329e-01f, -7.72190765e-02f, -2.13051528e-01f,
  -4.19723749e-01f, 2.26522177e-01f, 1.10627957e-01f, -6.32608384e-02f, 2.02556968e-01f, 2.15803087e-01f, 2.69402057e-01f, 1.11898892e-01f, 1.52363285e-01f, 1.26203328e-01f,
  1.42065838e-01f, 9.51785967e-02f, 2.01626495e-01f, -1.97455630e-01f, -2.36475974e-01f, -1.89250976e-01f, 2.13025987e-01f, 7.89986625e-02f, -1.44170165e-01f, -2.70188332e-01f,
  4.46400970e-01f, 2.09037304e-01f, -1.10096626e-01f, 3.35948348e-01f, 7.95307457e-02f, -2.99830407e-01f, 4.30999190e-01f, -1.23979755e-01f, -4.00167167e-01f, -3.24088424e-01f,
  2.87145138e-01f, -2.22322926e-01f, -3.54366601e-02f, -1.44759282e-01f, -1.17466770e-01f, 1.69458508e-01f, 1.15961157e-01f, 3.35703731e-01f, 5.80095053e-02f, 1.24048702e-01f,
  1.55516535e-01f, 3.27744335e-01f, 1.83133915e-01f, 2.74146460e-02f, 2.34525681e-01f, 1.61451697e-01f, 7.53068179e-02f, 1.26637951e-01f, 5.38338050e-02f, -3.39432880e-02f,
  -1.42159522e-01f, -2.38291442e-01f, 3.50427598e-01f, 1.66065991e-01f, -1.14426315e-01f, -2.22555585e-02f, 6.74752751e-03f, 2.07442030e-01f, 1.47350468e-02f, 3.80638391e-02f,
  -1.63872674e-01f, 2.22925335e-01f, 1.40898675e-01f, -2.84303486e-01f, 2.86464721e-01f, -2.27894813e-01f, -1.32158697e-01f, 2.73167819e-01f, -4.85853478e-03f, -5.92429154e-02f,
  -8.99126101e-03f, 2.38499776e-01f, 6.30174130e-02f, 2.43823454e-01f, 8.38544685e-03f, 4.03717645e-02f, 6.48900121e-03f, 4.58763912e-02f, 2.59610474e-01f, -3.86600673e-01f,
  -2.35643938e-01f, -1.52413711e-01f, -1.64843321e-01f, -2.68484831e-01f, 2.97241777e-01f, 4.33302701e-01f, 2.61527777e-01f, -9.06089991e-02f, 1.11125916e-01f, 4.93799061e-01f,
  1.77476570e-01f, 1.80854738e-01f, 5.74514195e-02f, 3.24996978e-01f, -6.56374097e-02f, 8.49113092e-02f, 1.63594559e-02f, -1.97234198e-01f, 5.43550104e-02f, -1.41082659e-01f,
  -2.07540110e-01f, 2.84450483e-02f, 1.04430921e-01f, 3.04539930e-02f, 1.28102213e-01f, 1.52673051e-01f, 2.01398328e-01f, -1.29867584e-01f, 2.15327546e-01f, 8.11458603e-02f,
  8.94820318e-02f, -3.57439280e-01f, -1.60843208e-01f, -1.57290593e-01f, -1.77287340e-01f, -1.28855526e-01f, 9.92328227e-02f, 2.47155160e-01f, -1.45208329e-01f, -2.54123122e-01f,
  2.64064282e-01f, 1.40880227e-01f, 2.31371269e-01f, 4.79040593e-01f, 2.22028457e-02f, 5.83781339e-02f, 3.69336993e-01f, -5.02997376e-02f, 2.93469220e-01f, -4.16673273e-02f,
  1.01121776e-01f, 3.81820261e-01f, 8.18480328e-02f, 2.44906738e-01f, 1.80343387e-03f, 2.91850865e-02f, 2.10756198e-01f, 4.27867100e-02f, 1.14365414e-01f, -3.12811226e-01f,
  1.47883501e-02f, 1.73305646e-01f, 4.14024770e-01f, 2.23383352e-01f, -4.26325463e-02f, -5.84510304e-02f, 3.02078985e-02f, -4.48905751e-02f, 1.37077317e-01f, 3.15250516e-01f,
  1.61007628e-01f, -1.43494070e-01f, 1.65292859e-01f, 5.68605304e-01f, -1.02306366e-01f, 1.53055191e-01f, 1.93572775e-01f, 2.22267479e-01f, -1.37299269e-01f, 1.15285300e-01f,
  -2.43426055e-01f, -1.92341909e-01f, 1.01705715e-01f, 1.41853929e-01f, 7.72422105e-02f, 1.21004097e-01f, 1.78891167e-01f, 7.92591274e-02f, 3.50331306e-01f, -7.74664879e-02f,
  2.36299053e-01f, 4.17080857e-02f, -3.50666046e-01f, -3.95868808e-01f, -1.54839791e-02f, -2.22331822e-01f, 2.57995781e-02f, -3.35783213e-01f, -5.18928051e-01f, -2.24971324e-01f,
  -1.87743381e-01f, -2.73160368e-01f, -1.61355417e-02f, -2.86234200e-01f, -4.02392558e-04f, 2.37588659e-02f, 9.92773622e-02f, 4.68937382e-02f, 3.45694125e-02f, 1.12373158e-01f,
  1.37478486e-01f, 2.06155907e-02f, -4.91656750e-01f, 2.39188164e-01f, 2.32227802e-01f, -9.65521932e-02f, 1.42685696e-01f, 3.53102349e-02f, 1.62331179e-01f, 3.62317562e-01f,
  -2.11752113e-02f, 8.07125121e-02f, 3.87346774e-01f, -1.65860891e-01f, -1.15023553e-01f, -1.67136580e-01f, 1.25888353e-02f, 1.85779154e-01f, 4.17409778e-01f, 9.43081602e-02f,
  -2.01986790e-01f, -6.87916875e-02f, 3.55780423e-01f, 8.47005006e-03f, -9.35821608e-02f, 2.41916887e-02f, 6.06986806e-02f, -6.53320327e-02f, -4.85343263e-02f, 1.22782975e-01f,
  -5.84055036e-02f, 7.92068541e-02f, 3.09926480e-01f, -1.22202210e-01f, 2.44090393e-01f, 1.81146517e-01f, 2.41851643e-01f, 9.39954296e-02f, 1.62651628e-01f, -2.51447856e-02f,
  -1.27943009e-01f, 9.56930667e-02f, 2.67324418e-01f, 2.27792263e-01f, 1.13001980e-01f, -4.93513159e-02f, 3.25986952e-01f, -2.87913412e-01f, 2.73582280e-01f, -7.04000816e-02f,
  -1.34893358e-01f, -2.02626899e-01f, -2.51295537e-01f, 1.32992789e-01f, -3.40156049e-01f, -2.66229529e-02f, 3.04564964e-02f, -2.56758362e-01f, 1.96957394e-01f, 4.43194151e-01f,
  2.85128325e-01f, 2.92036235e-01f, -3.32704127e-01f, -7.34176859e-02f, 2.49678507e-01f, -1.88512325e-01f, 2.33405650e-01f, -7.79479817e-02f, 3.31250548e-01f, 8.05399790e-02f,
  3.72575849e-01f, 2.89924711e-01f, 6.49627820e-02f, 1.01857603e-01f, -6.14476204e-02f, 2.15040714e-01f, 2.40741402e-01f, -1.85276233e-02f, 3.24289501e-01f, 3.17158967e-01f,
  -2.21717492e-01f, -7.93757290e-02f, 2.49327093e-01f, 3.43872577e-01f, 2.44915947e-01f, 1.29991814e-01f, 2.23014364e-03f, -2.58157969e-01f, 6.06044084e-02f, 1.57199651e-01f,
  -1.92936167e-01f, -1.53057724e-01f, 1.07179552e-01f, -1.06182739e-01f, -1.38366461e-01f, 3.94612789e-01f, 2.06137467e-02f, -3.16144019e-01f, 5.37671030e-01f, -3.17546159e-01f,
  3.07789832e-01f, -1.41751960e-01f, 1.23896286e-01f, 3.66131105e-02f, 3.77233833e-01f, 1.11027651e-01f, -6.22403808e-03f, 2.04480395e-01f, 1.70173407e-01f, 1.29752070e-01f,
  -2.67953813e-01f, -4.08130676e-01f, -2.75617272e-01f, -1.31604269e-01f, 1.45153314e-01f, -1.38307244e-01f, -4.45437789e-01f, -4.45486270e-02f, -1.93477377e-01f, -9.85702425e-02f,
  -2.67703354e-01f, 4.85727452e-02f, 5.62393665e-02f, -5.27001731e-02f, 1.99488476e-01f, 2.60409024e-02f, 1.95425287e-01f, -4.06729251e-01f, 4.54852313e-01f, 5.15944958e-02f,
  2.15205163e-01f, 3.70177507e-01f, 2.18141511e-01f, 2.59841353e-01f, 2.49727666e-01f, -8.57440233e-02f, 1.97109714e-01f, -9.76854116e-02f, 9.92565602e-03f, -1.89528093e-01f,
  6.23077080e-02f, -2.88512528e-01f, -2.27372691e-01f, 1.18198104e-01f, 5.08290939e-02f, 2.61716783e-01f, -9.90486220e-02f, 2.63050765e-01f, 1.70552164e-01f, 2.96742976e-01f,
  6.09552711e-02f, 2.30910137e-01f, 3.32875460e-01f, 5.91447316e-02f, -6.60481229e-02f, -1.48891538e-01f, -3.03251475e-01f, -1.54493749e-01f, 2.99577534e-01f, 2.37797812e-01f,
  -2.02174470e-01f, 2.01467618e-01f, 4.96090539e-02f, 2.33392287e-02f, 1.75608963e-01f, 2.76763260e-01f, -5.27295005e-03f, 1.49892792e-01f, 2.76616395e-01f, 1.28391348e-02f,
  8.71787686e-03f, -3.53297479e-02f, -1.80288870e-02f, 3.48607190e-02f, -2.62320042e-02f, 1.21009029e-01f, -6.81448102e-01f, -2.19538495e-01f, 7.74488002e-02f, -7.65200406e-02f,
  -1.46066114e-01f, -3.05345714e-01f, 4.47568148e-01f, 1.27384096e-01f, 2.64509499e-01f, 4.16523784e-01f, 2.60004997e-02f, -1.61011919e-01f, -1.87581077e-01f, -1.37676761e-01f,
  4.77208614e-01f, 3.76079470e-01f, -2.71711290e-01f, 3.50403130e-01f, 1.23583287e-01f, 4.13185179e-01f, 3.86091292e-01f, 2.50238985e-01f, 2.14623660e-01f, -1.04171447e-01f,
  2.18123555e-01f, -1.74748942e-01f, 2.00812295e-01f, -2.45428473e-01f, -1.89212069e-01f, -2.63893545e-01f, -1.11943439e-01f, 2.73176491e-01f, -1.86422735e-01f, 2.68359423e-01f,
  6.23746254e-02f, 8.55302140e-02f, 1.53078780e-01f, 1.81592599e-01f, 5.96965626e-02f, 2.20913626e-02f, 4.76566374e-01f, 3.19797277e-01f, -1.19674638e-01f, -1.13956854e-01f,
  -2.16836870e-01f, -9.76162925e-02f, 3.73238146e-01f, 1.37848079e-01f, -2.89616525e-01f, 2.78547406e-01f, 2.09599845e-02f, 3.82068194e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -8.91418979e-02f, 2.04976778e-02f, 2.33190775e-01f, 5.79192117e-02f, 3.30161839e-03f, 9.14295539e-02f, 7.61128888e-02f, 2.99510866e-01f, 2.85781860e-01f, 5.32352217e-02f,
  1.81339517e-01f, 2.40028709e-01f, 1.46484911e-01f, 1.13415472e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.71690792e-01f, 1.95507891e-02f, 1.17292657e-01f, 3.27883810e-02f, 4.42115292e-02f, -8.63480419e-02f, -6.42821193e-02f, 1.13128416e-01f, 2.27996722e-01f, -1.17308877e-01f,
  -8.33295509e-02f, -2.19700754e-01f, -2.82862093e-02f, -3.21676075e-01f, -6.46100715e-02f, -2.41771594e-01f, 1.34773865e-01f, 1.51102692e-01f, -1.70834407e-01f, -2.04978153e-01f,
  -2.20346034e-01f, 1.08581064e-02f, -1.18978471e-01f, 1.27466649e-01f, 1.40362054e-01f, 1.15602881e-01f, -4.23449241e-02f, -2.98828304e-01f, 1.36591822e-01f, 1.84844777e-01f,
  -6.02285229e-02f, 2.46534586e-01f, -2.43493587e-01f, -1.68723017e-01f, 5.05719669e-02f, 1.17702391e-02f, 3.46328728e-02f, -1.47914767e-01f, -2.63591763e-02f, -2.34076098e-01f,
  -1.15024149e-02f, -7.53697231e-02f, 2.13119328e-01f, -1.09245740e-02f, -5.92168905e-02f, -2.13291436e-01f, 7.18628392e-02f, -5.64167500e-02f, -1.17032364e-01f, -1.35162607e-01f,
  1.65392548e-01f, -1.49515912e-01f, -1.49543688e-01f, 4.41555446e-03f, -1.85933188e-01f, 6.07126541e-02f, 1.12200275e-01f, -7.25321919e-02f, -2.25971609e-01f, -2.77106136e-01f,
  4.15885188e-02f, 1.53023094e-01f, 2.80425817e-01f, 6.21397533e-02f, -2.48632561e-02f, -1.18226811e-01f, 1.48095144e-02f, -3.51977199e-01f, 4.70790304e-02f, -2.32103001e-02f,
  7.08856657e-02f, 9.18303505e-02f, 2.64130649e-03f, 2.61520654e-01f, 1.11074813e-01f, 1.53954536e-01f, -3.32595378e-01f, -2.42198169e-01f, -8.97127539e-02f, -1.20729893e-01f,
  1.83379948e-01f, -4.06043649e-01f, 4.35925454e-01f, -1.17793441e-01f, -1.12146951e-01f, 7.21984357e-02f, -2.95941085e-01f, -4.44346778e-02f, 1.58885673e-01f, -7.41228312e-02f,
  -1.67905807e-01f, 2.95171559e-01f, 1.22061837e-02f, -3.29536386e-02f, 2.76925236e-01f, 1.15576535e-01f, 2.10333198e-01f, -7.30831474e-02f, 2.06373066e-01f, 4.87421639e-02f,
  2.19265938e-01f, -1.49092689e-01f, 1.27043068e-01f, 4.60553542e-02f, 2.44924918e-01f, -2.95813769e-01f, -1.41573325e-01f, -1.24846064e-01f, -2.70667095e-02f, -2.77333260e-01f,
  1.02293111e-01f, -1.25706971e-01f, -2.00921763e-02f, 2.91702393e-02f, -5.36733456e-02f, -1.09755717e-01f, -2.67126560e-01f, -1.06888497e-02f, -9.10974070e-02f, 5.09534106e-02f,
  2.91705370e-01f, -1.28890887e-01f, 8.16761479e-02f, -3.40540439e-01f, 1.76250234e-01f, 2.06348896e-01f, 5.29726334e-02f, 3.08159143e-01f, -3.01279053e-02f, 1.69432327e-01f,
  2.34652698e-01f, 8.24259769e-04f, 4.55203578e-02f, -9.19221044e-02f, 1.72677428e-01f, 1.52578607e-01f, 1.94195673e-01f, 3.27621520e-01f, -3.01418960e-01f, -2.02895746e-01f,
  -2.31993437e-01f, 1.24879088e-02f, -1.69917971e-01f, 1.63134709e-02f, -1.59429908e-01f, -8.33638832e-02f, -2.71956056e-01f, -1.15028419e-01f, -2.38429941e-02f, 1.78830594e-01f,
  5.50603531e-02f, 1.21890761e-01f, 8.63275081e-02f, -1.81496978e-01f, 2.71270841e-01f, 9.67038646e-02f, -4.37345356e-01f, 2.55643576e-01f, -3.26809853e-01f, 1.92856088e-01f,
  -3.46573293e-01f, -2.83866911e-03f, -1.64209023e-01f, 4.94956672e-02f, -2.27668390e-01f, -2.67126830e-03f, -1.51817039e-01f, 2.21116301e-02f, 1.76281575e-02f, -1.45630151e-01f,
  4.10921797e-02f, -2.70233750e-01f, -5.30290566e-02f, 1.24334715e-01f, 1.10026740e-01f, 2.50928134e-01f, -1.62083104e-01f, -4.08558488e-01f, -1.02483287e-01f, -1.09724395e-01f,
  -5.23957610e-03f, 1.16257668e-01f, -1.09330572e-01f, -1.60056531e-01f, 2.28391215e-02f, -1.63969442e-01f, 2.23846100e-02f, 7.81825781e-02f, 9.10049528e-02f, 5.69510087e-02f,
  2.05265358e-01f, 1.26856551e-01f, -6.33611977e-02f, -8.52159560e-02f, -2.22247690e-01f, -7.80746639e-02f, 9.66376215e-02f, -8.44955146e-02f, -9.40893888e-02f, -1.20125592e-01f,
  -4.47401702e-02f, -3.23470712e-01f, 2.43087143e-01f, 2.89664090e-01f, 1.13221712e-01f, -4.29930210e-01f, 2.84869105e-01f, 1.01371534e-01f, 8.54159221e-02f, -7.05998912e-02f,
  3.10517430e-01f, 9.88214016e-02f, -1.08470067e-01f, -1.97569970e-02f, -1.77102819e-01f, 1.90396942e-02f, 2.51978993e-01f, -2.72753209e-01f, -4.09814008e-02f, -1.53117105e-01f,
  2.84932945e-02f, 1.00461461e-01f, 2.27923036e-01f, 2.72004098e-01f, -2.49906126e-02f, -1.46219373e-01f, 1.32866409e-02f, -4.44918834e-02f, -2.35277519e-01f, 1.52857393e-01f,
  -7.22997189e-02f, -9.14125144e-02f, -1.72349796e-01f, -1.44550920e-01f, 1.16444819e-01f, -1.08379582e-02f, -2.51238883e-01f, -1.90386772e-01f, -1.32937893e-01f, 1.02266438e-01f,
  -2.99990308e-02f, -1.68869644e-02f, -1.27913922e-01f, -2.91287452e-02f, -1.41306415e-01f, 2.79250648e-02f, -1.08126603e-01f, -1.48248851e-01f, 4.53870259e-02f, -1.21634997e-01f,
  -3.65087152e-01f, -1.04032122e-02f, -3.44395712e-02f, 1.67103276e-01f, 3.40691775e-01f, 2.97211081e-01f, 1.73823193e-01f, 5.57132363e-02f, -8.98068547e-02f, -2.00389415e-01f,
  3.48859310e-01f, -9.76479892e-03f, 8.92934203e-02f, 9.99784190e-03f, 1.24755152e-01f, -2.37188232e-03f, 1.76262572e-01f, 3.18285346e-01f, 1.20179795e-01f, -3.01370889e-01f,
  -1.89239278e-01f, -6.63322909e-03f, 1.27739847e-01f, 2.49687769e-02f, 3.80639523e-01f, 2.80954212e-01f, 1.59861058e-01f, -9.02228814e-04f, -2.89727628e-01f, 1.38555378e-01f,
  -1.13422669e-01f, 1.63318843e-01f, -4.14565578e-02f, -1.28313497e-01f, -1.83560342e-01f, -1.16534894e-02f, -1.82891026e-01f, -6.92562982e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.13813508e-01f, 2.65587687e-01f, 2.77013481e-01f, 1.87178716e-01f, 2.09247053e-01f, 2.04102054e-01f, -7.48417899e-02f, 1.41459465e-01f, 2.86776751e-01f, -3.43282610e-01f,
  1.54342905e-01f, 3.35854024e-01f, 6.37586236e-01f, 7.09209815e-02f, 5.26079297e-01f, 4.52536792e-01f, 1.46728218e-01f, -6.45720735e-02f, 2.26119459e-01f, 5.95663786e-01f,
  1.22547701e-01f, 3.01296711e-01f, 4.17786986e-01f, -1.47017896e-01f, 1.24058418e-01f, 1.68101057e-01f, 4.57208633e-01f, -9.01311636e-02f, 3.64548355e-01f, -3.38851005e-01f,
  -1.56734884e-01f, -4.21916544e-01f, -4.42931690e-04f, 1.51379466e-01f, -1.61572337e-01f, -4.45125222e-01f, 2.32237935e-01f, -1.96389914e-01f, 2.22914502e-01f, 1.91167980e-01f,
  5.60238212e-02f, -1.70891300e-01f, 3.87737244e-01f, 2.36032307e-01f, 2.68791527e-01f, -2.82376945e-01f, 4.79055017e-01f, 8.04117620e-02f, 3.47217083e-01f, 1.79032430e-01f,
  7.72744596e-01f, 3.36186737e-01f, -3.88465039e-02f, 6.75299242e-02f, -9.32334177e-03f, -1.73127413e-01f, 6.07123852e-01f, -1.38795808e-01f, 9.76299718e-02f, -2.24316254e-01f,
  2.79312909e-01f, -2.43625209e-01f, 1.83394682e-02f, -2.63308167e-01f, -1.58434622e-02f, 7.72639662e-02f, 1.65083736e-01f, -3.96198295e-02f, -3.80196661e-01f, 2.70976633e-01f,
  3.41905765e-02f, -3.86203788e-02f, -2.36343723e-02f, -5.51903546e-01f, 1.84442997e-02f, 1.19646117e-01f, 2.14766100e-01f, -3.79312038e-01f, 1.59168407e-01f, 5.18425703e-01f,
  -3.76981705e-01f, -5.99250615e-01f, 7.68684074e-02f, 3.10721338e-01f, 2.43555650e-01f, 2.44976863e-01f, -4.89412732e-02f, 2.29544789e-01f, 9.67786685e-02f, 1.61452219e-01f,
  -3.30328405e-01f, -1.11893736e-01f, -1.24852672e-01f, 3.90035719e-01f, 4.50204730e-01f, 3.55329335e-01f, -1.54734880e-01f, 1.06848575e-01f, 1.23518687e-02f, 1.34086788e-01f,
  2.08642576e-02f, 1.72813699e-01f, 1.76231563e-01f, 5.95916957e-02f, 1.57168821e-01f, 1.13035336e-01f, -4.77327138e-01f, -5.04046559e-01f, 2.67514378e-01f, 1.31761432e-01f,
  1.87983945e-01f, 5.41650355e-01f, -5.02250135e-01f, -6.59442365e-01f, -2.25959256e-01f, -1.15723319e-01f, 2.99245149e-01f, 5.95449269e-01f, 1.07063949e-01f, 5.70635021e-01f,
  -1.09321468e-01f, -9.40279290e-02f, 1.54261947e-01f, 1.47889987e-01f, -4.81932849e-01f, 1.46708980e-01f, 1.60673279e-02f, 1.72015905e-01f, 2.94695914e-01f, 1.23541579e-01f,
  2.20485628e-01f, 9.75646824e-02f, 3.59467417e-01f, 4.62887846e-02f, 2.07216725e-01f, 7.00948313e-02f, 1.78549901e-01f, -1.38288558e-01f, -1.53069556e-01f, 6.31090999e-02f,
  -1.98744088e-01f, -1.45991832e-01f, -1.96479961e-01f, -2.78753519e-01f, 1.60421133e-01f, 2.47081265e-01f, 3.17832343e-02f, -7.20763654e-02f, -3.13880257e-02f, -1.90570146e-01f,
  -9.44661349e-02f, 1.55790895e-01f, 3.44125301e-01f, 1.17693067e-01f, 1.83560431e-01f, -9.08578709e-02f, 7.38582015e-02f, 1.98746160e-01f, -1.19472548e-01f, 1.02186412e-01f,
  -9.70080420e-02f, 2.33385131e-01f, 1.82652935e-01f, 1.12428851e-01f, -1.36352964e-02f, 2.01172069e-01f, -5.81237301e-03f, 9.51384827e-02f, 1.11679742e-02f, -1.29679859e-01f,
  -4.64453213e-02f, -1.71069875e-02f, -3.96634415e-02f, -5.65979332e-02f, -2.93872710e-02f, -3.82501930e-02f, 1.57061502e-01f, 7.11608380e-02f, 1.66201085e-01f, 1.74327374e-01f,
  2.42782220e-01f, 1.37142792e-01f, 1.41036704e-01f, 1.32045075e-01f, 2.56614089e-01f, 3.75781804e-01f, 1.61316231e-01f, 2.03590587e-01f, 2.92326510e-01f, 1.86949328e-01f,
  3.18854541e-01f, 1.82727471e-01f, -1.19458243e-01f, 1.48913115e-01f, -7.24817738e-02f, -4.68402170e-02f, 4.77262819e-03f, 2.15510488e-01f, 2.88028996e-02f, 2.06561103e-01f,
  1.24683813e-03f, 6.98186383e-02f, -7.21752569e-02f, 4.20217812e-01f, -2.11181521e-01f, -4.87048537e-01f, -4.73010421e-01f, 1.99149400e-01f, -6.93951398e-02f, -5.07978082e-01f,
  4.23928618e-01f, 3.08850169e-01f, 1.45026982e-01f, -1.96350254e-02f, -2.69385457e-01f, 1.76994756e-01f, -1.90313175e-01f, 2.65437514e-02f, -2.12257817e-01f, 2.90843904e-01f,
  -3.11997682e-01f, 3.37941438e-01f, 1.54564485e-01f, 3.46983492e-01f, -4.44174446e-02f, 5.72147220e-02f, 5.12873288e-03f, -1.96193412e-01f, -2.82005668e-01f, 1.75856516e-01f,
  -1.37544960e-01f, 3.71454768e-02f, -6.22432679e-02f, 1.83810860e-01f, 2.02136025e-01f, -1.74461693e-01f, 5.22604465e-01f, 4.68935102e-01f, 5.16332150e-01f, 5.23036480e-01f,
  6.76502883e-02f, -6.28264964e-01f, 1.49481833e-01f, 4.06210065e-01f, 3.13710600e-01f, 3.53417754e-01f, 4.02700961e-01f, -1.50320768e-01f, -2.53531843e-01f, 3.07389826e-01f,
  2.86153227e-01f, 3.07199836e-01f, 1.43355459e-01f, -3.33821505e-01f, 3.45812768e-01f, -9.65887532e-02f, 3.21865588e-01f, 2.26771757e-01f, -8.93313065e-03f, -1.02874167e-01f,
  2.49740526e-01f, 2.26014510e-01f, 2.10764512e-01f, 3.89648117e-02f, 2.31721714e-01f, 1.34635568e-01f, -1.73903197e-01f, 1.86048225e-01f, -5.78669310e-01f, -2.45257050e-01f,
  -5.54607987e-01f, -6.06602728e-01f, 4.32462245e-01f, 5.44733442e-02f, 2.35332206e-01f, 1.03095368e-01f, 2.42576674e-01f, -9.55771804e-02f, -1.86982214e-01f, 1.13702700e-01f,
  3.28046650e-01f, 3.73562604e-01f, 5.09489216e-02f, 4.31249589e-01f, 8.72327983e-02f, 2.91071177e-01f, 1.98698804e-01f, 4.17789787e-01f, 1.86399370e-01f, -1.26836756e-02f,
  2.52577186e-01f, 2.34364763e-01f, -5.61499298e-02f, 2.63573021e-01f, 1.01393744e-01f, 7.70451576e-02f, 8.56734216e-02f, -6.31359458e-01f, -3.58717293e-01f, -2.60151684e-01f,
  1.07329443e-01f, -2.14607224e-01f, 2.30301559e-01f, -5.06373383e-02f, -1.88171357e-01f, -4.99298461e-02f, -5.26816510e-02f, -3.63363147e-01f, -1.74216069e-02f, 2.88333863e-01f,
  -6.26770109e-02f, 4.25365120e-01f, 4.87790257e-01f, 1.63987234e-01f, 6.91854432e-02f, -3.97412747e-01f, 1.74217254e-01f, 2.90660232e-01f, 4.98721927e-01f, 4.00962323e-01f,
  1.01280011e-01f, -2.83025112e-02f, 4.79207560e-03f, -1.22911908e-01f, -1.65812497e-03f, 1.02288630e-02f, 2.54201531e-01f, 2.61341959e-01f, 2.12499872e-01f, 8.30868661e-01f,
  -1.88579410e-01f, 3.51877995e-02f, -5.00525832e-01f, 1.95678055e-01f, -5.17225742e-01f, 4.08467539e-02f, -1.82208121e-01f, -2.44280741e-01f, -2.24849984e-01f, -3.07774097e-01f,
  1.30406752e-01f, 2.21986651e-01f, 1.25481561e-02f, 1.70253128e-01f, -4.88467157e-01f, -2.97233313e-01f, 2.74280280e-01f, 5.14422536e-01f, -3.11475873e-01f, 2.03815401e-01f,
  -1.08352862e-01f, 2.32814088e-01f, 1.84219927e-01f, 1.89609572e-01f, 7.88451582e-02f, 3.58168989e-01f, 2.47925043e-01f, 2.60907084e-01f, 2.38307789e-01f, 1.74996823e-01f,
  1.64058000e-01f, 2.36112535e-01f, -3.51647526e-01f, -2.13512480e-01f, -1.94361228e-02f, 3.08421552e-01f, -1.46474659e-01f, -3.06941330e-01f, 2.57564247e-01f, 4.35913593e-01f,
  -3.34549367e-01f, 7.89080635e-02f, 2.85945743e-01f, 1.08645983e-01f, 2.50614226e-01f, 1.09815538e-01f, 2.16648340e-01f, 2.08174393e-01f, 4.86351669e-01f, 3.69504184e-01f,
  3.05604905e-01f, 1.52467582e-02f, -1.66191876e-01f, -2.17874557e-01f, -1.98133126e-01f, 4.94584367e-02f, -1.80479381e-02f, 2.62469679e-01f, 1.50913581e-01f, 1.22517161e-01f,
  2.22301662e-01f, -3.87383974e-03f, -1.01939753e-01f, -3.23201716e-01f, -2.70615667e-01f, -5.54623187e-01f, 5.30240476e-01f, 4.34702605e-01f, 5.17003894e-01f, 4.27464634e-01f,
  -2.18225271e-01f, -4.06741858e-01f, 1.23238035e-01f, -4.46683094e-02f, 2.10026473e-01f, 4.36514825e-01f, 4.01962459e-01f, 2.77182102e-01f, -2.93822009e-02f, 9.67988893e-02f,
  2.67588615e-01f, -2.18879178e-01f, 1.04350798e-01f, -1.03936143e-01f, 4.35790718e-02f, -2.94281393e-01f, 4.32054013e-01f, 3.20422739e-01f, 1.27660677e-01f, 2.92301606e-02f,
  4.38848048e-01f, -2.55016126e-02f, 4.49207686e-02f, 4.09281217e-02f, 2.09372252e-01f, -1.75575346e-01f, 1.16303071e-01f, 2.06342384e-01f, -2.18071247e-04f, -2.05545425e-01f,
  5.88953607e-02f, -3.49625468e-01f, 5.84497690e-01f, 3.54775369e-01f, 4.19333637e-01f, 3.68864536e-01f, 2.34532952e-01f, -2.12296307e-01f, 2.46065184e-01f, 7.52537027e-02f,
  4.84951556e-01f, 3.27753276e-01f, 1.74453065e-01f, 2.12347209e-01f, 3.84798199e-01f, 1.41879484e-01f, -8.62036049e-02f, -3.39873545e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  7.93925375e-02f, -2.22392119e-02f, 2.53791809e-02f, 1.53531596e-01f, 1.22616030e-01f, 2.22266763e-01f, 1.04331300e-01f, 4.26825769e-02f, 2.68740296e-01f, 1.85994253e-01f,
  3.91646475e-02f, 3.24932456e-01f, 8.20985511e-02f, 1.86206713e-01f
};

// L3_fan_Wp (Shape: 9 x 32)
const int L3_fan_Wp_rows = 9;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -7.75288865e-02f, -4.01602536e-02f, 1.15052946e-01f, 1.82237491e-01f, 1.90913469e-01f, 3.53432149e-02f, 3.36655200e-01f, 1.88101918e-01f, 1.80326223e-01f, 2.39951000e-01f,
  2.86816925e-01f, -1.18579470e-01f, 2.00547706e-02f, 2.09930003e-01f, 3.72694880e-01f, -8.46975297e-02f, 2.88894176e-01f, -3.49367946e-01f, -1.90406606e-01f, 6.72333539e-02f,
  1.03636593e-01f, 3.78303044e-02f, -9.83476080e-03f, -7.03893304e-02f, 1.46637484e-01f, -1.13388494e-01f, 1.83518901e-01f, 6.89369738e-02f, 7.78371617e-02f, -1.50193319e-01f,
  1.72277033e-01f, -2.06268117e-01f, 8.19673613e-02f, 5.58270467e-03f, 7.74453431e-02f, -3.82950297e-03f, -6.34244010e-02f, 1.81047931e-01f, 1.55345071e-02f, 1.04738176e-02f,
  -2.29450706e-02f, 2.33747736e-01f, 1.84149027e-01f, -1.02415942e-01f, 2.46951655e-01f, -4.36149985e-02f, 7.39411712e-02f, 8.86830688e-02f, 2.75330991e-01f, 5.59027083e-02f,
  -1.16592780e-01f, -1.38988718e-01f, 2.75118172e-01f, 2.22880632e-01f, -3.66846770e-02f, -1.48341442e-02f, -5.46220802e-02f, -1.25089198e-01f, -2.67596692e-02f, 1.02112278e-01f,
  -6.39352277e-02f, -1.44011825e-01f, -1.19738095e-01f, 1.83101762e-02f, -1.24592267e-01f, 2.54354119e-01f, 1.66319236e-01f, -5.78132607e-02f, -2.19596341e-01f, 1.59021035e-01f,
  -1.53537579e-02f, 3.34637523e-01f, -8.76062214e-02f, -8.04316252e-02f, -1.46731347e-01f, -1.24669045e-01f, -1.00339660e-02f, 4.08047736e-02f, -1.80623561e-01f, 7.60053284e-03f,
  -1.54579431e-01f, 4.93526645e-02f, 2.42644131e-01f, 1.38395220e-01f, -1.13590270e-01f, -3.47663686e-02f, -2.85270084e-02f, -1.67161264e-02f, -9.84635800e-02f, 2.35913008e-01f,
  -1.36475906e-01f, 3.45889106e-02f, -5.05813956e-02f, 1.85309619e-01f, 2.81475727e-02f, -5.01474626e-02f, 1.36721566e-01f, -2.18562409e-01f, -2.04467736e-02f, -1.13182880e-01f,
  -3.47856283e-02f, -1.32094041e-01f, -2.81983703e-01f, -1.05543301e-01f, -3.34348343e-03f, -8.90014321e-02f, 7.26756752e-02f, 1.51179761e-01f, -8.61318558e-02f, 2.94242382e-01f,
  1.56407759e-01f, -6.91320524e-02f, 1.44204363e-01f, -1.69008806e-01f, -1.64651245e-01f, -5.59286401e-02f, -1.06173910e-01f, 2.14915484e-01f, -4.90765311e-02f, 2.42010802e-01f,
  6.37209788e-02f, -2.57856995e-01f, 2.57332146e-01f, -5.97902350e-02f, 8.09962153e-02f, 3.11418083e-02f, -2.21824601e-01f, -1.72623873e-01f, -1.00052983e-01f, 2.21804213e-02f,
  6.32950962e-02f, -1.94820352e-02f, 3.09352912e-02f, 9.91497636e-02f, -1.72115713e-01f, 2.02406347e-02f, -1.30684808e-01f, 6.99044615e-02f, -4.33944464e-01f, 3.41664515e-02f,
  -4.58257757e-02f, -2.17367187e-01f, -5.19789197e-02f, 2.11574972e-01f, 7.95322955e-02f, -3.76788005e-02f, -1.46431908e-01f, 5.17657101e-02f, 9.02513936e-02f, -1.87244564e-01f,
  6.27577007e-02f, 1.93714369e-02f, 2.95810569e-02f, -9.49372500e-02f, 2.60702461e-01f, 1.31578967e-01f, 6.77656904e-02f, 1.06971385e-02f, -2.17269674e-01f, -7.16973692e-02f,
  5.85985258e-02f, 8.62018988e-02f, -1.88353360e-02f, -8.57108757e-02f, 1.61024839e-01f, 2.52676662e-02f, 2.57183552e-01f, -2.32633665e-01f, 7.09588677e-02f, 2.50624627e-01f,
  -1.50101259e-01f, -3.02095264e-01f, 3.63778621e-01f, 1.63441688e-01f, 1.22900167e-02f, -6.33268803e-02f, 5.41191176e-02f, -1.89926907e-01f, 1.74177438e-01f, -2.60703620e-02f,
  1.02484025e-01f, 1.42797455e-01f, 5.63854389e-02f, 7.90383145e-02f, -1.32204667e-01f, -6.35048896e-02f, -2.13530540e-01f, 2.03674063e-01f, -1.07915662e-01f, -1.12669198e-02f,
  5.29076457e-02f, -2.20486984e-01f, -2.54586153e-02f, 6.60415143e-02f, 2.29196325e-01f, 2.15186998e-01f, 1.06297225e-01f, 1.84819818e-01f, 1.00962982e-01f, 1.77123442e-01f,
  4.81483191e-02f, 1.26245111e-01f, -2.44159892e-01f, 2.17837691e-01f, -8.17908943e-02f, -9.61170420e-02f, -1.42307401e-01f, -1.68717265e-01f, -1.70105323e-01f, 1.25409603e-01f,
  -2.43610203e-01f, -3.33649516e-02f, -1.58218399e-01f, -1.96038470e-01f, 4.89901751e-02f, 3.75568196e-02f, 1.61876932e-01f, -3.28350887e-02f, 2.67709970e-01f, -7.20823109e-02f,
  4.09878977e-03f, 2.03506768e-01f, -5.38172983e-02f, 2.06265032e-01f, 2.22827271e-01f, 1.34638637e-01f, 1.75623029e-01f, 3.41829121e-01f, -1.02455504e-01f, -4.12771255e-02f,
  1.76619608e-02f, 1.29936382e-01f, -1.73795186e-02f, 4.49782349e-02f, -4.42213342e-02f, 9.54972431e-02f, 1.50552288e-01f, -1.66663423e-01f, 1.49425820e-01f, 2.62012780e-02f,
  -1.46728486e-01f, 2.51718253e-01f, 6.95265830e-02f, 1.31004944e-01f, 1.27774581e-01f, 7.26046115e-02f, -2.29494385e-02f, -3.49149890e-02f, -1.57745391e-01f, 5.70432059e-02f,
  -2.79492199e-01f, 8.36793408e-02f, 3.56531539e-03f, -2.73808271e-01f, 2.81907916e-01f, -8.79957527e-02f, 1.06787510e-01f, 1.66704625e-01f, -9.95413214e-02f, 3.35272104e-01f,
  -2.39181090e-02f, 5.35304612e-03f, -1.34848466e-03f, -7.06900954e-02f, 1.20633477e-02f, 3.70368361e-02f, -1.24964975e-01f, 6.85401335e-02f, -9.36684981e-02f, 3.25104952e-01f,
  1.42181357e-02f, -2.18814120e-01f, -9.75414515e-02f, -2.08735973e-01f, 1.13424391e-01f, 1.33255897e-02f, -1.89956516e-01f, 5.85873537e-02f, -3.11935693e-02f, 1.13558121e-01f,
  -1.95421860e-01f, 1.17863566e-01f, 7.32242689e-02f, -2.01606169e-01f, 9.75811332e-02f, 1.19539991e-01f, 2.87211925e-01f, -1.24192670e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 32)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.37992629e-01f, 4.92181540e-01f, 5.00859141e-01f, 3.25726449e-01f, 5.39605021e-01f, 1.63301647e-01f, 7.68373251e-01f, 2.55711138e-01f, 4.16745067e-01f, 5.53210914e-01f,
  -4.69364405e-01f, -3.26526523e-01f, 7.31827319e-01f, 1.75331980e-01f, -1.69244245e-01f, -1.23358585e-01f, -3.63347143e-01f, 2.70961374e-01f, 1.94938719e-01f, 1.87105443e-02f,
  6.56504557e-02f, 3.38425130e-01f, 3.91048729e-01f, 2.71580126e-02f, -5.81861772e-02f, -3.27890188e-01f, -9.39042568e-02f, 4.31301087e-01f, -4.64074820e-01f, 8.07349309e-02f,
  4.32417601e-01f, 6.64712936e-02f, -3.87340397e-01f, -3.97883169e-02f, -9.45141017e-02f, -5.18774927e-01f, 1.07246630e-01f, -2.26604328e-01f, 1.09838217e-01f, -2.10770503e-01f,
  1.16910912e-01f, 2.90222913e-01f, 2.61361122e-01f, -6.45775199e-02f, 1.53400883e-01f, -4.32094336e-01f, -1.75229892e-01f, 1.76525742e-01f, 2.20797006e-02f, -1.67089924e-01f,
  2.16954321e-01f, 4.11692530e-01f, 3.17787156e-02f, -5.33546567e-01f, 2.50250608e-01f, 2.75959253e-01f, -3.69542301e-01f, 1.11393839e-01f, 2.42071226e-01f, 2.08432406e-01f,
  -4.01523381e-01f, 3.16273808e-01f, -1.86387375e-02f, 4.43955302e-01f, 1.14973165e-01f, -8.19037557e-02f, 6.86394125e-02f, 2.15299308e-01f, 2.83936620e-01f, -5.04350178e-02f,
  1.14082545e-01f, -1.60907600e-02f, -2.46972013e-02f, -4.97888535e-01f, 2.23442256e-01f, -3.61570120e-01f, -4.15446848e-01f, 1.32046938e-01f, 4.81323421e-01f, -2.64460981e-01f,
  3.11794966e-01f, -3.80986631e-01f, 3.62375498e-01f, -7.15467572e-01f, 1.64292678e-01f, 3.65592211e-01f, -3.96709532e-01f, 1.92295700e-01f, -1.23656549e-01f, 7.79504180e-01f,
  -1.06510952e-01f, 5.77658713e-02f, 2.99713463e-02f, 3.29859197e-01f, 4.58439499e-01f, -8.60149972e-03f, 2.58991420e-01f, 3.10047328e-01f, 1.03856638e-01f, 3.66874784e-01f,
  -2.42187068e-01f, 3.43413144e-01f, -4.30923477e-02f, 3.53918672e-01f, -8.68159458e-02f, -5.95671713e-01f, -3.32992494e-01f, 3.24607462e-01f, -5.51753819e-01f, 4.29511070e-02f,
  1.51141092e-01f, -9.28880274e-02f, -3.70779932e-02f, 3.03252190e-01f, 4.20010656e-01f, 5.95123172e-01f, 2.34083936e-01f, 1.63920209e-01f, -2.07220003e-01f, 1.08913362e-01f,
  3.89908463e-01f, 5.71234167e-01f, -4.34172340e-02f, -2.61646479e-01f, 5.03678679e-01f, -3.99368964e-02f, 1.99611470e-01f, 1.00689873e-01f, -1.77512378e-01f, -4.13671046e-01f,
  1.34184361e-02f, -3.58865112e-01f, -1.95314903e-02f, -4.16178405e-01f, -4.11069959e-01f, -5.34664154e-01f, -7.17693940e-02f, 3.77025068e-01f, 4.71296787e-01f, 3.18823814e-01f,
  4.20587718e-01f, -1.34750426e-01f, 8.16449746e-02f, 4.69200969e-01f, 2.91902602e-01f, -4.19377685e-01f, -3.45822304e-01f, 2.72475541e-01f, 3.11523557e-01f, 6.66363761e-02f,
  1.10868819e-01f, 2.71508753e-01f, 1.65319636e-01f, -2.12102249e-01f, 1.86771259e-01f, 4.65125054e-01f, -1.17831469e-01f, -2.55149782e-01f, -1.00332394e-01f, -6.20743521e-02f,
  -2.37730518e-02f, 2.33129412e-01f, 2.37253413e-01f, 1.80189908e-01f, 4.09662277e-01f, 1.00828275e-01f, 3.74806672e-01f, 1.15088172e-01f, 2.05650926e-01f, 3.28483701e-01f,
  -2.72139788e-01f, -4.96644452e-02f, 2.86162138e-01f, 1.73998192e-01f, -2.13946953e-01f, -2.45528430e-01f, -2.91418284e-01f, -1.00502335e-01f, -1.67425036e-01f, 1.19481370e-01f,
  -2.09791541e-01f, -1.13865964e-01f, 4.34459031e-01f, 9.39038619e-02f, -7.11885244e-02f, -1.94092214e-01f, 3.56879562e-01f, 2.93929279e-01f, -6.60196170e-02f, 5.26556611e-01f,
  -1.02068387e-01f, 4.72430080e-01f, -5.10738045e-03f, -2.03598496e-02f, -6.92556500e-02f, -1.80037662e-01f, -7.37414300e-01f, 2.36846745e-01f, -2.53930748e-01f, -1.88874498e-01f,
  1.10662654e-01f, 9.32949595e-03f, 2.35819747e-03f, 7.16390610e-01f, -1.94235787e-01f, 1.77382931e-01f, 2.48104483e-01f, -1.79001689e-01f, -6.96469098e-02f, -2.08869889e-01f,
  -4.68698502e-01f, -4.30182600e-03f, 7.55233765e-02f, 1.39537424e-01f, 1.76881209e-01f, 5.62491827e-02f, 3.83109212e-01f, -1.37129679e-01f, 3.51151764e-01f, 1.07483342e-01f,
  1.06266212e+00f, -1.33597702e-02f, -3.95678848e-01f, -1.05612623e-02f, 3.94395404e-02f, -8.85369349e-03f, 1.82166725e-01f, 1.76632598e-01f, 1.03713721e-01f, -9.74036455e-02f,
  -2.05048546e-02f, -1.88936785e-01f, 1.22534977e-02f, -2.72597522e-01f, -3.27323750e-02f, -2.29917645e-01f, 3.27550322e-02f, 3.63313794e-01f, 4.16805744e-01f, -4.09420729e-02f,
  2.03972235e-01f, -3.64257574e-01f, -8.10138062e-02f, -3.80754292e-01f, 4.64193285e-01f, 7.80443192e-01f, -1.60764143e-01f, 1.50716364e-01f, 2.41308287e-01f, 3.03237736e-01f,
  -7.21680149e-02f, 4.30107296e-01f, 2.98183411e-01f, -6.72480911e-02f, 5.19649565e-01f, -2.55960673e-01f, -1.06141143e-01f, -2.57574707e-01f, 1.22011252e-01f, -6.37402236e-02f,
  2.68922240e-01f, 3.77551802e-02f, 5.96040254e-03f, -2.12063581e-01f, 1.72674537e-01f, -2.69401640e-01f, -3.22568953e-01f, -4.27002102e-01f, -1.59796149e-01f, -2.35287726e-01f,
  -3.23548555e-01f, -2.59525478e-01f, -3.53755862e-01f, -2.14468747e-01f, 5.39856791e-01f, 2.71662116e-01f, -5.19462585e-01f, -1.48407012e-01f, 2.05156356e-01f, 4.99982424e-02f,
  -5.41761935e-01f, 3.20274204e-01f, -8.14668685e-02f, -6.20319732e-02f, -4.96072024e-02f, 3.66658479e-01f, 4.41658586e-01f, 4.33223218e-01f, 2.84721572e-02f, -6.34378195e-02f,
  -1.87911347e-01f, -9.53265652e-03f, -7.65416473e-02f, 1.38010666e-01f, -3.59561294e-01f, -1.66204482e-01f, -7.40718469e-02f, -1.06278308e-01f, 4.77902710e-01f, 4.54658538e-01f,
  1.81171879e-01f, -3.93703401e-01f, 2.80891031e-01f, 5.72978437e-01f, 5.74545443e-01f, -1.21660538e-01f, 1.88924313e-01f, 6.02456808e-01f, 5.28134882e-01f, -2.94476479e-01f,
  -5.04237972e-02f, 1.92299992e-01f, 2.64485896e-01f, 3.74033600e-01f, 9.62377936e-02f, 3.95050734e-01f, -3.29443783e-01f, -4.05026287e-01f, -5.17972298e-02f, 7.61524811e-02f,
  2.33302459e-01f, 2.13718772e-01f, 1.52640104e-01f, 6.49370477e-02f, 7.80316908e-03f, -8.59283730e-02f, 2.65388727e-01f, -5.85722551e-02f, 3.02527249e-01f, -5.11565618e-02f,
  -3.49539757e-01f, -1.97295830e-01f, 2.87167668e-01f, -3.95775944e-01f, -3.11626345e-01f, 2.98265852e-02f, -5.68166494e-01f, 5.73090971e-01f, 4.17436987e-01f, 7.93690622e-01f,
  4.22154143e-02f, -4.46103901e-01f, 3.44499052e-01f, 8.88296664e-02f, 1.94137126e-01f, 9.23835486e-03f, 2.82581210e-01f, -5.33802509e-02f, -2.02813685e-01f, 6.38367161e-02f,
  1.25853553e-01f, 4.37878937e-01f, 1.82250783e-01f, 2.10584089e-01f, 4.44314718e-01f, -2.47673243e-02f, -2.56001204e-01f, 2.68872976e-01f, 2.33381361e-01f, 4.81428355e-01f,
  3.28115612e-01f, 4.56939936e-01f, -4.72075716e-02f, -1.00820653e-01f, 2.80897915e-01f, 9.43750069e-02f, -3.74933541e-01f, 2.63056159e-01f, -1.41879499e-01f, 5.59810519e-01f,
  5.85682504e-02f, 4.62971121e-01f, 2.54769534e-01f, 7.86807165e-02f, 2.75902092e-01f, 2.08426014e-01f, 5.16113758e-01f, -2.87038356e-01f, 4.10056919e-01f, 9.88229662e-02f,
  4.70657051e-01f, 4.93694022e-02f, -3.33619446e-01f, 2.88391292e-01f, -3.48560691e-01f, 3.67427588e-01f, -1.40530005e-01f, -3.50595295e-01f, 3.04032177e-01f, 3.89741510e-01f,
  3.36976081e-01f, 1.19303122e-01f, 3.55435342e-01f, 3.04046944e-02f, -9.02790949e-02f, -2.35918224e-01f, -1.14134245e-01f, -2.83010572e-01f, 5.67704402e-02f, 2.09656462e-01f,
  -2.74397130e-03f, -2.05388546e-01f, 2.08449468e-01f, -3.82063031e-01f, 3.22493017e-01f, -2.00256512e-01f, 3.02292287e-01f, 1.17081434e-01f, -1.24461688e-01f, -5.09818792e-02f,
  1.31616861e-01f, 2.13195339e-01f, -5.24491668e-01f, 1.08735830e-01f, -6.70623034e-02f, 2.89098173e-01f, -6.85678944e-02f, 3.04932415e-01f, 1.12819215e-02f, 7.16867223e-02f,
  -1.86129808e-02f, 1.75120786e-01f, 1.63217440e-01f, 4.17723417e-01f, 1.04429297e-01f, -6.02145754e-02f, 4.93412837e-02f, -1.66495278e-01f, -3.12956840e-01f, -4.90983725e-02f,
  -1.24978758e-02f, -7.79877827e-02f, 1.04441814e-01f, 4.52728756e-02f, 3.22522298e-02f, -4.43108827e-01f, 4.37606014e-02f, 4.43823859e-02f, 1.32793903e-01f, 1.45712212e-01f,
  4.17462111e-01f, 1.24615297e-01f, 3.59744251e-01f, -1.94544241e-01f, 3.65892321e-01f, 3.58601511e-01f, -2.18155175e-01f, 1.40478730e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.96092033e-01f, -3.78106683e-02f, -7.55270943e-02f, 1.77908018e-01f, 7.21388832e-02f, 2.39229202e-01f, 1.19174019e-01f, 1.33463159e-01f, 2.16676742e-01f, -5.11142388e-02f,
  2.31030762e-01f, 1.61325976e-01f, -3.32523845e-02f, 8.67872536e-02f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -2.65205294e-01f, 1.45007828e-02f, -3.17976475e-01f, -2.75240332e-01f, 3.48725975e-01f, 2.41851747e-01f, 2.25205213e-01f, 2.49683395e-01f, 2.74354815e-01f, 2.38514990e-01f,
  -2.63629079e-01f, -1.55884802e-01f, -1.68974593e-01f, -2.49176890e-01f, -1.15242466e-01f, 2.83882141e-01f, 5.01957476e-01f, 2.23211259e-01f, -4.88277599e-02f, 1.89575449e-01f,
  -3.22674394e-01f, 1.31612256e-01f, -1.77386567e-01f, -1.17758932e-02f, -5.36489367e-01f, -7.27486432e-01f, 1.21025376e-01f, 1.98375016e-01f, 3.24018538e-01f, 1.27612457e-01f,
  -9.66685191e-02f, -7.15979576e-01f, 1.34534925e-01f, -1.08393855e-01f, 7.06047416e-02f, 5.39830066e-02f, -3.07116300e-01f, 7.62038678e-02f, -1.27336457e-01f, -1.39985204e-01f,
  -2.61809289e-01f, 1.70979708e-01f, 3.56981546e-01f, -1.37161821e-01f, 2.21029833e-01f, -3.11167128e-02f, -2.12280259e-01f, 2.75811613e-01f, 6.87704831e-02f, -2.48654872e-01f,
  -1.59818664e-01f, 5.03233075e-02f, -4.62176859e-01f, -5.49088895e-01f, 1.69427186e-01f, 2.07939550e-01f, -2.85306294e-02f, -1.68934628e-01f, -5.69767952e-01f, 4.27414238e-01f,
  -2.07758263e-01f, 6.69448674e-02f, 4.22330976e-01f, -1.17212506e-02f, -1.10526077e-01f, -1.51234105e-01f, -5.72792143e-02f, 1.38901457e-01f, 3.27336162e-01f, -1.91859126e-01f,
  -1.77062169e-01f, -1.90859973e-01f, 9.30183232e-02f, 1.25409558e-01f, -5.62227182e-02f, -3.82100582e-01f, 1.14324786e-01f, 5.77751659e-02f, -5.19409068e-02f, -1.88118920e-01f,
  4.17875618e-01f, -1.96755663e-01f, 6.80009499e-02f, -9.11223367e-02f, 1.38710469e-01f, -5.13014078e-01f, 3.65879893e-01f, -5.39744258e-01f, -3.27748567e-01f, 4.25999254e-01f,
  -4.74656403e-01f, 3.53676200e-01f, -4.33023930e-01f, -1.10574350e-01f, -4.04380679e-01f, -5.16431451e-01f, 9.66305733e-02f, 1.16243608e-01f, -3.10723662e-01f, 1.33785054e-01f,
  -1.80120617e-01f, -7.60407448e-02f, -8.30473006e-02f, 1.54390171e-01f, -8.49318877e-02f, -3.54105830e-01f, -2.87761837e-01f, -1.00666665e-01f, -1.83325648e-01f, -8.73362124e-02f,
  3.40364456e-01f, -2.72613198e-01f, 6.16176752e-03f, 5.57711981e-02f, -4.79019463e-01f, -4.02655751e-01f, 3.65237236e-01f, 1.69584721e-01f, -1.99425504e-01f, -5.51967502e-01f,
  -4.77113247e-01f, 3.70679349e-01f, 2.34486446e-01f, -3.56107384e-01f, -5.08824527e-01f, -6.58323169e-01f, -5.82369268e-01f, 2.07574926e-02f, 1.83287695e-01f, 1.75987050e-01f,
  -1.58404689e-02f, -1.45259559e-01f, -7.53679723e-02f, -2.09886819e-01f, 8.39690045e-02f, -8.69352072e-02f, -3.00760925e-01f, -5.26570082e-01f, -5.05561471e-01f, 1.20600916e-01f,
  -5.73427118e-02f, -3.96457821e-01f, 1.48938373e-01f, -4.16026711e-02f, 6.80760592e-02f, 1.52233220e-03f, 3.92291099e-01f, -1.06390744e-01f, 1.23423345e-01f, 2.16689464e-02f,
  -5.57530820e-01f, -5.62487729e-02f, -4.48112875e-01f, 1.20129295e-01f, 2.33606324e-01f, -3.34851146e-02f, 2.20700264e-01f, -4.09655035e-01f, 1.23052403e-01f, -4.53563362e-01f,
  1.22629903e-01f, 2.43397325e-01f, 6.23396337e-02f, 4.08683419e-01f, -1.23415060e-01f, 1.41813278e-01f, -2.38594353e-01f, -2.61013329e-01f, 2.48577625e-01f, -7.02285320e-02f,
  4.16935841e-03f, 1.96375966e-01f, -1.47996977e-01f, 2.76636451e-01f, 1.25550896e-01f, 2.72061050e-01f, -3.90087843e-01f, -4.42855895e-01f, 3.43000352e-01f, 9.49666202e-02f,
  -3.20484698e-01f, -4.78505462e-01f, -2.47658700e-01f, 3.20589811e-01f, -6.69962525e-01f, -3.06519866e-01f, 1.15460679e-02f, -4.18364793e-01f, 1.76549464e-01f, 2.34055221e-01f,
  2.48527125e-01f, 7.58833960e-02f, -1.65802941e-01f, -2.43818328e-01f, 3.34756047e-01f, -6.49175374e-03f, -3.11282761e-02f, -2.06955478e-01f, 1.50216177e-01f, -6.39202222e-02f,
  1.38164818e-01f, 5.64517677e-01f, 6.06624424e-01f, 3.76862884e-01f, -4.40795332e-01f, -3.42570335e-01f, 2.89988786e-01f, -1.56003281e-01f, 1.63970366e-01f, 2.27827922e-01f,
  4.47338074e-01f, -3.69768381e-01f, 2.62831330e-01f, 1.24820419e-01f, -4.56622124e-01f, -1.55631036e-01f, -7.54323959e-01f, 2.53272176e-01f, -6.70769513e-01f, 4.30171490e-02f,
  -3.32524151e-01f, 1.00383356e-01f, 2.35972524e-01f, 1.47152722e-01f, -2.88712323e-01f, -1.01562977e-01f, 1.58045754e-01f, 2.09180750e-02f, -2.25599423e-01f, 1.47714084e-02f,
  -7.41952136e-02f, -2.67623931e-01f, 8.17864239e-02f, 6.40729964e-02f, 2.08031312e-02f, 1.75312962e-02f, -9.34209749e-02f, 1.17876746e-01f, -4.63226497e-01f, -5.93346134e-02f,
  -5.20518184e-01f, 6.77431584e-04f, -8.01435649e-01f, 3.20558995e-01f, 2.64087141e-01f, -7.86035508e-02f, -8.59200433e-02f, -9.53787342e-02f, 1.53067946e-01f, -5.85640073e-01f,
  3.69098574e-01f, -5.57361394e-02f, 1.73502326e-01f, -4.75867510e-01f, 2.04493985e-01f, 3.31950933e-01f, -4.34663631e-02f, -2.88809657e-01f, 6.49601072e-02f, -2.69447118e-01f,
  6.61869533e-03f, -1.23133592e-01f, 2.55831420e-01f, 1.60364375e-01f, -1.08655423e-01f, -6.58126771e-02f, 1.15654781e-01f, -1.76352605e-01f, 2.01855510e-01f, 2.14296445e-01f,
  3.72278869e-01f, -1.65338561e-01f, -3.74388963e-01f, -2.17606246e-01f, -2.69785881e-01f, -5.93234241e-01f, -5.73412240e-01f, -2.98486650e-01f, 1.31049871e-01f, -3.94188970e-01f,
  5.04090965e-01f, 1.99426338e-01f, -8.72587785e-02f, 7.31737390e-02f, -6.26880527e-01f, 2.25362733e-01f, 3.61431539e-02f, 1.71759561e-01f, 1.69238284e-01f, -1.01470090e-02f,
  4.92339656e-02f, -5.79385012e-02f, 1.34663150e-01f, 5.05382232e-02f, 8.06910545e-03f, 2.81802807e-02f, 1.20165989e-01f, -3.89285207e-01f, 1.42057622e-02f, 2.96180882e-02f,
  -8.98542851e-02f, 2.34395266e-01f, -3.37945670e-01f, 1.99795067e-01f, 1.67221740e-01f, -2.69404739e-01f, -4.70595360e-01f, -3.20922524e-01f, -5.35670295e-02f, 4.52468455e-01f,
  -3.89037997e-01f, -5.98232865e-01f, -2.62381017e-01f, -8.16015229e-02f, -3.10587764e-01f, 3.68473411e-01f, 2.79539526e-01f, 2.10320756e-01f, 1.69773586e-02f, 1.89433426e-01f,
  5.04943952e-02f, 2.32769445e-01f, 1.44652143e-01f, -2.63120800e-01f, 2.29310200e-01f, 1.52074546e-01f, -1.46245405e-01f, -2.49445508e-03f, -2.54806399e-01f, 3.32929939e-01f,
  -2.74200421e-02f, 1.46285549e-01f, 3.83413583e-01f, 5.64004183e-02f, -1.90807551e-01f, 3.19729388e-01f, -4.36358809e-01f, 2.57111341e-01f, -6.11269712e-01f, -4.93222952e-01f,
  2.06265971e-01f, 3.34381282e-01f, -4.26547498e-01f, 8.32495168e-02f, 2.17552394e-01f, 2.56730467e-01f, -3.16764474e-01f, -2.71901816e-01f, -4.78447378e-01f, -2.68715471e-02f,
  -4.78728741e-01f, 2.50831485e-01f, 2.50110596e-01f, 1.12766556e-01f, 3.22468996e-01f, -1.19295739e-01f, 3.55316520e-01f, 2.10012257e-01f, -2.44608596e-01f, 6.12869486e-02f,
  1.70339718e-01f, 6.48808554e-02f, 5.77077642e-02f, 1.86331242e-01f, 3.19612384e-01f, 6.09561317e-02f, -3.41604710e-01f, 8.01168941e-03f, -3.11018109e-01f, 4.35720801e-01f,
  2.77536780e-01f, -5.58093071e-01f, -4.21851248e-01f, 1.58793721e-02f, -4.38218534e-01f, 3.27186495e-01f, 3.17113250e-01f, -2.33153835e-01f, -3.37649614e-01f, -5.31136751e-01f,
  1.57932997e-01f, 4.22563791e-01f, -7.18538404e-01f, 2.13735506e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.11650386e-01f, 4.34858724e-02f, 5.25485203e-02f, 1.85893402e-01f, 1.16194196e-01f, 1.26957223e-02f, -1.52904093e-01f, 4.43074591e-02f, -1.57200053e-01f, -1.86908126e-01f,
  -2.99710017e-02f, 6.36286587e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    