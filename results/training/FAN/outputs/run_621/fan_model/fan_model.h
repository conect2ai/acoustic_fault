/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.37059212e-01f, 9.88109186e-02f, 7.97227770e-02f, -3.15812498e-01f, -1.38563618e-01f, 1.41728511e-02f, -2.09814698e-01f, 1.61095992e-01f, -5.27236573e-02f, -1.23146266e-01f,
  9.22251791e-02f, -1.81584954e-02f, -2.28285924e-01f, 1.42682903e-03f, -1.02854781e-01f, -1.93372592e-01f, -2.36420646e-01f, -3.03493649e-01f, -9.98175368e-02f, 1.64860547e-01f,
  -3.33211757e-02f, -3.07722121e-01f, -1.15837574e-01f, 2.90801506e-02f, 9.61207412e-03f, -6.52911589e-02f, -4.64346521e-02f, 4.18464355e-02f, 1.67881712e-01f, -1.23877183e-01f,
  4.69783396e-02f, 2.68346846e-01f, -5.12522981e-02f, -6.31709024e-02f, 5.90971820e-02f, -3.24165146e-03f, -1.12599283e-01f, -1.26533527e-02f, -2.78824680e-02f, 1.54293580e-02f,
  3.31392102e-02f, 2.88337190e-02f, -7.18469080e-03f, 9.26717278e-03f, -2.04091184e-02f, 2.99472231e-02f, 4.71666716e-02f, -2.77724527e-02f, -1.74179617e-02f, 6.86390400e-02f,
  3.34364809e-02f, 2.54229791e-02f, 5.26718795e-02f, 4.53533195e-02f, 1.34558873e-02f, -7.99328163e-02f, 1.84078649e-01f, 1.49363160e-01f, 1.16032429e-01f, 7.67082870e-02f,
  -5.37814051e-02f, 4.57630642e-02f, 3.40955779e-02f, -2.13502925e-02f, -9.07067731e-02f, 3.73499393e-02f, 6.39088750e-02f, -5.70935309e-02f, 6.30122784e-04f, -2.39666980e-02f,
  8.92092809e-02f, -6.31666854e-02f, -4.38632667e-02f, 1.33676780e-02f, -5.31610325e-02f, 4.45160605e-02f, -4.48115310e-03f, -7.02042878e-02f, 6.12375923e-02f, -2.05433294e-02f,
  -2.47664824e-02f, 1.53697049e-02f, 2.07076743e-02f, 5.30908071e-02f, 3.47991921e-02f, -2.23264731e-02f, -5.52752204e-02f, 3.36906151e-03f, 9.24559906e-02f, 7.58376792e-02f,
  -3.06561917e-01f, -1.17839858e-01f, -2.24414021e-02f, 6.22024089e-02f, -5.69580719e-02f, 4.05316763e-02f, 2.14214325e-02f, 3.09307836e-02f, -4.48895656e-02f, 4.32336181e-02f,
  5.21085002e-02f, -3.62173701e-03f, -3.14383060e-02f, 1.01646550e-01f, -7.51002356e-02f, 1.91772226e-02f, -6.25436828e-02f, -1.50031433e-01f, 3.63098010e-02f, 6.21632375e-02f,
  -9.22783613e-02f, -7.25395530e-02f, -1.76107138e-01f, -7.19504803e-02f, -2.13691662e-03f, -2.38677204e-01f, -9.66465473e-02f, 2.63840035e-02f, -6.49811327e-02f, -1.95257694e-01f,
  1.15589130e+00f, -9.67301279e-02f, 8.82004350e-02f, 2.31682658e-01f, -1.61834508e-01f, -1.24865405e-01f, -2.35617071e-01f, -1.40969589e-01f, 1.48024470e-01f, -6.89809844e-02f,
  -4.61321808e-02f, 6.06417730e-02f, 8.23856220e-02f, -4.74207699e-02f, 2.13336945e-01f, -1.82632759e-01f, -1.58635646e-01f, 3.27282012e-01f, 1.00462988e-01f, -1.85347974e-01f,
  -1.66860282e-01f, 2.01451629e-01f, 4.38863426e-01f, 1.18339866e-01f, -7.71330968e-02f, -6.30995259e-02f, -1.58926681e-01f, 1.88018978e-01f, -5.55293560e-02f, 4.48293686e-02f,
  1.21031843e-01f, 2.80247107e-02f, 3.68254958e-03f, 8.58163387e-02f, -4.31629010e-02f, 4.90327328e-02f, -4.71580774e-02f, 3.16259153e-02f, -2.47669797e-02f, 2.55132709e-02f,
  -2.29929877e-03f, 2.12783534e-02f, 1.04945101e-01f, -6.78197891e-02f, 4.64123450e-02f, 1.96461584e-02f, 6.62796618e-03f, 6.36156201e-02f, 2.06730533e-02f, -1.60906062e-01f,
  -1.05859585e-01f, 1.23107694e-02f, 8.10604244e-02f, -8.57542455e-02f, 2.29935199e-02f, 1.04005404e-01f, 5.45171537e-02f, 1.05419513e-02f, 6.97432086e-02f, -5.93243800e-02f,
  -3.33419144e-02f, -4.64532450e-02f, -1.53844198e-02f, -4.15595900e-03f, -4.48256731e-02f, -1.86741035e-02f, -4.54382449e-02f, 1.73897389e-02f, -2.89613158e-02f, -8.62056483e-03f,
  1.02022977e-03f, -1.42851286e-02f, -3.02719679e-02f, 3.47717889e-02f, -1.59801915e-02f, -2.02236902e-02f, 2.72150524e-02f, -2.66560130e-02f, -1.29563594e-02f, 3.02352943e-02f,
  1.77967157e-02f, -5.97179821e-03f, -6.04935214e-02f, -2.52791774e-02f, 9.24539566e-03f, 7.20600113e-02f, -4.33500335e-02f, -3.86498496e-02f, -3.30386795e-02f, 2.68811882e-02f,
  -6.39808923e-02f, 6.10776134e-02f, -4.20655422e-02f, -1.43854380e-01f, 3.40582877e-02f, 3.66926901e-02f, -3.80870663e-02f, -2.80076731e-03f, 3.07221394e-02f, -5.34808775e-03f,
  1.27257276e-02f, 8.91734511e-02f, 7.38432445e-03f, 8.64683557e-03f, -9.30279121e-03f, -3.30354124e-02f, 7.47758849e-03f, 2.22305264e-02f, -3.45500298e-02f, 2.71625780e-02f,
  4.05340306e-02f, 6.80922046e-02f, 8.91685560e-02f, -4.57587615e-02f, -5.84142841e-02f, -3.50063480e-02f, -3.29796299e-02f, -1.24296651e-03f, -2.41284147e-02f, -8.78737867e-02f,
  -1.55784488e-01f, 2.20238566e-01f, -4.06253874e-01f, -1.00268215e-01f, 1.60103902e-01f, 2.41159841e-01f, 4.07035053e-01f, 8.14916790e-02f, -1.61055297e-01f, 1.13041490e-01f,
  1.62087187e-01f, -4.14837413e-02f, -1.88891798e-01f, -1.13645896e-01f, -1.02433316e-01f, 1.81775481e-01f, -1.85689658e-01f, -4.87477064e-01f, -2.47678727e-01f, 1.70856610e-01f,
  1.61696434e-01f, -9.48607847e-02f, -3.08411866e-01f, -2.09886685e-01f, -1.08773269e-01f, 5.12561686e-02f, 1.10695004e-01f, 1.83194757e-01f, 2.22003549e-01f, -5.07057190e-01f,
  -7.31939450e-02f, 6.03781641e-02f, -1.29934728e-01f, -5.21591399e-03f, -2.31379941e-02f, -6.73052743e-02f, 4.08033561e-03f, -5.94178624e-02f, -1.64139345e-02f, -1.43869063e-02f,
  7.49791339e-02f, -1.39132496e-02f, 1.14115439e-02f, -4.15666923e-02f, 4.46158834e-02f, 4.66179624e-02f, -2.97278762e-02f, -9.74631906e-02f, -1.29232422e-01f, 3.95235382e-02f,
  6.52314574e-02f, 6.39879927e-02f, 7.55021423e-02f, 1.21383034e-01f, 1.07474759e-01f, -1.76981062e-01f, 5.05045131e-02f, -1.18586555e-01f, -2.84198672e-02f, -1.50373578e-01f,
  4.72637406e-03f, -3.69286127e-02f, 3.43170092e-02f, 5.69998771e-02f, -9.45606269e-03f, 1.25935804e-02f, 1.35609033e-02f, 1.29106529e-02f, -2.52690781e-02f, 3.12301442e-02f,
  -1.63448825e-02f, 1.93443000e-02f, -1.92127994e-03f, 2.85524856e-02f, -6.83693811e-02f, -2.41207629e-02f, 1.68956853e-02f, -2.27270145e-02f, 3.86211909e-02f, -2.85378359e-02f,
  -6.17610440e-02f, -2.31883526e-02f, 6.10574568e-03f, -7.37986267e-02f, 4.45641167e-02f, -1.00481734e-02f, -4.56460044e-02f, 3.50496620e-02f, 4.82331701e-02f, 3.19746472e-02f,
  1.05452448e-01f, -6.32316470e-02f, -7.72837084e-03f, -5.54719344e-02f, -3.32960337e-02f, 4.44654748e-02f, -5.69400452e-02f, -5.30634671e-02f, -2.00607870e-02f, -5.26750460e-02f,
  1.58678778e-02f, 5.92953758e-03f, 2.24644598e-02f, -8.34114384e-03f, 6.70917612e-03f, 4.56758738e-02f, 3.08887288e-02f, -3.74912359e-02f, 8.17920140e-04f, -4.81632762e-02f,
  -2.30961740e-02f, 1.09474380e-02f, 1.41186148e-01f, -7.96237886e-02f, 2.24687643e-02f, 3.63149010e-02f, 1.26130104e-01f, 1.37902185e-01f, 8.43550190e-02f, 1.86181203e-01f,
  3.60516280e-01f, -3.16322207e-01f, -5.10042533e-02f, 5.56434840e-02f, -9.37236175e-02f, -4.43250574e-02f, -4.74007308e-01f, 1.27766535e-01f, 8.41158703e-02f, -3.27397913e-01f,
  1.80224970e-03f, 2.66943753e-01f, 8.18680599e-02f, 4.64983433e-02f, 1.09904774e-01f, -5.39320529e-01f, -3.99164051e-01f, 2.29348704e-01f, 5.08010864e-01f, 1.67618841e-01f,
  -6.69555813e-02f, 8.83995369e-02f, 4.20072317e-01f, 2.17487901e-01f, -3.32893729e-01f, 4.08788361e-02f, -3.12198371e-01f, -1.37836963e-01f, -9.96962786e-02f, -6.68974161e-01f,
  -7.22933114e-02f, -4.15639617e-02f, 1.46954328e-01f, 9.37813818e-02f, -4.94429022e-02f, 6.47794157e-02f, 1.09768778e-01f, 1.10627469e-02f, 3.25907371e-03f, 3.85195836e-02f,
  1.15898028e-02f, 7.99792111e-02f, 9.03427526e-02f, 1.86377745e-02f, 3.95222865e-02f, 8.67402647e-03f, 2.06032321e-02f, 8.84206817e-02f, -3.46431658e-02f, -8.73745158e-02f,
  -1.02161013e-01f, -6.68872297e-02f, -2.89117377e-02f, 2.09790412e-02f, 1.11926749e-01f, 8.06243196e-02f, 1.75255574e-02f, 1.26563460e-01f, 1.06241226e-01f, -8.73226374e-02f,
  -7.13458434e-02f, -2.86310147e-02f, 1.85894780e-02f, -8.87732878e-02f, 5.63741103e-02f, -4.23492305e-02f, 7.95529969e-03f, -4.34667207e-02f, 4.92798127e-02f, -1.21758534e-02f,
  2.69686580e-02f, -1.52648287e-02f, 3.51560712e-02f, -3.15477438e-02f, 6.65736664e-03f, 8.17693956e-03f, 1.20109990e-02f, -3.62193608e-03f, 2.91515812e-02f, -2.69130133e-02f,
  6.84275851e-02f, 1.70602668e-02f, -4.30362150e-02f, 7.73265660e-02f, -6.61053061e-02f, 4.49918769e-02f, 3.27876285e-02f, 1.66826192e-02f, 9.90038738e-03f, -4.28278409e-02f,
  6.70543686e-02f, 1.82490095e-01f, -1.08668543e-01f, 5.97751476e-02f, 1.09925726e-02f, -2.66187601e-02f, -7.98218045e-03f, 2.17289981e-02f, 5.42461015e-02f, -2.02517770e-03f,
  7.53149316e-02f, 6.03633262e-02f, -1.41964331e-02f, 1.41914133e-02f, 6.91938922e-02f, 9.26932096e-02f, -5.12629226e-02f, 1.74796991e-02f, 5.56197017e-02f, 5.04133366e-02f,
  -4.09999192e-02f, -3.85787748e-02f, 8.68063718e-02f, 9.36152320e-03f, 3.03329658e-02f, 1.36883765e-01f, -6.40185401e-02f, -1.16073698e-01f, 8.71536359e-02f, -2.07910851e-01f,
  -3.76327373e-02f, -9.61835962e-03f, 3.43322992e-01f, -1.34133892e-02f, 4.41994220e-01f, 5.02101518e-03f, 2.84770578e-01f, -1.01173632e-01f, -9.94140208e-02f, 1.95543140e-01f,
  -1.65456250e-01f, -6.83836490e-02f, -2.28438661e-01f, -1.77848518e-01f, -3.41154546e-01f, 1.35823727e-01f, 1.10800385e-01f, -1.97416879e-02f, -1.32337824e-01f, 1.76341712e-01f,
  1.99638084e-01f, 2.34082788e-01f, -1.72008276e-01f, -2.25520507e-01f, 2.21857294e-01f, 1.05723478e-02f, -1.20633096e-01f, 5.28854989e-02f, -1.27520502e-01f, 4.74441141e-01f,
  1.98422655e-01f, 1.05280735e-01f, -6.21091649e-02f, -8.58178288e-02f, 1.52269483e-01f, 1.15928516e-01f, 9.11725909e-02f, 4.23337594e-02f, -4.86883186e-02f, 3.58655676e-02f,
  4.91558015e-02f, 7.46940821e-03f, 3.98694612e-02f, 1.12274997e-01f, 2.04900876e-02f, 5.61361909e-02f, -5.93049191e-02f, -4.77284528e-02f, -8.49073604e-02f, 5.17961718e-02f,
  8.85321423e-02f, 8.77280757e-02f, 8.82175565e-02f, -1.39394656e-01f, -1.04038090e-01f, -6.84846491e-02f, -1.78174824e-02f, 1.09220517e-03f, -1.60351127e-01f, 1.47136273e-02f,
  -7.60516822e-02f, 2.21926030e-02f, 2.80159619e-02f, -4.42961082e-02f, -3.55021842e-02f, -2.11817236e-03f, 5.18089570e-02f, -4.66576368e-02f, -6.03911281e-03f, 6.08727597e-02f,
  1.36511791e-02f, -8.14076662e-02f, -3.43958521e-03f, -4.31119986e-02f, 4.68941778e-02f, 7.19672814e-02f, 9.00129080e-02f, 1.77940708e-02f, -8.83806720e-02f, 4.41571290e-04f,
  -2.51151528e-02f, 4.35513370e-02f, -1.10590598e-03f, 8.90209153e-03f, -6.88347295e-02f, -2.29620710e-02f, 4.48930152e-02f, 6.08732400e-04f, -3.76478843e-02f, 6.03347830e-02f,
  -1.70526430e-02f, -2.36215547e-01f, -4.68944811e-04f, -8.58104527e-02f, 7.18137845e-02f, -8.66473839e-02f, 1.42628630e-03f, -9.01027769e-03f, 6.25191033e-02f, 4.86516347e-03f,
  -4.14660461e-02f, -2.71048695e-02f, -2.67204158e-02f, 3.01878024e-02f, 1.69405062e-02f, 3.53398025e-02f, -6.82773963e-02f, 2.62481533e-02f, -1.18102111e-01f, 9.84624028e-03f,
  -9.02015865e-02f, 2.40673637e-03f, 1.32398792e-02f, -4.40975763e-02f, -2.49311943e-02f, 4.19723662e-03f, 8.13938901e-02f, 2.95919813e-02f, -1.29294079e-02f, -7.93141080e-04f,
  -1.21882223e-01f, 4.24135029e-01f, 1.27687842e-01f, -2.19386533e-01f, -2.77022332e-01f, -2.07387879e-01f, 1.82586610e-01f, 1.08903632e-01f, -2.57570744e-01f, 8.85082036e-02f,
  2.30085626e-01f, -1.75289795e-01f, 1.62660539e-01f, -1.08682597e-02f, 1.12980090e-01f, 5.41293882e-02f, -1.28276959e-01f, 4.99203289e-03f, -2.43757039e-01f, -2.79830873e-01f,
  -3.48952115e-01f, -6.56919032e-02f, 2.29762923e-02f, -5.61037585e-02f, -7.92308003e-02f, -1.25453755e-01f, 1.99552700e-01f, 3.95882912e-02f, 1.42888054e-01f, -1.10571958e-01f,
  1.65834442e-01f, 2.23693773e-01f, -8.92546475e-02f, -4.05730195e-02f, 1.65306240e-01f, -6.63876757e-02f, -1.07070301e-02f, 3.11897602e-02f, 2.28680950e-02f, -2.87397746e-02f,
  -3.96454446e-02f, -2.63693873e-02f, -8.18530172e-02f, -3.61846648e-02f, 5.78444116e-02f, 8.41529109e-03f, 1.86975244e-02f, 6.57675490e-02f, 5.68829104e-02f, 1.36330009e-01f,
  -4.06573080e-02f, -5.01841642e-02f, -2.42061447e-02f, 1.40637495e-02f, -2.24251812e-03f, -1.19949833e-01f, 9.30741206e-02f, -1.28959212e-02f, 5.06525673e-02f, 1.26770735e-01f,
  9.05758142e-03f, -4.41765115e-02f, -2.06698738e-02f, -3.64430882e-02f, -6.35979623e-02f, -6.57805940e-03f, 5.21684112e-03f, 2.85562817e-02f, 9.57916607e-04f, -8.13958794e-03f,
  -2.66148467e-02f, 4.07570451e-02f, 3.33415009e-02f, 3.76620777e-02f, -5.68657108e-02f, -1.10639036e-02f, -1.53381820e-03f, 6.93525672e-02f, 3.56353037e-02f, -2.43441574e-02f,
  -1.52361710e-02f, 6.53710449e-03f, 1.39419260e-02f, 8.11706856e-02f, -3.34813558e-02f, 1.50471907e-02f, -4.79153991e-02f, 5.25089204e-02f, -2.39024553e-02f, -9.33729112e-02f,
  1.13631941e-01f, -3.18555012e-02f, -2.32790466e-02f, 2.55695973e-02f, -4.17358316e-02f, 4.78506945e-02f, 4.90913615e-02f, 4.68311347e-02f, 5.65754399e-02f, 2.52260584e-02f,
  -4.18998823e-02f, 1.45862484e-02f, 6.23917617e-02f, 5.65389432e-02f, -1.13704056e-01f, -1.38928210e-02f, -2.71576028e-02f, -1.44173354e-02f, -3.60814147e-02f, -6.14442118e-02f,
  -9.02231783e-03f, -3.59251313e-02f, -1.07256718e-01f, -3.28671634e-02f, -6.81862310e-02f, -1.47312939e-01f, -6.40646443e-02f, -5.55867031e-02f, -1.88747838e-01f, 3.59600708e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.67907667e-01f, -8.41332898e-02f, -5.28885901e-01f, -3.60687785e-02f, 1.84157699e-01f, 1.47500724e-01f, 8.11759790e-04f, -1.80387385e-02f, 2.60369599e-01f, -1.92808986e-01f,
  1.38981715e-01f, 3.54403466e-01f, 3.40213403e-02f, 1.72242135e-01f, -1.21811025e-01f, -1.90976933e-01f, -4.20137011e-02f, -2.28638157e-01f, -1.38181038e-02f, 2.43142948e-01f,
  4.04729426e-01f, -6.22760616e-02f, -4.37804818e-01f, 1.76236257e-02f, 1.72133580e-01f, 1.22122481e-01f, -2.28625581e-01f, -6.49914071e-02f, -5.92739135e-02f, 9.25103873e-02f,
  -1.97437599e-01f, -2.06568867e-01f, 3.44996862e-02f, 1.02351800e-01f, -3.81045267e-02f, -1.87339202e-01f, -1.20738834e-01f, -1.86309859e-01f, 2.84732250e-03f, -6.53286651e-02f,
  -2.72574835e-02f, -2.83479169e-02f, 8.81979167e-02f, 9.28549469e-02f, -1.51203200e-01f, 7.88841397e-02f, -1.56813450e-02f, -2.07996622e-01f, -8.86133909e-02f, -1.50619656e-01f,
  3.14125448e-01f, 2.25401118e-01f, -2.61309862e-01f, 9.13612396e-02f, -2.47424766e-02f, -3.05426456e-02f, -1.17433384e-01f, 2.72882998e-01f, -1.57118693e-01f, -2.73025811e-01f,
  1.33270798e-02f, -5.75114449e-04f, 1.11736963e-02f, -1.22797973e-01f, 6.79600462e-02f, 6.97301934e-03f, -7.16538429e-02f, 3.89718972e-02f, 1.08661458e-01f, -1.86444864e-01f,
  5.48070408e-02f, -1.71441343e-02f, -4.40701917e-02f, -1.69908796e-02f, 4.79839742e-02f, -2.35591419e-02f, 9.61587727e-02f, -1.37120644e-02f, 4.99885790e-02f, 4.59202044e-02f,
  5.47749214e-02f, -2.39597121e-03f, -5.60570545e-02f, 8.87515023e-02f, 2.03881077e-02f, 4.60553840e-02f, -7.08366036e-02f, 1.87823288e-02f, -8.24742913e-02f, -7.46286362e-02f,
  -7.62939677e-02f, 6.83561489e-02f, -1.68722153e-01f, -2.33017132e-02f, 2.05002576e-02f, 8.13634172e-02f, -4.90716808e-02f, 7.65568689e-02f, -1.02175307e-02f, -7.15490133e-02f,
  6.88538002e-03f, -1.30385086e-01f, -1.14015803e-01f, 9.95911285e-02f, -1.29833510e-02f, -2.20172293e-02f, -8.62288177e-02f, 1.52231082e-01f, 9.24104676e-02f, -5.86664751e-02f,
  -8.59910399e-02f, 4.16472629e-02f, -1.34465799e-01f, -7.26627335e-02f, -1.99876595e-02f, -9.24205557e-02f, -3.67651522e-01f, -1.20475821e-01f, -2.68647164e-01f, -4.81241584e-01f,
  2.91720629e-01f, -1.06462084e-01f, -2.93354720e-01f, 7.32829094e-01f, 6.95559233e-02f, -5.02847612e-01f, -7.47111619e-01f, 8.92344024e-03f, 5.41986465e-01f, 8.96456763e-02f,
  8.05952325e-02f, 2.49288335e-01f, 1.65081441e-01f, -4.34860028e-02f, -6.58566415e-01f, -5.39096415e-01f, -3.08953136e-01f, -5.33794820e-01f, -6.75265312e-01f, -2.77244031e-01f,
  -1.05680369e-01f, -1.46825835e-01f, 1.65245719e-02f, 4.84473445e-02f, 2.85250932e-01f, 1.45184025e-01f, 2.20538840e-01f, 6.72837868e-02f, -2.72587448e-01f, 2.84275822e-02f,
  -4.25918996e-01f, 3.83774564e-02f, -8.08875933e-02f, 8.15575197e-02f, 1.48003586e-02f, 9.11165327e-02f, -1.72757879e-01f, 7.73727372e-02f, 1.21485516e-01f, 6.29901141e-02f,
  1.42278835e-01f, 1.47673890e-01f, 9.58102848e-03f, -1.12940371e-01f, 2.23060995e-02f, 5.42366058e-02f, 1.21409312e-01f, -1.50880307e-01f, 2.32366659e-02f, 1.26828730e-01f,
  -8.97950679e-02f, -2.57449985e-01f, -6.36972114e-02f, -1.03480816e-01f, -1.39450356e-01f, -1.37584597e-01f, -1.99404359e-02f, 4.93143573e-02f, -1.43347442e-01f, 1.29668489e-01f,
  1.87762827e-02f, 3.03254426e-02f, -1.73426829e-02f, 1.00258239e-01f, 1.84026733e-02f, 4.43496853e-02f, 1.61656514e-02f, -1.97087321e-02f, -9.53604132e-02f, -4.21273485e-02f,
  1.11465782e-01f, -2.17584111e-02f, -3.19514424e-02f, -1.25456613e-03f, -5.34103699e-02f, 4.14495096e-02f, -5.00857085e-02f, 7.40971342e-02f, -1.41536258e-02f, 7.96262994e-02f,
  -3.43594514e-02f, 2.08143773e-03f, 2.03499963e-04f, 4.95422259e-02f, -8.86321440e-02f, 6.20454224e-03f, 4.73895110e-02f, 2.17193924e-02f, 8.15886632e-02f, 3.09635568e-02f,
  2.67181933e-01f, -2.80600309e-01f, 8.76831189e-02f, 5.89044690e-02f, 8.82702470e-02f, 1.25250071e-01f, 6.12511486e-03f, 1.09883957e-01f, 7.65371919e-02f, -1.12323873e-02f,
  -4.30727638e-02f, -8.42752233e-02f, 9.67569556e-03f, -4.28109132e-02f, -4.88656461e-02f, -9.98430140e-03f, -1.92643218e-02f, -1.73840523e-02f, -7.74468556e-02f, 8.10449496e-02f,
  1.77557051e-01f, 9.89213064e-02f, -1.03760685e-03f, -9.29455087e-02f, 1.10011682e-01f, -7.83308148e-02f, -3.62689793e-02f, 6.91309124e-02f, -1.75802663e-01f, 1.83501318e-01f,
  1.24954969e-01f, 1.58077165e-01f, 3.09358537e-01f, 5.45033157e-01f, 3.80755901e-01f, 4.77844328e-01f, 5.13587952e-01f, 3.34349215e-01f, 2.16370344e-01f, 1.34089246e-01f,
  1.02824591e-01f, 1.51735798e-01f, 7.52539113e-02f, -4.97996397e-02f, 4.10211496e-02f, 1.96040034e-01f, 2.88335055e-01f, 3.04388301e-03f, -4.31073681e-02f, 6.15506880e-02f,
  7.33772963e-02f, -1.63085908e-01f, -2.71641970e-01f, -1.41503364e-01f, 6.39875308e-02f, 1.07420310e-01f, -8.66483599e-02f, -1.63574934e-01f, -1.82364598e-01f, -1.83942430e-02f,
  -1.75426796e-01f, 2.56578982e-01f, 1.55291185e-01f, 6.23089969e-02f, 1.26024168e-02f, -7.91472793e-02f, 7.03140944e-02f, -8.28026161e-02f, -2.29464509e-02f, -2.15345491e-02f,
  -6.32750336e-03f, -1.29531980e-01f, 3.65365185e-02f, 1.17692376e-04f, -2.57889628e-02f, -1.81042384e-02f, -7.59910792e-02f, -1.07744224e-02f, 1.65268742e-02f, 5.00866100e-02f,
  4.28593121e-02f, 1.04859956e-01f, 1.56945556e-01f, 2.08429486e-01f, 7.42542446e-02f, 6.22582734e-02f, 1.49480313e-01f, 9.27579328e-02f, 1.42430905e-02f, 6.36364296e-02f,
  1.33120164e-01f, -1.11284830e-01f, -3.34230205e-03f, -1.38451904e-01f, -2.22983629e-01f, -1.95513293e-02f, 1.82150930e-01f, -4.74036448e-02f, -3.10071465e-02f, -4.77597192e-02f,
  -2.90039205e-03f, 1.69969779e-02f, -1.67082194e-02f, 6.48416206e-02f, 5.74754998e-02f, 1.93806998e-02f, 2.95591019e-02f, -5.58082908e-02f, -7.60525987e-02f, -7.42527172e-02f,
  -4.85738963e-02f, -1.78410336e-02f, 4.30575162e-02f, -4.71424265e-03f, 1.18228728e-02f, 1.70292389e-02f, 1.33881560e-02f, -2.32533012e-02f, -5.65411448e-02f, 9.85063091e-02f,
  -1.23597465e-01f, 3.59730810e-01f, 5.04368693e-02f, -5.51216640e-02f, 1.14093348e-02f, -1.90511435e-01f, 4.26229052e-02f, -5.74446395e-02f, -3.43190543e-02f, 8.84357095e-02f,
  8.07945281e-02f, 3.93624380e-02f, 6.14509732e-02f, -5.86090870e-02f, 7.77429640e-02f, 6.84186295e-02f, -1.44609464e-02f, 7.70921335e-02f, 1.56393573e-02f, -6.86358241e-03f,
  -6.06921427e-02f, 2.97863167e-02f, 4.74648960e-02f, 2.03906104e-01f, 1.45406589e-01f, 1.55626545e-02f, -4.31012996e-02f, -4.58300114e-02f, 1.28874600e-01f, -1.04865484e-01f,
  6.04499519e-01f, 2.81713605e-01f, 2.28592321e-01f, 2.02798564e-02f, 6.47035018e-02f, 2.95311641e-02f, 2.39392683e-01f, 1.10045969e-01f, -1.73529431e-01f, 1.02219768e-01f,
  7.41883591e-02f, -2.10635513e-01f, -2.20369786e-01f, -1.51733652e-01f, 4.03276943e-02f, 2.67003179e-02f, -2.00552911e-01f, 1.41571000e-01f, 1.16642408e-01f, 2.24886745e-01f,
  -1.51761472e-01f, 4.20340560e-02f, 4.66797352e-01f, 6.89305961e-02f, 9.28800628e-02f, -3.17083925e-01f, -1.24965003e-02f, 1.03013776e-01f, 1.62056684e-01f, -9.59739368e-03f,
  6.70997147e-03f, 3.61445159e-01f, -2.48607025e-01f, 6.18184544e-02f, 3.94764021e-02f, -9.06063914e-02f, -5.30902967e-02f, 6.86182454e-02f, -7.04577565e-02f, -1.10446159e-02f,
  4.63464148e-02f, -4.26205900e-03f, 5.82712004e-03f, -3.76718715e-02f, 6.67188168e-02f, 9.74897388e-03f, 3.69438762e-03f, 1.67097256e-01f, -3.93440202e-02f, 8.47917646e-02f,
  -1.87828377e-01f, 8.91893208e-02f, 2.88353115e-01f, 6.23198450e-02f, 2.03659073e-01f, -7.01171011e-02f, 6.35572076e-02f, 1.53736055e-01f, 1.95409674e-02f, 1.15731336e-01f,
  2.82885544e-02f, 1.13384992e-01f, -2.40339693e-02f, 1.96882915e-02f, 7.11105689e-02f, -3.59514207e-02f, -1.16205029e-01f, -3.68903950e-02f, 2.13749446e-02f, 1.17408156e-01f,
  -1.51172236e-01f, -2.20923014e-02f, -1.84684321e-02f, 4.96507203e-03f, -8.26519877e-02f, 2.29332093e-02f, -1.29105840e-02f, 6.63914531e-02f, 1.01065515e-02f, 2.03102026e-02f,
  2.64276583e-02f, 1.02485821e-01f, -7.33353645e-02f, 1.44479144e-02f, 2.67338324e-02f, 2.39269305e-02f, -2.24814587e-03f, 2.83800215e-02f, 4.80108298e-02f, -1.48862489e-02f,
  -6.15292728e-01f, -3.02987397e-01f, 5.88260555e-05f, 1.78543795e-02f, 2.10198179e-01f, -4.06333990e-02f, -8.94855633e-02f, 2.45703124e-02f, -1.11228101e-01f, -9.88164693e-02f,
  4.00221460e-02f, -4.50738221e-02f, -2.92166732e-02f, 8.87396187e-02f, -5.51408343e-02f, -8.40916764e-03f, 1.07074328e-01f, -2.70230067e-03f, -3.30404192e-02f, -1.48261219e-01f,
  -1.56927779e-01f, -1.44314552e-02f, -2.51661599e-01f, -1.06766306e-01f, -1.20275676e-01f, -2.27430671e-01f, -1.55080229e-01f, -4.65749837e-02f, -5.85027672e-02f, -6.63631186e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  5.89668512e-01f, 2.86117584e-01f, -1.83980271e-01f, -1.33371800e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.47996080e-01f, 4.02135432e-01f, -2.81435903e-02f, -1.37597427e-01f, -1.33825019e-01f, 2.76974529e-01f, -1.45183638e-01f, 3.94836426e-01f, -1.78056404e-01f, 4.25428391e-01f,
  -3.87225300e-01f, 4.79354039e-02f, -5.21642268e-01f, -9.06795729e-03f, -2.12271973e-01f, 8.95991456e-03f, -5.61161861e-02f, -2.56915158e-03f, -8.59568343e-02f, -5.30953825e-01f,
  -1.80753648e-01f, 9.73792002e-02f, 2.65882611e-01f, -4.15181249e-01f, 4.92814749e-01f, 1.72514990e-01f, -3.58676314e-01f, -5.54031543e-02f, 4.60122945e-03f, 3.29051942e-01f,
  -1.87630057e-01f, -1.02963947e-01f, 5.64329103e-02f, -1.13463886e-01f, 2.30853483e-01f, 4.98926103e-01f, 2.45936334e-01f, 4.03223671e-02f, -1.22933924e-01f, -1.67895496e-01f,
  1.82671249e-01f, -3.83640230e-01f, 2.62793154e-01f, 2.98498601e-01f, -5.09968027e-03f, 2.33511880e-01f, -8.87155533e-02f, 1.61158964e-01f, -1.83876932e-01f, 3.18959862e-01f,
  2.59838521e-01f, 8.25450495e-02f, -1.05466805e-01f, -3.61812532e-01f, 7.25883916e-02f, 3.76403742e-02f, 3.74876633e-02f, 1.34845838e-01f, 3.04529637e-01f, -4.63156223e-01f,
  -1.96770042e-01f, 6.23303473e-01f, -2.96556413e-01f, -3.90399769e-02f, 8.65455270e-02f, -2.43882254e-01f, -2.76040971e-01f, 2.79135182e-02f, -1.54162243e-01f, -1.32164717e-01f,
  -1.15115151e-01f, -2.04734877e-01f, 2.27259085e-01f, -1.55463159e-01f, -8.03238824e-02f, 2.09882051e-01f, -4.30778652e-01f, -1.32217899e-01f, 6.43306896e-02f, 3.33895862e-01f,
  3.78994316e-01f, 3.19174260e-01f, 3.03367645e-01f, 7.78378248e-02f, -1.83446795e-01f, -1.60918176e-01f, -3.31975967e-01f, 2.98644155e-01f, -2.12466195e-01f, 1.87320989e-02f,
  6.74899817e-01f, -3.12788785e-01f, -3.64807174e-02f, 8.14136490e-03f, -6.19036444e-02f, 1.66292442e-03f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  8.67347494e-02f, 1.95656434e-01f, 6.87430620e-01f, 3.86832267e-01f, 3.99530172e-01f, -2.29863584e-01f, 1.47888780e-01f, -3.72965634e-01f, 5.76044440e-01f, 1.39284253e-01f,
  5.71996510e-01f, -3.51708055e-01f, -6.91989303e-01f, -9.12650645e-01f, -1.55487329e-01f, 9.17419568e-02f, -1.82322606e-01f, 3.50680202e-01f, 6.42997086e-01f, 1.19754232e-01f,
  5.16887069e-01f, 1.93849012e-01f, 2.82655656e-01f, -6.63240850e-01f, 2.94923902e-01f, -2.08878577e-01f, -3.43566149e-01f, 2.70441562e-01f, 2.40906910e-03f, 6.77989483e-01f,
  -3.98887455e-01f, -6.62919998e-01f, -2.10891098e-01f, 1.63037181e-01f, 3.25773388e-01f, -7.23918259e-01f, -9.37571302e-02f, 9.27748159e-02f, 1.84005164e-02f, -2.39308938e-01f,
  1.47360951e-01f, 2.00117439e-01f, 2.66095191e-01f, -2.15729997e-01f, 5.14349520e-01f, 5.87001331e-02f, 1.99654400e-01f, -7.47461975e-01f, 6.99296355e-01f, 4.49031562e-01f,
  -9.32216108e-01f, 1.16218120e-01f, -1.38931647e-01f, 2.98030883e-01f, -1.34505585e-01f, 4.79226232e-01f, -6.35663271e-01f, -2.62563646e-01f, 2.99837828e-01f, -1.54533265e-02f,
  1.23627312e-01f, 1.89877838e-01f, -3.03450078e-01f, 6.68167323e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.64341897e-01f, 2.32299820e-01f, -1.18820198e-01f, 2.68710315e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -4.21718895e-01f, -2.31279373e-01f, 1.71241388e-02f, 9.48653184e-03f, -3.02985251e-01f, 4.32476513e-02f, 3.09462517e-01f, 1.80143416e-01f, -3.38047236e-01f, 3.06474417e-01f,
  -4.95062679e-01f, -4.35687542e-01f, -5.44010520e-01f, -3.58974226e-02f, 2.57305324e-01f, -2.92506844e-01f, -3.50987017e-01f, 2.35910714e-01f, 2.44913667e-01f, -1.99630678e-01f,
  6.48298040e-02f, 2.38610655e-01f, 1.95317999e-01f, -2.82870978e-01f, 2.54757285e-01f, -3.78511220e-01f, -1.02463409e-01f, 1.70656562e-01f, -5.16721189e-01f, -1.70380965e-01f,
  -1.35337740e-01f, 4.65101838e-01f, -2.89953381e-01f, 3.03373486e-01f, 1.13238499e-01f, 1.33081481e-01f, -7.11579695e-02f, -5.47105409e-02f, 8.39434378e-03f, 2.70317495e-01f,
  -3.35504502e-01f, -5.46677649e-01f, -5.56399524e-01f, -7.90734068e-02f, -7.13757277e-01f, 1.55798301e-01f, 2.69087374e-01f, -5.69131792e-01f, 5.90123951e-01f, 2.84571409e-01f,
  -2.89159298e-01f, -1.77374274e-01f, 1.30286828e-01f, 6.09436296e-02f, 9.37462673e-02f, -3.84823792e-02f, 5.48324823e-01f, 1.72571257e-01f, 6.56268239e-01f, 4.78190780e-01f,
  5.03082275e-01f, 9.01807025e-02f, 1.44987881e-01f, -7.26411715e-02f, -4.98747438e-01f, 7.45670544e-03f, 1.35094553e-01f, -6.63946616e-03f, 1.33656025e-01f, 2.15723410e-01f,
  5.73760629e-01f, -2.37837911e-01f, 1.11745996e-02f, 7.99277350e-02f, -8.05163831e-02f, 9.30670500e-02f, -3.09326947e-01f, -8.41913000e-02f, 4.02506977e-01f, 5.23374677e-01f,
  2.38591745e-01f, -2.61105001e-01f, -2.65736639e-01f, 9.65720788e-03f, -5.31668589e-02f, 3.21469843e-01f, 5.58391035e-01f, -2.47323275e-01f, -2.69092381e-01f, -6.37272716e-01f,
  1.06753147e+00f, -6.37740791e-02f, -2.06523091e-01f, 8.44905153e-02f, -2.61791706e-01f, 6.21480756e-02f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  2.74342239e-01f, -7.25128174e-01f, 2.12008849e-01f, -3.40780914e-01f, -5.62610216e-02f, 5.53909957e-01f, -1.17382735e-01f, 5.02032459e-01f, -1.68792084e-01f, 1.02889383e+00f,
  -6.57617688e-01f, 1.16806984e-01f, -4.74053562e-01f, 5.63410044e-01f, 2.45964364e-03f, -7.43444920e-01f, 4.06200916e-01f, 4.06036526e-01f, 2.68416889e-02f, 3.38790625e-01f,
  1.79203629e-01f, 6.78625107e-01f, -4.06017751e-02f, 7.67183602e-01f, 6.85742199e-01f, 4.57258701e-01f, -5.38868666e-01f, -4.77181226e-01f, -2.87085533e-01f, 7.77714491e-01f,
  -4.79257792e-01f, -7.66680539e-01f, -9.38498452e-02f, 1.16010308e+00f, -5.18921912e-01f, -1.51979223e-01f, 6.62208200e-01f, 6.17934763e-01f, 4.05145407e-01f, 6.84838653e-01f,
  1.05636060e+00f, -6.13454096e-02f, 4.36052203e-01f, -3.08812588e-01f, 1.25087917e-01f, 5.33671916e-01f, -6.75795853e-01f, -3.35159183e-01f, -5.44611402e-02f, -7.28791803e-02f,
  4.12252694e-01f, 4.64180678e-01f, -2.34394670e-01f, 7.17473090e-01f, 9.56937253e-01f, 9.66528058e-03f, -3.65164638e-01f, -2.07609031e-03f, -7.94260025e-01f, -5.55967651e-02f,
  -1.49334598e+00f, 1.26347229e-01f, -8.84989977e-01f, 9.21845376e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  -1.81198478e-01f, 1.87166825e-01f, 2.78735638e-01f, 3.47950488e-01f
};

// L3_fan_Wp (Shape: 6 x 16)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.17710307e-01f, -3.14486980e-01f, -4.36409742e-01f, 2.02424869e-01f, -1.15083039e-01f, -1.54257789e-02f, -1.79709606e-02f, -1.11624196e-01f, -1.43207043e-01f, -2.13787794e-01f,
  1.89971685e-01f, -1.48037100e+00f, 5.59097230e-02f, 2.23651573e-01f, -1.72074214e-01f, -4.63720858e-01f, 2.23476384e-02f, -3.85720670e-01f, -1.81035966e-01f, 3.11538041e-01f,
  -3.57693225e-01f, -8.83561134e-01f, -2.38820255e-01f, -4.62793708e-02f, 2.98204035e-01f, -7.26647582e-03f, -1.68147311e-02f, -3.08710545e-01f, 5.64984605e-02f, -8.62546489e-02f,
  -5.55355728e-01f, -2.96674907e-01f, -5.74174598e-02f, -4.97207701e-01f, 1.37877584e-01f, -2.94106011e-03f, 3.94541733e-02f, 3.16599697e-01f, 5.81486151e-03f, 2.01335520e-01f,
  -3.98720764e-02f, -6.94001853e-01f, 1.21147633e-02f, 2.01736033e-01f, 3.61338884e-01f, -4.70572263e-02f, -5.77786505e-01f, 7.74013698e-01f, -1.58801749e-01f, 1.34275332e-01f,
  2.55480587e-01f, -1.78884238e-01f, 3.09294820e-01f, -9.48509201e-02f, -5.35931051e-01f, -1.95836499e-01f, -8.94509554e-01f, 3.83728862e-01f, 1.91669896e-01f, -7.33591437e-01f,
  -3.44579279e-01f, -9.72467847e-03f, -1.37332559e-01f, 5.19378662e-01f, 4.66300428e-01f, 1.23585247e-01f, 7.02726841e-02f, 2.63758332e-01f, -2.61552155e-01f, 1.89167506e-03f,
  5.36354423e-01f, -4.38491046e-01f, 7.72351265e-01f, -8.48267198e-01f, -5.42225778e-01f, -7.40785539e-01f, -4.56470042e-01f, -2.83337925e-02f, 6.43556565e-02f, -1.91678077e-01f,
  -1.33143142e-01f, 6.75256550e-01f, 2.09608391e-01f, 2.21865118e-01f, 8.69667828e-02f, 7.02672780e-01f, 2.58570462e-02f, -8.31222117e-01f, 5.90781271e-02f, -1.93903074e-01f,
  4.95715886e-01f, -9.68285441e-01f, -2.49923408e-01f, -2.56154716e-01f, -5.29616952e-01f, -5.07737935e-01f
};

// L3_fan_Wp_bar (Shape: 4 x 16)
const int L3_fan_Wp_bar_rows = 4;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -1.19731772e+00f, 8.03433180e-01f, -6.82610869e-01f, -2.18761668e-01f, 1.03286576e+00f, 1.77546978e-01f, -1.46826172e+00f, 3.50295186e-01f, -1.37875807e+00f, 1.17435384e+00f,
  4.58664894e-01f, 9.42954481e-01f, -7.27894485e-01f, 5.57868443e-02f, 2.88425267e-01f, 3.29010710e-02f, -1.49027303e-01f, 9.08112805e-03f, 3.59133482e-01f, 3.10233325e-01f,
  6.83394074e-01f, 4.18932468e-01f, 7.91780949e-01f, -5.60841501e-01f, 1.13446057e+00f, -2.43518010e-01f, -4.55426335e-01f, 1.41239077e-01f, 1.10586834e+00f, 1.08091199e+00f,
  6.32294655e-01f, 3.18471342e-01f, 3.09119016e-01f, 8.85326803e-01f, 3.02024573e-01f, -2.42282495e-01f, 5.13584256e-01f, 1.99007317e-01f, -1.14104545e+00f, -7.88168684e-02f,
  1.42992556e-01f, 6.38499558e-01f, -7.60406613e-01f, -4.15158242e-01f, -6.81206346e-01f, 6.26688421e-01f, 1.43092573e+00f, -2.11403742e-01f, 7.67098308e-01f, 6.04162097e-01f,
  3.73444647e-01f, 8.80473256e-01f, 3.83311838e-01f, 9.83165741e-01f, 4.25948322e-01f, 1.33734286e+00f, 2.12870374e-01f, -9.24692988e-01f, 9.62198555e-01f, -9.56618607e-01f,
  -3.68402779e-01f, 1.18105439e-02f, 8.78497139e-02f, 1.55240333e+00f
};

// L3_fan_Bp_bar (Shape: 1 x 4)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 4;
const float L3_fan_Bp_bar_data[] = {
  7.72373259e-01f, 2.17427015e-01f, 3.79318058e-01f, 4.59664881e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -6.12260938e-01f, 1.68803111e-01f, 3.88980955e-01f, -4.01303440e-01f, 2.21356690e-01f, 1.41280606e-01f, 4.83131140e-01f, 4.29699689e-01f, 1.54963708e+00f, -4.59665000e-01f,
  5.59262753e-01f, -5.47577918e-01f, -4.84803438e-01f, 6.55763984e-01f, -6.89220905e-01f, -4.28416967e-01f, 6.74644828e-01f, -6.77990377e-01f, -7.49904454e-01f, 1.11572969e+00f,
  8.24204087e-01f, 6.10758662e-01f, -6.38763845e-01f, -7.53570974e-01f, 1.42825580e+00f, 1.31491542e-01f, 6.23695254e-01f, -4.33741838e-01f, -7.66180158e-01f, 1.43382564e-01f,
  -6.73011661e-01f, 3.71586293e-01f, -3.97061497e-01f, -6.53219342e-01f, 3.70153993e-01f, -5.35032392e-01f, 7.13241577e-01f, -1.44230998e+00f, -7.90266395e-01f, -5.05128920e-01f,
  -7.33021796e-01f, 5.02856553e-01f, -6.65127039e-01f, -1.25789240e-01f, -1.48237288e+00f, -6.90262794e-01f, -1.15964448e+00f, 6.96170032e-01f, -9.70014155e-01f, -7.37978935e-01f,
  -6.59944832e-01f, 5.84071994e-01f, -1.56642377e+00f, 1.63414359e+00f, 7.21410394e-01f, -9.22858596e-01f, -9.62052405e-01f, -8.54135811e-01f, 8.72318029e-01f, -8.78252387e-01f,
  -1.01092625e+00f, -1.57421887e-01f, 5.77928543e-01f, -2.10689068e-01f, -4.98866141e-01f, -7.91687071e-01f, -2.58280843e-01f, -6.89351082e-01f, 2.84906864e-01f, -1.24029732e+00f,
  -8.16367641e-02f, -5.34420192e-01f, -1.20354509e+00f, -5.22599995e-01f, 4.54562485e-01f, 4.50042635e-01f, -9.53088820e-01f, 3.84585351e-01f, 3.28893632e-01f, -9.61734295e-01f,
  3.21642309e-01f, 3.75681192e-01f, 8.55373561e-01f, -2.51919657e-01f, 1.52764618e-01f, -6.24714851e-01f, -3.70213807e-01f, 1.20152402e+00f, -6.63343966e-01f, 8.78980100e-01f,
  -9.56027985e-01f, 6.50853753e-01f, -8.03023219e-01f, 9.80452970e-02f, 4.08887297e-01f, 1.05726905e-01f, -1.29847336e+00f, 9.26437199e-01f, 1.59113482e-01f, -4.56059098e-01f,
  -8.63954518e-03f, -1.05393124e+00f, -4.89689410e-01f, -4.23530668e-01f, 1.44075727e+00f, 8.89745593e-01f, 1.68784738e-01f, 1.14678226e-01f, 8.20063829e-01f, -2.03920037e-01f,
  -8.59327018e-01f, -2.11504012e-01f, -3.55887026e-01f, 7.37682521e-01f, 5.61461627e-01f, 7.32508540e-01f, -6.92431852e-02f, 5.65379441e-01f, 9.88006413e-01f, 1.46034133e+00f,
  -2.71725982e-01f, -8.95338953e-01f, 7.09097564e-01f, 8.71275961e-01f, -7.77839065e-01f, -8.49457204e-01f, -1.33248508e+00f, 4.81559426e-01f, 6.65523887e-01f, 7.09870875e-01f,
  2.94070840e-01f, -5.37220180e-01f, 9.88455713e-01f, -3.71745497e-01f, 1.62342930e+00f, -1.30410835e-01f, -1.05945003e+00f, 3.09947282e-01f, -8.61817539e-01f, 1.25931466e+00f,
  5.16132295e-01f, -8.48959506e-01f, 2.15467021e-01f, -6.25768602e-01f, 1.61609697e+00f, -6.66189373e-01f, -5.77056944e-01f, -7.22679853e-01f, -8.19120288e-01f, 6.44408822e-01f,
  -1.79890558e-01f, -1.31877795e-01f, 5.66970408e-01f, -7.31018901e-01f, -9.45650935e-01f, -6.93564415e-01f, 2.19361827e-01f, -7.78282404e-01f, -2.75436640e-01f, 3.72668087e-01f,
  5.27521491e-01f, -5.68990827e-01f, -9.49315786e-01f, 3.55305284e-01f, 1.11640565e-01f, -3.98677021e-01f, -5.65464556e-01f, 9.68214929e-01f, 4.87911463e-01f, 2.42090479e-01f,
  -3.05502385e-01f, -5.99049091e-01f, -3.07932012e-02f, -5.48151135e-02f, 7.02304661e-01f, -1.36638498e+00f, -4.59480137e-01f, -8.56083751e-01f, 6.73628032e-01f, 7.88240433e-01f,
  -1.17947781e+00f, 9.88784254e-01f, -1.32892764e+00f, -7.86160305e-02f, -1.00112307e+00f, 4.41240370e-01f, -5.80667555e-02f, -6.79232657e-01f, 8.76948893e-01f, -9.16014850e-01f,
  2.97592785e-02f, -1.04969287e+00f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  6.65437803e-02f, 1.13476597e-01f, -7.52724614e-03f, -3.06117713e-01f, -3.93177718e-02f, -4.00803357e-01f, 4.36978787e-01f, 2.25441396e-01f, 3.75086039e-01f, -2.47689914e-02f,
  -1.43625125e-01f, -1.62073165e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    