/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.28268915e-01f, 2.12187484e-01f, -2.21224185e-02f, -9.25517157e-02f, 1.18059851e-01f, 1.49908960e-01f, 1.57766476e-01f, 1.09952517e-01f, -1.05352975e-01f, -2.34018471e-02f,
  3.14718366e-01f, 3.02756935e-01f, 1.76838383e-01f, 1.98031366e-01f, 1.67165890e-01f, -6.27053007e-02f, -9.18034464e-02f, -1.12805352e-01f, -3.27325054e-02f, -4.00576256e-02f,
  -3.20747979e-02f, -1.77159533e-01f, -1.11314006e-01f, -1.02573924e-01f, -1.45447060e-01f, -9.45457593e-02f, -2.49480426e-01f, -7.55897388e-02f, 2.75186710e-02f, -2.87463725e-01f,
  -1.59197617e-02f, 1.09530166e-01f, -6.20352961e-02f, 1.21195629e-01f, 7.03020021e-02f, 2.02146377e-02f, -4.49414514e-02f, -1.03612561e-02f, 1.17522895e-01f, 2.70688105e-02f,
  1.01135738e-01f, 1.57706290e-01f, 1.97247013e-01f, 6.64847493e-02f, 7.13266060e-02f, -2.86670774e-02f, 3.52924913e-02f, -1.31453916e-01f, -5.89222685e-02f, -1.00888573e-02f,
  6.85031563e-02f, 3.64926457e-02f, 2.07508560e-02f, -2.74971519e-02f, 3.51316594e-02f, -3.10123060e-02f, -2.59086285e-02f, -7.00057531e-03f, -9.17882994e-02f, -3.07982117e-01f,
  -1.30620584e-01f, -2.53471043e-02f, 7.44037405e-02f, -4.76778969e-02f, 5.89965004e-03f, 7.28404224e-02f, -2.51602214e-02f, -7.09117576e-02f, -8.92927051e-02f, 9.98717733e-03f,
  1.48944840e-01f, 1.71830715e-03f, -9.30818450e-03f, 5.59788086e-02f, 2.78489031e-02f, -1.99907031e-02f, -1.90078337e-02f, -9.38556120e-02f, -7.18850195e-02f, -5.74590378e-02f,
  8.15846026e-03f, -1.69296544e-02f, 1.09654935e-02f, 9.11754221e-02f, 6.32795691e-02f, -3.63856293e-02f, -1.14709526e-01f, 8.82220864e-02f, -3.91572751e-02f, 5.53570390e-02f,
  -2.37527788e-01f, 2.28598952e-01f, -4.30342145e-02f, -2.96237953e-02f, -2.46462063e-03f, 3.44940647e-02f, 2.08245199e-02f, -5.84895909e-02f, 7.87157752e-03f, 6.95471838e-03f,
  1.68322995e-02f, 8.56761560e-02f, 1.26374602e-01f, -3.60274836e-02f, -4.44061942e-02f, -4.96330895e-02f, 2.55928766e-02f, 1.30709875e-02f, -9.51285735e-02f, -1.49730057e-01f,
  -3.02225407e-02f, -1.42521441e-01f, -5.00180312e-02f, -8.96018520e-02f, -8.91291276e-02f, -1.25532793e-02f, -3.22457179e-02f, -2.16123983e-01f, -3.18775624e-02f, -2.01670349e-01f,
  -1.43888324e-01f, 4.11404446e-02f, 2.07221106e-01f, -1.09321050e-01f, -5.45292459e-02f, -1.64973259e-01f, -2.09227502e-01f, -1.41289383e-01f, -2.02607900e-01f, -1.68255925e-01f,
  -6.05279058e-02f, -2.12008774e-01f, -9.40434262e-02f, 1.97783895e-02f, -3.28738056e-02f, -5.29398993e-02f, 8.07309076e-02f, 9.76902619e-02f, -8.95033181e-02f, -1.32425472e-01f,
  -1.69776455e-01f, -2.97947377e-02f, -7.25335926e-02f, -6.30316064e-02f, -1.37079686e-01f, -2.67004877e-01f, -5.89397475e-02f, 5.70173562e-02f, 7.88874403e-02f, 1.17789835e-01f,
  -5.54351658e-02f, 2.16578141e-01f, -9.02604312e-02f, -7.38140121e-02f, -4.90893014e-02f, -6.39564991e-02f, -1.03926808e-01f, -1.98214818e-02f, -1.88895818e-02f, -8.84269364e-03f,
  -9.40143764e-02f, -8.52697790e-02f, -3.51887122e-02f, -3.01491302e-02f, -1.56405404e-01f, -1.59695491e-01f, 9.05711029e-04f, 2.27699056e-02f, -5.49355559e-02f, -1.08806476e-01f,
  -1.23328142e-01f, -1.18145823e-01f, -5.16922027e-02f, 6.51501864e-03f, -4.79456522e-02f, -1.04923598e-01f, 1.08919255e-02f, 1.36663513e-02f, -1.66533366e-01f, -2.02007413e-01f,
  -6.65220320e-02f, -4.35910234e-03f, 1.08399145e-01f, -5.00591286e-03f, 3.61839198e-02f, -1.91373173e-02f, 9.79460776e-02f, -6.85142428e-02f, 8.34692866e-02f, -4.39521158e-03f,
  4.05312702e-02f, -7.46484548e-02f, 8.94347355e-02f, -6.51731389e-03f, -4.46170680e-02f, -7.64756650e-02f, -1.01205118e-01f, 5.55447526e-02f, 1.21900521e-01f, 8.46685246e-02f,
  -5.21543361e-02f, 6.10522144e-02f, 2.25559752e-02f, -6.35384321e-02f, -3.24440785e-02f, 3.12545858e-02f, 1.49235772e-02f, -7.13011995e-02f, -3.00691128e-02f, -7.55994022e-02f,
  -2.98903257e-01f, 1.92670912e-01f, -1.19792648e-01f, -4.44016792e-02f, 4.95400690e-02f, 4.20714878e-02f, -7.25039989e-02f, 1.08761452e-02f, -1.17676873e-02f, -1.32866859e-01f,
  -1.74670219e-02f, -1.67320184e-02f, -1.60719864e-02f, -1.23931617e-01f, -7.56363049e-02f, -4.79797088e-02f, -1.56101108e-01f, -6.60365745e-02f, -5.28602116e-02f, -1.02201194e-01f,
  -1.17782190e-01f, -1.61177471e-01f, -3.52198571e-01f, -2.00182080e-01f, -1.24731235e-01f, -1.99098304e-01f, -2.11498708e-01f, -1.91182196e-01f, -2.48964146e-01f, -3.79536539e-01f,
  -3.44844699e-01f, 2.87341237e-01f, 2.97134146e-02f, -2.63134185e-02f, 1.80740371e-01f, 2.11841464e-01f, 5.88981062e-02f, -8.02750932e-04f, -6.19976036e-02f, 1.48670256e-01f,
  4.37321156e-01f, 3.91799241e-01f, 3.05755824e-01f, 1.66111991e-01f, -3.38182189e-02f, -2.42240086e-01f, -3.17816645e-01f, -2.08533868e-01f, 2.84627806e-02f, 1.38277441e-01f,
  1.31831795e-01f, -2.21352965e-01f, -2.48035505e-01f, -4.02510352e-02f, -6.16813116e-02f, 7.05514103e-02f, 9.45244953e-02f, -3.48432139e-02f, 1.16186328e-01f, -2.16716111e-01f,
  4.69572514e-01f, 1.27072737e-01f, -2.28729378e-02f, -7.20561445e-02f, 1.16800748e-01f, -1.11916277e-03f, 1.33264795e-01f, -1.25727698e-01f, 7.76681006e-02f, -7.88700394e-03f,
  8.92495513e-02f, 3.86287794e-02f, 4.01539877e-02f, 3.22003774e-02f, -1.52234420e-01f, -3.84877734e-02f, -8.98242667e-02f, -6.54573217e-02f, -2.05884743e-02f, 1.82005048e-01f,
  1.27864584e-01f, 1.06134035e-01f, 4.53394055e-02f, -2.54203752e-02f, 6.54245019e-02f, 3.78343798e-02f, 1.51270837e-01f, -4.37044818e-03f, 2.66307127e-02f, -5.09410212e-03f,
  6.28448054e-02f, -3.73168313e-03f, 7.26609910e-03f, -7.00678229e-02f, -1.29693076e-01f, 2.75505483e-02f, -6.39156252e-02f, 2.78474372e-02f, -4.99362387e-02f, -1.02617167e-01f,
  -1.01750910e-01f, -1.28686130e-02f, 7.07915798e-02f, 2.45575346e-02f, 3.55123803e-02f, 1.16748139e-01f, -1.67883222e-03f, 7.84711167e-03f, -3.16033363e-02f, 6.02223948e-02f,
  -1.01805538e-01f, -4.65866402e-02f, -5.59144579e-02f, -6.47373348e-02f, 9.23640851e-04f, 3.87817845e-02f, -7.24676345e-03f, 5.91438301e-02f, -7.99571350e-02f, 3.14558707e-02f,
  1.89164415e-01f, 1.83899552e-01f, 6.72869235e-02f, -3.89220268e-02f, 1.14806704e-01f, 8.02819729e-02f, 2.26149917e-01f, 5.79498783e-02f, 1.21066585e-01f, 2.82224286e-02f,
  7.20286816e-02f, 1.12228312e-01f, 1.05583526e-01f, -3.49249952e-02f, 4.80795689e-02f, 1.20218536e-02f, 6.37289956e-02f, -2.63113063e-02f, 4.83668186e-02f, 7.86196738e-02f,
  -2.43274085e-02f, -1.43987434e-02f, -6.13493882e-02f, -6.22254200e-02f, 8.31762552e-02f, -1.65969692e-02f, -3.37162688e-02f, 6.19047619e-02f, -4.68784608e-02f, -1.63766637e-01f,
  6.67489707e-01f, 7.75459707e-02f, -1.11282133e-01f, 1.18403599e-01f, -1.23506650e-01f, -1.22107089e-01f, -2.26714071e-02f, -8.45392272e-02f, 1.37600034e-01f, 1.32327333e-01f,
  6.20437823e-02f, 3.31505053e-02f, -3.31842829e-03f, -9.91522744e-02f, -7.48131499e-02f, 3.67373489e-02f, -1.22228742e-01f, -1.75938055e-01f, -1.61381304e-01f, -1.02376603e-01f,
  -4.96098027e-02f, 6.04900233e-02f, 1.48146480e-01f, 8.52278098e-02f, -2.09737979e-02f, -9.69681218e-02f, -7.45469704e-02f, 9.37157795e-02f, 7.21410066e-02f, 2.87550054e-02f,
  -6.21369742e-02f, 3.66352275e-02f, -1.80319279e-01f, -2.13276483e-02f, -7.43800849e-02f, 5.68294190e-02f, 8.07536708e-05f, -7.60866031e-02f, -1.15943938e-01f, 1.81113277e-02f,
  -1.44085914e-01f, -9.75778252e-02f, -1.31210685e-01f, -9.08605158e-02f, 8.96069687e-03f, -7.25797638e-02f, -5.92443533e-02f, -1.47380233e-01f, -5.84515035e-02f, -1.04949340e-01f,
  -1.16391785e-01f, -6.36775121e-02f, -2.86752433e-02f, -3.97260934e-02f, -1.66406959e-01f, -5.71966544e-02f, -1.16861090e-01f, -9.44317598e-03f, -1.10865995e-01f, 1.38251588e-01f,
  -1.20117694e-01f, 1.54074416e-01f, 1.03452638e-01f, 6.86169341e-02f, 1.20813683e-01f, 1.14902563e-01f, 1.50155097e-01f, 5.64661808e-02f, 2.73078345e-02f, 8.85175690e-02f,
  1.33944508e-02f, 9.18610319e-02f, -3.02477255e-02f, 6.13535494e-02f, 7.96687156e-02f, 7.67631605e-02f, 7.28987437e-03f, 3.46162468e-02f, 5.17428294e-02f, 1.21335059e-01f,
  3.66704464e-02f, 9.54711959e-02f, 6.85049742e-02f, -1.24328062e-02f, 1.18941449e-01f, -4.50732782e-02f, 3.57383788e-02f, 1.23882689e-01f, 6.99729174e-02f, 5.66679910e-02f,
  2.41104573e-01f, -3.08047503e-01f, 4.29720394e-02f, -2.69107521e-02f, -4.01148349e-02f, -1.06759958e-01f, -1.02926247e-01f, -4.44758460e-02f, -1.81778833e-01f, -6.85262028e-03f,
  -4.89851274e-02f, 7.10782455e-03f, -3.29717696e-02f, -4.50421385e-02f, -1.03441805e-01f, -7.39147365e-02f, -7.21450821e-02f, -1.18524686e-01f, -2.73742136e-02f, -4.90635447e-02f,
  -5.89526780e-02f, 8.50282013e-02f, 5.02589047e-02f, 7.54370317e-02f, -2.27073580e-02f, 5.74070960e-02f, 2.53600180e-02f, -5.73813021e-02f, -6.60965070e-02f, 2.93051321e-02f,
  -1.95719987e-01f, -2.19376281e-01f, -3.06807399e-01f, -3.16158563e-01f, -2.13045448e-01f, -1.38928413e-01f, -6.45449683e-02f, -2.18151193e-02f, -1.20924115e-01f, -1.01091430e-01f,
  -2.85767056e-02f, -1.19050965e-01f, 4.24055681e-02f, -7.36398473e-02f, -1.36528552e-01f, -1.05031073e-01f, -1.92028940e-01f, -2.34100342e-01f, -2.66985983e-01f, -2.73491770e-01f,
  -1.85983732e-01f, -1.75843552e-01f, -2.23427087e-01f, -1.88019082e-01f, -1.70018643e-01f, -1.36389762e-01f, -2.52472878e-01f, -1.85725018e-01f, -1.78042665e-01f, -2.78823376e-01f,
  -1.33987650e-01f, -1.66238055e-01f, -1.01284832e-01f, -1.25908226e-01f, -1.32020056e-01f, 1.10217333e-02f, -1.29248515e-01f, -4.80821915e-02f, 5.32551631e-02f, -1.49622941e-02f,
  -2.03693226e-01f, -8.55275840e-02f, -5.24441972e-02f, -7.72023872e-02f, -7.77275860e-02f, -4.16256227e-02f, -7.97027815e-03f, -1.68932244e-01f, -1.05480067e-01f, -8.28591213e-02f,
  -1.18978810e-03f, -1.38083100e-01f, 1.39188990e-02f, -1.61126032e-02f, -1.04443811e-01f, -7.00767338e-02f, -5.91695495e-02f, -9.49724317e-02f, -3.73446047e-02f, -7.70069882e-02f,
  1.56169772e-01f, 2.73975004e-02f, -4.65832166e-02f, -7.72026193e-04f, 6.77068606e-02f, 9.25363675e-02f, 2.87611745e-02f, -1.02540385e-02f, -1.23881372e-02f, 5.86725026e-02f,
  -1.79928597e-02f, -3.61615308e-02f, 1.81904603e-02f, -6.20835423e-02f, -1.57233607e-02f, -1.14826271e-02f, 7.09204599e-02f, -1.40636470e-02f, -1.26439873e-02f, -4.38894033e-02f,
  -6.23865761e-02f, -1.27044078e-02f, -8.19721073e-02f, 1.88697577e-02f, 6.37259334e-02f, -1.22582577e-02f, 1.82984229e-02f, 8.84237234e-03f, 1.76672056e-01f, -1.65498275e-02f,
  -1.79272637e-01f, 7.81939104e-02f, -9.46837198e-03f, -7.01234564e-02f, -1.52422979e-01f, -1.15006045e-01f, -6.25146255e-02f, -4.58218977e-02f, -1.19397312e-01f, -1.56683579e-01f,
  -1.23282082e-01f, -6.09583110e-02f, -5.67653440e-02f, 2.84917350e-03f, -1.59347087e-01f, -2.06505328e-01f, -1.68103036e-02f, -6.42374158e-02f, -1.09499551e-01f, -1.07289277e-01f,
  -1.79735813e-02f, -1.18762180e-01f, 1.66785959e-02f, 1.53971799e-02f, -5.19834273e-02f, -4.89594713e-02f, -6.49945810e-02f, -3.88885774e-02f, -4.08404842e-02f, 6.49291351e-02f,
  -4.85641032e-01f, -1.77067786e-01f, 7.44422972e-02f, 7.62861818e-02f, 2.60654002e-01f, 4.15287688e-02f, -2.48646319e-01f, -9.31055620e-02f, 1.95283890e-02f, -3.04191448e-02f,
  2.41422355e-02f, 1.48580417e-01f, 5.10470755e-03f, 1.34134308e-01f, -1.07929438e-01f, -2.43503207e-04f, 2.54621264e-03f, 4.10843221e-03f, -2.37057973e-02f, 1.33026659e-01f,
  3.72535326e-02f, -1.44381002e-01f, -1.62336349e-01f, 4.53457944e-02f, 8.06013495e-02f, 9.07411799e-02f, 8.46853629e-02f, 1.14012197e-01f, 1.30137697e-01f, 2.62120605e-01f,
  1.93113700e-01f, -5.46678305e-02f, 1.17571786e-01f, 6.89801574e-02f, 1.82866320e-01f, 4.01391387e-02f, 5.39068319e-03f, 3.98637243e-02f, 1.21440634e-01f, -1.61063857e-02f,
  1.79803610e-01f, 1.60105690e-01f, 6.69717118e-02f, 1.46275073e-01f, 4.82262723e-04f, 4.04211618e-02f, 4.81473021e-02f, 4.78519537e-02f, 1.12482399e-01f, 1.13642126e-01f,
  8.10163543e-02f, 1.54227108e-01f, 1.09997086e-01f, 3.83783728e-02f, 1.20740160e-01f, 1.22438826e-01f, 1.10808864e-01f, 2.03958318e-01f, 1.59878090e-01f, -2.81280410e-02f,
  1.86777413e-02f, -3.00217583e-03f, 4.57103960e-02f, -2.89864521e-02f, -7.85536319e-02f, 6.41353726e-02f, -5.82042485e-02f, -5.51726483e-02f, -5.09918435e-04f, -1.52284622e-01f,
  5.42104430e-02f, 7.09021091e-02f, 1.00848926e-02f, -5.28186709e-02f, -2.96112001e-02f, -5.76636754e-03f, 1.98152196e-02f, -5.96456900e-02f, 1.21953916e-02f, 2.19853260e-02f,
  -1.25878835e-02f, 6.98821917e-02f, 1.59760995e-04f, -7.62397572e-02f, -3.66619765e-03f, -6.08798526e-02f, 5.80257103e-02f, 1.97497793e-02f, -1.29145846e-01f, 1.28463358e-02f,
  -2.20790163e-01f, 8.91960710e-02f, -1.80290619e-04f, -1.17652632e-01f, 1.29207626e-01f, 1.07219584e-01f, 1.29257202e-01f, 8.09424445e-02f, 1.43441141e-01f, -3.32953930e-02f,
  1.34264464e-02f, -3.68106208e-04f, 3.72422896e-02f, 5.70758246e-02f, 6.41969815e-02f, 3.53107229e-02f, 6.25608191e-02f, 5.87812476e-02f, 2.17122789e-02f, 4.24299948e-02f,
  -6.17931187e-02f, 1.89254694e-02f, -3.85648347e-02f, -6.29647374e-02f, -1.87609356e-03f, -1.07896039e-02f, 2.14901268e-02f, 1.25796452e-01f, 6.93489313e-02f, -1.44442201e-01f,
  -3.82168233e-01f, 7.55004212e-02f, -1.52842477e-01f, 2.73419227e-02f, 1.86982661e-01f, -1.49355456e-01f, -3.04906994e-01f, -5.02273776e-02f, 2.60064732e-02f, 3.28294151e-02f,
  1.49958014e-01f, 2.00204700e-01f, 3.05662658e-02f, 8.69755670e-02f, -1.67854637e-01f, -2.30871335e-01f, -1.56029269e-01f, -1.48424178e-01f, -2.31169283e-01f, 1.59804802e-02f,
  7.45315850e-02f, 6.34069815e-02f, 7.13215619e-02f, 4.06111628e-02f, 6.50623962e-02f, 2.80326288e-02f, 5.98377921e-02f, 8.07220638e-02f, 5.48331402e-02f, 8.70618224e-02f,
  -1.39933079e-01f, 3.14208008e-02f, -7.10347146e-02f, 1.24423400e-01f, -1.04446085e-02f, -3.59183289e-02f, 4.41610850e-02f, -4.63306829e-02f, 4.05655056e-02f, 6.18296750e-02f,
  8.56636465e-02f, 1.53288931e-01f, -6.22575842e-02f, -3.43355052e-02f, -5.42218331e-04f, 7.94838220e-02f, 5.12247672e-03f, -4.42380421e-02f, 6.72796881e-03f, 1.03303283e-01f,
  4.99243811e-02f, 1.53093219e-01f, 3.99350328e-03f, -5.13859503e-02f, -2.82808095e-02f, -2.82848328e-02f, 1.05604948e-02f, 1.39402732e-01f, -7.07224682e-02f, 3.64796035e-02f,
  4.78536263e-02f, 1.34172756e-02f, -6.23381771e-02f, -1.91164983e-03f, -5.82563169e-02f, 2.59467196e-02f, 1.98246855e-02f, -1.02041975e-01f, -2.56587323e-02f, 7.95683265e-02f,
  2.11153850e-02f, -2.58584134e-02f, 6.85705664e-03f, -7.99772516e-02f, 9.64580849e-02f, 1.35235302e-02f, -3.97528373e-02f, 1.17553517e-01f, -4.66462933e-02f, 2.26433836e-02f,
  3.36919092e-02f, -6.22066371e-02f, -2.33746152e-02f, 1.48621146e-02f, 4.20027971e-02f, -7.67344655e-03f, 3.31992432e-02f, 7.25861713e-02f, 4.80418280e-02f, 1.13529503e-01f,
  1.09507237e-02f, -1.20510235e-01f, -2.62227282e-02f, -3.30683589e-02f, -1.63164046e-02f, 5.32209687e-02f, 6.39000908e-02f, -4.63926382e-02f, -1.24888215e-02f, 3.83025110e-02f,
  5.72293177e-02f, 1.39442263e-02f, -8.09396580e-02f, 1.16323814e-01f, 2.94498783e-02f, 6.63208067e-02f, 6.20751530e-02f, -2.60162335e-02f, -6.73115924e-02f, 5.51067386e-03f,
  3.25576812e-02f, -1.10716233e-02f, -1.26587182e-01f, -1.70845501e-02f, -4.84277420e-02f, -9.26822200e-02f, -1.48309087e-02f, 5.94845191e-02f, -1.35589495e-01f, -1.69478692e-02f,
  -2.38779366e-01f, 4.09365177e-01f, 2.34133139e-01f, -1.24882817e-01f, -1.50708538e-02f, 6.57230429e-03f, 2.41278708e-01f, 1.04697347e-02f, -1.74433783e-01f, 1.54708177e-01f,
  8.25327337e-02f, -1.89574271e-01f, -7.53997564e-02f, -6.58934414e-02f, 7.06548914e-02f, 2.32516050e-01f, 1.49526447e-01f, -8.64990652e-02f, -3.65348876e-01f, -5.97213767e-02f,
  -3.26872244e-02f, -7.52777793e-03f, -1.71588868e-01f, -1.16842292e-01f, 8.66631866e-02f, -6.88933432e-02f, 1.14498913e-01f, 1.81677938e-01f, 2.58306563e-01f, 2.72515744e-01f,
  1.93206683e-01f, 2.54609406e-01f, -1.17494866e-01f, -3.80210616e-02f, 1.27316415e-01f, -4.44150250e-03f, 3.63845378e-02f, 1.46039039e-01f, 6.78665284e-03f, 9.94831324e-02f,
  3.05708442e-02f, 4.29645963e-02f, 3.87427099e-02f, 6.07773103e-02f, 6.87400550e-02f, 2.27362756e-02f, 1.14674181e-01f, 1.34087726e-01f, 3.42321321e-02f, 2.00712636e-01f,
  8.69881958e-02f, 1.12002574e-01f, 1.26042336e-01f, 1.32317826e-01f, 2.64871009e-02f, -4.79640514e-02f, 1.22784525e-01f, 1.28988609e-01f, 1.33164093e-01f, 1.26096159e-01f,
  -4.16291654e-02f, -5.38997687e-02f, -1.35006830e-02f, -6.59598038e-02f, -5.71776405e-02f, -3.10556237e-02f, -7.37074837e-02f, 3.07522416e-02f, -1.39407694e-01f, -2.27138139e-02f,
  -3.69861871e-02f, 1.75058283e-02f, -8.53311643e-02f, 4.15608026e-02f, -1.62542295e-02f, -4.59989719e-02f, 7.80069735e-03f, -1.15856854e-03f, -6.32421896e-02f, -5.05422279e-02f,
  -2.32552178e-02f, -3.15490663e-02f, -7.18515590e-02f, -9.76346508e-02f, 3.25771831e-02f, 4.96466756e-02f, -3.00291479e-02f, 5.53461760e-02f, -8.17040280e-02f, -1.08751968e-01f,
  -1.60188839e-01f, -1.28365271e-02f, -9.79988351e-02f, -8.84176418e-03f, -2.10493971e-02f, -5.40694520e-02f, -6.12296769e-03f, -9.70667005e-02f, 4.94470634e-02f, 7.86089618e-03f,
  4.81050760e-02f, -2.97226533e-02f, -4.30534128e-03f, 5.43503091e-02f, -1.20042741e-01f, -4.60646190e-02f, -4.05037291e-02f, -1.33100376e-01f, 1.55721698e-02f, -1.64602604e-02f,
  2.68759690e-02f, -7.73946717e-02f, -5.77786043e-02f, -2.02219449e-02f, 2.05755662e-02f, -1.53088689e-01f, -7.16202855e-02f, -9.81883779e-02f, -1.26565635e-01f, -9.10711959e-02f,
  -1.39168590e-01f, -8.91807899e-02f, -9.83644500e-02f, -2.07440048e-01f, -1.03517786e-01f, -2.24982649e-01f, -1.27185225e-01f, -3.54467362e-01f, -2.66896844e-01f, -2.14478374e-01f,
  -1.21143207e-01f, -2.74962038e-01f, -4.12055701e-01f, -3.97759289e-01f, -3.42869222e-01f, -2.01826945e-01f, -8.88336226e-02f, -1.79201692e-01f, -2.78007537e-01f, -2.85581082e-01f,
  -2.58309335e-01f, -1.22044802e-01f, -1.59394294e-01f, -2.89519846e-01f, -6.08214587e-02f, -2.41757527e-01f, -9.11909789e-02f, -4.73461905e-03f, -2.48081520e-01f, -2.91740764e-02f,
  -4.12477441e-02f, -1.35467604e-01f, -2.73324817e-01f, -3.43135029e-01f, -2.00659886e-01f, -2.87441850e-01f, -2.20325917e-01f, -2.65914321e-01f, -2.37484634e-01f, -2.93611765e-01f,
  -2.33572528e-01f, -3.04930300e-01f, -2.79134989e-01f, -2.26678267e-01f, -1.76692083e-01f, -2.32089058e-01f, -2.04099983e-01f, -3.42984259e-01f, -2.60461062e-01f, -2.09040686e-01f,
  -2.68058300e-01f, -2.29975000e-01f, -2.46153802e-01f, -3.37606519e-01f, -2.26321936e-01f, -2.31345624e-01f, -1.73242792e-01f, -2.34230503e-01f, -1.06211036e-01f, -5.30810319e-02f,
  -1.03460560e-02f, 4.14366536e-02f, 1.11340813e-01f, 3.73808928e-02f, 6.40970096e-02f, 8.91806185e-02f, 3.30822952e-02f, 2.07945332e-02f, 3.64914834e-02f, 6.75356686e-02f,
  5.77900521e-02f, 9.22774449e-02f, 6.43048286e-02f, 1.50327176e-01f, 1.00442998e-01f, 8.43933225e-02f, 2.22952534e-02f, 9.24537778e-02f, 8.71420652e-02f, 6.75183311e-02f,
  4.38545793e-02f, 1.52432591e-01f, 5.24124652e-02f, 1.03680626e-01f, 1.08751282e-01f, 1.26896217e-01f, 8.81124586e-02f, 8.72829333e-02f, 1.91249415e-01f, 1.65225238e-01f,
  -2.99240559e-01f, -2.38052219e-01f, -2.23449990e-01f, -3.07997584e-01f, -2.51842946e-01f, -2.96894670e-01f, -2.69786388e-01f, -2.92516232e-01f, -2.17880130e-01f, -1.20604225e-01f,
  -2.58120835e-01f, -3.36626530e-01f, -2.85153031e-01f, -3.36783081e-01f, -2.48219982e-01f, -2.55468726e-01f, -3.21770668e-01f, -2.86217660e-01f, -3.00929427e-01f, -1.80389345e-01f,
  -2.03279942e-01f, -2.33514130e-01f, -2.44278327e-01f, -2.20711365e-01f, -1.94179118e-01f, -2.47431740e-01f, -2.61947513e-01f, -1.14859983e-01f, -1.84950486e-01f, -1.82759732e-01f,
  6.38058901e-01f, -3.94049019e-01f, -1.70819238e-01f, 3.56789619e-01f, -6.61402717e-02f, -1.05846860e-01f, -2.75357097e-01f, -2.52824277e-02f, 1.46264493e-01f, -1.53155878e-01f,
  -9.90734696e-02f, 2.13283077e-01f, 1.55123174e-01f, 1.20096304e-01f, 9.75255221e-02f, -2.85057634e-01f, -1.42965421e-01f, 2.66099393e-01f, 4.42427814e-01f, 1.34564698e-01f,
  1.80890448e-02f, -4.17543529e-03f, 2.59535521e-01f, 9.61007625e-02f, -1.90842405e-01f, 1.31094500e-01f, -2.80159086e-01f, -1.75600529e-01f, -6.70444295e-02f, -2.57223696e-01f,
  -1.29499480e-01f, -1.85969900e-02f, 1.23144746e-01f, 5.95977083e-02f, -1.51780903e-01f, -6.89107031e-02f, 5.32252826e-02f, -8.57018009e-02f, 7.26304622e-03f, -1.12798661e-01f,
  -5.35754003e-02f, 2.07598377e-02f, 6.62188455e-02f, -8.04195255e-02f, -5.99513799e-02f, -2.58797370e-02f, -5.50668240e-02f, -8.52703210e-03f, -8.49668235e-02f, -3.28197405e-02f,
  -4.41852175e-02f, 1.29564237e-02f, -4.20573018e-02f, -1.52435992e-02f, -3.83748338e-02f, 1.09162144e-01f, -1.24170698e-01f, 1.04959525e-01f, -4.24875692e-02f, -9.38415453e-02f,
  6.06753081e-02f, -1.00351556e-03f, -3.93593609e-02f, 2.54027937e-02f, 7.50620589e-02f, -4.76809172e-03f, 7.33307824e-02f, -6.89808428e-02f, 4.89273146e-02f, -2.36815177e-02f,
  -3.33254635e-02f, -1.38651337e-02f, 6.35576546e-02f, -7.24270344e-02f, -8.03078488e-02f, 3.07609374e-03f, 6.13731286e-03f, -6.24125153e-02f, -3.05820201e-02f, 7.64361173e-02f,
  -4.25621215e-03f, -1.78424027e-02f, -5.38300201e-02f, 3.23052681e-03f, -6.37255237e-02f, 7.23442659e-02f, 5.55493981e-02f, 7.12235123e-02f, -3.39156874e-02f, 6.27545193e-02f,
  -7.75517747e-02f, 6.93477690e-02f, -8.54401886e-02f, -2.36773249e-02f, -5.35320267e-02f, -2.71060113e-02f, -7.11735785e-02f, -9.80254449e-03f, -6.54599518e-02f, 2.07118597e-02f,
  3.55288796e-02f, 2.65957229e-02f, -5.20343706e-02f, -8.66341591e-02f, -2.33441107e-02f, -2.69555543e-02f, -1.18694521e-01f, 7.87469000e-03f, 2.89863646e-02f, -5.26623502e-02f,
  -1.66112736e-01f, -1.86186116e-02f, 6.91767856e-02f, -1.10985618e-02f, 2.40428038e-02f, 1.15207776e-01f, -1.86718047e-01f, -6.10179156e-02f, 3.07804067e-02f, -1.89172789e-01f,
  1.65846720e-01f, 3.34764607e-02f, 2.44963974e-01f, 9.01069492e-02f, 9.62774083e-02f, -8.88152197e-02f, -1.91134065e-01f, -6.05148152e-02f, 9.45909992e-02f, 1.88009441e-01f,
  2.56502867e-01f, 2.50673831e-01f, 2.00009644e-01f, 7.08087385e-02f, -6.74981400e-02f, -5.61621636e-02f, -9.43272188e-03f, 9.17838365e-02f, 9.47339833e-02f, 8.93666819e-02f,
  3.49160545e-02f, 1.83107495e-01f, 3.44676673e-02f, 8.32028612e-02f, 1.94688320e-01f, 2.56184787e-01f, 7.66277462e-02f, 1.77792460e-01f, 2.41747741e-02f, 3.17926288e-01f,
  3.04098547e-01f, 9.39403921e-02f, 7.53018931e-02f, 8.24800804e-02f, 1.50390595e-01f, 1.19410224e-01f, 6.71068653e-02f, 9.79048759e-02f, 1.19871527e-01f, 6.64575398e-02f,
  1.92219734e-01f, 7.53991455e-02f, 8.36726353e-02f, 1.64434522e-01f, 1.60170123e-01f, 8.35605785e-02f, 9.43451077e-02f, 1.79495141e-02f, -6.70003239e-03f, 1.20769687e-01f,
  8.68061706e-02f, 9.82153788e-02f, 7.26059228e-02f, -2.23273933e-02f, -5.65760210e-02f, 1.14005663e-01f, 9.14821327e-02f, 1.89358786e-01f, 5.39193302e-02f, 1.90953687e-01f,
  -1.22181885e-01f, -1.05895385e-01f, -3.86377424e-02f, -2.63949595e-02f, -4.95012999e-02f, -8.44590515e-02f, -3.02787554e-02f, 2.65716687e-02f, -8.90445411e-02f, 2.35004257e-02f,
  -3.96777019e-02f, -1.08735645e-02f, -7.44162723e-02f, -6.29501715e-02f, -4.67050122e-03f, -9.60292146e-02f, -1.77813023e-02f, -1.23731956e-01f, -4.75374870e-02f, -1.00537091e-01f,
  -3.76723111e-02f, 3.44386995e-02f, -5.59782945e-02f, 5.33393770e-03f, -1.05319105e-01f, -1.76494604e-03f, -1.40649423e-01f, -1.16883539e-01f, -3.44347488e-03f, -4.54554781e-02f,
  1.06901862e-01f, -1.15814591e-02f, 2.18813136e-01f, 1.29393592e-01f, 1.64978072e-01f, 1.40290141e-01f, 8.64083543e-02f, -1.45315081e-02f, 2.04133108e-01f, 2.01576531e-01f,
  1.03142299e-01f, 9.08205360e-02f, 1.93280607e-01f, 1.36947200e-01f, 2.23328158e-01f, 1.82249904e-01f, 7.67554268e-02f, 1.78175569e-01f, 9.61536448e-03f, 1.97376862e-01f,
  1.50023058e-01f, -2.93370429e-02f, 8.86834413e-02f, 5.36972582e-02f, 1.62576392e-01f, 6.36334866e-02f, 2.16367006e-01f, 7.79386684e-02f, 7.46899098e-02f, 1.49835274e-01f,
  1.07694395e-01f, 2.89287597e-01f, 2.13169940e-02f, 1.92584485e-01f, -1.19172214e-02f, -1.88743800e-01f, -3.32405329e-01f, -7.66912773e-02f, 7.25985542e-02f, 4.44402993e-02f,
  4.98215556e-02f, -3.47594656e-02f, 1.90311763e-02f, -1.19980365e-01f, -1.56365991e-01f, -1.55503303e-01f, 8.21057111e-02f, -1.90090582e-01f, -2.62057364e-01f, -2.02479079e-01f,
  -4.76774387e-03f, -9.36477352e-03f, 1.52867585e-01f, 6.20627450e-03f, 2.84801483e-01f, 8.63941982e-02f, 3.22468847e-01f, 1.61796361e-01f, 1.29714524e-02f, 3.21962774e-01f,
  -4.55856211e-02f, 2.72309095e-01f, -4.50837724e-02f, 4.33058813e-02f, 1.28283545e-01f, 2.31626034e-02f, -1.12976665e-02f, 1.03631221e-01f, -5.97603843e-02f, 7.25686625e-02f,
  7.96454325e-02f, 1.96513683e-02f, 6.60478771e-02f, 1.17890947e-01f, 4.51200828e-02f, -8.52330327e-02f, 1.45061442e-03f, -4.55455743e-02f, 1.76622986e-03f, 8.15517083e-02f,
  -1.21226897e-02f, -3.40350382e-02f, -7.11455196e-02f, 3.28180217e-03f, -6.89971633e-03f, -9.99606028e-02f, 9.92045254e-02f, 2.20127255e-02f, 3.72557230e-02f, 1.54959872e-01f,
  -2.40550060e-02f, 1.57242976e-02f, 2.71012727e-02f, 9.81184915e-02f, -3.00575383e-02f, 1.26414597e-02f, 2.41909735e-02f, -2.30730418e-02f, 1.77855417e-02f, -5.36893234e-02f,
  7.27714505e-03f, -2.21473444e-02f, 6.27120435e-02f, 1.91045627e-02f, 2.70486958e-02f, 6.48115128e-02f, -4.70813438e-02f, 9.23030451e-02f, -4.73988019e-02f, 4.23885062e-02f,
  -8.74057040e-02f, -8.28259215e-02f, 2.37952992e-02f, -8.74581635e-02f, 1.53728547e-02f, 6.72894940e-02f, 5.08874767e-02f, 2.44446490e-02f, -7.95072988e-02f, -4.21582460e-02f,
  -4.76904884e-02f, -1.61841940e-02f, -4.66731675e-02f, -7.83644989e-02f, -5.22581376e-02f, -2.34213136e-02f, -5.90279512e-03f, 7.56804571e-02f, 6.34762272e-02f, -7.75509924e-02f,
  6.30852878e-02f, 1.88057106e-02f, 4.01060171e-02f, -4.98658791e-03f, -7.66449198e-02f, -2.25351267e-02f, 4.37198207e-02f, -1.02403216e-01f, -9.16966870e-02f, 8.01621154e-02f,
  -2.44891196e-02f, -2.06675559e-01f, -2.85305411e-01f, -1.68217063e-01f, -1.36231270e-03f, -1.28038064e-01f, -1.47406399e-01f, -4.92134094e-02f, -2.51690030e-01f, -6.29005432e-02f,
  -6.64090335e-01f, -1.54330896e-03f, 4.12899196e-01f, -1.60557583e-01f, 2.23016009e-01f, 1.97119609e-01f, 2.75741786e-01f, -1.06955171e-01f, -1.23322658e-01f, -6.67778775e-02f,
  1.83895063e-02f, -1.08901203e-01f, -1.88423488e-02f, -5.27617112e-02f, 8.48543495e-02f, 1.76620454e-01f, 1.85924381e-01f, 5.41277006e-02f, -1.25456750e-01f, -1.13550555e-02f,
  2.76894271e-02f, -1.32446587e-01f, -2.87828475e-01f, -1.31096780e-01f, -1.47267133e-02f, -7.82973766e-02f, 3.75340506e-02f, 7.66536593e-02f, 1.62827700e-01f, 7.59448633e-02f,
  -1.32092848e-01f, -5.52326180e-02f, 6.69518039e-02f, -1.43389255e-01f, 4.73458022e-02f, -6.89673498e-02f, -9.07047745e-03f, -8.96287635e-02f, -4.94594872e-02f, -2.87698787e-02f,
  5.81618436e-02f, -7.64796659e-02f, -4.55335453e-02f, -9.19798389e-02f, -1.18851347e-03f, -8.37741569e-02f, -9.82390270e-02f, 5.03138965e-03f, 2.50936523e-02f, 1.82687417e-02f,
  1.03020072e-01f, 1.74903180e-02f, 4.79924399e-03f, 3.58756073e-02f, 1.51760234e-02f, -3.23213749e-02f, 1.45038337e-01f, -2.55522430e-02f, 7.68322721e-02f, -1.39045835e-01f,
  3.41232382e-02f, 9.20977294e-02f, 5.83366267e-02f, -6.44766539e-02f, 5.98727493e-03f, 1.29238591e-02f, -2.83835892e-04f, 5.50277308e-02f, 4.11562948e-03f, -7.10526109e-02f,
  8.05028379e-02f, 6.48795217e-02f, -1.58767309e-02f, 1.61876250e-02f, 4.70189042e-02f, 3.93997841e-02f, 1.92682017e-02f, 3.56422365e-02f, -3.27089871e-03f, -5.47359437e-02f,
  -7.16881640e-03f, 1.25342906e-01f, 4.26800437e-02f, 5.10074757e-02f, 8.93741250e-02f, 4.56466116e-02f, -2.49100290e-02f, -1.99612267e-02f, 2.46500969e-02f, -2.64501180e-02f,
  -3.02025497e-01f, 2.35328987e-01f, -3.36000174e-02f, -1.80209056e-02f, -2.49502435e-02f, 2.36415900e-02f, 3.06601054e-03f, -4.43362966e-02f, -7.32580229e-05f, -3.63230221e-02f,
  5.81395254e-02f, -9.86045897e-02f, -1.68299600e-02f, 7.58188367e-02f, -8.23396891e-02f, -1.73809323e-02f, -4.27564196e-02f, -3.72051634e-02f, 2.81270985e-02f, 7.37984944e-03f,
  -4.64193560e-02f, -1.09871902e-01f, -2.63807833e-01f, -1.14194378e-02f, -1.41742371e-03f, -9.56077129e-02f, -4.93663289e-02f, -9.38926339e-02f, -7.55952904e-03f, -2.78923213e-01f,
  3.67140695e-02f, -1.09217569e-01f, -4.34020609e-01f, -2.68154562e-01f, -2.79689670e-01f, -8.90299603e-02f, -1.84026852e-01f, -9.61618125e-02f, 6.52484745e-02f, -1.97558358e-01f,
  -6.05787965e-04f, 6.99783787e-02f, -2.48877294e-02f, -3.02159134e-02f, 1.39591256e-02f, -2.74402291e-01f, -1.77508429e-01f, -1.25746980e-01f, -5.20837642e-02f, -1.53559195e-02f,
  4.91658896e-02f, 2.02248972e-02f, 1.91632882e-01f, 1.01230107e-01f, -2.03910261e-01f, -2.06630807e-02f, -2.05084220e-01f, -7.07999691e-02f, -3.61327007e-02f, -3.21266979e-01f,
  -4.26702499e-01f, -2.67593831e-01f, -1.89054623e-01f, -4.65137251e-02f, -5.69090098e-02f, -6.59600571e-02f, -1.74621165e-01f, -6.51268438e-02f, -7.43051022e-02f, -1.54063135e-01f,
  -9.24865007e-02f, -8.87160674e-02f, -1.78610499e-03f, -8.64067152e-02f, -1.52659699e-01f, 4.48595639e-03f, -4.32515368e-02f, -4.38741781e-03f, -9.49907079e-02f, -1.59411043e-01f,
  -1.84931904e-01f, -1.45762578e-01f, -1.73022673e-01f, -9.22052115e-02f, -4.32739034e-02f, -1.19060770e-01f, -1.95047274e-01f, -1.64636672e-01f, 2.51661707e-02f, -1.22183487e-01f,
  -1.24521978e-01f, 3.92060876e-02f, 7.63821751e-02f, 5.31818829e-02f, 1.05076045e-01f, 1.30591542e-01f, -4.42157723e-02f, 2.94723529e-02f, -1.00787682e-02f, 8.30429569e-02f,
  2.62116548e-02f, -5.23704365e-02f, -2.00265869e-02f, 2.96283383e-02f, 2.38520801e-02f, 4.73680086e-02f, 3.73231061e-02f, 1.19864881e-01f, 8.09007287e-02f, 7.82583654e-03f,
  1.81923155e-03f, -1.72448624e-02f, -1.29613299e-02f, 4.35731150e-02f, 5.10188863e-02f, -2.50093895e-03f, -4.17275500e-04f, 7.74589255e-02f, 9.39442068e-02f, -5.18030766e-03f,
  8.25918391e-02f, -5.01878746e-02f, -2.80233443e-01f, -6.15474358e-02f, 2.27504149e-02f, -3.59273963e-02f, -6.43287674e-02f, -2.00605877e-02f, -4.65818420e-02f, -6.89003244e-02f,
  -5.43286242e-02f, -1.16142966e-01f, -9.38301608e-02f, -1.03543125e-01f, -1.45217627e-01f, -7.28629157e-02f, 2.56649777e-02f, -8.18306431e-02f, -2.75777634e-02f, -8.48668218e-02f,
  1.67971868e-02f, 3.34800184e-02f, -8.66983011e-02f, -1.61269113e-01f, -4.55878079e-02f, -9.83020812e-02f, -7.95615539e-02f, -9.83771458e-02f, 1.14730150e-02f, 3.67274210e-02f,
  -3.93500209e-01f, -1.76730826e-01f, -4.09229025e-02f, -1.72653392e-01f, -2.48087361e-01f, -1.15826830e-01f, -5.21302894e-02f, -7.10480735e-02f, -9.52149332e-02f, -1.73299551e-01f,
  -1.85588166e-01f, -3.73143293e-02f, -7.95523170e-03f, 1.87408701e-02f, 4.30788286e-02f, -1.55868068e-01f, -1.14061363e-01f, -1.02654926e-01f, -9.54277590e-02f, -7.57051930e-02f,
  -1.53999731e-01f, -3.25606554e-03f, -6.15709499e-02f, 7.58820027e-02f, -1.04187198e-01f, -5.00679202e-02f, 1.05809271e-01f, -9.71587189e-03f, 4.44681384e-02f, -2.27595553e-01f,
  -1.18153393e-01f, -1.48399919e-01f, 1.15617998e-01f, -1.12456538e-01f, -2.50476170e-02f, -7.50119463e-02f, -1.44255191e-01f, 1.12020057e-02f, -9.31453630e-02f, -3.00266743e-02f,
  -3.53636257e-02f, -8.76818895e-02f, 1.70177745e-03f, -5.92219457e-02f, -9.50450543e-03f, -1.30767584e-01f, -5.13583273e-02f, 6.45379126e-02f, 1.79872047e-02f, -2.66552363e-02f,
  -1.00903707e-02f, -1.66941017e-01f, -1.58788472e-01f, -1.34630315e-02f, 5.15271015e-02f, -5.32000810e-02f, 1.23652455e-04f, -2.86215264e-02f, 7.06453398e-02f, -4.88645211e-02f,
  -1.35454461e-01f, -7.83819482e-02f, -6.32015839e-02f, 3.55445258e-02f, -9.08208191e-02f, 9.43291187e-02f, 5.10827377e-02f, 1.16092688e-03f, 1.97430216e-02f, -1.22179631e-02f,
  -4.15319093e-02f, -6.25257194e-02f, 5.72971217e-02f, -8.96516666e-02f, 7.00368732e-02f, -1.91713590e-03f, -9.21908244e-02f, -2.28799690e-04f, 4.07380685e-02f, -7.31158955e-03f,
  4.20989469e-02f, 7.80640990e-02f, 1.21659748e-02f, 1.02613233e-01f, -7.28334785e-02f, -1.31951915e-02f, -7.58005008e-02f, -5.55387512e-02f, -4.90404554e-02f, -4.89184074e-02f,
  9.73646194e-02f, 2.43258595e-01f, -1.18285909e-01f, -5.75791635e-02f, 5.72264232e-02f, 2.63562799e-02f, 5.05970279e-03f, 1.61900967e-02f, 4.05788235e-02f, -9.36242267e-02f,
  -9.11041424e-02f, 1.88855287e-02f, -4.02993150e-02f, 4.95580547e-02f, 3.62415724e-02f, -4.93379980e-02f, -2.79132258e-02f, -6.44347668e-02f, 1.28691658e-01f, 7.12520257e-02f,
  1.05956374e-02f, 4.48615383e-03f, -1.10396191e-01f, 6.91506267e-02f, 2.22279876e-03f, -1.07504204e-01f, -1.58758704e-02f, -3.07682585e-02f, -4.74949442e-02f, -3.73287499e-02f,
  1.04806930e-01f, -7.55922645e-02f, 3.34469408e-01f, 1.20691136e-01f, 1.57627791e-01f, 2.78819233e-01f, 3.03543687e-01f, 2.14587316e-01f, -3.89194675e-02f, -8.73219371e-02f,
  -2.60847837e-01f, -2.32559979e-01f, -2.55455494e-01f, -1.27198070e-01f, 4.31907512e-02f, 2.47174680e-01f, 2.36617059e-01f, 2.35989988e-01f, 2.06576660e-01f, 1.30221933e-01f,
  -1.12344921e-01f, 1.84971869e-01f, 2.05394372e-01f, 2.65883077e-02f, 4.31338213e-02f, -5.47406729e-03f, 5.72457537e-02f, 1.31667078e-01f, -4.70813923e-02f, 1.90923978e-02f,
  -9.02312398e-02f, 1.63468778e-01f, -4.97912057e-02f, -6.06570840e-02f, 7.57159293e-02f, -2.70548351e-02f, -1.38078397e-02f, 8.19962285e-03f, -1.45856086e-02f, 2.00242065e-02f,
  1.03419133e-01f, 1.53686285e-01f, 1.22571498e-01f, 1.54872581e-01f, 1.40663072e-01f, 2.15330318e-01f, 9.96600240e-02f, 1.23851694e-01f, 1.13827892e-01f, -2.55744066e-02f,
  -7.17940480e-02f, 1.60971522e-01f, 2.48848543e-01f, 1.49547502e-01f, 1.88070893e-01f, 1.15629911e-01f, 2.20382482e-01f, 1.63810670e-01f, 2.20572188e-01f, -3.87038253e-02f,
  -4.56570648e-02f, -7.82305822e-02f, 7.28562474e-02f, -3.48142572e-02f, 1.53782722e-02f, -9.94971469e-02f, -4.07271869e-02f, -3.36846970e-02f, 1.05311908e-01f, 1.14141770e-01f,
  -4.59053256e-02f, -5.96916005e-02f, 4.04724143e-02f, -7.53367096e-02f, -2.23087724e-02f, -1.94117650e-02f, 4.27465439e-02f, -5.38290516e-02f, 2.40844116e-03f, -5.49582280e-02f,
  1.41317592e-04f, 4.38762419e-02f, 3.78186330e-02f, -8.73242691e-02f, -4.57132570e-02f, 3.56535241e-02f, -1.09590821e-01f, -1.71206531e-03f, -7.82773644e-03f, -8.11921731e-02f,
  -1.88378677e-01f, 1.19976349e-01f, -1.23200782e-01f, -4.39426117e-02f, 1.61580369e-01f, 2.28924453e-02f, 3.87866818e-03f, 7.71306381e-02f, 8.33002180e-02f, -1.50050297e-02f,
  1.06394753e-01f, 8.93794671e-02f, -7.06013739e-02f, 4.93552648e-02f, 1.01591170e-01f, 6.16786294e-02f, -6.32236386e-03f, 8.88109505e-02f, 7.69351646e-02f, -2.92336605e-02f,
  7.63160959e-02f, 8.13274607e-02f, 2.49516182e-02f, 9.09411684e-02f, 2.73557976e-02f, 1.03374317e-01f, -1.81140434e-02f, -1.20150540e-02f, 1.60744995e-01f, 3.84531990e-02f,
  -3.52196604e-01f, -1.34964615e-01f, -1.36683643e-01f, -4.89356257e-02f, -1.51491780e-02f, -1.55346826e-01f, -2.84324348e-01f, -7.30027035e-02f, 2.17939131e-02f, -7.96867162e-02f,
  -1.26594290e-01f, 7.24801868e-02f, 7.21647739e-02f, 1.40135512e-01f, 5.90764498e-03f, -1.37567595e-01f, 2.89070071e-03f, -3.64156887e-02f, -5.37313037e-02f, -1.97633319e-02f,
  1.39491305e-01f, 8.91652107e-02f, 4.81707864e-02f, 4.06448953e-02f, 3.68660130e-02f, 9.22605023e-03f, -3.68859582e-02f, -1.47032291e-02f, -1.07344789e-02f, 8.47178847e-02f,
  -7.17770979e-02f, 6.66640624e-02f, 1.02014437e-01f, 1.67788807e-02f, 1.30662397e-01f, 6.87619075e-02f, -4.30479040e-03f, 4.41391766e-02f, 5.83700426e-02f, 5.99829890e-02f,
  9.51705053e-02f, 1.23057291e-02f, 1.36232316e-01f, 6.51068687e-02f, 8.55092406e-02f, 8.43094941e-03f, 1.02531806e-01f, 1.20543756e-01f, 9.73098353e-02f, 1.89618971e-02f,
  1.54436707e-01f, 7.75597021e-02f, -5.66910282e-02f, 5.88853881e-02f, 8.96731168e-02f, 5.92769757e-02f, 1.51859015e-01f, 9.00421143e-02f, 3.25440690e-02f, -7.52511919e-02f,
  -4.97521646e-02f, -9.11613181e-02f, -1.05436906e-01f, -1.29278630e-01f, -1.52713373e-01f, -9.58115608e-02f, -6.53314814e-02f, -5.78880049e-02f, -1.46420747e-01f, -7.29692578e-02f,
  -8.85091573e-02f, -1.35365680e-01f, -8.38011205e-02f, -9.87754017e-02f, -1.63061470e-01f, -1.11708380e-01f, -1.60172507e-01f, -5.41859716e-02f, -1.01378582e-01f, -9.56487730e-02f,
  -6.10271208e-02f, -1.32953271e-01f, -1.93886712e-01f, -3.29981782e-02f, -1.39893442e-01f, -7.29890540e-02f, -1.10272974e-01f, -1.37576804e-01f, -7.95988142e-02f, -9.61948261e-02f,
  -4.19276804e-02f, 3.70807648e-02f, -9.99962073e-03f, 6.54213727e-02f, 1.69060454e-02f, 1.25968814e-01f, 4.22509834e-02f, 1.78327933e-01f, 1.03621945e-01f, -3.88007052e-02f,
  -5.35488687e-02f, -1.64371524e-02f, 1.01060696e-01f, 4.52803746e-02f, 2.57894006e-02f, -4.51755896e-03f, -8.23316630e-03f, 1.36874495e-02f, 1.19256392e-01f, 7.72213265e-02f,
  1.29392222e-01f, 5.74499229e-03f, -4.85299937e-02f, -1.04344292e-02f, 9.62041542e-02f, -1.30209671e-02f, -8.08336884e-02f, -4.68591170e-05f, -1.45074934e-01f, -1.85429543e-01f,
  -3.61380965e-01f, 2.08106622e-01f, 2.38863826e-01f, -6.75831586e-02f, 1.15754314e-01f, 1.01850234e-01f, 2.08030432e-01f, 2.79942900e-02f, -1.32372081e-01f, 1.11805245e-01f,
  1.64623156e-01f, 7.32158124e-02f, 7.82909319e-02f, 1.27603918e-01f, 3.87590826e-02f, 2.31738299e-01f, 2.43591383e-01f, 5.97238503e-02f, -8.30805302e-02f, 1.28097519e-01f,
  1.44640863e-01f, -1.98250376e-02f, -3.00512137e-03f, -2.80461665e-02f, 3.09191048e-01f, 2.45847836e-01f, 3.04236948e-01f, 2.84242123e-01f, 2.91989118e-01f, 5.69654346e-01f,
  2.47018054e-01f, 2.49103889e-01f, 1.02260575e-01f, 1.46530062e-01f, 2.67702281e-01f, 1.34202480e-01f, 2.69238770e-01f, 1.36407509e-01f, 1.55910268e-01f, 1.48675293e-01f,
  2.19748870e-01f, 1.05060503e-01f, 9.69571546e-02f, 3.02243561e-01f, 2.23773971e-01f, 2.21300960e-01f, 1.33743554e-01f, 1.14250429e-01f, 2.22406268e-01f, 2.38589391e-01f,
  2.82679945e-01f, 1.66597977e-01f, 2.99716324e-01f, 2.02832058e-01f, 2.38397047e-01f, 1.06064990e-01f, 2.47970819e-01f, 2.95020521e-01f, 2.57102489e-01f, 3.19983363e-01f,
  9.69457161e-03f, -1.07388720e-02f, -8.98434445e-02f, 1.60469189e-02f, -1.19877398e-01f, -6.55753613e-02f, -3.75586897e-02f, -5.11333160e-02f, -6.08967803e-02f, -5.17312177e-02f,
  -7.24570677e-02f, 5.08429855e-02f, -4.50501665e-02f, -5.19121997e-02f, -2.57744454e-02f, 2.11469438e-02f, 8.90331790e-02f, 1.07107908e-02f, -1.18661125e-03f, -2.36615003e-03f,
  -7.75736570e-02f, -3.06559056e-02f, -8.71661827e-02f, 4.38230904e-03f, 3.38526070e-02f, 9.98726115e-03f, -6.10142481e-03f, -7.59377424e-03f, -7.58911148e-02f, -4.68098000e-02f,
  -1.16219865e-02f, -2.80786809e-02f, 1.57918751e-01f, 2.09030181e-01f, 1.15154348e-01f, 1.48061156e-01f, 1.55129984e-01f, 1.47597313e-01f, 1.01255551e-01f, 1.89083084e-01f,
  2.23797947e-01f, 2.03572720e-01f, 1.61776111e-01f, 1.69379234e-01f, 1.45144194e-01f, 1.42101809e-01f, 1.33013397e-01f, 1.47742957e-01f, 1.61273047e-01f, 2.54071921e-01f,
  6.41519949e-02f, 1.39964685e-01f, 1.46710038e-01f, 1.10995799e-01f, 2.09254682e-01f, 9.01490375e-02f, 3.28972906e-01f, 1.99880049e-01f, 1.62311986e-01f, 8.51402432e-02f,
  -9.08387452e-02f, 2.74532318e-01f, -1.17346779e-01f, 4.20611463e-02f, 1.13190569e-01f, 2.00506866e-01f, 3.93207401e-01f, 1.70477718e-01f, 7.97967091e-02f, 1.03616334e-01f,
  -8.02615359e-02f, -2.90226251e-01f, -2.79506832e-01f, -1.29612356e-01f, -1.53301239e-01f, 1.79488361e-01f, 9.21304375e-02f, -8.07782784e-02f, -2.69619197e-01f, -9.69090685e-02f,
  -3.79089899e-02f, -3.16237658e-02f, -1.22012891e-01f, -9.49198976e-02f, 6.43784031e-02f, -1.37976483e-01f, 5.76310195e-02f, -1.28501486e-02f, -5.24463765e-02f, 2.50447653e-02f,
  -3.09122443e-01f, 1.42397031e-01f, -9.64590982e-02f, -4.56221327e-02f, -2.58331769e-03f, 4.08984423e-02f, -1.11097442e-02f, -3.60764042e-02f, -4.37888801e-02f, -4.13168147e-02f,
  5.97471185e-02f, 1.02524431e-02f, -3.30076069e-02f, 8.70418027e-02f, 2.13237144e-02f, -4.93150018e-02f, 5.76922484e-02f, 4.06192616e-02f, -5.84618608e-03f, -1.66974701e-02f,
  1.11673526e-01f, 4.65799831e-02f, -3.31702642e-03f, 1.00361645e-01f, 1.35221288e-01f, 2.30510682e-02f, 1.04910828e-01f, 1.16620407e-01f, -2.46632695e-02f, 2.13916879e-02f,
  1.84765428e-01f, 6.76821247e-02f, -5.04355244e-02f, 9.47084129e-02f, -8.61637201e-03f, -7.12249428e-03f, -5.71313500e-02f, -3.31674404e-02f, -2.22320966e-02f, 4.53200601e-02f,
  -9.72204432e-02f, 4.59663197e-02f, -8.31553191e-02f, -2.98373010e-02f, -9.36687086e-03f, 6.91108853e-02f, -6.89086020e-02f, -1.73499100e-02f, -1.16504878e-01f, 3.15871835e-02f,
  -5.41079491e-02f, -1.46613633e-02f, -3.27750742e-02f, -7.51190186e-02f, 6.10450879e-02f, 4.52652425e-02f, 4.44706716e-02f, 1.94091946e-02f, 1.64691806e-02f, 7.33006299e-02f,
  -2.85301983e-01f, -1.35227963e-01f, 6.92928657e-02f, -2.36020386e-02f, -9.25886706e-02f, 1.71197280e-02f, 2.59012524e-02f, 3.75849679e-02f, 1.05285749e-01f, -4.30286713e-02f,
  -2.25856956e-02f, -7.84928910e-03f, -1.21724799e-01f, -3.73170301e-02f, 1.19660012e-02f, -6.30524233e-02f, 6.49844110e-02f, -1.02815337e-01f, -8.14217795e-03f, 1.00347787e-01f,
  1.18701965e-01f, 2.44200286e-02f, -1.26626715e-01f, -6.22580387e-02f, 6.48048241e-04f, -1.16613410e-01f, -8.99573043e-03f, -6.23360053e-02f, -6.93069771e-02f, 5.08364923e-02f,
  -2.12041408e-01f, -3.20872009e-01f, 8.82674605e-02f, -2.73233324e-01f, -9.71643031e-02f, 1.29458815e-01f, -1.55772343e-01f, -2.17038080e-01f, -1.16636746e-01f, -1.70679033e-01f,
  6.26909062e-02f, 1.85585633e-01f, 1.04164772e-01f, 9.76054147e-02f, 1.42134190e-01f, -2.66598195e-01f, -2.74968088e-01f, 5.55336066e-02f, 2.36612096e-01f, 1.12554789e-01f,
  -1.49662569e-01f, -2.32533962e-01f, -3.56449224e-02f, -9.48062614e-02f, -1.48629278e-01f, -3.37278731e-02f, -6.73087984e-02f, -1.61931083e-01f, -9.83284786e-03f, -1.54126450e-01f,
  2.26024866e-01f, 4.42453772e-02f, 8.51287395e-02f, -3.45786177e-02f, 4.52797413e-02f, -8.92639812e-03f, -7.36178532e-02f, -7.42159635e-02f, -6.78735077e-02f, -1.62371323e-01f,
  3.53653170e-03f, -2.31173839e-02f, -1.21884964e-01f, -5.18248193e-02f, -1.63797334e-01f, -2.98846443e-03f, -1.55002400e-01f, -1.04897447e-01f, -4.23617512e-02f, -1.10880002e-01f,
  -6.50987253e-02f, -1.16099656e-01f, -4.47039977e-02f, 5.83031960e-02f, 8.85307267e-02f, 4.13526222e-02f, -9.64765903e-03f, -9.47957560e-02f, 4.12437133e-02f, -2.04119265e-01f,
  -9.51323211e-02f, 1.33986533e-01f, 3.89805622e-02f, 2.95658372e-02f, 4.86172549e-02f, 6.07589185e-02f, 7.55693316e-02f, 5.71484119e-02f, 5.72875328e-03f, 2.82608233e-02f,
  2.91663595e-02f, 1.02516450e-01f, 1.13079802e-03f, 1.52992830e-01f, 7.43851587e-02f, 4.31899540e-02f, -4.67133000e-02f, -1.91000775e-02f, 6.08049631e-02f, 2.57773548e-02f,
  2.86416039e-02f, 1.07332937e-01f, -7.00524449e-02f, 4.53296080e-02f, 1.25411764e-01f, 2.91924290e-02f, -3.54480483e-02f, 6.66564181e-02f, 5.47091439e-02f, -2.01255269e-02f,
  -1.62017480e-01f, 1.82468429e-01f, -6.48545325e-02f, -6.28888011e-02f, -1.47913307e-01f, -7.37922341e-02f, 1.01284552e-02f, -3.94702004e-03f, 8.11243802e-02f, 1.14737311e-02f,
  -5.64866103e-02f, -2.93730181e-02f, -1.54899403e-01f, -2.33288705e-02f, -5.65193705e-02f, -4.42801602e-02f, -1.49303243e-01f, 3.53234634e-03f, -3.90574373e-02f, -1.07067101e-01f,
  -7.02486262e-02f, -2.06069410e-01f, -1.49515405e-01f, -5.92961628e-03f, -1.69032943e-02f, -1.97161268e-02f, 4.76984158e-02f, -5.44517078e-02f, -6.29406571e-02f, -3.04336399e-01f,
  1.18462108e-01f, 7.00439885e-03f, 2.75422215e-01f, -7.81187564e-02f, 1.23157062e-01f, 1.18991591e-01f, 2.54132539e-01f, 3.09515372e-02f, 2.29631122e-02f, -7.35142920e-03f,
  -3.23746093e-02f, 3.90593074e-02f, -5.41760102e-02f, -1.56054716e-03f, 2.94405043e-01f, 2.31535867e-01f, 3.14040065e-01f, 3.51998866e-01f, 4.01647061e-01f, 2.42753819e-01f,
  9.46951881e-02f, 2.17142388e-01f, 2.29787841e-01f, 3.45836431e-02f, 8.48227516e-02f, 3.72708440e-02f, 1.17924437e-01f, 2.01692581e-01f, 1.43905759e-01f, 1.36711612e-01f,
  4.12525743e-01f, 2.79752463e-01f, 1.25635758e-01f, 8.80363882e-02f, 1.40420824e-01f, 1.35881826e-01f, 1.14834055e-01f, 1.63607553e-01f, 2.38074567e-02f, 1.37761191e-01f,
  2.70987432e-02f, 9.41610858e-02f, 1.29761085e-01f, 1.32962316e-01f, 5.62476404e-02f, 1.34462819e-01f, 1.55704543e-01f, 2.26913705e-01f, 1.01869315e-01f, 1.15999110e-01f,
  -8.39586407e-02f, 1.00535922e-01f, 2.17668846e-01f, 1.14010923e-01f, 1.12420000e-01f, -4.82866950e-02f, 1.99564882e-02f, 1.18341766e-01f, 9.37796980e-02f, 5.73316216e-02f,
  -3.31262429e-03f, -1.73981171e-02f, -7.63483346e-02f, -4.71437089e-02f, -8.59794542e-02f, -1.93850081e-02f, 3.48495729e-02f, 1.07111577e-02f, -8.01235437e-03f, -4.33364958e-02f,
  -5.08722626e-02f, -3.08719277e-02f, -1.23776905e-01f, 1.10959224e-02f, -4.14469130e-02f, -1.13087543e-03f, -9.00090784e-02f, -1.23717152e-01f, -7.72863626e-02f, -4.04292271e-02f,
  -1.69996638e-02f, -8.38696957e-02f, -3.23433653e-02f, -4.01180349e-02f, 1.84853803e-02f, -1.74879819e-01f, 4.01838906e-02f, -7.74543956e-02f, -9.23147053e-02f, -7.27452803e-03f,
  1.20442234e-01f, 1.82630643e-02f, 4.86438088e-02f, 1.89963773e-01f, 1.23624086e-01f, 2.62721870e-02f, 1.59757142e-03f, 1.09494962e-01f, -3.96801718e-03f, 7.36018419e-02f,
  4.17762548e-02f, -3.90400626e-02f, 5.87247387e-02f, 1.32644102e-01f, 3.08963172e-02f, 1.18937507e-01f, 8.09907392e-02f, 9.95034128e-02f, 1.01178862e-01f, 5.02784848e-02f,
  8.09390396e-02f, -4.12036516e-02f, 3.10034771e-02f, 6.12455904e-02f, 5.08562811e-02f, 1.57013573e-02f, 1.30255058e-01f, 1.56920522e-01f, 4.10637483e-02f, 3.77804041e-02f,
  -2.63818771e-01f, 2.95105070e-01f, 1.20368369e-01f, -1.88953698e-01f, -1.86330333e-01f, -5.37388399e-02f, 1.09059162e-01f, 1.66327521e-01f, -1.10793114e-01f, -5.43529121e-03f,
  7.78820887e-02f, -1.96690381e-01f, 4.78793913e-03f, -3.44004706e-02f, 1.47620916e-01f, 1.67624742e-01f, -3.68917473e-02f, -1.47408500e-01f, -3.44283253e-01f, -2.59357005e-01f,
  -2.55603582e-01f, -3.53775531e-01f, -3.40690136e-01f, -1.74691513e-01f, -8.67263228e-02f, -2.00731337e-01f, -3.40405367e-02f, -1.54267251e-01f, -1.68507874e-01f, -2.20361859e-01f,
  6.88776225e-02f, 5.55624329e-02f, 9.21728164e-02f, -8.65348708e-03f, 3.57509926e-02f, 1.14709139e-01f, 7.52526000e-02f, 1.56907085e-02f, 1.10211268e-01f, 8.96052197e-02f,
  1.85906682e-02f, 9.83080734e-03f, -5.95655628e-02f, -1.30844191e-02f, -2.70166136e-02f, 4.35289042e-03f, 7.42331371e-02f, 1.07691707e-02f, 5.80075607e-02f, 1.06186010e-01f,
  1.17703453e-01f, -1.12548374e-01f, 2.76944321e-03f, 9.87358391e-02f, 4.59473096e-02f, -1.71253115e-01f, 1.44726723e-01f, 8.31936076e-02f, 1.51801882e-02f, 7.80044794e-02f,
  1.46274477e-01f, 3.43444757e-02f, 8.01411457e-03f, -4.24696468e-02f, -1.08294733e-01f, 4.91245762e-02f, -1.11883566e-01f, -2.25108545e-02f, -9.06215161e-02f, 1.13587514e-01f,
  1.49997333e-02f, 2.89748367e-02f, 2.63616946e-02f, 1.17550045e-02f, -2.06876900e-02f, -4.30631228e-02f, -4.93805930e-02f, -1.58152319e-02f, -5.03392220e-02f, -2.46715304e-02f,
  -1.08481720e-01f, -7.06004957e-03f, -7.51789883e-02f, -6.56557605e-02f, -2.94733662e-02f, -7.77808530e-03f, -1.82527769e-03f, -8.63559619e-02f, 9.37518198e-03f, 6.58753589e-02f,
  1.06179923e-01f, -1.84354633e-02f, -3.16003934e-02f, 9.17212889e-02f, 1.64455891e-01f, 1.12529933e-01f, 4.58894037e-02f, 1.24700136e-01f, -3.96767408e-02f, 3.88238057e-02f,
  1.60737503e-02f, -4.54414543e-03f, 6.66540265e-02f, -1.51613690e-02f, -1.39438331e-01f, -8.81560706e-03f, -1.39698163e-02f, -7.33170211e-02f, 8.01812187e-02f, 8.21190029e-02f,
  1.14841796e-01f, 4.39466797e-02f, -6.38104603e-02f, 1.12583280e-01f, 4.28209975e-02f, -8.11484456e-02f, 9.75269526e-02f, 2.94442791e-02f, 6.25956655e-02f, 2.63486624e-01f,
  1.17944986e-01f, -6.83505535e-02f, -1.71283185e-02f, 2.20780119e-01f, -6.55220542e-03f, -2.30756372e-01f, -3.43172759e-01f, -1.99795957e-03f, 2.44878128e-01f, -1.45208105e-01f,
  -4.14323583e-02f, 3.80963266e-01f, 2.01883614e-01f, 1.59456953e-01f, 1.71668865e-02f, -1.29024938e-01f, 1.22648470e-01f, 2.26677820e-01f, 2.87623078e-01f, 1.25743479e-01f,
  1.80361032e-01f, 5.63502777e-03f, 4.44532037e-02f, 1.79914400e-01f, 8.51045623e-02f, 1.00518376e-01f, -1.71909004e-01f, -3.93237099e-02f, -1.01316556e-01f, 3.06440264e-01f,
  -1.36062596e-02f, 3.49065871e-03f, 2.21940085e-01f, 9.57011878e-02f, 5.43360822e-02f, 1.19333908e-01f, 4.63197455e-02f, 9.96399820e-02f, 1.23244904e-01f, 5.45830429e-02f,
  8.34758207e-02f, 1.33725002e-01f, 2.02540278e-01f, 1.45469844e-01f, -6.11124374e-02f, 1.44616008e-01f, 1.35129765e-01f, 2.16110945e-01f, 1.02755956e-01f, 1.25664815e-01f,
  1.59257337e-01f, 1.18186148e-02f, -5.63138425e-02f, 5.47939725e-02f, 6.71756789e-02f, 2.68666536e-01f, 3.37470733e-02f, 1.26412377e-01f, 2.66226642e-02f, 1.08450688e-01f,
  9.33593661e-02f, 6.03783224e-03f, -5.64342886e-02f, -6.27138689e-02f, -6.81598037e-02f, -2.87753996e-02f, 8.21538344e-02f, -7.85870999e-02f, -2.76024044e-02f, 1.00427866e-02f,
  6.52994365e-02f, -6.72321022e-02f, -7.27559626e-02f, 3.19745243e-02f, -2.40882766e-02f, 3.43115330e-02f, -5.80918193e-02f, -4.61629294e-02f, -6.44366741e-02f, -9.35739353e-02f,
  9.41954628e-02f, -1.09633869e-02f, -6.34443313e-02f, 1.05792664e-01f, 4.76423465e-02f, -1.96521841e-02f, 3.59678902e-02f, 2.14011781e-03f, -3.52299027e-02f, -1.12289317e-01f,
  -1.24626979e-01f, 6.53594062e-02f, 6.11000434e-02f, 7.87138343e-02f, -4.06330526e-02f, 6.54276982e-02f, 3.39604616e-02f, 9.07578021e-02f, 4.05403301e-02f, 1.28967855e-02f,
  -8.24385211e-02f, 2.66285986e-03f, -1.21315047e-02f, 8.56155604e-02f, -2.72529069e-02f, 1.03426278e-02f, -6.92907870e-02f, 1.11349277e-01f, 7.64629394e-02f, -1.00996932e-02f,
  6.78099841e-02f, -3.55872475e-02f, -3.62862274e-03f, 4.18174379e-02f, 8.68787691e-02f, -5.83696812e-02f, -2.09777784e-02f, -6.51634932e-02f, -8.83553736e-03f, -1.96595177e-01f,
  1.16855025e-01f, -2.04485476e-01f, 3.45114619e-01f, 6.03515543e-02f, 7.83879533e-02f, 2.18421426e-02f, -1.17456593e-01f, -1.96840316e-01f, -7.05383793e-02f, -2.05439441e-02f,
  -3.84299234e-02f, -2.30838768e-02f, -7.77301863e-02f, 2.99482681e-02f, -2.21543908e-01f, -1.21600978e-01f, 8.30283314e-02f, 1.81008339e-01f, 1.07201124e-02f, -2.04600319e-02f,
  -5.13201244e-02f, 7.85321370e-02f, -8.08824524e-02f, -7.53972307e-02f, 1.71902999e-01f, 1.34077594e-01f, 1.27296463e-01f, 2.71844953e-01f, 1.47468969e-01f, 4.21796679e-01f,
  3.59709442e-01f, 3.01456023e-02f, 5.57843782e-02f, -6.69372007e-02f, 1.29565462e-01f, -2.03548688e-02f, -5.42602912e-02f, 6.33656085e-02f, -6.29270747e-02f, -5.37773594e-02f,
  9.33444314e-03f, 3.02252043e-02f, 1.03911147e-01f, -7.19022611e-03f, -5.62259220e-02f, -4.65473393e-04f, -9.77433175e-02f, -9.46000740e-02f, 4.98514995e-02f, -3.23179236e-04f,
  -3.27267647e-02f, 4.28159535e-02f, 6.13141730e-02f, -1.38285935e-01f, -1.42691031e-01f, 7.90409371e-03f, 1.04747489e-01f, 8.80926549e-02f, 6.41333535e-02f, 1.13509610e-01f,
  -1.04507871e-01f, 1.60588205e-01f, 1.40675217e-01f, 6.93734288e-02f, 1.66617364e-01f, 2.19955370e-01f, 2.06589505e-01f, 1.85219973e-01f, 1.09639026e-01f, 1.16392203e-01f,
  3.80697399e-02f, 1.44396231e-01f, 6.69811890e-02f, 1.08576573e-01f, 1.29772589e-01f, 1.00410394e-01f, 2.11523056e-01f, 1.02320664e-01f, 1.07360885e-01f, 8.34380537e-02f,
  1.19713210e-01f, 6.69811293e-02f, 2.15080902e-01f, 9.93300676e-02f, 1.55889347e-01f, 1.92941472e-01f, 1.68514609e-01f, 1.29444927e-01f, 2.54438352e-02f, 8.55519809e-03f,
  -1.18796937e-01f, -6.06021611e-03f, -3.08995210e-02f, -4.35318649e-02f, 3.49211209e-02f, -5.15737422e-02f, 8.69175121e-02f, -9.54645425e-02f, 1.38787627e-01f, 2.84025655e-03f,
  1.41816428e-02f, 9.54089407e-03f, -2.92094629e-02f, -7.70165622e-02f, -6.76064864e-02f, -8.81325919e-03f, -2.01192815e-02f, 7.79713765e-02f, -4.72387969e-02f, -1.24940239e-01f,
  -1.73904449e-01f, -1.98944554e-01f, -9.60425436e-02f, -1.52121484e-01f, -1.46925692e-02f, -3.22040394e-02f, -4.93365936e-02f, -1.94768514e-02f, -7.38081336e-02f, -6.59661293e-02f,
  -1.78947553e-01f, -5.14641739e-02f, 4.64277379e-02f, 6.29477575e-02f, 9.79537070e-02f, -1.58084840e-01f, -3.85931641e-01f, -2.56724745e-01f, -4.84053567e-02f, -1.43857375e-01f,
  1.98558077e-01f, 2.35778615e-01f, 1.19214699e-01f, 7.61279538e-02f, -1.68811470e-01f, -2.59535491e-01f, -2.28485823e-01f, -3.73654813e-02f, 1.21579118e-01f, 4.06798013e-02f,
  1.00784630e-01f, -3.80461290e-02f, 7.15330467e-02f, 4.25331295e-02f, 5.45397326e-02f, 2.08474323e-01f, 1.33008391e-01f, 8.50063264e-02f, 8.43177810e-02f, 9.94455535e-04f,
  5.68457916e-02f, -1.24693468e-01f, 6.16633072e-02f, 2.73073427e-02f, 1.12612218e-01f, -3.52465175e-02f, -4.42185216e-02f, 3.61454561e-02f, -9.24874768e-02f, -3.35464031e-02f,
  3.30986604e-02f, 8.03671032e-02f, 3.31882164e-02f, 3.51691842e-02f, 3.20267081e-02f, -4.86771483e-03f, 3.96206528e-02f, -2.76362393e-02f, -3.26144248e-02f, -7.28463903e-02f,
  8.44661817e-02f, 9.23601761e-02f, -2.09606886e-02f, 4.01633978e-02f, 4.00899202e-02f, 4.16927785e-02f, 5.63666709e-02f, 2.19752137e-02f, 1.95557028e-02f, 4.55515161e-02f,
  1.33481780e-02f, 1.01522595e-01f, 5.55954166e-02f, 1.28785614e-02f, 6.13779686e-02f, 4.07664701e-02f, 5.30502498e-02f, -1.80846453e-02f, 2.88370457e-02f, 1.01023354e-01f,
  2.41106730e-02f, 1.76479146e-02f, 3.65944132e-02f, -7.12388679e-02f, 1.01818897e-01f, 4.92142886e-02f, 1.01942562e-01f, 3.46818492e-02f, 4.60149124e-02f, 1.55278295e-02f,
  -1.53757688e-02f, -7.73087190e-03f, 1.44019574e-01f, -2.31726188e-02f, -4.35606167e-02f, 7.34345615e-02f, 1.33000985e-01f, 8.81723836e-02f, 1.67775765e-01f, 5.44677563e-02f,
  5.48216002e-03f, 6.01848252e-02f, -3.05400137e-02f, -6.32617474e-02f, -9.61749256e-03f, 4.77943756e-03f, -3.75037231e-02f, 4.19185683e-02f, -3.99113037e-02f, -1.12990893e-01f,
  -2.09829621e-02f, -1.36865884e-01f, -1.18824571e-01f, -3.22646424e-02f, 1.27120176e-02f, -1.12565942e-02f, -3.18498947e-02f, -4.80653346e-02f, -3.83220874e-02f, -3.62541527e-02f,
  -1.34167522e-01f, -4.08586264e-02f, -2.81402841e-03f, 5.01353070e-02f, -6.05975017e-02f, 1.79875121e-02f, 9.26177427e-02f, 7.34973475e-02f, 6.43887594e-02f, 1.92718878e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.75786567e-01f, 4.46630061e-01f, 1.75846249e-01f, 6.42809346e-02f, 6.05501188e-03f, -1.62074283e-01f, 2.48065591e-02f, -6.30454794e-02f, -7.50447214e-02f, 2.06575215e-01f,
  2.37276524e-01f, -2.06345841e-01f, -2.02617757e-02f, -2.10716560e-01f, -2.09180936e-01f, 8.61825794e-02f, -4.13476676e-02f, -2.02342078e-01f, -5.35693944e-01f, -3.78122300e-01f,
  -1.74607128e-01f, 7.53348097e-02f, 2.33708955e-02f, -2.08417684e-01f, 3.03207159e-01f, -1.24714538e-01f, 2.36635998e-01f, 1.57189593e-01f, 1.93527564e-01f, 2.51218140e-01f,
  3.00050914e-01f, 5.40118337e-01f, -3.17372978e-01f, 1.10063843e-01f, 1.63723886e-01f, -5.66505007e-02f, -1.03467308e-01f, 4.92252037e-02f, 4.18119133e-02f, -5.93304709e-02f,
  2.92110622e-01f, 6.17032349e-02f, 1.05246916e-01f, -7.16137663e-02f, -1.32418633e-01f, -1.40779883e-01f, 5.06739505e-02f, -3.20181847e-02f, -1.59273192e-01f, 7.88721293e-02f,
  6.84497282e-02f, 1.44254431e-01f, 6.15990795e-02f, -1.09352365e-01f, 3.37595455e-02f, -7.25878179e-02f, 1.07959257e-02f, -1.22113049e-03f, -2.14344844e-01f, 1.78397968e-01f,
  -1.09255888e-01f, 1.34626850e-01f, 9.26475450e-02f, -1.24010853e-01f, -1.88949376e-01f, -3.87973431e-03f, -2.06304230e-02f, -2.14358270e-02f, -1.02797784e-01f, -2.02720612e-02f,
  -1.43363759e-01f, -6.38387576e-02f, -1.15295850e-01f, -5.97091839e-02f, -1.01603046e-01f, -1.02577787e-02f, -9.07467306e-03f, -9.63674784e-02f, -4.55778241e-02f, -9.14868116e-02f,
  -1.53503353e-02f, -2.99239270e-02f, 7.78335184e-02f, 3.90473455e-02f, 5.06103262e-02f, -2.22750768e-01f, -1.39319658e-01f, -1.27066374e-01f, 1.99524313e-02f, 1.28837228e-01f,
  -2.99184501e-01f, -1.38446897e-01f, -1.07243747e-01f, 6.52573407e-02f, 1.93839878e-01f, 1.27680928e-01f, 1.33714154e-01f, 5.01347631e-02f, 3.46895978e-02f, -9.10027102e-02f,
  5.24432324e-02f, -1.24401540e-01f, 8.34321007e-02f, -5.68390004e-02f, -1.75346345e-01f, 8.01532157e-03f, 3.13879810e-02f, 2.89957877e-03f, -8.30951333e-02f, -4.42844518e-02f,
  -1.44720361e-01f, -1.97836772e-01f, -1.45709306e-01f, -1.37676179e-01f, -8.49476382e-02f, -3.25733334e-01f, -2.57124957e-02f, -4.32845280e-02f, -1.76002309e-01f, -2.32518792e-01f,
  -3.04993659e-01f, 1.76172629e-02f, 9.79014412e-02f, 1.50484219e-01f, 1.45162508e-01f, 1.00253165e-01f, 1.79297272e-02f, 6.22903258e-02f, 5.72313368e-02f, 1.49492830e-01f,
  1.00836866e-01f, 2.74049193e-01f, 2.06854090e-01f, 9.81709138e-02f, 1.70675546e-01f, 1.62654296e-01f, 8.86338875e-02f, -6.69826427e-03f, 4.14960794e-02f, 1.01230115e-01f,
  3.64768915e-02f, -8.83483514e-02f, -1.76523849e-01f, -7.59626273e-03f, 1.39446840e-01f, 1.37041137e-01f, 2.57113017e-02f, 8.57524872e-02f, 1.85259599e-02f, 1.14985131e-01f,
  3.75015527e-01f, 3.67688201e-02f, 6.59253895e-02f, -4.24392372e-02f, -4.97534312e-02f, -1.19422646e-02f, -5.33259213e-02f, -5.07762469e-02f, 1.56056033e-02f, 8.63404348e-02f,
  -7.62931481e-02f, -6.40934035e-02f, -1.73287690e-01f, -5.67497015e-02f, -1.78690217e-02f, -2.50167437e-02f, -1.04200959e-01f, 1.29200548e-01f, 1.92549899e-01f, 1.68015301e-01f,
  6.63054315e-03f, 7.15586469e-02f, 1.37620419e-01f, 6.13802858e-02f, 7.67034367e-02f, -3.83395655e-03f, 5.81796616e-02f, -4.05667499e-02f, 7.92695507e-02f, 5.71859367e-02f,
  2.55577322e-02f, -2.68357638e-02f, 1.32397279e-01f, 4.29120213e-02f, -2.70342082e-03f, 7.92889595e-02f, 4.82472591e-02f, 3.74855809e-02f, -1.68212671e-02f, -1.08393505e-01f,
  -1.61397383e-01f, 1.76047176e-01f, 1.29870728e-01f, 9.28685665e-02f, 6.82272017e-02f, 7.55370185e-02f, -5.60917258e-02f, 3.27452123e-02f, 4.78014238e-02f, -1.91142652e-02f,
  -5.31287538e-03f, -8.59697610e-02f, -1.47873983e-01f, -1.75885886e-01f, 1.32855605e-02f, -4.68011089e-02f, -8.96980017e-02f, -1.45040914e-01f, -2.24205807e-01f, -9.35690105e-02f,
  4.92127419e-01f, 1.99080318e-01f, 8.02655369e-02f, -8.87128413e-02f, -3.55051421e-02f, -8.96841437e-02f, 1.64157286e-01f, 9.22034606e-02f, 6.95138350e-02f, 1.68357804e-01f,
  1.57768056e-02f, -3.37302089e-02f, -1.94012165e-01f, 3.07410341e-02f, -9.75728408e-02f, -2.31861323e-02f, 4.02886309e-02f, 1.24193184e-01f, 2.20573545e-01f, 1.69211626e-01f,
  2.12576776e-03f, 1.33473113e-01f, 1.22493215e-01f, 2.29057521e-01f, 1.52056202e-01f, 9.07422230e-03f, 8.98405463e-02f, -9.64645892e-02f, 2.48697959e-02f, -2.06383355e-02f,
  1.25621585e-02f, -1.69626057e-01f, 4.64812219e-01f, 1.49175823e-01f, -3.06893259e-01f, -4.92178142e-01f, -7.35038936e-01f, -4.32315558e-01f, -2.19047386e-02f, -4.26304415e-02f,
  -1.75442442e-01f, 3.03099193e-02f, 7.90821109e-03f, 1.26791805e-01f, -2.06355769e-02f, 3.05404365e-02f, 3.38209271e-01f, 2.85756886e-01f, -6.26542643e-02f, -1.16648719e-01f,
  -1.30082175e-01f, 1.82170197e-01f, 2.02592820e-01f, 1.29110813e-01f, 2.52374023e-01f, -5.36929630e-03f, 2.08698601e-01f, 6.04163483e-02f, -1.27504483e-01f, 5.15869260e-01f,
  3.02124381e-01f, -1.27068490e-01f, -1.17212854e-01f, 3.61774452e-02f, 7.19701946e-02f, 9.14150923e-02f, 5.57880402e-02f, 2.57086575e-01f, 1.44378915e-02f, 1.98652163e-01f,
  1.53651953e-01f, 4.58684750e-02f, -8.44680518e-02f, 5.40891513e-02f, -1.52685836e-01f, -5.62801249e-02f, 2.33020753e-01f, 1.79627180e-01f, 1.31918162e-01f, 2.58715581e-02f,
  2.10587326e-02f, -6.52237609e-02f, -9.25111696e-02f, -2.24083632e-01f, -1.36486292e-01f, 2.12145559e-02f, -2.09503949e-01f, 1.18721195e-01f, -8.45860839e-02f, -5.06057264e-03f,
  -1.28780946e-01f, -7.43449777e-02f, 5.17928451e-02f, -2.18982752e-02f, 3.35681550e-02f, -3.29822078e-02f, 1.94934104e-02f, -9.47422236e-02f, 2.17425805e-02f, 6.01462089e-02f,
  -7.98821002e-02f, 1.35653587e-02f, -6.41445396e-03f, -4.87802811e-02f, 4.17311527e-02f, 1.10123202e-01f, 2.39399336e-02f, -2.57107038e-02f, 4.71958630e-02f, 2.69934684e-02f,
  -3.36559713e-02f, 1.37770340e-01f, 9.88225639e-02f, 1.02004707e-01f, 1.69761274e-02f, 1.36003733e-01f, 1.01171695e-01f, 1.98168959e-02f, 6.58993796e-02f, -1.71840638e-02f,
  -8.77442062e-02f, -1.47476807e-01f, 1.35025710e-01f, 1.54895838e-02f, 2.18026806e-03f, -4.76715304e-02f, 9.89328772e-02f, -1.23421177e-02f, -7.16046095e-02f, -1.93948671e-02f,
  -1.52099922e-01f, -5.61288781e-02f, -1.39104063e-02f, 8.55635926e-02f, -8.11390057e-02f, -4.03416954e-04f, 1.07249781e-01f, -1.10790782e-01f, 4.82005347e-03f, 1.09325610e-01f,
  -7.72251422e-03f, -3.45671564e-01f, -3.38846624e-01f, -1.87384218e-01f, -5.90398759e-02f, -1.84952840e-01f, -3.08664113e-01f, -2.26046547e-01f, -3.45308632e-01f, -4.19017255e-01f,
  -7.18611479e-01f, -1.94366500e-01f, -4.24246222e-01f, 6.04990795e-02f, 3.67443562e-01f, 9.41786021e-02f, -5.31395674e-02f, -3.85655686e-02f, -4.72074598e-02f, -1.49225160e-01f,
  -4.35287170e-02f, 2.68262863e-01f, 1.18079811e-01f, 8.84474888e-02f, -2.01712310e-01f, -1.06806144e-01f, 2.52779812e-01f, -1.14639271e-02f, -6.67467387e-03f, 2.46911913e-01f,
  2.31505245e-01f, 2.65595317e-02f, -1.92001715e-01f, 1.56233400e-01f, 1.64708614e-01f, 1.23836532e-01f, -8.12982097e-02f, 2.08107736e-02f, 1.63557768e-01f, 1.41494557e-01f,
  -1.58778474e-01f, -2.77838320e-01f, 2.96192267e-03f, 9.38092265e-03f, 3.94041725e-02f, -2.26641938e-01f, -2.46953666e-01f, -2.62821436e-01f, -1.02219604e-01f, -2.25452960e-01f,
  1.78572953e-01f, -3.47400928e-04f, 1.62544966e-01f, -2.76385602e-02f, -1.20567098e-01f, -1.31678045e-01f, -1.11683235e-01f, -2.10512325e-01f, -3.37899774e-01f, -2.32716680e-01f,
  4.81662691e-01f, 3.38855714e-01f, -2.34611347e-01f, -2.02324949e-02f, -2.08008662e-01f, -9.52062085e-02f, -1.88682992e-02f, 1.25321180e-01f, -2.30929241e-01f, -3.20076138e-01f,
  6.41562343e-02f, 1.05132200e-02f, -1.78045437e-01f, -7.18342140e-02f, 8.65196958e-02f, 4.20043953e-02f, 1.89352110e-01f, 1.23387218e-01f, 2.14991421e-01f, -7.02135786e-02f,
  4.24165204e-02f, -6.31060153e-02f, -2.11597066e-02f, -5.95852882e-02f, 5.89325689e-02f, 5.07989563e-02f, 9.98372957e-02f, 2.86355186e-02f, 3.56085673e-02f, -1.33202849e-02f,
  3.49393189e-02f, -2.77873743e-02f, -5.59982955e-02f, 6.82464764e-02f, -8.52515697e-02f, -4.97447401e-02f, -3.03197224e-02f, -1.72254190e-01f, -1.07355058e-01f, -9.16204751e-02f,
  -1.54212773e-01f, 6.07800670e-02f, -5.59794344e-02f, 6.57112300e-02f, 3.20315473e-02f, -5.67418570e-03f, 5.38322106e-02f, 1.15709096e-01f, -3.89251020e-03f, -2.17155471e-01f,
  -1.31428003e-01f, -1.79061145e-02f, 2.58082338e-02f, -7.47313276e-02f, -9.75123420e-02f, -8.57435167e-02f, -1.25199221e-02f, 1.84863657e-02f, 3.19638513e-02f, -1.51475798e-03f,
  -6.46435097e-02f, 9.53548180e-04f, -2.43494734e-01f, -1.17357351e-01f, -1.90358102e-01f, -7.21508637e-02f, -2.76184510e-02f, -1.37109950e-01f, -2.87833601e-01f, -4.96508420e-01f,
  -5.25922298e-01f, -1.54505193e-01f, -2.35733226e-01f, -5.00139713e-01f, -3.62694114e-01f, -2.54145741e-01f, -4.79960650e-01f, -7.02398196e-02f, -7.32539669e-02f, -3.55762154e-01f,
  -3.34852152e-02f, 2.61237144e-01f, 5.45737110e-02f, 5.83622605e-02f, 7.12654665e-02f, -5.07762432e-01f, -4.14880902e-01f, -1.40149802e-01f, 3.27099860e-01f, 1.66382611e-01f,
  -1.63744971e-01f, -2.60050416e-01f, -9.82203558e-02f, 5.80827855e-02f, -2.26877689e-01f, 3.86744849e-02f, -3.03096205e-01f, -1.59864545e-01f, 1.35720717e-02f, -3.46343428e-01f,
  -3.65069732e-02f, 5.71050905e-02f, -8.06365758e-02f, -7.32133863e-03f, -2.18685389e-01f, 2.19867360e-02f, -3.26506421e-02f, -7.87709504e-02f, 2.95828329e-03f, -1.59404069e-01f,
  -4.04817984e-02f, 4.88858558e-02f, -1.28464222e-01f, 1.16228890e-02f, -1.12235226e-01f, -7.66768977e-02f, -1.37728184e-01f, -1.62866618e-02f, -2.11281516e-02f, 1.30661607e-01f,
  8.35831314e-02f, 2.95812525e-02f, 9.42921788e-02f, 9.91438925e-02f, 6.09367900e-02f, 2.59664245e-02f, 1.31701544e-01f, 1.74046695e-01f, 1.41922399e-01f, -1.38025537e-01f,
  -8.47140327e-02f, 5.38689569e-02f, 5.77957928e-02f, 2.13159826e-02f, 2.62703225e-02f, -3.86818731e-03f, -6.59323782e-02f, 2.90909279e-02f, -6.36346340e-02f, 4.55794632e-02f,
  -6.74878955e-02f, -1.06548712e-01f, 2.44563334e-02f, -6.56024367e-02f, -4.33628522e-02f, 8.78057703e-02f, 1.13296034e-02f, -3.05972863e-02f, -4.21092436e-02f, -3.40689197e-02f,
  5.52928075e-02f, 1.23664178e-01f, -1.84172448e-02f, 9.27388966e-02f, 3.86921950e-02f, -1.68989569e-01f, -1.82529148e-02f, 1.68614656e-01f, 3.16815376e-02f, 6.31368458e-02f,
  -1.03535786e-01f, 1.21856220e-02f, -2.40969449e-01f, 1.07992254e-01f, 1.21971304e-02f, 9.11727175e-02f, 2.98716724e-02f, 4.01369557e-02f, -6.60248399e-02f, -7.61554688e-02f,
  1.06457107e-01f, 4.17808183e-02f, -6.63171113e-02f, 3.70813214e-04f, -1.55925676e-01f, 4.01149653e-02f, 1.20735704e-03f, 5.53462990e-02f, 1.09863840e-01f, 4.17011529e-02f,
  -3.94761413e-02f, 6.06666841e-02f, 3.58799435e-02f, 6.46319911e-02f, 1.18890725e-01f, -1.82943512e-02f, -4.41617630e-02f, 1.19550273e-01f, 1.63845271e-01f, -1.56460330e-01f,
  4.38540608e-01f, -8.28869864e-02f, -3.08800101e-01f, 3.81072521e-01f, 1.31969720e-01f, -3.98783445e-01f, -4.26452279e-01f, -1.32907197e-01f, 3.59203368e-01f, -3.13978195e-02f,
  7.07664117e-02f, 1.17511407e-01f, 5.51213063e-02f, -2.11937696e-01f, -6.46192610e-01f, -4.52384263e-01f, -3.60425919e-01f, -3.81745756e-01f, -4.67588693e-01f, -2.96872377e-01f,
  -1.44737335e-02f, -1.04943626e-02f, -2.02039808e-01f, -2.32929081e-01f, 3.00477266e-01f, 8.76986608e-02f, 1.83453113e-01f, 6.17574304e-02f, -5.43554164e-02f, 3.88923645e-01f,
  -1.06200919e-01f, 1.58977389e-01f, -1.42365918e-01f, 4.78813127e-02f, 1.17688164e-01f, -8.71776640e-02f, -1.35372832e-01f, -1.12498049e-02f, -7.61969388e-02f, -5.81405088e-02f,
  2.00182170e-01f, -1.51075423e-01f, 2.54779216e-02f, 9.88376327e-03f, -9.62691680e-02f, -2.43765548e-01f, -4.09236811e-02f, -1.17189378e-01f, -2.00128660e-01f, -6.12731092e-02f,
  -7.14361817e-02f, 3.14083174e-02f, -7.97783211e-02f, -1.47025272e-01f, -1.08709417e-01f, 1.16118370e-02f, -1.53653109e-02f, 1.53428867e-01f, -1.15300313e-01f, 3.83850604e-01f,
  4.70421426e-02f, -6.99558109e-02f, 5.59426248e-02f, 9.06310789e-03f, 8.58430192e-02f, 1.46130875e-01f, 9.70171839e-02f, -1.26312599e-01f, -2.31480766e-02f, 8.61444175e-02f,
  -8.48880969e-03f, -4.23130952e-02f, -6.38895622e-03f, -2.31892336e-03f, -1.03915269e-02f, -7.31418356e-02f, -8.83765742e-02f, -1.64069775e-02f, -1.07794665e-01f, 4.27966751e-02f,
  -1.85123850e-02f, 1.29663676e-01f, 1.32828951e-01f, -8.72450136e-03f, -2.92083509e-02f, -7.69670457e-02f, -6.40619546e-03f, -1.13224231e-01f, -2.27217004e-02f, -1.72682758e-03f,
  1.94003776e-01f, -3.09998810e-01f, 1.74508661e-01f, -2.69337386e-01f, -5.69773726e-02f, -1.11759277e-02f, 1.24573946e-01f, -7.60591626e-02f, 1.45148471e-01f, -1.46863341e-01f,
  -1.32685497e-01f, -1.61856543e-02f, 1.29041940e-01f, 7.05595091e-02f, -3.98436226e-02f, -5.76626584e-02f, -1.47031039e-01f, -5.11826836e-02f, -2.19670013e-01f, 9.81144831e-02f,
  7.99909234e-03f, -2.17510641e-01f, -1.28452435e-01f, -6.87363669e-02f, 2.41499543e-01f, -3.80440988e-02f, -6.97611049e-02f, 7.92387575e-02f, -2.36393377e-01f, 5.47108008e-04f,
  8.65807176e-01f, 3.76077682e-01f, 1.83374539e-01f, 1.19330153e-01f, -2.44028755e-02f, -6.71224222e-02f, 1.35744989e-01f, 1.56320557e-01f, 1.35224283e-01f, 1.73490748e-01f,
  7.13025555e-02f, 1.23405069e-01f, 6.01059347e-02f, 1.77059844e-01f, 1.79619640e-01f, 1.49654672e-01f, 1.14141822e-01f, 2.11861193e-01f, 6.22387566e-02f, 1.62175179e-01f,
  1.29996791e-01f, 5.90903163e-02f, 1.44805267e-01f, 7.55610466e-02f, 5.84931076e-02f, 7.75683448e-02f, 2.09952076e-03f, -2.52117328e-02f, 8.39206576e-02f, 1.36909187e-01f,
  -2.12036327e-01f, 2.26410046e-01f, -1.67446416e-02f, -7.60834664e-02f, -1.21766858e-01f, 8.40581767e-03f, 6.28677905e-02f, 2.29371078e-02f, -2.11949259e-01f, -1.26804784e-01f,
  -4.54355702e-02f, 1.90764188e-03f, 9.03540254e-02f, -7.61529431e-02f, -1.06183298e-01f, 8.26029480e-03f, 5.76252304e-02f, 1.50781468e-01f, 2.20775045e-02f, 8.84968340e-02f,
  4.01011109e-02f, -6.01506680e-02f, -1.31821737e-01f, 7.16553703e-02f, 2.28712559e-02f, 5.94977401e-02f, 6.38762563e-02f, 1.44319519e-01f, -4.55148928e-02f, 2.18522146e-01f,
  1.73931266e-03f, 4.07753959e-02f, 4.55648564e-02f, 2.20819011e-01f, 6.00371063e-02f, 1.39307171e-01f, -2.36969031e-02f, -8.59557241e-02f, 1.56735227e-01f, 1.03289209e-01f,
  -2.16256484e-01f, 1.34038329e-02f, 8.16426203e-02f, 1.79905947e-02f, 6.51952699e-02f, 4.56565022e-02f, -5.99215254e-02f, -1.56811729e-01f, -9.79616791e-02f, -8.51178095e-02f,
  1.77181102e-02f, -1.05554961e-01f, -4.09134999e-02f, 3.13070416e-02f, -2.18985565e-02f, 4.45692278e-02f, -6.78351894e-02f, -7.28189796e-02f, -1.12982519e-01f, -5.97430132e-02f,
  -4.60180908e-01f, -8.35660025e-02f, 1.44752190e-01f, 3.40960845e-02f, -1.11299187e-01f, -5.93531840e-02f, 1.09992415e-01f, -1.15683593e-01f, -1.84320346e-01f, -2.56815076e-01f,
  -1.93869337e-01f, 6.42247556e-04f, -8.88620317e-03f, 1.78894382e-02f, -1.87009782e-01f, -1.67394027e-01f, 1.20063697e-03f, 6.41941503e-02f, -1.86868776e-02f, -9.90206450e-02f,
  8.27085506e-03f, -1.32644221e-01f, -9.27958563e-02f, -8.53144452e-02f, 1.31793385e-02f, -8.79384503e-02f, -1.49302959e-01f, -9.98439118e-02f, -1.61393911e-01f, -1.50550343e-02f,
  3.98753762e-01f, 2.64733940e-01f, 4.22444582e-01f, 2.62459368e-02f, 1.73851803e-01f, 2.57496804e-01f, 4.43854094e-01f, 1.97618946e-01f, -6.67561144e-02f, -7.43308337e-03f,
  -7.70634785e-02f, -2.31079131e-01f, -3.19493979e-01f, -7.21961185e-02f, 2.63547637e-02f, 9.06738564e-02f, 3.16694961e-03f, 1.19818904e-01f, 1.34814873e-01f, 6.43908009e-02f,
  -5.45820259e-02f, 6.41723424e-02f, 7.98266307e-02f, 9.69314054e-02f, -8.36952552e-02f, -3.67096782e-01f, 8.56987685e-02f, 1.93928972e-01f, 9.45984423e-02f, -8.47345442e-02f,
  -1.42872229e-01f, 3.25638622e-01f, -2.50281096e-01f, -1.92373261e-01f, 4.04902771e-02f, -7.03785047e-02f, -1.27927020e-01f, 1.36419050e-02f, -1.03169858e-01f, -1.18222311e-01f,
  -5.31197675e-02f, -7.81648979e-03f, 8.50977302e-02f, 1.33168921e-01f, 2.28454322e-01f, 1.30108997e-01f, 9.31345969e-02f, 5.70489317e-02f, 3.77756320e-02f, 3.54631208e-02f,
  -2.14471407e-02f, 1.63935378e-01f, 2.23507479e-01f, -2.81260591e-02f, 1.78026542e-01f, -1.01562545e-01f, 6.35760427e-02f, 4.97736372e-02f, -5.81925698e-02f, 7.98589736e-02f,
  -1.45957753e-01f, -4.00284082e-02f, 6.15735687e-02f, 4.05408777e-02f, 7.85854608e-02f, 8.66386890e-02f, 4.23698351e-02f, 1.02928825e-01f, 1.43480748e-01f, 2.60059506e-01f,
  1.29058063e-01f, -3.06124333e-02f, 1.02063566e-02f, -2.07180362e-02f, -1.13094091e-01f, 1.10615402e-01f, 9.83992666e-02f, 4.37114462e-02f, 1.68050975e-02f, 2.66999495e-03f,
  1.55590266e-01f, 3.89278717e-02f, -4.52368706e-02f, 1.25183433e-01f, 3.44301923e-03f, -8.46590847e-02f, -9.67208594e-02f, 7.71241961e-04f, -5.92622310e-02f, 1.70906982e-03f,
  -2.55030423e-01f, 5.53625003e-02f, -2.17846289e-01f, -4.23425883e-02f, -1.80378575e-02f, -6.32059202e-02f, -4.56533395e-02f, -1.11874692e-01f, -5.15162535e-02f, -1.49652869e-01f,
  -1.27211437e-01f, 2.36177389e-02f, 1.81498691e-01f, -6.35006055e-02f, -5.27904332e-02f, -9.33780000e-02f, -1.86673954e-01f, -3.76970954e-02f, -3.58153991e-02f, -2.47150928e-01f,
  -1.11428417e-01f, 1.14334712e-03f, -1.00709386e-01f, -1.09307908e-01f, 8.10341723e-03f, -2.46703222e-01f, -5.12125678e-02f, 5.62697127e-02f, 3.89267690e-02f, -1.16679594e-01f,
  -6.19034410e-01f, 3.03319484e-01f, -1.42914563e-01f, -2.55160183e-01f, 1.21958338e-01f, 2.27812231e-01f, 3.42149109e-01f, 1.54587403e-01f, 1.04732625e-01f, 1.59974471e-01f,
  2.10256919e-01f, -7.63809215e-03f, -5.55709302e-02f, -6.29358962e-02f, -3.83858457e-02f, 2.76346505e-01f, 2.59921074e-01f, -1.65907249e-01f, -3.66127968e-01f, 2.10240576e-02f,
  3.05424571e-01f, -5.19055165e-02f, -3.03707957e-01f, -1.10471390e-01f, -1.20920584e-01f, -1.33954093e-01f, -1.29072350e-02f, -6.30195737e-02f, 1.24673523e-01f, -1.77336380e-01f,
  -3.51951718e-01f, -2.61704385e-01f, 2.10504740e-01f, -1.85688823e-01f, -1.62468985e-01f, -1.37718484e-01f, 1.26886740e-01f, -9.76098031e-02f, 6.82450458e-02f, -1.58575431e-01f,
  -1.10176571e-01f, 9.93809402e-02f, -5.99797219e-02f, -8.20242520e-03f, -2.85804243e-04f, -1.72247179e-02f, -6.80720732e-02f, -3.93880121e-02f, -1.15140662e-01f, 5.90932630e-02f,
  1.28316417e-01f, -1.81195006e-01f, -5.17385542e-01f, 2.06722468e-01f, 6.32351711e-02f, -3.83787602e-02f, -1.63770869e-01f, -6.80259988e-03f, -1.02220520e-01f, -1.85362846e-01f,
  1.43551737e-01f, -1.90839171e-03f, 2.81364713e-02f, 1.03095099e-01f, -6.79412717e-03f, 9.13605839e-03f, 2.78686304e-02f, -4.24394757e-02f, 1.29276767e-01f, -8.36680755e-02f,
  4.74274568e-02f, 9.77712125e-02f, -4.31870930e-02f, 3.76741886e-02f, -3.77381481e-02f, -1.34569854e-01f, 4.40436006e-02f, -1.50132328e-01f, -2.33764380e-01f, 4.15605865e-02f,
  -1.62605971e-01f, -1.16301216e-01f, 5.92352413e-02f, -1.28838256e-01f, -7.69448234e-03f, -2.14015841e-02f, 9.20651108e-02f, 1.11296074e-02f, -4.43473384e-02f, 5.46809025e-02f,
  3.38630937e-02f, 2.67628372e-01f, -1.73174441e-01f, -1.47208320e-02f, -1.33287162e-01f, -1.58722818e-01f, -1.27264991e-01f, -4.56205681e-02f, 9.70553514e-03f, -5.35185542e-03f,
  -8.39860067e-02f, -7.16042444e-02f, 5.99285662e-02f, 5.97632825e-02f, 7.37599283e-02f, -2.39226362e-03f, 2.85581499e-02f, -1.32833719e-01f, 1.02112129e-01f, -1.62518322e-01f,
  -7.38646388e-02f, -2.29426175e-02f, -2.73988932e-01f, -2.99194008e-02f, 1.01561949e-01f, -5.45642190e-02f, -2.05845892e-01f, -1.83197826e-01f, -1.12322256e-01f, -1.86296716e-01f,
  9.77549672e-01f, -2.76824206e-01f, 6.50958866e-02f, 7.36580938e-02f, -6.02934649e-03f, -1.30001381e-01f, -2.93466687e-01f, -5.54247983e-02f, -6.44273311e-02f, -2.02832557e-02f,
  -3.80576581e-01f, -2.10445225e-01f, -7.60662183e-02f, -1.28492668e-01f, -4.07261699e-02f, 3.99372028e-03f, 9.69269797e-02f, 2.38440841e-01f, 1.83220059e-01f, -1.93083249e-02f,
  -1.96247935e-01f, 1.01470396e-01f, 1.83110967e-01f, 7.24327266e-02f, -1.14804484e-01f, -3.22518162e-02f, -8.81457329e-02f, -1.08422406e-01f, -3.03080171e-01f, 1.79717094e-02f,
  -7.69612044e-02f, 4.33850922e-02f, 1.55177221e-01f, 8.39013755e-02f, 1.10952511e-01f, 2.39680514e-01f, 1.13547608e-01f, 1.20710947e-01f, 7.38207102e-02f, -6.00946695e-02f,
  7.86574930e-02f, 8.69190320e-02f, 2.65591890e-02f, -8.03281069e-02f, 1.19331829e-01f, 9.98005643e-02f, -3.40092666e-02f, -7.50420019e-02f, -1.83001995e-01f, -4.86169010e-02f,
  -1.77959144e-01f, -4.85029332e-02f, -1.94951743e-01f, -1.49297401e-01f, -3.64448503e-02f, 9.27708868e-04f, -1.42675206e-01f, -3.97725664e-02f, -4.05957289e-02f, -4.61715879e-03f,
  -1.63105980e-01f, -7.05943629e-02f, -4.40047830e-02f, -7.29356781e-02f, -4.04931530e-02f, 1.67303234e-01f, 4.17383201e-02f, -8.67293626e-02f, -3.41107808e-02f, 1.24123208e-02f,
  -1.16263650e-01f, -8.87582004e-02f, -5.01702726e-02f, -4.15467583e-02f, 4.38909791e-02f, -2.55948417e-02f, 5.37912957e-02f, -7.51459673e-02f, -1.02626443e-01f, -1.00241959e-01f,
  -1.15195185e-01f, -4.44093607e-02f, 8.24258849e-02f, -4.96030226e-02f, 2.66245622e-02f, -2.86117364e-02f, -8.42829943e-02f, -1.26616612e-01f, -4.72979508e-02f, -3.52729112e-02f,
  -2.97645092e-01f, 8.45227689e-02f, 1.04563095e-01f, -1.00820728e-01f, 6.55749291e-02f, 5.91102941e-03f, -1.79322988e-01f, 4.10174206e-02f, 1.68244138e-01f, 2.82766600e-03f,
  7.54272863e-02f, 2.07743704e-01f, 3.90494838e-02f, -9.61434096e-02f, 2.11203858e-01f, 2.07419530e-01f, -2.29398832e-02f, -5.29293157e-02f, -5.49962260e-02f, -9.52128023e-02f,
  6.94685010e-03f, 2.41150912e-02f, 9.96422470e-02f, 2.28185132e-02f, 1.14631407e-01f, 2.19988018e-01f, 1.69465899e-01f, 5.29657900e-02f, 1.52068511e-01f, 1.39459193e-01f,
  3.99906009e-01f, 1.03908986e-01f, 2.09099963e-01f, 3.22588921e-01f, 8.90890732e-02f, 6.25122339e-02f, 5.26266359e-02f, 1.71078533e-01f, 2.33044073e-01f, 1.38488337e-01f,
  2.55743295e-01f, 3.38625193e-01f, 2.32737601e-01f, 1.03957154e-01f, 1.66784257e-01f, 6.88282773e-02f, -2.87590679e-02f, 1.15202956e-01f, 9.75815058e-02f, 1.74586982e-01f,
  1.16023123e-01f, 3.07668447e-02f, -2.39838976e-02f, 9.32413340e-02f, 6.64703548e-02f, 2.13277310e-01f, 5.92384152e-02f, 7.67377988e-02f, 8.43884498e-02f, 1.26429677e-01f,
  1.09250352e-01f, -7.64057040e-03f, 4.57781786e-03f, -3.49581204e-02f, -1.75211117e-01f, -1.84227452e-01f, 9.76536721e-02f, -1.32478267e-01f, -1.31810188e-01f, -8.77487510e-02f,
  -5.42427553e-03f, -1.12246163e-01f, -6.51589185e-02f, -1.58396140e-01f, -1.17498353e-01f, -8.54555294e-02f, -8.17069411e-02f, 6.49839863e-02f, -6.57281131e-02f, 1.69981550e-02f,
  -1.59122124e-02f, 3.81662063e-02f, -1.47311296e-02f, 1.23940498e-01f, 1.41896278e-01f, -1.62844937e-02f, 6.72908574e-02f, 2.33647078e-02f, 1.25739202e-02f, -2.48697251e-02f,
  1.96869791e-01f, 2.39981055e-01f, 1.31984964e-01f, 1.06756061e-01f, 1.95504557e-02f, -2.43222509e-02f, 7.95702487e-02f, 1.59261093e-01f, 1.14321642e-01f, 1.58354025e-02f,
  -8.71187001e-02f, 1.67072520e-01f, 1.35547251e-01f, 1.30542040e-01f, 6.75531924e-02f, 5.56977428e-02f, 1.37027144e-01f, 3.27843167e-02f, 8.95671025e-02f, -1.83401571e-03f,
  -2.22492572e-02f, -1.16650276e-02f, 5.24168313e-02f, -6.12566769e-02f, -1.53013349e-01f, 5.83611690e-02f, 8.61974806e-02f, 9.47038084e-02f, 7.94338137e-02f, -3.07769738e-02f,
  -1.76138043e-01f, 6.99178949e-02f, 1.60687208e-01f, 5.20264395e-02f, -4.49301042e-02f, -3.45542356e-02f, 1.24026895e-01f, -1.13799376e-02f, -2.39286497e-01f, -1.07835636e-01f,
  1.26831075e-02f, 3.53052728e-02f, -1.51632288e-02f, -8.61038081e-03f, 8.91721770e-02f, 4.27504592e-02f, -3.43318246e-02f, 1.30137697e-01f, -1.10012607e-03f, 1.03593417e-01f,
  -4.01905216e-02f, 1.23361170e-01f, 1.77746624e-01f, 1.45883501e-01f, 1.50927588e-01f, 4.32377718e-02f, -6.29036576e-02f, -4.14155647e-02f, -1.21234881e-03f, -2.95700803e-02f,
  -5.55848777e-01f, -1.32802933e-01f, -4.31887537e-01f, -4.81195301e-01f, -2.88724959e-01f, 1.53030455e-03f, 5.71551360e-02f, 3.89906950e-02f, -3.02421711e-02f, -3.25913429e-01f,
  -1.30639270e-01f, -2.73174644e-02f, -3.40515524e-02f, -6.32093176e-02f, 2.33842973e-02f, -3.69200677e-01f, -4.24767107e-01f, -3.29630077e-01f, 3.68559249e-02f, 1.96128547e-01f,
  -7.53368437e-02f, -3.84620637e-01f, -2.28678569e-01f, -9.20542702e-02f, -2.04682529e-01f, -2.08705455e-01f, -2.29674533e-01f, -1.74733654e-01f, -3.90286297e-02f, -3.75794560e-01f,
  -1.14128709e-01f, 4.09703441e-02f, 1.98955446e-01f, 6.87626973e-02f, -2.60503404e-02f, 5.17266756e-03f, 2.67417319e-02f, -1.77942086e-02f, 1.25793216e-03f, 2.33693793e-02f,
  3.18715349e-03f, 6.73099905e-02f, -1.07190818e-01f, 9.35526490e-02f, -4.03390750e-02f, 3.13050002e-02f, 6.37571365e-02f, 9.23854262e-02f, -1.69060733e-02f, 1.85374573e-01f,
  4.43876013e-02f, 1.23211734e-01f, 2.58671820e-01f, 2.66735971e-01f, 3.37814152e-01f, -1.80894062e-02f, 2.62346566e-01f, 3.52768749e-01f, 1.53792560e-01f, 1.87083870e-01f,
  -1.59945831e-01f, -3.54367159e-02f, 1.16996147e-01f, 1.11716382e-01f, 1.58318669e-01f, 1.30812064e-01f, -4.58494723e-02f, -2.85429470e-02f, 3.46913487e-02f, 4.31399941e-02f,
  4.65196408e-02f, -3.32288556e-02f, 1.33017734e-01f, -8.50339830e-02f, -1.49651602e-01f, -2.89799161e-02f, -3.74510661e-02f, 4.03394774e-02f, 1.48841053e-01f, 6.51745051e-02f,
  7.92248547e-02f, 1.24489136e-01f, -2.05068693e-01f, 6.03577718e-02f, 1.78295691e-02f, -8.74696523e-02f, -8.64804164e-02f, -1.99405756e-02f, -7.84461573e-02f, -1.60902172e-01f,
  -1.60660028e-01f, -7.41021484e-02f, -1.14739180e-01f, 1.53990299e-01f, -1.67579502e-02f, 4.16197814e-02f, 4.19670865e-02f, -8.52865279e-02f, -2.07754806e-01f, -6.25108555e-02f,
  7.34209791e-02f, -2.00992636e-02f, -1.18528731e-01f, 8.37621689e-02f, 4.13557105e-02f, 1.17743999e-01f, 2.80704871e-02f, -3.37914005e-02f, -7.95870870e-02f, 3.11955661e-02f,
  -2.41703670e-02f, 1.21530883e-01f, 1.06454805e-01f, 1.37271702e-01f, 8.63147825e-02f, -3.10575031e-02f, -3.41077559e-02f, 1.54328272e-01f, 1.02392267e-02f, -2.48590447e-02f,
  1.50900170e-01f, -2.44316176e-01f, -1.43412158e-01f, 1.02196597e-02f, -4.54768464e-02f, -5.27152307e-02f, -2.94999450e-01f, 1.77548409e-01f, 2.00768262e-01f, -3.16129804e-01f,
  -5.23599125e-02f, 2.31891990e-01f, -3.33902836e-02f, 4.94953319e-02f, -7.63033777e-02f, -5.50130010e-01f, -4.24237639e-01f, -1.94896013e-01f, 2.56815821e-01f, 2.36303419e-01f,
  -4.22745012e-02f, 4.72344570e-02f, 1.33143812e-01f, -5.18030999e-03f, -8.62632394e-02f, -1.38851879e-02f, -2.90770322e-01f, -2.41284650e-02f, -8.09445977e-02f, -4.86321151e-01f,
  -3.48532200e-01f, 1.64176747e-01f, -1.01980213e-02f, 5.29483855e-02f, 5.84706813e-02f, 1.54170081e-01f, 1.19748451e-01f, 5.49120270e-02f, -2.68059932e-02f, -1.15797780e-01f,
  6.78163841e-02f, 7.64042661e-02f, 1.43558234e-01f, -6.07307889e-02f, 4.45032977e-02f, 6.45158589e-02f, 8.32905155e-03f, 1.43887699e-01f, -9.49813519e-03f, -1.88130364e-01f,
  -1.26993179e-01f, -2.28811651e-01f, -3.62933204e-02f, -1.73531085e-01f, 1.34383338e-02f, -3.26162688e-02f, 5.34604229e-02f, 1.53846383e-01f, 2.81546991e-02f, -4.17315990e-01f,
  -3.45785357e-02f, -1.63903572e-02f, -4.83402424e-02f, 1.30210165e-03f, -7.89228752e-02f, -7.35547692e-02f, -9.14724693e-02f, -1.38409898e-01f, 1.26677798e-02f, 8.74413922e-02f,
  3.40518653e-02f, 2.13256516e-02f, -2.91945301e-02f, -1.01586506e-01f, -1.02889277e-02f, -2.39617620e-02f, -8.51728842e-02f, -1.61724478e-01f, -9.87459645e-02f, -1.38078928e-02f,
  -2.12355033e-02f, -4.31676656e-02f, -6.36960864e-02f, 1.05506793e-01f, -1.15353070e-01f, -9.56912637e-02f, -2.92582214e-02f, 1.31274298e-01f, 3.20601538e-02f, -5.04844561e-02f,
  2.37717763e-01f, 4.92069945e-02f, -1.55655295e-01f, 1.15771838e-01f, -1.10333726e-01f, 2.04685722e-02f, -1.10993661e-01f, 1.72168575e-02f, 8.67733806e-02f, 4.15273160e-02f,
  8.28414261e-02f, -5.10343499e-02f, 2.20151152e-02f, 9.42597836e-02f, 1.65020213e-01f, -3.52167636e-02f, -1.21364988e-01f, -1.02573022e-01f, -5.39404266e-02f, 4.42800485e-02f,
  -2.44341999e-01f, -1.32241040e-01f, -8.87182821e-03f, -1.44902855e-01f, 3.80852297e-02f, -2.13833116e-02f, -9.65272933e-02f, 3.06765530e-02f, -6.07533902e-02f, -3.97025257e-01f,
  -5.34003198e-01f, -3.41072589e-01f, 3.27577591e-01f, -3.02976072e-01f, -1.28018837e-02f, -1.15361638e-01f, 1.03493512e-01f, -2.85575539e-01f, -2.57548690e-01f, 9.72462147e-02f,
  7.78331757e-02f, 2.31404733e-02f, 1.49079263e-01f, 7.25068152e-02f, -3.49695385e-02f, 9.30267572e-03f, -2.34203581e-02f, 1.04407594e-01f, 1.33862849e-02f, -1.76661480e-02f,
  -4.44659293e-02f, 7.14918971e-02f, -2.10704386e-01f, -1.48767933e-01f, 2.52296776e-01f, 1.42673060e-01f, 1.95698887e-01f, -1.36835948e-01f, -2.79689580e-02f, 1.62396848e-01f,
  6.25966370e-01f, -2.24934429e-01f, -1.36679485e-01f, -2.52329439e-01f, -7.20405532e-03f, -9.60257798e-02f, -1.42454982e-01f, -8.82463008e-02f, -1.08015224e-01f, -1.73357680e-01f,
  -2.62714131e-03f, 4.84208763e-02f, -7.18093216e-02f, 1.76450923e-01f, -4.20017773e-03f, -7.45532960e-02f, -7.89430812e-02f, -2.70304263e-01f, -7.66137913e-02f, 1.30210608e-01f,
  -1.09631410e-02f, 3.99192274e-02f, 1.12052642e-01f, -6.89619500e-03f, -3.18771936e-02f, 3.92756537e-02f, 1.84028558e-02f, -1.25546575e-01f, -9.20101628e-02f, 3.47002074e-02f,
  -6.36822507e-02f, 1.46147996e-01f, 1.91629320e-01f, 9.21240523e-02f, -3.01001798e-02f, 2.15654019e-02f, 4.22612913e-02f, 1.55328542e-01f, -2.36728266e-02f, 2.42728125e-02f,
  -8.92480835e-03f, -4.36963290e-02f, -1.47354811e-01f, 6.80814832e-02f, -7.55409822e-02f, -1.42562732e-01f, -4.04516421e-02f, -1.05962478e-01f, -1.34696394e-01f, -6.59508333e-02f,
  -5.36208856e-04f, -1.46638647e-01f, -8.45350046e-03f, -1.16281942e-01f, -1.47009000e-01f, -1.69170350e-01f, -9.54669341e-02f, 4.44469228e-02f, 2.63873450e-02f, -9.64160785e-02f,
  1.79051220e-01f, -3.33511323e-01f, 2.28596628e-01f, -2.63987333e-01f, -1.20055513e-03f, -8.46021846e-02f, -5.78444749e-02f, -1.55964896e-01f, -7.25897253e-02f, -4.59086038e-02f,
  -8.79785269e-02f, -6.71305060e-02f, 1.11986436e-01f, 4.44556996e-02f, 3.14817429e-02f, 1.40044972e-01f, -1.81623787e-01f, 7.36021902e-03f, -2.71916777e-01f, -3.95333245e-02f,
  -8.00799802e-02f, -4.44699600e-02f, 2.49155954e-01f, 4.30379175e-02f, -1.63315106e-02f, 1.62812337e-01f, 3.24060977e-01f, 2.10942447e-01f, 2.01382652e-01f, 1.22840442e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.65172833e-01f, -2.56157309e-01f, 2.52297074e-01f, 1.78437874e-01f, 1.52236924e-01f, 4.41698693e-02f, 7.09405243e-02f, 2.06526384e-01f, 2.41491139e-01f, 3.25191468e-01f,
  8.74047875e-02f, 1.71383880e-02f, 1.47170171e-01f, 3.72084171e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.18614055e-01f, -1.19964622e-01f, 1.40332505e-01f, 2.18666438e-02f, -2.11191460e-01f, 2.52484441e-01f, -2.74153333e-02f, 1.48074748e-02f, -5.54713272e-02f, 8.26509297e-02f,
  1.54511288e-01f, -5.54273762e-02f, 9.76785943e-02f, -7.58426040e-02f, 9.54959989e-02f, -1.51028901e-01f, 5.65470606e-02f, 9.45138745e-03f, 1.95969492e-02f, 1.56025961e-01f,
  4.57915924e-02f, 1.17429025e-01f, 8.69198143e-02f, -7.62379169e-02f, 5.27423210e-02f, 2.36367717e-01f, -9.24679264e-02f, 1.22362105e-02f, -1.30486965e-01f, 3.62320915e-02f,
  5.46041168e-02f, -2.82999992e-01f, -2.12015375e-01f, -9.57998410e-02f, -1.56701431e-01f, -2.05012262e-01f, -2.77664870e-01f, 2.30029389e-01f, -1.77219823e-01f, 1.44068040e-02f,
  4.46724752e-03f, -9.07923728e-02f, 1.13575079e-01f, 5.38123474e-02f, -5.30312397e-02f, -1.96892321e-02f, 4.06232923e-02f, -1.35774255e-01f, -1.03732020e-01f, 7.51743913e-02f,
  1.49333552e-01f, 1.71623662e-01f, -4.01642948e-01f, -2.35369317e-02f, 1.12453662e-01f, -4.97225791e-01f, -1.49270028e-01f, 1.84725225e-01f, -8.45465362e-02f, 6.22950941e-02f,
  -4.58136797e-02f, 1.30611891e-02f, -2.53856629e-01f, 2.54019380e-01f, -5.97479641e-02f, -1.88195035e-01f, 6.92094862e-02f, -9.20429230e-02f, -1.10263638e-02f, -1.21081069e-01f,
  4.04739454e-02f, 4.03291509e-02f, -2.00627279e-02f, -5.53922690e-02f, -3.39158922e-02f, 6.56719506e-02f, 1.86320841e-02f, 1.88775077e-01f, 8.07831213e-02f, -1.45047030e-04f,
  5.93009330e-02f, 8.91626626e-02f, -1.00978389e-01f, -6.53082132e-02f, -2.54079457e-02f, -5.93015924e-02f, 4.98470739e-02f, -9.04956460e-02f, 1.24367498e-01f, 8.95931497e-02f,
  -1.13380529e-01f, 2.54160732e-01f, -4.14379276e-02f, 1.96124852e-01f, -1.28591150e-01f, 5.23686372e-02f, 2.87813455e-01f, 3.31809744e-02f, -4.71541971e-01f, 7.34279454e-02f,
  2.77965609e-02f, 2.71624714e-01f, -8.27961490e-02f, -1.35814801e-01f, 5.75633943e-02f, -1.44318625e-01f, 1.19373292e-01f, 2.47043297e-01f, -4.10237722e-02f, -5.91233931e-02f,
  1.51525795e-01f, -2.65348554e-01f, 8.00618157e-02f, -5.86375035e-02f, 2.73311913e-01f, -1.12904690e-01f, -3.97432774e-01f, -2.23068446e-02f, -5.84916119e-03f, -1.01521432e-01f,
  1.14352278e-01f, 2.16129258e-01f, 1.26251087e-01f, -2.07333162e-01f, -1.74411178e-01f, 1.86497748e-01f, -2.61528432e-01f, 1.08641826e-01f, 2.01657087e-01f, 5.31715378e-02f,
  6.56934157e-02f, 9.49053280e-03f, 1.44643858e-02f, 3.32804099e-02f, 9.13566444e-03f, 3.92145477e-02f, 1.67338015e-03f, -9.89665315e-02f, -8.12980011e-02f, 1.06951091e-02f,
  -1.75569057e-01f, 5.38838729e-02f, 2.12885980e-02f, -1.48562863e-01f, -6.71866238e-02f, 4.76798825e-02f, 1.71521142e-01f, -2.98744477e-02f, 4.09859866e-02f, -1.38065070e-01f,
  -3.49772237e-02f, 2.76950095e-02f, 2.48364974e-02f, 9.20413509e-02f, -1.63600296e-01f, 1.40176751e-02f, -2.12141126e-03f, 1.96026996e-01f, 7.61402678e-03f, -2.92417794e-01f,
  -3.05333547e-02f, -3.89834493e-02f, 2.76795417e-01f, 4.59664408e-03f, -2.06285015e-01f, 7.24297538e-02f, -5.29641425e-03f, -1.58410475e-01f, 5.08247083e-03f, -5.51980212e-02f,
  -1.71985671e-01f, -5.22350296e-02f, 1.98307097e-01f, -4.68570665e-02f, -3.52868289e-02f, -6.16797023e-02f, 4.47835699e-02f, -6.91482946e-02f, -5.66954575e-02f, -8.20264295e-02f,
  -2.42360055e-01f, -2.39357844e-01f, 4.87077935e-03f, -2.09180459e-01f, -2.25687176e-02f, -1.75647845e-03f, -1.42834440e-01f, 2.51566321e-01f, 1.12252168e-01f, -1.54508665e-01f,
  -1.57507494e-01f, 3.34209800e-01f, 1.32493019e-01f, 9.18787420e-02f, -7.29633048e-02f, 1.38279915e-01f, -6.74141049e-02f, -2.69495659e-02f, 1.75774261e-01f, 5.73162213e-02f,
  8.16923231e-02f, -3.18719656e-03f, 2.03698408e-02f, 5.36296815e-02f, -2.32087746e-01f, 1.04765177e-01f, 5.86656108e-03f, 1.58361092e-01f, 9.82223898e-02f, -2.25746393e-01f,
  1.43760055e-01f, -8.47030804e-02f, 1.21683091e-01f, 2.52745468e-02f, -1.55234318e-02f, 6.99177086e-02f, 1.12379156e-01f, -2.60683984e-01f, 2.87805945e-01f, -1.68148383e-01f,
  -6.32310926e-04f, 1.26122206e-01f, -1.49508417e-01f, 1.71535499e-02f, 8.28787759e-02f, -7.95313194e-02f, -9.67749283e-02f, -2.03771576e-01f, 1.28448591e-01f, 1.01248547e-01f,
  8.38835463e-02f, 2.40547493e-01f, 1.44232824e-01f, -1.27298059e-02f, 5.21351695e-02f, 2.83254057e-01f, 1.24373613e-02f, -3.26371901e-02f, 5.95207065e-02f, -1.12604806e-02f,
  -1.17757052e-01f, 7.38564879e-02f, -1.12138443e-01f, 1.18098445e-01f, -1.40598461e-01f, 2.12589964e-01f, 2.38691628e-01f, -8.36776122e-02f, -4.20716479e-02f, -1.36017844e-01f,
  3.87251288e-01f, -1.08540520e-01f, -1.36373147e-01f, -8.60201716e-02f, 2.60977715e-01f, -1.82374850e-01f, 1.99681491e-01f, 4.45564985e-02f, -1.82741843e-02f, 2.22943928e-02f,
  9.93787199e-02f, 1.29627645e-01f, 1.45376235e-01f, 3.55970375e-02f, 1.12936525e-02f, 3.21135088e-03f, -8.17738622e-02f, 2.16277037e-02f, 1.24215866e-02f, -1.74584866e-01f,
  6.42690808e-02f, -1.52806997e-01f, -8.38697702e-02f, 6.15595169e-02f, 2.03563669e-03f, 4.95657809e-02f, 1.56321600e-01f, -9.29694399e-02f, 1.29726052e-01f, -1.60615325e-01f,
  1.16120592e-01f, -1.02578782e-01f, -3.09645176e-01f, -2.56904382e-02f, -7.16135949e-02f, 1.15662336e-01f, -1.08893424e-01f, -1.79676935e-01f, -3.56498092e-01f, -3.17785963e-02f,
  2.00956360e-01f, -8.62265378e-02f, -1.59420416e-01f, -1.37957484e-01f, 8.60382020e-02f, 4.27316539e-02f, 5.24032451e-02f, -2.04288568e-02f, -7.46360868e-02f, -6.99576959e-02f,
  -1.28510746e-03f, 4.05786373e-02f, -1.15896888e-01f, -8.58195350e-02f, 1.11518838e-01f, 4.72252481e-02f, -4.84878898e-01f, 1.86093494e-01f, -2.54066378e-01f, -1.67846249e-03f,
  1.49337336e-01f, -1.48203522e-01f, 4.31715697e-02f, -1.51145130e-01f, -6.67579547e-02f, 2.07797736e-02f, -1.07301557e-02f, -1.90320686e-01f, 2.77081966e-01f, 1.31757140e-01f,
  5.74986376e-02f, 2.14485407e-01f, -1.36440608e-03f, -1.43707231e-01f, -3.78680415e-02f, -3.47509235e-02f, 1.33473463e-02f, -9.11008567e-02f, -1.03109116e-02f, -5.90462834e-02f,
  -1.20547108e-01f, 2.28082597e-01f, -3.01712275e-01f, -6.14386871e-02f, -1.11017324e-01f, 8.03594515e-02f, 3.25176795e-03f, -9.74233374e-02f, -1.39392922e-02f, 3.98722589e-02f,
  1.68967426e-01f, 7.90161639e-02f, -1.02840818e-01f, -1.98220517e-02f, 6.69009760e-02f, 4.63687256e-02f, -8.09866935e-02f, -6.35638833e-02f, 1.87899575e-01f, -2.50267033e-02f,
  1.00342236e-01f, 5.26949577e-02f, -1.51840031e-01f, -3.54323611e-02f, 2.18084261e-01f, -3.03918384e-02f, -2.76058167e-01f, -8.47562253e-02f, 1.49410330e-02f, -3.62355262e-02f,
  -8.97778373e-04f, 8.77208710e-02f, -4.74043228e-02f, 1.10227495e-01f, -1.71898261e-01f, -8.82362723e-02f, -5.57841249e-02f, -1.60879672e-01f, -1.53773800e-01f, 2.47086883e-02f,
  -1.26942500e-01f, 1.19335338e-01f, -4.82976526e-01f, 2.71451592e-01f, 1.79486006e-01f, -1.64824814e-01f, 7.64348507e-02f, -1.90723419e-01f, 2.82761782e-01f, 5.21873832e-02f,
  -1.47147179e-01f, 1.63089678e-01f, 1.25971586e-01f, -3.84288639e-01f, 2.70257533e-01f, 6.21482953e-02f, 2.24057809e-02f, 1.79270767e-02f, 8.70304927e-02f, -1.08266501e-02f,
  6.18180297e-02f, -3.38054150e-02f, 1.07480936e-01f, -2.81798601e-01f, -6.08699843e-02f, -6.83963150e-02f, 2.16492251e-01f, -2.95219682e-02f, 1.37788445e-01f, 5.59711941e-02f,
  1.61277987e-02f, 5.64079881e-02f, -1.33677591e-02f, -4.69664522e-02f, 7.70313218e-02f, 4.44366001e-02f, 1.39472991e-01f, 7.13601261e-02f, 5.62100485e-02f, 1.33268118e-01f,
  -4.25174907e-02f, 3.34998608e-01f, -2.19803333e-01f, 3.82113829e-02f, 2.34199494e-01f, 6.44509271e-02f, -2.67230630e-01f, -6.81999847e-02f, 2.93180019e-01f, 1.27718925e-01f,
  -8.59258249e-02f, -3.55256200e-02f, -5.03575196e-03f, 5.11994958e-02f, -1.57354046e-02f, -6.28516227e-02f, -9.14772227e-02f, -4.23899382e-01f, 1.67498291e-01f, -1.99042410e-01f,
  -1.18909582e-01f, 4.64845270e-01f, 3.04173306e-02f, 2.57459372e-01f, -1.20582387e-01f, -4.45085317e-02f, 9.80491191e-02f, 3.43660861e-01f, 4.27061170e-01f, -8.41263086e-02f,
  -6.03447221e-02f, -2.86555469e-01f, -2.94527382e-01f, -4.60774936e-02f, 1.95439141e-02f, 1.94410589e-02f, 1.00080185e-01f, 2.70995766e-01f, -7.35881105e-02f, 1.77484468e-01f,
  -8.59364942e-02f, -1.03967793e-01f, -9.87946019e-02f, -6.42073601e-02f, -3.49018886e-03f, -1.35774687e-02f, 3.55822854e-02f, -7.35039860e-02f, 9.38147455e-02f, 3.01708467e-02f,
  -6.83755428e-02f, -7.32977390e-02f, -1.37170339e-02f, -1.31949037e-01f, -1.29793867e-01f, -1.78486571e-01f, -2.67675873e-02f, -1.69187207e-02f, 3.77925001e-02f, -1.41679570e-02f,
  3.77334096e-02f, -1.65162596e-03f, 6.68140175e-03f, 2.11977646e-01f, -1.77128911e-02f, 3.17921937e-01f, 1.04187958e-01f, -1.69616323e-02f, 2.73278076e-03f, 1.57034472e-01f,
  5.05316444e-02f, -1.90132428e-02f, -1.25950441e-01f, 4.59683463e-02f, -1.01546660e-01f, -1.09278239e-01f, 4.43907678e-02f, -1.51075527e-01f, -2.11229056e-01f, -1.45758823e-01f,
  3.07710823e-02f, 6.53929338e-02f, -5.34548191e-03f, -1.87997669e-02f, 1.69949993e-01f, -1.43536821e-01f, -4.73488569e-02f, 3.11983526e-02f, 2.95248717e-01f, 9.90460441e-02f,
  -3.66049916e-01f, 1.11542583e-01f, 4.61238623e-02f, 3.52436095e-01f, -1.87451884e-01f, -1.54072195e-01f, 7.80062303e-02f, 8.47478732e-02f, 5.06396890e-02f, 1.45221189e-01f,
  1.39039829e-01f, -8.97367136e-04f, -8.84888053e-04f, -2.83754580e-02f, 1.11196131e-01f, 6.67519122e-02f, 2.11351551e-04f, 1.33531898e-01f, 9.77282673e-02f, -1.37928203e-02f,
  -3.62708457e-02f, -2.17500150e-01f, 1.80570725e-02f, 1.89411789e-02f, 2.02511996e-01f, -9.46359411e-02f, 4.01368439e-02f, -4.66526262e-02f, 1.00988641e-01f, -8.53319652e-04f,
  -1.15702376e-01f, -9.13711824e-03f, 7.90962428e-02f, 1.80305198e-01f, 7.87465498e-02f, 1.30081177e-01f, 6.40294552e-02f, 2.55820662e-01f, 6.58399984e-02f, 1.58422947e-01f,
  -1.22209303e-01f, 2.12662648e-02f, 2.87605450e-02f, -4.31102440e-02f, 8.52627978e-02f, 6.91354424e-02f, 4.35580969e-01f, 5.24044037e-02f, -9.33135375e-02f, 1.39305428e-01f,
  -1.28313333e-01f, 9.73420143e-02f, 1.43701047e-01f, -3.65929194e-02f, -1.67310998e-01f, -1.62226334e-01f, 2.16762811e-01f, 5.31743169e-02f, 1.03222160e-02f, -6.45625070e-02f,
  -5.75387366e-02f, 1.22186333e-01f, 3.67801869e-03f, -9.50136483e-02f, -2.26702109e-01f, -8.61758441e-02f, 3.33677232e-01f, -2.71893978e-01f, -2.00288123e-04f, 5.56996986e-02f,
  -1.19632080e-01f, -1.31810874e-01f, 1.49988428e-01f, -1.57411117e-02f, 3.44133645e-01f, 8.04379061e-02f, -7.33369961e-02f, 1.59387626e-02f, 1.25010237e-01f, 9.42686051e-02f,
  5.25161959e-02f, 5.67854336e-03f, -2.41635785e-01f, 4.18900177e-02f, 8.11080039e-02f, -1.18224546e-01f, 2.23655924e-02f, -6.60921037e-02f, -9.53230634e-03f, -7.81079531e-02f,
  1.20113030e-01f, 3.69152464e-02f, 2.39114240e-02f, 9.20984820e-02f, -3.13675515e-02f, -5.05372807e-02f, -4.81153913e-02f, 6.46717921e-02f, 9.02330130e-02f, -8.96199271e-02f,
  -1.41254842e-01f, 1.42964497e-01f, 2.07657993e-01f, 1.24081001e-01f, -1.38500512e-01f, -9.07844603e-02f, 3.67725879e-01f, 2.15927258e-01f, 7.25364164e-02f, -6.83624903e-03f,
  -8.31782371e-02f, -8.94596800e-02f, 8.91372114e-02f, 2.29925618e-01f, -9.62939411e-02f, 1.24686554e-01f, -1.16972193e-01f, -2.97486708e-02f, 1.85328871e-01f, 1.87730834e-01f,
  -7.09676668e-02f, -6.45815507e-02f, -1.89864337e-01f, 2.46349707e-01f, -1.05239488e-01f, 5.61183281e-02f, -9.55651104e-02f, -1.37726784e-01f, 3.29063535e-01f, 4.61210638e-01f,
  1.02363504e-01f, -1.80511132e-01f, -2.80112624e-01f, -7.71575570e-02f, 3.01110506e-01f, -1.75198629e-01f, -1.75364956e-03f, 1.34181932e-01f, -6.88961744e-02f, 8.69910493e-02f,
  -2.85634305e-02f, -2.21010029e-01f, 8.01738873e-02f, 3.00665647e-02f, 4.80202101e-02f, -5.54561689e-02f, -8.41300189e-02f, 6.33027703e-02f, -6.76134899e-02f, 1.24959648e-02f,
  1.11818880e-01f, -1.31901437e-02f, 1.52120627e-02f, 2.83245114e-03f, -3.52714658e-02f, 6.34320304e-02f, 1.81075986e-02f, -4.34656665e-02f, 1.68637708e-01f, 1.87512022e-02f,
  -9.38826725e-02f, -1.13861812e-02f, -3.84819023e-02f, 8.25657994e-02f, -9.64306109e-03f, -1.93030074e-01f, 7.82910641e-03f, -1.39561325e-01f, -3.58036943e-02f, -9.71908942e-02f,
  -4.71928902e-02f, -1.32063270e-01f, -1.87337641e-02f, 2.89515313e-02f, -1.48476154e-01f, -1.57570601e-01f, 8.39434564e-02f, 2.05662951e-01f, 1.99738532e-01f, 7.50660598e-02f,
  1.42262252e-02f, 4.98638907e-03f, -3.80755626e-02f, 1.65081799e-01f, -1.19506128e-01f, -2.66291276e-02f, -1.65226515e-02f, -7.31449574e-02f, 1.69642031e-01f, -3.73995826e-02f,
  8.14406723e-02f, 1.04432702e-01f, 1.68326780e-01f, 2.82776840e-02f, -2.41110161e-01f, -1.12880066e-01f, -2.19597250e-01f, 2.92280298e-02f, 2.81580746e-01f, 5.90176843e-02f,
  -5.36725707e-02f, 2.04783201e-01f, -1.77958563e-01f, 1.61748715e-02f, -7.28986263e-02f, 9.83170047e-02f, -3.82466763e-02f, 6.54377788e-02f, 9.74065587e-02f, 1.05075032e-01f,
  1.30160838e-01f, -5.01737632e-02f, -6.09747171e-02f, -9.30599030e-03f, -6.44980818e-02f, 1.18232585e-01f, -7.14638084e-02f, -6.51252493e-02f, -1.60747429e-03f, 3.63635160e-02f,
  -2.87778843e-02f, 1.19292215e-02f, -8.85006562e-02f, -4.01086323e-02f, 4.55937460e-02f, -9.00891703e-03f, -1.51370103e-02f, 1.86295938e-02f, 7.59482533e-02f, 1.58266336e-01f,
  -6.63252175e-03f, 1.32773891e-01f, -2.13461313e-02f, -1.04782328e-01f, -7.33176842e-02f, -2.56256363e-03f, 9.22422186e-02f, 1.58915892e-02f, -3.70396636e-02f, 9.95071903e-02f,
  -2.71222085e-01f, 6.95471615e-02f, -7.01395944e-02f, -2.20529214e-01f, -8.24701134e-03f, -3.64043005e-02f, 1.61191449e-01f, -2.81804502e-02f, -3.67676429e-02f, 2.83567235e-02f,
  -1.68582126e-01f, -8.63698274e-02f, 8.32653977e-03f, 3.18855271e-02f, -1.44590110e-01f, 1.37020737e-01f, -3.81934166e-01f, 4.78386402e-01f, 1.41155198e-02f, -3.25697631e-01f,
  -2.94627007e-02f, -1.06032893e-01f, 1.90828726e-01f, -2.98524529e-01f, -9.01280642e-02f, 8.85972008e-02f, 1.97100844e-02f, -6.71594813e-02f, 6.29928410e-02f, 7.84232616e-02f,
  -1.41437560e-01f, -1.04241364e-01f, -2.10162312e-01f, 2.96834689e-02f, 1.30433798e-01f, 1.04191452e-01f, -7.22455233e-02f, 4.42441069e-02f, -1.04560498e-02f, 2.49026105e-01f,
  -3.08335602e-01f, -1.64032012e-01f, -3.73776280e-03f, -1.40618145e-01f, -6.25228211e-02f, 5.97261712e-02f, 1.18043751e-01f, 1.19661041e-01f, 4.68351543e-02f, -1.10019751e-01f,
  -1.92866698e-01f, 2.86116768e-02f, 4.31390330e-02f, -1.84030250e-01f, -2.53445834e-01f, -4.43222225e-01f, 3.04978430e-01f, -1.77604869e-01f, -2.47528881e-01f, 4.18287814e-02f,
  5.30523323e-02f, 9.50542241e-02f, -7.73308203e-02f, -3.05466745e-02f, -5.38284890e-02f, -2.57923752e-01f, 2.47815885e-02f, -2.35501334e-01f, -9.98468772e-02f, -8.18821862e-02f,
  1.36928588e-01f, 1.35093585e-01f, -4.34954703e-01f, 1.69494860e-02f, 5.66583872e-02f, -2.78989404e-01f, -4.94598299e-02f, -2.50563771e-01f, 1.06805488e-01f, -1.59290150e-01f,
  -2.67630547e-01f, 1.28949620e-02f, -3.75295460e-01f, 1.59490675e-01f, 1.73370719e-01f, -5.83845191e-02f, 6.51241764e-02f, 8.88755992e-02f, -4.23195437e-02f, -1.71399154e-02f,
  -3.30133826e-01f, -8.64362866e-02f, -2.45856177e-02f, -1.60539690e-02f, 3.75797786e-02f, 1.03232294e-01f, 3.46646681e-02f, 1.00856788e-01f, -2.72589959e-02f, 4.55746986e-02f,
  -5.73258959e-02f, -1.87912479e-01f, -3.78534757e-02f, -3.51849124e-02f, 9.65424329e-02f, 1.41043276e-01f, 5.42814545e-02f, 4.08186279e-02f, -2.95361280e-02f, -5.09188548e-02f,
  -1.71241090e-01f, -7.19904527e-02f, 8.22239742e-02f, -2.82500833e-02f, -1.27519488e-01f, 3.84453945e-02f, -1.10494411e-02f, 6.92031980e-02f, 3.95624489e-02f, 1.17416531e-01f,
  -6.09036349e-02f, -6.25739470e-02f, 2.30736107e-01f, 3.00828874e-01f, 2.37363502e-01f, -3.87714058e-02f, 6.47917762e-02f, 1.31548718e-01f, 2.39724785e-01f, 9.77822766e-02f,
  -1.93199869e-02f, 2.54433639e-02f, -1.23078004e-02f, 1.85119826e-02f, 9.78241209e-03f, 5.89919798e-02f, 2.69703627e-01f, -1.08074814e-01f, -1.20938241e-01f, 2.07204372e-01f,
  -4.14667502e-02f, -2.95229498e-02f, 4.66109961e-02f, 7.38712912e-03f, 4.13349390e-01f, 1.05392247e-01f, 1.08024538e-01f, 2.26396799e-01f, 8.30328017e-02f, -1.25920326e-01f,
  -5.53804561e-02f, 1.69571996e-01f, -7.81790838e-02f, -1.39451940e-02f, 3.18790168e-01f, -4.12306517e-01f, -5.99687099e-02f, 1.38642883e-03f, 1.03843100e-01f, 8.98585320e-02f,
  1.81787595e-01f, 1.85394853e-01f, -1.88957453e-01f, 6.50089905e-02f, -6.15146793e-02f, 2.70465913e-04f, -4.43056077e-02f, 2.99244691e-02f, 8.80185366e-02f, 2.87652817e-02f,
  1.81541443e-01f, 7.56060705e-02f, -7.53607508e-03f, 5.80315925e-02f, -1.40815051e-02f, -3.12078632e-02f, -1.10788159e-01f, -7.31817111e-02f, 4.09692479e-03f, -1.13865614e-01f,
  6.40302822e-02f, 1.38187110e-01f, 1.43476680e-01f, -1.43336877e-01f, -1.61117956e-01f, -1.90553918e-01f, 6.42206967e-02f, 1.01817854e-01f, -1.55711994e-01f, 1.42311946e-01f,
  2.08159432e-01f, 7.07012415e-02f, 7.59003535e-02f, 1.31735653e-01f, 3.18192653e-02f, -1.23872897e-02f, -4.97879200e-02f, 2.60812968e-01f, 8.22198316e-02f, -1.53458059e-01f,
  9.94564518e-02f, -1.65501535e-01f, -2.94800345e-02f, 1.44294769e-01f, 1.10353783e-01f, 1.32013738e-01f, -1.12720042e-01f, 1.35645330e-01f, 3.71358305e-01f, 2.44393215e-01f,
  -1.23693570e-01f, -3.87956984e-02f, -5.86669333e-02f, -7.84460679e-02f, -3.05696249e-01f, 1.44559741e-01f, -3.18324044e-02f, -3.25441688e-01f, -1.02495633e-01f, 4.82820906e-02f,
  2.94335820e-02f, 1.11171804e-01f, 7.87312984e-02f, 7.38827586e-02f, -2.12570354e-02f, 1.80480197e-01f, 1.32649586e-01f, 1.98291674e-01f, 2.63396688e-02f, -2.09191395e-03f,
  -1.48798123e-01f, -4.60504703e-02f, 1.59955606e-01f, -5.45577100e-03f, -8.79596174e-02f, -2.39942446e-02f, -2.36390345e-02f, -3.27668749e-02f, -7.49869347e-02f, 1.61757559e-01f,
  -6.81057870e-02f, 5.71833402e-02f, 8.11350495e-02f, -3.11074872e-02f, 4.65021580e-02f, -4.91677485e-02f, -2.00271189e-01f, 3.60368681e-03f, 7.52000064e-02f, 5.10068163e-02f,
  -7.20825419e-02f, 5.05021587e-02f, -2.15724587e-01f, 5.65978624e-02f, 4.35068876e-01f, 9.75651443e-02f, 4.85103764e-02f, -2.70246118e-01f, -5.49941435e-02f, -4.10658531e-02f,
  2.85225059e-03f, -1.91901550e-02f, -5.35008274e-02f, -1.33757457e-01f, -1.03343809e-02f, 2.92867031e-02f, 1.13552697e-01f, 9.59879011e-02f, 3.32007520e-02f, -1.82498805e-02f,
  -1.49716750e-01f, -7.27960616e-02f, 2.80320436e-01f, -1.54643759e-01f, -1.06624179e-01f, 5.15747905e-01f, 8.84511992e-02f, -1.34626135e-01f, -2.72199303e-01f, 2.37362340e-01f,
  -1.21440217e-02f, -1.76721234e-02f, 3.02623123e-01f, -1.86000150e-02f, -2.00107753e-01f, -2.04825122e-02f, 6.93049058e-02f, 1.06184267e-01f, 2.50248238e-02f, -2.10428424e-02f,
  -3.87303323e-01f, -6.91820830e-02f, -8.73244628e-02f, -6.18248172e-02f, -1.33381575e-01f, -1.02412723e-01f, 1.08331293e-01f, -1.09540520e-03f, -7.63300285e-02f, 1.71614736e-01f,
  -7.45480433e-02f, -8.29879269e-02f, -1.99014246e-02f, -9.22225267e-02f, -5.12430184e-02f, 4.72770482e-02f, -1.27698600e-01f, -1.44248381e-01f, 1.04795843e-02f, 2.25403517e-01f,
  -7.70861879e-02f, 3.65012407e-01f, -1.56586841e-01f, 9.55479592e-02f, 2.07870677e-01f, 2.98985094e-01f, 1.21437296e-01f, 7.37523958e-02f, -9.96806994e-02f, 5.35929501e-02f,
  1.60891369e-01f, 1.23007141e-01f, 1.00728281e-01f, -1.85488343e-01f, 1.72951370e-02f, -6.62252605e-02f, 7.47806057e-02f, 3.85902226e-01f, -5.92417717e-02f, -1.92797080e-01f,
  -1.35116592e-01f, -2.16872498e-01f, -2.27188729e-02f, 2.79236455e-02f, -5.61517552e-02f, 1.08657777e-02f, -1.15167424e-01f, 3.24101388e-01f, 6.73732068e-03f, -5.48863821e-02f,
  -2.58388400e-01f, 1.37463868e-01f, 3.19125086e-01f, -1.81658939e-01f, -1.73589051e-01f, 2.32320234e-01f, 1.92622796e-01f, 3.49378325e-02f, -9.12921652e-02f, -1.05616907e-02f,
  -1.05438322e-01f, -5.05565479e-02f, 5.12414537e-02f, 1.25939595e-02f, -2.11551473e-01f, 1.44386157e-01f, 5.85406870e-02f, 6.75545037e-02f, 1.16918646e-01f, -2.63674825e-01f,
  1.06750563e-01f, 5.79270050e-02f, -1.57786891e-01f, 2.52219252e-02f, -5.55911800e-03f, -7.89474789e-03f, 9.54517499e-02f, 2.66905148e-02f, -3.04360446e-02f, 3.12413722e-02f,
  -8.38238448e-02f, 1.59780949e-01f, 2.28485659e-01f, -3.87676209e-02f, -3.62640955e-02f, 2.83337533e-02f, -8.24415833e-02f, -1.25380814e-01f, 4.10188325e-02f, -2.41346568e-01f,
  4.17854032e-03f, 1.18542336e-01f, -3.55176061e-01f, 1.31770283e-01f, -1.02926590e-01f, 3.68835360e-01f, -3.04959714e-01f, -2.45245889e-01f, 2.83852786e-01f, -1.23445503e-01f,
  3.14672627e-02f, 2.79493511e-01f, -7.92001560e-02f, 2.11577296e-01f, -3.00319672e-01f, 1.24907821e-01f, 1.46543428e-01f, -5.07563502e-02f, -3.17322426e-02f, -8.00621659e-02f,
  -1.00002967e-01f, 1.59491271e-01f, -7.08311424e-02f, -1.05566561e-01f, 1.12605728e-01f, 2.48104230e-01f, 2.11244062e-01f, -9.08536911e-02f, 3.78987230e-02f, 2.75785401e-02f,
  -2.74110436e-01f, 5.31180128e-02f, -1.49559468e-01f, -1.66731738e-02f, -1.22888736e-01f, -4.23005000e-02f, 6.52668625e-02f, 4.50996235e-02f, 1.85341458e-03f, 2.79539675e-02f,
  8.73868614e-02f, -1.06247447e-01f, 5.26308175e-03f, 3.63559537e-02f, 2.27679238e-02f, 1.53991088e-01f, -8.87829363e-02f, -1.01327458e-02f, -9.77001432e-03f, -3.13464459e-03f,
  -1.07430995e-01f, 1.13852516e-01f, -1.10771760e-01f, -7.27799088e-02f, -4.53287400e-02f, -4.50670421e-02f, -5.23965880e-02f, 3.95323366e-01f, -2.91125895e-03f, 3.08633387e-01f,
  -1.08479209e-01f, -1.04275860e-01f, 1.88933238e-01f, 5.45220673e-02f, 2.74853945e-01f, 1.19218364e-01f, -3.88080508e-01f, 7.63283344e-03f, 6.20135590e-02f, 1.59329802e-01f,
  -1.36142924e-01f, -1.48545802e-01f, 1.88283566e-02f, -5.47060976e-04f, -4.95256819e-02f, 9.09677893e-02f, -1.51796892e-01f, 1.25623241e-01f, -3.14190686e-02f, -2.72930916e-02f,
  -3.28201018e-02f, -1.46424890e-01f, 3.72538090e-01f, 9.61256623e-02f, -5.46965860e-02f, 1.03404924e-01f, -1.44856542e-01f, 1.16678163e-01f, 1.13588899e-01f, -1.38840690e-01f,
  1.50014579e-01f, -6.12616576e-02f, 2.54165024e-01f, -1.98476762e-01f, -3.97278666e-01f, 2.58400124e-02f, -1.58444136e-01f, -1.07888155e-01f, 1.36566879e-02f, 3.41811590e-02f,
  -3.28137749e-03f, -1.22725956e-01f, -2.19265446e-01f, 3.46241146e-02f, -8.76771882e-02f, -8.26881528e-02f, -1.16801545e-01f, -2.35496402e-01f, 1.00491263e-01f, -2.82703713e-02f,
  -1.83268115e-01f, -7.80999884e-02f, 3.14147621e-02f, -6.34201840e-02f, -4.97870669e-02f, -1.57850012e-01f, -1.67600796e-01f, 1.21184206e-02f, -2.07110178e-02f, -3.76538113e-02f,
  -4.74127792e-02f, -4.53251116e-02f, 2.19262108e-01f, 1.61775678e-01f, 2.28129849e-02f, 8.79713446e-02f, 1.84992760e-01f, 3.77973646e-01f, 1.84149876e-01f, 6.40874077e-03f,
  -1.22999899e-01f, 1.19806767e-01f, 2.73594379e-01f, 1.57253936e-01f, 9.46935564e-02f, 7.50612840e-02f, -1.11420453e-01f, 9.24616680e-02f, 6.30192831e-02f, 1.14100650e-01f,
  -2.14113370e-02f, -1.20827168e-01f, -1.27820447e-02f, 2.79626269e-02f, 5.54979704e-02f, -1.81513131e-02f, 1.82430238e-01f, 1.64184347e-01f, 9.45888236e-02f, 1.37783602e-01f,
  -4.59918007e-02f, 4.84649599e-01f, 5.23976907e-02f, -9.75127965e-02f, -6.91965595e-02f, -5.83000183e-02f, 1.85839579e-01f, -8.49276260e-02f, -7.12771574e-03f, -2.10402042e-01f,
  -4.77340221e-02f, 4.28815186e-02f, 1.09929834e-02f, -1.31372705e-01f, 4.16778289e-02f, 3.33751626e-02f, 1.08806603e-01f, -2.21012514e-02f, 9.15270746e-02f, -4.08822000e-02f,
  2.69274600e-02f, 1.23900905e-01f, -8.30770880e-02f, -7.16432706e-02f, 1.56176565e-02f, -4.31178603e-03f, 5.12116775e-02f, 1.01693552e-02f, 1.62478834e-01f, 3.69692631e-02f,
  -5.41345042e-04f, 6.80297390e-02f, 7.08045885e-02f, 2.17111800e-02f, 1.14005499e-01f, -1.84686586e-01f, 6.53671771e-02f, -3.15667003e-01f, -1.19024262e-01f, 7.94168860e-02f,
  -3.00380409e-01f, -1.69236273e-01f, 6.73792064e-02f, 6.17237855e-03f, -1.45549700e-01f, 4.82411198e-02f, -1.48778155e-01f, -2.63077896e-02f, -9.78847966e-02f, 5.46325818e-02f,
  6.16660565e-02f, -6.09298237e-02f, 1.13447301e-01f, 1.06259830e-01f, -1.14800155e-01f, -3.17278542e-02f, -8.50614533e-02f, -2.80335322e-02f, -8.89434293e-02f, -2.23221883e-01f,
  -5.87507300e-02f, 1.07209288e-01f, 3.47872339e-02f, -1.16252832e-01f, 6.81592524e-02f, -4.20232028e-01f, -4.31821756e-02f, 2.45241642e-01f, 7.01341406e-02f, 1.47588685e-01f,
  -1.46423906e-01f, 5.02832280e-03f, -3.09377521e-01f, -1.27836913e-01f, -3.79787162e-02f, -4.81624082e-02f, 2.73166262e-02f, 7.40952790e-02f, -4.81453836e-02f, 3.97246592e-02f,
  -1.75015822e-01f, -1.37366980e-01f, 5.89691056e-03f, 1.39081493e-01f, -5.80691025e-02f, -1.92302212e-01f, 2.66075701e-01f, -6.91781864e-02f, -2.54912283e-02f, -1.56744242e-01f,
  4.26107980e-02f, -7.23801702e-02f, -3.19550410e-02f, -7.16358200e-02f, -1.31565213e-01f, 6.60601258e-02f, 1.17140330e-01f, 9.69674960e-02f, 6.72574937e-02f, -1.78191364e-01f,
  -8.10771063e-02f, 5.85537590e-02f, 9.26355422e-02f, 4.87255976e-02f, -1.23183141e-02f, -1.13011032e-01f, 9.87287611e-02f, -4.97414060e-02f, -1.01118632e-01f, 8.94201547e-02f,
  1.07988566e-01f, -2.19341740e-01f, -1.62098676e-01f, -1.21025451e-01f, 7.89491534e-02f, -6.53556660e-02f, -4.82916832e-02f, -2.49931589e-02f, -9.76853743e-02f, 1.11646168e-01f,
  5.65300807e-02f, -1.51707456e-01f, -3.29725556e-02f, 8.25435817e-02f, 2.20401004e-01f, -1.14824951e-01f, 8.00185204e-02f, -8.79837796e-02f, -8.67462084e-02f, 3.08817446e-01f,
  7.37645999e-02f, 3.58416378e-01f, -2.58047819e-01f, -1.49465114e-01f, 9.18281823e-02f, -2.20401615e-01f, 8.65265578e-02f, 3.79199445e-01f, -4.42091078e-02f, -3.31751518e-02f,
  -6.81843385e-02f, -5.26485918e-03f, 5.96695244e-02f, 1.94865391e-02f, 8.55658352e-02f, 1.40055075e-01f, 1.35253947e-02f, 3.42728794e-01f, 1.96200423e-03f, 8.21709186e-02f,
  1.04346886e-01f, 2.66516536e-01f, 9.91318673e-02f, -1.77112352e-02f, 1.06305823e-01f, 3.81661914e-02f, 1.92566723e-01f, 8.71745870e-02f, 9.98859406e-02f, -9.35921744e-02f,
  -1.07471883e-01f, 4.71984148e-02f, -2.99076550e-02f, -1.06244944e-01f, 1.57261416e-01f, -1.07425839e-01f, -1.15793217e-02f, -7.76125565e-02f, 1.45929598e-03f, 3.36516164e-02f,
  2.86034435e-01f, 1.89521119e-01f, -1.75381437e-01f, -1.41686648e-01f, 1.43506780e-01f, 1.25291958e-01f, -2.54015215e-02f, -1.21073825e-02f, 3.08917891e-02f, 1.07243843e-01f,
  4.24874537e-02f, 3.30772281e-01f, -1.67055175e-01f, 1.05452761e-01f, -1.97514579e-01f, -1.83843747e-01f, 1.17575407e-01f, -3.17868590e-02f, 1.79256499e-01f, -2.21212670e-01f,
  1.54957637e-01f, 2.84038126e-01f, -3.79912823e-01f, 1.49735972e-01f, -1.41893802e-02f, 1.53947338e-01f, 1.93214729e-01f, 1.94403473e-02f, 7.71746412e-02f, -6.16620928e-02f,
  -8.52244124e-02f, 1.58229232e-01f, 1.01214737e-01f, -5.63238710e-02f, -1.04798786e-01f, 5.15894704e-02f, -2.71724276e-02f, 8.32291842e-02f, 2.41792835e-02f, -5.02064191e-02f,
  5.11658490e-02f, -8.35652202e-02f, 3.51279825e-02f, -2.27755621e-01f, 1.41706809e-01f, 1.62165374e-01f, -3.53784338e-02f, -6.25321120e-02f, 6.85360506e-02f, -7.92815760e-02f,
  -8.50241929e-02f, -2.73055229e-02f, -1.15106553e-01f, -9.97941718e-02f, -3.43735404e-02f, 4.13003787e-02f, 7.42956474e-02f, 1.29982233e-01f, 5.03644757e-02f, 2.26108417e-01f,
  2.54451670e-02f, -9.28083807e-02f, -6.57912940e-02f, -1.88031718e-01f, 2.73145139e-02f, 3.34057212e-02f, 1.26679778e-01f, -6.50827885e-02f, 9.18326434e-03f, 3.82064395e-02f,
  -7.93743432e-02f, -6.51195869e-02f, -5.58728650e-02f, -7.64308199e-02f, 3.51735689e-02f, -2.07738653e-01f, -4.90129599e-03f, 1.20696314e-01f, 1.10458657e-01f, 3.88961434e-02f,
  2.59738490e-02f, -4.92899492e-02f, 1.46544784e-01f, 1.90155476e-01f, 7.45130703e-02f, -2.88916707e-01f, -5.84786199e-02f, -6.22719415e-02f, -1.02048993e-01f, 2.31586080e-02f,
  -3.85507286e-01f, 9.84899700e-02f, 1.60872266e-02f, -1.75125867e-01f, -1.75618321e-01f, 1.61279008e-01f, -1.47539303e-01f, -1.00054204e-01f, -4.33501648e-03f, -2.87316162e-02f,
  6.55218214e-02f, -9.76183787e-02f, 7.10764676e-02f, 9.22223367e-03f, -6.20237133e-03f, 3.03516872e-02f, 3.13669629e-02f, 1.91801041e-02f, -1.36570379e-01f, 1.16183244e-01f,
  3.81117724e-02f, 1.66359730e-02f, 4.59900536e-02f, 1.24045797e-01f, -5.16050234e-02f, -1.00159876e-01f, 9.54111107e-03f, -7.76545703e-02f, -1.17941260e-01f, 5.27505241e-02f,
  -2.10034903e-02f, 1.70383707e-01f, 2.08185941e-01f, 3.27364579e-02f, -1.56093016e-01f, -6.90237135e-02f, 2.31985837e-01f, -4.50417809e-02f, 3.29096913e-01f, 1.12814695e-01f,
  -5.02699375e-01f, -5.66173121e-02f, 9.59398132e-03f, 2.38092721e-01f, 3.90327498e-02f, 7.37404749e-02f, -1.22580543e-01f, 5.11263832e-02f, 3.10859308e-02f, 1.70456097e-01f,
  1.65300325e-01f, -3.88938468e-03f, -8.65790769e-02f, -2.18927804e-02f, 5.40009737e-02f, 4.21112701e-02f, 2.05612183e-01f, 1.51576743e-01f, 3.70519646e-02f, 6.07237592e-02f,
  5.22876717e-03f, -2.30659440e-01f, 9.62795839e-02f, 1.33910701e-01f, 2.12365031e-01f, -2.59352267e-01f, 1.88866645e-01f, -1.31624145e-02f, -2.07973033e-01f, 4.03927686e-03f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  9.25662098e-05f, 7.19511732e-02f, 1.25253454e-01f, 1.92396939e-01f, 1.69343185e-02f, 9.45917666e-02f, -8.62444863e-02f, 2.11816609e-01f, 8.90519097e-02f, -8.96787196e-02f,
  8.72363336e-03f, -1.85131267e-01f, 3.28757048e-01f, 1.08368509e-02f, 1.61846995e-01f, -2.50159465e-02f, 1.44208893e-01f, 1.74658254e-01f, -1.50050566e-01f, -1.96699183e-02f,
  -7.04916045e-02f, -2.34937109e-02f, 1.72378287e-01f, 6.03247210e-02f, -9.65210870e-02f, 1.27640858e-01f, 3.32733467e-02f, 3.59367996e-01f, -6.61187842e-02f, 2.06221834e-01f,
  2.88431704e-01f, 2.29368538e-01f, 5.46705425e-02f, -4.15671207e-02f, -2.41409808e-01f, 1.40989453e-01f, 1.54184207e-01f, 2.12598257e-02f, 1.06406696e-02f, 2.31940955e-01f,
  -5.11435233e-03f, -2.45575979e-02f, -1.35941535e-01f, -2.41005272e-01f, 2.01497123e-01f, -2.01782390e-01f, 9.81638357e-02f, 1.36438772e-01f, 7.81565607e-02f, 1.79177135e-01f,
  2.90840179e-01f, 1.32461771e-01f, 2.69948900e-01f, 3.27405155e-01f, 2.45704576e-01f, 4.43740845e-01f, -2.67895520e-01f, 2.44229380e-02f, -1.22220345e-01f, -2.85466373e-01f,
  -3.34694944e-02f, 6.19280040e-02f, 2.52107918e-01f, 2.38308772e-01f, 1.52602941e-01f, -6.30432069e-02f, 2.67253041e-01f, 8.77688378e-02f, 4.82436344e-02f, 5.76857813e-02f,
  1.86991856e-01f, 3.27041000e-01f, 2.96598494e-01f, 2.97796845e-01f, 8.60847160e-02f, 1.83200568e-01f, 3.50030839e-01f, 2.39317268e-01f, 1.06957801e-01f, 1.48887753e-01f,
  1.08456045e-01f, 1.75902963e-01f, 2.97479518e-02f, 3.85069735e-02f, -3.31205055e-02f, -1.81309670e-01f, 2.12498546e-01f, 7.33762607e-02f, 2.19273910e-01f, -1.75180689e-01f,
  9.62549355e-03f, 2.09143102e-01f, 2.17591032e-01f, 7.46647790e-02f, -1.02163449e-01f, 2.25479543e-01f, 2.09968090e-01f, -5.88967428e-02f, -4.42767709e-01f, 4.36961874e-02f,
  2.86389500e-01f, -2.48465925e-01f, 1.58421155e-02f, -6.76752776e-02f, -1.57865733e-01f, -1.46775432e-02f, -2.47659519e-01f, 1.75766245e-01f, -2.79642642e-01f, -9.61932763e-02f,
  2.35741571e-01f, -3.19401294e-01f, 8.25715661e-02f, 4.01911028e-02f, 5.86081207e-01f, -2.87962183e-02f, 3.05521876e-01f, -1.93674535e-01f, -1.60477638e-01f, 3.17985415e-01f,
  -5.44829741e-02f, 9.22863781e-02f, 9.97614041e-02f, -1.26292214e-01f, -1.07532769e-01f, -7.35340267e-02f, -1.38114855e-01f, 1.90900579e-01f, 9.80055146e-03f, -8.25727824e-04f,
  2.97607984e-02f, 2.62618452e-01f, 2.93437261e-02f, 1.93438664e-01f, -4.37652096e-02f, 9.59152132e-02f, 6.09748997e-02f, 1.47374079e-01f, 1.81963101e-01f, -1.57894686e-01f,
  2.35185713e-01f, -1.20302655e-01f, -7.68030658e-02f, 1.14556924e-01f, 1.71513073e-02f, 1.03409134e-01f, 2.77854741e-01f, 1.76364794e-01f, -1.68359503e-01f, 1.59137174e-01f,
  1.37990236e-01f, 1.30712554e-01f, 3.28541212e-02f, -1.07445806e-01f, 1.74865752e-01f, -2.63324440e-01f, 2.02612132e-02f, -2.71016836e-01f, -7.21383914e-02f, -2.24761099e-01f,
  7.30351433e-02f, 6.98726717e-03f, 2.26509899e-01f, 5.65892877e-03f, 2.02121995e-02f, -4.65738326e-02f, -1.82431102e-01f, -1.67568028e-01f, 2.78041542e-01f, -1.75293609e-01f,
  1.55250609e-01f, -5.12318388e-02f, -1.20928721e-03f, 1.39948577e-01f, -2.14012526e-02f, -8.34279433e-02f, 1.02814361e-01f, -1.84102193e-01f, 1.86202049e-01f, -1.78092197e-01f,
  1.70598686e-01f, -4.09427226e-01f, -3.53458762e-01f, -3.33923042e-01f, 2.64037788e-01f, 3.16270590e-01f, -4.62041110e-01f, 3.31125587e-01f, 2.23455159e-03f, -1.10652365e-01f,
  -3.03206235e-01f, 1.44008994e-01f, 1.37652993e-01f, 8.17965195e-02f, 1.54310003e-01f, -8.86657387e-02f, -1.58143923e-01f, 1.14027932e-01f, 1.97897762e-01f, -7.44644552e-03f,
  2.82632597e-02f, -7.37890080e-02f, 4.49450165e-02f, 2.33695090e-01f, -2.32995629e-01f, 3.91858332e-02f, 1.43925056e-01f, -4.79125232e-03f, 1.57735318e-01f, 1.26996562e-01f,
  -1.64525192e-02f, 1.22248910e-01f, 9.85812768e-02f, 1.44111201e-01f, 8.79659355e-02f, 5.13540655e-02f, 9.78488382e-03f, 3.13403815e-01f, -4.35978584e-02f, -8.54934826e-02f,
  7.21866190e-02f, 1.45330345e-02f, -6.66182637e-02f, -9.27024782e-02f, -1.57657847e-01f, -5.14494488e-03f, 3.27814847e-01f, 2.09395997e-02f, -3.18321586e-01f, -1.06825203e-01f,
  -1.71570733e-01f, -1.58426449e-01f, 1.72004737e-02f, 2.73403320e-02f, -3.05440128e-02f, -2.04592332e-01f, -9.32622701e-02f, -2.25066766e-02f, -3.99908088e-02f, 1.64725125e-01f,
  3.23049426e-02f, 1.41860014e-02f, -1.17873944e-01f, 1.54759243e-01f, -5.49850285e-01f, 3.86741221e-01f, 2.57520914e-01f, 1.33987322e-01f, 1.66101530e-01f, 1.08742662e-01f,
  6.05765730e-02f, -1.98283345e-01f, 2.15728879e-01f, -3.73144001e-02f, 2.25988686e-01f, -3.12188089e-01f, -1.08031467e-01f, 1.93053279e-02f, 1.03438176e-01f, 1.08630352e-01f,
  -1.44055367e-01f, -1.56632122e-02f, -1.08108066e-01f, 9.78304371e-02f, -2.23765243e-02f, 2.12963760e-01f, 1.03699431e-01f, -2.88648784e-01f, 1.52320221e-01f, -2.54744347e-02f,
  9.33328271e-02f, -9.27765891e-02f, -1.93137914e-01f, 8.43558684e-02f, 2.21200585e-01f, -3.72361951e-02f, -3.41978222e-01f, 1.37571737e-01f, -3.88668105e-02f, 1.45642862e-01f,
  4.42318171e-02f, 1.85853858e-02f, 5.57220615e-02f, -2.09125265e-01f, 4.37727273e-02f, -2.93792486e-01f, 1.06085889e-01f, -4.19696301e-01f, 7.83981308e-02f, 6.98649585e-02f,
  -1.27113760e-01f, 2.26421859e-02f, -1.67161107e-01f, 2.18328878e-01f, -3.19625556e-01f, -1.98932201e-01f, 2.06348866e-01f, -5.34426719e-02f, 3.93492907e-01f, 1.45718381e-01f,
  -4.26487774e-02f, 1.17309116e-01f, -2.97143370e-01f, 3.53725255e-02f, 1.05815940e-01f, -7.81181231e-02f, -2.24332154e-01f, -2.22338792e-02f, 9.12330821e-02f, 2.58206129e-01f,
  -4.44501460e-01f, -1.79447263e-01f, -4.57422622e-02f, -2.01768223e-02f, 8.70406926e-02f, 8.54143407e-03f, 1.90908819e-01f, -3.64788681e-01f, -7.48436213e-01f, 1.21939629e-01f,
  2.72189409e-01f, 2.21612796e-01f, 4.97806929e-02f, 1.84973165e-01f, 2.16719255e-01f, 8.76880586e-02f, 2.36935377e-01f, 1.37937248e-01f, 1.65393297e-02f, 2.25525871e-01f,
  -1.47435255e-02f, 3.06801736e-01f, 8.17568153e-02f, 1.10366292e-01f, 7.47500407e-03f, 1.21728428e-01f, 2.27278136e-02f, 1.79449812e-01f, 2.28696331e-01f, 1.28649488e-01f,
  -1.52127119e-02f, 1.95416942e-01f, 2.23720163e-01f, 2.09913611e-01f, 1.07348271e-01f, -8.55267569e-02f, 1.45601511e-01f, -1.19146071e-01f, -2.97452986e-01f, 1.64902866e-01f,
  9.29351375e-02f, -1.72980651e-01f, -2.49634594e-01f, -2.65443586e-02f, 1.86648622e-01f, -7.51831606e-02f, -2.54965611e-02f, 2.20267802e-01f, 1.68462619e-01f, 9.98788327e-02f,
  2.24596590e-01f, 6.96852058e-02f, -1.18481666e-01f, -9.06978026e-02f, 9.59627032e-02f, -7.35021532e-02f, 1.92522798e-02f, -4.33156872e-03f, -5.01070209e-02f, 1.28909886e-01f,
  -6.14897251e-01f, 1.42280860e-02f, 1.73650786e-01f, 3.02840352e-01f, 1.22290872e-01f, -2.35332251e-01f, -1.67005897e-01f, -2.98228562e-01f, 2.36464739e-01f, 1.72385737e-01f,
  -5.51568046e-02f, 2.34882832e-01f, 3.43161941e-01f, -2.40112524e-02f, -7.59415980e-03f, 8.70648480e-04f, 7.54935741e-02f, 9.68912467e-02f, 6.64589405e-02f, 1.54815940e-02f,
  7.85043184e-03f, 1.16138890e-01f, 1.80275720e-02f, 1.38057008e-01f, -5.89453466e-02f, 2.30133921e-01f, -3.89458612e-02f, 2.15771999e-02f, -5.33463657e-02f, 2.16427892e-01f,
  5.05556501e-02f, 6.73775747e-02f, -1.63362157e-02f, -8.70788097e-02f, 3.17062736e-02f, 7.97084570e-02f, 2.56366879e-01f, 3.44903432e-02f, -8.10760725e-03f, -5.97406039e-03f,
  -1.68655366e-01f, -1.35130867e-01f, 3.00058603e-01f, -2.32641902e-02f, -7.34229907e-02f, 2.47404099e-01f, -3.90779190e-02f, -9.43270177e-02f, -3.83186303e-02f, -2.93415331e-04f,
  -1.09013081e-01f, -8.94191936e-02f, 1.12090357e-01f, -9.42539722e-02f, -2.70380855e-01f, 3.99835445e-02f, -7.73114711e-02f, 2.70177752e-01f, -3.22980434e-02f, -4.56106439e-02f,
  4.01819348e-01f, -2.18860298e-01f, -2.61320978e-01f, 1.06316688e-03f, 5.26569113e-02f, 1.23153860e-02f, 1.97478440e-02f, 1.14765793e-01f, 2.41136387e-01f, 4.88559842e-01f,
  1.12222112e-03f, -4.65162694e-01f, 4.70394701e-01f, -2.44153321e-01f, -3.49815845e-01f, 5.47609329e-01f, 3.40493500e-01f, -1.75689787e-01f, 6.09650984e-02f, 1.57989010e-01f,
  1.24496788e-01f, -3.80650461e-02f, -1.31999865e-01f, 1.17639020e-01f, -4.71664732e-03f, 1.01060636e-01f, -2.81224642e-02f, 2.94192374e-01f, 3.29811461e-02f, 2.68643443e-02f,
  1.54652193e-01f, 5.13736010e-02f, 9.36752111e-02f, 2.33236894e-01f, 9.77049321e-02f, -3.14248912e-02f, 1.76839143e-01f, 1.90106466e-01f, 7.46824453e-03f, -9.01308283e-02f,
  1.03320539e-01f, 8.29162262e-03f, 8.29196125e-02f, -4.10449505e-02f, -5.28039448e-02f, 1.42147271e-02f, 1.32893801e-01f, -4.46869619e-02f, -5.59743941e-02f, 2.90941089e-01f,
  -8.14860910e-02f, 5.67199513e-02f, -1.03035338e-01f, 2.04756930e-02f, 3.06118101e-01f, -3.66080314e-01f, 7.13016838e-02f, -1.87857881e-01f, -1.03791028e-01f, 5.43815605e-02f,
  1.38117462e-01f, 1.79754093e-01f, -2.54750133e-01f, -1.69583246e-01f, -7.67458975e-02f, 1.75882518e-01f, -1.49093777e-01f, -1.48672000e-01f, 3.19786787e-01f, 1.16527095e-01f,
  2.96601474e-01f, 3.03815275e-01f, -1.41447917e-01f, 5.25339067e-01f, 1.51297286e-01f, -1.79996654e-01f, 2.72909611e-01f, 1.12061091e-01f, -8.50238092e-03f, -6.03680968e-01f,
  1.83131509e-02f, 2.04721078e-01f, 2.90343136e-01f, 3.53397382e-03f, 3.02793503e-01f, 8.70838761e-02f, 1.59944326e-01f, 1.45137355e-01f, 4.05371159e-01f, 2.63791770e-01f,
  -7.68617392e-02f, 2.43860707e-01f, 6.96870238e-02f, 3.93841386e-01f, 1.43809587e-01f, 2.05274791e-01f, 2.17851326e-01f, 2.51777530e-01f, -1.52159914e-01f, 2.26824611e-01f,
  1.75667271e-01f, 5.27958907e-02f, 2.42085472e-01f, -1.29907712e-01f, 2.27004826e-01f, 1.16375521e-01f, 7.67029375e-02f, -1.42232524e-02f, -6.11696392e-02f, 1.93700090e-01f,
  -2.12877899e-01f, 1.66036084e-01f, -1.15111563e-02f, 1.09867141e-01f, -2.22629294e-01f, -1.18193552e-01f, -4.35273468e-01f, 3.03748339e-01f, 1.76013838e-02f, 5.74581325e-02f,
  1.29239991e-01f, 2.35598072e-01f, 7.28993565e-02f, -4.59727049e-02f, -2.32528105e-01f, -3.08051948e-02f, -3.13559845e-02f, -1.08416207e-01f, 1.14121199e-01f, -1.36504928e-02f,
  3.38983499e-02f, 2.80557603e-01f, 1.39097106e-02f, -2.25954577e-01f, 1.61443233e-01f, 1.81107506e-01f, 1.85337231e-01f, 3.19120526e-01f, -3.00595075e-01f, -2.91832983e-01f,
  3.79892349e-01f, -4.26040024e-01f, -9.57202092e-02f, 2.03097254e-01f, 2.59637266e-01f, 3.92156154e-01f, 6.79609627e-02f, 2.13750213e-01f, 2.25954860e-01f, 3.04732341e-02f,
  1.95315644e-01f, 9.27104428e-02f, -1.83825836e-01f, 3.60097885e-01f, 4.13550399e-02f, 3.14921886e-01f, 1.79077670e-01f, -8.74195434e-03f, 1.49869114e-01f, -5.05738147e-02f,
  3.00780207e-01f, -5.74080199e-02f, 1.52929025e-02f, 1.87477663e-01f, 2.39208773e-01f, -6.87916204e-03f, 9.10841823e-02f, 2.23543018e-01f, 1.73762307e-01f, 1.62032455e-01f,
  7.21423775e-02f, -2.27956310e-01f, 2.19608560e-01f, -3.76679868e-01f, -1.58679172e-01f, -4.45686392e-02f, 8.01045299e-02f, -5.87072410e-02f, -2.48464212e-01f, 9.83903408e-02f,
  1.16174288e-01f, 8.73925835e-02f, 1.74832359e-01f, -1.05012380e-01f, -6.67715073e-02f, -8.28236043e-02f, 1.67947970e-02f, -3.64234373e-02f, 1.76597685e-01f, -5.69918118e-02f,
  -1.00087807e-01f, -1.39144763e-01f, -2.35196859e-01f, 1.74759358e-01f, 4.36364301e-02f, 1.06344417e-01f, -1.18785322e-01f, 7.35519230e-02f, 5.62870085e-01f, 6.35341346e-01f,
  -6.91897869e-01f, 1.71580046e-01f, -2.80606866e-01f, -9.63153224e-03f, 1.03296869e-01f, -1.96647093e-01f, 1.36595637e-01f, -4.16671634e-01f, -3.30879122e-01f, 3.60038102e-01f,
  8.10386762e-02f, -1.47772431e-01f, -2.49541327e-01f, -1.08118698e-01f, 1.85993299e-01f, 1.61159232e-01f, 1.48045689e-01f, 1.58108041e-01f, 9.61756259e-02f, -2.08296806e-01f,
  -4.67884801e-02f, -2.78373778e-01f, 2.03572899e-01f, -2.14776769e-02f, 7.07743615e-02f, -1.77236274e-01f, 1.01589382e-01f, 1.26296625e-01f, -1.42248496e-01f, -1.56650707e-01f,
  1.47637531e-01f, -1.08287208e-01f, -1.95244014e-01f, -1.23127498e-01f, -7.50791654e-02f, -2.68051606e-02f, -3.42597634e-01f, 4.83871698e-01f, -1.58315986e-01f, -3.54371071e-02f,
  7.38384202e-03f, 1.97167039e-01f, -3.18002291e-02f, 7.83688426e-02f, -4.55330491e-01f, 7.38926157e-02f, -8.18042234e-02f, -5.87437190e-02f, -1.60050750e-01f, 1.15474880e-01f,
  -3.10600579e-01f, -1.76322341e-01f, 3.78927410e-01f, -4.13206786e-01f, -7.28244781e-02f, -8.90858099e-02f, -3.08761001e-03f, 5.76974340e-02f, 7.55598620e-02f, -1.10457679e-02f,
  9.72598717e-02f, -9.16015450e-03f, -2.24150587e-02f, 6.37488589e-02f, 7.03506544e-02f, -1.09571315e-01f, -1.74374744e-01f, -2.38668934e-01f, -3.47602397e-01f, -3.00892442e-01f,
  -1.79886565e-01f, -7.56666586e-02f, -2.57961988e-01f, 4.44459260e-01f, 1.04779415e-01f, 7.05226883e-02f, 7.88954645e-02f, 1.59600407e-01f, 7.20862150e-02f, 1.26392484e-01f,
  1.50683746e-01f, 1.80650517e-01f, 1.11603253e-01f, -1.49602666e-02f, 1.90378100e-01f, 3.77660364e-01f, 5.83645795e-03f, 2.10876077e-01f, 1.46977291e-01f, 9.95764881e-02f,
  1.87633157e-01f, 2.98684657e-01f, 7.04038069e-02f, 1.63965344e-01f, 1.63285419e-01f, 2.14926749e-01f, -6.69246987e-02f, 1.88368186e-01f, 2.74297953e-01f, 4.25938845e-01f,
  2.62165517e-01f, -4.81740646e-02f, -9.14140418e-02f, 1.07280254e-01f, 8.09431076e-02f, -9.17857066e-02f, 3.01016927e-01f, 1.03903227e-01f, 3.26638997e-01f, -6.71422258e-02f,
  4.73628640e-02f, -4.02288251e-02f, -8.22725669e-02f, -5.71875647e-02f, 2.86935009e-02f, 1.17133074e-01f, -3.80331688e-02f, 3.85714113e-03f, 1.33667931e-01f, -1.81413263e-01f,
  -3.99637520e-01f, 1.75990894e-01f, 1.88350379e-02f, 4.42975275e-02f, 5.69352686e-01f, -5.53249829e-02f, 3.21318537e-01f, 1.94197699e-01f, 9.38690901e-02f, -2.18610808e-01f,
  1.83102503e-01f, 4.26719278e-01f, -3.65738496e-02f, -1.46095634e-01f, -2.73571834e-02f, 5.27017713e-02f, -1.12078018e-01f, -9.50130969e-02f, 3.56980711e-01f, -1.02270385e-02f,
  1.02101400e-01f, -3.21276509e-03f, 1.76048934e-01f, 2.45976910e-01f, 2.25532487e-01f, 3.77370417e-01f, 2.38044202e-01f, 2.80999154e-01f, 1.16251610e-01f, -1.59585364e-02f,
  6.74644560e-02f, 2.27569025e-02f, 2.10569337e-01f, -7.43125230e-02f, 1.08248316e-01f, -2.45357002e-03f, 2.78677642e-01f, 1.69225726e-02f, -1.81571171e-01f, -1.63484782e-01f,
  2.03251883e-01f, 3.72586176e-02f, 8.51661712e-02f, -3.92177224e-01f, -1.91250652e-01f, -1.01790786e-01f, 1.81674704e-01f, 2.23643646e-01f, -3.34393978e-01f, -1.17385484e-01f,
  -4.85295475e-01f, 7.88835958e-02f, -1.47853807e-01f, 1.15127467e-01f, -2.44694293e-01f, -3.88369411e-01f, 1.96667105e-01f, 7.58333579e-02f, 2.06845254e-02f, 1.62239429e-02f,
  -1.56031176e-02f, -2.99264222e-01f, -2.24730983e-01f, -8.20088685e-02f, 1.66170359e-01f, -1.53462827e-01f, -2.04906955e-01f, 1.12049095e-01f, -6.84159935e-01f, -9.25246328e-02f,
  -3.81794930e-01f, -3.71474355e-01f, 1.44443229e-01f, -1.64982349e-01f, 1.75751187e-02f, -2.10375991e-02f, -1.73772395e-01f, -4.23641652e-02f, 1.21282332e-01f, -6.03091232e-02f,
  -2.25717828e-01f, 4.97865796e-01f, 9.14769545e-02f, 1.92837939e-02f, 8.25114548e-02f, 1.12528920e-01f, -1.83531776e-01f, 1.12717517e-01f, -9.54656452e-02f, 4.82078195e-02f,
  -6.88349530e-02f, -1.42160449e-02f, -6.44945167e-03f, -7.72305205e-02f, 2.47917384e-01f, -1.83118731e-01f, -1.18670143e-01f, 6.43017665e-02f, 1.46674886e-01f, -2.06221100e-02f,
  -1.05424233e-01f, 2.88321804e-02f, 8.15473795e-02f, 5.34396172e-02f, 5.32011613e-02f, 5.67976609e-02f, 7.68148080e-02f, 6.54675886e-02f, -1.28852382e-01f, -3.95860374e-02f,
  5.04652895e-02f, -1.15590855e-01f, -1.87270865e-02f, 2.15321198e-01f, -1.10210590e-01f, 1.45787343e-01f, 4.99443740e-01f, 1.19052678e-01f, -8.49616826e-02f, -8.62538144e-02f,
  -4.89349179e-02f, -8.33683386e-02f, -1.06187671e-01f, -5.47533371e-02f, 4.42484058e-02f, -1.42193928e-01f, 1.54420257e-01f, 7.66140968e-02f, -1.48901332e-03f, 1.56346947e-01f,
  8.26336071e-03f, 7.02770129e-02f, -1.24957107e-01f, 1.37289137e-01f, -9.99557376e-02f, -5.23682758e-02f, 1.56279445e-01f, 1.25620350e-01f, 3.64834934e-01f, -1.79522876e-02f,
  -6.07302375e-02f, -6.29070103e-02f, 1.77146032e-01f, 3.61025810e-01f, 2.72708714e-01f, -3.70023966e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  9.57297310e-02f, 1.10281684e-01f, 8.08923021e-02f, 7.95792565e-02f, 4.29758057e-02f, 3.56768537e-03f, 2.19406456e-01f, 1.74614042e-01f, 1.79589987e-01f, 4.17078167e-01f,
  -1.09902531e-01f, 2.33461246e-01f, 1.19028628e-01f, -3.04259695e-02f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.57023415e-01f, -2.09116831e-01f, -3.84897850e-02f, -4.02011424e-02f, -1.98728234e-01f, -1.36033550e-01f, -1.52915835e-01f, -1.63030237e-01f, -3.61002088e-01f, -5.79703739e-03f,
  -4.07811463e-01f, -1.73147798e-01f, -1.27125278e-01f, 4.87415399e-03f, -1.32695045e-02f, -9.91663784e-02f, -2.22314641e-01f, -1.11497715e-01f, 2.19394028e-01f, 2.79939473e-02f,
  -2.27164999e-01f, -1.52350232e-01f, -1.76630586e-01f, -4.39179577e-02f, -1.05462549e-02f, 1.43881187e-01f, 5.55655546e-02f, 1.09816432e-01f, -8.76831040e-02f, -3.08020294e-01f,
  1.93919972e-01f, -8.35086312e-03f, 7.11968541e-02f, 2.10434094e-01f, -7.68537372e-02f, -1.61131188e-01f, 1.25175482e-02f, -4.15973008e-01f, 4.42297220e-01f, -1.99709274e-03f,
  -1.93638653e-01f, 7.49624670e-02f, 1.50260687e-01f, 2.86105633e-01f, -1.08443171e-01f, 1.74774155e-01f, 8.69164392e-02f, -2.67400622e-01f, 3.27905029e-01f, 3.20632964e-01f,
  -1.10346653e-01f, 6.51302412e-02f, 8.95425901e-02f, -1.55592084e-01f, -1.39050439e-01f, -8.63275304e-02f, -9.54249054e-02f, -1.20754205e-01f, -2.35606641e-01f, -2.63926297e-01f,
  -1.56620175e-01f, 1.80874631e-01f, -3.10724825e-01f, -7.76287541e-02f, -3.28287840e-01f, 1.02401555e-01f, -2.78010488e-01f, -4.09827307e-02f, 9.67568085e-02f, -8.54830593e-02f,
  6.07006624e-02f, -5.57906516e-02f, -2.80459642e-01f, 1.63819954e-01f, -3.76251549e-01f, -4.13004542e-03f, -2.23521497e-02f, -2.73275137e-01f, 2.16985822e-01f, 1.07496105e-01f,
  6.93691075e-02f, -1.55321851e-01f, 2.73183376e-01f, -1.66802481e-01f, -4.40583736e-01f, -2.26956699e-02f, -6.71463907e-02f, 1.43771738e-01f, 1.63926288e-01f, -8.36499333e-02f,
  -2.46219948e-01f, 1.16772108e-01f, -1.38128936e-01f, -1.31098717e-01f, -3.25114191e-01f, -6.79226592e-02f, -1.12412877e-01f, 6.70726672e-02f, 3.02143037e-01f, -4.11546463e-03f,
  -1.55772030e-01f, -1.79452643e-01f, 1.36181846e-01f, -4.46825586e-02f, 2.66023874e-01f, 3.48028958e-01f, -1.12965079e-02f, -1.11551754e-01f, 2.49705628e-01f, -1.82184830e-01f,
  3.34333569e-01f, -4.86840755e-02f, 2.71656871e-01f, -1.26237348e-01f, 5.09706251e-02f, -1.66139722e-01f, 2.51868933e-01f, -3.95861082e-02f, 1.70381770e-01f, 1.54097393e-01f,
  1.36564612e-01f, 1.68093517e-01f, -1.71169236e-01f, 1.13266252e-01f, 9.97454002e-02f, -2.13943496e-01f, -3.73698063e-02f, 1.67485863e-01f, 1.45889267e-01f, 6.18296824e-02f,
  -1.34333774e-01f, 2.22180143e-01f, -1.18527047e-01f, 5.53777209e-03f, -8.51230472e-02f, 1.70621410e-01f, -1.58984840e-01f, -4.29359563e-02f, -1.83076784e-01f, 1.78293511e-02f,
  9.85908061e-02f, -1.58785433e-01f, 2.40902722e-01f, 5.93530647e-02f, 2.36454174e-01f, -7.40932897e-02f, 4.43674484e-03f, -2.46300280e-01f, 2.39307992e-02f, 2.17072755e-01f,
  1.50532693e-01f, -6.88604861e-02f, 1.00834355e-01f, 1.30534127e-01f, 2.25136295e-01f, 2.94373006e-01f, -5.26520237e-02f, 1.99491873e-01f, -2.94918306e-02f, 1.31730512e-01f,
  1.02634557e-01f, -1.30878970e-01f, -4.89041246e-02f, -1.63216129e-01f, -1.57301515e-01f, 4.48020697e-02f, -1.59332737e-01f, -1.58732578e-01f, 1.37837991e-01f, -2.89579481e-02f,
  1.37314677e-01f, 1.44072905e-01f, -7.76793808e-02f, -1.62379723e-02f, 2.73613632e-01f, -2.52047479e-01f, 1.79664627e-01f, -2.03587756e-01f, -9.20260251e-02f, 3.54721211e-02f,
  1.40082575e-02f, 8.27797130e-02f, 1.60389561e-02f, 5.08553572e-02f, 1.59828484e-01f, 2.59284675e-02f, -1.72364150e-06f, -3.11500996e-01f, 1.92176312e-01f, -2.44942069e-01f,
  1.75252885e-01f, 1.74954608e-01f, -1.71024546e-01f, -2.34343022e-01f, 1.93667971e-02f, 2.06406161e-01f, -6.02128264e-03f, -4.98476401e-02f, 1.69575568e-02f, -7.29778633e-02f,
  4.05369662e-02f, -1.14028879e-01f, -6.99413717e-02f, -6.08235784e-03f, 1.89445481e-01f, 6.23884462e-02f, 5.81756867e-02f, -3.79405506e-02f, 1.45261094e-01f, -1.23701571e-03f,
  8.29192400e-02f, -1.45624489e-01f, 1.02043301e-01f, -1.23971223e-03f, -2.89831907e-01f, -1.15423419e-01f, -5.94233684e-02f, 3.04544359e-01f, -3.10791470e-02f, 2.56199241e-01f,
  4.68297713e-02f, 2.33556286e-01f, 1.78227559e-01f, 2.51223832e-01f, -3.62224840e-02f, 6.32703258e-03f, -3.74646820e-02f, 9.89100263e-02f, -3.38565111e-02f, -3.31088543e-01f,
  8.55358765e-02f, 3.96214187e-01f, -2.80505419e-01f, -2.43485078e-01f, 2.90316697e-02f, 6.07805289e-02f, -1.13749072e-01f, 9.21776667e-02f, -5.37866279e-02f, 1.26516730e-01f,
  6.29564822e-02f, 1.72744855e-01f, 2.26152390e-01f, -1.70174494e-01f, -4.16277014e-02f, 2.51101591e-02f, 2.03182682e-01f, 1.92752808e-01f, -2.52136350e-01f, -2.06219837e-01f,
  3.41732390e-02f, 1.23612754e-01f, -3.31755191e-01f, 1.00688294e-01f, 1.01852700e-01f, -1.22789569e-01f, 1.07029423e-01f, -1.27067938e-02f, -2.24322975e-02f, 5.30144153e-03f,
  2.09475532e-01f, 8.86937231e-02f, 5.35700656e-02f, -1.35166317e-01f, -3.09500489e-02f, 1.12614654e-01f, 1.17922820e-01f, -3.87671590e-02f, 2.57356316e-02f, 1.68069169e-01f,
  1.59738556e-01f, 2.77094748e-02f, -7.15089962e-02f, -9.52013433e-02f, -8.70962292e-02f, 3.57166857e-01f, -4.87118401e-02f, 1.04889154e-01f, 1.06105022e-01f, 9.44092423e-02f,
  -1.34543851e-01f, -1.09128319e-01f, -2.61836704e-02f, 1.40894443e-01f, -5.83498785e-03f, 1.37494534e-01f, 1.74881652e-01f, -1.49885014e-01f, -1.11128837e-01f, -1.09434091e-01f,
  1.87490135e-02f, 2.17798520e-02f, 1.22455239e-01f, 3.58374208e-01f, -7.23870646e-04f, -2.17433617e-01f, -2.49810852e-02f, -9.58270803e-02f, 1.64228398e-02f, -2.06180722e-01f,
  -1.50337800e-01f, 2.78037563e-02f, -7.88344592e-02f, -1.38198361e-01f, -1.41986132e-01f, -3.07073861e-01f, -2.45206773e-01f, -6.45093620e-02f, 2.45918170e-01f, -1.13857098e-01f,
  2.89115193e-03f, -4.59875204e-02f, 1.56098098e-01f, -1.07688054e-01f, 1.37947142e-01f, -1.07725672e-01f, -5.02699427e-02f, -1.61510274e-01f, 2.04108432e-01f, -1.25303507e-01f,
  -5.50901343e-04f, -1.68370325e-02f, -1.78033859e-01f, -2.14562505e-01f, -1.15362197e-01f, -4.53779474e-02f, -3.04031253e-01f, 2.26334333e-02f, -3.52817684e-01f, 2.27171425e-02f,
  -4.05321568e-02f, 9.05434191e-02f, -8.46421942e-02f, -9.08091385e-03f, -5.91686033e-02f, -9.62722003e-02f, -1.36570394e-01f, -1.40646771e-01f, -2.78992295e-01f, -3.27258080e-01f,
  -1.93175778e-01f, 1.31268809e-02f, -7.92102292e-02f, -8.60077068e-02f, 2.70847343e-02f, -1.28136307e-01f, -2.62361199e-01f, 1.98356420e-01f, 1.36525452e-01f, -1.46074757e-01f,
  2.71485783e-02f, 1.32875845e-01f, -1.84810579e-01f, 1.80488870e-01f, 2.91368395e-01f, -3.39077204e-01f, -3.68849821e-02f, -1.24136634e-01f, -3.49243060e-02f, 8.54919851e-02f,
  1.62695885e-01f, -1.85534671e-01f, 4.83884998e-02f, 2.86932945e-01f, -8.95338431e-02f, -3.13882858e-01f, -2.64044441e-02f, -1.43266388e-03f, -2.63135552e-01f, 1.84278768e-02f,
  6.66691139e-02f, -2.14454457e-01f, -1.76631957e-01f, 1.72692820e-01f, -9.86890309e-03f, 2.34073490e-01f, -2.55387813e-01f, 2.12472647e-01f, 1.56860828e-01f, 3.28694135e-02f,
  -8.26058444e-03f, -1.56223085e-02f, -1.59038231e-01f, -6.12096265e-02f, -4.53597546e-01f, 2.68393815e-01f, 1.15861714e-01f, 9.82848182e-02f, 1.47197112e-01f, -9.86019000e-02f,
  2.20172256e-01f, -2.36782685e-01f, 2.40665097e-02f, -5.88765182e-02f, -2.33677447e-01f, 2.04032332e-01f, 1.92010705e-03f, -2.22843632e-01f, 4.98598143e-02f, -2.90879030e-02f,
  2.56762236e-01f, -9.08014365e-04f, 6.89867958e-02f, -1.25390943e-02f, -2.60525823e-01f, -8.19394365e-02f, 4.33619209e-02f, -1.53998751e-02f, 2.01675266e-01f, -2.65888810e-01f,
  -9.09124240e-02f, 2.62202710e-01f, 1.49044216e-01f, -7.49898245e-05f, -2.40639895e-01f, 8.56624171e-02f, -4.05083954e-01f, -2.08626255e-01f, 2.20198911e-02f, 9.42002162e-02f,
  -2.56825477e-01f, -3.67881283e-02f, 6.59103394e-02f, 9.81754884e-02f, 2.43154660e-01f, 5.28656766e-02f, -1.95729405e-01f, -2.64238656e-01f, 1.51235268e-01f, -1.37225270e-01f,
  1.71244889e-01f, 3.03590506e-01f, -1.21334568e-01f, -3.12807590e-01f, 1.28133342e-01f, 2.09935173e-01f, -3.91220860e-02f, -1.40833214e-01f, 2.18926698e-01f, 1.80030346e-01f,
  6.36219396e-04f, 4.64136451e-02f, -1.50968045e-01f, 2.60056466e-01f, 8.16112980e-02f, -1.99572250e-01f, 2.56305672e-02f, -3.31423394e-02f, -1.35466337e-01f, -1.44894538e-03f,
  -2.35014204e-02f, -7.45147169e-02f, 5.21291234e-03f, -2.70067640e-02f, -2.05825865e-01f, -1.80217847e-01f, -4.82723713e-01f, -1.26256734e-01f, -1.46019831e-01f, -2.81554520e-01f,
  4.48308960e-02f, 3.77788916e-02f, -8.37990865e-02f, -1.57045767e-01f, -1.17880695e-01f, -1.12030260e-01f, -1.61077023e-01f, 7.84176216e-02f, 1.36461362e-01f, 1.04181215e-01f,
  -1.33286193e-01f, -1.55696562e-02f, -3.69884461e-01f, -4.19384837e-02f, -1.91400811e-01f, 1.89306661e-01f, -9.69952941e-02f, -2.58761078e-01f, 9.13879871e-02f, -5.48339561e-02f,
  -5.34892492e-02f, 1.59707591e-01f, 6.52116397e-03f, -1.14931285e-01f, 6.79645464e-02f, -2.21280716e-02f, -6.15534410e-02f, 2.54895121e-01f, -1.59117103e-01f, -4.05440964e-02f,
  6.09160867e-04f, 3.23138624e-01f, -2.61633754e-01f, 1.08176500e-01f, -3.64237517e-01f, -1.99302107e-01f, 1.05880804e-01f, 6.57028854e-02f, -4.14689034e-02f, -2.11067855e-01f,
  1.26176611e-01f, 2.12482765e-01f, 7.07977116e-02f, -1.13239668e-01f, -1.43466726e-01f, 8.51679742e-02f, -6.45638108e-02f, 9.10294652e-02f, -9.41231325e-02f, 2.32101783e-01f,
  -2.21588463e-02f, -1.55705470e-03f, 1.90737978e-01f, -1.18954130e-01f, -2.19766825e-01f, -6.02819510e-02f, -1.34181380e-01f, -7.47149587e-02f, -2.74840325e-01f, 2.62608021e-01f,
  2.10787635e-02f, 3.86911221e-02f, -1.71725586e-01f, -3.46377715e-02f, 7.32987225e-02f, -1.74265519e-01f, 1.39921889e-01f, -2.98201561e-01f, 4.16541323e-02f, -1.59575507e-01f,
  1.67837456e-01f, -3.52736503e-01f, -1.00551791e-01f, 7.79115781e-02f, -9.04082730e-02f, 2.30097696e-01f, 3.24025452e-01f, 4.86964136e-02f, 3.69107425e-02f, 3.46149653e-02f,
  2.44802367e-02f, 7.57922232e-02f, -6.99416101e-02f, 2.11415976e-01f, 1.62909441e-02f, 1.16350703e-01f, 1.06689535e-01f, -1.77586630e-01f, -1.54553920e-01f, -2.02857152e-01f,
  1.78928543e-02f, -3.24677415e-02f, 3.45712513e-01f, -5.71179651e-02f, -1.52019799e-01f, 1.90807477e-01f, -1.61479432e-02f, -1.70332760e-01f, 2.99264789e-01f, -1.99306440e-02f,
  9.05661210e-02f, -1.67999223e-01f, 1.49597093e-01f, -9.16628316e-02f, -1.56028539e-01f, 2.13440731e-01f, -1.76082864e-01f, -4.17850763e-02f, -4.96945567e-02f, 1.08908966e-01f,
  -6.46050461e-03f, -2.46235028e-01f, 3.19220930e-01f, -1.23561993e-01f, 8.53075981e-02f, 2.73405343e-01f, -1.59083754e-01f, 1.31502729e-02f, 1.35207132e-01f, 2.10697092e-02f,
  1.77094877e-01f, -8.50697327e-03f, -1.96859449e-01f, -8.10827315e-02f, 2.33877748e-01f, 3.65563482e-01f, 1.87720269e-01f, 3.77249233e-02f, 9.23306122e-02f, -8.62846449e-02f,
  -6.17299639e-02f, 1.26578271e-01f, 1.79998487e-01f, 8.49568546e-02f, -1.98473126e-01f, 2.75997370e-01f, 1.77660152e-01f, 1.39889181e-01f, -4.59001809e-02f, 3.82274121e-01f,
  7.19304383e-02f, 1.31736070e-01f, -2.17307732e-02f, -8.72469470e-02f, -2.92263150e-01f, -3.36857259e-01f, -5.42405963e-01f, -1.31116316e-01f, -2.20725685e-01f, 1.37710169e-01f,
  1.09762959e-01f, 6.68803975e-02f, -2.46708035e-01f, 3.84859852e-02f, -2.35517889e-01f, 1.24820374e-01f, -1.26961112e-01f, 7.75820240e-02f, 1.50192648e-01f, -2.06977129e-01f,
  -2.62597889e-01f, 2.41650835e-01f, 1.12135420e-02f, -1.86947003e-01f, 7.93140158e-02f, 1.26104672e-02f, 9.45953280e-02f, -1.53408330e-02f, 2.88997497e-02f, -7.12706968e-02f,
  2.20254928e-01f, -2.96573769e-02f, -1.27469540e-01f, -2.35347338e-02f, -4.91710342e-02f, 2.48255908e-01f, 2.24511608e-01f, 2.72415727e-01f, 1.78281307e-01f, -5.29499799e-02f,
  -1.68512031e-01f, 5.73620908e-02f, 2.45020837e-01f, -9.51443166e-02f, -1.32279447e-03f, -1.81802839e-01f, -1.15983486e-01f, 9.35757235e-02f, 1.07237309e-01f, 7.77665749e-02f,
  8.01076144e-02f, -6.68415353e-02f, -1.47658780e-01f, -4.88031022e-02f, 5.97120486e-02f, 4.66336608e-02f, 6.71560969e-03f, -4.10349621e-03f, -2.46860772e-01f, 2.56733716e-01f,
  1.32471681e-01f, 6.03047349e-02f, -2.18203291e-01f, 1.96241558e-01f, -3.48690510e-01f, 3.28779697e-01f, 4.05703746e-02f, 1.46453544e-01f, -6.13404438e-02f, 6.88085184e-02f,
  8.19345787e-02f, 7.64188990e-02f, 3.23780440e-02f, -7.02319741e-02f, -1.16275050e-01f, 1.67363346e-01f, 3.72789316e-02f, 1.62967473e-01f, -1.33594066e-01f, 1.26443014e-01f,
  -2.76256710e-01f, -1.65227950e-01f, 2.31953356e-02f, -6.89828303e-03f, -2.62588143e-01f, 4.38929051e-01f, -1.47665013e-02f, -1.47234306e-01f, 8.41270089e-02f, -6.91024512e-02f,
  -1.28113016e-01f, -9.80056003e-02f, 2.41728529e-01f, 1.12062268e-01f, 1.97623316e-02f, -1.86530396e-01f, -4.31136526e-02f, -1.28252044e-01f, -2.48310894e-01f, 1.70822978e-01f,
  -1.87312085e-02f, 5.88042960e-02f, 7.06240982e-02f, 1.81495830e-01f, 2.18476161e-01f, -1.53397501e-01f, -1.99899413e-02f, -1.22278212e-02f, -2.08467856e-01f, 1.56265453e-01f,
  9.08404440e-02f, 2.86680669e-01f, 7.04994798e-02f, 6.11439021e-03f, 5.49065648e-03f, -7.04532713e-02f, 6.99899718e-02f, 1.76302195e-01f, -4.95413616e-02f, -1.08573429e-01f,
  -1.68009251e-01f, -1.14400595e-01f, -3.57435904e-02f, 2.73047294e-02f, 7.59209320e-02f, -7.64406249e-02f, -3.60594094e-02f, 5.71932993e-04f, -1.46675989e-01f, 7.28453547e-02f,
  1.11024886e-01f, -7.17388913e-02f, 5.29971905e-02f, 1.05745897e-01f, 9.95064378e-02f, 1.43458977e-01f, 3.54726434e-01f, 1.30973626e-02f, -1.71451062e-01f, -4.97391410e-02f,
  2.71469831e-01f, 3.37920636e-01f, -1.92332923e-01f, -3.23446125e-01f, -2.00664103e-01f, -1.19984217e-01f, -1.25269210e-02f, 1.38284907e-01f, -2.16500729e-01f, -1.96289625e-02f,
  -2.23903418e-01f, -2.39066228e-01f, 5.58739230e-02f, -4.01073694e-02f, -8.70191902e-02f, -6.29479960e-02f, -1.24680601e-01f, 1.01213977e-01f, -5.28771617e-02f, -9.70532075e-02f,
  6.89401776e-02f, -9.36457813e-02f, 2.26172790e-01f, -1.02586187e-01f, 1.96748540e-01f, -1.36733696e-01f, 2.66411096e-01f, -3.38070840e-02f, -9.90293995e-02f, -3.63334529e-02f,
  2.49303311e-01f, 1.28300652e-01f, 1.00004114e-01f, 9.64670330e-02f, 1.78379729e-01f, -2.30552867e-01f, 1.04443774e-01f, -7.69531578e-02f, -2.00270846e-01f, 2.85497993e-01f,
  9.78154838e-02f, 1.41661435e-01f, 3.12277116e-02f, 1.98290378e-01f, 9.99492109e-02f, -1.32202610e-01f, -1.71887383e-01f, 3.48194629e-01f, -2.00457610e-02f, -1.10008858e-01f,
  -1.79670691e-01f, -1.30420282e-01f, -5.97396269e-02f, 2.78641909e-01f, -3.32655847e-01f, 2.08721280e-01f, 2.71636099e-01f, 1.89669535e-01f, 3.06170285e-01f, -2.16512144e-01f,
  -1.07587516e-01f, -3.12274635e-01f, -2.51203358e-01f, 2.86496639e-01f, -2.00898632e-01f, 1.04164809e-01f, 4.57254536e-02f, 5.23868166e-02f, -4.66175526e-02f, -2.62262702e-01f,
  -2.00035468e-01f, -6.89242128e-03f, -7.90031329e-02f, 4.55800086e-01f, -2.24176168e-01f, -7.74887130e-02f, -1.93352010e-02f, -2.03169405e-01f, -1.05909176e-01f, -8.51720721e-02f,
  1.37989074e-01f, 9.81214941e-02f, 1.01666689e-01f, 2.26377711e-01f, -1.18480220e-01f, 9.89491213e-03f, -1.48283899e-01f, 8.18031728e-02f, -4.76684004e-01f, -4.10803296e-02f,
  2.50449050e-02f, 1.30838335e-01f, -6.30873591e-02f, -1.53565273e-01f, -7.11041540e-02f, -2.76820302e-01f, -1.55130774e-01f, -7.45073184e-02f, -4.55184579e-02f, -2.58617252e-01f,
  -1.90707326e-01f, -9.89703462e-03f, 2.37768255e-02f, 4.03677253e-03f, -1.86699554e-01f, -8.23821202e-02f, -9.21338350e-02f, 1.38696387e-01f, -1.78649276e-01f, -1.63040832e-02f,
  -5.83595000e-02f, -2.73013934e-02f, 5.93783520e-02f, -1.21384233e-01f, 3.76706347e-02f, 2.16014050e-02f, -5.43112159e-02f, -1.93812340e-01f, 1.16718195e-01f, -1.03963586e-02f,
  1.65286258e-01f, -1.36695087e-01f, 5.64876907e-02f, 9.57597345e-02f, -1.33646190e-01f, 2.52001941e-01f, 2.40496114e-01f, 8.69025141e-02f, 4.56385702e-01f, -1.74306765e-01f,
  1.04971223e-01f, 9.32392403e-02f, -3.06412280e-01f, -1.35710865e-01f, 2.26219997e-01f, 3.14437598e-01f, -2.38569006e-01f, 2.16738936e-02f, -1.58789426e-01f, 7.95251131e-02f,
  -2.97771245e-01f, 3.54534417e-01f, 1.83311120e-01f, -2.03964040e-01f, -7.74227381e-02f, 9.02428329e-02f, 2.16202155e-01f, 2.06203401e-01f, -7.42551759e-02f, 1.87221006e-01f,
  -6.39278665e-02f, 2.88584590e-01f, -5.51762208e-02f, 5.18506430e-02f, -3.52975167e-02f, -4.38923277e-02f, 2.49875113e-01f, -1.89676344e-01f, 5.34843467e-02f, -1.66177139e-01f,
  -3.85650918e-02f, 6.76936060e-02f, -2.03641638e-01f, -6.10305183e-02f, 8.95169973e-02f, -1.47240654e-01f, 1.33041337e-01f, -3.40037160e-02f, -2.83537805e-01f, 3.11402101e-02f,
  5.52230403e-02f, -8.88104141e-02f, -1.50923301e-02f, -8.04920867e-02f, -2.27013513e-01f, -8.28740653e-03f, 1.46255977e-02f, -3.19270492e-01f, 2.98682582e-02f, 6.68241605e-02f,
  -2.02670589e-01f, -3.33386175e-02f, 1.89549029e-01f, -3.41804147e-01f, 3.85147899e-01f, -1.03703938e-01f, 8.33251514e-03f, -1.03117816e-01f, 7.19488785e-02f, 1.79275051e-01f,
  2.29156718e-01f, 5.63885942e-02f, 3.50750893e-01f, -1.45353526e-01f, -1.52577776e-02f, -1.83652312e-01f, -3.66129369e-01f, -8.05933848e-02f, 5.84184751e-02f, 2.20310576e-02f,
  -5.35282940e-02f, 1.42038807e-01f, 5.40930172e-03f, 2.99397439e-01f, -3.84943604e-01f, 1.32474899e-01f, 1.03950433e-01f, -2.73501854e-02f, -1.92637369e-01f, 4.17789370e-02f,
  -2.34071210e-01f, 7.45440871e-02f, 1.30699366e-01f, -1.68478325e-01f, 3.49956751e-02f, -4.53094952e-02f, -1.60209894e-01f, 1.85815886e-01f, -1.29620969e-01f, -7.59593397e-02f,
  2.46047392e-03f, 1.01715997e-01f, 1.23523846e-01f, 8.39476138e-02f, 2.26570871e-02f, -3.22451860e-01f, 5.62963597e-02f, 1.70895398e-01f, -5.29174544e-02f, -1.40944682e-02f,
  1.11281700e-01f, -1.08670771e-01f, 3.40028331e-02f, -1.37802035e-01f, -5.17838262e-03f, -2.10746914e-01f, -1.51473224e-01f, 6.38332739e-02f, -2.77624518e-01f, -5.32883368e-02f,
  5.92552535e-02f, 1.93718255e-01f, -5.99688552e-02f, -9.24938992e-02f, -1.05238542e-01f, -3.31653863e-01f, -2.39952222e-01f, -2.04979450e-01f, 1.25351220e-01f, 2.71672825e-03f,
  -8.72749016e-02f, 1.44773021e-01f, 7.11370260e-02f, -1.40712112e-01f, -1.48514777e-01f, -2.99148589e-01f, -2.73665208e-02f, 8.77296180e-02f, 2.23096550e-01f, 2.21158206e-01f,
  1.84021726e-01f, -1.08303130e-02f, -8.33282992e-02f, 3.34582418e-01f, 1.14472985e-01f, -9.56200622e-03f, -3.08739096e-01f, 3.24406624e-02f, -1.01319723e-01f, -9.18931589e-02f,
  1.60752207e-01f, -5.39244600e-02f, -2.92215466e-01f, 1.86575562e-01f, -6.37136772e-02f, 1.72964617e-04f, 2.60294616e-01f, -1.26758926e-02f, -6.78712800e-02f, 1.22814678e-01f,
  3.81982811e-02f, 7.25166872e-02f, -1.27348658e-02f, 8.77314061e-02f, -1.75853312e-01f, -3.51509126e-03f, -9.86568108e-02f, 1.12257279e-01f, -7.79009843e-03f, 4.68211547e-02f,
  6.54861853e-02f, -3.72573026e-02f, 4.55300277e-03f, 9.55379605e-02f, 9.69860479e-02f, -2.33768206e-02f, 4.27107438e-02f, -5.84908947e-02f, 6.62768930e-02f, 3.63567732e-02f,
  4.72149439e-02f, -2.56378710e-01f, 1.64631501e-01f, -3.13752182e-02f, -9.57004726e-02f, -5.30314259e-02f, -2.27611572e-01f, 1.18820831e-01f, 2.77305562e-02f, 1.36480168e-01f,
  -1.80833250e-01f, 2.60435134e-01f, -1.01404540e-01f, 8.14749897e-02f, 1.72870860e-01f, 7.57022351e-02f, 1.74257115e-01f, -1.44290537e-01f, -1.13092899e-01f, 6.90124044e-03f,
  -2.87316501e-01f, 1.00630306e-01f, -7.39470348e-02f, 1.14057980e-01f, 1.13269791e-01f, -1.01350740e-01f, 9.44941044e-02f, 2.45502397e-01f, 3.24051417e-02f, 1.79506484e-02f,
  1.78224906e-01f, -7.81678483e-02f, 8.55926052e-02f, -5.42595126e-02f, -1.81385111e-02f, 1.04559816e-01f, 1.95928410e-01f, -1.29905790e-01f, 1.50987133e-01f, -6.00335300e-02f,
  -8.44078958e-02f, 2.18899459e-01f, -1.55642807e-01f, -6.99357539e-02f, -3.67703795e-01f, 1.19256288e-01f, -4.60107513e-02f, -3.43328416e-01f, -1.05504848e-01f, 2.58915033e-02f,
  1.99161723e-01f, 6.91624880e-02f, 1.41535342e-01f, 4.09751013e-02f, 2.11401105e-01f, -8.22157264e-02f, 1.09156400e-01f, 7.84058198e-02f, -4.18663323e-02f, 3.04531697e-02f,
  8.50982666e-02f, 4.12802398e-02f, 1.95521768e-02f, 1.69712946e-01f, 1.93434149e-01f, -1.40713587e-01f, 8.48959573e-03f, 2.56716639e-01f, 6.76564500e-02f, -1.74157858e-01f,
  -1.01675667e-01f, -6.92205206e-02f, -8.34838971e-02f, 1.14064038e-01f, -2.21598327e-01f, -1.56855695e-02f, 1.59994438e-01f, 2.25309744e-01f, 1.25385121e-01f, -2.03251392e-01f,
  2.05455255e-02f, -5.73035002e-01f, -4.08631206e-01f, 9.26151127e-02f, -1.81973338e-01f, 2.38430768e-01f, 5.75535856e-02f, 3.21843117e-01f, 1.50433227e-01f, -1.40953317e-01f,
  -3.33303630e-01f, -2.43647650e-01f, 6.28236011e-02f, 2.79347807e-01f, 9.96421129e-02f, 1.67911630e-02f, 8.09555277e-02f, -2.14308962e-01f, -2.06223026e-01f, 7.40420893e-02f,
  2.08433121e-01f, -1.34844109e-01f, 6.74359873e-02f, -1.22356310e-01f, -2.79284753e-02f, -1.21568963e-02f, -1.77428704e-02f, 1.66261181e-01f, -2.17726573e-01f, 4.87114564e-02f,
  6.79018870e-02f, -2.35370010e-01f, -6.56399429e-02f, 9.41739976e-02f, 2.33968496e-02f, -9.89396032e-03f, 1.50479957e-01f, 4.33588587e-02f, 2.95604199e-01f, 2.97651310e-02f,
  -9.39024836e-02f, 1.64286047e-02f, -1.51697814e-01f, -4.74106595e-02f, -6.98013082e-02f, -5.03424220e-02f, -4.48578745e-02f, 5.34357596e-03f, -9.24424231e-02f, -1.35706291e-01f,
  -4.33650473e-03f, 9.74250361e-02f, 1.29370719e-01f, 2.11726069e-01f, 2.51157165e-01f, 1.30052537e-01f, 1.74836349e-02f, 3.86141427e-02f, 7.48293623e-02f, 1.99464381e-01f,
  -2.97093131e-02f, -1.78059246e-02f, 1.72935620e-01f, -3.04110795e-01f, 3.63187566e-02f, -1.74146771e-01f, -2.00792491e-01f, -1.75287023e-01f, -1.22490324e-01f, 2.37075716e-01f,
  -5.08743264e-02f, -2.22778335e-01f, 2.89804991e-02f, 1.86836667e-04f, 1.19853847e-01f, 4.76020053e-02f, -3.36090952e-01f, -9.04954970e-03f, 2.94229686e-01f, -5.93680292e-02f,
  3.78791615e-02f, -1.13631949e-01f, -1.64729640e-01f, 5.29704243e-02f, 2.85308331e-01f, -1.29957333e-01f, 8.19125969e-04f, 1.83368307e-02f, -1.57010213e-01f, 3.37277316e-02f,
  -1.49724826e-01f, -6.97418153e-02f, -1.37582347e-01f, 3.25306617e-02f, 1.58866227e-01f, -1.42043918e-01f, 1.89062521e-01f, -2.91460544e-01f, -1.18266858e-01f, 5.57105802e-02f,
  -1.03123248e-01f, -4.24016174e-03f, -2.69771695e-01f, -1.07896430e-02f, -1.45823136e-01f, -2.09042996e-01f, 1.10198714e-01f, -1.18630439e-01f, 6.33009449e-02f, 1.82696700e-01f,
  -4.98250476e-04f, -2.55484760e-01f, -5.91008589e-02f, 1.12064622e-01f, -1.74062759e-01f, -1.24692671e-01f, 2.33922422e-01f, 2.26353146e-02f, -1.01435527e-01f, -3.38159114e-01f,
  -2.68578917e-01f, -1.40044652e-02f, -1.63227841e-02f, -7.16329366e-02f, 5.89806139e-02f, -4.19914611e-02f, 1.25004157e-01f, 2.27187097e-01f, -1.64030015e-01f, 3.74482423e-01f,
  -2.77220085e-02f, -6.30023554e-02f, 3.48264724e-01f, -1.67477593e-01f, -1.21572502e-01f, 2.98293710e-01f, -1.59051016e-01f, 4.34655696e-02f, 2.29767546e-01f, 1.22302197e-01f,
  5.78589477e-02f, 5.50625846e-02f, -2.73057342e-01f, -9.24491212e-02f, -4.22774702e-02f, 2.30777040e-01f, 7.80321583e-02f, -1.84456259e-01f, -1.31391034e-01f, 9.12059322e-02f,
  6.72062188e-02f, -9.74771101e-04f, 6.42062053e-02f, -2.87543207e-01f, -2.50940993e-02f, 1.24484643e-01f, -2.96886355e-01f, 1.62623882e-01f, -2.13034943e-01f, 1.03092611e-01f,
  3.42872441e-02f, 2.58813500e-01f, 1.42957285e-01f, 6.78033456e-02f, -8.86421204e-02f, -5.29167242e-02f, 3.54129374e-01f, 5.91682307e-02f, 6.54116720e-02f, -1.76921654e-02f,
  -1.13492399e-01f, 6.51343260e-03f, 3.18830237e-02f, -6.01893626e-02f, 7.94550404e-02f, -3.31520401e-02f, -1.95328481e-02f, -1.11472353e-01f, -8.08410943e-02f, -1.00837678e-01f,
  -1.02984414e-01f, 6.98428005e-02f, -2.24905740e-02f, 1.13189131e-01f, 9.74128321e-02f, -8.28181207e-03f, -2.09722981e-01f, 9.27941203e-02f, 1.70288548e-01f, -1.82356834e-02f,
  2.15396047e-01f, -6.49672523e-02f, 5.60279191e-02f, -5.47985375e-01f, -2.62884825e-01f, -2.30833411e-01f, -2.61205107e-01f, 3.15096349e-01f, -5.12091536e-03f, 2.56951332e-01f,
  3.64443570e-01f, -1.39161065e-01f, -4.06319872e-02f, 2.75385708e-01f, -9.57725570e-03f, -8.61823559e-02f, -1.07897893e-01f, -7.61342868e-02f, 8.19729716e-02f, -1.10621661e-01f,
  -1.70905426e-01f, -4.47926931e-02f, -1.82954386e-01f, -1.32807838e-02f, 4.17319797e-02f, -4.93018515e-02f, 4.09065560e-02f, 3.60537827e-01f, -1.62104368e-01f, 1.75661430e-01f,
  -2.44611859e-01f, -1.95989221e-01f, 5.11187464e-02f, 5.80958389e-02f, 1.13862403e-01f, -2.30506554e-01f, 1.36763364e-01f, 2.31296625e-02f, -5.74398749e-02f, -5.32267280e-02f,
  -1.82007611e-01f, 2.77373582e-01f, -3.65368314e-02f, -1.23323172e-01f, -1.59373172e-02f, 1.38257280e-01f, 2.13053435e-01f, 2.03811154e-01f, -2.41345331e-01f, 3.40198688e-02f,
  1.61970593e-02f, -6.03818260e-02f, -7.12159872e-02f, -3.40807438e-02f, 1.10139482e-01f, -1.91751700e-02f, -1.54393986e-01f, 5.67355491e-02f, -2.83724457e-01f, 1.67659655e-01f,
  6.84387190e-03f, 1.01756915e-01f, 8.67617130e-03f, 4.44581024e-02f, 4.34213392e-02f, 1.29957944e-01f, 2.81360447e-01f, -1.27698168e-01f, -1.50115877e-01f, -9.21891630e-02f,
  3.56808871e-01f, 3.89862299e-01f, -1.67058557e-01f, 3.72100510e-02f, -1.39948249e-01f, -4.55035537e-01f, -3.70663102e-03f, 2.95505226e-01f, -3.79222147e-02f, -1.22629451e-02f,
  -2.41076916e-01f, -1.65471405e-01f, 1.24176323e-01f, 1.33102328e-01f, 4.80635278e-02f, -2.20440224e-01f, -1.92930594e-01f, 3.84461641e-01f, -5.81558011e-02f, -4.73299697e-02f,
  -1.50517195e-01f, 2.51206845e-01f, 1.29841283e-01f, 9.48255882e-02f, 4.31212895e-02f, -3.36103402e-02f, 1.22558407e-01f, 1.64810181e-01f, -3.00727487e-01f, 1.28969193e-01f,
  4.27655838e-02f, 5.51234093e-03f, 3.67179955e-03f, -7.87403509e-02f, 1.79429322e-01f, -1.74169794e-01f, 1.79410905e-01f, 1.28863320e-01f, 3.28715406e-02f, 3.21353450e-02f,
  1.62511855e-01f, 1.79731712e-01f, -2.23565340e-01f, 1.01765431e-01f, -8.25958923e-02f, 6.65840507e-02f, 2.19934545e-02f, 1.08941190e-01f, -9.03084502e-03f, -2.06358105e-01f,
  -1.17168896e-01f, -2.76682347e-01f, 1.13627195e-01f, 2.06843525e-01f, -1.51745170e-01f, 9.18838531e-02f, 8.17804858e-02f, 8.45640600e-02f, 5.94934151e-02f, 5.57278208e-02f,
  8.99820123e-04f, -3.67965460e-01f, 6.11390769e-02f, 2.98652679e-01f, -1.76202372e-01f, 3.62797864e-02f, -1.93148069e-02f, 4.01762068e-01f, -2.51617104e-01f, 1.26369838e-02f,
  1.78910128e-03f, -4.00217995e-02f, 2.18098655e-01f, 2.74626076e-01f, -2.55350411e-01f, -5.32578863e-03f, 5.39289750e-02f, -5.67896515e-02f, -1.10344879e-01f, -7.95428902e-02f,
  1.28086835e-01f, 4.26668907e-03f, 3.79791975e-01f, -5.56192324e-02f, -1.20100446e-01f, 2.11801723e-01f, -1.44249126e-01f, 2.41492987e-01f, -2.48792946e-01f, -4.47633602e-02f,
  -1.17838262e-02f, 4.46042456e-02f, 2.89672494e-01f, -6.46671727e-02f, -6.66665733e-02f, 1.68113783e-01f, -1.40541360e-01f, 2.41768911e-01f, -6.62079304e-02f, 1.03892229e-01f,
  -1.94282502e-01f, -1.27911299e-01f, 1.86823860e-01f, 1.50095955e-01f, 3.03829521e-01f, -1.10121958e-01f, 2.86653936e-02f, -1.28762037e-01f, 2.62751460e-01f, 2.36432534e-03f,
  1.55479982e-01f, -4.24768001e-01f, -1.75845504e-01f, 7.24603087e-02f, 2.23979130e-02f, -1.07536174e-01f, 1.20014615e-01f, 2.93500852e-02f, -1.54029071e-01f, 4.51237848e-03f,
  -2.04225540e-01f, 1.26952618e-01f, -2.82037199e-01f, 2.36885145e-01f, 2.81789213e-01f, 5.54764010e-02f, 1.22339427e-01f, -2.01053038e-01f, -2.43024632e-01f, -1.39779568e-01f,
  -6.34575263e-02f, -4.41700555e-02f, 4.46725339e-01f, -7.41374912e-04f, 5.77698238e-02f, 2.38292918e-01f, 4.18395221e-01f, -2.65051067e-01f, -9.79604572e-02f, -1.01140074e-01f,
  2.47228473e-01f, -1.45381764e-01f, 4.58136909e-02f, 9.35982168e-02f, -2.33887851e-01f, -9.52122808e-02f, 5.55155016e-02f, -1.35761961e-01f, 6.93881512e-02f, 4.87926602e-02f,
  2.28236258e-01f, -3.20075750e-02f, 1.52738551e-02f, -1.20786428e-01f, -6.80056810e-02f, 1.73790716e-02f, 1.07521236e-01f, -7.30949119e-02f, 1.91544872e-02f, -3.65840346e-02f,
  4.05002534e-02f, -2.24090859e-01f, 1.95267543e-01f, 1.57292709e-01f, 3.39646935e-02f, -1.55140072e-01f, 1.99365795e-01f, -4.66466621e-02f, -1.66058969e-02f, 1.55028567e-01f,
  2.52522808e-02f, -7.82262012e-02f, -1.29777566e-01f, 6.33361787e-02f, 7.85592292e-03f, -2.27086451e-02f, -2.50502490e-02f, 1.08484372e-01f, 5.23868464e-02f, -1.22440539e-01f,
  -2.57040262e-01f, 5.05530126e-02f, -7.42275044e-02f, -3.04764718e-01f, 1.19523533e-01f, 1.94973331e-02f, 8.65170956e-02f, 2.40561903e-01f, 2.21334472e-01f, -1.19465142e-02f,
  2.19413042e-02f, 1.36084750e-01f, 1.99419811e-01f, 3.12227607e-01f, -6.39058370e-03f, -7.58305043e-02f, -1.51127726e-01f, -6.43524975e-02f, 1.10445857e-01f, 2.25460529e-01f,
  6.41170815e-02f, -2.22349375e-01f, -4.04866755e-01f, -1.05872750e-01f, -7.63242841e-02f, -8.39000642e-02f, 1.02291092e-01f, -8.47655386e-02f, -2.11148366e-01f, 2.46739417e-01f,
  -6.79380223e-02f, -6.70161322e-02f, 3.37308019e-01f, 5.81688248e-02f, 1.60983223e-02f, 1.17289647e-02f, 5.13258055e-02f, -2.32803583e-01f, 1.20438673e-02f, 1.39597893e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -7.06268754e-03f, -1.02070905e-01f, 3.41242999e-01f, 6.70353323e-02f, 2.20884621e-01f, 1.75473049e-01f, 1.13839015e-01f, 2.84549594e-01f, 1.81130663e-01f, 8.93903151e-02f,
  1.83103308e-01f, -4.25558798e-02f, 1.73815548e-01f, 3.22463751e-01f, 4.27656658e-02f, -1.77487880e-01f, 9.22088698e-02f, -1.25481695e-01f, 1.87803254e-01f, -6.68529198e-02f,
  3.45519871e-01f, 2.04159855e-03f, -1.75556958e-01f, -1.79639295e-01f, -8.69513601e-02f, 3.01638305e-01f, -1.16910063e-01f, -3.44064951e-01f, 5.78969717e-02f, -1.06381416e-01f,
  1.47194043e-01f, -1.93874717e-01f, 2.02340692e-01f, -2.40889102e-01f, -3.87208968e-01f, -5.68512245e-04f, 1.23458900e-01f, 9.57640782e-02f, -1.86121389e-01f, 1.77301705e-01f,
  -3.07725310e-01f, -2.21782535e-01f, 1.47241816e-01f, 4.48636949e-01f, 3.76275688e-01f, 2.69538373e-01f, 7.85389841e-02f, -2.60528296e-01f, 4.09487039e-01f, 4.27104145e-01f,
  9.65907201e-02f, 5.46934247e-01f, 3.24897408e-01f, 9.81427059e-02f, 2.97216140e-02f, -3.22423637e-01f, -2.52859056e-01f, 2.88767368e-01f, -4.00990605e-01f, 2.00421736e-01f,
  -2.49458179e-01f, 5.08593738e-01f, -3.19775254e-01f, -1.07381918e-01f, 1.30676910e-01f, 3.56412172e-01f, 1.69520881e-02f, -1.97117403e-01f, 2.87067056e-01f, 2.25410059e-01f,
  4.09141064e-01f, -6.37072548e-02f, 3.63725007e-01f, 2.40345448e-01f, 1.23773240e-01f, 1.87975138e-01f, 8.03115889e-02f, 5.56918159e-02f, -1.87674552e-01f, -2.53999066e-02f,
  2.36984298e-01f, 1.84739545e-01f, -7.42170960e-02f, 4.18459065e-02f, -2.12052330e-01f, -4.27439623e-02f, 4.25071418e-02f, 2.19521165e-01f, 1.49405837e-01f, -1.97336420e-01f,
  -9.63315368e-02f, -3.05137396e-01f, 1.56023115e-01f, -1.96797714e-01f, 2.00128853e-01f, 2.89896071e-01f, 1.90699428e-01f, -3.43466103e-01f, 3.16203684e-01f, 4.06728923e-01f,
  3.69774140e-02f, 2.72543252e-01f, 1.28507718e-01f, -1.15901470e-01f, 9.56546888e-02f, 2.94212669e-01f, -2.05456972e-01f, -2.30080321e-01f, 2.72668183e-01f, -1.11383766e-01f,
  -1.02497108e-01f, 2.22194985e-01f, -5.68062067e-01f, -2.60673821e-01f, 2.34752700e-01f, 3.41281623e-01f, -3.28258991e-01f, 8.06097314e-02f, 4.24891785e-02f, 3.43428105e-02f,
  3.26801360e-01f, 2.49336287e-01f, 2.80925274e-01f, 2.95832008e-01f, -2.81212419e-01f, -7.44967163e-02f, -1.99761435e-01f, 5.55490749e-03f, 2.43267030e-01f, 5.20420492e-01f,
  1.62690327e-01f, -1.09882737e-02f, 2.50370800e-01f, 1.51187822e-01f, 5.38244307e-01f, -2.05728740e-01f, 2.98932847e-03f, 1.12405263e-01f, -2.85283923e-02f, -1.62203312e-01f,
  7.80245587e-02f, 2.67722398e-01f, 2.74244666e-01f, -1.72727659e-01f, -2.21545264e-01f, -2.23024234e-01f, -8.52046162e-03f, 1.96806729e-01f, 2.93961823e-01f, 2.49461919e-01f,
  2.63108552e-01f, 1.70472085e-01f, 1.07063435e-01f, -1.99735731e-01f, -3.16649258e-01f, -5.72180413e-02f, 4.42780524e-01f, 3.40215415e-02f, 3.45760047e-01f, -1.71571881e-01f,
  -6.66568875e-02f, -5.94633341e-01f, -4.37985182e-01f, -2.37610220e-04f, -1.93177566e-01f, 5.98987758e-01f, 1.88339621e-01f, 2.41153419e-01f, 3.58940512e-01f, -2.34767720e-01f,
  -2.32968643e-01f, -4.15130705e-02f, -1.98236972e-01f, 9.87135693e-02f, -2.10052609e-01f, -1.42923761e-02f, -7.62534961e-02f, -2.36175835e-01f, -2.14281157e-01f, 1.49983987e-01f,
  2.47908588e-02f, 1.17958538e-01f, 1.93793610e-01f, 1.41132325e-01f, 4.74294052e-02f, 4.60190505e-01f, -1.56345323e-01f, 1.76359251e-01f, -5.40914297e-01f, -7.96144009e-02f,
  2.26692587e-01f, 2.23234326e-01f, -6.64677024e-02f, -3.29434574e-01f, 3.34502012e-01f, 2.15300947e-01f, 9.99283344e-02f, 6.30453303e-02f, -2.11643681e-01f, 1.53128535e-01f,
  2.09274739e-01f, 2.65991706e-02f, 1.66497529e-01f, 1.03752151e-01f, 1.32569849e-01f, -1.81195438e-02f, -2.29853898e-01f, 2.44599044e-01f, 1.21157430e-01f, 4.70377386e-01f,
  2.80625790e-01f, 1.16023615e-01f, 2.77076006e-01f, 2.64955074e-01f, 4.56933454e-02f, 1.69095904e-01f, 2.57934570e-01f, 1.31681159e-01f, 3.47303748e-01f, 2.92073674e-02f,
  -7.26013184e-02f, 2.23794617e-02f, -5.61293244e-01f, 4.25521821e-01f, -1.81514129e-01f, 3.29466939e-01f, 6.58993304e-01f, 1.22632548e-01f, 2.30187878e-01f, -4.02536690e-01f,
  -1.92211717e-01f, 9.49412584e-02f, -3.72844875e-01f, -3.04122955e-01f, 7.56197656e-03f, -4.07794446e-01f, 1.23526612e-02f, -1.29918829e-01f, -4.36794497e-02f, 4.49240267e-01f,
  4.94450741e-02f, 4.03448552e-01f, 2.88690120e-01f, 3.03606063e-01f, 5.94929494e-02f, -2.36864626e-01f, -1.22238211e-01f, 5.26598878e-02f, -2.41136830e-02f, -2.65042186e-01f,
  2.55458921e-01f, 5.39435983e-01f, 6.41212583e-01f, 2.25137308e-01f, 4.38372016e-01f, -2.96085238e-01f, 2.78653622e-01f, -4.28679287e-02f, 2.07524553e-01f, 1.53145567e-02f,
  1.22888759e-01f, 1.97779804e-01f, 2.31824070e-01f, 6.58507869e-02f, 4.09980059e-01f, 9.82981771e-02f, 2.56213874e-01f, 3.14699560e-02f, 8.56818631e-02f, 2.97570944e-01f,
  7.71302804e-02f, 8.15961361e-02f, 1.67866871e-01f, 2.07291931e-01f, 1.37748361e-01f, 2.68066883e-01f, 3.31630670e-02f, -6.17346764e-02f, -6.82086274e-02f, 2.43499652e-01f,
  2.00663000e-01f, -5.19406870e-02f, 3.29587102e-01f, -4.71716046e-01f, 4.77903754e-01f, -3.66337061e-01f, 1.54478103e-01f, 4.15594205e-02f, 2.04788476e-01f, -1.91609427e-01f,
  2.68104617e-02f, 5.57918549e-01f, 1.55919105e-01f, 1.65319681e-01f, 5.30785844e-02f, -1.76729500e-01f, -4.17099357e-01f, -9.98062491e-02f, -1.21193707e-01f, -1.85033798e-01f,
  1.97016448e-01f, 9.49135274e-02f, -2.51722693e-01f, 3.54811549e-01f, -3.11459363e-01f, 2.92184532e-01f, 8.50190371e-02f, 5.05224884e-01f, 3.32869701e-02f, 1.29858935e-02f,
  -1.18140467e-01f, 6.42234161e-02f, 2.98541039e-02f, 2.22624809e-01f, 1.54475525e-01f, 2.55837232e-01f, -4.53676492e-01f, 4.70809877e-01f, -1.52699172e-01f, -2.64608443e-01f,
  -1.38964370e-01f, -4.42477837e-02f, 1.34979799e-01f, -6.16040900e-02f, 7.04524666e-02f, -1.71837643e-01f, 1.91174924e-01f, -1.56884819e-01f, -9.34904143e-02f, 2.62157153e-02f,
  2.60612249e-01f, 3.84169146e-02f, 2.21225709e-01f, -3.54680538e-01f, -3.04199427e-01f, -1.15298189e-01f, -1.56065241e-01f, 1.67126790e-01f, -2.25995213e-01f, -1.48799434e-01f,
  1.00824870e-01f, 7.47674257e-02f, -2.31382877e-01f, -3.50131869e-01f, 2.12804452e-01f, -3.08929414e-01f, -6.69738889e-01f, 3.82883959e-02f, -1.28835011e-02f, 5.61931789e-01f,
  -1.27494276e-01f, 4.14166629e-01f, -3.60910892e-01f, 3.51553271e-03f, -1.19048417e-01f, -1.35722056e-01f, -1.84628531e-01f, -3.63979638e-01f, 1.65625855e-01f, 7.16365218e-01f,
  6.83488607e-01f, -1.75319150e-01f, -1.33252153e-02f, -1.52464643e-01f, 2.43785813e-01f, -1.82799757e-01f, -1.36547372e-01f, -1.91710860e-01f, 5.90934940e-02f, -4.89951760e-01f,
  5.78147583e-02f, -1.90787703e-01f, 4.81810987e-01f, -6.60471767e-02f, 2.21297547e-01f, 2.97699064e-01f, -2.74470635e-02f, 1.94013685e-01f, 7.33119547e-02f, 5.41933775e-01f,
  -2.73640484e-01f, 2.28077203e-01f, 9.89257470e-02f, 1.35175437e-01f, 3.19788605e-01f, -8.71232003e-02f, 4.39910106e-02f, -1.30912066e-01f, 1.39504019e-02f, 1.24610044e-01f,
  -1.04822449e-01f, 2.74701864e-01f, -2.82009337e-02f, -1.44907581e-02f, 3.05977255e-01f, -8.12900662e-02f, 1.31921783e-01f, 3.49490672e-01f, 1.36732787e-01f, 2.80020721e-02f,
  -2.46505871e-01f, 3.00806854e-02f, -2.34069332e-01f, -4.22672369e-02f, 2.73879677e-01f, -2.36851349e-02f, -1.20354332e-01f, -3.60462844e-01f, -1.63341388e-01f, 2.04078287e-01f,
  -9.68000516e-02f, -2.65554041e-01f, 2.30517551e-01f, 1.05312586e-01f, 2.11814567e-01f, 1.91427857e-01f, 2.09099516e-01f, 1.69489011e-01f, 9.77873132e-02f, -1.33264378e-01f,
  3.49370211e-01f, -9.88976061e-02f, 1.97533686e-02f, -7.03621060e-02f, -4.76501226e-01f, 2.30922550e-01f, 1.52021378e-01f, 1.05189003e-01f, -1.20487968e-02f, -6.27750605e-02f,
  -6.78701460e-01f, -2.53012300e-01f, 7.51401111e-02f, 1.78193703e-01f, 1.69848204e-01f, -2.20033243e-01f, -2.47731000e-01f, 4.08666760e-01f, 2.72518843e-01f, 1.66160330e-01f,
  3.08744699e-01f, 7.88689107e-02f, 1.14756100e-01f, 4.34929924e-03f, -2.03240722e-01f, 1.52392507e-01f, -1.40117913e-01f, 3.11800420e-01f, 1.97197080e-01f, 1.09507546e-01f,
  2.37581447e-01f, 4.33094017e-02f, 1.73650980e-01f, 2.55548626e-01f, 1.63911998e-01f, 3.69695991e-01f, 1.89532220e-01f, 5.83450384e-02f, 1.23819694e-01f, -7.06085712e-02f,
  3.85402322e-01f, 2.53301293e-01f, 2.67629176e-01f, -1.20524563e-01f, -5.91109321e-02f, -1.36030525e-01f, -1.85607940e-01f, -1.63205251e-01f, 3.33347112e-01f, 2.53726304e-01f,
  -2.08222970e-01f, 2.09001526e-01f, -3.15316230e-01f, 3.29542547e-01f, -3.06633592e-01f, 1.56668141e-01f, 2.41260707e-01f, 1.23872146e-01f, 1.34850115e-01f, -3.45379449e-02f,
  2.20300909e-02f, -1.41492799e-01f, -3.03401828e-01f, -1.82690263e-01f, 9.91103798e-02f, 4.60844308e-01f, -4.26044166e-01f, 7.17825517e-02f, -1.18274830e-01f, -2.69090444e-01f,
  3.17326605e-01f, -1.71113014e-03f, -4.23159629e-01f, 2.79436082e-01f, -2.12910756e-01f, -9.37260762e-02f, -1.43217435e-02f, 1.00446858e-01f, 2.49131117e-02f, -1.44097582e-01f,
  2.71244459e-02f, 3.24338645e-01f, 2.53127068e-01f, 1.37707740e-01f, -3.65933552e-02f, 3.87887023e-02f, 1.15284406e-01f, 1.43574312e-01f, -4.60264027e-01f, -7.84642715e-03f,
  5.66760778e-01f, -3.00608203e-03f, 1.08278997e-01f, 3.66721511e-01f, -1.57255143e-01f, 6.68567717e-02f, -2.80707050e-02f, 8.73739347e-02f, 8.68910179e-02f, -1.15874864e-01f,
  1.95990756e-01f, 1.64889842e-01f, 7.12406412e-02f, 1.80286035e-01f, -1.31255118e-02f, 9.68363881e-02f, -9.64436308e-02f, 2.76879191e-01f, -1.71860978e-01f, 1.21213965e-01f,
  3.41867775e-01f, 3.02465260e-02f, -2.41450161e-01f, -1.78976968e-01f, -1.48569971e-01f, 2.90145308e-01f, 3.72999281e-01f, -2.65539020e-01f, 1.41170016e-02f, -1.75820336e-01f,
  1.34792879e-01f, -4.77040708e-01f, -3.72871384e-02f, 4.21359800e-02f, 2.21319661e-01f, -1.79689527e-01f, 3.32002729e-01f, 1.01972811e-01f, -4.87850904e-01f, -1.90079138e-01f,
  5.47053874e-01f, 1.89771250e-01f, 1.83608249e-01f, 9.95752662e-02f, -1.00231618e-01f, 1.58392593e-01f, 3.60859692e-01f, -2.27330867e-02f, -2.30270531e-02f, 1.79315656e-01f,
  8.65854993e-02f, 2.26192474e-01f, 2.04327792e-01f, 2.85161436e-01f, 2.20783383e-01f, -2.04610094e-01f, 2.17669606e-01f, -2.66256630e-01f, 7.78921023e-02f, 3.75531107e-01f,
  -5.77371381e-02f, -3.94714400e-02f, 1.64052229e-02f, 8.67454186e-02f, -5.89521468e-01f, 8.85215029e-02f, 1.42389044e-01f, -5.94071448e-02f, 1.59172656e-03f, 1.04003780e-01f,
  -4.74914312e-02f, 6.79317936e-02f, -2.50111312e-01f, 5.06754637e-01f, -2.96846274e-02f, 5.03321514e-02f, 3.20734143e-01f, 3.70107323e-01f, 4.05098438e-01f, -2.33876687e-02f,
  2.78053463e-01f, 8.99606571e-02f, 1.72196358e-01f, 3.43527257e-01f, 2.21485943e-01f, -2.24745333e-01f, 1.19714893e-01f, 2.96203583e-01f, -3.03294897e-01f, 3.21079999e-01f,
  -7.80732706e-02f, 3.98678064e-01f, 7.24304542e-02f, 2.51478225e-01f, -6.92824543e-01f, -8.72445479e-02f, -3.34391117e-01f, 6.08628336e-03f, 4.23209727e-01f, 5.13321638e-01f,
  -1.54484704e-01f, -3.09954375e-01f, -2.42831320e-01f, 1.43272564e-01f, -8.68538208e-03f, -1.02778994e-01f, 1.79314613e-01f, -7.62552395e-02f, 2.43065149e-01f, 2.38146797e-01f,
  1.22336462e-01f, -2.64997691e-01f, 2.85301000e-01f, -3.62334549e-01f, 6.86409771e-01f, -5.09336311e-03f, 6.58407509e-02f, 3.14735919e-01f, 3.43631953e-01f, 2.51281083e-01f,
  1.50237635e-01f, -5.87834604e-02f, -4.92233522e-02f, 1.24172777e-01f, -1.92659825e-01f, 2.87660975e-02f, 5.24044000e-02f, 2.78048933e-01f, 2.13734552e-01f, 2.08299205e-01f,
  2.61574298e-01f, -1.33952633e-01f, 1.67811170e-01f, 2.50403762e-01f, -1.41887784e-01f, -1.68067832e-02f, -4.46805894e-01f, 1.32611813e-02f, -1.54153422e-01f, 6.70615658e-02f,
  2.97663003e-01f, 1.78107470e-01f, -4.98130098e-02f, 7.38302097e-02f, 5.11804760e-01f, 2.69578278e-01f, 1.94088116e-01f, -3.81275006e-02f, -3.61417323e-01f, -9.45315361e-02f,
  1.18360527e-01f, 4.59821820e-01f, 7.94542581e-02f, -2.06274316e-01f, -1.69446692e-01f, -2.98572313e-02f, -2.98207790e-01f, 2.33955950e-01f, -2.17954755e-01f, 1.70805216e-01f,
  -3.85919511e-02f, 1.56031266e-01f, -1.07123509e-01f, 2.51431465e-01f, -2.56152183e-01f, -6.97107911e-01f, -2.11543992e-01f, -3.62808198e-01f, 1.82458311e-01f, 1.24385603e-01f,
  4.48242635e-01f, 4.18383814e-03f, -6.71354681e-02f, 1.01720773e-01f, -1.57259032e-01f, -8.13643262e-02f, -2.28845671e-01f, -3.70383561e-01f, 2.31551647e-01f, -2.74893731e-01f,
  1.19410224e-01f, -5.37574328e-02f, 1.55659392e-01f, 1.70320556e-01f, -1.13901950e-01f, 2.06137404e-01f, 1.18699558e-01f, -7.64689967e-02f, 8.80789757e-02f, -4.25665498e-01f,
  1.57967404e-01f, 2.72620648e-01f, 1.21808782e-01f, 4.22569782e-01f, 3.62891585e-01f, 1.13119416e-01f, 1.74572751e-01f, 4.17396687e-02f, 1.92239583e-01f, -7.12840781e-02f,
  1.55510396e-01f, 4.82748449e-02f, 8.16850811e-02f, 8.71101841e-02f, 1.86186403e-01f, 3.19732994e-01f, -1.28092933e-02f, 1.26121357e-01f, -6.55625463e-02f, 1.63256928e-01f,
  1.91502288e-01f, 1.80803522e-01f, 8.74578357e-02f, 3.71394157e-01f, 1.97742313e-01f, 1.98756844e-01f, 4.25875038e-01f, -1.28878802e-01f, 1.09329484e-01f, -2.26673692e-01f,
  3.00505996e-01f, -2.36257806e-01f, 4.78730083e-01f, 3.05571824e-01f, 3.18413496e-01f, 1.79215923e-01f, 1.40029028e-01f, -1.03484593e-01f, 1.06947832e-01f, -1.57831058e-01f,
  3.41788620e-01f, -5.04139923e-02f, 2.86660403e-01f, -3.23881656e-01f, 1.44701883e-01f, 3.46777141e-02f, -2.51314133e-01f, -2.46371999e-01f, -1.93421319e-01f, -3.56770575e-01f,
  -2.45288968e-01f, 2.28783160e-01f, -4.44565535e-01f, 5.85060790e-02f, 1.53426668e-02f, 3.44218910e-01f, -1.30224034e-01f, -4.89349756e-03f, -3.57487172e-01f, 3.88626367e-01f,
  6.34649932e-01f, -4.48742695e-02f, 6.45851135e-01f, -1.80442691e-01f, 3.38107824e-01f, 9.96741503e-02f, 2.23262131e-01f, 1.99725673e-01f, 2.33973414e-01f, 5.09974420e-01f,
  -1.06718494e-02f, 3.57027382e-01f, 1.32958665e-01f, 2.79582858e-01f, 2.86901165e-02f, 1.00502618e-01f, 3.13509792e-01f, 1.92039728e-01f, 1.03946626e-02f, 2.85815895e-01f,
  1.69232085e-01f, 1.31253690e-01f, 3.79354984e-01f, 3.45901474e-02f, 2.08255708e-01f, 2.21520275e-01f, 1.73034981e-01f, 3.47625613e-02f, 2.33389974e-01f, 4.66972589e-01f,
  1.45338356e-01f, 2.73374826e-01f, 2.12023199e-01f, 1.32829487e-01f, -1.74894780e-01f, 2.89968312e-01f, -2.62241423e-01f, 1.54663786e-01f, -2.27466822e-01f, 2.38362566e-01f,
  2.54554171e-02f, 1.00086108e-01f, -3.53460878e-01f, 7.58806765e-02f, -5.74218392e-01f, 1.22078113e-01f, -1.63656101e-01f, 4.56920005e-02f, 5.37072480e-01f, -2.08467364e-01f,
  -1.55160889e-01f, -4.67944562e-01f, -1.31828591e-01f, -1.50190607e-01f, 2.30471268e-01f, 1.24923557e-01f, 1.92381088e-02f, -4.71333385e-01f, 5.01876883e-02f, 2.40485877e-01f,
  2.48776838e-01f, 1.46908566e-01f, 3.45051028e-02f, 2.83334907e-02f, 1.34320244e-01f, 5.02616316e-02f, 3.63567285e-02f, -3.54913026e-02f, 3.09568620e-03f, -2.78466791e-01f,
  4.71095234e-01f, 7.27350935e-02f, -2.25420758e-01f, 6.47594482e-02f, 1.13486327e-01f, 1.50894180e-01f, 1.31253213e-01f, 8.70237872e-02f, -2.80349970e-01f, 3.54069054e-01f,
  2.55330414e-01f, 3.73014152e-01f, 2.23013192e-01f, 2.15457946e-01f, 7.00528920e-02f, 8.81204233e-02f, -2.16793846e-02f, 3.16155851e-02f, 4.55920726e-01f, -4.64184135e-02f,
  1.30413145e-01f, -1.22953750e-01f, -2.31752336e-01f, 4.56893891e-02f, -2.45335415e-01f, 1.79952830e-01f, 4.56857868e-02f, 4.30180579e-01f, 3.14955175e-01f, -2.22461104e-01f,
  -1.31705515e-02f, -2.82799691e-01f, -1.73618138e-01f, 2.90697217e-01f, 3.39561284e-01f, 5.83320037e-02f, 2.36344412e-01f, 2.36968622e-01f, 4.28198338e-01f, -1.68369472e-01f,
  -2.81133771e-01f, -3.97356637e-02f, -2.91979343e-01f, 3.12397256e-02f, 2.14910991e-02f, -2.13974738e-04f, 1.81823969e-01f, -5.43435141e-02f, 2.53412247e-01f, -7.53490105e-02f,
  1.05487376e-01f, 1.35585278e-01f, 4.48865056e-01f, 1.54180214e-01f, -4.46109623e-01f, 3.81823123e-01f, 2.29710311e-01f, -1.92540288e-01f, -6.04072735e-02f, 2.17475668e-01f,
  8.41124132e-02f, 3.47685605e-01f, 4.84603524e-01f, 6.62341043e-02f, 9.70965177e-02f, 2.02324074e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  9.42459330e-02f, 8.47792253e-02f, 1.44849285e-01f, 1.83551341e-01f, 2.48823985e-01f, 1.94096670e-01f, 1.58544391e-01f, 2.45596558e-01f, 1.37884647e-01f, 1.42233044e-01f,
  1.60860419e-02f, 2.69057810e-01f, 2.65815351e-02f, 1.93502918e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.98184118e-01f, 4.37456891e-02f, -1.50749460e-01f, -1.63384065e-01f, -6.86005801e-02f, 3.42246257e-02f, 1.05901703e-01f, -7.82850832e-02f, -9.53611359e-03f, -1.47249466e-02f,
  -3.71146202e-01f, 7.47063085e-02f, 3.37304413e-01f, 1.86921954e-01f, -4.45788354e-02f, -1.66962147e-02f, -1.56853035e-01f, -2.16507778e-01f, -2.50704616e-01f, -4.08254676e-02f,
  -6.59491792e-02f, 2.28717864e-01f, -1.66815713e-01f, -4.81366850e-02f, -5.12537323e-02f, 3.10273379e-01f, 2.01080158e-01f, -5.15526012e-02f, -2.96908677e-01f, 2.94149190e-01f,
  3.43477607e-01f, -5.18332943e-02f, -3.22770536e-01f, 1.76922336e-01f, -9.14902464e-02f, -3.05773139e-01f, 2.26965517e-01f, -2.86469221e-01f, 3.63822848e-01f, 2.55360454e-01f,
  -3.44564140e-01f, 3.38987052e-01f, 3.48501652e-02f, 1.41314834e-01f, 2.32548475e-01f, -3.24634075e-01f, 1.78783968e-01f, -1.82999820e-01f, 3.75663072e-01f, -5.09091914e-02f,
  -5.70833348e-02f, 8.40583742e-02f, -2.52835244e-01f, -4.53230530e-01f, -5.06562829e-01f, 2.84028530e-01f, 1.87024787e-01f, -2.88154364e-01f, -3.68251771e-01f, -4.38121319e-01f,
  2.59071380e-01f, 2.08305508e-01f, -1.39721662e-01f, -3.72607738e-01f, -2.77405143e-01f, -1.35566955e-02f, -1.43400729e-01f, -5.64396195e-02f, -5.10115847e-02f, 3.89845103e-01f,
  -4.99855392e-02f, 3.93476039e-01f, -2.95351952e-01f, 1.88131943e-01f, 1.22019209e-01f, -9.52848569e-02f, -1.62186503e-01f, 1.87205881e-01f, -2.92457268e-02f, -1.21014230e-01f,
  -3.39312255e-02f, 3.66906881e-01f, 1.89054087e-01f, 3.38994533e-01f, 2.41255522e-01f, -6.31506324e-01f, -9.89858732e-02f, 2.75620446e-02f, 4.82644178e-02f, -3.85075152e-01f,
  -2.74207890e-01f, 1.53313801e-01f, 3.23954135e-01f, -4.74870019e-03f, 3.76786351e-01f, -3.82179260e-01f, 2.28793576e-01f, 3.23371232e-01f, 1.25435628e-02f, 8.20540935e-02f,
  2.50433795e-02f, 2.04472199e-01f, -1.21756151e-01f, -5.54883629e-02f, 2.08918229e-01f, -1.57714531e-01f, -3.70879650e-01f, -3.57866585e-01f, 3.09547395e-01f, 1.43780529e-01f,
  8.34837183e-02f, -1.49426162e-01f, 1.70127422e-01f, 3.85580659e-01f, 3.91186737e-02f, -5.15353501e-01f, 9.11166966e-02f, -5.39914489e-01f, -4.70201045e-01f, 6.47536218e-02f,
  2.23852053e-01f, 2.55013674e-01f, -1.48267448e-01f, 2.51419157e-01f, 4.34465826e-01f, -2.66195578e-03f, 1.30275607e-01f, -3.12217355e-01f, -7.23190010e-02f, -1.00834921e-01f,
  -3.13269883e-01f, -1.71125099e-01f, 1.30193159e-01f, 4.63529519e-04f, -2.77628899e-01f, 2.10098490e-01f, -1.69599593e-01f, -2.99320698e-01f, 1.84736803e-01f, -2.15256065e-01f,
  -7.26665184e-02f, 1.17272558e-02f, 1.89930812e-01f, 1.88029751e-01f, 3.71612579e-01f, 1.18842721e-01f, 8.52122158e-02f, 1.54647797e-01f, 6.43246993e-02f, 2.01485604e-01f,
  3.91843408e-01f, 1.66756153e-01f, 5.07613085e-02f, 2.21997559e-01f, -1.71503022e-01f, -1.89936087e-01f, 5.10164261e-01f, -1.03137761e-01f, 4.16109145e-01f, 1.87960207e-01f,
  -5.52247316e-02f, -8.49803612e-02f, -6.52151257e-02f, -2.85806358e-01f, -2.17812777e-01f, 4.81456667e-01f, 3.41864854e-01f, 9.78042930e-02f, 2.69964099e-01f, -5.18276036e-01f,
  -4.04422281e-05f, -2.84925878e-01f, 1.35964751e-01f, -3.92497778e-01f, -4.26704437e-01f, 2.21287116e-01f, -1.77882358e-01f, -4.26996559e-01f, -6.50631905e-01f, -4.83780019e-02f,
  -9.40750092e-02f, 4.51483339e-01f, 2.05118552e-01f, 4.09610957e-01f, -3.73932868e-01f, -1.89953476e-01f, -1.75428495e-01f, -6.07259214e-01f, 8.81987438e-02f, 1.00499906e-01f,
  -3.65324989e-02f, -5.63064575e-01f, -8.39372799e-02f, -5.07188924e-02f, 1.57445967e-01f, 2.21957311e-01f, 9.91393551e-02f, 1.02241509e-01f, -4.72406745e-02f, -5.90460226e-02f,
  4.41102823e-03f, 6.73377141e-02f, -1.62969843e-01f, -1.93096280e-01f, 7.78754801e-02f, -2.23131120e-01f, -4.47650313e-01f, 9.32321325e-02f, -2.20564842e-01f, -3.44510078e-01f,
  -1.20880738e-01f, 1.83462519e-02f, -5.47936380e-01f, 1.97294503e-01f, 1.06402643e-01f, 2.07500443e-01f, -2.08472654e-01f, -2.37461269e-01f, -4.64341283e-01f, -2.61312604e-01f,
  6.84457794e-02f, 2.10726112e-01f, -3.10448855e-01f, -2.99804062e-01f, -2.39327952e-01f, -3.88474435e-01f, -1.60975829e-01f, -1.75373882e-01f, 4.32076931e-01f, -2.00966284e-01f,
  4.42256719e-01f, 7.05528855e-02f, 3.24349016e-01f, 8.26296024e-03f, -1.80287004e-01f, -7.57326856e-02f, 3.33842278e-01f, -2.09611714e-01f, 2.62372822e-01f, -4.25130337e-01f,
  -2.96300322e-01f, -2.49947757e-01f, -3.98171544e-01f, 4.69814204e-02f, -7.54643321e-01f, 2.87036806e-01f, 2.86479473e-01f, -8.21128249e-01f, 3.10615778e-01f, -1.09167442e-01f,
  -2.55972654e-01f, -6.69694841e-01f, -4.68986362e-01f, 3.00135404e-01f, -4.48208988e-01f, -8.00202787e-02f, -1.38814464e-01f, -1.01672165e-01f, 2.65227318e-01f, 5.40368212e-03f,
  2.79739231e-01f, -3.70921474e-03f, -3.86299491e-02f, -5.22187829e-01f, 4.05928046e-02f, 3.43887836e-01f, -9.37077329e-02f, 4.06594366e-01f, -2.95449048e-01f, 5.59520051e-02f,
  5.50465919e-02f, 7.92120472e-02f, -1.71010308e-02f, 7.05999136e-02f, -3.18718135e-01f, -5.76629490e-02f, 5.50400130e-02f, -2.23473504e-01f, -1.00431509e-01f, -3.26639563e-01f,
  -2.73543298e-01f, -1.43226357e-02f, 4.89124954e-01f, 2.40463182e-01f, -3.32318485e-01f, -2.35105231e-01f, -3.75417434e-02f, 2.94079840e-01f, 3.37535411e-01f, 3.90178204e-01f,
  1.59129322e-01f, 5.30961573e-01f, -1.26413032e-01f, -1.14551686e-01f, -1.48858160e-01f, 2.28268862e-01f, 4.56330925e-01f, -3.97872835e-01f, -4.70501125e-01f, -1.06647551e-01f,
  -3.66273224e-01f, -2.98058540e-01f, -4.41354305e-01f, -3.21214348e-02f, -1.79027230e-01f, 5.83081365e-01f, -4.06410694e-01f, 2.52912134e-01f, -6.36902526e-02f, -1.07305586e-01f,
  1.57506883e-01f, -2.82519579e-01f, -1.62751321e-03f, -3.51427227e-01f, 3.68038327e-01f, -1.97244152e-01f, -4.06484045e-02f, 8.51265863e-02f, 1.35236993e-01f, 1.45941436e-01f,
  5.19416332e-01f, -2.97446400e-01f, 7.91357271e-03f, -2.16952730e-02f, -3.05808634e-01f, -9.31273103e-02f, 2.09241495e-01f, -2.89628416e-01f, 1.38200790e-01f, 4.93005723e-01f,
  4.92740013e-02f, -8.73444304e-02f, 1.24186993e-01f, -2.22594038e-01f, 2.09508628e-01f, 2.07090601e-01f, 4.31939721e-01f, -1.40949279e-01f, 3.73809069e-01f, -3.00766200e-01f,
  -7.69614130e-02f, 1.94420084e-01f, 2.99772382e-01f, 4.31084968e-02f, 6.69037923e-02f, 3.16732287e-01f, -3.53213191e-01f, 1.08623527e-01f, -5.33537626e-01f, 1.64845347e-01f,
  -4.47202504e-01f, 2.45391414e-01f, -3.30955505e-01f, 1.88696093e-03f, 6.60442784e-02f, -3.00313294e-01f, 2.15037614e-01f, 1.67866752e-01f, -1.97186589e-01f, -2.96548128e-01f,
  3.67723346e-01f, -2.02718586e-01f, 3.19933116e-01f, 2.58638382e-01f, -2.93511540e-01f, 4.84167218e-01f, 1.24885403e-01f, -4.11342025e-01f, -5.31072095e-02f, 1.17061019e-01f,
  -3.13052952e-01f, 1.37571901e-01f, 3.66193533e-01f, -2.59741843e-01f, 8.23751539e-02f, -1.66096047e-01f, -2.62246907e-01f, 8.04955587e-02f, -1.41221836e-01f, -1.99254438e-01f,
  -9.23021734e-02f, 2.14058056e-01f, 2.70730257e-01f, -4.08607513e-01f, 4.64906007e-01f, 2.59140611e-01f, -3.45253088e-02f, 1.14891209e-01f, 1.73156708e-01f, 2.58935839e-02f,
  3.00959498e-01f, 6.23928495e-02f, -2.92072475e-01f, 1.15193695e-01f, 6.90496713e-02f, -2.04950437e-01f, 2.76323646e-01f, 1.06647134e-01f, -1.99019715e-01f, 2.85725713e-01f,
  -1.01298280e-01f, -2.57975221e-01f, 9.74982604e-02f, -2.41681412e-01f, -1.53369501e-01f, 1.63672984e-01f, -5.69072217e-02f, 5.98058105e-02f, -8.13399032e-02f, -3.07203028e-02f,
  1.72845080e-01f, -3.18553522e-02f, -1.81691349e-01f, -1.80398360e-01f, -4.63705629e-01f, 1.77025348e-01f, 2.60509133e-01f, -4.83771041e-02f, -2.17552498e-01f, 1.84700206e-01f,
  3.05835996e-02f, -2.57458165e-02f, -1.95755288e-01f, 3.13900411e-02f, -6.02719560e-02f, 2.10080951e-01f, -1.46573678e-01f, 5.12270033e-01f, -1.75320171e-02f, 3.18865597e-01f,
  -2.45578289e-01f, -2.23960087e-01f, -2.16627225e-01f, -1.38117686e-01f, 2.36184746e-01f, -8.36626440e-02f, 2.87565053e-01f, -3.08482379e-01f, 8.75729322e-02f, 1.94888949e-01f,
  -4.65181887e-01f, -2.71416932e-01f, 2.99321443e-01f, -7.51928240e-02f, -2.09425971e-01f, -4.76810515e-01f, -2.46890903e-01f, -5.49808860e-01f, -1.39776051e-01f, -1.95755482e-01f,
  -4.50089499e-02f, -7.93769360e-02f, -1.97332159e-01f, 8.85671601e-02f, 5.59482798e-02f, -1.95000932e-01f, -3.02447863e-02f, 1.48957595e-01f, 2.28146259e-02f, 2.68929422e-01f,
  -1.30539000e-01f, -2.02122271e-01f, 1.26346454e-01f, -2.73745298e-01f, 1.78358927e-02f, 1.57827273e-01f, -2.11796686e-01f, 1.12259731e-01f, 5.79140596e-02f, -1.86395213e-01f,
  -2.70059854e-01f, 2.69626174e-02f, -5.75845987e-02f, 8.23477730e-02f, -3.65143061e-01f, -2.68369704e-01f, 1.54972702e-01f, -4.92314324e-02f, 2.54386872e-01f, -1.30933031e-01f,
  2.46493325e-01f, -3.69564801e-01f, 8.90357494e-02f, 2.56419212e-01f, 1.59290031e-01f, 1.58027604e-01f, 2.68539488e-01f, 3.79267961e-01f, 1.52590975e-01f, 8.03056955e-02f,
  3.95738557e-02f, -1.71954274e-01f, 1.84601545e-01f, 2.63593704e-01f, -5.80473728e-02f, 3.19485515e-01f, -7.65944878e-03f, 1.91121146e-01f, 2.53167152e-01f, 6.27355203e-02f,
  2.13705748e-01f, -3.19175154e-01f, 2.34572455e-01f, -1.84523284e-01f, 1.95110008e-01f, 2.26010680e-01f, -1.64214060e-01f, -4.51797664e-01f, -2.92341232e-01f, -1.37205660e-01f,
  -3.92999530e-01f, 2.99234360e-01f, -5.33021450e-01f, -6.02230802e-02f, 2.89845467e-01f, -1.14944480e-01f, -4.91340868e-02f, 1.45186232e-02f, -2.06676200e-01f, 8.61654207e-02f,
  -6.09236863e-03f, -6.20172620e-01f, -4.04474348e-01f, 2.76832074e-01f, -2.62680918e-01f, 1.17539354e-02f, -2.81475842e-01f, -1.24246374e-01f, -1.14902996e-01f, -2.56583750e-01f,
  -2.43786559e-01f, -2.90344030e-01f, 2.87851334e-01f, 1.93296507e-01f, 1.83592681e-02f, 1.72830299e-01f, -2.16881096e-01f, 1.81956515e-01f, 5.67893386e-01f, 3.15813452e-01f,
  4.66841191e-01f, 5.63768864e-01f, -1.89763874e-01f, 4.27766234e-01f, -1.74842060e-01f, -2.64438808e-01f, -2.01814026e-02f, 1.16939262e-01f, -3.08082014e-01f, 2.20672652e-01f,
  -1.03454582e-01f, -1.09594956e-01f, -7.65222847e-01f, 5.50881922e-01f, 3.35923731e-01f, 4.52855527e-01f, -9.84640121e-02f, 2.00173125e-01f, -2.32407972e-01f, 5.29456615e-01f,
  -1.98683843e-01f, -5.65334499e-01f, -2.97072798e-01f, -7.25710392e-02f, 5.06334379e-02f, 2.06894465e-02f, -3.81798595e-01f, 2.71535873e-01f, -1.35560811e-01f, 2.73092270e-01f,
  -7.06349432e-01f, 1.26785308e-01f, -2.75621980e-01f, -5.81493914e-01f, 2.95045853e-01f, 5.12219295e-02f, -3.07775944e-01f, 9.11501721e-02f, -4.97838557e-02f, -1.32314088e-02f,
  -2.93873340e-01f, 1.35627016e-01f, -2.47971803e-01f, 2.47248888e-01f, 1.78471297e-01f, -1.70714140e-01f, 7.93365240e-02f, -2.73494959e-01f, -3.56938452e-01f, 1.91600233e-01f,
  2.89395228e-02f, -1.72747836e-01f, 6.06717840e-02f, 2.17526004e-01f, 1.12341963e-01f, -1.59529150e-01f, -2.12064371e-01f, 1.38841301e-01f, -1.64360926e-01f, -1.34347871e-01f,
  5.12423754e-01f, -1.44111499e-01f, 4.98318762e-01f, -4.50089216e-01f, 1.77426621e-01f, -1.21580526e-01f, 6.64938867e-01f, 1.29380181e-01f, -2.74259359e-01f, 2.28852794e-01f,
  2.79100984e-02f, -4.32921797e-01f, -3.13628048e-01f, -4.19046223e-01f, 1.95780113e-01f, -3.18374336e-01f, -1.10477492e-01f, 6.25197053e-01f, 2.07552835e-01f, -4.48234409e-01f,
  1.07423916e-01f, 3.72520059e-01f, 4.86679316e-01f, 5.15939236e-01f, 5.41451037e-01f, 1.54174715e-01f, -2.56825071e-02f, 1.55689493e-01f, -1.93552092e-01f, 1.60555691e-01f,
  5.71453385e-02f, 2.20115498e-01f, -3.61713886e-01f, -3.54385763e-01f, 1.45181075e-01f, 1.67919174e-01f, -5.13920963e-01f, -4.29066747e-01f, -2.11825028e-01f, 3.40750545e-01f,
  -8.67217109e-02f, 1.81862772e-01f, -3.43553066e-01f, 5.10567576e-02f, 5.68373390e-02f, -2.22400859e-01f, -2.50890590e-02f, -3.34343344e-01f, -1.14203997e-01f, -3.86258513e-01f,
  2.83694685e-01f, -2.96959698e-01f, 1.04600042e-01f, -1.46762937e-01f, -4.54166010e-02f, 1.83595717e-01f, -9.06233788e-02f, 1.92961469e-01f, 3.23418766e-01f, -4.15540308e-01f,
  -2.24776417e-01f, -3.75370592e-01f, -1.22136086e-01f, -1.80024859e-02f, 2.72989661e-01f, 1.01461761e-01f, -1.14513852e-01f, 1.67508036e-01f, -6.35098666e-02f, 1.79993942e-01f,
  -1.74270540e-01f, 6.91071451e-02f, -1.68272927e-01f, 3.10963988e-01f, -1.31353170e-01f, -1.87467530e-01f, 2.53322482e-01f, -2.73509771e-01f, -2.29858041e-01f, -3.55620772e-01f,
  -2.26311982e-01f, -1.21497951e-01f, -2.16728061e-01f, -1.93540767e-01f, 1.63382106e-02f, -4.13128972e-01f, 1.86754853e-01f, 5.65124191e-02f, 2.77871132e-01f, 2.35667676e-01f,
  -2.91697085e-01f, -5.16840398e-01f, -7.52430022e-01f, 5.37641943e-01f, -4.32530075e-01f, -4.45462495e-01f, -4.82985049e-01f, -1.66444376e-01f, -4.41239893e-01f, 1.52081281e-01f,
  1.17464103e-01f, 1.23091646e-01f, 1.92561179e-01f, 3.91373098e-01f, 5.17566442e-01f, -1.79127082e-01f, 2.53434867e-01f, 1.48524866e-01f, 8.19976255e-02f, -2.31596068e-01f,
  -5.12901135e-02f, 1.56948954e-01f, 2.24144295e-01f, -1.68986082e-01f, -1.66621223e-01f, 2.53461272e-01f, 2.76330501e-01f, 8.45797434e-02f, 3.71659309e-01f, -5.50846085e-02f,
  -1.98014587e-01f, 3.32543887e-02f, 5.65375201e-02f, 1.88403681e-01f, -1.11505061e-01f, -9.84468535e-02f, 3.65115464e-01f, 2.06281543e-02f, -1.24496102e-01f, -8.33343938e-02f,
  -4.66761827e-01f, -4.38662656e-02f, -2.77273804e-01f, -1.96741268e-01f, -2.11920679e-01f, -5.05402267e-01f, 1.79059654e-01f, -3.19167189e-02f, 1.77472271e-02f, 2.09461361e-01f,
  -3.65575100e-03f, 1.82081476e-01f, -4.33938056e-01f, 2.67242491e-01f, -4.09932882e-01f, 9.38046202e-02f, 6.71266988e-02f, 2.72232920e-01f, 5.70015945e-02f, -6.36937737e-01f,
  2.46506989e-01f, -4.88261953e-02f, -1.54874563e-01f, -4.10702288e-01f, 3.83366883e-01f, -3.16000700e-01f, -5.24266720e-01f, 2.41369344e-02f, 2.73016512e-01f, -7.08783865e-01f,
  -2.67968148e-01f, 6.43160383e-05f, -1.01117477e-01f, 3.74484152e-01f, -8.89535761e-04f, -2.99334168e-01f, -1.43694982e-01f, 2.24212795e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.50334352e-01f, 1.63345542e-02f, 3.99869233e-02f, 9.16784033e-02f, -4.75651100e-02f, 1.22085489e-01f, 1.43542960e-02f, -9.69100818e-02f, 9.39822569e-02f, -5.02107926e-02f,
  -4.50606784e-03f, -1.56520419e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    