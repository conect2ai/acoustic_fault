/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.24222063e-01f, 5.48472963e-02f, 5.64764082e-01f, -2.56022245e-01f, 2.18511254e-01f, -1.86108556e-02f, 1.78279757e-01f, -1.59024745e-01f, -1.73431903e-01f, 1.35894030e-01f,
  -1.76269203e-01f, -1.41745120e-01f, -1.73751846e-01f, -7.64999986e-02f, -1.34129480e-01f, 1.46680132e-01f, 1.96080536e-01f, 1.08720303e-01f, -1.57360896e-01f, -6.77829906e-02f,
  -1.17963709e-01f, -8.98321271e-02f, -1.64791614e-01f, -9.43014547e-02f, 1.39409363e-01f, -1.55682802e-01f, 1.06034674e-01f, 2.02954799e-01f, -5.47879711e-02f, 6.88192070e-01f,
  2.01854885e-01f, 1.90235496e-01f, -2.93349009e-03f, -1.68170372e-04f, 4.92488556e-02f, -8.59187245e-02f, -2.70439847e-03f, 4.13685329e-02f, -3.84261124e-02f, 2.90990714e-02f,
  -3.50656100e-02f, -2.25668214e-03f, -1.42730892e-01f, 1.92299124e-03f, 1.15134306e-01f, 1.64543316e-02f, -6.27832785e-02f, 1.51634142e-01f, 6.01157323e-02f, 5.68107553e-02f,
  4.31366600e-02f, 1.37380555e-01f, 1.57263160e-01f, 5.89712560e-02f, -8.85877386e-03f, -8.90353248e-02f, 6.45634010e-02f, 1.19832501e-01f, 7.04591721e-02f, 2.37304777e-01f,
  -2.61889882e-02f, 3.63064595e-02f, -4.57669906e-02f, 1.86590180e-02f, -5.33621460e-02f, -3.94733660e-02f, 4.50312607e-02f, -2.42652986e-02f, -1.15160029e-02f, 3.50497961e-02f,
  -1.57154929e-02f, 2.21905038e-02f, 7.52971182e-03f, -1.52213871e-02f, 3.67257781e-02f, 4.14997675e-02f, 5.84407384e-03f, 1.31185597e-03f, -3.53678577e-02f, -2.21429039e-02f,
  -8.17990676e-02f, 1.52119184e-02f, 2.64026895e-02f, 2.98536513e-02f, 4.16288637e-02f, 8.91035888e-04f, -1.91561356e-02f, -3.23205777e-02f, -8.39548856e-02f, -5.98263964e-02f,
  -1.89364001e-01f, -2.90996023e-02f, -7.21850470e-02f, -1.87921580e-02f, 9.29964706e-03f, -3.14878374e-02f, -2.31842455e-02f, 1.34508284e-02f, 1.89316031e-02f, -3.05088833e-02f,
  -7.05594430e-03f, -2.19021123e-02f, 9.34768543e-02f, -5.49051864e-03f, -2.81858034e-02f, -4.55120280e-02f, -2.87921838e-02f, -2.48645265e-02f, -6.86765611e-02f, 1.63933616e-02f,
  -4.97891009e-02f, -1.12652652e-01f, -1.19065456e-01f, 3.15341949e-02f, 1.47163880e-03f, -7.46625811e-02f, 3.87710822e-03f, -5.10459952e-02f, -1.43946007e-01f, -1.90647736e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.91500378e-01f, -1.79583803e-01f, -2.09139973e-01f, -1.78608552e-01f, -8.27027485e-03f, 8.61000270e-02f, 1.39128193e-01f, 1.05905175e-01f, -5.54641485e-02f, 1.64729934e-02f,
  -7.49095082e-02f, -1.01028085e-01f, -2.39602074e-01f, 7.70785892e-03f, 2.13339627e-02f, -8.25938284e-02f, -1.87240556e-01f, -1.21335328e-01f, 1.54911226e-03f, 2.23644689e-01f,
  1.67451531e-01f, -1.64076760e-01f, -1.25588208e-01f, 1.19175456e-01f, -1.29306540e-01f, -1.37690559e-01f, -2.61800945e-01f, -1.08773798e-01f, 2.89406404e-02f, -3.60412866e-01f,
  -1.94567710e-01f, -1.63285106e-01f, 1.00397646e-01f, 1.12850219e-01f, -3.51712927e-02f, -2.17976701e-02f, 5.81498444e-03f, -1.39608160e-02f, 1.27580459e-03f, -5.53971641e-02f,
  5.21097779e-02f, 8.34370032e-02f, -1.14985909e-02f, 2.84064934e-02f, 1.03367921e-02f, 1.26025602e-01f, 6.41998127e-02f, -1.03580859e-02f, 2.56955232e-02f, 1.11688919e-01f,
  9.96788740e-02f, -5.30385673e-02f, 1.91457644e-02f, 7.89642930e-02f, 1.08359180e-01f, -4.60675173e-02f, -1.06466757e-02f, 3.47850248e-02f, 4.72478718e-02f, -7.29658827e-02f,
  5.10971844e-02f, -5.80885075e-02f, -3.41452323e-02f, -9.20254388e-04f, 7.04047382e-02f, -1.00306049e-01f, -2.71926466e-02f, 4.47696224e-02f, 3.15966271e-02f, -4.58051413e-02f,
  -2.64681485e-02f, -2.91050542e-02f, 6.18662015e-02f, -1.81468353e-02f, 1.22425910e-02f, -3.32795084e-02f, 5.85226603e-02f, 2.16495916e-02f, 6.59993961e-02f, 9.29254014e-03f,
  -7.66409747e-03f, -2.78729647e-02f, 5.32350037e-03f, 5.75910583e-02f, -7.71266818e-02f, 2.40457207e-02f, 3.33924964e-02f, 6.77424893e-02f, -2.54715290e-02f, -5.64642176e-02f,
  -1.95826218e-01f, 8.15091282e-02f, -8.58135298e-02f, 1.32671878e-01f, -5.79237528e-02f, 8.27702805e-02f, -1.46324813e-01f, 5.22901937e-02f, -2.14557652e-03f, 7.60357305e-02f,
  9.50697139e-02f, 8.62007611e-04f, -7.66837597e-02f, 4.98301089e-02f, 1.28338158e-01f, 9.86354575e-02f, 1.04879059e-01f, -3.53930369e-02f, 5.64163215e-02f, 8.51615518e-02f,
  4.51506674e-02f, 9.45424959e-02f, 4.33711074e-02f, -7.11451322e-02f, -5.60207944e-03f, -2.69401334e-02f, -4.71464396e-02f, -4.00947481e-02f, -1.80946872e-01f, 1.76911615e-03f,
  -8.19978774e-01f, -2.23240852e-01f, 2.51876622e-01f, -1.28718451e-01f, 5.57028055e-02f, 2.24576250e-01f, 9.10332799e-02f, 2.07434427e-02f, 4.02388535e-02f, -2.54166514e-01f,
  -9.48250294e-03f, -2.20722884e-01f, -2.02850893e-01f, -1.25912875e-02f, -1.07896931e-01f, 2.24772771e-03f, -1.25032943e-02f, -1.32210955e-01f, 1.27486140e-01f, 5.71840554e-02f,
  -8.42710510e-02f, -2.14941129e-01f, -2.11419895e-01f, 3.51255499e-02f, -1.63150921e-01f, -3.48014645e-02f, -1.04973279e-02f, -7.33352527e-02f, 9.00340155e-02f, -4.14218038e-01f,
  -2.77252477e-02f, 2.20690724e-02f, 1.29725009e-01f, -2.10117459e-01f, 8.60502943e-02f, 3.05111445e-02f, 5.36101721e-02f, 2.95016132e-02f, 1.95537768e-02f, -1.18929166e-02f,
  1.98659617e-02f, 1.06002383e-01f, 3.05435974e-02f, 4.16393951e-02f, -1.04109142e-02f, -3.45924236e-02f, 9.63047221e-02f, 1.46594085e-02f, -2.79330425e-02f, 6.22514002e-02f,
  1.80805679e-02f, -5.94208613e-02f, -3.83428484e-02f, 2.30486944e-01f, 7.43998513e-02f, 6.36325330e-02f, 4.92620207e-02f, 4.62442338e-02f, 9.83327404e-02f, -3.56830537e-01f,
  1.65922157e-02f, 1.77736953e-02f, -5.89212403e-03f, -2.50040106e-02f, -1.25433579e-01f, 7.54363313e-02f, -1.95459672e-03f, -4.88601550e-02f, -7.45566785e-02f, -5.14209047e-02f,
  6.94433376e-02f, 3.35980318e-02f, -1.22251594e-02f, -9.97281224e-02f, 2.26773438e-03f, 4.84354869e-02f, 3.82781625e-02f, -3.87374423e-02f, -2.33498868e-02f, -2.43797619e-02f,
  -1.70369875e-02f, -9.02938098e-03f, -4.77440357e-02f, 5.04662395e-02f, 1.08527932e-02f, -7.44663402e-02f, 4.75941524e-02f, -1.04127806e-02f, -4.51533534e-02f, 4.19416912e-02f,
  -2.86740482e-01f, 1.85689762e-01f, -2.35147268e-01f, -4.09063995e-02f, -5.34090847e-02f, -4.44161408e-02f, 1.31455949e-02f, 3.19040231e-02f, -1.45365465e-02f, -2.71315612e-02f,
  -1.15692550e-02f, 7.90722109e-03f, 1.51812546e-02f, -3.57109644e-02f, -8.04002732e-02f, -1.68700367e-02f, -1.38561964e-01f, -1.34630322e-01f, -2.92396899e-02f, 1.26183003e-01f,
  -4.84229550e-02f, -2.39019439e-01f, -4.07537580e-01f, -1.89470515e-01f, -7.92050883e-02f, -1.91988200e-01f, -1.29141793e-01f, -2.02571899e-01f, -2.16265664e-01f, -5.10336816e-01f,
  -1.07839376e-01f, -3.90471555e-02f, -1.44207567e-01f, -4.94954661e-02f, 1.80973597e-02f, 2.01920532e-02f, 1.79437727e-01f, 1.47794902e-01f, -3.54717253e-03f, -5.14833219e-02f,
  3.23310941e-02f, -4.28292453e-02f, 4.32481207e-02f, -1.73834618e-02f, 9.26834121e-02f, 4.41068262e-02f, 1.59327492e-01f, 1.18986005e-03f, -2.05793530e-02f, 6.61401153e-02f,
  1.39193833e-02f, 2.22614575e-02f, -3.42829973e-02f, 5.54977879e-02f, 1.17815502e-01f, 7.94539899e-02f, 6.01519272e-03f, -8.47873241e-02f, -3.24073099e-02f, 3.13558541e-02f,
  -1.72635734e-01f, -7.65812919e-02f, 6.85361922e-02f, 5.82107790e-02f, -3.82953547e-02f, -7.08297417e-02f, 3.59984189e-02f, 5.17513156e-02f, -3.12979259e-02f, 9.93021131e-02f,
  1.10640526e-02f, -1.08218148e-01f, -7.43218362e-02f, -9.07666087e-02f, 4.56623733e-02f, -4.94356193e-02f, -1.02847055e-01f, -9.78169143e-02f, 9.43869799e-02f, 4.32633385e-02f,
  7.02905804e-02f, 2.03164686e-02f, -5.72290830e-02f, 9.50877219e-02f, 2.25143172e-02f, 1.38166845e-01f, 6.84029534e-02f, -1.18993483e-02f, 8.30959342e-03f, -7.74017796e-02f,
  9.44004953e-03f, -7.62668774e-02f, -8.98467004e-03f, -3.88978003e-03f, -3.28351371e-02f, -4.29636315e-02f, 9.26622003e-03f, -3.76598686e-02f, -3.31561896e-03f, -1.01558417e-01f,
  -1.03184707e-01f, -6.39406312e-03f, -2.55998336e-02f, 5.30976541e-02f, -6.91778362e-02f, 5.70254363e-02f, 1.12370618e-01f, 7.25037381e-02f, -4.00191583e-02f, -6.56315386e-02f,
  7.75714079e-03f, -7.12333694e-02f, -4.00343314e-02f, 5.99009879e-02f, 7.01564774e-02f, -2.79044490e-02f, 8.48764032e-02f, 6.11354895e-02f, 2.48350240e-02f, -1.97818447e-02f,
  -1.03696086e-01f, -9.01464000e-02f, -1.53125254e-02f, -2.83572171e-02f, -4.76863869e-02f, -1.05928510e-01f, -9.97030437e-02f, 6.04766468e-03f, -6.25843108e-02f, 2.49206088e-02f,
  -3.17490548e-02f, -1.26076549e-01f, -7.61767179e-02f, 7.69829825e-02f, 7.04771206e-02f, -4.15099077e-02f, -7.14451745e-02f, -9.79555920e-02f, 6.89963549e-02f, 7.34709874e-02f,
  6.73967972e-02f, -1.07794525e-02f, -1.58848893e-02f, 9.08278674e-02f, 1.04953408e-01f, 4.89578210e-02f, -2.48989332e-02f, -4.98086251e-02f, -6.11729026e-02f, 2.79487930e-02f,
  -2.61081122e-02f, -3.37303728e-02f, -1.07617678e-04f, -1.45897865e-02f, -4.63918485e-02f, 5.35908490e-02f, -2.36927792e-02f, 1.22223973e-01f, 1.35282487e-01f, 5.94576523e-02f,
  1.76381785e-02f, 1.62949443e-01f, 9.71869193e-03f, 4.48966399e-02f, 4.03852426e-02f, -4.11352795e-03f, 4.85057160e-02f, -2.18721405e-02f, 4.61250059e-02f, -5.85976765e-02f,
  1.11858837e-01f, 3.77344787e-02f, -1.04245327e-01f, 5.19874878e-02f, 3.98147851e-02f, 1.33252382e-01f, 3.98551822e-02f, 4.56154905e-02f, 7.38827363e-02f, 3.23562250e-02f,
  2.69832220e-02f, -2.22931877e-02f, 5.82425408e-02f, 5.73418550e-02f, 1.02299951e-01f, 7.17416629e-02f, 4.83001284e-02f, -2.07899436e-02f, 7.54267201e-02f, -5.79699827e-03f,
  5.38583472e-02f, 3.26959975e-02f, 9.22825187e-02f, -6.50664940e-02f, -2.31555272e-02f, -2.79849991e-02f, 4.37670164e-02f, -3.26585621e-02f, 7.35340267e-02f, 1.10317409e-01f,
  -2.31838655e-02f, 4.66643944e-02f, -1.06002010e-01f, 2.84819826e-02f, 1.14238746e-02f, 2.11159643e-02f, -7.25918785e-02f, 7.65168071e-02f, 6.48379773e-02f, -2.47614011e-02f,
  4.88826707e-02f, 9.60575193e-02f, -2.31199525e-02f, -6.33623600e-02f, -3.13716382e-02f, -8.42531696e-02f, -6.72096685e-02f, -2.75695301e-03f, -8.00023526e-02f, -6.49048984e-02f,
  2.93841623e-02f, -3.00414581e-02f, 2.89780684e-02f, -1.84460413e-02f, 3.60005125e-02f, 8.24045017e-03f, -4.96049561e-02f, -7.13693872e-02f, 4.10259701e-02f, -1.08592615e-01f,
  -2.74648191e-03f, -1.16478145e-01f, -3.31397378e-03f, 2.82299668e-02f, 5.49236275e-02f, -7.51966387e-02f, 5.66598587e-03f, -7.77369514e-02f, -6.17290288e-02f, 2.86874827e-02f,
  9.36005861e-02f, 1.11997768e-01f, 5.23718931e-02f, -2.88254227e-02f, 6.65302575e-02f, 9.62889660e-03f, 8.81460961e-03f, 8.06828961e-02f, -5.33591993e-02f, -2.90119816e-02f,
  -3.39810438e-02f, 1.37887308e-02f, -5.69251291e-02f, 7.07544526e-03f, -5.14616817e-02f, 8.20926577e-02f, -5.50437085e-02f, 9.19856057e-02f, 9.87430736e-02f, 1.04301400e-03f,
  -3.64714302e-02f, 3.97934206e-03f, -6.61298335e-02f, 1.74155124e-04f, -1.55119281e-02f, 5.54223992e-02f, 3.62458127e-03f, -3.43845412e-02f, 4.63349186e-02f, 6.78425133e-02f,
  -1.42139448e-02f, -5.51766902e-02f, -8.59981701e-02f, -5.96770197e-02f, -6.47580549e-02f, -1.03595257e-02f, -8.53833705e-02f, 7.75246173e-02f, 8.12879652e-02f, -3.47752050e-02f,
  -1.17252164e-01f, 1.19868806e-02f, -6.91929162e-02f, 1.30259963e-02f, -1.24360919e-01f, -8.89689177e-02f, -8.23082849e-02f, -7.67939985e-02f, -6.26092330e-02f, -1.63935065e-01f,
  -7.39424080e-02f, -4.80940714e-02f, -1.14026546e-01f, -6.87840655e-02f, -4.24606428e-02f, 1.22986520e-02f, 4.85896207e-02f, -5.22445031e-02f, -2.77725626e-02f, 1.32144932e-02f,
  -8.56406540e-02f, -3.82588990e-02f, -8.34985971e-02f, 2.84586065e-02f, -3.89871933e-02f, 5.83786592e-02f, -2.50915177e-02f, -3.81233878e-02f, 5.23934290e-02f, -2.33599599e-02f,
  7.13605434e-02f, 5.34771457e-02f, -3.02593764e-02f, -7.87602067e-02f, 5.56158945e-02f, -4.02526259e-02f, -5.15478291e-03f, 5.58981001e-02f, -7.73681179e-02f, -8.76533166e-02f,
  -2.23910641e-02f, 1.94980260e-02f, -1.96422208e-02f, 9.21374634e-02f, 3.32144350e-02f, -7.42917135e-02f, 1.72365159e-02f, 9.47929919e-02f, -5.88375442e-02f, -1.10296989e-02f,
  -5.68992645e-02f, -4.19536382e-02f, -7.89307505e-02f, 4.99688163e-02f, -9.53488424e-02f, -2.65816180e-03f, -2.30383910e-02f, -9.17896777e-02f, -1.78232708e-03f, -6.81087226e-02f,
  1.17691355e-02f, -9.07414109e-02f, 3.55345830e-02f, 5.46376817e-02f, -1.46397203e-02f, 2.57269014e-02f, 3.31247263e-02f, 4.52798456e-02f, -7.82178864e-02f, -1.68251456e-03f,
  5.26308045e-02f, 1.43847996e-02f, 1.91293824e-02f, 7.24473745e-02f, -5.17538413e-02f, 4.00174074e-02f, 3.49834226e-02f, 6.75987303e-02f, -1.32328011e-02f, 3.84702943e-02f,
  -3.42765264e-02f, -1.35644823e-01f, -9.60574076e-02f, -3.99494311e-03f, 2.41233166e-02f, 4.65494692e-02f, -7.56772533e-02f, -5.05367145e-02f, -2.10090727e-02f, -8.77195671e-02f,
  -3.88884284e-02f, -3.02976482e-02f, 3.23459767e-02f, 1.84215866e-02f, -3.22844945e-02f, -1.31771266e-01f, 1.15445536e-02f, -2.86395382e-02f, 9.53523070e-03f, 3.40353213e-02f,
  3.14160287e-02f, 5.97938932e-02f, -7.16146082e-02f, 5.18750492e-03f, -1.01829087e-02f, 9.95419733e-03f, -8.02441314e-02f, 1.79627817e-03f, 1.71504803e-02f, 8.18905532e-02f,
  -7.35898256e-01f, 2.37208009e-01f, -2.07080424e-01f, -3.66757154e-01f, 1.99585229e-01f, 7.74515569e-02f, 2.72144735e-01f, -2.86761317e-02f, -2.04259351e-01f, 7.12937638e-02f,
  8.12722836e-03f, -4.42313701e-02f, -1.92307809e-03f, 9.67610553e-02f, -1.20217660e-02f, 1.92326412e-01f, 3.44833970e-01f, -7.90037494e-03f, -3.40670735e-01f, -6.64045438e-02f,
  2.94064552e-01f, -1.18434958e-01f, -2.66815960e-01f, -9.24345627e-02f, -2.67951321e-02f, -1.11408897e-01f, -5.53914942e-02f, 4.85456809e-02f, 1.78730533e-01f, 5.65157712e-01f,
  -1.99726939e-01f, -1.29191354e-01f, 1.04358224e-02f, 2.39237193e-02f, 4.56830375e-02f, -9.63353142e-02f, 1.36175836e-02f, -2.04973668e-02f, 2.13467069e-02f, -1.00154327e-02f,
  4.12843376e-02f, 2.61544473e-02f, 7.23892450e-02f, -6.50330856e-02f, -1.40291810e-01f, -5.37610054e-02f, -1.78092830e-02f, -6.11138791e-02f, -9.02309418e-02f, 4.80049383e-03f,
  2.90662318e-01f, 1.27009258e-01f, -9.59009752e-02f, 5.19304834e-02f, 1.41308680e-02f, 7.20369667e-02f, 7.77041838e-02f, 7.04257488e-02f, 2.80969311e-02f, -7.44884694e-03f,
  7.92716816e-02f, 4.27346155e-02f, 4.67995219e-02f, -9.66854277e-04f, 2.93626767e-02f, -9.88824293e-03f, 5.19464165e-02f, -4.19854634e-02f, 2.41700485e-02f, -5.99869601e-02f,
  6.50953799e-02f, 2.73846481e-02f, -8.28096364e-03f, -4.52116393e-02f, -6.73273802e-02f, -8.97595659e-03f, -2.66779102e-02f, -2.09654658e-03f, -3.65020521e-02f, 4.94885407e-02f,
  -1.19008510e-04f, 1.41697796e-02f, -4.19123396e-02f, 2.86161657e-02f, 1.11029916e-01f, -9.40380245e-03f, 4.39506164e-03f, 4.10508290e-02f, -5.05853854e-02f, 4.60297540e-02f,
  -2.84857452e-01f, 2.62936950e-01f, -2.01460123e-01f, -4.11096476e-02f, 4.22659852e-02f, -3.02021485e-02f, -2.97185425e-02f, -1.40490914e-02f, -8.46070647e-02f, -2.65358705e-02f,
  -3.25791016e-02f, -3.01903859e-02f, -3.49411331e-02f, 3.84071283e-02f, -1.08483531e-01f, 1.11679928e-02f, 6.42506853e-02f, -4.74913307e-02f, 1.35102170e-02f, -5.26843555e-02f,
  5.73716909e-02f, -1.58608839e-01f, -2.86447555e-01f, -8.43577310e-02f, -1.02287546e-01f, -7.88136050e-02f, -1.44882873e-01f, -1.57869950e-01f, -7.39484578e-02f, -2.75039613e-01f,
  -3.56979251e-01f, -4.86978181e-02f, 6.91183805e-02f, -9.02745277e-02f, 1.38026312e-01f, 1.43555626e-01f, -1.38566285e-01f, -9.83811244e-02f, -1.39787450e-01f, -8.89947936e-02f,
  1.45578980e-01f, 9.31753740e-02f, 1.00869089e-01f, -3.91170681e-02f, -1.08163089e-01f, -1.53211191e-01f, -7.59643177e-03f, 5.90583906e-02f, -4.30338494e-02f, 1.71707757e-02f,
  1.59864500e-02f, 1.64771229e-01f, 1.38281018e-01f, 1.24438293e-01f, -7.51561373e-02f, 1.86990499e-01f, 2.75736988e-01f, 1.70809135e-01f, 2.02692926e-01f, -7.66298994e-02f,
  -8.58606100e-02f, -1.53779969e-01f, 9.38078165e-02f, 9.47862342e-02f, 1.60128787e-01f, -9.88115892e-02f, -1.17075682e-01f, 2.82722190e-02f, 1.67734493e-02f, -1.30466208e-01f,
  1.59524605e-02f, -3.37603167e-02f, -9.17183086e-02f, 5.29576913e-02f, -7.91783407e-02f, -1.17299527e-01f, 5.04295267e-02f, -4.68291417e-02f, -3.11697684e-02f, -1.20664433e-01f,
  8.27593505e-02f, 1.63582683e-01f, 3.51440422e-02f, 1.06197275e-01f, -1.18461005e-01f, -3.25621702e-02f, 3.86157297e-02f, -1.31992400e-02f, -3.31706293e-02f, -2.11446080e-02f,
  3.99574004e-02f, -5.24530225e-02f, 5.13613708e-02f, -4.03068848e-02f, -2.09405515e-02f, -4.75322530e-02f, 4.87586409e-02f, 3.45824882e-02f, -5.27982898e-02f, -1.22052105e-03f,
  2.74711922e-02f, 8.16373341e-03f, -1.85508970e-02f, 1.65331438e-02f, 9.68198627e-02f, 1.64089855e-02f, 1.67086571e-02f, 7.62906596e-02f, 1.18531205e-01f, -3.76760736e-02f,
  4.73817550e-02f, 2.22986192e-02f, 7.46981148e-03f, -6.62149116e-02f, 1.86673217e-02f, 1.21851154e-02f, -9.21448320e-02f, -1.07062541e-01f, -3.41280736e-02f, 1.37011809e-02f,
  -1.06589139e-01f, 3.80369782e-01f, -1.72767729e-01f, -2.20115818e-02f, 2.95154303e-02f, -1.08183566e-02f, -5.35114668e-02f, 1.66848786e-02f, -8.48515891e-04f, -4.74749841e-02f,
  -1.02399237e-01f, -4.64384593e-02f, -5.13100345e-03f, 3.98244001e-02f, 1.49030667e-02f, -1.08321287e-01f, 4.90800738e-02f, 6.12830929e-02f, 4.10466269e-02f, -1.02494434e-01f,
  -1.07550271e-01f, -6.32274821e-02f, -8.91963840e-02f, -7.23374262e-02f, -3.78921516e-02f, 3.48834433e-02f, 5.30790649e-02f, -1.56597607e-02f, -9.54322144e-02f, -1.54039457e-01f,
  6.04167059e-02f, 3.42695899e-02f, -1.97078183e-01f, -7.11380411e-03f, -6.86441585e-02f, -9.48840156e-02f, -5.03348410e-02f, 5.99217750e-02f, 1.55143682e-02f, -7.19119832e-02f,
  -2.68436577e-02f, -2.54913233e-02f, 4.19176295e-02f, -4.61234190e-02f, 1.01817280e-01f, -8.51800144e-02f, -6.82085305e-02f, 2.19362695e-02f, -2.83056572e-02f, 3.97407264e-02f,
  7.27698654e-02f, -7.29788840e-02f, -5.44549376e-02f, 5.06584458e-02f, -3.40392478e-02f, 3.82105745e-02f, -1.20401740e-01f, 4.85468656e-02f, -8.14109594e-02f, 6.34604366e-03f,
  -9.08095017e-02f, -4.65167463e-02f, -9.33301542e-03f, 7.50436261e-02f, -9.58885103e-02f, -4.59397696e-02f, 4.30797748e-02f, -5.06151654e-02f, -8.20798520e-03f, 1.00151725e-01f,
  -5.05340425e-03f, 4.43017408e-02f, -8.91385321e-03f, 6.61941245e-02f, -3.13635130e-04f, -3.65415029e-03f, -4.03133929e-02f, 2.34700255e-02f, 5.81080839e-02f, -2.38613617e-02f,
  8.09102878e-02f, -2.73307133e-02f, -3.46122123e-02f, 1.99535508e-02f, 3.99844944e-02f, -3.77051197e-02f, 6.37241825e-02f, 3.19029093e-02f, -2.33689863e-02f, 3.22825275e-02f,
  5.94492480e-02f, 7.33778160e-03f, 3.73049602e-02f, -3.13078985e-02f, -5.30661978e-02f, -1.27392644e-02f, -2.72872970e-02f, 4.07316275e-02f, 3.27732377e-02f, -1.78884733e-02f,
  1.22551825e-02f, 4.70134951e-02f, -3.28098089e-02f, 5.34903305e-03f, 5.61885163e-02f, -8.60294849e-02f, -2.61518843e-02f, 4.73195910e-02f, -4.21687849e-02f, -4.31095064e-02f,
  -4.72840033e-02f, 3.70783135e-02f, 3.55598107e-02f, -1.80947594e-02f, -6.37734160e-02f, -2.36790385e-02f, -9.08061117e-02f, -7.02725947e-02f, -6.32006079e-02f, -1.02972351e-01f,
  1.91992432e-01f, -1.51727088e-02f, 4.47099134e-02f, 8.73125046e-02f, -4.44125338e-03f, 1.07465517e-02f, 4.23163213e-02f, 1.36464704e-02f, 3.75871025e-02f, 3.97029743e-02f,
  1.89920589e-02f, 9.76843014e-02f, 2.73206308e-02f, -3.75135168e-02f, -1.10896733e-02f, -6.03188388e-02f, 6.27421308e-03f, -1.46821840e-02f, 2.83266474e-02f, 4.39944640e-02f,
  8.62178877e-02f, -5.05712442e-02f, 5.92716895e-02f, -5.29199839e-02f, 4.20278013e-02f, 9.90611501e-03f, 4.37427796e-02f, -1.87486466e-02f, -6.46502823e-02f, 9.92546529e-02f,
  -3.96444827e-01f, 3.31395119e-01f, -8.67088065e-02f, -1.98371634e-01f, -1.97899103e-01f, -2.12429777e-01f, -7.22130835e-02f, -2.11670939e-02f, -3.09278592e-02f, 1.81178637e-02f,
  -6.77913055e-02f, -6.95979372e-02f, -2.20385157e-02f, -1.13984607e-02f, -2.15461537e-01f, -6.27876371e-02f, -1.89469069e-01f, -1.92457587e-01f, -3.08687091e-01f, -2.07834959e-01f,
  -2.31982470e-01f, -2.46651486e-01f, -1.49690732e-01f, -1.02836289e-01f, 3.35030332e-02f, -5.62549511e-04f, 1.39176071e-01f, -6.27288595e-02f, 2.74831243e-02f, -1.55169860e-01f,
  -5.57314195e-02f, -2.59675443e-01f, -3.84427570e-02f, -1.08070455e-01f, 3.34259472e-03f, -5.15423790e-02f, -5.76247424e-02f, 2.23917682e-02f, -4.13067080e-02f, 8.18546712e-02f,
  -4.76600491e-02f, -5.80411963e-02f, -5.96159585e-02f, -5.42179868e-02f, -4.75408956e-02f, -2.63106246e-02f, 3.64722349e-02f, -9.26711783e-02f, 1.49233919e-03f, -5.09849526e-02f,
  3.25345877e-03f, -1.17209993e-01f, -7.14699179e-02f, 4.54811603e-02f, 3.98713388e-02f, -1.74407780e-01f, 9.64717120e-02f, 1.18949413e-01f, -3.87363248e-02f, 1.76953897e-01f,
  3.82841937e-02f, -3.10084112e-02f, -5.28246397e-03f, 6.72626346e-02f, -2.81122569e-02f, 1.06415026e-01f, -2.37465408e-02f, 1.00096278e-01f, 1.54780438e-02f, 5.99053651e-02f,
  -1.03131616e-02f, 4.03272137e-02f, 1.01886271e-02f, 1.00943753e-02f, 1.57975813e-03f, -8.25100765e-02f, -1.19890552e-02f, 1.18195703e-02f, -1.07173949e-01f, -4.84196581e-02f,
  3.67134437e-02f, 2.82145217e-02f, 3.25530320e-02f, 3.34055796e-02f, -7.45621473e-02f, 9.67136119e-03f, -1.16288029e-02f, -4.09892313e-02f, 2.35956647e-02f, -4.18853089e-02f,
  2.12017223e-01f, -2.08686188e-01f, 5.81798665e-02f, 5.52474149e-02f, 9.67242289e-04f, 1.96600910e-02f, 1.04953654e-01f, 2.14079563e-02f, 8.63193646e-02f, 1.13016497e-02f,
  -6.52479827e-02f, 3.84309958e-03f, -2.33907066e-03f, 1.64974146e-02f, -7.37317465e-03f, -3.25674117e-02f, 6.40200973e-02f, -1.32253030e-02f, -3.42903240e-03f, 3.80095430e-02f,
  1.69237599e-01f, 1.02232195e-01f, 1.51125723e-02f, 1.50301054e-01f, 1.19910510e-02f, -1.39883325e-01f, 1.78410977e-01f, 5.61875217e-02f, -2.08743904e-02f, 3.70542765e-01f,
  6.99350774e-01f, 2.79415190e-01f, 1.84304461e-01f, 2.10770711e-01f, 1.88962549e-01f, 2.84310162e-01f, 6.17203951e-01f, 3.16852659e-01f, 7.28481859e-02f, 1.22037843e-01f,
  1.15942508e-02f, -2.65670806e-01f, -2.01900005e-01f, -1.77227691e-01f, 1.80391550e-01f, 2.23687425e-01f, 7.37726986e-02f, -1.21096298e-01f, -5.51846884e-02f, 1.64727867e-02f,
  -1.12248421e-01f, -9.81453061e-02f, -1.27883377e-02f, 1.24088384e-01f, -1.42111378e-02f, 1.43507114e-02f, 9.96342376e-02f, 9.41776559e-02f, 4.24831808e-02f, -2.59244770e-01f,
  -3.39897305e-01f, 2.92805642e-01f, -1.56600952e-01f, -4.44183610e-02f, -1.97440684e-02f, -9.31885019e-02f, -2.51743812e-02f, -2.78118625e-02f, -8.15278962e-02f, -4.23225900e-03f,
  -2.08642349e-01f, -9.27493870e-02f, -4.92979027e-02f, -1.23988710e-01f, -6.98891729e-02f, -7.61396857e-03f, 3.66080701e-02f, 3.40801664e-02f, 5.45345806e-02f, -8.38210341e-03f,
  -7.56008103e-02f, -1.32156312e-02f, 1.15548305e-01f, 2.07080320e-01f, 1.87508985e-02f, -6.43935427e-02f, 2.79571153e-02f, 1.07429735e-01f, 2.46861055e-01f, 2.34047502e-01f,
  -8.30479115e-02f, 5.01318350e-02f, 5.64398244e-02f, 8.18502437e-03f, 7.02485591e-02f, -1.12500070e-02f, -5.09746633e-02f, -4.08097506e-02f, 6.72923326e-02f, 4.12059128e-02f,
  -2.03814041e-02f, 7.58918151e-02f, -3.94337624e-02f, 2.05932371e-02f, -2.11924836e-02f, -2.78863460e-02f, -1.38361817e-02f, -1.20439902e-02f, -8.11052248e-02f, 8.22148249e-02f,
  2.89880987e-02f, 1.58060261e-03f, -2.56254077e-02f, -2.55797748e-02f, 5.92209175e-02f, -3.73211540e-02f, -5.24492711e-02f, 1.64308548e-02f, -4.97075208e-02f, 3.32202055e-02f,
  -6.28673285e-02f, 1.57614097e-01f, -1.15897112e-01f, -6.64765388e-02f, -5.42533137e-02f, -9.15282071e-02f, -2.00922415e-02f, -4.41140905e-02f, -9.72069427e-02f, 9.38230306e-02f,
  3.48876603e-02f, -5.54957017e-02f, 7.53420517e-02f, 2.75726561e-02f, 3.72420140e-02f, 5.92425577e-02f, -2.19237637e-02f, 1.10027893e-02f, -3.63545083e-02f, -8.97042453e-02f,
  -4.47320901e-02f, 1.68308645e-01f, 3.00928764e-02f, 1.27789959e-01f, -1.98952034e-02f, -8.68360251e-02f, -1.67996194e-02f, 3.88124064e-02f, 1.05707392e-01f, 2.27120385e-01f,
  4.96306345e-02f, 9.02627930e-02f, 1.00966789e-01f, -5.93753979e-02f, -2.38370411e-02f, 6.21022237e-03f, -2.54683867e-02f, -3.48419254e-03f, -6.71245679e-02f, 3.88268637e-03f,
  4.16400060e-02f, -7.51401708e-02f, -7.62220547e-02f, -7.05299899e-03f, -4.86085415e-02f, 3.06386221e-02f, 5.88422120e-02f, 1.77339807e-01f, 3.21663991e-02f, -4.80316728e-02f,
  1.16366260e-01f, 9.21988953e-03f, 1.14723772e-01f, 9.86423623e-03f, 1.15679547e-01f, -4.92341891e-02f, 6.00537173e-02f, 1.53373837e-01f, 1.50061399e-01f, 1.59095392e-01f,
  -6.24401942e-02f, 1.86577469e-01f, -1.41939953e-01f, -3.44660617e-02f, 2.07465515e-02f, 7.19538629e-02f, 9.85416323e-02f, 6.57876879e-02f, -5.18120490e-02f, -1.02602258e-01f,
  -6.50055483e-02f, -2.24738289e-02f, 6.96176216e-02f, 4.53215949e-02f, -7.32029378e-02f, -4.97195609e-02f, 3.57409194e-02f, 6.88527673e-02f, 1.50099667e-02f, -2.24452768e-03f,
  -2.71348935e-02f, -7.14611486e-02f, 4.79487479e-02f, -4.60746139e-03f, -5.57387061e-02f, -1.00598879e-01f, -9.52392817e-02f, 9.63965282e-02f, -6.04878627e-02f, -3.77402566e-02f,
  -1.14124514e-01f, -5.48442043e-02f, 3.30197327e-02f, -6.90465271e-02f, -2.15146206e-02f, 8.73054191e-03f, -8.03750306e-02f, 6.04369827e-02f, -8.71191993e-02f, -3.75960097e-02f,
  1.19295502e-02f, -1.11954406e-01f, -8.45973045e-02f, -4.33585644e-02f, -6.55452013e-02f, 3.13284434e-02f, 1.36321634e-01f, 3.34173478e-02f, -5.84203489e-02f, 1.18270898e-02f,
  -6.24442995e-02f, 4.50264290e-02f, -2.55171489e-02f, -1.50545016e-02f, -3.93614396e-02f, -2.78867595e-02f, -4.57531698e-02f, -1.06593996e-01f, -4.11117114e-02f, 5.73640689e-02f,
  -1.25463232e-01f, -8.67393464e-02f, 2.55041663e-02f, 2.91103777e-03f, 2.45545264e-02f, 5.28237149e-02f, 1.55508518e-02f, 3.07564642e-02f, 1.20473377e-01f, -2.72348467e-02f,
  -3.44614647e-02f, 1.06920421e-01f, 7.61539023e-03f, -9.63072106e-02f, -1.54734664e-02f, -1.11800738e-01f, -3.18730474e-02f, 4.89128977e-02f, 3.42896022e-02f, 1.70352850e-02f,
  3.19629684e-02f, -1.19980611e-01f, -1.59499437e-01f, -1.21619411e-01f, -1.56376436e-02f, -1.10183991e-01f, 4.54360284e-02f, -1.01398155e-02f, -4.79122205e-03f, -8.64423811e-02f,
  3.29836458e-01f, -3.08143318e-01f, -2.55371094e-01f, -1.72964662e-01f, -1.83500066e-01f, -1.89157441e-01f, -1.79278776e-01f, -1.13465093e-01f, -3.55290398e-02f, -1.57648236e-01f,
  -1.17332026e-01f, -8.70716106e-03f, -1.45267760e-02f, -4.45577763e-02f, -1.87407490e-02f, -1.76097795e-01f, -8.49630684e-02f, -5.00557460e-02f, -3.78055945e-02f, -1.38933480e-01f,
  -1.32525891e-01f, -1.74021944e-01f, 6.17969632e-02f, 5.45153487e-03f, -1.58913031e-01f, -7.68081546e-02f, -1.70194089e-01f, -4.74973656e-02f, -1.77450091e-01f, -1.71128318e-01f,
  -1.32788867e-01f, -6.48315549e-02f, 6.78398088e-03f, 6.66693896e-02f, -3.35469618e-02f, -7.06683379e-03f, -5.20471595e-02f, -4.55899872e-02f, 6.24596030e-02f, -3.35355885e-02f,
  2.28583422e-02f, 9.51093342e-03f, -3.21056284e-02f, -9.94063243e-02f, -9.20526460e-02f, -3.46325450e-02f, -6.53141886e-02f, 3.78067456e-02f, 6.96358904e-02f, -4.42782342e-02f,
  -6.86691627e-02f, 1.47349352e-03f, 1.35063864e-02f, 6.79548946e-04f, -5.85529618e-02f, -2.99134641e-03f, -3.73705514e-02f, 7.47720823e-02f, 1.40050398e-02f, -3.02117579e-02f,
  -3.30803730e-02f, 2.34033726e-02f, 2.04756800e-02f, 4.91373837e-02f, -4.77328897e-02f, 9.12592262e-02f, -1.05586378e-02f, 2.01559532e-02f, 6.60518482e-02f, 3.07013486e-02f,
  -5.63136814e-03f, -2.95321401e-02f, -1.04433345e-02f, -1.26761838e-03f, -6.67721331e-02f, 2.59812139e-02f, 5.15504330e-02f, -6.50445223e-02f, 4.67809178e-02f, 4.14426252e-02f,
  2.00680327e-02f, 2.42923014e-03f, -2.75736544e-02f, -2.21395157e-02f, 1.10533051e-02f, -2.27521118e-02f, 2.08505802e-02f, -7.80900940e-02f, -5.73969334e-02f, -4.94353399e-02f,
  -7.07822368e-02f, 1.99261248e-01f, -5.32074869e-02f, 5.60805351e-02f, 1.17392670e-02f, -3.59713547e-02f, -2.55838018e-02f, 4.32985537e-02f, 4.16325554e-02f, -4.46093641e-02f,
  -7.24526644e-02f, 2.96120327e-02f, -8.36708620e-02f, -3.92485745e-02f, 1.39932695e-03f, 1.39243931e-01f, 4.20478582e-02f, 1.04324780e-01f, 9.82817262e-02f, -4.68221903e-02f,
  4.88452837e-02f, 8.18229243e-02f, 2.18911543e-01f, 1.64444864e-01f, 1.32404476e-01f, 9.73455086e-02f, 5.86987771e-02f, 1.02537677e-01f, 1.54287219e-01f, 5.29094748e-02f,
  -4.74204719e-01f, 1.74179867e-01f, 6.10389672e-02f, -1.30861998e-01f, 1.85431968e-02f, -1.94534212e-02f, 7.11609190e-03f, -1.43506017e-03f, -1.24091111e-01f, 4.18110266e-02f,
  7.14332163e-02f, 2.64976565e-02f, 7.85266906e-02f, 1.22956242e-02f, -8.90949182e-03f, -1.18426979e-02f, -2.38357112e-02f, 2.90143769e-02f, -8.63517150e-02f, 3.18982340e-02f,
  1.28874229e-02f, -2.80069355e-02f, -4.91812564e-02f, -2.62133572e-02f, 1.00774549e-01f, 7.12105185e-02f, 3.17526720e-02f, 5.05542755e-02f, 2.79437210e-02f, 9.49734971e-02f,
  2.84436226e-01f, -1.11620612e-01f, 1.11504517e-01f, -2.95109283e-02f, -4.69148569e-02f, -2.57977601e-02f, -2.11660434e-02f, -9.62424278e-02f, -5.82796633e-02f, -2.44708117e-02f,
  -1.23822978e-02f, 4.50531989e-02f, -3.51662301e-02f, 1.57166813e-02f, -2.35492643e-02f, -7.08571896e-02f, -1.32152960e-01f, -2.60800719e-02f, 5.76256700e-02f, 1.98894553e-02f,
  -6.79488331e-02f, -5.26889674e-02f, 4.71049026e-02f, -9.48619936e-03f, -2.53743846e-02f, 7.41675077e-03f, 1.19144551e-01f, 3.62023674e-02f, 8.32296833e-02f, 1.56234026e-01f,
  4.84647453e-02f, 5.20055071e-02f, -8.72861370e-02f, -6.19860329e-02f, -9.99738462e-03f, 3.28815505e-02f, 8.31625983e-02f, 8.71029589e-03f, -4.39255163e-02f, -2.07252279e-02f,
  6.91859284e-03f, -3.98545340e-03f, -1.85160004e-02f, -5.59126437e-02f, 3.85206416e-02f, -9.25343297e-03f, 8.48406777e-02f, 2.59100106e-02f, -8.34309217e-03f, 6.04623137e-03f,
  2.48081889e-02f, -2.25392152e-02f, 8.01063776e-02f, 2.71799639e-02f, 2.40752520e-03f, -1.06104910e-01f, 1.18674524e-02f, -7.51023833e-03f, 1.54427607e-02f, -1.24500155e-01f,
  2.48603225e-01f, -1.70448169e-01f, 4.16374505e-02f, -1.77518814e-03f, 3.00919469e-02f, 5.32212574e-03f, 2.36641206e-02f, -1.27325073e-01f, -8.94008670e-03f, 3.16406079e-02f,
  5.78761473e-02f, 1.29164206e-02f, 2.23094262e-02f, 8.24707747e-03f, -6.20868653e-02f, 8.65287706e-02f, 3.98484915e-02f, 1.29231706e-01f, 1.23111665e-01f, 5.32427765e-02f,
  1.09480940e-01f, 7.71057978e-02f, 1.47541597e-01f, 1.49226159e-01f, 6.29076883e-02f, -4.89894859e-03f, 2.67834187e-01f, 1.16551802e-01f, 1.46216288e-01f, 2.47842014e-01f,
  -2.16407314e-01f, -6.04649901e-01f, 5.78253269e-02f, 1.31028250e-01f, 2.88605541e-01f, 4.69103098e-01f, 4.66289073e-01f, 2.65788615e-01f, 2.48885527e-01f, -9.77219194e-02f,
  -3.54052305e-01f, -2.11758539e-01f, -2.01519862e-01f, -1.50434762e-01f, -9.17153209e-02f, 2.84928560e-01f, 3.18519473e-01f, 7.23917782e-02f, 3.32560003e-01f, 1.34417579e-01f,
  6.49667159e-02f, -6.67626038e-02f, -2.44318917e-01f, -7.70563856e-02f, 5.28972000e-02f, 8.27452838e-02f, 6.88873902e-02f, 2.41327658e-02f, -8.68685544e-02f, 3.50573473e-02f,
  -1.53021023e-01f, -8.49321708e-02f, 1.48799181e-01f, -1.77418247e-01f, 8.14286352e-04f, -1.81317627e-02f, -1.60960797e-02f, -1.27673566e-01f, -1.23182759e-01f, 4.42143157e-03f,
  -4.87484150e-02f, -6.85205534e-02f, 5.04385419e-02f, 5.75214662e-02f, -2.45994646e-02f, 5.76628372e-04f, -1.21051386e-01f, -6.98797181e-02f, 3.16414386e-02f, -1.57248944e-01f,
  -2.02538986e-02f, -2.15670951e-02f, 7.16882274e-02f, 7.87704289e-02f, 1.14599153e-01f, 1.65990487e-01f, -1.82725579e-01f, 9.46730450e-02f, 4.43876684e-02f, -9.07796845e-02f,
  3.61937881e-02f, 4.28087935e-02f, 7.60645121e-02f, -4.62349728e-02f, 2.05266289e-02f, -1.12060609e-03f, 7.69676119e-02f, 5.20125870e-03f, 2.30883677e-02f, -1.65979490e-02f,
  -4.61597517e-02f, 7.48930266e-03f, 6.29037321e-02f, 5.70133030e-02f, 8.03710222e-02f, 1.44317672e-02f, 3.78356427e-02f, -7.91928098e-02f, -1.36360988e-01f, 2.45281663e-02f,
  -1.40392007e-02f, 1.36701822e-01f, -1.82406493e-02f, 9.79892095e-04f, -6.67953268e-02f, -2.34434735e-02f, 6.58940375e-02f, -6.66572899e-02f, -3.16939875e-02f, 7.76507184e-02f,
  -1.85562730e-01f, 6.03235839e-03f, 1.09194599e-01f, -1.98011361e-02f, 6.23481870e-02f, -8.79155621e-02f, -8.51450115e-02f, -1.08669296e-01f, 8.71216878e-03f, 3.24253440e-02f,
  -1.13045044e-01f, -1.95973013e-02f, -3.19271535e-02f, 1.47966631e-02f, 7.17156678e-02f, 8.53660610e-03f, -9.43034887e-02f, 8.25212896e-02f, -4.64819595e-02f, -6.88126609e-02f,
  -6.24518245e-02f, 2.08798468e-01f, 2.16552243e-01f, 1.44145444e-01f, 1.27270281e-01f, 9.17167887e-02f, 1.34912625e-01f, 4.44197766e-02f, 2.43804127e-01f, 6.37456551e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.05179751e-01f, 3.65679353e-01f, 1.01350114e-01f, -6.85114339e-02f, -1.26146719e-01f, 5.44721842e-01f, 1.13533340e-01f, -3.99720222e-02f, 3.06732714e-01f, 7.79798746e-01f,
  1.04907624e-01f, -8.14929511e-03f, -1.79570004e-01f, -7.78981224e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.39560670e-01f, 8.41056108e-02f, 5.74232638e-02f, -1.95238084e-01f, 1.82169020e-01f, -2.76772887e-01f, 3.45897116e-02f, 2.10385486e-01f, -1.75969660e-01f, -1.17784090e-01f,
  -2.45337412e-01f, -2.53065586e-01f, 5.20569757e-02f, 2.93334574e-01f, -3.06157649e-01f, 3.88978153e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.00819874e+00f, 1.77039430e-01f, 2.85834782e-02f, 8.41002703e-01f, -1.17178760e-01f, -5.27387671e-02f, -4.69520949e-02f, 2.36913666e-01f, 5.71578324e-01f, -3.04727972e-01f,
  8.52001131e-01f, -3.01366508e-01f, -1.25713319e-01f, -3.58339727e-01f, 3.73114586e-01f, -2.80038953e-01f, 4.28242207e-01f, 1.05583274e+00f, -2.89858222e-01f, -1.38528883e-01f,
  -7.37998933e-02f, -1.82513580e-01f, -2.53508538e-01f, 6.00213945e-01f, -3.39140564e-01f, -2.42932856e-01f, -5.30318141e-01f, 6.05935991e-01f, 2.60098130e-01f, -3.36457551e-01f,
  -3.16544771e-01f, 5.61762393e-01f, -1.03731140e-01f, -1.10152187e-02f, 2.45068833e-01f, -2.56140847e-05f, -2.90455762e-02f, -1.32501930e-01f, -1.52222827e-01f, -2.07716480e-01f,
  -1.23075657e-01f, -1.47208452e-01f, 1.84889734e-01f, 3.22277427e-01f, -2.59212971e-01f, -1.93910152e-01f, -2.15758666e-01f, 7.36995190e-02f, -1.69129983e-01f, 2.66026437e-01f,
  -1.46638192e-02f, 2.67482530e-02f, -2.00961187e-01f, 2.00586125e-01f, 1.19840346e-01f, 3.82473171e-01f, 8.05583820e-02f, -3.25342156e-02f, -1.27465189e-01f, 8.87922794e-02f,
  2.75602728e-01f, -1.75298825e-01f, 3.75399053e-01f, -1.81943789e-01f, 6.26069844e-01f, 5.15665948e-01f, 4.39633757e-01f, 1.23641595e-01f, 1.94138050e-01f, 5.83849698e-02f,
  -2.18277097e-01f, 1.19321656e+00f, 3.96918446e-01f, -7.98886642e-04f, -1.87096983e-01f, -3.58870387e-01f, 1.92190543e-01f, -6.78766668e-02f, -3.23886722e-01f, -2.77899861e-01f,
  -1.96634591e-01f, -1.21730253e-01f, 3.78307223e-01f, 3.63949388e-01f, -1.20343067e-01f, 1.39351085e-01f, -8.05112422e-02f, 6.85349926e-02f, -1.48368880e-01f, 2.75413483e-01f,
  -1.21651404e-01f, 1.07536599e-01f, 6.63732598e-03f, -2.81649157e-02f, 5.43667078e-02f, 6.96607605e-02f, -1.46393389e-01f, -3.55955541e-01f, 5.89557178e-02f, -3.29051256e-01f,
  3.88633274e-02f, 1.75815836e-01f, -1.75323598e-02f, -4.05027002e-01f, -2.08606601e-01f, 3.63270305e-02f, 1.23277515e-01f, 1.90018162e-01f, -2.20131092e-02f, 6.02439165e-01f,
  -2.98792213e-01f, 5.15833974e-01f, -6.56083180e-03f, 3.36762160e-01f, 2.28506580e-01f, -1.13786481e-01f, 1.03877589e-01f, 2.06924602e-01f, -6.33166637e-03f, 1.77935973e-01f,
  -4.76929918e-02f, -5.96804731e-02f, -1.50884598e-01f, -2.07893044e-01f, -1.02112755e-01f, -2.67730765e-02f, 2.27075126e-02f, -1.81429252e-01f, -2.57305056e-01f, -3.66803914e-01f,
  5.44783533e-01f, 5.10922074e-01f, 3.10875654e-01f, -2.41308719e-01f, -2.27268264e-02f, 3.98354262e-01f, 2.13847861e-01f, -9.48833972e-02f, 1.77751705e-01f, 7.39782691e-01f,
  1.14526421e-01f, 2.07110092e-01f, -2.34271869e-01f, -1.02301203e-01f, -1.73204407e-01f, -3.51154625e-01f, 5.00293672e-01f, 4.32295114e-01f, 1.18345067e-01f, -3.73019986e-02f,
  -1.22451007e-01f, -3.83847114e-03f, 2.07906395e-01f, 5.43949194e-02f, -7.49249607e-02f, 1.90499604e-01f, -1.63789243e-01f, -6.39795661e-02f, -1.39532492e-01f, 1.59531176e-01f,
  -9.27376077e-02f, 2.11300194e-01f, 2.41885841e-01f, 6.80440843e-01f, -7.90258422e-02f, 3.26084495e-02f, 1.81334853e-01f, 2.70541236e-02f, -8.09058826e-03f, -2.62722671e-01f,
  7.50724077e-02f, 7.35178113e-01f, 2.35433817e-01f, -1.32771000e-01f, -3.17354858e-01f, -2.48005480e-01f, -7.23177269e-02f, -5.42021453e-01f, 4.10161316e-01f, 7.07268894e-01f,
  2.36373305e-01f, 1.07097469e-01f, 2.92372674e-01f, 2.42395848e-01f, 1.62305392e-03f, 1.15629703e-01f, 3.74387145e-01f, 6.91941977e-01f, -3.74281585e-01f, 6.89648613e-02f,
  -2.29858637e-01f, 1.79222435e-01f, 3.99197340e-02f, 1.13845885e-01f, 1.03812546e-01f, 1.28877655e-01f, 3.07130486e-01f, -1.34613700e-02f, 1.64957568e-01f, 5.04808962e-01f,
  -2.84143209e-01f, -8.77607837e-02f, -5.02518192e-02f, 1.13845773e-01f, 5.42573594e-02f, 1.92156047e-01f, -5.26924506e-02f, 6.87326193e-01f, 1.86848864e-01f, -2.10154817e-01f,
  -2.20582467e-02f, -2.22520828e-02f, -8.22317600e-02f, -1.41242191e-01f, -1.69192702e-01f, -1.67194843e-01f, 1.23260207e-01f, -1.13295905e-01f, 1.20334607e-02f, 2.57852912e-01f,
  -7.05174133e-02f, 2.36403346e-01f, -2.99165975e-02f, -2.32814029e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.49903035e-01f, 5.66365242e-01f, -1.34681195e-01f, 4.77090776e-02f, 2.57615834e-01f, -2.12662563e-01f, 1.82455003e-01f, -1.42580867e-01f, 5.04318953e-01f, -1.17433220e-01f,
  2.84114361e-01f, 4.86250252e-01f, -1.02750547e-01f, -5.47040999e-02f
};

// L2_fan_Wp (Shape: 1 x 16)
const int L2_fan_Wp_rows = 1;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  3.34249660e-02f, 3.83116841e-01f, -1.30661756e-01f, 5.53186774e-01f, -1.42733708e-01f, 1.24225020e-01f, -6.15805611e-02f, -4.84515652e-02f, 1.17762670e-01f, 1.00880586e-01f,
  -4.72427964e-01f, -2.49142990e-01f, 4.24512615e-03f, 8.53438377e-02f, 4.53144342e-01f, -1.46297142e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 16)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -2.16491818e-02f, 1.71156093e-01f, 2.00389490e-01f, -1.55826613e-01f, -2.13868752e-01f, 6.68537617e-02f, -2.34490260e-01f, 1.16600588e-01f, -1.53938189e-01f, -2.16300264e-01f,
  -6.64697355e-03f, -2.23096162e-01f, -8.65669921e-02f, 8.54795799e-02f, -2.55064249e-01f, 1.22790173e-01f, 1.94888175e-01f, -1.07571751e-01f, -9.24317241e-02f, 1.73609063e-01f,
  2.40356803e-01f, -1.93467587e-01f, 5.22263423e-02f, -7.86452591e-02f, -8.77131671e-02f, -2.55612433e-01f, 1.20537728e-02f, 2.04513639e-01f, 4.98132370e-02f, -7.20426962e-02f,
  -8.97458121e-02f, 1.05769396e-01f, -1.58110801e-02f, -2.13744774e-01f, -2.00807559e-03f, -1.82283446e-01f, -5.38544469e-02f, -1.09746657e-01f, 9.19558033e-02f, -7.02941194e-02f,
  -2.15411544e-01f, 1.62417382e-01f, 1.80141985e-01f, -1.01692349e-01f, -7.16600418e-02f, -5.90147786e-02f, -1.68268800e-01f, -2.24073857e-01f, 8.71906459e-01f, -9.93935540e-02f,
  -6.16932452e-01f, 9.05595601e-01f, 1.91397429e-01f, -2.33221605e-01f, -5.94872415e-01f, -1.87248752e-01f, 6.44612312e-01f, -1.64278045e-01f, 5.94139457e-01f, 2.00213287e-02f,
  4.44314599e-01f, 3.43429476e-01f, -1.31405324e-01f, 2.19933018e-01f, 2.09744126e-01f, 2.73356643e-02f, 1.23376697e-01f, -1.59148380e-01f, 7.64970034e-02f, -1.48123175e-01f,
  -9.92186144e-02f, -1.75899088e-01f, -9.89744812e-02f, 1.14394195e-01f, -1.16139837e-01f, 9.39702094e-02f, -9.79423299e-02f, 2.06040025e-01f, -2.56530315e-01f, 1.28361031e-01f,
  1.31724551e-01f, 1.50439560e-01f, -1.32617489e-01f, -1.94610104e-01f, 1.53402150e-01f, -1.61122069e-01f, -1.44944653e-01f, -1.27625227e-01f, 2.46936738e-01f, 8.04412663e-02f,
  1.42403886e-01f, 2.67126560e-01f, 2.10255623e-01f, 3.59493881e-01f, 3.32376808e-02f, 8.47371966e-02f, 1.62152320e-01f, 3.19633037e-02f, -5.65041937e-02f, 1.32882878e-01f,
  2.31175914e-01f, -3.57350528e-01f, 7.58019686e-02f, 3.73729080e-01f, 2.08501488e-01f, 1.36253372e-01f, 7.46487677e-01f, 5.66000819e-01f, 3.61122370e-01f, 7.67222524e-01f,
  5.09502470e-01f, -1.14874229e-01f, -9.72550660e-02f, 2.98267990e-01f, 1.85566440e-01f, 1.74719959e-01f, -1.62793577e-01f, 1.27768889e-01f, 6.62037671e-01f, -8.60986114e-02f,
  -2.87174284e-01f, 1.55008420e-01f, 1.47361755e-01f, 9.96458381e-02f, 1.10098951e-01f, -1.48263082e-01f, -5.53966202e-02f, -2.79184431e-01f, 7.45094955e-01f, 3.85361016e-01f,
  7.02444673e-01f, 9.59777117e-01f, -1.93911240e-01f, 6.82978183e-02f, 9.81723666e-01f, -2.04858825e-01f, -3.24244678e-01f, 2.52583891e-01f, -3.67535069e-03f, -1.72988936e-01f,
  1.61308482e-01f, -5.92220426e-01f, -1.08840011e-01f, 1.96458042e-01f, 1.06338911e-01f, -4.82720286e-02f, 1.92549661e-01f, -1.64097384e-01f, -5.29280340e-04f, 1.08097732e-01f,
  2.32872173e-01f, 1.49223596e-01f, -3.24099839e-01f, -1.17676660e-01f, 2.82638431e-01f, 2.86051661e-01f, 4.38376039e-01f, 5.48974395e-01f, -2.37429932e-01f, 2.12118104e-01f,
  -2.04146816e-03f, 2.41099030e-01f, 1.04844697e-01f, 6.81670368e-01f, 1.84975222e-01f, 1.96316659e-01f, 8.22461665e-01f, -2.24516675e-01f, -1.08947411e-01f, 1.64411277e-01f,
  3.81492943e-01f, -5.52848689e-02f, 6.95663318e-02f, 1.49287432e-01f, 3.90356928e-01f, -2.65510827e-01f, 4.11045700e-01f, -1.59129072e-02f, 4.56806481e-01f, 6.69483691e-02f,
  1.37488544e-01f, -1.08608983e-01f, -3.88644457e-01f, -8.05014670e-02f, -1.09378926e-01f, 3.97584960e-02f, -2.27306053e-01f, -2.99269646e-01f, 1.20708853e-01f, 7.59039521e-02f,
  -1.65841118e-01f, -4.13086042e-02f, -1.42166093e-01f, -1.87927086e-04f, -8.88414457e-02f, -1.17429867e-01f, 7.86567107e-02f, 3.14540833e-01f, 4.70012799e-02f, 1.49510697e-01f,
  1.67479634e-01f, 5.97364306e-02f, 1.72865167e-01f, 4.86501902e-02f, 3.31470937e-01f, -1.87252507e-01f, 1.84729680e-01f, -1.31018713e-01f, 4.10573423e-01f, -7.86983252e-01f,
  1.40783501e+00f, -2.76407838e-01f, 1.19365446e-01f, -9.73493457e-02f, -9.81472433e-03f, -1.71013504e-01f, -5.03038883e-01f, -1.08879209e-01f, 5.98805368e-01f, -8.10120851e-02f,
  7.10974276e-01f, 4.26342934e-01f, -2.90171593e-01f, -2.43865848e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  8.32492560e-02f, -8.15505534e-03f, -1.57955974e-01f, 5.60311854e-01f, -3.90021168e-02f, 1.71293721e-01f, 2.54618645e-01f, 1.82553194e-02f, 6.83183491e-01f, -8.68475288e-02f,
  -4.48692814e-02f, 3.11852753e-01f, -7.91694745e-02f, 4.95475709e-01f
};

// L3_fan_Wp (Shape: 1 x 16)
const int L3_fan_Wp_rows = 1;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.27134040e-01f, -3.66058081e-01f, 1.70329273e-01f, -7.24364817e-02f, -1.11749656e-01f, 3.26389559e-02f, 1.76678792e-01f, -9.87576917e-02f, 5.35876416e-02f, -4.83052768e-02f,
  -2.76181787e-01f, 3.07840616e-01f, -2.20119432e-01f, -3.91755760e-01f, -1.50774226e-01f, 1.69738993e-01f
};

// L3_fan_Wp_bar (Shape: 14 x 16)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  3.89170200e-01f, 3.87063920e-01f, -1.28654182e-01f, 2.94779301e-01f, -6.24588728e-02f, 4.99430150e-01f, -2.45587647e-01f, 3.16807106e-02f, -3.35298866e-01f, -2.74387896e-01f,
  2.76257485e-01f, -1.66924763e-02f, -8.29097107e-02f, 3.00929755e-01f, 1.25233904e-01f, 1.36002049e-01f, -5.74601054e-01f, 4.69277561e-01f, -1.96475819e-01f, -8.15104023e-02f,
  -3.02490085e-01f, 5.51613629e-01f, -1.45203039e-01f, -3.01219933e-02f, 6.96286142e-01f, 2.85240680e-01f, 1.53736457e-01f, -2.53603518e-01f, 6.47791803e-01f, -4.68846373e-02f,
  -1.97852314e-01f, -4.06898052e-01f, -1.34819239e-01f, 1.55675933e-01f, -3.26051638e-02f, -1.22161038e-01f, 1.61235094e-01f, 4.34102923e-01f, 1.01705521e-01f, 2.92506486e-01f,
  3.29936951e-01f, -1.50433304e-02f, -5.91078848e-02f, -2.25630626e-01f, -1.95648849e-01f, -1.69574738e-01f, 9.53552779e-03f, -1.13756917e-01f, 9.45679769e-02f, 2.95626640e-01f,
  -1.85729399e-01f, -1.73753038e-01f, -1.48000941e-01f, 3.92835796e-01f, -1.59666985e-01f, -2.55744040e-01f, -2.08320484e-01f, -2.51825200e-03f, 1.10851176e-01f, -1.26470223e-01f,
  1.59852076e-02f, 6.60667419e-02f, 1.16423123e-01f, -1.06283657e-01f, 3.60373333e-02f, -1.73196688e-01f, 5.67635633e-02f, 1.85952216e-01f, 1.24261200e-01f, 5.08584715e-02f,
  1.25488952e-01f, -2.15482563e-01f, -2.26608366e-01f, 1.11690626e-01f, 1.85750037e-01f, 1.31661251e-01f, 2.09711298e-01f, 3.53199452e-01f, 4.32333238e-02f, 4.20609862e-01f,
  6.64799213e-01f, -7.04500377e-01f, 2.06021160e-01f, 2.09811106e-02f, 2.18080014e-01f, -6.51858449e-01f, 1.95332110e-01f, -3.32369804e-01f, -7.40231276e-01f, -8.44002068e-02f,
  7.04383790e-01f, -2.16325074e-01f, -1.97812960e-01f, 2.59439021e-01f, -3.45812857e-01f, 1.03594911e+00f, -2.94616759e-01f, 3.21173519e-02f, -3.25178027e-01f, -2.10064322e-01f,
  1.45725176e-01f, -2.44550034e-01f, -2.83624798e-01f, -2.21664742e-01f, 3.75947922e-01f, 2.81898826e-01f, 5.11053562e-01f, 4.87263829e-01f, 2.98067093e-01f, -2.70608157e-01f,
  2.34597519e-01f, 6.24918342e-01f, 8.06621075e-01f, 7.96835780e-01f, -1.11904964e-01f, 1.85926154e-01f, -1.94293842e-01f, 6.33953333e-01f, 2.41607912e-02f, -1.88955188e-01f,
  -1.29437372e-02f, 1.57195941e-01f, 1.18141711e+00f, -1.45366296e-01f, 3.26258928e-01f, -7.72737898e-03f, 1.02614149e-01f, -2.14841872e-01f, 3.64160448e-01f, -5.85402131e-01f,
  1.68768712e-03f, 1.67809859e-01f, -1.52434826e-01f, 9.25952315e-01f, -1.22928210e-02f, -1.25446254e-02f, 1.69812799e-01f, -4.92874146e-01f, -3.78579289e-01f, 9.15211737e-02f,
  -5.16535699e-01f, 4.21851248e-01f, 3.81509811e-02f, 2.82136261e-01f, -7.87505228e-03f, 1.75679103e-01f, 1.94310620e-01f, -7.92890936e-02f, 1.63492799e-01f, 3.44789058e-01f,
  1.81213260e-01f, 1.91887259e-01f, 3.53237271e-01f, -2.11875826e-01f, -2.36630484e-01f, -2.03559339e-01f, -1.67239740e-01f, -1.06213950e-01f, -8.85782242e-02f, -3.15385431e-01f,
  1.38493851e-01f, -8.16020846e-01f, -4.99768481e-02f, -6.42949641e-02f, 2.29328200e-01f, -2.38601461e-01f, 2.11680681e-01f, 1.24532357e-01f, 5.44993579e-01f, 5.90040125e-02f,
  -3.42697591e-01f, 2.83366978e-01f, -2.46403903e-01f, 1.99388206e-01f, 3.71026509e-02f, 1.37826550e+00f, 2.07429323e-02f, 1.87872767e-01f, 6.14833236e-02f, 1.36537567e-01f,
  4.96487878e-02f, -6.17959321e-01f, 2.32391730e-02f, -2.77999789e-01f, -1.43068254e-01f, 3.91076863e-01f, 8.85912061e-01f, -8.94389004e-02f, 7.10620761e-01f, -1.03535689e-01f,
  1.39475226e-01f, -1.21257834e-01f, -2.33491540e-01f, -5.74819803e-01f, 1.56981107e-02f, 1.83948129e-01f, -1.21541753e-01f, 1.41221002e-01f, 1.50433937e-02f, 3.02415341e-01f,
  3.44221056e-01f, -1.57123774e-01f, -3.59685391e-01f, 5.42598307e-01f, 2.14096412e-01f, -3.52660869e-03f, -2.00255942e-02f, 6.21966243e-01f, -3.74740750e-01f, 1.10909060e-01f,
  1.91835314e-01f, 2.01541677e-01f, 8.36879089e-02f, -6.15192205e-02f, -1.32528782e-01f, -2.61110924e-02f, 2.00227425e-01f, -1.11224309e-01f, -2.99670488e-01f, 1.29581243e-01f,
  -5.71804047e-02f, 1.21467084e-01f, 6.88924789e-02f, 9.30744559e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  2.91999221e-01f, 2.18354732e-01f, 2.83716977e-01f, 2.97997631e-02f, -9.04894024e-02f, 4.36653435e-01f, -3.79912913e-01f, 9.14379776e-01f, 6.11896992e-01f, 5.53339114e-03f,
  3.35611552e-01f, -7.61752129e-02f, 2.90172547e-01f, -1.26617640e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  -7.31523216e-01f, 1.61477745e-01f, -3.41804445e-01f, -9.49917659e-02f, 1.27567157e-01f, 6.14295416e-02f, -2.56895304e-01f, -8.41784596e-01f, 3.85381520e-01f, -9.16388392e-01f,
  4.56793495e-02f, -2.02201068e-01f, 6.45719528e-01f, 1.55888826e-01f, 4.32126939e-01f, 4.35499877e-01f, 4.73647743e-01f, 7.13890851e-01f, 1.77074671e-01f, -1.03441731e-03f,
  3.49760801e-01f, 5.39285690e-02f, -1.29715004e-03f, -5.99373132e-02f, -4.81918544e-01f, 1.54535577e-01f, 8.58919740e-01f, 3.68307620e-01f, -6.84921369e-02f, -4.11047459e-01f,
  8.57541487e-02f, -2.47191805e-02f, 6.30275846e-01f, -3.25730592e-01f, -1.87696263e-01f, -5.31476259e-01f, 3.49238068e-02f, 6.83656409e-02f, 2.39496514e-01f, 6.12266719e-01f,
  4.62800562e-01f, 2.57197410e-01f, -3.03470343e-01f, 8.35036412e-02f, 9.75860432e-02f, 1.05544187e-01f, 1.48656160e-01f, 1.30048499e-01f, -4.76692617e-01f, 1.45089790e-01f,
  4.60881330e-02f, 2.35271931e-01f, 7.98154343e-03f, 1.28537253e-01f, 8.60290527e-02f, -2.07869709e-02f, 6.80975258e-01f, -3.14467460e-01f, -5.76562226e-01f, -1.08264543e-01f,
  4.55908626e-01f, 1.74576808e-02f, 1.88256010e-01f, -7.50388205e-02f, -3.57337564e-01f, 3.18577975e-01f, -2.75551915e-01f, -9.18937773e-02f, -9.64707043e-03f, -4.67104241e-02f,
  3.54043424e-01f, 4.91988212e-01f, 3.92260104e-01f, -6.20772243e-01f, 2.06370622e-01f, 2.74781346e-01f, 3.91770929e-01f, -4.50185299e-01f, 3.51983398e-01f, 1.09175563e-01f,
  7.43151382e-02f, 6.69977427e-01f, -1.04626819e-01f, -3.72881711e-01f, 1.59125939e-01f, -1.12069830e-01f, -1.45435765e-01f, 2.86051482e-02f, -4.59808499e-01f, -4.98145640e-01f,
  7.00809002e-01f, 8.11545998e-02f, 6.31954372e-01f, -4.04155254e-01f, 5.96281886e-01f, -2.49962598e-01f, 2.16595717e-02f, -7.22073019e-01f, 4.66126680e-01f, 1.68246832e-02f,
  6.70422316e-02f, 5.05915046e-01f, -1.43983394e-01f, -3.99645209e-01f, -4.19680774e-02f, 1.04322994e+00f, -5.15459239e-01f, -1.41662940e-01f, -7.37056613e-01f, 7.52306059e-02f,
  -4.98891383e-01f, -2.11748287e-01f, -5.81045449e-01f, -3.48444544e-02f, -6.02002501e-01f, 8.77761483e-01f, 1.44972622e-01f, 5.26505150e-02f, -7.87460059e-02f, -4.50162560e-01f,
  2.44827718e-01f, -3.59161571e-02f, -4.57715362e-01f, 4.32334170e-02f, -3.99132520e-01f, 8.79978836e-01f, 1.73791453e-01f, -3.91939990e-02f, 5.15395701e-01f, -4.24063861e-01f,
  1.39524609e-01f, 7.43348539e-01f, 5.04416704e-01f, 1.59954593e-01f, -3.76403630e-01f, -5.42964578e-01f, -4.36362356e-01f, 4.74063039e-01f, 1.54023826e-01f, 2.27547854e-01f,
  -1.03278422e+00f, -3.51085305e-01f, -4.09737706e-01f, 1.34307742e-01f, -7.09618330e-02f, -4.13365126e-01f, 1.22488230e-01f, -4.04966563e-01f, -1.18014244e-02f, -1.38412327e-01f,
  -1.25700338e-02f, 6.64771616e-01f, 1.29648030e-01f, 5.90621650e-01f, -2.85638809e-01f, -2.82044187e-02f, -5.71436703e-01f, 6.96887910e-01f, -6.27994537e-01f, -1.53981119e-01f,
  4.29200381e-01f, 5.70146516e-02f, 8.71729106e-02f, -4.13517267e-01f, -1.61260054e-01f, -2.09542483e-01f, 3.10422271e-01f, 1.18948007e+00f, -3.96847904e-01f, -5.90954721e-01f,
  2.01084957e-01f, -3.48406971e-01f, 5.72235107e-01f, -2.39230558e-01f, -1.07386149e-01f, -2.08065420e-01f, 1.79483607e-01f, -1.49618641e-01f, 3.77325565e-01f, 1.62457809e-01f,
  -1.44470453e-01f, 1.32060006e-01f, 2.73398995e-01f, -5.22880256e-01f, 4.37238723e-01f, 4.41021532e-01f, 9.42725390e-02f, -1.79209128e-01f, -1.02696680e-01f, -4.59256500e-01f,
  9.35085639e-02f, -2.85887271e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -7.40491524e-02f, 6.54627562e-01f, -4.73699421e-02f, -1.85092330e-01f, -3.19746882e-01f, 4.97096211e-01f, 1.77381679e-01f, -3.09387535e-01f, 9.27719399e-02f, 8.10091347e-02f,
  -6.71258569e-02f, 5.24953716e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    