/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.93022126e-01f, -3.11555535e-01f, 4.19673353e-01f, 1.89343482e-01f, 1.27204537e-01f, 1.84908658e-01f, 9.68378261e-02f, -8.01659599e-02f, 8.56530443e-02f, 1.02781862e-01f,
  -2.18331859e-01f, -1.30656391e-01f, -5.03744371e-02f, -4.96369787e-03f, -1.08699352e-01f, 1.02881342e-01f, 2.38385394e-01f, 1.93064108e-01f, 8.69241133e-02f, -1.10434601e-02f,
  -6.62299171e-02f, -5.80276176e-02f, -8.64994228e-02f, -1.96391732e-01f, 1.21787645e-01f, 1.66950703e-01f, -3.21995765e-02f, -1.04430787e-01f, 1.49019547e-02f, 3.45965177e-01f,
  3.79492909e-01f, -1.27503544e-01f, 9.95898299e-05f, -1.06823139e-01f, -4.46100300e-03f, -4.56299111e-02f, 4.45738100e-02f, 4.88036200e-02f, -3.30998152e-02f, 3.24583501e-02f,
  -1.96152665e-02f, 5.87344822e-03f, -7.77739882e-02f, 1.46996193e-02f, -5.50618544e-02f, -5.35324914e-03f, -4.68285307e-02f, 2.86579644e-03f, 9.07393321e-02f, 1.68133266e-02f,
  -5.76807708e-02f, -2.09511500e-02f, 1.00143002e-02f, -9.46067739e-03f, -2.70301756e-02f, 6.32972643e-03f, -5.59661239e-02f, -4.61767539e-02f, -2.22596154e-03f, -2.25212779e-02f,
  -1.98636688e-02f, -2.42778938e-02f, 8.23598653e-02f, -3.67452912e-02f, -6.22106120e-02f, 2.60230117e-02f, 4.71333712e-02f, 5.55444788e-03f, -1.17098279e-02f, -5.31038567e-02f,
  7.68708764e-03f, 9.20770317e-02f, -2.89253071e-02f, 3.01481187e-02f, 4.63666990e-02f, -2.10103877e-02f, -2.36873701e-02f, 1.80238504e-02f, -5.92653379e-02f, 2.35178489e-02f,
  -2.08422430e-02f, -4.92956564e-02f, 3.51797119e-02f, -4.28867042e-02f, 9.16775968e-03f, 2.82413308e-02f, 3.52327116e-02f, -4.35808226e-02f, 3.46158422e-03f, -8.03650469e-02f,
  -4.03420888e-02f, -4.51065153e-02f, 1.17987223e-01f, -1.09453641e-01f, 5.44022843e-02f, -4.81765382e-02f, 6.07239129e-03f, -5.31682149e-02f, 6.55055493e-02f, 7.19412789e-03f,
  -5.22732399e-02f, -6.02776604e-03f, -7.95626640e-03f, -3.89791802e-02f, 9.65380371e-02f, 4.64739986e-02f, -2.10590437e-02f, 2.66306419e-02f, -8.50903839e-02f, 4.76454711e-03f,
  3.10899428e-04f, 1.60360411e-02f, 1.46884337e-01f, 1.07782349e-01f, -8.16413462e-02f, 6.02163225e-02f, -1.63497739e-02f, 7.15836063e-02f, 1.73602309e-02f, 9.73181501e-02f,
  -4.82298523e-01f, 2.88959563e-01f, 1.84454247e-02f, 9.39129014e-03f, 2.46174976e-01f, 1.02934808e-01f, 7.00784326e-02f, 9.05707553e-02f, 1.01086227e-02f, 1.18415490e-01f,
  1.78044900e-01f, 3.23007256e-02f, 3.86784635e-02f, 4.09817621e-02f, -4.34073955e-02f, 2.35703755e-02f, 1.06396079e-01f, -2.14185193e-01f, -2.44384274e-01f, -2.21464802e-02f,
  4.85144854e-02f, -1.67752653e-01f, -1.24626018e-01f, -7.82675520e-02f, 6.98416457e-02f, 1.49073743e-03f, 1.35226905e-01f, 4.86786179e-02f, 1.41751274e-01f, -4.52371538e-02f,
  -4.86231372e-02f, 3.12167615e-01f, -2.52055284e-02f, -2.64614093e-04f, 8.90144557e-02f, -6.38453588e-02f, -7.51637518e-02f, -1.02385124e-02f, -3.28564201e-03f, 2.06680354e-02f,
  5.47293574e-02f, 9.01647436e-04f, 1.30435824e-02f, -2.71815900e-02f, 7.04995543e-03f, 2.43469644e-02f, 5.63118653e-03f, 7.59595558e-02f, 8.80422443e-02f, 9.45842490e-02f,
  6.61617517e-02f, 1.44607335e-01f, 1.11349382e-01f, 5.52942604e-03f, 1.04361717e-02f, 3.28709814e-03f, 1.78261906e-01f, 1.14294931e-01f, 1.76542625e-01f, -5.35786822e-02f,
  -3.15510258e-02f, 4.74595204e-02f, -7.64352269e-04f, -1.99571066e-02f, 1.18123386e-02f, -1.22330803e-03f, -6.69278726e-02f, -1.05413664e-02f, 3.54667678e-02f, -4.94653136e-02f,
  1.10489279e-02f, 1.58085991e-02f, -4.81294021e-02f, 2.84213852e-02f, -2.57379562e-02f, 2.81127580e-02f, 4.38605109e-03f, 1.68805085e-02f, 3.81086245e-02f, -8.22398812e-03f,
  -1.35671033e-03f, 5.37418239e-02f, 2.25255862e-02f, -4.92635965e-02f, 4.13213372e-02f, -6.50603548e-02f, 1.97264133e-04f, 3.12324129e-02f, -1.30066799e-03f, 5.30056208e-02f,
  -1.69191748e-01f, 8.10686946e-02f, -5.88588901e-02f, -4.17848416e-02f, -6.52795881e-02f, 1.78851075e-02f, 3.93450968e-02f, 6.30378164e-03f, -2.19624583e-02f, 8.81584920e-03f,
  -1.42386314e-02f, -9.19742808e-02f, -2.17405017e-02f, -1.46717462e-03f, -8.82334560e-02f, 1.42158242e-02f, -5.15077189e-02f, -7.68912062e-02f, 2.99953707e-02f, 6.56584427e-02f,
  2.29252409e-03f, -5.41079789e-02f, -1.75253183e-01f, 1.60968129e-03f, -7.44251243e-04f, -8.49941075e-02f, -1.21875830e-01f, -4.22837920e-02f, -1.55013427e-01f, -1.62746593e-01f,
  -5.16561806e-01f, 7.64383748e-02f, 3.60355139e-01f, -1.56407058e-01f, 3.31817120e-01f, 3.04150850e-01f, 3.22620600e-01f, 1.01484448e-01f, -1.45279497e-01f, -7.75956139e-02f,
  8.23797360e-02f, -5.03906012e-02f, -1.50325164e-01f, -1.19910732e-01f, 3.10011208e-02f, -2.26828586e-02f, 4.51558071e-06f, -1.58440709e-01f, 1.34021893e-01f, 1.07030533e-01f,
  -7.97382668e-02f, -7.25436732e-02f, -2.21143857e-01f, -6.17840700e-02f, -4.42975275e-02f, -2.31106713e-01f, 7.98201002e-03f, 3.72815095e-02f, 1.01941667e-01f, -4.74285036e-01f,
  -1.54600531e-01f, 8.61439854e-02f, -8.05523247e-02f, -1.61916763e-01f, 6.43000156e-02f, 4.47228504e-03f, -5.53237237e-02f, -9.32750329e-02f, 3.66864689e-02f, -8.79792944e-02f,
  -9.69316810e-03f, -1.80685762e-02f, 4.47774082e-02f, 7.78348818e-02f, 4.23174128e-02f, 1.02811703e-03f, -1.45553118e-02f, -4.84835617e-02f, -2.88554374e-02f, 8.36157054e-02f,
  -1.48141747e-02f, 9.60522890e-02f, 1.85636029e-01f, 1.09340183e-01f, 1.23581387e-01f, 4.78333561e-03f, 4.37252447e-02f, -4.21026312e-02f, 6.79618418e-02f, -2.84420788e-01f,
  -1.01490185e-01f, -1.51790325e-02f, 5.94037864e-03f, 1.60275325e-02f, -2.25065816e-02f, -7.96260871e-03f, 5.55088650e-03f, -3.74198928e-02f, -2.66318396e-02f, 5.75875910e-03f,
  -6.90959350e-05f, -3.38943005e-02f, 2.08246354e-02f, 2.73817834e-02f, -1.80786904e-02f, 3.30432244e-02f, 3.25226821e-02f, -3.44460122e-02f, 3.55897397e-02f, -2.96580754e-02f,
  -4.19420376e-02f, -6.52170628e-02f, -2.04284675e-02f, -8.90351310e-02f, -4.26384577e-05f, -4.00471836e-02f, -1.85740758e-02f, 5.58026321e-02f, 9.32557732e-02f, 2.46167406e-02f,
  -9.79666114e-02f, 9.87545252e-02f, -2.01381579e-01f, -5.41668646e-02f, 1.73132326e-02f, 7.45640602e-03f, -1.23476852e-02f, -2.17655636e-02f, 2.14377679e-02f, -2.74498705e-02f,
  4.56335675e-03f, -1.77976452e-02f, -9.31410771e-03f, -4.82596979e-02f, -1.70204677e-02f, 1.62505414e-02f, 4.03472632e-02f, -5.68992905e-02f, -1.53417652e-02f, -1.09911030e-02f,
  -2.17605280e-04f, -1.51997041e-02f, 1.03205545e-02f, -1.61885470e-02f, -5.51866926e-03f, -1.15035109e-01f, 8.03313106e-02f, 1.95279233e-02f, 2.84864823e-03f, -9.01959538e-02f,
  1.92411944e-01f, -7.32584968e-02f, 1.27135264e-02f, -4.78668362e-02f, 1.16069680e-02f, 1.41106518e-02f, -1.06355250e-01f, -1.13233831e-02f, 3.06737442e-02f, -1.42885312e-01f,
  5.08996211e-02f, 1.79528683e-01f, 5.88040613e-02f, 1.59870759e-01f, 9.40655991e-02f, -2.12982714e-01f, -1.48197055e-01f, 1.28650498e-02f, -6.62983209e-02f, 2.78503145e-03f,
  -1.82428107e-01f, -1.97170898e-02f, 1.34168476e-01f, 1.85190618e-01f, -2.92742968e-01f, -1.54494867e-01f, -9.98492390e-02f, -1.15957074e-02f, -1.75583303e-01f, -6.91551507e-01f,
  -1.71330497e-02f, 1.08253658e-01f, -2.18334366e-02f, -5.52610755e-02f, 6.71058707e-03f, -8.52135289e-03f, 5.04087619e-02f, -3.40284333e-02f, 2.32467800e-02f, 1.25250751e-02f,
  1.91951301e-02f, 1.26077058e-02f, -2.76822727e-02f, 4.80647618e-03f, 1.28879892e-02f, -6.70614913e-02f, -1.13893785e-02f, -4.69665341e-02f, -1.08950868e-01f, -6.01499155e-02f,
  -8.36767107e-02f, 6.82988856e-03f, 2.50083134e-02f, 7.42715970e-02f, 4.18735370e-02f, -3.51959355e-02f, 3.53346057e-02f, -4.65974696e-02f, -2.38958281e-02f, -3.01530123e-01f,
  -3.07849832e-02f, -1.03483619e-02f, 6.79482073e-02f, -4.15846817e-02f, 2.48476653e-03f, 1.21576637e-02f, 1.33513100e-02f, 1.39324320e-02f, -5.23242727e-02f, -7.97161907e-02f,
  2.24217996e-02f, -5.03746532e-02f, 2.80295983e-02f, -6.68181330e-02f, -6.06383346e-02f, -3.91565561e-02f, 4.46483633e-03f, 2.41980441e-02f, 2.45611537e-02f, 3.61087285e-02f,
  -1.09044135e-01f, 1.11146597e-02f, -2.49935780e-02f, 1.25703216e-02f, -1.40123349e-02f, 4.79645543e-02f, -1.55628962e-03f, -3.09128556e-02f, -1.72118153e-02f, -1.56299025e-02f,
  6.00772761e-02f, 1.29091099e-01f, 1.02502685e-02f, -4.66018431e-02f, -3.74911018e-02f, 5.13434038e-02f, 6.26470223e-02f, 2.84953564e-02f, 8.15238953e-02f, 5.79971867e-03f,
  3.76068950e-02f, 2.43916437e-02f, 1.26071617e-01f, -2.15444025e-02f, 2.27457117e-02f, 5.36081716e-02f, 2.87898704e-02f, -1.58451498e-02f, 4.92622964e-02f, -2.40090284e-02f,
  -1.70923676e-02f, -1.01632088e-01f, -3.51200788e-03f, -3.50347534e-02f, 1.58460196e-02f, -3.76008973e-02f, -2.36868765e-02f, -1.26565114e-01f, 6.25880212e-02f, -2.35970318e-01f,
  6.23855650e-01f, -7.03392476e-02f, 8.48252028e-02f, -1.54396230e-02f, -9.59377587e-02f, -1.24818936e-01f, -3.71763885e-01f, -5.54921031e-02f, 2.33083591e-02f, -5.98716214e-02f,
  1.60306364e-01f, 1.58819005e-01f, 1.79067031e-01f, 1.48051724e-01f, 5.89301512e-02f, -2.82818556e-01f, -2.47136593e-01f, 2.00013462e-02f, 3.33714066e-03f, -7.38126487e-02f,
  -1.37806714e-01f, -7.78575391e-02f, 1.70915768e-01f, 6.12251610e-02f, -4.10828255e-02f, -1.53762385e-01f, -1.49950152e-02f, 1.21144310e-01f, 7.85341263e-02f, 4.55778986e-02f,
  1.66457266e-01f, 2.30113015e-01f, -5.85442893e-02f, 3.90433185e-02f, -7.33850747e-02f, -5.77873811e-02f, -4.15345142e-03f, -3.10396478e-02f, -3.67455743e-02f, -1.13054924e-02f,
  -6.41158447e-02f, 6.06782697e-02f, -3.36226672e-02f, 2.07618494e-02f, -7.69940913e-02f, 3.15641500e-02f, -6.89215586e-02f, 8.26073959e-02f, -5.15106581e-02f, -3.52307968e-02f,
  -8.64572003e-02f, 3.45021822e-02f, 2.67306864e-02f, -4.85433191e-02f, 2.76034651e-03f, 1.87692791e-02f, 4.62698489e-02f, 6.01609983e-02f, 4.24284413e-02f, -8.49861559e-03f,
  5.12913093e-02f, -3.96192586e-03f, 4.82015088e-02f, 3.26583907e-02f, -8.83405283e-03f, 5.56744561e-02f, 2.72029880e-02f, -3.53843905e-02f, 3.96888331e-02f, -4.57102805e-02f,
  6.87815696e-02f, -5.70516251e-02f, -1.03436839e-02f, -5.26596121e-02f, 4.14368622e-02f, -2.47040461e-03f, -6.43473268e-02f, -5.12695219e-03f, 7.92456195e-02f, 7.90419243e-03f,
  2.36742403e-02f, -2.31236499e-03f, 5.08413184e-03f, 6.08926639e-03f, 2.93051600e-02f, 2.12506577e-02f, -1.71115678e-02f, 1.21559890e-03f, -2.77217533e-02f, 3.02518588e-02f,
  -3.70193034e-01f, 1.46459475e-01f, -7.94464536e-03f, -6.16912283e-02f, 2.21439414e-02f, 7.33586401e-02f, 2.36423742e-02f, 1.53715340e-02f, -1.64238121e-02f, -6.06195144e-02f,
  4.13532974e-03f, -3.06959469e-02f, 3.45713086e-02f, -1.61931142e-02f, -7.01102093e-02f, -8.74131024e-02f, -5.42880334e-02f, -5.96931502e-02f, -4.10658084e-02f, -4.33127582e-02f,
  -1.23859569e-01f, -1.91535994e-01f, -2.16737717e-01f, -1.23515069e-01f, -7.26277381e-02f, -1.01987824e-01f, -1.50489897e-01f, -2.13314235e-01f, -6.93846196e-02f, -3.70890647e-01f,
  1.48828119e-01f, -5.07922232e-01f, -1.05339952e-01f, -4.54497002e-02f, 1.04394548e-01f, 8.32692757e-02f, 2.61565181e-03f, 4.40662876e-02f, 1.21459678e-01f, -2.21176907e-01f,
  -7.53745735e-02f, 1.96518853e-01f, 5.90165891e-02f, 1.02464862e-01f, 6.42542467e-02f, -1.97913289e-01f, -1.42278314e-01f, -5.47715463e-03f, 3.30653161e-01f, 2.50536889e-01f,
  1.18622907e-01f, -7.50429183e-02f, -1.08549967e-01f, 4.16133329e-02f, -1.24087162e-01f, 1.57068416e-01f, -1.53984621e-01f, -1.56167597e-01f, -1.12793081e-01f, -4.01636302e-01f,
  -4.00554575e-02f, -2.51083463e-01f, 1.92463085e-01f, 3.82875316e-02f, -7.32771829e-02f, 2.04768740e-02f, 4.45787646e-02f, -6.53755665e-02f, 3.08893267e-02f, -3.47950421e-02f,
  -4.84405309e-02f, -6.85523450e-02f, -5.12903482e-02f, 7.52819702e-03f, -1.06792711e-01f, 2.63962205e-02f, -1.04857557e-01f, -6.86184615e-02f, -6.82715327e-02f, -2.20689382e-02f,
  3.27436998e-02f, 1.97732858e-02f, -6.36779442e-02f, 6.46551847e-02f, 9.97672677e-02f, 7.06890076e-02f, -4.59321961e-02f, 8.12130980e-03f, 3.41324918e-02f, -1.37247920e-01f,
  2.40550507e-02f, -3.28672640e-02f, 2.91820318e-02f, -2.66537722e-03f, -4.49260212e-02f, 4.37350720e-02f, -2.16637831e-02f, 1.05230894e-03f, 6.06504232e-02f, -7.93595333e-03f,
  -5.34473211e-02f, 5.23345433e-02f, -2.33593881e-02f, 6.78188354e-03f, 6.71894150e-03f, -5.03218956e-02f, 1.62298810e-02f, -5.63847758e-02f, 4.43672463e-02f, -9.97946113e-02f,
  6.46935180e-02f, 3.98204196e-03f, -1.08178360e-02f, -4.90619615e-02f, 1.38489099e-03f, -5.56263840e-03f, 3.68242227e-02f, 1.65680666e-02f, 2.89817974e-02f, -1.99039802e-02f,
  -2.51741093e-02f, 1.31885365e-01f, -8.48888680e-02f, 2.39457767e-02f, -4.38265502e-02f, -1.32214231e-02f, -2.31672805e-02f, -1.97770596e-02f, -2.41193175e-03f, -3.07792816e-02f,
  -2.43170280e-02f, 5.71939312e-02f, -1.16278358e-01f, -5.85655756e-02f, 4.64924909e-02f, 7.02521577e-02f, -4.88976995e-03f, 4.91279736e-02f, 6.32592961e-02f, -4.52344818e-03f,
  3.15238796e-02f, 5.52786477e-02f, 1.18441090e-01f, 5.81658781e-02f, 2.84731183e-02f, 1.82304606e-01f, -2.56662760e-02f, 4.53212634e-02f, 1.20302312e-01f, -9.28961113e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.94404322e-01f, 4.72713023e-01f, -1.93336591e-01f, -1.15194708e-01f, 3.93731654e-01f, -2.84621418e-02f, 1.93797186e-01f, -1.70062870e-01f, 1.09786531e-02f, 7.57704377e-02f,
  7.41865560e-02f, -7.28587881e-02f, 6.40627444e-02f, 3.18298601e-02f, -2.54240274e-01f, 2.68404901e-01f, 4.06654686e-01f, -2.93805599e-01f, -6.61076665e-01f, -3.84591162e-01f,
  1.93780571e-01f, -6.83287457e-02f, -3.51474047e-01f, -2.15934545e-01f, 2.70969301e-01f, 3.90160978e-02f, 2.27774233e-01f, -1.79559942e-02f, 1.86549053e-01f, 4.18952227e-01f,
  -2.87475716e-02f, -7.08000809e-02f, -7.17221871e-02f, -1.44823819e-01f, 7.19875991e-02f, -6.47141188e-02f, 4.64926660e-02f, -7.77953118e-02f, 1.24505619e-02f, -7.03856628e-03f,
  3.46458778e-02f, -9.04598013e-02f, -3.75572480e-02f, -1.28037155e-01f, -1.19543420e-02f, -1.88075099e-02f, -6.47538900e-02f, -3.08494091e-01f, -1.93558991e-01f, -6.51842356e-02f,
  3.42639774e-01f, 1.06895030e-01f, -1.24892658e-02f, -7.79382735e-02f, -9.62830260e-02f, -1.36380404e-01f, -1.61136523e-01f, -1.94072500e-01f, -2.02658519e-01f, -9.77241769e-02f,
  -2.26579141e-03f, 4.27053533e-02f, 7.91838542e-02f, 3.08231320e-02f, 6.73117563e-02f, 5.64811118e-02f, 6.05604351e-02f, -3.30085941e-02f, 7.49579025e-03f, 3.19667980e-02f,
  -5.68319261e-02f, 5.33180572e-02f, 1.49801625e-02f, -9.47370231e-02f, 2.13878714e-02f, 1.36829000e-02f, -4.92730141e-02f, -3.10755782e-02f, 4.02839249e-03f, -1.82613302e-02f,
  -7.85349607e-02f, 4.62426879e-02f, 4.46539707e-02f, -7.32358322e-02f, 3.34497467e-02f, -3.58100049e-02f, 8.05161544e-04f, -1.14786558e-01f, -3.31817307e-02f, 4.21645604e-02f,
  1.71214156e-02f, 3.63708511e-02f, -3.30337510e-02f, 1.63879432e-02f, -4.75089476e-02f, 1.83347408e-02f, 9.30328295e-03f, -1.80607177e-02f, 6.59527332e-02f, -7.70726651e-02f,
  -1.38422325e-01f, 2.21617557e-02f, 3.05813346e-02f, -1.46181164e-02f, -1.66637927e-01f, -1.88793149e-02f, 9.70601365e-02f, 4.66317981e-02f, -2.88671665e-02f, -3.29587571e-02f,
  6.72730356e-02f, 3.64948511e-02f, 4.30941768e-03f, 1.87236685e-02f, 9.54181254e-02f, 1.00046158e-01f, 2.71891337e-02f, -1.24650318e-02f, -2.78539751e-02f, 1.25686884e-01f,
  -1.22757816e+00f, -3.23197603e-01f, 1.48091793e-01f, -2.38734275e-01f, 3.82735252e-01f, -7.39040300e-02f, -3.37862253e-01f, -2.75594532e-01f, 9.40031633e-02f, -1.48910329e-01f,
  1.32105470e-01f, -3.36731337e-02f, 2.56401956e-01f, 1.83436513e-01f, -2.18413413e-01f, -2.31949575e-02f, 3.10338706e-01f, 1.50417420e-03f, 1.35234743e-02f, -1.18841164e-01f,
  1.57164913e-02f, -1.29778832e-01f, -4.41532843e-02f, 1.10917129e-01f, 1.98905375e-02f, 8.88266116e-02f, 2.67863244e-01f, 7.04755932e-02f, 2.25702584e-01f, -1.53755635e-01f,
  1.14398766e-02f, -3.28136861e-01f, 6.18111975e-02f, -6.74930513e-02f, 2.55148876e-02f, -1.25354677e-01f, -1.12849884e-02f, 7.53581990e-03f, 1.19168080e-01f, 1.12391688e-01f,
  1.36108369e-01f, 5.59502132e-02f, 1.73401292e-02f, 1.77611560e-01f, -6.50449889e-03f, -9.67671424e-02f, 3.55222858e-02f, 8.70409440e-06f, -6.20068284e-03f, -2.71370381e-01f,
  -5.44444695e-02f, -8.78732931e-03f, -1.13230139e-01f, 1.20468311e-01f, -9.59778428e-02f, 2.05918968e-01f, -2.35780738e-02f, -5.42836189e-02f, 1.35060370e-01f, -1.58311248e-01f,
  2.84534041e-02f, -2.26056799e-02f, -5.94598940e-04f, -1.22790635e-01f, 8.17730054e-02f, -8.57790262e-02f, 1.05412781e-01f, -8.97321478e-03f, 5.13755381e-02f, -1.14943676e-01f,
  1.21572867e-01f, -9.74574760e-02f, 9.29182768e-03f, -1.00533456e-01f, 1.17655180e-01f, -1.13581195e-02f, -4.88242544e-02f, 5.24015259e-03f, 4.81091291e-02f, 6.85098916e-02f,
  9.72673204e-03f, 6.76179258e-03f, -9.16809663e-02f, 1.01054914e-01f, 1.82174519e-02f, 8.84593800e-02f, 6.18052445e-02f, -6.06539808e-02f, -5.34601836e-03f, 7.27036521e-02f,
  -2.86273569e-01f, 2.96117514e-01f, -1.11929365e-01f, -9.76790674e-04f, 5.23127802e-02f, 1.01621710e-01f, 5.73069602e-02f, 2.67917886e-02f, 1.45077379e-02f, -9.03191864e-02f,
  -6.91396520e-02f, -4.70611937e-02f, 8.38250965e-02f, 1.22090466e-01f, 1.46264769e-02f, 5.13779484e-02f, -9.48571321e-03f, -1.33961742e-03f, -4.83938083e-02f, 4.51213028e-03f,
  -6.82221577e-02f, -1.51128396e-01f, -2.58046210e-01f, -1.62972465e-01f, -1.03025533e-01f, -2.59387076e-01f, -1.80259094e-01f, -3.54176350e-02f, -1.63180053e-01f, -3.47533733e-01f,
  5.80733001e-01f, -7.29725957e-02f, -1.77789092e-01f, 3.95846188e-01f, -3.56675565e-01f, -6.26706779e-01f, -1.26767218e+00f, -3.61438036e-01f, 6.20818257e-01f, -9.15256292e-02f,
  2.94906814e-02f, 1.66463375e-01f, 2.23046705e-01f, -5.85520938e-02f, -4.85561579e-01f, -6.04277253e-01f, -3.49503532e-02f, 2.54931990e-02f, -5.13819337e-01f, -4.95396793e-01f,
  -9.36791226e-02f, 2.38704979e-01f, 4.49501485e-01f, 7.69949344e-04f, 1.33093521e-01f, -1.39697671e-01f, -3.83015275e-02f, 4.90249246e-02f, -2.52473116e-01f, 4.30716187e-01f,
  -1.24152387e-02f, -2.12923169e-01f, 7.76177198e-02f, 2.19538152e-01f, 1.03598401e-01f, 9.14054364e-02f, -1.78582624e-01f, 4.08204719e-02f, 1.58161335e-02f, -4.15859781e-02f,
  1.01122677e-01f, 5.33864275e-03f, 5.09826504e-02f, 4.33071591e-02f, -5.64301722e-02f, -6.98495954e-02f, 1.25564113e-01f, -5.77716455e-02f, 5.20385951e-02f, -3.33746858e-02f,
  1.51542071e-02f, -6.30828589e-02f, 2.14954931e-02f, -1.21227704e-01f, -1.26777053e-01f, 1.33765772e-01f, -5.48194088e-02f, -4.43185121e-02f, -1.09775901e-01f, -1.89636573e-02f,
  -2.00630277e-01f, -6.92987023e-03f, -7.25753307e-02f, 2.50807242e-03f, -6.34682924e-02f, 3.87124717e-02f, 1.30414953e-02f, 4.60404418e-02f, -4.60602827e-02f, -4.09581959e-02f,
  1.30922683e-02f, 6.65573552e-02f, 4.22133096e-02f, 7.80689996e-03f, 1.11253522e-01f, 3.62238623e-02f, 9.91794653e-03f, 4.17782441e-02f, 8.87632892e-02f, 5.67864701e-02f,
  1.92286018e-02f, 3.46855856e-02f, 1.17902189e-01f, -4.61601987e-02f, -6.25244924e-04f, -3.22522968e-02f, 6.05437830e-02f, 6.88991994e-02f, 3.53939645e-02f, -7.68127367e-02f,
  1.27855003e-01f, -1.49375886e-01f, 7.47573078e-02f, 2.12922953e-02f, -6.54798150e-02f, 4.12711427e-02f, 5.60794733e-02f, 4.51215431e-02f, 1.75717965e-01f, 9.51852724e-02f,
  -2.07667612e-02f, -5.17816469e-03f, -3.03459689e-02f, -2.28511915e-03f, -6.01173043e-02f, -3.60862585e-03f, 6.94073215e-02f, -4.53916304e-02f, 3.49573828e-02f, 1.48985371e-01f,
  2.38654494e-01f, -1.43961340e-01f, -1.46433309e-01f, 3.98255177e-02f, 7.08664507e-02f, -2.49593437e-01f, -1.16454631e-01f, 6.31170794e-02f, -1.23547330e-01f, -1.69660360e-01f,
  -1.44359672e+00f, 1.70439020e-01f, 9.16552264e-03f, -8.40559065e-01f, -7.95275494e-02f, -1.83865324e-01f, 9.51093435e-02f, 1.28298506e-01f, -1.81750089e-01f, 1.26884967e-01f,
  1.27993494e-01f, -1.52706251e-01f, -2.59235233e-01f, 7.25863352e-02f, -3.63527179e-01f, -7.93998875e-03f, -5.07666588e-01f, -7.77354181e-01f, -1.68837443e-01f, 1.43817127e-01f,
  -1.27099022e-01f, -5.63392937e-01f, -9.06903386e-01f, -1.55449361e-01f, 1.82645425e-01f, -1.49692044e-01f, -4.20687348e-02f, -5.13912559e-01f, 2.71523416e-01f, -4.92676049e-01f,
  3.09615135e-01f, -2.82303691e-01f, 6.97101355e-02f, -2.60938823e-01f, -7.51480972e-03f, 7.93975666e-02f, -2.05029491e-02f, 1.16504515e-02f, 4.95482385e-02f, -6.20851964e-02f,
  -1.68224990e-01f, 6.22854196e-02f, -1.70264632e-01f, 1.36853650e-01f, -1.46231085e-01f, -1.72674954e-02f, -1.53852571e-02f, -8.66490901e-02f, 6.48914054e-02f, 3.14764321e-01f,
  2.70635307e-01f, -6.48201481e-02f, 4.22727428e-02f, 1.62884668e-01f, 1.52269959e-01f, -1.43977493e-01f, 2.42611513e-01f, 1.08622514e-01f, 1.47247389e-01f, 2.02427879e-01f,
  -5.63491508e-02f, -1.68869253e-02f, 2.54159197e-02f, -9.68260467e-02f, -1.59761915e-03f, 8.85367095e-02f, 1.38116945e-02f, 8.21878202e-03f, 1.61870077e-01f, -6.80195400e-03f,
  4.25242558e-02f, 1.21255256e-01f, 3.14683504e-02f, -1.19098127e-02f, 1.61340475e-01f, -4.44875807e-02f, -1.26902804e-01f, 7.37936646e-02f, 4.50449213e-02f, -1.72552854e-01f,
  2.08525453e-02f, 1.07013382e-01f, -1.63463515e-03f, 9.83031914e-02f, 1.75071675e-02f, -7.80699030e-02f, 1.54295089e-02f, 1.91459414e-02f, 6.64009005e-02f, -7.69698992e-02f,
  1.05318993e-01f, -4.25453782e-01f, -2.69700103e-02f, 6.28086999e-02f, 4.10247222e-03f, -1.71574932e-02f, -1.99594870e-01f, 1.34684686e-02f, 5.19034825e-03f, 1.14240488e-02f,
  6.49788231e-02f, -4.85738106e-02f, 5.57214878e-02f, -1.10035641e-02f, -6.78353608e-02f, 3.38515230e-02f, -6.58695847e-02f, -6.91947341e-02f, 9.79567245e-02f, 5.28047159e-02f,
  1.32495806e-01f, 9.87957194e-02f, -1.27233028e-01f, 6.65862560e-02f, 4.86961082e-02f, -9.42285210e-02f, 1.85570195e-01f, 2.28158355e-01f, 4.10454907e-03f, 1.81206062e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  6.71664834e-01f, 5.74995458e-01f, 6.89333081e-01f, 6.92850590e-01f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.13939479e-01f, 6.44547045e-02f, 3.28576624e-01f, 8.26539025e-02f, 4.06122833e-01f, 2.99725682e-01f, -9.79921445e-02f, -1.61934495e-01f, -2.14610353e-01f, 6.18225113e-02f,
  1.24411643e-01f, 5.96099973e-01f, -2.91979492e-01f, 4.51096684e-01f, 3.01349729e-01f, -1.34487599e-01f, -3.03785235e-01f, -1.09567553e-01f, -1.99639440e-01f, -8.88553038e-02f,
  -6.33611903e-02f, -7.88352042e-02f, -3.08112830e-01f, -3.73131000e-02f, -1.28031641e-01f, 1.01812243e-01f, -2.90844202e-01f, 3.76814038e-01f, -4.65278566e-01f, -7.11776316e-01f,
  -3.77638102e-01f, 4.51614439e-01f, 5.76752611e-03f, 3.36684108e-01f, -2.09123254e-01f, -7.85129238e-03f, 8.89904127e-02f, -9.80742201e-02f, -8.62144157e-02f, 3.21671724e-01f,
  1.03463233e-01f, 2.87582912e-02f, 1.49749741e-01f, -4.19400841e-01f, 3.39877635e-01f, 7.93499649e-02f, -1.69425141e-02f, 2.80756712e-01f, -6.15113974e-01f, 1.63608510e-02f,
  -1.17785349e-01f, -4.82576579e-01f, 1.98027670e-01f, -3.70205790e-01f, -1.93219885e-01f, 2.41044343e-01f, 9.56951976e-02f, 2.19292730e-01f, 2.16829285e-01f, 8.88723731e-01f,
  -4.57337290e-01f, 4.99331117e-01f, 7.99007043e-02f, -2.24639149e-03f, -7.93023407e-02f, 4.40148562e-02f, 9.22932057e-04f, 5.38915694e-02f, -2.67795976e-02f, 5.41843653e-01f,
  -1.42985694e-02f, -8.63822699e-02f, -4.80392188e-01f, -2.91598648e-01f, -4.35993314e-01f, -8.75226706e-02f, 7.34556854e-01f, 8.25340077e-02f, 4.31478739e-01f, -3.82260442e-01f,
  -2.89036244e-01f, 1.80173844e-01f, 4.61603738e-02f, -1.86138049e-01f, 1.13959424e-01f, -4.00243163e-01f, 1.75749570e-01f, -3.16434354e-01f, -8.26634988e-02f, 7.87075832e-02f,
  3.05061847e-01f, 7.32891142e-01f, -2.96714902e-01f, -1.93669870e-01f, 1.16344206e-01f, -3.28758985e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.27352947e-02f, 9.89579260e-02f, 3.17022234e-01f, 2.83509493e-01f, 3.86897147e-01f, -2.92868018e-01f, -8.96841884e-02f, 2.60794997e-01f, 4.41684246e-01f, 4.36128348e-01f,
  4.15600628e-01f, 2.30142042e-01f, -1.42895043e-01f, -3.04759271e-03f, 1.14079595e-01f, 8.32066298e-01f, 5.53988278e-01f, 2.35737979e-01f, 5.30922174e-01f, 4.02456075e-01f,
  4.91465032e-01f, 7.20797598e-01f, -2.27022991e-01f, 3.64782274e-01f, 2.08710372e-01f, -5.92587106e-02f, -4.32512850e-01f, 2.90196240e-01f, 7.14313507e-01f, 5.57860255e-01f,
  -2.75112063e-01f, 7.63327658e-01f, -4.21114899e-02f, 2.84755379e-01f, 6.98870003e-01f, 4.14660633e-01f, 2.81202435e-01f, 5.03260612e-01f, 3.87564451e-02f, -9.40331876e-01f,
  -1.81656614e-01f, 1.45910814e-01f, -4.95974034e-01f, 8.37763488e-01f, 1.02482349e-01f, -6.85440958e-01f, -3.65720801e-02f, 6.31319225e-01f, -1.10568464e-01f, -3.07035465e-02f,
  3.91506582e-01f, 2.01196864e-01f, -1.85216397e-01f, 3.05246085e-01f, 4.93023485e-01f, -1.63664326e-01f, 5.64505517e-01f, -7.12659180e-01f, -3.22796762e-01f, 5.94201505e-01f,
  6.41036868e-01f, 5.52288115e-01f, -1.60713887e+00f, 4.64362741e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  -8.89143273e-02f, -5.10530844e-02f, -3.44444722e-01f, -1.60430670e-01f
};

// L2_fan_Wp (Shape: 6 x 16)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -6.97431982e-01f, 2.26243556e-01f, -1.91307157e-01f, 3.97953659e-01f, 1.99817136e-01f, -7.15896249e-01f, -4.22794133e-01f, -8.50804821e-02f, -1.99905619e-01f, 2.77928323e-01f,
  1.81470606e-02f, -3.28445554e-01f, 1.96441397e-01f, 2.34983593e-01f, -3.31313759e-01f, -6.17529631e-01f, 8.06509912e-01f, 4.87492770e-01f, 3.91646534e-01f, -1.69689491e-01f,
  6.80352151e-01f, 1.27088815e-01f, 1.57727581e-02f, 1.59645185e-01f, 7.48818070e-02f, 2.14266330e-02f, 3.63449156e-01f, 3.72633666e-01f, -1.08670063e-01f, -5.65031469e-01f,
  4.05246288e-01f, -1.63336098e-01f, -1.67757064e-01f, 2.06979811e-01f, -3.51590127e-01f, -8.08900416e-01f, -5.17556250e-01f, -6.89999685e-02f, 5.56482852e-01f, -2.78556049e-01f,
  2.93376416e-01f, -4.22670484e-01f, 4.37468082e-01f, 1.22648902e-01f, -2.48024762e-01f, -2.21963510e-01f, 6.38134718e-01f, -4.79331501e-02f, -9.03541207e-01f, -7.21264064e-01f,
  -3.68414849e-01f, 3.70097309e-01f, -2.85459518e-01f, -4.13530231e-01f, -2.99662724e-02f, 2.07740813e-01f, -3.46291624e-02f, 5.72125018e-01f, 1.04071379e-01f, -9.54191163e-02f,
  1.12200052e-01f, 3.92009944e-01f, -5.51092923e-01f, -1.45369127e-01f, -3.44143957e-02f, -7.38140881e-01f, -2.92656813e-02f, 2.08406895e-01f, -5.38224936e-01f, -4.48167231e-03f,
  5.27176380e-01f, 2.45817408e-01f, 6.05945468e-01f, -4.37360436e-01f, 4.61621374e-01f, -1.78850994e-01f, -2.06207797e-01f, 1.07259222e-03f, 5.87531403e-02f, -4.33042347e-01f,
  -4.76830333e-01f, -2.36732543e-01f, -1.17221847e-01f, 5.55896938e-01f, -2.61813879e-01f, -4.34565276e-01f, -1.21294945e-01f, 6.55969083e-01f, -4.95387107e-01f, 2.84913987e-01f,
  -5.73963486e-02f, 5.58200598e-01f, -1.13719232e-01f, -4.77541685e-02f, 1.36821315e-01f, 6.47821307e-01f
};

// L2_fan_Wp_bar (Shape: 4 x 16)
const int L2_fan_Wp_bar_rows = 4;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.71945322e-01f, -3.65526713e-02f, -8.07740808e-01f, 8.98662508e-01f, -3.95246118e-01f, -1.05478764e+00f, -3.83413553e-01f, -4.20564353e-01f, -3.02801639e-01f, -9.12313461e-01f,
  1.44591257e-01f, 2.69672751e-01f, -2.40343481e-01f, 7.10556209e-01f, 4.98416245e-01f, 1.14464068e+00f, 4.40935433e-01f, -2.06866816e-01f, -1.19765890e+00f, -6.52251303e-01f,
  6.59444630e-01f, -1.34910166e+00f, -6.62499368e-01f, -9.61434066e-01f, -7.99177811e-02f, 5.79764605e-01f, -3.97851020e-01f, -1.56504795e-01f, 1.03452492e+00f, 7.28287101e-01f,
  2.52323717e-01f, -1.38004590e-02f, -7.21388280e-01f, 1.07094336e+00f, 3.86712015e-01f, 2.24050984e-01f, 4.53980327e-01f, 2.81700999e-01f, 3.69416326e-01f, 1.00565150e-01f,
  -4.84219551e-01f, -1.68175146e-01f, 8.36114213e-02f, 2.42820218e-01f, 6.73146307e-01f, 4.70663458e-01f, 1.43468475e+00f, -8.08875561e-02f, -3.44348818e-01f, 1.22149006e-01f,
  -1.34478331e-01f, -1.49588680e+00f, -1.27318704e+00f, 1.56237766e-01f, 3.38074505e-01f, 7.56078184e-01f, 4.89148051e-01f, -5.70280194e-01f, -1.14615810e+00f, -6.06923044e-01f,
  -1.75377205e-01f, 5.43471515e-01f, 4.76471037e-01f, 9.12381411e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 4)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 4;
const float L2_fan_Bp_bar_data[] = {
  -2.63615876e-01f, 1.32549196e-01f, 2.13942468e-01f, -1.30961418e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  1.89313307e-01f, -3.84933233e-01f, 6.99877858e-01f, 1.86061189e-01f, -8.40826482e-02f, 2.01429456e-01f, 6.65911198e-01f, 2.43499950e-02f, -3.78846610e-03f, 9.17338073e-01f,
  -1.23408794e+00f, 6.31897002e-02f, -1.59988046e+00f, 1.88839868e-01f, -5.02670333e-02f, 6.62860930e-01f, 5.03436089e-01f, -2.61047371e-02f, 5.41781545e-01f, -7.67626762e-02f,
  5.16367137e-01f, 5.80899537e-01f, 5.93226578e-05f, 1.46239901e+00f, 5.18555939e-01f, -6.25418484e-01f, -1.14551783e+00f, 3.95787060e-01f, -5.64093411e-01f, -6.19993687e-01f,
  4.52566922e-01f, -1.53787231e+00f, 7.10273445e-01f, -9.96512473e-01f, -5.06821692e-01f, -1.18612599e+00f, 2.70262212e-01f, 9.89907205e-01f, 1.23123610e+00f, -9.56904292e-01f,
  -1.34726524e+00f, 1.29390574e+00f, 1.52619326e+00f, 1.07818030e-01f, -5.61964452e-01f, -7.13750005e-01f, 3.57685387e-01f, -1.10504258e+00f, 1.08571208e+00f, 6.15205526e-01f,
  -1.47433364e+00f, -9.82387722e-01f, -8.89701307e-01f, -4.74654406e-01f, 4.12561715e-01f, 8.46303344e-01f, 3.31638098e-01f, 9.84018862e-01f, 1.21046340e+00f, 1.45133913e+00f,
  4.24817383e-01f, 4.09420669e-01f, -6.67413652e-01f, -5.49782634e-01f, -1.29962814e+00f, -9.25870657e-01f, -5.53164244e-01f, -3.71981710e-01f, 3.77217561e-01f, 6.00593269e-01f,
  3.36350501e-01f, -1.30530432e-01f, -3.35346431e-01f, -7.88506679e-03f, -5.75654984e-01f, -4.19495881e-01f, -1.21927813e-01f, 6.80975020e-01f, -2.67292053e-01f, -1.27035284e+00f,
  2.31000185e-01f, 3.54979485e-01f, -1.43093956e+00f, 4.47391383e-02f, 2.40423307e-01f, 1.23239554e-01f, -3.68588895e-01f, -5.86110651e-01f, 4.55342412e-01f, -7.03452349e-01f,
  1.31620622e+00f, -1.29095972e+00f, -3.12868133e-02f, -7.04745293e-01f, 3.63716841e-01f, -2.44342655e-01f, -1.15198112e+00f, 5.96116066e-01f, 4.13141221e-01f, -1.67177230e-01f,
  -1.67446226e-01f, -8.38102937e-01f, -1.07053602e+00f, 1.59301937e+00f, 1.79541814e+00f, -1.52857864e+00f, 1.67900753e+00f, -4.12131995e-01f, -1.09674144e+00f, -1.17128718e+00f,
  -7.45336056e-01f, -1.32849741e+00f, -1.51110336e-01f, -8.88194978e-01f, 8.43204781e-02f, -9.72779095e-02f, 8.31586123e-01f, 1.48265481e-01f, -5.48080921e-01f, 5.70931077e-01f,
  -1.01694620e+00f, 3.20604593e-01f, -9.16422546e-01f, 5.75152874e-01f, 4.99320060e-01f, -7.23013163e-01f, -1.02103925e+00f, 5.63145339e-01f, -1.09549034e+00f, -4.25440334e-02f,
  -8.48132521e-02f, -5.14768004e-01f, -1.58647433e-01f, -5.41021347e-01f, 5.12361050e-01f, 4.44405735e-01f, 2.08867654e-01f, 4.87536758e-01f, -1.21508348e+00f, 1.12382936e+00f,
  9.72703457e-01f, -2.03946924e+00f, 8.70521143e-02f, -5.00642538e-01f, 9.13602948e-01f, 4.70289886e-01f, 1.35335255e+00f, 1.01407826e+00f, -8.65016699e-01f, 1.18547320e+00f,
  -1.16934645e+00f, -1.21425879e+00f, 1.97429463e-01f, 9.39150393e-01f, 8.56914461e-01f, -1.18352401e+00f, -6.69292688e-01f, -1.31752181e+00f, -9.60310936e-01f, 7.83252895e-01f,
  -9.03514266e-01f, -3.68448645e-01f, -9.75736976e-02f, 5.07108212e-01f, -8.08222830e-01f, -2.89320975e-04f, 2.70460963e-01f, -1.03574944e+00f, 9.69171882e-01f, -6.53909028e-01f,
  -9.10139799e-01f, 1.54331160e+00f, 1.02940276e-01f, -1.84132308e-01f, -3.31473649e-01f, 3.64838481e-01f, 8.74017060e-01f, 1.04355788e+00f, -5.18874079e-02f, 6.25572264e-01f,
  1.31873548e+00f, -9.63330150e-01f, -3.08783263e-01f, -1.05389500e+00f, -9.96933103e-01f, -6.68714523e-01f, -1.96678832e-01f, 4.23005708e-02f, -1.22737087e-01f, 4.80294824e-01f,
  -1.08675957e+00f, -1.08133823e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.86504349e-01f, -2.58959264e-01f, 5.17897248e-01f, -1.02871168e+00f, -2.93758094e-01f, -3.60380590e-01f, 7.24702060e-01f, 1.15495987e-01f, -1.27341151e-02f, 6.93990469e-01f,
  -1.18729448e+00f, 3.10459822e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    