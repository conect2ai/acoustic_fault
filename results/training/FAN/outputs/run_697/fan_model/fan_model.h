/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.16893131e-01f, 4.11898270e-02f, 4.36429046e-02f, -2.60614216e-01f, -1.15249574e-01f, 4.13605534e-02f, 2.12954301e-02f, 2.34023724e-02f, -5.44726960e-02f, -9.11023170e-02f,
  -1.57389760e-01f, -1.67504951e-01f, -8.98423046e-02f, 9.45680030e-03f, -2.33122800e-02f, -8.48940462e-02f, -7.14820772e-02f, -3.97030041e-02f, -2.30625067e-02f, -8.86612684e-02f,
  1.33973947e-02f, -1.38671724e-02f, 2.18198393e-02f, 4.48736101e-02f, -1.69281244e-01f, -1.69191100e-02f, -3.36921923e-02f, -9.83533636e-02f, 8.48101079e-02f, -1.58408731e-01f,
  -3.47858995e-01f, -1.25345096e-01f, -1.39835641e-01f, -7.47757405e-02f, -2.20638812e-02f, -3.69004086e-02f, -4.70954217e-02f, -1.23791419e-01f, -1.07267156e-01f, -3.24395858e-02f,
  -6.30623996e-02f, -2.86257993e-02f, -1.31825417e-01f, -8.30330327e-02f, -9.79823247e-02f, -6.83446303e-02f, -4.19947281e-02f, -1.45320185e-02f, -2.31851712e-02f, -5.87437898e-02f,
  3.60167250e-02f, -8.71630907e-02f, -1.10979136e-02f, -5.96945323e-02f, -7.77893588e-02f, -1.92910004e-02f, -8.68840963e-02f, -4.69625928e-02f, 3.48749310e-02f, -2.24883839e-01f,
  -8.18509832e-02f, -1.71059314e-02f, 2.64530350e-02f, 8.49847868e-02f, 2.48396266e-02f, 1.11957893e-01f, 1.14085935e-01f, -1.37690559e-03f, 3.71291302e-02f, -3.88398990e-02f,
  6.93485886e-02f, 2.66895816e-02f, 1.18600741e-01f, 6.44857511e-02f, 9.50625241e-02f, 2.91335732e-02f, 5.65012582e-02f, 5.51834330e-03f, 5.84352687e-02f, 9.81963873e-02f,
  -2.85158157e-02f, 5.16795963e-02f, 8.38236585e-02f, 4.91223671e-02f, 1.20690405e-01f, 1.13482535e-01f, 7.18404725e-02f, 8.78477097e-03f, 4.25352566e-02f, 6.57187700e-02f,
  -2.84204960e-01f, -1.18514420e-02f, -2.14285672e-01f, -1.13052011e-01f, -1.18615605e-01f, -1.97172333e-02f, -5.75018525e-02f, -7.99474493e-02f, -1.03321195e-01f, -1.09634869e-01f,
  -6.49107099e-02f, -1.14331312e-01f, -7.68580809e-02f, -9.64880735e-02f, -1.31712928e-01f, -9.60395634e-02f, -6.66182786e-02f, -2.82835364e-02f, -5.28281741e-02f, -1.15164608e-01f,
  -8.77535343e-02f, -9.26688835e-02f, -1.27872542e-01f, -1.05567984e-01f, -5.85994013e-02f, -1.63978398e-01f, -1.25421733e-01f, -4.96228226e-02f, -6.78469287e-03f, -7.94162080e-02f,
  3.68785828e-01f, 2.66998053e-01f, -1.77242048e-02f, 4.18239869e-02f, -9.13473684e-03f, 8.23865086e-02f, 2.19787702e-01f, 3.81897762e-02f, 7.77132586e-02f, 1.76864937e-01f,
  2.33734995e-02f, -7.28655010e-02f, 7.90369418e-03f, -7.13451803e-02f, 2.17476729e-02f, 2.46298000e-01f, 5.32046035e-02f, -1.10959083e-01f, -2.05662742e-01f, -1.97406903e-01f,
  6.22445159e-03f, 8.23242590e-02f, 2.09086053e-02f, -7.99500793e-02f, 5.72550893e-02f, 2.74363272e-02f, 3.67911756e-02f, 1.45870363e-02f, -7.86645487e-02f, 1.75954252e-01f,
  1.76417455e-03f, 8.93151313e-02f, -1.22579403e-01f, -1.22797765e-01f, -1.24762446e-01f, -3.67298424e-02f, -4.85924110e-02f, 6.82114661e-02f, -7.54643530e-02f, 5.82491681e-02f,
  -1.11993335e-01f, -6.24739118e-02f, 1.45388730e-02f, -1.03540018e-01f, -4.08693105e-02f, 3.70259881e-02f, -5.83079755e-02f, 1.06846765e-02f, -8.55171308e-02f, -7.54800290e-02f,
  -1.54405870e-02f, 1.31329866e-02f, 6.18941560e-02f, -1.17338002e-01f, -2.95514818e-02f, -1.22897685e-01f, 1.84861682e-02f, -3.54735330e-02f, 6.06728345e-02f, 1.79369673e-01f,
  4.84472141e-03f, 2.40165764e-03f, 3.10642587e-04f, -1.33244684e-02f, 6.69709444e-02f, 2.92348191e-02f, 4.47148904e-02f, 4.26818058e-02f, -1.76057629e-02f, 1.26090413e-02f,
  5.23694903e-02f, 1.74060203e-02f, -2.42556408e-02f, 3.63704152e-02f, -2.98399832e-02f, 9.45011452e-02f, 2.94191185e-02f, 3.08102171e-04f, 2.01236811e-02f, -1.47337057e-02f,
  2.37165876e-02f, -2.32860465e-02f, 8.92218575e-02f, -2.70579997e-02f, -4.95527834e-02f, 9.69498977e-02f, 3.44515070e-02f, -2.89145056e-02f, 1.17482759e-01f, 3.88275087e-02f,
  1.20163038e-01f, -1.33403808e-01f, 5.92493340e-02f, 1.94171984e-02f, -8.92227218e-02f, -4.09847945e-02f, -5.52848615e-02f, -4.99807484e-03f, 6.81876205e-04f, -2.90464126e-02f,
  -5.73220290e-02f, -3.29625420e-02f, -6.66916370e-02f, 1.92345325e-02f, -3.61695513e-02f, -2.49830959e-03f, 7.90312886e-02f, -9.38993543e-02f, -7.85643384e-02f, 2.63825972e-02f,
  -4.24774624e-02f, 8.56068358e-02f, 1.01182885e-01f, 6.07357435e-02f, 3.35881263e-02f, 1.43664144e-02f, 2.66198069e-02f, 1.73028801e-02f, 1.13565378e-01f, 2.75127739e-01f,
  -3.16159636e-01f, -2.04926729e-01f, -7.68746659e-02f, -2.06629515e-01f, -9.13564637e-02f, -1.23652466e-01f, -2.61317372e-01f, -1.35222167e-01f, -5.44770323e-02f, -1.42620772e-01f,
  3.25425193e-02f, 1.27004251e-01f, -3.22118215e-02f, 5.95396943e-02f, -3.81979644e-02f, -1.70664757e-01f, -2.38054872e-01f, 5.11065759e-02f, 6.70112669e-02f, 5.12965433e-02f,
  -4.01360728e-02f, -3.09776701e-03f, 2.98760794e-02f, 6.82390705e-02f, -3.67212594e-02f, 1.04412623e-01f, -4.47778031e-02f, -3.87557745e-02f, 8.73640478e-02f, -2.21777931e-02f,
  6.10100143e-02f, -9.17181820e-02f, -6.69073546e-03f, -2.01796554e-02f, -5.00286892e-02f, -7.84397274e-02f, -1.28230201e-02f, 4.31374088e-02f, 4.53722998e-02f, 9.60621517e-04f,
  -2.98091788e-02f, 9.50170960e-03f, -8.19648206e-02f, -8.34101718e-03f, -4.17891368e-02f, 1.09414225e-02f, -7.11973459e-02f, -3.50053944e-02f, -1.09922372e-01f, -6.86745951e-03f,
  -2.53668558e-02f, -1.02948328e-03f, -9.53327864e-02f, 6.26008734e-02f, 5.00219241e-02f, 9.39304978e-02f, -2.55829003e-02f, 1.01525925e-01f, -3.74081358e-02f, -8.17631111e-02f,
  -1.90550014e-02f, 7.38903433e-02f, 3.34201194e-02f, 7.25582838e-02f, 8.64102095e-02f, 1.55264959e-01f, 5.03901988e-02f, 5.71220554e-02f, 4.37383913e-02f, 6.55349493e-02f,
  9.08307657e-02f, 1.06763497e-01f, 6.07094504e-02f, 3.29581723e-02f, 1.47444889e-01f, 9.00293440e-02f, 5.48444986e-02f, -5.74383093e-03f, 1.39105380e-01f, 4.02389690e-02f,
  1.06083781e-01f, 9.89140868e-02f, 8.56100991e-02f, 5.36115794e-03f, 3.36161442e-02f, 1.01670444e-01f, 2.32504532e-02f, 1.49901181e-01f, 5.23745231e-02f, 1.33049175e-01f,
  -6.71201274e-02f, 4.81598191e-02f, -1.18750453e-01f, -3.44983116e-02f, -1.92286391e-02f, -3.40461768e-02f, -2.27333326e-03f, -5.84579743e-02f, -3.96649539e-02f, -2.76074093e-02f,
  -2.05700938e-02f, -4.99913320e-02f, -9.82562006e-02f, 4.77859266e-02f, -6.21336885e-02f, -8.04490596e-03f, -6.73892573e-02f, -4.61047217e-02f, -5.99623173e-02f, -4.28155158e-03f,
  -1.37516186e-01f, -4.14623180e-03f, -2.22908910e-02f, -6.69788122e-02f, -8.10142383e-02f, -7.74625316e-02f, -5.63956201e-02f, -3.17954943e-02f, -1.55304996e-02f, -2.04402193e-01f,
  3.50255817e-01f, -1.10145003e-01f, 2.75378704e-01f, 2.53253710e-02f, -6.05672896e-02f, 9.79664102e-02f, 4.23809923e-02f, 1.00771002e-01f, -5.07454686e-02f, 8.85419175e-02f,
  2.68082060e-02f, -3.51999737e-02f, 5.91462962e-02f, 1.11248828e-01f, 1.81069106e-01f, 1.65217277e-02f, 2.97923815e-02f, 1.57423392e-01f, 1.98239699e-01f, -3.70689034e-02f,
  -1.63318053e-01f, -6.27954453e-02f, 1.13180876e-01f, 5.30379862e-02f, -6.50126934e-02f, 1.11514982e-02f, 1.04231134e-01f, -6.39850125e-02f, 1.04567058e-01f, 2.91453563e-02f,
  3.67949605e-01f, 2.41576299e-01f, 9.65627730e-02f, 3.13911028e-02f, 9.67347771e-02f, 1.41190350e-01f, 1.23980314e-01f, -7.04632979e-03f, 9.42444652e-02f, 7.62374029e-02f,
  1.04305446e-01f, -1.00675935e-03f, 4.27540727e-02f, 6.66928664e-02f, 4.53319922e-02f, 3.15843523e-02f, 5.96806705e-02f, 1.53893262e-01f, 2.56915372e-02f, 1.96002629e-02f,
  -7.31374994e-02f, -6.28002733e-02f, 8.93200040e-02f, 1.41245043e-02f, 2.27036774e-02f, 1.30934447e-01f, 6.07914068e-02f, 4.12130244e-02f, 2.15219826e-01f, 1.63319111e-01f,
  -1.09153897e-01f, -1.12223342e-01f, -4.70722280e-02f, -1.51472881e-01f, -1.86387338e-02f, -9.97696593e-02f, -3.18350759e-03f, -9.90294367e-02f, -5.23450039e-02f, -1.13582939e-01f,
  -2.86459029e-02f, 6.08735122e-02f, -7.71663114e-02f, -3.13611031e-02f, -1.22774974e-01f, -6.11451678e-02f, 2.17544511e-02f, 2.85964482e-03f, -2.88584223e-03f, -1.53378595e-03f,
  7.50384778e-02f, -2.84156483e-02f, -7.00901374e-02f, -7.14698732e-02f, 2.27078684e-02f, -3.36025879e-02f, -9.95720699e-02f, -4.51089907e-03f, 4.22534719e-02f, -3.90580818e-02f,
  6.94547174e-03f, 1.66575521e-01f, 4.05281670e-02f, 1.06254093e-01f, 9.51803029e-02f, 7.39403814e-02f, -3.74260880e-02f, 1.09742597e-01f, 1.11601308e-01f, 7.41715282e-02f,
  4.77528684e-02f, 7.18736351e-02f, 1.35429753e-02f, 1.56118751e-01f, 4.88970615e-02f, 6.31062463e-02f, -8.98553133e-02f, 7.96103776e-02f, 3.98174785e-02f, 1.35417446e-01f,
  5.65233789e-02f, 4.84806485e-02f, 6.99626282e-02f, 4.78212833e-02f, 1.14682764e-01f, 1.27816439e-01f, 7.99071640e-02f, 5.46600074e-02f, 1.67549714e-01f, 1.12439461e-01f,
  3.20709646e-01f, -2.00125620e-01f, 8.60696658e-02f, 1.96416862e-02f, -2.16268063e-01f, -1.44251719e-01f, -1.75742596e-01f, -5.01216995e-03f, -9.57696438e-02f, -9.48650166e-02f,
  -9.90501493e-02f, 4.18347195e-02f, 3.76947969e-02f, -9.39280689e-02f, 3.75062265e-02f, -1.20507263e-01f, -9.99818370e-02f, 3.72323580e-02f, 1.06989957e-01f, -1.32679433e-01f,
  -2.21968010e-01f, -4.02383469e-02f, 8.12710598e-02f, -2.96869092e-02f, -2.42886513e-01f, -4.28307839e-02f, -1.23586558e-01f, -1.22241512e-01f, -2.69900084e-01f, -2.78773576e-01f,
  2.56298572e-01f, 1.62671320e-02f, -8.28912631e-02f, -1.46165878e-01f, -5.55028431e-02f, 3.20200585e-02f, -5.57590164e-02f, 2.04248168e-02f, -1.16194598e-01f, 1.43177854e-02f,
  -6.16074130e-02f, -1.47347763e-01f, -1.99726615e-02f, -1.47823229e-01f, -5.63164242e-02f, 6.42608404e-02f, -1.12741813e-01f, -3.50152142e-02f, 3.09066977e-02f, -1.27800316e-01f,
  -1.48449093e-01f, -1.00714505e-01f, 7.93666095e-02f, -2.76794266e-02f, -4.24182527e-02f, -1.50554568e-01f, -5.65631576e-02f, -8.57989416e-02f, 2.61616297e-02f, -5.10019511e-02f,
  -7.86185730e-03f, -7.77338073e-03f, 3.99451591e-02f, 1.13240227e-01f, 1.30743226e-02f, 7.17087090e-02f, -7.87228867e-02f, -1.13135320e-03f, 7.34352246e-02f, 7.82192349e-02f,
  3.31254788e-02f, 6.78289309e-02f, 7.58678392e-02f, 6.59089983e-02f, 6.08497113e-03f, 2.66558547e-02f, -4.58008982e-02f, 5.50050288e-02f, 5.50043397e-02f, 1.21645622e-01f,
  1.16128094e-01f, -1.32037532e-02f, 6.32704003e-03f, 7.43037388e-02f, 7.97693133e-02f, 2.15879343e-02f, 1.82810165e-02f, 8.12098831e-02f, 1.47355840e-01f, 9.18431208e-02f,
  2.94173062e-02f, -5.46493195e-03f, 4.78480533e-02f, -1.61606949e-02f, -1.28848791e-01f, -6.30248562e-02f, 4.67432244e-03f, -8.53410810e-02f, -7.28625879e-02f, -2.79069599e-03f,
  -9.42058414e-02f, -5.63951097e-02f, -1.75785751e-03f, -6.35624155e-02f, -2.17477251e-02f, 9.92793310e-03f, -6.93131797e-03f, -3.01270615e-02f, -4.83619273e-02f, -1.70274392e-01f,
  -1.80826150e-02f, 3.32944803e-02f, 1.30280256e-01f, -7.20209479e-02f, -1.27558857e-01f, 6.09641410e-02f, -7.27753639e-02f, -2.80958731e-02f, -1.90766752e-02f, -1.04504908e-02f,
  -7.28250816e-02f, -2.22065955e-01f, 9.80482250e-02f, -1.80282742e-02f, 1.72505602e-02f, 9.30796936e-02f, -5.87264523e-02f, 5.66515997e-02f, -9.55255795e-03f, -3.06948051e-02f,
  3.23932990e-02f, 1.87853009e-01f, 2.66636815e-02f, 1.18164994e-01f, 1.92468688e-02f, -1.11780889e-01f, -1.70914695e-01f, 7.86203742e-02f, 1.81773335e-01f, 1.92304015e-01f,
  1.14972284e-02f, 1.74232863e-03f, 3.37680243e-02f, 1.10853337e-01f, -1.01375073e-01f, 3.45599465e-02f, -1.54795833e-02f, -1.23072922e-01f, -1.67100728e-02f, -2.68262297e-01f,
  2.09671751e-01f, 1.93351898e-02f, 2.25189254e-01f, 1.27392083e-01f, 1.04902573e-01f, 8.77757221e-02f, 1.43307522e-01f, 1.31878704e-01f, 8.22511986e-02f, -8.59399140e-03f,
  1.21303506e-01f, 7.00713471e-02f, 1.06109530e-01f, 1.11978941e-01f, -8.80813040e-03f, 6.18678629e-02f, -4.31621596e-02f, 8.05788413e-02f, 1.91955179e-01f, 1.41504025e-02f,
  1.26147494e-02f, 5.63756339e-02f, 1.25167608e-01f, 1.55986771e-01f, 9.93514583e-02f, 7.54129887e-02f, 1.10757407e-02f, 9.33519527e-02f, 1.38959870e-01f, -6.16723634e-02f,
  -2.60491073e-02f, -1.06708072e-01f, -3.34812663e-02f, -1.76902175e-01f, -4.47364151e-02f, -7.84127116e-02f, -9.70884189e-02f, -4.11643982e-02f, -1.07801132e-01f, -1.52225256e-01f,
  -8.27721879e-02f, 2.27660891e-02f, -3.61081213e-02f, -1.11477837e-01f, -6.74177036e-02f, 5.69728483e-03f, -4.34683561e-02f, -6.29184693e-02f, -3.00274435e-02f, -1.34967178e-01f,
  -2.42509390e-03f, 2.53001247e-02f, -4.33672778e-02f, 3.21181081e-02f, -4.08443511e-02f, 9.85889789e-03f, -9.13036335e-03f, -5.23393676e-02f, -1.11025572e-01f, -9.59229916e-02f,
  1.28984317e-01f, 2.18216911e-01f, 8.11203420e-02f, 1.65793642e-01f, 9.88724753e-02f, 1.21636339e-01f, 1.99877799e-01f, 4.96467687e-02f, -9.31180082e-03f, 1.61068156e-01f,
  1.29860297e-01f, 1.94933325e-01f, 2.27312129e-02f, 6.78847954e-02f, 1.67050168e-01f, 1.06878810e-01f, 1.27270788e-01f, 7.44281337e-02f, 1.67649701e-01f, 7.48117566e-02f,
  1.29392624e-01f, 1.79137871e-01f, 9.57633480e-02f, 1.76397756e-01f, 8.49727392e-02f, 1.97391182e-01f, 1.00158617e-01f, 1.09541997e-01f, 2.31502876e-01f, -2.71128817e-03f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.39102513e-01f, -2.80545473e-01f, -5.20922989e-02f, -2.00300217e-01f, -6.84221163e-02f, -8.59515071e-02f, -2.20441565e-01f, -5.51045388e-02f, -1.96741205e-02f, -3.74108434e-01f,
  -8.03506449e-02f, 1.57762114e-02f, -1.61427259e-01f, -6.59688115e-02f, -9.67517868e-02f, -3.47128123e-01f, -1.81232929e-01f, 3.93530317e-02f, 1.94590524e-01f, 9.28582177e-02f,
  3.18841562e-02f, 1.61482263e-02f, 1.38914108e-01f, -2.97091668e-03f, -1.17045917e-01f, -4.97482568e-02f, -1.07758142e-01f, -3.27582844e-02f, -1.18910462e-01f, -3.13976437e-01f,
  -2.05214694e-01f, 6.89125508e-02f, 1.06585845e-01f, -4.98903804e-02f, -2.93419175e-02f, -9.71034318e-02f, 1.24966614e-02f, -5.24195358e-02f, 4.98333350e-02f, 2.32665371e-02f,
  9.37762111e-02f, 1.03095599e-01f, 1.58936959e-02f, 6.69857860e-02f, 9.92312059e-02f, 9.71555188e-02f, -6.94088265e-02f, 7.59092644e-02f, -7.47889578e-02f, -1.38141453e-01f,
  -4.52766344e-02f, -1.23943835e-01f, 4.06323858e-02f, 1.15030691e-01f, 7.88457915e-02f, -5.06127020e-03f, 6.33883402e-02f, 1.69354156e-01f, 4.08326611e-02f, -2.37543061e-01f,
  -1.10068522e-01f, -7.00905919e-03f, 6.95913360e-02f, -5.55643141e-02f, 5.64108696e-03f, -6.94768876e-02f, -2.96749342e-02f, -1.16157964e-01f, 1.30048051e-01f, -1.17375225e-01f,
  4.53259796e-02f, 4.32894677e-02f, -3.79975233e-03f, -5.47821186e-02f, -9.46806073e-02f, -5.00033237e-02f, -1.94523595e-02f, 2.35533565e-02f, -7.31603382e-03f, -1.43072121e-02f,
  2.45915055e-02f, -4.22102213e-02f, 3.00215231e-03f, 3.80870774e-02f, 1.04126250e-02f, -6.78388774e-02f, 7.11763427e-02f, 5.12825362e-02f, 7.51737505e-02f, 4.70351093e-02f,
  -7.62897804e-02f, 1.23600267e-01f, -2.50275284e-01f, 1.35336846e-01f, 3.31573300e-02f, 2.19144095e-02f, -8.32004920e-02f, 4.08616364e-02f, 1.35460958e-01f, -1.36310279e-01f,
  1.89157978e-01f, -7.30524957e-02f, -4.99749705e-02f, 4.37408760e-02f, -5.01064435e-02f, 3.95448320e-02f, -1.84417456e-01f, 4.80860099e-02f, 6.69924840e-02f, -2.43669320e-02f,
  -1.22617178e-01f, -4.80661914e-02f, -9.79626849e-02f, -3.82638685e-02f, -5.54877892e-02f, -3.01269279e-03f, -6.91851228e-02f, -2.15829518e-02f, -1.03115834e-01f, -2.88030356e-01f,
  -1.60184726e-01f, -2.99754471e-01f, 7.01712295e-02f, 1.95552886e-01f, 8.16017017e-02f, -2.52997279e-01f, -3.63927931e-01f, -3.33511680e-01f, 1.88384037e-02f, -1.98744312e-02f,
  4.55572903e-02f, 2.84811556e-01f, 1.68167442e-01f, 5.63083477e-02f, -6.74379691e-02f, 2.99100485e-02f, 1.89021513e-01f, 2.48122096e-01f, 6.27191737e-02f, 4.63566408e-02f,
  1.35790169e-01f, 1.36516355e-02f, 1.04373440e-01f, 1.46611020e-01f, 1.29333824e-01f, 1.74385712e-01f, 1.36273012e-01f, 1.62615582e-01f, 8.36626217e-02f, 3.96041214e-01f,
  1.30856156e-01f, -1.18523434e-01f, 1.51491657e-01f, 1.39490098e-01f, 1.00221097e-01f, -1.00540780e-01f, 8.56379338e-04f, -7.24456012e-02f, 2.04727873e-02f, -9.35732275e-02f,
  8.55569988e-02f, 9.41042155e-02f, 3.83163169e-02f, -5.53646423e-02f, -1.10851809e-01f, -8.87799542e-03f, -3.93230170e-02f, -1.34300694e-01f, -2.84116361e-02f, -8.11925530e-02f,
  2.07879975e-01f, 4.11370918e-02f, -2.72020735e-02f, -1.96856216e-01f, -2.20320709e-02f, 1.84013724e-01f, -6.15465175e-03f, -2.29747519e-02f, -1.67417794e-01f, -1.37657806e-01f,
  -4.36695404e-02f, -3.34766740e-03f, 3.48268859e-02f, 3.71491797e-02f, 7.92470425e-02f, -6.94910213e-02f, 6.99339136e-02f, 7.29202405e-02f, 8.53556412e-05f, -3.58247571e-02f,
  7.37074241e-02f, -3.21589410e-02f, -6.79007471e-02f, -7.73622543e-02f, 1.57313943e-01f, 1.21124610e-01f, 5.14367931e-02f, 1.03307441e-01f, 3.27206440e-02f, 9.73829534e-03f,
  5.39500564e-02f, 5.83815053e-02f, -2.67551020e-02f, -2.10855324e-02f, 4.96891513e-02f, 7.56599456e-02f, -5.37815467e-02f, -4.79264669e-02f, 4.51862551e-02f, 4.42372151e-02f,
  -2.06835344e-01f, 2.83383131e-02f, 1.99113905e-01f, -7.92243518e-03f, 3.44050553e-04f, 9.57820117e-02f, 1.19235039e-01f, -5.93789183e-02f, 1.16341732e-01f, -1.07102931e-01f,
  -1.54184967e-01f, -6.02245741e-02f, -6.37854785e-02f, -5.83705679e-02f, -5.96655495e-02f, 1.45379629e-03f, 1.73656553e-01f, 5.78199290e-02f, -6.90943981e-03f, 4.23437655e-02f,
  1.21866064e-02f, -1.99637532e-01f, -1.16710454e-01f, -1.58736885e-01f, 5.20909019e-03f, -4.54767011e-02f, -1.03930831e-01f, 2.57464754e-03f, -7.34934956e-02f, -2.42029101e-01f,
  3.86625320e-01f, -1.85613781e-01f, 1.41187832e-02f, 1.47254035e-01f, 1.32526830e-01f, 1.73931330e-01f, 1.48759395e-01f, 3.74265164e-02f, 8.49863216e-02f, 7.16390014e-02f,
  1.93678737e-01f, 2.11186096e-01f, 2.34712660e-01f, 1.86163396e-01f, 1.85237616e-01f, -3.97365838e-02f, 1.04521610e-01f, 1.49237797e-01f, 1.09552592e-01f, 4.04428877e-02f,
  3.39049064e-02f, -9.27278921e-02f, -1.02842562e-02f, 1.10438965e-01f, -1.30816540e-02f, 9.09255743e-02f, 5.78988865e-02f, 3.57500953e-03f, -9.58130416e-03f, -1.18675999e-01f,
  -1.46096721e-01f, -1.68652628e-02f, 6.51303399e-03f, -1.08413689e-01f, -7.94440061e-02f, -9.09265131e-02f, 1.11411577e-02f, -2.47597266e-02f, 3.19839902e-02f, -1.70622300e-02f,
  -5.91040170e-03f, -1.98235102e-02f, -2.01823637e-01f, -7.84862339e-02f, -1.88398600e-01f, 9.48889367e-03f, -1.06721640e-01f, 1.00582175e-01f, 1.01809062e-01f, -7.86179826e-02f,
  3.46505120e-02f, 5.41547462e-02f, -3.68864834e-02f, -9.97740030e-03f, 6.04342073e-02f, -4.09986824e-02f, -3.53538170e-02f, 1.90192778e-02f, 1.06769927e-01f, 1.14399947e-01f,
  1.80391818e-01f, 5.64759485e-02f, 9.01967958e-02f, 1.76845421e-03f, 1.21040143e-01f, -2.85051242e-02f, -2.61682235e-02f, -4.01209742e-02f, 8.42624828e-02f, -1.39778331e-01f,
  -1.29792213e-01f, 1.09368563e-01f, 1.38684496e-01f, -1.06510730e-03f, 1.71950888e-02f, 3.87028754e-02f, -2.20684055e-02f, 5.47413975e-02f, -9.42277089e-02f, 2.90182009e-02f,
  -9.66798663e-02f, 3.84255163e-02f, -1.18114553e-01f, -2.07240194e-01f, -1.41927585e-01f, 4.62685414e-02f, -1.69499189e-01f, -3.97595204e-02f, -4.91266586e-02f, 2.35388447e-02f,
  -2.68980056e-01f, 1.76033825e-01f, 7.11148679e-02f, 3.68576609e-02f, 1.34836221e-02f, -8.87970105e-02f, 1.23246893e-01f, -1.69934575e-02f, -1.25563983e-02f, -6.57773986e-02f,
  -5.29530570e-02f, 1.37481643e-02f, -1.66297868e-01f, -9.91321951e-02f, -8.47702175e-02f, 3.73247415e-02f, 5.92769831e-02f, 5.42319678e-02f, -2.87323706e-02f, -3.73049416e-02f,
  -7.75489630e-03f, 1.03968292e-01f, -2.64043920e-02f, 1.36845171e-01f, 4.26859185e-02f, 1.75756831e-02f, 3.86234163e-03f, -5.02923541e-02f, -7.40452856e-02f, -6.75659478e-02f,
  5.20779431e-01f, 2.30894715e-01f, 2.05005303e-01f, 1.50872573e-01f, 3.81987207e-02f, -3.49618159e-02f, 1.54424101e-01f, 9.01670530e-02f, 9.33092367e-03f, 1.46037310e-01f,
  1.38110638e-01f, -1.65691972e-02f, 1.23407945e-01f, 2.91772117e-03f, 1.29573286e-01f, 1.01523824e-01f, -3.81659809e-03f, 1.33487498e-02f, 8.99572819e-02f, 1.60652529e-02f,
  8.54855962e-03f, 3.76423635e-02f, 1.45635813e-01f, -4.00249194e-03f, 8.90932828e-02f, -5.69931045e-02f, 5.65505214e-02f, -4.38592397e-02f, 1.95725970e-02f, 4.67410870e-02f,
  -2.00556591e-01f, 2.07959041e-01f, -1.50166646e-01f, 9.67035070e-04f, 1.03915734e-02f, -2.39634383e-02f, -1.40506318e-02f, -6.42396659e-02f, -1.53225616e-01f, -7.08772913e-02f,
  -1.31900432e-02f, -3.80648486e-02f, 1.00382846e-02f, 5.75787276e-02f, -1.81607846e-02f, -6.38011768e-02f, 3.37088518e-02f, 1.24545425e-01f, 9.58290771e-02f, 4.00225371e-02f,
  -1.23266131e-03f, -3.81920040e-02f, -6.95454851e-02f, 5.12136035e-02f, 1.51853755e-01f, 4.77267355e-02f, 4.08351421e-02f, 9.82232671e-03f, 9.32773277e-02f, 1.82298601e-01f,
  3.26650105e-02f, 3.69802676e-02f, 4.48465757e-02f, 1.10641673e-01f, 3.59461643e-02f, 3.63327912e-03f, -3.40020508e-02f, -1.34829849e-01f, -3.37691717e-02f, 5.16108163e-02f,
  -3.35820168e-02f, 4.88568358e-02f, 8.12558979e-02f, 6.10047653e-02f, -2.19740514e-02f, -8.82500410e-02f, -3.37765962e-02f, 1.46436123e-02f, -6.21416382e-02f, -1.35257870e-01f,
  3.98252234e-02f, 1.26920815e-03f, -5.23031913e-02f, -4.01563756e-02f, 2.98773553e-02f, 1.00272708e-01f, -6.02817908e-02f, -1.21558001e-02f, 6.35383576e-02f, 8.02910551e-02f,
  -3.75360459e-01f, -9.33106616e-02f, -6.46031648e-02f, -7.24233501e-03f, 5.91136925e-02f, -1.05987340e-01f, 9.75923836e-02f, -1.38830975e-01f, -1.96696684e-01f, -1.35633901e-01f,
  -1.20075196e-01f, 6.03945404e-02f, 2.98660323e-02f, 3.84469852e-02f, -1.52578861e-01f, -6.95303902e-02f, -9.51594636e-02f, 5.97968623e-02f, -3.48887071e-02f, -8.77201036e-02f,
  2.04531550e-02f, 1.48064187e-02f, -1.01368636e-01f, 5.49302623e-02f, 4.26796973e-02f, -9.38434005e-02f, -2.64303591e-02f, -2.22542286e-02f, -1.10097498e-01f, 6.68630823e-02f,
  4.47565973e-01f, -9.88906622e-02f, -3.28746200e-01f, 8.45216662e-02f, -1.37762025e-01f, -2.34788805e-01f, -1.90612718e-01f, -1.09596014e-01f, 1.20627508e-01f, -7.83784539e-02f,
  -1.37609497e-01f, -7.12730214e-02f, -7.97192529e-02f, -2.09669366e-01f, -8.41520354e-02f, -1.56227559e-01f, -1.10916726e-01f, -1.37883127e-01f, -2.01556519e-01f, -1.42692432e-01f,
  6.15946464e-02f, 1.90268487e-01f, 1.19754910e-01f, -5.27064316e-02f, 8.19991753e-02f, 5.85399866e-02f, -1.68898657e-01f, -3.80137824e-02f, -1.15596831e-01f, -2.64935233e-02f,
  -1.93391263e-01f, -6.86331242e-02f, -7.43066892e-02f, 4.84366603e-02f, -6.58159936e-03f, 8.82410482e-02f, -5.12607992e-02f, 7.01188669e-02f, 2.85327546e-02f, -4.82720956e-02f,
  -4.74226922e-02f, -1.98214978e-01f, -8.99286345e-02f, -1.44665420e-01f, -3.41460109e-02f, -1.57876998e-01f, 2.45338362e-02f, -7.90722668e-02f, -3.49132158e-02f, -1.05394423e-01f,
  -1.55449156e-02f, -1.23605188e-02f, 8.92483443e-03f, -4.49901558e-02f, -1.20531760e-01f, 2.57827323e-02f, -2.43921265e-01f, -9.12859738e-02f, -2.32216790e-01f, 1.65581152e-01f,
  -6.10445589e-02f, -8.48230347e-03f, 2.05924804e-03f, 1.09294206e-01f, 1.00302599e-01f, 6.05937578e-02f, -9.93571654e-02f, 1.57792214e-02f, -4.62203734e-02f, 5.62513024e-02f,
  -6.49709404e-02f, 1.24273496e-02f, -5.57986684e-02f, 8.94370228e-02f, -2.56307237e-02f, -5.28585874e-02f, 3.68415006e-03f, -5.83680905e-02f, -2.83561405e-02f, -6.04347400e-02f,
  -6.53033704e-02f, 8.41781776e-03f, -1.02457893e-03f, -1.87820308e-02f, -1.25075117e-01f, -3.43361981e-02f, -5.71332453e-03f, -7.16524944e-02f, -3.55586633e-02f, -6.08211122e-02f,
  2.58005172e-01f, -2.38087431e-01f, 1.54974461e-01f, -9.74330455e-02f, 9.43646487e-03f, 1.01463040e-02f, -6.35406375e-02f, -3.58014815e-02f, 1.10697307e-01f, 7.90117234e-02f,
  -1.38350859e-01f, -7.12580457e-02f, -5.96801192e-02f, -7.75002018e-02f, -1.01631418e-01f, -2.29604635e-02f, 4.71977293e-02f, -9.37359594e-03f, 3.58258141e-03f, -2.42458563e-02f,
  6.40083477e-02f, 1.10821441e-01f, 2.16778859e-01f, 1.53631821e-01f, 1.05494566e-01f, 1.60473734e-01f, 7.48123275e-03f, -6.94695627e-03f, 7.00329542e-02f, 2.45861232e-01f,
  5.08715332e-01f, -1.15112685e-01f, 1.14731900e-01f, 2.50555634e-01f, 1.66536048e-01f, 1.79420725e-01f, 2.32295081e-01f, 1.13384552e-01f, 1.78254634e-01f, 6.59759017e-03f,
  -3.51295695e-02f, -1.20700367e-01f, -1.77930802e-01f, -1.98303685e-01f, -8.71982649e-02f, 9.53584909e-02f, 5.25174551e-02f, 1.04297504e-01f, 2.33474329e-01f, 1.24540158e-01f,
  5.31286001e-02f, 1.59809023e-01f, 2.26270348e-01f, 1.74603320e-03f, -4.35967557e-02f, -5.51263895e-03f, 4.93946411e-02f, 3.27209905e-02f, -1.41989008e-01f, -1.55207748e-02f,
  -7.47539252e-02f, -2.36968249e-02f, -6.65294821e-04f, -5.11557944e-02f, -6.53890967e-02f, -2.97222054e-03f, 8.92708823e-02f, -1.10278443e-01f, 2.26967745e-02f, -1.17704839e-01f,
  -8.22763219e-02f, 1.46523304e-02f, -2.05135718e-01f, -4.77045886e-02f, -9.65890884e-02f, 6.97655883e-03f, -7.55509362e-02f, -7.17737079e-02f, -7.39096329e-02f, -1.98979244e-01f,
  -1.47347569e-01f, -5.75847887e-02f, -6.62237182e-02f, -4.62439992e-02f, -1.19243242e-01f, 1.32281957e-02f, -9.82661322e-02f, -9.23214331e-02f, 1.31847784e-02f, 7.75785446e-02f,
  -2.82222070e-02f, 6.23286702e-03f, -2.42517516e-02f, -1.23351321e-01f, -1.80352703e-01f, 1.77252032e-02f, -6.38304055e-02f, -1.68911796e-02f, -1.09803028e-01f, -7.30198696e-02f,
  -1.26109883e-01f, -1.67484581e-01f, -1.74106881e-01f, 2.23087538e-02f, -1.24407046e-01f, -3.61558162e-02f, -2.54460070e-02f, -1.74642280e-01f, -1.49707332e-01f, -7.88886938e-03f,
  -1.37059599e-01f, -2.16666814e-02f, -2.57492103e-02f, -1.71955928e-01f, -1.17781281e-01f, -1.50797680e-01f, -8.34370777e-02f, -1.84162825e-01f, 4.61608283e-02f, 5.55770658e-02f,
  -3.03410321e-01f, -1.56484738e-01f, 1.34986103e-01f, -1.11624114e-01f, -2.54245978e-02f, 1.70767773e-03f, -3.30202878e-02f, 3.45579125e-02f, -7.76628852e-02f, -9.56019666e-03f,
  -3.91994342e-02f, 1.16777286e-01f, -3.98597866e-02f, -1.38960958e-01f, 9.07396600e-02f, 1.29260540e-01f, -4.49363738e-02f, 2.28100158e-02f, -2.70858537e-02f, -1.01095110e-01f,
  -6.00504838e-02f, 1.42673507e-01f, 4.93600555e-02f, 1.46145478e-01f, 1.38094738e-01f, 1.12103820e-01f, 1.07144699e-01f, 5.33653749e-03f, 2.83364649e-03f, 2.14531675e-01f,
  -2.61316806e-01f, 9.76381972e-02f, -1.57743856e-01f, 2.70812303e-01f, 2.96803504e-01f, -1.03173092e-01f, -2.14754567e-01f, -2.58657396e-01f, 2.39885319e-02f, 1.48385569e-01f,
  1.91102281e-01f, 2.43375406e-01f, 1.09046109e-01f, -1.11385807e-01f, -1.98563933e-01f, -3.82113121e-02f, 8.27899054e-02f, -1.88955709e-01f, -2.85330802e-01f, -1.26877338e-01f,
  1.41596898e-01f, -6.52292510e-03f, -3.80491912e-02f, -1.37304053e-01f, 1.54260799e-01f, 1.29794896e-01f, 1.38979152e-01f, 2.30223790e-01f, 1.47299320e-01f, 1.69248059e-01f,
  5.16883172e-02f, -1.09514855e-01f, -2.19376549e-01f, 4.33344170e-02f, 4.88868542e-02f, 2.40391698e-02f, -7.24060014e-02f, 9.86448601e-02f, 2.89813578e-02f, -2.60514114e-02f,
  1.80529267e-01f, 4.90106791e-02f, 5.96560910e-02f, 3.98348644e-02f, 6.43152073e-02f, -1.35807889e-02f, -6.71980679e-02f, -1.02533497e-01f, -1.42628342e-01f, -3.13969515e-02f,
  3.08629870e-01f, 2.79574007e-01f, 1.46817202e-02f, -1.58144265e-01f, -1.43272862e-01f, -4.69246469e-02f, -2.03807041e-01f, 2.93831713e-02f, -1.83892101e-01f, -1.09602809e-01f,
  -5.05648404e-02f, 3.30131128e-02f, -5.45440391e-02f, -6.75752088e-02f, 2.30441540e-02f, 8.75799060e-02f, 7.14793727e-02f, 6.50221556e-02f, 7.18226191e-03f, 2.87422724e-02f,
  -8.26026350e-02f, -2.44392492e-02f, -5.89117110e-02f, -3.04448251e-02f, -5.12315053e-03f, 9.90373418e-02f, -9.23018754e-02f, -3.11921816e-02f, 1.04550738e-02f, 5.08414656e-02f,
  4.32584621e-02f, -7.66384155e-02f, 3.68275344e-02f, -8.83982629e-02f, -2.37543341e-02f, -6.06939346e-02f, 7.80670941e-02f, -8.62877294e-02f, -4.59771976e-02f, -3.66492346e-02f,
  -4.69922312e-02f, -2.62032300e-01f, -1.25844851e-01f, -1.18481763e-01f, 4.70969863e-02f, 1.89199690e-02f, -3.76575091e-03f, -7.90259615e-02f, -5.23468107e-02f, 2.14711558e-02f,
  6.27113972e-03f, -2.04168651e-02f, -1.46025512e-02f, -1.03956256e-02f, -3.02180368e-02f, 1.16538696e-01f, -4.87532653e-03f, 3.18839028e-02f, -2.80301757e-02f, 1.02939703e-01f,
  -9.41790789e-02f, -1.89139545e-01f, -7.97040984e-02f, -2.06734568e-01f, -5.44117950e-02f, -1.56293094e-01f, -1.81887403e-01f, -1.19988672e-01f, -2.32810944e-01f, -2.20650271e-01f,
  2.19950557e-01f, 2.05692932e-01f, 1.73561111e-01f, 1.59348190e-01f, 1.18752331e-01f, -8.34054798e-02f, -8.81871581e-03f, -2.26292178e-01f, -1.02027103e-01f, 2.52758533e-01f,
  1.85825095e-01f, -3.92586589e-02f, -9.70416665e-02f, -1.51077867e-01f, -2.58755296e-01f, -1.07688587e-02f, -1.59424394e-02f, -1.28501087e-01f, -2.23673224e-01f, -2.47615978e-01f,
  -6.34215996e-02f, -7.66166439e-03f, 6.06354028e-02f, 2.62851641e-02f, 1.54875100e-01f, -4.08906750e-02f, 1.39571279e-01f, 2.25886256e-01f, 3.10859941e-02f, 2.57087290e-01f,
  2.47290447e-01f, 3.06156188e-01f, -2.49541357e-01f, -1.58971306e-02f, 1.69360101e-01f, 5.09319678e-02f, -2.55133677e-02f, 8.40577409e-02f, 8.70730951e-02f, 1.05254687e-01f,
  2.68022805e-01f, 8.33688974e-02f, 7.98146501e-02f, -7.55111054e-02f, 3.99723370e-03f, -1.30434126e-01f, -1.52509794e-01f, -4.94397469e-02f, -1.54360190e-01f, 4.06035744e-02f,
  -1.83731802e-02f, 1.09276503e-01f, 8.58003572e-02f, -1.32208735e-01f, -9.55462083e-02f, -1.01073004e-01f, 1.72016323e-02f, 5.61875887e-02f, -5.81689142e-02f, 1.36282325e-01f,
  -1.43025666e-01f, 1.53365076e-01f, 1.40736073e-01f, -3.46428156e-02f, -1.03206588e-02f, -1.27317272e-02f, 6.93213269e-02f, -5.02359793e-02f, -6.54423311e-02f, 8.53787437e-02f,
  -3.88609767e-02f, 3.21428403e-02f, 3.83761674e-02f, 7.34648556e-02f, -3.43409106e-02f, 1.16085142e-01f, -1.90532785e-02f, -4.89072315e-02f, -3.01265554e-03f, -6.67086691e-02f,
  -4.48131226e-02f, -3.56197916e-02f, 1.25417799e-01f, -1.12734791e-02f, 2.73889899e-02f, -6.21814318e-02f, 5.68087958e-02f, -7.01449364e-02f, -8.75905305e-02f, 1.73643962e-01f,
  1.51177183e-01f, -1.37606621e-01f, 1.82727128e-02f, -1.01972431e-01f, 9.29245576e-02f, -3.60501036e-02f, 2.37242039e-02f, -1.96553737e-01f, 8.84950161e-02f, 1.11560170e-02f,
  5.73409833e-02f, -8.34335461e-02f, 3.06702219e-02f, -1.08992986e-01f, -2.88067274e-02f, -9.54510942e-02f, -9.65881273e-02f, -1.11500606e-01f, -3.44842294e-04f, 7.12997792e-03f,
  -1.09321192e-01f, -2.97792107e-01f, -2.59344310e-01f, -2.63825327e-01f, -4.63751182e-02f, -2.18596637e-01f, -1.57866806e-01f, -1.05165459e-01f, -1.50794536e-01f, -1.63874611e-01f,
  2.87446707e-01f, -3.09952617e-01f, -4.57716852e-01f, 5.69935665e-02f, -1.40084043e-01f, 2.51937807e-02f, -8.29041004e-02f, 2.24665537e-01f, 2.40878418e-01f, -1.19499288e-01f,
  3.80510017e-02f, 1.16086669e-01f, 8.27435926e-02f, 1.99810620e-02f, 1.21416569e-01f, -2.89762229e-01f, -2.95812875e-01f, -9.69111472e-02f, 1.95945233e-01f, 3.07446182e-01f,
  9.02764127e-02f, 1.00809246e-01f, 1.76970512e-01f, 1.57504883e-02f, -3.96361314e-02f, 3.94064635e-02f, -2.15954587e-01f, -1.08201057e-01f, -1.32936880e-01f, -2.58320093e-01f,
  -3.38746831e-02f, -2.43338004e-01f, -1.98708680e-02f, -6.53764606e-02f, -2.48355523e-01f, -5.39494343e-02f, 8.25802982e-02f, -1.61366373e-01f, -8.86883214e-03f, -7.36626908e-02f,
  -1.08637169e-01f, -4.20311764e-02f, 1.05317146e-01f, 4.16632071e-02f, 2.46510450e-02f, 3.86596397e-02f, -1.68548957e-01f, -2.10787803e-01f, -1.90476522e-01f, 4.01406400e-02f,
  -1.07767209e-01f, -1.71101615e-01f, -2.21046522e-01f, -1.25901446e-01f, -6.26606792e-02f, -7.69923329e-02f, -1.58327729e-01f, -1.06412955e-01f, -9.34586003e-02f, -1.25896454e-01f,
  7.05433115e-02f, -5.55518754e-02f, -5.21817580e-02f, -2.68217060e-03f, -6.23207502e-02f, -3.77517864e-02f, -1.03151157e-01f, 2.84835417e-02f, 8.78106952e-02f, 6.76969737e-02f,
  3.13886404e-02f, -6.18375726e-02f, -5.40643148e-02f, 3.69116515e-02f, -3.75107080e-02f, -8.90032053e-02f, -3.17264125e-02f, 1.00078933e-01f, -3.91444303e-02f, -8.90273415e-03f,
  1.23542510e-01f, -4.92192321e-02f, -6.73223883e-02f, 1.09014273e-01f, -6.25626817e-02f, 8.98618549e-02f, 2.94846874e-02f, 8.55158269e-02f, 5.64816929e-02f, 9.24186781e-02f,
  3.61910850e-01f, -1.02661245e-01f, 5.31759560e-02f, 4.47537601e-02f, -5.11525236e-02f, -7.82460719e-02f, -7.47243688e-02f, -2.20175590e-02f, 2.67978571e-02f, 7.10351691e-02f,
  7.72436634e-02f, 6.54286221e-02f, -1.87786426e-02f, 4.53129550e-03f, 9.61599946e-02f, 7.72095621e-02f, 5.69892898e-02f, -6.76649958e-02f, 7.58118182e-02f, -2.56150990e-04f,
  6.49348870e-02f, 5.50774634e-02f, 3.37198153e-02f, -6.54295757e-02f, -6.67947717e-03f, 7.33996332e-02f, 1.40225023e-01f, 6.28152937e-02f, 8.03768337e-02f, 1.98595285e-01f,
  -5.23435473e-01f, 1.39713928e-01f, -3.55147794e-02f, -2.07836151e-01f, 1.10847272e-01f, 9.14609432e-02f, 2.36562401e-01f, -1.24676727e-01f, -9.75057185e-02f, 3.82852368e-02f,
  1.43304262e-02f, -3.51194143e-02f, 6.47683293e-02f, 1.15208492e-01f, -3.30691598e-02f, 2.69619018e-01f, 2.88567424e-01f, 3.53268385e-02f, -7.48925209e-02f, -4.52258587e-02f,
  8.90143141e-02f, 5.61703965e-02f, -2.65528470e-01f, -8.82972553e-02f, -2.11103093e-02f, 4.74080518e-02f, -9.80271306e-03f, 7.74776042e-02f, 6.07824326e-02f, 7.47631490e-02f,
  1.09932691e-01f, -4.56288487e-01f, -9.38275084e-02f, -1.22544624e-01f, -2.95242220e-02f, -1.17838435e-01f, -2.69763749e-02f, -2.06961364e-01f, -2.22364724e-01f, 4.03476320e-02f,
  -1.20458916e-01f, -1.18681826e-01f, -8.08966085e-02f, 8.90139043e-02f, -1.12063810e-01f, -4.07628827e-02f, -4.14980836e-02f, -9.68098491e-02f, -1.94403887e-01f, -1.28052652e-01f,
  7.72371665e-02f, -1.03059530e-01f, -1.47724181e-01f, -2.25344077e-02f, -3.65072303e-02f, -7.38184899e-02f, -1.17160067e-01f, -1.43285781e-01f, -2.37449601e-01f, -4.42038514e-02f,
  -4.71466817e-02f, 6.11352101e-02f, -2.45146248e-02f, 8.76852348e-02f, 1.28976047e-01f, 3.57436948e-02f, 4.01373729e-02f, 8.99999067e-02f, 6.01250827e-02f, -7.00771436e-02f,
  -6.07270002e-03f, -8.22937873e-04f, -4.11518402e-02f, -7.06855580e-02f, 3.82489339e-02f, -1.15190679e-02f, 1.22700054e-02f, 9.46353972e-02f, -2.81734243e-02f, -1.53182104e-01f,
  -2.17626020e-02f, 3.50101963e-02f, 1.50965815e-02f, 2.01848280e-02f, -4.70512994e-02f, -5.15993044e-04f, 3.60385794e-03f, -4.23312513e-03f, -4.93237153e-02f, -4.66067009e-02f,
  1.17044166e-01f, -1.86758384e-01f, 5.33152930e-02f, 1.15818098e-01f, -5.60576580e-02f, -9.17126015e-02f, 8.85303915e-02f, -5.97208329e-02f, -4.24311161e-02f, -5.94007522e-02f,
  -3.19886468e-02f, 5.41926222e-03f, 8.22426155e-02f, 1.05966106e-01f, 4.15120535e-02f, 4.68056165e-02f, 2.76382506e-01f, 5.41567914e-02f, 8.51352066e-02f, -7.24836886e-02f,
  1.66004881e-01f, 1.14058159e-01f, 6.82923943e-02f, 7.31355771e-02f, 1.25019342e-01f, 6.49602786e-02f, 5.57455346e-02f, 1.02822013e-01f, 5.34049831e-02f, 6.22799844e-02f,
  -1.68975756e-01f, -3.91106665e-01f, 2.11823329e-01f, -1.34246778e-02f, -1.52686030e-01f, -2.26865843e-01f, -4.46812451e-01f, -2.98598617e-01f, 2.28689462e-02f, -1.61950022e-01f,
  -1.45782441e-01f, 5.55536859e-02f, 1.04625560e-01f, 1.34598181e-01f, 4.32049707e-02f, -1.08537804e-02f, 1.71440750e-01f, 2.88401306e-01f, 2.26865113e-01f, -1.42443970e-01f,
  4.44814842e-03f, 9.43094417e-02f, 1.86946511e-01f, 1.07621662e-01f, 3.50303464e-02f, 1.24935545e-02f, 8.83160681e-02f, 8.78573209e-02f, -6.46092966e-02f, 1.13244258e-01f,
  -1.20887989e-02f, 5.24347313e-02f, 6.39922544e-02f, 1.70131668e-01f, -8.95285159e-02f, -1.77734792e-01f, -4.37348783e-02f, 1.12099327e-01f, 1.54565927e-02f, 1.07168794e-01f,
  -7.02990666e-02f, 3.05893887e-02f, -3.49243730e-02f, -5.02661392e-02f, 6.19773827e-02f, -1.45124033e-01f, 6.88093826e-02f, 1.05325185e-01f, -1.30714194e-04f, -8.74657035e-02f,
  -7.39000738e-02f, -9.17748511e-02f, 2.98304968e-02f, -7.79994428e-02f, -7.57486280e-03f, 1.35266259e-01f, -4.84337285e-02f, -4.30363864e-02f, -3.59727181e-02f, -1.31774873e-01f,
  9.62832943e-02f, 4.52556536e-02f, 1.44376103e-02f, -9.22176018e-02f, -3.47706676e-02f, 5.17941937e-02f, 4.04725447e-02f, 4.14876416e-02f, 7.48866722e-02f, -9.17088091e-02f,
  -7.75153190e-02f, 8.53147060e-02f, -2.98199877e-02f, -2.06862134e-03f, 1.47349924e-01f, -1.32003939e-02f, 4.77258442e-03f, 1.56151339e-01f, 6.78166300e-02f, 8.29624012e-03f,
  -4.74490039e-02f, -7.38549605e-02f, 8.07197541e-02f, -4.74151559e-02f, 1.42661566e-02f, -2.17238013e-02f, 3.98616493e-02f, -9.37301144e-02f, -5.55831529e-02f, 3.26667018e-02f,
  -2.20537871e-01f, 1.85617313e-01f, -1.60855666e-01f, 9.17259380e-02f, -7.73731992e-02f, 7.18031302e-02f, -4.67200391e-02f, 7.80194327e-02f, -8.00942183e-02f, -6.97438866e-02f,
  -2.61718392e-01f, -1.22344922e-02f, -2.33145691e-02f, 3.41041237e-02f, -7.86885992e-02f, -2.10089073e-01f, -1.35207504e-01f, -4.75841351e-02f, 5.32087311e-02f, -1.71351776e-01f,
  -1.65998980e-01f, -1.82795137e-01f, -6.74104169e-02f, -1.83222041e-01f, 2.44442257e-03f, -5.19761704e-02f, 5.89290336e-02f, 1.01985335e-02f, -6.25853240e-02f, -3.85691345e-01f,
  -1.11099862e-01f, -2.05802158e-01f, 2.01178323e-02f, 1.88859895e-01f, 2.62091279e-01f, 2.40725666e-01f, 7.46279284e-02f, 6.04802631e-02f, 1.55895576e-01f, 3.37593034e-02f,
  -5.96237481e-02f, -4.58140130e-04f, 3.98447923e-03f, 5.89748807e-02f, 6.57824278e-02f, 8.74268040e-02f, 1.79899156e-01f, 1.56834722e-01f, 1.14844754e-01f, 1.48671418e-02f,
  4.56900969e-02f, -2.95527233e-03f, -6.90496117e-02f, 9.42483842e-02f, 9.32829008e-02f, 5.15621416e-02f, 7.03757815e-03f, 3.12610157e-02f, -1.22542968e-02f, 4.56963219e-02f,
  -2.05018952e-01f, -7.28450567e-02f, 2.43346721e-01f, -3.24745625e-02f, -4.15947177e-02f, -1.61729351e-01f, 4.64431271e-02f, -1.40124261e-01f, -2.23475378e-02f, -1.39396591e-02f,
  -7.68589927e-03f, -1.63677871e-01f, 6.69044182e-02f, -2.20672973e-02f, 4.82979342e-02f, 5.00019416e-02f, -3.19906999e-03f, -8.46797451e-02f, 6.40129205e-03f, -1.25897322e-02f,
  3.43634151e-02f, -3.07564531e-02f, 2.51262411e-02f, 9.10264403e-02f, -4.86120917e-02f, 2.93737371e-02f, -1.00098722e-01f, -3.34669948e-02f, -8.75944272e-02f, -4.13319319e-02f,
  6.55288771e-02f, 6.85531134e-03f, 6.98466003e-02f, -1.36657357e-01f, -1.14390433e-01f, -2.70278705e-03f, 2.28016991e-02f, 5.84499948e-02f, 8.88156071e-02f, 1.30812554e-02f,
  9.31477025e-02f, 3.90909798e-02f, -2.94239614e-02f, -6.66913763e-02f, 1.03656895e-01f, 1.61357541e-02f, -8.89753643e-03f, 4.22711624e-03f, -4.50137407e-02f, -1.40737414e-01f,
  -4.53161821e-02f, 3.48359346e-02f, 1.38744032e-02f, 1.38416281e-02f, 3.44361104e-02f, 1.48472995e-01f, 8.55144709e-02f, 3.08253355e-02f, 4.72860709e-02f, 1.34998839e-02f,
  -3.10318023e-01f, 1.89322725e-01f, 3.16023268e-02f, -8.00639838e-02f, 7.03218440e-03f, -3.02798562e-02f, -2.36263331e-02f, -1.89145118e-01f, -1.81414723e-01f, -1.53914526e-01f,
  -1.73302621e-01f, 2.26575676e-02f, -2.66687684e-02f, -8.86551887e-02f, 2.97983959e-02f, 1.61054283e-02f, -2.63595991e-02f, 4.35610786e-02f, -8.46655145e-02f, -8.83538872e-02f,
  -4.23363075e-02f, 3.21415737e-02f, 8.69555771e-02f, 2.96916217e-02f, 1.72542892e-02f, -3.54725681e-02f, 3.23858559e-02f, -3.88148911e-02f, 2.22121552e-02f, -8.27212930e-02f,
  4.59244013e-01f, 1.24698773e-01f, 1.45066649e-01f, 7.84007236e-02f, 1.25576882e-02f, -3.90644148e-02f, 2.85359342e-02f, 1.60814449e-01f, 5.10647893e-02f, 1.63862824e-01f,
  7.89047405e-02f, 4.60944436e-02f, 7.97316805e-02f, -1.61109976e-02f, 8.74186680e-02f, 2.10650750e-02f, -4.36836258e-02f, 3.60912196e-02f, 9.73948911e-02f, 5.20760939e-02f,
  -1.94092486e-02f, 4.93457466e-02f, 1.32085815e-01f, -6.64108945e-03f, -1.04195729e-01f, -3.29004116e-02f, -7.56533071e-02f, 1.40206264e-02f, 4.06320347e-03f, -5.69240947e-04f,
  9.58030894e-02f, 1.30657047e-01f, -1.45690262e-01f, 1.83351785e-02f, 2.52768043e-02f, 3.36837880e-02f, 5.53859249e-02f, 1.34984963e-02f, -1.12742186e-01f, -1.33307070e-01f,
  -1.07199654e-01f, -9.11942571e-02f, -5.18829487e-02f, 8.62289872e-03f, -6.14329241e-03f, -7.05583990e-02f, -7.30941519e-02f, -7.89494589e-02f, -6.54043779e-02f, -3.84925790e-02f,
  -1.71439853e-02f, -5.75529598e-02f, -9.88558829e-02f, -5.97793330e-03f, 3.13258395e-02f, 1.42649338e-02f, -7.27134347e-02f, 6.05412722e-02f, -4.53062318e-02f, 5.17602302e-02f,
  7.16546401e-02f, 2.00243536e-02f, 1.43041238e-02f, -7.28644803e-02f, -1.40001148e-01f, 8.02091602e-03f, -7.50885904e-02f, -9.14882794e-02f, -4.92422692e-02f, -9.87282172e-02f,
  -6.05431423e-02f, 1.98106132e-02f, 3.15193981e-02f, 2.94100586e-02f, -1.01350490e-02f, 2.34335400e-02f, -4.94746305e-02f, 2.87137763e-03f, 9.94054414e-03f, -4.02900353e-02f,
  4.43376340e-02f, -4.88508418e-02f, -7.81211862e-03f, -1.00520432e-01f, 9.92923882e-03f, -5.11511862e-02f, 1.39542846e-02f, -1.95418280e-02f, 2.37126295e-02f, -4.13788203e-03f,
  -2.59425908e-01f, 2.06051767e-02f, -8.70343000e-02f, -4.26957384e-03f, 3.94020602e-02f, -1.56079493e-02f, 2.98717283e-02f, -4.93941829e-02f, -6.61048368e-02f, 3.90591212e-02f,
  1.74006764e-02f, 7.18466863e-02f, -3.83844376e-02f, -7.09043294e-02f, -7.24226087e-02f, -1.09605834e-01f, -9.10981596e-02f, -3.78951430e-02f, -3.72769833e-02f, 1.75563395e-02f,
  -5.63971289e-02f, -2.58757602e-02f, -6.67427480e-02f, 2.98480075e-02f, 5.39857559e-02f, 4.30423357e-02f, -1.94994919e-02f, -5.10586612e-02f, 9.74679440e-02f, -9.37872380e-02f,
  -4.11033601e-01f, 2.39103884e-01f, -1.32935315e-01f, 2.31245812e-02f, 2.67176747e-01f, 1.59920096e-01f, 3.07350576e-01f, 1.45667553e-01f, 7.66312405e-02f, 9.06325504e-02f,
  1.53092340e-01f, 8.41816440e-02f, 8.33429843e-02f, 7.38826767e-02f, 2.40524262e-02f, 2.12857649e-01f, 9.94154066e-02f, -9.07799695e-03f, -1.39627412e-01f, 1.01009719e-01f,
  1.44286424e-01f, 1.03435367e-02f, -2.44300276e-01f, -1.80981942e-02f, 3.15814205e-02f, -1.25364773e-02f, 8.59175175e-02f, 1.54618442e-01f, 2.02861652e-01f, 6.91246539e-02f,
  -1.46593213e-01f, 9.87589061e-02f, 2.04898976e-03f, -4.90344912e-02f, -2.99709924e-02f, -1.96029425e-01f, -9.70166773e-02f, -9.33659524e-02f, 2.93827206e-02f, 4.59121838e-02f,
  5.57195991e-02f, -1.05368182e-01f, 8.21225643e-02f, -8.34327042e-02f, -4.83479723e-02f, -1.31610960e-01f, -2.26482060e-02f, 6.03629053e-02f, 1.82386503e-01f, 9.01552439e-02f,
  9.40790921e-02f, 1.55881509e-01f, 5.73995896e-02f, 1.88471600e-01f, 2.89812684e-02f, 7.60312155e-02f, 8.90318453e-02f, -3.35222147e-02f, -5.07566474e-05f, -1.21316254e-01f,
  4.50717099e-02f, -1.27344597e-02f, 3.61243542e-03f, -7.64000490e-02f, -3.81129161e-02f, -4.82353158e-02f, -8.10352638e-02f, 6.77746162e-02f, -1.67521778e-02f, -1.58984326e-02f,
  4.87919990e-03f, 3.20469141e-02f, -5.74985370e-02f, -1.78951263e-01f, -8.04169700e-02f, 7.09480867e-02f, -5.53184971e-02f, -1.20587371e-01f, 4.79914062e-02f, 1.61457788e-02f,
  8.20203200e-02f, 6.62383512e-02f, -1.15621723e-01f, 7.63356360e-03f, 7.32044056e-02f, 8.87725968e-03f, -6.83351606e-02f, 1.89324804e-02f, -1.71017721e-02f, 4.66024466e-02f,
  4.67835180e-02f, 2.55008727e-01f, -7.26049766e-02f, -6.06187619e-02f, -1.03582576e-01f, -1.91227853e-01f, 3.83803761e-03f, -8.87035429e-02f, 1.41372718e-02f, -4.99445684e-02f,
  -2.56018830e-03f, -2.26781577e-01f, -7.05830334e-03f, -8.37346688e-02f, -1.31045237e-01f, -1.18385173e-01f, -1.49480239e-01f, 6.21981965e-03f, 1.45968243e-01f, -5.52658625e-02f,
  2.55085435e-02f, 3.73484306e-02f, -3.05364840e-03f, -1.84511319e-02f, 2.16148030e-02f, -5.51084466e-02f, -3.79144587e-02f, -4.47091758e-02f, 3.06461193e-02f, -1.25380620e-01f,
  -4.37645495e-01f, 3.32376689e-01f, 1.99396148e-01f, -7.98001289e-02f, 1.35681629e-01f, -5.58008105e-02f, 2.22191047e-02f, -1.81315884e-01f, -1.22190267e-01f, 3.38605911e-01f,
  1.25886425e-01f, -3.11350167e-01f, -1.87124655e-01f, -2.12892085e-01f, -3.56677383e-01f, 1.37589842e-01f, -5.81975840e-02f, -4.01127636e-01f, -5.94324529e-01f, -3.07699740e-01f,
  -2.63931602e-01f, -1.87302902e-01f, -3.75880927e-01f, -2.54798889e-01f, 1.58543587e-01f, -2.26786584e-01f, 1.43456504e-01f, -1.31817177e-01f, 8.65141302e-02f, 1.68604150e-01f,
  2.53092647e-01f, 1.60756320e-01f, -1.18432440e-01f, -1.66404933e-01f, 8.03987160e-02f, 8.71319696e-03f, 4.33804318e-02f, 8.51316750e-02f, 3.59738730e-02f, 7.42775798e-02f,
  1.48180518e-02f, -6.18471624e-03f, -1.19472863e-02f, 1.30787250e-02f, -2.48122364e-02f, -7.42214844e-02f, 1.16247967e-01f, -6.28606901e-02f, -4.15850841e-02f, 1.56592175e-01f,
  1.05738424e-01f, 1.14974432e-01f, 1.97666362e-02f, 5.59234619e-02f, 6.75253496e-02f, -4.66335900e-02f, 1.26916960e-01f, -6.79211617e-02f, 7.96972513e-02f, 9.53862965e-02f,
  5.65862888e-03f, -2.61929091e-02f, 3.02284192e-02f, -4.17111516e-02f, 1.53667084e-03f, 1.11486338e-01f, -9.50798690e-02f, 1.17000975e-01f, -5.25826029e-02f, -4.68877330e-02f,
  9.11274552e-02f, 4.83457595e-02f, -6.97754184e-03f, 5.66547103e-02f, -2.70476099e-02f, 3.39314640e-02f, 6.56028762e-02f, 9.12155490e-03f, -1.90929528e-02f, 4.68969345e-02f,
  1.55653022e-02f, 6.32235557e-02f, -1.18085891e-02f, -7.09224259e-03f, 1.27012178e-01f, 4.98959087e-02f, 9.90772843e-02f, 6.25886917e-02f, -7.11334795e-02f, 2.69901231e-02f,
  8.13882146e-03f, -8.60748440e-02f, -3.41950916e-02f, -1.33533971e-02f, 8.51868317e-02f, 2.17693523e-01f, 3.76863703e-02f, 5.32637537e-02f, 6.53229132e-02f, 1.14978969e-01f,
  -7.77233858e-03f, 5.64321131e-02f, 5.10740206e-02f, -5.11991121e-02f, -1.40815407e-01f, 4.03134562e-02f, 1.30209699e-01f, -1.46410719e-01f, 3.21056470e-02f, 1.07442446e-01f,
  1.60601407e-01f, 8.81728902e-03f, -1.57137483e-01f, -4.59413864e-02f, 4.10790332e-02f, -6.24839254e-02f, -1.09479770e-01f, 6.72949478e-02f, -5.13710938e-02f, 1.44889094e-02f,
  -6.31420970e-01f, 1.79377273e-01f, 2.22930178e-01f, -4.21367496e-01f, -2.56952755e-02f, 4.33553159e-02f, 2.38582090e-01f, -5.49117923e-02f, -3.11786324e-01f, 6.38825912e-03f,
  8.85255933e-02f, -6.76755384e-02f, -9.99749973e-02f, -8.10496956e-02f, -1.02040976e-01f, 1.19511180e-01f, -2.04860300e-01f, -2.98621237e-01f, -1.94810629e-01f, -4.43953238e-02f,
  -3.07351816e-02f, -1.75407305e-01f, -2.73950338e-01f, -1.85076281e-01f, 1.28202438e-02f, -1.57975778e-01f, 7.45280236e-02f, -5.77303693e-02f, 2.78808568e-02f, -6.42362460e-02f,
  2.64509529e-01f, -9.62736458e-02f, 5.60434759e-02f, -1.08950712e-01f, 2.09664889e-02f, -4.22279797e-02f, -1.71139225e-01f, -1.71839576e-02f, 1.05684728e-03f, -8.81644487e-02f,
  -1.61082014e-01f, 2.90333889e-02f, -1.26283839e-01f, 1.90239993e-03f, -1.59907773e-01f, -4.38519455e-02f, -5.81512935e-02f, -1.35944545e-01f, -6.11506552e-02f, 2.25214571e-01f,
  1.98761523e-01f, 2.05706805e-02f, 8.34624618e-02f, 1.51848003e-01f, 6.46217912e-02f, -6.82119802e-02f, 1.37180939e-01f, 1.40999690e-01f, -1.69686265e-02f, 1.11263186e-01f,
  8.70668739e-02f, -5.95035963e-02f, -4.80995281e-03f, 2.62707807e-02f, -3.09798829e-02f, 6.63642436e-02f, -2.94907261e-02f, -1.25258695e-02f, -1.20486289e-01f, 2.39272974e-02f,
  -1.32545214e-02f, 6.79945722e-02f, -1.10434182e-01f, -2.28951517e-02f, 2.76363809e-02f, -1.59463249e-02f, -7.46379867e-02f, 7.69823119e-02f, 3.41420509e-02f, -1.08875580e-01f,
  -1.65824126e-02f, -1.31231863e-02f, -7.90101662e-02f, -5.75004108e-02f, -4.10117060e-02f, -7.37370625e-02f, 1.98713760e-03f, 7.53177255e-02f, 2.47515496e-02f, -3.01985554e-02f,
  5.67340143e-02f, -1.20320931e-01f, -8.69750530e-02f, 8.88401791e-02f, -1.42414927e-01f, 5.82260452e-02f, -1.44975409e-02f, -4.30077091e-02f, -5.15001863e-02f, -9.18421075e-02f,
  3.06699774e-03f, 2.42585707e-02f, -5.59341069e-03f, 9.14997458e-02f, -2.72770263e-02f, 1.64475404e-02f, 1.74006343e-01f, 5.14642298e-02f, -2.46577952e-02f, 1.70913655e-02f,
  9.72007960e-02f, -6.15927726e-02f, -2.17842888e-02f, 1.09401919e-01f, -1.38665680e-02f, -3.37342471e-02f, 3.42502631e-03f, 5.30619137e-02f, -7.99226463e-02f, 8.64483267e-02f,
  -3.20228279e-01f, -1.15464255e-01f, 2.31635034e-01f, 4.45151962e-02f, 1.26694933e-01f, 1.54532522e-01f, 1.86530635e-01f, -1.38827823e-02f, -1.67982019e-02f, -4.02834564e-02f,
  -1.11157950e-02f, -1.58373937e-01f, -1.64577425e-01f, -5.26009165e-02f, -5.09968624e-02f, 1.35570183e-01f, 1.93223834e-01f, 2.19035465e-02f, -3.11967526e-02f, 5.71124367e-02f,
  -9.30567682e-02f, -4.95490879e-02f, -5.68394437e-02f, -9.38702300e-02f, 1.95046682e-02f, -7.67461210e-02f, 1.29095703e-01f, 3.83338258e-02f, 1.60165690e-02f, 1.23563083e-02f,
  1.56151876e-01f, -8.55569839e-02f, -1.39302080e-02f, -1.45637915e-01f, -4.68065310e-03f, 5.21817915e-02f, 6.56701550e-02f, 2.00933199e-02f, 4.57786806e-02f, 6.34013936e-02f,
  -5.80240153e-02f, -1.01074995e-02f, 5.68092521e-03f, -1.08023264e-01f, 6.63913041e-02f, -1.30694220e-02f, -1.48427948e-01f, -1.34238437e-01f, -9.87117365e-02f, -2.64070630e-02f,
  -2.16167033e-01f, -1.24696337e-01f, 1.55770394e-03f, -5.42641506e-02f, 3.91840003e-02f, 1.40865361e-02f, -9.71782506e-02f, -5.95754832e-02f, -9.85396206e-02f, -8.29010159e-02f,
  -4.08051014e-02f, 5.45568578e-02f, -8.72164816e-02f, 8.54927674e-02f, -2.57968884e-02f, 1.00859269e-01f, 4.06908207e-02f, 6.78303316e-02f, 8.29817578e-02f, 1.88367233e-01f,
  5.26658678e-03f, 1.91602141e-01f, 1.50919572e-01f, 1.28360927e-01f, 1.18876800e-01f, 1.57071069e-01f, 1.82023063e-01f, 1.49131678e-02f, 6.92514703e-02f, 8.94681960e-02f,
  2.25941557e-02f, 1.41676694e-01f, 4.21085805e-02f, 1.05551101e-01f, 7.29008764e-02f, 3.69150788e-02f, 4.80973162e-02f, 1.12237588e-01f, 1.35497242e-01f, 8.57884511e-02f,
  2.02075690e-01f, -5.73371165e-02f, 1.76116347e-01f, -6.08599074e-02f, 1.13243073e-01f, 2.88605317e-02f, 1.01981051e-01f, 1.70685854e-02f, 1.58814415e-01f, 3.91225889e-02f,
  9.09469128e-02f, 7.04184696e-02f, 3.43901478e-02f, 7.20913783e-02f, 2.30816230e-02f, 5.10593131e-02f, 2.30385605e-02f, -1.81343232e-03f, 3.54236476e-02f, 1.80662386e-02f,
  2.98153590e-02f, -4.16239761e-02f, 1.19975217e-01f, 1.53670087e-01f, 1.01550091e-02f, 7.39488006e-02f, 1.49933770e-01f, 1.36128783e-01f, 1.62953615e-01f, 9.19390470e-02f,
  -3.03423434e-01f, -2.68972144e-02f, -2.24615872e-01f, -1.81658387e-01f, 1.48434833e-01f, 3.81202757e-01f, 3.48305702e-01f, 1.57494500e-01f, 5.40220998e-02f, -6.76769018e-02f,
  5.70617579e-02f, 1.03928119e-01f, -9.95074585e-02f, 7.02091828e-02f, 2.11104155e-01f, 4.58682403e-02f, 4.29804921e-02f, -1.04907647e-01f, 1.30056664e-01f, 1.70150086e-01f,
  9.88877490e-02f, 5.99635690e-02f, -4.48235720e-02f, 9.69567224e-02f, -9.13150385e-02f, -1.51072130e-01f, -1.97573572e-01f, -1.65618718e-01f, 1.45881753e-02f, -3.61521304e-01f,
  -3.00474972e-01f, -3.51374894e-01f, 1.28733352e-01f, 5.43791875e-02f, -2.31325611e-01f, -7.51187801e-02f, 7.18861371e-02f, -2.01638937e-01f, 8.09530448e-03f, -9.11578089e-02f,
  -5.15662767e-02f, 9.95470807e-02f, -1.12938017e-01f, 2.88332673e-03f, -9.82033014e-02f, 1.05158731e-01f, -8.57110023e-02f, -9.86200944e-02f, -2.01302990e-01f, 3.66070867e-02f,
  1.93484783e-01f, -1.31098619e-02f, -2.97777712e-01f, 4.91411835e-02f, -1.09091982e-01f, -1.55033236e-02f, 3.17491144e-02f, -4.17718329e-02f, -8.40827599e-02f, -2.75975019e-01f,
  2.93317940e-02f, -7.24407956e-02f, 1.76189803e-02f, 4.72536460e-02f, -2.04324815e-02f, 3.84534635e-02f, 5.09840623e-02f, 2.20107920e-02f, 1.28166184e-01f, 1.99034414e-03f,
  1.20970443e-01f, -1.37643274e-02f, -3.27804573e-02f, 6.73902333e-02f, -2.67574284e-02f, 4.33840826e-02f, -2.49185469e-02f, -3.07743857e-03f, 3.54648009e-02f, -3.05416305e-02f,
  1.34285957e-01f, -3.02683748e-02f, -1.38529927e-01f, 2.85357721e-02f, 2.58745858e-04f, 1.22941025e-02f, 6.64141849e-02f, 8.41382146e-03f, -1.16343021e-01f, 7.09481090e-02f,
  -2.58971993e-02f, 1.81577116e-01f, -2.15337083e-01f, 8.60274285e-02f, -6.05119579e-02f, -8.69676378e-03f, -2.49920953e-02f, -2.63148528e-02f, 2.54491046e-02f, 1.10273650e-02f,
  9.40608606e-02f, -9.20667499e-02f, -1.37505800e-01f, -1.10292919e-01f, -4.16315384e-02f, -7.69056529e-02f, 1.94238834e-02f, 4.55913804e-02f, 9.47822928e-02f, -2.36844029e-02f,
  -1.36661539e-02f, -1.37623365e-03f, -2.71334797e-01f, -6.27920702e-02f, -2.16312692e-01f, -3.30780819e-02f, -1.25116661e-01f, -1.35429680e-01f, 1.03967953e-02f, -2.43473947e-01f,
  -3.39477181e-01f, -1.26183957e-01f, 2.64578700e-01f, -2.54981041e-01f, 5.53803844e-03f, 1.55044273e-01f, -3.92291360e-02f, 6.60781711e-02f, -6.53309599e-02f, -1.98445067e-01f,
  1.25541510e-02f, -1.50450930e-01f, -7.11797103e-02f, 7.33020604e-02f, 5.78188822e-02f, -9.54442546e-02f, -8.19202140e-02f, 6.31086007e-02f, 1.93217203e-01f, 1.13387063e-01f,
  -3.30385305e-02f, -1.64542526e-01f, -3.27443741e-02f, -7.46365339e-02f, -2.76807904e-01f, -1.11308418e-01f, -1.53101087e-01f, -1.49557859e-01f, -4.31167856e-02f, -3.45824152e-01f,
  -1.15600370e-01f, -2.84145959e-02f, 1.81715846e-01f, -1.88823059e-01f, -1.89770665e-02f, -1.03937201e-01f, -1.09122414e-02f, 8.57177228e-02f, -9.55028236e-02f, 5.88445365e-02f,
  -1.93885043e-02f, 1.41943008e-01f, -4.60884627e-03f, 4.24802750e-02f, 3.16697098e-02f, 1.29468720e-02f, 2.62802392e-02f, 1.05457895e-01f, 9.02241245e-02f, 5.98595031e-02f,
  -3.41510363e-02f, -8.65076184e-02f, -4.53866869e-02f, 9.24841836e-02f, 2.10703798e-02f, -8.28793943e-02f, 5.19114546e-02f, -1.42586185e-02f, 1.49053290e-01f, -3.51513892e-01f,
  -2.99625192e-02f, 1.01226732e-01f, 1.10330991e-01f, -1.86659209e-03f, 6.22423626e-02f, -5.41113922e-03f, 1.49208969e-02f, -1.47480056e-01f, 4.65802923e-02f, 4.50755619e-02f,
  4.07970883e-02f, -3.51974480e-02f, 4.38704807e-03f, -1.91642225e-01f, -6.95101544e-02f, -2.23894045e-02f, -1.80775225e-02f, -1.40815139e-01f, -2.05725543e-02f, -8.89156833e-02f,
  -3.24322022e-02f, 1.21376384e-02f, -7.58635551e-02f, 6.23380914e-02f, 1.48432842e-02f, -8.94470490e-04f, -2.41023768e-02f, 9.64660123e-02f, -8.51501301e-02f, -1.20658726e-01f,
  -1.55890048e-01f, 1.44139215e-01f, -3.11701775e-01f, 5.43932877e-02f, 2.90906355e-02f, -3.54157500e-02f, -9.17408988e-02f, 1.37236401e-01f, -6.66784719e-02f, -4.28597722e-03f,
  7.23892003e-02f, 4.17669639e-02f, -2.13810384e-01f, 5.45205474e-02f, -5.99354766e-02f, -6.75885305e-02f, -1.21286504e-01f, -1.06582418e-02f, 8.98343697e-03f, -3.94984819e-02f,
  -7.78012201e-02f, -2.16421843e-01f, -2.36805379e-01f, -2.79646993e-01f, -2.40057439e-01f, -2.10268721e-01f, -1.53789312e-01f, -1.82805762e-01f, -1.47148132e-01f, -4.57681596e-01f,
  4.53307927e-01f, -1.04768790e-01f, -3.05997640e-01f, 1.78369254e-01f, -1.58850074e-01f, -1.36703774e-01f, -3.87577206e-01f, 1.02648959e-01f, 2.31212243e-01f, -1.96277246e-01f,
  -1.53749198e-01f, 1.11295983e-01f, -8.62988010e-02f, 4.26285341e-03f, -1.18663631e-01f, -3.62039506e-01f, -1.88039824e-01f, -3.96508910e-02f, 8.63723680e-02f, -7.13040605e-02f,
  -6.52429275e-03f, 4.04071622e-02f, 1.64165586e-01f, -3.14457119e-02f, -7.72841126e-02f, -2.72862595e-02f, -2.58103073e-01f, -1.71738535e-01f, -2.97613025e-01f, -2.16947138e-01f,
  -2.86547959e-01f, -5.43269962e-02f, -3.87312137e-02f, 1.25549123e-01f, -2.50213128e-02f, 6.22540489e-02f, -6.90035149e-02f, -2.83044316e-02f, -1.31735345e-02f, -1.06672579e-02f,
  -7.22210994e-03f, 7.17860684e-02f, 1.48781259e-02f, -1.44484490e-02f, -8.07712674e-02f, 6.62097055e-03f, -1.34360045e-01f, -3.28652821e-02f, -1.25601470e-01f, -9.67330337e-02f,
  -2.92306822e-02f, -2.15224437e-02f, 2.10848283e-02f, 2.06889603e-02f, -9.12400559e-02f, -8.57845321e-02f, -1.03817023e-01f, -1.40053675e-01f, -2.07810447e-01f, -2.43482273e-02f,
  8.95247683e-02f, -8.63498226e-02f, 1.03487521e-02f, -4.52400297e-02f, -7.78187439e-02f, -5.05128317e-02f, 2.53488924e-02f, -6.83811009e-02f, -9.03273094e-03f, 7.35609457e-02f,
  4.59890552e-02f, -3.10955532e-02f, 3.46329473e-02f, 5.04216366e-02f, -6.97386041e-02f, 1.69034880e-02f, -4.68689129e-02f, -9.59719438e-03f, -5.77167310e-02f, -1.54380221e-02f,
  -4.21729647e-02f, -8.84200854e-04f, -1.00063466e-01f, 6.60696104e-02f, -6.32453039e-02f, 1.06410710e-02f, 1.73684582e-02f, 8.35128650e-02f, -7.86356570e-04f, 3.39998631e-03f,
  7.95545653e-02f, -1.35106118e-02f, -9.00683478e-02f, 5.83068356e-02f, 1.24994442e-02f, -2.74986885e-02f, -2.14897525e-02f, -5.34624755e-02f, 1.26259163e-01f, 5.54823643e-03f,
  3.53204608e-02f, 1.37658522e-01f, 7.88950641e-03f, -3.45135964e-02f, 1.43455090e-02f, -1.19139794e-02f, 8.28575529e-03f, 6.89192489e-02f, -5.53296916e-02f, 7.10734576e-02f,
  4.81858104e-02f, 4.24137563e-02f, 1.84489384e-01f, 2.77059600e-02f, 8.18482861e-02f, 9.35310274e-02f, -1.35108039e-01f, -1.33839599e-03f, 2.69757826e-02f, 9.40021351e-02f,
  1.69382885e-01f, 1.26984537e-01f, 2.36299291e-01f, -1.38004169e-01f, -3.80739808e-01f, -2.21763715e-01f, -3.05218697e-01f, -1.72035187e-01f, -1.67149082e-01f, 4.45708595e-02f,
  -3.48635912e-02f, -1.94300622e-01f, -1.33058140e-02f, 1.52152432e-02f, 3.27504650e-02f, 1.61962360e-01f, 1.50108621e-01f, 2.22183496e-01f, -1.21790199e-02f, -1.30550072e-01f,
  -1.00387134e-01f, -6.46233410e-02f, 2.03291550e-01f, 1.16561808e-01f, -8.87146499e-03f, 2.46925540e-02f, 1.85892433e-01f, 1.50359953e-02f, 2.30270438e-03f, 2.10270911e-01f,
  1.49517193e-01f, 2.66213238e-01f, -9.31472704e-02f, -1.49596915e-01f, 2.43576877e-02f, -1.30570317e-02f, 3.22648510e-03f, 2.10239857e-01f, -6.60301819e-02f, -2.91945077e-02f,
  -1.10202603e-01f, 1.55757358e-02f, -1.21313460e-01f, 1.04545634e-02f, -5.77264577e-02f, -1.08931988e-01f, 1.38484254e-01f, 1.48401707e-01f, 9.45510715e-02f, 5.26933698e-03f,
  -2.93606728e-01f, -9.22598913e-02f, 6.28428087e-02f, -1.06097326e-01f, 9.61205810e-02f, -1.09200694e-01f, -7.96766728e-02f, -5.82549050e-02f, -4.55132313e-02f, 1.46351829e-01f,
  4.38202545e-03f, 7.36974999e-02f, -2.67991740e-02f, 1.40141755e-01f, -8.93685892e-02f, -6.50939420e-02f, -6.66278005e-02f, -7.21254423e-02f, -1.40545517e-02f, -5.78995384e-02f,
  -2.87177265e-02f, 7.10416003e-04f, 4.39451598e-02f, -5.34513593e-02f, -2.46357694e-02f, -1.77296177e-02f, -7.41502419e-02f, 1.28568292e-01f, 9.06655099e-03f, 5.30497991e-02f,
  -8.35018829e-02f, 8.27913638e-03f, 8.22085217e-02f, -2.55929213e-02f, 1.07926503e-01f, 3.61667350e-02f, 7.88180009e-02f, -1.05802476e-01f, -1.14500653e-02f, 1.25883937e-01f,
  -7.64229223e-02f, -1.30234852e-01f, 1.28467744e-02f, -9.59308818e-02f, -8.17387849e-02f, 4.79114195e-03f, -6.37644157e-02f, -2.50455886e-02f, -5.93143702e-02f, -4.13101055e-02f,
  -3.79144512e-02f, -8.26298147e-02f, 1.86067005e-03f, -5.17709088e-03f, -1.43599510e-01f, -3.59085649e-02f, -9.13113356e-02f, -1.78073794e-01f, -2.06494331e-01f, -1.48398727e-02f,
  -1.09630466e-01f, -2.46715844e-01f, -1.05951570e-01f, -1.11850850e-01f, -1.35323957e-01f, -2.38059625e-01f, -1.83359697e-01f, -1.60268262e-01f, -6.50136396e-02f, -1.70076728e-01f,
  3.86058629e-01f, 1.71503603e-01f, 2.09885493e-01f, 4.04549390e-02f, -1.97920531e-01f, -1.57160491e-01f, -1.09938152e-01f, -4.98339860e-03f, 3.86867598e-02f, 1.11237457e-02f,
  -6.85281381e-02f, -1.12664334e-01f, -8.46292675e-02f, -5.39109781e-02f, 4.73910794e-02f, 1.32163540e-01f, 1.94603018e-02f, 2.34884366e-01f, 1.56699196e-01f, -5.84943928e-02f,
  -7.33341426e-02f, 8.25506002e-02f, 2.07720771e-01f, 1.13824736e-02f, 6.34382442e-02f, -1.41615300e-02f, -7.51995072e-02f, 3.55401374e-02f, -1.07052647e-01f, 2.91693896e-01f,
  5.08481897e-02f, 1.53136685e-01f, -9.00718346e-02f, -2.91963294e-02f, 5.06870523e-02f, 3.16788405e-02f, 5.46531714e-02f, -2.89810691e-02f, -3.53418961e-02f, 4.29046080e-02f,
  5.27282842e-02f, 5.82450218e-02f, 1.20685715e-02f, 6.95582666e-03f, -5.03446274e-02f, -9.55200642e-02f, 1.02302298e-01f, 1.34847477e-01f, 1.06064968e-01f, 3.43188061e-04f,
  -2.84909811e-02f, -1.22092895e-01f, -1.31182000e-01f, -1.73300147e-01f, -4.43626195e-02f, -7.59813190e-02f, -1.28444463e-01f, 3.86067256e-02f, -9.83013958e-02f, 3.34548801e-02f,
  -4.01234403e-02f, -1.03357390e-01f, -1.06547512e-01f, -1.34987772e-01f, -8.61329585e-02f, -1.24694750e-01f, -6.31332723e-03f, -1.88898575e-02f, -6.73902687e-03f, 3.00740562e-02f,
  -1.56898931e-01f, -3.47382911e-02f, -7.40100145e-02f, -1.97598077e-02f, -7.36667663e-02f, -1.89454462e-02f, 1.34474905e-02f, -7.55843415e-04f, -7.27248341e-02f, -6.64091036e-02f,
  1.95152611e-02f, -2.58828048e-02f, -1.53967604e-01f, 1.91343799e-02f, -3.50405648e-02f, -7.84200504e-02f, -5.06376550e-02f, -2.79327873e-02f, -6.99873939e-02f, -7.80645981e-02f,
  -1.75573170e-01f, -3.72939348e-01f, -7.96843879e-03f, 1.31773904e-01f, 1.22453049e-01f, -5.81336133e-02f, 9.69429687e-02f, 2.04633642e-02f, -5.27401529e-02f, 2.68828520e-03f,
  6.20097034e-02f, 1.63072750e-01f, 3.09605673e-02f, 6.21914417e-02f, 2.38557383e-02f, -6.40594736e-02f, -6.73889816e-02f, 6.68058619e-02f, 3.65108028e-02f, 2.64218100e-03f,
  -3.07533201e-02f, -1.09338403e-01f, -1.79861650e-01f, -7.89770633e-02f, -1.72190592e-02f, -2.07059190e-01f, -1.77000239e-01f, 8.89382418e-03f, -9.55593958e-02f, -1.10099062e-01f,
  -6.06760345e-02f, -3.23053211e-01f, -1.88203722e-01f, -1.54441312e-01f, -1.32424638e-01f, 1.34641789e-02f, -1.97198540e-01f, -1.60522968e-01f, -2.05911413e-01f, -2.85741240e-01f,
  -1.06454924e-01f, 1.40094519e-01f, 8.17525908e-02f, 9.38378349e-02f, 1.91050917e-01f, -7.80760124e-02f, -2.80028760e-01f, 1.34532511e-01f, 3.62997800e-01f, 1.39547661e-01f,
  3.80140617e-02f, 1.28822094e-02f, -6.99069053e-02f, -8.66843238e-02f, -3.08609337e-01f, -5.16086863e-03f, -2.09873736e-01f, -1.92903772e-01f, -1.34130090e-01f, -3.92709404e-01f,
  2.03748286e-01f, -1.83772013e-01f, -6.33351281e-02f, -1.61897108e-01f, -2.79473606e-02f, -7.30386528e-05f, 2.71422081e-02f, -6.26627654e-02f, 2.10828949e-02f, -2.29756478e-02f,
  -7.00957850e-02f, 2.22224393e-03f, 1.22154258e-01f, 1.13821859e-02f, 5.11844344e-02f, 6.59016967e-02f, -1.48098215e-01f, -1.47621632e-01f, -4.82858270e-02f, 8.28124508e-02f,
  3.11601441e-02f, -9.31788459e-02f, 3.08619700e-02f, 2.70244274e-02f, 3.20957936e-02f, -3.94694228e-03f, -1.02016237e-02f, -7.10003451e-02f, 6.03023805e-02f, -1.15314737e-01f,
  1.04038469e-01f, 6.48752693e-03f, -7.17431307e-02f, 4.93535362e-02f, 4.56321426e-02f, -4.06117514e-02f, 1.03857495e-01f, 5.84209971e-02f, -1.12463653e-01f, -7.39395469e-02f,
  -3.86336148e-02f, -6.26119226e-02f, 3.07263825e-02f, 1.59411822e-02f, -1.46335363e-01f, -1.16450764e-01f, -1.16182603e-01f, -3.31701158e-04f, -7.80664161e-02f, -1.24976911e-01f,
  -9.20353159e-02f, -9.46190022e-03f, -8.57283268e-03f, -4.59433235e-02f, -7.72095025e-02f, -5.94278425e-02f, 3.14196572e-02f, -1.05009219e-02f, 1.31639494e-02f, -4.95549962e-02f,
  3.92180011e-02f, 2.21461188e-02f, -1.29219349e-02f, -4.55046371e-02f, 8.40240996e-03f, -7.30767250e-02f, 3.00853644e-02f, -4.94481176e-02f, -8.79012328e-03f, 9.02753994e-02f,
  -6.62192479e-02f, 9.27488580e-02f, 1.04518279e-01f, -4.24062982e-02f, 1.76386863e-01f, -9.50594246e-03f, -1.40814140e-01f, 3.15535851e-02f, -8.59286264e-02f, 1.27792906e-03f,
  -1.77865550e-01f, 8.74626338e-02f, 1.42611042e-01f, 1.63974450e-03f, 8.67397711e-03f, 2.64098614e-01f, 1.34322375e-01f, 9.90920216e-02f, 1.91018477e-01f, 4.14925665e-02f,
  -9.89615843e-02f, 3.01614016e-01f, -8.94189253e-02f, 1.32319719e-01f, 3.05421799e-01f, 2.45557249e-01f, 3.53968322e-01f, 1.55541614e-01f, 2.12955661e-02f, 5.74831143e-02f,
  1.22989491e-01f, 9.16103646e-02f, 9.26738232e-02f, 6.04713187e-02f, 4.60798033e-02f, 1.77707925e-01f, 2.02626437e-01f, -7.58132041e-02f, -1.99555308e-01f, -2.24598516e-02f,
  1.78717390e-01f, 4.85074036e-02f, -1.16202869e-01f, 4.36813608e-02f, 1.63957756e-02f, 1.14486843e-01f, 1.23787843e-01f, 6.66651428e-02f, 1.38925850e-01f, 6.23924993e-02f,
  -1.15742341e-01f, 4.19807024e-02f, -7.05415979e-02f, -4.39435951e-02f, 6.28844351e-02f, -1.91237733e-01f, 1.75925801e-04f, -1.11661538e-01f, 7.80442953e-02f, 5.64020034e-03f,
  9.18834284e-02f, -6.93223905e-03f, 2.69948300e-02f, -2.20635999e-02f, 1.62042547e-02f, -1.23353750e-01f, -1.10949658e-01f, 9.92071033e-02f, 5.19606285e-02f, 2.48479620e-02f,
  3.91809195e-02f, 1.38055906e-01f, 6.84153736e-02f, 1.17490530e-01f, 2.54185721e-02f, -7.39466622e-02f, 5.40252365e-02f, -8.86231735e-02f, -1.68625005e-02f, 2.58017909e-02f,
  -1.44841047e-02f, 3.67443077e-02f, -1.74912885e-01f, -1.10546909e-01f, -4.21857126e-02f, -7.92143196e-02f, -1.15177296e-01f, -2.44517513e-02f, -6.31859824e-02f, -6.75817356e-02f,
  4.43292484e-02f, -1.06394729e-02f, -1.75515875e-01f, -1.64151892e-01f, -2.37082690e-01f, -2.52285879e-03f, -7.48197287e-02f, -1.64379030e-01f, -1.08936809e-01f, 6.45757616e-02f,
  6.73022643e-02f, 5.12156077e-02f, -8.38349983e-02f, -1.25414282e-01f, -1.25093460e-01f, -7.60639831e-02f, -1.06912762e-01f, 3.93889807e-02f, 4.21934389e-02f, 1.31505176e-01f,
  1.37438342e-01f, 5.32790683e-02f, -3.47402729e-02f, 9.54074636e-02f, -5.07417461e-03f, -1.08602084e-01f, -2.78784093e-02f, -1.55024573e-01f, -5.15630804e-02f, 1.08227506e-02f,
  -1.14259571e-01f, -1.17193535e-01f, -2.91826054e-02f, -2.90907472e-02f, -8.30118433e-02f, -1.24106258e-01f, -6.24883100e-02f, 6.22552633e-02f, 8.11809003e-02f, 5.61278611e-02f,
  5.11919111e-02f, 1.51497135e-02f, 1.25307795e-02f, 2.96321381e-02f, -1.05996631e-01f, -1.09342925e-01f, -1.34684175e-01f, -5.32385847e-03f, -9.33515579e-02f, -1.76189750e-01f,
  -5.94274290e-02f, -3.80704589e-02f, -2.04833344e-01f, 2.97666639e-01f, 2.36015469e-01f, 1.44960046e-01f, 2.12954387e-01f, 1.42256647e-01f, 1.40335277e-01f, 1.30851239e-01f,
  1.21021502e-01f, 1.99533910e-01f, 2.14792892e-01f, 1.52854145e-01f, -1.77714881e-02f, -9.57831554e-03f, -1.01518771e-02f, -3.09520261e-03f, 4.88512404e-03f, 1.39810974e-02f,
  2.35232517e-01f, 3.43961492e-02f, -1.05923533e-01f, -3.45720984e-02f, 2.57633664e-02f, 1.23229623e-01f, 6.26456812e-02f, -6.70951512e-03f, 7.08103937e-04f, -1.22028165e-01f,
  -2.61161029e-01f, -1.22092538e-01f, 1.33426592e-01f, -8.31147423e-04f, -1.46117821e-01f, -9.07791629e-02f, 2.72788666e-03f, -1.49211973e-01f, -7.49203982e-03f, -2.42674109e-02f,
  2.88603199e-03f, -3.38860974e-02f, 9.92015600e-02f, -7.73923937e-03f, -3.14083062e-02f, -3.10487896e-02f, -7.37914070e-02f, -1.90749735e-01f, -9.26981941e-02f, -1.47116333e-01f,
  7.05224052e-02f, -7.49342889e-02f, -1.12952992e-01f, 4.49540503e-02f, -2.97010168e-02f, 4.74348404e-02f, -8.48572627e-02f, -1.64947152e-01f, -1.08824052e-01f, -2.59941906e-01f,
  6.53466657e-02f, 4.82868329e-02f, -4.12845314e-02f, -9.65595841e-02f, -7.89598969e-04f, 6.51612133e-02f, 4.13377136e-02f, 2.71701906e-02f, -1.88362319e-02f, -2.66036224e-02f,
  1.18654966e-01f, 3.19580100e-02f, 6.35052621e-02f, 1.04464658e-01f, 2.10243657e-01f, -1.23642430e-01f, -2.73730531e-02f, 2.35015526e-02f, -1.12344638e-01f, -1.26688525e-01f,
  -3.70609015e-02f, 6.36643078e-03f, 3.92014198e-02f, -7.63620883e-02f, 6.73338994e-02f, -1.06436629e-02f, -9.81049985e-02f, 6.16238676e-02f, -3.16074900e-02f, -7.29655772e-02f,
  7.99867585e-02f, 1.16271444e-01f, 9.33407545e-02f, 2.39446852e-02f, -1.08218700e-01f, 6.00943575e-03f, 2.22504422e-01f, 6.98030507e-03f, -1.18650189e-02f, 4.70207781e-02f,
  -5.54037914e-02f, -7.33868778e-02f, 6.84514642e-02f, -4.00351025e-02f, 7.64311850e-02f, -2.92249657e-02f, 5.65878004e-02f, 1.28732622e-03f, -2.38809492e-02f, -7.82990679e-02f,
  -5.88476062e-02f, -8.39917287e-02f, -2.77467091e-02f, 3.79164168e-03f, 1.85484160e-02f, 5.94464689e-02f, -1.10594079e-01f, -1.58042207e-01f, -1.09498695e-01f, -1.66809976e-01f,
  8.84584486e-02f, -7.81398118e-02f, 2.33330831e-01f, 1.14215640e-02f, 2.74776459e-01f, 3.85270745e-01f, 3.53100538e-01f, 1.78611234e-01f, -3.68161080e-03f, 1.16433874e-01f,
  -1.15937240e-01f, -5.33597350e-01f, -4.35382336e-01f, -3.71886164e-01f, -1.79626912e-01f, 2.01066107e-01f, 1.96852088e-01f, 3.89464349e-02f, -1.18689448e-01f, 6.59533367e-02f,
  -1.13243982e-01f, -3.80556770e-02f, 7.19903456e-03f, -1.49815857e-01f, -6.98883310e-02f, -2.23642483e-01f, 1.54913649e-01f, 2.04920731e-02f, -8.10834244e-02f, -1.25959516e-01f,
  -1.12319238e-01f, 1.20679408e-01f, 2.10090186e-02f, -2.38302559e-01f, 7.38370344e-02f, -1.59194112e-01f, -6.73182309e-02f, -1.59603000e-01f, -9.14669707e-02f, -9.34907645e-02f,
  -8.85138810e-02f, -1.66360453e-01f, -2.61297785e-02f, -1.77556455e-01f, 6.38895947e-03f, -1.02985732e-01f, -1.27429798e-01f, -7.57628381e-02f, -2.97788903e-02f, -5.07967435e-02f,
  -1.66451231e-01f, 2.24775091e-01f, 2.71470070e-01f, 4.34762388e-02f, -1.87698789e-02f, 5.27217314e-02f, 7.65490085e-02f, 1.95316295e-03f, -2.70336941e-02f, -7.63523877e-02f,
  8.96862745e-02f, 9.80953947e-02f, 6.62494823e-02f, -1.47271156e-02f, 6.41663820e-02f, -2.44474504e-03f, -5.40469997e-02f, 5.86714447e-02f, 9.83749032e-02f, -4.65767160e-02f,
  -6.83934167e-02f, -1.94110125e-02f, 2.12913882e-02f, 3.44979130e-02f, -8.24168921e-02f, -3.61781120e-02f, 2.86761485e-02f, -1.32717818e-01f, -1.10155463e-01f, -6.22402094e-02f,
  -4.16998304e-02f, 1.26409382e-01f, -2.46943217e-02f, -1.37044564e-01f, 2.21249508e-03f, -2.49570236e-02f, 2.48589572e-02f, -6.72800690e-02f, 7.07715377e-02f, -7.14309812e-02f,
  -3.22244942e-01f, -4.75309417e-02f, 5.31098768e-02f, -1.46189570e-01f, 5.97176328e-02f, -9.34583619e-02f, -3.06723621e-02f, -9.09032673e-03f, 2.74283662e-02f, 6.24784604e-02f,
  -5.78628071e-02f, -8.10904056e-02f, -9.44463164e-02f, 6.56555220e-02f, 9.68980324e-03f, 1.97754912e-02f, -3.79767492e-02f, -1.70250386e-02f, 9.54060853e-02f, 3.06369457e-03f,
  -2.26478893e-02f, 1.63914397e-01f, 1.11394599e-01f, 3.12076062e-02f, 1.33622319e-01f, 1.76322430e-01f, 1.85320284e-02f, 8.41964781e-02f, 4.98482771e-02f, 8.38828310e-02f,
  -3.23611349e-01f, -1.15061864e-01f, -6.85177222e-02f, 1.83401734e-01f, 2.27354318e-01f, 2.62486160e-01f, 1.52613446e-01f, 1.21562548e-01f, 1.21109359e-01f, 1.65514052e-01f,
  1.05813265e-01f, 1.72255725e-01f, 1.39199048e-01f, 1.26148596e-01f, 7.26833846e-03f, 2.28996992e-01f, 2.99038470e-01f, 6.78852424e-02f, 1.09623455e-01f, 1.77651301e-01f,
  2.58194208e-01f, -2.78636590e-02f, -1.20394930e-01f, 5.23424409e-02f, 6.07061498e-02f, 2.15398297e-01f, 1.18492655e-01f, 3.21954899e-02f, 1.45581320e-01f, 5.00473157e-02f,
  -1.54919013e-01f, -1.43436447e-01f, 7.48716146e-02f, -4.56135795e-02f, -2.12394834e-01f, -1.08267143e-01f, 3.57071720e-02f, 1.82776246e-02f, -2.91274283e-02f, 8.99820700e-02f,
  -2.11745333e-02f, -1.12858914e-01f, -1.34299442e-01f, -1.45306125e-01f, 3.12788202e-03f, -7.96403084e-03f, -8.65672380e-02f, 5.87719753e-02f, 1.05395831e-01f, -8.58552605e-02f,
  2.23429315e-02f, -6.74964711e-02f, 5.28269187e-02f, 1.00965150e-01f, -8.66601095e-02f, 7.69360736e-02f, -5.37787415e-02f, -6.13628067e-02f, 3.78750153e-02f, 3.38075012e-02f,
  1.94898143e-01f, -2.50603650e-02f, -1.34342490e-02f, 8.55185986e-02f, -1.93523243e-02f, -4.38925214e-02f, 5.87051474e-02f, 1.18871227e-01f, 9.63238180e-02f, -1.62145525e-01f,
  8.23630858e-03f, 1.67112350e-01f, 1.74167268e-02f, 2.03841962e-02f, 2.68952306e-02f, 1.74270365e-02f, -6.99815750e-02f, -6.51802961e-03f, -1.38712227e-01f, -8.09706226e-02f,
  -5.69869466e-02f, -6.48658276e-02f, -8.21679011e-02f, -1.17509723e-01f, 1.09009435e-02f, -1.48116648e-02f, 1.78569909e-02f, 4.26248796e-02f, -2.43308935e-02f, -5.23685338e-03f,
  2.22766012e-01f, 1.16382040e-01f, 4.62012440e-02f, -3.86867486e-02f, -5.68299294e-02f, -1.07691914e-01f, 5.64184636e-02f, 1.81143973e-02f, -9.11875255e-03f, -9.16520599e-03f,
  -1.23918936e-01f, -7.49208257e-02f, -8.33061263e-02f, -6.08725138e-02f, -1.06399938e-01f, -4.53482643e-02f, -4.30793390e-02f, 7.76669607e-02f, 6.49212673e-02f, -7.88285509e-02f,
  -1.31080123e-02f, 7.98833668e-02f, 1.81938857e-01f, 6.19997643e-02f, 1.03105791e-01f, 1.26321495e-01f, -6.75573051e-02f, -5.80542274e-02f, 3.62050049e-02f, -7.71192834e-02f,
  -8.58422965e-02f, 4.72793803e-02f, 2.22321674e-01f, 1.83432668e-01f, -8.71993899e-02f, -2.03656584e-01f, -2.44283468e-01f, -1.05458058e-01f, 2.52051353e-02f, 2.16671303e-02f,
  -1.30767852e-01f, -5.15958704e-02f, 1.53896287e-01f, 2.52921637e-02f, 5.96103556e-02f, 2.42177546e-01f, 2.96036243e-01f, 7.88237303e-02f, -1.39111847e-01f, -2.41220102e-01f,
  1.10041266e-02f, 2.74496209e-02f, -5.31470915e-03f, 4.38278839e-02f, 4.32853177e-02f, -5.09329028e-02f, 1.48085415e-01f, 4.05516773e-02f, 1.05071478e-01f, 3.59115899e-01f,
  -5.39585482e-03f, -2.03799218e-01f, -1.86684877e-01f, -1.13164581e-01f, -6.16671853e-02f, -2.90324576e-02f, -1.08100571e-01f, 2.02844758e-02f, 2.94442866e-02f, -6.76829368e-02f,
  7.59284571e-02f, -7.22934678e-02f, -4.50753532e-02f, -2.88914498e-02f, -5.58382981e-02f, -2.67054915e-01f, 1.64259180e-01f, 1.32742658e-01f, 8.28257278e-02f, -1.47132710e-01f,
  -1.05043150e-01f, -2.66474277e-01f, -1.01923741e-01f, -5.32679074e-03f, -1.26281917e-01f, -1.31616160e-01f, -2.12541353e-02f, -1.18395522e-01f, -2.37845019e-01f, -1.97789725e-02f,
  -1.19063303e-01f, -1.17004566e-01f, -1.29822358e-01f, 1.51831672e-01f, 7.52162114e-02f, -7.01311752e-02f, -7.01311678e-02f, 2.69729551e-02f, 2.78724059e-02f, -1.85218483e-01f,
  2.87239105e-02f, -1.04175001e-01f, -6.48707226e-02f, -4.67603914e-02f, -2.47242507e-02f, -6.24587573e-02f, -1.23608328e-01f, -2.48613469e-02f, 6.69832528e-03f, -5.41782118e-02f,
  -5.88824181e-03f, -4.13654894e-02f, -7.04619512e-02f, 8.22697580e-02f, 6.42612204e-02f, -6.05756268e-02f, -8.27765986e-02f, -2.29107440e-01f, -1.82052748e-03f, -8.57569724e-02f,
  7.43481666e-02f, -9.88072157e-02f, -1.53285787e-01f, -1.49597963e-02f, -1.63020566e-01f, 3.78212482e-02f, -5.22308983e-02f, -1.29155517e-01f, 5.25693819e-02f, -5.36886752e-02f,
  -8.44675377e-02f, -2.33355965e-02f, 3.92792299e-02f, 1.25533357e-01f, -6.30090833e-02f, -3.23312171e-02f, 1.01051286e-01f, 5.22633307e-02f, 2.34371275e-02f, -1.45300359e-01f,
  6.19011894e-02f, -1.54217288e-01f, -1.16542861e-01f, 1.01577878e-01f, 4.46004979e-03f, -9.59446281e-02f, -1.24486476e-01f, -1.74131989e-01f, -3.06656808e-01f, -1.34119302e-01f,
  -5.41888773e-01f, -3.94468993e-01f, 2.03850985e-01f, 1.13769047e-01f, 2.89371997e-01f, 2.06459790e-01f, 9.11328048e-02f, -3.01755220e-02f, -1.16839055e-02f, -1.22727886e-01f,
  -1.82415798e-01f, -1.39983937e-01f, -1.54650748e-01f, -1.27348125e-01f, 3.11189536e-02f, 1.74720153e-01f, 2.93006510e-01f, 2.22468853e-01f, 2.21454769e-01f, 1.52211383e-01f,
  1.47318050e-01f, 3.87167446e-02f, -3.91063020e-02f, -8.15695599e-02f, 5.68946498e-03f, 8.71005356e-02f, 1.35745853e-01f, 6.12388663e-02f, 1.12196103e-01f, 1.81481794e-01f,
  3.32231015e-01f, -2.39791960e-01f, 1.21528327e-01f, -1.50822461e-01f, -1.31739244e-01f, -1.08725533e-01f, 1.91071518e-02f, 1.23150023e-02f, -2.44040284e-02f, 5.61073646e-02f,
  5.67024164e-02f, -1.40116841e-01f, 6.94382237e-03f, -1.03025042e-01f, -4.25256416e-02f, -3.58590074e-02f, -2.54490376e-01f, -6.20905636e-03f, -4.40902300e-02f, -1.81725509e-02f,
  -1.11343354e-01f, 1.82517394e-02f, -3.97465238e-03f, 2.73904596e-02f, -7.58361891e-02f, 2.43188068e-03f, -7.52976015e-02f, -3.41853760e-02f, -9.78495777e-02f, -6.26109168e-02f,
  -8.33510086e-02f, -9.83234271e-02f, 2.97754072e-02f, -4.17727092e-03f, -7.98220932e-02f, 5.41489050e-02f, 1.11496367e-01f, 9.41489935e-02f, -2.84197479e-02f, 6.73621194e-03f,
  4.05337848e-02f, 9.24212113e-02f, -3.12757795e-03f, 7.77763454e-03f, 4.28871065e-03f, -3.30859348e-02f, -3.09772380e-02f, -6.43557757e-02f, -2.66179107e-02f, -6.90045878e-02f,
  -3.07812952e-02f, 3.48933190e-02f, 3.91560383e-02f, 4.45883684e-02f, -6.43844604e-02f, 7.57755805e-03f, -1.36863720e-02f, 3.52147669e-02f, -8.32071528e-02f, -6.33226931e-02f,
  2.18698248e-01f, -1.08426198e-01f, 1.01280406e-01f, -2.96000298e-02f, 5.81156425e-02f, -5.42088002e-02f, 4.98323552e-02f, 1.27734557e-01f, 1.09916605e-01f, 1.98507532e-01f,
  6.48206286e-03f, 4.88450862e-02f, -1.79461110e-02f, -9.14294645e-02f, 1.48228496e-01f, 7.64687285e-02f, -1.48380235e-01f, 8.13760310e-02f, 9.56459343e-03f, 3.13012227e-02f,
  -5.15907183e-02f, 5.92817031e-02f, 1.73635513e-01f, 9.19211954e-02f, 1.00189120e-01f, 5.00975400e-02f, 1.34091020e-01f, -2.10798335e-05f, 1.59172788e-01f, 7.94230103e-02f,
  5.21262705e-01f, -1.47887945e-01f, -4.73667413e-01f, 2.25698501e-01f, -3.13170016e-01f, -1.46615312e-01f, -3.17480326e-01f, 1.81523450e-02f, 2.45680630e-01f, -1.01742096e-01f,
  -7.83818029e-03f, 1.54190078e-01f, -5.33447601e-02f, -1.61673293e-01f, -1.72192436e-02f, -2.70694941e-01f, -3.15390050e-01f, -1.86203063e-01f, 3.13924514e-02f, -2.45052781e-02f,
  3.95663977e-02f, 1.30520299e-01f, 1.27153397e-01f, -4.88833990e-03f, -5.32639809e-02f, -4.11965959e-02f, -2.35052079e-01f, -7.15463758e-02f, -2.03219160e-01f, -2.80914813e-01f,
  -3.83043677e-01f, -2.05340877e-01f, -8.24249536e-02f, 9.39492509e-02f, -1.04026720e-02f, 1.49904996e-01f, -2.30404525e-03f, 1.43658087e-01f, 4.79094125e-02f, 1.01684079e-01f,
  -5.13989516e-02f, -1.90944765e-02f, -3.66354687e-03f, 1.70824435e-02f, 4.06970978e-02f, 4.96577397e-02f, 9.21331719e-02f, 6.31978037e-04f, 3.09719630e-02f, 2.79071573e-02f,
  4.20432314e-02f, -1.08714342e-01f, -1.84732359e-02f, 3.52488160e-02f, -9.91296172e-02f, 3.06205880e-02f, -1.37919798e-01f, -1.49248049e-01f, -6.84580952e-02f, 5.38387075e-02f,
  3.92145757e-03f, 5.65585680e-02f, 1.16523774e-02f, 1.24426052e-01f, 1.47618517e-01f, 1.20312512e-01f, 1.42791867e-01f, -2.56894645e-03f, 7.10870251e-02f, 4.36781421e-02f,
  4.08665501e-02f, 5.30408807e-02f, -2.82990858e-02f, -1.67769901e-02f, -5.62171824e-02f, -1.18766250e-02f, 3.05699352e-02f, 9.88955796e-03f, 1.13737881e-01f, 8.24376941e-02f,
  6.80114627e-02f, -2.45222896e-02f, -2.13374998e-02f, 7.30486661e-02f, -6.92542270e-02f, -5.49918003e-02f, -1.13100380e-01f, 1.89708211e-02f, 1.88826062e-02f, -1.51573434e-01f,
  2.47224987e-01f, -2.40928292e-01f, -4.77293096e-02f, -5.02831563e-02f, 2.13648193e-02f, -5.64794689e-02f, -9.76161193e-03f, 8.00544620e-02f, 1.21504664e-01f, 8.55739042e-02f,
  -1.52773380e-01f, -2.95958202e-02f, 8.96374509e-02f, -1.29623085e-01f, 7.04534426e-02f, -6.30245432e-02f, 6.06776327e-02f, -1.14306470e-03f, 1.65137164e-02f, 8.55428800e-02f,
  4.94067334e-02f, 7.61893019e-02f, 1.30191311e-01f, 1.14944344e-02f, -9.06350389e-02f, -4.29164059e-03f, -6.13938421e-02f, 4.18361649e-02f, 5.55674769e-02f, 1.62976176e-01f,
  -4.61475372e-01f, -1.52824134e-01f, -1.40020743e-01f, 7.95557946e-02f, 2.15478063e-01f, -7.93064535e-02f, -3.20313990e-01f, -2.28151962e-01f, 1.13553489e-02f, -7.25973994e-02f,
  1.01850450e-01f, 2.63283491e-01f, 1.66399494e-01f, -2.04191916e-02f, -2.65052050e-01f, -1.07170857e-01f, 3.88686135e-02f, 6.88905036e-03f, -9.18514505e-02f, 8.22222903e-02f,
  2.25540712e-01f, 1.53689712e-01f, 2.09588986e-02f, 6.60330132e-02f, 5.02824225e-02f, 2.01246902e-01f, 3.80236246e-02f, 5.75807272e-03f, 2.56663524e-02f, -5.07544167e-02f,
  -2.15593368e-01f, -2.78351992e-01f, 9.62841660e-02f, 1.13208801e-01f, 2.20845625e-01f, -4.02071886e-02f, 3.34849097e-02f, 9.43468735e-02f, 1.18522659e-01f, -6.33466542e-02f,
  1.54631674e-01f, 1.40745327e-01f, 1.45610064e-01f, 5.32611310e-02f, -1.44216612e-01f, -2.77755372e-02f, -7.73514360e-02f, -1.77583352e-01f, -2.73715436e-01f, -8.35871622e-02f,
  2.01514110e-01f, 2.19530612e-01f, -1.60480469e-01f, -9.94782373e-02f, -2.45823503e-01f, 1.11009805e-02f, -1.19232088e-01f, -1.79283276e-01f, -1.93376034e-01f, -3.53368521e-01f,
  7.08500808e-03f, -2.51485873e-02f, -4.45015542e-02f, -4.25862558e-02f, -6.18479587e-02f, -7.15988576e-02f, -1.50706694e-02f, -1.16302557e-02f, -8.22178870e-02f, -5.07685244e-02f,
  -2.98012290e-02f, 9.06245783e-03f, -7.30660185e-02f, -3.58600505e-02f, 2.69617438e-02f, 7.74240494e-02f, -4.09073718e-02f, -5.89046516e-02f, -3.15998383e-02f, 1.07431067e-02f,
  -3.54457460e-02f, -8.00303370e-02f, 6.85436651e-02f, -9.39525962e-02f, -1.05623648e-01f, -1.60034299e-01f, 5.41300513e-03f, -8.88366327e-02f, 2.54399888e-02f, -5.91297820e-02f,
  -2.78153606e-02f, 1.33667454e-01f, -1.26612812e-01f, -1.14429221e-01f, 6.60686113e-04f, 1.25865489e-02f, -4.29644771e-02f, -1.28820926e-01f, -6.92317709e-02f, -1.09840095e-01f,
  -1.49673253e-01f, -4.55119722e-02f, -1.52703999e-02f, -5.00108823e-02f, 1.33138930e-03f, -4.00966406e-02f, -1.30753189e-01f, -1.19424708e-01f, -1.06097184e-01f, -2.21619997e-02f,
  -5.97172864e-02f, -1.69065386e-01f, -2.30919316e-01f, -2.39144415e-01f, -9.55013856e-02f, -2.98625324e-02f, -5.70402704e-02f, -1.53845772e-01f, -1.40408039e-01f, -2.77666867e-01f,
  -8.52737725e-02f, 2.84120589e-02f, 1.52025623e-02f, 1.58928290e-01f, 1.07266746e-01f, -2.40099803e-01f, -3.40988517e-01f, -2.47577280e-01f, 4.02984135e-02f, 1.20750271e-01f,
  1.19244397e-01f, 1.95990369e-01f, 8.38360861e-02f, -1.74000442e-01f, -3.80711883e-01f, -3.50498945e-01f, -2.23313242e-01f, -2.96779990e-01f, -3.33846629e-01f, -2.39801466e-01f,
  -9.58668441e-02f, -2.03141328e-02f, -4.66811247e-02f, -3.64752933e-02f, 2.48068422e-01f, 1.57969877e-01f, 1.91100657e-01f, 4.66380492e-02f, -1.02620594e-01f, 2.05557212e-01f,
  7.89695829e-02f, 4.86345217e-02f, -3.77068222e-02f, 6.54619709e-02f, 1.51235327e-01f, 4.24704663e-02f, -8.19180906e-02f, 3.70860994e-02f, 4.05780077e-02f, -1.21020526e-01f,
  1.37705892e-01f, -4.58266549e-02f, -8.79203156e-02f, 1.24606015e-02f, -5.36690243e-02f, -8.41333047e-02f, 1.51205910e-04f, -3.65493931e-02f, -9.78267342e-02f, -9.09671932e-02f,
  -8.28277618e-02f, -9.52942371e-02f, -8.77234861e-02f, -1.04470052e-01f, -1.48836419e-01f, -9.04525295e-02f, -2.03426741e-02f, 1.75861605e-02f, -7.69466162e-02f, 9.75725998e-04f,
  3.95290330e-02f, 4.67759334e-02f, 6.05047913e-03f, -5.07577881e-02f, 1.40676079e-02f, 1.70386449e-01f, -4.57080640e-02f, 9.80672687e-02f, -7.17875082e-03f, -3.52405459e-02f,
  2.99474355e-02f, -9.71714687e-03f, 1.10512376e-01f, 1.08286187e-01f, -4.86353971e-02f, 6.62268475e-02f, -4.08220254e-02f, 3.13069224e-02f, 8.90695304e-02f, 1.48615725e-02f,
  4.30597775e-02f, 1.09606072e-01f, 1.06722854e-01f, 6.59877211e-02f, 1.47517342e-02f, -5.12516033e-03f, 3.23878825e-02f, -5.09614572e-02f, 1.41832516e-01f, 9.11953971e-02f,
  3.15883875e-01f, -1.75848365e-01f, 3.77898626e-02f, -7.42431059e-02f, 1.11311032e-02f, 1.41355991e-01f, 1.51473507e-01f, 6.14910983e-02f, 1.15076646e-01f, -5.32089919e-02f,
  -1.41181676e-02f, 1.15945324e-01f, 3.94886173e-02f, -5.26171513e-02f, -2.20602453e-01f, 1.06024640e-02f, -4.26207185e-02f, 5.87422736e-02f, -2.78252196e-02f, 1.24138139e-01f,
  -1.30168512e-01f, -2.38841221e-01f, -1.63388744e-01f, -9.46882926e-03f, 8.01747814e-02f, -6.85416386e-02f, -2.78546289e-03f, -5.58743253e-04f, -1.52266458e-01f, -1.35994526e-02f,
  3.07059824e-01f, 1.92794874e-01f, 3.08193803e-01f, 1.30157679e-01f, -7.41391182e-02f, 1.46571234e-01f, 1.40324026e-01f, 9.75410044e-02f, -1.20581888e-01f, 9.76127982e-02f,
  -1.10863447e-01f, -1.53512239e-01f, -1.18705086e-01f, -1.01406418e-01f, 1.02522932e-01f, 1.00549877e-01f, -3.86644006e-02f, 1.47815436e-01f, 1.02441534e-01f, 4.15392853e-02f,
  -6.64178357e-02f, 8.78331959e-02f, 1.60700545e-01f, 8.19622278e-02f, 3.06002367e-02f, -7.42155313e-02f, 3.76173034e-02f, 4.38724346e-02f, -3.58902626e-02f, -1.01873733e-01f,
  4.93053608e-02f, 2.48408481e-01f, -1.07194610e-01f, -8.15524608e-02f, -2.86459699e-02f, -6.20043129e-02f, 3.83998305e-02f, 3.29342484e-02f, -5.51231764e-02f, -8.22501704e-02f,
  3.50849293e-02f, 1.01213992e-01f, 6.86637089e-02f, 1.06848083e-01f, -1.12973947e-04f, 8.49857703e-02f, 8.03066790e-02f, 1.44614995e-01f, 2.96964645e-02f, 5.72963618e-02f,
  -3.48931439e-02f, -7.52330571e-02f, 8.69130492e-02f, -3.41805816e-02f, 3.01694516e-02f, -1.00120276e-01f, 4.03386503e-02f, 6.38870671e-02f, 9.99868512e-02f, 1.01871975e-01f,
  -2.09072888e-01f, 1.02349520e-02f, -1.81777717e-03f, 6.07087724e-02f, -4.32258658e-02f, 6.85812067e-03f, -5.32524586e-02f, -7.69970119e-02f, -1.81053504e-02f, 1.41635716e-01f,
  1.71525553e-02f, 1.69989541e-02f, -1.61159523e-02f, 6.34172931e-02f, -4.46659066e-02f, 4.88503650e-02f, 9.67950523e-02f, -9.06370115e-04f, 5.36805242e-02f, 5.98441716e-03f,
  7.53934681e-03f, 4.38058078e-02f, -1.01452805e-01f, 5.93117364e-02f, -4.52665463e-02f, 6.40953183e-02f, 4.97924304e-03f, 8.05331618e-02f, -6.15011826e-02f, -5.45926131e-02f,
  -5.46266325e-02f, 1.19639568e-01f, -1.89609709e-03f, -8.85316133e-02f, -8.02938417e-02f, -7.32378811e-02f, -1.99888535e-02f, -7.10188523e-02f, -8.47805738e-02f, -1.11562610e-01f,
  -3.99453677e-02f, 4.73691225e-02f, 5.70327938e-02f, -1.41984187e-02f, -8.11554641e-02f, -4.83426228e-02f, -1.69005573e-01f, 1.28093315e-02f, -9.09316391e-02f, -3.81939933e-02f,
  -9.15762186e-02f, -6.16206042e-02f, -5.93646243e-03f, -2.71149967e-02f, -1.22243755e-01f, -1.50230885e-01f, -1.00818165e-01f, -5.01104966e-02f, -5.29939122e-03f, -5.89855984e-02f,
  5.55374846e-02f, 2.46090114e-01f, -6.94454387e-02f, 1.30574003e-01f, 3.00518900e-01f, 2.64199644e-01f, 3.48174870e-01f, 2.07907155e-01f, 2.57676840e-02f, 9.80420411e-03f,
  -1.33420259e-01f, -3.17981452e-01f, -2.02543825e-01f, -2.36962244e-01f, -1.04280084e-01f, 2.12222874e-01f, 3.19557339e-01f, -1.49798170e-01f, -1.07566208e-01f, -2.04845890e-02f,
  1.16140448e-01f, 1.91615775e-01f, 1.34473234e-01f, -1.01479463e-01f, 1.35543406e-01f, -9.81625170e-02f, 1.27384692e-01f, 1.70262173e-01f, -2.31416225e-02f, -1.89359292e-01f,
  -4.07766938e-01f, -3.72356176e-02f, -4.68429327e-02f, -4.62639928e-02f, 6.96098953e-02f, 1.81420278e-02f, -4.10148315e-02f, 1.13830708e-01f, -1.00916006e-01f, -6.79197013e-02f,
  -5.67892045e-02f, -1.19244829e-01f, -1.70081601e-01f, -6.79824874e-03f, 5.86047061e-02f, -5.37993647e-02f, 1.20080404e-01f, -2.90053394e-02f, -3.08693945e-01f, -1.11271568e-01f,
  -7.49613494e-02f, 3.01309004e-02f, -3.48701552e-02f, 1.52301332e-02f, -1.86106116e-01f, -1.38930768e-01f, -9.84482691e-02f, -2.14884952e-01f, -1.18106268e-01f, -4.51209284e-02f,
  -7.60492831e-02f, -6.98322952e-02f, -9.12822336e-02f, 8.10748786e-02f, 5.12572788e-02f, -2.82262303e-02f, -7.83441141e-02f, -9.27779600e-02f, -4.87546474e-02f, 5.08300141e-02f,
  2.16775853e-02f, -1.41260937e-01f, -6.71104565e-02f, 4.30963642e-04f, 4.47382182e-02f, -1.03157245e-01f, -2.97489800e-02f, -2.97731198e-02f, -4.07366827e-02f, 1.52869904e-02f,
  -8.15401971e-03f, -3.06442752e-02f, 4.07175906e-02f, -8.01732987e-02f, 6.01749942e-02f, -2.41957456e-02f, -6.28314316e-02f, -4.04892303e-03f, 6.43326640e-02f, 2.17646152e-01f,
  -2.45352425e-02f, -5.04824221e-02f, -6.60144985e-02f, 7.84962475e-02f, 8.31873808e-03f, -1.75807014e-01f, 6.86454261e-03f, -6.11608773e-02f, -5.97683005e-02f, -9.88192633e-02f,
  -8.68557766e-02f, -1.02973163e-01f, -1.49384916e-01f, 4.22186870e-03f, 2.00038366e-02f, 1.84810832e-02f, -7.01469509e-03f, 1.31742999e-01f, -5.57133220e-02f, 6.89116120e-02f,
  2.25321371e-02f, 1.82018504e-01f, 9.71097946e-02f, 4.63691466e-02f, 2.39734631e-02f, 7.22543001e-02f, 1.06265180e-01f, 1.16224915e-01f, 5.79563566e-02f, 2.25598291e-01f,
  -5.36277175e-01f, -1.30309105e-01f, -5.45304618e-04f, -2.29012445e-01f, -9.84674022e-02f, -1.01074308e-01f, -4.72701266e-02f, -1.24608770e-01f, -1.32525444e-01f, -2.58300193e-02f,
  2.39484422e-02f, 2.20807036e-03f, -1.93314105e-02f, 1.83277344e-03f, 1.70412636e-03f, -2.80633271e-02f, -3.96181270e-02f, -7.75321946e-02f, -8.20510983e-02f, 4.53503281e-02f,
  -1.05943546e-01f, -4.28587794e-02f, -1.58561066e-01f, -3.09344791e-02f, 6.32548705e-02f, 1.26474947e-01f, 4.61362489e-02f, 7.52057284e-02f, 7.88165536e-03f, 4.26197574e-02f,
  4.47962373e-01f, -5.22211567e-03f, -4.83473875e-02f, 5.02346875e-03f, -2.06192825e-02f, -1.14017405e-01f, -1.13680936e-01f, -5.01719341e-02f, 2.23446973e-02f, 1.03602044e-01f,
  -2.35307291e-02f, -1.47814274e-01f, 1.27454468e-05f, 3.20694707e-02f, 5.31073548e-02f, 7.25704134e-02f, 5.59863932e-02f, 2.44045556e-02f, 7.82685205e-02f, -1.78872291e-02f,
  5.44510931e-02f, -5.57259768e-02f, 6.02964945e-02f, 1.11071423e-01f, -3.99475219e-03f, 4.54396792e-02f, 1.09854434e-02f, -1.45180020e-02f, 4.29296456e-02f, 1.58251092e-01f,
  -1.89399719e-02f, 7.46009033e-03f, 8.39100704e-02f, 3.42879221e-02f, -1.39149144e-01f, -6.33536875e-02f, -5.41114174e-02f, 8.88712332e-03f, -1.05461396e-01f, -5.36587760e-02f,
  4.36255289e-03f, 9.91638824e-02f, -8.85388851e-02f, 7.88361952e-03f, 2.67208312e-02f, -3.23599130e-02f, -3.36265452e-02f, 1.05920523e-01f, 5.60063608e-02f, -1.35917649e-01f,
  -1.05039865e-01f, -4.51266486e-03f, -5.40457666e-02f, -3.97344939e-02f, 1.10617168e-01f, 8.34991261e-02f, 5.91391139e-03f, -2.26544086e-02f, -1.03102885e-01f, -6.77811950e-02f,
  3.49560827e-01f, -9.53458399e-02f, -3.47602367e-02f, -1.19089447e-01f, 6.32473230e-02f, 1.77591667e-02f, 1.21855699e-01f, 7.12532997e-02f, 3.94252539e-02f, 8.61746147e-02f,
  4.92176972e-02f, -8.48226175e-02f, 3.13751847e-02f, -6.03881218e-02f, -7.62648806e-02f, 2.00486220e-02f, -5.77173680e-02f, 9.52078402e-02f, 1.24037467e-01f, 1.23848021e-01f,
  -2.12776661e-02f, 5.66274151e-02f, 1.70198143e-01f, 6.73261508e-02f, -9.00183544e-02f, -1.16270101e-02f, 6.32043630e-02f, 1.91571206e-01f, 9.45348367e-02f, 6.76821098e-02f,
  4.21765924e-01f, 2.45709404e-01f, 3.62165362e-01f, 4.59440015e-02f, -1.01390056e-01f, -1.76076144e-01f, -2.76610821e-01f, -1.57776669e-01f, -3.52506749e-02f, -4.28595841e-02f,
  -2.65388675e-02f, -2.44036783e-02f, 5.63388169e-02f, 1.62104219e-01f, 1.08122945e-01f, 1.15647830e-01f, 7.63152018e-02f, 2.48071805e-01f, 4.73356023e-02f, -2.75595840e-02f,
  3.73687521e-02f, 2.09371120e-01f, 2.34135687e-01f, 2.33193651e-01f, 2.05667704e-01f, 2.01436654e-02f, 7.29052946e-02f, 8.90195370e-02f, 6.38347305e-03f, 3.10373485e-01f,
  2.39693463e-01f, 8.44909027e-02f, -8.28815624e-02f, 1.27815783e-01f, 1.14300705e-01f, 6.55515566e-02f, -4.50570807e-02f, 7.74250627e-02f, -9.60040614e-02f, -1.30827397e-01f,
  2.16519497e-02f, 1.28696576e-01f, -1.55103114e-02f, -2.95717008e-02f, -1.04862198e-01f, -5.85794337e-02f, -3.92311849e-02f, -9.90828499e-02f, -8.53054821e-02f, 6.78530112e-02f,
  -2.21972577e-02f, -8.41389969e-02f, -1.90181166e-01f, -1.56319976e-01f, -1.07252218e-01f, 1.20548066e-02f, -3.60980514e-03f, 7.81201571e-02f, -3.89032103e-02f, -7.29839951e-02f,
  -1.08475775e-01f, -3.07283942e-02f, 5.49818166e-02f, -1.54391915e-01f, -7.22210258e-02f, -1.47038639e-01f, -6.33849651e-02f, -1.30470648e-01f, 3.55069363e-03f, -6.38728067e-02f,
  -5.20025939e-02f, -1.33766517e-01f, -1.12862065e-01f, -3.49389948e-03f, 1.13988586e-01f, 1.30411834e-01f, -8.26802179e-02f, 1.81694818e-03f, -1.59971230e-02f, -6.40520602e-02f,
  5.95113123e-03f, -3.73507887e-02f, 1.03708245e-01f, 4.65962403e-02f, -9.21222046e-02f, 3.70735233e-03f, 4.60812310e-03f, 6.82897419e-02f, 7.68835843e-02f, 5.81145883e-02f,
  -2.09245220e-01f, 6.49803802e-02f, -2.21495926e-02f, 1.66734725e-01f, 1.06071696e-01f, 1.54364526e-01f, 1.63331524e-01f, 1.13115042e-01f, 7.39541873e-02f, 4.53384314e-03f,
  8.99968892e-02f, 1.39468685e-01f, 1.39404426e-03f, -6.43292814e-02f, -5.01506105e-02f, -1.05602317e-01f, -4.91407104e-02f, -2.93126442e-02f, -3.27081867e-02f, 1.48502797e-01f,
  3.75014693e-02f, -1.27716377e-01f, -1.14301667e-01f, -1.01895452e-01f, -2.02960327e-01f, -1.25669405e-01f, 2.23166086e-02f, 2.88505536e-02f, -3.69069278e-02f, -1.72112137e-01f,
  -1.57553956e-01f, 4.34923619e-01f, 1.40617222e-01f, 3.14936265e-02f, 1.88394561e-01f, 1.10287346e-01f, 3.40920806e-01f, 5.96671849e-02f, -7.19552338e-02f, 7.06576332e-02f,
  -6.97312970e-03f, -9.49416533e-02f, -1.25128850e-01f, -6.07910082e-02f, 9.11828950e-02f, 1.61462247e-01f, 1.53078914e-01f, -5.26751280e-02f, -2.63093829e-01f, -3.29631083e-02f,
  -1.16354167e-01f, -2.36963015e-02f, -1.47830516e-01f, -1.48980752e-01f, 8.31181929e-02f, -8.74742046e-02f, 1.03887729e-01f, 1.17010206e-01f, 1.98815092e-01f, 5.69152683e-02f,
  -1.21128662e-02f, 1.76758260e-01f, -3.14646274e-01f, -1.63373798e-01f, 1.32949218e-01f, 2.22239289e-02f, -6.37416840e-02f, 9.24205757e-04f, 6.54786006e-02f, -6.81622699e-02f,
  3.85299623e-02f, 1.07612260e-01f, 6.99843690e-02f, 6.12339564e-02f, 6.87857196e-02f, -1.00053027e-01f, 3.14051770e-02f, -3.28533235e-03f, -1.01799898e-01f, -2.94512715e-02f,
  4.01495956e-02f, 5.83846010e-02f, -3.05876825e-02f, -1.21818390e-02f, -2.43145078e-02f, -1.29099950e-01f, 1.42895296e-01f, -2.06502080e-02f, -1.02476396e-01f, -7.66796544e-02f,
  -5.40693775e-02f, 7.83055350e-02f, 1.27966732e-01f, 1.06443251e-02f, -7.07776025e-02f, 1.67547893e-02f, -7.03719631e-03f, -1.82598047e-02f, -3.68933864e-02f, -4.53213267e-02f,
  -2.04111654e-02f, -1.20151147e-01f, 7.59842852e-03f, 3.84248011e-02f, -7.54055604e-02f, 1.37699351e-01f, 2.41057500e-02f, -7.18044415e-02f, 3.14464048e-02f, -4.34725471e-02f,
  -2.02500969e-02f, 4.01902162e-02f, -1.62623413e-02f, 1.25860810e-01f, -2.42697634e-03f, -9.65868607e-02f, -7.10998997e-02f, -4.27854024e-02f, -6.04710653e-02f, 2.50133816e-02f,
  -1.51391745e-01f, -2.66407393e-02f, -1.97261855e-01f, 8.82317722e-02f, 1.54570043e-01f, -6.14037812e-02f, 4.72403318e-02f, 7.26150274e-02f, 3.02048922e-02f, 1.58826262e-02f,
  2.42172461e-02f, 5.27984872e-02f, 7.02022314e-02f, 8.98048840e-03f, -7.89519250e-02f, -4.49628904e-02f, 3.97361368e-02f, -4.72471826e-02f, -1.53512791e-01f, -1.14911593e-01f,
  -2.87690237e-02f, -1.05728723e-01f, -2.40764216e-01f, -4.60009053e-02f, -1.73173353e-01f, -2.26221845e-01f, -5.82404137e-02f, -1.03507742e-01f, -4.36576176e-03f, -1.77959949e-01f,
  -3.89478326e-01f, 3.87781382e-01f, 1.40258521e-01f, -2.85930127e-01f, 2.01025233e-01f, 3.75972092e-01f, 3.78209621e-01f, 5.32572865e-02f, -7.36222267e-02f, 1.21065639e-01f,
  1.43017083e-01f, -8.56075883e-02f, -1.07899748e-01f, -1.07261702e-01f, 8.86777118e-02f, 1.85996905e-01f, 1.77321404e-01f, -1.88318849e-01f, -2.59210557e-01f, 3.38658392e-02f,
  9.46558341e-02f, -1.35752290e-01f, -1.46353677e-01f, -2.24301502e-01f, -1.52046278e-01f, -2.06235811e-01f, 7.97692537e-02f, 8.07495415e-02f, 2.36191005e-01f, -4.54085767e-02f,
  -9.52517465e-02f, -1.92468911e-02f, 5.96598983e-02f, -2.23019585e-01f, 1.54607430e-01f, 1.56542510e-02f, 1.85386296e-02f, -4.47939858e-02f, 3.83468382e-02f, -3.90234068e-02f,
  5.94693907e-02f, 5.88334054e-02f, 3.29148360e-02f, -1.36002198e-01f, -1.76437542e-01f, -1.33721922e-02f, -1.73990369e-01f, -1.34567946e-01f, -2.01215535e-01f, -1.77647173e-01f,
  1.72009647e-01f, 9.48292241e-02f, 1.77123137e-02f, 2.05590595e-02f, 5.66286184e-02f, -1.23242773e-01f, 5.03496230e-02f, -1.31105334e-02f, -1.23926260e-01f, -1.74971715e-01f,
  -4.70042042e-02f, 6.96469769e-02f, 7.68740401e-02f, 5.02976067e-02f, 7.69573683e-03f, 5.59540018e-02f, 6.37656683e-03f, 4.24143411e-02f, 8.70287642e-02f, -4.86986600e-02f,
  -2.83579361e-02f, 5.32773621e-02f, 7.67180249e-02f, 1.10581964e-01f, -3.95531356e-02f, 4.14410606e-02f, 4.56118882e-02f, -1.02872234e-02f, 3.42626646e-02f, -5.06393686e-02f,
  -8.09033737e-02f, -2.41946988e-02f, 4.54557613e-02f, -1.17626950e-01f, 6.97580650e-02f, 1.39597598e-02f, -1.96318571e-02f, 1.18469879e-01f, -1.26404446e-02f, -5.33819161e-02f,
  -3.60084265e-01f, 2.22284734e-01f, 6.15611784e-02f, 7.05738068e-02f, -2.99454946e-02f, -1.06917359e-01f, -4.93278950e-02f, 1.27380744e-01f, -1.34154307e-02f, -1.14850933e-02f,
  7.88840577e-02f, 2.88350806e-02f, 9.79905725e-02f, -4.00890484e-02f, -6.73789680e-02f, 6.45871684e-02f, 9.46142897e-03f, -1.42928809e-01f, -3.40814032e-02f, -7.02226236e-02f,
  1.29028946e-01f, 2.99751014e-02f, -1.31291658e-01f, -1.68433622e-01f, 2.50487514e-02f, -6.95474967e-02f, -4.80945446e-02f, -9.40100104e-02f, 1.30668469e-02f, -2.29365245e-01f,
  -1.98240820e-02f, 2.38216266e-01f, 1.92759305e-01f, -9.84718055e-02f, -8.20593536e-02f, 7.19892746e-03f, 1.04020961e-01f, 7.86351636e-02f, -2.25250293e-02f, 7.51070753e-02f,
  1.16538711e-01f, -1.86889932e-01f, -1.66205421e-01f, -1.35211423e-01f, -3.36841606e-02f, 6.86825886e-02f, -1.03355467e-01f, -3.40703391e-02f, 9.74156149e-03f, 2.76093232e-03f,
  -1.99232951e-01f, -3.99261005e-02f, -4.48269024e-02f, -1.19562991e-01f, -8.66528675e-02f, -1.63465202e-01f, -9.74810719e-02f, 4.63978760e-02f, -6.08302578e-02f, -1.79965436e-01f,
  2.86921617e-02f, 1.85020566e-01f, 1.70044042e-02f, 8.22685808e-02f, 2.58316875e-01f, 1.70247883e-01f, 7.87764341e-02f, 1.44058794e-01f, 1.48291901e-01f, 4.01502438e-02f,
  2.27183364e-02f, 1.26300797e-01f, 7.31055290e-02f, 4.54788432e-02f, 1.71527222e-01f, 1.79915708e-02f, 2.19607770e-01f, 1.10814549e-01f, 8.57385546e-02f, 7.82798082e-02f,
  2.51841862e-02f, 8.21506754e-02f, 1.45798966e-01f, 1.03007361e-01f, -3.07790600e-02f, 9.94970351e-02f, 4.64314148e-02f, 5.37963100e-02f, 6.38390705e-02f, -3.90171260e-02f,
  1.28036151e-02f, -8.93530175e-02f, 6.44584224e-02f, -4.42973562e-02f, -6.96038082e-02f, 4.18943837e-02f, -2.81425659e-02f, -5.76171987e-02f, -5.45725673e-02f, 1.40835643e-01f,
  6.72028493e-03f, -1.86497062e-01f, -3.39729153e-02f, -7.87587464e-02f, -8.14329013e-02f, 5.11032604e-02f, 7.69110620e-02f, 4.40112464e-02f, 4.18293439e-02f, -6.91422895e-02f,
  -4.46113162e-02f, 9.94742960e-02f, 7.49821886e-02f, -4.25986573e-03f, 1.57829970e-01f, 8.68110955e-02f, 3.57435122e-02f, 2.77629178e-02f, -1.03851564e-01f, -2.12564208e-02f,
  -3.19628678e-02f, -1.05045490e-01f, -2.50314206e-01f, -1.33353055e-01f, 1.10251002e-01f, 1.27700433e-01f, -5.72156347e-02f, -7.31194671e-03f, 7.17932880e-02f, -6.92107081e-02f,
  1.55319693e-02f, -5.35625555e-02f, -3.28136906e-02f, 1.04686385e-02f, 2.34451275e-02f, 7.48144686e-02f, 5.96744753e-02f, -3.94929610e-02f, -1.36267915e-02f, 3.70455123e-02f,
  9.45075080e-02f, -2.88090035e-02f, -1.02102347e-02f, 2.08726227e-02f, -6.51187673e-02f, -1.61766320e-01f, -8.42972770e-02f, 3.42799500e-02f, -7.16371760e-02f, 2.76006125e-02f,
  5.24897993e-01f, 8.51443037e-02f, 2.78190076e-01f, 1.61563173e-01f, -1.64381087e-01f, -1.08594373e-02f, 1.58026665e-01f, 1.48499116e-01f, -5.19505180e-02f, 1.25800818e-01f,
  -6.65612379e-03f, 6.65306374e-02f, 9.93441418e-03f, 8.46646577e-02f, 9.95289534e-02f, -2.85133184e-03f, -2.40546116e-03f, 1.90590724e-01f, 1.58344597e-01f, 1.85796708e-01f,
  -2.88570914e-02f, 6.69120103e-02f, 2.60327935e-01f, 1.01295924e-02f, -3.12963985e-02f, -7.10247755e-02f, 6.45115525e-02f, 8.37319195e-02f, 7.91780949e-02f, 1.35332078e-01f,
  1.63779795e-01f, 2.07391858e-01f, -7.17604980e-02f, -2.06708647e-02f, -7.50044286e-02f, 5.56768402e-02f, -4.80910838e-02f, -7.38020018e-02f, -3.71415280e-02f, 1.08544510e-02f,
  4.50118817e-03f, -8.45988002e-03f, 9.68857761e-03f, -3.38821374e-02f, 6.59749210e-02f, -3.65125202e-02f, 2.59309113e-02f, 4.99999486e-02f, 8.98617506e-02f, 1.07405625e-01f,
  -3.32358629e-02f, -3.44169587e-02f, 2.47847452e-03f, 1.84569173e-02f, 1.44355327e-01f, -7.13022351e-02f, 2.56535448e-02f, 4.91109444e-03f, 9.96733233e-02f, 2.06003144e-01f,
  1.53089732e-01f, 9.88094732e-02f, 1.71763167e-01f, 1.39093369e-01f, 1.18011899e-01f, 1.66464085e-03f, 2.79393494e-02f, 2.57899612e-02f, 4.24094647e-02f, 1.18897773e-01f,
  1.12373076e-01f, 3.01660188e-02f, 8.11784491e-02f, 6.30163997e-02f, -2.79848464e-02f, 5.45124784e-02f, -6.42546415e-02f, 2.37580165e-02f, 6.97575659e-02f, -4.28765193e-02f,
  6.61694556e-02f, 5.51654212e-02f, 2.38643065e-02f, 3.44229527e-02f, -4.80961092e-02f, 5.60969971e-02f, 1.76152602e-01f, 1.17617901e-02f, 5.74341938e-02f, 1.78700268e-01f,
  -4.01172638e-01f, -9.53751728e-02f, 1.75556391e-01f, 5.11477888e-02f, -1.09585248e-01f, -7.14175552e-02f, 6.55817166e-02f, -6.15432598e-02f, -1.22582577e-01f, -8.69771987e-02f,
  -5.48335910e-02f, 2.76541021e-02f, -5.00546843e-02f, 1.28924591e-03f, 9.22658518e-02f, -1.34981915e-01f, -8.89202133e-02f, -1.57954078e-02f, -9.28939059e-02f, -1.56803325e-01f,
  -7.22427219e-02f, -7.64945596e-02f, -1.79083735e-01f, -1.22189395e-01f, -8.81641805e-02f, -8.25857148e-02f, -1.46494880e-01f, -9.66171622e-02f, -3.73877166e-03f, 6.10678531e-02f,
  2.93766230e-01f, -5.35505295e-01f, 3.60494256e-01f, 1.76959544e-01f, 1.85709700e-01f, 1.47054702e-01f, -6.86500175e-03f, 1.15043797e-01f, 1.23613752e-01f, 2.02357266e-02f,
  -1.84599102e-01f, -2.19969638e-02f, -6.71716081e-03f, -7.17442259e-02f, -8.80295634e-02f, -9.64205153e-03f, 1.09481253e-01f, 3.45127046e-01f, 3.71307433e-01f, 1.55110300e-01f,
  -2.76841205e-02f, -8.15445185e-02f, -6.86740736e-03f, 1.27182841e-01f, -3.12880762e-02f, 9.56505835e-02f, 8.37219995e-04f, -8.32572021e-03f, -1.03891671e-01f, 1.24092162e-01f,
  -3.52664478e-02f, -1.52792439e-01f, 1.87253177e-01f, -1.19452581e-01f, -1.12054730e-02f, -1.19777761e-01f, -4.36712131e-02f, -1.44321201e-02f, -1.11830272e-01f, 2.33078133e-02f,
  -3.10327001e-02f, -1.19820582e-02f, -1.07413523e-01f, -7.70412460e-02f, 1.04292557e-01f, 8.25824142e-02f, -4.63475995e-02f, -9.58282501e-03f, -9.11755487e-02f, -2.52667274e-02f,
  -4.17098813e-02f, -2.35845353e-02f, 6.31633773e-02f, -8.91660899e-02f, 9.84710455e-03f, -1.61559973e-02f, -9.94101614e-02f, 5.31797670e-02f, 7.76301548e-02f, 2.82690804e-02f,
  6.18296005e-02f, 1.67722888e-02f, -2.95927394e-02f, 4.64693345e-02f, 1.03154182e-01f, 7.07811043e-02f, 2.53238864e-02f, -7.96283856e-02f, 5.25082462e-02f, 9.78128314e-02f,
  7.64140934e-02f, 4.10103947e-02f, -8.78552943e-02f, 3.27474326e-02f, 5.92951328e-02f, 9.75364223e-02f, 1.26434088e-01f, 4.59725149e-02f, -8.41704085e-02f, -4.77629676e-02f,
  1.50266320e-01f, 1.02267995e-01f, -5.21645136e-02f, -1.46311615e-02f, -2.28678863e-02f, -2.84756720e-02f, -1.63565967e-02f, -8.54954347e-02f, -9.02602822e-02f, 7.93182701e-02f,
  -3.07559669e-01f, -4.03305814e-02f, 6.04288056e-02f, -7.75533989e-02f, -3.05586085e-02f, -9.93015766e-02f, -1.69945791e-01f, -9.29096341e-02f, -1.27108455e-01f, -4.02928367e-02f,
  -3.47770415e-02f, -8.64713043e-02f, -4.67998050e-02f, 9.40237194e-03f, 1.84444234e-01f, -4.28781025e-02f, -1.39828458e-01f, -1.02949981e-02f, -8.67937654e-02f, -5.45121841e-02f,
  -3.90521400e-02f, -3.37033719e-02f, 1.08163275e-01f, 6.17670380e-02f, -7.28460327e-02f, 1.54313251e-01f, 1.83574911e-02f, 1.89836081e-02f, 2.55754571e-02f, -2.10160241e-02f,
  -6.13579035e-01f, 6.49382919e-02f, -1.76474497e-01f, -4.04972643e-01f, -1.00613065e-01f, 6.41289502e-02f, 2.43055880e-01f, 9.36917290e-02f, -1.01136789e-01f, 1.13378406e-01f,
  1.05785519e-01f, -2.39649102e-01f, -2.14544177e-01f, 1.13614392e-03f, -1.44120246e-01f, 4.23687175e-02f, -2.67371982e-01f, -2.22959235e-01f, -2.18095586e-01f, 1.79551437e-01f,
  6.71603158e-02f, -2.64948279e-01f, -3.16351891e-01f, -8.12778026e-02f, -5.36376387e-02f, -1.14999294e-01f, -1.19350171e-02f, -1.84444577e-01f, 1.09879218e-01f, -1.04654104e-01f,
  -9.80760157e-02f, -5.61286323e-02f, 3.91181074e-02f, -8.75617266e-02f, 2.08888892e-02f, -1.57808483e-01f, -2.95161847e-02f, -2.42884383e-02f, 2.36525834e-02f, -3.63800898e-02f,
  -1.32283658e-01f, 9.96566415e-02f, -1.36423245e-01f, -1.44498255e-02f, -3.76160219e-02f, -8.37679505e-02f, -7.03399926e-02f, -1.77420393e-01f, -7.25531653e-02f, 1.30926147e-01f,
  8.63670856e-02f, 8.00004303e-02f, 2.47239247e-02f, 7.88417161e-02f, 1.05485052e-01f, -8.80950913e-02f, 1.09601289e-01f, 1.40502349e-01f, 5.93647473e-02f, 2.01694369e-01f,
  1.55852824e-01f, -8.83987988e-04f, -1.30665172e-02f, -7.38223121e-02f, 9.11304578e-02f, 6.72291666e-02f, 2.33699847e-02f, 8.03721100e-02f, -2.81274859e-02f, -1.52458511e-02f,
  4.03287336e-02f, 4.71253060e-02f, 6.10293895e-02f, -5.32287313e-03f, 2.52969172e-02f, 3.52450982e-02f, -5.88686951e-02f, 7.29717463e-02f, -1.55553957e-02f, 2.16110749e-03f,
  6.65275473e-03f, 1.11349873e-01f, -8.08835998e-02f, 6.81553334e-02f, 7.27881789e-02f, -7.19911531e-02f, 2.02348325e-02f, 1.19775072e-01f, 2.65347790e-02f, -7.98564777e-02f,
  -1.95755959e-01f, -1.96100771e-01f, -9.53111276e-02f, -3.25159803e-02f, -9.03375670e-02f, -4.87330742e-03f, -9.33385361e-03f, -1.10661815e-04f, -7.74059743e-02f, -4.83243875e-02f,
  7.29297623e-02f, -1.19844088e-02f, 1.32599436e-02f, -5.10256179e-02f, -6.11877590e-02f, 5.99850379e-02f, 1.01277225e-01f, -8.36836621e-02f, -5.97226713e-03f, 4.40131612e-02f,
  6.86996207e-02f, -2.82729252e-06f, -7.88051113e-02f, 8.08127299e-02f, 5.10150343e-02f, -1.33359954e-01f, -2.04002410e-02f, 3.29943746e-02f, 4.89105396e-02f, 1.66311026e-01f,
  -1.99812017e-02f, -1.98296160e-01f, 1.80670679e-01f, -1.97061256e-01f, -1.66289613e-01f, 5.33126155e-03f, -3.88643891e-01f, -2.32954919e-01f, -1.97620228e-01f, -2.62812972e-01f,
  3.85475606e-02f, 3.25826049e-01f, 2.71976292e-01f, 3.14925373e-01f, 2.85685748e-01f, -1.56580493e-01f, -1.96115956e-01f, 3.58215302e-01f, 4.88924235e-01f, -2.82524212e-04f,
  -7.51152262e-02f, -4.39613126e-02f, 1.91574931e-01f, 3.91087681e-03f, -3.02299738e-01f, 1.32436320e-01f, -2.60968864e-01f, -1.17457457e-01f, -1.39675170e-01f, -3.45785618e-01f,
  2.06297949e-01f, -1.91737905e-01f, 4.09570746e-02f, -7.93479532e-02f, -4.88010533e-02f, 2.39169523e-02f, -9.94632393e-02f, -7.69205913e-02f, -3.70051488e-02f, -8.69510025e-02f,
  7.79137462e-02f, 9.19849053e-02f, 1.04038015e-01f, -3.65910828e-02f, -1.24249972e-01f, -5.21642268e-02f, -1.46110564e-01f, 7.80137628e-02f, 2.38952274e-03f, -1.03442401e-01f,
  -7.47724026e-02f, -1.11549765e-01f, 7.88835958e-02f, 3.65640596e-02f, -1.46646053e-01f, 1.10859297e-01f, -7.60234371e-02f, 9.58768371e-03f, 7.60565624e-02f, -3.11358511e-01f,
  -1.40390947e-01f, 7.75394663e-02f, 5.94881305e-04f, -1.44995183e-01f, -7.04784319e-03f, 4.22475487e-02f, -3.04270014e-02f, -4.35650684e-02f, -5.89655191e-02f, 1.34165660e-01f,
  1.43797129e-01f, -5.17699085e-02f, -6.35989457e-02f, 5.80812665e-03f, 1.19745359e-01f, 1.83101837e-02f, 3.84839065e-02f, -9.74653065e-02f, -4.93058711e-02f, 7.27613941e-02f,
  5.04949279e-02f, 1.08697647e-02f, -4.05068882e-03f, -2.17660442e-02f, 5.56600094e-02f, 1.08347930e-01f, 6.62553683e-02f, 1.43414229e-01f, -1.98632642e-03f, -6.90092240e-03f,
  8.58338028e-02f, 2.21662641e-01f, -1.28892079e-01f, 1.21817959e-03f, -1.14594318e-01f, 8.26898031e-03f, -1.81988433e-01f, -1.45331456e-03f, 4.16518077e-02f, 2.37386636e-02f,
  1.41064161e-02f, -1.05418697e-01f, 5.84182926e-02f, -6.19735457e-02f, 1.25508318e-02f, -6.69263825e-02f, -8.37255269e-02f, 8.83720741e-02f, -1.14207540e-03f, -9.24770907e-02f,
  -2.97670543e-01f, -7.03084245e-02f, 2.60580450e-01f, 1.64015874e-01f, -6.74300417e-02f, 1.56853899e-01f, 6.96353018e-02f, 2.19101384e-02f, 1.92263469e-01f, -9.64422822e-02f,
  -3.93162906e-01f, 2.49663591e-01f, 3.25404167e-01f, -2.19580993e-01f, -6.34934306e-02f, 1.35082871e-01f, 2.67518044e-01f, -3.15714367e-02f, -3.49062294e-01f, -9.18955542e-03f,
  9.39979870e-03f, -2.84476757e-01f, -1.66907534e-02f, -3.10220029e-02f, 1.37632713e-01f, 1.23728842e-01f, 1.58056766e-01f, 7.69079402e-02f, 4.84040938e-02f, 1.54829919e-02f,
  -1.32694796e-01f, -1.45524099e-01f, -1.59074105e-02f, -4.52821739e-02f, -1.20255284e-01f, -1.29160374e-01f, 9.90405958e-03f, 7.17525482e-02f, 1.54296339e-01f, -1.19897969e-01f,
  -4.68745886e-04f, -4.69741672e-02f, -1.63079090e-02f, -2.04801872e-01f, 3.44180092e-02f, -4.83055487e-02f, 1.84677746e-02f, -4.88494784e-02f, 2.21198034e-02f, -4.72357981e-02f,
  -1.24383278e-01f, -1.83742587e-02f, 2.69126203e-02f, 3.08823101e-02f, -7.53098726e-02f, -6.52042106e-02f, 5.77515028e-02f, 2.56141946e-02f, 1.03403501e-01f, 5.73898405e-02f,
  -1.51874833e-02f, -7.62303993e-02f, 1.07215926e-01f, 1.48130700e-01f, 1.31760985e-01f, -1.52557030e-01f, -8.62117782e-02f, -6.12284876e-02f, 7.92137831e-02f, -2.23061979e-01f,
  -1.39413267e-01f, -1.82004124e-02f, 3.46854478e-02f, -1.64099574e-01f, -3.35377268e-02f, -7.81975091e-02f, 4.20761891e-02f, 3.85809615e-02f, 3.09459250e-02f, -2.15755608e-02f,
  5.90834916e-02f, 7.34860674e-02f, -9.54103023e-02f, 1.37845173e-01f, -1.20888188e-01f, -3.05415923e-03f, 3.71449143e-02f, -1.00222405e-03f, 8.20143074e-02f, 4.67190966e-02f,
  -5.07194772e-02f, 8.72148201e-02f, 2.09386870e-02f, 8.52018408e-03f, 1.64330713e-02f, 3.20674516e-02f, -3.55986841e-02f, -2.17407867e-02f, 8.30623358e-02f, -5.98858930e-02f,
  -3.35488111e-01f, 2.74182558e-01f, -1.82652220e-01f, -1.12561770e-01f, 4.69819866e-02f, 1.13256052e-01f, 9.51262936e-02f, 1.34608269e-01f, 1.42119033e-02f, -1.06700957e-02f,
  7.64369071e-02f, -1.05952039e-01f, 5.14176153e-02f, 1.43766627e-02f, 3.36495526e-02f, -5.02979895e-03f, 4.14345302e-02f, 1.25597343e-02f, 1.31516650e-01f, -3.01983934e-02f,
  -4.41068271e-03f, -4.35582586e-02f, -1.48443907e-01f, 9.18907672e-02f, -7.61944428e-02f, -1.34347364e-01f, -1.24477282e-01f, -2.25882798e-01f, -3.87713239e-02f, -3.80486399e-01f,
  -4.60406750e-01f, 1.18046381e-01f, 3.06090266e-01f, -2.91624814e-01f, -7.87983164e-02f, -7.68295601e-02f, 1.15925958e-03f, -1.67353526e-01f, -1.80742756e-01f, 1.01271726e-01f,
  2.42314667e-01f, 6.17211610e-02f, 1.09457962e-01f, -2.26264708e-02f, -1.61850169e-01f, 1.08434223e-01f, -1.08030394e-01f, -6.14689067e-02f, -1.85869724e-01f, -1.98474824e-01f,
  -7.86142945e-02f, -6.89361989e-02f, -1.86230883e-01f, -2.38972470e-01f, 1.06942780e-01f, 1.12161346e-01f, 1.34935081e-01f, 2.32083704e-02f, 1.69335619e-01f, 7.08710849e-02f,
  2.94515461e-01f, -8.19909349e-02f, -1.88971739e-02f, -3.18846166e-01f, 1.41790479e-01f, -7.62621984e-02f, -1.77161589e-01f, 3.09649594e-02f, -7.70894885e-02f, -1.39567079e-02f,
  -1.32808015e-01f, -5.57606928e-02f, -8.59111547e-02f, 1.94774885e-02f, -8.48862901e-02f, -9.98335108e-02f, -9.90911871e-02f, -2.08491549e-01f, -3.58314626e-02f, 1.14940062e-01f,
  -6.75794557e-02f, -9.34663974e-03f, 7.64718577e-02f, 3.47073795e-03f, 4.86042015e-02f, -1.06321827e-01f, 1.65689051e-01f, -1.17234737e-01f, -6.16356805e-02f, 1.35092378e-01f,
  -1.08453436e-02f, -6.80634156e-02f, -8.79916251e-02f, -3.96491848e-02f, -5.92324585e-02f, -6.40136674e-02f, -3.10527515e-02f, -2.06311885e-02f, -6.85407445e-02f, 4.45751883e-02f,
  -4.62713391e-02f, 2.76858136e-02f, 2.95407102e-02f, 4.83145714e-02f, 3.76904421e-02f, -5.23901805e-02f, -7.77944326e-02f, 1.94152482e-02f, 1.13439530e-01f, -1.03631662e-02f,
  -1.89371660e-01f, -7.66182691e-02f, 8.10199976e-02f, -3.35415155e-02f, 2.87322421e-03f, -8.33515674e-02f, -1.56909805e-02f, -7.26000890e-02f, -5.49264699e-02f, -9.89677235e-02f,
  2.04106092e-01f, -9.65964347e-02f, 9.14282948e-02f, -1.51752517e-01f, -7.02510253e-02f, 1.66059300e-01f, -2.16008779e-02f, -1.47249568e-02f, 8.13869238e-02f, 1.95020586e-02f,
  -1.12691717e-02f, 3.55765107e-03f, 1.65017247e-01f, 2.00042222e-02f, -4.41639051e-02f, 2.23087650e-02f, -5.10412678e-02f, 2.01846957e-02f, -9.48791429e-02f, -1.32463977e-01f,
  3.95060666e-02f, -8.91341567e-02f, 6.18908294e-02f, 4.34851535e-02f, 1.64629072e-01f, -7.93547407e-02f, 2.00880498e-01f, 1.57279462e-01f, 1.32293940e-01f, 1.53331861e-01f,
  -3.19780260e-02f, -1.42884463e-01f, -2.06783116e-01f, -6.61093518e-02f, -2.70311963e-02f, -4.07404043e-02f, -1.64692387e-01f, 7.25473166e-02f, 2.41911039e-02f, -3.00493509e-01f,
  -6.87476546e-02f, 1.21682867e-01f, -1.27386376e-01f, 8.27219114e-02f, 5.39281331e-02f, -3.24020803e-01f, -1.80475339e-01f, -4.46469113e-02f, 2.72114784e-01f, 2.46095434e-01f,
  8.00926164e-02f, 3.31022479e-02f, 8.80088210e-02f, 1.17377087e-01f, -6.21876046e-02f, -5.76986633e-02f, -2.33977482e-01f, -1.34267628e-01f, -6.84515610e-02f, -3.65557164e-01f,
  -3.27742070e-01f, 5.95480613e-02f, 4.71448153e-02f, -5.93043193e-02f, -6.23032488e-02f, 1.37310624e-01f, 5.54847252e-03f, 5.32809272e-02f, -4.05492373e-02f, 1.53090432e-02f,
  -2.53868736e-02f, 1.64738715e-01f, -1.41989049e-02f, -3.95825431e-02f, -5.70779033e-02f, 1.55266076e-01f, 3.44660766e-02f, 5.70605788e-03f, -6.76056519e-02f, -8.21855813e-02f,
  -1.52040839e-01f, -4.45950814e-02f, -1.37530282e-01f, -2.24670265e-02f, 4.84687313e-02f, 9.56815481e-02f, 4.00251411e-02f, 1.13626033e-01f, 2.49594972e-02f, -3.09174180e-01f,
  -7.10990578e-02f, -1.46663919e-01f, 2.30005570e-02f, 3.86953540e-02f, 1.02633961e-01f, -9.17770937e-02f, -6.93021193e-02f, -1.11577772e-01f, -3.95335294e-02f, 5.04310243e-02f,
  9.90865566e-03f, -3.49619053e-03f, 1.38867766e-01f, -9.40485075e-02f, -1.27887562e-01f, -2.22872980e-02f, -8.88958350e-02f, -1.13629952e-01f, -7.00182468e-03f, -2.02543195e-02f,
  6.60716832e-05f, -1.23410737e-02f, -9.96815115e-02f, 7.10054114e-02f, 2.76531260e-02f, -1.24720842e-01f, -5.45286797e-02f, 1.02919713e-02f, 1.96195394e-02f, -1.61603004e-01f,
  -8.09005946e-02f, 6.60684332e-02f, -1.85945258e-01f, 8.71145353e-02f, 5.55242263e-02f, -1.55729316e-02f, -1.12197429e-01f, 9.68927518e-02f, -1.16233015e-02f, 4.46485132e-02f,
  -2.45261304e-02f, -1.47638293e-02f, -6.53852448e-02f, -7.52631575e-02f, 3.10954116e-02f, -6.44704551e-02f, -7.62549415e-02f, -1.36567861e-01f, -3.05339191e-02f, -6.81206137e-02f,
  -1.14626199e-01f, -5.17773181e-02f, -3.88573259e-02f, -9.01872590e-02f, -1.45692140e-01f, 1.05880089e-02f, -2.41795499e-02f, -9.01068971e-02f, -1.48869054e-02f, -1.64673179e-01f,
  -1.37587443e-01f, 1.45720795e-01f, 5.46506830e-02f, 1.87424615e-01f, 1.85243428e-01f, -1.48540109e-01f, -1.79598883e-01f, -1.04491509e-01f, 5.32720387e-02f, 1.10762060e-01f,
  6.60107136e-02f, -5.95988594e-02f, 7.03855976e-02f, -8.61783233e-03f, -9.62600783e-02f, 3.66528742e-02f, 1.76475227e-01f, -1.47008434e-01f, -3.04942697e-01f, -3.13501120e-01f,
  2.97330171e-02f, -5.49088418e-02f, -2.15297192e-01f, -1.61229577e-02f, 2.41275549e-01f, 1.84522271e-02f, 1.92183286e-01f, 1.38181493e-01f, 2.60490943e-02f, 2.70481616e-01f,
  3.32179628e-02f, 3.20676975e-02f, -1.85639828e-01f, 1.66992560e-01f, 1.16590649e-01f, -3.14869955e-02f, -7.21829906e-02f, -8.97973329e-02f, -1.93472747e-02f, -9.56746750e-03f,
  2.44653299e-01f, -1.37034461e-01f, 1.55509368e-01f, -8.71100873e-02f, -1.75424233e-01f, -2.61129528e-01f, -1.66915432e-01f, -2.71394908e-01f, -2.00859994e-01f, -1.73538893e-01f,
  1.13740899e-01f, -2.63948785e-03f, -1.10285260e-01f, -6.93385378e-02f, -1.18796237e-01f, -8.39070678e-02f, -8.71689469e-02f, -3.36781107e-02f, -2.92362124e-01f, -7.07651302e-02f,
  -2.41954462e-04f, 9.28108469e-02f, -4.86609899e-02f, -1.86364949e-02f, -3.76599468e-02f, 4.97213518e-03f, 8.81277546e-02f, 1.04091585e-01f, 6.47090822e-02f, -1.20519474e-01f,
  -8.02784488e-02f, 4.46541719e-02f, 4.49324585e-03f, -6.56719804e-02f, 4.57366705e-02f, 5.99940158e-02f, 2.44008116e-02f, -5.07319346e-02f, -1.68057699e-02f, 4.73586470e-02f,
  -1.26520693e-02f, -8.91150236e-02f, 6.57413080e-02f, -7.87308216e-02f, 4.18375619e-02f, -1.12126887e-01f, 6.53109476e-02f, -8.20076317e-02f, 3.42320837e-02f, 9.88315418e-03f,
  -4.24527153e-02f, -1.22672446e-01f, -6.26328662e-02f, -9.11302269e-02f, 6.29542470e-02f, -6.25334010e-02f, 6.27245083e-02f, -1.89038124e-02f, 1.33951843e-01f, -8.47252384e-02f,
  -1.13817863e-01f, -1.11449147e-02f, 1.06997617e-01f, -3.02205887e-02f, -1.08272612e-01f, 4.96312194e-02f, 5.96595593e-02f, 1.86303295e-02f, -6.65232632e-03f, -6.93032751e-03f,
  7.90076405e-02f, -8.43899027e-02f, -9.77024809e-02f, -2.68126018e-02f, 1.81639567e-01f, -8.05868059e-02f, -1.86753850e-02f, -1.48024812e-01f, -1.73154831e-01f, -1.29739270e-01f,
  2.41003245e-01f, 3.74284200e-02f, 1.01646423e-01f, 1.50524378e-01f, -2.05303922e-01f, -3.17730308e-01f, -3.95815015e-01f, -3.09865683e-01f, -4.13888209e-02f, 6.81664944e-02f,
  -3.81236710e-02f, 6.86242878e-02f, 5.55867925e-02f, -6.66752318e-03f, -1.28151238e-01f, -5.28026745e-02f, 1.68776318e-01f, 6.29443675e-02f, -1.93397850e-01f, -1.52788833e-01f,
  -2.67683566e-02f, 6.94129691e-02f, 1.12120137e-01f, -3.67443301e-02f, 2.09381014e-01f, -6.10323735e-02f, 1.13179483e-01f, 8.83632675e-02f, 6.87269643e-02f, 3.78203362e-01f,
  1.99014053e-01f, -9.87180602e-03f, -1.33046746e-01f, 2.22111158e-02f, 7.01514855e-02f, 9.27868187e-02f, -7.05117881e-02f, 1.93117127e-01f, 2.80158799e-02f, 2.31762473e-02f,
  1.09802313e-01f, 2.96497606e-02f, 3.87762710e-02f, -2.66070627e-02f, 6.58670962e-02f, -9.25113708e-02f, 8.57558660e-03f, 1.01802826e-01f, 2.15606794e-01f, 1.08307209e-02f,
  -6.22505182e-03f, -1.02113865e-01f, -1.84320331e-01f, -1.47234946e-01f, -2.50718538e-02f, 5.67761771e-02f, -2.25135386e-01f, 2.03071325e-03f, -1.79271117e-01f, 1.43578291e-01f,
  -6.59629703e-02f, 9.34794173e-03f, -9.57311988e-02f, 4.95376252e-02f, -1.13200964e-02f, 8.21331292e-02f, 2.54591275e-02f, 5.06734755e-03f, -5.26723394e-04f, 3.73617820e-02f,
  3.15983184e-02f, -6.33505033e-03f, 5.37650324e-02f, -4.76008393e-02f, -4.78322897e-03f, 7.12929964e-02f, -7.94966146e-03f, 4.39385511e-03f, -1.80720873e-02f, -4.03643288e-02f,
  -6.42829388e-02f, 9.55372583e-03f, 4.78437766e-02f, 8.62315148e-02f, 1.62817799e-02f, -3.67892981e-02f, 7.33507378e-03f, 4.34397422e-02f, 7.29592666e-02f, 1.02714039e-01f,
  -1.66103877e-02f, -1.91413969e-01f, 1.11512557e-01f, 3.47407348e-02f, -4.02796008e-02f, -8.25277716e-02f, 1.01110652e-01f, -4.10425738e-02f, 5.10024019e-02f, 2.59515569e-02f,
  -9.44228098e-02f, -1.09626234e-01f, 7.34266415e-02f, -2.47505251e-02f, -8.66196975e-02f, -7.47981966e-02f, -6.20475709e-02f, -8.03003684e-02f, -3.28816921e-02f, -7.62945740e-03f,
  -5.84193729e-02f, -2.74126381e-01f, -2.48903975e-01f, -9.95184705e-02f, -4.97766733e-02f, -1.21292852e-01f, -1.60306424e-01f, -1.21637017e-01f, -1.60213754e-01f, -1.37816831e-01f,
  4.33757424e-01f, -1.88113019e-01f, -3.99920732e-01f, -3.67427655e-02f, -3.05304646e-01f, -9.00230780e-02f, -3.45571935e-01f, -1.00545157e-02f, -4.02571373e-02f, -3.50790352e-01f,
  -1.13959879e-01f, 1.28061309e-01f, 1.02865294e-01f, 7.54514337e-02f, 1.45623326e-01f, -3.15467209e-01f, -1.92439124e-01f, 1.29022887e-02f, 1.94693938e-01f, 5.19910492e-02f,
  -7.37861618e-02f, 5.69669455e-02f, 1.37036428e-01f, 1.84974317e-02f, -1.87294140e-01f, -9.69663560e-02f, -2.99301714e-01f, -9.88586843e-02f, -1.94025010e-01f, -2.28454545e-01f,
  -2.95541942e-01f, -5.82306273e-02f, -6.99522272e-02f, 9.02517736e-02f, -1.19443968e-01f, -1.39680943e-02f, 7.17174783e-02f, -2.20759939e-02f, -1.98094100e-02f, -1.12824231e-01f,
  -1.10963330e-01f, 4.15593050e-02f, 9.77933332e-02f, -1.21205047e-01f, 7.52234692e-03f, -7.13575492e-03f, -8.23929980e-02f, 5.72287925e-02f, -1.12834878e-01f, -8.91728848e-02f,
  8.50454196e-02f, -4.39756270e-03f, 3.32259387e-03f, 1.70475263e-02f, -5.62314223e-03f, 7.24598169e-02f, -5.53661548e-02f, 4.96209376e-02f, -4.37459946e-02f, -1.42301202e-01f,
  -5.89762181e-02f, -1.57922849e-01f, -4.52151103e-03f, -8.58242344e-03f, -4.58209440e-02f, -2.87466943e-02f, -1.11588882e-02f, -3.60095277e-02f, 6.61658645e-02f, 8.08509067e-02f,
  -2.51490274e-03f, -5.16798273e-02f, 4.30292897e-02f, -7.36798247e-05f, 1.05699142e-02f, 6.23180531e-02f, 4.99285087e-02f, 6.36143535e-02f, -3.06773335e-02f, -4.96377200e-02f,
  1.54547766e-01f, -9.04271752e-03f, 2.82876883e-02f, 3.68557386e-02f, 8.41217414e-02f, 1.77980624e-02f, -1.70695260e-02f, 1.51999548e-01f, 5.86184748e-02f, 1.03225455e-01f,
  4.02373932e-02f, 2.00070605e-01f, -1.72459394e-01f, 8.83566737e-02f, -7.43600652e-02f, 6.18177429e-02f, -7.80181810e-02f, -1.63860749e-02f, -7.92746246e-03f, -1.21100046e-01f,
  2.81576142e-02f, 1.31113291e-01f, 2.04621200e-02f, -3.97891030e-02f, 5.78567535e-02f, -4.30484973e-02f, 6.88275397e-02f, 1.77386507e-01f, 1.37972072e-01f, 3.97491530e-02f,
  -2.49963459e-02f, 1.03330880e-01f, 2.89759606e-01f, -2.81722043e-02f, 9.07644928e-02f, 8.51935148e-02f, 1.19756207e-01f, 9.69662517e-03f, 1.65712491e-01f, 2.65092999e-02f,
  4.30982918e-01f, -3.68213475e-01f, 5.22314236e-02f, 5.69794960e-02f, -7.91285280e-03f, 1.02806762e-01f, -1.36804655e-01f, -4.71511036e-02f, 3.03968263e-04f, 3.77064198e-02f,
  1.64509609e-01f, 3.13962162e-01f, 2.04674527e-01f, 1.95279658e-01f, 1.41802773e-01f, -1.18050367e-01f, -3.70426401e-02f, 1.02108613e-01f, 1.27260000e-01f, 2.60211658e-02f,
  -1.13218918e-01f, -2.27132849e-02f, -6.58568740e-02f, -1.39899328e-01f, -2.56886810e-01f, -2.53794454e-02f, -1.23842889e-02f, -8.26340285e-04f, 1.08888242e-02f, -1.38847306e-01f,
  1.11436836e-01f, -3.46000120e-02f, 1.02595679e-01f, -2.41517760e-02f, -3.32796462e-02f, 7.79939964e-02f, 6.56039193e-02f, -3.82398046e-03f, -5.70581015e-03f, -1.43292295e-02f,
  -1.30399212e-01f, -7.49461800e-02f, 1.56916399e-02f, -5.09471782e-02f, -1.52664527e-01f, -9.99848694e-02f, -5.56184351e-02f, -7.10789338e-02f, 7.21393824e-02f, 5.53665981e-02f,
  -6.32925704e-02f, 9.50456224e-03f, 9.18839574e-02f, 6.45807129e-04f, 9.58909988e-02f, 1.57890603e-01f, 6.65612519e-02f, 2.81815492e-02f, 1.63856700e-01f, 8.11429694e-02f,
  9.99919400e-02f, 2.78203785e-02f, 1.10195160e-01f, 1.44650668e-01f, 6.43058959e-03f, 2.81492863e-02f, -2.38723271e-02f, 3.18694301e-03f, 8.34047124e-02f, -5.03154807e-02f,
  -1.35015130e-01f, -1.97062287e-02f, -2.57004444e-02f, -7.82501418e-03f, 5.23395836e-03f, -1.37455061e-01f, -1.14391342e-01f, -4.02880311e-02f, 8.09341520e-02f, -3.86408530e-02f,
  -1.41589167e-02f, -1.68615468e-02f, -1.19068153e-01f, -1.58933580e-01f, -1.66098088e-01f, 3.62975001e-02f, 4.10905965e-02f, -8.50258842e-02f, 1.24060232e-02f, 3.51069756e-02f,
  -8.02079365e-02f, 2.52640754e-01f, -2.41340958e-02f, -1.24842510e-01f, -1.01475298e-01f, 7.81734847e-03f, 2.43206933e-01f, -2.60364115e-02f, -1.46200418e-01f, 3.28618549e-02f,
  3.86951640e-02f, -5.27268052e-02f, -1.10794418e-01f, -1.03376821e-01f, -1.71865448e-02f, 7.20924363e-02f, 2.81684808e-02f, 5.39643951e-02f, -1.23311225e-02f, -1.68137059e-01f,
  -4.29611132e-02f, 1.90101206e-01f, 1.60835519e-01f, 1.32924169e-01f, 1.13345526e-01f, 1.43755466e-01f, 1.09790131e-01f, 9.15338024e-02f, 1.42643541e-01f, -3.48889232e-02f,
  2.45194674e-01f, 9.66555774e-02f, -4.18112606e-01f, 4.11171801e-02f, -1.31743640e-01f, -2.25145847e-01f, -1.92777753e-01f, 7.80945718e-02f, 8.04345980e-02f, 8.96526203e-02f,
  7.13749900e-02f, 2.76846383e-02f, -7.38141164e-02f, -2.88315117e-01f, -3.11450690e-01f, -2.97500491e-01f, -1.64315224e-01f, -3.83342654e-01f, -4.10148442e-01f, -2.57568568e-01f,
  -1.42819896e-01f, -2.92886458e-02f, -1.37671143e-01f, 1.84819549e-02f, 2.06341058e-01f, 1.73970044e-01f, -3.37795317e-02f, -4.22765426e-02f, -9.23194513e-02f, 8.63661990e-02f,
  -1.75789788e-01f, -1.39125064e-01f, -5.03626652e-02f, 1.20523437e-04f, -2.28094831e-02f, 7.64396861e-02f, -1.87190637e-01f, 3.65949534e-02f, 1.26724243e-01f, 1.80922579e-02f,
  -1.24579139e-01f, -3.16970493e-03f, -1.07855566e-01f, -5.01841716e-02f, -9.78815481e-02f, -1.12795442e-01f, 6.54823706e-02f, -5.27354479e-02f, -1.19715378e-01f, -5.14734387e-02f,
  -2.12390944e-01f, -1.77340254e-01f, -2.28104591e-01f, -7.41890967e-02f, -1.78092599e-01f, -2.34558731e-01f, 5.44312336e-02f, -4.77349348e-02f, -1.88960992e-02f, 2.80119985e-01f,
  5.28461747e-02f, -3.05707324e-02f, -6.08985610e-02f, 1.20832413e-01f, 1.74087230e-02f, 5.76666929e-02f, -3.50325741e-02f, 6.54257312e-02f, -4.22409400e-02f, -3.72263566e-02f,
  1.03768364e-01f, -1.00447400e-03f, -9.46270023e-03f, -4.28408235e-02f, 4.14590463e-02f, -5.57825202e-03f, -1.36685446e-01f, -2.16222089e-02f, -3.52716260e-02f, -9.79490671e-03f,
  -8.48262012e-02f, -6.26533106e-02f, 3.91052030e-02f, 4.46024397e-03f, -4.75640781e-02f, -6.85223490e-02f, -3.49893421e-02f, -1.25377148e-01f, 7.80874789e-02f, -9.30031165e-02f,
  1.46520510e-01f, -2.50852138e-01f, 3.31906639e-02f, -8.27187374e-02f, -7.07150623e-02f, 1.30679330e-03f, 2.45830286e-02f, 1.37413787e-02f, -1.31012365e-01f, -7.35101998e-02f,
  -1.07961453e-01f, 1.98312439e-02f, -2.28527784e-02f, 6.40551299e-02f, -3.82374376e-02f, -1.60914585e-01f, 2.58162431e-02f, 4.65030894e-02f, -1.35847822e-01f, -1.93689088e-03f,
  8.63949955e-02f, -1.32079825e-01f, -1.22796418e-02f, 1.23493209e-01f, -3.25830169e-02f, -1.00143932e-01f, -3.40725072e-02f, 1.49301067e-01f, 4.45075035e-02f, 2.39478722e-01f,
  2.03649372e-01f, 1.95865527e-01f, 3.00608836e-02f, 1.54629737e-01f, 1.74188539e-01f, 1.93187296e-01f, 2.98175544e-01f, 2.07733676e-01f, 1.09636784e-02f, 1.58661097e-01f,
  -4.67513502e-02f, -3.71830165e-01f, -3.19128752e-01f, -3.31078917e-01f, -1.30743966e-01f, 5.66103449e-03f, -1.94722675e-02f, -2.06957817e-01f, -1.72633797e-01f, -8.19885582e-02f,
  8.19491223e-02f, 3.34156632e-01f, 1.72552362e-01f, 7.64514580e-02f, -1.69984810e-02f, -5.15005551e-02f, 1.13998711e-01f, 1.68091327e-01f, 4.65259627e-02f, -1.50399774e-01f,
  -1.48244917e-01f, 2.76150256e-01f, -2.87979096e-01f, -1.51551530e-01f, -3.26498672e-02f, -6.54181391e-02f, 4.32936102e-02f, -2.40262989e-02f, 4.28828560e-02f, 6.65475577e-02f,
  -6.94662780e-02f, -5.55807278e-02f, -7.18531013e-02f, -3.73994447e-02f, 1.15677647e-01f, -3.14588994e-02f, 9.67663527e-02f, -5.71740270e-02f, -1.71079680e-01f, -3.00730150e-02f,
  -2.24447194e-02f, 1.24918967e-01f, 1.37180239e-01f, -6.48744702e-02f, -1.18325226e-01f, -1.68452919e-01f, 2.42853141e-03f, -5.93702607e-02f, -1.08050525e-01f, 1.70169249e-01f,
  4.22483943e-02f, -9.23334062e-02f, -1.48628160e-01f, 1.27130553e-01f, 1.38481464e-02f, -3.81722525e-02f, 1.38359908e-02f, 1.04219660e-01f, 1.55823112e-01f, 5.27895950e-02f,
  -7.29442909e-02f, 1.11528695e-01f, 8.63382220e-02f, 1.05763771e-01f, -5.29494993e-02f, 4.51895110e-02f, -5.76217175e-02f, 7.73664042e-02f, 3.55662294e-02f, 4.14574370e-02f,
  5.05090542e-02f, -5.47097484e-03f, 7.77061284e-02f, -1.23381853e-01f, 1.04735807e-01f, 1.27062742e-02f, 6.88688755e-02f, 7.15119019e-02f, 8.99676606e-02f, 4.02029604e-03f,
  2.71403611e-01f, 9.46573541e-02f, -1.57760262e-01f, -2.26063475e-01f, 1.51808262e-01f, -2.22978145e-02f, -9.91095416e-03f, -3.41559909e-02f, 7.01244622e-02f, 6.98339343e-02f,
  -5.91781437e-02f, -1.24025829e-02f, 1.25235274e-01f, 1.33901045e-01f, 5.24484329e-02f, 7.68161891e-03f, 3.67202424e-02f, -6.51418138e-03f, -1.14113249e-01f, -6.09158259e-03f,
  8.43186006e-02f, 1.33484945e-01f, 1.51593953e-01f, -4.46911342e-02f, -4.50098552e-02f, -1.52163863e-01f, 5.50765619e-02f, -1.33027071e-02f, -1.54847028e-02f, 2.89918333e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.99757645e-02f, 2.53473878e-01f, -7.13917315e-02f, 2.55070720e-02f, 8.05404037e-02f, 2.30853021e-01f, 6.36624023e-02f, 1.24380462e-01f, 2.22180441e-01f, 3.38364184e-01f,
  8.82257596e-02f, 3.30989510e-02f, -5.75953834e-02f, 4.08629626e-02f, 3.38398874e-01f, 1.80238649e-01f, 6.40563071e-02f, 1.82255417e-01f, -4.92424844e-03f, 1.59500211e-01f,
  2.06056044e-01f, 1.20150380e-01f, 2.33028263e-01f, 1.29582763e-01f, 9.43997726e-02f, 2.49504969e-01f, -1.11751920e-02f, 2.26192027e-01f, 1.21103719e-01f, 1.73163220e-01f,
  1.44321024e-01f, 2.01626942e-01f, 4.74797674e-02f, 2.36530021e-01f, -1.17041908e-01f, 1.06521457e-01f, 1.57760173e-01f, 2.07634419e-01f, -1.13594681e-01f, 1.78230792e-01f,
  9.90256518e-02f, 2.16690049e-01f, 2.89862573e-01f, 2.53910691e-01f, 5.76775558e-02f, 1.10644862e-01f, 1.41410649e-01f, 1.39721572e-01f, 3.61940153e-02f, -4.04247232e-02f,
  1.03075407e-01f, 1.62407786e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.60474032e-02f, 4.08362560e-02f, 3.37589011e-02f, -6.26508445e-02f, 7.77996257e-02f, 2.90300287e-02f, 7.57858679e-02f, 1.37968466e-01f, -1.34586528e-01f, -2.90103592e-02f,
  7.75596052e-02f, -3.57526680e-03f, -2.04293385e-01f, -2.66262919e-01f, 9.73649397e-02f, 7.01094195e-02f, 1.64593786e-01f, 6.64236816e-03f, -1.18984185e-01f, -1.51966065e-01f,
  2.43904084e-01f, 1.20694965e-01f, -3.07298630e-01f, 3.75109054e-02f, -6.33242652e-02f, 1.85694322e-01f, -9.41423625e-02f, -6.47320673e-02f, 5.20578586e-02f, 2.14250702e-02f,
  -2.76543677e-01f, 6.28415421e-02f, -2.78815180e-02f, 3.70568782e-02f, -7.36436248e-02f, 1.14882104e-01f, 1.35919198e-01f, -1.18883394e-01f, 1.11040063e-01f, 9.77527425e-02f,
  -5.58966286e-02f, 1.25055194e-01f, -1.86370105e-01f, -1.82067662e-01f, 9.32117403e-02f, 1.62548289e-01f, -3.77236530e-02f, -5.97263835e-02f, 1.42213359e-01f, 3.59477438e-02f,
  9.65045914e-02f, -2.62022130e-02f, -1.03131756e-01f, -1.20210633e-01f, -7.80975297e-02f, -1.81514621e-01f, -1.17466912e-01f, -4.61124033e-02f, 9.93402582e-03f, -3.11017130e-02f,
  1.02025576e-01f, -5.40848933e-02f, 1.26089334e-01f, 2.27259770e-01f, -1.40441181e-02f, -1.44927368e-01f, -4.01847325e-02f, -1.16542645e-01f, -6.95351884e-02f, 2.70624496e-02f,
  4.85793240e-02f, -1.69386297e-01f, 3.63095887e-02f, -4.56189588e-02f, -3.34737413e-02f, 1.20247891e-02f, 1.33266300e-01f, 1.14465319e-01f, -2.90534217e-02f, -2.35021766e-02f,
  -1.45816311e-01f, -2.58951068e-01f, 2.39758212e-02f, -1.39819264e-01f, -1.36830062e-01f, -1.08809896e-01f, 1.66145086e-01f, 2.03761589e-02f, -4.55238819e-02f, 7.90411979e-03f,
  -8.35379809e-02f, 9.78141278e-02f, 2.31981669e-02f, 1.50915936e-01f, 2.07604364e-01f, -2.77156569e-02f, -4.04124632e-02f, -2.20751405e-01f, -1.27413526e-01f, 2.37727668e-02f,
  1.93113342e-01f, -1.99563056e-01f, -2.91310176e-02f, 1.52406752e-01f, -9.63167250e-02f, -1.73593506e-01f, 1.53088063e-01f, -9.70327109e-02f, -2.20231384e-01f, -6.23324141e-02f,
  -2.07925383e-02f, -1.52506651e-02f, -7.88354967e-03f, 1.32875010e-01f, 1.12224579e-01f, -8.83871615e-02f, 1.28283659e-02f, 2.35535935e-01f, -5.90603799e-02f, 1.14731856e-01f,
  -5.25043309e-02f, 3.69204703e-04f, 3.91432121e-02f, -2.27710202e-01f, 6.79780319e-02f, 6.22537965e-03f, -1.10361591e-01f, -3.86980660e-02f, -1.16995007e-01f, -5.08096367e-02f,
  1.02940155e-02f, -4.01588483e-03f, -7.00618401e-02f, 7.99939856e-02f, -1.49678692e-01f, 1.07885733e-01f, 7.18893483e-02f, -1.27320543e-01f, 2.15839688e-02f, -1.42443463e-01f,
  -1.30231872e-01f, 1.48325339e-01f, -7.04035386e-02f, 1.36378303e-01f, 1.08213320e-01f, -2.84320079e-02f, 4.04284447e-02f, 1.72880888e-01f, -1.35379553e-01f, -8.78877342e-02f,
  5.71943400e-03f, -4.11566608e-02f, 6.02383576e-02f, 2.53819823e-02f, -1.05795294e-01f, -9.80163962e-02f, -4.27240180e-03f, -2.58215755e-01f, -1.59588262e-01f, 1.44478977e-01f,
  -2.49969661e-02f, 2.52611618e-02f, -1.15805462e-01f, 1.14618413e-01f, -3.93917076e-02f, -1.59114927e-01f, -1.13111630e-01f, 9.03360024e-02f, -1.39733195e-01f, 5.85173815e-02f,
  2.30985954e-02f, 6.76693618e-02f, -1.68562345e-02f, -1.64126858e-01f, -1.10029913e-01f, 2.88019985e-01f, -1.20649308e-01f, -2.41235852e-01f, 1.64616667e-02f, 1.33114293e-01f,
  -8.10542777e-02f, -2.87784487e-01f, -2.41030812e-01f, -7.84713551e-02f, -1.30990788e-01f, 4.85607944e-02f, 9.86313894e-02f, 9.69985649e-02f, 6.29572710e-03f, -9.45761949e-02f,
  -9.02643020e-04f, 1.61426097e-01f, -1.54031180e-02f, 1.38211660e-02f, 1.20393753e-01f, -2.29222886e-02f, 1.50387630e-01f, 4.08970900e-02f, -6.48428872e-02f, 1.97778627e-01f,
  -8.44137836e-03f, 6.66502267e-02f, 7.75646567e-02f, -3.25311460e-02f, -1.54328942e-01f, -2.21759453e-01f, -1.43940583e-01f, -1.13803491e-01f, 1.94672793e-01f, -5.88262593e-03f,
  4.34538759e-02f, 3.77026320e-01f, -1.62294284e-02f, -9.03916508e-02f, 2.55156774e-03f, -1.78256631e-01f, 4.86101024e-02f, -3.96151505e-02f, 2.02309847e-01f, -2.09191851e-02f,
  1.03714012e-01f, -1.70982406e-01f, -2.12505504e-01f, -8.44209176e-03f, 4.53617498e-02f, 5.20958565e-02f, -3.93594839e-02f, 7.10186586e-02f, -2.21709654e-01f, 1.43446207e-01f,
  -1.05946615e-01f, -9.09986421e-02f, 9.14882794e-02f, -6.24103956e-02f, 2.65605487e-02f, 1.85177922e-01f, 3.20857279e-02f, 2.50309676e-01f, 1.41554847e-01f, 2.84563168e-03f,
  7.33596757e-02f, -1.76681262e-02f, 4.55532297e-02f, 3.67607945e-03f, 1.22165047e-01f, -1.22850724e-01f, -2.08307251e-01f, -2.17773497e-01f, 8.17767605e-02f, -1.63706437e-01f,
  1.58515051e-01f, 3.26611787e-01f, -1.81252539e-01f, 6.75052032e-02f, 2.11584076e-01f, 1.84302047e-01f, -1.27391508e-02f, -3.11775077e-02f, -4.91339304e-02f, 6.56262487e-02f,
  1.03626035e-01f, -7.27607086e-02f, -4.70376313e-02f, -9.90495309e-02f, -6.02847263e-02f, -2.18804460e-02f, 1.12414107e-01f, -1.02704793e-01f, -2.57234305e-01f, 1.74329311e-01f,
  -1.14575811e-01f, 1.96716171e-02f, 1.52451331e-02f, -4.44738753e-02f, -1.48810476e-01f, -2.29065940e-01f, -9.12977755e-02f, 1.49938673e-01f, 2.16908008e-01f, 4.95105516e-03f,
  -8.53711367e-02f, 1.14665046e-01f, -4.77378145e-02f, 1.34365916e-01f, -1.31257683e-01f, -1.20739024e-02f, -1.31436542e-01f, -2.25574180e-01f, 4.83528338e-02f, 1.30833760e-01f,
  1.33694366e-01f, 7.44321346e-02f, 1.65839598e-01f, -1.26217946e-01f, -1.88616171e-01f, 2.58399934e-01f, -2.27001727e-01f, -2.31448069e-01f, -4.50466834e-02f, -1.51910171e-01f,
  3.20766866e-02f, 1.10213514e-02f, -1.45630524e-01f, -2.36509778e-02f, -3.37374061e-02f, -5.16603924e-02f, -1.27456054e-01f, -3.12095694e-02f, -8.68333876e-02f, -1.87551305e-02f,
  2.55142469e-02f, 1.51542336e-01f, 7.55535439e-02f, -1.73343182e-01f, 8.64719748e-02f, 5.94558530e-02f, -2.00512365e-01f, -1.87736332e-01f, -1.54509082e-01f, -2.26973966e-01f,
  -9.55900997e-02f, -3.26915905e-02f, 3.12424246e-02f, -2.09732711e-01f, -1.29269704e-01f, 9.37759951e-02f, -5.89847192e-02f, -2.04052299e-01f, 1.90941796e-01f, -1.05780698e-01f,
  -1.48180053e-01f, 1.66096669e-02f, -2.60488465e-02f, 2.42538974e-01f, 4.65685800e-02f, 6.99048191e-02f, -4.76744995e-02f, -7.22916871e-02f, 1.45184696e-01f, 7.80093372e-02f,
  -2.14136064e-01f, 2.07242146e-01f, -3.49013172e-02f, 8.38622749e-02f, 4.00766283e-02f, 1.70062691e-01f, 1.63438365e-01f, 2.99545284e-02f, 1.18108932e-02f, -1.98047936e-01f,
  4.34521101e-02f, -2.29030505e-01f, -6.17888980e-02f, -3.90094444e-02f, -1.28105074e-01f, -3.96220572e-02f, -7.99627155e-02f, -2.37846449e-01f, -2.82655936e-02f, 5.02884537e-02f,
  1.11723460e-01f, -2.41986945e-01f, 1.18414938e-01f, 1.91737443e-01f, -1.82337269e-01f, -1.17704391e-01f, 1.56284481e-01f, -1.59294643e-02f, 1.09912567e-01f, -2.86646485e-02f,
  -4.46634274e-03f, -4.50827330e-02f, -1.04557492e-01f, -6.97940309e-03f, 7.98173100e-02f, -7.96674788e-02f, 2.66148478e-01f, -2.21152827e-01f, 1.66003972e-01f, 1.62940115e-01f,
  -2.32070565e-01f, -2.11181883e-02f, -1.19060755e-01f, -1.11341372e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  6.38363436e-02f, -5.05585410e-02f, 5.24828993e-02f, -1.38543800e-01f, -1.61449149e-01f, -1.74805492e-01f, 6.52350858e-02f, -1.15015052e-01f, -8.31254125e-02f, -1.19388402e-02f,
  -1.18727781e-01f, -4.95357364e-02f, 9.44505632e-02f, -1.14361152e-01f, 5.28125353e-02f, 2.96682846e-02f, -5.38435169e-02f, -2.85106719e-01f, 2.45475732e-02f, -1.36887431e-01f,
  -1.00526147e-01f, 1.96058244e-01f, -1.35039508e-01f, -4.89365272e-02f, 9.34830308e-03f, 1.11231066e-01f, -8.53380188e-02f, -3.16010229e-03f, 6.86976090e-02f, 2.40249649e-01f,
  -4.42478321e-02f, -1.23924673e-01f, -1.60833582e-01f, -5.73248751e-02f, -1.30181730e-01f, 1.37970731e-01f, 1.32079870e-01f, 1.87678814e-01f, 1.38988942e-01f, 1.47456929e-01f,
  1.79848939e-01f, -1.74797520e-01f, -1.32752761e-01f, -8.68265852e-02f, -2.53557339e-02f, 1.58503652e-01f, 1.07001193e-01f, -6.02650605e-02f, 1.89191148e-01f, 3.04518402e-01f,
  -1.08278878e-01f, -8.36177319e-02f, -3.56938643e-03f, 1.42391801e-01f, -1.53819412e-01f, 1.34541288e-01f, -1.16314210e-01f, 1.52371125e-02f, 1.10084400e-01f, -1.17548563e-01f,
  -3.94232310e-02f, 8.28366429e-02f, -1.32635683e-01f, 6.99889585e-02f, 7.25356191e-02f, -7.08652660e-02f, -5.77293932e-02f, 1.14414349e-01f, 1.56990975e-01f, 1.59562483e-01f,
  -2.87268944e-02f, -6.19479939e-02f, 1.05051503e-01f, 8.46502557e-02f, 8.79025310e-02f, -1.94750577e-02f, 7.75589421e-02f, -7.94329494e-02f, -2.78765149e-02f, 4.16059308e-02f,
  -6.58642175e-03f, -1.18039653e-01f, 1.42996952e-01f, 2.50634551e-01f, 1.75937817e-01f, 8.40527937e-02f, -4.39505950e-02f, -5.62581271e-02f, 4.52793092e-02f, 2.01231703e-01f,
  5.12855232e-01f, 3.44768226e-01f, -2.94859055e-02f, 6.14879616e-02f, 2.30828822e-01f, -9.11491513e-02f, 7.36533478e-02f, -1.27958611e-01f, -8.56170245e-03f, 2.12426767e-01f,
  1.24298625e-01f, 2.56658476e-02f, -7.90594593e-02f, -1.74555570e-01f, -1.46937966e-01f, -2.69038603e-02f, 2.77900487e-01f, 2.45792389e-01f, 1.11545632e-02f, 8.00153688e-02f,
  3.41571984e-04f, -2.10199133e-02f, 2.09526613e-01f, 2.18889683e-01f, 1.08962104e-01f, -1.59036413e-01f, -2.80245960e-01f, 3.84632111e-01f, -1.12300053e-01f, 5.91899753e-02f,
  3.37634921e-01f, 1.55864567e-01f, 1.27966618e-02f, -1.07491083e-01f, -4.12690192e-02f, 3.08350101e-02f, 3.10800016e-01f, 1.74464583e-01f, -4.21240553e-02f, -6.63968697e-02f,
  6.82809018e-03f, -1.21874526e-01f, -7.77323497e-04f, -7.85276517e-02f, 7.15141371e-02f, 2.35642463e-01f, 1.43227980e-01f, 7.71388561e-02f, -8.46178457e-02f, -3.00956994e-01f,
  7.01546744e-02f, -5.19093461e-02f, -1.42173581e-02f, -4.71582077e-02f, 1.00087896e-02f, 3.64136770e-02f, 6.75776526e-02f, 2.57839859e-01f, -1.09241396e-01f, -3.85577261e-01f,
  1.77893415e-01f, -2.35927291e-02f, 2.01891121e-02f, -2.80463517e-01f, 2.51895100e-01f, -5.50929364e-03f, -5.26049137e-02f, -2.22546801e-01f, -6.15112074e-02f, -3.04307044e-02f,
  2.08641127e-01f, 2.06776276e-01f, 4.25725505e-02f, -2.07375493e-02f, 5.82217313e-02f, -6.90689832e-02f, -1.60806384e-02f, 1.94038287e-01f, 8.93315151e-02f, 2.35492513e-02f,
  -7.23614097e-02f, 1.54155448e-01f, -5.00030257e-02f, -8.95740315e-02f, 5.86601682e-02f, 8.10556263e-02f, 1.30125806e-01f, -7.16982186e-02f, -5.54689281e-02f, 4.64333501e-03f,
  5.76650724e-02f, -3.22992057e-02f, -2.84517080e-01f, -6.83460087e-02f, 1.29795492e-01f, -2.14203391e-02f, 1.36977911e-01f, 3.38108391e-01f, -1.36473228e-03f, -5.82885593e-02f,
  1.12154931e-01f, -1.39235944e-01f, 3.36379814e-03f, 3.24762553e-01f, -2.09999830e-02f, 9.04074162e-02f, -1.17194196e-02f, -4.64918613e-02f, -4.25524823e-03f, 9.91711318e-02f,
  1.10931352e-01f, 2.99573187e-02f, 9.40881446e-02f, 3.74233156e-01f, 3.99431996e-02f, -7.00510219e-02f, -1.31547943e-01f, -8.43432322e-02f, -7.36458525e-02f, 5.31085953e-02f,
  -1.89330786e-01f, -2.30555758e-02f, -8.02519321e-02f, 4.29078877e-01f, -1.29213437e-01f, 5.45924855e-03f, -1.30531445e-01f, -2.86624543e-02f, 2.01214477e-01f, 3.07448745e-01f,
  1.75589308e-01f, -8.50857049e-02f, 4.29751165e-02f, -5.02211452e-02f, -6.56012669e-02f, -9.88292098e-02f, 2.15451807e-01f, -1.65809199e-01f, -7.70667642e-02f, 2.59984910e-01f,
  -1.01437373e-02f, 3.46096754e-02f, 2.17767432e-01f, -3.02033454e-01f, 7.60178566e-02f, 3.23142596e-02f, 1.02219589e-01f, 3.07510525e-01f, -2.15158500e-02f, -1.66344628e-01f,
  1.11610919e-01f, 3.28588217e-01f, -1.61980987e-01f, -1.88281629e-02f, 3.28196079e-01f, 1.71043336e-01f, 1.77549630e-01f, 2.22905278e-01f, 3.09249103e-01f, -1.30192131e-01f,
  9.26823393e-02f, -5.77068180e-02f, -1.61635533e-01f, -1.16914079e-01f, -1.41398519e-01f, 5.63781941e-03f, 3.89078446e-02f, -3.34602222e-02f, -7.71565959e-02f, 6.22283518e-02f,
  -1.20566450e-01f, -1.09793898e-02f, 6.54971674e-02f, -3.00858498e-01f, 1.17838033e-01f, -1.60738215e-01f, -1.79195598e-01f, -5.91306053e-02f, 2.06144691e-01f, 3.19178730e-01f,
  -1.33167371e-01f, -1.40839666e-01f, -1.55494347e-01f, -1.18111193e-01f, 1.99474171e-01f, -4.57749814e-02f, -7.54923895e-02f, 4.12046611e-02f, 2.75039524e-01f, -1.37622543e-02f,
  -1.68040410e-01f, 3.33238505e-02f, 1.06963202e-01f, 2.47464832e-02f, 2.53261887e-02f, 1.16918765e-01f, 2.87350804e-01f, 1.91982426e-02f, 1.75932765e-01f, 1.39713332e-01f,
  -1.48885146e-01f, -4.74313321e-03f, 9.93193164e-02f, -1.72879517e-01f, -2.36469135e-02f, 2.89528728e-01f, 2.99577452e-02f, -8.55174474e-03f, 2.79019684e-01f, 1.82226837e-01f,
  -8.14311355e-02f, -8.78301263e-02f, -1.52042225e-01f, 1.64266035e-01f, 7.75856450e-02f, 1.04605950e-01f, -8.66802335e-02f, 1.39011264e-01f, 1.33656070e-01f, -7.74516314e-02f,
  -8.85328650e-02f, 7.93500338e-03f, -1.51892856e-01f, 1.40115142e-01f, 2.14615509e-01f, 1.61305800e-01f, -3.75553370e-02f, -9.34016705e-02f, -4.17281576e-02f, -9.59661976e-02f,
  -4.97556292e-02f, -9.58803743e-02f, 2.37693209e-02f, 1.11866571e-01f, 3.31064761e-02f, -1.13090277e-01f, -8.66419226e-02f, -1.10772699e-01f, 7.89565891e-02f, -4.82615493e-02f,
  -6.03604950e-02f, 5.56445643e-02f, 2.51635492e-01f, 1.77268032e-02f, -1.08280726e-01f, -3.72503251e-02f, -6.57057166e-02f, -1.72462836e-01f, 1.66653574e-01f, -4.09452692e-02f,
  3.62893902e-02f, -8.00382420e-02f, 1.75162837e-01f, -1.19421436e-02f, -7.64425248e-02f, -1.44465253e-01f, 1.70052320e-01f, 1.14912450e-01f, -1.04326822e-01f, 2.13273719e-01f,
  2.28034705e-01f, 6.57833368e-02f, -3.61438282e-02f, 1.51605308e-01f, 8.99275318e-02f, -1.96390256e-01f, -8.76237974e-02f, 1.03334039e-01f, -1.02303542e-01f, -1.76756769e-01f,
  -1.22292124e-01f, 2.18232535e-03f, 9.08337235e-02f, 6.29537851e-02f, -2.40124539e-02f, -1.36663064e-01f, 1.00206837e-01f, -3.94461565e-02f, 7.77050480e-03f, 1.54001996e-01f,
  1.86051518e-01f, -9.17599946e-02f, -1.19850021e-02f, 2.75547773e-01f, 4.51050550e-02f, -6.39342293e-02f, 4.13697436e-02f, 2.49666408e-01f, -1.38328761e-01f, -5.30759506e-02f,
  1.46503076e-01f, 3.71453054e-02f, 1.48850292e-01f, -7.55945146e-02f, -1.32587641e-01f, -4.03491370e-02f, 6.45700172e-02f, -1.66765243e-01f, -5.07551245e-02f, 8.41939673e-02f,
  -5.73281310e-02f, 1.93576626e-02f, 1.42329820e-02f, 2.10553423e-01f, 1.26315251e-01f, 1.57454088e-01f, -3.12587887e-04f, 5.16208028e-03f, 1.40817076e-01f, -1.75251231e-01f,
  2.39979452e-03f, 1.06854439e-01f, -3.30915228e-02f, -1.13235191e-01f, -1.45767629e-01f, -2.17626262e-02f, -5.35524404e-03f, -1.21281318e-01f, -8.49635899e-02f, 2.06908658e-02f,
  -7.22989859e-03f, 1.43492129e-02f, -1.58679321e-01f, -5.02119547e-05f, 9.19273298e-04f, 1.66323828e-03f, -6.77283504e-04f, 1.42976306e-02f, -3.07443380e-01f, 4.89299223e-02f,
  1.68767720e-02f, -4.74951863e-02f, -4.01148908e-02f, -3.78103927e-02f, 2.09181294e-01f, -2.89182812e-02f, 1.28470836e-02f, 2.95985024e-03f, -2.03681618e-01f, -2.68029552e-02f,
  1.85925812e-01f, 2.86317505e-02f, -5.63248135e-02f, -5.05178655e-03f, 7.46276304e-02f, -3.04351091e-01f, -1.77871436e-01f, -1.60110090e-02f, -2.35919431e-02f, -1.06706088e-02f,
  -8.55698586e-02f, -4.94425278e-03f, -1.97496428e-03f, 7.05768354e-04f, -2.16259179e-03f, 6.51113763e-02f, 1.08547686e-02f, -3.56885940e-02f, 1.59560323e-01f, -3.15016098e-02f,
  2.16074005e-01f, -1.35844946e-01f, -3.86393517e-02f, -3.12453993e-02f, -7.74292052e-02f, 1.59777656e-01f, -7.09440187e-02f, -9.98632461e-02f, 1.12647831e-01f, -1.33456485e-02f,
  -7.36719519e-02f, 1.55563772e-01f, -1.38439536e-01f, 1.68636050e-02f, 3.60808447e-02f, -8.44439492e-02f, 2.30368242e-01f, 7.89014995e-02f, -2.20071211e-01f, 2.49442220e-01f,
  1.24683447e-01f, -1.06160246e-01f, -7.60330185e-02f, 1.11469857e-01f, 2.57197648e-01f, 8.49812776e-02f, 1.41876429e-01f, -1.40380666e-01f, 1.30514819e-02f, -1.16927959e-01f,
  1.74034089e-01f, 2.01808512e-02f, -1.06934207e-02f, 1.28887832e-01f, 7.48165771e-02f, -1.18524984e-01f, 1.52554750e-01f, 2.66248792e-01f, 1.03148133e-01f, -1.51302265e-02f,
  -6.85105845e-02f, 1.90556780e-01f, -1.27685651e-01f, 1.30989954e-01f, 1.70748889e-01f, 3.76561061e-02f, 1.95885450e-01f, 4.99234535e-02f, 1.15891686e-02f, -7.86357149e-02f,
  -1.48449019e-01f, 1.54518783e-01f, -7.02799186e-02f, -2.21091323e-02f, 3.08201373e-01f, -2.52557136e-02f, 2.27760762e-01f, 9.78404656e-02f, -1.07604563e-01f, -1.79428980e-01f,
  1.37746111e-01f, -4.25171591e-02f, 3.86915938e-03f, 1.51047081e-01f, 6.67589083e-02f, 3.29772867e-02f, 4.56247926e-02f, -2.01288983e-02f, -1.39979854e-01f, -1.31803036e-01f,
  9.63444561e-02f, 5.60232624e-02f, 8.29652846e-02f, 2.21102700e-01f, 2.77068857e-02f, 2.30999812e-01f, 7.72054791e-02f, -1.20312259e-01f, -8.11062902e-02f, 1.02517985e-01f,
  -6.50878921e-02f, -4.91078012e-02f, -5.48602641e-02f, 2.03737408e-01f, 2.51598567e-01f, 1.64418146e-01f, -5.30865304e-02f, -1.05620474e-01f, -4.07133624e-02f, 6.34720623e-02f,
  1.54310822e-01f, -1.91205561e-01f, -2.22279411e-02f, -1.74200624e-01f, 4.52301688e-02f, -3.64989974e-02f, -1.39175234e-02f, -1.47516048e-02f, -2.84055602e-02f, 1.74040109e-01f,
  9.69120264e-02f, 3.11704259e-02f, 3.98298770e-01f, -5.18315099e-02f, -1.62858833e-02f, 3.81422862e-02f, -1.68791920e-01f, 2.41594091e-02f, -8.24059397e-02f, 1.94978923e-01f,
  -1.24606617e-01f, -1.41346054e-02f, -3.51622254e-02f, -1.18571140e-01f, 3.21758628e-01f, -2.40923673e-01f, 9.30149704e-02f, 1.07220765e-02f, 1.02221102e-01f, -1.76659953e-02f,
  -3.87126282e-02f, 1.75292999e-01f, -6.16187677e-02f, 6.44517913e-02f, -1.45762786e-01f, -1.43107846e-01f, 1.00029610e-01f, 9.03292671e-02f, 4.85306047e-02f, 2.23075554e-01f,
  1.28070787e-01f, 1.03581473e-01f, 1.68972552e-01f, -5.59676997e-02f, 4.74070199e-02f, 3.50493286e-03f, 1.38070881e-01f, -2.53157248e-03f, 5.32972105e-02f, 2.77324137e-03f,
  8.98363590e-02f, -2.07049064e-02f, 1.65076315e-01f, 3.24053824e-01f, 3.94700002e-03f, 1.05934292e-01f, 2.98526525e-01f, -2.95326740e-01f, 2.78616369e-01f, 2.65695341e-02f,
  1.30488262e-01f, -2.13691935e-01f, -2.48172998e-01f, -1.77761465e-01f, 1.97797250e-02f, -7.75538161e-02f, 1.52857497e-01f, 2.11544260e-01f, 1.57569289e-01f, 1.05359927e-01f,
  -2.45520864e-02f, -7.65472604e-03f, 1.63687184e-01f, -7.00181723e-02f, -1.39109030e-01f, 7.41019621e-02f, -6.04727194e-02f, 3.88327956e-01f, -3.26090492e-02f, 4.65443023e-02f,
  8.32884759e-02f, 4.39173505e-02f, -9.06461384e-03f, 2.58762807e-01f, -6.50136247e-02f, -2.35219613e-01f, 1.16837718e-01f, 4.69336472e-02f, 1.14982232e-01f, -1.02067754e-01f,
  3.47279519e-01f, 9.49454755e-02f, -2.03686252e-01f, 2.74203956e-01f, -3.30130197e-02f, 7.03451112e-02f, 3.84586394e-01f, 1.42387852e-01f, 3.02978642e-02f, 1.00310706e-01f,
  9.70294774e-02f, 8.02288651e-02f, 1.84714831e-02f, -2.34017503e-02f, 1.58812016e-01f, 1.28634214e-01f, -8.79300013e-02f, 7.99284801e-02f, 1.03232197e-01f, -6.98991641e-02f,
  3.40984166e-02f, -1.19959647e-02f, 2.11750902e-02f, 1.01856858e-01f, -1.35584071e-01f, -4.43530679e-02f, 3.81013721e-01f, 1.66979387e-01f, 1.70979962e-01f, 6.64784163e-02f,
  3.85999531e-01f, 1.07426822e-01f, -1.46715358e-01f, 7.84742460e-02f, 7.51186907e-02f, 2.61781275e-01f, 2.78475761e-01f, -7.91611299e-02f, 9.34417769e-02f, 1.08623365e-02f,
  -4.61914688e-02f, 2.83282280e-01f, -2.14208871e-01f, -1.36135489e-01f, 8.42871666e-02f, 2.00852320e-01f, 1.41386390e-01f, 2.52093703e-01f, 6.76774606e-02f, -6.47102073e-02f,
  -8.27072337e-02f, 3.86642158e-01f, 1.86159253e-01f, 2.81138659e-01f, 2.48258468e-02f, 2.61742234e-01f, -9.98031646e-02f, -1.24107689e-01f, -7.75462165e-02f, -9.75577682e-02f,
  -2.90328134e-02f, 1.00764055e-02f, -2.73274556e-02f, 1.36138886e-01f, -1.01637952e-01f, -2.10375756e-01f, 2.29486711e-02f, -8.98507796e-03f, 1.90089494e-01f, -3.95375229e-02f,
  1.40943512e-01f, -5.27229020e-03f, 3.39109331e-01f, 2.09271982e-01f, 7.14164823e-02f, 1.15889847e-01f, 1.97094634e-01f, 2.66280144e-01f, 2.37702623e-01f, 2.24483341e-01f,
  -2.80478019e-02f, -1.30960941e-01f, 1.17836580e-01f, 5.03417477e-02f, 2.41737336e-01f, 1.95187643e-01f, 6.22532666e-02f, 4.83592078e-02f, 4.42771278e-02f, 4.76658903e-02f,
  8.84725899e-02f, -3.22695374e-02f, -1.99918151e-01f, -3.35140973e-01f, 1.92446396e-01f, 2.77369261e-01f, 1.87601730e-01f, 6.91000745e-02f, 8.71246681e-02f, -5.14169931e-02f,
  -2.65597939e-01f, 1.13727272e-01f, -2.66389921e-02f, 1.70469642e-01f, -2.47887112e-02f, 1.04820669e-01f, 3.94985229e-02f, 5.34832701e-02f, 2.49315172e-01f, 5.78375440e-03f,
  1.99574515e-01f, -3.79162461e-01f, 9.32748169e-02f, -1.53982099e-02f, -5.45947030e-02f, 1.81186959e-01f, -2.69446149e-02f, -1.38824747e-03f, 1.39843315e-01f, -2.35795081e-01f,
  -1.97773706e-03f, 5.13458475e-02f, -1.03770047e-01f, -2.19613254e-01f, -2.08127931e-01f, 5.44193909e-02f, 4.28020433e-02f, -3.83113772e-02f, 5.31945705e-01f, 1.12705439e-01f,
  1.51329696e-01f, 1.22671358e-01f, -2.81245023e-01f, -9.13988054e-02f, 1.70517012e-01f, 5.32844625e-02f, -7.28715584e-02f, -6.29515126e-02f, -3.49875465e-02f, 1.33058980e-01f,
  9.90099981e-02f, -8.25585518e-03f, 5.40478937e-02f, 2.64838766e-02f, -3.39656807e-02f, 1.11935169e-01f, -3.04481629e-02f, 1.82425082e-01f, 2.42064878e-01f, 1.54413700e-01f,
  -3.77138965e-02f, -2.98621878e-02f, 1.66420653e-01f, 2.67219812e-01f, -6.41372278e-02f, 1.47456616e-01f, -1.74148008e-01f, 1.10975169e-01f, 4.55695949e-02f, -1.93061948e-01f,
  -4.50765416e-02f, -3.61381844e-02f, 1.33967593e-01f, -3.81628387e-02f, -1.07636414e-01f, -6.89307749e-02f, -1.79541633e-01f, 3.80724482e-02f, 1.40945856e-02f, -8.16262066e-02f,
  1.91604078e-01f, 1.76906377e-01f, -1.12587914e-01f, 7.59898871e-02f, 1.86571673e-01f, -2.14745656e-01f, 2.04709843e-02f, 9.83250216e-02f, -2.18056247e-01f, -6.00545220e-02f,
  -2.71139026e-01f, -2.48065338e-01f, 6.06591143e-02f, -1.46437749e-01f, -1.42885163e-01f, 2.59944886e-01f, -6.00240268e-02f, -1.09515883e-01f, -3.98540758e-02f, 2.07776845e-01f,
  4.88093160e-02f, -1.00317886e-02f, 1.46500781e-01f, -9.44452584e-02f, -2.48529427e-02f, -8.47839564e-02f, -1.47475764e-01f, -4.09268253e-02f, -2.78701279e-02f, 8.28080028e-02f,
  -1.23071700e-01f, -1.11518633e-02f, 3.72982025e-02f, 1.17147334e-01f, 4.46301233e-03f, -3.43353562e-02f, 1.77078590e-01f, 4.32946347e-02f, 3.94617617e-02f, -2.47430235e-01f,
  1.46169528e-01f, -1.70079246e-02f, -1.11456238e-01f, 7.50598684e-02f, 1.40811294e-01f, 3.77203822e-01f, -2.80631613e-03f, -9.12424773e-02f, 1.16448782e-01f, -2.22234741e-01f,
  2.67305255e-01f, 2.31577948e-01f, -1.28275111e-01f, -1.60955548e-01f, 3.59956980e-01f, 1.47677496e-01f, -2.12014522e-02f, -2.02258322e-02f, 2.59004743e-03f, -1.02911822e-01f,
  -3.00744977e-02f, -9.75741446e-02f, 8.05396289e-02f, 5.91832586e-02f, 6.82048947e-02f, 1.33318365e-01f, -2.27604404e-01f, -1.09391958e-01f, 4.04093228e-02f, -1.03168465e-01f,
  -9.56240147e-02f, 1.83209106e-01f, 2.23470077e-01f, 9.85624194e-02f, 2.84162104e-01f, 3.06202620e-01f, -1.61148414e-01f, -2.01701790e-01f, -1.14083759e-01f, 6.09234720e-02f,
  -9.37848613e-02f, -1.62134916e-01f, -9.69465449e-02f, 7.26399827e-04f, 7.88952783e-02f, -1.79392189e-01f, 5.80478236e-02f, -6.89171031e-02f, 4.40286137e-02f, 4.04986218e-02f,
  2.61073440e-01f, 2.78788030e-01f, -5.85289113e-02f, -1.78982466e-01f, 3.84101532e-02f, -1.31987661e-01f, 1.62036553e-01f, -4.00156453e-02f, -4.27230448e-02f, 2.06086665e-01f,
  1.26615450e-01f, 1.38946369e-01f, 2.25671992e-01f, -3.32314730e-01f, 1.44714430e-01f, 4.12771255e-02f, 1.34681873e-02f, 2.37124696e-01f, 2.13022754e-01f, 1.18026815e-01f,
  -9.97149721e-02f, -1.12890989e-01f, -1.60285383e-01f, -1.31346032e-01f, -2.91797012e-01f, -2.42292628e-01f, -5.95488846e-02f, -4.56242785e-02f, 3.69390666e-01f, 1.32298488e-02f,
  -1.56007603e-01f, 8.64019021e-02f, 6.07853942e-02f, 1.20478578e-01f, -1.91428675e-03f, 2.44225010e-01f, 3.70829910e-01f, -1.92012992e-02f, 2.00168058e-01f, -2.92187724e-02f,
  2.38353647e-02f, -3.28238517e-01f, -1.68768615e-01f, 1.77979812e-01f, -3.87509130e-02f, 1.33202195e-01f, 5.56925219e-03f, -1.69503391e-01f, 2.02957168e-01f, -7.04351217e-02f,
  1.13182589e-01f, -1.49677947e-01f, -1.20393999e-01f, 6.84188381e-02f, -5.40716480e-03f, 2.32340246e-01f, 9.80511531e-02f, -1.88192666e-01f, 1.19346932e-01f, 1.81642875e-01f,
  1.56697065e-01f, 4.56408888e-01f, -7.40267290e-03f, 5.18507138e-02f, -1.00923792e-01f, -1.08018763e-01f, 2.91444361e-02f, 6.95911646e-02f, -6.76271096e-02f, -8.53438526e-02f,
  -9.29671451e-02f, 1.27658680e-01f, 1.93060748e-02f, 6.98769465e-02f, 3.77500639e-03f, -1.42806536e-02f, 3.41163091e-02f, 1.68029919e-01f, -1.57867730e-01f, 1.06219478e-01f,
  9.99680087e-02f, 5.42375073e-02f, 4.84045073e-02f, -6.04227781e-02f, -3.71956117e-02f, 2.51654565e-01f, -9.24269557e-02f, 6.69332296e-02f, -1.28174946e-01f, 2.08238408e-01f,
  -7.37775341e-02f, -1.04983963e-01f, -1.97336078e-01f, 1.57006472e-01f, 6.66807666e-02f, 1.14062071e-01f, -7.10346252e-02f, -5.90407290e-02f, 1.41620442e-01f, -2.23111451e-01f,
  3.20633054e-02f, -1.86822817e-01f, 6.58677518e-02f, 2.14016855e-01f, 1.47237226e-01f, -5.82610928e-02f, 2.79504675e-02f, 3.55645150e-01f, 2.82883178e-02f, -2.12269686e-02f,
  -3.88897583e-02f, -2.23599821e-01f, -3.27144086e-01f, -2.36539841e-01f, 2.64379025e-01f, 1.54056028e-01f, -1.06558658e-01f, -1.31682931e-02f, 2.42888525e-01f, 1.56638846e-01f,
  -3.33755016e-02f, 2.66625464e-01f, 2.99096048e-01f, -1.08150039e-02f, -7.44396076e-02f, 1.65572137e-01f, -1.80371091e-01f, -9.98458564e-02f, 2.07079947e-02f, 2.98719155e-03f,
  -1.91575155e-01f, -4.80837971e-02f, -2.46825024e-01f, 1.78509295e-01f, 5.54807968e-02f, 1.98249370e-01f, 1.95438579e-01f, 1.32112026e-01f, 2.62803406e-01f, 1.34999320e-01f,
  -1.23134099e-01f, 1.03545971e-01f, -3.05417106e-02f, 2.67010868e-01f, 1.59308404e-01f, -1.08384015e-02f, -1.57953411e-01f, 1.55246228e-01f, -8.21219012e-02f, 9.50736925e-02f,
  1.40027449e-01f, 1.62607238e-01f, -3.34973224e-02f, 2.05170035e-01f, 1.56752810e-01f, -9.06357989e-02f, 3.31355142e-03f, 1.65355191e-01f, 1.85695738e-02f, -1.79308251e-01f,
  -1.06093921e-01f, -4.15809602e-02f, 1.52435556e-01f, -1.50893748e-01f, -6.73444718e-02f, 1.34771630e-01f, 2.12208405e-01f, 1.00417770e-01f, 1.24744168e-02f, -1.23971142e-02f,
  -2.40094867e-02f, 1.14861041e-01f, 2.44264398e-02f, -2.21569426e-02f, 9.22332257e-02f, 1.21412858e-01f, -1.02000207e-01f, 2.53006555e-02f, 3.74699906e-02f, 1.05500054e-02f,
  1.92144625e-02f, 1.06238365e-01f, -1.65489078e-01f, -9.64737833e-02f, -1.01899087e-01f, 2.91347623e-01f, 1.40629306e-01f, -1.44200504e-01f, 1.94475248e-01f, -8.29237178e-02f,
  4.85801883e-02f, -1.07139044e-01f, -5.52390423e-03f, 8.64949748e-02f, 1.23631001e-01f, -2.06636619e-02f, -1.06712416e-01f, 1.04246087e-01f, 1.30768791e-01f, 4.53790799e-02f,
  4.40679826e-02f, 1.77682072e-01f, 1.29271597e-01f, 8.25016666e-03f, -6.11782745e-02f, 2.13754535e-01f, -1.70671985e-01f, -5.44329286e-02f, 1.40118867e-01f, -9.78965163e-02f,
  -9.95863080e-02f, -7.40563199e-02f, -6.23784363e-02f, 6.82236776e-02f, 9.73860323e-02f, 3.06065291e-01f, -3.13258059e-02f, 1.98264390e-01f, 1.83684483e-01f, 1.74060948e-02f,
  -1.11903757e-01f, 7.14900494e-02f, 1.86347850e-02f, -2.01975837e-01f, 2.29260270e-02f, -1.94003403e-01f, 7.28221834e-02f, -6.82197362e-02f, -1.54842868e-01f, 2.30965652e-02f,
  1.36744738e-01f, 2.68478394e-01f, -4.94144894e-02f, 1.74376264e-01f, -1.65036060e-02f, 3.22552413e-01f, -6.70619234e-02f, 9.51436237e-02f, 2.27005914e-01f, 2.74751902e-01f,
  -2.20868900e-01f, -2.04609320e-01f, 1.43714726e-01f, 2.72376299e-01f, -2.44685765e-02f, 7.01304972e-02f, 2.26257686e-02f, -3.56890671e-02f, -5.02361394e-02f, 1.12204462e-01f,
  1.03366055e-01f, 8.22643861e-02f, -3.39555889e-01f, -8.53627622e-02f, -8.63175318e-02f, -5.71790673e-02f, 4.63798549e-03f, 2.09221512e-01f, 1.58830304e-02f, -1.83484167e-01f,
  1.19748740e-02f, 2.48880416e-01f, 1.39824152e-01f, 1.30734652e-01f, 7.05214590e-02f, 1.26312166e-01f, 6.64695650e-02f, 9.34378132e-02f, -9.41755250e-02f, 1.35592088e-01f,
  -1.27937987e-01f, -1.53843001e-01f, -5.64872101e-02f, -1.72357503e-02f, -2.38820106e-01f, -1.06195703e-01f, 8.25750008e-02f, -5.70463464e-02f, 2.06556767e-01f, -2.63600294e-02f,
  1.56748712e-01f, -2.72334795e-02f, 5.91468960e-02f, 3.65083098e-01f, -1.59404933e-01f, 7.80312270e-02f, 3.00040543e-02f, 1.88055262e-01f, 1.49094447e-01f, 3.09461411e-02f,
  1.98721021e-01f, -3.95487575e-03f, -2.30242759e-01f, -5.28188720e-02f, -1.89733356e-01f, 1.06343970e-01f, 1.37627162e-02f, 2.42462993e-01f, 1.02742456e-01f, 2.55484819e-01f,
  1.77272901e-01f, 8.09938312e-02f, 2.45041847e-01f, 1.76193878e-01f, -5.31116053e-02f, 1.56204790e-01f, -1.36147752e-01f, 3.95425290e-01f, 4.04734872e-02f, -1.35062009e-01f,
  2.42029056e-01f, 1.22392491e-01f, -1.00801229e-01f, -1.19158894e-01f, -1.35684283e-02f, 8.46244246e-02f, -7.05295056e-02f, 1.60692900e-01f, 1.00598611e-01f, -1.98697522e-01f,
  2.18443543e-01f, -1.06308870e-01f, -1.08969644e-01f, 1.30835623e-02f, 9.87018049e-02f, 1.19219117e-01f, 9.00744498e-02f, 7.85408020e-02f, 8.51859897e-02f, 1.47746176e-01f,
  5.82415983e-02f, -1.16262473e-01f, 8.41459036e-02f, -7.00297058e-02f, 1.06801055e-01f, 7.64518902e-02f, -1.48475934e-02f, 1.25190675e-01f, 1.11571118e-01f, 2.70785660e-01f,
  -4.01241593e-02f, -1.67399511e-01f, -3.06802779e-01f, -1.07368872e-01f, 4.87397201e-02f, 4.52581607e-02f, -2.26410583e-01f, 9.04182717e-02f, 3.03524941e-01f, -3.03391390e-03f,
  1.07169986e-01f, -1.38633654e-01f, 2.21793249e-01f, 1.57803297e-01f, -1.45580182e-02f, 1.23111248e-01f, 3.00396442e-01f, -1.47428229e-01f, 2.09841490e-01f, 9.73418429e-02f,
  3.87634337e-02f, -6.37117624e-02f, -1.26057252e-01f, 8.14166069e-02f, -2.65094727e-01f, 2.43668497e-01f, 9.81798861e-03f, -2.71709949e-01f, -3.36321443e-02f, 1.32176490e-03f,
  1.19280264e-01f, -1.16185457e-01f, 1.06906749e-01f, 2.99034983e-01f, 1.56816304e-01f, 1.86913475e-01f, 9.89771411e-02f, 2.27658134e-02f, 6.94607794e-02f, 1.89575642e-01f,
  2.47727245e-01f, 3.42140913e-01f, 2.91294903e-01f, 6.57956675e-02f, 6.27555093e-03f, 8.83700401e-02f, -9.23340768e-02f, -1.13441207e-01f, -1.52140677e-01f, 1.22870598e-02f,
  5.67697808e-02f, 1.31862611e-01f, 1.38097674e-01f, 6.10037893e-02f, -8.71434622e-03f, 7.55250752e-02f, -1.76459238e-01f, 1.30773842e-01f, -1.96388960e-01f, -2.03793477e-02f,
  4.02501289e-04f, -9.70259979e-02f, -8.07329919e-03f, 2.34850552e-02f, 1.62357777e-01f, 1.51082933e-01f, -5.51492721e-02f, -9.18321963e-03f, 1.33260906e-01f, 1.77398622e-01f,
  -1.13650169e-02f, -1.94733173e-01f, -1.05841443e-01f, -8.08651149e-02f, 1.49956554e-01f, 4.13034782e-02f, -4.40196283e-02f, 6.37672693e-02f, -1.35864854e-01f, -8.78280401e-02f,
  -2.18982305e-02f, -4.62395027e-02f, 1.88135475e-01f, 9.10397023e-02f, -1.11629598e-01f, 1.49271518e-01f, 2.05029830e-01f, -2.83836592e-02f, -3.41363661e-02f, 7.18207061e-02f,
  -1.17635012e-01f, -1.55701846e-01f, -1.77122027e-01f, -1.23970978e-01f, 8.96445960e-02f, -1.18050553e-01f, -2.08525360e-01f, 3.19969922e-01f, 1.12866059e-01f, 1.99996233e-02f,
  -1.72981933e-01f, 2.99164712e-01f, 1.12332031e-02f, -3.73737849e-02f, 4.09421884e-03f, 1.90978758e-02f, 9.24434513e-02f, -5.48885278e-02f, 6.01901934e-02f, 1.11740567e-01f,
  1.29098007e-02f, 5.54818772e-02f, -9.49922279e-02f, 8.36136416e-02f, 2.25406989e-01f, 1.45606235e-01f, 2.14342847e-01f, 1.15047134e-02f, 2.41923764e-01f, -3.22123058e-02f,
  -1.20370649e-01f, 1.09134734e-01f, 5.58298975e-02f, -1.82016134e-01f, -1.58499226e-01f, -1.20491818e-01f, -3.12336050e-02f, 1.37008518e-01f, -6.28375486e-02f, 1.46601722e-02f,
  2.19280973e-01f, -8.95221010e-02f, 1.88181698e-01f, 2.13336706e-01f, -3.21810469e-02f, 1.08406566e-01f, 9.06335637e-02f, -9.79996473e-02f, -1.52687475e-01f, -1.17991880e-01f,
  1.17837340e-01f, -1.74533278e-02f, -9.23123434e-02f, -2.30804637e-01f, -2.53414720e-01f, 1.02944113e-01f, 5.07076979e-02f, 8.01466480e-02f, -2.04543933e-01f, 9.56529900e-02f,
  -7.84496311e-03f, -1.94788098e-01f, 3.48864868e-02f, 3.22788328e-01f, 5.06686419e-02f, 2.35051170e-01f, 8.43631253e-02f, 1.39472723e-01f, -6.64351359e-02f, 2.24453822e-01f,
  3.78502440e-03f, 8.37386847e-02f, 1.43296853e-01f, -6.68052491e-03f, -1.01527236e-01f, 1.54316917e-01f, -6.32535890e-02f, 1.36772040e-02f, -1.73222750e-01f, -2.17824116e-01f,
  2.03420177e-01f, -1.91585675e-01f, 1.72082946e-01f, 3.28041136e-01f, -1.29711211e-01f, -2.91084915e-01f, 2.49730274e-01f, 2.88759857e-01f, 7.88916200e-02f, 2.66681295e-02f,
  6.16109669e-02f, 1.49925768e-01f, 1.51071697e-01f, 1.06538102e-01f, 1.67636991e-01f, 1.48349166e-01f, -1.46709502e-01f, 1.58512089e-02f, -4.94633503e-02f, 4.35322002e-02f,
  -9.48506370e-02f, -1.35589272e-01f, -1.11495361e-01f, -6.85745701e-02f, -3.17793004e-02f, -7.19762519e-02f, -8.27308670e-02f, 1.17018208e-01f, -3.00730877e-02f, 2.36458153e-01f,
  -5.61090708e-02f, -2.13336498e-02f, 3.88181210e-02f, 2.83098608e-01f, 3.01530927e-01f, 2.76890635e-01f, -4.56656292e-02f, 2.10888803e-01f, 8.95487517e-02f, -3.65804844e-02f,
  -8.34638104e-02f, -5.19725867e-02f, -7.89308399e-02f, 2.07762912e-01f, 1.58672384e-03f, 1.82488874e-01f, 3.36987488e-02f, -6.91504106e-02f, -2.79569417e-01f, -4.00897209e-03f,
  7.75876120e-02f, 1.44738376e-01f, 6.11548238e-02f, 2.69287050e-01f, -5.38734756e-02f, 3.63255627e-02f, 1.53526664e-01f, 1.40612558e-01f, 1.80635899e-01f, -4.50006351e-02f,
  -3.33518207e-01f, 1.48377225e-01f, -1.46782205e-01f, 2.65660048e-01f, 2.09184319e-01f, 8.83506536e-02f, 8.84715915e-02f, -1.63256198e-01f, -1.71319582e-03f, -6.72378764e-02f,
  8.35929215e-02f, 1.54445723e-01f, 1.45058736e-01f, -5.21718636e-02f, 3.75585221e-02f, 1.07239641e-01f, 1.02502052e-02f, 1.10472448e-01f, 4.25087027e-02f, -3.43792550e-02f,
  7.42732882e-02f, 1.97323598e-03f, -1.84862360e-01f, -1.75009355e-01f, 2.18080729e-02f, 2.65613139e-01f, -1.08618423e-01f, -1.29501134e-01f, -1.43615633e-01f, -1.09299012e-01f,
  2.15289712e-01f, 3.06582838e-01f, -1.87377036e-01f, -7.68812597e-02f, 2.38761902e-01f, 9.26328301e-02f, -2.69420035e-02f, -5.00926636e-02f, 3.31108332e-01f, -2.42849328e-02f,
  -4.53084894e-02f, 8.46066400e-02f, 1.39311358e-01f, 6.17721379e-02f, 1.77979767e-01f, 5.56607768e-02f, -1.42902955e-01f, 1.57724526e-02f, 1.23371653e-01f, 1.08345516e-01f,
  4.50343154e-02f, 1.61606476e-01f, -5.63823506e-02f, -1.76474825e-01f, 6.60679936e-02f, 1.81711987e-01f, 2.89417356e-02f, 1.68502443e-02f, 6.60359859e-02f, 1.67072162e-01f,
  2.31664449e-01f, 9.25125182e-02f, 8.43800530e-02f, 3.22987437e-02f, -1.04612380e-01f, 1.44817829e-01f, -6.01826236e-03f, 1.63476229e-01f, -3.13222706e-02f, 1.27639860e-01f,
  2.25818336e-01f, 2.41493564e-02f, -3.15491036e-02f, -1.08110651e-01f, -5.92457643e-03f, 1.39541447e-01f, 3.20440792e-02f, -1.87103059e-02f, 3.54507416e-02f, 8.07823334e-03f,
  2.75615364e-01f, 3.66286755e-01f, 5.72906099e-02f, 1.24219796e-02f, 9.31242183e-02f, 8.91098008e-02f, -1.43908784e-01f, 2.38121711e-02f, -1.87212564e-02f, -2.85375305e-02f,
  -1.52534112e-01f, 3.29251513e-02f, -1.48874581e-01f, 9.86879840e-02f, 2.69385297e-02f, 2.03382690e-02f, 9.15495157e-02f, 1.12548240e-01f, 8.78290385e-02f, 9.24890041e-02f,
  1.41316494e-02f, -4.42007706e-02f, 3.48074049e-01f, 3.48468602e-01f, 7.73018301e-02f, -6.24398626e-02f, 9.87566039e-02f, -1.29713535e-01f, 1.58855423e-01f, -1.52878746e-01f,
  1.38650015e-01f, -3.13202254e-02f, 3.98836322e-02f, 5.57505898e-02f, 4.88223173e-02f, 3.95244285e-02f, 1.33110106e-01f, -4.24199626e-02f, 1.30957931e-01f, 3.01936507e-01f,
  -3.17903459e-02f, 2.96724617e-01f, 7.04162493e-02f, -8.86130035e-02f, -1.24250196e-01f, -3.11124474e-02f, 1.29683152e-01f, -5.92362508e-02f, 2.57867239e-02f, 1.51367471e-01f,
  1.03838935e-01f, 3.96533124e-02f, 3.71233135e-01f, 1.01028077e-01f, 1.16147608e-01f, -4.12295610e-02f, -2.28083566e-01f, -1.54549062e-01f, 8.80814269e-02f, 1.39827222e-01f,
  -2.07201624e-03f, -4.99988571e-02f, 2.52510291e-02f, -6.86071143e-02f, 2.46646464e-01f, 2.61102200e-01f, -1.18899621e-01f, -1.05346382e-01f, 9.77579877e-02f, -4.85191345e-02f,
  7.28424266e-02f, 7.08075427e-03f, 2.29159594e-01f, 8.39193240e-02f, 4.43967525e-03f, -3.52602825e-02f, 1.34923905e-01f, -2.94457432e-02f, 8.00872818e-02f, -8.51676520e-03f,
  3.18856537e-01f, -1.21720724e-01f, 1.49465606e-01f, -5.62731884e-02f, 7.12341666e-02f, -1.02615923e-01f, 4.64370064e-02f, 4.86934334e-02f, -2.56909788e-01f, 2.29980469e-01f,
  8.32159966e-02f, 2.24648118e-01f, -7.09212571e-02f, 2.62752734e-02f, -2.72267144e-02f, 8.30016881e-02f, 2.85560131e-01f, 7.74675086e-02f, 4.80016433e-02f, -4.83084694e-02f,
  -1.88093811e-01f, 2.57361293e-01f, 1.33718982e-01f, 2.05259904e-01f, 8.55517834e-02f, -2.08750721e-02f, 1.65539488e-01f, -1.63084984e-01f, -1.37928069e-01f, -8.64802226e-02f,
  1.23251945e-01f, 1.17659263e-01f, -2.61991024e-01f, 6.78997710e-02f, -4.13855258e-03f, -2.29590699e-01f, -9.53369960e-02f, 2.07303956e-01f, -9.74835828e-02f, -9.58594158e-02f,
  2.26888925e-01f, -2.29079947e-02f, 2.99128026e-01f, 3.64348001e-04f, 4.43530902e-02f, -5.37801087e-02f, 8.62633530e-03f, 1.02971077e-01f, 1.28928453e-01f, -4.88710254e-02f,
  -1.28032044e-01f, 1.06879592e-01f, -5.55445515e-02f, 4.89086704e-03f, 2.45254301e-03f, -2.12699249e-01f, -1.11366585e-01f, 2.10770175e-01f, -8.91902670e-02f, 1.02016389e-01f,
  1.84490271e-02f, 4.93018515e-02f, 1.94031253e-01f, 2.21504509e-01f, -9.41395853e-03f, -1.23159930e-01f, 9.83027145e-02f, -7.18583632e-03f, 1.47398666e-01f, -1.41941756e-01f,
  -1.36310399e-01f, -2.38036454e-01f, -2.49768775e-02f, -2.01540127e-01f, -2.06824809e-01f, 5.46463728e-02f, 1.98861122e-01f, 2.28541285e-01f, -1.08222246e-01f, 1.05136655e-01f,
  -2.73717530e-02f, -1.67977750e-01f, -1.77074254e-01f, 7.99653903e-02f, -9.02433395e-02f, 4.15199250e-02f, -5.64026423e-02f, 5.36462143e-02f, -5.82111143e-02f, -2.37067506e-01f,
  7.33262673e-02f, 2.57717371e-01f, 4.95740846e-02f, -1.40240848e-01f, 2.63994392e-02f, 1.45324036e-01f, 1.44460183e-02f, -1.89436376e-01f, -7.15702623e-02f, -6.20139539e-02f,
  8.16681758e-02f, -1.20742083e-01f, 1.33197963e-01f, 2.64359057e-01f, 8.11665319e-03f, -9.65343639e-02f, -2.13090211e-01f, -6.10218011e-02f, 1.00675793e-02f, 1.27747640e-01f,
  -7.62623698e-02f, -3.43736224e-02f, -2.14188918e-02f, -1.10761441e-01f, 1.47581577e-01f, 1.44089878e-01f, -1.51654750e-01f, 7.97588900e-02f, 1.15466617e-01f, 4.63431664e-02f,
  1.12877294e-01f, -2.22069040e-01f, 1.22760303e-01f, -2.31026895e-02f, -9.84341577e-02f, 1.82991177e-02f, -3.58082987e-02f, 1.62990481e-01f, -3.14518690e-01f, -5.86148575e-02f,
  -2.24469215e-01f, -2.04332471e-01f, 1.22107938e-01f, 1.40422761e-01f, 2.40577281e-01f, 1.28134906e-01f, -5.29504232e-02f, 1.13932066e-01f, 1.49908677e-01f, 5.94673073e-03f,
  4.91655618e-02f, -1.45644005e-02f, -2.67385751e-01f, 1.29121855e-01f, -1.46367595e-01f, 5.26403189e-02f, 1.49467988e-02f, -1.70873731e-01f, 2.49097613e-03f, -2.12437510e-01f,
  -1.03768267e-01f, -2.68093552e-02f, -2.53317673e-02f, -9.96253714e-02f, 1.27383387e-02f, 9.32162926e-02f, 2.82433927e-01f, 3.39332461e-01f, 3.49101946e-02f, -1.25680074e-01f,
  -2.05035567e-01f, 1.51024729e-01f, -1.49459556e-01f, 3.61135870e-01f, -6.25355821e-03f, -2.84563135e-02f, 8.62568021e-02f, -1.50001973e-01f, -1.99917555e-02f, 8.69895294e-02f,
  1.84962656e-02f, 1.82001710e-01f, 1.45080179e-01f, 1.92236215e-01f, 9.77853462e-02f, 1.88398156e-02f, 7.21849874e-02f, 2.07176268e-01f, -1.73006162e-01f, 4.25140187e-02f,
  -7.51042366e-02f, 1.65354088e-01f, 1.77355066e-01f, 5.90200201e-02f, 4.46730433e-03f, 2.69941151e-01f, -1.23519721e-02f, 8.89498815e-02f, 1.25800401e-01f, 1.88222766e-01f,
  -4.99990545e-02f, 1.02476761e-01f, 4.30544056e-02f, 9.05420631e-02f, 7.04628825e-02f, 6.98115528e-02f, -6.63962588e-02f, 5.09565324e-02f, -1.99854136e-01f, -1.78921312e-01f,
  5.20874672e-02f, -2.70524845e-02f, -1.35434493e-01f, 2.20987499e-01f, 1.27538562e-01f, 2.09116787e-01f, 2.13253185e-01f, 2.60101389e-02f, -1.97656499e-03f, 2.31428623e-01f,
  9.05720610e-03f, 1.50577053e-01f, 1.03262052e-01f, 1.15189984e-01f, -9.67809260e-02f, 3.29223908e-02f, 1.14749715e-01f, 4.00353447e-02f, -2.31253892e-01f, -9.33145136e-02f,
  7.17510432e-02f, -9.88907516e-02f, -2.31524959e-01f, 2.46699795e-01f, 3.21352810e-01f, -8.49263221e-02f, 2.35169873e-01f, 2.37674303e-02f, -3.92668368e-03f, 1.86347705e-03f,
  3.76190543e-02f, 9.03169513e-02f, 2.94240117e-01f, 1.96064506e-02f, 2.02930216e-02f, 2.07641140e-01f, 1.44335583e-01f, 2.11624831e-01f, 1.64849535e-01f, 1.96941674e-01f,
  1.22894473e-01f, 1.52728841e-01f, 5.53576536e-02f, 1.80276245e-01f, 2.97375082e-04f, 1.48384899e-01f, 1.50110483e-01f, 4.99705523e-02f, 3.50119639e-03f, 1.59217939e-01f,
  8.33869129e-02f, -4.28956077e-02f, 2.45263875e-01f, 2.84541547e-01f, 2.13647969e-02f, -8.25557560e-02f, 1.72311664e-01f, 2.39748523e-01f, 2.30764528e-03f, 1.14130989e-01f,
  2.19749231e-02f, -6.12737462e-02f, -2.49760989e-02f, -3.97998355e-02f, -8.15915242e-02f, -1.08631425e-01f, -2.30716541e-01f, 1.05201133e-01f, -4.96864989e-02f, -3.77940796e-02f,
  1.68376505e-01f, -6.94334088e-03f, 1.81082353e-01f, 2.52486020e-02f, -6.35311157e-02f, 3.88774127e-02f, 1.88869402e-01f, 2.34979942e-01f, 4.44009416e-02f, 8.37822706e-02f,
  -1.26579449e-01f, 1.99007601e-01f, -2.65131406e-02f, -2.27586806e-01f, -1.30201235e-01f, -1.66944727e-01f, -7.05977678e-02f, -7.78050274e-02f, 2.65392989e-01f, -1.77211568e-01f,
  4.38538343e-01f, -2.07667112e-01f, 1.06931418e-01f, 1.28689809e-02f, -6.81411102e-03f, 6.84807152e-02f, 2.57652670e-01f, 1.13935694e-01f, 4.09543701e-02f, 1.14847266e-03f,
  -2.02688370e-02f, 1.66156232e-01f, -8.92408751e-03f, -4.94019166e-02f, 1.99912697e-01f, 3.59711312e-02f, -4.72898521e-02f, -1.06222384e-01f, 5.39649501e-02f, -1.03793569e-01f,
  6.91761374e-02f, 1.09410882e-01f, 1.27548069e-01f, 1.71935707e-01f, 1.30858982e-03f, 1.29790902e-01f, -4.03690264e-02f, -1.15897413e-02f, -8.46828613e-03f, -4.47402485e-02f,
  1.53689861e-01f, 1.23321578e-01f, 9.49779078e-02f, 2.89232749e-02f, -9.68962759e-02f, -9.52144563e-02f, -2.17749365e-03f, 1.72799945e-01f, -2.47307438e-02f, 9.67436507e-02f,
  -1.30868535e-02f, 1.44954741e-01f, -8.68561268e-02f, -1.64547756e-01f, 1.66703999e-01f, -5.65491430e-03f, 1.64856747e-01f, -1.57780111e-01f, 1.70208067e-01f, 6.69389144e-02f,
  1.48897365e-01f, 1.35476768e-01f, 3.06448817e-01f, 1.54793903e-01f, -3.03959977e-02f, -2.40566339e-02f, 2.51917869e-01f, -1.02140561e-01f, -2.43574325e-02f, -6.29012808e-02f,
  8.14308152e-02f, -6.21274710e-02f, 2.28166208e-02f, -7.09226727e-03f, 3.39039028e-01f, -4.78747897e-02f, 8.31641778e-02f, 1.69707701e-01f, 2.55841464e-02f, 2.01882478e-02f,
  1.38138250e-01f, 9.34823975e-02f, 1.14305943e-01f, -1.92032516e-01f, 1.53609335e-01f, 1.55253842e-01f, 3.58811691e-02f, 4.87343706e-02f, -6.10653609e-02f, 8.27768221e-02f,
  1.17074810e-01f, -1.18522301e-01f, -4.37655412e-02f, 1.65747553e-01f, 1.30277187e-01f, 1.18134104e-01f, 7.15594366e-02f, 1.14891604e-01f, 4.52482775e-02f, 4.66107298e-03f,
  4.28823419e-02f, 1.67455539e-01f, -1.92909971e-01f, -1.22201614e-01f, -1.28073618e-03f, 1.06284708e-01f, 6.22758940e-02f, 8.13627169e-02f, -8.93053971e-03f, -1.00595869e-01f,
  -1.56020299e-02f, -4.48790714e-02f, 9.37204584e-02f, -8.59473497e-02f, -7.53137693e-02f, 8.08521435e-02f, 9.38858837e-02f, 3.82013060e-02f, 1.83686674e-01f, 6.84754848e-02f,
  3.91197056e-02f, -5.68196848e-02f, 7.84309283e-02f, 1.02783605e-01f, 1.88174862e-02f, 1.45302340e-01f, -7.89823085e-02f, 6.01469912e-02f, 3.45467888e-02f, 3.67007814e-02f,
  1.70914028e-02f, -1.66169122e-01f, -1.22798444e-03f, -1.96669146e-01f, 5.15313558e-02f, 4.67220098e-02f, 1.86785161e-01f, -1.17273599e-01f, 4.38894421e-01f, -1.02508366e-02f,
  -6.97479546e-02f, 1.10040223e-02f, -1.65820807e-01f, 2.62200180e-02f, 1.45919725e-01f, 1.94143951e-01f, 1.27480581e-01f, -8.82357731e-02f, -6.09883070e-02f, 1.57218844e-01f,
  1.64186478e-01f, -3.67895775e-02f, 7.18908310e-02f, 2.11792290e-02f, 8.18258747e-02f, -2.10667122e-02f, -6.53417036e-02f, 1.68445930e-01f, 2.84873061e-02f, 3.22687030e-01f,
  1.73628047e-01f, -9.82692763e-02f, 1.65147468e-01f, 1.99915901e-01f, -2.90839653e-02f, 8.51139948e-02f, -1.73925951e-01f, 3.84714752e-02f, -2.38003265e-02f, -6.29627239e-03f,
  9.08757909e-04f, 8.92331153e-02f, 1.00116991e-01f, 8.68492797e-02f, -9.36222970e-02f, 5.65537214e-02f, -1.47835177e-03f, -9.43029001e-02f, 7.84129500e-02f, 3.81689024e-04f,
  2.96925064e-02f, 1.76258862e-01f, 4.49151732e-02f, -2.16290336e-02f, -4.51592617e-02f, 8.94995332e-02f, 8.76287371e-02f, 4.68706508e-04f, 4.14134003e-02f, -6.48191050e-02f,
  -3.30556273e-01f, -6.21328503e-02f, 1.35583326e-01f, -6.02026507e-02f, -1.08661652e-01f, -8.77889805e-03f, 9.90924537e-02f, 1.37631521e-01f, -6.30580857e-02f, 1.92487970e-01f,
  2.17211843e-01f, 5.79036027e-02f, 1.27893090e-01f, 4.20123972e-02f, 1.23484470e-01f, -1.23726660e-02f, -9.33447629e-02f, -1.04530081e-01f, 5.61127141e-02f, 1.08022667e-01f,
  -1.90398246e-01f, -8.56048614e-02f, 4.28431258e-02f, 1.20580509e-01f, 1.08537816e-01f, -2.15039661e-04f, 8.59263688e-02f, 7.80670792e-02f, -5.20316027e-02f, -2.32884344e-02f,
  1.15210339e-01f, 2.47394200e-03f, 8.71278346e-02f, -3.99123393e-02f, 1.13041639e-01f, -9.23292562e-02f, 1.24061229e-02f, 2.58803181e-02f, 2.11409822e-01f, 2.40766238e-02f,
  -3.77415530e-02f, -2.53376603e-01f, 2.60960907e-01f, 2.30449662e-01f, -1.52992055e-01f, -9.31067318e-02f, -1.46734059e-01f, -1.81054920e-01f, -8.31455737e-02f, 1.45338595e-01f,
  -6.56183660e-02f, 1.54917419e-01f, -2.07384136e-02f, -3.35197598e-02f, -7.04796538e-02f, 1.19648643e-01f, 1.68259874e-01f, -8.97319466e-02f, 2.49473397e-02f, -3.00892573e-02f,
  -1.58297136e-01f, -2.90068656e-01f, 3.42851095e-02f, 1.29568979e-01f, 1.03640869e-01f, -8.55830982e-02f, -1.19711228e-01f, -1.72573194e-01f, 2.56669343e-01f, -2.65861750e-01f,
  -3.59423831e-02f, -7.97503516e-02f, 1.24455385e-01f, 3.41357589e-02f, -2.21957564e-01f, 1.21237732e-01f, 2.23544836e-01f, -1.34432137e-01f, 4.11883667e-02f, -3.03932726e-02f,
  -1.46724507e-01f, -1.46057472e-01f, 2.15811744e-01f, 1.02791838e-01f, 6.05767369e-02f, -4.59399521e-02f, 8.81677344e-02f, 1.66221678e-01f, 3.75455543e-02f, 2.31119562e-02f,
  2.27957442e-01f, 1.05519101e-01f, 5.10500632e-02f, 3.12107265e-01f, -2.14013010e-01f, 8.49588364e-02f, 1.30815312e-01f, -4.20372076e-02f, -1.46250293e-01f, -2.72150457e-01f,
  -1.35653675e-01f, 8.68938714e-02f, 5.35363369e-02f, 4.29574773e-02f, -4.03099209e-02f, 2.24274606e-01f, -2.68619712e-02f, -1.09901592e-01f, -3.11562363e-02f, -7.81833082e-02f,
  1.03852257e-01f, 8.42604786e-02f, 1.96961761e-01f, 1.16734639e-01f, 1.50387511e-01f, 6.31624684e-02f, 7.07963929e-02f, 2.88637877e-02f, 3.31455976e-01f, 1.34794608e-01f,
  -2.04316348e-01f, 1.24179974e-01f, -1.39152855e-01f, 2.76821196e-01f, -1.69707671e-01f, -8.77962112e-02f, -1.45405531e-01f, -2.12098062e-02f, -2.59286135e-01f, -7.57414773e-02f,
  2.12958068e-01f, 2.50474304e-01f, -1.19409688e-01f, 5.99116273e-02f, 2.28532627e-01f, 9.34014767e-02f, 5.06967418e-02f, 1.54408485e-01f, -8.23243558e-02f, 1.00592732e-01f,
  -2.85191000e-01f, 3.35605800e-01f, 1.44776583e-01f, -6.09053634e-02f, -8.28207582e-02f, -4.04141247e-02f, 7.71715939e-02f, -2.77879983e-01f, 1.26060406e-02f, 3.68182927e-01f,
  5.68799786e-02f, -1.05748750e-01f, 1.17423892e-01f, 2.82293535e-03f, 2.46088356e-02f, 8.55858028e-02f, 9.30664837e-02f, 2.14898456e-02f, -1.18652806e-01f, -3.45543504e-01f,
  -7.14732558e-02f, -9.32428241e-02f, -1.38920829e-01f, 6.68173376e-03f, -1.66367009e-01f, 7.13895336e-02f, 1.71462208e-01f, -9.46940631e-02f, 7.97723308e-02f, -6.95996657e-02f,
  3.43229741e-01f, 3.40479881e-01f, -9.84597057e-02f, -4.71313410e-02f, -4.87036295e-02f, 4.25624922e-02f, -1.02298439e-01f, 4.52810824e-02f, -2.05480605e-01f, 2.67180800e-01f,
  -7.70704970e-02f, -1.96199231e-02f, -7.22385347e-02f, -1.21741988e-01f, -6.90180212e-02f, 4.72132415e-02f, 1.53230458e-01f, -1.64983154e-03f, 1.45416275e-01f, 3.83189134e-02f,
  -5.21489307e-02f, 2.75035024e-01f, 1.62162244e-01f, 1.38906036e-02f, -1.07266456e-01f, 2.03477129e-01f, -1.48890493e-02f, -8.87737721e-02f, 4.05654795e-02f, 6.46987334e-02f,
  1.67554095e-02f, -1.55472560e-02f, -2.22445279e-01f, 7.49262571e-02f, -2.89769620e-01f, -3.62744294e-02f, -1.61838993e-01f, -6.07561357e-02f, 6.16787784e-02f, -1.14034154e-01f,
  1.19665064e-01f, -7.59680122e-02f, 4.87524420e-02f, 1.49241403e-01f, -9.61247087e-02f, 1.06622644e-01f, 1.48344541e-03f, -8.83760229e-02f, -1.15244277e-01f, -3.96956392e-02f,
  -1.18292198e-01f, 6.68827370e-02f, 3.87422852e-02f, -3.68715785e-02f, 1.14169016e-01f, 2.08107784e-01f, -5.40317781e-03f, 1.70195878e-01f, 2.16105923e-01f, 1.78309247e-01f,
  -1.41278908e-01f, -5.43916188e-02f, -2.49297321e-02f, -4.68691699e-02f, -9.49777886e-02f, 3.17375138e-02f, -1.45133585e-01f, 1.51608214e-01f, -2.26754081e-02f, 1.58259511e-01f,
  1.55909853e-02f, -2.92358249e-02f, -4.49560918e-02f, 1.03864968e-01f, -4.65191249e-03f, -6.61971048e-02f, -2.41213113e-01f, -6.68266341e-02f, -3.34533662e-01f, 1.27056763e-01f,
  2.03508168e-01f, -1.82010472e-01f, 2.61939943e-01f, -2.71188971e-02f, -4.69297543e-02f, 2.19201273e-03f, -6.42739981e-02f, 5.68493567e-02f, 2.05901917e-02f, -1.71061903e-01f,
  1.38545543e-01f, 9.53181833e-02f, -1.35975048e-01f, -3.29969823e-02f, -1.02803819e-01f, 6.73611760e-02f, 1.38542548e-01f, -5.89927770e-02f, 2.50489898e-02f, -7.97662884e-02f,
  -8.54856223e-02f, -7.75089934e-02f, 1.01703927e-02f, 1.01678784e-03f, -5.01294173e-02f, 2.60366172e-01f, -2.42307726e-02f, -1.58487201e-01f, -3.19495201e-02f, 1.47775635e-01f,
  9.64391753e-02f, 1.72256365e-01f, 9.34980810e-02f, -4.59483638e-03f, 2.34969072e-02f, -2.40442842e-01f, -1.25827059e-01f, -7.54988790e-02f, 6.01241365e-02f, -1.35511443e-01f,
  3.55508961e-02f, 6.59855753e-02f, 8.67016092e-02f, 4.13444154e-02f, -2.76279926e-01f, -1.56405032e-01f, -1.71777268e-03f, -5.06707057e-02f, -2.62466371e-01f, 1.25582114e-01f,
  8.22526682e-03f, 7.90283605e-02f, -9.18902904e-02f, 3.10593933e-01f, 6.05662763e-02f, 1.50140747e-01f, 3.55148800e-02f, 1.29702866e-01f, 1.60492167e-01f, -5.80180548e-02f,
  1.11010768e-01f, 1.30656287e-01f, -8.40319246e-02f, 1.76080719e-01f, 1.00797657e-02f, 9.41787586e-02f, 1.92825664e-02f, 1.71378002e-01f, -1.83535278e-01f, -1.55221969e-01f,
  -6.32042065e-02f, -1.55539081e-01f, 1.72917098e-01f, -1.10794403e-01f, 1.55626666e-02f, 4.71916944e-02f, 3.09359342e-01f, 2.15507284e-01f, -1.96645528e-01f, 7.95684978e-02f,
  2.83887144e-02f, 1.11391671e-01f, 1.84270769e-01f, 2.35564202e-01f, 2.82683849e-01f, -1.63774803e-01f, -2.81717330e-02f, 1.89696823e-03f, -3.54492143e-02f, -6.65950030e-02f,
  -1.09440856e-01f, 4.91795279e-02f, -2.78932303e-02f, 4.73390408e-02f, -2.46654321e-02f, -8.19028839e-02f, -1.18503116e-01f, -9.69906300e-02f, -6.88970760e-02f, -6.95450455e-02f,
  -1.67165380e-02f, -1.77632440e-02f, 1.27311543e-01f, 1.53229252e-01f, 2.69297332e-01f, 1.44233853e-02f, 6.44731969e-02f, 4.15715016e-02f, 5.02389073e-02f, 9.31494310e-02f,
  6.45316839e-02f, -2.62060165e-01f, 1.35521233e-01f, -8.22691321e-02f, -1.89456895e-01f, 1.72241628e-01f, -4.14566807e-02f, 1.53755456e-01f, -1.75525740e-01f, -1.38294727e-01f,
  7.94673711e-02f, 1.43924251e-01f, 2.98550222e-02f, 2.69511163e-01f, -1.02725230e-01f, 2.04042555e-03f, 9.28765461e-02f, 7.11106807e-02f, 2.39496678e-01f, 9.92006958e-02f,
  1.02496251e-01f, -1.34455889e-01f, -7.16361478e-02f, 5.09793721e-02f, -5.17321229e-02f, -2.36469824e-02f, 6.36776537e-02f, -8.50195289e-02f, -1.00097828e-01f, -1.59857348e-01f,
  1.37843778e-02f, 9.07714143e-02f, -1.91767454e-01f, 1.37346804e-01f, 7.41914138e-02f, -2.03210451e-02f, 1.21817850e-01f, 1.07569888e-01f, -2.94903249e-01f, 8.15298855e-02f,
  -1.47413060e-01f, -3.09884667e-01f, 2.52263486e-01f, 5.88601045e-02f, -5.61527833e-02f, -3.82597186e-02f, 1.18358009e-01f, 1.23273404e-02f, 9.08049755e-03f, 1.39302522e-01f,
  1.03226461e-01f, 1.81580305e-01f, 8.99651647e-03f, -2.94614136e-01f, 1.56327203e-01f, -2.98262481e-02f, -6.31136680e-03f, 1.15840867e-01f, 1.86519101e-01f, 1.42854288e-01f,
  -2.68502180e-02f, -1.04754269e-01f, 5.22946008e-02f, -1.54566169e-01f, 1.93440571e-01f, -8.45097229e-02f, 3.39417279e-01f, 3.22937191e-01f, 1.23130254e-01f, 8.54548253e-03f,
  -1.65375575e-01f, 1.48267940e-01f, -1.08101228e-02f, 1.76562250e-01f, 1.38957500e-01f, 2.26604119e-01f, 1.65332228e-01f, 1.96952954e-01f, 1.60490721e-02f, -9.91911292e-02f,
  2.51369268e-01f, 1.51015535e-01f, 2.64818281e-01f, -2.08914027e-01f, 1.19237885e-01f, -3.89683619e-02f, 4.39548865e-02f, 9.60685611e-02f, 4.01189595e-01f, 1.91343129e-01f,
  -1.84098765e-01f, -8.04171115e-02f, -5.92709519e-02f, -3.12045123e-02f, 8.13800767e-02f, 1.04235761e-01f, -1.56615093e-01f, -1.49211898e-01f, -1.58193648e-01f, 4.97929677e-02f,
  3.66921335e-01f, -7.00042844e-02f, 2.47116387e-01f, 2.76472449e-01f, 5.05163632e-02f, -5.44133084e-03f, 1.37424499e-01f, 9.79754254e-02f, 2.34897926e-01f, -1.63727358e-01f,
  -5.54629862e-02f, 3.66416238e-02f, 1.35306856e-02f, -3.22331180e-04f, -1.45293608e-01f, -4.95784283e-02f, 6.27859086e-02f, -6.07412718e-02f, 1.14993855e-01f, -1.03232943e-01f,
  4.46672626e-02f, -3.87252755e-02f, 5.32794334e-02f, 3.57369408e-02f, 1.00090899e-01f, 1.28925666e-02f, -1.85952634e-01f, -3.18667740e-01f, -1.16359368e-01f, -1.69138730e-01f,
  -1.42345861e-01f, 4.33679968e-01f, -3.22790146e-01f, 5.88376932e-02f, -1.59767717e-01f, 1.84787959e-01f, -5.39140031e-02f, 2.79125482e-01f, 1.35758221e-01f, 2.55298615e-01f,
  1.35584518e-01f, -1.21208385e-01f, -2.23331571e-01f, -1.63678885e-01f, -5.59044704e-02f, 1.18228264e-01f, 1.32935211e-01f, 9.39965099e-02f, 1.73745200e-01f, 1.41264498e-01f,
  1.46220431e-01f, -2.46352643e-01f, 3.90208848e-02f, -1.64138019e-01f, -1.18235067e-01f, 6.35716915e-02f, 1.10955849e-01f, -1.06990160e-02f, 1.22021593e-01f, 2.56632119e-01f,
  -1.38726607e-01f, -8.80570933e-02f, 4.39441986e-02f, 2.10633501e-01f, -5.72026297e-02f, 3.05799603e-01f, 3.59091125e-02f, -5.52525520e-02f, 7.86271021e-02f, -2.85138309e-01f,
  -2.41859704e-02f, 8.34021643e-02f, -1.48588195e-01f, -1.04585037e-01f, 1.01676337e-01f, -2.13519484e-02f, -6.88308924e-02f, -3.73507030e-02f, 1.22023644e-02f, 1.31130382e-01f,
  2.94132885e-02f, -7.96093941e-02f, -9.57859829e-02f, -1.23174787e-01f, -1.48535937e-01f, 5.51558360e-02f, -4.65514287e-02f, 1.82193726e-01f, 5.59624434e-02f, -8.60493630e-02f,
  4.00953926e-02f, -1.40306503e-01f, 2.09872857e-01f, 1.50975958e-01f, -1.17433392e-01f, 2.11789131e-01f, 5.32884039e-02f, 1.64505571e-01f, -3.58113237e-02f, 2.18275979e-01f,
  1.72915503e-01f, 1.43196071e-02f, 8.29922482e-02f, 2.25523576e-01f, -6.24135733e-02f, 9.87271145e-02f, -1.77993611e-01f, -1.45915940e-01f, -7.94055164e-02f, 3.55755799e-02f,
  1.88091621e-01f, 2.89362073e-01f, 1.53167233e-01f, 6.10338338e-02f, 1.41416773e-01f, 4.50802259e-02f, 2.16858387e-01f, 8.88055936e-02f, -7.72195160e-02f, 1.86809644e-01f,
  -2.74553597e-02f, -1.18617855e-01f, 2.22038373e-01f, 3.17581356e-01f, -1.23980328e-01f, -1.77224159e-01f, -1.37278382e-02f, 6.21367693e-02f, -3.24245155e-01f, 1.25980437e-01f,
  -4.86680977e-02f, 3.47934254e-02f, 2.71138906e-01f, -4.12339829e-02f, -2.20509209e-02f, 1.07803559e-02f, 1.50382936e-01f, 2.21617058e-01f, 5.76466545e-02f, 1.96057595e-02f,
  8.99978913e-03f, 2.59174779e-02f, -6.03914931e-02f, 2.46786959e-02f, -3.51600535e-02f, 7.20508909e-03f, 3.53087485e-02f, -1.03607036e-01f, 4.54090126e-02f, -3.28804404e-02f,
  -1.57642797e-01f, 5.56687787e-02f, -9.46563408e-02f, -1.37650177e-01f, 1.51487663e-01f, 6.35310039e-02f, 2.19135180e-01f, -1.79658402e-02f, -1.61476374e-01f, 2.56885648e-01f,
  -8.19415525e-02f, 8.44425187e-02f, -9.54647660e-02f, 1.21321738e-01f, -2.91195303e-01f, -1.22972280e-01f, 7.32281208e-02f, 3.15599740e-02f, -1.12166844e-01f, 1.07245922e-01f,
  -1.50178581e-01f, -6.87146410e-02f, 2.18905900e-02f, 2.21205950e-02f, 2.45611724e-02f, 2.65754431e-01f, 4.43724096e-02f, 1.29204795e-01f, 3.31330836e-01f, 3.98949832e-02f,
  2.20861673e-01f, 1.32338613e-01f, -8.00746605e-02f, 3.39024574e-01f, 5.16615137e-02f, -3.27977315e-02f, 5.03018834e-02f, 6.71232939e-02f, -1.19870178e-01f, -1.37703210e-01f,
  8.60932022e-02f, -1.89487979e-01f, -3.38739246e-01f, -3.84149998e-02f, -1.83998451e-01f, -9.81072709e-02f, 2.81548262e-01f, 2.79800668e-02f, -6.31744340e-02f, -2.68631644e-04f,
  1.17552802e-01f, 1.45254852e-02f, 9.75446105e-02f, 7.12452009e-02f, 1.18562177e-01f, -7.26007000e-02f, 1.91371635e-01f, 2.41806701e-01f, 9.60305631e-02f, 2.10889522e-02f,
  -1.01068906e-01f, -1.73449799e-01f, -1.45066902e-01f, 9.32531431e-02f, 3.14137153e-02f, 3.85161676e-02f, -1.97406054e-01f, 8.00569132e-02f, 1.02742225e-01f, 1.94014862e-01f,
  1.07192241e-01f, 3.12141597e-01f, -3.87029350e-02f, -2.32643820e-02f, -3.33937928e-02f, 2.52197813e-02f, -1.27879620e-01f, 1.40507713e-01f, 2.22887591e-01f, -1.16115436e-01f,
  -1.43005457e-02f, 5.71711101e-02f, 8.64128545e-02f, 9.54704285e-02f, 7.75152398e-03f, 8.48009586e-02f, -1.73616618e-01f, -1.09211411e-02f, 3.43626551e-02f, 2.82084733e-01f,
  6.73103184e-02f, 6.98154420e-02f, -1.55606885e-02f, 2.14844316e-01f, 2.24918619e-01f, 1.10847764e-01f, 1.47444993e-01f, 3.03631186e-01f, -4.63923663e-02f, -2.54530422e-02f,
  1.28807694e-01f, 1.45912319e-02f, 6.86520562e-02f, -1.28627211e-01f, 1.07198544e-01f, -1.08676806e-01f, -1.44701004e-01f, 8.80519524e-02f, 8.13176204e-03f, -1.01251133e-01f,
  2.10393190e-01f, 1.51019886e-01f, -1.35588706e-01f, -2.70034134e-01f, 1.95350543e-01f, 3.84514153e-01f, 6.93595111e-02f, 1.67168871e-01f, 9.06183198e-02f, 1.91325054e-01f,
  3.26987691e-02f, -1.56373605e-02f, -7.07893595e-02f, -1.07488587e-01f, 1.33663630e-02f, -1.90790184e-02f, -9.76559222e-02f, 2.66025425e-03f, 9.95198712e-02f, 2.19713897e-01f,
  -1.26846731e-01f, 1.68720707e-02f, 5.16903400e-02f, 8.95676576e-03f, 2.04902545e-01f, 1.82463720e-01f, -2.97267646e-01f, -2.59066105e-01f, 3.39111239e-01f, -1.44073337e-01f,
  -4.22947519e-02f, -3.03886265e-01f, 1.80996522e-01f, -9.97727364e-03f, 8.07130337e-02f, -2.43139103e-01f, 3.34295584e-03f, -4.52716164e-02f, 2.45090008e-01f, 1.70617670e-01f,
  -3.16312835e-02f, -1.35655716e-01f, -7.29779005e-02f, -7.92999864e-02f, -2.18311623e-02f, 1.26148179e-01f, 1.36931883e-02f, -1.04372270e-01f, 1.11162432e-01f, 4.87718321e-02f,
  5.32820448e-02f, -3.16700459e-01f, 3.05863917e-02f, 3.09327632e-01f, -1.42604876e-02f, -2.70973016e-02f, -8.36289749e-02f, -1.71493385e-02f, 1.06928706e-01f, -1.28643736e-01f,
  5.24271466e-03f, 8.27337205e-02f, 6.50855538e-04f, -1.12034962e-01f, 1.50372222e-01f, 2.63696611e-01f, 7.54002407e-02f, 7.69530460e-02f, 4.43812832e-02f, -1.14307888e-01f,
  1.70599014e-01f, 7.60237649e-02f, -9.00200978e-02f, -1.92659907e-02f, 1.03963472e-01f, 1.38355747e-01f, -2.30858102e-02f, 3.06203663e-02f, -1.47792995e-01f, -2.26832524e-01f,
  -1.65318877e-01f, 5.28415330e-02f, 6.48331270e-02f, 5.78645356e-02f, -5.11021018e-02f, 5.27936593e-02f, -7.01187477e-02f, 4.33021262e-02f, 2.10019112e-01f, 2.52782077e-01f,
  9.45604667e-02f, 2.90012985e-01f, -1.46556869e-01f, -4.15989049e-02f, -1.86349496e-01f, 2.10643098e-01f, 3.47916663e-01f, 1.86934039e-01f, 5.33662327e-02f, 2.02048004e-01f,
  1.12237945e-01f, 1.44818947e-01f, -3.66341788e-03f, -1.33393496e-01f, -2.04788134e-01f, 7.41605684e-02f, 1.74882054e-01f, 1.64374918e-01f, -6.19889908e-02f, -1.98491942e-02f,
  2.77152676e-02f, 5.36084827e-03f, 3.14630926e-01f, 1.54579639e-01f, 8.68235379e-02f, 4.37580436e-01f, -6.34171143e-02f, -1.98334903e-01f, 2.37128094e-01f, 2.93876171e-01f,
  4.89028916e-02f, -1.83429107e-01f, -6.62138462e-02f, 3.10903072e-01f, -3.22418720e-01f, 2.38104641e-01f, 1.30373761e-01f, 6.79333508e-03f, 1.77736849e-01f, 5.81040718e-02f,
  -7.69183263e-02f, -3.21989000e-01f, 2.81218320e-01f, 2.08019406e-01f, 1.75957218e-01f, 9.71989259e-02f, 1.93950593e-01f, 1.00522704e-01f, 7.04683438e-02f, 1.53424889e-01f,
  1.00362666e-01f, 1.79347813e-01f, 1.16437055e-01f, 1.22338772e-01f, 6.08566441e-02f, -2.52741545e-01f, -7.86897913e-02f, 7.43248686e-02f, -8.97056833e-02f, 6.69821678e-03f,
  9.50785354e-02f, 1.88706324e-01f, 6.84505403e-02f, 2.45771110e-01f, -1.58756182e-01f, -5.35226054e-02f, 3.00878063e-02f, -2.00761944e-01f, -9.03379265e-03f, -1.19068757e-01f,
  1.29996568e-01f, 1.03892684e-01f, 2.16688737e-01f, -1.96393862e-01f, -7.59417862e-02f, -1.72958360e-04f, 3.32837611e-01f, 9.40299928e-02f, -1.10596284e-01f, 8.08564648e-02f,
  -1.01831906e-01f, 7.56274536e-02f, -2.01806515e-01f, 1.84093699e-01f, -3.47604454e-02f, 1.05572008e-02f, -1.23877302e-01f, 8.13504755e-02f, 1.03189699e-01f, 2.84023602e-02f,
  -8.10897052e-02f, 2.12721556e-01f, 1.59079567e-01f, 8.07718039e-02f, 1.10778533e-01f, 1.77688301e-01f, -4.91244718e-02f, -3.33938524e-02f, -1.86725914e-01f, 7.60808736e-02f,
  1.92135841e-01f, 1.63896531e-02f, 8.93300027e-02f, 2.73894906e-01f, -1.67973921e-01f, -1.72245726e-01f, 1.73766136e-01f, 3.00870091e-01f, -1.74896419e-02f, -4.98937955e-03f,
  -1.84791625e-01f, -1.43839389e-01f, -8.15385804e-02f, -5.97291999e-02f, 2.94272341e-02f, -9.13513750e-02f, -5.22131771e-02f, -1.44008785e-01f, -1.10858064e-02f, -4.23359592e-03f,
  -1.05895903e-02f, 1.62083000e-01f, -3.73990759e-02f, 6.17846698e-02f, -2.49425750e-02f, -1.50062710e-01f, 1.29631683e-01f, 8.05518031e-02f, -6.54587224e-02f, 2.82451004e-01f,
  -6.78604990e-02f, 9.47642475e-02f, 4.73872498e-02f, 1.34213462e-01f, -1.28141791e-01f, -3.64726260e-02f, -6.04691803e-02f, 5.50531931e-02f, -7.12058172e-02f, 7.48627819e-03f,
  -9.64869782e-02f, -3.36215608e-02f, -1.13216765e-01f, 1.74813941e-01f, 2.05929175e-01f, -2.00796515e-01f, 1.11432172e-01f, 1.03367135e-01f, 9.91669744e-02f, -9.06626284e-02f,
  1.83470100e-01f, 1.57918677e-01f, -8.11371766e-03f, -6.69180676e-02f, 4.24078153e-03f, -1.34875223e-01f, 7.87230805e-02f, 3.23276334e-02f, -1.44366264e-01f, 5.23393191e-02f,
  4.56934087e-02f, -1.38391823e-01f, 1.06073553e-02f, 8.98597315e-02f, -4.05518897e-02f, -5.34597151e-02f, 2.49352634e-01f, 5.05026914e-02f, 3.24997678e-02f, -8.24565589e-02f,
  -3.38530615e-02f, -2.06438720e-01f, 1.73321322e-01f, -2.70006509e-04f, 1.76399648e-01f, -4.16260622e-02f, 2.27784701e-02f, 1.10857956e-01f, -4.01595198e-02f, 1.63978860e-01f,
  -7.89667740e-02f, 1.26184197e-04f, 1.80753812e-01f, -6.61773011e-02f, 8.84486064e-02f, -5.77235147e-02f, -1.12604806e-02f, 1.90750197e-01f, 2.74915457e-01f, 8.93793069e-03f,
  5.31277247e-02f, 1.26465648e-01f, 1.04106881e-01f, -1.87153623e-01f, 7.45743364e-02f, 2.45846249e-02f, 6.06513675e-03f, 1.03591837e-01f, 1.56600937e-01f, -1.23502865e-01f,
  -1.83260906e-02f, -7.84313083e-02f, 6.69637099e-02f, 1.87744603e-01f, 1.55405983e-01f, 2.50387430e-01f, -5.25873043e-02f, 1.37023628e-01f, 2.20723391e-01f, 1.63955063e-01f,
  4.72117625e-02f, 1.33004591e-01f, -1.38745621e-01f, 2.19688937e-01f, 8.16353559e-02f, 4.12132181e-02f, 1.55019537e-01f, 6.36088401e-02f, -6.08871207e-02f, 4.31710258e-02f,
  1.54900238e-01f, -1.04210064e-01f, 5.30961677e-02f, 1.61723375e-01f, -5.22590280e-02f, -1.62839323e-01f, -1.03299208e-01f, -7.47037008e-02f, -1.18676320e-01f, 7.65269101e-02f,
  4.17087600e-02f, 1.54365718e-01f, 1.51307851e-01f, 9.22690853e-02f, 9.25428048e-02f, 2.41328105e-01f, 2.74430681e-02f, -9.35034379e-02f, -2.23993301e-01f, 1.86063945e-02f,
  2.54805367e-02f, -1.12475909e-01f, 1.18651176e-02f, -1.92433357e-01f, 1.47605501e-02f, -1.24882936e-01f, 7.72217941e-03f, 2.34263353e-02f, 1.08765014e-01f, -5.79272993e-02f,
  1.95303373e-02f, -3.99483629e-02f, 1.39113367e-01f, -4.81301248e-02f, 5.69736660e-02f, -2.33378068e-01f, 1.84833452e-01f, -2.48002142e-01f, 3.09701208e-02f, -1.65982638e-02f,
  -5.39584160e-02f, -2.36125529e-01f, -1.46067455e-01f, -5.13169207e-02f, -2.00464919e-01f, 1.43127814e-01f, 6.91847429e-02f, 1.25155672e-01f, -1.34441435e-01f, 6.12215772e-02f,
  6.86684102e-02f, -2.01628938e-01f, -5.46493009e-02f, 3.26941609e-02f, -1.51040152e-01f, -3.35177362e-01f, -6.90631419e-02f, 2.05934867e-01f, 6.83534518e-02f, -4.20522615e-02f,
  -5.43310493e-02f, -2.58871287e-01f, 5.70616871e-02f, -1.35705039e-01f, -3.08923662e-01f, -6.29548207e-02f, 2.17365950e-01f, 1.49089554e-02f, -1.56033605e-01f, -1.32488590e-02f,
  1.13044649e-01f, -2.11569160e-01f, -1.77514121e-01f, 1.65984154e-01f, -2.17741236e-01f, -1.59312069e-01f, 1.23777203e-01f, 2.12866798e-01f, 4.49714959e-02f, -7.33319744e-02f,
  1.97955415e-01f, -3.38340731e-04f, 4.63203415e-02f, 8.10377151e-02f, 6.76704422e-02f, 1.46862850e-01f, -1.86381981e-01f, -1.84453186e-02f, 1.32235112e-02f, -9.77374464e-02f,
  5.96664883e-02f, -5.21789268e-02f, -1.75379589e-01f, 9.26028341e-02f, -1.19717762e-01f, -7.74744377e-02f, 1.29378974e-01f, 1.58365399e-01f, 2.61619925e-01f, 1.30181730e-01f,
  -4.05810438e-02f, 3.61188173e-01f, 3.00753210e-02f, 8.96871239e-02f, -2.77787037e-02f, -1.46940395e-01f, 1.06280789e-01f, 1.14406660e-01f, 2.56421834e-01f, -2.57448733e-01f,
  -3.19151521e-01f, -1.58430293e-01f, 7.01573789e-02f, 8.15333501e-02f, 1.77608371e-01f, -1.01490051e-01f, -7.76371732e-03f, 1.72464117e-01f, -2.80082654e-02f, 2.72229463e-02f,
  2.05303088e-01f, -9.71758962e-02f, 2.07246989e-01f, 1.31145269e-01f, -1.16126083e-01f, 1.93722412e-01f, 1.56835899e-01f, 9.22271907e-02f, -1.27399519e-01f, 2.06906393e-01f,
  -1.03916384e-01f, -2.77647171e-02f, 7.71135688e-02f, 1.75384030e-01f, 7.44789764e-02f, -2.17815444e-01f, 2.72389621e-01f, -1.46827251e-01f, 2.17871681e-01f, -2.84378529e-02f,
  -2.16180280e-01f, -6.94445595e-02f, 3.89642976e-02f, 2.17808545e-01f, 1.49864867e-01f, -2.21531942e-01f, -1.80985611e-02f, 1.64601058e-02f, 3.34345326e-02f, 1.63348287e-01f,
  -5.05361753e-03f, -5.42968884e-02f, 8.43024030e-02f, -1.82074383e-01f, -8.52083787e-02f, -3.33223725e-03f, 8.45894292e-02f, -4.02185284e-02f, -1.73778445e-01f, 1.40367135e-01f,
  1.34756729e-01f, 4.90521491e-02f, 1.81957111e-01f, -2.43414827e-02f, 3.00953060e-01f, -1.52570412e-01f, 6.56047696e-03f, -1.79214954e-01f, 6.46416247e-02f, 1.62010327e-01f,
  1.95347235e-01f, 2.33214542e-01f, -2.30622128e-01f, 3.67042869e-01f, 9.71675217e-02f, 2.50659019e-01f, 4.03649732e-02f, -1.24983221e-01f, 3.70821171e-02f, 9.24292058e-02f,
  2.32311577e-01f, 1.37686580e-01f, 8.64925906e-02f, -9.53022093e-02f, -3.41237038e-01f, 2.92261213e-01f, 2.34752670e-01f, 1.79263681e-01f, 3.40558477e-02f, 1.52192324e-01f,
  -1.07869670e-01f, -7.46581703e-02f, -4.11497802e-02f, 1.12150826e-01f, 1.63882598e-02f, -4.27506827e-02f, -3.85752231e-01f, 3.16552281e-01f, -2.66887248e-01f, -1.28492415e-01f,
  -8.26118588e-02f, 2.21754268e-01f, 8.85811150e-02f, -1.43380865e-01f, 1.59450412e-01f, -1.76283553e-01f, 2.19028860e-01f, 2.47737870e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -1.12905595e-02f, 1.80093329e-02f, 3.01524606e-02f, 3.46579775e-02f, 4.36652191e-02f, -3.03574745e-02f, -1.05870642e-01f, 7.08644539e-02f, -3.26392949e-02f, 2.57329285e-01f,
  1.86324656e-01f, 1.95062697e-01f, -2.41289008e-02f, 1.82209879e-01f, 6.05757572e-02f, 1.73065737e-01f, 1.92792639e-01f, 1.60674721e-01f, 1.00936450e-01f, -1.93914305e-02f,
  6.40841275e-02f, 3.84935737e-02f, 2.07063317e-01f, 1.04134046e-01f, 1.06131164e-02f, -1.43864751e-02f, 2.40531057e-01f, -1.26170531e-01f, 1.84081510e-01f, 1.86069116e-01f,
  8.48095343e-02f, 3.36126350e-02f, -1.04258284e-01f, -9.38449875e-02f, 4.19599339e-02f, 8.50853603e-03f, -3.47917378e-02f, 1.92490339e-01f, 9.08754766e-02f, 2.03643993e-01f,
  -7.57518560e-02f, 1.60549730e-01f, -1.37779480e-02f, 5.69352359e-02f, 2.31151223e-01f, 1.28244713e-01f, 1.04044914e-01f, 4.66876701e-02f, 7.88874999e-02f, -1.27564222e-01f,
  5.08103445e-02f, 1.62807763e-01f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.06477834e-01f, 3.89402732e-02f, -1.16389550e-01f, -4.97899279e-02f, -1.27795622e-01f, -1.69033557e-01f, -1.23554565e-01f, 2.66911685e-01f, -2.29936197e-01f, -8.67816731e-02f,
  8.27418119e-02f, -7.55454898e-02f, -4.49716114e-03f, 1.28004536e-01f, 4.07113023e-02f, 4.59609032e-02f, -5.88830933e-02f, 1.42154023e-01f, -2.03575253e-01f, -1.21255830e-01f,
  -1.12756908e-01f, -2.60550110e-03f, -5.27389115e-03f, 3.78845334e-02f, -7.78048933e-02f, 5.96461222e-02f, 1.12912849e-01f, -4.90823910e-02f, -1.15748003e-01f, -1.40406549e-01f,
  -1.94716975e-02f, 3.34777422e-02f, -6.63895085e-02f, -7.27824196e-02f, 3.96685675e-02f, -5.63892312e-02f, 3.43579128e-02f, 1.57706942e-02f, -1.16206750e-01f, -1.31604537e-01f,
  -5.71753904e-02f, 4.26569246e-02f, -4.52336334e-02f, -1.19391389e-01f, -4.51175794e-02f, -2.90529095e-02f, -1.68020725e-01f, 1.26585951e-02f, -1.72783241e-01f, -6.32829443e-02f,
  3.56163308e-02f, 1.97386995e-01f, -1.37341976e-01f, -1.58283990e-02f, 7.49105960e-02f, -7.30777206e-03f, 3.97602990e-02f, -9.71539170e-02f, -7.18716905e-02f, -1.09755263e-01f,
  -1.36408731e-01f, 6.75404593e-02f, -1.76670533e-02f, 1.02047347e-01f, -1.78819343e-01f, 1.09195327e-02f, 1.09614916e-01f, -2.43933890e-02f, -9.95412171e-02f, 9.87878069e-02f,
  -2.60197699e-01f, 9.54008475e-02f, 2.88246095e-01f, -2.56856102e-02f, -5.53003103e-02f, 9.52484608e-02f, 6.16043136e-02f, 1.15769625e-01f, -2.25954369e-01f, -1.52005479e-02f,
  2.40990110e-02f, 1.27286445e-02f, 3.77544425e-02f, 9.10989270e-02f, -9.71935987e-02f, 1.23628184e-01f, -1.03389598e-01f, -4.60924767e-02f, 1.46871865e-01f, 1.11866765e-01f,
  -1.44778972e-03f, -6.52489364e-02f, 1.00420574e-02f, 5.26937321e-02f, -1.83432415e-01f, 2.43236959e-01f, 6.69614375e-02f, 6.54217377e-02f, 1.12602606e-01f, 1.19617619e-01f,
  3.10117938e-02f, 1.14389047e-01f, 1.25173599e-01f, 1.64466649e-02f, -1.71645001e-01f, -1.07759111e-01f, -3.81892808e-02f, -1.10488683e-01f, 6.82615191e-02f, -9.49075352e-03f,
  1.67092502e-01f, -1.11271404e-02f, 5.01305126e-02f, -2.44844618e-04f, -1.77050933e-01f, -7.89554268e-02f, -6.96883500e-02f, 2.31409888e-03f, -8.34221840e-02f, 1.37704864e-01f,
  3.62404287e-02f, 9.04464051e-02f, 1.50897041e-01f, -3.23902741e-02f, 3.06442436e-02f, 1.59023907e-02f, -1.35840045e-03f, 1.58611432e-01f, -1.94685295e-01f, -7.81823546e-02f,
  -1.06914729e-01f, 9.15738121e-02f, 1.13054313e-01f, -1.05512917e-01f, -2.49135330e-01f, 1.43472135e-01f, -7.27131963e-02f, -3.86302382e-01f, 7.82578066e-02f, -1.17901601e-01f,
  -6.91955090e-02f, -7.80966058e-02f, -8.01672637e-02f, 2.94661969e-02f, 3.53316069e-02f, -2.43935566e-02f, 1.12060430e-02f, -1.49036571e-01f, 1.97502628e-01f, 1.86000869e-01f,
  -1.24253906e-01f, 1.85625143e-02f, 1.38300091e-01f, 1.07647568e-01f, 1.33629441e-01f, -1.96186438e-01f, -8.70479345e-02f, -4.90593277e-02f, -8.62003712e-04f, 8.29576626e-02f,
  9.48733650e-03f, -2.47026071e-01f, -1.43105194e-01f, -1.04208335e-01f, 8.91775414e-02f, 1.84105884e-03f, -1.62300736e-01f, 1.45001158e-01f, 3.04923207e-02f, 1.09415807e-01f,
  1.08743191e-01f, 1.82634115e-01f, 1.78122580e-01f, 2.33475231e-02f, -1.25465691e-01f, -9.53827277e-02f, 1.16617039e-01f, -1.67263269e-01f, -1.02026135e-01f, 1.82418957e-01f,
  -8.26340839e-02f, -1.22722842e-01f, -1.57558203e-01f, -1.32448092e-01f, -1.06087886e-01f, -1.34346932e-01f, -2.10794479e-01f, -1.66107461e-01f, -2.88522337e-02f, 3.03705707e-02f,
  7.64340488e-03f, 3.95275317e-02f, 2.58640088e-02f, 2.26599246e-01f, 1.13013983e-01f, 9.81584713e-02f, -2.73255467e-01f, 1.46217821e-02f, 3.93329382e-01f, -1.35485709e-01f,
  -1.21820778e-01f, 3.55159730e-01f, -1.11833364e-01f, -9.69820004e-03f, -2.50323713e-02f, -7.72982463e-02f, 7.67720863e-02f, 1.22346571e-02f, 9.39080939e-02f, -1.27358409e-03f,
  -1.68337122e-01f, 5.80431260e-02f, -1.26930878e-01f, -1.48597313e-02f, 3.07643898e-02f, -8.22493583e-02f, -1.43585980e-01f, 1.90200120e-01f, -1.48281202e-01f, 3.16233411e-02f,
  4.24993560e-02f, 1.02083541e-01f, -5.66734113e-02f, -1.65803745e-01f, 2.17934940e-02f, 1.15366049e-01f, 1.38410956e-01f, -1.00383051e-01f, 1.22709073e-01f, -2.43520550e-02f,
  -1.09801712e-02f, -2.13280961e-01f, -2.51843706e-02f, -8.84033181e-03f, 5.01032686e-03f, -8.39377269e-02f, -1.22019753e-01f, 4.04357277e-02f, -2.12991182e-02f, 1.00876749e-01f,
  -9.76505801e-02f, -8.41471851e-02f, -6.05535731e-02f, -1.43667638e-01f, -1.92518532e-01f, -6.23971298e-02f, 1.09562159e-01f, 2.00402990e-01f, 6.23992458e-02f, 1.85405210e-01f,
  1.14182550e-02f, 1.95665192e-02f, 2.47187894e-02f, 7.43209326e-04f, 3.15212421e-02f, -9.13674906e-02f, 8.99317339e-02f, -1.75307617e-01f, 4.46331948e-02f, -1.20013863e-01f,
  -8.32831115e-02f, -9.57433581e-02f, -1.83788985e-02f, -1.48532018e-01f, -2.26710260e-01f, -6.64109513e-02f, 3.53320912e-02f, -1.98808730e-01f, 1.83077395e-01f, -6.67955801e-02f,
  8.31165090e-02f, 1.87996805e-01f, -4.70341109e-02f, -6.86421525e-03f, 2.22911298e-01f, 4.78883721e-02f, 3.22509468e-01f, 2.29176223e-01f, -1.54173210e-01f, -8.99823382e-02f,
  1.58970207e-01f, -1.54772997e-01f, -1.85094327e-01f, 2.46693138e-02f, -9.67315584e-02f, 1.40451342e-01f, 3.69886681e-02f, -4.70616706e-02f, -1.33197280e-02f, -1.34360433e-01f,
  -1.19610153e-01f, -1.38457850e-01f, -3.38361822e-02f, -3.41837071e-02f, -4.53337422e-03f, 1.56084225e-01f, 2.98698470e-02f, 1.78895801e-01f, 1.82043418e-01f, 1.69912353e-01f,
  1.50539830e-01f, 1.77299529e-01f, -1.21429309e-01f, -1.05907731e-01f, 1.37888879e-01f, -6.70111999e-02f, 3.18611565e-04f, -7.91604072e-02f, 2.11694956e-01f, -1.31694973e-02f,
  8.81791487e-02f, -1.59500748e-01f, -3.95731367e-02f, -1.00735433e-01f, -5.61491735e-02f, -1.23543449e-01f, -1.55300284e-02f, 4.67953831e-02f, 3.11266035e-02f, -1.07381053e-01f,
  4.34027798e-02f, -6.52861074e-02f, -1.36799738e-02f, -1.20587982e-01f, -9.88621712e-02f, -1.23130195e-01f, -2.45284170e-01f, 9.55332816e-02f, -2.91130424e-01f, -1.08656526e-01f,
  -1.07672242e-02f, 9.49566290e-02f, -5.72169162e-02f, -9.16063115e-02f, 1.63972378e-01f, -7.81232342e-02f, 1.41500443e-01f, 8.79230164e-03f, 3.11502926e-02f, 9.17403921e-02f,
  2.89007843e-01f, 9.99949574e-02f, -1.50447451e-02f, -2.66013712e-01f, -1.37057165e-02f, 2.59979993e-01f, -1.15524888e-01f, -6.05118647e-02f, 7.22637922e-02f, 1.62586533e-02f,
  -7.90358633e-02f, 8.17397162e-02f, -2.39998028e-01f, -5.19049726e-02f, -1.66640624e-01f, 1.64201245e-01f, 1.16568297e-01f, 7.53946789e-03f, 2.60188002e-02f, 7.33153895e-02f,
  7.96726346e-02f, -2.93926522e-02f, -4.23873402e-02f, 9.15903449e-02f, 2.16542650e-02f, -1.32874802e-01f, -1.27997875e-01f, -2.01759517e-01f, 6.08643517e-03f, -5.99683262e-02f,
  4.71928343e-02f, -9.65339318e-02f, -3.49907465e-02f, 6.03384413e-02f, 1.53507352e-01f, 5.48482919e-03f, 1.83814526e-01f, -8.01798403e-02f, -7.39404187e-03f, -1.94052793e-02f,
  9.65156108e-02f, -2.59308703e-02f, 5.44746816e-02f, -1.63933426e-01f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.37633845e-01f, -5.53371571e-03f, -7.92186931e-02f, 2.75085837e-01f, 2.25510478e-01f, 1.82307631e-01f, 8.25934112e-02f, -1.69491410e-01f, 2.23202199e-01f, -5.91684766e-02f,
  -1.18920788e-01f, -6.44503087e-02f, -5.06218011e-03f, 8.86005536e-02f, -2.03840107e-01f, 2.77632654e-01f, 1.42907193e-02f, 4.30322327e-02f, -3.17109793e-01f, -8.51278156e-02f,
  -5.52038364e-02f, 4.38182205e-02f, 5.96570782e-02f, 1.47405759e-01f, 1.57775462e-01f, -3.20876479e-01f, 1.72656193e-01f, 2.01486722e-01f, 1.60261676e-01f, 8.41506757e-03f,
  7.17752352e-02f, 1.81675274e-02f, 1.82425767e-01f, -1.62603796e-01f, 2.91350912e-02f, -2.71600969e-02f, 6.27233610e-02f, -8.05116668e-02f, 1.29231021e-01f, 2.82583218e-02f,
  1.98974356e-01f, 1.01243198e-01f, -1.34985611e-01f, 7.98008293e-02f, -1.05271209e-02f, -3.21271196e-02f, 1.32731929e-01f, -2.48600885e-01f, -2.68045105e-02f, 2.77694792e-01f,
  1.86973408e-01f, 8.48544389e-02f, 1.46137819e-01f, 3.55376154e-02f, -2.88806766e-01f, -1.34095669e-01f, 1.76751185e-02f, -4.86564673e-02f, 2.20965326e-01f, -3.68479975e-02f,
  -1.24183886e-01f, -1.29971638e-01f, 3.91705371e-02f, -1.64578676e-01f, -7.39125116e-03f, 1.71620145e-01f, 7.02313483e-02f, 6.13793507e-02f, -9.24321488e-02f, 1.24534853e-02f,
  4.25994359e-02f, 5.30272573e-02f, -1.08081415e-01f, -2.50830144e-01f, 6.62182271e-02f, 1.10037867e-02f, 2.04103127e-01f, 7.43036866e-02f, 1.20320775e-01f, -1.93786219e-01f,
  -1.01234280e-02f, 1.85574144e-01f, 3.42271626e-02f, 5.90573177e-02f, -2.56828610e-02f, -8.73324573e-02f, 2.35907301e-01f, -6.54584840e-02f, 3.45245600e-02f, 1.02566242e-01f,
  -1.10382564e-01f, -6.02612011e-02f, 9.40223504e-03f, -9.51103941e-02f, -3.18130329e-02f, -1.86890990e-01f, 2.97821090e-02f, -1.56063884e-01f, -7.19042048e-02f, -9.78461001e-03f,
  -1.16785057e-01f, 3.03408474e-01f, -7.33123049e-02f, -3.44687030e-02f, -4.19996008e-02f, 7.35300332e-02f, 1.46350250e-01f, 1.02192566e-01f, 4.81512919e-02f, -2.56749010e-03f,
  -1.68535829e-01f, 1.19725414e-01f, 2.66124368e-01f, -1.57782994e-02f, 2.41239905e-01f, 8.81411359e-02f, 2.66734302e-01f, 2.17277974e-01f, 1.76429272e-01f, 7.58072585e-02f,
  -1.27434775e-01f, -5.26649132e-02f, -1.12729043e-01f, 4.18303758e-02f, 2.00991333e-01f, 1.29836172e-01f, -1.81351364e-01f, 2.54176348e-01f, -9.53249410e-02f, 3.22138257e-02f,
  6.52299554e-04f, -8.20100605e-02f, -1.26637504e-01f, 9.43919495e-02f, 1.45676032e-01f, 1.34354547e-01f, 1.73412547e-01f, 1.77417770e-02f, 1.11497827e-02f, -1.28132895e-01f,
  -4.38469797e-02f, 1.77238323e-02f, 2.91689280e-02f, 7.45552480e-02f, -1.24840401e-01f, 1.59812719e-01f, -1.13164835e-01f, -1.16793476e-02f, -1.39776710e-02f, 5.73655181e-02f,
  -1.73870996e-01f, 6.30454868e-02f, 9.83954817e-02f, -7.94939771e-02f, 1.01991504e-01f, 1.45140037e-01f, -3.62697542e-02f, 2.51523349e-02f, -5.03208116e-02f, 5.49054109e-02f,
  1.31765351e-01f, 5.42823300e-02f, 1.88340142e-01f, 9.09183398e-02f, -1.31325305e-01f, -1.08162630e-02f, 1.27359614e-01f, 8.32770839e-02f, 1.39629051e-01f, -8.48365948e-02f,
  -1.71789303e-01f, -1.37131333e-01f, -2.29510609e-02f, -2.07537698e-04f, 3.03235710e-01f, 2.81622056e-02f, 4.66020852e-02f, 8.81166756e-02f, -1.65456422e-02f, -2.64423132e-01f,
  -7.30171204e-02f, -1.81383967e-01f, -9.02505293e-02f, 3.52983624e-02f, 1.02400586e-01f, -1.43736482e-01f, 1.94933265e-01f, -1.75508037e-01f, 7.61839524e-02f, 6.50222227e-02f,
  -6.73398599e-02f, -6.96516186e-02f, 2.45167986e-01f, -2.37132788e-01f, -1.54782221e-01f, 1.49641275e-01f, 3.19198743e-02f, 2.32824877e-01f, 7.24816173e-02f, -1.00735873e-01f,
  -1.57144263e-01f, 2.68943191e-01f, -1.21448934e-02f, -1.21079691e-01f, -1.95682272e-02f, -3.55186969e-01f, 1.39461234e-01f, 2.00839326e-01f, -1.31697562e-02f, -1.33235678e-01f,
  -1.25879437e-01f, -4.69279587e-02f, 1.22923173e-01f, -2.42554359e-02f, 9.57091153e-03f, -1.50427902e-02f, 4.58919629e-02f, -2.25493070e-02f, 1.10405963e-02f, 1.10553719e-01f,
  6.78231269e-02f, 1.87424064e-01f, -2.88708135e-02f, -6.19045384e-02f, 1.08510526e-02f, -2.54262127e-02f, -2.10127532e-01f, -9.73539874e-02f, -9.06518009e-03f, -2.12829068e-01f,
  8.16265121e-02f, -2.34465957e-01f, 1.08366303e-01f, 2.22157657e-01f, -2.10069433e-01f, 1.19759738e-01f, 6.42046556e-02f, -5.16656190e-02f, 1.05190061e-01f, -3.70256677e-02f,
  -8.23965520e-02f, -6.81325048e-02f, 1.12251021e-01f, -1.99877188e-01f, -4.58273105e-02f, 6.79870844e-02f, 8.33156258e-02f, 1.22782573e-01f, 1.44399449e-01f, -1.03536680e-01f,
  8.60370621e-02f, 9.65941511e-03f, -5.84670044e-02f, -8.10735524e-02f, 2.81044841e-02f, -4.28145081e-01f, -1.55841842e-01f, -2.20462784e-01f, 3.54311205e-02f, 1.98051244e-01f,
  1.28389135e-01f, 1.16741195e-01f, 4.59355004e-02f, -5.39636575e-02f, -1.22740880e-01f, 1.66671619e-01f, -2.55653530e-01f, -7.64166936e-02f, 8.03350508e-02f, 1.52787864e-01f,
  -9.44254100e-02f, 4.37728703e-01f, -1.74181163e-02f, 1.23425387e-01f, 2.33984217e-02f, -2.77193356e-02f, 6.67565092e-02f, -2.26946414e-01f, 1.44082978e-01f, -1.38032436e-01f,
  -9.60720256e-02f, -3.63511235e-01f, 1.34356141e-01f, 1.02247380e-01f, -6.98582530e-02f, 2.47654200e-01f, 1.98941514e-01f, 1.51692927e-01f, 3.79225723e-02f, -1.52695552e-01f,
  1.24668047e-01f, 1.08544305e-01f, 1.96771845e-01f, 3.38455141e-02f, -1.71185359e-01f, 4.22771499e-02f, -2.15940047e-02f, -1.39539033e-01f, 9.85062346e-02f, -5.81745990e-02f,
  6.55713603e-02f, 1.42669663e-01f, 3.92776281e-01f, 1.34955823e-01f, -1.10681280e-01f, 1.52423337e-01f, -5.21192094e-03f, 1.25558376e-01f, 2.46868595e-01f, 1.49101615e-01f,
  -6.21711686e-02f, -7.04296166e-03f, -2.45372579e-01f, 1.99700728e-01f, 1.20725662e-01f, -2.05560938e-01f, -2.10214928e-02f, -1.51603371e-01f, 1.70344219e-01f, 3.12726274e-02f,
  3.28192294e-01f, -9.06966701e-02f, 8.93491358e-02f, -3.88420284e-01f, -4.03035313e-01f, 9.37358215e-02f, 1.10184699e-02f, -9.93187577e-02f, -3.51343215e-01f, 2.53197551e-01f,
  1.12410218e-01f, -9.69663411e-02f, 1.90569982e-01f, -1.87720448e-01f, 4.84141819e-02f, 2.23224208e-01f, 7.40087999e-04f, -8.15007463e-02f, 5.15647978e-02f, 6.40030280e-02f,
  4.05969732e-02f, 5.54565825e-02f, 2.24429220e-02f, -3.50693882e-01f, -1.77736551e-01f, 1.31313456e-02f, 1.13946572e-01f, 1.04317576e-01f, 1.25887334e-01f, 5.48862666e-02f,
  1.79530680e-01f, -5.64946607e-02f, -1.76741064e-01f, -2.69321948e-01f, -1.52694946e-02f, -2.36863922e-02f, 4.12603877e-02f, -2.21239164e-01f, 2.67137378e-03f, 1.09951431e-02f,
  -1.26486644e-02f, 5.37830628e-02f, 2.28955969e-03f, 1.27321377e-01f, 1.26158688e-02f, -2.31592380e-03f, -5.27758989e-03f, 2.69237510e-03f, 7.68171847e-02f, 2.50419956e-02f,
  9.93345380e-02f, -1.16189964e-01f, 2.06041932e-01f, 1.42886847e-01f, 1.62962317e-01f, 2.94409189e-02f, 5.45625873e-02f, -3.46046798e-02f, -1.17232345e-01f, -1.73230674e-02f,
  7.34630972e-02f, -6.76383525e-02f, 1.48406968e-01f, -3.07265490e-01f, 8.85114744e-02f, 2.86797166e-01f, -1.63599961e-02f, 1.05580419e-01f, 2.57631004e-01f, -4.67393361e-02f,
  -7.13907778e-02f, 6.95531722e-04f, 3.76299210e-02f, -3.09780091e-01f, 3.89111280e-01f, 2.62135983e-01f, 5.28133847e-02f, -1.08179733e-01f, -2.05603731e-03f, 1.05594061e-01f,
  1.53281406e-01f, 1.22738913e-01f, -6.32982105e-02f, -3.56197208e-02f, 1.69193923e-01f, -2.91361995e-02f, -5.58804758e-02f, 3.84632230e-01f, -1.12681307e-01f, 2.56336600e-01f,
  3.20883811e-01f, -1.39278620e-01f, -4.62521054e-02f, -1.77047729e-01f, 3.59612145e-02f, 2.01266140e-01f, -1.97199285e-02f, -1.17067896e-01f, 2.08095219e-02f, 6.23114705e-02f,
  -6.10445738e-02f, 1.48591638e-01f, 2.52041966e-02f, -1.90461725e-01f, -3.28517854e-02f, 1.54930592e-01f, 2.13923946e-01f, 8.46249834e-02f, -2.66533401e-02f, 2.45957643e-01f,
  -1.99995533e-01f, -9.95009169e-02f, -3.20769213e-02f, 2.92470038e-01f, 5.78791201e-02f, 2.71794468e-01f, 2.62824059e-01f, 1.18595719e-01f, 6.92002773e-02f, -1.96880087e-01f,
  1.05655961e-01f, -3.61794718e-02f, -1.21801913e-01f, 2.72228032e-01f, -1.43686775e-02f, 2.49044150e-01f, 7.93212745e-03f, -1.39748022e-01f, 8.98699835e-02f, -5.80088054e-05f,
  2.98633985e-02f, 1.57150522e-01f, -1.34404570e-01f, -7.54767191e-03f, 1.74530342e-01f, -2.00989872e-01f, 3.03409934e-01f, 1.20448403e-01f, -2.80844599e-01f, -2.40468934e-01f,
  -3.79762123e-03f, 2.50270627e-02f, -1.38839468e-01f, -8.51661637e-02f, -9.35691968e-02f, -2.95867268e-02f, -9.66746882e-02f, -1.36040092e-01f, 2.65961811e-02f, 1.58668996e-03f,
  3.12629849e-01f, 4.52384725e-02f, -1.89904217e-02f, -4.52413596e-03f, -2.97522515e-01f, 2.17006221e-01f, 2.03763753e-01f, 3.71615231e-01f, 1.99850947e-01f, -2.63259411e-01f,
  2.70979941e-01f, 1.71338826e-01f, -1.41443223e-01f, -4.50747162e-02f, -2.11811244e-01f, -3.67958210e-02f, 2.09526032e-01f, -1.70128345e-01f, 2.71780282e-01f, 1.26113683e-01f,
  -1.57598838e-01f, -9.88208055e-02f, 5.98482750e-02f, 8.33147839e-02f, 8.59524682e-02f, 2.69499272e-01f, -1.48425698e-01f, 2.52727251e-02f, 2.25437477e-01f, 8.92872270e-03f,
  -1.39235258e-01f, -6.07702369e-03f, 7.57978410e-02f, 1.61107346e-01f, 7.47750103e-02f, 7.89916143e-02f, 7.23135024e-02f, 1.05556674e-01f, 1.66949943e-01f, 8.38801172e-03f,
  4.41455208e-02f, 5.42005822e-02f, 8.96752551e-02f, -5.56375794e-02f, -1.76339865e-01f, 4.08403357e-05f, 3.21401879e-02f, -1.29381061e-01f, -9.51880217e-03f, 3.79484780e-02f,
  -7.44489804e-02f, -3.88403654e-01f, 1.02747850e-01f, -2.10330471e-01f, 1.19482018e-01f, 7.38768205e-02f, -2.42619827e-01f, -1.87016919e-01f, 6.79830015e-02f, 1.51119888e-01f,
  2.47082412e-02f, -2.42659509e-01f, -1.92882016e-01f, 2.18308404e-01f, -3.82145196e-02f, 2.34652549e-01f, -1.20648984e-02f, -1.09554067e-01f, -1.12849977e-02f, -4.81583215e-02f,
  4.78812493e-02f, -2.21928269e-01f, -2.05486700e-01f, -1.66051418e-01f, -3.30086797e-02f, -3.49424213e-01f, -1.07742108e-01f, -1.80743560e-02f, 1.98764540e-02f, 1.69437855e-01f,
  2.04000529e-03f, -1.33531183e-01f, 1.33199528e-01f, -4.63049710e-02f, 1.67206585e-01f, 1.14885695e-01f, -1.80645406e-01f, 1.35848477e-01f, -2.41115734e-01f, 3.83799779e-03f,
  -4.22136076e-02f, -2.69176006e-01f, 3.17567468e-01f, 1.68726712e-01f, 8.41859579e-02f, 2.00882442e-02f, -1.62676051e-01f, 2.33881567e-02f, -2.48354450e-01f, -1.27787799e-01f,
  -2.50295818e-01f, -6.30347282e-02f, -2.93433834e-02f, 3.02535057e-01f, -3.60144049e-01f, 1.46069199e-01f, -7.30723217e-02f, 1.57947317e-01f, 2.26350009e-01f, 2.07044948e-02f,
  1.44742340e-01f, 3.80520821e-02f, 1.07641732e-02f, 2.00595409e-01f, -6.94495114e-03f, -1.60792232e-01f, 1.46123722e-01f, 1.08075932e-01f, 3.20428535e-02f, 1.82410106e-01f,
  -5.99020347e-02f, -1.91477299e-01f, 9.17792469e-02f, 2.21331462e-01f, 1.67856757e-02f, 1.24989256e-01f, -2.74372548e-02f, -1.00542873e-01f, 1.31337196e-01f, 2.22567916e-02f,
  -1.38196543e-01f, 2.38928739e-02f, 4.51427817e-01f, -9.36745852e-02f, -1.62113667e-01f, -1.37549462e-02f, -3.03705484e-02f, 8.03196952e-02f, 9.44948103e-03f, 9.00307447e-02f,
  4.41378891e-01f, 1.61219284e-01f, 1.48500770e-01f, 2.16389358e-01f, -5.07754646e-02f, 1.39232919e-01f, 2.13013496e-02f, -2.35890120e-01f, 7.35814795e-02f, -9.22121480e-02f,
  -1.23486899e-01f, -7.99436867e-02f, 7.30122626e-02f, 2.69589424e-01f, -4.61460315e-02f, 2.01793090e-01f, -1.06264099e-01f, 2.27295250e-01f, 1.19471230e-01f, 3.14304590e-01f,
  8.35585594e-02f, 2.49694228e-01f, -1.25268593e-01f, 4.08703655e-01f, -5.02010770e-02f, 1.06153987e-01f, -3.16507295e-02f, -7.39949495e-02f, -1.02348648e-01f, 2.68540531e-01f,
  -6.04727045e-02f, 1.08802468e-01f, -2.42372453e-02f, 2.01384872e-01f, 9.47387591e-02f, 3.14358622e-02f, 5.57252504e-02f, -6.43184334e-02f, -6.88940240e-03f, -1.91604570e-01f,
  -1.71912700e-01f, 7.28554726e-02f, -8.03207383e-02f, 3.02785546e-01f, 2.08500456e-02f, 1.55774951e-01f, -6.86904090e-03f, 1.58447683e-01f, 8.42457730e-03f, 2.44736560e-02f,
  -8.44790116e-02f, -8.66364539e-02f, 1.56902641e-01f, 1.66350737e-01f, 1.56406492e-01f, -2.76602715e-01f, 1.11011080e-01f, -8.50980952e-02f, -4.98126149e-02f, -2.41668299e-01f,
  1.41914114e-01f, -3.89789566e-02f, 1.62716899e-02f, -2.95140948e-02f, 1.93184882e-01f, -4.25926819e-02f, 1.60030752e-01f, 2.67675847e-01f, -2.87869871e-01f, 1.89788356e-01f,
  -1.76257849e-01f, 1.11165307e-01f, 1.68713525e-01f, 1.27946451e-01f, 2.92416010e-02f, 1.11881301e-01f, 1.48856333e-02f, -5.19290566e-02f, 3.83781679e-02f, -4.96819690e-02f,
  7.35251456e-02f, 2.61843085e-01f, 1.69639528e-01f, 1.61971271e-01f, -8.45169276e-02f, -1.61344618e-01f, -1.76066115e-01f, 1.03363164e-01f, -6.59796968e-02f, 9.76628624e-03f,
  1.61309503e-02f, -2.00518835e-02f, -4.78156023e-02f, 2.24106655e-01f, -1.46699697e-01f, -9.82281938e-03f, 9.38917547e-02f, 1.24514528e-01f, 3.44496849e-03f, 5.71716204e-02f,
  -1.38551578e-01f, 1.95431337e-01f, 4.92980815e-02f, -2.09592775e-01f, -1.68970570e-01f, -4.03175429e-02f, 6.72572702e-02f, 3.32675159e-01f, -3.04471757e-02f, -7.34803081e-02f,
  2.12942466e-01f, 2.11489812e-01f, -2.07911502e-03f, 7.44659826e-02f, 1.56088378e-02f, -1.66777343e-01f, 1.68504879e-01f, 4.80515361e-02f, -3.69039476e-02f, 1.00976285e-02f,
  3.93962741e-01f, -2.75141336e-02f, -1.46904245e-01f, -1.75301284e-01f, 1.68232590e-01f, 1.33040190e-01f, -1.49004295e-01f, -4.71990071e-02f, 3.58179957e-01f, 2.16204435e-01f,
  3.40688974e-01f, 6.43018410e-02f, -2.16605484e-01f, 1.20316662e-01f, -7.29220137e-02f, -2.28239283e-01f, 6.35950416e-02f, 4.97624129e-02f, -1.66829806e-02f, 1.08775413e-02f,
  6.83719516e-02f, 1.62144184e-01f, 4.84594442e-02f, -9.78687257e-02f, -2.66894698e-03f, 2.36795545e-01f, 1.99508086e-01f, 1.29573733e-01f, 2.21808460e-02f, 2.30369747e-01f,
  -5.71542494e-02f, 3.77194256e-01f, -2.13376563e-02f, 4.12351415e-02f, 1.26969904e-01f, -2.77557075e-02f, 4.46837656e-02f, 2.54168928e-01f, 5.17097749e-02f, 5.79764955e-02f,
  2.33823620e-02f, 2.29900368e-02f, 4.76189256e-02f, -9.61496383e-02f, -8.45147371e-02f, -1.37553969e-02f, 2.86509283e-02f, 1.10381052e-01f, 1.00853942e-01f, 9.68803763e-02f,
  9.46649015e-02f, -8.87985602e-02f, -1.65418237e-01f, 3.04047316e-01f, 1.30784780e-01f, -1.60419926e-01f, -1.29525900e-01f, 7.01382756e-02f, 1.52979285e-01f, 3.68883125e-02f,
  5.67502826e-02f, 1.08064860e-02f, -2.05685899e-01f, 1.69190615e-01f, -2.30779294e-02f, -1.57914981e-01f, 1.60761788e-01f, -5.40381297e-02f, 1.61923513e-01f, 1.25592023e-01f,
  -1.75290946e-02f, 9.76953730e-02f, 1.36689134e-02f, 7.28858961e-03f, 5.95553145e-02f, -1.88305318e-01f, 1.23989815e-02f, -2.32117251e-01f, 2.13849828e-01f, 3.33107769e-01f,
  8.48857462e-02f, 1.70662463e-01f, -1.00785248e-01f, -2.01915391e-02f, -3.55042845e-01f, -8.00718963e-02f, -8.71601105e-02f, 1.29393488e-01f, 7.11916089e-02f, 1.08844079e-01f,
  1.96566164e-01f, 2.31365740e-01f, 3.40551019e-01f, 4.54302244e-02f, 1.28369138e-01f, -5.29559292e-02f, -1.40111297e-01f, 2.42458001e-01f, -1.40402973e-01f, -1.33428618e-01f,
  2.71530449e-01f, -1.62779465e-01f, 5.54705858e-02f, 4.83551994e-02f, 1.33365137e-03f, -9.92611051e-02f, 7.37372488e-02f, -1.10290892e-01f, -1.66800261e-01f, -1.10365793e-01f,
  1.11328177e-01f, 1.41581550e-01f, -1.48070768e-01f, 1.51838765e-01f, 6.99508702e-04f, 2.73951888e-01f, 7.41398111e-02f, -1.09279804e-01f, 2.13471994e-01f, 1.90994754e-01f,
  1.05751753e-01f, 7.26294443e-02f, -1.24612413e-01f, -1.41907101e-02f, 1.70619488e-01f, -3.56822729e-01f, -3.19239609e-02f, 1.83697954e-01f, -7.82192498e-02f, -2.17157945e-01f,
  -1.53114229e-01f, 1.81146041e-01f, 9.31264609e-02f, 3.91132385e-02f, 5.43526039e-02f, 1.74053073e-01f, 1.91519320e-01f, 1.45412505e-01f, 7.56446868e-02f, 1.67557254e-01f,
  8.83595943e-02f, 1.19039647e-01f, -1.54136652e-02f, -2.79904962e-01f, -2.89955940e-02f, -1.31132215e-01f, 1.90980565e-02f, -1.35031477e-01f, -1.82053164e-01f, 2.15032801e-01f,
  -5.39047308e-02f, -1.83092873e-03f, 2.26381943e-02f, 1.16090640e-01f, 1.26555175e-01f, 2.85138369e-01f, 9.88522023e-02f, 8.98502171e-02f, -1.14061147e-01f, 3.81919146e-01f,
  7.89086744e-02f, 3.64628881e-02f, 1.06078580e-01f, 1.38729319e-01f, 2.52544492e-01f, 2.99056768e-01f, 3.68707888e-02f, -1.32697076e-01f, -1.67301521e-01f, 1.16815776e-01f,
  -4.92492765e-02f, 1.70976773e-01f, -1.59232378e-01f, 3.46010202e-03f, -2.14279175e-01f, 3.49058956e-01f, -2.51933992e-01f, -5.19741252e-02f, -9.99789238e-02f, 1.11290969e-01f,
  1.17721342e-01f, 4.28842425e-01f, -9.15721506e-02f, 5.66994175e-02f, -2.76685148e-01f, 1.72030747e-01f, 6.38359785e-02f, -1.41889364e-01f, 1.20194897e-01f, -1.09604433e-01f,
  -1.10869460e-01f, -4.86746468e-02f, 7.10253492e-02f, 1.87903553e-01f, 1.32858474e-02f, 1.43938854e-01f, 8.64067376e-02f, 1.34479553e-01f, -4.78541590e-02f, 4.41196188e-03f,
  1.83892995e-01f, 2.82881949e-02f, 3.61999154e-01f, -8.68141949e-02f, -1.91301238e-02f, -6.56568035e-02f, -1.85087677e-02f, 8.36134255e-02f, 4.35391925e-02f, 8.40206593e-02f,
  3.77322324e-02f, 9.16546062e-02f, 2.26357520e-01f, -8.59460607e-03f, -1.12985782e-01f, -7.22582964e-03f, -1.00118183e-01f, -7.94706400e-03f, -8.89508054e-02f, 9.92892981e-02f,
  2.46326588e-02f, 1.60001740e-01f, -1.63025439e-01f, 3.37919593e-01f, 9.80867818e-02f, -1.41318023e-01f, -1.06562220e-01f, -1.92425907e-01f, 1.76182285e-01f, -1.33578867e-01f,
  9.00553837e-02f, -4.69909087e-02f, -6.16434515e-02f, 8.80687684e-03f, 4.57488745e-02f, -7.52524137e-02f, -4.76754047e-02f, 2.14178681e-01f, 1.11990042e-01f, -3.92194301e-01f,
  1.39892131e-01f, -1.09430306e-01f, -2.44193859e-02f, 1.08776934e-01f, -9.68968719e-02f, -1.80682868e-01f, 1.50777116e-01f, 1.28792331e-01f, 6.76478073e-02f, -1.85873196e-01f,
  -1.22343503e-01f, 2.00815558e-01f, 9.23732072e-02f, 1.83602452e-01f, -7.07610324e-02f, -1.06172904e-01f, 1.52219728e-01f, -1.81394015e-02f, -3.59777845e-02f, -1.65554583e-01f,
  -2.46289447e-01f, -3.59424725e-02f, -2.04053801e-02f, -3.22908342e-01f, -1.14275895e-01f, -1.23859145e-01f, -6.17493130e-02f, 9.87335443e-02f, 1.70161258e-02f, -1.37503281e-01f,
  -3.69544923e-02f, -1.02044167e-02f, 1.87552944e-01f, -3.24257463e-02f, 1.50450775e-02f, 6.91016838e-02f, -1.94171548e-01f, 5.25734797e-02f, -4.65614758e-02f, -2.08873034e-01f,
  1.17122091e-01f, 4.52031046e-02f, -5.21022715e-02f, -7.33853830e-03f, -8.50633755e-02f, 2.23779539e-03f, -1.83282375e-01f, 1.19741581e-01f, -3.53351802e-01f, -5.77653795e-02f,
  -1.20803394e-04f, 2.24965930e-01f, -9.92988497e-02f, 1.48082897e-01f, 1.79437310e-01f, -1.01059273e-01f, 8.11936110e-02f, 2.10787490e-01f, -2.70874977e-01f, 1.68350730e-02f,
  2.85087496e-01f, -3.19044322e-01f, 1.96666084e-02f, 1.27199858e-01f, -2.26704210e-01f, -9.98412222e-02f, -4.30598520e-02f, -6.51326105e-02f, -9.06069577e-02f, 1.65285319e-02f,
  4.49714949e-03f, -1.87967054e-03f, -2.60133684e-01f, -2.11714476e-01f, -5.30129261e-02f, 1.04339205e-01f, 8.71877447e-02f, 1.09885216e-01f, 1.16383970e-01f, -2.90846042e-02f,
  -2.70076990e-01f, 2.35029340e-01f, 3.47112060e-01f, 8.01511034e-02f, -5.38030313e-03f, -2.37488240e-01f, 2.27690786e-01f, -1.46167830e-01f, 2.09716670e-02f, -8.83486960e-03f,
  -3.74198183e-02f, -3.16762552e-02f, 1.58402398e-01f, -1.99951053e-01f, 3.35927576e-01f, 8.80818535e-03f, -2.35081501e-02f, -1.01941884e-01f, 9.55692753e-02f, -4.39516008e-02f,
  1.39542833e-01f, 1.01363167e-01f, -3.95581536e-02f, 1.58400536e-01f, 2.51498729e-01f, 1.01400264e-01f, 7.99653381e-02f, 1.75783783e-01f, 2.90189087e-02f, 2.40855683e-02f,
  -9.65535566e-02f, 1.99247152e-02f, 6.52737916e-02f, 1.19843997e-01f, 1.05867192e-01f, 1.37175962e-01f, 1.24040641e-01f, -1.26205012e-01f, 1.42227888e-01f, 2.23262087e-01f,
  1.05929598e-01f, -5.19540645e-02f, -1.21576246e-02f, -6.52870610e-02f, -2.25375146e-01f, -9.59979221e-02f, -9.77023388e-04f, 1.11683607e-01f, -1.70182027e-02f, 8.08603019e-02f,
  -1.08733490e-01f, -7.35627161e-03f, 1.82124525e-01f, 1.01464450e-01f, -6.84286132e-02f, 1.56266212e-01f, -4.71514799e-02f, 6.76584840e-02f, 9.68756974e-02f, 1.07049897e-01f,
  1.70743942e-01f, 1.76827878e-01f, 1.31441757e-01f, 3.01325142e-01f, -1.65766358e-01f, 3.87811884e-02f, 2.13221416e-01f, -1.42331123e-01f, -5.91988154e-02f, -6.27095103e-02f,
  1.09759971e-01f, 3.29486728e-02f, -2.01814249e-01f, 5.95556311e-02f, 5.54701649e-02f, 1.21225975e-01f, 1.36083588e-01f, -8.89892131e-02f, 2.27501154e-01f, 2.05334485e-01f,
  4.03772369e-02f, 1.48971468e-01f, 9.57006514e-02f, 1.81641549e-01f, -2.96854705e-01f, -9.06894207e-02f, 9.53447297e-02f, -7.46764913e-02f, 8.92717019e-02f, 2.50014544e-01f,
  -1.69568762e-01f, -8.33409093e-03f, 1.34229204e-02f, -1.50326202e-02f, 2.01302409e-01f, -1.26331195e-01f, 4.42162063e-03f, 9.37984362e-02f, -7.36244693e-02f, 1.42532572e-01f,
  1.47824600e-01f, -1.16856433e-01f, 4.48021293e-02f, 9.23980623e-02f, 6.72258064e-02f, -1.77181903e-02f, 6.61159679e-02f, 1.85586154e-01f, 3.59890550e-01f, -7.93975294e-02f,
  1.38870040e-02f, -8.93249065e-02f, -3.87824066e-02f, -2.27813408e-01f, -3.00160591e-02f, -1.57419622e-01f, -4.94085178e-02f, -2.67930239e-01f, 2.75614765e-02f, 9.62015390e-02f,
  1.73573673e-01f, -1.73367321e-01f, -7.83680230e-02f, 4.34368372e-01f, 8.01546723e-02f, 1.70794293e-01f, 8.90121982e-02f, -1.10289603e-02f, 7.90748466e-03f, 2.71493830e-02f,
  2.07419410e-01f, 2.99145341e-01f, -1.22507393e-01f, 4.42634039e-02f, 4.59353775e-02f, -3.55152204e-03f, -1.35722384e-01f, 9.98574961e-03f, -2.52559315e-02f, 1.55075595e-01f,
  1.54076770e-01f, 6.04143329e-02f, 2.41865337e-01f, 3.45312506e-01f, -5.48650287e-02f, 1.43963560e-01f, -9.68198329e-02f, 1.35845050e-01f, 2.30093807e-01f, 1.07265189e-01f,
  2.09951736e-02f, 4.85296212e-02f, -2.11334825e-02f, -9.44106579e-02f, -8.78044665e-02f, -8.08107182e-02f, 7.17094690e-02f, -2.09310539e-02f, 1.26494512e-01f, -1.26260981e-01f,
  2.08366722e-01f, -4.74074557e-02f, 1.31468996e-01f, 3.67355645e-01f, -3.22623476e-02f, -4.20922413e-02f, 3.31463923e-07f, 1.57583302e-09f, -3.19741069e-08f, 7.64313700e-06f,
  -3.29611477e-10f, -1.38475355e-06f, -2.67376640e-06f, 1.09683988e-05f, 2.06320692e-07f, 3.70099951e-09f, -8.88459545e-06f, -2.92082518e-07f, -1.13481462e-07f, -4.04916354e-04f,
  -4.28492086e-09f, -1.20971988e-09f, -3.06151596e-05f, -3.65656306e-05f, -2.75413948e-03f, -2.28301924e-05f, -4.50120715e-05f, -5.16926451e-03f, 1.48821864e-05f, 7.83473216e-18f,
  -1.04753744e-05f, -1.53349077e-07f, -1.47502296e-05f, 9.38209084e-08f, 4.67898387e-09f, 2.28199156e-06f, 3.43032152e-05f, -8.84880646e-05f, -2.53314965e-06f, -1.50314605e-07f,
  -1.37853783e-06f, -8.63569494e-06f, -2.76673563e-05f, -8.13624320e-06f, -4.82457065e-13f, -5.39902365e-04f, 4.47191223e-06f, -1.87946091e-04f, -2.12963670e-03f, -5.87684393e-04f,
  -2.53470003e-04f, -6.81018981e-04f, -2.24739765e-08f, 5.79823279e-07f, -1.45147240e-03f, -1.65482961e-05f, 7.99271938e-09f, -8.01030401e-05f, -3.80355782e-11f, -2.99151125e-05f,
  1.87889287e-10f, -2.28918361e-05f, -2.77229084e-09f, -8.95275298e-05f, -2.10347789e-05f, -3.71282893e-10f, -3.14453326e-04f, -6.22170337e-04f, 4.11756155e-05f, -2.41899652e-05f,
  2.30832830e-01f, 8.22616369e-02f, 1.65206119e-02f, -1.26286909e-01f, -1.96242332e-01f, 1.65413782e-01f, -1.40894860e-01f, -1.42446488e-01f, -2.17720300e-01f, 4.04450983e-01f,
  -1.10027313e-01f, 2.58100957e-01f, -1.63163081e-01f, 8.59496444e-02f, 2.30454311e-01f, 1.16454296e-01f, -4.60227802e-02f, -9.06405672e-02f, 1.10403663e-02f, 1.66080058e-01f,
  2.03268632e-01f, -7.09393173e-02f, 1.04908034e-01f, 7.54135335e-03f, -1.08127572e-01f, 2.46963784e-01f, -2.29642600e-01f, 3.27952462e-03f, 2.01518461e-01f, 1.96121186e-01f,
  -2.65786387e-02f, 5.95375337e-02f, -1.84791848e-01f, 3.17078084e-01f, -9.70490575e-02f, 3.74877006e-02f, 1.07082188e-01f, -8.82990286e-03f, 3.43761481e-02f, -6.23194724e-02f,
  1.41797438e-01f, 1.41794354e-01f, 4.87940200e-02f, 2.12353002e-02f, -3.55618633e-02f, 5.29670790e-02f, 7.34267458e-02f, -1.18188828e-01f, -1.76182687e-01f, -1.55949211e-02f,
  -2.15971202e-01f, 3.06558306e-03f, -2.09307343e-01f, 7.91766588e-03f, 1.47802075e-02f, 1.16611414e-01f, 2.54760712e-01f, 4.07258607e-03f, 2.70391285e-01f, -8.42919648e-02f,
  4.88637611e-02f, -2.47367337e-01f, 1.71753868e-01f, -1.61015555e-01f, 2.74100876e-03f, 1.13844290e-01f, 1.69068411e-01f, 1.10023111e-01f, -2.12225512e-01f, 3.60262813e-03f,
  1.74094081e-01f, -1.87827945e-01f, -2.56795645e-01f, 6.44870549e-02f, -2.38280088e-01f, -5.07835560e-02f, -1.00900605e-01f, -4.08257097e-02f, 7.71851689e-02f, -1.13084763e-02f,
  -2.19626613e-02f, -3.70298326e-02f, -1.06192693e-01f, -1.29269496e-01f, -3.30484994e-02f, 2.30892345e-01f, 2.37762719e-01f, 1.46440625e-01f, -2.02472359e-01f, -2.11946736e-03f,
  -2.05364242e-01f, -1.11692930e-02f, 1.08929664e-01f, 1.86343625e-01f, 2.41663396e-01f, -2.18495637e-01f, -1.72039002e-01f, 1.08348161e-01f, -5.17426208e-02f, -1.68512538e-01f,
  8.62355530e-02f, 1.55915484e-01f, -1.00764260e-01f, -1.52099371e-01f, 2.35086828e-01f, 3.02868605e-01f, 2.41210505e-01f, 1.10210381e-01f, -6.33956268e-02f, 2.30019037e-02f,
  1.83444899e-02f, 9.91370752e-02f, -5.36869355e-02f, -1.77900419e-01f, 1.60489932e-01f, 1.37500495e-01f, -2.03738123e-01f, 1.33382797e-01f, 1.57224059e-01f, 1.91535771e-01f,
  -1.55746162e-01f, 1.17641343e-02f, -2.39830818e-02f, -6.80448711e-02f, -1.51341474e-02f, 1.43234625e-01f, 1.04405791e-01f, 5.80862612e-02f, 1.27262659e-02f, 7.63948336e-02f,
  2.31337920e-02f, -6.86778575e-02f, 3.82456146e-02f, -2.28606954e-01f, -1.06191430e-02f, -1.86198294e-01f, 1.96090285e-02f, 8.77036527e-02f, 7.20553845e-02f, 8.71549547e-02f,
  3.82296294e-02f, -1.51119391e-02f, -8.55730623e-02f, 2.00812772e-01f, 4.80099730e-02f, -1.99486509e-01f, 1.09875938e-02f, 2.40564644e-01f, 1.06119037e-01f, -2.11601108e-01f,
  1.38041945e-02f, 5.07695861e-02f, -1.52616903e-01f, 6.10104389e-02f, -3.55245620e-01f, -1.23420745e-01f, -7.39432778e-03f, -6.38467222e-02f, 2.23409623e-01f, 5.45323938e-02f,
  5.67282103e-02f, -7.47278798e-04f, -4.89414930e-02f, 8.81505013e-02f, -3.69154662e-02f, -1.17789395e-01f, 1.38879433e-01f, -1.62054285e-01f, 6.81919651e-03f, 5.28300963e-02f,
  1.03472732e-01f, 8.90404859e-04f, -5.18851280e-02f, 4.15527038e-02f, -2.80560464e-01f, 5.54347597e-02f, -9.92645696e-02f, 2.08950579e-01f, -3.67056169e-02f, 2.64148623e-01f,
  2.31581658e-01f, 1.80571035e-01f, 2.64194280e-01f, 1.25320479e-02f, -5.07237017e-02f, 3.39622870e-02f, -1.10749476e-01f, 2.69744724e-01f, -1.53211057e-01f, -9.88624170e-02f,
  2.35835597e-01f, -3.04207295e-01f, -1.89256892e-01f, 1.34953573e-01f, 2.26436108e-01f, 5.48839457e-02f, -1.06455207e-01f, -5.37708700e-02f, 1.84589848e-01f, -1.16550803e-01f,
  -3.28001022e-01f, -7.13104382e-02f, -2.52017587e-01f, -5.91174141e-02f, 1.51333630e-01f, 1.13247767e-01f, 3.93908769e-02f, -2.02227592e-01f, -6.27179518e-02f, 8.14845711e-02f,
  7.22083673e-02f, 1.41714469e-01f, -1.92640796e-02f, -9.57196727e-02f, 8.01474825e-02f, 8.87140036e-02f, -1.11052105e-02f, 1.35865929e-02f, -2.74453342e-01f, 1.29761294e-01f,
  -1.15614571e-01f, 7.47623444e-02f, 2.25339010e-01f, -2.21292913e-01f, -4.51176837e-02f, 1.32090747e-01f, 1.79833576e-01f, -1.31180629e-01f, 1.50739118e-01f, 1.69417322e-01f,
  -6.21218532e-02f, 4.71615903e-02f, 3.61118875e-02f, 1.51450172e-01f, 6.68719038e-02f, 1.82370991e-01f, -3.63987163e-02f, 9.70081426e-04f, 4.61459979e-02f, 9.39140841e-02f,
  8.95375684e-02f, -7.57597089e-02f, -2.74541005e-02f, 6.38214871e-02f, -1.92795292e-01f, 7.20938072e-02f, 1.05157480e-01f, 5.96313737e-02f, -2.50257313e-01f, 1.06482627e-03f,
  -1.15324266e-01f, 1.09926976e-01f, 1.70991585e-01f, -1.22300133e-01f, -4.66474481e-02f, 6.76598102e-02f, -1.73982278e-01f, -1.57261148e-01f, -7.02305585e-02f, 1.33494005e-01f,
  3.06370944e-01f, 1.18570581e-01f, 5.71228331e-03f, -1.57347888e-01f, 2.27427617e-01f, 1.81130692e-01f, -2.22751424e-01f, -4.74132225e-02f, -3.37831900e-02f, 5.43887429e-02f,
  -1.93502367e-01f, 2.83789366e-01f, -1.68979809e-01f, -6.42202646e-02f, -6.31209761e-02f, -3.72075429e-03f, -9.81577784e-02f, -1.35681823e-01f, 6.91485107e-02f, 1.01268485e-01f,
  1.96116939e-02f, -2.70399451e-01f, -7.47482246e-03f, -1.79021824e-02f, 2.37900089e-03f, 1.41594827e-01f, 1.13956816e-01f, 3.01672169e-03f, 6.38811290e-02f, 1.58746257e-01f,
  1.66949168e-01f, -8.85886699e-02f, 1.35855630e-01f, -1.38734933e-02f, -1.57606862e-02f, -5.64968698e-02f, -8.18785653e-02f, 4.97576594e-02f, -4.08636890e-02f, -7.90542439e-02f,
  -3.49733904e-02f, 1.66819487e-02f, 1.46211609e-01f, 1.45759299e-01f, -1.14486299e-01f, 7.85530508e-02f, -1.39691085e-01f, 6.36563525e-02f, 1.66600630e-01f, -7.59106549e-03f,
  -1.41760841e-01f, -2.41713654e-02f, -1.88225746e-01f, 1.54886872e-01f, 4.80530336e-02f, -9.32561755e-02f, -1.23412475e-01f, -2.05708474e-01f, 1.02959342e-01f, 7.72325546e-02f,
  5.96958920e-02f, 1.70906857e-01f, 1.96133301e-01f, 1.52374119e-01f, -1.64993599e-01f, 1.41863525e-01f, 1.58109769e-01f, -2.20763236e-01f, -3.54948074e-01f, 3.01991552e-01f,
  -3.00199747e-01f, -1.52919933e-01f, -8.62328261e-02f, 1.54234038e-03f, 2.42238119e-01f, -2.12915808e-01f, -1.73231214e-01f, -8.90443102e-03f, -9.45605189e-02f, -3.05772629e-02f,
  -1.17247529e-01f, 2.12975413e-01f, 2.75177926e-01f, -1.42570987e-01f, 2.37712488e-01f, 2.65741311e-02f, -2.28874773e-01f, 2.39169165e-01f, 1.07935213e-01f, 1.22165009e-01f,
  3.17097120e-02f, -1.94544271e-01f, 1.10113412e-01f, 1.04914896e-01f, 9.15685743e-02f, 6.58796430e-02f, 6.91115484e-02f, 5.05422130e-02f, -1.21425733e-01f, -9.87456962e-02f,
  2.12370515e-01f, 1.07852399e-01f, -7.87804723e-02f, 1.20894834e-01f, -5.97778475e-03f, -2.95170024e-03f, 2.43874058e-01f, 8.07197317e-02f, -8.43983144e-02f, -1.54165223e-01f,
  2.00144088e-04f, -1.82590596e-02f, -1.59180716e-01f, 2.20096614e-02f, -1.42105103e-01f, 1.43778399e-01f, -1.11725546e-01f, 7.62172416e-02f, 2.72055924e-01f, -8.26915503e-02f,
  1.76796481e-01f, -8.29582363e-02f, -1.14460073e-01f, 9.06776115e-02f, 2.45187730e-01f, 3.00842762e-01f, 2.89873090e-02f, -9.63165164e-02f, -2.83058494e-01f, -1.23919100e-01f,
  1.88817143e-01f, -1.55118285e-02f, 8.13447535e-02f, -1.61574557e-01f, 2.48834580e-01f, 1.54014170e-01f, -6.03639102e-03f, 1.84897624e-03f, 2.03865357e-02f, -1.96282268e-01f,
  7.49016479e-02f, 1.16543934e-01f, 4.72809508e-04f, 8.71846918e-03f, -2.78534535e-02f, 1.18708558e-01f, 4.19867747e-02f, 1.97481483e-01f, -7.59483203e-02f, 2.02123612e-01f,
  -5.92427589e-02f, -2.01610057e-03f, 1.01504982e-01f, -1.04352720e-01f, -8.31247866e-02f, -1.31721999e-02f, 3.69568691e-02f, -7.04947710e-02f, -6.30733222e-02f, 3.06594837e-02f,
  -4.39238269e-03f, 8.51723254e-02f, 1.52183697e-01f, -9.33845788e-02f, 1.04195885e-01f, 1.60392255e-01f, 9.79528278e-02f, 4.53656279e-02f, -5.69754653e-02f, 1.82974681e-01f,
  -1.26629129e-01f, 1.98795889e-02f, 6.02664147e-03f, -1.96415489e-03f, 6.25515878e-02f, 8.74234512e-02f, -6.46267384e-02f, 2.00751722e-02f, 8.98251161e-02f, -4.17095656e-03f,
  1.46355703e-01f, -1.04872294e-01f, -2.24105045e-02f, 1.09502219e-01f, 3.95372361e-02f, 2.92868882e-01f, -4.25732275e-03f, 1.64449625e-02f, 1.11351661e-01f, 1.37162417e-01f,
  4.51030359e-02f, 1.35330737e-01f, 9.49214324e-02f, 1.82461627e-02f, 5.39986715e-02f, -2.16768637e-01f, 2.18784645e-01f, 2.73428023e-01f, -1.13586560e-01f, 2.88629591e-01f,
  -6.44676164e-02f, 2.00738385e-01f, 1.12101570e-01f, 5.46132848e-02f, 5.98208383e-02f, -3.23545262e-02f, 2.63865711e-03f, 2.88021713e-01f, -1.99347630e-01f, -2.02205092e-01f,
  1.13011152e-01f, -1.21942915e-01f, -3.28275077e-02f, 2.75474619e-02f, -1.46073386e-01f, 1.28455358e-02f, -7.33695701e-02f, 1.23176940e-01f, 1.22444086e-01f, 1.76023971e-02f,
  7.50958174e-02f, 2.32791826e-01f, 2.25862980e-01f, 1.49206683e-01f, 1.01638749e-01f, 9.20639858e-02f, 1.20161340e-01f, 1.11163691e-01f, -5.92326112e-02f, 1.85689814e-02f,
  4.63458113e-02f, -1.15753427e-01f, -1.77083045e-01f, -2.49811411e-02f, 1.45904437e-01f, 1.88719526e-01f, -9.55096707e-02f, 1.10663928e-01f, -1.87288985e-01f, 6.37656376e-02f,
  4.40672673e-02f, 1.64861217e-01f, 7.55227357e-02f, 2.20896989e-01f, 1.58793673e-01f, 1.29903823e-01f, 2.16547132e-01f, 8.91478583e-02f, -9.55518056e-03f, -2.84909934e-01f,
  1.61614060e-01f, 2.52734542e-01f, 6.98893294e-02f, 1.42588526e-01f, 9.25669447e-02f, 2.31464967e-01f, 2.64235526e-01f, 1.95612505e-01f, 9.79057625e-02f, -8.62423331e-02f,
  -1.09665126e-01f, -4.47515361e-02f, -2.35642381e-02f, 7.58265480e-02f, -3.14702764e-02f, 2.10761540e-02f, 5.20994477e-02f, 1.57348484e-01f, -1.10727139e-01f, 1.03520781e-01f,
  -1.21006206e-01f, -2.21320912e-02f, -7.96884000e-02f, 1.55964032e-01f, 3.95672992e-02f, 2.82200128e-01f, 1.99190840e-01f, -1.90416202e-01f, 2.40701109e-01f, 8.23388249e-02f,
  1.44253612e-01f, -2.01379098e-02f, -1.49104416e-01f, 2.39653125e-01f, 1.55643448e-01f, -9.91998985e-02f, 1.03693940e-01f, -8.17489251e-02f, 3.44580784e-02f, -1.32652700e-01f,
  9.95207950e-02f, -3.97432111e-02f, 7.91451260e-02f, -7.04805553e-02f, 4.30331938e-02f, 1.02346547e-01f, 1.93180919e-01f, -5.68672009e-02f, 2.05741644e-01f, -1.49992719e-01f,
  4.52982225e-02f, 1.71718255e-01f, 9.76291671e-03f, 1.17931850e-02f, -3.24842110e-02f, -1.90534577e-01f, -2.38802150e-01f, 5.40762581e-02f, -1.28875747e-02f, -1.74297631e-01f,
  2.08984286e-01f, -8.44840556e-02f, 1.35401636e-01f, -1.26389906e-01f, -1.57637432e-01f, 3.03028408e-03f, 1.05964921e-01f, 6.88432455e-02f, -1.73715398e-01f, -3.90911885e-02f,
  -8.54241177e-02f, -7.70906284e-02f, -3.43158752e-01f, -1.45891964e-01f, -8.04873183e-02f, 3.35253805e-01f, -3.18761766e-01f, 2.99698144e-01f, 3.77832502e-02f, 1.20791182e-01f,
  1.28285050e-01f, 3.87050331e-01f, 5.28836474e-02f, 3.14641073e-02f, -1.31360022e-02f, 1.91412330e-01f, -1.53281558e-02f, -1.35826632e-01f, 3.11053060e-02f, -3.68488021e-02f,
  4.38875286e-04f, 1.19629651e-01f, -9.88083854e-02f, -1.27941698e-01f, 1.74987931e-02f, -1.20175622e-01f, 9.59333032e-02f, 4.25712727e-02f, 1.81381183e-03f, 1.25128776e-01f,
  8.50769877e-02f, 7.95136318e-02f, 1.19111866e-01f, -2.47271638e-02f, 2.36128252e-02f, -2.26743259e-02f, 4.73884912e-03f, 7.33742043e-02f, 1.42440110e-01f, -6.49356395e-02f,
  5.05883172e-02f, -2.86372323e-02f, -4.02902998e-02f, -4.08012904e-02f, 6.88915551e-02f, 4.23899889e-02f, -1.42045170e-01f, 5.98862469e-02f, 1.46271691e-01f, -4.77299280e-02f,
  -1.39438855e-02f, 1.03643075e-01f, 1.84137039e-02f, 1.26699179e-01f, 1.16222642e-01f, 1.33677363e-01f, -9.73156691e-02f, -2.87360847e-01f, 2.95833737e-01f, -2.83906702e-02f,
  2.86863297e-01f, 7.10771084e-02f, 5.03009111e-02f, -1.57693997e-01f, 8.98863841e-03f, 1.26619846e-01f, -8.52577165e-02f, -1.22111559e-01f, 1.06557854e-01f, 2.82979399e-01f,
  1.33557439e-01f, 5.68901226e-02f, 1.10307634e-01f, 5.27898148e-02f, 2.94433802e-01f, 2.69107297e-02f, 2.37180576e-01f, -1.15059584e-01f, 4.96313535e-02f, 1.22461230e-01f,
  8.95054266e-02f, 1.53892204e-01f, -1.25453159e-01f, -1.98744953e-01f, -1.67811036e-01f, 2.78603345e-01f, 1.54485375e-01f, 6.63641617e-02f, 9.42175314e-02f, 3.75269428e-02f,
  6.30627424e-02f, 2.40440339e-01f, 1.13708861e-01f, 1.82727337e-01f, 1.47371031e-02f, 2.12962195e-01f, -6.31784052e-02f, -1.50433332e-01f, 2.45539531e-01f, 4.86811660e-02f,
  6.02478720e-02f, -1.68156177e-01f, 8.42519291e-03f, 2.72442773e-02f, -1.21348336e-01f, -2.98223078e-01f, 1.37459010e-01f, 2.83388644e-02f, -4.00077999e-02f, -1.80584826e-02f,
  -3.62123512e-02f, -7.19105676e-02f, -1.01953134e-01f, -2.15259977e-02f, 2.81918235e-02f, 4.43055294e-02f, 2.21150503e-01f, 1.17931746e-01f, 2.50341237e-01f, 8.39058962e-03f,
  7.60928765e-02f, -3.75951901e-02f, 2.13684887e-02f, -1.37288630e-01f, 1.05501063e-01f, 1.71686888e-01f, 7.97806829e-02f, 1.06852002e-01f, -2.63277233e-01f, -1.48936629e-01f,
  1.84909537e-01f, -2.42354155e-01f, 1.19083384e-02f, 1.50493324e-01f, -8.34560096e-02f, -2.24012081e-02f, 2.11026520e-01f, -1.37593925e-01f, 4.27664109e-02f, -4.50202823e-02f,
  9.69684720e-02f, 1.96165312e-02f, 3.33563536e-02f, 2.22730767e-02f, -4.61972766e-02f, -4.29801121e-02f, 2.27055326e-01f, -1.05373152e-01f, -1.85290813e-01f, 4.15047854e-02f,
  -2.85531193e-01f, 4.99331728e-02f, 4.88562547e-02f, 2.00937673e-01f, 1.97107509e-01f, -2.96541274e-01f, 1.00090422e-01f, 1.38602823e-01f, -1.46230325e-01f, 1.06240120e-02f,
  -2.43542582e-01f, 2.21725926e-01f, 1.05072163e-01f, -2.20196217e-01f, 2.04498723e-01f, 1.07838608e-01f, 1.42693957e-02f, -8.31080775e-04f, -4.07181159e-02f, 4.59503457e-02f,
  -2.93750584e-01f, 1.59332082e-01f, 2.16684401e-01f, 5.69791440e-03f, 1.81024969e-01f, 1.72270462e-01f, 8.14808905e-02f, 3.12492609e-01f, 3.76806706e-01f, 1.59605041e-01f,
  -8.29046406e-03f, 9.26507488e-02f, -7.78863952e-02f, 1.72319680e-01f, 2.16438890e-01f, 1.40444934e-01f, -6.35510162e-02f, 1.69977218e-01f, -3.09411474e-02f, 3.92324701e-02f,
  1.17027968e-01f, -2.71983929e-02f, 2.13009804e-01f, 1.65023759e-01f, -5.27602173e-02f, 4.14398685e-02f, 2.35522613e-01f, -2.66711358e-02f, 8.29479247e-02f, 9.82298404e-02f,
  4.63929586e-03f, -1.93128258e-01f, 4.77683507e-02f, -5.40064834e-02f, 1.80714846e-01f, -1.78689927e-01f, -1.40312880e-01f, 1.07981235e-01f, -6.98201358e-02f, 2.28412330e-01f,
  -1.58757269e-01f, 9.24439952e-02f, 3.60975489e-02f, 9.80804190e-02f, 2.15914726e-01f, 1.07831977e-01f, 2.44745389e-02f, 9.23713818e-02f, -2.15184223e-02f, 4.52855453e-02f,
  -4.92504127e-02f, 1.02032393e-01f, 4.67990041e-02f, 1.84949011e-01f, -2.72715173e-04f, -1.62654206e-01f, 1.02502353e-01f, -2.34696958e-02f, 1.68270901e-01f, 1.43263554e-02f,
  -1.62331551e-01f, -7.29111508e-02f, -1.00625783e-01f, -1.78038582e-01f, 1.39322042e-01f, 3.91564853e-02f, -7.01547340e-02f, 1.98845103e-01f, 2.49566101e-02f, -2.58450452e-02f,
  -7.78590271e-04f, -8.86576995e-03f, 1.09649852e-01f, 2.92400233e-02f, 5.43858148e-02f, -3.31863388e-02f, 2.43564799e-01f, 8.55142176e-02f, 4.40678485e-02f, -3.98311839e-02f,
  -3.83086242e-02f, -1.54813513e-01f, 3.37741673e-02f, 2.42727742e-01f, 2.08553579e-02f, 1.83409780e-01f, -2.88603138e-02f, 8.21834207e-02f, -8.97301883e-02f, 3.80945280e-02f,
  -1.59600340e-02f, -3.36583585e-01f, 1.27028883e-01f, -2.76213605e-02f, -1.69597417e-02f, -7.40467086e-02f, -1.05716482e-01f, -2.25349098e-01f, 1.10681079e-01f, -1.50229665e-03f,
  -1.17015854e-01f, -1.44059569e-01f, 1.64620318e-02f, 1.66351855e-01f, 9.59666073e-02f, 2.49155551e-01f, 1.93098754e-01f, 1.44326493e-01f, 3.08460802e-01f, 1.43078966e-02f,
  2.38319077e-02f, -1.91597179e-01f, -4.73612025e-02f, 3.44934687e-02f, 9.35114771e-02f, -2.25242421e-01f, 1.24134040e-02f, -1.00859655e-02f, -1.13751873e-01f, 5.28200828e-02f,
  -2.44260132e-02f, -4.78676707e-02f, 6.37543574e-02f, 5.30813038e-02f, 1.52023047e-01f, 1.21003173e-01f, 1.57917768e-01f, 4.01703157e-02f, -1.61938027e-01f, -1.16272494e-01f,
  1.50945947e-01f, -3.19838263e-02f, 1.14725128e-01f, 1.54758379e-01f, -5.69744855e-02f, 2.91122776e-02f, -6.50615692e-02f, -1.33178746e-02f, 3.00241094e-02f, -1.03770539e-01f,
  -1.57785907e-01f, 8.99309590e-02f, 1.55107558e-01f, 3.88135985e-02f, -2.83591360e-01f, 6.38085231e-02f, 8.81430656e-02f, 7.52342865e-02f, -2.09180266e-02f, -1.43463397e-02f,
  1.86721697e-01f, 2.83474624e-01f, -2.33917937e-01f, 2.11051106e-02f, 2.49470919e-01f, 1.72329172e-01f, -4.73997332e-02f, 2.52368450e-01f, -8.35520923e-02f, 2.31711328e-01f,
  1.91850156e-01f, 1.46545619e-01f, 1.60349056e-01f, 1.17838375e-01f, -8.67229253e-02f, 5.74020781e-02f, -1.24678889e-03f, -3.67486030e-02f, -1.05036080e-01f, -1.05889335e-01f,
  4.60539944e-02f, 1.71662375e-01f, 2.95712382e-01f, 3.03482771e-01f, 1.52386469e-03f, 1.61463037e-01f, -9.84968692e-02f, 4.02195007e-01f, 2.80561298e-01f, 6.87747374e-02f,
  2.67231911e-01f, 2.62902230e-01f, -8.19176808e-03f, -7.48510882e-02f, 8.80628750e-02f, 2.52204329e-01f, 5.82772121e-02f, -2.73807675e-01f, -2.03684017e-01f, -1.16750576e-01f,
  9.84740481e-02f, -2.05177888e-01f, 3.87935072e-01f, -2.70693034e-01f, -1.85613230e-01f, 3.10626030e-01f, -4.10156883e-02f, -1.25778958e-01f, -1.48918912e-01f, 3.09673473e-02f,
  -3.22680116e-01f, 1.29074395e-01f, 2.40274817e-01f, 1.15796782e-01f, 3.50901991e-01f, -1.19487107e-01f, 1.59862563e-02f, -1.82421133e-01f, -1.29231066e-01f, -4.36263718e-02f,
  -2.77934313e-01f, -3.44809070e-02f, 1.79673195e-01f, 6.08299917e-04f, 9.97574553e-02f, -7.85622001e-02f, -2.19638333e-01f, -1.55010819e-01f, -3.21016818e-01f, 3.18687148e-02f,
  -4.53618616e-01f, -6.29311949e-02f, -3.66430432e-02f, 1.57055974e-01f, 1.62251696e-01f, -1.46607161e-01f, 2.13355571e-02f, 7.28119165e-03f, 8.18750486e-02f, 1.11848682e-01f,
  -3.91914845e-02f, -1.71105191e-02f, 1.49525478e-01f, -2.10557595e-01f, 1.05884597e-01f, 1.80769518e-01f, -1.97045922e-01f, -2.38203004e-01f, -9.69762206e-02f, 1.83070581e-02f,
  1.14217728e-01f, 5.60832769e-02f, -2.81723123e-03f, 2.92229742e-01f, 7.31454492e-02f, 1.00530513e-01f, 1.21190898e-01f, 9.95667651e-02f, -9.50715505e-03f, 1.22737177e-01f,
  -1.90796524e-01f, 2.77771521e-02f, -7.30825309e-03f, 5.23370914e-02f, 6.16678968e-02f, -9.53000039e-02f, 5.30847609e-02f, 4.60851863e-02f, 1.23670802e-01f, -1.44063890e-01f,
  -1.19919479e-01f, 2.10975669e-03f, -2.04914942e-01f, 3.18474248e-02f, -9.35160369e-02f, 1.03021435e-01f, 4.93422151e-02f, 7.42732882e-02f, 3.80781814e-02f, -2.93805599e-02f,
  1.22359581e-01f, -1.75241083e-01f, -7.24759279e-03f, 1.63789421e-01f, 1.02340644e-02f, 2.51107980e-02f, 1.70499265e-01f, 7.64552876e-02f, 1.86711140e-02f, 1.55131087e-01f,
  4.52847213e-01f, 5.85454702e-02f, 4.42489423e-02f, -2.10513517e-01f, -7.40069151e-02f, -4.84808758e-02f, 7.27826282e-02f, 9.27992687e-02f, -2.82873183e-01f, -1.24223549e-02f,
  -1.62417963e-01f, -9.01556313e-02f, 4.08061706e-02f, -2.47678366e-02f, -2.44588003e-01f, 1.03091814e-01f, 1.39608666e-01f, -6.70426933e-04f, 5.86273968e-02f, -2.92211890e-01f,
  1.71347126e-01f, 2.51014438e-02f, -8.90434012e-02f, -2.72643454e-02f, 5.86063378e-02f, -8.87915492e-02f, 1.20134361e-01f, -1.78163737e-01f, 1.49908692e-01f, 2.10787244e-02f,
  -1.16660595e-01f, 1.18458942e-01f, -4.85902540e-02f, 3.39751244e-02f, 2.36034766e-02f, 9.31671113e-02f, -7.66432509e-02f, 9.42764655e-02f, -1.93156544e-02f, 1.30679175e-01f,
  2.41594255e-01f, 1.05015308e-01f, -8.92243162e-02f, 1.82780281e-01f, 2.25353658e-01f, -2.95819286e-02f, 1.03585310e-01f, 2.08829299e-01f, 7.56499171e-02f, 1.89823508e-01f,
  -2.03170747e-01f, 9.96572226e-02f, -9.17290279e-04f, 1.22447424e-01f, 1.23430349e-01f, -6.11993019e-03f, -1.57869995e-01f, 4.22649309e-02f, 1.20017514e-01f, -8.50181654e-02f,
  -1.54028803e-01f, -4.02351543e-02f, 1.06215425e-01f, 1.66976191e-02f, -5.73598482e-02f, -9.18698311e-02f, 9.03756171e-02f, 8.90900120e-02f, 1.15724549e-01f, 5.86324148e-02f,
  -5.75853586e-02f, -2.82109320e-01f, 2.31495380e-01f, -3.96765620e-02f, 1.52830333e-01f, -9.11417510e-03f, 2.15354338e-02f, 1.98530242e-01f, -8.43417048e-02f, -5.37472405e-02f,
  -2.26269007e-01f, -1.89670995e-01f, -3.18328366e-02f, 5.29236384e-02f, -9.48146954e-02f, 1.51605621e-01f, 1.75276935e-01f, 2.40204915e-01f, -4.84687351e-02f, 1.17039718e-01f,
  1.46502808e-01f, 1.22489475e-01f, -1.93991914e-01f, 5.34204543e-02f, -1.35622844e-01f, -8.01910982e-02f, 2.24665940e-01f, -2.41756946e-01f, -1.52656566e-02f, -7.79788643e-02f,
  -2.93708384e-01f, 2.64046062e-02f, -1.48019075e-01f, -8.23480338e-02f, -1.56916343e-02f, -6.39879033e-02f, -1.65636793e-01f, -2.88116490e-03f, -9.63111967e-02f, -3.53892028e-01f,
  -1.77436043e-02f, -9.41544920e-02f, -5.25274053e-02f, -2.61303969e-02f, 8.28813836e-02f, -1.28247485e-01f, 1.29850715e-01f, 9.12587121e-02f, 1.26067787e-01f, 2.88497610e-03f,
  -1.03860274e-02f, -1.71057224e-01f, -7.24110529e-02f, 8.16350896e-03f, 1.35157049e-01f, -1.31957408e-03f, 5.30865416e-03f, 1.04188323e-01f, 1.96574599e-01f, -1.84661672e-01f,
  1.50611177e-02f, 8.46588090e-02f, 2.52132654e-01f, 3.21991205e-01f, 1.65411666e-01f, -8.47623348e-02f, 3.71414796e-02f, -1.14358999e-01f, 9.98396203e-02f, -1.09326012e-01f,
  4.80340794e-02f, 2.36783251e-02f, 4.81963381e-02f, -2.80538872e-02f, -5.93320578e-02f, 1.15733579e-01f, 2.53177792e-01f, -9.60846171e-02f, -2.10244432e-01f, 1.61172837e-01f,
  -4.85193990e-02f, -9.57853794e-02f, 7.86470473e-02f, -3.39857931e-03f, 2.55459458e-01f, 4.55553308e-02f, -1.39444798e-01f, 8.90605245e-03f, -3.18068594e-01f, 5.07421345e-02f,
  1.73562802e-02f, 2.97311600e-02f, 1.05494790e-01f, 2.20439676e-03f, 8.81417245e-02f, 8.60280395e-02f, 1.44800678e-01f, -1.10737480e-01f, -1.42800927e-01f, 2.07870957e-02f,
  2.79851526e-01f, 1.85773179e-01f, -1.05021521e-02f, -1.34532824e-01f, 3.69545430e-01f, 7.30162263e-02f, 4.26064879e-02f, -9.89042670e-02f, 8.88211057e-02f, 7.02752694e-02f,
  -7.81676918e-02f, 1.65720314e-01f, 7.63167590e-02f, -8.50612521e-02f, -9.92084518e-02f, -7.44153336e-02f, -6.56942949e-02f, 4.43068929e-02f, 6.46653250e-02f, 2.22902782e-02f,
  1.48462057e-01f, 5.42592369e-02f, -1.56514674e-01f, -2.22291239e-02f, 1.79756805e-01f, 1.86149422e-02f, -4.64198478e-02f, 8.46691206e-02f, -2.03973368e-01f, 6.36634901e-02f,
  -4.69353944e-02f, -1.06214613e-01f, 1.61232948e-01f, 1.40425727e-01f, 1.24367289e-01f, 1.87603965e-01f, 8.06314051e-02f, 2.36759499e-01f, 7.68042803e-02f, 8.64774585e-02f,
  4.56915945e-02f, 1.13841310e-01f, 1.22232445e-01f, -2.81322271e-01f, 3.14034522e-02f, -7.99635798e-02f, -1.02075785e-01f, 1.65030628e-01f, 5.41358478e-02f, 2.87521273e-01f,
  8.37105140e-02f, 1.19767115e-01f, 2.36820176e-01f, 1.92440614e-01f, 1.21503219e-01f, -1.23663418e-01f, 4.81328145e-02f, -6.91749528e-02f, 1.17890693e-01f, 8.46654922e-03f,
  -9.81612876e-02f, 1.39161959e-01f, -5.65245887e-03f, 1.61978289e-01f, -4.45469059e-02f, 1.32524560e-03f, -1.86591983e-01f, 1.83261111e-01f, -1.09828867e-01f, -3.86372581e-02f,
  -5.48987612e-02f, -1.95306148e-02f, 1.20986305e-01f, -2.50187912e-03f, 1.84163243e-01f, -6.74833283e-02f, -1.09250844e-01f, 3.44668292e-02f, 2.06984550e-01f, 2.77333409e-01f,
  1.81927755e-01f, -6.45898879e-02f, -2.21713349e-01f, -9.30170566e-02f, -1.66083928e-02f, 2.30859414e-01f, -1.20739423e-01f, 3.93266268e-02f, -3.62239182e-02f, 1.24966636e-01f,
  1.72913164e-01f, 1.53471783e-01f, 8.78451616e-02f, -2.03477234e-01f, 1.70500591e-01f, 4.14984643e-01f, 2.75773376e-01f, 1.34782121e-01f, -1.03056535e-01f, 1.12174219e-02f,
  1.42598018e-01f, -5.60889617e-02f, -8.27740878e-02f, -1.28495604e-01f, -3.86264585e-02f, 1.09843053e-01f, 2.44925886e-01f, 2.53671616e-01f, 4.73335274e-02f, 1.93743616e-01f,
  -5.69937676e-02f, 1.65316358e-01f, -2.11663288e-03f, 1.13039069e-01f, 1.22331548e-02f, 1.39792025e-01f, 2.34534182e-02f, -1.44675940e-01f, 6.23843260e-02f, -1.92200005e-01f,
  1.65355012e-01f, -3.31398621e-02f, 9.60805342e-02f, -4.73944098e-02f, 1.61143783e-02f, -9.71509814e-02f, -1.66283604e-02f, -4.44266759e-02f, -1.57299832e-01f, 9.83847976e-02f,
  4.10160683e-02f, -7.11071640e-02f, 1.53182074e-01f, 1.48469985e-01f, 1.22084886e-01f, 1.65444911e-01f, 2.31381223e-01f, 1.29836574e-01f, 1.06039345e-01f, 1.64512135e-02f,
  -3.48528363e-02f, -1.06141590e-01f, 2.04989478e-01f, -1.35242715e-01f, -8.48420337e-02f, 1.31088331e-01f, 5.58114089e-02f, 3.30779552e-02f, -1.81937423e-02f, 1.35687664e-02f,
  2.81483620e-01f, -4.44037840e-02f, 1.10207468e-01f, -2.37378225e-01f, -6.56139255e-02f, -5.69736538e-03f, 1.16340004e-01f, 7.66136497e-02f, -1.42240837e-01f, -6.76553175e-02f,
  1.11188665e-01f, -2.88963248e-03f, 6.34772331e-02f, 9.92642045e-02f, -1.08414523e-01f, 3.94868590e-02f, 6.39605820e-02f, -1.81160122e-02f, 1.83018431e-01f, -2.34593362e-01f,
  -4.58937734e-02f, -2.02108901e-02f, -1.15094356e-01f, 2.09633075e-02f, 1.11797288e-01f, 2.66668256e-02f, 1.26999289e-01f, 3.34820561e-02f, 9.38588008e-02f, 6.91123605e-02f,
  -8.29053745e-02f, 1.37736246e-01f, 1.53748199e-01f, 2.17342511e-01f, 6.74578547e-02f, -4.08050977e-02f, -1.10837340e-01f, -4.50671203e-02f, -2.38165054e-02f, 1.42852962e-01f,
  7.28934258e-02f, 1.22697003e-01f, 9.77516174e-03f, 1.24899462e-01f, 1.65124178e-01f, 4.27613445e-02f, 6.49698004e-02f, 5.98444492e-02f, -5.14480956e-02f, -9.76874158e-02f,
  -9.86677408e-02f, -5.41822203e-02f, -1.82828363e-02f, 2.09243357e-01f, 5.06125800e-02f, 8.06505531e-02f, -8.45513344e-02f, 2.00755656e-01f, 4.44381200e-02f, -1.12841100e-01f,
  7.63948932e-02f, 1.68485522e-01f, 8.45653191e-03f, 1.29507646e-01f, 3.62023205e-01f, -1.69959784e-01f, 6.15369380e-02f, 2.70144522e-01f, -2.62291729e-01f, -3.14707994e-01f,
  1.67288959e-01f, 1.98296178e-02f, -1.74724102e-01f, 1.01185583e-01f, -2.17729852e-01f, -1.25628486e-01f, -1.76820993e-01f, 1.14761770e-01f, -1.40575811e-01f, -1.77025288e-01f,
  2.08225399e-01f, -4.63647805e-02f, -1.59015179e-01f, -3.62647712e-01f, 6.25871122e-02f, 4.91225533e-02f, 6.36062846e-02f, 7.32137933e-02f, 2.42678016e-01f, -2.06828639e-01f,
  -6.87459409e-02f, -1.97674129e-02f, 3.54656428e-01f, -1.79326162e-02f, 9.14400816e-02f, -1.56831011e-01f, -1.00205675e-01f, 9.18763690e-03f, -1.50538655e-02f, -5.98312938e-04f,
  -6.85777813e-02f, 2.67669205e-02f, 4.55601178e-02f, 1.85011942e-02f, 3.00436020e-01f, 2.46862933e-01f, -1.46237984e-01f, 9.24564973e-02f, -4.43302542e-02f, 9.53318775e-02f,
  2.47735858e-01f, 1.75990552e-01f, 1.66990384e-01f, 1.84960797e-01f, -3.48077595e-01f, 2.86843419e-01f, 4.08756845e-02f, 1.15889326e-01f, -2.80477535e-02f, -1.17410518e-01f,
  1.47707731e-01f, -3.65815572e-02f, 2.62086809e-01f, 9.25245956e-02f, 1.43413320e-01f, -2.36411393e-02f, 1.03524841e-01f, 1.00032665e-01f, -3.14393565e-02f, -5.20433560e-02f,
  1.30626321e-01f, 1.17422640e-01f, 1.10947095e-01f, 2.17956513e-01f, 1.27384558e-01f, -8.51756707e-02f, 1.31902888e-01f, -5.61585575e-02f, 4.67440113e-02f, 8.29996690e-02f,
  6.58286512e-02f, -4.12967950e-02f, 8.52173252e-04f, 1.92374423e-01f, -1.04925767e-01f, 2.33600676e-01f, 1.55148312e-01f, 3.90273556e-02f, 2.21273482e-01f, 2.01067448e-01f,
  4.79730964e-02f, 1.88764751e-01f, 6.66348115e-02f, 1.82212964e-01f, 2.59603322e-01f, 8.96620527e-02f, -3.56988162e-02f, 5.82666397e-02f, 2.42511067e-03f, -4.29293439e-02f,
  1.50724381e-01f, 7.12621287e-02f, 3.40581946e-02f, -1.64731577e-01f, -1.30435690e-01f, 1.26137972e-01f, -2.33073030e-02f, -1.82863399e-01f, 1.93284422e-01f, -1.63020298e-01f,
  8.55333265e-03f, 1.59232393e-01f, 7.69146308e-02f, -2.05404609e-01f, 1.11530520e-01f, 6.00008443e-02f, -8.03177804e-02f, 8.23192596e-02f, 1.97967157e-01f, -1.80505708e-01f,
  7.97691494e-02f, 6.23837076e-02f, 1.47031292e-01f, -1.83854380e-03f, -6.09861761e-02f, -3.10730338e-01f, 1.60330138e-10f, -8.67510508e-11f, -1.09334321e-11f, -1.42149140e-10f,
  -2.38601912e-12f, 5.42650404e-11f, -7.15663061e-16f, -1.25934508e-15f, 7.01674682e-15f, 6.85519911e-16f, -1.09022519e-13f, 1.80203718e-16f, -4.96772917e-40f, -4.48642127e-13f,
  1.79646422e-14f, 3.03118088e-15f, 6.15661197e-15f, 3.88165230e-19f, -4.99497042e-40f, 8.05902383e-15f, -1.70584326e-12f, -1.09759500e-12f, -3.31578931e-11f, 4.47393062e-16f,
  1.14146871e-14f, 5.02949572e-15f, 5.00337821e-40f, 1.89038746e-14f, 1.25427445e-14f, 6.20628494e-14f, -5.73968661e-13f, 2.34168950e-14f, 2.90317121e-14f, 1.16841758e-14f,
  9.89571143e-15f, 1.59045225e-14f, 6.06593540e-15f, -6.07159887e-16f, 2.23320118e-14f, 1.35670419e-14f, 1.82222977e-14f, -1.44881091e-12f, -2.56450203e-08f, -5.54990054e-10f,
  -1.41685112e-13f, 1.84849233e-10f, 2.62408469e-14f, -4.94186120e-40f, 5.96552023e-30f, 1.72350402e-14f, -1.58196825e-24f, -3.38185515e-08f, 4.99010791e-40f, 5.03503319e-15f,
  5.77261847e-16f, 1.72378100e-14f, 1.95223256e-14f, 5.61345929e-15f, 2.35615818e-14f, -4.79414734e-18f, 1.75515560e-14f, -3.80440636e-31f, 6.48317451e-15f, -1.34011736e-12f,
  1.04793876e-01f, 6.02752082e-02f, -6.78749429e-03f, -5.81425242e-02f, -1.89461038e-01f, -1.40637517e-01f, 1.55959994e-01f, 4.97298650e-02f, 6.48535416e-02f, -1.69796422e-01f,
  2.31576309e-01f, -2.56796747e-01f, -5.58875641e-03f, -3.37074995e-02f, -1.65058225e-01f, -1.76934749e-01f, -5.72539121e-02f, 1.93009168e-01f, 7.56006222e-04f, -6.79713488e-02f,
  -1.12670012e-01f, 1.91026852e-01f, 1.40629575e-01f, 2.38171354e-01f, -9.34828818e-02f, -5.40993363e-02f, 7.55150020e-02f, -7.13261440e-02f, 1.94606036e-02f, -1.77210003e-01f,
  -2.34588921e-01f, 1.89226773e-03f, 7.84622058e-02f, -1.76430330e-01f, -8.17278400e-02f, -9.96222440e-03f, -2.93624378e-03f, 1.68707967e-01f, 9.14490372e-02f, 2.91004274e-02f,
  4.09687795e-02f, 4.43411320e-02f, 2.26333961e-02f, 9.41884965e-02f, -7.11486265e-02f, 1.52796894e-01f, -1.50543407e-01f, -5.20742731e-03f, 4.42645513e-02f, -1.72928765e-01f,
  1.03891023e-01f, 1.38701245e-01f, -4.95347136e-04f, -1.44330919e-01f, -1.85030565e-01f, -1.38806313e-01f, -1.43715516e-01f, -1.61304608e-01f, -1.73276544e-01f, -8.27457383e-02f,
  5.34167290e-02f, 3.52120101e-01f, -2.43591562e-01f, 8.62654746e-02f, 2.10753009e-01f, 1.54725805e-01f, 1.08563796e-01f, 2.99985278e-02f, -3.02845061e-01f, -3.34894322e-02f,
  2.50320405e-01f, -1.63437292e-01f, -7.84534663e-02f, 2.43818507e-01f, -1.78591654e-01f, -1.15952812e-01f, -7.91918337e-02f, -1.12363927e-01f, 2.07569271e-01f, -9.02764797e-02f,
  1.86331123e-01f, -1.51591808e-01f, 3.02098859e-02f, -6.85100704e-02f, 1.79981783e-01f, 3.96785468e-01f, 1.79532185e-01f, 1.26197919e-01f, -7.91342333e-02f, 3.72141987e-01f,
  -1.72971144e-01f, 1.21637948e-01f, 3.29065561e-01f, 1.48357108e-01f, 1.82641685e-01f, -1.25434279e-01f, -4.15807590e-02f, 3.52547199e-01f, 1.44292759e-02f, 1.50095686e-01f,
  -4.07137908e-02f, 1.03215016e-01f, 1.99710086e-01f, -1.36148900e-01f, 3.28695178e-01f, 2.28240177e-01f, -3.87075357e-02f, 1.92983255e-01f, 2.39215251e-02f, -1.32870600e-01f,
  7.23432526e-02f, -3.02413125e-02f, 5.76595999e-02f, -1.16345279e-01f, 1.29275918e-01f, -8.17633197e-02f, -2.32069910e-01f, 1.91814706e-01f, 1.86416000e-01f, 2.95731336e-01f,
  3.46340477e-01f, -7.10463598e-02f, 2.87816793e-01f, 1.02944702e-01f, 3.10610920e-01f, -4.36097383e-02f, 1.04474658e-02f, 4.64269668e-02f, 2.15229422e-01f, 1.81024205e-02f,
  -1.67618394e-01f, -5.94957247e-02f, 7.03777149e-02f, 1.53432041e-01f, -3.01133096e-02f, -1.63952038e-01f, 2.35488623e-01f, 1.93587497e-01f, 7.12648407e-02f, 9.73318741e-02f,
  -2.87971878e-03f, -2.60113567e-01f, 2.04252988e-01f, -5.26109338e-02f, 1.27647683e-01f, 4.90625948e-03f, 1.27901407e-02f, 1.36977822e-01f, 1.27085790e-01f, 9.71544087e-02f,
  -2.14702591e-01f, -1.32558644e-01f, 2.18869355e-02f, 1.44803643e-01f, -1.44983098e-01f, -9.63847861e-02f, 4.92430516e-02f, 2.64916420e-01f, 3.41950729e-02f, 8.94870013e-02f,
  1.13166660e-01f, 2.86369801e-01f, -2.26970732e-01f, 1.74022064e-01f, -8.40640813e-02f, -8.09953809e-02f, 1.78136170e-01f, -1.57727584e-01f, 1.25026545e-02f, -1.40434265e-01f,
  -1.43587992e-01f, -2.13849060e-02f, -7.20723271e-02f, -9.84784514e-02f, 8.24941993e-02f, -2.27961652e-02f, -2.26059109e-02f, 9.28769931e-02f, -3.91694568e-02f, -2.82083899e-01f,
  -7.14018419e-02f, -1.39039025e-01f, 3.18937562e-02f, -1.28084226e-02f, 2.54275292e-01f, -1.63793162e-01f, 1.20330133e-01f, -5.24765998e-02f, 6.35869652e-02f, -2.71559320e-02f,
  7.01167583e-02f, -1.05922200e-01f, 3.52544673e-02f, 4.86115403e-02f, 7.01050758e-02f, 1.69850513e-01f, 3.10207397e-01f, 1.83381543e-01f, 6.07975118e-04f, 2.29107752e-01f,
  -1.86393023e-01f, -4.37887490e-01f, 8.69621336e-02f, -1.45462960e-01f, -1.97094306e-02f, 2.86257714e-01f, -6.30693734e-02f, 1.70203820e-01f, 1.61034837e-02f, 2.85898298e-01f,
  -5.29695675e-02f, 3.12200114e-02f, -2.25977898e-02f, 6.49501234e-02f, -4.14390629e-03f, 5.24565995e-01f, -1.17639571e-01f, -4.31903079e-03f, 3.14675003e-01f, -9.85078365e-02f,
  -3.96052450e-02f, -1.86457276e-01f, -1.58267274e-01f, 1.05764985e-01f, -1.90787733e-01f, -2.17017055e-01f, 1.15966059e-01f, 9.59793553e-02f, 2.90081918e-01f, 1.56139851e-01f,
  -8.14203620e-02f, -9.09227133e-03f, 1.26074299e-01f, 1.48402929e-01f, 1.87043592e-01f, 1.78068683e-01f, -2.07930710e-02f, 2.95784503e-01f, -4.17880937e-02f, -8.45007002e-02f,
  -2.08574519e-01f, 1.22243114e-01f, 8.63707140e-02f, 2.80075341e-01f, 4.22880203e-02f, -4.37104888e-02f, -2.04227984e-01f, -7.87139460e-02f, -1.05840318e-01f, 1.31322565e-02f,
  -6.77673519e-02f, -6.26735464e-02f, -1.00599997e-01f, 3.19743574e-01f, -3.28275673e-02f, 8.04729015e-02f, -9.30016581e-03f, 2.63195902e-01f, 1.02911063e-01f, -1.56984497e-02f,
  -1.65225774e-01f, -2.65540369e-02f, -2.50357181e-01f, 1.39683291e-01f, -1.13527268e-01f, -7.61615187e-02f, -6.47468567e-02f, 5.35199083e-02f, -2.67330050e-01f, 3.21497530e-01f,
  9.25127491e-02f, -2.75029153e-01f, 2.22845405e-01f, 1.06465168e-01f, -3.70891914e-02f, 2.72980575e-02f, 3.15208510e-02f, 1.01545699e-01f, 2.51689613e-01f, -1.41723882e-02f,
  -3.17052692e-01f, 3.75860542e-01f, -2.86540948e-02f, -1.79540321e-01f, -7.22091412e-03f, -1.94590941e-01f, -1.84039310e-01f, 5.57139739e-02f, -1.80761516e-01f, 9.22217742e-02f,
  1.78029239e-02f, 2.07352102e-01f, 2.58464545e-01f, 3.03844064e-01f, -1.03937481e-02f, -6.99715763e-02f, -1.51058599e-01f, 1.11479133e-01f, 1.72318488e-01f, 1.81700662e-02f,
  -3.44028115e-01f, 1.33947700e-01f, -4.36025262e-02f, -8.76536518e-02f, 1.21765763e-01f, -1.83376461e-01f, -1.94332838e-01f, 2.41162226e-01f, -4.10847604e-01f, 5.79829440e-02f,
  1.39903510e-02f, 1.81405455e-01f, 1.22224495e-01f, 2.13286251e-01f, 8.40686113e-02f, -6.26738966e-02f, 1.55103892e-01f, 9.07660797e-02f, 6.63939631e-03f, 7.07769692e-02f,
  3.45197283e-02f, 3.11279278e-02f, 1.54451072e-01f, 4.72675525e-02f, -7.51873571e-03f, 7.88240209e-02f, 1.71885103e-01f, -2.27749661e-01f, -8.46000239e-02f, 2.35018134e-01f,
  -2.12737843e-01f, -5.54034002e-02f, -2.31909528e-01f, -3.75660905e-03f, 4.42394204e-02f, 2.94277724e-02f, -1.14966549e-01f, -9.17931423e-02f, 3.44510339e-02f, 1.26515301e-02f,
  9.70840976e-02f, 2.97278970e-01f, 4.61571291e-02f, 2.87256122e-01f, 6.88345879e-02f, 1.04162678e-01f, -1.57007456e-01f, -1.43560469e-01f, 2.22518414e-01f, 1.18961714e-01f,
  1.82316117e-02f, -8.74690264e-02f, 5.35060503e-02f, 2.88249701e-01f, -1.97917223e-02f, -5.75982109e-02f, 1.45085543e-01f, -7.71113439e-03f, 6.83182701e-02f, -2.26587489e-01f,
  1.87186971e-01f, 3.56001973e-01f, 1.74176931e-01f, 1.39059842e-01f, -8.06937292e-02f, 1.39829412e-01f, -8.95617753e-02f, 1.01856329e-01f, -1.15971580e-01f, 2.98664141e-02f,
  -9.13481191e-02f, 9.08529237e-02f, -2.86312938e-01f, -1.30027130e-01f, -7.34962374e-02f, 9.98578668e-02f, 1.61090523e-01f, 3.12332064e-02f, 1.79375246e-01f, -5.84393507e-03f,
  1.51752114e-01f, -1.13375194e-01f, 1.79947779e-01f, 3.25584374e-02f, -4.06904742e-02f, 1.07174739e-01f, 1.32920012e-01f, -3.40807773e-02f, 2.06043452e-01f, 8.54067653e-02f,
  -4.53166157e-01f, 2.00257465e-01f, -4.17053401e-02f, -7.94554576e-02f, -1.63361430e-01f, 5.71519043e-03f, 1.29183799e-01f, 1.20857894e-01f, 5.74666355e-03f, -2.52332091e-02f,
  3.01088154e-01f, 2.09096596e-01f, 6.56474009e-02f, 8.02069455e-02f, -2.39205472e-02f, -1.61618471e-01f, 3.00475359e-02f, -1.81925163e-01f, -1.21345809e-02f, 2.28384167e-01f,
  4.37696636e-01f, 2.79826410e-02f, -1.24205090e-01f, -1.60579130e-01f, -6.20568059e-02f, 1.99775070e-01f, 9.11682248e-02f, 4.52969745e-02f, 2.91401327e-01f, 3.28219712e-01f,
  9.27845612e-02f, 1.13243878e-01f, -5.97735774e-03f, 3.05009604e-01f, -6.78192452e-02f, -1.93528414e-01f, -9.50796902e-02f, -1.01111485e-02f, -9.40748900e-02f, -2.13282079e-01f,
  2.54399300e-01f, -1.08128101e-01f, 1.01742186e-01f, 3.63715962e-02f, -9.74741671e-03f, 1.40663415e-01f, 1.61219686e-02f, 2.40562052e-01f, -1.54291302e-01f, 2.10475549e-01f,
  2.01572239e-01f, 2.38851249e-01f, 1.30456001e-01f, 1.15625057e-02f, 1.09556966e-01f, -1.05154559e-01f, -1.02643080e-01f, 1.73944429e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.27415031e-01f, 7.61353746e-02f, -3.49963680e-02f, -5.40180393e-02f, 7.49280080e-02f, 5.32658137e-02f, 1.09776534e-01f, 5.33499755e-02f, -1.29951805e-01f, 4.53676619e-02f,
  -2.50249542e-02f, 4.54041772e-02f, 5.84303029e-02f, 6.25428697e-03f, 1.20131634e-01f, -1.12127483e-01f, 4.08564545e-02f, 9.92655382e-02f, 2.32122391e-01f, -1.04090004e-05f,
  1.84146576e-02f, -8.83444771e-03f, 1.42516360e-01f, 1.16251163e-01f, -2.85334364e-02f, 1.42657295e-01f, 1.28472909e-01f, 7.22264722e-02f, 8.55655596e-02f, -2.78403144e-02f,
  2.03622833e-01f, 5.11452779e-02f, 9.34021175e-02f, 1.31165445e-01f, 1.56491876e-01f, -2.00046115e-02f, 5.32181524e-02f, 4.05393541e-02f, 8.79365206e-02f, 1.34865820e-01f,
  1.20431624e-01f, -4.31350694e-04f, 5.02122976e-02f, 3.67405079e-02f, -3.61357805e-10f, -3.65222916e-02f, 2.99522758e-01f, -1.63070357e-03f, 5.55399135e-02f, 1.94424346e-01f,
  1.46030426e-01f, 8.08168799e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -2.10262299e-01f, -1.30405709e-01f, -1.86954245e-01f, -1.16345957e-01f, 1.25931650e-01f, -1.23618238e-01f, 3.52110639e-02f, 1.35750756e-01f, 1.12539567e-01f, -5.93110695e-02f,
  -1.40090749e-01f, -1.36405393e-01f, -2.75755674e-01f, 1.46206275e-01f, -9.51537192e-02f, -4.27061954e-04f, -8.45503435e-02f, -7.52664924e-01f, 8.41369778e-02f, -7.88581520e-02f,
  3.26043606e-01f, 1.16075493e-01f, 6.46598563e-02f, 1.06914550e-01f, -2.67074138e-01f, 1.48851588e-01f, -5.80877177e-02f, 3.58698964e-01f, -1.60794541e-01f, 4.78438586e-02f,
  1.69704191e-03f, -2.11064844e-06f, -2.81961828e-01f, 1.14889983e-02f, -7.68918321e-02f, 3.91081460e-02f, -1.16891384e-01f, -1.09043472e-01f, 6.90172985e-02f, -1.25801831e-01f,
  -8.33394453e-02f, -1.50557935e-01f, -2.20185608e-01f, -5.31170405e-02f, -1.16081052e-01f, 6.55950531e-02f, -3.06591213e-01f, -6.12796508e-02f, -1.04261227e-02f, -1.39158906e-03f,
  -3.09916675e-01f, 1.23429686e-01f, -2.82191932e-01f, 4.78952229e-02f, -1.93659112e-01f, -1.50387108e-01f, -3.54777433e-28f, 2.85877526e-01f, -2.09239691e-01f, -3.79472487e-02f,
  1.67759821e-01f, 1.76557451e-01f, -1.42894536e-01f, -1.51031408e-02f, -2.92215586e-01f, -3.30656059e-02f, -2.33820394e-01f, 4.86387648e-02f, -1.77918449e-01f, 1.67587221e-01f,
  1.90053999e-01f, -3.18697602e-01f, 5.54719210e-01f, -3.75625163e-01f, 3.38767916e-01f, -1.58150166e-01f, 1.52119711e-01f, 1.66493297e-01f, 2.55280454e-02f, -1.78511511e-03f,
  -1.71487436e-01f, -2.01931641e-01f, 7.79588223e-02f, 1.39828339e-01f, 2.63191134e-01f, -2.35351026e-01f, 1.07429393e-01f, -1.04364656e-01f, 7.62485713e-03f, -3.47989082e-01f,
  -3.30684334e-01f, 5.47092147e-02f, 1.43608153e-01f, 8.21103305e-02f, 1.65893391e-01f, -1.22747095e-02f, -2.23140210e-01f, 5.69313280e-02f, -1.96324568e-02f, 9.62769240e-02f,
  -3.06224525e-01f, 8.13203976e-02f, 8.43720287e-02f, -4.01495427e-01f, 1.98774517e-01f, -2.71935850e-01f, -1.24300070e-01f, 1.36836052e-01f, -5.83872385e-02f, 1.96102425e-01f,
  -5.46258762e-02f, -3.25353771e-01f, 1.69172421e-01f, -8.13705102e-02f, 1.81263551e-01f, -1.33031353e-01f, -6.46373630e-02f, 9.77139026e-02f, -8.73287916e-02f, 3.04615367e-02f,
  -2.46175663e-10f, 2.91946232e-01f, 1.01817116e-01f, -1.81472763e-01f, 1.58878461e-01f, -6.43497929e-02f, 5.79272658e-02f, -4.23909307e-01f, 9.71595123e-02f, 5.88486604e-02f,
  9.27262679e-02f, 1.07611649e-01f, 4.41505574e-02f, -1.14460595e-01f, -2.15043396e-01f, -5.87133095e-02f, 1.70816466e-01f, -2.75759399e-01f, -3.01944762e-02f, 8.51916224e-02f,
  2.99219918e-02f, -9.58543643e-02f, 9.91048440e-02f, -7.76208714e-02f, -4.25011128e-01f, -1.61318928e-01f, 3.23916227e-01f, -4.31116611e-01f, -2.29867592e-01f, 1.59962535e-01f,
  -2.60580331e-01f, 1.24807386e-02f, 2.24309132e-01f, -2.19387650e-01f, -2.16736466e-01f, -2.17622612e-02f, -3.92185956e-01f, 6.29523322e-02f, 2.03756765e-01f, -7.83675537e-03f,
  -3.01434156e-02f, -5.16960658e-02f, -1.20260835e-01f, -2.50787199e-01f, -5.64326942e-02f, -3.38404536e-01f, 1.71840340e-01f, -1.12721831e-01f, 1.64545491e-01f, -3.23548347e-01f,
  1.44979209e-01f, -4.44563717e-01f, 2.41790026e-01f, 1.69712216e-01f, 1.29736781e-01f, -4.19234425e-01f, -3.56810130e-02f, -1.55984998e-01f, -2.81649619e-01f, 1.28716350e-01f,
  1.27986357e-01f, -1.93855822e-01f, -1.23759881e-01f, 6.97969645e-02f, -3.73465269e-07f, 8.68161246e-02f, 9.91460085e-02f, -1.71374559e-01f, 2.21051142e-01f, 1.28511831e-01f,
  9.82004106e-02f, 7.14910328e-02f, 7.41464645e-02f, 5.49764186e-02f, 3.04856207e-02f, -7.51527697e-02f, -8.51973295e-02f, -1.74679965e-01f, 1.79611191e-01f, -6.58868551e-02f,
  4.33955751e-02f, -1.89825982e-01f, -1.63448662e-01f, -1.74430013e-01f, 2.03471467e-01f, -6.55267900e-03f, -1.82569951e-01f, -3.24602952e-05f, 2.38458365e-01f, -5.02667204e-02f,
  -1.02303165e-03f, -2.40034580e-01f, -4.11966294e-02f, 1.50653914e-01f, 1.52152777e-01f, 1.21915370e-01f, -5.85884713e-02f, 5.35625890e-02f, 8.71145651e-02f, -4.23098020e-02f,
  -2.60115474e-01f, -2.57445127e-01f, -3.03289801e-01f, 3.00846505e-03f, -3.18177551e-01f, -3.13651323e-01f, -1.73019573e-01f, -1.87641039e-01f, 1.87029302e-01f, -3.87386650e-01f,
  -3.44027072e-01f, 7.07417950e-02f, 4.57275547e-02f, 6.60850406e-02f, -1.23177134e-01f, -3.35629374e-01f, -1.42032310e-01f, -7.65633658e-02f, 8.35547671e-02f, -1.54901862e-01f,
  8.13186094e-02f, -2.06574379e-03f, -2.52990961e-01f, 9.12695304e-02f, 2.45515760e-02f, 1.32632822e-01f, 7.97817484e-02f, -2.21440732e-01f, -2.98414681e-24f, -2.18102187e-01f,
  -5.54190695e-01f, -3.04204058e-02f, 1.06990673e-01f, -1.98260732e-02f, -4.79035079e-01f, 1.62243605e-01f, 3.01991671e-01f, -2.15517148e-01f, -3.10510229e-02f, 1.21279404e-01f,
  -1.51992813e-01f, 8.87289345e-02f, 1.27083421e-01f, 2.53385697e-02f, -8.06215033e-02f, 3.28096420e-01f, -1.24044940e-01f, 3.39195967e-01f, -1.82840198e-01f, 1.16623595e-01f,
  -2.20243990e-01f, -1.24988155e-02f, -2.37304624e-02f, -1.01130866e-01f, -6.80920556e-02f, -2.59469301e-01f, -1.85519308e-01f, 4.55681458e-02f, 6.97850809e-02f, 1.06638573e-01f,
  -1.49570286e-01f, 5.14263064e-02f, 1.23454429e-01f, -1.33076161e-01f, -4.18265492e-01f, 2.95085441e-02f, -3.07718426e-01f, 1.86506100e-02f, 1.37665272e-01f, -3.87877822e-02f,
  -2.33938128e-01f, 1.47063091e-01f, -1.04015857e-01f, 9.79777053e-02f, -1.09582074e-01f, 5.33319898e-02f, 5.95961064e-02f, 1.22855701e-01f, 1.66322216e-02f, -6.29433542e-02f,
  -3.61880183e-01f, 1.01888709e-01f, 1.65894516e-02f, 1.72077671e-01f, -8.33198428e-02f, -1.32128835e-01f, 1.91138193e-01f, 3.10659073e-02f, -1.07342131e-01f, -2.29144059e-02f,
  -2.32889891e-01f, -1.42009659e-02f, -1.11811283e-19f, -3.18804890e-01f, 3.15613449e-02f, -2.75589645e-01f, 1.40790995e-02f, 2.00465679e-01f, -4.87446599e-02f, 1.30658999e-01f,
  9.60308239e-02f, 2.42597476e-01f, 2.69001424e-01f, -1.97639257e-01f, 1.87241495e-01f, -1.35354787e-01f, 6.03373274e-02f, 1.51831493e-01f, -3.46336931e-01f, 4.42598253e-01f,
  -1.41399592e-01f, -2.93542862e-01f, -1.69650316e-01f, 6.34954348e-02f, -2.35625044e-01f, -4.35186654e-01f, 4.36868239e-03f, -2.85434783e-01f, -2.93419749e-01f, 1.63360298e-01f,
  -2.22184747e-01f, 6.91994280e-02f, 3.22982706e-02f, 2.59530209e-02f, -1.77491695e-01f, -4.16844897e-02f, -6.62781373e-02f, -2.97114760e-01f, -7.78876618e-02f, -3.70077938e-02f,
  2.20283613e-01f, 3.54678789e-03f, 1.41513599e-02f, 1.49670362e-01f, -1.70669749e-01f, 1.94432437e-01f, 2.07386434e-01f, 2.14362249e-01f, -1.79341827e-02f, 8.95531252e-02f,
  -4.38832119e-02f, -1.78968057e-01f, -1.43608406e-01f, 7.26154000e-02f, -1.40364051e-01f, -6.23402633e-02f, -5.69179237e-01f, 4.83269058e-02f, 1.51981056e-01f, -7.95858447e-03f,
  -1.81142583e-01f, 1.24971658e-01f, -4.85934705e-01f, 7.48513937e-02f, 2.46593684e-01f, -2.04666868e-01f, -2.41462466e-23f, -1.41921535e-01f, 1.66719824e-01f, -1.63596764e-01f,
  -2.19278466e-02f, 3.52453813e-02f, 2.22723737e-01f, -3.66369605e-01f, 2.32332740e-02f, -1.39763072e-01f, -5.77693060e-02f, 1.06408689e-02f, 1.41570345e-01f, -9.52308029e-02f,
  7.92074576e-02f, 1.35166481e-01f, -2.13210776e-01f, 1.13930516e-01f, -4.25958000e-02f, 1.93633765e-01f, 6.13894984e-02f, -1.20448001e-01f, -2.72502396e-02f, 2.61716038e-01f,
  -3.12031329e-01f, -2.41788432e-01f, -1.46465808e-01f, 5.59800491e-02f, -1.69188678e-02f, -4.49155182e-01f, -9.62016135e-02f, -4.29967403e-01f, -1.87718809e-01f, -1.30465493e-01f,
  -4.65737395e-02f, -5.24234995e-02f, -1.17049292e-01f, -4.46741953e-02f, 2.78306901e-01f, -2.53576587e-11f, 4.95371111e-02f, -3.99252951e-01f, -3.36957753e-01f, -2.19055548e-01f,
  -1.06250063e-01f, -1.91424135e-02f, -6.33215904e-02f, 3.61335054e-02f, 1.24575667e-01f, -1.38358861e-01f, 2.15071395e-01f, -1.08978495e-01f, 1.87769115e-01f, -1.61784574e-01f,
  1.52618885e-01f, -1.56494752e-01f, -1.57272488e-01f, 3.46665770e-01f, 4.44044508e-02f, 7.89328068e-02f, 1.45575762e-01f, 5.76881021e-02f, -2.83373892e-01f, 1.58151031e-01f,
  -2.67701587e-15f, 7.01767718e-03f, 1.23736389e-01f, 3.13282579e-01f, -2.44593814e-01f, -3.59701484e-01f, 5.70275933e-02f, -1.06224746e-01f, -1.30716503e-01f, -1.99435372e-02f,
  -6.96163625e-02f, -1.11026600e-01f, 1.42746614e-02f, 1.14799887e-01f, -6.70554563e-02f, -2.59832799e-01f, 1.12004042e-01f, -7.90999159e-02f, -1.09810859e-01f, 6.81136400e-02f,
  -1.62825897e-01f, 1.39338776e-01f, -7.09779561e-02f, -1.33817121e-01f, -4.32531983e-02f, 8.97714868e-02f, 1.22675247e-01f, -6.36840388e-02f, -2.03221831e-02f, 2.25401059e-01f,
  -9.70411897e-02f, 7.30576143e-02f, 1.91652134e-01f, 1.81720451e-01f, -6.53233528e-02f, -2.34621707e-02f, -1.86553821e-01f, -2.00426400e-01f, -3.59780550e-01f, -9.58775563e-05f,
  -1.69382706e-01f, -6.51109815e-02f, 2.38461971e-01f, 1.71162948e-01f, -1.45820886e-01f, -2.40691304e-01f, -3.43141668e-02f, 1.56148240e-01f, -3.63956124e-01f, 4.73817289e-02f,
  7.76009783e-02f, 1.98458254e-01f, 8.84858817e-02f, -1.77409917e-01f, -1.66937247e-01f, -1.12800941e-01f, 7.82759339e-02f, 1.73688252e-02f, 5.21187223e-02f, -2.07988888e-01f,
  6.12713993e-02f, 9.21011195e-02f, 1.87153816e-01f, -7.32440278e-02f, -3.14729702e-21f, -1.18343756e-01f, -3.12648192e-02f, -6.97845593e-02f, -2.56886154e-01f, -2.52771318e-01f,
  -1.83118448e-01f, 1.43938400e-02f, 1.44519001e-01f, -7.73880407e-02f, 5.32086240e-03f, -6.50357604e-02f, -1.20939024e-01f, 7.96082318e-02f, -1.77655056e-01f, -2.95921654e-01f,
  -1.50636490e-02f, 2.68871456e-01f, 2.39562429e-02f, 1.51145756e-01f, 1.86662320e-02f, -7.60412663e-02f, -1.54403210e-01f, 4.20506954e-01f, 1.25135809e-01f, 2.43944973e-01f,
  -2.72224784e-01f, 1.52048260e-01f, -9.09328461e-02f, -3.25955480e-01f, -3.08933139e-01f, -8.78043547e-02f, 1.51509568e-01f, -2.89481461e-01f, 2.93360442e-01f, -5.66040585e-03f,
  1.62239283e-01f, 4.62026261e-02f, 4.02436182e-02f, 7.18070714e-09f, 2.05341101e-01f, 2.36198336e-01f, -7.28636011e-02f, 1.27571085e-02f, -3.39145698e-02f, 1.46911278e-01f,
  -4.62388657e-02f, -3.06124687e-01f, -1.46265283e-01f, 2.06414461e-02f, -1.05189048e-02f, 9.52074751e-02f, -1.37078270e-01f, -1.31784901e-01f, -2.21931905e-01f, -5.49563646e-01f,
  -6.98486790e-02f, -2.61263438e-02f, -2.36867294e-01f, -3.87174964e-01f, 2.15817839e-01f, -3.63564372e-01f, 2.15643451e-01f, -1.42063513e-01f, -8.50919869e-19f, -1.03862889e-01f,
  2.00702533e-01f, -8.26558545e-02f, -9.88578796e-02f, -4.17042583e-01f, 8.82039964e-02f, -7.92134330e-02f, -3.11190188e-01f, 1.41154408e-01f, 2.46208400e-01f, 6.66991472e-02f,
  -1.45996913e-01f, -1.69076160e-01f, -3.91591489e-02f, 2.37446174e-01f, -1.33414268e-01f, -9.02421772e-02f, -5.96152395e-02f, 2.46379912e-01f, -3.60024571e-02f, -6.45095855e-02f,
  -5.32933295e-01f, -3.50568652e-01f, -3.36391985e-01f, 3.08946967e-02f, 2.49614324e-02f, 8.02711695e-02f, -2.42122691e-02f, -1.41776338e-01f, -5.22636414e-01f, -1.66476667e-01f,
  2.21279651e-01f, 1.90712988e-01f, -1.08674124e-01f, -3.79052497e-02f, -4.28217165e-02f, 1.89902112e-01f, -5.72257824e-02f, 2.51153391e-03f, 1.72049791e-01f, -8.18179548e-02f,
  1.77969337e-01f, -2.14251921e-01f, -9.28086415e-02f, -1.36526257e-01f, 1.50208682e-01f, 1.39573887e-01f, -2.57127851e-01f, 1.41481072e-01f, 1.63414583e-01f, 1.29161075e-01f,
  1.58724952e-02f, -1.31822735e-01f, -2.29459815e-02f, -1.11803994e-01f, -2.49936551e-01f, -3.36384401e-02f, -7.13397339e-02f, 1.56076998e-01f, 5.07945642e-02f, -1.09395171e-02f,
  -3.12057674e-01f, -5.67196943e-02f, 1.78370953e-19f, -2.38921836e-01f, 1.48283556e-01f, 2.43710317e-02f, -6.33501649e-01f, 1.67191491e-01f, 8.18168521e-02f, 2.91809160e-02f,
  1.83486745e-01f, 1.31595403e-01f, 7.90045336e-02f, 1.02511652e-01f, -1.44091006e-02f, 4.64412719e-02f, 6.34587556e-02f, -1.70393020e-01f, 8.32435861e-02f, -1.13934159e-01f,
  1.84076682e-01f, -1.69870332e-01f, 2.14551345e-01f, -3.35296661e-01f, -6.72596879e-03f, -1.79843456e-01f, 1.17668487e-01f, -4.09700334e-01f, 1.92115426e-01f, -4.86958735e-02f,
  -7.04017803e-02f, -1.68082714e-01f, 1.66052967e-01f, 3.02681606e-03f, 1.89820126e-01f, -1.61895499e-01f, 2.72179633e-01f, -2.65058652e-02f, -8.01726580e-02f, 1.65402576e-01f,
  -2.59179622e-01f, -7.37227965e-05f, 2.11296871e-01f, 6.62055686e-02f, 3.81535619e-01f, 3.71726044e-02f, 3.56109411e-01f, -7.65818357e-02f, -2.26297528e-01f, 7.20868036e-02f,
  1.35746881e-01f, 2.83859700e-01f, -3.19739103e-01f, -3.76105428e-01f, -1.15826465e-01f, -1.88473016e-01f, -3.07485193e-01f, -2.18857214e-01f, -3.43427867e-01f, -1.80423865e-03f,
  -1.93292201e-01f, 1.34358868e-01f, -9.08470228e-02f, -3.89509499e-01f, 1.33465335e-01f, -2.39309445e-01f, -4.19116776e-26f, -4.45127264e-02f, -3.47357869e-01f, -2.52373870e-02f,
  1.89108089e-01f, -1.02626219e-01f, 1.45665541e-01f, -3.99624676e-01f, 8.25100299e-03f, -1.17405811e-02f, -7.38255084e-02f, 2.38848925e-02f, 8.46856236e-02f, -1.43580824e-01f,
  1.45922065e-01f, 1.75372526e-01f, -2.72743739e-02f, 1.16676107e-01f, -2.07904130e-01f, -3.47994864e-01f, 1.89889863e-01f, -2.87886232e-01f, -2.96609793e-02f, -3.95888239e-01f,
  1.14277028e-01f, -3.11950117e-01f, -2.46026397e-01f, 1.18462294e-01f, -4.30488866e-03f, -5.30579686e-03f, -3.49406600e-01f, -2.11635008e-02f, -3.58165652e-01f, -1.94298278e-03f,
  1.69496492e-01f, -1.01321714e-03f, 1.37900680e-01f, -3.85546565e-01f, 4.81432490e-02f, -6.88960031e-03f, -2.60024071e-02f, -1.23387903e-01f, -2.32355818e-01f, 1.64444353e-02f,
  4.99898195e-02f, 1.23890571e-01f, -1.34906396e-01f, 1.81754291e-01f, 1.43803582e-01f, -1.78459853e-01f, 1.18917920e-01f, -1.30505294e-01f, 1.06802374e-01f, -2.67238796e-01f,
  2.65912712e-01f, -1.15905538e-01f, 2.10665673e-01f, -1.54146031e-01f, -2.32825696e-01f, -2.77928412e-01f, -9.70121920e-02f, 3.94277722e-02f, 2.69982010e-01f, 4.60849404e-02f,
  7.64995689e-15f, -2.64851674e-02f, 3.92992198e-02f, -1.88772038e-01f, -2.04152584e-01f, -2.14817882e-01f, -7.18306601e-02f, 1.81586623e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.50569499e-01f, 1.46116078e-01f, 1.23384468e-01f, -1.19408192e-02f, -1.54974004e-02f, -2.52051558e-03f, 1.71069521e-02f, 6.66862875e-02f, -3.14131193e-02f, 4.93102670e-02f,
  -3.79664749e-02f, 2.27406304e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    