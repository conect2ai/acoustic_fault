/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.54116976e-02f, -1.21098973e-01f, 1.70194045e-01f, -3.67210545e-02f, -7.02440962e-02f, 3.40410918e-01f, 2.02665791e-01f, -2.75330115e-02f, 2.56262571e-01f, -3.10965776e-01f,
  3.65757607e-02f, -3.74450177e-01f, 1.00891851e-01f, -1.35362461e-01f, 3.48520041e-01f, 2.84034640e-01f, 1.71882823e-01f, 9.59911756e-03f, 1.51113957e-01f, -2.16822531e-02f,
  1.28017738e-01f, -1.24297656e-01f, -1.36556318e-02f, -1.56194344e-01f, -3.09985161e-01f, -1.28164276e-01f, -3.31899345e-01f, -8.33647028e-02f, -2.63790578e-01f, -4.89336327e-02f,
  7.59091675e-02f, 3.01448628e-02f, -5.49194291e-02f, 1.09830365e-01f, -2.79453713e-02f, -1.18999131e-01f, -4.77735847e-02f, -7.00287670e-02f, 4.80887555e-02f, -4.33555804e-03f,
  -7.29872435e-02f, -3.11226379e-02f, 7.97089338e-02f, -4.70143519e-02f, -2.32128473e-03f, -2.28444897e-02f, -2.08235830e-02f, -2.56589241e-02f, -5.95000125e-02f, -1.19294983e-03f,
  8.17621648e-02f, 4.97264266e-02f, 1.01337940e-01f, -4.99880016e-02f, 5.16854301e-02f, 3.62839513e-02f, 4.52471599e-02f, 9.35298484e-03f, 8.34847912e-02f, 6.90163299e-02f,
  -3.89547572e-02f, 4.91366684e-02f, -6.57801926e-02f, -3.30778137e-02f, 2.19882391e-02f, -7.41084218e-02f, -5.71819805e-02f, -6.07047640e-02f, -1.34316087e-01f, 4.77722706e-03f,
  5.46284160e-03f, -9.62831255e-04f, 4.62010652e-02f, 3.49671021e-02f, -1.60838757e-02f, -1.55291045e-02f, -9.48224589e-03f, 5.44544542e-03f, 9.97540429e-02f, -7.00196102e-02f,
  -8.09701309e-02f, 7.17650577e-02f, -3.01168556e-03f, -4.14039493e-02f, 1.20751500e-01f, -8.10855925e-02f, -6.17369562e-02f, 3.27987857e-02f, -5.86923547e-02f, -5.72005175e-02f,
  1.83756948e-01f, -6.03912026e-02f, 1.29999898e-04f, 1.21262101e-02f, -3.36763375e-02f, -9.56057757e-02f, 3.09429746e-02f, -2.53264327e-02f, 7.11090341e-02f, -4.60237265e-02f,
  -2.89383456e-02f, -8.89537930e-02f, -2.45532747e-02f, 5.12578748e-02f, 7.80572966e-02f, 4.58728410e-02f, 4.82287109e-02f, -2.05663070e-02f, -7.77807552e-03f, -1.72598511e-02f,
  -1.81931835e-02f, -1.12637736e-01f, -4.60839532e-02f, -7.84432963e-02f, -1.61600355e-02f, -8.49575922e-02f, -1.01929784e-01f, 7.33653009e-02f, 5.05922250e-02f, -1.55796017e-02f,
  4.68331903e-01f, -1.58015519e-01f, -2.51666665e-01f, 1.03557229e-01f, 3.09660494e-01f, 1.56273231e-01f, 2.70268172e-01f, -8.24199915e-02f, -1.01546086e-02f, -9.15270001e-02f,
  6.52337819e-02f, 1.34587616e-01f, -1.64030418e-01f, -1.58674151e-01f, -1.70609094e-02f, -2.23961860e-01f, 3.02140368e-03f, 1.64059967e-01f, -2.03968197e-01f, 9.55971852e-02f,
  -8.09587538e-02f, 7.78372511e-02f, -2.01281995e-01f, -4.35198881e-02f, 7.04968795e-02f, 5.46121597e-02f, 6.52224720e-02f, -1.16118014e-01f, 1.69632658e-01f, 1.36964634e-01f,
  1.12240970e-01f, -1.72933191e-01f, 7.83998985e-03f, -9.18033347e-02f, 4.46572863e-02f, 5.09691164e-02f, 1.62965767e-02f, -8.42375979e-02f, -1.36808194e-02f, -2.30267476e-02f,
  9.20259580e-02f, -1.17561668e-02f, -1.52937844e-02f, -5.53093143e-02f, 2.71313414e-02f, -5.50464503e-02f, -1.14717260e-01f, 2.92141791e-02f, -1.12251781e-01f, -9.20061953e-03f,
  -5.36579974e-02f, -5.87919280e-02f, -2.30205450e-02f, -1.28687471e-02f, -3.18285637e-02f, -1.30466875e-02f, 7.59604061e-03f, 7.25755170e-02f, 1.24114387e-01f, 6.08928688e-02f,
  -8.58859643e-02f, -9.04954150e-02f, 3.01831737e-02f, -2.09356528e-02f, 5.54933073e-03f, 1.76276416e-02f, -7.29083316e-03f, -2.09274478e-02f, 3.46140973e-02f, -1.62136252e-03f,
  1.24775231e-01f, 6.66873083e-02f, -7.71958660e-03f, 3.54172029e-02f, 5.87353520e-02f, 1.43836597e-02f, 8.69041756e-02f, 1.19030640e-01f, 5.89865781e-02f, -6.04141410e-03f,
  -4.59117889e-02f, 1.02322260e-02f, -2.80596800e-02f, 1.65127870e-03f, 9.80864558e-03f, -3.36305685e-02f, -4.09875289e-02f, -5.47246076e-02f, 4.96047437e-02f, 8.18310305e-02f,
  2.44972765e-01f, -7.00230850e-03f, 1.20579572e-02f, 1.09715402e-01f, 6.63420260e-02f, -3.51831913e-02f, -4.26144786e-02f, 2.33297125e-02f, -9.66194868e-02f, 7.32346550e-02f,
  2.40901131e-02f, 2.54539750e-03f, 1.49230942e-01f, 6.21907152e-02f, 6.52903095e-02f, -3.14144487e-03f, 7.23661929e-02f, 8.72501805e-02f, 1.94151357e-01f, 2.05124263e-03f,
  -4.07126285e-02f, 9.16237310e-02f, -6.71078786e-02f, 1.13969985e-02f, 1.47498190e-01f, 3.30958441e-02f, 8.48146304e-02f, -7.46778026e-02f, 2.62844358e-02f, -1.92223340e-02f,
  2.66569197e-01f, -5.10577969e-02f, -4.31506941e-03f, 2.25049302e-01f, -1.77179471e-01f, 3.33407789e-01f, 2.72454828e-01f, -1.96773186e-01f, 1.16180442e-02f, 1.23539045e-01f,
  2.16117457e-01f, 1.41532168e-01f, -7.09924400e-02f, 4.04051185e-01f, 5.06092049e-02f, 7.72504061e-02f, 3.99695963e-01f, 3.93933684e-01f, -9.38443393e-02f, 9.30490643e-02f,
  3.70769086e-03f, 3.77835520e-02f, 2.83543412e-02f, -3.52012902e-01f, 1.43019974e-01f, -2.87052721e-01f, -2.05178455e-01f, -2.00318769e-01f, 2.38103226e-01f, 4.95207831e-02f,
  2.08475694e-01f, -5.19940145e-02f, -2.45916415e-02f, -3.56174521e-02f, 3.76298837e-02f, 1.51781477e-02f, 1.15017198e-01f, -5.96944652e-02f, -6.99347183e-02f, 1.09706922e-02f,
  4.73691244e-03f, -7.65458420e-02f, -7.45235831e-02f, -6.76513612e-02f, -3.61964642e-03f, -2.17438824e-02f, 8.92122276e-03f, 1.34913683e-01f, -5.50665185e-02f, 9.60716698e-03f,
  1.02326058e-01f, 1.05206847e-01f, 1.21092014e-01f, 2.63430942e-02f, 6.07310757e-02f, 4.32478860e-02f, 2.43348740e-02f, 3.42743322e-02f, -1.97140835e-02f, -5.99003546e-02f,
  -1.78861972e-02f, 4.62126583e-02f, 7.43060932e-02f, 1.82520933e-02f, 2.16751620e-02f, -3.23862582e-02f, 3.21121551e-02f, 1.25082890e-02f, -3.17213647e-02f, 4.77591120e-02f,
  5.59490174e-03f, -2.28369441e-02f, -1.10883890e-02f, 2.79076491e-02f, 5.42253554e-02f, -5.31225689e-02f, 1.35175083e-02f, 1.89794861e-02f, 8.49468336e-02f, 2.66179871e-02f,
  -2.05425955e-02f, 3.46335210e-02f, 4.86074314e-02f, -3.13529484e-02f, 1.83522534e-02f, 2.53867358e-02f, 5.02716415e-02f, 6.04248792e-02f, 4.29455824e-02f, 5.34562347e-03f,
  5.62269278e-02f, -9.97657776e-02f, -3.01441718e-02f, -4.37504463e-02f, -1.51731959e-02f, 6.49048537e-02f, 1.61322095e-02f, -9.15609766e-03f, -3.05374321e-02f, 3.07036024e-02f,
  5.30516095e-02f, 4.99188248e-03f, -2.16206033e-02f, 4.20714393e-02f, 4.32540588e-02f, 4.25873417e-03f, 5.14456183e-02f, -6.81436285e-02f, -1.63481082e-03f, -1.45647451e-02f,
  -9.14328173e-03f, -1.05547709e-02f, -3.44422869e-02f, -9.82565656e-02f, 3.03744078e-02f, -7.41691962e-02f, -2.20149290e-02f, -2.77910512e-02f, 9.53975075e-04f, 5.26195802e-02f,
  -3.87772322e-01f, 4.24871296e-02f, 1.26468450e-01f, -3.70491594e-01f, -5.18828332e-02f, 2.33457889e-02f, 8.49750116e-02f, -1.55775800e-01f, -2.97005117e-01f, 3.03660985e-02f,
  8.92056823e-02f, -1.58368602e-01f, 3.16822112e-01f, -1.98588997e-01f, -1.72667623e-01f, 1.59414053e-01f, -2.09415883e-01f, -1.21517040e-01f, 2.69109067e-02f, -9.42608118e-02f,
  -2.54364073e-01f, -3.04374069e-01f, 7.27405027e-02f, -9.83565003e-02f, -1.76812410e-01f, -9.16434526e-02f, -2.34430972e-02f, 1.95163295e-01f, -9.95945632e-02f, -1.43282134e-02f,
  -1.34822786e-01f, -1.17663920e-01f, 1.36418402e-01f, 1.47711327e-02f, -4.45247516e-02f, 4.90972959e-02f, -3.67680821e-03f, 1.19167648e-01f, 5.32873981e-02f, 1.62580013e-02f,
  1.04540423e-01f, -2.77290531e-02f, -3.20156664e-02f, -1.90566108e-02f, -2.79630553e-02f, 7.10086478e-03f, -3.76492366e-02f, 9.31194127e-02f, -1.30115887e-02f, -2.22189836e-02f,
  6.49167672e-02f, -1.90874655e-02f, 3.93364280e-02f, 9.96528892e-04f, 2.62509603e-02f, 8.88182819e-02f, -1.50952507e-02f, 1.12026528e-01f, -1.16957448e-01f, -1.02668628e-01f,
  3.88251022e-02f, 4.22078446e-02f, 2.94589158e-03f, -1.27596231e-02f, -2.33962983e-02f, -7.13075101e-02f, 5.07151820e-02f, 5.23048267e-02f, 7.88681675e-03f, 1.19692041e-02f,
  -6.77897334e-02f, -5.84165119e-02f, -7.14744478e-02f, -4.24467633e-03f, 8.22229311e-03f, -7.50802457e-02f, 1.05724469e-01f, -9.34989378e-02f, -1.26589900e-02f, -2.59707179e-02f,
  9.86554878e-05f, -1.70117300e-02f, -1.19729824e-02f, 6.88472092e-02f, 2.79715136e-02f, 4.87230569e-02f, 2.22944953e-02f, -1.81468427e-02f, 3.51044573e-02f, 8.58423933e-02f,
  -2.00712770e-01f, -3.66844803e-01f, 2.76661161e-02f, -8.81262869e-03f, -3.84695269e-02f, -3.08771990e-02f, 1.19376043e-03f, -1.07417554e-02f, 1.84192825e-02f, -2.84293126e-02f,
  4.09786357e-03f, -6.40056506e-02f, -7.82348774e-03f, 5.67455217e-02f, 3.49136144e-02f, -3.55248600e-02f, 6.44325539e-02f, -4.36719954e-02f, -3.53404246e-02f, -9.50705335e-02f,
  -1.07769044e-02f, 3.50428261e-02f, 5.14847226e-02f, -4.15832773e-02f, 2.28207149e-02f, -4.27315310e-02f, -1.29040807e-01f, 5.37986401e-03f, 9.92080197e-02f, 3.89500186e-02f,
  4.38282639e-01f, -3.09178770e-01f, 2.43573204e-01f, 3.17595489e-02f, -1.94188654e-01f, -8.97915140e-02f, -1.15728274e-01f, -1.52019799e-01f, -1.20088778e-01f, -2.66759425e-01f,
  -1.72779053e-01f, 3.24164957e-01f, -1.19126663e-01f, -2.77754635e-01f, 3.99417281e-01f, -6.14634641e-02f, 5.40071167e-02f, -1.61290914e-02f, -1.62913371e-02f, -2.61320882e-02f,
  1.37112468e-01f, -3.60434860e-01f, 8.32253844e-02f, -3.51999640e-01f, -1.66765124e-01f, 4.80127186e-02f, 1.21049285e-01f, -2.53794412e-03f, 1.63242519e-02f, 7.21025094e-02f,
  -1.00303786e-02f, -9.78062376e-02f, 9.62601625e-04f, -6.41450658e-02f, 1.52349221e-02f, 3.44129764e-02f, 9.64163020e-02f, 2.39942297e-02f, 7.72530288e-02f, 9.05271340e-03f,
  6.83174282e-02f, 6.99382927e-03f, -8.81581679e-02f, -7.90295601e-02f, -6.41824901e-02f, 5.43352775e-02f, 4.76989709e-02f, 5.50007299e-02f, -1.50824144e-01f, 8.59971344e-02f,
  3.07154972e-02f, 1.36520654e-01f, 1.09226421e-01f, 8.16574842e-02f, 9.66083109e-02f, 2.25580465e-02f, 4.30182368e-02f, 7.03356490e-02f, 9.23446566e-02f, 2.77782865e-02f,
  -3.95526513e-02f, 4.91035171e-03f, -6.92300173e-03f, -2.13183071e-02f, -1.06881469e-01f, -2.73084617e-03f, -5.55103123e-02f, 2.33565457e-02f, 1.04459859e-01f, -1.32910174e-03f,
  1.31282449e-01f, -6.61896728e-03f, -9.22698528e-02f, 4.10751328e-02f, 3.75017780e-03f, -4.46866490e-02f, 8.45223516e-02f, 8.52437632e-04f, 2.44283658e-02f, 6.85724691e-02f,
  -3.23848799e-02f, 7.20744673e-03f, -2.95912977e-02f, -7.86565524e-03f, -6.35528266e-02f, 6.14506602e-02f, -1.03335880e-01f, 3.32152210e-02f, 4.07544151e-03f, 1.85738131e-02f,
  -5.43203875e-02f, -6.77836761e-02f, -7.58071691e-02f, -3.49109173e-02f, 1.02261333e-02f, -2.26468183e-02f, 1.23725552e-02f, -3.82947810e-02f, -1.61603577e-02f, -6.12740032e-02f,
  7.58721828e-02f, -3.41497026e-02f, 8.74250457e-02f, 5.50507493e-02f, 3.06780469e-02f, 3.91724594e-02f, 2.51124706e-02f, 2.11940221e-02f, 9.82643142e-02f, 3.85450907e-02f,
  3.10367662e-02f, -2.14828178e-02f, -3.17197246e-03f, -1.14407547e-01f, -3.52853276e-02f, 4.59606536e-02f, 3.72191630e-02f, 3.38876843e-02f, 1.78483501e-02f, -2.66034584e-02f,
  -2.65975654e-01f, 6.63493648e-02f, 3.45391572e-01f, 8.86787102e-02f, -2.25706160e-01f, 1.51699126e-01f, -6.54643923e-02f, -5.01568243e-02f, -4.03422505e-01f, -2.96498593e-02f,
  -2.64489036e-02f, -1.68061242e-01f, -2.63174564e-01f, -9.48387608e-02f, 1.30847901e-01f, -2.52035260e-01f, 9.88253281e-02f, 5.94980717e-02f, -1.03804037e-01f, 1.07516952e-01f,
  -3.20948362e-02f, -1.42546475e-01f, 1.21468954e-01f, 1.66192040e-01f, 1.49159536e-01f, 1.84224188e-01f, 2.25560442e-01f, 1.14517577e-01f, 2.74653792e-01f, 8.03616717e-02f,
  -7.66338482e-02f, -2.34041229e-01f, -2.75468919e-02f, 9.14795548e-02f, 1.18226595e-01f, 8.70542228e-02f, 1.71249658e-01f, 5.98317795e-02f, -1.12328440e-01f, -5.74327745e-02f,
  2.56512593e-02f, -9.42567736e-02f, -2.82282848e-02f, -1.14347197e-01f, -6.71134740e-02f, -3.00649460e-02f, -3.43802683e-02f, 3.73682119e-02f, -1.09483458e-01f, -5.71910739e-02f,
  -4.94732670e-02f, 5.26331365e-02f, 6.43803105e-02f, 7.61429071e-02f, 3.97251211e-02f, -7.11052120e-02f, 3.19635645e-02f, 1.14327185e-01f, 4.82329391e-02f, 1.89376045e-02f,
  3.51919271e-02f, -1.23126972e-02f, -4.15341556e-02f, 8.52309691e-04f, -3.49985212e-02f, 1.06562153e-02f, -1.05648324e-01f, 5.35992607e-02f, 3.45814265e-02f, -2.67211217e-02f,
  3.11379805e-02f, -3.14050876e-02f, -6.23322744e-03f, -2.62939725e-02f, -5.09611592e-02f, -1.84800453e-03f, 6.01326935e-02f, 1.46838622e-02f, 2.84744110e-02f, 5.30912317e-02f,
  -1.35623306e-01f, 1.05799742e-01f, -2.16113646e-02f, 4.27129082e-02f, 3.00923530e-02f, -2.38988418e-02f, 6.94749430e-02f, -1.05279125e-02f, 3.57165188e-02f, 1.19564682e-01f,
  1.42047569e-01f, 2.00954869e-01f, -4.99557965e-02f, -3.45538221e-02f, -1.26661714e-02f, -6.22221082e-03f, 1.47615736e-02f, 4.02042083e-03f, 5.92035241e-02f, 8.64963010e-02f,
  1.64576203e-01f, 2.06860732e-02f, 1.52139187e-01f, 1.57032604e-03f, 8.48240554e-02f, 2.81884912e-02f, 7.24399313e-02f, 5.94661199e-03f, 1.59564063e-01f, 4.63947840e-02f,
  8.22283775e-02f, -8.26725736e-03f, 4.65519279e-02f, -4.78829592e-02f, 1.25121459e-01f, 5.63061163e-02f, 5.33479042e-02f, -1.71184003e-01f, 1.07998617e-01f, 2.54750866e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.09998867e-01f, -5.54758251e-01f, 4.11972776e-02f, 3.72946084e-01f, -2.67475843e-01f, -2.99402922e-01f, 1.64311945e-01f, -3.75436574e-01f, 1.92525372e-01f, -4.03189749e-01f,
  7.20384344e-02f, 2.82741725e-01f, 2.27254987e-01f, -5.39749935e-02f, 6.23888254e-01f, 4.28365320e-01f, -1.38766736e-01f, 1.77260935e-01f, 1.34044290e-01f, -1.59444600e-01f,
  6.53144494e-02f, -1.73937663e-01f, 1.29894957e-01f, -4.22872990e-01f, -3.79544526e-01f, -1.28895000e-01f, 2.22706094e-01f, -6.70212507e-02f, -2.75165528e-01f, 8.35123733e-02f,
  -3.73331457e-01f, -7.88161010e-02f, -1.24572247e-01f, -7.51193836e-02f, -1.70866728e-01f, 7.71491742e-03f, 7.31857792e-02f, 1.71602055e-01f, 1.33964524e-01f, -7.79725239e-02f,
  5.84483100e-03f, -1.47979721e-01f, -1.48347452e-01f, -2.34218184e-02f, -1.65501565e-01f, -8.33793953e-02f, -6.44808933e-02f, -1.79746598e-01f, -9.42825526e-02f, -2.23947316e-02f,
  -6.42562807e-02f, -1.74201075e-02f, -1.18041607e-02f, -1.72564797e-02f, 1.13228373e-01f, -8.37146416e-02f, 3.64171490e-02f, 2.12524503e-01f, -1.51279895e-02f, 9.26036015e-03f,
  1.12834303e-02f, 1.03487603e-01f, -1.08385302e-01f, 5.61382100e-02f, 5.07551953e-02f, 3.76651846e-02f, -5.54865226e-02f, 3.72574441e-02f, -5.48896156e-02f, 3.01656835e-02f,
  -3.91429700e-02f, 1.05797060e-01f, -5.74655496e-02f, 1.88734115e-03f, 3.07039414e-02f, 4.27101217e-02f, 5.96239418e-03f, -1.30401492e-01f, -1.20190136e-01f, -6.36739507e-02f,
  -3.51308733e-02f, -7.18305483e-02f, -6.72473237e-02f, -5.20986803e-02f, -6.23210520e-02f, 5.58088906e-02f, -5.47182560e-02f, -7.89904818e-02f, 4.55281213e-02f, -7.17814267e-02f,
  -3.59796643e-01f, -1.09024920e-01f, -7.34253153e-02f, -9.06713083e-02f, 5.95024005e-02f, -1.61164388e-01f, 4.21652459e-02f, 1.12851681e-02f, 2.99302824e-02f, -3.83626521e-02f,
  -1.71518132e-01f, 2.05125492e-02f, -7.75651308e-03f, 1.18794087e-02f, -2.35648546e-03f, -5.20518012e-02f, 9.40515772e-02f, 5.06311134e-02f, 1.10335454e-01f, 3.59139740e-02f,
  -2.92549618e-02f, 9.11816396e-03f, 5.64432470e-03f, -9.63781849e-02f, -5.61592244e-02f, -1.31320739e-02f, 4.83202003e-02f, -9.52227637e-02f, 4.82683927e-02f, 5.82837947e-02f,
  1.75099224e-01f, 4.47395891e-01f, -2.06906140e-01f, 1.01507559e-01f, -2.21878976e-01f, 2.20516905e-01f, 5.06166518e-01f, -7.38574937e-02f, -2.37199411e-01f, 4.20447916e-01f,
  2.02890068e-01f, -1.30631730e-01f, 3.56409162e-01f, 4.54425246e-01f, 3.05143893e-02f, 4.59606528e-01f, 4.99172151e-01f, 2.82465398e-01f, -2.09517762e-01f, 1.48689851e-01f,
  -5.06057777e-02f, 4.22508568e-01f, 1.60694763e-01f, -8.85172039e-02f, 1.84852228e-01f, -3.36047202e-01f, 2.26229385e-01f, -3.29883665e-01f, 4.99275960e-02f, -4.53476496e-02f,
  6.78712651e-02f, 5.23832291e-02f, -5.46933189e-02f, -5.00703454e-02f, 1.56827107e-01f, -3.43645476e-02f, 3.81506048e-02f, 1.38747804e-02f, -2.43080258e-01f, 3.79157886e-02f,
  3.87844928e-02f, -4.45266441e-02f, 1.98378265e-02f, -1.30474135e-01f, -1.22127004e-01f, -9.87859517e-02f, -1.09693594e-01f, -5.15773632e-02f, -6.04747050e-02f, 6.95180893e-02f,
  1.65196285e-02f, 2.73326617e-02f, 1.22770138e-01f, 1.12168804e-01f, -1.10777475e-01f, 7.16773942e-02f, 3.08401436e-02f, -8.94466508e-03f, -3.55715342e-02f, -1.07721910e-02f,
  -1.96120180e-02f, 2.12067664e-02f, 1.55578613e-01f, -1.49510652e-02f, 5.07405167e-03f, 2.77733784e-02f, -6.06591031e-02f, 2.17606500e-02f, -1.07385874e-01f, 1.66573912e-01f,
  -7.17606395e-02f, -4.47081366e-05f, 8.32834020e-02f, 3.17908451e-02f, 7.84750506e-02f, 1.01414509e-01f, -8.83091763e-02f, -1.27560068e-02f, -4.53131758e-02f, -4.42298949e-02f,
  -3.36318985e-02f, -2.95658298e-02f, -1.03763817e-02f, -1.19724218e-02f, 5.75329736e-02f, -3.90668446e-03f, 1.04574025e-01f, 8.50624219e-02f, 3.66480947e-02f, -3.51821296e-02f,
  1.04076855e-01f, 3.74978572e-01f, 2.94866506e-02f, 1.45161478e-02f, 2.26228917e-03f, 4.80650887e-02f, 9.82948858e-03f, 1.05273746e-01f, 3.36675905e-02f, 6.98336661e-02f,
  9.46926177e-02f, -3.08093615e-02f, -1.30481534e-02f, -9.63811055e-02f, -8.19455981e-02f, 1.27982602e-01f, 1.55655161e-01f, 2.10675076e-02f, 3.92770246e-02f, 3.60501893e-02f,
  6.00971691e-02f, 1.06062837e-01f, -1.51160583e-02f, 3.01793423e-02f, -6.33834489e-03f, 1.16431914e-01f, -6.43409938e-02f, -3.09069492e-02f, -1.06169023e-02f, 4.41074260e-02f,
  3.91086608e-01f, -9.00402889e-02f, 1.03446387e-01f, -2.09087819e-01f, -5.65071888e-02f, 3.17086279e-01f, 3.25127542e-01f, -4.00867462e-01f, -6.02380693e-01f, -3.20024610e-01f,
  -1.94563165e-01f, 9.96081755e-02f, 2.82156527e-01f, -8.46826881e-02f, 6.21477127e-01f, 2.20477179e-01f, -1.05234817e-01f, -8.34156200e-02f, -6.58685416e-02f, 2.23459482e-01f,
  5.50745577e-02f, 6.77078888e-02f, 3.37737173e-01f, -7.96141010e-03f, 1.23164639e-01f, -1.60658926e-01f, -5.24747483e-02f, 2.20857307e-01f, -2.22509578e-01f, -3.05150747e-02f,
  3.96639518e-02f, -1.74195603e-01f, 6.19431324e-02f, 2.02013925e-02f, -2.38242503e-02f, 5.44074215e-02f, -3.95922437e-02f, 2.19468132e-01f, -1.10506952e-01f, -1.09020703e-01f,
  1.69988617e-01f, 4.42517512e-02f, -1.29298002e-01f, 9.57386866e-02f, -1.51137292e-01f, -1.75590366e-01f, -6.68722689e-02f, -9.14139971e-02f, 1.19368896e-01f, 1.06759727e-01f,
  1.29176393e-01f, -8.52940679e-02f, -1.17424205e-01f, -1.76172480e-01f, 3.24996114e-02f, -1.95690304e-01f, 7.42543191e-02f, 1.20961182e-02f, -2.74846166e-01f, 3.98498103e-02f,
  7.23313913e-02f, 6.28646389e-02f, 5.19733913e-02f, -1.21421225e-01f, 6.09451346e-02f, -7.60848001e-02f, -8.96759704e-02f, -1.59854386e-02f, 8.18859562e-02f, 9.54340473e-02f,
  -2.26770580e-01f, -1.76725909e-01f, -8.01449046e-02f, -1.93783566e-01f, -1.04876305e-03f, 3.85413580e-02f, 1.72911942e-01f, -4.57511358e-02f, -2.14186572e-02f, 1.47500653e-02f,
  -8.98679495e-02f, 3.32666002e-02f, 3.86667298e-03f, -9.64387581e-02f, -2.81548891e-02f, 7.53017589e-02f, -9.67015028e-02f, -3.07400823e-02f, -5.18772751e-02f, 1.45009041e-01f,
  -4.33758013e-02f, 6.75524250e-02f, 5.28144017e-02f, -1.06031626e-01f, 2.26222426e-02f, -4.44986075e-02f, -5.14471456e-02f, -1.42970920e-01f, 1.31385243e-02f, 1.52042165e-01f,
  -1.39875740e-01f, 3.14694247e-03f, -6.22013025e-02f, -6.38847873e-02f, -6.26552030e-02f, -3.29844803e-02f, -2.40476299e-02f, -1.11381784e-02f, -1.56443939e-02f, 3.16496892e-03f,
  -9.27858520e-03f, 5.14263771e-02f, 8.02970380e-02f, -1.61165208e-01f, -9.88433287e-02f, -1.18800290e-01f, 5.80635741e-02f, -3.52382846e-02f, -6.77389503e-02f, -1.38062805e-01f,
  -7.30028808e-01f, 7.99083114e-02f, -4.48210567e-01f, -3.41599345e-01f, 1.21493623e-01f, -3.28183055e-01f, 9.31152180e-02f, -7.35328048e-02f, -1.92338109e-01f, 6.05848551e-01f,
  3.55185717e-01f, -4.29021776e-01f, 4.15979534e-01f, -2.43028954e-01f, -7.39120662e-01f, -1.38327017e-01f, -2.84656286e-01f, -1.20648436e-01f, -2.48076677e-01f, 3.97441536e-02f,
  -2.93768585e-01f, 1.36440434e-02f, -3.05092722e-01f, 3.58698338e-01f, -1.01076543e-01f, -3.43751274e-02f, 2.51405418e-01f, 1.76044732e-01f, -1.04773967e-02f, -2.28708908e-01f,
  3.39103565e-02f, -5.44670410e-02f, -6.00343049e-02f, -1.14121124e-01f, -4.63173427e-02f, 2.08281070e-01f, 9.23153162e-02f, -1.25716226e-02f, -4.96464036e-02f, -1.88871846e-02f,
  4.91129570e-02f, -1.17322803e-01f, -1.47794694e-01f, -7.45453984e-02f, 7.10502127e-03f, 1.73524360e-03f, -6.43217042e-02f, -2.10072510e-02f, -1.99661255e-02f, -2.59964645e-01f,
  -8.96912366e-02f, -6.47008345e-02f, 1.63244235e-03f, 1.51375197e-02f, -7.71811679e-02f, -3.68349105e-02f, -5.91131821e-02f, -7.86744803e-02f, 1.00881653e-02f, -1.98025838e-01f,
  6.33924156e-02f, 5.20363031e-03f, 4.15196829e-02f, -4.22177576e-02f, 1.46761518e-02f, 2.83879600e-02f, 5.91553859e-02f, 1.20622627e-02f, -4.69311066e-02f, -5.28572649e-02f,
  3.08731068e-02f, -1.01556763e-01f, 1.07176222e-01f, -2.16079224e-02f, -2.11887397e-02f, -4.85992841e-02f, -1.22472644e-02f, 7.12377056e-02f, -7.05686212e-02f, -3.32616381e-02f,
  7.70783871e-02f, -5.67261279e-02f, -5.40549285e-04f, 1.27974376e-01f, 2.26836260e-02f, -3.85427848e-02f, 5.99986315e-02f, -1.17533095e-01f, 3.43570136e-03f, 7.15118274e-02f,
  1.57987878e-01f, 8.44762474e-02f, 1.53719410e-02f, 4.56749089e-02f, -2.10678428e-02f, 3.69878821e-02f, -5.42074628e-02f, -1.13760099e-01f, -8.44913349e-02f, -5.44517003e-02f,
  6.95692748e-02f, 1.15085468e-01f, 1.09379500e-01f, 1.98334968e-03f, 1.11011546e-02f, -8.40826780e-02f, 1.79657355e-01f, 8.06412548e-02f, 3.10785323e-02f, 1.86799765e-02f,
  6.80838302e-02f, 1.22246854e-01f, -5.31385392e-02f, 8.31423104e-02f, 6.57084882e-02f, 3.28196660e-02f, -6.12466261e-02f, -2.70598698e-02f, 4.35299836e-02f, 4.43212688e-02f,
  1.87757179e-01f, 3.14465374e-01f, -2.52960250e-02f, 6.91798851e-02f, 3.50485623e-01f, 4.83857840e-01f, 3.66060704e-01f, 4.11441058e-01f, 5.90547681e-01f, -4.19426151e-02f,
  -1.22948214e-01f, 8.82094353e-02f, -2.54840795e-02f, -7.02696592e-02f, 4.21999604e-01f, 5.71659170e-02f, 2.72503942e-01f, 1.70286626e-01f, 2.57105082e-01f, 1.56026676e-01f,
  4.36193608e-02f, 1.32598966e-01f, -4.36626434e-01f, -1.06863707e-01f, -2.28998929e-01f, -2.23853439e-01f, -3.26518744e-01f, -2.05323160e-01f, -3.09651494e-01f, 1.00540623e-01f,
  -3.07648610e-02f, 1.91458091e-01f, -1.73627838e-01f, -1.55484349e-01f, 4.08233367e-02f, -7.42679238e-02f, -9.81412902e-02f, 2.88585536e-02f, 9.45172086e-02f, 6.88470080e-02f,
  6.06855284e-03f, -1.74746718e-02f, 1.61340654e-01f, -2.77549662e-02f, 6.58331811e-02f, -9.70273092e-02f, -1.26835957e-01f, -3.03909816e-02f, -2.94428449e-02f, 2.11959314e-02f,
  -9.25334692e-02f, -5.08216657e-02f, -6.78767487e-02f, 4.91669029e-03f, 3.86414006e-02f, -8.69156420e-03f, -6.38951594e-03f, -6.75825924e-02f, 4.79518203e-03f, 8.13945010e-02f,
  -8.93301796e-03f, 4.49860655e-02f, 3.64988111e-03f, -6.05449267e-02f, 8.53179991e-02f, 1.51429288e-02f, 4.28427197e-02f, -2.34763008e-02f, 5.46111166e-02f, -1.56049997e-01f,
  5.45009673e-02f, 9.37657058e-02f, 8.43410939e-02f, 5.52029535e-02f, 4.28459840e-03f, 1.61511283e-02f, -1.92798637e-02f, 7.27931485e-02f, 6.16944348e-03f, -2.43240949e-02f,
  1.15062250e-02f, -1.84572786e-02f, -3.09442319e-02f, -2.05425084e-01f, -7.01777041e-02f, 9.69124734e-02f, 3.12791802e-02f, -7.93309510e-02f, -1.00783542e-01f, 3.91730666e-03f,
  1.99266672e-01f, 4.59808499e-01f, 1.64117906e-02f, -1.11979529e-01f, -1.07549675e-01f, 1.04313895e-01f, 5.71964448e-03f, 1.95528030e-01f, 1.89925924e-01f, 4.43515331e-02f,
  -5.98451570e-02f, -4.11905758e-02f, -3.13383676e-02f, -7.45951605e-04f, -1.17822513e-01f, 2.36149460e-01f, -1.04315564e-01f, 6.53218254e-02f, -1.81993525e-02f, -2.84746923e-02f,
  -2.35383138e-01f, 9.12738815e-02f, -1.10726692e-02f, 9.11773592e-02f, 8.11229460e-03f, -1.18791878e-01f, 1.32119894e-01f, -4.53023836e-02f, 5.95027432e-02f, 1.54872611e-01f,
  8.41680586e-01f, -5.19149542e-01f, -1.66488186e-01f, 2.93518931e-01f, 4.51801091e-01f, 3.39081228e-01f, 3.63490164e-01f, 3.00829299e-02f, 3.98750082e-02f, -4.02451277e-01f,
  2.21977100e-01f, -2.58063793e-01f, -2.42006540e-01f, 2.23116025e-01f, 5.43759882e-01f, -2.22243652e-01f, 1.69231832e-01f, 8.74513537e-02f, -2.97900420e-02f, 3.72937396e-02f,
  3.15766633e-01f, 2.87760437e-01f, 1.00171752e-01f, -1.82836086e-01f, 2.26392984e-01f, -1.23462245e-01f, -1.10465966e-01f, -3.21865797e-01f, 8.43821317e-02f, 2.49119267e-01f,
  5.61580919e-02f, 1.20876841e-02f, 2.05479506e-02f, -1.63723841e-01f, 3.00940704e-02f, 6.15976565e-03f, -1.26213819e-01f, 9.52290893e-02f, 1.41957611e-01f, 5.64835817e-02f,
  -1.98263489e-02f, 9.78333727e-02f, 5.81462048e-02f, 7.83666596e-03f, 2.70017050e-03f, -2.62818802e-02f, 1.23276360e-01f, -8.72412473e-02f, -2.44619939e-02f, 1.02971695e-01f,
  1.04595181e-02f, -2.87403297e-02f, 2.94579491e-02f, 1.23905186e-02f, -2.04028009e-04f, 1.48868710e-01f, 5.12892753e-02f, -4.52055372e-02f, -3.32725816e-03f, 6.51861355e-03f,
  2.68887859e-02f, -8.33490714e-02f, 4.03283574e-02f, -1.19540028e-01f, 4.67502363e-02f, 1.49200976e-01f, -5.01408055e-02f, 9.48521569e-02f, -7.10638240e-02f, -6.86256588e-02f,
  1.36825085e-01f, -3.58282849e-02f, -8.87223706e-02f, 6.23949170e-02f, -2.44008861e-02f, 1.31368740e-02f, -1.41039649e-02f, 1.14726247e-02f, -9.51429978e-02f, -5.77889662e-03f,
  -1.82008874e-02f, 1.12065692e-02f, -7.15716705e-02f, 1.07986540e-01f, 6.97555626e-03f, -9.13105067e-03f, -1.25836074e-01f, -5.51782325e-02f, 1.18420972e-02f, 5.16991355e-02f,
  -5.89907408e-01f, -4.99291182e-01f, -1.13816068e-01f, 3.78535017e-02f, -1.34363934e-01f, -8.81720856e-02f, -9.38936919e-02f, 3.60787213e-02f, -1.37990922e-01f, 1.16157733e-01f,
  4.37999666e-02f, -4.86025251e-02f, -3.94499451e-02f, 7.35226739e-03f, -1.36563584e-01f, 1.76873943e-03f, -3.04129496e-02f, -8.17543119e-02f, -2.15265062e-03f, -7.09099770e-02f,
  -2.18502712e-02f, -2.56749578e-02f, -9.12419185e-02f, 1.77699439e-02f, 1.05630629e-01f, 9.02209729e-02f, 3.21664810e-02f, 2.21868251e-02f, 4.88377362e-02f, -1.48379020e-02f,
  -4.66485769e-01f, 1.78168163e-01f, 2.05305070e-01f, 3.44441205e-01f, -3.90570760e-01f, -2.78108150e-01f, 1.10715687e-01f, -1.61402792e-01f, -8.24850202e-02f, 1.30226329e-01f,
  2.97434088e-02f, -2.25235313e-01f, 1.71776697e-01f, 3.62344176e-01f, -3.47187147e-02f, 4.04315561e-01f, 3.49354237e-01f, 7.06444681e-02f, 7.06112310e-02f, -1.83372684e-02f,
  2.52114236e-01f, 1.19557172e-01f, 4.06874895e-01f, 4.78334446e-03f, -1.81024194e-01f, 9.44007337e-02f, 1.72544718e-01f, 2.77817938e-02f, 2.89666116e-01f, -5.23105338e-02f,
  -8.69826674e-02f, -1.25651322e-02f, 9.03611407e-02f, 4.52187620e-02f, 1.68083519e-01f, -1.46999151e-01f, -3.28437500e-02f, -8.85057896e-02f, 9.35042277e-02f, 8.16610605e-02f,
  -1.27873763e-01f, 4.42535728e-02f, 2.65338402e-02f, -3.72547330e-03f, -1.18234403e-01f, 1.13979891e-01f, 2.48018149e-02f, -9.01298076e-02f, 2.03485563e-02f, -9.31117907e-02f,
  2.05915514e-02f, 5.74538670e-02f, 1.20246537e-01f, 2.76679993e-01f, 3.08170579e-02f, 5.08330613e-02f, 1.17300645e-01f, -4.89963070e-02f, 2.40932740e-02f, 7.12658316e-02f,
  5.96685782e-02f, 1.85338538e-02f, 1.19040154e-01f, -1.33119330e-01f, 2.52094958e-02f, 1.45806029e-01f, 1.26563460e-01f, -1.18878402e-01f, 5.55144921e-02f, 6.36434257e-02f,
  -2.88921874e-03f, -4.91865957e-03f, -3.57961729e-02f, -1.25760650e-02f, 2.98954155e-02f, -1.41376391e-01f, -9.84994620e-02f, 5.74591048e-02f, -1.38553921e-02f, 1.25365295e-02f,
  4.82042916e-02f, -9.28677320e-02f, -3.48476730e-02f, 3.96112502e-02f, 4.09318227e-03f, -6.50077164e-02f, 4.74503897e-02f, 8.54571462e-02f, 7.33407354e-03f, -2.09552068e-02f,
  1.59326822e-01f, 2.57889450e-01f, 7.13385642e-02f, -5.57608269e-02f, 1.55197024e-01f, -1.20596051e-01f, 4.64104908e-03f, 1.28816895e-03f, 1.23881318e-01f, -8.95780027e-02f,
  -1.08851686e-01f, 3.81755158e-02f, 1.46758575e-02f, -7.34279677e-02f, 1.04156889e-01f, 5.43021262e-02f, 3.56418379e-02f, 2.74779042e-03f, 4.46007587e-02f, 5.90308271e-02f,
  3.39077227e-02f, -1.75995886e-01f, 1.03762180e-01f, -9.93867964e-02f, 5.75329177e-02f, 9.12127495e-02f, -1.38816476e-01f, -5.62844351e-02f, 7.52289817e-02f, 1.62346244e-01f,
  1.84068531e-01f, -4.19556379e-01f, 2.93163266e-02f, 4.09654140e-01f, -3.36759746e-01f, 2.10215710e-02f, 3.76265585e-01f, -2.09367454e-01f, 4.35761541e-01f, -2.36991465e-01f,
  -6.16463087e-02f, -1.88528255e-01f, 1.77561462e-01f, -1.54118631e-02f, 2.53814548e-01f, 4.15725559e-01f, 1.77358061e-01f, 2.89381385e-01f, 7.04493001e-02f, -1.02018170e-01f,
  -3.77169363e-02f, -3.34758252e-01f, -5.62884212e-02f, -3.13192576e-01f, -2.78084666e-01f, -2.14360163e-01f, -1.01358153e-01f, -1.29360721e-01f, -3.72282624e-01f, -1.72293201e-01f,
  -5.03197193e-01f, 6.28621578e-02f, -1.70834541e-01f, 3.38641778e-02f, -1.60004482e-01f, -3.53616178e-02f, 9.81030464e-02f, 4.05091271e-02f, 1.78502277e-02f, 1.13605104e-01f,
  3.94361652e-02f, 1.00364566e-01f, 1.01693021e-02f, 2.07156446e-02f, 1.57895405e-02f, -2.77138352e-02f, -2.91345809e-02f, -5.34727387e-02f, -9.53347534e-02f, -1.25353426e-01f,
  1.85072911e-03f, -1.50372773e-01f, -1.68958213e-02f, -7.70783005e-03f, 5.94984181e-02f, 4.76468764e-02f, 1.06060348e-01f, -6.62872270e-02f, -7.13630691e-02f, -1.79698635e-02f,
  -2.17233156e-03f, -3.99258509e-02f, 1.21346815e-02f, 1.55416448e-02f, -7.48546142e-03f, -1.33610398e-01f, 6.12307433e-03f, 1.54482603e-01f, 7.97188580e-02f, -1.09061293e-01f,
  1.36771817e-02f, -6.05873801e-02f, -1.36002023e-02f, -1.18443202e-02f, 6.95991442e-02f, 1.40186414e-01f, 9.84183028e-02f, -4.03490551e-02f, 1.40781388e-01f, 1.64593477e-03f,
  -1.41362762e-02f, 5.92804290e-02f, -5.02846427e-02f, -3.47405742e-03f, -6.20703213e-02f, 5.59885949e-02f, -4.04988192e-02f, 3.99949998e-02f, 1.27603218e-01f, -1.00147963e-01f,
  -4.77545530e-01f, -2.91514128e-01f, -1.20088182e-01f, -1.44311845e-01f, -1.37304068e-01f, -2.27012467e-02f, 1.11962289e-01f, -1.57502722e-02f, -1.02054335e-01f, 1.26762837e-01f,
  -1.09563053e-01f, -2.01432854e-02f, 3.73606570e-02f, 1.21041097e-01f, -1.14960328e-01f, -2.80329189e-03f, -7.70692229e-02f, 1.64492540e-02f, -1.88692138e-01f, -1.32642910e-01f,
  -9.75832865e-02f, -8.38400424e-03f, -6.94935536e-03f, -8.58328887e-04f, -1.25819713e-01f, 1.05691450e-02f, 3.87432575e-02f, -8.55175778e-02f, -1.06353879e-01f, 1.07973523e-01f,
  -2.89033204e-01f, 7.23096073e-01f, 4.70298827e-01f, 2.30307996e-01f, -1.42412901e-01f, -5.16739190e-01f, -3.25166017e-01f, 2.75566697e-01f, -3.07777971e-02f, 2.39811808e-01f,
  6.14401847e-02f, 3.94079328e-01f, 1.76584229e-01f, 8.54394287e-02f, -5.78644276e-01f, -3.40619653e-01f, -3.42880338e-01f, -1.32927045e-01f, -2.92426869e-02f, 2.35717550e-01f,
  -7.49799982e-02f, -1.10573217e-01f, 5.29576056e-02f, 2.20609084e-01f, 1.32449389e-01f, 4.37820196e-01f, 5.77880479e-02f, 2.59283543e-01f, 1.96885750e-01f, -1.43165454e-01f,
  -2.66135186e-01f, 2.80176878e-01f, 2.72939563e-01f, 2.12009400e-02f, -1.54557809e-01f, 2.49929298e-02f, 1.70943514e-02f, -2.11592186e-02f, -4.80500236e-02f, -7.89121464e-02f,
  4.91397195e-02f, -3.41021530e-02f, 1.03511907e-01f, 1.47242565e-03f, 2.98678782e-02f, 1.05033904e-01f, 7.34701306e-02f, -7.00986907e-02f, 1.54108822e-01f, -7.36796123e-04f,
  1.25777394e-01f, 3.73575501e-02f, -2.73861438e-02f, 3.32738943e-02f, 7.75753483e-02f, -1.09067122e-02f, -7.57072121e-02f, 8.35691392e-02f, 9.24925506e-03f, 5.87976761e-02f,
  -1.44478679e-01f, 4.94161285e-02f, 1.20852977e-01f, 6.20515691e-03f, -1.84266306e-02f, 1.71897672e-02f, 1.98580530e-02f, 1.02268038e-02f, 1.46957822e-02f, -3.67409177e-02f,
  4.01047105e-03f, 1.66385904e-01f, -5.52393422e-02f, -8.56438801e-02f, 2.83088591e-02f, 3.69882658e-02f, -8.51710439e-02f, 5.61364517e-02f, -7.01760054e-02f, 3.01518422e-02f,
  1.00372866e-01f, -1.29484504e-01f, 1.27491951e-01f, -6.67910352e-02f, -1.82689160e-01f, -8.42283759e-03f, 1.33363381e-01f, -6.20245710e-02f, 1.68055538e-02f, 4.64589149e-02f,
  -1.03945218e-01f, 3.14603329e-01f, 5.84065169e-02f, -7.74355978e-02f, 2.58956458e-02f, 2.87476964e-02f, -6.77256510e-02f, 1.91628169e-02f, -4.23055366e-02f, 4.07657735e-02f,
  -2.56652534e-02f, 3.14522311e-02f, -2.44119242e-02f, -1.48987782e-03f, -5.14167175e-02f, -3.96780521e-02f, 1.33099379e-02f, 6.09786548e-02f, -3.75968702e-02f, 1.40625119e-01f,
  1.47458002e-01f, -1.84161738e-02f, 8.71470720e-02f, -4.02871668e-02f, -5.78809120e-02f, -3.79235595e-02f, -1.55236935e-02f, -2.76532341e-02f, 7.84029812e-02f, -7.01814368e-02f,
  2.01711476e-01f, 1.93624832e-02f, -2.18949810e-01f, -5.23397207e-01f, -9.15424377e-02f, -5.19467741e-02f, -4.47788030e-01f, 6.15222454e-02f, -4.39686775e-01f, -7.25880787e-02f,
  1.71259537e-01f, -2.94622540e-01f, -4.00258340e-02f, -2.94626132e-02f, 1.42103329e-01f, -4.90196832e-02f, 1.85002089e-01f, 1.17079251e-01f, 1.92127451e-01f, 3.93744379e-01f,
  3.72465283e-01f, 4.56106395e-01f, 1.70221627e-01f, 5.79215109e-01f, 3.23950261e-01f, 3.41564804e-01f, 3.53649586e-01f, 1.00202896e-01f, 1.83492526e-01f, 2.36210108e-01f,
  -1.13025993e-01f, 9.14488658e-02f, -9.16833431e-02f, -6.69994876e-02f, 1.10192657e-01f, 2.27083117e-02f, -1.36691136e-02f, -6.64669322e-03f, -1.09978497e-01f, -3.66243497e-02f,
  -2.41647544e-03f, 1.17060922e-01f, 9.06615239e-03f, -1.15134090e-01f, 9.12055224e-02f, -9.26923230e-02f, 1.05683140e-01f, -5.73476329e-02f, -2.11684972e-01f, 7.98073709e-02f,
  -6.79976121e-02f, -7.68230343e-03f, 4.56119478e-02f, -6.45078421e-02f, -1.26317292e-01f, -5.10356016e-02f, -2.20216233e-02f, 3.10441684e-02f, 6.30574897e-02f, -6.30296767e-02f,
  2.07663506e-01f, 2.02130061e-02f, 1.38309821e-01f, -6.49578720e-02f, -5.13868891e-02f, -1.10947728e-01f, -5.31351045e-02f, -7.70238638e-02f, -4.09963615e-02f, -5.29282400e-03f,
  -1.41705006e-01f, -6.30939007e-02f, -1.17371507e-01f, 6.90439716e-02f, 9.83109772e-02f, -1.72938686e-03f, 9.68615264e-02f, 7.01387227e-02f, -9.19243246e-02f, -1.39158219e-01f,
  -1.14282131e-01f, 5.90821952e-02f, -6.09052703e-02f, -1.24462750e-02f, -5.09785675e-02f, -9.97522846e-02f, 1.21366918e-01f, -1.34252712e-01f, 9.25248563e-02f, 9.31818858e-02f,
  7.67318308e-02f, 3.68994534e-01f, -7.64349177e-02f, -1.38608232e-01f, 8.50120094e-04f, 4.50719744e-02f, -1.55889452e-01f, 1.91878260e-03f, 1.21200338e-01f, 6.28160536e-02f,
  1.91493720e-01f, 1.11337025e-02f, 6.12547509e-02f, -1.56549104e-02f, -9.09447670e-03f, 1.60729647e-01f, 4.49666977e-02f, -2.08519280e-01f, -1.94258615e-01f, 1.51592091e-01f,
  3.42547335e-02f, 1.37838066e-01f, -4.01891172e-02f, -3.12516652e-02f, -3.61581147e-02f, -2.72337925e-02f, 1.16684966e-01f, -1.60676241e-02f, 5.51135316e-02f, -8.30724686e-02f,
  -7.57723227e-02f, -3.03561717e-01f, 4.80645932e-02f, -2.06731334e-01f, -5.32524660e-02f, -1.56023338e-01f, -1.49168551e-01f, -3.21746588e-01f, -2.61191368e-01f, -4.89818960e-01f,
  -2.93563426e-01f, 2.02245772e-01f, 1.32424831e-02f, -2.47211814e-01f, 6.58882499e-01f, 3.21894377e-01f, -1.89959675e-01f, 2.52304878e-02f, 8.50144960e-03f, -1.18925452e-01f,
  1.34271115e-01f, -1.17080826e-02f, 4.16133374e-01f, -1.35428950e-01f, -2.58640438e-01f, 3.10947206e-02f, 4.07948315e-01f, 1.71584293e-01f, 1.85171470e-01f, 3.23978543e-01f,
  -1.31309062e-01f, -1.34931460e-01f, -7.37747625e-02f, 6.70501739e-02f, -2.06389390e-02f, -5.82954660e-02f, -3.93831357e-02f, 2.57617176e-01f, 2.94526927e-02f, 1.74589362e-02f,
  -3.36967246e-03f, 1.58198148e-01f, -5.41503020e-02f, 2.39547446e-01f, -2.46904925e-01f, -8.66753608e-02f, 1.20170511e-01f, 9.85363615e-04f, 7.03390241e-02f, -1.63201854e-01f,
  -5.43946922e-02f, -1.71193019e-01f, -7.55165070e-02f, 9.55126658e-02f, 1.45674959e-01f, -1.11868441e-01f, 5.50359860e-02f, 1.41471863e-01f, 4.69611399e-02f, 4.40222509e-02f,
  -5.53062260e-02f, -1.06613934e-02f, -6.65724277e-02f, -1.18803173e-01f, -6.31944165e-02f, -7.04771802e-02f, -8.12070593e-02f, -6.84983190e-03f, 4.30654222e-03f, -8.34061578e-02f,
  7.11467117e-02f, -1.39476275e-02f, -1.78497136e-01f, -1.21045239e-01f, -3.82640064e-02f, -1.45592064e-01f, 4.50023785e-02f, -1.02461036e-03f, -5.20486496e-02f, -1.37265161e-01f,
  -6.58249184e-02f, 1.93083789e-02f, -4.13888171e-02f, 5.82662001e-02f, -1.54506356e-01f, -3.63638699e-02f, -1.15123294e-01f, 9.42583159e-02f, 1.72053318e-04f, 1.97024077e-01f,
  1.23658635e-01f, 2.71873474e-01f, 5.75908609e-02f, 2.47364230e-02f, -1.54271920e-03f, -7.01240823e-02f, 4.09813449e-02f, -7.23835528e-02f, 1.71722218e-01f, 6.40052557e-02f,
  -1.81261793e-01f, 1.23423733e-01f, -8.39627236e-02f, -3.52170914e-02f, 9.97201800e-02f, -7.55656511e-02f, 1.37590557e-01f, 1.88263953e-02f, 1.41614959e-01f, 7.54021630e-02f,
  6.23041764e-02f, -5.50262928e-02f, 1.37465239e-01f, -6.36571199e-02f, 1.16954651e-03f, 4.28592712e-02f, -3.90519053e-02f, -6.44670725e-02f, 1.39042333e-01f, 9.08132643e-02f,
  6.01404607e-01f, -5.92696011e-01f, -2.64838696e-01f, 2.89913416e-01f, 3.93473059e-01f, 3.20866495e-01f, 2.38532990e-01f, -4.61608060e-02f, -1.19070344e-01f, -4.70274657e-01f,
  2.44673729e-01f, -2.63742715e-01f, -3.37789148e-01f, 1.07748717e-01f, 4.37866211e-01f, -3.34624887e-01f, 2.65768230e-01f, 6.39276728e-02f, -3.28766778e-02f, 1.00667223e-01f,
  2.28226915e-01f, 3.66216481e-01f, 8.41071829e-03f, -4.64391336e-02f, 1.66283995e-01f, -1.78389579e-01f, 1.15682878e-01f, -1.64025187e-01f, 4.04539099e-03f, 1.00664664e-02f,
  7.98201337e-02f, 4.27340232e-02f, 1.82309635e-02f, -6.26919419e-02f, 1.24020509e-01f, 1.93950564e-01f, 2.80498173e-02f, 3.69862355e-02f, 1.41393065e-01f, -7.44337961e-03f,
  1.16451830e-02f, -2.21542958e-02f, 4.69934605e-02f, 1.72091927e-02f, 7.50173479e-02f, 4.15267721e-02f, -4.85668220e-02f, 3.60333920e-02f, -5.28781675e-02f, -1.38207991e-02f,
  -5.72613403e-02f, 2.37792498e-03f, 1.19760327e-01f, -9.57267508e-02f, -6.00144342e-02f, -3.41883935e-02f, -4.72502224e-02f, -7.62264132e-02f, -9.11328569e-02f, -5.37959747e-02f,
  2.85423994e-02f, 7.59503394e-02f, -6.07199445e-02f, 4.60020229e-02f, 1.47350635e-02f, 1.06391674e-02f, 1.08768821e-01f, -1.49039170e-02f, -3.11240065e-03f, -9.57487971e-02f,
  5.58024719e-02f, 9.54857916e-02f, 5.28631993e-02f, -4.43530083e-02f, 1.32489949e-01f, 1.22991251e-02f, 1.27408400e-01f, -5.54613620e-02f, 3.73465270e-02f, 3.36223356e-02f,
  -5.48893623e-02f, 9.86940190e-02f, -3.34532298e-02f, -2.11530991e-04f, -7.30586946e-02f, 3.73482555e-02f, -6.88895732e-02f, 2.20388686e-03f, -4.48360443e-02f, 4.60307859e-02f,
  -6.67963102e-02f, -6.56615436e-01f, -7.14624599e-02f, -5.98294996e-02f, -1.45596579e-01f, 9.86756682e-02f, -1.03985168e-01f, -2.16749385e-02f, -1.02620393e-01f, -2.49519516e-02f,
  3.74972932e-02f, 5.99800088e-02f, -6.69381768e-02f, 1.19418144e-01f, 2.30942443e-02f, -1.27903502e-02f, -1.72076926e-01f, -2.38914951e-03f, 1.11755617e-02f, -9.52484831e-02f,
  9.15382989e-03f, 2.46675219e-02f, -3.31026651e-02f, 9.36816931e-02f, -2.67674644e-02f, -1.42281596e-03f, -5.89783378e-02f, -1.12432584e-01f, 4.77381870e-02f, -1.56200111e-01f,
  1.55728295e-01f, -1.54692262e-01f, -5.77697679e-02f, 1.05029875e-02f, -1.44419279e-02f, 4.42744315e-01f, 6.32421911e-01f, -1.83035821e-01f, -2.19258651e-01f, 1.50353268e-01f,
  7.88528845e-02f, 2.56743282e-01f, 1.95496514e-01f, -2.24919487e-02f, 4.30148810e-01f, 3.02611530e-01f, 1.91656530e-01f, 2.94269234e-01f, -2.20076814e-01f, -9.78524536e-02f,
  -1.85396001e-01f, 2.98579603e-01f, -8.89150202e-02f, -3.27295572e-01f, 9.04290676e-02f, -2.85729796e-01f, -3.56935826e-03f, 8.65913033e-02f, 7.08412752e-02f, 2.56948709e-01f,
  4.85518435e-03f, -9.41198841e-02f, -1.17322885e-01f, 1.63167361e-02f, 1.28272111e-02f, 7.28595629e-02f, 1.74342155e-01f, 3.01644892e-01f, 2.60711350e-02f, -9.68620256e-02f,
  1.43351853e-01f, 4.83980998e-02f, -5.54532707e-02f, 2.82647405e-02f, -9.33945365e-03f, -2.82413065e-01f, -2.23733455e-01f, -2.03289628e-01f, -1.23186521e-01f, 5.05037904e-02f,
  -1.07368760e-01f, -1.61148697e-01f, 3.38674970e-02f, -6.62333472e-03f, -7.95840845e-02f, 5.18958531e-02f, -4.34346264e-03f, 1.06136695e-01f, 7.65331388e-02f, -6.82255207e-03f,
  1.06711268e-01f, 1.31966770e-01f, 1.39147818e-01f, -4.39250134e-02f, -5.67077287e-02f, -6.14772290e-02f, 1.41623402e-02f, -6.70921504e-02f, -8.37020800e-02f, -6.22141361e-02f,
  -1.28879651e-01f, -5.81269227e-02f, -4.69409041e-02f, 3.69851962e-02f, 6.61792979e-02f, -1.22540426e-02f, 9.04229954e-02f, -2.61660554e-02f, -6.95468485e-02f, -1.39787093e-01f,
  -1.34542845e-02f, -5.48322052e-02f, 3.73874232e-02f, 2.65881810e-02f, -5.86424358e-02f, -3.34584829e-03f, 8.48515332e-03f, -3.69507633e-02f, -2.26769239e-01f, 1.30280003e-01f,
  9.73061323e-02f, 2.31298655e-01f, -1.30021021e-01f, 9.63353813e-02f, 6.38556629e-02f, 3.30784805e-02f, 1.91016629e-01f, -1.56151131e-02f, 4.54438627e-02f, -2.14896202e-02f,
  1.17113553e-02f, 5.18344045e-02f, 3.31759527e-02f, -5.78249246e-02f, 1.26712650e-01f, -5.86076006e-02f, 9.34245884e-02f, -7.80013353e-02f, 1.43412892e-02f, -6.67808279e-02f,
  -4.66033407e-02f, 7.88218081e-02f, 6.28049076e-02f, 8.71398579e-03f, -1.20345138e-01f, 1.37771321e-02f, -2.96713621e-03f, 9.36330631e-02f, 6.83423951e-02f, 1.24886315e-02f,
  -6.55221224e-01f, -4.04730797e-01f, -3.51330906e-01f, -2.67251939e-01f, 4.46606874e-01f, 2.51308799e-01f, -3.26469392e-01f, 8.01061839e-02f, -3.51279557e-01f, -1.37368247e-01f,
  -8.10020491e-02f, -5.20010054e-01f, -3.49940836e-01f, -2.77036011e-01f, -4.01561052e-01f, -4.25803691e-01f, -2.28347465e-01f, -1.73393920e-01f, -1.83906853e-01f, -9.62674096e-02f,
  -2.57655550e-02f, 2.28727832e-01f, -2.84134001e-01f, 4.82302129e-01f, 6.81610852e-02f, 2.17863366e-01f, 3.10444683e-01f, 2.63831824e-01f, 2.34075472e-01f, 1.84468806e-01f,
  -7.95253739e-02f, -3.06891561e-01f, -2.78755985e-02f, 1.46446705e-01f, 1.35219088e-02f, 5.33880219e-02f, 2.44339854e-01f, -2.03929618e-02f, 5.28488820e-03f, 1.96546894e-02f,
  -4.21248116e-02f, 6.01374060e-02f, 5.89722246e-02f, 5.47362864e-02f, 9.67509672e-02f, 3.58658582e-02f, 1.02015212e-02f, -1.03141606e-01f, -2.79537365e-02f, -2.26651877e-01f,
  -2.52200603e-01f, -7.74080530e-02f, 5.26693417e-03f, -2.57183146e-02f, -5.66758681e-03f, 3.58739272e-02f, 4.72758822e-02f, -1.29974350e-01f, 5.85768512e-03f, -1.35920011e-02f,
  2.32668966e-02f, 5.53017622e-03f, -7.11568967e-02f, -5.97564951e-02f, -4.01175953e-02f, 1.27204835e-01f, 1.30753741e-01f, -7.39712361e-03f, 1.43957715e-02f, -8.94378051e-02f,
  9.20638964e-02f, -1.29162312e-01f, 9.23105255e-02f, 1.85912386e-01f, -6.24869987e-02f, 1.90993249e-02f, 8.87025744e-02f, -5.26594706e-02f, -4.33905274e-02f, -7.43482187e-02f,
  6.63150996e-02f, 2.31455062e-02f, -9.05473530e-02f, 1.22364111e-01f, -5.01836166e-02f, -1.65752862e-02f, 7.99561515e-02f, -4.19659130e-02f, -1.08667031e-01f, -4.89235148e-02f,
  -5.22251502e-02f, -4.03411910e-02f, -4.22931239e-02f, 1.35637611e-01f, 8.16340670e-02f, 3.57763804e-02f, 7.11790323e-02f, 3.86137106e-02f, 7.35914931e-02f, -3.52705456e-02f,
  4.95637348e-03f, 9.88833308e-02f, 4.16379161e-02f, -3.39010805e-02f, 1.24229074e-01f, -4.59218845e-02f, 4.93299812e-02f, 4.29349893e-04f, 1.10969141e-01f, 1.58306569e-01f,
  -1.46905947e-02f, 1.15115173e-01f, -8.21122974e-02f, -1.02418726e-02f, 1.25098854e-01f, -4.96969298e-02f, -9.59566757e-02f, -4.02608737e-02f, -2.39994377e-02f, -2.73272395e-02f,
  -9.21255648e-02f, -4.99275953e-01f, -1.07872039e-01f, -3.75915766e-01f, 1.87048063e-01f, 2.22023636e-01f, 2.81599402e-01f, -2.36346453e-01f, -4.41163480e-01f, -2.15561479e-01f,
  4.79431152e-02f, 3.50237601e-02f, 2.23777175e-01f, -6.22137964e-01f, 4.21030223e-01f, -6.30877987e-02f, -4.13826317e-01f, -1.16827905e-01f, -4.10039663e-01f, -2.30565548e-01f,
  -1.80093944e-01f, -4.00749087e-01f, 5.75027578e-02f, -4.31563795e-01f, -3.17654282e-01f, -1.87345475e-01f, 3.90760720e-01f, 3.15069497e-01f, -9.18645635e-02f, 1.57430470e-01f,
  -1.74792781e-01f, -3.40059757e-01f, -1.41737863e-01f, -2.04831036e-03f, 1.39447495e-01f, 1.50200188e-01f, 1.21782385e-01f, 2.03495666e-01f, 1.26033396e-01f, -5.23965508e-02f,
  1.71893343e-01f, -1.28519833e-01f, -2.94754207e-01f, 1.09998509e-01f, -1.22374646e-01f, -9.33170691e-02f, -1.03090227e-01f, -3.54541391e-02f, -7.74322525e-02f, 1.25380028e-02f,
  -1.00581370e-01f, -8.64051282e-02f, -8.71800259e-02f, -6.83270721e-03f, 6.01295345e-02f, -7.85119981e-02f, 1.46337235e-02f, 2.12599665e-01f, -6.31879494e-02f, -7.98005238e-02f,
  5.63967563e-02f, 1.98216792e-02f, -6.98085800e-02f, -2.21902117e-01f, -2.22007488e-03f, 3.58561464e-02f, 3.28465141e-02f, 4.35442664e-02f, 6.73289150e-02f, 1.73633278e-03f,
  -9.25629884e-02f, 9.53245908e-02f, -1.67562261e-01f, 1.02839479e-02f, -5.29418997e-02f, -8.98137540e-02f, 6.26470819e-02f, 8.59181359e-02f, -1.14716524e-02f, 8.62520486e-02f,
  7.49168098e-02f, -3.04984916e-02f, 9.87446979e-02f, 3.54978740e-02f, -8.97803679e-02f, 2.13977322e-01f, -5.94223961e-02f, -1.51616605e-02f, -4.87781949e-02f, 1.75546706e-01f,
  4.82569374e-02f, -1.35691971e-01f, -5.76342344e-02f, -9.31968093e-02f, 1.07807025e-01f, 1.38439059e-01f, -4.49248552e-02f, -2.03738764e-01f, -9.35258530e-03f, -8.89398232e-02f,
  1.25387028e-01f, 2.42824648e-02f, -1.71858706e-02f, 3.23512554e-02f, 8.16564113e-02f, 5.85865974e-02f, 2.27985047e-02f, 7.79730873e-03f, 1.37601480e-01f, -6.31753802e-02f,
  8.76764432e-02f, 2.43287836e-03f, -1.09028528e-02f, -1.90693438e-01f, -7.20237847e-03f, 1.55005172e-01f, -8.00363198e-02f, -5.20874932e-02f, 1.87426805e-02f, 9.24869031e-02f,
  6.09838367e-01f, -1.09320641e-01f, 1.77558914e-01f, 6.99428916e-02f, 6.97975755e-02f, 1.54978096e-01f, 3.07412714e-01f, -3.32218736e-01f, -3.73611718e-01f, -1.35933995e-01f,
  -2.02441245e-01f, 3.00636172e-01f, -8.23148564e-02f, -5.22780232e-02f, -1.61653042e-01f, -2.68660069e-01f, 1.68957224e-03f, 1.03171892e-01f, -5.76694347e-02f, 1.02136113e-01f,
  -2.45130762e-01f, -2.47134954e-01f, -2.88741499e-01f, -1.51790753e-01f, 4.36891705e-01f, 2.83126324e-01f, 4.74654138e-03f, 1.79631412e-01f, 1.59376338e-01f, 1.06772743e-02f,
  3.23454500e-03f, -8.02145749e-02f, -1.55663630e-02f, 7.31357094e-03f, 2.80733928e-02f, 6.48328736e-02f, 1.95854947e-01f, 5.62915765e-02f, -7.03096092e-02f, -5.43388613e-02f,
  8.65829512e-02f, 9.55095440e-02f, 3.70406024e-02f, 1.60096791e-02f, 1.60869330e-01f, -2.46285554e-02f, -2.01223860e-03f, 6.90463632e-02f, 7.14022890e-02f, 4.02847417e-02f,
  3.28665711e-02f, 1.95974410e-01f, -8.15856177e-03f, 4.91521768e-02f, -3.16076423e-03f, -3.75982001e-02f, -4.99061979e-02f, 1.49676651e-01f, 2.63647228e-01f, 4.43908432e-03f,
  4.83815186e-02f, 6.10969104e-02f, 1.21292435e-01f, -1.31401578e-02f, -1.96676999e-02f, 1.70873813e-02f, 3.71631682e-02f, -1.76701322e-01f, -9.10181850e-02f, -5.72009049e-02f,
  7.21425191e-02f, 2.89686285e-02f, -9.98450965e-02f, -3.80557477e-02f, -9.21308100e-02f, 1.27781823e-01f, 5.67144379e-02f, 2.69260049e-01f, -1.66238055e-01f, -2.50208918e-02f,
  -6.60908148e-02f, 4.12539067e-03f, -7.50752613e-02f, 6.62498176e-02f, -1.93614091e-04f, -2.29970515e-01f, -2.30002299e-01f, 1.30618513e-01f, -1.03550836e-01f, -9.50490013e-02f,
  -7.83916712e-02f, -2.36221835e-01f, -1.44174770e-01f, -1.69099420e-02f, -3.76443528e-02f, 9.16364696e-03f, 4.25818786e-02f, -1.31034359e-01f, -1.39747843e-01f, -1.56508222e-01f,
  3.18503641e-02f, 8.12240690e-02f, 1.01107843e-01f, 1.77777782e-02f, 7.97335058e-03f, -3.25474322e-01f, 1.03953280e-01f, 1.26155868e-01f, 8.47377405e-02f, -3.79053950e-02f,
  -1.88565832e-02f, 1.31155938e-01f, 1.17791325e-01f, 9.37367752e-02f, -1.54426634e-01f, 1.48715109e-01f, 2.89917495e-02f, 1.76167544e-02f, 1.71372861e-01f, -7.90445656e-02f,
  -2.40104482e-01f, -6.02168143e-01f, 3.89650971e-01f, 3.31566155e-01f, -1.03473276e-01f, -3.09044451e-01f, 1.56856000e-01f, -3.03681076e-01f, -4.28492874e-01f, -5.26269495e-01f,
  7.58876354e-02f, -6.96448088e-02f, -1.67071685e-01f, 1.82360947e-01f, 5.45428514e-01f, 4.03187796e-02f, 1.48847178e-01f, 1.56337291e-01f, 1.76504061e-01f, 7.06996769e-02f,
  2.27424577e-01f, 2.87934005e-01f, 4.22643781e-01f, 9.74904895e-02f, 1.12969026e-01f, 6.46818951e-02f, 2.41809800e-01f, 1.56636447e-01f, 2.75154650e-01f, 1.20987713e-01f,
  -3.96005422e-01f, 8.81024599e-02f, 8.33042860e-02f, -1.04339413e-01f, 3.10986303e-02f, -1.09118588e-01f, 1.00189619e-01f, 1.98236167e-01f, 1.74350262e-01f, -6.06292672e-03f,
  -1.48299605e-01f, -2.00387053e-02f, 1.00386649e-01f, 5.28142080e-02f, -1.01619475e-01f, -2.11963933e-02f, -1.27779394e-01f, -7.01504946e-02f, -9.62665901e-02f, 5.44109382e-02f,
  5.52853011e-03f, -6.60365075e-02f, -3.31354700e-02f, 2.72939131e-02f, 1.38704941e-01f, -1.18314147e-01f, 9.23627615e-02f, 7.61400461e-02f, -6.80886135e-02f, -7.05499351e-02f,
  2.57550739e-02f, -1.29983574e-02f, -9.68934968e-02f, 3.98321776e-03f, 2.82200165e-02f, 5.36195002e-02f, 2.54402738e-02f, 2.72795204e-02f, 7.21859187e-02f, -1.15418188e-01f,
  -6.06774911e-02f, 7.30362236e-02f, -7.30848983e-02f, -1.06484883e-01f, 7.20760971e-02f, 4.52941358e-02f, 1.25395879e-01f, -1.38975456e-01f, 2.79353056e-02f, 3.72991711e-02f,
  1.12565242e-01f, -1.20475031e-01f, 1.51185517e-03f, -9.25745408e-04f, -1.68432936e-01f, 2.21832376e-02f, 1.47405732e-02f, -4.28002812e-02f, 6.88621262e-03f, 6.97887167e-02f,
  -6.36797607e-01f, -4.73876558e-02f, -3.76694873e-02f, -2.02805534e-01f, 3.88776772e-02f, -6.91152513e-02f, 6.86190724e-02f, -8.27352032e-02f, -1.18157472e-02f, -1.76538303e-02f,
  2.66329828e-03f, 5.25206402e-02f, -6.40014708e-02f, 2.85799075e-02f, 1.25018060e-01f, -1.04134299e-01f, 2.07256097e-02f, 3.65885049e-02f, -3.66492160e-02f, 2.67728022e-03f,
  -3.70808430e-02f, 6.13129027e-02f, 5.82371466e-02f, -3.78105231e-02f, 2.30297502e-02f, -3.68031263e-02f, -3.65389846e-02f, -1.44395535e-03f, 4.12581302e-02f, 1.00945812e-02f,
  7.61013687e-01f, -8.25733319e-02f, 3.43741983e-01f, 5.06230295e-01f, 2.22722426e-01f, -5.97771704e-01f, -1.86661586e-01f, 3.35584544e-02f, 4.49110001e-01f, -3.67756695e-01f,
  -1.40604630e-01f, 2.04011023e-01f, -5.44000231e-02f, -2.14093238e-01f, -3.51627409e-01f, 7.76312221e-03f, -3.42147291e-01f, -2.47490704e-01f, 1.82855129e-01f, 1.08284272e-01f,
  8.49752128e-02f, -4.68679279e-01f, 1.62512317e-01f, -4.33287323e-01f, 1.00821488e-01f, 2.52439439e-01f, -1.99819177e-01f, 2.87274979e-02f, -3.64357322e-01f, -1.72959507e-01f,
  3.10141966e-02f, 3.11742604e-01f, 3.09120536e-01f, -5.44842184e-02f, -3.91411781e-03f, 3.08139138e-02f, 9.49406400e-02f, 4.42050099e-02f, 1.68114930e-01f, -4.74835932e-02f,
  6.04733117e-02f, -2.07239408e-02f, -6.10807426e-02f, -1.37065709e-01f, 1.09285749e-01f, 2.82396786e-02f, 9.07226279e-02f, 1.70671828e-02f, 1.14555761e-01f, 2.29313493e-01f,
  8.73219520e-02f, 4.99841310e-02f, 5.40221296e-02f, -4.81698401e-02f, 2.14452222e-01f, 6.69495494e-04f, 1.98672451e-02f, -7.07767680e-02f, -6.29109666e-02f, 2.83116996e-02f,
  -3.61937359e-02f, -5.80377504e-02f, 9.27262381e-02f, 5.06635532e-02f, -9.28305164e-02f, 6.47520274e-02f, -2.27218475e-02f, -9.37062725e-02f, 3.13602202e-02f, 3.94361243e-02f,
  -4.08949628e-02f, 1.51582226e-01f, 6.56937510e-02f, 1.09067168e-02f, 2.46558469e-02f, 1.62497625e-01f, -2.07497180e-02f, -1.01456039e-01f, 5.84046058e-02f, 4.34562042e-02f,
  4.63955328e-02f, -9.07079205e-02f, 5.63261360e-02f, 9.13496539e-02f, -7.90224522e-02f, 3.23188695e-04f, -1.89350918e-02f, 8.94574299e-02f, 3.35227288e-02f, -8.88621733e-02f,
  -5.39880574e-01f, -5.06505251e-01f, 5.19327559e-02f, 2.38046702e-02f, -1.71130583e-01f, -7.15569109e-02f, 2.29929388e-02f, 3.53270546e-02f, -1.55458838e-01f, -8.77692625e-02f,
  -1.65525451e-01f, 8.36487636e-02f, -1.89806148e-01f, -1.70313567e-02f, -1.38140634e-01f, -4.79563028e-02f, -4.34117839e-02f, -8.57560933e-02f, -5.36300912e-02f, -1.57472149e-01f,
  -1.11649044e-01f, -8.34987015e-02f, 3.82548049e-02f, 5.70869073e-02f, -4.66369539e-02f, 1.40524441e-02f, -1.90638006e-02f, 3.49447504e-02f, -1.49726838e-01f, -1.13321334e-01f,
  2.55028874e-01f, 4.89939272e-01f, 4.41976964e-01f, 3.54186267e-01f, -2.10107535e-01f, -3.14976126e-01f, -2.56836355e-01f, -8.64322558e-02f, -1.16420723e-02f, 2.30281591e-01f,
  -1.21308237e-01f, 3.39494348e-01f, -2.35482097e-01f, 2.33824387e-01f, -2.94923753e-01f, -2.75950998e-01f, 1.58581361e-01f, 1.22634843e-01f, 4.09687683e-02f, 3.49266082e-01f,
  1.30784037e-02f, -2.42999509e-01f, 1.02760531e-01f, -9.23447125e-03f, 2.05161914e-01f, 3.25832963e-01f, 2.77107388e-01f, -1.78686692e-03f, 3.85019898e-01f, -1.91941381e-01f,
  -1.05052523e-01f, 8.73688608e-02f, 1.31445557e-01f, 2.04362329e-02f, -5.69235766e-03f, -4.47187498e-02f, 6.36925399e-02f, -1.43972963e-01f, -1.20058753e-01f, 6.70493394e-02f,
  9.58036855e-02f, -2.47164145e-02f, 1.85553711e-02f, -8.75509977e-02f, 9.72175226e-02f, 1.74109802e-01f, 6.19011894e-02f, 1.45237058e-01f, 9.21499208e-02f, 2.78485902e-02f,
  1.88650250e-01f, 8.75109211e-02f, 1.19913705e-02f, 7.95842335e-02f, 6.13484681e-02f, -3.67269330e-02f, 2.58080624e-02f, 1.10585682e-01f, 9.68968198e-02f, 4.32003103e-02f,
  9.02576894e-02f, -4.39421609e-02f, -1.91405229e-02f, -1.51593459e-03f, -3.71258855e-02f, 2.35029366e-02f, 3.49352323e-02f, -1.99978426e-02f, 5.25462739e-02f, 4.28448021e-02f,
  6.45103306e-03f, 6.69348612e-02f, -1.29028127e-01f, -5.69623448e-02f, 4.74792905e-02f, -2.33634003e-02f, -6.06685989e-02f, 5.29145030e-03f, 1.01641119e-01f, 3.15723382e-02f,
  -5.31167425e-02f, -4.37159650e-02f, -3.98747204e-03f, -2.15211927e-04f, -1.43780664e-01f, 3.78452688e-02f, 1.19882420e-01f, 1.52374476e-01f, -1.58872060e-03f, -2.29344629e-02f,
  1.38931841e-01f, 2.11616352e-01f, 2.51089521e-02f, -1.20076656e-01f, 3.84810939e-02f, -8.09230190e-03f, -5.34070246e-02f, 9.37330574e-02f, 1.50772005e-01f, -7.06744865e-02f,
  1.17237858e-01f, -1.07496031e-01f, 1.01040252e-01f, 2.14694124e-02f, -7.26526529e-02f, 1.06232271e-01f, 7.65758231e-02f, 1.71889454e-01f, 1.13871641e-01f, 1.60296962e-01f,
  1.42363042e-01f, -4.58555669e-02f, -3.22258510e-02f, -1.59285128e-01f, 1.88210383e-02f, 3.09008472e-02f, 1.12018287e-01f, 1.51001904e-02f, 8.21051598e-02f, 9.93482843e-02f,
  3.07315171e-01f, -3.71000879e-02f, -3.20709109e-01f, -3.91637743e-01f, 2.27924109e-01f, 4.58542794e-01f, 4.59441245e-01f, -1.52975336e-01f, -4.15809035e-01f, 9.40976515e-02f,
  4.21168089e-01f, -9.33865272e-03f, 3.54403675e-01f, 1.65177807e-01f, 2.53446877e-01f, 3.70897532e-01f, 6.70779198e-02f, 1.17714405e-01f, 4.25034836e-02f, 6.13319986e-02f,
  -8.91555771e-02f, 3.95277441e-01f, 1.44457594e-01f, -9.55324546e-02f, 2.81021714e-01f, -2.87787944e-01f, -4.00344282e-03f, 1.63157254e-01f, -5.88946864e-02f, 1.32186607e-01f,
  1.18471481e-01f, -1.79371610e-02f, 1.24813110e-01f, -1.22319395e-02f, -4.04213071e-02f, -5.61431423e-03f, 4.04896215e-02f, 1.25300720e-01f, -1.00996457e-01f, 2.35490147e-02f,
  7.08380528e-03f, -2.28162527e-01f, -1.33175194e-01f, -4.38160636e-02f, -5.13875596e-02f, -1.95600897e-01f, -1.74435005e-02f, -3.53177264e-02f, -1.45799965e-01f, 5.50074950e-02f,
  7.34252036e-02f, -7.18657076e-02f, 1.49075650e-02f, -1.31443471e-01f, 2.85025593e-02f, -8.70508403e-02f, -2.99346242e-02f, 1.08154699e-01f, -9.73681808e-02f, -8.96376371e-02f,
  -3.51085216e-02f, 3.43734808e-02f, 2.70087179e-02f, -3.92028280e-02f, 1.34899197e-02f, 7.42312297e-02f, 1.07367665e-01f, 3.61032784e-02f, -1.12284727e-01f, 1.03776641e-01f,
  -7.17731938e-02f, 8.94246739e-04f, 2.24428289e-02f, 7.62293264e-02f, 7.67988861e-02f, -5.06031662e-02f, 1.18553974e-01f, -9.58316436e-04f, -5.95289981e-03f, -4.76774685e-02f,
  7.74153648e-03f, -9.05319769e-03f, 9.94284451e-02f, 7.07574785e-02f, -4.67711650e-02f, -2.94690765e-02f, 3.12202983e-02f, 6.05287291e-02f, -1.79048348e-02f, 6.40261397e-02f,
  -7.94291943e-02f, -1.41171023e-01f, -8.06444287e-02f, -6.18914329e-03f, -1.05109522e-02f, 6.27765581e-02f, 3.62804011e-02f, -1.84555456e-01f, -8.26130658e-02f, 4.55209613e-03f,
  -9.46482047e-02f, -9.90046859e-02f, -7.93268532e-02f, -2.45805625e-02f, -6.50703162e-02f, 1.09138504e-01f, 4.08332009e-04f, -1.02810189e-01f, -5.75538091e-02f, -8.07908997e-02f,
  2.18949486e-02f, 5.23461960e-02f, -5.92714921e-02f, -8.89892802e-02f, -1.45161942e-01f, 1.04334667e-01f, 3.98333147e-02f, -1.12121791e-01f, 7.35474229e-02f, -1.28554255e-01f,
  -3.15583721e-02f, 2.76990891e-01f, 2.46567979e-01f, -1.58018544e-01f, -2.30449021e-01f, 4.95037168e-01f, -2.22448781e-02f, 6.50417134e-02f, -5.46864001e-03f, 3.36501867e-01f,
  -1.97350964e-01f, 4.60545808e-01f, -2.68914521e-01f, -1.41124934e-01f, -4.39777464e-01f, -3.35069746e-01f, -7.05504566e-02f, 1.19546682e-01f, -3.36266220e-01f, 2.33487204e-01f,
  -1.46761879e-01f, -3.55633140e-01f, -3.51666033e-01f, -4.24884483e-02f, 6.87342361e-02f, 3.37417006e-01f, -1.72851607e-01f, -8.24616924e-02f, 2.46928811e-01f, -2.68964827e-01f,
  -5.20373359e-02f, -1.69480711e-01f, 8.97700489e-02f, 1.88223884e-01f, 1.30931377e-01f, 2.58533418e-01f, 5.91708459e-02f, 2.26520933e-02f, -2.21815538e-02f, 4.48421985e-02f,
  -4.78493981e-02f, 9.65592563e-02f, 2.86353640e-02f, -1.76165015e-01f, 1.56889886e-01f, 1.07057681e-02f, 5.43125197e-02f, 1.52293891e-01f, 2.27068976e-01f, -3.48762274e-02f,
  4.20596972e-02f, 1.17430136e-01f, 1.17280245e-01f, 5.33930250e-02f, 9.61533040e-02f, 9.88421589e-02f, 1.38951018e-01f, 2.26435155e-01f, 1.44871593e-01f, -7.34198792e-03f,
  -3.94857377e-02f, 1.11882068e-01f, 3.60959135e-02f, -1.03292409e-02f, -1.66066632e-01f, -1.79317355e-01f, -1.59446299e-02f, -9.84718204e-02f, 4.24080864e-02f, 9.09578055e-02f,
  9.94519368e-02f, 5.77045977e-02f, -1.21640600e-01f, 1.56391725e-01f, -5.76053299e-02f, -2.11655572e-02f, 6.45218641e-02f, 3.91126610e-03f, 1.03302248e-01f, -1.84277054e-02f,
  -2.45024011e-01f, -1.38824899e-02f, -2.65356321e-02f, -8.70315060e-02f, 8.38090405e-02f, 8.58404487e-02f, 1.33501232e-01f, 4.79599945e-02f, -2.33809888e-01f, -1.29624113e-01f,
  1.00113541e-01f, 1.37320429e-01f, 6.61847889e-02f, 9.82882306e-02f, -1.18563157e-02f, 3.29651721e-02f, 1.99571773e-02f, 1.17912896e-01f, -8.35055299e-03f, 5.57873175e-02f,
  7.68630058e-02f, 2.13973835e-01f, 1.16749287e-01f, -1.19335376e-01f, 7.73939420e-04f, 1.85499817e-01f, 6.82509914e-02f, 9.55965221e-02f, 4.23577381e-04f, 1.10305563e-01f,
  1.36671677e-01f, 4.13605608e-02f, -6.12907484e-03f, 8.34905654e-02f, 5.07364534e-02f, 3.41391601e-02f, 1.52474105e-01f, 1.26470283e-01f, -1.87701255e-01f, 1.54249668e-01f,
  4.95943666e-01f, 2.33639792e-01f, 2.12868854e-01f, -1.53892100e-01f, -1.72919370e-02f, 4.54595745e-01f, -1.84849307e-01f, -1.30414283e-02f, -3.94120485e-01f, 3.95168900e-01f,
  -1.17724195e-01f, 2.21200868e-01f, -2.16970190e-01f, 1.63898826e-01f, -1.09777629e-01f, -4.46882963e-01f, 1.04229882e-01f, 2.53418628e-02f, -3.80669773e-01f, 1.93160653e-01f,
  -1.38055041e-01f, -8.34640115e-02f, -2.92779893e-01f, 1.50701951e-03f, 4.22135413e-01f, 1.18062653e-01f, -3.41905057e-02f, -4.40048546e-01f, 1.82569236e-01f, -1.81854934e-01f,
  -1.20416898e-05f, -1.38659194e-01f, 1.69483721e-01f, 1.36610717e-02f, 1.33036628e-01f, 1.17713287e-01f, 1.66307062e-01f, -1.13253318e-01f, -1.94982320e-01f, -1.06288105e-01f,
  7.18287528e-02f, 2.59519070e-02f, 3.10456622e-02f, -1.60691619e-01f, 1.06981747e-01f, 2.90116705e-02f, 7.54802972e-02f, 3.13053280e-02f, -1.71055552e-02f, 3.07238623e-02f,
  -6.32458776e-02f, 1.29030347e-01f, 5.38603291e-02f, 2.85141468e-02f, -8.16514343e-02f, -2.14975234e-02f, 2.92740613e-02f, 9.93545353e-02f, 1.00921869e-01f, 1.81821480e-01f,
  9.92199406e-03f, -1.23989366e-01f, 5.77718988e-02f, -1.04350321e-01f, -1.07799415e-02f, -1.24116182e-01f, -6.77881613e-02f, -5.15670441e-02f, -9.68305990e-02f, -1.73712634e-02f,
  -5.92343807e-02f, 1.11926369e-01f, -1.48954660e-01f, -9.19814259e-02f, 7.57355392e-02f, 1.11999132e-01f, 1.22470185e-01f, -6.53955042e-02f, 3.76540385e-02f, 1.02802597e-01f,
  -2.16220871e-01f, 2.75732931e-02f, -3.20612937e-02f, -5.43634892e-02f, -2.23271456e-02f, -7.64471199e-03f, 2.49490738e-02f, 6.26911446e-02f, -6.12282269e-02f, -5.60049824e-02f,
  2.12007351e-02f, 1.46299541e-01f, -3.28093395e-03f, -8.43397528e-02f, 6.85657337e-02f, 1.49621964e-01f, -8.47031549e-02f, 1.01793818e-01f, -5.18111661e-02f, 8.16405788e-02f,
  1.37321278e-01f, -9.79492590e-02f, 3.41719747e-01f, -5.44241630e-03f, -1.64490581e-01f, 3.80691513e-02f, -4.51601185e-02f, -1.59291357e-01f, 8.59356672e-02f, 5.78815416e-02f,
  -5.68785071e-02f, -7.90504366e-02f, 2.02628523e-02f, 7.18749017e-02f, 6.68413416e-02f, 1.67369898e-02f, 7.26110414e-02f, -1.03247657e-01f, -5.01546748e-02f, -1.83001235e-02f,
  -1.55290812e-01f, 1.87202785e-02f, -1.49797052e-01f, -3.85425776e-01f, 2.19775021e-01f, -9.69912112e-02f, -2.55626857e-01f, -1.62877925e-02f, -2.77471811e-01f, -1.46696880e-01f,
  -2.65929371e-01f, -1.52036548e-01f, 2.47910008e-01f, -3.74876499e-01f, -1.33998901e-01f, 5.48034580e-03f, -3.13931346e-01f, -2.33025342e-01f, 5.63204139e-02f, -2.16374695e-01f,
  -8.17295536e-02f, -2.62099743e-01f, -2.12911084e-01f, 1.71944439e-01f, -1.50354862e-01f, -6.59311712e-02f, 2.00768441e-01f, 1.52656034e-01f, -2.94596314e-01f, 8.60966668e-02f,
  -1.44667462e-01f, -2.93360293e-01f, -2.76493937e-01f, -1.30277842e-01f, -1.73407808e-01f, -4.64580543e-02f, -2.25194246e-02f, 1.00547532e-02f, -1.62886441e-01f, 2.13253219e-02f,
  -7.32587045e-03f, 8.41857567e-02f, -2.97972579e-02f, -3.46413697e-03f, -3.44630727e-03f, -4.19819020e-02f, 3.88776213e-02f, -8.73213038e-02f, -1.49180070e-01f, 9.32443738e-02f,
  5.32037439e-03f, 1.05472423e-01f, -2.93676071e-02f, -5.92928044e-02f, 2.07432341e-02f, 1.12378951e-02f, -6.03970140e-03f, 2.04038754e-01f, -4.27000597e-02f, -1.89432409e-02f,
  1.78180896e-02f, -5.86525798e-02f, 5.08483350e-02f, -7.89866075e-02f, -2.65848339e-02f, -3.26879025e-02f, -3.38451797e-03f, -1.64808165e-02f, 6.33303002e-02f, 5.98733267e-03f,
  7.63093531e-02f, -5.60288616e-02f, 5.48532465e-03f, -1.23740137e-02f, -2.71391701e-02f, -7.46929422e-02f, -3.24732177e-02f, -3.67690087e-03f, 1.78408604e-02f, 1.23244263e-01f,
  -7.04858750e-02f, 1.72412507e-02f, 5.38574457e-02f, -3.29050841e-03f, -6.54444024e-02f, 4.45968332e-03f, 1.04873087e-02f, 7.57793039e-02f, -4.91460003e-02f, -1.46395946e-02f,
  5.66214994e-02f, -1.42676845e-01f, -9.07752737e-02f, -8.26128125e-02f, -3.71938720e-02f, -6.12436794e-02f, -9.43217948e-02f, 3.30267362e-02f, -1.32977339e-02f, -1.53656229e-02f,
  9.90449041e-02f, -7.45450631e-02f, 1.90559588e-02f, -5.01682274e-02f, 7.28404298e-02f, 7.93517083e-02f, 1.40188215e-02f, 3.40992175e-02f, -6.26018345e-02f, 1.04686715e-01f,
  7.09519088e-02f, -1.44243073e-02f, 9.24962983e-02f, 1.09968953e-01f, -5.88943660e-02f, 8.32661167e-02f, 9.02778879e-02f, 1.04373574e-01f, 1.82884634e-01f, 4.93017286e-02f,
  -9.01492894e-01f, 3.96711528e-01f, -1.96372196e-01f, -1.31151259e-01f, 2.34523743e-01f, 2.41791889e-01f, -2.79487725e-02f, 7.36499801e-02f, -2.47351527e-01f, 3.66977602e-01f,
  5.28832853e-01f, -2.81329691e-01f, 3.90332252e-01f, 5.07954419e-01f, -9.58881602e-02f, 5.04403412e-01f, 2.10990354e-01f, 1.38550237e-01f, -3.13620031e-01f, -2.03725383e-01f,
  -1.03770182e-01f, 3.27975124e-01f, 2.74191946e-01f, -7.84210563e-02f, 2.08334059e-01f, -3.22682679e-01f, 2.34654099e-01f, -2.41514668e-01f, 1.48565799e-01f, 1.43978326e-02f,
  -2.13070050e-01f, -7.45681152e-02f, -8.64038691e-02f, -3.12952608e-01f, -4.00468297e-02f, -1.53018713e-01f, -1.87627256e-01f, -2.64688674e-02f, -1.69839203e-01f, -1.07741036e-01f,
  -1.27344400e-01f, -1.92602202e-02f, -3.72492112e-02f, -5.73525429e-02f, -3.18762250e-02f, -6.43813759e-02f, 1.91737384e-01f, 1.86271831e-01f, 7.53504038e-02f, 1.09870225e-01f,
  1.93925723e-01f, 1.16777427e-01f, 1.15477018e-01f, 3.27302068e-02f, 2.32869133e-01f, 4.28645872e-02f, -4.29758355e-02f, 5.37876152e-02f, 4.36592028e-02f, -2.53995471e-02f,
  -5.69077320e-02f, -2.81525403e-02f, 3.77569497e-02f, 7.83131551e-03f, 1.85450856e-02f, 8.14673603e-02f, 1.97287351e-02f, 5.40954918e-02f, -2.37323895e-01f, 4.80315201e-02f,
  6.21722937e-02f, 1.81517992e-02f, -9.31393132e-02f, -5.27911037e-02f, -1.51801795e-01f, -1.40998200e-01f, -1.35281593e-01f, -4.72873077e-02f, 9.10574421e-02f, -9.49427951e-03f,
  -7.25694653e-03f, -5.41334674e-02f, 7.50721619e-02f, -1.17692845e-02f, 1.25246895e-02f, 2.96799503e-02f, -9.04058218e-02f, 7.48590901e-02f, -6.40598387e-02f, -3.93530214e-03f,
  -2.61274129e-01f, -2.95151114e-01f, -4.40202802e-02f, -7.85713345e-02f, -1.22053482e-01f, 1.35749876e-02f, -1.02152392e-01f, 4.32530083e-02f, 1.13505814e-02f, -4.55681495e-02f,
  -1.31912408e-02f, 9.86573007e-03f, -3.05862669e-02f, -5.99789247e-02f, -1.01545826e-01f, 2.05322251e-01f, -1.75246164e-01f, -1.25204757e-01f, -1.35171190e-02f, 4.61858921e-02f,
  -8.57864579e-05f, 4.40652184e-02f, -5.26373200e-02f, 1.01966441e-01f, 9.78804082e-02f, 6.68434203e-02f, -1.45768434e-01f, -2.08699927e-02f, 8.34183842e-02f, 1.48148596e-01f,
  -4.13145125e-03f, -1.38670839e-02f, -2.81696349e-01f, -1.85027897e-01f, 3.93591151e-02f, 2.77947456e-01f, -1.91103909e-02f, -1.15086690e-01f, -3.63145977e-01f, 2.27034628e-01f,
  3.16289306e-01f, -3.50171477e-01f, -5.24281859e-02f, 5.82157314e-01f, 1.33007150e-02f, 3.30031514e-01f, 2.68686056e-01f, 3.46823126e-01f, -3.40109169e-02f, -9.74455550e-02f,
  5.28336316e-03f, 5.36170304e-01f, -3.26993577e-02f, 1.89519897e-01f, 1.17382348e-01f, -3.75384361e-01f, 2.01712579e-01f, -2.97735214e-01f, 2.80131847e-01f, 1.65176377e-01f,
  2.63238966e-01f, 8.97895172e-02f, 1.08607998e-02f, 3.92148830e-02f, 6.78937733e-02f, 1.14197381e-01f, 2.19157599e-02f, -3.28282416e-02f, -9.22012627e-02f, -7.49180987e-02f,
  -3.58750820e-02f, -7.97191914e-03f, 3.38363163e-02f, 2.60733292e-02f, -2.76836324e-02f, -1.05488170e-02f, 1.55135700e-02f, 8.19663517e-03f, -4.00834978e-02f, -4.05601449e-02f,
  -1.70381114e-01f, -1.67691102e-03f, -6.89358860e-02f, -2.90323310e-02f, -1.39599159e-01f, -9.20448303e-02f, 1.21906549e-02f, -9.96035784e-02f, 7.38379136e-02f, -7.11708982e-03f,
  2.35582255e-02f, 2.25416869e-02f, 1.42850026e-01f, 1.07298434e-01f, 5.73022813e-02f, 8.18796605e-02f, -8.01136717e-02f, 8.11078250e-02f, -1.25553474e-01f, 3.17685492e-02f,
  -1.46718649e-03f, -3.36245708e-02f, 1.49183832e-02f, 5.23941778e-02f, 9.64127630e-02f, 5.67893349e-02f, -2.41605844e-02f, 5.68015613e-02f, -1.12467647e-01f, 1.45397754e-02f,
  -2.91054565e-02f, -5.07975295e-02f, 2.53720321e-02f, 8.26965719e-02f, 8.13686922e-02f, -9.60220695e-02f, 9.18553397e-02f, 8.71291198e-03f, -1.72360137e-03f, -3.11426516e-03f,
  2.46947836e-02f, -9.34692249e-02f, 5.98324127e-02f, 8.74644443e-02f, 9.78308450e-03f, 7.00578615e-02f, 8.25539753e-02f, 7.96133745e-03f, -5.56281880e-02f, 1.23845544e-02f,
  5.46273664e-02f, 6.00623153e-02f, -6.87817708e-02f, 4.49583568e-02f, -4.84736264e-02f, -4.30043936e-02f, -4.21414748e-02f, -4.68827449e-02f, -1.63293049e-01f, 2.95110401e-02f,
  2.26813853e-02f, 1.93952024e-02f, -1.86508268e-01f, 4.37533157e-03f, 6.02304339e-02f, -9.51667428e-02f, -4.75614406e-02f, -9.27845016e-04f, -1.60919279e-02f, -9.12867710e-02f,
  -1.84460610e-01f, -7.85665438e-02f, 5.82197964e-01f, -7.93272108e-02f, 3.11490864e-01f, 5.88401377e-01f, 3.37089062e-01f, 1.88912451e-01f, 3.91700476e-01f, -4.50500220e-01f,
  -2.46581286e-01f, -3.64384770e-01f, 1.41371652e-01f, -1.53229639e-01f, 5.13681114e-01f, 3.85799736e-01f, 4.13359255e-02f, -1.35935649e-01f, 1.78667441e-01f, -8.92143846e-02f,
  1.24716535e-01f, -3.20741355e-01f, 2.15648770e-01f, -3.09104145e-01f, -3.36475521e-02f, -1.40508607e-01f, -4.65891510e-01f, 2.60346919e-01f, -3.68072569e-01f, 1.51932329e-01f,
  1.88764095e-01f, -7.35172406e-02f, 6.43570274e-02f, 4.59522381e-02f, 9.03810933e-02f, -3.56753917e-05f, 4.39070873e-02f, 1.28602266e-01f, 1.44992232e-01f, -2.99315136e-02f,
  -1.39351234e-01f, -4.39226720e-03f, -1.60726726e-01f, 2.66360287e-02f, 1.20198965e-01f, 9.89511888e-03f, 2.00076595e-01f, 6.50903732e-02f, 8.45097229e-02f, 1.95221439e-01f,
  1.72190994e-01f, 1.59013703e-01f, 1.31828800e-01f, -1.53899372e-01f, 7.91359767e-02f, 2.04115044e-02f, 1.96824241e-02f, 5.06026484e-02f, 8.24839771e-02f, 8.53071585e-02f,
  -9.45882201e-02f, 5.02373204e-02f, 6.00318201e-02f, 1.11722918e-02f, -1.01069305e-02f, -8.12795609e-02f, -4.69746776e-02f, -7.14676753e-02f, 7.17209354e-02f, 5.38217202e-02f,
  4.99435514e-02f, -6.10846691e-02f, 1.07188776e-01f, 4.89672422e-02f, -1.31236628e-01f, -1.13581114e-01f, 2.57311054e-02f, -1.32487789e-01f, 6.49072751e-02f, 1.07616492e-01f,
  -5.31164780e-02f, 1.85502991e-02f, -6.90222755e-02f, -9.60751623e-02f, 1.31432846e-01f, 2.84049120e-02f, -5.80160879e-02f, 3.30663212e-02f, 1.89098213e-02f, 3.70944738e-02f,
  5.01833558e-02f, -3.71074587e-01f, -9.76429656e-02f, -3.09779327e-02f, -4.31359932e-02f, -7.15074465e-02f, 5.30268997e-02f, -2.31257663e-03f, -7.98879773e-04f, -8.42903703e-02f,
  -5.94027266e-02f, -1.19204134e-01f, 8.14978406e-02f, 6.24994785e-02f, -3.47295366e-02f, 8.15013051e-02f, -2.16241274e-02f, -1.41130865e-01f, -1.59538798e-02f, -2.04207584e-01f,
  -1.03258029e-01f, -5.20492950e-03f, -2.94534303e-03f, -9.96495858e-02f, -1.71015501e-01f, -1.76922455e-02f, -1.32316425e-01f, -4.82834987e-02f, -1.44105731e-02f, -9.41724516e-03f,
  4.77507293e-01f, -4.11196560e-01f, -3.66906077e-01f, 7.91541412e-02f, 3.58820260e-01f, 3.51871014e-01f, 1.81439355e-01f, 3.74639362e-01f, 2.48715147e-01f, 1.56748656e-03f,
  2.22422689e-01f, -4.13091511e-01f, -3.88905525e-01f, 2.34094605e-01f, 1.76965013e-01f, -4.16625321e-01f, 3.36892694e-01f, 1.57591999e-02f, 4.83492464e-02f, 3.02149467e-02f,
  1.24759406e-01f, 4.03578490e-01f, -3.88020158e-01f, 1.66832060e-01f, 2.95679659e-01f, -1.66385502e-01f, -3.59767079e-02f, -3.42635810e-01f, 2.97329370e-02f, 7.02650249e-02f,
  6.93233386e-02f, -8.76964629e-03f, 2.41149161e-02f, -3.35628800e-02f, 6.98716640e-02f, 2.43644211e-02f, -1.16132349e-01f, -1.15286745e-01f, 7.83134950e-04f, 4.69375066e-02f,
  -1.36518776e-01f, 1.28624337e-02f, 3.37830633e-02f, -1.11689329e-01f, 2.10499570e-01f, 1.14977648e-02f, -3.67187336e-02f, 1.51724955e-02f, -8.43369365e-02f, -1.29699737e-01f,
  5.71877370e-03f, 1.20884106e-02f, 2.16961056e-01f, 5.74993901e-04f, 3.55665386e-02f, 8.10689405e-02f, -1.32379428e-01f, -1.51614070e-01f, -3.03735752e-02f, 4.45050113e-02f,
  -4.50854897e-02f, 7.06764758e-02f, -2.64097340e-02f, -4.76169884e-02f, -1.22289611e-02f, -1.29942419e-02f, 3.95804457e-02f, -2.57926788e-02f, 1.39866816e-02f, 1.69701478e-03f,
  1.06677763e-01f, -1.03561720e-02f, 2.91986447e-02f, 1.64730977e-02f, 6.62593693e-02f, -9.35390312e-03f, -1.00677311e-01f, -2.56279930e-02f, 4.81827464e-03f, 2.56400742e-02f,
  -8.89578238e-02f, 1.11120850e-01f, -1.84782371e-02f, -8.35950747e-02f, 3.25295627e-02f, -6.80005411e-03f, 7.96070769e-02f, 1.02598190e-01f, -2.37746220e-02f, -6.15983363e-03f,
  2.93006729e-02f, -1.14098817e-01f, -3.09923030e-02f, -4.80776504e-02f, -1.53158039e-01f, 1.48109689e-01f, -2.14650948e-03f, 3.54801267e-02f, -6.37865514e-02f, 1.39768884e-01f,
  5.61840199e-02f, -4.35091816e-02f, 1.30603071e-02f, 3.53281968e-03f, -1.28256977e-01f, 1.34803623e-01f, -4.40277485e-03f, 6.02915250e-02f, 9.56409574e-02f, -1.10642336e-01f,
  6.83312118e-02f, 1.38849057e-02f, -2.04172935e-02f, 9.75999981e-02f, 1.30556166e-01f, -1.11006558e-01f, 2.59786416e-02f, -1.41502827e-01f, -2.02067830e-02f, 4.79980558e-02f,
  -5.82128048e-01f, 4.37570125e-01f, -1.80595115e-01f, -9.23318267e-02f, 6.59386814e-02f, 5.98700583e-01f, -1.78917348e-02f, 8.12054351e-02f, -2.84431815e-01f, 1.52803242e-01f,
  -2.57662740e-02f, -1.90874919e-01f, -2.61345625e-01f, 3.68097872e-01f, 4.04853940e-01f, 3.49568695e-01f, 3.74212772e-01f, 1.28208488e-01f, 3.03244181e-02f, -9.18767676e-02f,
  6.31299801e-03f, 2.73387760e-01f, 1.90732077e-01f, 2.37842858e-01f, -2.20664330e-02f, -1.58477500e-01f, -1.88136816e-01f, -1.08748265e-01f, 3.65568459e-01f, 1.77424610e-01f,
  -1.76515907e-01f, -4.56772387e-01f, -3.47273797e-01f, -1.56336978e-01f, -1.29001200e-01f, -1.78225324e-01f, -1.50399789e-01f, -5.44209555e-02f, -4.34951968e-02f, 2.06161030e-02f,
  -1.41343966e-01f, 3.60794589e-02f, 2.23983806e-02f, -1.05307162e-01f, -5.13564795e-02f, 1.33674797e-02f, 1.45313784e-01f, 1.29868966e-02f, -4.59968112e-02f, 7.58415982e-02f,
  4.52566110e-02f, 9.19977427e-02f, 4.28731702e-02f, 9.78142768e-02f, 8.11296627e-02f, 1.54607639e-01f, 4.17609625e-02f, -7.46641457e-02f, 1.92031264e-01f, 9.38140228e-02f,
  -1.38366781e-02f, -1.02611423e-01f, -8.74731615e-02f, -1.17690086e-01f, -8.94775763e-02f, 1.04400031e-01f, 1.14265410e-02f, 9.90349501e-02f, 3.79414894e-02f, 9.69507024e-02f,
  1.02861151e-01f, 3.56165804e-02f, -5.75955845e-02f, 5.83927147e-02f, -1.17035965e-02f, -3.37942527e-03f, -7.05152452e-02f, -4.95312475e-02f, 2.99233142e-02f, 3.32942121e-02f,
  -1.63122252e-01f, 1.41669018e-02f, -3.86550352e-02f, 5.37552759e-02f, 3.79089295e-04f, -7.55491927e-02f, -1.12126343e-01f, 1.21877715e-01f, -1.07091246e-02f, 2.86054909e-02f,
  -1.24548718e-01f, -2.69655257e-01f, 1.18753258e-02f, 7.15619028e-02f, -4.25204448e-02f, 6.49084002e-02f, -5.63783720e-02f, 1.12295290e-02f, -1.37614207e-02f, -3.93809453e-02f,
  -4.18592691e-02f, 3.21469223e-03f, -1.30293686e-02f, 2.42005964e-03f, 3.99496444e-02f, 3.03646326e-02f, -8.20305794e-02f, -7.06156567e-02f, 1.38468640e-02f, 7.13731674e-03f,
  -8.61503854e-02f, -8.06950927e-02f, 4.99724261e-02f, 5.04302867e-02f, -5.42584248e-03f, 1.32422717e-02f, -1.00440107e-01f, 4.52183001e-02f, 8.30247626e-02f, 3.37590016e-02f,
  -4.16058749e-01f, 1.18974686e-01f, -2.11629733e-01f, 2.40565360e-01f, -1.31582141e-01f, -1.56640857e-01f, -1.69908926e-01f, 1.50492996e-01f, -4.65194166e-01f, 2.14189425e-01f,
  3.80286872e-01f, -5.48094094e-01f, 2.19470650e-01f, 3.43608469e-01f, -3.55668552e-02f, 1.11100882e-01f, 4.50347334e-01f, 2.16240764e-01f, 6.57705814e-02f, 1.91265762e-01f,
  1.24686114e-01f, 3.01367939e-01f, 2.71464139e-01f, 2.26448089e-01f, 1.41813755e-01f, 1.44288659e-01f, 4.64283973e-01f, 6.03746586e-02f, 4.10162628e-01f, -1.87404469e-01f,
  1.16506159e-01f, -6.10450190e-03f, -1.20334662e-02f, -1.02345265e-01f, 1.80467963e-01f, 1.42196296e-02f, 1.35663688e-01f, -7.15721920e-02f, -1.27975628e-01f, -2.72763632e-02f,
  -8.93514901e-02f, -1.12661198e-01f, -8.51551369e-02f, -5.54425046e-02f, -2.25387532e-02f, -9.15727690e-02f, -8.95161852e-02f, -1.82486698e-02f, -5.47524355e-02f, -3.82837988e-02f,
  -4.41951491e-02f, 3.54489423e-02f, -1.39386673e-02f, 2.09551174e-02f, -1.42023712e-01f, -1.75254032e-01f, -4.64930460e-02f, -7.91060030e-02f, 6.60460517e-02f, -1.73630729e-01f,
  4.85229753e-02f, -7.43959919e-02f, 2.77292170e-02f, -6.19512470e-03f, -7.26821050e-02f, -1.41075812e-02f, 1.46452698e-03f, 7.12686330e-02f, -5.46174496e-02f, 9.73539129e-02f,
  -2.60733608e-02f, -4.52464521e-02f, -5.35702556e-02f, -8.34752619e-02f, -2.44444218e-02f, -3.55347879e-02f, 4.36107256e-02f, -4.17257249e-02f, -1.02058172e-01f, 1.98120996e-01f,
  -7.01882169e-02f, -6.85816631e-02f, -4.43647839e-02f, 1.18313387e-01f, 6.07230887e-02f, -6.16097227e-02f, 4.09258939e-02f, -7.14905858e-02f, 1.96955130e-02f, 4.17392589e-02f,
  1.29114881e-01f, 1.82296604e-01f, 4.29997332e-02f, -1.12139054e-01f, 1.40803941e-02f, 1.82839315e-02f, 8.22308883e-02f, -7.46054202e-03f, 5.26460595e-02f, -6.93261102e-02f,
  7.66647533e-02f, 1.19786143e-01f, 2.60796528e-02f, -9.70386490e-02f, 1.79738835e-01f, -4.87229377e-02f, -9.20505449e-02f, -1.60478726e-01f, 5.08196354e-02f, 5.90030625e-02f,
  3.98177952e-02f, -9.90062803e-02f, 9.91744101e-02f, -6.80056810e-02f, -2.12420132e-02f, -2.26771273e-02f, -5.56164533e-02f, -9.32401270e-02f, 1.55682310e-01f, 6.50593191e-02f,
  3.39737535e-02f, 5.24879217e-01f, -4.04046088e-01f, 4.03615624e-01f, -1.39498845e-01f, 5.66525996e-01f, 7.08226383e-01f, 3.65108885e-02f, 3.15055370e-01f, 5.10973513e-01f,
  3.32908601e-01f, 1.75936237e-01f, 2.43977845e-01f, 4.72186893e-01f, 3.10069114e-01f, 4.69016433e-01f, 4.73832607e-01f, 4.09360677e-01f, -1.52932853e-01f, 3.53731602e-01f,
  1.26813248e-01f, 4.41505879e-01f, -5.02738468e-02f, -1.03750087e-01f, 1.12674937e-01f, -4.15393621e-01f, 4.10591662e-02f, -4.29183900e-01f, 9.32078138e-02f, 3.49275805e-02f,
  4.08018008e-02f, 1.04551576e-01f, -5.83701879e-02f, -1.05416402e-01f, 7.96319097e-02f, -2.00136229e-01f, -1.43252537e-01f, -1.85404643e-01f, -1.42190352e-01f, 8.60795565e-03f,
  1.33516965e-02f, -5.95058091e-02f, 3.43351103e-02f, -6.03371412e-02f, -1.02728061e-01f, -1.24663197e-01f, -9.93950441e-02f, -5.18481806e-02f, 3.36852930e-02f, -7.59546384e-02f,
  -8.92810225e-02f, 1.66883096e-02f, 1.04981631e-01f, 8.09068009e-02f, -4.38540764e-02f, 1.05710693e-01f, 8.36613253e-02f, -4.37401496e-02f, -2.71161203e-03f, 5.51837683e-02f,
  -2.83820163e-02f, 1.76870242e-01f, 1.64077934e-02f, -1.07370839e-01f, 2.82227807e-02f, -1.15209959e-01f, 8.34189206e-02f, 6.90707425e-03f, -8.47231820e-02f, 1.45053357e-01f,
  -1.15727074e-02f, -1.24888029e-02f, -1.49043957e-02f, 4.63595949e-02f, 6.81439266e-02f, 3.85847725e-02f, -1.04854420e-01f, 8.77358690e-02f, -5.93392598e-03f, -1.36435911e-01f,
  -2.68819202e-02f, 1.09965399e-01f, 4.25884426e-02f, -5.42224292e-03f, 8.28163251e-02f, -2.91142855e-02f, 1.17446914e-01f, -3.17209288e-02f, -1.42392665e-02f, 3.15881148e-02f,
  1.95851356e-01f, 5.60770214e-01f, 6.72554150e-02f, 6.62888959e-02f, -1.61440875e-02f, 3.13284658e-02f, 9.95750204e-02f, -6.09262213e-02f, 1.27255917e-01f, 7.03799948e-02f,
  2.87896451e-02f, 7.75607396e-03f, -1.78766027e-02f, -1.31947979e-01f, 6.90125227e-02f, 2.26224005e-01f, 2.58604109e-01f, -2.85045952e-02f, 1.91951960e-01f, 6.73559532e-02f,
  -9.67994332e-02f, 4.57284711e-02f, -7.55318105e-02f, -1.05709411e-01f, 6.94105104e-02f, -6.83930442e-02f, 1.23427689e-01f, -1.82077959e-01f, -4.28581387e-02f, 5.28894924e-02f,
  6.64214969e-01f, -4.36144084e-01f, -6.37155846e-02f, 4.78451490e-01f, 1.81229606e-01f, -4.77212071e-01f, -5.09744227e-01f, 3.40347558e-01f, 2.22691432e-01f, -4.14384454e-01f,
  4.68823463e-02f, -2.36931056e-01f, -4.89889413e-01f, 4.00385678e-01f, 3.22686017e-01f, -1.97898820e-01f, 4.88749772e-01f, 6.27074530e-03f, 2.02752993e-01f, 2.31089532e-01f,
  4.27014619e-01f, 3.99417639e-01f, 2.63018429e-01f, 1.05090313e-01f, 2.04248890e-01f, 1.50497779e-01f, 2.80599952e-01f, -2.90407002e-01f, 1.20729849e-01f, -6.99661998e-03f,
  -6.73463196e-03f, 3.28540742e-01f, 1.02100194e-01f, -4.68875244e-02f, 1.20377868e-01f, -1.89193353e-01f, -1.08609319e-01f, -1.61586195e-01f, -3.61306332e-02f, -5.64349294e-02f,
  -9.92536321e-02f, 2.05797255e-01f, 1.28808483e-01f, -2.34381645e-03f, -4.26067859e-02f, 5.95905036e-02f, 9.56268683e-02f, 3.65159959e-02f, -3.70866060e-02f, 2.88596414e-02f,
  -2.58199591e-02f, 3.72162485e-03f, 8.93500373e-02f, -2.44304407e-02f, 1.19462274e-01f, 8.41023400e-02f, -3.67721319e-02f, -1.00619845e-01f, -1.15767485e-02f, 1.68132231e-01f,
  6.56120405e-02f, -2.69667599e-02f, -1.00644909e-01f, -5.81382290e-02f, -3.43813412e-02f, 8.89812317e-03f, -8.70198682e-02f, -5.46977632e-02f, -1.10634759e-01f, -4.74872999e-02f,
  -2.22461503e-02f, 9.72881690e-02f, 9.58037078e-02f, -4.35977057e-02f, 1.16785407e-01f, 1.33681700e-01f, -6.10382557e-02f, 1.03193605e-02f, 1.29445314e-01f, 1.32590774e-02f,
  1.61483884e-02f, 2.98374686e-02f, -1.11503854e-01f, -1.88226942e-02f, -3.11947223e-02f, -2.71645691e-02f, 7.40315318e-02f, 4.54248376e-02f, 5.05996589e-03f, -7.85717964e-02f,
  -1.25195265e-01f, 2.52883993e-02f, -1.31990626e-01f, 9.77567062e-02f, -1.43389732e-01f, -1.39405681e-02f, 6.00174293e-02f, 1.66434124e-01f, -8.40511918e-02f, 2.25370694e-02f,
  8.95384252e-02f, -7.47894943e-02f, 2.93346066e-02f, 3.61564308e-02f, 2.74889506e-02f, -1.96888372e-02f, -1.14437053e-02f, -2.85539404e-02f, 8.60582069e-02f, 1.57436877e-01f,
  4.75990623e-02f, -5.69217764e-02f, 1.78862140e-02f, 2.17617992e-02f, -7.20195174e-02f, -1.19698785e-01f, -6.54245168e-03f, 3.25565860e-02f, 7.45027512e-02f, -1.71072800e-02f,
  -5.48737526e-01f, 5.87646484e-01f, 6.11864388e-01f, 3.64587963e-01f, 2.55870879e-01f, 4.68310714e-01f, 4.03956920e-01f, 1.68512508e-01f, 5.13949037e-01f, -3.46957803e-01f,
  -5.42649448e-01f, 5.81289306e-02f, -6.35063723e-02f, -1.31343991e-01f, -3.21699046e-02f, 2.68193513e-01f, 2.99969912e-01f, -5.88887604e-03f, 5.18254578e-01f, -5.05543500e-02f,
  1.56854331e-01f, -3.96584451e-01f, 1.36076838e-01f, -1.75853565e-01f, -4.05158773e-02f, 1.02911733e-01f, -5.34864247e-01f, 3.41861784e-01f, -2.28998080e-01f, 8.30774680e-02f,
  -1.54182643e-01f, -5.30424751e-02f, -2.42997736e-01f, -7.78574646e-02f, -1.45275623e-01f, -2.78064162e-02f, 9.43341032e-02f, 2.73350161e-02f, -4.71485518e-02f, -1.88750699e-02f,
  -4.91009280e-02f, -1.29738986e-01f, -3.61769013e-02f, 3.75370751e-03f, 1.82761744e-01f, -1.29297050e-02f, 2.15698138e-01f, -4.75411490e-02f, 2.76371352e-02f, 1.74696609e-01f,
  -1.26050683e-02f, -4.25685719e-02f, -1.03231072e-01f, 1.31495953e-01f, -4.70981002e-02f, 1.34370595e-01f, 1.66191101e-01f, 4.01626267e-02f, 5.36749661e-02f, 1.64833978e-01f,
  6.46908879e-02f, 1.38171032e-01f, -5.98929897e-02f, -2.50254907e-02f, 2.46145763e-02f, -2.35040626e-03f, -1.04340509e-01f, -1.63298890e-01f, 2.00944263e-02f, -8.16971660e-02f,
  -2.31257565e-02f, 2.04730500e-02f, 3.92522151e-03f, 4.06208076e-02f, -6.11562207e-02f, -6.37232289e-02f, -4.53482568e-02f, -8.93444568e-03f, -3.96134891e-02f, -6.66840598e-02f,
  6.66582212e-02f, 1.53617725e-01f, -4.82595824e-02f, 7.00477287e-02f, 7.70170568e-03f, 2.91861109e-02f, -1.11666463e-01f, -7.40378629e-03f, -5.58690652e-02f, -6.89494759e-02f,
  5.55404238e-02f, 2.08148137e-01f, -1.23909950e-01f, -3.73000830e-01f, -4.69012745e-02f, -1.61562815e-01f, 7.29232356e-02f, -9.11113620e-02f, 1.93982214e-01f, -4.02202569e-02f,
  -2.29462758e-02f, -6.16549253e-02f, -6.46296516e-02f, 2.43251659e-02f, -3.73656042e-02f, -1.09539963e-01f, -4.82509509e-02f, 2.12484747e-02f, -1.16842687e-01f, -1.13411538e-01f,
  -2.44147137e-01f, -8.20076689e-02f, -7.05860741e-03f, -1.07721584e-02f, -1.21944785e-01f, -2.27302685e-01f, -7.63985049e-03f, 2.94144042e-02f, -1.01123806e-02f, 8.23138058e-02f,
  5.34867883e-01f, 3.90768379e-01f, 2.76568145e-01f, 1.90717205e-01f, -3.46966207e-01f, -3.05382639e-01f, -4.16978627e-01f, -8.99743848e-03f, 2.74732977e-01f, 1.38522899e-02f,
  -2.60899931e-01f, 2.70540267e-01f, 4.47907299e-02f, 6.74438775e-02f, -1.82060786e-02f, 5.83545864e-02f, -1.60335481e-01f, -1.61057830e-01f, 4.42598052e-02f, 5.66558652e-02f,
  1.64608285e-01f, -2.17204556e-01f, 1.42451435e-01f, -6.48367852e-02f, 3.74998562e-02f, 2.32589796e-01f, -1.75326705e-01f, -1.93880051e-01f, 4.06381208e-03f, -2.44375169e-01f,
  -3.52720208e-02f, 2.55940855e-01f, 1.04645930e-01f, 4.00423706e-02f, 9.97254550e-02f, -7.41411820e-02f, 2.27455497e-02f, -4.47155684e-02f, -6.03734478e-02f, 1.17054015e-01f,
  1.03507891e-01f, 1.26577556e-01f, 8.25103149e-02f, -2.95468210e-03f, -2.13396214e-02f, 1.65821373e-01f, 1.25582904e-01f, 1.51188979e-02f, 7.42933434e-03f, 6.00485988e-02f,
  7.13963360e-02f, 9.61098075e-02f, 8.78401697e-02f, -4.73464392e-02f, 1.30950153e-01f, 3.53233106e-02f, -6.49897084e-02f, -1.30048186e-01f, 1.08699352e-02f, 1.36288464e-01f,
  1.64582744e-01f, -7.18414690e-03f, -4.21346985e-02f, -1.37839153e-01f, 4.77373637e-02f, -3.11422460e-02f, 7.83984587e-02f, -1.22195762e-02f, 3.43604833e-02f, -1.05377458e-01f,
  -2.42024258e-01f, -3.03669441e-02f, -2.74083167e-02f, -2.23240480e-02f, 4.49430719e-02f, 1.35972410e-01f, -3.48708034e-02f, 1.18284533e-02f, -7.13407248e-02f, -8.10511336e-02f,
  -5.55595495e-02f, -1.98654950e-01f, 5.37794530e-02f, -8.93921852e-02f, -1.89200789e-01f, 5.11306897e-02f, 8.70995671e-02f, 1.80658385e-01f, -1.31533653e-01f, -1.32818967e-01f,
  -2.95048244e-02f, 1.70714855e-01f, 6.96054846e-02f, 5.24461679e-02f, 7.98102543e-02f, 5.42538725e-02f, 9.28566307e-02f, 5.32222614e-02f, 9.36875045e-02f, 3.74318399e-02f,
  -8.25250056e-03f, -1.20797321e-01f, -1.23262867e-01f, 8.51675272e-02f, -6.56452030e-02f, -5.08944876e-02f, 3.87311429e-02f, -7.57914707e-02f, -1.40000910e-01f, 1.06639840e-01f,
  3.32498215e-02f, 6.39485288e-03f, 5.07339053e-02f, -6.14989437e-02f, -1.65959224e-02f, 1.38030546e-02f, -2.10041776e-02f, 8.25314969e-02f, 6.79863766e-02f, -7.00073689e-02f,
  -4.28833425e-01f, 3.19405854e-01f, -2.68814534e-01f, -1.52692124e-01f, 1.81371234e-02f, -3.22694570e-01f, -1.70139983e-01f, -1.42454758e-01f, 1.61660299e-01f, 3.92326444e-01f,
  7.89389163e-02f, 1.35313898e-01f, 3.07686061e-01f, -2.85412192e-01f, -7.14683414e-01f, -2.96222985e-01f, -3.03501278e-01f, 1.91719979e-02f, 1.62975658e-02f, -6.11309148e-02f,
  -2.66941398e-01f, -1.90112546e-01f, -2.83838004e-01f, 2.00246826e-01f, -3.72249298e-02f, 9.96067077e-02f, -2.07785636e-01f, 1.64475873e-01f, -2.78361231e-01f, -1.52747765e-01f,
  1.05856694e-01f, 3.00885826e-01f, 9.29688588e-02f, 6.59064725e-02f, -2.05983091e-02f, -3.71552110e-02f, -1.25463665e-01f, -3.38375866e-02f, 1.77198768e-01f, -1.28640041e-01f,
  1.30904794e-01f, 1.33870710e-02f, -5.60007021e-02f, -1.01797774e-01f, -1.60856079e-02f, 1.68915931e-02f, -1.37794599e-01f, -1.14780731e-01f, 1.24871418e-01f, -1.44542560e-01f,
  -8.49850997e-02f, 3.58006954e-02f, -3.19263898e-02f, 1.28775001e-01f, -1.16149686e-01f, 9.96005684e-02f, -8.66124779e-02f, -2.24790365e-01f, -4.81501780e-02f, -3.89365293e-02f,
  -7.16028064e-02f, -2.29969993e-02f, -4.37233858e-02f, -2.09188443e-02f, -9.88578424e-02f, 1.32492520e-02f, -7.27517009e-02f, 3.61555815e-02f, -3.08791604e-02f, -8.23784247e-02f,
  7.65937343e-02f, 2.37511983e-03f, -1.34539800e-02f, 3.60646867e-03f, -8.13125968e-02f, -3.22086848e-02f, -1.02225121e-03f, 1.86983898e-01f, 1.02358170e-01f, -5.28539792e-02f,
  8.83428156e-02f, 6.43245922e-03f, 1.02862768e-01f, -6.41159713e-02f, -1.20512217e-01f, -1.20728444e-02f, -7.37055019e-02f, -6.05572462e-02f, 8.82673934e-02f, -7.97115043e-02f,
  6.12074323e-02f, 1.00479692e-01f, 2.54311055e-01f, 1.61736026e-01f, 4.79329266e-02f, -1.26535222e-01f, -5.57503514e-02f, -5.40883802e-02f, 5.69707640e-02f, -1.10674284e-01f,
  -1.18394017e-01f, 4.71175574e-02f, 2.05526855e-02f, -1.01823024e-01f, 1.63429826e-01f, -1.57817319e-01f, 3.50624472e-02f, 1.09314933e-01f, 1.65877506e-01f, -3.38340886e-02f,
  2.41831988e-01f, 1.07902907e-01f, -4.66976352e-02f, 2.69112289e-01f, 9.81780514e-02f, 7.99450874e-02f, 1.43470988e-02f, -3.11829187e-02f, 9.89165530e-02f, 1.71382472e-01f,
  -1.38425454e-01f, 1.00636557e-01f, -6.92568347e-02f, 2.47333497e-02f, -3.64424199e-01f, -9.10601765e-02f, -2.15476155e-01f, -3.81112009e-01f, 2.14005262e-01f, 2.36400262e-01f,
  -2.65206158e-01f, 8.64032805e-02f, -1.59779787e-01f, -1.57809585e-01f, -1.14570163e-01f, 3.26068848e-01f, 3.22427601e-01f, 1.60201088e-01f, 1.76090971e-02f, -2.08790392e-01f,
  -4.17605489e-02f, -2.81937242e-01f, -1.92240879e-01f, -3.08832407e-01f, -3.29025686e-01f, 8.53546932e-02f, 1.81600451e-01f, -1.89945474e-01f, 1.22874007e-01f, -1.72846466e-01f,
  4.34917286e-02f, -1.26686454e-01f, -2.27578077e-02f, 1.32924870e-01f, 5.92636652e-02f, 9.30949226e-02f, 1.64369673e-01f, -6.84500486e-02f, -1.17829725e-01f, -6.46402761e-02f,
  7.36556128e-02f, -1.37123084e-02f, 5.56405112e-02f, -7.86152631e-02f, -2.77799070e-01f, 2.40825843e-02f, 5.18254340e-02f, 6.85711280e-02f, -2.72618197e-02f, -7.98709169e-02f,
  4.04738858e-02f, 9.45347324e-02f, -9.74598229e-02f, 1.78685561e-01f, 2.65696216e-02f, -1.51424333e-01f, 2.31789440e-01f, -4.69688885e-02f, 1.79570362e-01f, 5.89816831e-02f,
  -3.58312018e-02f, 2.23869935e-01f, -2.26560608e-02f, 1.41093554e-02f, -4.49431539e-02f, 6.39944163e-04f, -1.40320240e-02f, -5.48422560e-02f, -7.61195347e-02f, 9.16203111e-02f,
  2.18696408e-02f, -1.77295864e-01f, -1.09627899e-02f, -4.78198305e-02f, -1.38169304e-01f, 3.00231222e-02f, -1.09547466e-01f, -4.57422575e-04f, 7.70389512e-02f, 1.44920163e-02f,
  -4.93809464e-04f, 1.40652105e-01f, 2.18867585e-02f, -1.03507759e-02f, -1.17009487e-02f, -1.21305965e-01f, -2.58215740e-02f, -4.86715659e-02f, -6.99619725e-02f, -1.33620296e-02f,
  1.93031758e-01f, 2.15578139e-01f, -4.51603858e-03f, -1.24852564e-02f, 7.45022818e-02f, 5.38457483e-02f, 9.54748541e-02f, -4.43496276e-03f, 9.27837789e-02f, -1.32860303e-01f,
  1.02312952e-01f, 1.42601645e-02f, 1.83665514e-01f, -1.08976334e-01f, -5.69069907e-02f, -3.10576917e-03f, 1.63754195e-01f, 1.08176194e-01f, 5.89484386e-02f, -6.34635612e-02f,
  -1.54704219e-02f, 1.34117961e-01f, 5.19921817e-02f, 8.54046121e-02f, 1.95871115e-01f, 9.91332605e-02f, 5.47180586e-02f, -2.54445523e-03f, -4.60094623e-02f, 1.45274565e-01f,
  -6.02075994e-01f, 1.03301704e-01f, -1.61292598e-01f, -2.31987193e-01f, -4.28073615e-01f, -2.51565039e-01f, -9.37838294e-03f, -8.29996988e-02f, -1.25356438e-02f, 4.50035363e-01f,
  2.36579198e-02f, 4.28728126e-02f, 4.05009955e-01f, -1.42036881e-02f, 3.29629071e-02f, 3.62945616e-01f, -2.11354923e-02f, 8.46602023e-02f, -1.70386642e-01f, -2.01628163e-01f,
  -1.65736035e-01f, -1.39236495e-01f, 1.79071724e-02f, -2.04723284e-01f, -4.31076735e-01f, -2.85544991e-01f, -1.88481480e-01f, -2.58790404e-01f, -2.96196759e-01f, -2.50288427e-01f,
  -6.03549063e-01f, -3.50815892e-01f, -2.75624488e-02f, -1.47800118e-01f, -1.48735642e-01f, -2.35443637e-02f, -1.14650048e-01f, 4.08586115e-04f, -1.42647788e-01f, 2.87077874e-02f,
  6.69799373e-02f, -7.19607249e-02f, -1.09971516e-01f, 4.50525507e-02f, -6.59043938e-02f, -1.40474096e-01f, -6.53800368e-02f, -9.82755572e-02f, -4.95429896e-02f, -6.45480379e-02f,
  1.46655273e-02f, -3.67047414e-02f, -1.61438495e-01f, 1.98712144e-02f, -2.32757062e-01f, -2.03670427e-01f, 5.03203236e-02f, -8.79312158e-02f, -1.35414988e-01f, -1.69174448e-01f,
  3.71390693e-02f, -4.18060236e-02f, 6.61333948e-02f, 3.56321298e-02f, 3.31563014e-03f, -9.40963179e-02f, -7.55961761e-02f, 5.41256033e-02f, -6.09439686e-02f, -1.59640506e-01f,
  -8.51482525e-02f, -6.77712709e-02f, -1.43089190e-01f, -4.74060923e-02f, 4.47797738e-02f, 7.96450004e-02f, 1.06458724e-01f, -1.31359413e-01f, -3.25424522e-02f, -2.70916447e-02f,
  1.83274765e-02f, -2.36721244e-02f, -8.77016261e-02f, 3.25063318e-02f, 7.78928725e-03f, 3.24893966e-02f, 3.09464447e-02f, 3.40349264e-02f, -3.43256295e-02f, -7.25148842e-02f,
  -5.52061677e-01f, -4.77444410e-01f, -1.42394258e-02f, -8.23927969e-02f, 9.67182815e-02f, 7.60812014e-02f, -2.18291879e-02f, -5.94866229e-03f, -1.48166716e-01f, 1.06517024e-01f,
  -1.10701900e-02f, 1.12784564e-01f, -1.68515071e-01f, 8.46392214e-02f, 7.19942898e-02f, -7.67401308e-02f, -1.36227654e-02f, -6.77541690e-03f, -8.67228732e-02f, -6.00391403e-02f,
  -2.46792585e-02f, 1.34986579e-01f, 1.56907007e-01f, -5.90832941e-02f, -6.04986548e-02f, -3.57015729e-02f, -1.89575087e-02f, 7.30238929e-02f, -2.52990961e-01f, -5.08653559e-02f,
  4.04156074e-02f, 1.64519101e-01f, 5.53664267e-01f, -6.62319735e-02f, 1.00241289e-01f, 3.89117777e-01f, 1.48871854e-01f, 2.81561673e-01f, 4.70401973e-01f, -2.64244974e-01f,
  -3.52930188e-01f, 5.48045263e-02f, 1.24523118e-01f, -2.73352206e-01f, 4.31428313e-01f, 2.38455623e-01f, 8.14167783e-02f, -8.65296423e-02f, 3.08498263e-01f, -2.11989153e-02f,
  1.30817249e-01f, -3.07902426e-01f, -1.32432982e-01f, -3.55711102e-01f, -2.75910854e-01f, -8.45936015e-02f, -5.05014658e-01f, 6.23215064e-02f, -3.67386580e-01f, 2.12682597e-02f,
  -1.43793881e-01f, -2.23920152e-01f, 1.44462168e-01f, 1.67518511e-01f, 3.63197699e-02f, -5.16157411e-02f, 1.64056104e-02f, -2.71161273e-02f, 1.51104331e-01f, 3.81605029e-02f,
  -4.84421588e-02f, -8.82102996e-02f, -1.40399605e-01f, 1.75234266e-02f, 1.16019502e-01f, -5.11828326e-02f, -1.61924213e-02f, 1.25809953e-01f, 1.94466915e-02f, 1.76033765e-01f,
  2.33494923e-01f, 1.60644546e-01f, -1.02218566e-02f, -2.72774254e-03f, 1.09140866e-01f, -4.06585597e-02f, -1.85583048e-02f, -2.85668094e-02f, 1.32051140e-01f, -3.51954554e-03f,
  6.85429797e-02f, 1.14499502e-01f, -6.55057728e-02f, 5.52523248e-02f, 1.58975348e-02f, 2.51932684e-02f, 6.44798428e-02f, -2.30288684e-01f, 8.85077640e-02f, -8.32698494e-02f,
  -6.56514019e-02f, -5.81670962e-02f, 4.99403197e-03f, 1.07653320e-01f, -4.21885774e-02f, -5.46136722e-02f, -7.15925619e-02f, 2.66665127e-02f, -2.44961567e-02f, -9.56956297e-02f,
  1.62174311e-02f, 8.82669687e-02f, -2.16162875e-01f, -8.22854266e-02f, 3.90065387e-02f, -1.21586611e-02f, 7.12748757e-03f, 3.98293957e-02f, -3.04062106e-02f, 1.45036234e-02f,
  9.78695825e-02f, -6.14277786e-03f, -3.89794335e-02f, -4.80554067e-02f, -8.79427418e-03f, -5.78443371e-02f, 1.35875255e-01f, 4.23250254e-03f, 1.73484851e-02f, 7.57264420e-02f,
  1.08038366e-01f, -3.61293629e-02f, -8.54510665e-02f, -5.33519313e-03f, 5.63637987e-02f, 5.49830757e-02f, -1.13387130e-01f, 4.48084995e-02f, 7.40982667e-02f, -4.38631028e-02f,
  8.21583197e-02f, -1.33951623e-02f, -3.59857120e-02f, -1.20923199e-01f, -1.34771541e-01f, -1.44828483e-01f, -1.02010496e-01f, 6.26931190e-02f, 6.08624481e-02f, -4.74711806e-02f,
  -6.04487896e-01f, 4.84777719e-01f, -3.78866851e-01f, -1.26988381e-01f, 1.83609664e-01f, 2.00206935e-01f, 3.63469511e-01f, 1.24728210e-01f, 4.31642622e-01f, 3.85258913e-01f,
  3.80519927e-01f, 1.56265765e-01f, 2.99497187e-01f, 3.62576753e-01f, -2.98421144e-01f, 1.72085077e-01f, -1.08605884e-01f, 6.15891665e-02f, 1.81929201e-01f, -6.30226731e-02f,
  -2.50362784e-01f, 3.63596290e-01f, -2.96946168e-01f, 8.29193294e-02f, -1.48465082e-01f, -2.14978755e-01f, -6.92740083e-02f, 2.87930697e-01f, -9.50202644e-02f, 2.79115140e-01f,
  -2.71278143e-01f, -9.90503933e-04f, -1.20088257e-01f, -1.71737716e-01f, -2.30060667e-01f, -1.64113909e-01f, -1.80275217e-01f, 8.12447891e-02f, 1.00090787e-01f, 5.94594032e-02f,
  9.50146690e-02f, -9.48169455e-02f, 6.77042007e-02f, 8.44005868e-02f, -2.43316800e-03f, 2.23310161e-02f, -3.96004645e-04f, -1.19771205e-01f, 9.88331288e-02f, -9.09875706e-02f,
  -5.48401140e-02f, -9.68714952e-02f, -1.33402437e-01f, -5.26966788e-02f, 4.56777122e-03f, 9.15412977e-02f, -1.20601222e-01f, -9.95976925e-02f, -1.26219571e-01f, -7.89433345e-02f,
  -3.88151854e-02f, 5.35847284e-02f, -2.95574572e-02f, 2.03703288e-02f, 1.39149353e-01f, -8.16262290e-02f, 1.60990991e-02f, 3.15484367e-02f, -2.51438767e-02f, 8.11357722e-02f,
  -1.71743315e-02f, -5.85064478e-02f, -3.11951153e-02f, -3.15659270e-02f, 1.64179213e-03f, 1.56144528e-02f, 8.48580599e-02f, 2.93037761e-03f, -6.49252832e-02f, -5.30542023e-02f,
  1.97598994e-01f, -2.91036405e-02f, 1.09018413e-02f, -1.31800100e-01f, 6.28075749e-03f, 5.86951093e-04f, 3.54392007e-02f, -8.28523934e-02f, 9.02534127e-02f, -2.30773948e-02f,
  9.61805284e-02f, -1.23069450e-01f, 1.80917159e-01f, -5.67595996e-02f, 5.09036109e-02f, -9.60174054e-02f, 3.33545208e-02f, -1.07357316e-01f, 4.14262824e-02f, -8.03972874e-03f,
  -1.63377181e-01f, -5.47686033e-02f, -7.21858069e-02f, 8.95984024e-02f, -1.12566985e-01f, 6.96874708e-02f, 1.28162429e-01f, 1.22202620e-01f, 2.63465438e-02f, -1.27359435e-01f,
  -2.52130982e-02f, 1.59506593e-02f, -1.06580919e-02f, -5.10533480e-03f, -3.22454199e-02f, 2.14611907e-02f, -7.87609369e-02f, -1.08766101e-01f, -5.07371798e-02f, -6.76658154e-02f,
  -1.38884574e-01f, 6.15381636e-02f, -2.95249313e-01f, -5.99646747e-01f, 1.11600347e-01f, -2.45880574e-01f, -4.10241783e-01f, -1.50214061e-02f, 3.57363932e-02f, 4.32929546e-02f,
  -6.33219332e-02f, -1.38846442e-01f, 3.20300251e-01f, -3.64501804e-01f, -2.13940799e-01f, 1.48056820e-01f, -4.67113048e-01f, -4.18971181e-01f, 2.12179750e-01f, -2.66891003e-01f,
  -1.88763633e-01f, -2.01018229e-01f, -2.35516623e-01f, 3.65416706e-01f, -3.08649451e-01f, -1.39974236e-01f, -1.12060584e-01f, 1.66298226e-01f, -4.31806505e-01f, 7.39220483e-03f,
  -1.08504005e-01f, 1.66689306e-01f, -1.22713469e-01f, 1.01072483e-01f, 1.14089614e-02f, -9.22333747e-02f, -2.20229685e-01f, 1.30622223e-01f, -9.27109793e-02f, 8.47648755e-02f,
  -7.85354376e-02f, 4.11349572e-02f, 6.68313261e-03f, 1.34187430e-01f, 1.21208467e-01f, -2.53619021e-03f, 2.29727011e-03f, -2.09303454e-01f, -3.75556126e-02f, -1.82992928e-02f,
  -2.47259364e-02f, -1.30330071e-01f, -6.40522912e-02f, -6.16998412e-02f, -7.77994748e-03f, 2.28069536e-03f, -1.85098901e-01f, -1.56346202e-01f, 5.67893013e-02f, -7.26314038e-02f,
  4.78985719e-02f, -7.85449520e-02f, 1.33778393e-01f, 1.40829667e-01f, 1.43371254e-01f, 4.22169752e-02f, -1.41176119e-01f, -8.29954669e-02f, 9.40549150e-02f, -9.96320620e-02f,
  -6.73109666e-02f, -4.00378573e-04f, 9.92252305e-02f, -1.65292978e-01f, -1.76490337e-01f, 3.38560641e-02f, -1.73089597e-02f, 3.43701169e-02f, -1.50299713e-01f, 1.33684771e-02f,
  8.18285793e-02f, -9.12432298e-02f, 1.02544755e-01f, 5.90578727e-02f, -2.59080785e-03f, 1.29948482e-01f, 1.63894281e-01f, -3.49424258e-02f, 4.60684262e-02f, -2.58692503e-02f,
  -1.25215113e-01f, 2.23860979e-01f, 5.06833903e-02f, 1.42971724e-01f, -2.50322092e-02f, -4.29678485e-02f, -2.42070835e-02f, -6.11955337e-02f, -8.39219149e-03f, 1.90232739e-01f,
  -1.54533550e-01f, -1.82183415e-01f, 3.57763347e-04f, 2.83215418e-02f, 3.71218249e-02f, 2.30322760e-02f, -8.59650001e-02f, -1.64426751e-02f, -1.06357284e-01f, 1.55376224e-02f,
  7.25652352e-02f, 1.26245648e-01f, -1.50034223e-02f, 3.55735831e-02f, 5.88790402e-02f, -2.03195885e-01f, 1.15554780e-01f, -5.72745726e-02f, -1.77057944e-02f, -4.51933630e-02f,
  1.70642108e-01f, -1.55479163e-01f, -4.34691578e-01f, -4.95481461e-01f, 5.42441485e-05f, -4.33566242e-01f, -4.66476709e-01f, -1.50019243e-01f, -1.65094078e-01f, 2.75477707e-01f,
  7.02902228e-02f, -1.39920756e-01f, 2.72453785e-01f, -4.06870484e-01f, -5.91100514e-01f, -1.86009631e-01f, -4.66889769e-01f, -4.21267837e-01f, 1.28246602e-02f, -2.17804182e-02f,
  -1.16523102e-01f, 3.71902436e-02f, -4.41506952e-01f, 4.25726414e-01f, -2.61870530e-02f, 9.17089731e-02f, 3.39333773e-01f, 2.69560099e-01f, -1.92862064e-01f, -9.25356448e-02f,
  -1.09183930e-01f, 7.99971148e-02f, -1.60817459e-01f, -1.19552009e-01f, -1.39004886e-01f, 1.15453839e-01f, 1.13114342e-02f, -1.08705387e-01f, -2.54028607e-02f, -1.12903602e-01f,
  1.34982944e-01f, 1.84888676e-01f, -7.50478208e-02f, 1.18101463e-01f, 1.77933991e-01f, 2.45593805e-02f, -7.41683319e-02f, -6.26068711e-02f, 1.27844186e-02f, -9.33352858e-02f,
  -2.19563827e-01f, -5.62706478e-02f, 7.74756223e-02f, 3.09557258e-03f, 2.89754346e-02f, -4.12298106e-02f, -4.49956767e-02f, 2.55392268e-02f, 3.67552079e-02f, 2.38414593e-02f,
  1.08843237e-01f, 1.62991241e-01f, 1.56803913e-02f, -2.38313824e-02f, -2.97795050e-02f, 2.74304487e-03f, -2.20249388e-02f, -1.16538346e-01f, 3.54658663e-02f, -3.14099565e-02f,
  3.77979241e-02f, -1.26165912e-01f, 8.13922063e-02f, 2.36381125e-02f, 2.10777596e-02f, 4.37110066e-02f, 6.05424084e-02f, 2.30509602e-02f, -1.13341257e-01f, -1.10324979e-01f,
  6.98617101e-02f, 1.60053931e-02f, -7.59853795e-02f, 1.45191282e-01f, -1.22586377e-01f, -1.98812354e-02f, 1.07987739e-01f, -4.32517268e-02f, -3.01854834e-02f, 5.89723848e-02f,
  -9.09711346e-02f, 5.15305363e-02f, -6.74422607e-02f, 5.53494953e-02f, -1.34972900e-01f, -3.80625897e-05f, -1.04525864e-01f, -2.02489108e-01f, 3.84347290e-02f, 1.15338549e-01f,
  9.05282572e-02f, 5.86036108e-02f, 1.12449057e-01f, 3.85975614e-02f, -6.73733056e-02f, -3.23197879e-02f, 1.62832096e-01f, 4.69318219e-02f, 2.56244633e-02f, 1.79692209e-02f,
  1.59523174e-01f, 1.97344407e-01f, 7.43468180e-02f, -1.08184502e-01f, 4.93536741e-02f, 1.17820680e-01f, 1.44221559e-02f, 2.70466022e-02f, 1.01655938e-01f, -3.70813231e-03f,
  7.63927773e-02f, -3.46468836e-01f, -7.81135112e-02f, 3.15339267e-01f, 3.83945376e-01f, -1.26935840e-01f, 1.54541865e-01f, 3.49588066e-01f, 7.94711486e-02f, -1.75069645e-01f,
  1.07938179e-03f, -4.65866774e-01f, -4.08160180e-01f, -4.21229243e-01f, -1.87664062e-01f, -6.27652287e-01f, -4.14458327e-02f, -2.26551205e-01f, -1.21512689e-01f, 2.93719172e-01f,
  2.70488113e-01f, 1.64793149e-01f, 2.55491167e-01f, 3.16951215e-01f, 3.64505053e-01f, 4.57351804e-01f, 5.51363349e-01f, 9.34641957e-02f, 2.47943550e-01f, -2.27836266e-01f,
  -1.42155364e-01f, -1.93529502e-02f, 1.03493772e-01f, -1.31466970e-01f, 3.11089665e-01f, 1.18730642e-01f, 2.80212928e-02f, -1.61145180e-01f, -2.72189099e-02f, -4.09205556e-02f,
  1.92243129e-03f, -1.19198272e-02f, -2.12198883e-01f, -6.90588355e-02f, 7.78484270e-02f, 3.48034911e-02f, -1.07714757e-01f, 7.08709732e-02f, -2.40899678e-02f, -7.81551525e-02f,
  3.53060402e-02f, -6.06964305e-02f, -1.19130993e-02f, -6.58206642e-02f, 1.82564743e-02f, 3.87848131e-02f, 1.12760849e-02f, 9.95082706e-02f, 2.23553870e-02f, 1.78714573e-01f,
  -9.39647947e-03f, 8.10387805e-02f, -6.90873638e-02f, -1.07034035e-01f, 1.55430529e-02f, 1.37750104e-01f, -1.48406401e-01f, -3.01472079e-02f, 8.44052806e-02f, 3.62434387e-02f,
  1.56477004e-01f, 6.56811073e-02f, -1.43624013e-02f, 7.58951604e-02f, 1.17482096e-01f, -7.48600112e-03f, -9.40179527e-02f, -1.44313887e-01f, 2.38233536e-01f, -1.98312551e-02f,
  -1.44729957e-01f, -4.31945212e-02f, 1.20413080e-02f, 1.32056866e-02f, -1.55518830e-01f, 1.45752281e-01f, -1.32560721e-02f, -6.40493631e-02f, 3.26136053e-02f, 2.11760923e-02f,
  3.84729803e-02f, 9.84803662e-02f, 8.90123833e-04f, -9.76561755e-02f, -8.96057189e-02f, -2.98004989e-02f, -1.93431005e-01f, -3.67302746e-02f, -3.07375807e-02f, -2.94174887e-02f,
  3.04833740e-01f, 1.39386848e-01f, -3.34367976e-02f, -1.03863731e-01f, -2.00418439e-02f, 2.17860907e-01f, 8.96522403e-02f, 1.71422645e-01f, 1.16794989e-01f, 2.27819934e-01f,
  1.60860598e-01f, 1.22548491e-01f, 7.54253492e-02f, 1.35996804e-01f, 1.52172036e-02f, 9.14210677e-02f, 1.40369385e-02f, 7.25345612e-02f, -9.50526744e-02f, -1.09648012e-01f,
  4.21636440e-02f, -1.09714344e-01f, -4.19289321e-01f, -1.45787418e-01f, -6.71006620e-01f, -3.09385844e-02f, 1.68200806e-01f, -2.41864651e-01f, -3.61662991e-02f, 2.94120997e-01f,
  -1.64694726e-01f, 1.10845990e-01f, 3.92523855e-01f, -2.37590730e-01f, 3.58770281e-01f, 5.58833420e-01f, 1.40839368e-01f, 2.72972912e-01f, -5.54215237e-02f, 2.43579764e-02f,
  -1.21298447e-01f, 4.09437269e-02f, 4.45470288e-02f, -2.40221709e-01f, -4.73748416e-01f, -3.66455227e-01f, -1.64469004e-01f, -3.53708297e-01f, -4.29640085e-01f, -2.27468103e-01f,
  -2.96953022e-01f, -3.14787060e-01f, -2.41875034e-02f, 2.11601540e-01f, -1.36693388e-01f, -6.09674491e-02f, -8.87016580e-02f, 1.42976446e-02f, -1.31130204e-01f, -1.16898745e-01f,
  1.63043678e-01f, 9.39275622e-02f, 4.22901055e-03f, 9.70881358e-02f, 6.45875037e-02f, -2.07155302e-01f, -1.76094100e-01f, -1.90108607e-03f, -3.47984396e-02f, -5.64315990e-02f,
  4.48218212e-02f, -1.26781359e-01f, -1.28336594e-01f, 9.53158457e-03f, -2.62064517e-01f, -6.45775124e-02f, 1.39231876e-01f, -9.04441699e-02f, -1.11774132e-01f, -1.63081855e-01f,
  -5.90598881e-02f, -1.12575255e-01f, -8.42310861e-03f, -1.18524057e-03f, -2.73675434e-02f, -1.16708227e-01f, 5.58248870e-02f, 4.56196023e-03f, 8.26767460e-02f, -4.19044159e-02f,
  -7.37490430e-02f, -2.37430888e-03f, -6.14228509e-02f, 5.91274314e-02f, 2.84037143e-02f, 7.98170194e-02f, 1.53388977e-01f, -6.29059449e-02f, 4.87301201e-02f, 2.50926614e-02f,
  -5.20644858e-02f, 3.55672953e-03f, -1.00103952e-02f, 9.10693128e-03f, -4.53130640e-02f, -2.54420880e-02f, -1.49232134e-01f, -1.54714920e-02f, -6.47453293e-02f, -3.26422192e-02f,
  -1.27888054e-01f, -9.20314342e-02f, 3.47012212e-03f, 5.73648363e-02f, 1.18277274e-01f, -7.62389600e-02f, -9.58755910e-02f, -1.02739833e-01f, 1.24721145e-02f, 7.53022656e-02f,
  1.02604859e-01f, 1.36382565e-01f, -1.43516347e-01f, -5.81828319e-02f, 1.14794053e-01f, -5.11295488e-03f, 1.15055464e-01f, 9.22046229e-03f, -3.85352932e-02f, 1.34799760e-02f,
  5.89709170e-02f, 1.09788947e-01f, 1.88703299e-01f, 4.78985161e-02f, 1.39062941e-01f, 7.18694180e-02f, 1.69303101e-02f, -6.00715056e-02f, -9.21891928e-02f, -3.04080211e-02f,
  -1.03635752e+00f, 6.49669945e-01f, 4.34246689e-01f, -3.46038133e-01f, -1.81530967e-01f, -2.61563361e-02f, 2.09247038e-01f, 1.45269157e-02f, -4.62726653e-02f, 3.64217967e-01f,
  -1.84836183e-02f, 3.08412224e-01f, 1.94025084e-01f, 2.50047207e-01f, -5.63195527e-01f, 1.78395540e-01f, -1.19151853e-01f, 6.54481202e-02f, -4.38033007e-02f, -1.46450326e-01f,
  -1.75945237e-01f, -2.91788995e-01f, 9.82071757e-02f, 8.65937322e-02f, 2.03161463e-01f, -5.91672510e-02f, -3.85939807e-01f, 1.25963345e-01f, 1.00097671e-01f, 1.87662631e-01f,
  -5.99032581e-01f, -2.51155347e-01f, 5.49650379e-03f, 9.49129537e-02f, -1.03913084e-01f, 8.59140884e-03f, 4.13840525e-02f, -2.17826068e-02f, -1.78390250e-01f, 4.48659956e-02f,
  1.52548477e-01f, 2.65972968e-02f, -5.70915057e-04f, 2.03342382e-02f, -4.95615378e-02f, 1.82556920e-02f, 1.15879357e-01f, 1.93417475e-01f, 1.50688201e-01f, 1.96575835e-01f,
  2.13825554e-01f, 2.00448766e-01f, 9.85277444e-03f, 5.61085753e-02f, 3.76274362e-02f, -2.73223855e-02f, 4.86832187e-02f, 9.43667218e-02f, 1.10146403e-02f, -9.40259025e-02f,
  -1.06575437e-01f, -1.68692842e-01f, 4.14132746e-03f, -1.38099520e-02f, 7.55208507e-02f, 1.08432896e-01f, -3.64810205e-03f, 1.90864578e-02f, 5.69151454e-02f, -1.17211208e-01f,
  -1.04779914e-01f, 1.18807787e-02f, -1.61776468e-01f, -1.20328933e-01f, -1.45917252e-01f, 5.48955202e-02f, 1.18687311e-02f, -2.69900654e-02f, 3.26829255e-02f, -5.64379580e-02f,
  -4.93688695e-02f, -1.53852804e-02f, 1.18199244e-01f, -1.04091112e-02f, 4.97220866e-02f, -2.41725445e-02f, 2.78246440e-02f, 8.15822110e-02f, -9.77638140e-02f, -1.25910908e-01f,
  -8.60676050e-01f, -6.46207690e-01f, -1.15723059e-01f, -8.84339213e-02f, -3.96723449e-02f, -3.10354121e-02f, -5.51088750e-02f, -4.46412265e-02f, -1.41841114e-01f, -1.10472545e-01f,
  -6.15185089e-02f, 5.60367666e-02f, -1.88967839e-01f, -1.65535789e-02f, -3.27379517e-02f, -8.22161138e-02f, -1.21395856e-01f, -1.33206770e-01f, -2.01904282e-01f, 6.37457753e-03f,
  8.24924856e-02f, -1.09055817e-01f, -4.96416129e-02f, -1.48395365e-02f, -3.86946872e-02f, -8.22432637e-02f, -1.05456673e-01f, 1.25104204e-01f, -1.10734671e-01f, 1.10269800e-01f,
  -2.33243689e-01f, 6.59650087e-01f, 7.39242584e-02f, -1.75543740e-01f, 2.42463332e-02f, -3.12806338e-01f, -2.19520941e-01f, 2.40407407e-01f, 2.66973525e-01f, 1.16460398e-03f,
  -2.51993924e-01f, 5.19736707e-01f, 2.53118962e-01f, -1.89519897e-01f, -4.34643120e-01f, 9.97427627e-02f, -3.17458063e-01f, -7.14972690e-02f, 2.21875593e-01f, -1.60514325e-01f,
  -1.26337543e-01f, -2.89953351e-01f, -1.59831226e-01f, 1.08987056e-01f, -1.18517287e-01f, 1.26421908e-02f, -3.58751386e-01f, -4.09112731e-03f, -1.30103320e-01f, -1.91196259e-02f,
  -4.18759406e-01f, -1.31745458e-01f, -1.32465348e-01f, -5.95720224e-02f, -1.64982736e-01f, -1.18483379e-01f, -2.40451887e-01f, -4.26324494e-02f, -1.10716105e-01f, 9.47899967e-02f,
  1.47435054e-01f, 1.25178769e-01f, 1.56925730e-02f, 1.36528745e-01f, 4.03785445e-02f, 8.14051777e-02f, -4.54356894e-02f, -6.17428198e-02f, 8.37838724e-02f, 1.19556889e-01f,
  9.14026201e-02f, -9.53060295e-03f, -2.57691115e-01f, -4.66422439e-02f, -1.28835946e-01f, -1.11340299e-01f, -1.33021876e-01f, -8.52114484e-02f, 3.27264480e-02f, 8.15987587e-02f,
  1.10660270e-02f, -1.07679375e-01f, -6.29624799e-02f, 4.12781201e-02f, 5.17492332e-02f, 2.28346512e-02f, -1.39219612e-02f, -3.23290788e-02f, -1.77208427e-02f, -1.26482993e-01f,
  2.00106446e-02f, -6.18625246e-03f, 6.12176396e-02f, -6.73708171e-02f, -8.18408001e-03f, 3.11252717e-02f, -1.25211000e-01f, 1.48270074e-02f, 5.86321168e-02f, 2.72206850e-02f,
  -3.17806415e-02f, -1.06903806e-01f, 1.00261949e-01f, -4.49765213e-02f, -1.20262414e-01f, -4.27671187e-02f, -6.27814159e-02f, 5.39937392e-02f, -2.58181579e-02f, -1.21673867e-01f,
  -5.54472804e-01f, -4.64635462e-01f, -1.32816061e-01f, 2.90963165e-02f, 1.86624173e-02f, -7.61209056e-02f, -2.35039238e-02f, 2.93602664e-02f, -2.37743303e-01f, -3.20371054e-03f,
  -2.68964842e-02f, 7.00796489e-03f, -1.62855327e-01f, 5.34996204e-02f, -3.53598893e-02f, -1.18522957e-01f, -9.56141427e-02f, -8.27608556e-02f, -2.21570686e-01f, 7.12663773e-03f,
  2.08660904e-02f, -5.42975143e-02f, -1.64136350e-01f, -2.06342191e-02f, -4.36925143e-02f, -1.95903897e-01f, -7.19543695e-02f, 7.42812604e-02f, -1.87785059e-01f, 6.71398863e-02f,
  2.04459459e-01f, 4.77448583e-01f, 2.68975377e-01f, 5.07154882e-01f, -6.00973591e-02f, -1.78083122e-01f, 1.99718520e-01f, 1.63055986e-01f, 4.79069978e-01f, -2.43230000e-01f,
  -2.61272788e-01f, 3.39282870e-01f, -2.03425705e-01f, 1.39529556e-01f, -1.80390939e-01f, -9.53956917e-02f, 2.90085226e-01f, 8.25045332e-02f, 3.46927375e-01f, 2.79082626e-01f,
  1.95849091e-01f, -3.85678440e-01f, -1.25436157e-01f, -5.17749377e-02f, 9.49333012e-02f, 3.21615219e-01f, -4.00299370e-01f, 2.96381470e-02f, -2.03568295e-01f, -2.29505152e-02f,
  1.07095176e-02f, 2.44811535e-01f, 7.82144591e-02f, 7.33256266e-02f, 6.06286153e-02f, -1.01022065e-01f, -7.96207637e-02f, -5.32514863e-02f, 1.25551373e-01f, -6.72218390e-03f,
  3.78583260e-02f, -9.17397588e-02f, 2.31299754e-02f, -6.76431730e-02f, 2.45713964e-01f, 1.13316551e-01f, 7.85815343e-02f, 2.45599002e-02f, 1.67651042e-01f, 3.40109952e-02f,
  7.88659453e-02f, 5.70156276e-02f, 9.14557874e-02f, -1.01272967e-02f, 1.05176359e-01f, 1.67764276e-01f, -3.36590363e-03f, -4.78000045e-02f, -9.78111941e-03f, 1.28319964e-01f,
  8.90719332e-03f, -9.85026881e-02f, -5.74209122e-03f, -4.91300859e-02f, -4.17201482e-02f, 7.17726871e-02f, 5.86984232e-02f, -1.46215903e-02f, 1.63991138e-01f, 4.16864501e-03f,
  1.50306392e-02f, 1.51977226e-01f, 2.60575656e-02f, 6.21323250e-02f, 5.85092977e-02f, 4.65769209e-02f, -1.10115431e-01f, -2.89749317e-02f, 8.59295949e-02f, 4.61891331e-02f,
  -1.26638308e-01f, -2.04221401e-02f, 1.11880183e-01f, -4.32030372e-02f, 3.78662907e-02f, 2.57560448e-03f, -1.14777341e-01f, -5.43567128e-02f, -9.74103436e-02f, 1.93847883e-02f,
  8.33048970e-02f, 3.42808694e-01f, 9.35872272e-02f, 8.24367478e-02f, 1.38125848e-02f, -1.70114953e-02f, -4.02442329e-02f, 9.97645855e-02f, 1.91927463e-01f, 2.04472877e-02f,
  6.63520861e-03f, 4.07971293e-02f, -1.08279526e-01f, -1.36531845e-01f, 1.78252459e-02f, -1.03274822e-01f, -2.31134240e-02f, 1.98602676e-02f, 1.13896668e-01f, -2.96377987e-02f,
  -4.79318574e-02f, -6.82045966e-02f, -4.13304046e-02f, 9.95035693e-02f, 6.58599287e-02f, 5.30517027e-02f, -5.01694381e-02f, 8.48796591e-02f, -1.19669937e-01f, 3.68675627e-02f,
  5.81661761e-01f, -3.35562043e-04f, 9.03865919e-02f, 3.95161122e-01f, 1.68684766e-01f, 3.92427504e-01f, 2.90417314e-01f, 9.77080166e-02f, 5.12884021e-01f, -3.05205043e-02f,
  4.92681637e-02f, 1.98969066e-01f, -2.80910194e-01f, 1.53133065e-01f, -6.82365596e-02f, -2.20106766e-01f, 2.34406605e-01f, 2.98319995e-01f, 4.29623276e-02f, 2.87169874e-01f,
  2.36879498e-01f, 7.61332959e-02f, -4.12297547e-01f, -2.98489213e-01f, 2.02147946e-01f, -1.81249097e-01f, -4.07168567e-01f, -2.24273756e-01f, -3.24314415e-01f, -2.24891499e-01f,
  3.42172273e-02f, 1.92440487e-02f, -1.44002996e-02f, -2.75277626e-02f, 4.78602499e-02f, -1.27996458e-03f, -8.43237787e-02f, -2.04959869e-01f, -9.95642841e-02f, -2.44161095e-02f,
  1.62467450e-01f, -7.94613175e-03f, 1.47382751e-01f, 2.09762845e-02f, 1.88891172e-01f, -4.29495573e-02f, 8.69656503e-02f, 7.14368820e-02f, -2.44513795e-01f, 9.02480334e-02f,
  1.47205219e-01f, 5.84534407e-02f, 1.85725152e-01f, -8.55461732e-02f, -7.94645548e-02f, -8.04310217e-02f, 9.70837101e-03f, -5.44652529e-02f, 8.20469260e-02f, 6.15291856e-03f,
  -3.12360860e-02f, 5.80868199e-02f, -4.34523188e-02f, -4.63175252e-02f, 7.15909824e-02f, -1.08683996e-01f, 3.41094211e-02f, -1.14713553e-02f, 8.74859244e-02f, 1.23799033e-02f,
  8.27680379e-02f, -1.17018102e-02f, 5.74336313e-02f, 1.99408215e-02f, 1.47974426e-02f, 9.16154087e-02f, 2.26268023e-02f, -5.24423905e-02f, 3.52225564e-02f, -1.39035275e-02f,
  -8.34355038e-03f, -6.80936575e-02f, -6.10306673e-02f, -2.68796980e-02f, 8.85760691e-03f, -6.91938996e-02f, -2.49052290e-02f, 2.70032361e-02f, 9.07300487e-02f, 1.51941821e-01f,
  1.21421710e-01f, 8.02149549e-02f, -7.63668120e-02f, -4.56535034e-02f, 4.97370474e-02f, 5.25160655e-02f, -1.65421199e-02f, 3.73432487e-02f, -1.22583406e-02f, -2.48164125e-03f,
  9.80086252e-03f, 1.29571900e-01f, 1.02788232e-01f, -6.16206452e-02f, -9.10189934e-03f, -1.01918697e-01f, 9.68078077e-02f, -1.26314051e-02f, -1.38237491e-01f, 9.41488519e-02f,
  1.70024917e-01f, 5.60654476e-02f, 9.42703858e-02f, 7.49160424e-02f, 4.90038916e-02f, -1.31272495e-01f, 1.22943431e-01f, -1.71472266e-01f, 1.64851248e-01f, -1.09488599e-01f,
  -3.16552699e-01f, 1.62695184e-01f, 4.05165404e-01f, -6.55815423e-01f, 1.92327008e-01f, 4.41310406e-01f, -2.48037100e-01f, 9.07948762e-02f, -3.37765247e-01f, -1.62492678e-01f,
  1.12580182e-02f, -2.74441600e-01f, 2.28996083e-01f, -4.80213016e-01f, -1.45593667e-02f, -2.74587460e-02f, -3.80576760e-01f, -5.00985444e-01f, -1.85720593e-01f, -1.79657459e-01f,
  -1.74287722e-01f, -4.16824639e-01f, 5.44893146e-02f, 8.34086910e-02f, -1.24264039e-01f, -1.45554170e-02f, -1.44253090e-01f, 3.41550767e-01f, -1.60112247e-01f, 1.11046217e-01f,
  6.06734417e-02f, -2.04148456e-01f, 1.57671675e-01f, 2.44057383e-02f, 1.23794533e-01f, 3.05744875e-02f, -4.73669842e-02f, 6.04201220e-02f, -2.01154277e-02f, -9.89393890e-02f,
  -8.92041624e-02f, 3.13074850e-02f, -9.71975029e-02f, 1.59539527e-03f, -1.36908516e-01f, 1.27669787e-02f, 7.18144476e-02f, 1.71978846e-01f, -3.68301012e-02f, 9.04560089e-02f,
  -3.98730636e-02f, 7.44804442e-02f, -7.17621818e-02f, -4.06441018e-02f, -6.11891225e-02f, 1.64339226e-02f, -5.41068390e-02f, -4.50070910e-02f, -2.03740466e-02f, -6.43625250e-03f,
  -1.26978636e-01f, -5.99892251e-02f, 6.45522550e-02f, 5.70661277e-02f, 2.36769561e-02f, 6.67640865e-02f, -8.93165469e-02f, -2.47554742e-02f, 3.73786092e-02f, 1.15221776e-01f,
  1.59516800e-02f, -5.15420921e-03f, -1.04232021e-01f, -1.47593349e-01f, -6.28289357e-02f, -7.01238438e-02f, 5.37919365e-02f, -2.27566622e-03f, -7.64392689e-02f, 9.16178077e-02f,
  -8.10773969e-02f, -3.35684828e-02f, -3.56568885e-03f, -7.07793459e-02f, 6.56327307e-02f, 1.51216257e-02f, -1.05749913e-01f, 2.09267855e-01f, 1.52758300e-01f, -6.25616387e-02f,
  6.75009862e-02f, -8.11967701e-02f, 1.54149741e-01f, -2.09104549e-03f, 6.61655143e-02f, 1.45805463e-01f, -3.46864536e-02f, 2.55836956e-02f, -3.67400646e-02f, -5.27411625e-02f,
  -5.06987944e-02f, 2.16888841e-02f, 9.15146917e-02f, -1.69437155e-02f, -9.12084430e-03f, 1.37419790e-01f, -8.63757804e-02f, 4.62587290e-02f, 1.28631210e-02f, 2.13206541e-02f,
  -2.48046033e-02f, -8.54822770e-02f, -4.40671034e-02f, -1.27760842e-01f, -2.41409421e-01f, 5.07766195e-02f, 3.86539884e-02f, -1.04354836e-01f, -1.73068374e-01f, -9.95772481e-02f,
  1.64499670e-01f, 5.01166768e-02f, -2.58464813e-01f, 1.98729172e-01f, 5.62470965e-02f, 2.42794141e-01f, -1.91135462e-02f, -4.66291383e-02f, -2.66895235e-01f, -1.62631512e-01f,
  1.79358304e-01f, 1.12346575e-01f, -3.01189750e-01f, 4.22488093e-01f, 5.83131552e-01f, -1.87170319e-02f, 3.27595383e-01f, 2.26939499e-01f, -9.29301828e-02f, 2.03199521e-01f,
  1.10884763e-01f, 5.27229548e-01f, 2.11736649e-01f, 3.66593182e-01f, 3.22364420e-01f, 2.51454003e-02f, 2.46423438e-01f, -3.89745459e-02f, 3.23998481e-01f, 3.04672897e-01f,
  -4.29262361e-03f, 3.44282240e-02f, -1.05360396e-01f, -6.22360148e-02f, 3.05713732e-02f, -1.25593925e-02f, 8.29854459e-02f, 8.42586979e-02f, 1.32874940e-02f, -3.25533748e-02f,
  3.04913372e-02f, 1.81798220e-01f, 1.97425708e-01f, 4.46577035e-02f, -5.21664359e-02f, 5.00494838e-02f, -6.35621920e-02f, -1.48118213e-01f, -1.10441595e-01f, -5.67828529e-02f,
  -1.10337086e-01f, -5.85862584e-02f, -4.55101207e-02f, 1.22946106e-01f, -2.39279084e-02f, -8.58839974e-02f, -1.40397530e-02f, -3.68474349e-02f, 1.07272454e-01f, 5.97185269e-02f,
  2.01755241e-01f, -1.42984927e-01f, -6.84912726e-02f, -3.25732753e-02f, 1.02437176e-01f, -6.08039275e-02f, -1.30995940e-02f, 2.40437891e-02f, -6.69400319e-02f, -3.52119543e-02f,
  -2.30284054e-02f, 1.71377920e-02f, -4.38580550e-02f, -8.87011439e-02f, 3.40222605e-02f, -1.10632643e-01f, 4.22726735e-04f, 7.52656385e-02f, -1.39078662e-01f, -1.43645868e-01f,
  -6.34660572e-02f, 5.18639050e-02f, -1.31339170e-02f, -7.47582540e-02f, 3.93144935e-02f, -5.44621013e-02f, 6.20251223e-02f, -5.20254225e-02f, -6.74275160e-02f, 1.06679392e-03f,
  1.04562119e-01f, 2.68475920e-01f, -7.08831474e-02f, -4.66330238e-02f, -1.13924090e-02f, 1.70198247e-01f, 6.99217096e-02f, 1.42914683e-01f, 1.67265028e-01f, 1.29565701e-01f,
  8.94193575e-02f, -1.10797755e-01f, -7.17723221e-02f, 8.04860890e-02f, 9.36091095e-02f, -7.11056292e-02f, 6.79207081e-03f, 6.27561882e-02f, 1.12797476e-01f, 1.60854772e-01f,
  4.64798436e-02f, 5.83821908e-02f, 3.12223639e-02f, -2.39435285e-02f, 9.81254354e-02f, -4.97623011e-02f, 9.11090821e-02f, -1.19223543e-01f, 3.92870903e-02f, 3.11186397e-03f,
  -5.78702092e-01f, -2.90227264e-01f, 5.10651827e-01f, -5.66361129e-01f, 2.09908575e-01f, 4.94512796e-01f, 8.33502114e-02f, -2.01345116e-01f, -3.86984318e-01f, -3.08659583e-01f,
  -2.01527342e-01f, -1.01526223e-01f, 2.10667193e-01f, -1.53895453e-01f, 4.57806915e-01f, 2.96216846e-01f, -1.39779821e-01f, -1.77960694e-01f, 1.58392146e-01f, -1.29543275e-01f,
  8.62099603e-02f, -1.71857372e-01f, 3.23255926e-01f, 3.56543250e-02f, 1.81471147e-02f, -1.70986027e-01f, -8.28543305e-02f, 2.53912330e-01f, -1.44084930e-01f, 1.42375439e-01f,
  -1.11628473e-01f, -3.15605342e-01f, 5.88938110e-02f, 2.04977561e-02f, 2.69559901e-02f, -8.09114650e-02f, 1.75747603e-01f, 1.23658016e-01f, -8.83459970e-02f, 3.81319486e-02f,
  -8.99177603e-03f, 1.05770007e-01f, -1.03428930e-01f, -2.39781737e-02f, -1.30491570e-01f, -3.83556634e-02f, 8.01499039e-02f, 4.63063717e-02f, 3.31160277e-02f, 2.26818323e-01f,
  1.07345618e-01f, 1.24998510e-01f, 8.09046701e-02f, -2.19597891e-02f, 1.38404816e-01f, -8.44915658e-02f, 4.30716947e-02f, 7.95312226e-02f, -8.20712559e-03f, -7.51160085e-02f,
  2.24748868e-02f, 2.66720429e-02f, -1.01198917e-02f, -1.30660743e-01f, -1.10610478e-01f, -1.34368062e-01f, -4.03223820e-02f, 3.21313180e-03f, -5.10440813e-03f, -6.75692782e-02f,
  1.91381667e-02f, -9.31598917e-02f, -1.77492145e-02f, 7.95679458e-04f, -6.35446087e-02f, -7.24564344e-02f, 6.66052550e-02f, -2.02660523e-02f, -6.40556291e-02f, 4.18199971e-02f,
  -3.19618322e-02f, 2.10170839e-02f, -2.26660981e-03f, 5.06907217e-02f, 2.06261892e-02f, 1.17028624e-01f, -9.44887027e-02f, -1.68450847e-02f, -1.95284188e-03f, 1.93272382e-01f,
  -2.92654574e-01f, -4.83925819e-01f, -7.07450286e-02f, 1.11421989e-02f, -7.57266507e-02f, 8.33676308e-02f, 6.44323155e-02f, -1.08029142e-01f, -1.44838775e-02f, -6.29184172e-02f,
  -8.98075029e-02f, -5.15827276e-02f, -7.28609338e-02f, 5.71493134e-02f, 3.60939950e-02f, -6.82868110e-03f, -4.45932485e-02f, -9.33728367e-02f, -9.14131403e-02f, -1.16573110e-01f,
  -1.39178619e-01f, -1.24000221e-01f, 9.76438746e-02f, -2.91263051e-02f, -5.33062406e-02f, -7.34473765e-02f, -4.54185419e-02f, 1.93497706e-02f, 1.13106191e-01f, -9.14846733e-03f,
  -3.60780805e-01f, 2.50673980e-01f, 2.69546598e-01f, 3.23850751e-01f, -1.61373720e-01f, 4.13863808e-01f, 3.86627316e-01f, 1.21407084e-01f, 4.53271925e-01f, 1.12369336e-01f,
  -6.41805260e-03f, -3.64732146e-01f, 1.31551614e-02f, 3.86306316e-01f, -2.05800176e-01f, 4.15973663e-01f, 2.86824524e-01f, 1.81113943e-01f, 1.25733301e-01f, -1.14779614e-01f,
  -3.88258742e-03f, -1.52964011e-01f, -1.20836161e-01f, -3.30937296e-01f, -1.30047843e-01f, -3.92650701e-02f, -3.78948927e-01f, -1.35852098e-01f, -1.28088281e-01f, -1.45180255e-01f,
  -2.65516549e-01f, -9.54383984e-02f, -1.73283562e-01f, -1.43833905e-01f, -2.86138300e-02f, 1.08784146e-03f, -8.03474933e-02f, -1.07314087e-01f, -8.94402489e-02f, 1.99988279e-02f,
  -5.46002500e-02f, -9.17717144e-02f, -7.24300742e-02f, -7.84835368e-02f, -3.03928759e-02f, -3.19709592e-02f, 1.07471824e-01f, 1.01231880e-01f, -5.00030182e-02f, 5.83988279e-02f,
  4.52495879e-03f, 4.97997850e-02f, 1.54181421e-01f, 4.50221486e-02f, -1.03096724e-01f, -3.06387339e-02f, 1.67757720e-01f, 2.24607587e-02f, -1.03134297e-01f, 4.67296727e-02f,
  4.04650979e-02f, 1.95239186e-02f, 3.68636698e-02f, -1.05801918e-01f, -8.07631090e-02f, 1.24948239e-02f, 1.74610894e-02f, -1.22726075e-02f, -4.04505013e-03f, 1.23249588e-03f,
  -8.52744505e-02f, -6.61612079e-02f, 5.97527809e-02f, 6.71169907e-03f, 3.00367028e-02f, 1.03333145e-01f, -9.48249698e-02f, 7.88924284e-03f, 1.51096150e-01f, -5.90273477e-02f,
  4.40819450e-02f, 1.02951489e-01f, -6.24157675e-02f, -1.22231850e-02f, -6.78238571e-02f, -6.23192973e-02f, 6.92889020e-02f, 2.83326030e-01f, 5.83645999e-02f, -5.69761768e-02f,
  -1.31005213e-01f, -1.19947404e-01f, -7.74703845e-02f, -4.35943604e-02f, -5.56041226e-02f, -2.01765597e-02f, 8.24067043e-04f, -3.15604992e-02f, -1.07860100e-02f, 1.69026814e-02f,
  -1.29614333e-02f, 8.74527991e-02f, -1.25695869e-01f, 1.40184036e-03f, -2.35792454e-02f, -4.73994538e-02f, -1.46634772e-01f, -2.97053847e-02f, -1.38075665e-01f, -1.03134684e-01f,
  -1.63397834e-01f, -9.34022944e-03f, 6.16536662e-02f, -1.96727924e-02f, -2.13798098e-02f, -1.47447094e-01f, -1.06918424e-01f, -3.49405147e-02f, -7.04973787e-02f, 6.71033859e-02f,
  6.71318769e-01f, -5.32692373e-01f, 6.55939728e-02f, 2.56675422e-01f, 3.23383182e-01f, 2.21559212e-01f, 3.43533367e-01f, -2.43522637e-02f, -6.82785809e-02f, -3.89230371e-01f,
  -1.85536537e-02f, 9.47210044e-02f, -2.04775885e-01f, 2.32140973e-01f, 4.48261231e-01f, -2.88101226e-01f, 1.84176460e-01f, 7.19912350e-02f, -6.60475045e-02f, 6.25123307e-02f,
  1.73648655e-01f, 6.15751781e-02f, 9.03237537e-02f, -2.89555669e-01f, 1.96767360e-01f, 6.90835714e-02f, -8.29013437e-02f, -1.06079943e-01f, 7.59304091e-02f, 2.06309199e-01f,
  1.48783565e-01f, -5.39300181e-02f, 5.43056335e-03f, -7.41658807e-02f, -7.78838247e-02f, -3.21079269e-02f, -9.17655602e-03f, -1.45342480e-03f, 2.09417269e-01f, -6.06405875e-03f,
  -5.29260561e-02f, -4.20620106e-02f, -4.41509970e-02f, 2.03885399e-02f, 1.67094395e-01f, 1.04358815e-01f, 8.27165917e-02f, 5.29622175e-02f, -2.58457884e-02f, -4.83768731e-02f,
  3.91655043e-02f, -4.07996215e-02f, 4.70429100e-02f, -3.79374586e-02f, 2.06757430e-02f, 1.28561743e-02f, -3.49463038e-02f, -5.04215136e-02f, 1.27997203e-02f, 4.70669717e-02f,
  -1.10305734e-01f, -8.30509067e-02f, 4.68481593e-02f, 1.46791428e-01f, 7.26255924e-02f, 2.39361841e-02f, 4.82127443e-02f, -6.69016540e-02f, 2.95580998e-02f, -2.22186763e-02f,
  6.55704513e-02f, 3.51447761e-02f, 6.46402389e-02f, -1.29277380e-02f, 4.20335587e-03f, 8.48078877e-02f, 6.86730444e-02f, -8.40692371e-02f, -3.65315191e-02f, 7.47195110e-02f,
  1.51806483e-02f, 2.43149884e-02f, 5.38148917e-02f, 4.83608358e-02f, -4.01150212e-02f, -4.81271781e-02f, -6.38279840e-02f, 3.81055549e-02f, -8.33001658e-02f, 7.70429969e-02f,
  -9.81672779e-02f, -5.66782176e-01f, -5.46783619e-02f, -1.91275729e-03f, -7.82727450e-02f, 4.08525132e-02f, -1.36668295e-01f, 2.82579716e-02f, -2.22325362e-02f, -5.83215840e-02f,
  -1.22038729e-01f, 7.34423324e-02f, -1.06627699e-02f, 7.09537864e-02f, -5.17040379e-02f, -2.52325647e-02f, -3.87628190e-02f, -1.05406880e-01f, -9.69884358e-03f, -6.42328784e-02f,
  -4.81333286e-02f, -1.23981290e-01f, 7.06985891e-02f, 6.78483723e-03f, -7.78776258e-02f, -5.05317599e-02f, -1.06359422e-01f, 8.99323747e-02f, -4.14258763e-02f, -4.45761308e-02f,
  -1.81950048e-01f, -1.34255484e-01f, -4.86617148e-01f, -1.01141976e-02f, 1.23887666e-01f, 3.69335204e-01f, -3.17380399e-01f, -1.44142583e-01f, -2.47520030e-01f, 2.51627807e-02f,
  1.81610566e-02f, 2.62176424e-01f, -6.09107673e-01f, 5.55900753e-01f, 1.00721322e-01f, -3.25372696e-01f, 3.70457351e-01f, 4.04386103e-01f, 1.85206160e-02f, -1.70148864e-01f,
  -1.64333154e-02f, 4.68241096e-01f, -1.51684061e-01f, 2.22767964e-01f, 1.68800995e-01f, 1.34066164e-01f, 6.21178895e-02f, -1.24173120e-01f, 5.82894444e-01f, 3.57533813e-01f,
  1.72912478e-01f, -1.16014853e-01f, -1.75657645e-01f, 9.57167000e-02f, -9.25148204e-02f, 3.65875550e-02f, 1.05327405e-02f, 7.16461539e-02f, -5.66199124e-02f, 1.37757268e-02f,
  1.69695150e-02f, 1.38804868e-01f, 1.81274265e-01f, -1.92262966e-03f, 9.04038846e-02f, 8.86429772e-02f, -4.06863950e-02f, -5.99972047e-02f, -6.20960668e-02f, -9.02012885e-02f,
  -1.60618901e-01f, -2.42116954e-02f, 2.01442931e-03f, 6.41625300e-02f, -1.01721391e-01f, -8.57784152e-02f, 1.55687898e-01f, -2.78720949e-02f, 1.54655963e-01f, 7.69595876e-02f,
  4.76370426e-03f, 4.31291424e-02f, -3.96103412e-02f, -5.14844107e-03f, -7.62300491e-02f, -4.34982181e-02f, 1.09926976e-01f, 1.62750125e-01f, -3.45339626e-02f, -3.18885706e-02f,
  -9.03970283e-03f, 8.14477913e-03f, 1.02195382e-01f, -4.00526263e-02f, 8.60965773e-02f, 9.68407094e-03f, -3.71139497e-02f, -3.81360725e-02f, -6.97376132e-02f, 9.23440680e-02f,
  -5.35830744e-02f, 8.93953890e-02f, -8.98419470e-02f, 3.55633125e-02f, 1.78442627e-01f, -1.42436445e-01f, 1.48656711e-01f, -1.32446289e-01f, -2.31575314e-02f, 6.19583065e-03f,
  2.89038252e-02f, -3.06692451e-01f, -8.48459154e-02f, 1.61551073e-01f, -7.24110380e-02f, 3.09881400e-02f, 7.62103647e-02f, 1.07866816e-01f, 3.84153016e-02f, -3.36480439e-02f,
  -5.62638156e-02f, -1.84399094e-02f, 2.37430111e-02f, 1.61146164e-01f, 1.96278185e-01f, -2.25014284e-01f, -1.16484739e-01f, 1.58642847e-02f, -1.31812587e-03f, 3.11761796e-02f,
  -1.13896117e-01f, -3.95148918e-02f, 8.60791430e-02f, -1.12425566e-01f, 6.53559715e-02f, 1.39196357e-02f, 5.08969910e-02f, 4.72924262e-02f, -3.43863443e-02f, 1.21763758e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  3.98261577e-01f, 3.10222805e-01f, 3.02946895e-01f, 3.28927547e-01f, 3.94758463e-01f, 2.52102315e-01f, 1.80553943e-01f, 4.63518709e-01f, 5.17831206e-01f, 4.31834310e-01f,
  6.10795617e-01f, 3.71199876e-01f, 4.07838404e-01f, 5.40205598e-01f, 4.01994109e-01f, 5.32623827e-01f, 4.06556636e-01f, 6.81608260e-01f, 3.52650195e-01f, 3.47145915e-01f,
  5.20727098e-01f, 6.23188734e-01f, 5.16656101e-01f, 1.94783732e-01f, 2.26507574e-01f, 5.77769458e-01f, 4.65231091e-01f, 3.86514544e-01f, 4.38907921e-01f, 4.38235521e-01f,
  3.94335598e-01f, 5.15906453e-01f, 5.79102397e-01f, 3.13612580e-01f, 4.25975561e-01f, 2.37983391e-01f, 6.27809584e-01f, 5.15070617e-01f, 5.28838038e-01f, 3.36057544e-01f,
  3.44414175e-01f, 2.54221052e-01f, 4.39704001e-01f, 4.69024032e-01f, 5.45549929e-01f, 4.64161038e-01f, 4.53822166e-01f, 3.61231267e-01f, 3.27785641e-01f, 2.63581544e-01f,
  3.71013910e-01f, 2.09667236e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -4.39938121e-02f, -2.06883937e-01f, -3.66287798e-01f, -1.13203704e-01f, -1.63521007e-01f, 3.63106690e-02f, 1.25368178e-01f, -3.06117564e-01f, 2.89323300e-01f, 3.21496129e-01f,
  -2.13595614e-01f, -8.22556484e-03f, 1.22295223e-01f, 4.34762597e-01f, -5.61153054e-01f, 3.74375224e-01f, -6.40627682e-01f, -4.06467706e-01f, 5.23230672e-01f, 2.39564896e-01f,
  -3.58144522e-01f, -3.88132006e-01f, -4.98949319e-01f, -3.61509770e-01f, -5.02291210e-02f, -3.96742642e-01f, -2.55394280e-01f, -4.38363016e-01f, 1.17041074e-01f, -1.61615893e-01f,
  -1.63530409e-01f, 9.33564752e-02f, -2.26599172e-01f, -2.84424603e-01f, -5.81319571e-01f, 5.04850686e-01f, 4.48603868e-01f, -4.00548667e-01f, -3.09434533e-01f, 2.38138020e-01f,
  3.47168893e-01f, 2.61963964e-01f, -5.31863272e-01f, -2.52310872e-01f, -5.21157563e-01f, 1.41385496e-01f, 3.34059536e-01f, 4.18062329e-01f, -5.38724124e-01f, 3.03263992e-01f,
  -6.25760496e-01f, -4.53031331e-01f, -1.81997508e-01f, 3.38069946e-01f, 4.30623353e-01f, -2.49227807e-01f, -4.40378368e-01f, -3.77827734e-01f, -4.70872581e-01f, -2.48580500e-01f,
  -2.21771657e-01f, 4.01753217e-01f, -4.62615430e-01f, -2.03600153e-02f, 3.17432314e-01f, -1.45270020e-01f, -2.10570335e-01f, -1.25991449e-01f, 5.33453859e-02f, -2.99361050e-02f,
  5.30206934e-02f, 4.09979820e-01f, 2.11596668e-01f, -4.83425081e-01f, -3.27517927e-01f, -2.34029189e-01f, -7.82134950e-01f, 3.92526835e-01f, 2.09774226e-01f, -5.41887939e-01f,
  3.49626362e-01f, 7.71110207e-02f, -3.04066837e-01f, -7.15262115e-01f, -5.55997610e-01f, 3.62502187e-01f, -4.01927888e-01f, 1.52272016e-01f, 2.89416283e-01f, -3.90252918e-01f,
  2.44335998e-02f, 2.17535898e-01f, -8.45234215e-01f, -6.30889311e-02f, -1.55582756e-01f, 5.11115670e-01f, -2.07147658e-01f, 3.06223601e-01f, -2.65733093e-01f, 3.68320972e-01f,
  3.89625430e-01f, -4.21863049e-01f, 4.00973946e-01f, 2.91755378e-01f, -3.30428518e-02f, 4.86368179e-01f, -2.45510079e-02f, -6.15903258e-01f, -4.03168201e-02f, -7.52959907e-01f,
  -2.81844974e-01f, -6.06700778e-01f, -4.51692730e-01f, 2.66009659e-01f, 7.43672103e-02f, 2.65001178e-01f, -3.13178569e-01f, -8.03270814e-05f, -6.56352758e-01f, -5.09526014e-01f,
  -3.85947645e-01f, 1.89862669e-01f, -4.20691192e-01f, 4.18156981e-01f, -4.84646201e-01f, -2.61363477e-01f, -5.88405952e-02f, 1.92247078e-01f, -3.04423217e-02f, -9.68698785e-02f,
  2.21444368e-02f, -1.39465079e-01f, -1.19613662e-01f, -1.54634282e-01f, -1.88720211e-01f, 1.88603997e-01f, 7.67586902e-02f, -2.69120961e-01f, 8.28085542e-02f, 1.65152073e-01f,
  -3.72171924e-02f, -7.10285187e-01f, -2.92451054e-01f, -2.27507949e-01f, -3.90609682e-01f, 3.83707017e-01f, -1.22943990e-01f, -3.13873023e-01f, -4.29398000e-01f, -1.12112902e-01f,
  1.55924886e-01f, 3.97214383e-01f, -1.52920678e-01f, 4.19325262e-01f, -2.90859163e-01f, 5.25684357e-02f, 4.05793250e-01f, -5.68806589e-01f, -3.49419713e-01f, -4.56499606e-01f,
  -1.44296765e-01f, -9.66726542e-02f, -2.15077221e-01f, -4.27500755e-01f, 2.17873469e-01f, -4.59475994e-01f, 3.03021967e-01f, 3.83955568e-01f, -4.51220684e-02f, -4.46858138e-01f,
  3.88887227e-01f, -4.39761251e-01f, -3.91390264e-01f, -1.44461572e-01f, -9.69693512e-02f, -1.86020017e-01f, -3.95302296e-01f, -5.03858209e-01f, -2.47065485e-01f, -3.21940094e-01f,
  6.11495897e-02f, -5.55748008e-02f, -2.22678348e-01f, -1.05961300e-01f, -4.05077666e-01f, -2.22105101e-01f, -3.36064100e-01f, 4.51252788e-01f, -5.13763316e-02f, -4.13817465e-01f,
  3.98020744e-01f, 6.74596786e-01f, 3.08202151e-02f, 9.12634656e-03f, -3.04363817e-01f, -1.91444695e-01f, -3.27993125e-01f, 1.68628633e-01f, -4.27098632e-01f, -4.26164895e-01f,
  -3.18460017e-01f, 2.00639233e-01f, -4.08798039e-01f, -5.19097984e-01f, -3.47649783e-01f, -3.31926405e-01f, -3.79093289e-01f, 4.29613411e-01f, -1.47403032e-01f, -1.89155310e-01f,
  -1.10076696e-01f, -3.96898210e-01f, 4.24721539e-01f, -2.74733305e-01f, -2.59739310e-01f, -3.69151801e-01f, -2.92150706e-01f, 1.14735119e-01f, -3.32820863e-01f, -3.22615176e-01f,
  -2.51435935e-01f, 1.67486206e-01f, -1.89320758e-01f, 3.70738097e-02f, -1.95482790e-01f, -8.91717732e-01f, 1.89789623e-01f, 7.38439932e-02f, -1.37073591e-01f, -7.18419790e-01f,
  -3.54985625e-01f, -4.72161263e-01f, -3.51632088e-01f, -2.92753011e-01f, -1.63553804e-01f, -1.55969307e-01f, 3.45032103e-02f, 4.67752874e-01f, -5.63666761e-01f, 7.94973224e-02f,
  -5.26876450e-01f, 5.67458212e-01f, 4.99639809e-01f, 3.12742203e-01f, -6.01027906e-01f, -3.39325428e-01f, 4.66567218e-01f, 4.98107493e-01f, 1.02577299e-01f, -6.71501100e-01f,
  9.40115824e-02f, -1.57540351e-01f, -2.27163300e-01f, -4.44281399e-01f, -2.52412617e-01f, -1.78228438e-01f, 4.21551317e-02f, -2.58110315e-01f, 4.68471140e-01f, -1.18337736e-01f,
  3.40386987e-01f, 1.19753525e-01f, 5.28200924e-01f, -4.64444548e-01f, -3.16910982e-01f, 4.52837884e-01f, -1.47684321e-01f, 1.71648458e-01f, -7.53572524e-01f, -2.63570428e-01f,
  2.98467487e-01f, -2.87264466e-01f, -8.39245990e-02f, -4.26848799e-01f, -4.47884612e-02f, -2.65871078e-01f, -1.94425195e-01f, 2.61989206e-01f, 8.65471959e-02f, -2.08909407e-01f,
  -5.05265236e-01f, -6.57296553e-02f, 1.03710908e-02f, -4.74851370e-01f, 7.14222342e-02f, -3.06507736e-01f, -3.80190015e-01f, 1.41702339e-01f, 1.12443499e-01f, 1.74054638e-01f,
  2.15972617e-01f, 3.65542948e-01f, 5.57932332e-02f, 4.86053973e-01f, -3.72188658e-01f, 5.30910790e-01f, 8.71458873e-02f, -7.06241429e-01f, -2.97056943e-01f, 4.49982107e-01f,
  -8.44208077e-02f, -2.23219410e-01f, -1.14904352e-01f, -3.25107860e-04f, 3.54652733e-01f, -2.14856174e-02f, 6.96754679e-02f, -5.81174135e-01f, -3.78197193e-01f, -3.05718482e-01f,
  4.11795437e-01f, 2.09287569e-01f, -2.23620415e-01f, -5.97637177e-01f, 6.30567908e-01f, 2.61430927e-02f, 5.85010111e-01f, 2.07694009e-01f, -5.23027420e-01f, -9.39558819e-02f,
  -3.61112356e-02f, 4.59964722e-02f, 2.26430252e-01f, 4.13470082e-02f, 2.45476007e-01f, 1.14278153e-01f, 4.81901139e-01f, 9.03858691e-02f, 4.62068230e-01f, -2.74374396e-01f,
  -3.42306681e-02f, 1.26784425e-02f, -4.52889316e-02f, 1.65664732e-01f, 4.54506800e-02f, -2.44690120e-01f, 5.55508018e-01f, -4.60486829e-01f, 1.62313461e-01f, 2.47575119e-01f,
  -4.01287585e-01f, -3.64402801e-01f, 1.66761503e-01f, -8.03927243e-01f, 2.14108139e-01f, -2.22964928e-01f, -4.40715909e-01f, -5.27122505e-02f, -3.89550626e-01f, -8.52778971e-01f,
  3.93662043e-02f, -3.64768326e-01f, 2.10394710e-01f, 9.77838486e-02f, -4.13311958e-01f, -8.27508569e-01f, -3.93759072e-01f, 1.59995884e-01f, -8.79107118e-02f, -1.06153525e-01f,
  -7.27811635e-01f, 4.00321513e-01f, -3.78828675e-01f, 6.40543640e-01f, 1.13940082e-01f, 3.79067250e-02f, 3.34215313e-01f, 2.55861342e-01f, 4.49008346e-01f, 1.51813895e-01f,
  -8.81566331e-02f, -1.40698895e-01f, -2.75756270e-01f, 5.70404708e-01f, -5.18488169e-01f, -6.26842603e-02f, 4.73388702e-01f, 2.76952654e-01f, -6.82760894e-01f, 9.98351257e-03f,
  -6.18682802e-01f, 3.32206935e-01f, -2.81365693e-01f, -1.95106909e-01f, -1.08355448e-01f, 1.52697414e-02f, -1.50209695e-01f, -1.99960964e-03f, 1.87603533e-02f, -7.65926763e-02f,
  1.26332179e-01f, 3.35773155e-02f, -1.52215987e-01f, -2.99108922e-01f, -4.08235081e-02f, -3.99898440e-01f, 5.58559448e-02f, -2.77405113e-01f, -2.40018710e-01f, -2.78727412e-01f,
  1.73914209e-01f, 4.66907918e-01f, -5.18040061e-01f, 3.99459988e-01f, -5.10119975e-01f, -4.23401475e-01f, -7.13652134e-01f, 4.26328778e-01f, -5.02105594e-01f, -9.52091813e-02f,
  -6.43957436e-01f, -1.82134453e-02f, -9.76134166e-02f, 6.46452367e-01f, -5.08780062e-01f, -1.56590745e-01f, -5.09788096e-01f, -2.19080597e-01f, -2.61421859e-01f, -5.96866757e-02f,
  -2.21662760e-01f, 2.92187870e-01f, 4.52139646e-01f, -6.35896146e-01f, -2.36539587e-01f, -1.57323241e-01f, 5.18672884e-01f, 1.04792111e-01f, 1.40384778e-01f, -1.98189244e-01f,
  -3.14791977e-01f, -5.76409817e-01f, 1.16658971e-01f, -7.40642965e-01f, -1.21316975e-02f, -1.93490475e-01f, 6.13856137e-01f, -5.23775935e-01f, -5.21890342e-01f, -4.33400758e-02f,
  3.48022521e-01f, 4.67190832e-01f, -2.62464851e-01f, -4.72649068e-01f, -2.70157337e-01f, 2.13817433e-01f, 3.96082908e-01f, -6.09497190e-01f, -2.50637710e-01f, -7.10297823e-02f,
  8.37218482e-03f, -1.63988769e-01f, -2.37648711e-01f, -2.39557996e-01f, -4.46972772e-02f, -1.13777414e-01f, -1.99882805e-01f, -1.57919422e-01f, 2.83621013e-01f, -1.17569111e-01f,
  4.25748855e-01f, -1.36012971e-01f, -2.43451253e-01f, -4.20903899e-02f, 1.13530971e-01f, -3.52949917e-01f, -3.18757206e-01f, 2.50433981e-01f, -5.03527761e-01f, 5.69260381e-02f,
  4.21081901e-01f, -4.39821959e-01f, -3.13815266e-01f, -3.53623390e-01f, 2.86174327e-01f, -1.97527826e-01f, -1.23717055e-01f, 2.31953412e-01f, -4.53466550e-02f, -3.93850535e-01f,
  -3.84015679e-01f, -1.74093246e-01f, 3.67871284e-01f, -2.26655394e-01f, -3.74657512e-02f, -2.57826179e-01f, -2.06364870e-01f, -3.57573360e-01f, -4.64725643e-01f, -4.00746584e-01f,
  1.23587213e-01f, -3.77722859e-01f, 3.11317801e-01f, 6.40979335e-02f, 3.41259420e-01f, 3.15481335e-01f, 5.27261868e-02f, -5.13760805e-01f, 3.99065942e-01f, 2.71536618e-01f,
  -1.53828621e-01f, 3.40203315e-01f, -4.59975928e-01f, 2.67358571e-01f, -3.97619069e-01f, -3.10885400e-01f, 5.96778803e-02f, -3.27443570e-01f, 7.86125660e-03f, -1.44557282e-01f,
  -3.83075535e-01f, 8.94974321e-02f, -1.57452643e-01f, -1.01804383e-01f, 1.31345645e-01f, -1.75414726e-01f, 6.61149472e-02f, -2.93748528e-01f, -2.26757601e-01f, -3.74051332e-01f,
  -1.82851017e-01f, -1.20190993e-01f, 2.39355981e-01f, 2.79039741e-01f, 7.49558955e-02f, 1.82911381e-01f, -5.38441576e-02f, -3.82076293e-01f, -7.37604499e-02f, -4.81659472e-01f,
  3.90564650e-01f, -2.59439915e-01f, 4.75242496e-01f, 2.36225799e-01f, 2.87595719e-01f, -2.48494774e-01f, -2.88953394e-01f, -3.41015846e-01f, -2.18541443e-01f, -4.50368255e-01f,
  3.39332253e-01f, 3.04238554e-02f, 4.34061229e-01f, -6.58499300e-01f, -4.72157359e-01f, -1.23048555e-02f, -2.78169841e-01f, 1.28208235e-01f, -2.63762236e-01f, -3.50169510e-01f,
  -3.90409201e-01f, -3.30519110e-01f, 4.13343132e-01f, 1.14929855e-01f, 3.93993169e-01f, -2.45726645e-01f, 3.02287847e-01f, -2.63609916e-01f, -1.22706011e-01f, -2.93759018e-01f,
  -3.18980575e-01f, -3.56933653e-01f, -2.62471259e-01f, -3.12922269e-01f, 3.20247263e-01f, -3.53598177e-01f, -2.38906965e-01f, -2.01943994e-01f, 1.82389349e-01f, -1.15220681e-01f,
  -2.63242692e-01f, 3.33930999e-01f, -3.02386940e-01f, -2.43754491e-01f, -1.56595856e-01f, -2.11291492e-01f, -5.70560470e-02f, 2.52945013e-02f, 1.77385673e-01f, -7.19470810e-03f,
  -1.46324098e-01f, 3.07805073e-02f, -8.79363641e-02f, 2.01678872e-01f, 2.50976682e-01f, 4.15445238e-01f, 4.79781151e-01f, 7.52678216e-02f, 5.19784927e-01f, -9.60381031e-02f,
  5.63430309e-01f, -2.39479631e-01f, -2.60100037e-01f, 2.81896859e-01f, -3.34791750e-01f, 2.26036459e-01f, -7.07669556e-02f, -4.46403742e-01f, 3.49030018e-01f, 1.72069967e-01f,
  3.84863704e-01f, -5.68208456e-01f, 6.71168029e-01f, 3.43157917e-01f, 3.84917498e-01f, 3.55617981e-03f, -2.95459658e-01f, 4.29867715e-01f, -3.35814416e-01f, -1.54159412e-01f,
  3.35191451e-02f, -2.82713145e-01f, -5.78653455e-01f, 2.45364070e-01f, -4.33857858e-01f, -5.97699344e-01f, -3.95551562e-01f, -2.44924366e-01f, -6.43202782e-01f, -4.77232486e-02f,
  -5.14824390e-01f, -3.30870122e-01f, -3.59565198e-01f, -1.56394258e-01f, 1.43109471e-01f, -1.29012972e-01f, -5.64274728e-01f, -3.13888073e-01f, -6.36701584e-01f, 1.44698709e-01f,
  -8.46936777e-02f, -3.84041965e-01f, -5.40712714e-01f, -9.33630839e-02f, 6.70450460e-03f, 3.31637636e-02f, 4.32594091e-01f, -3.84059727e-01f, 3.24250787e-01f, -4.26743835e-01f,
  -3.03096864e-02f, 1.72397330e-01f, 2.02739701e-01f, 2.87699431e-01f, 1.81520104e-01f, 4.00412530e-02f, -2.97070116e-01f, 4.45876002e-01f, -3.66140187e-01f, 1.44420311e-01f,
  -1.82706490e-01f, 5.56405842e-01f, -3.39459300e-01f, -3.67466509e-01f, -4.46925372e-01f, 5.31062424e-01f, -3.83948028e-01f, -2.39453405e-01f, -8.48125070e-02f, -3.31057340e-01f,
  1.02420580e-02f, 2.44351417e-01f, -1.05562128e-01f, -8.50182697e-02f, 5.98408515e-04f, 5.31884015e-01f, 5.39541900e-01f, 1.66952699e-01f, -3.39906365e-01f, -6.37050927e-01f,
  9.13204476e-02f, -1.57852501e-01f, 2.97891289e-01f, 1.88507348e-01f, 4.27786410e-01f, -4.76627558e-01f, -2.65444517e-01f, -3.83662105e-01f, 1.72919795e-01f, -3.81276071e-01f,
  1.41924113e-01f, -1.99258342e-01f, -6.56077504e-01f, -2.85934925e-01f, -5.06809950e-01f, 1.69160083e-01f, 2.07451865e-01f, -4.95197862e-01f, -2.32743546e-01f, -2.71672308e-01f,
  3.68333384e-02f, 4.33087498e-01f, 5.87973714e-01f, -3.70488226e-01f, -7.10611403e-01f, -6.65731966e-01f, -3.67468208e-01f, 1.63820773e-01f, 1.97703347e-01f, -3.50671381e-01f,
  -5.03697634e-01f, -3.09723824e-01f, -3.99141639e-01f, -7.12627470e-02f, 8.75192434e-02f, 1.40590698e-01f, -2.45456584e-02f, 2.21585140e-01f, -2.70392913e-02f, 1.09290734e-01f,
  -4.10648674e-01f, 8.75571892e-02f, 3.60178947e-01f, 3.35050113e-02f, 2.08456844e-01f, 1.47901163e-01f, -3.73055130e-01f, -3.63486588e-01f, -3.81629795e-01f, -3.50290596e-01f,
  -5.01247585e-01f, -2.23937720e-01f, -3.37842762e-01f, -3.00732911e-01f, 4.45215523e-01f, -3.99829715e-01f, -4.10786867e-01f, -3.03073734e-01f, -3.96641672e-01f, -4.88425821e-01f,
  -2.86711305e-01f, 5.01289725e-01f, -3.82089913e-01f, 5.29047787e-01f, 4.86643761e-01f, -2.39791930e-01f, 3.76016200e-01f, 4.52409804e-01f, -2.89944828e-01f, -3.61609995e-01f,
  -4.51484531e-01f, -2.93106019e-01f, -5.33904016e-01f, -2.64685333e-01f, -3.61072302e-01f, -4.54124600e-01f, -2.81817585e-01f, 2.32343420e-01f, 4.58784401e-01f, 1.84047922e-01f,
  1.37773961e-01f, -2.51527369e-01f, 1.08073622e-01f, -4.11775649e-01f, -4.98093367e-01f, -4.17052090e-01f, -3.34776402e-01f, -1.98606253e-01f, 3.98259193e-01f, 4.34089810e-01f,
  4.22008097e-01f, 2.64039308e-01f, -1.91625461e-01f, -2.43907675e-01f, -4.86869007e-01f, -5.48908636e-02f, 1.40532434e-01f, 1.99586466e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  2.22755782e-02f, 4.41946872e-02f, -9.36866924e-02f, -1.26610965e-01f, 1.17489539e-01f, 1.45057991e-01f, 7.67403543e-02f, -1.19601570e-01f, -1.57634109e-01f, -5.57320341e-02f,
  1.15123868e-01f, 1.30596668e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    