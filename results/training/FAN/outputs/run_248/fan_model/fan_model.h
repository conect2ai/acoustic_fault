/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.68524826e-01f, -1.87393457e-01f, 2.91707486e-01f, 2.14291692e-01f, -8.42919648e-02f, -1.23443305e-01f, -8.58933628e-02f, -7.13281333e-02f, 1.79428875e-01f, -2.98929691e-01f,
  -2.42173210e-01f, 1.61172122e-01f, -1.82557106e-01f, -1.21240519e-01f, 1.68610185e-01f, -6.98004887e-02f, -8.26675668e-02f, -5.14172576e-02f, 8.00261945e-02f, -1.43999100e-01f,
  5.11858426e-02f, -1.93729520e-01f, 1.27518982e-01f, -1.31252542e-01f, -2.13029981e-03f, 1.47457346e-01f, -1.64438188e-01f, -2.97412388e-02f, -6.94078729e-02f, 8.37739259e-02f,
  -1.28614411e-01f, -1.61323957e-02f, 5.32412641e-02f, 1.02807665e-02f, -6.61449507e-02f, 1.39632793e-02f, -6.65981919e-02f, 1.61202103e-02f, 3.62548083e-02f, 4.04207520e-02f,
  -6.04714733e-03f, -5.11071645e-03f, 1.99674945e-02f, 4.07453552e-02f, 2.02821381e-02f, 8.93111601e-02f, 8.02344829e-02f, -1.86768733e-03f, 5.97825535e-02f, 7.54657388e-02f,
  6.13472611e-02f, 3.72599326e-02f, 2.01202873e-02f, 1.56555884e-02f, 1.09058477e-01f, -2.50620302e-03f, 4.68128659e-02f, 2.07662079e-02f, 2.97321882e-02f, 7.22415419e-03f,
  4.35971618e-02f, -5.11786938e-02f, 3.88312042e-02f, 9.60116647e-03f, 1.62769412e-03f, 3.68505679e-02f, -3.62740122e-02f, -1.89227741e-02f, -1.79087580e-03f, -5.13748936e-02f,
  -1.16714025e-02f, 3.09562888e-02f, -1.19867306e-02f, 1.47317685e-02f, -1.72407106e-02f, 3.46536040e-02f, 2.82892957e-02f, -1.61479916e-02f, -2.02515461e-02f, 2.30216235e-02f,
  -1.12239365e-02f, -4.10962813e-02f, -5.21343574e-02f, -3.54380272e-02f, 2.75165569e-02f, 6.11220561e-02f, -2.97177397e-02f, 6.49254620e-02f, -1.30690308e-02f, -1.21625056e-02f,
  -3.51482570e-01f, -3.65418434e-01f, -3.51808853e-02f, 1.26750022e-02f, -2.40462627e-02f, -5.00050299e-02f, 2.41174232e-02f, 6.35742694e-02f, -3.15468647e-02f, -1.00261690e-02f,
  -4.94732112e-02f, 9.38784331e-04f, -6.35152012e-02f, 2.68392731e-02f, -6.31709918e-02f, -4.62558381e-02f, -8.97803679e-02f, -8.49757418e-02f, -6.92069978e-02f, -7.90856108e-02f,
  -6.66245744e-02f, -7.89508596e-02f, 1.48603823e-02f, 4.93221991e-02f, -4.50456031e-02f, 1.41503615e-02f, 2.45482139e-02f, 5.95212691e-02f, -1.05642313e-02f, -4.67609987e-02f,
  1.34021798e-02f, 4.46808562e-02f, 5.20787202e-02f, -7.45950565e-02f, 1.19321577e-01f, 6.65271878e-02f, 8.99778381e-02f, 1.48783550e-02f, -3.44151497e-01f, 2.12517381e-02f,
  1.79200083e-01f, 1.16281472e-01f, 9.59099904e-02f, -8.00724179e-02f, 6.72565848e-02f, -8.65810812e-02f, -1.00573182e-01f, -3.80832218e-02f, -1.00914583e-01f, 2.54107803e-01f,
  -9.33063924e-02f, 8.94547403e-02f, 4.58406694e-02f, 6.38087168e-02f, 6.13347664e-02f, 5.08767292e-02f, 1.91553965e-01f, 2.34450415e-01f, 1.73409030e-01f, 1.15373842e-01f,
  -1.57255426e-01f, -8.51134807e-02f, -7.30896555e-03f, -9.79051068e-02f, 5.45454249e-02f, 1.33423889e-02f, 5.39771132e-02f, 9.27241743e-02f, -7.20803719e-03f, -3.92139815e-02f,
  4.92890738e-02f, 6.24168627e-02f, -2.32217908e-02f, -2.15791557e-02f, -1.06787365e-02f, -9.25929695e-02f, -4.22718562e-02f, -1.06554724e-01f, -2.42283028e-02f, 5.20396531e-02f,
  -2.40844116e-02f, -3.19628678e-02f, 6.81181671e-03f, 1.81246630e-03f, 4.18257043e-02f, -2.59338524e-02f, -1.65225267e-02f, 1.05725795e-01f, -6.67162091e-02f, -4.93956506e-02f,
  2.76949089e-02f, 8.61860532e-03f, 1.45718269e-03f, -1.02953777e-01f, 4.22771536e-02f, -5.07010259e-02f, -8.55641961e-02f, 4.52675857e-02f, -3.04885488e-02f, 3.65329832e-02f,
  -1.06757898e-02f, -1.61101930e-02f, -7.99883232e-02f, 1.81327295e-03f, 6.79000467e-02f, -2.07571853e-02f, 2.95901224e-02f, 7.10241422e-02f, -5.34093566e-02f, -5.64292073e-02f,
  -3.49542759e-02f, 2.51546986e-02f, 3.70177329e-02f, 2.50672121e-02f, -5.78538775e-02f, 1.65004395e-02f, 2.24015098e-02f, -2.73407274e-03f, -7.90841803e-02f, 8.15553367e-02f,
  1.82458252e-01f, 3.97085965e-01f, 1.62839908e-02f, 3.87385227e-02f, -7.12242946e-02f, 4.83943745e-02f, -7.86897913e-02f, 1.21197244e-02f, 1.35902762e-01f, 8.22758973e-02f,
  6.35150149e-02f, -5.83613887e-02f, 9.10574570e-02f, -2.79456843e-02f, -3.97040844e-02f, 6.02416322e-02f, 7.15094358e-02f, 1.99370552e-02f, 8.73780530e-03f, 6.86573833e-02f,
  1.13016896e-01f, 3.65830548e-02f, -5.43185696e-02f, -6.17727190e-02f, -4.90926094e-02f, 3.96464206e-02f, 1.27728134e-02f, -2.62179635e-02f, 8.15321431e-02f, 5.77306747e-02f,
  3.34095836e-01f, -1.74088180e-01f, -8.21723342e-02f, 1.16448447e-01f, 1.93970039e-01f, 2.34466001e-01f, 2.92730063e-01f, -4.45263498e-02f, 2.14149877e-01f, -1.38246521e-01f,
  -1.16122859e-02f, -1.02445014e-01f, -2.45738924e-02f, -3.04961592e-01f, 3.09919775e-01f, -1.00889057e-01f, -1.65503249e-02f, -3.40029970e-02f, -7.92170614e-02f, 1.87540129e-01f,
  9.07531008e-02f, -1.32493719e-01f, -9.55407470e-02f, -3.04197520e-02f, 7.89685920e-03f, -5.36898151e-02f, -5.44421710e-02f, -4.24782885e-03f, -1.60425782e-01f, -7.29428753e-02f,
  1.29487514e-01f, -8.90092254e-02f, -7.74974376e-02f, 2.23889593e-02f, -1.33186416e-03f, 9.38066915e-02f, 3.64630446e-02f, -3.41207162e-02f, 1.85863134e-02f, 8.85086656e-02f,
  2.03288980e-02f, 1.31550059e-02f, -8.91818404e-02f, 1.86941754e-02f, 7.36720264e-02f, -5.50257042e-02f, -1.14421926e-01f, -5.14302477e-02f, 1.67077426e-02f, -3.49923931e-02f,
  -2.62141880e-02f, -7.34451115e-02f, 1.69681851e-02f, -3.63615938e-02f, 3.26165594e-02f, -1.88021455e-02f, 1.17539708e-02f, 1.33773759e-02f, 3.49939391e-02f, 8.15237314e-02f,
  8.07889327e-02f, 7.89930820e-02f, -2.55411174e-02f, -4.35096445e-03f, -1.20306583e-02f, 3.94308614e-03f, -5.05599007e-02f, -4.76518013e-02f, -6.34226203e-02f, 3.09047215e-02f,
  6.12309724e-02f, 1.20282797e-02f, 1.76619571e-02f, 5.98718561e-02f, -2.70429309e-02f, 1.07682437e-01f, -3.90562266e-02f, 1.75611433e-02f, 6.08627349e-02f, 3.14239152e-02f,
  -2.60532033e-02f, 6.76620007e-02f, -1.03701213e-02f, -2.30874550e-02f, 5.33571765e-02f, 1.09189032e-02f, -4.53839414e-02f, 7.74673745e-03f, 3.04106884e-02f, 4.29079793e-02f,
  2.54626185e-01f, 1.80330604e-01f, -5.30231185e-03f, -1.54768443e-03f, -4.82248701e-02f, -2.57884935e-02f, -5.70713123e-03f, -1.75038688e-02f, 1.18333455e-02f, 6.01545051e-02f,
  6.18727617e-02f, 9.34452657e-03f, 1.40049785e-01f, -6.94318069e-03f, 2.92842761e-02f, 7.12402388e-02f, 6.98910728e-02f, -9.44420882e-03f, 8.62558261e-02f, -4.19043861e-02f,
  1.96825117e-02f, -1.48220006e-02f, -2.65711695e-02f, 4.89789061e-02f, -2.43168566e-02f, 7.51068536e-03f, 7.97664225e-02f, -2.53383461e-02f, -1.11170225e-02f, -3.01180873e-02f,
  3.63969922e-01f, 1.44827709e-01f, -1.65836498e-01f, -5.93330152e-02f, 1.66651025e-01f, 2.38307074e-01f, -9.98887271e-02f, 1.81358069e-01f, 2.48251021e-01f, -1.09957874e-01f,
  -1.46109283e-01f, 4.57433891e-03f, -2.16821387e-01f, 5.57500944e-02f, 1.66177571e-01f, 1.56864873e-04f, 2.27936327e-01f, -1.50539717e-02f, 9.26711261e-02f, -7.19452202e-02f,
  1.53164446e-01f, 6.72772573e-03f, -1.69513285e-01f, 7.70514831e-02f, 1.03266418e-01f, -8.77135694e-02f, -1.43591389e-01f, -1.93631008e-01f, -3.93883362e-02f, 8.78711566e-02f,
  -2.59282179e-02f, 4.71860804e-02f, -3.08131650e-02f, 1.23716749e-01f, 5.51672764e-02f, -7.28602782e-02f, -1.04623958e-01f, -5.95506057e-02f, -1.28172532e-01f, 5.95685169e-02f,
  -4.87401523e-02f, 4.34952043e-02f, 5.98931052e-02f, 5.23681380e-02f, 1.00189231e-01f, -3.15731540e-02f, 3.97587493e-02f, -2.75871977e-02f, -6.83799610e-02f, 6.90768808e-02f,
  -1.62762925e-02f, 4.90784878e-03f, 4.28031683e-02f, 3.82232480e-02f, -4.25942289e-03f, 3.32397111e-02f, 3.49780843e-02f, -1.98540483e-02f, 4.48678099e-02f, 5.92086725e-02f,
  9.58666578e-02f, 2.88012717e-02f, -2.53906418e-02f, -2.17101704e-02f, 1.72039289e-02f, -2.92172306e-03f, -3.55393216e-02f, -1.33232856e-02f, 2.19269041e-02f, -3.68871614e-02f,
  -1.35948556e-02f, 1.22536428e-03f, 9.07561742e-03f, -4.85780910e-02f, 9.15851537e-03f, -6.85364306e-02f, -5.11657558e-02f, -1.99804362e-02f, -2.30611637e-02f, -4.86098491e-02f,
  -3.23362537e-02f, 3.86110917e-02f, -4.86420989e-02f, -1.99963544e-02f, -2.78032757e-03f, -1.39225945e-02f, 1.06110629e-02f, 4.01686504e-02f, -8.73471424e-02f, -1.34002715e-02f,
  9.99219436e-03f, 2.14854926e-01f, 1.75873395e-02f, -2.65907403e-02f, -3.69596854e-02f, 1.13211758e-01f, 6.16710223e-02f, 7.59478360e-02f, 4.93794233e-02f, 7.39990547e-02f,
  1.19418398e-01f, -9.00287647e-03f, -2.22644564e-02f, -1.07352529e-02f, -7.81325549e-02f, 1.95249096e-02f, -1.09770864e-01f, -4.55662236e-03f, -7.71699660e-03f, -7.70098250e-03f,
  -9.29919928e-02f, 3.27663533e-02f, -4.04609106e-02f, 5.57838455e-02f, 2.81493608e-02f, -1.28737852e-01f, -5.48459543e-03f, 5.73946051e-02f, 2.44227387e-02f, 2.26351265e-02f,
  -1.18586838e-01f, 3.05434406e-01f, 1.41194567e-01f, 1.64214358e-01f, -5.85963950e-02f, -2.52455503e-01f, -1.33260921e-01f, 3.70177142e-02f, 9.59909856e-02f, 6.07563891e-02f,
  -2.76052892e-01f, 2.13688716e-01f, -1.31217569e-01f, -2.53041945e-02f, -4.28382277e-01f, -1.84797317e-01f, -8.34339932e-02f, 3.96340825e-02f, 2.14480739e-02f, 1.19484901e-01f,
  -2.66008899e-02f, -1.49136513e-01f, -1.31956697e-01f, 1.24789909e-01f, -8.52432474e-02f, 2.76409030e-01f, -6.24943040e-02f, 4.51213643e-02f, 6.57010078e-02f, -7.78356940e-02f,
  -1.37146115e-01f, 1.29493758e-01f, 4.45353836e-02f, 6.98081926e-02f, 1.20204575e-02f, -1.07734492e-02f, 2.46808734e-02f, -1.17470808e-02f, -3.85430902e-02f, 1.87747069e-02f,
  3.91375925e-03f, -2.25373637e-02f, 8.20790324e-03f, -3.37615125e-02f, 6.66841120e-02f, 8.04930329e-02f, 3.04400232e-02f, -5.95770963e-02f, 7.39238188e-02f, -1.03031240e-01f,
  -3.67776072e-03f, -5.21926172e-02f, 1.04640024e-02f, 1.09388288e-02f, -6.17026128e-02f, -6.50790869e-04f, -1.87066011e-02f, -3.39279696e-02f, 3.98097970e-02f, 2.18933485e-02f,
  -3.50020528e-02f, -1.78034231e-02f, -3.86791565e-02f, -8.17099772e-03f, -4.53793909e-03f, -1.65568125e-02f, -1.25128077e-02f, -1.40247373e-02f, 3.14219147e-02f, -2.02339236e-02f,
  -1.77894495e-02f, 6.08008690e-02f, -2.48564943e-03f, -2.47427560e-02f, -3.13393921e-02f, 2.99061593e-02f, 7.52484286e-03f, 4.40995721e-03f, -1.07175661e-02f, -2.39070542e-02f,
  -2.60014329e-02f, -1.79741916e-03f, -3.85653367e-03f, -1.26270950e-02f, -5.41010983e-02f, -5.35465777e-02f, 1.31801274e-02f, 1.77151449e-02f, -1.38101196e-02f, -8.82071704e-02f,
  3.65469530e-02f, 4.51329760e-02f, 2.44833753e-02f, 4.79855537e-02f, 3.14499587e-02f, -2.92103011e-02f, -1.65534094e-02f, 1.08499231e-03f, 2.24467572e-02f, -3.91816497e-02f,
  -1.30057950e-02f, 3.52929905e-02f, 1.84051245e-02f, 1.05336662e-02f, 1.41192824e-02f, -7.51224533e-02f, -4.13005427e-02f, 6.03590347e-02f, -2.01668516e-02f, 4.74839658e-02f,
  6.61043124e-03f, -1.72532164e-02f, -1.22855534e-03f, -4.33138758e-03f, 3.22309546e-02f, -2.13697068e-02f, 4.64033112e-02f, 5.47978356e-02f, -6.32863566e-02f, 2.15561613e-02f,
  4.44940716e-01f, 6.70938706e-03f, -1.92713305e-01f, 1.53000399e-01f, 6.33176193e-02f, 2.06842527e-01f, 2.31400505e-01f, -3.95416170e-02f, 1.48227941e-02f, 1.90939009e-01f,
  1.84141681e-01f, 1.20929419e-03f, -1.37193918e-01f, 3.46188426e-01f, -3.70479017e-01f, -2.19179332e-01f, 1.78752646e-01f, 2.55153686e-01f, -9.80219617e-02f, 8.23013112e-02f,
  -6.45499602e-02f, 1.90254152e-01f, -1.30160868e-01f, -1.08023643e-01f, 2.44539708e-01f, -8.73396546e-03f, -1.49797738e-01f, -1.66539639e-01f, 1.58654824e-01f, -5.83623946e-02f,
  5.15776537e-02f, 7.51964822e-02f, 4.64444561e-03f, -1.24701113e-01f, 5.04414365e-02f, 1.12474181e-01f, 2.36532511e-03f, 3.00103333e-02f, -5.31497449e-02f, 7.04428367e-03f,
  3.76701504e-02f, -5.00615919e-04f, 4.47677299e-02f, -6.49540545e-03f, 8.84052515e-02f, -1.84280686e-02f, 7.62080308e-03f, 5.27477190e-02f, -1.36553692e-02f, 5.68313710e-02f,
  6.61412114e-03f, 4.38487604e-02f, 4.66266833e-02f, -2.29103062e-02f, -7.55610093e-02f, 1.16394423e-02f, -3.43195833e-02f, 1.06661506e-02f, 1.52390534e-02f, 1.32050924e-02f,
  2.83852331e-02f, -4.59737033e-02f, 3.33163440e-02f, -2.36661825e-02f, -2.18416378e-02f, 3.31991836e-02f, 1.70434751e-02f, -7.95618258e-03f, -5.72762312e-03f, 5.56751601e-02f,
  -1.67357251e-02f, 6.21378683e-02f, 1.67302880e-02f, 8.89484026e-03f, 3.71366404e-02f, 5.98559007e-02f, -5.30745871e-02f, -1.62893794e-02f, 1.30256508e-02f, 1.28249731e-02f,
  -1.42763825e-02f, -2.71518081e-02f, -1.47544136e-02f, 2.45469548e-02f, -2.92504653e-02f, -4.54252958e-02f, 4.47372571e-02f, -1.86200887e-02f, -1.24048889e-02f, -1.09295873e-02f,
  -9.15322378e-02f, -2.57902861e-01f, -8.19058493e-02f, 9.80812684e-03f, -3.85799780e-02f, 3.00464546e-03f, 2.16870140e-02f, -3.25956680e-02f, -4.32058051e-02f, -1.15180891e-02f,
  5.24713881e-02f, 5.71977645e-02f, -3.88078801e-02f, 3.96297015e-02f, -4.72602546e-02f, 6.25757426e-02f, 3.99097102e-03f, 8.99834745e-03f, 1.74269136e-02f, -9.71919484e-03f,
  3.72849428e-03f, 4.11042310e-02f, -4.33861837e-02f, 4.45276946e-02f, 4.14075516e-02f, 4.09867279e-02f, -1.05140917e-02f, -6.86192513e-02f, -3.44035365e-02f, -2.84597911e-02f,
  -1.81990251e-01f, 4.10332561e-01f, 2.02731162e-01f, 2.90592108e-02f, -3.75650167e-01f, -1.05918780e-01f, 3.51107538e-01f, -1.65238202e-01f, 7.34245107e-02f, 2.24944115e-01f,
  -2.02431440e-01f, 3.27411443e-01f, 2.70956159e-01f, -1.29517941e-02f, -2.23021299e-01f, 2.59788811e-01f, -5.43283038e-02f, 1.73994705e-01f, -2.21208800e-02f, -3.34718339e-02f,
  -1.25534236e-01f, -7.97955617e-02f, -3.10068000e-02f, -1.80539504e-01f, -7.60924593e-02f, 1.94474645e-02f, -1.03600495e-01f, 8.56094137e-02f, -8.61544088e-02f, -3.03344857e-02f,
  -2.06679255e-02f, 2.53222696e-02f, 1.02045694e-02f, 8.61414745e-02f, -7.40162209e-02f, -3.72234173e-02f, 4.32219394e-02f, 3.21162790e-02f, -1.00846663e-01f, 8.24594405e-03f,
  7.68661201e-02f, -3.29559036e-02f, 2.00677663e-03f, 2.54443102e-02f, -5.33089153e-02f, -5.54033741e-02f, -7.82292560e-02f, -6.84669912e-02f, 3.86121683e-02f, 3.44137996e-02f,
  3.30994613e-02f, -2.27598194e-02f, -3.40420865e-02f, 9.65646058e-02f, -5.89295514e-02f, -3.87029909e-03f, 4.11524810e-02f, 4.30710539e-02f, 2.36154441e-02f, -2.67341528e-02f,
  -3.14667895e-02f, 8.23019259e-03f, 3.39239510e-03f, -3.06641571e-02f, -3.96128893e-02f, -3.40259671e-02f, -1.32671203e-02f, -7.72111071e-03f, 1.12443557e-02f, -4.49316092e-02f,
  -2.68988851e-02f, -2.72074458e-03f, -2.19629873e-02f, 9.73805413e-03f, -6.76941033e-03f, -1.75093096e-02f, -2.29393188e-02f, 7.30706304e-02f, -7.15457209e-05f, -6.34168237e-02f,
  5.96146882e-02f, -4.13260721e-02f, 3.68159600e-02f, -3.16146091e-02f, -7.17364484e-03f, 1.27376122e-02f, -1.05296206e-02f, 1.92349460e-02f, -3.02168112e-02f, -2.54029664e-03f,
  4.38848622e-02f, 1.71389624e-01f, 5.51590994e-02f, -1.40788723e-02f, 9.07295048e-02f, -4.16941494e-02f, 1.02377404e-02f, -3.98334339e-02f, 6.91606328e-02f, -1.36356363e-02f,
  -3.95860784e-02f, -3.41954455e-03f, 1.38683023e-03f, -7.19994828e-02f, 4.11315728e-03f, 1.59844402e-02f, 7.95940012e-02f, 2.74691097e-02f, -7.55312666e-03f, -3.28607038e-02f,
  -4.90094684e-02f, -2.15495620e-02f, 2.85883825e-02f, -1.34432957e-01f, 2.87471339e-02f, -2.65660841e-04f, -3.36991400e-02f, 2.99038012e-02f, -9.09808208e-04f, 9.78341326e-02f,
  2.04794183e-01f, -1.54488847e-01f, 1.38572201e-01f, 1.13198698e-01f, 1.85009554e-01f, -9.25732404e-03f, 5.12791537e-02f, 2.48337418e-01f, -3.80712003e-02f, 2.29394272e-01f,
  1.78930447e-01f, -1.41636878e-01f, 1.20252334e-02f, 7.85367340e-02f, -1.31828457e-01f, -2.16952041e-01f, 1.58511594e-01f, 1.08424738e-01f, -2.14265272e-01f, 2.25511581e-01f,
  7.08340527e-03f, 2.01163724e-01f, 2.35890504e-02f, -1.37762036e-02f, 3.65661353e-01f, 6.34826571e-02f, 2.91447014e-01f, -2.25544095e-01f, 1.71699047e-01f, -1.20383792e-01f,
  7.48327598e-02f, 1.03791401e-01f, 1.34417698e-01f, 6.11040257e-02f, 1.28367662e-01f, 5.89315295e-02f, 3.77667658e-02f, -1.08963519e-01f, -6.23956099e-02f, -5.81542514e-02f,
  -1.31386090e-02f, -4.45053317e-02f, -4.01412249e-02f, -1.30075719e-02f, 9.28338170e-02f, -1.17221437e-02f, -2.46149884e-03f, 7.64929578e-02f, -4.09096591e-02f, -9.87075921e-03f,
  -7.11627007e-02f, 2.40321308e-02f, 5.54776601e-02f, 7.32473880e-02f, -2.85051744e-02f, -9.26008448e-02f, 9.79634374e-03f, -1.33943828e-02f, 3.08821592e-02f, -9.19482112e-03f,
  7.67806079e-03f, -1.29686564e-03f, -2.28821971e-02f, 2.90032066e-02f, -2.87032109e-02f, 9.89906639e-02f, -1.90749438e-03f, -6.00127410e-03f, -3.96967046e-02f, 1.17944507e-02f,
  3.87955531e-02f, 2.20709927e-02f, 4.12364071e-03f, -2.14337222e-02f, 3.59694026e-02f, 3.40225808e-02f, 7.24767521e-03f, 5.19410074e-02f, 1.99031085e-02f, 2.32456382e-02f,
  -4.78218533e-02f, -4.69211601e-02f, 3.04447841e-02f, 3.48341726e-02f, -3.91802341e-02f, -5.15937321e-02f, 3.62576023e-02f, -1.59820039e-02f, 3.84949557e-02f, 4.94373683e-03f,
  2.44441956e-01f, 9.87574756e-02f, -7.93560594e-03f, 9.23992600e-03f, 3.64285223e-02f, 2.36919075e-02f, -1.73713677e-02f, -1.65262558e-02f, -1.68596506e-02f, 1.12111391e-02f,
  6.86723366e-02f, 7.40104392e-02f, 4.35129292e-02f, 1.83415599e-02f, -1.09339431e-01f, 2.51553319e-02f, 3.46094705e-02f, -1.24935610e-02f, 1.03718437e-01f, 5.46863899e-02f,
  4.58275229e-02f, -8.81222822e-03f, -4.37837318e-02f, 1.38092935e-02f, 8.53973851e-02f, 8.76136124e-02f, 2.24751737e-02f, -6.19712882e-02f, -5.98756857e-02f, -3.40097374e-03f,
  6.81972146e-01f, -1.17078386e-01f, -5.01970276e-02f, 2.82892466e-01f, -2.09460501e-02f, -9.51646939e-02f, 3.94847132e-02f, -1.39472848e-02f, 1.06797047e-01f, -1.15375221e-01f,
  -9.67512503e-02f, 1.17710225e-01f, -2.39367694e-01f, -1.16102278e-01f, 1.31602973e-01f, -2.06404701e-01f, 3.24566737e-02f, 6.98345155e-02f, 1.43927019e-02f, 5.51345982e-02f,
  3.66235524e-02f, -9.87629741e-02f, -1.23189256e-01f, -9.62698758e-02f, 1.23300534e-02f, 1.16467603e-01f, -8.07040706e-02f, -4.52684835e-02f, 2.77593266e-02f, -4.13013808e-02f,
  1.38505876e-01f, 1.60212085e-01f, -1.22220427e-01f, 3.85302166e-03f, 3.22314799e-02f, 5.08944616e-02f, 6.10394776e-02f, -5.20313010e-02f, 3.31979850e-03f, -3.06345932e-02f,
  -4.26449860e-03f, 3.05013750e-02f, 2.44798157e-02f, -6.31501749e-02f, 2.34789848e-02f, -1.52617786e-02f, -2.07617152e-02f, -5.13815805e-02f, -3.60364281e-02f, 4.61924961e-03f,
  1.70003772e-02f, -1.82721894e-02f, -3.05246469e-02f, -1.08657489e-02f, -2.83590816e-02f, -9.31058265e-03f, 2.97811534e-02f, -3.81608334e-05f, 1.94622260e-02f, 3.95286083e-02f,
  3.75947286e-03f, 4.49138321e-02f, -6.29746243e-02f, 2.00595073e-02f, 1.71850901e-02f, -5.74038476e-02f, 2.42543197e-03f, -5.05305082e-02f, 2.16187853e-02f, 1.03075691e-02f,
  2.09515523e-02f, 1.19682793e-02f, 6.99837785e-03f, 3.05805635e-02f, -1.73572581e-02f, 5.37528582e-02f, 1.34140821e-02f, -3.00542116e-02f, 2.05895808e-02f, 2.67154742e-02f,
  1.09852338e-02f, 4.62472159e-03f, 1.35436216e-02f, -1.76475868e-02f, -5.99792376e-02f, 1.44682461e-04f, -8.94557312e-02f, 4.60125972e-03f, -4.97611053e-02f, 9.63646919e-03f,
  1.47942593e-02f, 1.45597145e-01f, 4.17836150e-03f, 3.25253345e-02f, -3.07691917e-02f, -4.55318764e-02f, -1.75950080e-02f, 6.75562099e-02f, -2.74471231e-02f, 2.18454786e-02f,
  2.34679896e-02f, 3.49347554e-02f, 1.45617705e-02f, 1.95076056e-02f, 3.22770365e-02f, -3.85063402e-02f, -2.28500105e-02f, 6.06521815e-02f, 1.02402652e-02f, 4.27097380e-02f,
  5.49001433e-02f, 8.43381882e-02f, 1.45775769e-02f, 4.36489359e-02f, 8.78540147e-03f, 1.95707902e-02f, 4.80265506e-02f, 1.77271273e-02f, 4.53344509e-02f, -3.43482867e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.80683428e-01f, -7.98653424e-01f, 1.85989842e-01f, 3.25413227e-01f, 2.39854842e-01f, 2.23053023e-01f, 4.45987344e-01f, -2.60289162e-01f, -2.58122478e-02f, -5.57481468e-01f,
  -1.61088899e-01f, -2.93340199e-02f, -2.16503948e-01f, 4.38062958e-02f, 6.02510989e-01f, -3.28113660e-02f, 1.74641935e-03f, 9.59426463e-02f, 3.28929387e-02f, -2.30723768e-02f,
  1.46000862e-01f, 5.81115521e-02f, 8.35131258e-02f, -2.78646916e-01f, -8.64665397e-03f, -1.51993513e-01f, 7.49601871e-02f, 1.38721541e-01f, 6.63934946e-02f, 2.37826541e-01f,
  -1.78001001e-01f, -1.74464807e-01f, -2.35119164e-02f, -8.32282156e-02f, -9.42460075e-02f, -1.31262228e-01f, 6.93031251e-02f, 1.61548391e-01f, 6.98937923e-02f, -1.14131607e-02f,
  -1.45346737e-02f, -2.32242439e-02f, 3.94561775e-02f, 9.24124047e-02f, 5.45685925e-03f, -8.74707252e-02f, -2.47469936e-02f, -1.09053083e-01f, -1.13804825e-01f, 1.46780154e-02f,
  -8.32784697e-02f, -5.70053943e-02f, -2.50834301e-02f, 9.96543281e-03f, 2.34976597e-02f, 4.80095595e-02f, 6.75102770e-02f, 1.11507185e-01f, -3.03910393e-03f, -3.56942341e-02f,
  6.40487149e-02f, 5.19160591e-02f, -5.38930716e-03f, -2.95628142e-02f, 7.45377019e-02f, 5.29513732e-02f, -1.59077775e-02f, 3.05809528e-02f, 2.99787745e-02f, 5.20617999e-02f,
  2.64598727e-02f, -1.29868211e-02f, 8.33187345e-03f, 3.44164576e-03f, 6.69198558e-02f, 7.56845623e-03f, 1.68540310e-02f, 2.12517455e-02f, -8.47037658e-02f, -7.07782283e-02f,
  3.14957574e-02f, 1.17613850e-02f, -6.43312410e-02f, -2.22983751e-02f, -5.83354663e-03f, 5.32294028e-02f, -5.20370156e-02f, -1.08493036e-02f, -3.30799143e-03f, 1.27657086e-01f,
  -3.27559203e-01f, -3.01720470e-01f, -9.34790075e-02f, -9.36459675e-02f, -4.01212499e-02f, -6.07377104e-02f, 1.83468424e-02f, 1.49303926e-02f, -5.35204783e-02f, -5.05940616e-02f,
  -4.52276655e-02f, 8.84851515e-02f, -4.55307327e-02f, -1.18968235e-02f, 4.01991606e-02f, -7.35618249e-02f, 3.17009874e-02f, -4.57295217e-02f, 5.65964468e-02f, -1.27254069e-01f,
  -1.00187823e-01f, -3.91477533e-02f, 1.11147398e-02f, -6.18926212e-02f, -1.55092813e-02f, -4.68116999e-02f, -1.17515577e-02f, -9.53070633e-03f, 5.85229741e-03f, -1.42689003e-03f,
  -2.87495464e-01f, -1.97242036e-01f, 1.50269538e-01f, -2.41493568e-01f, -1.18637927e-01f, 1.40512921e-02f, -1.03261266e-02f, -6.31913915e-02f, -2.91924447e-01f, -3.42914611e-02f,
  7.89999813e-02f, -2.04567298e-01f, 2.27171972e-01f, -1.19687706e-01f, 1.56654596e-01f, 3.40978444e-01f, 8.90570059e-02f, 1.37877941e-01f, -7.05836564e-02f, -2.10909948e-01f,
  -1.32032309e-03f, -7.81319514e-02f, 3.55409533e-01f, -2.06040777e-02f, -1.46308273e-01f, -8.66363868e-02f, 2.21895520e-02f, 1.17884412e-01f, -8.13134760e-02f, 4.98372875e-02f,
  -2.25721553e-01f, -1.73265591e-01f, -6.35653064e-02f, -3.37486193e-02f, 4.97214347e-02f, 6.30039573e-02f, 8.41844156e-02f, 1.31244883e-02f, 1.74108427e-02f, 1.76512189e-02f,
  3.56315926e-04f, -6.51441067e-02f, -3.38807553e-02f, 4.30446230e-02f, -4.48740199e-02f, -5.41520640e-02f, -6.33950531e-02f, 5.96677251e-02f, -4.35081422e-02f, 3.16825174e-02f,
  -3.11171431e-02f, 5.58311492e-02f, 3.33339386e-02f, 1.58157781e-01f, 7.52324462e-02f, -4.37547751e-02f, 8.30858201e-02f, -2.87770126e-02f, -1.57972872e-02f, -2.29450986e-02f,
  9.65250358e-02f, -4.57892567e-02f, -2.80954689e-02f, -7.79223070e-02f, -3.01952045e-02f, 2.53770314e-02f, 8.83612707e-02f, -3.29277404e-02f, 3.38739268e-02f, 3.77490511e-03f,
  -2.73421407e-02f, 2.47281529e-02f, -2.46581677e-02f, -1.48055069e-02f, 5.25994524e-02f, 3.72016542e-02f, 8.98910388e-02f, -8.36810023e-02f, 5.63909635e-02f, -9.55889060e-04f,
  -4.47572619e-02f, 2.25833827e-03f, 7.29643255e-02f, 7.12469444e-02f, 1.72667727e-02f, 6.44434020e-02f, -6.22878931e-02f, 2.29255389e-02f, 3.13450582e-02f, 2.21939422e-02f,
  -1.11979596e-01f, -1.57509685e-01f, -1.74814891e-02f, -1.58289254e-01f, -2.96002440e-03f, 4.11258191e-02f, 5.42861931e-02f, -8.14459696e-02f, 3.61350216e-02f, -1.24391802e-02f,
  4.31723222e-02f, -3.99293425e-03f, -1.35692701e-01f, -5.99184148e-02f, -6.49190396e-02f, -5.19847609e-02f, -2.68224142e-02f, 6.45197779e-02f, -1.21058665e-01f, -1.82446223e-02f,
  3.72409746e-02f, 1.03025595e-02f, -2.01295875e-02f, -2.46477295e-02f, 5.77336438e-02f, -2.52476074e-02f, -5.76203912e-02f, 1.49970148e-02f, -6.43392950e-02f, 5.66304773e-02f,
  -2.98584491e-01f, 1.45146266e-01f, -4.54922497e-01f, -2.82704026e-01f, 1.43905401e-01f, -5.87745965e-01f, -3.96076053e-01f, 6.61284104e-02f, 1.55659944e-01f, 2.54653335e-01f,
  8.68094712e-02f, -8.01625177e-02f, 2.49675632e-01f, -2.76055515e-01f, -5.69837153e-01f, -1.47797298e-02f, -5.10104954e-01f, -2.38008067e-01f, 8.66530836e-02f, -1.77662030e-01f,
  -2.26764873e-01f, 1.30687684e-01f, -3.14381003e-01f, 2.01353654e-01f, -1.42645344e-01f, -6.12186007e-02f, 4.75035571e-02f, 2.82634556e-01f, -2.71852314e-01f, 7.75918365e-02f,
  -1.56975776e-01f, 2.68697113e-01f, -4.27597985e-02f, -1.32130021e-02f, -2.31176347e-01f, -1.45475373e-01f, -1.11412287e-01f, 2.64775380e-02f, 2.47132052e-02f, -3.14649157e-02f,
  -3.46199684e-02f, 2.29026750e-02f, -4.93108556e-02f, 1.39329359e-01f, 1.28987348e-02f, 5.90012316e-03f, -9.51615721e-02f, -6.71498775e-02f, -6.18452467e-02f, -9.77545008e-02f,
  -8.71944055e-02f, -1.18021868e-01f, -1.17532551e-01f, -2.46169958e-02f, -6.73877820e-02f, -1.01118013e-02f, -1.23264179e-01f, -6.58846349e-02f, -1.10320777e-01f, -2.03098971e-02f,
  2.45856866e-02f, -7.87196774e-03f, 5.10232300e-02f, 4.35450673e-02f, -6.52479893e-03f, 2.61793584e-02f, 4.30143997e-02f, 4.07290682e-02f, 2.54947338e-02f, -4.24306802e-02f,
  -1.78109761e-02f, 1.68627501e-02f, 8.40388685e-02f, -1.05801798e-01f, -5.43918414e-03f, 3.67973670e-02f, 1.46003244e-02f, 2.52850670e-02f, -8.04991499e-02f, -3.37683223e-02f,
  1.50075465e-01f, -4.82633449e-02f, 5.45468852e-02f, -2.62467600e-02f, -3.78244705e-02f, 4.86644804e-02f, 8.62931018e-04f, -1.74811352e-02f, -9.44799837e-03f, -6.39618114e-02f,
  -6.29534796e-02f, 4.07340154e-02f, 3.45670357e-02f, 7.70241320e-02f, -3.35727185e-02f, -4.49553765e-02f, -7.97836930e-02f, -6.15621656e-02f, -1.11511156e-01f, 6.09743819e-02f,
  -3.98848020e-02f, -1.01719843e-02f, -5.58510385e-02f, 2.04201974e-02f, -5.31524420e-02f, 1.33619644e-02f, 3.18757929e-02f, 1.89166758e-02f, -5.99351414e-02f, -1.16326688e-02f,
  4.36683185e-02f, 1.23530598e-02f, -1.73826572e-02f, 2.31067091e-02f, -2.36468557e-02f, -3.92572917e-02f, -1.08903060e-02f, -1.35723350e-03f, -2.99224444e-02f, -3.51904854e-02f,
  1.54738337e-01f, -1.88573033e-01f, -3.71938288e-01f, 2.89658487e-01f, -1.09141752e-01f, -2.74317712e-01f, -4.30985987e-01f, 6.08977266e-02f, -2.69535035e-01f, -1.37534335e-01f,
  1.70853734e-01f, 1.25603713e-02f, -2.59053349e-01f, 2.99327880e-01f, 5.24817228e-01f, -1.08641498e-01f, 3.68988812e-01f, 1.50138378e-01f, 6.60891384e-02f, 1.59346402e-01f,
  3.64569813e-01f, 5.91131091e-01f, 2.58855104e-01f, 3.34976226e-01f, 1.40709355e-01f, 1.79231375e-01f, 5.50658882e-01f, -7.02709928e-02f, 5.04861176e-01f, 1.76249653e-01f,
  -8.98955390e-02f, 7.79549479e-02f, -6.18619435e-02f, -1.11246109e-01f, 7.01647205e-03f, -4.76537123e-02f, -7.04106316e-02f, 3.07349414e-02f, -1.29811749e-01f, -2.94315796e-02f,
  -1.23094685e-01f, 6.96351677e-02f, 4.30324562e-02f, -1.22993495e-02f, 8.84077046e-03f, -1.34216491e-02f, -9.03001055e-02f, -1.15480751e-01f, -1.10132575e-01f, -4.86463169e-03f,
  -1.32181466e-01f, -4.39878292e-02f, -3.09850778e-02f, 1.26082078e-02f, -2.08205599e-02f, -1.40079446e-02f, -7.03318790e-02f, -9.18838382e-03f, 7.94340372e-02f, 5.41765578e-02f,
  7.91777074e-02f, -6.58360347e-02f, -6.27729744e-02f, -9.22919288e-02f, 7.39527866e-02f, -5.05655967e-02f, 4.79898043e-03f, -9.09819081e-03f, -3.12887244e-02f, 4.33484502e-02f,
  -5.99982403e-03f, 4.30011749e-02f, -9.64014512e-03f, -7.08081648e-02f, 5.54182194e-02f, -6.42550737e-02f, -9.95161943e-03f, 3.59557420e-02f, -3.14727277e-02f, -9.81783844e-04f,
  2.82199215e-03f, 5.64653613e-02f, -2.50405725e-02f, -6.71960227e-03f, -4.05208543e-02f, -3.64288827e-03f, 6.20039739e-02f, -5.36414236e-02f, -4.17083763e-02f, -1.42097389e-02f,
  9.05103087e-02f, 4.14071947e-01f, -1.38614804e-01f, -5.69203980e-02f, 4.76081669e-02f, 6.75332919e-02f, 4.74766456e-03f, 7.47263283e-02f, 1.59334138e-01f, 1.61201530e-03f,
  5.95326349e-02f, -1.39581515e-02f, 6.16075583e-02f, 9.11938900e-04f, 2.34205946e-02f, 1.18343376e-01f, 1.08529575e-01f, 5.61032519e-02f, 5.03626615e-02f, 1.11395165e-01f,
  -5.31192049e-02f, -7.57025704e-02f, 5.56194112e-02f, -1.59054726e-01f, 8.46791733e-03f, 2.39047501e-02f, 3.87038700e-02f, -9.22310108e-04f, 1.38423331e-02f, 2.01018173e-02f,
  3.31670612e-01f, -3.16445827e-01f, 5.22719659e-02f, 1.36140287e-01f, 3.57830733e-01f, 2.16048732e-01f, 3.61827224e-01f, 1.28914833e-01f, 2.72664905e-01f, -3.31670940e-01f,
  -2.51758158e-01f, -1.17983274e-01f, 1.02011509e-01f, -2.05656841e-01f, 3.60608906e-01f, 3.59822921e-02f, -2.59844363e-02f, -1.15488559e-01f, 1.19548596e-01f, -5.42215221e-02f,
  6.01314381e-02f, -2.16513619e-01f, -4.33591083e-02f, -3.45405877e-01f, -1.52026147e-01f, -1.51124179e-01f, -2.32359707e-01f, 3.65978330e-02f, -3.97688478e-01f, -1.09842904e-01f,
  6.32294640e-02f, 5.82061075e-02f, 7.39765540e-02f, -9.53109562e-02f, 1.03741497e-01f, -3.70776691e-02f, -9.86639038e-02f, 1.18266912e-02f, 9.13688317e-02f, 5.90650691e-03f,
  -5.58280572e-02f, -7.71983340e-02f, 4.82553942e-03f, -4.53765392e-02f, 5.29127084e-02f, -1.65885258e-02f, -8.51495308e-04f, 1.14305699e-02f, 2.69730799e-02f, -7.84521848e-02f,
  -6.31736293e-02f, -4.40603979e-02f, 5.43152168e-02f, -1.49760991e-01f, -6.64972961e-02f, -4.19152193e-02f, -1.08211245e-02f, -3.57545950e-02f, -9.96936634e-02f, -5.05737960e-02f,
  -2.63222288e-02f, -4.21601534e-02f, 9.45093706e-02f, -7.88522325e-03f, 8.10720623e-02f, -9.27374214e-02f, 1.62055884e-02f, -1.25790844e-02f, 6.84980676e-02f, -1.88873578e-02f,
  -1.96259301e-02f, -1.45258792e-02f, 1.72661319e-02f, -5.51073998e-02f, 4.93130796e-02f, -3.23552894e-03f, 1.58463717e-02f, -6.87577054e-02f, 5.59106767e-02f, -8.70180875e-02f,
  -1.12735638e-02f, 8.15569423e-03f, 2.37819087e-03f, -5.70533238e-02f, -6.47664145e-02f, 2.51403544e-02f, -5.56168072e-02f, 2.25207042e-02f, -5.16648218e-02f, -1.79525986e-02f,
  2.93668080e-03f, -2.62130439e-01f, 4.15481143e-02f, -3.49604432e-03f, -3.34736891e-02f, 5.25708906e-02f, -3.09411138e-02f, -7.51230419e-02f, -1.53602827e-02f, 6.65356293e-02f,
  -1.07085347e-01f, -7.95815364e-02f, 1.01676676e-02f, 2.18187291e-02f, -9.03103575e-02f, 2.41218451e-02f, -1.20755956e-01f, -2.19357982e-02f, -5.86355925e-02f, -4.74203415e-02f,
  -5.92771135e-02f, -2.30337679e-02f, 7.12141320e-02f, 2.67639849e-03f, -5.78215718e-02f, -4.30181623e-02f, -4.45436575e-02f, -8.86548832e-02f, -1.17940776e-01f, 3.05182412e-02f,
  3.83743852e-01f, 6.04223870e-02f, 2.15866014e-01f, 5.82397282e-01f, 1.30873218e-01f, -5.33594787e-02f, 1.01322919e-01f, 2.54449725e-01f, 8.08513403e-01f, -1.34526551e-01f,
  -1.92575473e-02f, 5.40408539e-03f, -2.96470653e-02f, 7.29473755e-02f, 2.05664575e-01f, 1.03996567e-01f, 2.80284673e-01f, 1.55906593e-02f, 3.80596966e-01f, 1.42981261e-01f,
  3.14784050e-01f, -4.58789393e-02f, -1.78947881e-01f, -2.17191756e-01f, -1.03930138e-01f, 1.02351099e-01f, -2.03304455e-01f, -1.50843963e-01f, -2.38820061e-01f, -8.63815024e-02f,
  -6.59982488e-02f, 2.87385136e-01f, -5.75460270e-02f, -1.03250422e-01f, 7.87093639e-02f, -1.13564520e-03f, -8.04666579e-02f, -1.19081572e-01f, 7.13437572e-02f, 6.60718977e-02f,
  -2.77781058e-02f, -1.96823683e-02f, 8.22030380e-02f, -1.99069502e-03f, 5.62011190e-02f, -2.56959926e-02f, 8.97021443e-02f, 2.65530851e-02f, -7.63238892e-02f, -1.76559424e-03f,
  -1.77018754e-02f, -2.40374040e-02f, 2.37956680e-02f, -9.42967739e-03f, 1.32050375e-02f, 7.90307298e-02f, -6.19597025e-02f, -7.98931271e-02f, -5.93559071e-02f, 1.56506747e-01f,
  1.96673740e-02f, -1.19602662e-02f, -7.59921595e-02f, -1.98645461e-02f, -6.25855774e-02f, 3.57957818e-02f, 1.18438341e-02f, -5.24117313e-02f, 1.49487825e-02f, -2.07001194e-02f,
  1.22507736e-02f, 8.82432144e-03f, 3.17193801e-03f, 2.58067325e-02f, 1.01083674e-01f, 5.22608273e-02f, -3.66882756e-02f, 1.03776101e-02f, 1.10686682e-01f, 6.14269376e-02f,
  5.62961437e-02f, 8.51383433e-03f, -8.82360786e-02f, 1.99248306e-02f, 2.94771623e-02f, 4.50279098e-03f, 7.11233094e-02f, -3.75574306e-02f, 8.07040781e-02f, -5.27929068e-02f,
  9.98557582e-02f, 4.03861970e-01f, -6.41272292e-02f, -2.73702070e-02f, -4.67904694e-02f, -1.04058817e-01f, 2.10082084e-02f, 3.64655405e-02f, 1.59813643e-01f, 8.38705525e-02f,
  -2.85224542e-02f, -5.37833432e-03f, -6.90783784e-02f, -3.21529880e-02f, 1.56371519e-02f, 5.23593556e-03f, 2.66120285e-02f, 6.34101406e-02f, 2.44499296e-02f, 1.56965479e-02f,
  -6.48318008e-02f, 1.74361896e-02f, 1.74003355e-02f, 2.03823522e-02f, 3.58700305e-02f, 1.34771867e-02f, 8.27424675e-02f, -2.81429272e-02f, -4.79218252e-02f, 6.01064079e-02f,
  -2.59572834e-01f, 4.63646352e-02f, -6.49181902e-02f, -2.84549564e-01f, -2.70987868e-01f, -5.83753437e-02f, -5.34717329e-02f, -5.17927594e-02f, 4.08421233e-02f, 2.65234381e-01f,
  -3.68164033e-02f, -1.28550544e-01f, 4.92178917e-01f, -9.50858966e-02f, 7.20749423e-02f, 4.46908802e-01f, -5.22547327e-02f, -5.60681932e-02f, -9.72980354e-03f, -1.38025925e-01f,
  -1.46702603e-01f, -1.46915719e-01f, -3.21557708e-02f, -1.27240255e-01f, -4.40165222e-01f, -2.59233296e-01f, -1.05967313e-01f, -1.57963768e-01f, -2.94805586e-01f, -1.67490259e-01f,
  -1.58979014e-01f, -2.75045663e-01f, -1.49101228e-01f, -4.33779396e-02f, -1.24903180e-01f, -9.83394682e-02f, -8.33713338e-02f, -1.31054344e-02f, -9.52590182e-02f, 2.71182824e-02f,
  -4.07384299e-02f, -3.59886698e-02f, -9.43266824e-02f, 8.56493637e-02f, -2.41219606e-02f, -9.40418020e-02f, -1.48619441e-02f, -1.16180321e-02f, -7.26912096e-02f, -9.21358541e-02f,
  -8.15914851e-03f, -5.71858846e-02f, -6.11128099e-02f, 5.17224185e-02f, -1.08233273e-01f, -5.53924963e-02f, -1.96924768e-02f, 2.28048395e-02f, -7.77728483e-02f, -8.55838358e-02f,
  -7.03546777e-03f, 1.66287329e-02f, 1.47327939e-02f, -4.38841507e-02f, -2.07748413e-02f, -6.19334430e-02f, -1.30285532e-03f, -1.84234120e-02f, 5.04176244e-02f, 3.54943541e-03f,
  -3.30156982e-02f, -9.28348023e-03f, 2.53574876e-03f, 5.31712882e-02f, 2.28148028e-02f, 8.57370123e-02f, 3.46171148e-02f, 4.87878686e-03f, 6.76316842e-02f, -3.63479904e-03f,
  1.34605414e-03f, 5.32323979e-02f, 3.33634689e-02f, 7.27274567e-02f, -3.65426280e-02f, 8.67495015e-02f, 5.06325252e-02f, 4.72156852e-02f, 3.50165069e-02f, -4.20918912e-02f,
  -2.43622795e-01f, -1.74347401e-01f, -9.64148715e-02f, 6.58170320e-04f, 7.71069666e-03f, -1.60226617e-02f, -7.43421144e-04f, -8.66706967e-02f, -3.76649462e-02f, -2.59359237e-02f,
  -4.49056126e-04f, 7.89001733e-02f, 1.92075539e-02f, 3.17192860e-02f, 6.49998933e-02f, -1.02771521e-02f, -1.07779711e-01f, -9.22872312e-03f, -3.34287435e-02f, -1.55278426e-02f,
  -7.80905634e-02f, -2.93370560e-02f, 1.08292148e-01f, 3.36432531e-02f, -4.25875783e-02f, -5.24801016e-02f, -7.25121051e-02f, -2.83917934e-02f, -1.29083797e-01f, -3.38840019e-03f,
  1.23319849e-01f, -3.25691879e-01f, -1.97645128e-01f, 2.24792719e-01f, 1.31750107e-01f, 1.65608436e-01f, 2.14973226e-01f, -1.31402433e-01f, 4.32443544e-02f, -1.41967610e-01f,
  8.07281211e-02f, -7.17596263e-02f, -1.77778184e-01f, 3.65858495e-01f, 2.77686983e-01f, 1.55876698e-02f, 3.06148916e-01f, 9.02168602e-02f, -1.70924123e-02f, -2.67245583e-02f,
  7.98317567e-02f, 3.39630663e-01f, -8.45905300e-03f, -3.68288271e-02f, 3.73953357e-02f, -1.28146224e-02f, 9.73874405e-02f, -1.72820687e-01f, 1.12254746e-01f, 1.12928845e-01f,
  1.54182464e-01f, -5.05229179e-03f, -2.79202946e-02f, 4.63580526e-02f, -2.45278068e-02f, 6.51092380e-02f, -6.87651988e-03f, 7.23130703e-02f, 4.22139056e-02f, -2.30108276e-02f,
  -7.14953616e-02f, -5.05764224e-03f, 4.84665222e-02f, 3.53010036e-02f, -5.20645753e-02f, -4.46046665e-02f, -7.22820088e-02f, -9.52225775e-02f, -2.70363092e-02f, -1.28295869e-01f,
  -6.07855804e-02f, -7.32582286e-02f, 4.44928892e-02f, 2.65094992e-02f, -1.20760435e-02f, 6.96965944e-05f, -9.51586962e-02f, -2.95187160e-02f, -1.27598479e-01f, 4.13536765e-02f,
  -6.86173066e-02f, 4.66759801e-02f, -3.14767212e-02f, 8.65742341e-02f, -7.91041479e-02f, 9.02549271e-03f, 1.81199219e-02f, 3.15309726e-02f, -3.61877866e-02f, -3.26697826e-02f,
  -2.82329451e-02f, -3.83887067e-02f, -3.02543472e-02f, 6.61007836e-02f, -3.05239391e-02f, -4.43828367e-02f, 8.24767649e-02f, 5.42174391e-02f, 7.45359212e-02f, -2.59122439e-02f,
  -5.52902976e-03f, 1.24728903e-02f, -6.30286634e-02f, 2.46104971e-02f, -3.84711437e-02f, 7.62941502e-03f, 6.00461885e-02f, -8.52532312e-02f, 4.42973189e-02f, 2.87135225e-02f,
  -5.49055710e-02f, -2.21339807e-01f, 5.22397319e-03f, -1.69339720e-02f, -8.41793492e-02f, -3.68217416e-02f, -3.52720134e-02f, 2.55530179e-02f, -1.28102023e-02f, 2.28313748e-02f,
  -7.30542615e-02f, 2.00294312e-02f, -3.94891389e-02f, -1.86841898e-02f, 8.53653997e-02f, 2.96347756e-02f, -7.75142685e-02f, 5.22243381e-02f, -6.88266680e-02f, -7.27621168e-02f,
  -2.75642015e-02f, -7.07024857e-02f, 2.45205183e-02f, -1.12997191e-02f, 5.51510789e-03f, -3.84023413e-02f, -4.35848124e-02f, -1.18879281e-01f, -8.77839997e-02f, 3.02440207e-02f,
  -4.65867102e-01f, 1.35002304e-02f, -7.78944343e-02f, -3.31370294e-01f, 2.76622981e-01f, 2.47479081e-01f, -1.44816771e-01f, 1.27102017e-01f, -3.06766659e-01f, 5.52761219e-02f,
  -1.62411630e-02f, -2.30982259e-01f, 6.19247779e-02f, -2.64112562e-01f, -3.10983717e-01f, -2.35463738e-01f, -2.28538811e-01f, -2.13119701e-01f, -2.04986021e-01f, -1.58271074e-01f,
  -1.51962012e-01f, 1.34442337e-02f, -1.70287296e-01f, 3.30617845e-01f, 7.86826015e-03f, 5.33683598e-02f, 1.66585028e-01f, 2.22726643e-01f, 1.42437071e-01f, 1.55267045e-01f,
  7.95142539e-03f, -8.42122361e-02f, -3.84765491e-02f, -1.38154635e-02f, 1.55864030e-01f, 2.66715754e-02f, -4.40171594e-03f, -3.61807942e-02f, -6.57574013e-02f, 6.19359454e-03f,
  2.98740324e-02f, 1.45708695e-01f, -7.05415681e-02f, -1.17030218e-02f, -2.63137259e-02f, 2.48450134e-02f, -3.03133354e-02f, -7.23452568e-02f, 2.42989021e-03f, 6.09481744e-02f,
  -3.45571339e-02f, 8.47241357e-02f, -1.95475784e-03f, -3.06584891e-02f, -5.91720752e-02f, 8.41462538e-02f, 1.30356653e-02f, -6.59174984e-03f, 4.03241441e-02f, -6.99779317e-02f,
  4.23336737e-02f, -3.50930281e-02f, -4.38833125e-02f, -8.08103941e-03f, -5.71824946e-02f, 3.11965533e-02f, -3.26555856e-02f, 3.91122000e-03f, 3.69220674e-02f, 1.23834396e-02f,
  4.09264602e-02f, -8.14732835e-02f, -3.72693501e-02f, 4.59602140e-02f, -4.90985289e-02f, -1.12432078e-01f, -4.35657846e-03f, -2.41422225e-02f, 6.87451055e-03f, -4.69219610e-02f,
  -2.76167821e-02f, -9.00920406e-02f, -6.58044312e-03f, -3.02336365e-02f, 6.51558042e-02f, 2.02975981e-02f, -2.72573382e-02f, 2.73638126e-03f, 1.42538222e-02f, 2.54547056e-02f,
  -7.86857828e-02f, -1.50359064e-01f, 6.06494136e-02f, -6.21623965e-03f, -3.96560803e-02f, 7.44130388e-02f, -4.07176726e-02f, -4.57468852e-02f, -2.86171176e-02f, 3.30340341e-02f,
  6.95308894e-02f, -2.93799080e-02f, 2.82241474e-03f, -4.39795330e-02f, 4.53353710e-02f, -7.36702457e-02f, 3.46917622e-02f, 3.54400985e-02f, 1.57568487e-03f, -1.66931991e-02f,
  -2.86546536e-02f, 2.06966195e-02f, 2.26933919e-02f, -1.94143243e-02f, 3.45568061e-02f, -3.22174504e-02f, 1.41804712e-02f, -3.17217261e-02f, 2.48582792e-02f, 8.53476748e-02f,
  1.65351436e-01f, 5.23144715e-02f, -4.35881317e-01f, -1.29858077e-01f, -2.97345847e-01f, 3.62334907e-01f, 5.71973920e-01f, -3.03644270e-01f, -5.16938940e-02f, 3.88259768e-01f,
  2.12735713e-01f, 1.07494863e-02f, 2.90744662e-01f, 4.33807641e-01f, 3.79423261e-01f, 5.47828376e-01f, 4.82869178e-01f, 4.14421469e-01f, -9.97398123e-02f, -9.78381708e-02f,
  -7.74765462e-02f, 3.07918042e-01f, -1.35464817e-01f, -1.65235475e-01f, -1.04906358e-01f, -4.70295697e-01f, -1.03862792e-01f, -3.01824331e-01f, 2.28410047e-02f, 1.02688476e-01f,
  7.87817314e-02f, -6.42988980e-02f, -1.25647724e-01f, -3.06526572e-02f, 6.18138276e-02f, 6.25232458e-02f, 1.64042041e-02f, 3.93691435e-02f, -1.66146204e-01f, -4.83194308e-04f,
  4.44445610e-02f, -6.11815229e-02f, -1.52255576e-02f, -8.63531977e-02f, -3.67968939e-02f, -1.67610571e-01f, -1.20611824e-01f, -1.87356412e-01f, -8.11922848e-02f, -8.51583853e-02f,
  -1.37202159e-01f, -5.06947264e-02f, -1.03031158e-01f, 7.92498663e-02f, -7.89676830e-02f, -1.61255915e-02f, 8.05948004e-02f, 1.56102916e-02f, 4.41865139e-02f, -8.93899612e-03f,
  6.94157630e-02f, 9.28185433e-02f, 9.04324949e-02f, 5.52141778e-02f, 1.79647952e-02f, -2.75887400e-02f, 3.84537540e-02f, 4.88890447e-02f, -5.65406457e-02f, 3.79803553e-02f,
  -2.97687780e-02f, -4.97742444e-02f, -2.46837214e-02f, -1.97234703e-03f, 7.29379728e-02f, 7.89235160e-03f, 4.27977815e-02f, -3.19157951e-02f, -3.01490948e-02f, -8.20797607e-02f,
  3.72566953e-02f, 3.06367725e-02f, -1.10506285e-02f, 1.60617661e-02f, 1.02022290e-01f, -1.02191593e-03f, 2.30078474e-02f, -3.22204083e-02f, -8.84654075e-02f, -3.37059982e-02f,
  1.09377481e-01f, 1.10295117e-01f, -6.96406215e-02f, 5.77224558e-03f, -5.75698866e-03f, 1.35709336e-02f, 7.43210465e-02f, -2.80114878e-02f, 6.97897449e-02f, 9.02442709e-02f,
  6.66802190e-03f, -1.26202954e-02f, 4.40099388e-02f, 1.84849724e-02f, -6.43184558e-02f, 9.38159674e-02f, 9.08232853e-02f, 4.59007407e-03f, -4.56502363e-02f, -8.53834450e-02f,
  -4.30380441e-02f, 3.12891975e-02f, 1.37566216e-02f, -1.95548474e-03f, -2.54120622e-02f, -5.70742832e-03f, -7.98216928e-03f, -8.69562551e-02f, -9.64859780e-03f, -2.61269957e-02f,
  -1.58035494e-02f, -2.32231200e-01f, -4.37882543e-01f, -1.79859072e-01f, 6.77742437e-02f, -3.92394662e-01f, -4.49647278e-01f, -1.17158726e-01f, -5.16479043e-03f, 1.36913329e-01f,
  -1.42226666e-01f, -7.81226158e-02f, 1.48303220e-02f, -6.09729528e-01f, -3.60212296e-01f, -1.32828742e-01f, -4.25681293e-01f, -1.60707146e-01f, -5.45259118e-02f, -1.53661415e-01f,
  -2.27429736e-02f, -2.41685271e-01f, -2.58360088e-01f, 8.47833678e-02f, -2.31333852e-01f, 1.53317735e-01f, 4.23614591e-01f, 6.82575777e-02f, -1.23934574e-01f, -5.66065796e-02f,
  -1.23126402e-01f, -1.52232587e-01f, -5.43131866e-02f, -5.94087243e-02f, -4.46229316e-02f, 4.96397056e-02f, -7.04462454e-03f, -7.96391536e-03f, 6.36211038e-02f, 1.31891128e-02f,
  7.51571283e-02f, -4.15507928e-02f, -1.51083618e-02f, 2.55277008e-02f, 5.97612113e-02f, -6.61215037e-02f, -8.92983973e-02f, -3.17076966e-03f, -9.85983312e-02f, -1.59386396e-01f,
  -1.62620842e-01f, -8.01691115e-02f, 1.67358276e-02f, -2.11495869e-02f, -9.83306393e-03f, 1.76097602e-02f, 1.45658432e-02f, 7.16530159e-03f, -6.38338132e-03f, 1.60038006e-02f,
  8.01692754e-02f, 1.41838714e-01f, -2.28747912e-02f, -4.65578996e-02f, -8.90524834e-02f, 2.24755872e-02f, -2.67381947e-02f, 7.85431191e-02f, 1.77923664e-02f, 3.10640372e-02f,
  6.02588579e-02f, -6.71013296e-02f, 1.95392538e-02f, 2.85491347e-02f, -2.31143218e-02f, 9.47375083e-05f, -4.37490158e-02f, -9.82685946e-03f, -5.07095195e-02f, -8.36416855e-02f,
  4.48305672e-03f, -1.32246520e-02f, -5.80908544e-02f, 3.38966250e-02f, -4.75144759e-02f, 3.95748243e-02f, 5.42050675e-02f, -2.09494289e-02f, 1.13260187e-02f, 6.32265583e-02f,
  1.85512193e-02f, 3.81493270e-02f, -1.21778361e-02f, -5.09355403e-02f, 3.01925987e-02f, 5.14247604e-02f, -8.58168304e-02f, -1.51980087e-01f, -7.33110607e-02f, -3.57930474e-02f,
  6.72637150e-02f, 6.58836961e-02f, 3.41974664e-03f, -4.72714379e-02f, 3.52459773e-02f, 3.59891653e-02f, 5.45019656e-02f, 7.50923455e-02f, 7.73474127e-02f, 2.06299010e-03f,
  5.30941561e-02f, 6.79362118e-02f, 6.04423061e-02f, 6.23823106e-02f, 9.13854688e-02f, 8.18751976e-02f, 1.09272078e-01f, 7.31093958e-02f, 5.02786972e-02f, 1.10101504e-02f,
  -6.29634500e-01f, 3.97124767e-01f, 1.34099454e-01f, -1.24811471e-01f, 5.54432683e-02f, 3.09107065e-01f, -4.52358602e-03f, 2.27524981e-01f, 1.74554557e-01f, 1.13228753e-01f,
  2.61636376e-02f, -2.28256091e-01f, 2.22287089e-01f, 1.13561988e-01f, -4.91543300e-02f, 2.83362776e-01f, 5.89667223e-02f, -1.23602431e-02f, 1.61801755e-01f, -3.12132612e-02f,
  -4.49659191e-02f, 9.19463858e-02f, 2.46576499e-02f, 2.18126580e-01f, -1.04411446e-01f, -1.70815453e-01f, -1.53937772e-01f, 9.50031132e-02f, -1.00318387e-01f, 4.62939255e-02f,
  -9.84951556e-02f, -2.61753500e-01f, -4.17820886e-02f, 4.83013969e-03f, -2.25413367e-02f, -8.58020037e-02f, -1.42595917e-01f, -1.07645234e-02f, -5.13305292e-02f, -1.43432850e-02f,
  -1.29386216e-01f, -1.67538431e-02f, -3.82510498e-02f, 9.91572663e-02f, 1.68478640e-03f, 4.99724969e-02f, 6.18182532e-02f, -1.70723833e-02f, -6.16212236e-03f, 7.14091063e-02f,
  8.42760578e-02f, 3.04060876e-02f, -7.81071093e-03f, 2.74382019e-03f, 4.12576646e-02f, -3.41547914e-02f, 2.46689469e-03f, -9.23806708e-03f, -1.06507530e-02f, 9.12957862e-02f,
  1.41395405e-02f, -1.41070969e-03f, -3.60427760e-02f, 1.35039128e-02f, 5.12500480e-02f, -2.54321098e-02f, 2.55235191e-02f, -3.21686007e-02f, -5.32348789e-02f, -7.66539760e-03f,
  -5.22331521e-02f, -8.09611082e-02f, -2.52141953e-02f, -1.94454212e-02f, -3.99812125e-02f, 4.18926263e-03f, -7.38943443e-02f, -3.87727842e-02f, 7.82219470e-02f, 3.01775280e-02f,
  3.35536040e-02f, -8.13586265e-02f, -5.87404072e-02f, -9.68638286e-02f, -5.86465225e-02f, -1.92912705e-02f, -3.62626240e-02f, -2.74141692e-02f, -9.06667090e-04f, -9.51493979e-02f,
  -1.57867134e-01f, -2.50649184e-01f, 3.15390304e-02f, -1.36512429e-01f, -4.10890393e-02f, -5.98806143e-02f, 7.63034634e-03f, 6.35424117e-03f, -2.61242315e-02f, -4.46044514e-03f,
  -9.15065110e-02f, 7.04430323e-03f, -6.19524531e-02f, 5.26187848e-03f, -5.14725409e-03f, 6.65954798e-02f, -5.02873138e-02f, -1.29759684e-01f, -6.81644166e-03f, 4.21327576e-02f,
  -5.24458550e-02f, 2.83290371e-02f, -8.35366920e-02f, -5.14261425e-02f, -1.49161397e-02f, -1.90342236e-02f, -1.96849313e-02f, 3.70167270e-02f, 3.64095271e-02f, 6.58756867e-02f,
  3.14796448e-01f, -7.18982369e-02f, 3.49682122e-01f, 1.95867449e-01f, -1.62096873e-01f, -3.06417763e-01f, -1.04706243e-01f, -3.16368669e-01f, -6.51476830e-02f, -3.58577460e-01f,
  -1.20319329e-01f, 4.18786556e-01f, 2.89193720e-01f, -1.70207441e-01f, 4.00430501e-01f, 7.61198848e-02f, -2.13702261e-01f, -9.88265499e-02f, 2.70764511e-02f, -7.55860358e-02f,
  9.31640118e-02f, -3.27140003e-01f, 2.95471638e-01f, -3.43119711e-01f, -5.27600870e-02f, 2.07769405e-02f, 4.44136225e-02f, 9.79498997e-02f, -2.85413593e-01f, -2.39949021e-02f,
  -1.17728882e-01f, 3.16769890e-02f, 7.03631788e-02f, -3.56098562e-02f, -8.11874419e-02f, -9.65514686e-03f, 1.14221200e-01f, 5.22870533e-02f, 1.79908685e-02f, -5.72229736e-03f,
  9.61126164e-02f, 8.28975514e-02f, -1.61943868e-01f, 9.39040557e-02f, -8.21189657e-02f, -1.15581177e-01f, 5.70059568e-02f, 1.26070946e-01f, 5.25664501e-02f, 1.87318668e-01f,
  2.05241844e-01f, 5.88450357e-02f, 5.74137494e-02f, 8.01845733e-03f, 4.26810607e-02f, -3.71341668e-02f, 4.44968604e-02f, 9.30731893e-02f, -7.38565624e-02f, 5.20328879e-02f,
  -1.62017867e-02f, -1.26774423e-03f, -4.58378159e-02f, -3.78318205e-02f, -4.96939868e-02f, -1.00908736e-02f, -2.44541327e-03f, 2.85802651e-02f, 1.00654038e-02f, -6.84730383e-03f,
  -1.64617859e-02f, 6.50797188e-02f, -8.59975291e-04f, -3.86376157e-02f, -8.56062248e-02f, 4.32500541e-02f, 8.28785747e-02f, -1.14514865e-01f, -4.76957858e-03f, 3.04412432e-02f,
  6.47107810e-02f, -3.76485065e-02f, -6.78833872e-02f, -1.07484553e-02f, -5.53326569e-02f, 5.03311381e-02f, 4.56998944e-02f, -1.99780278e-02f, 4.03620265e-02f, 6.46814331e-02f,
  -4.67233174e-02f, -6.15781024e-02f, -8.29479769e-02f, -1.93683747e-02f, -5.94854839e-02f, -5.63161075e-02f, -5.90046383e-02f, -6.87084943e-02f, 4.28990498e-02f, -5.16859852e-02f,
  -2.69952230e-02f, -1.51547352e-02f, 9.64295957e-03f, 4.01459858e-02f, 1.13442000e-02f, -4.73304242e-02f, 1.20221656e-02f, -8.25006589e-02f, -5.25482334e-02f, 1.91641636e-02f,
  2.18934636e-03f, 2.19996646e-03f, 7.76441172e-02f, -2.71463748e-02f, 4.20424715e-02f, 1.81797203e-02f, -2.89962012e-02f, 5.72724082e-02f, 1.07034341e-01f, 1.91464629e-02f,
  -1.62729733e-02f, 2.34743897e-02f, 1.87423099e-02f, 2.07569525e-01f, -1.12972371e-01f, -1.64477602e-01f, 3.97156691e-03f, 8.12401101e-02f, 2.44297355e-01f, -3.53619270e-02f,
  -2.73157693e-02f, 3.45495008e-02f, 4.23329175e-02f, 2.51233280e-01f, 2.04915747e-01f, 2.82042082e-02f, 2.57154286e-01f, 2.28763912e-02f, 9.64022130e-02f, 1.89277142e-01f,
  4.99577224e-02f, 2.32497290e-01f, 7.60757402e-02f, 1.53397983e-02f, -1.66991744e-02f, -2.36914847e-02f, 1.86742619e-01f, -1.64759248e-01f, 3.83517751e-03f, 6.09712154e-02f,
  -5.54927662e-02f, 4.40867469e-02f, -3.96492779e-02f, -1.02613926e-01f, 6.81745782e-02f, -1.93133771e-01f, -1.12169169e-01f, -6.14842214e-02f, 6.13680892e-02f, 5.31295016e-02f,
  -5.15685976e-02f, -1.21120483e-01f, -5.09243309e-02f, 4.30853330e-02f, -8.08983594e-02f, 2.05875821e-02f, -4.41211127e-02f, -1.99348852e-02f, -1.13309547e-02f, -1.55277327e-01f,
  -5.46134822e-02f, 9.16056633e-02f, 8.27467665e-02f, -4.47688662e-02f, 7.25144893e-02f, -1.58129353e-03f, 5.52608259e-02f, -3.37131508e-02f, -6.83471188e-03f, -2.80344915e-02f,
  1.61622092e-02f, -2.59342492e-02f, -6.24082014e-02f, -3.37905362e-02f, -2.85294820e-02f, 6.20885491e-02f, 1.29998131e-02f, -3.05690657e-04f, 1.72325075e-02f, 1.01769296e-02f,
  -1.80953592e-02f, 1.12648480e-01f, 7.62463138e-02f, 2.41475739e-02f, 6.69061169e-02f, 1.27215004e-02f, -8.77300054e-02f, -9.97742042e-02f, 2.81861611e-02f, -8.38399678e-02f,
  -5.77187575e-02f, 5.93092106e-02f, -1.61147118e-02f, -1.21596619e-01f, 4.37481236e-03f, -7.17892721e-02f, 7.77121782e-02f, -2.73020864e-02f, 3.57840285e-02f, 2.49549225e-02f,
  8.35371837e-02f, 4.46707815e-01f, 1.38587290e-02f, -9.67379734e-02f, -4.77757566e-02f, 5.09802951e-03f, 4.23413366e-02f, 6.64408356e-02f, 3.50541361e-02f, -5.32853492e-02f,
  -4.74301688e-02f, -7.24473521e-02f, -1.95943341e-02f, -3.37030664e-02f, 6.28959388e-02f, 7.35426992e-02f, 2.30889283e-02f, 6.63350075e-02f, 1.48542345e-01f, -1.31662935e-02f,
  4.63322736e-02f, 1.75421666e-02f, 5.04345372e-02f, 5.56465574e-02f, 2.30897348e-02f, 9.91050620e-03f, 6.75207078e-02f, 2.43250169e-02f, 1.08039221e-02f, 1.01202317e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.87723094e-01f, 1.55245408e-01f, 1.42404526e-01f, 3.88104498e-01f, 4.41907436e-01f, 4.21019226e-01f, 3.22371215e-01f, 1.81084201e-01f, 3.08635503e-01f, 6.66166961e-01f,
  2.21131846e-01f, 2.27264524e-01f, 4.29042041e-01f, 1.56436637e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.33524188e-02f, -4.05260772e-02f, -3.63786966e-01f, -8.55294168e-02f, -1.47383228e-01f, -3.59430686e-02f, -7.11327493e-02f, 2.44250689e-02f, -4.33012784e-01f, -4.20960069e-01f,
  -2.50675648e-01f, -6.00054920e-01f, -3.23907375e-01f, -2.82236934e-01f, 4.19070899e-01f, 5.73254466e-01f, 1.31403968e-01f, -5.23194551e-01f, -2.59767771e-01f, 3.99269640e-01f,
  -2.11328402e-01f, -2.78307408e-01f, -5.05159199e-01f, -3.36761117e-01f, 4.37981427e-01f, 2.99200803e-01f, -2.20577702e-01f, 9.51529443e-01f, -2.34149754e-01f, 4.20054585e-01f,
  -2.79604912e-01f, 3.05967609e-04f, -1.61583811e-01f, 5.13955951e-02f, 2.68627614e-01f, -2.85019755e-01f, -3.21832418e-01f, -4.59099352e-01f, 3.18547070e-01f, -3.34041893e-01f,
  -3.70624624e-02f, -6.05771661e-01f, 4.04126495e-01f, 2.87524253e-01f, 5.94284654e-01f, -7.07180142e-01f, 6.73989713e-01f, -4.37695414e-01f, 4.69929039e-01f, -8.89915079e-02f,
  -4.27012652e-01f, -3.85302722e-01f, -1.85960352e-01f, 5.26707232e-01f, 1.12966802e-02f, -4.80571277e-02f, -5.20177543e-01f, 3.25110257e-01f, -1.58178091e-01f, 9.08386350e-01f,
  6.15075007e-02f, 4.99361940e-02f, -2.57882535e-01f, 1.11284159e-01f, 1.45276383e-01f, 1.51838839e-01f, 9.88255218e-02f, 4.49717455e-02f, -1.81547161e-02f, 9.19190794e-02f,
  -9.34000075e-01f, -6.26740530e-02f, -1.54843330e-01f, 3.85997593e-01f, -1.10004254e-01f, -3.50166053e-01f, 1.38527021e-01f, -8.33504945e-02f, 1.87731102e-01f, -5.40380776e-01f,
  4.68141772e-02f, 1.90656751e-01f, 6.34396911e-01f, 7.91288540e-03f, -3.17369640e-01f, 7.61970043e-01f, -3.67297024e-01f, -2.79811949e-01f, -3.24907601e-01f, 6.55313909e-01f,
  2.03609720e-01f, -1.98037416e-01f, -1.76955059e-01f, -1.55407026e-01f, -3.63915443e-01f, -2.11788695e-02f, -5.60195148e-02f, 1.82938129e-01f, -2.41944671e-01f, -3.20301890e-01f,
  -1.38200015e-01f, -1.58317849e-01f, 9.08256620e-02f, 8.43006894e-02f, -3.68180573e-01f, -3.45088333e-01f, 2.35290945e-01f, -4.28030282e-01f, -1.66136429e-01f, 4.29487050e-01f,
  -2.25921333e-01f, 2.24569440e-01f, -4.80003178e-01f, -1.80556461e-01f, -2.51244366e-01f, -1.81865811e-01f, 1.25734234e+00f, -3.90900880e-01f, -2.35353485e-01f, -1.53012037e-01f,
  1.35236204e-01f, -2.08995789e-01f, 3.43844324e-01f, -3.89330000e-01f, 1.93968341e-01f, 3.35358173e-01f, -3.66701245e-01f, -5.77730313e-02f, 5.36202967e-01f, 3.17381054e-01f,
  1.56844407e-01f, 5.45586407e-01f, 4.86846089e-01f, 6.19885400e-02f, 4.51091021e-01f, -4.76110637e-01f, -9.82498284e-03f, 1.76987514e-01f, 3.54519226e-02f, -1.92051396e-01f,
  1.08654760e-01f, -3.18086863e-01f, -7.91684568e-01f, -1.27233312e-01f, -7.10480809e-01f, -8.84801745e-01f, -2.03134313e-01f, 4.46670055e-01f, -2.85824776e-01f, -1.49024606e-01f,
  3.10445309e-01f, -4.00097311e-01f, 3.38411689e-01f, -2.91626394e-01f, 4.34647113e-01f, -2.94064999e-01f, -5.40143430e-01f, 7.35468924e-01f, -9.35553014e-02f, -4.14019704e-01f,
  3.97427738e-01f, -6.28570914e-02f, 3.43834013e-02f, -2.01720148e-01f, 5.01499832e-01f, 3.30549568e-01f, -1.17440941e-02f, 1.92867637e-01f, 2.56403774e-01f, -1.52216211e-01f,
  -3.59760895e-02f, 7.35505700e-01f, 4.98529524e-01f, 1.57027990e-01f, -2.12117806e-01f, 9.71020937e-01f, -3.20052743e-01f, 2.40169868e-01f, -4.34326939e-02f, -2.64401704e-01f,
  -3.46004039e-01f, -2.62128711e-01f, 1.44791096e-01f, 7.77716458e-01f, 2.83172190e-01f, -1.24706194e-01f, -3.98070008e-01f, 6.02217972e-01f, -3.46694499e-01f, 1.22601308e-01f,
  -2.66196311e-01f, 3.19598287e-01f, -3.34131300e-01f, -8.59537572e-02f, -3.29737991e-01f, 1.48066759e-01f, 1.83317259e-01f, -1.66106313e-01f, -2.36853823e-01f, 8.49149302e-02f,
  -9.49915946e-02f, 3.77488524e-01f, -6.04425788e-01f, 5.66831350e-01f, 4.08764035e-01f, -2.25236624e-01f, 1.39256254e-01f, -9.28345680e-01f, 2.39836559e-01f, 4.05459911e-01f,
  5.28819621e-01f, -3.48600030e-01f, -2.88796335e-01f, -4.81144756e-01f, 7.60496557e-01f, 7.61367083e-01f, -3.78028214e-01f, 2.88990587e-01f, -2.47006491e-01f, -5.05791247e-01f,
  6.05506860e-02f, -6.10413402e-02f, -3.85154709e-02f, 1.93515439e-02f, -4.19725806e-01f, -4.05473262e-01f, -2.26607054e-01f, -1.49706155e-01f, -1.06208296e-02f, -4.94960517e-01f,
  1.43843750e-02f, -1.69420943e-01f, -1.14557818e-01f, 3.54629070e-01f, -2.77871281e-01f, -4.33185436e-02f, 2.49550417e-01f, -1.19706877e-01f, -5.25467873e-01f, 2.23329477e-03f,
  -2.84820229e-01f, 2.33943686e-01f, -1.69226870e-01f, 2.32407212e-01f, 4.22184199e-01f, 1.89123198e-01f, 1.94944382e-01f, 5.28980717e-02f, 5.52326143e-01f, -9.74373966e-02f,
  -1.06532998e-01f, -7.50050042e-03f, 8.22044075e-01f, -1.89506546e-01f, 4.32470441e-01f, 1.44314226e-02f, 9.27224755e-02f, -5.44688344e-01f, -4.57514636e-02f, -1.93167225e-01f,
  5.58378696e-02f, -2.06967384e-01f, 9.94710177e-02f, -2.19608605e-01f, -2.23261770e-02f, -2.13137612e-01f, 3.15268576e-01f, -3.15194696e-01f, -1.67202920e-01f, 1.23326235e-01f,
  -5.18667638e-01f, -2.47078210e-01f, 3.76932412e-01f, 8.07652771e-02f, -4.07584935e-01f, 1.70244098e-01f, -2.63736069e-01f, 1.05506933e+00f, -3.72645110e-01f, 4.37779576e-01f,
  -2.71729261e-01f, -9.46914479e-02f, -3.28153789e-01f, -4.32333291e-01f, -2.08904088e-01f, -7.30697811e-02f, 3.77621084e-01f, 5.49137115e-01f, -9.44936275e-02f, -9.83340964e-02f,
  -1.32149994e-01f, -4.51927772e-03f, -3.42688054e-01f, 2.32033253e-01f, 1.46137133e-01f, 1.63725931e-02f, 2.13474497e-01f, 8.34979936e-02f, 3.74246299e-01f, 2.28956550e-01f,
  -5.09062409e-01f, -5.93662322e-01f, -2.17110544e-01f, 8.72494727e-02f, -2.09406123e-01f, 3.36738005e-02f, 1.01140428e+00f, 2.57160306e-01f, -4.08328414e-01f, -4.80993897e-01f,
  5.12561142e-01f, -5.16154051e-01f, 1.73433628e-02f, 1.65979132e-01f, -1.60827607e-01f, 1.46268293e-01f, -2.59440958e-01f, -3.13183188e-01f, 7.08354950e-01f, -2.92681485e-01f,
  -3.33801776e-01f, -3.51648629e-01f, 2.87009656e-01f, 1.62603453e-01f, 3.52957278e-01f, 3.83164614e-01f, 2.87171751e-01f, -8.02614093e-02f, 2.52200991e-01f, -7.25315690e-01f,
  4.75911230e-01f, 3.13542426e-01f, -3.66168946e-01f, 3.16409528e-01f, 2.48018637e-01f, -5.24610341e-01f, 6.68449879e-01f, 1.15987070e-01f, -4.48992491e-01f, 8.26057047e-02f,
  1.60019681e-01f, 5.61384410e-02f, -2.92422861e-01f, -3.92776668e-01f, -3.61713737e-01f, -2.33852759e-01f, 6.59376800e-01f, -4.08096045e-01f, 7.54022300e-01f, -3.50231171e-01f,
  -4.63795215e-01f, -2.09083959e-01f, 1.19783133e-01f, 5.07065535e-01f, 3.91822368e-01f, 4.37049478e-01f, -7.64740527e-01f, 2.82095611e-01f, 1.93032980e-01f, 4.25524384e-01f,
  1.42909214e-01f, 8.21395278e-01f, -3.34221393e-01f, -4.54092920e-01f, -2.87367851e-02f, 8.35685015e-01f, 6.09203637e-01f, 9.05718267e-01f, 2.53209889e-01f, 5.25304258e-01f,
  -3.70877624e-01f, -2.90128499e-01f, -2.40686253e-01f, -5.06442368e-01f, 3.42293531e-02f, 1.93958923e-01f, -3.82087022e-01f, -2.88412422e-01f, -2.03325257e-01f, -5.93141198e-01f,
  2.42992081e-02f, -2.47380838e-01f, 4.88244861e-01f, -2.40165666e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.36717185e-01f, 1.49128109e-01f, -1.21483363e-01f, -1.63934126e-01f, 3.16885620e-01f, -7.63235614e-02f, 8.20884183e-02f, -3.49682391e-01f, -1.16494395e-01f, 5.64116938e-03f,
  1.20040812e-01f, 5.80623209e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    