/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.71134099e-01f, -1.12023778e-01f, -2.36342326e-01f, -1.34095803e-01f, 1.17136844e-01f, -3.73208761e-01f, -5.49667656e-01f, -4.22498167e-01f, -4.04721039e-04f, -2.14929819e-01f,
  3.05593610e-01f, 3.58226836e-01f, 1.30223036e-01f, -5.28356396e-02f, -3.79838020e-01f, -6.75633430e-01f, -7.51168907e-01f, -5.61337292e-01f, -3.15142065e-01f, -3.48028570e-01f,
  -1.82560891e-01f, -1.03832878e-01f, -2.46909723e-01f, -2.19104469e-01f, 1.35857865e-01f, 1.97296128e-01f, 1.72311947e-01f, 5.09912968e-02f, -1.60954699e-01f, -4.57892306e-02f,
  3.34533788e-02f, -2.08823323e-01f, -1.20296106e-01f, 4.73677032e-02f, 2.00216711e-01f, -1.03314087e-01f, -9.33528990e-02f, -1.48373231e-01f, -4.02033366e-02f, -1.43593401e-01f,
  9.96593460e-02f, -2.94488072e-02f, -1.82454720e-01f, -3.51171382e-02f, -6.25889748e-02f, -9.30119008e-02f, -2.30271697e-01f, -1.68099627e-01f, -1.76135436e-01f, -1.41497627e-01f,
  -2.46526673e-02f, -2.11234003e-01f, -1.99944019e-01f, -2.23226413e-01f, -2.38027334e-01f, -1.03524633e-01f, -2.80079152e-02f, -2.02093303e-01f, -1.23268194e-01f, -1.20803379e-01f,
  -3.65348607e-02f, 1.67309910e-01f, 1.78901628e-01f, 1.29507273e-01f, 2.13970467e-01f, 1.37463406e-01f, 7.59035498e-02f, 1.21440031e-01f, 1.65596142e-01f, 1.56481981e-01f,
  1.30814329e-01f, 1.35154366e-01f, 4.02967595e-02f, 1.74024329e-02f, 6.77193105e-02f, 1.45046964e-01f, 1.26507431e-01f, 1.38920709e-01f, 9.73493159e-02f, 1.23959534e-01f,
  9.48838741e-02f, 1.08445533e-01f, 1.50213629e-01f, 1.50015503e-01f, 4.21974659e-02f, 5.05317152e-02f, 1.52448088e-01f, 3.51441532e-01f, 1.67043492e-01f, 7.71988928e-02f,
  7.65635371e-02f, -7.01569617e-02f, -7.38523453e-02f, -2.36294985e-01f, -3.84475514e-02f, -5.44027686e-02f, -1.93180423e-02f, -1.07089065e-01f, 2.98871449e-03f, -8.62691253e-02f,
  -1.20132670e-01f, -1.56806171e-01f, -9.39404070e-02f, -7.89165571e-02f, -1.90345347e-01f, -8.23131874e-02f, -2.25422606e-01f, -1.01447865e-01f, -1.40488282e-01f, 6.73093041e-03f,
  -1.93283543e-01f, -2.94751316e-01f, -1.85414284e-01f, -1.62499741e-01f, -1.33476153e-01f, -1.67011529e-01f, -9.17502418e-02f, -4.62128371e-02f, -2.55668402e-01f, -3.00438255e-01f,
  1.42972842e-01f, -6.00621521e-01f, -4.13066983e-01f, 2.12484285e-01f, 2.11288169e-01f, -1.31927803e-02f, -1.60061315e-01f, -7.94330761e-02f, 8.95920992e-02f, -1.99063331e-01f,
  -1.59584031e-01f, 2.24510118e-01f, 6.66947849e-03f, -4.73226747e-03f, -4.93250601e-02f, -2.31551573e-01f, 3.80908363e-02f, 2.48284727e-01f, 3.79151046e-01f, 2.06918657e-01f,
  1.10526241e-01f, 7.97806531e-02f, 9.66583341e-02f, 1.75519258e-01f, 1.07918687e-01f, 1.98806569e-01f, -2.20773026e-01f, 5.16654886e-02f, 1.79406852e-02f, 2.42577717e-01f,
  -1.87940374e-01f, -1.74959134e-02f, 4.31041680e-02f, 1.76642165e-01f, -1.65346786e-01f, -1.54778466e-01f, -2.64723208e-02f, -5.51389530e-02f, -6.69551417e-02f, -3.05573493e-02f,
  9.76908207e-02f, 5.69043346e-02f, 6.67645335e-02f, 3.42117697e-02f, 1.31433047e-02f, 2.82146987e-02f, 5.10830432e-02f, -1.86519697e-02f, -3.06713432e-02f, -1.05062515e-01f,
  1.30608818e-02f, 1.80359080e-01f, 3.05247456e-02f, -4.32250574e-02f, -2.72913333e-02f, 2.27334723e-01f, -8.67660269e-02f, 1.19330607e-01f, -3.86741050e-02f, -1.84669897e-01f,
  6.48906603e-02f, -9.17597190e-02f, -4.66934107e-02f, -1.09898470e-01f, 3.66925970e-02f, 7.57551938e-02f, 3.14709693e-02f, 2.67089605e-02f, 5.48705049e-02f, -2.06276076e-03f,
  4.67809997e-02f, -7.67220706e-02f, -7.54528195e-02f, -5.46947494e-02f, 2.43076682e-02f, -5.07248864e-02f, 9.37867984e-02f, -7.86676854e-02f, -6.46176487e-02f, 3.81913707e-02f,
  7.71988705e-02f, 1.11519761e-01f, -5.27485497e-02f, 1.85587052e-02f, -7.80763999e-02f, -1.52612217e-02f, 3.29368673e-02f, 4.40169945e-02f, 3.40045020e-02f, 7.62229487e-02f,
  -1.62071988e-01f, -9.84866023e-02f, -1.46196678e-01f, -1.03387823e-02f, -6.72547519e-02f, -4.07403223e-02f, -6.29852340e-02f, -6.79016933e-02f, -5.25060967e-02f, -6.15270101e-02f,
  -1.26316343e-02f, -1.79687031e-02f, -1.34696439e-01f, -2.00553313e-02f, 2.42065117e-02f, -1.55981947e-02f, -8.02641958e-02f, -2.35555805e-02f, -4.43845056e-02f, -1.66190594e-01f,
  -7.39957318e-02f, 1.06470881e-03f, -1.27968937e-01f, -5.78763448e-02f, -5.89771010e-02f, 2.25590970e-02f, -3.27214628e-01f, -1.03731409e-01f, -1.68634951e-01f, -3.26986879e-01f,
  7.09388018e-01f, 1.13514148e-01f, 3.63914520e-01f, 1.40396729e-01f, -3.80778342e-01f, -8.57047830e-03f, 2.04312637e-01f, 7.37354085e-02f, -6.28573969e-02f, 8.60135108e-02f,
  -2.65477479e-01f, -1.30470514e-01f, 6.62432984e-02f, -5.77822924e-02f, 1.00172676e-01f, 2.67343253e-01f, 2.64011264e-01f, 3.72752815e-01f, 3.43500003e-02f, -2.09109247e-01f,
  -3.09661359e-01f, -8.29263479e-02f, 2.32947841e-02f, 4.85430621e-02f, -5.59719056e-02f, -7.00689405e-02f, 9.77151766e-02f, 1.13894939e-01f, -6.57123281e-03f, 2.97760397e-01f,
  3.26352090e-01f, 2.18157157e-01f, -6.65599704e-02f, -1.46805823e-01f, -1.48210675e-01f, 1.60402358e-01f, 6.74981475e-02f, 1.11257836e-01f, -7.83163011e-02f, 8.19997191e-02f,
  -1.12651445e-01f, -7.66549855e-02f, -1.04994647e-01f, -8.58276784e-02f, 5.84189333e-02f, -1.68339312e-02f, 8.68443679e-03f, 1.79274470e-01f, 8.32472071e-02f, 1.58957038e-02f,
  -1.58903345e-01f, -1.01324432e-01f, 1.85863987e-01f, -4.87350859e-03f, 4.57435213e-02f, 3.93954478e-03f, 1.29129579e-02f, -2.16293614e-03f, 1.51027098e-01f, 2.32469752e-01f,
  -6.58386126e-02f, -3.08445897e-02f, -3.39996889e-02f, -5.65030575e-02f, 1.48667628e-02f, 5.36797270e-02f, 3.89749147e-02f, -8.27837735e-02f, -4.88331355e-02f, 6.92503154e-02f,
  3.41937430e-02f, 1.43987099e-02f, 3.32787670e-02f, 8.53893310e-02f, -1.18116796e-01f, -4.31217887e-02f, 2.23985482e-02f, -6.83361366e-02f, -9.57894772e-02f, -8.74014497e-02f,
  -4.45515960e-02f, -4.36001010e-02f, 1.34882424e-02f, -5.55492751e-02f, -7.32124746e-02f, 5.42354770e-02f, 1.93196591e-02f, -2.17320286e-02f, 1.63248219e-02f, 4.01703082e-02f,
  7.23796040e-02f, -2.81367332e-01f, 2.12613672e-01f, 6.23794496e-02f, 4.10519764e-02f, 2.83382181e-02f, -4.40968983e-02f, -1.01797014e-01f, -4.85474132e-02f, 5.15150838e-02f,
  -5.24029881e-02f, 5.77940829e-02f, 4.07819226e-02f, -5.63625768e-02f, -6.58399835e-02f, -9.75204166e-03f, -8.65980983e-02f, 1.43649466e-02f, -3.21077295e-02f, -4.94550392e-02f,
  -7.50667974e-02f, 1.58020005e-01f, 2.60072768e-01f, 1.15836136e-01f, 1.56432185e-02f, 1.45618930e-01f, 1.90432265e-01f, 1.31093517e-01f, 1.34482518e-01f, 3.41538459e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.53153539e-01f, 2.34195247e-01f, -5.19212723e-01f, -3.22571546e-01f, 5.01483738e-01f, 7.94673026e-01f, 1.43122196e+00f, 8.25287938e-01f, 3.67462672e-02f, 2.85266787e-01f,
  -2.90216714e-01f, -9.08627987e-01f, -1.19298029e+00f, -6.79643214e-01f, 6.80565014e-02f, 6.91803753e-01f, 2.10056707e-01f, -6.79127932e-01f, -7.29897246e-02f, 9.59515095e-01f,
  6.57060504e-01f, 6.40618876e-02f, -4.38432217e-01f, -6.37275577e-02f, -2.35231116e-01f, -5.49760461e-01f, -3.58228654e-01f, -3.09745878e-01f, 1.27131835e-01f, -6.35794759e-01f,
  -7.78102398e-01f, -3.14933881e-02f, 1.61641821e-01f, -2.50453651e-01f, -1.59446895e-01f, -5.97139113e-02f, 6.06820583e-02f, -2.70784736e-01f, -9.54302102e-02f, 4.78224829e-03f,
  -3.48325878e-01f, -8.99945498e-02f, -5.52576125e-01f, -1.95502445e-01f, -1.67592257e-01f, -2.81928405e-02f, -1.06305443e-01f, -6.00685440e-02f, -4.82891321e-01f, 1.05459131e-01f,
  3.03059250e-01f, 5.04610799e-02f, -1.86425626e-01f, 2.15038627e-01f, 2.02009112e-01f, -3.62100542e-01f, 2.14335784e-01f, -4.95417118e-02f, -1.90036520e-02f, -3.70570600e-01f,
  1.29755706e-01f, -1.62709996e-01f, 1.04919806e-01f, 4.07356806e-02f, 6.36532903e-02f, 1.75308466e-01f, -1.57909200e-01f, -3.00821941e-02f, -8.02033246e-02f, 1.88749880e-02f,
  6.32122010e-02f, -1.11161143e-01f, -1.05311714e-01f, 5.13043394e-03f, -2.48556927e-01f, -7.49686733e-02f, 1.56612452e-02f, 2.17304483e-01f, -6.51530772e-02f, -8.07220936e-02f,
  -1.54644981e-01f, -1.44243687e-02f, -1.11147694e-01f, -3.67442444e-02f, 1.25554785e-01f, 2.92499792e-02f, -4.88167070e-02f, 1.07652448e-01f, -1.42380714e-01f, 9.60389376e-02f,
  -4.99776602e-01f, 2.93648392e-01f, -5.83299518e-01f, 2.35097464e-02f, -2.82973275e-02f, 1.70139186e-02f, -1.80969536e-01f, -4.27088849e-02f, -1.08768836e-01f, -3.67132202e-02f,
  1.09548405e-01f, -5.37318178e-02f, -7.00613633e-02f, 2.00174391e-01f, -3.39446124e-03f, 7.63657875e-03f, 3.69606704e-01f, -1.10558897e-01f, 2.46860206e-01f, -1.64082814e-02f,
  2.03370526e-01f, 1.83392495e-01f, -7.86792263e-02f, -1.81655705e-01f, 6.29097894e-02f, -1.96785092e-01f, -1.01855896e-01f, 2.46272259e-03f, 7.44421082e-03f, 2.78659523e-01f,
  1.06332564e+00f, 7.05977082e-01f, 6.37358308e-01f, 6.69001415e-02f, -2.22860292e-01f, -2.10938439e-01f, 6.68881238e-02f, 8.94836262e-02f, -2.16584429e-01f, 1.94343910e-01f,
  6.49467483e-02f, -1.88146532e-01f, -2.89642632e-01f, -2.23462209e-02f, 2.46022463e-01f, -1.00181952e-01f, -1.10634476e-01f, 3.90849948e-01f, 1.46260664e-01f, -9.73625928e-02f,
  -2.59180844e-01f, 3.99704486e-01f, 6.43236399e-01f, 1.37593061e-01f, -6.53145239e-02f, -4.23479319e-01f, -3.28267440e-02f, 1.24484688e-01f, 2.94617331e-03f, 1.68640986e-01f,
  4.66277868e-01f, 5.48436224e-01f, -5.05392432e-01f, -1.54517457e-01f, 8.70981514e-02f, 9.91172716e-02f, 1.82408653e-02f, 5.01030944e-02f, -1.07087903e-01f, -1.79806963e-01f,
  -5.51937856e-02f, 6.08369894e-02f, -8.27798024e-02f, -4.16617505e-02f, 6.01566136e-02f, -2.95312535e-02f, 5.78164011e-02f, -7.41577893e-02f, -2.83993054e-02f, 6.69313520e-02f,
  -1.31603003e-01f, -4.85320501e-02f, 1.19059561e-02f, -2.28032842e-01f, -4.14444506e-02f, -2.68167198e-01f, -5.48617579e-02f, -3.98694016e-02f, -1.37579978e-01f, -1.76923975e-01f,
  -1.76844299e-01f, 2.15446614e-02f, -5.48548810e-02f, -5.72625585e-02f, 1.14181869e-01f, -6.98835924e-02f, -9.34530050e-02f, 9.54143424e-03f, -2.04109717e-02f, 1.07707277e-01f,
  -1.42333776e-01f, -1.11705083e-02f, 2.23080069e-02f, -1.14786588e-01f, -1.65601343e-01f, 2.44392350e-01f, 3.00503701e-01f, 6.59064576e-02f, -8.02100077e-02f, 9.67103541e-02f,
  -7.29136262e-03f, -1.54676363e-02f, 5.34612760e-02f, -7.03146011e-02f, -2.29623467e-01f, -1.89398572e-01f, -1.21683985e-01f, -8.90482068e-02f, -6.30921572e-02f, -3.18777487e-02f,
  -3.27802390e-01f, 1.21757485e-01f, 5.55056594e-02f, 1.40746713e-01f, 1.19666465e-01f, 1.24566607e-01f, 6.15477934e-02f, 3.05862781e-02f, 1.09572820e-01f, 8.80836770e-02f,
  9.23648775e-02f, 1.54217288e-01f, 2.29861557e-01f, 1.10350557e-01f, -7.59773254e-02f, -3.42307077e-03f, 1.69420049e-01f, 1.57334134e-01f, 1.26551107e-01f, 2.13992432e-01f,
  7.33648464e-02f, -1.77716553e-01f, -1.44032538e-01f, -2.51239538e-01f, -8.19551796e-02f, -3.45868498e-01f, -1.40984535e-01f, -7.47954771e-02f, -1.74004212e-01f, -4.08080876e-01f,
  1.45807827e+00f, -5.72084606e-01f, -5.98925233e-01f, 1.89121991e-01f, -1.26481339e-01f, -4.98993099e-02f, -2.52966076e-01f, 4.10140678e-02f, 1.31929368e-01f, -1.54146716e-01f,
  2.32691616e-01f, 5.08838177e-01f, 4.45365638e-01f, 1.74773514e-01f, 2.81802922e-01f, -4.75850016e-01f, -5.24621010e-01f, 4.61803004e-02f, 2.38600194e-01f, 2.24617973e-01f,
  -5.79386614e-02f, 2.02341583e-02f, 4.29919988e-01f, 8.21563043e-03f, -4.35365856e-01f, 5.66737202e-04f, -3.54267627e-01f, -1.32802933e-01f, -2.69437313e-01f, -6.22036338e-01f,
  -4.74119008e-01f, 1.63841635e-01f, 3.40183228e-02f, 1.04977272e-01f, -6.33476824e-02f, 1.76625419e-02f, 4.87173982e-02f, -8.94753262e-02f, 7.58474916e-02f, -1.69837609e-01f,
  2.30008606e-02f, -7.04852492e-02f, 4.90308702e-02f, -1.28307611e-01f, -4.42135148e-02f, -8.17028508e-02f, 5.65027818e-02f, -2.83640251e-02f, -1.33854508e-01f, -1.26912668e-01f,
  -1.37544170e-01f, 1.24222465e-01f, 8.85851532e-02f, 6.26712516e-02f, 1.96487799e-01f, 1.43655896e-01f, -5.94802685e-02f, 6.87227026e-02f, 8.72164294e-02f, -4.31839861e-02f,
  3.31973247e-02f, -5.52766472e-02f, 9.74772498e-02f, 7.11616725e-02f, 1.93966702e-01f, -1.37838498e-02f, -4.71753031e-02f, 4.78834398e-02f, 8.72736201e-02f, -1.71005186e-02f,
  -7.29507431e-02f, 4.59749028e-02f, 4.05231081e-02f, -1.48121612e-02f, -3.23350243e-02f, -1.43808544e-01f, -1.99708194e-02f, -5.24601452e-02f, 1.96960509e-01f, 3.36691774e-02f,
  1.69283316e-01f, -2.56596934e-02f, -9.04167444e-02f, -1.26633197e-01f, -7.76720047e-02f, -1.47440746e-01f, -5.69018386e-02f, 1.29331186e-01f, -8.06565210e-02f, -2.36617234e-02f,
  1.99698322e-02f, 4.22514707e-01f, -1.61225442e-02f, 5.78105114e-02f, -9.40827578e-02f, -1.45464405e-01f, 3.79583165e-02f, -3.88053991e-02f, -2.20809877e-01f, -9.31378528e-02f,
  2.50651203e-02f, 2.31620707e-02f, -4.08884250e-02f, -7.12788850e-02f, 1.07027285e-01f, 1.03705160e-01f, 1.15033604e-01f, 7.17598051e-02f, -1.33444995e-01f, -2.23771185e-01f,
  -1.12982959e-01f, 1.34073004e-01f, 2.03776807e-01f, 3.42285708e-02f, 1.44301429e-01f, 2.76946396e-01f, -2.17613280e-02f, -1.08277693e-01f, 1.54135942e-01f, -7.06059262e-02f,
  1.27918768e+00f, 5.92835069e-01f, -1.35004926e+00f, 1.24100113e+00f, -3.57112110e-01f, -8.85805190e-01f, -5.67811251e-01f, 1.90113693e-01f, 5.36220849e-01f, 3.78063828e-01f,
  -2.65639424e-01f, -9.29290429e-02f, -2.87150621e-01f, -5.77733457e-01f, -8.11929166e-01f, -3.39103580e-01f, -5.02734900e-01f, -1.00811589e+00f, -1.00557077e+00f, 2.57359147e-02f,
  5.23558676e-01f, 8.14377308e-01f, 5.88222027e-01f, -1.25961572e-01f, 5.47239363e-01f, -2.14121625e-01f, 2.52292175e-02f, 3.83569449e-01f, -3.90016764e-01f, 4.97508734e-01f,
  1.21897524e-02f, 2.84762800e-01f, -7.14451671e-01f, -1.93436846e-01f, -1.42389715e-01f, 1.81689218e-01f, 3.65773737e-02f, -1.22445658e-01f, 2.74201967e-02f, 2.24270940e-01f,
  -1.01629168e-01f, -6.58870628e-03f, -1.67594939e-01f, 2.24125516e-02f, 2.89294511e-01f, 5.09016402e-02f, 9.13813785e-02f, -5.43875210e-02f, -2.88753629e-01f, -1.21594943e-01f,
  -2.00131093e-03f, -2.76222348e-01f, -8.17714274e-01f, -3.23843598e-01f, -3.16073149e-01f, -2.27938160e-01f, -1.18980337e-04f, -6.41542971e-02f, -5.53914845e-01f, 7.69475222e-01f,
  3.37245613e-02f, -9.20842518e-04f, -1.12320080e-01f, 7.41918460e-02f, 1.66445747e-01f, -7.92440102e-02f, 5.52029014e-02f, 6.77411184e-02f, 5.23278341e-02f, 6.75855950e-02f,
  -2.45875850e-01f, -8.91005038e-04f, 1.80880845e-01f, 1.00660354e-01f, 5.15750870e-02f, 4.72178645e-02f, -5.20754792e-02f, 2.43309423e-01f, -5.00688329e-02f, 8.70401338e-02f,
  -3.46641205e-02f, -2.26787269e-01f, 4.11936603e-02f, -9.91353486e-03f, -1.21611133e-01f, -1.99385330e-01f, 9.33457240e-02f, 4.77780029e-02f, 4.94250953e-02f, 1.14879154e-01f,
  5.08087754e-01f, -9.31016445e-01f, 4.49701309e-01f, -2.52825916e-02f, 5.96509613e-02f, -1.84220850e-01f, 1.45735353e-01f, -9.74946916e-02f, 1.78438976e-01f, 6.69132397e-02f,
  -1.46146610e-01f, -1.42668094e-02f, 1.13167614e-01f, 7.27036819e-02f, -8.23823884e-02f, 3.85234766e-02f, 6.53536022e-02f, -2.90287882e-01f, -1.76796272e-01f, 3.71761948e-01f,
  2.64341921e-01f, -1.42942786e-01f, -7.71961585e-02f, -5.40064871e-02f, 3.01357061e-01f, -3.89906794e-01f, -1.76036492e-01f, -6.80104345e-02f, -7.05470502e-01f, 4.62830007e-01f,
  1.43506181e+00f, 1.12624943e+00f, 5.26925921e-01f, 3.18614781e-01f, 1.48474693e-01f, 4.22929287e-01f, 7.21887946e-01f, 4.62389678e-01f, 7.67860711e-02f, 2.14579076e-01f,
  5.76945357e-02f, -1.50978193e-01f, -1.20304734e-01f, -8.88652653e-02f, 2.03733519e-01f, 9.99612361e-02f, -1.16580695e-01f, -4.24594469e-02f, -1.45171344e-01f, -2.53359020e-01f,
  -4.00988042e-01f, -1.76135540e-01f, -1.17062896e-01f, -6.02065288e-02f, 2.46289261e-02f, -2.65624225e-01f, 1.54542802e-02f, 1.01796106e-01f, 1.33880615e-01f, -1.84719060e-02f,
  -2.02520952e-01f, 8.14413965e-01f, -3.95452261e-01f, -1.51291683e-01f, -1.20162196e-01f, -1.81121349e-01f, -1.00562230e-01f, -1.08307920e-01f, -1.16328105e-01f, -5.00016212e-02f,
  -9.35651809e-02f, -1.14782387e-02f, 9.40971896e-02f, 5.28481975e-02f, 1.17304645e-01f, -1.57240406e-02f, 1.08985461e-01f, 2.25464970e-01f, 1.25117630e-01f, 2.12809704e-02f,
  -1.80999134e-02f, -1.62323043e-02f, 1.22441649e-01f, 1.01579167e-01f, 2.58510590e-01f, -5.83052821e-02f, 1.45144030e-01f, 1.83194771e-01f, 2.26129845e-01f, 3.88969719e-01f,
  -8.06297511e-02f, 1.12777412e-01f, 1.61582813e-01f, 1.38170868e-01f, -1.14757372e-02f, 6.61840616e-03f, 8.80739912e-02f, 3.81982066e-02f, 1.42328978e-01f, 2.51183566e-02f,
  1.00170270e-01f, 3.67799699e-02f, 4.02534269e-02f, -6.81441799e-02f, -8.71828049e-02f, 4.85632531e-02f, -1.38370842e-01f, 7.81661924e-03f, -1.37413144e-02f, -1.87880993e-01f,
  8.69770646e-02f, -3.68443094e-02f, 4.25820127e-02f, 1.42937154e-01f, 3.77785265e-02f, 9.46237966e-02f, -7.56180882e-02f, 3.86198647e-02f, 6.63414299e-02f, -1.09105639e-01f,
  -5.14157355e-01f, -1.19638398e-01f, -3.15986961e-01f, -3.53269242e-02f, 3.48546021e-02f, -4.88930009e-02f, 4.16413061e-02f, -1.51385963e-01f, -8.58186185e-02f, -1.06924579e-01f,
  -1.76519752e-02f, 2.74474565e-02f, 2.29715601e-01f, -2.86840871e-02f, -1.46368325e-01f, -7.35009015e-02f, -1.00347348e-01f, 9.72899608e-03f, -3.48672792e-02f, -1.51880577e-01f,
  -4.20776047e-02f, -1.71062902e-01f, -2.18190148e-01f, -8.65068752e-03f, -1.91809833e-01f, -3.68055940e-01f, -2.13913664e-01f, -1.58153489e-01f, -1.50815606e-01f, -1.69474155e-01f,
  9.45567727e-01f, -1.22855711e+00f, 1.96728796e-01f, 2.57578135e-01f, -9.49000478e-01f, -5.50216973e-01f, -8.83011043e-01f, 1.68797120e-01f, 7.98752159e-02f, -8.09388697e-01f,
  -7.82212138e-01f, -7.43421838e-02f, -3.67552698e-01f, 9.92093086e-02f, 4.99088466e-01f, -6.02449059e-01f, -1.66076377e-01f, 9.03008163e-01f, 1.35083115e+00f, 5.64656258e-01f,
  -2.02132314e-01f, 5.10187387e-01f, 9.12332833e-01f, 6.34129941e-01f, -3.47842127e-01f, 3.26463468e-02f, -3.58374864e-01f, -1.59054458e-01f, -3.97595853e-01f, -3.37337434e-01f,
  -2.46764615e-01f, -2.09320277e-01f, 3.84634018e-01f, 1.03279278e-01f, -2.81345218e-01f, 1.27980337e-01f, 3.21935341e-02f, 1.67894706e-01f, 4.15885337e-02f, -5.08837923e-02f,
  -1.69809043e-01f, 2.00553522e-01f, 7.52404705e-02f, -3.00587993e-02f, -5.53267915e-03f, 4.09125388e-02f, 3.78766090e-01f, 5.57381690e-01f, 2.42102534e-01f, -2.25536972e-01f,
  -6.47241056e-01f, -3.65372896e-01f, -2.35296860e-01f, -3.58147384e-03f, 3.45793158e-01f, 1.78087741e-01f, -3.18035409e-02f, 5.84642291e-01f, 2.21894637e-01f, -2.70907208e-02f,
  3.47743481e-02f, -1.22720905e-01f, -1.34902038e-02f, 4.35363464e-02f, -6.41800240e-02f, -2.55050743e-03f, 9.83176529e-02f, -2.59591006e-02f, 1.33499295e-01f, -9.60833877e-02f,
  2.64050402e-02f, -3.01371664e-02f, 8.00483972e-02f, -4.45907079e-02f, 1.17293648e-01f, -1.47422403e-01f, -1.66206822e-01f, 1.27225444e-01f, -1.54918460e-02f, -1.90476142e-02f,
  1.36032984e-01f, -7.17194900e-02f, -1.62449896e-01f, 2.02682510e-01f, -3.48117948e-02f, 2.31619269e-01f, -2.45612971e-02f, 1.38381168e-01f, -1.37641635e-02f, -2.08104879e-01f,
  2.17671692e-02f, 8.89130607e-02f, -2.65853226e-01f, 2.31946602e-01f, -2.51914531e-01f, -4.11827043e-02f, -1.79490581e-01f, 1.34797310e-02f, -1.05699204e-01f, 4.74713423e-04f,
  -1.44505054e-01f, 7.07113072e-02f, -2.40920603e-01f, -6.34328127e-02f, 7.42321908e-02f, -3.52306329e-02f, -3.85922194e-01f, -1.82024315e-01f, 1.91850942e-02f, -1.08408824e-01f,
  -4.19200137e-02f, -2.48234570e-01f, -2.09162846e-01f, -3.08439434e-01f, -1.47605434e-01f, -2.79002994e-01f, -2.02014431e-01f, -7.96378851e-02f, -2.58702815e-01f, -6.71648800e-01f,
  -1.54032135e+00f, -5.60903624e-02f, -4.59778607e-01f, -1.80052769e+00f, -1.12804210e+00f, -2.13382959e-01f, -2.26766542e-01f, 2.14429751e-01f, -3.50654840e-01f, -5.28399825e-01f,
  1.80290595e-01f, 3.42054665e-01f, 2.92341977e-01f, 3.80672544e-01f, -2.82596983e-02f, -5.32703698e-01f, -1.08314025e+00f, -7.63021827e-01f, -4.22164440e-01f, -3.92390490e-01f,
  -5.95794141e-01f, -1.26730704e+00f, -1.01165175e+00f, -4.39508647e-01f, -3.12347978e-01f, -3.02648954e-02f, -3.10061991e-01f, -7.16880381e-01f, -2.53810082e-02f, -7.02851951e-01f,
  2.12416515e-01f, 1.81204483e-01f, -5.69195822e-02f, -5.44981584e-02f, -2.50646591e-01f, 1.28907159e-01f, -1.25190228e-01f, -1.17476076e-01f, -2.83647571e-02f, -1.32990405e-01f,
  -3.88918102e-01f, -4.33910787e-02f, -9.47938487e-02f, 1.21258900e-01f, -4.23021197e-01f, -5.93186878e-02f, -1.39523238e-01f, -3.34572852e-01f, -5.11579998e-02f, 3.67680162e-01f,
  5.37594408e-02f, -2.33874783e-01f, 1.87124923e-01f, 4.18792486e-01f, 4.70436066e-01f, -1.15540214e-01f, 3.04720342e-01f, 3.60751599e-01f, 2.26306722e-01f, 1.27970343e-02f,
  -1.76873058e-01f, 1.60619393e-01f, 4.06787731e-02f, -8.46627727e-02f, 3.09486166e-02f, 1.25974417e-01f, -1.15194440e-01f, -8.73510689e-02f, -6.58541126e-03f, 1.03895098e-01f,
  3.56225595e-02f, -4.92265821e-02f, 2.55552661e-02f, -1.49698734e-01f, -1.73077196e-01f, -2.68928707e-01f, 1.09421089e-01f, 7.91108459e-02f, -1.17232271e-01f, -2.68421084e-01f,
  -1.93906769e-01f, -1.52233884e-01f, -1.33733496e-01f, 8.90614912e-02f, -2.04165243e-02f, -1.30553678e-01f, 2.06264835e-02f, 3.83649051e-01f, 1.90734997e-01f, 7.67626390e-02f,
  2.37202600e-01f, 9.66455787e-02f, 1.13566630e-01f, 3.16848531e-02f, -1.74666703e-01f, 1.14260346e-01f, -1.22878835e-01f, 3.07598673e-02f, 6.29891306e-02f, 4.31336910e-02f,
  1.37009129e-01f, -1.23192973e-01f, -4.16434892e-02f, 1.50862649e-01f, -1.88169777e-01f, 5.71621209e-02f, -2.86666602e-01f, -2.78054148e-01f, -3.21720839e-02f, 1.90269165e-02f,
  -5.03588766e-02f, -1.12921447e-01f, 8.07047635e-02f, 1.51300505e-01f, 2.40737781e-01f, 7.79644474e-02f, 2.76767135e-01f, 2.64851213e-01f, 1.34235069e-01f, -1.79908052e-01f,
  6.41248077e-02f, -1.72004942e-02f, 8.20134044e-01f, -2.56598502e-01f, 3.61938506e-01f, 5.89433908e-01f, 7.69287288e-01f, 7.52892867e-02f, -4.23861474e-01f, -1.01025388e-01f,
  -1.74258679e-01f, -4.82894748e-01f, -4.10420179e-01f, -2.81417668e-01f, -1.60981610e-01f, -7.11027309e-02f, -8.56873468e-02f, 1.23850815e-01f, 6.60073459e-01f, 3.91226113e-01f,
  -6.50702566e-02f, 1.19450815e-01f, -6.35286272e-02f, -8.49046409e-02f, -9.23264772e-02f, 2.15674168e-03f, -1.27217948e-01f, -8.07774812e-02f, -1.59092367e-01f, -4.81787473e-01f,
  6.43661261e-01f, -3.50461811e-01f, -8.26418549e-02f, -5.45222104e-01f, -1.15852259e-01f, -2.43292645e-01f, 1.70541197e-01f, -1.24343850e-01f, -1.22132964e-01f, -3.08725797e-02f,
  -1.11511104e-01f, -2.42856517e-01f, -7.61299278e-04f, 8.58596563e-02f, 2.91709155e-01f, 7.55216777e-02f, -2.88329899e-01f, -2.13457227e-01f, -3.90759587e-01f, -2.12873951e-01f,
  -2.34644905e-01f, 1.64948404e-01f, 3.01077336e-01f, 6.27096444e-02f, -1.48630857e-01f, -1.68947592e-01f, 7.93899372e-02f, -1.40344590e-01f, -6.21449053e-02f, -9.38203484e-02f,
  -2.92995453e-01f, 5.00818603e-02f, -1.92700267e-01f, 1.84774637e-01f, 1.68260127e-01f, -6.42539039e-02f, 4.69249524e-02f, 4.97033373e-02f, 1.48162052e-01f, 2.45491013e-01f,
  6.25934005e-02f, 1.26724364e-02f, 1.33564040e-01f, 5.64643629e-02f, -1.11141741e-01f, 1.93041768e-02f, 7.16535002e-02f, -8.13044906e-02f, -1.76542364e-02f, 2.74122842e-02f,
  2.48331167e-02f, 3.00705992e-02f, 3.99328694e-02f, 3.21265459e-02f, -9.84458402e-02f, -7.64819756e-02f, 4.52192985e-02f, 5.34722134e-02f, -1.41254961e-01f, -3.92998159e-02f,
  3.11204761e-01f, -2.26327285e-01f, -3.74190994e-02f, -2.08823159e-01f, -1.52627259e-01f, -4.42754388e-01f, -3.80777381e-02f, -2.24455133e-01f, -1.03141993e-01f, -8.09501782e-02f,
  -3.45141627e-02f, -5.80273271e-02f, 9.08992440e-02f, 9.10474584e-02f, 3.88280153e-01f, 9.59766656e-02f, -2.01624006e-01f, 1.13622516e-01f, -3.21009874e-01f, 1.22626014e-02f,
  -5.64895235e-02f, 2.55532026e-01f, 4.45497364e-01f, 2.74242461e-01f, -3.48840542e-02f, 2.39878014e-01f, 3.95106018e-01f, 2.14232996e-01f, 2.00905353e-01f, 3.22034746e-01f,
  -1.34470797e+00f, 4.05401230e-01f, 5.60415208e-01f, 7.60033280e-02f, 9.57759559e-01f, 1.51645008e-03f, -6.89394891e-01f, -8.76147509e-01f, -4.98661846e-02f, 1.88207198e-02f,
  3.59381795e-01f, 8.06018487e-02f, 1.89550534e-01f, -9.40742269e-02f, -8.05309415e-01f, -3.24575454e-02f, 4.21938837e-01f, -3.43856812e-01f, -9.54812825e-01f, -7.67013609e-01f,
  1.49612948e-01f, -1.74560472e-01f, -5.96373975e-01f, -2.39951208e-01f, 6.21894002e-01f, 1.28861487e-01f, 6.27552807e-01f, 4.74932313e-01f, 3.32840055e-01f, 1.02478838e+00f,
  3.30711268e-02f, 1.24298573e-01f, -2.00115919e-01f, -3.88704948e-02f, 4.55213279e-01f, -3.92012715e-01f, -3.95820051e-01f, -1.21038929e-02f, 5.22505641e-02f, -1.15496973e-02f,
  5.26579440e-01f, -1.15966603e-01f, 5.12265980e-01f, 1.79934412e-01f, -1.24053732e-01f, -4.12003547e-01f, -6.82626292e-02f, -4.88403916e-01f, -4.46939349e-01f, -3.07353050e-01f,
  8.22399557e-01f, 2.57976621e-01f, -3.77278656e-01f, -9.35741439e-02f, -2.91633040e-01f, 2.14719832e-01f, -9.06255394e-02f, -9.12386551e-02f, -4.34877187e-01f, -2.81485945e-01f,
  -9.79306549e-02f, 1.11201771e-01f, 9.11415219e-02f, 3.58449593e-02f, -4.58906069e-02f, 1.42193124e-01f, 3.20974320e-01f, -1.17848277e-01f, 1.02131851e-01f, -2.50391752e-01f,
  -8.87789428e-02f, 1.24687269e-01f, -4.34216717e-03f, -1.68651655e-01f, 6.02739975e-02f, 1.11508057e-01f, -8.67854133e-02f, -1.26964808e-01f, 5.52033260e-02f, 3.76670957e-02f,
  -6.22249432e-02f, 8.08252543e-02f, 4.99295667e-02f, -2.44024888e-01f, 1.65780813e-01f, 4.56741340e-02f, 8.13679323e-02f, -6.15809970e-02f, -7.49107078e-02f, -1.15544507e-02f,
  -5.61259031e-01f, 3.77851576e-02f, -3.50395232e-01f, -1.36862427e-01f, 1.21220440e-01f, 1.83779866e-01f, 2.57344246e-01f, 2.35942766e-01f, 1.14488140e-01f, -4.84056860e-01f,
  -2.69512475e-01f, -1.23349383e-01f, 6.66531250e-02f, 4.25242148e-02f, -3.77079785e-01f, -1.44973798e-02f, 2.58022044e-02f, 8.06906447e-02f, -2.45904103e-01f, 8.96823220e-03f,
  -9.84860137e-02f, -7.17950583e-01f, -8.24724793e-01f, -6.01769149e-01f, -1.85136095e-01f, -7.13000953e-01f, -5.81011832e-01f, -5.08891881e-01f, -9.31743860e-01f, -1.31410444e+00f,
  5.83671153e-01f, -1.34307772e-01f, -7.30787158e-01f, 6.40977502e-01f, 1.70600772e-01f, -5.84987514e-02f, -1.04606729e-02f, 2.24052399e-01f, 5.09111106e-01f, 1.98993355e-01f,
  -1.68890864e-01f, 2.22710446e-01f, 1.22775897e-01f, 6.67097792e-02f, 1.12115405e-01f, 3.69714320e-01f, 4.91972208e-01f, 7.46821659e-03f, -1.66304156e-01f, 9.72270742e-02f,
  3.54703486e-01f, 1.51807398e-01f, 1.26064545e-03f, -4.11452837e-02f, -2.37925760e-02f, 2.62622952e-01f, -4.90400866e-02f, -1.83913961e-01f, -3.24642897e-01f, 3.20981801e-01f,
  -4.53903794e-01f, -4.62078691e-01f, 1.69094846e-01f, 1.59500331e-01f, -3.00210267e-01f, -1.04021356e-01f, 2.84312312e-02f, -1.19308122e-01f, -1.19040959e-01f, 9.01659653e-02f,
  -5.18566333e-02f, -1.18915945e-01f, -1.75411299e-01f, -9.82616618e-02f, 4.11433987e-02f, -1.54340774e-01f, -4.58665611e-03f, -3.02109160e-02f, 1.39479935e-01f, -1.13809250e-01f,
  -1.73710361e-02f, -2.15625688e-01f, -6.29145354e-02f, -4.37892554e-03f, -2.44941249e-01f, 2.70609930e-02f, -3.40165645e-01f, -1.45039216e-01f, -1.12201333e-01f, 5.69779389e-02f,
  1.76592723e-01f, -7.07621723e-02f, -2.14247689e-01f, 1.85165945e-02f, -4.52862047e-02f, 1.63935870e-01f, 4.90776822e-02f, -9.64341871e-03f, 1.25417691e-02f, 4.33362275e-02f,
  8.59718472e-02f, 7.86035061e-02f, -1.09101906e-01f, 1.22441344e-01f, 3.64028960e-02f, -6.02895468e-02f, 4.00606915e-02f, -1.03259660e-01f, -1.64088085e-01f, 6.16402961e-02f,
  -1.28233628e-02f, 8.75860676e-02f, -2.31556371e-02f, -1.93168417e-01f, 7.60959089e-02f, -6.49237558e-02f, 6.38107136e-02f, -8.24835524e-02f, 2.36997250e-02f, 2.05205843e-01f,
  4.50309902e-01f, -2.43182629e-01f, 2.46722415e-01f, 1.03426605e-01f, -1.22960351e-01f, -2.17142105e-01f, -1.16485365e-01f, -9.55027789e-02f, -1.24268964e-01f, -5.67427985e-02f,
  -3.45006675e-01f, -5.10513857e-02f, -7.99616501e-02f, -8.36964250e-02f, 1.41720800e-03f, -9.20365602e-02f, 1.40868137e-02f, 1.18502334e-01f, 5.79282343e-02f, -1.22683428e-01f,
  -4.34078788e-03f, 2.16175899e-01f, 4.62127030e-01f, 2.11457163e-01f, 1.89114913e-01f, 3.69491935e-01f, -5.14028259e-02f, -3.87941152e-02f, 7.09231058e-03f, 5.29070735e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.83111262e+00f, 9.97423172e-01f, 1.18636191e+00f, 1.00442696e+00f, 6.53693914e-01f, 1.25991857e+00f, 1.16773522e+00f, 1.20575249e+00f, 8.92841935e-01f, 1.64916134e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -2.41977051e-01f, -8.27208042e-01f, -1.05530047e+00f, 7.88272619e-02f, 9.05334830e-01f, -3.76571566e-01f, 4.77747351e-01f, -5.76699018e-01f, 5.96600056e-01f, 2.20180556e-01f,
  -3.84481221e-01f, 7.68394828e-01f, 1.29561096e-01f, -7.47993290e-01f, -1.17694306e+00f, -2.17354107e+00f, 1.65763497e-01f, 2.88982004e-01f, 2.67679632e-01f, 2.46870875e-01f,
  9.27300900e-02f, 1.80696934e-01f, -1.80492485e+00f, -4.50764894e-02f, 1.01064670e+00f, -1.21155429e+00f, 4.65994954e-01f, 5.53938627e-01f, 3.44733149e-01f, -4.38316196e-01f,
  -1.50252104e+00f, 2.90330589e-01f, 4.33824599e-01f, -7.69466581e-03f, 3.80810887e-01f, 1.88414171e-01f, 3.83722037e-01f, -3.42797369e-01f, -1.02441645e+00f, 2.04866707e-01f,
  3.57205659e-01f, -1.74494040e+00f, -1.71161020e+00f, 1.84463310e+00f, -1.14544082e+00f, -6.88584149e-01f, 2.16333896e-01f, -1.45679069e+00f, 1.75671175e-01f, 2.29787111e-01f,
  -3.90288651e-01f, 1.11223031e-02f, -5.25706947e-01f, -3.56726110e-01f, 1.28752589e+00f, -9.35660958e-01f, -1.81402802e+00f, -2.12486100e+00f, -7.49261677e-01f, -1.69088531e+00f,
  4.55769598e-01f, -6.05335236e-01f, 1.89678609e-01f, -8.40698183e-01f, -7.50211596e-01f, 4.03565347e-01f, 3.86796147e-02f, 9.53564346e-02f, -5.39528489e-01f, -6.67417288e-01f,
  -1.03237152e+00f, -4.62141156e-01f, -1.33845448e+00f, 1.88795105e-01f, 2.63284832e-01f, -1.31134975e+00f, 5.55288494e-01f, -1.26717961e+00f, 4.97774899e-01f, 2.89925218e-01f,
  3.49106550e-01f, 1.19606525e-01f, 3.21696311e-01f, 1.28360674e-01f, -4.86749232e-01f, -4.75701541e-02f, 4.29921746e-01f, -7.24427104e-01f, 1.45189166e-01f, 1.57535648e+00f,
  -7.10665524e-01f, -9.63241637e-01f, -3.22888345e-01f, -6.94641054e-01f, -1.74259210e+00f, 5.48772395e-01f, 2.62349039e-01f, 2.27917686e-01f, -6.06004238e-01f, -6.51903749e-01f,
  7.13556446e-03f, 1.19612670e+00f, -1.44769108e+00f, 1.05800474e+00f, -1.33922541e+00f, 6.47478998e-01f, 1.43554181e-01f, 8.79883587e-01f, -9.21252370e-01f, -1.02520752e+00f,
  -4.71756548e-01f, -4.57253814e-01f, -1.19070984e-01f, -2.08768696e-01f, -1.76424980e-01f, -8.69659986e-03f, 2.35635370e-01f, -4.13953602e-01f, 8.22163463e-01f, -1.47754622e+00f,
  -1.46102858e+00f, -5.31626105e-01f, -8.93846452e-02f, -1.66951370e+00f, -1.70690453e+00f, -6.50894046e-01f, 1.17357683e+00f, 7.20200598e-01f, -4.82048035e-01f, 4.46788460e-01f,
  -1.24088824e-01f, -5.01040518e-01f, -1.17497332e-01f, 5.34727335e-01f, 8.78082752e-01f, -9.80875194e-01f, -5.35982370e-01f, -1.61207473e+00f, -5.24052083e-01f, -6.52636439e-02f,
  -1.68203783e+00f, 1.17924154e+00f, -7.11440086e-01f, 2.90436447e-01f, -3.74128103e-01f, -8.48483086e-01f, 9.10217345e-01f, 1.03110528e+00f, 4.75535125e-01f, -1.12069714e+00f,
  -1.86021149e+00f, 2.04563484e-01f, -7.25225210e-01f, 7.69522786e-01f, -1.00903594e+00f, -4.72933531e-01f, -1.72403419e+00f, -4.88234192e-01f, 1.07081723e+00f, -9.31656808e-02f,
  4.79379117e-01f, -6.01812541e-01f, 5.82361639e-01f, 4.72698897e-01f, -6.19482338e-01f, 5.93211770e-01f, -1.20539880e+00f, -1.04990768e+00f, -1.53467369e+00f, -1.40708089e+00f,
  -1.10178971e+00f, -6.21901155e-01f, 6.47206843e-01f, 1.12682450e+00f, -1.02603018e+00f, -3.31781179e-01f, 2.66764760e-01f, 1.87170669e-01f, 1.25697732e-01f, -3.24182808e-01f,
  -1.50573254e-01f, 2.05254644e-01f, 2.75779873e-01f, 6.21608853e-01f, -2.08472520e-01f, -6.55102670e-01f, 7.22109616e-01f, -1.65107536e+00f, -1.09066844e+00f, 7.06628919e-01f,
  2.09633723e-01f, -1.58802927e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -6.43846691e-02f, -7.92864442e-01f, 8.72335613e-01f, -7.34932244e-01f, 4.98893976e-01f, 8.00506547e-02f, -6.47922635e-01f, -3.27600129e-02f, -2.64143229e-01f, 2.75826544e-01f,
  -6.89776242e-02f, -4.67035472e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    