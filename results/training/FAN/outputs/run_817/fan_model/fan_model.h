/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.36478120e-01f, -2.59193212e-01f, -2.85211354e-01f, 6.78759366e-02f, -2.54634256e-03f, -3.65351617e-01f, -5.38290799e-01f, -6.76794350e-02f, 9.14244279e-02f, -6.43376708e-02f,
  7.58057609e-02f, 4.20716077e-01f, 1.66921780e-01f, 1.90774441e-01f, -8.67938399e-02f, -3.17239881e-01f, -3.04022580e-01f, -1.14341170e-01f, -3.74506377e-02f, 6.25755042e-02f,
  1.69819340e-01f, -8.46882258e-03f, 5.76331764e-02f, 3.30359116e-03f, 4.89628986e-02f, 8.09019282e-02f, -1.62852988e-01f, -3.50536481e-02f, -1.46322832e-01f, -1.12527728e-01f,
  -1.72694042e-01f, -1.41517147e-01f, 3.72256376e-02f, 1.30734056e-01f, 7.22511709e-02f, -6.01437129e-02f, -1.06151111e-01f, 1.85469557e-02f, 3.30216587e-02f, -1.14106670e-01f,
  7.69054890e-02f, -1.02764312e-02f, -6.93107098e-02f, 7.01356381e-02f, 1.55521100e-02f, -1.00726381e-01f, -1.15991533e-01f, -5.03105894e-02f, -7.22907633e-02f, -9.37330257e-03f,
  1.15162022e-01f, -5.40775852e-03f, -1.57367304e-01f, -6.11406267e-02f, -9.27615911e-02f, 1.06265761e-01f, -6.22253455e-02f, 1.76913813e-02f, -1.15864255e-01f, -2.62725204e-01f,
  -3.64868119e-02f, 1.95292830e-02f, 4.83758003e-02f, 3.31449509e-02f, -2.44078314e-04f, 4.32513468e-02f, 2.61529535e-02f, -4.11292091e-02f, 8.91043618e-03f, -3.17364782e-02f,
  5.17500415e-02f, 2.12303009e-02f, 2.67732330e-02f, -1.26296684e-01f, 9.53033566e-02f, -2.76971292e-02f, -2.19225679e-02f, 1.98921352e-03f, 5.27439900e-02f, 8.09188560e-02f,
  -3.75079885e-02f, -3.30293737e-03f, 6.24698699e-02f, -7.08535165e-02f, 3.51206996e-02f, -2.83904728e-02f, -2.77789570e-02f, 7.27627128e-02f, -7.45831477e-03f, -7.57861882e-03f,
  2.05764174e-01f, -4.42462461e-03f, -1.88168995e-02f, -8.90048817e-02f, -4.04352322e-03f, 6.10581413e-02f, 5.91127314e-02f, 2.08360013e-02f, 7.12233558e-02f, -4.82507795e-03f,
  -3.20588872e-02f, -3.20605934e-02f, -4.13917005e-02f, 2.03218535e-02f, -1.18897576e-02f, -7.91662745e-03f, 4.95586433e-02f, -2.91274171e-02f, 4.43516262e-02f, 8.44026208e-02f,
  -2.00773496e-03f, -9.28855985e-02f, 2.58479696e-02f, -3.81752402e-02f, 6.17112145e-02f, 3.53017487e-02f, -1.36313379e-01f, -5.72983772e-02f, -1.74043566e-01f, -2.70565331e-01f,
  1.64603636e-01f, -4.78656560e-01f, 3.01331758e-01f, -7.32019171e-03f, -2.38981172e-01f, -1.35727614e-01f, -3.30700696e-01f, -5.45753278e-02f, 6.03523515e-02f, -3.59243378e-02f,
  -1.19847722e-01f, 2.87882425e-02f, 1.27085030e-01f, 2.02058807e-01f, 1.15360260e-01f, 3.80580723e-02f, -3.16417888e-02f, 3.07202876e-01f, 3.71376991e-01f, -1.17545307e-01f,
  -1.69015706e-01f, -1.00279331e-01f, 1.16722368e-01f, -8.71921889e-03f, -7.95332342e-02f, 1.14114538e-01f, 9.44399312e-02f, -6.46391138e-02f, -5.53664975e-02f, -7.12270364e-02f,
  3.31882298e-01f, -2.14223519e-01f, 1.80017009e-01f, -4.32936922e-02f, -2.36040633e-02f, 6.62910864e-02f, 4.68810946e-02f, 1.13377556e-01f, -6.86667040e-02f, 2.98623275e-02f,
  1.32459570e-02f, -1.54972464e-01f, 6.40154770e-03f, -5.98028004e-02f, -6.06232062e-02f, 1.24830501e-02f, -5.59970438e-02f, 6.87016919e-02f, 8.26806352e-02f, 3.14595103e-02f,
  -1.31518900e-01f, -1.21813774e-01f, 5.22515923e-02f, 3.02339699e-02f, 4.66711484e-02f, -8.14140122e-03f, -9.89909917e-02f, 1.91558022e-02f, 4.94459197e-02f, 6.61934819e-03f,
  -2.84365788e-02f, -6.88713603e-03f, -2.51155123e-02f, -7.93536156e-02f, -2.61601899e-02f, 3.97773944e-02f, 5.00842230e-03f, 6.14780746e-03f, -3.50162834e-02f, -5.11763208e-02f,
  1.63668003e-02f, -5.98807000e-02f, 2.36425567e-02f, 1.79762580e-02f, 8.11044350e-02f, 3.74566093e-02f, 2.42556278e-02f, 4.44450229e-02f, 3.80693004e-02f, 2.35748012e-02f,
  -1.55640710e-02f, 8.88213068e-02f, 4.63083312e-02f, -5.83192753e-03f, -1.95413618e-03f, 5.52416146e-02f, 3.19321193e-02f, -5.00778705e-02f, 4.86491434e-02f, -6.44090176e-02f,
  1.86663389e-01f, 1.99881494e-01f, 1.92478344e-01f, 2.15942357e-02f, -1.00117056e-02f, 3.23304050e-02f, 1.31788012e-02f, -3.09501141e-02f, 3.73487547e-02f, 2.08316818e-02f,
  1.11611746e-02f, 2.22364757e-02f, -1.14831077e-02f, -7.49074062e-03f, 5.13466336e-02f, 7.23267570e-02f, -9.03638080e-02f, 7.37238675e-02f, 3.18111442e-02f, -1.24358371e-01f,
  -7.88086578e-02f, 7.89535269e-02f, 3.03165406e-01f, 1.20032519e-01f, 3.02160587e-02f, 2.26353079e-01f, 1.13657594e-01f, 2.03418806e-01f, 2.61902750e-01f, 1.43587515e-01f,
  4.76625949e-01f, 2.35308781e-01f, -3.36113632e-01f, 4.01931584e-01f, 7.66404048e-02f, -2.56360203e-01f, -2.64222622e-01f, -1.33604497e-01f, 1.95543662e-01f, 2.59511262e-01f,
  1.83471084e-01f, 1.83689788e-01f, 2.14482546e-01f, 1.32060051e-02f, -1.46122843e-01f, -1.09267041e-01f, -2.17681929e-01f, -3.91987532e-01f, -4.09732163e-01f, -9.70408171e-02f,
  1.02354094e-01f, 1.26314729e-01f, -4.00669686e-02f, 1.36310905e-02f, 2.61703014e-01f, 1.85664698e-01f, 6.75597712e-02f, 5.70927113e-02f, -1.01990268e-01f, 9.94163156e-02f,
  -1.72417909e-02f, 4.10978645e-02f, -9.76769999e-02f, 8.21080655e-02f, 4.64075319e-02f, -5.84970899e-02f, -1.93072967e-02f, 6.10767901e-02f, 6.32058457e-02f, 4.90710065e-02f,
  5.71603850e-02f, 1.47711914e-02f, 5.64294532e-02f, -2.54595391e-02f, -2.15037782e-02f, -3.37463547e-03f, -7.60328993e-02f, -8.21005702e-02f, -4.32320759e-02f, -2.54321862e-02f,
  1.37066856e-01f, -2.05457378e-02f, -1.50386710e-02f, -1.33121580e-01f, -1.89233527e-01f, -2.34305412e-02f, -7.91664720e-02f, -9.21847224e-02f, -1.51398420e-01f, 9.61258113e-02f,
  7.06316605e-02f, -2.30760928e-02f, -2.78984755e-02f, -2.14883825e-03f, -3.11728679e-02f, 6.67993128e-02f, -2.97851022e-02f, 2.91947299e-03f, -9.10530835e-02f, -5.89696690e-03f,
  1.33457361e-02f, -1.34180104e-02f, 1.53652020e-02f, 1.26598319e-02f, 1.21949697e-02f, 3.28356922e-02f, -8.44766945e-03f, -2.54268921e-03f, -4.18588221e-02f, 4.37975600e-02f,
  -2.51374114e-02f, -6.21165894e-02f, 2.19376720e-02f, -4.56687883e-02f, -3.18007991e-02f, 3.28727849e-02f, -9.72259045e-03f, 2.05958635e-02f, 5.44270091e-02f, 3.42640989e-02f,
  2.77414143e-01f, -2.48508453e-01f, 1.27276942e-01f, -6.57558218e-02f, 8.17981139e-02f, -9.48787667e-03f, 1.16367526e-01f, -3.27480249e-02f, 7.51680434e-02f, -3.41295563e-02f,
  -3.05330157e-02f, -1.18281953e-01f, -1.33090001e-02f, -1.36037543e-02f, -7.44716357e-03f, -6.57833815e-02f, 9.80933309e-02f, 6.44091740e-02f, -5.94237782e-02f, 3.17319930e-02f,
  7.12810606e-02f, -1.81202274e-02f, 9.83565077e-02f, 1.60406604e-02f, 2.39904951e-02f, -4.31119930e-03f, -9.02776420e-02f, 6.83838129e-02f, -9.95374173e-02f, 2.23819301e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.84528962e-01f, 1.12654977e-01f, 1.16455279e-01f, 1.65957719e-01f, 2.23825783e-01f, 3.09388101e-01f, 3.76096040e-01f, 2.19935134e-01f, 2.58193821e-01f, 1.58172220e-01f,
  1.23651221e-01f, 8.13585594e-02f, 2.59925723e-01f, 2.51704693e-01f, 2.16220945e-01f, 2.30880737e-01f, 2.27748498e-01f, 1.21902652e-01f, 4.30014022e-02f, -2.05200147e-02f,
  1.11095384e-01f, -2.01133708e-03f, -1.08654611e-01f, -3.23134959e-02f, 9.35788155e-02f, 1.96037561e-01f, 8.27423260e-02f, -2.22765878e-02f, 7.42027462e-02f, 2.50539612e-02f,
  -2.64703065e-01f, -1.03330426e-02f, -3.72223966e-02f, -3.23486067e-02f, -3.58215682e-02f, -5.94730228e-02f, -8.47615674e-02f, -1.54761523e-01f, -7.77227506e-02f, -1.75166260e-02f,
  -4.44652289e-02f, -5.40092066e-02f, -2.21592598e-02f, -1.24715708e-01f, -1.21243790e-01f, -1.01938240e-01f, -1.44990291e-02f, 1.74713004e-02f, 1.23820052e-01f, -5.56393340e-02f,
  6.75726309e-02f, -9.55189914e-02f, -5.71533479e-02f, 1.10021822e-01f, 1.54816490e-02f, -1.65481344e-02f, -9.61664245e-02f, 1.11550023e-03f, 5.28934672e-02f, 4.79002632e-02f,
  2.42871121e-02f, 4.51572128e-02f, 8.07958171e-02f, 2.29535289e-02f, -2.23034080e-02f, 2.86990982e-02f, 7.59702772e-02f, -3.27671058e-02f, 8.81537497e-02f, -1.53138181e-02f,
  5.69395460e-02f, 4.43830602e-02f, 6.97445357e-03f, 4.04456705e-02f, 2.65159439e-02f, -6.04226366e-02f, -1.15984641e-02f, -2.74943449e-02f, 1.08919246e-02f, -5.33987433e-02f,
  -4.73421626e-03f, -1.05350995e-02f, -1.00701958e-01f, 9.04629156e-02f, -6.84539974e-02f, 2.48767585e-02f, -3.95508762e-03f, 1.53929228e-02f, -2.97728162e-02f, -3.44856605e-02f,
  5.34804612e-02f, 9.76972505e-02f, -1.41636953e-02f, -3.60559337e-02f, -4.60481718e-02f, -8.22093859e-02f, 9.66526121e-02f, -7.46557415e-02f, -1.36778235e-01f, 3.22691128e-02f,
  -8.50287154e-02f, -2.50209775e-03f, 5.74456304e-02f, -3.27345356e-02f, -5.04710600e-02f, -1.29125983e-01f, -1.49592822e-02f, 5.71929440e-02f, 9.01316032e-02f, -4.58386913e-02f,
  -3.57496552e-03f, -5.85267246e-02f, -1.48037504e-02f, -1.72985308e-02f, 1.03503585e-01f, -6.38193861e-02f, 1.61073189e-02f, 6.70327060e-03f, -1.13517933e-01f, -1.64546780e-02f,
  -6.14574194e-01f, -1.06139764e-01f, -3.03285662e-02f, -1.77713707e-01f, 7.14126742e-04f, 3.90927419e-02f, 5.97504452e-02f, 4.68584001e-02f, -1.22133464e-01f, -7.94594660e-02f,
  -5.01376092e-02f, -1.46017194e-01f, -1.41341165e-01f, -5.53967245e-02f, -4.25334722e-02f, -1.80562660e-02f, -1.98414177e-01f, -2.96757042e-01f, -2.51361310e-01f, -4.64644395e-02f,
  -1.55098602e-01f, -2.40483731e-01f, -3.20033878e-01f, -1.31098941e-01f, 4.15675715e-02f, -5.64593188e-02f, 3.64864096e-02f, -5.47352470e-02f, -5.28982952e-02f, 1.08307321e-03f,
  2.40280971e-01f, -6.04822114e-02f, 9.89257824e-04f, -4.18634638e-02f, 2.80662253e-02f, -5.97923659e-02f, 5.18377405e-03f, -6.79096431e-02f, -3.17585543e-02f, 4.31118496e-02f,
  -1.03198388e-03f, 7.56673217e-02f, -6.51996136e-02f, 5.38977757e-02f, 3.01913042e-02f, -1.57161988e-02f, 4.95755300e-02f, -9.42153782e-02f, -6.31220415e-02f, 1.40734896e-01f,
  7.80463219e-02f, -8.88230950e-02f, -7.86107183e-02f, 1.35274261e-01f, 8.25435519e-02f, -7.82447383e-02f, 1.66232407e-01f, 1.29044771e-01f, 1.24538928e-01f, 1.19459052e-02f,
  3.94622646e-02f, -2.95064151e-02f, 1.37974415e-02f, 4.83997315e-02f, -9.84665602e-02f, 2.16801148e-02f, 1.91339981e-02f, -7.27898329e-02f, -3.11876321e-03f, -1.93070713e-02f,
  5.28625492e-03f, 9.07127038e-02f, 6.96512521e-04f, -4.27437872e-02f, 6.71754181e-02f, -7.08017796e-02f, -9.59017724e-02f, 6.16629757e-02f, 2.12211814e-03f, 4.95376624e-02f,
  -9.30028036e-02f, 5.16603962e-02f, 4.43104915e-02f, 3.04533876e-02f, 6.36337399e-02f, 2.99145631e-03f, 1.65683497e-02f, -1.27782105e-02f, -1.68725047e-02f, -8.21990296e-02f,
  1.45664271e-02f, -1.49218529e-01f, -7.84934089e-02f, 3.15282270e-02f, 6.92763403e-02f, 9.38113853e-02f, 2.77230628e-02f, 4.06201184e-02f, -7.93519467e-02f, -4.36628237e-02f,
  7.40594789e-02f, 3.87553871e-02f, -1.48545112e-02f, 1.20253004e-01f, 1.49354730e-02f, 6.49756566e-02f, 4.90449229e-03f, -7.44661912e-02f, -3.67153659e-02f, 3.86945345e-02f,
  8.93725231e-02f, -1.18441574e-01f, -1.51764035e-01f, -4.09070700e-02f, 8.22816640e-02f, -7.32513890e-02f, -2.72302143e-02f, 8.95143151e-02f, -3.69538441e-02f, -1.10680997e-01f,
  -1.44844502e-01f, 8.33740383e-02f, 2.21128404e-01f, -4.58959639e-02f, 8.41214955e-02f, 5.29569387e-02f, -2.24137716e-02f, -7.17938542e-02f, -1.14173658e-01f, -8.15676749e-02f,
  -6.43772632e-02f, -1.22898392e-01f, -1.42140370e-02f, -1.30317837e-01f, -1.64165884e-01f, -7.36548305e-02f, -7.86461234e-02f, 3.44070420e-02f, -4.18496542e-02f, -1.88177168e-01f,
  -1.33342564e-01f, -3.08463201e-02f, -7.97779635e-02f, -9.65897366e-02f, 3.47929378e-03f, -1.26846209e-01f, -1.09571218e-02f, -8.22599381e-02f, -8.38934109e-02f, -1.36679202e-01f,
  2.40719598e-02f, 1.90515205e-01f, -1.42086610e-01f, -1.12902686e-01f, 1.08998315e-03f, -5.73855564e-02f, 2.88789514e-02f, 1.21732123e-01f, 2.42163483e-02f, 4.92510274e-02f,
  -5.79249822e-02f, -8.31832886e-02f, 4.60357442e-02f, -5.82047328e-02f, 3.71220708e-02f, -7.33296722e-02f, -4.67380648e-03f, 7.30812699e-02f, -1.06882453e-02f, -5.28914966e-02f,
  -1.74459927e-02f, 2.71888115e-02f, -8.68199840e-02f, 4.08295803e-02f, 6.51628971e-02f, -1.46244600e-01f, 2.38354430e-02f, -4.66162525e-02f, -3.11008692e-02f, -1.33860752e-01f,
  -1.06594041e-01f, 6.72531426e-02f, -8.61595292e-03f, -2.21727435e-02f, -1.39244543e-02f, 8.43637958e-02f, -7.55634308e-02f, -1.72577761e-02f, -2.66976301e-02f, -8.03731307e-02f,
  -3.06007583e-02f, 6.15948997e-02f, -2.44149864e-02f, 3.99454571e-02f, -5.15701026e-02f, -1.48717873e-02f, -4.00971286e-02f, -1.85079705e-02f, 7.80864656e-02f, -7.98683390e-02f,
  -4.87021171e-02f, 3.91262621e-02f, -2.35236473e-02f, -2.50337832e-03f, 8.15895423e-02f, 6.52749985e-02f, 4.76748124e-02f, 6.67666048e-02f, -3.65430042e-02f, 6.61212727e-02f,
  -1.61557958e-01f, 2.12983951e-01f, -6.18593432e-02f, -7.34536052e-02f, -6.29206523e-02f, 3.79283503e-02f, 1.21940793e-02f, -2.62957457e-02f, 8.65594819e-02f, -5.20264059e-02f,
  1.61028188e-02f, -3.32772397e-02f, 3.94736305e-02f, -6.68878332e-02f, -6.55255914e-02f, -7.38711134e-02f, -1.40797332e-01f, -1.13426857e-01f, -5.88913681e-03f, -1.96652785e-02f,
  -9.87103283e-02f, -1.95154846e-01f, -2.18806371e-01f, -6.91849142e-02f, -8.85793194e-02f, -1.31380931e-01f, -6.35578558e-02f, -1.27556831e-01f, -2.00877681e-01f, -3.00337255e-01f,
  4.18079436e-01f, 4.97776084e-02f, -6.08406305e-01f, -1.61101520e-02f, -2.52103090e-01f, -2.74687022e-01f, -2.39580907e-02f, -1.40959146e-02f, -6.77200806e-05f, 9.30837635e-03f,
  -4.56242934e-02f, 1.50787324e-01f, 8.17988962e-02f, 4.85262387e-02f, 4.91035692e-02f, -8.14489722e-02f, -2.45377138e-01f, -1.06844544e-01f, -1.07854120e-01f, -2.61022132e-02f,
  2.79487390e-02f, 9.74653810e-02f, 1.51301950e-01f, -3.33328992e-02f, -9.15961340e-02f, -2.31573358e-02f, -1.22979484e-01f, -1.87418327e-01f, -1.69017613e-01f, -2.38779098e-01f,
  -3.84223402e-01f, -2.09321171e-01f, -9.09820944e-02f, 9.76429507e-02f, -4.29949202e-02f, 2.95991097e-02f, -1.85611274e-03f, -6.54723942e-02f, 8.43742192e-02f, -5.68226203e-02f,
  -1.39775127e-01f, 3.74033637e-02f, 3.46505120e-02f, -4.93225548e-03f, 1.19669631e-03f, -2.38310304e-02f, 3.09376027e-02f, -6.85343221e-02f, -1.22826889e-01f, -1.18799433e-01f,
  1.94835570e-02f, -4.04392779e-02f, -1.42512977e-01f, 2.39785574e-02f, -8.72823074e-02f, -1.49846539e-01f, -2.35187355e-02f, -1.58924028e-01f, -2.01853558e-01f, 3.34383100e-02f,
  -2.75213365e-02f, -2.75881737e-02f, 7.91647099e-03f, -9.20929853e-03f, 1.76531568e-01f, -7.77832568e-02f, 3.56463008e-02f, 5.81047758e-02f, -2.47918512e-03f, -1.49210040e-02f,
  2.88738608e-02f, 4.32275757e-02f, -2.68628579e-02f, 6.63982034e-02f, -3.63060203e-03f, -2.84386147e-03f, 5.66382669e-02f, 8.65833387e-02f, 7.14860559e-02f, 1.95671921e-03f,
  1.61307063e-02f, -6.35984121e-03f, -2.81957071e-02f, -9.96191800e-03f, -1.99141190e-03f, -7.68061131e-02f, -2.78628524e-02f, 9.06947777e-02f, 4.21005301e-02f, -5.77849988e-03f,
  3.59451205e-01f, -8.25385377e-02f, 4.53223102e-02f, 1.00324236e-01f, -6.77497908e-02f, -1.96211170e-02f, 5.13663003e-03f, 2.16108803e-02f, -1.49828559e-02f, -1.34177012e-02f,
  -1.79854594e-02f, 1.41907185e-01f, 4.05188985e-02f, 2.79735252e-02f, -2.89173014e-02f, -5.25468588e-02f, 2.13956594e-01f, -4.58318479e-02f, -2.53084023e-02f, 4.08648513e-02f,
  8.21580291e-02f, 1.21839143e-01f, 2.08776295e-01f, 9.20195971e-03f, 4.58899625e-02f, -8.54481384e-03f, 1.72053222e-02f, -4.54447092e-03f, 5.87648386e-03f, 4.53345329e-01f,
  -2.01628625e-01f, 2.03820556e-01f, -1.51617333e-01f, 8.59314054e-02f, 2.59877503e-01f, -3.79113443e-02f, -2.73124091e-02f, -1.54892862e-01f, 5.62305078e-02f, -3.09580518e-03f,
  6.40518591e-02f, -3.53876967e-03f, 6.30202144e-02f, -1.36442766e-01f, -1.51222453e-01f, -7.52871409e-02f, 1.01515390e-01f, -1.56271085e-01f, -1.01547077e-01f, -1.15560777e-01f,
  1.12209164e-01f, 1.02284178e-01f, -1.57683179e-01f, 1.26680788e-02f, 2.12951019e-01f, 1.63271293e-01f, 1.57758549e-01f, 7.63647854e-02f, 8.21201652e-02f, 2.22351819e-01f,
  3.46214697e-02f, -2.19650120e-01f, -4.44008373e-02f, 9.43385214e-02f, 1.64798766e-01f, -1.25451600e-02f, -1.12188354e-01f, -1.45663053e-01f, -1.07963316e-01f, -1.11177549e-01f,
  1.09926112e-01f, -9.25728753e-02f, 4.53147441e-02f, -4.62320149e-02f, -1.67906787e-02f, -8.56280029e-02f, -1.93814650e-01f, -2.34180897e-01f, -1.19838491e-01f, -1.79110065e-01f,
  9.02146250e-02f, 1.04189664e-01f, -4.75969426e-02f, -1.29430160e-01f, -9.38664079e-02f, -5.29296920e-02f, 2.80628297e-02f, -2.37936415e-02f, -1.40389264e-01f, -3.29406336e-02f,
  -3.82509604e-02f, -3.59752513e-02f, -2.62206420e-03f, 4.73891944e-03f, -6.49898350e-02f, 9.20103043e-02f, -1.88287124e-02f, 5.63821271e-02f, 1.83974896e-02f, 1.93172134e-02f,
  -7.17156008e-02f, 7.12513458e-03f, -5.35517149e-02f, -3.46359611e-02f, -9.76531766e-03f, 1.99560239e-03f, 1.37275048e-02f, 3.11517227e-03f, -1.35127185e-02f, 1.69017892e-02f,
  -6.03609234e-02f, 6.22242801e-02f, -4.60314006e-02f, -2.35582963e-02f, -2.53729150e-02f, 1.04671970e-01f, -2.33826283e-02f, 4.53130044e-02f, -6.00692928e-02f, 7.73956627e-02f,
  1.84493110e-01f, 1.59525555e-02f, 9.45447832e-02f, -1.16603956e-01f, 6.64663017e-02f, 1.13037126e-02f, -1.24209421e-02f, 2.41040904e-02f, -1.66687630e-02f, -1.35668993e-01f,
  -4.16709632e-02f, -1.35350510e-01f, 3.03775799e-02f, -1.00257635e-01f, 3.20133613e-03f, -1.22507073e-01f, 5.56139760e-02f, -7.04184175e-02f, -7.39951953e-02f, -8.56261700e-02f,
  9.63228792e-02f, -3.25885341e-02f, -4.98310626e-02f, -9.20129046e-02f, 2.43046675e-02f, 6.64351210e-02f, 4.46995273e-02f, -1.43237493e-03f, -1.69575095e-01f, -1.08991221e-01f,
  -2.51700699e-01f, -1.40181899e-01f, 1.59931421e-01f, -1.08641468e-01f, 2.88489107e-02f, 1.34437215e-02f, 1.07099421e-01f, -2.28012144e-03f, -9.60043594e-02f, 2.86364704e-02f,
  1.92450415e-02f, -6.17776066e-03f, 2.82655023e-02f, -1.84919927e-02f, -1.17829993e-01f, -7.71962553e-02f, -1.35807157e-01f, 1.02413885e-01f, 1.98050842e-01f, 1.60565004e-01f,
  5.16880024e-03f, -4.63139340e-02f, -1.98848657e-02f, -7.56795928e-02f, -7.03672469e-02f, -3.46557535e-02f, -6.67687356e-02f, -5.95792308e-02f, -8.59416127e-02f, -9.92699340e-02f,
  2.78921008e-01f, -1.16727039e-01f, 4.77727083e-03f, -1.03969797e-01f, -4.38003503e-02f, -6.77145272e-02f, 3.55360620e-02f, -9.61727127e-02f, 3.74056138e-02f, 5.88169359e-02f,
  -9.12862048e-02f, -8.01351666e-02f, -1.72364933e-03f, 6.87629953e-02f, -5.35226613e-02f, 6.65122643e-02f, -1.34602889e-01f, -1.06260650e-01f, -3.01895700e-02f, -5.65486960e-02f,
  -1.78218588e-01f, -8.44265241e-03f, -6.66092103e-03f, 4.66484763e-02f, 1.19885718e-02f, -9.96621251e-02f, 7.84432963e-02f, -5.10132052e-02f, -6.44578561e-02f, 7.79438391e-02f,
  6.90354779e-02f, -4.87988181e-02f, 1.62176099e-02f, -1.34248985e-03f, 8.21879953e-02f, -6.27864376e-02f, 5.78083806e-02f, 3.58149447e-02f, -1.20349210e-02f, -5.15021160e-02f,
  5.02366088e-02f, -6.76214844e-02f, -1.96605269e-02f, -5.56317419e-02f, 1.29412999e-02f, 3.11401114e-02f, -4.67557907e-02f, 2.64031943e-02f, -2.20454410e-02f, 3.72379646e-02f,
  -6.61603734e-02f, -1.14986589e-02f, -1.98941473e-02f, 9.25003290e-02f, -9.67984349e-02f, -4.82011959e-02f, -8.40813294e-03f, -2.76441965e-02f, 3.99065949e-02f, -8.46034810e-02f,
  2.29855165e-01f, -1.87245905e-01f, 5.69635816e-03f, 1.96588971e-02f, 5.47033027e-02f, -1.28785655e-01f, -5.06630503e-02f, -7.78582394e-02f, -5.00408374e-02f, 3.88826914e-02f,
  3.88998501e-02f, 6.94307089e-02f, -4.64305505e-02f, -5.59284240e-02f, 2.27030776e-02f, -1.51960254e-02f, -8.89617726e-02f, -1.68164223e-02f, -2.87709907e-02f, -1.19506335e-02f,
  -1.42002463e-01f, 1.19541429e-01f, 9.73356664e-02f, 1.12427570e-01f, 6.96678758e-02f, 1.19040832e-01f, 1.97944224e-01f, 1.77949727e-01f, 1.18355729e-01f, 2.85156118e-03f,
  6.30190643e-03f, -5.27532846e-02f, 7.41836578e-02f, 3.24615277e-02f, 1.69112049e-02f, 1.34564295e-01f, 1.29944459e-01f, 1.01774514e-01f, -1.43738287e-02f, -4.48390096e-02f,
  -1.50405392e-01f, -8.66387784e-02f, -1.31763309e-01f, -1.92022368e-01f, -3.62004973e-02f, 1.46015123e-01f, 1.55702204e-01f, -5.90143465e-02f, 7.25558773e-02f, 4.02308367e-02f,
  1.17885366e-01f, 5.52149378e-02f, 6.00148179e-02f, 2.48716846e-02f, -1.91599671e-02f, -5.67294769e-02f, 9.10149664e-02f, -8.12371746e-02f, -5.89270107e-02f, 6.16251081e-02f,
  5.64133562e-02f, -1.77479804e-01f, -6.80187568e-02f, -8.99700522e-02f, -1.20206349e-01f, -9.60817784e-02f, 7.41615742e-02f, -2.38496158e-02f, -1.48295403e-01f, -3.21775228e-02f,
  -1.11104883e-01f, -9.14782956e-02f, -3.34713347e-02f, -5.30862547e-02f, -1.29772210e-02f, -1.16543763e-03f, 5.43580540e-02f, -4.37052883e-02f, -4.08376493e-02f, -4.40971404e-02f,
  -5.81612214e-02f, -6.50875568e-02f, -1.40845537e-01f, -7.81479031e-02f, -1.48504660e-01f, -4.41849567e-02f, -1.39659140e-02f, -2.21301153e-01f, -9.99761745e-02f, 5.34363165e-02f,
  1.97668243e-02f, 1.46464873e-02f, -3.00676152e-02f, -4.00926359e-02f, 1.08450102e-02f, 2.51031388e-03f, 1.30587265e-01f, 3.36978026e-02f, 1.04594350e-01f, 2.42935326e-02f,
  -6.34412002e-03f, 2.39411071e-02f, 7.82408193e-02f, 5.64837642e-03f, 7.49692172e-02f, -5.00200391e-02f, 6.94394112e-02f, 3.12298350e-02f, -7.06687942e-02f, 2.90858578e-02f,
  6.05737083e-02f, -2.39336733e-02f, 5.05811460e-02f, -3.32724117e-02f, 3.67666930e-02f, -2.56723128e-02f, -1.93756130e-02f, -6.70628771e-02f, 4.18788306e-02f, -1.07276300e-02f,
  3.10053229e-01f, -1.61122188e-01f, 2.64905039e-02f, -1.05133787e-01f, -5.36789466e-03f, 2.21793354e-02f, -4.57831435e-02f, 1.89582426e-02f, -1.13113552e-01f, 1.76568162e-02f,
  -1.21235535e-01f, 2.43164077e-02f, -2.85234693e-02f, 1.02759495e-01f, 1.76984370e-01f, 1.04449376e-01f, -1.61003862e-02f, 3.29584554e-02f, -8.43875110e-02f, -4.16038074e-02f,
  5.58099821e-02f, 9.68566537e-02f, 1.26469076e-01f, 8.19604248e-02f, 7.28608435e-03f, 1.04245402e-01f, 8.33373517e-02f, 6.92270547e-02f, 1.21122018e-01f, 4.23128635e-01f,
  -4.79440354e-02f, 1.29561916e-01f, -1.70184642e-01f, 1.51824400e-01f, -3.36448327e-02f, -1.84876025e-01f, -1.86010703e-01f, -1.62729844e-02f, 5.37260212e-02f, 8.77980143e-02f,
  1.19002581e-01f, 1.02950977e-02f, -1.68803185e-01f, -2.93840915e-01f, -4.04748231e-01f, -2.76476234e-01f, -2.16402024e-01f, -3.89709532e-01f, -4.60374683e-01f, -3.06915134e-01f,
  -2.58489680e-02f, -1.18024811e-01f, -3.13100427e-01f, -1.00669749e-01f, 1.55353427e-01f, -2.00095214e-02f, 3.61203626e-02f, 3.97624411e-02f, -1.45244509e-01f, 4.67601791e-02f,
  -5.71999922e-02f, 7.02031106e-02f, -3.98550928e-02f, 2.37524230e-02f, 2.72807851e-02f, 5.04424497e-02f, 1.56585053e-02f, 2.79443501e-03f, 4.19729576e-02f, -4.34196889e-02f,
  7.64597803e-02f, 2.72172205e-02f, 7.96623677e-02f, -1.39085902e-02f, -5.44750728e-02f, -6.95200711e-02f, -2.99682748e-02f, -1.07439883e-01f, -1.25576615e-01f, -2.57341899e-02f,
  -7.95671623e-03f, 3.08628250e-02f, -2.22760141e-01f, -1.11426301e-01f, -2.06128433e-02f, -4.85235080e-02f, -1.38898566e-01f, -1.13225028e-01f, -2.10819125e-01f, 3.75001766e-02f,
  -9.47374403e-02f, 2.35245470e-02f, 1.92678440e-02f, 3.80710438e-02f, 1.26011092e-02f, 2.97745056e-02f, -2.54683867e-02f, -5.61546981e-02f, -3.43983546e-02f, -1.65139716e-02f,
  -6.13009147e-02f, 1.55982962e-02f, -3.29033285e-02f, 3.77132446e-02f, -4.67471443e-02f, -1.29609788e-02f, 4.31540199e-02f, -8.32618847e-02f, -6.25040978e-02f, -2.59305090e-02f,
  -9.34483204e-03f, -2.25460567e-02f, 7.66489729e-02f, -2.26515420e-02f, -2.52726935e-02f, -4.59742248e-02f, 4.34185266e-02f, -7.22634196e-02f, 5.90142123e-02f, -6.65520430e-02f,
  8.38699117e-02f, -1.42150506e-01f, -5.83375664e-03f, -8.19303542e-02f, 4.59032971e-03f, 9.31918100e-02f, 2.25245189e-02f, -5.36233149e-02f, 5.84356748e-02f, -7.06830397e-02f,
  -7.87836462e-02f, -9.30888113e-03f, 6.38427353e-03f, -3.26006091e-03f, -2.64172368e-02f, -2.31287330e-02f, 4.28295396e-02f, -1.20846294e-01f, -1.24024674e-01f, 1.20832212e-01f,
  -3.66369039e-02f, -2.04446539e-01f, -1.39128461e-01f, -1.41095698e-01f, -9.00527462e-02f, -8.86276215e-02f, -1.12706825e-01f, -1.03117108e-01f, -1.83560416e-01f, -2.19580352e-01f,
  -4.77646261e-01f, 3.15052122e-02f, -3.64669263e-02f, -3.42287511e-01f, -6.81715757e-02f, 2.85393268e-01f, 2.12988183e-01f, -7.87950645e-04f, -7.61382878e-02f, 1.47503223e-02f,
  5.98035045e-02f, -4.45013754e-02f, -1.72420308e-01f, -2.73131969e-04f, 7.36587271e-02f, 6.31805435e-02f, 5.15172370e-02f, 1.08571805e-03f, -6.96852338e-03f, 2.14680526e-02f,
  -7.63096586e-02f, -1.48900479e-01f, -2.25847200e-01f, -7.86057264e-02f, -2.02946663e-01f, -9.64501724e-02f, -3.15752253e-02f, -1.25226006e-01f, 4.58497414e-03f, -2.56015882e-02f,
  -1.33182015e-02f, -1.75168335e-01f, 6.18815683e-02f, -7.22622201e-02f, -4.90095243e-02f, 5.81827275e-02f, 7.28970161e-03f, -1.14084542e-01f, -1.15690507e-01f, 3.03335045e-03f,
  -4.41422537e-02f, -2.01806873e-02f, -1.58251181e-01f, 3.78398560e-02f, -1.19869173e-01f, 6.28187433e-02f, 4.54080142e-02f, -1.15642999e-03f, -2.23893374e-02f, 1.35233387e-01f,
  1.34812519e-01f, 2.34689601e-02f, -8.63157287e-02f, 6.16006926e-02f, 1.42922118e-01f, -5.03404103e-02f, 1.11747365e-02f, 7.34148398e-02f, 2.86391694e-02f, 1.92989893e-02f,
  9.00564268e-02f, -2.19826610e-03f, -1.57572906e-02f, -6.96288347e-02f, 3.88983972e-02f, 5.87381423e-02f, 7.31056631e-02f, -2.61913780e-02f, -3.82566378e-02f, -5.43431118e-02f,
  -2.92622913e-02f, 9.29156244e-02f, -4.59940992e-02f, -6.62492514e-02f, -2.65002251e-02f, 7.12705329e-02f, -1.37926396e-02f, -2.99607236e-02f, 2.64670476e-02f, -7.03792125e-02f,
  -2.01695990e-02f, 1.65191013e-03f, -6.12316728e-02f, -2.55434029e-02f, 1.20921299e-01f, -9.28038824e-03f, 1.50278471e-02f, 6.02353849e-02f, 6.94441572e-02f, -1.95009727e-02f,
  -2.62454182e-01f, 1.71286121e-01f, -4.57332060e-02f, -7.18416274e-02f, 1.33028561e-02f, -3.07295881e-02f, -4.73101102e-02f, -1.11250788e-01f, 8.91279895e-03f, -9.39133540e-02f,
  5.90971410e-02f, -1.86476123e-03f, 5.53921051e-03f, 3.92510705e-02f, -2.29509715e-02f, -3.44742425e-02f, 3.97267705e-03f, -1.46259174e-01f, 5.04350588e-02f, 7.52646104e-02f,
  1.25824912e-02f, -3.75243798e-02f, -8.13300014e-02f, -5.57969809e-02f, -3.54042859e-03f, -1.17751196e-01f, 3.79156992e-02f, 7.26957396e-02f, 7.49825910e-02f, 6.17101043e-03f,
  6.53220057e-01f, -2.83627838e-01f, -9.87964720e-02f, 3.88504416e-02f, -7.63292164e-02f, -1.51887648e-02f, -1.97224364e-01f, 4.02969271e-02f, 8.61702859e-02f, -8.94039646e-02f,
  9.67489704e-02f, 4.46725041e-01f, 3.53805810e-01f, 3.43783289e-01f, 2.57968724e-01f, -1.11649163e-01f, -1.89432994e-01f, 1.76794842e-01f, 3.09248149e-01f, 1.89542864e-03f,
  -6.38934597e-02f, -1.34018913e-01f, 7.24730417e-02f, -6.95088059e-02f, -2.78938740e-01f, 3.21893720e-03f, -2.29248747e-01f, -1.71855718e-01f, -6.33597448e-02f, -2.93090194e-01f,
  -9.44520831e-02f, 4.45049964e-02f, 1.22233711e-01f, 1.18961960e-01f, -1.09427527e-01f, 2.41664983e-02f, -5.07540023e-03f, -3.08372993e-02f, -1.48268277e-02f, -2.05557048e-01f,
  2.88160294e-02f, 7.08949491e-02f, 3.23585495e-02f, -1.41952693e-01f, -9.32396501e-02f, -2.13897079e-02f, -2.05445960e-02f, -3.30509804e-02f, -6.49840906e-02f, -6.61350191e-02f,
  -4.89375331e-02f, -7.99466297e-02f, 2.91632209e-02f, -4.68525477e-02f, 1.02293178e-01f, 2.10662246e-01f, -6.79179206e-02f, 1.51079781e-02f, 7.66135305e-02f, -1.69340715e-01f,
  -3.27093992e-03f, 7.35459402e-02f, 3.54485906e-04f, 4.29767519e-02f, 1.27810827e-02f, 7.94356316e-02f, -4.57732603e-02f, 1.00476043e-02f, 2.09609494e-02f, -7.95131270e-03f,
  -8.29101726e-02f, 7.61803091e-02f, -2.09664814e-02f, 5.33623621e-02f, 3.57996188e-02f, -8.85928273e-02f, -4.13543135e-02f, -3.18651795e-02f, 6.75880238e-02f, -1.36836730e-02f,
  1.08622655e-01f, 3.75865884e-02f, -8.45548734e-02f, -1.12569287e-01f, -4.89437021e-02f, 3.64369340e-02f, -1.29664307e-02f, 5.93621023e-02f, 1.92685984e-02f, -4.56434637e-02f,
  -2.19683677e-01f, 3.59725177e-01f, 1.55133419e-02f, -5.66474581e-03f, -2.22822912e-02f, 1.91547964e-02f, 4.53710705e-02f, -7.06540495e-02f, -6.86924383e-02f, -1.84661180e-01f,
  -1.11577734e-01f, 5.25270123e-03f, -7.42352530e-02f, -4.69111316e-02f, 2.46905014e-02f, -6.39112368e-02f, -3.66432816e-02f, 9.34451669e-02f, -7.73910806e-02f, -2.21048206e-01f,
  -1.34809256e-01f, 1.54707655e-01f, 1.99257702e-01f, 1.31799147e-01f, 7.95873925e-02f, 3.50346237e-01f, 1.67061780e-02f, -1.63034201e-02f, 2.35966787e-01f, -9.93802398e-02f,
  -8.10173273e-01f, 1.49513543e-01f, 3.29443872e-01f, -3.12377036e-01f, -6.06437586e-03f, 1.85953528e-01f, 2.57917136e-01f, 3.87375467e-02f, -2.73701459e-01f, -2.89021675e-02f,
  1.93634145e-02f, -1.78550780e-01f, -8.05346072e-02f, 5.85202239e-02f, 1.57514140e-01f, 2.06590340e-01f, 3.18761468e-01f, 1.57602549e-01f, -3.76019031e-02f, -2.94471495e-02f,
  4.51330394e-02f, -6.50039166e-02f, -1.31890953e-01f, 4.41655144e-02f, -1.27522275e-01f, -4.57185134e-02f, 2.39854157e-02f, 5.02045676e-02f, 6.43945783e-02f, -1.49222076e-01f,
  -1.86127380e-01f, -2.50035495e-01f, 8.66358429e-02f, -1.01552956e-01f, 4.41721529e-02f, -1.79547757e-01f, -8.09101611e-02f, -9.21193957e-02f, -1.14455009e-02f, -1.17028639e-01f,
  1.27934972e-02f, -1.38306648e-01f, -6.30483925e-02f, -1.05045922e-01f, -1.78668395e-01f, -9.30986479e-02f, -4.30936702e-02f, 1.69855338e-02f, 1.15279384e-01f, -1.20285466e-01f,
  6.35880157e-02f, 2.25610193e-02f, -3.29344459e-02f, 5.07925712e-02f, -2.09206361e-02f, -1.59236800e-03f, -5.31436317e-02f, -1.62494704e-01f, 7.56537542e-02f, -3.15108836e-01f,
  -1.04400599e-02f, 4.77826074e-02f, 9.30948928e-02f, -9.30434372e-03f, -5.01014180e-02f, -6.10712506e-02f, 9.54993721e-03f, 3.25648934e-02f, 1.00026326e-03f, -1.19247446e-02f,
  5.17598130e-02f, 3.32318731e-02f, -6.11268124e-03f, -1.37616634e-01f, 3.19484510e-02f, -4.45708930e-02f, 1.19826816e-01f, 1.63568147e-02f, 1.93723198e-02f, 6.94664642e-02f,
  -3.08446996e-02f, -8.44109058e-03f, -9.34537873e-03f, 8.61042738e-02f, 2.67755408e-02f, 6.18551783e-02f, -5.48621304e-02f, -2.05665212e-02f, -1.79953016e-02f, -8.48844126e-02f,
  -4.18501467e-01f, 4.82427806e-01f, -2.60669976e-01f, -1.54407099e-01f, -9.50439721e-02f, 7.02024326e-02f, -3.27682421e-02f, 5.23057282e-02f, -6.82692155e-02f, -7.53518119e-02f,
  -4.09259275e-02f, -7.07356334e-02f, -1.56505462e-02f, 5.08593321e-02f, -1.02501614e-02f, -1.00377232e-01f, 2.77947467e-02f, -8.42664950e-03f, 1.01921238e-01f, -1.39758676e-01f,
  4.80076857e-02f, -4.32845280e-02f, -1.99679017e-01f, -8.22642371e-02f, -1.22194417e-01f, -1.28098771e-01f, -1.01059638e-01f, -1.32914811e-01f, -7.75904208e-02f, -3.05054486e-01f,
  -1.19763680e-01f, -3.48289639e-01f, -5.75900853e-01f, -3.36153656e-01f, -1.66892186e-01f, -4.83648255e-02f, 5.29587530e-02f, 4.33430672e-02f, -9.02756825e-02f, -2.10258529e-01f,
  -8.56953934e-02f, -6.35677874e-02f, -2.01908365e-01f, 1.59229189e-02f, -9.78524908e-02f, -2.48747259e-01f, -2.68671006e-01f, -2.73999393e-01f, -5.11827786e-03f, -3.04711647e-02f,
  -1.76216029e-02f, -2.14512959e-01f, -1.80233464e-01f, -1.10763967e-01f, -3.31889510e-01f, -1.76299810e-01f, -4.08251166e-01f, -3.69000316e-01f, -1.95731163e-01f, -4.25730735e-01f,
  -2.19209149e-01f, -1.13460690e-01f, 8.76399651e-02f, 4.89958264e-02f, -2.14699924e-01f, 1.00043528e-01f, -5.78557700e-02f, -7.41753951e-02f, 5.23130111e-02f, -7.01551437e-02f,
  -5.33279702e-02f, 4.98014763e-02f, -4.69348729e-02f, -6.27476256e-04f, -1.14116147e-01f, 5.51934317e-02f, -9.03995261e-02f, -8.30492750e-03f, -4.80857529e-02f, -2.21959110e-02f,
  2.49454919e-02f, 6.77267974e-03f, -2.36691348e-02f, 3.83856311e-03f, 4.66081426e-02f, -3.15159336e-02f, -4.27316725e-02f, -3.14584002e-02f, -6.41976297e-02f, -1.06467076e-01f,
  -4.90066670e-02f, -3.65315676e-02f, 3.40963784e-03f, -4.92283190e-03f, 4.98506576e-02f, -1.14926847e-03f, -1.33323967e-01f, 4.97584753e-02f, -2.99531501e-02f, -1.42422067e-02f,
  -6.11201022e-03f, -3.54236253e-02f, -6.15973584e-02f, -1.97699610e-02f, -1.01856135e-01f, 2.31415667e-02f, 3.70859802e-02f, 2.57932954e-02f, -1.99668184e-02f, 1.56318769e-04f,
  1.07033476e-02f, 3.37545052e-02f, -4.92119370e-03f, 5.91243804e-02f, -1.68204308e-02f, -2.54123341e-02f, 5.72017580e-02f, 7.73841441e-02f, -4.46918197e-02f, 9.91046876e-02f,
  -1.80077508e-01f, 7.69797042e-02f, 2.73632016e-02f, 1.43076926e-01f, -1.19246624e-01f, 1.05651282e-02f, -6.90463260e-02f, 8.73415172e-02f, -2.33603511e-02f, 3.14187594e-02f,
  4.23723459e-02f, -5.06314598e-02f, -1.04407892e-01f, -4.04137000e-02f, 3.23140658e-02f, 1.09894328e-01f, -2.65244562e-02f, -8.40565637e-02f, 1.92788839e-02f, -3.42254043e-02f,
  -4.29962575e-02f, 4.72585857e-02f, 2.34093741e-02f, 1.10206380e-01f, 8.21808875e-02f, 1.03115905e-02f, -1.00808339e-02f, 1.09057039e-01f, 9.02582705e-02f, 6.76392019e-02f,
  3.85247111e-01f, -2.93638974e-01f, -6.29538074e-02f, 2.98622489e-01f, 2.86225915e-01f, 1.08954191e-01f, 1.15016520e-01f, 1.84893534e-01f, 2.53426671e-01f, 1.11727268e-02f,
  -2.47989133e-01f, -2.55434185e-01f, -1.91328153e-01f, -1.67210102e-01f, -2.21626788e-01f, 3.29318009e-02f, 1.32904083e-01f, 9.84053165e-02f, 5.20263463e-02f, 2.77755260e-02f,
  5.89100495e-02f, 1.27118379e-01f, 3.70097533e-02f, 6.92091556e-03f, 7.02940822e-02f, -4.59388420e-02f, 7.90627599e-02f, -1.73354391e-02f, -7.29501545e-02f, -3.03827524e-02f,
  -3.15204501e-01f, -2.42172956e-01f, 1.01098999e-01f, -9.71918777e-02f, -1.57753050e-01f, -7.34033138e-02f, -8.24445933e-02f, -8.62144977e-02f, -4.50831354e-02f, 3.83696705e-02f,
  -1.53269500e-01f, -1.77891962e-02f, -9.86261889e-02f, -3.70619260e-02f, 3.47101539e-02f, -4.16848175e-02f, -3.48329321e-02f, -4.78121899e-02f, -7.55574927e-02f, -1.06926799e-01f,
  -2.28756309e-01f, 2.36084163e-02f, -8.17104429e-02f, -5.33125810e-02f, -9.57759917e-02f, -7.27174850e-03f, -2.00593725e-01f, -1.25198290e-01f, -8.68870616e-02f, 6.37095496e-02f,
  8.37152228e-02f, 6.82175253e-03f, -5.23839742e-02f, 3.56575735e-02f, 6.66564628e-02f, 1.10974550e-01f, -1.66586041e-02f, 5.37056141e-02f, -2.26688832e-02f, 3.84637378e-02f,
  3.13471034e-02f, -2.79056784e-02f, -2.40589920e-02f, 4.73475009e-02f, -4.82445583e-02f, -4.38643731e-02f, 6.57068044e-02f, -7.60487244e-02f, -1.22841718e-02f, 7.97724277e-02f,
  2.51552947e-02f, 8.57448056e-02f, 1.17207561e-02f, -7.80063719e-02f, -7.40589993e-03f, -3.12372874e-02f, 1.85121060e-03f, -2.78920047e-02f, -2.12552156e-02f, 1.06775470e-01f,
  3.22780013e-02f, -6.65691197e-02f, 1.22940883e-01f, 6.86492473e-02f, 9.27640498e-02f, -5.63146472e-02f, 2.15552351e-03f, -3.96517775e-04f, -9.08641890e-02f, -1.51900239e-02f,
  -6.54362217e-02f, -4.51911055e-02f, -1.22913882e-01f, 4.75674216e-03f, 1.25547528e-01f, 9.12688524e-02f, 4.29856554e-02f, 3.87752391e-02f, -4.45404835e-02f, -5.36136664e-02f,
  2.69267391e-02f, 3.38784873e-01f, 3.31731707e-01f, 2.19128370e-01f, 1.08738476e-02f, 2.18497828e-01f, 1.08052947e-01f, 1.83781758e-01f, 1.21818319e-01f, 4.07003433e-01f,
  1.44830540e-01f, 2.00497016e-01f, -2.48185366e-01f, -5.26212119e-02f, -1.65075988e-01f, -2.81667203e-01f, 3.51568460e-02f, -6.29864708e-02f, 8.53698608e-03f, 1.16665326e-01f,
  -5.90058565e-02f, -1.50762824e-03f, -7.78986067e-02f, 5.86818382e-02f, -2.83434279e-02f, 2.05264557e-02f, -7.48186260e-02f, -8.51081777e-03f, -2.20546678e-01f, -1.22208193e-01f,
  -1.03326172e-01f, -2.29814928e-02f, 1.10106613e-03f, -1.26130372e-01f, -4.17635366e-02f, -6.36211261e-02f, -7.57578909e-02f, -1.65779382e-01f, -1.08968362e-01f, -4.56248708e-02f,
  -1.36053279e-01f, -2.09493995e-01f, 3.20884623e-02f, 5.75818121e-02f, -2.19060946e-02f, 7.32984394e-02f, -2.43991651e-02f, 4.85438155e-03f, 9.16422606e-02f, 1.00903101e-01f,
  -4.40669879e-02f, 2.16037314e-02f, -1.09001070e-01f, -6.64457828e-02f, 3.25158089e-02f, -3.94615270e-02f, 1.34798642e-02f, -8.36581737e-03f, 6.81275725e-02f, -5.39125614e-02f,
  3.85360569e-02f, -2.52351840e-03f, -1.28617093e-01f, -1.17573971e-02f, -1.55936196e-01f, -5.18298429e-03f, -1.07281454e-01f, -1.17361873e-01f, -4.02404666e-02f, 8.13269913e-02f,
  -2.00460739e-02f, 8.03691987e-03f, -2.45258640e-02f, 7.71769583e-02f, -2.86927093e-02f, -2.44523957e-02f, -2.15418451e-02f, 5.44934608e-02f, -5.56017160e-02f, -6.20499253e-03f,
  5.58700226e-02f, -1.61022022e-02f, 4.82525080e-02f, 5.70187196e-02f, 3.04813292e-02f, -1.25311673e-01f, -3.12920772e-02f, -2.74591930e-02f, 7.08203763e-02f, 4.02431935e-02f,
  4.71713804e-02f, -1.24400914e-01f, -9.40694213e-02f, 5.64832315e-02f, 3.46731357e-02f, -5.00789657e-02f, -4.60923463e-02f, -1.08145503e-02f, 3.20997052e-02f, -1.22747764e-01f,
  1.20398141e-01f, 3.27195186e-04f, 3.09856664e-02f, -5.59427254e-02f, -6.36434257e-02f, -2.19066124e-02f, -3.02021652e-02f, 6.64406568e-02f, -1.13072336e-01f, 5.05338609e-03f,
  -1.31213427e-01f, 5.99968433e-03f, 2.80784033e-02f, 5.56978136e-02f, -4.11576927e-02f, -8.48994479e-02f, 1.95553496e-01f, 7.19724298e-02f, -5.73879890e-02f, -9.87937227e-02f,
  1.25219926e-01f, 4.85086367e-02f, 1.61883578e-01f, 7.77648538e-02f, 4.17176336e-02f, 8.08914453e-02f, -5.92137203e-02f, -1.06563363e-02f, 4.81466390e-02f, 2.83010602e-01f,
  2.02696681e-01f, 2.89569169e-01f, -1.30458176e-02f, -5.33772213e-03f, -2.77315438e-01f, -3.14349085e-01f, -3.65936428e-01f, -1.94312379e-01f, -9.50644538e-02f, 1.13617681e-01f,
  -6.48333058e-02f, -1.02930233e-01f, -7.24988952e-02f, 8.42169374e-02f, -8.17700326e-02f, 2.07235180e-02f, 1.30085438e-01f, 1.63671181e-01f, -4.76389714e-02f, -1.70757443e-01f,
  -1.74346063e-02f, 4.47310470e-02f, 2.47967452e-01f, 1.28105462e-01f, 2.31623754e-01f, 5.61500154e-02f, 1.12554327e-01f, 1.09203741e-01f, 5.05497232e-02f, 4.59988326e-01f,
  2.65929282e-01f, 1.96953025e-02f, -2.04305500e-01f, -7.59509532e-03f, -1.09235547e-01f, 7.92646781e-03f, -4.27454785e-02f, 3.14917825e-02f, -2.29713339e-02f, 1.58970729e-02f,
  -5.44014461e-02f, 3.90759744e-02f, -1.00156680e-01f, 2.57861353e-02f, -9.10910368e-02f, -1.30870596e-01f, 9.51186493e-02f, 5.75823188e-02f, -3.80650647e-02f, -7.03729168e-02f,
  -6.86675981e-02f, -3.48416902e-02f, -2.10528076e-01f, -1.59857333e-01f, -1.14067063e-01f, -1.22138612e-01f, -1.34267733e-01f, -6.85977191e-02f, -8.00966173e-02f, 1.77024066e-01f,
  -1.62075385e-02f, -1.88551880e-02f, -6.44820482e-02f, 1.17356526e-02f, 6.13987446e-02f, -5.87757826e-02f, -4.55931900e-03f, 7.07290694e-02f, -3.62535082e-02f, -6.30440041e-02f,
  -1.08123265e-01f, -8.15305579e-03f, -1.26126036e-01f, 2.22137105e-02f, -4.23130393e-02f, 2.15574242e-02f, -7.27630928e-02f, 1.49340751e-02f, -2.90639717e-02f, 2.34795678e-02f,
  -5.25671393e-02f, 3.61773856e-02f, 4.47643548e-03f, 4.13869731e-02f, -7.54761919e-02f, -3.33144963e-02f, 7.46811107e-02f, 2.64183469e-02f, 2.85717808e-02f, 9.68625620e-02f,
  3.49891447e-02f, -4.23938185e-01f, 1.47185519e-01f, 8.61132145e-03f, -1.19133480e-02f, 2.29037181e-03f, 3.40930652e-03f, 6.92166016e-02f, -8.84046629e-02f, -2.68046521e-02f,
  -3.04598939e-02f, -4.21110168e-02f, -5.49783558e-02f, -1.02756722e-02f, -1.14345714e-01f, -4.88048196e-02f, 6.81050196e-02f, -9.47515219e-02f, -1.10900484e-01f, -6.81580380e-02f,
  -4.74128835e-02f, -1.22803561e-01f, -6.26769811e-02f, -1.75672054e-01f, -1.03464782e-01f, -1.58254012e-01f, 7.02894246e-03f, -5.78450486e-02f, -1.17981695e-01f, 9.53018889e-02f,
  -6.64389789e-01f, 1.91239849e-01f, 1.17695153e-01f, -3.26030046e-01f, -5.23435697e-02f, -1.82199944e-02f, 9.86993983e-02f, -1.72810420e-01f, -9.23996493e-02f, 1.77896529e-01f,
  1.31933928e-01f, -7.07084015e-02f, 2.59119235e-02f, -1.19168781e-01f, -1.56751812e-01f, 1.05005272e-01f, -4.71577346e-02f, -2.70966589e-01f, -3.19156617e-01f, -2.01526567e-01f,
  -4.95822802e-02f, -2.54579097e-01f, -2.64410317e-01f, -2.20825970e-01f, 9.51409191e-02f, -4.15981412e-02f, 1.66997194e-01f, -8.55727028e-03f, 1.30058110e-01f, 1.59439668e-01f,
  5.93009949e-01f, -2.30415791e-01f, -1.06925637e-01f, -2.01406106e-01f, 5.31265605e-03f, 3.48496065e-02f, 4.56547774e-02f, -6.39999192e-03f, -4.01712321e-02f, -8.21244065e-03f,
  -3.96944163e-03f, 1.60856098e-02f, -8.29267651e-02f, 6.68714121e-02f, -8.73747543e-02f, 4.33883592e-02f, -1.61266536e-01f, -1.20620459e-01f, -1.07547492e-02f, 1.72452718e-01f,
  9.53478143e-02f, 3.57494876e-02f, 3.34143490e-02f, -1.48113500e-02f, -7.48647898e-02f, -7.25902170e-02f, 4.29678708e-02f, -3.66072431e-02f, 2.55855061e-02f, 1.12753168e-01f,
  2.61366330e-02f, 1.21139266e-01f, -6.84855506e-02f, -6.96759820e-02f, 5.93884960e-02f, 4.26622704e-02f, -4.17547747e-02f, 7.50313997e-02f, -7.00372234e-02f, 8.91917273e-02f,
  8.28806758e-02f, 1.36566078e-02f, 4.55103293e-02f, 4.46976125e-02f, -1.14919050e-02f, -1.58890206e-02f, 6.41817525e-02f, 7.76790008e-02f, 4.97560995e-03f, -2.74362992e-02f,
  1.73185393e-02f, 3.16740535e-02f, 4.19047996e-02f, -3.77816558e-02f, 8.47092364e-03f, 5.17434329e-02f, 1.46499388e-02f, 8.21579248e-02f, -1.04223557e-01f, -7.19551891e-02f,
  1.10148020e-01f, -2.43734926e-01f, 1.19328253e-01f, -9.60686356e-02f, -9.74475872e-03f, -4.69041541e-02f, 1.13333933e-01f, 1.20335352e-02f, 4.84618396e-02f, 2.86621843e-02f,
  1.19714057e-02f, -7.45019242e-02f, -2.37218011e-03f, 1.08543904e-02f, -9.67950895e-02f, -4.23639193e-02f, -6.23763017e-02f, -4.46947627e-02f, -7.39039406e-02f, 1.48838490e-01f,
  1.08270064e-01f, -5.90278208e-02f, 2.11094506e-02f, 1.64878070e-01f, -8.79629701e-03f, 4.53962572e-02f, 1.31452411e-01f, 1.68573305e-01f, -1.38234384e-02f, 9.00242478e-02f,
  -4.77065533e-01f, -7.58477375e-02f, -1.95870176e-01f, 2.30520263e-01f, 1.74700245e-01f, 1.83836117e-01f, 1.09674983e-01f, 4.29096669e-02f, 1.01732522e-01f, -3.76714282e-02f,
  3.71711850e-02f, 1.65822327e-01f, 7.76254386e-02f, 1.64260790e-01f, -1.50770163e-02f, 8.41520652e-02f, 2.38276318e-01f, 6.02994999e-03f, -7.92395324e-03f, 4.92432453e-02f,
  1.85551554e-01f, 2.78056748e-02f, -1.27859980e-01f, 2.29045320e-02f, 2.01586738e-01f, 1.30201772e-01f, 1.68087729e-03f, 6.15277030e-02f, 1.36133805e-01f, 2.82425314e-01f,
  -2.17821121e-01f, -4.02241498e-01f, 2.74526943e-02f, -1.44540425e-02f, -3.57294045e-02f, -1.37136683e-01f, -1.04714662e-01f, -1.31181017e-01f, -4.56544198e-02f, 3.62286344e-02f,
  7.00024366e-02f, -6.26665130e-02f, 5.44781238e-02f, 1.15353381e-02f, -1.21739507e-01f, -2.34311987e-02f, -6.18984699e-02f, -1.64293289e-01f, -1.26994506e-01f, -1.92032427e-01f,
  9.95398313e-02f, -8.32765643e-03f, -1.55632719e-01f, -5.82652576e-02f, -5.94934449e-02f, -3.36310267e-02f, -1.72729328e-01f, -1.51513040e-01f, -2.56653637e-01f, -2.20520601e-01f,
  5.43640926e-02f, -2.88531296e-02f, -3.25595289e-02f, -2.26570908e-02f, 7.27047846e-02f, 1.35989618e-02f, 3.37922312e-02f, 9.21866223e-02f, -3.04909982e-02f, -1.69399697e-02f,
  -4.60444391e-03f, -1.70006733e-02f, -8.60754699e-02f, -7.61015574e-03f, 7.27844238e-02f, 2.50158887e-02f, 1.77239235e-02f, -3.88084278e-02f, 3.61661874e-02f, -1.21283114e-01f,
  -7.89121613e-02f, -1.47999143e-02f, -1.64913256e-02f, 7.40657523e-02f, -3.64904366e-02f, -1.57657396e-02f, 1.88668575e-02f, -3.07182316e-02f, -1.57231987e-02f, -9.03006792e-02f,
  3.47994268e-02f, -8.53742138e-02f, 3.03936168e-03f, -4.31051804e-03f, 1.44432364e-02f, -8.43191519e-02f, 5.76080270e-02f, -2.98394617e-02f, 4.28815670e-02f, -5.74609265e-02f,
  -5.55316918e-02f, -9.59313437e-02f, -7.83991963e-02f, -3.26708262e-03f, -3.55810970e-02f, -3.95018113e-04f, -3.36080901e-02f, 1.18481405e-02f, -9.98763517e-02f, -3.07793971e-02f,
  8.44291970e-02f, -1.42932102e-01f, -2.13577062e-01f, -1.79881770e-02f, -1.17918953e-01f, 8.25319290e-02f, -2.21460104e-01f, -3.46995629e-02f, -1.75139755e-01f, -1.94436997e-01f,
  1.55492022e-03f, -1.71960637e-01f, -4.75512534e-01f, -1.74713567e-01f, -3.13285328e-02f, -4.58850712e-03f, 3.54830883e-02f, 1.66349411e-01f, -3.84323485e-02f, -1.37065083e-01f,
  7.11397594e-03f, 1.15302548e-01f, -8.03024098e-02f, 2.49487907e-02f, 6.36000559e-02f, -2.41862863e-01f, -2.78796554e-01f, -1.16808802e-01f, 1.11046068e-01f, 3.09287876e-01f,
  1.13427170e-01f, 5.42381406e-02f, 2.45308243e-02f, -4.25281152e-02f, -1.05454996e-01f, -9.48429629e-02f, -2.22598314e-01f, -3.39289233e-02f, -5.40299080e-02f, -2.41338596e-01f,
  5.99669898e-03f, -1.02193423e-01f, 9.85499397e-02f, 7.31370673e-02f, -1.59036726e-01f, -3.86727154e-02f, -6.22332692e-02f, -6.10179901e-02f, -6.86251968e-02f, -9.84219182e-03f,
  -8.56031403e-02f, 9.84082185e-03f, -3.77406813e-02f, 2.58625578e-02f, 8.39095116e-02f, -2.93535516e-02f, 1.20781092e-02f, -1.31620035e-01f, 9.27847624e-03f, 6.71366602e-02f,
  -8.47524405e-02f, -1.32425860e-01f, -1.05216511e-01f, -3.45988460e-02f, -6.20453805e-02f, -4.91802543e-02f, -2.99808625e-02f, -4.50071916e-02f, -2.07316745e-02f, 1.15307264e-01f,
  4.91153337e-02f, -8.56223106e-02f, 1.29229771e-02f, -1.34397438e-02f, 6.79295510e-02f, -1.54186215e-03f, -5.55106699e-02f, -1.29508262e-03f, 1.31020099e-01f, 2.68593673e-02f,
  -2.44707381e-03f, -6.95499256e-02f, 1.12130512e-02f, 3.29720452e-02f, -4.58238684e-02f, -3.97893004e-02f, -9.92571637e-02f, 5.32666557e-02f, -5.48275448e-02f, 1.16593828e-02f,
  -2.53305882e-02f, 3.54376659e-02f, -1.96796414e-02f, -3.00827087e-03f, -1.62728488e-01f, -1.09556317e-03f, -5.45750037e-02f, 3.86722758e-02f, -3.52261728e-03f, 5.55425941e-04f,
  1.89258799e-01f, -1.14547946e-01f, -1.22537268e-02f, 1.13965437e-01f, -1.85116798e-01f, -2.42668279e-02f, -4.68681231e-02f, -6.48833141e-02f, -7.97894150e-02f, -1.97278429e-03f,
  -8.95616226e-03f, -2.56689247e-02f, -1.70724820e-02f, 2.98506953e-03f, 1.32841468e-01f, 1.02437422e-01f, -5.05148321e-02f, -1.04394117e-02f, -1.08015001e-01f, 5.05643189e-02f,
  -3.20698321e-02f, -3.52884978e-02f, -4.60959785e-03f, 1.30338008e-02f, -1.34534650e-02f, -2.91313194e-02f, -1.71716288e-02f, 4.15107282e-03f, 7.46591669e-03f, 9.75057110e-02f,
  -2.20976561e-01f, -6.35121837e-02f, 7.98934996e-02f, -2.14660451e-01f, -1.40669167e-01f, -2.18296811e-01f, -2.25179747e-01f, -1.21554852e-01f, -1.56370297e-01f, -1.48943663e-01f,
  -1.09226532e-01f, -7.81222358e-02f, 9.87311751e-02f, 2.47017369e-02f, -4.50194441e-02f, -6.45238115e-03f, 1.02069303e-02f, -3.06002200e-02f, -3.41874361e-02f, -1.15892343e-01f,
  -1.99694857e-01f, -5.26931398e-02f, -1.44093767e-01f, -7.44849071e-02f, -2.38198005e-02f, 8.06291923e-02f, 2.40916591e-02f, 1.74408108e-02f, -5.23968646e-03f, -4.17555720e-02f,
  3.27476561e-01f, -2.47586012e-01f, 4.37847115e-02f, -2.94278003e-02f, 3.68866213e-02f, -4.33071777e-02f, 1.08273858e-02f, 8.98877308e-02f, -9.23433006e-02f, 1.15499366e-02f,
  -4.39233445e-02f, -1.22955382e-01f, -9.60971490e-02f, -1.42195700e-02f, -3.16735171e-02f, -3.03784641e-03f, 5.50159439e-02f, 4.43493612e-02f, -6.60350248e-02f, -5.26325628e-02f,
  -7.29334801e-02f, -1.41493306e-01f, -1.07431956e-01f, -2.21783649e-02f, -1.68826841e-02f, -1.12099424e-01f, 9.17396098e-02f, -2.50963401e-02f, -3.62066664e-02f, 6.76646978e-02f,
  -1.92204881e-02f, -2.61094398e-03f, 4.54596803e-02f, 6.57559931e-02f, 2.37250384e-02f, 2.47917194e-02f, 1.30424174e-02f, 8.44622105e-02f, -5.64609608e-03f, -1.35862809e-02f,
  3.05648409e-02f, -9.50655900e-03f, 7.64042288e-02f, 4.01408337e-02f, 1.46599617e-02f, 2.20096111e-02f, -4.22706967e-03f, 4.02613403e-03f, 5.75260632e-02f, -1.13092005e-01f,
  -8.03328231e-02f, -6.59312755e-02f, 5.13811894e-02f, 3.46735641e-02f, -5.35203330e-02f, -6.64738342e-02f, -7.14533255e-02f, 2.88277287e-02f, -3.98235284e-02f, -9.33242291e-02f,
  3.22958410e-01f, -4.41293232e-02f, -3.92791107e-02f, -6.17879033e-02f, 1.31957969e-02f, -2.21233089e-02f, -3.15616578e-02f, 6.26084954e-02f, 4.19045091e-02f, -7.00086681e-03f,
  -8.73227939e-02f, 3.87241840e-02f, 9.10311937e-02f, -5.99163808e-02f, -1.99691392e-02f, -2.99486779e-02f, -3.70571204e-03f, 5.51254638e-02f, 1.44764744e-02f, -1.52392033e-02f,
  1.02815591e-02f, -5.64209148e-02f, 2.28332877e-02f, 1.48836464e-01f, 4.29647714e-02f, 1.97765213e-02f, 8.61788467e-02f, -3.57274599e-02f, 9.90858749e-02f, 1.30364433e-01f,
  3.45956206e-01f, 2.45361075e-01f, 3.65249008e-01f, 1.15521006e-01f, 5.08716345e-01f, 4.87347811e-01f, 4.89288241e-01f, 2.23056152e-01f, 1.06015526e-01f, 9.74205732e-02f,
  2.79619377e-02f, -2.18914807e-01f, -3.13204795e-01f, -3.02056462e-01f, -1.48182333e-01f, 4.70544659e-02f, -7.70132616e-03f, -1.40093863e-01f, -1.17970789e-02f, -5.18181100e-02f,
  -1.31118864e-01f, 8.06076825e-02f, 6.56084158e-03f, -8.26711673e-03f, -1.56251341e-01f, -2.11469442e-01f, 2.42016278e-02f, 1.20474838e-01f, -3.55799049e-02f, -3.17014158e-01f,
  -2.22562000e-01f, 2.98152179e-01f, -2.35303864e-01f, -2.22486272e-01f, 7.06494898e-02f, -6.57522604e-02f, -6.17685877e-02f, -6.54116496e-02f, 3.81803960e-02f, -1.47341657e-02f,
  -1.20812012e-02f, -1.24684893e-01f, -7.72909671e-02f, -9.91761833e-02f, 6.74671754e-02f, -6.77629933e-02f, -1.06232585e-02f, -1.19406082e-01f, -1.88773066e-01f, -1.59476161e-01f,
  -1.64661065e-01f, 9.36543494e-02f, 3.46748948e-01f, 9.72665995e-02f, -4.80811335e-02f, -1.24333963e-01f, 1.67800933e-01f, -2.14641666e-04f, 3.34779732e-02f, -3.64730097e-02f,
  -9.76003855e-02f, -2.16609631e-02f, 3.13956924e-02f, 4.14106920e-02f, -3.70940007e-02f, -6.63701119e-03f, -1.25337821e-02f, 6.48718625e-02f, -2.96377540e-02f, 1.33055881e-01f,
  -6.69062361e-02f, -2.40927450e-02f, -8.91282707e-02f, -3.10750073e-03f, -1.49115816e-01f, 3.78391333e-02f, -7.52831399e-02f, -1.62795931e-02f, 3.61860320e-02f, -2.14905464e-04f,
  -3.35654616e-02f, 2.46045031e-02f, 3.89204808e-02f, -9.23939571e-02f, -5.51568381e-02f, -1.74047367e-03f, -1.13343947e-01f, 3.10295951e-02f, 1.12803755e-02f, 4.21873815e-02f,
  -8.78484920e-02f, 1.91972613e-01f, -1.66125506e-01f, -1.98028237e-01f, 5.46155311e-02f, -1.36475608e-01f, -3.92591255e-03f, -5.34280576e-02f, 4.30617891e-02f, -3.70711051e-02f,
  4.68771271e-02f, -3.02815195e-02f, -4.51662671e-03f, -2.46189386e-02f, 9.20293629e-02f, 4.33161296e-02f, 2.94359867e-03f, -1.64415985e-02f, -1.76272288e-01f, 2.45278068e-02f,
  -3.41050550e-02f, 1.59921616e-01f, 1.64592102e-01f, -3.92251574e-02f, -8.22012946e-02f, -8.00250769e-02f, 2.69923452e-02f, 6.56773001e-02f, 4.91326787e-02f, 1.08574025e-01f,
  -6.94217831e-02f, -1.31485760e-01f, -8.42244923e-03f, -2.25377738e-01f, -2.03049317e-01f, 4.43734862e-02f, -6.26910478e-02f, -3.22119631e-02f, -8.21824372e-02f, -1.99224144e-01f,
  -1.01766335e-02f, 1.04440786e-01f, 6.44524619e-02f, 1.82751179e-01f, 1.03301860e-01f, -1.29341096e-01f, -1.76894590e-01f, 1.26259714e-01f, 1.41458511e-01f, 1.60883050e-02f,
  1.08782910e-02f, 1.36609271e-03f, -4.21891212e-02f, -7.10655600e-02f, -2.47066885e-01f, -5.92249334e-02f, -1.26404062e-01f, -5.20134345e-02f, -1.57490835e-01f, -2.69529849e-01f,
  2.89278775e-01f, -5.69588430e-02f, 1.44338802e-01f, 1.85917392e-02f, -1.16204567e-01f, -7.63467476e-02f, 5.66020608e-03f, -4.56813164e-02f, -7.46588707e-02f, -9.63758230e-02f,
  -6.30932599e-02f, 7.68670961e-02f, 4.86373417e-02f, -7.72781968e-02f, -4.71805893e-02f, -3.05692852e-02f, -5.60016222e-02f, 1.31364344e-02f, -2.30160076e-02f, -2.49483604e-02f,
  -1.29232109e-01f, 2.27168389e-02f, 2.08182423e-03f, -4.66273874e-02f, -7.72558004e-02f, 9.46160965e-03f, 1.08213611e-02f, -2.86391890e-03f, -1.02602735e-01f, -1.28924221e-01f,
  -7.11526200e-02f, 1.15442509e-02f, -2.35468652e-02f, -1.51452636e-02f, 2.30250191e-02f, 3.15342210e-02f, 1.99423153e-02f, 3.18545550e-02f, -5.43687232e-02f, -2.59717256e-02f,
  5.43645695e-02f, -3.40568982e-02f, 3.69451679e-02f, -8.89399052e-02f, -7.20286518e-02f, -4.82759774e-02f, 7.57762864e-02f, -9.66396704e-02f, 1.58748170e-03f, -1.04004599e-01f,
  8.24472085e-02f, 4.39875387e-02f, -1.17135674e-01f, 3.50104296e-03f, -1.66926952e-03f, -9.58733410e-02f, 5.16064316e-02f, 3.91950235e-02f, 4.53815199e-02f, -4.68786201e-03f,
  2.44920731e-01f, 6.99262619e-02f, 2.08714213e-02f, 3.16736177e-02f, -1.12009481e-01f, -1.16084516e-01f, -5.26730269e-02f, -6.68010488e-02f, -8.99473503e-02f, 4.71149422e-02f,
  2.64920834e-02f, 7.84014314e-02f, 6.88227564e-02f, 4.99903820e-02f, 1.09771807e-02f, 8.34021568e-02f, -1.21077120e-01f, 4.66788523e-02f, -4.37781401e-02f, -6.10022582e-02f,
  -7.30523989e-02f, -2.69197002e-02f, 2.41706282e-01f, 9.37802866e-02f, -2.53275521e-02f, 1.21345401e-01f, 2.26921797e-01f, 1.27034307e-01f, 1.82211265e-01f, -3.93989868e-02f,
  6.34430647e-01f, 4.42155212e-01f, 3.23996544e-01f, 1.37863263e-01f, 1.32773742e-01f, -2.10338719e-02f, -6.43076301e-02f, -1.10006668e-01f, -1.05791897e-01f, 2.12394342e-01f,
  1.26813367e-01f, 9.98438969e-02f, -9.18169543e-02f, -1.65116638e-01f, -5.28890565e-02f, 6.62724227e-02f, 1.85364597e-02f, -3.06248069e-02f, -5.44315763e-02f, 3.66523042e-02f,
  1.60900041e-01f, 2.15444863e-01f, 2.90923834e-01f, -9.02744755e-03f, 1.15380757e-01f, -2.23860312e-02f, 1.57486033e-02f, 2.98791200e-01f, 2.32699022e-01f, 2.33143553e-01f,
  4.07552510e-01f, 5.15583038e-01f, -3.83089870e-01f, -4.69293036e-02f, 1.64040133e-01f, 9.90208588e-04f, 2.80843750e-02f, -6.31450191e-02f, -5.56297153e-02f, 4.06900458e-02f,
  4.29489575e-02f, 1.13822021e-01f, 2.71455534e-02f, 2.70498209e-02f, -6.72810003e-02f, 1.41239036e-02f, -3.07966508e-02f, -1.01593979e-01f, -1.14749379e-01f, 9.73734781e-02f,
  4.07547988e-02f, 1.61091313e-01f, 1.25110969e-01f, -1.17958061e-01f, -4.78918590e-02f, -7.79913887e-02f, 9.94474590e-02f, -1.94355194e-02f, -1.70466434e-02f, 5.77775389e-03f,
  6.03750953e-03f, 4.15095910e-02f, 8.73951167e-02f, 4.73254472e-02f, 3.05836014e-02f, -5.41814715e-02f, 6.56906590e-02f, -6.22988790e-02f, 1.67592112e-02f, -3.20464931e-02f,
  -3.50106917e-02f, 9.95913669e-02f, -1.30981021e-02f, -4.19351980e-02f, 2.71701277e-03f, 5.07458784e-02f, 7.16953352e-02f, -2.55188812e-02f, 2.72831414e-02f, -1.88648850e-02f,
  4.33524475e-02f, 4.26622704e-02f, 2.10847761e-02f, 2.28832792e-02f, 1.11963851e-02f, -1.03028864e-02f, 6.00323528e-02f, 4.07899125e-03f, 1.08638175e-01f, 4.29532155e-02f,
  -3.17283422e-01f, -2.43573785e-01f, -1.33790579e-02f, -6.07132092e-02f, 1.36710986e-01f, -5.59612028e-02f, 1.79905444e-02f, 2.22304631e-02f, 6.95394948e-02f, -9.96940304e-03f,
  2.73954868e-02f, 5.63869700e-02f, -2.97056921e-02f, -8.67578387e-03f, -4.16072533e-02f, -7.69609064e-02f, -2.70408168e-02f, -6.90245768e-03f, -1.58560544e-01f, 3.80749628e-02f,
  -6.21031597e-02f, -1.81583017e-01f, -1.66247591e-01f, -2.66811073e-01f, -1.61237478e-01f, -1.22917987e-01f, -1.44109175e-01f, -1.16986342e-01f, -2.68407494e-01f, -2.94663757e-01f,
  2.04370320e-01f, 8.63200203e-02f, 2.20218629e-01f, 1.58348650e-01f, -1.68724373e-01f, -4.63514209e-01f, -5.33598542e-01f, -1.72948942e-01f, 3.44506130e-02f, -2.85046175e-02f,
  -2.10374638e-01f, -1.14288405e-01f, -1.43855726e-02f, -2.59028543e-02f, -1.49309009e-01f, -1.36196643e-01f, 6.28652126e-02f, 3.11885811e-02f, -1.38830602e-01f, -2.45145515e-01f,
  -2.02253282e-01f, 3.30893174e-02f, 7.89243206e-02f, 9.45768952e-02f, 1.57200634e-01f, 4.93406616e-02f, 1.51684508e-01f, 1.59201577e-01f, -3.46228899e-03f, 2.98902929e-01f,
  7.54629299e-02f, 9.87087861e-02f, -7.83986822e-02f, 7.16938749e-02f, 2.21087337e-02f, -7.93188065e-03f, -4.74542715e-02f, 8.79301429e-02f, -5.47501491e-03f, -1.09188119e-02f,
  2.11650680e-04f, 1.72982831e-02f, 2.54468340e-02f, -1.00354508e-01f, -1.16092741e-01f, -1.13572374e-01f, 5.33169620e-02f, 2.05495685e-01f, 5.19280024e-02f, -4.15959656e-02f,
  -1.59461126e-01f, -1.53136596e-01f, -6.78991377e-02f, -1.01628035e-01f, -5.89744467e-03f, 5.75703271e-02f, 1.08737953e-01f, 1.57788843e-01f, 7.96088055e-02f, 2.28373080e-01f,
  -5.98834641e-02f, 4.50408682e-02f, -5.68253212e-02f, 3.09030451e-02f, -5.87744899e-02f, 3.99888158e-02f, 2.71322913e-02f, -5.00249974e-02f, 4.31255996e-03f, -2.17428748e-02f,
  3.64979431e-02f, -1.03819659e-02f, -3.71528305e-02f, 8.20420403e-03f, 3.33542116e-02f, 6.26886934e-02f, -4.20242101e-02f, 1.06351208e-02f, -3.58544961e-02f, 4.80905212e-02f,
  7.10550100e-02f, -3.29562984e-02f, 1.16064005e-01f, -8.07185099e-03f, 1.64193809e-02f, 7.42934123e-02f, 1.73119735e-02f, -8.97588208e-02f, 3.42723392e-02f, 6.59288615e-02f,
  -3.74451652e-02f, -1.30183846e-01f, -8.82495642e-02f, 7.40041286e-02f, -2.26214845e-02f, -4.49599437e-02f, -1.59015283e-02f, 1.28121404e-02f, 2.07320489e-02f, -8.95350650e-02f,
  -1.28422529e-01f, -5.00054993e-02f, 3.40524241e-02f, -8.90121236e-03f, -1.18044436e-01f, -7.96393305e-02f, -1.40745565e-01f, 5.75148479e-05f, -1.12892821e-01f, -9.81213897e-02f,
  -9.34566036e-02f, -1.52404219e-01f, -2.33896151e-01f, -4.60675284e-02f, 3.16441618e-02f, -1.54709518e-01f, -1.45586535e-01f, 1.66961551e-02f, -1.21241763e-01f, -1.44427359e-01f,
  -3.61639746e-02f, 1.52928650e-01f, 1.27168700e-01f, -2.40353942e-02f, -9.54932049e-02f, 7.37601146e-02f, 1.43047169e-01f, 1.02876350e-02f, 8.94872248e-02f, 2.50934027e-02f,
  7.16741905e-02f, -6.90572709e-02f, -1.75932631e-01f, -1.61092386e-01f, -1.82599545e-01f, 2.94342823e-02f, 4.95529845e-02f, -1.90071762e-01f, -3.09904993e-01f, -2.30174765e-01f,
  -3.21690917e-01f, -3.56663227e-01f, -3.14727545e-01f, -2.33186558e-01f, -7.25672618e-02f, -1.36188835e-01f, -2.42509767e-02f, -1.86496958e-01f, -1.19594388e-01f, -4.84370030e-02f,
  -6.56360062e-03f, 2.20065460e-01f, -1.13413513e-01f, -1.27418473e-01f, 1.59941204e-02f, 5.15146293e-02f, -8.37168172e-02f, -3.66789922e-02f, -3.60035524e-02f, 9.79817733e-02f,
  -1.59011837e-02f, -2.97010783e-02f, 8.93050134e-02f, -8.05703625e-02f, 2.35549230e-02f, -8.91368613e-02f, 4.01875526e-02f, -2.21940316e-02f, 1.00113486e-03f, 7.57006332e-02f,
  -6.78208545e-02f, -1.22900382e-01f, 2.47524064e-02f, 3.43851186e-02f, -2.00423654e-02f, -1.09202499e-02f, -8.36142376e-02f, -1.13256037e-01f, -7.79433399e-02f, -3.30081508e-02f,
  1.49332937e-02f, -1.17032649e-02f, 4.54904325e-02f, -8.19088146e-02f, -7.55221862e-03f, 1.48118045e-02f, 1.47657124e-02f, -2.79443862e-04f, 8.49681534e-03f, -1.08753601e-02f,
  3.91249359e-03f, 1.62651661e-04f, 5.05595692e-02f, -2.64703948e-02f, 2.63610594e-02f, 5.77997491e-02f, 6.62005991e-02f, -4.09301221e-02f, 6.46271277e-03f, -2.57001352e-02f,
  4.12723422e-02f, 2.91601606e-02f, 5.73450997e-02f, -7.48612136e-02f, -1.44929700e-02f, -4.76224609e-02f, -1.54019613e-02f, 2.46062223e-02f, 7.31090736e-03f, 1.32841870e-01f,
  -1.28266290e-01f, 2.22490784e-02f, -3.31509230e-03f, -2.97101345e-02f, 8.21927860e-02f, -9.56107005e-02f, 7.91536793e-02f, -6.37134463e-02f, 4.91259880e-02f, -5.77876940e-02f,
  8.32629856e-03f, -3.36477570e-02f, 6.61422312e-02f, -8.09196234e-02f, -9.38880146e-02f, 2.23283023e-02f, -8.10101703e-02f, -1.24631792e-01f, 3.18718888e-02f, 8.74866918e-02f,
  -1.28292292e-02f, -7.98151270e-02f, -8.54155123e-02f, -5.30536287e-02f, 2.79749539e-02f, -1.62078261e-01f, -4.98712324e-02f, -1.28217205e-01f, -1.36792034e-01f, -8.41063112e-02f,
  -6.48408243e-03f, -6.28353357e-01f, -1.50155500e-01f, -1.18977893e-02f, 7.31976479e-02f, -3.85077983e-01f, -5.17171621e-01f, -3.85742933e-01f, -1.41389415e-01f, -2.65634358e-01f,
  -3.92181091e-02f, 1.42431557e-01f, 6.71848580e-02f, -2.29205340e-02f, -2.22336829e-01f, -5.46999991e-01f, -4.08532530e-01f, -3.62574309e-02f, 2.28845760e-01f, 1.55722320e-01f,
  6.84575960e-02f, 2.82784194e-01f, 2.30578542e-01f, 5.83236031e-02f, -8.96486547e-03f, 2.07097962e-01f, -1.36898160e-01f, -2.64620464e-02f, -1.20882861e-01f, -1.12490721e-01f,
  -6.88450933e-02f, -1.50874943e-01f, 1.42261192e-01f, 1.44153893e-01f, 1.66937515e-01f, -6.27912208e-02f, -7.77838975e-02f, 6.14177585e-02f, 2.77244505e-02f, -4.96788025e-02f,
  8.45212340e-02f, -1.95356347e-02f, -1.87573005e-02f, 7.09620044e-02f, -1.01381928e-01f, -2.07333546e-02f, -1.08760744e-01f, 1.96653791e-03f, 1.03323711e-02f, -1.12560652e-01f,
  7.32939839e-02f, 1.36551514e-01f, -9.16119106e-03f, -1.19223580e-01f, -1.05419621e-01f, 1.13592997e-01f, -4.76338677e-02f, -5.56030013e-02f, -1.47660255e-01f, -2.81462908e-01f,
  -2.30955146e-02f, 4.50666174e-02f, -3.47773843e-02f, 6.99653709e-03f, -1.32138385e-02f, 2.64495239e-02f, -1.72749907e-03f, 3.11158560e-02f, 1.80593207e-02f, -2.41151247e-02f,
  -2.91389190e-02f, 5.13405278e-02f, 2.98219118e-02f, -1.26914987e-02f, -3.34140696e-02f, 5.03754579e-02f, 3.44612659e-03f, -8.35555792e-02f, -3.21189873e-02f, 1.11487219e-02f,
  9.52192023e-02f, 2.61603333e-02f, 1.23705648e-01f, 7.62566328e-02f, -4.33994867e-02f, -4.64850627e-02f, 3.03085819e-02f, 6.43033013e-02f, -1.08755743e-02f, 8.28180090e-03f,
  -1.05193898e-01f, 2.23357350e-01f, -1.50032580e-01f, -7.71050379e-02f, -4.82900478e-02f, -2.52179671e-02f, 4.96054590e-02f, -2.28234287e-03f, 7.38810524e-02f, -9.91843045e-02f,
  1.10364981e-01f, -3.84044237e-02f, -4.57351096e-02f, 8.41677189e-03f, 3.95878367e-02f, -4.03071679e-02f, -1.04352243e-01f, -1.15177513e-03f, 4.99457270e-02f, -1.10776089e-01f,
  -1.15217976e-01f, -1.24303028e-01f, -1.93707690e-01f, -2.15068176e-01f, -1.06455557e-01f, -2.03316333e-04f, -1.72033936e-01f, -1.01179376e-01f, -2.09862709e-01f, -4.24939424e-01f,
  3.58890414e-01f, 2.00476080e-01f, 4.41848516e-01f, 1.50617044e-02f, -1.41841382e-01f, -1.35413647e-01f, -5.40227536e-03f, -1.45663386e-02f, -1.27173305e-01f, -1.49843946e-01f,
  -3.46091360e-01f, -2.01503307e-01f, -3.36129665e-02f, -1.14565708e-01f, 1.34233266e-01f, 1.98800594e-01f, 9.76278335e-02f, 3.28824103e-01f, 2.50916600e-01f, 5.52647896e-02f,
  -1.69315457e-01f, 9.12105218e-02f, 1.83595732e-01f, 2.30064169e-01f, 5.52039109e-02f, -1.01519324e-01f, -7.82832224e-03f, 1.32676437e-01f, -2.48450413e-02f, 4.46385331e-02f,
  -3.09976041e-02f, 1.38255507e-01f, -4.05882224e-02f, -1.96376607e-01f, -1.03579395e-01f, 9.45096314e-02f, -1.09628178e-01f, 3.72729078e-02f, -3.04473937e-03f, 4.96008061e-02f,
  -5.45193292e-02f, -6.57175258e-02f, -6.91448078e-02f, -5.14036790e-02f, -1.07877916e-02f, 1.46150691e-02f, 1.43419042e-01f, 2.65438080e-01f, 1.15134366e-01f, -3.97243723e-02f,
  -1.53639242e-01f, -1.58593222e-01f, 1.15584701e-01f, 4.65531722e-02f, -2.82604340e-02f, -1.52759254e-01f, -2.82858871e-02f, 6.15035221e-02f, -4.59190756e-02f, 8.52731168e-02f,
  -1.05224058e-01f, 8.34261440e-03f, -7.02724308e-02f, 5.97171336e-02f, -2.59844344e-02f, 6.89113215e-02f, -6.29747808e-02f, -4.55324873e-02f, 1.39781665e-02f, 3.06397919e-02f,
  6.38572499e-02f, 3.19163576e-02f, 2.47768778e-02f, 4.10557985e-02f, -1.26844674e-01f, 2.04162039e-02f, 6.56839609e-02f, -6.58752471e-02f, -1.11403940e-02f, -4.53610495e-02f,
  -4.70045730e-02f, 7.55601302e-02f, -5.72919436e-02f, 3.81714292e-02f, 4.88204844e-02f, 2.33923290e-02f, 7.44998008e-02f, -9.18943211e-02f, -7.14998916e-02f, -1.23444833e-02f,
  -2.94670254e-01f, -3.20675671e-02f, -1.06827073e-01f, 1.74282901e-02f, 2.46442482e-03f, 2.32665371e-02f, -6.99295327e-02f, 3.20893265e-02f, -1.04502421e-02f, -1.26743838e-02f,
  -8.28111395e-02f, -1.43823614e-02f, -5.57809733e-02f, 5.21811889e-03f, 6.59002960e-02f, -1.94146577e-02f, -8.27091113e-02f, -5.39658032e-02f, -1.08327409e-02f, -3.77599262e-02f,
  -4.35068225e-03f, -5.31881973e-02f, -1.75666496e-01f, -1.03122041e-01f, -1.24399275e-01f, -1.48910776e-01f, -4.87976894e-02f, -3.02732699e-02f, -1.23790972e-01f, -4.01682481e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.28981413e-02f, 1.56366736e-01f, 1.86691687e-01f, 2.93397516e-01f, 2.43921116e-01f, 1.41985957e-02f, 3.77820462e-01f, 6.94227517e-02f, 4.21739072e-02f, 3.36856753e-01f,
  3.80963534e-01f, 1.70843884e-01f, 4.56006467e-01f, 1.99565902e-01f, 4.67437744e-01f, 3.53972316e-01f, 5.12561463e-02f, 1.40279680e-01f, 2.88769990e-01f, 3.93975765e-01f,
  1.27433777e-01f, 2.71381855e-01f, 2.85598308e-01f, 1.38061628e-01f, 4.10076380e-01f, 2.12882340e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -7.39577174e-01f, -3.71365435e-02f, -1.66268125e-01f, -3.05599183e-01f, -3.45255256e-01f, -1.41905516e-01f, -2.26644382e-01f, 2.49038398e-01f, -1.48084862e-02f, 2.93284535e-01f,
  -3.39396000e-01f, 7.10837841e-02f, -2.98044115e-01f, 1.36003494e-01f, 6.12471998e-02f, -1.09523758e-02f, -4.11630750e-01f, 8.52884173e-01f, -2.80809909e-01f, -1.16512865e-01f,
  -4.59771544e-01f, -4.79138732e-01f, -1.37019068e-01f, 7.41663396e-01f, -1.12408079e-01f, -7.32099712e-02f, 1.22949585e-01f, -2.53182769e-01f, -3.21244001e-01f, -1.47700652e-01f,
  7.19301879e-01f, -2.29784831e-01f, 4.46398370e-03f, -4.00064170e-01f, 1.04813494e-01f, 1.59715056e-01f, 5.42137206e-01f, 2.11957768e-01f, 4.66525078e-01f, -4.71386671e-01f,
  -2.60826230e-01f, 4.84271049e-01f, -4.47718024e-01f, -1.36907846e-01f, -3.55157465e-01f, -3.03351223e-01f, -2.12618738e-01f, 1.32619822e+00f, -4.91208851e-01f, 6.78166091e-01f,
  7.91937932e-02f, 2.61842787e-01f, -4.25577849e-01f, -4.80113894e-01f, 1.91994861e-01f, 3.85349691e-02f, 1.52876750e-01f, -2.85128295e-01f, 4.74632055e-01f, 2.89607227e-01f,
  -2.34344125e-01f, -3.14157493e-02f, 9.20780301e-02f, 6.87148469e-03f, 3.49749953e-01f, 5.84211886e-01f, 2.37783581e-01f, 6.72798455e-01f, 4.09763455e-01f, -6.68412685e-01f,
  -2.08574727e-01f, -1.38698295e-01f, 2.88887680e-01f, -1.00405507e-01f, -1.09470509e-01f, -1.06357507e-01f, -9.15837884e-02f, -3.52206856e-01f, -2.70034522e-02f, 1.34233728e-01f,
  6.60765827e-01f, -3.86658102e-01f, -2.09804818e-01f, -3.71090765e-03f, 8.45147371e-02f, -4.09004629e-01f, -1.62210185e-02f, -1.92626461e-01f, 2.26950020e-01f, -2.23438576e-01f,
  9.26901586e-03f, -4.28404570e-01f, 3.67959678e-01f, -3.86797071e-01f, 8.40521991e-01f, 3.94616961e-01f, 2.30575129e-01f, -6.44073784e-02f, -5.16062498e-01f, 3.27566952e-01f,
  -3.10042202e-01f, -7.10372865e-01f, -3.14011604e-01f, 5.50948918e-01f, 2.95922697e-01f, -3.66419345e-01f, -7.44453371e-02f, -1.16332822e-01f, -9.82062072e-02f, -3.89169939e-02f,
  8.54667246e-01f, -4.22960855e-02f, 8.30697358e-01f, 3.89732659e-01f, -1.35123715e-01f, 4.76840045e-03f, -2.45203316e-01f, 5.50218701e-01f, -4.44438271e-02f, -1.16401307e-01f,
  -4.70182672e-02f, -1.05188116e-01f, -1.49487197e-01f, -7.51927420e-02f, -4.85905290e-01f, 4.26698804e-01f, -4.38663661e-01f, -1.45564497e-01f, -4.77829605e-01f, 1.70497387e-03f,
  -5.52569106e-02f, 1.23439170e-01f, 2.27404624e-01f, 4.74018067e-01f, 2.82501966e-01f, 5.87285638e-01f, 4.30885941e-01f, -2.77263194e-01f, 3.06563377e-02f, -4.00647447e-02f,
  -3.35286140e-01f, 8.46033871e-01f, -1.69128329e-01f, -1.63194910e-01f, -4.62764293e-01f, -1.40714049e-01f, -1.14181891e-01f, -7.58892074e-02f, 1.37345433e-01f, 5.15358329e-01f,
  -2.81245649e-01f, -3.67478341e-01f, 2.88650125e-01f, 4.06813994e-02f, -3.56177986e-01f, -3.59246343e-01f, 6.73411429e-01f, 7.15867400e-01f, -6.04782328e-02f, -7.41163418e-02f,
  4.11685556e-01f, 6.92863107e-01f, -1.78245977e-01f, 3.53743918e-02f, -1.40633732e-01f, 8.71103585e-01f, 7.74076730e-02f, -2.24506170e-01f, -2.68398523e-01f, 1.06791258e+00f,
  2.34200314e-01f, -3.09630007e-01f, 3.87261301e-01f, 1.88962579e-01f, -7.16161653e-02f, -1.96184516e-01f, -3.20877552e-01f, 2.53200710e-01f, 5.32940149e-01f, 7.54796982e-01f,
  2.74463445e-01f, -6.08211346e-02f, 8.98328796e-02f, 2.63240248e-01f, 1.40670359e-01f, 2.70135731e-01f, -2.58824080e-01f, -2.64951676e-01f, -1.41622379e-01f, 9.52623263e-02f,
  -5.31297147e-01f, -3.50262195e-01f, 8.20513815e-02f, 4.28958833e-01f, 7.56678209e-02f, -5.90794504e-01f, -3.36068988e-01f, -8.22741240e-02f, -2.08021462e-01f, -9.88578200e-02f,
  -4.49585654e-02f, -2.97145158e-01f, -4.15287673e-01f, -5.75493984e-02f, -5.28444164e-02f, -4.50056225e-01f, -1.73168421e-01f, -3.19978535e-01f, -4.11368132e-01f, -1.28609627e-01f,
  -1.68485627e-01f, -1.44260839e-01f, 8.68339479e-01f, -3.36638868e-01f, -4.49065804e-01f, -2.21476376e-01f, -2.13654503e-01f, -5.62784255e-01f, -2.73614258e-01f, 7.09839523e-01f,
  4.34248120e-01f, -4.53060791e-02f, -5.57251394e-01f, 9.28396225e-01f, 1.39578670e-01f, -7.15378106e-01f, -1.57405376e-01f, 2.12710146e-02f, -3.99480343e-01f, -2.41754819e-02f,
  6.72567248e-01f, 6.63085207e-02f, -2.30191574e-01f, -2.32328735e-02f, 3.31064016e-01f, -2.19134897e-01f, -7.26103736e-03f, -1.14659265e-01f, 9.54060405e-02f, -4.34694976e-01f,
  5.85085988e-01f, -2.37817481e-01f, 1.00242130e-01f, -1.70098588e-01f, -3.04170195e-02f, -1.32555202e-01f, 8.63812804e-01f, -2.17213690e-01f, -1.73718497e-01f, -2.33836293e-01f,
  -5.32260686e-02f, -4.40918863e-01f, -2.69279540e-01f, -8.88158977e-02f, -4.08246070e-01f, -1.30740836e-01f, -5.15397191e-01f, 7.60369003e-02f, 1.99824139e-01f, -7.95378089e-01f,
  5.64642847e-01f, -3.52454543e-01f, -7.91634098e-02f, -2.31010944e-01f, -2.12978870e-01f, -2.66507804e-01f, 7.22933933e-03f, 2.96508312e-01f, 5.54168761e-01f, -5.92601299e-02f,
  -1.16426475e-01f, -2.81632114e-02f, -1.99887872e-01f, -1.49183095e-01f, 1.13841021e+00f, -1.76258981e-01f, -2.53049135e-01f, -1.57834440e-01f, -8.02909732e-02f, -2.32830510e-01f,
  -8.63603279e-02f, 6.61334634e-01f, 6.63979724e-02f, -3.65564376e-01f, -3.34163100e-01f, -1.73499227e-01f, -2.60656923e-01f, 2.37960607e-01f, 1.11813232e-01f, 1.90666437e-01f,
  -2.69932210e-01f, 5.99674165e-01f, -4.30317014e-01f, 6.60954833e-01f, -2.72566915e-01f, -2.01993272e-01f, -5.49088344e-02f, -1.07413279e-02f, 5.55139899e-01f, -2.31943876e-01f,
  -1.49644747e-01f, 4.31471318e-01f, -2.77109653e-01f, -2.43431687e-01f, -3.65253985e-01f, -4.83882695e-01f, -1.49495125e-01f, 2.92526297e-02f, 5.22740364e-01f, 1.29975155e-01f,
  3.29584688e-01f, -4.31237072e-02f, -2.88827956e-01f, -3.80654693e-01f, -1.48623884e-01f, 7.71017253e-01f, 8.92462581e-02f, -2.86166757e-01f, 6.21423483e-01f, -3.64848137e-01f,
  6.74367994e-02f, -3.92075390e-01f, 1.48999810e-01f, -8.15494657e-02f, 3.94817621e-01f, -2.99838521e-02f, -9.58867520e-02f, 2.61836499e-01f, -2.58528113e-01f, 2.44961418e-02f,
  -1.41527439e-02f, 6.07484698e-01f, 2.98890114e-01f, -4.16839212e-01f, 3.80917825e-02f, -1.95861787e-01f, 3.04732174e-02f, -8.64831954e-02f, -3.48140806e-01f, 5.12437597e-02f,
  1.26347959e-01f, 8.19069386e-01f, -2.51107514e-01f, 2.35531881e-01f, 6.54464245e-01f, -9.34548452e-02f, 5.93833447e-01f, -2.88679570e-01f, -4.10873830e-01f, -2.48777986e-01f,
  -4.05642211e-01f, -1.20277137e-01f, -3.14498037e-01f, -2.47028470e-02f, 2.21452683e-01f, -6.11237764e-01f, -6.50509000e-01f, -1.33348480e-01f, -1.18586823e-01f, -1.31609336e-01f,
  3.15730482e-01f, -4.73306961e-02f, -8.17191880e-03f, 9.73441824e-02f, -1.93169296e-01f, -1.10315755e-01f, -1.34930238e-02f, -2.91028649e-01f, 2.46580362e-01f, -2.96295941e-01f,
  -2.53093541e-01f, -1.59640223e-01f, -3.46086055e-01f, -1.28845498e-01f, -5.00340521e-01f, -1.26753956e-01f, -1.74748167e-01f, 1.15524960e+00f, 1.34699747e-01f, 7.19982505e-01f,
  -3.15223008e-01f, 2.38891959e-01f, -1.38157561e-01f, 2.42316619e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.86204189e-01f, 9.94141251e-02f, 2.50749677e-01f, -3.40116501e-01f, -1.54282108e-01f, 1.26605839e-01f, 2.17549935e-01f, -1.72230706e-01f, 7.01568201e-02f, -3.62052917e-02f,
  -2.10308105e-01f, -6.56247362e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    