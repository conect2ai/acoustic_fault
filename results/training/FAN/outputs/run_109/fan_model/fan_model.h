/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.01801062e-01f, 4.38581407e-01f, -4.62167747e-02f, 8.86009037e-02f, -5.60457483e-02f, 2.99502879e-01f, -2.76899897e-02f, 1.40284136e-01f, -7.04687461e-02f, 1.83567792e-01f,
  -3.97952534e-02f, -6.47931695e-02f, 1.05218545e-01f, 2.68854886e-01f, -1.33364722e-02f, 1.33724641e-02f, 3.07777643e-01f, 1.60933182e-01f, -1.07329004e-01f, 1.21853463e-01f,
  -8.28808323e-02f, 1.47020683e-01f, 7.92018101e-02f, 7.32599851e-03f, 4.94286343e-02f, 1.98636088e-03f, 9.53611806e-02f, -2.45036647e-01f, 1.80324927e-01f, -1.18320342e-02f,
  3.82574350e-02f, -6.26958385e-02f, 9.95378010e-03f, -3.64239141e-03f, 5.58064878e-02f, 2.11010873e-02f, -5.93744405e-02f, -9.31004137e-02f, -1.37724012e-01f, -3.12052555e-02f,
  -3.33261117e-03f, 8.33939016e-03f, 2.63963230e-02f, 1.47067020e-02f, 4.58123125e-02f, 1.25960875e-02f, -8.51528794e-02f, -1.57631421e-03f, 7.19736293e-02f, 8.22743103e-02f,
  -3.10641639e-02f, 2.74646766e-02f, 4.60341014e-02f, 4.32776995e-02f, 1.13947624e-02f, -4.00026217e-02f, 4.53704484e-02f, 8.10130388e-02f, 5.81996292e-02f, 4.78581451e-02f,
  -4.55058068e-02f, -7.22504640e-03f, -4.41793576e-02f, -8.32312629e-02f, 5.68432771e-02f, -6.77548274e-02f, -7.07389563e-02f, -3.32155339e-02f, -8.91772136e-02f, 5.33352457e-02f,
  -5.83411157e-02f, -4.37127836e-02f, 8.01780168e-03f, 1.30512491e-02f, 3.84949818e-02f, -7.10560530e-02f, -4.10590917e-02f, -3.87638435e-02f, -8.85472074e-02f, -9.89166722e-02f,
  -8.71599168e-02f, 7.78161082e-03f, -2.59897020e-02f, 2.16400102e-02f, -2.65051015e-02f, -1.34269148e-01f, 1.10115536e-01f, -9.40561760e-03f, -1.09191677e-02f, 4.99278940e-02f,
  2.60614216e-01f, 2.59123743e-01f, -2.87840143e-02f, -1.71968190e-03f, -3.94023815e-03f, 1.10009534e-03f, 2.78569888e-02f, -1.05850184e-02f, -2.66008377e-02f, -2.51068808e-02f,
  9.37547460e-02f, -4.35619988e-03f, 9.06166062e-03f, 5.19908406e-03f, 8.49587321e-02f, 7.77459815e-02f, -4.97882403e-02f, -9.14402604e-02f, 4.58643138e-02f, 7.18948022e-02f,
  -1.89810470e-02f, -2.86036711e-02f, -5.18289767e-02f, -3.60090993e-02f, 8.59543011e-02f, -4.45326865e-02f, 2.57399436e-02f, 3.57003906e-03f, -5.79108112e-02f, 8.32935497e-02f,
  1.46487430e-01f, -2.78914720e-01f, 2.43010178e-01f, -2.01835558e-02f, 1.38475403e-01f, -2.70220399e-01f, -2.49457285e-01f, -9.45211276e-02f, -1.47436857e-01f, -2.42443264e-01f,
  1.37240723e-01f, -2.41755381e-01f, -7.93983713e-02f, -1.12031005e-01f, 3.02736402e-01f, 1.10777922e-01f, -9.06131417e-02f, -3.20364267e-01f, -1.12619981e-01f, -5.82770966e-02f,
  5.81071079e-02f, 1.20667061e-02f, 2.14989483e-01f, -6.58857152e-02f, -7.11805420e-03f, -6.95722317e-03f, 9.41318870e-02f, 6.88048080e-02f, -8.83620754e-02f, 2.36844062e-03f,
  3.51028889e-02f, 1.59970834e-03f, -4.19853488e-03f, -6.01548329e-02f, 4.69266139e-02f, -4.66378294e-02f, -1.43052842e-02f, -3.57938930e-02f, 1.27215579e-01f, -4.26197574e-02f,
  -3.21699716e-02f, -4.71504033e-03f, -9.63027030e-02f, 9.11049172e-02f, -3.80676128e-02f, -5.72250374e-02f, 1.31565675e-01f, 7.37478063e-02f, -9.78555679e-02f, 3.82715417e-03f,
  6.40185773e-02f, 3.20538878e-02f, 2.34611402e-03f, -1.38964936e-01f, 5.30357771e-02f, 1.08108362e-02f, 1.75963432e-04f, -3.16504277e-02f, -5.22616655e-02f, -5.01022153e-02f,
  4.14657444e-02f, -2.04834919e-02f, 6.27907664e-02f, 8.84523094e-02f, -4.15375978e-02f, 1.86475378e-03f, 3.55510972e-02f, 4.37463075e-03f, 5.71783260e-03f, 4.07751016e-02f,
  4.57393676e-02f, -9.91268829e-03f, 1.95719227e-02f, 2.75942907e-02f, -4.69997302e-02f, 9.12125874e-03f, 7.79573843e-02f, 7.52425641e-02f, 3.89687903e-02f, 1.19345725e-01f,
  -6.10966310e-02f, 8.98576081e-02f, -4.52412851e-02f, -6.65104166e-02f, -1.67953800e-02f, 4.20829840e-02f, -6.29764274e-02f, 1.60524771e-01f, 3.56763154e-02f, -1.00827720e-02f,
  -1.34899363e-01f, -1.31888628e-01f, -5.26390523e-02f, -5.67429736e-02f, -1.31730616e-01f, -7.71515118e-03f, 2.91694123e-02f, -7.71065205e-02f, -9.31971744e-02f, 7.06419870e-02f,
  -4.86932099e-02f, -2.55231094e-02f, -8.92316643e-03f, -3.75140421e-02f, -4.04308923e-02f, -1.02425620e-01f, 1.08889818e-01f, 1.12512290e-01f, -1.28412694e-02f, -8.68626907e-02f,
  7.88599625e-03f, 2.85185669e-02f, -3.69299427e-02f, -2.41182856e-02f, -4.57502194e-02f, -8.45700875e-02f, 5.62836416e-02f, 3.05929836e-02f, 1.40159070e-01f, -1.29333017e-02f,
  -5.15390694e-01f, 1.27281323e-01f, -1.12980962e-01f, -9.10630897e-02f, 5.26145510e-02f, -1.22535117e-01f, 6.41144766e-03f, 4.84182872e-02f, -3.38429213e-02f, 2.64539540e-01f,
  2.40686908e-01f, -1.31112067e-02f, 2.62491643e-01f, 1.72366485e-01f, -2.00506642e-01f, 1.68886408e-01f, -1.52432665e-01f, 6.41429424e-02f, 6.17492050e-02f, -9.55680832e-02f,
  -7.83542469e-02f, 7.06651136e-02f, 3.03544197e-02f, 1.96425185e-01f, -7.97826424e-02f, -1.06318437e-01f, 2.72437364e-01f, 2.17985064e-02f, 1.64205939e-01f, 1.13993607e-01f,
  2.25076564e-02f, 5.88401780e-02f, -6.44927919e-02f, -6.41414896e-02f, -1.29926518e-01f, -1.77674126e-02f, -1.52287319e-01f, -9.76092592e-02f, -9.69756544e-02f, 8.31623620e-04f,
  -9.66756269e-02f, 7.55249383e-03f, 2.20107241e-03f, 6.19229972e-02f, 8.39786883e-03f, 9.81155131e-03f, -1.36649888e-02f, -7.04680011e-02f, 9.54470932e-02f, -9.45870590e-04f,
  8.66604075e-02f, 5.79014383e-02f, 3.83154042e-02f, 2.34450195e-02f, -3.45894136e-02f, -5.05549647e-03f, 7.23752426e-03f, 9.27700996e-02f, 9.30135250e-02f, -8.76376964e-03f,
  -2.18551559e-03f, 6.69656768e-02f, -1.42755553e-01f, -3.93008254e-02f, 1.83610674e-02f, -6.92573376e-03f, 7.82074872e-03f, 3.45774577e-03f, -4.49783467e-02f, 8.74442160e-02f,
  -1.38504906e-02f, 2.44209040e-02f, 5.12485653e-02f, -3.27130705e-02f, -1.65810287e-02f, 5.64553328e-02f, 1.54452315e-02f, -1.37312412e-02f, -4.54963669e-02f, -9.23841596e-02f,
  1.62965178e-01f, 9.66144539e-03f, 1.24654658e-01f, -3.55450921e-02f, 9.05862972e-02f, 5.09030297e-02f, -4.10868861e-02f, -1.70254800e-02f, 8.04056600e-02f, -3.96812297e-02f,
  -1.56404004e-01f, -8.13550800e-02f, -1.97291858e-02f, -8.14502686e-02f, 3.00053246e-02f, 8.59797522e-02f, -5.56008853e-02f, -5.35073727e-02f, -1.08089723e-01f, 1.32068973e-02f,
  -8.13501030e-02f, -3.30253839e-02f, 6.43125400e-02f, -3.99939995e-03f, -3.72403115e-02f, 8.89092833e-02f, 5.79373874e-02f, -3.37183885e-02f, -2.73515712e-02f, 4.84541021e-02f,
  1.31247686e-02f, 8.23106989e-02f, 1.53393131e-02f, -2.60033980e-02f, 2.19802782e-02f, -1.20303463e-02f, -3.86741869e-02f, -9.43093468e-03f, -7.27968961e-02f, -9.26142372e-03f,
  -2.11129755e-01f, 1.60455689e-01f, 2.05471739e-01f, -3.98529060e-02f, 2.69687790e-02f, -2.98543751e-01f, -2.75811821e-01f, 1.98785841e-01f, -4.70431615e-03f, 6.05404302e-02f,
  -2.02056348e-01f, 1.38554662e-01f, 6.83320239e-02f, -2.09350646e-01f, -2.58048803e-01f, -3.38618159e-02f, -2.21052051e-01f, -9.30493250e-02f, 5.65619543e-02f, -2.13388335e-02f,
  7.70845264e-02f, -2.10052386e-01f, -8.08087587e-02f, 1.27542555e-01f, 1.54551372e-01f, 2.14790523e-01f, 6.15516342e-02f, 1.92802012e-01f, -3.84239107e-02f, -5.82307130e-02f,
  -1.78630933e-01f, -9.81277823e-02f, 6.82739094e-02f, -2.91803293e-02f, -5.38079664e-02f, -1.33188199e-02f, -8.45195353e-02f, 3.07584722e-02f, 7.06064105e-02f, 4.10198495e-02f,
  -3.44838127e-02f, 2.83697564e-02f, 1.91374533e-02f, 3.19483574e-03f, -9.37312469e-02f, 3.93683128e-02f, 4.07132320e-02f, -5.66203631e-02f, 3.47237103e-02f, -4.63913232e-02f,
  1.53806247e-02f, 1.53538433e-03f, -7.17214793e-02f, -4.13054340e-02f, -3.03939860e-02f, 7.00489836e-05f, -1.16040474e-02f, -2.27401312e-02f, 1.00605306e-03f, 2.24167481e-02f,
  -9.25958380e-02f, 4.15721647e-02f, 8.43926668e-02f, 7.04619288e-02f, 6.30215406e-02f, 6.35850430e-02f, -5.79178669e-02f, 1.80872437e-02f, 1.28002271e-01f, 2.20368709e-02f,
  3.97954695e-02f, 2.59186085e-02f, -4.97027598e-02f, 3.89064513e-02f, 1.08488031e-01f, 2.24645995e-02f, 1.35224429e-03f, -5.39840795e-02f, -1.32458955e-01f, 1.39058586e-02f,
  1.07791029e-01f, -1.04911678e-01f, 7.46816173e-02f, -6.20839447e-02f, -5.24063641e-03f, 1.31104901e-01f, -5.00673838e-02f, 1.05314283e-02f, 4.97642532e-02f, 4.99631390e-02f,
  -9.04395953e-02f, 1.40610874e-01f, -5.95027115e-03f, -4.38250881e-03f, 4.09795567e-02f, 1.01696603e-01f, 2.71674804e-02f, 2.46033221e-02f, 5.34851514e-02f, -2.48531438e-02f,
  -4.81996275e-02f, 5.34785017e-02f, 7.66754895e-02f, -3.10518332e-02f, -7.13600218e-02f, -4.88162339e-02f, -9.57368501e-03f, 1.44048976e-02f, 1.80857908e-03f, -2.99341716e-02f,
  1.16008520e-01f, 6.29315227e-02f, 8.12462624e-03f, 4.03159261e-02f, -5.80493174e-02f, -3.03080771e-02f, -4.67624292e-02f, 3.81668434e-02f, -1.03268288e-01f, -4.71717939e-02f,
  -1.54340565e-01f, -2.51263291e-01f, 1.94293827e-01f, 4.95816991e-02f, 1.68621317e-02f, 2.19401434e-01f, 2.71414250e-01f, -1.04122356e-01f, 1.62459597e-01f, -6.96565360e-02f,
  -1.73388243e-01f, -7.26843327e-02f, -7.29498267e-02f, -5.14420196e-02f, 3.01282406e-01f, 1.47842437e-01f, 7.24353269e-02f, -1.90475620e-02f, 3.52403671e-02f, 2.85098627e-02f,
  1.47677511e-01f, 3.78541052e-02f, 6.50890358e-03f, -3.59269083e-02f, 7.16453372e-03f, -3.56260389e-02f, -1.20095937e-02f, 9.59121436e-02f, -1.78229753e-02f, -6.86677992e-02f,
  -5.54489419e-02f, -1.86106130e-01f, 8.19654204e-03f, 9.04177502e-02f, -6.39839768e-02f, -1.81476809e-02f, 3.61156948e-02f, 1.86560243e-01f, 6.18326142e-02f, 6.68199807e-02f,
  -1.80765949e-02f, 6.62526786e-02f, -8.25543851e-02f, 9.75428671e-02f, -4.40111645e-02f, 6.89385235e-02f, 7.40138441e-02f, 5.20039387e-02f, 6.26341030e-02f, 5.13450541e-02f,
  2.01401263e-02f, 6.35345876e-02f, 1.02298416e-01f, 9.55536682e-03f, -6.68279752e-02f, 1.60039384e-02f, 6.28165454e-02f, 1.19952336e-02f, -4.90635540e-03f, -2.84137111e-02f,
  -1.78967789e-02f, 2.03946345e-02f, -8.91784579e-03f, -5.12420870e-02f, -1.75841097e-02f, -2.89445240e-02f, 5.95698413e-03f, -5.44139855e-02f, -7.24709034e-02f, -1.91476718e-01f,
  -1.05479859e-01f, -1.10479221e-01f, -2.78893244e-02f, 1.21647879e-01f, 7.64708221e-02f, 1.31166577e-02f, 7.10383011e-03f, -1.70047417e-01f, -9.80214924e-02f, -2.72302199e-02f,
  9.21834186e-02f, 5.89211881e-02f, -1.18116356e-01f, -2.89610233e-02f, 1.07469745e-01f, 2.04060636e-02f, -4.26113419e-02f, -1.42778531e-02f, 9.00711566e-02f, 2.11597215e-02f,
  -1.61165148e-01f, -1.54675424e-01f, 4.34041470e-02f, -6.69460669e-02f, -4.38727178e-02f, -1.63045954e-02f, 7.44501129e-02f, 9.06616747e-02f, -5.08087575e-02f, 2.85650492e-02f,
  2.11411472e-02f, 7.44432807e-02f, 4.90856217e-03f, -6.14081370e-03f, 6.26782626e-02f, -1.01018893e-02f, 5.75348027e-02f, 6.28480762e-02f, -7.15510687e-04f, -6.22010939e-02f,
  1.12159466e-02f, 1.36577440e-02f, 1.32534325e-01f, -2.78952532e-02f, -8.08753818e-02f, -8.78578424e-02f, 4.61139604e-02f, -8.06570984e-03f, -5.84978126e-02f, -4.61815484e-03f,
  3.38996142e-01f, -1.14127189e-01f, 2.58538444e-02f, 3.72565463e-02f, -8.47491547e-02f, -1.92603558e-01f, -3.07484359e-01f, 1.21120806e-03f, -1.17169917e-01f, -2.24782035e-01f,
  -8.33447278e-02f, 1.26269301e-02f, -1.14821687e-01f, 4.29912321e-02f, 1.80890203e-01f, -1.39817774e-01f, 7.24295899e-02f, -1.51892424e-01f, -5.23424186e-02f, -5.82124852e-02f,
  1.01075143e-01f, -1.64216496e-02f, 6.86915293e-02f, -9.04045403e-02f, -3.47316302e-02f, 2.91625112e-02f, -4.27453071e-02f, 2.52346415e-02f, 6.16511935e-03f, -2.59496421e-02f,
  2.17251107e-03f, -4.29562144e-02f, 1.39330635e-02f, 6.75865635e-02f, -2.49965563e-02f, 2.45605335e-02f, 1.12863608e-01f, 2.87501551e-02f, 1.73401758e-02f, 1.78799648e-02f,
  6.92401500e-03f, 1.36754115e-03f, -5.44371679e-02f, -1.12688981e-01f, 6.56379387e-02f, -1.29291639e-01f, -1.17956065e-02f, 4.84531047e-03f, -6.06726184e-02f, 2.18899939e-02f,
  2.42459308e-02f, -2.15836093e-02f, 1.40381223e-02f, 4.30084486e-03f, 8.74915570e-02f, 6.02259971e-02f, -8.70972648e-02f, -1.89265963e-02f, -8.65164027e-02f, -2.68735038e-03f,
  -5.82616776e-03f, 7.90817849e-03f, -8.20836872e-02f, -8.49376395e-02f, -1.26661539e-01f, 6.10414557e-02f, 6.96243048e-02f, -5.14153130e-02f, -4.58195014e-03f, 1.62222646e-02f,
  -2.10535638e-02f, -7.78257474e-03f, 8.53860751e-02f, 2.93343458e-02f, -1.00185156e-01f, -4.04180633e-03f, 7.62459710e-02f, 1.44983353e-02f, 6.09889813e-02f, -3.39949690e-02f,
  -7.88269117e-02f, 4.64874227e-03f, -5.72821535e-02f, -3.69767621e-02f, 1.77289862e-02f, -2.47593522e-02f, 5.13244197e-02f, 1.11843109e-01f, -2.61056293e-02f, -4.38290946e-02f,
  -6.51898654e-03f, 7.41803050e-02f, 4.10721749e-02f, 9.48851928e-03f, -4.03961278e-02f, -6.56016991e-02f, 7.37050697e-02f, 5.94935454e-02f, 2.09632795e-02f, -8.00520927e-02f,
  4.90514096e-03f, -6.43135160e-02f, 1.24101825e-02f, -1.11875555e-03f, 9.38025266e-02f, -9.94179845e-02f, 1.21945195e-01f, 2.34735478e-02f, 7.23954812e-02f, 7.29727224e-02f,
  3.65406796e-02f, -9.76211578e-02f, 1.16805024e-02f, -9.72760841e-02f, -8.82815570e-02f, 6.10637441e-02f, -1.17977619e-01f, 6.45331889e-02f, 7.16033727e-02f, 1.75296783e-01f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -7.43848458e-02f, -1.30105481e-01f, -1.61220908e-01f, -5.95192723e-02f, 2.80506700e-01f, 4.58348915e-02f, 2.08804663e-02f, 1.08980209e-01f, 9.74341761e-03f, 3.48235257e-02f,
  1.03640696e-03f, -2.39902720e-01f, -2.06316590e-01f, -2.56813169e-01f, -3.10541600e-01f, -3.53904396e-01f, -6.87798783e-02f, -2.16284290e-01f, -1.77380696e-01f, 3.43501791e-02f,
  -2.09212434e-02f, -1.00209400e-01f, -2.10970584e-02f, 3.30432922e-01f, 1.58697322e-01f, 1.90093055e-01f, 2.93771088e-01f, 9.47321113e-03f, 1.51990518e-01f, -4.90264036e-02f,
  -1.49155438e-01f, -1.36689633e-01f, 5.47247641e-02f, -9.63226110e-02f, 1.25580534e-01f, 2.11998060e-01f, 8.18143692e-03f, -1.00592755e-01f, -1.50093079e-01f, -2.71513760e-02f,
  4.73807454e-02f, -7.00253323e-02f, -1.53805405e-01f, -1.51202334e-02f, 6.76788092e-02f, 1.07998066e-02f, -8.82648751e-02f, 2.98026092e-02f, -2.46285405e-02f, 2.08924934e-02f,
  5.67784011e-02f, 3.50639299e-02f, 1.06496587e-01f, -1.03010781e-01f, -5.73841445e-02f, -8.40201676e-02f, 1.28629385e-02f, -6.12617508e-02f, 7.12251663e-02f, -3.10212523e-02f,
  1.20113995e-02f, 1.28628269e-01f, -3.62710357e-02f, -1.51057735e-01f, -5.47811575e-02f, 8.70993063e-02f, -5.53200431e-02f, 1.31408777e-02f, -4.96373065e-02f, -5.98218404e-02f,
  6.10294417e-02f, -1.25675187e-01f, 2.44710576e-02f, 3.57430242e-02f, -1.01848627e-02f, -2.65540462e-02f, 1.19598433e-01f, 9.72889771e-04f, 5.58450967e-02f, -6.04602844e-02f,
  1.41520025e-02f, 3.95153016e-02f, -2.92057972e-02f, 1.22070916e-01f, -9.65704769e-02f, -6.96264580e-03f, 6.93435147e-02f, -7.60059059e-02f, 1.50099937e-02f, 8.29964280e-02f,
  4.54096822e-03f, -4.37866338e-02f, -6.11834526e-02f, -1.34175152e-01f, -5.10131232e-02f, -3.81077006e-02f, -6.05641268e-02f, -5.69281466e-02f, -9.70158279e-02f, 2.40295846e-02f,
  1.08634531e-01f, 1.57725617e-01f, 2.07320914e-01f, -2.33076792e-02f, 2.40921527e-02f, 1.00291029e-01f, 1.00792468e-01f, -6.23591430e-02f, 1.49608761e-01f, 9.76466611e-02f,
  9.22290981e-02f, 7.15696141e-02f, -8.34947545e-03f, 5.15005328e-02f, -7.01666751e-04f, 5.13635129e-02f, 1.02454320e-01f, -6.97724745e-02f, 5.48329949e-02f, 2.18018461e-02f,
  -5.02575219e-01f, 9.33973566e-02f, 2.24315405e-01f, -5.96439242e-02f, -2.50084400e-01f, 1.78863123e-01f, 2.75112271e-01f, 3.50294523e-02f, 5.33617176e-02f, 3.08365136e-01f,
  1.08836733e-01f, -1.60385847e-01f, 2.06426665e-01f, 1.58262730e-01f, 7.78896660e-02f, 2.68691540e-01f, 1.07746296e-01f, 1.56407133e-02f, -1.14726432e-01f, -2.19012409e-01f,
  -1.40471220e-01f, -5.12334965e-02f, 1.14062749e-01f, -2.15212166e-01f, -3.58118750e-02f, -1.00573957e-01f, -7.67378584e-02f, 3.66128609e-03f, -3.64813544e-02f, -7.13513345e-02f,
  -6.31667525e-02f, -1.59574345e-01f, -9.79422964e-03f, 9.32211503e-02f, 1.53997958e-01f, 6.85279025e-04f, -1.48610529e-02f, 4.45357300e-02f, 2.96872412e-03f, -8.86964351e-02f,
  -4.22798023e-02f, -9.42780375e-02f, -9.21787694e-02f, 1.76995248e-02f, -3.03725544e-02f, -4.12390160e-04f, 1.93488002e-02f, -1.94180117e-03f, -7.97593500e-03f, 6.39096051e-02f,
  1.38621390e-01f, -9.52439010e-03f, 1.52614161e-01f, -9.78973974e-03f, -3.63095291e-02f, 7.89217502e-02f, 3.53731588e-02f, 7.50521347e-02f, -4.58543412e-02f, -2.07074881e-02f,
  -1.93462029e-01f, -1.80465840e-02f, 2.94691734e-02f, -6.79522194e-03f, 3.04518249e-02f, -9.84920189e-02f, 9.18090492e-02f, 3.95023301e-02f, 9.77955461e-02f, -4.89440374e-02f,
  2.18414869e-02f, -7.67353475e-02f, -3.44559997e-02f, 9.17190537e-02f, -4.15551700e-02f, 7.06459954e-02f, 3.44585255e-02f, -5.22178076e-02f, 8.01105425e-02f, 6.11079531e-03f,
  1.86211448e-02f, 2.35913824e-02f, -3.63481827e-02f, -1.24932602e-01f, 4.78919819e-02f, 1.92594547e-02f, -2.09888932e-03f, 4.74089235e-02f, 5.45269735e-02f, -1.25100106e-01f,
  -1.03221595e-01f, -1.67910650e-01f, -1.33337174e-02f, -1.06235959e-01f, -1.73463894e-03f, -3.03959753e-02f, -4.31916118e-02f, -1.53454626e-02f, -7.47518316e-02f, -8.51927698e-02f,
  -7.21179098e-02f, -6.80425623e-03f, -1.44632161e-01f, 5.31215854e-02f, 3.27491388e-02f, 7.99947679e-02f, -1.12823611e-02f, -2.60779317e-02f, 5.33206761e-02f, -4.87519056e-02f,
  -1.98521148e-02f, -7.08021298e-02f, 5.35635918e-04f, -3.49448398e-02f, -3.57367434e-02f, 5.61544932e-02f, -9.66190323e-02f, 1.56922285e-02f, -1.24488734e-01f, 6.11786470e-02f,
  6.84581771e-02f, -2.25788340e-01f, -1.48381531e-01f, 6.95452169e-02f, -7.41621805e-03f, 8.07122290e-02f, 1.78270802e-01f, -1.41289338e-01f, -2.23998055e-01f, 1.26686871e-01f,
  2.78590053e-01f, 6.57829791e-02f, 2.06734091e-01f, 2.12800637e-01f, 1.06641121e-01f, 1.21979967e-01f, 4.39594202e-02f, 1.13202244e-01f, -3.38309370e-02f, -2.02309974e-02f,
  5.89803830e-02f, 4.04751897e-02f, 1.61105037e-01f, -1.08946882e-01f, 1.30429387e-01f, -1.13494769e-02f, 7.61005059e-02f, 1.15539901e-01f, 1.60349175e-01f, 2.46112701e-02f,
  -1.87669657e-02f, -7.28661269e-02f, -2.36388240e-02f, -6.95035756e-02f, 4.78534885e-02f, 6.78253174e-02f, 4.21636403e-02f, 1.09694332e-01f, 2.90854592e-02f, -4.76966202e-02f,
  3.15065272e-02f, -3.05824238e-03f, 1.80230308e-02f, 1.55000184e-02f, -5.43811955e-02f, -8.62150714e-02f, -3.28548253e-02f, -2.46896707e-02f, -6.81467056e-02f, 1.41039729e-01f,
  -1.78935733e-02f, -1.44942522e-01f, -1.07872291e-02f, -5.95404245e-02f, -5.28052747e-02f, -2.97781508e-02f, 4.72250432e-02f, 3.03639770e-02f, -8.40317607e-02f, -1.77937537e-01f,
  -3.45593430e-02f, 8.75476226e-02f, -1.00976396e-02f, 2.96579208e-02f, 3.40292901e-02f, 1.08376658e-02f, 1.38359681e-01f, 1.34483367e-01f, 6.73395768e-02f, 1.08943231e-01f,
  1.10154070e-01f, 1.01062462e-01f, -9.84599162e-03f, 1.40132591e-01f, 4.72672917e-02f, -6.40294328e-02f, 3.94203067e-02f, -1.62467793e-01f, 3.77946347e-02f, -1.02559254e-02f,
  1.25314027e-01f, 1.72041804e-02f, 1.18585914e-01f, -6.16892576e-02f, 7.81554952e-02f, 8.09108540e-02f, -4.83576767e-02f, -1.79935694e-02f, -3.40318382e-02f, -1.25039956e-02f,
  -6.96028471e-02f, -3.36699001e-02f, -5.69562949e-02f, -1.20651007e-01f, 2.57284287e-02f, -7.61648035e-03f, 2.20550075e-02f, -9.96935293e-02f, 1.06052635e-02f, -1.42102852e-01f,
  8.92622620e-02f, -2.95725390e-02f, -9.58628859e-03f, 2.16456521e-02f, -7.70573467e-02f, 1.81561301e-03f, 1.41156435e-01f, 7.68198690e-04f, -1.56226829e-02f, 3.08314301e-02f,
  5.55187091e-02f, -8.34670588e-02f, 8.20175111e-02f, -8.15925151e-02f, 2.23312397e-02f, 7.34292939e-02f, -1.31747946e-01f, 2.33117733e-02f, 2.73316950e-02f, -7.51719922e-02f,
  5.16876671e-03f, 2.51248121e-01f, -3.00546978e-02f, 2.48833746e-01f, -5.99218830e-02f, 2.14825004e-01f, 2.86132395e-01f, 5.72451726e-02f, 2.27931783e-01f, 3.75220031e-01f,
  8.41011330e-02f, 2.13125706e-01f, -3.58246900e-02f, 1.95595682e-01f, -8.85384716e-03f, 1.91847503e-01f, 2.09597006e-01f, 2.19621763e-01f, 2.44760867e-02f, 2.30757311e-01f,
  1.35017850e-03f, 2.51720995e-01f, -1.65776432e-01f, 9.85305756e-02f, 9.99838412e-02f, -1.36061385e-01f, -1.58027738e-01f, -1.59092277e-01f, 1.12587409e-02f, -6.10971600e-02f,
  -1.00170128e-01f, 3.41402814e-02f, -9.18052644e-02f, -5.22245467e-02f, -1.02152877e-01f, -9.07756686e-02f, -2.65506785e-02f, -1.05647212e-02f, -5.18077984e-02f, -1.00626554e-02f,
  8.20127800e-02f, 3.54957916e-02f, 6.66061118e-02f, -8.63692351e-03f, 3.54112834e-02f, -1.06561258e-01f, 2.75807790e-02f, -3.68893743e-02f, -2.03967057e-02f, -9.52743217e-02f,
  4.69108000e-02f, 1.56493578e-02f, -5.53483330e-02f, -2.15831846e-02f, -1.21098414e-01f, 7.84038156e-02f, 6.15318753e-02f, 4.23391256e-03f, 4.62191962e-02f, 8.69060457e-02f,
  -1.30755939e-02f, 4.37232368e-02f, 8.44040811e-02f, 5.83164431e-02f, -2.63135917e-02f, -3.12570408e-02f, 1.00684591e-01f, -3.38771082e-02f, -2.98868697e-02f, 3.74795347e-02f,
  5.45471087e-02f, 4.64954898e-02f, 1.39404619e-02f, 7.05977529e-02f, 1.33046910e-01f, 1.16622902e-01f, 2.51659956e-02f, 3.01707070e-02f, 1.35323042e-02f, 9.68964547e-02f,
  3.94753588e-04f, 2.26815864e-02f, 2.02362668e-02f, -1.04190923e-01f, 2.28224471e-02f, 5.47756292e-02f, -8.25095922e-02f, -1.36462562e-02f, -3.02050682e-03f, -4.25866507e-02f,
  1.27209485e-01f, 3.04023623e-01f, 4.42928672e-02f, 5.96420430e-02f, 3.21195135e-03f, 3.04520763e-02f, 5.79456389e-02f, -2.30387636e-02f, 3.03542782e-02f, -1.35803455e-02f,
  -5.23489006e-02f, 1.29320487e-01f, 5.53103574e-02f, -1.55052552e-02f, -4.10007499e-02f, 1.33694559e-01f, 1.25513852e-01f, -2.17527840e-02f, -8.43237527e-03f, -2.10128769e-01f,
  -3.76336910e-02f, 8.29898417e-02f, 1.47293666e-02f, -5.99990897e-02f, -7.13162795e-02f, 6.08523674e-02f, 6.58259317e-02f, -1.82520419e-01f, -8.08859244e-02f, -4.90658022e-02f,
  2.08239898e-01f, -1.70807526e-01f, -7.73175508e-02f, -4.84319739e-02f, 1.30562112e-01f, 1.39510557e-01f, 2.33561933e-01f, -1.18829019e-01f, -2.63022542e-01f, -4.76255566e-02f,
  1.77028820e-01f, 2.23080553e-02f, 1.10483959e-01f, 1.48819864e-01f, 3.05459082e-01f, 2.86465287e-02f, 1.52187971e-02f, 2.04498976e-01f, -6.60099685e-02f, 1.79966554e-01f,
  9.15538073e-02f, 2.77135134e-01f, -1.85880810e-02f, -5.26860058e-02f, 1.88785240e-01f, -1.35019615e-01f, 1.57377005e-01f, 1.05726123e-01f, -1.60173103e-02f, 6.29610568e-02f,
  -7.97034353e-02f, -1.43164331e-02f, 2.59574945e-03f, -7.15187490e-02f, 1.02432415e-01f, 1.14562482e-01f, 9.54600424e-02f, 5.20059280e-02f, 9.41424966e-02f, 3.77303176e-02f,
  3.26225944e-02f, 3.74787375e-02f, -8.43675509e-02f, -5.92919774e-02f, -9.05315727e-02f, 2.48981733e-03f, -4.13735025e-02f, -5.84028475e-02f, -1.00333644e-02f, 3.38938236e-02f,
  -1.29267424e-02f, 8.55349377e-02f, -4.27386835e-02f, -7.30481222e-02f, -2.08969191e-02f, 8.81389901e-03f, 5.23327552e-02f, -2.97222715e-02f, 1.05708659e-01f, 2.57905461e-02f,
  5.64973429e-02f, 5.75907342e-03f, 1.06074154e-01f, -1.62407123e-02f, 1.30270854e-01f, 5.46438284e-02f, 1.14861047e-02f, 3.38784158e-02f, -5.43744117e-02f, 9.56272036e-02f,
  -1.50480364e-02f, 9.78070050e-02f, -6.13196287e-03f, -5.22369519e-02f, 1.20603584e-01f, -5.83678037e-02f, 6.30119517e-02f, -1.48246856e-02f, -8.82508829e-02f, 1.47081241e-02f,
  -5.87559817e-03f, 4.09427620e-02f, 2.86774486e-02f, -8.62255469e-02f, 7.49860033e-02f, -1.78590622e-02f, -5.42357638e-02f, 3.67185194e-03f, -4.00820151e-02f, -1.64508801e-02f,
  -5.22021018e-02f, -1.19337372e-01f, -1.48221403e-01f, -1.13819979e-01f, -3.34888063e-02f, 1.85758457e-01f, 1.91043653e-02f, 1.10715041e-02f, -1.07130088e-01f, -2.40577403e-02f,
  1.13718279e-01f, 5.66924661e-02f, -5.20926863e-02f, -3.81797925e-02f, -5.31939603e-02f, -6.18794896e-02f, -4.67324816e-02f, 2.80080214e-02f, -9.01108980e-03f, 6.13749288e-02f,
  -3.06570437e-02f, 1.36989400e-01f, -6.90928241e-03f, 1.66264288e-02f, -9.65104699e-02f, -1.42117226e-02f, -2.17935648e-02f, -8.26033726e-02f, 8.04958418e-02f, -9.99793876e-03f,
  -1.88067839e-01f, -4.59054075e-02f, -1.32550105e-01f, 1.22599244e-01f, 4.76485193e-02f, -2.12674905e-02f, -1.39015138e-01f, 1.92527264e-01f, -1.63137883e-01f, -4.46244255e-02f,
  1.35276884e-01f, -1.39466763e-01f, -1.93676591e-01f, -2.41019707e-02f, 7.57887587e-02f, -2.34676182e-01f, 1.17462292e-01f, 5.47043746e-03f, -1.00350771e-02f, 1.02924414e-01f,
  1.01251323e-02f, 1.64105907e-01f, 1.42889589e-01f, 1.75424501e-01f, -7.49220327e-02f, 1.53068438e-01f, 3.01803797e-01f, -6.65495591e-03f, 2.04334661e-01f, 1.10863727e-02f,
  -9.21739042e-02f, -2.97453869e-02f, -3.51516083e-02f, -1.32115841e-01f, 1.21034659e-01f, -3.42096649e-02f, 2.64156442e-02f, -6.66377023e-02f, 1.92230698e-02f, 4.57986481e-02f,
  -9.37987864e-02f, -2.80415826e-02f, -3.31431143e-02f, -6.41207621e-02f, -7.22032115e-02f, 1.68540683e-02f, 2.10635383e-02f, 1.15808379e-02f, 3.61253954e-02f, -7.52053708e-02f,
  6.52919151e-03f, 5.87775111e-02f, -3.02434023e-02f, 7.14871613e-03f, 1.37175545e-01f, 1.05571195e-01f, 7.44712800e-02f, 3.11964303e-02f, 7.66899288e-02f, 9.48913470e-02f,
  -4.84203026e-02f, -7.06832558e-02f, 1.01474330e-01f, 3.13825649e-03f, 3.31346430e-02f, 8.02174285e-02f, 3.50896306e-02f, 1.11682296e-01f, 1.53618166e-02f, 8.67374018e-02f,
  4.67808060e-02f, 1.69928312e-01f, 2.66731679e-02f, 2.54454389e-02f, 3.39974277e-02f, -3.05952821e-02f, 1.80919711e-02f, 5.70198447e-02f, 5.79239726e-02f, 1.04027633e-02f,
  -1.12723902e-01f, 5.06572388e-02f, 1.18450401e-02f, -3.29207047e-03f, -6.09895624e-02f, 8.50196257e-02f, 6.08955100e-02f, -2.78344601e-02f, -3.18921357e-02f, -3.04595251e-02f,
  2.84261703e-02f, 4.96385880e-02f, 6.63028434e-02f, 1.29151042e-03f, -1.43958405e-02f, 3.61045115e-02f, -4.58678231e-02f, 3.31836566e-02f, 4.42924574e-02f, 3.83573808e-02f,
  5.99529184e-02f, -1.20446214e-03f, 1.09634048e-03f, -4.36104685e-02f, -5.98476715e-02f, 1.29097775e-01f, -5.61475828e-02f, 7.94486925e-02f, 1.70201696e-02f, 1.87183425e-01f,
  -6.06667586e-02f, 1.09862983e-01f, -4.99594100e-02f, 2.96936631e-02f, 1.23288907e-01f, 8.01687688e-02f, 4.06672060e-02f, 6.98762983e-02f, -1.47742145e-02f, 5.06882928e-02f,
  2.78984874e-01f, -1.88116640e-01f, 1.53293982e-01f, 2.64817625e-01f, -3.83936092e-02f, 1.15408011e-01f, 1.34373620e-01f, 7.13739619e-02f, 3.84832680e-01f, -9.77032930e-02f,
  -1.95939898e-01f, -1.48043353e-02f, 1.89349800e-02f, -7.18589351e-02f, 8.82892385e-02f, 2.60397494e-01f, 1.42423902e-04f, 1.19556248e-01f, 1.49815006e-03f, -6.10946640e-02f,
  2.01613083e-02f, -8.04769248e-02f, -5.17899655e-02f, -6.65451586e-02f, -2.20625982e-01f, 2.36187112e-02f, -1.84525922e-01f, -1.60347372e-02f, -1.15237147e-01f, -1.49823055e-01f,
  -1.48625582e-01f, -7.52676725e-02f, -1.63137168e-01f, -2.69579254e-02f, -5.77971898e-02f, -2.05449071e-02f, 3.48377675e-02f, 3.78808305e-02f, -4.85269213e-03f, 2.75827516e-02f,
  6.00385442e-02f, -6.09389767e-02f, 6.40024319e-02f, 7.82265291e-02f, 8.65754560e-02f, -6.05149847e-03f, 3.45543995e-02f, -1.38770327e-01f, -8.17492902e-02f, -7.58102089e-02f,
  6.11660397e-03f, -2.77748201e-02f, 8.32732320e-02f, -6.71152771e-02f, -9.71917361e-02f, -1.55814877e-02f, 2.36145556e-02f, -3.24214958e-02f, -1.06696360e-01f, 3.52397487e-02f,
  4.54481803e-02f, 1.35637401e-02f, -3.22408080e-02f, 3.89098562e-03f, 5.73060736e-02f, -9.14396942e-02f, 2.22109668e-02f, 2.59505231e-02f, 7.82899652e-03f, 5.00455908e-02f,
  1.29842786e-02f, -1.69876337e-01f, 9.77862775e-02f, -5.37769385e-02f, -8.41380432e-02f, 7.47500807e-02f, 9.65097249e-02f, -4.36821729e-02f, -6.49290606e-02f, -3.80284861e-02f,
  1.05640724e-01f, 5.97245395e-02f, -4.23242040e-02f, -2.94567384e-02f, 4.29332033e-02f, -1.00627551e-02f, -3.52186225e-02f, 5.84777594e-02f, 1.11001089e-01f, -4.10440117e-02f,
  -1.91377923e-02f, 4.88140844e-02f, -1.27888739e-01f, -1.72912627e-01f, 8.72827768e-02f, -9.98662189e-02f, 7.26710334e-02f, -3.04466654e-02f, -6.68550581e-02f, 2.14158581e-03f,
  -3.73720750e-02f, -9.71524343e-02f, -8.37413445e-02f, 3.93153168e-02f, 3.77048776e-02f, -1.01395920e-01f, 1.89775135e-02f, -2.80814860e-02f, -1.89509764e-02f, -3.51963714e-02f,
  -4.85881604e-02f, -1.42729226e-02f, 1.22515084e-02f, -5.47777265e-02f, -2.91260276e-02f, -1.08207405e-01f, -9.61419195e-03f, -1.41701624e-01f, -5.59309311e-02f, -9.60031711e-03f,
  6.29529655e-02f, 8.48507732e-02f, 4.56482172e-02f, 1.93636715e-01f, -2.78810024e-01f, -1.11040741e-01f, -9.35301650e-03f, 7.87237138e-02f, 6.68753078e-03f, 4.12957594e-02f,
  2.30562240e-01f, -2.29317714e-02f, 1.34053543e-01f, 2.13502228e-01f, -5.91168776e-02f, 2.73661047e-01f, 4.97139655e-02f, -1.48398988e-02f, 5.15171662e-02f, 9.40639153e-02f,
  3.55874784e-02f, 1.99082017e-01f, 2.30546236e-01f, 1.01776399e-01f, 7.53431991e-02f, 4.43181060e-02f, 9.55238342e-02f, -1.08293049e-01f, -2.87174527e-02f, -1.53602421e-01f,
  -3.32112461e-02f, 2.17299566e-01f, 2.76948456e-02f, -4.29032966e-02f, 1.32077530e-01f, -2.87765749e-02f, -1.29181802e-01f, -5.14808558e-02f, -9.80306417e-02f, 5.04137129e-02f,
  -2.44121291e-02f, -2.17491593e-02f, 5.44552021e-02f, -1.07848700e-02f, 1.00470604e-02f, -4.60073464e-02f, -6.86507449e-02f, 6.05887594e-03f, -5.81930801e-02f, 1.10919833e-01f,
  1.27011269e-01f, 6.12068325e-02f, -7.28265368e-05f, 1.14274532e-01f, 8.99553970e-02f, -1.21447491e-03f, -9.61974934e-02f, 1.48085793e-02f, 7.32678697e-02f, 3.99242938e-02f,
  3.87154147e-02f, -2.55858619e-02f, 3.24519202e-02f, 8.07992741e-03f, -1.37890413e-01f, -1.21978465e-02f, -3.98149230e-02f, -1.46549389e-01f, -1.18648149e-01f, 1.90932176e-03f,
  -5.06577305e-02f, 6.17182739e-02f, 7.84024969e-02f, -3.09142470e-02f, 1.58158466e-02f, 1.34939551e-01f, -4.15602811e-02f, 5.18844761e-02f, -2.50989590e-02f, -4.73552495e-02f,
  -7.74685219e-02f, -6.15891553e-02f, 3.05909105e-02f, -2.48932932e-02f, 6.81887940e-03f, 2.33263951e-02f, 1.02310374e-01f, -5.89173380e-03f, -6.93472400e-02f, -5.14506996e-02f,
  9.54215676e-02f, 3.38246614e-01f, -1.37290834e-02f, -1.73256006e-02f, 1.21144485e-02f, 8.69612992e-02f, 2.59793494e-02f, 4.72535305e-02f, 1.43114343e-01f, 8.33278745e-02f,
  3.87405157e-02f, -1.42214611e-01f, -7.99062476e-02f, -9.08911750e-02f, 4.34971750e-02f, 1.46336451e-01f, -2.53250059e-02f, 7.33043207e-03f, 4.89405207e-02f, 1.04538370e-02f,
  7.70892128e-02f, 8.99773389e-02f, 1.04087591e-01f, 4.24603140e-03f, 7.86949694e-02f, 1.46350160e-01f, -9.96826589e-02f, -1.65406596e-02f, 7.54114613e-02f, 9.07207876e-02f,
  -5.91103196e-01f, 4.05245483e-01f, 5.30167855e-02f, -5.98271005e-02f, -2.00873241e-01f, 2.06372440e-01f, 1.23526715e-01f, 9.39723104e-02f, -2.00635388e-01f, 1.16106957e-01f,
  -1.27998978e-01f, -5.03101721e-02f, 7.96999708e-02f, 1.06278524e-01f, -7.41198137e-02f, 1.61843374e-01f, 1.78404480e-01f, -2.23041289e-02f, 7.52971694e-02f, -6.32441714e-02f,
  -7.75788203e-02f, -2.25298721e-02f, 1.66713968e-01f, 9.12637636e-02f, 6.90980852e-02f, -3.03208176e-02f, -1.40717715e-01f, -2.94461288e-02f, -1.57848056e-02f, -1.08181372e-01f,
  -1.02261551e-01f, -2.20630720e-01f, -1.01820379e-02f, -5.79531752e-02f, -4.05152850e-02f, -5.85971735e-02f, 8.27066973e-03f, 3.89096402e-02f, -1.20609283e-01f, -9.69031826e-02f,
  -1.11406870e-01f, -1.65109169e-02f, -1.72482058e-02f, -1.13094389e-01f, -4.37185951e-02f, -8.46879184e-02f, 1.68276146e-01f, 1.59702580e-02f, -1.37357814e-02f, 1.14042960e-01f,
  1.68391496e-01f, 3.15094553e-02f, 7.85096511e-02f, 4.41677943e-02f, -4.92257215e-02f, 4.45841439e-02f, 1.18374959e-01f, -1.49364257e-02f, 2.91075502e-02f, -1.11419022e-01f,
  -2.52224151e-02f, 4.38193567e-02f, -4.94599342e-03f, -9.18585956e-02f, -7.53956754e-03f, -1.10379383e-01f, 3.55238356e-02f, -9.00062919e-02f, 7.87474960e-02f, 8.48216191e-02f,
  -2.14700494e-02f, -6.14973158e-03f, -9.08094123e-02f, 2.92836502e-02f, 5.06521901e-03f, -5.74158691e-02f, -6.37659505e-02f, -2.76794564e-02f, 8.83772001e-02f, 1.12139292e-01f,
  -1.28920432e-02f, 2.51335315e-02f, -1.92129286e-03f, -9.19762440e-03f, 2.37041693e-02f, -9.02167428e-03f, -9.69168097e-02f, 1.05555683e-01f, 8.21360275e-02f, -8.74274224e-02f,
  -2.04289347e-01f, -2.48177037e-01f, -4.87457626e-02f, -1.81630969e-01f, -8.13593790e-02f, -1.05219381e-02f, -2.22050399e-02f, 8.12434778e-02f, -1.42583221e-01f, -6.56722859e-02f,
  -1.13859132e-01f, 1.13432128e-02f, -8.02184716e-02f, 2.62376666e-02f, 7.38137439e-02f, -4.52549607e-02f, 1.79455951e-02f, -4.94589172e-02f, -1.50818499e-02f, 1.00736576e-03f,
  7.09118275e-03f, -9.81052741e-02f, -3.00304499e-02f, 8.39168578e-02f, -7.42031354e-03f, -1.33450851e-01f, -8.82487670e-02f, 1.50051981e-01f, -9.05378163e-02f, 3.55675705e-02f,
  -2.80964822e-01f, -3.02596274e-03f, -4.15937036e-01f, 1.13196000e-01f, 1.39311537e-01f, 2.33767167e-01f, 8.09596181e-02f, 9.80730280e-02f, -4.47598211e-02f, 4.24368620e-01f,
  2.77867913e-01f, -2.44531319e-01f, -9.80338603e-02f, 2.80535370e-01f, -5.75934835e-02f, -4.35586199e-02f, 1.94849014e-01f, 9.77038592e-02f, -8.07915255e-02f, -5.62770553e-02f,
  -1.91523165e-01f, 2.47270912e-01f, -7.52672926e-02f, 1.77704487e-02f, 9.73266289e-02f, -1.98866233e-01f, 2.68943161e-01f, -3.29609007e-01f, 2.88350105e-01f, 8.94653723e-02f,
  1.08810673e-02f, -2.33683765e-01f, 4.09508348e-02f, -2.48337463e-01f, -1.35158017e-01f, -2.07886882e-02f, 5.29667735e-02f, -2.43934348e-01f, -2.99902149e-02f, -6.41574413e-02f,
  -4.21859045e-03f, -6.78728595e-02f, 7.80601278e-02f, -1.12670161e-01f, -6.72173426e-02f, -7.34653100e-02f, -1.23020103e-02f, 7.84327462e-02f, 6.61813840e-02f, -1.29322290e-01f,
  -6.02218360e-02f, -3.85032222e-02f, 5.22498116e-02f, 7.56010786e-02f, 3.55909355e-02f, 8.37858417e-04f, 2.40747817e-02f, -1.79026257e-02f, 1.70678169e-01f, 6.92628743e-03f,
  2.68052313e-02f, -3.25438231e-02f, -8.79963413e-02f, 4.56139073e-02f, -9.95117426e-02f, 1.24111623e-02f, 6.14492223e-02f, 3.32061648e-02f, -4.64332327e-02f, 1.98221114e-02f,
  1.05549162e-02f, 4.87036780e-02f, 1.59226712e-02f, -2.10722890e-02f, 2.57916078e-02f, -1.14000300e-02f, 2.32901890e-02f, 8.72873813e-02f, 8.15517232e-02f, 3.98741364e-02f,
  -6.42347708e-02f, -1.00182854e-01f, 6.74500540e-02f, 6.95536360e-02f, -4.45794174e-03f, 2.87872826e-04f, -2.19060015e-02f, 1.85764097e-02f, 3.66050899e-02f, -2.45584883e-02f,
  -4.24395576e-02f, -1.59370542e-01f, -3.45849581e-02f, 1.75667796e-02f, -4.75383624e-02f, -2.53197160e-02f, 3.37647870e-02f, -5.64941671e-03f, 2.25683581e-02f, -4.46452312e-02f,
  -8.22782703e-03f, 1.97602101e-02f, -3.28983255e-02f, 2.12497469e-02f, 3.39762531e-02f, 8.59068632e-02f, -6.65158406e-02f, -2.04471573e-02f, 1.38211459e-01f, -1.70044950e-03f,
  1.32483328e-02f, -1.69551596e-02f, -1.23001467e-02f, 7.39947706e-02f, 1.56793252e-01f, 1.92755193e-01f, -3.94291766e-02f, -6.06341176e-02f, 9.89960954e-02f, 9.51279476e-02f,
  -4.94084246e-02f, 4.20644820e-01f, 1.13492221e-01f, -5.63575700e-03f, -8.89940709e-02f, -2.15277076e-01f, -3.92584689e-02f, 1.23492368e-01f, 7.37099946e-02f, 1.80199176e-01f,
  -1.18996844e-01f, 3.61563027e-01f, 2.89134067e-02f, -8.92367214e-02f, -5.63824713e-01f, -3.28755975e-01f, -2.90358037e-01f, -2.27624271e-02f, -8.01956505e-02f, -4.17677592e-03f,
  -1.37006477e-01f, -1.76340938e-01f, -1.77478954e-01f, 5.92846051e-02f, 1.69430315e-01f, 1.94023117e-01f, -2.27746010e-01f, 1.26374468e-01f, 3.10088675e-02f, -7.40479305e-02f,
  4.11431156e-02f, 1.65673628e-01f, 1.04680516e-01f, 1.69158522e-02f, -7.66798109e-02f, 2.24040039e-02f, 3.96106625e-03f, 5.53266658e-03f, -7.10690320e-02f, 1.80049843e-04f,
  4.32038493e-02f, -3.43992561e-02f, -3.54738012e-02f, -1.28449142e-01f, 1.69275180e-02f, -1.84270218e-02f, 7.16183931e-02f, 2.70891469e-02f, 5.46428524e-02f, 1.98410843e-02f,
  1.02146730e-01f, 8.62537175e-02f, -4.02876288e-02f, -6.49092495e-02f, -1.13678686e-01f, -7.78034478e-02f, 9.09806043e-03f, -3.41704376e-02f, -2.66094748e-02f, -5.31303845e-02f,
  1.64099075e-02f, -1.03683501e-01f, -5.16515002e-02f, 1.07995793e-01f, -6.56464621e-02f, 4.19718586e-02f, -3.12171876e-02f, 5.25999814e-02f, 1.36247156e-02f, 1.18883505e-01f,
  3.80207226e-02f, 1.67138223e-02f, -9.75916237e-02f, -2.08405890e-02f, -1.13510778e-02f, -4.30660099e-02f, -9.41646993e-02f, 8.54443386e-02f, -7.53956661e-02f, -2.92265639e-02f,
  1.44227207e-01f, -4.13840003e-02f, -4.77225147e-03f, -5.40510863e-02f, -9.32435784e-03f, -1.44896954e-02f, 2.09239982e-02f, -4.60213795e-02f, 9.94616672e-02f, -1.12565599e-01f,
  -1.03584826e-01f, 4.81632389e-02f, -9.57200490e-03f, 8.38749632e-02f, -4.45693322e-02f, 2.67748125e-02f, -7.24001825e-02f, -1.05389776e-02f, -9.74284194e-04f, -2.78637409e-02f,
  4.80495812e-03f, -6.83605820e-02f, -4.26550955e-03f, 8.28108657e-03f, -9.17065516e-02f, -1.02221377e-01f, -4.10944894e-02f, 4.38718423e-02f, -5.03942966e-02f, 1.92715619e-02f,
  1.00187398e-01f, 8.21305439e-02f, -6.66066110e-02f, -4.14596125e-02f, -1.68651007e-02f, -2.77877576e-03f, -1.84118506e-02f, 4.88666035e-02f, -6.11723475e-02f, -8.82498696e-02f,
  -3.85778844e-02f, -2.46012956e-01f, -4.36853543e-02f, -1.27318576e-01f, -8.00516177e-03f, -3.33748162e-02f, -9.61345285e-02f, -9.39526036e-02f, -1.06466435e-01f, -2.53156871e-01f,
  -1.35256782e-01f, 7.58341141e-03f, 5.90503588e-02f, -3.10902268e-01f, 3.24469447e-01f, 1.32279202e-01f, -9.97385085e-02f, -8.63697454e-02f, 2.76067015e-02f, -1.36254370e-01f,
  -1.63369313e-01f, -3.33152562e-01f, 1.14122988e-03f, -2.23838598e-01f, -2.95526266e-01f, -1.84751779e-01f, 2.09366512e-02f, 1.01356572e-02f, -2.55141407e-01f, 6.12820685e-02f,
  4.09001149e-02f, -7.25225955e-02f, -7.24460632e-02f, -4.40877751e-02f, -1.05171874e-02f, -3.07360478e-02f, -4.51610750e-03f, 1.24933012e-03f, 8.46428946e-02f, -2.57057343e-02f,
  3.67658474e-02f, -5.79489097e-02f, -6.69303983e-02f, 5.59249632e-02f, -1.10925891e-01f, -4.94104363e-02f, -2.59089321e-02f, 1.49598926e-01f, -5.24415150e-02f, -1.69758778e-02f,
  2.32231040e-02f, 4.03476506e-02f, -1.37240896e-02f, 7.38167018e-02f, 2.52532214e-02f, -6.02722317e-02f, -4.04598042e-02f, 1.13047622e-01f, 3.20101604e-02f, -3.02576497e-02f,
  -4.86774594e-02f, -5.95585033e-02f, -7.53679872e-02f, -1.43529568e-02f, -1.23418637e-01f, -1.22526698e-01f, -1.14402184e-02f, -7.08946912e-03f, -6.44745529e-02f, 3.41608711e-02f,
  5.20703159e-02f, 6.49668053e-02f, -5.85581292e-04f, -5.42058647e-02f, -1.53485075e-01f, 2.58147828e-02f, -3.59610543e-02f, 4.02332582e-02f, 5.17217815e-02f, 8.03222284e-02f,
  -5.43052368e-02f, 1.26001341e-02f, -7.09913895e-02f, 2.57096253e-02f, -9.54289064e-02f, 2.12999526e-02f, -4.47227657e-02f, -8.08270201e-02f, -2.77529620e-02f, 9.68239680e-02f,
  4.47388366e-02f, 2.36341991e-02f, 2.06956342e-02f, 3.42177227e-02f, 6.59823865e-02f, -1.12708956e-02f, 4.76434780e-03f, -5.77200204e-02f, 2.25213449e-02f, -8.69113579e-02f,
  -4.18139920e-02f, -6.99368268e-02f, 5.59952669e-02f, 1.40808895e-01f, -4.23182696e-02f, -6.38058856e-02f, -3.99429239e-02f, 1.01774067e-01f, 9.61954445e-02f, 9.30733606e-02f,
  -9.20611322e-02f, 2.88972147e-02f, 1.07086860e-02f, 3.01972236e-02f, -2.92384829e-02f, 8.03620517e-02f, 1.11896619e-02f, -1.95509344e-02f, 2.95324828e-02f, -2.94955261e-02f,
  -3.56524289e-01f, 2.60895461e-01f, 2.42856458e-01f, 6.66252896e-02f, 1.37630552e-01f, 4.90101784e-01f, 2.73321092e-01f, 1.93428889e-01f, 3.78827125e-01f, 2.03607649e-01f,
  4.24625240e-02f, 7.25152576e-03f, 1.90467928e-02f, 5.35638519e-02f, 1.79026097e-01f, 2.54194230e-01f, 1.33578926e-01f, 1.12761185e-01f, 7.27438033e-02f, -1.35575965e-01f,
  -1.30371153e-01f, -2.27080584e-02f, -1.70542687e-01f, -1.17569856e-01f, -6.83546215e-02f, -1.64331406e-01f, -1.97080269e-01f, 8.29539225e-02f, -1.01004563e-01f, 1.66086793e-01f,
  -1.17242694e-01f, -6.34875670e-02f, -2.40337312e-01f, 4.86201309e-02f, -4.27360497e-02f, 1.19303325e-02f, -2.06778347e-02f, 8.75025094e-02f, 1.31618464e-02f, 4.88753952e-02f,
  -4.90783677e-02f, -4.14380804e-02f, -6.91207079e-03f, 9.61491466e-02f, 1.14857696e-01f, -3.66765447e-02f, 5.11690974e-02f, -6.70769298e-03f, -1.67445447e-02f, -2.95067541e-02f,
  -3.23989876e-02f, 6.70286641e-02f, -1.32329702e-01f, 6.77619036e-03f, -4.01587114e-02f, 5.80191761e-02f, 8.83472059e-03f, -5.80213405e-02f, 1.25606265e-02f, 1.23229817e-01f,
  -9.93496645e-03f, -4.50815409e-02f, 8.24594032e-03f, -2.61918660e-02f, 4.31787362e-03f, -1.00390799e-01f, -2.19886564e-02f, -9.25486814e-03f, -1.05533794e-01f, -1.51515380e-01f,
  1.50490459e-03f, -7.44000971e-02f, -1.88301876e-03f, 2.46693403e-03f, 1.06675643e-02f, -1.74494218e-02f, -4.71703596e-02f, -1.82204377e-02f, -2.37559881e-02f, -9.17331800e-02f,
  3.11472709e-03f, 8.32140222e-02f, -6.45588264e-02f, 3.57174635e-04f, 4.75529991e-02f, 9.33744572e-03f, 6.43403828e-02f, 6.40321821e-02f, 3.19379792e-02f, -1.33401882e-02f,
  1.97714180e-01f, 2.40134493e-01f, -2.40552947e-02f, 1.13340672e-02f, 5.46131246e-02f, 2.12668143e-02f, 2.67157871e-02f, 1.24458894e-02f, 1.16593689e-01f, 6.45844191e-02f,
  1.17375376e-02f, -4.28749621e-02f, -5.32370582e-02f, 7.63113275e-02f, 1.24169663e-01f, 8.04271400e-02f, 4.19065468e-02f, 6.58688769e-02f, 1.10820115e-01f, -1.18105002e-02f,
  -2.47867834e-02f, -4.85406211e-03f, -3.55842486e-02f, -5.99541441e-02f, -9.48034320e-03f, -1.21275000e-01f, -2.62632649e-02f, 5.25112785e-02f, 1.69921797e-02f, 7.05398098e-02f,
  1.58530518e-01f, -1.08365618e-01f, -2.33803585e-01f, -1.95130572e-01f, 1.41525537e-01f, 2.42873758e-01f, -2.37788975e-01f, 7.18151778e-02f, -2.47007087e-01f, -1.14114836e-01f,
  6.93350360e-02f, -7.12223724e-02f, -2.41376907e-01f, 2.75337219e-01f, 3.55099767e-01f, -1.82164237e-01f, 1.93659753e-01f, 1.68965340e-01f, -1.24909151e-02f, 3.84224430e-02f,
  8.15950707e-02f, 3.74198675e-01f, -2.50335522e-02f, 3.01141292e-01f, 2.05683231e-01f, 7.42052170e-03f, 1.44398779e-01f, -3.03975400e-02f, 2.22584665e-01f, 1.24098919e-01f,
  8.28472599e-02f, -6.36213273e-02f, -8.94937664e-02f, 6.74691871e-02f, -1.19372010e-01f, -6.69481140e-03f, -2.42152736e-02f, 8.78492817e-02f, -3.33088241e-03f, -1.05649561e-01f,
  -4.70343865e-02f, 3.28299925e-02f, 5.39773628e-02f, 7.21699744e-02f, 7.88533129e-03f, -1.05977375e-02f, -3.83858159e-02f, -1.17041960e-01f, -8.53593051e-02f, 6.07648715e-02f,
  -5.38723171e-02f, -1.06464967e-03f, -2.09510252e-02f, -9.08273235e-02f, -1.19006485e-01f, 1.64098088e-02f, -6.65378720e-02f, -9.46192592e-02f, 7.77410269e-02f, -5.20311557e-02f,
  5.76215610e-02f, 5.11788167e-02f, 7.29999319e-02f, -9.54737887e-03f, -8.27824790e-03f, -3.58750336e-02f, 1.19139239e-01f, 1.10178012e-02f, 1.47100948e-02f, -6.64841980e-02f,
  9.61828418e-03f, -5.38812354e-02f, -4.36666869e-02f, 6.08106959e-04f, 1.31217808e-01f, -1.16113033e-02f, -2.77036596e-02f, -1.34927565e-02f, -1.46014825e-01f, 1.92136057e-02f,
  1.49281323e-02f, 1.05306186e-01f, -9.53209028e-02f, -3.96745428e-02f, 1.43619284e-01f, -1.16718352e-01f, 7.98152536e-02f, 4.91778119e-05f, 3.93175669e-02f, 1.16447350e-02f,
  5.57939969e-02f, -1.11812867e-01f, -9.42308903e-02f, -4.96883392e-02f, -5.06889671e-02f, 1.16686746e-01f, 2.11487170e-02f, -1.13155553e-02f, -2.62122918e-02f, -4.01848257e-02f,
  4.67245206e-02f, -4.15546298e-02f, 1.69318402e-03f, -5.80288470e-02f, 8.27887282e-02f, -5.43588027e-02f, -6.56917542e-02f, -8.28329921e-02f, -1.92798242e-01f, -3.56653472e-03f,
  -1.62535384e-02f, 5.57782836e-02f, -1.21902473e-01f, 2.39226781e-02f, -3.55425291e-02f, -6.96984679e-02f, 1.17244177e-01f, -3.58580202e-02f, 7.31822103e-02f, -1.54555917e-01f,
  -4.59299050e-02f, -5.16798973e-01f, -1.65401883e-02f, 8.46302062e-02f, 2.04893798e-01f, 1.12510994e-01f, 1.30433947e-01f, -7.15665892e-02f, -2.43710265e-01f, -2.47229576e-01f,
  -1.43488916e-02f, -1.10236920e-01f, -2.64492065e-01f, 1.03128903e-01f, 3.41719568e-01f, -1.35436147e-01f, 1.11237690e-01f, 1.08914077e-01f, -1.23528510e-01f, -3.45603339e-02f,
  5.02640940e-02f, 2.06701875e-01f, 4.02769595e-02f, 1.36425728e-02f, -3.49497795e-02f, -3.41634229e-02f, -4.04082611e-02f, 3.00594307e-02f, 1.20275795e-01f, 1.66007072e-01f,
  1.88409742e-02f, -1.78434923e-01f, 8.97471420e-03f, -8.56183842e-03f, -7.29756504e-02f, 8.93004518e-03f, 1.24109700e-01f, 1.74118038e-02f, 1.48414383e-02f, -3.23958732e-02f,
  -5.19425534e-02f, -4.91839088e-02f, 6.93786442e-02f, 3.07260919e-03f, -1.13967277e-01f, -7.69769698e-02f, -9.62037891e-02f, 1.99917797e-02f, -9.34105590e-02f, -9.94993374e-02f,
  -6.41538799e-02f, 3.65839973e-02f, -6.81836158e-02f, 4.01886776e-02f, -3.84015590e-02f, 1.81258582e-02f, 6.36498183e-02f, 1.36734471e-02f, -3.40545960e-02f, -2.39265580e-02f,
  -6.64428845e-02f, 6.59514740e-02f, -6.88301623e-02f, 5.65784313e-02f, -2.69053262e-02f, 2.27763373e-02f, -5.56751341e-02f, 1.49237821e-02f, -6.77517205e-02f, -3.72085050e-02f,
  2.52081137e-02f, 1.01167737e-02f, -1.29979745e-01f, -6.76082745e-02f, -1.03772832e-02f, 6.10607602e-02f, -7.67445075e-04f, 9.99124497e-02f, 7.43030906e-02f, 3.65684368e-02f,
  8.24825242e-02f, 4.74286936e-02f, 2.92914808e-02f, -1.74372718e-02f, 2.10810583e-02f, -1.33934200e-01f, -7.65533745e-02f, 2.29702555e-02f, 1.34956476e-03f, 1.75383482e-02f,
  -1.70729831e-01f, -3.93609494e-01f, 4.23187800e-02f, 1.06597275e-01f, 5.68774119e-02f, -3.23537402e-02f, 7.94376433e-02f, 7.56491488e-03f, -6.60812855e-02f, -1.56390920e-01f,
  5.01774773e-02f, 4.10351828e-02f, -5.88288670e-03f, -6.26571383e-03f, 8.83566737e-02f, -1.21009134e-01f, -1.22417510e-01f, 3.36360522e-02f, -3.07438150e-03f, 4.34184400e-03f,
  1.72932949e-02f, -8.14334825e-02f, 9.99016091e-02f, 7.90431798e-02f, -2.15661433e-02f, 1.05779938e-01f, -3.97947580e-02f, 1.39936253e-01f, 6.81684986e-02f, 2.79856455e-02f,
  -4.46017236e-01f, 4.69639897e-02f, 5.27531505e-01f, -3.52731228e-01f, 2.64557041e-02f, 3.53280723e-01f, 2.47861683e-01f, -8.58768225e-02f, -3.58145386e-01f, -1.52608966e-02f,
  -5.95170371e-02f, 1.07888527e-01f, 1.40596360e-01f, -1.37901306e-01f, 2.48493388e-01f, 6.49748445e-02f, -1.67707741e-01f, -3.26176174e-02f, -4.40464988e-02f, -6.42118752e-02f,
  -5.97819760e-02f, -9.36594456e-02f, 2.21944854e-01f, -1.33952066e-01f, 1.28656626e-01f, -7.37903863e-02f, -7.18290731e-02f, 2.34602049e-01f, -3.92628973e-03f, 2.26757392e-01f,
  -6.39870465e-02f, -2.35901937e-01f, -5.55657111e-02f, 3.41355838e-02f, 3.88233061e-03f, -3.02286819e-02f, 1.45168854e-02f, 9.96953174e-02f, -2.02992350e-01f, -5.31003959e-02f,
  -2.93587893e-03f, 1.25571758e-01f, -7.68809393e-02f, -1.63567849e-02f, -1.11722313e-01f, -1.04292138e-02f, 1.50624722e-01f, 8.70508403e-02f, 8.23767781e-02f, 1.24197379e-01f,
  8.54795799e-02f, 5.86114712e-02f, 1.07294628e-02f, 1.54360672e-02f, 5.64947948e-02f, -6.20170543e-03f, -1.49625847e-02f, 1.02630511e-01f, -4.80403118e-02f, -1.13311797e-01f,
  -7.89978635e-03f, 9.29434225e-03f, -3.70450243e-02f, -2.69016735e-02f, 4.05911990e-02f, 5.05168959e-02f, -3.77186947e-03f, 3.15787569e-02f, -4.29900130e-03f, 3.10883229e-03f,
  -1.00379614e-02f, 3.45427580e-02f, -8.03251266e-02f, -1.17794037e-01f, -1.57130398e-02f, -4.41410989e-02f, 2.98730899e-02f, -2.12544184e-02f, 2.06492357e-02f, 5.70860952e-02f,
  -2.75591668e-02f, 2.88520940e-02f, 2.86491442e-04f, -1.21026009e-01f, 1.01072593e-02f, 3.05146128e-02f, -3.51168364e-02f, 1.01882756e-01f, -6.56423643e-02f, 4.66044918e-02f,
  -1.85671255e-01f, -2.73403913e-01f, -7.67584890e-02f, -9.83832404e-02f, 5.93833067e-03f, -2.78504156e-02f, -4.51423340e-02f, -7.86641762e-02f, -1.64222643e-01f, -3.11189368e-02f,
  1.97935682e-02f, -1.36406487e-02f, -1.02270655e-02f, 2.70373803e-02f, 1.39797509e-01f, -1.71253514e-02f, -3.19942050e-02f, -4.46514115e-02f, -6.13790341e-02f, -5.37350550e-02f,
  -3.91420126e-02f, -9.37134251e-02f, 1.59775585e-01f, -6.65039336e-03f, -9.94313955e-02f, 8.09469000e-02f, -6.24977201e-02f, 2.48720851e-02f, -8.58952180e-02f, 9.95505676e-02f,
  -4.27485168e-01f, 1.40862793e-01f, -3.57057899e-01f, -3.41250807e-01f, 1.57615587e-01f, -3.02299500e-01f, -1.99490622e-01f, 3.86739299e-02f, -1.22835860e-01f, 2.02021495e-01f,
  1.03737768e-02f, -1.34933084e-01f, 1.82548493e-01f, -4.54760611e-01f, -4.89146858e-01f, -3.22926939e-01f, -4.54578042e-01f, -3.06222916e-01f, 2.23744772e-02f, -1.84652284e-01f,
  -1.81370258e-01f, -6.42604828e-02f, -2.88454443e-01f, 2.70507127e-01f, -2.07748070e-01f, 1.30831003e-01f, 1.30311772e-01f, 1.39166877e-01f, -1.45710111e-01f, 1.24685206e-01f,
  -1.37150809e-02f, 9.15774703e-02f, -1.93893984e-02f, -3.06741875e-02f, -6.54811636e-02f, 1.78812034e-02f, -1.20319203e-01f, 2.74853408e-02f, -4.06010225e-02f, -5.97035000e-03f,
  -1.03327604e-02f, 3.00205555e-02f, -2.54652277e-02f, 1.11784913e-01f, 2.68549994e-02f, 1.83424670e-02f, -1.00108176e-01f, -2.76936740e-02f, -2.79781688e-03f, -1.60328493e-01f,
  -7.41522312e-02f, -1.26677483e-01f, -1.26722530e-02f, -3.49051207e-02f, -3.86466784e-03f, 4.10600603e-02f, -2.52214652e-02f, 1.24471962e-01f, -3.88904735e-02f, -2.62625422e-02f,
  1.04761057e-01f, -2.48396583e-02f, -1.28796652e-01f, -2.91894600e-02f, -8.99033062e-03f, -2.46515851e-02f, -3.85382399e-02f, -5.75231612e-02f, -4.41250429e-02f, 7.28845596e-02f,
  -1.85327996e-02f, -1.16263954e-02f, 2.95179542e-02f, -1.76480394e-02f, -7.69423842e-02f, -3.78369689e-02f, -1.25381783e-01f, 8.67645368e-02f, -4.88406047e-02f, -5.06963246e-02f,
  6.14838637e-02f, -3.95510681e-02f, -3.49181704e-02f, 5.09778373e-02f, -2.55052336e-02f, 2.68852394e-02f, 5.19008413e-02f, -1.38117567e-01f, -3.81829813e-02f, 5.68850301e-02f,
  2.19626985e-02f, 1.80014417e-01f, 2.27334946e-02f, 6.41916618e-02f, 2.87168324e-02f, -4.69742436e-03f, -6.79858699e-02f, -1.35993898e-01f, -9.04074637e-04f, 4.71552461e-02f,
  -9.67778638e-02f, -5.77335283e-02f, 5.30311950e-02f, 6.71265572e-02f, 9.91525222e-03f, -1.70862880e-02f, -4.76315239e-04f, 4.93495241e-02f, 3.89737412e-02f, -3.17276828e-02f,
  2.76915953e-02f, 3.54989767e-02f, -1.16933081e-02f, -8.83783698e-02f, 3.93917300e-02f, 4.24451716e-02f, 9.67394263e-02f, 1.17338495e-04f, 7.31607750e-02f, -2.87051592e-02f,
  -5.60784459e-01f, 1.71386495e-01f, 9.72846970e-02f, -4.79359567e-01f, 3.13455284e-01f, 2.78605849e-01f, -2.45075211e-01f, 1.86844781e-01f, -1.75986916e-01f, 6.85526878e-02f,
  4.19157259e-02f, -3.16269606e-01f, 1.44381791e-01f, -3.23629141e-01f, -1.46999121e-01f, -7.22575039e-02f, -3.34076315e-01f, -3.21854740e-01f, -7.13896453e-02f, -1.80214018e-01f,
  -1.57668158e-01f, -2.38146663e-01f, -1.50831804e-01f, 2.31053293e-01f, -2.19474286e-02f, 9.16030258e-02f, 2.28917338e-02f, 1.78284928e-01f, -5.37180481e-03f, -6.20680600e-02f,
  -7.46565238e-02f, -1.48483112e-01f, 7.69778043e-02f, 6.62699267e-02f, -6.76851161e-03f, 6.17601871e-02f, -9.25843865e-02f, -1.38844103e-02f, -5.75259700e-02f, 6.71931058e-02f,
  -6.29639477e-02f, 7.81478435e-02f, -7.08767623e-02f, 1.48682669e-03f, -3.57220061e-02f, 1.30533010e-01f, 1.26598656e-01f, 1.03459664e-01f, 8.84837434e-02f, -4.60670441e-02f,
  -5.92542998e-02f, 1.56827450e-01f, 7.19119981e-02f, 1.22158034e-02f, 3.32476534e-02f, 2.05177963e-01f, -2.63673235e-02f, -1.01279644e-02f, -1.80031583e-02f, -8.48046876e-03f,
  2.04839204e-02f, -2.59731486e-02f, 1.07036736e-02f, 7.90765956e-02f, -9.18575674e-02f, 4.63886000e-02f, -1.74162518e-02f, -3.09698880e-02f, -6.64090142e-02f, -1.03964135e-02f,
  5.97146899e-02f, -9.63371024e-02f, 4.93675247e-02f, 3.53998020e-02f, 4.13636006e-02f, -6.44953027e-02f, -9.42959730e-03f, -3.12008243e-02f, -9.78191420e-02f, -7.63813928e-02f,
  -1.53300283e-03f, -7.00213239e-02f, -9.31827053e-02f, 2.42392868e-02f, 5.03254160e-02f, -3.92511003e-02f, 1.02749832e-01f, -1.19270450e-02f, -2.28977557e-02f, -7.09615201e-02f,
  7.57241100e-02f, 1.49771599e-02f, 8.98461137e-03f, 2.56910920e-02f, 2.98912656e-02f, 1.94964418e-03f, -7.26688188e-03f, 1.97362117e-02f, 1.15522631e-02f, 2.70423442e-02f,
  -9.15292092e-03f, -2.02818699e-02f, 1.06237400e-02f, -3.31109134e-03f, 3.66626233e-02f, 9.49463248e-03f, -7.54407048e-02f, -2.24656891e-02f, 6.65984601e-02f, -6.56857807e-03f,
  -6.12716675e-02f, 1.04293652e-01f, -6.32590577e-02f, 4.70531955e-02f, -1.06564619e-01f, 7.85768107e-02f, -5.73564023e-02f, -2.06890218e-02f, -8.31470713e-02f, 2.72365585e-02f,
  7.25535229e-02f, -9.15364400e-02f, -6.58236519e-02f, -2.23513052e-01f, 5.38907573e-02f, -1.00165121e-01f, -2.41311714e-01f, -1.01343729e-01f, -1.84008613e-01f, -1.19905680e-01f,
  -1.82012379e-01f, -4.48387973e-02f, -3.52669135e-02f, -2.61524141e-01f, 1.15387551e-01f, 1.43668726e-01f, -1.93259090e-01f, -5.92304282e-02f, 4.26393189e-02f, -1.63511053e-01f,
  -1.05550945e-01f, -1.27971590e-01f, -1.18081523e-02f, -3.03037167e-02f, -1.83352143e-01f, -1.11509152e-01f, 1.81478739e-01f, -1.56136066e-01f, -1.77331015e-01f, -5.64035587e-02f,
  2.92766560e-02f, 3.61358412e-02f, 1.82120763e-02f, -1.47622200e-02f, -5.83822839e-02f, 1.65349245e-03f, -1.44248948e-01f, -6.49259537e-02f, -8.37435350e-02f, 1.28348395e-02f,
  -3.80801074e-02f, 6.51772097e-02f, -9.78359655e-02f, 6.89812824e-02f, -2.29797922e-02f, 6.52424991e-02f, 8.51865560e-02f, 8.65102783e-02f, -1.19674029e-02f, 5.93812466e-02f,
  -1.02859378e-01f, 9.23682600e-02f, 9.37386137e-03f, -9.33247209e-02f, -1.17046878e-01f, 6.08307943e-02f, 1.66723356e-01f, -7.81950727e-02f, 8.99613202e-02f, 5.11655919e-02f,
  1.08095715e-02f, 9.62628946e-02f, 9.31985974e-02f, 2.78025437e-02f, 6.05772212e-02f, 7.95155093e-02f, 1.76522471e-02f, 8.54415521e-02f, -1.81407798e-02f, 4.06509340e-02f,
  -8.08623508e-02f, -2.81406660e-02f, 7.00816810e-02f, 3.97298411e-02f, 5.60064465e-02f, 1.70443937e-01f, 2.25772876e-02f, -3.65748964e-02f, -8.65066648e-02f, 4.95355129e-02f,
  8.60979035e-02f, 2.58666109e-02f, 8.75383522e-03f, -4.13626898e-03f, 1.30256182e-02f, 4.25116159e-02f, -2.34727897e-02f, -4.50547487e-02f, 3.59600969e-02f, -7.74733424e-02f,
  -4.39774431e-02f, -2.30514184e-02f, -5.80282658e-02f, -5.20806015e-02f, 5.96634252e-03f, 1.45752221e-01f, -7.35502467e-02f, -8.94927084e-02f, -1.21838085e-01f, 3.83781195e-02f,
  -7.39935860e-02f, 4.96959835e-02f, 5.70424497e-02f, 8.79082456e-02f, 5.71023412e-02f, 1.42395776e-02f, -2.25415730e-04f, 2.91781817e-02f, -1.43579710e-02f, 1.02919579e-01f,
  -2.80807316e-02f, 1.26832291e-01f, -3.36559527e-02f, 3.62642556e-02f, -1.89429317e-02f, -6.33058250e-02f, 1.97289795e-01f, -1.38822436e-01f, 1.89575143e-02f, -3.66975851e-02f,
  -2.53643155e-01f, 1.23762757e-01f, -1.15142375e-01f, -2.76411891e-01f, -1.59940705e-01f, -1.15988903e-01f, -2.96477586e-01f, 1.78849939e-02f, 3.39385606e-02f, 2.09642183e-02f,
  -1.72902852e-01f, 1.55093282e-01f, 9.72674266e-02f, -2.66751409e-01f, 1.10105753e-01f, 3.43884826e-01f, -2.04229414e-01f, -9.24354419e-02f, 4.35857326e-02f, -1.77696794e-01f,
  4.56398427e-02f, -1.19040944e-01f, -6.53370544e-02f, 9.60090682e-02f, -2.09058508e-01f, -1.50268272e-01f, -9.56890956e-02f, -9.68061015e-02f, -2.31620893e-01f, -1.33529142e-01f,
  -2.28082478e-01f, -1.62501872e-01f, -1.97170436e-01f, -5.06799147e-02f, -2.57195197e-02f, 6.72455207e-02f, -4.63559479e-03f, 1.62867606e-02f, -3.45578231e-02f, 3.57971676e-02f,
  3.88930775e-02f, 1.72057316e-01f, 5.11311330e-02f, 1.56247303e-01f, -5.63767999e-02f, -6.79641590e-02f, -3.40157710e-02f, -9.98999998e-02f, -1.99164867e-01f, -1.13555253e-01f,
  1.21142408e-02f, 2.36476623e-02f, -1.42903164e-01f, -1.01729408e-01f, -1.99828401e-01f, -2.42312327e-01f, -6.32956252e-02f, -1.05167940e-01f, -7.97636658e-02f, -1.11889593e-01f,
  2.46541575e-02f, -3.00768986e-02f, -6.58626705e-02f, 1.04481885e-02f, 3.93518843e-02f, -4.21825871e-02f, -8.99921209e-02f, 5.10227680e-02f, 9.07750428e-02f, -3.84631916e-03f,
  -8.02446827e-02f, -1.28410935e-01f, -8.44166651e-02f, 1.98196322e-02f, -5.88835962e-03f, -4.07556444e-02f, -6.77239373e-02f, -8.51259008e-02f, 1.15804218e-01f, 1.17105164e-03f,
  9.38883796e-02f, 2.83109974e-02f, -6.60212804e-03f, -8.27322826e-02f, -2.44821305e-03f, -2.18491647e-02f, 2.16427743e-02f, -2.29404550e-02f, 4.36793007e-02f, -7.06114247e-03f,
  -1.73954874e-01f, -2.07075015e-01f, -5.34197874e-02f, -9.46080461e-02f, -4.19479720e-02f, 9.47564319e-02f, 9.33585986e-02f, 7.53957480e-02f, 4.69778590e-02f, 5.33318408e-02f,
  3.11550591e-02f, 3.75797115e-02f, -1.72573365e-02f, 3.06445919e-02f, 5.26911877e-02f, -4.02445868e-02f, -6.70789853e-02f, -1.64493285e-02f, -7.63758197e-02f, -1.49051934e-01f,
  -2.89297178e-02f, 5.49328364e-02f, -1.68715846e-02f, 4.25757514e-03f, 4.91082594e-02f, -1.75685763e-01f, 4.37964424e-02f, 4.65751551e-02f, -6.52765483e-02f, 4.24876204e-03f,
  -8.36972147e-02f, -1.58375222e-02f, 4.32886258e-02f, 2.56967098e-01f, -1.42935067e-02f, -2.22979173e-01f, -3.09623331e-01f, 1.66192934e-01f, -8.79657920e-03f, -1.40617445e-01f,
  1.84034798e-02f, 3.52814165e-03f, -4.90104891e-02f, 1.51566207e-01f, 2.41906062e-01f, 1.89329050e-02f, 2.04084530e-01f, 6.13695830e-02f, 7.87870958e-02f, 9.84421968e-02f,
  1.80900276e-01f, 2.02430800e-01f, 3.18774819e-01f, 3.48215640e-01f, 1.22045323e-01f, 2.19030112e-01f, 2.80997694e-01f, 1.43597618e-01f, 1.41018122e-01f, -7.76055381e-02f,
  -5.75580113e-02f, 4.97393403e-03f, -2.05002092e-02f, -6.57834560e-02f, -9.27314535e-02f, -1.64568901e-01f, -6.30450249e-02f, 1.77119635e-02f, -5.19533008e-02f, -1.45747513e-01f,
  -5.27026169e-02f, 8.86359438e-02f, 7.00415745e-02f, -2.30359659e-02f, -1.55281737e-01f, 5.34439050e-02f, 7.50225112e-02f, 4.05574553e-02f, -3.03417332e-02f, -4.48658690e-02f,
  1.03687309e-01f, 3.86123843e-02f, -8.80372971e-02f, -3.25399339e-02f, 8.44955221e-02f, 8.87754411e-02f, 3.56444046e-02f, -6.74578920e-03f, -1.70901455e-02f, -5.14300587e-03f,
  -1.15942895e-01f, -7.74287358e-02f, 7.87721723e-02f, 7.58270472e-02f, 1.22717097e-01f, -6.08944916e-04f, 6.18296936e-02f, 3.71936224e-02f, -7.01074451e-02f, 3.25390324e-02f,
  1.92225561e-01f, 6.94084615e-02f, -6.36777580e-02f, -8.01018775e-02f, -2.68565025e-02f, 2.08506975e-02f, -1.70950349e-02f, -7.60830268e-02f, -5.35704680e-02f, 6.77467734e-02f,
  -4.09348756e-02f, -5.45204654e-02f, 7.55789578e-02f, 2.46836781e-03f, 5.70710469e-03f, 2.05656271e-02f, -2.07745973e-02f, -1.26727685e-01f, 1.67336334e-02f, 6.32672682e-02f,
  4.15525921e-02f, 2.00078860e-01f, -3.51713262e-02f, 3.50970514e-02f, 1.88590027e-02f, 4.92350236e-02f, -7.51970336e-02f, 8.52436572e-02f, 5.87381562e-03f, -7.29381964e-02f,
  -1.84926689e-02f, 5.51505107e-03f, 7.55804703e-02f, 8.33771825e-02f, 1.08958511e-02f, 7.37167150e-03f, 4.33736481e-02f, 2.32465789e-02f, -3.55121046e-02f, 1.05090968e-01f,
  1.22200102e-01f, 2.76042838e-02f, 1.12112790e-01f, 1.29310146e-01f, 1.44838337e-02f, 5.42116165e-02f, -8.21764767e-02f, -7.49101415e-02f, 7.14878961e-02f, -1.02569975e-01f,
  8.05265680e-02f, 7.20025897e-02f, 1.66746229e-01f, 5.46542220e-02f, -1.41011074e-01f, -1.98803499e-01f, -9.11273509e-02f, -1.37574837e-01f, 9.51504055e-03f, -3.81791666e-02f,
  -7.71443546e-02f, 3.87054324e-01f, 6.58965576e-03f, -1.89070985e-01f, 5.92901222e-02f, -6.63670748e-02f, -3.15860838e-01f, 3.64493608e-04f, 1.19239362e-02f, -1.14127822e-01f,
  -1.63521469e-01f, -2.93191433e-01f, -2.62867976e-02f, -2.28249758e-01f, -1.23057254e-01f, 3.62491672e-04f, -8.98434818e-02f, -8.51545855e-02f, -1.34698838e-01f, 2.45592836e-02f,
  -4.51369062e-02f, -1.75207004e-01f, 9.90994275e-03f, -8.86137504e-03f, -8.63383934e-02f, 8.78775120e-03f, -9.47445165e-03f, -1.07016107e-02f, -3.28279771e-02f, 8.58015940e-02f,
  6.49688691e-02f, 1.30724683e-01f, -4.27437089e-02f, 4.37511951e-02f, -4.40036654e-02f, -1.07025988e-02f, 9.09413472e-02f, -1.05035212e-02f, 3.51551622e-02f, 5.83390258e-02f,
  8.53694528e-02f, 1.13051452e-01f, -4.24790047e-02f, -2.13857051e-02f, 4.44973856e-02f, -1.21962361e-01f, -1.40475412e-03f, 9.41465944e-02f, 3.76888597e-03f, 5.70279658e-02f,
  -7.44745880e-02f, 1.95660419e-03f, -3.07352506e-02f, -3.36410552e-02f, -5.98478839e-02f, -3.08582075e-02f, 5.90640865e-02f, 3.30042653e-02f, -1.05038665e-01f, 5.32228239e-02f,
  5.03270095e-03f, 9.13479328e-02f, -5.78446724e-02f, -5.95092997e-02f, 7.29972348e-02f, 3.31935175e-02f, 3.82266305e-02f, 4.36594710e-02f, 8.89792144e-02f, 7.46831074e-02f,
  -9.51748267e-02f, -7.88549557e-02f, 4.05127555e-02f, 6.73026070e-02f, -1.19815871e-01f, 1.03807114e-01f, 8.41327682e-02f, -3.54202953e-03f, -2.58703716e-02f, -2.25275531e-02f,
  -1.05986089e-01f, -1.25085697e-01f, -6.06241897e-02f, 2.66585127e-02f, 4.59473804e-02f, 9.06011462e-02f, 2.57917531e-02f, -6.28995663e-03f, -1.33279875e-01f, -9.75567698e-02f,
  -1.67846739e-01f, 1.21321268e-01f, 1.20849706e-01f, 1.08448155e-01f, 1.57160182e-02f, 2.33972259e-02f, 8.57101306e-02f, 2.47676205e-02f, 6.80062873e-03f, -4.52165417e-02f,
  -2.51010284e-02f, 9.65260901e-03f, 2.08963335e-01f, 1.41268261e-02f, 5.72147896e-04f, -2.93482952e-02f, 1.67470817e-02f, -4.23568580e-03f, -3.48733105e-02f, 1.33259716e-02f,
  2.73454487e-01f, 3.29027444e-01f, 2.09900290e-01f, 2.13032976e-01f, 1.84969194e-02f, -2.38334492e-01f, 7.43745938e-02f, -8.13026428e-02f, 1.73155442e-01f, -2.24427935e-02f,
  -2.85286397e-01f, 2.84733206e-01f, -1.87547997e-01f, 8.34938064e-02f, -3.34790587e-01f, -3.03005368e-01f, 8.06484967e-02f, 5.04147857e-02f, -6.07502423e-02f, 1.50273830e-01f,
  5.47274873e-02f, -2.73721516e-01f, 1.65405758e-02f, -2.32661828e-01f, 9.42649543e-02f, 1.49994478e-01f, -2.35901684e-01f, -6.02332950e-02f, 9.63875502e-02f, -7.74336755e-02f,
  -5.17183123e-03f, 4.63607386e-02f, 1.09434947e-01f, 3.60166468e-02f, 1.07995450e-01f, 1.09331291e-02f, -4.97762524e-02f, -3.49768884e-02f, -4.59437817e-02f, 7.89445341e-02f,
  1.49799496e-01f, -6.55995607e-02f, 7.91782141e-02f, -7.03859031e-02f, 2.38677442e-01f, 1.68661848e-01f, 1.39560714e-01f, 1.33629695e-01f, 7.54308179e-02f, 9.83024598e-04f,
  4.84315604e-02f, 1.32759839e-01f, 2.32412428e-01f, 4.83932011e-02f, 1.64387539e-01f, 1.27795041e-01f, 3.25705111e-02f, 1.69115663e-01f, 8.22871178e-02f, 8.89495462e-02f,
  -4.24364861e-03f, -3.41450460e-02f, -2.13116873e-02f, -1.50018096e-01f, -1.20981999e-01f, -3.24702486e-02f, 1.71915721e-02f, 5.12825185e-03f, -1.33313537e-02f, -2.66781375e-02f,
  3.71226817e-02f, 1.01671830e-01f, -1.76369771e-02f, 7.13923201e-03f, -4.18421589e-02f, 1.12126388e-01f, -5.75688621e-03f, -4.25503477e-02f, 1.00809045e-01f, -3.21126245e-02f,
  -1.66086763e-01f, -1.23051561e-01f, -5.32239117e-03f, 2.78369058e-02f, -1.88807130e-01f, 7.56369457e-02f, 8.36713985e-02f, -8.39123800e-02f, -1.51155010e-01f, 1.52866235e-02f,
  -1.02046775e-02f, 1.80042740e-02f, 9.85013023e-02f, 7.07170367e-02f, 7.59783480e-03f, -6.29751757e-02f, -1.11218877e-01f, 1.00512937e-01f, 2.87919305e-02f, -8.30008537e-02f,
  6.92784190e-02f, -2.03931555e-02f, 2.37813313e-02f, -7.03113293e-03f, -4.75209877e-02f, 3.39531824e-02f, -4.88145836e-03f, -1.10341990e-02f, 1.10608831e-01f, 4.15243953e-03f,
  -5.77073023e-02f, 2.44744559e-04f, 1.42302409e-01f, 7.71213174e-02f, 7.03322142e-02f, 1.10956207e-01f, -4.84321788e-02f, 8.11772123e-02f, -5.27739190e-02f, -4.99101763e-04f,
  -6.57829583e-01f, 2.41919309e-01f, 2.59894282e-01f, -2.88922012e-01f, 1.11454949e-01f, 2.49160230e-01f, 8.02231058e-02f, 1.54744256e-02f, -2.03241333e-01f, -1.84106305e-01f,
  -2.03533635e-01f, -1.16207421e-01f, 2.82725729e-02f, -1.13742175e-02f, 1.30709872e-01f, 1.49029821e-01f, 3.25454250e-02f, -2.32855797e-01f, 9.35659781e-02f, -1.18687123e-01f,
  -2.76764315e-02f, -1.33885697e-01f, 1.72183096e-01f, 2.25000173e-01f, 8.41407478e-02f, -6.62036538e-02f, -1.41082868e-01f, 1.36979938e-01f, 9.46810916e-02f, 1.39539525e-01f,
  -7.35770836e-02f, -2.76726902e-01f, -6.65482432e-02f, -3.41089852e-02f, -1.85836088e-02f, -1.33823520e-02f, 2.43253242e-02f, -9.07750204e-02f, -9.30787548e-02f, -6.25009164e-02f,
  -7.23986998e-02f, 4.52714078e-02f, -2.85875425e-02f, -1.22604057e-01f, -4.19244282e-02f, -4.95750345e-02f, 1.84532642e-01f, 1.11579210e-01f, 5.53834513e-02f, 3.45107391e-02f,
  1.21827297e-01f, 9.37065035e-02f, -9.59752314e-03f, -3.48952152e-02f, 2.57472880e-02f, -2.73215808e-02f, -1.84739586e-02f, -1.75011978e-02f, 1.49544301e-02f, -9.14848596e-02f,
  7.38283396e-02f, -8.36220458e-02f, 4.81679179e-02f, -6.77332580e-02f, -2.31369250e-02f, -8.22466463e-02f, -1.43963490e-02f, -2.16488261e-02f, 4.56140470e-03f, 5.59470579e-02f,
  3.41437967e-03f, -1.28828898e-01f, -1.17335677e-01f, 1.53857619e-02f, -3.40668298e-02f, -2.22239122e-02f, -1.56844091e-02f, -4.03654017e-02f, 5.40293343e-02f, 5.73472530e-02f,
  -9.88200679e-02f, 4.75217625e-02f, -2.47511044e-02f, -1.92353483e-02f, 5.31796599e-03f, -7.03450292e-02f, -7.68330023e-02f, 6.10623546e-02f, -1.47573312e-03f, -2.31188107e-02f,
  -3.02303135e-01f, -3.23764116e-01f, -5.12150489e-02f, -1.35974586e-01f, -1.47966027e-01f, -5.90127287e-03f, 2.19988544e-02f, -3.55311222e-02f, -1.31440967e-01f, -5.22279404e-02f,
  -2.92456988e-02f, -9.99794006e-02f, -3.09355538e-02f, -5.17952926e-02f, 9.34038535e-02f, 1.14362342e-02f, -2.50536017e-02f, -1.23891413e-01f, -1.28668487e-01f, 2.50284001e-02f,
  1.07280232e-01f, -1.13091268e-01f, -6.43985495e-02f, 4.26388606e-02f, 4.70027141e-03f, -9.04408991e-02f, -1.45850584e-01f, 9.07179490e-02f, 1.08202156e-02f, 2.95735560e-02f,
  -1.65403113e-01f, 1.40607536e-01f, -1.31216809e-01f, -2.34016012e-02f, -2.74252802e-01f, -1.24831408e-01f, -4.07628603e-02f, -1.22315340e-01f, 3.31754200e-02f, 6.65004030e-02f,
  -1.88174143e-01f, 1.04491517e-01f, 1.70241311e-01f, -6.91736639e-02f, -7.70055354e-02f, 2.07597435e-01f, 3.93609656e-03f, 8.60390142e-02f, 8.84360075e-02f, -7.25680664e-02f,
  5.68624213e-02f, -5.45136333e-02f, 1.37162179e-01f, -3.26822028e-02f, -1.83665887e-01f, -5.97807169e-02f, -1.74380481e-01f, -1.21206746e-01f, -1.76147446e-01f, -4.96744104e-02f,
  -3.23634915e-04f, 1.61016911e-01f, -1.04047395e-01f, 8.20166618e-02f, 4.41124029e-02f, -1.09836087e-01f, -8.79762173e-02f, -7.48815015e-02f, 1.69092063e-02f, 1.79761592e-02f,
  9.34659168e-02f, 4.79373671e-02f, 9.13630053e-02f, -8.38744193e-02f, 6.10554311e-03f, 5.52438796e-02f, 6.18715584e-03f, -8.64901114e-03f, -7.06268381e-03f, -1.62867624e-02f,
  -7.32840225e-02f, 3.35781984e-02f, 5.08378446e-02f, 2.28425592e-01f, 8.31455737e-02f, -3.20493579e-02f, 5.15059121e-02f, 9.09529477e-02f, 3.96970548e-02f, 1.10409325e-02f,
  -5.23716062e-02f, -1.40109770e-02f, -1.18469549e-02f, -1.22686312e-01f, 2.45308643e-03f, 5.11531048e-02f, -5.32765128e-02f, 1.11995032e-02f, 7.61844963e-02f, -4.84617864e-04f,
  6.27973229e-02f, 5.59152924e-02f, 1.07480155e-03f, -4.64117117e-02f, -9.23262909e-03f, -8.95028189e-03f, 2.14401241e-02f, -4.27776426e-02f, 1.55914854e-02f, -5.49935251e-02f,
  -1.75526403e-02f, -5.08446340e-03f, 3.39512639e-02f, 1.12086460e-01f, -1.12619594e-01f, 1.51753630e-02f, 5.10367155e-02f, -1.22203492e-02f, -8.35132673e-02f, 9.65037942e-02f,
  -1.40219340e-02f, 1.97627395e-01f, 1.12921529e-01f, 4.62745354e-02f, -2.09394749e-02f, -1.40583500e-01f, -4.07703146e-02f, -3.16004753e-02f, 5.22055887e-02f, 1.75729971e-02f,
  2.74754409e-02f, 3.04296091e-02f, -1.81648154e-02f, -1.27011329e-01f, -4.75338511e-02f, 4.52707708e-02f, 4.41654213e-02f, 1.18670978e-01f, 6.13448359e-02f, -1.19447887e-01f,
  -2.12537255e-02f, 1.02415025e-01f, 1.59279808e-01f, 3.66247706e-02f, 1.18470430e-01f, 1.15082294e-01f, -1.10897385e-01f, 3.29127498e-02f, 5.23099490e-02f, 1.34211242e-01f,
  3.89769465e-01f, -5.95635921e-02f, 2.25090757e-01f, 3.41692150e-01f, 9.38023254e-02f, 1.52476311e-01f, 1.79402187e-01f, 1.25589773e-01f, 4.90378618e-01f, -1.07350931e-01f,
  -1.87468991e-01f, 8.57273787e-02f, -1.36620924e-01f, 3.14702955e-03f, -1.71722949e-01f, -6.38575293e-04f, 1.38512209e-01f, -2.54215673e-02f, 1.90104142e-01f, 1.37019753e-01f,
  1.82108417e-01f, -2.18270004e-01f, -2.84649074e-01f, -2.18729675e-01f, 1.37861580e-01f, 3.75097431e-02f, -4.01537746e-01f, -1.03261657e-01f, -2.11864576e-01f, -1.24153353e-01f,
  6.76656589e-02f, 7.77717456e-02f, -1.48297668e-01f, -1.75664369e-02f, 9.65864807e-02f, -1.38292164e-01f, -1.34357035e-01f, -1.26481041e-01f, -3.47235091e-02f, -8.92314594e-03f,
  -2.77143791e-02f, -2.02760380e-02f, 3.18515934e-02f, -8.28172937e-02f, 1.12839222e-01f, -1.02330305e-01f, 6.56580552e-02f, 2.20979843e-02f, -3.57400216e-02f, -3.99132408e-02f,
  8.55320245e-02f, 1.35583192e-01f, 1.23009682e-01f, -7.00719655e-02f, 1.81360394e-02f, 7.50524849e-02f, 2.35763695e-02f, -6.20362498e-02f, 4.91602942e-02f, 7.62367472e-02f,
  -1.89378858e-02f, -4.07264009e-02f, 1.63252902e-04f, -3.03735174e-02f, 5.49762174e-02f, 6.93255067e-02f, 5.41854426e-02f, 4.86816578e-02f, 1.85914233e-01f, 3.18876579e-02f,
  3.40586714e-02f, 5.57498410e-02f, 1.38641179e-01f, -1.75803527e-02f, 2.00705126e-01f, 1.01793068e-03f, -8.12878646e-03f, 7.51557108e-03f, 5.73651791e-02f, 2.28850804e-02f,
  1.45676807e-02f, 2.93249660e-03f, -7.72622526e-02f, -6.43564295e-03f, 2.72065978e-02f, 9.20637697e-02f, 3.91893163e-02f, 5.87759539e-02f, -8.98156539e-02f, -7.08582848e-02f,
  -7.82763436e-02f, -4.12837192e-02f, 2.25266647e-02f, -6.24164799e-03f, 6.75309077e-02f, -2.89310440e-02f, 1.11531196e-02f, 6.65094778e-02f, -6.57486990e-02f, -5.75674996e-02f,
  -6.56198664e-03f, 9.79817286e-02f, -5.11055775e-02f, 1.31867565e-02f, -1.46330103e-01f, -3.74117568e-02f, -1.52616547e-02f, -4.47192229e-02f, -1.10896878e-01f, -1.17901117e-01f,
  -1.75705180e-02f, 9.18694437e-02f, 6.92595821e-03f, -1.90314986e-02f, -1.08887076e-01f, -1.29612207e-01f, -3.93889397e-02f, -7.15291649e-02f, -2.61902846e-02f, -2.18728930e-02f,
  2.54202634e-01f, -2.19494596e-01f, -2.04656333e-01f, -1.86373875e-01f, -9.96278152e-02f, -2.03942120e-01f, -7.58672729e-02f, -1.62381902e-01f, -1.22530796e-01f, 1.18120192e-02f,
  -1.51044279e-01f, 1.13857768e-01f, 1.91750467e-01f, -7.87784308e-02f, 1.74876392e-01f, 2.81638354e-01f, -2.24488571e-01f, -2.61917319e-02f, -6.44638762e-02f, -1.52940545e-02f,
  5.58615364e-02f, -4.74447832e-02f, -1.08262904e-01f, -4.55487967e-02f, -3.62598039e-02f, -4.10659462e-02f, 9.13475305e-02f, 1.48164317e-01f, -1.23237282e-01f, 5.43016680e-02f,
  -1.41092956e-01f, 8.54597762e-02f, -8.00150782e-02f, 4.97401226e-03f, 5.84906782e-04f, 3.31608276e-03f, -7.12428764e-02f, 1.16079278e-01f, 3.72022986e-02f, 5.31915352e-02f,
  1.14724278e-01f, 1.35484293e-01f, -7.60143697e-02f, 1.41270638e-01f, 8.28984194e-03f, 9.62359272e-03f, 3.22270356e-02f, -3.43836248e-02f, -2.06645764e-02f, 4.52759899e-02f,
  1.10917248e-01f, 3.34853530e-02f, -7.13247955e-02f, -4.43942212e-02f, -2.36934610e-02f, -4.78992350e-02f, 7.29352329e-03f, -7.79190511e-02f, 1.28491312e-01f, 4.96305004e-02f,
  8.08505621e-03f, 7.65623897e-02f, 6.59604790e-03f, -7.36932009e-02f, 5.36848269e-02f, -4.08653952e-02f, 5.65018281e-02f, 4.94599752e-02f, -4.85428981e-02f, 7.11346790e-02f,
  -3.27477306e-02f, -2.00203136e-02f, 1.86110362e-02f, 4.32486683e-02f, 4.39807810e-02f, 1.01419583e-01f, 1.10136241e-01f, -7.13343769e-02f, -1.49131134e-01f, -1.45861208e-01f,
  -1.73751302e-02f, -3.38333771e-02f, 4.05155681e-02f, -1.33646607e-01f, -6.80662170e-02f, 8.67621303e-02f, 3.19790021e-02f, 9.02451500e-02f, -5.29455580e-02f, 1.04935184e-01f,
  -4.01225276e-02f, -3.42653170e-02f, -3.18562314e-02f, -3.79953580e-03f, -2.92253271e-02f, 7.57228360e-02f, -2.07060222e-02f, -1.00295782e-01f, -4.02716622e-02f, -4.23357934e-02f,
  -3.42620537e-02f, 3.37457955e-02f, -1.47121111e-02f, -2.55503133e-02f, -2.07220181e-03f, -2.38838848e-02f, 1.06209375e-01f, 3.04056369e-02f, -1.18911721e-01f, -3.73039991e-02f,
  1.39045805e-01f, 1.22761033e-01f, 2.86972132e-02f, -4.08638008e-02f, -6.64649010e-02f, -9.43935215e-02f, -3.11406162e-02f, -9.89139080e-02f, 8.03121459e-03f, -6.01316243e-02f,
  1.42716020e-01f, -7.70935118e-02f, 4.03515063e-02f, 1.94430292e-01f, 2.89386272e-01f, 1.49287507e-02f, 2.20281035e-01f, 2.48685211e-01f, 3.57113123e-01f, -2.97293127e-01f,
  -8.80621932e-03f, -1.69925362e-01f, 1.25761312e-02f, -3.27719748e-01f, -9.55062807e-02f, -1.74578935e-01f, -2.29456365e-01f, -3.31618130e-01f, 1.20185256e-01f, -8.78724977e-02f,
  -4.28720042e-02f, -7.69792050e-02f, 3.47541794e-02f, -6.55586198e-02f, 1.74105540e-01f, 7.83785991e-03f, -1.19665325e-01f, 2.11963728e-02f, -3.51761788e-01f, 5.31259738e-03f,
  1.84829578e-01f, 1.53845862e-01f, 3.27844881e-02f, -5.63798957e-02f, 1.07296526e-01f, -1.32584795e-01f, -2.01682016e-01f, -8.80919471e-02f, 1.67244986e-01f, 1.60210207e-02f,
  -6.98704422e-02f, -9.72467214e-02f, -1.95168272e-01f, 5.22852764e-02f, 1.84370615e-02f, 8.26537162e-02f, 1.45888582e-01f, 9.77458581e-02f, 9.92833748e-02f, 5.32829389e-02f,
  8.27844366e-02f, -2.11125985e-02f, 3.09015810e-02f, -1.91980794e-01f, -7.88018256e-02f, 1.31348729e-01f, -9.97403041e-02f, -1.29151762e-01f, -5.64323179e-02f, -1.06284253e-01f,
  -1.58585519e-01f, 3.58849019e-02f, 8.11991990e-02f, 1.26702443e-01f, 1.61005091e-02f, 2.42021270e-02f, 1.71116479e-02f, -2.56712846e-02f, 4.45016660e-03f, -3.68606113e-03f,
  9.18787811e-03f, -3.02425027e-02f, 1.00564033e-01f, 1.39552262e-02f, -1.50706246e-01f, 1.22241355e-01f, -1.40778601e-01f, -5.32183796e-02f, -4.95898491e-03f, 7.84242153e-02f,
  -3.41455676e-02f, -1.31407171e-01f, -1.70017965e-02f, -1.61532569e-03f, 4.53912206e-02f, 1.02293469e-01f, -5.51745370e-02f, -1.49933264e-01f, 1.59412518e-01f, -8.42235014e-02f,
  -3.02800294e-02f, -3.16104025e-01f, 5.58074303e-02f, 1.96396355e-02f, -6.47332743e-02f, -6.97619617e-02f, -1.57423705e-01f, -7.32735619e-02f, -2.91244825e-04f, -1.56690199e-02f,
  -6.52644858e-02f, 2.73315026e-03f, -1.04233392e-01f, 6.19443394e-02f, -8.25869385e-03f, 8.77155550e-03f, -1.02852896e-01f, -6.63075298e-02f, 2.94061266e-02f, -4.81800660e-02f,
  -6.84055313e-02f, 6.89729527e-02f, 9.02545080e-03f, 4.52652611e-02f, -1.23483934e-01f, 7.66115040e-02f, -3.38379033e-02f, 1.02067657e-01f, -1.64359018e-01f, -1.19207747e-01f,
  1.03832603e-01f, -4.08505052e-02f, 2.48918578e-01f, 2.48990223e-01f, -6.12717755e-02f, -5.67534529e-02f, -5.45115136e-02f, 4.89870906e-02f, -1.53393060e-01f, -9.82018262e-02f,
  -6.62884638e-02f, 1.98629588e-01f, -1.50458857e-01f, 2.59396940e-01f, -7.90305510e-02f, -2.73793992e-02f, 3.37139256e-02f, 1.19907446e-01f, -7.75848404e-02f, -6.96745217e-02f,
  -9.38789696e-02f, -2.20937401e-01f, 1.76800966e-01f, 4.07970361e-02f, 2.55495936e-01f, 1.72620535e-01f, 3.03298142e-02f, 2.05441847e-01f, 2.44603708e-01f, 1.29712060e-01f,
  -7.84651339e-02f, -2.36948729e-02f, 3.85738797e-02f, 1.00396229e-02f, -7.57043585e-02f, 2.17378396e-03f, 1.03173703e-02f, 4.80884947e-02f, 7.59513453e-02f, -6.62844256e-03f,
  -4.81068343e-02f, -8.43040794e-02f, 1.03780426e-01f, -3.20285559e-02f, 7.66386315e-02f, 4.95451353e-02f, 4.07021195e-02f, 1.06764331e-01f, 6.06329069e-02f, 1.33744061e-01f,
  9.25728306e-02f, 2.81551573e-02f, 4.69277799e-02f, 6.90615550e-02f, 1.00452108e-02f, -2.96815652e-02f, 4.22229897e-03f, 1.47017464e-01f, 9.31078121e-02f, -3.12649794e-02f,
  -8.85598287e-02f, -7.79313073e-02f, 6.57807514e-02f, 1.75248832e-02f, -1.27778381e-01f, 3.79504636e-02f, -8.06132704e-03f, -4.57892194e-02f, 9.09746159e-03f, -9.14492086e-02f,
  7.19007254e-02f, -1.13567885e-03f, 1.88505137e-03f, -1.60853434e-02f, -9.67836678e-02f, 2.40580607e-02f, 2.83572432e-02f, 7.36961067e-02f, -6.48870990e-02f, 1.58585440e-02f,
  -1.27984375e-01f, 4.01460566e-02f, -3.13068144e-02f, 6.04399033e-02f, 1.51204253e-02f, -3.93491015e-02f, 3.27989049e-02f, 4.97777499e-02f, 1.16129443e-01f, 4.98386472e-02f,
  -1.07412860e-01f, -1.06312148e-01f, -1.84010174e-02f, 2.89001986e-02f, -9.35356990e-02f, -1.28067296e-03f, -1.46479048e-02f, -3.13648246e-02f, -6.05820306e-02f, -1.22942597e-01f,
  -6.29779324e-02f, 6.04666304e-03f, 2.64119599e-02f, 4.05222215e-02f, 2.83109564e-02f, -1.07720420e-01f, 5.54146338e-03f, -2.83124559e-02f, 3.92800570e-02f, 1.23373650e-01f,
  8.31615552e-02f, -3.69480290e-02f, 7.75959343e-02f, -5.61425909e-02f, -2.24026013e-02f, 4.38729813e-03f, 8.57486669e-03f, 8.50997772e-03f, 1.42980859e-01f, 5.64109208e-03f,
  3.41023624e-01f, -1.86248660e-01f, -1.98286802e-01f, 2.79283762e-01f, 2.87337929e-01f, 2.18010694e-01f, 1.27300099e-01f, 3.74110699e-01f, 2.69858390e-01f, -5.02747521e-02f,
  3.35987568e-01f, -2.25956813e-01f, -1.09576844e-01f, 2.72703052e-01f, 1.71522930e-01f, -8.23006965e-03f, 1.64793536e-01f, 3.59009802e-02f, 1.71602264e-01f, 1.49478257e-01f,
  2.40643814e-01f, 2.88325250e-01f, -8.03043600e-03f, 1.31020099e-01f, 1.33620888e-01f, 8.67838040e-02f, -4.70172390e-02f, -1.63661703e-01f, 4.28069308e-02f, -5.66595569e-02f,
  8.57371613e-02f, 8.48003253e-02f, 1.08073473e-01f, -1.45178139e-01f, 5.22364443e-03f, -5.68315424e-02f, -8.13356042e-02f, -1.78602234e-01f, 7.21935940e-04f, 3.44235934e-02f,
  -7.64296576e-02f, 5.85791133e-02f, 4.48350385e-02f, -2.88803857e-02f, -4.67258878e-03f, 1.24398600e-02f, 9.36992373e-03f, 8.37440267e-02f, 6.52645677e-02f, 1.61909405e-02f,
  9.49683562e-02f, 3.47803570e-02f, 1.14792824e-01f, -1.82426162e-02f, 6.37338534e-02f, 6.33216277e-02f, -8.54031125e-04f, -1.77981481e-01f, -1.11399172e-03f, 9.92365852e-02f,
  1.43119982e-02f, -2.60401517e-02f, -2.26019993e-02f, -6.02988414e-02f, 3.45759951e-02f, 4.55654822e-02f, -4.73115705e-02f, 1.86109040e-02f, -7.07173496e-02f, 5.71977794e-02f,
  1.34197786e-01f, 5.41636311e-02f, 7.98298120e-02f, -6.53348193e-02f, 1.15946725e-01f, 9.69966277e-02f, -8.01597312e-02f, -6.89059868e-02f, 4.39630598e-02f, 1.30393505e-01f,
  3.84835936e-02f, -6.21833839e-02f, 1.01022862e-01f, -8.65409449e-02f, -2.79666372e-02f, -2.50951182e-02f, -6.59292042e-02f, 8.69321376e-02f, -4.89145592e-02f, -1.37791529e-01f,
  -1.21534586e-01f, -2.45371252e-01f, 4.91169244e-02f, -3.23806591e-02f, -1.09912664e-01f, 7.08457977e-02f, -3.75871696e-02f, 2.92028375e-02f, -1.30558208e-01f, 3.98428738e-02f,
  1.30165862e-02f, 1.85845476e-02f, -1.00381831e-02f, -8.80605206e-02f, -1.69394702e-01f, 4.95968312e-02f, -1.25908330e-01f, -3.73599567e-02f, -3.46256420e-02f, 6.61420450e-02f,
  -3.71255390e-02f, 3.61245647e-02f, -7.16585740e-02f, 6.71579391e-02f, -1.83110218e-02f, -6.67968243e-02f, 1.01143077e-01f, -1.51712960e-02f, -1.04280144e-01f, -9.18589681e-02f,
  -2.27067664e-01f, -5.71360998e-02f, -2.73645878e-01f, -2.41162814e-03f, -2.36862674e-01f, 1.90374970e-01f, 3.56881678e-01f, -1.40483513e-01f, -1.82935864e-01f, 3.74223530e-01f,
  4.71504331e-01f, -1.47476032e-01f, 3.54510188e-01f, 3.63838106e-01f, -1.38498666e-02f, 2.70060539e-01f, 1.92257285e-01f, 1.88652560e-01f, -2.56913811e-01f, 3.27813551e-02f,
  -6.06958866e-02f, 1.52059570e-01f, 1.82626843e-01f, -2.19653726e-01f, 1.40715346e-01f, -1.11538813e-01f, 1.37800366e-01f, -6.09446988e-02f, 1.89897865e-01f, -4.21182662e-02f,
  1.57699034e-01f, 6.89180866e-02f, -3.58963646e-02f, -3.67708235e-05f, 2.70922258e-02f, 2.32722145e-02f, 3.83585393e-02f, -3.38000315e-03f, -3.93541306e-02f, -5.00086211e-02f,
  6.94769844e-02f, -8.25183615e-02f, 5.43392636e-02f, -1.95944443e-01f, -4.89505455e-02f, -1.00406244e-01f, -9.31501463e-02f, 6.24818821e-03f, -9.43852141e-02f, 1.11512102e-01f,
  1.97872450e-03f, 5.44646895e-03f, 3.79971378e-02f, 1.40696853e-01f, -3.81161869e-02f, -1.47981215e-02f, 3.09238606e-03f, -2.41209418e-02f, 1.97921973e-02f, -5.47019579e-02f,
  -6.83741793e-02f, 4.15993296e-02f, -1.06981266e-02f, 4.73548099e-02f, -5.01906499e-02f, 6.20526113e-02f, 4.25667986e-02f, 5.58750853e-02f, -5.81966452e-02f, 2.45340765e-02f,
  -1.30714513e-02f, -1.04577951e-01f, -3.50006782e-02f, 4.24225703e-02f, -2.06399825e-03f, -2.55814791e-02f, -3.87311690e-02f, 1.74728259e-02f, 4.66534160e-02f, 3.59272696e-02f,
  4.63567786e-02f, -2.21152306e-02f, 6.95063686e-03f, 9.69503298e-02f, 5.04326783e-02f, -1.82067081e-02f, -1.12813905e-01f, 1.11038633e-01f, 1.98515624e-01f, -1.80018097e-02f,
  9.35158879e-02f, -6.57856017e-02f, 2.74609365e-02f, 7.50118271e-02f, 1.38339745e-02f, -6.50116056e-02f, 2.54858453e-02f, -5.14013097e-02f, 5.64321466e-02f, 5.12227009e-04f,
  -4.00831811e-02f, -4.20214161e-02f, 8.88172984e-02f, 4.45709750e-03f, 2.91545969e-02f, -5.51124886e-02f, 1.32123008e-01f, -7.87207559e-02f, -4.66567166e-02f, -7.66856372e-02f,
  1.15511380e-01f, 2.97593083e-02f, -8.37090984e-02f, -2.43246909e-02f, -8.60287026e-02f, 1.33857250e-01f, -9.65829119e-02f, -6.85294643e-02f, -6.11102246e-02f, 9.47979465e-03f,
  3.02131832e-01f, -4.61181909e-01f, 1.29958272e-01f, 1.76053986e-01f, 1.94606245e-01f, -7.72164986e-02f, 2.43274704e-01f, -7.36156702e-02f, 1.45302519e-01f, -2.59690791e-01f,
  -1.16618715e-01f, 5.32155931e-02f, 5.82379140e-02f, -2.40593761e-01f, 4.12168890e-01f, 2.10367027e-03f, 3.32030491e-03f, -1.53968349e-01f, 5.33965118e-02f, 5.23448037e-03f,
  8.91885608e-02f, -8.59964564e-02f, 1.43145651e-01f, -3.13158900e-01f, -6.42978260e-03f, -1.16733633e-01f, -1.12820774e-01f, 8.39000568e-02f, -2.95243293e-01f, 1.32246852e-01f,
  -1.47032648e-01f, -9.92135331e-03f, 3.65525186e-02f, -3.07353977e-02f, -6.40710965e-02f, -7.16107041e-02f, 2.22103726e-02f, 1.42732337e-01f, 9.71131548e-02f, -5.10197617e-02f,
  8.68926104e-03f, -4.92808558e-02f, -5.65647781e-02f, 2.87386235e-02f, 2.50918884e-02f, -1.06583454e-01f, -1.93772260e-02f, -1.22327901e-01f, -4.26217802e-02f, 6.79489151e-02f,
  4.45089899e-02f, -9.25972536e-02f, 2.72901710e-02f, -1.76405326e-01f, 3.34751494e-02f, 1.53037941e-03f, 1.29874544e-02f, 8.97237211e-02f, 3.53800785e-03f, 9.11978781e-02f,
  2.72867754e-02f, 4.27645296e-02f, -2.30348278e-02f, -7.10024834e-02f, 2.69560199e-02f, -2.82879639e-03f, -3.27276029e-02f, -7.12058470e-02f, -6.63787797e-02f, -3.35145704e-02f,
  2.44871210e-02f, -4.64601852e-02f, 1.14480900e-02f, 2.81047914e-02f, 2.38232221e-02f, 3.89302708e-02f, -6.25130609e-02f, -4.28539813e-02f, -4.55136448e-02f, 4.64982651e-02f,
  -6.41003773e-02f, -1.91775281e-02f, 5.05151153e-02f, 3.33811417e-02f, 7.33020063e-03f, 2.60472484e-02f, -1.36989012e-01f, 1.50880953e-02f, 4.48744707e-02f, 1.23840697e-01f,
  -3.30010712e-01f, -3.30310136e-01f, -2.94147781e-03f, -1.00645564e-01f, -1.84756353e-01f, -1.59824163e-01f, -8.25354382e-02f, -6.06701039e-02f, -4.60775308e-02f, 4.17941745e-04f,
  -1.01306655e-01f, -1.17614036e-02f, -8.17271229e-03f, -6.24728622e-03f, 3.55045288e-03f, 3.94957960e-02f, -3.35811414e-02f, -1.80377841e-01f, -1.14460988e-02f, -4.50823493e-02f,
  -8.84753559e-03f, -1.16418891e-01f, -1.00760028e-01f, -5.63211441e-02f, -1.76265314e-01f, -8.37727562e-02f, 3.62819210e-02f, 8.61383155e-02f, -2.54102387e-02f, -2.28419248e-02f,
  -1.71732008e-01f, -2.67833710e-01f, -1.45201668e-01f, -7.19260871e-02f, 2.64135271e-01f, 9.29000154e-02f, 5.96132502e-02f, -8.19881260e-02f, -3.38390648e-01f, -2.20195949e-03f,
  7.66335651e-02f, -2.13227078e-01f, -1.87228054e-01f, -2.68191010e-01f, -9.31210369e-02f, -3.73353243e-01f, -8.80532041e-02f, -3.05727888e-02f, -1.97097510e-01f, 1.61953762e-01f,
  -5.24702258e-02f, -5.91864921e-02f, -1.56949803e-01f, 2.31884569e-01f, 6.75834566e-02f, 2.28188053e-01f, 3.48923951e-01f, 1.95748180e-01f, 2.52362996e-01f, -2.48598717e-02f,
  -7.31500611e-02f, -2.65812159e-01f, -2.81542558e-02f, -9.00778919e-02f, 8.86336118e-02f, 9.54397172e-02f, 1.38949901e-01f, -1.07643969e-01f, -4.46993075e-02f, -1.07644878e-01f,
  2.50146724e-02f, -2.92443037e-02f, -7.91986361e-02f, -5.16008995e-02f, -6.99304231e-03f, -2.47793961e-02f, 1.73738077e-02f, 7.63581544e-02f, -2.25139335e-02f, -1.53483868e-01f,
  -6.49411082e-02f, 6.22538403e-02f, -1.71478197e-03f, 2.66691968e-02f, 2.08284725e-02f, -7.93700013e-03f, 1.25896975e-01f, 1.68997347e-01f, -4.58540618e-02f, 7.88926408e-02f,
  6.33360399e-03f, 9.65672731e-02f, 1.01054408e-01f, -5.63904904e-02f, 2.88348868e-02f, 1.16945907e-01f, -9.94408056e-02f, -3.32106687e-02f, 2.85382140e-02f, 8.60980991e-03f,
  1.22508399e-01f, 1.54968267e-02f, -1.33997068e-01f, 7.01922774e-02f, 1.97453350e-01f, -3.85816917e-02f, -2.89364606e-02f, 1.18127823e-01f, 9.42259505e-02f, 9.30039138e-02f,
  -3.66376005e-02f, 4.24648002e-02f, 1.24353319e-01f, -4.45061643e-03f, -1.27743572e-01f, 8.01126212e-02f, 9.28001665e-03f, 9.06795338e-02f, 1.56665444e-02f, -8.52733478e-03f,
  1.01698197e-01f, 4.93870117e-02f, -9.98530630e-03f, -1.34844622e-02f, -4.95202094e-02f, 1.03890143e-01f, -9.90508124e-02f, -8.69467780e-02f, -2.56475136e-02f, -5.41645475e-02f,
  1.95082903e-01f, 1.13335326e-01f, 1.81397200e-01f, 1.30766816e-02f, -2.39537116e-02f, 1.03370003e-01f, 1.28539920e-01f, 1.15719453e-01f, -1.33423703e-02f, 1.41359437e-02f,
  1.76028132e-01f, 2.07170889e-01f, -3.22563797e-02f, 1.16077788e-01f, 3.94437723e-02f, -6.61031762e-03f, 1.08602479e-01f, -3.49376397e-03f, -9.43536311e-02f, 1.09145176e-02f,
  1.52482288e-02f, 3.47197592e-01f, -1.07617356e-01f, 5.81557117e-02f, 8.29796642e-02f, 1.60682678e-01f, -8.25884752e-03f, 1.03330769e-01f, 8.26363042e-02f, 2.53305376e-01f,
  1.82016000e-01f, 6.94666952e-02f, 4.59893681e-02f, 2.96927482e-01f, 2.47297376e-01f, 5.12777306e-02f, 2.79406428e-01f, 1.45561621e-01f, -9.14137065e-03f, 1.53265283e-01f,
  3.88438478e-02f, 2.58158743e-01f, 3.38788470e-03f, 4.27300371e-02f, 6.45542070e-02f, -8.52669850e-02f, 1.70493662e-01f, -1.23247966e-01f, 1.55372679e-01f, 6.41688854e-02f,
  -5.30941375e-02f, 4.43622023e-02f, -8.72763917e-02f, -1.21987738e-01f, -4.37458307e-02f, -4.96943370e-02f, -4.57101576e-02f, -6.85839728e-02f, -2.30903421e-02f, -3.08433594e-03f,
  1.14239939e-02f, 3.36788199e-03f, 3.99326049e-02f, 9.20652524e-02f, 4.18673679e-02f, -2.03617165e-05f, -1.26278335e-02f, -3.83142680e-02f, -1.49087152e-02f, -7.33864978e-02f,
  5.59019633e-02f, 1.75085161e-02f, 6.44893274e-02f, 9.58757475e-03f, 2.24393476e-02f, -3.37956697e-02f, -6.38333056e-03f, -5.52453548e-02f, 1.16333172e-01f, 2.58245394e-02f,
  4.71255668e-02f, -4.11476195e-02f, -4.62916642e-02f, -7.21218139e-02f, 6.96873069e-02f, -2.82868533e-03f, 1.00960657e-02f, 4.00874689e-02f, -1.03259511e-01f, 5.78526556e-02f,
  2.68881093e-03f, 9.20738094e-03f, -7.01964423e-02f, 2.02150121e-02f, 6.98037148e-02f, -7.74763227e-02f, -4.53795381e-02f, -4.06506807e-02f, -7.42012039e-02f, -6.80001900e-02f,
  -1.74077271e-04f, 6.85329810e-02f, -2.34441459e-02f, 1.87633242e-02f, 6.69676140e-02f, 2.89416760e-02f, 2.05908287e-02f, -2.25739907e-02f, 3.18169408e-02f, 1.01350352e-01f,
  1.35081574e-01f, 2.41486639e-01f, -9.36637912e-03f, -5.91773540e-02f, -4.52372693e-02f, -1.09406812e-02f, -4.32814332e-03f, -3.64454389e-02f, -7.96820130e-03f, -1.03549458e-01f,
  2.58864332e-02f, -6.54085772e-03f, 2.73640957e-02f, 1.46882627e-02f, 1.70917958e-01f, 1.12470925e-01f, 6.85554296e-02f, -1.76018812e-02f, 9.42605361e-02f, 2.69903932e-02f,
  7.46178702e-02f, 2.54885741e-02f, -6.37484118e-02f, -5.75950518e-02f, 3.69977951e-02f, -7.99224377e-02f, 1.41020687e-02f, -5.46736792e-02f, -3.75387780e-02f, -2.86136959e-02f,
  1.65163860e-01f, 1.40519097e-01f, 2.18575776e-01f, 7.14418814e-02f, 2.80027688e-01f, 2.64853567e-01f, 2.11195618e-01f, 1.14118956e-01f, 4.51449424e-01f, -2.18538672e-01f,
  -1.32083580e-01f, -5.52668311e-02f, -1.78117175e-02f, 3.42791080e-02f, 7.76226968e-02f, 1.50237232e-01f, 2.56822169e-01f, 1.22211315e-01f, 2.62851775e-01f, 3.78730595e-02f,
  6.75674677e-02f, -1.43624887e-01f, -2.69721389e-01f, -1.35129467e-01f, 2.06852630e-02f, 5.85230775e-02f, -3.12659293e-01f, 1.10443130e-01f, -2.52049744e-01f, 1.08892627e-01f,
  2.18682475e-02f, 5.86223900e-02f, 4.94565666e-02f, 1.17493302e-01f, -5.17484918e-02f, -6.50751814e-02f, -3.42043042e-02f, 1.43838897e-02f, 1.25378534e-01f, -3.72096524e-02f,
  -7.79281408e-02f, -9.19070169e-02f, 2.88349632e-02f, -5.37250936e-02f, 8.30386654e-02f, 3.22859250e-02f, 4.59215080e-04f, -1.43702538e-03f, -3.21423002e-02f, 3.60805281e-02f,
  1.95583589e-02f, 7.19684437e-02f, 1.06741339e-01f, 5.61038889e-02f, 4.18277010e-02f, 2.15113401e-01f, 6.32864758e-02f, 7.84444734e-02f, 2.11484022e-02f, -4.02500965e-02f,
  9.14148695e-04f, 1.10105410e-01f, -4.53107618e-02f, -9.84952748e-02f, -2.12845113e-02f, -5.44121899e-02f, -5.51925153e-02f, -1.37924448e-01f, 5.27172163e-02f, -2.40470991e-02f,
  9.46803689e-02f, 6.40196800e-02f, 4.32948992e-02f, 9.92169455e-02f, -1.15032062e-01f, 3.14146094e-02f, -4.08944041e-02f, -8.43290519e-03f, 1.68817826e-02f, -3.08657940e-02f,
  -5.22806793e-02f, 2.07748413e-02f, -4.37056599e-03f, -8.88877660e-02f, -1.79917533e-02f, 5.26400171e-02f, -1.03700936e-01f, -5.09236939e-02f, 1.94779446e-03f, -3.98843139e-02f,
  6.13240711e-03f, 7.57844970e-02f, -1.11630268e-03f, 2.05138847e-02f, 6.95284270e-03f, -1.03304423e-01f, 1.28747135e-01f, 5.99967018e-02f, 3.68827097e-02f, 3.82963344e-02f,
  -6.49013817e-02f, -3.20301019e-02f, 1.25610204e-02f, -2.02920828e-02f, -1.45793870e-01f, -8.76355320e-02f, -4.06790897e-02f, 1.05845295e-01f, -1.13744922e-02f, -2.61420030e-02f,
  1.52211050e-02f, -5.11167059e-03f, 5.73552772e-02f, 5.91793545e-02f, 2.49935128e-02f, 2.45820265e-02f, -1.37798591e-02f, 1.21609360e-01f, -3.95045877e-02f, -1.38507150e-02f,
  -3.12421247e-02f, -4.06476669e-02f, -1.29912188e-02f, 3.91198955e-02f, -5.34982905e-02f, -7.64473528e-02f, -1.77972808e-01f, 3.34665775e-02f, -1.40916899e-01f, -1.57699451e-01f,
  5.01946434e-02f, -1.21453404e-01f, -1.21378481e-01f, -9.61205885e-02f, 7.97716603e-02f, -1.27906770e-01f, 7.47678056e-02f, -1.32398522e-02f, 1.43409893e-02f, 1.17052875e-01f,
  8.65872428e-02f, 1.18698351e-01f, 1.92423284e-01f, 2.48646721e-01f, -4.62472811e-02f, 1.39867961e-01f, 3.21377397e-01f, 2.51032915e-02f, 1.31005362e-01f, 2.11584233e-02f,
  7.46811833e-03f, 7.45572662e-03f, 4.39523011e-02f, -9.85937007e-03f, 9.19001102e-02f, -4.52517793e-02f, 7.66666904e-02f, -3.76463383e-02f, -7.68126845e-02f, 1.18380282e-02f,
  4.33629528e-02f, -5.38522862e-02f, -5.05799800e-02f, 4.48139524e-03f, 2.12311167e-02f, -6.43625334e-02f, 2.20280210e-03f, -7.44207157e-03f, -2.23531500e-02f, -4.52899151e-02f,
  -2.44014747e-02f, -7.42980987e-02f, 1.58122927e-02f, -7.44399847e-03f, 4.68337312e-02f, 2.08290908e-02f, -6.81378469e-02f, 7.25122318e-02f, -1.00901015e-01f, -2.05940083e-02f,
  8.64103362e-02f, -6.11039922e-02f, -6.06839731e-02f, -4.35741246e-02f, -5.16906939e-02f, 6.59532696e-02f, 1.63751692e-02f, 1.08293723e-02f, -2.35746633e-02f, -3.09051797e-02f,
  -1.90322101e-02f, 6.18951721e-03f, 4.16288758e-03f, 5.29824710e-03f, 7.38765392e-03f, -3.49844880e-02f, 4.08149697e-02f, -4.39317934e-02f, 3.49661075e-02f, -5.29716210e-03f,
  -3.40606198e-02f, 5.44236340e-02f, -1.18889540e-01f, 5.61268181e-02f, -1.56901532e-03f, -4.78517637e-02f, 6.36573359e-02f, -1.06402084e-01f, 5.28296009e-02f, 3.62564623e-02f,
  3.93802039e-02f, 1.54032856e-01f, 6.01956509e-02f, 1.45327840e-02f, 3.88361253e-02f, -1.69987734e-02f, 2.01253314e-02f, -9.69692040e-03f, 3.65482233e-02f, -3.08122393e-02f,
  1.12868398e-01f, -4.00115252e-02f, 3.27638574e-02f, 8.00742581e-02f, 1.34279862e-01f, 7.83792436e-02f, -1.05394907e-02f, 1.94544904e-02f, 5.03612719e-02f, 1.15514927e-01f,
  -9.97443199e-02f, -7.92868584e-02f, 9.28886235e-03f, -5.45779876e-02f, -2.65368428e-02f, -1.65973383e-03f, 1.49169434e-02f, 7.31586292e-02f, -5.20352162e-02f, 3.54283638e-02f,
  -3.53265464e-01f, 3.82313341e-01f, -7.57434964e-02f, -8.12099576e-02f, -1.54265150e-01f, -3.87573272e-01f, -1.68139059e-02f, 6.90708756e-02f, 9.33807809e-03f, 6.68080077e-02f,
  1.45653421e-02f, 3.10829550e-01f, 2.08920076e-01f, 8.83282423e-02f, -4.21375185e-01f, 1.40112326e-01f, -1.71208352e-01f, 4.36953567e-02f, 4.37103510e-02f, -5.11360765e-02f,
  -1.61307994e-02f, -1.65781826e-02f, -1.18873917e-01f, 9.23629627e-02f, -5.20574264e-02f, 2.17126664e-02f, -6.02345057e-02f, 1.17622316e-01f, 2.70014331e-02f, 2.25070547e-02f,
  -2.81993121e-01f, -6.33129431e-03f, 9.09862295e-02f, -1.37375131e-01f, -2.77556568e-01f, -9.51865762e-02f, -5.47486693e-02f, 8.74335878e-03f, -6.25271648e-02f, -1.55746471e-02f,
  8.75547379e-02f, 4.52598743e-03f, -2.07559541e-02f, 4.74140197e-02f, -3.47690471e-02f, 4.75589791e-03f, -3.28273177e-02f, -3.62948701e-02f, 9.59443208e-03f, -6.92724884e-02f,
  3.20840217e-02f, -4.10263799e-02f, -2.35192776e-01f, 4.07973453e-02f, -1.16097629e-01f, -1.37110382e-01f, -9.62558575e-03f, -3.29465605e-03f, -2.73384992e-03f, -1.12644255e-01f,
  2.86363456e-02f, -4.39635217e-02f, 3.05629019e-02f, -7.73047656e-02f, 3.43295075e-02f, 1.32573798e-01f, 8.22918564e-02f, 4.72003110e-02f, 6.44073039e-02f, -2.35763546e-02f,
  -9.90291387e-02f, 5.02559617e-02f, -5.59958294e-02f, -3.60273942e-02f, 9.49607696e-03f, -6.51382562e-03f, -6.82256520e-02f, -2.02323515e-02f, -3.71829420e-03f, -5.02361394e-02f,
  -9.75435041e-03f, 4.41949628e-02f, -3.57934684e-02f, -3.42304492e-03f, 7.59094255e-03f, -5.92205897e-02f, 4.84132059e-02f, 1.59083791e-02f, 6.71949610e-03f, -1.22976750e-01f,
  -4.99880135e-01f, -3.15535367e-01f, 8.95767212e-02f, -7.08624572e-02f, -5.91858402e-02f, -1.14324376e-01f, -4.06139418e-02f, 2.48548761e-02f, -6.65929615e-02f, -7.01032728e-02f,
  -9.33615956e-03f, 1.23111852e-01f, -7.62493387e-02f, 1.22176223e-02f, -8.53282660e-02f, -1.03066742e-01f, -9.07938182e-02f, 8.38185623e-02f, -1.82637528e-01f, -3.79492603e-02f,
  -2.78140027e-02f, 1.18810736e-01f, -1.18952272e-02f, -2.37115994e-02f, -5.82198389e-02f, -8.01515654e-02f, -2.49542184e-02f, -5.22698388e-02f, -8.69351774e-02f, -3.22771817e-02f,
  1.28461123e-01f, -7.14554414e-02f, 1.79403022e-01f, 3.37435663e-01f, 1.22893162e-01f, -1.78620562e-01f, -2.92708278e-01f, 1.57138392e-01f, 3.49523164e-02f, -1.29501641e-01f,
  9.64749381e-02f, 1.32391050e-01f, -1.59269869e-01f, 2.06654266e-01f, 2.37026848e-02f, -1.69401273e-01f, 1.87498182e-01f, -8.55690613e-03f, 7.03939125e-02f, 1.28413856e-01f,
  1.93919852e-01f, 4.75609675e-02f, 8.70799795e-02f, 7.86363930e-02f, 1.24575704e-01f, 1.26681849e-01f, 3.17266807e-02f, -3.50749157e-02f, 1.97147563e-01f, -3.95080894e-02f,
  -1.30997360e-01f, -6.88343570e-02f, 4.66115400e-02f, -2.97528924e-03f, -8.51242896e-03f, 4.45142016e-02f, 2.90531665e-02f, -2.67267833e-03f, -6.14272878e-02f, -8.03195834e-02f,
  -7.47113600e-02f, 5.72888888e-02f, 5.10322787e-02f, -2.27494240e-02f, -1.27179906e-01f, 1.66364178e-01f, 9.37964022e-02f, 1.08516384e-02f, -6.82199327e-03f, 1.05622970e-01f,
  -6.65195705e-03f, -5.23692183e-03f, 1.75538525e-01f, 5.81680797e-02f, -3.47421765e-02f, 9.68079790e-02f, 1.91606134e-02f, 2.58255983e-03f, 4.40122597e-02f, 6.65016100e-02f,
  -8.86958167e-02f, -8.53731334e-02f, -3.29682082e-02f, 1.30518362e-01f, 6.72679744e-04f, 5.94805693e-03f, 9.50768366e-02f, -2.90339459e-02f, -3.46889496e-02f, -6.35066582e-03f,
  1.38815954e-01f, 1.17410406e-01f, 6.02881471e-03f, -1.44973435e-02f, 6.93229958e-02f, 6.97437674e-02f, 5.03803045e-02f, -4.90463786e-02f, 2.46982872e-02f, 8.69802386e-02f,
  2.34513748e-02f, 1.54336086e-02f, -1.75317582e-02f, -1.98480748e-02f, 1.10500745e-01f, -7.41371512e-02f, 6.49281740e-02f, -3.19690146e-02f, -7.63418227e-02f, 6.39726222e-02f,
  4.37557586e-02f, 5.30436598e-02f, -1.62588235e-03f, -1.22831821e-01f, -3.33505049e-02f, 1.70116618e-01f, 4.04103026e-02f, 4.71139215e-02f, -1.19673200e-01f, -9.06130299e-03f,
  -7.61745051e-02f, -4.04847115e-02f, 1.27913669e-01f, 4.99469340e-02f, 3.73591967e-02f, -7.64305145e-02f, 5.21105230e-02f, -3.76639031e-02f, 1.23027332e-01f, 5.16190864e-02f,
  4.92677502e-02f, -1.13007762e-01f, 1.92097962e-01f, 4.47377078e-02f, -1.49609027e-02f, -2.99175922e-02f, 2.99092289e-02f, 1.37808286e-02f, 1.26254529e-01f, -3.34981307e-02f,
  5.79012856e-02f, -3.44614118e-01f, -3.15010279e-01f, -2.02606052e-01f, 1.48400337e-01f, 1.09910183e-01f, -2.34512746e-01f, 5.07716499e-02f, -2.17408359e-01f, -3.63121107e-02f,
  2.23203953e-02f, -8.97674449e-03f, -2.33600229e-01f, 4.23711389e-02f, 1.59641281e-01f, -3.44804436e-01f, 1.61505416e-01f, 1.22029789e-01f, -2.55973071e-01f, 7.99964145e-02f,
  8.96366611e-02f, 3.17806751e-01f, -7.43628591e-02f, 1.28405645e-01f, 9.78751779e-02f, 1.17807742e-02f, 3.27924699e-01f, 2.25027818e-02f, 2.36496225e-01f, 2.06126139e-01f,
  -9.78170894e-03f, -6.72769248e-02f, -3.48345637e-02f, 1.44404955e-02f, -1.07984513e-01f, 5.00777289e-02f, 7.78760239e-02f, 1.23701477e-02f, -9.51256230e-03f, -4.81332317e-02f,
  -6.85789948e-03f, 7.50985593e-02f, -3.52835134e-02f, 1.02527127e-01f, 9.79690254e-03f, -5.70157217e-03f, -3.31332684e-02f, 1.18719377e-01f, 7.40599930e-02f, -1.41616896e-01f,
  -2.17062771e-01f, 7.38848150e-02f, -5.67071475e-02f, -8.68011080e-03f, -2.81054601e-02f, 3.12597714e-02f, 1.01450518e-01f, 2.73857340e-02f, -2.82507148e-02f, 6.19762242e-02f,
  -2.61836853e-02f, 1.65306404e-01f, 3.28563564e-02f, 2.22926550e-02f, -2.66416110e-02f, -8.52228701e-02f, 6.95245713e-03f, -2.26571281e-02f, 6.91362517e-03f, 1.92791279e-02f,
  -4.16863114e-02f, -7.27276653e-02f, 1.29684126e-02f, 9.71599743e-02f, 1.06759280e-01f, 2.37002950e-02f, -1.48610640e-02f, 4.20547947e-02f, 5.75414626e-03f, -9.78997946e-02f,
  1.13152654e-03f, 5.43630123e-02f, 3.34207267e-02f, 7.55131245e-02f, -9.47903842e-02f, 4.20696959e-02f, 8.25429708e-02f, 1.19948236e-03f, -6.38135448e-02f, -6.10025711e-02f,
  3.45652923e-02f, 7.07466081e-02f, -3.66697013e-02f, 4.46194075e-02f, -1.74962088e-01f, 7.61005804e-02f, 8.52645934e-02f, -4.36624959e-02f, -2.79859044e-02f, 2.43760664e-02f,
  5.55789471e-02f, 1.20998345e-01f, 2.92597432e-02f, 9.84489247e-02f, 8.54870901e-02f, -5.41538075e-02f, 5.89602217e-02f, 1.82012632e-01f, 3.81344871e-04f, -3.19321640e-02f,
  7.58530945e-02f, 3.21621820e-02f, 4.16281037e-02f, -6.89736679e-02f, -2.92380285e-02f, 1.67469941e-02f, 1.28841428e-02f, 3.75326611e-02f, 6.59541273e-03f, 1.93799529e-02f,
  -7.39021879e-03f, -2.88925141e-01f, -4.70640063e-02f, -7.58091956e-02f, 1.86764579e-02f, -3.29250358e-02f, 1.90427423e-01f, -1.68239295e-01f, -2.31816262e-01f, -1.05019964e-01f,
  1.30396649e-01f, 9.24389213e-02f, 1.58588991e-01f, -6.67204186e-02f, 3.12464982e-01f, 1.18558519e-01f, -3.93978097e-02f, 1.81999609e-01f, -6.03524363e-03f, 5.32246977e-02f,
  3.33519951e-02f, -3.86266410e-02f, 1.08476862e-01f, -1.52884007e-01f, 8.79158303e-02f, -2.23072320e-02f, 2.12318167e-01f, 1.31760567e-01f, -1.49557367e-02f, 7.72500709e-02f,
  -5.38110547e-02f, -1.69077963e-01f, -3.65334786e-02f, -7.50072449e-02f, -8.15671235e-02f, -1.18467525e-01f, 6.72341809e-02f, 1.26756907e-01f, 1.70695946e-01f, 1.43265827e-02f,
  4.62775081e-02f, 3.52178328e-02f, -1.78484052e-01f, 6.93721920e-02f, -1.38237417e-01f, -8.49945694e-02f, 9.48244613e-03f, 4.87355515e-02f, -4.73677367e-02f, 1.84511486e-02f,
  1.73540805e-02f, 6.46604374e-02f, -7.25002587e-02f, 4.96214330e-02f, -5.92904389e-02f, 4.15048972e-02f, -3.35107222e-02f, 7.76076764e-02f, 2.35942472e-02f, -2.24046819e-02f,
  -2.74732150e-02f, 6.23900220e-02f, 3.65987681e-02f, 4.56663929e-02f, -1.85718443e-02f, 3.47528458e-02f, 1.06653251e-01f, 8.33659545e-02f, 3.37458141e-02f, 4.04732525e-02f,
  -8.50885734e-02f, 2.83542499e-02f, -5.02582081e-02f, -1.05139175e-02f, -6.25832900e-02f, -4.82784212e-02f, 1.59908086e-02f, 9.61586926e-03f, -9.36261117e-02f, 6.87246174e-02f,
  8.82136300e-02f, -1.13331983e-02f, -6.87990412e-02f, 9.04180557e-02f, 5.36375493e-02f, -1.80195589e-02f, -2.63138469e-02f, -4.34175394e-02f, -2.53896024e-02f, 7.56098479e-02f,
  -4.44399752e-02f, -1.65127546e-01f, -9.85828880e-03f, -9.96447578e-02f, -4.56213579e-02f, -7.34957159e-02f, -5.65301031e-02f, -8.46255943e-02f, 3.87472324e-02f, -3.61923799e-02f,
  -3.55221564e-03f, 9.80982557e-02f, -6.83978423e-02f, -1.23573363e-01f, -5.30957133e-02f, -7.21725076e-02f, 1.51995391e-01f, 2.63037477e-02f, -4.66728918e-02f, -8.14349204e-02f,
  -3.19765322e-02f, 7.16405511e-02f, -6.13593534e-02f, -6.16316535e-02f, 2.86548510e-02f, -9.16220248e-03f, 1.27326802e-03f, -1.00562491e-01f, 4.69814725e-02f, -7.21684247e-02f,
  -1.17805945e-02f, 4.70716655e-02f, -6.78129354e-03f, 1.46931380e-01f, -1.53616488e-01f, -1.83066890e-01f, -1.24688447e-01f, -5.90141602e-02f, -5.60879298e-02f, 2.11725514e-02f,
  7.79933333e-02f, 7.24768415e-02f, 1.54109625e-02f, 1.12826392e-01f, 5.53198829e-02f, 1.03461310e-01f, 1.36459440e-01f, 3.07366420e-02f, 7.38640800e-02f, -5.56593295e-03f,
  8.64087716e-02f, 1.04288295e-01f, 2.11751714e-01f, 1.13924682e-01f, -6.71039149e-02f, 4.34057117e-02f, 1.96466669e-01f, -5.98232001e-02f, 7.65173957e-02f, -1.29952980e-02f,
  1.51595322e-03f, 6.33137748e-02f, -6.28986284e-02f, -1.60724223e-02f, 6.91685081e-02f, -7.71173313e-02f, -9.24430601e-03f, -5.84424473e-03f, -2.73363553e-02f, 4.85272706e-02f,
  4.78892558e-04f, -5.48310578e-02f, 8.15081671e-02f, -4.54658130e-03f, -5.55817187e-02f, 6.77132886e-03f, -3.05656740e-03f, -5.10858791e-03f, -1.66599185e-03f, 2.72874273e-02f,
  4.49074954e-02f, 6.68528378e-02f, 2.65823733e-02f, 1.21110983e-01f, 1.20160602e-01f, 3.75018269e-02f, 5.21476343e-02f, 5.31988256e-02f, 3.75148579e-02f, 7.06070848e-03f,
  7.47620761e-02f, -1.03388071e-01f, 4.80272844e-02f, -3.13121267e-02f, -6.40262738e-02f, 3.12908813e-02f, -2.44330913e-02f, -3.74525301e-02f, -6.47740215e-02f, 9.55780074e-02f,
  1.46059627e-02f, 2.53860988e-02f, 3.11517529e-02f, -4.89554033e-02f, 2.85838302e-02f, -1.68214291e-02f, -4.22722800e-03f, 2.90031284e-02f, 1.04582436e-01f, 3.18965502e-02f,
  -1.15369000e-01f, -1.78978574e-02f, -6.17955588e-02f, 3.96453813e-02f, -8.73659626e-02f, 5.42671233e-02f, 1.55128226e-01f, -7.18897879e-02f, -8.38282853e-02f, -5.44794388e-02f,
  6.59460872e-02f, 1.84603885e-01f, -1.23331854e-02f, 1.34987412e-02f, 6.27266765e-02f, -2.90281940e-02f, 9.07326955e-03f, 1.85193270e-02f, 9.37065855e-02f, -3.11522861e-03f,
  9.18034688e-02f, -1.50664061e-01f, 2.56042611e-02f, -1.73715991e-03f, 7.97495469e-02f, 4.68734279e-02f, -3.43857221e-02f, 7.67595395e-02f, 7.18921050e-02f, 5.84472902e-02f,
  2.10337881e-02f, -2.76362225e-02f, 1.06914103e-01f, -6.44164756e-02f, 1.12465493e-01f, 8.67492482e-02f, -7.19137788e-02f, 1.56943779e-02f, 1.26974642e-01f, 1.40018821e-01f,
  -2.69083097e-03f, -2.62931120e-02f, -1.68471992e-01f, -1.64707363e-01f, -2.40688458e-01f, 6.72762617e-02f, 1.27736703e-01f, 3.26954238e-02f, -1.47919565e-01f, 2.84794003e-01f,
  -1.26284868e-01f, 1.23048471e-02f, 1.48139730e-01f, -2.01452330e-01f, -1.77147582e-01f, 1.06037788e-01f, -5.65268956e-02f, 1.43705875e-01f, -1.14891388e-01f, 1.10737972e-01f,
  4.21910780e-03f, -9.86768678e-02f, -8.02077800e-02f, 3.20385359e-02f, -1.96535755e-02f, -3.18236612e-02f, -1.91153660e-02f, -1.01597905e-01f, -1.08946472e-01f, -2.24846423e-01f,
  3.99352377e-03f, -2.35955138e-03f, -1.11147419e-01f, 9.17651206e-02f, 8.53332803e-02f, 3.04588582e-02f, -3.63745391e-02f, 6.94475486e-04f, -6.12418428e-02f, 1.18887894e-01f,
  9.81763899e-02f, 9.01011899e-02f, -5.82004599e-02f, 4.23585735e-02f, -6.36713505e-02f, 5.53504704e-03f, -1.01529278e-01f, -2.32194718e-02f, 6.97112456e-02f, -4.58930731e-02f,
  8.32243413e-02f, 3.48643996e-02f, -1.61638074e-02f, -2.19155699e-02f, -8.80529583e-02f, 4.09185849e-02f, 1.43975005e-01f, 3.72102112e-02f, -1.93899050e-02f, -6.25922717e-03f,
  -3.04804221e-02f, 2.07928956e-01f, 5.83299957e-02f, 2.02541053e-02f, -2.81632412e-02f, -3.97453904e-02f, 3.19841094e-02f, 2.10003853e-02f, -1.79655291e-02f, 1.11301206e-01f,
  1.03275314e-01f, 3.94045860e-02f, 9.12495404e-02f, 8.85988101e-02f, -1.02334820e-01f, 1.11458972e-01f, 8.90665203e-02f, 5.71479648e-02f, -1.03084959e-01f, 8.08179379e-02f,
  1.41896242e-02f, -1.02942642e-02f, 4.24482338e-02f, -1.60825357e-01f, -1.02842916e-02f, 1.53530985e-01f, 9.31259245e-03f, -2.30709910e-02f, 9.69568193e-02f, 2.61836629e-02f,
  -6.95885643e-02f, 9.25762230e-04f, 7.65210912e-02f, 2.24588886e-02f, 8.94637033e-02f, 1.20913804e-01f, 4.94572297e-02f, 2.10058447e-02f, -4.93393838e-02f, 3.91816460e-02f,
  2.83146184e-03f, 7.81950653e-02f, 9.42044891e-03f, 4.33941558e-02f, -3.93502675e-02f, 7.07840025e-02f, 1.61604688e-01f, 2.25109141e-02f, -2.14765407e-02f, 1.78313255e-02f,
  1.04587777e-02f, 1.58905566e-01f, 1.90947264e-01f, 8.61424580e-02f, -2.34263279e-02f, 4.35181037e-02f, -2.47625578e-02f, 2.23030951e-02f, -1.92623153e-01f, -4.08450179e-02f,
  6.67218491e-02f, -1.43528178e-01f, 2.47086450e-01f, -7.35625029e-02f, 1.37694299e-01f, 1.41669229e-01f, 2.59116292e-01f, -5.85288256e-02f, -1.13579094e-01f, -2.03641057e-01f,
  -9.63446647e-02f, 1.87341198e-01f, 9.57370028e-02f, -1.97444618e-01f, 4.20280159e-01f, 1.20064661e-01f, -1.45037085e-01f, -1.18593693e-01f, 1.88020207e-02f, -4.10507470e-02f,
  -1.09841563e-01f, -2.70805925e-01f, 1.39754623e-01f, -3.07139248e-01f, -7.41749555e-02f, -2.07021162e-01f, -1.13177702e-01f, 1.07061230e-01f, -2.02886894e-01f, 6.70959055e-02f,
  -1.45605251e-01f, -1.35712236e-01f, -6.56849071e-02f, -1.19439512e-01f, -6.75818250e-02f, -1.86857525e-02f, 7.31365755e-02f, 1.33292183e-01f, 6.53692931e-02f, 2.30034674e-03f,
  -2.85525154e-02f, 3.31728579e-03f, -3.49872038e-02f, 7.59252086e-02f, 3.12071964e-02f, -6.80786222e-02f, 6.86200261e-02f, 3.24350707e-02f, -2.77860295e-02f, 1.27840728e-01f,
  1.81092784e-01f, 2.95950174e-02f, -5.77917583e-02f, -6.63088188e-02f, 7.54111633e-02f, -5.90082780e-02f, 4.89427783e-02f, 1.67536795e-01f, 8.35993737e-02f, -2.03758534e-02f,
  1.06015459e-01f, 3.32831815e-02f, 3.45405377e-02f, -1.48771301e-01f, -8.63015354e-02f, -1.66569069e-01f, -6.83458820e-02f, 6.31883293e-02f, -1.73194055e-02f, -3.40837128e-02f,
  -4.56214584e-02f, -4.56441613e-03f, 3.12875621e-02f, 2.77910661e-02f, -3.62735204e-02f, -3.82142961e-02f, 1.05454437e-01f, 1.28100272e-02f, 3.33225615e-02f, -5.65807186e-02f,
  -4.48468961e-02f, 6.25250041e-02f, -6.87920721e-03f, 2.03018468e-02f, -3.57707292e-02f, 1.33322433e-01f, -2.52428427e-02f, 4.57479134e-02f, -8.57957453e-02f, 1.20855272e-01f,
  -2.45134130e-01f, -1.97408229e-01f, -9.37972888e-02f, -9.90459546e-02f, -1.08456820e-01f, -5.49854003e-02f, 4.02130149e-02f, 5.15576191e-02f, 3.79929761e-03f, 5.18043973e-02f,
  -1.07967496e-01f, -1.25595862e-02f, -2.12651994e-02f, 4.34068628e-02f, 2.21407469e-02f, 9.87549722e-02f, 9.32632908e-02f, -6.12643659e-02f, 7.43009709e-03f, -5.50813563e-02f,
  -4.72269692e-02f, 3.71649023e-03f, 3.12379878e-02f, -5.27014323e-02f, -5.11079794e-03f, -1.13555692e-01f, 1.49972007e-01f, 1.07168881e-02f, -1.35100242e-02f, 6.68009557e-03f,
  2.94008017e-01f, 3.54270250e-01f, 3.64822119e-01f, 3.50308925e-01f, -3.38847756e-01f, -2.74701178e-01f, -1.27751425e-01f, 1.60094164e-02f, 8.23095664e-02f, 7.48683093e-03f,
  -8.26414078e-02f, 3.50461155e-01f, -3.25585753e-02f, 2.30292350e-01f, -1.14083186e-01f, -9.82814431e-02f, 1.37316048e-01f, 1.58436745e-02f, 6.40215212e-03f, 1.86048239e-01f,
  1.20642029e-01f, -3.21650878e-02f, 2.57262588e-01f, 7.04225451e-02f, 1.08940870e-01f, 2.72232801e-01f, 1.56232482e-02f, -4.72685546e-02f, 9.12613273e-02f, -2.55065054e-01f,
  -1.23753436e-01f, 4.55287658e-02f, 1.09480426e-03f, -3.92890461e-02f, -1.28946647e-01f, 5.46496585e-02f, -1.90298799e-02f, -7.74352252e-02f, -2.90881027e-03f, 1.64683163e-02f,
  1.26720771e-01f, -1.82031468e-02f, -7.68362656e-02f, -3.83438133e-02f, -1.16449252e-01f, 2.48159859e-02f, -2.28126571e-02f, 1.75915256e-01f, -8.67397524e-04f, 4.37080301e-02f,
  2.35318512e-01f, 4.41465490e-02f, -3.74485515e-02f, -7.53567070e-02f, 1.11626305e-01f, 1.39129236e-02f, -2.24602167e-02f, -1.25672063e-02f, 3.03413663e-02f, -9.50948149e-02f,
  5.75558515e-03f, -6.03134036e-02f, 8.07295963e-02f, 1.79479104e-02f, 5.00282273e-02f, 1.88167449e-02f, 3.47026344e-03f, -1.40427306e-01f, -1.43256709e-02f, 1.26101458e-02f,
  -1.70624349e-02f, 2.47168057e-02f, -7.51288459e-02f, -1.04644103e-02f, 7.75224566e-02f, -3.27943498e-03f, 2.46959347e-02f, -1.13069884e-01f, -3.87818366e-02f, -3.18480916e-02f,
  -6.34646565e-02f, 9.30179469e-03f, 1.30434722e-01f, -5.55606931e-02f, -1.60646923e-02f, 4.37193103e-02f, 6.46218508e-02f, 7.57495612e-02f, 5.76454885e-02f, 4.27742749e-02f,
  -5.16926162e-02f, 1.99127153e-01f, -1.17119551e-02f, -6.27031326e-02f, -3.63652557e-02f, 6.07048683e-02f, -3.83071741e-03f, -1.03336647e-01f, 5.76288253e-03f, -5.55685312e-02f,
  -3.22508886e-02f, -8.87082443e-02f, 4.83187549e-02f, -1.21830121e-01f, 8.97749513e-03f, -2.87229139e-02f, -7.08560366e-03f, 1.50106266e-01f, -9.80778784e-02f, 4.51510474e-02f,
  2.86197901e-01f, -9.05005410e-02f, 6.40934007e-03f, -1.29576430e-01f, -5.86510040e-02f, -9.26456824e-02f, 3.17918435e-02f, -7.34101282e-03f, -7.10056648e-02f, -7.51242787e-02f,
  1.87039226e-02f, 1.97031721e-01f, 1.75097406e-01f, 7.20032230e-02f, -9.81577262e-02f, -1.55239150e-01f, -3.36570263e-01f, 1.03633255e-01f, -2.04215154e-01f, -1.41899884e-01f,
  -1.05250077e-02f, -1.89030036e-01f, 6.96040988e-02f, 5.96972145e-02f, 4.23656404e-02f, 7.35235289e-02f, 1.15142830e-01f, -2.90754531e-02f, 1.33550182e-01f, 2.22228944e-01f,
  5.58268987e-02f, 1.92838404e-02f, 3.48910213e-01f, 2.21733063e-01f, 1.02450483e-01f, 6.99718222e-02f, 1.26225263e-01f, 3.21716554e-02f, -6.56287670e-02f, -5.50359301e-02f,
  -1.51003096e-02f, 9.60371792e-02f, 8.14509541e-02f, 3.56031246e-02f, 1.59265220e-01f, -6.63739815e-02f, 1.17820008e-02f, -6.39227703e-02f, -1.47893250e-01f, -2.29927320e-02f,
  -9.40084830e-03f, -9.98888388e-02f, -1.03962999e-02f, -7.52921263e-03f, -8.82296637e-02f, -1.26729295e-01f, 2.50746068e-02f, -2.78603714e-02f, -3.07634156e-02f, 1.41876161e-01f,
  2.50097923e-02f, -7.60948062e-02f, -9.98568162e-02f, 7.73318985e-04f, 1.89763773e-02f, -1.04920000e-01f, -8.68529826e-02f, 3.44767496e-02f, -1.32420897e-01f, -1.40353262e-01f,
  1.05839893e-01f, -8.97021368e-02f, -1.68361682e-02f, 5.84677085e-02f, -4.66010720e-02f, 3.80427155e-05f, -1.42377257e-01f, -7.32207373e-02f, -1.84312779e-02f, 5.53519912e-02f,
  -1.86869651e-02f, -5.06155491e-02f, -3.70883830e-02f, -3.44318487e-02f, -8.98368061e-02f, -9.53801069e-03f, 1.01351747e-02f, 4.02012654e-02f, 1.16607836e-02f, 2.32356228e-02f,
  -1.00745715e-01f, -5.09626046e-02f, -7.58443773e-02f, 7.84360468e-02f, -1.37228340e-01f, -9.61413085e-02f, 1.61019623e-01f, 4.37454022e-02f, 5.62113523e-02f, 4.04329821e-02f,
  -6.63809199e-03f, 2.46099085e-01f, -1.25487344e-02f, -9.26563144e-02f, 1.21446095e-01f, 5.31485938e-02f, 6.68947846e-02f, 9.23487693e-02f, 2.87711825e-02f, 1.50675010e-02f,
  -3.29271592e-02f, -1.54206336e-01f, -2.27562357e-02f, 5.37129641e-02f, 4.25475240e-02f, -4.53766697e-04f, -5.18524908e-02f, -1.44940183e-01f, 1.15850233e-02f, 1.47899151e-01f,
  -5.83687285e-03f, -7.21449405e-02f, -1.17128193e-01f, 4.12220089e-03f, 3.79000651e-03f, -1.17808945e-01f, 3.92672559e-03f, 9.55368218e-04f, 6.93682507e-02f, 1.36972070e-02f,
  6.76849345e-03f, 3.06130230e-01f, -9.25317034e-02f, 1.08660169e-01f, 2.00844064e-01f, 3.75288874e-01f, 1.95631027e-01f, 2.73291707e-01f, 3.32275599e-01f, 1.64384484e-01f,
  1.08692013e-01f, -9.54441503e-02f, 1.31415427e-02f, 1.33029446e-01f, 6.30782964e-03f, 1.08939156e-01f, 1.75027400e-01f, 1.00538820e-01f, 6.05951250e-02f, 1.81161426e-02f,
  -5.95849827e-02f, 1.27197415e-01f, -2.26587355e-01f, -9.90301371e-02f, 3.19848545e-02f, -1.89383090e-01f, -2.26109132e-01f, -1.29885703e-01f, -2.11833060e-01f, 7.64244944e-02f,
  -2.44830474e-02f, -3.47317383e-02f, -2.36038283e-01f, -3.17872018e-02f, -5.99654838e-02f, -3.70852761e-02f, -6.71029612e-02f, -9.77998693e-03f, -1.35009229e-01f, 1.13209561e-01f,
  -4.60835658e-02f, -1.05847642e-01f, -2.16253232e-02f, 1.04405582e-01f, -1.53188221e-02f, -6.33198395e-02f, 8.27138033e-03f, 5.87262437e-02f, -7.55483576e-04f, -6.27194345e-02f,
  -4.23786193e-02f, 9.85479578e-02f, 4.43747677e-02f, -1.20804822e-02f, -3.28466445e-02f, 2.65076151e-03f, -3.35369222e-02f, 2.42793448e-02f, 5.69849387e-02f, 7.87548199e-02f,
  3.78086157e-02f, -4.53349799e-02f, -2.91614309e-02f, -1.36591382e-02f, 8.04994628e-02f, -5.86354062e-02f, -8.34226701e-03f, 1.46170091e-02f, -2.50271931e-02f, 4.56615277e-02f,
  1.44961402e-01f, 5.28069399e-03f, 7.97784179e-02f, 3.28498669e-02f, -4.20214832e-02f, 8.81746318e-03f, -5.98122552e-02f, 1.78159345e-02f, 3.04446798e-02f, -1.92527287e-02f,
  5.76161407e-03f, 2.47681625e-02f, -1.08699091e-02f, -7.52685219e-02f, -8.68838932e-03f, -7.95229990e-03f, 6.81624785e-02f, -7.39077013e-03f, -5.25317416e-02f, 6.45239502e-02f,
  1.19904324e-01f, 2.33425453e-01f, -4.07936610e-02f, -4.52512577e-02f, -6.81051463e-02f, -3.84717025e-02f, -1.61649510e-02f, -8.49759430e-02f, -3.59141007e-02f, 5.85599300e-05f,
  -1.45099284e-02f, -4.88295332e-02f, 1.00265983e-02f, 9.88650247e-02f, -2.96683554e-02f, 1.75432824e-02f, 1.66993272e-02f, 6.02723733e-02f, -3.88283134e-02f, 1.00244492e-01f,
  -8.96031633e-02f, 4.43806238e-02f, -1.22025862e-01f, -7.23109469e-02f, -2.68779397e-02f, -5.07084839e-02f, 1.84463799e-01f, -6.14946075e-02f, 4.33660820e-02f, 4.32134122e-02f,
  -5.06511688e-01f, 2.14207619e-01f, 1.98146135e-01f, 7.03778341e-02f, -1.68696016e-01f, -1.92564219e-01f, 1.39979899e-01f, -6.92051351e-02f, -7.28178397e-02f, 2.48249695e-01f,
  2.51825333e-01f, 1.67057645e-02f, 1.72208652e-01f, 2.20901102e-01f, -3.18285137e-01f, 7.12759644e-02f, 3.59570049e-02f, 5.13438694e-02f, 2.13486869e-02f, -1.55024901e-01f,
  -1.40638992e-01f, 1.84011925e-02f, 1.13088809e-01f, -7.93363377e-02f, 8.81677195e-02f, -8.39732401e-03f, 1.59251932e-02f, -3.90241034e-02f, 8.26925561e-02f, -5.67465164e-02f,
  -1.75933808e-01f, -2.37984732e-02f, 2.81469002e-02f, -1.09333023e-01f, 2.20486578e-02f, 8.12319890e-02f, -2.22743116e-03f, 5.19000590e-02f, -3.02818045e-02f, -6.91371337e-02f,
  -6.76694065e-02f, -5.45024462e-02f, -3.16696912e-02f, -5.57646379e-02f, -8.08822736e-02f, -1.81753635e-02f, -2.19908524e-02f, -1.13010274e-05f, -4.39042365e-03f, 1.03454262e-01f,
  1.14082992e-01f, -4.51927073e-02f, 7.97024071e-02f, 1.34699598e-01f, 1.31912157e-02f, 9.77644771e-02f, 8.88222009e-02f, 3.04483827e-02f, -8.27849358e-02f, -1.46241160e-02f,
  1.73473991e-02f, 1.81016952e-01f, 4.40882146e-02f, 4.07540239e-02f, -4.96829599e-02f, -3.67637724e-02f, 2.64559947e-02f, 5.68935066e-04f, 1.57502636e-01f, -6.81144372e-02f,
  -4.09788899e-02f, -3.76712009e-02f, 8.13945755e-03f, 1.52793499e-02f, -5.14735281e-02f, 2.11971775e-02f, 2.59854030e-02f, 7.37342760e-02f, 6.42100498e-02f, 1.93603919e-03f,
  6.70828298e-02f, 1.06928023e-02f, 2.37284452e-02f, 2.09673686e-04f, -3.16361599e-02f, 7.53133511e-03f, -1.16941798e-02f, -1.11888675e-02f, 8.48581195e-02f, -1.08283952e-01f,
  -4.80879754e-01f, -3.08208287e-01f, 5.99116534e-02f, -1.25388488e-01f, 2.00233292e-02f, -7.10366070e-02f, 3.05421697e-03f, -2.99333017e-02f, -6.81161806e-02f, -8.67747962e-02f,
  -6.03204407e-02f, -4.07675542e-02f, -8.19184259e-02f, 4.95218299e-02f, 9.94307082e-03f, 8.49771500e-02f, -1.01560749e-01f, 3.70897874e-02f, 2.49565635e-02f, -6.73425943e-02f,
  2.52741040e-03f, -5.70680127e-02f, 3.82294618e-02f, 5.06001115e-02f, -8.12532101e-03f, 8.79872441e-02f, -1.02575973e-01f, -1.07592586e-02f, -4.71384786e-02f, -4.54152515e-03f,
  2.26039693e-01f, -2.94453204e-02f, -1.28290102e-01f, 9.34765581e-03f, 6.76949099e-02f, -8.49604458e-02f, -1.32409304e-01f, 1.48132578e-01f, 4.43714783e-02f, -2.87497230e-02f,
  1.24943167e-01f, 1.11228980e-01f, -4.79301289e-02f, 1.62996590e-01f, 2.65501797e-01f, -8.29077885e-02f, 1.50001377e-01f, 1.80206336e-02f, 8.76007080e-02f, 1.43286660e-01f,
  1.50696054e-01f, 1.73626766e-01f, 1.11419156e-01f, 1.72273546e-01f, 1.56623095e-01f, -2.20017368e-03f, 2.83154011e-01f, -9.05217305e-02f, 6.14953823e-02f, 1.07333034e-01f,
  -5.88095970e-02f, 5.56072704e-02f, -1.98081043e-02f, -9.31849554e-02f, -8.91395733e-02f, -7.19154924e-02f, -2.03596707e-02f, -9.28857699e-02f, -4.00638804e-02f, -3.72924493e-03f,
  -3.74269076e-02f, 6.76947227e-03f, 5.73148392e-02f, -4.21652058e-03f, -7.18111405e-03f, 1.56930145e-02f, 5.98889887e-02f, -3.06331720e-02f, 2.01127101e-02f, 7.14707598e-02f,
  1.67130698e-02f, -9.55571048e-03f, 2.55931132e-02f, -5.55393808e-02f, 1.28820445e-02f, 5.85416332e-02f, -1.67079624e-02f, 7.78722577e-03f, 6.16885088e-02f, 1.89536661e-02f,
  1.00683972e-01f, -4.16421443e-02f, -3.18751559e-02f, -1.73431300e-02f, -9.66938660e-02f, -8.31778795e-02f, 3.88557985e-02f, -5.33158667e-02f, -3.82002518e-02f, -1.20987678e-02f,
  -9.37249362e-02f, -3.47811319e-02f, 4.47750874e-02f, 3.25123146e-02f, 4.14246619e-02f, -8.98463055e-02f, 1.63136632e-03f, 5.02434112e-02f, 3.30049694e-02f, -5.42416498e-02f,
  -1.80103090e-02f, 5.51365055e-02f, -1.10446908e-01f, -5.20631447e-02f, 2.03889515e-02f, -1.65058393e-02f, 9.15862918e-02f, 1.33989146e-02f, -6.96480125e-02f, -2.62351334e-02f,
  -8.78004804e-02f, 1.07987814e-01f, -2.22693221e-03f, -1.48291394e-01f, -4.50030752e-02f, 2.92845834e-02f, 2.38951594e-02f, -7.42897093e-02f, 4.33251373e-02f, -1.35282241e-02f,
  -6.78419194e-04f, -8.50706175e-03f, 3.60517837e-02f, 1.59546919e-02f, 2.17262693e-02f, 9.62205678e-02f, 1.06445946e-01f, -6.84596375e-02f, 7.43383318e-02f, 1.14334814e-01f,
  2.59357560e-02f, 2.54000314e-02f, 5.39824031e-02f, -9.77785885e-02f, -2.80353278e-02f, 3.29011469e-04f, 9.21326950e-02f, -2.84283143e-02f, 9.08680111e-02f, 4.62142192e-02f,
  -4.25376650e-03f, 5.65670989e-02f, -6.25167415e-02f, -1.13570973e-01f, -9.71143320e-02f, -4.64134961e-02f, -2.21955135e-01f, 2.43393648e-02f, 1.67658597e-01f, -6.41733482e-02f,
  -1.44701183e-01f, 1.22654080e-01f, 2.13652909e-01f, -2.21547499e-01f, 1.02415480e-01f, 5.80528900e-02f, -1.20355271e-01f, -1.46135867e-01f, -3.30909342e-02f, -5.74461594e-02f,
  -4.47382219e-02f, -1.53464764e-01f, -1.73928306e-01f, -1.71440318e-02f, -1.55228809e-01f, -6.77780658e-02f, -2.14996636e-01f, -1.17377173e-02f, -2.57396936e-01f, -5.85174710e-02f,
  -1.30757466e-01f, -1.10545829e-01f, -3.27472668e-03f, 7.78703019e-02f, 1.61898285e-02f, 3.75023647e-03f, -9.92310420e-02f, -9.06197168e-03f, -1.26849553e-02f, -3.79139185e-02f,
  1.65378854e-01f, -7.69792125e-02f, -7.76879024e-03f, 3.58808041e-02f, 2.12211102e-01f, 3.70692872e-02f, 3.11658308e-02f, 6.09902330e-02f, 1.62535217e-02f, 2.93345917e-02f,
  5.43004535e-02f, 9.06554386e-02f, 5.72391972e-02f, 7.57262260e-02f, 4.09583710e-02f, -4.94584925e-02f, 1.24430144e-02f, 9.60214436e-03f, -3.31919715e-02f, 3.08071617e-02f,
  1.07382499e-01f, -1.00608364e-01f, -3.13408449e-02f, -1.41718209e-01f, -4.30862745e-03f, 1.90442447e-02f, 4.72711697e-02f, 1.90938881e-03f, -5.03048748e-02f, -3.31858657e-02f,
  -3.36727723e-02f, -8.00329223e-02f, 3.97765636e-02f, 8.34305808e-02f, 4.44638766e-02f, 4.56064157e-02f, 4.68647713e-03f, 4.42611240e-03f, 4.39010039e-02f, 3.74306105e-02f,
  3.19683515e-02f, -7.81936720e-02f, -8.70567262e-02f, -1.55516434e-02f, -6.03651851e-02f, 4.13521752e-02f, 7.07208291e-02f, 5.50555950e-03f, -5.45619465e-02f, 8.87901559e-02f,
  -7.48707056e-02f, -3.27360667e-02f, 4.49404381e-02f, 9.36723948e-02f, 7.02949092e-02f, -6.50361972e-03f, -1.39338588e-02f, 8.12139809e-02f, 2.93905120e-02f, 3.56062292e-03f,
  8.60623717e-02f, -6.41063899e-02f, 5.99075072e-02f, 1.88599974e-02f, 1.79136634e-01f, -2.39215251e-02f, 4.49565686e-02f, 2.07590088e-01f, 9.56759676e-02f, 1.18479691e-01f,
  3.94627452e-02f, -5.57597801e-02f, 1.11494400e-01f, -1.19589325e-02f, 8.85946900e-02f, -1.47658400e-03f, 2.07746644e-02f, 3.07060741e-02f, -3.71216163e-02f, -5.96388876e-02f,
  3.49481314e-01f, -4.71793711e-01f, -2.70159304e-01f, 2.04231828e-01f, 3.58376533e-01f, 1.85817823e-01f, 6.56769518e-03f, 1.56313181e-01f, 2.05299910e-02f, -1.53188020e-01f,
  2.29681581e-01f, -2.37581417e-01f, -3.26535404e-01f, 3.10866147e-01f, 2.92689383e-01f, -1.68931484e-01f, 2.63476431e-01f, 1.80618539e-01f, -5.20039424e-02f, -4.80339350e-03f,
  1.64719373e-01f, 3.66745263e-01f, -5.38392365e-02f, 2.08656415e-02f, 1.21042304e-01f, -6.01209737e-02f, 1.04563474e-03f, -2.47116268e-01f, 2.07690865e-01f, 3.61170843e-02f,
  1.46321118e-01f, 7.66435824e-03f, -7.38747790e-02f, 2.25998368e-02f, 1.97855867e-02f, -2.05339122e-04f, -8.42096955e-02f, 8.85334909e-02f, 1.50260240e-01f, 4.69288640e-02f,
  -6.61877021e-02f, 1.04692057e-01f, 6.26579225e-02f, -3.22137624e-02f, 1.69063248e-02f, 6.92399815e-02f, 3.49960178e-02f, -2.93884184e-02f, -2.15730239e-02f, -8.19755420e-02f,
  -7.67771006e-02f, 2.50170603e-02f, -2.95077031e-03f, -7.76788127e-03f, -3.01406384e-02f, 5.25479615e-02f, -6.04843907e-02f, -2.23538890e-01f, 4.34403634e-03f, -3.04426011e-02f,
  -1.97963305e-02f, -8.71523395e-02f, 1.26971770e-02f, 4.03187647e-02f, 8.14472362e-02f, 7.61104971e-02f, 5.61762974e-02f, -1.73949841e-02f, -1.18372798e-01f, -6.66513816e-02f,
  5.99886850e-02f, 4.95845219e-03f, 2.36786772e-02f, 1.03955105e-01f, 5.54890409e-02f, -1.70821119e-02f, 6.71167001e-02f, -2.56872345e-02f, -1.67408437e-02f, 3.76959629e-02f,
  5.15396707e-02f, 5.15228733e-02f, 6.73270673e-02f, 3.74388061e-02f, 6.83581531e-02f, 1.54619450e-02f, -9.16101635e-02f, 9.70562026e-02f, 3.75585491e-03f, -7.39979073e-02f,
  -1.92481115e-01f, -3.91709954e-01f, -1.44446149e-01f, 8.14742818e-02f, -4.42953221e-02f, 6.16146587e-02f, 1.19718798e-02f, 1.25252113e-01f, -8.43022019e-02f, 9.09152105e-02f,
  6.45812973e-02f, 9.73406527e-03f, -5.54343511e-04f, 7.38964081e-02f, -2.96588782e-02f, 6.41665161e-02f, -7.22826496e-02f, -3.49445529e-02f, -1.27816647e-01f, -2.79427860e-02f,
  5.26093468e-02f, 8.52331147e-02f, -3.15009989e-02f, 1.26882240e-01f, 5.95122613e-02f, -1.02826364e-01f, 2.46052397e-04f, -1.34142086e-01f, -6.20022640e-02f, -6.30162582e-02f,
  -6.21398807e-01f, 2.91998148e-01f, -9.07789767e-02f, -8.66287109e-03f, -1.80007070e-01f, -2.51021266e-01f, 7.96902925e-02f, 3.33511196e-02f, -9.39685702e-02f, 1.77111477e-01f,
  1.05154619e-01f, -5.81818223e-02f, 2.71551847e-01f, 2.35217080e-01f, -3.59631568e-01f, 2.15292722e-01f, -1.32458284e-02f, 5.02097383e-02f, 6.84842318e-02f, 2.07099458e-03f,
  7.94310961e-03f, 2.48676538e-01f, 1.13316283e-01f, 1.64454758e-01f, -6.80881366e-02f, -7.90150985e-02f, 4.74484600e-02f, 6.07579537e-02f, 9.87700224e-02f, -1.27388835e-01f,
  -1.82674885e-01f, -2.35707443e-02f, -1.38869826e-02f, -2.07740530e-01f, -2.00082034e-01f, -9.00899321e-02f, -8.59974474e-02f, 3.86646092e-02f, -3.82771604e-02f, -8.11310709e-02f,
  2.04030387e-02f, -5.86446142e-03f, 3.04778828e-03f, 5.86515889e-02f, -1.03311680e-01f, 2.52348296e-02f, 3.69425416e-02f, -3.76698351e-03f, 6.11353405e-02f, 1.55023811e-02f,
  1.14415549e-01f, -1.84225140e-03f, -2.06751041e-02f, 1.12046720e-02f, -4.38219272e-02f, -1.27753464e-03f, 5.48633523e-02f, -1.81759614e-02f, -1.18752800e-01f, -1.25865817e-01f,
  8.74330848e-03f, 1.38910934e-02f, -2.70008272e-03f, -7.76079893e-02f, 7.28329048e-02f, 1.22560812e-02f, 6.14182130e-02f, -1.18189611e-01f, 7.53172785e-02f, 2.25861445e-02f,
  -5.56336232e-02f, -7.09028468e-02f, -8.02723542e-02f, 2.17319443e-03f, 6.18856549e-02f, -3.45566832e-02f, 3.08336392e-02f, -3.75872036e-03f, 3.44795883e-02f, -1.36131067e-02f,
  5.76665327e-02f, 4.87706363e-02f, -2.16706679e-03f, -1.04481652e-01f, -5.23901954e-02f, 1.95839349e-03f, -3.16483453e-02f, -5.44141904e-02f, 1.81120168e-02f, -3.27389315e-02f,
  -3.60347033e-01f, -1.94569558e-01f, 3.52233686e-02f, -1.98928237e-01f, -1.76812261e-02f, -6.00548163e-02f, 9.28504318e-02f, -3.59526314e-02f, -2.82073971e-02f, -1.42100081e-01f,
  -2.06142385e-02f, -2.78942976e-02f, -3.72586735e-02f, 3.57191041e-02f, 5.76892234e-02f, 3.48731577e-02f, -8.27343687e-02f, -2.29893886e-02f, -3.90325151e-02f, -1.32471368e-01f,
  2.35976856e-02f, 2.61432063e-02f, 3.15188803e-02f, 3.17388475e-02f, 2.30564736e-02f, 1.07473216e-03f, 8.21953654e-05f, 1.33279921e-03f, -6.53343275e-02f, 2.12508086e-02f,
  2.13329285e-01f, 1.12454504e-01f, -2.31320426e-01f, -1.42570883e-01f, -8.14962909e-02f, 3.92977387e-01f, 2.14729488e-01f, -6.81302398e-02f, -2.78071284e-01f, 1.78653076e-01f,
  1.28646776e-01f, -9.04425085e-02f, 1.18646547e-01f, 2.69594997e-01f, 1.17430016e-01f, 1.33550942e-01f, 1.97874606e-01f, 2.09079489e-01f, -9.12427157e-02f, 9.38649997e-02f,
  4.58000191e-02f, 3.81101459e-01f, -9.28803012e-02f, 1.62298784e-01f, 2.37361684e-01f, -1.76821068e-01f, 6.25782758e-02f, -1.61862135e-01f, -1.55631807e-02f, -1.98392235e-02f,
  7.33074024e-02f, -1.18183857e-02f, -2.69362722e-02f, -5.49933314e-02f, 6.20253347e-02f, 9.76098329e-02f, 1.55884102e-02f, 6.81950757e-03f, -1.09015569e-01f, -8.04786310e-02f,
  7.05474466e-02f, -1.39808049e-02f, 3.85794565e-02f, -2.39832941e-02f, -3.72081026e-02f, -8.24891850e-02f, -9.22252424e-03f, -5.87108061e-02f, -1.39907494e-01f, -7.05084472e-04f,
  -9.50312614e-02f, 2.04563886e-02f, 1.04732914e-02f, -7.65480474e-02f, -1.70337424e-01f, -1.31828869e-02f, 5.32726049e-02f, -8.16517696e-02f, 4.93574608e-03f, 4.19398211e-02f,
  2.51205284e-02f, 9.97527763e-02f, 1.18454807e-01f, 5.38091883e-02f, 3.42839658e-02f, 5.99061549e-02f, 7.35196099e-02f, 4.02827002e-02f, -8.96750540e-02f, 9.50369090e-02f,
  -7.54704326e-02f, -1.23096816e-01f, 1.82129741e-02f, 1.33722976e-01f, 8.50750282e-02f, 2.13526748e-02f, 1.81320813e-02f, -3.30177583e-02f, -5.90505600e-02f, -2.71117408e-02f,
  -4.55617532e-03f, 8.85596350e-02f, -1.15358853e-03f, -9.70034972e-02f, 1.10808343e-01f, -5.44121824e-02f, 4.79530729e-03f, 1.28430128e-01f, -3.16936448e-02f, -4.46668826e-02f,
  3.36840935e-02f, -1.10393688e-01f, -4.90952283e-02f, -2.13770419e-02f, -3.72278430e-02f, 1.27590612e-01f, 7.70188794e-02f, -5.99805042e-02f, -1.22454114e-01f, 9.43879187e-02f,
  6.71471953e-02f, -3.67175154e-02f, 2.72624753e-02f, -8.04411843e-02f, -1.28117770e-01f, 3.14716296e-03f, 2.28177849e-02f, -6.87353984e-02f, -1.24505609e-01f, -8.37989077e-02f,
  3.76662947e-02f, 4.02574465e-02f, -8.30369294e-02f, 2.02607885e-02f, -9.08010826e-03f, -4.91110012e-02f, -1.96710825e-02f, -1.11016735e-01f, -6.09141700e-02f, -5.96930757e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  2.24006742e-01f, 5.01056239e-02f, 6.59418330e-02f, 1.75579652e-01f, 1.72101408e-01f, 1.77267104e-01f, 9.62923467e-02f, 1.55869976e-01f, 1.28152966e-01f, -2.66111232e-02f,
  2.33192682e-01f, 1.94298863e-01f, 1.46355927e-01f, 1.09098621e-01f, 1.81289926e-01f, 1.07085645e-01f, 1.95047945e-01f, 2.54725218e-01f, 2.16869637e-03f, 1.75305068e-01f,
  1.01990432e-01f, 1.60783976e-01f, 2.39077836e-01f, 1.04594126e-01f, 1.00003399e-01f, 2.30727836e-01f, 1.16418846e-01f, 2.27675438e-01f, 1.59198523e-01f, 2.00497478e-01f,
  1.20269760e-01f, 3.40718031e-01f, 5.00149876e-02f, 1.47898063e-01f, 2.56244838e-01f, 1.58052400e-01f, 2.78748572e-01f, 2.03101277e-01f, 1.65465847e-01f, 1.35341465e-01f,
  1.14771836e-01f, 1.87710568e-01f, 2.97420919e-01f, 1.60083562e-01f, 8.23778808e-02f, 1.42991439e-01f, 1.25508651e-01f, 1.12221599e-01f, 8.63629580e-02f, 1.78601965e-01f,
  8.87577236e-02f, 1.63437977e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.33968681e-01f, -9.79025289e-02f, -1.11204565e-01f, -9.17452425e-02f, -2.42777988e-01f, -1.70220509e-01f, 1.06146820e-01f, 6.34616092e-02f, 1.91402346e-01f, -1.75845444e-01f,
  -6.56022578e-02f, -5.37988655e-02f, -1.62809581e-01f, 4.40189801e-02f, 1.57393366e-01f, 2.19779235e-04f, 7.57863224e-02f, 9.17191152e-03f, -1.59887463e-01f, 9.67448950e-02f,
  6.57602027e-02f, 2.53316104e-01f, -1.30897969e-01f, -5.16500473e-02f, 1.20943356e-02f, 3.67362611e-02f, -1.92640666e-02f, 1.11653015e-01f, -1.98468417e-01f, -1.47996962e-01f,
  8.67882371e-02f, -1.52128801e-01f, -1.38711512e-01f, -3.75826284e-02f, -1.02132306e-01f, 7.46526271e-02f, -4.13524657e-02f, -1.97386131e-01f, -4.13197950e-02f, -4.76544127e-02f,
  -4.17757779e-02f, -5.08059561e-03f, 2.47989342e-01f, -1.15364529e-01f, -1.14155702e-01f, 9.22763795e-02f, -1.75251737e-01f, -7.42952749e-02f, -5.78718856e-02f, -1.27603084e-01f,
  1.91794839e-02f, 7.73747414e-02f, -1.01900566e-02f, 1.13970265e-02f, -6.03696927e-02f, -1.40932605e-01f, 5.88089265e-02f, 9.11132712e-03f, 1.38812080e-01f, -5.94047643e-02f,
  -1.65030658e-01f, 1.94780268e-02f, 4.20146435e-02f, 1.20576613e-01f, -3.01721990e-02f, -9.71858669e-03f, -1.89613596e-01f, -3.38952728e-02f, -1.64389744e-01f, 6.87668622e-02f,
  -5.76271042e-02f, 9.02512446e-02f, 1.22118257e-01f, -5.06203659e-02f, 2.82750893e-02f, -1.87687382e-01f, 1.12081371e-01f, 1.08735390e-01f, 9.18061957e-02f, -7.30063170e-02f,
  6.62667081e-02f, 9.34878713e-04f, -7.32209757e-02f, -4.89077996e-03f, 7.26474226e-02f, 1.61429107e-01f, 6.11961959e-03f, 1.27199516e-01f, -5.07989042e-02f, -1.08127616e-01f,
  -6.71177078e-03f, 8.11662227e-02f, 2.23983988e-01f, 3.24040167e-02f, 5.10638691e-02f, 5.81282713e-02f, -1.94141090e-01f, -4.07435838e-03f, -1.28217608e-01f, -3.10483705e-02f,
  1.47905611e-02f, -1.19291134e-01f, 7.54421949e-02f, 2.07257733e-01f, -1.98982105e-01f, -1.47738606e-02f, 2.90602148e-01f, 2.22913548e-01f, 4.81844470e-02f, -3.45029160e-02f,
  -9.72840115e-02f, -2.12550238e-02f, 5.52643929e-03f, -1.98804617e-01f, -1.53786048e-01f, 3.13897356e-02f, -6.03985675e-02f, -8.17759149e-03f, 1.07893579e-01f, -2.62814403e-01f,
  -1.12420253e-01f, 6.79394826e-02f, 1.30802587e-01f, -5.02119623e-02f, -2.45556030e-02f, 3.27384309e-03f, 9.86115560e-02f, 1.15035594e-01f, 6.25567138e-03f, 2.62319464e-02f,
  -6.38804212e-02f, 2.69308761e-02f, 1.39734978e-02f, 5.24565205e-02f, -5.01272380e-02f, -8.50334093e-02f, 4.21634987e-02f, -1.66749090e-01f, 2.74806342e-04f, -1.69097781e-01f,
  2.26101786e-01f, -6.51670946e-03f, -7.32919425e-02f, 1.99508861e-01f, -1.29125103e-01f, 1.49181788e-03f, 8.67070481e-02f, -5.64774051e-02f, -4.07285392e-02f, 1.54774249e-01f,
  -7.27241933e-02f, -2.00249925e-01f, 1.77896135e-02f, -1.25209272e-01f, 5.26746996e-02f, -3.09669435e-01f, 6.03262633e-02f, -7.92190880e-02f, -4.67687994e-02f, 6.02473915e-02f,
  -4.64802496e-02f, -5.59961237e-02f, 7.03945011e-02f, -1.15607046e-01f, 7.96363652e-02f, 2.51949161e-01f, -3.27992737e-02f, 1.18365139e-01f, -1.22757658e-01f, 1.74706727e-01f,
  1.19168594e-01f, -5.82265481e-02f, 9.39685944e-03f, 6.65430352e-02f, 1.20781615e-01f, -9.18681398e-02f, -5.59771992e-02f, 3.07391072e-03f, -1.34880915e-01f, -1.62368163e-01f,
  3.68934660e-03f, -4.91184704e-02f, -2.09650621e-01f, -9.58356336e-02f, -1.68027416e-01f, 2.29903907e-01f, -6.36329036e-03f, -6.80472329e-02f, -1.05676338e-01f, 1.09078310e-01f,
  -2.14215666e-02f, 4.87745292e-02f, 2.08427180e-02f, -4.99830954e-02f, -1.32324934e-01f, -4.03443687e-02f, -4.52716388e-02f, 1.55393481e-02f, -7.43132383e-02f, -4.67107221e-02f,
  8.31326395e-02f, 1.05507158e-01f, 1.31730199e-01f, -5.42089604e-02f, -4.04991619e-02f, -1.48339063e-01f, -6.94899559e-02f, 7.30023906e-02f, -7.86595494e-02f, -7.97880590e-02f,
  -9.28862020e-02f, 4.41773189e-03f, -8.00168887e-03f, -1.09794520e-01f, -6.01239316e-02f, -6.60841260e-03f, -2.01841556e-02f, -6.56069592e-02f, -1.50915280e-01f, -1.06637247e-01f,
  2.21949846e-01f, 6.29707947e-02f, 8.89982134e-02f, 2.38783717e-01f, -6.80340677e-02f, 3.96408960e-02f, -6.41002953e-02f, -5.82750067e-02f, 1.37382463e-01f, -3.50795453e-03f,
  7.32919797e-02f, 3.06912083e-02f, -2.35829368e-01f, 1.61481779e-02f, 3.32298875e-02f, -1.13248609e-01f, -2.23919958e-01f, 2.62807645e-02f, 8.30208044e-03f, 4.46201302e-02f,
  1.52735665e-01f, -1.57700241e-01f, -1.07295774e-01f, -1.35641456e-01f, 5.45431711e-02f, 1.12278223e-01f, -1.21554442e-01f, -2.74129301e-01f, -3.74857523e-02f, 3.23293284e-02f,
  1.42213451e-02f, 7.77546316e-02f, 4.54787649e-02f, 2.42215046e-03f, 9.37708169e-02f, 4.61336672e-02f, 7.05074519e-02f, -8.63938555e-02f, -2.31175162e-02f, 7.63186365e-02f,
  9.86780319e-03f, 3.05445362e-02f, -1.57778896e-02f, -1.65655434e-01f, -2.41100267e-02f, 1.41029686e-01f, 1.89666763e-01f, -5.11222221e-02f, -1.72034800e-01f, 8.05350542e-02f,
  7.80663192e-02f, 4.37587798e-02f, -5.77112958e-02f, -1.69165224e-01f, 7.92378653e-03f, 5.14233531e-03f, 1.17551595e-01f, -1.15420833e-01f, 5.86554110e-02f, 5.38047440e-02f,
  1.50633916e-01f, -1.42446831e-01f, -1.86949924e-01f, 1.18521973e-01f, 4.63831872e-02f, -1.29348963e-01f, 5.27327769e-02f, 1.93794295e-01f, -1.69848979e-01f, 1.14458725e-01f,
  5.31299300e-02f, 1.25574902e-01f, 3.15989554e-02f, -1.55130401e-01f, 6.63177297e-02f, 8.21696967e-03f, 6.84194788e-02f, -2.61870891e-01f, 1.10892661e-01f, 2.55586449e-02f,
  -2.20997572e-01f, -3.79270315e-02f, -2.60473266e-02f, -6.93267509e-02f, 1.97413951e-01f, -1.49335176e-01f, -1.64357662e-01f, -5.05912816e-03f, 2.44083209e-03f, 1.27056032e-01f,
  3.62685360e-02f, 7.70490989e-02f, -4.14045751e-02f, -7.85373002e-02f, 1.67185947e-01f, -1.53882042e-01f, 3.22059095e-02f, -3.14847589e-01f, 4.78632860e-02f, -9.36732963e-02f,
  1.50714815e-02f, -3.41591164e-02f, 7.94590190e-02f, 5.21872379e-02f, 7.84935653e-02f, -2.80299317e-03f, -7.51238614e-02f, -1.63692925e-02f, -3.39777507e-02f, 1.40908957e-01f,
  -1.56130865e-01f, 9.58475173e-02f, 2.03472227e-01f, -1.58353448e-01f, -3.45297009e-02f, 4.44904566e-02f, 9.62346513e-03f, 3.12092919e-02f, -4.68359329e-02f, -9.44827646e-02f,
  -1.05259277e-01f, -1.73716974e-02f, 9.04535577e-02f, -7.04737455e-02f, -1.98581666e-01f, 1.16814621e-01f, 1.55366519e-02f, -1.47517711e-01f, 8.01675841e-02f, -5.56598529e-02f,
  -1.10707752e-01f, -1.30514458e-01f, 1.06885999e-01f, 1.53400784e-03f, 1.78145945e-01f, -1.08473241e-01f, -1.08817771e-01f, 1.72564656e-01f, -1.16186470e-01f, -6.49841204e-02f,
  1.42129194e-02f, 9.39373076e-02f, -2.33204648e-01f, -1.56684980e-01f, 1.16713777e-01f, -1.53112402e-02f, 3.62452455e-02f, 6.86361939e-02f, -1.46546233e-02f, 1.97057396e-01f,
  8.71827155e-02f, -5.10376953e-02f, 3.99127044e-02f, -8.60719234e-02f, -1.78275257e-01f, 1.52761102e-01f, -2.14030743e-02f, -1.12512887e-01f, -7.78118595e-02f, 3.10951490e-02f,
  -4.57754061e-02f, 1.65228516e-01f, -8.30748975e-02f, -1.30422533e-01f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -8.00379291e-02f, -3.89223988e-03f, -8.29751045e-02f, 9.05789509e-02f, 4.72717769e-02f, 4.69565243e-02f, -1.09410927e-01f, 3.72436829e-02f, 1.36888400e-02f, -1.33860752e-01f,
  2.05124080e-01f, -1.69244949e-02f, -9.06163529e-02f, 3.57956409e-01f, 1.91149384e-01f, -4.89150956e-02f, -4.96222675e-02f, -4.86042649e-02f, 5.74088134e-02f, 5.54062203e-02f,
  1.15674548e-01f, 1.87668204e-01f, -9.56317857e-02f, 1.80148646e-01f, -4.79611568e-02f, -2.78726846e-01f, 1.18719719e-01f, 2.14790732e-01f, -1.74522251e-01f, -3.09598833e-01f,
  -3.49562708e-03f, 1.43559963e-01f, -1.10291667e-01f, 8.65632147e-02f, -1.21439390e-01f, -1.28107732e-02f, 1.64137721e-01f, -1.91612408e-01f, 4.88859192e-02f, 2.00877264e-02f,
  1.70484453e-01f, -2.92834938e-01f, 4.59412217e-01f, 1.96797282e-01f, 3.02845351e-02f, -3.88942286e-02f, -2.48487756e-01f, -1.19201705e-01f, 1.55170992e-01f, -2.26977989e-01f,
  -1.12823665e-01f, 1.83044255e-01f, 8.59323964e-02f, 1.32268131e-01f, 2.67182440e-01f, -7.10230395e-02f, -2.07244337e-01f, -2.05389917e-01f, 2.89476216e-01f, -1.83290020e-01f,
  4.41793911e-02f, -1.43915892e-01f, 1.54515281e-01f, -5.61058037e-02f, -1.61396824e-02f, 1.45928124e-02f, -4.79453579e-02f, 5.22377416e-02f, -1.81805473e-02f, 5.84054440e-02f,
  1.74659900e-02f, -1.43557027e-01f, 3.34795378e-02f, -1.93358943e-01f, -1.61427915e-01f, -1.01436719e-01f, 2.86489483e-02f, 8.57637525e-02f, 3.01243633e-01f, 1.84779927e-01f,
  1.94919676e-01f, -3.97358235e-04f, 5.13133742e-02f, 1.71556219e-01f, 5.39726987e-02f, 1.87691972e-01f, 1.93161905e-01f, 1.22719188e-03f, 1.58377700e-02f, -1.48025244e-01f,
  -8.70546326e-03f, 1.61855385e-01f, 1.16623044e-01f, -1.58095047e-01f, 3.86779793e-02f, -3.74707580e-02f, -2.43926331e-01f, 7.89399222e-02f, 6.96377158e-02f, -1.54964715e-01f,
  1.53441012e-01f, -1.12781487e-01f, 1.40432686e-01f, 1.50989899e-02f, 1.69944257e-01f, -9.72516388e-02f, 3.15272778e-01f, 8.02617967e-02f, 4.95488346e-02f, 4.65790965e-02f,
  -9.43137705e-02f, -7.04585016e-02f, 2.08112523e-01f, -1.83504611e-01f, 3.28067206e-02f, 2.27349564e-01f, 5.66267036e-02f, 2.56021678e-01f, 1.13567241e-01f, 6.99583665e-02f,
  -1.43524185e-01f, 3.86739746e-02f, 2.02852651e-01f, -8.27486590e-02f, 2.12610308e-02f, -1.10918254e-01f, 1.18724935e-01f, 1.06427111e-01f, 1.37162268e-01f, 5.14863245e-02f,
  3.57402372e-03f, 7.93468952e-02f, 6.46401662e-03f, 1.24961175e-01f, 1.47215620e-01f, -2.33083263e-01f, 7.79609978e-02f, -1.59270465e-01f, 1.75968800e-02f, -1.17494531e-01f,
  1.21107794e-01f, 1.46548554e-01f, 2.19259188e-01f, 2.48532355e-01f, 3.99530381e-02f, 4.44578566e-02f, 2.43205521e-02f, 1.49321511e-01f, 6.84954748e-02f, 1.33282751e-01f,
  2.87540466e-01f, -1.63611397e-01f, 1.73918679e-01f, -1.44572735e-01f, -5.86142167e-02f, -2.96811163e-02f, 2.09330842e-01f, -4.60252985e-02f, -7.38505125e-02f, -2.47525983e-02f,
  -1.94049895e-01f, -9.56370160e-02f, 1.40481427e-01f, -5.69650680e-02f, 2.20330641e-01f, -1.42028518e-02f, 5.61523736e-02f, -1.54984314e-02f, 4.74385433e-02f, -5.16691729e-02f,
  3.85953367e-01f, -1.30497992e-01f, 2.13925578e-02f, 1.89008817e-01f, 5.82580976e-02f, -1.98924895e-02f, 2.40376100e-01f, -1.68943554e-01f, -9.07846540e-02f, 1.58638023e-02f,
  3.45966555e-02f, 2.88919359e-01f, -1.29260346e-01f, 9.04893409e-03f, -7.56195262e-02f, 1.18198961e-01f, 2.60806471e-01f, -7.60144889e-02f, -1.11309610e-01f, 1.84899885e-02f,
  1.54463872e-01f, 1.69933975e-01f, 8.06716830e-03f, 9.52028111e-02f, 4.48995233e-02f, 6.03369549e-02f, -3.66949253e-02f, 3.98003161e-02f, 2.17064247e-01f, -1.86955914e-01f,
  -1.47684202e-01f, -3.10862452e-01f, -8.51051360e-02f, -5.78855351e-02f, -9.42449942e-02f, 3.72926593e-02f, 1.01671778e-01f, 1.40714824e-01f, 1.04764052e-01f, -5.26001714e-02f,
  8.57036561e-02f, 1.21407323e-01f, -8.79694223e-02f, 4.91113774e-02f, 5.78841791e-02f, -5.10935262e-02f, 2.79762119e-01f, 5.71393073e-02f, 9.94544253e-02f, -1.31438719e-02f,
  -2.50847816e-01f, -2.26107731e-01f, -3.35702449e-02f, -1.75496982e-03f, -1.69953063e-01f, 7.65273646e-02f, 1.30469635e-01f, -1.78351849e-01f, 1.27828479e-01f, 1.41557410e-01f,
  1.20096289e-01f, -7.43373856e-02f, 6.68733642e-02f, 1.49969593e-01f, 1.07883200e-01f, -4.66897935e-02f, -1.18415378e-01f, 1.39989197e-01f, 2.26064965e-01f, -1.42124236e-01f,
  -1.14549279e-01f, -1.34074271e-01f, -2.09251642e-02f, 3.20186429e-02f, 9.82036348e-03f, 2.22639874e-01f, -1.86064709e-02f, 3.80567610e-02f, -1.57222137e-01f, 2.43992478e-01f,
  -2.79098842e-02f, 4.50535901e-02f, 5.42720361e-03f, 3.79060917e-02f, -5.06682657e-02f, 2.88919300e-01f, -1.38755262e-01f, -1.02019697e-01f, -5.14137819e-02f, -1.57497063e-01f,
  -6.90089911e-02f, -1.16316579e-01f, -2.50055417e-02f, 1.96686208e-01f, 1.12640522e-01f, -9.19244885e-02f, -9.54579562e-02f, 3.15089189e-02f, -1.09591939e-01f, 1.28427982e-01f,
  8.54795203e-02f, -6.77635223e-02f, 1.28869072e-01f, 9.40862447e-02f, -1.91448644e-01f, 9.11398008e-02f, 1.49072915e-01f, 2.50139862e-01f, -1.83890477e-01f, 1.59558207e-02f,
  -3.68887000e-02f, 2.65078813e-01f, 2.03924328e-01f, 1.79474339e-01f, -2.05008417e-01f, -8.93360376e-02f, 3.60105410e-02f, -1.45929024e-01f, 2.23547041e-01f, -9.25133228e-02f,
  -1.30936950e-01f, 1.25667170e-01f, -5.60317673e-02f, -1.49076894e-01f, -1.17481880e-01f, 2.95322333e-02f, 1.51330069e-01f, 1.37049124e-01f, 1.55625567e-01f, -1.00367315e-01f,
  3.32668759e-02f, 4.70256209e-02f, -1.37439117e-01f, 1.50931254e-01f, -5.57894111e-02f, 6.17883913e-02f, 1.97416797e-01f, 9.93631408e-02f, 1.29991740e-01f, -1.06700629e-01f,
  -1.08216792e-01f, 3.91180441e-02f, 2.83849210e-01f, 8.08794871e-02f, 1.81375310e-01f, 1.03091538e-01f, -2.20398366e-01f, 1.48153871e-01f, 1.14922062e-01f, 1.64166361e-01f,
  1.02618318e-02f, 7.94571862e-02f, -6.65278509e-02f, -2.42689904e-03f, -1.13885432e-01f, -6.18952550e-02f, 8.10989887e-02f, 6.31375760e-02f, 2.34257072e-01f, 9.04034749e-02f,
  5.04977182e-02f, -1.15872920e-01f, -1.36443675e-01f, 1.67691201e-01f, 3.40438709e-02f, 1.14610437e-02f, -1.27210155e-01f, 3.78973968e-02f, -1.06044553e-01f, 7.42783323e-02f,
  2.90825754e-01f, 1.90447792e-01f, -1.28208790e-02f, -1.06880590e-02f, 5.16159600e-03f, 3.09334453e-02f, -1.06051318e-01f, 5.78531437e-02f, 2.16792315e-01f, 2.83731461e-01f,
  1.71686560e-01f, 2.29466647e-01f, 8.58327970e-02f, -3.98971234e-03f, -1.56399980e-01f, 2.66553760e-01f, 6.86480403e-02f, -1.40176073e-01f, 6.32741004e-02f, 2.85390839e-02f,
  -9.70450118e-02f, -4.74629439e-02f, 1.25360727e-01f, -1.93759203e-01f, -8.34520087e-02f, 1.11510456e-01f, -1.04778953e-01f, 6.46143705e-02f, 2.36137733e-01f, -4.72072773e-02f,
  -1.39676882e-02f, -6.54829443e-02f, 7.64661953e-02f, 1.10786937e-01f, -2.75606494e-02f, -3.32025737e-02f, 2.65023738e-01f, 2.59029213e-02f, 1.52948186e-01f, 4.77833934e-02f,
  2.43716575e-02f, -1.76025033e-01f, 1.87820226e-01f, 1.43270478e-01f, 2.26033151e-01f, 5.91847301e-02f, 5.73784932e-02f, 2.61513621e-01f, 2.33588189e-01f, 7.08422735e-02f,
  8.32238272e-02f, -2.12308154e-01f, -1.04566023e-01f, 2.81173468e-01f, 1.06318407e-01f, -6.14417382e-02f, 1.88031897e-01f, -4.40139472e-02f, -1.26682058e-01f, 9.50181931e-02f,
  -2.10500360e-01f, -1.03721306e-01f, 6.00126609e-02f, 1.30969584e-01f, 2.27493435e-01f, -1.89686015e-01f, 3.58416855e-01f, -1.52332664e-01f, -2.08398849e-02f, -1.23908341e-01f,
  -8.00386816e-02f, 2.09581181e-02f, 1.29348308e-01f, 2.77096748e-01f, -8.92747194e-02f, 7.94035643e-02f, 7.55671225e-03f, 1.06765829e-01f, 3.84968221e-01f, 1.34359166e-01f,
  8.89039412e-02f, 3.88690680e-01f, -1.33105144e-01f, 3.71295214e-01f, 7.16738850e-02f, 1.10925362e-01f, -6.98409379e-02f, 3.17323320e-02f, -6.02654926e-02f, -7.42885545e-02f,
  2.58748859e-01f, 9.74498019e-02f, 2.37209052e-01f, 9.06943828e-02f, -2.16561094e-01f, -1.38186187e-01f, -4.90896031e-02f, 1.77045912e-01f, -3.21433432e-02f, 2.69672275e-01f,
  1.64623693e-01f, -5.03695512e-04f, 1.43699437e-01f, -1.45015065e-02f, 1.33220941e-01f, -1.41491801e-01f, 1.97592109e-01f, -1.27590045e-01f, 7.24643320e-02f, -8.48129112e-03f,
  8.54979530e-02f, 9.85835418e-02f, 1.96394950e-01f, 2.10615769e-01f, -1.75715581e-01f, 4.26203907e-02f, -1.10981129e-01f, 2.30617002e-01f, -1.50138268e-03f, 4.76938076e-02f,
  -1.37489304e-01f, -6.22884557e-02f, -1.21945385e-02f, -1.06133439e-03f, 5.94451986e-02f, -1.46768659e-01f, 8.37463140e-02f, 1.10941045e-01f, 2.51538586e-02f, -2.39657789e-01f,
  3.38700593e-01f, 7.58473277e-02f, -5.87128960e-02f, -5.34493700e-02f, -7.35475123e-02f, 1.76398084e-01f, 8.86124149e-02f, 5.41289821e-02f, 5.45038469e-02f, 1.98891491e-01f,
  1.08406700e-01f, 3.07764620e-01f, 2.93732762e-01f, 1.28674477e-01f, 5.04905879e-02f, 2.15676904e-01f, 1.83555204e-02f, 2.23932937e-01f, 9.98253226e-02f, 1.19415767e-01f,
  -1.77691400e-01f, 2.66385913e-01f, -2.64706165e-01f, 2.84500811e-02f, 2.33477518e-01f, -1.30865157e-01f, 3.65307897e-01f, 1.05768189e-01f, -1.46839634e-01f, 1.27921656e-01f,
  -8.05857927e-02f, 3.89761627e-02f, 2.54420459e-01f, 2.88446635e-01f, 1.34438455e-01f, -4.79559861e-02f, 1.50313422e-01f, 3.21334116e-02f, 1.59041524e-01f, -6.77566901e-02f,
  9.34705436e-02f, -2.11616606e-01f, 1.26704797e-01f, 8.39295983e-02f, 1.13928266e-01f, -7.83441961e-03f, 7.06745461e-02f, 1.12799071e-01f, 2.01229468e-01f, -1.73699439e-01f,
  -1.00923469e-02f, -2.09851172e-02f, -2.80153483e-01f, 7.43625984e-02f, 3.19065303e-01f, -2.01070189e-01f, 2.35454030e-02f, 2.30179485e-02f, 1.50146186e-01f, 2.36086577e-01f,
  -4.34988514e-02f, -1.63306221e-01f, -1.30380988e-01f, 1.84239060e-01f, 1.75632864e-01f, -1.39798075e-02f, -8.03259835e-02f, 2.82923102e-01f, 1.94802433e-01f, -8.17764178e-02f,
  4.77342606e-02f, 1.66278388e-02f, -4.74307463e-02f, -1.65739313e-01f, 3.32618468e-02f, 4.31173816e-02f, 2.28548437e-01f, -1.99614570e-01f, -5.61313778e-02f, 1.86149403e-02f,
  1.03615411e-02f, -2.33451903e-01f, 1.65736988e-01f, 6.39177039e-02f, -2.41313428e-02f, -1.07621931e-01f, 3.51418763e-01f, 2.20515858e-02f, -3.68737206e-02f, 2.26835553e-02f,
  -1.34683207e-01f, 2.10357413e-01f, 3.08433473e-01f, 3.54837701e-02f, -2.49113720e-02f, 1.02474973e-01f, -1.05838150e-01f, 1.37666583e-01f, -1.15230657e-01f, 1.03102580e-01f,
  -1.95197314e-01f, 7.69487545e-02f, -1.76877156e-02f, 3.23962629e-01f, -2.70480096e-01f, 1.85177088e-01f, -5.78852855e-02f, -4.81769741e-02f, -9.71493945e-02f, -7.84389824e-02f,
  -1.46426141e-01f, 4.87488788e-03f, 1.52051225e-01f, -1.14034582e-02f, 2.17793286e-01f, -2.82895360e-02f, -1.04689591e-01f, -1.98304743e-01f, -2.11814381e-02f, 1.43233702e-01f,
  1.23765483e-01f, 2.65502315e-02f, 8.84900764e-02f, 7.70514831e-02f, -1.65422365e-01f, 1.23714581e-01f, 2.21694529e-01f, 2.87687600e-01f, 6.13726862e-02f, -1.38492003e-01f,
  1.21078193e-01f, 9.54633057e-02f, -1.53606581e-02f, 1.39362946e-01f, 2.10081786e-01f, 2.48486578e-01f, -4.97363061e-02f, -5.50756380e-02f, -4.56179567e-02f, -1.14814110e-01f,
  -1.46933585e-01f, 1.68457240e-01f, -5.69634438e-02f, -1.50664687e-01f, -1.21600898e-02f, 2.78276000e-02f, -1.20410785e-01f, 4.25129905e-02f, 2.97891974e-01f, -1.37707442e-01f,
  -3.29915099e-02f, 1.18840598e-01f, -1.58113569e-01f, 4.76218462e-02f, 7.01315403e-02f, -1.30498618e-01f, -6.93130717e-02f, -5.14309155e-03f, 1.25720669e-02f, 9.29446612e-03f,
  -7.42694736e-02f, -1.19111627e-01f, 2.46799603e-01f, 5.92662804e-02f, 1.97970301e-01f, 6.22284077e-02f, -1.13469444e-01f, -3.89143005e-02f, 1.92721531e-01f, 1.79382607e-01f,
  -4.83363345e-02f, -2.34009400e-01f, -1.46291375e-01f, -1.27638966e-01f, 3.36043015e-02f, -3.22639346e-02f, -3.66450250e-01f, -7.43624708e-03f, 1.64075404e-01f, 1.81018561e-01f,
  -2.24896669e-01f, -1.09326363e-01f, 2.24122375e-01f, -3.28280896e-01f, 4.96250996e-03f, 1.20438384e-02f, 4.13807742e-02f, -1.52919531e-01f, -5.46564870e-02f, 1.10485330e-01f,
  -1.26865372e-01f, -1.22865625e-01f, 2.27715477e-01f, -4.16846015e-02f, -2.49199867e-01f, -1.03157930e-01f, -5.58886603e-02f, -1.76657721e-01f, 5.29033780e-01f, 2.02614695e-01f,
  1.08026199e-01f, 1.92009419e-01f, -5.40854074e-02f, 2.30642278e-02f, -1.18605942e-01f, -5.02726957e-02f, 1.29752055e-01f, -2.36506864e-01f, 1.90911859e-01f, -1.38290431e-02f,
  -8.96458775e-02f, -1.03121549e-01f, -1.53771639e-01f, -9.27329510e-02f, 9.60875005e-02f, -1.28125116e-01f, -1.31446138e-01f, -8.80122110e-02f, 3.36551309e-01f, -2.05653533e-02f,
  6.96267709e-02f, 1.57602169e-02f, 7.80801028e-02f, 6.57153353e-02f, -1.37817696e-01f, -1.34020239e-01f, -6.06218316e-02f, -1.30227774e-01f, 3.03684454e-02f, 2.90176738e-03f,
  1.24706328e-01f, 2.60126800e-03f, 1.64695412e-01f, -1.76795363e-01f, 7.98652694e-02f, 1.18390925e-01f, 2.27865204e-02f, 1.32036403e-01f, 9.32282284e-02f, 7.65962079e-02f,
  3.87375243e-02f, -6.63155764e-02f, -3.08617167e-02f, -1.33523807e-01f, 1.51467651e-01f, -4.22474034e-02f, 3.03881150e-02f, 1.71243116e-01f, 5.70283793e-02f, 1.04028314e-01f,
  -6.24845698e-02f, -6.96148723e-02f, 1.64970890e-01f, 7.90637210e-02f, 3.74116041e-02f, -1.72174945e-02f, 7.27839172e-02f, 9.53639597e-02f, 1.10888019e-01f, -2.38910332e-01f,
  -6.15212659e-04f, 1.52808931e-02f, -1.48419917e-01f, -2.24968135e-01f, 6.81567891e-03f, 8.58210996e-02f, -1.49084002e-01f, 1.58937722e-01f, 9.77261290e-02f, -7.01028407e-02f,
  1.70444012e-01f, 2.01680690e-01f, 1.05862588e-01f, 1.10878065e-01f, 1.23448640e-01f, -5.97281642e-02f, 2.08274707e-01f, 2.59030074e-01f, -9.25271064e-02f, -4.28442098e-02f,
  1.31326690e-01f, -3.53111997e-02f, 1.59643084e-01f, -5.92156835e-02f, -1.58885658e-01f, 8.50515291e-02f, -5.36260603e-04f, 1.42000392e-01f, 1.39085218e-01f, 1.92352515e-02f,
  -1.29417360e-01f, 6.24740496e-03f, 1.75315052e-01f, -1.31259322e-01f, 6.93280995e-02f, -7.24770948e-02f, 6.91358745e-02f, 6.86860904e-02f, 2.69268274e-01f, 2.69421518e-01f,
  2.14015618e-01f, 2.03405306e-01f, 2.18539909e-01f, 2.01680437e-01f, 1.73420981e-01f, -2.73615599e-01f, -2.53446937e-01f, -7.57997558e-02f, -4.03686725e-02f, -2.76567172e-02f,
  2.75926441e-01f, -7.37069026e-02f, -6.81335032e-02f, 1.93768531e-01f, 3.39503139e-02f, -2.98180487e-02f, 2.08583921e-01f, -7.95680135e-02f, -1.52416989e-01f, -1.42790765e-01f,
  5.94828427e-02f, 2.87969559e-02f, 2.33218774e-01f, -1.20336957e-01f, -8.22328329e-02f, -6.13370426e-02f, -4.05829772e-02f, 8.65507498e-03f, -5.27216308e-02f, 1.47584468e-01f,
  -7.93064088e-02f, 1.19811893e-01f, 2.43568957e-01f, -7.90429041e-02f, 5.00967167e-02f, 2.69747913e-01f, 1.88262329e-01f, -6.37354329e-02f, 1.81322382e-03f, -3.51511165e-02f,
  -5.56832440e-02f, 7.67912716e-02f, 1.90237910e-01f, 6.82088509e-02f, 3.25084507e-01f, -9.42640901e-02f, -1.11619592e-01f, 3.73528972e-02f, -1.95624921e-02f, 7.05878139e-02f,
  -3.67005654e-02f, 2.19891891e-01f, 1.74771845e-01f, 1.34315610e-01f, -2.24031255e-01f, 2.32819334e-01f, -2.10032225e-01f, -5.45758791e-02f, 2.09664613e-01f, -1.44354686e-01f,
  -2.23029956e-01f, 2.95159705e-02f, 1.64073169e-01f, 4.19133268e-02f, -1.03721339e-02f, 1.70508474e-01f, 5.27203865e-02f, 5.26359417e-02f, -3.65719534e-02f, -9.89160687e-02f,
  -4.95313294e-02f, -5.44340573e-02f, 1.60686016e-01f, -1.67362407e-01f, -4.27019708e-02f, -1.25767663e-01f, -2.03373581e-01f, 1.41120434e-01f, -9.28507596e-02f, -8.99699479e-02f,
  6.01247996e-02f, 6.97643310e-02f, 5.96773811e-02f, -1.26709610e-01f, 2.47514486e-01f, -1.78241387e-01f, 1.01822205e-01f, -1.28020614e-01f, -5.81575260e-02f, -6.98588863e-02f,
  1.35432824e-01f, -3.53829749e-02f, -1.40650243e-01f, 1.81484997e-01f, -3.37453596e-02f, -5.89146763e-02f, 2.08341137e-01f, 7.32056648e-02f, 8.31361488e-02f, 3.18737447e-01f,
  9.00930259e-03f, 3.34302247e-01f, -8.47228318e-02f, 1.32839024e-01f, 1.19812079e-02f, 7.42759258e-02f, -2.97288299e-01f, 8.16500485e-02f, 2.24614397e-01f, -1.06701404e-01f,
  2.50640988e-01f, -1.20557444e-02f, -2.80702263e-01f, -1.75799727e-01f, -1.30874410e-01f, 2.35845093e-02f, -4.91937809e-02f, 5.29011711e-02f, -4.38176580e-02f, 1.15177363e-01f,
  2.16483809e-02f, -5.41715883e-02f, 3.33672911e-02f, 7.29804561e-02f, 1.98349789e-01f, 4.77920510e-02f, 9.26631093e-02f, -1.12707019e-01f, 1.85398355e-01f, 3.12483728e-01f,
  2.51604289e-01f, -1.24220401e-02f, 1.23161197e-01f, -4.55816537e-02f, -1.62814818e-02f, 3.31692606e-01f, 1.41721174e-01f, 3.96059565e-02f, -3.11248124e-01f, 1.37011021e-01f,
  -1.86158076e-01f, 5.31641729e-02f, -2.23987803e-01f, 4.06199172e-02f, 8.15271363e-02f, 2.07605943e-01f, 1.83798566e-01f, -2.57155567e-01f, 1.39473200e-01f, 1.03284627e-01f,
  2.41684750e-01f, -1.33638293e-01f, -2.12844864e-01f, 1.43158481e-01f, -1.32295024e-02f, 1.92706466e-01f, 1.00230359e-01f, 4.90149736e-01f, 3.71398598e-01f, 1.89732447e-01f,
  1.98276430e-01f, 2.97343045e-01f, 1.30794287e-01f, 6.63393438e-02f, 4.92803454e-02f, 4.96104471e-02f, 6.27114773e-02f, -2.23441631e-01f, -2.47797579e-01f, -2.09820777e-01f,
  -2.67423600e-01f, 9.27564129e-02f, 1.88201562e-01f, 1.35564402e-01f, 2.54831254e-01f, 1.77288890e-01f, -1.72161665e-02f, -8.31928402e-02f, 1.73954070e-01f, 5.66384718e-02f,
  1.30656222e-02f, 3.70300293e-01f, 3.17309022e-01f, 1.05821237e-01f, 3.02187409e-02f, 4.95277159e-02f, 2.87478954e-01f, -4.63751405e-01f, 1.80950910e-01f, -2.36973017e-01f,
  1.31610364e-01f, 6.41490370e-02f, -5.70154712e-02f, 5.90238608e-02f, 3.37145962e-02f, 6.08705506e-02f, 1.68084174e-01f, -7.70887807e-02f, 2.09560871e-01f, 7.06153139e-02f,
  1.12679161e-01f, -2.59943098e-01f, -3.57848592e-02f, 2.28913024e-01f, 1.06117092e-01f, 2.60908306e-01f, -1.61767807e-02f, 1.48006022e-01f, -1.09048352e-01f, 1.67469770e-01f,
  2.57056892e-01f, 2.60321796e-01f, 8.34049284e-02f, -1.03496306e-01f, 1.60087600e-01f, -7.70117640e-02f, -5.96151203e-02f, 1.00781828e-01f, 1.94275305e-01f, 2.67465562e-01f,
  -1.17244326e-01f, 9.72721204e-02f, 5.56022786e-02f, -1.84808239e-01f, -1.56199008e-01f, 1.72131658e-01f, 1.03545122e-01f, -1.56914398e-01f, -1.75834894e-01f, -1.27492137e-02f,
  -1.01475805e-01f, -3.81845348e-02f, 2.74278522e-01f, -2.14514911e-01f, 9.37541798e-02f, 1.79765686e-01f, -7.24937469e-02f, 9.04543325e-02f, 1.40886262e-01f, -1.07650913e-01f,
  -1.23330086e-01f, 2.31445916e-02f, 9.39557180e-02f, 2.90284194e-02f, -1.12881266e-01f, 1.89016517e-02f, 2.68393397e-01f, 2.08236605e-01f, 2.73996234e-01f, -9.29545909e-02f,
  -9.56126228e-02f, -1.45838737e-01f, 2.59438485e-01f, 1.21983834e-01f, -2.55997092e-01f, -2.75699526e-01f, -3.43921036e-02f, -2.29720905e-01f, -5.21601774e-02f, -5.71766421e-02f,
  -1.07844226e-01f, 8.15192536e-02f, 1.44140229e-01f, -7.07004145e-02f, -2.51500130e-01f, 3.07756178e-02f, -7.68749788e-02f, -1.23215005e-01f, 6.52761385e-02f, 1.81146026e-01f,
  5.99940754e-02f, 1.17702030e-01f, 3.40656377e-02f, 2.51436234e-01f, -8.47158656e-02f, 1.09532200e-01f, -1.65238902e-02f, -2.34840550e-02f, 9.14220810e-02f, 6.01915270e-02f,
  1.93335190e-02f, -1.61266670e-01f, 3.74050021e-01f, 5.80745600e-02f, 1.07120812e-01f, 1.47747815e-01f, 1.65845081e-01f, 7.81950727e-02f, -9.05550569e-02f, -1.58620164e-01f,
  2.05520466e-01f, -1.22605786e-01f, 1.59081802e-01f, -1.23886243e-01f, -3.12100369e-02f, 1.25833675e-01f, -7.73604885e-02f, -1.73520476e-01f, -1.16227837e-02f, 1.55028984e-01f,
  1.96647663e-02f, 6.76673353e-02f, 1.87132925e-01f, 7.02133924e-02f, 1.70370251e-01f, -3.94551493e-02f, 2.16775432e-01f, -2.02580597e-02f, -1.96959555e-01f, 1.88748941e-01f,
  5.71520887e-02f, 1.01207502e-01f, -1.59881637e-02f, 1.46208242e-01f, 6.33215532e-02f, 1.15716130e-01f, 1.50134236e-01f, 9.14775953e-03f, -1.06680930e-01f, -1.01935625e-01f,
  1.40140615e-02f, 4.33881879e-02f, 2.13384196e-01f, 2.44945660e-02f, -1.11532308e-01f, -7.65193030e-02f, 6.39505535e-02f, 2.54259646e-01f, -2.52456129e-01f, 8.09522048e-02f,
  1.91773742e-01f, -1.84281841e-01f, 7.70486221e-02f, 3.30260918e-02f, 2.60145403e-02f, 1.02947518e-01f, -2.74908170e-02f, 1.08232811e-01f, -1.14289269e-01f, -2.56860796e-02f,
  2.13603973e-01f, 1.23438329e-01f, -2.71794647e-01f, -8.64695907e-02f, -1.53001383e-01f, -1.59178659e-01f, 3.46138060e-01f, 1.61402583e-01f, 1.12125739e-01f, 1.33369610e-01f,
  1.52621865e-01f, 2.13001326e-01f, 2.31928498e-01f, -1.46611735e-01f, 1.31850064e-01f, -3.11628450e-02f, 5.35800867e-02f, -1.80334941e-01f, 1.24712206e-01f, -3.45437974e-02f,
  -1.19305044e-01f, -7.70540014e-02f, 2.87545562e-01f, -2.41729859e-02f, -1.74386770e-01f, 2.15231273e-02f, 2.50524580e-01f, 1.81285143e-01f, 1.30936205e-01f, 1.09212205e-01f,
  6.17180914e-02f, 7.53924921e-02f, -8.79411995e-02f, 3.20455223e-01f, 1.32528050e-02f, -1.32469326e-01f, 2.48005148e-02f, 6.27541691e-02f, 9.11783427e-02f, -8.91658217e-02f,
  5.11665735e-03f, -1.91035569e-01f, -3.53712440e-02f, 3.57200392e-02f, 4.01448458e-02f, 3.43582928e-02f, 1.02590315e-01f, 5.85578121e-02f, -1.05948597e-02f, 4.18070816e-02f,
  -3.59611167e-03f, -2.41649240e-01f, 1.35796042e-02f, -8.72799382e-03f, -1.04493305e-01f, 1.35772318e-01f, 1.59377187e-01f, 1.65929720e-01f, 1.51800215e-01f, -2.57282536e-02f,
  1.24449067e-01f, 2.08569482e-01f, 1.07617110e-01f, 9.69133824e-02f, -6.07128888e-02f, -5.09571731e-02f, 4.78326995e-03f, -1.03040725e-01f, 2.95861829e-02f, 7.32192397e-02f,
  -2.41453052e-01f, -2.05932260e-01f, -1.19651519e-01f, -1.54012144e-01f, 2.10045576e-02f, 5.34701981e-02f, 6.49297535e-02f, -6.04415797e-02f, 1.28141772e-02f, 1.26918033e-01f,
  -5.98357320e-02f, 5.94819225e-02f, 1.53151855e-01f, 1.12242952e-01f, 1.27345458e-01f, 2.12787569e-01f, -4.33402956e-02f, 9.13131312e-02f, 7.68688396e-02f, 3.32506076e-02f,
  3.04905549e-02f, 7.46299420e-03f, -1.61033999e-02f, 1.39109880e-01f, 1.57861546e-01f, 2.73031518e-02f, 6.80297464e-02f, 2.29619160e-01f, 5.42167723e-02f, 9.07511190e-02f,
  1.82776883e-01f, 3.01458985e-02f, -4.39800955e-02f, 2.10164003e-02f, 3.99151519e-02f, 8.00276548e-02f, 2.34998181e-03f, 8.99051204e-02f, 1.44069806e-01f, 1.76004305e-01f,
  8.17675889e-03f, 5.77624999e-02f, 2.36437723e-01f, -4.88061178e-03f, -6.16615824e-02f, -1.74168020e-01f, 1.05654806e-01f, -2.12796237e-02f, -7.60554103e-03f, 1.45756930e-01f,
  -6.45487681e-02f, 9.09311175e-02f, 1.09226763e-01f, 5.10162860e-02f, 1.58268377e-01f, 1.13003083e-01f, 9.28105786e-02f, 3.46457474e-02f, -7.73947984e-02f, -4.16725650e-02f,
  2.43638173e-01f, 5.62995151e-02f, -3.72888148e-02f, -5.35803773e-02f, -1.87469184e-01f, 3.26778963e-02f, 6.81768823e-03f, 4.67616059e-02f, 9.68712345e-02f, -7.02294856e-02f,
  1.30829081e-01f, 1.14923008e-01f, 7.04829991e-02f, 2.92523265e-01f, -1.21197579e-02f, 2.18694255e-01f, -1.20645411e-01f, 2.89573848e-01f, -2.95632277e-02f, 6.52732626e-02f,
  -1.60777897e-01f, 1.56008512e-01f, 2.28167146e-01f, 1.10406250e-01f, -9.09049213e-02f, 4.68202867e-02f, -8.20039958e-02f, -1.24694653e-01f, -2.51128580e-02f, -4.36864502e-04f,
  -3.44031453e-02f, 1.18118569e-01f, 1.71173766e-01f, 2.93987006e-01f, -6.13793470e-02f, 1.67327642e-01f, 2.89172959e-02f, 9.93235931e-02f, -2.59156357e-02f, 2.15205520e-01f,
  1.25907347e-01f, 1.81329057e-01f, 1.08100004e-01f, 2.00170562e-01f, -3.78262252e-02f, 7.78200850e-02f, 5.97999953e-02f, 2.68578227e-03f, -5.49037792e-02f, -1.58822194e-01f,
  1.63627967e-01f, 2.88367900e-03f, -1.03937760e-01f, 6.10341094e-02f, -1.34543260e-03f, -2.25277594e-03f, 1.40469283e-01f, -3.00107133e-02f, 1.27954230e-01f, -6.95025548e-02f,
  4.23169807e-02f, -1.03445172e-01f, -1.67995855e-01f, 2.38090441e-01f, 2.70705283e-01f, 1.38877496e-01f, 6.23389110e-02f, 2.39851877e-01f, -9.07913148e-02f, 4.69867475e-02f,
  2.18743399e-01f, 1.73800290e-01f, -1.57445103e-01f, 1.62400886e-01f, -1.84418276e-01f, 1.60208583e-01f, 6.42530397e-02f, -1.28682461e-02f, 2.70010322e-01f, 6.71220869e-02f,
  -8.66659284e-02f, -1.04902685e-01f, 1.44004360e-01f, 2.34512657e-01f, -6.19542487e-02f, 1.01014711e-02f, 1.88193172e-01f, -2.15713903e-02f, -1.13173768e-01f, -1.84771717e-01f,
  -1.53846266e-02f, 1.56143293e-01f, 3.77369970e-02f, 1.67369530e-01f, 3.19296002e-01f, -1.57775849e-01f, -4.07215431e-02f, 1.13807499e-01f, -1.23031601e-01f, 3.26520875e-02f,
  1.90073743e-01f, 1.81690441e-03f, -1.33991048e-01f, 2.02640072e-01f, -1.75352082e-01f, -2.93982476e-01f, -7.58083537e-02f, -2.05082402e-01f, -2.68925745e-02f, -1.13785587e-01f,
  -1.45431580e-02f, -1.32418767e-01f, 4.16459516e-02f, -5.90632483e-02f, -2.91692048e-01f, -5.12198173e-02f, -1.73921570e-01f, -9.62882191e-02f, 6.90036789e-02f, 2.79125959e-01f,
  6.49602637e-02f, -6.45168498e-02f, -1.04475446e-01f, 2.39111707e-01f, 5.41315526e-02f, 1.13706075e-01f, 2.85726309e-01f, -1.74950734e-01f, -2.11495403e-02f, 5.27890539e-03f,
  -1.65391967e-01f, -5.77858798e-02f, 5.51809184e-02f, -5.54163940e-03f, -4.38619638e-03f, -1.14448123e-01f, 7.51881078e-02f, 9.44808498e-02f, 1.38709560e-01f, -3.08668986e-02f,
  5.14298491e-02f, 5.12648523e-02f, 9.40210745e-02f, -2.00057738e-02f, 1.85619459e-01f, 7.44516999e-02f, 5.42227030e-02f, -2.20514208e-01f, -2.23659679e-01f, 1.86731726e-01f,
  -4.53837849e-02f, -6.65084720e-02f, 3.10034990e-01f, 9.57595706e-02f, 5.76714100e-03f, 2.21076384e-02f, 1.27906412e-01f, -3.12963640e-03f, -2.17229828e-01f, 3.74855489e-01f,
  2.53772318e-01f, 1.11413069e-01f, 1.50580838e-01f, 1.35226876e-01f, -3.44666876e-02f, -5.04782945e-02f, 2.11901367e-01f, -4.03536297e-03f, 6.27470538e-02f, 4.35810827e-04f,
  4.80712354e-02f, -8.69262367e-02f, 1.45210959e-02f, 1.22164316e-01f, 5.99189252e-02f, -1.54476315e-01f, 9.68850628e-02f, 2.22382709e-01f, -2.67705679e-01f, -1.43906787e-01f,
  1.70744091e-01f, -1.11192457e-01f, 7.06730485e-02f, -4.35617566e-02f, 5.43799363e-02f, 2.29222104e-02f, -4.87444997e-02f, -9.53365788e-02f, 1.49198398e-01f, -1.66799147e-02f,
  3.71603727e-01f, -1.02106720e-01f, -1.64827198e-01f, -5.41869365e-02f, -1.67919353e-01f, 2.04391982e-02f, 2.08258912e-01f, 2.84922540e-01f, 3.62698436e-02f, -5.06476201e-02f,
  -1.93125308e-01f, 1.14801824e-01f, 2.40847468e-01f, 7.37685636e-02f, -5.85438870e-02f, 3.25566530e-02f, -7.17440695e-02f, -5.77465221e-02f, 5.91933168e-02f, -1.15665644e-01f,
  -4.92175147e-02f, -1.00930505e-01f, 1.84437752e-01f, -7.95575827e-02f, -9.04269889e-02f, -6.24662731e-04f, 2.56350189e-01f, -4.90492769e-03f, -2.54324246e-02f, 6.79228008e-02f,
  -5.34638129e-02f, 8.23660791e-02f, -2.38193385e-02f, 2.50593543e-01f, 1.18404903e-01f, -5.30320592e-02f, 9.80884731e-02f, 1.56717561e-02f, -2.06185319e-02f, -1.88545808e-01f,
  8.51242617e-02f, -7.09007159e-02f, -7.76719749e-02f, -7.42421225e-02f, 1.13785435e-02f, -1.52159750e-01f, -1.79037571e-01f, -5.28122969e-02f, -4.09648269e-02f, 1.93230495e-01f,
  1.67500183e-01f, -1.51116490e-01f, -1.95577711e-01f, 1.08275786e-01f, -9.03189853e-02f, -8.94820243e-02f, 1.62543982e-01f, 7.96041042e-02f, 1.85574919e-01f, 7.93215334e-02f,
  -9.33680385e-02f, 6.86763600e-02f, -5.63242147e-03f, 2.32965484e-01f, -1.85350493e-01f, 1.20300055e-01f, -3.18179615e-02f, 3.19837064e-01f, 1.70711994e-01f, 1.35534763e-01f,
  -7.07657039e-02f, -1.20016105e-01f, 1.90046072e-01f, 6.79062726e-03f, 1.29321843e-01f, 2.25405786e-02f, -2.22998187e-01f, 1.02592390e-02f, -8.19096044e-02f, -2.02471480e-01f,
  1.21871583e-01f, -1.35300219e-01f, 1.30856618e-01f, 9.48279127e-02f, 6.57694489e-02f, -5.89156747e-02f, -4.84242514e-02f, 1.82390913e-01f, -1.03450879e-01f, -3.59878503e-03f,
  -9.28459466e-02f, 5.76248094e-02f, 2.75182635e-01f, 1.32272184e-01f, 9.64776501e-02f, -3.97923104e-02f, 9.89405960e-02f, -1.04761221e-01f, 8.29749182e-02f, -8.02463945e-03f,
  2.82777976e-02f, 1.95399731e-01f, -6.98807836e-02f, 2.94032037e-01f, -1.02977738e-01f, 1.94007292e-01f, 4.83998880e-02f, 7.64651820e-02f, 2.67055124e-01f, 2.25650802e-01f,
  1.63270891e-01f, 4.22452856e-03f, 1.85406402e-01f, -1.47122368e-01f, -9.82778817e-02f, 7.89420307e-02f, 7.11976364e-02f, 1.03602082e-01f, -1.98386341e-01f, 1.08881652e-01f,
  -2.49120742e-02f, 4.02607173e-02f, 3.44606936e-02f, 6.19359203e-02f, -4.08278927e-02f, 5.59527278e-02f, 1.37313306e-01f, -4.53052931e-02f, 2.17499235e-03f, 4.38181087e-02f,
  3.12209696e-01f, 2.74116784e-01f, 2.96798605e-03f, 1.65339082e-01f, -2.70340294e-01f, 1.26856282e-01f, 1.45277277e-01f, 1.42611995e-01f, 2.13790312e-01f, 6.45763651e-02f,
  3.19661461e-02f, 1.57106712e-01f, -1.96612086e-02f, -2.83624083e-02f, 6.91279545e-02f, -1.76506311e-01f, 1.30024016e-01f, -6.85825199e-02f, -1.27128810e-01f, -2.10481092e-01f,
  -7.91885629e-02f, 1.75651729e-01f, 1.90015435e-01f, 9.21881199e-02f, -1.01854399e-01f, 1.20986544e-01f, 2.14858279e-01f, 4.94446680e-02f, 6.34215549e-02f, 9.71800834e-03f,
  1.19862705e-03f, 1.68492734e-01f, 1.51584014e-01f, 1.21854350e-01f, -8.33226293e-02f, 1.03376336e-01f, 8.55990425e-02f, -1.08360231e-01f, -6.82650805e-02f, 1.48911119e-01f,
  -9.81038511e-02f, -4.22768295e-02f, 9.26153436e-02f, -2.32217416e-01f, -1.15996525e-01f, -4.58593257e-02f, 7.41568953e-02f, -1.33714164e-02f, -8.63704272e-03f, -3.21838617e-01f,
  -1.21892437e-01f, 4.76437956e-02f, 4.69712839e-02f, 1.24939404e-01f, 5.98896667e-02f, 2.21016675e-01f, 2.14051679e-01f, 1.00632481e-01f, 1.84680521e-01f, 1.94191605e-01f,
  -6.36682361e-02f, 2.72114486e-01f, -2.52236307e-01f, -1.11254141e-01f, 2.38352612e-01f, 1.18354842e-01f, 1.63202092e-01f, -2.42197499e-01f, -2.41227314e-01f, -2.06707522e-01f,
  -1.06787100e-01f, -1.31238714e-01f, 1.24792501e-01f, -8.05050209e-02f, 2.27232911e-02f, -1.92299709e-01f, 1.07616015e-01f, 1.49040565e-01f, -3.19384672e-02f, 9.00364071e-02f,
  1.14801824e-02f, 3.98668796e-01f, 1.23068452e-01f, 1.44938692e-01f, -2.50326823e-02f, 1.56302378e-01f, 1.47941992e-01f, 2.75479909e-02f, -1.69391960e-01f, 8.28803703e-02f,
  1.00713700e-01f, -7.38243982e-02f, 1.03810124e-01f, 2.07764581e-02f, -7.71330744e-02f, -1.35811334e-02f, -9.16977748e-02f, 3.15504909e-01f, -8.80357325e-02f, 1.00823216e-01f,
  -6.33237734e-02f, 4.60445046e-01f, -4.11076508e-02f, 2.51956373e-01f, 1.81830302e-01f, 1.51800513e-01f, 1.65838018e-01f, 1.78604469e-01f, 4.78599556e-02f, 1.42899200e-01f,
  1.34181501e-02f, -8.32089037e-02f, -4.47257273e-02f, 4.60857749e-02f, 4.44506668e-02f, -5.64510301e-02f, 5.14331348e-02f, -1.88142415e-02f, 1.06651723e-01f, -2.15158552e-01f,
  2.21501768e-01f, 9.49578062e-02f, -6.37605637e-02f, -1.80373892e-01f, 1.46165174e-02f, -1.00081548e-01f, 6.40482679e-02f, 1.52036250e-01f, 2.05680221e-01f, 2.30943039e-01f,
  2.63386220e-01f, 4.57161218e-01f, 1.59369141e-01f, 3.47401172e-01f, 2.05846205e-02f, -7.25686774e-02f, 7.14183375e-02f, 4.73348424e-03f, -2.05702633e-01f, 2.81502753e-01f,
  -1.36084229e-01f, -2.13586897e-01f, -2.37450302e-02f, -3.50181200e-02f, 5.84840365e-02f, -2.42108375e-01f, -5.48174605e-03f, 2.64663380e-02f, 2.51013428e-01f, -4.27945256e-02f,
  1.19640253e-01f, 1.67236790e-01f, -6.14121258e-02f, -5.39159123e-03f, 2.52601206e-01f, 2.21736312e-01f, -1.13145955e-01f, 9.92687419e-02f, 2.46583790e-01f, -2.93156952e-01f,
  3.55302617e-02f, 2.70449724e-02f, -4.70437817e-02f, -1.05539523e-01f, 3.99424285e-02f, -3.57699394e-02f, -7.33986422e-02f, 7.07785040e-02f, 2.07189336e-01f, 2.33071283e-01f,
  1.13122918e-01f, 1.59751073e-01f, 1.62645131e-01f, 1.59238592e-01f, -2.86928415e-01f, 1.09662808e-01f, -4.51879464e-02f, 3.00932825e-01f, 9.98608172e-02f, -5.77607304e-02f,
  3.05040747e-01f, -9.12922919e-02f, 7.46978389e-04f, -2.05163762e-01f, 5.14232442e-02f, -1.71414409e-02f, -4.05466259e-02f, -1.84410512e-01f, -1.32096568e-02f, -1.07192472e-01f,
  1.76377550e-01f, 1.86104521e-01f, -2.04603836e-01f, 7.14085996e-02f, 2.76658051e-02f, 2.80733854e-01f, 3.95018220e-01f, 3.20954204e-01f, 1.21555895e-01f, 8.76000971e-02f,
  -8.33185017e-02f, 1.93442672e-01f, 3.44917998e-02f, 2.04308838e-01f, -1.42954990e-01f, 6.02154844e-02f, 6.18511252e-02f, 2.40760788e-01f, 1.06213093e-02f, 6.70182193e-03f,
  -1.11327291e-01f, 2.96332449e-01f, 2.37817183e-01f, -1.76329523e-01f, 1.00024454e-01f, 1.18332103e-01f, 1.04886621e-01f, 1.00813419e-01f, 1.79102849e-02f, 1.67222038e-01f,
  -1.73292682e-01f, -6.67024627e-02f, 3.12567949e-01f, -1.03546984e-01f, 4.31505740e-02f, -1.16042830e-01f, 5.47517315e-02f, -6.90333825e-03f, 9.14197415e-02f, 6.72823712e-02f,
  -2.81528886e-02f, -1.39795199e-01f, 1.13630354e-01f, 8.39319304e-02f, 4.25995216e-02f, -4.42358032e-02f, 1.66050300e-01f, 9.98329818e-02f, -1.65013656e-01f, 2.39263549e-02f,
  -9.45884455e-03f, 1.39466599e-01f, -1.29911199e-01f, 6.72989041e-02f, 4.00422186e-01f, -1.12138413e-01f, 4.79924046e-02f, -3.46153490e-02f, -5.00262454e-02f, 1.73241526e-01f,
  4.48704511e-02f, 7.99444225e-03f, -6.09127246e-02f, 1.96459927e-02f, 1.11437932e-01f, -8.72304812e-02f, -2.88525045e-01f, 6.42064065e-02f, 9.37369317e-02f, -1.13250077e-01f,
  2.76070744e-01f, 1.89327344e-01f, -1.77525491e-01f, -1.53170660e-01f, 2.49992177e-01f, -1.49808571e-01f, 1.44229114e-01f, -1.16876334e-01f, -8.19961801e-02f, 6.40211254e-02f,
  -1.87720716e-01f, 1.30959362e-01f, 6.76890016e-02f, 2.05064148e-01f, -1.14109442e-01f, 1.06661282e-01f, 3.90371382e-01f, -4.08040062e-02f, -3.05383652e-02f, 1.24401867e-01f,
  6.16264790e-02f, 2.30160475e-01f, 1.23039432e-01f, -7.01981485e-02f, 3.41155380e-02f, -1.10043027e-01f, -1.21966958e-01f, 1.58510089e-01f, 7.96184223e-03f, -1.75141558e-01f,
  3.33057158e-02f, 5.37444241e-02f, -4.14219350e-02f, 1.94851220e-01f, 6.80165440e-02f, -5.62000982e-02f, -1.17028244e-01f, 1.92500800e-02f, 3.91439460e-02f, -1.22137353e-01f,
  -1.42158866e-01f, -1.19919077e-01f, 1.15881080e-03f, 7.28076994e-02f, 1.99774101e-01f, -6.02405630e-02f, -2.07404777e-01f, 4.76372987e-02f, 1.43450692e-01f, -1.82320550e-02f,
  7.69159794e-02f, 4.55721952e-02f, 8.96499306e-02f, 2.28603750e-01f, -1.06448404e-01f, 1.33041084e-01f, 6.94164559e-02f, 3.20407271e-01f, -1.15148641e-01f, -5.08095510e-02f,
  2.92105209e-02f, 2.92719305e-01f, 2.30572686e-01f, -7.67879635e-02f, 1.36365190e-01f, 1.55704468e-01f, 1.52079642e-01f, -1.08479775e-01f, 2.37163469e-01f, -1.15276873e-01f,
  -1.06141761e-01f, 5.08529367e-03f, 2.53267270e-02f, -1.93072334e-01f, -5.02015501e-02f, 4.08989284e-03f, 3.24689001e-02f, 1.04400292e-01f, 5.47922403e-02f, -1.98064253e-01f,
  1.16687201e-01f, 5.52502051e-02f, -1.05135821e-01f, 2.15870410e-01f, -8.16969573e-02f, 1.73075646e-01f, 1.97029054e-01f, -5.98633625e-02f, 1.30085737e-01f, -6.73901290e-02f,
  -2.00232059e-01f, -4.37772311e-02f, 9.48034525e-02f, 6.41063377e-02f, -3.69274765e-02f, 1.54720947e-01f, -1.12504333e-01f, 2.31645778e-01f, 5.75838014e-02f, 2.04706445e-01f,
  5.07213511e-02f, 1.64546818e-01f, -2.56740972e-02f, -1.15888260e-01f, -9.79375765e-02f, 2.60096602e-02f, -2.59896129e-01f, 3.04000676e-01f, -2.16648821e-02f, -1.08487286e-01f,
  -1.01557568e-01f, 1.69310644e-02f, 2.59701163e-01f, -7.67391399e-02f, 1.30790427e-01f, -6.65684342e-02f, 2.63170779e-01f, 1.65070757e-01f, 2.39037424e-01f, -1.03978850e-01f,
  -2.81386375e-01f, 9.79252830e-02f, -1.39237568e-01f, 2.90594727e-01f, -4.31618840e-02f, 6.13519959e-02f, 2.56652176e-01f, -1.27178608e-02f, 4.19559479e-02f, -9.94275138e-02f,
  1.63135007e-01f, 2.21042559e-02f, -5.08954860e-02f, 1.90657645e-01f, -1.72235712e-01f, -1.49426132e-01f, -6.61794618e-02f, 7.20406696e-02f, 1.89436153e-01f, 2.20658481e-01f,
  4.86457571e-02f, 2.18362406e-01f, 1.04604110e-01f, 4.37716186e-01f, 3.16404700e-01f, -4.77563553e-02f, 3.99438012e-03f, 6.34320527e-02f, -1.37381181e-01f, 1.29668295e-01f,
  2.47126237e-01f, 1.92907333e-01f, -4.04488742e-02f, -9.35977101e-02f, 3.22076589e-01f, -2.21449137e-01f, -2.34733686e-01f, -5.10894619e-02f, -7.92687759e-02f, 6.14328571e-02f,
  4.40208130e-02f, 3.54303956e-01f, -2.90402710e-01f, 2.45562866e-02f, 1.77211896e-01f, 2.04730675e-01f, -6.79659769e-02f, 1.47087546e-02f, 1.53790386e-02f, 1.48696780e-01f,
  -2.37423286e-01f, 2.01932624e-01f, 1.08410396e-01f, 2.12839767e-02f, 2.55355120e-01f, 8.73863846e-02f, 5.83923645e-02f, 1.21518441e-01f, 5.18063121e-02f, -2.45923072e-01f,
  -6.76484481e-02f, 8.11553840e-03f, -2.04729531e-02f, -1.80908114e-01f, 1.59770742e-01f, 3.60192023e-02f, -5.53304404e-02f, 2.72126138e-01f, -1.16076402e-01f, 1.12175904e-01f,
  2.51540512e-01f, 2.41172820e-01f, 1.86006725e-01f, 8.96241888e-02f, 3.63200083e-02f, 2.09239349e-01f, 6.41033519e-03f, 1.66100621e-01f, -1.77668855e-01f, 2.27235898e-01f,
  7.79718459e-02f, -1.28547465e-02f, -8.07558820e-02f, 3.29397410e-01f, 1.06597632e-01f, 2.29254011e-02f, 1.81760713e-01f, 2.15776935e-01f, -2.11908258e-02f, -1.62560731e-01f,
  6.09535798e-02f, 6.57664239e-02f, 1.83119968e-01f, 8.75245109e-02f, 7.03358650e-02f, 1.33487031e-01f, -8.85603763e-03f, -5.12769595e-02f, 2.40823448e-01f, -2.58604109e-01f,
  4.28697607e-03f, -1.83329031e-01f, 1.83764815e-01f, -1.35760561e-01f, 4.96570766e-02f, 3.11146408e-01f, 1.80297941e-01f, -7.47966692e-02f, 1.10188536e-01f, 1.26701608e-01f,
  3.76606882e-02f, 7.47925714e-02f, -7.47104436e-02f, 6.69868067e-02f, 5.54382913e-02f, 5.11282589e-03f, 9.10614990e-03f, -8.11360180e-02f, 2.22973257e-01f, -1.85519382e-01f,
  -1.42831011e-02f, 9.91851836e-02f, -1.13289826e-01f, 1.60439178e-01f, -5.74691929e-02f, 3.05316932e-02f, 7.76136816e-02f, 1.09242029e-01f, 1.33516639e-01f, 5.67139238e-02f,
  -1.10247366e-01f, -1.54756933e-01f, 2.34407812e-01f, -9.02856141e-02f, -6.36743009e-02f, -2.46718414e-02f, 7.37653226e-02f, 9.43498015e-02f, -8.55041370e-02f, 1.22729927e-01f,
  -6.03578128e-02f, -1.41082942e-01f, -2.20132992e-02f, 7.27073997e-02f, 1.61313519e-01f, 1.31049231e-01f, 2.79218395e-04f, 3.31669033e-01f, -2.08835527e-01f, 2.58714020e-01f,
  2.25548610e-01f, -2.36583352e-02f, -1.73864439e-01f, 1.39067307e-01f, 1.86525032e-01f, -1.80339031e-02f, 1.08891040e-01f, -1.42969519e-01f, -2.18315214e-01f, -2.01725870e-01f,
  -1.56355463e-02f, 2.92153433e-02f, -3.19871455e-02f, -1.69119850e-01f, 1.03797488e-01f, 2.38387540e-01f, 7.02150166e-02f, 4.97950278e-02f, -8.71702377e-03f, 5.51971942e-02f,
  2.45702371e-01f, 2.00069174e-01f, 2.23869666e-01f, 8.59731957e-02f, -1.03043251e-01f, 2.95101497e-02f, 6.24321774e-02f, -1.45368753e-02f, -1.94696561e-01f, 1.00694969e-01f,
  -7.18013048e-02f, 8.80973637e-02f, 1.31479606e-01f, 1.45941079e-01f, -1.27140386e-02f, 1.73450634e-01f, 9.29884315e-02f, -1.38970584e-01f, -2.06041951e-02f, -1.99990887e-02f,
  -1.83560252e-02f, -1.48037434e-01f, 1.85049072e-01f, 6.87185973e-02f, 3.75418067e-01f, -2.33743954e-02f, -1.09765001e-01f, 6.79418966e-02f, 3.39683294e-01f, 3.30423445e-01f,
  -7.45360255e-02f, -5.39658219e-02f, -1.43492520e-01f, -1.40244946e-01f, -1.12151708e-02f, 1.83837131e-01f, 2.02739730e-01f, 3.26539725e-01f, -3.87593471e-02f, 7.44537488e-02f,
  -3.11545044e-01f, 2.72248894e-01f, 3.45178276e-01f, 1.05408423e-01f, 8.29188675e-02f, 2.71342486e-01f, -8.48300308e-02f, -1.75318867e-01f, -9.37383622e-02f, -1.03039518e-01f,
  3.19486707e-01f, 1.43117368e-01f, 8.15960243e-02f, 1.00848027e-01f, -1.11032963e-01f, -1.06645063e-01f, 1.92593843e-01f, 1.05358191e-01f, -1.27636880e-01f, -1.36518762e-01f,
  3.89089465e-01f, -1.11641377e-01f, -1.15811743e-01f, 3.75803620e-01f, 2.10729018e-01f, -1.09834954e-01f, 1.24664895e-01f, 2.52676010e-01f, 1.24039777e-01f, 1.75899640e-01f,
  -9.76494700e-02f, 6.92722797e-02f, 1.57601416e-01f, -2.82605123e-02f, -6.98495135e-02f, -7.33492151e-02f, 2.48517051e-01f, -1.21178240e-01f, 1.08142442e-03f, 2.10823476e-01f,
  -7.70727992e-02f, 3.43570262e-02f, -3.81094925e-02f, -8.71235225e-03f, 1.31589979e-01f, 8.24587941e-02f, 1.01332523e-01f, 4.18379419e-02f, -1.87146544e-01f, 7.55689070e-02f,
  2.16188848e-01f, -1.30710071e-02f, -2.55004857e-02f, 1.67227117e-03f, -1.91764548e-01f, 8.35687220e-02f, 2.94111818e-02f, 1.48989290e-01f, -7.46550635e-02f, -8.75370130e-02f,
  -1.06492937e-01f, 1.38666987e-01f, 1.28681570e-01f, 7.43375868e-02f, 5.90001233e-02f, 7.53561854e-02f, -1.45262197e-01f, 8.62498656e-02f, 1.99530438e-01f, 2.64031515e-02f,
  -1.48452908e-01f, 1.47014260e-01f, 1.57366276e-01f, 3.11753154e-03f, -1.17737830e-01f, -1.96756080e-01f, -1.16400614e-01f, -6.16822839e-02f, -2.88719479e-02f, 1.74203917e-01f,
  8.31587911e-02f, -1.94395259e-01f, -4.28425707e-02f, 2.38243535e-01f, -5.24100363e-02f, 2.94499602e-02f, 6.23427592e-02f, -3.41432914e-02f, 2.92802807e-02f, 2.79478073e-01f,
  1.22562833e-01f, 2.47578204e-01f, 2.70002782e-01f, 3.09216917e-01f, 1.12969279e-01f, 7.34735699e-03f, 1.54155865e-01f, 6.82905167e-02f, 2.67991964e-02f, 1.73098922e-01f,
  1.36743695e-01f, 1.42484959e-02f, 2.12897360e-01f, 1.34590775e-01f, -4.77925092e-02f, -2.98420172e-02f, -4.32003289e-02f, 2.40832448e-01f, 2.70227110e-03f, 5.89884957e-03f,
  6.92129433e-02f, -7.34324381e-02f, -2.11419091e-01f, 5.79494424e-02f, 1.30576134e-01f, 2.48890687e-02f, -1.05828837e-01f, 1.53078698e-02f, -6.34801909e-02f, 3.31355274e-01f,
  3.55986990e-02f, 8.32659099e-03f, 3.35222870e-01f, -1.84159532e-01f, -1.08490154e-01f, 2.01694384e-01f, -3.65353413e-02f, -1.86656918e-02f, -7.67244250e-02f, -1.09768532e-01f,
  -1.35011911e-01f, -2.12956127e-03f, -1.06983215e-01f, -1.58786044e-01f, 2.39754185e-01f, 1.35774717e-01f, 7.57986754e-02f, 3.09718877e-01f, -1.89998239e-01f, 1.59472302e-01f,
  1.48068368e-01f, -9.69416946e-02f, 1.29145160e-01f, 6.60772249e-02f, -6.23532236e-02f, 6.83309436e-02f, 1.66016459e-01f, 9.33809802e-02f, -8.45367461e-02f, 1.31219104e-01f,
  9.64275450e-02f, -1.54315665e-01f, -4.39656228e-02f, -9.50704794e-03f, 7.27688242e-03f, 3.45304869e-02f, 3.96029763e-02f, -9.34008807e-02f, -1.00094065e-01f, -5.26751438e-03f,
  1.20298058e-01f, -4.39705290e-02f, 1.95009157e-01f, -1.02856651e-01f, -2.68432051e-01f, 3.40122245e-02f, 2.32523233e-01f, -3.03123537e-02f, 1.11008272e-01f, 2.39303708e-01f,
  9.45808366e-02f, 2.68430352e-01f, -3.51201929e-02f, 3.91222723e-03f, -6.37334064e-02f, 3.24313819e-01f, 8.36969074e-03f, -3.88909541e-02f, 8.95140767e-02f, 1.10417724e-01f,
  1.20763540e-01f, -1.73033372e-01f, 1.19431496e-01f, 1.57673866e-01f, 5.75536340e-02f, -1.72823191e-01f, 1.57841772e-01f, -1.51881397e-01f, -9.77119505e-02f, -2.11475760e-01f,
  -3.36346440e-02f, -1.72937945e-01f, -5.98068684e-02f, -2.63017088e-01f, -2.79700831e-02f, 9.85731855e-02f, 1.41719609e-01f, -1.53334066e-01f, 3.41640264e-01f, 1.75679356e-01f,
  -7.06535801e-02f, 1.86249107e-01f, -1.99646756e-01f, 8.79766867e-02f, 3.24038655e-01f, 1.96513683e-02f, 5.70449904e-02f, 1.41391367e-01f, -1.90029100e-01f, -1.19123226e-02f,
  5.16512580e-02f, 2.05977306e-01f, -8.99396986e-02f, 1.05601855e-01f, -5.66237494e-02f, 2.34631106e-01f, -7.65622929e-02f, 1.22192718e-01f, -7.56400079e-02f, 1.72373019e-02f,
  6.27991259e-02f, 1.70469344e-01f, 1.68996304e-01f, 5.32620847e-02f, -9.38125178e-02f, 8.92012790e-02f, -1.46355361e-01f, 2.19217092e-02f, -3.00611127e-02f, 8.83615986e-02f,
  3.54695250e-03f, -4.81158122e-03f, -5.90992272e-02f, 1.54142305e-01f, 1.60174537e-02f, 5.55150285e-02f, 2.89814919e-01f, 2.44668037e-01f, -1.35062292e-01f, -1.14073016e-01f,
  -2.93525219e-01f, 1.49193123e-01f, 1.02644429e-01f, -1.11244552e-01f, -2.14393750e-01f, -3.55889291e-01f, -6.17279392e-03f, -1.69872921e-02f, 1.83054551e-01f, 2.33902216e-01f,
  2.19953761e-01f, 1.31522447e-01f, 1.76602602e-01f, -1.79533452e-01f, 2.06889316e-01f, 3.85618269e-01f, 1.18428886e-01f, 1.09836951e-01f, -1.60119906e-01f, 2.85720199e-01f,
  -1.91879883e-01f, 9.19499472e-02f, -3.94696370e-02f, 1.53167382e-01f, 2.18990475e-01f, 9.36998948e-02f, -3.14479601e-03f, 1.97338372e-01f, -1.81188267e-02f, -3.01328171e-02f,
  1.16121210e-01f, -4.57752403e-03f, 2.93456428e-02f, 3.05845201e-01f, 1.18181251e-01f, 2.23904535e-01f, -1.53427035e-01f, 2.10389882e-01f, 2.22926468e-01f, -5.96705787e-02f,
  3.63449268e-02f, -1.48675084e-01f, 1.37741774e-01f, 1.40175834e-01f, 2.09006369e-01f, 3.45149517e-01f, 2.31813505e-01f, 4.07429636e-02f, 7.39627182e-02f, -1.54875711e-01f,
  1.38722554e-01f, 3.29575330e-01f, 1.38310790e-01f, -1.39385700e-01f, 2.03754127e-01f, 9.58098695e-02f, -1.20673925e-01f, 8.22719708e-02f, -1.85853571e-01f, -5.18797114e-02f,
  3.05717327e-02f, 1.03666913e-02f, 2.09010750e-01f, -1.39073461e-01f, 1.48266688e-01f, 7.03593194e-02f, 1.49879038e-01f, -7.20642284e-02f, -1.93033561e-01f, 6.51800493e-03f,
  3.61641705e-01f, 4.02305216e-01f, 1.72829971e-01f, 4.30126369e-01f, 1.69451756e-04f, 6.77283704e-02f, 6.38611615e-02f, 2.13434637e-01f, 1.02381453e-01f, -3.72663774e-02f,
  -1.93779054e-03f, 1.46613084e-02f, -1.05958991e-01f, -2.21270114e-01f, -7.20257610e-02f, -1.39138311e-01f, 1.99555144e-01f, -6.69304058e-02f, 5.57633564e-02f, 4.10925932e-02f,
  2.54330069e-01f, -1.78426560e-02f, -8.21064487e-02f, -1.08408101e-01f, -4.44310419e-02f, 2.39644900e-01f, 1.97333358e-02f, 2.32556229e-03f, -1.26921665e-02f, 3.88656408e-02f,
  -5.21703921e-02f, -3.04192230e-02f, 1.30202964e-01f, -2.80325085e-01f, 1.87701955e-01f, -9.96625945e-02f, -1.47888690e-01f, -1.66841019e-02f, 7.55007192e-02f, 1.05022617e-01f,
  1.32197633e-01f, 7.83890672e-03f, 1.98236227e-01f, -1.16723232e-01f, -9.90973786e-03f, -1.28723636e-01f, -1.07772768e-01f, -3.91415916e-02f, -1.03707559e-01f, 2.26199567e-01f,
  1.04410470e-01f, 3.75894666e-01f, -3.50692347e-02f, 3.48626599e-02f, 3.17052156e-02f, 3.28347683e-01f, 1.67544037e-01f, 2.13895634e-01f, -1.71062816e-02f, -3.85605209e-02f,
  1.71430320e-01f, -1.03957884e-01f, -2.22260579e-01f, -7.03859180e-02f, -2.85268694e-01f, -1.60547242e-01f, -2.40650568e-02f, -1.42518729e-02f, 7.54208341e-02f, -9.50069651e-02f,
  1.56592309e-01f, -1.20383412e-01f, 9.45358723e-02f, 1.62529927e-02f, 6.22913381e-03f, -1.82747662e-01f, 5.96354567e-02f, -9.50546749e-03f, 1.49863496e-01f, -1.37423784e-01f,
  1.93898205e-03f, 1.84496775e-01f, 4.78942133e-03f, 3.33033167e-02f, 4.00275327e-02f, 2.51686014e-02f, 1.49578452e-02f, 7.10224286e-02f, 2.48158842e-01f, 1.92431539e-01f,
  -1.79416761e-01f, 3.25770199e-01f, 1.63828328e-01f, 2.15951651e-01f, 1.32346034e-01f, 1.69032458e-02f, -8.67378898e-03f, -1.25032499e-01f, 1.70133978e-01f, 8.58829096e-02f,
  2.06768021e-01f, 2.45607957e-01f, -9.14671458e-03f, 9.31717753e-02f, -5.58003783e-02f, 6.06613085e-02f, 1.53330818e-01f, 8.45423117e-02f, -4.23547253e-02f, -9.55633596e-02f,
  1.56845704e-01f, -3.59131210e-02f, -7.26992041e-02f, 2.27260724e-01f, 2.47927755e-02f, 5.59946485e-02f, 9.73567516e-02f, -9.29790176e-03f, 2.62923073e-02f, 8.57693180e-02f,
  2.41209239e-01f, 1.82471573e-01f, -7.65599404e-03f, 3.27449217e-02f, 1.94511607e-01f, 1.54027343e-01f, 1.85989231e-01f, 2.47105822e-01f, -3.13496023e-01f, -9.02806520e-02f,
  -1.64180005e-03f, -1.48215026e-01f, -5.55847548e-02f, 5.69541417e-02f, 5.29326089e-02f, 2.53007829e-01f, -8.02746695e-03f, 1.68835476e-01f, -6.86197877e-02f, 1.50800094e-01f,
  1.37885422e-01f, 1.70004979e-01f, 2.25131154e-01f, 2.18613908e-01f, -7.96685368e-02f, 7.97027797e-02f, 7.07549080e-02f, 4.33408953e-02f, -1.07066713e-01f, 2.34536976e-02f,
  -6.04181215e-02f, -8.12684931e-03f, -5.78507371e-02f, -2.78990250e-02f, 1.59481063e-01f, -5.28036198e-03f, 1.19251855e-01f, 1.59709156e-01f, 1.64880916e-01f, 2.88236234e-02f,
  -6.12619743e-02f, 2.32997343e-01f, -1.11770220e-02f, 2.15986580e-01f, 1.87378660e-01f, 1.82660699e-01f, 1.16880298e-01f, 1.63832486e-01f, -5.30879200e-02f, 1.31035715e-01f,
  -2.57092286e-02f, 2.04223856e-01f, -1.89911246e-01f, -1.64859891e-01f, 1.94357142e-01f, -5.93446866e-02f, 7.32216686e-02f, 1.27545610e-01f, -7.60933608e-02f, 1.12962713e-02f,
  1.96245253e-01f, -3.31799388e-02f, 1.66283146e-01f, 3.76998112e-02f, 5.61641194e-02f, -1.68333083e-01f, -2.53368765e-01f, 5.53058945e-02f, 2.29772508e-01f, 3.49966660e-02f,
  1.21414468e-01f, 1.52961463e-01f, -1.87966451e-01f, 8.16556450e-04f, -9.47900489e-03f, -1.20333135e-02f, -1.53863998e-02f, 3.28975059e-02f, -1.31048352e-01f, 2.34451026e-01f,
  -8.90480503e-02f, 3.06866109e-01f, 3.76247764e-02f, 3.43131185e-01f, -1.53320149e-01f, 3.23844045e-01f, -3.96314915e-03f, 4.04651165e-01f, -7.03167468e-02f, 7.16496110e-02f,
  3.54371816e-01f, 8.47057775e-02f, -1.75891832e-01f, -4.96081039e-02f, -8.01787376e-02f, 6.30349144e-02f, -5.90262823e-02f, -3.44359912e-02f, 2.74304956e-01f, -1.19958282e-01f,
  1.18047848e-01f, 1.77830145e-01f, -5.62888868e-02f, 1.10457763e-01f, 8.94176066e-02f, 2.16914132e-01f, -7.88292512e-02f, 1.80651858e-01f, 1.47976622e-01f, 1.44659474e-01f,
  1.04036801e-01f, 6.76294193e-02f, 2.44212791e-01f, 1.68540329e-01f, -1.16099775e-01f, 6.43327311e-02f, -1.62025243e-01f, 2.28492528e-01f, -3.92361656e-02f, 1.67537883e-01f,
  2.15444744e-01f, -4.58175503e-02f, -8.38146266e-03f, -6.45609424e-02f, -4.10383679e-02f, 1.74698681e-01f, 2.18280375e-01f, -3.02784704e-02f, -3.14182118e-02f, -8.97510126e-02f,
  1.37376100e-01f, 8.32948014e-02f, -2.79156536e-01f, -3.62278498e-03f, 1.49139777e-01f, 3.96865904e-02f, -1.15453407e-01f, -6.42852783e-02f, -9.70976651e-02f, -1.67150527e-01f,
  2.31715530e-01f, 1.60038069e-01f, 3.03095162e-01f, 3.79866138e-02f, -7.14822710e-02f, 1.95002556e-01f, -1.51623622e-01f, 1.53424650e-01f, 2.21660107e-01f, 1.82270914e-01f,
  -2.07115963e-01f, 2.27438509e-01f, 1.57790065e-01f, -1.01646140e-01f, 1.23875691e-02f, 7.05302283e-02f, -3.69010754e-02f, 3.83401722e-01f, 1.29379839e-01f, -3.33514102e-02f,
  4.68726233e-02f, -1.39976695e-01f, 1.09789126e-01f, 2.37694457e-01f, 9.99475196e-02f, -2.07751453e-01f, 8.42285603e-02f, 5.78704700e-02f, 1.52026489e-02f, 1.61298469e-01f,
  -2.03276556e-02f, -2.61293888e-01f, -5.64115345e-02f, 4.82626371e-02f, 8.29164907e-02f, -7.23193213e-03f, -1.53665736e-01f, 8.69493000e-03f, 1.79434821e-01f, 2.22030887e-03f,
  5.65044694e-02f, -8.19197670e-02f, -1.63217321e-01f, -1.30954534e-01f, 1.55843839e-01f, 2.50279494e-02f, 1.07157022e-01f, -3.27457972e-02f, 2.06116408e-01f, 8.20107684e-02f,
  -1.98734462e-01f, -2.18960550e-02f, 7.38701969e-02f, 2.00059667e-01f, -4.19883942e-03f, -4.73230612e-03f, 8.35441351e-02f, 1.40904158e-01f, -1.06063962e-01f, 1.02685474e-01f,
  -5.38287160e-04f, 2.29222089e-01f, 1.96223691e-01f, -1.04862824e-01f, -1.67823821e-01f, -2.37647481e-02f, -1.04526088e-01f, 1.49388731e-01f, -1.09165415e-01f, -1.10090911e-01f,
  8.76624659e-02f, -8.27361643e-02f, -1.64590850e-01f, 8.27283487e-02f, 1.06692679e-01f, -9.38652828e-02f, 1.77669197e-01f, 9.06539485e-02f, -6.54624179e-02f, 6.89203590e-02f,
  -1.92203194e-01f, -1.36722431e-01f, 4.37473170e-02f, 3.51924784e-02f, -8.86528566e-02f, 4.29802053e-02f, -2.12599728e-02f, -8.01591501e-02f, 1.98548660e-01f, 1.37704432e-01f,
  -1.00584142e-01f, 5.32692224e-02f, -1.00105733e-01f, -4.54655997e-02f, -1.28887802e-01f, 2.38320127e-01f, 1.03820525e-01f, 3.90989445e-02f, -1.06296502e-02f, 1.54176012e-01f,
  -7.29342476e-02f, 1.71681374e-01f, 1.06532546e-02f, 8.01958293e-02f, -9.94488820e-02f, -3.47423507e-03f, 3.28607708e-02f, 1.09077886e-01f, -1.40228540e-01f, 6.90499321e-02f,
  1.33725733e-01f, -2.48470560e-01f, 1.66926548e-01f, -1.09507278e-01f, 1.81496926e-02f, -1.12093098e-01f, 6.33985177e-02f, -1.16552472e-01f, 7.82632381e-02f, 2.73092598e-01f,
  6.61479533e-02f, 5.44805117e-02f, 6.31673783e-02f, 3.97411615e-01f, -1.13972723e-01f, -7.38970116e-02f, 1.83167651e-01f, 5.22957854e-02f, -1.92344919e-01f, 3.38664740e-01f,
  5.35463467e-02f, 2.16775462e-01f, 2.04121023e-02f, -1.24618195e-01f, 3.10855687e-01f, -7.25970417e-02f, 2.50711203e-01f, -3.25905889e-01f, 3.78054120e-02f, 2.51586229e-01f,
  -3.36597264e-02f, -1.40413299e-01f, -7.08179474e-02f, -4.13733236e-02f, -3.75727974e-02f, -1.04247510e-01f, 4.80699092e-02f, 2.87754893e-01f, -2.56658662e-02f, 1.04096889e-01f,
  2.83278614e-01f, 6.82389215e-02f, 3.53166945e-02f, -1.38460949e-01f, 2.59776898e-02f, 3.14238891e-02f, 1.37652531e-01f, -2.04802126e-01f, -1.94773108e-01f, 8.50536674e-02f,
  1.95562631e-01f, 2.13904172e-01f, 2.86934346e-01f, 3.19407731e-01f, 3.37918371e-01f, 2.24066660e-01f, -8.29759017e-02f, -8.36425985e-04f, -2.88309723e-01f, 2.28772312e-02f,
  1.62414446e-01f, 1.57271922e-01f, 1.92540407e-01f, 1.43747032e-02f, -1.09229364e-01f, 7.21672252e-02f, 2.80116983e-02f, 7.40516484e-02f, 2.93930084e-01f, -8.97146016e-02f,
  -7.27371722e-02f, -1.98544100e-01f, -2.20436957e-02f, 1.43934548e-01f, 9.61170942e-02f, 1.08624026e-01f, 1.87771067e-01f, 9.68604535e-02f, -1.51406676e-01f, -1.33347986e-02f,
  4.34226803e-02f, 1.04277030e-01f, 2.09429756e-01f, 2.03512549e-01f, 2.62933612e-01f, 6.42667012e-03f, 9.90193486e-02f, 4.01776195e-01f, 4.31724079e-02f, 1.00189716e-01f,
  1.92728043e-01f, 1.40758500e-01f, -2.21629918e-01f, 3.09134722e-01f, 1.72592983e-01f, -1.19347554e-02f, 3.62266123e-01f, 5.23603484e-02f, -7.45323449e-02f, 3.28959882e-01f,
  1.25920117e-01f, 1.10896371e-01f, 9.08882543e-02f, -1.60912294e-02f, 1.99142709e-01f, 2.58326650e-01f, 1.88252504e-03f, 1.46641791e-01f, -1.75974015e-02f, 1.41995430e-01f,
  1.90857306e-01f, 1.19832225e-01f, -1.36650190e-01f, -1.69825196e-01f, -8.34396482e-02f, 1.84033811e-02f, -3.93668599e-02f, 2.89425571e-02f, -1.47938192e-01f, 1.63159370e-02f,
  -1.12375893e-01f, 1.77967474e-01f, 3.89955044e-02f, -4.58886754e-03f, -1.34485230e-01f, 1.86033752e-02f, -3.70726287e-02f, 1.98465623e-02f, 9.51142013e-02f, -2.06358090e-01f,
  1.76278293e-01f, -4.03309278e-02f, 8.51871893e-02f, -3.41472179e-02f, -6.41000122e-02f, -1.37123317e-01f, -7.07581714e-02f, 2.60036767e-01f, -8.11318774e-03f, -5.06328000e-03f,
  -6.73965141e-02f, 2.31573954e-01f, 5.84392138e-02f, 1.54891372e-01f, 1.61783099e-01f, 2.32854351e-01f, -7.96100646e-02f, 1.91615254e-01f, -1.55266985e-01f, 5.37575409e-02f,
  3.97279598e-02f, -1.25249535e-01f, 3.41779113e-01f, -4.94273864e-02f, 6.87384382e-02f, -1.90776169e-01f, -1.42002413e-02f, 2.31000856e-01f, -2.96731647e-02f, -6.54545650e-02f,
  -1.03997499e-01f, -3.05868238e-02f, -5.00276731e-03f, -1.25606880e-01f, 7.80843422e-02f, 2.39807338e-01f, 9.91780907e-02f, 4.97673489e-02f, 1.84905559e-01f, -3.56690325e-02f,
  6.58421293e-02f, -8.31639245e-02f, -8.19742233e-02f, 1.31852448e-01f, 2.31194198e-01f, -2.01262355e-01f, -1.02492929e-01f, 4.44357842e-02f, -1.11769743e-01f, -2.34739669e-02f,
  5.76848648e-02f, 7.76827559e-02f, 1.84520975e-01f, 5.30045368e-02f, -9.85320583e-02f, -1.53535428e-02f, 1.93933286e-02f, -1.51625827e-01f, 2.34558135e-01f, 5.48624136e-02f,
  -1.05265781e-01f, 2.74516016e-01f, 8.68148450e-03f, 1.14018731e-01f, -6.00400567e-02f, -4.74998765e-02f, 2.65493214e-01f, 6.90321624e-02f, 2.20740438e-02f, 2.16016881e-02f,
  -2.29810655e-01f, 2.04811305e-01f, 1.43712133e-01f, -2.98117161e-01f, 9.48595721e-03f, -5.77201322e-02f, -1.22580186e-01f, -2.91703612e-01f, 3.54519077e-02f, 1.57051593e-01f,
  -4.81233047e-03f, 5.91089483e-03f, -2.64145732e-02f, -1.35603696e-01f, 3.00532639e-01f, 8.47227797e-02f, 1.30994841e-01f, 4.45290618e-02f, 1.55240400e-02f, -1.48909122e-01f,
  1.62166625e-01f, 2.20404074e-01f, -4.66054305e-02f, -3.62827443e-02f, 9.94794071e-02f, 4.36978005e-02f, 1.05702356e-01f, -9.99461561e-02f, -1.57521605e-01f, 1.41398003e-02f,
  1.40908793e-01f, 2.24939540e-01f, 1.09153509e-01f, 3.69201787e-02f, -1.63222685e-01f, 2.79500689e-02f, 1.34206399e-01f, -6.30035996e-02f, 6.51450455e-02f, -2.26283222e-01f,
  1.21705033e-01f, -8.89913179e-03f, 1.18879601e-01f, 1.70015916e-01f, 1.79594666e-01f, 3.08295101e-01f, 2.02809691e-01f, 8.46090391e-02f, 2.30269879e-01f, -2.01654717e-01f,
  -7.91259557e-02f, 8.50830153e-02f, -2.98731569e-02f, 1.89549308e-02f, 3.13707963e-02f, 8.94335210e-02f, -4.69838120e-02f, 1.49110481e-01f, -3.55371870e-02f, 1.34555608e-01f,
  -5.95437288e-02f, 5.72109222e-02f, 1.90541744e-01f, 9.56806615e-02f, 1.17409617e-01f, -7.71364793e-02f, 1.93460971e-01f, 1.65225223e-01f, 3.90267335e-02f, 2.11763382e-02f,
  -1.99182421e-01f, 1.52967662e-01f, -9.13652778e-03f, -1.15567418e-02f, 9.15561467e-02f, -5.15378639e-02f, 2.94141650e-01f, 1.33687168e-01f, -1.81176513e-02f, 2.58514918e-02f,
  -9.75336954e-02f, -2.16139764e-01f, 5.21531552e-02f, -5.28997704e-02f, -5.74394129e-02f, -2.37458915e-01f, 1.05039716e-01f, 1.39372334e-01f, 6.00292236e-02f, 1.46976277e-01f,
  -7.48720914e-02f, 1.15526296e-01f, 1.37439236e-01f, -1.48139030e-01f, 5.94530925e-02f, 1.40134275e-01f, -3.69381644e-02f, 1.84693485e-01f, 1.23033285e-01f, 9.83120650e-02f,
  -5.91349928e-03f, 6.21732464e-03f, 1.03941001e-01f, -3.30887362e-02f, -5.53035177e-02f, 1.13024294e-01f, 1.34259582e-01f, 9.23999399e-02f, 2.03353733e-01f, -4.52102311e-02f,
  -1.03698097e-01f, 4.97642457e-02f, 3.82973254e-02f, 1.07837319e-01f, 3.42658609e-02f, -1.33191809e-01f, -2.10025460e-01f, 2.67044152e-03f, 2.32098922e-01f, -1.08124383e-01f,
  1.95887163e-01f, -4.96706143e-02f, 2.77398646e-01f, 2.96312124e-01f, 5.73239736e-02f, -1.34264082e-01f, -1.90710947e-01f, 2.22777829e-01f, -4.38718833e-02f, 5.95621392e-02f,
  2.79973280e-02f, 2.32476294e-01f, 2.65218556e-01f, 1.40924022e-01f, 8.52322057e-02f, 8.69103074e-02f, 2.19970960e-02f, -2.76515692e-01f, 1.14171669e-01f, -2.09082253e-02f,
  -9.96838957e-02f, -6.57572150e-02f, -1.72128245e-01f, -1.56167373e-01f, -6.46311045e-02f, -1.52977109e-01f, 1.00236222e-01f, 5.13672568e-02f, -7.51437992e-03f, 1.38803095e-01f,
  4.25134063e-01f, 9.11578834e-02f, -7.35663027e-02f, 1.65708825e-01f, -3.24575514e-01f, 1.56474173e-01f, 3.65589410e-01f, 1.97237507e-01f, 1.01017149e-03f, -8.23473334e-02f,
  1.33886486e-01f, -1.26611307e-01f, -7.53000379e-02f, 5.84674142e-02f, -1.80515856e-01f, 1.02535367e-01f, -9.88984033e-02f, 3.11364681e-01f, -2.35705301e-01f, 1.10031292e-01f,
  2.78286412e-02f, 2.39426419e-02f, 1.03587084e-01f, 2.36976802e-01f, 1.58083692e-01f, 9.51115564e-02f, 7.75370374e-02f, -1.39224276e-01f, 7.91895986e-02f, 1.97157875e-01f,
  3.80316861e-02f, -7.24236593e-02f, -9.66816247e-02f, 8.76488760e-02f, -1.07892184e-02f, 8.14115331e-02f, 2.86243130e-02f, -1.46247847e-02f, -8.21206123e-02f, 1.40079886e-01f,
  1.06813394e-01f, -1.30016938e-01f, 1.34793133e-01f, 2.66960766e-02f, 1.64987400e-01f, 5.74011207e-02f, -1.64651081e-01f, 2.07463861e-01f, 1.49230003e-01f, 2.88069814e-01f,
  1.76565573e-01f, 2.71168083e-01f, 1.12548105e-01f, 1.60820279e-02f, -2.53280438e-02f, 1.52302250e-01f, 1.11004904e-01f, -5.10006957e-02f, 1.53734311e-01f, -1.18013322e-01f,
  -6.27085119e-02f, -1.62968740e-01f, -6.51688501e-02f, -1.82123125e-01f, -3.77343222e-02f, 1.29777595e-01f, 1.05046213e-01f, 9.57292914e-02f, 1.20643616e-01f, -5.35209365e-02f,
  -2.12890897e-02f, 4.67940196e-02f, 2.82754842e-02f, 1.27076760e-01f, -3.59673030e-03f, 1.04733191e-01f, 2.24307328e-01f, 1.16272494e-01f, 3.40610184e-02f, 9.54415202e-02f,
  2.11669981e-01f, -2.04218060e-01f, 1.84645087e-01f, 6.20063115e-03f, 1.30134135e-01f, 2.00117305e-01f, 5.04434891e-02f, -1.96246784e-02f, -1.66272521e-02f, 6.43711910e-02f,
  4.67021279e-02f, -2.79107643e-03f, 1.65898219e-01f, 1.12982638e-01f, 1.85677916e-01f, -5.39385267e-02f, 8.95164609e-02f, 8.84318650e-02f, -3.26116681e-02f, -3.16285081e-02f,
  -1.47263691e-01f, 8.22204724e-02f, -1.13476425e-01f, -9.60902274e-02f, 2.51431286e-01f, 1.84537366e-01f, 1.02589987e-01f, 3.92772406e-02f, 1.38961608e-02f, 1.58088341e-01f,
  1.11570969e-01f, 1.17105894e-01f, 2.82502502e-01f, 3.48535985e-01f, 6.18304126e-02f, 2.18645096e-01f, 4.58995737e-02f, -6.68497011e-02f, -1.85859501e-01f, 2.67866403e-01f,
  1.51948621e-02f, -2.34391600e-01f, -1.64378449e-01f, 1.24850728e-01f, -2.77057551e-02f, -1.50346607e-01f, 1.72744006e-01f, -1.94920778e-01f, 2.58576823e-03f, -4.31892797e-02f,
  -7.90151432e-02f, 1.08182982e-01f, 1.66655406e-01f, 6.74666762e-02f, 1.09782264e-01f, -9.13031548e-02f, -7.76064117e-03f, 6.62835389e-02f, -1.08786672e-01f, -2.23568812e-01f,
  -8.90015718e-03f, -7.46696070e-02f, 1.08722463e-01f, -2.20737271e-02f, -1.88291352e-02f, 1.30430982e-01f, 2.71667629e-01f, 5.83720468e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  -8.88462439e-02f, 9.84737948e-02f, 5.65200709e-02f, 4.41664159e-02f, -1.96960792e-02f, 2.90582534e-02f, 2.46049911e-01f, 1.68425009e-01f, 6.37741759e-02f, 4.99624163e-02f,
  8.10443237e-02f, 9.10530761e-02f, 8.88279229e-02f, 1.40224978e-01f, 3.21279205e-02f, 1.59685865e-01f, 5.68864085e-02f, 7.24965706e-02f, 6.18433245e-02f, 9.99194682e-02f,
  8.50262940e-02f, 9.03666988e-02f, 3.47496755e-02f, 5.82738630e-02f, 1.38489977e-01f, 1.77772455e-02f, 1.11638777e-01f, 2.16861188e-01f, 8.57444555e-02f, -5.45133837e-02f,
  -2.25283112e-03f, 1.30493984e-01f, 9.02816653e-02f, 9.50802937e-02f, 1.33005753e-01f, 4.76323590e-02f, -8.33845139e-03f, -1.39694409e-02f, 1.04448244e-01f, 6.60952330e-02f,
  3.11031267e-02f, 1.82395443e-01f, 1.08256593e-01f, 3.20435427e-02f, 5.68789355e-02f, 2.06281021e-01f, 1.94619072e-03f, 3.30748297e-02f, 9.75567102e-02f, 1.06391400e-01f,
  7.37891719e-02f, 8.93332660e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -2.92603135e-01f, -4.04547900e-01f, -1.35842398e-01f, -5.86612299e-02f, -5.77456839e-02f, -3.01429987e-01f, 2.99773455e-01f, 1.60099402e-01f, 1.24567069e-01f, 1.25323087e-02f,
  2.91187614e-01f, -1.41460389e-01f, 6.61676884e-01f, 3.04734319e-01f, 3.86403888e-01f, 6.71787336e-02f, 1.41643927e-01f, 2.54228771e-01f, -9.92510021e-02f, -3.51690471e-01f,
  -4.30087328e-01f, 2.41626531e-01f, -1.64478227e-01f, 2.22483069e-01f, -4.84024286e-01f, -2.47934703e-02f, -3.52457762e-01f, 3.65033507e-01f, -8.99912640e-02f, -3.18199635e-01f,
  1.60765931e-01f, 1.29549508e-03f, -3.55159417e-02f, 6.34649396e-02f, -1.54389873e-01f, -6.55576065e-02f, -2.01417193e-01f, 7.97450077e-03f, -4.42563355e-01f, -3.91732991e-01f,
  -2.54278928e-01f, 2.24948451e-02f, -2.26785332e-01f, 9.61803198e-02f, 2.50883371e-01f, 1.56677246e-01f, 1.66887790e-01f, -1.87659994e-01f, -3.32740247e-02f, -3.80002975e-01f,
  -1.23769782e-01f, 2.95213133e-01f, 1.74819365e-01f, -2.03328118e-01f, -3.27170908e-01f, -5.76493926e-02f, -1.37340352e-01f, -5.55530369e-01f, -3.50918800e-01f, 3.43045741e-01f,
  3.32942493e-02f, -2.97366649e-01f, -4.80201952e-02f, 1.95750624e-01f, -1.86336637e-02f, 2.71088421e-01f, -1.66364774e-01f, -2.89256684e-03f, -1.13659622e-02f, 1.65023997e-01f,
  4.12749738e-01f, 6.43147603e-02f, 4.04624715e-02f, -1.51444793e-01f, -2.94116437e-01f, -8.40111375e-02f, -4.23026294e-01f, 3.50000039e-02f, 1.75928008e-02f, 2.09672347e-01f,
  1.85227022e-01f, 3.34905945e-02f, -5.72277665e-01f, -3.94879043e-01f, 1.46955177e-01f, 1.50756955e-01f, -9.08565894e-02f, -1.94963679e-01f, -9.38524529e-02f, -1.20392308e-01f,
  -7.20239878e-01f, 6.93478435e-02f, 1.78101435e-01f, -1.60938427e-01f, 9.63679105e-02f, 1.75741047e-01f, 6.05562925e-02f, 1.97437704e-01f, -4.77644913e-02f, 2.78927565e-01f,
  1.23943619e-01f, 3.97224277e-01f, -1.17977567e-01f, -3.48967165e-01f, -1.34585053e-01f, 2.43178099e-01f, 5.80776995e-03f, -3.20745975e-01f, 8.25075284e-02f, -4.25015748e-01f,
  6.14192449e-02f, -9.14745629e-02f, 2.31494233e-01f, -8.53603110e-02f, -4.88146245e-01f, 1.33237377e-01f, 1.23256773e-01f, 2.41455194e-02f, -4.76403087e-01f, 3.40589464e-01f,
  2.64977347e-02f, -1.92431733e-01f, 1.19543664e-01f, -2.73461729e-01f, 8.68331045e-02f, 1.39660865e-01f, -5.85825257e-02f, -1.51407391e-01f, -1.54314106e-02f, -4.58048508e-02f,
  1.47283033e-01f, -7.85002112e-02f, -1.61273405e-01f, -1.40501916e-01f, -4.22089770e-02f, -2.09697157e-01f, -7.56658465e-02f, -2.96778008e-02f, 1.17024571e-01f, 7.87066743e-02f,
  -1.62621468e-01f, -4.47942108e-01f, -4.82278854e-01f, -1.66537777e-01f, 1.85437098e-01f, -3.80166918e-01f, -3.69535804e-01f, -3.94114017e-01f, 2.79082537e-01f, -3.51553202e-01f,
  -8.41819569e-02f, -3.72496009e-01f, -2.78924316e-01f, -3.26339990e-01f, -3.26813698e-01f, -4.67082381e-01f, -1.62865557e-02f, -1.03625275e-01f, -3.82440351e-02f, -7.26032406e-02f,
  -1.14639610e-01f, -3.52197647e-01f, -3.10506731e-01f, 2.20079735e-01f, 5.70307709e-02f, 1.81048155e-01f, 1.96799025e-01f, -8.40899348e-02f, 2.79355377e-01f, 2.69182444e-01f,
  1.90210074e-01f, 2.81784147e-01f, -3.43980163e-01f, 3.39036822e-01f, -2.09410757e-01f, 2.48819292e-02f, 1.89475656e-01f, -2.94614434e-01f, -2.61783600e-01f, -3.87167215e-01f,
  3.42089832e-02f, -1.14268839e-01f, 1.69827312e-01f, -3.83888632e-01f, -3.05728853e-01f, 2.22928584e-01f, -3.41968209e-01f, -2.04266638e-01f, 1.05380028e-01f, 2.73065478e-01f,
  -4.43771005e-01f, 2.42877811e-01f, -2.31399946e-02f, -1.71720862e-01f, 7.68660381e-02f, -1.00401044e-01f, 2.78820656e-02f, 1.98743492e-01f, -1.10422134e-01f, 1.26445815e-01f,
  4.56120931e-02f, 3.84269357e-01f, 3.54768813e-01f, -1.40922263e-01f, -3.18993509e-01f, 9.88306850e-02f, 2.25553885e-01f, -2.05192775e-01f, -3.79518360e-01f, 1.99150741e-01f,
  2.28331804e-01f, 1.88662037e-01f, -3.73587400e-01f, 2.08781973e-01f, 5.77280760e-01f, -1.53833508e-01f, -3.61665845e-01f, 2.34733373e-01f, 1.40223265e-01f, 2.87193447e-01f,
  2.89377093e-01f, 8.36065933e-02f, -4.07399952e-01f, -4.12268728e-01f, -1.89019963e-01f, 3.20643395e-01f, 1.74901858e-01f, -9.07407254e-02f, -3.80965382e-01f, -1.01256631e-01f,
  2.59223636e-02f, 2.02245370e-01f, 4.07135822e-02f, 6.12151169e-04f, -5.00072002e-01f, 1.23414703e-01f, 1.53978184e-01f, 6.14160933e-02f, -2.33917937e-01f, -3.60971838e-01f,
  -1.97935104e-01f, -2.91974366e-01f, 1.67422295e-01f, -3.03200066e-01f, -5.21325052e-01f, -5.15659988e-01f, -3.02413732e-01f, -1.59065098e-01f, -3.22928399e-01f, -5.32303751e-01f,
  -1.09055251e-01f, -3.33473951e-01f, -2.55007893e-01f, -5.53106844e-01f, 2.01260388e-01f, 2.81086147e-01f, 1.40839994e-01f, 6.82207718e-02f, 1.69652309e-02f, 2.36367315e-01f,
  1.04691543e-01f, -4.97804172e-02f, 8.36979672e-02f, 8.57413262e-02f, -1.91992596e-01f, 3.49946395e-02f, -7.44387798e-04f, -2.84699529e-01f, -1.82126909e-01f, -2.59320885e-01f,
  -1.93463683e-01f, -2.89968222e-01f, 1.28941908e-01f, 2.47929335e-01f, 1.22990310e-01f, -1.51401861e-02f, -2.74139196e-01f, 1.34738132e-01f, -6.30990326e-01f, -8.90591592e-02f,
  -1.97529420e-01f, -5.51335178e-02f, 3.79274786e-01f, 1.92998573e-01f, -4.59658414e-01f, -5.54332078e-01f, -2.04680339e-01f, 8.19500759e-02f, 2.48456523e-01f, -3.06806624e-01f,
  -6.96930587e-02f, -3.85035877e-03f, 2.90727228e-01f, -7.81749129e-01f, 3.38360041e-01f, 1.60015240e-01f, -2.94715822e-01f, -7.08608255e-02f, -3.19118202e-01f, 2.38586232e-01f,
  1.60550207e-01f, 1.01977825e-01f, 2.39647001e-01f, 3.47227126e-01f, -2.87936509e-01f, -2.89517790e-01f, 2.14569926e-01f, -2.02621087e-01f, 1.80638984e-01f, 1.41840190e-01f,
  -1.89312920e-01f, 2.12914005e-01f, 1.74692497e-01f, -7.97221363e-02f, -9.37469676e-03f, -3.10848147e-01f, 1.45254850e-01f, -1.28556222e-01f, 2.63104200e-01f, 2.94627219e-01f,
  1.90638795e-01f, 1.50011748e-01f, -1.19703278e-01f, 1.88440338e-01f, 5.70638254e-02f, 1.02995612e-01f, -2.56612897e-01f, -2.40998268e-01f, 1.50674194e-01f, -4.61446494e-02f,
  1.34139851e-01f, -8.68123248e-02f, 6.26530051e-02f, 8.18703026e-02f, 1.70858204e-01f, 3.27247113e-01f, -4.89501417e-01f, -1.82978511e-01f, 8.53571370e-02f, -1.77203014e-01f,
  -1.21614419e-01f, -2.88206846e-01f, -1.16588347e-01f, 1.92741454e-01f, 4.13655728e-01f, 1.96549505e-01f, 2.27945939e-01f, -8.08547363e-02f, -1.29993767e-01f, -2.77174592e-01f,
  9.38726068e-02f, 2.39087075e-01f, 1.80240124e-01f, -1.21795446e-01f, -4.30415779e-01f, -3.64780694e-01f, 1.56943157e-01f, 5.41273272e-03f, -1.15057088e-01f, -5.47671258e-01f,
  -1.26675338e-01f, -3.48086953e-01f, -3.06760520e-01f, -4.01486784e-01f, 2.31434479e-01f, -4.70815808e-01f, 2.54630566e-01f, 4.60129306e-02f, -1.34145454e-01f, 2.23796174e-01f,
  5.57486117e-02f, 1.40042692e-01f, 1.58004984e-02f, 1.11763395e-01f, -3.24268430e-01f, -2.98025161e-01f, -4.72161807e-02f, 2.27630958e-01f, -1.30006209e-01f, 3.07125062e-01f,
  1.61544234e-01f, -2.17190087e-01f, 1.30325288e-01f, -2.56797224e-01f, -1.33031800e-01f, 1.66389450e-01f, -1.62827864e-01f, 6.54683709e-02f, -2.43559793e-01f, -8.08752514e-03f,
  -1.12457879e-01f, 1.32816344e-01f, 3.55055362e-01f, -9.62610021e-02f, -3.65776747e-01f, 3.53100717e-01f, -7.05600798e-01f, -4.10703242e-01f, -4.61139381e-01f, -9.98108387e-02f,
  -1.36567682e-01f, -3.19141448e-01f, 2.08286628e-01f, 1.20604947e-01f, -1.28784925e-01f, -2.52585143e-01f, 1.46981208e-02f, 4.36827205e-02f, 6.33016005e-02f, 2.32957289e-01f,
  -4.46399897e-01f, -4.31744009e-01f, -2.53314108e-01f, -1.61242589e-01f, 1.32969186e-01f, 2.69724876e-01f, -7.60560930e-02f, -3.13408852e-01f, -2.85329342e-01f, -3.00251156e-01f,
  -5.09521306e-01f, 2.57110327e-01f, -5.26411057e-01f, 1.63873047e-01f, 3.27035189e-01f, -9.76322740e-02f, 2.84600049e-01f, 1.17994949e-01f, 2.13464558e-01f, 1.64938807e-01f,
  1.95677150e-02f, -2.08663732e-01f, -2.66265124e-01f, 3.94487113e-01f, -3.26484859e-01f, -5.00069916e-01f, 1.30561724e-01f, 3.64649683e-01f, 2.30834648e-01f, -1.02803662e-01f,
  -4.91416961e-01f, 3.13741833e-01f, -3.93188298e-01f, -8.52583572e-02f, -3.07232440e-01f, -8.43016654e-02f, -4.29948032e-01f, -2.78325230e-01f, -5.51214889e-02f, -1.57822058e-01f,
  -1.82718616e-02f, -2.08018497e-01f, -3.74924466e-02f, -1.19998589e-01f, 8.26625228e-02f, -1.05636984e-01f, 1.02189593e-01f, 2.15627268e-01f, 1.47882760e-01f, -2.88704820e-02f,
  2.12296277e-01f, 1.28949406e-02f, -3.17653894e-01f, -1.59526855e-01f, -2.10739225e-01f, 9.72868130e-02f, -3.45705569e-01f, 1.64821610e-01f, -1.62028953e-01f, -4.13736761e-01f,
  2.99650371e-01f, 1.44242078e-01f, 2.91500557e-02f, -1.74967378e-01f, 3.54261726e-01f, -3.50284576e-01f, 1.86155856e-01f, 2.98711777e-01f, -3.05506855e-01f, -2.57171810e-01f,
  2.48742402e-01f, -1.07907385e-01f, -1.43726081e-01f, 9.87952054e-02f, -1.03988117e-02f, -2.48703539e-01f, -2.50655949e-01f, 1.63590536e-01f, -3.79977971e-01f, -6.58480972e-02f,
  2.74374902e-01f, 2.23592669e-01f, -9.71005112e-02f, -4.07345295e-01f, 2.76204385e-02f, -1.71810016e-01f, -2.17845187e-01f, 3.95797849e-01f, 1.89185560e-01f, -8.81012008e-02f,
  -4.84656960e-01f, -2.79456407e-01f, -1.76616833e-01f, -1.89788431e-01f, 2.57547528e-01f, 9.37302038e-02f, 3.46624196e-01f, 2.65222490e-01f, -3.33543628e-01f, -3.34528416e-01f,
  1.58616349e-01f, -1.76096410e-02f, 3.14366706e-02f, -2.45958269e-01f, -1.05641119e-01f, -1.74125031e-01f, -5.26430085e-02f, -1.40982017e-01f, -1.06157400e-01f, -2.64291793e-01f,
  -2.27552250e-01f, -1.09908409e-01f, -1.37090996e-01f, 1.92785516e-01f, -1.18345030e-01f, -2.22751170e-01f, -3.08074385e-01f, -2.69044846e-01f, 1.84099391e-01f, 4.10169326e-02f,
  -1.39420480e-01f, 2.22870596e-02f, -7.91986883e-02f, -8.58330131e-02f, -9.08215716e-02f, -2.51670986e-01f, -2.73082823e-01f, -2.82588840e-01f, 5.04611611e-01f, 6.61111698e-02f,
  2.23867252e-01f, 1.88329548e-01f, 1.23636119e-01f, 9.05565917e-02f, -3.52150559e-01f, 2.60494441e-01f, -4.62577082e-02f, 4.49136235e-02f, 2.18049958e-01f, -7.72360191e-02f,
  -2.25029290e-01f, -2.79829770e-01f, 1.48930922e-01f, 1.27316654e-01f, -2.69890130e-01f, -3.46621871e-01f, -1.66751117e-01f, -2.39877060e-01f, -2.56567985e-01f, 2.97190458e-01f,
  1.05467908e-01f, 3.02485675e-01f, -1.85028851e-01f, 2.43177235e-01f, -1.06223166e-01f, -1.52781948e-01f, 1.49647638e-01f, -1.94174290e-01f, -1.82957575e-01f, 1.09055780e-01f,
  -4.64405678e-02f, -4.35457714e-02f, 1.58987537e-01f, -2.08075754e-02f, 1.16696678e-01f, -1.93457216e-01f, 1.78588152e-01f, -8.34994689e-02f, 6.89861476e-02f, -4.81794327e-02f,
  1.00892097e-01f, -8.83566961e-02f, 3.05869151e-04f, 2.02032641e-01f, -3.24130654e-01f, -2.85636365e-01f, 1.58317074e-01f, -2.10585728e-01f, 5.14974296e-01f, 2.86360860e-01f,
  -9.73853767e-02f, -7.02339113e-02f, 3.28681394e-02f, -3.70538026e-01f, -3.83439124e-01f, 1.34377539e-01f, -2.24199742e-01f, -2.25826457e-01f, -2.06639856e-01f, 1.60514340e-01f,
  -2.79463213e-02f, -2.67978460e-01f, -4.07856315e-01f, -3.07835281e-01f, -3.62144768e-01f, -1.10471413e-01f, 1.91871881e-01f, -2.46096745e-01f, 2.52775520e-01f, -1.47108838e-01f,
  -1.92119122e-01f, 8.66025686e-02f, -1.67158127e-01f, -3.57896924e-01f, 3.27113122e-01f, 2.44001716e-01f, -1.40775368e-01f, -4.10986423e-01f, 3.37915182e-01f, 2.68557906e-01f,
  -2.95138180e-01f, 2.62912780e-01f, -9.08782557e-02f, -4.23254132e-01f, -3.56753379e-01f, -2.93705404e-01f, -4.51873988e-01f, -1.65690780e-01f, 8.10899287e-02f, 1.22124188e-01f,
  -6.97742274e-04f, -2.12244347e-01f, 4.42844093e-01f, 1.23934507e-01f, 2.01024011e-01f, 1.86781287e-01f, -4.38990831e-01f, 1.82626829e-01f, -1.61566064e-01f, -3.40237975e-01f,
  -9.71208438e-02f, 4.10326496e-02f, 1.45390118e-02f, 1.42342612e-01f, 2.23799050e-01f, 1.34042293e-01f, -2.02732265e-01f, 1.51845574e-01f, 5.90891503e-02f, -1.67097062e-01f,
  -3.21019888e-01f, 3.25384706e-01f, -8.76799449e-02f, 8.37480277e-02f, 1.20977879e-01f, -2.30777904e-01f, -4.79994208e-01f, -1.08077325e-01f, 2.87291240e-02f, -3.74791086e-01f,
  3.53562653e-01f, -1.95822753e-02f, 1.54488429e-01f, -1.39504448e-01f, 3.08729589e-01f, -3.82988960e-01f, -4.57167447e-01f, 1.27696320e-01f, -1.43178955e-01f, 3.24072748e-01f,
  -2.79196590e-01f, -3.27104867e-01f, -1.45679519e-01f, -4.25105810e-01f, 2.89339393e-01f, -2.96796590e-01f, -2.81414717e-01f, -4.17515546e-01f, 2.27303177e-01f, 2.65121490e-01f,
  3.42254788e-01f, 9.94843915e-02f, 1.00541934e-01f, -1.63872704e-01f, -3.35515618e-01f, -4.15807456e-01f, -1.14943303e-01f, 3.40176195e-01f, 3.86902153e-01f, -2.24870831e-01f,
  2.85689712e-01f, -4.61697802e-02f, -4.71086979e-01f, -4.78907287e-01f, 3.39815840e-02f, 3.08661699e-01f, -2.48601913e-01f, -1.54414074e-02f, -5.97259700e-02f, -1.14143930e-01f,
  1.71308786e-01f, 3.00556064e-01f, -1.96769740e-03f, 1.13327220e-01f, 6.88659400e-02f, 6.41240599e-03f, 4.31677848e-02f, -1.30496353e-01f, 8.60143173e-03f, -1.12706855e-01f,
  -2.07874253e-01f, -3.17341596e-01f, 1.32316807e-02f, -1.77381009e-01f, 3.36452961e-01f, 2.59631634e-01f, -1.23294011e-01f, 1.56359926e-01f, 7.34943599e-02f, 1.50340408e-01f,
  -2.91561097e-01f, -3.27067226e-01f, 4.05575871e-01f, 3.74879450e-01f, 2.24958301e-01f, -3.20283264e-01f, -3.13306034e-01f, 1.51536420e-01f, 1.66599199e-01f, 1.31024525e-01f,
  2.14405805e-01f, -3.36000443e-01f, -4.05712336e-01f, 1.50700927e-01f, 5.56380861e-02f, -7.56460801e-02f, -2.40022749e-01f, 3.38671029e-01f, 3.29920471e-01f, -2.21376613e-01f,
  1.95450950e-02f, -4.08793569e-01f, -2.58634955e-01f, -2.20666658e-02f, 4.86715790e-03f, -4.63412225e-01f, -3.78557056e-01f, -2.44933814e-01f, -3.06083322e-01f, 4.33374792e-01f,
  -3.65563273e-01f, -5.61678171e-01f, -4.01650369e-01f, -1.87907860e-01f, -5.65259270e-02f, 5.77922165e-03f, 6.25469238e-02f, -3.96442294e-01f, 2.56187826e-01f, -2.25636736e-01f,
  2.28916779e-01f, 1.95005834e-01f, -3.05108815e-01f, -3.34215164e-01f, 2.34689921e-01f, -2.95518607e-01f, -1.01063937e-01f, -3.04292053e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.35134771e-01f, 1.26314862e-03f, 4.18432653e-02f, 6.45017326e-02f, -4.94840406e-02f, -4.50772494e-02f, -3.27735245e-02f, -4.75705191e-02f, -8.57400596e-02f, -1.08289104e-02f,
  7.34276548e-02f, 7.83632249e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    