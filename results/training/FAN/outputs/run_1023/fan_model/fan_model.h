/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.05829751e-01f, 1.77479744e-01f, -1.71521917e-01f, 1.57759916e-02f, -6.70746192e-02f, -1.82004809e-01f, -1.63259625e-01f, -2.79559553e-01f, -5.17661944e-02f, 4.00625803e-02f,
  -2.13651150e-01f, -1.22670680e-01f, -6.49629161e-02f, -2.46209815e-01f, -3.95548403e-01f, 2.83861980e-02f, 1.17922910e-01f, -3.25449377e-01f, -6.30493581e-01f, -3.42530310e-01f,
  -2.24898029e-02f, -6.67606667e-02f, -3.57280225e-01f, -1.89615473e-01f, 1.60290912e-01f, -1.04242906e-01f, 2.38989387e-02f, 4.06749547e-02f, -4.05655690e-02f, 2.67002285e-01f,
  -1.26419201e-01f, -1.66564852e-01f, -3.04414988e-01f, -1.55602470e-01f, -1.39712229e-01f, -2.01705173e-01f, -1.78942531e-01f, -1.32911786e-01f, -6.19771034e-02f, -1.34293810e-01f,
  -1.92463011e-01f, -1.47860616e-01f, -1.56849012e-01f, -1.26902431e-01f, -1.32802412e-01f, -1.52931675e-01f, -1.26859397e-01f, -2.07439914e-01f, -1.95505261e-01f, -6.22932352e-02f,
  -2.61463616e-02f, -1.72309682e-01f, -2.27033526e-01f, -1.98907599e-01f, -3.50865513e-01f, -2.69134641e-01f, -3.18670601e-01f, -1.66306019e-01f, -2.91187227e-01f, 3.11095752e-02f,
  -7.79651329e-02f, 1.09634191e-01f, 6.31409585e-02f, 1.83810353e-01f, 1.36262968e-01f, 9.82935056e-02f, 1.62280023e-01f, 1.26301795e-01f, 2.40025297e-03f, 1.52965978e-01f,
  7.94407800e-02f, 1.47567555e-01f, 1.23546347e-01f, 1.07064985e-01f, 1.21127784e-01f, 5.88714331e-02f, 1.06394134e-01f, 1.13189057e-01f, 1.44161925e-01f, 1.36533871e-01f,
  9.71327126e-02f, 1.22032829e-01f, 2.01503217e-01f, 1.11787677e-01f, 9.51587707e-02f, 5.11249825e-02f, 1.00952923e-01f, 9.43280160e-02f, 1.02769420e-01f, 1.13961704e-01f,
  3.54877450e-02f, -3.06608468e-01f, -1.16993776e-02f, -1.68454319e-01f, -1.13266312e-01f, -9.69980732e-02f, -1.00482635e-01f, -7.76366219e-02f, -7.41374642e-02f, -1.71942666e-01f,
  -2.12504193e-01f, -2.61387259e-01f, -1.46851838e-01f, -1.83373451e-01f, -2.46397272e-01f, -1.75507262e-01f, -9.34799165e-02f, -6.11258261e-02f, -1.53033391e-01f, -4.98987436e-02f,
  -1.41062215e-01f, -1.61971092e-01f, -2.44264200e-01f, -1.60867989e-01f, -1.23169318e-01f, -1.82902977e-01f, -3.73878106e-02f, -1.67929590e-01f, -3.38787436e-01f, -4.14862595e-02f,
  -2.80687124e-01f, -1.03117330e-02f, -1.45092502e-01f, -5.57588832e-03f, 5.34821376e-02f, 4.98342849e-02f, 2.07221285e-01f, -6.47815317e-02f, -3.80845293e-02f, -4.93790656e-02f,
  -8.61840993e-02f, -1.73448771e-01f, -1.52704597e-01f, -1.79694206e-01f, -1.25169665e-01f, 1.82742197e-02f, 6.62819073e-02f, -1.09238632e-01f, -1.55425649e-02f, -3.75115536e-02f,
  1.80471599e-01f, -2.40526181e-02f, -1.97767183e-01f, -4.80958410e-02f, 9.82803702e-02f, -1.69470906e-02f, -7.06440285e-02f, -7.07578436e-02f, -5.63009419e-02f, -5.70338406e-02f,
  -1.23190269e-01f, -3.14786822e-01f, -5.44451177e-02f, -1.09646454e-01f, -2.41240598e-02f, -5.69043867e-02f, -1.00670844e-01f, 3.09634674e-02f, -6.65221140e-02f, -5.05002066e-02f,
  -1.20520532e-01f, -6.23184778e-02f, -4.19876240e-02f, -6.05420992e-02f, -1.24098934e-01f, -1.01227738e-01f, -1.24151111e-01f, -8.71648639e-02f, -5.84085956e-02f, -1.12944409e-01f,
  -1.50869563e-01f, -1.04073197e-01f, -1.15720361e-01f, -6.24620765e-02f, -1.37034893e-01f, -1.95940614e-01f, -1.43810734e-01f, -1.14232481e-01f, -1.69309080e-01f, 6.85615838e-02f,
  1.29905686e-01f, 2.89590303e-02f, 3.87665629e-02f, 6.09502494e-02f, 5.25615960e-02f, 3.10906190e-02f, 4.31648344e-02f, 8.14302564e-02f, 8.83380026e-02f, 5.57075888e-02f,
  2.46344712e-02f, 2.92321052e-02f, 1.24905206e-01f, -1.98519556e-03f, 7.74528608e-02f, 3.41246501e-02f, 6.89212373e-03f, 1.23517767e-01f, 9.19864886e-03f, 5.45002520e-02f,
  -1.83343794e-02f, 5.05286753e-02f, 4.26034592e-02f, 6.93587586e-02f, -1.98679231e-02f, -7.94296619e-03f, -7.89372250e-03f, 1.31822247e-02f, 4.80046570e-02f, 9.32733342e-03f,
  -3.19160596e-02f, -3.64513904e-01f, -1.09354993e-02f, -9.67293158e-02f, 3.27728912e-02f, -5.29075488e-02f, -2.10102517e-02f, -2.49356194e-03f, -7.86983445e-02f, 3.17123234e-02f,
  -6.94356710e-02f, -1.16454147e-01f, -1.49795637e-01f, -9.51767713e-03f, -1.17096893e-01f, 1.65451635e-02f, 1.00330207e-02f, 1.32828001e-02f, -9.51410085e-02f, 5.01821153e-02f,
  1.75304264e-02f, -2.89346352e-02f, -8.66245851e-03f, 2.18507126e-02f, -1.44028896e-02f, 2.82381382e-02f, 5.00350595e-02f, 5.76465577e-02f, 7.62251839e-02f, 1.81930378e-01f,
  2.40733653e-01f, 1.45825502e-02f, -1.11390911e-01f, 3.71431261e-02f, -8.48110765e-02f, -1.72325552e-01f, -1.03728086e-01f, -1.98348314e-01f, -7.45289251e-02f, 3.61719937e-03f,
  4.11049388e-02f, 1.00237630e-01f, 1.20984260e-02f, 7.07160160e-02f, 7.17898309e-02f, 4.78384756e-02f, 1.02224685e-01f, 2.29004905e-01f, 1.15327194e-01f, 4.42159399e-02f,
  1.14275210e-01f, 1.12770066e-01f, 1.38893262e-01f, 1.72506273e-01f, 3.02772522e-01f, 2.18040645e-01f, 1.45480409e-01f, 1.41593724e-01f, 2.04691276e-01f, 3.67867053e-01f,
  1.37309909e-01f, 1.97181419e-01f, -1.56083191e-02f, 1.70617804e-01f, 6.49453141e-03f, 3.05149686e-02f, 1.07886940e-01f, 6.73654601e-02f, 7.63665810e-02f, 9.00892466e-02f,
  1.36599317e-01f, 1.96444660e-01f, 9.23122093e-02f, 1.57860950e-01f, 2.05937043e-01f, 8.47413018e-02f, 8.09095502e-02f, 2.42132768e-01f, 1.60094693e-01f, 4.37879339e-02f,
  2.32906744e-01f, 3.12187374e-01f, 1.03213340e-01f, 7.60177597e-02f, 7.83424079e-02f, 1.84807479e-01f, 4.39497381e-02f, 1.00835092e-01f, 6.06403053e-02f, 1.72844082e-01f,
  2.04091966e-02f, -1.32080019e-01f, -1.56920865e-01f, -1.46100387e-01f, -1.44557416e-01f, -3.47240530e-02f, -7.08326995e-02f, -8.52766633e-02f, -1.00934483e-01f, -1.13102928e-01f,
  -7.22475797e-02f, -1.46261692e-01f, -1.20240614e-01f, -8.11192319e-02f, -5.04278466e-02f, -1.05774119e-01f, -1.30621925e-01f, -1.81276590e-01f, -4.77580130e-02f, -1.01020224e-01f,
  -1.68629646e-01f, -8.73480886e-02f, -1.54329881e-01f, -6.20949902e-02f, -1.27593547e-01f, -6.43159449e-02f, -1.40397429e-01f, -1.76341817e-01f, -1.72738642e-01f, -2.20249280e-01f,
  -8.00193548e-02f, -4.43521664e-02f, 8.97855759e-02f, 8.75496268e-02f, 4.81685847e-02f, 1.25478968e-01f, 9.44682285e-02f, 1.37566626e-01f, 7.11785927e-02f, 3.38945873e-02f,
  1.14192016e-01f, 5.58804534e-02f, 8.58707428e-02f, 1.44416198e-01f, 2.58815158e-02f, 1.83005065e-01f, 8.22097138e-02f, 9.98474732e-02f, 9.45673063e-02f, 7.66379684e-02f,
  -9.72925406e-03f, 1.23836525e-01f, 8.28182790e-03f, 1.13619436e-02f, 2.53042355e-02f, -8.27126484e-03f, -8.78447108e-03f, -4.19405587e-02f, 3.94271649e-02f, -1.46022126e-01f,
  -3.29300940e-01f, 3.83097157e-02f, 6.28246814e-02f, -1.32115647e-01f, 1.23885758e-02f, 2.75976777e-01f, 2.66088516e-01f, 2.00117856e-01f, -1.30809903e-01f, -6.57365695e-02f,
  -4.01746929e-01f, -4.41110194e-01f, -3.03666681e-01f, -2.12666556e-01f, 3.02476827e-02f, 3.06859463e-01f, 1.42611682e-01f, -5.67431860e-02f, -3.28917317e-02f, -1.09787002e-01f,
  -1.09326303e-01f, -4.16570082e-02f, -2.46710151e-01f, -4.95611764e-02f, -4.98347767e-02f, -8.48401040e-02f, -8.37835148e-02f, -5.54270297e-02f, -1.57046199e-01f, 3.54500934e-02f,
  -3.31308872e-01f, -8.78737792e-02f, -5.75625077e-02f, -1.71784848e-01f, -2.13167027e-01f, -1.84102520e-01f, -9.33163911e-02f, -1.58999473e-01f, -1.47122011e-01f, -1.06909908e-01f,
  -1.67263702e-01f, -1.39315918e-01f, -1.99411958e-01f, -2.03309521e-01f, -2.16348395e-01f, -1.64192319e-01f, -9.75466818e-02f, -1.58522815e-01f, -8.09410810e-02f, -1.40976459e-01f,
  -1.51697889e-01f, -1.26634270e-01f, -1.63549468e-01f, -1.07756682e-01f, -1.42183512e-01f, -1.80005401e-01f, -1.93297654e-01f, -1.13871887e-01f, -1.85322225e-01f, -5.97583801e-02f,
  -1.08437121e-01f, -5.85567346e-03f, 5.94946407e-02f, 6.78533018e-02f, 1.06900267e-01f, -1.15091708e-02f, 8.71896222e-02f, -1.88250449e-02f, 1.03702709e-01f, 1.29069671e-01f,
  -3.84460352e-02f, 9.40011814e-02f, -1.57524529e-03f, 8.66270810e-02f, 7.74541721e-02f, 1.02692522e-01f, 5.76034114e-02f, 1.02012061e-01f, 7.30808154e-02f, 1.04835987e-01f,
  2.41057910e-02f, 5.13000973e-02f, 4.01028097e-02f, 5.47629371e-02f, 1.15615703e-01f, 3.56524326e-02f, 9.51850340e-02f, 4.74596322e-02f, 8.77178237e-02f, 5.47692133e-03f,
  -1.91494420e-01f, -7.79377595e-02f, -1.53754637e-01f, -9.16441977e-02f, -4.92578335e-02f, -3.39706503e-02f, -1.50941491e-01f, -4.06535380e-02f, -1.56133860e-01f, -9.86370295e-02f,
  -1.53813243e-01f, -1.09473437e-01f, -1.54891580e-01f, -1.64718077e-01f, -1.44790441e-01f, -7.93283358e-02f, -7.61571079e-02f, -1.11390673e-01f, -1.66148856e-01f, -1.87149301e-01f,
  -1.21178888e-01f, 4.46482981e-03f, -1.78798094e-01f, -7.13030621e-02f, -6.91972449e-02f, -1.48725882e-01f, -1.46214426e-01f, -3.21251936e-02f, 5.02359532e-02f, 5.01242802e-02f,
  6.42431974e-01f, 2.33618692e-01f, 4.24038231e-01f, 3.30679327e-01f, 1.81161821e-01f, 2.02370778e-01f, 3.15395772e-01f, 5.17594889e-02f, 6.20020926e-02f, 2.52366871e-01f,
  1.54085562e-01f, -1.33180201e-01f, 2.93315575e-03f, -6.52027205e-02f, 3.59017327e-02f, 2.60808110e-01f, 3.91224205e-01f, 1.92555845e-01f, 1.92046985e-02f, 8.74505118e-02f,
  8.64715129e-03f, 1.09210208e-01f, 1.29631057e-01f, 8.77989456e-02f, 8.43248665e-02f, 8.27383529e-03f, 2.70586759e-01f, 1.98796391e-01f, 9.51923057e-02f, 2.85483867e-01f,
  2.39003018e-01f, 2.01154873e-01f, -2.70463862e-02f, -7.61687243e-03f, 5.33871129e-02f, 2.66783759e-02f, 2.95255445e-02f, 6.77955523e-02f, -1.09232385e-02f, 9.58308727e-02f,
  4.32426818e-02f, -5.53286895e-02f, 5.32525703e-02f, 1.61468461e-02f, 1.15941621e-01f, -1.26713347e-02f, 1.15853883e-01f, 5.41182160e-02f, 1.02465348e-02f, 6.31601512e-02f,
  1.57969128e-02f, 1.21154435e-01f, 1.13151982e-01f, -1.34717245e-02f, -1.54336058e-02f, 4.50490750e-02f, 3.02593596e-02f, -7.28538185e-02f, 5.90724591e-03f, 9.73238237e-03f,
  9.53891650e-02f, 9.25613269e-02f, -5.45704328e-02f, -5.24763241e-02f, -1.49014713e-02f, -3.02905031e-02f, -1.00116553e-02f, -6.42351434e-02f, 4.35823080e-04f, -6.53162226e-02f,
  -2.06509717e-02f, 2.20365468e-02f, -8.67653862e-02f, 4.39807996e-02f, -3.79394777e-02f, 7.19658658e-02f, -5.64663112e-02f, -2.31651906e-02f, -4.28460352e-02f, -3.29057239e-02f,
  -7.21188774e-03f, -1.77006852e-02f, -2.87641697e-02f, -9.66082066e-02f, -3.11237592e-02f, 7.26580620e-02f, -9.94429961e-02f, -8.47412571e-02f, -9.94507875e-03f, 7.74357468e-02f,
  -1.63502961e-01f, -8.97046030e-02f, 5.05778007e-02f, -2.91738426e-03f, 7.24765584e-02f, 5.91238029e-03f, -4.45905142e-03f, 2.11950485e-02f, 1.85300522e-02f, 1.93216708e-02f,
  2.58777384e-02f, 8.63860622e-02f, 5.20387366e-02f, -5.08023053e-02f, 8.31046402e-02f, -9.40856338e-03f, 2.21663155e-02f, 1.25070259e-01f, -6.92761242e-02f, -1.55209880e-02f,
  4.37598675e-02f, 6.74729496e-02f, 9.55449566e-02f, -1.23175541e-02f, -2.82166321e-02f, 3.58746685e-02f, -4.89200503e-02f, -1.62306558e-02f, 3.30177732e-02f, 7.35710114e-02f,
  5.01580536e-01f, 3.52900118e-01f, 1.77487627e-01f, 1.61886409e-01f, -2.79813353e-03f, -2.04783291e-01f, -5.25637269e-02f, 5.92230558e-02f, 1.41531704e-02f, 2.73357779e-01f,
  2.54092991e-01f, 5.79689629e-02f, 1.98030099e-02f, -1.16325535e-01f, -1.96739033e-01f, 6.41429517e-03f, -2.28883386e-01f, -2.33431235e-01f, -1.60811931e-01f, -8.63081589e-02f,
  -1.82297651e-03f, 1.26242653e-01f, 2.02252194e-01f, 7.24079460e-02f, 2.48072922e-01f, -4.58891988e-02f, 1.37853324e-01f, 2.43217379e-01f, -5.80474548e-02f, 7.99686760e-02f,
  1.63865522e-01f, 3.99395615e-01f, -1.88148916e-01f, -4.58781123e-02f, 1.22099876e-01f, 5.52868918e-02f, -6.06638603e-02f, 1.36550173e-01f, -1.05268648e-02f, 1.34135671e-02f,
  1.46135399e-02f, -9.92422551e-03f, 2.60273144e-02f, 1.47987800e-02f, 2.67876685e-02f, 9.27875638e-02f, 5.72625026e-02f, 4.37614955e-02f, 1.80618167e-02f, 1.01892732e-01f,
  -9.81083047e-03f, 1.63906030e-02f, 3.46661336e-03f, -1.26125310e-02f, -4.00673635e-02f, -1.89363927e-01f, 1.60824597e-01f, 3.47930416e-02f, -1.13328107e-01f, 2.71449596e-01f,
  -1.64225057e-01f, -2.44319253e-02f, -4.92866226e-02f, 5.54150669e-03f, -5.00501599e-03f, -3.01558021e-02f, 4.02422361e-02f, -5.17270751e-02f, -1.82492826e-02f, -1.99799500e-02f,
  -1.51086962e-02f, -5.57084680e-02f, -2.25214567e-02f, 3.11376783e-03f, 1.57438125e-02f, -4.60886732e-02f, -2.14611180e-02f, 1.70352031e-02f, -1.13299582e-02f, 1.11384001e-02f,
  -6.65357895e-03f, -2.28984701e-03f, 2.97417138e-02f, -7.04159513e-02f, -6.48501068e-02f, -5.13331965e-03f, 2.11407281e-02f, -2.33279318e-02f, 1.46953523e-01f, -2.85917311e-03f,
  1.76514789e-01f, -2.95480371e-01f, 1.61479861e-01f, 6.43285364e-02f, -2.43156981e-02f, 2.76452620e-02f, 8.45473856e-02f, -3.12867798e-02f, 2.81980708e-02f, 1.03039160e-01f,
  2.41333656e-02f, 4.99458872e-02f, 2.75705159e-02f, 1.24011301e-02f, -5.30131944e-02f, -6.56157658e-02f, 4.38136309e-02f, -1.57434344e-02f, -5.89528494e-02f, 6.84207752e-02f,
  6.07102588e-02f, -2.87745293e-04f, -8.16906244e-03f, -6.12237453e-02f, -4.90525179e-02f, -1.21774361e-01f, -4.57016639e-02f, 4.77745794e-02f, -1.97101951e-01f, 1.27506137e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  7.87136972e-01f, -4.05578732e-01f, 1.50889084e-01f, 4.08297241e-01f, -5.38831204e-03f, 2.82392889e-01f, 5.53897507e-02f, 1.54736906e-01f, 2.41460532e-01f, 7.59316608e-02f,
  2.90905163e-02f, 2.36471295e-01f, 1.89707488e-01f, 6.34842440e-02f, 8.35493058e-02f, 4.02570255e-02f, 4.97498550e-02f, 2.87833393e-01f, 2.65652061e-01f, 1.50948763e-01f,
  -1.19224161e-01f, 1.64891481e-02f, 8.39341581e-02f, 7.46304244e-02f, -2.83879310e-01f, 4.85465191e-02f, -8.20033625e-02f, -1.05273649e-01f, -1.44400120e-01f, -1.92322046e-01f,
  -3.04403126e-01f, 4.94873933e-02f, -6.37026355e-02f, -1.55565739e-01f, -2.52008289e-01f, -4.51712348e-02f, -2.09099185e-02f, -1.37525216e-01f, -1.18319623e-01f, -3.58136818e-02f,
  -1.19067252e-01f, -1.09350897e-01f, -2.06192479e-01f, -1.06027260e-01f, -7.24474192e-02f, -3.15245204e-02f, -2.56244123e-01f, 1.50113657e-01f, 3.70678604e-02f, -4.65324223e-02f,
  -1.61752298e-01f, 9.16238427e-02f, 1.44823296e-02f, -5.54321036e-02f, 1.75435826e-01f, 1.57925323e-01f, -1.48920119e-02f, -1.93313987e-03f, 1.55989811e-01f, 5.32277077e-02f,
  -2.62241308e-02f, -2.26405337e-02f, -5.54404519e-02f, 6.29885420e-02f, 5.96397668e-02f, -2.50435118e-02f, -4.38528694e-02f, 1.33993983e-01f, 1.43409029e-01f, -1.56069592e-01f,
  -7.50810206e-02f, 4.51761298e-02f, 7.74175152e-02f, 4.47792932e-02f, -5.60859069e-02f, -1.00139298e-01f, 9.35166627e-02f, -2.16960907e-01f, -1.86214566e-01f, -5.73309921e-02f,
  5.78787811e-02f, 1.23136595e-01f, -6.81266561e-02f, -1.97427347e-01f, -1.67349145e-01f, -1.09984195e-02f, -2.44857054e-02f, -6.71919659e-02f, -1.60123222e-02f, -2.95255706e-03f,
  -4.38992232e-01f, 8.39942843e-02f, 1.56312622e-03f, -1.89361796e-02f, -1.78772006e-02f, -1.42733246e-01f, 4.40980104e-04f, -1.60671979e-01f, -1.96694791e-01f, -2.01094244e-02f,
  -5.09602018e-02f, -6.42729029e-02f, -8.89052227e-02f, 1.81320366e-02f, 9.67879966e-02f, -5.25246896e-02f, -1.85529634e-01f, 8.55550840e-02f, 3.39838415e-02f, -7.32827708e-02f,
  -7.20032007e-02f, 1.46844953e-01f, 2.81739682e-01f, 2.33368099e-01f, 1.61220580e-01f, 2.36627579e-01f, 1.04675628e-01f, -2.41539739e-02f, 2.88266808e-01f, 2.40663871e-01f,
  -5.94631195e-01f, 2.97181576e-01f, -8.70666876e-02f, -1.08198904e-01f, -1.41605094e-01f, -1.68019459e-01f, -2.91108843e-02f, 1.58453256e-01f, 3.01554143e-01f, 4.33324754e-01f,
  8.13106671e-02f, -2.88903981e-01f, -6.37451857e-02f, -2.59997368e-01f, -5.34014821e-01f, 7.42150322e-02f, -2.43911147e-01f, -5.32444537e-01f, -7.16655135e-01f, -5.59799016e-01f,
  -2.81945407e-01f, -5.04565895e-01f, -6.04268432e-01f, -2.09650531e-01f, 3.47780406e-01f, -8.79724622e-02f, 2.03277603e-01f, -1.68320790e-01f, -5.89320622e-02f, -1.15689859e-02f,
  1.74232591e-02f, -1.71690434e-02f, -5.68653196e-02f, -3.43676746e-01f, 2.99279928e-01f, -4.35525514e-02f, 7.30275875e-03f, -2.37828935e-03f, 1.15044927e-03f, 1.58604514e-02f,
  -1.23145662e-01f, -8.23235735e-02f, -2.79738665e-01f, -7.66670778e-02f, -2.51356870e-01f, -3.14288735e-01f, -2.44356468e-01f, -3.95274460e-01f, -2.20057130e-01f, -7.82401189e-02f,
  -4.79638487e-01f, -5.73851407e-01f, -4.60294217e-01f, -2.04651058e-02f, 6.05200864e-02f, -3.76430422e-01f, 8.14829916e-02f, 1.42045617e-01f, -6.42588688e-03f, 2.08985224e-01f,
  1.23203605e-01f, 1.09741777e-01f, -1.62453711e-01f, 2.33008470e-02f, 5.62473610e-02f, 7.64600709e-02f, 1.22571088e-01f, 8.62520486e-02f, -1.21927755e-02f, 1.06765539e-03f,
  -2.10885815e-02f, 2.33975664e-01f, 1.56897306e-01f, -2.97042727e-02f, 2.60402076e-02f, -1.17289545e-02f, -2.08480824e-02f, 5.87304644e-02f, -5.15500009e-02f, 9.05603021e-02f,
  -1.29889101e-01f, -7.80925825e-02f, -3.82579602e-02f, 1.08373143e-01f, -1.63076296e-01f, 9.73423868e-02f, 3.94496322e-02f, 7.60098323e-02f, -5.97753488e-02f, -4.15565725e-03f,
  1.27930745e-01f, -2.44350418e-01f, 1.62132263e-01f, -1.18327723e-03f, 2.58076727e-01f, 3.02526951e-02f, 5.10062575e-02f, 1.27924636e-01f, 2.42037266e-01f, -2.87059490e-02f,
  -2.90034980e-01f, 8.41126963e-02f, 1.27926499e-01f, -3.56588066e-02f, -2.31912836e-01f, -8.55623409e-02f, -2.97503592e-03f, -2.54273593e-01f, -1.45712197e-01f, 9.38287154e-02f,
  2.63270121e-02f, -1.38628095e-01f, -3.29884589e-01f, -6.05941424e-03f, 7.22809210e-02f, -2.60632336e-01f, -4.64993678e-02f, 2.69872308e-01f, -3.84285226e-02f, 3.86825174e-01f,
  -1.55172721e-01f, 1.08881436e-01f, -1.88762560e-01f, -8.64944905e-02f, -3.19989234e-01f, -3.89851302e-01f, -1.87571734e-01f, -1.96180537e-01f, -2.25263134e-01f, 7.04882443e-02f,
  -4.03873548e-02f, -1.31329093e-02f, 1.30623639e-01f, -5.11402264e-02f, -2.59437442e-01f, -2.97980346e-02f, -3.76926571e-01f, -4.48257208e-01f, -3.82224828e-01f, -3.38075787e-01f,
  -2.99030662e-01f, -2.69205481e-01f, -2.54111409e-01f, -2.94212997e-01f, -1.78326815e-02f, -4.89598326e-02f, -4.47083861e-02f, -3.89902145e-01f, -6.54754996e-01f, -3.31140727e-01f,
  2.45393932e-01f, -4.74626750e-01f, -1.14899585e-02f, -1.59946486e-01f, 8.84013399e-02f, 5.82214147e-02f, 5.54132136e-03f, 1.41417325e-01f, 1.22637331e-01f, 3.59829515e-02f,
  -3.53428312e-02f, -3.62485312e-02f, -5.23598120e-02f, 1.02752037e-01f, 5.60255274e-02f, -1.22264177e-02f, 8.74511078e-02f, -2.63008801e-03f, 9.78937447e-02f, 9.07584056e-02f,
  3.52274179e-02f, -3.91661227e-02f, 2.10510790e-01f, 5.42973280e-02f, -3.93766314e-02f, 2.79116357e-04f, -3.42015103e-02f, -1.43255353e-01f, -1.49480045e-01f, 8.28237608e-02f,
  -6.12456650e-02f, 2.33487114e-01f, -1.99732818e-02f, -9.45058390e-02f, 1.88433528e-01f, 1.73673689e-01f, 1.38126910e-01f, 2.19088718e-01f, 9.35189351e-02f, 1.28379285e-01f,
  1.63750291e-01f, -9.62055176e-02f, -7.97776878e-02f, 1.29678354e-01f, -1.70113072e-02f, 2.15548184e-02f, -4.05134000e-02f, 2.83923894e-02f, 6.80989698e-02f, 3.34811886e-03f,
  -1.48921274e-04f, -4.00580987e-02f, -2.39056684e-02f, -1.35461343e-02f, -2.30860800e-01f, -1.56725547e-03f, -7.95256793e-02f, -9.42556411e-02f, -7.81278014e-02f, 7.27975275e-03f,
  3.65546852e-01f, -4.52420503e-01f, 1.94412738e-01f, 2.78710742e-02f, 4.38982956e-02f, 1.67268254e-02f, -8.37680325e-02f, -1.48463354e-01f, -7.37087727e-02f, -1.02183118e-01f,
  -1.93658113e-01f, -5.82254194e-02f, 7.38634309e-03f, 2.92656813e-02f, 8.90470892e-02f, -1.56918466e-01f, 2.28335820e-02f, 1.98460728e-01f, 6.32323138e-03f, 1.45959750e-01f,
  5.30809462e-02f, 4.78692129e-02f, 3.72438371e-01f, 1.75874367e-01f, -4.58403826e-02f, 1.37844207e-02f, 2.02059031e-01f, 5.68817817e-02f, 4.01089936e-02f, 2.36144096e-01f,
  -1.43045217e-01f, -4.29195851e-01f, 1.04582354e-01f, 2.44443700e-01f, 2.29042366e-01f, 3.45270842e-01f, 1.17985629e-01f, 5.21515831e-02f, 1.56021655e-01f, 1.01985291e-01f,
  1.83323607e-01f, 2.40812778e-01f, 2.13143080e-02f, 1.43499941e-01f, -6.46501547e-03f, 1.24381870e-01f, 2.84382045e-01f, 3.96749638e-02f, -5.00670914e-03f, 5.22670969e-02f,
  -7.67961666e-02f, -1.74113706e-01f, -3.10057610e-01f, -9.19188187e-02f, -1.47221208e-01f, 8.13123286e-02f, 1.29467085e-01f, 1.78039879e-01f, -6.93704188e-02f, -1.93237394e-01f,
  1.83462232e-01f, -1.78410243e-02f, -1.85957719e-02f, -2.41202209e-02f, -4.61221673e-02f, -1.19298920e-01f, -7.01300949e-02f, -9.27248150e-02f, 8.76535624e-02f, 7.14829937e-02f,
  -2.48830598e-02f, -1.78876102e-01f, -3.34398486e-02f, -5.22629544e-02f, 4.58521908e-03f, 2.36257259e-02f, -8.79711956e-02f, 1.77108154e-01f, 1.93226218e-01f, 1.40861616e-01f,
  1.53155560e-02f, 1.25870109e-01f, 3.34525883e-01f, 2.15296909e-01f, 1.57202616e-01f, 1.79140702e-01f, -3.85485105e-02f, 6.44207047e-03f, 2.52259970e-01f, 2.05092877e-01f,
  2.05532297e-01f, -1.60086676e-01f, -9.44185629e-02f, 1.01137988e-01f, -1.17519498e-01f, -7.04979971e-02f, 5.69050573e-02f, 5.18769175e-02f, 8.22390392e-02f, -1.45482674e-01f,
  1.25801593e-01f, 2.54841149e-01f, 1.72076002e-01f, 5.09423241e-02f, -3.00309062e-02f, -9.98645350e-02f, -2.34199420e-01f, -1.18514925e-01f, 5.29637821e-02f, 3.74945290e-02f,
  -6.73303008e-02f, 7.27871954e-02f, -1.17866226e-01f, -5.33229448e-02f, 1.16713494e-01f, 2.80233383e-01f, 9.96968672e-02f, 1.30790949e-01f, -1.12858854e-01f, -1.59821630e-01f,
  2.46300057e-01f, 2.21677154e-01f, -1.11523300e-01f, -5.17058671e-02f, 2.23760922e-02f, -1.86281770e-01f, -1.14722870e-01f, 6.35125255e-03f, -2.61236746e-02f, 1.84622362e-01f,
  6.96886554e-02f, -3.22624385e-01f, -2.44553626e-01f, -1.61374629e-01f, -7.87576213e-02f, 4.06151265e-03f, -1.36360675e-01f, 3.05066817e-02f, 8.48700181e-02f, -9.67460743e-04f,
  -1.95734680e-01f, 1.93494022e-01f, 2.96420574e-01f, 2.03561671e-02f, -8.03120285e-02f, 2.37991698e-02f, -1.19548097e-01f, -9.30393189e-02f, 1.27844512e-01f, 8.65879804e-02f,
  1.08694279e+00f, 3.34292620e-01f, 5.80742538e-01f, 1.40596151e-01f, -3.00086945e-01f, -2.18348831e-01f, -4.71081845e-02f, 6.63016662e-02f, -6.60425946e-02f, 7.43520632e-02f,
  3.04705687e-02f, 7.41685852e-02f, 9.66678336e-02f, 6.15506805e-02f, 2.82762468e-01f, 1.16750546e-01f, 5.42167686e-02f, 3.80881697e-01f, 3.86483043e-01f, 1.18475743e-01f,
  3.64701636e-02f, 1.73214778e-01f, 4.32400137e-01f, 2.24597514e-01f, 6.07951693e-02f, -3.58636607e-04f, 2.30484992e-01f, 8.80662650e-02f, 7.42675588e-02f, 2.38764837e-01f,
  8.47840682e-02f, 4.67715323e-01f, -1.29790753e-01f, -1.41530454e-01f, -9.73851830e-02f, -7.76932016e-02f, -3.64787206e-02f, -5.93039580e-02f, -1.56091347e-01f, -1.05783500e-01f,
  -1.60252005e-01f, -5.95684648e-02f, -4.62549068e-02f, -7.53374323e-02f, 2.10914444e-02f, -1.07864425e-01f, 7.96168447e-02f, 1.98803097e-01f, 1.08851694e-01f, -6.34420663e-03f,
  -7.47701377e-02f, -1.19097941e-01f, -4.54842336e-02f, -1.44479707e-01f, 6.43532649e-02f, 2.33960077e-02f, 7.78923836e-03f, 1.05443850e-01f, 6.71084747e-02f, 3.31639759e-02f,
  -7.99580067e-02f, 2.76151001e-02f, 1.29652008e-01f, 1.11090187e-02f, 2.32414708e-01f, 7.62052387e-02f, 3.48447748e-02f, 1.76857021e-02f, 1.67165380e-02f, 1.47843942e-01f,
  -6.21105358e-02f, 1.03142500e-01f, -1.18428851e-02f, 4.08266596e-02f, -1.40752986e-01f, -1.22716554e-01f, -7.19947442e-02f, -1.33995339e-01f, -5.70056168e-03f, -7.36921728e-02f,
  3.62366512e-02f, 3.19960304e-02f, 5.60242161e-02f, 1.06471725e-01f, -2.27327435e-03f, 5.69708645e-02f, -2.08848063e-02f, 1.28596723e-02f, -2.41015740e-02f, 1.56604573e-02f,
  -6.39841557e-01f, 1.08709615e-02f, 7.66498521e-02f, -4.58279476e-02f, 1.14378054e-02f, 1.34602726e-01f, 4.59842384e-02f, 8.64574760e-02f, -3.29547971e-02f, 5.00302203e-02f,
  -8.08960572e-02f, 9.77007151e-02f, 2.77913995e-02f, 1.94759984e-02f, -4.44029272e-02f, -1.69735178e-01f, -4.88123260e-02f, -4.58348542e-03f, -1.47934213e-01f, -1.45506382e-01f,
  -1.88521430e-01f, -3.08937967e-01f, -2.67154694e-01f, -2.14536980e-01f, -1.11661799e-01f, -3.33693594e-01f, -1.17508262e-01f, -8.90900195e-02f, -6.66510090e-02f, -6.21694745e-03f,
  1.16137236e-01f, -6.67028904e-01f, 6.11171871e-02f, 5.83665609e-01f, -1.78225916e-02f, -5.41863441e-01f, -1.17702043e+00f, -3.33098382e-01f, 4.11815286e-01f, -6.20664299e-01f,
  -4.63565975e-01f, 1.56173706e-01f, 3.66948366e-01f, -7.71477371e-02f, -4.56970721e-01f, -8.54136825e-01f, -3.10702503e-01f, 7.14262128e-02f, 1.08469620e-01f, -7.38921225e-01f,
  -4.44204360e-01f, 1.47933602e-01f, 2.69776404e-01f, 1.36764988e-01f, 9.85733941e-02f, 3.93154234e-01f, 3.09267282e-01f, 2.55256474e-01f, -3.28199089e-01f, -7.62466714e-02f,
  -3.42060685e-01f, -1.87007427e-01f, 2.51193732e-01f, 7.26689994e-02f, 2.44092211e-01f, -5.46155274e-02f, -1.86440423e-01f, 2.25316018e-01f, 1.40079460e-03f, -4.31928672e-02f,
  1.87146097e-01f, 1.97021309e-02f, 2.52570748e-01f, 1.28213376e-01f, -3.06810290e-02f, -2.73569643e-01f, 9.19027627e-02f, -2.85010654e-02f, 1.36408776e-01f, -3.45875800e-01f,
  -1.79783791e-01f, -8.54521319e-02f, -1.70640498e-01f, 3.30421664e-02f, -1.58857450e-01f, 3.65999848e-01f, 5.81222922e-02f, -3.18783522e-03f, 1.43685266e-01f, -2.27102295e-01f,
  -1.16235219e-01f, 1.43006787e-01f, -1.53152617e-02f, -8.52063745e-02f, -8.61456022e-02f, 2.98880003e-02f, 4.86516207e-02f, -7.87843987e-02f, -1.09629981e-01f, 3.56733575e-02f,
  -1.99353322e-02f, 5.83423525e-02f, 5.22921085e-02f, -8.01652595e-02f, 4.21568491e-02f, 2.30271574e-02f, 3.06347813e-02f, -3.67410034e-02f, -1.29756153e-01f, 9.76014286e-02f,
  -8.59938040e-02f, -3.75957787e-02f, 1.66481420e-01f, -6.51501678e-03f, -1.38648584e-01f, 6.81059435e-02f, 3.68007496e-02f, 2.49163434e-02f, 2.23856524e-01f, -6.87516779e-02f,
  5.24774551e-01f, 3.28559905e-01f, -2.28291869e-01f, -1.74173951e-01f, -8.01658109e-02f, 2.58114152e-02f, 1.33428335e-01f, -1.19516477e-01f, 1.90199852e-01f, -1.61881208e-01f,
  -1.82765603e-01f, -1.25320405e-01f, 2.39018455e-01f, -1.00502960e-01f, 3.27281617e-02f, -8.88911784e-02f, -2.41519749e-01f, -1.24382257e-01f, -8.61949548e-02f, -7.69762844e-02f,
  1.03231743e-01f, -4.65846121e-01f, -1.53364345e-01f, -1.90854759e-03f, 3.79442349e-02f, 8.60105604e-02f, 1.13824790e-03f, 5.75997047e-02f, -5.02103474e-03f, -4.60877120e-01f,
  -2.97718823e-01f, -6.79298282e-01f, 5.00778973e-01f, -1.76575288e-01f, 2.58821905e-01f, 4.25168186e-01f, 2.98486203e-01f, 1.59270260e-02f, -3.18536073e-01f, -1.88724279e-01f,
  -2.68725246e-01f, -2.54532576e-01f, -2.36420095e-01f, -1.79428101e-01f, -9.59807634e-03f, 2.81771153e-01f, 2.24541843e-01f, 2.83301860e-01f, 5.34323990e-01f, 3.82250160e-01f,
  -1.81212336e-01f, -1.49161220e-01f, -2.01145470e-01f, -1.67202994e-01f, -2.20547691e-01f, -3.82487178e-02f, -1.98568925e-01f, -3.16522211e-01f, -1.48587987e-01f, -3.52237940e-01f,
  6.65342867e-01f, -2.96164066e-01f, 1.69055402e-01f, -2.88402677e-01f, -6.47271276e-02f, -1.57943994e-01f, 1.34975821e-01f, -1.28821924e-01f, -1.50704294e-01f, -9.78715532e-03f,
  -1.36746317e-01f, -8.07424635e-02f, 3.61993797e-02f, -6.60462976e-02f, 3.98127846e-02f, -2.45247968e-02f, -9.16706920e-02f, -1.99645415e-01f, -9.40594524e-02f, -5.01742661e-02f,
  -2.10708097e-01f, 8.06128141e-03f, 9.42038819e-02f, 3.55645758e-03f, -1.38760000e-01f, 1.22374974e-01f, -1.44328892e-01f, -1.03857815e-01f, -4.16985452e-02f, -1.31000042e-01f,
  5.03289849e-02f, 7.88955465e-02f, -4.85801807e-04f, 8.21214393e-02f, 3.44345905e-02f, 5.24511002e-02f, 1.03505194e-01f, -3.28954346e-02f, -2.16222424e-02f, -5.16307838e-02f,
  -4.64384817e-02f, 1.03680961e-01f, 6.17821142e-02f, 1.15821147e-02f, -1.48595542e-01f, -1.47024477e-02f, 1.45092323e-01f, -7.77540058e-02f, -1.15951464e-01f, -3.75023000e-02f,
  -1.61156967e-01f, -1.70497727e-02f, 7.44031789e-03f, 1.43182613e-02f, -1.19393162e-01f, 2.06847247e-02f, 3.82506996e-02f, -2.89877933e-02f, 5.17108925e-02f, -6.57197684e-02f,
  2.83493698e-01f, 4.88654636e-02f, 8.78311321e-02f, -1.11390926e-01f, -2.05539335e-02f, -2.27896482e-01f, -4.08131145e-02f, -1.84931029e-02f, -4.03012000e-02f, 9.01092365e-02f,
  -1.07154980e-01f, -4.55190986e-02f, -4.90113087e-02f, -4.34003659e-02f, 1.83056310e-01f, 1.06050372e-02f, -8.10737312e-02f, 1.49025116e-02f, 4.86395583e-02f, 7.24168047e-02f,
  -1.35630995e-01f, 8.68448764e-02f, 2.58368790e-01f, 1.48992494e-01f, 3.78453685e-03f, 3.63817483e-01f, 1.90046519e-01f, 1.56081185e-01f, 2.50162095e-01f, 1.88608423e-01f,
  -1.37847647e-01f, 4.65135455e-01f, 4.10657495e-01f, -2.32642278e-01f, 3.39646339e-01f, 5.20891905e-01f, 7.39063859e-01f, 1.32023066e-01f, -3.74242872e-01f, 7.75592178e-02f,
  4.19487596e-01f, -3.49976480e-01f, -1.92391068e-01f, -1.07655942e-01f, 2.49803171e-01f, 1.84741423e-01f, -9.18349251e-02f, -1.90236732e-01f, -1.43054798e-01f, -1.35938495e-01f,
  -2.66775578e-01f, -7.46068582e-02f, -3.34995203e-02f, -1.55527458e-01f, -4.43576783e-01f, -4.76982445e-01f, 1.24912091e-01f, 1.73473001e-01f, 1.54655650e-01f, -5.55602372e-01f,
  -3.19085419e-02f, 1.18598975e-01f, -3.23515505e-01f, -1.27618715e-01f, 2.79920012e-01f, -2.05829918e-01f, -7.43229091e-02f, -1.35648981e-01f, 1.15427300e-01f, -9.24555883e-02f,
  5.85121959e-02f, 5.91262169e-02f, 1.03336550e-01f, -1.91556774e-02f, 4.11521941e-02f, -7.74099585e-03f, -4.76021804e-02f, 1.04144635e-02f, 1.33583203e-01f, 7.68907517e-02f,
  6.50458112e-02f, 2.30803952e-01f, 2.57532835e-01f, 9.94284153e-02f, 1.82867706e-01f, -5.10595441e-02f, 1.60747349e-01f, -4.25984822e-02f, 1.06306247e-01f, -1.88656747e-01f,
  -8.41541141e-02f, 7.26463795e-02f, 1.72345191e-01f, 3.49875130e-02f, -1.63466111e-02f, -3.79900709e-02f, 3.39193568e-02f, 1.68413639e-01f, 4.77339588e-02f, 6.59812540e-02f,
  9.26071927e-02f, 4.26984988e-02f, -6.90486096e-03f, 2.60659400e-02f, -5.14170974e-02f, 9.97143462e-02f, 9.65971053e-02f, 8.45317915e-02f, 1.15066089e-01f, 1.44628361e-01f,
  9.34467167e-02f, 4.65814173e-02f, 1.50652826e-01f, 2.60178410e-02f, 9.02199373e-02f, -8.12797323e-02f, -3.24942768e-02f, 5.34906238e-02f, -2.03119610e-02f, 9.43855867e-02f,
  -2.24175766e-01f, 4.33015883e-01f, -3.78475875e-01f, -3.56094539e-02f, 3.06753498e-02f, 3.64292040e-02f, -3.88177931e-02f, -5.71329631e-02f, 1.00417165e-02f, -1.39644742e-01f,
  4.23844904e-02f, -9.92489308e-02f, 1.06624506e-01f, 5.76530024e-02f, -1.38722554e-01f, 1.74041395e-03f, 8.83240849e-02f, -1.88240051e-01f, -1.88254975e-02f, 4.11646441e-02f,
  5.62486351e-02f, -3.77749056e-02f, -2.71507591e-01f, -1.78070843e-01f, -1.75719485e-01f, -3.26153725e-01f, -4.70649526e-02f, -1.44996092e-01f, 1.10366598e-01f, -1.41488552e-01f,
  1.95281386e-01f, -4.72851276e-01f, -3.71340901e-01f, -2.60029048e-01f, -2.74934798e-01f, -1.39597673e-02f, -2.70583063e-01f, 1.64521143e-01f, 7.53891170e-02f, -2.98198551e-01f,
  9.11453441e-02f, 5.80916643e-01f, 1.99835077e-01f, 3.88583869e-01f, 3.64249527e-01f, -4.85875905e-01f, -3.53365779e-01f, 1.17611080e-01f, 6.87712669e-01f, 4.01602596e-01f,
  9.58677754e-02f, 1.69621466e-03f, 3.68134737e-01f, 1.64839119e-01f, -4.99000251e-01f, -6.25517517e-02f, -4.62427467e-01f, -2.45296672e-01f, -2.97655284e-01f, -6.94410026e-01f,
  -9.45447534e-02f, -3.56005967e-01f, 1.87635690e-01f, 2.42261663e-01f, 9.47297588e-02f, 1.02355614e-01f, -7.36471564e-02f, -2.77543850e-02f, -7.03046545e-02f, -1.74139246e-01f,
  -3.89201641e-02f, 1.01911351e-01f, -8.23775604e-02f, 1.42747108e-02f, -9.41908658e-02f, -3.46020155e-04f, -1.24096200e-01f, -2.97045484e-02f, -2.35362247e-01f, -2.22438544e-01f,
  -1.51731506e-01f, -1.63891658e-01f, -1.39159203e-01f, -9.19318423e-02f, -3.94014455e-02f, -2.78705973e-02f, 7.61639513e-03f, -1.23807900e-01f, -2.72040181e-02f, -5.77136934e-01f,
  -3.60812843e-02f, 2.48730946e-02f, 4.04165825e-03f, -9.70603451e-02f, 6.41846135e-02f, 4.85290363e-02f, -1.21690137e-02f, 1.25128075e-01f, 1.57116905e-01f, -9.25525799e-02f,
  5.34563214e-02f, -1.55658692e-01f, 7.35849887e-02f, -3.40581499e-02f, 1.75206028e-02f, -4.36626524e-02f, -3.99043113e-02f, -6.57277033e-02f, 1.62295669e-01f, -2.77149491e-02f,
  1.03843674e-01f, -1.94014031e-02f, 5.43232262e-02f, 1.06133707e-01f, -4.43814136e-02f, -1.02698244e-02f, -2.32277997e-02f, 2.42503032e-01f, 7.10088760e-02f, -2.09716223e-02f,
  2.53055841e-01f, 2.15016618e-01f, -2.33274326e-01f, 1.15916453e-01f, -7.83337876e-02f, -6.73493743e-03f, -2.13702261e-01f, 1.04691833e-01f, -5.82716465e-02f, 7.17193931e-02f,
  1.33176893e-01f, 1.22492142e-01f, -1.97249055e-01f, 1.50572229e-02f, 3.88534218e-02f, 6.27732500e-02f, -8.90354887e-02f, 1.38677254e-01f, 7.33240461e-03f, -3.05500329e-01f,
  -1.06560923e-01f, 6.33938462e-02f, 2.41838634e-01f, -1.02917403e-01f, 4.17138310e-03f, 9.21643600e-02f, -8.07108916e-03f, -2.31147707e-02f, 1.45254567e-01f, -2.19801307e-01f,
  -3.56921367e-02f, 1.84256077e-01f, -1.21619545e-01f, 3.38152021e-01f, 2.94131875e-01f, 1.04550429e-01f, 2.60553136e-03f, -1.19944206e-02f, 1.85499653e-01f, 5.22168949e-02f,
  -5.75470068e-02f, 4.70048934e-03f, -4.26134579e-02f, -7.81775266e-02f, -6.52707517e-02f, 1.36784792e-01f, 1.70606062e-01f, 1.46427736e-01f, -3.43581177e-02f, 1.08864151e-01f,
  3.62045884e-01f, 3.29737216e-01f, 1.14916466e-01f, 9.15377289e-02f, 3.33158314e-01f, 2.41208956e-01f, 1.56559423e-01f, 2.47535035e-01f, 7.76976347e-02f, 3.78864288e-01f,
  -3.63875508e-01f, -2.07016155e-01f, 8.79242420e-02f, -3.46228890e-02f, -2.49959856e-01f, -2.41468415e-01f, -2.18626354e-02f, -1.62911713e-02f, -1.96672976e-02f, -1.75108369e-02f,
  3.59934829e-02f, -4.21821102e-02f, -7.79526904e-02f, -9.56301689e-02f, 7.55778747e-03f, -9.71085299e-03f, -8.64459723e-02f, -1.19402379e-01f, -1.79651648e-01f, -1.01032138e-01f,
  9.79620293e-02f, -1.03566637e-02f, -2.19972849e-01f, -2.05433294e-01f, -1.99359939e-01f, 1.37814134e-02f, -1.96901277e-01f, -3.47683430e-02f, -2.57625222e-01f, -5.85072562e-02f,
  -1.13734799e-02f, 8.16201419e-03f, 9.75087360e-02f, 1.78980246e-01f, -1.14175461e-01f, -8.70994758e-03f, 2.06164643e-02f, 1.68243185e-01f, 2.79868394e-01f, 2.43880585e-01f,
  1.46881565e-01f, 1.00951403e-01f, 2.12523043e-02f, 2.38264278e-01f, 1.13703087e-01f, 1.97792426e-01f, 1.29913315e-01f, 4.89814803e-02f, 4.60505811e-03f, 1.45321088e-02f,
  1.56654075e-01f, 1.05559267e-01f, 1.13762453e-01f, 9.06847641e-02f, 6.44760877e-02f, 1.59315974e-01f, 2.16133088e-01f, 9.91735831e-02f, 1.36614040e-01f, 1.51741982e-01f,
  3.34939808e-02f, -1.53103799e-01f, 1.93302017e-02f, -6.90530986e-02f, 6.92421347e-02f, -1.12262629e-01f, 1.25184571e-02f, -2.56610960e-02f, -8.03340673e-02f, -5.96278645e-02f,
  -8.25704485e-02f, -2.98410431e-02f, -1.10698042e-04f, -3.62051092e-02f, 1.06588021e-01f, 4.98186238e-02f, 3.63483243e-02f, -5.25613427e-02f, -4.91198339e-02f, -1.65379494e-01f,
  4.80917990e-02f, 3.48288193e-02f, -1.05772853e-01f, -4.02606018e-02f, -7.40536628e-03f, 6.57886267e-02f, -1.57976463e-01f, -8.63505229e-02f, -2.64061302e-01f, 2.48619746e-02f,
  -3.95622514e-02f, -1.13671049e-01f, -3.06665301e-01f, 3.55188340e-01f, 3.80727857e-01f, 1.98559612e-01f, 2.10135251e-01f, 2.22004458e-01f, 3.38998675e-01f, 2.78576106e-01f,
  4.17485356e-01f, 3.68635148e-01f, 3.87009978e-01f, 1.43358052e-01f, 1.87294353e-02f, 1.06547080e-01f, 1.13663264e-01f, -1.59125775e-01f, -2.69990647e-03f, 7.72605836e-02f,
  2.09243312e-01f, 1.20064333e-01f, -1.16769910e-01f, 7.95555040e-02f, 1.15669869e-01f, 2.63280928e-01f, -3.42102461e-02f, -2.00514980e-02f, 9.61626647e-04f, -8.23314786e-02f,
  -2.36534283e-01f, -1.55725824e-02f, 2.67722845e-01f, 1.16738707e-01f, -1.79775089e-01f, -6.55855015e-02f, -9.63354260e-02f, -1.71850443e-01f, 6.07410222e-02f, -4.70283292e-02f,
  -1.13779768e-01f, -1.69365153e-01f, 9.36438963e-02f, 2.34721061e-02f, -1.24207608e-01f, -4.17851731e-02f, -2.05779120e-01f, -2.38321200e-01f, -1.69652313e-01f, -2.42505670e-02f,
  8.99256095e-02f, -1.35068208e-01f, -2.39664942e-01f, -5.78195192e-02f, -1.13618039e-01f, 1.39216334e-01f, -9.55801979e-02f, -1.58924863e-01f, -4.00270112e-02f, -2.61899233e-01f,
  1.79005921e-01f, 1.42246820e-02f, 1.25019802e-02f, -1.52676404e-02f, 9.33911130e-02f, 6.53919429e-02f, -1.38601571e-01f, -9.00967568e-02f, -4.45527881e-02f, -2.05827594e-01f,
  1.28142759e-01f, -2.32673548e-02f, -8.04554448e-02f, -2.85775624e-02f, 2.63872057e-01f, -1.21544257e-01f, -1.86014429e-01f, -5.88620491e-02f, -9.90977436e-02f, -7.63560981e-02f,
  7.04199895e-02f, -1.84074894e-01f, -4.27979529e-02f, -1.67266324e-01f, 8.77873823e-02f, -5.64088486e-02f, -4.08479944e-02f, 6.10087812e-02f, 1.70684561e-01f, 1.64791167e-01f,
  1.78804114e-01f, 3.45615327e-01f, 3.92477773e-02f, -6.51321337e-02f, -2.46905178e-01f, -1.89227723e-02f, 8.48304108e-02f, -3.04519571e-03f, -3.94434556e-02f, 1.46745667e-02f,
  -9.51545760e-02f, 5.21050096e-02f, 1.06913544e-01f, -1.96842272e-02f, -4.13846858e-02f, 4.75387089e-02f, 5.17707914e-02f, -1.70947403e-01f, -3.74722853e-02f, -2.42675573e-01f,
  -9.94685143e-02f, -7.07770810e-02f, -2.15766862e-01f, -1.46064654e-01f, -3.65817174e-02f, 1.93067595e-01f, -9.59771425e-02f, -3.20589617e-02f, -1.64048851e-01f, -1.23229310e-01f,
  -1.14562976e+00f, -8.93909670e-03f, -2.87551910e-01f, -7.68748283e-01f, -9.99786705e-02f, 1.03971764e-01f, 3.51389021e-01f, 3.30051407e-02f, -2.33222142e-01f, 3.08515847e-01f,
  1.80242538e-01f, -1.64000124e-01f, -3.62598389e-01f, -3.59942876e-02f, -2.66907424e-01f, 1.37194350e-01f, -3.63383412e-01f, -5.76371610e-01f, -4.62579370e-01f, 2.12404102e-01f,
  3.65309156e-02f, -5.18820703e-01f, -6.52496159e-01f, -3.02417129e-01f, 4.51316349e-02f, -2.06030577e-01f, -1.59237131e-01f, -2.01840967e-01f, 9.09986272e-02f, 3.28249000e-02f,
  2.10959777e-01f, -3.06170076e-01f, -4.68520261e-02f, -7.35481456e-02f, -8.82628411e-02f, -4.99377772e-02f, -9.26322415e-02f, -1.77190155e-01f, -2.17172224e-02f, 1.11905038e-02f,
  -1.14696406e-01f, 3.38981785e-02f, -2.58682251e-01f, -1.78577714e-02f, -1.32372096e-01f, 2.63693444e-02f, 8.80323127e-02f, -1.98150545e-01f, -5.31737367e-03f, 3.97682965e-01f,
  3.17108154e-01f, -7.50853643e-02f, -4.46550660e-02f, 1.44685254e-01f, 6.09944351e-02f, -7.78472945e-02f, 2.06878349e-01f, 1.09501414e-01f, 2.26518866e-02f, 1.72253415e-01f,
  1.57710776e-01f, 1.07635610e-01f, -2.43700240e-02f, -4.32301778e-03f, 8.02721605e-02f, -5.73894307e-02f, -5.62746115e-02f, -2.98994705e-02f, -3.53538133e-02f, -1.63532004e-01f,
  7.47198313e-02f, 1.21600181e-01f, 1.24725699e-01f, -1.49200052e-01f, -5.68426447e-03f, -1.17524818e-01f, -1.00665679e-02f, 1.17611326e-01f, -4.70258445e-02f, -1.04570098e-01f,
  -3.50947157e-02f, 8.52445439e-02f, -3.52340117e-02f, -4.20257039e-02f, 1.41532913e-01f, 8.62835273e-02f, 1.56249814e-02f, 6.08763434e-02f, 1.75980981e-02f, 4.12939563e-02f,
  -9.24116075e-02f, -2.42528334e-01f, -1.23163208e-01f, -1.07338719e-01f, -2.43914649e-01f, 1.08640321e-01f, 6.12683216e-05f, -3.13108861e-02f, -8.57627168e-02f, 1.30474433e-01f,
  2.11742595e-01f, -6.30867388e-03f, 2.03611664e-02f, 1.26637414e-01f, 6.82549551e-03f, 1.13147721e-01f, 1.19889215e-01f, -7.69640505e-02f, -5.31518720e-02f, 1.98799178e-01f,
  1.61179125e-01f, 4.36155051e-02f, -5.70234545e-02f, 1.05450831e-01f, 7.08459988e-02f, -1.15970112e-01f, 3.38740014e-02f, 9.47730392e-02f, -5.65471612e-02f, 1.67009026e-01f,
  -7.96080649e-01f, -3.01501721e-01f, -1.29106030e-01f, -2.14093208e-01f, 7.94757903e-02f, -5.08351251e-02f, -1.55195668e-01f, -2.87644356e-01f, -1.74163327e-01f, -2.27570504e-01f,
  -3.06951374e-01f, 1.08808383e-01f, 1.99634343e-01f, 3.13765258e-01f, 3.25869232e-01f, 2.56311059e-01f, 5.99540472e-01f, 5.10406137e-01f, 1.11879580e-01f, -7.57902116e-02f,
  2.44675010e-01f, 2.33944476e-01f, -1.61014069e-02f, 2.85491168e-01f, 1.78777203e-02f, 1.00537300e-01f, 8.50868672e-02f, 3.75112928e-02f, 1.79089159e-01f, 4.04713005e-01f,
  -5.93500793e-01f, -5.97706437e-01f, 2.20072582e-01f, 1.33212522e-01f, 6.93305954e-02f, -1.98170185e-01f, -1.92009047e-01f, 2.55699586e-02f, 1.88015953e-01f, -8.85363482e-03f,
  -4.13617492e-03f, -4.95996289e-02f, 4.01987955e-02f, -1.88691597e-02f, -1.65897772e-01f, -2.04481706e-01f, 1.54070273e-01f, 1.54453456e-01f, 3.58731672e-02f, -1.78455710e-01f,
  5.04327774e-01f, -1.78087011e-01f, -3.61189991e-01f, 2.61292197e-02f, -3.73507291e-02f, 2.13328943e-01f, -2.12977812e-01f, -4.16878790e-01f, -3.14771384e-01f, -2.96129733e-01f,
  -2.46630376e-03f, 1.41117081e-01f, -4.37273178e-03f, -2.01274958e-02f, 1.53565779e-01f, 1.20521220e-03f, 1.36340216e-01f, 2.56245345e-01f, 7.09986165e-02f, -6.07278645e-02f,
  9.05285850e-02f, -1.62798893e-02f, 2.37554163e-02f, -1.82222873e-01f, -8.89785513e-02f, -1.94350585e-01f, 7.47716948e-02f, 7.60700405e-02f, 1.60547301e-01f, -1.37091950e-01f,
  5.30545302e-02f, -2.31607277e-02f, -2.01252997e-02f, 1.90962926e-01f, -9.43819713e-03f, 7.56319091e-02f, -1.77171797e-01f, -1.31937563e-01f, -1.59613192e-01f, -6.23785965e-02f,
  -6.22929931e-01f, 4.29081142e-01f, -3.50150585e-01f, -4.25907597e-02f, -8.17439109e-02f, 7.45378956e-02f, -9.43826362e-02f, 5.16489260e-02f, -1.21863611e-01f, -2.06426129e-01f,
  -2.69243062e-01f, -8.87371302e-02f, -3.56341526e-02f, 2.12933779e-01f, -1.56210586e-01f, -3.07078779e-01f, 7.56529719e-02f, 1.04198672e-01f, -6.44627661e-02f, -1.23782776e-01f,
  1.07116282e-01f, -4.05720532e-01f, -6.24307454e-01f, -2.75861889e-01f, -2.21390620e-01f, -3.16467822e-01f, -1.81994960e-01f, -3.93123358e-01f, -2.83695906e-01f, -6.13285899e-01f,
  -1.78101480e-01f, -4.95233238e-01f, -3.19203198e-01f, 1.59184188e-01f, 4.22979832e-01f, -1.55317904e-02f, -4.69294161e-01f, -3.30397189e-01f, 4.19258550e-02f, -2.22706050e-01f,
  2.53329366e-01f, 4.32422489e-01f, -1.00714661e-01f, 4.92534190e-02f, -6.15826011e-01f, -7.14012563e-01f, -4.70759571e-01f, -2.92324454e-01f, -8.68745819e-02f, 2.19175965e-01f,
  3.62494528e-01f, 1.61001921e-01f, -1.14699574e-02f, -1.49038658e-02f, 6.30974844e-02f, 3.40057574e-02f, -3.27553421e-01f, 1.13825254e-01f, -1.12570085e-01f, 4.23551388e-02f,
  7.36338738e-03f, 1.64700180e-01f, 7.16870874e-02f, 1.51500627e-01f, 2.04599991e-01f, -7.79906213e-02f, 3.50302062e-03f, 1.21496588e-01f, 9.92569253e-02f, -1.04370572e-01f,
  1.68668985e-01f, 1.48220986e-01f, 1.94735184e-01f, 7.88889602e-02f, 2.63502449e-01f, -2.09944807e-02f, -3.04248706e-02f, -1.57673910e-01f, -4.33688998e-01f, 2.17239521e-02f,
  2.34676138e-01f, 1.37400433e-01f, -1.56422138e-01f, -3.79611373e-01f, -1.45150974e-01f, -1.39650941e-01f, -1.07715391e-01f, 1.40554920e-01f, -5.52585542e-01f, -3.80351901e-01f,
  5.10026738e-02f, 4.77563590e-02f, 9.87273306e-02f, 5.42676747e-02f, -3.34988236e-02f, 1.36012331e-01f, 1.67079251e-02f, 9.52401981e-02f, 1.20575577e-01f, -6.39989898e-02f,
  5.62599972e-02f, 3.56048793e-02f, 8.03267304e-03f, 2.96324715e-02f, -7.63602331e-02f, 9.63178184e-03f, -4.10569459e-02f, -1.78038850e-01f, -1.52430534e-01f, 2.08965689e-02f,
  -7.71388086e-03f, 1.84372634e-01f, 1.81667153e-02f, -5.65219969e-02f, -1.33836836e-01f, -3.75787653e-02f, 1.29903823e-01f, -1.11692145e-01f, -7.11369067e-02f, -2.13889722e-02f,
  -1.90125331e-01f, -1.33175209e-01f, -1.65532991e-01f, -6.09660558e-02f, 2.70604044e-01f, -3.17531154e-02f, -3.94109450e-02f, 5.88225722e-02f, 1.08409807e-01f, -1.25824615e-01f,
  1.06452413e-01f, -1.80132184e-02f, -1.32279947e-01f, -8.37715045e-02f, 1.27773449e-01f, -8.43959749e-02f, -1.91109970e-01f, 4.51772548e-02f, -2.11828008e-01f, 2.29865223e-01f,
  -2.34367251e-01f, -2.92458504e-01f, -2.39822865e-01f, -4.46801603e-01f, 1.30390832e-02f, -3.44394714e-01f, -2.97942907e-01f, -2.14668289e-01f, -4.43873495e-01f, -7.15844035e-01f,
  -4.58832949e-01f, 1.51294112e-01f, -1.37779415e-01f, 3.04135662e-02f, 2.87500054e-01f, -2.79595405e-01f, -3.94222021e-01f, -5.79356015e-01f, -2.35100865e-01f, 1.48785815e-01f,
  2.70714492e-01f, 2.82684952e-01f, 2.98635513e-01f, 3.28773521e-02f, -2.95880973e-01f, -1.08698070e-01f, -2.67417878e-02f, -1.53939918e-01f, -2.77874500e-01f, -1.32720560e-01f,
  2.88289040e-01f, 1.57130122e-01f, -2.41178527e-01f, -2.87640154e-01f, 2.65452892e-01f, 1.09196402e-01f, 8.38669091e-02f, 3.20162654e-01f, 3.15516263e-01f, 5.20370245e-01f,
  5.20808518e-01f, -2.87133694e-01f, -1.63658753e-01f, 7.55074546e-02f, 2.12383926e-01f, -1.52629405e-01f, -6.80474341e-02f, -1.99134618e-01f, -5.76184951e-02f, -1.55879959e-01f,
  2.42352948e-01f, -1.14725105e-01f, 1.36690319e-01f, 3.39591913e-02f, -1.12845093e-01f, -2.65204042e-01f, -2.47581288e-01f, -4.38083351e-01f, -3.29583019e-01f, -5.13103642e-02f,
  4.45749849e-01f, 3.04786325e-01f, 8.00454840e-02f, -2.44373560e-01f, -2.35097721e-01f, -3.11480016e-02f, -1.39392197e-01f, -1.52757317e-01f, -3.44638675e-01f, -1.94320194e-02f,
  -1.82863865e-02f, -4.30839648e-03f, 3.02367043e-02f, 2.93571129e-02f, 3.59772854e-02f, 8.03045183e-02f, 6.42038807e-02f, 3.53423059e-02f, -5.31630442e-02f, -3.12439371e-02f,
  -2.88565401e-02f, -7.06836581e-02f, -1.13978550e-01f, -5.57572171e-02f, 1.52533199e-03f, -5.90230478e-03f, 1.57102495e-02f, -8.32426026e-02f, -5.76257939e-03f, -3.66001613e-02f,
  4.81873788e-02f, -1.02105394e-01f, 1.21781342e-01f, -5.85861243e-02f, 7.87119642e-02f, -1.38334662e-01f, -7.57145584e-02f, -6.50851950e-02f, -8.18531066e-02f, -1.97239671e-04f,
  2.75243111e-02f, -1.24896914e-01f, 7.51930177e-02f, -2.11321875e-01f, 6.42819609e-03f, -6.50736839e-02f, 3.30719771e-03f, -1.59861267e-01f, 2.63431221e-02f, -1.28705204e-01f,
  -1.35904357e-01f, -1.44772068e-01f, 1.30616754e-01f, -2.93711256e-02f, -1.24528803e-01f, -9.64212641e-02f, 8.33541080e-02f, 5.66669703e-02f, -1.62904393e-02f, 1.38149662e-02f,
  -4.50820029e-02f, -1.95422605e-01f, -4.69609685e-02f, -5.77937178e-02f, 1.54622331e-01f, -8.09683576e-02f, 1.80534348e-01f, 7.37179071e-02f, -8.77721533e-02f, -8.40753168e-02f,
  1.08987713e+00f, 4.38156538e-02f, -8.63215625e-01f, 2.12081000e-01f, -6.29507780e-01f, -4.27608252e-01f, -4.02407467e-01f, 1.05768390e-01f, 2.83146530e-01f, -2.73188293e-01f,
  -1.22475050e-01f, 1.91188619e-01f, 8.08237344e-02f, -7.95403644e-02f, 4.85783257e-02f, -5.57509303e-01f, -4.55590308e-01f, -2.81658024e-01f, -2.33336851e-01f, -3.85194540e-01f,
  -3.09110045e-01f, -7.03830868e-02f, 2.38581866e-01f, -4.20950875e-02f, -2.41389871e-01f, -2.93995082e-01f, -6.41422451e-01f, -3.23067486e-01f, -3.63748550e-01f, -5.54662764e-01f,
  -5.77467620e-01f, 2.70010140e-02f, -2.12669566e-01f, 1.60171539e-01f, -1.89996049e-01f, 1.24125555e-01f, 3.18533741e-02f, 6.71822429e-02f, 1.89065054e-01f, 2.94293426e-02f,
  -2.36975290e-02f, 7.84245133e-02f, 1.19441457e-01f, -1.18580699e-01f, -1.34977087e-01f, 3.08715627e-02f, -1.30858719e-01f, -1.56732858e-03f, -1.26366124e-01f, -1.05190113e-01f,
  -1.87637564e-02f, -2.97562480e-02f, 2.24431232e-02f, -1.18153378e-01f, -1.38853922e-01f, 1.00417724e-02f, -2.92313755e-01f, -2.85262883e-01f, -1.64083377e-01f, -1.38110012e-01f,
  1.12649903e-01f, 3.55364643e-02f, -9.02310535e-02f, 9.50601026e-02f, 9.51332822e-02f, 5.40565327e-02f, 9.72843990e-02f, 7.05319224e-03f, -3.44857052e-02f, -2.64374483e-02f,
  -1.35720149e-01f, -2.21250439e-03f, 1.21247277e-01f, 1.56433940e-01f, -1.99277066e-02f, 1.04336776e-01f, 8.20700005e-02f, 9.33643952e-02f, 1.15008783e-02f, 9.40595493e-02f,
  -5.45848124e-02f, -5.97567670e-02f, 1.59719475e-02f, -3.75632755e-02f, -1.02137804e-01f, -1.71631656e-03f, 2.13153008e-02f, -4.32694238e-03f, 3.17935832e-02f, -1.85681544e-02f,
  -6.45468310e-02f, 5.69916912e-04f, 1.52508244e-01f, -1.98440570e-02f, -2.95807216e-02f, 5.77112213e-02f, 1.07035443e-01f, 3.70540842e-02f, 1.70984387e-01f, 6.53745309e-02f,
  -1.13555081e-01f, 1.18591771e-01f, 4.97410707e-02f, -1.23468235e-01f, -1.02711260e-01f, -3.69641408e-02f, 5.63498307e-03f, 4.31343354e-02f, 3.77204195e-02f, -5.13450615e-02f,
  8.72179400e-03f, 2.51063108e-01f, 2.37456158e-01f, 2.46120896e-02f, 4.88502346e-02f, 2.08080158e-01f, -1.39298588e-01f, -1.87082082e-01f, 1.16956264e-01f, 2.37645492e-01f,
  8.33924174e-01f, -1.34353101e-01f, -9.83641505e-01f, 2.82886416e-01f, -1.82524100e-01f, -1.68469131e-01f, -1.16203345e-01f, 4.05613601e-01f, 4.57345009e-01f, 1.59352832e-02f,
  -1.46904603e-01f, -1.27867818e-01f, -2.27839425e-01f, -1.63495913e-01f, -2.36828718e-02f, -3.92547250e-01f, -4.52402115e-01f, -4.49803859e-01f, -5.59616610e-02f, 1.63553014e-01f,
  3.72517049e-01f, 4.62842554e-01f, 4.51388210e-01f, 7.27291033e-02f, -8.52190927e-02f, 5.61460555e-02f, -3.09638172e-01f, -7.56559074e-02f, -2.29237780e-01f, -4.40928012e-01f,
  -4.48242962e-01f, -1.32749036e-01f, -2.17272267e-01f, 5.34737520e-02f, -2.47338768e-02f, 9.37523171e-02f, 1.52783073e-03f, -1.19059853e-01f, -1.23457730e-01f, -1.67689800e-01f,
  -1.46855429e-01f, -1.07514970e-01f, -2.66480923e-01f, -1.77363142e-01f, 1.38413580e-02f, 2.72496399e-02f, 3.47881354e-02f, -1.79925963e-01f, -1.91720575e-02f, -1.21144742e-01f,
  -1.23897530e-01f, -1.80151165e-01f, -2.86202073e-01f, -1.82738870e-01f, -1.11548774e-01f, -2.12312803e-01f, -2.51722634e-01f, -1.39846012e-01f, -1.13029569e-01f, 5.55260889e-02f,
  4.27068025e-02f, -3.13674361e-02f, 1.44297089e-02f, 7.83304647e-02f, 1.14952736e-01f, -9.21182856e-02f, -1.66067526e-01f, -1.91808399e-02f, -8.68851028e-04f, -5.23696980e-03f,
  -6.55004457e-02f, -1.30551821e-02f, -3.36608551e-02f, 4.78131883e-02f, 1.50657045e-02f, -1.53318703e-01f, -9.20695588e-02f, 4.82507460e-02f, 1.87834501e-02f, 1.51153803e-02f,
  1.47680352e-02f, -5.84493242e-02f, 4.86139581e-02f, 7.72458836e-02f, -1.05096370e-01f, -4.56216410e-02f, -4.43297625e-02f, -6.34772852e-02f, 1.45112751e-02f, 1.27974749e-01f,
  4.25216854e-01f, 2.82118600e-02f, 8.63764714e-03f, -7.11366758e-02f, -4.66039462e-04f, -1.99026167e-02f, -4.76311222e-02f, -1.32218879e-02f, -3.69636193e-02f, -1.83046404e-02f,
  -6.63060695e-02f, -8.89010578e-02f, -1.14391692e-01f, -6.28877059e-02f, -1.59636680e-02f, 6.09814562e-02f, 2.20219269e-01f, -2.27917655e-04f, 8.49470571e-02f, 1.77004814e-01f,
  1.84908971e-01f, 1.26590297e-01f, 1.52578086e-01f, 9.90373343e-02f, 1.04098953e-01f, 9.03718993e-02f, 1.71663482e-02f, 2.12527066e-02f, 8.23009610e-02f, 5.52265704e-01f,
  -3.44787464e-02f, -1.87890064e-02f, -2.76934486e-02f, 3.34334731e-01f, 4.91361111e-01f, 3.42227906e-01f, 6.05641305e-01f, 2.68983692e-01f, 1.69001415e-01f, 1.30393058e-02f,
  -2.90608644e-01f, -3.81950170e-01f, -2.94807255e-01f, -3.21549475e-01f, -1.95529774e-01f, 2.11330473e-01f, 2.29905695e-01f, -9.38011184e-02f, -1.04744002e-01f, 9.41364188e-03f,
  1.08856186e-01f, 2.08930746e-01f, -8.14865977e-02f, -2.59662922e-02f, 1.00471720e-01f, -6.99359179e-02f, 1.09061882e-01f, 7.97928870e-02f, -9.09278095e-02f, -1.46334901e-01f,
  -8.77469122e-01f, -1.32922798e-01f, -7.00371489e-02f, -1.39599070e-01f, -9.76036415e-02f, -1.32231236e-01f, 1.81763675e-02f, -1.16418347e-01f, -4.08368409e-02f, -4.68910560e-02f,
  -3.65258269e-02f, -1.70734767e-02f, 7.45979100e-02f, -1.87770966e-02f, 1.20745756e-01f, -1.55486418e-02f, 5.90847097e-02f, -2.16742590e-01f, -1.98296204e-01f, -2.56250113e-01f,
  -6.19725510e-02f, -5.68596199e-02f, 4.51927818e-02f, -1.42734665e-02f, -7.96741769e-02f, -1.88184410e-01f, -8.63023624e-02f, -1.98578566e-01f, -2.47469470e-01f, -2.15338245e-02f,
  -1.40870482e-01f, -2.14616060e-02f, 3.57629694e-02f, 7.65696447e-03f, 1.02835685e-01f, 2.16785930e-02f, 1.67983286e-02f, -8.47698562e-03f, 3.97205129e-02f, 8.12854841e-02f,
  4.37186174e-02f, -2.87227500e-02f, -1.00254685e-01f, -6.30919710e-02f, -1.16459645e-01f, 9.62271821e-03f, 1.92501699e-03f, -6.64625242e-02f, -1.62136838e-01f, 1.92770168e-01f,
  -7.46414810e-02f, -9.34490655e-03f, -5.50027154e-02f, 4.30312082e-02f, -4.60397080e-02f, -1.78636722e-02f, -9.17068217e-03f, 3.88917252e-02f, 1.16087474e-01f, 1.44720510e-01f,
  1.24161482e-01f, -1.13637753e-01f, -1.46143273e-01f, -1.10852584e-01f, -3.76079939e-02f, -6.53857216e-02f, -1.30081177e-01f, -1.94179669e-01f, 9.26887244e-03f, -1.44053236e-01f,
  3.09551712e-02f, -7.63812065e-02f, -8.06084946e-02f, 7.07625821e-02f, 1.52366102e-01f, 3.51665961e-03f, -5.58758527e-03f, 5.69386333e-02f, -3.14904898e-02f, -1.18127264e-01f,
  1.20121958e-02f, 2.37844676e-01f, 1.34919181e-01f, -2.65643131e-02f, -5.65763265e-02f, -3.32124047e-02f, 4.30387110e-02f, 9.93175954e-02f, 7.39236623e-02f, 2.95260459e-01f,
  -4.89152074e-01f, -2.83546716e-01f, -2.66034663e-01f, -6.83775663e-01f, -2.46248871e-01f, 1.69767544e-01f, -2.03690305e-01f, -2.31504411e-01f, -3.42991740e-01f, -5.71975410e-01f,
  -3.48192364e-01f, -7.89026096e-02f, -3.48348230e-01f, -4.10299599e-02f, -1.16610013e-01f, -4.79472667e-01f, -4.96225238e-01f, -1.62937149e-01f, 2.76669949e-01f, 1.86732322e-01f,
  -1.93337779e-02f, -3.33511055e-01f, -1.29685581e-01f, -1.58916429e-01f, -5.64732611e-01f, -1.98645145e-01f, -4.27659392e-01f, -2.47362256e-01f, 1.20391153e-01f, -4.41311628e-01f,
  -4.80221182e-01f, -1.46291256e-01f, 3.79231840e-01f, -4.76381294e-02f, -3.82666618e-01f, 1.12703621e-01f, 7.81527534e-02f, -1.42367721e-01f, 3.35436910e-01f, -1.68438479e-01f,
  -8.44798833e-02f, 2.42886156e-01f, 6.20316453e-02f, 7.54795671e-02f, 2.88855713e-02f, -8.99440199e-02f, -8.52917507e-02f, -1.30678982e-01f, 1.69796566e-03f, 6.41891286e-02f,
  1.44172728e-01f, 9.65049565e-02f, 7.88858905e-02f, 1.94960192e-01f, 1.41043395e-01f, 1.63427338e-01f, 2.02809259e-01f, 1.28815308e-01f, 2.60251313e-01f, -4.65647817e-01f,
  -1.53433150e-02f, -7.64466897e-02f, 7.05049783e-02f, 3.60775590e-02f, 1.19506828e-02f, 1.47251219e-01f, -6.55992031e-02f, -6.63628280e-02f, 1.14464588e-01f, -2.50087120e-04f,
  1.42074421e-01f, -2.77654845e-02f, -6.49097860e-02f, -1.20984234e-01f, 1.04929216e-01f, -7.87154492e-03f, -8.09156001e-02f, -1.65443507e-03f, 8.17740615e-03f, 1.27078276e-02f,
  4.62636799e-02f, 6.22276068e-02f, -7.66534731e-02f, -6.55347407e-02f, 1.33381411e-02f, -2.45135263e-01f, 5.59640713e-02f, 3.86468731e-02f, -8.68034139e-02f, 6.17676787e-02f,
  -6.70193195e-01f, 5.25690734e-01f, -3.94960135e-01f, 8.58891904e-02f, -1.54611185e-01f, 4.15878035e-02f, -1.24199159e-01f, -1.95005223e-01f, -1.00030728e-01f, -2.02301174e-01f,
  2.04727441e-01f, -1.09487399e-01f, -1.05802901e-01f, 8.44508484e-02f, 8.64021759e-03f, 5.42206578e-02f, 2.10001916e-02f, -5.37925325e-02f, 7.82595947e-02f, 1.05016381e-01f,
  9.52320620e-02f, -1.67515188e-01f, -1.90585822e-01f, -1.06699467e-01f, -1.41975917e-02f, -9.74824503e-02f, -1.70149595e-01f, -6.29988685e-02f, -7.89046586e-02f, -6.01910651e-01f,
  -5.03994048e-01f, 4.58959639e-01f, 5.46824992e-01f, -2.65324891e-01f, 1.47753591e-02f, -7.79718813e-03f, 1.48103461e-01f, 8.67222920e-02f, -1.84678528e-02f, 2.77475029e-01f,
  1.44040227e-01f, -4.13068980e-01f, 6.10930920e-02f, -2.11495981e-01f, -4.73891795e-02f, 3.08922857e-01f, 2.71287024e-01f, -1.32888844e-02f, -3.74642283e-01f, -6.68104768e-01f,
  -4.37655836e-01f, -2.91959375e-01f, -1.94337368e-01f, -9.94046405e-02f, -1.47388563e-01f, -3.35966527e-01f, 4.88392651e-01f, -6.26395037e-03f, 3.10195405e-02f, -7.43253008e-02f,
  7.35944360e-02f, 2.89939582e-01f, -1.92657635e-01f, -2.79079407e-01f, -1.50088742e-01f, -4.15357612e-02f, -2.25774688e-03f, 1.24805816e-01f, -3.39536443e-02f, 1.50033906e-01f,
  -5.19055575e-02f, 1.45604480e-02f, -7.64823332e-02f, -3.09830252e-02f, -7.79143646e-02f, -1.33099213e-01f, 5.61396070e-02f, 1.43301962e-02f, -6.33531809e-02f, 4.67949584e-02f,
  -3.96278590e-01f, -2.26545885e-01f, 3.22663516e-01f, 2.39725396e-01f, 3.42434883e-01f, -1.98165596e-01f, 1.23247601e-01f, -2.18520746e-01f, 1.81555077e-01f, -1.18648186e-01f,
  -5.95426708e-02f, 5.27672879e-02f, 7.59805292e-02f, 4.94090468e-02f, -2.59046048e-01f, 4.77987342e-02f, 6.18433133e-02f, -1.97294168e-02f, -1.40226439e-01f, -5.24686612e-02f,
  9.07415226e-02f, -7.21489266e-02f, 9.84460339e-02f, 2.25946769e-01f, -1.75568685e-02f, 7.25689009e-02f, -1.47004992e-01f, -6.24653697e-02f, 1.56304836e-02f, -2.26442498e-04f,
  -2.74489610e-03f, 1.88453812e-02f, 7.11228848e-02f, -2.75998730e-02f, 7.23080412e-02f, -1.22998953e-01f, -1.41474918e-01f, -5.87360486e-02f, 1.62256579e-03f, 1.24941237e-01f,
  -1.90338641e-01f, 1.23482086e-01f, -1.28445998e-01f, -9.09048468e-02f, 1.75960939e-02f, 7.34746903e-02f, 9.75839868e-02f, 6.35100901e-02f, -1.75824407e-02f, 1.29302230e-03f,
  1.02592863e-01f, -1.04840882e-01f, 2.90052444e-02f, -1.44302368e-01f, -2.04722688e-01f, 3.46399769e-02f, -1.33514628e-01f, -2.29219124e-01f, -7.36695081e-02f, -1.48118198e-01f,
  -1.28275037e-01f, -3.70027453e-01f, -4.91299689e-01f, -7.83874691e-02f, -1.99365124e-01f, -4.34119850e-01f, -2.86103249e-01f, -4.70957458e-01f, -1.75576761e-01f, -4.98929918e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  4.88442779e-01f, 3.57775778e-01f, 5.79616725e-01f, -1.70532420e-01f, 6.37249529e-01f, 5.27688861e-01f, 1.00900173e+00f, 4.57314372e-01f, 4.72672611e-01f, 4.00954336e-01f,
  2.38561660e-01f, 6.28860831e-01f, 4.65562612e-01f, 8.16673636e-02f, 5.61968803e-01f, 2.16488525e-01f, 3.49190325e-01f, 7.95634449e-01f, 4.13828701e-01f, 5.76071322e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.00774989e-01f, 2.01179624e-01f, 6.30338537e-03f, -3.71298194e-02f, -1.35982167e-02f, -2.43649818e-02f, -1.58395335e-01f, -2.76905317e-02f, 6.21688776e-02f, 5.56972511e-02f,
  -7.88277090e-02f, -4.39993255e-02f, 3.66960377e-01f, -6.62509948e-02f, -2.19013635e-02f, 1.09924436e-01f, 1.05644807e-01f, 1.31613985e-01f, 5.25582671e-01f, -3.34156096e-01f,
  3.24791461e-01f, -5.85835278e-02f, -6.85200281e-03f, -3.54634404e-01f, -2.33064666e-01f, -1.87041804e-01f, -2.48431414e-01f, 1.71613783e-01f, 2.06163511e-01f, 2.25071702e-02f,
  -1.15540355e-01f, -1.36890531e-01f, 2.18735814e-01f, -1.15171177e-02f, -3.99896242e-02f, 1.47551075e-01f, 1.11950465e-01f, 2.39038491e-03f, 5.94419837e-02f, -1.89108074e-01f,
  2.03417381e-03f, -1.43730268e-01f, 2.21419651e-02f, 1.94033727e-01f, -2.29451433e-01f, -1.38710275e-01f, 5.06168902e-02f, 1.76997438e-01f, -6.01887591e-02f, 2.94852167e-01f,
  -6.84606284e-02f, -4.97034788e-01f, -2.08366215e-01f, 6.05705194e-02f, -7.74992332e-02f, -2.00093146e-02f, 4.45116252e-01f, 3.65950048e-01f, 1.75953403e-01f, -2.67947204e-02f,
  -6.48424253e-02f, -3.38228405e-01f, -6.78862929e-02f, -3.04978546e-02f, -1.37489304e-01f, -7.92427212e-02f, 1.14998937e-01f, -8.05913210e-02f, 9.58975330e-02f, 3.18076573e-02f,
  2.15095073e-01f, 1.05896577e-01f, -3.67084928e-02f, 1.38795331e-01f, -1.24553747e-01f, -1.73130363e-01f, -2.25322977e-01f, 4.02001411e-01f, 2.43450508e-01f, -2.72495985e-01f,
  -1.13560386e-01f, -9.22778994e-02f, -3.12184058e-02f, -2.05112100e-01f, -4.67881203e-01f, 1.51556721e-02f, 3.04251105e-01f, 4.39312309e-02f, -9.35589001e-02f, -1.50516853e-01f,
  3.08042705e-01f, -6.84500411e-02f, 9.87603515e-02f, 3.34430605e-01f, -4.10678536e-01f, -3.94990966e-02f, -5.01669534e-02f, -1.39787197e-02f, 2.33609453e-02f, -1.09826192e-01f,
  -4.47153151e-02f, 2.92657199e-03f, 1.81903429e-02f, 1.84678644e-01f, 3.72166224e-02f, 1.50501594e-01f, 1.24380857e-01f, 1.44478679e-01f, -5.90793304e-02f, -4.63339724e-02f,
  8.84519592e-02f, -2.01576099e-01f, 9.99516770e-02f, 2.33992293e-01f, -4.84661430e-01f, 3.57638806e-01f, -2.80663848e-01f, -2.51917797e-03f, 1.26777925e-02f, 1.37416393e-01f,
  -1.25768811e-01f, 3.97028387e-01f, -1.12712681e-01f, -5.35009019e-02f, 3.77950668e-01f, 3.03254277e-01f, -1.51927739e-01f, -6.00188933e-02f, -2.06773221e-01f, -1.78483620e-01f,
  -1.34387210e-01f, -1.59345016e-01f, 1.97240025e-01f, 6.93658367e-02f, 1.60644859e-01f, 2.14787558e-01f, 3.17480080e-02f, -8.14383384e-03f, 3.53256799e-02f, 9.54116806e-02f,
  -3.33509594e-02f, 3.18683922e-01f, -1.02733918e-01f, 3.67243923e-02f, 1.17338695e-01f, -2.09089071e-01f, 2.76769042e-01f, -6.76768541e-01f, -4.65808928e-01f, 1.28935948e-01f,
  7.56046325e-02f, 1.68188423e-01f, -7.04773590e-02f, 2.01783463e-01f, 3.32612365e-01f, -1.59991950e-01f, -1.70518562e-01f, 1.05100013e-01f, -2.07551941e-01f, -1.46240458e-01f,
  2.07094233e-02f, -8.77612978e-02f, -3.53309512e-02f, 2.11323239e-02f, 1.36082143e-01f, -7.01929033e-02f, 6.40882850e-02f, 1.51037738e-01f, 2.51101851e-01f, -1.04738452e-01f,
  1.44156963e-01f, -2.45724488e-02f, 6.78809509e-02f, -2.13100597e-01f, -7.81513751e-02f, 2.06088081e-01f, 2.42755830e-01f, 1.17808379e-01f, -2.29676366e-01f, 3.70963424e-01f,
  -2.30749488e-01f, -9.95204877e-03f, -3.13984640e-02f, -1.94214836e-01f, 1.48082748e-01f, 1.40470847e-01f, -9.52062476e-03f, -1.02957189e-01f, 1.12822931e-03f, -5.76831102e-02f,
  -1.85819104e-01f, 1.46893531e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.52313918e-01f, 8.93893093e-02f, -5.89963645e-02f, 1.46857500e-02f, 1.56018168e-01f, 1.70712188e-01f, 4.70444083e-01f, 1.24460667e-01f, 9.56316888e-02f, 2.71481067e-01f,
  1.40487283e-01f, 1.55521527e-01f, 2.37244546e-01f, -1.25470951e-01f, 2.19325393e-01f, -2.12731697e-02f, 2.82365888e-01f, -2.71407038e-01f, 1.98550850e-01f, -6.74430430e-01f,
  -3.73361796e-01f, 3.09107333e-01f, 4.33011442e-01f, -8.76258686e-02f, 8.49513188e-02f, -1.82044223e-01f, 5.91461480e-01f, 6.76021397e-01f, 6.83560789e-01f, 6.36887997e-02f,
  -3.97187322e-01f, -4.61308897e-01f, 7.79190063e-02f, 2.81893332e-02f, 5.32019325e-02f, 1.94424614e-01f, 5.01035973e-02f, 3.54505509e-01f, -6.19264804e-02f, 2.00134456e-01f,
  -1.89906999e-01f, -3.35657150e-02f, 6.92554340e-02f, -2.24299170e-02f, -7.21196691e-03f, 2.42544979e-01f, 2.03504413e-01f, 1.12303793e-01f, -1.85220197e-01f, -1.49114668e-01f,
  1.05764115e+00f, -3.90648305e-01f, -4.98707980e-01f, 1.04999416e-01f, -2.66616076e-01f, -1.08977899e-01f, 2.45738432e-01f, -7.47379065e-01f, 3.47591966e-01f, -3.53701323e-01f,
  -3.41918208e-02f, 6.00790858e-01f, -5.62226593e-01f, 1.15668155e-01f, 1.56927198e-01f, 4.53226626e-01f, -1.58541828e-01f, 6.30969629e-02f, 1.33544058e-01f, 7.33578801e-02f,
  3.26571107e-01f, 1.60682559e-01f, -2.26566747e-01f, -1.91318281e-02f, -2.79325336e-01f, 8.18414330e-01f, 9.82009768e-02f, 3.24711144e-01f, 5.09468794e-01f, -1.68483049e-01f,
  6.07027233e-01f, 5.86494088e-01f, -4.75231975e-01f, -1.00179791e+00f, 2.23379403e-01f, 8.50156918e-02f, 6.28398359e-02f, -1.51370661e-02f, -3.30739349e-01f, 3.75495315e-01f,
  2.11124405e-01f, 4.44561422e-01f, 9.98700619e-01f, -8.47017691e-02f, -3.50311249e-01f, -1.62182525e-01f, -6.60535991e-02f, 7.51392916e-02f, 1.05761468e-01f, -1.28987715e-01f,
  6.89457208e-02f, 6.99017383e-03f, -2.71035939e-01f, 2.15267260e-02f, -6.04671203e-02f, -3.22661161e-01f, -1.51803970e-01f, -2.34088957e-01f, 1.43672571e-01f, -1.55897111e-01f,
  -2.67165959e-01f, 2.78008729e-01f, 2.94468813e-02f, 8.20001960e-01f, -1.37009040e-01f, 1.36839017e-01f, 4.71222401e-01f, -7.87245333e-02f, 3.80902082e-01f, -3.22868489e-02f,
  6.28998637e-01f, 6.60709620e-01f, 2.32801124e-01f, 5.14501989e-01f, 2.27470577e-01f, -3.96690696e-01f, 9.07271922e-01f, -8.25573429e-02f, 2.12607533e-01f, 5.47256097e-02f,
  4.34888294e-03f, 1.97872564e-01f, -6.21860474e-02f, 2.00356141e-01f, -7.70891979e-02f, 2.16690898e-01f, -4.72993739e-02f, -2.14596525e-01f, 2.99385265e-02f, 3.09095472e-01f,
  -6.33869708e-01f, 3.24457407e-01f, 5.39901316e-01f, 1.40183732e-01f, -2.96775222e-01f, 5.90465553e-02f, -4.43538666e-01f, -2.14115202e-01f, 3.61486405e-01f, 1.48647264e-01f,
  6.15121663e-01f, 3.64311606e-01f, 1.54869482e-01f, 7.07046270e-01f, 7.51337528e-01f, 2.27581412e-01f, 5.05984128e-01f, 2.76951790e-01f, 1.81536198e-01f, -3.76496851e-01f,
  7.84625411e-02f, -6.22103252e-02f, 1.42832354e-01f, -7.43546486e-02f, -9.17996690e-02f, 1.53464630e-01f, 4.97687608e-04f, -1.15489058e-01f, -1.87439188e-01f, 1.61316488e-02f,
  -1.80159852e-01f, -3.40892583e-01f, 1.47481546e-01f, 5.32106340e-01f, 4.92559433e-01f, 2.30812758e-01f, 2.86357313e-01f, 2.34337211e-01f, -5.02349734e-01f, 7.43597627e-01f,
  7.42809653e-01f, -1.85651779e-01f, 4.19423282e-01f, 6.65410697e-01f, -3.96792918e-01f, 3.35292935e-01f, -6.28288269e-01f, 4.21413958e-01f, 1.87144935e-01f, -3.90627868e-02f,
  5.63023746e-01f, 5.86050451e-01f, 2.85365820e-01f, 4.11616936e-02f, 8.03679153e-02f, 7.94951618e-02f, -1.08187377e-01f, -4.30107117e-02f, 6.05157837e-02f, 5.34048826e-02f,
  2.30938926e-01f, 2.35726818e-01f, 4.04588252e-01f, -1.13556460e-01f, 1.99025363e-01f, -5.45170486e-01f, -2.39057839e-01f, -1.82816833e-01f, 6.63165331e-01f, -9.65048969e-01f,
  3.82881552e-01f, 3.96598816e-01f, -6.31634891e-01f, 2.30046079e-01f, 1.13151725e-02f, -3.40305865e-01f, -2.68472582e-02f, -2.99083889e-01f, -2.83790857e-01f, -7.41323590e-01f,
  1.00017317e-01f, 7.08193064e-01f, -8.35435212e-01f, 6.03312552e-01f, 8.53329524e-02f, 3.77249807e-01f, 6.35706857e-02f, 3.98792028e-02f, 1.73520878e-01f, 1.25104085e-01f,
  1.74687624e-01f, 7.36841261e-02f, -3.81281562e-02f, 2.88027734e-01f, -7.09246770e-02f, -2.85711229e-01f, 4.92892385e-01f, 3.64688665e-01f, 1.85662583e-01f, 1.17068887e-01f,
  -2.81455517e-01f, 2.13386804e-01f, 2.01726601e-01f, -6.59649400e-03f, -1.95047930e-01f, -7.66900629e-02f, 5.60089469e-01f, 1.00704223e-01f, 7.79552698e-01f, -4.22505707e-01f,
  -3.79983693e-01f, -6.66318554e-03f, -7.67666548e-02f, 4.77443516e-01f, 2.58101195e-01f, 5.73072851e-01f, 3.05733979e-01f, 1.82572111e-01f, -7.16563389e-02f, 5.55731803e-02f,
  3.63571495e-02f, 2.05843389e-01f, 6.80577978e-02f, -1.72193781e-01f, -6.59970269e-02f, -4.54811364e-01f, 4.90501039e-02f, 3.07154000e-01f, -4.79750335e-01f, 3.03212732e-01f,
  2.16799751e-01f, 8.74919072e-02f, 1.36246905e-01f, 8.84444058e-01f, -1.30088389e-01f, -5.05580604e-01f, 3.35329562e-01f, 1.11661382e-01f, -9.47129279e-02f, 2.46020406e-01f,
  9.64228511e-02f, 6.67889833e-01f, 7.28253424e-01f, -2.19009474e-01f, -3.57247621e-01f, -7.02007532e-01f, 1.26160875e-01f, 1.87319949e-01f, 3.83778252e-02f, 8.75552893e-02f,
  2.39080247e-02f, 2.08098635e-01f, 5.88980496e-01f, 2.83596843e-01f, 5.56496799e-01f, -3.03765595e-01f, -3.29727381e-02f, 1.20268621e-01f, 4.62867767e-02f, -6.28684536e-02f,
  -5.08997262e-01f, 8.34922716e-02f, 8.97271093e-03f, -4.06286001e-01f, 3.39796484e-01f, 5.14399111e-01f, -7.54630744e-01f, -1.12859055e-01f, -4.91697818e-01f, 3.42009723e-01f,
  -5.76816201e-02f, 3.01437527e-01f, 7.31026709e-01f, 4.43197787e-01f, 6.04543388e-01f, -2.45533183e-01f, -8.41902018e-01f, 1.01706780e-01f, 5.69307841e-02f, 7.71178186e-01f,
  3.44431609e-01f, 3.93862486e-01f, 1.39554292e-01f, -8.35739728e-03f, -3.41869481e-02f, 1.70976326e-01f, -1.33774191e-01f, -1.65315837e-01f, 2.03472242e-01f, 2.70273656e-01f,
  3.07410717e-01f, 4.35950935e-01f, -1.84582323e-01f, -3.32718998e-01f, -2.55278170e-01f, -8.41183811e-02f, 7.07498133e-01f, -2.83581555e-01f, 5.45902876e-03f, 5.32056808e-01f,
  -5.04413962e-01f, 4.67929482e-01f, -1.46555066e-01f, -3.50392520e-01f, -4.94199879e-02f, 6.11581206e-01f, 2.84967750e-01f, -5.25829829e-02f, -2.55390316e-01f, 2.91134208e-01f,
  -1.71121508e-01f, 4.26382780e-01f, 3.32917243e-01f, 2.60905474e-01f, 1.21845584e-02f, 1.88327178e-01f, 3.81638557e-02f, 1.32296100e-01f, 3.88663933e-02f, -4.46321629e-02f,
  -9.08984244e-02f, -7.09610581e-02f, -2.73512036e-01f, -3.31983149e-01f, 1.00705316e-02f, 3.00331086e-01f, 2.51707792e-01f, -4.53260541e-01f, 4.43084121e-01f, -4.08149213e-01f,
  7.38890827e-01f, 1.03670549e+00f, 3.27371567e-01f, -1.00997426e-01f, -3.14068049e-01f, 4.54631567e-01f, 2.89094895e-01f, -2.31520668e-01f, 3.06015849e-01f, -4.89633143e-01f,
  -7.76137471e-01f, -1.58878654e-01f, 3.32384825e-01f, 6.65242612e-01f, 1.35260329e-01f, 3.15552115e-01f, 4.37143230e-04f, 1.50985077e-01f, 1.44207656e-01f, 2.31740803e-01f,
  -1.59375027e-01f, 6.70943409e-02f, -8.57401267e-02f, 2.15254351e-01f, 4.04122844e-02f, -1.37049973e-01f, 2.46673837e-01f, 2.42494851e-01f, 8.76052305e-02f, -1.21884845e-01f,
  -4.05908734e-01f, -2.75132239e-01f, 4.48582232e-01f, -4.90464032e-01f, 3.73033911e-01f, 3.36057961e-01f, 1.22406997e-01f, 6.14220351e-02f, -7.04131052e-02f, -6.18549772e-02f,
  3.33241150e-02f, 2.15477031e-02f, 7.61110604e-01f, 7.86186337e-01f, -2.41915416e-02f, -6.91035271e-01f, 5.98618425e-02f, 1.72790289e-01f, 1.20166749e-01f, -7.43595660e-02f,
  3.84964466e-01f, -1.95036475e-02f, 1.44460529e-01f, -1.53239071e-03f, -2.40872860e-01f, -9.49242115e-02f, -1.22451238e-01f, 4.00519580e-01f, -3.64614278e-01f, 3.66201550e-01f,
  4.14536178e-01f, -1.25824541e-01f, -3.12958747e-01f, 1.09250911e-01f, -6.41846657e-01f, 5.28647780e-01f, -5.49352884e-01f, 2.33497575e-01f, 6.16192698e-01f, 1.28651276e-01f,
  -2.16330886e-01f, 1.55094370e-01f, 1.03030694e+00f, 1.17010422e-01f, 1.58916980e-01f, 5.01009762e-01f, -9.50043127e-02f, 3.75290483e-01f, 7.79903457e-02f, 2.38300964e-01f,
  -1.33829042e-02f, 2.81914413e-01f, 6.37804791e-02f, 4.96329404e-02f, -4.43876445e-01f, -2.05976099e-01f, 2.41626352e-01f, -4.00199354e-01f, 1.39355794e-01f, -1.90820754e-01f,
  1.51192084e-01f, -6.07819676e-01f, -1.56603023e-01f, -1.80059955e-01f, 6.93291426e-01f, 4.34593409e-01f, -6.39283508e-02f, -4.46227401e-01f, 7.34301627e-01f, 2.64234722e-01f,
  8.61594528e-02f, -1.40118659e-01f, 6.09177291e-01f, 2.67414838e-01f, -2.65298158e-01f, 2.00635403e-01f, 1.39476851e-01f, -9.02397811e-01f, 5.34577608e-01f, -5.55801034e-01f,
  2.64631420e-01f, 2.34920397e-01f, 1.03943562e-02f, -8.16094130e-02f, 2.45644465e-01f, -7.48058334e-02f, 1.36024743e-01f, 1.51239216e-01f, 2.86292225e-01f, 8.61828551e-02f,
  -5.91776669e-02f, -2.37856075e-01f, -1.59408838e-01f, 1.05155811e-01f, -2.06218600e-01f, -1.13592543e-01f, -3.10687721e-01f, -8.42012525e-01f, 4.61751521e-01f, 5.25428355e-01f,
  -1.08766802e-01f, 3.20543379e-01f, 1.72045231e-01f, 3.16118240e-01f, 3.10323238e-01f, 3.49342525e-01f, 6.78248346e-01f, 8.17840621e-02f, 4.01402712e-01f, 4.34127063e-01f,
  3.47559243e-01f, 1.07211992e-01f, -1.69386849e-01f, 5.63111641e-02f, 2.42317811e-01f, -1.64229974e-01f, 2.33234894e-02f, -6.29529729e-02f, 2.23804116e-02f, 1.79994836e-01f,
  -9.61764902e-02f, -2.02502191e-01f, -2.00914264e-01f, -1.95569977e-01f, -1.34306431e-01f, -2.38417014e-01f, 1.71488225e-01f, 1.78875729e-01f, -7.25688636e-02f, 9.79995206e-02f,
  1.00813675e+00f, -2.84162253e-01f, 1.67360306e-01f, 2.61263877e-01f, 7.99012855e-02f, -2.57973909e-01f, 5.80220938e-01f, 1.97867841e-01f, 6.90290332e-01f, 5.60986921e-02f,
  -4.23366964e-01f, 3.38545889e-01f, -4.18423027e-01f, -4.83216822e-01f, -1.85578570e-01f, 2.00595096e-01f, 1.37442306e-01f, 2.45272323e-01f, 2.94118494e-01f, 2.74259478e-01f,
  6.69620633e-02f, -8.32484141e-02f, -2.01738492e-01f, 1.09184511e-01f, -2.09536865e-01f, 7.31221959e-02f, 2.99388558e-01f, 8.39487910e-02f, 5.08825600e-01f, 5.25229722e-02f,
  5.32646239e-01f, 3.76375943e-01f, -4.03333008e-02f, 2.88659424e-01f, -3.60244736e-02f, 1.48291916e-01f, 1.93689555e-01f, -1.17154732e-01f, -7.82371759e-01f, -1.66234449e-01f,
  -1.27651706e-01f, 4.20302927e-01f, 3.31983715e-01f, 4.07056093e-01f, -4.56007212e-01f, 1.94966257e-01f, 3.47824723e-01f, 1.62230924e-01f, 2.78223813e-01f, 2.79057324e-01f,
  3.51518840e-01f, 2.93200493e-01f, 1.23722024e-01f, 2.11393572e-02f, 8.33455250e-02f, -1.31401703e-01f, -3.42082322e-01f, 5.15238881e-01f, -5.16395748e-01f, 2.90240020e-01f,
  3.42363864e-01f, -3.34384590e-01f, 1.79948792e-01f, 3.39864671e-01f, 2.08042096e-03f, 7.02181971e-03f, -1.62636951e-01f, 1.16258129e-01f, -9.59687978e-02f, 3.33383866e-02f,
  4.95210499e-01f, -9.86571908e-02f, 7.68926740e-01f, -1.37712583e-01f, 4.18677986e-01f, 3.69930327e-01f, -5.27452886e-01f, 4.52362686e-01f, 1.54775873e-01f, 1.53176002e-02f,
  3.05018038e-01f, 1.61285564e-01f, 3.71650010e-01f, 2.26269692e-01f, -2.75341064e-01f, -1.25549272e-01f, -2.03940719e-01f, 6.59939498e-02f, -7.27815703e-02f, -3.02818000e-01f,
  3.65584850e-01f, -6.23017013e-01f, 3.86066169e-01f, -1.69265658e-01f, 2.20401376e-01f, 8.32448363e-01f, 3.92720282e-01f, 9.90510881e-01f, 8.85210752e-01f, 4.45236892e-01f,
  2.93306440e-01f, -6.01964712e-01f, -2.50991940e-01f, -5.66974640e-01f, -3.51952165e-01f, 5.95098376e-01f, 5.11688769e-01f, 6.75300777e-01f, 1.50177181e-01f, -3.15942079e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.76396209e-01f, -1.34179249e-01f, 2.59150773e-01f, 3.49591643e-01f, -1.27966721e-02f, -3.84353250e-02f, 2.23147199e-01f, -9.76126045e-02f, 5.36148250e-01f, 7.10843265e-01f,
  8.23541701e-01f, 7.67662883e-01f, -6.58108329e-04f, 2.61028469e-01f, 3.23978543e-01f, -6.98046684e-02f, -1.48960963e-01f, 3.58242512e-01f, 5.07609248e-01f, -2.31298562e-02f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  1.92331165e-01f, -5.07235587e-01f, -7.40704656e-01f, -5.70791245e-01f, -4.90682572e-01f, -1.36688933e-01f, -2.98326053e-02f, 1.78248212e-02f, 1.34186819e-01f, 5.74544482e-02f,
  -7.91855156e-02f, 7.53422128e-03f, -6.64790332e-01f, 7.94299617e-02f, 2.28878662e-01f, 2.66479284e-01f, 4.65641707e-01f, 3.75370771e-01f, -1.18084013e-01f, -2.32241824e-01f,
  2.21453011e-01f, -7.05718994e-01f, -4.05498058e-01f, -5.22520185e-01f, 1.33321658e-01f, -5.43897212e-01f, 4.82706755e-01f, 8.19630176e-02f, 1.88732650e-02f, -3.92903030e-01f,
  -7.22698808e-01f, -3.54664177e-01f, -5.33766091e-01f, 3.54066581e-01f, -4.00131911e-01f, 3.76545042e-01f, -2.35743150e-01f, -2.66055256e-01f, 3.66830617e-01f, -2.32496291e-01f,
  -1.57847866e-01f, -7.94384062e-01f, 1.39393508e-01f, 8.59637558e-02f, 2.39344299e-01f, -6.21379912e-01f, 2.94956714e-01f, 2.28339374e-01f, -2.04081580e-01f, 1.82481498e-01f,
  1.61782697e-01f, 3.49726453e-02f, -3.03458214e-01f, -4.16448921e-01f, 5.61400987e-02f, -7.20420778e-01f, -7.98721761e-02f, -8.98643672e-01f, 5.98253727e-01f, -7.43090570e-01f,
  -6.81867674e-02f, 2.17854306e-01f, -1.00667703e+00f, 4.70787495e-01f, 4.40871894e-01f, -2.56344806e-02f, -4.81253862e-01f, 9.99634638e-02f, -9.57745463e-02f, 5.09802818e-01f,
  4.32484061e-01f, 5.32485723e-01f, -5.69038987e-01f, -3.76662672e-01f, -3.73366952e-01f, 4.48270887e-01f, -5.40828466e-01f, -2.02154554e-02f, -3.09952825e-01f, 2.49991193e-01f,
  -2.09375009e-01f, -1.83878362e-01f, -6.82655156e-01f, 2.08706677e-01f, 3.47455919e-01f, 3.58782291e-01f, -1.27925277e-01f, 4.23989743e-02f, -1.37149379e-01f, -8.25787187e-01f,
  5.48454821e-01f, -9.47022438e-01f, -1.09010093e-01f, -3.12462926e-01f, 1.92088351e-01f, 2.56645203e-01f, -1.66985691e-01f, -2.76915252e-01f, 6.64052889e-02f, 2.72249132e-01f,
  -3.12749684e-01f, -2.02176392e-01f, -3.61863966e-03f, -5.16373754e-01f, -1.16696090e-01f, -4.67691198e-03f, -3.00000846e-01f, -2.56468952e-01f, -4.84743893e-01f, -4.31416899e-01f,
  -8.73318315e-01f, -8.95559564e-02f, -1.07689463e-01f, 2.35814288e-01f, -2.87333895e-02f, 3.21702182e-01f, -1.62604004e-01f, 1.07355891e-02f, -7.90912569e-01f, 7.51564622e-01f,
  -2.10343152e-01f, 6.64007366e-02f, -1.85864329e-01f, 6.19744301e-01f, -7.74465978e-01f, -8.80859256e-01f, -4.47642028e-01f, -6.12991095e-01f, -5.78647971e-01f, -7.90686086e-02f,
  5.97108066e-01f, -3.53363067e-01f, -3.36414054e-02f, -1.55663505e-01f, -7.84092605e-01f, 2.62525797e-01f, 5.95851481e-01f, 5.60371339e-01f, 2.10031196e-01f, -7.15547025e-01f,
  -3.25436622e-01f, -3.08593027e-02f, 3.13740909e-01f, 1.65820383e-02f, -6.66251406e-02f, 2.64056027e-01f, -3.14690061e-02f, 6.34109676e-02f, 2.29106694e-01f, 1.25843987e-01f,
  -5.74808300e-01f, -1.13455065e-01f, -7.23168612e-01f, 5.38423777e-01f, -6.78282082e-01f, -6.10118508e-01f, -2.50819534e-01f, 1.60278916e-01f, 2.10030004e-01f, -7.65492439e-01f,
  2.37178970e-02f, 4.69842041e-03f, 8.56485516e-02f, -2.05433860e-01f, 1.63131967e-01f, 1.81783941e-02f, 4.85146016e-01f, -7.81308413e-02f, 1.01287758e+00f, 4.84625362e-02f,
  -3.85543108e-01f, 8.42756554e-02f, 4.82741982e-01f, -3.88017118e-01f, 4.11978573e-01f, -1.62609279e-01f, 2.52828479e-01f, 6.55431896e-02f, -1.68418124e-01f, 2.62265444e-01f,
  -5.03995121e-01f, -7.65818954e-01f, -3.92242759e-01f, -8.97480011e-01f, 3.15444678e-01f, 3.75504404e-01f, -6.03213966e-01f, -8.71126428e-02f, -4.08783197e-01f, 2.59902358e-01f,
  3.17124337e-01f, 5.24645932e-02f, 5.76004565e-01f, 4.76765454e-01f, 4.13913041e-01f, 2.07891315e-01f, 6.51184678e-01f, 5.73725462e-01f, -1.37177883e-02f, 4.12317604e-01f,
  -2.30911702e-01f, 2.31808811e-01f, 3.96112978e-01f, 4.70299006e-01f, 3.02084446e-01f, -1.03529938e-01f, 3.91449988e-01f, -2.44479224e-01f, -1.09302533e+00f, -3.50997746e-01f,
  4.20617491e-01f, -4.22605455e-01f, -1.32054999e-01f, 4.37974960e-01f, 2.63486505e-01f, 4.65255171e-01f, -4.40129995e-01f, -6.59757376e-01f, 3.25799167e-01f, -6.05544627e-01f,
  -3.76116306e-01f, 1.47804335e-01f, 2.73033589e-01f, -5.66902280e-01f, -2.89145466e-02f, -2.16226086e-01f, -8.91305283e-02f, -8.16844031e-02f, -2.55380660e-01f, -5.79182953e-02f,
  -4.19809133e-01f, 2.50856638e-01f, 1.87914342e-01f, 4.36319381e-01f, 2.44755253e-01f, -7.87949413e-02f, 1.59240142e-01f, 4.52082843e-01f, -7.28930175e-01f, 8.40043426e-02f,
  -2.40460455e-01f, -1.38944104e-01f, 3.68667394e-02f, 3.65410477e-01f, -6.51145577e-01f, 3.43785256e-01f, -1.56311944e-01f, -7.73351431e-01f, -1.55864686e-01f, 2.42630318e-01f,
  -3.75627398e-01f, 4.73231614e-01f, 4.11380708e-01f, -1.14994176e-01f, 2.03704700e-01f, -3.37239772e-01f, -3.89056325e-01f, -3.67774338e-01f, 3.69128108e-01f, 2.07843125e-01f,
  -9.27817896e-02f, -9.60269719e-02f, 1.98676482e-01f, -7.99615920e-01f, 1.45079583e-01f, -8.09220597e-02f, 1.64672598e-01f, -5.11842012e-01f, 2.38356322e-01f, 5.04644454e-01f,
  -6.40079021e-01f, -5.57323575e-01f, -6.69998050e-01f, -8.22486639e-01f, 2.55761802e-01f, -1.08766064e-01f, -5.42381287e-01f, -4.41768080e-01f, 5.47424257e-02f, -7.79119655e-02f,
  5.77980876e-01f, -4.86540109e-01f, -3.30820382e-01f, 2.12653220e-01f, 8.30218196e-02f, 9.26488712e-02f, -4.39183772e-01f, 4.73535746e-01f, 1.02581918e-01f, -8.53089318e-02f,
  6.27196848e-01f, 2.79017985e-01f, 2.02194244e-01f, 4.13223743e-01f, -5.14370620e-01f, 1.91016257e-01f, -4.45599496e-01f, -5.69436252e-02f, 3.32326978e-01f, 4.19357777e-01f,
  3.15854222e-01f, -4.95893091e-01f, 5.96421212e-02f, 2.49277279e-01f, 2.25793540e-01f, -6.78805888e-01f, -5.78780770e-01f, -8.74783218e-01f, 3.85256022e-01f, 2.72741348e-01f,
  1.53176531e-01f, -5.96068621e-01f, -4.55257833e-01f, 5.24502158e-01f, 1.86775148e-01f, 3.59595478e-01f, 8.01021159e-02f, -3.87585461e-01f, 2.34181411e-03f, -4.16550487e-01f,
  1.88007429e-01f, 1.20460931e-02f, -2.92457212e-02f, -2.06332535e-01f, -3.76935363e-01f, -7.62448490e-01f, 2.14939430e-01f, -4.39217240e-01f, 6.25522912e-01f, -5.78088403e-01f,
  3.72078776e-01f, -2.24676758e-01f, -1.22268043e-01f, 5.37815034e-01f, -3.12190820e-02f, -1.05281508e+00f, 1.86869830e-01f, -4.72946525e-01f, -8.17050099e-01f, -6.64346397e-01f,
  3.52226019e-01f, -7.23934650e-01f, -5.81356287e-01f, 7.94250488e-01f, 3.04019004e-01f, 2.08003949e-02f, -3.79534483e-01f, 1.20504074e-01f, 2.59287894e-01f, -7.44476765e-02f,
  4.12685841e-01f, -3.34486961e-01f, 2.75928348e-01f, -2.18505383e-01f, -2.91603893e-01f, -1.88465178e-01f, -6.65288940e-02f, -3.91616553e-01f, -2.69635767e-01f, -8.22240353e-01f,
  -4.63354528e-01f, 3.61407727e-01f, -6.82369351e-01f, 3.01405132e-01f, -5.17858863e-01f, -5.08977711e-01f, -6.53623223e-01f, -2.81423450e-01f, -4.40759063e-01f, 1.77672029e-01f,
  3.00922185e-01f, -4.82085466e-01f, -6.55211627e-01f, -1.14710547e-01f, 3.70143831e-01f, 4.98531461e-01f, -6.36304915e-01f, 3.72605979e-01f, -4.72510785e-01f, -1.32407427e-01f,
  -4.00096178e-01f, 3.06153476e-01f, 4.23637778e-02f, 4.88660753e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  7.34810010e-02f, 6.18649237e-02f, -1.04384758e-02f, -1.20679803e-01f, -4.16545533e-02f, 7.74787515e-02f, 3.81435931e-01f, -1.66376278e-01f, -1.38380468e-01f, 4.45809066e-02f,
  -2.93312877e-01f, 7.88362324e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    