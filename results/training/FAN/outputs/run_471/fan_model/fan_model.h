/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.47327432e-01f, -2.03807265e-01f, 2.55261779e-01f, 5.12053035e-02f, -1.17333509e-01f, 3.98216844e-02f, 1.87996373e-01f, -6.35498241e-02f, 1.82585083e-02f, -1.27917975e-01f,
  -1.56264365e-01f, 1.91987962e-01f, -1.48116359e-02f, 6.50455505e-02f, 1.22013047e-01f, -8.64660144e-02f, 2.40440052e-02f, -2.05973885e-03f, 7.07241744e-02f, -8.84221271e-02f,
  6.14778996e-02f, -7.55383968e-02f, 1.18841127e-01f, -4.70586568e-02f, 1.24633960e-01f, 5.92420846e-02f, -8.91472548e-02f, -6.49959743e-02f, 3.89608331e-02f, 6.42925277e-02f,
  2.38647126e-02f, 2.60231107e-01f, -3.65748778e-02f, -4.30946648e-02f, 9.46596789e-04f, 7.04142377e-02f, -1.19610680e-02f, 1.49315931e-02f, -2.60081626e-02f, 2.43591834e-02f,
  7.44713321e-02f, 3.44082690e-03f, 3.62905748e-02f, -3.73911336e-02f, -3.49322408e-02f, -4.30875085e-02f, 6.18236288e-02f, -2.39085797e-02f, 1.52981058e-02f, 1.09908015e-01f,
  4.29164479e-03f, 5.94934961e-03f, 4.53358814e-02f, 9.41966698e-02f, -1.20688798e-02f, 4.21677493e-02f, 2.38309801e-02f, -1.79066770e-02f, -2.81438716e-02f, -1.91657059e-02f,
  3.48595455e-02f, 2.98180636e-02f, -5.08856885e-02f, -6.49224222e-02f, -1.80079453e-02f, 1.08415224e-01f, -9.64864716e-02f, -2.01179683e-02f, 1.74749754e-02f, -8.03009570e-02f,
  2.57302001e-02f, 8.91784113e-03f, -8.85157958e-02f, -9.25876386e-03f, 1.52392325e-03f, 5.79330511e-02f, 5.90771809e-02f, 4.35405746e-02f, 4.28521214e-03f, 5.33285886e-02f,
  7.43704513e-02f, -3.63107547e-02f, 4.04892191e-02f, -3.60878892e-02f, 5.24794916e-03f, -1.48578370e-02f, 1.71260126e-02f, 7.32579455e-02f, -3.81348208e-02f, 4.87215854e-02f,
  -3.44930470e-01f, -1.43872574e-01f, -7.48794824e-02f, -5.25946207e-02f, 4.14123433e-03f, -8.66707638e-02f, -2.85087600e-02f, -3.33629325e-02f, -3.06588616e-02f, 1.83995757e-02f,
  -3.03559322e-02f, -8.50933418e-03f, -3.49911191e-02f, 1.02550559e-01f, -2.14082915e-02f, -3.40768993e-02f, -1.17453150e-02f, -5.20783998e-02f, -4.82827798e-02f, -6.98303953e-02f,
  -7.96339065e-02f, -8.66495594e-02f, 4.37844098e-02f, -1.74101500e-03f, -3.98668572e-02f, 4.81884964e-02f, 2.48505198e-03f, 3.85634974e-02f, 7.29625523e-02f, 3.67461964e-02f,
  -1.15586758e-01f, 9.95688736e-02f, -3.42775658e-02f, 7.47034624e-02f, 1.86558262e-01f, -1.72365569e-02f, -2.03691021e-01f, 1.58085227e-01f, -1.04197953e-02f, -8.78073499e-02f,
  2.25537326e-02f, -1.20334588e-01f, -3.11920848e-02f, -7.54260123e-02f, -2.65654846e-04f, -1.12715863e-01f, -6.05139807e-02f, -9.13939476e-02f, 2.08682120e-02f, -1.01909321e-02f,
  -1.10472580e-02f, 1.07441522e-01f, -3.85341905e-02f, 1.33554906e-01f, 5.25700785e-02f, 2.70957984e-02f, 1.60096083e-02f, -8.92620441e-03f, -4.17170813e-03f, -7.42669478e-02f,
  -1.99502677e-01f, -1.15864344e-01f, -8.18470418e-02f, 3.72262555e-03f, -2.72410661e-02f, -1.06753349e-01f, -5.76621555e-02f, -8.28009937e-03f, -8.31868276e-02f, -2.30907928e-02f,
  -4.70173396e-02f, 2.84020770e-02f, 5.95505498e-02f, 3.96748893e-02f, 4.53672446e-02f, -1.33091640e-02f, 3.61891501e-02f, -1.94621682e-02f, -6.14222512e-03f, -6.27562329e-02f,
  5.56786731e-02f, 2.94878073e-02f, 2.66882349e-02f, -2.55825929e-02f, 9.43486467e-02f, 2.05647461e-02f, 2.04520952e-02f, 4.36117463e-02f, 3.20376642e-02f, 3.28391953e-03f,
  6.98968861e-03f, 8.47652331e-02f, 1.35387052e-02f, 7.87213743e-02f, -2.35124268e-02f, 5.11591770e-02f, 1.69789128e-03f, -1.90154817e-02f, 2.49081645e-02f, 7.25797191e-02f,
  -2.92227864e-02f, 2.55905576e-02f, 1.18986964e-02f, -2.07547452e-02f, -2.48838589e-02f, -4.35865624e-03f, 3.11158281e-02f, 3.28398421e-02f, -2.24634800e-02f, -2.63759438e-02f,
  -2.70814281e-02f, 4.47151698e-02f, 2.37764735e-02f, -3.28867277e-03f, 9.20441300e-02f, -6.10106345e-03f, 8.98405537e-02f, -2.92778364e-03f, 4.93575223e-02f, 5.55591146e-03f,
  1.03202999e-01f, 1.60766646e-01f, 3.33442613e-02f, -8.45616534e-02f, -1.22319041e-02f, 4.06946689e-02f, -1.77908354e-02f, 7.71681145e-02f, 2.13352907e-02f, 4.48037423e-02f,
  1.64054167e-02f, 4.93546166e-02f, -4.08365652e-02f, -3.35382409e-02f, -6.13127612e-02f, 1.07460134e-02f, 4.64329962e-03f, 4.82189059e-02f, 1.84062365e-02f, 9.60182026e-02f,
  -2.02365499e-03f, 6.44837469e-02f, 5.05517935e-03f, 1.69671495e-02f, -2.06993949e-02f, -2.46221796e-02f, -2.01612711e-02f, 3.75627948e-04f, 2.86961556e-04f, 7.06679225e-02f,
  -3.23096842e-01f, -6.29962683e-02f, -1.63390845e-01f, -1.50282189e-01f, -2.62465235e-02f, 3.41490954e-01f, 3.70873868e-01f, -1.00117996e-01f, -2.19326943e-01f, 1.90327585e-01f,
  1.12095527e-01f, -1.55121163e-02f, 1.89004272e-01f, 8.34271982e-02f, 1.76961794e-02f, 6.55267537e-02f, 1.78607609e-02f, 8.80184118e-03f, -2.37553045e-01f, -9.35913846e-02f,
  -8.19984004e-02f, 5.26822396e-02f, 6.49246350e-02f, -5.83074391e-02f, 4.68061008e-02f, -3.05940788e-02f, 9.51406509e-02f, 8.69551003e-02f, -3.23978066e-02f, 8.94928724e-02f,
  1.01098754e-01f, -4.63809408e-02f, -2.70555560e-02f, -2.43744776e-02f, 8.29241872e-02f, 4.59846668e-02f, 8.47271979e-02f, 3.38697769e-02f, 1.17411446e-02f, -1.71644390e-02f,
  6.09807968e-02f, -2.19841115e-02f, 1.31661501e-02f, -2.26350371e-02f, 3.20535004e-02f, -1.09207883e-01f, -6.61727488e-02f, -4.11773892e-03f, -5.68304993e-02f, -8.34882408e-02f,
  4.06416059e-02f, -6.37503117e-02f, 1.38760228e-02f, -5.59693426e-02f, 3.65871042e-02f, -7.85406157e-02f, 7.31289238e-02f, 7.02902600e-02f, -4.11374588e-03f, -7.04986751e-02f,
  4.71704453e-02f, -1.13444636e-02f, -2.01978069e-02f, -4.49440666e-02f, -4.17381935e-02f, -8.22967216e-02f, 5.09418957e-02f, 4.54901271e-02f, -1.03676626e-02f, 5.19674979e-02f,
  -8.60292464e-02f, -3.70887830e-03f, -6.77900612e-02f, -5.46326628e-03f, -1.59635097e-02f, 2.19399817e-02f, 3.04415841e-02f, -1.07937958e-02f, -2.92323548e-02f, 3.55560519e-02f,
  4.27809767e-02f, -2.37652417e-02f, 4.52885926e-02f, 6.53337240e-02f, -1.34129329e-02f, -5.57986572e-02f, 1.13802673e-02f, -6.08543344e-02f, -4.55444418e-02f, 6.60059303e-02f,
  1.30280390e-01f, 8.35381970e-02f, 5.84635027e-02f, -8.69869366e-02f, -4.38482547e-03f, -3.26056667e-02f, -4.00090814e-02f, -2.04449967e-02f, -2.16860157e-02f, 2.36418936e-02f,
  -3.46234925e-02f, 5.10077216e-02f, -4.77340491e-03f, 3.02320975e-03f, -6.22022199e-03f, -5.40569276e-02f, 2.79631782e-02f, 4.93345922e-03f, 2.78116222e-02f, -1.78394523e-02f,
  -2.09232676e-03f, 5.20284735e-02f, 2.32493877e-02f, -6.32046867e-05f, 5.67660071e-02f, 7.74075314e-02f, 4.11948701e-03f, -5.85785098e-02f, -2.76734345e-02f, -8.77155084e-03f,
  2.80521542e-01f, -1.09884508e-01f, 1.76648021e-01f, 7.07757697e-02f, 8.98974389e-03f, 4.51335497e-02f, -1.82274710e-02f, -4.08317186e-02f, 1.03324004e-01f, -1.99361861e-01f,
  4.39449251e-02f, 5.62126748e-03f, 3.26481722e-02f, -3.61435823e-02f, -3.81786339e-02f, 2.51704250e-02f, 2.09762268e-02f, 1.83359422e-02f, 6.75139055e-02f, -1.24267042e-01f,
  2.38519348e-02f, -3.74561548e-02f, 1.13507435e-01f, -4.33489308e-02f, -1.14190336e-02f, -2.03869548e-02f, -1.16760403e-01f, 5.79243898e-03f, -2.12080926e-02f, 3.33837420e-02f,
  3.74571159e-02f, 1.16319858e-01f, 9.52025652e-02f, 4.88416851e-02f, 7.64469579e-02f, 3.20652947e-02f, 5.39500639e-02f, 6.41815290e-02f, 5.27056456e-02f, 1.43862106e-02f,
  7.11629447e-03f, 3.99461295e-03f, 4.03178781e-02f, 2.54953001e-02f, 7.91940391e-02f, 5.69360740e-02f, 3.55883799e-02f, 1.41828945e-02f, 1.91344339e-02f, -4.04749531e-03f,
  9.58982334e-02f, 1.36068851e-01f, 3.24177891e-02f, -2.18180045e-02f, 9.30107459e-02f, 2.24722140e-02f, 4.26143408e-02f, -3.20833996e-02f, 5.64536080e-02f, -3.33964713e-02f,
  -6.55466765e-02f, -1.22143961e-01f, -2.81132013e-02f, 1.22291166e-02f, 1.90284359e-03f, -9.13984999e-02f, 3.84353958e-02f, 3.07892077e-02f, -4.87196632e-03f, 8.23250879e-03f,
  -2.49906108e-02f, 3.57858054e-02f, 6.30502179e-02f, 6.63923919e-02f, 1.19109955e-02f, -1.55991763e-02f, 1.24693029e-02f, -2.28887349e-02f, -3.28861289e-02f, 8.50779749e-03f,
  2.40959022e-02f, 2.76898332e-02f, 1.40219396e-02f, -3.35516855e-02f, 4.19526920e-02f, 2.25223247e-02f, 3.88801545e-02f, -2.21850015e-02f, -8.41185823e-03f, 2.39491835e-02f,
  -1.85080394e-01f, -2.79177487e-01f, -5.03314808e-02f, -2.67269835e-02f, 3.97207541e-03f, 3.13114449e-02f, -2.01742892e-04f, 2.44574547e-02f, -2.22327411e-02f, 3.28738391e-02f,
  -2.60013947e-03f, 4.85117771e-02f, -5.57530373e-02f, 1.73468757e-02f, -2.51988992e-02f, 6.84189871e-02f, -4.64347154e-02f, 4.48182449e-02f, 1.09479623e-02f, 3.34823690e-02f,
  -8.02196488e-02f, -5.28010875e-02f, 5.89922667e-02f, -4.69645932e-02f, -1.07630193e-02f, -3.56423780e-02f, -9.99015644e-02f, -6.90495363e-03f, -2.09614988e-02f, -3.45552191e-02f,
  2.08695516e-01f, 5.33033572e-02f, 1.38322175e-01f, 7.30143562e-02f, 2.92127915e-02f, -4.08028886e-02f, 1.22673206e-01f, -5.41260168e-02f, -1.84741080e-01f, -3.54818404e-02f,
  -5.41994572e-02f, 1.66165382e-01f, -3.81907672e-02f, 5.46941794e-02f, -1.22426130e-01f, -1.43885791e-01f, 1.88164469e-02f, 9.79187489e-02f, -6.85116500e-02f, -2.95581929e-02f,
  -2.94388626e-02f, -5.27255833e-02f, 1.09991379e-01f, -1.26150459e-01f, 9.43818092e-02f, -1.68030805e-04f, -5.06370403e-02f, 5.48681319e-02f, -3.78099643e-02f, -1.97209511e-02f,
  6.42821565e-02f, -5.82057014e-02f, 1.12871733e-02f, -2.06852574e-02f, 3.01675107e-02f, -8.31314828e-03f, 8.45108926e-02f, -1.77080818e-02f, 1.68964267e-02f, 4.69512902e-02f,
  4.98742387e-02f, -5.06034493e-02f, 1.04592904e-01f, -6.42663911e-02f, -7.54807889e-02f, 3.65135819e-02f, -1.05873093e-01f, 1.35722775e-02f, 5.53487241e-02f, 8.98565724e-03f,
  4.21289494e-03f, 3.07708792e-02f, -7.76857734e-02f, -1.48499422e-02f, -6.35812208e-02f, -1.84686873e-02f, 3.12425531e-02f, -2.75646932e-02f, -3.09582874e-02f, -4.30380926e-02f,
  -3.99390161e-02f, 1.14726846e-03f, 2.53619850e-02f, 1.42963916e-01f, -2.85572503e-02f, 2.42797248e-02f, -4.91689518e-02f, 7.90234581e-02f, -5.40805608e-02f, 1.11459428e-02f,
  1.28603587e-02f, -2.32012626e-02f, 1.99603494e-02f, -4.90040183e-02f, -1.34364486e-01f, -1.20979715e-02f, 9.97026637e-03f, 1.80439185e-02f, 6.42492920e-02f, 1.59922056e-02f,
  -4.28911997e-03f, 4.16997308e-03f, 7.27717299e-03f, 8.40425957e-03f, -4.77562509e-02f, -1.02438116e-02f, -8.54073763e-02f, -2.50034202e-02f, 8.26250389e-02f, -1.97845735e-02f,
  -3.85277383e-02f, -1.70688540e-01f, -5.59287751e-03f, 9.80824828e-02f, 6.18738495e-03f, 2.12596124e-03f, -3.84794548e-02f, -2.35571782e-03f, 4.14033327e-03f, -8.97463411e-03f,
  1.24503560e-02f, -6.18635491e-03f, -6.46391362e-02f, -1.24462964e-02f, -1.16470819e-02f, -2.37707309e-02f, 4.30000983e-02f, 5.08572161e-02f, 8.90911967e-02f, 3.16468552e-02f,
  6.03665225e-02f, 5.81319742e-02f, -7.86684155e-02f, -1.29062638e-01f, -1.41479336e-02f, 6.22564554e-02f, 2.76821270e-03f, -3.83061985e-03f, -7.42276609e-02f, -6.18632995e-02f,
  -2.45477945e-01f, 1.16806321e-01f, 1.55018017e-01f, -8.04176461e-03f, -1.25989869e-01f, -1.65935338e-01f, -1.96010083e-01f, 1.37699753e-01f, -1.80577025e-01f, 1.77913513e-02f,
  -6.26356453e-02f, -2.88936310e-03f, -3.15356534e-03f, -6.15608431e-02f, -4.93348837e-01f, -2.05503777e-01f, -8.69186446e-02f, -1.04943328e-01f, -5.68405278e-02f, 1.25409039e-02f,
  3.30222286e-02f, 5.12300171e-02f, 1.28281817e-01f, 2.95498878e-01f, 1.35368034e-01f, 2.87453890e-01f, 1.08495817e-01f, 1.38692290e-01f, 1.50686502e-01f, -7.27766752e-03f,
  -9.62948054e-02f, -4.06581499e-02f, 4.53458205e-02f, -1.56106763e-02f, -1.38685361e-01f, 3.24188918e-02f, -3.89078259e-02f, -1.40414890e-02f, 4.36915979e-02f, -3.26884873e-02f,
  1.33448038e-02f, -8.09078962e-02f, -4.74841036e-02f, 3.26968729e-02f, -3.85569446e-02f, 8.82877633e-02f, 2.92562004e-02f, 5.57470173e-02f, 3.52832787e-02f, -9.70326066e-02f,
  6.16947748e-02f, -5.98691218e-02f, 3.44749764e-02f, -4.24209908e-02f, 2.61484720e-02f, -6.81626871e-02f, -2.54465789e-02f, -4.77245338e-02f, -2.18333751e-02f, -4.10963446e-02f,
  -8.86789709e-02f, 1.27368160e-02f, 3.33922617e-02f, 8.25022906e-02f, 2.03968696e-02f, -7.63248792e-03f, -2.49929354e-03f, 1.80724002e-02f, 7.87450001e-02f, -7.01914951e-02f,
  -1.62345655e-02f, -1.75539646e-02f, 3.31056281e-03f, -1.63387153e-02f, 6.36066496e-02f, 4.84695248e-02f, 8.13534763e-03f, 5.51925711e-02f, 4.13130559e-02f, 1.00220041e-02f,
  3.94438058e-02f, -1.64998658e-02f, 8.92168358e-02f, 1.99691616e-02f, -4.73509915e-02f, -6.43527508e-02f, 7.48632895e-03f, 2.23100502e-02f, 5.61801158e-02f, -8.25091824e-03f,
  3.18830064e-03f, 4.37369905e-02f, 6.34473488e-02f, -4.74900380e-02f, 8.00544471e-02f, -2.48806607e-02f, -4.13688086e-02f, -1.36284456e-02f, -3.04977559e-02f, 1.18184080e-02f,
  -4.32588346e-02f, -5.96778318e-02f, 4.17541414e-02f, -1.85782406e-02f, 7.07898214e-02f, -4.95525673e-02f, 2.68346886e-03f, -1.57367270e-02f, 1.72848888e-02f, 3.88851985e-02f,
  -9.99649242e-03f, -7.97022581e-02f, -2.98729725e-02f, 1.45253213e-02f, -8.58690366e-02f, -9.63186938e-03f, -2.20658649e-02f, -3.24911848e-02f, -5.12421830e-03f, 1.10446364e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.05789542e-01f, 3.97131234e-01f, 4.22563404e-03f, -1.68473870e-01f, -2.58728713e-01f, 4.58078772e-01f, 2.53372312e-01f, 9.45801288e-02f, 4.91637364e-03f, 3.47726673e-01f,
  2.48109460e-01f, -2.11724788e-01f, 1.67435274e-01f, 2.35674545e-01f, 2.47684903e-02f, 2.69374460e-01f, 2.96376199e-01f, 1.25113472e-01f, 2.49464530e-02f, -3.54007408e-02f,
  -1.14540812e-02f, 2.06330746e-01f, 1.77016050e-01f, 6.81187678e-03f, -5.96844703e-02f, -2.64016092e-01f, -1.81495786e-01f, -1.81542739e-01f, 6.08985350e-02f, -3.26605253e-02f,
  2.85880510e-02f, -2.84580380e-01f, -1.87548906e-01f, -5.57608567e-02f, -8.88398141e-02f, -6.03587851e-02f, -1.15408458e-01f, -7.97101110e-02f, 3.48247169e-03f, -9.11678076e-02f,
  -1.12632446e-01f, -1.12087935e-01f, -9.09606833e-03f, -5.97817600e-02f, -7.37390341e-03f, -6.99281394e-02f, 5.90381250e-02f, 9.41993147e-02f, 3.79372165e-02f, 6.73978627e-02f,
  7.62909204e-02f, 7.67683685e-02f, 5.29333912e-02f, 7.00166449e-02f, -5.73332645e-02f, 5.76092862e-02f, 1.43968109e-02f, -7.09366426e-02f, -2.50225980e-03f, -2.69464198e-02f,
  -9.84653309e-02f, -6.90785190e-03f, 7.16522262e-02f, -3.01598664e-02f, 3.86469848e-02f, 4.40357812e-02f, 3.97491716e-02f, 3.21438275e-02f, 2.22054198e-02f, 2.79562045e-02f,
  -2.64473110e-02f, -1.20278436e-03f, -8.68436843e-02f, 1.86174095e-01f, 1.10707749e-02f, -2.00003684e-02f, -3.71389021e-03f, -3.11343316e-02f, 4.60139401e-02f, 4.92132939e-02f,
  -1.75001174e-02f, -1.93988457e-02f, 6.45567290e-03f, -7.88847581e-02f, -2.90801469e-03f, 7.27654248e-03f, 3.93814109e-02f, 1.02123283e-01f, -1.00261960e-02f, -6.01550229e-02f,
  5.10478616e-02f, -1.79212585e-01f, 1.79843083e-02f, 2.58949935e-03f, 4.74436767e-02f, 6.83081569e-03f, -4.80558351e-02f, 8.90851170e-02f, 8.93608630e-02f, -1.95845068e-02f,
  -4.37894911e-02f, 1.47773260e-02f, -6.95480360e-03f, -1.18475761e-02f, 1.61530189e-02f, 8.91526267e-02f, 7.27896988e-02f, 4.41843532e-02f, 5.06046563e-02f, 3.80081199e-02f,
  -1.16115816e-01f, 2.44418271e-02f, 2.44372804e-02f, -8.01512003e-02f, -2.06663106e-02f, 7.10046962e-02f, -1.49908260e-01f, 5.14870975e-03f, -3.76651697e-02f, 3.99715230e-02f,
  3.40282805e-02f, -2.92503417e-01f, -2.33687431e-01f, 1.44134149e-01f, 2.10617721e-01f, -4.39517312e-02f, -2.93225944e-01f, 5.29209562e-02f, 5.90175390e-03f, -1.00578576e-01f,
  -3.85974273e-02f, -1.44755642e-04f, -3.00887048e-01f, -3.85442786e-02f, 9.78350360e-03f, -2.55388737e-01f, 1.98432535e-01f, 3.72956246e-02f, 1.71019658e-01f, -5.10001592e-02f,
  1.18071385e-01f, 2.43783370e-01f, 1.64657217e-02f, 1.92857578e-01f, 1.01284422e-01f, 1.12735696e-01f, 1.37980133e-01f, -9.39594507e-02f, 1.36302844e-01f, 1.89085990e-01f,
  3.30027677e-02f, -6.98492080e-02f, -1.31065384e-01f, 1.68722436e-01f, -5.24514802e-02f, -4.78589460e-02f, 2.33703963e-02f, -2.41405461e-02f, -1.31984595e-02f, -2.88444646e-02f,
  -2.27737073e-02f, 5.85580878e-02f, 3.05598825e-02f, 4.06568721e-02f, 2.06430674e-01f, 2.37565096e-02f, -2.02757958e-02f, -8.26081187e-02f, 4.25016247e-02f, -1.70363113e-01f,
  -1.51841953e-01f, -3.34814861e-02f, 8.11348334e-02f, -7.46194180e-03f, -1.25783458e-01f, -1.45264855e-02f, 8.30407292e-02f, -1.22831650e-01f, 3.52992713e-02f, -3.77662256e-02f,
  -2.35070344e-02f, -5.51669858e-02f, 5.18694893e-02f, 1.14875890e-01f, -3.07701901e-02f, 1.12880217e-02f, 5.71762547e-02f, 3.31226997e-02f, 1.77707195e-01f, 3.45881023e-02f,
  6.34928122e-02f, 1.00542799e-01f, 9.27870534e-03f, -1.98544133e-02f, -9.71723422e-02f, -1.75714884e-02f, 4.98187244e-02f, -1.45926867e-02f, 1.86892282e-02f, 6.66610375e-02f,
  5.59078120e-02f, 6.31695017e-02f, -5.87644987e-02f, 3.30885537e-02f, 3.23983990e-02f, -1.10667966e-01f, -6.69871876e-03f, 6.99416688e-03f, 3.25131714e-02f, 1.57524779e-01f,
  -1.03058271e-01f, -1.53422087e-01f, -5.19058071e-02f, 5.46810590e-02f, 3.56190428e-02f, 1.17888391e-01f, 8.11273009e-02f, 2.86355503e-02f, 1.26320263e-02f, -5.29980175e-02f,
  2.78638359e-02f, 2.11204775e-02f, 1.39472827e-01f, 9.77015421e-02f, 1.54962882e-01f, 3.59855816e-02f, -7.86248669e-02f, 3.61528806e-02f, 6.28278330e-02f, 9.16791335e-03f,
  -1.06204458e-01f, -1.04030214e-01f, 6.88180849e-02f, 1.33316532e-01f, -4.87463549e-02f, 1.58336237e-02f, 7.67729878e-02f, 1.73323341e-02f, 3.72531600e-02f, 9.00276995e-04f,
  -5.01074612e-01f, -3.60477343e-02f, -1.15706595e-02f, -4.93635356e-01f, 2.93472290e-01f, 2.73057044e-01f, -9.71690416e-02f, 1.77294418e-01f, -2.90573120e-01f, -1.93669479e-02f,
  -4.11527790e-02f, -2.55254596e-01f, -1.12093603e-02f, -2.76906013e-01f, -4.82053101e-01f, -3.42341691e-01f, -2.31562346e-01f, -1.27152264e-01f, 4.09980565e-02f, 1.95838488e-03f,
  -1.42055139e-01f, -1.60508081e-01f, -9.06736851e-02f, 3.20611805e-01f, 4.76461947e-02f, 1.34867296e-01f, 4.81853262e-02f, 1.64656073e-01f, 3.24745104e-02f, -2.14653581e-01f,
  -9.05228257e-02f, -1.18643992e-01f, 1.15406245e-01f, 6.89450651e-02f, 6.21258952e-02f, -1.45771643e-02f, 4.49549109e-02f, -1.25074219e-02f, -2.13161074e-02f, -3.27433199e-02f,
  -4.54966538e-02f, 3.25285532e-02f, 7.32468674e-03f, 5.27664572e-02f, 9.44739878e-02f, 2.30921861e-02f, 1.32330924e-01f, 6.00700676e-02f, -2.81031281e-02f, -3.87061313e-02f,
  8.61122534e-02f, -1.19304564e-02f, 2.97315009e-02f, -4.54589762e-02f, 4.11477825e-03f, 7.90738389e-02f, 4.62022312e-02f, 8.87154881e-03f, -4.86660972e-02f, -7.70104080e-02f,
  8.74014758e-03f, -1.91008989e-02f, -9.08026751e-03f, 2.38524806e-02f, -1.08556196e-01f, -1.50670325e-02f, 3.90097441e-04f, 4.81722020e-02f, 4.38608453e-02f, -2.41907556e-02f,
  3.50377522e-02f, 7.02181086e-03f, -2.14885175e-02f, 7.29613900e-02f, -3.99927571e-02f, -1.19654485e-03f, 5.07567711e-02f, 4.37221490e-02f, -3.96224000e-02f, 2.09959224e-02f,
  1.22472979e-02f, 5.01542836e-02f, -8.01512301e-02f, 5.31344004e-02f, 3.92489992e-02f, -1.60741806e-02f, 1.29674137e-01f, -7.44488388e-02f, -3.05916965e-02f, 3.55192907e-02f,
  8.75514839e-03f, -6.41067103e-02f, -8.01873654e-02f, -7.77043477e-02f, -1.70288794e-02f, -3.64452484e-04f, -1.14195542e-02f, -3.17232534e-02f, 3.15334685e-02f, 3.02405003e-02f,
  5.12424782e-02f, 4.24744412e-02f, 5.55993356e-02f, 1.56614706e-02f, 2.42535640e-02f, -5.48246615e-02f, -6.39185170e-03f, 1.88107850e-04f, 6.85870126e-02f, 4.60515469e-02f,
  8.15533623e-02f, 7.81652033e-02f, -1.56973787e-02f, 3.72978263e-02f, -4.97042090e-02f, 1.50360567e-02f, 1.77327171e-02f, -2.12825579e-03f, -1.20349526e-02f, -1.10277552e-02f,
  1.97512105e-01f, 8.26875400e-03f, -5.72881848e-02f, 1.09483391e-01f, -5.80685399e-02f, 1.41275092e-03f, -1.87181264e-01f, 4.43245061e-02f, -1.69747829e-01f, -1.63735181e-01f,
  1.39015287e-01f, -1.84187535e-02f, -1.40021652e-01f, 1.68129712e-01f, 2.05878332e-01f, -9.71953869e-02f, 1.61040887e-01f, -3.54904146e-03f, -6.72331825e-02f, 1.11060642e-01f,
  1.31646141e-01f, 3.33841711e-01f, 1.15712255e-01f, 1.09517299e-01f, 2.42702421e-02f, 9.03073698e-02f, 1.76915482e-01f, -4.78791632e-02f, 2.18240187e-01f, 3.80943827e-02f,
  -3.21046337e-02f, 9.46244299e-02f, -8.22807997e-02f, -1.05687067e-01f, 8.78931805e-02f, -4.00131680e-02f, -1.32061213e-01f, -8.51288363e-02f, -3.68655398e-02f, -2.89689172e-02f,
  -4.56654653e-02f, -8.22486803e-02f, 7.57626742e-02f, 5.95350899e-02f, 3.94224841e-03f, 1.00517295e-01f, 1.95179582e-02f, -3.50043625e-02f, -2.56234817e-02f, 1.02271348e-01f,
  8.42343494e-02f, 1.10973671e-01f, -4.72695343e-02f, -1.17297778e-02f, 1.09362714e-01f, 1.32331863e-01f, -8.44768342e-03f, -8.71274062e-03f, 4.42360714e-02f, -6.41091466e-02f,
  -3.81278023e-02f, -3.94426659e-02f, -4.16656472e-02f, -1.66324243e-01f, 3.66455801e-02f, -6.03731126e-02f, -1.51722357e-01f, -6.73124269e-02f, -2.07922440e-02f, -1.82601325e-02f,
  2.29554381e-02f, 1.68843139e-02f, -9.28677171e-02f, -1.83928013e-02f, -4.40156646e-02f, 3.31234485e-02f, -3.38158496e-02f, 1.17588274e-01f, 8.44900496e-03f, 6.73004091e-02f,
  -9.10013318e-02f, 1.15207292e-01f, -1.79337244e-02f, -7.54003301e-02f, 1.10987365e-01f, 5.00626117e-02f, 1.24701217e-01f, 2.72061899e-02f, -8.47545415e-02f, -8.70278552e-02f,
  8.08769092e-02f, 1.13871150e-01f, 1.70227867e-02f, -8.86485353e-03f, -3.06074265e-02f, -4.02519256e-02f, -6.72924891e-02f, -8.99742544e-02f, -5.67645282e-02f, 1.04145870e-01f,
  1.03781976e-01f, -6.47573397e-02f, 7.74152651e-02f, 4.23838422e-02f, 6.09058551e-02f, 1.44725163e-02f, 7.87317529e-02f, -1.21950231e-01f, 3.34640518e-02f, 1.45513982e-01f,
  3.68340164e-02f, -7.71569228e-03f, 6.63285777e-02f, -1.16046071e-01f, 1.23236582e-01f, 1.23367831e-01f, 9.23075676e-02f, 8.41786265e-02f, 1.42621830e-01f, -6.88639134e-02f,
  3.57975857e-03f, -3.62864852e-01f, -1.74759999e-01f, -2.43878081e-01f, 1.45243108e-01f, 1.49488240e-01f, -3.07037923e-02f, 8.72505009e-02f, -2.69593149e-01f, 1.47848144e-01f,
  8.25286508e-02f, -3.63607734e-01f, -4.95595932e-02f, -3.32777619e-01f, -2.13116929e-01f, -3.09731364e-01f, -4.95040193e-02f, 4.15780134e-02f, -1.49366245e-01f, 2.95739453e-02f,
  -1.99026152e-01f, -7.12502077e-02f, -3.42034638e-01f, 3.96046899e-02f, -4.41390947e-02f, 1.27720639e-01f, 1.82198077e-01f, -6.63357452e-02f, 7.37967119e-02f, -9.92221460e-02f,
  -2.19411999e-02f, -4.86570671e-02f, 6.37925193e-02f, 4.95150462e-02f, 1.39475375e-01f, 1.53730974e-01f, 8.17962587e-02f, -9.19996351e-02f, -8.51771235e-02f, -3.80887464e-02f,
  -3.28662172e-02f, -1.13281824e-01f, 1.35447513e-02f, -1.81618467e-01f, -3.83765157e-03f, 4.27305289e-02f, -8.47517177e-02f, 5.00791008e-03f, -5.63580655e-02f, -8.05379674e-02f,
  -7.70101845e-02f, -5.06898463e-02f, 6.19485527e-02f, 2.52011251e-02f, -8.28100592e-02f, 6.34968206e-02f, -4.85317409e-02f, -3.45415883e-02f, 1.34304557e-02f, -2.62331758e-02f,
  -4.35425900e-02f, 9.86846313e-02f, -7.81898573e-02f, -1.59417152e-01f, 9.52582732e-02f, 6.75966963e-02f, -2.22289972e-02f, 5.01862466e-02f, -4.08638306e-02f, 2.29004472e-02f,
  5.20840138e-02f, 3.93714830e-02f, -3.70807276e-04f, -1.43815756e-01f, 6.00730181e-02f, -2.35556122e-02f, 5.46922311e-02f, 1.48696974e-02f, -3.16243544e-02f, 6.02888688e-02f,
  -7.02847466e-02f, 5.17145693e-02f, 6.31328449e-02f, 1.62511066e-01f, -1.17297042e-02f, -7.49085546e-02f, -2.04307940e-02f, -6.29378557e-02f, 9.37177017e-02f, 5.38329110e-02f,
  2.26184070e-01f, 1.54706433e-01f, 5.97575903e-02f, -9.93741269e-05f, 2.15450674e-02f, 3.92618328e-02f, -9.23521146e-02f, 4.40225657e-03f, 1.85233343e-03f, 4.26393375e-02f,
  1.33211389e-01f, 4.84751277e-02f, 1.06538333e-01f, -5.09051532e-02f, -8.57679173e-02f, 9.32074562e-02f, 9.63650830e-03f, 7.10983872e-02f, 4.02389467e-02f, 8.62130970e-02f,
  6.54602572e-02f, 1.04625091e-01f, 7.37168943e-04f, 3.31761949e-02f, 5.59030026e-02f, 7.62271956e-02f, 6.62631616e-02f, -3.95764410e-03f, 1.29873618e-01f, -1.96144544e-02f,
  -8.93740356e-03f, -2.17480749e-01f, -1.76864937e-01f, -4.80635539e-02f, 2.04122663e-02f, -2.28037462e-01f, -3.10883015e-01f, -4.77273650e-02f, -1.76202565e-01f, 4.25349660e-02f,
  -6.57281652e-02f, 3.25081907e-02f, -3.71919721e-02f, -1.81050614e-01f, -1.11824967e-01f, -1.29532441e-01f, -2.18637511e-02f, -1.27355129e-01f, 6.41238838e-02f, 5.47933467e-02f,
  4.15427014e-02f, 9.40062164e-04f, 1.55429438e-01f, -1.52231343e-02f, 9.62129682e-02f, 1.34362206e-01f, 3.32406938e-01f, 5.59864827e-02f, 1.14643835e-01f, 6.37421459e-02f,
  -9.28830206e-02f, 1.05781749e-01f, -1.24234609e-01f, 5.09606069e-03f, 8.41442198e-02f, -2.70566642e-02f, -2.72268467e-02f, -2.48091854e-02f, -2.88186781e-02f, -1.89536233e-02f,
  4.48665991e-02f, -5.23028290e-03f, -1.42138479e-02f, -2.97222380e-02f, -4.73812521e-02f, -5.20665720e-02f, -1.48296021e-02f, 5.60470559e-02f, -8.62531215e-02f, 7.96311721e-02f,
  -6.43022582e-02f, -1.35311186e-01f, -4.15803790e-02f, 5.01216725e-02f, 7.08651394e-02f, -4.38489206e-02f, 1.08733550e-01f, 4.31760326e-02f, 1.08718583e-02f, -3.39883789e-02f,
  4.40005176e-02f, -5.37771769e-02f, 5.70784044e-03f, -5.86180277e-02f, 4.30358760e-02f, 4.35341075e-02f, 1.49719026e-02f, 7.38958654e-04f, 9.96555611e-02f, 4.84593287e-02f,
  6.99694082e-02f, 1.58194512e-01f, -4.50179577e-02f, 1.28340181e-02f, -2.92620827e-02f, -5.67145599e-03f, 3.42684127e-02f, -4.49049519e-03f, 7.55426660e-02f, 4.09158058e-02f,
  -1.33387491e-01f, -4.72843125e-02f, 1.65085271e-02f, -3.73236611e-02f, -1.60008145e-03f, 9.34204981e-02f, -8.40043128e-02f, 9.51953083e-02f, -4.91533168e-02f, -7.10908920e-02f,
  1.32928297e-01f, 2.21567363e-01f, 4.60831070e-05f, -2.97591370e-02f, -3.70630436e-02f, -8.99220333e-02f, -5.96293621e-02f, -1.00543173e-02f, -2.97385082e-02f, 2.10729316e-02f,
  7.33812824e-02f, -6.42111227e-02f, 4.78563309e-02f, 1.61601566e-02f, -5.99163026e-02f, 1.31992847e-01f, 5.03495038e-02f, 7.07650781e-02f, 1.25472128e-01f, 1.56096369e-01f,
  3.54965255e-02f, -4.94792406e-03f, -1.75350124e-03f, 2.74097174e-03f, 3.17287259e-02f, -1.89288966e-02f, 5.89897973e-04f, 5.26161194e-02f, -7.16707036e-02f, -5.38550578e-02f,
  4.18914497e-01f, -2.53957391e-01f, -1.74062982e-01f, 1.43649533e-01f, 2.30271786e-01f, 2.03308567e-01f, 1.88635215e-01f, 2.29808629e-01f, 2.42554531e-01f, -1.38652965e-01f,
  1.52667031e-01f, -9.42869708e-02f, -2.40910262e-01f, 1.34053841e-01f, 2.15278000e-01f, -2.37854183e-01f, 3.02700758e-01f, 4.86370772e-02f, 2.82393489e-03f, 8.62662345e-02f,
  2.02352256e-01f, 2.82415062e-01f, -1.28630847e-01f, 2.25272998e-02f, 2.27686897e-01f, -9.65416878e-02f, -1.02846228e-01f, -5.11639193e-02f, -6.39775097e-02f, -3.69130448e-02f,
  2.27210566e-01f, 9.62591618e-02f, 1.08160369e-01f, 1.88937616e-02f, 3.49749699e-02f, -3.79614271e-02f, -8.99887308e-02f, -7.83263743e-02f, 6.24729134e-02f, -5.87374754e-02f,
  -2.88817678e-02f, 6.26234934e-02f, 2.07592323e-02f, -5.55194505e-02f, 9.44257155e-02f, 6.21995293e-02f, 2.22736970e-02f, -6.54600561e-03f, -6.98357373e-02f, -1.27028795e-02f,
  -8.29996392e-02f, -3.32625583e-02f, 4.82189935e-03f, -9.51567665e-02f, -1.58245955e-02f, -3.97853889e-02f, -1.20789431e-01f, -7.98758864e-02f, 1.70919988e-02f, -5.26056020e-03f,
  6.48970678e-02f, -9.91877094e-02f, -5.06550819e-02f, 1.06794186e-01f, 1.46155888e-02f, 6.50546625e-02f, 3.88166821e-03f, -5.02066761e-02f, 1.46987271e-02f, 4.06062566e-02f,
  2.63850763e-03f, 1.07795149e-01f, 1.96941998e-02f, 8.21240097e-02f, -7.79195875e-02f, -3.78719531e-02f, -4.48940396e-02f, 4.27029990e-02f, 4.28874381e-02f, -9.27902162e-02f,
  -3.38235758e-02f, 6.03088066e-02f, -2.49068681e-02f, 4.07721512e-02f, 2.64581796e-02f, 5.96296266e-02f, 1.06292948e-01f, 4.08238405e-03f, -6.68750405e-02f, -8.59662518e-03f,
  7.53132626e-02f, -2.35459268e-01f, 3.14950421e-02f, 1.93588603e-02f, -5.54781519e-02f, 3.40556838e-02f, -2.06826627e-02f, 4.40142006e-02f, 2.11306251e-04f, 2.57673487e-02f,
  -6.28171908e-03f, -1.76046249e-02f, 8.04673359e-02f, -7.02787656e-04f, -4.89821099e-02f, 3.74527909e-02f, 9.64535691e-04f, -8.85528848e-02f, 2.11561900e-02f, 2.10781433e-02f,
  -4.51970175e-02f, 5.61114363e-02f, 5.62973833e-03f, 1.47138871e-02f, -3.81237306e-02f, -1.39123827e-01f, -9.12131444e-02f, -1.60888806e-02f, -7.86918849e-02f, 1.24800038e-02f,
  1.78158283e-01f, 4.18711565e-02f, -1.72982797e-01f, 1.58946916e-01f, 8.56631342e-03f, -4.29473482e-02f, -8.54374096e-02f, 1.25466838e-01f, -2.59506106e-01f, -5.52233495e-02f,
  9.07224864e-02f, -6.40413091e-02f, -7.44563714e-02f, 2.12191954e-01f, 4.20212522e-02f, -2.08216533e-01f, 2.11612895e-01f, 9.47340950e-02f, -5.37574664e-02f, 2.90905625e-01f,
  1.68017969e-01f, 3.39548588e-01f, 1.51858419e-01f, 3.56031984e-01f, 1.45792991e-01f, 2.11230889e-01f, 1.62995666e-01f, 5.51475324e-02f, 2.69667953e-01f, 7.26251155e-02f,
  1.52179110e-03f, 2.62444392e-02f, -9.88329723e-02f, 9.48511437e-03f, 8.69304910e-02f, 1.19169742e-01f, 3.16238590e-02f, 4.13610972e-02f, -1.01915970e-02f, -3.71864103e-02f,
  -2.45323312e-02f, 3.96286771e-02f, -4.70791757e-02f, 2.13394151e-03f, 2.88338419e-02f, -5.64895459e-02f, -6.04540221e-02f, -4.18593176e-02f, -3.88918556e-02f, 2.26702690e-02f,
  5.79921603e-02f, -6.07589111e-02f, -3.87057215e-02f, -3.18404846e-02f, -1.14829227e-01f, 5.86043037e-02f, -7.96534773e-03f, -1.75139476e-02f, -9.12516564e-02f, -1.69048719e-02f,
  2.36532521e-02f, -1.47218313e-02f, 5.50332591e-02f, -5.65257743e-02f, 4.20875810e-02f, -3.19684669e-02f, -2.73248125e-02f, -7.41761085e-03f, -6.88586533e-02f, 3.09853218e-02f,
  7.39494488e-02f, -1.61041715e-03f, -2.26625390e-02f, 4.78159115e-02f, 6.08553626e-02f, -5.37067326e-03f, 1.90371983e-02f, -5.64918183e-02f, -3.80240157e-02f, -1.80323552e-02f,
  -4.46882099e-02f, 4.02933285e-02f, 1.37367919e-02f, -2.29950156e-02f, 4.68211770e-02f, -1.38022611e-02f, 7.59579521e-03f, -5.91443516e-02f, -8.17127824e-02f, 1.14607876e-02f,
  2.20486924e-01f, 1.91904172e-01f, -4.05342178e-03f, -2.13120934e-02f, 1.10550807e-03f, 6.01526871e-02f, 1.11362962e-02f, -1.06797917e-02f, 7.93116987e-02f, -3.10220681e-02f,
  3.76149192e-02f, 1.29409786e-02f, -1.70316529e-02f, 1.69601254e-02f, 4.72815074e-02f, 2.26946902e-02f, -7.45573873e-03f, 7.19783157e-02f, 6.19117133e-02f, 7.24261925e-02f,
  1.86797902e-02f, 6.73941523e-02f, -3.70028280e-02f, -2.15325579e-02f, -1.02265400e-03f, -7.53355771e-02f, 5.47271483e-02f, -1.61967129e-02f, -1.89740397e-02f, -3.18047814e-02f,
  1.81141496e-01f, -1.08498029e-01f, -1.96741343e-01f, -2.39654556e-01f, -1.12430379e-01f, -3.74507189e-01f, -3.59911948e-01f, -1.32840469e-01f, 1.84671387e-01f, -3.04568987e-02f,
  -1.52501255e-01f, 1.14353739e-01f, 2.70543277e-01f, -2.87689179e-01f, 9.22987089e-02f, 1.10100880e-01f, -2.02925980e-01f, -1.70531914e-01f, 1.14367656e-01f, -8.26778039e-02f,
  1.80819854e-02f, -1.86720550e-01f, -1.58654094e-01f, -1.19147696e-01f, -3.43956500e-01f, -1.67229488e-01f, 4.24116254e-02f, -1.52250156e-01f, -1.86388448e-01f, -5.60703762e-02f,
  -1.48721725e-01f, -1.44993355e-02f, -1.13863483e-01f, 9.62071179e-04f, -7.40159303e-02f, -1.68871391e-03f, 3.29821147e-02f, -7.29316771e-02f, 9.16030549e-04f, 9.54059360e-04f,
  9.81652066e-02f, 1.50230676e-01f, 7.26632401e-02f, -1.09312404e-02f, 4.16051447e-02f, -5.18971793e-02f, -6.96361065e-03f, -4.06076685e-02f, -2.94070691e-02f, 6.37148246e-02f,
  -9.26202685e-02f, 3.44771892e-02f, -6.10206760e-02f, -1.20956913e-01f, 3.84116694e-02f, -1.09059562e-03f, 2.88166106e-02f, 3.90238054e-02f, 9.22532976e-02f, 3.77682373e-02f,
  1.16074286e-01f, 8.24773014e-02f, 3.38135287e-02f, 5.49551323e-02f, -1.35337338e-01f, -2.62631550e-02f, 1.81021132e-02f, -2.05665287e-02f, 6.82792291e-02f, -1.12561285e-01f,
  3.66757857e-04f, -1.93200856e-02f, -1.05076458e-03f, 4.39266153e-02f, -5.70922680e-02f, 8.52605253e-02f, -4.25116122e-02f, -4.90026847e-02f, 4.86250073e-02f, -5.95541019e-03f,
  -2.36469470e-02f, 1.17615059e-01f, -5.24865054e-02f, 5.48130162e-02f, 3.25945131e-02f, 1.96533650e-02f, 1.01851802e-02f, 4.10488807e-04f, -4.57910029e-03f, -1.53060667e-02f,
  4.72718701e-02f, 3.54502015e-02f, -1.24313971e-02f, -5.47681749e-02f, -1.07873753e-02f, -7.70648941e-02f, -3.75893936e-02f, 1.83032397e-02f, -8.44489187e-02f, 2.39441898e-02f,
  2.78153848e-02f, -1.53739657e-03f, -2.78161243e-02f, 3.36982794e-02f, 6.91907406e-02f, -1.11796372e-01f, 4.34794202e-02f, -5.94524741e-02f, -1.23866700e-01f, -7.30476007e-02f,
  -8.03317279e-02f, 2.99627911e-02f, 5.85611910e-02f, -8.13391209e-02f, -6.10959195e-02f, 1.09593784e-02f, -3.25394534e-02f, -2.87110396e-02f, 7.94844627e-02f, -4.16251570e-02f,
  1.96096390e-01f, -8.27580690e-02f, -6.53311312e-02f, 2.27740899e-01f, 4.52178359e-01f, 3.79061937e-01f, 2.47315779e-01f, 4.06828016e-01f, 3.43086421e-01f, 4.00455631e-02f,
  5.90669364e-02f, -1.32384583e-01f, -2.81806558e-01f, 2.86093116e-01f, 1.89332172e-01f, -1.90437630e-01f, 2.74956912e-01f, 6.79272413e-02f, 1.11990765e-01f, 1.03928894e-01f,
  1.34255186e-01f, 1.02951609e-01f, -3.90798971e-02f, 5.41815907e-02f, -3.89882084e-03f, -1.73900593e-02f, -2.14322984e-01f, -1.50233880e-01f, -2.53537558e-02f, 4.12820093e-02f,
  8.43453854e-02f, 6.06497526e-02f, 3.08754276e-02f, 3.71524058e-02f, 1.35283787e-02f, -3.32217366e-02f, -1.39487982e-01f, 4.93294820e-02f, 4.77054231e-02f, -6.82480708e-02f,
  -1.25674710e-01f, 6.09501489e-02f, 3.73988710e-02f, 3.26979831e-02f, 9.24421623e-02f, -2.37470530e-02f, -1.85997598e-02f, 6.98138028e-02f, 8.78760889e-02f, -8.87370631e-02f,
  4.53599729e-02f, -9.03385284e-04f, 1.44968420e-01f, -9.47568566e-03f, 1.12923533e-02f, 8.76265243e-02f, -6.69741929e-02f, -3.28335613e-02f, 1.23103075e-02f, 2.05442771e-01f,
  8.39589536e-03f, -2.98854872e-03f, -7.96946064e-02f, -5.64447530e-02f, 2.69286986e-02f, 8.43357062e-04f, 5.15740588e-02f, 1.83411483e-02f, -3.30928303e-02f, -1.82625873e-03f,
  6.08915351e-02f, 3.16125378e-02f, 1.17712684e-01f, -5.51728345e-02f, 3.05430088e-02f, 8.11431557e-02f, 1.84036363e-02f, -3.24221104e-02f, 7.22580627e-02f, -1.00103123e-02f,
  2.19638250e-03f, 4.58263606e-03f, -1.94758512e-02f, 6.94379732e-02f, -6.98737726e-02f, -1.71674579e-01f, -7.12767392e-02f, -7.67606348e-02f, 4.50497940e-02f, -3.25998515e-02f,
  3.40103619e-02f, 2.03747721e-03f, -7.71427751e-02f, -5.54425567e-02f, -1.68433599e-02f, -1.80086400e-02f, -5.57675585e-03f, 1.05874287e-02f, -3.68203558e-02f, 8.78377557e-02f,
  4.42209505e-02f, 8.79578218e-02f, -6.40444756e-02f, -9.81810018e-02f, -8.76093879e-02f, 4.63727023e-03f, -1.22651860e-01f, 1.19053364e-01f, 4.91055734e-02f, 5.03480360e-02f,
  2.25193482e-02f, 4.28297929e-02f, -5.99767976e-02f, 1.64227858e-01f, 4.26379545e-03f, 6.06087931e-02f, 5.95568642e-02f, -4.36329991e-02f, -1.33393854e-01f, 6.73128068e-02f,
  -4.05827790e-01f, 1.23077556e-02f, -2.62414664e-01f, 1.67822301e-01f, 3.20816822e-02f, 3.17324311e-01f, 1.79830909e-01f, 4.72085588e-02f, -1.52817398e-01f, 2.86533415e-01f,
  1.36822373e-01f, -1.09280296e-01f, -1.26420200e-01f, 5.14470994e-01f, -1.64142177e-02f, 1.12499468e-01f, 3.55611742e-01f, 2.53822267e-01f, -1.04368970e-01f, -5.37705645e-02f,
  -8.59480724e-02f, 2.62638330e-01f, 8.96942094e-02f, 3.50047909e-02f, 1.73177212e-01f, -1.60251275e-01f, 1.32291719e-01f, -1.88950583e-01f, 2.97883958e-01f, 1.46037877e-01f,
  9.89185199e-02f, -1.33993179e-01f, -5.16525619e-02f, -6.21973611e-02f, -7.10786656e-02f, -4.66879234e-02f, 1.91091131e-02f, 3.29148844e-02f, -4.04136032e-02f, -9.19015799e-03f,
  -4.04926017e-02f, -9.94768217e-02f, 1.03878692e-01f, -3.95774804e-02f, -4.41134758e-02f, -2.24874094e-02f, 1.16854031e-02f, 9.22061130e-02f, -1.02195796e-03f, 2.11110413e-02f,
  9.74606536e-03f, 8.31513330e-02f, 1.91984344e-02f, 8.24574307e-02f, 1.18876947e-03f, 1.03258669e-01f, 1.18504144e-01f, -5.75437732e-02f, -1.89638659e-02f, 5.42801134e-02f,
  -5.61059229e-02f, -7.47275800e-02f, -2.86378916e-02f, 5.51180504e-02f, -8.65043998e-02f, 8.09191242e-02f, 3.24723274e-02f, 3.07284831e-03f, -1.02352589e-01f, 1.47296665e-02f,
  4.63874899e-02f, -2.00564880e-02f, -1.26888342e-02f, -8.93382262e-03f, 9.69166961e-03f, 1.22318855e-02f, -1.94233805e-02f, -1.66656002e-02f, 1.78106700e-03f, 4.88510057e-02f,
  5.42463958e-02f, -3.11620813e-02f, -4.66652811e-02f, -8.50726012e-03f, 2.29828265e-02f, -7.08642453e-02f, 1.52129168e-03f, -3.81841511e-02f, 5.12531325e-02f, -4.94298823e-02f,
  -1.26438528e-01f, -2.79600084e-01f, 1.28647722e-02f, 2.05721147e-02f, -4.20213863e-02f, 3.75018418e-02f, -7.27814203e-03f, -3.07539217e-02f, -1.18374273e-01f, -8.22405368e-02f,
  3.55278067e-02f, 6.33584615e-03f, -1.03299849e-01f, 1.18524432e-02f, 8.94592255e-02f, -6.38465136e-02f, -6.47130013e-02f, 1.61148068e-02f, 9.03715473e-03f, -7.28488108e-03f,
  -5.22096790e-02f, -1.72969215e-02f, 5.86663149e-02f, -4.82375063e-02f, 1.03054747e-01f, -2.70468108e-02f, -1.00414202e-01f, 1.22183589e-02f, -5.00135217e-03f, -1.96036007e-02f,
  2.23293483e-01f, -2.97874302e-01f, 1.44358993e-01f, 1.41150385e-01f, 1.02921650e-01f, 2.01883554e-01f, 3.43783706e-01f, -1.97254587e-03f, 2.91156601e-02f, -2.97277272e-01f,
  -1.26041844e-01f, 1.77796230e-01f, 5.13065234e-02f, -6.20163232e-03f, 2.50207514e-01f, 3.56544973e-03f, 6.67714551e-02f, 1.80182934e-01f, 1.35835782e-01f, 7.77165741e-02f,
  6.21289834e-02f, -1.58274040e-01f, 9.03144851e-02f, -3.86334270e-01f, 1.49714187e-01f, -3.51002067e-02f, -8.35506395e-02f, 7.00439662e-02f, -2.71976680e-01f, -9.00522713e-03f,
  1.97841246e-02f, -3.58467139e-02f, -2.51729600e-02f, -1.08747289e-01f, 1.69280730e-02f, 9.00172889e-02f, -2.74977949e-03f, 1.62469044e-01f, 1.72930434e-01f, 4.65070084e-02f,
  7.30216736e-03f, -1.26799115e-03f, -8.82535242e-03f, 9.41210389e-02f, 3.37011628e-02f, 2.01620162e-02f, -2.00558640e-02f, 3.02297045e-02f, 3.10010780e-02f, 5.21169342e-02f,
  6.58970252e-02f, -2.94795837e-02f, 5.55892773e-02f, -3.34505402e-02f, -2.62386333e-02f, 5.27718998e-02f, 1.29355997e-01f, 1.12660006e-01f, 1.61813069e-02f, 1.11523140e-02f,
  -1.02068335e-01f, 8.99804989e-04f, 1.37378434e-02f, 6.07574619e-02f, -2.87455935e-02f, -4.81302217e-02f, -1.28676072e-02f, 7.31917918e-02f, -2.34658774e-02f, 3.42638465e-03f,
  8.16472340e-03f, -1.80836990e-02f, -3.25374790e-02f, 2.75962949e-02f, -1.35796098e-02f, -3.96986268e-02f, 3.96684334e-02f, 1.12989638e-02f, 1.25637110e-02f, -6.06797263e-02f,
  -7.77343195e-03f, 1.00336604e-01f, -6.31258860e-02f, 5.97212836e-02f, -7.41247321e-03f, 7.31784180e-02f, -9.79314446e-02f, 7.18523711e-02f, 6.53589591e-02f, 1.50139853e-02f,
  -1.50307128e-02f, -1.54083967e-01f, -9.53222141e-02f, -4.46066782e-02f, -8.52721855e-02f, 5.37783839e-03f, -8.24926347e-02f, -1.23322196e-01f, 1.24678966e-02f, -8.06010142e-02f,
  9.26663727e-03f, -5.28016221e-03f, 8.25365353e-03f, 6.97443038e-02f, -7.32943416e-02f, -8.25696439e-02f, 2.56743226e-02f, -8.55402872e-02f, -1.07104294e-01f, 2.15705354e-02f,
  -1.75234769e-02f, 8.42254460e-02f, 9.50894281e-02f, 2.25474574e-02f, -1.68367885e-02f, -8.57990328e-03f, 4.10187505e-02f, 1.37423130e-03f, -2.46529803e-02f, -2.44312901e-02f,
  9.83479712e-03f, -4.95920889e-02f, 1.81455329e-01f, 8.40080455e-02f, -3.44241150e-02f, -2.31038705e-01f, -1.35111213e-01f, -9.32865143e-02f, 1.00447738e-03f, -6.73797876e-02f,
  -5.62400632e-02f, 2.35745355e-01f, -1.11801468e-01f, 8.70821476e-02f, 1.40701950e-01f, -1.36708394e-01f, 9.71956849e-02f, -8.91789347e-02f, 1.56204388e-01f, 2.19356120e-02f,
  1.79017335e-01f, -3.97257470e-02f, 1.52188018e-01f, 3.23697478e-02f, 9.22824144e-02f, 1.66468427e-01f, 2.45177060e-01f, 3.48655656e-02f, 1.17378399e-01f, 4.03500423e-02f,
  -9.86619890e-02f, 1.19550034e-01f, -9.08355752e-04f, 1.35248364e-03f, 5.61871240e-03f, -4.08370281e-03f, -9.46120471e-02f, -8.65629390e-02f, 9.27663073e-02f, 1.14240870e-01f,
  -7.16816038e-02f, 8.70057419e-02f, -1.33777186e-01f, -4.47144434e-02f, -7.01734796e-02f, 1.30364001e-01f, 1.06958061e-01f, 3.83175537e-02f, -1.02291495e-01f, 1.31030930e-02f,
  5.28199365e-03f, -2.46087220e-02f, 2.97571030e-02f, -2.63031386e-02f, 9.90559161e-02f, -5.88149913e-02f, 4.57861051e-02f, 1.60390567e-02f, 8.19798484e-02f, 1.49266943e-01f,
  -3.48359719e-02f, 1.14213303e-03f, -1.27953547e-03f, 4.95667607e-02f, 5.13530336e-02f, 8.90928600e-03f, -1.05189756e-02f, 4.57766056e-02f, -2.91456245e-02f, -5.84306978e-02f,
  -2.06532851e-02f, -1.67855024e-02f, -6.36254176e-02f, 5.19494787e-02f, 6.39694110e-02f, -5.10457978e-02f, -5.70105435e-03f, -9.28991381e-03f, 4.05395776e-02f, 7.31209144e-02f,
  7.75898471e-02f, 5.68576008e-02f, 2.73330696e-02f, -1.18371718e-01f, -4.87844273e-02f, 1.06652498e-01f, 2.65531186e-02f, 2.68671289e-02f, 4.28429954e-02f, -3.98717523e-02f,
  1.34988353e-02f, 2.28203997e-01f, 1.13736622e-01f, -5.53482063e-02f, -5.84439700e-03f, -1.98441800e-02f, 1.37038482e-02f, 8.30347911e-02f, 8.93644392e-02f, -3.04021407e-02f,
  4.22868952e-02f, 3.22967581e-02f, 1.07242122e-01f, -2.31720340e-02f, -1.21574014e-01f, 8.44626948e-02f, 1.01006649e-01f, 8.31379741e-02f, 1.00174919e-02f, -6.47253022e-02f,
  2.95020472e-02f, -8.73047113e-02f, 6.56378120e-02f, -1.47963360e-01f, 1.51359901e-01f, -1.06477700e-01f, -1.42876580e-01f, -1.40502065e-01f, -5.41514233e-02f, -1.55855874e-02f,
  2.64319420e-01f, -1.14168003e-01f, 6.45349994e-02f, 3.10664326e-01f, 1.50264740e-01f, -5.87541722e-02f, 1.37451157e-01f, 9.89135504e-02f, 2.75205195e-01f, -6.95690215e-02f,
  -1.28189251e-02f, -2.26618245e-01f, -2.23044977e-01f, -2.11062804e-02f, -8.87399614e-02f, -2.18166545e-01f, 5.94177917e-02f, -8.35813060e-02f, 1.02265723e-01f, 4.15317826e-02f,
  1.09717682e-01f, 9.89946071e-03f, 4.21110839e-02f, -1.95434075e-02f, 9.02180187e-03f, 7.04310313e-02f, -6.65876940e-02f, -1.08488023e-01f, 1.16165556e-01f, -9.20635089e-02f,
  1.01470925e-01f, 9.98955593e-02f, 1.31832957e-01f, -8.80823061e-02f, 3.43421474e-02f, -2.36349721e-02f, 6.68884069e-02f, -6.57753125e-02f, 5.21381535e-02f, 6.53676689e-02f,
  -6.36206865e-02f, -8.55210051e-02f, 9.18839723e-02f, 2.49393191e-02f, 1.53353959e-02f, 1.62951294e-02f, 1.28689542e-01f, 1.16783171e-03f, 4.08007279e-02f, -3.75719629e-02f,
  2.66830120e-02f, 5.76006994e-03f, -1.61978900e-02f, -9.52612534e-02f, 1.19103536e-01f, 1.15876019e-01f, 4.87861596e-02f, 1.92468949e-02f, -1.72540471e-02f, 5.62657118e-02f,
  -7.18045747e-03f, 9.43626985e-02f, -1.95821971e-02f, 2.04266398e-03f, -8.78643151e-03f, 6.99774474e-02f, -1.52133301e-01f, -7.83999357e-03f, 6.52162284e-02f, -8.73952508e-02f,
  -1.87744141e-01f, 9.75669846e-02f, -1.14392871e-02f, -1.71227679e-02f, 9.15292725e-02f, 9.82225686e-02f, -6.67351484e-03f, -1.03366725e-01f, 1.65817484e-01f, 5.56049459e-02f,
  -8.69171843e-02f, -3.16150524e-02f, -1.58155859e-02f, 2.54678656e-04f, -5.23091517e-02f, -1.11041769e-01f, 3.63634266e-02f, -2.26344634e-02f, 8.82021561e-02f, -4.97999415e-02f,
  -2.35757381e-01f, -2.23202586e-01f, -4.12167758e-02f, -3.16761844e-02f, 3.01657505e-02f, -6.79909391e-03f, -3.18408050e-02f, -3.46746631e-02f, -1.44168943e-01f, -2.70497240e-02f,
  6.69416785e-02f, 8.35119337e-02f, -4.88892850e-03f, -8.40182379e-02f, -1.49048893e-02f, -1.14313804e-01f, -3.35465968e-02f, -2.59932429e-02f, 4.38271761e-02f, 1.25838667e-01f,
  2.24930719e-02f, -3.71470768e-03f, 1.61734354e-02f, 4.08142060e-02f, 8.84727091e-02f, -7.67728537e-02f, 6.08113818e-02f, -2.94770226e-02f, -2.38746972e-04f, 2.76088044e-02f,
  -8.87358114e-02f, 3.41683894e-01f, -2.95914579e-02f, -1.63959071e-01f, -6.93000928e-02f, -1.59579694e-01f, -1.46818444e-01f, 7.94411972e-02f, 9.61594582e-02f, 2.95482308e-01f,
  3.33598033e-02f, 1.84020728e-01f, -1.17670834e-01f, -2.05937728e-01f, -5.15693069e-01f, -3.04046482e-01f, -2.63620943e-01f, -2.75423881e-02f, -1.33015634e-02f, 7.90889375e-03f,
  -5.60947359e-02f, 1.27140097e-02f, -3.46508175e-01f, 1.60105512e-01f, 9.36971754e-02f, 1.94561779e-01f, -7.42409453e-02f, 1.29534692e-01f, -1.02443323e-02f, -2.49715662e-03f,
  -3.29094119e-02f, 8.77914876e-02f, 1.05469272e-01f, 5.33628911e-02f, 7.55813271e-02f, -4.00119536e-02f, -7.67782750e-03f, -8.18516314e-02f, 1.77570041e-02f, -1.95016619e-02f,
  1.39099425e-02f, -1.02359261e-02f, -9.52352509e-02f, -5.24921604e-02f, 8.87950733e-02f, 7.29916096e-02f, -2.13991441e-02f, 7.51220505e-04f, 8.42212662e-02f, -1.11584544e-01f,
  -7.35843405e-02f, -2.92985607e-02f, 1.20292129e-02f, -1.00199834e-01f, 1.03914728e-02f, 1.50012746e-02f, -2.88731861e-03f, -1.08236618e-01f, -8.03063903e-03f, -5.06349653e-02f,
  4.60305950e-03f, -1.60046697e-01f, -1.96445864e-02f, -4.62786704e-02f, -2.31352393e-02f, -1.55631695e-02f, 3.58817563e-03f, -6.05928525e-02f, 9.89953652e-02f, 9.00619489e-06f,
  5.94044104e-02f, -5.80023043e-04f, 9.05339792e-03f, -4.02043983e-02f, 3.49520780e-02f, -2.78123505e-02f, 1.41555155e-02f, -6.45075589e-02f, -5.59295230e-02f, -1.06507810e-02f,
  3.13560702e-02f, -6.10724911e-02f, 4.25486043e-02f, -9.90444571e-02f, 9.14417207e-02f, 2.28261147e-02f, -4.06264737e-02f, 4.61570472e-02f, -3.11236121e-02f, -5.18056788e-02f,
  1.51817784e-01f, 9.40848887e-02f, 1.59666866e-01f, 1.07732452e-01f, 5.36412373e-02f, -4.70745154e-02f, -1.24427982e-01f, -7.46494979e-02f, 6.24499400e-04f, -1.23563409e-01f,
  7.77017921e-02f, -3.43941748e-02f, 1.68875400e-02f, -9.13014859e-02f, 1.27946958e-02f, 6.69553652e-02f, 1.63205564e-02f, 2.05588546e-02f, -6.50861934e-02f, 1.20749073e-02f,
  -5.85025027e-02f, 8.89442191e-02f, 2.73041222e-02f, 8.79228637e-02f, 2.22003534e-02f, 7.75923058e-02f, 5.09390198e-02f, 5.25667593e-02f, -2.51417123e-02f, 5.24434336e-02f,
  2.66924381e-01f, -2.99484491e-01f, 1.05801314e-01f, 2.36626968e-01f, 2.23746017e-01f, 2.56941140e-01f, 8.59483555e-02f, 1.55817434e-01f, 9.69703272e-02f, -1.94941953e-01f,
  -1.39999107e-01f, -1.40235052e-01f, -2.58772641e-01f, -7.79519156e-02f, 5.20347804e-02f, -1.14904866e-01f, 1.85011610e-01f, -1.15383163e-01f, 7.77271912e-02f, 1.07554672e-02f,
  9.28145647e-02f, 2.10264139e-02f, 8.15636069e-02f, -3.22215296e-02f, -4.09351615e-03f, 1.42695218e-01f, 3.42060216e-02f, -9.96438563e-02f, 2.31755581e-02f, -3.04100811e-02f,
  1.27724018e-02f, -6.90555051e-02f, -1.28956204e-02f, 2.04969500e-03f, -9.04894024e-02f, -5.69764525e-02f, 6.37703529e-03f, -6.01844750e-02f, 6.46854341e-02f, 2.11135074e-02f,
  -4.63774391e-02f, -5.26892655e-02f, 2.29375809e-02f, -5.70140183e-02f, 2.76308134e-02f, -2.36872267e-02f, 1.33299500e-01f, 4.40695472e-02f, -6.99746385e-02f, 4.36020084e-02f,
  -3.48943248e-02f, 6.01986051e-02f, -6.54956847e-02f, -4.25939932e-02f, -2.36697998e-02f, -8.92415643e-03f, 1.44284815e-01f, 3.64678688e-02f, 6.58357069e-02f, 4.36165780e-02f,
  6.17513843e-02f, 4.66733165e-02f, 4.84199896e-02f, -1.12104639e-01f, 2.46737301e-02f, -1.51429307e-02f, 6.59360215e-02f, 2.84301303e-02f, 8.84301737e-02f, 5.20816520e-02f,
  1.16936035e-01f, -1.46308374e-02f, 3.98648530e-02f, 7.57566839e-02f, -2.50790864e-02f, -2.13122405e-02f, -3.70462835e-02f, -5.75345308e-02f, -3.90397049e-02f, 1.13905355e-01f,
  8.88351798e-02f, 6.87010810e-02f, -8.50920230e-02f, -1.12427427e-02f, -8.61563683e-02f, 6.43955097e-02f, -5.86061180e-03f, -8.20585191e-02f, 5.37319593e-02f, -9.45520028e-03f,
  -5.47673285e-01f, -3.12642395e-01f, -6.37083175e-03f, -7.14522526e-02f, -7.40851695e-03f, -1.89635500e-01f, 4.66579683e-02f, -4.07293264e-04f, -1.55668529e-02f, 3.20993476e-02f,
  -3.64639834e-02f, 6.21943101e-02f, -9.49987248e-02f, -4.63949218e-02f, 2.01231632e-02f, -3.52101610e-03f, -4.51895148e-02f, -2.50755455e-02f, 1.61900669e-02f, -4.95783612e-02f,
  -6.10497594e-02f, -9.32277068e-02f, -6.47406429e-02f, 5.92902377e-02f, 1.21880909e-02f, 8.02912489e-02f, -4.88104522e-02f, -1.41645912e-02f, -5.22562861e-02f, -8.78865048e-02f,
  1.88139439e-01f, -9.92650166e-02f, -2.07063049e-01f, -2.24662110e-01f, -2.41280630e-01f, -1.51183486e-01f, -1.56742603e-01f, -1.82041258e-01f, 1.27874359e-01f, 1.01461530e-01f,
  -9.22635645e-02f, 6.84275627e-02f, 2.53863662e-01f, -1.56553939e-01f, 1.94982708e-01f, 3.03810179e-01f, -1.08436290e-02f, 6.86459765e-02f, 6.51602894e-02f, -6.98353499e-02f,
  8.06158260e-02f, -1.03825912e-01f, -1.40718833e-01f, -4.74994965e-02f, -2.80840605e-01f, -8.40013549e-02f, -9.59743336e-02f, -2.83456355e-01f, -2.23936319e-01f, -1.42795384e-01f,
  -6.57611713e-02f, -1.48176298e-01f, -8.48539472e-02f, 8.86554644e-02f, -2.02489756e-02f, 4.55569699e-02f, 4.72988524e-02f, 5.52559737e-03f, -1.02074873e-02f, -6.79856911e-02f,
  2.55300812e-02f, 6.16569147e-02f, -2.69264597e-02f, -1.34440633e-02f, -1.18757471e-01f, -1.00240439e-01f, 9.42232385e-02f, -6.94322214e-02f, 6.06316775e-02f, 2.22629886e-02f,
  -4.36100364e-02f, -1.55449733e-01f, -8.96431282e-02f, 5.48179299e-02f, -1.25626460e-01f, -1.74000685e-04f, 5.09628318e-02f, -8.70272294e-02f, 5.13111129e-02f, -2.76173819e-02f,
  1.52414031e-02f, 8.25794265e-02f, 8.10789168e-02f, 7.76295885e-02f, -2.02392414e-03f, -9.50069167e-03f, -4.04779390e-02f, -3.06090936e-02f, 6.11195862e-02f, -3.94907035e-03f,
  -8.01914856e-02f, 1.07219800e-01f, -4.42700908e-02f, 2.36072671e-02f, 1.22699708e-01f, 3.93410474e-02f, -5.60169108e-02f, -3.20465714e-02f, 2.09394824e-02f, 1.18971109e-01f,
  7.30132982e-02f, -4.85218540e-02f, -3.37536484e-02f, -1.69702806e-02f, -1.89295784e-02f, -3.54991667e-03f, 1.35178994e-02f, 9.33632068e-03f, -9.35636833e-02f, -7.40996702e-03f,
  6.72024861e-02f, 5.29496223e-02f, 6.62695095e-02f, 1.11290533e-02f, -7.29220221e-03f, 9.71474405e-03f, 1.08615465e-01f, 2.59252009e-03f, 5.11439284e-03f, 6.13646992e-02f,
  -3.04306243e-02f, 1.33148581e-02f, -5.18288761e-02f, -1.78912450e-02f, -1.76165923e-01f, 2.42381562e-02f, 6.70774579e-02f, -1.90355536e-02f, -1.41670357e-03f, -5.76161854e-02f,
  2.16712113e-02f, 2.03590579e-02f, 3.49850729e-02f, 9.63680372e-02f, 1.37947008e-01f, 4.49610688e-02f, 2.39084363e-02f, -4.17388491e-02f, -1.67399384e-02f, 5.11834323e-02f,
  8.94669518e-02f, 5.08344591e-01f, 1.44949093e-01f, 1.90249085e-02f, 5.78525066e-02f, -1.68065459e-01f, -8.48749951e-02f, 1.38317913e-01f, 1.29842103e-01f, 1.52336329e-01f,
  -7.31150955e-02f, 2.48241439e-01f, -1.88553035e-01f, 5.77236861e-02f, -3.56802344e-01f, -2.17493057e-01f, -1.08860098e-01f, -4.99524064e-02f, 7.85756111e-03f, -3.70598189e-03f,
  3.84416617e-02f, -2.12947771e-01f, -2.52551641e-02f, 6.90468252e-02f, 5.44595048e-02f, 1.66223869e-01f, -1.77802444e-01f, 2.92745332e-04f, -8.04766640e-03f, 1.41301593e-02f,
  1.98617592e-01f, 1.98223442e-01f, 9.17663947e-02f, 3.06074172e-02f, -1.07232876e-01f, 5.39279403e-03f, -5.03728278e-02f, -5.15885502e-02f, 3.38750356e-03f, 4.02022079e-02f,
  -7.11782090e-03f, 1.98088982e-03f, 5.52899987e-02f, 6.73738047e-02f, 9.78075787e-02f, 6.48738071e-02f, -2.51771323e-02f, 8.93488303e-02f, 1.27556860e-01f, 1.23407938e-01f,
  2.90466249e-02f, 5.75368218e-02f, -1.36916181e-02f, 3.10105924e-02f, 2.36528292e-02f, -6.80795172e-03f, -5.59143461e-02f, 6.85148537e-02f, 1.30318493e-01f, 3.57935429e-02f,
  7.85614625e-02f, 5.85389324e-03f, 3.12726945e-02f, 1.82363577e-03f, 3.84748355e-03f, 3.76022384e-02f, -4.19193599e-03f, -1.01316087e-01f, 5.85389184e-03f, -3.31279933e-02f,
  2.21719616e-03f, 1.13831617e-01f, -1.40556032e-02f, -6.26654103e-02f, -2.72223186e-02f, 3.87896225e-02f, -3.99788655e-02f, -2.94821486e-02f, -4.92438376e-02f, 6.41921489e-03f,
  -6.85329661e-02f, -1.40493661e-01f, 3.98668833e-02f, 2.14369092e-02f, 1.95832197e-02f, -3.91187407e-02f, 6.48312420e-02f, 3.18685062e-02f, -2.88802572e-02f, -9.66349244e-02f,
  -3.70157689e-01f, -2.42404297e-01f, 5.19229583e-02f, 2.92370474e-04f, -6.99952915e-02f, 1.31981149e-01f, -1.78354923e-02f, 7.59240836e-02f, -1.79012790e-01f, -8.55333805e-02f,
  2.20336448e-02f, -8.06611311e-03f, 1.18625555e-02f, 1.07886726e-02f, -2.93996688e-02f, -1.23564087e-01f, -6.45798221e-02f, -2.06403751e-02f, -1.00832969e-01f, -2.48796176e-02f,
  2.99991462e-02f, -9.35110375e-02f, -2.35336795e-02f, 1.01469215e-02f, 4.11607623e-02f, 9.84866358e-03f, 6.85163960e-02f, 1.02084629e-01f, -1.78608000e-01f, -7.67499730e-02f,
  -4.14566845e-01f, 2.32760519e-01f, 2.45415866e-02f, -2.85085514e-02f, 1.38384715e-01f, 3.64743143e-01f, 2.91298926e-01f, 2.78342724e-01f, 4.32122320e-01f, 1.43676221e-01f,
  -1.46863937e-01f, 1.78480342e-01f, 1.80311520e-02f, 4.70145792e-02f, 8.54310989e-02f, 1.14282407e-01f, 2.04951525e-01f, 2.12267593e-01f, 2.51275748e-01f, 3.37106250e-02f,
  -6.39842227e-02f, 6.87843263e-02f, -2.21218064e-01f, 1.78953577e-02f, -9.13842320e-02f, -2.35818210e-04f, -3.22825611e-01f, 6.08150810e-02f, -1.28836185e-01f, 1.51825905e-01f,
  -9.43650082e-02f, -2.44511049e-02f, -1.74954802e-01f, 1.78740826e-02f, -1.79546431e-01f, -4.45208140e-02f, 1.96639504e-02f, -5.30924089e-02f, 4.82005924e-02f, 1.70019846e-02f,
  -7.65456911e-03f, -7.56315589e-02f, 1.52589809e-02f, 1.06147826e-01f, 8.08539093e-02f, -4.06290293e-02f, -8.40416402e-02f, -7.98114166e-02f, 1.88404471e-02f, -7.93305412e-02f,
  2.57890346e-03f, -3.08703240e-02f, -2.94196997e-02f, 1.71533525e-01f, -1.20901175e-01f, -1.78397540e-02f, 9.38182250e-02f, -2.94225067e-02f, 5.39367795e-02f, 7.75709003e-02f,
  6.66172877e-02f, 9.04872864e-02f, 1.85873024e-02f, 7.71549996e-03f, 4.44528200e-02f, -2.77183075e-02f, -3.53581458e-02f, -1.81569122e-02f, 2.70985421e-02f, -6.84411973e-02f,
  -6.99751228e-02f, 2.79819011e-03f, 7.96990395e-02f, 5.40844351e-03f, -2.12318394e-02f, -1.37251001e-02f, -1.16314143e-01f, 3.95711921e-02f, 1.07638128e-01f, -2.79330742e-02f,
  -6.89327950e-03f, 8.69677812e-02f, -1.25067174e-01f, -6.98151812e-02f, -3.66633534e-02f, -9.66637209e-02f, 2.79926844e-02f, -7.45390058e-02f, 4.12430130e-02f, 4.71788421e-02f,
  3.39993328e-01f, 4.68559951e-01f, -1.11101968e-02f, -1.07608149e-02f, -1.58769377e-02f, 4.14297953e-02f, 2.15679239e-02f, -9.95223373e-02f, 8.24833959e-02f, 4.85255532e-02f,
  9.21994820e-03f, -5.83185665e-02f, 1.32335220e-02f, -5.66002578e-02f, 6.31754473e-02f, 6.62582070e-02f, 6.74542189e-02f, 8.02317858e-02f, 7.83454329e-02f, 1.08916514e-01f,
  -1.04920380e-01f, 3.62465456e-02f, 3.15785520e-02f, -8.47607777e-02f, -7.21384659e-02f, -3.20879444e-02f, -1.30518880e-02f, 3.86734977e-02f, -2.85961144e-02f, 2.36823596e-02f,
  -5.44710755e-01f, 1.32056564e-01f, 3.91224563e-01f, -3.26870978e-01f, 3.52233142e-01f, 4.30676222e-01f, 1.09827466e-01f, 9.71224681e-02f, -2.00974628e-01f, -2.47540861e-01f,
  -2.55289167e-01f, -5.71554676e-02f, 1.63823947e-01f, -9.33011174e-02f, 1.51903257e-01f, 8.88567865e-02f, -4.94539067e-02f, -1.06949113e-01f, 1.37041345e-01f, -4.24307287e-02f,
  1.32644206e-01f, -1.55505456e-03f, 2.63357610e-01f, 5.53372242e-02f, 2.66577513e-03f, -1.64004833e-01f, -1.26928821e-01f, 2.68031836e-01f, -1.70848519e-01f, 7.62362406e-02f,
  -2.47031022e-02f, -8.04685354e-02f, -7.38355448e-04f, 9.38995630e-02f, 8.14293697e-02f, -3.41154858e-02f, 6.58071786e-02f, 8.62400457e-02f, -1.35704413e-01f, 6.39988715e-03f,
  -7.51486886e-03f, 1.30777240e-01f, -7.23482221e-02f, 3.56190540e-02f, -3.29478993e-03f, -9.76017769e-03f, 4.01307978e-02f, 1.74068548e-02f, -1.22152874e-02f, 7.33590797e-02f,
  -2.14270651e-02f, 2.21622717e-02f, -9.99166723e-03f, -1.24407478e-01f, 8.31122398e-02f, 2.34506987e-02f, -2.50324141e-03f, 7.99038622e-04f, -1.38427317e-02f, 7.85411671e-02f,
  1.27161192e-02f, -4.74373735e-02f, 3.57477814e-02f, -6.81216642e-02f, 7.63579383e-02f, -3.81828398e-02f, -7.14068860e-02f, -1.86216477e-02f, -3.75878066e-02f, -5.57779595e-02f,
  -6.33729771e-02f, -3.56523171e-02f, 8.50952938e-02f, -1.30514860e-01f, -6.08699955e-02f, -2.70579308e-02f, -5.35919005e-03f, 3.45452614e-02f, 3.95631529e-02f, -1.31588615e-02f,
  1.10367602e-02f, 5.38644381e-02f, -2.00042482e-02f, 1.69632714e-02f, 6.05358779e-02f, 6.40635863e-02f, -4.86474223e-02f, -1.84039883e-02f, -7.58351088e-02f, 5.46173528e-02f,
  -3.61883730e-01f, -2.10842788e-01f, -9.03893784e-02f, -1.36911515e-02f, -5.93377389e-02f, 2.59640031e-02f, 3.53473648e-02f, -2.37983502e-02f, 3.61956563e-03f, 1.56648997e-02f,
  -1.30773429e-02f, -5.34664206e-02f, 2.40582880e-02f, -1.04532264e-01f, 5.33245280e-02f, 2.35090777e-02f, -1.06931448e-01f, -8.64496231e-02f, -6.22311197e-02f, -2.23309826e-02f,
  1.32211326e-02f, -5.05077764e-02f, -9.65543613e-02f, -5.83185777e-02f, -3.31412139e-03f, -1.04509398e-01f, -1.43085763e-01f, -7.12696835e-02f, 9.48178098e-02f, 8.46097246e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.23411575e-01f, 1.19049894e-03f, 3.05402517e-01f, 7.20735565e-02f, 5.82892485e-02f, 6.49122372e-02f, 1.98893771e-01f, 9.25118029e-02f, -8.64919722e-02f, 1.83887184e-01f,
  5.25012836e-02f, 1.86345488e-01f, -8.67493376e-02f, -8.51576701e-02f, 1.30177394e-01f, 2.04930991e-01f, 3.33340056e-02f, 1.16131149e-01f, 1.79609850e-01f, 3.29013050e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.08602011e-01f, 3.27701010e-02f, 1.71679080e-01f, -1.21270046e-01f, 1.83154583e-01f, -4.60400246e-02f, 1.61254257e-01f, 1.48188844e-02f, -2.78685063e-01f, 7.01329485e-02f,
  -1.04680769e-01f, -3.96895498e-01f, -1.08350933e-01f, 2.04855368e-01f, -3.26482832e-01f, 2.51128703e-01f, -2.79682606e-01f, 1.37481481e-01f, 3.12952578e-01f, 1.19139425e-01f,
  4.20736849e-01f, 9.77544487e-02f, -1.35012165e-01f, 6.68740794e-02f, 2.96447992e-01f, 1.26465589e-01f, -2.00454503e-01f, -1.11148385e-02f, 1.24391973e-01f, -3.05227309e-01f,
  1.87791660e-02f, -8.85143504e-02f, -2.14031279e-01f, 4.80744615e-02f, -6.35518432e-02f, -5.96362352e-02f, 1.07287295e-01f, 2.04112902e-01f, -1.52180955e-01f, -4.30071447e-03f,
  3.24992925e-01f, 1.38117999e-01f, 2.45829746e-02f, -3.29383373e-01f, 2.03776613e-01f, 2.09363326e-01f, 1.64705828e-01f, -1.91208124e-01f, 3.71554166e-01f, 1.56875312e-01f,
  1.84413865e-01f, -1.44031867e-01f, 5.47735654e-02f, -5.81586212e-02f, 2.76429951e-01f, 1.59181375e-02f, -1.42734990e-01f, -3.36283110e-02f, -6.55277818e-02f, -1.44602865e-01f,
  1.81980953e-01f, -1.43003076e-01f, -2.05448568e-01f, -2.20174223e-01f, -1.60631701e-01f, -1.41327837e-02f, 8.41753408e-02f, -5.58058098e-02f, 1.79908246e-01f, 1.86676934e-01f,
  2.35509515e-01f, -2.52983302e-01f, 7.97484145e-02f, 2.81792521e-01f, -2.02188998e-01f, -3.94869447e-02f, 2.46488839e-01f, -6.80709407e-02f, -6.83051869e-02f, -7.97086358e-02f,
  -1.17651857e-01f, -9.58943292e-02f, 8.83961096e-03f, -2.45923072e-01f, -8.73214155e-02f, -7.84199610e-02f, 1.01343930e-01f, -5.48037812e-02f, -8.34346116e-02f, 1.31306872e-01f,
  -1.42602801e-01f, 2.70063937e-01f, -1.71417415e-01f, 2.99121529e-01f, 2.96617951e-02f, 1.66362390e-01f, 2.34998837e-02f, 2.37331688e-02f, 7.39879906e-02f, 1.19484007e-01f,
  -2.13524982e-01f, 2.80449055e-02f, 2.66442537e-01f, 2.51019988e-02f, -1.18884847e-01f, 1.45443931e-01f, 3.24576460e-02f, 1.99079677e-01f, 2.86202312e-01f, 4.26994674e-02f,
  3.36203128e-02f, -1.76337093e-01f, -3.19750607e-01f, -2.50677556e-01f, -2.92481899e-01f, -3.55887771e-01f, -6.79958314e-02f, -2.51984894e-01f, 5.99560030e-02f, -3.20648924e-02f,
  -3.74066904e-02f, -1.22010365e-01f, 8.07573646e-02f, -6.58453405e-02f, 1.41808875e-02f, 4.02056247e-01f, -1.33592915e-02f, 3.23525220e-01f, -3.77768241e-02f, -1.53956264e-01f,
  2.95412857e-02f, 3.95880230e-02f, 1.30270213e-01f, 6.67862445e-02f, 3.80262971e-01f, -9.85334441e-02f, -2.28811935e-01f, 1.73190340e-01f, -1.50213510e-01f, 1.03970669e-01f,
  -1.83147341e-01f, -3.57666463e-01f, -5.84529154e-02f, -9.09064561e-02f, -1.35557249e-01f, -2.65465021e-01f, -4.52925749e-02f, -3.65574092e-01f, 2.46338304e-02f, 1.25755623e-01f,
  -4.12840784e-01f, 3.49364430e-01f, -1.24664478e-01f, -1.37180194e-01f, 1.12970419e-01f, 4.97642756e-02f, -1.11577645e-01f, 1.89161226e-01f, 3.54901046e-01f, 3.74964803e-01f,
  -1.11830711e-01f, 4.50339653e-02f, 1.90621987e-01f, -1.40128285e-01f, 1.84224546e-01f, 1.61852553e-01f, 1.38498768e-01f, 9.64247212e-02f, 7.48178810e-02f, 8.44914392e-02f,
  -9.30190831e-02f, -1.55928265e-02f, -5.92925660e-02f, -1.84103716e-02f, 8.30247626e-02f, -3.10855836e-01f, 1.88705012e-01f, -7.98771232e-02f, -7.79796019e-02f, -2.27278575e-01f,
  -3.01442087e-01f, -1.42987505e-01f, -4.05009389e-01f, 3.79010767e-01f, -2.08338812e-01f, 8.16914663e-02f, 3.06887984e-01f, 2.93602914e-01f, -1.08161710e-01f, 2.27140769e-01f,
  1.54011101e-01f, 1.58658698e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.15724438e-01f, 2.90928364e-01f, 1.47127479e-01f, 4.72574793e-02f, 2.98198223e-01f, 2.92381972e-01f, 2.12569013e-01f, -1.38023809e-01f, 3.38654906e-01f, 2.30497777e-01f,
  -3.22521590e-02f, -4.53920364e-01f, 4.70148325e-01f, -2.72700071e-01f, -2.34891012e-01f, 3.78683172e-02f, -3.71889817e-03f, -9.62787718e-02f, 2.92096615e-01f, 2.58934200e-01f,
  1.26385599e-01f, 2.24690586e-01f, 3.56049091e-01f, 2.32705697e-01f, -1.86964437e-01f, -2.68100232e-01f, -3.05399626e-01f, -5.32010337e-03f, 2.87379146e-01f, -3.08086723e-01f,
  3.89566422e-01f, 4.53859568e-01f, 1.67234197e-01f, 3.93704623e-02f, 3.83325487e-01f, 2.60869801e-01f, 1.44331172e-01f, -4.65091951e-02f, -1.91800892e-01f, 4.51272845e-01f,
  1.60138413e-01f, -3.88545632e-01f, -1.68651417e-01f, 1.96728557e-01f, 5.57122380e-03f, 2.83533782e-02f, 6.23951793e-01f, 1.17999449e-01f, 3.07242513e-01f, 2.96788126e-01f,
  -1.97689801e-01f, 3.18287700e-01f, -2.43387371e-01f, 1.16481915e-01f, -1.20001264e-01f, 4.08158042e-02f, 2.38363203e-02f, -2.15718716e-01f, 2.16910034e-01f, -3.53679806e-03f,
  -2.29414180e-01f, -1.48101225e-01f, 2.46955827e-01f, 4.33970928e-01f, 8.19282457e-02f, 4.30468500e-01f, 4.00792986e-01f, 1.92690432e-01f, 3.67242306e-01f, 3.09006155e-01f,
  4.37050849e-01f, -3.50519985e-01f, 1.86658978e-01f, 2.88252175e-01f, 2.71702141e-01f, -4.26699281e-01f, -6.50431812e-02f, 7.92818666e-02f, -1.22875884e-01f, 4.61131968e-02f,
  -1.39287546e-01f, -5.82251698e-02f, 3.50817651e-01f, -8.96851569e-02f, -1.92749575e-02f, 3.20117086e-01f, -2.09146678e-01f, 4.62417096e-01f, 8.33547711e-02f, 4.76217978e-02f,
  1.44133329e-01f, 8.79396498e-02f, 1.36663899e-01f, -1.34949945e-02f, 1.33590922e-01f, 3.80744785e-01f, 2.59106457e-01f, 1.97122321e-01f, 1.27447441e-01f, 2.84842342e-01f,
  1.48034006e-01f, 2.34633267e-01f, 6.95257708e-02f, -6.24483675e-02f, 4.63873535e-01f, -1.04746915e-01f, 5.42547889e-02f, -1.96241125e-01f, 4.33067977e-01f, -2.30119348e-01f,
  -9.14990380e-02f, -3.42461243e-02f, 2.85859797e-02f, 1.91937938e-01f, -3.07510436e-01f, -3.38707805e-01f, 6.45352378e-02f, -3.14637423e-01f, 2.49477118e-01f, 2.73345232e-01f,
  -1.50995165e-01f, -9.56593379e-02f, 6.26635551e-02f, 1.63078249e-01f, 2.59093970e-01f, -2.52514750e-01f, 1.57201648e-01f, 3.00901890e-01f, 3.53338093e-01f, 1.00900993e-01f,
  1.37450159e-01f, 2.93294281e-01f, 6.75204471e-02f, -1.89867496e-01f, -2.99078047e-01f, 2.61540979e-01f, 1.66421801e-01f, -3.05140674e-01f, -1.13553993e-01f, 2.83292737e-02f,
  -1.54013097e-01f, -1.76490158e-01f, -2.41793115e-02f, 2.14189798e-01f, 2.30438277e-01f, 2.66049832e-01f, 1.26662210e-01f, 2.09136412e-01f, -4.56515066e-02f, 2.42470399e-01f,
  -2.68035959e-02f, 1.42940730e-02f, 3.27367872e-01f, -2.19222441e-01f, 9.31499824e-02f, -1.73735932e-01f, 8.16877186e-02f, -2.89525449e-01f, 3.48184109e-01f, -1.21803105e-01f,
  3.09727997e-01f, 1.07793525e-01f, 1.32238761e-01f, 2.48372316e-01f, 2.16055155e-01f, -2.13813022e-01f, -2.83558518e-01f, 6.44458532e-02f, -2.53972411e-01f, -1.89534128e-01f,
  -1.54813930e-01f, -2.60356426e-01f, -1.67989582e-01f, 1.45578668e-01f, 1.91696107e-01f, 2.21735522e-01f, 1.09691568e-01f, 3.14531177e-01f, -1.07116237e-01f, 7.31644258e-02f,
  4.48055238e-01f, 2.43095443e-01f, -3.73076648e-02f, -1.02878310e-01f, 4.58442569e-01f, -1.91999108e-01f, -7.94589296e-02f, -3.97132039e-01f, 2.90478855e-01f, -2.73676932e-01f,
  1.43755093e-01f, -2.20718890e-01f, 4.60624874e-01f, 4.17112499e-01f, 5.33257902e-01f, 3.76407743e-01f, 4.72614467e-01f, 2.07756639e-01f, -2.60786772e-01f, 4.68128324e-01f,
  -4.75228429e-01f, -5.61641455e-02f, -2.30096504e-01f, 6.18782461e-01f, 1.21023236e-02f, 4.98844296e-01f, 6.08269691e-01f, 2.64492124e-01f, 2.32143253e-01f, -7.36051574e-02f,
  4.17674303e-01f, 2.25459456e-01f, -1.01399653e-01f, 4.63871270e-01f, 1.40292034e-01f, -2.84615010e-02f, 3.20898592e-01f, 2.42592171e-01f, 9.21331421e-02f, 3.78360301e-01f,
  -2.40122691e-01f, 5.16999364e-01f, -6.32290468e-02f, 4.32521194e-01f, -3.09497397e-02f, -1.13478892e-01f, 1.51664853e-01f, -4.88337129e-02f, -1.26718238e-01f, -2.95488182e-02f,
  1.19982585e-01f, 3.68534736e-02f, 2.80275017e-01f, -1.02988318e-01f, 1.62142664e-01f, -2.51267791e-01f, 1.19764164e-01f, -4.91380207e-02f, -4.36661303e-01f, -2.47999966e-01f,
  2.16564223e-01f, 1.11699499e-01f, -2.03477457e-01f, -6.22284748e-02f, -2.14790270e-01f, -1.91766784e-01f, -1.04791149e-01f, 2.78471529e-01f, 9.66648683e-02f, -1.30537778e-01f,
  4.32734936e-02f, 2.04843968e-01f, 1.90898478e-01f, -4.83903199e-01f, 1.60434574e-01f, 2.05029815e-01f, 3.43073666e-01f, 3.00090224e-01f, 3.41488451e-01f, 2.98256069e-01f,
  2.21480101e-01f, 3.33207071e-01f, -1.69005305e-01f, -5.06722331e-02f, 6.13567770e-01f, -7.65883178e-02f, -1.90263838e-01f, -3.67221922e-01f, 3.34305525e-01f, -2.03318715e-01f,
  2.45704964e-01f, -2.84517091e-02f, 4.36096072e-01f, 3.10679991e-02f, 6.06938004e-02f, -1.23534918e-01f, 3.66190016e-01f, 1.07059687e-01f, 5.73016480e-02f, 2.36302659e-01f,
  2.23097634e-02f, -3.86435151e-01f, 1.71351507e-01f, -9.53637362e-02f, 3.57830495e-01f, -2.25680217e-01f, 5.72036922e-01f, 5.05263925e-01f, 5.87182306e-02f, -1.30260596e-02f,
  4.25056033e-02f, 2.88182557e-01f, 3.18266541e-01f, -1.30653784e-01f, 1.10061415e-01f, -1.87708382e-02f, -1.32666856e-01f, 2.28797302e-01f, 4.03347276e-02f, -2.54632086e-01f,
  2.98478585e-02f, 1.76918060e-01f, -3.58151346e-01f, 3.98053944e-01f, 4.56961989e-03f, -9.34207141e-02f, 3.47028673e-01f, -6.47061989e-02f, 3.85414749e-01f, 3.57081026e-01f,
  -2.54702363e-02f, 1.75717875e-01f, 5.02686873e-02f, 2.64603436e-01f, -1.53061911e-01f, 1.38673574e-01f, 1.83002576e-01f, -3.56943160e-01f, 3.29547644e-01f, -1.53137237e-01f,
  1.69660777e-01f, 6.65492564e-02f, 3.44383385e-04f, 2.50551164e-01f, 2.62217849e-01f, 3.56444597e-01f, 1.05865069e-01f, -3.37631702e-01f, 8.86532515e-02f, 5.64888939e-02f,
  -1.56395435e-01f, -2.77361453e-01f, 3.83296400e-01f, 3.22447807e-01f, 4.63817641e-02f, 2.23015442e-01f, -1.62652463e-01f, -2.57453471e-01f, 2.01045126e-01f, 3.69416848e-02f,
  -1.08275302e-01f, 2.89930165e-01f, 3.70266944e-01f, 3.16783667e-01f, -2.85248548e-01f, 3.93589318e-01f, 1.55544626e-02f, 3.95091265e-01f, -1.45295367e-01f, -1.48884103e-01f,
  -5.92405498e-02f, 2.65005052e-01f, -3.36082838e-02f, 1.34154692e-01f, 2.61644185e-01f, 1.85657501e-01f, 3.48380581e-02f, 2.16164052e-01f, 2.12887570e-01f, -3.87324780e-01f,
  5.42343676e-01f, -1.11341693e-01f, 2.70815074e-01f, -2.84415603e-01f, 3.17761719e-01f, -3.80392641e-01f, -5.74481562e-02f, -1.32507667e-01f, 1.52555957e-01f, 1.64136648e-01f,
  3.08755100e-01f, 1.02160737e-01f, -1.75228328e-01f, -4.87125516e-02f, -4.57055829e-02f, 5.85638322e-02f, -1.86123639e-01f, -3.11429799e-01f, 8.79475847e-02f, -8.59635249e-02f,
  7.46484697e-02f, -4.61932331e-01f, 1.64704964e-01f, 1.79754838e-01f, -1.24625415e-01f, 2.44816840e-02f, -3.92843299e-02f, 2.43097022e-02f, -4.69800970e-03f, 1.61773354e-01f,
  3.55844557e-01f, -1.88540444e-01f, -4.98987585e-02f, 1.44497557e-02f, 3.31090182e-01f, 5.20429425e-02f, -2.44852483e-01f, 1.08893253e-01f, -8.80547166e-02f, 9.39913467e-02f,
  2.27319792e-01f, 3.56710516e-02f, 2.91606426e-01f, 1.65059999e-01f, -1.14618689e-01f, 2.01513067e-01f, -1.22029029e-01f, 1.44880891e-01f, -4.67327684e-02f, 4.85276788e-01f,
  2.52488196e-01f, 3.29351187e-01f, -9.00908280e-03f, 4.19910133e-01f, -1.98576614e-01f, -2.40195990e-01f, 2.94564545e-01f, 3.34426135e-01f, 3.85394305e-01f, 3.13482702e-01f,
  1.46706281e-02f, 3.10456380e-02f, 3.40176851e-01f, -2.16619503e-02f, -1.64962843e-01f, 2.75318921e-01f, -2.39951015e-02f, 7.58399023e-03f, 5.99092282e-02f, -2.51254797e-01f,
  -1.16962716e-01f, -2.38123536e-01f, -2.11363450e-01f, -2.79443234e-01f, 1.08526781e-01f, -3.63154083e-01f, -1.42634392e-01f, 1.00614913e-01f, -3.37820709e-01f, 2.17902049e-01f,
  5.07857464e-02f, 5.98414429e-02f, 3.70807439e-01f, 2.55309731e-01f, -2.60517132e-02f, 5.45356750e-01f, 2.96847254e-01f, 2.18436778e-01f, 6.85024858e-02f, 2.10745737e-01f,
  2.00804368e-01f, 3.96241248e-01f, 4.55144614e-01f, -1.05166391e-01f, -1.74059719e-01f, 2.79821813e-01f, -1.25852942e-01f, -3.61702263e-01f, -2.46932149e-01f, 5.04328646e-02f,
  -2.18669385e-01f, -1.01978362e-01f, 2.80732214e-01f, 1.43378153e-01f, 1.71508536e-01f, 1.58410087e-01f, -2.83252209e-01f, -2.46039897e-01f, 2.73999304e-01f, 2.02421024e-01f,
  -2.74608940e-01f, 1.54490367e-01f, 2.88061321e-01f, 2.91098375e-02f, 4.20133233e-01f, -3.11469495e-01f, 1.28981635e-01f, 3.70609164e-02f, 5.54512918e-01f, -1.19038142e-01f,
  1.58529088e-01f, 2.23001912e-01f, 1.33859977e-01f, 8.55844170e-02f, 2.63221085e-01f, 2.35869382e-02f, 3.98526788e-01f, -2.01742247e-01f, -3.45473468e-01f, 3.07700545e-01f,
  2.34081402e-01f, -1.15411326e-01f, -5.20818710e-01f, 2.23905146e-01f, 1.33423835e-01f, 9.23836976e-02f, -2.12791160e-01f, -3.42445552e-01f, 3.92424226e-01f, -4.60429601e-02f,
  -3.03557575e-01f, 2.91672289e-01f, 8.20445195e-02f, 4.14955467e-01f, -3.81957665e-02f, 2.73780346e-01f, -5.68213537e-02f, 3.75871599e-01f, -5.05707189e-02f, 3.10866505e-01f,
  -4.00424331e-01f, 8.69590417e-02f, 3.27990800e-01f, 2.68023342e-01f, 5.67864887e-02f, 6.99833110e-02f, 2.34972164e-01f, 1.72263667e-01f, 8.89626667e-02f, 1.19708531e-01f,
  -2.31130794e-01f, 3.37740444e-02f, -3.02389730e-02f, -2.78001279e-01f, 1.99649379e-01f, 1.51945874e-01f, -1.73439279e-01f, 2.41226569e-01f, 1.48674220e-01f, 4.12132926e-02f,
  4.07450855e-01f, 3.77258122e-01f, 2.12309986e-01f, 3.45847607e-01f, 3.35427910e-01f, -2.05163762e-01f, -5.93605675e-02f, 1.03788376e-01f, -1.68474197e-01f, 8.21860209e-02f,
  1.88318908e-01f, -2.90328473e-01f, 2.64232069e-01f, -3.23142372e-02f, 3.06494027e-01f, 1.63182706e-01f, 3.79909500e-02f, 1.60006374e-01f, 2.07392529e-01f, 8.56643990e-02f,
  4.94087040e-02f, 2.62600541e-01f, -2.07968399e-01f, 1.81158021e-01f, -2.62887955e-01f, -9.10282955e-02f, 2.04188332e-01f, 3.27165186e-01f, 2.21310645e-01f, 3.17835778e-01f,
  7.39529282e-02f, 1.35772582e-02f, 1.60918966e-01f, 4.19592589e-01f, 1.20584868e-01f, 7.68740252e-02f, 4.88550067e-01f, -3.10933858e-01f, -4.26856279e-02f, 5.95916659e-02f,
  -3.20773005e-01f, 1.87053293e-01f, 2.29259312e-01f, -2.20367070e-02f, 1.49686545e-01f, 2.82109231e-01f, 1.76117569e-01f, 4.55567725e-02f, 2.43695989e-01f, 1.60139620e-01f,
  2.87333965e-01f, 2.79515564e-01f, -3.10394168e-01f, 4.12796959e-02f, 8.47695395e-02f, -2.35115469e-01f, -2.01354951e-01f, -2.80632436e-01f, 2.69133866e-01f, 2.10689679e-01f,
  2.71562040e-01f, 6.57683937e-03f, 3.49325955e-01f, 2.41049856e-01f, -1.38330117e-01f, -1.04671404e-01f, 3.71376723e-01f, 2.08351031e-01f, 7.49428663e-03f, -1.64364368e-01f,
  1.39312491e-01f, -3.00824165e-01f, -7.85602853e-02f, -3.27741295e-01f, 2.52250612e-01f, -1.15737602e-01f, 4.70114976e-01f, 1.65983796e-01f, 1.24751896e-01f, 2.34027773e-01f,
  2.62189835e-01f, 3.02080750e-01f, 1.48902386e-01f, 1.61081865e-01f, 4.32709791e-02f, -5.99844614e-03f, -6.28528446e-02f, -7.73605565e-03f, -1.08291663e-01f, 1.61034673e-01f,
  1.52707204e-01f, 4.80604768e-02f, 3.07049215e-01f, -1.92147493e-01f, 2.58731041e-02f, 1.53838411e-01f, -4.41935092e-01f, -3.60293299e-01f, 4.24147844e-01f, -5.45132831e-02f,
  5.27776927e-02f, -2.50682160e-02f, -1.65152520e-01f, -2.08274409e-01f, 3.61172855e-01f, -3.65086757e-02f, 1.23265229e-01f, 1.94344863e-01f, 1.14619046e-01f, 4.42576319e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  3.22759449e-01f, 1.54521093e-01f, 1.66790143e-01f, 7.89907724e-02f, -2.64449641e-02f, 2.34895200e-01f, 4.43052769e-01f, -4.16205935e-02f, 1.39676750e-01f, 7.82332346e-02f,
  1.37509570e-01f, 2.58540213e-01f, 3.49611938e-02f, 3.75924051e-01f, 4.01595175e-01f, 1.98072344e-02f, 2.90675331e-02f, 3.33005399e-01f, 1.08399741e-01f, 1.53297544e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.82333475e-02f, -1.34795606e-01f, -1.60364091e-01f, -1.59687132e-01f, 3.44110504e-02f, 8.99601951e-02f, -3.36764395e-01f, 3.08005184e-01f, 1.96298495e-01f, 2.06789449e-02f,
  -1.51352054e-02f, 8.79765600e-02f, -8.83514658e-02f, 3.05593316e-03f, -1.35983571e-01f, 2.09750071e-01f, 6.02107719e-02f, -2.57449359e-01f, 3.54690291e-02f, -2.38352343e-01f,
  4.68958803e-02f, -3.10623556e-01f, 5.46517298e-02f, 2.60724902e-01f, 1.72062501e-01f, -3.58624533e-02f, -2.25099593e-01f, -2.02951223e-01f, -1.39691293e-01f, 7.05217868e-02f,
  -1.50624067e-01f, 3.06094974e-01f, 1.24923820e-02f, 6.33892119e-02f, -7.36794025e-02f, -1.21312693e-01f, -8.20082799e-03f, -1.38164192e-01f, 2.89343357e-01f, 3.98658253e-02f,
  -3.15102160e-01f, -3.42008084e-01f, 1.08402148e-01f, -3.70670743e-02f, -1.06405489e-01f, -5.76836150e-03f, 7.56173730e-02f, -2.25700483e-01f, 4.04671103e-01f, 2.29700774e-01f,
  -2.06710055e-01f, 6.83646500e-02f, 1.48796678e-01f, 4.73567285e-02f, -2.91860372e-01f, 3.12263489e-01f, 1.26382813e-01f, -3.50916642e-03f, 1.25148952e-01f, -3.31847340e-01f,
  1.85551539e-01f, -1.02381252e-01f, 5.58611415e-02f, -1.66870907e-01f, 8.42746422e-02f, -2.65387148e-01f, -8.13010782e-02f, -2.53299356e-01f, -3.29337150e-01f, 3.44446115e-02f,
  -2.34570637e-01f, -3.22575606e-02f, -6.79691881e-02f, -1.64310560e-01f, -6.24945499e-02f, -2.44342774e-01f, 2.36688778e-01f, 4.28211629e-01f, -3.49104464e-01f, -1.56884223e-01f,
  1.83254361e-01f, -1.16970703e-01f, -5.38915880e-02f, 1.63916111e-01f, 1.01468548e-01f, -8.46772641e-02f, -8.51275548e-02f, -5.55088036e-02f, -5.41528203e-02f, -3.10078502e-01f,
  -1.76400244e-01f, -8.58892053e-02f, 2.45664164e-01f, 2.37881601e-01f, 2.04739675e-01f, -1.64843157e-01f, -2.67288294e-02f, -2.01625869e-01f, -1.19187392e-01f, -2.50820667e-01f,
  -3.80747728e-02f, -2.51193941e-01f, -2.80914027e-02f, -6.26349729e-03f, 3.28973196e-02f, 2.64045596e-02f, -2.63740748e-01f, -8.24928358e-02f, 1.34761110e-01f, 2.03215137e-01f,
  1.97809637e-01f, -2.14473605e-02f, -7.70527869e-02f, 5.19505441e-02f, 3.58590148e-02f, 5.43891862e-02f, 1.57994851e-01f, -3.28064650e-01f, -5.53553551e-02f, 2.39832401e-01f,
  -1.08901083e-01f, -2.07101464e-01f, -2.18622461e-01f, -2.13577703e-01f, -2.84364969e-01f, 6.00432344e-02f, 4.86998633e-02f, -8.93634707e-02f, 4.38530296e-02f, -1.47402793e-01f,
  -2.00467542e-01f, -7.86549821e-02f, 1.10241994e-01f, -1.57357603e-01f, -1.39099061e-01f, -3.37198049e-01f, -4.56357151e-02f, -1.37506679e-01f, 1.16581000e-01f, 2.21163988e-01f,
  -7.98372030e-02f, 2.77413189e-01f, -9.46874544e-02f, 1.89598948e-02f, 1.76926643e-01f, -1.52866647e-01f, 1.54596508e-01f, 1.05289713e-01f, 1.57544225e-01f, -1.08436324e-01f,
  -1.30486652e-01f, 9.92250536e-03f, -2.95438826e-01f, -1.74834698e-01f, 7.96705186e-02f, -2.64783919e-01f, -2.54849106e-01f, -3.65450718e-02f, -3.15521546e-02f, 1.39221204e-02f,
  -2.34337281e-02f, 1.48760498e-01f, 1.43880427e-01f, 5.73861860e-02f, 2.56904095e-01f, -1.96779683e-01f, -4.14108038e-02f, -5.77311888e-02f, -1.72690615e-01f, -6.03054743e-03f,
  -1.49478927e-01f, -1.61973033e-02f, -1.24388285e-01f, -1.66683942e-01f, -4.53955233e-02f, -2.94525892e-01f, -5.25604077e-02f, 3.79602723e-02f, 1.65408388e-01f, -3.88673037e-01f,
  -5.48780560e-02f, -5.84387803e-04f, -8.00885037e-02f, -3.50572169e-01f, 5.46427891e-02f, 1.21234037e-01f, -6.29544184e-02f, 7.84456134e-02f, 4.21969593e-02f, 3.03800464e-01f,
  -2.60588899e-02f, 3.88934582e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -5.90083702e-03f, -9.40268934e-02f, -2.86137365e-04f, -6.37161657e-02f, -3.46756652e-02f, -6.85158074e-02f, 2.46942475e-01f, -1.00582801e-01f, -1.76873103e-01f, -4.37105089e-01f,
  -1.66377559e-01f, -3.34695131e-01f, 2.78751999e-01f, 4.48440760e-01f, -6.49655312e-02f, -2.03249276e-01f, 3.21743071e-01f, 1.62659764e-01f, 3.87968600e-01f, -4.02371824e-01f,
  1.56892046e-01f, 1.01131191e-02f, 1.77564755e-01f, -7.96434656e-02f, 4.76596616e-02f, -7.59852529e-02f, 6.10181130e-02f, -1.37471527e-01f, 2.84720421e-01f, 2.97167361e-01f,
  1.11976169e-01f, -3.19923878e-01f, -2.06821442e-01f, 2.30254591e-01f, 2.79434502e-01f, 1.82031035e-01f, 1.70390561e-01f, 2.84998924e-01f, -1.53152406e-01f, -1.23686038e-01f,
  -4.34578121e-01f, -3.78581047e-01f, -2.82599062e-01f, 8.92802253e-02f, -3.73310953e-01f, 1.89824924e-01f, 6.39911443e-02f, 6.80386275e-02f, 1.90718293e-01f, 3.67457390e-01f,
  2.74556249e-01f, -4.68548760e-03f, 1.83978304e-01f, 1.57306448e-01f, -2.10548133e-01f, -1.45979688e-01f, -2.74554133e-01f, -1.24563232e-01f, 3.82897079e-01f, -3.39120239e-01f,
  -5.43461516e-02f, -4.17086557e-02f, 2.39484847e-01f, 2.92770654e-01f, 3.21452439e-01f, 1.19689614e-01f, 1.31201297e-01f, 3.24660242e-01f, 3.20722103e-01f, 3.36422414e-01f,
  1.40675560e-01f, 1.32205427e-01f, -1.95390657e-02f, 2.46341422e-01f, 3.69492769e-01f, 4.62177098e-01f, 1.48377508e-01f, 4.33245659e-01f, 3.74238789e-01f, 4.88633722e-01f,
  2.25273557e-02f, 2.10769340e-01f, 9.09389108e-02f, 2.26084292e-01f, 4.45314735e-01f, -8.40457454e-02f, 1.20977283e-01f, 2.13915721e-01f, -2.10173354e-01f, 2.32983515e-01f,
  5.76783121e-01f, 6.50869235e-02f, -6.45492598e-02f, -1.23241514e-01f, 4.29033905e-01f, 5.12525380e-01f, -3.51735130e-02f, 1.96668833e-01f, 2.17033386e-01f, 1.53776526e-01f,
  2.25006551e-01f, 6.39498010e-02f, 2.62817323e-01f, 6.59659877e-02f, -3.20977345e-02f, 7.16226026e-02f, 1.75217181e-01f, 4.51484740e-01f, 9.09438729e-02f, -6.26338869e-02f,
  4.52081680e-01f, -1.50452942e-01f, 3.19025517e-02f, -1.78597048e-01f, 5.51120453e-02f, -1.32852141e-02f, -1.08607216e-02f, 2.32546434e-01f, 3.67091656e-01f, -1.05678715e-01f,
  3.89622927e-01f, 3.14456880e-01f, -1.47517979e-01f, 4.65527773e-01f, 1.26747966e-01f, -7.62005225e-02f, -7.08434954e-02f, -7.16047138e-02f, 1.14824548e-01f, 1.98224679e-01f,
  2.93394834e-01f, 1.38339341e-01f, 2.38743469e-01f, 1.56954765e-01f, 6.51242211e-02f, 2.15632543e-02f, 8.46619383e-02f, 3.24365437e-01f, 2.40660250e-01f, 1.85292587e-01f,
  8.82900730e-02f, 1.13034006e-02f, 2.77837127e-01f, 6.88424781e-02f, -3.46282393e-01f, -3.12119186e-01f, 1.79705217e-01f, -1.42449662e-01f, 1.43914759e-01f, -9.56520811e-02f,
  -5.61879016e-02f, 5.71399964e-02f, 9.53376386e-03f, 4.17733639e-01f, 1.34989321e-01f, 1.32090539e-01f, -1.43033132e-01f, -2.29991615e-01f, -3.29354197e-01f, 2.90549219e-01f,
  -4.62645702e-02f, 1.30014017e-01f, 1.10411771e-01f, 1.40459770e-02f, -1.45477280e-01f, -3.54622900e-02f, 5.36116004e-01f, -2.04042166e-01f, -4.41068877e-03f, -2.32607916e-01f,
  -2.68261075e-01f, -3.37776661e-01f, 1.37952834e-01f, -3.16064768e-02f, 1.34816900e-01f, -4.26297098e-01f, 3.45433727e-02f, 2.11993724e-01f, 2.12959141e-01f, -3.49963307e-01f,
  -2.37669259e-01f, 1.86960265e-01f, 9.36170369e-02f, -1.52362987e-01f, -1.74238130e-01f, -2.08155543e-01f, -4.98604514e-02f, 4.59092595e-02f, 3.19807231e-01f, 4.20378953e-01f,
  3.46461893e-03f, -5.44159949e-01f, -3.60266834e-01f, -3.89918797e-02f, 2.01937780e-02f, 6.33621365e-02f, -2.75798827e-01f, -2.92652342e-02f, 2.27426827e-01f, 1.73996743e-02f,
  -1.77233309e-01f, -6.24128938e-01f, -3.21255207e-01f, -2.94710964e-01f, -1.78864285e-01f, 6.74862340e-02f, -3.45814112e-03f, -3.47398341e-01f, -1.17807679e-01f, 1.99404106e-01f,
  2.77649939e-01f, -5.26398540e-01f, -5.53184338e-02f, 3.79209220e-01f, 1.46323383e-01f, -2.59676129e-01f, 2.06591234e-01f, -1.54655308e-01f, 1.82206005e-01f, 3.16585094e-01f,
  1.56072766e-01f, 3.56205910e-01f, 9.36779231e-02f, -3.01721424e-01f, 1.02536500e-01f, 2.12737143e-01f, 1.54527962e-01f, 1.10533357e-01f, -8.15729573e-02f, 1.44101992e-01f,
  4.32380795e-01f, 4.82502073e-01f, 1.16625562e-01f, 1.11943029e-01f, 1.73322260e-01f, -2.67994553e-01f, 6.87337339e-01f, -2.81786621e-01f, 5.67663372e-01f, 5.68773627e-01f,
  -6.81669414e-02f, -4.20799740e-02f, -1.67251658e-02f, 2.67067045e-01f, 4.07661140e-01f, 1.34010941e-01f, 4.89121616e-01f, 3.36501658e-01f, -4.43996429e-01f, 8.30358639e-02f,
  -1.74419194e-01f, 1.85085475e-01f, 3.41896027e-01f, 2.73632795e-01f, 3.46720159e-01f, 4.23673391e-02f, 1.10210115e-02f, 2.68261041e-02f, 7.52055198e-02f, 4.25570225e-03f,
  -1.88739747e-01f, 8.26756880e-02f, -1.49518296e-01f, 4.30581093e-01f, 2.94137299e-01f, 2.51612097e-01f, -5.22390366e-01f, -3.67315948e-01f, 2.42917001e-01f, 2.96992455e-02f,
  1.95051536e-01f, 3.89506608e-01f, -1.84967577e-01f, -4.90976349e-02f, 1.65279910e-01f, -3.12117636e-01f, 2.80520648e-01f, -8.73181969e-02f, 4.24599320e-01f, 3.13981205e-01f,
  2.26534471e-01f, -1.00531660e-01f, -3.37445021e-01f, 3.08242384e-02f, 3.52916002e-01f, 4.65766788e-01f, 2.46997833e-01f, -6.80425316e-02f, -2.75164455e-01f, -1.75438419e-01f,
  -1.94849715e-01f, -1.87701702e-01f, 2.25876391e-01f, 4.91379388e-02f, -3.62042874e-01f, 1.59656275e-02f, 1.14443228e-01f, -6.78766146e-02f, -1.74071193e-01f, 9.10950825e-02f,
  -2.21104011e-01f, 1.05473168e-01f, -1.61833659e-01f, -9.93764326e-02f, 4.91238236e-02f, -8.50493759e-02f, -7.84351840e-04f, -3.16434056e-02f, 7.31928088e-03f, -2.44666234e-01f,
  9.71248001e-02f, -5.55755757e-02f, -1.33692011e-01f, -2.21775115e-01f, 1.72308072e-01f, -2.44578585e-01f, -2.28012111e-02f, 4.26090471e-02f, -6.04726486e-02f, 2.51809865e-01f,
  2.72296667e-01f, 3.51409882e-01f, 1.64787009e-01f, 1.97633341e-01f, 5.21024466e-02f, 1.62838489e-01f, 1.00209586e-01f, -8.81807134e-02f, 3.52055430e-01f, 5.57119548e-01f,
  3.81783932e-01f, 3.12331706e-01f, 2.74185210e-01f, -1.35893021e-02f, 4.69351500e-01f, 2.89538532e-01f, 6.08008802e-02f, -1.37069702e-01f, -3.52245616e-03f, 2.06784397e-01f,
  3.23464990e-01f, -3.00140716e-02f, 1.86724633e-01f, 2.35935017e-01f, -1.96971036e-02f, 2.76286304e-01f, -4.12279367e-02f, 1.94074124e-01f, -1.78790912e-02f, 1.44679964e-01f,
  3.67793553e-02f, 2.47463822e-01f, 4.00271386e-01f, 3.08869570e-01f, 6.06234791e-03f, 7.48408139e-02f, 3.59187663e-01f, 3.37006599e-01f, -3.54216784e-01f, -1.94485456e-01f,
  1.15021966e-01f, 5.22061288e-01f, 2.86761343e-01f, 5.89951873e-01f, 1.15429513e-01f, 3.35080355e-01f, 1.34037554e-01f, 2.03502513e-02f, 6.60073310e-02f, -2.44938821e-01f,
  1.55635551e-01f, 4.28392105e-02f, 1.55264094e-01f, -5.14443159e-01f, 1.99601799e-02f, 1.83892429e-01f, -4.63681221e-02f, 4.16571051e-01f, 1.49047464e-01f, -4.65649404e-02f,
  -1.22560263e-01f, 1.29198760e-01f, 8.91293511e-02f, 3.03107828e-01f, 9.44394767e-02f, 3.71173561e-01f, 1.09471753e-01f, -1.11988179e-01f, 2.51701713e-01f, 3.64092529e-01f,
  -5.84713101e-01f, -1.50662780e-01f, -1.52992913e-02f, 3.40839744e-01f, 4.15428638e-01f, 6.52582169e-01f, -2.40178436e-01f, 3.99504930e-01f, -4.58952971e-03f, -4.82833982e-02f,
  6.01523593e-02f, -7.75722861e-02f, 3.83256018e-01f, 1.54583499e-01f, 1.89578682e-01f, -4.51364636e-01f, -3.27326395e-02f, 1.60575524e-01f, 2.81543851e-01f, 4.84011739e-01f,
  3.50182235e-01f, 8.31215382e-02f, -2.03964293e-01f, 5.19726165e-02f, 1.15312502e-01f, 1.61354780e-01f, -2.45167077e-01f, 2.44587362e-01f, 1.36330113e-01f, 3.01815391e-01f,
  1.43151432e-01f, -1.01274900e-01f, 4.37186360e-01f, 3.97353619e-02f, -4.32700217e-01f, -2.27181613e-01f, -2.28254363e-01f, -2.05840975e-01f, 1.37557015e-02f, 7.27606267e-02f,
  -1.20774202e-01f, -2.11650684e-01f, 3.07268947e-01f, 5.22494972e-01f, 2.94921249e-01f, -2.29626387e-01f, 1.47159308e-01f, 2.08338767e-01f, -2.29556888e-01f, -2.16040358e-01f,
  -3.66796523e-01f, 1.27634965e-03f, 3.70817125e-01f, -2.09378585e-01f, 5.50307781e-02f, 2.49120414e-01f, 2.42362052e-01f, 1.38455361e-01f, 9.18805152e-02f, 2.45110109e-01f,
  6.90991580e-02f, 1.33661956e-01f, 1.17057256e-01f, -1.61777765e-01f, 6.40709400e-01f, -1.33317634e-01f, 1.89112246e-01f, -6.00236177e-01f, -2.43108913e-01f, -9.47809666e-02f,
  2.47384652e-01f, -9.68995318e-02f, 3.86914372e-01f, -3.18334669e-01f, 2.88798332e-01f, -7.41677079e-03f, 2.55799919e-01f, -3.16268146e-01f, -8.53326693e-02f, 4.70451206e-01f,
  1.98116645e-01f, 1.91863090e-01f, 4.15638499e-02f, 2.28105649e-01f, 4.62524481e-02f, 4.28864479e-01f, 3.43970060e-01f, 1.88497789e-02f, -2.14095667e-01f, -6.58884585e-01f,
  2.25865722e-01f, 3.86028200e-01f, 1.55983567e-01f, 9.39852670e-02f, 2.38296673e-01f, 1.72999099e-01f, 4.01207339e-03f, -3.90540957e-01f, 2.98250377e-01f, 4.00354475e-01f,
  4.68277901e-01f, 5.16147494e-01f, -1.65060267e-01f, -1.16477638e-01f, 4.53471065e-01f, 1.20682991e-03f, -3.11415344e-01f, -2.50463009e-01f, 4.53761637e-01f, -4.45467561e-01f,
  -6.53515905e-02f, -5.06433323e-02f, 7.08221421e-02f, -9.63919610e-02f, 1.87932402e-01f, 5.34085393e-01f, 1.89305782e-01f, 4.72971112e-01f, -1.15548238e-01f, 1.79200843e-01f,
  -1.08577505e-01f, 1.71975061e-01f, -5.19562066e-02f, -2.98243582e-01f, 3.15625891e-02f, -6.90875947e-02f, -3.28624278e-01f, 1.71103165e-01f, -9.46182460e-02f, 5.43177307e-01f,
  1.35442808e-01f, 1.07151046e-01f, -5.40948212e-01f, -1.35326326e-01f, 1.38025194e-01f, 6.91104382e-02f, 1.00266889e-01f, 2.87132025e-01f, -4.92310002e-02f, -1.51431173e-01f,
  3.58073831e-01f, -2.66121268e-01f, 1.80736259e-01f, -2.21949980e-01f, 4.47586685e-01f, 1.82255313e-01f, 1.99468911e-01f, -2.38485485e-01f, -4.33165073e-01f, 2.31758982e-01f,
  2.80715674e-01f, 4.03561711e-01f, -6.28677756e-02f, -1.31957978e-01f, 2.22898006e-01f, 3.14838171e-01f, 3.67746979e-01f, 3.56730819e-01f, 3.42201471e-01f, 9.27647389e-03f,
  4.13710654e-01f, -1.22567266e-01f, 1.35774881e-01f, -1.82256028e-01f, 4.02398676e-01f, 5.21101236e-01f, 8.51470008e-02f, -2.33818024e-01f, 4.78633165e-01f, -6.00390173e-02f,
  1.98002104e-02f, 3.14985327e-02f, -1.21357277e-01f, 1.48664623e-01f, 2.07642347e-01f, 4.03903544e-01f, 2.24597260e-01f, 1.85333744e-01f, 3.09266120e-01f, 1.99153736e-01f,
  1.60325512e-01f, 4.96592313e-01f, -1.84565842e-01f, -3.18789899e-01f, -3.41261238e-01f, -1.66394681e-01f, -5.54785728e-02f, 1.01190038e-01f, 1.24630488e-01f, 7.59314746e-02f,
  9.61292088e-02f, -2.72838604e-02f, 6.18938580e-02f, 2.71997243e-01f, -1.89145193e-01f, -4.97141071e-02f, -7.71035478e-02f, -2.89330721e-01f, 3.57329965e-01f, -3.52226384e-02f,
  1.46884456e-01f, 3.94157141e-01f, 1.73710629e-01f, 4.59554553e-01f, -1.63054448e-02f, -8.46234784e-02f, 4.60469455e-01f, 1.45495340e-01f, -2.47547507e-01f, 1.68443739e-01f,
  -4.73844618e-01f, 6.29670620e-02f, 4.67140198e-01f, -4.38981354e-01f, 2.71495789e-01f, 2.10418105e-01f, 5.33970952e-01f, 1.17241979e-01f, -1.20530752e-02f, 1.15336388e-01f,
  1.58533588e-01f, 2.36810669e-01f, -1.34828761e-01f, 1.43177852e-01f, 3.66152555e-01f, 4.14696693e-01f, 9.61821806e-03f, -2.24114478e-01f, -2.54463315e-01f, -2.73631990e-01f,
  2.54739761e-01f, 1.06571980e-01f, 1.50278315e-01f, -6.11246862e-02f, 5.65480366e-02f, 2.85076708e-01f, 7.05658784e-03f, -1.52098492e-01f, 2.54179120e-01f, 5.73628485e-01f,
  2.50177443e-01f, -3.28516332e-03f, -9.65188816e-02f, -7.11979195e-02f, 3.13285977e-01f, 6.09232895e-02f, 2.84449011e-01f, 4.18495297e-01f, 2.15494096e-01f, 1.16828661e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  7.09104585e-03f, 3.11269350e-02f, 1.64190590e-01f, -6.90643415e-02f, 6.76080212e-02f, 3.05042304e-02f, -9.80300978e-02f, 1.38363332e-01f, 2.19430938e-01f, -1.49496999e-02f,
  2.52941936e-01f, 2.26807714e-01f, 2.04330720e-02f, 1.83424160e-01f, -2.54034512e-02f, 3.00606877e-01f, 7.75178336e-03f, 1.75144047e-01f, 2.69237161e-01f, 6.22021072e-02f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  1.79244727e-01f, 1.33222137e-02f, -2.84454197e-01f, 1.39016286e-01f, 1.02496510e-02f, 5.92671745e-02f, 1.04758032e-01f, 1.26855269e-01f, 2.24940881e-01f, -1.31136198e-02f,
  -6.75462708e-02f, -1.00968279e-01f, -1.38031080e-01f, 2.06987172e-01f, 1.31678581e-01f, 1.30221963e-01f, -4.70983535e-02f, -1.15427464e-01f, 3.16790044e-02f, -1.40302271e-01f,
  1.65652912e-02f, -1.22148067e-01f, 1.33837700e-01f, -3.36988382e-02f, -4.13730778e-02f, -1.45541579e-01f, -3.08566168e-02f, -7.06287846e-02f, 2.90843487e-01f, 1.62885234e-01f,
  -1.99359775e-01f, -1.30861029e-01f, 7.59804323e-02f, -4.04872298e-02f, -2.12526619e-01f, -2.29649972e-02f, 5.61673678e-02f, 2.35418767e-01f, -2.38241944e-02f, -9.39770192e-02f,
  -1.21289298e-01f, 8.15885961e-02f, -1.32533938e-01f, 1.77131705e-02f, -9.16848630e-02f, -1.52385265e-01f, -1.08201513e-02f, -1.16807885e-01f, 6.32312298e-02f, -1.07055314e-01f,
  -1.50466114e-01f, -2.65995748e-02f, -4.65107448e-02f, -4.52642627e-02f, 2.68977821e-01f, 2.82228768e-01f, 7.49234983e-04f, -5.79618737e-02f, -2.77974997e-02f, 8.52956101e-02f,
  1.35434009e-02f, 2.03665271e-01f, -4.82034832e-02f, 1.64592595e-04f, 5.32498248e-02f, 6.44856170e-02f, 1.53855039e-02f, 3.94103564e-02f, 1.37862647e-02f, -9.84094962e-02f,
  5.42522669e-02f, -2.48482764e-01f, -5.38989231e-02f, 2.28218868e-01f, 1.67052839e-02f, -1.36432312e-02f, -1.21593438e-01f, -1.44353136e-01f, 2.35438421e-02f, 1.57049716e-01f,
  7.08744396e-03f, -2.73517109e-02f, 1.87132925e-01f, -9.99074802e-02f, -1.78204983e-01f, -3.56860459e-02f, 2.06626415e-01f, -7.92161003e-02f, -5.66695072e-02f, 1.21112838e-01f,
  -1.15618343e-02f, 2.07326829e-01f, 2.01502755e-01f, 8.99640694e-02f, -2.15682968e-01f, -1.08607337e-01f, -6.31994605e-02f, 7.01165125e-02f, 4.57892507e-01f, -9.44886878e-02f,
  1.01053536e-01f, -1.24647677e-01f, 1.91318430e-02f, 3.54198702e-02f, -5.20400666e-02f, -2.75674134e-01f, 8.16948116e-02f, 3.60854745e-01f, -2.71529108e-02f, 1.71000972e-01f,
  -3.33456323e-02f, -1.67992741e-01f, 1.06922947e-01f, 9.36490893e-02f, 9.65574160e-02f, 5.27215414e-02f, 1.43670070e-03f, -6.43844083e-02f, 3.10599413e-02f, -1.11688830e-01f,
  -1.19963840e-01f, 2.62130708e-01f, -4.43220176e-02f, 1.26259834e-01f, 2.17041597e-02f, -1.28597304e-01f, -1.03146307e-01f, -7.70961447e-03f, 1.14248283e-01f, -8.50580633e-02f,
  -1.03034213e-01f, 1.06280647e-01f, -1.22312665e-01f, 1.51624694e-01f, -4.33574051e-01f, 2.56871581e-01f, 1.84944883e-01f, 9.95116085e-02f, -2.62198925e-01f, 3.12220305e-02f,
  2.16851085e-01f, -7.68993795e-02f, -1.35089755e-01f, -5.24734743e-02f, -9.79272574e-02f, 2.47425944e-01f, -1.27222925e-01f, 8.21030065e-02f, -1.54340535e-01f, -1.03902638e-01f,
  8.14478546e-02f, -1.05211049e-01f, -3.70268784e-02f, -7.68921897e-03f, 1.18821319e-02f, -5.15514053e-02f, -2.04270840e-01f, -1.92095533e-01f, 1.64707497e-01f, 3.26057263e-02f,
  7.55321980e-02f, 1.96338102e-01f, -1.17647024e-02f, -1.66144595e-01f, -2.77328283e-01f, -1.52150169e-01f, 1.33051053e-01f, -5.01543693e-02f, -2.02921510e-01f, -1.50759965e-01f,
  -1.86309323e-01f, 1.48225259e-02f, -2.78532207e-01f, 4.32745107e-02f, -1.00431457e-01f, 1.82838380e-01f, 5.87859228e-02f, -8.06430541e-03f, 1.73136473e-01f, 2.09689047e-02f,
  -2.48074774e-02f, 1.52356461e-01f, -1.69913024e-01f, 1.05937742e-01f, 1.92400813e-02f, 1.09982900e-01f, 7.74477124e-02f, 1.69956475e-01f, -3.15571390e-02f, 2.28989031e-02f,
  -1.76013008e-01f, 7.40237087e-02f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.81372255e-01f, -9.74264815e-02f, 1.84731722e-01f, 1.81267574e-01f, 2.46806024e-03f, 9.47075635e-02f, -5.39616048e-02f, -2.32373863e-01f, -3.75348777e-02f, -1.32519081e-01f,
  1.92824960e-01f, 6.31023288e-01f, 2.21068263e-01f, 2.50769317e-01f, 1.98154643e-01f, -2.01707244e-01f, 1.26224056e-01f, 2.30872378e-01f, 2.42815971e-01f, -3.28450590e-01f,
  -5.42968996e-02f, -7.28679150e-02f, 1.16209596e-01f, 2.47268200e-01f, 6.14298165e-01f, 2.56305248e-01f, -5.14806844e-02f, 5.27834713e-01f, -1.27952829e-01f, -1.09307356e-01f,
  1.16118759e-01f, -1.02186076e-01f, 1.92726582e-01f, -1.71462700e-01f, -3.95039022e-02f, 1.69373900e-01f, -9.62178409e-02f, -1.98746309e-01f, 4.57457155e-02f, -2.25399256e-01f,
  5.57640046e-02f, 2.59524971e-01f, -3.81427109e-01f, -5.28928041e-01f, -1.60759166e-01f, -3.02128911e-01f, 3.02170753e-01f, 3.94843519e-01f, -1.42654166e-01f, 4.39040884e-02f,
  1.37759335e-02f, 1.93339631e-01f, 4.43600357e-01f, -1.52019933e-01f, 3.38793397e-01f, -1.02490820e-02f, -4.38956559e-01f, -1.86417952e-01f, 9.87595916e-02f, 3.67400423e-02f,
  2.88126737e-01f, 2.00633869e-01f, 1.49066439e-02f, 2.10378796e-01f, 1.77131698e-01f, -2.91393012e-01f, 1.19584128e-01f, 1.77448809e-01f, 1.46068662e-01f, 2.03635991e-01f,
  2.45134786e-01f, -4.01538759e-01f, 8.72927383e-02f, 2.17958793e-01f, -1.08138762e-01f, 1.66334376e-01f, 1.84502840e-01f, -2.87530363e-01f, -1.61885649e-01f, -1.45103157e-01f,
  -6.45649433e-02f, 2.76288718e-01f, 2.44733058e-02f, 2.74761051e-01f, 4.04266447e-01f, -2.81470478e-01f, 1.06470443e-01f, 2.60558128e-01f, -9.41319838e-02f, -1.40424609e-01f,
  -7.48886243e-02f, -1.36117354e-01f, 5.10357678e-01f, -5.52578807e-01f, 8.33486859e-03f, 1.29605100e-01f, 3.11146080e-01f, 1.17856398e-01f, 4.73263681e-01f, 4.79230769e-02f,
  -2.55506616e-02f, 1.35462865e-01f, 1.55449465e-01f, 2.60175884e-01f, -1.28836721e-01f, 1.09179601e-01f, 4.38774675e-01f, 4.72535104e-01f, 8.91686976e-02f, 5.73256671e-01f,
  4.22315478e-01f, -4.33829814e-01f, -7.40961209e-02f, -2.81340126e-02f, 2.22796351e-01f, -1.35638779e-02f, 1.57806396e-01f, -2.25517288e-01f, 4.39010235e-03f, 1.43727601e-01f,
  1.89771861e-01f, 3.69477719e-01f, -4.49102670e-01f, 1.78059667e-01f, -2.08331212e-01f, -4.43652779e-01f, 3.69230926e-01f, 2.61348218e-01f, 8.68973508e-02f, -3.26173991e-01f,
  -4.27274629e-02f, 1.31717205e-01f, 7.81974941e-02f, 6.83491826e-02f, 2.22295284e-01f, 5.64161912e-02f, -3.67367864e-02f, 6.34760618e-01f, -4.21846546e-02f, -4.91556376e-01f,
  1.91847861e-01f, -1.64146513e-01f, 8.71668309e-02f, 3.66205201e-02f, 1.28848270e-01f, -3.37650716e-01f, -1.80943340e-01f, 2.78180778e-01f, 2.45585203e-01f, -1.41358554e-01f,
  2.37571627e-01f, 2.24570855e-01f, -1.78957134e-01f, -4.26489115e-01f, -9.44875330e-02f, -8.19969922e-02f, 3.11662018e-01f, 4.89146337e-02f, 2.48044059e-01f, -1.12975523e-01f,
  9.88101661e-02f, -1.03273792e-02f, 1.25830993e-01f, 2.91430861e-01f, -4.36496064e-02f, -6.27914369e-02f, 2.94373538e-02f, -4.65738177e-02f, -4.48788144e-02f, 9.40898061e-02f,
  -2.65115768e-01f, -3.08260262e-01f, -4.53308746e-02f, 3.45749468e-01f, 5.09214520e-01f, -2.54347593e-01f, 1.42731026e-01f, -4.95448828e-01f, -5.55320859e-01f, 1.32814512e-01f,
  2.41484031e-01f, -2.20225826e-01f, 2.96303481e-01f, 1.15050368e-01f, 7.86376670e-02f, -6.15221933e-02f, -5.91172315e-02f, -1.53250203e-01f, 1.36428192e-01f, -1.85301065e-01f,
  1.65794700e-01f, 2.77157605e-01f, -2.00267956e-01f, -9.49245095e-02f, 4.59807999e-02f, 1.85582250e-01f, 3.23336869e-01f, 1.64495349e-01f, -1.02163672e-01f, 1.08808927e-01f,
  1.49352655e-01f, -2.37432063e-01f, -4.88560259e-01f, -4.32246268e-01f, -2.25842111e-02f, -2.27929294e-01f, 1.61468089e-01f, -3.04307118e-02f, -2.03497887e-01f, -2.50081837e-01f,
  -9.62118804e-03f, 4.88609612e-01f, 3.49291652e-01f, -1.50512801e-02f, 3.61945599e-01f, -3.63150239e-02f, -3.10007006e-01f, -1.30396366e-01f, -1.60033405e-01f, -1.73286423e-01f,
  1.31017640e-01f, -1.30484402e-01f, 3.02289933e-01f, 2.13234335e-01f, 2.41064116e-01f, 2.17062742e-01f, 2.58610938e-02f, 1.76766649e-01f, 2.53473282e-01f, 2.71538228e-01f,
  2.65401483e-01f, -2.15163946e-01f, 2.02614497e-02f, 1.07862249e-01f, 2.82116830e-01f, -8.55599493e-02f, 1.02145106e-01f, 1.41069651e-01f, 4.19287175e-01f, 4.48218659e-02f,
  1.24081172e-01f, -4.69311595e-01f, -4.57287610e-01f, 1.51293695e-01f, 8.40940773e-02f, -2.06695378e-01f, 2.00119704e-01f, 5.04644215e-01f, 6.41748011e-01f, -6.50022775e-02f,
  -3.97278190e-01f, 3.30243945e-01f, 1.26318550e-02f, -1.67471975e-01f, -9.51947719e-02f, -9.08769518e-02f, 3.17212522e-01f, 2.63647467e-01f, -9.12720114e-02f, 2.89851665e-01f,
  -4.66443002e-02f, -1.48085691e-02f, -3.61303031e-01f, -1.78811759e-01f, -1.42781705e-01f, -4.52923030e-01f, -6.39656708e-02f, -1.14705628e-02f, -1.62373558e-01f, 3.40468347e-01f,
  2.85440236e-01f, 1.09454021e-01f, 1.72870636e-01f, -3.82793427e-01f, -5.11525095e-01f, -9.12687257e-02f, -1.66600302e-01f, -5.53777330e-02f, 2.88863957e-01f, 3.28069597e-01f,
  4.58071411e-01f, 1.18827313e-01f, -1.16122581e-01f, 4.30417150e-01f, -3.59949201e-01f, 1.16102539e-01f, 2.74108261e-01f, -8.14877674e-02f, 3.49293083e-01f, -1.36844620e-01f,
  1.43719837e-01f, 2.59473383e-01f, 1.31036252e-01f, 6.55590147e-02f, 2.59933203e-01f, -3.05976570e-01f, -2.73211122e-01f, 2.06892818e-01f, -8.06082264e-02f, -1.66661814e-01f,
  -2.90295593e-02f, -1.47830009e-01f, 3.95269394e-01f, 9.28452313e-02f, 5.28404176e-01f, -3.10208529e-01f, -4.34249371e-01f, 1.49010241e-01f, 3.22313905e-02f, -2.98514873e-01f,
  3.23985010e-01f, 4.73790318e-01f, 6.83435142e-01f, -3.04929495e-01f, -2.11074650e-01f, 5.66041052e-01f, -5.23337536e-02f, 1.63475230e-01f, 1.05397692e-02f, -1.84652060e-01f,
  2.02183530e-01f, 1.31870415e-02f, -1.30404979e-01f, 3.53402942e-01f, -9.26756486e-02f, -2.91384220e-01f, 2.81700231e-02f, -2.81157643e-01f, -2.58235425e-01f, -1.06556512e-01f,
  -4.99957889e-01f, -3.37401479e-01f, -1.86143771e-01f, 1.10303983e-02f, 1.07972212e-01f, -1.57043129e-01f, 2.32872516e-01f, -1.82749465e-01f, -3.54563475e-01f, 3.93030941e-01f,
  2.92628229e-01f, -2.58917630e-01f, 1.06753439e-01f, -9.96538773e-02f, -3.57361317e-01f, 1.62074268e-01f, -2.22819969e-01f, -1.69725493e-01f, 5.49786873e-02f, 1.06619097e-01f,
  3.16368550e-01f, 2.46652618e-01f, 2.30010495e-01f, -1.65062428e-01f, -2.62005538e-01f, 4.89269197e-02f, 1.48058906e-01f, 1.32382765e-01f, -1.35206550e-01f, -3.35033357e-01f,
  -4.44634080e-01f, 7.06803724e-02f, -1.66966751e-01f, 1.94450095e-01f, -2.32646778e-01f, -4.77843881e-02f, 2.64582425e-01f, 2.02633411e-01f, 4.98476177e-01f, -3.22868735e-01f,
  -3.15430433e-01f, 9.59277079e-02f, -1.16866879e-01f, -3.69310789e-02f, 4.34097916e-01f, 3.32188725e-01f, 2.96783715e-01f, -1.69743910e-01f, 2.89476305e-01f, 5.28399765e-01f,
  -2.59922892e-01f, 5.40814996e-01f, -3.44901353e-01f, -2.20914572e-01f, -9.02899355e-02f, 1.97071582e-01f, 1.00952916e-01f, 1.15821891e-01f, 8.34879130e-02f, -7.32753379e-03f,
  -5.09505212e-01f, 5.47081649e-01f, 1.41637981e-01f, -1.88100040e-01f, -1.81577936e-01f, 1.95636570e-01f, 4.70879614e-01f, 3.36039782e-01f, 1.11056693e-01f, 4.46344092e-02f,
  -3.04339290e-01f, 4.12142813e-01f, 4.68484312e-01f, 9.11272690e-03f, -2.56536566e-02f, 3.30862433e-01f, -1.45574316e-01f, -9.74875018e-02f, -2.18718886e-01f, 6.15139961e-01f,
  3.29546005e-01f, -4.61686283e-01f, -1.91491470e-01f, 1.51041463e-01f, 4.23377573e-01f, 4.02899683e-01f, -1.08421324e-02f, -4.35020924e-01f, -1.04801118e-01f, -1.67556062e-01f,
  8.01366642e-02f, 1.26349017e-01f, 2.98025042e-01f, -3.79549176e-01f, 2.57086847e-02f, -3.82998176e-02f, -3.82297002e-02f, 2.38302976e-01f, 1.85411811e-01f, -4.80085433e-01f,
  4.66915853e-02f, 9.63180140e-02f, 2.11125240e-02f, 4.85812910e-02f, 4.52295691e-01f, -3.52015793e-02f, 4.24857914e-01f, -3.91022831e-01f, 1.59704074e-01f, 2.15697899e-01f,
  7.99393728e-02f, -4.59271580e-01f, -7.99791142e-02f, 2.60314316e-01f, 4.63702738e-01f, -1.07089758e-01f, -7.26148635e-02f, 9.26174819e-02f, 1.42379627e-01f, -1.12785690e-01f,
  -2.36148879e-01f, 1.43106103e-01f, -1.39190540e-01f, 2.42888987e-01f, -3.29001428e-04f, -3.50970179e-01f, 1.06813774e-01f, 6.28859699e-02f, 8.67034197e-02f, 1.18602790e-01f,
  1.99067429e-01f, -3.05978119e-01f, -1.60307795e-01f, 3.93940389e-01f, 1.44536242e-01f, 2.35538125e-01f, 1.84048966e-01f, 2.65049100e-01f, 4.00408745e-01f, -9.94831398e-02f,
  1.07419722e-01f, -1.07541643e-01f, 1.01428637e-02f, -2.71466821e-01f, 4.52999920e-01f, 2.74692655e-01f, 5.46231747e-01f, 6.03868105e-02f, -2.23177552e-01f, 3.56778622e-01f,
  2.45855004e-02f, 2.12713182e-01f, -5.40311746e-02f, 2.17435062e-01f, 7.59763941e-02f, 1.68598990e-03f, -1.55286074e-01f, 3.08780760e-01f, -2.64950424e-01f, 3.54471318e-02f,
  -3.88304174e-01f, -2.21226484e-01f, -1.16505519e-01f, 6.34462312e-02f, 3.70015204e-01f, -2.67884016e-01f, 1.23706311e-01f, -2.42878526e-01f, -2.09714890e-01f, 2.92905331e-01f,
  -8.81341845e-02f, 1.96150243e-01f, 2.93244459e-02f, 1.56847760e-01f, 8.12689364e-02f, 1.40974402e-01f, 2.87273228e-02f, -1.77377149e-01f, 5.83251044e-02f, 1.58520918e-02f,
  3.65769178e-01f, 1.42253280e-01f, -4.87351231e-02f, -1.41910285e-01f, 1.54566839e-01f, -6.46826997e-02f, 3.47190559e-01f, -6.20230101e-02f, -4.80813712e-01f, 5.00996336e-02f,
  -3.45095694e-01f, -3.53265405e-01f, -1.50978759e-01f, -8.41719955e-02f, -1.70748636e-01f, -2.25944012e-01f, 4.08532560e-01f, 3.29598010e-01f, 3.83012652e-01f, -2.44498610e-01f,
  -3.95641506e-01f, 2.28103146e-01f, -2.07916006e-01f, -3.80970508e-01f, 4.37139869e-01f, 2.07000732e-01f, 4.71658334e-02f, -2.71541849e-02f, 1.09484501e-01f, 4.01817679e-01f,
  -3.61307770e-01f, 2.65833408e-01f, 1.18464204e-02f, 1.27934232e-01f, -1.29191980e-01f, 1.91298611e-02f, 3.95741999e-01f, 2.23251134e-01f, 1.02704525e-01f, 1.16925642e-01f,
  -3.02876025e-01f, 8.97604972e-02f, 2.50405788e-01f, 3.91355045e-02f, 3.72367382e-01f, 5.27702212e-01f, 2.73826927e-01f, 2.47747242e-01f, 1.40118793e-01f, -1.73466057e-01f,
  -1.66738808e-01f, 6.63716853e-01f, 4.71162826e-01f, 1.93428457e-01f, 1.07394263e-01f, -2.35835597e-01f, -2.43852399e-02f, 2.11828515e-01f, -1.05603792e-01f, 7.07009137e-01f,
  1.47479579e-01f, -1.35408834e-01f, 3.20947766e-02f, -1.93101406e-01f, 3.87701184e-01f, 4.29348826e-01f, -4.02614139e-02f, 2.13884667e-01f, 1.70852602e-01f, -1.05067894e-01f,
  -1.32588014e-01f, 4.64485325e-02f, -5.93554795e-01f, 3.00879240e-01f, -1.79595530e-01f, -4.57718223e-01f, -1.46581888e-01f, -1.38648152e-01f, 1.58779964e-01f, -4.03005421e-01f,
  1.98250055e-01f, 4.04988974e-01f, -2.38444153e-02f, 3.96220416e-01f, 3.01854461e-01f, 3.82265955e-01f, 1.10100783e-01f, -2.89708842e-03f, 1.55892432e-01f, -1.28708959e-01f,
  -1.87967569e-01f, -1.14723057e-01f, 7.25591481e-01f, 3.64588916e-01f, 2.33627595e-02f, 7.20134079e-01f, -2.42468581e-01f, 3.65060747e-01f, 4.54822145e-02f, -1.89679205e-01f,
  4.19798344e-02f, 3.23714375e-01f, -1.08689278e-01f, 1.90256551e-01f, -1.25600070e-01f, 4.50337350e-01f, 4.43673521e-01f, 4.48777348e-01f, 1.02280825e-02f, -1.07311811e-02f,
  3.76578003e-01f, 3.05083692e-01f, 8.53554681e-02f, -4.43360656e-01f, -3.87852192e-01f, 3.36550415e-01f, 1.44775003e-01f, 7.72088170e-02f, 1.34846270e-01f, 2.01418437e-02f,
  -2.10905150e-01f, -2.06845969e-01f, -3.00076157e-01f, 4.74090070e-01f, 2.46551797e-01f, -6.63953722e-01f, 1.69021964e-01f, -4.52118933e-01f, 1.83844715e-01f, 2.87954718e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  2.89330989e-01f, 2.30176263e-02f, 1.62479669e-01f, 3.03234849e-02f, -2.84184292e-02f, 7.56298006e-02f, 3.82986888e-02f, 1.50476499e-02f, 1.94747999e-01f, 2.82665998e-01f,
  8.66352320e-02f, 1.35153681e-01f, 4.42725681e-02f, 1.52499586e-01f, 1.62767678e-01f, 1.07218660e-01f, -3.63239720e-02f, 2.45586410e-01f, 1.06785417e-01f, 2.39739552e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  1.74711108e-01f, 2.43094921e-01f, -9.20559987e-02f, 1.23301866e-02f, 1.99339703e-01f, -3.50566693e-02f, 1.04454301e-01f, 2.25899577e-01f, -2.11955681e-01f, -9.07134637e-02f,
  -2.30324566e-01f, -4.88991588e-02f, -4.08578455e-01f, 1.98222131e-01f, 2.81664789e-01f, -2.37211287e-01f, 2.36332551e-01f, 2.13105768e-01f, 3.63970280e-01f, 1.37485862e-02f,
  -5.70092201e-01f, 6.24014586e-02f, 3.09928596e-01f, -2.67611653e-01f, -3.13078165e-01f, 2.45737165e-01f, 8.48774165e-02f, -5.31925261e-02f, -1.72480822e-01f, -1.53654277e-01f,
  -1.98567569e-01f, -6.32851198e-02f, -7.42733479e-02f, 1.52982250e-01f, -2.73479849e-01f, 1.40547514e-01f, -2.31835172e-01f, -2.11859792e-01f, 1.25490040e-01f, -4.41035092e-01f,
  -2.01330066e-01f, -5.98301329e-02f, 3.20941597e-01f, -2.61920869e-01f, -5.21022320e-01f, -2.09350269e-02f, 2.94267565e-01f, -1.87178105e-01f, -1.56793743e-02f, -1.85334653e-01f,
  1.33838385e-01f, -3.20525497e-01f, -5.96021831e-01f, -3.80912513e-01f, 1.98215306e-01f, -2.35903800e-01f, 1.45332769e-01f, -5.00222892e-02f, 1.50656506e-01f, 1.97948053e-01f,
  -2.28177801e-01f, 1.08475193e-01f, 9.07705650e-02f, 2.35023767e-01f, 2.63338722e-02f, -2.18390867e-01f, 2.38777772e-01f, -1.59677625e-01f, 1.58142909e-01f, 2.43659131e-02f,
  7.54473358e-03f, -1.54165745e-01f, 3.93330097e-01f, 1.53702393e-01f, -1.02352567e-01f, 4.84253436e-01f, 2.45233886e-02f, 1.32693768e-01f, 2.63171047e-01f, -5.14736772e-01f,
  -4.66439009e-01f, -6.50882900e-01f, -3.10325604e-02f, -2.24575147e-01f, -2.18416348e-01f, -4.98301625e-01f, -2.12503165e-01f, -3.53711784e-01f, -3.69949304e-02f, 2.17087492e-01f,
  3.90236646e-01f, -5.37031472e-01f, -3.23266178e-01f, 2.09571138e-01f, 3.04434389e-01f, -2.20960513e-01f, 9.81552973e-02f, 2.62347966e-01f, 1.02626681e-01f, -1.40786394e-01f,
  -8.87770429e-02f, 8.98295194e-02f, -2.64652312e-01f, 5.06407142e-01f, -2.53106534e-01f, 1.82316542e-01f, -2.42918313e-01f, 7.91974552e-03f, 2.69780904e-01f, -5.00036180e-01f,
  -3.41927558e-01f, 1.76012173e-01f, -2.12812945e-01f, 1.72896415e-01f, -4.66901898e-01f, 1.97634652e-01f, 2.58797139e-01f, 1.91177502e-01f, -5.23054600e-02f, 1.11992635e-01f,
  -2.65698433e-01f, -3.66939157e-01f, -4.35446680e-01f, 1.48924544e-01f, 6.87133893e-02f, -4.23437543e-03f, -5.27249515e-01f, -6.40564919e-01f, 1.00705683e-01f, -1.79721132e-01f,
  1.75584927e-01f, 8.85909125e-02f, 1.39661431e-01f, -2.23100949e-02f, -1.31058604e-01f, -8.09465349e-02f, -2.01967105e-01f, -8.42201337e-02f, -7.66374916e-02f, -1.57650262e-01f,
  8.06123093e-02f, -6.34392127e-02f, 1.90528363e-01f, 5.75634725e-02f, 2.00205937e-01f, 1.02820583e-01f, -1.00000523e-01f, 3.10224891e-01f, -1.12072170e-01f, 2.21684173e-01f,
  -8.19760486e-02f, 8.58534314e-03f, -4.44021314e-01f, 2.88847923e-01f, -2.97473129e-02f, -1.40983254e-01f, 1.74029499e-01f, 3.11723538e-02f, -1.56551659e-01f, -2.90186614e-01f,
  -1.51514992e-01f, 8.41764584e-02f, -1.13396436e-01f, 1.08726569e-01f, 2.87886679e-01f, 7.22085834e-02f, -2.41482347e-01f, 3.24511796e-01f, -9.61873531e-02f, 8.62683082e-05f,
  9.32063162e-02f, -1.76073432e-01f, -1.98006526e-01f, -3.56657244e-02f, -2.81497985e-01f, -2.30179802e-01f, -1.43464087e-02f, 6.95601180e-02f, 2.78571993e-01f, 1.24917194e-01f,
  1.07044861e-01f, -4.79031727e-03f, 6.85442239e-02f, -1.28442228e-01f, 2.51513600e-01f, -2.31281564e-01f, -2.83421159e-01f, 1.77738041e-01f, 2.76102722e-01f, -2.23857816e-03f,
  3.08266908e-01f, -2.71536112e-01f, 9.78593901e-03f, -1.12505496e-01f, 4.32623327e-02f, 1.11149795e-01f, -2.04395786e-01f, -1.85935006e-01f, 1.95101202e-01f, 3.17822337e-01f,
  1.25098586e-01f, -2.33276263e-01f, -4.48508896e-02f, 1.56132430e-01f, -1.21768698e-01f, 1.84642971e-01f, -2.01732978e-01f, -1.41499236e-01f, 1.22428678e-01f, -4.63669360e-01f,
  -1.75312966e-01f, -1.44234121e-01f, -3.84861887e-01f, -5.91276437e-02f, -2.89506525e-01f, 2.13502333e-01f, -1.36082485e-01f, 2.58174032e-01f, 3.49425346e-01f, -2.24157706e-01f,
  1.43121272e-01f, -1.10758021e-01f, 2.62489498e-01f, -2.99468458e-01f, -3.07888001e-01f, -1.04336023e-01f, 3.46451476e-02f, -2.47648016e-01f, 1.33861288e-01f, 1.08546592e-01f,
  -3.02636754e-02f, -1.45094350e-01f, 4.97181602e-02f, 1.14752360e-01f, 1.75969824e-01f, 1.34142060e-02f, -1.72511160e-01f, -2.83535998e-02f, -7.60116652e-02f, 3.56302053e-01f,
  -2.03871548e-01f, 1.36740476e-01f, 2.01925263e-01f, -4.25521195e-01f, -2.09210277e-01f, -4.64545369e-01f, 3.19787264e-01f, -2.43558645e-01f, 1.83435664e-01f, -5.54978728e-01f,
  -6.74646139e-01f, 1.30303994e-01f, 8.99196193e-02f, 1.47925764e-01f, -1.99760199e-01f, 5.66097014e-02f, -4.73547578e-02f, -2.69033372e-01f, 4.42486070e-02f, -1.44580632e-01f,
  4.62635830e-02f, -1.05866544e-01f, -3.12939078e-01f, -1.20518215e-01f, -3.32310319e-01f, 2.11899862e-01f, 2.50839025e-01f, -2.01575696e-01f, 2.49585286e-01f, -4.32608873e-01f,
  -6.36835173e-02f, 1.77738279e-01f, -3.60791445e-01f, -4.82045352e-01f, -4.38585103e-01f, -5.25009811e-01f, -4.60825384e-01f, -2.50689864e-01f, -5.32361269e-01f, -3.20353545e-02f,
  3.59313399e-01f, -3.11914325e-01f, -1.94399297e-01f, -3.65032881e-01f, 7.98634440e-03f, 2.81499207e-01f, 1.11307919e-01f, 3.50860476e-01f, -8.20003748e-02f, -6.33433536e-02f,
  1.68026760e-02f, -2.44887516e-01f, 1.40639795e-02f, 2.92246848e-01f, 2.10389182e-01f, -2.01413438e-01f, 2.52405316e-01f, -1.78885341e-01f, -7.32537434e-02f, 3.75131220e-01f,
  -4.44748193e-01f, 2.50052094e-01f, -2.33854651e-01f, -8.01640928e-01f, 1.67988926e-01f, 1.73045963e-01f, -4.87851575e-02f, 2.28493921e-02f, 4.63901348e-02f, 7.14002550e-02f,
  3.89191002e-01f, 2.68607378e-01f, -4.07524735e-01f, -1.80883154e-01f, -1.99241675e-02f, 1.10157952e-01f, 2.23546281e-01f, -3.37105900e-01f, 2.08267570e-01f, -2.79255569e-01f,
  1.58375964e-01f, 1.67137429e-01f, -2.80818701e-01f, 2.33218625e-01f, 2.93890595e-01f, 8.69895741e-02f, -1.87269345e-01f, -5.11560619e-01f, -2.21448675e-01f, 1.61502853e-01f,
  -2.98332453e-01f, -3.70525688e-01f, 1.43426642e-01f, -3.07682604e-01f, -3.25037867e-01f, 3.11838120e-01f, -1.09756492e-01f, 1.45774558e-01f, -3.86613548e-01f, 2.16942951e-01f,
  3.99668552e-02f, 1.53127424e-02f, -3.08588356e-01f, -5.53523183e-01f, 1.76394314e-01f, -1.96445033e-01f, -1.55421987e-01f, 1.51063845e-01f, -5.29027760e-01f, 5.68889007e-02f,
  -3.29901010e-01f, 1.12491854e-01f, 1.01853743e-01f, -2.47662351e-01f, -1.21143512e-01f, -3.35704237e-02f, 9.79812164e-03f, -1.57213993e-02f, 3.38268012e-01f, 3.26390900e-02f,
  1.28662929e-01f, -1.80122763e-01f, -1.65563568e-01f, 3.14595729e-01f, 2.48184755e-01f, -2.55091578e-01f, -2.11104095e-01f, -2.95526862e-01f, -2.14585304e-01f, -2.76348263e-01f,
  -4.89421338e-01f, 2.20067993e-01f, 3.44770044e-01f, 2.51407385e-01f, -2.54640251e-01f, 3.53759676e-01f, -1.89404860e-01f, 2.51038134e-01f, -1.11045837e-01f, -1.07068755e-01f,
  2.63136446e-01f, -6.13159239e-01f, 4.22894247e-02f, -1.70432732e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -5.54892421e-02f, 5.16601205e-02f, -5.35961241e-02f, 3.33587825e-02f, -1.03042513e-01f, -1.89000636e-01f, 2.23551728e-02f, 1.88651178e-02f, 1.39050975e-01f, 3.50663923e-02f,
  1.08093038e-01f, -3.78736146e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    