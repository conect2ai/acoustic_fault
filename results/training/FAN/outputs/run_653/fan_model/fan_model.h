/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.37256300e-01f, -4.26541299e-01f, 2.63071805e-02f, -8.45102295e-02f, 2.70588785e-01f, 2.50413477e-01f, 1.10915147e-01f, -1.10348299e-01f, -5.87210022e-02f, -1.01729020e-01f,
  1.22713700e-01f, 2.12086946e-01f, 1.31176502e-01f, 1.63554877e-01f, 3.00786849e-02f, -1.54207975e-01f, -1.54378382e-03f, 3.98949198e-02f, 2.36101642e-01f, 9.05257910e-02f,
  -6.85979845e-03f, -2.26510420e-01f, -3.14640880e-01f, -2.15119079e-01f, -2.08946437e-01f, 1.75998747e-01f, -4.29975800e-02f, -7.86265358e-02f, 9.57896411e-02f, -1.77258924e-01f,
  1.19475469e-01f, -2.79021949e-01f, 1.13590181e-01f, 7.02301487e-02f, 9.33548212e-02f, -1.71480104e-01f, -3.64138366e-04f, -8.19383636e-02f, -1.01405559e-02f, -2.05559075e-01f,
  1.08826213e-01f, 6.48953719e-03f, 1.10421024e-01f, -3.44592109e-02f, -1.27835944e-01f, -6.08388474e-03f, -1.96709782e-01f, -1.66755900e-01f, -8.33524987e-02f, -1.34971052e-01f,
  1.17985404e-03f, 4.66638394e-02f, 6.70554563e-02f, -8.00046027e-02f, -9.63614881e-02f, 1.37505844e-01f, 3.47271487e-02f, -7.58947209e-02f, 7.98777565e-02f, -2.44452953e-01f,
  -1.51235506e-01f, -8.04224461e-02f, 2.71224063e-02f, -1.89800486e-02f, 3.17772105e-02f, 9.24603716e-02f, -6.49556145e-02f, 1.52502600e-02f, -3.96648459e-02f, 1.24210734e-02f,
  8.51715729e-02f, 7.58088147e-03f, -3.91900130e-02f, 4.77678934e-03f, 1.83864646e-02f, -4.16336581e-02f, 7.03322738e-02f, -5.63993603e-02f, 2.17554960e-02f, -1.63077768e-02f,
  2.46761162e-02f, 5.61248623e-02f, -7.21036941e-02f, -6.55192435e-02f, 7.57961869e-02f, -3.02900816e-03f, -8.57686996e-02f, 1.78875607e-02f, -1.59243837e-01f, -7.17754290e-02f,
  -3.20259556e-02f, 1.40060976e-01f, -6.57901093e-02f, -4.97731790e-02f, 2.54622158e-02f, 2.33987416e-03f, -2.87425295e-02f, 2.79432908e-02f, -4.92607057e-02f, 2.53555626e-02f,
  1.11787748e-02f, 3.04207373e-02f, 4.40475456e-02f, 1.35191046e-02f, -7.19462894e-03f, 4.33456860e-02f, -4.43657823e-02f, 1.44470766e-01f, -1.93230435e-02f, -9.66409594e-02f,
  -1.01108171e-01f, -5.11754490e-02f, 1.63877770e-01f, 3.42495702e-02f, -8.16108659e-02f, 1.99568003e-01f, -1.98259624e-03f, -1.79913826e-02f, 2.23857790e-01f, -1.39660686e-01f,
  -3.32669586e-01f, 4.01730210e-01f, 5.09944409e-02f, 1.50926709e-01f, 2.51793236e-01f, 2.80651957e-01f, 5.47199965e-01f, 1.87620312e-01f, 6.53063431e-02f, 3.26875865e-01f,
  2.12796405e-01f, -4.45339121e-02f, 8.84273723e-02f, -6.81821182e-02f, -1.22828543e-01f, 3.95028234e-01f, 3.18305522e-01f, -1.43096223e-01f, -2.62249112e-01f, -6.77513331e-02f,
  1.93107009e-01f, 8.02203193e-02f, -2.49747530e-01f, -7.37642646e-02f, 1.56651571e-01f, -6.65589198e-02f, 2.08900467e-01f, 5.99234477e-02f, 1.40270069e-01f, 3.25205117e-01f,
  6.44228384e-02f, 5.28417230e-02f, -3.30851972e-02f, 3.62317152e-02f, 1.12354606e-01f, 4.92633432e-02f, 7.32620507e-02f, 3.06241028e-02f, 1.06216744e-01f, 1.28691778e-01f,
  1.72943741e-01f, 2.72237770e-02f, 1.72647491e-01f, 5.75135536e-02f, 1.88532677e-02f, 1.25593051e-01f, 8.91800225e-02f, -3.09541784e-02f, 1.14023415e-02f, 1.71174631e-01f,
  2.15619534e-01f, 1.03590280e-01f, 7.46740252e-02f, 1.02631710e-01f, -6.60933182e-02f, -3.71825807e-02f, 1.46246910e-01f, -3.70694175e-02f, -1.25071183e-01f, 1.17102407e-01f,
  2.33102366e-02f, -6.47097081e-02f, -7.14577138e-02f, 1.52605884e-02f, 2.16661394e-03f, -2.75994884e-04f, -3.66822593e-02f, -5.02200658e-03f, -5.84137887e-02f, -1.17282905e-01f,
  -4.74795625e-02f, -8.63192379e-02f, -5.35606779e-02f, -2.55128257e-02f, 4.82710339e-02f, -8.10443535e-02f, -4.88208719e-02f, -2.48240530e-02f, -6.09194972e-02f, 2.13992391e-02f,
  6.83637988e-03f, -6.31469786e-02f, 4.67315726e-02f, 4.85630101e-03f, 1.40778366e-02f, -2.87667606e-02f, -9.21540856e-02f, -1.12228632e-01f, -8.28621089e-02f, -2.41915230e-02f,
  9.76152420e-02f, -4.59667481e-02f, 1.53025031e-01f, 5.52398823e-02f, 1.43115997e-01f, 6.04839437e-02f, 1.55473441e-01f, 1.24595063e-02f, 7.32765123e-02f, 1.25156462e-01f,
  5.74294925e-02f, 7.42695406e-02f, 6.89228624e-02f, 1.78759024e-01f, 9.95802209e-02f, 9.62628499e-02f, 1.55044839e-01f, 1.58772916e-01f, 8.46332163e-02f, 1.37859643e-01f,
  1.32169172e-01f, 1.77573919e-01f, 7.50936940e-03f, 1.19474970e-01f, 5.47339395e-02f, 7.61186108e-02f, 1.44815221e-01f, 1.11492068e-01f, 8.13969821e-02f, 2.35381052e-01f,
  -1.68302253e-01f, 5.78454733e-02f, 3.27486455e-01f, -2.55973369e-01f, 4.14662659e-02f, 3.14157158e-01f, 3.54914486e-01f, -1.87529847e-02f, -3.21693689e-01f, 9.95881110e-02f,
  3.71762253e-02f, -2.20324516e-01f, -2.00178772e-01f, -9.38202143e-02f, -3.71086784e-02f, 1.91832513e-01f, 4.57368754e-02f, 7.27090687e-02f, 3.32653448e-02f, -5.32040522e-02f,
  -1.66190863e-01f, -1.54188618e-01f, -1.26958981e-01f, -2.27189913e-01f, -5.35279997e-02f, -2.27107063e-01f, 5.91073558e-02f, 1.03639990e-01f, 4.94854227e-02f, 9.24765840e-02f,
  2.73289621e-01f, 2.49906227e-01f, -3.83661687e-02f, -1.64913103e-01f, 3.32908034e-02f, -6.94259480e-02f, 2.24725204e-03f, -6.15142174e-02f, -5.52467518e-02f, 9.94623005e-02f,
  -9.18851942e-02f, -9.65854824e-02f, -6.03703484e-02f, 2.80506513e-03f, 2.28951991e-04f, -1.17916213e-02f, -9.15787220e-02f, -7.13538677e-02f, -4.40519489e-02f, -9.07253101e-03f,
  4.16702367e-02f, 8.58934522e-02f, 1.86046436e-01f, 2.01367456e-02f, -4.57663881e-03f, -7.72176757e-02f, 1.10500894e-01f, -2.59424075e-02f, -2.48360615e-02f, -6.07289635e-02f,
  -5.65285049e-02f, -2.92853974e-02f, -5.16408868e-02f, -1.01426449e-02f, 1.11164036e-03f, -3.02453991e-02f, 2.97824349e-02f, 2.52980087e-02f, 9.87454038e-03f, -3.18640620e-02f,
  -1.31368181e-02f, 2.72994339e-02f, 4.52693626e-02f, -2.33124793e-02f, -1.79709867e-02f, 8.91588442e-03f, 4.69527058e-02f, -6.53918833e-02f, 4.61484259e-03f, -3.57310884e-02f,
  -1.66738778e-02f, 2.38956939e-02f, -4.65676002e-03f, 5.15194759e-02f, -3.32882702e-02f, 2.75098402e-02f, -2.46288031e-02f, -6.04936928e-02f, -7.51885399e-02f, -1.64148733e-02f,
  -1.13126799e-01f, -1.22605823e-02f, 1.24568313e-01f, -5.55075705e-03f, 3.06970309e-02f, 2.77041551e-02f, 3.39313932e-02f, 2.10180506e-02f, 6.60599619e-02f, -2.73580626e-02f,
  3.93866412e-02f, -5.20311631e-02f, 8.55584256e-03f, 3.11741270e-02f, -3.26625295e-02f, -8.63468722e-02f, -5.46363071e-02f, 3.62231769e-02f, -5.10038659e-02f, 4.19260710e-02f,
  -1.03188336e-01f, -2.03220695e-02f, -3.30313183e-02f, -4.26873416e-02f, -8.35120380e-02f, -2.75436342e-02f, 9.35004838e-03f, -1.58780925e-02f, -4.87399437e-02f, -1.43124163e-02f,
  -1.76204279e-01f, 2.11836457e-01f, 4.19945061e-01f, -1.08542122e-01f, 8.19135178e-03f, 1.08176604e-01f, 4.00988311e-01f, 3.72502618e-02f, -2.73928076e-01f, 4.20686007e-02f,
  -3.66805792e-02f, -4.18697983e-01f, -2.69170344e-01f, -2.66166180e-01f, -1.10514849e-01f, 3.09276700e-01f, 3.45156461e-01f, 3.58997062e-02f, -1.77319750e-01f, -2.33334884e-01f,
  -2.04808209e-02f, -5.14796935e-03f, -7.50981178e-03f, -1.15808204e-01f, 3.74181680e-02f, -1.43212706e-01f, 1.89831257e-01f, 1.29625220e-02f, -1.02747068e-01f, 2.02404678e-01f,
  9.66370478e-03f, 8.71625319e-02f, -6.72366172e-02f, -7.74678364e-02f, -3.67115885e-02f, -7.67898560e-02f, 1.54916942e-02f, -5.54700494e-02f, -2.77450923e-02f, 9.78193060e-03f,
  4.90997406e-03f, -7.03535601e-02f, -1.00063883e-01f, -1.25165164e-01f, -9.87979993e-02f, -3.06187198e-02f, -3.24343368e-02f, 2.89893933e-02f, -5.26590496e-02f, -4.73755039e-02f,
  -7.96392784e-02f, -9.42275152e-02f, 7.48459324e-02f, -1.78406313e-01f, -8.84941071e-02f, -1.68040544e-01f, -1.20411679e-01f, -1.81574866e-01f, -5.03196344e-02f, 1.50992069e-03f,
  -7.54602440e-03f, 3.21080312e-02f, 5.95009625e-02f, -6.71485905e-03f, -1.67787392e-02f, 5.88807873e-02f, -8.61458555e-02f, 3.38718332e-02f, -3.28743458e-03f, 7.07489476e-02f,
  -5.26882894e-02f, 4.49163690e-02f, -4.31864373e-02f, 3.52421626e-02f, 7.10491687e-02f, -3.90563533e-02f, -1.71957612e-02f, -1.11538160e-03f, -1.70318801e-02f, 8.53839144e-03f,
  -6.39309874e-04f, 2.08464414e-02f, 3.75047326e-02f, -4.51686010e-02f, 6.13214225e-02f, 3.38722840e-02f, -2.76003163e-02f, -1.64061449e-02f, -1.36475470e-02f, 3.60503905e-02f,
  -1.73778519e-01f, -9.72901285e-02f, -7.32207745e-02f, 5.50404638e-02f, 2.87138335e-02f, -7.77833387e-02f, -8.24024677e-02f, -4.99386340e-02f, -1.14609927e-01f, -1.80660095e-02f,
  -7.53678530e-02f, -6.18654117e-02f, -3.53361666e-02f, -4.04224023e-02f, -4.71199490e-02f, -9.57215130e-02f, 5.15375137e-02f, -6.26896620e-02f, -1.43930465e-01f, -2.54489668e-02f,
  4.41790745e-02f, 7.66608045e-02f, -1.52597249e-01f, -1.90020986e-02f, -1.14593945e-01f, -1.51109889e-01f, 1.95201188e-02f, 9.83073004e-03f, -3.06308735e-02f, 4.95896526e-02f,
  3.49331737e-01f, -2.67194659e-01f, -6.22549474e-01f, 8.41638222e-02f, -1.45217195e-01f, -4.30149212e-02f, -2.76527464e-01f, 2.72546262e-02f, 2.51623183e-01f, -1.49828389e-01f,
  -1.14180252e-01f, 1.43746436e-01f, 4.30743583e-02f, 4.59273271e-02f, 1.75447464e-02f, -2.34735772e-01f, -3.29699159e-01f, -1.78717077e-01f, 2.35519209e-03f, 1.00679792e-01f,
  4.44881693e-02f, 9.19492319e-02f, 3.94909456e-02f, 5.28747886e-02f, -3.00670359e-02f, 8.41609612e-02f, -1.63695768e-01f, -7.92750865e-02f, -1.93168685e-01f, -1.33627430e-01f,
  -2.47264445e-01f, -1.04187436e-01f, -4.88319900e-03f, 9.80925001e-03f, -1.66886717e-01f, 1.66267306e-02f, 4.34463769e-02f, -2.85036080e-02f, 9.66633204e-03f, -2.18225773e-02f,
  -2.29041632e-02f, 1.32703716e-02f, -4.66646850e-02f, 2.81975586e-02f, -7.74131194e-02f, 1.50977513e-02f, -8.28005075e-02f, -1.63522124e-01f, -4.39751744e-02f, -1.41097054e-01f,
  -1.00921519e-01f, -1.87559530e-01f, -7.32533857e-02f, -9.25753787e-02f, -6.88790902e-02f, -9.41999443e-03f, -2.21442908e-01f, -1.65702943e-02f, -1.06549293e-01f, -6.27978966e-02f,
  -3.17806676e-02f, 2.05557030e-02f, 1.77942570e-02f, 4.00364138e-02f, 7.47382790e-02f, 1.28630370e-01f, -8.94567072e-02f, 5.95114492e-02f, 2.70731375e-02f, 1.37395086e-02f,
  3.38026613e-04f, -4.21330407e-02f, -2.55566854e-02f, 4.39030901e-02f, 5.78110889e-02f, 6.03949232e-03f, 8.04768503e-02f, -5.76645210e-02f, 8.27762038e-02f, 5.71360663e-02f,
  1.65952146e-02f, 9.67057124e-02f, 6.72819167e-02f, -2.34308131e-02f, -9.56827477e-02f, -2.40084250e-02f, 5.49926870e-02f, 8.70616138e-02f, 3.08676846e-02f, 6.71156272e-02f,
  1.44451842e-01f, -8.88629816e-03f, 5.86641654e-02f, 2.33730432e-02f, 7.21096471e-02f, 1.16050400e-01f, 2.08802558e-02f, -1.99724101e-02f, -1.00863921e-02f, -7.12267607e-02f,
  -4.15589139e-02f, 1.06208012e-01f, 7.62716755e-02f, 7.39135779e-04f, -5.27630001e-02f, -5.65394461e-02f, 1.00703873e-01f, 3.41731198e-02f, -1.23388451e-02f, -2.06280015e-02f,
  1.07780203e-01f, 5.31007759e-02f, 7.96976537e-02f, 5.75753488e-02f, 3.52825150e-02f, 3.27952877e-02f, -7.24892169e-02f, -4.61979136e-02f, 4.48391493e-03f, 9.11343843e-02f,
  4.52367127e-01f, 3.75101343e-02f, -2.76239932e-01f, 2.53468126e-01f, 2.22240180e-01f, 1.16818763e-01f, 1.46365911e-02f, 3.79801989e-02f, 8.74045193e-02f, 3.17262560e-02f,
  2.65693724e-01f, 2.97497600e-01f, 2.19393857e-02f, -7.98065066e-02f, -1.96690904e-03f, -2.26775527e-01f, -4.32194144e-01f, -2.91344374e-01f, 1.21361378e-03f, 1.80510744e-01f,
  1.01294875e-01f, -7.39415362e-02f, -7.99002275e-02f, -1.65151671e-01f, -5.44018932e-02f, 8.63174424e-02f, -2.74821073e-01f, 3.95881012e-02f, -2.92946547e-02f, -3.04265887e-01f,
  1.95424527e-01f, 3.26691389e-01f, 1.85775340e-01f, 2.49337792e-01f, 2.15484887e-01f, 8.10457990e-02f, 1.69557497e-01f, 1.13159247e-01f, 1.07515365e-01f, -4.91194353e-02f,
  1.19956285e-01f, 1.38443306e-01f, 1.04982518e-01f, 4.79176380e-02f, 7.68026561e-02f, 1.79483876e-01f, -1.01751357e-01f, -6.65583387e-02f, -5.72166257e-02f, 1.62991479e-01f,
  2.00815201e-01f, 2.48739839e-01f, 2.05392197e-01f, -3.20418850e-02f, -2.94839256e-02f, 1.41095251e-01f, 9.67514887e-02f, 7.04623908e-02f, 2.62417980e-02f, -4.75725941e-02f,
  7.06571480e-03f, -2.81046070e-02f, -3.81665565e-02f, -8.76731053e-02f, -5.90784624e-02f, -6.68059364e-02f, -6.27781674e-02f, 3.96991260e-02f, -1.04126394e-01f, 8.50960799e-03f,
  -6.02255762e-03f, -3.95963788e-02f, -6.50315136e-02f, -4.11091335e-02f, -1.25930309e-02f, -9.77141261e-02f, -6.09614886e-02f, -1.09844990e-01f, -9.13733020e-02f, -4.80698235e-02f,
  2.35814787e-02f, -6.95337728e-02f, -6.52269125e-02f, -1.53090686e-01f, -1.16351552e-01f, -7.18908235e-02f, -1.10862531e-01f, 2.08944231e-02f, -3.06209400e-02f, -2.93001328e-02f,
  2.24361524e-01f, 2.80367639e-02f, 1.96937606e-01f, 1.47364274e-01f, 1.72146052e-01f, 7.00001940e-02f, 1.38013974e-01f, 8.06008577e-02f, 1.48882642e-01f, 6.12786636e-02f,
  2.82253385e-01f, 1.11114711e-01f, 7.65617490e-02f, 4.71408814e-02f, 1.09460294e-01f, 7.77511597e-02f, 1.13021910e-01f, 1.46235466e-01f, 7.22565949e-02f, 1.72883511e-01f,
  7.64153749e-02f, 1.97654963e-01f, 2.62517184e-01f, 1.21305518e-01f, 2.47598991e-01f, 2.65042812e-01f, 8.86891186e-02f, 1.74349353e-01f, 1.85063675e-01f, 5.52713359e-03f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.32156646e-01f, -2.97667831e-01f, -3.72255668e-02f, -3.45494062e-01f, 6.89067468e-02f, 2.02736855e-01f, -1.08850203e-01f, -7.74366222e-03f, -5.33445925e-02f, -2.84494728e-01f,
  1.12318367e-01f, 1.26066864e-01f, -8.83153826e-02f, -5.28804772e-02f, -2.14494765e-01f, -4.06012714e-01f, -3.64943534e-01f, -2.29003504e-01f, 1.28321230e-01f, 3.08670044e-01f,
  1.38956323e-01f, -1.67429537e-01f, -1.06497534e-01f, -1.18699186e-02f, -2.71284997e-01f, -1.79783225e-01f, -1.93925142e-01f, -1.30273208e-01f, 3.42222229e-02f, -3.40402663e-01f,
  -2.07745850e-01f, 4.81557474e-02f, 9.58104357e-02f, -1.99710459e-01f, -8.20964873e-02f, 3.99158821e-02f, -1.00614578e-01f, -5.58911115e-02f, 2.30584428e-01f, -1.72901466e-01f,
  -1.03400208e-01f, -6.15889998e-03f, -1.24281412e-02f, 6.67803660e-02f, 1.25113785e-01f, -4.91671599e-02f, -1.30812511e-01f, 3.79871689e-02f, -5.49455769e-02f, 1.91810787e-01f,
  -1.03168637e-01f, -7.77162015e-02f, -1.60035908e-01f, -5.70581034e-02f, 5.26668653e-02f, 4.27748375e-02f, 9.20226872e-02f, -1.92146674e-02f, -4.59475778e-02f, -3.49740654e-01f,
  -1.69617671e-03f, -6.45885197e-03f, 8.21806304e-03f, 5.66632254e-03f, -1.27940297e-01f, -4.37917514e-03f, -1.92404896e-01f, -2.39704065e-02f, 5.91825917e-02f, -3.63258086e-02f,
  5.19254468e-02f, 9.21477526e-02f, 9.94896069e-02f, -2.05691457e-01f, -4.65655699e-02f, -1.23445906e-01f, -3.83799081e-03f, -1.16332933e-01f, -5.72301820e-02f, 6.36539608e-02f,
  1.34703711e-01f, -7.53194839e-02f, -2.05618758e-02f, -1.02498978e-01f, 1.34331966e-02f, -1.89245865e-01f, 3.82682271e-02f, 8.02038386e-02f, 9.20175090e-02f, 6.69459626e-02f,
  -3.42668712e-01f, 1.40200719e-01f, -1.52161896e-01f, -1.52821332e-01f, -3.63384709e-02f, -6.64288104e-02f, -9.89096463e-02f, 7.86977112e-02f, -3.05294562e-02f, 9.00554471e-03f,
  1.15244500e-01f, -3.01091969e-01f, -2.57878512e-01f, 7.13780671e-02f, -2.23411638e-02f, -4.06976379e-02f, -1.47500440e-01f, -9.14848521e-02f, -8.09096470e-02f, 8.91057104e-02f,
  -3.06383044e-01f, -1.05590045e-01f, -3.95410061e-01f, -3.78715605e-01f, -2.61360735e-01f, -2.78714359e-01f, -1.96121648e-01f, -5.85534796e-03f, -2.42594391e-01f, -5.24274111e-01f,
  6.20089531e-01f, 9.61528942e-02f, -6.51817858e-01f, 4.17437673e-01f, -4.05817300e-01f, -3.49985033e-01f, -2.59546280e-01f, 1.03872791e-02f, 2.62704730e-01f, -1.50114030e-01f,
  -2.17739493e-01f, 1.16650440e-01f, 5.39982989e-02f, -1.87438309e-01f, 8.10047518e-03f, -2.16958880e-01f, -4.54968631e-01f, -2.20522970e-01f, -2.55339056e-01f, -2.97509015e-01f,
  6.99619763e-03f, 1.17772333e-01f, 7.08407015e-02f, -9.40410569e-02f, 1.26569584e-01f, -9.18735117e-02f, -3.18186790e-01f, -1.85578495e-01f, -3.49439681e-01f, -1.92417949e-01f,
  -3.92807186e-01f, -2.44530644e-02f, -6.74649402e-02f, 3.47940661e-02f, -7.13048130e-03f, 9.06662643e-02f, -1.26522079e-01f, -1.16700992e-01f, -6.07845858e-02f, -1.33312345e-01f,
  -1.69440899e-02f, -2.14807585e-01f, -9.37936082e-02f, -9.48067233e-02f, -2.06876040e-01f, 4.84186299e-02f, -2.70917211e-02f, -3.84900421e-02f, -7.41608888e-02f, -2.86489248e-01f,
  -3.36665362e-02f, -1.68164775e-01f, -1.95526883e-01f, -1.41388580e-01f, -1.97719291e-01f, 3.48820388e-02f, -2.76088089e-01f, -1.63755745e-01f, -2.68385500e-01f, 4.88688648e-02f,
  6.00364059e-02f, 3.46132019e-03f, 2.11919285e-03f, 1.01427972e-01f, 8.05196837e-02f, -5.34342777e-04f, 3.73834595e-02f, -6.12322055e-02f, -3.69896926e-02f, 5.11945449e-02f,
  -8.44652019e-03f, -4.14786823e-02f, -3.67332958e-02f, 5.18654063e-02f, -1.01652265e-01f, -1.32915517e-02f, -5.54646365e-02f, -3.88788916e-02f, 1.15243206e-03f, 4.36258465e-02f,
  5.51095745e-03f, -1.20285898e-01f, -1.14862155e-03f, 1.41419908e-02f, -2.77995542e-02f, -1.09024659e-01f, -4.68999147e-02f, -1.69991449e-01f, 1.31845102e-01f, -1.11010289e-02f,
  3.52335155e-01f, -3.36583182e-02f, 1.46219850e-01f, -3.06733269e-02f, -3.07747945e-02f, -1.26091558e-02f, -4.41446342e-02f, -2.30432659e-01f, -8.19109287e-03f, -2.46642269e-02f,
  -1.97226420e-01f, -6.06526434e-02f, -1.39533933e-02f, -1.29304394e-01f, -1.00989640e-01f, -1.14138447e-01f, 8.17420781e-02f, -8.34752992e-02f, -7.63574168e-02f, 1.08532362e-01f,
  1.13439187e-01f, -3.39877494e-02f, 2.11009771e-01f, 6.89475164e-02f, 7.79088661e-02f, 2.09194779e-01f, 2.25765072e-02f, -1.23433821e-01f, -6.41643405e-02f, 4.15412724e-01f,
  -5.16763091e-01f, -2.09116817e-01f, -3.17637652e-01f, -3.20355237e-01f, -1.54507071e-01f, 2.24377111e-01f, -3.89807262e-02f, 1.24257021e-01f, 1.19719163e-01f, -1.63040310e-01f,
  -3.33760642e-02f, -1.11487582e-01f, -2.64984816e-01f, -4.91153263e-02f, -2.23399445e-01f, -2.02932253e-01f, -1.67740971e-01f, -2.90870219e-01f, -3.54480743e-02f, 2.81471610e-01f,
  -1.51715623e-02f, -4.64572549e-01f, -2.52130389e-01f, -1.25277743e-01f, -1.96214274e-01f, -3.00203800e-01f, -4.32157129e-01f, -2.33506918e-01f, -3.99147049e-02f, -5.09815156e-01f,
  -2.06634700e-01f, -1.01830304e-01f, 3.24419774e-02f, -8.13562647e-02f, -1.20858304e-01f, 2.34374274e-02f, -5.41043133e-02f, 1.22755673e-02f, 1.40110150e-01f, 1.13796309e-01f,
  3.95741612e-02f, 5.85313700e-02f, -1.52825061e-02f, -8.45090523e-02f, 5.56382388e-02f, 2.06969514e-01f, 2.42870167e-01f, -5.40617816e-02f, 1.06911875e-01f, 1.37395769e-01f,
  2.17144370e-01f, 1.86680675e-01f, 1.19527958e-01f, 2.64639288e-01f, 2.22481206e-01f, 3.62358727e-02f, 1.71190366e-01f, 1.82959422e-01f, 1.67157367e-01f, -1.18823104e-01f,
  5.03627583e-03f, -7.43660554e-02f, -1.72561601e-01f, 5.73496222e-02f, 3.75276320e-02f, 3.45328115e-02f, -1.48667172e-01f, -1.10272497e-01f, -7.59502649e-02f, 9.11919773e-03f,
  1.59579560e-01f, -1.03301466e-01f, 1.53100332e-02f, -8.25241804e-02f, -5.83957098e-02f, 2.78485678e-02f, -1.70352422e-02f, 4.26824652e-02f, 1.28052160e-01f, 8.45333263e-02f,
  1.32110924e-01f, 1.92183908e-02f, -6.38638437e-02f, -1.38692513e-01f, -1.34476677e-01f, 5.99714136e-03f, 7.72508308e-02f, 5.24806194e-02f, 8.75852257e-02f, 1.59092024e-01f,
  -2.24186942e-01f, -1.45764351e-01f, -2.48185694e-01f, 1.30352795e-01f, -4.26863693e-02f, 1.07638240e-01f, -8.19499120e-02f, 5.56588806e-02f, -9.11553279e-02f, 4.11739126e-02f,
  6.80578724e-02f, -1.19683683e-01f, -1.61685586e-01f, 9.85231251e-02f, 2.96625663e-02f, 9.58123729e-02f, 3.99043821e-02f, -1.61494821e-01f, 1.33851305e-01f, 2.03914911e-01f,
  1.39332801e-01f, 1.46968171e-01f, -1.08888941e-02f, 3.08919195e-02f, 1.27491340e-01f, -2.85888284e-01f, -1.54960766e-01f, 1.87622625e-02f, -1.26369521e-01f, -2.32305586e-01f,
  5.96942246e-01f, -1.35602906e-01f, -7.08021998e-01f, -9.42115635e-02f, -3.53764683e-01f, -1.85357586e-01f, -2.14004323e-01f, 1.19117901e-01f, 1.75276190e-01f, -3.29882443e-01f,
  -1.79325879e-01f, 2.55750835e-01f, -4.85676788e-02f, 2.01833863e-02f, 8.35415125e-02f, -4.45952594e-01f, -3.93288463e-01f, -7.03609809e-02f, 4.16119367e-01f, 2.02398062e-01f,
  1.58235997e-01f, 1.63613632e-01f, 1.73930034e-01f, 1.59267008e-01f, -2.02885330e-01f, 5.85487634e-02f, -4.62941796e-01f, -1.39645919e-01f, -9.98962820e-02f, -4.99099106e-01f,
  -3.79943460e-01f, -1.02614656e-01f, 4.42814603e-02f, 1.34545043e-01f, -1.05709635e-01f, 1.42529011e-01f, 1.34225041e-01f, -2.92516872e-02f, 1.65668443e-01f, -1.33006528e-01f,
  1.38227902e-02f, 1.20827153e-01f, 1.56989604e-01f, 1.25832558e-01f, 3.73909436e-02f, 7.60552958e-02f, -7.37056136e-02f, 2.79757511e-02f, -9.14800763e-02f, -1.40235350e-02f,
  -6.36763796e-02f, -7.25015104e-02f, 1.07119931e-03f, -1.46577314e-01f, -3.24248970e-02f, -1.54855043e-01f, -2.22803578e-01f, -3.92582230e-02f, -1.14150032e-01f, -1.79937243e-01f,
  -1.14440128e-01f, -6.59278557e-02f, 1.35742407e-02f, 9.53040496e-02f, 1.03398308e-01f, 7.95371756e-02f, 4.57726419e-02f, -5.24273999e-02f, 6.34406656e-02f, 5.98103179e-05f,
  -1.30453587e-01f, -3.06546539e-02f, 9.78953298e-03f, -9.67163518e-02f, -4.20655124e-02f, 2.37909537e-02f, -5.90821356e-02f, -3.76792327e-02f, -4.40530945e-03f, 7.13798255e-02f,
  1.59736395e-01f, -2.74738241e-02f, -3.53698153e-03f, 2.36485023e-02f, -6.25427589e-02f, -4.72416244e-02f, -2.02230900e-03f, 3.45446989e-02f, 8.00467059e-02f, -5.05912267e-02f,
  1.98067501e-01f, -1.85601994e-01f, -1.03136241e-01f, 2.55347155e-02f, -3.88742913e-03f, -2.96358056e-02f, -6.02121241e-02f, 1.96960777e-01f, 1.69004247e-01f, 1.31340638e-01f,
  9.08708945e-02f, 1.57952711e-01f, -7.14881122e-02f, -1.55688420e-01f, 1.63663626e-02f, -1.53868953e-02f, 1.11001628e-02f, 9.81248170e-02f, 1.43389320e-02f, -7.33639523e-02f,
  -1.65016159e-01f, 1.52678221e-01f, 1.63397759e-01f, -6.95621148e-02f, -7.31913596e-02f, 1.41769379e-01f, -1.32246062e-01f, -5.99394478e-02f, 4.06421274e-02f, 5.05031906e-02f,
  4.23638999e-01f, -6.74351990e-01f, 1.40114605e-01f, 1.77921414e-01f, 2.55657852e-01f, 2.85148650e-01f, 1.92121387e-01f, 6.32999688e-02f, 5.67220338e-02f, -2.39192042e-03f,
  -5.84931552e-01f, -5.42076111e-01f, -3.82670015e-01f, -4.47501808e-01f, -1.94623321e-01f, 2.39935815e-01f, 3.63381058e-01f, 2.14214757e-01f, 3.03209275e-01f, 3.59739661e-02f,
  1.91966351e-02f, 1.42017797e-01f, 5.74201159e-02f, -2.44702096e-03f, -1.26362205e-01f, -2.90211607e-02f, 6.54844493e-02f, -1.44823626e-01f, -2.65270650e-01f, -2.46606618e-02f,
  -3.74457776e-03f, -2.24735767e-01f, 1.60679236e-01f, -1.71934903e-01f, -1.21447407e-01f, -4.37017754e-02f, -3.80080082e-02f, 3.85662466e-02f, -2.68445387e-02f, 6.63662180e-02f,
  -1.20400049e-01f, -5.90792224e-02f, -7.03355819e-02f, -6.09167814e-02f, 1.90537721e-01f, 2.45748516e-02f, -6.23777173e-02f, -9.64625552e-02f, -2.37459838e-01f, -1.64781049e-01f,
  -3.13970596e-01f, -1.39861420e-01f, -2.43903324e-03f, -1.25985786e-01f, -2.72407234e-01f, -1.00842044e-01f, -2.23494723e-01f, -1.00630350e-01f, -1.64759651e-01f, 2.27343157e-01f,
  4.78541069e-02f, 1.42394707e-01f, -1.22644342e-01f, -6.47143573e-02f, 4.26303372e-02f, 7.07712919e-02f, 8.21418762e-02f, 2.17850562e-02f, 6.65921867e-02f, 8.78060795e-03f,
  -5.91615215e-02f, -4.73286211e-02f, -2.73676682e-02f, 9.92843602e-03f, -1.24170154e-01f, -5.98595552e-02f, 7.84607008e-02f, -7.64369080e-03f, -5.16913161e-02f, 3.67702655e-02f,
  -1.05300941e-01f, 2.78565730e-03f, 3.84880304e-02f, -9.56325307e-02f, -7.99415037e-02f, -1.24111287e-01f, 1.60738882e-02f, -1.69123188e-01f, 9.97939799e-03f, -3.16782519e-02f,
  2.07330078e-01f, -3.41847390e-01f, 1.75545529e-01f, -1.06230535e-01f, 9.44111198e-02f, -1.51353225e-01f, -1.34468317e-01f, -9.78015363e-02f, -3.33859138e-02f, 1.04514532e-01f,
  -1.67878479e-01f, -2.85797864e-02f, -1.25230491e-01f, 1.98038425e-02f, 1.92761451e-01f, 1.16202541e-01f, -7.75494725e-02f, -3.05506494e-02f, 1.61779374e-02f, 1.77123360e-02f,
  1.08095855e-01f, 2.87275255e-01f, 2.92401612e-01f, 1.52288049e-01f, 2.72721127e-02f, 2.85978615e-01f, 2.11367115e-01f, 1.10780723e-01f, 1.90384850e-01f, 4.98569638e-01f,
  -4.39423203e-01f, -1.15563972e-02f, -6.26446214e-03f, 7.30379745e-02f, -2.15325803e-01f, -2.88621843e-01f, -1.54247850e-01f, 5.48539385e-02f, -6.17461093e-02f, -9.77582335e-02f,
  -2.66564786e-01f, -2.81776432e-02f, 1.67547733e-01f, 2.26806626e-01f, 2.49143794e-01f, 3.14808905e-01f, 5.28526068e-01f, 3.77433151e-01f, 8.88777990e-03f, -1.71515439e-02f,
  2.11419180e-01f, 2.45984178e-02f, -5.67672886e-02f, 2.67225146e-01f, 3.25986713e-01f, 1.68466151e-01f, 1.75309107e-01f, 4.15002601e-03f, 3.64963454e-03f, 6.49853945e-01f,
  -8.82122889e-02f, -2.90832907e-01f, -1.00044250e-01f, -1.92528918e-01f, -1.63484961e-01f, -6.12932779e-02f, -1.43329903e-01f, 1.31662181e-02f, -6.73749298e-02f, 7.06269145e-02f,
  -1.37097016e-01f, -4.01796512e-02f, 1.90510049e-01f, 5.85911386e-02f, -4.98473905e-02f, -1.20114192e-01f, 5.46039566e-02f, 1.98451370e-01f, 5.45990095e-02f, 1.06908695e-03f,
  2.17078015e-01f, -2.71006763e-01f, -2.25690976e-01f, 1.75521061e-01f, 1.45226866e-01f, 9.22337472e-02f, -1.80133116e-02f, -8.91033635e-02f, -2.48770654e-01f, 7.98347071e-02f,
  4.17998247e-02f, -1.07625229e-02f, -2.24393886e-02f, 4.95350882e-02f, 5.10529568e-03f, 5.67158982e-02f, 8.13575462e-02f, 8.90255719e-03f, 2.16430798e-01f, 8.37370381e-02f,
  -1.23766130e-02f, 7.14926869e-02f, 9.90166590e-02f, -8.46154243e-02f, 3.23480815e-02f, -1.05791226e-01f, 7.17242956e-02f, 2.67470907e-02f, -5.43827116e-02f, -2.83988193e-03f,
  -6.39250278e-02f, 8.64798725e-02f, 2.70696394e-02f, 1.65203169e-01f, -5.90935871e-02f, 8.64276215e-02f, 1.26123019e-02f, -2.73610502e-02f, 3.69659588e-02f, -1.01767227e-01f,
  -2.91125864e-01f, -4.08413589e-01f, 1.36524113e-02f, 8.46490338e-02f, -1.23126127e-01f, -3.23433354e-02f, -6.30011410e-02f, -1.07844710e-01f, -1.62901923e-01f, -5.11613712e-02f,
  -2.10571319e-01f, -4.02114242e-02f, -6.69006333e-02f, 3.73492651e-02f, -5.42857982e-02f, -1.72005475e-01f, -7.65197724e-02f, 4.22064506e-04f, 7.66467974e-02f, -3.91377369e-03f,
  1.15924470e-01f, -2.41564274e-01f, -2.85427690e-01f, -1.39111988e-02f, -3.45328078e-02f, -2.74127930e-01f, -2.31003001e-01f, -1.01116769e-01f, -4.29298133e-01f, -1.83391586e-01f,
  -7.20348880e-02f, 1.47897601e-01f, -5.29983044e-01f, 2.85605043e-01f, -2.93804090e-02f, -3.19868803e-01f, -3.80982667e-01f, -1.15372404e-01f, 3.12306345e-01f, 2.01290831e-01f,
  1.40233748e-02f, -2.58920789e-02f, 1.31769583e-01f, -3.18414241e-01f, -5.25822341e-01f, -3.61455798e-01f, -3.82579446e-01f, -4.99226779e-01f, -4.70191568e-01f, -4.10537601e-01f,
  -1.31491065e-01f, -1.05447128e-01f, -2.55917102e-01f, -6.97918981e-02f, 3.08279723e-01f, 1.54000178e-01f, 8.39198083e-02f, 6.36981707e-03f, -1.63007900e-01f, 8.46555531e-02f,
  -1.98035717e-01f, -2.08455607e-01f, -2.60861814e-02f, -2.82535274e-02f, 1.38634935e-01f, 1.57163050e-02f, 5.88405132e-02f, 1.70878664e-01f, 1.13166079e-01f, 8.64874199e-02f,
  -2.35811025e-02f, 8.07754323e-02f, 3.56874242e-02f, 1.23940120e-02f, -6.42000660e-02f, -1.64309859e-01f, 2.41128393e-02f, 1.88503414e-03f, 1.43360533e-02f, 5.06111421e-02f,
  -3.96769717e-02f, -2.43572146e-01f, -1.84464470e-01f, -2.62773335e-02f, -1.07824102e-01f, -5.20391501e-02f, 1.15302838e-01f, 9.50746387e-02f, -6.74403086e-02f, 2.87067771e-01f,
  -4.60395850e-02f, 1.33925125e-01f, -7.07935402e-03f, 2.40495373e-02f, 1.03841484e-01f, 9.94330794e-02f, -1.88770406e-02f, 1.97790876e-01f, 3.19389887e-02f, 5.24757318e-02f,
  8.60545337e-02f, 3.14021762e-03f, -3.37171694e-03f, -6.06717765e-02f, -8.45850483e-02f, -1.04577160e-02f, -1.34915300e-02f, 4.74139042e-02f, 3.24997562e-03f, -4.77945767e-02f,
  -1.09010115e-02f, 1.53759509e-01f, 1.23916686e-01f, 3.26181762e-02f, -8.02727491e-02f, 8.69857892e-02f, -2.67799273e-02f, -5.77812418e-02f, -6.07212260e-02f, -3.92705873e-02f,
  1.64666429e-01f, -4.08682346e-01f, 1.05416887e-01f, -3.59944478e-02f, 1.16762280e-01f, 1.61689669e-01f, 6.97108880e-02f, 1.09261386e-01f, 2.20396370e-01f, -1.33841764e-02f,
  -4.10504751e-02f, -2.55803880e-03f, -4.17723553e-03f, 4.30602692e-02f, 3.96107212e-02f, -1.91201732e-01f, 9.46917161e-02f, 5.29117025e-02f, -5.35869040e-02f, 3.61873031e-01f,
  1.64184883e-01f, 1.83607321e-02f, 4.95335571e-02f, 1.29545987e-01f, 4.16827090e-02f, -1.79956898e-01f, 6.07305653e-02f, -1.00391917e-02f, -1.41733199e-01f, 3.58738095e-01f,
  -3.45213145e-01f, -5.88010699e-02f, 3.69781673e-01f, 3.05786598e-02f, 2.37252846e-01f, -9.90952253e-02f, -4.07983482e-01f, -3.58384103e-01f, 1.04419827e-01f, 1.18829301e-02f,
  1.64875492e-01f, 2.78095037e-01f, 3.06103736e-01f, 8.11975151e-02f, -3.47452074e-01f, -2.02697828e-01f, 6.35694265e-02f, 1.02944158e-01f, -7.03262538e-02f, -1.83046147e-01f,
  1.73768960e-03f, -9.99832749e-02f, -2.00119346e-01f, -4.12763171e-02f, -2.78339684e-01f, 8.09513032e-02f, 3.10643320e-03f, -3.57240215e-02f, 5.21581136e-02f, -4.77259830e-02f,
  -8.25959221e-02f, -2.74437517e-01f, 2.13309780e-01f, 1.00682557e-01f, 1.20473675e-01f, -1.64797023e-01f, -6.92155287e-02f, -9.87945050e-02f, 1.86386600e-01f, -1.99732129e-02f,
  -4.26286384e-02f, 7.48982131e-02f, 9.18659121e-02f, -4.23653014e-02f, -2.18037620e-01f, -1.90376174e-02f, 8.20547193e-02f, -1.42000526e-01f, -1.51100203e-01f, -1.20720498e-01f,
  4.23514377e-03f, -2.20265538e-02f, -2.89656729e-01f, -1.01307891e-01f, -1.82380259e-01f, 1.15855867e-02f, -2.16188848e-01f, -3.62070292e-01f, -3.00742269e-01f, -5.90064764e-01f,
  1.35615662e-01f, 1.24749646e-01f, 2.09645540e-01f, -5.82323037e-02f, 1.22417189e-01f, 1.70607373e-01f, -4.58677597e-02f, 7.94887394e-02f, 6.24638163e-02f, -4.84182276e-02f,
  1.17133074e-01f, 7.97382444e-02f, -2.21750280e-03f, -1.87783483e-02f, 1.28530362e-03f, -3.33763622e-02f, 4.15680334e-02f, 2.62297373e-02f, -1.16011441e-01f, -7.32533261e-03f,
  3.55129912e-02f, -3.66610698e-02f, 1.29401475e-01f, -1.41973376e-01f, 3.25262845e-02f, 1.33234099e-01f, -8.81185159e-02f, 1.09611206e-01f, -5.74362278e-03f, 4.22445908e-02f,
  -4.48388644e-02f, 2.86658436e-01f, -6.62306696e-02f, 1.33176120e-02f, 9.02623534e-02f, 1.93896309e-01f, 8.51809084e-02f, 7.24408552e-02f, -5.56916967e-02f, -4.88296300e-02f,
  -1.51120290e-01f, -1.90667138e-01f, 1.04062387e-03f, 9.71566513e-02f, -1.66963220e-01f, -9.26273987e-02f, -5.25602065e-02f, -1.08928375e-01f, -5.87907583e-02f, -9.88875851e-02f,
  -6.10138252e-02f, -1.82795957e-01f, -3.16606224e-01f, -2.11060748e-01f, -2.02673092e-01f, -1.75942600e-01f, -1.63113847e-01f, -1.89949319e-01f, -2.84937739e-01f, -5.62889934e-01f,
  3.05770576e-01f, 2.70650476e-01f, 4.49219942e-01f, 1.41615212e-01f, -7.12446542e-03f, -3.87898475e-01f, -2.41111040e-01f, -3.72929215e-01f, -1.61878318e-01f, 1.65482178e-01f,
  1.85820639e-01f, -1.80186227e-01f, -2.76253130e-02f, -1.51967794e-01f, -3.89917463e-01f, -5.03368638e-02f, 9.92961600e-02f, -2.11120248e-01f, -5.33195913e-01f, -5.42435944e-01f,
  -2.45624676e-01f, 1.31142056e-02f, 9.01784524e-02f, -1.44262955e-01f, 2.66432285e-01f, -2.69393902e-02f, 4.20964807e-01f, 2.66786218e-01f, 2.16903076e-01f, 4.15233284e-01f,
  3.29656392e-01f, 3.96596491e-01f, -3.54170501e-01f, -5.04852049e-02f, -1.30951516e-02f, -1.34692162e-01f, 6.80259764e-02f, 3.71414423e-02f, -5.57475537e-02f, 1.83565423e-01f,
  1.39042303e-01f, -2.07686163e-02f, 5.96598201e-02f, -9.15249065e-02f, -9.80373994e-02f, -1.65546089e-01f, -4.45858724e-02f, -9.89902318e-02f, -1.64194152e-01f, 1.46089653e-02f,
  2.56103594e-02f, 1.68566301e-01f, 1.55455530e-01f, -1.40905008e-01f, -5.82262222e-03f, -1.27331302e-01f, -4.66905944e-02f, 8.05344582e-02f, -7.96454847e-02f, 1.64988980e-01f,
  -9.43451449e-02f, -2.43780036e-02f, 1.82633922e-02f, 7.27295727e-02f, -6.47266731e-02f, -1.09026153e-02f, 1.24132358e-01f, -4.35097404e-02f, -1.48941860e-01f, -7.24004433e-02f,
  -3.86442244e-02f, 8.48477930e-02f, -1.41249709e-02f, 1.97123095e-01f, 6.67425543e-02f, 8.67899582e-02f, -1.61014423e-01f, -8.94941315e-02f, 9.35514346e-02f, -4.55079833e-03f,
  -1.12199284e-01f, -8.43790174e-03f, 7.57089406e-02f, -7.26078153e-02f, 5.92143759e-02f, -4.70445380e-02f, 8.45996756e-03f, -3.74476835e-02f, -4.10693958e-02f, 6.66034818e-02f,
  -2.72751600e-01f, -1.37741521e-01f, 2.22641206e-03f, -1.97115704e-01f, -2.66398657e-02f, -6.07588775e-02f, 2.71538407e-01f, -2.41900049e-02f, 1.01501517e-01f, -1.04353800e-01f,
  -6.29034936e-02f, -5.60221355e-03f, 1.59128085e-01f, -2.06288025e-01f, -2.37386584e-01f, -3.40188679e-04f, -7.81001896e-02f, -1.51755735e-01f, -2.51971722e-01f, -9.16787311e-02f,
  -1.64941385e-01f, -3.42864841e-01f, -2.03025103e-01f, 8.18032119e-03f, 4.69776895e-03f, -2.62535304e-01f, -2.46836320e-01f, -2.58372903e-01f, -1.79037258e-01f, -2.81791091e-01f,
  8.44834447e-01f, -3.14874113e-01f, 3.32510412e-01f, 3.72523397e-01f, 7.79429004e-02f, 1.13480255e-01f, -6.98903203e-02f, 4.73064110e-02f, 7.10017011e-02f, -1.40646780e-02f,
  -5.32092638e-02f, 4.57534194e-02f, 5.92712089e-02f, 7.60155320e-02f, -2.96788965e-03f, 3.94512378e-02f, 1.06521167e-01f, 3.77391428e-01f, 3.63205969e-01f, 1.23502910e-01f,
  -3.26688997e-02f, 1.72546823e-02f, 1.64333522e-01f, 8.74723196e-02f, -1.31670609e-01f, 5.02992868e-02f, -6.22417443e-02f, -2.25690097e-01f, -1.77046254e-01f, -5.94636835e-02f,
  -1.36650026e-01f, 4.56258096e-03f, 1.46334916e-01f, -1.92448989e-01f, -1.98940739e-01f, 5.37254177e-02f, 1.23463254e-02f, 3.55953276e-02f, -1.37939319e-01f, -2.47461982e-02f,
  -8.50048512e-02f, -1.07187890e-01f, -8.91819745e-02f, -9.90319699e-02f, -8.13097134e-03f, -4.61877398e-02f, -1.83323696e-01f, 7.57102743e-02f, 1.25204027e-01f, -8.29687435e-03f,
  -1.44836634e-01f, -3.08445003e-03f, -5.00925444e-03f, 9.79086533e-02f, 2.80154869e-02f, 8.64714906e-02f, 5.41519746e-02f, -5.67226596e-02f, 6.87161786e-03f, 4.12898958e-02f,
  -4.16898951e-02f, 7.64091387e-02f, 6.23850860e-02f, 4.50029187e-02f, -1.02825306e-01f, 1.38353026e-02f, 1.14869468e-01f, 6.47618771e-02f, 9.33221057e-02f, -9.94684547e-02f,
  -1.17258869e-01f, 3.78615484e-02f, 1.56660676e-02f, 5.33509478e-02f, 7.13161156e-02f, -1.25085292e-02f, -9.89466347e-03f, -5.44009171e-02f, -6.31511770e-03f, 4.53214087e-02f,
  6.44208193e-02f, 1.15449183e-01f, 1.25137523e-01f, 1.25741675e-01f, -6.29496872e-02f, 1.41429916e-01f, 1.63783375e-02f, -5.40606268e-02f, -7.97168240e-02f, -5.31258620e-03f,
  -2.12898314e-01f, 1.15895979e-01f, 1.10203922e-01f, -2.63314489e-02f, -1.35371163e-01f, -8.15411359e-02f, 1.87831551e-01f, -6.62014857e-02f, -2.18984023e-01f, -8.08653608e-02f,
  -1.18454576e-01f, 9.00683701e-02f, -1.02621838e-01f, -8.31922814e-02f, -2.04337612e-02f, -1.21752605e-01f, -2.39938632e-01f, 1.57222480e-01f, 1.10758379e-01f, -4.48434912e-02f,
  -8.54347497e-02f, 8.17707554e-02f, 1.25166267e-01f, 1.09391421e-01f, 5.11282571e-02f, 1.22808002e-01f, 8.56330320e-02f, -3.18265408e-02f, 5.99168018e-02f, 1.91337794e-01f,
  3.54518265e-01f, -1.41440809e-01f, 6.51255846e-02f, 2.29999349e-01f, 9.00334939e-02f, 2.03111589e-01f, 2.15498269e-01f, 2.01922134e-01f, 1.87777415e-01f, 1.39249906e-01f,
  1.58020407e-01f, 2.30154201e-01f, 1.09849326e-01f, -1.76192576e-03f, 1.17109619e-01f, -2.17647757e-02f, 5.09780385e-02f, 6.90997317e-02f, 1.57057002e-01f, 1.24540426e-01f,
  -2.33310647e-02f, 1.15049828e-03f, -1.63405202e-02f, 7.68478364e-02f, -2.24485502e-01f, 1.04183011e-01f, -7.06053972e-02f, -1.29990712e-01f, -1.02102369e-01f, -3.83730769e-01f,
  8.86714384e-02f, -1.29632493e-02f, 2.17007637e-01f, 7.97330886e-02f, -1.78654119e-02f, 4.09179293e-02f, 4.51917611e-02f, 8.79264176e-02f, 2.37095654e-02f, 1.23541817e-01f,
  6.32581040e-02f, -1.22584216e-01f, -2.26050112e-02f, -4.91493288e-03f, -4.80215391e-03f, 2.47846078e-03f, 4.81177121e-02f, 1.29388735e-01f, 7.59004429e-02f, -8.91014206e-05f,
  -1.07511580e-01f, 1.06401235e-01f, 2.98387915e-01f, 1.31624281e-01f, 9.89941135e-03f, 5.39438613e-02f, 4.13776897e-02f, -1.16959279e-02f, 8.01588371e-02f, 1.00393151e-03f,
  2.38412246e-01f, 1.05908185e-01f, -4.10616696e-02f, 6.29938096e-02f, -9.39788595e-02f, 9.84963924e-02f, 2.63530645e-03f, -4.42674868e-02f, -1.85990147e-02f, -1.85069293e-01f,
  5.85648231e-02f, 2.06351411e-02f, 7.34165236e-02f, 1.92922086e-01f, 7.17054820e-03f, -2.77543743e-03f, -7.20786154e-02f, -1.09047685e-02f, -5.30962758e-02f, -5.70869558e-02f,
  -1.52722308e-02f, 1.46654531e-01f, 5.75522613e-03f, -1.80161968e-01f, 4.24750783e-02f, 2.46503167e-02f, -5.48259430e-02f, -2.57608611e-02f, -9.17235091e-02f, 1.49559796e-01f,
  2.96605498e-01f, -4.63915318e-02f, -1.37556478e-01f, -6.26085922e-02f, -1.90766022e-01f, -1.75892249e-01f, -6.33414537e-02f, -3.41199227e-02f, 8.18987861e-02f, 1.15570538e-01f,
  6.40168637e-02f, 2.50674840e-02f, -1.44402146e-01f, -1.32930756e-01f, 1.00733615e-01f, 3.85864526e-02f, -1.77300125e-01f, 3.08615491e-02f, -7.36830384e-02f, -3.04203145e-02f,
  -6.67496100e-02f, 1.56813294e-01f, 4.10861760e-01f, 1.21524021e-01f, -4.41472093e-03f, 2.18127474e-01f, 7.96537846e-02f, -4.42865230e-02f, 1.43233314e-01f, 1.81295469e-01f,
  -7.87681878e-01f, -1.61393918e-02f, -3.75426143e-01f, -4.43962663e-01f, -4.71120775e-01f, -2.66069710e-01f, -1.23575464e-01f, 4.34455238e-02f, -1.50538832e-01f, -1.86567575e-01f,
  -1.20935731e-01f, -2.52666827e-02f, 1.00846797e-01f, 3.80059257e-02f, -1.23796007e-02f, -1.45242825e-01f, -3.28547567e-01f, -3.91751647e-01f, -2.40679845e-01f, -1.06836095e-01f,
  -1.08161867e-01f, -2.35312864e-01f, -3.45908284e-01f, -5.62126115e-02f, 1.68045014e-01f, 6.81773946e-02f, -1.35532394e-01f, -1.00753874e-01f, -1.40210921e-02f, -1.48899719e-01f,
  2.38775849e-01f, -1.78207442e-01f, -3.95426154e-02f, -1.04888827e-01f, -4.09044661e-02f, -3.85010540e-02f, -6.65231720e-02f, -4.45747077e-02f, -9.62897539e-02f, 3.26977745e-02f,
  -1.50115967e-01f, -1.41477808e-02f, -2.91568264e-02f, 9.97896120e-03f, -5.51538430e-02f, -8.35392475e-02f, -9.91350338e-02f, -9.53025222e-02f, 9.69364643e-02f, 1.33269101e-01f,
  1.05463281e-01f, -1.66381061e-01f, -8.70044157e-03f, 8.29377919e-02f, 1.29974991e-01f, -1.79818287e-01f, 2.03067422e-01f, 2.72218062e-06f, 7.03989789e-02f, 1.83133632e-01f,
  1.09698409e-02f, 2.44036779e-01f, 1.03804149e-01f, -5.90779483e-02f, -4.55141291e-02f, -9.54878703e-03f, 7.85146430e-02f, 9.67418104e-02f, 2.47288588e-03f, -4.89303581e-02f,
  4.59241457e-02f, 6.64687455e-02f, 6.08499758e-02f, -4.79945093e-02f, 2.09404975e-02f, -1.57081544e-01f, 3.03952508e-02f, 1.29282936e-01f, -3.91363949e-02f, -6.39337301e-02f,
  -1.09522425e-01f, -2.62809489e-02f, -8.17627832e-03f, 1.83017716e-01f, 7.08903000e-02f, -2.38214191e-02f, -1.10173598e-01f, -2.94463690e-02f, 2.08932478e-02f, -9.18106958e-02f,
  2.77257830e-01f, -2.78122455e-01f, 2.72570737e-02f, 1.20004505e-01f, -1.88166261e-01f, -6.19012155e-02f, 4.16976884e-02f, -3.45309228e-02f, 4.04201075e-03f, -1.98095497e-02f,
  -8.23229272e-03f, 2.11087931e-02f, -7.08243102e-02f, 8.97353217e-02f, -1.01434402e-01f, -1.56883329e-01f, -9.82864350e-02f, 1.08655043e-01f, 8.68369918e-03f, 1.16688274e-01f,
  -6.94919452e-02f, 1.65292807e-02f, 1.03660740e-01f, 2.60669202e-01f, 1.44117713e-01f, -1.99677367e-02f, 1.87287822e-01f, 1.70600206e-01f, 1.13805696e-01f, 2.96832144e-01f,
  -4.67412531e-01f, -3.04095000e-01f, -2.94323355e-01f, 2.97991186e-01f, 3.78842652e-01f, 2.48388544e-01f, 1.18464150e-01f, 5.23015149e-02f, 2.20882848e-01f, 1.32103026e-01f,
  1.27805039e-01f, 2.63052970e-01f, 2.42862761e-01f, 2.64192104e-01f, 1.29257262e-01f, 1.42338485e-01f, 1.51064098e-01f, -6.59167320e-02f, 1.97136581e-01f, 2.95350701e-01f,
  3.06397438e-01f, -8.84156376e-02f, -2.80153424e-01f, 1.20302603e-01f, 3.90330553e-02f, 3.08343798e-01f, -8.09580684e-02f, -2.07981408e-01f, 4.76188259e-03f, 2.10614368e-01f,
  -2.77343601e-01f, -4.60054964e-01f, 2.04765648e-01f, 6.11177608e-02f, -5.92631139e-02f, -3.72990966e-02f, 7.94776678e-02f, -1.77480504e-01f, -8.83089320e-04f, -6.83634803e-02f,
  -2.96588847e-03f, -1.32309973e-01f, 3.59278530e-01f, 1.22541167e-01f, -4.34733629e-02f, 7.51031637e-02f, 1.92863103e-02f, -2.68745810e-01f, -1.36061877e-01f, -5.10536358e-02f,
  4.09096152e-01f, -1.10296324e-01f, -4.36046898e-01f, 1.46154746e-01f, 9.97488350e-02f, 1.47454143e-01f, -1.47042632e-01f, -2.61636287e-01f, -2.00482458e-01f, -3.67980450e-01f,
  1.44463778e-01f, -5.71002662e-02f, 2.30389759e-02f, -1.38641775e-01f, -1.39612872e-02f, -2.61422805e-02f, 1.10719621e-01f, 7.75710121e-03f, -1.21246628e-01f, -2.20212579e-01f,
  4.08536717e-02f, 4.80743349e-02f, 5.17859086e-02f, 1.92395244e-02f, 1.30821317e-01f, -1.31595746e-01f, -2.95872986e-02f, 7.81042874e-02f, -4.15408127e-02f, -1.39631391e-01f,
  -1.15937404e-01f, -1.03722237e-01f, -7.21089169e-02f, 9.61534604e-02f, 1.71192184e-01f, 1.87232941e-01f, 6.70920014e-02f, 2.42584974e-01f, 1.19030979e-02f, -1.68275490e-01f,
  -3.36167999e-02f, 7.77054578e-03f, 3.05444170e-02f, 7.15445261e-04f, -1.47298276e-01f, 3.26940231e-02f, -5.68653978e-02f, -3.39432340e-03f, -4.12195809e-02f, 9.43087116e-02f,
  -9.77547243e-02f, -7.24575222e-02f, 9.29301009e-02f, -4.53548913e-04f, 2.01710816e-02f, -7.01106340e-02f, -1.36592850e-01f, -4.60678972e-02f, -1.06873333e-01f, -1.19528165e-02f,
  -1.62061509e-02f, -1.76838055e-01f, -2.61009753e-01f, -5.99990003e-02f, -3.96437161e-02f, 6.98134303e-02f, -1.73002273e-01f, -2.28911281e-01f, -1.56652674e-01f, -2.51047648e-02f,
  -3.12331200e-01f, -5.37208557e-01f, -3.15845191e-01f, 2.50882894e-01f, 2.52481457e-02f, -5.64083695e-01f, -7.67299056e-01f, -5.42986631e-01f, 9.49628577e-02f, -1.28963158e-01f,
  1.74216814e-02f, 3.21102560e-01f, 1.33202180e-01f, 8.91248658e-02f, -3.42061758e-01f, -2.73048043e-01f, -3.08962651e-02f, 5.78638241e-02f, 3.67658474e-02f, 5.05649894e-02f,
  4.41677600e-01f, 2.67261684e-01f, 3.00575078e-01f, 2.14527979e-01f, 3.27918917e-01f, 2.79242307e-01f, 1.23060355e-02f, 1.96843922e-01f, -1.15670741e-01f, 3.00890595e-01f,
  4.05980311e-02f, -1.39999360e-01f, -5.36396131e-02f, 1.59139886e-01f, -1.17670856e-02f, -9.22956988e-02f, -1.08418189e-01f, 5.95187582e-02f, -5.54936714e-02f, 6.04009070e-02f,
  2.11459100e-01f, -8.31719395e-03f, 2.86933452e-01f, 1.95515111e-01f, 1.61497846e-01f, -7.37739727e-02f, -5.56534976e-02f, -1.13104522e-01f, -2.01621369e-01f, -2.23121792e-01f,
  3.41896594e-01f, 1.51870251e-01f, -4.66555268e-01f, -3.53212893e-01f, -1.34768605e-01f, 1.92949951e-01f, -1.73759684e-01f, 5.06077856e-02f, -2.38060027e-01f, -1.44891456e-01f,
  -1.26229525e-01f, -5.36022894e-02f, -7.89094120e-02f, -1.27259657e-01f, -8.01547319e-02f, 6.97584897e-02f, 8.91644787e-03f, 9.66871977e-02f, 1.72543466e-01f, -1.83708638e-01f,
  -6.25797287e-02f, 8.42237845e-03f, 7.29289055e-02f, -2.31444836e-02f, 7.04124421e-02f, 2.94545852e-02f, 1.73325296e-02f, -1.59469545e-02f, -2.43080710e-03f, -7.53140152e-02f,
  4.85624820e-02f, 1.81552358e-02f, 2.02911496e-01f, 1.01564825e-01f, -1.00295328e-01f, -1.04985535e-01f, 1.11232609e-01f, 2.88413335e-02f, 1.40474970e-02f, -3.13358419e-02f,
  1.55332372e-01f, -9.90744010e-02f, -4.19217302e-03f, -8.45208764e-02f, 8.40688497e-02f, -6.59558699e-02f, -6.46268250e-04f, -1.20558247e-01f, 6.78672045e-02f, -2.92813666e-02f,
  -2.21072778e-01f, 3.27923037e-02f, 9.94995534e-02f, 9.01792496e-02f, 6.98447600e-02f, -5.16415611e-02f, -1.72838807e-01f, -8.97597447e-02f, 3.88507210e-02f, 1.61469460e-01f,
  -1.82638243e-01f, -1.32749543e-01f, -2.98834205e-01f, -3.69822562e-01f, -5.36097661e-02f, -2.66352296e-01f, -7.18833357e-02f, -1.70659468e-01f, -5.37509799e-01f, -5.63185990e-01f,
  -4.71028835e-01f, -2.85217404e-01f, 1.87667273e-02f, -6.44265592e-01f, -3.42589617e-01f, -1.76433548e-01f, -2.22716331e-01f, -1.41025692e-01f, -3.33436877e-01f, -4.35803771e-01f,
  -1.89015642e-01f, -2.88955756e-02f, -9.37901884e-02f, 2.03012094e-01f, 2.50490338e-01f, -2.41546839e-01f, -3.19474973e-02f, 2.74385154e-01f, 4.79654133e-01f, 1.47330120e-01f,
  -8.61364752e-02f, -1.89644232e-01f, 2.01917350e-01f, 7.88824111e-02f, -5.45954704e-01f, -7.09833577e-02f, -2.46291488e-01f, -7.57558718e-02f, -2.11122297e-02f, -3.44101369e-01f,
  -1.93871096e-01f, -1.29083738e-01f, 9.91602466e-02f, 8.58057663e-02f, -2.32353762e-01f, 2.64602043e-02f, -1.66918933e-02f, -1.38543665e-01f, 3.23268101e-02f, -6.98683411e-02f,
  -1.01000383e-01f, 1.58251032e-01f, -1.02555398e-02f, -9.82385781e-03f, 3.51268612e-02f, -5.87945767e-02f, -8.92992467e-02f, 1.90959364e-01f, 7.31791183e-02f, -9.51973721e-02f,
  -4.20460366e-02f, -9.76110175e-02f, 7.23615661e-02f, 4.09201495e-02f, -1.10199973e-02f, 6.44416884e-02f, 8.51415098e-02f, 2.14104012e-01f, 2.92727113e-01f, -3.25045556e-01f,
  3.47438678e-02f, -2.87900660e-02f, 6.11503348e-02f, 7.75873810e-02f, -8.98602651e-04f, 2.56716311e-02f, 9.51839834e-02f, -4.12318073e-02f, 2.26902626e-02f, -9.95266512e-02f,
  6.43502474e-02f, -2.18634922e-02f, -4.38387878e-03f, -1.55772911e-02f, 1.93242310e-03f, -1.18841812e-01f, 6.84573641e-03f, -5.06770946e-02f, 4.71412241e-02f, 2.91357618e-02f,
  9.89502817e-02f, -5.98686077e-02f, -1.79244280e-02f, 6.45098463e-02f, 6.48158509e-03f, -2.86862366e-02f, -4.40749750e-02f, -7.30345258e-03f, -1.09760322e-01f, 5.39282560e-02f,
  -3.24169278e-01f, 4.06496286e-01f, -3.49236488e-01f, 2.62456033e-02f, -5.77489324e-02f, 6.08165301e-02f, -1.06422670e-01f, -7.57683394e-03f, -1.06608020e-02f, -2.76318733e-02f,
  1.73814505e-01f, -8.57610703e-02f, -6.47681952e-02f, 1.80143733e-02f, -1.02312207e-01f, 3.02609652e-02f, 3.25933583e-02f, -5.88822663e-02f, 1.44755214e-01f, -3.76776233e-03f,
  1.43701330e-01f, -5.90521805e-02f, -8.65282938e-02f, -5.98149523e-02f, -5.11457995e-02f, -3.11899874e-02f, 4.13756967e-02f, 6.85272412e-03f, 2.14128286e-01f, -2.31949583e-01f,
  5.96417010e-01f, 3.53886783e-01f, 4.31711495e-01f, 2.13823721e-01f, 1.35652646e-01f, 1.48012608e-01f, 3.44872952e-01f, 2.04419851e-01f, 5.75693883e-03f, 9.40060765e-02f,
  8.25504363e-02f, -1.19374126e-01f, 6.56260103e-02f, 1.04143612e-01f, 1.97766110e-01f, 1.49472386e-01f, 1.31413534e-01f, 3.30343902e-01f, 1.76423952e-01f, 9.61043537e-02f,
  -5.34138409e-03f, 2.58212537e-01f, 3.51790696e-01f, 1.49681956e-01f, 1.85867801e-01f, -9.06313509e-02f, 3.75774503e-02f, 1.76620215e-01f, 9.48838517e-02f, 2.16364428e-01f,
  9.08939093e-02f, 3.26649368e-01f, -3.42052549e-01f, -4.81200963e-02f, -3.10634468e-02f, -4.39326800e-02f, -5.31585552e-02f, 1.34008974e-01f, 3.42766009e-02f, -6.26059398e-02f,
  -8.80585387e-02f, 1.87101826e-01f, 2.06853747e-01f, 2.14382380e-01f, 9.57286805e-02f, 1.06195793e-01f, 5.84661067e-02f, 1.42255634e-01f, 3.20088454e-02f, -3.54215465e-02f,
  3.14691812e-02f, 3.16325054e-02f, 8.59431252e-02f, -4.50260378e-02f, 1.84431121e-01f, -1.00259580e-01f, -7.98253715e-02f, 1.71969272e-02f, 5.83443604e-02f, 2.66289618e-02f,
  -2.65355915e-01f, -7.86681473e-02f, 4.64091748e-02f, 4.41768467e-02f, 5.49726076e-02f, -2.54794434e-02f, 1.41897844e-02f, 1.16081610e-02f, 2.24655911e-01f, 1.44239634e-01f,
  6.02670424e-02f, 1.61991015e-01f, 1.40227243e-01f, -3.83531861e-02f, -1.53566405e-01f, 8.21504816e-02f, 1.44864962e-01f, 9.20353159e-02f, -8.23046546e-03f, 5.74299358e-02f,
  2.14474246e-01f, 6.47714883e-02f, 1.06928974e-01f, 2.51604438e-01f, 7.96000194e-03f, -1.33353546e-01f, 9.31824520e-02f, 2.04985831e-02f, -6.13800948e-03f, -5.52494377e-02f,
  -3.16045493e-01f, -1.41728938e-01f, -2.05301777e-01f, 4.51970585e-02f, 2.75099538e-02f, 2.56230123e-02f, 1.44265294e-02f, -9.60180983e-02f, -1.25064343e-01f, -9.59794596e-02f,
  2.94155963e-02f, -6.89878911e-02f, 1.37433901e-01f, 1.49324343e-01f, -7.06343427e-02f, -1.47872433e-01f, -1.18571088e-01f, 1.68108027e-02f, -6.46778420e-02f, -6.51070029e-02f,
  -1.97981857e-02f, -4.06600349e-02f, -9.99204293e-02f, -2.27280870e-01f, -5.81162386e-02f, -3.40291232e-01f, -1.93258062e-01f, -3.34983468e-02f, -1.79983273e-01f, -1.20470934e-01f,
  -2.92238623e-01f, -1.95712954e-01f, -3.12275529e-01f, -3.00554931e-01f, -2.96964347e-01f, -1.98844284e-01f, 1.01549894e-01f, -1.62949890e-01f, -2.11211964e-01f, 2.23134607e-01f,
  2.59470671e-01f, 4.00694221e-01f, 3.55845600e-01f, 2.99285978e-01f, 1.82554454e-01f, 4.10084426e-02f, -3.96357477e-01f, -1.07692286e-01f, 2.20219091e-01f, 2.89130598e-01f,
  2.22269326e-01f, 2.22289547e-01f, 1.97157323e-01f, 2.73325182e-02f, 4.17178050e-02f, 1.54505149e-01f, -1.36887476e-01f, -1.87767431e-01f, 3.62678580e-02f, -4.72790271e-01f,
  5.00476122e-01f, -4.19902414e-01f, -1.11459874e-01f, -1.40650094e-01f, -2.83861365e-02f, -1.26288265e-01f, -4.88379300e-02f, -2.10261971e-01f, -1.00157842e-01f, 3.84472869e-02f,
  -8.47405195e-02f, 2.57545169e-02f, 7.55400397e-04f, 3.23064663e-02f, 6.12805970e-02f, 1.63531989e-01f, -7.27419257e-02f, -1.69039100e-01f, -1.52498126e-01f, 1.52631879e-01f,
  -9.81484540e-03f, -3.18141319e-02f, 1.03657357e-01f, -9.55464691e-02f, -5.48785478e-02f, -4.78515178e-02f, 7.43387341e-02f, -3.52764651e-02f, -7.31741488e-02f, -2.30357125e-01f,
  -1.34250252e-02f, 1.04443766e-01f, -1.11665830e-01f, -4.39139903e-02f, 1.03744669e-02f, -5.82054630e-02f, 1.81795191e-02f, 9.69527811e-02f, 4.74012084e-03f, 4.62200902e-02f,
  -7.18046203e-02f, 3.61772999e-03f, -4.78372052e-02f, 3.30630355e-02f, 6.20171987e-02f, 2.70916987e-02f, -9.34034307e-03f, 1.12183802e-01f, -1.10384613e-01f, -2.71944068e-02f,
  -5.63992299e-02f, 1.54556083e-02f, -1.24607990e-02f, -5.91843054e-02f, -1.04470670e-01f, -9.80013534e-02f, -3.43816467e-02f, 5.42246513e-02f, 7.59641454e-02f, 1.03673369e-01f,
  3.50400031e-01f, -2.67739058e-01f, 1.72838762e-01f, 4.32665311e-02f, -2.00125694e-01f, -1.16123175e-02f, -1.36522204e-01f, -1.18622042e-01f, -2.85719752e-01f, -6.80452771e-03f,
  -1.16659112e-01f, 1.90486386e-02f, -3.57609503e-02f, 1.21734748e-02f, 4.78537269e-02f, -2.37526000e-02f, 2.98563186e-02f, -5.88555709e-02f, -1.05797082e-01f, 6.25719801e-02f,
  2.18265001e-02f, -1.37471706e-01f, 2.23655447e-01f, -1.33024510e-02f, -6.15671612e-02f, 4.21625115e-02f, 2.88223505e-01f, 1.72743022e-01f, 9.97694731e-02f, 1.13845006e-01f,
  3.99687946e-01f, 2.23817036e-01f, 1.55328602e-01f, 3.45793694e-01f, 1.84191167e-01f, 6.77001700e-02f, 9.61621925e-02f, 6.16544038e-02f, 1.57575533e-01f, 2.10521504e-01f,
  2.43520617e-01f, 3.61967236e-01f, 2.24734351e-01f, 1.59690738e-01f, 1.30613238e-01f, 1.04975171e-01f, 1.09362595e-01f, 1.25965357e-01f, 8.83595198e-02f, 1.93055883e-01f,
  1.56324089e-01f, 2.03302473e-01f, 1.75861016e-01f, 2.15437040e-01f, 1.11568965e-01f, 1.40178755e-01f, 9.63332877e-02f, 1.30228087e-01f, 1.39844388e-01f, 3.31177473e-01f,
  9.39797387e-02f, 1.38180792e-01f, 1.05465427e-01f, -7.57453917e-03f, -1.35999266e-02f, -1.57569200e-01f, -6.06421530e-02f, -2.00785443e-01f, -1.10566162e-01f, -1.41669303e-01f,
  1.84183344e-02f, -1.11669667e-01f, -3.50904129e-02f, -8.57777894e-02f, -1.38407171e-01f, -1.95672333e-01f, -2.40862779e-02f, -4.40068990e-02f, 8.47349167e-02f, -9.68966354e-03f,
  5.21857776e-02f, -6.72245547e-02f, 3.38610969e-02f, 7.19298720e-02f, 3.20443697e-02f, 2.80667543e-02f, -2.06072628e-02f, -3.91512625e-02f, 6.96298406e-02f, 1.44850630e-02f,
  4.42386359e-01f, 2.79909760e-01f, 1.94385722e-01f, 2.11136669e-01f, 8.52717236e-02f, -4.88814265e-02f, -7.88086653e-02f, 4.35284823e-02f, 7.73550346e-02f, -1.11723706e-01f,
  -1.26171932e-01f, 8.75972137e-02f, 5.50108664e-02f, 7.12192431e-02f, 2.07958892e-02f, -4.40977775e-02f, -2.84412913e-02f, -2.72886939e-02f, -1.30615771e-01f, -2.40515359e-02f,
  -1.72809497e-01f, -1.07436381e-01f, -1.59483805e-01f, -1.98799387e-01f, -1.30956337e-01f, 3.37157212e-02f, -1.10261649e-01f, 3.03836688e-02f, 5.69706112e-02f, -1.14314025e-02f,
  -3.41402590e-01f, 5.52461743e-02f, 7.86892548e-02f, -9.30543989e-02f, 6.99311942e-02f, -2.49250736e-02f, 1.98019251e-01f, 1.95423178e-02f, -1.17473602e-02f, 4.35669795e-02f,
  -6.33605346e-02f, -9.13997460e-03f, 2.88114436e-02f, -7.18005672e-02f, -2.31311336e-01f, -1.20499022e-01f, -5.67506216e-02f, 2.90884520e-04f, 1.37705341e-01f, -3.98028307e-02f,
  -1.27715901e-01f, -2.48359982e-02f, -7.65464306e-02f, -1.33914977e-01f, -2.97952481e-02f, 5.94660193e-02f, -2.09305007e-02f, -8.80689844e-02f, -1.71208799e-01f, -1.40678167e-01f,
  1.79829806e-01f, -1.30348787e-01f, 1.82269365e-01f, 4.65962775e-02f, -3.98681849e-01f, -6.04362249e-01f, -7.23658144e-01f, -5.01064122e-01f, -2.01756582e-01f, -6.61054254e-02f,
  7.40304310e-03f, 1.67262122e-01f, 1.10520966e-01f, 5.98244481e-02f, 3.00658364e-02f, -9.14865956e-02f, 1.11991949e-01f, 3.55347544e-01f, 1.90552145e-01f, 5.37336618e-02f,
  1.38640270e-01f, 3.29152316e-01f, 3.67785633e-01f, 2.23497242e-01f, 1.11238480e-01f, -9.04450342e-02f, 3.95922223e-03f, 2.67198741e-01f, 1.15036920e-01f, 4.57455724e-01f,
  4.64111626e-01f, -8.22350532e-02f, -7.79664442e-02f, 1.23429649e-01f, 1.61932334e-01f, 1.08820498e-01f, -4.12054658e-02f, 2.45469347e-01f, -8.76479670e-02f, 1.32619157e-01f,
  8.76543149e-02f, 1.31367296e-01f, -2.14505121e-01f, -3.25459950e-02f, -4.67704162e-02f, -1.70643136e-01f, 1.80395946e-01f, 1.66083604e-01f, 1.10870544e-02f, 3.65976873e-03f,
  1.73200756e-01f, 1.52707577e-01f, -1.64479733e-01f, -2.47825384e-01f, -2.63383269e-01f, 2.28259759e-03f, -1.97623104e-01f, -7.70562738e-02f, -1.93230778e-01f, 8.61566961e-02f,
  1.65745422e-01f, 7.50361234e-02f, 6.94992170e-02f, 8.35205540e-02f, -6.58495585e-03f, 4.90212254e-02f, 6.17113672e-02f, 4.69805524e-02f, 5.43623678e-02f, -3.36464830e-02f,
  -1.24145634e-01f, -5.53584397e-02f, 5.20044789e-02f, 8.82803649e-03f, -9.57603082e-02f, 7.05327690e-02f, -8.59781206e-02f, -3.17947790e-02f, -1.18844688e-01f, 3.34045701e-02f,
  -5.91707677e-02f, -9.41709131e-02f, 2.05478203e-02f, -3.46620008e-02f, -2.60010250e-02f, 7.92524964e-02f, 7.46406987e-02f, -1.45637661e-01f, 3.82433757e-02f, 7.43358582e-02f,
  -1.67997897e-01f, -5.35204262e-02f, 1.02903225e-01f, 1.19694933e-01f, 3.41653079e-02f, -1.27109706e-01f, 7.01587647e-03f, -2.31519807e-02f, -1.32709235e-01f, 2.09856033e-02f,
  -1.69179112e-01f, -6.52641281e-02f, -9.00210366e-02f, -2.63455920e-02f, -3.69189754e-02f, -9.40189883e-02f, 8.76538232e-02f, -4.35749702e-02f, -8.71953368e-02f, -1.54424518e-01f,
  -2.21579731e-01f, -2.74123520e-01f, -1.96537495e-01f, -3.42955589e-01f, -8.33733603e-02f, -2.94798166e-01f, -1.66050524e-01f, -2.90555745e-01f, -3.80600393e-01f, -2.62765050e-01f,
  4.47911888e-01f, -4.50012565e-01f, -3.32563043e-01f, 2.36166388e-01f, 4.83340472e-02f, 6.10827580e-02f, -1.43529242e-02f, 3.79187949e-02f, 2.01094836e-01f, 2.34964173e-02f,
  1.59405485e-01f, 3.40594113e-01f, 2.69464284e-01f, 2.06948996e-01f, 1.20629743e-01f, 6.78112730e-02f, 9.41168591e-02f, 7.34460540e-03f, 1.78514078e-01f, 1.41395032e-01f,
  -1.08455596e-02f, -1.77759692e-01f, -8.21730494e-02f, 5.88350780e-02f, -1.85560063e-01f, 1.04388222e-01f, -9.75567847e-02f, -1.64904103e-01f, -2.67009884e-01f, -1.15548976e-01f,
  -1.61158800e-01f, -4.58469465e-02f, 2.19310850e-01f, 1.63924675e-02f, -1.50642693e-01f, 6.10788018e-02f, 2.37323977e-02f, -8.74083787e-02f, -6.72789663e-02f, 8.53715756e-04f,
  -6.35966733e-02f, -1.40132308e-01f, -3.83314975e-02f, -1.18726030e-01f, -1.27617627e-01f, -1.72680303e-01f, 1.74930897e-02f, 1.68457583e-01f, 8.01964924e-02f, 6.00400157e-02f,
  4.50878218e-02f, -1.20216860e-02f, -3.02546397e-02f, 1.58463150e-01f, 1.69294387e-01f, 2.42189243e-01f, -4.45181914e-02f, -3.31876911e-02f, 1.46937653e-01f, 5.25196604e-02f,
  1.81156695e-01f, -2.67114546e-02f, -1.76102147e-02f, 1.56403497e-01f, 4.68029901e-02f, -2.20525358e-02f, -4.51153778e-02f, 6.16285950e-02f, 7.61692300e-02f, 1.55331017e-02f,
  -1.50998961e-02f, 1.17468067e-01f, 1.78927705e-01f, 1.73354104e-01f, -4.86102402e-02f, -2.31969636e-02f, -9.45656151e-02f, -8.40286836e-02f, -7.77066872e-02f, -1.22101400e-02f,
  2.59934310e-02f, -1.14006013e-01f, -2.00843319e-01f, -1.21664017e-01f, -5.00064567e-02f, 4.96180579e-02f, 4.31347005e-02f, 6.74855784e-02f, 3.98174562e-02f, -9.27367900e-03f,
  -5.26554212e-02f, 2.20002621e-01f, 2.04107568e-01f, 4.55166027e-02f, -1.15250960e-01f, -1.61431998e-01f, 1.68535545e-01f, -1.63758844e-01f, -3.03785264e-01f, -2.67557334e-02f,
  -1.86459452e-01f, -9.83463451e-02f, -1.75331205e-01f, 1.59367844e-02f, 6.59809411e-02f, -8.78618658e-02f, -9.88404006e-02f, 1.08116932e-01f, -3.21763679e-02f, -1.14957802e-01f,
  -1.69640869e-01f, 1.72032610e-01f, 2.26818681e-01f, 1.48492217e-01f, 1.27799809e-01f, 1.25558168e-01f, -6.24347758e-03f, -1.01913996e-01f, 2.67537282e-04f, 1.02944419e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  3.01192105e-01f, 2.49041736e-01f, 1.57656312e-01f, 3.69125277e-01f, 5.01513183e-01f, 5.62936217e-02f, 4.48721081e-01f, 1.71060517e-01f, 3.06107342e-01f, 3.86364162e-01f,
  -3.05397063e-01f, 5.13622761e-01f, 1.31436691e-01f, 2.47327730e-01f, 2.66361684e-01f, 3.55449975e-01f, 3.53410214e-01f, 4.64545280e-01f, 1.50286436e-01f, 1.42455429e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.19477421e-01f, -6.35858625e-02f, 8.26566368e-02f, -1.51274920e-01f, 8.86841938e-02f, -1.21741623e-01f, 2.23095462e-01f, 2.28376519e-02f, 1.76957697e-01f, 7.93233141e-02f,
  -1.92298032e-02f, -3.32664810e-02f, -1.36487767e-01f, -9.68622714e-02f, -1.59393236e-01f, -1.40177429e-01f, 1.55368567e-01f, 2.76589721e-01f, -1.36903182e-01f, 4.11095843e-02f,
  2.81093925e-01f, 4.39254660e-03f, 1.07074723e-01f, -1.83008146e-02f, 2.55768061e-01f, -3.67818415e-01f, 1.46680191e-01f, -2.18220606e-01f, -4.76929426e-01f, 4.20033559e-02f,
  -1.76198125e-01f, 2.44161978e-01f, 3.05412197e-03f, -1.17126722e-02f, 1.05672389e-01f, -3.05938330e-02f, 5.80659322e-03f, 2.06038356e-01f, 1.19314462e-01f, 4.94912192e-02f,
  2.15605184e-01f, -5.44044673e-02f, -1.76329073e-02f, 1.08290091e-01f, 1.74418628e-01f, -4.31214236e-02f, 3.00718248e-02f, 3.84911299e-01f, -6.98077306e-02f, -3.89480978e-01f,
  -1.56721562e-01f, 1.48427695e-01f, -1.79572120e-01f, -6.82457611e-02f, 2.29005858e-01f, 1.20650873e-01f, -2.19270382e-02f, -5.05166233e-01f, 2.92157382e-01f, -1.37347691e-02f,
  2.29583710e-01f, 1.03124380e-01f, -1.56234860e-01f, -1.75016955e-01f, 4.61944379e-02f, 1.63317710e-01f, -3.86253037e-02f, 1.01434879e-01f, 9.38113313e-03f, 6.89814389e-02f,
  -1.63734496e-01f, -1.53667241e-01f, -3.80189776e-01f, -2.69881971e-02f, 2.04779759e-01f, -1.81975767e-01f, -2.01714486e-01f, 6.53446093e-02f, -1.30468279e-01f, 2.18654320e-01f,
  3.31872106e-01f, 3.26675773e-01f, -1.32663757e-01f, -5.07803783e-02f, -2.89959967e-01f, 3.16710398e-02f, 2.23225370e-01f, -1.83038548e-01f, 2.99382895e-01f, 1.78614631e-01f,
  3.60181451e-01f, -2.13964581e-01f, -4.01594847e-01f, -3.80225480e-03f, 3.72225553e-01f, -5.96350543e-02f, 3.98723446e-02f, -2.44196262e-02f, 6.71059266e-03f, -1.14384286e-01f,
  1.03891931e-01f, -2.11823676e-02f, 6.13006055e-02f, 1.44202426e-01f, 1.03100166e-01f, 9.93901044e-02f, -7.05066174e-02f, 1.31567895e-01f, -1.01812989e-01f, -2.64833957e-01f,
  2.51937270e-01f, -1.49736777e-01f, -5.77213988e-02f, 2.92261451e-01f, -3.03550046e-02f, 5.49440272e-02f, 1.92152634e-02f, -1.47308141e-01f, 2.68288583e-01f, -1.48214981e-01f,
  2.79552519e-01f, -3.41414809e-01f, -7.56729171e-02f, -1.66314587e-01f, -3.01340371e-01f, -1.95480242e-01f, -4.27960940e-02f, 1.63236875e-02f, 1.84399590e-01f, 2.13874057e-01f,
  -5.37170991e-02f, -1.28660977e-01f, -1.51157826e-01f, 2.24018008e-01f, -5.71173988e-03f, 2.33579859e-01f, -1.17233247e-01f, -9.72624570e-02f, -4.53970805e-02f, 1.60671934e-01f,
  2.18472064e-01f, -4.46512457e-03f, 7.63369128e-02f, 1.07961230e-01f, -5.45730114e-01f, -3.25115651e-01f, 1.41246766e-01f, -1.18612386e-01f, 5.76316155e-02f, 2.34350432e-02f,
  -1.45536467e-01f, 1.36666477e-01f, 5.86046986e-02f, 1.25159085e-01f, -8.68934989e-02f, -5.86012006e-03f, 2.38585055e-01f, 9.61817279e-02f, 2.28268243e-02f, 1.44060850e-01f,
  -1.32989138e-01f, 3.06666382e-02f, 1.28222391e-01f, 1.37876496e-01f, 4.36017476e-02f, 1.41448170e-01f, 9.69448164e-02f, -1.24297582e-01f, 1.67723611e-01f, 2.74581295e-02f,
  -1.07097439e-01f, 7.43240304e-03f, -1.02704100e-01f, -2.23380119e-01f, -3.81343663e-02f, -2.70224929e-01f, -2.31372058e-01f, -1.14069730e-01f, -3.52097787e-02f, -1.38821721e-01f,
  4.03036177e-01f, -1.36885568e-01f, 2.53263693e-02f, 2.90227115e-01f, -5.33370495e-01f, -1.37030616e-01f, 6.67842701e-02f, 1.24261335e-01f, 7.58303851e-02f, 9.58598331e-02f,
  4.29176956e-01f, -4.51652795e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.35651493e-01f, 7.54302070e-02f, 8.18359479e-02f, 6.19058870e-02f, 8.79461020e-02f, 1.68534532e-01f, 3.91977310e-01f, -6.97986735e-03f, 2.58963972e-01f, -3.70371193e-01f,
  7.33808726e-02f, 2.83921361e-01f, -1.72550812e-01f, 5.87825887e-02f, -1.63923115e-01f, 3.50744724e-01f, 5.52062750e-01f, -7.18134642e-02f, -1.01025410e-01f, -1.11865088e-01f,
  -5.63003421e-01f, 2.98601925e-01f, -2.65209168e-01f, 3.72348964e-01f, 3.23868096e-02f, -2.67831564e-01f, 2.26233378e-01f, 6.48878142e-02f, 7.68750608e-01f, -1.11248605e-01f,
  6.37066141e-02f, 1.23206973e-01f, 1.27972901e-01f, 7.35302418e-02f, 6.77169040e-02f, 4.34648156e-01f, 3.96180302e-01f, 2.59265900e-01f, -3.33111405e-01f, -3.62398326e-01f,
  -3.51969630e-01f, -1.53450653e-01f, 1.99663743e-01f, 6.78668991e-02f, -2.38495935e-02f, 3.44104677e-01f, -1.73080433e-02f, 1.67894185e-01f, 2.17487112e-01f, 6.33399487e-02f,
  5.53157449e-01f, 5.76133206e-02f, 1.52296737e-01f, 2.39790399e-02f, 4.19696830e-02f, -1.68642461e-01f, 4.62599955e-02f, 7.80502558e-01f, -2.83771098e-01f, -5.81449829e-02f,
  -3.94422233e-01f, 3.44829351e-01f, 3.83824140e-01f, 2.57586479e-01f, -5.44120334e-02f, -2.53561080e-01f, 1.94936216e-01f, -3.54320519e-02f, 2.17413306e-01f, 1.52019747e-02f,
  5.90480030e-01f, -2.15181798e-01f, 1.10902101e-01f, -2.34465316e-01f, -1.40601650e-01f, 3.56344618e-02f, 3.95302474e-01f, -2.14269727e-01f, 3.47187877e-01f, 3.39829892e-01f,
  1.32309377e-01f, 5.22480309e-01f, -3.31418425e-01f, 3.30455512e-01f, -3.91324133e-01f, 3.30604255e-01f, -2.06027821e-01f, 8.48653913e-02f, 3.14295113e-01f, -8.01992416e-03f,
  4.29427505e-01f, 1.74058408e-01f, -1.67280510e-01f, 1.93964824e-01f, 6.31360710e-02f, 1.51082918e-01f, 2.64652103e-01f, -7.08866492e-02f, 1.28907040e-01f, 1.53699249e-01f,
  1.46740049e-01f, 1.34422928e-01f, 3.04945916e-01f, -1.48823019e-03f, 3.29941064e-01f, 1.10609874e-01f, -1.32959977e-01f, 2.40669817e-01f, -2.15831064e-02f, -3.51105392e-01f,
  -4.21536602e-02f, -1.92037493e-01f, 8.79124284e-01f, -8.25599059e-02f, 1.79647002e-02f, -5.88974774e-01f, 2.88488925e-01f, 1.46036476e-01f, 6.01146556e-02f, 2.30873823e-01f,
  -2.45873734e-01f, -1.30115137e-01f, -1.46696195e-01f, 3.25995445e-01f, 1.59546062e-01f, 7.69801065e-02f, 6.22581877e-02f, -3.00398320e-01f, -2.23653302e-01f, 5.92304505e-02f,
  8.03158507e-02f, 4.70054559e-02f, -3.71620357e-02f, 4.72898521e-02f, -2.66219348e-01f, 2.41592571e-01f, 3.41432601e-01f, 1.05810277e-01f, -3.12379092e-01f, 1.27725154e-01f,
  3.22586782e-02f, -8.46605450e-02f, -6.17112666e-02f, -4.35794145e-01f, -1.91670820e-01f, 1.42343089e-01f, -3.98576707e-01f, -3.73254448e-01f, 3.99755299e-01f, 1.59095421e-01f,
  -2.23116130e-01f, -4.87488061e-01f, 5.47461249e-02f, 7.18799308e-02f, -6.03594542e-01f, 4.60430235e-01f, -4.31996226e-01f, 2.66948730e-01f, 1.82033986e-01f, 1.67710513e-01f,
  1.56183496e-01f, 1.75207436e-01f, 1.73800692e-01f, 2.40543529e-01f, 9.27740335e-02f, 2.56248921e-01f, -6.10812493e-02f, 1.32655064e-02f, 4.44226414e-01f, 2.77059585e-01f,
  -6.13399073e-02f, 6.42425194e-02f, -1.03301518e-01f, 1.29002258e-01f, 3.32674868e-02f, -1.63954541e-01f, 4.87072736e-01f, -1.65028960e-01f, 2.41112158e-01f, 8.44279677e-02f,
  5.03427684e-01f, 2.56452203e-01f, -4.82286848e-02f, 2.27603331e-01f, 4.96249460e-03f, -4.83887821e-01f, -1.75387487e-01f, 3.81711632e-01f, 5.60725033e-01f, -1.00533046e-01f,
  -2.27375269e-01f, 1.07848458e-01f, 4.22589600e-01f, 3.69948685e-01f, 1.42090276e-01f, 3.15117300e-01f, 2.77495742e-01f, 3.27164263e-01f, -2.58030981e-01f, 5.62415719e-02f,
  -1.55627474e-01f, 5.79356402e-02f, 3.73794734e-01f, -1.56642407e-01f, -3.29283893e-01f, 5.11731625e-01f, -8.82536769e-02f, 2.96643704e-01f, 6.39154255e-01f, -2.59836435e-01f,
  5.77884763e-02f, -2.52145916e-01f, -4.53176498e-01f, 4.23255831e-01f, -5.26557975e-02f, 1.09564207e-01f, 1.97264716e-01f, -3.15270692e-01f, -4.38575417e-01f, 2.75039449e-02f,
  6.37191460e-02f, 1.01078592e-01f, -1.56936407e-01f, 2.22131804e-01f, 2.17675999e-01f, 6.18120916e-02f, 3.07297319e-01f, 1.52294546e-01f, 2.22190991e-01f, -1.14096522e-01f,
  6.21800244e-01f, -3.29612494e-02f, 2.83884227e-01f, -1.35829911e-01f, -2.19277233e-01f, 1.23565681e-01f, 1.13573506e-01f, 1.04654670e-01f, -2.38203667e-02f, 1.17118642e-01f,
  -3.34098101e-01f, 2.56548375e-01f, -1.13442302e-01f, 9.82777551e-02f, -4.15089786e-01f, 2.71784246e-01f, -1.61770031e-01f, 5.12250721e-01f, 2.35077932e-01f, 1.93681475e-02f,
  7.22049117e-01f, -4.97679561e-02f, 7.06042111e-01f, 2.36496821e-01f, 7.75585473e-02f, 2.50047687e-02f, 9.79873314e-02f, 7.47735873e-02f, 1.78691491e-01f, 2.29240149e-01f,
  2.69845396e-01f, -4.39557107e-03f, -2.50726044e-01f, 3.95012833e-02f, -3.79185155e-02f, 7.58297145e-02f, -1.22781031e-01f, -1.24384716e-01f, 1.79049209e-01f, -4.38816361e-02f,
  3.82912308e-02f, -4.26129133e-01f, -5.26833415e-01f, -2.04941742e-02f, 1.29302278e-01f, 2.64139652e-01f, 6.68803871e-01f, 2.12186024e-01f, -3.90337966e-02f, -1.13750547e-01f,
  -3.93633187e-01f, 8.66131335e-02f, 1.05869748e-01f, 4.62123722e-01f, -3.08292627e-01f, 4.68885809e-01f, 3.12758356e-01f, 1.81936994e-01f, 4.94939685e-01f, 6.37247264e-01f,
  2.44568124e-01f, 2.94927686e-01f, 4.68238115e-01f, 1.09565444e-01f, 3.19263995e-01f, 4.13434543e-02f, -2.50232429e-03f, -2.47535646e-01f, 1.70838926e-02f, -2.10243076e-01f,
  3.88670653e-01f, -3.15784276e-01f, 2.65383273e-01f, -1.22147053e-01f, -1.50938854e-01f, -1.23754576e-01f, 3.12767774e-01f, 3.05102021e-01f, 2.66852558e-01f, -2.06714675e-01f,
  -5.48314095e-01f, 2.71298856e-01f, -3.94225344e-02f, 2.93037295e-01f, 2.82753855e-02f, -3.18974033e-02f, 2.28482895e-02f, -1.58402994e-01f, 3.93919349e-01f, -1.26062602e-01f,
  -4.92946506e-01f, 3.57744724e-01f, 3.89097422e-01f, 1.90549359e-01f, 2.01561436e-01f, -2.74988660e-03f, -4.96975034e-01f, 9.29618925e-02f, -3.56079303e-02f, -1.55628741e-01f,
  -1.52478337e-01f, 1.27794445e-01f, 2.22639404e-02f, 1.59909144e-01f, -3.21346492e-01f, -4.68322486e-02f, -4.29874212e-02f, 5.77756427e-02f, -6.66536808e-01f, -5.81710696e-01f,
  5.03435791e-01f, -1.10535026e-01f, -3.14885080e-01f, -5.38482487e-01f, -3.64989340e-01f, 1.56226918e-01f, -1.72905490e-01f, 2.44254783e-01f, -5.34372807e-01f, -4.06095205e-04f,
  5.70613027e-01f, -2.24339738e-01f, 4.05415297e-01f, -2.68227190e-01f, 4.79693376e-02f, 1.75263956e-01f, 2.10150823e-01f, 8.62221196e-02f, -1.12564981e-01f, -3.14225852e-01f,
  -3.14428210e-01f, -3.39709163e-01f, 1.15295708e-01f, -2.15983242e-01f, 4.43995744e-01f, -2.39232287e-01f, 4.28765893e-01f, 6.48615509e-02f, -1.46133021e-01f, 3.55532229e-01f,
  1.18217900e-01f, 1.34253100e-01f, -5.27873524e-02f, -4.98821065e-02f, -4.58574474e-01f, 2.93721795e-01f, 3.11849713e-01f, 2.82575160e-01f, 5.63018560e-01f, -1.94939062e-01f,
  -5.55268042e-02f, -8.51103887e-02f, -3.66877876e-02f, 5.28204180e-02f, 2.11803630e-01f, 2.50877738e-01f, 1.57816902e-01f, 4.26516891e-01f, 3.98703031e-02f, 8.14998373e-02f,
  -4.22456652e-01f, -2.29286492e-01f, -2.61478335e-01f, 3.51675437e-03f, 3.15038204e-01f, -2.14336321e-01f, -6.37475997e-02f, 4.97965604e-01f, 1.77835271e-01f, 3.34310532e-01f,
  -1.30527169e-01f, -1.91854000e-01f, 3.83027703e-01f, 1.37429778e-02f, 3.05784345e-01f, -6.26585335e-02f, -4.97991703e-02f, 1.29314587e-01f, -8.69099945e-02f, 2.07634240e-01f,
  -6.62899077e-01f, -2.02962235e-01f, 6.19653799e-02f, -1.34742916e-01f, -1.03813112e-01f, 4.83986698e-02f, -1.96361002e-02f, -2.90017486e-01f, 5.02734959e-01f, 2.72178024e-01f,
  2.42704824e-01f, -6.12338297e-02f, -3.91822666e-01f, -3.32337618e-01f, -3.20460469e-01f, -5.41428700e-02f, -1.50586903e-01f, -1.71645448e-01f, -1.46206975e-01f, -1.26248106e-01f,
  -6.60969436e-01f, -1.71282694e-01f, 3.69057097e-02f, 5.07312775e-01f, -1.82447985e-01f, -7.20568523e-02f, 1.61479071e-01f, -2.24850729e-01f, -6.41906857e-01f, -6.45543873e-01f,
  2.75241882e-01f, 5.33706188e-01f, 3.91131848e-01f, -1.32013634e-01f, -2.09968626e-01f, 1.35433570e-01f, 4.36158627e-01f, -3.11933365e-02f, 7.08913431e-02f, -8.94505903e-02f,
  -1.31642029e-01f, -2.02145219e-01f, -1.42005295e-01f, 1.18818469e-01f, 1.78930402e-01f, -4.13034074e-02f, -6.41741157e-02f, -1.06049649e-01f, 9.51517299e-02f, 1.04960501e-01f,
  5.67323677e-02f, 2.56068796e-01f, 1.03886642e-01f, 3.82109851e-01f, -3.12110543e-01f, -1.87841713e-01f, -6.53382018e-02f, -5.64496368e-02f, -6.57454908e-01f, 3.75862837e-01f,
  1.89419061e-01f, 1.16019165e-02f, -3.87830362e-02f, 4.17484948e-03f, 2.25835994e-01f, 5.93975782e-02f, 2.57449271e-03f, 2.03557789e-01f, -6.92028203e-04f, 4.10610110e-01f,
  7.07282722e-02f, -2.07581803e-01f, -1.73862815e-01f, -3.97059135e-03f, -4.83047277e-01f, 1.69642642e-02f, 9.84044224e-02f, -4.25887734e-01f, -2.08230913e-01f, -4.18382347e-01f,
  3.90291840e-01f, 1.48537070e-01f, 3.36339772e-02f, 4.96840209e-01f, 8.39780457e-03f, 5.32405019e-01f, -2.15639979e-01f, -2.52721131e-01f, -1.38657376e-01f, 1.45590147e-02f,
  -2.93070465e-01f, 2.97850575e-02f, 1.31000564e-01f, -4.94374521e-02f, -3.65687191e-01f, -1.18630603e-01f, 1.32976860e-01f, -1.35084897e-01f, 2.01876229e-03f, -3.61586362e-01f,
  -2.86755469e-02f, 2.26967469e-01f, 7.38274097e-01f, -3.86923808e-03f, -1.06821202e-01f, 1.22014843e-01f, -3.06391150e-01f, 4.40724380e-02f, -1.46330833e-01f, 3.63343209e-01f,
  -1.50651067e-01f, -3.15691829e-01f, 4.67299551e-01f, 2.95908630e-01f, 2.52568498e-02f, 4.16486621e-01f, -3.67238894e-02f, 2.62570649e-01f, -5.13226874e-02f, -1.15246855e-01f,
  5.66754103e-01f, 9.01311487e-02f, 4.08008620e-02f, -4.39100236e-01f, -2.75710374e-01f, 2.36594379e-01f, 2.80631006e-01f, 4.62775320e-01f, -9.28559005e-01f, 5.99988624e-02f,
  4.68832403e-01f, 3.39300007e-01f, 2.38827452e-01f, -1.22087188e-01f, 5.66727400e-01f, 2.60772645e-01f, 2.49359533e-01f, 4.00601566e-01f, 1.34824753e-01f, 2.76923478e-01f,
  -4.17256773e-01f, 1.65890798e-01f, -6.58207899e-03f, -5.54395877e-02f, 1.13455988e-01f, -2.50509065e-02f, 3.24382931e-01f, 2.18957916e-01f, 5.13773322e-01f, 5.80665283e-02f,
  -3.06092381e-01f, -1.41981378e-01f, 4.88080263e-01f, 4.29913968e-01f, 4.94574726e-01f, -3.31784010e-01f, 8.63813162e-02f, 4.68254060e-01f, 3.52312386e-01f, 1.57028615e-01f,
  -4.74870503e-01f, -1.79697171e-01f, 3.00526530e-01f, -1.45330029e-02f, -9.24593285e-02f, -1.26635596e-01f, 9.45871547e-02f, -2.70775735e-01f, -1.26867458e-01f, -1.79822948e-02f,
  -3.06004763e-01f, -1.70177070e-03f, 1.31641522e-01f, -1.36373103e-01f, -1.60792440e-01f, -1.66507766e-01f, 2.43364140e-01f, -7.86372423e-02f, 4.08818275e-02f, 1.86421961e-01f,
  3.37637067e-02f, 4.54286903e-01f, -5.09289131e-02f, -2.55046915e-02f, 1.31300539e-01f, -2.23034874e-01f, -4.15984839e-01f, 5.60532808e-02f, 1.62372917e-01f, -5.28143086e-02f,
  3.85972351e-01f, 2.91214526e-01f, 6.63076341e-02f, -1.63621932e-01f, 1.19149014e-01f, 2.49178857e-01f, -4.26275581e-01f, 4.05243993e-01f, 8.51424187e-02f, 2.90879309e-01f,
  9.06315073e-02f, 3.23616892e-01f, -2.39941739e-02f, 3.12957883e-01f, -4.59309697e-01f, 3.75049084e-01f, -7.40358829e-02f, 2.25365132e-01f, 2.20406264e-01f, -1.80310994e-01f,
  -1.76021025e-01f, 5.65405190e-01f, 1.63125917e-01f, 2.72239894e-01f, 2.77305990e-01f, 3.49429250e-01f, 1.46847934e-01f, -3.10515791e-01f, 1.68746918e-01f, -1.79481164e-01f,
  -2.46360943e-01f, 2.50942772e-03f, 1.69410408e-01f, 4.05688316e-01f, -6.99081421e-01f, 2.44787931e-01f, 4.18623120e-01f, 1.78106844e-01f, 3.36396962e-01f, -3.40569288e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.36427173e-01f, 3.34706008e-01f, 2.88778722e-01f, 1.31645212e-02f, 5.14454961e-01f, 1.76177174e-01f, -1.77123062e-02f, 3.43016326e-01f, 4.32427794e-01f, 1.37591377e-01f,
  5.42852998e-01f, 9.58238244e-02f, -1.25077173e-01f, 4.34937567e-01f, -5.51433936e-02f, -2.76206136e-01f, 5.56312501e-02f, 2.55188465e-01f, -1.20673753e-01f, 2.67974496e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  3.99400771e-01f, 2.00427487e-01f, 1.44940376e-01f, 1.85128182e-01f, 1.18713461e-01f, 4.46803212e-01f, -1.75724737e-02f, 1.98181152e-01f, 1.21527035e-02f, 1.41221955e-01f,
  1.76288635e-01f, -2.09681541e-01f, 5.99541739e-02f, -2.49185607e-01f, -5.16892672e-02f, -8.70003775e-02f, -2.04433814e-01f, 2.89312720e-01f, 2.42762163e-01f, 1.59761980e-01f,
  -1.12867765e-01f, 1.54940799e-01f, -1.86677158e-01f, -1.06930703e-01f, 1.09054513e-01f, -7.74221569e-02f, -2.78541982e-01f, -7.22563043e-02f, 2.05510259e-02f, -3.82878594e-02f,
  -7.83621445e-02f, -8.96416903e-02f, -1.43612191e-01f, -3.00110374e-02f, 2.05762476e-01f, 1.61159620e-01f, 1.67265143e-02f, -8.20122659e-02f, 2.65783191e-01f, -1.71378627e-01f,
  5.20146132e-01f, 4.23461273e-02f, -2.45191678e-01f, -5.13341725e-01f, 2.82126397e-01f, 3.62849236e-02f, 1.69897527e-01f, -9.50478464e-02f, 1.02798030e-01f, 7.69000202e-02f,
  -2.76524872e-02f, -4.20655720e-02f, -7.30244666e-02f, -6.47980422e-02f, 2.33023036e-02f, 1.70434475e-01f, -8.36505964e-02f, 7.56392183e-05f, 2.04587668e-01f, 5.00365086e-02f,
  -2.00361386e-01f, -2.32824534e-01f, 1.95477560e-01f, 1.09347962e-01f, -2.14391097e-01f, 3.01671922e-01f, -7.12759644e-02f, 3.16434920e-01f, 5.38309664e-02f, -2.89551049e-01f,
  -2.36984670e-01f, -2.58746117e-01f, -1.92669094e-01f, -2.10689127e-01f, 2.91035950e-01f, -2.06370562e-01f, 8.62503499e-02f, -1.77511554e-02f, -1.07093807e-02f, -2.70253867e-01f,
  1.57265976e-01f, 2.38349259e-01f, -2.59876996e-02f, 2.01989219e-01f, 4.20459248e-02f, -3.13512087e-01f, 1.70986295e-01f, -3.09022784e-01f, 6.04745559e-02f, 5.89072146e-02f,
  3.06127608e-01f, -1.28377974e-01f, -2.11441785e-01f, -6.01264648e-02f, 5.22604883e-02f, -5.48985191e-02f, -6.42974734e-01f, 2.74327904e-01f, -1.70752779e-01f, -2.98294220e-02f,
  -3.52059044e-02f, -2.10397616e-01f, 4.09690946e-01f, -2.53950387e-01f, -2.99368531e-01f, 4.03611302e-01f, -2.52867281e-01f, -4.14071590e-01f, 7.35825449e-02f, 1.39263570e-01f,
  1.95350051e-01f, 1.31980702e-01f, 2.18334064e-01f, -8.19507148e-03f, -6.71363994e-02f, -2.45916456e-01f, -3.93971689e-02f, -1.20590806e-01f, -1.06966853e-01f, 1.20289316e-02f,
  2.46629730e-01f, -1.49079055e-01f, -1.46074206e-01f, 2.29876470e-02f, -1.75709412e-01f, 1.06571764e-01f, -7.39725232e-02f, 4.02371399e-02f, -2.76728366e-02f, 7.96171501e-02f,
  1.03630029e-01f, 3.81842017e-01f, 1.22887179e-01f, 2.81715617e-02f, 2.12785661e-01f, 1.65709481e-01f, -2.30374098e-01f, 9.89370719e-02f, -1.48551285e-01f, -1.25312746e-01f,
  1.55086130e-01f, -2.32735291e-01f, 9.07459855e-02f, -1.57962918e-01f, 2.71135420e-01f, -1.18131079e-02f, -1.60378173e-01f, -7.01169372e-02f, -7.20439106e-02f, -3.31982315e-01f,
  2.50703901e-01f, 4.38834205e-02f, -1.72331676e-01f, 5.75781986e-02f, -1.33917689e-01f, 2.23416001e-01f, 3.33040357e-02f, -1.01008616e-01f, -4.55140620e-02f, 2.06032723e-01f,
  -6.31386191e-02f, -2.98488736e-01f, 1.13017648e-03f, -1.01535343e-01f, -1.95456892e-01f, -2.35050336e-01f, 3.68031025e-01f, 7.85119534e-02f, -4.49359566e-01f, 4.55415577e-01f,
  2.48877719e-01f, 6.91311061e-02f, -2.01683298e-01f, 1.82611048e-01f, 1.19208038e-01f, -6.54982924e-02f, -2.76601445e-02f, -2.13024810e-01f, -5.08902855e-02f, -8.09091628e-02f,
  -1.01859041e-03f, -7.50287697e-02f, -2.14670122e-01f, -7.55731612e-02f, 1.03246011e-01f, -3.24510112e-02f, 2.43611857e-01f, -9.26688313e-03f, 7.59613588e-02f, 3.10727358e-01f,
  2.17797846e-01f, -2.56360710e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -3.84824067e-01f, 5.18538892e-01f, 3.13580662e-01f, -3.00650239e-01f, 1.94922641e-01f, -2.00868517e-01f, -1.53990999e-01f, 1.47579029e-01f, 1.33045554e-01f, -4.74306732e-01f,
  4.28284816e-02f, -2.53808647e-01f, -3.48006755e-01f, 3.30818325e-01f, -1.96704328e-01f, 2.01355051e-02f, 6.62573427e-02f, 5.52684814e-02f, 5.37227035e-01f, -8.32812712e-02f,
  4.67130616e-02f, -1.34117901e-01f, -4.75787669e-01f, 1.05208389e-01f, 3.10548276e-01f, -1.45344183e-01f, 8.02236795e-02f, 8.01976100e-02f, 2.96925217e-01f, 2.55385727e-01f,
  3.18092972e-01f, 3.77850592e-01f, 4.40877140e-01f, -1.69089194e-02f, 1.57984465e-01f, 9.74233598e-02f, -3.92269999e-01f, 9.12266225e-02f, 5.03237769e-02f, -1.72043070e-01f,
  3.43129426e-01f, -8.20004568e-02f, -7.71279931e-02f, -3.98443520e-01f, -1.52193591e-01f, -1.40884981e-01f, 3.75207245e-01f, 3.48089874e-01f, -1.52665555e-01f, 3.19739789e-01f,
  3.07759166e-01f, -3.16015214e-01f, 5.44523150e-02f, 1.70566827e-01f, -5.15876651e-01f, 3.00565451e-01f, 1.43443510e-01f, -1.24504916e-01f, 5.26509769e-02f, 1.93822719e-02f,
  -1.88226148e-01f, 3.34491163e-01f, -2.80271769e-01f, -2.58789569e-01f, 2.55924672e-01f, 8.45003247e-01f, 1.89403027e-01f, -6.94928393e-02f, 3.57457966e-01f, 5.40455222e-01f,
  -3.96354914e-01f, 3.76684546e-01f, -3.68190974e-01f, -2.52415150e-01f, 4.16651249e-01f, 1.88146353e-01f, -1.90513209e-01f, 2.15857789e-01f, -4.78539258e-01f, -2.91995466e-01f,
  1.86812460e-01f, 2.71315604e-01f, 7.85660148e-02f, -2.46556506e-01f, 2.21935049e-01f, 2.58539408e-01f, 3.94825011e-01f, -3.08212638e-01f, 3.89126211e-01f, -9.98556539e-02f,
  -5.98819971e-01f, -1.74511448e-01f, 2.92223513e-01f, 2.42709428e-01f, -1.62973985e-01f, 4.99361038e-01f, -8.03612471e-02f, -1.98184699e-01f, -1.14948660e-01f, 2.58033007e-01f,
  -5.46638966e-02f, -9.68900174e-02f, -6.25731722e-02f, 8.15913379e-02f, -3.17330867e-01f, 1.10636503e-01f, 3.64658684e-01f, 2.24516675e-01f, 6.32208586e-01f, -6.92533374e-01f,
  3.99102449e-01f, -2.89195716e-01f, -6.41382933e-02f, 1.97533309e-01f, -4.04106155e-02f, 4.34857011e-01f, -3.61420959e-01f, 3.49912494e-01f, -2.15349793e-01f, 2.75226235e-01f,
  1.58472300e-01f, -1.91511288e-01f, 1.74196959e-01f, 2.08708674e-01f, 2.69582242e-01f, 3.58623981e-01f, -5.25805727e-02f, 1.13168947e-01f, 6.61115766e-01f, -9.40665662e-01f,
  7.88174495e-02f, 3.53749961e-01f, -1.31081179e-01f, 7.92116299e-02f, -3.41701694e-02f, 2.42566466e-01f, 3.82193506e-01f, -5.99227428e-01f, -3.32368873e-02f, -3.80223423e-01f,
  1.34307772e-01f, -1.56993344e-01f, 3.25465769e-01f, -4.67919707e-01f, -1.23261765e-01f, -2.68336292e-02f, 2.55283192e-02f, 2.22033709e-01f, -6.31359816e-02f, 2.59122998e-01f,
  -1.41995534e-01f, 3.13363135e-01f, -1.57022372e-01f, 2.25103602e-01f, 3.73494685e-01f, 5.95477998e-01f, -1.16185762e-01f, -2.33073514e-02f, 1.36216477e-01f, -2.72961468e-01f,
  2.77497977e-01f, 6.32558540e-02f, -2.44892538e-01f, -9.64011718e-03f, 2.80636817e-01f, 1.83936223e-01f, 5.11084676e-01f, -4.76625770e-01f, 6.28889859e-01f, 3.81890684e-01f,
  -8.78933668e-01f, -4.68432344e-02f, 8.52147862e-02f, 3.04719895e-01f, 2.35846773e-01f, 2.45351449e-01f, -1.43202871e-01f, -5.87436706e-02f, 3.87428179e-02f, 1.84830368e-01f,
  5.14816403e-01f, -7.34213665e-02f, 5.49393773e-01f, 2.38938183e-01f, -4.76015806e-01f, 3.69232357e-01f, 5.01408502e-02f, -2.67120600e-01f, -5.69981873e-01f, -5.38168430e-01f,
  8.30533057e-02f, 7.69608915e-02f, 4.65494096e-02f, 4.58684936e-02f, 1.41893548e-03f, 9.59473848e-02f, 2.23861355e-02f, 6.59480035e-01f, -5.60864747e-01f, 3.68168540e-02f,
  -1.16947129e-01f, -5.92255652e-01f, 4.31416541e-01f, -2.44599819e-01f, -8.94082412e-02f, 1.34298578e-01f, -5.65797053e-02f, -1.34538308e-01f, -4.52465922e-01f, -7.00222179e-02f,
  1.13909416e-01f, 6.91648498e-02f, -9.21140611e-03f, 5.51346123e-01f, -1.59222662e-01f, 1.30390704e-01f, 1.38949305e-01f, -7.95407295e-02f, 2.37100989e-01f, 1.66498542e-01f,
  7.04962969e-01f, 5.57829499e-01f, -1.17293157e-01f, 1.39455972e-02f, -7.09426552e-02f, 4.31627959e-01f, -1.70298547e-01f, -1.55385181e-01f, 6.20638020e-02f, -5.63418381e-02f,
  -5.86668625e-02f, 1.97832823e-01f, -5.78689396e-01f, -2.50331581e-01f, -3.65145393e-02f, -6.00815788e-02f, 5.31312466e-01f, -3.18416119e-01f, -2.22714454e-01f, 4.37093049e-01f,
  1.02487788e-01f, 4.31747526e-01f, 4.18016106e-01f, 2.94741660e-01f, -1.03134237e-01f, -1.75144941e-01f, 2.28219293e-02f, -9.75387394e-02f, 2.18262330e-01f, 1.69863887e-02f,
  -3.58120114e-01f, -2.65299469e-01f, 3.89015628e-03f, 2.55995452e-01f, -2.67202735e-01f, 4.52629983e-01f, 1.58048719e-01f, 3.67650479e-01f, -4.20904309e-01f, 4.47220683e-01f,
  1.70266539e-01f, 4.12673503e-01f, -5.72627664e-01f, 7.38109529e-01f, -1.00982165e+00f, -3.52996975e-01f, 4.66480225e-01f, 8.88428569e-01f, 2.11985074e-02f, -2.16912702e-01f,
  -2.81304326e-02f, 1.83634713e-01f, 2.81869043e-02f, 2.55227119e-01f, -4.06607836e-01f, 4.34686840e-01f, 1.89735234e-01f, 3.49686682e-01f, 4.98547629e-02f, 1.04249164e-01f,
  -1.62789702e-01f, -3.34626958e-02f, -2.50845283e-01f, -7.46973276e-01f, 1.12725303e-01f, 3.53031665e-01f, -6.21988595e-01f, -1.21006019e-01f, 4.15064037e-01f, -6.50527850e-02f,
  4.08972234e-01f, 5.64580321e-01f, 6.21948987e-02f, 8.20713118e-02f, 1.45667136e-01f, 3.30319703e-01f, -3.40714417e-02f, -2.21788079e-01f, 4.01892304e-01f, -1.55690849e-01f,
  -1.08683571e-01f, -2.55580127e-01f, 2.01046690e-01f, -4.55940276e-01f, 1.19930014e-01f, 1.02240197e-01f, 2.43421674e-01f, 4.22491193e-01f, 2.10816234e-01f, 2.34634075e-02f,
  -3.47584575e-01f, 1.19779229e-01f, 1.76888525e-01f, -4.38087523e-01f, 6.60643131e-02f, 2.41054222e-01f, -1.25657007e-01f, 2.57875174e-01f, -1.21407852e-01f, -3.33700269e-01f,
  -2.16228962e-01f, -1.26984164e-01f, 1.48754101e-02f, -6.39580548e-01f, -1.11093044e-01f, -1.57488182e-01f, -2.03907594e-01f, -3.90450060e-01f, -3.97632957e-01f, -9.14144814e-01f,
  -4.67158072e-02f, 3.19913350e-04f, 5.27015686e-01f, 1.82656780e-01f, -1.36876151e-01f, -1.19740911e-01f, -3.69850129e-01f, -2.04356238e-01f, 4.17880230e-02f, 2.09678501e-01f,
  -3.93511325e-01f, -7.20210820e-02f, 1.15489736e-01f, 1.47258878e-01f, 1.97615221e-01f, -4.09514368e-01f, 2.88713574e-01f, 3.65044802e-01f, 4.24038112e-01f, 6.56535849e-02f,
  3.08598757e-01f, 2.11239472e-01f, 9.87255201e-02f, 6.23439312e-01f, 1.18935734e-01f, 3.12426925e-01f, 2.83337474e-01f, 4.48783010e-01f, -2.41118729e-01f, 1.74733281e-01f,
  1.24072872e-01f, -1.92173138e-01f, -2.03948438e-01f, 2.24840254e-01f, 4.47877884e-01f, 2.25272477e-01f, -2.57129669e-01f, 4.24062610e-01f, 6.14474118e-02f, 2.49767199e-01f,
  3.53048146e-01f, -1.90165028e-01f, -1.58983886e-01f, 1.63984835e-01f, 4.85338837e-01f, -4.42291081e-01f, 8.82714838e-02f, 1.91430047e-01f, -5.39475501e-01f, -2.89494991e-01f,
  4.35470104e-01f, 1.07977642e-02f, -4.65494990e-01f, 5.58099568e-01f, -7.57942677e-01f, 1.31457508e-01f, 5.69767892e-01f, -3.01826090e-01f, -4.56789546e-02f, -1.14302114e-01f,
  1.29838929e-01f, 9.84306633e-02f, 7.08479583e-02f, 4.59682196e-01f, 8.92372504e-02f, -6.15540266e-01f, -2.98897535e-01f, 1.47055030e-01f, 3.04805428e-01f, -2.77546644e-01f,
  2.07972467e-01f, -2.44443379e-02f, 4.66190279e-01f, 2.68857181e-01f, 9.04950947e-02f, -2.07604602e-01f, -6.59323335e-01f, 2.80326214e-02f, 4.46790338e-01f, 1.28791064e-01f,
  1.54584214e-01f, 3.48324746e-01f, 6.96041524e-01f, -1.36886528e-02f, 4.37101573e-01f, 4.17717576e-01f, -6.57580048e-02f, 4.25525159e-01f, -1.66588515e-01f, 1.15392119e-01f,
  -2.07319409e-01f, -2.28502646e-01f, -2.64039457e-01f, 5.06116152e-02f, -1.10411286e-01f, -1.10976920e-01f, 3.17676030e-02f, -2.76052743e-01f, 1.46216810e-01f, -2.90532522e-02f,
  -1.05957776e-01f, 5.82302272e-01f, 2.33805448e-01f, 5.83897352e-01f, 4.59292620e-01f, 4.66935858e-02f, 1.43705472e-01f, 7.17005655e-02f, -5.56641102e-01f, -2.27049574e-01f,
  2.96442151e-01f, -3.02869707e-01f, -1.04079716e-01f, -1.45567164e-01f, -6.13891929e-02f, 2.06549510e-01f, -4.07436818e-01f, 3.37223530e-01f, 6.65068090e-01f, -4.95299399e-02f,
  5.61697900e-01f, 4.18733656e-01f, 4.46067005e-01f, 4.04817045e-01f, -2.75747329e-01f, 7.90116131e-01f, 5.07713735e-01f, -6.00071609e-01f, 5.20495594e-01f, -2.42250934e-01f,
  -1.00557491e-01f, 2.23598003e-01f, 3.03165734e-01f, -4.42260802e-01f, 2.10187837e-01f, -1.75012067e-01f, 2.20330283e-01f, -4.56160447e-03f, 1.43518254e-01f, -5.68370931e-02f,
  2.68998116e-01f, -2.63853997e-01f, -3.67683657e-02f, 4.16722655e-01f, 5.05854525e-02f, 1.25966370e-01f, 1.19831368e-01f, 3.66615728e-02f, -1.82217732e-01f, 3.70901495e-01f,
  1.17905572e-01f, -1.95754599e-02f, -2.62011081e-01f, 1.52715698e-01f, 1.23198301e-01f, 5.18407077e-02f, -2.11337700e-01f, -6.91390187e-02f, -2.81434298e-01f, 3.18653807e-02f,
  -9.12532732e-02f, 4.04784501e-01f, -5.15018880e-01f, -5.49636073e-02f, 6.51605368e-01f, -1.98358148e-01f, -2.03929514e-01f, 1.40192881e-01f, -3.75662804e-01f, 1.86166048e-01f,
  1.62330374e-01f, 5.66604674e-01f, -2.12622315e-01f, 7.38695800e-01f, -8.27787146e-02f, 3.93184423e-01f, -3.56708556e-01f, -3.12466294e-01f, -9.74490047e-02f, 4.75815505e-01f,
  -3.53133619e-01f, -3.61991733e-01f, -6.72747428e-03f, -5.95564425e-01f, -1.80739179e-01f, 2.68395126e-01f, -9.76366922e-02f, -2.87710726e-02f, 6.20095611e-01f, -4.67685789e-01f,
  3.97534579e-01f, 5.94238460e-01f, -6.98766530e-01f, -1.84155330e-01f, 3.27625200e-02f, -5.99053726e-02f, 3.44673246e-01f, 1.08817190e-01f, 1.89815700e-01f, -4.80545908e-01f,
  -3.46396029e-01f, 1.41563565e-01f, -1.91183671e-01f, 1.70668796e-01f, 4.29248244e-01f, 1.27934322e-01f, -7.54183754e-02f, 4.42218482e-01f, -8.10673088e-02f, 1.65288374e-01f,
  9.41145569e-02f, 1.85661733e-01f, 2.33389288e-01f, 2.19052270e-01f, -3.73022437e-01f, 3.82244229e-01f, -1.49648726e-01f, -6.03040755e-02f, -3.33366990e-01f, 5.01597643e-01f,
  -4.96320665e-01f, -2.06624836e-01f, -6.13392115e-01f, -5.18040240e-01f, 2.36488536e-01f, 1.18773863e-01f, -1.77512765e-01f, 3.47089678e-01f, -1.06093818e-02f, -1.56146929e-01f,
  -3.13407809e-01f, -2.68683463e-01f, -1.79805040e-01f, 3.39716226e-02f, -4.12294525e-04f, 5.22468030e-01f, -2.41285518e-01f, 4.10284519e-01f, 1.90324619e-01f, 1.65627286e-01f,
  -2.33781531e-01f, -1.29630402e-01f, 3.88021231e-01f, 2.32502863e-01f, -4.11667794e-01f, -9.03880447e-02f, 3.60056251e-01f, -2.57189065e-01f, 1.45702630e-01f, 7.22536370e-02f,
  2.42072850e-01f, 1.61377843e-02f, -1.34510413e-01f, 1.73217237e-01f, 5.09464383e-01f, -7.36651182e-01f, -7.30756596e-02f, -1.80721715e-01f, 8.28418016e-01f, -1.51515275e-01f,
  3.11286122e-01f, -2.10669860e-02f, 1.40147015e-01f, 2.64226019e-01f, 2.84119844e-01f, 4.63120729e-01f, 8.74216706e-02f, -9.52293724e-02f, -1.15331933e-01f, -1.01712301e-01f,
  -1.66590542e-01f, 2.46758834e-01f, 1.08630491e-04f, 2.96095014e-01f, -3.71410698e-01f, -1.04501456e-01f, -6.43317848e-02f, -1.82939932e-01f, 4.52800274e-01f, 5.31345010e-01f,
  3.26816261e-01f, 9.26335990e-01f, 1.20084785e-01f, 2.68836945e-01f, -1.27766818e-01f, 7.24778950e-01f, -4.78229821e-01f, 2.58230746e-01f, 2.34854758e-01f, 3.78908634e-01f,
  1.27724126e-01f, -1.05373152e-01f, 1.64461672e-01f, 4.95326996e-01f, 5.38841903e-01f, 3.48961085e-01f, -1.72989011e-01f, 2.74227113e-01f, 4.01836514e-01f, 2.77311802e-01f,
  2.72165895e-01f, -2.95522094e-01f, -1.98033035e-01f, -9.20169875e-02f, -2.94952780e-01f, -5.28717637e-01f, 2.37136707e-01f, 5.65239936e-02f, -5.25903761e-01f, 2.48193853e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.06223986e-01f, 8.68664086e-02f, 3.59341800e-01f, -9.04399753e-02f, 1.14132032e-01f, 3.26056749e-01f, 6.73390850e-02f, -2.11445630e-01f, 2.18651935e-01f, -1.30597711e-01f,
  2.37958819e-01f, 4.29162771e-01f, 7.95095321e-03f, -1.43966258e-01f, 3.58089596e-01f, 9.22242701e-02f, 4.42707300e-01f, 1.82325497e-01f, 8.58323276e-02f, 4.36892986e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.07060173e-01f, 2.52090722e-01f, 1.25191107e-01f, 4.11374718e-02f, -1.04681917e-01f, 1.22250207e-01f, -3.71736676e-01f, 3.07545662e-01f, -9.07761678e-02f, 2.21907437e-01f,
  -4.78959270e-02f, -9.53322928e-03f, 1.93609931e-02f, 7.11039528e-02f, -5.08639216e-01f, 2.44513854e-01f, 2.81785190e-01f, -1.12596405e+00f, 2.17918962e-01f, -2.14938715e-01f,
  -2.12198183e-01f, 7.27417041e-03f, 3.09267879e-01f, -3.57108235e-01f, 1.94403991e-01f, -2.66778946e-01f, -5.30332386e-01f, -2.01890729e-02f, 5.37628710e-01f, 1.46249592e-01f,
  -4.29551005e-01f, -8.47780466e-01f, -1.92759037e-02f, -3.31491023e-01f, -3.98260802e-01f, -6.45577237e-02f, 1.79333344e-01f, 4.84083444e-02f, 2.32767001e-01f, 1.73497230e-01f,
  1.39163956e-01f, -2.73637384e-01f, -3.94039840e-01f, 2.13112012e-01f, 1.04414701e-01f, -9.21243876e-02f, -5.15862048e-01f, 2.13351041e-01f, 4.49166238e-01f, -1.64726496e-01f,
  7.99553692e-02f, -1.96693212e-01f, -4.09212798e-01f, 4.22543406e-01f, 3.74400765e-01f, -7.45628655e-01f, 2.33790770e-01f, -1.25029072e-01f, 4.25331384e-01f, -8.82981241e-01f,
  -5.53626239e-01f, -6.96991742e-01f, 4.09331858e-01f, 6.50806054e-02f, 1.95435211e-01f, 3.86817902e-01f, 1.90807819e-01f, 3.86184314e-03f, -9.22383219e-02f, 2.29989916e-01f,
  -5.42223632e-01f, 9.64987352e-02f, -6.10305786e-01f, -4.18975741e-01f, -7.71978140e-01f, -9.63254049e-02f, -9.12001058e-02f, 1.93292350e-01f, -2.83777803e-01f, -6.58108056e-01f,
  4.60704058e-01f, 3.53212029e-01f, 2.07214102e-01f, -4.39299166e-01f, 4.72806059e-02f, -4.56806809e-01f, -1.18859857e-01f, -2.48587325e-01f, -6.06652915e-01f, -2.90074557e-01f,
  8.45712237e-03f, 5.32184362e-01f, 1.30624836e-02f, 2.59327650e-01f, 3.04534733e-01f, -5.56083500e-01f, -2.11036772e-01f, 5.69694713e-02f, -1.41441733e-01f, -2.54842967e-01f,
  -2.16973260e-01f, -6.97796941e-02f, 5.97669482e-01f, -1.19279094e-01f, -3.15262914e-01f, -3.35234463e-01f, -1.60486534e-01f, 2.46633381e-01f, -5.71379900e-01f, 2.66271263e-01f,
  -2.89794624e-01f, 2.55129933e-01f, 2.76461810e-01f, -5.94286382e-01f, 1.29361898e-01f, -1.66888803e-01f, 2.59926438e-01f, 3.06098014e-01f, -5.89099348e-01f, -5.69215775e-01f,
  -3.83006632e-01f, -2.48119496e-02f, -2.29039967e-01f, 3.56169343e-01f, 1.67233452e-01f, -6.48213252e-02f, -1.15519233e-01f, 1.02350518e-01f, 5.36275923e-01f, -6.26253307e-01f,
  -4.35124159e-01f, 2.08843738e-01f, -3.63174886e-01f, -2.32485890e-01f, 3.18922520e-01f, -1.39840811e-01f, -3.37835848e-01f, 2.55715877e-01f, 4.56594378e-01f, 2.90950179e-01f,
  2.46879339e-01f, 1.45789862e-01f, 3.19854498e-01f, -8.64055194e-03f, -3.24627757e-01f, 1.16731584e-01f, 1.89894974e-01f, -1.09316878e-01f, 1.23930141e-01f, 3.53805311e-02f,
  -9.30451080e-02f, -2.95363933e-01f, 1.05343603e-01f, 1.18783616e-01f, -4.05190319e-01f, 2.03795806e-01f, -4.02364671e-01f, 2.83524275e-01f, -1.83281824e-01f, -1.42488495e-01f,
  -5.72406411e-01f, 4.83791232e-01f, -1.94203958e-01f, 2.63628006e-01f, -2.49706998e-01f, -1.12813383e-01f, -1.96152907e-02f, 1.14701413e-01f, 5.07656693e-01f, 9.32800472e-02f,
  -3.46625477e-01f, 1.49597064e-01f, 4.39576298e-01f, 1.37505904e-01f, 3.58273745e-01f, 1.44184697e-02f, -2.82830626e-01f, -5.29333234e-01f, 2.27646649e-01f, 1.51861176e-01f,
  -5.01389384e-01f, -3.39555442e-02f, 1.78896606e-01f, 8.68765116e-02f, 3.41507673e-01f, 2.55235314e-01f, 4.55927067e-02f, -6.31235898e-01f, -4.70757365e-01f, -9.56670567e-02f,
  -2.70226777e-01f, -6.68724418e-01f, -1.46924108e-01f, 2.79615134e-01f, 2.39445597e-01f, 3.08337510e-01f, 4.20764461e-02f, -2.12049618e-01f, 5.33185244e-01f, 7.75224566e-01f,
  -8.93041566e-02f, 5.28547615e-02f, 3.60935241e-01f, -3.37493867e-01f, -2.13949800e-01f, -1.92269266e-01f, 3.41197938e-01f, -8.47724155e-02f, -3.14518750e-01f, 4.05495763e-01f,
  -4.80282992e-01f, -4.45574373e-01f, -3.50051999e-01f, -5.15598580e-02f, 2.00683787e-01f, 4.37505305e-01f, -4.28228766e-01f, -6.71879172e-01f, 2.03735486e-01f, -5.98196089e-01f,
  3.68758917e-01f, -5.88749290e-01f, -1.06713682e-01f, 9.48850960e-02f, 1.32330447e-01f, -1.77095383e-01f, 2.74303526e-01f, 1.14550658e-01f, -5.26737012e-02f, 1.44087449e-01f,
  -3.07510614e-01f, 2.11832285e-01f, -3.06432545e-01f, 3.97984445e-01f, 3.71520638e-01f, 4.22910005e-01f, -8.63742549e-03f, -3.62640172e-01f, -3.75027508e-01f, 1.65231898e-01f,
  -7.82344565e-02f, 3.12756807e-01f, -4.63104099e-01f, -2.91610062e-01f, -6.84424043e-01f, -4.36163753e-01f, -7.03451991e-01f, -3.30724508e-01f, 4.96173054e-01f, -2.03181580e-01f,
  -9.24083441e-02f, 2.42149755e-01f, 5.44026375e-01f, -1.08791731e-01f, -2.68589519e-02f, -4.80239451e-01f, 3.74902278e-01f, -2.03594282e-01f, 6.88400418e-02f, -2.78459787e-01f,
  -2.15973984e-02f, 1.56636581e-01f, 4.35338944e-01f, 1.11707389e-01f, 3.20586056e-01f, 5.34999132e-01f, -2.54432946e-01f, -3.95499259e-01f, -9.29732397e-02f, 4.25411820e-01f,
  -4.44063962e-01f, -4.09303531e-02f, -3.64683837e-01f, -1.43530026e-01f, -5.91232121e-01f, 2.98481137e-01f, -5.83878398e-01f, -3.55472237e-01f, -2.74782747e-01f, 3.21084261e-01f,
  -2.50442028e-01f, 4.10000861e-01f, -3.88221145e-01f, -3.40348184e-01f, 1.02797940e-01f, -1.53534070e-01f, 3.32630962e-01f, 3.36926319e-02f, 2.82887846e-01f, 2.80648381e-01f,
  1.29902691e-01f, 6.37291372e-02f, 1.16226196e-01f, 4.37304229e-01f, 5.30740976e-01f, -6.32169366e-01f, -3.25521797e-01f, -5.70785284e-01f, -1.37268990e-01f, 2.85833806e-01f,
  -6.63430393e-02f, -3.05174559e-01f, 3.39090645e-01f, -7.21172214e-01f, -3.94912690e-01f, -3.37659180e-01f, 4.04725999e-01f, -4.26463664e-01f, 1.43699765e-01f, -3.85760963e-01f,
  -2.24290475e-01f, 2.48011649e-01f, 8.52312222e-02f, -3.68545443e-01f, 1.69362739e-01f, -2.78817534e-01f, 1.55069148e-02f, 4.46386784e-01f, -4.61488694e-01f, 1.70784950e-01f,
  -4.35221672e-01f, -6.16590343e-02f, -3.94186974e-02f, -3.29564005e-01f, -1.60481334e-01f, -1.93285093e-01f, -7.23093525e-02f, -3.11218053e-01f, 4.69773635e-02f, -4.05131996e-01f,
  7.12397397e-02f, -4.33200747e-01f, -2.79689252e-01f, -4.81540382e-01f, -1.53120542e-02f, 4.50833648e-01f, -2.81177640e-01f, -7.25756764e-01f, -5.92022911e-02f, 2.87491083e-01f,
  4.52802509e-01f, -7.69006088e-02f, 4.07001257e-01f, 1.01880386e-01f, -3.50963682e-01f, 9.39811096e-02f, -8.09889615e-01f, -3.03388268e-01f, -9.13546830e-02f, -2.99405791e-02f,
  2.93899715e-01f, 1.61941219e-02f, -1.73859388e-01f, 1.99937209e-01f, 1.78686887e-01f, -7.12539852e-02f, -1.84262529e-01f, 1.65108114e-01f, -9.44484770e-01f, -4.71863776e-01f,
  5.06726682e-01f, 1.40798688e-01f, 5.11954904e-01f, -3.05734187e-01f, -3.91124964e-01f, -6.23811424e-01f, 4.30103540e-01f, -4.67760682e-01f, -1.92524150e-01f, -1.46897092e-01f,
  -5.75992227e-01f, 2.34652504e-01f, 6.00127518e-01f, -2.57943481e-01f, -4.36466336e-01f, 1.35000601e-01f, -2.59005576e-01f, 4.60388921e-02f, -7.71496594e-02f, -7.81552121e-03f,
  -7.28867650e-01f, -5.17330766e-01f, -1.42525807e-01f, 4.48379487e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -8.88616815e-02f, -9.47894827e-02f, 2.00810283e-01f, -9.50471908e-02f, 1.76964179e-02f, 8.30013677e-02f, 1.07663095e-01f, 1.13492630e-01f, -7.05486862e-03f, 7.45729282e-02f,
  -3.23423952e-01f, -7.61478953e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    