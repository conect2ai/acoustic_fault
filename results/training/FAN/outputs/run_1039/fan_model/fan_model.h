/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.36326295e-01f, 1.36683345e-01f, 2.81452090e-02f, -5.28663285e-02f, 3.50536853e-02f, 2.13086847e-02f, 3.07165116e-01f, -6.57418296e-02f, -8.59457776e-02f, 3.30325127e-01f,
  1.31789058e-01f, -3.72384936e-02f, -9.72774252e-02f, -4.43166085e-02f, -3.08048129e-01f, 4.72208783e-02f, -4.55516540e-02f, -2.80792326e-01f, -4.61434841e-01f, -1.65093631e-01f,
  -7.22140074e-02f, -5.60446754e-02f, -2.72969484e-01f, -2.34873086e-01f, 5.89432158e-02f, 7.22480053e-03f, 2.12462008e-01f, -4.08403166e-02f, -1.14278309e-01f, 1.19130507e-01f,
  1.54991195e-01f, -1.36879593e-01f, -6.99293315e-02f, -8.05067793e-02f, -1.73674077e-02f, -1.50671735e-01f, -6.72566369e-02f, -7.18136951e-02f, -4.84388806e-02f, 4.23153210e-03f,
  -9.54056978e-02f, -5.82505353e-02f, -1.36835143e-01f, 6.15468919e-02f, -9.72269252e-02f, -1.17758419e-02f, 5.05121425e-02f, -9.22013447e-02f, -1.51342675e-01f, 9.40844789e-02f,
  6.32650917e-03f, -1.87174249e-02f, -1.34855524e-01f, -9.20483563e-03f, -6.74148276e-02f, -1.74136579e-01f, 1.86085440e-02f, -9.97064263e-03f, -1.13704391e-01f, 1.99532419e-01f,
  -2.44158879e-02f, 1.89567134e-02f, 1.18368876e-03f, 1.72637065e-03f, 1.13054998e-01f, 3.92200239e-03f, -4.52932948e-03f, 3.62221780e-03f, 1.94933712e-02f, 2.16348767e-02f,
  -3.59118134e-02f, 9.83605906e-02f, 8.80236402e-02f, 2.68131346e-02f, 4.86341305e-02f, -5.32972366e-02f, -4.10543941e-02f, 7.11233169e-02f, -1.04318671e-02f, -3.94818559e-02f,
  -4.72928248e-02f, -2.54877638e-02f, 1.15973065e-02f, 7.10759237e-02f, -2.26318818e-02f, -7.70479813e-03f, -3.04980092e-02f, -1.64518096e-02f, 1.31642809e-02f, -1.27310202e-01f,
  1.82134435e-01f, -1.39449850e-01f, 3.30729261e-02f, -1.11883149e-01f, 6.21910430e-02f, -9.26283598e-02f, 1.12276953e-02f, -8.19082931e-02f, -4.29338366e-02f, -2.85563096e-02f,
  -3.03065721e-02f, -3.28814164e-02f, 3.80065069e-02f, 9.45776552e-02f, 1.54685986e-03f, 4.95669022e-02f, 4.17716242e-03f, -3.33121829e-02f, 1.27714127e-02f, -8.34019762e-03f,
  9.71035138e-02f, 5.32620493e-03f, 5.46241887e-02f, 4.16202284e-02f, 2.73237899e-02f, -1.27800955e-02f, 8.97153467e-02f, 1.05358381e-02f, -9.36967805e-02f, 3.24472129e-01f,
  2.88612664e-01f, 1.64674565e-01f, -4.17003274e-01f, 8.31338391e-02f, -4.36316520e-01f, -4.75768417e-01f, -5.07460535e-01f, -2.36454420e-02f, 1.06988639e-01f, 1.07960440e-01f,
  4.43847105e-02f, 4.13592517e-01f, 2.40993842e-01f, 1.94991663e-01f, -2.85345912e-02f, -2.34239340e-01f, -3.14122587e-01f, -1.09466501e-02f, 3.83722000e-02f, -2.24585310e-02f,
  9.86976698e-02f, 1.66679204e-01f, 3.07443500e-01f, 1.05723202e-01f, 7.08270371e-02f, 1.50081307e-01f, -9.13613215e-02f, 3.33249383e-02f, -4.55006436e-02f, 1.17441505e-01f,
  1.17822094e-02f, -9.22458991e-02f, 2.12673414e-02f, -1.41844815e-02f, -2.84266733e-02f, 1.49506718e-01f, -3.45841935e-03f, 1.27258927e-01f, 1.82115175e-02f, 1.76693611e-02f,
  -2.41096765e-02f, 7.08617568e-02f, 2.83861766e-03f, -2.54052668e-03f, -1.21073231e-01f, 9.81681980e-03f, 5.91291711e-02f, 9.13934857e-02f, -5.07142767e-02f, -1.51791843e-03f,
  1.63314976e-02f, -1.96199551e-01f, -2.14628726e-01f, -1.42429829e-01f, -1.15971588e-01f, -8.72068778e-02f, -3.29983123e-02f, -1.08612943e-02f, -1.84848100e-01f, 1.23226851e-01f,
  7.16920346e-02f, -5.91734424e-02f, -5.59251606e-02f, 4.51871157e-02f, 1.58418622e-02f, 6.32911026e-02f, -4.69380021e-02f, -4.93038911e-03f, 6.01738505e-02f, 6.15307353e-02f,
  6.31555915e-02f, -2.42873132e-02f, -7.69651011e-02f, 7.97104929e-03f, 3.63530852e-02f, -7.87020698e-02f, -1.46777183e-01f, 2.89412104e-02f, -4.29442488e-02f, 3.62837985e-02f,
  1.95060708e-02f, -2.11790763e-02f, -3.35855335e-02f, -1.61304977e-02f, -2.78963838e-02f, 2.30977945e-02f, 2.60721091e-02f, 3.87721956e-02f, 6.46911487e-02f, -3.06643844e-02f,
  1.57980084e-01f, -1.15189411e-01f, 1.52690098e-01f, 1.14205256e-01f, -1.44509524e-01f, 5.52467187e-04f, 2.58471072e-03f, -3.08784377e-02f, -1.70485675e-02f, 5.40879816e-02f,
  -7.29506686e-02f, 4.13679145e-03f, -4.47700918e-02f, 1.14187989e-02f, 1.08164568e-02f, -2.85425652e-02f, 5.35033410e-03f, 8.54719952e-02f, 9.38919187e-03f, -8.61826763e-02f,
  4.55887392e-02f, 2.33517215e-02f, 1.50356680e-01f, 4.86142710e-02f, 6.78410307e-02f, -5.50390081e-03f, 4.47170716e-03f, -2.80995779e-02f, -8.76984522e-02f, 9.27733555e-02f,
  6.79468215e-02f, 3.15335169e-02f, -6.68697059e-02f, 7.54697472e-02f, -2.36417592e-01f, -2.05946624e-01f, -2.41485741e-02f, 4.69789915e-02f, 1.50175840e-01f, 2.16766924e-01f,
  -1.40701264e-01f, -2.59631425e-01f, -1.14170693e-01f, -1.51278779e-01f, -1.32092074e-01f, 1.48902506e-01f, 5.94290383e-02f, -1.09431475e-01f, -2.85201371e-01f, -2.34511957e-01f,
  -8.61560106e-02f, 1.29806608e-01f, 1.03817694e-01f, -9.68368575e-02f, 2.75434583e-01f, -3.52285691e-02f, 1.02567792e-01f, 1.33502213e-02f, -9.01137367e-02f, 1.96536958e-01f,
  -4.50592823e-02f, -1.52967006e-01f, -1.42545074e-01f, -2.23946765e-01f, -1.96111426e-01f, -1.01846784e-01f, -1.56637862e-01f, -1.09858908e-01f, -1.53995812e-01f, -9.13245883e-03f,
  -1.68164939e-01f, -1.99215516e-01f, -1.84728459e-01f, -6.25265166e-02f, -6.90258592e-02f, -9.77427363e-02f, 2.59760115e-02f, -1.12194203e-01f, -1.36743441e-01f, -7.75286630e-02f,
  -8.33312720e-02f, -1.93479508e-01f, -1.91154867e-01f, -1.53126493e-01f, -1.41817555e-01f, -2.75146812e-01f, -1.61754981e-01f, -1.67231277e-01f, -2.15549454e-01f, 1.06549129e-01f,
  -5.79161607e-02f, -2.57938411e-02f, 2.90638562e-02f, -2.97152475e-02f, 1.15092851e-01f, -1.49598615e-02f, 7.97603372e-03f, 6.89780014e-03f, -3.99329960e-02f, 9.36097428e-02f,
  -3.08435317e-03f, 6.47410974e-02f, -1.14249326e-02f, 3.34270820e-02f, -3.19373086e-02f, -4.48435880e-02f, -6.18190840e-02f, 1.34551331e-01f, 9.31285098e-02f, -1.12918601e-03f,
  8.59094113e-02f, 7.40463287e-03f, 5.32467850e-02f, -2.62094159e-02f, 3.67833301e-02f, 2.86118756e-03f, 1.09760426e-02f, 7.68526569e-02f, 7.90981501e-02f, 4.85496521e-02f,
  9.26619843e-02f, -2.79552191e-01f, 1.21927418e-01f, 8.23179819e-03f, -6.24059252e-02f, -4.40218449e-02f, -1.12062395e-01f, -8.35792050e-02f, -1.90664992e-01f, -1.25145596e-02f,
  -2.20306203e-01f, -1.36968777e-01f, -1.27807036e-01f, -2.16346253e-02f, -1.34528071e-01f, -6.85058013e-02f, 3.57597694e-02f, -1.42747909e-01f, -1.56536877e-01f, -6.61741942e-02f,
  -1.65999215e-02f, -1.13935634e-01f, -1.16768405e-01f, -4.89222445e-03f, -9.34146866e-02f, -1.87432736e-01f, -5.20485379e-02f, -5.28333560e-02f, -2.46241286e-01f, 1.35951430e-01f,
  3.79118681e-01f, 7.86113665e-02f, 3.77881378e-01f, 4.53179866e-01f, 3.16856563e-01f, 1.34708464e-01f, 1.24824479e-01f, 1.41056582e-01f, 6.78208619e-02f, 1.61324725e-01f,
  -4.95987795e-02f, -1.67983085e-01f, -6.75587505e-02f, -8.93205479e-02f, -6.29268885e-02f, 1.08459122e-01f, 2.79643416e-01f, 7.21034706e-02f, 5.57653494e-02f, 2.44804323e-01f,
  4.79323231e-03f, 1.24557160e-01f, 1.65057510e-01f, 9.66943055e-02f, 1.98489264e-01f, -2.82045593e-03f, 1.18018419e-01f, 1.57048687e-01f, -4.28437181e-02f, 3.31179112e-01f,
  1.05595604e-01f, 1.34725198e-01f, -1.77552402e-02f, -3.62362303e-02f, 7.76966885e-02f, -1.22880593e-01f, 6.31686077e-02f, 9.65871662e-03f, -4.78971750e-03f, -6.28431933e-03f,
  1.16504438e-01f, 2.47909711e-03f, -2.46166177e-02f, 1.00426096e-02f, 1.11646041e-01f, 7.22921193e-02f, -6.66123033e-02f, -5.17702065e-02f, 4.22976613e-02f, 4.20724303e-02f,
  3.60402465e-02f, -6.57751178e-03f, -5.95220365e-02f, -8.10282901e-02f, -8.67598057e-02f, 7.57488143e-03f, -5.92414886e-02f, -3.57511006e-02f, -6.30664080e-02f, -1.79209504e-02f,
  5.03977090e-02f, -3.84144522e-02f, -5.79241216e-02f, -5.18234037e-02f, -6.29752800e-02f, -8.19057971e-02f, -1.20335938e-02f, 3.70408446e-02f, 5.16119711e-02f, -2.15425849e-01f,
  -3.75040099e-02f, 4.87289727e-02f, 1.19409058e-02f, -8.02307855e-03f, -2.59758178e-02f, 1.08017754e-02f, -1.62199158e-02f, -8.51207823e-02f, -3.28473188e-02f, 2.39307135e-02f,
  -8.39462783e-03f, 3.66679765e-02f, 8.69117826e-02f, 1.00460397e-02f, 5.82544804e-02f, -1.33197708e-02f, 7.30090067e-02f, 3.30791958e-02f, -1.91458203e-02f, 3.37290019e-02f,
  -1.53270707e-01f, -1.49811953e-01f, 5.66850565e-02f, -1.22429123e-02f, 4.04364914e-02f, -4.63998131e-02f, -3.41913383e-03f, 2.72756740e-02f, -3.31918746e-02f, 4.78052199e-02f,
  2.69767493e-02f, -3.57824266e-02f, 1.96320657e-02f, -3.85863520e-02f, 7.93300860e-04f, 5.15874103e-03f, -2.00688411e-02f, 6.24850243e-02f, 1.06168136e-05f, 8.12332481e-02f,
  -6.64622188e-02f, -5.52271493e-03f, -9.87412110e-02f, -5.68927824e-02f, -8.47507566e-02f, -6.61906898e-02f, -1.04179844e-01f, -2.39838604e-02f, -8.68131667e-02f, -1.12312615e-01f,
  2.05777735e-01f, -2.66358219e-02f, -4.60361272e-01f, -2.98121311e-02f, -5.96009903e-02f, 3.97671722e-02f, -1.26922160e-01f, 9.37634781e-02f, 2.33925208e-01f, -1.37350233e-02f,
  2.37785861e-01f, 2.87685037e-01f, 1.06816925e-01f, 1.56759098e-01f, -6.18878892e-03f, -1.13985501e-01f, -3.67003143e-01f, -3.47586364e-01f, -8.03183168e-02f, 1.67639494e-01f,
  1.68090045e-01f, -1.63699076e-01f, -1.59946010e-01f, 1.07787944e-01f, -4.72733974e-02f, 1.40390277e-01f, -2.29598030e-01f, -1.51603237e-01f, 3.97922099e-02f, -2.34809041e-01f,
  -1.90148465e-02f, -1.53379634e-01f, 1.70586482e-02f, 5.79680428e-02f, 1.08609319e-01f, 6.70566186e-02f, 7.66610056e-02f, -3.68470810e-02f, 2.52906419e-02f, 4.74232994e-02f,
  3.08714993e-02f, -2.58646207e-03f, -4.03591730e-02f, 7.90346265e-02f, 5.19887097e-02f, 1.05439991e-01f, 9.23945382e-03f, -2.38298066e-02f, -2.91233771e-02f, 6.15908802e-02f,
  1.06366530e-01f, -2.50401758e-02f, 2.31343042e-02f, 2.72616055e-02f, -3.16539109e-02f, -3.30455638e-02f, 7.93344155e-02f, 1.31595537e-01f, 9.93998721e-02f, 1.90674677e-01f,
  3.14035751e-02f, -4.27493080e-02f, -1.29951581e-01f, -1.35090485e-01f, -1.04711704e-01f, -4.39587496e-02f, -1.05169900e-01f, -8.57260972e-02f, 4.66390327e-02f, -7.49591887e-02f,
  -6.09539123e-03f, -8.92269164e-02f, -9.52703059e-02f, -2.62569860e-02f, -6.09473027e-02f, -9.96877700e-02f, 3.53433774e-03f, -1.57545488e-02f, -4.28031348e-02f, -5.79535030e-02f,
  2.55995970e-02f, -5.10803163e-02f, -9.91502181e-02f, -4.45774533e-02f, -1.16057821e-01f, -4.54115868e-02f, -5.03104217e-02f, -9.27957669e-02f, -4.65587564e-02f, -4.44135405e-02f,
  2.10231528e-01f, -8.41742679e-02f, -3.51623558e-02f, 1.72829583e-01f, 3.01904455e-02f, 7.60487542e-02f, -4.80821822e-03f, 3.86470705e-02f, 2.73771528e-02f, 1.21231683e-01f,
  1.07932307e-01f, 2.72642877e-02f, -5.99301830e-02f, 5.17849848e-02f, 5.52185066e-02f, 6.44342974e-02f, 1.35859758e-01f, 1.95387676e-02f, -4.27669100e-02f, 6.20686337e-02f,
  -7.91467447e-03f, 1.16676129e-01f, 2.49874536e-02f, 6.18448332e-02f, 8.39167461e-02f, 7.97993615e-02f, -8.01574886e-02f, 7.03429729e-02f, -2.93090474e-02f, 3.09266075e-02f,
  -4.95618671e-01f, -9.48929563e-02f, 2.54255325e-01f, -8.96642879e-02f, 5.31309284e-02f, -1.56343848e-01f, -3.48028153e-01f, -3.13034326e-01f, -1.66347250e-01f, 1.30166169e-02f,
  2.19684988e-01f, 3.38428140e-01f, 2.90459216e-01f, 1.67840496e-01f, -8.98471177e-02f, -9.10579488e-02f, -2.22422212e-01f, -1.26539215e-01f, -1.05544031e-01f, -7.85798654e-02f,
  4.32352386e-02f, -1.56210378e-01f, -2.04360396e-01f, -5.66630587e-02f, 1.19300084e-02f, 2.00151682e-01f, 1.94140896e-01f, 7.85243139e-02f, 1.57740340e-01f, 5.74588440e-02f,
  3.23382556e-01f, -6.80952743e-02f, -1.73607375e-02f, 7.64159893e-04f, 1.06535785e-01f, -4.03439105e-02f, -4.29972261e-02f, -6.89600259e-02f, -3.98143828e-02f, 6.70279339e-02f,
  2.95665525e-02f, 2.18529291e-02f, -1.11365527e-01f, 4.94743623e-02f, -8.91896039e-02f, 1.88100971e-02f, -3.42464447e-02f, -2.22870372e-02f, -7.27775618e-02f, 4.01381077e-03f,
  1.18086271e-01f, 1.11886017e-01f, 7.99029469e-02f, 4.24386188e-02f, -1.25728650e-02f, 2.98644137e-02f, 7.44865239e-02f, -4.50073369e-03f, 6.01510406e-02f, 3.93627472e-02f,
  -3.48189063e-02f, -3.98776941e-02f, 5.80733002e-04f, -1.01519383e-01f, -1.41714001e-02f, -3.46222073e-02f, 1.77807231e-02f, -1.64892673e-02f, 4.67601456e-02f, -3.78573723e-02f,
  -1.76594742e-02f, 2.16834769e-02f, -7.16900453e-03f, -1.14623867e-02f, 1.77014880e-02f, -2.40212101e-02f, -1.15923725e-01f, -2.73988508e-02f, 7.88244605e-03f, -8.56860355e-02f,
  1.06138485e-02f, -3.71727422e-02f, 5.60861975e-02f, -7.77811334e-02f, 1.77865531e-02f, -8.18444639e-02f, 6.02708943e-03f, -6.03370816e-02f, -2.16419213e-02f, -2.92414445e-02f,
  2.98994482e-02f, -4.70923167e-03f, 1.36515498e-02f, -1.01829916e-01f, -6.10648887e-03f, 3.92182097e-02f, 1.10346235e-01f, 4.05818745e-02f, 1.77504029e-02f, -3.31755616e-02f,
  4.69853031e-03f, -4.76095565e-02f, 4.71460000e-02f, -4.77650017e-02f, 2.74988730e-02f, 5.96269406e-02f, -3.78810316e-02f, -3.50977108e-03f, -5.04868198e-03f, 8.82196724e-02f,
  -7.77765810e-02f, 4.70708981e-02f, -1.85302906e-02f, 3.80228087e-02f, -8.32987428e-02f, -6.40802784e-03f, 1.21234164e-01f, 1.64943337e-02f, 1.72026381e-02f, -5.90223297e-02f,
  1.85674697e-01f, -5.35836862e-03f, -3.07891428e-01f, -1.16926339e-02f, -2.43999343e-02f, 2.01991186e-01f, 2.28369832e-01f, 2.72208124e-01f, 1.29399195e-01f, 6.74919337e-02f,
  -4.05348651e-02f, -2.54232250e-02f, -5.43061271e-02f, -8.87193084e-02f, 1.19299829e-01f, -9.70789716e-02f, -1.59120426e-01f, -1.33096546e-01f, 2.54097730e-01f, 3.35112661e-01f,
  1.17049530e-01f, -8.19835737e-02f, -3.91457118e-02f, 1.14790816e-02f, -1.44436687e-01f, 3.06732729e-02f, -1.86212525e-01f, -2.17466220e-01f, 2.62157600e-02f, -2.90016264e-01f,
  -3.91602278e-01f, -1.53551534e-01f, 5.94337769e-02f, -4.17427346e-02f, -1.17608540e-01f, 4.85695004e-02f, -3.52809355e-02f, -1.22720070e-01f, -2.30847355e-02f, -6.37051314e-02f,
  -1.51016474e-01f, -1.22513399e-02f, -1.03658453e-01f, -3.54427062e-02f, -5.10762781e-02f, 6.77892491e-02f, -1.31216243e-01f, -8.68652388e-02f, -6.30668104e-02f, 1.14148576e-02f,
  -6.94700256e-02f, -1.73812240e-01f, -9.00892913e-02f, -6.92724660e-02f, -7.95477480e-02f, -7.05774128e-02f, -6.49363548e-02f, -2.68188994e-02f, 4.33224998e-02f, -9.23477337e-02f,
  1.36432767e-01f, -4.72685657e-02f, -4.91964584e-03f, 1.39055634e-02f, 6.62487149e-02f, 2.87256707e-02f, -8.00893083e-02f, 6.26214547e-03f, 6.84589222e-02f, 5.36023378e-02f,
  4.07968834e-02f, 1.63748600e-02f, -2.29941923e-02f, -3.96736376e-02f, 3.70390862e-02f, -2.02346817e-02f, 3.27317268e-02f, 3.28324665e-03f, -2.59478157e-03f, -9.82035231e-03f,
  -1.01595558e-02f, -1.66821331e-02f, -4.71611433e-02f, 3.73975597e-02f, -1.06352493e-01f, -2.89696287e-02f, 1.55343721e-02f, 7.66846687e-02f, 5.70478514e-02f, 4.80991676e-02f,
  1.80176705e-01f, -6.94977343e-02f, -8.90853181e-02f, 4.30986136e-02f, -8.23412016e-02f, -5.70361726e-02f, -5.73209338e-02f, 7.49194203e-03f, -5.19326776e-02f, 5.89935966e-02f,
  3.28945033e-02f, -1.99746992e-02f, -6.41622394e-02f, -4.97155190e-02f, 5.49391769e-02f, 3.01319407e-04f, 2.23642774e-02f, 3.15416558e-03f, 9.27008223e-03f, 2.36897394e-02f,
  6.93353936e-02f, 1.31609693e-01f, 2.02248305e-01f, 4.93432768e-02f, 2.47664656e-02f, 2.85687689e-02f, 7.24584609e-02f, 1.78095475e-02f, 4.07110639e-02f, 3.59320372e-01f,
  -1.37355849e-01f, -1.85584381e-01f, -1.83913618e-01f, -2.33016089e-01f, 8.06825384e-02f, 1.82532474e-01f, 1.91699520e-01f, 8.70183855e-03f, -3.57539579e-02f, 1.20679066e-02f,
  -1.30968884e-01f, 7.04003423e-02f, 1.15508929e-01f, 1.15701370e-01f, 7.12499544e-02f, 3.11554838e-02f, 4.02122084e-03f, -4.80200537e-02f, 1.68340459e-01f, 7.10390061e-02f,
  2.71959770e-02f, -2.74487346e-01f, -3.47790182e-01f, -1.48278818e-01f, -3.41356218e-01f, 5.41790985e-02f, -2.73663402e-01f, -2.01262876e-01f, -3.14328335e-02f, -3.93818855e-01f,
  1.65039718e-01f, -1.37671590e-01f, -3.39233465e-02f, -7.17377961e-02f, -9.72562283e-02f, -8.48782063e-02f, -1.16892710e-01f, -2.06260368e-01f, -8.38984326e-02f, -1.05744451e-01f,
  -1.07202403e-01f, -1.18734548e-02f, -8.39197487e-02f, -5.72979599e-02f, -9.60108414e-02f, -6.57198429e-02f, -1.18965663e-01f, -8.17516968e-02f, -8.35439861e-02f, -3.45235579e-02f,
  -2.37110965e-02f, -1.80679962e-01f, -9.38395113e-02f, -1.21231727e-01f, -3.34799737e-02f, 1.12684496e-01f, -1.78360164e-01f, -2.27336287e-01f, -1.10255361e-01f, -3.38810205e-01f,
  8.20332915e-02f, -6.21300116e-02f, 2.99805962e-02f, -7.59948865e-02f, -1.28814420e-02f, 9.32137817e-02f, -1.50112947e-02f, 4.00897600e-02f, 9.39254761e-02f, -2.95975693e-02f,
  -8.35817587e-03f, -2.87606232e-02f, 5.82788489e-04f, -2.95261685e-02f, 4.67404239e-02f, 8.32677074e-03f, 1.96051854e-03f, 2.54088473e-02f, -4.32634875e-02f, -1.98781025e-02f,
  1.14443831e-01f, 1.00069419e-02f, 6.47851080e-03f, -1.17477924e-02f, 3.40333767e-02f, 2.04372499e-03f, 9.75823030e-02f, 1.04185522e-01f, 3.28887664e-02f, 6.54742941e-02f,
  5.01072370e-02f, -2.41050664e-02f, 2.67911274e-02f, -1.62507016e-02f, -7.15627000e-02f, 3.69370803e-02f, -8.74014348e-02f, -4.22529057e-02f, -1.62533239e-01f, -1.52966386e-04f,
  -1.71017237e-02f, 6.57158792e-02f, 7.47416914e-02f, -2.89032273e-02f, -1.53595582e-01f, -1.02146141e-01f, -5.99978827e-02f, 4.48805690e-02f, -5.85444123e-02f, 2.51063053e-02f,
  5.66307008e-02f, 3.37883495e-02f, 8.10062587e-02f, -7.06173256e-02f, -9.07492265e-02f, 6.88226148e-02f, 1.15499251e-01f, -5.89940137e-05f, 1.17324837e-01f, 4.92170453e-02f,
  3.08210373e-01f, -3.06918621e-01f, 1.14671752e-01f, 9.42394435e-02f, 2.17973500e-01f, 4.82518673e-02f, -9.79113579e-02f, -2.10601106e-01f, -7.67028704e-02f, -6.65010661e-02f,
  -2.16662332e-01f, -1.23956546e-01f, -1.93823278e-01f, -1.24850638e-01f, -1.67550683e-01f, 1.02473244e-01f, 2.63443232e-01f, 1.54285014e-01f, 6.46848083e-02f, 2.88338624e-02f,
  4.12969217e-02f, 2.49170944e-01f, 1.96060538e-01f, 4.61538769e-02f, 1.60380065e-01f, 2.10676104e-01f, 2.47319713e-01f, 1.92888781e-01f, 1.34289131e-01f, 5.14176905e-01f,
  -4.47276123e-02f, 9.03839320e-02f, -3.01400991e-03f, -1.33055925e-01f, -7.61035979e-02f, -7.95750096e-02f, -7.78803751e-02f, -2.85867713e-02f, -8.41749012e-02f, -5.21909036e-02f,
  6.16373494e-02f, -2.54600383e-02f, 2.00269930e-02f, 2.47138795e-02f, 1.76826753e-02f, -5.95136397e-02f, -9.55414400e-02f, -1.16956264e-01f, 4.72112596e-02f, -1.23579621e-01f,
  -9.65246111e-02f, 4.38564867e-02f, 6.41555116e-02f, -2.16656551e-01f, -5.88144176e-02f, -9.85536873e-02f, -7.10776076e-02f, 1.39567694e-02f, -4.26158197e-02f, 1.48777757e-03f,
  -1.20924778e-01f, -8.66614431e-02f, -8.51930231e-02f, 2.09888536e-02f, -4.07535136e-02f, 6.80899620e-02f, 1.33786649e-01f, 1.25985280e-01f, -6.61375793e-03f, 4.30630855e-02f,
  -8.64124000e-02f, 4.63432781e-02f, -4.60294075e-02f, 4.48677987e-02f, 2.12421566e-02f, -3.50573286e-03f, 8.58124197e-02f, 2.52658338e-03f, 8.93411934e-02f, 1.91100524e-03f,
  4.23490740e-02f, 8.19917917e-02f, 6.71937242e-02f, 7.65442103e-02f, 2.75847875e-02f, -5.90621643e-02f, 1.30301237e-01f, -2.04107985e-02f, -4.68126163e-02f, 9.05330479e-03f,
  -1.79125249e-01f, 5.94971366e-02f, 1.14682078e-01f, -1.12045957e-02f, 1.47472084e-01f, -7.30863139e-02f, -1.66128960e-03f, -2.93228570e-02f, -4.27594855e-02f, -1.11827450e-02f,
  7.68692978e-03f, -3.11522987e-02f, -6.83806986e-02f, -1.72654241e-02f, 4.19710390e-02f, -4.04249914e-02f, -6.92076981e-02f, 6.16944432e-02f, 3.03940363e-02f, -6.45575523e-02f,
  -9.79383588e-02f, 3.02229151e-02f, -1.16389751e-01f, -1.46592349e-01f, -1.04179615e-02f, 5.56339510e-02f, -2.85948953e-03f, 5.19533679e-02f, 6.28176983e-03f, -1.94026649e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.18651134e-01f, 1.49972960e-01f, 2.98347980e-01f, 1.23497479e-01f, 4.47781198e-02f, -3.37842852e-02f, 4.59816456e-02f, -1.03212342e-01f, -1.72116444e-01f, 7.02505857e-02f,
  2.44928841e-02f, -6.21914901e-02f, 1.17912923e-03f, 3.38269062e-02f, 2.13373244e-01f, -1.35659710e-01f, 3.33834742e-03f, 2.98789561e-01f, 2.15958565e-01f, 6.07844675e-03f,
  7.70121962e-02f, 3.79744560e-01f, 4.74156022e-01f, 2.56072674e-02f, -2.45575309e-02f, -2.13619724e-01f, 1.41791133e-02f, 2.82312363e-01f, 1.60835102e-01f, 2.21381187e-01f,
  1.49176002e-01f, 3.67786616e-01f, -2.66064405e-01f, 4.63200063e-02f, 1.21975243e-01f, -1.01259582e-01f, 3.81905511e-02f, 2.26458646e-02f, -8.42020363e-02f, -1.02243632e-01f,
  -7.93604851e-02f, 4.04504761e-02f, 1.63410604e-01f, 9.32803527e-02f, 1.77186236e-01f, 4.47045155e-02f, 8.39996338e-02f, 1.85376853e-01f, 2.01543774e-02f, 7.64947683e-02f,
  1.29584730e-01f, 2.07677871e-01f, 2.38222212e-01f, -9.58618075e-02f, 3.49984877e-02f, -7.05641210e-02f, -7.66303809e-03f, 1.34972245e-01f, -3.14027183e-02f, -1.38384715e-01f,
  -1.23583637e-02f, 2.45231786e-03f, 1.62894338e-01f, 1.69332862e-01f, 1.55168399e-01f, -2.77434904e-02f, 6.98104277e-02f, 5.76973520e-02f, 4.64821607e-02f, 1.28744423e-01f,
  2.77289897e-02f, 6.85712174e-02f, 6.50113747e-02f, 6.66549727e-02f, -5.30212820e-02f, 1.88211575e-01f, -3.98645032e-04f, 9.53752249e-02f, 5.45226261e-02f, 4.05364297e-02f,
  1.05689697e-01f, 5.52769937e-02f, -2.78522521e-02f, 1.05359197e-01f, 3.13690454e-02f, 6.18358254e-02f, -6.76383600e-02f, 1.70517340e-02f, -8.08080882e-02f, 2.28206888e-02f,
  -2.72954881e-01f, 1.89932927e-01f, -1.52067646e-01f, -1.41751051e-01f, -1.43858269e-01f, -1.01943456e-01f, -5.44398315e-02f, -9.76433530e-02f, -4.42810133e-02f, -1.46239549e-01f,
  -8.65790471e-02f, -8.73108953e-02f, 4.47262153e-02f, -2.45736521e-02f, -1.77388951e-01f, -1.99253082e-01f, 7.01843873e-02f, -1.32976333e-02f, -8.73850659e-02f, -6.59209043e-02f,
  -9.90836844e-02f, -1.55686140e-01f, -1.91764936e-01f, -1.59105703e-01f, -1.55234113e-01f, -3.33177209e-01f, -2.55078256e-01f, -1.30665511e-01f, -2.49751434e-01f, -3.02808344e-01f,
  4.67799336e-01f, 3.84710878e-01f, -3.00574630e-01f, 2.86437750e-01f, -2.07909774e-02f, -1.26337513e-01f, 9.51083750e-02f, 4.77193333e-02f, 1.51997089e-01f, 1.87410817e-01f,
  1.56009838e-01f, -1.74464896e-01f, -2.23817393e-01f, -3.74610752e-01f, -4.63921428e-01f, -1.63355619e-01f, -1.92532212e-01f, -4.10075366e-01f, -6.09638989e-01f, -2.78360665e-01f,
  -5.66981249e-02f, 1.35955691e-01f, 1.55380443e-01f, -1.04775041e-01f, 2.46755078e-01f, -1.37056068e-01f, 2.61055231e-01f, 3.14025015e-01f, -6.36667088e-02f, 1.62051737e-01f,
  -1.74093649e-01f, 9.47418883e-02f, -3.74716789e-01f, -8.77049118e-02f, 5.75831570e-02f, 1.30836636e-01f, -2.42302455e-02f, -5.40676946e-03f, 2.19102234e-01f, 1.53554440e-01f,
  1.37850627e-01f, 9.34934020e-02f, -6.87213764e-02f, 5.35610989e-02f, 5.75245842e-02f, 3.49760391e-02f, 2.19216406e-01f, -7.47906342e-02f, -1.13176130e-01f, 1.96560398e-02f,
  9.55455378e-03f, -4.38334644e-02f, -4.74671796e-02f, -1.52834626e-02f, -6.23576976e-02f, 3.93070746e-03f, 2.42000185e-02f, -1.02333128e-01f, -4.06049937e-02f, 1.66953281e-01f,
  -4.07222658e-02f, 6.98438333e-03f, 4.53309678e-02f, 5.16913161e-02f, 1.54456973e-01f, 2.98072435e-02f, -2.51061637e-02f, 8.86399299e-03f, -2.45290529e-02f, 5.23631684e-02f,
  5.35985306e-02f, 6.62697703e-02f, -8.03443789e-02f, 1.46516636e-01f, -1.93232298e-03f, -9.71609168e-03f, -3.35062072e-02f, 8.58602375e-02f, 4.45037484e-02f, 5.90102933e-02f,
  -6.22141883e-02f, -2.18636487e-02f, -1.43764457e-02f, -1.41910374e-01f, 5.03693847e-03f, 7.06944522e-03f, 5.22842780e-02f, -2.86573172e-02f, 2.71722432e-02f, 6.40606508e-02f,
  -1.74432788e-02f, -4.91397023e-01f, 1.29042014e-01f, 2.32273689e-03f, 6.16579503e-03f, 5.15498258e-02f, 8.26741606e-02f, 2.02120170e-02f, 2.13644609e-01f, 3.38341743e-02f,
  4.21764031e-02f, -4.41109128e-02f, -2.06221975e-02f, -9.01573822e-02f, 1.17767304e-02f, -2.32460871e-02f, 1.29453361e-01f, -4.99876030e-02f, -6.46507964e-02f, 7.34120235e-02f,
  6.94172680e-02f, -2.12404169e-02f, -1.00106321e-01f, -5.24637736e-02f, -3.26311924e-02f, -5.49750514e-02f, -1.03376813e-01f, -4.40384820e-02f, -1.81757942e-01f, 2.29581103e-01f,
  -2.37886190e-01f, -1.65451318e-01f, -3.64309877e-01f, -1.41005605e-01f, 6.06108233e-02f, 2.20392630e-01f, 8.08675960e-02f, 4.02353071e-02f, 9.74836797e-02f, 5.04337884e-02f,
  8.25627446e-02f, 1.32092416e-01f, 3.35479528e-01f, 3.18665236e-01f, 1.30755424e-01f, 1.15858302e-01f, 2.13489920e-01f, 1.53263703e-01f, 6.78536370e-02f, -4.60137241e-02f,
  6.95274174e-02f, -9.49671641e-02f, -7.31185153e-02f, 1.77426487e-01f, 7.36447796e-02f, 1.25185370e-01f, -1.14865275e-02f, -5.04231527e-02f, 8.65507945e-02f, 1.58287331e-01f,
  -4.45786342e-02f, -6.86875284e-02f, -5.67463040e-02f, -4.02986407e-02f, -1.20551512e-01f, -1.53564602e-01f, -9.65794027e-02f, -1.09335884e-01f, 5.27541619e-03f, -5.85827604e-03f,
  -4.06903662e-02f, 6.52381256e-02f, 4.68363762e-02f, -1.46621257e-01f, 2.48391069e-02f, -5.26419543e-02f, -8.61362964e-02f, 9.13035795e-02f, 6.74762111e-03f, 8.96703266e-03f,
  4.23461460e-02f, -1.48178302e-02f, -1.50107577e-01f, 2.48843729e-02f, 1.81307308e-02f, 1.89213697e-02f, 2.90176133e-03f, 1.00959837e-01f, -5.62741887e-03f, 5.80576248e-02f,
  1.54088512e-01f, -1.61849663e-01f, 1.86909493e-02f, 5.73318750e-02f, 2.58284986e-01f, 6.38836548e-02f, 1.25468776e-01f, 2.34469116e-01f, 1.32442385e-01f, -5.35775200e-02f,
  -3.84287052e-02f, 1.25123039e-01f, 6.84064180e-02f, 5.03883585e-02f, 9.01613608e-02f, -1.74362108e-01f, 1.20625675e-01f, 2.81798677e-03f, 9.00330320e-02f, 5.17091453e-02f,
  -4.80878279e-02f, -7.66557604e-02f, 7.69771561e-02f, 2.54329413e-01f, -1.48606114e-02f, -9.81307961e-03f, -1.79446608e-01f, -1.28964946e-01f, -1.32058367e-01f, 1.93245139e-03f,
  -4.46647078e-01f, 2.83937491e-02f, -2.38585491e-02f, 3.42926942e-02f, 1.29242375e-01f, -9.06091034e-02f, -5.02957404e-02f, -3.33516449e-02f, -1.57013699e-01f, -9.20492932e-02f,
  -1.17045261e-01f, -8.85499492e-02f, -4.08460312e-02f, -1.64673895e-01f, 8.30008388e-02f, -1.67156503e-01f, 6.90782070e-02f, 7.27016255e-02f, -1.45312846e-01f, -1.10709369e-01f,
  -1.10194251e-01f, -1.69172019e-01f, -2.81270325e-01f, -1.04477242e-01f, -7.12275133e-02f, -1.65476069e-01f, -5.16718924e-02f, -2.51004785e-01f, -1.57591105e-01f, -2.62053341e-01f,
  -3.84165078e-01f, -1.06819294e-01f, -1.62277631e-02f, 8.56180340e-02f, 4.41855252e-01f, 2.77476013e-01f, -2.07783476e-01f, 7.06147701e-02f, 2.21037373e-01f, -8.80456269e-02f,
  8.43704790e-02f, 7.80646130e-02f, 5.62177598e-03f, -2.33918473e-01f, -5.43826580e-01f, -3.26282233e-01f, -2.32674420e-01f, -4.72257018e-01f, -2.79888034e-01f, 4.65070754e-02f,
  5.72465658e-02f, -1.31931171e-01f, -2.31352985e-01f, -1.84880659e-01f, 5.48498593e-02f, -6.55519664e-02f, -1.59496769e-01f, -1.36717215e-01f, -1.56342462e-01f, -3.33224863e-01f,
  -1.37408987e-01f, -3.19826929e-03f, 1.04373522e-01f, -1.65205002e-01f, 2.51898188e-02f, -1.11199096e-02f, -9.15211290e-02f, 6.23868965e-02f, 2.41803210e-02f, -4.15001810e-02f,
  5.87346312e-03f, -9.03489366e-02f, 1.45545388e-02f, -3.82491983e-02f, -1.21073285e-02f, -7.89929330e-02f, -4.05475236e-02f, -4.72700521e-02f, -1.92383334e-01f, -8.99993703e-02f,
  -8.19154084e-03f, -5.89016192e-02f, -9.15751904e-02f, -4.85325009e-02f, -2.84027886e-02f, 1.68081775e-01f, -2.37232260e-02f, 3.79933417e-02f, -1.38135657e-01f, -1.43213242e-01f,
  -4.88880090e-02f, 8.69455934e-02f, 6.96397945e-02f, 7.90445060e-02f, -2.01926589e-01f, 1.65358379e-01f, 7.86623657e-02f, -7.37660602e-02f, 5.81160858e-02f, 6.28775135e-02f,
  -1.53485179e-01f, 6.18679412e-02f, -1.14739090e-01f, -1.57096729e-01f, -1.81142703e-01f, 1.08379662e-01f, -6.99433908e-02f, -1.17156185e-01f, -1.57151505e-01f, -2.14776453e-02f,
  -6.04393110e-02f, -1.76126289e-03f, 1.12187311e-01f, -2.44006775e-02f, -1.59268621e-02f, -4.89384383e-02f, 8.08668062e-02f, 1.76044460e-02f, 5.70987836e-02f, 1.54555440e-01f,
  -2.41568625e-01f, -1.10658156e-02f, 3.14462706e-02f, -1.99001580e-01f, -1.37467399e-01f, 4.26578075e-02f, -8.75446573e-03f, -2.33326806e-03f, 7.62974983e-03f, -1.65809244e-01f,
  -8.77950490e-02f, -1.75204441e-01f, -5.42892851e-02f, -6.22638874e-02f, -8.32259804e-02f, -1.30172729e-01f, -1.43995047e-01f, -1.23433158e-01f, -2.44685113e-02f, 2.71664411e-01f,
  -1.98476538e-01f, -4.71201301e-01f, -2.99760431e-01f, -1.97329715e-01f, 6.12664819e-02f, -1.69009492e-01f, -2.00220942e-01f, -2.55616516e-01f, -4.36064661e-01f, -5.70858240e-01f,
  -3.62492800e-01f, -4.36063468e-01f, -2.61929147e-02f, -2.59465873e-01f, -1.29387036e-01f, -4.01217714e-02f, -4.10080701e-01f, 3.71694309e-03f, 7.99734890e-02f, -3.80232006e-01f,
  -1.20792776e-01f, 1.98849708e-01f, -1.03872955e-01f, 7.73092955e-02f, -5.94832599e-02f, -5.28895557e-01f, -3.85342300e-01f, -1.33924693e-01f, 5.15063465e-01f, 3.94648224e-01f,
  1.51961833e-01f, -5.29104173e-02f, 1.56391457e-01f, 2.92148255e-02f, -2.64105827e-01f, -1.18404068e-01f, -3.85298640e-01f, -1.01851933e-01f, -3.22138891e-02f, -6.07784212e-01f,
  -2.71009773e-01f, 2.38587707e-02f, 4.91390117e-02f, -3.10397912e-02f, 1.02064557e-01f, 3.08452994e-02f, 6.01290390e-02f, -3.05780326e-03f, 2.03721434e-01f, -1.48668271e-02f,
  -1.70195475e-02f, 2.67699569e-01f, 1.37212798e-01f, 3.99000011e-02f, 1.44665642e-02f, 7.00022355e-02f, 7.11527020e-02f, 1.30657986e-01f, -1.40604302e-02f, -2.49393377e-02f,
  -1.24593049e-01f, -9.71734226e-02f, -7.23760128e-02f, -2.08405368e-02f, 1.01603597e-01f, 1.05008230e-01f, 2.18926787e-01f, 3.98093499e-02f, 4.09273058e-02f, -6.55695915e-01f,
  -2.59548333e-02f, -7.30140582e-02f, 8.02875757e-02f, -1.38082134e-03f, 9.79535375e-03f, 1.09766871e-02f, -9.36469994e-03f, -3.03280149e-02f, 9.69406813e-02f, 1.42163346e-02f,
  1.10870488e-01f, -4.50847074e-02f, -2.10978109e-02f, -1.93059400e-01f, 3.20778489e-02f, -3.97952124e-02f, -1.64763793e-01f, 1.17947506e-02f, 7.03898259e-03f, -6.26161471e-02f,
  1.44259319e-01f, 7.35447854e-02f, 5.10604978e-02f, 8.59311968e-02f, -6.91575706e-02f, -9.67166647e-02f, -1.00706900e-02f, 8.87280777e-02f, 1.76840480e-02f, -8.92301463e-03f,
  -8.39887634e-02f, 7.38862231e-02f, -4.21075195e-01f, 1.90582685e-02f, -8.33116248e-02f, -1.52332008e-01f, -2.38075212e-01f, 1.80783466e-01f, -6.57700077e-02f, 5.96258231e-02f,
  1.14019901e-01f, -1.51566481e-02f, -2.03996032e-01f, 1.09842762e-01f, 1.18254252e-01f, 1.13470167e-01f, -9.06397253e-02f, -8.57222006e-02f, -6.74133077e-02f, -3.19949687e-02f,
  -9.61197913e-02f, -1.60722136e-01f, -2.84318384e-02f, -2.39216179e-01f, -9.54800919e-02f, 1.21999690e-02f, -1.06279537e-01f, -1.93385929e-01f, -1.04049869e-01f, -6.04913890e-01f,
  -1.36778772e-01f, -3.30903262e-01f, -5.91830015e-01f, 2.55629092e-01f, 2.96205223e-01f, -8.74798149e-02f, -6.15444660e-01f, -1.53682694e-01f, 3.71414632e-01f, -9.74467248e-02f,
  2.82173038e-01f, 4.70726877e-01f, 8.65431651e-02f, -1.08817276e-02f, -4.37713742e-01f, -4.21235621e-01f, -2.18866378e-01f, -3.43636721e-01f, -1.27522811e-01f, 1.99011549e-01f,
  2.08333731e-01f, 1.89483911e-01f, 2.78755259e-02f, -5.43556511e-02f, 3.24494421e-01f, 2.43550435e-01f, 1.46026462e-02f, 1.74930647e-01f, 1.04758397e-01f, -8.41873046e-03f,
  -1.27189174e-01f, -1.40615642e-01f, -3.11324317e-02f, 3.97827208e-01f, 1.41935363e-01f, -3.51396263e-01f, -1.45836741e-01f, -1.34124205e-01f, -3.14579457e-02f, -1.25476092e-01f,
  1.33717820e-01f, -4.01574373e-03f, 1.59406632e-01f, 1.35965019e-01f, 9.91196781e-02f, -7.85222873e-02f, -1.65730879e-01f, -2.90406346e-01f, -4.54304338e-01f, -2.38014802e-01f,
  2.15480015e-01f, 2.82011539e-01f, -3.15225750e-01f, -1.43839940e-01f, -2.07018718e-01f, -2.85955109e-02f, -1.70945868e-01f, 1.32424280e-01f, -2.07035854e-01f, -1.52170137e-01f,
  -3.91541272e-02f, 2.48280596e-02f, 2.80663166e-02f, -4.58818041e-02f, 8.58668238e-02f, 1.38899490e-01f, -3.37229995e-03f, 4.11504917e-02f, 8.14955607e-02f, -1.73112769e-02f,
  4.36180718e-02f, -6.66945651e-02f, 9.01347548e-02f, -9.46369693e-02f, 1.22554824e-01f, -3.89860086e-02f, 1.69397891e-01f, -2.45446339e-02f, -1.08400486e-01f, 9.11316369e-03f,
  1.81983281e-02f, 1.00820720e-01f, 5.08017652e-02f, -6.70238910e-03f, -4.85716201e-02f, -1.85196698e-01f, -1.21848926e-01f, -4.50399183e-02f, -1.01891488e-01f, -8.87149498e-02f,
  3.58602256e-02f, -7.67767802e-02f, -2.42713764e-02f, 4.80813943e-02f, -3.35701033e-02f, 1.74163468e-02f, 9.04598609e-02f, -1.20934457e-01f, 1.02270745e-01f, -2.42427722e-01f,
  -3.52483504e-02f, -1.74534231e-01f, 1.47841975e-01f, 8.20132066e-03f, -4.48057341e-04f, 6.97317198e-02f, -7.37776160e-02f, 1.71615370e-02f, -6.21546693e-02f, 2.99949702e-02f,
  -3.02968677e-02f, -1.43975943e-01f, -2.47513518e-01f, -1.93484217e-01f, 7.31274113e-02f, -1.77359357e-01f, -1.34560257e-01f, 8.60772282e-02f, -3.09313267e-01f, -4.79107201e-01f,
  -1.38162613e-01f, -3.24909836e-01f, -4.35249358e-01f, -3.54987830e-01f, -2.39700958e-01f, 1.35305207e-02f, -2.13923782e-01f, 1.22568822e-02f, 1.08144723e-01f, -2.09882602e-01f,
  -6.67642951e-02f, 2.63030469e-01f, 3.79459411e-02f, -7.27632269e-02f, 1.30284205e-02f, -5.47730327e-01f, -4.88862693e-01f, -3.86410475e-01f, 3.41384895e-02f, 3.43868524e-01f,
  3.83857451e-02f, -3.55392963e-01f, -2.31484026e-01f, -1.60498638e-02f, -2.06759155e-01f, -1.96265951e-01f, -5.92372179e-01f, -1.62603378e-01f, 6.73762942e-03f, -4.83330995e-01f,
  -3.65409046e-01f, 8.69013891e-02f, 1.20275341e-01f, 1.65645495e-01f, -2.46013731e-01f, 1.02551363e-01f, -4.47753966e-02f, -2.95609478e-02f, 6.82915598e-02f, -2.65708622e-02f,
  1.10100966e-03f, 1.00443378e-01f, -9.65403840e-02f, -4.69308905e-03f, -1.19721055e-01f, 2.35555880e-02f, 1.54482186e-01f, 2.00136807e-02f, 6.26806244e-02f, 7.98186660e-02f,
  1.88504249e-01f, 1.44149527e-01f, 2.90839344e-01f, 1.72070503e-01f, 2.42744759e-01f, 1.71871528e-01f, 1.38640940e-01f, 3.51416588e-01f, 2.12780580e-01f, 4.72321659e-02f,
  -1.73977241e-01f, -4.28170413e-02f, 2.36291900e-01f, 1.27730310e-01f, 1.44652665e-01f, 1.98607482e-02f, -1.40904477e-02f, 1.30567104e-02f, 3.42071652e-02f, -4.94874865e-02f,
  6.48817644e-02f, 3.53777483e-02f, 4.65192832e-02f, -5.89263476e-02f, -8.17663074e-02f, 3.26209678e-03f, -5.81309944e-02f, 4.95906062e-02f, 1.81168944e-01f, 9.29095447e-02f,
  3.24611813e-02f, 8.94536600e-02f, -2.07555696e-01f, -2.56594759e-03f, 4.43742378e-03f, -2.02304628e-02f, 7.59741291e-02f, 1.26963230e-02f, -3.42673622e-02f, 8.37457627e-02f,
  -1.37642175e-01f, 1.00940131e-02f, -1.53492600e-01f, 1.38084590e-01f, -3.93953770e-02f, 9.22515467e-02f, -5.06485775e-02f, -4.45836373e-02f, -7.04207569e-02f, 1.73979905e-02f,
  1.57360271e-01f, -6.77087754e-02f, -1.09890766e-01f, 9.71120521e-02f, -6.91845790e-02f, 3.58632058e-02f, 2.65984572e-02f, 3.24131884e-02f, 1.60268143e-01f, 1.02375329e-01f,
  -2.02133283e-02f, 1.89757481e-01f, 2.00990245e-01f, -4.72330226e-04f, 1.39268130e-01f, 7.16055408e-02f, -3.59209441e-02f, 1.43019119e-02f, -5.03733233e-02f, -3.19852829e-01f,
  4.35851663e-01f, 5.52434623e-01f, 1.40038908e-01f, -1.71719659e-02f, 1.24677263e-01f, 7.30506629e-02f, 3.06218863e-01f, 3.37749012e-02f, -7.92394504e-02f, 1.29543960e-01f,
  1.10563628e-01f, -4.65869345e-02f, -2.06254005e-01f, -1.90303743e-01f, 1.37738183e-01f, 1.23556942e-01f, 3.87653820e-02f, 1.05856016e-01f, -1.18132137e-01f, 4.90386505e-03f,
  1.24489823e-02f, 2.54066586e-01f, 2.24558100e-01f, 6.70723021e-02f, 2.83882111e-01f, -2.71028459e-01f, 7.78235048e-02f, 1.48937806e-01f, 1.35322556e-01f, 3.44404489e-01f,
  -7.06934370e-03f, 4.36452568e-01f, -4.09499615e-01f, 1.73695534e-02f, 6.48922995e-02f, 6.97262585e-02f, -7.01132715e-02f, 1.20014464e-02f, -1.63332745e-01f, -8.23101103e-02f,
  1.27215385e-01f, -1.80959925e-02f, -2.26268801e-03f, 4.84595634e-02f, 1.61683291e-01f, -8.55269060e-02f, 9.00507644e-02f, 9.81428176e-02f, -1.80804908e-01f, 1.39245754e-02f,
  -9.07621458e-02f, 1.49816409e-01f, 6.39730692e-02f, -2.84223676e-01f, -1.41158536e-01f, -1.91180095e-01f, 1.55757833e-02f, -8.23335424e-02f, -8.67072195e-02f, -3.14502418e-02f,
  -1.50268421e-01f, -1.05081119e-01f, -5.31260334e-02f, -1.74492806e-01f, -1.35501638e-01f, -2.92798840e-02f, -6.85577095e-02f, -3.30811106e-02f, -8.56931210e-02f, 3.49705517e-02f,
  -1.36615321e-01f, -1.77592754e-01f, -1.64359957e-01f, -1.94513961e-03f, -9.41429753e-03f, 3.52097936e-02f, -1.35739133e-01f, -2.16563232e-02f, -6.59387186e-02f, 9.49310660e-02f,
  -7.66524523e-02f, -4.55456860e-02f, 1.10009328e-01f, -1.35851596e-02f, -4.47158851e-02f, -2.52545267e-01f, -1.53906643e-01f, -1.09540679e-01f, -3.65612959e-03f, 7.53084496e-02f,
  -2.27547854e-01f, -2.44911849e-01f, -1.31435752e-01f, 1.52733922e-01f, 1.10942788e-01f, -1.19651086e-03f, -4.09240611e-02f, -1.40810579e-01f, -6.03602827e-02f, -1.04221958e-03f,
  1.53408468e-01f, -4.47521880e-02f, 3.88414972e-02f, 1.22989006e-01f, -3.44540179e-02f, -3.31227742e-02f, -3.28367017e-02f, -4.24950533e-02f, -2.41619628e-02f, 4.09507155e-02f,
  -3.04721147e-02f, -4.65521850e-02f, -2.76928931e-01f, -2.33598515e-01f, -1.31601289e-01f, -4.41611737e-01f, -1.58813059e-01f, -1.47421941e-01f, -9.72446278e-02f, -1.89783722e-01f,
  7.40000546e-01f, 5.53772226e-02f, 3.36205006e-01f, 2.39765853e-01f, 3.88217419e-01f, 3.98787320e-01f, 3.66687268e-01f, 2.04267383e-01f, 5.12326509e-02f, 1.45273760e-01f,
  2.54737228e-01f, 1.41130015e-01f, 4.68729809e-02f, -1.42786905e-01f, 3.96199189e-02f, -7.21457973e-02f, -1.58349425e-01f, 1.26246864e-03f, 1.70630500e-01f, 6.90490305e-02f,
  -4.72649857e-02f, -4.61031646e-02f, 1.85351565e-01f, 2.46168934e-02f, -1.39197767e-01f, -1.19330905e-01f, -6.77308291e-02f, -3.87749374e-02f, -4.07256708e-02f, -4.75571126e-01f,
  -2.10599780e-01f, 1.05169952e-01f, -1.81858718e-01f, -1.32966414e-01f, 7.47546107e-02f, -4.80035618e-02f, 6.40887767e-02f, 8.42815563e-02f, -1.77392587e-02f, -1.57141238e-01f,
  -4.95660938e-02f, -3.97931598e-02f, 4.90224585e-02f, -1.62746534e-02f, 7.55743831e-02f, 1.27301291e-01f, -3.38834450e-02f, 3.77617180e-02f, 9.93013033e-04f, 8.35457165e-03f,
  -2.39186789e-04f, 9.75716785e-02f, 9.03185382e-02f, 5.10978550e-02f, 3.86196487e-02f, 2.88448967e-02f, 1.93323605e-02f, -1.00984536e-01f, 2.41699759e-02f, -1.84202775e-01f,
  2.01980546e-01f, 8.55272412e-02f, 1.11880876e-01f, 6.71613365e-02f, 6.71242625e-02f, 7.79915899e-02f, -1.28843978e-01f, 1.79364625e-02f, 9.73496363e-02f, 1.76681057e-01f,
  -5.92277711e-03f, 1.08834669e-01f, 2.41461828e-01f, 2.03140154e-01f, 3.67135229e-03f, 5.79254329e-02f, -8.87559820e-03f, -7.92682637e-03f, -9.01160389e-03f, 5.58820628e-02f,
  2.33095199e-01f, -1.03446201e-03f, 4.01745848e-02f, 3.09362561e-02f, 6.51517436e-02f, 2.72550546e-02f, 1.52066061e-02f, 8.81173983e-02f, -7.93439522e-03f, 3.94193106e-04f,
  -1.41577810e-01f, 3.35761487e-01f, -1.93941012e-01f, -2.65593156e-02f, 6.72468767e-02f, -9.86968726e-02f, 1.15917578e-01f, -5.86208105e-02f, -1.49343580e-01f, -2.21073836e-01f,
  -3.67290750e-02f, -1.78394578e-02f, 1.01011068e-01f, 8.33334252e-02f, 1.72290310e-01f, 9.33837873e-05f, -2.77037378e-02f, -4.90591228e-02f, -1.17536925e-01f, -1.27694532e-01f,
  -4.51768599e-02f, 3.75873744e-02f, 1.90373696e-02f, 7.77445883e-02f, -3.50349024e-02f, 7.77899995e-02f, -1.97031628e-02f, -4.91032600e-02f, 5.04361056e-02f, -2.68319137e-02f,
  -8.94866228e-01f, 1.46330267e-01f, -1.08950876e-01f, -2.04536900e-01f, 3.39454770e-01f, 4.04876202e-01f, 5.57645261e-01f, 1.51850119e-01f, -1.72898531e-01f, 8.16784725e-02f,
  -9.70330369e-03f, -6.72946274e-02f, -1.39805630e-01f, 1.86543111e-02f, 3.13108340e-02f, 3.20788026e-01f, 3.30136806e-01f, -7.44667202e-02f, -1.87964767e-01f, 1.85143799e-02f,
  1.94701374e-01f, -2.13728219e-01f, -5.21969676e-01f, -4.49742936e-02f, -3.51725332e-02f, 1.63041558e-02f, 2.77098902e-02f, -1.31895080e-01f, 1.71250015e-01f, 1.84469417e-01f,
  -3.84190530e-01f, -1.88041747e-01f, -6.34597838e-02f, -2.23297954e-01f, -1.33216783e-01f, -1.16602547e-01f, -9.18622017e-02f, -2.39918664e-01f, 3.91748883e-02f, -1.46976069e-01f,
  -1.09920047e-01f, -5.83451288e-03f, 4.85101417e-02f, 2.40026531e-03f, -6.07728884e-02f, 1.03136655e-02f, -2.80575734e-02f, -2.84961402e-01f, -1.95192695e-01f, 7.02693388e-02f,
  3.47041726e-01f, -1.02250174e-01f, -3.57476473e-01f, 2.18110412e-01f, 5.58108017e-02f, -2.06595734e-01f, -1.57345627e-02f, -4.12650667e-02f, -1.50335342e-01f, -4.60690469e-01f,
  -1.38090393e-02f, -5.00468761e-02f, 1.48724422e-01f, 6.59970269e-02f, -1.76468771e-02f, 9.05662477e-02f, 7.02824965e-02f, 1.81111749e-02f, 4.54675406e-02f, -3.41815054e-02f,
  1.15669496e-01f, -1.11849964e-01f, -2.99430378e-02f, -1.18657900e-02f, 5.56775108e-02f, -7.31334463e-02f, 1.71836302e-01f, 1.02913901e-01f, 3.25349383e-02f, 5.86473085e-02f,
  -9.86328125e-02f, -1.89443473e-02f, -5.88300712e-02f, -6.78275451e-02f, 4.27889898e-02f, 7.61947185e-02f, -8.53604078e-02f, 2.72768131e-03f, -7.32268691e-02f, -7.81477988e-02f,
  -3.26834291e-01f, 5.16646542e-02f, -2.64607280e-01f, 9.60868523e-02f, 7.11277872e-03f, -1.20823883e-01f, -2.72353385e-02f, -2.10615173e-02f, -6.68507740e-02f, -8.80065113e-02f,
  7.93090835e-02f, -5.18583544e-02f, -1.08021051e-01f, 2.91856192e-02f, -7.42377061e-03f, 7.05204979e-02f, 1.47595510e-01f, -1.07453791e-02f, -1.64100006e-01f, -6.79583848e-02f,
  1.28355548e-01f, -9.35679227e-02f, -3.42805952e-01f, -1.82910860e-01f, -5.54793775e-02f, -3.79841477e-01f, -1.22435652e-01f, -1.28462970e-01f, -2.08612725e-01f, -2.22111702e-01f,
  -4.83106107e-01f, 4.56706062e-03f, -9.87869501e-02f, 3.43212515e-01f, 4.64552790e-01f, 3.32625508e-01f, 2.97484636e-01f, 2.24283755e-01f, 3.29842150e-01f, 1.05259158e-01f,
  1.15600705e-01f, 2.87520051e-01f, 2.53675133e-01f, 1.64168566e-01f, 5.65685481e-02f, 2.20255315e-01f, 3.43388945e-01f, 1.43142730e-01f, 4.04812582e-03f, 1.68836683e-01f,
  3.20037633e-01f, 7.59916380e-02f, -1.58632398e-01f, 7.33058229e-02f, 1.88366830e-01f, 3.19573402e-01f, 1.56723857e-01f, 1.20556176e-01f, 1.51649177e-01f, 3.50725770e-01f,
  1.15875211e-02f, -3.13459903e-01f, 7.11314008e-02f, 1.04167489e-02f, -1.33883283e-01f, -1.05740398e-01f, -8.38350132e-03f, -3.65617755e-03f, -4.39337790e-02f, 8.58219042e-02f,
  -2.24313457e-02f, -1.38347253e-01f, -3.99819911e-02f, -4.14239839e-02f, -5.26449159e-02f, -8.27704296e-02f, -1.66008756e-01f, -3.29187252e-02f, 9.16350707e-02f, 9.53725539e-03f,
  1.32215098e-01f, 1.27736762e-01f, 5.62015995e-02f, 4.30446267e-02f, 7.73870274e-02f, 7.40079535e-03f, -1.29488096e-01f, 4.28738892e-02f, -2.86209565e-02f, 2.51603667e-02f,
  1.58278778e-01f, 2.39317156e-02f, 1.98720545e-02f, -2.70680450e-02f, -1.15151256e-01f, 6.82527572e-02f, 3.47858220e-02f, 8.58202502e-02f, 1.45502836e-01f, -6.62308112e-02f,
  1.34538524e-04f, 1.59379974e-01f, 2.33155079e-02f, -2.05106568e-02f, -2.67689992e-02f, 8.34022760e-02f, -1.37830243e-01f, 1.36390375e-02f, -1.60447016e-01f, -4.35489938e-02f,
  -5.59441112e-02f, -7.25784972e-02f, -7.24332929e-02f, -1.11250810e-01f, 9.83395949e-02f, 5.01596443e-02f, 7.01527596e-02f, 2.70509068e-03f, 6.52277693e-02f, -5.01672439e-02f,
  3.58943015e-01f, -3.91930677e-02f, -7.67159835e-02f, -2.20170300e-02f, -9.28900838e-02f, -2.38386407e-01f, -3.46639417e-02f, -5.31108975e-02f, -1.03683025e-01f, 1.38491318e-01f,
  -1.45427480e-01f, -1.50146917e-01f, -9.77745131e-02f, -1.07918963e-01f, -1.65385932e-01f, -3.87947857e-02f, -4.91516069e-02f, 1.33144572e-01f, 1.23361960e-01f, -1.10703066e-01f,
  -7.27420449e-02f, 1.17138296e-01f, 8.33822116e-02f, 5.49854040e-02f, 4.90948483e-02f, -3.08502894e-02f, -2.84963269e-02f, -1.57584324e-01f, -1.16780236e-01f, -6.88158795e-02f,
  6.03470325e-01f, 3.63782644e-02f, 1.81098655e-01f, 2.70483464e-01f, -5.45476303e-02f, 2.01191083e-02f, -2.40010861e-02f, 1.16031222e-01f, 1.81453034e-01f, 1.11783400e-01f,
  -4.41418551e-02f, 1.50819287e-01f, 1.32100224e-01f, 1.45559654e-01f, 1.27266303e-01f, 3.66010852e-02f, 5.99223822e-02f, 1.76959127e-01f, 2.27123216e-01f, 1.29539773e-01f,
  1.18005581e-01f, -6.84574172e-02f, 2.69335471e-02f, 1.20568506e-01f, 1.28299937e-01f, 9.21140835e-02f, -3.78631130e-02f, -3.11937071e-02f, -7.50053534e-03f, 2.50031769e-01f,
  -3.97435799e-02f, 6.93650022e-02f, 1.64018661e-01f, -4.83411439e-02f, 1.11195948e-02f, 2.23743413e-02f, 1.67199445e-03f, -6.53885305e-02f, 5.95101379e-02f, 2.47529075e-02f,
  -1.35209709e-01f, -1.22704171e-03f, 6.69406876e-02f, -1.40829766e-02f, -6.62467107e-02f, 2.97898296e-02f, 5.52710555e-02f, 1.71173796e-01f, 8.76145884e-02f, -1.36016784e-02f,
  -3.97137925e-03f, -7.35901520e-02f, -1.00397058e-01f, 6.50888262e-03f, 1.44904509e-01f, 2.70375796e-02f, 8.32779184e-02f, 1.08769238e-01f, 7.11969426e-03f, 1.42405897e-01f,
  7.08449706e-02f, 8.03423226e-02f, 5.07498905e-02f, 1.15481637e-01f, 4.80792448e-02f, 1.65261608e-02f, 1.18824244e-02f, -6.55640103e-03f, 1.29383713e-01f, -1.54697215e-02f,
  -1.18355013e-01f, -4.58348133e-02f, 1.49283081e-01f, -1.79069806e-02f, -1.25603065e-01f, -3.54025215e-02f, -1.91826168e-02f, 1.61780138e-02f, -6.75595552e-02f, 4.88653705e-02f,
  -1.75166596e-02f, -1.90841649e-02f, -5.09896390e-02f, -7.77299553e-02f, -9.32915285e-02f, -3.30895744e-02f, -1.41057014e-01f, -1.49122924e-01f, -1.32048965e-01f, -1.16878651e-01f,
  -1.42677739e-01f, 6.45422414e-02f, 1.39789268e-01f, 1.41693905e-01f, 1.39966279e-01f, -8.45397264e-02f, 1.52257890e-01f, 8.47467408e-02f, 7.17706978e-03f, -2.44217049e-02f,
  -2.39408147e-02f, 1.43133581e-03f, -1.07908603e-02f, -1.91420019e-02f, 4.08389457e-02f, -1.03214070e-01f, 5.11137731e-02f, 2.12619126e-01f, -4.86729760e-03f, -1.32773578e-01f,
  -1.33700579e-01f, 7.75152892e-02f, 2.25336873e-03f, 3.70614678e-02f, 1.44784227e-01f, 7.09614903e-02f, -6.31861761e-02f, 1.37329176e-02f, -7.39633515e-02f, 2.54253484e-02f,
  9.05933082e-01f, -6.84520662e-01f, -3.88413578e-01f, 4.92768794e-01f, 1.88501954e-01f, 2.45689631e-01f, -1.90353859e-02f, 1.44303665e-01f, 3.54318798e-01f, -1.20293871e-01f,
  -5.19361377e-01f, -3.63253385e-01f, -3.75698507e-01f, -3.48916233e-01f, -1.31169230e-01f, -1.57348029e-02f, 1.55626014e-01f, -1.05578586e-01f, 1.71299353e-01f, 1.84107333e-01f,
  7.40610287e-02f, 2.61541784e-01f, 2.02205807e-01f, 7.42490357e-03f, -1.21952735e-01f, 4.48921956e-02f, -3.00010622e-01f, -2.29010791e-01f, -3.80157888e-01f, -4.90628242e-01f,
  -2.73382902e-01f, -2.92059153e-01f, 1.51435718e-01f, -4.68995757e-02f, -1.33433148e-01f, -2.79175490e-02f, 5.28814420e-02f, -3.57631892e-02f, 1.02477754e-02f, 4.48195599e-02f,
  -1.08488098e-01f, -4.97477539e-02f, -6.58610836e-02f, -9.62239355e-02f, 1.19011573e-01f, 2.45328862e-02f, 2.82456493e-03f, -1.83916669e-02f, -1.84133887e-01f, -7.83154815e-02f,
  -1.95260808e-01f, 1.14134857e-02f, 1.61230005e-02f, -1.04200251e-01f, -1.22840017e-01f, -7.85581395e-03f, -1.48683101e-01f, -8.23746771e-02f, -1.02402359e-01f, -5.46126962e-02f,
  -7.66545683e-02f, 5.63214906e-02f, -4.67194505e-02f, 3.67055759e-02f, 7.97882900e-02f, 1.08165713e-02f, 5.92532521e-03f, 2.48578694e-02f, 7.87041709e-02f, 7.67473653e-02f,
  -5.22988066e-02f, -7.26757497e-02f, 1.08798705e-02f, -1.55230388e-02f, -1.00756884e-01f, 3.81714590e-02f, 4.29956578e-02f, -5.45134917e-02f, -1.93711668e-02f, 1.00942403e-01f,
  -5.84998652e-02f, -9.30524990e-03f, 1.24298163e-01f, -4.24656197e-02f, 4.88287956e-03f, -6.23124130e-02f, -2.92581948e-03f, -1.04527637e-01f, 3.14682834e-02f, -1.18675195e-02f,
  1.22237593e-01f, -2.54329890e-01f, 9.87582579e-02f, -9.80809331e-02f, -2.65381881e-03f, -1.45288622e-02f, -1.43790603e-01f, -2.46874541e-02f, 2.23588683e-02f, -4.65306379e-02f,
  -1.39032882e-02f, 1.30319558e-02f, -8.88007954e-02f, -1.10879578e-01f, 1.82131529e-01f, 4.70664762e-02f, -9.22170728e-02f, 3.08013353e-02f, 8.15542191e-02f, 8.90259519e-02f,
  2.08273195e-02f, 1.07437655e-01f, 2.41632536e-01f, 1.09743416e-01f, 6.29336610e-02f, 1.37288690e-01f, 7.37244189e-02f, 3.48586291e-02f, 1.25641182e-01f, 3.52742612e-01f,
  1.04150605e+00f, -3.43034744e-01f, 3.88016105e-02f, 2.17883468e-01f, 2.28929371e-01f, 2.60729969e-01f, 1.95974737e-01f, 1.43461391e-01f, 1.10259660e-01f, -2.80988775e-02f,
  1.04098953e-01f, 8.02494064e-02f, 8.00938681e-02f, -3.88416722e-02f, 3.98109071e-02f, -1.59023888e-02f, -2.43143085e-02f, 2.32704878e-01f, 2.61080563e-01f, 1.27656147e-01f,
  -1.21689677e-01f, -1.03126250e-01f, 6.76852763e-02f, -5.60462847e-02f, -1.23747185e-01f, 4.14371379e-02f, -4.02609073e-02f, -5.34194410e-02f, -1.27416730e-01f, -4.43274051e-01f,
  -3.33976150e-01f, 1.25259027e-01f, -5.69213182e-02f, -7.17216730e-02f, -8.49288478e-02f, 2.53098588e-02f, -8.08161795e-02f, -2.01193124e-01f, 6.23633387e-03f, -6.44342303e-02f,
  1.02280057e-03f, -2.08415203e-02f, -9.41502675e-02f, -1.50932476e-01f, -2.39292216e-02f, -3.42837386e-02f, -3.34926918e-02f, -3.49912569e-02f, -1.79152608e-01f, -2.18577266e-01f,
  -1.17730021e-01f, 5.23850732e-02f, -1.91009119e-02f, 1.02804527e-01f, 5.65119088e-02f, 1.53285280e-01f, -6.25832900e-02f, 8.13407674e-02f, 1.17264330e-01f, 5.38257658e-02f,
  -1.24843173e-01f, -2.90077459e-02f, -3.06462124e-02f, 6.75015599e-02f, 3.72045822e-02f, -2.26164814e-02f, 1.50386421e-02f, -4.19006869e-02f, 1.45880565e-01f, -1.99036803e-02f,
  -1.37219131e-01f, -9.73854505e-04f, -1.40864365e-02f, -9.34790354e-03f, -5.11010624e-02f, -4.15626206e-02f, -6.13207072e-02f, -2.10979447e-01f, 3.19014080e-02f, 3.56613621e-02f,
  -1.31554380e-01f, 1.35050025e-02f, -5.99411353e-02f, -1.78683847e-01f, -8.96043107e-02f, -1.31817415e-01f, -8.97808820e-02f, -1.94181427e-01f, -2.85804179e-03f, 8.76915529e-02f,
  -3.98152858e-01f, 1.66864708e-01f, 9.98134241e-02f, -5.29288985e-02f, -3.70589197e-02f, -1.06254518e-02f, 6.69108257e-02f, -1.14394158e-01f, -1.11672796e-01f, -3.41185071e-02f,
  -8.83378759e-02f, 9.15557425e-03f, -8.04709494e-02f, -1.05221570e-01f, 1.22911058e-01f, -2.35693343e-02f, 3.61559540e-02f, 1.92020908e-02f, -8.11772048e-02f, -1.51667446e-01f,
  -1.43260077e-01f, 4.65657227e-02f, 1.46032035e-01f, 1.81635469e-01f, 9.71920323e-03f, 1.50354877e-01f, 4.39342707e-02f, 6.49420638e-03f, 2.97987182e-02f, 2.01776773e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.97615433e-01f, 5.13414741e-01f, 2.14504927e-01f, 4.28832360e-02f, 2.92081237e-01f, 2.87159942e-02f, -7.55755454e-02f, 9.89790633e-02f, 3.44016552e-01f, -5.22585660e-02f,
  1.33833945e-01f, -1.02838963e-01f, 4.11500424e-01f, 3.71836126e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.28354684e-01f, -8.43256935e-02f, -7.16903806e-02f, 9.05595943e-02f, 1.09328181e-01f, -8.17630589e-02f, -7.47034997e-02f, 3.72073837e-02f, -1.72243744e-01f, 7.29652047e-02f,
  2.71003786e-02f, 1.68676168e-01f, 9.62132737e-02f, -2.79863238e-01f, -1.71602234e-01f, -1.20597363e-01f, -1.27287447e-01f, 7.83264339e-02f, 2.20438689e-01f, 4.85768020e-01f,
  1.20004416e-01f, 9.42174494e-02f, -3.61399621e-01f, -2.29151085e-01f, -1.10486165e-01f, 3.40671450e-01f, -1.75418690e-01f, -3.23160112e-01f, -2.29809627e-01f, 1.53604537e-01f,
  7.92016089e-02f, -2.46088341e-01f, -4.38928679e-02f, 3.29367705e-02f, -2.67070364e-02f, -1.43751735e-02f, 6.87576085e-02f, -2.37793371e-01f, -2.32654214e-01f, -9.63347107e-02f,
  -6.05108328e-02f, 4.01821136e-01f, -8.17146301e-02f, 8.89928490e-02f, 1.23362876e-01f, -7.62458518e-02f, -1.32337138e-02f, -6.07140362e-02f, -1.10855237e-01f, 7.72105996e-05f,
  1.33971006e-01f, 2.95970559e-01f, -2.53572345e-01f, 4.38889712e-02f, -4.91090626e-01f, 1.22038484e-01f, -1.39451131e-01f, 1.90951735e-01f, -6.00681044e-02f, 7.03315251e-03f,
  -4.42314669e-02f, 1.93057284e-01f, 1.09508641e-01f, -2.96877980e-01f, 7.68996626e-02f, -2.62048185e-01f, 4.25477028e-02f, -5.78927249e-02f, 7.53102899e-02f, -1.62559539e-01f,
  4.63882126e-02f, -7.66827539e-02f, 1.21025808e-01f, -6.41305149e-02f, -5.20109355e-01f, 8.80565345e-02f, 2.03258544e-01f, -1.00772232e-01f, -1.26257494e-01f, -1.50944471e-01f,
  8.75676498e-02f, -9.99063253e-03f, -1.22799519e-02f, 1.46322370e-01f, -2.73851931e-01f, -7.68530592e-02f, -2.15133563e-01f, -3.02506000e-01f, -3.13079566e-01f, 1.18634351e-01f,
  7.83559009e-02f, 3.24577153e-01f, 8.40403512e-02f, 7.35127702e-02f, 1.04899362e-01f, 2.23543376e-01f, 1.05329238e-01f, -1.14693528e-03f, 1.00849703e-01f, 1.93303406e-01f,
  -1.11960344e-01f, -5.05484222e-03f, 9.62028652e-02f, 1.19837122e-02f, -7.53920302e-02f, -4.66131791e-02f, 1.33332565e-01f, -2.51250877e-03f, 1.57412533e-02f, 1.45369887e-01f,
  4.79214117e-02f, 1.99891925e-01f, -7.27371080e-03f, -4.37523164e-02f, -3.75436917e-02f, 6.60393108e-03f, 1.00259811e-01f, 9.80320349e-02f, 5.40897399e-02f, 3.72298628e-01f,
  2.70354182e-01f, 1.44457743e-01f, 3.19499969e-01f, -3.78318697e-01f, -9.61400717e-02f, -2.20551670e-01f, 1.76456198e-01f, 3.80789116e-02f, 1.18227266e-01f, 4.35703211e-02f,
  -5.01805311e-03f, 1.53118297e-01f, 9.10835154e-03f, 1.31345931e-02f, 2.08027568e-02f, 8.69652107e-02f, 1.69745274e-02f, -2.19406083e-01f, -7.07562804e-01f, 3.72913517e-02f,
  6.55256305e-03f, -1.11116461e-01f, -4.80162129e-02f, 8.23133364e-02f, 1.50242567e-01f, -1.54549822e-01f, 2.32703298e-01f, -4.00468588e-01f, -9.02318358e-02f, 2.59776860e-01f,
  3.07665437e-01f, -3.61250430e-01f, 3.63982856e-01f, 2.45283693e-01f, 1.79099396e-01f, 3.55350003e-02f, -1.96615964e-01f, -1.58655066e-02f, 5.01289852e-02f, 7.16012029e-04f,
  -1.95919145e-02f, -2.34872997e-01f, -5.07548563e-02f, -1.48727363e-02f, 6.94054365e-02f, -8.68785456e-02f, 7.79429376e-02f, -3.27378847e-02f, 5.92017472e-02f, -4.74447501e-04f,
  -7.31166661e-01f, -5.99509701e-02f, 1.05220623e-01f, -1.59371763e-01f, 8.45949948e-02f, -1.32450476e-01f, 6.39923587e-02f, 1.58504292e-01f, 2.02911660e-01f, -1.93801284e-01f,
  -1.35930270e-01f, -1.20624863e-01f, -1.25922531e-01f, -3.89636397e-01f, -2.43724316e-01f, 1.43706664e-01f, -3.97075005e-02f, 3.49105120e-01f, -1.68444529e-01f, -2.80867945e-02f,
  3.20661455e-01f, 2.51473278e-01f, -3.69269773e-02f, -3.47556770e-01f, 6.18400169e-04f, -1.00819804e-01f, -2.59912401e-01f, -1.27852308e-02f, -8.62491727e-02f, -4.95253801e-02f,
  -1.46425352e-01f, -1.36427075e-01f, -3.48519683e-01f, 1.30746216e-01f, 3.28687802e-02f, 1.63239568e-01f, -1.80984929e-01f, 2.00573236e-01f, -1.47381440e-01f, 1.76178440e-01f,
  -9.66296941e-02f, -2.49865830e-01f, 6.42050803e-02f, -1.04093805e-01f, 4.94458340e-02f, -6.82978407e-02f, 2.12572180e-02f, -9.90970805e-02f, -2.69854248e-01f, 4.72335696e-01f,
  1.95219353e-01f, -1.00256197e-01f, 3.54209930e-01f, -1.00689776e-01f, -1.15336902e-01f, 8.08742642e-02f, 6.46869168e-02f, 1.81255508e-02f, 3.55571844e-02f, -1.71765581e-01f,
  -4.89038862e-02f, -3.56829762e-02f, -1.19146600e-01f, 3.76038134e-01f, -5.12908213e-02f, 1.72071949e-01f, -1.41374946e-01f, -2.12750118e-02f, -4.01047952e-02f, -1.55705288e-01f,
  -1.09276898e-01f, -1.45483240e-01f, 1.04961239e-01f, 5.79767227e-01f, -3.72411460e-01f, 2.05928802e-01f, -2.60017306e-01f, 3.03998590e-01f, -3.42268229e-01f, 3.32992673e-01f,
  -5.93452379e-02f, -4.44575459e-01f, 9.65089127e-02f, -2.16306180e-01f, 1.23217061e-01f, -1.60828792e-02f, 4.61952627e-01f, -6.20013885e-02f, 2.99715828e-02f, -1.03452981e-01f,
  -3.62546705e-02f, 1.24479152e-01f, -4.13869545e-02f, 5.35377599e-02f, -4.53336723e-02f, -3.16187769e-01f, 3.93663824e-01f, 1.35246530e-01f, 2.71816164e-01f, -4.66999738e-03f,
  -4.57313329e-01f, 2.96216130e-01f, -1.13971867e-01f, 2.20716283e-01f, 6.84969276e-02f, 1.24029249e-01f, -1.50492474e-01f, -4.11585532e-02f, 2.12801695e-02f, 1.49790362e-01f,
  6.61358386e-02f, 1.46734014e-01f, 6.57560155e-02f, -6.01035357e-02f, 1.06819384e-01f, 1.24456912e-01f, 4.59994018e-01f, 1.45696431e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -5.08895628e-02f, 9.98345241e-02f, -6.48240671e-02f, -1.35665592e-02f, -5.51861860e-02f, -1.31292179e-01f, -1.69194728e-01f, -2.11581722e-01f, -9.25845802e-02f, 6.57528341e-02f,
  -4.72547747e-02f, -5.52842729e-02f, 1.55710831e-01f, 2.53409445e-01f, 9.21424404e-02f, -1.22965649e-01f, -2.48988613e-01f, 2.78378725e-01f, -2.84618318e-01f, 5.46628535e-01f,
  3.19992602e-02f, 4.60766762e-01f, 5.69908917e-02f, 3.40498984e-01f, 3.55481744e-01f, -5.03461808e-02f, -2.61978090e-01f, -1.00219987e-01f, -1.19535960e-01f, -3.11003346e-03f,
  -2.87265807e-01f, -1.24712005e-01f, 7.74033740e-02f, -7.36365095e-02f, 3.38026658e-02f, 2.24230234e-02f, -1.17453095e-03f, 2.82597959e-01f, 2.86857307e-01f, 1.73748359e-01f,
  -5.01579642e-01f, 2.98625052e-01f, -4.32201147e-01f, 1.87548652e-01f, -3.40459019e-01f, 2.33471125e-01f, -1.68874100e-01f, 3.76324177e-01f, 1.43963739e-01f, 1.96832836e-01f,
  -4.22745824e-01f, 2.24942252e-01f, 2.65028387e-01f, 4.13129032e-01f, 2.88504601e-01f, 1.50419056e-01f, 2.65997320e-01f, 1.20510779e-01f, 4.55094688e-02f, 6.85274661e-01f,
  1.71144441e-01f, -2.13659152e-01f, 7.04564974e-02f, 1.81444183e-01f, -9.02107954e-02f, 5.96381068e-01f, 3.43358934e-01f, 2.88236976e-01f, 2.80152738e-01f, 3.57553661e-02f,
  1.05213515e-01f, 1.26976177e-01f, 7.47441724e-02f, -1.72658280e-01f, -4.00599688e-01f, 4.24012393e-02f, 1.13622071e-02f, -2.44205862e-01f, 4.34470832e-01f, -5.69507539e-01f,
  -2.33121291e-01f, 2.69943833e-01f, 2.10259467e-01f, 3.65380704e-01f, 2.27431387e-01f, 6.43710434e-01f, 2.88000882e-01f, 6.30215108e-01f, 2.15767801e-01f, 2.29538992e-01f,
  -9.97147933e-02f, 2.09928200e-01f, -1.21284604e-01f, -1.01555869e-01f, -5.97060859e-01f, -4.77815062e-01f, -1.33751230e-02f, 3.66878301e-01f, 1.51249141e-01f, 9.01602805e-02f,
  1.10163525e-01f, 1.40129149e-01f, -4.39878926e-02f, 2.03107417e-01f, -1.30410641e-01f, 4.30524677e-01f, 5.04422128e-01f, 2.04298675e-01f, -2.73198158e-01f, 2.89735973e-01f,
  -1.11905605e-01f, 2.80413270e-01f, 3.44327092e-01f, -4.47260201e-01f, -1.36646004e-02f, 4.67354327e-01f, -2.89258715e-02f, -8.71830508e-02f, -4.44234252e-01f, 2.50968933e-01f,
  -1.72883347e-02f, -1.16812056e-02f, 2.44777754e-01f, -2.15201572e-01f, 1.34804547e-01f, 1.22245975e-01f, 6.23420477e-01f, 4.10703540e-01f, 3.42211187e-01f, -4.23670709e-01f,
  -3.90373357e-02f, -3.06798488e-01f, 2.15439439e-01f, 2.61266917e-01f, 1.32776558e-01f, 2.15089321e-02f, 2.81424940e-01f, -2.09632084e-01f, -3.48161859e-03f, -6.71318546e-02f,
  1.57905594e-01f, 2.64936149e-01f, 9.10766423e-02f, -4.35483782e-03f, -5.13489172e-02f, 5.29715605e-02f, 5.09660602e-01f, 2.51801699e-01f, -1.84837848e-01f, 2.50966139e-02f,
  5.10118783e-01f, -6.88068345e-02f, 2.81609476e-01f, 5.68244278e-01f, 5.98203659e-01f, -1.22422136e-01f, -1.30137473e-01f, 2.22068224e-02f, 2.63246953e-01f, 2.74159312e-01f,
  -2.23958135e-01f, 6.40260160e-01f, 2.64149517e-01f, 1.83121577e-01f, 4.09287483e-01f, 3.58307600e-01f, 1.44541144e-01f, 3.95752698e-01f, 2.57236719e-01f, 2.41172820e-01f,
  9.33083951e-01f, 1.50027305e-01f, -3.73537809e-01f, 1.49683729e-02f, 8.60450193e-02f, -1.38362125e-02f, 1.47386402e-01f, -4.74447101e-01f, 1.25638777e-02f, 4.19439763e-01f,
  1.43192768e-01f, 1.66934535e-01f, 3.33320126e-02f, 3.25423837e-01f, 2.45716825e-01f, 1.34286731e-01f, -2.48163920e-02f, -2.78793871e-01f, -1.26789853e-01f, -2.95118272e-01f,
  4.41677943e-02f, 2.79325768e-02f, 1.68342471e-01f, -2.58744597e-01f, -1.76022559e-01f, -1.99941188e-01f, 1.98162481e-01f, -3.32301930e-02f, 3.86902248e-03f, 1.50441274e-01f,
  1.82187885e-01f, 2.03093678e-01f, -8.16307485e-01f, -1.78858861e-01f, 3.86232853e-01f, -5.87733313e-02f, -1.62482157e-01f, -1.39218522e-03f, -8.02258402e-02f, 3.62200022e-01f,
  2.28206977e-01f, 8.66858140e-02f, 3.68974693e-02f, 5.26508242e-02f, -6.20362222e-01f, -2.07007438e-01f, -1.77348912e-01f, 2.43200779e-01f, 3.14332277e-01f, 3.99392635e-01f,
  3.30758512e-01f, -8.58891457e-02f, 2.31786460e-01f, 1.13914169e-01f, 2.43659824e-01f, -1.46006286e-01f, 7.93356374e-02f, -2.60482401e-01f, -2.81686615e-02f, 3.01635891e-01f,
  2.57750571e-01f, 1.17917538e-01f, 4.86380197e-02f, -4.25944924e-01f, 5.74400306e-01f, 2.39615142e-02f, 1.30728632e-01f, 2.50336546e-02f, -1.35016710e-01f, 1.41453817e-01f,
  1.45031288e-01f, 2.80724496e-01f, 3.29306901e-01f, -1.06108479e-01f, 2.82563180e-01f, -1.91243276e-01f, 2.56999165e-01f, 1.83279067e-01f, 1.84621066e-01f, 1.22858129e-01f,
  1.25494853e-01f, -5.21708488e-01f, -1.02623202e-01f, 2.53316194e-01f, 7.06643343e-01f, 4.22456652e-01f, 1.21956192e-01f, 8.77725035e-02f, 1.92569777e-01f, 1.30509976e-02f,
  2.29766279e-01f, 2.25962326e-01f, 2.16449127e-01f, 2.00561702e-01f, -4.20089737e-02f, -2.45710388e-01f, -4.76302728e-02f, -2.12961480e-01f, -9.13076401e-02f, 2.80082338e-02f,
  1.40331343e-01f, -1.16318315e-01f, 2.63696760e-01f, -2.68103510e-01f, -7.62239471e-02f, -3.98756057e-01f, 3.50231558e-01f, 4.38589305e-01f, 1.45508155e-01f, 1.82427824e-01f,
  3.06710601e-01f, -3.88827354e-01f, 1.81999490e-01f, 6.66507304e-01f, 4.36635047e-01f, 9.37085748e-02f, -4.45696980e-01f, 1.97877720e-01f, 5.12549579e-02f, 1.37403712e-01f,
  1.09773897e-01f, -7.94099048e-02f, 4.57349531e-02f, 2.74153128e-02f, 1.48608670e-01f, -1.01463087e-02f, -5.59475496e-02f, -1.57275826e-01f, 3.30517918e-01f, -8.57103616e-02f,
  5.52724414e-02f, 1.01677924e-01f, -1.25435479e-02f, 1.52298212e-01f, -8.76926705e-02f, -1.90774962e-01f, -9.75494608e-02f, -4.68742639e-01f, -1.21847838e-01f, -6.03986800e-01f,
  -1.26148909e-01f, -3.49676348e-02f, 8.84931907e-02f, -3.51948798e-01f, 1.87326357e-01f, -5.06399214e-01f, 3.74446541e-01f, -2.83028800e-02f, 6.55468583e-01f, 3.35047007e-01f,
  4.95014310e-01f, 1.80296496e-01f, 1.88551843e-01f, 3.33875716e-01f, 3.43138985e-02f, 7.07696145e-03f, 3.47949229e-02f, 2.80935675e-01f, 3.21259946e-01f, 1.95213214e-01f,
  1.69306681e-01f, -6.90857992e-02f, -3.92096415e-02f, 4.17721659e-01f, 4.61942554e-02f, -3.67615893e-02f, -2.09444538e-01f, 1.49507761e-01f, -1.13021834e-02f, 5.17376423e-01f,
  -3.30858141e-01f, 4.47273999e-01f, 4.43987340e-01f, 7.48256564e-01f, -9.04696509e-02f, -1.71759650e-01f, 4.33030874e-01f, -4.29820746e-01f, 9.40595046e-02f, -4.54515278e-01f,
  3.60180259e-01f, 2.76272357e-01f, 6.08258955e-02f, -5.16459867e-02f, 3.10833484e-01f, -1.29185498e-01f, 4.13969979e-02f, 4.07857485e-02f, 1.44881099e-01f, 2.82695770e-01f,
  -1.90348551e-02f, 1.92129657e-01f, -2.81897545e-01f, 1.57568101e-02f, 1.92888394e-01f, 4.17543761e-02f, 5.58284074e-02f, 2.30512135e-02f, 1.05406478e-01f, 2.71153033e-01f,
  -3.20586652e-01f, 1.20811298e-01f, 2.41049632e-01f, 2.62944520e-01f, -5.39223671e-01f, 6.74462438e-01f, 1.27393886e-01f, -1.43760182e-02f, -3.14016134e-01f, 6.76914155e-01f,
  3.86032224e-01f, 6.56943023e-02f, -4.75996584e-01f, -4.33215767e-01f, 4.47958946e-01f, -3.57390821e-01f, 1.91589296e-01f, 2.27112293e-01f, 1.21769108e-01f, 2.09521517e-01f,
  1.36975035e-01f, 2.67217547e-01f, 1.26461372e-01f, 3.01395003e-02f, -6.30237401e-01f, 6.16919026e-02f, 9.15939212e-02f, 1.59219265e-01f, -2.97351778e-01f, 3.32673311e-01f,
  -1.04941256e-01f, 2.52417535e-01f, -1.86985865e-01f, 2.53364861e-01f, -3.09337646e-01f, 3.44775259e-01f, 2.67034084e-01f, 2.73604780e-01f, 4.15853336e-02f, 9.59464982e-02f,
  4.59822357e-01f, 3.40188034e-02f, 5.11909649e-02f, -1.62427172e-01f, 8.18781435e-01f, 1.99948981e-01f, 1.73672140e-01f, 2.09358394e-01f, 4.91764210e-02f, 2.73784548e-01f,
  2.01692060e-01f, 9.75805074e-02f, 2.44090915e-01f, 4.56536114e-01f, 3.68445933e-01f, -3.58718038e-01f, -1.79549679e-02f, -2.38371298e-01f, 3.91822934e-01f, -4.26790535e-01f,
  -1.08165830e-01f, -3.06231558e-01f, -1.78676724e-01f, 4.28736389e-01f, 6.43897295e-01f, 4.04767960e-01f, 6.23423569e-02f, 1.88134775e-01f, 3.59930456e-01f, 3.45446706e-01f,
  -4.88532007e-01f, 6.82164073e-01f, 4.13565002e-02f, -8.79860744e-02f, 4.16730158e-02f, -5.16909994e-02f, -5.54262936e-01f, 8.03233497e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  -1.25069529e-01f, 3.56868833e-01f, 3.30047637e-01f, 1.68609768e-01f, 1.14662141e-01f, 5.88522673e-01f, 8.96169171e-02f, 1.55139014e-01f, 1.48876190e-01f, 8.54712501e-02f,
  -1.03839301e-01f, 2.68568009e-01f, -9.72153917e-02f, 1.65675759e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  7.18485937e-02f, 4.08538073e-01f, 1.68664575e-01f, -6.60144761e-02f, 1.20629258e-01f, -7.21793324e-02f, 5.05575128e-02f, 1.45888343e-01f, 3.40861431e-03f, 4.26725030e-01f,
  5.57415485e-01f, 3.44918430e-01f, -2.46748235e-03f, 2.09433779e-01f, 3.04650277e-01f, -1.22550152e-01f, 2.85402089e-01f, 4.48315479e-02f, 6.34250864e-02f, -6.91654831e-02f,
  7.70444945e-02f, 9.47314426e-02f, 3.43299881e-02f, 4.69003059e-02f, 1.65248215e-01f, -1.05074629e-01f, -4.06790048e-01f, -9.19674411e-02f, 6.30941093e-02f, -3.32623929e-01f,
  1.74404327e-02f, 9.91873518e-02f, -2.03883931e-01f, 1.26590192e-01f, 2.06048377e-02f, -5.62472999e-01f, 5.78082306e-03f, -2.14933857e-01f, -2.49085613e-02f, -1.30843520e-01f,
  -2.54157603e-01f, 2.70787656e-01f, 4.77001160e-01f, -1.45775199e-01f, -8.56285021e-02f, 2.08660677e-01f, -2.15074480e-01f, 2.80795813e-01f, 3.49190146e-01f, -2.59873539e-01f,
  4.40750450e-01f, -7.51203820e-02f, -3.59538496e-02f, 2.43767217e-01f, -2.34308112e-02f, -1.55969337e-01f, -7.95441642e-02f, 5.43115512e-02f, 7.14085847e-02f, -1.22875273e-01f,
  1.68506593e-01f, 3.86367083e-01f, -5.12956262e-01f, -7.22135529e-02f, 7.22598583e-02f, -4.57038581e-01f, 5.79684563e-02f, -4.27947074e-01f, -5.56048518e-03f, -3.48438770e-01f,
  -1.60628811e-01f, -2.51462132e-01f, -1.15302116e-01f, -1.51835844e-01f, 3.41969490e-01f, 3.59923899e-01f, -4.67962265e-01f, -4.51898932e-01f, 1.89249784e-01f, 2.47711658e-01f,
  -5.69123507e-01f, 1.67303964e-01f, -1.58122644e-01f, -2.10856483e-03f, -5.24768420e-02f, -2.45384410e-01f, 2.66334265e-01f, -1.85625747e-01f, 3.07233810e-01f, -4.69572805e-02f,
  -1.45098776e-01f, -1.40163392e-01f, 1.78044066e-01f, 2.16026589e-01f, 1.09169021e-01f, 2.10913777e-01f, 2.80862227e-02f, 1.98923275e-01f, -2.23339107e-02f, -1.53603908e-02f,
  1.37655228e-01f, -1.17603406e-01f, 2.85578854e-02f, 7.56895617e-02f, -2.32196581e-02f, 1.41884029e-01f, 3.38520527e-01f, -2.00078517e-01f, 1.54543787e-01f, 1.79641277e-01f,
  -6.05214238e-02f, -4.71909374e-01f, 2.62876719e-01f, 8.07982218e-03f, 1.09773934e-01f, -2.29655594e-01f, 3.46566379e-01f, -3.34689230e-01f, -1.18273385e-01f, -7.80817866e-02f,
  -1.92100443e-02f, -2.23528415e-01f, -2.10242391e-01f, 3.21164764e-02f, 3.63348499e-02f, -7.30210319e-02f, -3.53453658e-03f, 2.76886880e-01f, -4.22380298e-01f, 1.98592246e-01f,
  3.55578810e-01f, 3.43691856e-01f, -5.31909950e-02f, 7.53453597e-02f, 1.79152280e-01f, 3.62641104e-02f, -3.35985720e-02f, -3.94316733e-01f, -2.30811030e-01f, -9.30004865e-02f,
  -1.58303946e-01f, -3.86950254e-01f, 1.77717388e-01f, 2.65174299e-01f, -2.87209302e-01f, 1.32532954e-01f, -9.96476933e-02f, 3.64930421e-01f, -1.06055409e-01f, -8.65993798e-02f,
  7.14541078e-02f, 1.72907785e-01f, -4.68113972e-03f, 1.14307873e-01f, -1.10683084e-01f, 2.05816686e-01f, -2.34624580e-01f, -3.28128040e-01f, 1.00557350e-01f, -2.69846946e-01f,
  1.49791256e-01f, 4.10969645e-01f, -1.55840423e-02f, -2.07746774e-01f, -3.11614662e-01f, -1.92628101e-01f, -5.41278943e-02f, -8.27365667e-02f, -3.63913089e-01f, 2.45827526e-01f,
  4.00376499e-01f, 2.34701902e-01f, 6.02031685e-02f, -1.63823918e-01f, -7.70809278e-02f, -1.37577355e-01f, 4.15034860e-01f, 1.49645090e-01f, 2.05200642e-01f, 7.95940384e-02f,
  1.51533827e-01f, 1.63313858e-02f, -1.90001726e-01f, -4.50766645e-02f, -4.84111458e-02f, -1.36951998e-01f, -2.79217452e-01f, -1.55510336e-01f, 2.41609991e-01f, -1.16941683e-01f,
  9.20435339e-02f, 1.33447587e-01f, -2.57577211e-01f, 3.98071297e-02f, 6.49717689e-01f, 1.38866052e-01f, -1.94479886e-03f, 2.31431544e-01f, 1.32573128e-01f, 2.09889331e-04f,
  -7.89636523e-02f, 2.22748443e-02f, 2.71063030e-01f, -2.16948777e-01f, -3.37095231e-01f, 1.68794274e-01f, -1.27985507e-01f, -1.56762019e-01f, -3.19074363e-01f, 2.18507215e-01f,
  -7.49621615e-02f, -2.17365280e-01f, 2.14606509e-01f, -1.90516099e-01f, 3.01953733e-01f, -1.45212144e-01f, -2.21846163e-01f, 6.06585555e-02f, -1.04204781e-01f, -7.84121745e-04f,
  -3.33250254e-01f, 3.97730842e-02f, -1.81242704e-01f, 1.55064732e-01f, 8.58898982e-02f, -2.52712816e-02f, -5.78762949e-01f, -1.15200572e-01f, 1.06010310e-01f, -4.01872903e-01f,
  -1.58445746e-01f, 1.19676985e-01f, -8.53499770e-02f, 3.27440292e-01f, 2.34422535e-01f, 2.03338712e-01f, 1.97918579e-01f, -2.72005975e-01f, 5.18670440e-01f, 1.31028602e-02f,
  3.48301589e-01f, 3.03850949e-01f, 3.58012356e-02f, -1.28300458e-01f, 1.08884819e-01f, 9.61810127e-02f, -2.88197827e-02f, -2.41075382e-01f, 1.26952544e-01f, 1.19608365e-01f,
  -2.36250073e-01f, -3.18308592e-01f, 3.76083612e-01f, 1.29025072e-01f, -1.36549855e-02f, 7.31940418e-02f, -1.18864000e-01f, -1.19858839e-01f, 1.48280440e-02f, -2.87391812e-01f,
  2.19153181e-01f, 5.37338816e-02f, -7.35857189e-02f, 1.18330389e-01f, 1.08192392e-01f, 2.67302990e-01f, 1.94469482e-01f, 3.09141338e-01f, -4.71042544e-01f, -2.62656093e-01f,
  2.96548456e-01f, 6.88931048e-02f, 2.75534630e-01f, 3.04750681e-01f, -2.33702838e-01f, 1.33331409e-02f, -4.13957937e-03f, -9.84878372e-03f, -9.86225456e-02f, -8.98293853e-02f,
  -6.15266189e-02f, 2.68799305e-01f, -1.93020135e-01f, -3.18749666e-01f, 1.02698512e-01f, -8.76580253e-02f, -1.69010863e-01f, 3.58468652e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -9.23172534e-02f, 3.65378186e-02f, -7.49956965e-02f, -2.29036108e-01f, 4.28320676e-01f, -1.67156890e-01f, -3.92280258e-02f, 5.04398823e-01f, -4.07660931e-01f, -4.36592728e-01f,
  -1.30632117e-01f, 7.12590694e-01f, -1.13936685e-01f, 1.10380553e-01f, 4.75767225e-01f, 1.69628441e-01f, -3.84548046e-02f, 4.60895181e-01f, -1.60619259e-01f, 1.41537532e-01f,
  -1.89152807e-01f, 9.19085518e-02f, 1.02226689e-01f, 1.06486544e-01f, 5.27250320e-02f, 5.39638221e-01f, 1.18256755e-01f, 4.26847547e-01f, 2.46635988e-01f, 2.85065584e-02f,
  2.25991502e-01f, 2.36754236e-03f, 7.64298081e-01f, 5.66353202e-01f, 1.83460310e-01f, 2.51098901e-01f, -1.67721566e-02f, 1.41258255e-01f, 1.18618429e-01f, 2.46492207e-01f,
  4.43824261e-01f, -1.89878285e-01f, 1.03557006e-01f, -3.30146134e-01f, 3.42299789e-01f, -3.09665687e-02f, -5.84481433e-02f, 3.49432528e-02f, 2.46082798e-01f, -3.43800426e-01f,
  2.78399169e-01f, 6.22089863e-01f, 4.47655797e-01f, 6.22074008e-02f, -4.34483171e-01f, 4.08341676e-01f, -1.68223932e-01f, -5.32712936e-01f, 3.36453408e-01f, -8.56209695e-02f,
  3.21581185e-01f, 5.42379141e-01f, 9.95318666e-02f, 1.99468553e-01f, 5.70202649e-01f, 1.96615547e-01f, 5.46026707e-01f, 7.00859368e-01f, -1.49915129e-01f, 6.47524536e-01f,
  4.25728351e-01f, 3.10512513e-01f, 6.56206369e-01f, -7.07129240e-01f, -6.66917086e-01f, -7.61782348e-01f, 5.91843545e-01f, 6.03927970e-01f, -2.42622972e-01f, -1.40900940e-01f,
  -5.32348335e-01f, -5.70869923e-01f, -1.00697711e-01f, 2.89812267e-01f, 3.30806702e-01f, 9.66065153e-02f, -2.00279474e-01f, 5.90119004e-01f, -2.78243691e-01f, -3.38008970e-01f,
  9.80057046e-02f, -1.18039377e-01f, -5.66755272e-02f, -2.53381640e-01f, -8.61627012e-02f, -9.79866832e-02f, 8.45565945e-02f, 4.48189303e-02f, 1.67876165e-02f, -7.58696973e-01f,
  2.38950998e-01f, -8.49856660e-02f, -2.98588514e-01f, -2.90402353e-01f, -3.45903099e-01f, -2.04740494e-01f, 1.24173518e-02f, 1.30709425e-01f, -2.70668596e-01f, -4.54778850e-01f,
  -3.70410144e-01f, -1.84725538e-01f, -8.57871413e-01f, 2.53948063e-01f, -1.44250348e-01f, -1.76969618e-01f, -9.83977690e-02f, 1.36445284e-01f, -8.49659368e-02f, 1.89805269e-01f,
  2.98427135e-01f, 1.62632819e-02f, 2.54767835e-01f, 1.87334165e-01f, 3.33143979e-01f, 4.17039841e-01f, -3.17130953e-01f, 3.06039184e-01f, 3.62617433e-01f, -7.01484010e-02f,
  7.62856901e-02f, -4.06776369e-01f, 3.81998508e-03f, -3.22118491e-01f, 5.37002496e-02f, 3.23980451e-01f, 8.17103758e-02f, -1.28716722e-01f, -4.37290549e-01f, 2.56465018e-01f,
  2.66563922e-01f, 4.25931066e-01f, 3.80984485e-01f, -2.04040155e-01f, -3.49901675e-04f, 4.89135772e-01f, -8.53219479e-02f, -2.52613813e-01f, -7.61480704e-02f, 1.80666953e-01f,
  5.33723593e-01f, 1.65024728e-01f, 1.23289272e-01f, 5.28926313e-01f, -1.20076962e-01f, 2.37167448e-01f, 6.27850950e-01f, -5.20247579e-01f, 5.51908135e-01f, 1.73586264e-01f,
  -3.20480138e-01f, 2.38645047e-01f, -9.72388014e-02f, 1.45269364e-01f, 4.52442467e-01f, 1.77186027e-01f, -3.40689421e-01f, 8.72282758e-02f, -2.46229976e-01f, 3.08706379e-03f,
  1.45146623e-01f, 5.12239814e-01f, -2.39212856e-01f, -1.52982816e-01f, 3.03680986e-01f, -2.81554848e-01f, -7.86467716e-02f, 3.37199926e-01f, -2.53673345e-01f, -2.72766858e-01f,
  2.26388708e-01f, -4.04504061e-01f, 4.95190412e-01f, 2.05037296e-02f, 5.85918486e-01f, -1.60530081e-03f, -1.54909059e-01f, -5.45589030e-01f, 2.80623548e-02f, 5.51892594e-02f,
  -1.40707493e-01f, 7.62569189e-01f, 4.04729158e-01f, -1.12031899e-01f, -4.70296770e-01f, -1.45714328e-01f, -7.19465137e-01f, -6.59828067e-01f, -1.47722498e-01f, -4.98300493e-01f,
  7.93417394e-02f, -8.39227289e-02f, -2.45340422e-01f, -5.29304659e-03f, 5.29425545e-03f, 1.57921426e-02f, 4.04615283e-01f, 7.08134890e-01f, -5.21874547e-01f, 1.25254154e-01f,
  4.80952948e-01f, 7.12780118e-01f, 5.41644633e-01f, -3.21522951e-01f, 2.92213857e-01f, -1.35213971e-01f, 4.73101288e-01f, -1.74154371e-01f, 5.03170013e-01f, -1.89553406e-02f,
  4.97252166e-01f, 6.52872264e-01f, 4.27894562e-01f, -1.87543184e-02f, 3.86732429e-01f, 6.69868663e-02f, -2.78146148e-01f, -1.93502858e-01f, -1.97820552e-02f, -3.76489580e-01f,
  -1.36518538e-01f, 1.69188604e-01f, -2.95649916e-01f, -2.06121262e-02f, -5.71603142e-02f, 2.52495825e-01f, 4.25405920e-01f, -1.28517464e-01f, 1.07840307e-01f, -3.85347724e-01f,
  -3.10062617e-01f, 5.40734410e-01f, -1.73940301e-01f, 5.83468825e-02f, -3.65567029e-01f, 1.89421639e-01f, 5.49391985e-01f, 6.58908635e-02f, 4.15906042e-01f, -1.53479036e-02f,
  -1.22897573e-01f, -1.67841595e-02f, 7.23231435e-01f, -5.55708110e-01f, 4.79823261e-01f, 3.28506157e-02f, 2.34680980e-01f, 3.93373834e-04f, -3.00823569e-01f, -4.82280970e-01f,
  -6.66795596e-02f, -3.63162607e-01f, -1.09368406e-01f, -2.74649203e-01f, -2.58249436e-02f, 5.69156468e-01f, 4.75655586e-01f, -3.77093852e-01f, 2.39243165e-01f, -7.12492943e-01f,
  -5.58627367e-01f, -2.84340322e-01f, 6.74925685e-01f, 5.47020018e-01f, 7.43474662e-01f, -6.23530112e-02f, 3.99876207e-01f, 1.27694746e-02f, -3.38107273e-02f, 3.58560592e-01f,
  -3.12821120e-01f, 1.70897290e-01f, -3.15978937e-02f, -6.43986464e-02f, 6.85062408e-01f, 2.31561244e-01f, 2.15955362e-01f, -6.38684407e-02f, 3.07538241e-01f, -1.21287577e-01f,
  2.68506795e-01f, -4.86752950e-02f, 2.99418299e-03f, 3.78999203e-01f, -2.26096764e-01f, 8.33458528e-02f, 2.29278818e-01f, 5.71067870e-01f, 7.18704984e-02f, -1.11453608e-01f,
  6.96831495e-02f, 7.10816205e-01f, 1.64002568e-01f, -6.19639993e-01f, 2.58818239e-01f, 4.35232997e-01f, -2.19692096e-01f, -5.21404386e-01f, 6.56964362e-01f, -5.51434278e-01f,
  4.19303179e-01f, 2.49892816e-01f, -2.04447970e-01f, 2.33870730e-01f, -1.67554513e-01f, -9.54348683e-01f, 6.27037585e-01f, -1.88571125e-01f, -5.79488650e-02f, 5.99733829e-01f,
  -5.21713495e-01f, -3.26926261e-01f, -3.44529957e-01f, -5.17359748e-02f, -7.99790144e-01f, -6.05910301e-01f, 4.19503972e-02f, -3.26901972e-01f, 3.02001208e-01f, -2.38139659e-01f,
  -4.00463730e-01f, -1.49987966e-01f, 2.43663177e-01f, 8.62471014e-02f, -2.01191485e-01f, 2.30429601e-02f, -4.98352200e-01f, -5.38315058e-01f, 5.32045960e-01f, 4.44269866e-01f,
  3.69077712e-01f, 7.66391084e-02f, 2.33291551e-01f, 2.36970633e-01f, -8.09596628e-02f, 8.75501931e-02f, 3.11304092e-01f, 1.35534275e-02f, 1.46452978e-01f, -1.43184036e-01f,
  -4.95953001e-02f, -5.49415469e-01f, 7.16912866e-01f, 6.07704937e-01f, 2.94918358e-01f, 5.34184515e-01f, 3.34060341e-01f, 8.59876871e-02f, 3.51463884e-01f, 1.90372974e-01f,
  2.76879489e-01f, -1.22321464e-01f, 1.07353270e-01f, -9.56808031e-01f, 7.40034103e-01f, 1.29164428e-01f, -8.47351611e-01f, -7.07291365e-01f, 6.18070662e-01f, -2.77305812e-01f,
  -1.28357396e-01f, -6.54302388e-02f, 1.20435633e-01f, 2.44130269e-01f, -1.04162671e-01f, 5.29863060e-01f, 7.69372582e-02f, -3.09211344e-01f, 2.20943913e-01f, 3.53004962e-01f,
  2.13317350e-01f, 4.49677967e-02f, -2.98209369e-01f, 2.95396209e-01f, 4.37492788e-01f, 6.79577887e-01f, -2.84800172e-01f, 8.58117223e-01f, 4.80883718e-02f, -4.48334575e-01f,
  2.22515002e-01f, 4.40123677e-01f, 3.80378328e-02f, 2.02823296e-01f, 1.86612800e-01f, 2.53880888e-01f, 6.32657945e-01f, -2.35067666e-01f, 3.95407945e-01f, 9.70941335e-02f,
  1.07908380e+00f, -2.19850522e-02f, 7.32520595e-03f, 2.40387350e-01f, -1.04940927e-03f, 3.13905269e-01f, 7.89910555e-02f, -4.07310203e-02f, 3.02977711e-01f, -7.11096451e-02f,
  -2.34850168e-01f, -1.00164022e-02f, 3.21114510e-02f, 2.59087205e-01f, 4.06957805e-01f, -1.37498736e-01f, -4.14379895e-01f, 1.32941172e-01f, 4.63959843e-01f, 5.56288540e-01f,
  6.95672393e-01f, 8.33022416e-01f, -6.48957565e-02f, 4.47399169e-01f, -3.14972132e-01f, 2.45421026e-02f, -3.87955531e-02f, -5.04613876e-01f, 1.97220907e-01f, -1.33773029e-01f,
  -9.19858336e-01f, -5.49279571e-01f, 4.00746852e-01f, -1.30401133e-02f, -1.06467135e-01f, -4.97152284e-02f, 7.52538517e-02f, 3.93346667e-01f, 2.20006481e-01f, 6.12888694e-01f,
  -1.49717450e-01f, 2.67190933e-01f, -3.53915691e-02f, -1.16187952e-01f, -6.62728697e-02f, -6.06659055e-02f, -4.00792122e-01f, 4.71138746e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.67620614e-01f, 1.19461782e-01f, 1.98275015e-01f, -6.05634460e-03f, 9.25348103e-02f, 4.04924117e-02f, -6.21880814e-02f, -8.16454738e-02f, -2.59645581e-01f, 1.15219384e-01f,
  -1.10556416e-01f, 3.25665742e-01f, 2.96705306e-01f, 2.21569896e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.90475577e-01f, 1.41419545e-01f, 1.33481488e-01f, -2.22416863e-01f, -6.70214323e-03f, 9.99558568e-02f, -3.43883663e-01f, 1.97043866e-01f, 3.94736886e-01f, -1.18730880e-01f,
  8.35337117e-02f, 2.36658931e-01f, -1.37580022e-01f, 5.76056764e-02f, 3.67151439e-01f, 3.77902716e-01f, 2.50819921e-01f, -2.76140153e-01f, 1.02495581e-01f, -9.60392132e-03f,
  -4.04493988e-01f, -4.58941273e-02f, -5.63625842e-02f, -5.57924628e-01f, 1.83990434e-01f, 4.87957262e-02f, 2.96420574e-01f, -3.47578585e-01f, 3.13889235e-01f, -9.59858954e-01f,
  -3.87712210e-01f, -3.86842132e-01f, -4.49906707e-01f, -1.35638624e-01f, 2.04230502e-01f, -3.74130636e-01f, -3.88046473e-01f, -6.70881212e-01f, 3.41976523e-01f, -2.41378650e-01f,
  -3.53007853e-01f, -6.27643585e-01f, -5.78982115e-01f, -8.43385905e-02f, 4.79903668e-02f, 2.83810169e-01f, -2.80370682e-01f, -2.62665212e-01f, -4.88935173e-01f, -2.32028365e-01f,
  2.58637369e-01f, -5.63543618e-01f, 1.64408535e-01f, 3.16582888e-01f, 3.12282234e-01f, 8.62965882e-02f, -2.03159377e-01f, 3.44444811e-01f, -3.92870456e-01f, -6.37789547e-01f,
  -7.36033684e-03f, -8.56907740e-02f, -6.74724042e-01f, 7.49538168e-02f, 2.88828671e-01f, -9.04346049e-01f, 4.47118849e-01f, 2.86001042e-02f, 6.53237253e-02f, 3.57703686e-01f,
  1.42510518e-01f, 4.83143240e-01f, 5.32253683e-01f, -4.56733555e-01f, -1.49710014e-01f, -4.44108576e-01f, 2.88491309e-01f, -6.51795328e-01f, -4.94111210e-01f, 5.90553582e-01f,
  -3.77837867e-01f, 5.79093218e-01f, -4.18545566e-02f, 1.64471477e-01f, 3.17568123e-01f, -2.33035743e-01f, 2.87240207e-01f, -3.24715704e-01f, -3.41137052e-01f, -4.84812886e-01f,
  -2.09605515e-01f, 5.54291666e-01f, -4.06785876e-01f, 3.44430730e-02f, -8.45097721e-01f, 5.43576889e-02f, -5.84139287e-01f, -3.33081037e-02f, 5.72655201e-01f, -5.01592219e-01f,
  -6.66706786e-02f, -1.43122226e-01f, 3.85970503e-01f, -7.15604961e-01f, -4.42354888e-01f, 3.08547348e-01f, -1.31674018e-02f, -1.58602223e-02f, -3.18005919e-01f, 7.26797879e-01f,
  -3.15446615e-01f, -5.06518602e-01f, -3.42812002e-01f, 1.46235839e-01f, -4.19930249e-01f, 3.03154498e-01f, 3.18865955e-01f, -7.05674231e-01f, -7.90092409e-01f, -4.40185159e-01f,
  4.38527197e-01f, -9.09548283e-01f, -3.41881901e-01f, -8.15743148e-01f, 2.79743314e-01f, -4.04575884e-01f, -1.65091380e-01f, -3.14938337e-01f, 3.62136900e-01f, -5.42778522e-02f,
  -1.03661954e-01f, 6.13186419e-01f, 2.38035247e-01f, -1.42452538e-01f, -3.63631994e-01f, 4.01105583e-01f, -4.75000232e-01f, -2.96624631e-01f, 3.11998367e-01f, -5.15777946e-01f,
  5.08278549e-01f, -5.18080592e-01f, 6.68087780e-01f, -2.44904548e-01f, -2.28115290e-01f, 2.42010169e-02f, -3.74481708e-01f, 1.61551699e-01f, 9.12274122e-02f, 2.86288094e-02f,
  -2.99232602e-01f, -7.78489470e-01f, 1.12994490e-02f, -5.01304030e-01f, 1.81331977e-01f, -3.77858095e-02f, 1.48973033e-01f, 3.72213662e-01f, 2.45115623e-01f, -1.80053085e-01f,
  1.12024490e-02f, 1.10197470e-01f, -2.47402042e-01f, -6.22564219e-02f, 2.28962153e-01f, 4.93581384e-01f, -3.24122012e-01f, 4.05391783e-01f, 3.40321422e-01f, 4.38673645e-01f,
  1.50332361e-01f, -1.53602794e-01f, -3.45367312e-01f, 1.96050361e-01f, 3.52941096e-01f, -3.17181170e-01f, -9.36798453e-02f, -3.90133232e-01f, -4.11146134e-03f, -1.33767526e-03f,
  -2.15237722e-01f, -2.76444584e-01f, 3.17040049e-02f, -1.17829360e-01f, -4.33208734e-01f, 1.89395934e-01f, 2.01661289e-01f, -6.20508552e-01f, -2.55520403e-01f, 1.93824396e-01f,
  6.40385449e-01f, 2.73838013e-01f, -3.00739914e-01f, 5.19602239e-01f, -2.82480180e-01f, -2.60982156e-01f, 5.18252969e-01f, 6.57985033e-03f, -3.95974636e-01f, 3.66737425e-01f,
  -3.35430473e-01f, 3.93230677e-01f, -1.20545417e-01f, 2.17081204e-01f, 5.29942572e-01f, -1.29948959e-01f, -4.91951592e-03f, -2.26083413e-01f, 6.12325013e-01f, 2.51066059e-01f,
  1.47747561e-01f, -8.70685756e-01f, -4.11463886e-01f, -1.80644870e-01f, -9.92759839e-02f, 4.72986460e-01f, -1.10840845e+00f, -4.36467648e-01f, -3.79337430e-01f, 2.98893392e-01f,
  -2.36025631e-01f, -2.35947803e-01f, 1.10741481e-02f, 5.79093099e-01f, -2.02815115e-01f, 6.48893863e-02f, -2.77153015e-01f, -4.58028689e-02f, -3.85007858e-01f, -1.27938747e-01f,
  1.18564844e-01f, 6.22978546e-02f, 8.72581378e-02f, -1.75718024e-01f, 2.45788634e-01f, 2.71445423e-01f, -3.80774178e-02f, -4.69615728e-01f, -3.25877309e-01f, 6.42057359e-02f,
  -1.67007130e-02f, 8.43214542e-02f, 1.68558538e-01f, 2.95910895e-01f, -3.84798557e-01f, 3.90224308e-01f, -3.22466612e-01f, 1.86927140e-01f, 3.69010776e-01f, -5.56882262e-01f,
  -1.65581256e-01f, -6.05009675e-01f, -4.77375716e-01f, -1.64462909e-01f, 1.06537089e-01f, -5.89490235e-01f, 5.98476112e-01f, -3.48818570e-01f, 4.51483130e-01f, -3.82504106e-01f,
  -1.73595592e-01f, 4.24267977e-01f, 1.08217828e-01f, 1.45054743e-01f, 4.92126755e-02f, 4.05133545e-01f, 1.86590180e-01f, -8.24480690e-03f, -4.17564422e-01f, 4.78246808e-01f,
  -4.32805508e-01f, -2.83890367e-02f, 6.04040325e-01f, 4.56009172e-02f, 4.12106216e-01f, -4.44524705e-01f, -6.54992223e-01f, -3.23499471e-01f, 4.03393716e-01f, -4.92316335e-01f,
  2.05890406e-02f, 3.07823807e-01f, -6.50298655e-01f, -7.51000583e-01f, -2.81496316e-01f, -7.36307979e-01f, 6.27317429e-01f, -8.43400240e-01f, 4.85649943e-01f, 4.30610865e-01f,
  3.84913027e-01f, 1.80702865e-01f, -3.46354157e-01f, -7.96948001e-02f, -2.49336585e-02f, -1.81804776e-01f, 3.44565660e-02f, 4.75575216e-02f, 9.55797315e-01f, 8.60330224e-01f,
  2.79055117e-03f, -5.71729708e-03f, 2.57416070e-01f, 4.53464240e-01f, 1.90673858e-01f, 7.69985020e-01f, -4.57689852e-01f, 3.18418210e-03f, -8.42662156e-01f, 2.96787828e-01f,
  -2.33285680e-01f, -2.21263450e-02f, -1.52463660e-01f, -3.04527789e-01f, 5.02809525e-01f, 2.42624089e-01f, -8.17635655e-01f, 1.48712113e-01f, -2.36421570e-01f, 2.45027900e-01f,
  4.93556708e-01f, 6.05624795e-01f, -3.45169991e-01f, 5.67195117e-01f, 4.07789916e-01f, 6.13455735e-02f, 2.34904051e-01f, -4.49043244e-01f, -1.15234055e-01f, 1.53407604e-02f,
  -9.14664716e-02f, -8.76792744e-02f, -2.98049361e-01f, 2.72427678e-01f, -5.44910908e-01f, 2.55130883e-02f, -5.12542069e-01f, -3.06561202e-01f, -3.81620109e-01f, 5.60236394e-01f,
  5.00519753e-01f, -3.59517008e-01f, -5.58094978e-01f, -3.28390241e-01f, -8.12530518e-01f, -9.14133608e-01f, -9.99914527e-01f, -5.83196342e-01f, -3.42912883e-01f, 6.78119302e-01f,
  2.72922754e-01f, 5.09278834e-01f, 4.40952294e-02f, -5.64586759e-01f, -4.84850228e-01f, 3.78449947e-01f, -2.98811495e-01f, 3.22826952e-02f, 1.57305881e-01f, -4.70827311e-01f,
  -1.34504065e-01f, 4.57651675e-01f, -2.73418725e-02f, 1.78667575e-01f, -1.29378110e-01f, -2.85991043e-01f, -1.98781937e-01f, 4.57218170e-01f, -9.30156410e-02f, 2.31315270e-01f,
  -2.62681395e-01f, -3.93869817e-01f, -1.63466573e-01f, -4.04858977e-01f, 2.22716093e-01f, 3.23653370e-01f, 7.57462382e-02f, 4.38766360e-01f, -4.74002987e-01f, 3.06359172e-01f,
  -2.94638276e-01f, -4.87822562e-01f, 2.61586040e-01f, -3.99318099e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -2.15759709e-01f, 4.90255728e-02f, -1.60310883e-02f, 2.82282174e-01f, -1.50220186e-01f, -4.29807082e-02f, 5.18778488e-02f, -1.69279367e-01f, 2.62835056e-01f, 1.39097005e-01f,
  2.08802342e-01f, -3.73995155e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    