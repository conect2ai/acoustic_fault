/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.71007788e-01f, 3.59410316e-01f, 8.66075158e-02f, 1.02427468e-01f, -8.53572413e-03f, 9.66191962e-02f, 1.12696871e-01f, 1.94445148e-01f, 4.01001304e-01f, 2.04172581e-01f,
  -3.76903601e-02f, 2.44604975e-01f, -6.82941750e-02f, 5.55326603e-02f, -2.59287953e-01f, -1.43632382e-01f, -2.15545729e-01f, -4.49786335e-02f, 5.83906248e-02f, -5.65804206e-02f,
  -1.17720589e-01f, -2.91970491e-01f, -3.48809928e-01f, -1.18747063e-01f, -1.15232259e-01f, 6.64467812e-02f, -1.65865228e-01f, -6.90502003e-02f, -5.06205224e-02f, 7.85594434e-03f,
  -4.93296646e-02f, 2.44752765e-01f, 3.05319391e-02f, 4.67249975e-02f, -3.00528351e-02f, 1.11204237e-02f, -4.27720770e-02f, -5.58251888e-03f, -5.16726412e-02f, 8.89991131e-03f,
  -9.23323259e-02f, 5.27946986e-02f, 2.43514478e-02f, -4.37066481e-02f, 1.05968542e-01f, 8.59342366e-02f, 4.23047915e-02f, 2.48949658e-02f, 4.37153615e-02f, -5.89998160e-03f,
  -3.82273123e-02f, -2.49836221e-02f, -6.86811209e-02f, -2.21769023e-03f, -2.92853126e-03f, 1.53860942e-01f, 1.36705386e-02f, -3.59673090e-02f, 5.52479662e-02f, 1.65546551e-01f,
  4.17982303e-02f, -6.49817660e-02f, -5.42644896e-02f, -4.17082310e-02f, 3.73309888e-02f, -4.06592600e-02f, -2.85512698e-03f, -1.75023545e-02f, -3.11911255e-02f, -1.00357607e-02f,
  1.25826402e-02f, 1.11425862e-01f, -6.33007288e-03f, 1.78207289e-02f, -5.01680933e-02f, 6.01898693e-03f, -1.03985339e-01f, -3.23231854e-02f, 6.94235181e-03f, -1.13335513e-02f,
  4.49028984e-03f, -2.47669257e-02f, -7.04290904e-03f, -7.05936849e-02f, 4.57529798e-02f, -3.69960964e-02f, 4.70185839e-02f, 7.60854334e-02f, -6.58525601e-02f, -1.11632161e-01f,
  1.78338829e-02f, 1.92092523e-01f, 9.18767648e-04f, -3.00994869e-02f, -3.32542881e-02f, -7.51701593e-02f, -8.31587166e-02f, 3.24984603e-02f, -5.74431475e-03f, -4.25063595e-02f,
  -3.98281924e-02f, -5.75525612e-02f, -4.13905829e-02f, 2.42958013e-02f, -1.15977861e-01f, 1.56579129e-02f, -5.93837313e-02f, -1.85453370e-02f, -1.26645580e-01f, -2.52717105e-03f,
  -9.28642079e-02f, -6.17284141e-02f, 6.23627938e-02f, -5.65934479e-02f, -1.90939810e-02f, -4.74987999e-02f, 3.66615839e-02f, 1.23559490e-01f, -9.17985290e-02f, -6.28696084e-02f,
  -6.60808325e-01f, 5.34434840e-02f, -8.40612724e-02f, -4.10221934e-01f, 8.89676511e-02f, -1.71321332e-01f, -2.79154092e-01f, 1.29959166e-01f, -3.50079507e-01f, 1.51180387e-01f,
  -4.07750271e-02f, -2.20538884e-01f, 6.22362681e-02f, -1.64117932e-01f, -3.40659529e-01f, -1.01869173e-01f, -2.87870795e-01f, -1.23918086e-01f, -7.33485594e-02f, -1.16932988e-01f,
  -1.40882581e-01f, -5.60716651e-02f, -7.22690746e-02f, 2.34232441e-01f, 8.74831900e-03f, 6.17777109e-02f, 1.08222313e-01f, 1.60400778e-01f, -4.78579588e-02f, 9.60876420e-02f,
  8.00173134e-02f, -5.64942583e-02f, 2.90173534e-02f, -4.30019223e-04f, -7.49709532e-02f, 2.39404943e-02f, -1.05218543e-02f, 2.88414452e-02f, -2.49784701e-02f, -3.49150151e-02f,
  -1.92770697e-02f, -4.79851700e-02f, -9.88462791e-02f, 5.45483045e-02f, -1.43782096e-02f, -2.25580893e-02f, 1.98677974e-03f, -6.11021258e-02f, 3.23780775e-02f, -5.78322336e-02f,
  -1.71932438e-03f, 8.67558178e-03f, -1.18924320e-01f, 9.87578090e-03f, 3.09709669e-03f, -4.21647169e-02f, -1.78569332e-02f, 5.03191017e-02f, -7.72657022e-02f, 3.23303230e-02f,
  -3.75391617e-02f, -1.48108322e-02f, -1.93362013e-02f, 4.04645354e-02f, -2.35415269e-02f, 4.47569489e-02f, -3.05559533e-03f, 3.39498483e-02f, -4.32451852e-02f, 1.63819324e-02f,
  -2.53958013e-02f, 4.30482486e-03f, 1.19309388e-02f, -3.29289846e-02f, 1.55758774e-02f, 1.87474322e-02f, 7.95655325e-03f, 4.15228605e-02f, -7.12804869e-02f, 1.34273330e-02f,
  8.88180919e-03f, -9.36547108e-03f, 4.68527526e-02f, 3.72251458e-02f, -6.57263445e-03f, 4.43966947e-02f, 1.24304462e-02f, 5.10500111e-02f, -2.05777027e-02f, -6.70738667e-02f,
  -5.48563115e-02f, -1.96079351e-02f, -1.86870340e-02f, -3.52746923e-04f, 4.33598682e-02f, 4.73866202e-02f, -4.42947000e-02f, -9.70185827e-03f, -9.73827904e-04f, 2.86112148e-02f,
  -3.55301425e-02f, -9.34003759e-03f, 2.59036552e-02f, -2.52725836e-02f, 3.59732355e-03f, 3.82298720e-03f, -4.54971492e-02f, -7.72330305e-03f, -7.86545202e-02f, -3.76550071e-02f,
  -1.88846793e-02f, -4.79917303e-02f, -2.31099897e-03f, 3.01705264e-02f, -7.02537298e-02f, -1.08801322e-02f, -1.56470742e-02f, -4.12552757e-03f, 4.42240899e-03f, 2.81197466e-02f,
  -9.23933163e-02f, 2.28602692e-01f, 4.45964098e-01f, 1.00194588e-01f, -2.27095231e-01f, -8.40336159e-02f, -2.24815914e-03f, 3.34568098e-02f, 2.81845808e-01f, -3.58417965e-02f,
  -2.38378957e-01f, 2.41905004e-01f, 7.74978250e-02f, -5.06348908e-02f, -1.84581071e-01f, 2.90777057e-01f, -1.78925321e-01f, -5.58613017e-02f, 1.41285151e-01f, 9.06617788e-04f,
  5.34784347e-02f, -3.53543907e-01f, 1.36384115e-01f, -7.84831047e-02f, -2.76350853e-04f, 1.54377460e-01f, -3.23590934e-01f, 9.26572606e-02f, -1.63273409e-01f, -9.85346735e-02f,
  5.27385399e-02f, 1.09919883e-01f, 6.75721392e-02f, 1.26745075e-01f, -4.97886091e-02f, -1.76712736e-01f, -2.99055874e-02f, -1.27304886e-02f, 6.88029453e-02f, 8.72326344e-02f,
  -4.92820106e-02f, -6.71449676e-02f, 8.72764736e-03f, -2.77177617e-02f, 1.48106739e-02f, 2.79742442e-02f, 8.55460837e-02f, -1.66388303e-02f, 8.63816515e-02f, 3.99774536e-02f,
  1.56405598e-01f, -1.13984235e-02f, -2.72891391e-02f, -6.50170967e-02f, 5.50215654e-02f, 6.05098270e-02f, -1.42099056e-03f, -2.21295580e-02f, -3.35008539e-02f, -2.47619543e-02f,
  -1.33091018e-01f, -9.34733078e-03f, -4.19820705e-03f, 2.07249094e-02f, 2.61047687e-02f, -1.36564011e-02f, -5.70727997e-02f, -6.17890358e-02f, 3.77568253e-03f, -2.09059976e-02f,
  2.11104695e-02f, 6.73455521e-02f, 4.57327114e-03f, -4.47252579e-02f, -2.27869339e-02f, 1.86446905e-02f, -4.98488657e-02f, 3.31196524e-02f, -1.09136738e-02f, -1.18024554e-03f,
  3.57154384e-02f, -2.47216839e-02f, 6.12359978e-02f, -5.18971980e-02f, -8.76417290e-03f, -2.95648677e-03f, -4.28327098e-02f, 2.74281856e-02f, 3.67558338e-02f, -1.12892933e-01f,
  -1.22231908e-01f, -5.21983914e-02f, 9.16904211e-02f, 2.41618045e-02f, 7.22862706e-02f, -5.90550452e-02f, 8.23974423e-03f, -1.55745517e-03f, -6.55201869e-03f, 8.71960260e-03f,
  -5.18471003e-02f, 1.03504211e-02f, -6.02519363e-02f, -3.55471186e-02f, -1.25072962e-02f, -7.76813850e-02f, -3.77946906e-02f, -3.08794212e-02f, -8.60762969e-02f, -8.66135210e-02f,
  -1.03985272e-01f, -6.52721673e-02f, -4.20596711e-02f, 1.21391648e-02f, -1.23013012e-01f, -8.01815167e-02f, -9.33963656e-02f, 3.70018892e-02f, -8.04943293e-02f, 3.00788023e-02f,
  -3.20194900e-01f, -2.55408704e-01f, -3.28971595e-02f, -2.13606000e-01f, 3.48024368e-02f, 3.04860454e-02f, -1.96027771e-01f, -3.18261757e-02f, -2.89898906e-02f, -1.57519326e-01f,
  -6.94242194e-02f, -5.38421646e-02f, -4.34237868e-02f, -2.58964114e-02f, 1.40865281e-01f, 2.05077119e-02f, -2.16430306e-01f, -1.20735787e-01f, 2.41637766e-01f, -2.67627329e-01f,
  9.06440318e-02f, -3.86315286e-02f, 3.06766219e-02f, 1.15792163e-01f, 4.25286666e-02f, 2.50934362e-02f, -1.18872141e-02f, 6.26897858e-03f, 9.75799784e-02f, 6.86437935e-02f,
  -1.79719310e-02f, -1.11885376e-01f, 7.36503378e-02f, 1.06853984e-01f, -5.58182038e-02f, 3.77959721e-02f, -8.13494846e-02f, 2.77626123e-02f, -6.66296110e-03f, 3.16462629e-02f,
  -3.54007706e-02f, 1.00893416e-01f, 8.41698647e-02f, 6.07759058e-02f, -4.34857570e-02f, 4.41663675e-02f, 3.92844714e-02f, 4.27811593e-02f, -2.50528790e-02f, 1.05081260e-01f,
  6.94822744e-02f, 8.32817983e-03f, -1.60182063e-02f, -4.74338494e-02f, 1.40367612e-01f, -4.23143096e-02f, 6.79419488e-02f, 2.95981043e-03f, -2.13329941e-02f, 9.61529836e-03f,
  -8.46447423e-02f, 3.54657769e-02f, 2.51506194e-02f, 5.41509222e-03f, -4.71155159e-02f, 1.54624404e-02f, -9.92670953e-02f, -1.86893046e-02f, 6.43040016e-02f, -3.48800868e-02f,
  -6.28679022e-02f, 3.93521339e-02f, -2.44883467e-02f, -4.78593865e-03f, 8.98503363e-02f, -5.27869351e-02f, -3.45364236e-03f, 6.50882628e-03f, -6.16928525e-02f, 7.45722204e-02f,
  -8.32083225e-02f, -7.21263662e-02f, -6.41111359e-02f, 9.66497883e-03f, -1.44836260e-02f, -4.75980248e-03f, 2.45577618e-02f, -2.27659922e-02f, -6.71736822e-02f, 2.82024667e-02f,
  -2.01502070e-01f, -3.28692824e-01f, -7.20206881e-03f, -1.60369780e-02f, -4.82357619e-03f, 3.22505049e-02f, 4.43681665e-02f, -9.93407518e-03f, -3.09051592e-02f, -3.73505317e-02f,
  2.97554638e-02f, -5.95590137e-02f, -9.09284279e-02f, 1.79327335e-02f, 1.86655540e-02f, 4.15758155e-02f, -1.03785843e-01f, -3.64978053e-02f, -2.33843904e-02f, -2.42406875e-02f,
  -4.25176360e-02f, -9.39220041e-02f, 8.33242089e-02f, 7.13739470e-02f, -4.47582873e-03f, -1.80665869e-02f, -1.06594481e-01f, 7.90335461e-02f, 1.01418972e-01f, 3.61319184e-02f,
  -1.40903756e-01f, -3.61647695e-01f, 1.48848861e-01f, -2.75207788e-01f, 1.06393665e-01f, 1.86188072e-01f, 3.55364263e-01f, -2.43775874e-01f, -2.78318822e-01f, -4.48973551e-02f,
  1.75369959e-02f, -1.33397937e-01f, 6.84496984e-02f, -6.46706372e-02f, 1.76403046e-01f, -1.21198423e-01f, -1.26285024e-03f, -7.76890293e-02f, -2.43348897e-01f, -8.53798464e-02f,
  -6.77057505e-02f, -8.74442160e-02f, 2.49343291e-01f, -1.87602028e-01f, 1.32667512e-01f, -5.67959733e-02f, -7.09429244e-03f, 7.62760639e-02f, 1.27731159e-01f, 4.75870110e-02f,
  3.70393954e-02f, -9.13574174e-02f, 8.28628894e-03f, -2.79238243e-02f, 4.92939055e-02f, 1.19756296e-01f, 6.60769045e-02f, 1.07853450e-01f, 1.56293884e-02f, -1.01503581e-02f,
  2.55821515e-02f, 7.39654806e-03f, -4.35161777e-02f, -2.42437329e-02f, -4.78184409e-02f, -4.14263420e-02f, 2.42361091e-02f, 6.43619820e-02f, -6.32806197e-02f, 1.10000424e-01f,
  -2.13146023e-02f, 8.59388486e-02f, 1.08035386e-01f, 5.23004588e-03f, -4.51001280e-04f, -9.64927487e-03f, 6.71447739e-02f, 1.24252483e-01f, 6.52571255e-03f, -3.91497687e-02f,
  4.54956405e-02f, 8.17859720e-04f, -3.19527206e-03f, -4.67150956e-02f, -7.86414817e-02f, -1.06454734e-03f, -9.86874625e-02f, 4.55435924e-02f, -3.42178494e-02f, -1.84988286e-02f,
  3.80575545e-02f, -1.03549249e-02f, -4.74393182e-02f, 2.17750622e-03f, -2.96283141e-02f, -4.00692858e-02f, 5.70452102e-02f, 7.28279469e-04f, 2.14990787e-02f, 2.15584617e-02f,
  8.15200154e-03f, -3.23818717e-03f, 1.37247089e-02f, 2.86653899e-02f, -9.30244178e-02f, -5.46162622e-03f, -1.18636219e-02f, 2.13905741e-02f, -8.35498981e-03f, 1.07784890e-01f,
  -2.05442175e-01f, -2.33853415e-01f, -9.88340527e-02f, -6.18601255e-02f, -7.13141263e-02f, -1.47579219e-02f, -6.00462183e-02f, -7.11125359e-02f, -8.46865401e-02f, -6.67899288e-03f,
  3.86585593e-02f, 2.45872792e-02f, 1.62743125e-03f, -6.25248402e-02f, 3.55081744e-02f, 1.18983975e-02f, 5.08962721e-02f, -4.22052145e-02f, 4.30217721e-02f, -1.24276169e-02f,
  4.47021537e-02f, -2.96921041e-02f, 5.80057763e-02f, -6.72172382e-02f, 2.75216755e-02f, 3.78510728e-02f, -1.07100070e-01f, -4.79124412e-02f, -1.66297108e-02f, 2.54357252e-02f,
  -7.48591244e-01f, -1.53311804e-01f, 4.52834666e-02f, -2.91931868e-01f, -1.03822902e-01f, -4.51767668e-02f, -5.34333102e-02f, -1.24773748e-01f, -2.46518165e-01f, 1.55263403e-02f,
  7.18372464e-02f, -8.59113559e-02f, 1.90940484e-01f, -1.23899383e-02f, -5.90278469e-02f, 9.32784304e-02f, -1.34507895e-01f, -1.36264309e-01f, 2.99596842e-02f, -1.70108855e-01f,
  -1.20221116e-01f, -1.19514756e-04f, 9.02746692e-02f, -2.31355727e-02f, -7.92429373e-02f, -2.93126293e-02f, 9.59914401e-02f, 1.19702645e-01f, -4.07371148e-02f, 7.26891756e-02f,
  -5.79635724e-02f, -1.06857277e-01f, 5.63356243e-02f, -7.61490781e-03f, -6.69448972e-02f, -5.72739867e-03f, -4.56043296e-02f, 9.73680466e-02f, -9.50414035e-03f, -5.01500405e-02f,
  3.94273596e-03f, -9.03428793e-02f, 4.57670633e-03f, 4.00035717e-02f, -1.10617824e-01f, -1.14872549e-02f, 4.49410081e-02f, 4.86301742e-02f, 7.08844289e-02f, 7.10661570e-03f,
  5.79025745e-02f, 4.97041503e-03f, -3.63227427e-02f, 9.46439523e-03f, -2.17305613e-03f, 1.11646801e-02f, -3.81407253e-02f, 8.41344297e-02f, -7.04558045e-02f, -2.91039944e-02f,
  3.20051312e-02f, 2.82005593e-02f, 4.44172397e-02f, 1.70768537e-02f, -2.14164238e-02f, -4.54456881e-02f, 1.64850671e-02f, 1.05269149e-01f, -6.31085783e-02f, 1.39009682e-02f,
  -4.19437252e-02f, -6.41833693e-02f, 3.72553281e-02f, -7.46190995e-02f, 1.16762323e-02f, -3.44734872e-03f, -1.68627035e-03f, -5.25085516e-02f, 1.56459020e-04f, 9.92178172e-03f,
  -2.63967514e-02f, -4.89180833e-02f, -2.56381948e-02f, 4.40726057e-02f, -9.56901163e-03f, 4.07506451e-02f, -2.76483269e-03f, -5.50450338e-03f, 9.26745534e-02f, -3.28075476e-02f,
  -2.39869326e-01f, -2.23655194e-01f, 9.10097808e-02f, -4.48406348e-03f, 4.73169796e-02f, -5.89048713e-02f, 2.58510783e-02f, 6.41135350e-02f, -2.29580589e-02f, 2.96664471e-03f,
  -2.02813111e-02f, -5.11021167e-02f, -1.22403167e-01f, -4.36554439e-02f, 2.02533267e-02f, 1.58724245e-02f, 1.33516645e-04f, -3.92387658e-02f, -3.48665938e-02f, -5.84709719e-02f,
  3.73342889e-03f, -3.75376642e-02f, 2.29754746e-02f, -3.74871343e-02f, 3.28241065e-02f, -3.59194167e-02f, -5.34866937e-02f, 3.98950791e-03f, 2.87037417e-02f, -6.13185167e-02f,
  -5.41515589e-01f, -2.37280041e-01f, -1.16426483e-01f, -2.66967773e-01f, -1.01571530e-01f, 6.87479228e-03f, 6.32528514e-02f, -1.95606127e-01f, -1.65017650e-01f, -3.96062769e-02f,
  8.18834528e-02f, -2.34004349e-01f, -7.01232068e-03f, -1.56960189e-02f, 2.77612120e-01f, 8.82552415e-02f, -3.26518603e-02f, -1.11887954e-01f, -9.43399966e-02f, -2.43702129e-01f,
  -7.90345371e-02f, -1.49808943e-01f, 1.52025744e-01f, -1.45174608e-01f, -1.77795038e-01f, -1.55927181e-01f, -5.63707249e-03f, 5.07586598e-02f, 8.98322985e-02f, 4.67928946e-02f,
  2.11110532e-01f, -1.27772382e-02f, -1.15988525e-02f, 6.55119494e-02f, -1.06506720e-01f, 7.17751235e-02f, 6.12144247e-02f, 1.96433052e-01f, 3.49397436e-02f, -2.26316229e-02f,
  -5.82254352e-03f, 3.28975096e-02f, -3.58958654e-02f, -1.16061671e-02f, -4.56980169e-02f, 2.50321552e-02f, 1.24730142e-02f, 8.88701826e-02f, -2.53263675e-02f, -4.56625335e-02f,
  -1.24353450e-03f, 6.44228756e-02f, -1.17573895e-01f, 1.38237253e-01f, -6.23294748e-02f, -6.58440404e-03f, 8.60932991e-02f, 8.01746324e-02f, 1.15905382e-01f, -8.14590976e-02f,
  -6.97111264e-02f, -1.44524779e-02f, 2.35694498e-02f, 2.67995577e-02f, 1.82607491e-02f, 1.51698058e-02f, -4.62037474e-02f, 6.35079443e-02f, -4.81825024e-02f, -6.82534501e-02f,
  1.19866303e-03f, -1.51077220e-02f, -1.11419242e-02f, 1.59773566e-02f, -1.38919353e-01f, -4.47358144e-03f, -1.03215827e-02f, -8.47504660e-03f, -2.52040457e-02f, 1.64525099e-02f,
  7.37439282e-03f, 7.35367164e-02f, -7.77998343e-02f, 2.23549530e-02f, 5.55396453e-02f, -5.30620702e-02f, -1.04253940e-01f, -1.72901545e-02f, 4.91781235e-02f, -2.87283435e-02f,
  -1.17069267e-01f, -1.49506435e-01f, -3.26323844e-02f, -1.96815375e-02f, 1.12714451e-02f, 2.43595708e-02f, -2.44536251e-02f, -1.89105406e-01f, 3.35391960e-03f, -9.09630582e-02f,
  -2.27580015e-02f, 3.85230556e-02f, -2.78226938e-02f, 3.43460143e-02f, -6.66952552e-03f, -5.02866171e-02f, -1.97292143e-03f, 5.84995095e-03f, -3.76980938e-02f, 1.47654386e-02f,
  -3.41549739e-02f, -3.31512205e-02f, 2.22776463e-04f, -2.03940067e-02f, -5.22735566e-02f, 1.49377892e-02f, -1.08840555e-01f, 5.25980555e-02f, -1.80187374e-02f, -3.84284630e-02f,
  -4.67188329e-01f, 2.07057238e-01f, 6.49300143e-02f, -1.59557447e-01f, -3.05886477e-01f, -2.35305905e-01f, -2.15593532e-01f, -7.52383694e-02f, 1.21941745e-01f, 1.94311574e-01f,
  -1.06812507e-01f, -3.00610028e-02f, 2.20658168e-01f, 3.31445895e-02f, -2.34252349e-01f, 3.87957126e-01f, -9.37452316e-02f, -5.67526929e-02f, 1.61522448e-01f, -2.62103170e-01f,
  -5.79779558e-02f, -1.23020962e-01f, -4.13175486e-02f, 3.00309025e-02f, -2.36455813e-01f, -3.96622568e-02f, -1.20319784e-01f, 3.04726418e-02f, -1.92321748e-01f, -6.67627826e-02f,
  -1.95510358e-01f, 1.15675189e-01f, 4.36701737e-02f, 9.69411731e-02f, -2.13756606e-01f, 9.28152073e-03f, -1.10320248e-01f, -3.94940488e-02f, -4.61823605e-02f, -1.96096441e-03f,
  1.01466374e-02f, -4.22939332e-03f, 6.02926966e-03f, 1.03945956e-01f, 2.35044397e-02f, 6.48958459e-02f, 7.94008523e-02f, -1.02619408e-02f, 5.01184165e-02f, 3.88130248e-02f,
  8.77849385e-02f, -1.89976487e-02f, 5.49037457e-02f, 6.36333749e-02f, -5.60469255e-02f, 1.79322995e-02f, -7.29544088e-02f, -1.04277693e-01f, 4.58665937e-02f, -1.07786544e-01f,
  -1.80407818e-02f, -6.84669428e-03f, -4.59072180e-02f, 5.87516949e-02f, 5.54325059e-02f, 2.74972711e-02f, 1.21794194e-01f, -6.93599880e-03f, 2.04590000e-02f, -2.51084752e-03f,
  -8.30244645e-02f, -2.89309453e-02f, 1.03137068e-01f, -1.22726476e-02f, -8.00505877e-02f, 4.34370227e-02f, -1.37648955e-02f, -1.18361935e-02f, -7.72282258e-02f, -2.24165842e-02f,
  1.48337260e-01f, -4.47458541e-03f, -7.39587396e-02f, 1.14740687e-03f, 6.38805181e-02f, -7.00910389e-02f, 8.51131454e-02f, 7.09005073e-02f, -4.87941355e-02f, -1.09993584e-01f,
  -1.81819096e-01f, -5.94357364e-02f, -4.57685404e-02f, 2.70567462e-02f, 9.23663378e-02f, -7.14969402e-03f, 8.67913663e-02f, 3.78295630e-02f, 6.24902323e-02f, -2.53097489e-02f,
  -9.80904177e-02f, -3.69176678e-02f, -3.18035297e-02f, -8.89910609e-02f, -2.93382946e-02f, -3.34722027e-02f, -7.88815320e-02f, -3.62009257e-02f, -1.05254509e-01f, -5.69463857e-02f,
  -6.91723600e-02f, -9.71306935e-02f, 7.69639686e-02f, -1.59240104e-02f, -1.50213307e-02f, -7.14876205e-02f, -4.76569459e-02f, 1.80803649e-02f, 2.79990919e-02f, 5.24979196e-02f,
  2.88089007e-01f, -1.37969986e-01f, -8.41633230e-02f, -6.57735020e-02f, 6.08918257e-03f, -3.70056987e-01f, -2.17496276e-01f, -2.44817790e-02f, 5.06281257e-02f, 1.23690711e-02f,
  -1.44061893e-01f, -8.78145024e-02f, -1.82075143e-01f, -3.81769031e-01f, -5.83992124e-01f, -2.94736058e-01f, -3.31651628e-01f, -1.01145707e-01f, -3.75827379e-03f, -5.01105487e-02f,
  -1.58504827e-03f, -2.26123869e-01f, -1.41083270e-01f, 1.32921323e-01f, 1.15341805e-01f, 3.09655577e-01f, 4.40585017e-02f, 9.58005413e-02f, 1.64023682e-01f, -1.68245453e-02f,
  2.82863695e-02f, -4.06434685e-02f, 7.87853822e-03f, -4.82993871e-02f, -7.84317181e-02f, 7.53347501e-02f, 4.35171984e-02f, -5.85913509e-02f, 3.65837812e-02f, 6.39903843e-02f,
  -1.19679132e-02f, 9.65231657e-03f, 1.19983321e-02f, -2.41345689e-02f, 8.00574571e-02f, 3.95894907e-02f, 2.58167796e-02f, 5.79227060e-02f, 9.89063531e-02f, -4.94401343e-02f,
  -5.03162108e-02f, 2.35117413e-02f, -2.60635396e-03f, 3.51066105e-02f, 5.54650053e-02f, -1.62676871e-02f, -6.57977983e-02f, -1.27060637e-02f, 1.93281155e-02f, -1.20064858e-02f,
  4.58602235e-02f, 3.17177996e-02f, -1.94295906e-02f, 9.26846042e-02f, -9.90625098e-02f, 1.07419133e-01f, -5.19516096e-02f, -3.19083105e-04f, 9.23230574e-02f, -9.76672247e-02f,
  2.76694000e-02f, 1.57638416e-02f, 3.72902565e-02f, 2.94413138e-03f, 5.63385198e-03f, 6.24278523e-02f, -3.71574834e-02f, 1.54347029e-02f, 3.92590985e-02f, 2.70917732e-02f,
  -7.55499490e-03f, -3.17102275e-03f, -1.05438661e-02f, 9.19094831e-02f, -6.13063388e-02f, 1.21385781e-02f, 6.08407520e-02f, 4.65446524e-02f, 9.36466455e-02f, -1.07622094e-01f,
  -1.66279510e-01f, -1.95602417e-01f, -2.08198577e-02f, 2.58209910e-02f, -3.52239497e-02f, -1.16162516e-01f, -9.89972651e-02f, -1.03874952e-01f, 3.43618542e-03f, -3.34198102e-02f,
  2.16116924e-02f, 4.40921448e-02f, 3.93940732e-02f, 1.16779678e-01f, 2.23145355e-02f, -1.23503171e-01f, -1.67884212e-02f, 9.05521885e-02f, -1.91714875e-02f, -3.84573545e-03f,
  1.73682126e-03f, -2.09401548e-02f, 3.94486934e-02f, -8.69701616e-03f, 2.02956016e-05f, 4.13789004e-02f, -9.31601077e-02f, 1.40828535e-01f, 8.36921949e-03f, -3.36442739e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.31029025e-01f, -4.39167261e-01f, -1.18409522e-01f, 6.78769201e-02f, -2.23889306e-01f, -8.75455141e-02f, 1.53854355e-01f, -2.67993987e-01f, 2.47789472e-01f, -1.99440181e-01f,
  -9.83529836e-02f, 3.48713785e-01f, 3.13871443e-01f, -3.43631059e-01f, 5.66227078e-01f, 3.65759879e-01f, -1.41125917e-01f, 9.71082523e-02f, -4.85205911e-02f, -1.55644998e-01f,
  -1.27804587e-02f, -2.53660917e-01f, -1.09343469e-01f, -5.69313347e-01f, -3.62163216e-01f, -1.83611155e-01f, -6.94937306e-03f, -1.74360555e-02f, -4.51480180e-01f, -1.13989845e-01f,
  -4.80014980e-01f, -2.75169879e-01f, -1.34266436e-01f, -9.63494033e-02f, -1.62029848e-01f, 5.35982437e-02f, 1.33191600e-01f, 2.04560325e-01f, -7.66334906e-02f, 6.02336321e-03f,
  1.97470754e-01f, -1.43277287e-01f, -6.99176714e-02f, 1.79323573e-02f, 8.76085088e-03f, -9.21557918e-02f, -2.31123194e-02f, -1.38526052e-01f, -1.39985129e-01f, -5.49157113e-02f,
  -1.03914142e-02f, -4.16760594e-02f, -1.22077145e-01f, 6.58270344e-02f, 1.13482676e-01f, -1.09461002e-01f, 1.03824474e-01f, 1.38465539e-01f, 3.39187048e-02f, -8.66655782e-02f,
  1.33016437e-01f, 1.25214100e-01f, 9.59417149e-02f, -1.22807343e-02f, 4.22137380e-02f, -1.80927172e-01f, -2.39809193e-02f, 1.40013933e-01f, -5.12587391e-02f, 9.80853662e-03f,
  -5.24026118e-02f, 3.58765200e-02f, 8.34410265e-02f, 1.38423825e-03f, -1.83145329e-02f, 1.45435944e-01f, 1.45392612e-01f, 4.85595651e-02f, -3.48923951e-02f, -6.10610470e-02f,
  3.67181115e-02f, 5.55365458e-02f, -1.11989222e-01f, -5.03558889e-02f, -4.66037095e-02f, 1.10305704e-01f, -1.23216383e-01f, -6.05014677e-04f, 7.79998815e-03f, 3.98742966e-02f,
  -1.90973595e-01f, 3.82247195e-02f, -1.49648592e-01f, -6.27888516e-02f, -3.57370153e-02f, 8.02354664e-02f, 1.25963017e-01f, 1.05650062e-02f, -1.33554146e-01f, 1.75456971e-01f,
  -5.47277592e-02f, -1.17392614e-01f, 6.19008504e-02f, 1.16649911e-01f, -2.01422721e-03f, -1.80563815e-02f, 6.60408512e-02f, 8.26740190e-02f, -6.79242611e-02f, -9.24779028e-02f,
  -9.10153240e-02f, 6.85989633e-02f, 2.36765924e-03f, -6.05047569e-02f, -8.88761729e-02f, -6.12838641e-02f, 8.59731585e-02f, 4.66252454e-02f, 2.23520081e-02f, -2.17593424e-02f,
  1.75230771e-01f, -1.39809179e-03f, -5.48136711e-01f, 3.88202667e-02f, -4.31360185e-01f, 9.95896459e-02f, 2.18909368e-01f, -1.06451042e-01f, -1.26207799e-01f, 5.59569001e-01f,
  4.89120871e-01f, -1.35850161e-01f, 3.59456092e-01f, 6.39036298e-01f, -2.05323189e-01f, 3.38190258e-01f, 4.45153654e-01f, 2.81201780e-01f, -2.90291578e-01f, 8.73194858e-02f,
  -7.70654902e-02f, 4.62169170e-01f, 3.27211209e-02f, 1.25907436e-01f, 1.27632335e-01f, -3.26944888e-01f, 2.30939701e-01f, -3.81159902e-01f, 7.79345259e-02f, -1.35838330e-01f,
  1.27080962e-01f, 2.57057641e-02f, -8.85181651e-02f, -1.17129914e-01f, -2.26005837e-02f, 3.02591585e-02f, -3.62647623e-02f, -8.99942145e-02f, -8.30077380e-02f, -1.64784433e-03f,
  4.94106067e-03f, -1.37046814e-01f, 1.39063569e-02f, -5.83769418e-02f, -7.65186176e-02f, -1.17321223e-01f, -7.59982094e-02f, -7.10202828e-02f, -2.03183033e-02f, 5.55430725e-02f,
  -5.88731319e-02f, -1.15004487e-01f, 5.10934778e-02f, 3.01908050e-02f, -8.72565284e-02f, -3.00435629e-02f, -5.47055975e-02f, -3.92222144e-02f, -6.37309626e-02f, -1.11795850e-01f,
  3.33648361e-02f, -5.42560406e-02f, 8.44898913e-03f, 6.34410009e-02f, -2.09556259e-02f, -1.67600121e-02f, 1.03556462e-01f, 1.08008288e-01f, -7.04445168e-02f, 1.56845346e-01f,
  6.63257316e-02f, -7.98551887e-02f, 7.25057675e-03f, 6.95430711e-02f, 1.41171217e-01f, -2.64497567e-02f, -1.82689317e-02f, 6.46902174e-02f, 7.69408885e-03f, -1.04749389e-01f,
  5.60927503e-02f, -4.45323773e-02f, -6.27334565e-02f, 5.89606538e-02f, -1.07036566e-03f, 2.54667941e-02f, 2.04904154e-01f, 2.70677488e-02f, 2.86619589e-02f, -9.20255780e-02f,
  -1.79123394e-02f, 8.81408006e-02f, 1.21222157e-02f, -9.66503248e-02f, -9.06840935e-02f, 5.74392155e-02f, 1.18268400e-01f, 2.64014453e-02f, 5.29351905e-02f, 5.69619723e-02f,
  -8.67810696e-02f, 3.96643952e-03f, 2.48604584e-02f, -3.30682173e-02f, -8.15264285e-02f, 9.22746584e-03f, 1.20924078e-01f, -1.96442813e-01f, 3.56526189e-02f, -4.65679504e-02f,
  -4.79062237e-02f, 5.90067729e-02f, -1.95103418e-02f, -1.40194878e-01f, 7.14288000e-03f, 7.24871363e-03f, -1.50392190e-01f, -8.57572779e-02f, -5.73825575e-02f, 1.51709383e-02f,
  -4.25614417e-02f, -2.87925601e-01f, -1.58764124e-01f, -1.09587505e-01f, -2.52251953e-01f, -1.36879653e-01f, 1.90586969e-02f, -4.28919345e-01f, -2.27131005e-02f, -1.14770129e-01f,
  -3.01767200e-01f, 2.09202275e-01f, 3.79841536e-01f, -3.45878690e-01f, 5.10155082e-01f, 5.33955276e-01f, -1.34778932e-01f, 1.60687730e-01f, 2.54924856e-02f, -2.52867311e-01f,
  -2.52360106e-01f, -4.31614518e-01f, 9.04536620e-02f, -3.73984277e-01f, -3.33386838e-01f, -2.11628720e-01f, 4.44931649e-02f, -1.89400509e-01f, -4.48416829e-01f, 5.93746267e-03f,
  -8.78828838e-02f, -5.40480986e-02f, -1.38841629e-01f, 8.71124789e-02f, 9.02437512e-03f, -6.17443286e-02f, -1.61726460e-01f, 7.72388875e-02f, 1.35557011e-01f, 3.55973616e-02f,
  1.12711288e-01f, 4.40510400e-02f, -7.64275938e-02f, 1.01716876e-01f, -2.10070640e-01f, -1.21245019e-01f, -4.99459542e-02f, -4.96084094e-02f, -4.72118817e-02f, 8.35275576e-02f,
  -3.93481851e-02f, -5.56736812e-02f, -5.10201976e-02f, 8.30263272e-02f, 2.52554175e-02f, -5.83922938e-02f, 7.60273263e-02f, 1.23376139e-02f, -2.19617672e-02f, 5.13547026e-02f,
  -1.11686513e-01f, 2.00256100e-03f, -2.36219149e-02f, -1.37204304e-01f, -1.07448198e-01f, -3.17264050e-02f, -7.78677594e-03f, -2.60372907e-02f, -2.71769483e-02f, 7.26115927e-02f,
  -1.41110821e-02f, -1.03863753e-01f, -1.76660120e-02f, 4.02324647e-02f, -2.97778491e-02f, -1.09389588e-01f, 1.43519089e-01f, -3.19044455e-03f, -1.81424525e-03f, 1.15590706e-01f,
  6.61999136e-02f, -5.61710633e-02f, 1.78165019e-01f, 7.81862885e-02f, -1.60055119e-03f, 1.17812842e-01f, -2.98602376e-02f, 1.06894396e-01f, 4.67862338e-02f, 7.84741566e-02f,
  6.07774146e-02f, 8.78316090e-02f, 8.97328779e-02f, 8.82055387e-02f, 9.53284130e-02f, -1.71526983e-01f, -1.29574358e-01f, -5.35141341e-02f, 1.21335611e-01f, -1.19626068e-01f,
  -1.36992916e-01f, 1.79410681e-01f, 5.52968159e-02f, -1.02415286e-01f, 2.89685894e-02f, -1.36391550e-01f, 2.01802421e-02f, 9.61992983e-03f, 8.42539519e-02f, -1.19838312e-01f,
  2.08900180e-02f, 3.64139564e-02f, 1.28473014e-01f, 8.06584358e-02f, 1.43372387e-01f, 1.44518211e-01f, -2.05083434e-02f, -2.98800860e-02f, 7.31586367e-02f, 1.06951864e-02f,
  2.56367266e-01f, -2.43538857e-01f, 1.25939146e-01f, 9.73973349e-02f, 3.58903706e-01f, 4.13082778e-01f, 2.49277517e-01f, 3.69049281e-01f, 3.40458065e-01f, -7.79322088e-02f,
  9.51598808e-02f, -3.97976846e-01f, -3.06919932e-01f, -2.02423364e-01f, -2.47059464e-01f, -2.83180237e-01f, 1.66626871e-01f, -1.27001747e-01f, 4.32872064e-02f, 1.59681350e-01f,
  1.16870873e-01f, -2.47596011e-01f, -3.50890875e-01f, -3.98445129e-02f, 1.54545411e-01f, 1.92767948e-01f, -2.84331627e-02f, -2.73379590e-03f, -3.67457531e-02f, -1.63649172e-01f,
  9.71877426e-02f, 2.37173196e-02f, 1.04832217e-01f, -8.18641856e-02f, 2.37819746e-01f, 9.67738554e-02f, 8.09710771e-02f, -1.50101453e-01f, 3.59555371e-02f, -3.23356986e-02f,
  -1.61201105e-01f, -1.45132676e-01f, 1.09474789e-02f, -1.42518148e-01f, 8.19078907e-02f, -5.91027038e-03f, -1.59092396e-02f, 1.41919151e-01f, -8.20907671e-03f, -2.68553328e-02f,
  5.65025583e-02f, -4.65659797e-02f, 2.80707896e-01f, -9.14161466e-03f, 1.09762751e-01f, -5.43625280e-03f, 8.10620263e-02f, 1.36527494e-01f, -1.83494873e-02f, 1.29286632e-01f,
  -7.83296954e-03f, 1.95406482e-01f, -3.72924022e-02f, -5.67940883e-02f, 2.35867575e-02f, 8.39702506e-03f, -7.39212707e-02f, 2.46066209e-02f, 3.67016182e-03f, -3.79557908e-02f,
  1.11432962e-01f, -1.42682239e-01f, -5.69272488e-02f, 4.47868593e-02f, -2.43111718e-02f, 8.01104121e-03f, -2.13849433e-02f, -1.93589423e-02f, 8.82626623e-02f, 4.71383445e-02f,
  -1.23484395e-02f, -1.78978816e-02f, -1.00211747e-01f, -1.16293751e-01f, -5.64330369e-02f, -4.44530929e-03f, -6.98619559e-02f, 5.41484123e-03f, 7.64957294e-02f, -1.35653004e-01f,
  1.24961503e-01f, 6.30862191e-02f, -4.07655574e-02f, -7.82609507e-02f, 2.11652797e-02f, 1.62371844e-01f, 9.51200873e-02f, 2.60655731e-02f, 5.43700755e-02f, 1.03848826e-04f,
  1.24189369e-01f, -2.44693961e-02f, 1.50681362e-01f, -6.08916432e-02f, -5.03143063e-03f, 6.25179037e-02f, -9.91719775e-03f, 5.82854673e-02f, 1.40950009e-01f, 1.84138492e-02f,
  5.49814031e-02f, 7.86870718e-02f, -8.38680491e-02f, 5.56777082e-02f, -8.30018334e-03f, -8.36237147e-02f, 1.32795841e-01f, -1.34450048e-02f, -3.65116708e-02f, 6.36156881e-03f,
  -5.46128631e-01f, 1.29383564e-01f, 2.14031458e-01f, -5.95900714e-01f, 5.80751523e-02f, -1.76182799e-02f, -1.18171029e-01f, 2.07880259e-01f, 1.86154097e-01f, -3.70440260e-02f,
  4.60498743e-02f, 8.05302560e-02f, 5.67792833e-01f, -2.96836525e-01f, 1.52064577e-01f, 2.71146655e-01f, -2.48936936e-01f, -2.16617659e-01f, 3.13319862e-02f, -8.31914917e-02f,
  -1.55981585e-01f, -2.53818810e-01f, -1.58850282e-01f, 3.18282954e-02f, -2.42554337e-01f, -2.60374159e-01f, -5.07964194e-01f, 1.08522698e-01f, -4.40162867e-01f, 2.82551479e-02f,
  -5.09928346e-01f, -1.67949930e-01f, -2.96386689e-01f, -1.97959527e-01f, -1.77498192e-01f, -7.17848167e-02f, -9.26914439e-02f, 9.35432911e-02f, -9.49216858e-02f, 1.41894400e-01f,
  7.42712151e-03f, 1.17714563e-02f, -1.12722039e-01f, 1.79941639e-01f, -1.34073541e-01f, -1.04695611e-01f, -1.01652239e-02f, -1.53569758e-01f, 9.98363122e-02f, 1.06653698e-01f,
  1.18661314e-01f, -7.96562582e-02f, -2.10709795e-01f, -9.00615305e-02f, -9.20586940e-03f, -1.18275620e-01f, -3.66352801e-03f, -2.96263937e-02f, -1.59268230e-01f, -9.97618772e-03f,
  1.83865741e-01f, -5.88954166e-02f, -1.05148014e-02f, 8.62078965e-02f, 1.81836128e-01f, -2.82196868e-02f, 3.07293367e-02f, -6.89020753e-02f, -4.60110232e-02f, -1.20160736e-01f,
  -7.06220269e-02f, -2.38450915e-01f, -2.92569268e-02f, -1.01113893e-01f, -8.20429251e-02f, -2.17146222e-02f, -3.97362262e-02f, -5.93836531e-02f, 9.53118578e-02f, -9.18562412e-02f,
  8.75882059e-02f, -3.77359241e-02f, -2.19923630e-02f, -1.47043288e-01f, 1.20342813e-01f, 5.27898930e-02f, -2.47252621e-02f, 2.56238487e-02f, -1.09373182e-01f, 3.47885638e-02f,
  -6.61896229e-01f, -3.22391033e-01f, -6.93074539e-02f, -1.38274580e-01f, -5.98986335e-02f, -1.00915127e-01f, 1.64096896e-02f, 1.60367582e-02f, -5.54990321e-02f, 3.57250161e-02f,
  -1.40891939e-01f, -2.78157629e-02f, -5.12441732e-02f, 2.04924252e-02f, 1.53642535e-01f, 1.15522472e-02f, -5.24750464e-02f, -5.65330423e-02f, -1.84138164e-01f, -5.30308783e-02f,
  -9.99398902e-02f, 1.63292259e-01f, 1.71354458e-01f, -1.62419200e-01f, -7.50578195e-02f, -1.03247575e-01f, 9.70878899e-02f, -6.53565973e-02f, -5.58983386e-02f, 1.99033096e-02f,
  -4.36777100e-02f, 3.70252550e-01f, 6.80480659e-01f, 7.32224226e-01f, -1.47912530e-02f, -5.36343336e-01f, -1.82109222e-01f, -4.41372395e-02f, 2.06201002e-01f, -2.17272535e-01f,
  -1.06732175e-01f, 1.56173885e-01f, -1.77592039e-01f, 4.00262564e-01f, 3.70693207e-01f, -3.41639817e-02f, 1.41946316e-01f, -1.10184006e-01f, 1.06907599e-01f, 6.06261194e-02f,
  2.67559558e-01f, 5.46597950e-02f, 3.55286151e-01f, 2.88298167e-02f, 3.29437047e-01f, 3.89062345e-01f, 4.40993220e-01f, 2.75977999e-01f, 4.14163947e-01f, 1.02300920e-01f,
  -1.79193512e-01f, 3.91033553e-02f, 2.70127356e-02f, -8.06101263e-02f, -1.09654642e-03f, -7.69991949e-02f, 4.19472568e-02f, 2.35866494e-02f, 7.11794868e-02f, -3.64405178e-02f,
  -1.63977206e-01f, 2.48831473e-02f, 1.04258090e-01f, 3.95489410e-02f, -1.08528733e-01f, 7.41953477e-02f, 5.06912395e-02f, -6.85900524e-02f, -2.15497613e-03f, -6.51116893e-02f,
  7.99954906e-02f, 4.27997634e-02f, -3.44708608e-03f, 6.34368658e-02f, 1.05160072e-01f, -4.57546301e-02f, 1.05698131e-01f, 6.25217184e-02f, 4.14497741e-02f, 5.22663891e-02f,
  -9.24452767e-02f, 8.24748725e-02f, 6.75707683e-02f, 7.40990341e-02f, -9.20025632e-02f, 1.10097341e-02f, 6.33518025e-02f, -8.87312889e-02f, 8.18746388e-02f, -2.01884974e-02f,
  -2.92508863e-02f, 5.06364591e-02f, -8.44989493e-02f, -2.84765754e-02f, 2.40342561e-02f, -9.98674482e-02f, -6.08917437e-02f, 2.20516808e-02f, 5.86900208e-03f, 5.17121814e-02f,
  4.77989651e-02f, -2.21749246e-02f, 1.26280949e-01f, 2.60242703e-03f, -1.20718367e-01f, 1.06088467e-01f, 1.21327884e-01f, -5.12705557e-02f, 2.16536745e-02f, -4.16924693e-02f,
  -1.88644940e-03f, 5.19538701e-01f, 4.01108228e-02f, -1.21858083e-01f, 4.73787673e-02f, 3.14412676e-02f, 9.12910700e-02f, -1.70223325e-01f, 1.01968482e-01f, -1.32864462e-02f,
  -1.31487742e-01f, -7.89482519e-02f, -2.54970454e-02f, -1.06709100e-01f, 3.50086764e-02f, 1.52958766e-01f, 5.87134659e-02f, -2.93358066e-03f, 1.02938674e-01f, 1.34871870e-01f,
  -1.59720611e-02f, -7.98977986e-02f, -2.69643627e-02f, -6.67235553e-02f, -1.50192961e-01f, 5.46518415e-02f, 1.26905208e-02f, 2.29644962e-02f, 9.21877176e-02f, 2.00372174e-01f,
  4.72115666e-01f, -4.76308584e-01f, -2.23780409e-01f, 3.37592125e-01f, 5.11403561e-01f, -4.29640710e-03f, -2.58066982e-01f, 2.25328863e-01f, 1.79579124e-01f, -3.66589248e-01f,
  2.91964114e-02f, -2.71827310e-01f, -5.11504054e-01f, 2.86950499e-01f, 2.76338726e-01f, -1.35849983e-01f, 1.93419740e-01f, 9.41822007e-02f, 1.74675912e-01f, -3.67399491e-03f,
  3.16604197e-01f, 4.11533594e-01f, -3.88958976e-02f, 5.62375747e-02f, 1.06655121e-01f, -4.09395285e-02f, -7.73250684e-02f, -2.82453418e-01f, 1.15984499e-01f, 8.51763785e-02f,
  -2.37462521e-02f, 4.49380316e-02f, -1.65241174e-02f, -1.64058119e-01f, -4.04269546e-02f, -8.05544928e-02f, -2.07069516e-01f, -7.38195181e-02f, -5.03718294e-02f, -1.60591584e-02f,
  -9.61062759e-02f, 6.72701374e-02f, 1.92844555e-01f, 1.09472588e-01f, -1.31818829e-02f, 1.46523073e-01f, 1.90860420e-01f, -9.01859552e-02f, 3.02937310e-02f, 6.57334030e-02f,
  3.10848691e-02f, 1.81099430e-01f, 7.27948248e-02f, 1.00571685e-01f, 4.21902612e-02f, 1.14874087e-01f, 1.45191485e-02f, -9.88282561e-02f, 2.47932132e-02f, 2.27319077e-03f,
  -1.20416908e-02f, -9.61269438e-02f, -2.38261577e-02f, -1.36872185e-02f, -4.53871079e-02f, 8.28086585e-02f, 4.83545065e-02f, 3.44787948e-02f, -1.00942753e-01f, -3.51638459e-02f,
  8.16586241e-02f, -6.87791407e-02f, 3.81785221e-02f, -3.12896594e-02f, -4.98515740e-02f, 7.66488612e-02f, -3.37870978e-02f, 4.15942632e-02f, 3.72124277e-03f, 9.26967934e-02f,
  -3.09806876e-03f, 4.68981788e-02f, -3.17913219e-02f, 8.57747942e-02f, 3.93119194e-02f, -7.05772638e-02f, 6.52434602e-02f, -1.30385771e-01f, 9.55126733e-02f, -3.36798728e-02f,
  -6.28048301e-01f, -5.70846140e-01f, -1.87897071e-01f, 8.97979438e-02f, -1.78411171e-01f, -2.31214310e-03f, 2.73266658e-02f, 1.67683616e-01f, -1.96841642e-01f, 1.85498875e-02f,
  -4.02866565e-02f, 6.20953850e-02f, -9.62373391e-02f, 9.58078131e-02f, -9.33517590e-02f, 4.52883579e-02f, -1.36478558e-01f, -9.38025936e-02f, -7.05418438e-02f, -5.61936409e-04f,
  -1.38553351e-01f, -6.52170479e-02f, 2.65311357e-02f, 1.18653513e-01f, 8.42515901e-02f, 2.92520300e-02f, 6.44977987e-02f, 5.93090467e-02f, 8.31291005e-02f, -8.55394900e-02f,
  4.50402111e-01f, -4.00487214e-01f, -3.35959882e-01f, 1.62638783e-01f, 9.62857977e-02f, -2.79059410e-01f, -1.38417393e-01f, -9.64333043e-02f, 5.51537931e-01f, -4.13726121e-01f,
  -1.29015595e-01f, -1.44885451e-01f, -2.06973925e-01f, -2.00287119e-01f, 5.72269142e-01f, 1.69658333e-01f, -7.78134540e-02f, -1.85876876e-01f, 2.51410037e-01f, -1.69353843e-01f,
  3.05479109e-01f, -8.20077136e-02f, -2.26009358e-02f, -3.84987265e-01f, -2.38643155e-01f, -2.56637245e-01f, 1.33687968e-03f, -3.70931864e-01f, -4.87043589e-01f, -9.18795764e-02f,
  8.22231695e-02f, 7.53197521e-02f, -2.61482946e-03f, 5.64323831e-03f, -2.77680475e-02f, -1.54832602e-02f, -1.41928002e-01f, -1.42421782e-01f, 1.98296070e-01f, 5.36391549e-02f,
  -4.44933437e-02f, 2.45412681e-02f, -5.56098521e-02f, 1.19339675e-02f, 2.07188483e-02f, 2.69264169e-03f, 2.75000371e-02f, 1.86299101e-01f, -7.06211776e-02f, -5.94829693e-02f,
  8.96885917e-02f, -7.51726478e-02f, 4.68285680e-02f, -2.02559218e-01f, 3.93260717e-02f, -1.89967882e-02f, -4.96324897e-02f, -2.83784419e-01f, -1.18613534e-01f, 1.71220541e-01f,
  -1.08287968e-01f, -2.97956169e-03f, -1.02856629e-01f, 9.34896525e-03f, -3.18954997e-02f, 1.46292727e-02f, -2.58852132e-02f, -7.69383162e-02f, 5.00996336e-02f, 1.18711591e-02f,
  -1.59851592e-02f, 5.20158075e-02f, 1.12257496e-01f, 8.70397240e-02f, 1.25320688e-01f, 1.07359424e-01f, -6.24272972e-02f, -8.32166150e-02f, 1.26053378e-01f, 6.87484145e-02f,
  -2.16022544e-02f, 6.31319359e-02f, -6.56185076e-02f, -7.17201680e-02f, -2.75577698e-02f, -1.69601535e-05f, -1.75750386e-02f, 6.97968602e-02f, 1.16335712e-01f, -3.68101038e-02f,
  2.05128565e-02f, -3.84214550e-01f, 7.42594525e-02f, -5.47738746e-02f, -7.07784593e-02f, 1.16421498e-01f, -2.19738465e-02f, 2.78205536e-02f, 4.71311621e-03f, -3.34479660e-02f,
  -1.36373520e-01f, -4.47927974e-03f, -3.04589290e-02f, 7.80416466e-03f, 1.12755243e-02f, 3.83422747e-02f, -1.23625219e-01f, 1.26709238e-01f, 8.49571638e-03f, -1.50492087e-01f,
  6.99751601e-02f, 4.64198180e-02f, 3.62792127e-02f, -3.04200575e-02f, -1.29207179e-01f, -1.42896205e-01f, 6.70688003e-02f, -4.64778095e-02f, -2.09790140e-01f, 9.27384347e-02f,
  5.10662675e-01f, 3.54010642e-01f, 3.71631324e-01f, 1.96889117e-01f, -3.84992033e-01f, -9.48433802e-02f, -2.31602713e-01f, -1.88265532e-01f, -4.14484786e-03f, 2.42350638e-01f,
  -4.05907333e-01f, 5.71563482e-01f, -3.26595634e-01f, 1.44217283e-01f, -4.26052153e-01f, -2.80303746e-01f, -5.28363362e-02f, 5.94741106e-02f, -8.65796953e-02f, 1.68937936e-01f,
  -7.42485002e-02f, -3.95064056e-01f, -5.65718710e-02f, -2.86977321e-01f, 2.17240185e-01f, 3.07722628e-01f, -3.47415894e-01f, -1.91985980e-01f, 2.74404258e-01f, -2.08798647e-01f,
  -7.86815956e-02f, -3.59352455e-02f, 7.41477981e-02f, 2.31201649e-02f, 6.45966381e-02f, 4.57880385e-02f, 3.28824222e-02f, -2.81707440e-02f, -1.94119383e-02f, 1.01792157e-01f,
  2.23840892e-01f, -2.14166939e-02f, 6.50310772e-04f, -1.12804070e-01f, 8.45394880e-02f, 4.19863909e-02f, 1.31982088e-01f, 1.51923507e-01f, 1.26535654e-01f, 1.14728980e-01f,
  2.06078082e-01f, 1.53984353e-01f, 6.28057495e-02f, 3.26660164e-02f, 1.99131873e-02f, -1.57179222e-01f, 1.00655548e-01f, 4.77484949e-02f, 8.10695142e-02f, 1.82105578e-04f,
  4.20179713e-04f, -4.92921099e-02f, -5.53739630e-02f, 3.53155285e-02f, -4.52587716e-02f, -4.33253907e-02f, 1.03529058e-02f, 2.77185980e-02f, -5.11558950e-02f, -6.34586364e-02f,
  -4.60517369e-02f, 8.34040269e-02f, -5.26536852e-02f, 1.24446191e-01f, 2.38403622e-02f, 6.73160776e-02f, 1.97295491e-02f, 5.12628406e-02f, 6.85275346e-02f, 3.97065878e-02f,
  -8.53173956e-02f, -7.42387325e-02f, -9.22757015e-02f, 4.04978963e-03f, -1.30852804e-01f, -1.00417979e-01f, -1.12979338e-02f, 8.45304877e-02f, -5.33123240e-02f, -7.34439492e-02f,
  4.51550819e-02f, -9.32221208e-03f, 8.74822810e-02f, -1.26844393e-02f, -4.70502041e-02f, 8.87857825e-02f, -2.42594201e-02f, 1.35410190e-01f, -4.56105620e-02f, -5.83943203e-02f,
  9.12976190e-02f, -3.79501306e-03f, 2.48358026e-02f, 5.52274324e-02f, -1.40215188e-01f, -2.93216575e-02f, -6.25404045e-02f, 2.54418608e-02f, 4.44204994e-02f, -2.38903929e-02f,
  1.05118029e-01f, -4.04075533e-02f, 6.50308728e-02f, -3.77688184e-02f, 1.45527581e-02f, 3.10819373e-02f, 3.95826697e-02f, 1.50940925e-01f, 3.18751559e-02f, 7.35603794e-02f,
  4.06227484e-02f, -2.39576817e-01f, -7.46500492e-02f, 3.27225327e-01f, -1.29786760e-01f, -6.24094129e-01f, -8.41770470e-01f, 1.41760632e-02f, -3.10753077e-01f, -2.63330489e-01f,
  9.33014378e-02f, 8.53186771e-02f, -4.40699697e-01f, 3.44517142e-01f, 4.28031594e-01f, -2.60394216e-01f, 2.00389713e-01f, -1.80400591e-02f, -2.14539301e-02f, 1.01951241e-01f,
  1.39273122e-01f, 3.30213994e-01f, 3.58643144e-01f, 3.79442543e-01f, 7.26829395e-02f, 3.56563181e-01f, 5.85034728e-01f, -8.24190155e-02f, 4.87402946e-01f, 6.36764094e-02f,
  -1.11845076e-01f, 1.29691765e-01f, 1.32402927e-02f, 1.81845520e-02f, -3.35718356e-02f, -7.39512742e-02f, -4.27495427e-02f, 6.80035278e-02f, 1.03135504e-01f, -1.34443014e-03f,
  -3.85949761e-02f, 1.27618283e-01f, 3.26960050e-02f, 9.17660296e-02f, 1.91343836e-02f, 9.20458809e-02f, -5.43501191e-02f, -1.05321305e-02f, -1.87807158e-01f, -8.02164748e-02f,
  -1.53235525e-01f, -7.63793588e-02f, -1.18652713e-02f, -5.29786833e-02f, -5.45628276e-03f, -4.65487503e-02f, -1.18631134e-02f, -6.31615147e-02f, 5.35569862e-02f, 8.28973204e-02f,
  2.47750282e-02f, -7.89570808e-02f, -1.45219266e-01f, -3.02469917e-02f, -7.46135116e-02f, 1.30060082e-03f, 4.73664403e-02f, -2.22538281e-02f, -1.94125734e-02f, 4.68886159e-02f,
  7.87529051e-02f, -6.44120481e-03f, -5.88666052e-02f, -6.52976036e-02f, -4.56798859e-02f, 1.69786382e-02f, 2.62125693e-02f, 3.45707238e-02f, -4.26548608e-02f, -3.43680643e-02f,
  3.03457119e-03f, 1.47323325e-01f, -1.64614186e-01f, -5.52312396e-02f, -3.21229100e-02f, 1.11537911e-01f, 1.48440436e-01f, 5.74065559e-02f, 4.02537035e-03f, -1.00802846e-01f,
  3.45118344e-02f, 1.61961496e-01f, -1.21401854e-01f, -3.80404852e-02f, -2.73025259e-02f, -3.75330984e-03f, 5.21164089e-02f, -3.57079580e-02f, 5.03853261e-02f, -8.67976323e-02f,
  1.45706087e-01f, 2.01623552e-02f, -2.66089588e-02f, 1.13899343e-01f, 1.36163428e-01f, -8.70688483e-02f, 5.50114028e-02f, 9.99860615e-02f, 7.17893466e-02f, 1.42100424e-01f,
  9.22501087e-02f, -1.18539244e-01f, 1.33438325e-02f, -1.89339101e-01f, 1.97752398e-02f, -1.31968468e-01f, 8.37343037e-02f, 2.40237527e-02f, -1.12245288e-02f, 3.52291018e-03f,
  5.56516647e-01f, -7.18815744e-01f, 3.85288537e-01f, 4.58129913e-01f, 4.12197113e-01f, 1.01183929e-01f, 7.06806481e-01f, -2.29989946e-01f, 1.63264737e-01f, -5.60564995e-01f,
  -5.90512827e-02f, -1.34182023e-02f, -2.13519260e-01f, -1.11430191e-01f, 4.99481678e-01f, -2.06205860e-01f, -9.68390889e-03f, 1.89478155e-02f, -6.18667006e-02f, -7.67365657e-03f,
  2.04069585e-01f, 5.53022958e-02f, 1.99340641e-01f, -3.61144543e-01f, 1.82184085e-01f, -5.14463149e-02f, -3.89542580e-02f, 1.96897313e-01f, -2.03280384e-03f, 2.61099517e-01f,
  -1.17908895e-01f, -1.04845330e-01f, 4.78707626e-03f, -4.56395820e-02f, -1.36625573e-01f, 1.75021179e-02f, 1.33606210e-01f, 1.43036038e-01f, 2.14581370e-01f, 7.86025357e-03f,
  -3.34846824e-02f, -7.25678504e-02f, 1.48753973e-03f, 7.87368417e-02f, 6.14798404e-02f, -6.92346692e-02f, 7.21188029e-03f, -5.95990084e-02f, 1.21455766e-01f, 2.96531860e-02f,
  1.59818027e-03f, -1.32947460e-01f, 1.17054828e-01f, -1.14990838e-01f, -8.59981403e-03f, 6.29312024e-02f, 4.07753363e-02f, 6.40278682e-02f, -1.22657493e-01f, 2.93292943e-02f,
  4.45736051e-02f, -1.24545842e-01f, 1.93476956e-02f, -5.03189787e-02f, 1.15832888e-01f, 1.23064741e-01f, 8.14546272e-02f, 4.55352925e-02f, -3.33495736e-02f, -3.64406705e-02f,
  7.32523799e-02f, 4.91421930e-02f, -1.67293474e-02f, -2.73618437e-02f, 3.97643596e-02f, -1.22013971e-01f, 4.55304645e-02f, -1.42587155e-01f, -5.62166460e-02f, 5.11772698e-03f,
  1.50892422e-01f, 6.93733543e-02f, -1.13882691e-01f, 1.11474276e-01f, 1.33532863e-02f, 7.81309605e-02f, -8.27345252e-02f, -5.08886166e-02f, -2.21315119e-02f, 2.59830989e-02f,
  -5.36461949e-01f, -3.16764385e-01f, 3.16558108e-02f, -8.68109390e-02f, -8.26616883e-02f, -2.14517638e-01f, -2.78796512e-03f, -1.07078090e-01f, -9.50991139e-02f, 6.90148026e-02f,
  -1.23492129e-01f, -1.06630265e-03f, -1.29144579e-01f, 1.23011786e-02f, -4.17813696e-02f, -7.59416772e-03f, -6.06374927e-02f, -1.83063075e-01f, -5.94350025e-02f, -9.93046835e-02f,
  -7.41404518e-02f, -3.73901688e-02f, 6.46434650e-02f, -3.95221673e-02f, -1.02438800e-01f, 3.96649651e-02f, -9.68769118e-02f, 4.66667488e-02f, 2.21071392e-02f, 2.81626228e-02f,
  -8.47377181e-01f, 4.78051275e-01f, -8.33049938e-02f, 3.36872876e-01f, -2.91444063e-01f, 7.50079989e-01f, 7.67676711e-01f, 9.07714441e-02f, 4.68318462e-01f, 4.07362550e-01f,
  1.31649345e-01f, -1.85997784e-01f, 9.38934609e-02f, 5.24945915e-01f, -2.63037713e-04f, 4.62546885e-01f, 4.84238088e-01f, 3.27832609e-01f, -4.89563448e-03f, -1.72367141e-01f,
  5.22023477e-02f, 1.79840043e-01f, 7.27148578e-02f, -4.10940230e-01f, -1.68085605e-01f, -5.04448414e-01f, -1.71291575e-01f, -3.94342333e-01f, -1.18084908e-01f, -3.79279144e-02f,
  -2.53023148e-01f, -3.81273627e-01f, -2.27811083e-01f, -1.55516528e-02f, -1.46432847e-01f, -7.78492615e-02f, -1.29804179e-01f, -1.14428818e-01f, -2.21687213e-01f, 6.89251870e-02f,
  1.14436029e-02f, -1.32059559e-01f, 1.16856366e-01f, 4.74220607e-03f, -4.36625220e-02f, 4.29857001e-02f, 3.11285611e-02f, 1.74550250e-01f, -8.51270091e-03f, -6.84230328e-02f,
  3.15981023e-02f, 3.53606194e-02f, 1.37476340e-01f, 1.52114719e-01f, 3.09603587e-02f, 1.06353037e-01f, 2.25550056e-01f, 3.87524888e-02f, 4.07425053e-02f, 7.57963061e-02f,
  -1.80593371e-01f, -8.27792753e-03f, 4.90363166e-02f, -2.82246973e-02f, -6.68441877e-02f, -6.30168244e-02f, 9.47233737e-02f, -1.87921524e-02f, -9.43713859e-02f, -5.77079551e-03f,
  -1.11593958e-02f, -3.78550030e-03f, -4.97783199e-02f, 1.27010420e-01f, 1.10877328e-01f, 8.26033875e-02f, -1.07619558e-02f, -4.61107530e-02f, 1.38245657e-01f, 1.58034727e-01f,
  -4.81234398e-03f, 1.03774659e-01f, 3.28597911e-02f, -4.60882559e-02f, 2.22628657e-03f, -9.02851298e-03f, 1.12575674e-02f, 7.31272697e-02f, 9.01610628e-02f, -7.39189088e-02f,
  1.51602268e-01f, -2.96476819e-02f, 3.01193818e-02f, -4.18956950e-02f, -8.56293067e-02f, -1.69309527e-02f, -4.13606316e-02f, 1.93214063e-02f, -6.79235766e-03f, -5.77524379e-02f,
  -7.78031647e-02f, 6.61209822e-02f, -1.38146281e-01f, 1.85408033e-02f, -1.13062365e-02f, 2.30949759e-01f, -1.10046834e-01f, 8.95119309e-02f, 1.50340451e-02f, -1.83552876e-01f,
  -8.79443362e-02f, -1.27092656e-02f, 3.90346237e-02f, 5.60227148e-02f, 1.65444482e-02f, 5.01988037e-03f, -2.86043007e-02f, -5.62733077e-02f, -1.13552166e-02f, 8.82860497e-02f,
  -6.73102140e-01f, 8.55910766e-04f, -5.49745977e-01f, -4.72419590e-01f, 8.48339349e-02f, -6.48808241e-01f, -1.98609591e-01f, -2.06850186e-01f, 7.22916238e-03f, 6.23373449e-01f,
  2.46843636e-01f, -1.41944513e-01f, 4.22976911e-01f, -3.38407695e-01f, -7.54224002e-01f, -1.83839902e-01f, -6.69759631e-01f, -2.99294323e-01f, -8.36756900e-02f, -1.84660837e-01f,
  -2.72352725e-01f, 2.20253542e-01f, -5.03394544e-01f, 3.23041260e-01f, -2.26019293e-01f, 5.93813919e-02f, 4.39927727e-01f, 1.89805880e-01f, -1.79834634e-01f, -1.11132167e-01f,
  -1.91285521e-01f, 1.82774544e-01f, -7.24874362e-02f, -1.06608503e-01f, -2.18316689e-01f, 7.09451213e-02f, -9.25293043e-02f, 6.05959678e-04f, 8.49053962e-04f, -1.28744632e-01f,
  2.15223618e-02f, 3.04538179e-02f, -3.04945260e-02f, 1.06454931e-01f, 1.29234539e-02f, 2.63439119e-02f, -6.06028400e-02f, -1.51144490e-01f, -3.33058164e-02f, -1.39439911e-01f,
  -2.03141451e-01f, -1.09513819e-01f, -4.05765995e-02f, 2.45052613e-02f, -1.29074425e-01f, 2.65194289e-02f, -5.87979369e-02f, 5.75839393e-02f, -1.00072034e-01f, -4.27920036e-02f,
  -5.31658111e-03f, -1.38179660e-02f, -1.57344490e-02f, -4.16133665e-02f, -1.39934197e-02f, 1.64912958e-02f, -6.76030014e-03f, 1.08344875e-01f, 1.08976355e-02f, 3.17727365e-02f,
  -2.91452575e-02f, -2.75231600e-02f, 2.17903429e-03f, -6.71310797e-02f, -3.83723453e-02f, 8.41711927e-03f, -1.21983727e-02f, 9.72630829e-02f, -1.34426117e-01f, -3.66603732e-02f,
  1.29997760e-01f, -7.90582895e-02f, 1.39422175e-02f, 6.52669650e-03f, -1.02876604e-01f, -1.53230857e-02f, -1.77216083e-02f, -1.04404978e-01f, -4.08030339e-02f, 8.66200328e-02f,
  5.60036115e-02f, 9.29531083e-02f, 1.23907506e-01f, 1.76967502e-01f, 4.08690982e-03f, -3.65874395e-02f, -3.45072299e-02f, -9.92961526e-02f, -2.64435541e-02f, 4.70104329e-02f,
  1.23204701e-01f, 7.54701272e-02f, -3.36863250e-02f, -1.94599498e-02f, -6.02940954e-02f, -8.38000141e-03f, 6.98963255e-02f, 1.15580797e-01f, -1.18193235e-02f, -2.52645481e-02f,
  1.63945004e-01f, 2.02513397e-01f, 5.68517148e-02f, 1.54917732e-01f, 9.77790505e-02f, 3.84832881e-02f, 2.95927469e-02f, -4.23309044e-04f, -3.91818723e-03f, 2.62138303e-02f,
  2.39169985e-01f, 4.21941429e-02f, -1.98133633e-01f, 3.11927050e-01f, -1.95524797e-01f, -1.02739863e-01f, -2.79881582e-02f, -6.99034557e-02f, -2.02548996e-01f, 2.01485734e-02f,
  1.37129247e-01f, -1.36691511e-01f, -1.42739609e-01f, 5.05121052e-01f, 3.22167039e-01f, 1.53276548e-01f, 3.94154698e-01f, 3.71496938e-03f, 3.63879954e-03f, 2.78605610e-01f,
  2.30796382e-01f, 4.21889424e-01f, 1.14147484e-01f, 2.39980295e-01f, 1.28807262e-01f, 3.30148288e-03f, 1.71364903e-01f, -5.62959835e-02f, 1.93429649e-01f, 8.38770121e-02f,
  2.28977442e-01f, 1.72802493e-01f, 5.36542609e-02f, 1.21558622e-01f, 1.80140510e-01f, 6.64276257e-02f, -1.46469497e-03f, -7.04598650e-02f, -6.57711737e-03f, 1.16440030e-02f,
  -1.40326871e-02f, 2.78067552e-02f, 5.61846755e-02f, -8.64672437e-02f, -1.74866080e-01f, -4.92530838e-02f, -2.09303737e-01f, -4.33180407e-02f, -5.02527952e-02f, 1.83246620e-02f,
  -1.04438335e-01f, 1.02814138e-02f, -5.79036064e-02f, -3.93691473e-02f, -7.42476657e-02f, -5.87925017e-02f, -1.76469497e-02f, -3.24681737e-02f, -8.14115480e-02f, 4.24128622e-02f,
  -1.74145661e-02f, -6.52082041e-02f, 1.63443070e-02f, -1.38655379e-02f, 7.16575757e-02f, 7.92630091e-02f, -1.39816672e-01f, -1.01014845e-01f, -8.68618563e-02f, 4.83300835e-02f,
  3.95845734e-02f, -1.61489975e-02f, 2.99553517e-02f, -4.78593782e-02f, 9.48256627e-03f, 5.17864265e-02f, -1.20145110e-02f, 1.14484392e-01f, -8.42023715e-02f, 1.96949970e-02f,
  8.30701068e-02f, -2.41821464e-02f, 1.95487980e-02f, -5.88989258e-02f, 1.18683502e-01f, -1.06631085e-01f, 5.43051772e-02f, -1.34145506e-04f, -1.12179980e-01f, -5.93300816e-03f,
  2.54627109e-01f, 3.29267621e-01f, -1.87289773e-03f, 6.58455789e-02f, -1.01422518e-02f, 1.00534268e-01f, 3.80020365e-02f, 7.99203292e-02f, 1.69949591e-01f, 1.16092116e-01f,
  1.72183737e-01f, -2.92155761e-02f, -5.48662618e-02f, -7.88035095e-02f, -2.98564099e-02f, 1.60100132e-01f, 7.35580474e-02f, 2.08636504e-02f, 5.91799952e-02f, 1.76109836e-01f,
  3.27323340e-02f, 6.84329346e-02f, -8.58369842e-02f, -7.22818077e-02f, 3.16312462e-02f, 7.79784918e-02f, 2.54072510e-02f, -9.40651149e-02f, 2.53164638e-02f, 5.23242950e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  3.01651150e-01f, 2.16633782e-01f, 4.51815188e-01f, 6.43387854e-01f, 5.67190945e-01f, 1.80917576e-01f, 2.86869347e-01f, 4.01463687e-01f, 3.01876277e-01f, -3.86520028e-02f,
  3.23151976e-01f, 5.02481639e-01f, 5.60313106e-01f, 3.81369352e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  1.44270167e-01f, 1.15230024e-01f, 2.22583398e-01f, -1.44884512e-01f, -1.82712272e-01f, 1.11815661e-01f, -2.28279069e-01f, 1.65395305e-01f, -1.62175149e-01f, -1.22214653e-01f,
  -3.83776426e-01f, -3.27952325e-01f, -2.17676628e-02f, -4.13979143e-02f, -1.57886192e-01f, 8.24977830e-02f, -3.93614441e-01f, -4.08498079e-01f, 3.22467059e-01f, -3.20104897e-01f,
  2.03618839e-01f, -9.49516073e-02f, 1.06405094e-01f, 2.96032339e-01f, -3.99306208e-01f, 5.52242883e-02f, -3.64146948e-01f, 2.64896840e-01f, 4.08610841e-03f, -1.32479578e-01f,
  -1.53960675e-01f, -2.97716204e-02f, 5.36099337e-02f, -2.63578475e-01f, -1.15066335e-01f, -1.37362182e-01f, -5.78577518e-02f, -5.71607091e-02f, 2.93067936e-02f, -2.41057217e-01f,
  -2.54179686e-01f, -2.47435480e-01f, 2.86206026e-02f, -4.91691865e-02f, 1.25800192e-01f, -1.34154946e-01f, 2.70603925e-01f, 1.53067410e-01f, 1.58795312e-01f, -2.33136445e-01f,
  -2.15198562e-01f, 2.64249802e-01f, -2.54197389e-01f, -4.74479049e-02f, -1.16987497e-01f, -8.57524723e-02f, 3.60861391e-01f, -5.17308190e-02f, -3.39422733e-01f, 3.74311775e-01f,
  -1.27912268e-01f, 1.20812483e-01f, 1.86237946e-01f, 1.15664631e-01f, -8.27758983e-02f, -2.41238251e-01f, 1.55072466e-01f, -5.88559471e-02f, -1.46540314e-01f, 5.20063490e-02f,
  2.52126068e-01f, -2.25674614e-01f, -1.16277382e-01f, -1.42726060e-02f, 1.91372409e-01f, -3.25815737e-01f, 1.99962050e-01f, -8.57751667e-02f, 2.47511696e-02f, -4.25635502e-02f,
  1.19469360e-01f, 3.35283786e-01f, 7.36335218e-02f, -2.85143107e-01f, 1.98525906e-01f, 4.48565781e-02f, 8.73385090e-03f, -4.09070402e-01f, 2.15347344e-03f, -6.51881173e-02f,
  -1.55318260e-01f, 1.08434148e-01f, -2.04513460e-01f, -3.70164841e-01f, 3.32086205e-01f, -1.42620474e-01f, 2.87992686e-01f, -2.97222167e-01f, 5.91038018e-02f, 2.01324776e-01f,
  -2.96338528e-01f, 1.84030384e-01f, 4.08184454e-02f, -2.65756380e-02f, -1.15208901e-01f, 1.91014364e-01f, -4.51173455e-01f, -4.48307961e-01f, -3.96879554e-01f, -2.93220371e-01f,
  -2.60703623e-01f, -2.88570374e-01f, -3.52134734e-01f, -9.45605785e-02f, 1.52285084e-01f, -1.18321121e-01f, 1.02867343e-01f, 4.36246628e-03f, -4.34237756e-02f, 7.27676228e-02f,
  5.94109967e-02f, 1.82731703e-01f, -3.62561941e-01f, -1.90311894e-02f, 1.06661163e-01f, -8.66063535e-02f, -1.55315280e-01f, 2.68895656e-01f, -7.80235827e-02f, -1.37859043e-02f,
  4.15074140e-01f, -1.14618510e-01f, -3.27655822e-01f, 3.97344232e-02f, -9.63774845e-02f, 1.30623400e-01f, 1.51479885e-01f, -2.00369716e-01f, -2.66213864e-01f, 3.42159718e-01f,
  -1.05960883e-01f, -3.84130026e-03f, 3.55645508e-01f, 1.37727037e-01f, 1.75315067e-01f, -5.41408360e-01f, 1.64800063e-01f, 1.11665256e-01f, 8.01346973e-02f, -1.91685244e-01f,
  1.50270283e-01f, 3.29302073e-01f, -4.56149012e-01f, -2.67505288e-01f, -1.31284371e-01f, -8.83869082e-02f, 5.03629409e-02f, 1.52698368e-01f, -1.38384581e-01f, 9.55324098e-02f,
  -1.20175526e-01f, -1.03614675e-02f, 9.92049556e-03f, 8.52702558e-02f, -1.55987278e-01f, -1.31368503e-01f, 1.73250481e-01f, -1.76256187e-02f, 3.21807653e-01f, 5.99549487e-02f,
  -3.91270816e-02f, 6.27052784e-02f, 8.68235603e-02f, 1.26386866e-01f, 1.02507710e-01f, 2.71096498e-01f, -1.45303771e-01f, -4.33593780e-01f, 3.71908955e-02f, -3.18064988e-01f,
  -9.92406160e-02f, 9.67681706e-02f, 1.82039335e-01f, 3.28473330e-01f, 6.95077628e-02f, 1.95453286e-01f, -3.10263038e-01f, 2.02855185e-01f, 2.37450778e-01f, -4.98356968e-02f,
  -3.99599969e-01f, -4.59649786e-02f, 1.15342423e-01f, -2.74914473e-01f, 9.01801363e-02f, 1.42254546e-01f, 3.02416533e-01f, 1.83004409e-01f, 1.90126687e-01f, 3.94589789e-02f,
  2.12367736e-02f, 3.06003779e-01f, 4.23854440e-01f, 2.61560798e-01f, 1.44983545e-01f, 2.37519845e-01f, 1.12106539e-01f, -2.56280657e-02f, 1.10007375e-01f, 6.55511841e-02f,
  -4.04561996e-01f, -1.48890004e-01f, -2.13838741e-01f, 2.14699835e-01f, 6.73153028e-02f, -1.87550277e-01f, 2.92048246e-01f, 5.71656972e-02f, 1.87162623e-01f, -1.13279708e-01f,
  7.79781565e-02f, -2.55580872e-01f, 1.92340270e-01f, -1.13445826e-01f, 3.25237930e-01f, -1.48532555e-01f, -1.49179757e-01f, 1.91016734e-01f, -2.03194991e-02f, 1.17280409e-01f,
  4.10165489e-02f, 2.13162124e-01f, -3.14498305e-01f, 2.42532313e-01f, -4.96705323e-01f, -2.46018618e-01f, -4.48193491e-01f, -3.74437898e-01f, -5.05224705e-01f, -1.62576661e-01f,
  -4.76052672e-01f, 2.43186489e-01f, 2.42698148e-01f, -8.65097046e-02f, 1.65863827e-01f, 1.20566055e-01f, 2.06939969e-03f, 6.50470927e-02f, 2.40846694e-01f, 1.48851216e-01f,
  3.45021822e-02f, 2.55674630e-01f, -9.50294435e-02f, -1.58528462e-01f, 9.71039087e-02f, 7.46514788e-03f, -2.08201289e-01f, 8.68040547e-02f, 1.04504097e-02f, 4.66291904e-02f,
  -1.81518331e-01f, 1.54795602e-01f, -1.30029559e-01f, 1.83136389e-01f, -6.12349063e-03f, -1.86141491e-01f, -3.93367529e-01f, 7.74845481e-02f, -5.06997444e-02f, 1.78097263e-01f,
  -2.54588760e-02f, -1.98527277e-01f, -2.29327351e-01f, 1.81425482e-01f, 8.54680911e-02f, -2.31082961e-01f, -4.67142612e-02f, -2.05917805e-01f, 1.44440085e-01f, 1.91228062e-01f,
  -1.56879947e-02f, -1.70949727e-01f, 3.26108664e-01f, 2.25134969e-01f, 2.26378709e-01f, -1.93106398e-01f, -3.62378716e-01f, 1.48434088e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.12176931e-01f, 3.57025802e-01f, 2.94737279e-01f, 3.76313291e-02f, -1.40469626e-01f, 1.02082662e-01f, 2.26317465e-01f, -1.25940144e-01f, -2.33847648e-01f, -2.66465217e-01f,
  -9.50141788e-01f, -3.43095392e-01f, -7.56898403e-01f, 6.61118850e-02f, 7.33807832e-02f, 2.09194332e-01f, -4.49479759e-01f, -5.85507691e-01f, 3.34947318e-01f, 8.85593235e-01f,
  5.09332895e-01f, -1.49642333e-01f, -8.58223513e-02f, 2.31082477e-02f, -4.93062526e-01f, -5.69527186e-02f, -8.01396519e-02f, -8.99298191e-02f, 2.85666704e-01f, 6.49765730e-01f,
  -5.38482964e-02f, 2.03985140e-01f, -1.80311054e-01f, -1.70484167e-02f, 7.81777263e-01f, 1.28862754e-01f, -1.60003096e-01f, 3.59585956e-02f, 4.31116253e-01f, 1.86535761e-01f,
  3.67328197e-01f, -1.60655379e-01f, 2.68159240e-01f, 6.61805630e-01f, 2.42563739e-01f, -1.69593636e-02f, 6.30953252e-01f, 3.59391272e-01f, 8.46198797e-01f, -7.56830394e-01f,
  1.00706019e-01f, -8.98890495e-02f, 4.40310568e-01f, 2.04741880e-02f, 8.69816661e-01f, 8.56083989e-01f, -5.31176805e-01f, -3.55311453e-01f, -1.38813689e-01f, -2.07058359e-02f,
  1.46273062e-01f, 3.63979518e-01f, 4.97370064e-01f, 2.61434317e-01f, 5.75921118e-01f, -3.37204263e-02f, 7.61800706e-02f, 1.84186518e-01f, 5.56358516e-01f, 2.29758918e-01f,
  4.88262683e-01f, 2.18840793e-01f, 2.78447032e-01f, 2.09628180e-01f, 6.83784664e-01f, -2.95539141e-01f, -1.25698730e-01f, 2.76538283e-01f, 1.49073273e-01f, -1.46032199e-01f,
  -2.95795709e-01f, 1.73473015e-01f, -4.65017885e-01f, 5.25056601e-01f, -3.89092028e-01f, 7.14373469e-01f, -5.33668362e-02f, -5.62077343e-01f, 2.77126670e-01f, 2.43997499e-01f,
  -2.87243724e-02f, -8.16465616e-02f, -6.63158521e-02f, 5.23764193e-01f, 3.04064900e-01f, 9.44072530e-02f, 1.39421657e-01f, 4.93697017e-01f, 2.25656390e-01f, 2.41432384e-01f,
  -2.44024228e-02f, 2.45980769e-01f, 2.80487686e-01f, 5.42869791e-03f, 4.23795462e-01f, -3.94802839e-01f, 1.89299639e-02f, 3.96557212e-01f, 7.57159770e-01f, 6.64331555e-01f,
  6.44149899e-01f, 7.85401702e-01f, 2.31454387e-01f, -7.45232582e-01f, 7.50526845e-01f, 9.12041515e-02f, 7.37931550e-01f, 4.28238034e-01f, 3.74407798e-01f, -5.29119298e-02f,
  6.73404634e-01f, 7.71271348e-01f, -3.40835541e-01f, -1.41879693e-01f, 6.93219185e-01f, 8.23349297e-01f, -5.70752084e-01f, 3.48057568e-01f, -1.18692748e-01f, 8.99840668e-02f,
  -2.25753170e-02f, 1.74880803e-01f, 6.41219020e-01f, -2.39548720e-02f, 1.31578460e-01f, 1.41616225e-01f, 1.40373945e-01f, 8.98859084e-01f, -4.32257980e-01f, 8.20385635e-01f,
  -2.58476973e-01f, -6.95428073e-01f, -7.90090442e-01f, -9.01906550e-01f, 1.58440739e-01f, 1.62608415e-01f, -1.98199451e-01f, -1.20247260e-01f, -1.49265423e-01f, 4.41746235e-01f,
  4.21529561e-01f, 7.44004130e-01f, 6.26181781e-01f, 2.77406156e-01f, 6.05673611e-01f, 3.59750003e-01f, -8.79662558e-02f, 1.61549568e-01f, -6.14740178e-02f, 2.09532380e-01f,
  -9.96036157e-02f, 5.64959943e-01f, 3.26238871e-01f, 2.09989399e-01f, 5.79443574e-01f, 3.68078142e-01f, 4.11560625e-01f, 6.72115982e-01f, 4.00938928e-01f, 1.13730758e-01f,
  2.71443158e-01f, 3.56792271e-01f, -1.58924267e-01f, 1.94273040e-01f, 2.10101902e-01f, 2.42878094e-01f, 3.80879939e-01f, -6.26664340e-01f, -2.09037766e-01f, 1.81807518e-01f,
  1.07851088e-01f, 3.32231939e-01f, 3.69074136e-01f, 5.50710857e-02f, -4.17587370e-01f, -4.55617905e-01f, 6.57833397e-01f, -2.48980626e-01f, -2.90377885e-01f, 8.53403687e-01f,
  1.16339810e-01f, 9.12154838e-02f, -2.96412498e-01f, 6.21555865e-01f, -8.38893235e-01f, 7.34567968e-03f, 1.14916682e-01f, 2.32693031e-01f, 1.89251557e-01f, -3.27359766e-01f,
  -2.38650978e-01f, -3.71551484e-01f, -1.54960945e-01f, -8.85540545e-01f, -7.96556920e-02f, -9.36566815e-02f, 1.55547068e-01f, 2.96062410e-01f, -2.86329955e-01f, 1.56051427e-01f,
  -3.83034378e-01f, 4.54223663e-01f, -2.38853171e-01f, -2.58707047e-01f, -4.61168021e-01f, 2.12256983e-01f, 5.78142166e-01f, -1.72748081e-02f, 5.12807727e-01f, 1.05586803e+00f,
  3.96293178e-02f, 2.58228749e-01f, -7.41159797e-01f, 3.55662882e-01f, -2.29747877e-01f, -8.86037294e-03f, 3.49140853e-01f, -1.70501918e-02f, 4.62190397e-02f, 7.62199610e-02f,
  9.29488316e-02f, -5.94137728e-01f, -2.34722868e-01f, 5.90436578e-01f, 4.50073890e-02f, 6.38216972e-01f, 3.88571113e-01f, -7.03121603e-01f, 1.56385154e-01f, -1.24114424e-01f,
  7.09577978e-01f, 3.46309751e-01f, 5.31671703e-01f, -1.52968496e-01f, 5.23237824e-01f, -3.24768037e-01f, 7.87078321e-01f, -2.49683410e-01f, -1.78894531e-02f, 4.66976643e-01f,
  9.05543268e-02f, 2.20612496e-01f, -8.63494515e-01f, -1.07187912e-01f, 5.51707864e-01f, 2.50844546e-02f, 1.37349457e-01f, 3.63995761e-01f, 3.26732427e-01f, 4.08497542e-01f,
  -1.21866360e-01f, 2.42144063e-01f, 3.03282082e-01f, -9.97902974e-02f, 3.99289221e-01f, -7.97513902e-01f, 6.22794688e-01f, -2.91334182e-01f, 6.09217703e-01f, 5.60910702e-01f,
  6.74633205e-01f, 7.67063439e-01f, -1.64932251e-01f, 6.05746686e-01f, 3.71568739e-01f, -1.82805043e-02f, 2.70490885e-01f, 7.50727057e-02f, 3.64784271e-01f, 4.27453935e-01f,
  4.40450102e-01f, 2.28516728e-01f, -2.28101954e-01f, 7.73009121e-01f, 5.23493409e-01f, -2.33878776e-01f, 1.03633749e+00f, 4.84248810e-02f, 5.20689130e-01f, 1.46189496e-01f,
  3.12246680e-01f, 5.43863118e-01f, 3.95549834e-01f, 4.55693603e-01f, 4.12895799e-01f, 4.75181550e-01f, -2.42209975e-02f, 2.96776980e-01f, -5.96607029e-01f, -2.51812100e-01f,
  -5.52168727e-01f, 2.39338785e-01f, -7.65416145e-01f, -4.63736326e-01f, -7.69745052e-01f, 3.60884041e-01f, 6.96881473e-01f, -9.05164778e-02f, 3.49415779e-01f, 5.64235687e-01f,
  -1.17742531e-01f, -1.00414261e-01f, 3.60685945e-01f, 5.16252398e-01f, 5.83056867e-01f, -5.61807871e-01f, 7.73252189e-01f, 5.42851463e-02f, -9.79050621e-02f, -1.52880907e-01f,
  -1.02212772e-01f, -2.47715674e-02f, 6.71684802e-01f, 6.94919303e-02f, -9.41360146e-02f, 4.50988233e-01f, -2.17617080e-01f, 5.86295903e-01f, -2.14112923e-02f, 4.36667502e-01f,
  -5.03958404e-01f, 5.40442169e-01f, -5.12213826e-01f, -4.95968491e-01f, -6.22415483e-01f, -4.99412596e-01f, 1.17815413e-01f, 1.25109851e-01f, 8.49131882e-01f, -8.16340074e-02f,
  7.45985746e-01f, 8.73966962e-02f, -4.30148728e-02f, 8.32791984e-01f, -5.30941486e-01f, 1.02150641e-01f, 7.39404142e-01f, 2.02404618e-01f, 3.61312069e-02f, 2.83900388e-02f,
  8.00509602e-02f, -1.89916804e-01f, 6.55035138e-01f, -2.23105058e-01f, 2.09841549e-01f, 2.62137055e-01f, 4.62818921e-01f, 1.74209267e-01f, 4.56723750e-01f, -1.25928238e-01f,
  -2.76123911e-01f, 2.51853645e-01f, -4.11477804e-01f, -3.42573941e-01f, -6.90299809e-01f, -6.68461442e-01f, -5.24309754e-01f, -4.64152008e-01f, -3.34987998e-01f, -4.10513699e-01f,
  -7.11140558e-02f, 7.89846778e-01f, -1.39175490e-01f, 2.01892689e-01f, -2.24274457e-01f, 1.85970783e-01f, -2.01655049e-02f, 1.70717314e-01f, -4.04708087e-01f, 7.85836875e-02f,
  -1.90541252e-01f, 7.00249493e-01f, 7.83197045e-01f, 4.08152819e-01f, 3.03249002e-01f, -1.28770262e-01f, 5.41665792e-01f, 4.27589938e-02f, 1.18563004e-01f, 1.38389125e-01f,
  3.26749951e-01f, 2.66097449e-02f, 1.49926752e-01f, 1.43685356e-01f, -5.25499781e-05f, 1.04262002e-01f, 4.14217323e-01f, 2.02893242e-01f, -6.20745905e-02f, 1.69670522e-01f,
  -2.57832315e-02f, 3.44738066e-01f, 4.73514080e-01f, -5.99081397e-01f, 1.78899243e-01f, 3.38991076e-01f, 6.06557369e-01f, 1.43652827e-01f, 7.11820662e-01f, 6.09115601e-01f,
  -4.80454683e-01f, 1.21303700e-01f, 7.58356452e-01f, -3.05715621e-01f, 6.59974575e-01f, 4.31815237e-02f, 5.49707472e-01f, 2.27189615e-01f, -3.20141435e-01f, 3.46698016e-01f,
  3.88628364e-01f, 3.47937286e-01f, 2.41459951e-01f, 5.95165968e-01f, -1.67661339e-01f, -3.79256457e-01f, 1.87815383e-01f, -9.95382845e-01f, -1.93385154e-01f, 4.64295894e-02f,
  1.27456822e-02f, -3.30743670e-01f, -7.15266168e-01f, 1.02973022e-01f, -3.10157418e-01f, 1.37874782e-01f, -4.66480404e-02f, 2.63379812e-01f, -6.13980114e-01f, 2.24844739e-01f,
  -1.47723228e-01f, -1.89179957e-01f, 5.79846323e-01f, 6.79020107e-01f, -3.92979652e-01f, -2.52563268e-01f, 1.46725684e-01f, 3.11560631e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  9.29756649e-03f, 2.59792566e-01f, 2.69225329e-01f, 3.34272057e-01f, 4.14152116e-01f, 4.27545488e-01f, 2.09074184e-01f, -7.40768854e-03f, 2.44089186e-01f, 1.87814757e-01f,
  2.38891050e-01f, 3.06122571e-01f, 3.35573912e-01f, 4.40125883e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -1.25625283e-01f, 3.23498361e-02f, -1.53047398e-01f, -2.58711744e-02f, -5.05958974e-01f, -1.16298318e-01f, -7.67932609e-02f, 1.12914234e-01f, -1.85506091e-01f, -4.67845529e-01f,
  3.33937943e-01f, 9.28339735e-02f, -5.76568484e-01f, 3.73728782e-01f, -6.56907678e-01f, -3.53052676e-01f, -7.27969170e-01f, 6.02560304e-03f, 5.91964722e-01f, 1.67304769e-01f,
  1.19410045e-01f, 2.08723947e-01f, -1.01429641e+00f, 3.36253822e-01f, -3.11417729e-01f, -3.39884967e-01f, -3.34782936e-02f, -5.58672965e-01f, -2.63436139e-01f, 2.55764157e-01f,
  -7.43395984e-01f, -3.47913116e-01f, 2.81879216e-01f, -2.13532485e-02f, -9.28559154e-02f, -1.42449349e-01f, 3.67350578e-01f, 3.40340644e-01f, 1.34454146e-01f, 8.94103548e-04f,
  3.16996753e-01f, -2.02960238e-01f, 5.56166410e-01f, -3.08150738e-01f, 3.61360490e-01f, -3.93090963e-01f, -3.50446612e-01f, -4.21848893e-01f, 2.48966813e-01f, -7.58038536e-02f,
  4.88363653e-01f, -1.10780060e+00f, 4.10537869e-01f, -2.38460496e-01f, -3.70147027e-04f, -1.33530945e-01f, 4.40153122e-01f, -3.51837277e-01f, -5.15159428e-01f, 8.39574561e-02f,
  -6.72333777e-01f, 5.33407807e-01f, -7.27438569e-01f, 3.45465660e-01f, 2.44526774e-01f, -4.01466876e-01f, 1.78529471e-01f, 4.91687655e-03f, -2.59621125e-02f, -2.37075850e-01f,
  2.20421910e-01f, -3.99910249e-02f, -2.63900161e-01f, 2.61164933e-01f, 4.17786062e-01f, -3.17447871e-01f, 2.54758030e-01f, -4.23974305e-01f, 2.63904959e-01f, 6.22500330e-02f,
  2.45044947e-01f, 3.73786479e-01f, -4.82709706e-01f, -6.34535313e-01f, -3.64683986e-01f, 5.66441827e-02f, -1.78681910e-01f, -5.63144863e-01f, 7.52479017e-01f, -3.97826016e-01f,
  4.55163926e-01f, -2.58175373e-01f, -8.61947596e-01f, -2.81707942e-01f, 2.53872991e-01f, 8.51193741e-02f, -3.76135081e-01f, 2.15750933e-01f, -3.21443200e-01f, -7.81545974e-03f,
  3.34472239e-01f, -2.60710150e-01f, -2.58308142e-01f, 3.69231880e-01f, -1.37203604e-01f, -5.27194858e-01f, 4.46660399e-01f, 5.00081420e-01f, -4.22084779e-01f, -1.09958649e-01f,
  -2.98728973e-01f, 3.25484246e-01f, -1.56046122e-01f, -4.23197150e-01f, -6.96768820e-01f, 5.21183193e-01f, -9.80850682e-02f, -8.29683840e-01f, 1.14902586e-01f, -8.63591954e-02f,
  -4.94307518e-01f, 5.05050778e-01f, 2.06154570e-01f, -7.30563402e-01f, -1.59202233e-01f, 8.91047269e-02f, 2.94990450e-01f, -7.57819951e-01f, 1.82390749e-01f, 3.37991893e-01f,
  5.26498795e-01f, -1.62161946e-01f, 3.44768137e-01f, 2.98561811e-01f, 3.63803893e-01f, 2.82519329e-02f, 3.57873887e-01f, -3.23648781e-01f, -1.88664913e-01f, -3.74375641e-01f,
  -5.32412827e-01f, 5.51790178e-01f, 8.86730492e-01f, 5.02808928e-01f, -6.08356416e-01f, -2.41803050e-01f, -7.37883329e-01f, 4.71847028e-01f, 1.47955149e-01f, 4.94244635e-01f,
  -4.46006190e-03f, 5.24677396e-01f, -3.50946307e-01f, -6.64324388e-02f, 7.80352876e-02f, -5.51569998e-01f, -5.28823912e-01f, -7.36545205e-01f, 8.13474413e-03f, -9.11631137e-02f,
  2.73931891e-01f, 2.42089793e-01f, 1.47771612e-02f, 7.80842442e-04f, 4.83574905e-02f, 1.41415820e-02f, 1.72373593e-01f, -2.19814435e-01f, 2.80164480e-01f, 4.36019778e-01f,
  -4.37049121e-01f, -1.15643524e-01f, 5.61291635e-01f, 6.85452104e-01f, 1.75516412e-01f, -3.90062630e-01f, 4.67539370e-01f, -4.80559506e-02f, 2.20449746e-01f, 1.69577390e-01f,
  -3.65591645e-01f, -1.14440396e-01f, 2.01892957e-01f, 3.25386286e-01f, -9.67239738e-01f, 2.40858700e-02f, -8.84594977e-01f, 2.60530710e-01f, 4.34090346e-01f, 2.79307872e-01f,
  -2.34780356e-01f, -2.38452643e-01f, 5.45553910e-03f, 9.28595886e-02f, -6.61054999e-02f, 1.96668189e-02f, -3.89857799e-01f, -1.12738028e-01f, -9.69936848e-02f, -6.19468540e-02f,
  1.89859644e-01f, -2.62322038e-01f, -6.90803379e-02f, -2.78888851e-01f, 2.48197660e-01f, -5.34078300e-01f, 4.68723476e-01f, 4.52527612e-01f, 1.22764029e-01f, 3.15389559e-02f,
  -5.66547990e-01f, -9.00712669e-01f, 4.10058141e-01f, 1.39800608e-01f, 3.08753461e-01f, -6.91754580e-01f, -9.52548206e-01f, -3.24464262e-01f, -1.31776437e-01f, 4.72992659e-01f,
  -7.56245479e-02f, 2.70990897e-02f, 4.44295436e-01f, -6.48763359e-01f, -1.30478755e-01f, -3.28024238e-01f, -1.30777275e-02f, -1.41171394e-02f, 3.47438902e-02f, 1.90059900e-01f,
  4.55228165e-02f, -4.84309345e-01f, -1.50603130e-01f, 5.17495573e-01f, 2.13751011e-02f, 4.74541366e-01f, -6.48049042e-02f, -3.56886566e-01f, -3.20648104e-01f, -4.88236934e-01f,
  -1.18508495e-01f, -4.35349166e-01f, -3.77641797e-01f, -1.75911888e-01f, -6.15510046e-01f, 1.30581468e-01f, -3.49102765e-01f, -6.91553950e-01f, -4.98432219e-01f, 6.45574987e-01f,
  2.59859681e-01f, -2.62000322e-01f, 3.95658940e-01f, -4.28761572e-01f, 2.91641563e-01f, -5.18395938e-03f, -3.59974712e-01f, -9.29240584e-02f, -2.51182914e-01f, -8.38457942e-02f,
  7.51626566e-02f, 8.44444036e-02f, -1.03455745e-01f, -4.20157462e-02f, -3.54059964e-01f, 3.54011089e-01f, 3.27415586e-01f, -1.79673582e-02f, 2.40853339e-01f, 5.46507597e-01f,
  5.17203569e-01f, -3.63151640e-01f, 5.50090149e-02f, 5.47055667e-03f, -2.02271089e-01f, 1.83621988e-01f, -4.30663794e-01f, -6.75819039e-01f, 2.55081177e-01f, -4.64043766e-01f,
  1.55178174e-01f, -4.78520930e-01f, 1.31503761e-01f, -5.96166253e-01f, 4.76497144e-01f, 1.87789649e-01f, -4.33954179e-01f, 4.38670963e-01f, -4.42704201e-01f, 1.20350502e-01f,
  2.18296930e-01f, 1.26628086e-01f, -8.68803710e-02f, -2.21821845e-01f, 5.15835248e-02f, 3.44969690e-01f, -1.22577973e-01f, 5.81426978e-01f, -5.66220164e-01f, -2.00231373e-01f,
  5.29802263e-01f, 5.33808529e-01f, 3.12698454e-01f, -2.34869376e-01f, 3.04172546e-01f, 4.03942049e-01f, 4.20061409e-01f, 8.66853818e-02f, -8.16356301e-01f, 3.19882512e-01f,
  -1.03971624e+00f, -3.99387568e-01f, -5.50177217e-01f, -6.15533948e-01f, 3.50261807e-01f, 3.26128751e-01f, 1.16199888e-02f, -5.84699035e-01f, 2.16882303e-01f, -2.92522490e-01f,
  4.08970825e-02f, 2.11985081e-01f, -2.09173001e-02f, 4.26481485e-01f, -2.50141267e-02f, -2.71888107e-01f, -1.06582902e-01f, -2.00529285e-02f, 2.84237452e-02f, -2.80072868e-01f,
  -1.49454564e-01f, 6.81429625e-01f, -1.46655485e-01f, -5.20970821e-01f, -5.22027194e-01f, 3.69869083e-01f, 2.25863948e-01f, -5.48235595e-01f, -5.96958935e-01f, -3.53573114e-01f,
  6.30437016e-01f, -8.38253438e-01f, -5.67428052e-01f, 2.13328436e-01f, -7.04046488e-01f, -6.24914408e-01f, 3.38580370e-01f, 2.35218957e-01f, -9.01565924e-02f, 2.07030609e-01f,
  4.50289249e-02f, 9.13824022e-01f, -3.62998605e-01f, -3.95058751e-01f, 8.61840248e-02f, 5.97269274e-02f, 2.08597660e-01f, -1.20049104e-01f, 1.47243634e-01f, -2.28731539e-02f,
  -1.31331801e-01f, -5.10691404e-01f, -2.46500954e-01f, -3.45065862e-01f, -6.50330126e-01f, -5.18358946e-01f, -3.83218795e-01f, 4.64469403e-01f, 1.67311594e-01f, 4.11124170e-01f,
  -6.60814047e-01f, -4.94131058e-01f, -2.29180679e-01f, -7.80094147e-01f, 5.76903462e-01f, 5.26368201e-01f, -1.36236787e-01f, 2.59814188e-02f, -4.62732255e-01f, 4.38143432e-01f,
  5.84868550e-01f, -5.97151577e-01f, -4.65138853e-01f, 2.08349392e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  4.15837439e-03f, -7.32475743e-02f, -1.30134001e-02f, -3.40597034e-02f, 2.52483845e-01f, -2.04638869e-01f, -1.89318895e-01f, -5.69235608e-02f, 6.73087835e-02f, -8.87596309e-02f,
  4.78566177e-02f, 1.28973126e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    