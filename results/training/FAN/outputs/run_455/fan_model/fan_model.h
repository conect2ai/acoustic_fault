/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.36926162e-01f, -2.60944933e-01f, 2.89335996e-01f, -6.35016188e-02f, 1.66632280e-01f, 7.70145357e-02f, 1.42231002e-01f, 6.75691962e-02f, -1.45405516e-01f, -9.97148752e-02f,
  1.65868714e-01f, -1.74017176e-02f, -2.92221718e-02f, -1.17478982e-01f, 7.17792511e-02f, -2.45179757e-01f, -9.97445062e-02f, 1.68159455e-01f, -2.00708166e-01f, 9.25807282e-02f,
  -4.45056111e-02f, -5.77582233e-02f, 1.91952750e-01f, 3.45048346e-02f, 2.30902642e-01f, 1.21590808e-01f, 8.52344558e-02f, 7.14069530e-02f, 1.93042189e-01f, 7.27844797e-03f,
  7.15344325e-02f, 1.64004639e-01f, 1.45601541e-01f, 4.62056287e-02f, 1.01427011e-01f, -3.35633126e-03f, 8.80735219e-02f, 5.45685403e-02f, -4.45063114e-02f, -6.11231253e-02f,
  -1.20445162e-01f, -2.28120461e-02f, -3.97634506e-03f, 1.73543785e-02f, 3.35080922e-02f, -1.34128034e-02f, -7.01530278e-02f, -1.01216510e-01f, -3.51663828e-02f, 1.94350351e-02f,
  -8.60955790e-02f, -4.94788494e-03f, 2.58762334e-02f, -1.54046249e-02f, 6.33565634e-02f, -1.05746873e-01f, 8.76049418e-03f, 1.31321326e-01f, 1.56592242e-02f, 4.11949642e-02f,
  8.77095237e-02f, -5.74161187e-02f, 3.82691100e-02f, 5.79904914e-02f, -3.87807265e-02f, 6.27677664e-02f, -3.08035314e-02f, 7.68477516e-03f, -8.75450745e-02f, -5.85606433e-02f,
  4.42579016e-02f, 1.02189500e-02f, -4.75587174e-02f, -2.74275281e-02f, -2.84429378e-04f, -2.13673916e-02f, -2.62651071e-02f, 4.88996059e-02f, -3.68998088e-02f, -1.09710370e-03f,
  -9.17838961e-02f, -5.19002117e-02f, 6.77091926e-02f, 4.11686786e-02f, -7.39477426e-02f, 2.05129292e-02f, -1.35885563e-03f, 4.45105098e-02f, 9.29152593e-03f, -1.09996172e-02f,
  2.67754085e-02f, 1.99424937e-01f, 3.97585966e-02f, 9.71596837e-02f, -8.34279209e-02f, -3.69277559e-02f, 2.85665356e-02f, -6.61937222e-02f, -3.07812495e-03f, 9.80698615e-02f,
  1.56120449e-01f, 8.57559443e-02f, 7.10906684e-02f, -4.55995686e-02f, -1.09867066e-01f, -3.04701738e-02f, 1.81593243e-02f, 3.14169750e-02f, -1.73013043e-02f, 6.40180036e-02f,
  1.22915596e-01f, 1.48691222e-01f, -1.16968229e-02f, -1.19220782e-02f, -1.85863730e-02f, 6.09393381e-02f, 8.93948004e-02f, 6.22536503e-02f, -7.85676911e-02f, -2.56063100e-02f,
  1.05973721e-01f, -8.06888714e-02f, -1.08854137e-01f, 1.65633589e-01f, 1.43922508e-01f, 4.28205281e-01f, 2.76798338e-01f, 2.33901232e-01f, 1.72332987e-01f, 9.59275588e-02f,
  1.35046974e-01f, -1.49741039e-01f, -1.94667622e-01f, 3.10374528e-01f, 1.60109252e-01f, 1.16842603e-02f, 2.72672266e-01f, 1.58873290e-01f, 6.45903051e-02f, 2.08696220e-02f,
  1.23297144e-02f, 2.69325346e-01f, 3.24611478e-02f, 8.38184506e-02f, 1.82630882e-01f, -6.89712465e-02f, -1.35359585e-01f, -5.10301888e-02f, 1.19802758e-01f, 2.44574379e-02f,
  2.14677036e-01f, 3.36530730e-02f, 6.03724904e-02f, -3.72937992e-02f, 4.76856083e-02f, -8.03828761e-02f, -4.81396727e-02f, -5.94601966e-02f, -3.24982740e-02f, 5.29502593e-02f,
  -9.08509493e-02f, 1.86546072e-02f, 3.23508903e-02f, -2.00256426e-02f, -3.48901562e-02f, 2.36911699e-02f, -1.17827402e-02f, -6.62201410e-03f, 3.86620872e-02f, 2.99458485e-02f,
  2.12272946e-02f, 5.36423251e-02f, -1.25506828e-02f, -5.50287962e-02f, 2.40260474e-02f, 5.33450767e-03f, -2.81291846e-02f, -2.26428881e-02f, 7.80822290e-03f, 1.10183936e-02f,
  2.24458389e-02f, -6.87167421e-02f, -3.25527899e-02f, 4.48551998e-02f, 8.68154876e-03f, 7.28060817e-03f, 3.46769132e-02f, -9.35738459e-02f, -3.54013965e-03f, -1.80264395e-02f,
  9.10979956e-02f, 4.95475978e-02f, 1.71369035e-02f, 4.31037061e-02f, -2.51614917e-02f, 6.33223057e-02f, -7.71129727e-02f, 3.20838764e-02f, 1.21870581e-02f, 7.78767690e-02f,
  -2.19272356e-02f, -4.53890214e-04f, 5.24023129e-03f, -2.42939256e-02f, 1.11410599e-02f, 1.62255447e-02f, -1.94404982e-02f, 1.81518532e-02f, 1.32541480e-02f, -6.16405997e-03f,
  -4.10606600e-02f, -2.78553903e-01f, 5.01918569e-02f, 5.49526997e-02f, -7.82046169e-02f, 7.73423761e-02f, 1.06911917e-04f, 1.41251996e-01f, -4.45633978e-02f, 1.05187185e-02f,
  2.71754786e-02f, 1.36613483e-02f, -2.62124557e-02f, -1.63592827e-02f, -4.42056097e-02f, 8.98027271e-02f, -9.25539061e-02f, -1.04290359e-02f, -8.21831729e-03f, -1.83379743e-02f,
  -8.22726190e-02f, 1.05052916e-02f, -2.57418510e-02f, 8.60337988e-02f, -2.00315192e-02f, -2.81024035e-02f, 1.06792711e-02f, -2.22725957e-03f, -1.02499850e-01f, -1.40811354e-02f,
  7.82184128e-04f, 5.96312359e-02f, -2.99960345e-01f, 3.25336084e-02f, 2.04825297e-01f, -1.60184056e-02f, -2.28845477e-01f, 2.91484088e-01f, -7.01872408e-02f, 1.02146931e-01f,
  8.70996937e-02f, -4.07422222e-02f, -1.89507693e-01f, 4.04975533e-01f, -2.54927073e-02f, -2.35039651e-01f, 5.45251966e-02f, -1.03692487e-02f, 2.58100424e-02f, 8.44409764e-02f,
  -5.27059436e-02f, 2.83773333e-01f, -3.78002040e-02f, 3.43054533e-01f, 9.66344625e-02f, -4.94014286e-02f, 2.42434010e-01f, -8.21310282e-02f, 2.20645368e-01f, -1.11079253e-02f,
  -8.63801315e-03f, -1.80695616e-02f, -3.11916191e-02f, -2.64327656e-02f, 7.07443655e-02f, -6.49961457e-02f, -6.36314973e-02f, -6.48816004e-02f, -2.28439812e-02f, -4.73636650e-02f,
  -4.05785888e-02f, 1.83522627e-02f, 7.22603649e-02f, -5.61745279e-02f, 2.16751602e-02f, 3.27282473e-02f, 2.71254294e-02f, 1.18429102e-02f, 1.14153849e-03f, -6.08321428e-02f,
  -1.35345459e-01f, -1.09434299e-01f, -3.40040252e-02f, -2.84018721e-02f, -1.72034770e-01f, -4.38666940e-02f, -1.91406701e-02f, -7.86399394e-02f, 2.17737239e-02f, -1.26963304e-02f,
  -2.41906848e-03f, -1.14502106e-02f, -4.14157379e-03f, 9.51533299e-03f, 4.01684009e-02f, 7.55730122e-02f, 2.18512565e-02f, -1.85177848e-02f, -9.82176140e-03f, -1.35727208e-02f,
  8.90057907e-02f, -2.63512526e-02f, 2.26468630e-02f, -5.96757606e-02f, -1.79868285e-02f, -1.01637281e-02f, -6.40811697e-02f, -4.45790309e-03f, -4.81020063e-02f, 2.07458232e-02f,
  -3.79022360e-02f, -7.32374936e-02f, 2.04012282e-02f, 1.19049279e-02f, 7.02569913e-03f, -5.98174967e-02f, -2.20365133e-02f, -6.49330840e-02f, -3.59208733e-02f, -4.74301614e-02f,
  2.59897828e-01f, 2.74985284e-01f, 6.93783760e-02f, 4.05547433e-02f, 9.10014436e-02f, 6.88672289e-02f, 3.38726565e-02f, 2.06893478e-02f, -1.95080172e-02f, 2.58803293e-02f,
  1.88141852e-03f, 8.42376277e-02f, 2.09785961e-02f, -1.10010849e-03f, -4.52763401e-02f, 7.48222088e-03f, 1.26413051e-02f, 6.35603368e-02f, 2.59350967e-02f, 6.50043711e-02f,
  5.92326075e-02f, 1.29796425e-03f, -7.69191934e-03f, 7.21122101e-02f, 3.51263173e-02f, -2.04747580e-02f, 3.06791272e-02f, -6.89771175e-02f, -1.11632207e-02f, 2.08246764e-02f,
  -9.01311487e-02f, 2.98087478e-01f, 1.78223506e-01f, 4.46779281e-02f, 1.11411568e-02f, 2.34533865e-02f, -2.65576959e-01f, 8.67189020e-02f, -1.40682951e-01f, 5.07723652e-02f,
  -2.66152341e-02f, -5.39271124e-02f, -9.71063972e-02f, -3.15177321e-01f, -2.14930326e-01f, -1.59385636e-01f, 2.23410595e-02f, 1.51668191e-01f, 4.88670915e-02f, 1.27675071e-01f,
  1.44738573e-04f, -1.21385284e-01f, -1.06154807e-01f, 4.22226526e-02f, 2.37408895e-02f, -6.76032715e-03f, -4.69762273e-02f, -6.32536598e-03f, -1.27348945e-01f, -1.68520398e-02f,
  -7.65995756e-02f, -3.44303548e-02f, 2.14169845e-02f, -1.47793191e-02f, 1.67761609e-01f, 7.02698305e-02f, 9.42451879e-02f, -3.48015316e-02f, -4.34033759e-02f, -8.46306328e-03f,
  2.50339564e-02f, 1.16756763e-02f, 3.72303389e-02f, -9.30900946e-02f, -1.26825785e-02f, -1.85947865e-02f, -2.62126792e-02f, 3.05981115e-02f, -4.70591970e-02f, -5.27435029e-03f,
  1.05125485e-02f, 1.21374376e-01f, 7.49787241e-02f, 1.41557679e-03f, -1.47360161e-01f, 7.31629133e-02f, 7.34262727e-03f, 4.63542081e-02f, 8.48427881e-03f, 5.84770404e-02f,
  -7.64735192e-02f, -5.17795198e-02f, 2.51819324e-02f, -4.27071704e-03f, -3.30670588e-02f, -2.57191360e-02f, -4.65114787e-02f, -7.80858248e-02f, 3.14445375e-03f, 6.63650874e-03f,
  -1.00245319e-01f, 1.01558315e-02f, 1.63112521e-01f, 3.05979587e-02f, -5.32791726e-02f, -2.21352652e-02f, -6.71168715e-02f, 1.74172390e-02f, 3.40633430e-02f, 4.03355062e-02f,
  -8.60913917e-02f, -2.54313536e-02f, -2.02950872e-02f, 4.93814144e-03f, 6.15257062e-02f, 1.40123796e-02f, -1.64597631e-02f, 5.32311946e-03f, -2.46235020e-02f, 4.48783673e-02f,
  8.44028220e-02f, 2.53113210e-01f, -2.30568815e-02f, 1.49016352e-02f, 3.03121135e-02f, 1.36349961e-01f, 2.37819236e-02f, -3.06905620e-02f, -2.13614199e-02f, -6.24334179e-02f,
  1.38991877e-01f, 3.46513465e-02f, 6.98358417e-02f, 1.68784019e-02f, -4.74754907e-02f, 4.31257337e-02f, 7.74087757e-02f, 4.66959216e-02f, 1.00725777e-02f, -7.99890980e-03f,
  -6.77374250e-04f, -6.28354177e-02f, -7.77188838e-02f, 2.35901680e-02f, 4.38569151e-02f, 4.31410223e-02f, 8.96255672e-02f, -6.44043041e-03f, 6.83638975e-02f, -4.23344737e-03f,
  4.22980756e-01f, -1.50774285e-01f, -2.51778662e-01f, 8.37986544e-02f, 3.37627083e-01f, -3.10324579e-01f, -1.99443221e-01f, 1.64980531e-01f, 4.64629903e-02f, -1.18395664e-01f,
  1.36537373e-01f, -1.64367706e-01f, 1.37352245e-02f, -1.81852981e-01f, 5.07379696e-02f, -1.78215623e-01f, -1.55921858e-02f, -2.94765402e-02f, 3.60323153e-02f, -3.58735807e-02f,
  4.51605953e-02f, 1.03562780e-01f, -2.25589097e-01f, 1.35098055e-01f, 7.78611191e-03f, 8.03791210e-02f, 1.02595963e-01f, 3.62834819e-02f, 3.87495309e-02f, 9.43420455e-03f,
  -9.14673284e-02f, 4.88903001e-02f, 2.53335182e-02f, -1.12860717e-01f, -1.04324771e-02f, 2.30344571e-02f, -9.90940928e-02f, -6.15779534e-02f, -2.10923906e-02f, 5.23171900e-03f,
  -7.30855763e-02f, 8.55524093e-02f, 1.33905211e-03f, -1.26874587e-02f, 8.20516348e-02f, 3.71943079e-02f, 6.27554357e-02f, -1.01143621e-01f, 4.09186399e-03f, -3.79674025e-02f,
  -2.45864559e-02f, 4.88771982e-02f, 3.50798070e-02f, 2.31852531e-02f, 4.25302386e-02f, 2.75518391e-02f, -1.66807711e-01f, -9.46833566e-02f, -6.61836341e-02f, 1.52922301e-02f,
  6.17705248e-02f, -3.05376146e-02f, -2.73154750e-02f, 8.54416937e-02f, -2.66052373e-02f, 5.21578304e-02f, -1.29952868e-02f, 1.58862248e-02f, -1.72320660e-02f, 4.27777544e-02f,
  9.79254115e-03f, 8.02391320e-02f, 6.65300116e-02f, -5.93173578e-02f, -4.56904620e-02f, 6.42854869e-02f, -6.14208318e-02f, 8.67422484e-03f, -1.23914964e-02f, -1.22364415e-02f,
  3.53031754e-02f, 1.12781590e-02f, -1.80344880e-02f, 4.44762483e-02f, 4.74361964e-02f, 1.97960455e-02f, 2.67249122e-02f, -2.46835575e-02f, -2.72693615e-02f, 2.61441469e-02f,
  -1.23299822e-01f, -1.40802890e-01f, -1.66711453e-02f, 1.30156502e-01f, -5.40946424e-02f, -1.31948106e-02f, -6.52858689e-02f, 2.91505828e-02f, -1.41776213e-02f, -3.82935330e-02f,
  2.36602221e-02f, -1.69660561e-02f, 1.90069084e-04f, 2.81697158e-02f, 2.40323376e-02f, -3.81292403e-02f, -8.88998508e-02f, 1.76501200e-02f, -1.51580945e-02f, 3.88104618e-02f,
  2.53328420e-02f, 1.53426984e-02f, 2.17790827e-02f, -3.81530486e-02f, 1.61541700e-02f, 1.84067816e-03f, 9.12732333e-02f, 5.02577499e-02f, 2.16296185e-02f, -3.17832604e-02f,
  -6.00517094e-02f, 3.16119134e-01f, -9.19803381e-02f, 2.28301231e-02f, 4.54855636e-02f, -2.11336449e-01f, -4.53485176e-02f, 1.04072951e-02f, 4.69846278e-02f, 1.69457003e-01f,
  -1.57709619e-05f, 4.28210907e-02f, -1.68459848e-01f, -6.96519576e-03f, -5.34036398e-01f, -1.18560955e-01f, -9.30847973e-02f, 7.94332400e-02f, 6.82873800e-02f, 6.36837855e-02f,
  6.36022091e-02f, -6.18322529e-02f, -3.28728467e-01f, 8.11125785e-02f, 3.04387342e-02f, 6.10782094e-02f, -7.43390024e-02f, 3.42770182e-02f, -9.65409633e-03f, -1.51876444e-02f,
  -1.74029738e-01f, 9.92883146e-02f, 3.92963737e-02f, 2.27346905e-02f, -8.94687995e-02f, -4.15626913e-02f, 1.83314942e-02f, -6.89570233e-02f, -3.89095396e-02f, 2.18019783e-02f,
  -4.99679102e-03f, -8.74719024e-03f, 7.46708363e-03f, 1.75089817e-02f, 1.64324138e-02f, -3.75456810e-02f, -3.90419550e-03f, -5.77317253e-02f, 3.14679667e-02f, -6.89949691e-02f,
  -5.60684688e-02f, -4.47109677e-02f, 5.81283756e-02f, 5.42050526e-02f, -1.44067183e-02f, -4.89347521e-03f, -2.89222728e-02f, -1.85078029e-02f, 3.34889665e-02f, 3.76972184e-02f,
  8.97476077e-02f, 3.52393952e-03f, -4.32442222e-03f, -5.36383502e-02f, 7.56038260e-03f, 4.80406657e-02f, -6.74565602e-03f, -4.11711931e-02f, 8.83687288e-02f, -3.13030481e-02f,
  1.68595687e-02f, -1.02835894e-02f, -1.94062234e-03f, -6.17207922e-02f, 6.71751127e-02f, 6.90431194e-03f, 2.43405104e-02f, 4.98631485e-02f, 6.50324225e-02f, -3.83024663e-02f,
  -2.22808518e-03f, 1.07414819e-01f, -2.27291659e-02f, -4.02125567e-02f, -2.58939359e-02f, -3.53534482e-02f, -2.36596670e-02f, -1.47389825e-02f, -1.51423197e-02f, 3.73575538e-02f,
  1.05758540e-01f, 1.31173134e-01f, -7.55417440e-03f, -9.29174945e-03f, 4.40490395e-02f, -4.02354226e-02f, -3.32509838e-02f, 2.48253364e-02f, 1.65949240e-02f, 7.99093302e-03f,
  8.55442956e-02f, -8.99562612e-03f, -2.19107815e-03f, 3.25590968e-02f, -1.35738002e-02f, -3.60312238e-02f, -3.26716923e-03f, 9.04067606e-02f, 5.00565507e-02f, 2.71335971e-02f,
  5.95145300e-03f, 2.46350151e-02f, 1.11711416e-02f, -2.13935990e-02f, 2.72696037e-02f, -5.29573997e-03f, 4.29189727e-02f, 3.12056076e-02f, -1.80572420e-02f, 1.58927252e-03f,
  3.01275730e-01f, -8.30505639e-02f, -1.03868291e-01f, 1.78286925e-01f, 7.93289989e-02f, 2.21053272e-01f, 2.13543564e-01f, -1.67969823e-01f, -7.48180300e-02f, -5.78996912e-02f,
  1.78204447e-01f, -6.92381337e-02f, -2.00501665e-01f, 2.24494234e-01f, 2.91178823e-01f, -1.89731479e-01f, 4.00277644e-01f, 8.79657045e-02f, -1.24274157e-01f, 1.39747351e-01f,
  9.90415812e-02f, 1.47684678e-01f, 2.06669532e-02f, -6.32872880e-02f, 5.18980213e-02f, -1.33430853e-01f, 1.23379759e-01f, -1.75137624e-01f, 2.49673814e-01f, 4.14647982e-02f,
  -1.55493282e-02f, -6.56840280e-02f, -5.37267653e-03f, -6.05932362e-02f, 7.35127404e-02f, 4.16576229e-02f, 2.24015601e-02f, -6.14267625e-02f, 2.20716875e-02f, -2.69540877e-04f,
  1.47373052e-02f, -1.45323025e-02f, -8.86631943e-03f, -6.10932931e-02f, 3.39302644e-02f, -6.41840845e-02f, 1.08267237e-02f, 4.61004451e-02f, -3.73283513e-02f, -3.82357128e-02f,
  -7.10165827e-03f, 6.62330445e-03f, 1.12734154e-01f, 1.50351916e-02f, -2.67810542e-02f, 5.18797748e-02f, 1.46918278e-03f, 9.45990253e-03f, -1.43626565e-03f, -7.73837091e-03f,
  2.63019297e-02f, -5.15285172e-02f, 2.09966972e-02f, -9.18337703e-02f, 1.82876457e-02f, 1.48831261e-02f, 1.02313794e-02f, 2.13364279e-03f, 3.36348712e-02f, -2.51108389e-02f,
  1.13990698e-02f, -5.08186668e-02f, -7.08760545e-02f, 2.29682904e-02f, 9.11008269e-02f, -1.02620935e-02f, 5.81754968e-02f, -3.60062234e-02f, 7.12293852e-03f, 2.85255089e-02f,
  1.22214956e-02f, 3.06611396e-02f, -3.72740105e-02f, 3.69085260e-02f, 2.34389491e-02f, -5.22258021e-02f, 2.44914312e-02f, -1.41792698e-02f, -2.59133615e-03f, 2.94486117e-02f,
  1.60456643e-01f, 1.19099200e-01f, -1.00721426e-01f, -1.77953895e-02f, 5.43371215e-03f, 4.00666445e-02f, -8.72287259e-04f, -2.23276131e-02f, -4.00657021e-03f, -5.90801239e-02f,
  3.39516290e-02f, -5.27949817e-02f, 8.13408494e-02f, 3.30236107e-02f, 4.85949740e-02f, 5.57681210e-02f, 8.08405206e-02f, -1.78027991e-02f, 1.09963194e-01f, 5.59275821e-02f,
  4.30044010e-02f, 7.05476105e-03f, -6.24506455e-03f, -8.19720444e-04f, 8.28941241e-02f, -1.27199301e-02f, -6.62000403e-02f, -1.19722215e-02f, 5.54867424e-02f, -3.96214798e-02f,
  -3.05842578e-01f, -2.48870268e-01f, -3.29319015e-02f, -1.66473001e-01f, 1.51435152e-01f, -7.05472678e-02f, -1.06207393e-01f, -4.96390499e-02f, 1.01112098e-01f, -1.74746707e-01f,
  1.56360179e-01f, -6.23661801e-02f, 2.05271086e-03f, -1.12080975e-02f, 1.05284818e-01f, 1.24203078e-02f, -1.74503610e-01f, -1.62750721e-01f, 8.09397995e-02f, -1.42704144e-01f,
  -2.76690014e-02f, 6.81412891e-02f, 5.62617742e-02f, -2.01214291e-02f, -1.65133271e-02f, -1.02164298e-01f, 2.33216975e-02f, -3.25926840e-02f, -9.73543036e-04f, 1.09744594e-01f,
  -5.72497845e-02f, 8.04181956e-03f, 1.22299977e-01f, 4.40744720e-02f, -4.46799174e-02f, -1.73621289e-02f, 1.65416356e-02f, 6.29551932e-02f, 7.35683888e-02f, -7.83166811e-02f,
  -7.66620189e-02f, -3.87315638e-02f, 7.96373412e-02f, 1.25447601e-01f, -6.56809881e-02f, -1.36404894e-02f, 6.15480095e-02f, 6.50651380e-02f, 2.56805364e-02f, -5.87662398e-05f,
  6.27802312e-02f, 3.25595178e-02f, -7.77143091e-02f, -7.59846419e-02f, -4.21052659e-03f, -9.11283866e-02f, -3.79814394e-02f, 1.74232982e-02f, -5.07544801e-02f, -3.43598872e-02f,
  -5.24396561e-02f, 1.70111936e-02f, 5.04405461e-02f, -3.49802081e-03f, -2.72178892e-02f, 1.51728066e-02f, -3.77523457e-03f, 3.33622880e-02f, -1.51620042e-02f, -4.42179553e-02f,
  -3.70036140e-02f, -9.24087688e-02f, 2.21212674e-03f, -3.24068367e-02f, 4.00405750e-02f, -4.53640223e-02f, -3.22442725e-02f, -5.88559993e-02f, 1.26168169e-02f, 5.86003289e-02f,
  -1.26953885e-01f, -1.11612700e-01f, -1.01775490e-01f, 7.46428873e-03f, -5.92156537e-02f, 3.53822038e-02f, -2.71119680e-02f, -2.37537809e-02f, 3.36786099e-02f, 3.54342237e-02f,
  -3.83471340e-01f, -5.32456279e-01f, 9.33685750e-02f, -4.06588987e-02f, -2.40735114e-02f, 2.90736817e-02f, 7.62005076e-02f, -4.78519425e-02f, -3.93851660e-03f, 1.56657621e-02f,
  3.48247914e-03f, -4.28671949e-03f, -5.99750094e-02f, -2.22392809e-02f, 9.19765607e-02f, 1.64699368e-02f, -8.12816471e-02f, -7.04564005e-02f, -7.58167803e-02f, -1.11419678e-01f,
  -6.33546039e-02f, -8.06078389e-02f, 2.49404944e-02f, 3.34203579e-02f, -5.68050258e-02f, 4.40646149e-03f, -7.06841126e-02f, 1.00874528e-02f, -5.93800768e-02f, 2.67210678e-04f,
  5.79874992e-01f, -2.71193355e-01f, 6.86852336e-02f, 3.71910930e-02f, 4.11215782e-01f, 1.11674808e-01f, 2.00858504e-01f, 9.36600566e-02f, 1.90484419e-01f, -1.83728442e-01f,
  1.11002944e-01f, -1.30055338e-01f, -1.22539282e-01f, -1.14769824e-01f, 2.78345615e-01f, -3.48114371e-01f, 1.34670675e-01f, -1.00683637e-01f, -6.31335378e-02f, -2.03683525e-02f,
  2.71970704e-02f, 6.63464591e-02f, -5.80358990e-02f, -5.46875037e-02f, 5.53209558e-02f, -4.63074818e-02f, 1.17575876e-01f, -4.77120318e-02f, -3.63515429e-02f, 7.06409290e-02f,
  -6.06912887e-03f, -1.45904869e-01f, 1.26932375e-02f, -1.04211019e-02f, 1.50699422e-01f, 1.16650343e-01f, 2.78168637e-02f, -2.14230977e-02f, 4.30867709e-02f, -7.61834756e-02f,
  -2.12008003e-02f, -2.23447792e-02f, 2.81147957e-02f, 1.67434961e-02f, 6.87002987e-02f, 1.55246006e-02f, -4.20342982e-02f, 7.23728538e-02f, -8.49825293e-02f, -2.33886875e-02f,
  -3.52839157e-02f, -9.15120705e-04f, 4.50393297e-02f, -7.31915534e-02f, -2.45051626e-02f, 2.48995554e-02f, -2.18941439e-02f, -4.57979403e-02f, -1.01268748e-02f, 6.80460110e-02f,
  1.30296452e-02f, -1.37265380e-02f, -2.29426194e-02f, 3.52704041e-02f, -2.10927594e-02f, 3.27249430e-02f, -6.20575622e-02f, -2.71808617e-02f, -6.78072975e-04f, -1.81603655e-02f,
  1.59673276e-03f, -8.24807584e-03f, 4.98466613e-03f, 4.20903862e-02f, 4.53551710e-02f, 1.28695779e-02f, -4.81528528e-02f, -1.63074844e-02f, 1.04268357e-01f, 3.40136401e-02f,
  3.84933650e-02f, 6.18037209e-02f, -2.89337672e-02f, 2.91103385e-02f, 5.86991534e-02f, -2.55552456e-02f, -1.84759591e-02f, -2.83342227e-03f, -1.38127906e-02f, 1.11175872e-01f,
  -4.72416393e-02f, 2.74045789e-03f, -6.07448630e-02f, -3.75403464e-02f, -1.22270122e-01f, 2.39561722e-02f, -2.23919600e-02f, 5.13405018e-02f, -5.96714355e-02f, 5.43769225e-02f,
  7.41975307e-02f, 8.39320361e-04f, 5.39512420e-03f, 1.96264274e-02f, 1.34693207e-02f, -2.52682786e-03f, -4.67798300e-02f, -3.82111147e-02f, 1.35015011e-01f, -3.43736634e-02f,
  3.96920517e-02f, 5.57730300e-03f, -1.59735028e-02f, 5.74238077e-02f, 3.44180688e-02f, 4.96484451e-02f, 4.26386148e-02f, -5.27750887e-03f, 7.04982802e-02f, -5.36482073e-02f,
  6.31530106e-01f, -1.67036563e-01f, -4.31678370e-02f, 6.81546703e-02f, 1.66767985e-01f, -2.50016123e-01f, -2.66861141e-01f, 1.08661503e-01f, 4.01354730e-02f, -2.25614056e-01f,
  -5.89959957e-02f, -2.92540193e-02f, -1.80822253e-01f, 9.65427831e-02f, 1.57039940e-01f, -3.26939276e-03f, 2.66929507e-01f, -1.01827169e-02f, 1.86409369e-01f, 1.75920174e-01f,
  2.50572234e-01f, 2.37442046e-01f, 1.94168329e-01f, 1.45457834e-01f, 2.29341626e-01f, 1.73103273e-01f, 1.30647108e-01f, -9.02121142e-02f, -1.54551730e-01f, -1.12553164e-02f,
  6.89298138e-02f, 1.15473196e-01f, -1.08586475e-01f, -9.78935435e-02f, 7.28889555e-02f, -9.35327932e-02f, -4.05918323e-02f, -2.92060003e-02f, 7.71109611e-02f, -4.99659255e-02f,
  -2.07819715e-02f, 6.11492321e-02f, 2.88004838e-02f, 8.20160434e-02f, 2.89343633e-02f, -3.01212650e-02f, 2.11002119e-02f, 1.14167770e-02f, -2.49754079e-02f, 3.76062728e-02f,
  -5.04683405e-02f, 3.07965595e-02f, 4.60158847e-02f, -2.35612039e-03f, -7.32201478e-03f, 4.60549146e-02f, -2.15030159e-03f, -9.75351110e-02f, 4.06827778e-02f, -2.64035743e-02f,
  -4.68749590e-02f, -3.47670317e-02f, 4.87612560e-03f, -2.14384124e-02f, -2.65128743e-02f, -6.19598711e-03f, 8.38972721e-03f, -3.35087143e-02f, 3.61069851e-02f, 1.97993014e-02f,
  -1.12564061e-02f, 3.66602279e-02f, 2.08074003e-02f, 1.43267075e-02f, -2.24257391e-02f, -8.43255594e-03f, 6.45586550e-02f, -3.00637614e-02f, 2.45579164e-02f, -4.80264761e-02f,
  -4.07987572e-02f, 7.19203129e-02f, -8.30784664e-02f, -6.73374385e-02f, 2.93343607e-02f, -6.56154007e-02f, 6.41774908e-02f, -3.52864452e-02f, 2.77124010e-02f, -2.84530129e-02f,
  -1.31528005e-01f, -1.65692419e-01f, -1.14959762e-01f, 4.41182628e-02f, -6.10978827e-02f, 8.40308890e-02f, 6.08874811e-03f, 8.63402113e-02f, -6.45115823e-02f, 5.47358170e-02f,
  -3.86980642e-03f, -2.14418285e-02f, -2.44144071e-02f, 1.52795883e-02f, 4.29287106e-02f, -3.85128781e-02f, -2.79529160e-03f, -5.70300445e-02f, -5.11851870e-02f, 2.35136859e-02f,
  -1.70163754e-02f, 2.13648584e-02f, 6.95382245e-03f, -1.54104512e-02f, -4.23446018e-03f, -6.49995580e-02f, 4.13239840e-03f, 3.98947708e-02f, 5.65363429e-02f, 3.70695479e-02f,
  2.50899374e-01f, 2.12031320e-01f, 1.54675081e-01f, 1.65742591e-01f, -1.82845652e-01f, 3.01460773e-02f, -7.14644715e-02f, 1.45279184e-01f, 3.89163524e-01f, -1.58091739e-01f,
  -2.34446466e-01f, 2.84321666e-01f, -1.80929810e-01f, -6.19016849e-02f, 3.89274627e-01f, 6.53507337e-02f, -4.03494574e-02f, -1.54267505e-01f, 9.40653980e-02f, -5.61980642e-02f,
  4.74515446e-02f, -3.31186414e-01f, 1.60538495e-01f, -2.03188553e-01f, 2.94025335e-03f, 3.30182724e-02f, -1.71281070e-01f, -1.63328081e-01f, -6.63853660e-02f, 1.28571883e-01f,
  -2.72500031e-02f, -7.71281484e-04f, 2.33649393e-03f, 7.49086887e-02f, -8.46400764e-03f, -8.33506882e-02f, -8.44810158e-02f, -7.24877715e-02f, -1.20080449e-03f, -5.03647095e-03f,
  -5.28728738e-02f, -8.06014463e-02f, 2.20024325e-02f, 4.33045663e-02f, -8.25203024e-03f, 1.21457398e-01f, -2.57130135e-02f, -1.29506337e-02f, 5.57116047e-02f, -6.21853443e-03f,
  3.15404087e-02f, 6.11798987e-02f, 5.78695349e-03f, 7.88358301e-02f, 4.72609811e-02f, 4.67853062e-02f, 5.39223067e-02f, -1.21406607e-01f, 2.79439148e-02f, -3.18363160e-02f,
  3.46860290e-02f, -5.62123880e-02f, -1.24882180e-02f, 6.38180529e-04f, 2.84810960e-02f, -2.62451191e-02f, -1.10310297e-02f, -2.34266631e-02f, 6.47351742e-02f, 1.50408614e-02f,
  -3.41985784e-02f, 2.71693747e-02f, -3.84926647e-02f, 2.12681666e-02f, -6.78417832e-02f, 1.14594614e-02f, 7.12936919e-04f, 7.25762919e-02f, 3.77495140e-02f, 1.58423036e-02f,
  -4.17832322e-02f, -6.99341157e-03f, -6.94983220e-03f, -7.56428167e-02f, 1.32096820e-02f, -2.39814967e-02f, 6.43926188e-02f, -2.90564355e-02f, -1.36448694e-02f, -5.59871905e-02f,
  3.92198414e-02f, 1.99847758e-01f, 1.01591349e-01f, -2.43648831e-02f, -2.32573110e-03f, 3.54997371e-03f, 2.59930938e-02f, 8.17692280e-02f, 2.76166573e-02f, 4.86360416e-02f,
  -5.12497835e-02f, -9.86350235e-03f, -2.18508812e-03f, -3.16375233e-02f, 1.21064596e-02f, -3.42888683e-02f, -1.22864479e-02f, -1.76673569e-02f, -3.30173485e-02f, -1.56020131e-02f,
  -3.12571228e-02f, -6.37484267e-02f, 6.91084042e-02f, -6.67012762e-04f, -4.93293777e-02f, -5.23762926e-02f, 6.62457123e-02f, 9.14845616e-02f, -7.93304443e-02f, 3.78458761e-02f,
  -2.73436040e-01f, -5.17621525e-02f, -2.54707128e-01f, -2.09434062e-01f, -2.02054530e-01f, 1.89364433e-01f, 1.29223745e-02f, -9.10195336e-02f, -1.75933674e-01f, 1.19410940e-01f,
  -3.45528424e-02f, -6.80670440e-02f, 7.96033815e-03f, -3.70570384e-02f, 2.72149801e-01f, 1.11774899e-01f, 8.49025175e-02f, -2.69386638e-02f, -1.33094177e-01f, 1.84486583e-02f,
  2.34427787e-02f, -1.23948552e-01f, -1.58493035e-02f, -1.61134198e-01f, -1.12811960e-01f, -3.09070330e-02f, 2.18385905e-01f, -1.28376082e-01f, 6.03968203e-02f, -1.35368839e-01f,
  2.82760765e-02f, -2.49323815e-01f, 7.00366721e-02f, 9.00325030e-02f, 6.99590668e-02f, 4.57638167e-02f, 1.23405449e-01f, -5.32647409e-02f, -6.89585228e-03f, -4.12983559e-02f,
  6.13684058e-02f, -4.59750779e-02f, -6.97884522e-03f, -6.82417080e-02f, -1.09165683e-02f, -9.01444256e-02f, -8.84546116e-02f, 3.37053128e-02f, -7.73635656e-02f, -8.18584785e-02f,
  -3.71223949e-02f, 9.42720696e-02f, 9.62981582e-02f, 5.49214594e-02f, 4.93866131e-02f, -3.79375368e-02f, 1.61272828e-02f, 1.11160792e-01f, 4.38569486e-02f, 2.60047261e-02f,
  -1.10338286e-01f, 8.42591450e-02f, -3.16080339e-02f, -7.34249800e-02f, -3.55688035e-02f, -9.91966352e-02f, -3.91815603e-03f, 1.30889062e-02f, 1.29608053e-03f, -2.65908148e-02f,
  2.26057079e-02f, 1.45251316e-03f, -1.10659517e-01f, -4.37011756e-02f, -8.03498402e-02f, -2.36050878e-02f, 6.58294633e-02f, -5.72676174e-02f, 1.53860286e-01f, -4.05779295e-03f,
  -7.49154165e-02f, 7.95450434e-02f, -1.79414228e-02f, 3.56939882e-02f, -3.46195959e-02f, 2.21125819e-02f, 2.89953332e-02f, -2.02729255e-02f, 3.66851571e-03f, 7.03176335e-02f,
  3.07359248e-01f, 7.58126378e-02f, 1.34177387e-01f, 2.08094586e-02f, 3.35101932e-02f, 7.53147528e-02f, -1.52613819e-01f, 1.85493119e-02f, 7.41353408e-02f, -2.33383346e-02f,
  -4.81239706e-02f, 6.81656972e-02f, 1.33830056e-01f, -2.16209609e-02f, -2.55739186e-02f, 2.41319705e-02f, 3.35269310e-02f, 1.07988425e-01f, 2.62253821e-01f, 2.76710056e-02f,
  7.29209781e-02f, -4.41120900e-02f, -1.81604587e-02f, 5.64839784e-03f, 6.36232272e-02f, 8.40726122e-02f, -1.49090402e-02f, -2.56646276e-02f, -1.43229561e-02f, 7.90591165e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.92701969e-02f, 4.87018339e-02f, -4.86769110e-01f, -1.82204410e-01f, -1.62318498e-01f, 1.94939375e-01f, 4.58252072e-01f, -7.08611235e-02f, -1.77173391e-01f, 4.54046667e-01f,
  3.67601454e-01f, 4.76334281e-02f, 2.00782210e-01f, 4.22120869e-01f, -3.50564778e-01f, 2.32745141e-01f, 1.93294168e-01f, 1.03460364e-01f, -1.18293054e-01f, 1.25684708e-01f,
  -3.56496722e-01f, 4.43605691e-01f, -1.63977414e-01f, 5.18730655e-02f, 2.13477165e-01f, -1.45814270e-01f, 1.87626988e-01f, -1.78403836e-02f, -4.78910469e-02f, 3.15938443e-02f,
  6.23484366e-02f, 9.03616101e-02f, 6.68463705e-04f, -1.24873988e-01f, 1.12326317e-01f, 1.16788052e-01f, 3.00594699e-02f, -5.31060286e-02f, -1.34048358e-01f, 5.80750369e-02f,
  9.48322713e-02f, -5.93862757e-02f, 1.55141996e-02f, -7.63259232e-02f, -1.56123526e-02f, -8.24404210e-02f, -2.29932487e-01f, -8.07661749e-03f, -9.84865129e-02f, 2.48864922e-03f,
  -6.11294806e-02f, -3.57789695e-02f, -3.70625667e-02f, -9.00098532e-02f, -1.43475562e-01f, 4.93205562e-02f, -2.95163449e-02f, 7.49373361e-02f, 4.96576391e-02f, -6.71106055e-02f,
  6.30735755e-02f, 3.75538990e-02f, 1.60499811e-01f, 1.00820489e-01f, -7.15355668e-03f, 1.20691676e-02f, 1.02612143e-02f, -9.77547467e-02f, -1.57982916e-01f, -1.65100601e-02f,
  -1.03492685e-01f, -5.01722358e-02f, 1.04013152e-01f, -1.49693182e-02f, -2.71855071e-02f, 1.13635518e-01f, 7.01137409e-02f, 5.20554371e-02f, -1.34842936e-02f, -1.52084887e-01f,
  8.27715825e-03f, -5.19337393e-02f, 3.52465026e-02f, 1.16789326e-01f, -2.34446879e-02f, -8.62998068e-02f, 1.39305219e-01f, 7.41419755e-03f, 8.33274797e-02f, -1.60057954e-02f,
  6.10702522e-02f, 2.45086744e-01f, 6.81803450e-02f, 7.66009605e-03f, -7.45201036e-02f, 1.04272582e-01f, 8.81543607e-02f, 4.59263921e-02f, 4.70586829e-02f, 4.95514870e-02f,
  4.13858332e-02f, 5.29997656e-03f, 3.05126850e-02f, 3.36852483e-02f, -1.82704702e-01f, 1.49202049e-01f, 1.48341224e-01f, -9.35750008e-02f, -1.02813415e-01f, -1.03773884e-01f,
  8.56139362e-02f, 2.25662082e-01f, -6.51490390e-02f, 5.83629776e-03f, -9.32466462e-02f, 1.17063589e-01f, -1.24442307e-02f, 3.48258391e-02f, -3.73135246e-02f, -8.89284387e-02f,
  9.49047282e-02f, -2.64513075e-01f, -2.72941172e-01f, -3.84125262e-02f, -8.30987990e-02f, -5.93035042e-01f, -7.12899864e-01f, 7.09652901e-02f, -3.87840837e-01f, -1.64755881e-02f,
  -4.68971115e-03f, -6.74687652e-03f, -5.96945807e-02f, -2.92312741e-01f, 1.69647545e-01f, -1.59234419e-01f, 2.10539445e-01f, 1.54741490e-02f, -7.30070770e-02f, 1.93910912e-01f,
  1.95228308e-01f, 1.64062053e-01f, 1.18462697e-01f, 2.77965903e-01f, 1.68609601e-02f, 3.99560153e-01f, 5.78920662e-01f, 2.93923970e-02f, 2.01916754e-01f, 1.39917165e-01f,
  -6.45477474e-02f, 1.01584904e-02f, -1.79714829e-01f, -6.82611763e-02f, 1.16295829e-01f, 1.39893815e-01f, 4.38477322e-02f, -6.56205863e-02f, -4.79769669e-02f, 2.39198357e-02f,
  3.40974480e-02f, 1.08558439e-01f, -1.45619020e-01f, -4.82714213e-02f, -1.03422090e-01f, -1.58434123e-01f, -3.73400673e-02f, -8.14705491e-02f, -1.49835616e-01f, 4.37878212e-03f,
  -1.23877227e-02f, -2.11733598e-02f, 5.62435463e-02f, 1.18699588e-01f, 1.17366895e-01f, 6.65101930e-02f, 3.34934629e-02f, 8.87804031e-02f, -2.97150388e-02f, 2.93732733e-02f,
  6.34724200e-02f, 5.03405072e-02f, 5.70175238e-02f, -9.21613127e-02f, -6.37677610e-02f, -6.69475272e-02f, -7.47572333e-02f, -3.45203467e-02f, 2.88535398e-03f, 2.62658275e-03f,
  -7.99518526e-02f, -1.53434305e-02f, -5.34718968e-02f, 1.78945027e-02f, 1.35599032e-01f, -1.36633754e-01f, -4.10646051e-02f, 5.99556696e-03f, -1.48947034e-02f, -1.83837429e-01f,
  -1.65515065e-01f, 1.06588587e-01f, -1.12875417e-01f, -4.75220643e-02f, -1.05601773e-01f, 8.70367736e-02f, 1.42427906e-01f, -6.30997345e-02f, 3.43461335e-02f, -7.81432316e-02f,
  1.19215243e-01f, 2.56881267e-01f, -8.03683996e-02f, -3.24265845e-02f, -7.26665407e-02f, -2.18828265e-02f, -1.56759862e-02f, 1.28136575e-01f, 1.61706865e-01f, -6.20830134e-02f,
  2.43097574e-01f, -7.97804445e-02f, 1.30399331e-01f, 1.44889560e-02f, 1.48149533e-02f, 1.79747969e-01f, 9.56624672e-02f, -9.82642290e-04f, 9.40636992e-02f, 2.61930302e-02f,
  1.16111077e-01f, -5.56511134e-02f, 9.60367639e-03f, -8.11040699e-02f, 8.87299478e-02f, 2.31452417e-02f, 1.23197801e-01f, 6.30735531e-02f, 1.47416040e-01f, -4.97834124e-02f,
  3.90304893e-01f, -7.41385579e-01f, 2.88495064e-01f, 4.82638091e-01f, 2.64957637e-01f, -4.32934314e-02f, 2.33798131e-01f, -2.81861097e-01f, -2.66700834e-01f, -5.00426650e-01f,
  3.78910154e-02f, 3.40912968e-01f, -3.96864444e-01f, 1.16077112e-02f, 5.34991503e-01f, -2.56830633e-01f, -7.00663403e-03f, 5.18987216e-02f, -5.09832688e-02f, 3.34478952e-02f,
  1.52385548e-01f, 3.80193964e-02f, 1.89603955e-01f, -9.38583165e-02f, 1.52168602e-01f, 1.53676808e-01f, 3.42252366e-02f, 3.56675051e-02f, 2.97746658e-01f, 2.72839963e-01f,
  -2.92689860e-01f, -1.19099788e-01f, 9.67775360e-02f, 4.44818987e-03f, -1.34195864e-01f, -6.88430518e-02f, 1.66030869e-01f, 1.58188954e-01f, 1.11362636e-01f, -7.14600384e-02f,
  3.44723426e-02f, 3.49619277e-02f, 1.14219442e-01f, 7.41947219e-02f, -1.23071738e-01f, -3.51023860e-02f, -5.94958849e-02f, -4.01811786e-02f, -1.74657218e-02f, -6.66548759e-02f,
  -1.58172563e-01f, 2.11614575e-02f, -3.33919600e-02f, 9.20903534e-02f, -3.01672542e-03f, -7.23455381e-03f, 8.74004047e-03f, 1.32470846e-01f, -8.88233706e-02f, -5.32721616e-02f,
  4.83050905e-02f, 6.96164323e-03f, -4.10712399e-02f, 6.62567886e-03f, -1.27236824e-02f, 6.23786300e-02f, -9.40528661e-02f, 2.47727633e-02f, 9.64746326e-02f, -6.54136539e-02f,
  1.72926334e-03f, 1.02841191e-01f, 9.39898565e-02f, -1.29017532e-01f, 2.91973427e-02f, -4.69880737e-02f, 1.23355919e-02f, 1.53396204e-02f, -6.29927814e-02f, 2.18309145e-02f,
  -5.76068237e-02f, 7.60378167e-02f, -9.92326811e-02f, 3.20771523e-02f, -2.73984633e-02f, 8.91117007e-02f, -8.60704929e-02f, -9.35114324e-02f, -3.30888890e-02f, 9.30340663e-02f,
  -8.09058845e-01f, -4.83524442e-01f, 4.88480069e-02f, -1.50507540e-05f, 5.33336364e-02f, -9.78827477e-03f, 3.96869285e-03f, -6.54382110e-02f, -1.87906116e-01f, 2.85740942e-02f,
  6.77627102e-02f, 9.14394259e-02f, -1.40744120e-01f, 5.07403836e-02f, 1.18488356e-01f, -1.59582719e-01f, -5.27978549e-03f, 2.20994838e-02f, -6.50361739e-03f, -1.43323556e-01f,
  -9.18144807e-02f, -1.82149976e-01f, 9.32257771e-02f, 4.51896712e-02f, 4.80864681e-02f, 6.13220185e-02f, -6.83669583e-04f, -5.24794720e-02f, 1.70719251e-02f, 9.95011851e-02f,
  4.87678438e-01f, 4.37875569e-01f, 4.90749836e-01f, 5.50171673e-01f, -2.22198173e-01f, -4.58644897e-01f, -1.68862924e-01f, 1.97849870e-01f, -1.24990428e-02f, -6.92939088e-02f,
  1.63863122e-01f, 3.25920284e-01f, 1.30463123e-01f, 1.93353102e-01f, 3.89147550e-01f, -1.47656813e-01f, 3.05813342e-01f, 1.48895141e-02f, -8.80403891e-02f, 3.78654838e-01f,
  1.69299856e-01f, 6.15349784e-02f, 3.86900365e-01f, -4.25140467e-03f, 1.89113662e-01f, 2.68419743e-01f, 3.50259632e-01f, -1.83038134e-02f, 2.39252955e-01f, -1.14577465e-01f,
  -2.48907521e-01f, 2.01978646e-02f, 1.97059736e-01f, -1.21190466e-01f, 5.49923256e-03f, -6.26474395e-02f, -5.82953654e-02f, 4.22559259e-03f, 2.74628121e-02f, -2.98012905e-02f,
  -1.27187535e-01f, 5.61540462e-02f, 1.64823625e-02f, -5.66463592e-03f, -6.34899437e-02f, 8.68420377e-02f, -5.77684827e-02f, 4.86125946e-02f, 8.42723548e-02f, 8.59728828e-02f,
  1.57872245e-01f, 6.01457171e-02f, -1.69847824e-03f, -1.51057914e-01f, 4.47148420e-02f, 1.57019310e-02f, -2.94202715e-02f, -1.87336630e-03f, 3.55119142e-03f, -3.87549475e-02f,
  -6.18397631e-02f, -2.09120265e-03f, 3.17172706e-02f, 1.92985721e-02f, 1.15057029e-01f, -1.08761862e-02f, 2.26122607e-02f, 3.58991101e-02f, -4.42869253e-02f, 2.52669938e-02f,
  3.19756120e-02f, -2.02945899e-02f, -4.19528596e-02f, 1.20009538e-02f, 3.40179503e-02f, 5.39887995e-02f, 1.05893411e-01f, -9.58809257e-02f, -4.45994036e-03f, 6.78782389e-02f,
  -8.19341019e-02f, 2.17212010e-02f, 8.48455206e-02f, -4.56412137e-02f, -5.19362912e-02f, -6.60767872e-03f, 5.99878617e-02f, 5.82744069e-02f, -2.18578242e-03f, 1.06335968e-01f,
  -1.13852983e-02f, 3.52510661e-01f, 7.18762055e-02f, -5.25323749e-02f, -1.39599636e-01f, -4.19758670e-02f, -2.89620385e-02f, 2.14579031e-02f, 1.38455898e-01f, 2.11501792e-02f,
  -4.28353883e-02f, -1.32097071e-02f, -1.93491936e-01f, -3.87716889e-02f, 1.61840953e-02f, 1.20625436e-01f, 1.04047656e-01f, 5.12687229e-02f, 6.71125129e-02f, 9.36786905e-02f,
  3.62336226e-02f, -1.37231007e-01f, -5.72522096e-02f, -1.17601529e-01f, -2.16581207e-02f, -1.37952998e-01f, -9.83346105e-02f, -7.64999166e-02f, 1.08638808e-01f, -3.77910696e-02f,
  -3.28068465e-01f, 2.74371117e-01f, -3.31304520e-01f, 3.37955683e-01f, -3.84112149e-01f, 5.39622128e-01f, 4.90961969e-01f, -2.09324211e-01f, 8.96113813e-02f, 3.66943777e-01f,
  3.33059371e-01f, 2.96103451e-02f, 1.39789045e-01f, 5.92720449e-01f, 2.35695392e-01f, 4.08716172e-01f, 5.38933456e-01f, 4.23502505e-01f, -3.34075801e-02f, 3.03667225e-02f,
  -4.61901277e-02f, 4.85745728e-01f, -1.60695225e-01f, -1.88482091e-01f, -1.93426777e-02f, -3.95574212e-01f, -1.45070419e-01f, -4.81218785e-01f, 1.34404480e-01f, 5.74864559e-02f,
  1.16888747e-01f, -6.38006255e-02f, -1.49020061e-01f, 9.08133388e-03f, 3.22369821e-02f, -2.79891081e-02f, -1.00335954e-02f, -1.02616372e-02f, -1.89895898e-01f, -5.09337932e-02f,
  -2.07494479e-02f, -7.42495432e-02f, 5.70497997e-02f, -9.86978412e-02f, 8.72854795e-03f, -6.48361119e-03f, 2.81727966e-02f, 3.30548100e-02f, -4.57706861e-02f, 1.44976014e-02f,
  -1.11815535e-01f, -1.58328675e-02f, 9.46113244e-02f, 8.45523849e-02f, -4.14493494e-02f, 8.23608786e-02f, 1.29498318e-01f, -1.23788178e-01f, 4.06390987e-02f, 9.48297966e-04f,
  -6.86937496e-02f, 1.96684133e-02f, -5.42367734e-02f, 4.68591740e-03f, 4.06354368e-02f, -1.60697121e-02f, 6.45156801e-02f, 1.31870685e-02f, 2.05493905e-02f, 7.52994865e-02f,
  -4.61469330e-02f, 9.23748612e-02f, -4.65385988e-02f, 4.41271588e-02f, 1.07346773e-01f, 3.39139700e-02f, -1.01248547e-01f, 9.11389440e-02f, 7.66452327e-02f, 4.97807004e-02f,
  -8.42925310e-02f, 5.09333313e-02f, 1.29259340e-02f, -1.02912955e-01f, 6.62550926e-02f, -1.21418536e-01f, 8.33246186e-02f, -2.78654117e-02f, -2.76978556e-02f, -6.47585019e-02f,
  2.65271842e-01f, 1.78470090e-01f, 6.23031557e-02f, -3.89924943e-02f, 3.84081490e-02f, -6.96117058e-02f, 1.52485375e-03f, -3.74000706e-02f, 7.76699511e-03f, 7.03669735e-04f,
  -4.10807366e-03f, 3.21874358e-02f, -7.07164630e-02f, -4.64191660e-02f, 2.22818367e-02f, 2.10711993e-02f, 1.51322067e-01f, -2.50112936e-02f, 7.70402476e-02f, -4.63194586e-02f,
  1.30587295e-02f, 4.26437519e-03f, -6.19156333e-03f, -4.33522202e-02f, 1.32079259e-01f, -1.35330278e-02f, 1.82392392e-02f, -5.22586256e-02f, -1.32560506e-01f, 9.44383368e-02f,
  -6.13267899e-01f, -9.60377827e-02f, 6.51176333e-01f, -3.66531551e-01f, 3.98445055e-02f, 3.79965723e-01f, 3.65530759e-01f, -9.99315456e-02f, -3.45793277e-01f, -2.43995339e-01f,
  -1.04085736e-01f, -7.61740282e-02f, 3.35512102e-01f, -2.67516840e-02f, 5.56037724e-01f, 2.12117493e-01f, 7.82685652e-02f, 5.19565865e-02f, -2.01552108e-01f, -1.42178327e-01f,
  2.77854037e-02f, -2.78651178e-01f, 3.52632612e-01f, -3.51030171e-01f, 1.14446811e-01f, -2.20369682e-01f, -2.35942274e-01f, 2.27978945e-01f, -1.16438501e-01f, 1.10606313e-01f,
  -5.07976972e-02f, -2.02697083e-01f, -1.02221318e-01f, -5.71102202e-02f, -3.51604708e-02f, 2.42131837e-02f, 4.81208898e-02f, 1.40375569e-01f, -6.08544871e-02f, -5.82803600e-03f,
  -2.36367737e-03f, 3.69096659e-02f, -1.78474471e-01f, 7.28590647e-03f, -4.33074869e-02f, -6.16741888e-02f, 8.34516808e-02f, 4.38152961e-02f, -7.11643882e-03f, 2.49016568e-01f,
  1.13430113e-01f, 5.89127429e-02f, 1.16811641e-01f, -1.35066491e-02f, 6.05292208e-02f, -2.56331656e-02f, 8.87708142e-02f, 1.06779985e-01f, -2.54839398e-02f, -5.67961857e-02f,
  3.59996669e-02f, -1.05615957e-02f, -2.30228174e-02f, -6.62003458e-02f, 1.71263535e-02f, 8.72384384e-03f, -5.96361384e-02f, -2.81749535e-02f, -1.62121654e-02f, -4.88986867e-03f,
  2.49520764e-02f, -1.47606023e-02f, 5.80134913e-02f, 5.93279139e-04f, -2.62241047e-02f, -1.05547660e-03f, 2.55989544e-02f, -7.04608485e-03f, 3.79865058e-02f, -2.83109434e-02f,
  -5.99137880e-03f, 6.98512718e-02f, 7.54983649e-02f, -1.27454251e-02f, -6.70680683e-03f, 1.67977121e-02f, -1.02504045e-01f, 1.11242123e-01f, -2.55904738e-02f, 1.64997742e-01f,
  -2.91385502e-01f, -4.72036242e-01f, -1.91752106e-01f, -1.24345005e-01f, -2.64635310e-03f, 1.37801226e-02f, -2.98840217e-02f, -6.03273064e-02f, -7.23556951e-02f, -1.71779208e-02f,
  -4.96784523e-02f, 2.11292622e-03f, -6.78382963e-02f, -6.45127222e-02f, -6.37226105e-02f, 2.94862892e-02f, -8.24602395e-02f, -6.60275668e-02f, -9.61419344e-02f, -9.62033346e-02f,
  -5.87646626e-02f, -9.32120159e-02f, 5.94474785e-02f, -1.81696892e-01f, -3.65934037e-02f, -5.73772937e-02f, -5.57452366e-02f, -5.94529398e-02f, 5.66825494e-02f, -1.96460485e-02f,
  8.20519984e-01f, 1.83721244e-01f, 4.80574310e-01f, 6.14013851e-01f, 2.52281949e-02f, -2.29100823e-01f, 1.89447418e-01f, 1.73864186e-01f, 6.29419804e-01f, -1.21503808e-01f,
  -1.57090321e-01f, 3.25066954e-01f, -4.52660739e-01f, 2.70330936e-01f, -3.36285114e-01f, -2.78220445e-01f, 1.75746128e-01f, 9.66998562e-02f, 5.66141084e-02f, 1.83104962e-01f,
  2.70171672e-01f, -4.12205249e-01f, -1.38746694e-01f, -3.42217207e-01f, 4.27255541e-01f, 2.04284832e-01f, -3.70853841e-01f, -2.99386829e-01f, 6.40472695e-02f, -3.32465917e-01f,
  3.09899021e-02f, 2.31059939e-01f, 1.51238784e-01f, 4.23799455e-02f, 1.87783867e-01f, 2.05180831e-02f, -4.88636494e-02f, -2.00011238e-01f, 1.46937415e-01f, 3.34568918e-02f,
  -7.75397476e-03f, -1.38094112e-01f, 1.55975074e-01f, -1.49797469e-01f, 1.18651479e-01f, 1.01109616e-01f, 1.15211323e-01f, 2.59373933e-01f, 1.12920702e-01f, 7.35924616e-02f,
  1.64525390e-01f, 1.23579018e-01f, 2.08388329e-01f, -5.89839704e-02f, 1.38940617e-01f, 5.75938784e-02f, -7.67520536e-03f, -2.72434903e-03f, 3.48900370e-02f, 1.14541702e-01f,
  -7.38820806e-02f, 2.05281638e-02f, -5.89120723e-02f, 1.22271404e-01f, -6.73924387e-03f, 1.00143766e-03f, 8.76723381e-04f, -3.88139077e-02f, 3.18942927e-02f, -5.37228324e-02f,
  3.94391418e-02f, 1.47749886e-01f, 9.96423438e-02f, 1.24342963e-01f, 5.37719615e-02f, 1.10532977e-01f, -4.95935753e-02f, 5.56416772e-02f, 1.18847065e-01f, 9.59425494e-02f,
  -7.93551281e-02f, 1.31559065e-02f, 8.27195495e-03f, -7.43099004e-02f, -7.67247975e-02f, -8.84139240e-02f, 1.90511253e-02f, 1.14508472e-01f, 4.85901944e-02f, -1.36490375e-01f,
  -1.20069079e-01f, -3.88135642e-01f, 4.14538980e-02f, 2.53911763e-02f, 1.20953843e-02f, 6.78048208e-02f, 2.94456519e-02f, 7.29504153e-02f, -1.34179950e-01f, -8.40780511e-03f,
  -5.79703748e-02f, 7.98173547e-02f, -6.02798536e-02f, 6.23667836e-02f, -1.02771975e-01f, 9.21682455e-03f, -4.14435565e-02f, -9.42029804e-02f, 4.10031807e-03f, -1.42421827e-01f,
  -4.55500931e-02f, -3.00081931e-02f, -1.08637679e-02f, 8.96598548e-02f, -1.45348050e-02f, 1.32688032e-02f, 8.17585886e-02f, 6.56656548e-02f, -1.08233593e-01f, -3.68906222e-02f,
  5.25042713e-01f, -1.90574169e-01f, 1.35388091e-01f, 4.41089272e-01f, 1.19825415e-01f, 6.37274802e-01f, 8.39350641e-01f, -2.30049193e-02f, 6.77907109e-01f, -2.21951619e-01f,
  -2.66755491e-01f, 2.29383886e-01f, 6.18684553e-02f, 2.65786871e-02f, 6.49642646e-01f, 1.81033477e-01f, 2.89389998e-01f, 3.16175699e-01f, 2.14903846e-01f, 1.99025869e-01f,
  2.56658733e-01f, 9.90811214e-02f, -1.31311178e-01f, -5.58679760e-01f, -9.96195525e-02f, -3.28899980e-01f, -5.47330678e-01f, -9.93866380e-03f, -4.55899090e-01f, 1.08367786e-01f,
  -1.07470732e-02f, 4.85876910e-02f, -1.43624052e-01f, 6.75764754e-02f, -6.44203648e-02f, -8.56597796e-02f, -2.87156040e-03f, 6.70218021e-02f, 1.27805825e-02f, 7.66066015e-02f,
  8.32249895e-02f, -1.91887412e-02f, 6.43652007e-02f, 2.41036899e-02f, 8.51564631e-02f, -1.27828121e-01f, -7.03931376e-02f, -2.09081605e-01f, 1.62081476e-02f, -1.14410974e-01f,
  -7.75647387e-02f, -1.45913735e-01f, -7.02377036e-02f, -1.76526923e-02f, -5.28521128e-02f, 2.89896745e-02f, 1.11087319e-03f, 7.31161609e-02f, -6.58730641e-02f, 7.46485144e-02f,
  6.89133704e-02f, 9.75065604e-02f, -1.79730589e-03f, -1.09279439e-01f, -1.79782184e-03f, -9.74634439e-02f, -6.22068793e-02f, -1.18517689e-01f, 2.86278334e-02f, 9.95589793e-02f,
  4.95731458e-02f, 2.83859321e-03f, 9.40598175e-02f, 2.45142970e-02f, 1.49664000e-01f, 3.48542109e-02f, 2.67357081e-02f, 1.39948539e-03f, 3.09544224e-02f, -2.26376839e-02f,
  1.30619872e-02f, 7.35470429e-02f, -1.52336955e-01f, -1.00459352e-01f, -6.37257844e-02f, 7.19959810e-02f, 2.69643646e-02f, -1.34185208e-02f, -5.51415198e-02f, 7.62536898e-02f,
  1.20248057e-01f, 4.17370886e-01f, 1.13721574e-02f, -5.22620454e-02f, 2.53876261e-02f, -7.45626986e-02f, 1.16060801e-01f, 8.15733895e-02f, 3.12095135e-02f, 1.08754195e-01f,
  3.60777192e-02f, 2.79235672e-02f, -6.86609466e-03f, -5.84393106e-02f, -2.09020860e-02f, -3.82634066e-02f, 1.31104976e-01f, 8.24115276e-02f, 8.10692180e-03f, -1.37543485e-01f,
  -1.62532836e-01f, 1.74920037e-01f, 1.27981409e-01f, -3.32391635e-02f, -2.80152038e-02f, -1.07548401e-01f, 9.14800763e-02f, -6.45916313e-02f, -7.55232945e-02f, -2.17410512e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.57046598e-01f, 3.58176559e-01f, 2.47416317e-01f, 5.41397780e-02f, 3.22678000e-01f, 3.15521181e-01f, 2.79154420e-01f, 3.28741640e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -3.87697183e-02f, 6.70475721e-01f, 2.26499632e-01f, -4.51794505e-01f, -1.64635122e-01f, -1.76125541e-01f, 5.83723962e-01f, 1.92033127e-02f, 1.21852450e-01f, 3.91723663e-01f,
  -3.36443037e-01f, -9.14302829e-04f, -8.84995162e-02f, -3.12684849e-02f, -2.66707927e-01f, 1.30923614e-01f, -6.60788476e-01f, -4.16279398e-02f, -5.18277213e-02f, -2.12055981e-01f,
  -3.14937145e-01f, -2.95881778e-01f, 1.74046531e-01f, 1.76402241e-01f, 6.91318810e-02f, -2.50816762e-01f, -1.14936931e-02f, -1.19325265e-01f, -1.60211523e-03f, 2.49494925e-01f,
  5.46256313e-04f, 5.78734353e-02f, -8.89262110e-02f, 4.05876160e-01f, -6.18535019e-02f, -1.42301545e-01f, 4.31669131e-02f, 2.83765346e-01f, 2.85747916e-01f, 3.17680299e-01f,
  1.30325541e-01f, 5.52084222e-02f, -1.86586529e-02f, 2.25680977e-01f, 2.48384759e-01f, 2.27164313e-01f, 1.36785612e-01f, -1.17743406e-02f, -4.13175017e-01f, -3.40575486e-01f,
  1.54469565e-01f, -5.69330119e-02f, 5.68218589e-01f, -2.57268369e-01f, -3.38631421e-01f, 1.69564366e-01f, 5.68908593e-03f, 1.52761847e-01f, 2.58199513e-01f, -3.90428364e-01f,
  3.09564263e-01f, 3.03628117e-01f, -2.80082941e-01f, -4.48062003e-01f, -9.16825682e-02f, -5.67376494e-01f, -2.96235699e-02f, 3.28518003e-01f, -2.28244290e-01f, 3.44881654e-01f,
  -4.05680180e-01f, -1.47680581e-01f, -2.28848413e-01f, -3.91273618e-01f, 2.13761479e-01f, 1.21343313e-02f, -8.53118449e-02f, 2.79018402e-01f, 3.52226049e-01f, -2.65167296e-01f,
  4.71353024e-01f, 2.70402059e-02f, 1.04735186e-02f, -1.91412047e-01f, 3.09907764e-01f, 2.42036119e-01f, 2.78386921e-02f, -1.47021428e-01f, -2.22689584e-02f, 1.39339373e-01f,
  -9.74777341e-02f, -3.65348876e-01f, 4.04528193e-02f, -3.13912839e-01f, 5.99121675e-02f, 2.49087632e-01f, 3.46848071e-01f, 5.43182433e-01f, 1.54436141e-01f, 3.16314399e-02f,
  1.60166681e-01f, -3.21901023e-01f, 3.67259741e-01f, -8.99159536e-02f, 2.62347162e-01f, 4.06323224e-01f, -1.26470327e-01f, -2.14089751e-02f, 3.21384698e-01f, -2.61281550e-01f,
  -3.76345783e-01f, 2.19017178e-01f, -2.40584344e-01f, 2.34912604e-01f, -2.32451826e-01f, -3.60770196e-01f, -1.02353185e-01f, -2.99476117e-01f, 2.73410708e-01f, -4.06430632e-01f,
  -3.13714296e-02f, -5.54698939e-03f, -1.97920166e-02f, 2.85264492e-01f, -3.37433040e-01f, 1.41856177e-02f, 1.30357474e-01f, 2.46745288e-01f, 1.11656353e-01f, -1.06382787e-01f,
  -2.54268169e-01f, 1.15106933e-01f, -2.27528825e-01f, -6.42451495e-02f, -1.11734860e-01f, 2.90826187e-02f, 9.18651447e-02f, -8.93364251e-02f, -8.03284626e-03f, -6.13296367e-02f,
  4.65620100e-01f, 2.05365837e-01f, 4.30121660e-01f, -9.70533639e-02f, 2.24130049e-01f, -1.26866519e-01f, 2.30359629e-01f, -4.70073372e-01f, 5.73765218e-01f, 2.80913889e-01f,
  -9.81744304e-02f, -1.53807744e-01f, -2.53666937e-01f, 2.07841545e-01f, 5.58599830e-03f, 3.45116466e-01f, 4.18030992e-02f, -4.06852603e-01f, 1.53118864e-01f, 2.51501739e-01f,
  -2.40960438e-02f, 1.05102994e-01f, 8.01025406e-02f, 4.66680415e-02f, -2.22980484e-01f, -2.49488875e-01f, -4.03473973e-01f, -1.15850829e-01f, -3.18028986e-01f, -2.12106690e-01f,
  1.89178213e-01f, 4.21435386e-02f, 4.94835200e-03f, 1.64143190e-01f, 7.82251805e-02f, -4.22431290e-01f, 2.71065980e-01f, -1.16441511e-01f, 3.69409025e-01f, -8.33009779e-02f,
  2.69477308e-01f, -4.84084077e-02f, -3.91636640e-01f, -3.00035298e-01f, 2.42162675e-01f, -2.93880612e-01f, 2.73986250e-01f, -6.83282986e-02f, 3.43304455e-01f, -3.03658694e-01f,
  -7.55072162e-02f, 3.70542079e-01f, 1.30627155e-01f, 6.57727480e-01f, 1.65339902e-01f, -3.22293282e-01f, 4.31882553e-02f, -1.94642320e-01f, 6.73662066e-01f, 1.15402229e-01f,
  2.27040544e-01f, 4.35349703e-01f, -7.46275038e-02f, -1.56068251e-01f, 4.05760556e-01f, -1.17773183e-01f, -2.67021298e-01f, 3.18429381e-01f, -3.60917866e-01f, -4.18437198e-02f,
  -1.69927090e-01f, -1.02641761e-01f, 5.31778298e-02f, -2.84109116e-01f, 2.46677116e-01f, -4.33677100e-02f, -1.88934252e-01f, -7.18470067e-02f, 7.11192414e-02f, 6.69560060e-02f,
  -1.81102544e-01f, 1.58092514e-01f, 9.24994498e-02f, 1.05512738e-01f, -3.12101811e-01f, 1.06588803e-01f, 8.25790390e-02f, -2.66107202e-01f, -1.00590214e-01f, 1.81912288e-01f,
  4.54995692e-01f, -8.43071565e-02f, -4.14539874e-02f, 4.97698709e-02f, -1.26938187e-02f, 1.19942993e-01f, -8.10339823e-02f, 2.96553850e-01f, 1.74810868e-02f, -1.79537147e-01f,
  -4.43574816e-01f, -3.62516850e-01f, 2.64418244e-01f, -1.95376262e-01f, 1.34406209e-01f, -1.10537104e-01f, 3.92834581e-02f, 5.44801176e-01f, 2.32148856e-01f, -1.01045378e-01f,
  -1.33870855e-01f, -3.83217186e-01f, 1.91804796e-01f, 3.58697653e-01f, -3.90245557e-01f, 7.51037002e-02f, -4.45097722e-02f, -2.79107481e-01f, -1.97220609e-01f, -1.86193781e-03f,
  -2.34480917e-01f, -2.86833607e-02f, -8.64145532e-03f, -3.99897285e-02f, -3.41530263e-01f, -1.74738154e-01f, 2.70783842e-01f, -7.04858154e-02f, -4.97583486e-03f, 1.98257431e-01f,
  2.29505181e-01f, -3.92155617e-01f, 9.30866152e-02f, -4.75475341e-01f, 2.36177985e-02f, -6.74893558e-02f, 4.10810918e-01f, 3.92069906e-01f, 2.84466952e-01f, -1.95925221e-01f,
  1.86649442e-01f, 3.06926522e-04f, -1.60433531e-01f, 2.70984739e-01f, 2.35059932e-01f, 3.23824547e-02f, -1.16946816e-01f, 3.97814840e-01f, 8.66822749e-02f, 2.45472714e-01f,
  6.50350511e-01f, 2.27602288e-01f, 9.75667760e-02f, -1.90439261e-02f, -2.59319227e-02f, 1.31272078e-02f, -4.77121361e-02f, 1.83608383e-01f, 6.26711845e-02f, -7.60330036e-02f,
  -3.30726862e-01f, -4.77943523e-03f, -3.30648452e-01f, 2.19101414e-01f, 3.02340183e-02f, 5.87003827e-01f, -2.41763517e-01f, 1.18468069e-01f, -5.08091867e-01f, -2.00310916e-01f,
  9.59854573e-02f, -4.12919670e-01f, 8.49389285e-02f, -2.21906617e-01f, -1.75981119e-01f, -3.36563855e-01f, -1.55086324e-01f, -1.77817777e-01f, 3.35571349e-01f, 2.56324679e-01f,
  -9.23423469e-03f, -1.29729897e-01f, 1.67161435e-01f, 2.35761493e-01f, -6.82592764e-02f, 1.70652941e-01f, -5.46604872e-01f, 7.92543367e-02f, -2.32512042e-01f, -2.23900050e-01f,
  2.35382214e-01f, 8.78126025e-02f, -4.88504559e-01f, 2.63884693e-01f, 2.58965164e-01f, -2.50595570e-01f, -2.15125829e-01f, -2.39767700e-01f, 3.87194715e-02f, 4.50616747e-01f,
  -5.49961254e-02f, 2.84162790e-01f, -5.57259381e-01f, -4.31204408e-01f, 2.85511345e-01f, -1.12520970e-01f, -9.61002856e-02f, -2.90139794e-01f, 1.59610093e-01f, -1.02064647e-02f,
  1.26550779e-01f, -2.58103848e-01f, 6.38439134e-02f, -1.59450561e-01f, 2.41261899e-01f, 1.04679368e-01f, 2.72532582e-01f, -1.70282498e-01f, -5.46683133e-01f, -5.20416722e-03f,
  1.50299773e-01f, 7.76517997e-03f, 7.19513595e-02f, 1.84540689e-01f, -3.21064174e-01f, -3.08486760e-01f, 2.95520663e-01f, -3.89226247e-04f, 1.92622602e-01f, 4.00618494e-01f,
  8.14537033e-02f, 3.40938091e-01f, -1.55833125e-01f, -1.97736681e-01f, -5.39198160e-01f, 1.29947364e-01f, 3.15177411e-01f, 3.87971364e-02f, -2.97887474e-01f, -3.91223669e-01f,
  4.79254089e-02f, 7.06864074e-02f, -1.70831665e-01f, -2.40428016e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.71647221e-03f, 8.01084340e-02f, 8.49736750e-01f, 4.42175776e-01f, 3.91271919e-01f, 4.27808493e-01f, -2.37862498e-01f, 1.62129506e-01f, 3.36951643e-01f, 1.62212402e-01f,
  3.91370982e-01f, 6.92889094e-01f, -1.01756883e+00f, -2.01627910e-01f, 2.72847861e-01f, -2.60659844e-01f, -1.69542525e-02f, 7.44355381e-01f, -1.07141726e-01f, 2.90927198e-02f,
  -7.54585683e-01f, -8.76285195e-01f, -3.53279144e-01f, -2.73166262e-02f, 7.15505838e-01f, 1.61475837e-01f, -6.66501641e-01f, -5.34187615e-01f, 7.35471070e-01f, -9.18534771e-02f,
  -5.33041418e-01f, 4.95826483e-01f, 5.19997895e-01f, 2.94958264e-01f, 5.63405633e-01f, 1.61711693e-01f, 1.35995954e-01f, 4.60226029e-01f, 6.58763349e-01f, 3.34439039e-01f,
  4.72809881e-01f, 6.81328893e-01f, 1.98020507e-02f, 7.99064562e-02f, 7.60226190e-01f, -7.58807966e-03f, 6.76293820e-02f, 4.77865696e-01f, 2.96420336e-01f, 6.70907795e-01f,
  4.70227040e-02f, -9.01702523e-01f, 3.90335530e-01f, -2.85330683e-01f, 7.51892924e-01f, 4.46568541e-02f, -3.85099603e-03f, 2.80009955e-01f, -5.08371115e-01f, 7.79330611e-01f,
  2.33588312e-02f, -8.97754908e-01f, 1.29849660e+00f, 9.85610783e-01f, 1.09718591e-01f, -2.16686666e-01f, -5.57100356e-01f, 2.32861757e-01f, 5.01973450e-01f, 9.52406898e-02f,
  1.91033795e-01f, 1.07761398e-01f, 7.48534918e-01f, 2.30098844e-01f, 4.07324970e-01f, 5.21589875e-01f, 8.55983317e-01f, -6.50532722e-01f, 6.99037194e-01f, -1.06586263e-01f,
  3.41438830e-01f, -4.24020857e-01f, 5.60333371e-01f, -2.18263969e-01f, 1.15638876e+00f, -2.34875530e-01f, -3.39780033e-01f, 9.05653775e-01f, 1.57924473e-01f, 7.65430987e-01f,
  4.26967293e-01f, 3.51585329e-01f, -1.01107948e-01f, 1.10172458e-01f, -7.23928034e-01f, 6.73711777e-01f, 3.86847913e-01f, 5.19951060e-02f, 1.43878073e-01f, 7.56736279e-01f,
  7.54178286e-01f, 1.28555447e-01f, -4.27653521e-01f, 1.62955806e-01f, 8.24794948e-01f, 3.56177628e-01f, 3.44071299e-01f, 5.91027975e-01f, 8.38122070e-02f, -9.03581977e-01f,
  4.48349297e-01f, 7.68152654e-01f, 7.92312682e-01f, 9.03292775e-01f, -3.43238235e-01f, -1.30973935e-01f, -6.04552805e-01f, -5.16757488e-01f, -5.31349778e-01f, 2.89107412e-02f,
  4.68583137e-01f, 5.03458977e-01f, -2.16508090e-01f, 7.05653667e-01f, -4.21394229e-01f, -4.12176043e-01f, 5.26653945e-01f, -6.76366985e-01f, 2.62327999e-01f, 1.63946152e-01f,
  4.15774643e-01f, 7.81381249e-01f, 5.56527674e-01f, 8.29004884e-01f, 2.92335212e-01f, 5.05626619e-01f, 1.36546150e-01f, 1.28409401e-01f, 6.46774650e-01f, 3.07274818e-01f,
  -7.50031888e-01f, 5.06352365e-01f, -8.99422526e-01f, 2.66175538e-01f, 2.10916489e-01f, -3.76275569e-01f, -1.13534749e+00f, 8.44695568e-01f, -4.41130877e-01f, 6.36368215e-01f,
  1.02848041e+00f, -3.14405680e-01f, -1.71164259e-01f, -4.02638838e-02f, 2.64431816e-03f, -5.37575066e-01f, -5.57349801e-01f, 9.80190337e-01f, 9.87462938e-01f, 8.82803090e-03f,
  -8.57456028e-02f, 3.63629967e-01f, 5.42902470e-01f, 5.73036931e-02f, 1.71987601e-02f, 5.01566112e-01f, 4.23676550e-01f, 2.61695147e-01f, 1.85142532e-01f, 3.42381418e-01f,
  4.24648747e-02f, 6.10349178e-01f, -1.15531832e-01f, 4.72545028e-01f, 4.60013270e-01f, -1.58177048e-01f, -6.96231306e-01f, -2.29555458e-01f, 6.48309588e-01f, -6.29649997e-01f,
  3.14353943e-01f, -6.12709284e-01f, -4.83645052e-01f, 9.75996315e-01f, 6.63968265e-01f, 2.52424121e-01f, -8.74766052e-01f, -1.15699098e-02f, 1.08788085e+00f, -1.67575359e-01f,
  2.27404628e-02f, 1.55541405e-01f, -1.64288253e-01f, -1.13438964e+00f, -7.14639366e-01f, 8.29879463e-01f, 4.06169027e-01f, 8.44595492e-01f, -1.06469524e+00f, -5.82884736e-02f,
  9.60596874e-02f, -8.43911767e-01f, 7.46235907e-01f, 2.60188043e-01f, 4.68984880e-02f, 6.07800424e-01f, 6.72235429e-01f, -5.60267627e-01f, 1.08896577e+00f, -6.74451888e-01f,
  4.27734822e-01f, 2.79781550e-01f, 3.84095222e-01f, 1.04767561e+00f, 7.57413447e-01f, 1.90058112e-01f, -1.31499976e-01f, 8.86394858e-01f, 7.72477925e-01f, 5.42666197e-01f,
  2.71810412e-01f, -3.65691394e-01f, 4.21712756e-01f, 5.92458695e-02f, 4.53911722e-01f, 4.70480472e-01f, 7.59803355e-02f, 7.27115795e-02f, 3.81391287e-01f, -1.55764803e-01f,
  2.15414628e-01f, 1.01391017e-01f, 1.22785583e-01f, 4.15948302e-01f, 7.61841059e-01f, 2.11747549e-02f, 6.68345332e-01f, 5.66930413e-01f, -2.34474838e-01f, -5.96059740e-01f,
  1.10733651e-01f, -6.24302745e-01f, 5.49344063e-01f, 2.77601182e-01f, 6.51352227e-01f, 7.14851916e-01f, -2.65622526e-01f, -6.31259561e-01f, 2.85746127e-01f, -2.34730452e-01f,
  1.04337478e+00f, 3.48308891e-01f, 1.98996365e-01f, 5.12179613e-01f, 7.19043434e-01f, 7.13747740e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  7.70706952e-01f, 1.97130203e-01f, 3.89031798e-01f, 5.57650805e-01f, 6.96667135e-01f, 3.16528946e-01f, 4.58879858e-01f, 2.53180832e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -3.50450754e-01f, -6.68150127e-01f, 1.98306143e-01f, -2.90146083e-01f, -3.92386794e-01f, 2.66388804e-02f, 3.39617312e-01f, -4.82795596e-01f, 2.24001825e-01f, 4.16956127e-01f,
  -3.81364584e-01f, 2.44350489e-02f, 6.25433266e-01f, -5.16600981e-02f, -4.94219601e-01f, -7.00032175e-01f, -5.72606146e-01f, 6.16775453e-01f, -5.87206125e-01f, -5.78214750e-02f,
  5.58459461e-01f, 1.77830271e-02f, 4.35598582e-01f, 5.00938773e-01f, 5.14582336e-01f, -8.06414425e-01f, -6.27723217e-01f, -5.51831305e-01f, -6.62468791e-01f, 7.48791695e-01f,
  -8.72516930e-01f, -2.49533623e-01f, 2.79456198e-01f, -8.57354030e-02f, -4.75347601e-02f, 5.73870428e-02f, 3.61634374e-01f, -2.10555747e-01f, -4.79934484e-01f, -1.44310057e-01f,
  -1.45985991e-01f, -9.46565419e-02f, -1.68268800e-01f, -5.36096245e-02f, -8.41520965e-01f, 7.92439207e-02f, 7.74580896e-01f, -8.96299899e-01f, 6.78669930e-01f, 2.94313282e-01f,
  -7.31058657e-01f, 5.49427927e-01f, 1.52541444e-01f, -5.01670182e-01f, 8.12474370e-01f, 5.77595890e-01f, 1.43737584e-01f, -7.06569850e-02f, 4.48249519e-01f, -5.50549999e-02f,
  -1.23621690e+00f, 4.28312570e-01f, 1.43023252e-01f, -1.66700423e-01f, -5.41356623e-01f, -5.03576159e-01f, -1.25592267e-02f, -7.67114758e-03f, -6.37051344e-01f, -2.91700602e-01f,
  2.19490200e-01f, 9.51756835e-02f, 1.03098229e-01f, -3.14741105e-01f, 4.43167277e-02f, 1.19123165e-03f, -2.76129931e-01f, 2.84806460e-01f, 7.05052674e-01f, -7.72394180e-01f,
  3.52739722e-01f, 5.26375234e-01f, -5.47278583e-01f, -4.89326179e-01f, 1.37587443e-01f, -5.67874849e-01f, 2.06596732e-01f, -5.46994865e-01f, -8.88525784e-01f, -7.43961811e-01f,
  2.60820746e-01f, -6.54294372e-01f, -7.39107728e-01f, -4.67540085e-01f, 7.96604037e-01f, 3.71267319e-01f, 1.70922771e-01f, 3.04995030e-01f, 2.94210434e-01f, 1.62143186e-01f,
  -6.74881563e-02f, 3.69209111e-01f, 2.22593859e-01f, -1.84140541e-02f, -2.16935109e-02f, -6.80730820e-01f, 2.86545288e-02f, -6.29426599e-01f, -4.12927896e-01f, -8.69468391e-01f,
  -7.90836886e-02f, 2.79428273e-01f, -4.17860568e-01f, -5.38988374e-02f, -4.70036834e-01f, -8.50275815e-01f, -4.50882971e-01f, 3.12167585e-01f, 7.21203268e-01f, 4.40906376e-01f,
  7.51019478e-01f, -3.59262466e-01f, -8.72743666e-01f, 7.67874360e-01f, -1.51597932e-01f, -9.63222563e-01f, -7.98388362e-01f, -5.85463881e-01f, -9.99799371e-02f, -2.59875774e-01f,
  -1.86049163e-01f, 4.62406963e-01f, -2.24129349e-01f, -1.74404755e-01f, 8.90520066e-02f, 3.99930984e-01f, 4.96794671e-01f, 3.61173749e-01f, 3.81080717e-01f, 5.06171227e-01f,
  6.96172535e-01f, 5.83301306e-01f, -5.44372737e-01f, 6.34586275e-01f, -3.98076653e-01f, -7.49047220e-01f, 6.06289148e-01f, 7.33570874e-01f, -5.05132675e-01f, 3.64623874e-01f,
  5.16618073e-01f, 3.22456747e-01f, -2.25521345e-02f, -6.57620609e-01f, -5.92197239e-01f, -2.40836099e-01f, 1.00511801e+00f, -2.29276419e-01f, -7.23238111e-01f, -1.27297878e-01f,
  -3.37423176e-01f, 3.24562579e-01f, 2.62364298e-01f, 1.96398064e-01f, 3.47198099e-01f, 8.00485462e-02f, 7.19887018e-02f, 2.76292376e-02f, 1.77023336e-01f, -5.09413123e-01f,
  2.59488761e-01f, -1.09996058e-01f, 5.85962772e-01f, -2.10762605e-01f, 3.49387556e-01f, 9.26361680e-01f, -1.28096985e-02f, 4.94715691e-01f, 6.24400437e-01f, 4.37051237e-01f,
  6.55480385e-01f, 3.68491620e-01f, -7.30076849e-01f, -7.04959989e-01f, 3.83996546e-01f, 7.79687583e-01f, -1.45521715e-01f, -8.79343629e-01f, -4.35190409e-01f, 2.56117702e-01f,
  -7.02238500e-01f, -1.27863348e-01f, 1.85801983e-01f, 3.50536972e-01f, 1.52140021e-01f, 2.59802490e-01f, -1.70807719e-01f, 1.49811851e-02f, 3.05941671e-01f, 9.83279347e-02f,
  -2.28074506e-01f, 2.01410159e-01f, 1.00952037e-01f, -2.08459526e-01f, -7.96984315e-01f, -3.50525171e-01f, 7.61054754e-01f, 2.86880970e-01f, 4.78177607e-01f, 4.74525541e-01f,
  3.28276396e-01f, -6.66027546e-01f, 5.06145656e-01f, 4.65199947e-01f, 2.84967870e-01f, -1.88269898e-01f, -1.06126499e+00f, 3.80577475e-01f, -6.94273114e-01f, -1.00936139e+00f,
  4.22956795e-01f, -3.66823912e-01f, 2.88103104e-01f, 3.38405997e-01f, -1.22681372e-01f, 2.76941150e-01f, 2.97374815e-01f, 4.35617343e-02f, 2.23259702e-01f, -9.69863310e-02f,
  1.09937333e-01f, 1.56551585e-01f, 1.89336568e-01f, 4.19181377e-01f, 3.32694024e-01f, 3.98736238e-01f, -5.40339470e-01f, -5.95335603e-01f, 6.21229708e-01f, -7.41468132e-01f,
  -4.64886665e-01f, -4.71561611e-01f, -8.06311011e-01f, 2.99557876e-02f, 8.01276714e-02f, -1.46227509e-01f, -9.47222039e-02f, 2.56588757e-01f, -1.13638550e-01f, -4.37817395e-01f,
  9.61473733e-02f, -5.08273244e-02f, 5.27927697e-01f, -8.35739493e-01f, 8.29924643e-01f, -9.32470083e-01f, -2.79407531e-01f, 2.29583845e-01f, -2.14447267e-03f, -3.09429437e-01f,
  -4.35552061e-01f, -4.61950637e-02f, 1.22102268e-01f, -4.85829562e-01f, 7.85716549e-02f, -4.08422112e-01f, -2.54973829e-01f, -4.31184322e-01f, -3.85754287e-01f, -3.29135686e-01f,
  -5.40459991e-01f, 5.48429430e-01f, 2.09377766e-01f, -2.46450007e-01f, -2.13092074e-01f, -2.32639953e-01f, 7.16140985e-01f, -3.71584654e-01f, -4.06338841e-01f, -5.17683685e-01f,
  -8.41598690e-01f, 3.55083406e-01f, 3.00671726e-01f, 5.68420410e-01f, -8.73036206e-01f, -2.57846177e-01f, 4.04464841e-01f, -4.00396466e-01f, -1.64031401e-01f, -2.20663100e-01f,
  -3.97334605e-01f, 1.26713976e-01f, 5.98273933e-01f, 2.19585538e-01f, -4.08025622e-01f, -2.35330939e-01f, 8.64811316e-02f, 1.76110625e-01f, -5.71482480e-02f, 3.81770134e-02f,
  5.75454831e-01f, 3.08951497e-01f, -6.29538178e-01f, 5.33331871e-01f, -4.69972283e-01f, 5.80504775e-01f, 4.44092393e-01f, 5.09075642e-01f, 3.24583173e-01f, -4.59601402e-01f,
  -6.45180464e-01f, -3.42755675e-01f, -7.98307121e-01f, -6.86735809e-01f, 7.31072426e-01f, -7.02849269e-01f, -1.23668335e-01f, -3.10387015e-01f, -4.17674959e-01f, 6.94503963e-01f,
  3.73274148e-01f, -2.23107323e-01f, 1.66249871e-01f, 1.94590732e-01f, 2.48800606e-01f, -9.32695270e-02f, 3.49480174e-02f, 4.31782693e-01f, -2.50198156e-01f, 2.84971178e-01f,
  -6.55927733e-02f, 3.12015531e-03f, -2.75327444e-01f, 5.37137389e-01f, -1.41644612e-01f, 5.27381003e-01f, 3.51426482e-01f, -4.36648190e-01f, 4.66443270e-01f, -9.16156545e-02f,
  -6.55678988e-01f, 7.89658260e-03f, -6.90703392e-01f, 6.94019914e-01f, -2.82455403e-02f, 5.05721867e-01f, 5.78050315e-01f, 5.40767491e-01f, -8.93821597e-01f, 1.66956559e-01f,
  -8.21251571e-01f, -1.13567364e+00f, 8.82074311e-02f, 3.66939642e-02f, -1.93020344e-01f, -6.13738358e-01f, 4.24265236e-01f, 4.62959372e-02f, -4.57388878e-01f, -4.23635632e-01f,
  -6.71831146e-02f, -1.02933288e-01f, -1.43776283e-01f, 2.65732557e-02f, 6.29766464e-01f, -5.42813063e-01f, -6.10130847e-01f, -3.83387581e-02f, 1.85815334e-01f, -5.33616245e-01f,
  2.53790706e-01f, -3.24144393e-01f, -7.35267282e-01f, 1.87592521e-01f, -4.15567309e-01f, -4.99860495e-01f, -1.02388465e+00f, 6.46453440e-01f, -1.07928944e+00f, 5.39379597e-01f,
  2.78849363e-01f, -3.92610908e-01f, -3.64326537e-01f, -1.23898044e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.27109304e-01f, -1.05571330e-01f, 2.70490032e-02f, 2.96604820e-02f, 9.31888670e-02f, 6.72857910e-02f, -1.81940541e-01f, 1.97440222e-01f, 3.95559072e-02f, 6.50606900e-02f,
  -1.12867981e-01f, -2.18561059e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    