/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.25650662e-01f, 1.27436429e-01f, 8.34195465e-02f, 1.65169343e-01f, 2.20885370e-02f, 9.74907875e-02f, 4.61517155e-01f, 2.28487939e-01f, 3.69457528e-02f, 1.83466226e-01f,
  -1.70648918e-01f, -4.13027585e-01f, -3.77196312e-01f, -2.83050627e-01f, -1.16913989e-01f, 2.86859930e-01f, 2.62652010e-01f, -8.26574415e-02f, -1.46608382e-01f, -2.69716047e-02f,
  -5.77386729e-02f, 1.98566213e-01f, 6.36492521e-02f, 4.04537246e-02f, 6.84299916e-02f, -2.56705821e-01f, 1.19696677e-01f, 1.05375342e-01f, -1.42083317e-01f, 1.27893865e-01f,
  -5.70628643e-02f, 1.36218950e-01f, -8.40293467e-02f, -1.11862719e-01f, -8.37901533e-02f, -6.33987114e-02f, -3.36645134e-02f, 1.01492768e-02f, -5.01919389e-02f, -2.91931676e-03f,
  2.01978125e-02f, -8.76744539e-02f, -4.47339416e-02f, -8.63578990e-02f, 9.36910231e-03f, 9.98628419e-03f, -6.34794263e-03f, 8.18117037e-02f, -6.78011328e-02f, -4.71414113e-03f,
  -1.65393382e-01f, 6.06695935e-02f, 1.31506532e-01f, -7.38221481e-02f, 3.05530392e-02f, -1.84829935e-01f, 2.18637437e-02f, -1.05800733e-01f, -1.11290216e-01f, 8.28847811e-02f,
  1.41305223e-01f, -3.95234674e-02f, -2.08940599e-02f, 3.09560690e-02f, 5.11387782e-03f, -1.49464002e-03f, 2.29110979e-02f, 7.84849524e-02f, 3.95339429e-02f, 3.94023731e-02f,
  -1.15956664e-01f, 3.04905120e-02f, 3.49980816e-02f, 4.77406606e-02f, -1.90843581e-04f, 3.62719968e-02f, 4.09373753e-02f, -2.17616092e-02f, 9.30058118e-03f, 4.69600549e-03f,
  -6.38874397e-02f, -5.79888038e-02f, 7.76921138e-02f, -2.72527076e-02f, -9.40202922e-02f, 3.14663164e-02f, 5.91581278e-02f, -2.83922777e-02f, -5.80425449e-02f, 6.08659759e-02f,
  -4.84789051e-02f, -1.64370567e-01f, 2.93564573e-02f, -7.92112648e-02f, 1.48576694e-02f, -3.81698273e-02f, -2.14078184e-02f, 1.63834281e-02f, -9.38629285e-02f, 7.53991771e-04f,
  -1.16974443e-01f, -9.97486617e-03f, 1.77155789e-02f, 1.35108614e-02f, 3.77672948e-02f, -6.60809800e-02f, -5.73322996e-02f, -1.01125754e-01f, 2.20548883e-02f, -3.42404610e-03f,
  1.04935676e-01f, 7.67514259e-02f, 4.03391309e-02f, -3.72717381e-02f, -6.82558492e-02f, -9.66148674e-02f, -7.41080418e-02f, -1.56651977e-02f, -4.41140123e-02f, 2.21136943e-01f,
  -3.26393731e-02f, 2.01600432e-01f, 2.71942019e-01f, 1.50632575e-01f, 8.30333605e-02f, -1.58756971e-01f, -3.47008258e-01f, -2.00433776e-01f, -8.93385932e-02f, 1.24490019e-02f,
  6.45843670e-02f, -1.27486154e-01f, 9.25957784e-02f, -6.22258447e-02f, -4.31263447e-02f, -1.41201317e-02f, 2.23499030e-01f, 1.35534465e-01f, -1.94861576e-01f, -2.02019244e-01f,
  -1.09380968e-01f, -4.88095358e-02f, -4.57285866e-02f, 1.18077725e-01f, 3.20769608e-01f, 9.31857377e-02f, 2.08542228e-01f, 2.80568391e-01f, 1.71297088e-01f, 4.93764967e-01f,
  1.73608616e-01f, 3.11230481e-01f, -1.67481050e-01f, -3.96915451e-02f, 9.58484132e-03f, -5.81793226e-02f, -5.26933819e-02f, -2.27791183e-02f, 1.87173001e-02f, -5.13109006e-02f,
  8.36177692e-02f, 2.40797419e-02f, 1.01555243e-01f, -5.69784194e-02f, 8.21965095e-03f, -8.74623284e-02f, -7.98233077e-02f, 4.26491126e-02f, -1.17746465e-01f, -7.66816363e-02f,
  -4.73840497e-02f, -9.72169340e-02f, -8.81190673e-02f, -7.50572011e-02f, -2.51145046e-02f, -1.61962770e-02f, -6.01672009e-02f, 8.09362531e-02f, 3.83141786e-02f, 1.73840821e-02f,
  -1.16871454e-01f, -2.66492683e-02f, -1.01400159e-01f, -5.75532131e-02f, -8.17665160e-02f, -2.20618341e-02f, 1.53746700e-03f, -5.16577251e-02f, -8.14794227e-02f, -1.90051466e-01f,
  3.22040804e-02f, -5.28074950e-02f, -4.01782282e-02f, 2.15288140e-02f, -6.20654263e-02f, -8.10635090e-02f, -3.47577482e-02f, -1.66280176e-02f, -4.69230935e-02f, -5.62630855e-02f,
  -6.80718571e-02f, -3.64462174e-02f, 3.21485177e-02f, -3.03653385e-02f, 2.46240338e-03f, -1.50549719e-02f, -1.35000095e-01f, -7.13412464e-02f, -4.58459519e-02f, -6.03581741e-02f,
  -2.06516474e-01f, 2.88669411e-02f, 1.26911141e-02f, -5.27197458e-02f, 4.29181606e-02f, 4.86818999e-02f, 8.32675919e-02f, 2.53934488e-02f, 1.17447034e-01f, 7.17345451e-04f,
  -3.55009828e-03f, -3.48592028e-02f, 7.46171772e-02f, -7.21936822e-02f, -5.75489253e-02f, -9.55474973e-02f, -1.21143997e-01f, -5.14234714e-02f, -3.68492976e-02f, -6.33366480e-02f,
  -1.68790445e-01f, -2.05586344e-01f, -2.43894294e-01f, -1.67371228e-01f, -5.54300398e-02f, -1.32235870e-01f, -3.22321467e-02f, -1.15966730e-01f, -2.09619626e-01f, -2.16115817e-01f,
  -4.13121790e-01f, 3.10285222e-02f, -8.93274844e-02f, -1.65577486e-01f, -4.26195562e-02f, -2.09263086e-01f, -2.24392176e-01f, -4.73213941e-02f, -2.94384584e-02f, -1.29852191e-01f,
  1.32760659e-01f, 2.27434129e-01f, 2.08763197e-01f, 5.83253875e-02f, -6.50097206e-02f, -1.98140800e-01f, -2.93797880e-01f, -1.34710148e-01f, -7.52665401e-02f, 1.23961695e-01f,
  1.49896473e-01f, 1.11643292e-01f, 4.47981916e-02f, 2.04907417e-01f, 1.19460411e-01f, 7.83955753e-02f, 1.12459436e-01f, 6.02558553e-02f, 1.49099484e-01f, 1.56268105e-01f,
  1.20626494e-01f, 6.93450421e-02f, 1.07851915e-01f, 1.36094168e-01f, 1.94957048e-01f, 6.74095610e-03f, 2.98439376e-02f, 9.48266089e-02f, 6.50150925e-02f, 5.76713122e-02f,
  1.73299581e-01f, 1.02833286e-01f, 1.19271293e-01f, 1.83470607e-01f, 1.27889737e-01f, 1.30887061e-01f, 6.46391809e-02f, 1.58666432e-01f, 1.36078551e-01f, 1.52164429e-01f,
  8.66324529e-02f, 1.79888841e-04f, 7.99200833e-02f, 4.19389680e-02f, 6.80718198e-02f, 5.14369272e-02f, 2.03358769e-01f, 1.40955478e-01f, 3.71974930e-02f, 1.57944441e-01f,
  -2.75727540e-01f, -1.40056625e-01f, -1.54855192e-01f, -1.25187740e-01f, -9.63559225e-02f, -7.03935791e-03f, -4.98257577e-02f, 2.21956316e-02f, -9.19940472e-02f, -6.69970885e-02f,
  -8.17110911e-02f, -2.78373640e-02f, -1.08687982e-01f, -1.31793693e-01f, -4.38691713e-02f, -8.11229199e-02f, -3.50821055e-02f, -8.84072110e-02f, -6.48158267e-02f, -7.68683106e-02f,
  -5.94120398e-02f, -8.01566150e-03f, -5.63067384e-02f, 1.09033749e-01f, -1.27841860e-01f, -1.15959130e-01f, -9.36070755e-02f, -7.73054436e-02f, -7.64609948e-02f, -1.02690510e-01f,
  1.87768713e-01f, 1.41949192e-01f, 2.65399809e-03f, 3.42378323e-03f, 8.85587931e-02f, 1.19005896e-01f, 1.36109725e-01f, 9.51021835e-02f, 1.56828463e-01f, 1.51893809e-01f,
  1.29813612e-01f, 7.12160468e-02f, 8.73482451e-02f, 1.66003287e-01f, 4.21120375e-02f, 4.77276295e-02f, -3.84243503e-02f, 1.39304996e-01f, 7.43529350e-02f, 1.01008385e-01f,
  1.10323161e-01f, 2.49048322e-02f, -9.43151116e-02f, 9.19352993e-02f, 1.44700736e-01f, -1.42578399e-02f, 5.92240319e-02f, 1.25362068e-01f, 6.86280876e-02f, 8.05290043e-02f,
  -4.88676369e-01f, -4.81584013e-01f, 5.82390845e-01f, -1.31523073e-01f, 1.22647963e-01f, 2.89103389e-01f, -3.02029978e-02f, -5.75052574e-02f, -4.57134470e-02f, 1.93866063e-02f,
  -2.28258409e-02f, 1.46921962e-01f, 2.19773069e-01f, 1.80344030e-01f, 1.65373087e-01f, 3.12872045e-02f, 1.36787027e-01f, 2.88094640e-01f, 4.56081718e-01f, 1.41394839e-01f,
  -1.62539005e-01f, -2.51343906e-01f, -1.84556842e-01f, -1.65454950e-02f, -1.28142938e-01f, 1.91785648e-01f, 9.09360275e-02f, 3.72967944e-02f, -7.86447525e-03f, -1.67126790e-01f,
  3.18083912e-01f, -1.00960553e-01f, 3.48814964e-01f, 6.81028282e-03f, 1.51408255e-01f, 1.00074060e-01f, 1.75536588e-01f, 1.98451757e-01f, 1.71480358e-01f, 8.29956606e-02f,
  9.75669250e-02f, 5.79330474e-02f, 1.65612414e-01f, 1.37951180e-01f, 1.32876828e-01f, 1.11228719e-01f, 1.14723012e-01f, 1.05775706e-01f, 1.35398880e-01f, 2.18793273e-01f,
  3.65049392e-02f, 9.91237685e-02f, 1.74787953e-01f, 1.34850413e-01f, 1.35560542e-01f, 8.54664072e-02f, 1.89863577e-01f, 1.57111064e-01f, 2.12258607e-01f, -2.95775607e-02f,
  -4.94259782e-02f, -2.37808637e-02f, -5.73636480e-02f, -1.06210269e-01f, -3.58760133e-02f, -1.38459140e-02f, -1.15259103e-02f, -3.96830924e-02f, -5.14902435e-02f, -6.52819574e-02f,
  3.93163562e-02f, -8.47709104e-02f, 1.59107707e-02f, -6.18049949e-02f, -8.23013186e-02f, -1.01952590e-02f, -3.94037366e-02f, -1.29074827e-01f, -2.41263993e-02f, -2.84324139e-02f,
  -5.15029319e-02f, 1.21666202e-02f, -8.79095569e-02f, -1.36310887e-02f, -9.93082598e-02f, -1.10296696e-01f, -6.81975260e-02f, -2.50337385e-02f, -1.37432441e-01f, -1.24272510e-01f,
  3.08001284e-02f, 3.06314796e-01f, 5.35199046e-02f, 7.18599409e-02f, 1.40108585e-01f, 1.86526358e-01f, 8.58708173e-02f, 1.15892798e-01f, 1.19770542e-01f, 9.03918147e-02f,
  1.00215510e-01f, 9.03280601e-02f, 1.26089931e-01f, 1.07286803e-01f, 1.27026871e-01f, 9.21078846e-02f, -1.70551252e-03f, 8.78194794e-02f, 1.28030375e-01f, 8.06348324e-02f,
  5.94661087e-02f, 1.61273330e-02f, 5.65559603e-02f, 1.07131094e-01f, 1.33142829e-01f, 1.23530813e-01f, 1.65718675e-01f, 1.31380036e-01f, 1.70421034e-01f, -3.70251536e-02f,
  2.51861632e-01f, 7.77497515e-02f, -5.40420234e-01f, 4.40793261e-02f, -8.27019140e-02f, -1.46201000e-01f, 3.49161103e-02f, 1.34667352e-01f, 1.38949081e-01f, 9.84471142e-02f,
  1.16098560e-01f, 1.16678357e-01f, 9.95985270e-02f, 1.52340278e-01f, -2.13353299e-02f, -2.00188279e-01f, -3.23255002e-01f, -2.69646317e-01f, -8.25011134e-02f, 7.76592791e-02f,
  5.63676059e-02f, -3.84311639e-02f, -1.50984135e-02f, 1.13719888e-01f, 4.54081260e-02f, 1.82806060e-01f, -1.42459914e-01f, -1.28961816e-01f, 1.97053105e-02f, -1.32127121e-01f,
  1.44529521e-01f, 9.90779046e-03f, 1.14411347e-01f, 1.18746616e-01f, 3.00758258e-02f, 1.32208109e-01f, 1.10610515e-01f, 7.97315463e-02f, 8.73697028e-02f, 9.16826949e-02f,
  1.34600952e-01f, 1.15337655e-01f, -2.41734758e-02f, 3.89736667e-02f, 7.32148066e-02f, 9.10819396e-02f, 1.57222822e-02f, -3.55323381e-03f, 5.08943163e-02f, 5.46883941e-02f,
  8.13068449e-02f, -1.09521747e-01f, -4.76767980e-02f, 1.85808502e-02f, 7.44103268e-02f, -9.72824693e-02f, 1.50350658e-02f, 1.24951452e-01f, 9.59962681e-02f, 2.69353986e-01f,
  -5.30664735e-02f, -9.95501056e-02f, -1.19838350e-01f, -6.63458630e-02f, -1.02952398e-01f, -8.93249363e-02f, -9.09883827e-02f, -2.90029142e-02f, -9.21648648e-03f, -1.10412883e-02f,
  1.88772418e-02f, -4.89060953e-02f, -7.20728263e-02f, 7.55763948e-02f, -8.09000954e-02f, -2.62235813e-02f, -1.31904781e-01f, 5.62882498e-02f, -1.02471292e-01f, -1.46727329e-02f,
  1.73288640e-02f, -3.08726542e-03f, -2.39850627e-03f, -2.15740930e-02f, -1.03559144e-01f, -1.26411363e-01f, -1.37662059e-02f, -7.35093206e-02f, -1.14112467e-01f, -1.21345185e-02f,
  4.07780588e-01f, -1.72897011e-01f, 1.61776692e-01f, 1.92888021e-01f, 1.39882997e-01f, 7.50816688e-02f, 8.66818875e-02f, 6.03757240e-02f, 3.69260237e-02f, 5.64943440e-02f,
  1.29210595e-02f, 8.42359513e-02f, 9.73058678e-03f, 3.73802148e-02f, 1.05177745e-01f, 6.80874437e-02f, 1.43955424e-01f, -3.99862118e-02f, 4.90359329e-02f, 4.51761335e-02f,
  6.16301671e-02f, 1.14153162e-01f, 1.47908077e-01f, 1.53227836e-01f, -3.33300121e-02f, 1.24957725e-01f, 9.45396870e-02f, 1.20570987e-01f, 1.78637981e-01f, 2.53753603e-01f,
  -2.06386074e-01f, -1.01240948e-01f, 1.86484195e-02f, -2.94653714e-01f, -4.11317162e-02f, 1.41812399e-01f, 2.70214945e-01f, 7.20368773e-02f, -2.18743429e-01f, -1.50405809e-01f,
  -2.48473093e-01f, -1.24095365e-01f, 6.16790541e-02f, 1.42633751e-01f, 2.93366700e-01f, 3.77732724e-01f, 2.59701282e-01f, 3.65892678e-01f, 3.96894723e-01f, 1.03690200e-01f,
  1.26064032e-01f, -2.90134586e-02f, -4.00105715e-02f, 1.27557442e-01f, -2.07538500e-01f, 4.22291607e-02f, -8.17628950e-02f, -6.47289529e-02f, -2.81984340e-02f, -2.37335324e-01f,
  -1.00244679e-01f, -3.24745417e-01f, 5.03201038e-02f, -1.31087825e-01f, -1.16370797e-01f, -1.33989617e-01f, -6.84378371e-02f, -1.85022369e-01f, -8.30087215e-02f, -4.05809693e-02f,
  -2.13024914e-01f, -1.57124579e-01f, 1.26811201e-02f, -9.66753438e-02f, -3.22502702e-02f, -7.69487470e-02f, -7.24061579e-02f, -4.22936752e-02f, -9.10324454e-02f, -1.66688740e-01f,
  -1.78320073e-02f, -1.43481836e-01f, -8.03755969e-02f, 3.54479603e-03f, -9.53742042e-02f, -1.15631325e-02f, -1.44417703e-01f, -4.83337119e-02f, -6.56772628e-02f, -1.09952576e-01f,
  3.14412415e-02f, 8.99256766e-02f, -4.02243808e-02f, -3.95980943e-03f, 7.46556520e-02f, 1.48113184e-02f, 5.10567054e-02f, 1.30381420e-01f, 7.01212287e-02f, -7.57144717e-03f,
  2.05220357e-02f, 1.75887179e-02f, 3.59442495e-02f, 5.69479130e-02f, 3.39997597e-02f, -1.69633552e-02f, 1.13841027e-01f, 5.39180562e-02f, 3.58932912e-02f, 5.75972954e-03f,
  -1.40394398e-03f, 6.11251444e-02f, 4.23934236e-02f, 5.21311052e-02f, -7.25307036e-03f, 2.56789029e-02f, 1.08004073e-02f, -2.78696362e-02f, -1.61276720e-02f, 1.74232125e-02f,
  -4.27375585e-02f, 4.29609939e-02f, -5.00405021e-02f, -1.09457551e-02f, -4.21705991e-02f, -7.47095868e-02f, -1.06284082e-01f, -5.05595990e-02f, -2.33957954e-02f, -6.81049423e-03f,
  -5.00745252e-02f, 1.51895499e-02f, 3.91302668e-02f, -6.84095919e-02f, 9.58922319e-03f, -8.82199183e-02f, 1.37988590e-02f, 7.13551417e-03f, 7.30119050e-02f, -1.07767090e-01f,
  -5.15471138e-02f, 1.08117975e-01f, -1.58530697e-02f, 5.05295582e-02f, 6.44045696e-02f, 2.10737392e-01f, 5.33943474e-02f, -5.05431630e-02f, 9.77992192e-02f, 6.17732517e-02f,
  -5.90280533e-01f, -5.01139462e-01f, -1.28778890e-01f, 8.55281577e-02f, 8.34549591e-02f, -1.62443697e-01f, -3.35054904e-01f, -1.53822154e-01f, 1.14579022e-01f, -1.34721264e-01f,
  -8.78487602e-02f, 4.50164778e-03f, -9.47979242e-02f, -3.77458595e-02f, -1.88452244e-01f, -3.53909194e-01f, -4.40884270e-02f, -4.71157134e-02f, 3.79684754e-02f, 1.16215944e-01f,
  1.92327246e-01f, -3.09869591e-02f, -7.88212866e-02f, -1.46695236e-02f, -6.77553192e-02f, -3.32333171e-03f, -1.21487752e-01f, 1.31961396e-02f, -1.87510476e-01f, -1.78280681e-01f,
  -2.47587577e-01f, -1.11923225e-01f, -5.21974228e-02f, -7.37305433e-02f, -6.27321303e-02f, -1.27829164e-01f, -1.78218842e-01f, -1.18145213e-01f, -6.06397763e-02f, -1.58781588e-01f,
  9.73702222e-03f, 1.81391630e-02f, -6.09162636e-02f, 2.64987126e-02f, -8.43506008e-02f, 1.25610633e-02f, 1.16822870e-04f, -7.41423592e-02f, -5.86229786e-02f, -6.81746081e-02f,
  4.67135943e-02f, -6.37663603e-02f, -1.43705368e-01f, -1.44818380e-01f, -1.28589928e-01f, -1.01025835e-01f, -2.11458921e-01f, -1.37476325e-01f, -1.49018466e-01f, -3.16910356e-01f,
  -9.31546651e-03f, -3.29239443e-02f, 1.00271933e-01f, 7.79449269e-02f, -1.02991909e-02f, -2.50237971e-03f, 8.06007162e-02f, 3.73144224e-02f, 1.11162312e-01f, -2.83983350e-03f,
  6.12729937e-02f, 2.97291726e-02f, 2.10957024e-02f, -1.12783268e-01f, 3.37527096e-02f, -1.04521424e-01f, -8.90936796e-03f, -6.32453784e-02f, 2.77479514e-02f, -1.84449786e-03f,
  2.38516256e-02f, -1.87895931e-02f, 1.71619058e-02f, 6.48147464e-02f, 1.93675328e-02f, 3.55626829e-02f, 1.86001174e-02f, 8.17442462e-02f, 8.84439051e-02f, 6.90366998e-02f,
  -9.51245129e-02f, -2.83768270e-02f, -1.91458032e-01f, -1.26763016e-01f, -2.89554354e-02f, -2.57664509e-02f, -6.53633922e-02f, -8.51185843e-02f, -1.54914558e-01f, -8.60944018e-02f,
  -3.75128053e-02f, -6.34544119e-02f, -1.41697556e-01f, -2.42847577e-02f, 3.39506231e-02f, -5.21321185e-02f, 5.69584733e-03f, -2.66440772e-02f, -5.80490083e-02f, -4.52417508e-02f,
  -3.53544615e-02f, -8.91129598e-02f, -7.90100247e-02f, -1.44856796e-01f, -2.33638994e-02f, -1.26472056e-01f, -7.70588219e-02f, -1.11092925e-01f, -2.59270012e-01f, -3.30908269e-01f,
  -3.38381469e-01f, -2.25750342e-01f, -4.10338044e-01f, 1.47575513e-02f, -1.75048523e-02f, -2.06010938e-01f, -3.21425736e-01f, -3.03459018e-02f, 1.49211749e-01f, -1.11405887e-01f,
  -4.19047065e-02f, 1.21312037e-01f, -4.78457026e-02f, -8.39199573e-02f, -2.97384799e-01f, -3.28098327e-01f, -1.52411729e-01f, -3.22636068e-01f, -3.40922296e-01f, -4.67487238e-02f,
  -1.40604505e-03f, -4.55130488e-02f, -1.97398245e-01f, 2.50789858e-02f, 6.45644143e-02f, 8.47960562e-02f, 2.44247857e-02f, -9.52599794e-02f, -1.26313493e-01f, 1.47739738e-01f,
  -3.78747404e-01f, -1.22311108e-01f, -4.69148979e-02f, -2.97750756e-02f, -1.60918627e-02f, -1.54293478e-01f, -1.71111465e-01f, -9.14347246e-02f, 2.55896263e-02f, -1.76490750e-02f,
  -6.84006736e-02f, -4.05718237e-02f, -7.91897997e-02f, 7.62391463e-03f, -7.13599324e-02f, -1.46164503e-02f, 5.05409837e-02f, -5.22969179e-02f, -1.35585710e-01f, -1.23459309e-01f,
  -8.20515025e-03f, -1.39946491e-01f, -1.99287802e-01f, -1.25218689e-01f, -2.03278325e-02f, -1.44193033e-02f, -1.40765309e-01f, 3.06293671e-03f, -5.47949858e-02f, -3.02723516e-03f,
  -2.36733351e-02f, 7.08335787e-02f, 8.81126896e-02f, -1.44821554e-02f, 5.55736497e-02f, 7.61495456e-02f, 2.22535152e-02f, 1.19400889e-01f, 3.47575806e-02f, 2.70938780e-02f,
  3.27380188e-02f, 1.90997962e-02f, 1.37419421e-02f, -1.94300932e-03f, -1.32362789e-03f, -1.49092944e-02f, 1.55753717e-02f, -2.42555328e-03f, 7.69287422e-02f, 1.55527703e-02f,
  2.93504819e-02f, 7.90433288e-02f, 2.42159422e-02f, -2.18684487e-02f, 5.41793182e-02f, 5.02307946e-03f, -2.73909443e-03f, 8.34757611e-02f, 7.60217458e-02f, 2.74974629e-02f,
  -1.12154409e-01f, -4.63519692e-02f, -1.08198583e-01f, -1.33457527e-01f, -1.12508059e-01f, -2.87045743e-02f, -3.97108719e-02f, -2.00608559e-02f, -6.71153069e-02f, -1.65434867e-01f,
  -1.33891344e-01f, -1.13356762e-01f, -1.11824304e-01f, -5.94686754e-02f, -9.33688059e-02f, 2.53106486e-02f, -1.10319607e-01f, -3.83488797e-02f, 8.53696465e-03f, -9.17588696e-02f,
  -2.42349859e-02f, -1.90438539e-01f, -1.42982349e-01f, -1.40602499e-01f, -1.29514545e-01f, -1.50037721e-01f, -1.97419167e-01f, -5.99226244e-02f, -2.13256299e-01f, -2.42748797e-01f,
  -1.42152742e-01f, -1.24056138e-01f, 2.05763176e-01f, -1.71695679e-01f, 5.11755887e-03f, 1.61345422e-01f, 3.33094567e-01f, 2.60298885e-02f, -6.42180517e-02f, -4.45780754e-02f,
  -1.73769042e-01f, -1.93489313e-01f, -1.05475962e-01f, 4.70642671e-02f, 1.11118168e-01f, 1.39571071e-01f, 2.79271752e-01f, 3.15899283e-01f, 1.88038170e-01f, 1.79689452e-01f,
  -1.45408371e-02f, -1.16522573e-02f, -1.07596532e-01f, 1.52768463e-01f, 1.08716026e-01f, 3.52647118e-02f, 1.54966623e-01f, 2.35598162e-02f, 1.84919789e-01f, 2.01251671e-01f,
  -3.52174081e-02f, -6.49340153e-02f, 1.02267332e-01f, -1.63280629e-02f, -1.33610740e-01f, -2.61443164e-02f, 4.84823138e-02f, 9.68906134e-02f, -6.18685596e-02f, 2.98974812e-02f,
  -4.84516937e-03f, 1.35186007e-02f, 5.84894679e-02f, 3.45736742e-03f, -4.94392626e-02f, 5.42323664e-02f, 8.69444311e-02f, 1.42180845e-01f, 1.36084333e-01f, -7.71184340e-02f,
  5.53705776e-03f, -3.64000001e-03f, 6.09523430e-02f, 1.18829280e-01f, 8.00182000e-02f, 6.74676821e-02f, 1.25718504e-01f, 1.48916066e-01f, 2.10443869e-01f, 1.30652025e-01f,
  6.00111336e-02f, -6.71811998e-02f, -5.76129332e-02f, -3.50961238e-02f, -6.99342936e-02f, -5.55313453e-02f, -8.43611881e-02f, -8.52532163e-02f, -9.90194008e-02f, 2.75680125e-02f,
  -1.60860002e-01f, -9.29577500e-02f, -1.09956473e-01f, -1.08623832e-01f, -8.80760700e-02f, -5.23442887e-02f, -1.63186248e-02f, -6.73820600e-02f, -8.86657462e-02f, -1.15299456e-01f,
  -6.86506331e-02f, -3.60369906e-02f, -1.36517614e-01f, 4.08284217e-02f, -9.12606120e-02f, 3.92515510e-02f, -4.31552380e-02f, -5.32308593e-02f, -4.72097173e-02f, -1.24570332e-01f,
  -6.82302266e-02f, -3.79368961e-02f, 4.32404839e-02f, 1.00153796e-01f, -1.26346825e-02f, 5.50592802e-02f, -2.63263732e-02f, 2.34399009e-02f, 1.55323802e-03f, 8.18166733e-02f,
  -6.08616024e-02f, 7.51968622e-02f, -4.26643528e-02f, 6.44298047e-02f, 8.87000710e-02f, 8.62208381e-03f, -4.57742549e-02f, 1.12801686e-01f, 3.26910987e-02f, -1.04856482e-02f,
  -4.22218535e-03f, 8.47300738e-02f, 2.18452606e-02f, 9.13993046e-02f, 2.03087702e-02f, 1.38834059e-01f, 1.47215173e-01f, 1.68600738e-01f, 1.13709949e-01f, 1.80889711e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  8.64261746e-01f, 5.40518522e-01f, 1.51645288e-01f, 5.42084932e-01f, 2.92928547e-01f, 3.09844285e-01f, 2.04468206e-01f, 6.43823221e-02f, 1.52310282e-01f, 3.08833331e-01f,
  3.10826272e-01f, 2.71312267e-01f, 1.95914596e-01f, 1.84201822e-01f, 2.40642652e-01f, 1.07801564e-01f, -4.59657311e-02f, 6.94481377e-03f, -3.37438099e-02f, 1.21834204e-01f,
  6.50730282e-02f, 8.97677690e-02f, 2.10962415e-01f, 1.32395625e-01f, 1.90638557e-01f, 2.15003192e-01f, 1.93739817e-01f, 1.68966189e-01f, 2.88050354e-01f, 1.59716487e-01f,
  1.98497012e-01f, 2.84301788e-01f, -2.64650702e-01f, -1.00752898e-01f, -2.39713285e-02f, -1.19661659e-01f, -6.75095152e-03f, -1.35579899e-01f, 7.67296702e-02f, -1.95116460e-01f,
  -1.19435683e-01f, -3.64006422e-02f, 3.18337344e-02f, -1.08028665e-01f, -1.22646481e-01f, -1.78389058e-01f, -1.27647743e-01f, -1.41529813e-01f, -7.35397413e-02f, -8.09391439e-02f,
  -2.11316496e-02f, -2.16517057e-02f, -1.58032715e-01f, -5.87694310e-02f, 1.66418105e-01f, 9.10805352e-03f, -2.58539431e-02f, -2.57893018e-02f, -6.05515670e-03f, -7.86066651e-02f,
  1.80841282e-01f, 1.36416033e-01f, 1.77186653e-01f, 5.00809476e-02f, 1.60232842e-01f, 2.81941537e-02f, 7.12081864e-02f, 3.33878994e-02f, 1.18980840e-01f, -1.63996071e-02f,
  -8.85083452e-02f, 6.37542680e-02f, 4.55601998e-02f, -5.81129454e-02f, 1.67130157e-01f, -4.98894192e-02f, -8.37508142e-02f, -1.56141341e-01f, 2.76036803e-02f, 1.95918754e-02f,
  -5.43268286e-02f, -2.58972853e-01f, -8.11692402e-02f, -1.98073745e-01f, -7.73985758e-02f, 1.41176805e-01f, 9.29683074e-02f, 5.92240393e-02f, 4.76286076e-02f, -2.95980517e-02f,
  -4.30083632e-01f, 1.23607159e-01f, -6.15309663e-02f, -1.72284231e-01f, 6.77354410e-02f, 1.90315600e-02f, 1.74030498e-01f, -1.58030257e-01f, -5.63353598e-02f, -9.16802660e-02f,
  3.35684493e-02f, 1.42394945e-01f, 3.42533886e-02f, -6.72423393e-02f, -1.48100063e-01f, -1.49999022e-01f, 3.30554880e-02f, -1.33641779e-01f, -1.77384213e-01f, -2.53272951e-01f,
  -2.08203822e-01f, -3.49053353e-01f, -2.63127446e-01f, -2.21302718e-01f, -1.65742844e-01f, -3.86391580e-02f, -1.73577085e-01f, -1.33614093e-01f, -1.12806283e-01f, -3.05021584e-01f,
  -1.59560275e+00f, 2.07360387e-02f, -2.61748701e-01f, -1.04879344e+00f, -4.83762324e-01f, -4.03697133e-01f, -8.43894109e-02f, 1.10918336e-01f, -3.89366686e-01f, -5.66910505e-02f,
  1.56405270e-01f, 2.02183455e-01f, 2.47138157e-01f, 1.87431589e-01f, -3.86648066e-02f, -1.23768158e-01f, -6.99661016e-01f, -5.66578805e-01f, -1.50593575e-02f, 7.82075822e-02f,
  -4.58148532e-02f, -4.99072760e-01f, -5.91058195e-01f, -1.53010011e-01f, 1.43904090e-01f, 2.05101743e-01f, 2.55296696e-02f, -3.24120969e-01f, 9.92414206e-02f, -2.95647472e-01f,
  6.67871892e-01f, -3.14286798e-01f, -2.51050591e-02f, -2.79366702e-01f, -5.36388122e-02f, -4.02020253e-02f, -2.85257529e-02f, -5.08044958e-02f, -1.20321512e-01f, -4.42523025e-02f,
  -1.93709388e-01f, -1.08932614e-01f, -1.93857551e-01f, 1.33210376e-01f, -7.73059949e-02f, 3.47423814e-02f, 7.62664527e-02f, -1.31473497e-01f, -1.42426342e-01f, 2.43391901e-01f,
  1.87304080e-01f, -2.27661639e-01f, -3.01128160e-02f, 1.70405075e-01f, 7.28101432e-02f, -1.83815897e-01f, 3.27452362e-01f, 3.96117195e-02f, 2.07971651e-02f, 7.08269402e-02f,
  8.06372315e-02f, 2.27517396e-01f, 4.60285209e-02f, 4.70668189e-02f, 6.70700846e-03f, -4.06439751e-02f, -1.19422469e-02f, 8.80885720e-02f, -1.90044902e-02f, 1.53669402e-01f,
  4.83682863e-02f, -1.02455072e-01f, 7.82119259e-02f, -1.55989872e-02f, -4.51910608e-02f, -1.86678723e-01f, -5.02825454e-02f, 7.50678182e-02f, -6.67386726e-02f, -1.86366186e-01f,
  -1.75260499e-01f, 1.06409788e-01f, -1.73346773e-02f, 1.65698946e-01f, -6.68753088e-02f, -4.58320752e-02f, -3.83491181e-02f, 1.81371570e-01f, 5.03349155e-02f, -1.59196824e-01f,
  3.44757289e-01f, -4.04189348e-01f, 5.79923689e-02f, 3.93640622e-02f, -6.82343170e-02f, -6.51169643e-02f, -1.08842015e-01f, -5.91305159e-02f, -1.37651592e-01f, -5.87451942e-02f,
  -1.56575181e-02f, -2.52710702e-03f, 2.36124620e-02f, 9.96382236e-02f, -8.22768733e-02f, 6.64937943e-02f, 9.89604890e-02f, -2.56247595e-02f, -1.33727059e-01f, 1.82440281e-01f,
  2.97669619e-02f, -1.36349991e-01f, 4.12304439e-02f, 1.07103243e-01f, 1.24101751e-01f, -1.58120885e-01f, 2.81937242e-01f, 2.04502195e-01f, -9.29520056e-02f, 2.29238659e-01f,
  5.35497606e-01f, -1.36407360e-03f, -1.16322899e+00f, -4.07068953e-02f, -7.09641099e-01f, -3.75392497e-01f, -1.50081962e-02f, 5.67687869e-01f, 3.16991895e-01f, -3.20919454e-01f,
  -7.31040351e-03f, 3.78763407e-01f, -4.01013345e-02f, -2.32847817e-02f, 6.26501292e-02f, -5.85817814e-01f, -6.93767250e-01f, -3.90649319e-01f, 8.70351493e-02f, 2.68254668e-01f,
  1.56016156e-01f, 1.78353116e-01f, 4.12807077e-01f, 1.89853951e-01f, -2.43239954e-01f, -1.59524560e-01f, -6.81580603e-01f, -4.64335710e-01f, -4.71863508e-01f, -9.01969433e-01f,
  -9.91078973e-01f, -5.74020267e-01f, -2.31254146e-01f, 6.50983751e-02f, -1.08878985e-01f, 1.71418652e-01f, 1.38491482e-01f, -6.34459183e-02f, 1.34231225e-01f, 6.16452582e-02f,
  -6.78835809e-02f, 1.38068199e-01f, 2.28090938e-02f, -3.27299982e-02f, 8.99130180e-02f, 1.42700359e-01f, -1.50087968e-01f, 1.78615807e-03f, -1.99343339e-01f, -2.65187174e-01f,
  -5.82101457e-02f, -2.74203569e-01f, -4.69220400e-01f, -2.79465586e-01f, -2.28646278e-01f, -4.41330403e-01f, -2.79013067e-01f, -2.75102288e-01f, -6.17060065e-01f, -2.06836760e-01f,
  -5.95823340e-02f, -6.27167374e-02f, -4.49351147e-02f, 1.75763413e-01f, 1.92465618e-01f, -1.06053464e-01f, -3.20996740e-03f, -6.62227571e-02f, 7.40074040e-03f, 8.32225233e-02f,
  6.77001253e-02f, -1.23138577e-01f, 9.91962254e-02f, 1.71986991e-03f, -1.97704554e-01f, -1.38005093e-01f, -4.83460166e-02f, 1.05072573e-01f, -1.46171704e-01f, 1.85024496e-02f,
  1.00124779e-03f, -1.09207049e-01f, 1.15831502e-01f, 9.29294825e-02f, -1.26490802e-01f, -5.14989905e-02f, 5.41955978e-02f, 2.31042579e-01f, 1.73749730e-01f, -4.19842042e-02f,
  5.55759490e-01f, -1.07533492e-01f, 8.48104656e-02f, 1.50740772e-01f, -3.18359919e-02f, -6.13766052e-02f, -9.53755230e-02f, 9.45193619e-02f, 1.82332307e-01f, 1.03987090e-01f,
  -9.40633416e-02f, -2.17526518e-02f, 1.95208639e-02f, 5.30844666e-02f, 8.22931528e-02f, 1.23849519e-01f, 8.36545080e-02f, -1.12107471e-01f, 1.84726641e-01f, 4.13053408e-02f,
  2.40362406e-01f, 1.89744607e-01f, 1.87948912e-01f, -2.12823437e-03f, 4.96066362e-02f, 1.62583496e-02f, 7.17722699e-02f, 4.16522473e-02f, -6.01959415e-03f, 6.26305997e-01f,
  7.48153150e-01f, 4.45508301e-01f, 1.89151466e-01f, -1.52547687e-01f, -1.20069675e-01f, 1.77042544e-01f, 5.14847398e-01f, 2.45904535e-01f, -2.79862046e-01f, 1.68478698e-01f,
  4.55438644e-02f, -4.71521407e-01f, -3.40885937e-01f, -2.23480299e-01f, 2.30919659e-01f, 1.02893539e-01f, 8.37791264e-02f, 1.49033353e-01f, 2.00121030e-02f, 8.62605199e-02f,
  -2.42964551e-02f, 3.53158861e-01f, 5.54031730e-01f, 1.30818695e-01f, 8.09797272e-02f, -3.57560813e-01f, 1.47181094e-01f, 2.38718152e-01f, 1.72432601e-01f, 4.57147360e-02f,
  6.24107243e-03f, 7.12836564e-01f, -2.59485543e-01f, -5.28032519e-02f, 8.94493908e-02f, -1.36206225e-01f, -8.37470517e-02f, -5.14272489e-02f, -4.06081378e-02f, -1.92070723e-01f,
  3.90795581e-02f, -5.89485373e-03f, -1.91113621e-01f, -1.60382856e-02f, -1.75953507e-02f, 7.29147121e-02f, 3.38133834e-02f, 1.20623738e-01f, -2.27231070e-01f, -5.12430035e-02f,
  -1.99115813e-01f, 2.41349861e-02f, 3.07176560e-01f, -6.31020591e-02f, -9.07809436e-02f, -2.63936281e-01f, 4.57020588e-02f, -4.35299650e-02f, -2.64422726e-02f, -5.36325648e-02f,
  -2.52219111e-01f, 1.24789383e-02f, 1.80263184e-02f, -4.50596139e-02f, -7.17006773e-02f, -8.99294838e-02f, -1.10448115e-01f, 2.19210014e-02f, 6.34011552e-02f, 1.18443981e-01f,
  -1.59489363e-01f, -6.25680983e-02f, -1.33169577e-01f, -5.97006455e-02f, -2.38730669e-01f, -5.60255498e-02f, -1.26754969e-01f, 4.38715108e-02f, 7.87337646e-02f, 2.19751354e-02f,
  -4.67378926e-03f, -7.24135935e-02f, -2.76898220e-03f, -9.87578109e-02f, -9.41111892e-02f, -1.98321000e-01f, -1.64405167e-01f, -7.37346709e-02f, 5.31486124e-02f, 5.79544306e-02f,
  -2.69777298e-01f, -7.67320627e-03f, -1.98877662e-01f, 9.32892226e-03f, 1.65270567e-01f, -3.65389176e-02f, -9.61034000e-02f, -1.71946689e-01f, -1.58703521e-01f, -1.67048424e-01f,
  1.04556210e-01f, -1.39065742e-01f, -1.07137002e-02f, 1.16936803e-01f, -1.80979043e-01f, -2.72725467e-02f, 1.61131278e-01f, -7.77159706e-02f, -4.64896336e-02f, -1.44546598e-01f,
  -5.65379448e-02f, -3.46534215e-02f, 8.94486997e-03f, -1.57269344e-01f, -1.57476380e-01f, -2.82487094e-01f, 5.12080118e-02f, -8.85540992e-02f, 7.07164481e-02f, 1.01221599e-01f,
  -4.02610332e-01f, -6.57964587e-01f, -2.97178656e-01f, 2.10997671e-01f, 3.19832712e-02f, -3.41339648e-01f, -6.86389387e-01f, -4.43445653e-01f, 1.94438361e-02f, -3.70490372e-01f,
  -3.20963442e-01f, 2.38311037e-01f, 9.54921022e-02f, -7.63728702e-03f, -2.02199250e-01f, 5.27646691e-02f, 4.06364173e-01f, 3.39286834e-01f, 2.12335996e-02f, 1.02433704e-01f,
  4.47070330e-01f, 5.77089190e-01f, 2.66997814e-01f, 2.18483135e-01f, 1.89962178e-01f, 3.09315860e-01f, 2.30250493e-01f, 3.85758758e-01f, -9.34314355e-02f, 4.20475274e-01f,
  -4.51888382e-01f, -4.09923553e-01f, 1.85365587e-01f, 8.51168204e-03f, -1.41890794e-01f, -3.79056297e-02f, -9.61366817e-02f, -3.54149342e-02f, -2.22031876e-01f, -4.57552411e-02f,
  1.45534828e-01f, 5.28522907e-03f, 1.08371265e-01f, -3.07890736e-02f, 1.01323836e-01f, -3.87830772e-02f, 2.85757706e-02f, 1.69998422e-01f, -1.14854947e-01f, -2.40520969e-01f,
  2.64035434e-01f, 6.40985370e-02f, -4.72714156e-01f, -3.04766804e-01f, -3.03962022e-01f, 1.90730214e-01f, -1.92373589e-01f, -1.65970176e-02f, -4.12029654e-01f, -3.28154147e-01f,
  -7.42011145e-02f, -1.40426412e-01f, -1.00175338e-02f, -2.39976183e-01f, 3.62757929e-02f, 6.35370705e-03f, 2.61135221e-01f, 1.06930807e-01f, 2.24662021e-01f, -5.05552744e-04f,
  5.15097678e-02f, -3.08425389e-02f, -3.64864506e-02f, -8.16609636e-02f, -8.03970546e-03f, 9.64891259e-03f, -1.31793305e-01f, 1.73030738e-02f, 4.55142334e-02f, -4.22497978e-03f,
  1.53236082e-02f, 8.37357044e-02f, 1.07419483e-01f, 2.05054209e-02f, -2.46842414e-01f, -1.81878004e-02f, -2.46667955e-02f, -8.45412835e-02f, 1.61842346e-01f, -6.90151751e-02f,
  1.32062316e-01f, 2.30338290e-01f, -1.66466489e-01f, -7.74436146e-02f, 5.50688691e-02f, -3.35524417e-02f, -1.03264123e-01f, -1.09592658e-02f, -1.28290370e-01f, -2.84184337e-01f,
  -1.53434187e-01f, -2.51508147e-01f, -1.76256914e-02f, 1.72329262e-01f, -1.15440954e-02f, 1.70600619e-02f, -1.04802407e-01f, -1.78850904e-01f, 1.30148130e-02f, 8.22758600e-02f,
  -1.30170872e-02f, -4.53890741e-01f, -5.82177997e-01f, -3.69291484e-01f, -8.78526047e-02f, -3.76910478e-01f, -2.10580960e-01f, -1.98290840e-01f, -5.56693494e-01f, -9.01361048e-01f,
  -4.20932353e-01f, -4.03706163e-01f, 1.92030862e-01f, 3.60919267e-01f, 5.10316789e-01f, 4.18084711e-01f, 1.34979293e-01f, 1.57897934e-01f, 2.94885129e-01f, 8.04594532e-02f,
  -1.06091015e-01f, 1.22503914e-01f, 6.44340217e-02f, 8.24159905e-02f, 2.32359208e-02f, 3.38506192e-01f, 4.24091518e-01f, 2.18046501e-01f, 1.39414385e-01f, 1.60561562e-01f,
  1.82021528e-01f, -7.05068856e-02f, -2.27456570e-01f, 7.69464448e-02f, 5.67414090e-02f, 1.99550748e-01f, -1.63282920e-02f, -8.69467035e-02f, -5.13028130e-02f, 2.93041259e-01f,
  1.19298240e-02f, -2.63117760e-01f, 1.15409769e-01f, -7.39161149e-02f, -2.12388664e-01f, -2.68189490e-01f, 2.58341357e-02f, -1.97429433e-01f, -1.87545732e-01f, -1.29087251e-02f,
  1.20650316e-02f, -1.10137142e-01f, -6.62720948e-02f, -1.45331770e-01f, -1.48986354e-01f, -1.54602736e-01f, -1.98717251e-01f, -3.11387200e-02f, 1.19177625e-01f, -6.17521405e-02f,
  2.61671077e-02f, 1.58037081e-01f, 1.90797940e-01f, 1.57210052e-01f, 6.09136783e-02f, 1.23275101e-01f, -6.92791939e-02f, -8.62057414e-03f, -1.86033901e-02f, -8.62837359e-02f,
  1.12974666e-01f, 1.35032967e-01f, 1.38304234e-01f, 5.47506986e-03f, 1.10726468e-02f, 2.68990528e-02f, 9.00710747e-02f, -3.28677706e-02f, 9.18163657e-02f, -1.17143638e-01f,
  4.27575968e-02f, 1.33868814e-01f, 1.27508000e-01f, -5.44503443e-02f, 1.16843663e-01f, 3.82719226e-02f, -2.94120226e-04f, -6.14086306e-03f, -4.02290970e-02f, -8.17524940e-02f,
  1.40492124e-02f, 7.71063706e-03f, -1.58509567e-01f, 7.74289249e-03f, -6.61136061e-02f, 1.48137227e-01f, 5.54792769e-02f, -6.16816916e-02f, 3.45169683e-03f, -3.31543796e-02f,
  2.81547576e-01f, 1.89645812e-01f, 2.33164534e-01f, 1.54062286e-01f, -8.82055014e-02f, -2.26651013e-01f, 1.70942828e-01f, -4.86700758e-02f, -7.37777054e-02f, 7.28769526e-02f,
  -1.99927822e-01f, -8.33301619e-02f, -1.84094802e-01f, -6.14136122e-02f, -1.91236719e-01f, -1.59510627e-01f, -1.71964720e-01f, 7.47254267e-02f, 9.84167680e-02f, -5.63988313e-02f,
  2.00242805e-03f, 1.27725482e-01f, 1.60180524e-01f, 9.78184566e-02f, -5.08655570e-02f, 1.94256440e-01f, -1.10859431e-01f, -8.91937092e-02f, -5.46083525e-02f, -1.09511055e-01f,
  -6.04098856e-01f, 4.96987283e-01f, 4.72927690e-02f, -5.60391247e-01f, -6.76243678e-02f, 4.46096212e-01f, 6.18236780e-01f, 2.18444750e-01f, -2.07789645e-01f, 8.91451612e-02f,
  2.31520504e-01f, -2.97991812e-01f, -5.21380603e-01f, -3.28565478e-01f, -2.85254568e-02f, 1.85643714e-02f, -2.00483412e-01f, -4.76106673e-01f, -3.35424751e-01f, 3.08770780e-02f,
  -1.70898199e-01f, -5.77148318e-01f, -4.42732871e-01f, -5.04612327e-01f, -4.86627519e-01f, -6.97877944e-01f, -3.11460286e-01f, -6.26198575e-02f, 3.00474286e-01f, -3.55617046e-01f,
  -1.57010987e-01f, 3.91294628e-01f, -7.56314248e-02f, -7.98161924e-02f, -6.82433248e-02f, -1.58147197e-02f, -4.97978628e-02f, -1.03173584e-01f, 9.41267163e-02f, 3.48335989e-02f,
  -3.43811214e-02f, -6.31558225e-02f, -1.52006909e-01f, -6.90417513e-02f, 2.67129391e-02f, 3.30301113e-02f, 8.75815284e-04f, 7.94124454e-02f, 2.08094388e-01f, 3.48165452e-01f,
  2.58557647e-01f, 3.68689716e-01f, 2.74067551e-01f, 2.06119239e-01f, 2.54794776e-01f, 1.04967162e-01f, 2.89552122e-01f, 2.49235779e-01f, 1.47722602e-01f, -1.71127737e-01f,
  1.53713813e-03f, -5.89872338e-02f, 1.27138495e-01f, 8.44783932e-02f, 4.01348881e-02f, 2.17017112e-03f, -9.11023691e-02f, 3.72800343e-02f, 1.44873504e-02f, -7.61530623e-02f,
  1.61009356e-02f, 1.09342657e-01f, 4.05148230e-02f, 1.60726998e-03f, -1.04214542e-01f, 4.52460535e-02f, 5.55144325e-02f, 1.70438603e-01f, 4.20733579e-02f, -1.76885892e-02f,
  -1.50793577e-02f, 1.22450076e-01f, -1.15184449e-01f, -8.52907151e-02f, 2.07505956e-01f, -4.25295122e-02f, 1.67856604e-01f, 1.33333653e-01f, -4.36961018e-02f, 6.35743439e-02f,
  -5.26097238e-01f, 3.16573828e-01f, -3.21108848e-01f, -5.39974384e-02f, -4.54773493e-02f, -2.33170274e-03f, 8.09433907e-02f, -3.01138479e-02f, 2.77507268e-02f, 6.75687715e-02f,
  1.97090343e-01f, -1.49760768e-01f, 4.74952124e-02f, 8.55925158e-02f, -1.63108945e-01f, 6.13871403e-02f, 1.93212464e-01f, -1.01981200e-01f, 9.87992212e-02f, 5.99356890e-02f,
  1.36958584e-01f, -4.88402434e-02f, -1.30044729e-01f, -1.86517850e-01f, 3.35913934e-02f, -1.16886862e-01f, -1.15385488e-01f, -9.30687636e-02f, 3.48239578e-02f, -3.57011348e-01f,
  9.27660227e-01f, -8.43221247e-01f, -4.05907214e-01f, -1.20632745e-01f, -2.22150505e-01f, -5.31250574e-02f, -4.81778592e-01f, -4.45417240e-02f, 9.07232538e-02f, -4.34600264e-01f,
  -2.29020149e-01f, 4.86265033e-01f, 1.51002243e-01f, 2.61348069e-01f, 3.05005699e-01f, -5.51779330e-01f, -3.27342033e-01f, 3.20863366e-01f, 8.73485565e-01f, 3.12658250e-01f,
  1.80612169e-02f, 1.37807280e-01f, 2.81795949e-01f, 1.79269433e-01f, -5.06570399e-01f, 3.56805474e-02f, -4.67245191e-01f, -2.70962209e-01f, -2.41931960e-01f, -8.14361751e-01f,
  -2.17750281e-01f, 1.10533677e-01f, 3.00033152e-01f, 2.19957083e-01f, -1.51204750e-01f, 1.99275270e-01f, -1.52387489e-02f, 4.66687419e-02f, 1.04219867e-02f, -6.57292753e-02f,
  -3.31946253e-03f, 4.80556525e-02f, 1.91183090e-02f, -5.42116761e-02f, -3.15240771e-02f, 9.15869977e-03f, -2.87931599e-02f, 1.90596208e-01f, -2.94741243e-02f, -2.44388506e-01f,
  -1.75776243e-01f, 7.89527744e-02f, 1.07993819e-01f, 2.47671045e-02f, 2.03251317e-01f, 3.69697094e-01f, -4.04445641e-02f, 1.46607012e-01f, 2.02970058e-01f, -1.24836475e-01f,
  1.42634036e-02f, -9.69830975e-02f, 7.97346681e-02f, 1.03496097e-01f, 6.96199611e-02f, 1.12301763e-02f, -6.81326613e-02f, 2.22906861e-02f, 1.77629381e-01f, -7.23482221e-02f,
  -8.61668885e-02f, -2.93595716e-02f, 8.45163390e-02f, -1.14125170e-01f, -6.94964975e-02f, -2.06281561e-02f, -2.95981523e-02f, -2.74507403e-02f, 7.94141069e-02f, 6.62949821e-03f,
  1.39111087e-01f, -9.20394529e-03f, -1.17980033e-01f, 3.44178081e-02f, -1.63826242e-03f, -3.07144341e-03f, 4.01519910e-02f, 7.69841895e-02f, -3.08896340e-02f, -3.87572646e-02f,
  -1.05681919e-01f, 3.52885365e-01f, -1.48965478e-01f, 1.90414060e-02f, -1.03494702e-02f, -8.72861370e-02f, -6.01157434e-02f, -8.47483724e-02f, -7.94458296e-03f, 1.95617788e-02f,
  -3.00610401e-02f, 6.59575090e-02f, -8.60308930e-02f, 3.21299694e-02f, 8.60919654e-02f, 1.39372557e-01f, 4.34432738e-02f, 5.12328222e-02f, -4.63173799e-02f, -2.78265625e-01f,
  -3.16679388e-01f, 6.43072650e-02f, 1.93884134e-01f, 4.53834049e-02f, 7.46785253e-02f, 1.85685202e-01f, -9.71822068e-02f, -7.32323900e-02f, 1.46777079e-01f, -2.50685930e-01f,
  5.69255799e-02f, -1.36766851e-01f, 7.40829781e-02f, 2.62865633e-01f, 1.67185605e-01f, 2.12285310e-01f, 2.26313174e-02f, 5.04859798e-02f, 2.96071261e-01f, 7.10866079e-02f,
  2.22794771e-01f, 3.16209733e-01f, 2.73996890e-01f, 1.53871581e-01f, 1.13733687e-01f, 1.39050826e-01f, 1.03310071e-01f, 1.98872864e-01f, 8.29933882e-02f, 1.66038528e-01f,
  1.53377905e-01f, 8.67434964e-03f, 4.76270076e-03f, -3.77741619e-03f, 1.53881237e-01f, 3.08041394e-01f, 1.28707200e-01f, 1.51563346e-01f, 8.87412205e-02f, 1.48299232e-01f,
  -8.32087696e-02f, -1.29286394e-01f, 1.33764699e-01f, 5.05976891e-03f, -4.48703244e-02f, -1.00626618e-01f, 4.43936884e-02f, -2.25327268e-01f, -2.35824063e-01f, -1.36377007e-01f,
  -1.59913674e-01f, -3.74786332e-02f, 2.30793580e-02f, -1.85404215e-02f, -1.23369291e-01f, -1.84566170e-01f, -4.43308093e-02f, 4.47004549e-02f, 3.12917978e-02f, -1.09294709e-02f,
  3.13317627e-02f, 1.35944383e-02f, 1.18502483e-01f, 2.12291721e-02f, 1.28239051e-01f, 1.33592635e-01f, 1.10767171e-01f, -4.16018851e-02f, 1.13077343e-01f, 1.11348867e-01f,
  3.20059896e-01f, 1.28892884e-01f, 2.07320437e-01f, 2.17426673e-01f, 7.73211792e-02f, 3.80188860e-02f, -3.02814376e-02f, -3.59672010e-02f, 8.60400274e-02f, -9.12581757e-02f,
  -1.18613578e-01f, 1.51844263e-01f, 3.48620191e-02f, 2.32258625e-02f, 8.31221193e-02f, -4.98498231e-02f, -4.40261923e-02f, -2.36020703e-02f, -1.26078576e-01f, -1.32540464e-01f,
  -1.89873606e-01f, -1.22789375e-01f, -1.68957084e-01f, -1.49496496e-01f, -3.31200175e-02f, 1.71650976e-01f, 1.86666455e-02f, 4.23745364e-02f, -7.92895406e-02f, -2.05381677e-01f,
  1.22657139e-02f, 1.75261214e-01f, -2.72115059e-02f, -1.10671796e-01f, -1.72647744e-01f, -2.61463255e-01f, 6.85125813e-02f, -2.23058611e-01f, -3.22934240e-01f, -1.72139004e-01f,
  -1.62704699e-02f, -6.08633161e-02f, -1.95044413e-01f, -5.37634157e-02f, -1.36825219e-01f, -6.45635426e-02f, 3.15760225e-02f, 1.15995422e-01f, -1.25904684e-03f, -1.77427337e-01f,
  3.18871215e-02f, 1.07594423e-01f, 2.16553763e-01f, 1.69811174e-01f, 1.36248037e-01f, 1.85096517e-01f, 5.03717475e-02f, 6.66720141e-03f, -9.87700652e-03f, -1.20170116e-02f,
  -1.25509536e+00f, 8.99903625e-02f, 5.56745887e-01f, -5.49419820e-01f, 4.53978270e-01f, 6.17437720e-01f, 9.07935619e-01f, 2.94401534e-02f, -4.21331435e-01f, -1.41776249e-01f,
  1.25892147e-01f, -2.46323988e-01f, -2.19151899e-01f, -1.12074753e-02f, 7.73927271e-02f, 3.69409770e-01f, 3.95880014e-01f, -1.57159101e-02f, 1.43507913e-01f, 2.10886896e-01f,
  2.06030950e-01f, -3.03533316e-01f, -6.14585221e-01f, -1.07634909e-01f, -2.34240472e-01f, -2.10579053e-01f, 5.62387072e-02f, -7.90218785e-02f, 3.33511263e-01f, -1.86271101e-01f,
  -5.62846065e-01f, -4.13921505e-01f, 2.75291353e-01f, -1.93573564e-01f, 1.37050360e-01f, -2.88573384e-01f, -1.19039617e-01f, -1.75786763e-01f, 1.66456744e-01f, -1.46184102e-01f,
  -2.14539155e-01f, 2.90212445e-02f, -1.13674402e-01f, 1.00265972e-01f, -2.39619628e-01f, 2.58105826e-02f, -1.11827180e-02f, -2.32855693e-01f, -1.69865549e-01f, 8.47986192e-02f,
  1.83073476e-01f, -1.95263237e-01f, -3.80990714e-01f, 3.40807468e-01f, 4.81818430e-02f, -4.33529764e-01f, -5.49780242e-02f, -2.99288481e-01f, -2.10088775e-01f, -1.06423044e+00f,
  4.71835490e-03f, 1.06846318e-01f, 4.60586585e-02f, -4.19224314e-02f, -4.99149673e-02f, 1.96090247e-02f, -4.27674800e-02f, -7.98813067e-03f, 1.16954871e-01f, -2.35152259e-01f,
  1.95656508e-01f, 8.35231245e-02f, 1.81499317e-01f, -1.90715417e-01f, -1.01068787e-01f, -2.33627502e-02f, 3.05526704e-02f, -1.92654833e-01f, 2.82725729e-02f, 1.13245703e-01f,
  -4.07055654e-02f, -5.45231812e-02f, -2.25471228e-01f, -4.04040106e-02f, 1.92220002e-01f, -3.51728983e-02f, -1.10566676e-01f, 1.77806932e-02f, -1.26658708e-01f, -1.83242541e-02f,
  -7.69390225e-01f, 5.19685686e-01f, -4.74863708e-01f, 1.21390499e-01f, 5.88327413e-03f, 1.16573878e-01f, -7.53055587e-02f, 4.54262225e-03f, -8.28468129e-02f, -1.58747271e-01f,
  8.96460190e-02f, -1.02894954e-01f, -2.56821036e-01f, 1.96379945e-01f, -5.82904108e-02f, -3.49172987e-02f, 1.61211342e-01f, -1.03581930e-02f, 3.31275500e-02f, -2.02737506e-02f,
  1.72242194e-01f, 6.51425682e-04f, -5.78453958e-01f, -2.16893051e-02f, -1.98267072e-01f, -5.15595794e-01f, -3.18563670e-01f, 5.48909977e-03f, -1.85293645e-01f, -5.87428570e-01f,
  5.77283740e-01f, 7.85696954e-02f, 1.54208869e-01f, 3.47862482e-01f, -6.86556399e-01f, -9.18455243e-01f, -8.11099410e-01f, -4.54514116e-01f, 2.42124200e-02f, 8.93199816e-03f,
  -2.61757106e-01f, -1.79992750e-01f, 7.10881650e-02f, -2.41311993e-02f, -6.14214726e-02f, 2.11730182e-01f, 3.93555373e-01f, 2.47020423e-01f, -2.01159969e-01f, -2.28654861e-01f,
  -2.29181200e-01f, 2.29302764e-01f, 3.00793767e-01f, -6.20283335e-02f, 2.71170437e-01f, -1.38041839e-01f, 2.55596429e-01f, 2.19404608e-01f, -4.01338525e-02f, 6.87324166e-01f,
  3.35136920e-01f, 1.75836191e-01f, -2.16307059e-01f, 5.37733827e-03f, 1.29668206e-01f, 2.29018927e-01f, 4.35844064e-02f, 3.67166638e-01f, -1.49054125e-01f, 2.44473994e-01f,
  -3.94024476e-02f, 9.87488553e-02f, -1.20653175e-01f, -1.64848030e-01f, -1.18971102e-01f, -7.04524890e-02f, 2.58483231e-01f, 2.95789689e-01f, 3.69520366e-01f, 9.51543078e-03f,
  -8.21858644e-03f, -2.36575872e-01f, -1.72607198e-01f, -1.36148155e-01f, 1.30296558e-01f, -4.76567410e-02f, -2.54943699e-01f, -6.93812817e-02f, -4.74139936e-02f, 3.55263084e-01f,
  7.11208954e-02f, 7.54393265e-02f, 9.49417502e-02f, 1.43088490e-01f, 1.33988038e-01f, 3.33684757e-02f, -6.01387396e-02f, -1.29360452e-01f, -5.04575819e-02f, -4.32571955e-03f,
  -8.30185190e-02f, 1.92688644e-01f, 1.26006708e-01f, 9.04132351e-02f, -8.50420743e-02f, 5.80644980e-02f, 9.77250561e-03f, 4.39624907e-03f, -9.33365524e-02f, -1.25230312e-01f,
  -7.29421973e-02f, -8.97243693e-02f, 8.81403163e-02f, 7.23383715e-03f, 1.52351428e-02f, 1.63362771e-01f, 2.25030467e-01f, -9.50707272e-02f, 3.02916244e-02f, 5.69702759e-02f,
  -2.76105016e-01f, -3.79591852e-01f, 1.88932672e-01f, -1.03396706e-01f, 1.14801444e-01f, -2.62743477e-02f, 3.65048796e-02f, 4.15505320e-02f, 1.07787447e-02f, -2.85693798e-02f,
  -3.94652039e-01f, 1.13798991e-01f, 1.65739190e-02f, 5.24805263e-02f, -8.90551433e-02f, -1.55260086e-01f, 9.67224613e-02f, -2.39022970e-01f, -2.38228619e-01f, 1.17251456e-01f,
  5.84333651e-02f, -2.96468318e-01f, -3.91410202e-01f, -9.37986821e-02f, 1.79338735e-02f, -5.31793356e-01f, -5.06423295e-01f, -1.40550494e-01f, -3.27958465e-01f, -8.22362676e-02f,
  2.72180229e-01f, -7.86068887e-02f, 1.44135863e-01f, 1.55677661e-01f, 1.76746801e-01f, 3.46058905e-01f, 5.00479519e-01f, 3.35631460e-01f, 7.72395059e-02f, 1.22538239e-01f,
  -2.73902327e-01f, -5.25643170e-01f, -4.55513775e-01f, -2.78252840e-01f, -3.99009325e-02f, 2.89230585e-01f, 2.55476147e-01f, 5.46960868e-02f, 1.50336996e-01f, 1.42432541e-01f,
  -1.57996211e-02f, 6.19826093e-02f, -2.14937385e-02f, 5.58393896e-02f, 5.79560101e-02f, -8.19427148e-02f, -7.24535668e-03f, -6.39238730e-02f, -2.84917057e-01f, 9.94353667e-02f,
  -5.33700347e-01f, -6.30177632e-02f, -1.51569501e-01f, -4.18319017e-01f, -2.25494802e-01f, 3.60147213e-03f, 1.16490610e-02f, -2.28631832e-02f, -4.54329364e-02f, 6.32203445e-02f,
  -6.75691515e-02f, -1.94754880e-02f, -2.75888704e-02f, -9.72165242e-02f, 1.46826014e-01f, 2.01278497e-02f, 6.80851191e-02f, 3.59937549e-03f, -1.26056850e-01f, -2.07625747e-01f,
  -1.06973879e-01f, -7.66331926e-02f, 4.58314084e-02f, 5.09741418e-02f, -9.18399170e-03f, -7.19325319e-02f, 4.14987514e-03f, -8.33327696e-02f, -7.21520111e-02f, 3.13167162e-02f,
  -6.33744523e-02f, 7.85146505e-02f, -6.98148161e-02f, 1.42062709e-01f, 1.31135091e-01f, 1.05711050e-01f, 1.25586256e-01f, 1.15413874e-01f, 1.10211685e-01f, 1.49447039e-01f,
  3.29869166e-02f, -2.93354578e-02f, 1.22868970e-01f, -3.17822844e-02f, -7.97207206e-02f, -1.61549402e-03f, 7.17394426e-02f, -1.42425999e-01f, -1.80904660e-02f, -6.40288219e-02f,
  1.68377221e-01f, 1.07808016e-01f, -8.17897320e-02f, 3.35124917e-02f, 2.51099467e-02f, 2.02748124e-02f, 1.04689822e-02f, -7.08314553e-02f, -5.01103140e-02f, -6.52045682e-02f,
  -1.55057609e-01f, -4.12495464e-01f, -7.02627823e-02f, -8.91832486e-02f, 2.40404569e-02f, -1.88864931e-01f, -1.34105563e-01f, -6.60981536e-02f, 7.83655047e-02f, 2.66977530e-02f,
  -3.03099137e-02f, -7.77539760e-02f, -4.00979519e-02f, 1.32524356e-01f, 2.36272052e-01f, 1.92921817e-01f, -1.80959105e-01f, 2.70393584e-02f, -1.29139751e-01f, -8.24814290e-02f,
  -3.16035599e-02f, 1.99554950e-01f, 8.85993242e-02f, 1.54253215e-01f, -2.06510723e-02f, -1.77027192e-02f, 1.34750962e-01f, 9.27005988e-03f, 1.46383181e-01f, 1.77080616e-01f,
  8.40373278e-01f, -2.73144364e-01f, 3.63342226e-01f, 2.27810666e-01f, 1.85501546e-01f, 1.82273924e-01f, 1.19466677e-01f, 1.21917300e-01f, 1.21272132e-02f, -2.66101235e-03f,
  -2.04402916e-02f, -4.28866744e-02f, -7.15211555e-02f, -8.13800022e-02f, 1.28861979e-01f, -7.34760612e-02f, -8.47373828e-02f, 2.45231777e-01f, 3.07874173e-01f, 5.73506206e-02f,
  -1.83993280e-01f, -1.47026241e-01f, 2.05761239e-01f, 5.12986735e-04f, -2.98933059e-01f, -6.73946664e-02f, -1.55052170e-01f, -1.55257463e-01f, -1.07795648e-01f, -2.76430637e-01f,
  -1.00157388e-01f, -1.02904707e-01f, -1.56560287e-01f, -1.90223843e-01f, -1.17604151e-01f, -4.88495380e-02f, -5.51584968e-03f, -9.42737684e-02f, -8.75885859e-02f, -1.82778955e-01f,
  -1.11990884e-01f, -3.46516147e-02f, 9.82991755e-02f, -7.04104900e-02f, 1.27470335e-02f, 7.50248805e-02f, -8.36949497e-02f, 7.16230692e-03f, 1.06440827e-01f, 5.75163178e-02f,
  -8.55238289e-02f, 1.39181599e-01f, 1.87675759e-01f, 8.23578313e-02f, 2.07682371e-01f, -2.97101215e-02f, -3.42297032e-02f, 7.24955797e-02f, 6.68161735e-02f, 1.38776600e-02f,
  1.10546231e-01f, -6.14306889e-02f, 1.33169711e-01f, -2.86204945e-02f, 1.57737911e-01f, 1.04423963e-01f, -4.69262414e-02f, -4.75609601e-02f, 7.81161264e-02f, 9.40553471e-02f,
  -4.05737683e-02f, 5.98040856e-02f, 1.34484723e-01f, 9.45253372e-02f, 7.56799951e-02f, 8.40016454e-02f, 8.85421261e-02f, -2.14237794e-01f, 4.70124744e-02f, 9.09313094e-03f,
  2.50525296e-01f, 1.32206589e-01f, -5.59253357e-02f, 9.00966227e-02f, -5.76990396e-02f, -9.94912232e-04f, 1.38591677e-02f, -1.08974706e-02f, -1.29762903e-01f, 1.27860056e-02f,
  -2.66912162e-01f, 2.60443926e-01f, -2.62329821e-02f, -8.22097138e-02f, -6.76665008e-02f, -6.62859529e-02f, 6.85874671e-02f, -1.42862380e-01f, -1.80504963e-01f, -2.00647682e-01f,
  -1.83353219e-02f, -4.54217978e-02f, 1.65976211e-01f, 5.03689125e-02f, 1.87410098e-02f, -5.34260981e-02f, -1.35471672e-01f, 1.92135177e-03f, -3.01744994e-02f, -1.51042089e-01f,
  -4.74303355e-03f, 1.35171235e-01f, 1.02863513e-01f, 1.98138729e-01f, -2.58409809e-02f, 1.22697972e-01f, -3.75938155e-02f, 1.02561414e-01f, 1.21657446e-01f, 2.55236421e-02f,
  -2.40659460e-01f, 3.38604748e-01f, -3.36578518e-01f, 2.74303108e-01f, 5.97567022e-01f, -1.50221050e-01f, -2.38516495e-01f, -2.46607825e-01f, 2.29275927e-01f, 2.04206929e-01f,
  4.80940431e-01f, 3.09455544e-01f, 2.97590911e-01f, 3.18265185e-02f, -6.99293792e-01f, -8.55421834e-03f, 7.00023845e-02f, -7.48124063e-01f, -9.99839485e-01f, -5.05025446e-01f,
  1.15846194e-01f, -1.53265446e-01f, -7.83345997e-01f, -3.20546865e-01f, 5.18492639e-01f, 1.14591748e-01f, 2.45712534e-01f, 9.44484770e-02f, 5.24446554e-02f, 6.47120059e-01f,
  -1.30183771e-01f, 1.16732955e-01f, -2.38333687e-01f, 1.47944212e-01f, 1.47628129e-01f, -2.29210973e-01f, -3.23039502e-01f, -2.12968513e-01f, 1.56834826e-01f, -1.03934534e-01f,
  4.22394127e-01f, -2.65705228e-01f, 4.46768105e-01f, -5.66844121e-02f, -1.90941483e-01f, -2.03061819e-01f, -1.79465920e-01f, -5.53759158e-01f, -4.52449590e-01f, -4.48263735e-01f,
  3.47387522e-01f, 2.81673372e-01f, -2.02517018e-01f, -1.56638280e-01f, -2.58071154e-01f, -1.28664836e-01f, -1.24738179e-01f, -1.30531654e-01f, -4.47265714e-01f, 2.17306577e-02f,
  -9.62786898e-02f, 8.49451274e-02f, 4.28435877e-02f, 8.22192729e-02f, 4.53709550e-02f, 7.01027885e-02f, 1.25249187e-02f, -5.24859242e-02f, -3.96610089e-02f, -1.20456837e-01f,
  4.56945710e-02f, 1.05682043e-02f, -1.60897933e-02f, -9.10940673e-03f, 1.41233914e-02f, 1.92570407e-02f, 4.91157286e-02f, -1.98869869e-01f, -4.33907248e-02f, 1.03876665e-01f,
  -2.92799510e-02f, 9.55063552e-02f, 7.77692050e-02f, -6.56252429e-02f, -1.39813907e-02f, -4.58949469e-02f, -6.36127964e-02f, 9.88848731e-02f, -1.30634293e-01f, -5.45812845e-02f,
  3.56447101e-02f, 7.86874443e-02f, -1.07653372e-01f, 2.16143373e-02f, -3.81102972e-02f, -4.68139388e-02f, 3.06154937e-01f, -2.42663305e-02f, 2.26766452e-01f, -3.45909208e-01f,
  -1.16681010e-01f, -5.78977466e-02f, 1.50728628e-01f, 1.33850291e-01f, -1.56321108e-01f, 7.65887424e-02f, -1.62822250e-02f, 3.37797999e-02f, -1.93944126e-01f, 6.54240847e-02f,
  -5.97717427e-02f, -2.60957032e-01f, -2.65218854e-01f, -1.30000217e-02f, 1.87745973e-01f, -2.50102967e-01f, -3.34893912e-01f, 4.62447815e-02f, -3.75406921e-01f, -2.21726090e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  8.21395159e-01f, 7.96177328e-01f, 9.86656368e-01f, 5.50132036e-01f, 6.07347071e-01f, 2.91234434e-01f, 5.74271142e-01f, 2.93481588e-01f, 2.44686052e-01f, 8.69613230e-01f,
  4.90990788e-01f, 8.46424341e-01f, 9.01531816e-01f, 4.07027036e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.27362346e-02f, 7.50448480e-02f, -2.43349135e-01f, -3.42947128e-03f, -6.09730836e-03f, -2.31127068e-01f, -2.23498587e-02f, 1.95435360e-02f, -7.34041631e-02f, 1.06334478e-01f,
  -1.40243964e-02f, -4.39926609e-03f, -5.25459647e-02f, -5.65866865e-02f, -5.01714833e-02f, 1.31501434e-02f, 1.54845238e-01f, 6.60803393e-02f, -4.36563976e-02f, -9.98749062e-02f,
  3.04700822e-01f, -2.37747282e-01f, 4.59715068e-01f, -2.40375847e-01f, 8.01261812e-02f, 3.30190003e-01f, 9.73647237e-02f, 1.66557610e-01f, -2.71065652e-01f, -3.70249987e-01f,
  8.40456262e-02f, -3.84562850e-01f, 1.12676695e-01f, -3.32328863e-02f, -1.40286386e-01f, 1.14386335e-01f, 3.91461551e-02f, -7.43396953e-02f, -1.89928383e-01f, -2.19957642e-02f,
  -7.59733766e-02f, 1.34388655e-01f, 8.27034190e-02f, 2.41246298e-02f, 9.75202490e-03f, -3.15948576e-02f, -1.29546300e-01f, 5.39616607e-02f, 5.52999824e-02f, -5.46021536e-02f,
  -5.95771037e-02f, -2.56246645e-02f, -3.03020328e-01f, 4.04949248e-01f, 1.80859882e-02f, -2.85017967e-01f, 2.43649036e-01f, -3.41604292e-01f, -2.93378145e-01f, -9.73302275e-02f,
  5.15007436e-01f, 1.01595223e-01f, -4.86619249e-02f, 2.28220999e-01f, -1.39600515e-01f, -1.36097372e-01f, -2.18849808e-01f, -8.40740725e-02f, 3.45111862e-02f, -2.42269278e-01f,
  1.48768440e-01f, -6.35938346e-02f, -2.60144453e-02f, 1.96012482e-01f, 1.70719296e-01f, -3.14124301e-02f, 8.68758280e-03f, 1.99356936e-02f, 2.03534395e-01f, 2.20469624e-01f,
  1.36901245e-01f, 9.17421654e-02f, -3.45360160e-01f, 1.66550457e-01f, -3.57075870e-01f, -2.37060502e-01f, -1.40002534e-01f, 6.79247156e-02f, -1.83814168e-01f, -4.92414147e-01f,
  8.68664533e-02f, -1.02601565e-01f, -2.82869011e-01f, 5.55190861e-01f, -3.08663726e-01f, 4.24229950e-01f, 7.86215626e-03f, -2.21832216e-01f, 3.49049568e-02f, 1.54218167e-01f,
  7.85450563e-02f, 1.96417525e-01f, 1.45573867e-02f, 5.86087741e-02f, -3.49803432e-03f, 1.94424074e-02f, -6.52365992e-03f, 5.38832694e-02f, 6.06918037e-02f, -1.91883937e-01f,
  7.48569742e-02f, -2.57164575e-02f, 2.21568346e-02f, 1.88711986e-01f, -2.80158997e-01f, 2.41490260e-01f, 1.16222903e-01f, 2.82924157e-03f, -2.35215016e-02f, -2.60859486e-02f,
  1.53195933e-01f, 4.41283673e-01f, 1.34271100e-01f, 3.14691752e-01f, 6.58674464e-02f, -6.01861849e-02f, 1.55012101e-01f, -3.89965147e-01f, 7.51526803e-02f, 5.75872585e-02f,
  1.75054767e-03f, -5.83574101e-02f, 5.94736310e-03f, 5.96360117e-02f, -9.95093118e-03f, 9.22228992e-02f, 2.88800187e-02f, -1.56319857e-01f, -6.06558062e-02f, -1.07616116e-03f,
  -8.35897401e-02f, 4.29012030e-02f, 2.21053749e-01f, -5.07247299e-02f, -6.49004057e-02f, 5.98830916e-02f, 3.28070581e-01f, 2.91265279e-01f, 4.80722696e-01f, -1.80248097e-01f,
  -2.30030075e-01f, -2.56151289e-01f, 1.82010666e-01f, -3.27668250e-01f, 2.15108156e-01f, -1.74685001e-01f, -5.18124461e-01f, -1.38695061e-01f, -2.27728356e-02f, -2.54334994e-02f,
  -7.92868957e-02f, -8.58614147e-02f, -3.16052362e-02f, 1.16014868e-01f, 3.49305831e-02f, -4.51154411e-01f, -8.62297118e-02f, 6.76118433e-02f, -2.42573339e-02f, -1.26107872e-01f,
  3.41806635e-02f, 1.60411805e-01f, 4.82233874e-02f, -1.19051941e-01f, -2.64524400e-01f, -2.89526153e-02f, 3.27359214e-02f, -1.18222527e-01f, 2.90383488e-01f, 1.80878520e-01f,
  -6.28220960e-02f, -2.41748005e-01f, 9.65988934e-02f, -1.41489327e-01f, 6.30398333e-01f, -1.21771134e-01f, -2.45333295e-02f, -1.24591701e-01f, -8.74168202e-02f, -3.11834127e-01f,
  -1.11389883e-01f, 2.94028431e-01f, -5.47410510e-02f, -9.04113203e-02f, -8.93111434e-03f, -1.17472939e-01f, -1.28814414e-01f, -2.72143453e-01f, 8.25269031e-04f, -3.90135124e-02f,
  -8.55753794e-02f, 3.94961923e-01f, 2.83679832e-02f, -4.11356501e-02f, -2.46590674e-01f, -5.93357980e-02f, -4.14045453e-01f, 2.42196634e-01f, 1.20978676e-01f, -8.36120546e-02f,
  -2.45806515e-01f, -1.82693616e-01f, -2.85775065e-01f, -1.45389140e-01f, 4.28772531e-02f, 1.76355883e-01f, -8.57235957e-03f, -2.09222436e-01f, 2.94054657e-01f, -2.95213759e-01f,
  4.03037012e-01f, 1.44555867e-01f, 7.47195184e-02f, 3.68979812e-01f, 8.88920873e-02f, 1.72421500e-01f, -1.16656870e-01f, -2.56635807e-02f, 4.77189012e-02f, 1.51877955e-01f,
  1.47527065e-02f, -9.05257910e-02f, -9.51981544e-02f, -3.83326709e-01f, -1.44468665e-01f, -4.96432073e-02f, 2.10050493e-01f, -6.35956461e-03f, 1.22644752e-01f, 8.65985751e-02f,
  -1.36352986e-01f, 6.29901513e-02f, 1.01280652e-01f, 2.29117304e-01f, 4.46204506e-02f, -4.56808567e-01f, 1.06718518e-01f, 9.25598145e-02f, -2.73414969e-01f, 4.86700594e-01f,
  1.17429942e-01f, 4.07316893e-01f, -5.40295184e-01f, -2.82370478e-01f, 2.06032276e-01f, -4.41213727e-01f, -6.89968932e-03f, -2.21483670e-02f, 6.31830916e-02f, -8.37072432e-02f,
  -1.68464880e-03f, 1.60096735e-01f, 7.18610287e-02f, -3.11929751e-02f, 5.79950225e-04f, 2.20812768e-01f, 4.22556587e-02f, -8.74937475e-02f, 3.01392972e-01f, -5.28521501e-02f,
  2.45057732e-01f, 2.55968552e-02f, -6.43205717e-02f, 6.99147731e-02f, -2.58575052e-01f, 2.35724643e-01f, -7.82937258e-02f, 2.65585244e-01f, -4.93918806e-01f, -1.14756897e-01f,
  -2.64290124e-01f, -2.75616169e-01f, -6.85140491e-02f, 1.59629956e-01f, 1.43022478e-01f, 4.65944916e-01f, 2.93503910e-01f, -2.99778193e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.83764468e-02f, -2.60478221e-02f, 1.27341196e-01f, -4.44379486e-02f, 7.82425776e-02f, -2.77840108e-01f, 1.34485647e-01f, 1.32044524e-01f, -1.15415297e-01f, 1.98328331e-01f,
  8.83479267e-02f, 9.28356647e-02f, -1.57140240e-01f, -1.59038022e-01f, -3.92610013e-01f, 7.75175989e-02f, 1.21642202e-01f, -1.43466135e-02f, 2.14403480e-01f, 4.71833386e-02f,
  -8.88073221e-02f, 5.54561168e-02f, -2.74860859e-01f, 3.90311390e-01f, 9.40145373e-01f, -3.42950016e-01f, 2.63548732e-01f, 4.14999783e-01f, -1.47521019e-01f, 1.84652731e-02f,
  2.74383388e-02f, 1.21046293e+00f, 2.23173928e-02f, 1.51533559e-01f, 6.93015456e-02f, 2.39961088e-01f, 7.98928663e-02f, 4.87391979e-01f, -1.51351374e-02f, 1.60060287e-01f,
  7.11865798e-02f, 1.71472460e-01f, -1.77482013e-02f, -4.40568000e-01f, -1.79264486e-01f, 1.07009232e-01f, 1.65285423e-01f, 7.80795142e-02f, 1.45911098e-01f, 6.26817644e-02f,
  4.47162092e-01f, -1.21326812e-01f, 8.33362699e-01f, 7.15754688e-01f, -1.08056411e-01f, 2.15355624e-02f, 4.77658898e-01f, 8.50508213e-01f, -1.93204626e-01f, 1.15389884e-01f,
  -2.26166978e-01f, 5.27191460e-01f, 6.59268796e-01f, -5.70330441e-01f, 2.53397673e-01f, 1.20024726e-01f, -3.77225764e-02f, 4.29417610e-01f, 1.86706796e-01f, -1.03970133e-01f,
  2.08618015e-01f, 1.10088132e-01f, 7.52091408e-02f, -3.08931470e-01f, 2.39692271e-01f, 2.59842128e-01f, -2.84036219e-01f, 2.66101748e-01f, -6.58174276e-01f, 1.98997930e-01f,
  3.28354090e-01f, -3.17687660e-01f, 6.47891641e-01f, 6.99196681e-02f, 8.90955210e-01f, -5.87146401e-01f, 5.67563295e-01f, 1.43509731e-01f, -2.41538107e-01f, 7.18780041e-01f,
  3.74947608e-01f, -8.75972867e-01f, 1.00535762e+00f, -4.57832783e-01f, -1.96723510e-02f, 6.10836565e-01f, 2.28955701e-01f, 1.53079078e-01f, 2.56865591e-01f, 1.58131450e-01f,
  4.18803170e-02f, 4.48809385e-01f, 2.83943474e-01f, 1.35473609e-01f, 4.45266455e-01f, -4.82567459e-01f, 2.56541744e-02f, 5.59100270e-01f, 2.11394310e-01f, -2.55406857e-01f,
  2.50074387e-01f, 1.18338592e-01f, -1.69884771e-01f, -7.30309635e-02f, 1.27975702e-01f, 7.33668327e-01f, -2.45768040e-01f, -5.48557222e-01f, 6.61970675e-01f, 4.84176129e-01f,
  2.63434559e-01f, 4.16188121e-01f, 1.26285404e-01f, 1.36333036e+00f, -2.46577874e-01f, -4.98643786e-01f, 4.59327102e-02f, 3.57655555e-01f, 2.11639717e-01f, -1.37094453e-01f,
  1.56330347e-01f, -1.47486553e-01f, -1.92546502e-01f, -2.46477708e-01f, -7.13871494e-02f, 9.69475880e-03f, 1.10265419e-01f, 3.82406294e-01f, -1.28037110e-01f, -1.71137184e-01f,
  -4.48911101e-01f, -3.77314053e-02f, -3.37124527e-01f, 8.24213251e-02f, 3.69750112e-01f, 8.66193771e-02f, 8.12081099e-02f, -2.02680439e-01f, 5.82158506e-01f, 2.00421795e-01f,
  8.82640839e-01f, 9.46205407e-02f, 3.66908908e-01f, -3.76435995e-01f, 9.44845751e-02f, -6.47273481e-01f, 6.65917337e-01f, 2.39483640e-01f, -7.65740097e-01f, 9.51668084e-01f,
  1.95665523e-01f, -3.46930278e-03f, 1.51840806e-01f, 2.28967935e-01f, -2.04925746e-01f, 3.10456038e-01f, 1.90343782e-01f, 2.41408542e-01f, 1.24998763e-01f, -8.17005485e-02f,
  3.00438523e-01f, 4.72091019e-01f, 3.15038800e-01f, -3.31308961e-01f, 1.12095043e-01f, 4.33767676e-01f, 1.33299232e-01f, 1.64364904e-01f, 5.78760862e-01f, -2.06760578e-02f,
  -4.06022251e-01f, 1.75597873e-02f, 2.92095065e-01f, -7.82159809e-03f, 3.73081625e-01f, -3.96482497e-01f, 8.38880390e-02f, 6.84847474e-01f, 4.39877570e-01f, -2.12705851e-01f,
  2.67081112e-01f, 4.49443817e-01f, 2.84593165e-01f, 1.21571705e-01f, 5.61979488e-02f, 1.18871346e-01f, 2.39771888e-01f, 4.21451211e-01f, 1.73293293e-01f, 2.80714452e-01f,
  5.44319093e-01f, -1.12349046e-02f, -2.77749270e-01f, 1.85436825e-03f, -1.29043981e-01f, 2.48790935e-01f, 4.53559637e-01f, -2.57064462e-01f, 2.74361987e-02f, 2.68401295e-01f,
  4.03268367e-01f, 4.85318333e-01f, 1.04659939e+00f, 5.17843425e-01f, -3.33414972e-01f, 1.77981749e-01f, -4.39387947e-01f, 2.49250934e-01f, 2.29007706e-01f, -7.57521451e-01f,
  -2.09258564e-04f, 5.43628752e-01f, 3.58172536e-01f, -7.30959773e-01f, 8.68511945e-02f, 1.16733655e-01f, 2.86957651e-01f, 2.78398007e-01f, 1.48765266e-01f, 3.97339463e-01f,
  1.64773807e-01f, 3.51238489e-01f, 1.25715047e-01f, 1.21945456e-01f, 9.05433595e-02f, -2.27090880e-01f, -6.50797933e-02f, -1.81763187e-01f, 3.73098761e-01f, -1.73667371e-01f,
  -7.31640086e-02f, 1.71291485e-01f, -2.38772884e-01f, -5.33620059e-01f, -2.70437032e-01f, 9.96969566e-02f, 6.10615373e-01f, 3.94342124e-01f, -4.60240185e-01f, 7.91625977e-01f,
  6.47266768e-03f, 6.47736013e-01f, 6.51839554e-01f, 5.31122029e-01f, 3.31599921e-01f, -1.05914555e-01f, 4.26083207e-01f, 9.95834246e-02f, 4.71186876e-01f, -2.58894652e-01f,
  1.07428305e-01f, 5.90837121e-01f, 3.75392854e-01f, 2.48864621e-01f, 3.45023811e-01f, 2.31419176e-01f, -6.74227253e-02f, 1.10667817e-01f, -5.38903654e-01f, 1.60433769e-01f,
  1.17774822e-01f, -1.11638635e-01f, -1.30009025e-01f, -1.28742829e-01f, 3.46166283e-01f, 4.88460869e-01f, 2.91868687e-01f, 5.00386298e-01f, -2.80860722e-01f, -4.79421973e-01f,
  3.01026940e-01f, -1.02176332e+00f, 1.99195713e-01f, -4.28362489e-01f, 2.42508143e-01f, 2.41507962e-02f, -1.24814376e-01f, 4.72929239e-01f, -5.80209447e-03f, -9.29704979e-02f,
  2.39955522e-02f, -1.57521456e-01f, 1.98977485e-01f, -9.78620350e-02f, 1.93548739e-01f, -9.50445533e-02f, 1.19686075e-01f, 3.79827887e-01f, 5.94978034e-02f, -2.58429557e-01f,
  -2.02700689e-01f, 1.38878599e-01f, 5.70533518e-03f, 1.42080709e-01f, 1.01477243e-01f, -6.12527542e-02f, 3.95877093e-01f, -8.57154310e-01f, -4.92383718e-01f, 2.27664396e-01f,
  -5.85262403e-02f, 7.46611953e-01f, -6.97175443e-01f, -2.55759686e-01f, 4.13066506e-01f, 2.02210128e-01f, 1.61746144e-01f, 6.91758335e-01f, 8.95748511e-02f, 1.06864119e+00f,
  -1.37250498e-01f, -6.06465712e-03f, -4.65639412e-01f, -2.27801830e-01f, 1.82631984e-01f, -4.68451113e-01f, -4.49061900e-01f, -4.50628996e-01f, -6.12012558e-02f, -2.20893204e-01f,
  1.21054284e-01f, 8.00842419e-03f, 1.48909152e-01f, 9.60824713e-02f, 7.89881572e-02f, -1.02920689e-01f, 7.20420107e-02f, 8.65949690e-02f, -2.12622672e-01f, 7.92681932e-01f,
  2.07739130e-01f, -4.82312679e-01f, 9.68569294e-02f, 5.72017372e-01f, 5.11696637e-01f, -1.80830762e-01f, 5.00330813e-02f, 8.52310002e-01f, -5.80027401e-01f, 1.64648756e-01f,
  -5.01562834e-01f, 7.50081539e-01f, 8.97346660e-02f, -1.56569816e-02f, 1.90555021e-01f, 6.67081773e-02f, -1.68889705e-02f, 1.33354068e-01f, -1.06070362e-01f, -1.63224153e-02f,
  7.65249804e-02f, 3.28413129e-01f, 2.91796699e-02f, -1.67428374e-01f, 4.99454141e-02f, 6.70363531e-02f, 5.25873639e-02f, -6.50211647e-02f, -1.35795429e-01f, -1.71668425e-01f,
  2.13912085e-01f, -1.06939629e-01f, -7.10888505e-01f, 3.98591906e-01f, -4.83417809e-01f, 1.98210344e-01f, 4.01383609e-01f, -4.64012831e-01f, -1.59502253e-01f, 1.09737086e+00f,
  -9.01871383e-01f, 4.67398405e-01f, 4.71937269e-01f, 5.28602183e-01f, -7.58452043e-02f, 3.79793830e-02f, -3.57545689e-02f, -1.01049945e-01f, 1.26551419e-01f, 6.49480045e-01f,
  -1.76260248e-01f, 2.31630743e-01f, 1.72158673e-01f, 1.00554876e-01f, 3.14054608e-01f, -2.30448708e-01f, -2.56686807e-01f, -3.51975739e-01f, -5.77810526e-01f, -2.02335656e-01f,
  -2.19727740e-01f, -7.84911513e-02f, 5.83248675e-01f, -4.61405039e-01f, -1.72222340e+00f, 7.53357947e-01f, -2.74805427e-01f, -5.86699307e-01f, 2.35303491e-01f, -5.35822809e-01f,
  -1.85340405e-01f, -2.50020385e-01f, 9.54511523e-01f, 1.19345542e-02f, 1.98832422e-01f, -5.19524813e-01f, 1.80122316e-01f, 3.74565758e-02f, 2.41872355e-01f, 1.40453100e-01f,
  -1.96719453e-01f, 1.37881413e-01f, -1.25099272e-01f, 6.87155500e-02f, 6.39239838e-03f, -1.29683882e-01f, 4.95788343e-02f, -3.95101383e-02f, 2.88425803e-01f, -7.65438825e-02f,
  1.34465337e-01f, 1.63925476e-02f, 1.35695487e-01f, -1.41603351e-02f, 5.78839257e-02f, 3.90815645e-01f, 2.89520115e-01f, -4.07722831e-01f, 1.21114552e+00f, 1.85038060e-01f,
  1.61240637e-01f, -7.00712562e-01f, 3.15589458e-02f, 2.91970491e-01f, 9.27896142e-01f, 4.65378799e-02f, -7.06286132e-01f, 6.40431762e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.05604520e-02f, -5.91032691e-02f, 4.01138157e-01f, -1.32986181e-03f, 5.28536141e-01f, -1.00509591e-01f, 2.15544134e-01f, 2.35609636e-01f, 4.85907406e-01f, 2.35880986e-01f,
  -2.28270859e-01f, 7.84983672e-03f, 5.66466391e-01f, 4.35343266e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -7.67570913e-01f, -1.87806085e-01f, -3.05357218e-01f, -1.63937837e-01f, 5.93074150e-02f, -4.18716699e-01f, -2.80750513e-01f, -5.64567089e-01f, -6.90036833e-01f, 6.24406487e-02f,
  -5.15651941e-01f, -5.57801649e-02f, -2.03837350e-01f, -4.51207489e-01f, 4.40154523e-02f, -2.10369661e-01f, 1.10939391e-01f, 1.23973697e-01f, -9.37840194e-02f, 2.46483326e-01f,
  1.68061793e-01f, 1.51436374e-01f, 1.84129536e-01f, -8.76528084e-01f, -2.11089060e-01f, -3.51700187e-02f, -7.61730373e-01f, -9.46966112e-01f, 4.53608483e-01f, -5.35497010e-01f,
  -2.40176901e-01f, 1.58745423e-01f, -2.90752769e-01f, -5.96480787e-01f, -2.60530621e-01f, -1.16009384e-01f, -2.51610518e-01f, 3.50426108e-01f, -7.13443637e-01f, -7.95017481e-01f,
  2.19960839e-01f, 1.46839544e-01f, -1.05118319e-01f, 3.98433983e-01f, -5.96906900e-01f, 7.70292938e-01f, 2.25349292e-01f, 2.11703092e-01f, 1.20961308e-01f, -6.28229082e-01f,
  -2.23925158e-01f, 2.56256253e-01f, 4.87899303e-01f, 5.45147173e-02f, -5.91244102e-01f, 1.25508770e-01f, 4.18003440e-01f, -1.42707676e-01f, -5.36550164e-01f, 8.09795260e-02f,
  -4.63921398e-01f, -1.36408269e-01f, -4.15000886e-01f, -9.56298470e-01f, 4.80040573e-02f, 2.34790668e-01f, -6.68136895e-01f, 4.57051098e-02f, -2.98082411e-01f, 4.71563041e-02f,
  8.75285715e-02f, -7.16352090e-02f, -6.95901662e-02f, 7.40963697e-01f, -7.48266056e-02f, 6.25861734e-02f, 3.87375563e-01f, -6.39342844e-01f, -2.25093797e-01f, -8.92638341e-02f,
  1.98651955e-01f, -4.02880520e-01f, -9.89186585e-01f, -1.93891808e-01f, 2.54964560e-01f, 5.23987293e-01f, -2.05348685e-01f, 4.87612724e-01f, -4.28124756e-01f, 3.46727997e-01f,
  -6.91994905e-01f, -8.60332608e-01f, -7.99131811e-01f, -5.46273232e-01f, -4.83737230e-01f, 3.30690891e-01f, -2.35074922e-01f, 8.51574689e-02f, -1.54510826e-01f, -3.83804083e-01f,
  6.87738657e-02f, 2.07013786e-02f, -8.12444746e-01f, -1.92689985e-01f, 2.14990214e-01f, 8.87511894e-02f, -1.79197356e-01f, -8.03905129e-02f, -7.55814373e-01f, -2.72228062e-01f,
  1.23707898e-01f, 3.11839543e-02f, 7.46836245e-01f, -1.06934257e-01f, 3.88909280e-01f, -5.04744291e-01f, -8.73688400e-01f, 3.70707572e-01f, -5.70915759e-01f, 4.13630098e-01f,
  -6.21829212e-01f, -5.65118730e-01f, 1.22841462e-01f, -9.33092475e-01f, 9.56468135e-02f, 3.75505090e-01f, -1.03498697e+00f, 4.73379269e-02f, 1.91378891e-01f, -2.81069130e-01f,
  4.54112023e-01f, 7.68046305e-02f, 1.89779580e-01f, -7.71235228e-01f, 4.07557279e-01f, 8.74913335e-02f, 6.30226061e-02f, 6.82748258e-02f, 1.30183136e+00f, 3.33220065e-01f,
  8.14592123e-01f, 9.39574838e-01f, -1.30466685e-01f, -3.89597058e-01f, -2.12586224e-01f, -2.92145997e-01f, 3.26579452e-01f, -7.05743551e-01f, 2.19266623e-01f, -6.65947199e-02f,
  2.26018399e-01f, -1.43320471e-01f, -3.94377500e-01f, -4.39848602e-01f, 1.31612480e-01f, -9.04682204e-02f, 2.74619788e-01f, -4.88097787e-01f, -5.12885153e-01f, 2.68073350e-01f,
  5.07190764e-01f, 2.94212550e-01f, -4.78615075e-01f, 5.20055741e-02f, -1.41616091e-01f, 2.75610894e-01f, 2.37797573e-01f, 8.89548063e-01f, 2.79259890e-01f, 6.43467188e-01f,
  -6.29473627e-01f, -4.83464390e-01f, 5.21938264e-01f, 3.52894634e-01f, 3.53562593e-01f, -3.63315821e-01f, 3.16074342e-01f, 1.41718447e-01f, -1.69045001e-01f, 1.94524258e-01f,
  1.15576841e-01f, -6.49165034e-01f, 4.90206957e-01f, -3.35173607e-01f, 4.05874103e-01f, -3.42289388e-01f, 5.17493308e-01f, -9.68540683e-02f, -5.01800478e-01f, -5.84239960e-01f,
  -6.64523602e-01f, 1.41746640e-01f, -2.49563958e-02f, 3.52996618e-01f, 3.52898508e-01f, 5.66442430e-01f, 1.25034690e-01f, 5.77580094e-01f, 1.30825058e-01f, -5.43989018e-02f,
  6.64812088e-01f, -3.43184561e-01f, 5.25670230e-01f, -4.15915400e-02f, -3.71096253e-01f, -3.40246081e-01f, -2.86792785e-01f, 2.66931921e-01f, -2.08547577e-01f, -2.49452397e-01f,
  -9.49173868e-01f, -2.63822466e-01f, 1.34487316e-01f, -8.90506923e-01f, 2.04207033e-01f, -8.02284777e-02f, 2.32089199e-02f, 1.59590632e-01f, 7.20477551e-02f, -2.01780740e-02f,
  -1.10397547e-01f, -4.95402992e-01f, 6.89890623e-01f, 1.33773550e-01f, -2.01493129e-01f, -4.06687111e-01f, 1.39350176e-01f, -2.50883281e-01f, -6.58849999e-02f, 1.33687705e-01f,
  -1.24433614e-01f, 1.51769176e-01f, -2.93513626e-01f, -3.67883623e-01f, -5.14882505e-01f, 6.25561237e-01f, -2.47293472e-01f, -2.73630202e-01f, -4.56405319e-02f, 5.01939237e-01f,
  -2.61266351e-01f, -9.98066962e-02f, 1.11806341e-01f, -8.56921256e-01f, -1.75550103e-01f, 1.08060971e-01f, 1.09444149e-01f, 6.45828173e-02f, -3.12009782e-01f, 1.81777000e-01f,
  -6.38974071e-01f, 2.74350524e-01f, 1.85075864e-01f, 1.45183235e-01f, -7.40626335e-01f, 6.92223087e-02f, -1.44728844e-03f, 4.68189389e-01f, 5.52093863e-01f, -1.16696365e-01f,
  3.35695893e-01f, -6.51454687e-01f, 6.78755641e-01f, 1.48291365e-04f, 7.02797771e-02f, -1.60465166e-01f, -6.51696682e-01f, 1.86314583e-01f, 7.39338994e-01f, -9.06581700e-01f,
  -5.08101404e-01f, 7.87260309e-02f, 4.59330171e-01f, 6.55803502e-01f, -3.30703080e-01f, 2.63178676e-01f, -6.37310266e-01f, -2.26040319e-01f, -5.51486313e-01f, -3.10896635e-01f,
  2.52518594e-01f, 5.35309911e-01f, -8.35388124e-01f, 1.44508034e-01f, -1.68038860e-01f, 3.02439302e-01f, -5.73975563e-01f, -4.83097851e-01f, 6.56572282e-01f, 4.85509664e-01f,
  5.63790560e-01f, 3.49833757e-01f, 1.62237212e-01f, -3.79567742e-01f, 1.88969165e-01f, -6.83009177e-02f, -4.36783373e-01f, -6.83566406e-02f, 4.04886156e-01f, -6.65745080e-01f,
  -6.92729354e-01f, -9.34003055e-01f, 6.67522788e-01f, 3.84259582e-01f, -7.16600120e-01f, 3.26335639e-01f, -6.60878867e-02f, -9.08779919e-01f, 5.81939757e-01f, -1.08699650e-01f,
  4.79145050e-01f, 1.21794276e-01f, -4.85825330e-01f, -3.26718360e-01f, 7.85019472e-02f, -1.10294320e-01f, -1.26529431e+00f, -2.37949744e-01f, -1.79641441e-01f, 2.85914242e-01f,
  1.92222282e-01f, -2.08357409e-01f, 3.36836040e-01f, -2.17385247e-01f, -7.26622581e-01f, 4.12170321e-01f, -3.19592953e-01f, -6.17178619e-01f, -4.69385624e-01f, -8.22449267e-01f,
  -5.07784545e-01f, 1.00179887e+00f, 5.75124860e-01f, 1.05257019e-01f, 1.11340858e-01f, -5.78702867e-01f, 4.38391656e-01f, 9.88686323e-01f, -7.03152597e-01f, -7.81995893e-01f,
  -4.84666318e-01f, 4.98102456e-01f, -1.08928525e+00f, -7.79513359e-01f, 5.88697016e-01f, -6.64535880e-01f, 3.71542454e-01f, -8.75111997e-01f, 4.04805124e-01f, -6.00221694e-01f,
  -6.95220828e-01f, 2.80212730e-01f, -7.36721456e-01f, -1.30478546e-01f, -7.17060566e-01f, -9.86791123e-03f, -1.00342885e-01f, -5.45925982e-02f, 5.91537207e-02f, -1.15536273e-01f,
  1.23083450e-01f, -2.33899127e-03f, 5.11506975e-01f, 3.50875519e-02f, -4.33013558e-01f, 2.43010536e-01f, 4.21750784e-01f, -3.21327031e-01f, -1.89528450e-01f, -1.66659445e-01f,
  1.30699903e-01f, 2.94059992e-01f, -7.96098113e-01f, -4.36602622e-01f, -3.33371073e-01f, 2.70310611e-01f, -2.51039118e-01f, -4.04163420e-01f, 2.92718798e-01f, -1.10977009e-01f,
  -4.28866535e-01f, 5.23824155e-01f, 4.70634490e-01f, -8.48097384e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.55632094e-01f, -1.28404409e-01f, 8.99645910e-02f, -4.19027060e-01f, -1.93261668e-01f, -1.19422667e-01f, 2.86616743e-01f, -1.00989491e-01f, -5.03995828e-02f, 2.82182097e-01f,
  1.70898676e-01f, -4.20158237e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    