/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.53040093e-01f, -1.68232217e-01f, 1.24111049e-01f, 1.03350967e-01f, 2.78352231e-01f, 2.40749165e-01f, 3.43352199e-01f, -9.87584740e-02f, -6.64936081e-02f, -1.67392343e-01f,
  6.95866197e-02f, 9.70969871e-02f, 7.59688318e-02f, -3.02354638e-02f, 5.38920403e-01f, -3.50275934e-02f, 1.07221603e-01f, -9.35482979e-02f, -1.17943689e-01f, -8.31834599e-03f,
  8.05300567e-03f, -7.19339326e-02f, 8.31054449e-02f, -2.16821935e-02f, 1.15782738e-01f, -2.97414549e-02f, 9.05442759e-02f, 7.84685835e-02f, 7.01985061e-02f, 5.98477349e-02f,
  -2.76528634e-02f, -2.39918187e-01f, -5.52608781e-02f, -7.29017630e-02f, 3.18980813e-02f, -3.11095035e-03f, 1.96996797e-02f, 8.51520374e-02f, 3.34380642e-02f, -2.99608596e-02f,
  6.31504431e-02f, 4.66713905e-02f, -1.01729028e-01f, -4.75319196e-03f, -3.17933783e-02f, -2.85721198e-02f, 2.95735896e-02f, -7.44712949e-02f, -8.05951953e-02f, 4.84429346e-03f,
  -7.65863284e-02f, -1.08700925e-02f, -1.30161988e-02f, 9.55586322e-03f, 1.23281479e-01f, -7.57879391e-02f, -5.04001975e-02f, 6.45738915e-02f, -1.22102415e-02f, -3.37582491e-02f,
  1.69591364e-02f, -1.33528579e-02f, -1.58976559e-02f, -2.56016472e-04f, 2.09999643e-02f, -2.50470899e-02f, 7.94908032e-02f, -5.47825098e-02f, 5.02298065e-02f, -1.55109167e-02f,
  1.08915595e-02f, 8.50941706e-03f, -2.44643763e-02f, 4.72168438e-03f, -5.07932603e-02f, -6.94220811e-02f, 1.23166945e-03f, -3.77686173e-02f, 7.57362694e-03f, 9.65517480e-03f,
  7.41186738e-02f, 3.04300850e-03f, 4.10982408e-02f, 1.29608661e-02f, -3.42799574e-02f, 8.82368907e-02f, 3.98276076e-02f, -6.95064515e-02f, 3.11033847e-03f, 1.09371915e-01f,
  -2.27023158e-02f, 8.06444138e-02f, 3.01255360e-02f, 1.67876892e-02f, -4.20304984e-02f, 1.36466371e-02f, -3.09421564e-03f, 7.13362871e-03f, 5.52145168e-02f, 4.89675160e-03f,
  -1.18637737e-02f, -5.61501645e-03f, 6.05645627e-02f, -2.50573899e-03f, 7.72304162e-02f, 3.51858810e-02f, 6.05601184e-02f, 7.95717761e-02f, 1.09234236e-01f, -7.02855885e-02f,
  9.59995538e-02f, 1.42020928e-02f, 4.37284410e-02f, -3.89183760e-02f, -4.84212190e-02f, 8.99768025e-02f, 5.24863154e-02f, -1.08443119e-01f, 4.46103979e-03f, 3.73267531e-02f,
  6.52057230e-01f, -4.86411452e-02f, -1.92437097e-01f, 1.01199806e-01f, 2.08680928e-01f, -2.80370116e-01f, -1.18613923e-02f, 8.22760388e-02f, 3.22083324e-01f, -1.36850467e-02f,
  3.70836933e-03f, 3.50551005e-03f, 5.01574203e-03f, -1.45885572e-01f, -2.05993071e-01f, -5.57821877e-02f, -1.67254344e-01f, 4.73649427e-02f, 6.07544929e-02f, 8.21727365e-02f,
  7.56943151e-02f, -7.42392614e-02f, -1.05781287e-01f, 4.86263447e-02f, -3.31869652e-03f, -3.79341170e-02f, -2.57433355e-02f, -4.30329032e-02f, -2.65470147e-01f, -1.70919850e-01f,
  -1.58136323e-01f, 1.49916988e-02f, -4.64035608e-02f, -4.36737016e-02f, 3.74971032e-02f, -1.05383424e-02f, -5.61937131e-02f, -7.56061822e-02f, -3.79644632e-02f, 6.69626577e-04f,
  3.03336028e-02f, 2.53680628e-02f, -5.93112456e-03f, 1.94500051e-02f, 8.48075077e-02f, 5.32084890e-02f, 1.67568289e-02f, 1.16464337e-02f, 9.36834291e-02f, -2.04696618e-02f,
  4.24281918e-02f, -4.85753566e-02f, 4.04495820e-02f, -3.36449593e-02f, 3.39176655e-02f, -1.70977932e-04f, -1.19375966e-01f, -5.93476258e-02f, -1.02452803e-02f, 4.62429784e-02f,
  1.87911391e-02f, 5.51365092e-02f, 1.66384224e-02f, -7.49826804e-03f, 1.14064310e-02f, 2.39158161e-02f, 2.72994433e-02f, -8.63068085e-03f, 4.98759113e-02f, -7.49921845e-03f,
  6.12222552e-02f, 2.27710977e-02f, -1.45568252e-02f, 8.22251569e-03f, 3.53827737e-02f, 2.72667427e-02f, -3.56723252e-03f, 1.52923511e-02f, 5.52932434e-02f, -3.24120112e-02f,
  2.77997693e-03f, -1.46801099e-02f, -1.47159202e-02f, -3.22526991e-02f, -1.21549685e-02f, -1.97395422e-02f, -1.46634439e-02f, -4.17006128e-02f, 5.64098544e-03f, -2.27352083e-02f,
  -8.00926015e-02f, -1.06963426e-01f, -1.03623057e-02f, 2.31058113e-02f, -5.90262078e-02f, 1.19503001e-02f, 3.18030315e-03f, 2.29586139e-02f, -5.39761670e-02f, -1.93499774e-02f,
  -1.55232858e-03f, -1.64775201e-03f, 1.77020095e-02f, 2.00779010e-02f, -3.96475568e-02f, -4.27396521e-02f, -2.20280960e-02f, -3.80956158e-02f, -9.78484564e-03f, -1.39819393e-02f,
  7.20222620e-03f, 6.82494864e-02f, 4.19278145e-02f, 3.83727774e-02f, 2.78515257e-02f, -3.79197411e-02f, 6.11093566e-02f, 4.52151634e-02f, -3.72384563e-02f, -4.90063541e-02f,
  -1.74499065e-01f, 1.74553052e-01f, -2.72841722e-01f, -1.28456622e-01f, -6.40445505e-04f, -2.77805746e-01f, -3.19463640e-01f, 1.93273902e-01f, -2.35456362e-01f, 2.83725441e-01f,
  1.03442132e-01f, -7.07006380e-02f, -7.65739288e-03f, 1.55511528e-01f, -3.89115542e-01f, -1.61034971e-01f, -5.90405241e-02f, -4.87329140e-02f, -1.94136705e-02f, 2.90780701e-02f,
  -1.36438012e-01f, 1.95452303e-01f, -1.66631103e-01f, 1.98993295e-01f, -1.00066133e-01f, -8.35842788e-02f, 1.47892296e-01f, -5.26423790e-02f, 2.54169703e-01f, -5.96344564e-03f,
  1.23109501e-02f, 1.42216563e-01f, -9.39483047e-02f, 2.64121890e-02f, 6.95699975e-02f, 5.40454872e-02f, -5.51799871e-02f, -7.80176818e-02f, -1.58063062e-02f, 8.50750785e-03f,
  -9.55514386e-02f, -2.10584775e-02f, 8.26213732e-02f, -5.74514344e-02f, -5.93190733e-03f, -6.35569468e-02f, -5.36657162e-02f, -4.13767770e-02f, -1.68374106e-02f, -1.40353039e-01f,
  -3.41610350e-02f, -4.87669893e-02f, -6.59093484e-02f, 1.33899506e-02f, -1.05065234e-01f, -2.12464646e-01f, -9.84312668e-02f, -8.01606849e-02f, 2.40990222e-02f, 1.32649112e-03f,
  5.94798941e-03f, -3.06085814e-02f, -2.42699068e-02f, 3.71165089e-02f, -2.88132508e-03f, 1.33487195e-01f, 4.22790051e-02f, 1.66533932e-01f, -9.13230106e-02f, 3.89347933e-02f,
  1.63237706e-01f, 1.23310061e-02f, 4.39467803e-02f, 1.52209029e-02f, -9.21522267e-03f, 1.60216764e-02f, 2.52252314e-02f, 7.87561238e-02f, -1.31762335e-02f, 6.49627065e-03f,
  5.51876798e-03f, -9.77062434e-03f, 1.27129059e-03f, -5.73360070e-04f, -5.65699711e-02f, 2.43555550e-02f, 6.68474063e-02f, 6.55520661e-03f, -2.89344583e-02f, -1.31400181e-02f,
  1.42589048e-01f, 3.42995375e-01f, 1.90832037e-02f, 3.37444209e-02f, 7.60347843e-02f, 1.80776585e-02f, -8.71662274e-02f, 3.79488356e-02f, 3.47759575e-02f, 5.40345237e-02f,
  2.18171570e-02f, 4.43992801e-02f, 5.67960255e-02f, -3.21754366e-02f, 2.51183677e-02f, 8.06648880e-02f, 4.32553031e-02f, 3.57225537e-02f, 3.08751892e-02f, 4.11122777e-02f,
  1.62145033e-01f, 6.91847429e-02f, -1.90449044e-01f, 6.90354556e-02f, 1.49383545e-01f, 3.29320244e-02f, 3.32857147e-02f, -1.32484278e-02f, 8.58965069e-02f, -4.75131162e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.33902743e-01f, -8.26512516e-01f, -5.97939909e-01f, 5.47270216e-02f, 3.14656585e-01f, 1.62727460e-02f, -5.35858989e-01f, 1.59581885e-01f, -3.72666210e-01f, -2.50971526e-01f,
  -7.55032673e-02f, -4.41617638e-01f, -5.89687586e-01f, -9.94079337e-02f, 1.48116648e-02f, -6.89724386e-01f, 3.07632178e-01f, -4.73904908e-02f, -1.20027624e-01f, 2.78018564e-01f,
  9.51021016e-02f, 4.04571712e-01f, -2.77790815e-01f, 2.84863681e-01f, 1.69630498e-01f, 3.65012586e-01f, 6.06071651e-01f, -8.47565010e-02f, 5.26111484e-01f, 6.07650131e-02f,
  -1.05665393e-01f, -1.34571522e-01f, -1.85264587e-01f, -3.76249067e-02f, 2.73670573e-02f, 3.21241438e-01f, 1.14059597e-01f, -1.50187477e-01f, 7.89681524e-02f, -7.49980807e-02f,
  -9.95461643e-03f, -3.24511416e-02f, 8.79882947e-02f, -1.29274264e-01f, 2.40294784e-02f, 4.62968051e-02f, -8.11242908e-02f, 3.99509706e-02f, -1.01226248e-01f, -2.20926836e-01f,
  -2.02464879e-01f, -1.35199688e-02f, 1.45794809e-01f, -3.64655326e-03f, -9.38468948e-02f, 4.53520678e-02f, 9.61629525e-02f, -3.31027173e-02f, 1.80857912e-01f, 1.01046011e-01f,
  6.67869151e-02f, 4.94746938e-02f, -6.43790290e-02f, 5.15136681e-02f, -8.76078289e-03f, -6.84543187e-03f, -3.31145898e-02f, -4.36204039e-02f, -4.92642634e-02f, -9.30836499e-02f,
  6.91824630e-02f, -9.19319689e-02f, -6.66172057e-03f, -8.06901604e-03f, 2.76708528e-02f, 8.09649006e-02f, 1.48236249e-02f, -1.18203359e-02f, 7.69038871e-02f, -4.58744429e-02f,
  1.38166165e-02f, 4.40436043e-02f, -1.13387309e-01f, 9.55295786e-02f, 8.39952659e-03f, -7.59540126e-02f, 6.46433532e-02f, -6.94934204e-02f, 4.25837152e-02f, 1.12639457e-01f,
  1.28704840e-02f, 7.02884272e-02f, -1.23801129e-02f, -4.80972417e-02f, -1.06798317e-02f, 4.25905846e-02f, -2.37062071e-02f, -3.41333896e-02f, -9.04261991e-02f, -3.91178317e-02f,
  2.74554431e-01f, 2.03372478e-01f, 5.40175177e-02f, 5.65477535e-02f, 9.02288184e-02f, 1.21784182e-02f, 1.07609987e-01f, 7.83233787e-04f, 2.12700233e-01f, 5.97880147e-02f,
  2.22940832e-01f, 6.69124424e-02f, 1.72489569e-01f, 9.75884125e-02f, 1.93912804e-01f, 1.03676453e-01f, 1.66559815e-01f, 1.89885416e-03f, 3.77900936e-02f, 5.02115451e-02f,
  -7.20924318e-01f, 3.10556471e-01f, -6.78295314e-01f, -7.26547658e-01f, 4.80777882e-02f, -5.99701107e-01f, -2.84711272e-01f, -9.38072056e-02f, -1.82582214e-01f, 5.33047199e-01f,
  -6.38613058e-03f, 3.98349762e-02f, 2.34377801e-01f, -4.90181267e-01f, -7.30625868e-01f, -1.00955300e-01f, -7.25860834e-01f, -2.17799753e-01f, -1.73227027e-01f, -2.45958522e-01f,
  -2.44313225e-01f, -1.25197336e-01f, -4.22965020e-01f, 4.69911724e-01f, -2.19407663e-01f, 2.97245886e-02f, 2.87290543e-01f, 4.13054556e-01f, -2.32527897e-01f, 7.04309940e-02f,
  -3.39591920e-01f, -7.04883114e-02f, -7.07840249e-02f, 2.99547403e-03f, -1.78208038e-01f, -4.46230695e-02f, -5.63290007e-02f, 1.30320862e-01f, -8.85320082e-03f, -6.15489744e-02f,
  1.43228874e-01f, -9.25530791e-02f, -1.04699619e-01f, -3.47593017e-02f, 7.06122592e-02f, 6.25376925e-02f, -1.81342170e-01f, -3.15521866e-01f, -8.20777640e-02f, -1.02550089e-01f,
  -1.18784785e-01f, -7.08851293e-02f, -3.62098068e-02f, -3.28922272e-03f, -1.95893601e-01f, -3.01921479e-02f, -5.75494915e-02f, 1.21567868e-01f, -5.60183562e-02f, -1.09025620e-01f,
  -1.94737520e-02f, -9.85041708e-02f, 1.43389061e-01f, -1.00182213e-01f, -1.02786077e-02f, 5.20192944e-02f, -9.08914730e-02f, 3.22768316e-02f, -2.58935150e-02f, 6.12712093e-02f,
  -1.40270397e-01f, 1.89998206e-02f, -6.02477901e-02f, -4.67607044e-02f, -1.47996824e-02f, -8.61963443e-03f, -4.87918183e-02f, 6.28189966e-02f, -1.20270997e-01f, -8.32745209e-02f,
  5.31376787e-02f, 9.32281911e-02f, 5.04607372e-02f, -7.87848756e-02f, -8.48593786e-02f, 9.46299061e-02f, 1.01098187e-01f, 3.48263495e-02f, -1.13987073e-01f, 3.29263732e-02f,
  -2.14837104e-01f, -1.32774174e-01f, 3.23862173e-02f, -1.03728615e-01f, -4.65553515e-02f, 1.25873717e-03f, -3.52098309e-02f, 8.47602859e-02f, -9.31072161e-02f, -1.41628375e-02f,
  1.02952853e-01f, -7.39032999e-02f, -3.77872773e-02f, -7.80856088e-02f, -7.80539885e-02f, -8.85790512e-02f, 7.47702969e-03f, 6.50739744e-02f, 1.04509452e-02f, 8.59100521e-02f,
  8.13780203e-02f, 1.83237091e-01f, 1.19253129e-01f, 1.42490938e-01f, -1.64408274e-02f, 2.36619972e-02f, -2.06858404e-02f, 7.41766952e-03f, 2.72502936e-02f, 1.06177190e-02f,
  3.78533244e-01f, 7.94804633e-01f, 5.10229886e-01f, 5.48832476e-01f, -3.89843434e-01f, -3.24455202e-01f, 1.12791937e-02f, -1.41165897e-01f, 1.60269111e-01f, 3.22384655e-01f,
  -5.61161995e-01f, 8.53737056e-01f, -2.25591943e-01f, 1.15969576e-01f, -3.96238923e-01f, -3.01682383e-01f, 4.41782326e-01f, 2.95797467e-01f, -2.07523070e-02f, 3.67977232e-01f,
  -5.26921079e-02f, -3.83821607e-01f, 2.64977776e-02f, -2.26350114e-01f, 1.81985483e-01f, 3.23526055e-01f, -1.61186326e-05f, -2.19721645e-01f, 3.89840752e-01f, -1.34947985e-01f,
  -1.40067726e-01f, 2.73450501e-02f, 3.67418975e-02f, -3.25113647e-02f, -1.93821229e-02f, 5.25489822e-02f, 8.21910799e-02f, -1.51333585e-01f, -1.57837659e-01f, 1.16931148e-01f,
  1.95273042e-01f, 3.71647701e-02f, -7.44937584e-02f, -9.18629318e-02f, -1.26232598e-02f, 9.77430567e-02f, 1.16481960e-01f, 1.55239090e-01f, 6.50778338e-02f, -1.85316615e-03f,
  1.41752407e-01f, 5.06671332e-02f, 8.97109434e-02f, 8.01124796e-02f, 1.04490165e-02f, 2.29290463e-02f, 8.10358673e-02f, 8.66038725e-02f, 1.52618676e-01f, 7.83310533e-02f,
  5.32876067e-02f, -1.62408724e-02f, -7.62572959e-02f, 5.74036501e-02f, -1.87348090e-02f, -3.32453325e-02f, -1.96058732e-02f, -2.20753953e-01f, 3.00760772e-02f, -1.01663999e-01f,
  -5.35236783e-02f, 2.24886443e-02f, -1.29798725e-01f, 4.36746813e-02f, 6.29637092e-02f, 5.59002534e-02f, -1.16719110e-02f, -1.34135364e-02f, 1.13324441e-01f, 9.63011459e-02f,
  -2.03574821e-02f, -2.71452814e-02f, 6.71331137e-02f, -1.24671059e-02f, -2.03712314e-01f, -2.69962251e-02f, 8.52199718e-02f, 1.11367650e-01f, -5.58030009e-02f, 5.46962991e-02f,
  2.21209586e-01f, 3.30715835e-01f, 7.20927492e-02f, -1.51073024e-01f, 1.30804092e-01f, -8.95613879e-02f, 1.42728481e-02f, 1.09148577e-01f, 9.28865969e-02f, -1.16217241e-01f,
  6.19123466e-02f, -6.46901503e-02f, 1.52098656e-01f, -3.52096222e-02f, 6.16166368e-03f, 4.52637859e-02f, 7.69437477e-03f, 9.32520330e-02f, 6.00162223e-02f, 4.33795713e-02f,
  3.71673852e-02f, -3.51639427e-02f, 1.36858160e-02f, -2.38592774e-02f, -2.36834344e-02f, 6.43352196e-02f, 4.98700254e-02f, -3.69706973e-02f, -2.46114656e-03f, 6.28846064e-02f,
  -1.01745129e+00f, 2.39681751e-01f, 1.28013687e-02f, -6.17025316e-01f, -4.11408007e-01f, 1.13431163e-01f, -2.03618258e-01f, -1.54005975e-01f, -2.82612503e-01f, 3.07908487e-02f,
  -1.71639815e-01f, -1.05855338e-01f, 4.57039475e-01f, -1.69559821e-01f, 4.62046742e-01f, 6.11015618e-01f, -1.02976553e-01f, -5.74134625e-02f, -1.14271402e-01f, -2.20453337e-01f,
  -6.07031323e-02f, 1.13217039e-02f, 2.62413949e-01f, 1.16882823e-01f, -3.80214274e-01f, -3.47313672e-01f, -1.21761329e-01f, 5.52726351e-02f, -3.23849827e-01f, -1.67615190e-01f,
  -7.92920887e-01f, -8.00230742e-01f, -3.88703138e-01f, -6.72828630e-02f, -5.90337105e-02f, -8.33053142e-02f, -5.14254868e-02f, 7.60824606e-02f, -2.47134939e-01f, 1.85703188e-02f,
  -5.24417907e-02f, 9.27466750e-02f, -1.75531328e-01f, -3.01453024e-02f, -1.02963507e-01f, -1.01271935e-01f, 1.48278683e-01f, -1.18095344e-02f, 4.12967876e-02f, 9.32994783e-02f,
  1.34683520e-01f, 4.60474007e-02f, -1.37131393e-01f, 6.54821098e-02f, -2.01204848e-02f, -1.02671571e-01f, -9.34316218e-02f, -3.80079634e-02f, -4.95185703e-02f, -1.15114152e-01f,
  2.84126192e-01f, 6.62709698e-02f, -4.29240577e-02f, -1.06730118e-01f, 1.22827657e-01f, -9.17448923e-02f, 5.48940301e-02f, -3.31895314e-02f, 7.71545023e-02f, 6.29703254e-02f,
  -1.34914532e-01f, -2.29375307e-02f, -1.77265733e-01f, 3.42022767e-03f, 4.48825434e-02f, 2.12906562e-02f, -3.15335579e-02f, -3.30345519e-02f, 9.20323730e-02f, -1.23393044e-01f,
  9.50269029e-02f, 1.30479321e-01f, 4.76562195e-02f, -3.99128310e-02f, -3.10617574e-02f, 3.09989676e-02f, -7.72009268e-02f, 1.24426097e-01f, -4.25269976e-02f, -3.39899734e-02f,
  -8.91367972e-01f, -5.19655287e-01f, -1.58763781e-01f, -1.85425892e-01f, -2.18551829e-02f, 4.29031849e-02f, 1.83401268e-03f, -1.45146221e-01f, 6.67451844e-02f, -2.32216101e-02f,
  -7.48780221e-02f, -1.12620011e-01f, -1.07913688e-01f, -3.49939521e-03f, 1.69286340e-01f, 1.02934264e-01f, -1.43466339e-01f, -7.31800869e-02f, -1.25744984e-01f, -1.69330947e-02f,
  -4.70151454e-02f, -1.36925292e-03f, 4.20999080e-01f, 9.82277691e-02f, -7.92767629e-02f, -3.20673324e-02f, -7.81600326e-02f, 1.13073356e-01f, 5.94646260e-02f, 1.93146542e-01f,
  6.85298264e-01f, 3.02269012e-01f, 3.32087159e-01f, 1.73511833e-01f, -4.77203220e-01f, -6.14598334e-01f, -4.36644346e-01f, 1.99051470e-01f, -1.46084011e-01f, -5.67114949e-02f,
  -4.08957489e-02f, -9.51466113e-02f, 2.13148206e-01f, 3.13566983e-01f, 1.82759538e-01f, 8.95939320e-02f, 2.20466256e-02f, -2.03539997e-01f, -6.41781688e-02f, 2.83509105e-01f,
  2.86010653e-01f, 2.45480224e-01f, 5.24499536e-01f, 1.02486067e-01f, 4.96532798e-01f, 2.86949456e-01f, 3.64414811e-01f, 1.53576374e-01f, 1.42696559e-01f, -3.13350081e-01f,
  -4.42714766e-02f, 9.26241651e-02f, 6.32266402e-02f, -4.42054272e-02f, 1.09107189e-01f, -1.07612228e-02f, -1.91106230e-01f, -1.79032147e-01f, -1.76787347e-01f, 8.99793021e-03f,
  -6.70360541e-03f, -6.58446401e-02f, -2.30488405e-02f, -6.16556555e-02f, -5.28032109e-02f, -1.73567802e-01f, -9.27370191e-02f, -7.94127211e-02f, -1.06955171e-01f, 1.42716676e-01f,
  9.44809839e-02f, 2.66513322e-02f, -2.09384579e-02f, -6.31273836e-02f, 6.73039258e-02f, 4.56056669e-02f, -1.50166482e-01f, 4.72499505e-02f, -9.48861614e-02f, 4.20019664e-02f,
  1.07322156e-01f, -4.75463718e-02f, 1.34249240e-01f, 8.50937217e-02f, 5.34128956e-02f, -2.13215984e-02f, -6.81481287e-02f, 6.61029145e-02f, 2.00209022e-03f, 2.77575459e-02f,
  6.84033474e-03f, 3.17766480e-02f, -5.85951060e-02f, -1.37444258e-01f, -7.22487196e-02f, -5.91739304e-02f, -1.00581139e-01f, 5.81999160e-02f, 1.56698097e-03f, -2.25199163e-02f,
  -8.73579755e-02f, -4.11839187e-02f, 8.67263898e-02f, -9.51045826e-02f, -1.77751914e-01f, 7.05894679e-02f, 2.29729295e-01f, 1.56468302e-01f, 6.93347380e-02f, -2.33397130e-02f,
  5.59017807e-02f, 3.44267398e-01f, -5.14482241e-03f, -9.10537392e-02f, -1.04063049e-01f, 1.09714217e-01f, -3.67938913e-02f, 2.33096797e-02f, 9.35335979e-02f, 7.24291205e-02f,
  5.78331500e-02f, -1.10682599e-01f, -1.76299796e-01f, -1.96581319e-01f, 1.25807356e-02f, 1.08561762e-01f, 4.35465388e-02f, -1.65063217e-01f, 8.63868967e-02f, 1.37399599e-01f,
  1.48201436e-01f, -6.17121011e-02f, 7.71911517e-02f, -1.88962966e-01f, -3.70141142e-03f, -3.97485234e-02f, -6.09043315e-02f, -5.46404012e-02f, 1.16005749e-01f, 3.21828574e-02f,
  5.95653415e-01f, -5.74338973e-01f, -2.31863335e-01f, -1.83750436e-01f, -2.36714736e-01f, -4.66291904e-01f, 5.59303425e-02f, -8.49507391e-01f, -2.80577600e-01f, -5.94421625e-01f,
  5.46230935e-02f, 3.55221421e-01f, 4.28782672e-01f, -3.81891161e-01f, 9.73616958e-01f, 5.04532516e-01f, -4.25161064e-01f, -1.04167171e-01f, -2.14416012e-02f, -3.13548625e-01f,
  3.72136720e-02f, -3.80362451e-01f, 1.92771763e-01f, -7.59765208e-01f, -3.19661170e-01f, -3.76111835e-01f, 1.44179761e-01f, 5.62325493e-02f, -4.77621794e-01f, 1.24639973e-01f,
  5.10376133e-02f, -1.98032726e-02f, -9.49890241e-02f, -1.07036307e-01f, -5.33980802e-02f, 1.12047665e-01f, 1.17199793e-01f, 4.60137129e-01f, 1.30082086e-01f, -7.52039105e-02f,
  2.35691354e-01f, 3.20898220e-02f, -2.57615924e-01f, -1.97551288e-02f, -6.23088144e-02f, -1.38512596e-01f, -3.12914141e-02f, -8.14999193e-02f, -2.24193141e-01f, 7.66150206e-02f,
  1.86406192e-03f, -6.00652434e-02f, 2.13031517e-03f, -7.60465935e-02f, -2.98170629e-03f, -3.30591463e-02f, 1.00234829e-01f, 1.16446070e-01f, 2.56362924e-04f, -1.66507840e-01f,
  3.39266323e-02f, 3.65917236e-02f, 1.45819813e-01f, -3.82493064e-02f, 1.11932941e-02f, -3.92066874e-02f, 5.90661056e-02f, 1.92089882e-02f, -7.80002307e-03f, 5.43371625e-02f,
  -1.07869431e-02f, -5.77368587e-03f, -8.98422301e-02f, 1.03306085e-01f, 1.13045219e-02f, -7.75747150e-02f, 1.58715665e-01f, -4.89584059e-02f, -1.09626874e-01f, -1.46556171e-02f,
  4.42279428e-02f, 2.28402694e-03f, -2.15732548e-02f, 1.43376216e-02f, 4.21924889e-02f, 7.60024637e-02f, -5.48006855e-02f, -7.54337609e-02f, 4.32310961e-02f, 1.34041175e-01f,
  -8.75124112e-02f, -4.33633864e-01f, -9.04591233e-02f, -7.05485344e-02f, 7.24532679e-02f, -3.04206088e-02f, 6.97762221e-02f, -2.16511384e-01f, -1.79114155e-02f, 1.05749043e-02f,
  -1.15195520e-01f, -5.85075747e-03f, 2.36816872e-02f, -5.10066710e-02f, -5.03085135e-03f, -1.20825268e-01f, 5.53143099e-02f, 6.42384142e-02f, -3.88365542e-03f, -9.36017409e-02f,
  -5.50738163e-02f, 8.86526853e-02f, 1.69889972e-01f, -6.22804686e-02f, -6.77664205e-02f, 1.06999226e-01f, -8.88114870e-02f, 7.12131858e-02f, 1.36525378e-01f, 2.24148687e-02f,
  2.12660551e-01f, 8.26017082e-01f, -4.30169880e-01f, 2.18929246e-01f, -9.30469036e-02f, 1.01968384e+00f, 7.83085048e-01f, -1.40486853e-02f, 5.51980317e-01f, 6.67262316e-01f,
  2.01829314e-01f, 2.85727859e-01f, 2.49361932e-01f, 4.45696324e-01f, 2.62550384e-01f, 5.41555703e-01f, 6.24776900e-01f, 3.65724921e-01f, 4.14369293e-02f, 1.71295211e-01f,
  -2.89981831e-02f, 4.31617290e-01f, -4.37781274e-01f, -1.20645218e-01f, 1.54704694e-03f, -3.79511565e-01f, -3.21670204e-01f, -4.00078446e-01f, -1.65379584e-01f, 7.96763077e-02f,
  1.28184050e-01f, 7.81703591e-02f, -2.07009122e-01f, -2.05236804e-02f, 1.96347572e-02f, -2.16324665e-02f, -1.07009552e-01f, -1.11998826e-01f, -1.72756642e-01f, 5.94649417e-03f,
  1.72546506e-01f, -9.45299417e-02f, 1.25554070e-01f, -7.26844668e-02f, -2.38052234e-02f, -1.33631408e-01f, -1.19983941e-01f, -2.00272426e-01f, -8.99396315e-02f, -1.19024791e-01f,
  -8.29758868e-02f, -1.13069899e-01f, 7.21671656e-02f, 5.07371761e-02f, -5.30269556e-02f, 1.11803398e-01f, 1.21174738e-01f, -6.14142045e-02f, 5.43944873e-02f, 1.80689201e-01f,
  -4.50846553e-03f, 1.28941789e-01f, 3.29393372e-02f, -1.61595061e-01f, 1.61538467e-01f, -2.01962635e-01f, 5.71591705e-02f, -1.35792613e-01f, 8.22849870e-02f, 1.55956388e-01f,
  1.68085732e-02f, -1.07895568e-01f, -6.49894103e-02f, 8.77160355e-02f, 7.87038878e-02f, -3.15457471e-02f, 2.22625909e-03f, -8.58547091e-02f, -9.77771729e-02f, -2.01991066e-01f,
  4.06781472e-02f, 1.00809842e-01f, -6.67924881e-02f, -1.07003987e-01f, 1.23216636e-01f, -1.15262561e-01f, 4.78471592e-02f, -5.26874103e-02f, -4.59163934e-02f, -3.76559757e-02f,
  3.76640767e-01f, 5.59670866e-01f, -3.87711935e-02f, 1.44238248e-02f, 1.12539995e-02f, 7.42006898e-02f, 2.07775146e-01f, 1.23117127e-01f, 2.05515891e-01f, 1.44137204e-01f,
  8.45318511e-02f, 9.45677515e-03f, 2.58513018e-02f, -1.05862685e-01f, 1.31871542e-02f, 2.06082314e-01f, 1.31501719e-01f, 1.11867197e-01f, 5.56164309e-02f, -3.67517695e-02f,
  -1.34393528e-01f, 2.72367924e-01f, -4.11239602e-02f, 1.04036048e-01f, -1.92060065e-03f, 2.01568976e-02f, 9.64512378e-02f, -9.58562493e-02f, -1.27335131e-01f, 1.06691331e-01f,
  -1.16686225e+00f, 2.25807220e-01f, -4.45585608e-01f, 6.12156451e-01f, -3.33637923e-01f, -3.68888706e-01f, 2.53475875e-01f, 2.61513703e-03f, -1.84713870e-01f, 6.26830041e-01f,
  5.73215604e-01f, -2.43135974e-01f, 4.10198808e-01f, 5.03277898e-01f, -5.69282770e-01f, 3.53774577e-01f, 1.34867609e-01f, 2.38061264e-01f, -2.36016884e-01f, -3.85729335e-02f,
  -1.61939844e-01f, 3.20945948e-01f, 1.20183878e-01f, 2.53249276e-02f, -1.69330224e-01f, -4.84463684e-02f, 4.52994704e-01f, -3.47755216e-02f, 2.11116493e-01f, -1.24057993e-01f,
  4.10599224e-02f, 2.74534464e-01f, -5.23229130e-02f, -7.14959726e-02f, -1.31706700e-01f, -4.12334800e-02f, -2.88639553e-02f, 4.90573682e-02f, -1.93530060e-02f, 2.45868508e-02f,
  1.30790938e-03f, 2.20566262e-02f, 1.15180854e-02f, -4.41450486e-03f, -1.11355357e-01f, -6.93482384e-02f, -2.29008168e-01f, -8.10605660e-02f, 1.65321119e-02f, -5.46403565e-02f,
  -1.40548006e-01f, -2.68908590e-02f, 4.61764485e-02f, 8.29678699e-02f, -6.79459199e-02f, 1.31815985e-01f, 6.39364496e-02f, 2.52992492e-02f, -1.43344074e-01f, -7.95802474e-02f,
  -1.50347114e-01f, 1.11150824e-01f, -4.63074744e-02f, 7.64751732e-02f, 1.05288799e-03f, 4.49166857e-02f, -2.32999977e-02f, 5.93886562e-02f, -6.57469109e-02f, 7.93733075e-02f,
  -2.78969072e-02f, 6.58941828e-03f, -3.81537303e-02f, 8.00201818e-02f, -3.92601378e-02f, 8.30013305e-02f, -1.59648601e-02f, 2.15535853e-02f, -6.15620660e-03f, -5.77677116e-02f,
  1.17839567e-01f, -3.76833379e-02f, 4.85291667e-02f, 6.59897402e-02f, 1.08225336e-02f, 7.71725699e-02f, 5.45495488e-02f, -8.04326758e-02f, 8.60494450e-02f, -4.04774398e-02f,
  1.18414186e-01f, 1.35471359e-01f, 1.19545512e-01f, 1.93651319e-02f, 7.00045526e-02f, -6.41606599e-02f, 3.77833545e-02f, -1.69280216e-01f, 7.82484785e-02f, -8.32875594e-02f,
  6.25616610e-02f, 1.12626083e-01f, -1.17228433e-01f, 1.80594698e-02f, 9.93388593e-02f, 4.48238626e-02f, 2.58973926e-01f, 9.72959772e-02f, 1.03996016e-01f, -3.15531087e-03f,
  8.34579691e-02f, -1.29220886e-02f, -1.88562777e-02f, -3.21103483e-02f, 3.56588475e-02f, 2.91403476e-02f, -1.27217114e-01f, -8.56414884e-02f, -2.84183454e-02f, 8.51410553e-02f,
  -2.10864693e-01f, 4.03842032e-01f, 2.88368817e-02f, -5.00794351e-01f, -1.38352394e-01f, -2.12179437e-01f, -5.72876036e-01f, 1.73819259e-01f, 4.10633177e-01f, 3.19803685e-01f,
  -1.83430374e-01f, 5.13679147e-01f, 1.49210334e-01f, -2.34846890e-01f, -4.69343454e-01f, -7.91093707e-02f, -6.25219285e-01f, -2.55879402e-01f, 3.21373969e-01f, -4.81773168e-01f,
  -4.07409728e-01f, -6.19939744e-01f, -2.95962930e-01f, -2.10500285e-01f, -2.00127631e-01f, 1.69823706e-01f, -3.33160251e-01f, -1.26341432e-01f, -2.48627186e-01f, 8.80142152e-02f,
  1.06045336e-01f, 1.14711590e-01f, 1.29894659e-01f, 2.47746080e-01f, 3.59574221e-02f, -6.27872907e-03f, 1.90379025e-04f, -9.85287353e-02f, 1.00122906e-01f, -4.72986465e-03f,
  -4.81586792e-02f, 2.37349663e-02f, 7.62032792e-02f, -2.02517007e-02f, -8.54259282e-02f, 1.88462194e-02f, 7.77869225e-02f, 9.16741341e-02f, 1.15937516e-01f, -1.03752412e-01f,
  -8.01593158e-03f, 1.25282690e-01f, -1.06376726e-02f, 1.58580214e-01f, -1.03512295e-01f, -5.74211143e-02f, 7.11441319e-03f, 4.44849208e-03f, 2.20620167e-02f, -4.53527831e-03f,
  -1.63426623e-01f, -4.20767553e-02f, -6.40874878e-02f, 1.72663499e-02f, -7.16658831e-02f, -7.63219083e-04f, -1.43759372e-02f, -1.27985492e-01f, -5.79308532e-02f, -1.16282284e-01f,
  1.02832891e-01f, 6.35758862e-02f, -2.49144509e-02f, -5.46166301e-02f, -3.85927886e-01f, 1.77450050e-02f, -1.01162374e-01f, -4.13636900e-02f, -1.80848956e-01f, -2.32455339e-02f,
  -1.65233895e-01f, -5.50143458e-02f, -6.20301925e-02f, -2.08896205e-01f, 7.51737729e-02f, 6.59002066e-02f, 6.36195317e-02f, 1.16742831e-02f, 2.92830355e-02f, -1.59419104e-01f,
  1.88455865e-01f, -7.45019689e-02f, 1.16019875e-01f, 1.90556780e-01f, 1.08092904e-01f, -9.07690749e-02f, -1.78561717e-01f, 7.63713643e-02f, -7.12545440e-02f, -1.69368386e-01f,
  -4.39176597e-02f, 3.10225766e-02f, 3.67248021e-02f, -1.21556140e-01f, 3.87894139e-02f, -1.05247706e-01f, -8.49363059e-02f, 1.01006031e-01f, 3.48909386e-02f, 1.70476381e-02f,
  -4.64860443e-03f, 3.77640873e-02f, -1.37197897e-01f, -5.09581156e-02f, -1.63549017e-02f, -2.92834714e-02f, 1.16734076e-02f, 1.57710522e-01f, -6.28137887e-02f, 7.44822323e-02f,
  2.45920986e-01f, -3.27419303e-02f, -7.93243766e-01f, -2.47488365e-01f, -4.22625728e-02f, 5.40005624e-01f, 6.90621044e-03f, -1.26360983e-01f, -5.27142704e-01f, 2.89085716e-01f,
  4.91935879e-01f, -2.61405051e-01f, -2.46872559e-01f, 8.50439012e-01f, 2.42311865e-01f, 8.38433672e-03f, 6.01770580e-01f, 2.56187379e-01f, -2.26243839e-01f, 9.82082076e-03f,
  -1.56040668e-01f, 8.55531454e-01f, 1.38094306e-01f, 5.77593207e-01f, 4.66366202e-01f, -3.96381050e-01f, 1.97391406e-01f, -4.26206559e-01f, 4.07494456e-01f, 4.01884884e-01f,
  3.16876739e-01f, -8.87990072e-02f, -6.46214560e-02f, -4.21077013e-02f, -5.20180129e-02f, 3.16640176e-02f, -1.01880558e-01f, 4.73935269e-02f, -1.09716445e-01f, -5.73035181e-02f,
  -2.05375049e-02f, -3.17677297e-02f, 3.48702632e-02f, -6.88559115e-02f, -6.63341656e-02f, -7.52313435e-02f, -7.90103972e-02f, 4.13732268e-02f, -7.93929547e-02f, 8.70474894e-03f,
  -2.11886361e-01f, 1.23394514e-02f, -9.79281440e-02f, -3.92214470e-02f, -2.13920429e-01f, -8.64313990e-02f, -1.07775204e-01f, -6.69877306e-02f, -8.03899914e-02f, -1.31280618e-02f,
  1.12405293e-01f, -5.38381115e-02f, 1.20713100e-01f, 1.59060180e-01f, 5.62652983e-02f, 2.05311403e-01f, 1.65686473e-01f, -1.61655825e-02f, -1.34361073e-01f, 2.07671672e-01f,
  -3.52277607e-02f, 5.48940264e-02f, 2.99446415e-02f, 2.87565845e-03f, 1.81924865e-01f, 5.58720306e-02f, -7.53611773e-02f, 6.20236658e-02f, -2.20602810e-01f, 1.06716141e-01f,
  -6.27795001e-03f, 1.61414302e-03f, 1.39464453e-01f, -3.57352644e-02f, 4.01502429e-03f, -9.17658880e-02f, 1.48205534e-01f, 5.40404543e-02f, -1.46399632e-01f, -5.71937300e-02f,
  1.01006672e-01f, -1.82896405e-01f, -9.97538343e-02f, 2.26825792e-02f, 6.19777627e-02f, 6.45520389e-02f, -7.62915388e-02f, 1.07732758e-01f, -1.28713027e-01f, 3.31799202e-02f,
  -2.16787774e-02f, -6.60294071e-02f, -6.75996765e-02f, -1.62914880e-02f, -8.52832422e-02f, -2.81329863e-02f, -9.26689282e-02f, -4.86363098e-02f, 5.98563924e-02f, 1.75747320e-01f,
  -5.61163872e-02f, -1.16027720e-01f, -1.64558515e-01f, 9.58108064e-03f, -2.95902789e-02f, 6.31376579e-02f, -8.89446065e-02f, -8.76994133e-02f, 8.23202655e-02f, -2.81542279e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  6.56189561e-01f, 7.40770936e-01f, 5.43177307e-01f, 6.64108276e-01f, 1.12452351e-01f, 2.42701575e-01f, 7.13697314e-01f, 5.39549768e-01f, 8.98078024e-01f, 4.23108071e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  3.13933194e-01f, 2.45798931e-01f, -2.35500753e-01f, 1.73151195e-01f, 6.83677495e-01f, 3.54385614e-01f, 2.82443404e-01f, -5.17199449e-02f, -2.16503501e-01f, -3.42821628e-01f,
  -2.81083852e-01f, 9.33825597e-02f, 1.21497467e-01f, -2.37421483e-01f, -1.76089391e-01f, 4.10669953e-01f, -2.44728625e-01f, 2.97732055e-01f, 9.69912019e-03f, 1.85080081e-01f,
  -1.06660581e+00f, -1.36322707e-01f, 6.51766881e-02f, -3.05177182e-01f, -1.53230309e-01f, 1.95485204e-01f, -2.32637852e-01f, -2.31898576e-02f, -3.18763971e-01f, -4.16316211e-01f,
  8.85145366e-02f, -1.56724849e-03f, 7.68276572e-01f, 2.55402088e-01f, 1.02576718e-01f, 2.59953529e-01f, -1.07475124e-01f, -3.60650867e-01f, 3.85431617e-01f, -9.64354798e-02f,
  1.98913906e-02f, 1.15184523e-01f, 2.32193440e-01f, -4.81956989e-01f, -4.92720217e-01f, -2.09551081e-01f, 1.05269797e-01f, -4.46611010e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  4.57514912e-01f, -2.29635879e-01f, 1.24803162e+00f, -1.06886780e+00f, -6.52074754e-01f, -3.62427086e-01f, -5.58369994e-01f, 5.63307762e-01f, 7.74216831e-01f, 9.01167095e-01f,
  1.32960647e-01f, 2.22886458e-01f, 4.19006109e-01f, 3.83196801e-01f, 1.12160480e+00f, -8.66065770e-02f, 4.30851370e-01f, 7.18632519e-01f, -1.18111283e-01f, -6.80386722e-01f,
  -1.81172401e-01f, 5.47327161e-01f, 6.42592967e-01f, 1.02213299e+00f, 8.62238109e-01f, -2.25331392e-02f, 7.34329462e-01f, -6.78420305e-01f, -8.31690490e-01f, 6.98965430e-01f,
  9.27231252e-01f, -2.01338470e-01f, -1.33321345e-01f, 3.71262372e-01f, 3.73009980e-01f, -8.27273488e-01f, -2.26422966e-01f, 2.95082361e-01f, 6.59234047e-01f, 1.08325601e+00f,
  3.96748602e-01f, 4.80938435e-01f, -1.11895013e+00f, 2.77930349e-01f, -6.53568923e-01f, 8.70474100e-01f, 6.37148440e-01f, 4.23153818e-01f, 9.39190149e-01f, 3.52559477e-01f,
  1.24641307e-01f, -5.70425689e-01f, -9.59331155e-01f, 5.17576635e-01f, 7.01801181e-01f, 5.96185565e-01f, -4.92719829e-01f, 4.34666008e-01f, -6.68980420e-01f, -8.13053608e-01f,
  9.87989366e-01f, 3.48576456e-01f, 3.46881181e-01f, 7.49897003e-01f, -2.50145912e-01f, -6.94478378e-02f, 3.03950906e-01f, -3.55369329e-01f, -1.14055228e+00f, 7.32849836e-01f,
  5.08563876e-01f, -3.52113456e-01f, -9.27061774e-04f, 4.00809973e-01f, 5.88991284e-01f, 9.44988132e-02f, 4.05005664e-01f, 1.02320528e+00f, -6.03405833e-01f, 1.12822759e+00f,
  1.32143223e+00f, 6.14638746e-01f, 2.07009017e-02f, 1.06644034e+00f, 1.63805628e+00f, 1.17536917e-01f, 9.05783594e-01f, -7.38676041e-02f, 1.10014713e+00f, -7.58851469e-01f,
  3.94530684e-01f, -2.32155457e-01f, 9.67124701e-01f, -4.34137493e-01f, -1.47601729e-02f, 2.44777754e-01f, -2.05569342e-01f, 3.84662390e-01f, -4.02036309e-01f, -3.99782434e-02f,
  -8.94298553e-02f, 5.93851566e-01f, -6.14654601e-01f, -7.09244370e-01f, 1.37036130e-01f, -6.05897382e-02f, 7.12412775e-01f, 8.85868251e-01f, 5.73982060e-01f, 1.16482747e+00f,
  -8.66471708e-01f, 5.76004982e-01f, 6.65374756e-01f, 8.63754511e-01f, 1.17517996e+00f, -2.42207572e-01f, -9.92767692e-01f, -1.09812093e+00f, -6.53090715e-01f, -5.50332606e-01f,
  8.77752721e-01f, 9.09849465e-01f, 8.56349245e-02f, -7.58361757e-01f, 8.01501215e-01f, -1.58819512e-01f, 5.18629432e-01f, 8.35961923e-02f, -6.85238600e-01f, 8.78754973e-01f,
  -3.87640595e-02f, 5.53688109e-01f, 1.06837422e-01f, -9.94497359e-01f, -8.70626986e-01f, 6.39525235e-01f, -2.87512392e-01f, 9.41610634e-01f, -4.99706149e-01f, 7.82925725e-01f,
  6.42554104e-01f, 4.04709995e-01f, 4.88183409e-01f, -6.12447619e-01f, 7.91783929e-01f, 9.08508182e-01f, 1.29657164e-01f, 1.02437055e+00f, -1.25787169e-01f, -9.73839343e-01f,
  9.42741930e-01f, -9.37188044e-02f, -9.40837681e-01f, 4.96590734e-01f, -2.56767347e-02f, 1.00260007e+00f, -1.22229613e-01f, -1.02567792e+00f, 3.36702764e-01f, 8.11796904e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  -3.12284622e-02f, 2.36430779e-01f, 3.30392778e-01f, 4.15246457e-01f, 1.19621195e-01f, 1.10494733e+00f, 2.82948911e-01f, 4.98135269e-01f, 5.55963278e-01f, 1.23157132e+00f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  9.21128094e-02f, -4.66328770e-01f, -1.31551966e-01f, -3.21899801e-01f, 1.53981363e-02f, -6.18535995e-01f, 3.43813807e-01f, -6.18541241e-01f, 3.56272042e-01f, 2.30170175e-01f,
  6.24039173e-01f, -8.33638489e-01f, 2.57276416e-01f, 4.28087674e-02f, -1.33718019e-02f, -8.97767127e-01f, -8.60483885e-01f, -5.39209306e-01f, -1.10984929e-02f, 3.98464292e-01f,
  -5.02809703e-01f, -5.78567922e-01f, -5.09903133e-01f, -8.04078996e-01f, -9.83545125e-01f, 2.96062738e-01f, 5.87520361e-01f, 3.06280106e-01f, 6.48846865e-01f, 7.26598129e-03f,
  -8.61667693e-01f, 2.46173274e-02f, -6.80315852e-01f, 1.10793404e-01f, -2.51605213e-01f, 2.25219667e-01f, 1.25495744e+00f, -9.49790478e-02f, -8.53260577e-01f, -2.78052539e-01f,
  3.17757845e-01f, 3.06360811e-01f, 4.23054367e-01f, 1.59631353e-02f, -7.35440910e-01f, -7.62232363e-01f, -6.27096832e-01f, 5.69245040e-01f, -1.43135697e-01f, -5.85471928e-01f,
  2.09139451e-01f, -8.06387007e-01f, -2.29419470e-01f, -3.78046751e-01f, 1.04803450e-01f, 5.94780445e-01f, 6.08747363e-01f, -2.98614446e-02f, -3.71532381e-01f, -1.46079338e+00f,
  -3.01336139e-01f, -8.36942136e-01f, 5.91673970e-01f, -1.28972638e+00f, -3.23660970e-02f, 2.28936046e-01f, 5.13218522e-01f, -7.65347004e-01f, 8.25823903e-01f, 1.08335936e+00f,
  3.91881317e-01f, 1.09589323e-02f, -6.49925396e-02f, 1.87900290e-01f, -1.70322999e-01f, -1.32845938e+00f, -7.42151380e-01f, 7.69074738e-01f, -1.59459144e-01f, 6.06928587e-01f,
  6.48021102e-01f, 1.85419545e-02f, 1.53740376e-01f, -2.39700645e-01f, -7.24070007e-03f, -9.06105936e-01f, 4.51494098e-01f, -9.68216956e-01f, -1.41550827e+00f, 1.00096107e-01f,
  -4.05576169e-01f, 4.96137083e-01f, -2.69775182e-01f, 8.44723761e-01f, 3.75441551e-01f, -7.05375850e-01f, 2.46313423e-01f, 3.61140341e-01f, 3.52201968e-01f, 1.01016414e+00f,
  -6.15147293e-01f, 8.94712269e-01f, -8.89454603e-01f, -4.59143132e-01f, -7.62798309e-01f, -4.93783534e-01f, -1.60295165e+00f, 1.46904135e+00f, -2.61359155e-01f, -1.71768129e-01f,
  1.39210090e-01f, 7.08617330e-01f, -3.55684072e-01f, -4.96766925e-01f, -2.89945722e-01f, -1.36086658e-01f, -5.18880486e-01f, -5.51380336e-01f, 7.05894411e-01f, -2.21169293e-01f,
  5.51854432e-01f, -1.03295708e+00f, -7.59801447e-01f, -4.71295089e-01f, -4.67045873e-01f, -8.97888780e-01f, 3.54424894e-01f, 3.65180045e-01f, -7.46953208e-03f, -3.76304150e-01f,
  -2.98336715e-01f, -5.94873607e-01f, -2.85774440e-01f, 2.26174876e-01f, -5.20659029e-01f, 9.10307050e-01f, -8.57186019e-01f, -8.60096633e-01f, 5.57638228e-01f, 4.17983532e-01f,
  6.27724290e-01f, -2.64469445e-01f, -5.99839628e-01f, -7.96347797e-01f, 4.17106390e-01f, 1.95282057e-01f, 3.75134706e-01f, 1.83691725e-01f, 9.82103348e-01f, -1.00881886e+00f,
  -9.04528022e-01f, -8.11826587e-01f, -5.93353659e-02f, -8.97916615e-01f, -4.40926403e-01f, -1.33196592e+00f, 5.09043396e-01f, -4.70332593e-01f, 1.05259430e+00f, 7.10636854e-01f,
  2.89660186e-01f, -1.71369255e-01f, 5.14834933e-02f, 8.50800872e-01f, -7.27032185e-01f, 4.55615640e-01f, -6.33237064e-01f, 7.26166606e-01f, 7.59969592e-01f, 8.05740654e-01f,
  -3.99636447e-01f, -5.52338585e-02f, -5.29819906e-01f, -7.76998401e-01f, -9.44486916e-01f, -5.50835967e-01f, 2.76059687e-01f, -1.80957332e-01f, 1.17494769e-01f, -4.83549327e-01f,
  -3.27580303e-01f, 2.45229885e-01f, 5.09294093e-01f, 4.24156129e-01f, 3.01938593e-01f, -1.14897263e+00f, -1.11884320e+00f, 4.43104625e-01f, -2.65480727e-01f, 5.68255126e-01f,
  -8.45467806e-01f, -8.22606564e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -6.31598532e-02f, -4.26841021e-01f, -6.29565045e-02f, -1.24010079e-01f, 3.55298787e-01f, 4.99767102e-02f, 4.46335644e-01f, -1.12454548e-01f, -1.63891628e-01f, 4.12236422e-01f,
  8.20661262e-02f, -8.02378654e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    