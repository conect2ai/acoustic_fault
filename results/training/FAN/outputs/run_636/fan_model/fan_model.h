/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.81894952e-01f, -3.45241040e-01f, -2.51065791e-01f, -2.90073633e-01f, 3.61342169e-02f, -1.54493093e-01f, -3.26726973e-01f, -8.57378542e-03f, 1.85098872e-02f, -1.78052738e-01f,
  -9.68027860e-02f, 1.01634473e-01f, -3.65332961e-02f, 2.10592076e-01f, 3.24960053e-02f, -2.20174015e-01f, -1.49221495e-01f, 8.81443545e-02f, 3.04303169e-01f, 2.78977603e-01f,
  1.43776253e-01f, -4.61706221e-02f, 1.07634239e-01f, 1.01006292e-01f, -2.17994563e-02f, 1.98774531e-01f, -1.94071665e-01f, 3.06111649e-02f, 6.48620203e-02f, -1.84450876e-02f,
  1.32242814e-01f, -9.48727652e-02f, 1.18285589e-01f, 8.04585367e-02f, 3.42367142e-02f, 2.90801190e-02f, 6.33338168e-02f, 6.38072612e-03f, 6.36946410e-02f, 2.63457838e-03f,
  -2.53156584e-04f, 6.79617152e-02f, 1.78604969e-04f, 9.12859067e-02f, -5.63074946e-02f, 7.76474401e-02f, 4.07317244e-02f, 1.42159071e-02f, 7.02777803e-02f, 3.82295065e-02f,
  -1.24641526e-02f, -7.20135123e-02f, -1.17596593e-02f, -4.29650508e-02f, 8.44511241e-02f, 1.65822700e-01f, 5.11310212e-02f, 7.94364437e-02f, 1.48348868e-01f, 8.83241892e-02f,
  1.62684709e-01f, -3.15303057e-02f, 6.32010475e-02f, -3.41995098e-02f, 3.05298250e-02f, -4.26888093e-02f, -9.89085212e-02f, -1.84963420e-02f, 6.51091114e-02f, -2.02390924e-02f,
  -2.59130821e-02f, -7.92323984e-03f, 7.29731694e-02f, -9.15092453e-02f, 2.21279282e-02f, -5.14586642e-02f, 1.80391204e-02f, -8.22279453e-02f, 4.31714430e-02f, -8.05208758e-02f,
  -5.04904203e-02f, 6.34470209e-03f, -6.19099289e-02f, 1.88221422e-03f, -8.21801499e-02f, -7.38567906e-03f, 1.64170284e-02f, 3.88028398e-02f, -2.55540293e-02f, -5.78364618e-02f,
  -9.22074169e-02f, 5.71100675e-02f, 3.10280584e-02f, 4.98290285e-02f, -4.28621359e-02f, 9.13154427e-03f, -1.41123319e-02f, 1.15335926e-01f, -2.49616206e-02f, 1.79184526e-02f,
  5.73991276e-02f, -8.10550004e-02f, -1.66155905e-01f, 1.63832083e-02f, 3.18841375e-02f, -3.82032245e-02f, -8.91424343e-02f, -2.27704868e-02f, -3.15564163e-02f, -1.06816050e-02f,
  -4.60827015e-02f, 1.82216540e-02f, -4.27491888e-02f, 7.44182291e-03f, 9.92007107e-02f, -2.24107541e-02f, 7.50017632e-03f, 1.04076505e-01f, -3.57933007e-02f, -7.12779239e-02f,
  5.05577922e-01f, -1.79304436e-01f, 6.44137501e-04f, 3.67510051e-01f, 9.73089784e-02f, -1.40616819e-01f, -2.01985866e-01f, 1.70363665e-01f, 3.30444634e-01f, -9.91353081e-05f,
  -1.86644584e-01f, 3.75581309e-02f, 8.84805694e-02f, 5.93243092e-02f, 1.26865357e-01f, 2.62466133e-01f, 3.51311326e-01f, 2.94531196e-01f, 1.59068882e-01f, -4.39783111e-02f,
  9.34759900e-02f, 1.60369098e-01f, 2.62113482e-01f, 1.90003395e-01f, 1.34261414e-01f, 1.05207726e-01f, 1.10779285e-01f, -6.10630177e-02f, -1.12094782e-01f, 1.74310058e-01f,
  -4.74503562e-02f, -6.56459332e-02f, 8.33136067e-02f, 6.48887008e-02f, -5.90161011e-02f, 1.57346904e-01f, 7.77185708e-02f, 1.45216271e-01f, 3.51956375e-02f, 1.05350047e-01f,
  6.46077767e-02f, 4.50919457e-02f, 1.51291773e-01f, 4.79704551e-02f, 1.22440442e-01f, 6.13730289e-02f, 2.03549013e-01f, 1.84949905e-01f, 9.00548473e-02f, -3.69111896e-02f,
  -3.82788256e-02f, -4.53435518e-02f, 6.85516000e-02f, -5.76744936e-02f, 7.79486224e-02f, 8.06443915e-02f, -5.93726151e-03f, 2.94521861e-02f, 8.32718611e-02f, 2.79292345e-01f,
  4.50072959e-02f, 6.18586987e-02f, -2.69582607e-02f, -5.75188771e-02f, -5.22719920e-02f, -6.53095171e-02f, -3.28208730e-02f, -4.20276932e-02f, -2.65395716e-02f, 2.46156584e-02f,
  -5.03464229e-02f, -5.79837263e-02f, -4.23254184e-02f, -2.98439749e-02f, -1.00148804e-02f, 3.25465687e-02f, -7.00298846e-02f, -1.20843828e-01f, -2.64783781e-02f, -3.09178382e-02f,
  -1.05657056e-01f, -7.05051124e-02f, -2.43180040e-02f, -8.02530125e-02f, -1.37597397e-02f, -2.90088281e-02f, -4.99314517e-02f, 1.70548297e-02f, -9.34070256e-03f, -2.00881734e-02f,
  1.29699573e-01f, -1.83244064e-01f, 2.19346974e-02f, 7.15671703e-02f, 4.67110500e-02f, 3.94827873e-02f, -7.35229924e-02f, 9.30624902e-02f, 3.80781069e-02f, 3.42352949e-02f,
  8.20458122e-03f, 5.75111806e-02f, 9.27990675e-03f, 7.80212209e-02f, 3.02574299e-02f, 2.78060175e-02f, 1.66492835e-02f, 5.27063273e-02f, 2.79252436e-02f, -4.59874086e-02f,
  8.97663236e-02f, 1.17455974e-01f, 2.16466099e-01f, 1.14065446e-01f, 4.38092723e-02f, 1.23713031e-01f, 1.99643262e-02f, 1.71800315e-01f, 5.71220927e-02f, 2.03642175e-01f,
  -2.89211888e-02f, 2.05531269e-01f, -1.68626115e-01f, 1.66058347e-01f, 8.04627240e-02f, -4.71397638e-02f, -1.53191835e-01f, -2.94578671e-02f, 1.62368208e-01f, 1.77912578e-01f,
  2.98168123e-01f, 3.32845300e-01f, 2.67300993e-01f, 1.67245075e-01f, 3.55601609e-02f, -1.03210546e-01f, -1.77694619e-01f, -1.56184420e-01f, -7.27847517e-02f, 5.23643941e-02f,
  2.66560405e-01f, 7.14523122e-02f, 1.36894450e-01f, 4.20505404e-02f, 8.35992172e-02f, 3.13323230e-01f, 2.22425073e-01f, 2.54924476e-01f, 2.23388866e-01f, 3.31927016e-02f,
  2.47130796e-01f, 8.06055441e-02f, 1.62039563e-01f, 2.72288531e-01f, 1.84139982e-01f, 1.06470034e-01f, 1.66972280e-01f, 1.31927028e-01f, 2.41175890e-01f, 1.64992914e-01f,
  6.00071587e-02f, 1.42065257e-01f, 1.00228414e-01f, 1.60030559e-01f, 1.79180186e-02f, 8.35089907e-02f, 2.41328757e-02f, -8.59496370e-02f, -2.25495901e-02f, 5.23024164e-02f,
  1.46817893e-01f, 2.04524826e-02f, -3.40015553e-02f, 2.18292531e-02f, 1.24990150e-01f, 5.19931316e-02f, 8.30186456e-02f, 1.12202182e-01f, 8.67656246e-02f, 2.10211933e-01f,
  1.73507724e-02f, 2.74149738e-02f, -8.23466703e-02f, -9.14981887e-02f, -1.30758081e-02f, -8.72220024e-02f, -3.95037197e-02f, -2.21913718e-02f, -9.57350507e-02f, -1.15311839e-01f,
  -1.40342906e-01f, -1.30037516e-01f, -7.07652196e-02f, -9.30252075e-02f, -6.49971217e-02f, -9.69388261e-02f, 2.04188619e-02f, -5.54511473e-02f, -9.34889168e-02f, -1.50441095e-01f,
  -8.54322463e-02f, -9.19749290e-02f, -5.68609051e-02f, -1.42021686e-01f, -7.93638229e-02f, -1.20541386e-01f, -5.23670912e-02f, 5.88019320e-04f, -1.29041925e-01f, -7.19350576e-02f,
  4.01313365e-01f, 5.28793149e-02f, 2.24896967e-01f, 6.77234605e-02f, 1.43455967e-01f, 1.39047712e-01f, 2.41643816e-01f, 1.61055937e-01f, 1.97555810e-01f, 1.05861761e-01f,
  1.59233168e-01f, 4.73186150e-02f, 6.49492219e-02f, 2.64716055e-02f, 9.78030860e-02f, 5.23541309e-02f, 1.13292076e-01f, 1.19575024e-01f, 1.17455944e-01f, 1.08913898e-01f,
  1.00414045e-01f, 1.12928919e-01f, 1.07864164e-01f, 1.98263556e-01f, 1.60903558e-01f, 1.65766314e-01f, 1.83024243e-01f, 2.12366745e-01f, 1.00857370e-01f, 2.16578111e-01f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.39118028e-01f, 5.07981002e-01f, -2.14686617e-02f, 4.33298647e-02f, 1.76743641e-01f, -1.02421574e-01f, 1.11154439e-02f, -7.60608390e-02f, -7.46850818e-02f, 6.04368560e-02f,
  8.97293612e-02f, 5.29993623e-02f, -3.04563008e-02f, -1.23614483e-01f, -7.91072696e-02f, 1.14913188e-01f, 7.00323656e-03f, 6.98331324e-03f, -1.75219223e-01f, -6.92696422e-02f,
  9.73994937e-03f, 2.37823680e-01f, 2.14957193e-01f, 5.75737609e-03f, 3.05729751e-02f, -1.83373615e-01f, 7.22464323e-02f, 1.69653788e-01f, 1.78708822e-01f, 3.39458317e-01f,
  1.14411853e-01f, 2.70759404e-01f, -4.45662528e-01f, 6.22816160e-02f, 1.77993521e-01f, 1.53312340e-01f, 6.31951690e-02f, 1.46525845e-01f, 6.49247468e-02f, 2.63257883e-02f,
  8.05395693e-02f, 1.78966552e-01f, 1.25072703e-01f, 4.28709984e-02f, -6.66599795e-02f, -3.78127955e-02f, 6.58993796e-02f, -1.68230206e-01f, -1.84402943e-01f, -4.96648205e-03f,
  1.31992489e-01f, 3.93762738e-01f, 1.24250390e-01f, -1.93480209e-01f, -2.66499072e-01f, -1.40388072e-01f, -1.26640871e-03f, -1.64682150e-01f, -1.59044251e-01f, -9.76918861e-02f,
  4.06219661e-02f, 8.02948996e-02f, 3.53865921e-02f, 4.42517661e-02f, -1.97708860e-01f, -6.83552250e-02f, -6.85672611e-02f, -1.72180951e-01f, -5.23123257e-02f, 1.92911290e-02f,
  -8.76856148e-02f, -1.77652806e-01f, -1.40676111e-01f, -8.30671489e-02f, -1.39045030e-01f, 6.08838499e-02f, -1.03492819e-01f, -7.44050667e-02f, -8.44582096e-02f, -1.62826735e-04f,
  -7.40538388e-02f, -1.39652342e-01f, -2.32594404e-02f, -1.32656964e-02f, 2.79954541e-02f, -1.23887219e-01f, -1.93428993e-02f, -2.03486159e-01f, 1.84606798e-02f, -1.34528494e-02f,
  -1.22575924e-01f, -3.04410815e-01f, -2.28146031e-01f, 2.78233051e-01f, 3.39101255e-01f, 2.38129068e-02f, 1.44794345e-01f, -1.11594155e-01f, 6.58994690e-02f, -8.26301202e-02f,
  5.10335937e-02f, -6.72925711e-02f, 6.31517023e-02f, -1.11150980e-01f, -1.02526143e-01f, 9.82045084e-02f, 1.51727065e-01f, -1.14656240e-01f, -6.81482926e-02f, -5.76269142e-02f,
  3.54157276e-02f, 2.10013762e-02f, -4.79399711e-02f, -2.92140990e-01f, -1.09077618e-01f, -3.79019082e-01f, -3.09838802e-01f, -2.41128162e-01f, -2.74472028e-01f, -2.74762809e-01f,
  5.12616634e-01f, 9.63023975e-02f, -9.50935423e-01f, 1.67139322e-01f, -3.55693758e-01f, -4.42362130e-01f, -2.21309066e-01f, 2.68396586e-01f, 2.46934086e-01f, 4.71949726e-02f,
  5.14412783e-02f, 2.59757191e-01f, 1.00036114e-01f, -3.31112221e-02f, 6.35127425e-02f, -2.45970637e-01f, -4.11965013e-01f, -4.33681816e-01f, -4.43609327e-01f, -2.31113523e-01f,
  -2.48070639e-02f, -5.10572009e-02f, -1.12067871e-01f, -1.64967820e-01f, -1.34781361e-01f, -1.00196697e-01f, -3.51113588e-01f, -4.76214111e-01f, -5.83104551e-01f, -5.15408516e-01f,
  -6.10790968e-01f, -3.80549133e-01f, 1.69012100e-01f, 1.33814842e-01f, -5.98899350e-02f, 2.06797063e-01f, 5.72689297e-03f, 1.35860547e-01f, 2.77377605e-01f, 1.50660932e-01f,
  -2.04669721e-02f, 3.25763896e-02f, -1.37592144e-02f, -1.00027971e-01f, -3.23726386e-02f, -8.31142813e-02f, 1.64430469e-01f, -2.66900044e-02f, 5.65531999e-02f, 8.97092819e-02f,
  2.28678789e-02f, -6.63885623e-02f, -1.52029945e-02f, 1.23398952e-01f, -8.94433632e-02f, -1.19830191e-01f, -9.46495533e-02f, -1.54776439e-01f, -1.82439372e-01f, 1.85563833e-01f,
  -2.09886074e-01f, -8.79906397e-03f, -1.13630995e-01f, 3.00179366e-02f, 2.27568626e-01f, 1.36656478e-01f, 2.33985651e-02f, 1.56249702e-01f, -2.93707643e-02f, 1.57140255e-01f,
  2.12309241e-01f, -5.41505329e-02f, -4.09766883e-02f, 4.13629189e-02f, -1.16532624e-01f, 2.30108202e-02f, -3.22929136e-02f, 7.40514174e-02f, 1.42872557e-01f, 1.87014088e-01f,
  9.11313370e-02f, -7.54096825e-03f, -6.97923079e-02f, -1.00879475e-01f, -1.58605307e-01f, -3.79663892e-02f, 3.86702456e-02f, -6.72967806e-02f, 1.67233318e-01f, 3.46204080e-02f,
  2.98607498e-01f, -3.30101728e-01f, 2.17483312e-01f, 2.33335376e-01f, -1.92071237e-02f, 9.52969566e-02f, -1.25746161e-01f, -2.27949377e-02f, 4.59963083e-02f, -4.38013598e-02f,
  -1.71068147e-01f, -8.01481605e-02f, -8.91457945e-02f, 1.96990147e-02f, 5.42291161e-03f, -2.26934180e-02f, 1.04336932e-01f, 5.44937626e-02f, 9.12927836e-02f, -2.68293992e-02f,
  1.19530223e-01f, 2.02118844e-01f, 3.78102899e-01f, 2.13018835e-01f, 1.17640309e-01f, 6.22993745e-02f, 2.06018444e-02f, -7.16223521e-03f, 6.94206730e-02f, 3.80147398e-01f,
  -6.66776717e-01f, -2.33021826e-01f, 5.27353764e-01f, -1.77750722e-01f, 9.87179130e-02f, 6.46745190e-02f, 2.88331896e-01f, -7.05064014e-02f, -1.58281609e-01f, 5.86872213e-02f,
  -1.28084645e-01f, -2.55290329e-01f, -1.20740846e-01f, -1.24640882e-01f, -1.42431229e-01f, 2.91840702e-01f, 2.02963367e-01f, 1.11957692e-01f, -6.88899402e-03f, -1.93190910e-02f,
  -7.20923394e-02f, -1.82761028e-01f, -2.64184147e-01f, -1.64042413e-01f, -1.48778126e-01f, -5.89382276e-02f, 1.04413159e-01f, -1.48870468e-01f, -1.22608058e-01f, -1.28574371e-01f,
  3.55260760e-01f, -5.66963375e-01f, -4.30838428e-02f, -3.65288377e-01f, -7.00215995e-02f, -2.11883575e-01f, -5.66750839e-02f, -1.33982286e-01f, -9.23179984e-02f, 1.05258010e-01f,
  -1.77526593e-01f, -1.81763411e-01f, -1.74891278e-01f, 3.95166129e-03f, -7.30290338e-02f, -3.69355939e-02f, -2.71900240e-02f, -2.03106478e-01f, -2.16373950e-02f, -7.71864802e-02f,
  -1.09686740e-01f, -5.90125620e-02f, 2.01108530e-01f, -4.20526713e-02f, -1.39428347e-01f, -1.44574553e-01f, -4.37067486e-02f, -1.86592698e-01f, -2.72054393e-02f, 6.38059601e-02f,
  6.51319101e-02f, 1.47796288e-01f, 7.32122338e-04f, 7.14602321e-03f, 1.34838432e-01f, 9.46655795e-02f, 4.52306792e-02f, 5.32412603e-02f, 7.21040368e-02f, 1.05424732e-01f,
  1.73725933e-01f, 1.38577998e-01f, 1.70360520e-01f, 1.29487187e-01f, 3.31851542e-02f, -4.87048142e-02f, 9.68673602e-02f, -7.85049424e-03f, -6.48332238e-02f, -5.72637394e-02f,
  -4.28060330e-02f, 6.29711449e-02f, -1.30472193e-02f, 4.74161580e-02f, 3.76530141e-02f, 4.02094536e-02f, 3.53384055e-02f, -9.17806663e-03f, -2.03925204e-02f, 3.72860506e-02f,
  7.57597089e-02f, -1.69591069e-01f, 2.32784167e-01f, -2.54151616e-02f, -2.86509264e-02f, -2.56908908e-02f, 7.54992012e-03f, 6.63199797e-02f, 3.57132480e-02f, 9.43098068e-02f,
  -7.63591528e-02f, 5.07354140e-02f, 8.13093334e-02f, 1.22168586e-01f, 1.82096079e-01f, 1.22215874e-01f, 6.99131712e-02f, 1.21802382e-01f, -4.00005840e-02f, 7.81383365e-02f,
  1.43493012e-01f, 2.74079800e-01f, 3.46525520e-01f, 2.62180328e-01f, 6.29108846e-02f, 1.58783019e-01f, 2.51179129e-01f, 1.31116465e-01f, 2.18754485e-01f, 3.17222774e-01f,
  -2.71813154e-01f, -1.34437829e-01f, -4.22169976e-02f, 1.25964601e-02f, 1.42527506e-01f, 4.25076997e-03f, -4.09411073e-01f, -2.86702752e-01f, 2.80994445e-01f, 1.41415834e-01f,
  3.58887732e-01f, 1.40284911e-01f, -1.84392780e-01f, -3.42300236e-01f, -6.87293947e-01f, -3.39224935e-01f, -4.46195602e-01f, -4.01734322e-01f, -4.77646142e-01f, -2.07255766e-01f,
  7.78943971e-02f, -3.82497646e-02f, -1.78713679e-01f, -2.52280176e-01f, 6.67746887e-02f, -1.09543145e-01f, -1.27405792e-01f, -9.97187942e-02f, -1.38527155e-01f, -7.75690377e-02f,
  4.24118415e-02f, 1.58043057e-01f, -2.02621985e-03f, 1.38228446e-01f, 1.94565892e-01f, -4.05758061e-02f, -9.48849395e-02f, -1.67706776e-02f, 6.66664615e-02f, 9.19826403e-02f,
  8.02321956e-02f, 1.55800164e-01f, -2.11528912e-02f, 4.63999547e-02f, -1.24612376e-01f, -7.40110800e-02f, 1.17403857e-01f, -2.11150140e-01f, -3.01647723e-01f, -3.06532048e-02f,
  2.55272150e-01f, 5.41338734e-02f, -2.99634486e-01f, -3.33744556e-01f, -1.43840805e-01f, -2.33802781e-03f, -1.55893967e-01f, -1.61860213e-01f, -4.20530349e-01f, -3.14776301e-01f,
  1.38005406e-01f, 1.44552235e-02f, 2.95516476e-02f, 2.19992287e-02f, -2.63895616e-02f, 8.23741779e-02f, -7.21861124e-02f, -8.32748115e-02f, -4.20917235e-02f, -1.02140203e-01f,
  3.23526114e-02f, 1.58641160e-01f, 7.45444149e-02f, -8.72929916e-02f, -2.03469560e-01f, -3.29853222e-02f, 1.02466337e-01f, -1.38908818e-01f, -1.57039449e-01f, 4.18397319e-03f,
  -1.42291682e-02f, 7.40114078e-02f, 3.18844110e-01f, -1.03131756e-01f, -1.68888979e-02f, 4.44035530e-02f, 3.53594236e-02f, 1.07207876e-02f, -2.60605086e-02f, 8.01451430e-02f,
  -2.27453988e-02f, 1.61014974e-01f, 1.23987637e-01f, -1.03915483e-01f, 3.38550024e-02f, 2.29089826e-01f, 1.40134886e-01f, 1.33059576e-01f, 2.30533406e-01f, -1.29012287e-01f,
  -1.18783824e-01f, -1.74456835e-01f, 1.88597813e-01f, 7.10811391e-02f, -1.37829170e-01f, -1.29850164e-01f, 8.45736191e-02f, 5.20942546e-03f, -1.67601824e-01f, 3.91667247e-01f,
  -8.43705889e-03f, -3.13112736e-01f, -3.30649257e-01f, -3.83313298e-01f, -2.93308675e-01f, -3.08720887e-01f, -4.12338108e-01f, -2.19110295e-01f, -3.78609151e-01f, -5.88325262e-01f,
  -6.77473426e-01f, 3.34682643e-01f, -1.04058936e-01f, 1.19914286e-01f, 1.88355893e-01f, 2.72008955e-01f, 2.34023347e-01f, 1.65313840e-01f, 3.23471516e-01f, 1.83419749e-01f,
  -3.77556719e-02f, 2.04094559e-01f, 1.50687292e-01f, 2.00860485e-01f, 1.98199414e-02f, 1.45141467e-01f, 2.54046053e-01f, -2.90680118e-02f, -2.37880588e-01f, 6.21934049e-02f,
  3.68084073e-01f, 1.81122527e-01f, -1.46322176e-01f, 9.58428457e-02f, 2.60683179e-01f, 3.35550755e-02f, 3.26276571e-02f, 5.21599501e-02f, 2.30669767e-01f, 1.89082474e-01f,
  -1.45873949e-01f, -1.95643783e-01f, 1.04520947e-01f, 8.70784372e-02f, -6.61857650e-02f, 8.93890299e-03f, -1.55626103e-01f, -3.48074809e-02f, -6.22930303e-02f, 3.43662910e-02f,
  4.81776008e-03f, -6.97287023e-02f, -1.85535356e-01f, -1.45238981e-01f, -1.13845080e-01f, -4.08478901e-02f, 3.53541598e-02f, 1.03472225e-01f, 1.82389513e-01f, 9.15157571e-02f,
  2.32441142e-01f, -2.78209941e-03f, 9.49606597e-02f, 7.62058347e-02f, 4.73468713e-02f, 4.02426235e-02f, -4.88664657e-02f, -1.06669053e-01f, -1.25857387e-02f, 9.52577125e-03f,
  -8.83909240e-02f, 1.58789888e-01f, 6.61924407e-02f, -2.04076633e-01f, -6.98734075e-02f, 1.19036041e-01f, 8.25776532e-02f, 1.01677738e-01f, -1.87815800e-01f, -7.40562603e-02f,
  -2.35427450e-02f, -1.02852471e-01f, 3.35788657e-03f, 3.84607539e-02f, 6.73321113e-02f, 1.91364530e-02f, 9.34657231e-02f, -3.23706530e-02f, -1.79203928e-01f, -8.88457373e-02f,
  -1.17074989e-01f, 9.95715484e-02f, 2.86234766e-02f, -2.87233945e-02f, 2.11321890e-01f, 2.78874431e-02f, 4.27564047e-03f, -1.79524869e-01f, -2.90720668e-02f, 8.48054439e-02f,
  3.94906342e-01f, -2.52369612e-01f, -1.00692257e-01f, 3.33599672e-02f, -3.16826738e-02f, 2.26782099e-03f, -6.95103407e-03f, 9.22112446e-03f, 5.95963076e-02f, 2.97518559e-02f,
  9.71258059e-02f, 2.02073827e-02f, 6.22918969e-03f, -2.40146164e-02f, -2.07225174e-01f, -5.97220697e-02f, 2.48892866e-02f, 9.04031098e-02f, 1.56580076e-01f, 1.92914769e-01f,
  1.74379855e-01f, 1.68745086e-01f, 1.07405141e-01f, 3.33629549e-02f, 1.46444008e-01f, 6.52052239e-02f, 1.53777860e-02f, -1.04121277e-02f, -3.15063074e-03f, 2.15774160e-02f,
  -2.99177885e-01f, 3.88907015e-01f, 6.54611230e-01f, -1.49308130e-01f, 4.01607379e-02f, 4.01309617e-02f, 1.94598719e-01f, -1.75343212e-02f, -1.60561875e-01f, 7.96529353e-02f,
  -7.99134597e-02f, -1.86174199e-01f, 6.12342767e-02f, -7.77618885e-02f, 1.37186889e-02f, 2.27154598e-01f, 3.33154202e-01f, 2.41671830e-01f, -1.90889880e-01f, -5.20877123e-01f,
  -4.01362956e-01f, -1.68755531e-01f, -7.35319629e-02f, 4.02391218e-02f, 1.85376145e-02f, -2.99874067e-01f, 4.48744118e-01f, 1.40214890e-01f, 1.57625049e-01f, -4.63691764e-02f,
  4.34466861e-02f, 3.83247703e-01f, -1.10225216e-01f, -2.22128838e-01f, 2.67457008e-01f, -5.35916612e-02f, -1.22118376e-01f, 2.37783030e-01f, -2.53833644e-02f, 1.35858372e-01f,
  4.26430926e-02f, 1.08151762e-02f, 3.16771073e-03f, -2.38353536e-02f, 6.72920495e-02f, -1.42911017e-01f, 2.86362827e-01f, 1.19806305e-01f, 1.48742259e-01f, 9.21551436e-02f,
  -2.11207837e-01f, -1.95604384e-01f, 1.72282174e-01f, 6.72184080e-02f, 1.47455260e-01f, -1.97234452e-01f, 2.14495793e-01f, -1.17638603e-01f, 4.84778881e-02f, -1.52053908e-01f,
  -2.00092658e-01f, 4.16187495e-02f, 1.21378928e-01f, 9.05816928e-02f, 9.68435663e-04f, -3.70933674e-02f, 6.22509941e-02f, -2.19898392e-02f, -5.45673333e-02f, 4.57775779e-02f,
  9.87284929e-02f, -3.72810173e-03f, 1.94228411e-01f, 1.51987806e-01f, -1.52074337e-01f, -6.79649506e-03f, 7.96652492e-03f, -2.14967914e-02f, -3.09857354e-02f, 1.37982468e-04f,
  -4.50598933e-02f, -1.58042391e-03f, 9.04994830e-02f, 3.61563116e-02f, 1.19015239e-01f, 1.26601875e-01f, -6.33844808e-02f, 5.91376200e-02f, -8.31779391e-02f, 3.62684503e-02f,
  -2.55930901e-01f, 3.84484559e-01f, 5.90030849e-03f, 1.39903799e-02f, -2.40774546e-02f, 1.63239650e-02f, 1.27222598e-01f, -7.66365156e-02f, -3.97219509e-02f, -2.30276026e-02f,
  -3.39895696e-03f, 7.85486177e-02f, 1.70099288e-01f, 7.41332918e-02f, -1.89631909e-01f, -6.57944828e-02f, -1.73127413e-01f, -7.68646076e-02f, -1.00401407e-02f, -3.64763513e-02f,
  -7.16144172e-03f, -3.41056585e-01f, -4.25606489e-01f, -1.64128155e-01f, -1.93211466e-01f, -4.46003675e-01f, -1.71442136e-01f, -2.02790633e-01f, -2.29849815e-01f, -5.65625548e-01f,
  3.71150196e-01f, -3.68379891e-01f, -7.65972674e-01f, -3.25917453e-01f, -3.68250519e-01f, 5.37179261e-02f, 2.76503302e-02f, 2.72393554e-01f, -1.47175446e-01f, -2.88883716e-01f,
  -1.74404100e-01f, 1.67986110e-01f, -2.24584848e-01f, 4.09427285e-02f, 1.67281806e-01f, -2.90193647e-01f, -4.25803304e-01f, -9.13374797e-02f, 3.01824749e-01f, 4.03181911e-01f,
  2.12862819e-01f, 1.89526882e-02f, 1.35782167e-01f, -8.30248669e-02f, -4.13650244e-01f, -1.56073853e-01f, -6.12984776e-01f, -2.72645473e-01f, -1.02598123e-01f, -5.88111401e-01f,
  -4.32164431e-01f, -8.22849274e-02f, 9.67642739e-02f, 3.71945798e-02f, -3.33782643e-01f, 8.02898929e-02f, -1.02640398e-01f, -1.37449712e-01f, 5.14996983e-02f, -1.92923471e-01f,
  -1.60577059e-01f, 5.23077361e-02f, -2.42188536e-02f, -3.14242505e-02f, -1.50007680e-02f, 1.09559670e-01f, -1.86468169e-01f, 3.94882634e-02f, -1.16863243e-01f, -1.57309428e-01f,
  -2.25048419e-02f, -8.82639736e-02f, -3.99239920e-02f, 8.95740688e-02f, -6.26555830e-02f, -4.07736488e-02f, -2.05206826e-01f, -6.45135045e-02f, 8.73395875e-02f, -4.39714864e-02f,
  9.40554515e-02f, -2.59710848e-02f, 8.21868703e-02f, 1.12478649e-02f, 1.46886647e-01f, -3.52140367e-02f, 2.87062284e-02f, 1.18891187e-01f, 5.33025078e-02f, 1.27051324e-01f,
  6.76559731e-02f, -1.45380516e-02f, 5.88643365e-02f, 2.39060726e-02f, -8.20556581e-02f, 1.99525896e-02f, -1.62835624e-02f, -5.20379730e-02f, -3.78049426e-02f, -1.80424526e-02f,
  -5.01371808e-02f, 8.86247233e-02f, 2.04108488e-02f, 1.49998084e-01f, -4.20547687e-02f, -1.49807855e-01f, -4.38586855e-03f, 6.36647791e-02f, -1.84176173e-02f, 4.19330075e-02f,
  -3.81978862e-02f, 1.47608370e-01f, -1.16786487e-01f, 1.77386984e-01f, -1.40509814e-01f, 2.25087944e-02f, -1.81947514e-01f, -4.74296100e-02f, -6.09351806e-02f, -7.23218778e-03f,
  1.54637799e-01f, 1.47370711e-01f, -1.63035169e-01f, 2.61295643e-02f, 9.46605355e-02f, 8.22679251e-02f, 1.66810572e-01f, 2.75799409e-02f, 1.69548213e-01f, 2.73081157e-02f,
  -8.50917771e-02f, 2.70762026e-01f, 2.71800607e-01f, 2.54398342e-02f, 3.81736904e-02f, 1.13718368e-01f, 1.03946134e-01f, 1.99519023e-01f, 2.80607104e-01f, 8.56750682e-02f,
  6.87512234e-02f, 1.82312086e-01f, -6.45737052e-01f, 1.50450498e-01f, -4.20001328e-01f, -5.87205946e-01f, -2.27225646e-01f, -2.50566993e-02f, 1.97529256e-01f, 2.53341030e-02f,
  -4.28076498e-02f, 2.03587890e-01f, 2.66004533e-01f, 1.71271153e-02f, -1.92360520e-01f, -3.57035220e-01f, -5.00085592e-01f, -4.73414868e-01f, -2.56599069e-01f, -1.53414935e-01f,
  7.39755780e-02f, 2.06602693e-01f, 7.26861581e-02f, -7.85596743e-02f, 1.92866862e-01f, 2.71180779e-01f, 5.28844967e-02f, 1.06966555e-01f, -6.53475076e-02f, -1.68966666e-01f,
  6.09311983e-02f, -2.43238270e-01f, -2.88646162e-01f, -1.07915625e-02f, 7.60863647e-02f, -7.30023906e-02f, -2.19679490e-01f, -1.08554102e-01f, -1.17650010e-01f, -1.87910840e-01f,
  -1.46632403e-01f, -1.52262002e-01f, -2.77839065e-01f, -8.17409381e-02f, -2.21157908e-01f, -1.44421160e-01f, -1.16756625e-01f, -1.82760432e-01f, -2.64949411e-01f, -4.08746265e-02f,
  -3.19984891e-02f, -3.70536834e-01f, -1.09791785e-01f, -1.07906103e-01f, -7.27470741e-02f, -1.90068737e-01f, -7.20898658e-02f, -9.92456675e-02f, -1.80718243e-01f, 3.08915794e-01f,
  1.08524345e-01f, 6.72715604e-02f, -5.59550710e-02f, 8.74080062e-02f, 1.01453327e-01f, -2.50032591e-03f, -9.18608159e-03f, -4.53019328e-03f, -1.84219424e-02f, 8.25747550e-02f,
  -3.21253575e-02f, -3.80101643e-04f, 5.04331999e-02f, 8.41147080e-02f, -4.53495868e-02f, -1.96268007e-01f, 1.79405212e-02f, 6.49569631e-02f, -3.50347832e-02f, -1.12889871e-01f,
  -7.94057623e-02f, 1.88977811e-02f, 3.63766328e-02f, 4.99801151e-02f, -3.10603768e-01f, -1.16883762e-01f, -8.21462125e-02f, 1.31867658e-02f, -6.18495941e-02f, -2.28526592e-01f,
  7.13939428e-01f, -4.56292182e-01f, 3.07714045e-01f, 1.28117455e-02f, -1.21239752e-01f, -1.31194681e-01f, 1.38632804e-01f, -5.05690137e-03f, -4.27056588e-02f, -4.83435206e-02f,
  -2.31390238e-01f, 1.34176552e-01f, 4.46894057e-02f, -8.12947750e-03f, -1.74191400e-01f, 3.36041823e-02f, 5.08757960e-03f, 3.11366306e-03f, -1.46499112e-01f, 2.67087519e-02f,
  7.12304637e-02f, -1.74925655e-01f, 2.10254326e-01f, 2.64450282e-01f, 1.22697905e-01f, 6.50120899e-02f, 2.25347891e-01f, 2.70359278e-01f, 8.33003595e-02f, 5.46212673e-01f,
  4.82678711e-01f, -1.11686513e-01f, 8.53629634e-02f, 1.91169247e-01f, -1.65382847e-01f, -5.49089313e-01f, -7.23591626e-01f, -5.25844216e-01f, -1.12717688e-01f, -1.23670675e-01f,
  1.08942010e-01f, 1.57603070e-01f, 6.21560737e-02f, 2.02998698e-01f, -6.29955456e-02f, -1.01149447e-01f, 2.72303432e-01f, 5.05598605e-01f, 2.39748046e-01f, 7.23149925e-02f,
  2.83157825e-01f, 1.68955594e-01f, 3.25359434e-01f, 2.38503277e-01f, 3.85105819e-01f, 3.00419003e-01f, 1.81298658e-01f, 2.60820031e-01f, 1.31871477e-01f, 5.11031032e-01f,
  4.05597210e-01f, -5.08871339e-02f, 1.19465545e-01f, 2.14148834e-01f, 3.07663381e-01f, 6.70982823e-02f, 1.86678395e-02f, 2.38868427e-02f, 5.09189591e-02f, -9.13261995e-02f,
  1.10821754e-01f, 1.85257703e-01f, 4.50488217e-02f, 1.20006755e-01f, -2.83784512e-02f, -9.52514112e-02f, -3.03779226e-02f, 6.43176809e-02f, -1.24567673e-01f, 1.74584333e-02f,
  1.28593892e-01f, -3.57084163e-02f, -1.81633979e-01f, -2.18586594e-01f, -1.40102729e-01f, 1.12773150e-01f, -1.22133614e-02f, 4.39053774e-02f, -1.99578047e-01f, 1.13061503e-01f,
  6.40361235e-02f, 9.27469432e-02f, 1.26572801e-02f, -2.53799750e-04f, -2.93206722e-02f, -4.77928370e-02f, 2.86828671e-02f, -5.24275228e-02f, -1.53570268e-02f, 4.00134921e-03f,
  -9.09983143e-02f, -7.41771609e-02f, -5.33539690e-02f, 2.30933316e-02f, 2.14001521e-01f, 7.29287788e-02f, 1.63653567e-02f, 1.04312353e-01f, 1.61983117e-01f, -5.40086813e-03f,
  2.45453808e-02f, -4.22676504e-02f, 1.90405428e-01f, 5.42567894e-02f, 5.79436645e-02f, -3.05437408e-02f, 3.56389172e-02f, 3.74311507e-02f, 4.15129662e-02f, -2.72983895e-03f,
  -2.61679173e-01f, -3.22006755e-02f, 2.54000783e-01f, 1.23942442e-01f, 1.70537412e-01f, 4.14085053e-02f, 1.67577013e-01f, 8.87162685e-02f, 8.79750103e-02f, -1.47969738e-01f,
  -1.66696720e-02f, 4.78192084e-02f, 4.44316790e-02f, 1.61192752e-02f, -4.77443598e-02f, -1.44270688e-01f, 1.00784888e-02f, 6.75118193e-02f, -4.75327075e-02f, 5.51528335e-02f,
  3.30256969e-02f, -3.77595007e-01f, -3.86870474e-01f, -3.05681586e-01f, -1.75910756e-01f, 3.39587592e-02f, -1.32803231e-01f, -2.29317665e-01f, -2.51030087e-01f, -2.50216126e-01f,
  -1.58038601e-01f, -2.83985436e-01f, -1.40563786e-01f, -3.90575141e-01f, -2.92560935e-01f, -1.51816770e-01f, -6.15449131e-01f, -2.09109560e-01f, -7.52801746e-02f, -4.14349496e-01f,
  -3.27710748e-01f, -6.98783388e-03f, -5.50375581e-02f, -1.66171327e-01f, -5.01236543e-02f, -4.54522789e-01f, -1.35413185e-01f, 2.62736809e-02f, -1.18336201e-01f, -2.74354160e-01f,
  -2.60639101e-01f, -2.48567671e-01f, -6.98528960e-02f, -4.28504497e-02f, -1.88043088e-01f, -1.17855847e-01f, -1.38510466e-01f, -1.31538808e-01f, 1.65781844e-02f, -1.73189327e-01f,
  -3.91198069e-01f, -1.17384195e-01f, -1.94734663e-01f, 1.07347526e-01f, -1.58958241e-01f, -2.31255405e-02f, -8.21853951e-02f, -2.08442993e-02f, 1.26759082e-01f, -1.18221849e-01f,
  -1.53745651e-01f, 5.40608503e-02f, -1.15034264e-02f, -1.12279497e-01f, -2.70928442e-01f, -2.33393669e-01f, -3.37359086e-02f, -4.62383926e-02f, 1.69940576e-01f, -7.52399210e-03f,
  1.54682040e-01f, 1.11748381e-02f, -5.59704006e-02f, 1.58580486e-02f, 2.40288317e-01f, 1.51144043e-01f, 6.58866242e-02f, 6.38871789e-02f, 3.04178089e-01f, -7.78887272e-02f,
  -9.36573967e-02f, 2.67428122e-02f, -7.06231967e-02f, -6.99510798e-02f, 3.62436427e-03f, -5.27672730e-02f, -1.12443261e-01f, -1.30915970e-01f, -1.71151653e-01f, -1.30488515e-01f,
  -1.16212733e-01f, 1.49155647e-01f, 2.73359418e-02f, -5.40122613e-02f, -5.02279848e-02f, 1.01608843e-01f, -4.83918674e-02f, -1.25844255e-01f, -1.58042610e-02f, 2.76550706e-02f,
  9.89959985e-02f, 1.09508187e-02f, 1.70947742e-02f, 9.35600791e-03f, 4.01203372e-02f, -8.18141177e-02f, 3.60627882e-02f, 4.07926179e-03f, -5.50714843e-02f, 1.58941969e-02f,
  -4.38974082e-01f, 1.61287934e-01f, -2.32993826e-01f, -1.07692573e-02f, 6.59894422e-02f, 1.14222318e-01f, -2.46086083e-02f, 7.01688090e-03f, 1.28610775e-01f, -1.07847035e-01f,
  9.99114569e-03f, -1.94691145e-03f, -6.09801486e-02f, -2.11066604e-02f, -1.37114450e-01f, -9.83233452e-02f, -4.73545939e-02f, -1.51955396e-01f, 1.35629490e-01f, 1.97022408e-02f,
  2.29920223e-01f, -9.85275656e-02f, -1.24896280e-01f, 5.82882166e-02f, 3.94585319e-02f, 1.27809674e-01f, -1.17288500e-01f, 6.23281635e-02f, 1.45639023e-02f, -3.25988561e-01f,
  -3.56576778e-02f, -5.09865403e-01f, 1.19146537e-02f, 4.26487118e-01f, 2.57189631e-01f, -2.96635509e-01f, -8.84454429e-01f, -4.72245067e-01f, 3.21234822e-01f, -4.16289091e-01f,
  5.15371561e-02f, 2.97269762e-01f, 2.18819067e-01f, -1.43964499e-01f, -6.96777344e-01f, -6.42239690e-01f, -4.41835582e-01f, -2.65014261e-01f, -1.41388223e-01f, -2.66921699e-01f,
  -4.02332619e-02f, -6.89159110e-02f, -1.07729062e-02f, 4.02562320e-02f, 2.72427917e-01f, 3.89738590e-01f, 1.88404575e-01f, 3.73874933e-01f, 3.12293097e-02f, 3.35370123e-01f,
  8.75410661e-02f, 3.55977900e-02f, -2.41096271e-03f, 8.61957297e-02f, 1.42504483e-01f, -2.72663832e-01f, -2.29449973e-01f, 2.05205176e-02f, -1.38389081e-01f, -2.20369697e-01f,
  2.40570143e-01f, 2.31751949e-02f, 1.12738013e-01f, 3.30743045e-02f, -2.72688329e-01f, -2.38097027e-01f, -3.13669533e-01f, -2.96097964e-01f, -1.68019488e-01f, -4.77778800e-02f,
  3.91165353e-02f, 1.95091099e-01f, 5.49777336e-02f, -1.45182803e-01f, 1.46538690e-02f, 1.90678284e-01f, 4.73717116e-02f, 1.51366547e-01f, -1.02361061e-01f, 4.62114029e-02f,
  8.42081755e-02f, 1.10812940e-01f, 1.37735335e-02f, -4.11389098e-02f, 3.01521979e-02f, 1.83896273e-01f, -2.16744132e-02f, -2.89586303e-03f, 6.60664514e-02f, 1.83137972e-02f,
  2.42169984e-02f, -6.52802885e-02f, -5.78036942e-02f, -7.95578491e-03f, 1.54930234e-01f, 4.55566011e-02f, 7.30554834e-02f, -7.89495558e-02f, -3.49966288e-02f, -2.20635496e-02f,
  -6.95869029e-02f, 4.36464697e-02f, 5.60893528e-02f, -1.10666573e-01f, -1.03386119e-01f, -6.24409281e-02f, 5.40280566e-02f, 2.40643718e-03f, 2.12327749e-01f, 1.11227736e-01f,
  6.23431131e-02f, -2.27211073e-01f, -5.83691113e-02f, -1.24606416e-01f, -1.65188126e-02f, 4.10567895e-02f, 1.64659843e-02f, -2.33214378e-01f, 1.43325999e-01f, -1.54881939e-01f,
  -1.39253825e-01f, -6.45318106e-02f, -7.18355477e-02f, -2.04967596e-02f, -2.67164618e-01f, 3.13944705e-02f, -4.50637460e-01f, -2.81805340e-02f, -8.25055465e-02f, 6.02841713e-02f,
  -1.76988274e-01f, -4.09784168e-01f, -3.05132627e-01f, -2.06460461e-01f, -1.56840235e-02f, -9.97246280e-02f, 3.01546939e-02f, 2.61404403e-02f, -3.40845108e-01f, -4.76723254e-01f,
  4.42854650e-02f, -6.76583588e-01f, 1.98545337e-01f, -2.65361339e-01f, -1.18488565e-01f, -1.95776969e-01f, -4.89218891e-01f, -2.00582385e-01f, -9.79193375e-02f, -5.56562722e-01f,
  -1.03646219e-01f, 6.10028386e-01f, 4.28507805e-01f, 5.50191760e-01f, 4.16855454e-01f, -5.69749117e-01f, -3.47945780e-01f, 6.00051165e-01f, 8.40255558e-01f, 1.76717401e-01f,
  -2.36178160e-01f, -1.56159595e-01f, 1.76224723e-01f, 2.02333644e-01f, -6.44200206e-01f, 4.86522056e-02f, -3.65206331e-01f, -1.91017494e-01f, -3.21507961e-01f, -6.89018846e-01f,
  6.08471371e-02f, -2.72799522e-01f, 2.12870941e-01f, 1.26187831e-01f, 3.39893848e-02f, -4.02212702e-02f, 1.35370297e-02f, -1.97829437e-02f, -3.53066809e-02f, -7.01431111e-02f,
  -5.14290743e-02f, 5.17880917e-02f, 1.03156477e-01f, -7.02609271e-02f, -2.29688004e-01f, -8.39100033e-02f, -5.38851134e-02f, 5.40994331e-02f, 4.93089333e-02f, -1.20456032e-01f,
  -1.78469464e-01f, -3.51123177e-02f, 6.04974665e-02f, -2.48050932e-02f, 5.23637310e-02f, 2.10871905e-01f, -1.21289097e-01f, -4.98780906e-02f, 8.58843103e-02f, -6.80289030e-01f,
  -8.65995288e-02f, 4.38567176e-02f, 5.13216555e-02f, -4.52606566e-03f, -1.33530334e-01f, 5.55470474e-02f, -1.77374352e-02f, -8.66458565e-02f, -9.73492563e-02f, -3.49986628e-02f,
  1.67207196e-01f, 1.07281804e-02f, 1.04820840e-01f, -8.40335935e-02f, -8.85974709e-03f, -7.23587871e-02f, 2.26945933e-02f, -9.51611251e-03f, 3.44634019e-02f, -2.90096942e-02f,
  3.05535216e-02f, 9.06580314e-02f, -9.04919361e-05f, 1.65196955e-02f, -8.21871962e-03f, 1.66487724e-01f, -3.61239649e-02f, 7.79887289e-02f, 3.24155949e-02f, -1.24645226e-01f,
  1.23785026e-01f, 4.13876444e-01f, -1.94211945e-01f, 1.96710318e-01f, -8.39699283e-02f, 1.06350504e-01f, -1.68922931e-01f, 1.51648358e-01f, 6.01890571e-02f, 1.06300160e-01f,
  6.88165501e-02f, 2.44820397e-02f, -1.49299219e-01f, -6.11219518e-02f, 3.82356457e-02f, 4.52984758e-02f, -1.01993226e-01f, 1.05382726e-01f, 3.68848606e-03f, -1.70038685e-01f,
  -2.68144488e-01f, -1.12432785e-01f, 5.36424331e-02f, -7.46228695e-02f, -1.10863879e-01f, 1.52008608e-01f, -2.39874959e-01f, -7.12278560e-02f, 2.17286378e-01f, -5.09652793e-01f,
  -4.03796360e-02f, 3.89249295e-01f, 2.46177793e-01f, -1.88989058e-01f, -4.69569057e-01f, -1.89558461e-01f, 3.26584764e-02f, 1.46404132e-01f, -4.13206145e-02f, 2.16677904e-01f,
  -3.26691955e-01f, -3.99456739e-01f, -7.29804859e-02f, -3.27573381e-02f, 7.50679374e-02f, 4.66320246e-01f, 3.28661025e-01f, -3.99027206e-02f, -3.41758698e-01f, -3.93206626e-01f,
  -2.49515891e-01f, -2.54491955e-01f, -7.55812898e-02f, 1.02434501e-01f, 3.12070906e-01f, -1.24462880e-01f, 2.20951378e-01f, -1.82791665e-01f, 6.91543147e-02f, 3.43986511e-01f,
  -7.33610019e-02f, 1.93185166e-01f, -1.91842377e-01f, -2.32497945e-01f, -2.24094093e-01f, 7.24397004e-02f, -3.11601069e-02f, 6.76196218e-02f, -8.41801539e-02f, 2.11031199e-01f,
  -3.46195430e-01f, -3.07797492e-02f, -2.50197202e-01f, -2.17712864e-01f, -3.80797595e-01f, -2.08132848e-01f, 1.45729572e-01f, 1.84385061e-01f, 8.60195532e-02f, -7.07188547e-02f,
  -3.27945739e-01f, -3.98052901e-01f, -1.82375684e-01f, 1.35787502e-01f, 3.73026967e-01f, 1.14782322e-02f, -1.65506806e-02f, 1.87265158e-01f, 2.81820565e-01f, 4.63509500e-01f,
  1.11077048e-01f, 1.52373733e-02f, -1.83517132e-02f, 1.36104479e-01f, -5.36870137e-02f, -1.27189815e-01f, 5.90746626e-02f, -1.03258885e-01f, -7.47134537e-02f, -8.76286402e-02f,
  -2.74526514e-02f, -3.12736002e-03f, -8.57781842e-02f, -5.14345132e-02f, 5.49900867e-02f, -1.32864311e-01f, -8.00780654e-02f, 6.19287044e-02f, 1.35976598e-01f, -6.07888773e-03f,
  6.72502220e-02f, -6.56612813e-02f, -9.77943614e-02f, 1.70315616e-02f, 1.01891592e-01f, 6.48791566e-02f, -1.38864785e-01f, 1.47047080e-02f, 7.09860101e-02f, 3.82789932e-02f,
  -1.58697367e-01f, -5.06936051e-02f, 7.70177245e-02f, 6.40226826e-02f, -1.09114964e-02f, -1.12261757e-01f, -1.64404675e-01f, -7.59738460e-02f, -1.85480326e-01f, -1.89062119e-01f,
  -6.02387078e-02f, -5.92813902e-02f, -1.39688760e-01f, -1.41327605e-02f, -4.03602630e-01f, -5.23324236e-02f, -8.75414908e-02f, -2.14609787e-01f, -2.85908818e-01f, -1.86185256e-01f,
  -1.37710661e-01f, -1.27549887e-01f, -3.61695498e-01f, -1.21456258e-01f, -1.52318284e-01f, -2.64537901e-01f, -2.25249067e-01f, -6.52720034e-02f, -8.16911161e-02f, 1.92230850e-01f,
  -1.10484719e+00f, -3.15210015e-01f, 4.14327115e-01f, -2.53740072e-01f, -7.82316774e-02f, -1.22091569e-01f, -1.08971402e-01f, -1.83528021e-01f, -2.28097841e-01f, -3.91616076e-02f,
  -7.29642361e-02f, -3.77201252e-02f, 4.84979972e-02f, 1.75946593e-01f, 1.06083766e-01f, 1.50906384e-01f, 9.07196030e-02f, 1.74932759e-02f, -2.25247275e-02f, -1.78152606e-01f,
  -1.76446408e-01f, -1.11218289e-01f, -1.69371471e-01f, -1.80299535e-01f, 7.27053732e-02f, -6.84308494e-03f, 1.74715862e-01f, -1.87675841e-02f, 1.35024348e-02f, 1.53668761e-01f,
  1.00447249e+00f, -1.63769692e-01f, 8.96155015e-02f, -7.36726299e-02f, -5.59895346e-03f, 2.11362094e-02f, 7.02204704e-02f, -7.71385524e-03f, -7.71530420e-02f, -7.34320376e-03f,
  1.17916487e-01f, -3.21382880e-02f, 7.67390281e-02f, -4.05060910e-02f, 6.51465878e-02f, 6.82840403e-03f, -7.99751505e-02f, 3.85782905e-02f, 4.44018766e-02f, 2.11751506e-01f,
  1.01228906e-02f, 4.64224741e-02f, 1.36373729e-01f, 7.33468831e-02f, -8.76267999e-03f, 1.21057875e-01f, 4.77292575e-02f, -1.77009050e-02f, -1.68943424e-02f, -9.32432637e-02f,
  -8.61634463e-02f, 1.87711380e-02f, 7.33436197e-02f, 5.05316071e-02f, -5.53610027e-02f, -5.43519519e-02f, -2.31975298e-02f, 7.70647079e-02f, -2.99811829e-02f, -3.66107896e-02f,
  -5.16458713e-02f, 7.91604072e-02f, -2.38481574e-02f, 7.93787127e-04f, 1.52693734e-01f, 1.37942150e-01f, -1.32907331e-02f, 7.43894354e-02f, 1.21454015e-01f, -1.10602491e-01f,
  3.01283021e-02f, 1.91366393e-03f, 1.61931869e-02f, 1.86555743e-01f, 1.07316613e-01f, -2.19350923e-02f, 4.74287719e-02f, -2.11037807e-02f, 7.57994279e-02f, -4.79346439e-02f,
  5.40569425e-01f, 4.58275266e-02f, 4.15657796e-02f, -8.30868557e-02f, -1.11720465e-01f, -6.22262852e-03f, 3.00191958e-02f, -4.51028682e-02f, 7.99838752e-02f, 1.39296129e-01f,
  1.14588231e-01f, 2.84649990e-02f, 5.73303364e-02f, 7.77735710e-02f, -6.65144473e-02f, -2.26884112e-02f, -1.65397167e-01f, 5.77777773e-02f, 8.73840600e-02f, 1.59161717e-01f,
  -1.36534572e-02f, -7.48538971e-02f, 1.11866429e-01f, 8.97657946e-02f, -4.72386628e-02f, 8.47252384e-02f, 2.05391392e-01f, 1.94641754e-01f, 8.11733603e-02f, -6.18057065e-02f,
  1.44905776e-01f, 2.48250037e-01f, 3.15105826e-01f, -1.54640332e-01f, 2.32612416e-01f, 3.12553257e-01f, 2.60815859e-01f, -4.74019386e-02f, -1.83176786e-01f, 8.57568383e-02f,
  4.21976477e-01f, 1.04022339e-01f, -2.83809491e-02f, -4.96695042e-02f, -8.61881897e-02f, -1.09705843e-01f, -2.17914060e-01f, -8.61163735e-02f, -3.89008150e-02f, 1.78731173e-01f,
  -1.90467853e-02f, 2.36438975e-01f, 2.23733813e-01f, -7.98756704e-02f, -9.52444272e-04f, -9.68480632e-02f, 2.05174565e-01f, 3.44351977e-01f, 3.19563597e-01f, -3.28909487e-01f,
  3.31621736e-01f, 2.94475913e-01f, -2.91841447e-01f, -7.41248801e-02f, 1.55382618e-01f, -1.79546252e-01f, 1.08532622e-01f, -1.15498461e-01f, -3.77570242e-02f, -8.44181553e-02f,
  1.10735379e-01f, -5.02412766e-02f, -3.95911336e-02f, -7.10734352e-02f, 5.74237220e-02f, 9.46935862e-02f, -1.44883454e-01f, -8.11282992e-02f, -4.12937440e-03f, 3.97616923e-02f,
  -3.77843603e-02f, 1.78731531e-01f, 2.67867476e-01f, -5.13903052e-02f, -7.28377104e-02f, 2.98502799e-02f, 1.74070179e-01f, -7.44147152e-02f, -5.35846949e-02f, -1.43302917e-01f,
  -6.17043935e-02f, -2.53815949e-01f, 9.30711906e-03f, -1.69217736e-01f, -1.54369995e-02f, -6.26185983e-02f, -7.69029036e-02f, 5.31099923e-02f, -5.45457006e-03f, -5.64276949e-02f,
  -3.77000049e-02f, 1.23759788e-02f, -4.39299382e-02f, -2.87074805e-03f, 2.36784983e-02f, 6.74827993e-02f, 8.79013315e-02f, -2.66841706e-02f, 1.45068854e-01f, 2.89784241e-02f,
  -1.89297069e-02f, -4.88006463e-03f, 1.15790613e-01f, -5.14848493e-02f, -6.15281202e-02f, -1.16746932e-01f, 7.86856469e-03f, 5.24581671e-02f, 6.46037608e-02f, 1.05972163e-01f,
  -3.51316035e-02f, 3.40773553e-01f, -2.41382062e-01f, -2.01755822e-01f, 4.03130334e-03f, -7.82066432e-04f, 7.73308426e-02f, -1.17892928e-01f, 2.36568563e-02f, -3.10538560e-02f,
  1.47416592e-01f, -1.29066080e-01f, 1.05168201e-01f, -7.90911764e-02f, 6.03570752e-02f, -6.88798651e-02f, -6.32120296e-02f, -9.11979154e-02f, -1.72417089e-01f, -5.19477949e-02f,
  -2.30525851e-01f, -1.25152007e-01f, -1.05410255e-01f, -1.29696369e-01f, -1.52710795e-01f, -8.40213373e-02f, -3.85549702e-02f, -4.18567099e-02f, 6.50405586e-02f, -2.39723638e-01f,
  -1.55184208e-03f, 4.56698425e-02f, 4.64487851e-01f, 3.23147744e-01f, 2.26982713e-01f, 4.86638807e-02f, 2.40160641e-03f, -9.33606476e-02f, -1.79622218e-01f, 8.23982991e-03f,
  1.00737847e-01f, -2.79676840e-02f, 1.06941149e-01f, 3.49455699e-02f, 1.37538612e-01f, 2.22064871e-02f, 3.09236884e-01f, 2.78086692e-01f, 2.28798494e-01f, 4.84959558e-02f,
  9.82833058e-02f, 2.30832264e-01f, 2.91668892e-01f, 9.98036265e-02f, 1.25385836e-01f, 5.80115169e-02f, 2.17235431e-01f, 3.97672921e-01f, 2.24155009e-01f, 2.24981830e-01f,
  4.15437333e-02f, 4.89776675e-03f, -2.52373904e-01f, -9.28015187e-02f, 1.15623564e-01f, -3.51165444e-01f, -1.81170598e-01f, -1.32369980e-01f, -1.36706740e-01f, -1.09134920e-01f,
  2.13874713e-01f, -2.18960433e-03f, 2.83577330e-02f, -7.28535801e-02f, -2.82832123e-02f, -1.46752492e-01f, 1.84012894e-02f, 1.85684487e-01f, 6.99584857e-02f, 3.77312787e-02f,
  1.67487398e-01f, 1.52534202e-01f, 1.74664542e-01f, -7.19567165e-02f, 8.05686340e-02f, 1.84297726e-01f, 1.91153362e-01f, 1.86547842e-02f, -5.17805070e-02f, -1.76998854e-01f,
  -5.08105196e-02f, 1.42134577e-01f, 7.41394907e-02f, -9.56277363e-03f, -1.11122906e-01f, -5.12313172e-02f, 2.86639966e-02f, 1.81805193e-01f, -3.81770753e-03f, -3.42901237e-02f,
  -9.14470628e-02f, -7.57058635e-02f, -2.49778759e-02f, -7.38932192e-02f, -8.60914215e-02f, -1.63496882e-02f, 3.04866359e-02f, 4.72202450e-02f, 3.20359431e-02f, 2.75440961e-02f,
  8.91069844e-02f, 6.36671782e-02f, -1.59382418e-01f, -9.83161777e-02f, -4.24454862e-04f, -4.18906063e-02f, -1.34122938e-01f, -2.34446630e-01f, -2.23125458e-01f, -1.39306456e-01f,
  -3.18336487e-01f, 1.09543853e-01f, -2.37800792e-01f, -1.19726203e-01f, 8.86629894e-02f, -1.19843207e-01f, -7.41492137e-02f, -7.71007091e-02f, 4.49420363e-02f, -9.73911509e-02f,
  -6.52680695e-02f, -2.44499426e-02f, -7.85675924e-03f, -7.45039284e-02f, -1.16181612e-01f, -1.56813875e-01f, -1.93628937e-01f, 2.46480107e-03f, -4.40485626e-02f, -7.64237298e-03f,
  2.88918838e-02f, -1.10132717e-01f, -1.42614752e-01f, -1.99170977e-01f, -1.99743479e-01f, -2.95799673e-01f, -2.50467896e-01f, -2.49025002e-01f, -3.59576583e-01f, -4.48748231e-01f,
  6.76909924e-01f, -4.11084384e-01f, 2.38750726e-02f, 9.87670049e-02f, 2.73107607e-02f, 1.59349665e-02f, -1.78929955e-01f, -8.01501498e-02f, 1.85526237e-01f, 6.23098947e-02f,
  1.38619274e-01f, 9.49676558e-02f, 5.09466492e-02f, 1.51204988e-02f, 5.17064296e-02f, -6.06363118e-02f, 3.19687612e-02f, 1.06018811e-01f, 1.35720000e-01f, 6.55196235e-02f,
  -8.26310441e-02f, -8.25562477e-02f, -5.02815060e-02f, 9.67879444e-02f, 5.93918934e-02f, -3.10811866e-02f, -9.33077782e-02f, -7.93150067e-02f, -1.95071176e-01f, -1.64885715e-01f,
  -7.74506405e-02f, -6.03992678e-02f, 2.17978522e-01f, -6.54105544e-02f, -4.71204817e-02f, 4.24260199e-02f, -1.48066590e-02f, -1.85416304e-02f, -8.75080898e-02f, 3.25452164e-02f,
  -5.45348302e-02f, -1.18463114e-01f, -4.81862389e-02f, -1.68982446e-01f, 2.15506777e-02f, 5.71361817e-02f, 9.88767967e-02f, -7.81940222e-02f, -1.39579192e-01f, -9.10638943e-02f,
  -4.60423715e-02f, 7.87985027e-02f, 7.67690316e-02f, -5.18374844e-03f, 9.32015106e-02f, 6.79563656e-02f, 4.64582304e-03f, 9.72332731e-02f, 9.81102735e-02f, 7.66241997e-02f,
  -1.57602504e-01f, -9.46513843e-03f, 9.15649831e-02f, 2.72476338e-02f, 1.21099740e-01f, 1.27187252e-01f, 9.44250003e-02f, -4.76081111e-03f, -6.73303306e-02f, -4.87623923e-03f,
  -2.42167935e-02f, -1.56787094e-02f, 9.51709002e-02f, -4.26642634e-02f, -1.05057620e-02f, -7.50716105e-02f, -5.14059030e-02f, -2.50714887e-02f, 1.72470440e-03f, 2.72397753e-02f,
  -2.80875899e-02f, -2.08389983e-02f, 2.01501343e-02f, -1.02938354e-01f, -1.05306827e-01f, 5.71335964e-02f, -9.93235782e-02f, -1.41059414e-01f, -1.04302034e-01f, -3.36212218e-02f,
  -2.02187151e-01f, 1.70382038e-01f, 3.68987620e-02f, 4.09105346e-02f, 5.99392056e-02f, 1.04940303e-01f, 1.23059891e-01f, -7.92084038e-02f, -1.33456945e-01f, 4.26775217e-02f,
  1.02712318e-01f, -2.60339845e-02f, -5.74281998e-02f, 4.93666343e-02f, 1.26157075e-01f, 1.74998105e-01f, 2.02450424e-01f, 1.50459081e-01f, -8.68352503e-02f, -1.10242851e-01f,
  1.64536685e-02f, 1.59056023e-01f, 2.15886340e-01f, 2.58002728e-01f, 2.01126978e-01f, 1.16986595e-01f, 2.54900400e-02f, 6.39812723e-02f, 7.07212910e-02f, 1.13017529e-01f,
  3.56678516e-02f, -7.34711289e-01f, 2.86012918e-01f, 1.34201810e-01f, 3.77011806e-01f, 4.37661380e-01f, 3.69090289e-01f, 6.39480576e-02f, 6.33380413e-02f, -7.99468011e-02f,
  -4.66373235e-01f, -1.80199385e-01f, -1.96339518e-01f, -1.73285395e-01f, -1.34435251e-01f, 1.58914551e-01f, 2.53659129e-01f, 2.46657565e-01f, 4.14962560e-01f, 1.87143415e-01f,
  -1.56301901e-01f, -1.07040629e-01f, -2.72384346e-01f, -6.57254159e-02f, -2.41312116e-01f, 3.44956629e-02f, -1.12554535e-01f, -1.37791261e-01f, -2.49993727e-01f, -2.80225456e-01f,
  7.07664713e-02f, -3.15505624e-01f, 1.84284464e-01f, -2.80320555e-01f, -6.25171736e-02f, -1.43594563e-01f, 4.37360965e-02f, -5.41317165e-02f, -5.57973124e-02f, 2.46468913e-02f,
  -8.78614858e-02f, -1.04515396e-01f, -9.79983713e-03f, -1.59030467e-01f, -5.04799709e-02f, 1.08930068e-02f, -2.25779414e-01f, -1.82987213e-01f, -1.48742244e-01f, -1.25457004e-01f,
  -3.01862895e-01f, -1.36022344e-01f, 4.48565669e-02f, 2.61517670e-02f, -9.50491950e-02f, 3.99986729e-02f, -2.14077026e-01f, -7.91743472e-02f, -4.65987138e-02f, -7.20325066e-03f,
  1.15967086e-02f, -9.47606415e-02f, -1.06752850e-02f, 4.13693301e-02f, -2.46729776e-02f, 1.71906576e-01f, 1.81284949e-01f, -5.57753704e-02f, 6.08279696e-03f, 2.34793010e-03f,
  -6.73051849e-02f, 3.05777416e-02f, -6.12478293e-02f, -9.13622677e-02f, -8.88831615e-02f, -9.83971134e-02f, 2.04356275e-02f, -6.12743832e-02f, -1.28333434e-01f, 8.47213715e-03f,
  -1.20426886e-01f, 4.00420604e-03f, 7.29925558e-03f, -1.10878602e-01f, -1.53995380e-01f, -7.79090002e-02f, -3.83233577e-02f, -1.66880995e-01f, -5.54016931e-03f, 4.17636186e-02f,
  1.28775820e-01f, -7.78443590e-02f, 2.11044148e-01f, 3.65773141e-02f, 4.02340181e-02f, -1.85331643e-01f, -9.63972956e-02f, -1.03137456e-01f, -1.68071613e-02f, 6.25244752e-02f,
  -5.87955937e-02f, 5.84590025e-02f, -1.12774536e-01f, -1.30004317e-01f, 2.42121980e-01f, -8.81956443e-02f, -1.72287032e-01f, 1.05325185e-01f, -3.60625163e-02f, -5.55137731e-02f,
  -1.83348373e-01f, 1.57090530e-01f, 3.55445117e-01f, 2.17288375e-01f, 3.58055122e-02f, 2.32972398e-01f, 2.51785219e-01f, 1.50927991e-01f, 1.91783831e-01f, 2.12690160e-01f,
  -5.68246841e-01f, 1.06270052e-01f, -4.19010557e-02f, -3.46117228e-01f, -1.91932265e-03f, 2.24816665e-01f, 2.32603118e-01f, 2.00634331e-01f, -1.13851808e-01f, -1.87847787e-03f,
  8.05601329e-02f, -1.27251312e-01f, -2.03079358e-01f, -1.43369034e-01f, -2.53192693e-01f, -6.88671544e-02f, -2.83895731e-01f, -3.79079968e-01f, -1.49371490e-01f, 2.63315380e-01f,
  2.51364093e-02f, -1.30687699e-01f, -2.86268294e-01f, -2.21708044e-01f, -2.49027774e-01f, -3.10528606e-01f, -3.59331667e-01f, -3.17052931e-01f, -8.87723193e-02f, -3.38871121e-01f,
  -2.07300857e-01f, 8.59032422e-02f, 1.68079302e-01f, -1.98281929e-01f, -5.72680682e-02f, -2.28975508e-02f, -1.29708081e-01f, -3.19444723e-02f, -6.04671501e-02f, 3.78333451e-03f,
  -1.01965912e-01f, 4.58795428e-02f, -2.16694146e-01f, 1.10538177e-01f, 2.20243316e-02f, 7.88679253e-03f, 4.74557802e-02f, 1.10847065e-02f, 5.36795668e-02f, 3.03440452e-01f,
  2.29256108e-01f, 8.87461356e-04f, -1.03503302e-01f, 7.67343864e-02f, 2.01718211e-01f, -4.20379005e-02f, 1.50158972e-01f, 3.45370620e-02f, -5.34484200e-02f, -1.52448028e-01f,
  -9.55462605e-02f, 4.91868109e-02f, 9.57279652e-02f, 6.05657585e-02f, 5.78919947e-02f, 3.59075330e-02f, -5.73396608e-02f, 2.07389127e-02f, 7.30780363e-02f, 5.35501763e-02f,
  1.88598052e-01f, 7.19946921e-02f, 1.06252410e-01f, -2.22911939e-01f, -1.10928796e-01f, -5.69264218e-02f, -2.11189419e-01f, -2.46374831e-01f, -1.58599600e-01f, -1.69217169e-01f,
  -1.75845131e-01f, 7.13519566e-03f, -4.90561798e-02f, -8.71786550e-02f, 9.06407833e-02f, -1.01470895e-01f, -6.86524063e-02f, 9.51356143e-02f, -8.70241150e-02f, -9.60743204e-02f,
  -2.61445463e-01f, -3.26455161e-02f, -1.81158990e-01f, -1.24365106e-01f, -1.27969950e-01f, 6.66389242e-02f, -1.53870299e-01f, 8.23969692e-02f, -6.31936789e-02f, 1.12620287e-01f,
  2.99440116e-01f, 5.64206764e-03f, -3.36471125e-02f, 1.93303093e-01f, 1.72535524e-01f, 5.98871075e-02f, 4.49287705e-02f, -1.47840723e-01f, -3.44664007e-02f, 1.89550087e-01f,
  1.25975147e-01f, -1.94708154e-01f, -3.05103451e-01f, -1.26415908e-01f, -7.49676526e-02f, -2.47387215e-01f, -1.66162074e-01f, -2.15762407e-02f, -2.07942948e-01f, -1.78426310e-01f,
  -9.87758875e-01f, 9.72641930e-02f, -2.58254528e-01f, -7.00560153e-01f, 1.88825637e-01f, 2.84759253e-01f, 5.87156475e-01f, 6.92799762e-02f, -2.79024452e-01f, 2.56375764e-02f,
  1.15031213e-01f, -4.44230251e-02f, -5.23328669e-02f, 2.16899365e-01f, 2.03191712e-01f, 3.52070481e-01f, 1.76527500e-01f, -1.19024962e-01f, 5.63531853e-02f, 2.71602660e-01f,
  3.64359856e-01f, -2.39968061e-01f, -5.13177097e-01f, -1.22442357e-01f, -5.34466058e-02f, -9.09576565e-02f, -6.00661710e-02f, -1.77844062e-01f, 2.61732101e-01f, 4.23813984e-02f,
  6.12037964e-02f, -3.89897734e-01f, 1.71851188e-01f, -8.66282508e-02f, -1.78295560e-02f, -3.22171390e-01f, -9.96023640e-02f, -3.67265761e-01f, -1.39987767e-01f, -1.32151514e-01f,
  -7.77968466e-02f, -5.29133417e-02f, -7.13663250e-02f, -6.34898916e-02f, -2.26307869e-01f, -2.30111443e-02f, -2.21766204e-01f, -3.23368341e-01f, -2.73193866e-01f, 2.41036620e-03f,
  4.18202162e-01f, 1.75283462e-01f, -1.72281146e-01f, 5.34123592e-02f, 4.84532975e-02f, -1.65078640e-01f, 1.15311936e-01f, 4.10048701e-02f, -6.30186945e-02f, -3.84597123e-01f,
  4.41233255e-02f, 2.01271344e-02f, 7.64473900e-02f, -6.41245916e-02f, 5.00151068e-02f, -1.88321918e-02f, -6.51914999e-02f, 1.64994985e-01f, 3.52419727e-02f, -5.51670492e-02f,
  8.51433873e-02f, 4.23513502e-02f, -1.34022264e-02f, -6.44619763e-02f, -7.29185063e-03f, -1.21982962e-01f, 1.25497892e-01f, 1.80882096e-01f, 1.31890178e-01f, -1.42143682e-01f,
  -6.28596395e-02f, -3.99345905e-03f, -2.39421427e-01f, 4.20152582e-03f, 1.39056772e-01f, 2.42041238e-02f, -1.50430396e-01f, 4.15026546e-02f, -1.34446308e-01f, -1.29578903e-01f,
  -2.68154800e-01f, 8.31423625e-02f, -2.54353344e-01f, -7.19051866e-04f, -4.87587228e-02f, -6.41191751e-02f, 2.82326788e-02f, -3.50449719e-02f, -7.65891075e-02f, -1.35188000e-02f,
  2.14224458e-01f, -9.36621502e-02f, -1.28933117e-01f, -1.50680682e-02f, -9.48341861e-02f, -9.93385538e-02f, 3.80333103e-02f, -1.09864213e-01f, -3.08055500e-03f, -9.02274624e-02f,
  1.02203339e-02f, 5.18763773e-02f, -1.78526267e-01f, -5.50133688e-03f, 8.50931108e-02f, -1.54206738e-01f, 1.26001716e-01f, 5.15354648e-02f, -1.70272682e-02f, -1.63639665e-01f,
  7.83460081e-01f, -4.75200444e-01f, 7.16300309e-02f, 4.66608033e-02f, -1.14425600e-01f, -2.96522155e-02f, -4.21257466e-01f, -1.04197480e-01f, 2.49292739e-02f, -2.97316033e-02f,
  1.66923031e-01f, 3.08848470e-01f, 2.50928998e-01f, 1.94380566e-01f, 1.71566114e-01f, -1.90552369e-01f, -2.18774706e-01f, 1.55822843e-01f, 2.41646826e-01f, -4.57200781e-02f,
  -1.23657823e-01f, -7.01184124e-02f, 1.28219500e-01f, 1.24551013e-01f, -2.70121276e-01f, -1.46117909e-02f, -1.19272433e-01f, -1.15930997e-01f, -2.45622754e-01f, -3.51942837e-01f,
  -1.77722707e-01f, -1.27812019e-02f, 8.19773674e-02f, 4.36805412e-02f, 3.96165624e-02f, 8.10852274e-02f, -3.20111141e-02f, -2.28131562e-02f, -3.12235579e-03f, -2.54378051e-01f,
  1.79249663e-02f, 5.27471639e-02f, 1.00872576e-01f, -6.40001670e-02f, -9.19937044e-02f, -2.26184968e-02f, 7.93025736e-03f, -6.51819259e-02f, -7.49989375e-02f, -9.67899859e-02f,
  -6.31199330e-02f, -2.82824808e-03f, -1.28941834e-01f, 6.42307773e-02f, 5.70557863e-02f, 1.72361597e-01f, -1.19174058e-02f, 6.10343665e-02f, 1.61133185e-01f, -3.17467414e-02f,
  2.97200680e-02f, -1.34715945e-01f, -1.21465186e-02f, 4.92926426e-02f, 6.67357892e-02f, 5.73417991e-02f, -9.24691930e-02f, -1.11713789e-01f, 1.47488773e-01f, 4.19117026e-02f,
  -1.45298943e-01f, 8.28835964e-02f, 5.40911295e-02f, -8.35330337e-02f, 3.83428931e-02f, -5.82908802e-02f, -4.14501727e-02f, -7.51608312e-02f, 1.43272787e-01f, 9.90186818e-03f,
  1.97469909e-02f, -1.60607383e-01f, 3.08116786e-02f, -8.32996145e-02f, -7.71992952e-02f, 6.61612153e-02f, -2.56136600e-02f, 1.01309478e-01f, -5.30452430e-02f, -2.02568606e-01f,
  -3.16139907e-01f, 5.45270681e-01f, -2.53393371e-02f, -2.64844429e-02f, -1.03724703e-01f, 5.91953844e-02f, 1.13030799e-01f, -2.26513930e-02f, -1.00045167e-01f, -2.16370225e-01f,
  -5.21014705e-02f, 1.15076773e-01f, -4.50794995e-02f, -8.21239082e-05f, 9.38142836e-02f, 8.55144635e-02f, 8.70727301e-02f, -1.20446170e-02f, -3.04572638e-02f, -5.30102924e-02f,
  -2.42170207e-02f, 2.53940094e-02f, 9.16530415e-02f, 1.65508196e-01f, 4.00405675e-02f, 1.21512212e-01f, 1.31461304e-02f, -8.21046680e-02f, 2.11674184e-01f, -1.41343195e-02f,
  -5.22390187e-01f, -2.48905551e-02f, 1.05493993e-01f, 3.08272481e-01f, 2.54473954e-01f, 2.25574017e-01f, 1.78269684e-01f, 2.21680738e-02f, 1.02468990e-01f, -7.26353154e-02f,
  -2.25154445e-01f, 3.99477482e-02f, 1.85888350e-01f, 2.46305943e-01f, -6.33766269e-03f, 1.31281421e-01f, 4.04486775e-01f, 2.74272829e-01f, 3.88081605e-03f, -4.88342941e-02f,
  7.99432993e-02f, -4.14189361e-02f, -1.81641117e-01f, 1.54759571e-01f, 3.11575860e-01f, 1.77537873e-01f, 1.55269012e-01f, 1.92825459e-02f, 1.06096212e-02f, 5.63424885e-01f,
  -2.96774775e-01f, -3.29781175e-01f, 2.56218374e-01f, -1.74210161e-01f, -1.12721920e-01f, -1.97661400e-01f, -1.73085347e-01f, 4.36068848e-02f, -6.93190545e-02f, -5.93516007e-02f,
  6.46647289e-02f, -2.30191782e-01f, 9.16943401e-02f, -8.61968473e-02f, -2.81794723e-02f, -1.41618848e-01f, 4.56584953e-02f, -1.10028073e-01f, -1.11611798e-01f, -1.73092753e-01f,
  2.90862292e-01f, -1.75512746e-01f, -2.01022103e-01f, -3.95085365e-02f, -2.67737303e-02f, -1.52783722e-01f, -1.15212053e-01f, -2.31093332e-01f, -3.70231867e-01f, -8.22012424e-02f,
  5.79872839e-02f, -1.25530690e-01f, 1.06182605e-01f, 7.04603037e-03f, -6.38376847e-02f, 1.48955947e-02f, 4.94931825e-02f, 1.56343192e-01f, 9.89762694e-02f, -1.22370280e-03f,
  1.05263963e-01f, 2.75662746e-02f, 1.67756795e-03f, 1.33660650e-02f, 1.39016390e-01f, -1.47477493e-01f, -6.18067896e-03f, -2.95485929e-02f, -5.88875301e-02f, -3.07302494e-02f,
  1.07636355e-01f, 1.05077334e-01f, -2.56027300e-02f, 1.56994715e-01f, -5.29543012e-02f, 1.79143774e-03f, -3.24125774e-02f, -1.68043971e-01f, -8.30957852e-03f, -1.24858364e-01f,
  -2.06199735e-01f, -1.80301398e-01f, -3.11080143e-02f, -8.85620192e-02f, -2.78620161e-02f, -7.56742656e-02f, -1.47647932e-01f, -4.20702957e-02f, -6.19094744e-02f, -1.01678520e-01f,
  -1.69090912e-01f, -1.67080685e-01f, -1.28921911e-01f, 9.58275571e-02f, -1.22731820e-01f, -8.44230354e-02f, -1.09817304e-01f, 1.96755081e-01f, -1.32890522e-01f, -1.67940408e-01f,
  2.54920572e-01f, 1.91329829e-02f, -1.16576061e-01f, -5.41714840e-02f, -8.59903693e-02f, -1.92327693e-01f, -4.84280251e-02f, -1.47776484e-01f, -3.61833543e-01f, -1.79217756e-01f,
  5.40411651e-01f, 1.74800262e-01f, 3.49574298e-01f, 3.15123320e-01f, 4.28077370e-01f, 4.67982024e-01f, 4.01484370e-01f, 3.00784916e-01f, 2.12171286e-01f, 2.57635236e-01f,
  1.23123445e-01f, 1.30239695e-01f, 7.05382004e-02f, -1.16085885e-02f, 7.61924982e-02f, 1.05575100e-01f, 7.23890495e-03f, -2.71179769e-02f, 9.82593074e-02f, 1.65328443e-01f,
  8.38899314e-02f, 7.55578205e-02f, 1.60373986e-01f, -2.53377948e-02f, -5.80207817e-02f, 6.98580965e-03f, 1.14372507e-01f, 1.70921087e-01f, 6.60093129e-02f, -1.63415298e-01f,
  -2.10125580e-01f, 1.60611272e-01f, -6.94069266e-02f, -1.67434633e-01f, -1.11745685e-01f, -2.22588494e-01f, -5.45912944e-02f, -7.30299056e-02f, -1.35267511e-01f, -1.18381552e-01f,
  1.26096997e-02f, -9.02941376e-02f, 9.47232321e-02f, -1.08630784e-01f, 1.58331711e-02f, 4.82285284e-02f, -2.36555245e-02f, -3.47949229e-02f, -2.52702797e-04f, -3.94379608e-02f,
  -4.06937152e-02f, 2.05864638e-01f, 2.29843721e-01f, 4.86668237e-02f, 1.68200359e-01f, 4.83511575e-02f, -6.04462158e-03f, 1.90275274e-02f, 5.31496033e-02f, -2.01491229e-02f,
  2.53246307e-01f, 1.57993838e-01f, 2.36576736e-01f, 1.41867265e-01f, 1.90818727e-01f, -2.02317499e-02f, -6.41461536e-02f, 1.86578736e-01f, 2.73158997e-01f, 8.72291103e-02f,
  3.90341207e-02f, 1.30019426e-01f, 8.63736123e-03f, 5.69441617e-02f, 9.58805308e-02f, 1.65957481e-01f, 3.24294046e-02f, 1.31132901e-01f, 8.75074342e-02f, 3.32686082e-02f,
  8.90548825e-02f, 3.94705981e-02f, -9.61420611e-02f, -1.22953236e-01f, -8.10074210e-02f, 1.07190669e-01f, 3.30998152e-02f, 1.45561904e-01f, -3.78693244e-03f, 4.49395180e-02f,
  -1.41967252e-01f, 3.52757901e-01f, 5.14256321e-02f, -1.66954294e-01f, -9.97077599e-02f, -1.83188602e-01f, 2.09771380e-01f, -1.07973844e-01f, -2.17305496e-01f, -1.13368243e-01f,
  7.41657615e-02f, -1.49938613e-01f, -5.57523668e-02f, -1.79420307e-03f, 1.38495535e-01f, 9.18313414e-02f, -1.28825247e-01f, 1.22713059e-01f, -1.00115165e-01f, -8.44760612e-02f,
  -3.41878086e-02f, 6.68355823e-02f, 1.29725337e-01f, 5.52670695e-02f, 1.89021498e-01f, 8.49850625e-02f, 2.26288792e-02f, 1.13223441e-01f, 1.51850715e-01f, -5.50068356e-02f,
  2.12015599e-01f, 4.98522371e-01f, 3.41210365e-01f, 2.29665086e-01f, -4.78544869e-02f, 7.66148046e-02f, 2.41730019e-01f, 3.10958028e-01f, 1.80837005e-01f, 4.59375456e-02f,
  -1.52594030e-01f, -8.98233131e-02f, 1.27627343e-01f, 1.84735894e-01f, 2.47296453e-01f, 4.85526383e-01f, 4.36770737e-01f, 2.83366323e-01f, 1.08734377e-01f, 6.37357086e-02f,
  8.03511292e-02f, 2.65849560e-01f, 3.39930326e-01f, 3.24158996e-01f, 2.81584352e-01f, -1.90327677e-03f, 2.09513485e-01f, 1.36239186e-01f, 1.89379767e-01f, 4.24917907e-01f,
  -1.39750019e-01f, 6.89199716e-02f, 4.24083043e-03f, -1.10813320e-01f, -1.02644719e-01f, 6.64554089e-02f, 5.97637892e-02f, 6.43450394e-02f, -3.64398435e-02f, -2.81513836e-02f,
  -7.38722607e-02f, 5.00173345e-02f, -3.59039158e-02f, 6.50238758e-03f, -8.11597779e-02f, -1.26525193e-01f, 4.05649245e-02f, 2.06593107e-02f, 2.16124550e-01f, -2.07095128e-02f,
  -4.64545116e-02f, -1.88243851e-01f, -3.04982383e-02f, -7.08843023e-02f, 4.44135405e-02f, -2.21011356e-01f, -9.84697863e-02f, -3.28525566e-02f, -6.53957129e-02f, 3.19675505e-02f,
  1.03503764e-01f, 1.25521958e-01f, -1.10362299e-01f, -3.86434123e-02f, -2.40386009e-01f, -1.10951155e-01f, -1.87255993e-01f, -5.62221184e-02f, 1.35574294e-02f, 1.89976748e-02f,
  -8.05153102e-02f, -3.45801115e-02f, 1.17552146e-01f, -9.44131389e-02f, -9.05122533e-02f, 1.03885859e-01f, 6.49331659e-02f, 4.15517762e-03f, -1.82962120e-01f, 5.80873415e-02f,
  -8.20904374e-02f, 6.27314523e-02f, -5.13741411e-02f, 1.68012619e-01f, -7.56077319e-02f, -1.21054456e-01f, -2.39913762e-02f, -4.86702137e-02f, 8.35886300e-02f, 1.69720381e-01f,
  -1.68571938e-02f, -2.35003188e-01f, 1.16468340e-01f, 3.12525988e-01f, -1.17147990e-01f, -2.31668148e-02f, 4.95901965e-02f, -4.53183204e-02f, 4.23417892e-03f, 1.08287454e-01f,
  -2.15492398e-02f, 1.10305130e-01f, 8.74846131e-02f, -4.79110815e-02f, -2.04176813e-01f, -1.39286771e-01f, -1.30235702e-01f, 3.85390669e-02f, 1.50351137e-01f, 7.61784464e-02f,
  1.04371138e-01f, -1.50603876e-01f, -9.16065052e-02f, -1.89257711e-01f, -1.67018428e-01f, -1.34951234e-01f, -1.18152604e-01f, -9.38240960e-02f, -2.46983260e-01f, -2.61633009e-01f,
  6.06702626e-01f, 1.33080393e-01f, 2.41204962e-01f, 3.17186177e-01f, -6.58934265e-02f, -2.69124925e-01f, -4.34939861e-01f, -2.24767536e-01f, 9.13438350e-02f, 2.20595449e-01f,
  1.66958839e-01f, 1.33574501e-01f, 7.70159364e-02f, 9.78533551e-02f, 5.90865649e-02f, 4.19358239e-02f, 1.40952855e-01f, 3.59674305e-01f, 3.04602504e-01f, 2.70767838e-01f,
  2.95246452e-01f, 2.77861863e-01f, 4.24042463e-01f, 2.42650717e-01f, 3.52607429e-01f, 1.95864260e-01f, 4.95183617e-02f, 1.58116847e-01f, 2.39583030e-01f, 3.16340387e-01f,
  6.28467560e-01f, 2.57187307e-01f, -1.11675538e-01f, -9.70686674e-02f, -2.21922435e-02f, 2.12776259e-01f, 1.50072306e-01f, 8.87463838e-02f, -1.21156171e-01f, 1.31889451e-02f,
  -2.10405234e-03f, 1.01660918e-02f, 5.30963354e-02f, -2.60359254e-02f, -1.03851661e-01f, 5.61700612e-02f, -2.66497880e-02f, 1.08425459e-02f, -1.10693336e-01f, 2.94329803e-02f,
  5.32802492e-02f, -1.22802192e-02f, -1.64283946e-01f, -3.55585366e-01f, -8.80045295e-02f, -2.04074234e-01f, -2.05080375e-01f, -7.23958537e-02f, -1.28425077e-01f, 8.02231878e-02f,
  -6.98964819e-02f, -8.33410770e-02f, -1.27854869e-01f, -6.66168705e-02f, 1.27945706e-01f, 2.65473463e-02f, -6.83875754e-02f, -5.93358986e-02f, 3.10257040e-02f, 1.19914383e-01f,
  6.14505671e-02f, 3.20187621e-02f, 7.55187729e-03f, 1.13481738e-01f, 1.71753019e-01f, 8.43685269e-02f, -9.18543488e-02f, 1.78640839e-02f, -7.50007033e-02f, 2.78420206e-02f,
  8.40497091e-02f, -3.28572914e-02f, 7.87153095e-03f, -8.16427246e-02f, -1.33229671e-02f, 8.00248012e-02f, 1.63559377e-01f, 1.33559495e-01f, 7.16513693e-02f, 1.76541701e-01f,
  6.09157048e-02f, -2.74010569e-01f, 2.09570855e-01f, -2.50532597e-01f, -1.43324807e-01f, -5.60842231e-02f, 4.03738245e-02f, -1.00112416e-01f, -1.12040848e-01f, 5.53578958e-02f,
  -9.54494849e-02f, -9.42042246e-02f, -6.00549467e-02f, -1.24273896e-01f, -2.31598653e-02f, -7.05160722e-02f, -1.48376331e-01f, -1.27094984e-01f, -2.49774054e-01f, -8.37039873e-02f,
  -1.88930377e-01f, -1.29749775e-01f, -1.89102322e-01f, -2.69240975e-01f, -2.08474845e-01f, -8.90458748e-02f, -1.21866509e-01f, -1.42397359e-01f, -3.25651586e-01f, -6.75951466e-02f,
  4.51985508e-01f, 3.10777992e-01f, -5.79859428e-02f, 4.89319980e-01f, 4.01391953e-01f, 2.66612023e-01f, 2.75887281e-01f, 2.18142882e-01f, 1.87538117e-01f, 2.93136328e-01f,
  4.47573066e-01f, 4.22229201e-01f, 2.69139856e-01f, 2.73514301e-01f, 1.03095412e-01f, 1.29693355e-02f, -9.67313349e-02f, -1.13936886e-01f, 1.46696037e-02f, 1.18815161e-01f,
  3.13699722e-01f, 3.99195217e-02f, 3.82481627e-02f, 5.35345078e-03f, 2.70829573e-02f, 2.38192961e-01f, 9.22877993e-03f, -8.44226256e-02f, 7.80524388e-02f, -7.80010745e-02f,
  -8.54128599e-02f, -4.57330085e-02f, 3.98234688e-02f, 1.84614465e-01f, 1.08169755e-02f, -1.08142801e-01f, -1.18996669e-02f, -1.95394069e-01f, -3.50896567e-02f, -3.22686955e-02f,
  -1.30344808e-01f, -1.40807882e-01f, 5.40582091e-02f, -9.08871740e-02f, -7.20257238e-02f, -1.92998201e-01f, -2.31639877e-01f, -2.46053621e-01f, -1.02886967e-01f, -8.47553015e-02f,
  9.51514989e-02f, 3.21750902e-02f, -8.11615363e-02f, -4.98069711e-02f, -1.38142556e-02f, 8.62337202e-02f, -1.05973996e-01f, -8.48951340e-02f, -1.20996311e-01f, -1.16282351e-01f,
  2.37140693e-02f, 4.87272590e-02f, 2.81032417e-02f, -1.35309910e-02f, 8.70371610e-02f, -4.92126495e-02f, -9.41167772e-02f, 2.54751686e-02f, -7.54626691e-02f, -1.74523950e-01f,
  -3.50586101e-02f, -9.78007764e-02f, -1.02867357e-01f, -3.03806346e-02f, 1.73657343e-01f, -7.84510970e-02f, -9.26917568e-02f, -8.09623450e-02f, 6.71438426e-02f, -3.49666998e-02f,
  1.19223490e-01f, -2.09135115e-01f, -4.10799943e-02f, -9.23177823e-02f, -6.04692847e-02f, 1.70461550e-01f, 2.52701528e-02f, 6.96395561e-02f, 2.25702748e-01f, 6.24887459e-02f,
  -2.74777468e-02f, 1.97324842e-01f, 2.09226869e-02f, -1.12766840e-01f, -1.39557600e-01f, 2.35603191e-02f, 2.03111053e-01f, 9.15290564e-02f, 9.39657316e-02f, -8.50972906e-02f,
  -1.00231692e-02f, -1.33896559e-01f, 7.41340518e-02f, -4.84467261e-02f, -2.54014522e-01f, -6.31412342e-02f, -7.25883991e-02f, -5.83720542e-02f, -2.61472434e-01f, -1.57766670e-01f,
  -1.25959814e-01f, -1.03122123e-01f, -9.36216190e-02f, 7.23603368e-02f, -6.42299429e-02f, 7.60047138e-02f, -2.18736485e-01f, -1.07807465e-01f, -3.87851223e-02f, -1.22790083e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.50288916e-01f, 7.25395560e-01f, 5.89413762e-01f, 1.96090385e-01f, -4.49122995e-01f, 7.05381751e-01f, 7.12429509e-02f, 7.41864622e-01f, 3.42961550e-01f, 1.68900728e-01f,
  2.51298249e-01f, 3.61636013e-01f, 7.05901921e-01f, 2.45157078e-01f, 2.89451361e-01f, 3.96275192e-01f, -1.94273710e-01f, 5.54812551e-01f, 2.00367987e-01f, 6.54118359e-01f,
  1.34478703e-01f, 6.32619634e-02f, 2.91492015e-01f, 2.13243127e-01f, 4.58232462e-01f, 1.75245732e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.91223638e-02f, 4.65770923e-02f, 9.47843492e-02f, -1.40745103e-01f, -1.90529581e-02f, -9.31542590e-02f, -9.15417727e-03f, 1.03057124e-01f, 1.64638281e-01f, -1.32862061e-01f,
  -6.25946596e-02f, 2.54559573e-02f, 1.47917271e-01f, 4.41500731e-02f, -1.61112309e-01f, -5.95221445e-02f, -4.19110149e-01f, 1.29091948e-01f, 9.47467759e-02f, 5.41329347e-02f,
  3.83900166e-01f, 1.64890260e-01f, 1.33070111e-01f, -2.85196602e-01f, -2.36353397e-01f, -2.35258192e-01f, 1.91197991e-01f, -2.96471030e-01f, 2.08820418e-01f, -5.71386330e-02f,
  -4.53177653e-02f, -3.64361219e-02f, 1.49515510e-01f, -1.23704717e-01f, -4.35873568e-02f, 2.29281694e-01f, 2.21656010e-01f, -1.86451048e-01f, -2.67300345e-02f, -2.98930734e-01f,
  1.37610778e-01f, -6.98372256e-03f, 1.55882105e-01f, 1.54356882e-01f, -4.03450802e-02f, -3.14795882e-01f, 3.23791318e-02f, 1.08334675e-01f, -1.52503431e-01f, -1.50070995e-01f,
  4.27345216e-01f, -6.27442002e-02f, -1.84664249e-01f, 3.13439332e-02f, 9.84996930e-02f, 8.72799680e-02f, -1.38797015e-01f, 1.30669191e-01f, -4.16106917e-02f, 2.30487496e-01f,
  -1.50396943e-01f, 1.98016509e-01f, 1.53300283e-03f, -1.32988632e-01f, 4.89789359e-02f, 5.53813465e-02f, -9.53101069e-02f, -6.10313453e-02f, 6.86660875e-03f, 2.89522856e-03f,
  -1.02339931e-01f, 9.59166437e-02f, 3.25973332e-01f, -1.38177797e-01f, 1.72694653e-01f, -1.04418516e-01f, -1.94331750e-01f, -1.55406892e-01f, -3.13018590e-01f, 1.04245566e-01f,
  -1.78538889e-01f, 1.50570333e-01f, -5.06125689e-02f, 2.63444781e-01f, -1.55817553e-01f, -7.24831820e-02f, 3.08993179e-02f, 2.71221668e-01f, -2.72760719e-01f, -1.92756876e-01f,
  -1.35889128e-02f, 2.05238059e-01f, 7.49860853e-02f, -4.64077219e-02f, -2.21123800e-01f, 9.29941386e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.38275950e-02f, 1.49014905e-01f, 1.26027539e-01f, 6.36718571e-02f, -2.30848849e-01f, -1.65642396e-01f, 2.73441106e-01f, 6.80940971e-03f, 3.34560692e-01f, 1.25341922e-01f,
  -4.21188399e-02f, 1.05559659e+00f, -6.16155803e-01f, -1.90534562e-01f, 2.75644153e-01f, 1.74522087e-01f, 1.19065911e-01f, 4.06381905e-01f, 5.66710949e-01f, 2.90306658e-01f,
  2.91598529e-01f, 2.69664943e-01f, -2.27893248e-01f, -2.66668588e-01f, 2.50858158e-01f, 6.17008567e-01f, -3.54962535e-02f, 2.51639932e-01f, 6.80252239e-02f, 2.62641072e-01f,
  -3.30869049e-01f, -3.50481510e-01f, -3.10702652e-01f, 1.54040664e-01f, -2.30793543e-02f, -1.80018663e-01f, -6.65351301e-02f, -1.08651511e-01f, -2.60194063e-01f, 2.37701640e-01f,
  5.85636944e-02f, -2.16811612e-01f, -2.17070565e-01f, -1.23499915e-01f, 7.95358479e-01f, 2.44877413e-01f, -8.89903679e-02f, 1.45912662e-01f, -4.04748261e-01f, 4.82143223e-01f,
  -3.69028002e-01f, -7.19654858e-02f, 5.10987461e-01f, 2.61181235e-01f, -7.74682239e-02f, 2.26541966e-01f, 6.53335080e-02f, 2.61756927e-01f, -2.52176318e-02f, -1.83577448e-01f,
  3.21557581e-01f, -2.37432793e-02f, 1.79973423e-01f, 3.57676536e-01f, 1.40884653e-01f, 7.84073845e-02f, 4.47865352e-02f, -5.16289473e-02f, 3.54498208e-01f, -2.79202104e-01f,
  4.06444013e-01f, 4.04941887e-02f, 2.50642329e-01f, -4.91720736e-01f, -1.86329022e-01f, -5.32882586e-02f, 2.51641840e-01f, -1.15797378e-01f, 3.76504689e-01f, -4.80611213e-02f,
  1.29864991e-01f, -7.63890743e-01f, 2.61576802e-01f, -3.47959012e-01f, -2.96862245e-01f, 3.00060231e-02f, 1.49748355e-01f, 8.42937350e-01f, -1.83574617e-01f, -7.50100799e-03f,
  -3.23773623e-01f, 2.58254915e-01f, -1.45115584e-01f, 2.85484064e-02f, 3.27135354e-01f, -3.00829113e-01f, -1.42214045e-01f, 1.09827898e-01f, 2.31061101e-01f, -5.07760048e-02f,
  -1.87145814e-01f, 5.52772358e-02f, 4.55421180e-01f, 2.95114756e-01f, 3.83241251e-02f, 4.87674356e-01f, -1.35030910e-01f, -3.29987645e-01f, 2.96254069e-01f, 5.18488467e-01f,
  1.19481273e-01f, -1.75258264e-01f, 5.73351197e-02f, -4.55028832e-01f, -1.92607164e-01f, 1.45502940e-01f, 5.90502679e-01f, 1.80429853e-02f, -5.83178639e-01f, -2.78678894e-01f,
  4.95911598e-01f, 7.82697082e-01f, -4.15800810e-01f, -6.82995170e-02f, 1.78374961e-01f, -3.34795177e-01f, 2.66023390e-02f, 2.41121143e-01f, 1.14694387e-01f, 1.05780765e-01f,
  3.05097520e-01f, -9.53264982e-02f, -1.95926592e-01f, -1.36479050e-01f, 4.26680148e-01f, -1.55881226e-01f, -5.18158637e-02f, 1.27518699e-01f, -1.21268846e-01f, 6.57967269e-01f,
  -3.55951488e-01f, -6.26834869e-01f, 4.86375034e-01f, 6.88349828e-02f, 1.99194215e-02f, -1.82401873e-02f, 5.65363728e-02f, -3.17190289e-02f, 1.82378158e-01f, 5.27005434e-01f,
  -2.58660406e-01f, -2.31224775e-01f, 7.13363066e-02f, 6.73651874e-01f, -6.34185150e-02f, 3.47601980e-01f, 1.43397301e-01f, -9.92030129e-02f, 1.50725409e-01f, 1.81847870e-01f,
  6.61259005e-03f, -2.83002518e-02f, 1.07200295e-01f, 1.82311431e-01f, -1.22695394e-01f, 2.37551674e-01f, -1.48410991e-01f, -8.39979798e-02f, 4.76615340e-01f, 2.58508801e-01f,
  4.49822731e-02f, 1.11940645e-01f, 2.52444774e-01f, 1.60204202e-01f, -3.30601543e-01f, 2.13706806e-01f, -5.47154397e-02f, 2.02363253e-01f, 1.04843467e-01f, 5.24410121e-02f,
  -3.22390467e-01f, -3.89420301e-01f, -1.33027375e-01f, 3.99566203e-01f, 2.43627876e-01f, 6.64967597e-01f, 1.01944422e-02f, -2.91484147e-01f, 2.42573336e-01f, -1.56678095e-01f,
  -1.53783128e-01f, -1.63552761e-02f, 2.86637992e-01f, -6.69830292e-02f, 7.43041709e-02f, 1.61355510e-01f, 1.75174102e-01f, 6.26000017e-02f, 2.61204422e-01f, 2.95298517e-01f,
  9.77735445e-02f, 2.47746967e-02f, 4.75497209e-02f, -1.44711167e-01f, 5.25003970e-01f, 8.95870849e-03f, 6.58648312e-01f, 2.71927685e-01f, 8.80301222e-02f, 4.36743289e-01f,
  1.88268557e-01f, -1.37226045e-01f, -1.57100394e-01f, -1.07637435e-01f, 1.91751122e-01f, -3.71601909e-01f, 1.65434465e-01f, -2.04554684e-02f, 4.50938374e-01f, -2.04192400e-01f,
  -4.44373012e-01f, 1.49284571e-01f, 5.50607979e-01f, -2.45826785e-03f, 2.18682855e-01f, -7.54196942e-02f, 1.80741936e-01f, 4.75505367e-02f, 4.66456234e-01f, -2.12597966e-01f,
  -1.75698385e-01f, -1.98808342e-01f, 3.68013918e-01f, 4.00518514e-02f, 2.01195292e-02f, -2.59303907e-03f, 5.09464622e-01f, -4.57009643e-01f, -1.16361685e-01f, -5.62157221e-02f,
  -5.61383367e-01f, -9.12685704e-04f, 3.19766104e-01f, 1.94444031e-01f, -4.07016724e-01f, 1.84284493e-01f, 1.15417212e-01f, 4.69455183e-01f, 1.74941570e-01f, 7.42478132e-01f,
  -9.84327048e-02f, 5.88664412e-01f, -7.48646185e-02f, -6.26424551e-02f, 2.96915799e-01f, -2.77115349e-02f, -2.07850784e-02f, 7.38875121e-02f, 9.73639637e-03f, -1.44347280e-01f,
  1.66172653e-01f, -1.86655432e-01f, 5.96986338e-02f, -1.64841175e-01f, 1.16244458e-01f, -4.10866618e-01f, 1.57646477e-01f, 1.83971584e-01f, -1.16406150e-01f, -1.27428159e-01f,
  -9.55566689e-02f, -4.08151180e-01f, -4.38196003e-01f, -2.84342051e-01f, 5.06097913e-01f, -6.34514447e-03f, -2.19016805e-01f, 3.18465263e-01f, -2.84537692e-02f, 3.03583145e-01f,
  -3.10586452e-01f, 1.19235896e-01f, -1.51423976e-01f, 2.62006968e-01f, 1.46189451e-01f, 4.77916658e-01f, 1.11002199e-01f, 3.23208183e-01f, 1.58715844e-01f, -2.49925181e-01f,
  2.20389470e-01f, 1.60272494e-01f, -1.47744985e-02f, 7.65096676e-03f, 7.11143315e-02f, 3.44127774e-01f, -1.45704597e-01f, 5.65596223e-01f, 8.00629556e-02f, 1.01906411e-01f,
  1.18801266e-01f, -9.92296487e-02f, -3.60107094e-01f, 5.40291071e-01f, 5.30070364e-01f, -7.19921291e-02f, 5.29941678e-01f, -2.00942121e-02f, -2.25148335e-01f, -4.37645525e-01f,
  2.26684049e-01f, -4.50642914e-01f, 2.44701520e-01f, 9.64768454e-02f, 1.69241458e-01f, -1.96614400e-01f, 9.46904048e-02f, -1.65679958e-02f, -1.61337644e-01f, 1.77512556e-01f,
  6.14703596e-01f, 3.19955111e-01f, 1.28746212e-01f, -2.23202765e-01f, 8.53906944e-02f, 7.56321102e-02f, 3.19349110e-01f, 2.92588502e-01f, 3.57914239e-01f, 2.29602307e-02f,
  -1.55088175e-02f, -3.30433935e-01f, 3.73993695e-01f, 1.70766726e-01f, 2.88361937e-01f, -6.91657066e-02f, -1.59101620e-01f, -6.07860863e-01f, 1.34460822e-01f, -2.56173223e-01f,
  -8.63679796e-02f, -1.10747507e-02f, -4.30219889e-01f, -2.67814279e-01f, 6.39062226e-02f, 4.71669436e-01f, -3.39820921e-01f, 3.64494413e-01f, -2.60002285e-01f, -7.61182234e-02f,
  3.96749973e-01f, 4.51240599e-01f, 1.19982421e-01f, 1.84624955e-01f, -3.17456685e-02f, 7.57905021e-02f, -1.06191956e-01f, -6.54210225e-02f, 2.75462065e-02f, 9.34757441e-02f,
  3.71834785e-01f, 4.55512851e-02f, -2.19127178e-01f, 3.57367456e-01f, -5.37044168e-01f, 3.57303381e-01f, 5.58685184e-01f, 2.68719107e-01f, 6.37195528e-01f, 7.13737369e-01f,
  9.20075551e-03f, 4.16962624e-01f, -4.97591525e-01f, 3.79195899e-01f, -1.68421715e-01f, 4.35292758e-02f, 2.18269154e-02f, -3.22658122e-01f, -3.82964797e-02f, 4.84824687e-01f,
  -3.93270791e-01f, 1.44675985e-01f, 2.68521041e-01f, -1.77893490e-01f, 1.13903329e-01f, 3.04771751e-01f, 3.65938246e-02f, -2.39813358e-01f, 1.33633107e-01f, 5.11540566e-03f,
  1.49212435e-01f, 2.48611033e-01f, 2.91567206e-01f, -4.27244008e-02f, 1.17053159e-01f, 5.89797497e-01f, -9.52883586e-02f, 5.84902823e-01f, -4.02942151e-01f, -1.08743466e-01f,
  -3.51292849e-01f, -1.98979735e-01f, 2.81812936e-01f, 2.70280195e-03f, 4.54820842e-01f, 1.82044879e-01f, -1.59254447e-01f, 4.58488256e-01f, 2.11702920e-02f, 2.39015222e-01f,
  -6.36396417e-03f, -9.97333899e-02f, 2.67028987e-01f, 1.55754879e-01f, -2.74519920e-01f, 7.39759058e-02f, -9.11658034e-02f, 6.28959909e-02f, -5.19470014e-02f, 1.06228054e-01f,
  1.55841798e-01f, -3.05705428e-01f, 1.93605289e-01f, 1.64608523e-01f, 3.44716728e-01f, -9.24483657e-01f, -1.92395329e-01f, 5.15461802e-01f, 1.56585231e-01f, -5.39331973e-01f,
  -5.95760867e-02f, 4.23129171e-01f, -1.57103911e-01f, 5.32988429e-01f, 3.08944404e-01f, -1.21811427e-01f, 1.74324989e-01f, 1.46386892e-01f, 2.62965430e-02f, 3.41701865e-01f,
  -3.33549976e-01f, -4.82330620e-01f, 4.34537590e-01f, -1.12433471e-02f, 6.49092555e-01f, 1.10137172e-01f, 1.08576246e-01f, 2.48576298e-01f, 2.37208188e-01f, -2.78491557e-01f,
  1.05833270e-01f, -9.26373079e-02f, -2.29011644e-02f, 1.51445553e-01f, 1.99308805e-02f, 6.16239369e-01f, 1.77581266e-01f, 5.15834928e-01f, 1.91196296e-02f, 4.49734002e-01f,
  -3.49199474e-01f, 3.41114819e-01f, -3.19673896e-01f, 1.66598976e-01f, 2.34281555e-01f, -8.43814373e-01f, 6.58285260e-01f, -1.14591479e-01f, -3.72780800e-01f, -6.38796449e-01f,
  -1.79495849e-02f, -3.18656981e-01f, 2.76850402e-01f, 2.22006947e-01f, -4.15700704e-01f, -3.82460356e-01f, -2.37116870e-02f, -3.85936588e-01f, -4.53120947e-01f, 4.43298101e-01f,
  -1.47293463e-01f, 3.77026528e-01f, 2.23949358e-01f, -1.13171183e-01f, -3.61245453e-01f, -3.14550959e-02f, 2.90519983e-01f, 2.82377303e-01f, -2.71082193e-01f, 3.86084735e-01f,
  -1.39132272e-02f, -6.32107377e-01f, 5.42048633e-01f, 5.07721782e-01f, 1.23819500e-01f, 6.39055073e-02f, 4.34957504e-01f, 2.04687774e-01f, -3.28734338e-01f, -5.54104269e-01f,
  4.15496498e-01f, 6.15211278e-02f, -8.84549599e-03f, -3.53453249e-01f, 1.25524038e-02f, -4.47047949e-01f, 2.12983578e-01f, -1.08947881e-01f, 2.60126084e-01f, -1.29368886e-01f,
  8.39925334e-02f, 5.19259691e-01f, 1.02133758e-01f, 6.46615447e-03f, 7.86762089e-02f, -1.51173919e-01f, 3.94659430e-01f, -4.69537452e-02f, 1.55898005e-01f, 3.98121893e-01f,
  5.75921685e-03f, -6.96774721e-01f, 1.75729707e-01f, 1.50812417e-01f, 1.39304027e-01f, 3.08179557e-02f, 1.24323383e-01f, -3.86567712e-01f, -3.58036339e-01f, -7.40729153e-01f,
  6.66727185e-01f, -5.10367081e-02f, -2.74503976e-01f, 3.59566486e-03f, 2.46661343e-02f, 1.46417111e-01f, -2.11172044e-01f, -1.51439831e-01f, -3.15433107e-02f, 2.33147278e-01f,
  -1.66211084e-01f, 4.86786306e-01f, 2.01172933e-01f, -1.00335419e-01f, -4.25361991e-01f, 6.31262437e-02f, 5.41257821e-02f, 3.39961320e-01f, -1.02016460e-02f, -1.22069167e-02f,
  -5.95922954e-02f, 6.41003102e-02f, -2.03988999e-01f, -4.41286005e-02f, -1.65487066e-01f, -2.89550517e-02f, 6.32183552e-01f, -2.81854123e-01f, 6.17603026e-02f, 1.85507551e-01f,
  4.47811112e-02f, 7.77155519e-01f, -1.81786731e-01f, -2.75504112e-01f, -1.28058121e-02f, 2.02002898e-01f, -5.91548979e-02f, 2.63212025e-01f, 3.50879341e-01f, 6.35393202e-01f,
  2.73719817e-01f, 3.66697699e-01f, 1.96373731e-01f, 1.67979762e-01f, -6.72712773e-02f, 2.44413853e-01f, 2.37618849e-01f, 3.22829038e-01f, -8.09751824e-03f, 1.84683159e-01f,
  2.91112233e-02f, 8.80346000e-02f, -2.81266332e-01f, 2.84764096e-02f, -6.78873509e-02f, 1.42987803e-01f, -7.82259777e-02f, -6.40967965e-01f, 3.48700225e-01f, 4.98470306e-01f,
  2.25828111e-01f, 1.83186218e-01f, 6.84666276e-01f, 9.53615069e-01f, -5.70870817e-01f, 3.19274098e-01f, 4.44647707e-02f, 2.69421548e-01f, 2.59977639e-01f, 3.11911076e-01f,
  -5.64162321e-02f, -1.67066351e-01f, 3.42947483e-01f, 2.83070803e-01f, 1.87097356e-01f, -2.57898122e-01f, 2.41489172e-01f, 1.87699512e-01f, 5.65562010e-01f, 1.61998734e-01f,
  1.34997517e-01f, 1.06138490e-01f, 1.20868526e-01f, 3.44866067e-01f, -2.00775005e-02f, 4.73624945e-01f, 2.40866482e-01f, 1.76927168e-02f, -1.89234212e-01f, -7.15047181e-01f,
  1.90281928e-01f, 5.26991129e-01f, 2.56112188e-01f, 1.00537324e-02f, -2.60923337e-02f, -3.06349397e-01f, -4.96896327e-01f, -2.63561994e-01f, 1.28128946e-01f, -8.83311499e-03f,
  6.72788024e-02f, 5.09805679e-01f, -4.46623087e-01f, -2.82714456e-01f, -3.85377854e-02f, 1.84264794e-01f, 2.26989582e-01f, -3.43589745e-02f, 4.88297850e-01f, 4.59542483e-01f,
  -1.81939393e-01f, 8.43140781e-02f, -1.06972277e-01f, 2.34878406e-01f, -7.74244890e-02f, 1.45456374e-01f, -7.87409842e-02f, 2.81719804e-01f, 3.35074812e-01f, -7.17413798e-02f,
  2.20104590e-01f, -2.35186279e-01f, 3.58813286e-01f, 4.50601161e-01f, -1.61434114e-01f, -1.09647594e-01f, -1.26873359e-01f, 2.59830058e-01f, 2.16378588e-02f, 3.94549787e-01f,
  1.19359359e-01f, -4.29938138e-02f, -1.10113792e-01f, -3.71532068e-02f, 3.58573526e-01f, 8.52663755e-01f, -2.93181092e-01f, 3.95059228e-01f, -4.76828009e-01f, -1.18152015e-01f,
  1.24101199e-01f, 1.94028303e-01f, 3.20523739e-01f, 3.04980993e-01f, 2.32660174e-01f, -1.58136770e-01f, 4.85056132e-01f, -2.14003533e-01f, -6.58073872e-02f, 4.60742921e-01f,
  -5.59436865e-02f, -3.22764128e-01f, -2.50892371e-01f, -2.66529083e-01f, 3.69876981e-01f, 4.24341798e-01f, 7.82548040e-02f, 7.43217543e-02f, -4.89443481e-01f, -2.96692997e-01f,
  4.32776302e-01f, -3.95824283e-01f, 9.39032510e-02f, -1.05709814e-01f, 4.62572873e-02f, 3.61781299e-01f, -4.15887058e-01f, -9.46877301e-01f, 2.90688604e-01f, -3.07214707e-01f,
  7.33875707e-02f, 2.85433859e-01f, 5.07658064e-01f, 1.66177958e-01f, 2.04961598e-01f, 1.17337154e-02f, 1.81367427e-01f, 2.24451795e-01f, -8.81908834e-02f, -1.28722023e-02f,
  4.39008996e-02f, 4.56335425e-01f, 2.47302994e-01f, 3.29549342e-01f, -3.66954990e-02f, 4.54780787e-01f, 1.27682807e-02f, -2.54898388e-02f, -4.01148289e-01f, 4.55490679e-01f,
  4.24555212e-01f, 2.68042535e-01f, 5.94948649e-01f, -2.24321485e-01f, -3.17063123e-01f, -2.32854292e-01f, 1.63360655e-01f, -4.00360674e-01f, 1.02554485e-01f, -3.10101062e-02f,
  1.24596745e-01f, -1.89844251e-01f, 1.79679900e-01f, -1.78799406e-01f, -3.34926605e-01f, 1.93981037e-01f, 3.13351512e-01f, 2.24689469e-02f, 3.29923689e-01f, 3.68781328e-01f,
  2.08935291e-01f, -2.54437059e-01f, 2.46033609e-01f, -2.95239180e-01f, 5.26501894e-01f, 4.69808141e-03f, -4.56935585e-01f, 4.05995846e-01f, 3.38309743e-02f, -3.06975394e-01f,
  3.03216010e-01f, 1.76010162e-01f, 1.74758886e-03f, 2.10928366e-01f, 1.77604184e-01f, 1.64515123e-01f, 2.70863265e-01f, 2.92111337e-01f, -4.59509492e-02f, 5.50004900e-01f,
  1.31540835e-01f, 2.58792877e-01f, -1.85628012e-01f, -2.53601342e-01f, -2.73773726e-02f, -3.94289978e-02f, 2.76864827e-01f, -4.16834861e-01f, -4.40731496e-02f, 2.87351739e-02f,
  -2.20005482e-01f, -3.15491080e-01f, 2.34740879e-02f, -4.32634652e-02f, 6.18421018e-01f, 4.21442568e-01f, -3.87135714e-01f, 4.20866758e-01f, -3.30325991e-01f, -1.68910831e-01f,
  6.81059808e-02f, 5.03063381e-01f, 2.76313692e-01f, 7.75036961e-02f, 6.83816671e-01f, -3.59067231e-01f, 2.31457427e-01f, -1.41887128e-01f, 3.23590413e-02f, -5.24306558e-02f,
  -1.95454150e-01f, -1.81692436e-01f, 1.33961022e-01f, -6.46992505e-01f, -4.32906896e-01f, -3.47802490e-01f, -7.38291442e-02f, 1.67623952e-01f, 3.67023677e-01f, 1.11249089e-01f,
  3.02711278e-01f, 9.11900848e-02f, -1.40620600e-02f, -2.28089228e-01f, -1.79281101e-01f, 1.27820089e-01f, 6.42445624e-01f, 2.86446482e-01f, 4.33749139e-01f, -7.79333115e-02f,
  -3.96966755e-01f, 5.11266649e-01f, -3.35256398e-01f, 5.55364192e-01f, -1.66238889e-01f, -9.31627899e-02f, 3.06195915e-01f, -7.61914968e-01f, 3.38809192e-01f, 3.15650791e-01f,
  3.48377138e-01f, 5.75614944e-02f, -3.64316791e-01f, 1.05388805e-01f, 1.15479215e-03f, -5.04665017e-01f, -3.74008179e-01f, -1.62305400e-01f, 1.67112112e-01f, 1.44837394e-01f,
  2.93044746e-01f, -2.63533682e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  5.04931986e-01f, 7.68710896e-02f, 4.92954493e-01f, 3.75637859e-01f, 1.81903437e-01f, 1.03140071e-01f, 4.19997156e-01f, 7.72577748e-02f, 1.75996367e-02f, 9.53951776e-02f,
  1.16446003e-01f, 2.99776167e-01f, 3.84293526e-01f, 3.30194026e-01f, 4.64400500e-01f, 9.32174399e-02f, 2.16126993e-01f, 6.07455224e-02f, 8.54008831e-03f, 1.20223351e-01f,
  2.15274975e-01f, 3.05074304e-01f, 7.32348040e-02f, 3.78855348e-01f, 1.67757824e-01f, 4.04103339e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -4.15098369e-01f, -4.69767332e-01f, -2.38626897e-01f, -3.65368903e-01f, -2.48204052e-01f, -5.33986866e-01f, -5.48622251e-01f, 3.84813339e-01f, 2.39586737e-02f, 2.85781831e-01f,
  -5.22387326e-01f, -2.58771554e-02f, 2.18853593e-01f, 1.78532764e-01f, -5.00270605e-01f, 2.15921938e-01f, -2.58066893e-01f, -1.17314048e-01f, -7.69099236e-01f, -4.37585890e-01f,
  -9.10703540e-02f, 4.77141351e-01f, -8.89155418e-02f, 5.23297071e-01f, 3.04946959e-01f, -3.75607610e-01f, 9.47724059e-02f, -7.39213705e-01f, -8.43865573e-02f, -4.69788194e-01f,
  2.86151469e-01f, -8.73256028e-01f, -1.03633054e-01f, -4.19932604e-02f, 4.42433983e-01f, 1.00630121e-02f, -1.53413802e-01f, 6.64735436e-01f, -6.69746816e-01f, 4.24718648e-01f,
  -7.09653020e-01f, -7.15360463e-01f, 2.31488980e-02f, 4.25361358e-02f, 7.19124153e-02f, -1.26160860e-01f, 8.47407207e-02f, 1.20741479e-01f, -1.83923811e-01f, -3.25148087e-03f,
  -1.45152017e-01f, 4.02893841e-01f, -8.65305066e-01f, 4.98132706e-01f, -1.48166075e-01f, 4.38718468e-01f, 2.94618011e-01f, 2.36888826e-01f, -2.95294166e-01f, 3.07899594e-01f,
  3.35993022e-01f, -4.97152328e-01f, -2.14930639e-01f, -7.72891283e-01f, 1.70710191e-01f, 1.08128428e-01f, -2.90233910e-01f, -3.10986191e-01f, 2.49145731e-01f, -4.66687530e-01f,
  4.03882146e-01f, -4.26615685e-01f, -4.54921931e-01f, -8.36273432e-01f, 1.68576092e-01f, -4.51422125e-01f, 2.84209907e-01f, -7.64531195e-02f, -6.83758557e-01f, 2.48240586e-02f,
  -3.95902246e-01f, 6.07873917e-01f, -3.04946035e-01f, 3.03126842e-01f, -5.03653407e-01f, -3.81401896e-01f, -3.05845529e-01f, 1.89847156e-01f, 3.54335517e-01f, -3.55278224e-01f,
  -7.03092098e-01f, -3.76083583e-01f, 1.59484372e-01f, 5.49432039e-01f, -4.49201554e-01f, -6.59449160e-01f, -5.64869940e-02f, 1.12144187e-01f, -8.63424167e-02f, -1.56692997e-01f,
  9.56414565e-02f, -2.98719823e-01f, 1.76341712e-01f, 1.17169231e-01f, -4.29267257e-01f, 1.85344622e-01f, 1.52455136e-01f, 4.11749572e-01f, 1.08847082e-01f, 4.43358332e-01f,
  -4.38380748e-01f, 2.06269830e-01f, 7.48352706e-02f, -5.27452230e-01f, -1.75684497e-01f, -2.10385490e-02f, 2.39236206e-01f, -8.60410333e-01f, -6.45865738e-01f, 1.73113838e-01f,
  -6.34805799e-01f, -2.26466894e-01f, 1.23704739e-01f, -3.62328798e-01f, 1.93639770e-01f, 3.49391013e-01f, -5.31836987e-01f, -5.08665919e-01f, -1.76602066e-01f, 1.66487023e-01f,
  1.94032580e-01f, -2.48068169e-01f, -4.94682223e-01f, -2.92454869e-01f, 1.48594812e-01f, -8.32029104e-01f, -4.91149545e-01f, -6.35513291e-02f, -5.02580166e-01f, -9.09899455e-03f,
  -1.61329016e-01f, -7.97694981e-01f, 1.25582069e-01f, 2.82713234e-01f, -4.76734966e-01f, 4.12689954e-01f, 4.96660806e-02f, 2.38084868e-01f, 4.92056370e-01f, -1.09001927e-01f,
  5.26672937e-02f, -2.35254660e-01f, -1.67904601e-01f, -4.36534822e-01f, -9.09006894e-02f, -4.66577560e-01f, 3.00728112e-01f, -2.99090654e-01f, 4.09427941e-01f, 3.92051935e-01f,
  1.78019151e-01f, 3.53003263e-01f, 5.36456823e-01f, 3.81999224e-01f, -3.72911900e-01f, -4.16794628e-01f, -9.99714792e-01f, 4.70366590e-02f, -2.46122852e-01f, 2.17855707e-01f,
  -4.45309371e-01f, -1.82104677e-01f, 1.02408879e-01f, -4.05236632e-02f, 9.12954211e-02f, 9.80517566e-02f, 5.41390538e-01f, -6.44128263e-01f, 2.29304597e-01f, -2.97565460e-01f,
  3.06498885e-01f, 3.38402092e-01f, 1.96987271e-01f, -6.69011593e-01f, -1.83468163e-01f, 4.77364182e-01f, -8.20852146e-02f, 5.89045048e-01f, 1.88482225e-01f, -7.19538629e-01f,
  1.99283540e-01f, 1.37468830e-01f, 5.15133023e-01f, -4.21024412e-02f, -2.28292495e-01f, 2.09319636e-01f, 4.67074752e-01f, -6.89469799e-02f, -1.02864519e-01f, -4.56049263e-01f,
  4.85906303e-01f, -7.06122696e-01f, -1.29753407e-02f, -3.11383218e-01f, 2.30118275e-01f, -1.56625584e-01f, 1.15834549e-02f, -1.13698922e-01f, 1.41940951e-01f, 2.91892923e-02f,
  -3.58337998e-01f, -2.89780237e-02f, -1.70772299e-01f, -3.27108234e-01f, 3.43681693e-01f, -7.78471112e-01f, -5.82667172e-01f, -2.89472461e-01f, -3.17305773e-01f, 4.54168856e-01f,
  -5.31566441e-01f, 1.80299357e-01f, 3.27667028e-01f, 4.31583732e-01f, -3.13400775e-01f, -5.07263720e-01f, -4.24692184e-02f, -2.55562335e-01f, 4.84304041e-01f, -1.86049476e-01f,
  2.53277510e-01f, -2.76903152e-01f, 5.74080050e-02f, -1.11461259e-01f, 2.23475173e-01f, -2.04102113e-03f, -7.22068012e-01f, 5.00354946e-01f, 2.81293601e-01f, -2.12260604e-01f,
  2.99068034e-01f, -1.45398647e-01f, 2.70026386e-01f, -3.23547004e-03f, -3.66471142e-01f, -2.84495533e-01f, 1.69737160e-01f, 1.39271304e-01f, -1.88399911e-01f, -5.15466452e-01f,
  7.34946728e-02f, -3.50396156e-01f, -3.87433618e-01f, -6.99143350e-01f, -6.17447272e-02f, -6.48585558e-01f, 3.08812022e-01f, 1.46630138e-01f, -2.16186985e-01f, 2.30472788e-01f,
  4.65617388e-01f, 2.95014679e-01f, -2.25533307e-01f, 1.07906669e-01f, 7.91093230e-01f, -5.83533645e-01f, -2.29717031e-01f, 4.72375542e-01f, -6.85769856e-01f, 5.27237296e-01f,
  -3.03446827e-03f, -3.01103413e-01f, -4.52083409e-01f, -5.82522452e-01f, 1.37950510e-01f, 3.12912852e-01f, -3.76464605e-01f, -6.56459212e-01f, -1.78739782e-02f, 5.02500981e-02f,
  -4.94752340e-02f, 4.12641019e-01f, -6.96847200e-01f, 2.47880757e-01f, -1.26946568e-01f, 3.61148596e-01f, -2.93467760e-01f, -1.84652917e-02f, 4.02072109e-02f, 3.15011591e-01f,
  -7.75826991e-01f, 3.18189055e-01f, 7.75512680e-02f, 2.95659870e-01f, -1.44974351e-01f, -2.38607660e-01f, -8.69971327e-03f, 4.29039717e-01f, 2.85093755e-01f, -8.57748210e-01f,
  1.93985894e-01f, -1.15782544e-01f, -3.83234650e-01f, 1.77245051e-01f, 3.83411676e-01f, 9.87934396e-02f, -4.50579107e-01f, -4.40667450e-01f, -5.44822693e-01f, 4.30512488e-01f,
  -2.94280797e-01f, -3.95957202e-01f, 3.93571198e-01f, 2.07937375e-01f, -3.23153526e-01f, -4.09879684e-01f, -6.66248798e-01f, 9.59245637e-02f, 3.02712947e-01f, -1.98721290e-02f,
  2.95057476e-01f, -4.39385138e-02f, -2.25965660e-02f, -2.12403432e-01f, -2.95743197e-01f, 4.73286182e-01f, -5.35463095e-02f, 3.38459939e-01f, -1.65736675e-01f, 4.23899531e-01f,
  -5.74142039e-01f, 2.46415824e-01f, -3.90014827e-01f, -6.47661835e-02f, -3.75541061e-01f, -6.18055284e-01f, -7.87525102e-02f, 3.19507599e-01f, 2.49751434e-01f, -8.76866639e-01f,
  -3.05708498e-01f, -4.87587780e-01f, -7.49425828e-01f, -4.33609217e-01f, 1.64426148e-01f, 1.74036682e-01f, 4.59065706e-01f, -3.83343130e-01f, -5.78560233e-01f, 1.54839322e-01f,
  -7.59356022e-01f, 4.43691462e-01f, -3.77767384e-01f, 2.83850282e-01f, 2.78373640e-02f, 5.60288489e-01f, -4.54659134e-01f, -1.05459593e-01f, 3.84709895e-01f, 2.99390167e-01f,
  -3.40100437e-01f, 3.92577171e-01f, 2.46095434e-01f, -1.67824998e-01f, -6.66400671e-01f, -6.27352118e-01f, -1.74998194e-01f, -4.61381704e-01f, -1.48397312e-01f, -5.50021410e-01f,
  5.06983817e-01f, 3.12582582e-01f, -2.11709782e-01f, 1.66625842e-01f, -3.94602120e-01f, -1.15604535e-01f, -4.96236473e-01f, -5.72562754e-01f, -4.03604239e-01f, -1.18664704e-01f,
  -1.88070148e-01f, 2.06020474e-01f, 1.20470166e-01f, 5.67906916e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.34255955e-01f, -2.75212944e-01f, -9.32411663e-03f, -5.29257096e-02f, -4.45643514e-02f, 2.01827362e-01f, 2.47969329e-02f, -1.40976598e-02f, -4.69113402e-02f, 3.76082748e-01f,
  -1.49765447e-01f, 1.25526175e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    