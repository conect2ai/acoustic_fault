/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.52764702e-01f, 1.15123563e-01f, 3.11467677e-01f, -3.65179956e-01f, -2.54516333e-01f, -2.54883349e-01f, 8.03058222e-02f, -5.54574579e-02f, -1.59102052e-01f, 7.49456882e-02f,
  -1.26276284e-01f, -3.27411056e-01f, -5.49779423e-02f, -5.51230786e-03f, 2.49794107e-02f, 2.33209252e-01f, 1.34155363e-01f, -1.09206457e-02f, -2.89654106e-01f, -1.48132205e-01f,
  -4.32311967e-02f, 3.32563519e-02f, 5.14307730e-02f, -3.16071808e-02f, 1.92497745e-01f, -1.42001975e-02f, 3.72409195e-01f, 1.72171950e-01f, 1.28975376e-01f, 6.67368233e-01f,
  8.67401585e-02f, 1.03446983e-01f, -9.48699862e-02f, -1.68452054e-01f, 1.46575019e-01f, 4.51209471e-02f, 2.44966261e-02f, 4.98203523e-02f, 6.12284429e-03f, 5.12698404e-02f,
  6.76376969e-02f, 1.75464852e-03f, -3.12346742e-02f, 5.81133030e-02f, 1.20590003e-02f, 9.24846437e-03f, 3.94764394e-02f, 4.62281443e-02f, 1.39771074e-01f, -1.42479092e-02f,
  -3.11481040e-02f, 6.64698631e-02f, 5.38892969e-02f, -6.13090992e-02f, -6.07743002e-02f, -5.54332621e-02f, 5.33907209e-03f, 1.27014190e-01f, 5.05370498e-02f, 1.88246772e-01f,
  -9.97860730e-02f, -2.15497054e-02f, 2.15737186e-02f, -2.97070816e-02f, -3.31761762e-02f, 4.72555272e-02f, -5.11978939e-02f, -6.73429146e-02f, 1.58566318e-03f, 2.85005793e-02f,
  -5.24193756e-02f, -2.21759966e-03f, -1.29128564e-02f, -5.89731336e-03f, -1.61122084e-02f, -1.23664262e-02f, 1.09641902e-01f, 4.01419438e-02f, 2.53631640e-02f, 2.96136714e-04f,
  -5.45454323e-02f, 8.15366060e-02f, -2.91099399e-02f, 2.29655169e-02f, 9.02262926e-02f, 2.27643177e-02f, 4.49893661e-02f, -6.33508861e-02f, -2.19986569e-02f, 1.46807320e-02f,
  -2.05080375e-01f, -3.62508893e-02f, 4.40773852e-02f, -1.41355451e-02f, 7.59312510e-02f, -5.82533143e-03f, 3.07602659e-02f, -4.13658544e-02f, 2.10591150e-03f, 2.55712997e-02f,
  -4.72236313e-02f, -2.54649017e-02f, 6.73323721e-02f, 3.45743597e-02f, -1.17691457e-01f, -1.09025791e-01f, -3.42467465e-02f, -3.59617546e-02f, 1.43440138e-03f, 7.74622336e-02f,
  5.64192198e-02f, -7.35983253e-02f, -1.73877031e-01f, -1.03676636e-02f, -2.11717300e-02f, -1.06802076e-01f, 8.34696740e-03f, 1.05937840e-02f, -5.50246425e-02f, -1.13047443e-01f,
  7.98326969e-01f, -4.51486632e-02f, -5.78694284e-01f, 3.45698684e-01f, -5.06458320e-02f, 4.76400629e-02f, -1.09107129e-01f, 1.23992264e-01f, 2.18186647e-01f, 1.60836950e-02f,
  1.05136551e-01f, -4.39438922e-03f, -8.38067606e-02f, -8.77392739e-02f, -2.18382478e-02f, -1.66138783e-01f, -4.72324565e-02f, -6.73824847e-02f, -4.77848947e-02f, 4.13183821e-03f,
  2.23424956e-02f, 2.43782066e-02f, 2.32941806e-01f, 1.65518522e-01f, -1.41710797e-02f, -1.12769514e-01f, -3.24222147e-02f, 2.64196336e-01f, 5.82882874e-02f, -2.62449771e-01f,
  -2.29338944e-01f, 1.56308323e-01f, -1.25351101e-01f, 1.07940719e-01f, -6.60221428e-02f, 7.79453740e-02f, -8.29297397e-03f, -1.32955946e-02f, -1.70527566e-02f, 1.09360553e-02f,
  -3.90442796e-02f, 2.38830447e-02f, 3.63790244e-02f, 2.40263809e-03f, 9.88102425e-03f, 4.92733866e-02f, -5.41551933e-02f, -6.63839430e-02f, -4.68030423e-02f, -8.80500153e-02f,
  -1.06208539e-02f, 6.62932768e-02f, 7.34970868e-02f, -8.84352475e-02f, 1.78790540e-02f, 3.21048684e-02f, -2.67154947e-02f, 6.15966059e-02f, 6.55940920e-02f, 5.91451935e-02f,
  7.02943699e-03f, -6.83921278e-02f, -7.39612058e-02f, 2.51025986e-02f, 7.28394687e-02f, -3.74730453e-02f, 1.09808045e-02f, 6.57079443e-02f, -1.00389507e-03f, 1.29213044e-03f,
  -3.68790887e-02f, 2.63201967e-02f, 3.60758677e-02f, 8.32909867e-02f, 3.84468026e-02f, -1.69593468e-02f, 6.43656999e-02f, 2.60342956e-02f, 3.28707173e-02f, 3.02514527e-02f,
  -2.62835957e-02f, -4.12643962e-02f, 3.28718573e-02f, -6.65512607e-02f, 7.05886483e-02f, -5.12517579e-02f, 1.73736140e-02f, 7.14259967e-02f, -4.98571470e-02f, 2.28052717e-02f,
  3.19666117e-02f, -6.83092624e-02f, 4.07495396e-03f, -1.00140370e-01f, -7.47379661e-03f, -1.19022736e-02f, -5.31536192e-02f, -2.44521853e-02f, 2.04523113e-02f, 4.42003012e-02f,
  -1.63729060e-02f, -2.69950740e-02f, 3.04761832e-03f, 8.27582106e-02f, 5.30764647e-02f, -2.51958962e-03f, 9.90514383e-02f, 5.73163806e-03f, 3.49679519e-03f, -2.12786365e-02f,
  6.02257363e-02f, 1.06350491e-02f, 6.89387769e-02f, -6.99963346e-02f, -2.52711326e-02f, -1.54342661e-02f, -9.13369134e-02f, 9.60642658e-03f, -9.12657678e-02f, 6.63120672e-03f,
  -6.30510032e-01f, 2.24200204e-01f, -2.41424203e-01f, -1.85588390e-01f, 1.71266943e-01f, 8.12195055e-03f, 2.82968372e-01f, 4.31707986e-02f, -2.02976596e-02f, 1.27247751e-01f,
  1.24067582e-01f, -2.60607358e-02f, -1.18270203e-01f, -3.33969854e-02f, -1.25493675e-01f, 1.77444741e-01f, -3.12547088e-01f, -4.34551805e-01f, -1.06737398e-01f, 4.62471455e-01f,
  2.90269047e-01f, -1.39819920e-01f, -2.89258569e-01f, 4.38368805e-02f, 3.19841415e-01f, 1.23501178e-02f, -7.45973783e-03f, -1.80113673e-01f, 2.64761657e-01f, -4.29040253e-01f,
  -3.65592986e-02f, -1.59349054e-01f, 1.10431015e-01f, 6.50761053e-02f, 9.67958122e-02f, -1.19447578e-02f, 1.50128324e-02f, -8.98041725e-02f, 4.97971987e-03f, -5.15293144e-02f,
  -2.65990067e-02f, -5.98478094e-02f, -6.58557862e-02f, -1.56063903e-02f, 8.47910717e-03f, 6.34297729e-02f, -6.32908642e-02f, -1.53888151e-01f, 5.34094637e-03f, 1.03583537e-01f,
  1.94273248e-01f, 6.75934507e-03f, -4.85410504e-02f, -3.86907086e-02f, 2.41254102e-02f, -6.07728958e-02f, 1.13974467e-01f, -7.09767863e-02f, -1.07987761e-01f, 3.96151096e-02f,
  1.13705628e-01f, -7.31376931e-02f, 3.33635882e-02f, -2.90401708e-02f, 1.21763228e-02f, -3.80322859e-02f, -4.20520492e-02f, -1.09429052e-02f, -1.34887220e-03f, -2.36761980e-02f,
  -3.26684155e-02f, 9.00292862e-03f, -2.47660372e-02f, 4.77697421e-03f, 4.90688905e-02f, -7.30009452e-02f, -1.10646887e-02f, 1.05365925e-01f, 5.30497991e-02f, -3.14824097e-02f,
  8.00520778e-02f, 3.59122083e-02f, 3.50955389e-02f, 6.86511174e-02f, 5.55634163e-02f, -2.48599034e-02f, 2.65006479e-02f, -3.60639915e-02f, -1.81145966e-02f, -3.61294970e-02f,
  1.65944010e-01f, 5.05854562e-02f, 1.56228309e-02f, 7.33702779e-02f, -2.46079694e-02f, 2.54783034e-02f, -3.94709744e-02f, 6.23235665e-02f, -1.28186554e-01f, -3.96487899e-02f,
  5.71870804e-02f, -7.73493201e-02f, -5.35481535e-02f, -1.53675629e-02f, 4.10906337e-02f, -1.50615033e-02f, 8.56641904e-02f, -1.09384909e-01f, 1.17948400e-02f, 2.80168932e-02f,
  5.66279031e-02f, 4.65748832e-02f, -5.26296757e-02f, -2.35943813e-02f, 4.78877164e-02f, -1.68996342e-02f, -1.48066906e-02f, 1.21232033e-01f, -3.99393700e-02f, 1.59102336e-01f,
  -2.59022474e-01f, 4.65142012e-01f, -8.57187510e-02f, -1.63363874e-01f, 3.22505444e-01f, 1.02998994e-01f, 5.61822534e-01f, -2.33683772e-02f, -2.24028602e-01f, 2.54826874e-01f,
  1.19063638e-01f, -1.71673089e-01f, -9.86529589e-02f, -2.60784775e-01f, -3.04756492e-01f, 1.23448208e-01f, -5.52908853e-02f, -3.66089314e-01f, -4.60609376e-01f, -8.70936960e-02f,
  8.12490135e-02f, 8.29412267e-02f, -2.54718751e-01f, -3.04973483e-01f, 1.20470993e-01f, -1.21658877e-01f, 2.86143452e-01f, 1.86401308e-01f, 2.16184735e-01f, -1.61194801e-01f,
  -2.78719440e-02f, 6.84496835e-02f, -1.85321003e-01f, 1.84701663e-02f, -3.03315613e-02f, -1.27621025e-01f, -2.81357039e-02f, 3.75191122e-02f, 1.07924312e-01f, 3.28481421e-02f,
  -4.07198407e-02f, -3.93531360e-02f, -2.65975315e-02f, 4.10423381e-03f, -5.16813714e-03f, -8.08544755e-02f, -3.70730050e-02f, -8.95197615e-02f, -5.24049848e-02f, 4.57968749e-02f,
  8.49667341e-02f, 6.28089607e-02f, 1.24173999e-01f, 1.12163536e-02f, -1.26199558e-01f, -1.06952183e-01f, 3.38013880e-02f, -9.98052508e-02f, -7.92349875e-02f, 9.58101079e-02f,
  1.24444030e-02f, 9.08359289e-02f, -3.39690000e-02f, 4.37460989e-02f, -4.49495241e-02f, 4.56612743e-02f, -2.67712791e-02f, 5.73389567e-02f, -6.01175837e-02f, 2.12994386e-02f,
  -9.55512468e-03f, -5.81512935e-02f, -4.32554334e-02f, 4.68118750e-02f, -2.78029870e-02f, 2.92331632e-02f, -3.38216163e-02f, -4.27218080e-02f, -5.46314344e-02f, -1.25272963e-02f,
  -4.45196778e-02f, -2.12370865e-02f, 3.72429588e-03f, -7.58833215e-02f, 3.63545353e-03f, -5.77560551e-02f, 2.13601459e-02f, -3.48174460e-02f, 7.18094110e-02f, 1.13643438e-01f,
  1.00459650e-01f, -2.88026065e-01f, -5.81421074e-04f, -8.54449049e-02f, -6.05656803e-02f, 7.52162337e-02f, -2.39954572e-02f, -1.54126640e-02f, 4.11311723e-02f, -1.14886789e-02f,
  -2.83814259e-02f, -5.23518063e-02f, 1.97031628e-02f, -7.15384707e-02f, -3.53615768e-02f, 9.71342027e-02f, -4.18202169e-02f, 6.74348250e-02f, -5.47938347e-02f, 7.25985393e-02f,
  2.64037903e-02f, -1.00292757e-01f, -4.25901674e-02f, -6.84781596e-02f, -4.82005328e-02f, -1.22668231e-02f, 4.77510877e-02f, 4.21843305e-02f, -7.44566545e-02f, 2.90611595e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.13687348e-01f, -2.39772275e-02f, -4.22795087e-01f, -1.31449908e-01f, -8.35234374e-02f, 3.82339470e-02f, -4.59947824e-01f, 2.34482422e-01f, 2.13226318e-01f, -4.48258072e-01f,
  -5.60498416e-01f, -4.42084551e-01f, -4.45173413e-01f, -1.98436081e-01f, -1.09613270e-01f, -4.07532007e-01f, -1.54847100e-01f, -2.41489038e-01f, 2.95186229e-03f, -2.77004438e-03f,
  -2.37909332e-03f, -4.69633758e-01f, -1.10810511e-01f, 1.74526379e-01f, -2.63891760e-02f, 3.00437249e-02f, -2.27466226e-01f, -2.51891129e-02f, 9.10707936e-02f, -2.41979271e-01f,
  -3.74667287e-01f, 1.92280143e-01f, 4.14165966e-02f, 4.93964367e-03f, -1.86412349e-01f, 4.75075021e-02f, 2.62136236e-02f, -1.56335279e-01f, 7.36965686e-02f, 7.57172629e-02f,
  -1.00468107e-01f, -1.24482960e-01f, 3.67803052e-02f, 1.81964394e-02f, -8.84048361e-03f, -5.67546189e-02f, -7.03819692e-02f, -1.50379106e-01f, 3.39195393e-02f, -7.54512697e-02f,
  -1.84760004e-01f, -1.51653379e-01f, 1.46712020e-01f, 2.09913999e-01f, 2.02016845e-01f, -5.70981205e-02f, 1.52374893e-01f, 1.01937540e-01f, 1.32062465e-01f, 1.72085702e-01f,
  -4.78775576e-02f, -2.39371099e-02f, -1.34824142e-01f, 1.01029113e-01f, -7.83471763e-02f, 1.60753235e-01f, 8.72202404e-03f, -1.27652511e-01f, -3.72466221e-02f, 5.92389256e-02f,
  -4.02147770e-02f, -1.37935877e-01f, -7.31057599e-02f, 1.08795404e-01f, -8.27908218e-02f, -1.66620072e-02f, -2.37837695e-02f, 4.92678285e-02f, -6.43651709e-02f, -2.51455307e-02f,
  1.30108017e-02f, 2.03172356e-01f, -4.54943851e-02f, -1.50348339e-02f, 7.07997829e-02f, -5.10746799e-02f, -8.24616626e-02f, -1.41484767e-01f, 8.73042941e-02f, -1.17002130e-01f,
  -9.43829119e-03f, -3.20100561e-02f, 5.73188774e-02f, -2.41777375e-02f, 4.92927060e-03f, 3.01395953e-02f, -8.87097567e-02f, -5.16674332e-02f, -1.14550658e-01f, 2.11812947e-02f,
  1.43950656e-02f, -1.92057461e-01f, -2.56982911e-03f, 6.01236820e-02f, 2.72778962e-02f, 8.31940304e-03f, -1.93620384e-01f, -3.20290700e-02f, 5.85586652e-02f, 1.08935870e-01f,
  -1.79556608e-02f, 4.59582917e-02f, 1.02121338e-01f, -1.56631488e-02f, 2.52163827e-01f, -1.54267773e-01f, 5.61063550e-02f, 2.26302147e-01f, 1.91247053e-02f, 9.54561979e-02f,
  -2.03441381e-01f, -4.91527878e-02f, 1.50008604e-01f, 3.42946351e-01f, 1.49757519e-01f, -2.04935312e-01f, -7.65461743e-01f, -3.14338326e-01f, 3.57933193e-01f, 9.09499303e-02f,
  4.24937576e-01f, 3.13878566e-01f, 2.70681921e-02f, -3.45085151e-02f, -5.61049283e-01f, -2.48630151e-01f, -2.04710569e-02f, -3.37693483e-01f, -4.59728569e-01f, -3.14576328e-01f,
  6.83852509e-02f, -5.63446134e-02f, -2.48582587e-01f, -2.57657558e-01f, 4.64724690e-01f, 2.66376376e-01f, 2.92149216e-01f, 3.31158787e-01f, 1.35364626e-02f, 7.89933383e-01f,
  3.97117227e-01f, 8.52222741e-02f, -2.32217476e-01f, 4.71694916e-02f, 2.90934384e-01f, -9.56330001e-02f, -1.30148485e-01f, 1.79437608e-01f, -3.88967805e-02f, 6.84315319e-06f,
  2.86860883e-01f, 9.36586186e-02f, 6.17858395e-02f, -4.25432362e-02f, -1.84805468e-01f, -2.31993899e-01f, -6.66380674e-02f, -2.09402606e-01f, -1.45830616e-01f, -6.95507601e-02f,
  1.71071768e-01f, 2.64153361e-01f, -1.71814188e-01f, -1.73029795e-01f, -5.81321232e-02f, 1.08477063e-01f, -2.98142079e-02f, 2.07031459e-01f, -2.44584635e-01f, 2.42887184e-01f,
  6.78544044e-02f, 3.28501984e-02f, 4.38192897e-02f, 4.31897566e-02f, -1.84012000e-02f, 9.42049623e-02f, 4.01599370e-02f, -5.55588529e-02f, -2.49973917e-03f, -2.61699837e-02f,
  9.42611694e-02f, -4.50663827e-02f, -2.31151003e-02f, -2.41002776e-02f, -7.07712844e-02f, -4.10676980e-03f, 4.12852280e-02f, -3.43415961e-02f, -1.64543420e-01f, -4.25703228e-02f,
  7.32649537e-03f, -1.35490363e-02f, 7.87429214e-02f, -3.51513661e-02f, -1.19528182e-01f, 7.18707889e-02f, -1.24085573e-02f, 5.15931733e-02f, 1.09326661e-01f, 1.07972072e-02f,
  -5.33417799e-02f, -3.36798579e-01f, 1.45397559e-01f, -1.21095397e-01f, 1.80037960e-03f, 8.28792900e-02f, 9.85300466e-02f, -6.74898550e-02f, 2.93945074e-02f, -2.61893738e-02f,
  -1.24454005e-02f, -1.35174394e-01f, -3.53763476e-02f, -9.45176110e-02f, -2.69223191e-02f, 5.59815727e-02f, 6.76636100e-02f, 7.54230917e-02f, -1.92504153e-01f, 1.40553221e-01f,
  4.19913419e-03f, -3.24471116e-01f, -3.65033746e-01f, -2.58009911e-01f, 8.27786997e-02f, -2.80810863e-01f, -2.00658128e-01f, 1.08530535e-03f, -4.89282221e-01f, -4.60245073e-01f,
  -7.58759677e-01f, -1.14739507e-01f, -2.88119346e-01f, 1.64905682e-01f, -1.61486253e-01f, -4.23188619e-02f, -5.76002412e-02f, 1.42194375e-01f, 5.51599488e-02f, -1.64603084e-01f,
  -4.64169830e-01f, -2.92100701e-02f, -8.65870938e-02f, 1.34011358e-01f, 1.35763809e-01f, 1.12448275e-01f, 2.75152087e-01f, 2.17473760e-01f, 4.19358648e-02f, -1.68569367e-02f,
  1.34076834e-01f, -2.56442875e-01f, -2.35470518e-01f, 2.27062523e-01f, 3.24993908e-01f, 1.33913234e-01f, -1.00405917e-01f, -1.39248446e-01f, 5.46735339e-02f, 6.66421950e-01f,
  -2.91297078e-01f, 1.20576762e-01f, -3.66962999e-02f, -2.10059378e-02f, -2.55804241e-01f, 4.55062874e-02f, -3.77499796e-02f, 2.25762129e-02f, -1.33900777e-01f, 1.94625840e-01f,
  -1.18194163e-01f, -9.48218629e-02f, 2.27666646e-01f, 5.48403012e-03f, -1.69101983e-01f, 1.25969723e-01f, 4.60099727e-02f, 1.04232907e-01f, -9.81019810e-02f, -4.80256043e-02f,
  1.55179337e-01f, -4.00704965e-02f, -1.49862066e-01f, 2.31685996e-01f, 6.46433309e-02f, 2.16226697e-01f, -8.01379513e-03f, 2.21419379e-01f, -1.62523046e-01f, 8.80305842e-03f,
  2.95782275e-03f, -5.33060357e-02f, -6.77650794e-02f, 7.67396986e-02f, -5.31746186e-02f, -4.79261577e-02f, 1.78142175e-01f, 7.31462166e-02f, 8.26071650e-02f, 5.23195490e-02f,
  2.83859000e-02f, -6.06225729e-02f, 1.07117161e-01f, 2.07187012e-02f, 5.49533851e-02f, -6.82608560e-02f, 7.58175999e-02f, 5.78267872e-03f, -1.07843697e-01f, 2.80934013e-02f,
  -1.50268869e-02f, -1.84524450e-02f, 1.22432090e-01f, 2.72646308e-01f, -4.98018302e-02f, -4.79335012e-03f, -1.36245996e-01f, 6.15614653e-02f, -6.40796870e-02f, -1.22845925e-01f,
  -1.30515456e-01f, -7.99123645e-02f, -7.81674162e-02f, 1.09456079e-02f, 3.65850031e-02f, -3.42460088e-02f, -5.94281293e-02f, -1.68548286e-01f, -8.44393596e-02f, 1.16724269e-02f,
  -7.11030886e-02f, -1.29873037e-01f, -1.99597552e-01f, -2.67837793e-02f, -9.09215212e-02f, 3.22869308e-02f, -7.50710592e-02f, -9.90559231e-04f, -3.88778709e-02f, 3.93840373e-02f,
  8.58804490e-03f, -2.14549258e-01f, -4.37906295e-01f, -1.92549035e-01f, -1.24590620e-01f, -3.77839506e-01f, -1.92435429e-01f, -1.20368347e-01f, -5.31605542e-01f, -3.28649789e-01f,
  -6.77822351e-01f, 8.21278840e-02f, -7.98510462e-02f, -1.38346720e-02f, 1.65841535e-01f, 1.77880093e-01f, -2.08184227e-01f, 6.15775287e-02f, 1.60004705e-01f, -3.38812135e-02f,
  5.24672493e-02f, -3.83842662e-02f, -2.86666989e-01f, -5.52360620e-03f, -1.10276647e-01f, -2.09669456e-01f, -2.37246007e-01f, -2.31756046e-01f, -1.15609847e-01f, 2.28858173e-01f,
  1.20440625e-01f, -3.30051392e-01f, -2.57268876e-01f, 6.77075833e-02f, -4.26953025e-02f, -6.14372343e-02f, -1.52540907e-01f, -2.42310449e-01f, 1.64799750e-01f, -1.58173263e-01f,
  -1.83192536e-01f, -1.62326135e-02f, 1.70902371e-01f, 7.93753415e-02f, 9.35365558e-02f, 6.99750036e-02f, -7.89716542e-02f, 3.03024855e-02f, 1.00969501e-01f, 1.34810269e-01f,
  1.06597178e-01f, 6.73371255e-02f, -1.47613630e-01f, -1.88461915e-02f, 1.66703835e-02f, 1.10753840e-02f, -1.89335144e-03f, 1.10347442e-01f, 9.49845463e-02f, 4.07469459e-02f,
  7.97065943e-02f, 9.03955773e-02f, 3.87764275e-02f, 1.11639008e-01f, 1.01418287e-01f, 7.20336959e-02f, 1.73228413e-01f, 2.16205895e-01f, 8.18233639e-02f, 8.69212672e-02f,
  1.91041194e-02f, 9.30944234e-02f, 7.76686594e-02f, 6.32991223e-03f, 4.08817418e-02f, 2.25128487e-01f, 4.50398028e-02f, -2.19537854e-01f, -3.28832380e-02f, 2.50320565e-02f,
  1.65204704e-02f, -1.03551514e-01f, 2.06526704e-02f, -6.12258576e-02f, -3.80872637e-02f, 6.16195798e-02f, 2.89192628e-02f, 6.70925900e-02f, 1.41846724e-02f, -5.18695153e-02f,
  1.68201596e-01f, 1.36958644e-01f, -8.59725699e-02f, 1.57160929e-03f, 8.23156908e-02f, 1.38804436e-01f, 1.93445925e-02f, -6.69992864e-02f, -1.04706079e-01f, 5.86976856e-02f,
  -4.89021875e-02f, -1.77964345e-01f, -2.31041998e-01f, -1.51396319e-01f, 1.02179408e-01f, 7.76001588e-02f, 1.29131321e-02f, 1.05278313e-01f, 1.45378873e-01f, 5.45352250e-02f,
  8.78559425e-02f, 4.95938361e-02f, -6.47529354e-03f, 5.84711060e-02f, 2.25749123e-03f, 1.96444497e-01f, 1.26821995e-01f, 4.63961437e-02f, 8.92774239e-02f, 1.11601755e-01f,
  1.31924778e-01f, 9.44935903e-02f, 3.62667888e-02f, 1.07237838e-01f, 1.17581017e-01f, -4.68454808e-02f, -1.51308076e-02f, 9.76432413e-02f, -2.32124832e-02f, 8.40689521e-04f,
  -1.22026145e-01f, -1.47908032e-01f, 2.98331529e-01f, 7.16163933e-01f, 4.75721151e-01f, 2.92003304e-01f, 4.65482563e-01f, 2.80528843e-01f, 2.64464885e-01f, 2.35160649e-01f,
  -8.62724930e-02f, 2.21192688e-02f, 1.03356622e-01f, -1.37960920e-02f, 1.37728661e-01f, 3.47143501e-01f, 4.08860236e-01f, 1.92059100e-01f, 2.09110007e-01f, 1.18402772e-01f,
  1.12129360e-01f, 8.91568065e-02f, -1.72272041e-01f, 8.08468759e-02f, 2.37345934e-01f, 1.64815411e-01f, 6.09041564e-02f, -1.64288171e-02f, -2.51925558e-01f, 4.80734497e-01f,
  -2.75892049e-01f, 6.04849160e-02f, 4.90719564e-02f, -1.80514485e-01f, -6.13029189e-02f, -2.90845726e-02f, -1.21136727e-02f, 1.95990279e-02f, -5.02232015e-02f, 3.44789028e-02f,
  -5.01343748e-03f, 5.29942922e-02f, 8.76595974e-02f, -4.05190736e-02f, 3.26518677e-02f, 3.03479340e-02f, -7.01675713e-02f, -8.09173062e-02f, 1.17520817e-01f, 8.00905302e-02f,
  5.04340604e-03f, 2.82745641e-02f, 1.99588060e-01f, 4.41023614e-03f, 6.42702207e-02f, 2.34399177e-03f, -1.63693085e-01f, -4.73715030e-02f, 6.22582324e-02f, -8.95982832e-02f,
  8.78403150e-03f, -2.93011796e-02f, 2.92049889e-02f, -2.78853960e-02f, -6.73390925e-02f, -1.69785872e-01f, -8.92095119e-02f, 3.66003476e-02f, 3.39286253e-02f, -1.05187677e-01f,
  -6.23947047e-02f, 7.47541338e-02f, -5.35211004e-02f, 4.41314988e-02f, 1.10525250e-01f, 1.46455839e-01f, -4.97898161e-02f, 9.56172869e-03f, -1.11936808e-01f, 5.37944473e-02f,
  -6.77938312e-02f, -6.97496682e-02f, -6.37164116e-02f, -8.57036412e-02f, -5.14784232e-02f, 1.09983258e-01f, 7.75226951e-02f, 9.12004709e-02f, 7.35767409e-02f, 9.25460383e-02f,
  -2.25052848e-01f, -5.20995930e-02f, -3.34762819e-02f, 7.74333254e-02f, 1.78982049e-01f, -1.82016298e-01f, 1.52226463e-01f, 2.33442821e-02f, -6.81674853e-02f, 1.66405179e-02f,
  -1.32292798e-02f, 3.14028636e-02f, 1.93131827e-02f, 7.21741468e-03f, 7.17672557e-02f, 1.16920210e-01f, -2.88487487e-02f, 7.97236860e-02f, 1.25169456e-01f, -1.12117246e-01f,
  -1.33864097e-02f, 1.48838520e-01f, 1.24496013e-01f, -1.06368409e-02f, -3.64850648e-02f, 2.06408259e-02f, -5.17901182e-02f, 8.36338848e-02f, 4.65115160e-02f, -2.86861621e-02f,
  4.06133160e-02f, -6.42638505e-01f, -5.82950935e-02f, -1.29490148e-03f, 1.57727569e-01f, -1.49995405e-02f, -8.95256698e-01f, -3.78055602e-01f, 3.29241931e-01f, -5.03727913e-01f,
  2.48094928e-02f, 1.85443804e-01f, 1.53915673e-01f, 9.58455577e-02f, -4.18936461e-01f, -5.83404899e-01f, -1.43825307e-01f, -2.33157426e-02f, 4.75758500e-02f, -4.50154580e-02f,
  4.46850024e-02f, 4.70503094e-03f, 2.69351482e-01f, 1.30821317e-01f, -8.38690624e-02f, 3.65013391e-01f, 1.11197159e-01f, 1.29108563e-01f, 3.78079414e-02f, -9.60706472e-02f,
  -1.16338380e-01f, -3.53359282e-02f, 1.67711511e-01f, 6.97555393e-02f, 8.73191431e-02f, -3.37061584e-02f, -8.35871622e-02f, 8.08353908e-03f, 1.51169077e-01f, 1.94498263e-02f,
  3.27414311e-02f, 6.32038862e-02f, 3.02229106e-01f, 8.49979073e-02f, -5.05330674e-02f, -2.77826309e-01f, 2.23169308e-02f, -1.79368526e-01f, -2.01448742e-02f, -1.15162291e-01f,
  -2.29491405e-02f, -6.34633005e-02f, -5.77024408e-02f, -7.26671666e-02f, -2.31692165e-01f, 1.84587002e-01f, -1.96950942e-01f, -1.63899988e-01f, -2.03668952e-01f, -4.59932804e-01f,
  3.16967145e-02f, 2.03980073e-01f, 4.88105277e-03f, -7.15884492e-02f, -6.91521391e-02f, 2.89265811e-02f, -1.01179846e-01f, 1.10600069e-02f, -1.75571963e-02f, -4.43734452e-02f,
  -8.29745159e-02f, 1.31500468e-01f, -9.13503021e-03f, 1.46533540e-02f, 4.59546335e-02f, 6.82041124e-02f, 6.33549392e-02f, -1.35388449e-01f, 5.37506491e-02f, 1.08070485e-01f,
  -6.56456053e-02f, 9.97895002e-02f, 5.41315833e-03f, 3.01459339e-02f, -3.53942029e-02f, 7.54055828e-02f, -4.55406085e-02f, -1.27009451e-01f, 2.80435141e-02f, 7.99531490e-02f,
  4.69810106e-02f, 3.78077418e-01f, -1.20638594e-01f, -2.13633645e-02f, 6.16772026e-02f, 1.30279008e-02f, 9.74836946e-02f, 7.43734017e-02f, 1.24036968e-01f, -9.89324674e-02f,
  -1.10764563e-01f, -1.28516123e-01f, 2.02626418e-02f, 1.01088949e-01f, 1.29100725e-01f, 3.85398306e-02f, -2.58979738e-01f, 1.29400402e-01f, 1.11249417e-01f, -1.14822360e-02f,
  -9.60991606e-02f, -3.38768661e-01f, -1.40666574e-01f, -9.22792554e-02f, 4.20663302e-04f, 1.29093826e-01f, 7.68032763e-03f, -4.40677814e-02f, -1.42840087e-01f, -5.85163474e-01f,
  -4.12319392e-01f, -9.20797408e-01f, 6.63855016e-01f, -1.10871971e-01f, 4.81511652e-01f, 3.79550368e-01f, 3.87441486e-01f, -9.92887840e-02f, -5.08696325e-02f, 1.87030599e-01f,
  -3.31366718e-01f, -4.50032830e-01f, -5.50808489e-01f, -3.48335207e-01f, -3.72480124e-01f, 3.27874511e-01f, 3.32663894e-01f, 1.30205765e-01f, 4.86016512e-01f, 1.72280103e-01f,
  -1.04347989e-01f, 1.51683614e-01f, -2.88468629e-01f, -2.61809528e-01f, -1.08464612e-02f, 1.67360026e-02f, 8.48518759e-02f, -7.54376724e-02f, -4.12857980e-01f, -4.51531857e-02f,
  2.34503627e-01f, -1.62651360e-01f, 7.96294138e-02f, -2.33031511e-01f, -3.13133225e-02f, -7.83849582e-02f, 3.74081843e-02f, -8.23295340e-02f, 9.65938531e-03f, 1.06708355e-01f,
  -1.67377993e-01f, -9.83796343e-02f, 5.29565141e-02f, 7.97741041e-02f, 1.69561937e-01f, 5.12788892e-02f, -5.17137684e-02f, -1.56952798e-01f, -1.57071173e-01f, -5.09443916e-02f,
  -1.88544124e-01f, -8.05281382e-03f, 6.00516200e-02f, -3.10683325e-02f, -5.66993244e-02f, -1.01327710e-01f, -3.53654549e-02f, -1.35368994e-02f, -1.02824800e-01f, -3.97862820e-03f,
  -1.94266010e-02f, 6.87407032e-02f, 1.52645454e-01f, -4.88580391e-02f, 2.30995864e-02f, 1.19329728e-01f, 2.82429010e-02f, -6.63270429e-02f, -5.68758361e-02f, 9.59886890e-03f,
  6.95134997e-02f, 4.15424816e-02f, 6.76720440e-02f, -1.28150508e-01f, -5.31948619e-02f, -8.43705386e-02f, 7.49798715e-02f, 1.38981845e-02f, -1.17166966e-01f, 7.29772225e-02f,
  7.15966616e-03f, 9.07844752e-02f, -5.59258508e-03f, 1.80013645e-02f, -3.87210883e-02f, -4.35697660e-02f, 5.26085123e-02f, -5.06074876e-02f, -4.08331528e-02f, -8.65568146e-02f,
  8.95453244e-02f, -1.13672875e-01f, 2.05712467e-01f, -1.07601553e-01f, 1.03172444e-01f, -2.54668087e-01f, -8.70657712e-03f, -1.71233147e-01f, -3.59879099e-02f, 3.99464257e-02f,
  -1.20410644e-01f, 1.68726500e-02f, 3.63144316e-02f, -1.59353092e-02f, 2.09636003e-01f, 2.32860558e-02f, -4.84885974e-03f, 8.27410147e-02f, -1.60171222e-02f, 8.72349143e-02f,
  5.61154075e-02f, 1.19923495e-01f, 1.95992187e-01f, 6.74039349e-02f, 3.78650911e-02f, 2.27328420e-01f, 1.86402723e-01f, 2.19421834e-01f, 9.87200513e-02f, 2.34980315e-01f,
  -5.02857864e-01f, -1.73394412e-01f, 1.68876097e-01f, -2.87374914e-01f, 1.02882594e-01f, 4.79727775e-01f, -5.51978350e-02f, 1.28830016e-01f, 1.21388264e-01f, 4.46751192e-02f,
  2.55771607e-01f, 1.24530926e-01f, -2.35236868e-01f, -6.15386702e-02f, 1.41988732e-02f, -1.22653663e-01f, -2.07138315e-01f, -2.06863835e-01f, 3.07894051e-01f, 3.84463549e-01f,
  8.04519951e-02f, -2.05567032e-01f, -7.43727386e-02f, 1.58756256e-01f, -2.08702132e-01f, -1.95050448e-01f, -3.66654605e-01f, -3.97275597e-01f, 1.84177011e-01f, -6.96290374e-01f,
  3.37306373e-02f, -7.80103952e-02f, -1.70568339e-04f, -1.37393594e-01f, 2.75370348e-02f, 9.91898701e-02f, 2.67250508e-01f, 7.43491054e-02f, 9.03087780e-02f, 8.35972577e-02f,
  1.44460306e-01f, 3.60523492e-01f, -4.07144688e-02f, 5.39947562e-02f, 8.80833566e-02f, 8.06882903e-02f, 1.32946327e-01f, -6.56072423e-02f, -2.15323806e-01f, 1.64401866e-02f,
  -8.30891132e-02f, -4.11542170e-02f, -3.71771425e-01f, -6.55146241e-02f, 2.29844168e-01f, 9.76803303e-02f, -6.97760843e-03f, 1.72043130e-01f, -3.60189788e-02f, -3.13229978e-01f,
  4.66152802e-02f, 5.05867600e-02f, 8.62326398e-02f, -3.96600738e-02f, 1.80711467e-02f, 1.62417646e-02f, -5.59406588e-04f, -1.35023585e-02f, 4.00940552e-02f, -2.96104383e-02f,
  1.70823008e-01f, 2.88843140e-02f, 1.42733485e-01f, -7.49642402e-02f, -1.07247978e-01f, -5.16517162e-02f, 7.28953779e-02f, -1.23415917e-01f, -2.28411272e-01f, 8.06345642e-02f,
  -1.68559011e-02f, -1.05930157e-01f, 1.26034424e-01f, 1.05847724e-01f, -1.00372575e-01f, -3.11745387e-02f, 2.42387485e-02f, 1.98950171e-01f, -8.21108669e-02f, 2.43107206e-03f,
  -2.60143936e-01f, 1.23533368e-01f, -5.83906285e-02f, 2.29940587e-03f, -1.41536504e-01f, -1.81881730e-02f, -1.53333187e-01f, -5.67238294e-02f, -9.10460129e-02f, -3.32542658e-02f,
  5.67132011e-02f, -2.05089264e-02f, -1.94685102e-01f, 1.14575230e-01f, -3.43178995e-02f, 6.85978904e-02f, -9.62216929e-02f, -2.61969328e-01f, 9.72622931e-02f, 5.55757619e-02f,
  -8.42390656e-02f, -1.74272165e-01f, -2.51557291e-01f, -1.50802463e-01f, -1.85037732e-01f, -1.49730533e-01f, -2.68407553e-01f, -1.22172378e-01f, -2.06573412e-01f, -3.95849228e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.32645041e-01f, -3.28487605e-02f, -1.94591619e-02f, -4.70284402e-01f, 5.05901039e-01f, 5.03228128e-01f, -1.53543696e-01f, 2.95701139e-02f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -2.10947901e-01f, 1.70771345e-01f, 1.29385278e-01f, -1.08661070e-01f, -1.15804501e-01f, -2.93130338e-01f, -1.79760247e-01f, -6.74078166e-01f, 3.67473662e-02f, 1.33496061e-01f,
  7.04581082e-01f, 2.64115512e-01f, 2.16535525e-03f, 1.90127119e-01f, -4.80342090e-01f, -1.37168780e-01f, -1.37215585e-01f, -1.68104231e-01f, 4.63910252e-02f, 4.21653569e-01f,
  -1.13350995e-01f, -2.27762252e-01f, -1.40454531e-01f, -4.12655830e-01f, -1.73717394e-01f, 1.29782438e-01f, 3.11122864e-01f, -9.90660638e-02f, 1.11483723e-01f, -2.19461203e-01f,
  5.10274470e-01f, -4.37136650e-01f, -2.00733244e-01f, 9.26119089e-02f, 3.25387716e-01f, -3.36222559e-01f, -3.98628652e-01f, 2.66336232e-01f, -1.93824261e-01f, -4.58449900e-01f,
  1.45086348e-01f, 1.99884742e-01f, -1.50301665e-01f, 5.78521900e-02f, -9.54625383e-02f, 4.82086480e-01f, -5.48816085e-01f, -2.34069407e-01f, -4.05865014e-01f, 1.06300563e-01f,
  2.70011909e-02f, 3.92357379e-01f, 2.19071075e-01f, 3.70929301e-01f, -2.97728479e-01f, -6.79649770e-01f, -2.52946734e-01f, -1.43142983e-01f, -2.91455002e-03f, -2.59768903e-01f,
  4.73680586e-01f, -1.74141690e-01f, 2.36857310e-02f, -3.06127131e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.78374335e-01f, 1.86938569e-01f, -1.88357264e-01f, 1.67632669e-01f, 5.45803793e-02f, -1.25900254e-01f, 2.49005817e-02f, -3.41414481e-01f, 2.16619074e-01f, -3.89317423e-01f,
  2.48750225e-01f, 3.93411219e-01f, -8.48069414e-02f, 4.87174243e-01f, -2.20046073e-01f, 8.36831033e-01f, 5.22443712e-01f, 4.43931550e-01f, 3.97927314e-01f, -3.04081261e-01f,
  -6.56719029e-01f, 3.85171801e-01f, 7.01593906e-02f, -1.93626389e-01f, 1.39849305e-01f, -1.85681581e-01f, 1.34442106e-01f, -1.58277243e-01f, 4.34001684e-01f, -1.65742785e-01f,
  2.50425845e-01f, -6.54687583e-01f, 7.06393421e-01f, -6.07644357e-02f, 3.98067772e-01f, 8.14729512e-01f, -2.58581221e-01f, 8.24834481e-02f, 6.76719189e-01f, 8.16254556e-01f,
  -8.16228315e-02f, -3.58327150e-01f, -6.61771059e-01f, -3.81299555e-01f, -2.43229210e-01f, -2.12951094e-01f, 4.13845211e-01f, -4.60631460e-01f, 7.47809350e-01f, 1.12091385e-01f,
  2.06680834e-01f, 7.47114301e-01f, -8.88918713e-02f, -1.33557737e-01f, -6.18760400e-02f, 6.37836635e-01f, -2.19835937e-01f, 4.13380086e-01f, 3.81453782e-01f, -2.13085949e-01f,
  2.96551678e-02f, -3.27328756e-03f, 1.05999959e+00f, 1.50989518e-02f, 9.39633548e-02f, 5.19292593e-01f, 4.64194596e-01f, 4.09931064e-01f, -1.03858829e+00f, 1.01619995e+00f,
  5.32697700e-02f, -3.12441699e-02f, 3.23313862e-01f, -6.78607345e-01f, -1.13155413e+00f, -3.66480827e-01f, 1.46821290e-01f, -1.90977454e-01f, -2.00583592e-01f, -3.64339381e-01f,
  -2.46672660e-01f, 5.92111290e-01f, 3.49355519e-01f, 4.19665486e-01f, -5.41859090e-01f, 6.94599509e-01f, 2.45874599e-01f, -8.69042054e-02f, 7.57561386e-01f, 7.31950164e-01f,
  2.76880451e-02f, 1.50335923e-01f, -4.65573370e-01f, 3.40988755e-01f, -1.34824783e-01f, 2.37308368e-01f, 9.58600879e-01f, 7.99396276e-01f, 7.02885211e-01f, -1.68459378e-02f,
  4.34513271e-01f, 6.37561083e-01f, -6.63461268e-01f, 5.50622344e-01f, -1.77470729e-01f, 9.42971230e-01f, -4.51387256e-01f, -5.69727480e-01f, 1.70719445e-01f, 4.23736840e-01f,
  1.86514959e-01f, -3.92835945e-01f, -3.09918106e-01f, 2.32854426e-01f, -6.10898510e-02f, -1.58383653e-01f, 1.65990278e-01f, -6.87810183e-02f, -1.41790107e-01f, -4.83155042e-01f,
  -9.93119776e-01f, 5.95050812e-01f, 6.53840125e-01f, -1.48310348e-01f, 2.63278037e-01f, -5.71617663e-01f, -3.24340194e-01f, -3.70131522e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -3.26031521e-02f, 3.15484107e-01f, 1.15511805e-01f, 5.21450043e-01f, 3.79402399e-01f, 1.54953793e-01f, 6.18053079e-01f, 2.55642444e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -1.16267793e-01f, 3.23728800e-01f, -9.67204869e-02f, 5.49570993e-02f, 2.13304952e-01f, -1.72338456e-01f, 5.50960243e-01f, -9.37471911e-02f, 3.73990834e-01f, 7.60311708e-02f,
  -3.32333267e-01f, -3.61813724e-01f, 1.89977497e-01f, 1.08215548e-01f, -8.17032903e-03f, 1.06780000e-01f, 1.66958705e-01f, 9.97092351e-02f, -1.76297724e-01f, 1.73391223e-01f,
  1.30634114e-01f, -2.99011976e-01f, 3.89133573e-01f, -4.33296204e-01f, -4.34299260e-02f, -3.79719883e-01f, -8.73730928e-02f, -1.44241899e-01f, 3.72133881e-01f, 4.27077204e-01f,
  1.97767377e-01f, -2.55847186e-01f, -3.67595226e-01f, -5.18664122e-01f, 3.50946605e-01f, -5.52574284e-02f, -1.44182444e-01f, 1.02276154e-01f, -1.59842864e-01f, 2.94823498e-01f,
  -6.05894923e-02f, -2.33202875e-02f, -8.32875967e-02f, 3.84203166e-01f, -4.46407914e-01f, -3.26096922e-01f, 3.29566747e-01f, 2.00610667e-01f, -3.18088681e-02f, -2.03373879e-01f,
  -2.82120556e-01f, -4.55362231e-01f, 6.02844894e-01f, 4.59442511e-02f, 5.80483079e-01f, 8.87446254e-02f, -2.65676647e-01f, 9.98204872e-02f, -5.11169195e-01f, -1.80643082e-01f,
  -2.67223805e-01f, 3.75286758e-01f, 5.57421334e-02f, 4.84087855e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  9.66159403e-01f, -3.01253110e-01f, -1.74811453e-01f, -7.22543001e-01f, -3.78773361e-01f, -3.94857109e-01f, -6.81752712e-02f, -2.22808123e-01f, 2.53721356e-01f, -1.07692005e-02f,
  5.00594735e-01f, 6.21819913e-01f, -4.08950113e-02f, 8.19397807e-01f, -1.71194509e-01f, -8.40794206e-01f, 7.34686032e-02f, 2.78829485e-01f, 4.26610485e-02f, 9.34166536e-02f,
  9.71061587e-01f, 2.20964961e-02f, 4.92439061e-01f, 5.67139208e-01f, -7.14094222e-01f, 3.08388114e-01f, -8.12365770e-01f, 3.25912267e-01f, 4.13852066e-01f, 3.02965701e-01f,
  1.16301572e+00f, 5.99634409e-01f, 1.59485266e-01f, -8.17973614e-01f, -7.52757788e-01f, 4.74446058e-01f, 4.28917766e-01f, 6.58458650e-01f, -4.02364135e-02f, 6.06465340e-01f,
  2.24321485e-01f, 5.83168268e-01f, -3.47863227e-01f, 3.79936785e-01f, 8.55002880e-01f, -2.48666987e-01f, -8.84014219e-02f, -3.18850018e-03f, -1.04407683e-01f, 5.37398279e-01f,
  -2.20437512e-01f, 6.54809058e-01f, -5.45113146e-01f, -5.02432346e-01f, 6.80559099e-01f, 3.44125926e-02f, -2.81217188e-01f, 1.80139348e-01f, 5.53543031e-01f, 1.22735858e-01f,
  4.30677503e-01f, 1.02222145e-01f, 9.55877960e-01f, -3.22782993e-01f, 2.65109837e-01f, 9.79968626e-03f, 3.13806653e-01f, 3.36266786e-01f, -7.44074047e-01f, -1.06485620e-01f,
  -4.01449025e-01f, 2.09361184e-02f, -6.03783786e-01f, 3.19994360e-01f, 1.09143186e+00f, 7.27472365e-01f, 2.56654561e-01f, -3.55145186e-01f, 3.94412577e-01f, -3.64899904e-01f,
  2.04217881e-01f, -3.67074072e-01f, 3.56319815e-01f, -1.92409799e-01f, -2.66750842e-01f, 3.33855122e-01f, -9.88285065e-01f, -1.80334717e-01f, -7.39342630e-01f, -2.80744016e-01f,
  4.15413976e-01f, 6.94798887e-01f, -1.27321288e-01f, -2.71038204e-01f, 5.00497162e-01f, 9.42499712e-02f, 6.57540858e-01f, 3.37821282e-02f, 2.24903505e-02f, -7.92247891e-01f,
  2.70297080e-01f, -3.82811502e-02f, 2.35420212e-01f, 5.72469950e-01f, 3.03539336e-01f, -4.89314169e-01f, -7.79152811e-02f, 2.63283014e-01f, -9.51249778e-01f, 5.14082253e-01f,
  3.43504041e-01f, 4.99098092e-01f, 5.74094296e-01f, 5.62725961e-01f, 1.14186339e-01f, 4.27020907e-01f, -3.04725349e-01f, -6.16860569e-01f, 1.24221697e-01f, -2.20879450e-01f,
  -6.75399229e-02f, 5.15038848e-01f, 3.74671161e-01f, 5.62066197e-01f, 9.89376009e-01f, 4.11331803e-01f, 5.71325839e-01f, -2.84919471e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.10923612e-01f, 3.91239196e-01f, -2.36620709e-01f, 3.05156052e-01f, 3.05228770e-01f, 1.04998559e-01f, 2.15964466e-01f, 4.04960483e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  1.39661461e-01f, 4.05865073e-01f, -1.16200991e-01f, 6.42279685e-01f, 5.19881904e-01f, -4.03045356e-01f, 2.07168251e-01f, 1.67497784e-01f, 1.45092696e-01f, -1.56329855e-01f,
  -3.34650546e-01f, -2.81547666e-01f, -2.77046263e-02f, -1.97718352e-01f, 2.95162797e-01f, -1.03664666e-01f, -5.70319474e-01f, 5.21037057e-02f, -2.97917187e-01f, 1.67846426e-01f,
  -6.39689490e-02f, -5.59884667e-01f, -2.99587160e-01f, 4.40340638e-01f, 3.63852046e-02f, -7.58353844e-02f, 5.57900608e-01f, -1.66406170e-01f, -2.54809856e-01f, -5.47345653e-02f,
  1.57903194e-01f, -1.46228105e-01f, -1.73936263e-01f, 2.54463941e-01f, 1.25954822e-01f, -6.43871278e-02f, 5.49392939e-01f, 5.18544137e-01f, -5.25226772e-01f, 3.67651194e-01f,
  1.04526274e-01f, 2.53810287e-01f, 2.38784738e-02f, 2.01618925e-01f, -4.17019755e-01f, -5.37540793e-01f, -2.03805074e-01f, 7.36073256e-02f, -2.17665479e-01f, -1.08266190e-01f,
  -3.69419128e-01f, 9.76412185e-03f, -6.84740424e-01f, -3.09241980e-01f, 4.57654595e-01f, 8.36213470e-01f, -1.91712752e-02f, 1.97818931e-02f, -2.61123657e-01f, -1.90114275e-01f,
  2.11788975e-02f, 2.02561915e-01f, 1.60274982e-01f, -3.11207205e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  1.05900608e-01f, 9.17596817e-01f, -2.50672728e-01f, 6.62536740e-01f, -9.01517034e-01f, -2.27864221e-01f, 7.02287555e-01f, 3.13435614e-01f, -4.91834730e-01f, 1.12866729e-01f,
  6.69545352e-01f, -3.67772840e-02f, 5.75809240e-01f, 1.95377946e-01f, -7.95534015e-01f, 2.58130550e-01f, 7.25731969e-01f, 1.01076238e-01f, 1.18688035e+00f, 3.72329742e-01f,
  1.24897659e+00f, 1.03442121e+00f, -1.09826429e-02f, 2.67050385e-01f, -3.18422318e-01f, 9.58514214e-01f, -1.21088982e-01f, 5.74229240e-01f, -1.10539705e-01f, -6.03406191e-01f,
  2.52881765e-01f, 4.27153140e-01f, 1.04997718e+00f, 1.21376351e-01f, -4.93976563e-01f, -4.61843656e-03f, 3.36058557e-01f, 6.53374791e-01f, -1.24046242e+00f, -1.01346874e+00f,
  8.39562953e-01f, -5.95100522e-01f, -3.56041752e-02f, -6.89370260e-02f, 4.83762771e-02f, -6.59085691e-01f, 4.32998836e-01f, 6.62484765e-01f, 3.86231422e-01f, -9.80849937e-02f,
  -1.18323281e-01f, -7.86064491e-02f, -1.66851476e-01f, -6.79127634e-01f, 1.89254448e-01f, 2.41316885e-01f, -6.25371397e-01f, 5.37630856e-01f, -1.31359056e-01f, 2.39467725e-01f,
  3.14254045e-01f, 1.56516171e+00f, 9.49034616e-02f, 1.18371069e-01f, 1.13945949e+00f, 3.46176893e-01f, -4.23789918e-01f, -4.06005174e-01f, 2.54041493e-01f, -1.33654743e-01f,
  2.11609945e-01f, 1.21863675e+00f, 5.75465858e-01f, 4.57450688e-01f, -1.27792895e+00f, -1.47719011e-01f, -4.88078922e-01f, 4.14325334e-02f, 9.09100652e-01f, -2.40970314e-01f,
  -5.81125557e-01f, -4.99067754e-01f, 6.41354620e-01f, 8.76133025e-01f, 9.86652255e-01f, 3.62616509e-01f, 2.16284171e-01f, -7.62806237e-02f, -4.38007593e-01f, 1.58906311e-01f,
  -2.27758482e-01f, 8.65305543e-01f, 1.03188775e-01f, -8.14702749e-01f, -2.28066757e-01f, 6.14615023e-01f, 5.69953620e-01f, 1.05408728e+00f, 7.34239459e-01f, -5.69502115e-01f,
  -5.21871686e-01f, -2.86566585e-01f, 2.21017152e-01f, -1.33133507e+00f, 4.18389857e-01f, -4.25276518e-01f, -1.25382185e-01f, 4.18207496e-01f, 8.26874912e-01f, 9.79546785e-01f,
  -4.77730542e-01f, 6.14692748e-01f, -3.40305179e-01f, -1.36011660e+00f, -1.34362268e+00f, -4.80127841e-01f, -2.02816352e-01f, -9.68790352e-01f, -9.92186666e-01f, 5.35570920e-01f,
  3.95919204e-01f, 6.96392059e-01f, 9.60046709e-01f, 1.31588299e-02f, -7.41407797e-02f, 1.04983538e-01f, -1.47312626e-01f, 4.85554546e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  3.52670819e-01f, 4.16371316e-01f, 2.19459534e-01f, 3.70093405e-01f, 3.37392122e-01f, 5.14192104e-01f, 4.05514032e-01f, -2.25082725e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  3.17148305e-02f, -5.50451636e-01f, 6.31418467e-01f, 2.67954409e-01f, 2.50071466e-01f, 8.63623798e-01f, 3.43867362e-01f, -8.89433846e-02f, -4.34383243e-01f, -1.00558460e+00f,
  3.60607952e-01f, -1.07298112e+00f, 3.55998814e-01f, 6.14725463e-02f, 5.78940064e-02f, 6.82843924e-01f, -4.09650266e-01f, 1.27470839e+00f, -4.59557287e-02f, -1.73798263e-01f,
  -2.30247840e-01f, 6.54058516e-01f, -6.66160643e-01f, -7.18698604e-03f, -8.20571780e-02f, 2.71573991e-01f, -1.79054976e-01f, -1.30731151e-01f, -1.38075566e+00f, 3.26483667e-01f,
  -6.44389510e-01f, 4.27408189e-01f, 6.30295515e-01f, -3.42908531e-01f, -3.75619888e-01f, 1.05772175e-01f, -8.97632539e-01f, -6.61832631e-01f, -1.74447551e-01f, -4.90812808e-01f,
  -4.26490158e-01f, 7.10777164e-01f, -5.37407994e-01f, -4.70455915e-01f, -3.36464286e-01f, 8.05985391e-01f, -9.60953593e-01f, -6.59059405e-01f, -3.84306848e-01f, 8.18211883e-02f,
  -9.65992585e-02f, -1.39108738e-02f, 9.12972167e-02f, 1.06839398e-02f, -3.04537802e-03f, 1.09541258e-02f, -2.72995442e-01f, -9.11979601e-02f, 8.96887779e-01f, -3.07355672e-01f,
  4.00929898e-01f, -1.52256596e+00f, 2.48487413e-01f, -1.35713911e+00f, 8.63879800e-01f, 3.89339834e-01f, -2.36375019e-01f, -5.21614909e-01f, 6.24437869e-01f, -6.51328266e-01f,
  6.34298101e-02f, -7.05578625e-01f, -4.69781505e-03f, 4.47609991e-01f, 1.27503335e-01f, -5.96650600e-01f, 3.02785248e-01f, -4.34050292e-01f, -8.72543827e-02f, 2.98115402e-01f,
  2.70265758e-01f, -9.90321517e-01f, -4.35461909e-01f, 1.81791872e-01f, 3.51208836e-01f, -2.37578169e-01f, 8.88768137e-01f, 1.25173762e-01f, 2.99610291e-02f, 6.92062378e-02f,
  5.38064718e-01f, -2.78812170e-01f, -8.94020200e-01f, 3.39970082e-01f, 4.56642546e-02f, -7.38422805e-03f, 7.68307507e-01f, 6.16622567e-01f, 1.36722922e-01f, 1.90632120e-01f,
  -1.12083125e+00f, -2.16258138e-01f, 5.63195825e-01f, 1.50382006e+00f, 3.67576689e-01f, 1.39528677e-01f, -8.52914870e-01f, 1.79543793e-01f, 7.69273043e-01f, -3.37366432e-01f,
  -9.25045133e-01f, -8.86935890e-02f, -4.76974733e-02f, 1.86804458e-01f, 3.79189104e-02f, 5.53257465e-01f, -3.25575650e-01f, 7.15748668e-01f, -1.13975763e+00f, 7.69992709e-01f,
  3.15050602e-01f, -3.44675124e-01f, -5.59922814e-01f, 3.78524512e-01f, -7.31852412e-01f, -6.09860718e-01f, -5.26341021e-01f, 6.00031435e-01f, 8.23673844e-01f, 2.36167639e-01f,
  -5.47331989e-01f, -8.50428581e-01f, 9.91009325e-02f, -4.03044671e-01f, -1.52556658e-01f, 3.48210961e-01f, 3.95083547e-01f, -9.75561023e-01f, -7.82757699e-02f, 1.45694800e-02f,
  -2.19363168e-01f, -1.74975350e-01f, 1.85201034e-01f, 5.18701136e-01f, -8.27659667e-01f, -2.06362437e-02f, 3.34046721e-01f, 2.81932414e-01f, 1.02875185e+00f, 3.95060629e-01f,
  6.93849742e-01f, -4.62437481e-01f, -8.58399332e-01f, 3.28810334e-01f, -1.10985363e+00f, 3.30761105e-01f, -6.81157690e-03f, 8.19358826e-02f, -4.86642897e-01f, 5.07181473e-02f,
  -1.64518073e-01f, -8.50035250e-01f, -2.46296972e-01f, 6.54017866e-01f, -9.23961401e-01f, -5.28733671e-01f, -5.92655223e-03f, -1.80523768e-01f, 1.05268709e-01f, -1.29489446e+00f,
  5.88598102e-02f, 1.92667410e-01f, -6.19673610e-01f, -3.87459099e-01f, 7.36552835e-01f, -8.53193820e-01f, -7.78061330e-01f, -3.72266412e-01f, 7.61696815e-01f, -1.33706704e-01f,
  1.83545647e-03f, 3.44602227e-01f, -1.18122828e+00f, -2.25094855e-01f, 2.42384821e-01f, 2.24756217e-03f, -1.18345368e+00f, 2.26708442e-01f, -5.60217559e-01f, 2.98911422e-01f,
  3.24493229e-01f, -5.15362382e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  3.35558772e-01f, -1.50768772e-01f, -9.70055908e-03f, -1.05794728e-01f, -1.78873226e-01f, 1.07755698e-01f, 5.69606483e-01f, 1.86674803e-01f, -5.01426816e-01f, -3.25377971e-01f,
  -1.23105487e-02f, 1.32513434e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    