/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.18294317e-01f, 1.93890668e-02f, 1.28996640e-01f, 7.37694129e-02f, 3.74141075e-02f, 1.01912014e-01f, 9.28421766e-02f, 1.69981364e-02f, 1.83294922e-01f, -1.22709675e-02f,
  -1.10019661e-01f, 4.24900539e-02f, -1.76438987e-01f, -5.23349456e-03f, -1.38834491e-01f, -1.14314049e-01f, 9.96813849e-02f, -1.47765633e-02f, 9.20322090e-02f, 5.88648282e-02f,
  1.02829732e-01f, 3.14673632e-02f, -1.00167856e-01f, -1.27111331e-01f, 4.60562594e-02f, 1.33012794e-02f, -1.12896599e-01f, -1.35418579e-01f, 2.05416628e-03f, -9.31247994e-02f,
  -4.37629875e-03f, -3.90195125e-03f, 5.50535955e-02f, 6.23010099e-02f, -3.52207683e-02f, 3.02539151e-02f, -1.43024214e-02f, -7.20296204e-02f, -2.18132734e-02f, -1.09127378e-02f,
  -4.73636352e-02f, 3.48934010e-02f, 2.13231128e-02f, 4.21348065e-02f, 4.04954739e-02f, 3.51180695e-02f, 8.89369175e-02f, 6.24945760e-02f, 3.35789025e-02f, 5.37214726e-02f,
  6.20983243e-02f, 4.66566980e-02f, 1.43441465e-02f, 2.33723335e-02f, -1.14160106e-02f, -3.38254496e-02f, 4.32185717e-02f, -9.23309997e-02f, 1.03081070e-01f, -3.79036553e-02f,
  -8.42842609e-02f, -2.85201799e-03f, -1.54836914e-02f, 1.86680835e-02f, -2.66100075e-02f, -2.66614165e-02f, -2.43463162e-02f, -7.04950690e-02f, 1.63766090e-03f, -1.75070781e-02f,
  5.11255041e-02f, -2.28714328e-02f, -3.08410022e-02f, -2.19676048e-02f, 3.42627279e-02f, -2.47989744e-02f, 7.46198222e-02f, -6.04048371e-02f, 6.48618713e-02f, -3.80961411e-03f,
  4.59875688e-02f, 7.15945708e-03f, -8.08472112e-02f, 2.22689044e-02f, -9.08932984e-02f, -5.70052601e-02f, -1.18362224e-02f, -9.32412073e-02f, -7.41194263e-02f, 1.27321063e-03f,
  -3.91314141e-02f, -1.50183499e-01f, 4.21374701e-02f, 2.07213406e-02f, -1.04158469e-01f, -3.09053771e-02f, -7.25531876e-02f, -2.12127157e-02f, -4.77366447e-02f, -9.05118212e-02f,
  -6.75058961e-02f, -3.66617590e-02f, 3.08295432e-02f, 2.34994255e-02f, -2.32671946e-03f, -9.71580017e-03f, -5.20222187e-02f, 4.84002894e-03f, 5.97551875e-02f, -5.48634753e-02f,
  -7.57934004e-02f, -3.30156125e-02f, 2.10476667e-02f, -6.35247603e-02f, 1.77026479e-04f, -1.15567379e-01f, 4.97812815e-02f, -2.02434510e-03f, -9.21765808e-03f, -9.97180119e-03f,
  4.55796719e-02f, -5.61973453e-02f, -2.09311113e-01f, 1.97706282e-01f, 1.24543093e-01f, -1.86497718e-01f, -2.44191900e-01f, 8.92662033e-02f, 1.93592347e-02f, -1.31436124e-01f,
  1.46899084e-02f, 6.12596842e-03f, -8.02886486e-02f, 2.10585911e-02f, -3.33586079e-03f, -1.79939792e-01f, 7.05865910e-03f, -1.64271947e-02f, -5.76761328e-02f, 7.36190006e-02f,
  6.48577139e-02f, -2.22286284e-02f, -1.17458440e-01f, 1.19220130e-01f, -1.31468205e-02f, 3.59946638e-02f, 1.81415170e-01f, 6.74716383e-03f, 6.41776398e-02f, 1.88601837e-02f,
  -1.00370295e-01f, -1.03997495e-02f, 3.66462916e-02f, -3.55624110e-02f, -2.80918609e-02f, 3.47665101e-02f, 1.57895200e-02f, -7.65201375e-02f, -5.81564717e-02f, -1.13118615e-04f,
  -5.91882989e-02f, 5.13466969e-02f, -2.59479415e-02f, -2.33278964e-02f, -1.66938417e-02f, 1.74192600e-02f, 3.31659392e-02f, 6.65379018e-02f, -4.28417027e-02f, -2.93567982e-02f,
  -2.62941811e-02f, 5.43439426e-02f, 2.97502987e-02f, 2.33080313e-02f, 2.83318628e-02f, -1.42640090e-02f, 2.75039282e-02f, 6.28218204e-02f, 2.88198143e-02f, 6.40061572e-02f,
  6.61397055e-02f, -4.68716919e-02f, -2.08624694e-02f, -5.01105636e-02f, -6.66974634e-02f, -1.86622627e-02f, 4.16357256e-02f, 2.18972135e-02f, 2.76888479e-02f, -6.19986765e-02f,
  2.74946839e-02f, 5.51752001e-03f, 3.79821286e-02f, -2.34330855e-02f, -2.40482762e-03f, 1.47102699e-02f, -8.51383340e-03f, -1.18771065e-02f, -4.12638113e-02f, 2.53629740e-02f,
  -2.38233656e-02f, 3.08316182e-02f, -2.62749363e-02f, -4.66575325e-02f, -1.46082491e-02f, 3.38620506e-02f, 5.15192300e-02f, 5.24700135e-02f, -5.54995984e-02f, -2.97496207e-02f,
  -7.54683919e-04f, 1.83130845e-01f, 4.74441709e-04f, -2.02205870e-03f, 2.01524273e-02f, 2.63856221e-02f, 4.13834862e-02f, 5.47753051e-02f, 2.54371651e-02f, 1.32581592e-02f,
  9.41736773e-02f, -7.20456243e-03f, -3.50742936e-02f, -3.99127342e-02f, 2.40417067e-02f, 1.45222563e-02f, -5.15666697e-03f, -4.66158874e-02f, 2.57251114e-02f, 5.90524487e-02f,
  8.92923325e-02f, -2.87514254e-02f, 2.40636319e-02f, -3.46742757e-02f, -2.71350294e-02f, 4.47867811e-03f, 3.98632102e-02f, -3.75032797e-02f, 6.83867559e-02f, 3.22610303e-03f,
  -1.01088248e-01f, 2.88299005e-02f, -3.82637560e-01f, 1.06229763e-02f, -1.99201405e-02f, -1.10002629e-01f, -5.15594929e-02f, -6.79000318e-02f, -2.08227918e-01f, 3.35511774e-01f,
  1.35354817e-01f, -1.15155138e-01f, 3.65622947e-03f, 1.11001022e-01f, -1.17655665e-01f, -9.13818553e-02f, 5.52457459e-02f, -1.06719490e-02f, -1.13743640e-01f, 1.07562892e-01f,
  -6.69946522e-02f, 2.69884557e-01f, -1.11194983e-01f, 1.61303878e-01f, 3.69775668e-03f, -1.41488239e-01f, 2.83715189e-01f, -2.70346701e-02f, 5.93008362e-02f, -7.64718931e-03f,
  -1.12797335e-01f, 5.74221164e-02f, -5.01144603e-02f, -8.82861465e-02f, 2.93396432e-02f, -2.36355141e-02f, -2.94639785e-02f, -3.26134376e-02f, -4.26312834e-02f, -1.08876778e-02f,
  -3.34734246e-02f, -3.40049714e-02f, -4.71898727e-03f, -2.80780941e-02f, -1.14511967e-01f, -4.23034802e-02f, -9.77861583e-02f, -3.67255360e-02f, -5.00875562e-02f, -7.04326481e-02f,
  -5.53822592e-02f, -6.85488954e-02f, -1.07215168e-02f, 2.21243761e-02f, -1.31686762e-01f, -4.11984324e-02f, -2.97911651e-02f, -4.94969673e-02f, 3.29102650e-02f, -7.86070675e-02f,
  3.00211068e-02f, -8.03055465e-02f, 8.81900340e-02f, 2.86608618e-02f, 5.09394631e-02f, -2.70782271e-03f, 3.03684939e-02f, 8.60912725e-03f, -4.93622385e-02f, 8.05941895e-02f,
  9.05075371e-02f, -2.87867915e-02f, -2.79777665e-02f, 1.17177479e-02f, 7.68073648e-02f, 1.69492830e-02f, 8.22489243e-03f, 3.01072188e-03f, 1.89775266e-02f, -9.09686163e-02f,
  2.92897895e-02f, -1.87479984e-02f, -4.77679353e-03f, 6.82482403e-03f, -1.62317939e-02f, -6.26724213e-02f, 8.91494751e-03f, -4.84492769e-03f, -2.06381772e-02f, -1.39909517e-02f,
  1.04250126e-01f, 1.79060951e-01f, 5.04826158e-02f, 3.17613222e-02f, -1.13365380e-02f, -2.45629121e-02f, 1.48395840e-02f, -3.35506350e-02f, -4.11720648e-02f, 3.38740125e-02f,
  1.95572209e-02f, 7.41076395e-02f, -5.00418171e-02f, -2.43668389e-02f, 5.77115687e-03f, 6.13820413e-03f, 5.65015487e-02f, 3.44551243e-02f, 9.55030471e-02f, 6.21269876e-03f,
  5.71768805e-02f, 9.49283764e-02f, 3.52965184e-02f, 5.72999306e-02f, 6.03288934e-02f, 2.91708838e-02f, -3.15811718e-03f, -2.20623203e-02f, -2.54948121e-02f, 2.65830159e-02f,
  5.25486410e-01f, -1.54341355e-01f, -1.71310276e-01f, 2.66240239e-02f, 1.25068858e-01f, 5.05509637e-02f, 1.25090461e-02f, -8.70646685e-02f, -1.04134850e-01f, -1.32337242e-01f,
  -9.19420645e-03f, 4.92839366e-02f, -1.32956013e-01f, -7.59595633e-02f, 3.30562964e-02f, -1.44657180e-01f, 4.09545526e-02f, 2.98124868e-02f, -9.31695998e-02f, 7.50158131e-02f,
  -1.89074390e-02f, -2.15322990e-02f, -2.02910323e-02f, -1.72894001e-02f, 1.00733310e-01f, -3.27115841e-02f, 3.24771293e-02f, -1.03008654e-02f, -1.34590641e-03f, -1.69412959e-02f,
  1.26609772e-01f, -1.04281433e-01f, -1.26296580e-02f, -5.81357218e-02f, 6.78196102e-02f, 7.43416846e-02f, 6.14368170e-02f, 2.64041796e-02f, 5.05803674e-02f, -2.91780140e-02f,
  6.57336786e-02f, 5.36157899e-02f, 6.87169135e-02f, -8.03376734e-02f, 1.81065314e-02f, -4.11676466e-02f, -2.39207968e-02f, 1.42420055e-02f, -3.45313107e-03f, 3.67096700e-02f,
  1.43370992e-02f, -3.50135230e-02f, -2.78340857e-02f, -4.84073050e-02f, 7.77771790e-03f, 7.11981505e-02f, 3.60639393e-02f, 4.48669493e-02f, -9.41175409e-03f, 6.57109991e-02f,
  4.36847657e-02f, 3.94824110e-02f, 9.53495037e-03f, -1.17736543e-02f, 1.19874822e-02f, 1.80400573e-02f, -6.00974783e-02f, 2.44235769e-02f, -3.39200199e-02f, 1.42050553e-02f,
  1.16914809e-01f, -2.65071876e-02f, 3.89798656e-02f, 3.32473703e-02f, 1.54781099e-02f, 5.57335978e-03f, 4.45880815e-02f, 5.59670962e-02f, 1.34245932e-01f, 1.34858415e-02f,
  -2.08323542e-02f, -1.21912388e-02f, 5.95810674e-02f, 3.87907811e-02f, 2.96137128e-02f, -3.09484750e-02f, -2.55402476e-02f, 4.17435355e-03f, 4.20138054e-02f, -1.56773180e-02f,
  8.47009048e-02f, -9.54511613e-02f, 6.25065193e-02f, 4.83625606e-02f, -1.95878651e-02f, -2.56517380e-02f, -1.31672114e-01f, -2.35742750e-03f, -9.54370201e-02f, 4.53035645e-05f,
  3.03747319e-02f, -1.12065552e-02f, -1.25318738e-02f, 1.99302752e-02f, -8.78974274e-02f, 1.17656086e-02f, 1.04053430e-02f, -7.05330074e-02f, 2.83340495e-02f, 6.13190085e-02f,
  4.52773599e-03f, 1.38749927e-02f, -4.33155634e-02f, 1.14142202e-01f, 1.02129299e-02f, -2.88772918e-02f, 1.21957678e-02f, 3.51686925e-02f, -5.69652133e-02f, -1.09024961e-02f,
  3.87493297e-02f, 4.78626341e-02f, 1.29050106e-01f, 7.54247308e-02f, -4.11787629e-02f, 1.19619228e-01f, 4.84055504e-02f, -7.13812783e-02f, 7.98221529e-02f, -8.38548914e-02f,
  -8.34415406e-02f, 1.77411273e-01f, -4.35566790e-02f, 7.68667739e-03f, 8.24492127e-02f, 4.62321751e-03f, 8.82986635e-02f, 5.34652546e-02f, 1.01503199e-02f, -5.58441803e-02f,
  -6.81037828e-02f, -1.10222235e-01f, 3.80092114e-02f, -3.69786546e-02f, 7.16411546e-02f, -1.86588746e-02f, -1.60182372e-01f, 1.68263651e-02f, 3.56501527e-02f, 6.23532152e-03f,
  -2.32908931e-02f, -1.46494955e-02f, -2.55835336e-03f, 4.04440872e-02f, -2.84088720e-02f, -4.93145548e-02f, -4.31254990e-02f, 1.06953047e-01f, 2.73834504e-02f, 9.05839354e-02f,
  -2.55987677e-03f, 3.72755304e-02f, 4.04584557e-02f, 2.39728093e-02f, 6.67487383e-02f, -3.79316770e-02f, -3.53809409e-02f, 6.42696694e-02f, 6.40955120e-02f, 5.49684428e-02f,
  -3.56094390e-02f, 5.51548228e-02f, -1.39581254e-02f, 1.68132149e-02f, 2.12614480e-02f, 1.58567838e-02f, -9.33958683e-03f, -3.83740366e-02f, 5.69374785e-02f, 8.22378919e-02f,
  1.49824293e-02f, -3.64720598e-02f, 3.69476415e-02f, -3.84732150e-02f, -2.26637926e-02f, -5.78840561e-02f, -5.21047339e-02f, -3.02272327e-02f, 4.23197709e-02f, -5.36722094e-02f,
  1.97455231e-02f, 3.12110633e-02f, -3.15657295e-02f, 2.09390447e-02f, -2.45389674e-04f, 2.35173781e-03f, 1.82859860e-02f, -4.62536812e-02f, 5.31847104e-02f, 3.71356718e-02f,
  -2.72668935e-02f, 1.04188165e-02f, 2.38269418e-02f, 1.79774594e-02f, 4.50800657e-02f, -1.71267409e-02f, 9.30113718e-03f, 4.80068959e-02f, -2.62747817e-02f, -4.21903096e-02f,
  -6.81506563e-03f, 4.27005552e-02f, 4.14216258e-02f, -3.72999012e-02f, 1.09851956e-02f, -2.59538479e-02f, 9.52566341e-02f, -6.65710215e-03f, 4.55777086e-02f, -7.70441955e-03f,
  -2.74970829e-02f, 6.41886052e-03f, 1.50041850e-02f, 4.44214195e-02f, 1.05878087e-02f, 3.96454241e-03f, 2.90051643e-02f, -5.63560948e-02f, -9.53625981e-03f, -7.65548497e-02f,
  -7.45195746e-02f, -5.74048869e-02f, -4.28153388e-03f, -1.00203324e-02f, -6.61229044e-02f, 3.51936035e-02f, -1.45889106e-04f, 3.32914218e-02f, -6.65061027e-02f, -1.66972224e-02f,
  1.59198239e-01f, 7.01591671e-02f, -2.21696809e-01f, 4.07506227e-02f, -3.20039093e-02f, 1.09205656e-01f, 1.96223676e-01f, -6.33694902e-02f, 7.46374503e-02f, 9.67232361e-02f,
  1.15724228e-01f, 3.62251773e-02f, -8.82764068e-03f, -1.30804034e-03f, 6.03811699e-04f, 1.63719013e-01f, 1.50465921e-01f, 1.04344934e-01f, -6.94228485e-02f, 1.03278659e-01f,
  2.39107963e-02f, 4.81091626e-02f, -1.49351001e-01f, -2.06260644e-02f, -7.59825334e-02f, -2.41338536e-02f, -1.09745726e-01f, -9.17916074e-02f, -6.42927922e-03f, -2.72454210e-02f,
  8.57853740e-02f, 2.92146727e-02f, -4.37421277e-02f, -3.73160616e-02f, 5.08406870e-02f, -3.14164534e-02f, 7.01942993e-03f, -1.22223787e-01f, -1.05677247e-01f, 1.37957260e-02f,
  -2.60256436e-02f, -5.19873276e-02f, -2.93033980e-02f, 2.30739806e-02f, -5.30171432e-02f, -1.15818515e-01f, -8.72602463e-02f, -3.42901610e-02f, 4.04165462e-02f, -1.01411037e-01f,
  -6.35180995e-02f, -9.42325965e-03f, -3.91592085e-02f, -2.46664640e-02f, -7.01991618e-02f, 1.50641231e-02f, -1.89476293e-02f, -3.18812672e-03f, 4.56591211e-02f, -6.57735541e-02f,
  5.64071983e-02f, 2.60882825e-02f, 3.29440366e-03f, -7.11164623e-02f, -6.95494190e-02f, 4.65460354e-03f, -4.00083065e-02f, -2.94876401e-03f, 1.18155610e-02f, 2.33795661e-02f,
  -3.75031084e-02f, 1.55063660e-03f, -2.96063051e-02f, -5.28806150e-02f, -4.10200320e-02f, -3.69042009e-02f, -2.80984472e-02f, 7.70950690e-03f, -4.45214286e-03f, -4.51643839e-02f,
  6.49145320e-02f, 3.05792671e-02f, -7.79104233e-02f, -1.04827946e-02f, 1.79412756e-02f, -4.28619087e-02f, -9.68768541e-03f, 3.07662785e-02f, 1.63237993e-02f, 2.66770739e-02f,
  9.40919518e-02f, 8.23817030e-02f, -1.75288843e-03f, 2.68283449e-02f, 4.74574566e-02f, 5.23870178e-02f, 1.13084307e-02f, 8.66982490e-02f, 5.17158806e-02f, 2.67737694e-02f,
  3.28062475e-02f, 3.28595154e-02f, -1.23545211e-02f, -1.63689088e-02f, 2.29692534e-02f, 4.56593335e-02f, 4.35618795e-02f, 1.01747356e-01f, -7.25136953e-04f, -5.76661304e-02f,
  -2.68205032e-02f, 2.01671142e-02f, -8.82442147e-02f, -5.50920069e-02f, -4.97692302e-02f, 1.57351699e-02f, -1.75079815e-02f, 1.84486844e-02f, -1.07493199e-01f, -3.48299276e-03f,
  -2.72964220e-02f, 1.69061139e-01f, 5.82694039e-02f, -7.86697119e-02f, 1.32007049e-02f, 1.87524900e-01f, 7.18158484e-02f, -2.96365470e-02f, 8.97441357e-02f, 8.82350579e-02f,
  -4.29424224e-03f, -6.42806366e-02f, 2.15101745e-02f, -1.08489826e-01f, -1.66212901e-01f, -6.80433139e-02f, -9.76495817e-02f, 1.18119642e-02f, -8.32277909e-03f, 1.97962336e-02f,
  -1.44626334e-01f, -1.25995725e-01f, -1.05661824e-01f, -4.99126837e-02f, 4.57957275e-02f, -1.68129578e-02f, -1.75108075e-01f, 7.56206885e-02f, -6.75987601e-02f, -6.54021129e-02f,
  5.59978075e-02f, -1.89658701e-02f, -1.90653559e-02f, -2.28559971e-02f, -9.64829251e-02f, 2.54511018e-03f, 2.11243071e-02f, 3.69063579e-02f, -1.57507323e-02f, -3.55478264e-02f,
  1.10412374e-01f, 3.47972885e-02f, 1.35902464e-02f, -6.98218588e-04f, -2.95777097e-02f, 3.30702327e-02f, 7.74210738e-03f, -4.63073552e-02f, 4.76027429e-02f, 2.96260454e-02f,
  -2.10822895e-02f, -5.56500144e-02f, 2.35684495e-02f, -3.48317623e-02f, 4.93845320e-04f, 7.47697949e-02f, 3.05250660e-03f, 5.02889901e-02f, 3.38743888e-02f, 6.24038803e-05f,
  -3.62310521e-02f, -2.88341064e-02f, 6.04418442e-02f, -8.34346283e-03f, 2.62955036e-02f, -7.37407878e-02f, 1.77584235e-02f, 9.36162844e-03f, -7.63155222e-02f, -2.25053821e-02f,
  -8.58719870e-02f, -8.01539570e-02f, -1.37723684e-02f, -6.35157060e-03f, -8.33995566e-02f, 1.92784928e-02f, -1.91644374e-02f, -4.57380451e-02f, -3.00259721e-02f, -2.00615060e-02f,
  5.00411279e-02f, 6.86186599e-03f, -2.84725577e-02f, 3.34673114e-02f, 4.79319431e-02f, -7.00482950e-02f, -4.09863405e-02f, 2.28481758e-02f, 4.94865216e-02f, -5.11134155e-02f,
  -2.59437803e-02f, -2.94445120e-02f, -2.16751639e-03f, -4.67616180e-03f, 4.61532846e-02f, -2.08336711e-02f, 4.69338000e-02f, -6.00431375e-02f, -5.10264523e-02f, -1.30898347e-02f,
  3.63199338e-02f, 6.24113008e-02f, 1.97273213e-03f, -5.66412546e-02f, -4.29157317e-02f, 1.92429014e-02f, -4.65480722e-02f, 1.82287395e-02f, 1.26361502e-02f, 6.26547216e-03f,
  2.33157575e-02f, 1.41125428e-03f, -3.08878366e-02f, 1.01405449e-01f, 1.03255212e-01f, -5.13117202e-02f, -2.50765821e-03f, 4.21377234e-02f, -5.77424355e-02f, -5.02226390e-02f,
  -1.70847997e-01f, -6.73397705e-02f, -3.33052315e-02f, -1.22550763e-01f, -5.28222248e-02f, -1.47593975e-01f, -8.30607116e-02f, -1.34613961e-01f, -8.14854875e-02f, -8.75531696e-03f,
  -5.00198267e-02f, -7.06509203e-02f, 1.87613502e-01f, -8.10253620e-02f, -8.88711885e-02f, 1.09148465e-01f, -8.21393952e-02f, -3.25799524e-03f, -1.88191719e-02f, -1.50494473e-02f,
  -6.58349469e-02f, 8.85309093e-03f, -3.86705473e-02f, -4.53127660e-02f, -9.59350541e-02f, -4.81991693e-02f, 1.44649306e-02f, 7.33076185e-02f, -4.35664840e-02f, 8.81503597e-02f,
  -1.74831208e-02f, -6.76424708e-03f, -1.78051218e-02f, 1.23984791e-01f, -2.92656645e-02f, 2.20416929e-03f, -2.57912464e-02f, 1.21474922e-01f, -6.95643947e-02f, 1.48419132e-02f,
  9.50654075e-02f, 3.25489305e-02f, -2.49903603e-03f, -3.96859460e-02f, -5.03966026e-02f, -2.46282145e-02f, 2.89305728e-02f, 3.37499916e-03f, -1.39502548e-02f, 1.77497454e-02f,
  -5.84154353e-02f, -4.68106428e-03f, -4.90332656e-02f, -5.05068861e-02f, -2.69996319e-02f, -6.06750418e-03f, -2.54712962e-02f, -4.59324457e-02f, 9.56228096e-03f, -6.29042685e-02f,
  2.78182281e-03f, 5.17617092e-02f, 1.01309512e-02f, 2.43651494e-02f, -1.10875983e-02f, 2.69703865e-02f, -2.14061588e-02f, 6.98337099e-03f, -3.02870031e-02f, -4.33467887e-02f,
  4.67975624e-02f, -1.40650349e-03f, 2.27008052e-02f, -2.30196156e-02f, -7.68823698e-02f, 7.02443197e-02f, -8.36367719e-03f, -3.32877971e-02f, -1.62316933e-02f, -6.06120378e-02f,
  3.20850164e-02f, -4.38638665e-02f, 2.26393603e-02f, 4.04048935e-02f, -2.03127675e-02f, -5.66694103e-02f, 5.39976284e-02f, 5.32838441e-02f, 3.21386079e-03f, 3.72994915e-02f,
  -5.27512245e-02f, -7.34124035e-02f, 5.28432876e-02f, 2.43563447e-02f, -1.01915402e-02f, 6.35874085e-03f, 4.03623059e-02f, -9.56120864e-02f, 1.57849398e-02f, 4.99521345e-02f,
  -6.87956810e-02f, -7.50855207e-02f, 1.22304102e-02f, 1.40981060e-02f, -5.16270921e-02f, 2.71417433e-03f, -7.75505044e-03f, -8.86534452e-02f, -9.52026919e-02f, -9.55824368e-03f,
  -6.63196594e-02f, -2.02604923e-02f, -5.92949567e-04f, 5.23193087e-03f, -3.99029963e-02f, -2.26284694e-02f, 3.90694477e-03f, -3.92332822e-02f, 3.30770314e-02f, -3.97291854e-02f,
  -2.86356628e-01f, -4.11329195e-02f, 1.53531104e-01f, 9.28657800e-02f, 6.27076030e-02f, 5.96857704e-02f, 6.38897344e-02f, -2.95917387e-03f, -1.02524593e-01f, 5.93558792e-03f,
  1.14671536e-01f, -1.29173607e-01f, 1.98316742e-02f, 1.09406345e-01f, 1.01552449e-01f, 9.50638577e-02f, 6.71048239e-02f, 1.41380001e-02f, -5.30485809e-02f, -9.66336578e-02f,
  -9.31401849e-02f, 8.68055820e-02f, 1.37357727e-01f, -1.36872251e-02f, -1.11529324e-02f, 1.70958287e-03f, -2.30739936e-02f, 4.96030152e-02f, -5.85673470e-03f, -9.43676848e-03f,
  -7.08243102e-02f, 8.63905079e-05f, 4.16603731e-03f, 1.37258042e-02f, -1.30649209e-02f, -1.05037605e-02f, -6.09059371e-02f, 2.76562832e-02f, 4.71736453e-02f, -2.06289738e-02f,
  -3.99943702e-02f, -3.53066511e-02f, -1.93388108e-02f, 2.38817409e-02f, -6.09487072e-02f, -1.82023495e-02f, 8.74472260e-02f, 3.23025063e-02f, 1.70781855e-02f, -4.32663336e-02f,
  -2.24374961e-02f, -4.13590781e-02f, 3.13237533e-02f, -1.30702397e-02f, -2.14332808e-02f, 4.63369004e-02f, -1.19925458e-02f, -4.28212360e-02f, 2.54766159e-02f, -1.39210420e-02f,
  -6.78741112e-02f, 2.36899238e-02f, -5.89570682e-03f, 6.66370019e-02f, -3.44881904e-03f, 7.24098682e-02f, 1.15041500e-02f, 5.08421734e-02f, -6.61878213e-02f, -4.68252935e-02f,
  3.18049861e-04f, -5.28293848e-02f, -1.13368921e-01f, 5.41623011e-02f, 2.27236468e-03f, -9.40406919e-02f, 6.64163148e-03f, -1.63346324e-02f, 4.09388170e-02f, -2.26099007e-02f,
  4.45544943e-02f, -5.00633493e-02f, 2.01188307e-02f, -8.87372624e-03f, -2.36322973e-02f, 3.39185037e-02f, -1.05837636e-01f, -4.74078991e-02f, 2.83134151e-02f, 5.56151755e-02f,
  -1.00911789e-01f, -1.01250865e-01f, 9.67830569e-02f, 4.98397723e-02f, -1.34748193e-02f, 7.34280944e-02f, -5.37610129e-02f, -2.15595886e-02f, 1.61139630e-02f, -1.58909243e-02f,
  7.71991536e-02f, 6.66910112e-02f, -7.33053386e-02f, 2.64334232e-02f, -5.37214354e-02f, -2.16800440e-03f, 3.29978801e-02f, 1.33701554e-02f, 7.35722035e-02f, 2.97813565e-02f,
  1.84075870e-02f, -4.86545898e-02f, -2.05541663e-02f, 7.62378722e-02f, -1.32719716e-02f, 7.91740641e-02f, 2.62925848e-02f, 6.27550110e-02f, 1.27292229e-02f, 2.66245510e-02f,
  -1.96391568e-01f, 1.70733899e-01f, 7.60657638e-02f, -1.72964826e-01f, -2.18708720e-02f, 2.18129754e-02f, 6.63051084e-02f, -1.89625770e-02f, 1.22848704e-01f, 3.42001505e-02f,
  -1.02000050e-01f, 1.52536735e-01f, 4.49413285e-02f, 3.59046161e-02f, -6.12953976e-02f, 1.24699533e-01f, -8.78860131e-02f, 1.74209904e-02f, 6.08574189e-02f, -1.43900275e-01f,
  -6.41148016e-02f, -5.09689525e-02f, -8.23818296e-02f, 5.69541343e-02f, -8.13227966e-02f, -6.08319975e-02f, -1.23869143e-01f, -1.46446805e-02f, -7.04162493e-02f, 3.58408391e-02f,
  -2.88487468e-02f, -1.32456437e-01f, -2.76620649e-02f, -8.87436140e-03f, -8.66929721e-03f, -8.30202177e-03f, -3.04518640e-02f, -1.42617244e-02f, -4.82816361e-02f, 6.57487959e-02f,
  -2.09827013e-02f, 2.33706627e-02f, 7.75411427e-02f, 3.39530259e-02f, 1.99286696e-02f, 9.60123986e-02f, -1.26344140e-03f, 2.97222249e-02f, 5.61761968e-02f, -1.89439580e-02f,
  6.24320023e-02f, 4.33868682e-03f, 2.66823657e-02f, -2.68133581e-02f, -6.97094426e-02f, 7.49627426e-02f, -4.80322056e-02f, -6.03711326e-03f, -7.72548169e-02f, 1.23612850e-03f,
  3.70492488e-02f, -8.20888951e-03f, -4.42545451e-02f, 2.92777140e-02f, -1.07959853e-02f, -4.10362966e-02f, 4.74661663e-02f, -4.14192565e-02f, 2.26432681e-02f, -6.49097264e-02f,
  -7.72913247e-02f, -4.75734696e-02f, 1.41825667e-02f, -2.11774707e-02f, -8.18542764e-03f, -2.69401874e-02f, 5.96033074e-02f, 5.30345887e-02f, -1.28248418e-02f, -2.50774194e-02f,
  2.06886474e-02f, 4.32814956e-02f, 3.14332824e-03f, -1.44352466e-02f, 4.84540053e-02f, 2.24809013e-02f, 2.98141558e-02f, 8.31981935e-03f, -5.89950243e-03f, -2.99847238e-02f,
  -1.79109275e-02f, -1.85489431e-01f, 5.40184192e-02f, 5.62020950e-02f, -6.39162138e-02f, -5.91996796e-02f, 3.56613137e-02f, 3.24179530e-02f, -5.40085211e-02f, -4.69206721e-02f,
  -2.42401790e-02f, 3.38125341e-02f, -1.01153925e-02f, -3.78273253e-05f, 3.08325198e-02f, -4.81972285e-02f, -5.04353344e-02f, -2.97777429e-02f, -1.64267704e-01f, -8.44402462e-02f,
  -8.83394852e-02f, 1.20212520e-02f, 4.70738113e-03f, 2.30784081e-02f, -6.92954734e-02f, -3.67581546e-02f, -6.49171509e-03f, -3.75892408e-02f, 2.52863374e-02f, 2.42432337e-02f,
  1.95848152e-01f, -6.62144721e-02f, 6.16072677e-03f, -7.25589022e-02f, -1.12651964e-03f, -8.95772129e-02f, -1.12425186e-01f, -5.66411726e-02f, -1.27098054e-01f, -1.17390200e-01f,
  -1.98356524e-01f, -1.05999053e-01f, -1.90214321e-01f, -2.69422472e-01f, -2.95058697e-01f, -1.57143131e-01f, -1.04238182e-01f, -4.80695330e-02f, 1.43699255e-02f, 7.56065594e-03f,
  -2.37746276e-02f, -1.83553457e-01f, -5.36363162e-02f, 1.23377182e-01f, 6.35501221e-02f, 2.56530553e-01f, 1.85507070e-02f, 1.10915288e-01f, 3.65896858e-02f, -3.74132469e-02f,
  1.36025762e-02f, -7.62520060e-02f, -6.08333424e-02f, -3.79727520e-02f, 6.86904863e-02f, 1.12915486e-01f, 5.03553599e-02f, -4.84914482e-02f, 1.48476977e-02f, -6.78373724e-02f,
  1.27998553e-02f, 2.95821968e-02f, -4.23804522e-02f, 1.74470153e-02f, 5.43721877e-02f, 3.25838402e-02f, -4.03693737e-03f, -1.50453765e-02f, -3.56243476e-02f, 1.34748463e-02f,
  -2.56003477e-02f, -1.90045014e-02f, 5.80934957e-02f, 2.65770648e-02f, 2.26592440e-02f, -4.02845703e-02f, -6.16699569e-02f, 3.12497839e-02f, -4.21898253e-02f, 5.71828038e-02f,
  -3.22484337e-02f, 4.85680476e-02f, -2.11958792e-02f, -1.54383406e-02f, -2.52491757e-02f, 5.32033816e-02f, -9.51794386e-02f, -1.49053842e-04f, 3.08236219e-02f, -7.63071328e-03f,
  3.45273800e-02f, -7.28848651e-02f, -6.11027852e-02f, 8.18458758e-03f, -3.39327753e-02f, -9.81609221e-04f, -3.13670263e-02f, -3.94840501e-02f, 1.42583381e-02f, -6.68931231e-02f,
  -6.05375282e-02f, -1.36080431e-02f, -1.62765291e-02f, -8.14572349e-03f, -4.47892696e-02f, 2.07598670e-03f, -7.71439523e-02f, -3.20102950e-03f, 3.98155972e-02f, -7.49631552e-03f,
  -4.84025590e-02f, -9.18116607e-03f, 3.22549492e-02f, 3.91929783e-02f, -2.93011777e-02f, 3.68280485e-02f, -1.67412776e-02f, 5.58663793e-02f, -1.35616753e-02f, -1.90056767e-02f,
  7.90108964e-02f, -2.33333819e-02f, 5.55071197e-02f, -3.66296358e-02f, 4.39574663e-03f, -6.75769895e-02f, -2.71903798e-02f, 4.36167978e-02f, -3.79219577e-02f, -3.35659906e-02f,
  1.47932991e-02f, 8.41065869e-03f, -1.22900726e-02f, 5.85442409e-02f, -6.64362079e-03f, 1.28858596e-01f, 3.66648547e-02f, 5.41584082e-02f, 2.26084981e-02f, -7.04201236e-02f,
  1.35288700e-01f, 1.15871076e-02f, 1.78868428e-01f, -9.85505357e-02f, 5.68343699e-02f, -3.27117294e-01f, -4.31329131e-01f, 6.36590272e-02f, -7.69323930e-02f, -2.14928046e-01f,
  -1.74927473e-01f, -1.33938923e-01f, -1.27893612e-01f, -3.05340648e-01f, -1.90639958e-01f, -1.32664874e-01f, -2.86503136e-01f, -2.09648043e-01f, 1.28826261e-01f, 3.93298529e-02f,
  3.38650942e-02f, -3.87696102e-02f, 5.11849299e-02f, 1.12327904e-01f, -1.81796646e-03f, 2.49353573e-01f, 1.60580009e-01f, 1.24337561e-01f, -1.80529468e-02f, -7.85325468e-02f,
  9.52039137e-02f, 2.44675249e-01f, -2.02481933e-02f, 5.07348478e-02f, 1.15544442e-02f, -8.81004184e-02f, 3.82855311e-02f, 3.07450071e-02f, 3.19204181e-02f, -1.43474443e-02f,
  -6.18479699e-02f, -3.70047726e-02f, 2.33702827e-02f, -2.46688165e-02f, -6.25757799e-02f, 6.07036948e-02f, 4.68598977e-02f, 7.74232950e-03f, 3.03715412e-02f, -1.57451686e-02f,
  -1.33753214e-02f, -3.37504670e-02f, -2.87170317e-02f, -5.27071729e-02f, 7.95254670e-03f, -9.33635980e-02f, -2.00792449e-03f, -3.18102390e-02f, -3.28916050e-02f, -6.25751019e-02f,
  5.52226938e-02f, 1.81707237e-02f, -3.11916731e-02f, 6.34709746e-02f, 6.98879082e-03f, 5.01130670e-02f, -7.13030994e-02f, -6.24757400e-03f, 5.18971644e-02f, -3.68354730e-02f,
  -3.38535793e-02f, 1.28976637e-02f, 4.13253084e-02f, -1.98209025e-02f, 4.38511148e-02f, 6.02505635e-03f, 2.28156820e-02f, 6.30192831e-02f, -1.88518800e-02f, 2.00740155e-02f,
  -3.24809481e-03f, -2.52725668e-02f, -2.08302736e-02f, 3.96579057e-02f, -6.49324283e-02f, -1.75912899e-03f, 2.05568932e-02f, 2.94914264e-02f, 1.26614990e-02f, 5.05397841e-02f,
  -3.80466245e-02f, 1.55249104e-01f, 4.26144451e-02f, 1.85462236e-02f, 1.09264590e-02f, -1.27906231e-02f, -2.73645166e-02f, -4.91130054e-02f, -8.11721664e-03f, 4.74562263e-03f,
  6.36084974e-02f, 5.92495361e-03f, 2.64862981e-02f, 5.11820661e-03f, -1.19884347e-03f, -5.77669293e-02f, -3.13450508e-02f, -5.48049286e-02f, -2.01153308e-02f, 4.64576110e-02f,
  9.29020494e-02f, 4.14205939e-02f, -4.51531671e-02f, 6.46546856e-02f, 1.68559123e-02f, -1.67486127e-02f, 6.09029038e-03f, 2.84794681e-02f, 3.56031433e-02f, 1.86036387e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.04748635e-02f, -1.77087113e-01f, 1.47869483e-01f, 4.37543839e-02f, 1.99345261e-01f, 1.79209113e-01f, 1.71287581e-01f, 8.70117396e-02f, -1.27881877e-02f, -2.66749144e-01f,
  -9.98275653e-02f, -6.03611991e-02f, 7.62265325e-02f, -7.61694014e-02f, 2.51790911e-01f, 7.52345100e-02f, 1.65501516e-02f, -1.48806453e-01f, 6.78892881e-02f, -4.57155034e-02f,
  5.57399914e-02f, -6.43352941e-02f, 1.93931177e-01f, 1.09801264e-02f, -4.56351079e-02f, -1.49286455e-02f, -1.19486563e-01f, 1.68050930e-01f, -1.11657321e-01f, 8.99742171e-02f,
  6.00983016e-02f, 9.56515409e-03f, 1.07342966e-01f, -2.80920807e-02f, 4.51482460e-02f, -6.43988550e-02f, 5.40884882e-02f, 8.85002092e-02f, -6.46048505e-03f, -1.02962181e-01f,
  5.67579549e-03f, -6.74629286e-02f, -4.21858132e-02f, -2.03108080e-02f, -3.14933732e-02f, 4.44707740e-03f, 1.58464555e-02f, 4.58174273e-02f, -4.25519980e-02f, 2.91392058e-02f,
  6.48535043e-02f, -5.16611105e-03f, 8.43076482e-02f, -5.69785498e-02f, 4.37073149e-02f, -6.90753907e-02f, 6.39536651e-03f, 1.22792229e-01f, 1.09959310e-02f, -3.80683541e-02f,
  6.45246953e-02f, 6.60939608e-03f, -3.22760157e-02f, 9.37891938e-03f, -4.17648368e-02f, -6.98331371e-02f, 6.00268543e-02f, -3.65188643e-02f, -1.91502720e-02f, -2.56543010e-02f,
  -2.92197634e-02f, -4.06937189e-02f, 3.08363438e-02f, 4.87710275e-02f, -4.43950593e-02f, -1.33791372e-01f, -5.73237091e-02f, 3.56156938e-02f, 4.96192202e-02f, -8.39995518e-02f,
  -5.22030555e-02f, 5.17920870e-03f, 5.46171069e-02f, 1.88374601e-03f, -8.76877680e-02f, 1.11522051e-02f, 1.77148394e-02f, -7.72405118e-02f, -1.00335553e-02f, 3.92316133e-02f,
  -7.94732049e-02f, -1.99744642e-01f, -6.26551583e-02f, -8.08099657e-02f, 6.69960901e-02f, -9.77074727e-02f, 6.02341630e-02f, -4.86885058e-03f, -6.37929216e-02f, 6.32729530e-02f,
  5.84458373e-02f, 4.46817428e-02f, -6.04092143e-02f, -7.64304250e-02f, -3.82664278e-02f, -2.72378400e-02f, -7.23633543e-02f, -7.49931782e-02f, -9.30088535e-02f, 2.54965331e-02f,
  7.84195960e-03f, 7.06823096e-02f, -3.30083654e-03f, -2.90829763e-02f, -7.36034140e-02f, 6.01612180e-02f, -6.06783666e-02f, -6.06709048e-02f, -1.53098796e-02f, -1.01036876e-01f,
  -1.49451699e-02f, 9.88134742e-03f, 9.84639302e-02f, -8.32913741e-02f, -5.69702499e-02f, -1.01666078e-01f, -3.61227896e-03f, -1.22071125e-01f, -7.25344643e-02f, -6.05827719e-02f,
  -5.27389199e-02f, -2.40708329e-02f, -2.71805562e-02f, -7.75895119e-02f, 9.89716053e-02f, 1.71100944e-01f, -1.07674918e-04f, 5.16438903e-03f, 7.09977001e-02f, -4.22632098e-02f,
  4.71782237e-02f, -1.77067053e-02f, 7.19017461e-02f, 5.43682501e-02f, -5.01716472e-02f, -4.76946309e-02f, 3.62602174e-02f, 5.40025812e-03f, 2.69223694e-02f, -9.83240157e-02f,
  -1.44166216e-01f, -4.17244099e-02f, -1.14243612e-01f, -7.52318725e-02f, -4.54633571e-02f, 1.17116738e-02f, -8.16179439e-02f, -7.70533399e-04f, -4.34873067e-02f, -5.07869720e-02f,
  5.16403913e-02f, 6.75000921e-02f, -3.27809453e-02f, 6.53504953e-02f, -6.04903512e-02f, 6.11288138e-02f, -1.55730154e-02f, -8.09909552e-02f, -7.65162185e-02f, 1.09451748e-02f,
  -3.24799935e-03f, -6.69929609e-02f, 2.33021714e-02f, 3.23870033e-02f, -5.55822775e-02f, 2.88390554e-03f, -7.36661106e-02f, -7.86887929e-02f, 4.01606448e-02f, -8.73143151e-02f,
  4.31251489e-02f, -1.57216880e-02f, 6.02445044e-02f, -6.31232560e-02f, -3.56299244e-02f, -2.93766856e-02f, -6.19119080e-03f, -1.43616321e-02f, -9.27163810e-02f, -5.65893278e-02f,
  1.82900559e-02f, 6.27985522e-02f, -1.62070040e-02f, -7.08200112e-02f, -3.37808095e-02f, -3.32741514e-02f, 2.10436564e-02f, -1.95472203e-02f, -3.84589098e-02f, -1.23694399e-02f,
  -2.35122796e-02f, -8.12954903e-02f, 2.24961862e-02f, -6.47460446e-02f, -6.29088879e-02f, -5.31893969e-03f, -2.74304152e-02f, -1.81210916e-02f, -7.91895911e-02f, 4.45012003e-03f,
  -7.41365105e-02f, 3.56290638e-02f, 5.44905514e-02f, -8.50015730e-02f, -7.79243633e-02f, -1.12249389e-01f, -4.08774354e-02f, 5.54665700e-02f, -6.08027913e-02f, -2.68336479e-02f,
  3.79639231e-02f, -7.27116913e-02f, -6.93990365e-02f, 4.86783078e-03f, -1.22933351e-02f, -7.53135886e-03f, 2.51964126e-02f, 3.29412259e-02f, 2.91706938e-02f, 4.20989469e-02f,
  2.09177216e-03f, 4.64994200e-02f, 1.08542465e-01f, 4.97838669e-02f, -5.43864444e-02f, -1.60485841e-02f, 4.71804850e-02f, 7.87404403e-02f, -1.54537912e-02f, 9.62614194e-02f,
  1.01497853e-02f, -1.08557843e-01f, 1.84183605e-02f, 2.66570095e-02f, 1.06016807e-01f, -5.82836233e-02f, -2.90304068e-02f, 4.46965247e-02f, 1.38679489e-01f, -1.48886546e-01f,
  -3.56889144e-02f, 5.86687289e-02f, -1.50543034e-01f, 3.96843851e-02f, 7.97832906e-02f, -9.24393758e-02f, 1.08217239e-01f, -9.79813281e-03f, -3.70786749e-02f, -4.17814478e-02f,
  9.31898728e-02f, 5.63399978e-02f, 1.36695087e-01f, 9.64827389e-02f, 3.04859169e-02f, 5.53135313e-02f, -7.45201036e-02f, -1.12370834e-01f, -2.95250900e-02f, 5.35241254e-02f,
  6.33966550e-02f, -5.28748184e-02f, 2.95176264e-02f, 5.21559604e-02f, 8.39600153e-03f, -7.05724955e-02f, 5.50874546e-02f, 1.90062402e-03f, 6.27910420e-02f, 9.22032446e-02f,
  -6.70036674e-02f, 8.19065273e-02f, 8.32005665e-02f, 7.68566728e-02f, 8.86802003e-02f, 9.56800357e-02f, 6.30280972e-02f, 8.06725398e-02f, -2.72417907e-02f, 1.57602690e-02f,
  -6.91847429e-02f, 6.95883995e-03f, -8.44435394e-02f, 4.71114006e-04f, -5.22633567e-02f, 4.59997589e-03f, -6.56374916e-02f, -1.68830529e-02f, -1.16800116e-02f, 5.53733259e-02f,
  -5.54515980e-02f, 5.33970483e-02f, 1.91360675e-02f, -7.07781538e-02f, 4.14180681e-02f, 8.16094056e-02f, -8.24741796e-02f, -8.68617296e-02f, -2.90328339e-02f, 4.85838503e-02f,
  -9.38202590e-02f, 2.82636415e-02f, -4.27805893e-02f, 5.82418814e-02f, 1.71055943e-02f, 3.13291177e-02f, -1.32818557e-02f, -7.55228475e-02f, 7.64763653e-02f, -4.01795655e-02f,
  -7.64456391e-02f, 5.02183177e-02f, 1.36330687e-02f, -5.76041453e-03f, 4.02756631e-02f, -5.09203933e-02f, -9.83930193e-03f, 3.22302990e-02f, 4.54369187e-02f, -5.80951236e-02f,
  -1.00501001e-01f, 1.53891854e-02f, -7.44703505e-03f, -3.25259956e-04f, -3.36051434e-02f, -9.26861241e-02f, -4.18620780e-02f, 4.29407805e-02f, -7.75400549e-02f, -3.33469100e-02f,
  6.81478754e-02f, 3.51287164e-02f, -8.58708844e-03f, 2.38141138e-02f, -2.49706097e-02f, -4.44599846e-03f, 8.96004289e-02f, 3.41629796e-03f, -5.98076247e-02f, -3.53158377e-02f,
  1.68685298e-02f, -4.35013697e-02f, -1.40894614e-02f, 8.64753220e-03f, 8.51914734e-02f, -1.09655121e-02f, -6.37313500e-02f, 6.11246414e-02f, -9.10313949e-02f, 9.22897011e-02f,
  6.53602630e-02f, 2.91040307e-03f, 1.72716409e-01f, 5.59525145e-03f, -3.57972607e-02f, 7.15958104e-02f, 6.87473267e-02f, -7.08249137e-02f, 5.04820459e-02f, -1.34970143e-01f,
  -9.88938212e-02f, 9.54045430e-02f, -5.12242541e-02f, -6.75427821e-03f, -6.67075301e-03f, 6.55858070e-02f, 4.04417068e-02f, 4.72284062e-03f, 8.37405846e-02f, -8.33897889e-02f,
  -2.97896210e-02f, -1.47792727e-01f, -4.87814136e-02f, 2.52892468e-02f, 7.87362605e-02f, -5.00964336e-02f, -1.07723117e-01f, -6.32482544e-02f, -1.09660558e-01f, -7.92016014e-02f,
  -5.34072928e-02f, -5.52248843e-02f, 8.10374841e-02f, -2.62474688e-03f, 3.27927731e-02f, -5.21669202e-02f, -3.50385644e-02f, 3.90461758e-02f, 7.73141161e-02f, -1.65503414e-03f,
  8.75195116e-02f, -3.52660045e-02f, 2.31724480e-04f, 8.40119943e-02f, -5.17170876e-02f, 3.75668220e-02f, -4.63389009e-02f, -5.36631048e-02f, -5.00080958e-02f, 3.96720208e-02f,
  4.42779101e-02f, 9.16040838e-02f, 1.38648823e-02f, 7.31925964e-02f, -6.60446361e-02f, 1.09973503e-02f, 4.54188436e-02f, -4.24884148e-02f, 6.66387677e-02f, -4.71875593e-02f,
  -6.16664486e-03f, -1.16375899e-02f, -2.29020845e-02f, 4.30302732e-02f, 4.64636423e-02f, -4.65903506e-02f, 6.86920062e-02f, -6.92249537e-02f, 3.10604125e-02f, 6.81937411e-02f,
  6.69110641e-02f, -7.14795217e-02f, 5.44415899e-02f, 8.27937871e-02f, 5.02165407e-02f, -6.98971301e-02f, -7.45321140e-02f, 4.28665280e-02f, -2.26936433e-02f, 3.65778692e-02f,
  9.69115272e-03f, -1.91264357e-02f, -3.50560248e-02f, 2.11383253e-02f, 7.78604671e-02f, -5.31202070e-02f, -7.74254324e-03f, -2.42425743e-02f, 5.38804866e-02f, 8.34029093e-02f,
  2.94380505e-02f, -3.48037630e-02f, 7.34528750e-02f, 1.92678701e-02f, 4.99976464e-02f, -1.31671038e-02f, -5.35172317e-03f, -5.81265651e-02f, 7.04134405e-02f, -1.49158677e-02f,
  2.18889397e-02f, 2.86907479e-02f, -6.66074157e-02f, 8.80576298e-02f, -3.08047198e-02f, -1.36107183e-03f, 2.88836639e-02f, -2.91803703e-02f, -8.70436355e-02f, -6.50195703e-02f,
  5.97049557e-02f, 5.39880209e-02f, 1.08227767e-01f, -4.98081110e-02f, 2.30318420e-02f, -1.17750876e-02f, 2.12923624e-02f, 7.85779133e-02f, 5.81591018e-02f, -4.84779142e-02f,
  -6.21939152e-02f, 9.80728418e-02f, 1.00398287e-01f, 8.40038285e-02f, -2.69890651e-02f, -1.59357652e-01f, -1.14663847e-01f, -3.31969485e-02f, -1.68526394e-03f, -7.06115291e-02f,
  3.66413891e-02f, -5.76047339e-02f, -2.80828471e-03f, 5.36418818e-02f, -9.07828510e-02f, -1.03317447e-01f, -1.47025272e-01f, -9.25833285e-02f, 6.79440722e-02f, 6.71958327e-02f,
  -4.19781432e-02f, 2.95902183e-03f, 4.68926616e-02f, 9.56120491e-02f, -4.60503437e-03f, 1.54278234e-01f, -2.59215124e-02f, -3.99142914e-02f, -1.32368924e-02f, 1.98644865e-02f,
  -8.79265144e-02f, 6.68634325e-02f, -1.02024034e-01f, -9.46073607e-02f, -4.58251759e-02f, -4.10414673e-03f, -4.81423922e-02f, -6.41197339e-02f, 4.84810658e-02f, -6.59983903e-02f,
  -1.00423478e-01f, -7.93349296e-02f, 9.42299590e-02f, 4.09803130e-02f, 7.10105300e-02f, -5.88916913e-02f, 4.95615751e-02f, -6.15743436e-02f, 2.52927523e-02f, 3.98954451e-02f,
  1.95835251e-02f, -5.36033250e-02f, -1.39613841e-02f, -2.23861188e-02f, 4.83288355e-02f, -2.01114938e-02f, 2.37588882e-02f, 1.61671021e-03f, -4.83111888e-02f, -2.59921663e-02f,
  5.47701195e-02f, -5.07827476e-02f, 7.20810369e-02f, 6.03540763e-02f, -8.99430085e-03f, -6.44705743e-02f, -3.40427272e-02f, 6.17702231e-02f, -8.49478170e-02f, -4.66680378e-02f,
  -1.09881070e-02f, -2.37053130e-02f, 8.82644206e-02f, -4.13420461e-02f, 1.02109641e-01f, 7.43766055e-02f, -5.10388464e-02f, -5.42376824e-02f, 2.43536662e-02f, 4.85245064e-02f,
  6.65162578e-02f, -1.04082398e-01f, -1.72335971e-02f, -2.25556996e-02f, 2.37896200e-02f, 3.88064347e-02f, -7.02892467e-02f, -6.29723147e-02f, -6.00157566e-02f, 6.51958138e-02f,
  -1.15480579e-01f, -2.36733700e-03f, 5.83281815e-02f, -1.16347611e-01f, -2.40365993e-02f, 3.18788886e-02f, 6.19938085e-03f, -9.07930825e-03f, 3.97551712e-03f, -4.09326367e-02f,
  -8.04416165e-02f, 3.40465941e-02f, -6.28990307e-02f, 6.19860329e-02f, 1.31644052e-03f, 4.34875861e-02f, 6.19082712e-02f, 4.35457751e-02f, -3.33357006e-02f, -4.87151630e-02f,
  7.63362050e-02f, 2.39787959e-02f, -8.36716369e-02f, -5.12120686e-02f, 3.11420895e-02f, -5.00385612e-02f, 1.12412858e-03f, 6.88024238e-02f, -7.52469823e-02f, -7.21540377e-02f,
  -7.70860016e-02f, 1.00164726e-01f, 5.31070009e-02f, -1.19568408e-02f, 4.01438512e-02f, 4.79902625e-02f, 7.55479261e-02f, 9.11110789e-02f, 1.04390077e-01f, 2.14964356e-02f,
  -3.83024812e-02f, 1.22323841e-01f, -2.88087260e-02f, 7.99633861e-02f, -4.59244289e-02f, -1.92549191e-02f, 5.25100976e-02f, 7.04087317e-02f, 8.33664089e-02f, 5.98615408e-02f,
  1.19805587e-02f, 2.34899223e-02f, -3.15255895e-02f, -2.57763024e-02f, -5.99582456e-02f, 5.94669171e-02f, -7.76685253e-02f, 2.15539150e-02f, -4.13963944e-02f, 1.77907590e-02f,
  -6.51627257e-02f, -2.60722409e-05f, -4.72909659e-02f, 5.19955717e-02f, 4.88322414e-02f, 8.15744326e-03f, -7.16416463e-02f, -3.26379873e-02f, 7.40921497e-03f, -5.61679304e-02f,
  4.10468541e-02f, -7.56121799e-02f, 1.73178203e-02f, -9.13872346e-02f, -5.74959144e-02f, 5.50632179e-02f, 4.82067093e-03f, 5.02504818e-02f, -3.33255380e-02f, -9.70793739e-02f,
  -1.96951930e-03f, 3.44930636e-03f, -1.91613678e-02f, -5.84159233e-02f, -7.04948008e-02f, 8.04198161e-02f, -9.64141544e-03f, -8.87294933e-02f, 9.08962544e-03f, -4.93294373e-02f,
  7.05973729e-02f, -4.34304327e-02f, 3.47752348e-02f, 1.30239651e-02f, 4.79837768e-02f, 9.87214316e-03f, -4.60636429e-03f, -3.21096294e-02f, 5.93997575e-02f, -4.40198593e-02f,
  6.42108545e-02f, -1.16474787e-02f, -6.53438969e-03f, 5.26489038e-03f, -3.79689373e-02f, -5.50745651e-02f, -4.72824574e-02f, 6.33677617e-02f, 7.63328969e-02f, -1.85757373e-02f,
  -6.68452606e-02f, -7.11896736e-03f, -3.38561349e-02f, 1.04923779e-02f, 7.61173740e-02f, 3.13913301e-02f, 3.37701477e-02f, -6.15089014e-02f, -7.79719204e-02f, 5.86033650e-02f,
  2.69264132e-02f, 1.06544174e-01f, -4.46662679e-02f, 1.32348249e-02f, 9.90312081e-03f, 3.98854502e-02f, 2.64415052e-02f, 5.15932292e-02f, 7.09730834e-02f, -4.99478355e-02f,
  6.54985905e-02f, -3.11858431e-02f, -9.44945067e-02f, -6.02033623e-02f, 1.50390742e-02f, 8.09173509e-02f, 7.55475834e-02f, -6.18100837e-02f, -2.71729399e-02f, -3.74655724e-02f,
  -4.07099631e-03f, 7.88315833e-02f, -5.89211918e-02f, 4.58296239e-02f, -5.28431945e-02f, -6.25863746e-02f, 9.27891806e-02f, -7.89064839e-02f, 6.68233633e-02f, 4.91703823e-02f,
  7.22291172e-02f, -8.32749009e-02f, -1.63657829e-01f, -7.77967274e-02f, -5.35995550e-02f, -8.08226243e-02f, -1.76497951e-01f, -4.28467691e-02f, 2.75202021e-02f, -9.51070860e-02f,
  -3.88055458e-03f, 1.18769467e-01f, 5.02716228e-02f, -1.94787532e-01f, 1.62046194e-01f, 1.88136861e-01f, 1.12989955e-02f, -4.24335599e-02f, 3.06656007e-02f, -9.92872193e-02f,
  -1.15786018e-02f, -1.40603617e-01f, -4.74805897e-03f, -1.60834223e-01f, -1.96526945e-01f, -6.51779622e-02f, -5.59664778e-02f, -6.92503080e-02f, -1.84345692e-01f, 3.00616603e-02f,
  2.51388252e-02f, -2.05573905e-02f, -9.27989408e-02f, 6.56386390e-02f, -6.58069458e-03f, -6.83854446e-02f, 6.21299669e-02f, 9.06366855e-02f, -6.41567484e-02f, -6.04748018e-02f,
  4.26334925e-02f, -6.57633096e-02f, -7.42906407e-02f, 1.00204468e-01f, -3.34634036e-02f, 2.42867488e-02f, 5.63771091e-02f, 2.31357999e-02f, -8.74278545e-02f, 6.06107712e-02f,
  2.45219888e-03f, 4.11093645e-02f, -6.33536130e-02f, 6.53463155e-02f, -6.23019896e-02f, 2.51305234e-02f, -1.14958454e-02f, 4.78896126e-02f, 3.18448767e-02f, -5.62778190e-02f,
  2.10610889e-02f, 7.24786669e-02f, 1.61773097e-02f, 5.39374240e-02f, 1.05050713e-01f, 1.12297675e-02f, 6.29439717e-03f, 5.46201039e-03f, 7.52816275e-02f, -1.10224165e-01f,
  -3.92477401e-02f, -2.15618256e-02f, -7.19746053e-02f, 6.27792999e-02f, -1.03986368e-01f, 6.48841113e-02f, 6.75558746e-02f, 4.77336161e-02f, -7.56260157e-02f, -9.52810794e-03f,
  6.41325936e-02f, 2.23584082e-02f, 2.38036346e-02f, 3.77384126e-02f, 5.63092250e-03f, -4.27452885e-02f, -7.88604617e-02f, 3.04839034e-02f, -5.76325553e-03f, 3.58502753e-02f,
  -4.11967821e-02f, -4.68351617e-02f, -2.00480688e-02f, -4.23809066e-02f, 4.82004583e-02f, -1.53022977e-02f, -7.76794255e-02f, -8.92479718e-02f, -5.34376455e-03f, -2.43229289e-02f,
  -7.13282600e-02f, -5.23198349e-03f, -4.90537398e-02f, -3.04785501e-02f, 8.37485120e-02f, -4.42061573e-03f, -5.71465679e-02f, 7.69312605e-02f, 4.65137288e-02f, 9.52161849e-03f,
  -7.24822357e-02f, 8.73146877e-02f, -4.78611607e-03f, -3.69289182e-02f, 3.17533985e-02f, -4.46579456e-02f, 7.55564496e-02f, 4.43709530e-02f, -3.88963297e-02f, -4.37430218e-02f,
  2.06208229e-01f, -8.95101130e-02f, 5.39877117e-02f, 4.30225357e-02f, 1.47183016e-01f, 1.52216077e-01f, 7.20128864e-02f, 6.55153319e-02f, 1.43222362e-01f, -1.04716443e-01f,
  -5.50855435e-02f, -5.46832243e-03f, -8.48141760e-02f, -2.81408746e-02f, 1.61522001e-01f, -6.46101087e-02f, 1.65757351e-02f, -9.93290842e-02f, 1.50487935e-02f, -6.09526075e-02f,
  1.15083687e-01f, -2.81567313e-02f, 6.06451835e-03f, -1.32675067e-01f, -4.19604443e-02f, -4.54501733e-02f, -7.96874927e-04f, 2.40798034e-02f, -4.62314822e-02f, 5.52768931e-02f,
  2.69832555e-02f, 5.09920605e-02f, -7.10627139e-02f, -2.49053016e-02f, -2.90877260e-02f, -2.74574514e-02f, 4.50252295e-02f, -1.90019161e-02f, 1.11208044e-01f, 8.46580416e-03f,
  -6.72252029e-02f, 4.16844003e-02f, -1.99743528e-02f, 1.00903817e-01f, -6.14698529e-02f, -1.56111708e-02f, -2.83518387e-03f, 3.74371819e-02f, -2.51064152e-02f, 2.02922197e-03f,
  -7.48879015e-02f, -1.17470464e-02f, -8.59731361e-02f, -7.96623603e-02f, -8.38337168e-02f, -1.66402999e-02f, 2.68698949e-02f, -5.96331768e-02f, -7.80084580e-02f, -4.16316837e-02f,
  5.23922266e-03f, -1.88436937e-02f, -1.78294294e-02f, 7.51604736e-02f, 5.08064181e-02f, 5.82452528e-02f, -4.97676469e-02f, 5.72670065e-02f, -4.75640260e-02f, 2.16139760e-02f,
  -3.33807580e-02f, -3.98853458e-02f, -3.22459615e-03f, 2.31961366e-02f, 9.25644953e-03f, -8.23395476e-02f, -3.31945904e-02f, -9.34893936e-02f, -2.68902676e-03f, 8.02659839e-02f,
  -3.86850350e-02f, 4.08705920e-02f, -5.09754755e-02f, -2.59637972e-03f, 5.00785233e-03f, -2.82087401e-02f, -8.73768777e-02f, 2.03255154e-02f, 5.24894707e-02f, -3.94185446e-02f,
  -6.14141151e-02f, -8.13275650e-02f, 2.37237420e-02f, 2.41813883e-02f, 2.73136683e-02f, 7.44914934e-02f, -7.90863484e-02f, 6.03948049e-02f, 2.42165457e-02f, -7.28443190e-02f,
  -3.65697369e-02f, 5.40033691e-02f, 5.10259010e-02f, 1.01965778e-01f, -1.11816041e-02f, -7.27561787e-02f, -1.53952418e-02f, -3.28238234e-02f, 4.74203229e-02f, -7.63950199e-02f,
  -4.63076755e-02f, 6.10549338e-02f, -4.56808694e-02f, 2.67750435e-02f, -7.72494003e-02f, 2.51589864e-02f, 2.23525669e-02f, 4.49725874e-02f, -4.69869412e-02f, 3.90853137e-02f,
  -3.31943870e-01f, 2.46125549e-01f, 1.96743816e-01f, 1.51224151e-01f, -3.45292613e-02f, -1.87371269e-01f, -1.79080531e-01f, 1.33478820e-01f, -1.63317025e-01f, -1.31108835e-01f,
  2.94065550e-02f, -1.43355429e-01f, 4.65492457e-02f, 7.21881315e-02f, 7.44800866e-02f, 2.20309664e-02f, 1.33831382e-01f, -7.36175627e-02f, 1.47140762e-02f, 1.54613048e-01f,
  6.25686571e-02f, 8.96357074e-02f, 1.83667839e-01f, 1.16480380e-01f, -2.71547288e-02f, 7.63058364e-02f, 1.85305282e-01f, 5.05794995e-02f, 1.14683576e-01f, -6.69919476e-02f,
  -1.03631049e-01f, 2.37972513e-02f, 2.91042887e-02f, -1.21278957e-01f, -2.45579649e-02f, -3.79374065e-02f, 3.88274267e-02f, -6.86568767e-02f, 9.62260664e-02f, -3.76091339e-02f,
  -1.71209816e-02f, 1.45756174e-02f, 1.92505289e-02f, -5.24520352e-02f, -7.94061199e-02f, 2.07665935e-02f, -2.65898332e-02f, 1.55621711e-02f, 3.79063189e-02f, -6.56099916e-02f,
  1.05802320e-01f, 8.65278021e-02f, 4.34421040e-02f, -1.28901735e-01f, 1.45787336e-02f, -7.56069571e-02f, -8.49654339e-03f, -2.77090427e-02f, 8.00705981e-03f, -2.20217463e-02f,
  -9.81912240e-02f, -5.40305562e-02f, -2.49206740e-02f, -9.03986301e-03f, -5.59750944e-02f, -2.48507131e-02f, -4.97961231e-02f, 3.03929374e-02f, -2.87758149e-02f, 4.62031811e-02f,
  -1.05787158e-01f, 8.54044706e-02f, -5.62997758e-02f, -1.87451616e-02f, -1.03011392e-02f, -6.85519204e-02f, 3.19554880e-02f, -4.27858569e-02f, -1.07729400e-03f, -3.22040319e-02f,
  -5.80461361e-02f, -7.87448138e-03f, -4.35509458e-02f, 1.07100152e-03f, 4.39710468e-02f, 1.96530763e-03f, -2.70430744e-02f, 1.36985825e-02f, 7.08905831e-02f, 4.36416566e-02f,
  -1.94553919e-02f, 1.42233744e-01f, -3.41291018e-02f, -4.46058735e-02f, -1.30630229e-02f, 1.35926548e-02f, -2.80368910e-03f, -4.57140841e-02f, -1.42262941e-02f, 8.31334293e-02f,
  -7.76960179e-02f, 3.42953168e-02f, 5.78523576e-02f, 1.52918138e-02f, 3.68508808e-02f, -1.65665394e-03f, 2.33655404e-02f, -4.63006534e-02f, 3.24688479e-02f, -2.38143038e-02f,
  -8.35593510e-03f, -4.67787273e-02f, -2.21981741e-02f, -3.43921641e-03f, -1.00811481e-01f, -6.04720227e-02f, -1.41731771e-02f, 3.47667933e-02f, 1.77323783e-03f, -2.86208298e-02f,
  -8.95779580e-02f, -9.41457078e-02f, 5.23258448e-02f, 6.17457889e-02f, -2.78377943e-02f, -3.10962517e-02f, 6.96155280e-02f, 1.14791647e-01f, 2.00832617e-02f, -5.79506345e-02f,
  -6.86047152e-02f, -1.06879324e-01f, 6.10175157e-05f, 1.20510690e-01f, 2.94799376e-02f, 4.09600846e-02f, 4.40525860e-02f, 2.59133205e-02f, 8.76365155e-02f, -3.65337846e-03f,
  2.45765280e-02f, 6.49784207e-02f, 6.60169730e-03f, 9.23681781e-02f, 3.62202115e-02f, 1.09061949e-01f, -4.28511156e-03f, 7.59727135e-02f, 1.73645671e-02f, 1.22586504e-01f,
  1.50433900e-02f, -9.55025256e-02f, 1.22677041e-02f, 8.93485099e-02f, 8.44115913e-02f, -6.12308420e-02f, -5.79640828e-02f, -3.54372114e-02f, 5.58033809e-02f, 1.98431928e-02f,
  4.66406085e-02f, 5.50487787e-02f, 5.34209348e-02f, 4.68915626e-02f, 8.73651430e-02f, -6.18400276e-02f, -3.29831056e-02f, -2.12328359e-02f, -6.30269051e-02f, -3.63254920e-02f,
  -6.45671487e-02f, -9.86951143e-02f, -7.22565055e-02f, 4.71317358e-02f, 4.50910702e-02f, 8.27026144e-02f, 1.67184304e-02f, 2.87775528e-02f, -7.35554472e-02f, 9.26974863e-02f,
  -7.24385455e-02f, -6.22357354e-02f, 3.09028085e-02f, -1.46597782e-02f, 8.00552741e-02f, 4.42466512e-02f, -5.12447804e-02f, 6.01738356e-02f, -3.87950093e-02f, 3.71693000e-02f,
  1.65715232e-03f, -8.48065540e-02f, 4.01292518e-02f, -2.73350859e-03f, 5.41532822e-02f, 5.27057499e-02f, 1.36425067e-02f, 9.09154639e-02f, 7.25110546e-02f, 5.71864210e-02f,
  -7.03423889e-03f, 5.06344363e-02f, -9.05719548e-02f, -1.71537995e-02f, -6.89679161e-02f, -3.30160931e-02f, 4.65712398e-02f, 1.73049001e-03f, 7.09656393e-03f, -4.31658626e-02f,
  -1.24324277e-01f, -7.07982481e-02f, 9.47360545e-02f, -6.49503991e-02f, -6.40280098e-02f, 2.06181202e-02f, -2.18866020e-03f, 6.46369979e-02f, -8.06144252e-02f, -1.96454115e-02f,
  -7.84379542e-02f, 5.03699668e-02f, 3.55386622e-02f, -3.41934375e-02f, -6.82293698e-02f, 6.87265769e-02f, 1.68022271e-02f, 5.20932302e-02f, -3.80967115e-03f, 9.65232588e-03f,
  7.68360570e-02f, 6.25647081e-04f, 7.18087703e-02f, 1.00828137e-03f, -3.97098176e-02f, -8.78567323e-02f, -4.78725024e-02f, -6.80899546e-02f, -8.31850395e-02f, 2.45374385e-02f,
  1.98299825e-01f, -3.60898614e-01f, 6.61674887e-02f, 1.43597260e-01f, 2.22383127e-01f, 1.29016325e-01f, 3.22140872e-01f, -1.37430161e-01f, 2.39902735e-02f, -2.39324361e-01f,
  9.49930176e-02f, 4.47456092e-02f, 1.91559643e-02f, -1.37412429e-01f, 2.51020581e-01f, -5.39709404e-02f, -6.99986070e-02f, -6.02487400e-02f, 2.35292464e-02f, 7.34914420e-03f,
  5.94830513e-02f, 1.44957490e-02f, 1.22756436e-02f, -1.59440309e-01f, 8.42926800e-02f, 1.89770814e-02f, 3.23794261e-02f, 9.56502631e-02f, -2.65891422e-02f, 4.59735747e-03f,
  -5.74092679e-02f, -2.71095918e-03f, 2.29075775e-02f, -1.00221708e-01f, -7.64216557e-02f, -9.29732472e-02f, -3.08140391e-03f, 1.18802208e-02f, 7.06171803e-03f, -2.21627741e-03f,
  -3.59482504e-02f, 5.80634251e-02f, -3.51752937e-02f, -3.44679318e-02f, 1.40378149e-02f, 2.57885978e-02f, -2.95477849e-03f, -1.51488883e-02f, 2.91517616e-04f, -1.04998676e-02f,
  5.70068061e-02f, -4.78264019e-02f, -1.35659678e-02f, -1.47224520e-04f, 2.78511513e-02f, -1.46824047e-02f, 5.45931011e-02f, 1.60174593e-02f, -6.19722120e-02f, -4.64919396e-02f,
  -3.83697189e-02f, 1.18915970e-02f, 1.50315659e-02f, 5.69936708e-02f, 4.29635383e-02f, 1.05460836e-02f, 2.79657934e-02f, 7.49459770e-03f, -1.68704167e-02f, -3.17803444e-03f,
  7.30353072e-02f, -4.48471531e-02f, -8.72638170e-03f, 3.01315822e-02f, 4.71048877e-02f, -3.88248973e-02f, 5.18684573e-02f, -4.43699770e-03f, 1.57467334e-03f, -4.39422131e-02f,
  4.09608223e-02f, 7.05492496e-02f, -8.64578709e-02f, -8.79168697e-03f, 2.16619540e-02f, -6.35811884e-04f, -5.55467308e-02f, -2.90483031e-02f, -6.56066556e-03f, 7.24146143e-02f,
  -1.96722835e-01f, -2.39008799e-01f, -2.25346368e-02f, 2.08256301e-02f, -3.27430554e-02f, -7.06916675e-02f, -2.57337485e-02f, -6.90816641e-02f, 3.20033953e-02f, 7.17734322e-02f,
  -5.14274761e-02f, 4.19707038e-02f, 3.98330390e-02f, -2.68115420e-02f, -8.41784701e-02f, 4.16540615e-02f, 8.55802745e-02f, -9.59715322e-02f, 4.12560180e-02f, -8.81391987e-02f,
  -6.64333031e-02f, -1.01390453e-02f, -1.31539558e-03f, -4.18118834e-02f, -1.86499581e-02f, -2.22182944e-02f, 4.40523103e-02f, -2.02077031e-02f, 4.43680324e-02f, -7.69126136e-03f,
  -2.31427014e-01f, -1.84985790e-02f, -1.27341390e-01f, 1.27483666e-01f, -1.57453239e-01f, 4.02771644e-02f, 1.60469506e-02f, -1.04746982e-01f, -1.88176349e-01f, -5.87839633e-03f,
  7.86433220e-02f, -8.54182392e-02f, 8.75577517e-03f, 2.40107447e-01f, 6.35939911e-02f, 1.76818728e-01f, 5.71487769e-02f, 1.47191912e-01f, 5.99992946e-02f, -2.28073171e-04f,
  4.03016210e-02f, 1.05134122e-01f, 1.50931627e-01f, 9.72147211e-02f, 5.49728833e-02f, -4.17589769e-02f, 9.82446447e-02f, -7.16627836e-02f, 6.09601066e-02f, 7.22550787e-03f,
  -1.85875949e-02f, -1.16679676e-01f, -1.60161941e-03f, -1.35155469e-01f, -1.78215024e-03f, -1.36330193e-02f, -1.56525262e-02f, -1.49106570e-02f, -6.50618374e-02f, -9.87660214e-02f,
  6.98412023e-03f, 4.37330194e-02f, 4.20430936e-02f, 7.36960918e-02f, -8.37588087e-02f, 8.98522977e-03f, -1.58715842e-03f, -3.96962427e-02f, 5.74122444e-02f, 7.49188801e-03f,
  6.51462525e-02f, -3.84549312e-02f, -4.59244363e-02f, 1.26221046e-01f, 4.81499620e-02f, 1.60263572e-02f, 5.01943901e-02f, -4.42522252e-03f, -1.08825497e-01f, 1.38130169e-02f,
  3.25923488e-02f, 7.10181072e-02f, 7.48168156e-02f, 1.89595725e-02f, -1.50999092e-02f, -2.79328935e-02f, 1.56528428e-02f, -4.49915091e-03f, -6.49824440e-02f, 1.53183201e-02f,
  2.42388062e-03f, -1.10072494e-02f, -1.96667351e-02f, 2.28281622e-03f, -3.70483398e-02f, -8.75180308e-03f, -5.39839007e-02f, -3.02758981e-02f, 4.60332679e-03f, 2.84573939e-02f,
  6.43381625e-02f, -9.14923381e-03f, -4.30307984e-02f, 8.20061285e-03f, 3.27360933e-03f, 3.80970500e-02f, -7.41755441e-02f, -1.08264387e-01f, -4.94341329e-02f, 4.75172885e-02f,
  -1.85931325e-01f, -1.37681574e-01f, -1.29507333e-02f, -1.15097910e-01f, -4.60401326e-02f, -1.25953443e-02f, 2.42430605e-02f, -2.87086666e-02f, -4.29861508e-02f, -2.62122639e-02f,
  -9.00360048e-02f, 6.29291907e-02f, -4.39441428e-02f, -4.64759022e-02f, 9.28936377e-02f, 5.40175177e-02f, -1.78185781e-03f, -8.28250274e-02f, 3.13520245e-02f, 1.98009741e-02f,
  -9.19327699e-03f, -5.89547418e-02f, 9.94288698e-02f, 4.14692983e-02f, 7.26725012e-02f, -2.28815880e-02f, 4.06933133e-04f, 7.13007972e-02f, 2.91925091e-02f, 5.90016358e-02f,
  2.16205060e-01f, -2.22504556e-01f, -6.57212883e-02f, 4.89265040e-05f, 7.06176311e-02f, 1.07098579e-01f, 2.91720815e-02f, -8.92811194e-02f, -1.24841399e-01f, -1.23760112e-01f,
  5.08776158e-02f, -2.70316787e-02f, -3.72750275e-02f, 9.45417434e-02f, 1.59877390e-01f, -1.04231246e-01f, 4.90381494e-02f, -7.40849972e-03f, -1.46111678e-02f, -6.06759684e-03f,
  7.50589836e-03f, 1.12268701e-01f, -4.37966101e-02f, 2.02038381e-02f, 3.58320288e-02f, 3.72454450e-02f, 7.24535212e-02f, -4.09304947e-02f, 3.98433506e-02f, 7.20967129e-02f,
  4.55203839e-02f, -1.71521641e-02f, -1.95681341e-02f, -5.81111014e-02f, 1.51200471e-02f, 7.77053982e-02f, 3.44076753e-02f, 1.05937466e-01f, -5.68244653e-03f, -1.61662966e-01f,
  -6.43884242e-02f, -6.38002902e-02f, -6.90822303e-02f, 4.15628329e-02f, 9.17633437e-03f, -7.30126277e-02f, -1.00279339e-01f, 5.93308285e-02f, 3.10575888e-02f, -8.33960921e-02f,
  -1.87766831e-02f, -9.55029801e-02f, -3.18390094e-02f, -4.39874083e-03f, -1.70657765e-02f, 1.63966697e-02f, -7.68900141e-02f, -4.18362468e-02f, -7.43502926e-04f, -5.54328449e-02f,
  1.57007445e-02f, 1.14858598e-01f, 1.06776636e-02f, 1.24929671e-03f, -3.65161500e-03f, -3.66822816e-02f, 8.29526111e-02f, -3.37269492e-02f, 6.68634325e-02f, -8.46425518e-02f,
  3.71719263e-02f, -3.26089337e-02f, 7.20401779e-02f, -2.53039245e-02f, 1.30831022e-02f, 2.12188791e-02f, 3.30557898e-02f, 2.11106241e-02f, -4.04160470e-02f, 3.15456092e-02f,
  6.72098175e-02f, 6.12702370e-02f, -6.80250451e-02f, 1.03535183e-01f, 9.22887307e-03f, 2.22624354e-02f, -3.23346294e-02f, -1.07014276e-01f, -1.79408602e-02f, -2.74950005e-02f,
  3.72997373e-02f, -1.01639457e-01f, -1.01193517e-01f, 6.84453547e-02f, 6.40014559e-02f, 6.79195747e-02f, 1.02835977e-02f, -8.11330751e-02f, -4.88416962e-02f, 9.92210931e-04f,
  1.25255585e-02f, -2.99590528e-02f, -1.43932262e-02f, -3.55649255e-02f, -2.03084797e-02f, 5.01766726e-02f, -4.42017317e-02f, -9.04505476e-02f, -7.01177642e-02f, -9.73274093e-03f,
  -4.01093885e-02f, -1.33702606e-01f, -2.09776759e-02f, 4.13556881e-02f, 6.67212382e-02f, -3.90412216e-03f, -2.23649777e-02f, -4.69975471e-02f, 3.40224430e-02f, -8.63539279e-02f,
  1.61016792e-01f, 2.48311497e-02f, 7.49412253e-02f, 2.01771148e-02f, 7.64703825e-02f, -1.01683684e-01f, 4.34997194e-02f, -5.66625185e-02f, 1.24796078e-01f, -1.12716347e-01f,
  -1.05715916e-03f, 1.47288740e-01f, -1.49970010e-01f, 6.23814836e-02f, 8.78127641e-04f, -1.12605961e-02f, -6.50806502e-02f, 8.83098170e-02f, -1.19219907e-02f, -3.25102843e-02f,
  5.88717200e-02f, -9.70402956e-02f, -5.40539771e-02f, -9.32590887e-02f, -2.19629724e-02f, 2.62801703e-02f, -1.52085572e-01f, -9.93555188e-02f, -4.31428030e-02f, 7.66408723e-03f,
  -3.98175120e-02f, 5.93998693e-02f, 5.02905548e-02f, -9.77978203e-03f, 4.71279211e-02f, 3.20966579e-02f, -2.26240382e-02f, 4.92900535e-02f, 1.38292223e-01f, -6.98752329e-02f,
  5.32568544e-02f, -5.80327474e-02f, 2.27541197e-02f, -8.11938569e-02f, 3.00327018e-02f, 5.50354049e-02f, 8.92151222e-02f, 9.36460644e-02f, 1.27870470e-01f, 5.11749722e-02f,
  -1.38183869e-02f, -6.45845849e-03f, 3.88199054e-02f, -8.09423253e-02f, 2.71940301e-03f, 2.79954057e-02f, -6.99722841e-02f, 2.17537060e-02f, -3.08958348e-02f, 6.58022240e-02f,
  -2.66344603e-02f, 1.76756065e-02f, -6.07965253e-02f, -8.30091387e-02f, -2.28694621e-02f, 7.18770102e-02f, -4.02727863e-03f, -8.26111734e-02f, 4.02647220e-02f, 5.13953716e-02f,
  8.83190054e-03f, 6.61012307e-02f, -3.87109263e-04f, -8.60473886e-02f, -4.92660962e-02f, 4.69907261e-02f, 1.74169485e-02f, -6.63433075e-02f, 6.51068985e-02f, -3.79833765e-02f,
  3.44539583e-02f, -2.96367202e-02f, -4.73184325e-02f, 9.31019709e-03f, 2.79077198e-02f, -1.40735749e-02f, -9.23843682e-02f, 7.19764531e-02f, -2.08566096e-02f, 4.52058762e-02f,
  -2.72514839e-02f, 4.26390022e-03f, -6.68910071e-02f, -8.86595249e-03f, -1.77941564e-02f, -5.46416175e-03f, 2.47072857e-02f, -5.18835932e-02f, 6.71968330e-03f, -3.10653020e-02f,
  -2.41928287e-02f, 9.49080810e-02f, -6.32651225e-02f, 2.83965394e-02f, 2.80596185e-02f, -3.77604924e-02f, -4.77430075e-02f, 1.82218645e-02f, -2.18963679e-02f, 7.79127181e-02f,
  3.28099653e-02f, 3.88590060e-02f, 6.29288098e-03f, 8.25577378e-02f, 1.46044632e-02f, -5.69247641e-02f, -6.43740445e-02f, 9.56856459e-03f, -3.55818421e-02f, -1.49890536e-03f,
  2.42905691e-01f, -1.99771658e-01f, -1.23878859e-01f, 6.63423911e-02f, 1.30997136e-01f, 2.88098902e-02f, 3.02880686e-02f, 2.39829663e-02f, 1.29136488e-01f, -1.20442308e-01f,
  -1.03504688e-01f, -1.17448658e-01f, -7.84927886e-03f, 2.42901295e-02f, 1.43298015e-01f, 8.75323415e-02f, 5.71609195e-03f, -1.88829675e-02f, 4.36393581e-02f, -6.47552684e-02f,
  4.24284376e-02f, -1.07781634e-01f, -6.18615709e-02f, -1.07919954e-01f, -1.64030008e-02f, 2.97883339e-02f, -9.40928608e-02f, -9.03659984e-02f, -2.68125683e-02f, 3.91598009e-02f,
  9.71718505e-02f, 4.78374101e-02f, 2.65333802e-02f, 4.97746188e-03f, -4.32741679e-02f, -7.31615722e-02f, -1.12417206e-01f, 3.68840657e-02f, 1.02386184e-01f, -8.58327001e-03f,
  -7.32720047e-02f, -4.37586904e-02f, -6.58101439e-02f, 6.78775948e-04f, -2.10483428e-02f, -1.26497447e-02f, -9.47580561e-02f, -7.33975098e-02f, -1.00279823e-01f, -8.51357952e-02f,
  -6.17105663e-02f, -3.65405232e-02f, -2.31913403e-02f, 7.64983660e-03f, -6.03584275e-02f, 3.04297693e-02f, -1.15070231e-01f, 3.17731872e-02f, -6.86863214e-02f, 7.34020099e-02f,
  1.25903254e-02f, 7.11210072e-02f, -2.73390170e-02f, -1.44060785e-02f, 4.35612872e-02f, -3.69543806e-02f, 5.26695102e-02f, 2.51776427e-02f, -6.10737018e-02f, 3.40543985e-02f,
  -6.71859756e-02f, 9.02555361e-02f, -1.54074114e-02f, 3.16558927e-02f, -1.97710060e-02f, 7.97125548e-02f, 1.00293890e-01f, -1.24008115e-02f, -3.63344215e-02f, -1.37070855e-02f,
  -3.50449458e-02f, -5.27446307e-02f, -4.16846387e-02f, -5.11890352e-02f, -7.51062110e-02f, -3.46643478e-02f, 7.95603842e-02f, -2.54734866e-02f, 9.15819257e-02f, -6.45674989e-02f,
  6.03490435e-02f, -4.48103109e-03f, -8.94964188e-02f, -3.49126458e-02f, -8.17544162e-02f, -5.71914017e-02f, -5.16689196e-02f, -1.83056854e-02f, -5.55168577e-02f, -5.39284274e-02f,
  2.68324614e-02f, 4.49593663e-02f, -4.75882962e-02f, -6.75087124e-02f, 3.25446129e-02f, 7.51355290e-02f, -4.76354323e-02f, 5.84513582e-02f, -8.32667127e-02f, 2.17188470e-04f,
  -6.33451119e-02f, -4.49753180e-02f, 4.53000441e-02f, -4.66356575e-02f, -9.94654447e-02f, 6.95698801e-03f, 4.95346710e-02f, -3.15105245e-02f, -1.19859107e-01f, 2.32674424e-02f,
  -1.92131866e-02f, 8.21958184e-02f, 1.86109971e-02f, -3.14344764e-02f, -4.12655547e-02f, 3.93818654e-02f, 6.51946515e-02f, 4.87128608e-02f, -3.09756529e-02f, 4.21388112e-02f,
  -9.20046642e-02f, 6.69208094e-02f, -5.55094108e-02f, 2.42044460e-02f, -5.64374700e-02f, -2.90535297e-02f, -3.31640206e-02f, -4.87219766e-02f, 7.45544657e-02f, 2.91284695e-02f,
  -5.43269329e-02f, 2.52220058e-03f, -1.51723698e-01f, -6.98921382e-02f, -5.93902282e-02f, 4.12312411e-02f, -1.03453889e-01f, 6.51249513e-02f, 3.25161442e-02f, -5.61761148e-02f,
  6.23104759e-02f, -7.49837309e-02f, 1.34609751e-02f, -5.37071936e-02f, 1.37866857e-02f, -2.73828786e-02f, -8.43148828e-02f, -3.42802554e-02f, 5.31884655e-02f, 3.93663645e-02f,
  -5.81930019e-02f, -6.02988675e-02f, -6.79999217e-02f, 4.00103629e-02f, -6.32004812e-02f, 3.67076807e-02f, -9.03960392e-02f, -6.02461249e-02f, 8.47564712e-02f, -6.11624867e-03f,
  2.35328870e-03f, 7.23088533e-02f, -4.16836292e-02f, -6.61655143e-02f, -9.95653942e-02f, 3.14281173e-02f, -5.27467288e-04f, 4.84084003e-02f, -7.63589842e-03f, -1.40408585e-02f,
  -7.88150430e-02f, 5.66746630e-02f, 8.63682106e-02f, 4.50075008e-02f, 6.60219043e-02f, -3.78402099e-02f, 4.80504371e-02f, 3.90174128e-02f, 5.30901887e-02f, -9.44655612e-02f,
  4.21710946e-02f, -8.26051682e-02f, 6.96872249e-02f, -3.95259596e-02f, 5.31505719e-02f, -4.46067043e-02f, 5.74126169e-02f, -4.61025257e-03f, 1.17556872e-02f, 1.72625724e-02f,
  -7.79306665e-02f, 4.57020476e-02f, 5.67659400e-02f, -1.78207308e-02f, -4.31790128e-02f, 4.33699694e-03f, -5.01484014e-02f, 5.34636714e-02f, -4.35057096e-02f, -7.86855817e-03f,
  9.54986811e-02f, 1.42514840e-01f, 1.17646873e-01f, 3.62667963e-02f, 8.04315954e-02f, -1.77831296e-02f, -3.62570435e-02f, 6.77516535e-02f, 6.94062114e-02f, -7.45737851e-02f,
  2.98690591e-02f, -6.33903220e-02f, -7.00054914e-02f, -3.47966030e-02f, 5.47974110e-02f, 8.17632154e-02f, 8.29411000e-02f, 5.50315753e-02f, -3.80787961e-02f, 5.80914542e-02f,
  -2.55102571e-02f, 8.02960154e-03f, 4.28406000e-02f, -4.61926237e-02f, 2.29359772e-02f, 3.77268493e-02f, -4.13209386e-03f, 4.68163230e-02f, -2.24278551e-02f, -6.35718852e-02f,
  -1.67734046e-02f, -4.14379776e-01f, 5.10212183e-02f, 1.72230437e-01f, 1.55465335e-01f, -1.30048888e-02f, -9.47792679e-02f, -9.12078917e-02f, -1.05668984e-01f, -2.55689800e-01f,
  -6.04988821e-02f, -2.25196574e-02f, -1.44723386e-01f, 1.15937792e-01f, 2.93690890e-01f, -1.34453341e-01f, 4.74164113e-02f, -9.24809128e-02f, 7.42573440e-02f, 7.31621459e-02f,
  1.63627550e-01f, 1.31886423e-01f, 2.04266235e-01f, 5.31281978e-02f, 6.69936240e-02f, 1.01118609e-02f, 4.60695587e-02f, 1.09890275e-01f, 1.24133579e-01f, 5.12029044e-02f,
  3.30298096e-02f, -8.00054744e-02f, 4.99904156e-02f, 3.60145830e-02f, -6.06228113e-02f, -3.92599553e-02f, 4.62646559e-02f, 1.51162922e-01f, 5.30114807e-02f, -1.81740262e-02f,
  -1.04514264e-04f, 6.25347495e-02f, 1.60305928e-02f, 7.05545470e-02f, 5.67513034e-02f, 9.77449119e-02f, 5.65047190e-02f, -8.72843433e-03f, -2.92214304e-02f, -7.81998783e-02f,
  -1.06778674e-01f, 6.99475855e-02f, 6.80033118e-02f, -1.59109384e-02f, 5.55560365e-03f, 1.26693659e-02f, 1.63890515e-03f, 2.04908047e-02f, 1.79394428e-02f, -7.41525367e-02f,
  -3.27853858e-02f, -2.29014233e-02f, -7.23208189e-02f, 2.94738170e-02f, -2.93496554e-03f, 3.11929286e-02f, 4.49474491e-02f, 1.65825319e-02f, -1.06336288e-02f, 2.62468141e-02f,
  -2.92577725e-02f, 6.38908613e-03f, 4.32404540e-02f, -8.18235874e-02f, -4.23454121e-02f, -3.84285338e-02f, 1.01112306e-01f, 3.23429294e-02f, -8.44357386e-02f, 2.86777541e-02f,
  -2.52266973e-02f, -1.52602755e-02f, 2.00834610e-02f, -9.65607725e-03f, 6.09769002e-02f, -1.64908636e-03f, 4.00404595e-02f, -3.27233188e-02f, 6.60608523e-03f, -1.68817975e-02f,
  -5.39172739e-02f, -2.14925900e-01f, 3.71300653e-02f, -2.99567208e-02f, -6.58812076e-02f, -2.80942135e-02f, 4.65127192e-02f, -1.36003308e-02f, 2.60688718e-02f, -7.50572383e-02f,
  -9.12634842e-03f, 1.34648353e-01f, -7.11733326e-02f, 6.77776709e-02f, 1.01757444e-01f, -5.10218367e-02f, -2.56202593e-02f, 1.15983017e-01f, 8.26944187e-02f, -7.82297738e-03f,
  7.63525218e-02f, 1.95683669e-02f, 6.78575188e-02f, 5.78480437e-02f, -7.43741989e-02f, 1.44194467e-02f, -6.37874603e-02f, -8.47619101e-02f, -2.91082319e-02f, 5.08401990e-02f,
  2.14819372e-01f, -3.21225584e-01f, -2.95540243e-01f, 5.58246523e-02f, 2.07194969e-01f, 9.41663682e-02f, -1.15496062e-01f, 2.30039820e-01f, -4.13252525e-02f, -6.22617491e-02f,
  7.99619183e-02f, -2.89304465e-01f, -2.97598004e-01f, 5.20861298e-02f, 6.69221506e-02f, -2.25518987e-01f, 1.83358520e-01f, 7.30581507e-02f, -5.53952008e-02f, -6.61534071e-02f,
  4.85459380e-02f, 2.63129145e-01f, -4.85880487e-02f, 2.00557634e-01f, 1.62339106e-01f, 7.01973662e-02f, 1.88550532e-01f, -1.81062639e-01f, 2.35681042e-01f, 9.75941122e-02f,
  2.21454129e-02f, -8.13582465e-02f, -7.20630437e-02f, 4.49558906e-03f, -9.94697120e-03f, 3.24347988e-02f, -3.15869972e-02f, -5.85495345e-02f, -2.76534748e-03f, 3.55608463e-02f,
  -3.30987088e-02f, 5.41738085e-02f, 1.08633533e-01f, 7.37705380e-02f, 3.46527360e-02f, 6.68710992e-02f, 3.35023031e-02f, -2.42010672e-02f, -3.40670208e-03f, -4.04195562e-02f,
  -1.32265970e-01f, -4.86560166e-03f, 6.46385923e-02f, -4.58068363e-02f, -2.73900460e-02f, 2.94063743e-02f, -4.33763862e-02f, -9.75224972e-02f, 5.25224581e-02f, -3.22072357e-02f,
  1.80394612e-02f, -8.38994980e-02f, 1.99347697e-02f, 9.38825607e-02f, 4.75729108e-02f, -3.11127063e-02f, 2.27021948e-02f, 1.47709474e-02f, 1.36917671e-02f, -9.75974500e-02f,
  2.54441295e-02f, -5.36599779e-04f, -8.95424746e-03f, -4.40784656e-02f, -4.20933925e-02f, -5.63249178e-03f, -3.80830802e-02f, 1.72253456e-02f, -6.45243004e-02f, 3.58797684e-02f,
  2.91661033e-03f, 2.04465948e-02f, -3.64518426e-02f, 6.20492473e-02f, 6.34693578e-02f, 1.72765721e-02f, 6.62752092e-02f, 3.63200530e-02f, -6.33263737e-02f, 9.08807814e-02f,
  -2.71485820e-02f, -9.13887694e-02f, -4.28793728e-02f, 1.23914927e-02f, -6.09795749e-02f, 4.40526893e-03f, -3.30555215e-02f, 4.35881428e-02f, -2.47312635e-02f, 4.55140732e-02f,
  1.72694307e-02f, -2.82592745e-03f, 4.16458137e-02f, 3.64505425e-02f, 5.37322983e-02f, 1.51623748e-02f, -5.24821803e-02f, -7.71209598e-03f, 1.12978125e-03f, 5.22733573e-03f,
  4.61073741e-02f, 4.93008755e-02f, -7.19383508e-02f, 9.47914179e-03f, 6.23344406e-02f, -4.42645214e-02f, 6.45346716e-02f, 2.03194935e-02f, 7.55251274e-02f, -6.35250509e-02f,
  -5.18841483e-02f, -1.80972770e-01f, 3.83260101e-02f, -1.72912795e-02f, 1.23332264e-02f, 1.07559144e-01f, 1.42233357e-01f, -4.54570837e-02f, -1.77642629e-02f, 6.70584738e-02f,
  1.09668195e-01f, -7.12304264e-02f, 7.30280504e-02f, 1.60953492e-01f, 1.43032908e-01f, -1.66261233e-02f, 1.39394552e-01f, 1.20605409e-01f, 2.52582878e-02f, -8.74717906e-02f,
  1.28981965e-02f, 3.51026058e-02f, -5.39446399e-02f, 2.29261778e-02f, 5.64012453e-02f, -2.69725304e-02f, -5.05013168e-02f, 1.69787016e-02f, 6.75397292e-02f, -3.97945382e-02f,
  -2.73222849e-02f, -2.87582185e-02f, -7.25526214e-02f, -6.02510609e-02f, -1.76185835e-02f, -6.93606064e-02f, 1.81647334e-02f, -2.25177091e-02f, -8.88245255e-02f, -9.76773724e-02f,
  1.59151312e-02f, 7.61542320e-02f, 1.97023395e-02f, -8.67414623e-02f, 4.12556119e-02f, -7.17661828e-02f, 6.71208799e-02f, -5.31185232e-02f, 6.37874976e-02f, -2.83450261e-02f,
  -2.18141135e-02f, -5.36304489e-02f, 3.35325636e-02f, -3.35394889e-02f, -3.88352722e-02f, -3.06013804e-02f, -5.26789296e-03f, -7.00125396e-02f, -3.74253951e-02f, -1.11143664e-01f,
  -7.35855326e-02f, -6.95434287e-02f, 7.05123544e-02f, 1.39149362e-02f, -1.48313623e-02f, -4.08310589e-04f, 8.87584090e-02f, -6.06217459e-02f, 5.86703792e-02f, 4.75720130e-02f,
  2.95341257e-02f, -4.74006310e-02f, 2.18896032e-03f, -8.60572159e-02f, 2.25621779e-02f, 4.93740141e-02f, 5.07608708e-03f, 5.75416982e-02f, -7.21831247e-02f, 9.12798569e-02f,
  -3.31707560e-02f, 1.59941893e-02f, -5.95987700e-02f, 2.11863536e-02f, -4.37600426e-02f, -2.33198032e-02f, -6.95456117e-02f, -5.88222444e-02f, 7.74742290e-02f, -3.65317129e-02f,
  -1.27087042e-01f, -5.31686693e-02f, 5.62211052e-02f, -2.03565806e-02f, -5.89748770e-02f, 1.59885660e-02f, 8.12658742e-02f, -3.44343670e-02f, 6.13281764e-02f, -2.25281622e-02f,
  -3.24735828e-02f, -5.42195328e-02f, 6.33742334e-03f, 3.47301848e-02f, -1.48234729e-04f, 2.00116728e-02f, 1.86713133e-02f, -2.80818995e-02f, -7.67608285e-02f, -1.04766659e-01f,
  -2.63960417e-02f, -2.06563193e-02f, 1.84559152e-02f, 2.19456349e-02f, -2.34621875e-02f, -6.00638986e-02f, -3.30281779e-02f, -2.05390677e-02f, -4.40043397e-02f, 1.89743526e-02f,
  -1.07893459e-01f, -2.16328263e-01f, 7.61892945e-02f, -1.85890973e-01f, 1.16481436e-02f, 5.64538352e-02f, 7.93417320e-02f, -2.39689872e-01f, -2.98837721e-01f, -2.96778500e-01f,
  -2.78265439e-02f, 6.41308501e-02f, 1.39654726e-01f, -2.09068120e-01f, 4.21976179e-01f, 1.33138970e-01f, -1.12624027e-01f, -2.39460804e-02f, -1.14299588e-01f, -1.32295534e-01f,
  -3.30594145e-02f, -1.43741295e-01f, 1.19397409e-01f, -1.59366533e-01f, -1.24870755e-01f, -2.12144703e-01f, 6.88017905e-02f, 1.43244013e-01f, -7.74997845e-02f, 8.00537914e-02f,
  -4.00540493e-02f, -6.65068179e-02f, -6.47479370e-02f, 1.72768775e-02f, -8.97335168e-03f, 9.44439396e-02f, -1.54320681e-02f, 1.04640543e-01f, 4.39621508e-02f, 4.86719310e-02f,
  7.27159530e-02f, 1.16886375e-02f, -3.32101174e-02f, -4.94803004e-02f, -1.04914255e-01f, -7.32032880e-02f, -1.11378059e-02f, 1.10173803e-02f, -5.24835885e-02f, -1.24687469e-02f,
  -3.13955769e-02f, 4.78919409e-02f, -3.19404006e-02f, -2.17592549e-02f, 7.57143423e-02f, -5.46053937e-03f, 3.26571204e-02f, 8.87387097e-02f, 2.78696511e-02f, -9.61646438e-02f,
  2.34901495e-02f, -2.30476279e-02f, -1.82378124e-02f, -7.20899850e-02f, -3.77298035e-02f, -7.14124963e-02f, 1.80676894e-03f, -4.99617122e-02f, 2.95722652e-02f, 3.64861684e-03f,
  -3.39370519e-02f, 6.36473224e-02f, -1.01656420e-02f, 4.21292242e-03f, 6.05121162e-03f, 1.21125262e-02f, 5.66956438e-02f, -2.18087621e-02f, -8.13629329e-02f, 8.17549508e-03f,
  -1.36117879e-02f, 1.62939485e-02f, 7.23645091e-02f, 2.38714386e-02f, -4.43007797e-02f, 7.45252371e-02f, -1.07580721e-02f, 1.04350140e-02f, 2.55113691e-02f, 5.47929741e-02f,
  -1.90613270e-01f, -1.72705010e-01f, -6.24392182e-02f, -9.37269852e-02f, -5.11190370e-02f, 2.73066945e-02f, 3.45733501e-02f, -5.17099090e-02f, -3.42089310e-02f, -3.18170190e-02f,
  -3.36798988e-02f, 2.87209060e-02f, -2.43815295e-02f, 8.67251679e-03f, 8.27672854e-02f, -5.87984882e-02f, -4.53401245e-02f, 4.09289040e-02f, 6.15200177e-02f, -3.69076654e-02f,
  -5.28987162e-02f, -1.78797189e-02f, 5.33494651e-02f, -6.11282624e-02f, 6.75589368e-02f, -3.51095982e-02f, -4.68959659e-02f, 2.03305786e-03f, 8.14356357e-02f, 6.60690814e-02f,
  -2.78964251e-01f, 8.47427994e-02f, -1.59463122e-01f, -2.61691898e-01f, 1.82541907e-01f, -7.68802315e-02f, -1.07853189e-02f, 9.43423361e-02f, -9.21147391e-02f, 1.62705749e-01f,
  4.82786708e-02f, -4.72731479e-02f, 3.33365053e-02f, -2.68219948e-01f, -4.77357000e-01f, -1.59656420e-01f, -3.31564069e-01f, -1.78213224e-01f, -9.63123366e-02f, -4.04879451e-03f,
  -2.43224010e-01f, -1.34552181e-01f, -2.87278622e-01f, 1.41215369e-01f, 2.24368051e-02f, -7.52682041e-04f, -1.73137952e-02f, 2.17271030e-01f, 1.50956940e-02f, -7.21853285e-04f,
  -2.89438870e-02f, 1.65092002e-03f, -1.04587795e-02f, 1.04638971e-02f, 9.07685701e-03f, 6.35182634e-02f, 3.97803858e-02f, 4.33361158e-02f, -4.33534160e-02f, -1.88708818e-03f,
  6.22109435e-02f, -4.93173301e-02f, 2.73014214e-02f, 2.57529356e-02f, 7.09252432e-02f, -2.45824512e-02f, 2.76001706e-03f, 5.26055619e-02f, -2.82968599e-02f, -3.27390358e-02f,
  1.19207632e-02f, 3.56062576e-02f, 2.13485826e-02f, -2.42096223e-02f, -1.05506018e-01f, 2.34101526e-02f, -5.91868795e-02f, -3.41295870e-03f, 6.49501756e-02f, -3.70786600e-02f,
  2.80539226e-02f, 5.82006872e-02f, 2.37983502e-02f, 5.91322072e-02f, 6.30618185e-02f, 1.34909432e-03f, -2.04807036e-02f, -2.60792635e-02f, 3.36769819e-02f, 4.98586660e-03f,
  -1.14780329e-02f, 3.28447931e-02f, -3.46019268e-02f, -1.40257841e-02f, -4.17363085e-02f, -6.38877973e-02f, 2.18419917e-02f, 1.06837619e-02f, -9.55184773e-02f, 5.67100607e-02f,
  3.22853550e-02f, -1.89827161e-03f, 7.67181739e-02f, 5.37879243e-02f, -1.57705061e-02f, -4.09555435e-02f, -4.00869846e-02f, -6.66207522e-02f, 2.26787776e-02f, -4.58290838e-02f,
  6.53461367e-02f, 9.27215256e-03f, 5.88388406e-02f, -2.62029096e-03f, 7.27633014e-02f, -2.52432227e-02f, -4.31597345e-02f, 2.34023836e-02f, 1.84763782e-02f, -3.11033055e-03f,
  5.53941801e-02f, 5.91424406e-02f, 1.64117664e-03f, 6.06333353e-02f, -5.25176153e-02f, -8.22260603e-03f, -1.25794625e-02f, 3.91078973e-03f, 1.72926318e-02f, 1.27890846e-02f,
  1.75413457e-04f, 1.05139576e-02f, -1.00295499e-01f, -7.04694986e-02f, -2.37114709e-02f, 9.98823419e-02f, -1.86897758e-02f, -6.91060275e-02f, -5.87891042e-03f, -6.08243719e-02f,
  -7.35430196e-02f, -4.13369387e-02f, 1.01128221e-01f, -1.48785174e-01f, 4.69350293e-02f, 6.23526610e-02f, 3.96565534e-02f, -2.42804084e-02f, -1.52657732e-01f, 8.08538962e-03f,
  2.98897903e-02f, 3.54037550e-03f, 3.39652449e-02f, -6.34569526e-02f, -1.07127100e-01f, -6.07382432e-02f, -4.75915670e-02f, -1.07562177e-01f, -6.42480329e-02f, -9.33131129e-02f,
  2.56131608e-02f, -9.51634347e-02f, -4.63928357e-02f, 9.66856480e-02f, 6.53339773e-02f, 8.37839693e-02f, 4.60833013e-02f, 1.69086725e-01f, -5.03503196e-02f, 1.07609928e-01f,
  7.07051381e-02f, -9.08971876e-02f, 1.64966490e-02f, -3.73039767e-02f, -6.42324314e-02f, 9.85580981e-02f, 2.53762156e-02f, -7.88861234e-03f, -5.47537208e-02f, -1.53021663e-02f,
  -7.47003555e-02f, 1.53578948e-02f, -6.82831630e-02f, 1.54214324e-02f, 3.01716737e-02f, -6.16660193e-02f, 3.40928137e-02f, 2.98268581e-03f, -7.80810416e-02f, 1.96410269e-02f,
  1.20830154e-02f, -3.34253274e-02f, -1.34926452e-03f, -2.96487268e-02f, -3.34267132e-02f, -2.36957334e-02f, 1.05233938e-02f, -5.20228110e-02f, 1.71625763e-02f, -4.14223000e-02f,
  1.55121973e-02f, 8.67378116e-02f, -5.75408014e-03f, -5.21344729e-02f, 4.13333252e-02f, 6.78714663e-02f, -9.98327062e-02f, -6.54285029e-02f, 2.72291768e-02f, -7.39124045e-02f,
  -8.02361295e-02f, 6.80395365e-02f, 3.39929350e-02f, -2.78630741e-02f, -9.78226680e-03f, -1.91738177e-02f, 3.49324979e-02f, 1.88439265e-02f, 5.54049015e-02f, 6.53560534e-02f,
  4.98436540e-02f, 4.59523387e-02f, 3.93395536e-02f, -7.86589608e-02f, -4.92395125e-02f, -6.57283738e-02f, 6.05261326e-02f, -9.63983312e-02f, 8.59610364e-02f, 2.69165356e-02f,
  -1.00006605e-03f, -2.66075972e-02f, -6.78461045e-02f, 7.87351802e-02f, -3.50729227e-02f, -7.50797167e-02f, -9.02227908e-02f, 3.12657207e-02f, -5.74663654e-02f, -7.58443549e-02f,
  -3.32951061e-02f, 3.67446872e-03f, 2.54696254e-02f, -6.79041967e-02f, 8.52721930e-02f, 4.72185537e-02f, 6.60072714e-02f, 8.72051939e-02f, 3.29697989e-02f, 5.93757443e-02f,
  7.00395107e-02f, -4.22424898e-02f, -7.85546973e-02f, -5.83604816e-03f, -4.42708954e-02f, -4.20473143e-02f, 4.06635040e-03f, -1.11906296e-02f, -8.59423447e-03f, 4.60883044e-02f,
  1.25641525e-01f, -2.25438643e-02f, -1.62772834e-01f, -1.00876801e-01f, -1.11400023e-01f, -1.28264621e-01f, -1.87356889e-01f, -3.82365547e-02f, -8.61886144e-02f, 8.30720142e-02f,
  -5.30079827e-02f, 3.37492414e-02f, 3.17112368e-04f, -5.20632043e-02f, 1.20435670e-01f, 7.73506835e-02f, 1.63101051e-02f, 2.95620579e-02f, 1.37133431e-02f, -1.16304010e-01f,
  -7.18288263e-03f, -9.28210095e-02f, 2.11023297e-02f, -9.95803997e-02f, -1.25555739e-01f, -1.11893095e-01f, 6.02425188e-02f, -1.36668041e-01f, -9.08388421e-02f, -1.17570080e-01f,
  4.07503061e-02f, 5.52415028e-02f, -5.76002672e-02f, 3.61098489e-03f, -3.93616594e-02f, -4.01652558e-03f, -1.77855417e-02f, 7.34499022e-02f, -2.28757635e-02f, -7.58099556e-02f,
  -2.93835923e-02f, 2.93925684e-02f, 6.54721484e-02f, 8.50842893e-02f, -8.30674246e-02f, -1.19224980e-01f, 3.04089710e-02f, -1.06441945e-01f, -3.08468118e-02f, -2.00379007e-02f,
  -1.25828087e-01f, -8.62894580e-02f, -9.57278628e-03f, -6.73062541e-03f, -2.88423616e-02f, -8.44698772e-03f, 8.91684517e-02f, -6.12902083e-02f, -1.05091948e-02f, -5.31707071e-02f,
  2.95648575e-02f, -1.86159287e-03f, -4.38541552e-04f, 6.10918179e-02f, 5.64552844e-02f, -8.73274505e-02f, 3.48052941e-02f, 4.83595394e-02f, -6.14071488e-02f, 4.03422751e-02f,
  1.69068482e-02f, 2.55663730e-02f, 6.75138608e-02f, 7.78182670e-02f, 4.26888131e-02f, 2.94025019e-02f, 2.22402439e-02f, 2.58575920e-02f, -1.21765159e-04f, 6.16978332e-02f,
  6.73320442e-02f, 3.66019420e-02f, 7.14881420e-02f, -5.44447601e-02f, -5.90917841e-02f, 2.65216120e-02f, 7.83288777e-02f, -4.56424132e-02f, -5.80610931e-02f, -6.34415150e-02f,
  -2.88745612e-02f, 1.61009864e-03f, 4.56483997e-02f, -5.95703349e-02f, -2.35522408e-02f, 3.57699990e-02f, 4.62399535e-02f, -4.77083139e-02f, -6.66559190e-02f, -5.31839170e-02f,
  -6.40695170e-02f, 7.53307194e-02f, 3.07876654e-02f, -4.29501832e-02f, -5.38784191e-02f, -6.50738627e-02f, 7.20159858e-02f, -3.14324126e-02f, -2.34884154e-02f, 3.78005505e-02f,
  3.88826281e-02f, -7.27537042e-03f, 5.45567088e-02f, 1.39729008e-02f, -6.92529455e-02f, 1.69662852e-02f, -6.11064658e-02f, -5.66588491e-02f, 2.00056750e-02f, 4.31594700e-02f,
  -1.37154013e-01f, -1.51303291e-01f, 5.87308221e-03f, -1.13443054e-01f, 1.40078485e-01f, 6.03701361e-02f, 3.36606726e-02f, 1.72471106e-02f, -7.14576319e-02f, -8.10146681e-04f,
  2.88636573e-02f, -1.28677804e-02f, -3.25800143e-02f, 2.71392856e-02f, 1.01976179e-01f, -2.97226328e-02f, -9.53812525e-02f, -2.21718643e-02f, -9.41803008e-02f, 2.79340036e-02f,
  -7.24390000e-02f, -8.31607953e-02f, 7.82805309e-02f, 3.91635001e-02f, 4.29963842e-02f, 7.05477148e-02f, -8.06815922e-02f, 4.10774872e-02f, -1.32701881e-02f, 9.22835916e-02f,
  -6.58940896e-02f, 5.78351021e-02f, 2.04388257e-02f, -3.21227536e-02f, 3.43220383e-02f, 1.42763238e-02f, -2.60059237e-02f, 8.04156661e-02f, -2.71716695e-02f, 6.88741952e-02f,
  -2.44666729e-02f, -4.47150245e-02f, 3.55027169e-02f, 6.67959824e-02f, -1.60561819e-02f, -4.35829125e-02f, 7.72781819e-02f, 2.73093674e-02f, -7.63746649e-02f, 4.67726700e-02f,
  -6.79552481e-02f, 2.84331944e-02f, 1.98634416e-02f, -9.86896362e-03f, -6.87057823e-02f, -4.33621891e-02f, 3.62197775e-03f, 9.22685638e-02f, 2.75585763e-02f, 9.39767051e-04f,
  2.29473240e-04f, 4.76995222e-02f, 2.35840809e-02f, 6.25351816e-02f, -5.52588888e-02f, 1.93984453e-02f, 5.28903678e-02f, -1.64271034e-02f, 6.61388086e-03f, 2.28351564e-04f,
  5.97168542e-02f, -8.45098719e-02f, 3.74640897e-02f, -8.19144845e-02f, -9.42286253e-02f, -1.72257628e-02f, -1.01964526e-01f, -6.69761673e-02f, 1.64839942e-02f, -3.96947041e-02f,
  3.60746905e-02f, 3.24048884e-02f, 5.75001724e-02f, -7.06110150e-02f, 7.43151903e-02f, 6.20716736e-02f, 8.06971788e-02f, 3.93122025e-02f, -3.81621271e-02f, -5.08039482e-02f,
  -1.63200527e-01f, 1.42339768e-03f, 4.36938368e-02f, 8.80688727e-02f, -1.25814956e-02f, 2.06194236e-03f, 5.11807911e-02f, -1.05304994e-01f, 6.32935315e-02f, -4.11589295e-02f,
  -7.45043308e-02f, -7.86684677e-02f, -7.11551830e-02f, -2.62634195e-02f, 1.95556562e-02f, -9.14305523e-02f, -1.85184292e-02f, 5.88176399e-02f, -1.66008878e-03f, -7.21596833e-03f,
  -1.11157028e-02f, 3.29147540e-02f, 7.58068189e-02f, -1.12663293e-02f, -3.81996371e-02f, -2.04479527e-02f, 5.27029298e-02f, 1.25511177e-03f, 4.56808619e-02f, -1.95071064e-02f,
  -6.98716491e-02f, -9.66361836e-02f, -1.06708884e-01f, -9.25181210e-02f, -5.97055927e-02f, 1.86470635e-02f, -1.48548797e-01f, 1.77615248e-02f, -7.96359591e-03f, -1.03070952e-01f,
  -1.12743028e-01f, 8.01451132e-03f, 6.80443048e-02f, -7.13615268e-02f, 3.27004083e-02f, 1.40059867e-03f, -7.93296620e-02f, -6.16705865e-02f, -3.29442024e-02f, -1.01288117e-01f,
  3.72347385e-02f, -5.97159490e-02f, -4.97548953e-02f, 2.82071643e-02f, 1.98600516e-02f, -2.99507305e-02f, -3.24568897e-02f, -6.94043413e-02f, -1.96606144e-02f, 7.50219375e-02f,
  -1.28098056e-01f, -1.55628130e-01f, 2.63702460e-02f, 5.27937450e-02f, -1.79725830e-02f, -1.04900058e-02f, 8.73794109e-02f, 2.41131820e-02f, 2.58203503e-02f, 6.64782748e-02f,
  -9.51608701e-04f, 7.71222636e-02f, -2.86667626e-02f, -4.36011739e-02f, -3.56026297e-03f, -5.80310486e-02f, -1.03340290e-01f, 6.09226450e-02f, 5.56204207e-02f, 2.88058189e-03f,
  3.26572135e-02f, -1.37720145e-02f, -1.06689058e-01f, 3.23251821e-02f, 5.84366098e-02f, 7.97783136e-02f, -5.18517196e-02f, 4.39278362e-03f, 3.43254693e-02f, -8.53077620e-02f,
  -4.27583829e-02f, 5.26755070e-03f, -4.09277156e-02f, -3.78275923e-02f, 9.40202996e-02f, -2.97182575e-02f, 4.13842462e-02f, 4.77041258e-03f, -3.37247439e-02f, 6.44939840e-02f,
  -8.27421769e-02f, 2.90603787e-02f, 8.12575966e-02f, -5.75312525e-02f, -6.38173521e-02f, 1.06694922e-02f, -9.28022992e-03f, -4.69694026e-02f, -4.12288979e-02f, -2.15598196e-02f,
  -7.27168890e-03f, -8.42123330e-02f, -2.85785738e-03f, 7.56290704e-02f, 8.38926136e-02f, -6.92157168e-03f, 6.75324649e-02f, 1.01960180e-02f, 2.18594372e-02f, 9.72156599e-02f,
  -9.60929319e-02f, -1.18261747e-01f, -4.59637083e-02f, 8.80761668e-02f, 2.50783600e-02f, -1.69836599e-02f, -4.98516336e-02f, 4.82291766e-02f, -2.25757584e-02f, -6.99427119e-03f,
  -4.79634106e-03f, -4.17374074e-02f, 1.37270130e-02f, 8.66283402e-02f, -4.12808731e-02f, -5.68102300e-02f, -5.97705133e-03f, -1.20482880e-04f, -9.26550478e-02f, 2.28090230e-02f,
  6.86586425e-02f, 8.09544101e-02f, -2.07089353e-02f, 1.06134027e-01f, -5.00331037e-02f, -6.50840402e-02f, -3.44080068e-02f, 7.18701184e-02f, 6.52010413e-03f, 2.97507849e-02f,
  9.86188576e-02f, 1.12056985e-01f, -3.92626040e-03f, 1.89028867e-02f, 6.91590533e-02f, 2.25796148e-01f, 2.19884604e-01f, 1.21635556e-01f, 2.74057537e-01f, 4.63250875e-02f,
  -7.80554265e-02f, 2.47693900e-02f, -2.70461082e-03f, 1.12437502e-01f, -4.17417213e-02f, 6.53594583e-02f, 1.52465120e-01f, 1.37660846e-01f, 1.41675457e-01f, -4.70956089e-03f,
  -3.83329131e-02f, 6.91494346e-03f, -5.48433065e-02f, -6.87535256e-02f, -6.05027005e-02f, -1.12342581e-01f, -7.45735615e-02f, -2.46848222e-02f, -6.05720468e-02f, 9.54075605e-02f,
  9.57847610e-02f, 1.77041795e-02f, -1.16185792e-01f, -5.02306595e-02f, 2.80763442e-03f, 3.96758988e-02f, -2.68795881e-02f, -5.59304953e-02f, 5.95951155e-02f, 5.31535707e-02f,
  -4.18531336e-02f, -3.96792553e-02f, 8.47585499e-02f, 2.46954393e-02f, 1.05897292e-01f, 1.90544152e-03f, 6.25893623e-02f, 1.98702663e-02f, -4.84926663e-02f, -5.37798256e-02f,
  -2.76996929e-04f, 1.95918623e-02f, 5.89146838e-02f, 1.00200087e-01f, -1.79846659e-02f, 7.38662928e-02f, 2.23066639e-02f, -7.29767755e-02f, 1.92503091e-02f, 4.07218449e-02f,
  6.34392202e-02f, 3.11296005e-02f, -5.78655526e-02f, 1.28714377e-02f, 7.50383064e-02f, 4.03040238e-02f, 2.73260009e-02f, -5.21464134e-03f, -8.13114196e-02f, -5.36735319e-02f,
  -1.75373591e-02f, 3.31615843e-02f, 1.56307276e-02f, -1.86794419e-02f, 8.42140615e-02f, 2.47241035e-02f, 3.46499197e-02f, -2.13441253e-02f, -9.01847407e-02f, -3.34437862e-02f,
  -4.19098884e-02f, 7.58126900e-02f, -2.63378825e-02f, -3.33614126e-02f, 1.04320079e-01f, -6.37427866e-02f, -1.79498196e-02f, -4.80165333e-02f, -3.92908566e-02f, -6.04769140e-02f,
  1.20866038e-01f, 1.25211060e-01f, -3.06518059e-02f, 3.88829671e-02f, -8.97394419e-02f, -3.65461521e-02f, 3.42320427e-02f, -5.60313389e-02f, 1.24148175e-01f, -3.58195454e-02f,
  -4.91346680e-02f, 3.79845649e-02f, 5.91441691e-02f, -4.24929969e-02f, -2.06077248e-02f, 3.62316072e-02f, 2.38982551e-02f, 1.11175636e-02f, 7.90976807e-02f, -9.89488587e-02f,
  -2.75848396e-02f, -5.19356616e-02f, -1.35243405e-02f, 5.89757087e-03f, 3.73974554e-02f, -1.01610348e-02f, -2.85248482e-03f, 5.23037165e-02f, 4.76009659e-02f, 1.11871377e-01f,
  3.13169301e-01f, -7.39783645e-02f, 1.85396388e-01f, 2.18692854e-01f, 5.00999279e-02f, 3.39687280e-02f, 3.41094807e-02f, -1.08122230e-01f, 1.55666605e-01f, -1.36779979e-01f,
  -1.84522402e-02f, 1.16095252e-01f, -3.11164446e-02f, 4.55315225e-02f, -6.55942783e-02f, -4.95695397e-02f, -1.28284752e-01f, 9.34877098e-02f, 7.36047179e-02f, 3.57177258e-02f,
  6.75309449e-02f, -5.88310286e-02f, -6.28388450e-02f, -1.98584005e-01f, 2.36157305e-03f, -4.39699776e-02f, -9.35622603e-02f, -6.69036806e-02f, -2.77243443e-02f, -5.40204979e-02f,
  2.57061459e-02f, 9.55173746e-03f, 5.39052561e-02f, -2.83158403e-02f, 2.23319163e-03f, -2.52334848e-02f, 5.67166274e-03f, -2.34617013e-03f, 6.03605178e-04f, 5.92188016e-02f,
  7.16958418e-02f, 4.39255917e-03f, 1.55405523e-02f, -3.53140272e-02f, 3.18095945e-02f, -4.35841046e-02f, 4.73091379e-02f, 7.18232095e-02f, -6.05071448e-02f, -1.05965035e-02f,
  7.71912280e-03f, 9.47425067e-02f, 8.32565054e-02f, -5.03598116e-02f, -1.26474043e-02f, 8.04188251e-02f, -1.07686087e-01f, 7.57347466e-03f, -6.02043122e-02f, 5.42422384e-02f,
  -7.79288039e-02f, -8.85765180e-02f, 2.56532431e-02f, 5.51692992e-02f, 3.88239808e-02f, 6.45105541e-02f, -9.47483908e-03f, 5.10606281e-02f, 2.75771916e-02f, 2.74409284e-03f,
  -5.92712536e-02f, 1.65937399e-03f, -2.90563460e-02f, -5.14672697e-02f, 9.16059241e-02f, 5.54999784e-02f, -5.92806302e-02f, 1.78574659e-02f, -4.78010215e-02f, 7.40418062e-02f,
  -4.83347625e-02f, 4.03737687e-02f, 3.59258242e-02f, -3.64209116e-02f, 1.25278663e-02f, -2.20314842e-02f, -5.38732931e-02f, 5.96716665e-02f, -1.04499217e-02f, 3.10890116e-02f,
  -7.12952688e-02f, -1.30198166e-01f, 1.10717034e-02f, -4.94480170e-02f, -1.29412804e-02f, 8.23863409e-03f, 6.56607077e-02f, 8.91757831e-02f, -1.11501984e-01f, 4.44293134e-02f,
  -7.88291171e-02f, -7.27718137e-03f, 4.71671000e-02f, 3.24028656e-02f, 2.73384713e-02f, -6.42736629e-02f, -3.52618145e-03f, -1.85589846e-02f, 5.99959567e-02f, 7.36017199e-03f,
  6.90022036e-02f, -1.15590066e-01f, 9.58996192e-02f, 1.02228932e-01f, -6.00207075e-02f, 4.07446586e-02f, -1.31441199e-03f, 2.99665220e-02f, -5.35170250e-02f, -3.18424404e-02f,
  -1.04575463e-01f, -7.35926488e-03f, -5.93176857e-02f, 8.68289825e-03f, -8.72653350e-03f, -1.12679616e-01f, -2.32285354e-02f, -5.46403043e-02f, 3.84901352e-02f, -2.29894510e-03f,
  -6.78649992e-02f, 1.74442064e-02f, 2.11478584e-02f, -5.52481301e-02f, -2.14532509e-01f, -1.44061163e-01f, -3.81973535e-02f, -1.07565541e-02f, -8.65790322e-02f, 1.64475925e-02f,
  -1.18422531e-01f, -1.53415129e-01f, -1.59696594e-01f, 6.14973232e-02f, -5.47867864e-02f, 3.55060995e-02f, -1.38977692e-02f, 3.51460576e-02f, 1.66795813e-02f, -1.11215636e-01f,
  5.19159175e-02f, 1.12039670e-01f, 9.84413773e-02f, 1.70805193e-02f, -5.65280914e-02f, -8.10357332e-02f, 9.46362223e-03f, -7.28341565e-02f, -7.95981511e-02f, 1.03711627e-01f,
  8.78637731e-02f, 2.69261599e-02f, 6.43287227e-02f, -3.70611846e-02f, 6.86552236e-03f, 7.96728507e-02f, -2.82215364e-02f, -3.90994661e-02f, 5.46241216e-02f, -2.93578692e-02f,
  -6.67463765e-02f, -3.58013362e-02f, -1.70408078e-02f, 1.06384428e-02f, 7.21202791e-02f, 8.89262855e-02f, -1.04149152e-02f, -1.85085610e-02f, 6.80045262e-02f, -2.26606112e-02f,
  6.54369518e-02f, -7.24944472e-02f, -9.78211612e-02f, 1.53851276e-02f, 2.61495616e-02f, 4.05717343e-02f, -5.70277497e-03f, -2.35545058e-02f, 6.63819015e-02f, 6.55090436e-02f,
  -4.86400798e-02f, -4.29251641e-02f, 5.34259416e-02f, -9.59709063e-02f, 4.45480794e-02f, 2.59183329e-02f, 6.75347447e-02f, 7.90093392e-02f, 4.72103767e-02f, -3.71483937e-02f,
  7.75748491e-02f, -1.95637085e-02f, -4.10421416e-02f, 7.58944452e-02f, 5.43910451e-02f, -5.83768487e-02f, -2.76864823e-02f, -3.02564446e-02f, 4.01089080e-02f, 5.31904064e-02f,
  1.82398148e-02f, 5.90541698e-02f, 1.73923392e-02f, 3.87811661e-02f, 5.69537170e-02f, 5.76872639e-02f, -8.12850967e-02f, 4.31529507e-02f, 8.48027542e-02f, 3.15425806e-02f,
  -1.46785332e-02f, -3.53898704e-02f, -5.51733784e-02f, -5.76019473e-02f, -8.15859884e-02f, 6.69589862e-02f, 2.26214994e-02f, 9.34680626e-02f, -8.67232159e-02f, -6.96150288e-02f,
  1.66262891e-02f, 1.39748389e-02f, 7.37173185e-02f, -3.54625992e-02f, -2.45975051e-02f, 7.32592493e-02f, 3.20597105e-02f, 9.35231224e-02f, -9.95801296e-03f, -2.93735880e-02f,
  7.28061870e-02f, -3.56601849e-02f, 6.21489831e-04f, -4.10695188e-02f, -9.18503776e-02f, -4.06445237e-03f, -2.32619382e-02f, -1.33306105e-02f, -9.18089002e-02f, 2.16264259e-02f,
  -2.55130474e-02f, -6.77029341e-02f, -4.00050357e-02f, 1.69508383e-02f, 2.94373427e-02f, -7.41331056e-02f, -2.24221982e-02f, 9.56199169e-02f, 9.95507697e-04f, 2.86467862e-03f,
  3.26266699e-02f, 8.91398191e-02f, 2.66850255e-02f, -7.34971315e-02f, -7.85228759e-02f, 2.49131024e-02f, -4.97928709e-02f, 5.66769652e-02f, -7.81614184e-02f, 6.44534379e-02f,
  9.77981836e-02f, -4.58048545e-02f, -1.01020776e-01f, 6.77466318e-02f, 6.17188998e-02f, 3.29248868e-02f, -5.59048913e-02f, 8.43719840e-02f, 2.17493121e-02f, -4.21205070e-03f,
  8.72700065e-02f, 7.38263205e-02f, -2.50084735e-02f, -4.84695658e-02f, 7.19360858e-02f, -7.66826645e-02f, 3.05230394e-02f, 6.71112165e-02f, -1.57777313e-02f, 3.42265628e-02f,
  5.99427596e-02f, -4.57399432e-03f, 7.39239380e-02f, 2.15833001e-02f, -3.61154079e-02f, -1.74667127e-02f, -2.11636387e-02f, 5.76066375e-02f, -7.70694092e-02f, -2.29036380e-02f,
  6.40975386e-02f, 9.46228579e-03f, 7.77032897e-02f, 8.08496103e-02f, 9.93238613e-02f, 9.45184007e-02f, 1.24690756e-02f, -5.01411147e-02f, 9.26113129e-02f, 7.40764439e-02f,
  6.50455654e-02f, -2.88632009e-02f, 5.92149273e-02f, -1.04134809e-02f, -9.04941410e-02f, 3.63634005e-02f, -6.46064356e-02f, -2.35609077e-02f, -3.67216431e-02f, -5.26057780e-02f,
  9.49618686e-03f, 1.73356608e-02f, 7.55461007e-02f, 5.34258187e-02f, -6.33465722e-02f, -1.10285580e-02f, 8.92317109e-03f, 1.64463054e-02f, 1.26118008e-02f, 7.97497481e-02f,
  8.20863321e-02f, -1.43521279e-02f, 4.98054400e-02f, -3.93444039e-02f, 7.45444670e-02f, 2.57002972e-02f, 5.07196076e-02f, 7.21700713e-02f, -7.58921504e-02f, 5.47802784e-02f,
  -2.74859481e-02f, -5.85844852e-02f, 4.73577902e-02f, -3.51054817e-02f, -5.17052077e-02f, 3.06951031e-02f, 7.45700151e-02f, -1.29156774e-02f, 4.03473340e-03f, 1.84155367e-02f,
  5.30497134e-02f, -7.36078396e-02f, 1.15923937e-02f, -1.41744260e-02f, -1.64123066e-02f, 9.08940583e-02f, -4.12782133e-02f, 1.45850228e-02f, 6.15599006e-02f, -2.80642812e-03f,
  -1.55267075e-01f, 3.38684656e-02f, -5.06051071e-02f, -1.47190452e-01f, 3.97685841e-02f, -8.72420426e-03f, -7.76477978e-02f, -1.31578729e-01f, -8.07903558e-02f, -1.61159113e-01f,
  -1.05511837e-01f, -3.06934938e-02f, 1.28871948e-02f, -1.31408930e-01f, 1.25581482e-02f, 4.19181846e-02f, -1.61360353e-01f, -1.67776197e-01f, 2.76791453e-02f, -2.07539573e-01f,
  -3.11747957e-02f, -1.63718551e-01f, -2.97953226e-02f, -6.35987520e-02f, -1.81415021e-01f, -7.14764148e-02f, -1.20530948e-01f, -1.82422320e-03f, -3.65997255e-02f, 7.17165396e-02f,
  1.47588372e-01f, -1.69314250e-01f, 1.08472951e-01f, -5.02319820e-02f, -1.18447468e-01f, -6.70258552e-02f, -2.70757694e-02f, 1.39090016e-01f, -1.46709727e-02f, 2.09011510e-02f,
  -5.06671555e-02f, 5.79165071e-02f, 4.26507182e-02f, -1.17117958e-02f, -5.70727140e-02f, -9.55549721e-03f, -4.96157259e-03f, 2.55868230e-02f, 5.53243719e-02f, -3.77020314e-02f,
  7.34851137e-02f, -1.18273320e-02f, -7.85590038e-02f, -9.19828415e-02f, -7.72868767e-02f, 4.31939624e-02f, 7.65763372e-02f, -8.52581859e-02f, -7.81131834e-02f, 2.84092892e-02f,
  -4.80097765e-03f, -1.33220837e-01f, 2.35314555e-02f, -2.13934109e-02f, 5.30796237e-02f, 7.51999244e-02f, -3.78761776e-02f, 3.69141698e-02f, 1.93725992e-02f, 9.06857699e-02f,
  4.30023521e-02f, -9.77512151e-02f, -8.02922100e-02f, -5.06392866e-02f, 1.60947740e-02f, -1.52613642e-02f, -3.97613458e-02f, -1.17717478e-02f, 6.88298047e-02f, 9.56767648e-02f,
  2.06866935e-02f, 8.96820575e-02f, -1.03860736e-01f, -6.60591805e-03f, 1.74213834e-02f, -9.63787138e-02f, 1.36922365e-02f, 1.30019924e-02f, -1.22119505e-02f, -4.83496599e-02f,
  2.59426683e-02f, -1.38128623e-01f, 8.18439573e-02f, 2.23281533e-02f, -3.30711119e-02f, 2.87965555e-02f, -8.91879275e-02f, -6.41873386e-03f, -1.48152737e-02f, -5.89757487e-02f,
  -3.62514555e-02f, -3.25118266e-02f, 2.81559546e-02f, -3.36445160e-02f, 4.50703092e-02f, 5.58970645e-02f, -2.95924842e-02f, -7.33476728e-02f, -6.56078607e-02f, 6.69029951e-02f,
  2.91175228e-02f, 2.38301381e-02f, 2.02875528e-02f, -3.72314341e-02f, -1.02689669e-01f, -5.46087585e-02f, -5.74583523e-02f, 9.46897119e-02f, -6.66744784e-02f, -1.91457327e-02f,
  -1.74749881e-01f, 6.54078200e-02f, 8.05605352e-02f, -1.22600213e-01f, -1.75412773e-04f, 4.82835574e-03f, 6.46612328e-03f, 6.30301684e-02f, -1.75357535e-02f, -6.61265338e-03f,
  -1.01296790e-02f, -2.78060567e-02f, -5.19637093e-02f, -7.09620677e-03f, -9.00531486e-02f, -5.78296278e-03f, 6.37655407e-02f, -4.97170240e-02f, 8.72774795e-02f, 3.20331678e-02f,
  -1.94233619e-02f, 3.81441526e-02f, 6.83554485e-02f, 1.66010838e-02f, 6.13848455e-02f, -7.35650286e-02f, -3.76073159e-02f, 6.61444589e-02f, 8.92823935e-02f, -7.95838013e-02f,
  2.99630240e-02f, -7.81899989e-02f, 4.93645296e-02f, 6.55661970e-02f, -1.60066294e-03f, 5.63670769e-02f, 6.82482496e-02f, 4.86924313e-02f, 6.07316121e-02f, 2.08559893e-02f,
  5.25378250e-02f, 7.13995323e-02f, -7.25232437e-02f, -6.05633669e-02f, 6.53694198e-03f, 7.99634904e-02f, 1.38298785e-02f, 7.60620236e-02f, 1.02678016e-01f, -3.01129427e-02f,
  -3.86274382e-02f, 8.41408297e-02f, -5.03664874e-02f, -6.30594790e-02f, 8.43772814e-02f, 2.75928136e-02f, -8.01441446e-02f, 4.32680137e-02f, -7.61043951e-02f, -8.96234140e-02f,
  -6.52417587e-03f, 5.06190732e-02f, 6.05042726e-02f, -5.16601801e-02f, 9.19629261e-02f, 4.67218272e-02f, -3.23654376e-02f, 4.81138704e-03f, -5.97837791e-02f, -3.68671529e-02f,
  -3.39177847e-02f, 7.03059658e-02f, -3.85792665e-02f, 3.50886793e-03f, -4.11296263e-02f, 6.37982786e-02f, 6.08296581e-02f, 2.56490242e-02f, 8.48486051e-02f, 9.33566988e-02f,
  -2.33420171e-02f, -7.03706220e-02f, -6.43948764e-02f, -5.08769453e-02f, 5.02966009e-02f, -9.24455523e-02f, -6.26658946e-02f, -7.57783130e-02f, 6.14203922e-02f, -7.93631226e-02f,
  -3.08060348e-02f, 5.92364408e-02f, 5.62862940e-02f, -2.03715521e-03f, -5.23584262e-02f, -3.20961070e-03f, 8.71394575e-02f, 1.34042008e-02f, -1.02378793e-01f, -4.25294647e-03f,
  -2.64062802e-03f, -6.39831647e-02f, 7.46954605e-02f, 7.46165887e-02f, -1.90588925e-02f, 8.83035362e-02f, 8.69908333e-02f, 6.80806637e-02f, 1.62520986e-02f, 9.23549011e-02f,
  -5.52573949e-02f, 3.50823998e-02f, -4.95082699e-02f, 7.54997209e-02f, -3.27967182e-02f, -8.79977718e-02f, -8.72870013e-02f, 4.69931914e-03f, -7.11768195e-02f, -8.28429088e-02f,
  -1.70906216e-01f, 5.46160229e-02f, -8.75397176e-02f, -1.22431397e-01f, 6.00818694e-02f, -1.29938036e-01f, -4.44733724e-02f, -6.51858095e-03f, 5.79325631e-02f, -6.96213916e-02f,
  9.92239192e-02f, -8.51997212e-02f, 4.72500995e-02f, -3.87088358e-02f, -1.58859476e-01f, -1.68078132e-02f, -1.40402570e-01f, -5.81347011e-02f, -2.92314496e-02f, -8.27904269e-02f,
  -3.43307183e-04f, -1.06979877e-01f, -2.33432334e-02f, -2.48965248e-03f, -5.92584312e-02f, -2.37649959e-02f, -7.99900591e-02f, 9.71653685e-02f, -5.72298355e-02f, 2.94822156e-02f,
  -7.54185393e-02f, -2.17743381e-03f, -1.78618694e-03f, -5.16710095e-02f, -1.15190029e-01f, -3.95098440e-02f, -5.80479801e-02f, -3.04686930e-02f, -4.66056913e-02f, -3.88727412e-02f,
  -9.91438329e-02f, 6.26201555e-02f, -7.76717216e-02f, -4.03490121e-04f, 2.28628162e-02f, 1.19736167e-02f, 1.10172458e-01f, -8.21826630e-04f, 9.62934121e-02f, -5.35267107e-02f,
  4.38560508e-02f, -6.84294775e-02f, -1.10940851e-01f, -8.87965262e-02f, 2.65098047e-02f, -2.54548341e-02f, -9.32249501e-02f, 3.73709612e-02f, 4.49926555e-02f, -9.90898535e-02f,
  2.77346163e-03f, -1.07114278e-02f, 8.84149373e-02f, -6.58115232e-03f, -6.16711304e-02f, 3.50060426e-02f, 4.00836244e-02f, -9.02515128e-02f, -7.56081715e-02f, -1.46550434e-02f,
  -9.15156037e-04f, -6.38728440e-02f, -9.02206376e-02f, 1.34643558e-02f, -7.88916275e-03f, -1.52411032e-02f, -4.63896012e-03f, 8.18928005e-04f, 4.99810278e-02f, -8.52702186e-02f,
  2.32784003e-02f, -1.77569129e-02f, -3.28032821e-02f, -5.31850792e-02f, 8.23925808e-02f, 5.60163371e-02f, 4.09286789e-04f, 5.75406030e-02f, -1.82203948e-02f, -4.73455936e-02f,
  -1.41215041e-01f, -1.51510566e-01f, 2.67432667e-02f, -8.41473937e-02f, -1.13506401e-02f, -5.48734814e-02f, -1.02915898e-01f, 4.36579064e-02f, -1.18378401e-01f, -1.73415281e-02f,
  3.14932205e-02f, -6.69157878e-02f, -1.07107386e-01f, -4.38263007e-02f, 5.49219251e-02f, -4.77416217e-02f, -3.50494087e-02f, 5.61857875e-03f, -2.50756107e-02f, 3.22347805e-02f,
  -4.59493473e-02f, -5.68122789e-03f, 7.32826218e-02f, -3.40480469e-02f, -5.70392199e-02f, -6.70439377e-02f, -3.43233570e-02f, -4.91525568e-02f, -5.17756343e-02f, 5.61253615e-02f,
  1.37735590e-01f, -1.29041076e-02f, 1.12556212e-01f, -5.07761575e-02f, -9.46700498e-02f, -1.21879816e-01f, -2.00999994e-02f, 1.97984595e-02f, 2.55997181e-02f, 6.91893883e-03f,
  -1.03399061e-01f, 1.43821344e-01f, -2.27005184e-02f, -1.10949785e-01f, 2.67217122e-02f, -7.68832713e-02f, -5.37750013e-02f, 6.54677227e-02f, -2.84666717e-02f, 7.69674554e-02f,
  1.07350297e-01f, -1.77491903e-01f, -2.47297883e-02f, -1.72146007e-01f, -1.06820107e-01f, 2.25140080e-02f, -1.57139897e-01f, 5.16252033e-02f, 1.28910001e-02f, -8.50541592e-02f,
  7.42152752e-03f, 4.98487987e-02f, -1.04867592e-01f, -7.36141205e-02f, -9.20899678e-03f, 9.46181174e-03f, 7.97192305e-02f, 1.09183574e-02f, -1.86173022e-02f, -1.49923293e-02f,
  1.04845725e-01f, 1.90323708e-03f, 3.24146748e-02f, 1.95571501e-02f, 9.71912965e-03f, 2.24607345e-02f, 2.42936593e-02f, -4.77912426e-02f, 1.85885951e-02f, -4.26966771e-02f,
  4.30970713e-02f, -6.19791672e-02f, 3.26139964e-02f, -1.89228486e-02f, 5.47372624e-02f, -7.57347271e-02f, -2.34935265e-02f, 4.44619469e-02f, 9.83696356e-02f, -4.59349118e-02f,
  -4.63742055e-02f, -1.43841282e-02f, 4.01965491e-02f, 5.74267954e-02f, 1.02826253e-01f, 6.50425069e-03f, -4.32436354e-02f, 6.54409379e-02f, 4.56471518e-02f, -1.97644196e-02f,
  -5.21694543e-03f, 3.06127314e-02f, 3.26551162e-02f, 7.43259117e-02f, -9.38126519e-02f, -6.68397965e-03f, -6.08036220e-02f, -5.24632744e-02f, -6.88531697e-02f, -2.49429159e-02f,
  -3.30513120e-02f, -6.91208290e-03f, -6.20234869e-02f, 7.18006399e-03f, 1.65249463e-02f, 2.21952964e-02f, 8.78993981e-03f, 3.31010856e-02f, -3.26237045e-02f, 3.92042883e-02f,
  -1.45977326e-02f, -1.52306274e-01f, 2.11054515e-02f, -1.41214253e-02f, -9.17936936e-02f, 2.95548141e-02f, 1.86395496e-02f, -7.29062781e-02f, -2.11049393e-02f, 8.05958062e-02f,
  6.02076165e-02f, 1.41861895e-02f, 6.67142347e-02f, 3.83834019e-02f, 2.43579485e-02f, -2.36910507e-02f, -8.60778689e-02f, -3.64686549e-02f, -7.28696659e-02f, 1.67888813e-02f,
  2.11331230e-02f, 6.74676448e-02f, 6.65505826e-02f, 1.82305519e-02f, 2.67352927e-02f, -8.07851925e-02f, 7.32880160e-02f, -4.97761257e-02f, 2.80759558e-02f, 6.46858737e-02f,
  1.07668601e-01f, 6.35293722e-02f, 8.44284594e-02f, 2.14706231e-02f, 4.24621925e-02f, 9.90891382e-02f, -1.32119739e-02f, 4.71367799e-02f, 1.16063550e-01f, 4.46427576e-02f,
  -3.68689857e-02f, 4.69884127e-02f, -8.03004801e-02f, 1.15074150e-01f, -5.06622344e-02f, -7.23829195e-02f, -8.39740969e-03f, 3.57991122e-02f, -2.95766222e-04f, 3.07764560e-02f,
  2.55516712e-02f, -5.01944274e-02f, -2.77975351e-02f, -1.72768775e-02f, 4.91157919e-02f, 7.59603530e-02f, -1.31674647e-01f, -1.36499643e-01f, -4.63066585e-02f, -6.28134012e-02f,
  4.04809006e-02f, -3.19479182e-02f, -3.34608741e-02f, -2.94849575e-02f, 4.97351289e-02f, -1.56179471e-02f, 8.84305537e-02f, -1.35307061e-02f, 2.08317805e-02f, 9.19317603e-02f,
  6.24262379e-04f, -2.33920515e-02f, 4.67035584e-02f, -1.92809626e-02f, 7.68794417e-02f, -4.76906896e-02f, 1.35924127e-02f, 1.05137959e-01f, -1.99223198e-02f, 7.54627632e-03f,
  5.63185811e-02f, 1.15917530e-02f, 9.77967232e-02f, -2.42272913e-02f, 6.54633567e-02f, 5.05893640e-02f, 9.61528346e-02f, -6.89887330e-02f, 1.08646519e-01f, 2.73643085e-03f,
  -3.00868917e-02f, -2.48593539e-02f, 4.38633971e-02f, -6.75406903e-02f, -7.11336732e-02f, -8.92459974e-03f, 6.91476315e-02f, 5.42813353e-02f, 6.87888265e-02f, -2.56156605e-02f,
  -6.22414611e-02f, 3.36815454e-02f, -2.85679940e-02f, -1.46825416e-02f, -3.55949579e-03f, -6.29678741e-02f, -5.02865501e-02f, 4.59712557e-02f, 7.64012411e-02f, -2.89776903e-02f,
  -5.33715077e-03f, 3.06545310e-02f, 9.87284165e-03f, -2.36985181e-02f, 6.92884922e-02f, 8.83797407e-02f, -1.79040144e-04f, -3.23952250e-02f, 6.27776459e-02f, 4.54524718e-02f,
  3.50280590e-02f, -4.13325205e-02f, 3.78643200e-02f, 3.03420965e-02f, 1.81495752e-02f, 3.98925655e-02f, -1.03373835e-02f, 4.09725942e-02f, -2.69029737e-02f, 1.56909488e-02f,
  -1.99381132e-02f, -1.23736607e-02f, 5.06405570e-02f, 2.72333827e-02f, -4.96790223e-02f, 4.07988243e-02f, 3.35720405e-02f, -5.46424501e-02f, 1.18726715e-02f, -6.09982051e-02f,
  5.42277917e-02f, 7.74981529e-02f, -4.82785963e-02f, 7.45031089e-02f, -6.18780367e-02f, -1.75044630e-02f, -4.43025082e-02f, -1.24936141e-02f, 1.06429979e-02f, -7.35664964e-02f,
  1.03880145e-01f, 7.00005516e-02f, 5.22965714e-02f, -3.11511699e-02f, -3.11507694e-02f, 1.45298153e-01f, 3.76662165e-02f, -8.53937701e-04f, 1.25866309e-01f, 8.21726304e-03f,
  -6.48883507e-02f, 8.46729055e-02f, 2.19665393e-02f, -5.59851527e-03f, 1.01985395e-01f, 4.76590693e-02f, 9.62993577e-02f, 8.07099044e-02f, -2.86680106e-02f, -3.86238769e-02f,
  3.41576971e-02f, 1.95136145e-02f, -2.83099506e-02f, 2.71461327e-02f, -2.29299022e-03f, -9.29387733e-02f, -1.97392907e-02f, 8.21925923e-02f, -3.74808013e-02f, 1.44988261e-02f,
  1.50017282e-02f, 1.16188012e-01f, 9.43144858e-02f, -1.75855793e-02f, 1.04006782e-01f, 1.00363895e-01f, 6.42952472e-02f, -3.78454104e-02f, 7.16200247e-02f, 1.48104792e-02f,
  -4.59171981e-02f, 2.52442230e-02f, -8.75239819e-03f, 5.14783412e-02f, -5.13255373e-02f, -2.11404022e-02f, 8.90484527e-02f, -4.65796366e-02f, 1.80798303e-02f, -1.71320029e-02f,
  3.70332375e-02f, -9.09995958e-02f, -9.20264982e-03f, 1.58531256e-02f, 8.09002966e-02f, -4.93082181e-02f, 8.26439187e-02f, -4.94425520e-02f, 1.07551580e-02f, -2.36473810e-02f,
  7.08225444e-02f, 1.95436925e-03f, 1.24986619e-01f, 5.34079596e-02f, 7.49951079e-02f, -1.02237314e-01f, -6.87570497e-02f, 1.11575304e-02f, 6.24395385e-02f, -4.93790768e-02f,
  -5.20762727e-02f, 2.13396996e-02f, -4.35526334e-02f, -9.85358506e-02f, -7.41102844e-02f, 1.27298841e-02f, -3.92094851e-02f, -6.32410869e-02f, -6.31083846e-02f, 4.21967395e-02f,
  8.20687860e-02f, -4.37248126e-03f, -4.27419394e-02f, -6.69968724e-02f, 5.83153553e-02f, 6.40244931e-02f, -7.94932023e-02f, -8.61485228e-02f, -6.06550202e-02f, -4.00968492e-02f,
  3.61609906e-02f, 1.30573884e-02f, 3.22665796e-02f, 2.71379128e-02f, -2.19376255e-02f, 1.42384665e-02f, -5.18845581e-02f, -4.13667597e-02f, 8.97651687e-02f, 6.79722801e-02f,
  2.28003580e-02f, -6.80286735e-02f, -7.02713728e-02f, -1.36701120e-02f, 3.18558291e-02f, 1.04449414e-01f, 6.67634308e-02f, -6.43398464e-02f, 4.42008395e-03f, -4.12206687e-02f,
  3.84416021e-02f, -3.72325294e-02f, 3.99534823e-03f, -3.53757590e-02f, -4.95300032e-02f, -1.08942628e-01f, 1.38939517e-02f, 6.09404631e-02f, 8.02622288e-02f, 3.02206390e-02f,
  -1.45608885e-03f, 2.39359979e-02f, -5.95199354e-02f, -3.27046699e-04f, 8.79545975e-03f, -3.11002154e-02f, -1.24535948e-01f, -1.67941421e-01f, -8.02030414e-02f, 1.07251950e-01f,
  -3.15906107e-02f, 1.96919948e-01f, -3.18106562e-02f, -1.89601302e-01f, -3.60077351e-01f, -2.32096478e-01f, -1.37532830e-01f, -3.87693159e-02f, 1.10422568e-02f, -6.16336428e-03f,
  9.32420837e-04f, -2.02977926e-01f, -8.69324580e-02f, 4.48403880e-02f, -9.50628892e-03f, 8.52910206e-02f, -4.37949896e-02f, 6.76752031e-02f, 8.92845765e-02f, -8.12196210e-02f,
  -7.24369660e-02f, 3.61441597e-02f, 8.32541194e-03f, 1.10719956e-01f, 1.38722686e-02f, 5.85197061e-02f, -1.69883389e-02f, 3.29538882e-02f, 7.56670311e-02f, 2.19666120e-03f,
  1.15789384e-01f, -3.25534455e-02f, -1.04215719e-01f, -4.32924740e-03f, 3.10696047e-02f, 1.36292269e-02f, 4.98825125e-02f, 2.88902130e-02f, 8.65529329e-02f, -4.67051342e-02f,
  1.05031095e-01f, 9.29148346e-02f, 7.32994378e-02f, 1.13871478e-01f, -3.80633175e-02f, 3.85116488e-02f, 4.73012440e-02f, 3.61870369e-03f, 1.82260517e-02f, -2.62870323e-02f,
  1.26899704e-02f, 3.17403600e-02f, -1.03011169e-02f, 5.71197830e-02f, -6.64022490e-02f, -2.16427147e-02f, -1.21094938e-02f, 4.35401648e-02f, -4.14264388e-02f, -9.11521912e-02f,
  2.10159719e-02f, 7.81739950e-02f, 3.70632298e-02f, -4.66172630e-03f, -2.54915096e-02f, -1.61513481e-02f, 2.99683418e-02f, -2.37558987e-02f, -5.27874418e-02f, 6.56682579e-03f,
  -1.07950434e-01f, -1.46618821e-02f, -2.08543055e-02f, -7.35093281e-02f, -8.08544233e-02f, -1.57532003e-02f, 4.83753867e-02f, -1.73325352e-02f, -1.12735378e-02f, -9.60551277e-02f,
  -6.92476481e-02f, 3.88258509e-02f, -6.48877621e-02f, -3.47510129e-02f, -9.99051780e-02f, -5.08234687e-02f, -4.44862880e-02f, -9.78191122e-02f, -1.26627684e-01f, -3.33663449e-02f,
  -3.62019055e-02f, 6.11922592e-02f, 3.70988175e-02f, 7.62456879e-02f, -3.07863168e-02f, -1.22154132e-02f, -1.01109505e-01f, -5.37909903e-02f, -3.48601900e-02f, 5.02125658e-02f,
  -1.91578139e-02f, -5.37444726e-02f, -6.49212115e-03f, -5.58475479e-02f, -5.48922271e-03f, -1.98873021e-02f, 6.24049194e-02f, 2.15512533e-02f, 6.60142377e-02f, 2.24622246e-02f,
  -5.21352030e-02f, -6.31201789e-02f, -1.39116362e-01f, -2.63975915e-02f, -1.69213176e-01f, -3.25789750e-01f, -3.09630424e-01f, -4.75799330e-02f, 1.97171792e-01f, 1.25924885e-01f,
  -1.25926405e-01f, 1.68693960e-01f, -3.33857816e-03f, -1.52158827e-01f, -2.72908937e-02f, 1.18770815e-01f, -3.02043140e-01f, -4.91842814e-02f, 8.87687504e-02f, -2.19581872e-01f,
  -1.09582156e-01f, -5.74799217e-02f, -1.83707461e-01f, -8.38557780e-02f, -1.60301909e-01f, -3.88451852e-02f, 1.60762742e-02f, -1.73774734e-01f, -1.53246149e-01f, -3.68486233e-02f,
  -1.02443650e-01f, 1.39270872e-01f, -6.18852302e-02f, -3.75000667e-03f, -1.94032099e-02f, -4.76745479e-02f, -5.28920256e-02f, -5.11241928e-02f, 7.84612447e-02f, 1.78455133e-02f,
  -3.50820757e-02f, 4.53182682e-02f, -2.34080944e-02f, -7.72976410e-03f, -6.54867571e-03f, -5.66953868e-02f, -2.06507649e-02f, 5.39638894e-03f, -4.47214488e-03f, 2.38808412e-02f,
  -7.84428045e-02f, 2.16663368e-02f, -7.24530444e-02f, 1.25126287e-01f, -7.20036179e-02f, -6.34751841e-02f, 1.79303102e-02f, 6.01263298e-03f, -5.30018955e-02f, 7.87425563e-02f,
  -4.60107028e-02f, -2.39880960e-02f, 4.27919813e-02f, -8.17165524e-02f, 1.35844089e-02f, -3.93790901e-02f, 6.05978481e-02f, -1.41777517e-02f, -4.80730366e-03f, 3.69397625e-02f,
  7.30022490e-02f, 3.35665196e-02f, -3.29047181e-02f, 6.13582553e-03f, 2.44094301e-02f, -1.07210847e-02f, -9.05057937e-02f, 8.50045979e-02f, -3.39891203e-03f, 3.78395841e-02f,
  -6.19808119e-03f, 3.62848304e-02f, 4.04069871e-02f, -9.10528284e-03f, -5.79923876e-02f, 4.63365316e-02f, -4.36752774e-02f, 3.34667824e-02f, -3.09136380e-02f, -3.24842334e-02f,
  -8.33626240e-02f, 1.68387573e-02f, 1.40661723e-03f, 4.95942943e-02f, -1.65377054e-02f, -6.31476864e-02f, -8.18616524e-03f, -2.35756468e-02f, -1.09482380e-02f, -6.00383282e-02f,
  -6.19331375e-03f, 8.69237632e-02f, 1.59356594e-02f, -1.38334313e-03f, -1.81941800e-02f, -1.19558610e-02f, 4.67255116e-02f, 6.49301484e-02f, 8.99339467e-02f, -5.17775957e-03f,
  9.30851623e-02f, -2.18515266e-02f, 8.84096622e-02f, -2.12242198e-03f, 4.49667685e-02f, -2.57937796e-02f, -5.92618762e-03f, 5.44527136e-02f, -1.84632633e-02f, -4.73878905e-03f,
  -6.11041933e-02f, 1.68179139e-01f, -7.56179467e-02f, 1.74572468e-01f, 8.44575744e-03f, -1.00108208e-02f, 4.85660955e-02f, -2.10967511e-02f, 7.44810700e-02f, 2.46267766e-02f,
  1.05505802e-01f, -1.47740124e-02f, 3.56739797e-02f, 1.85621589e-01f, 1.41898319e-01f, 7.43212327e-02f, 1.85228929e-01f, -3.35160270e-02f, 6.42686933e-02f, 1.02482840e-01f,
  -1.07810097e-02f, 1.20922543e-01f, -4.63193096e-02f, -8.31370428e-02f, -3.68839614e-02f, -7.82021359e-02f, -3.85649316e-02f, -7.23636672e-02f, 2.62692310e-02f, 2.21843012e-02f,
  2.06633937e-02f, 1.04929902e-01f, -5.95493838e-02f, 3.96404006e-02f, 1.86899472e-02f, -1.96535904e-02f, -6.08161353e-02f, 1.26914158e-02f, -6.53906912e-02f, -7.47960284e-02f,
  6.42018095e-02f, 1.79380309e-02f, 9.44127440e-02f, -4.97947223e-02f, -6.97089285e-02f, 2.59639118e-02f, 5.12926243e-02f, -2.61584818e-02f, -5.80211245e-02f, 1.23352138e-02f,
  7.21821338e-02f, -5.34238778e-02f, 4.97541800e-02f, 7.87060484e-02f, 6.46017492e-02f, 4.72673029e-02f, -4.26554903e-02f, -2.01873737e-03f, 2.66604871e-02f, 1.01192847e-01f,
  -6.20522983e-02f, 2.88344063e-02f, -5.72284199e-02f, 7.06429966e-03f, 1.24765362e-03f, -2.49989852e-02f, -5.33255227e-02f, -6.84608072e-02f, 2.16726530e-02f, -2.17262842e-02f,
  -2.10192259e-02f, -5.01963943e-02f, 5.93009181e-02f, 1.00185927e-02f, 3.71004529e-02f, 1.06899403e-02f, -7.74031356e-02f, -5.28452806e-02f, -6.43477077e-04f, -1.40779801e-02f,
  -1.04571030e-01f, 4.42684218e-02f, -4.13406380e-02f, -8.48290920e-02f, -3.23208161e-02f, -1.01949885e-01f, -3.51904556e-02f, -4.44761924e-02f, 6.64944900e-03f, 4.65188883e-02f,
  1.19665660e-01f, 4.07102033e-02f, 5.93791045e-02f, -4.36573327e-02f, -4.54524253e-03f, -2.16025934e-02f, 2.98050251e-02f, 5.31258546e-02f, -6.83668479e-02f, -7.18756998e-03f,
  8.14399049e-02f, 1.03668347e-02f, 7.71123990e-02f, -4.83213253e-02f, -6.03844561e-02f, -4.55505727e-03f, -3.67993838e-03f, 1.01094292e-02f, 2.37794649e-02f, 4.71550971e-02f,
  -4.15376462e-02f, 1.96070131e-02f, -4.12307940e-02f, 8.63473937e-02f, 8.53514373e-02f, -4.59137149e-02f, 5.03971167e-02f, -3.50695662e-02f, 7.04473704e-02f, -6.66665882e-02f,
  -9.15505812e-02f, 8.02176818e-02f, -2.79988460e-02f, 7.07199425e-02f, 1.73763260e-02f, -1.63374543e-01f, -1.57901451e-01f, 5.41054755e-02f, -6.63919449e-02f, -1.18009532e-02f,
  4.94626760e-02f, 1.43425530e-02f, 9.73120448e-04f, 8.25554207e-02f, 6.97757453e-02f, 5.19167706e-02f, -9.95065086e-03f, -4.20148559e-02f, -5.14739491e-02f, 1.19725555e-01f,
  7.25395679e-02f, 1.43867701e-01f, 1.67606533e-01f, 4.04036231e-02f, -3.53682451e-02f, 4.57492322e-02f, 1.31723523e-01f, 8.59352425e-02f, 1.17670819e-01f, -4.86355089e-02f,
  7.60400593e-02f, 1.09201930e-01f, -1.10048698e-02f, -7.23903701e-02f, 7.68497139e-02f, -2.30338778e-02f, -1.10537652e-02f, -5.16545288e-02f, 4.05415446e-02f, 5.67091256e-02f,
  2.91454215e-02f, -5.85137457e-02f, 4.86580096e-02f, 4.20963801e-02f, -6.94626421e-02f, 4.10929136e-02f, 6.77580386e-02f, -5.09768762e-02f, -7.26974290e-03f, 3.57271433e-02f,
  1.07917069e-02f, 4.88110930e-02f, 1.70511287e-02f, -3.97562645e-02f, 4.53959592e-02f, -5.35990996e-03f, -3.83807607e-02f, -5.96826337e-02f, 1.71579551e-02f, -2.74183657e-02f,
  6.59774691e-02f, -5.05892932e-02f, -2.40374003e-02f, 3.46871540e-02f, 1.24593340e-02f, -6.84596039e-03f, -8.43545422e-03f, 5.03974557e-02f, 6.52285293e-03f, 3.15364823e-02f,
  2.29982473e-02f, -3.09295114e-02f, 1.36562786e-03f, -1.17787812e-02f, 7.44744614e-02f, -7.42683634e-02f, 1.53410239e-02f, 6.42488822e-02f, 1.38073461e-02f, -1.27744833e-02f,
  -2.10767481e-02f, 3.67218070e-02f, 5.04712351e-02f, 1.24025485e-02f, -1.56787634e-02f, -2.52438765e-02f, 2.07665469e-02f, -5.17637543e-02f, 3.72316763e-02f, -3.47570553e-02f,
  6.91170171e-02f, 1.80088118e-01f, 4.49922383e-02f, -3.52559239e-02f, -2.75438279e-02f, -5.47129922e-02f, -4.84208539e-02f, -3.43784392e-02f, 3.90715227e-02f, 5.34507399e-03f,
  8.66468996e-02f, -5.26656285e-02f, 8.94947499e-02f, 5.52192666e-02f, -6.11650273e-02f, -4.37634997e-02f, 2.62267198e-02f, -4.04104479e-02f, 7.72627592e-02f, 1.07944764e-01f,
  3.99681292e-02f, -2.74266545e-02f, -5.18903285e-02f, 2.40139966e-03f, 3.21522132e-02f, -4.36139777e-02f, 1.88072510e-02f, 9.24059674e-02f, 8.84180441e-02f, -2.59906724e-02f,
  -3.47715259e-01f, 1.49736524e-01f, 3.82474661e-02f, -3.65282148e-02f, -1.68142747e-02f, 7.02061355e-02f, 1.34612396e-01f, -5.09110838e-02f, -1.42677084e-01f, 1.26719177e-01f,
  -1.09824063e-02f, -1.60708785e-01f, 4.42694761e-02f, 1.15821145e-01f, -7.84593821e-02f, 1.58542216e-01f, 1.43821701e-01f, -4.57544886e-02f, 1.24511652e-01f, -1.29584923e-01f,
  3.79265584e-02f, 2.26049926e-02f, 1.53654799e-01f, 4.24519517e-02f, -5.73349185e-02f, -3.54097262e-02f, -7.64767528e-02f, -6.50734827e-02f, -5.93195744e-02f, 2.30322662e-03f,
  -3.10801808e-02f, -4.73173633e-02f, -3.42789888e-02f, -5.58706447e-02f, 1.98579412e-02f, -1.40495911e-01f, 1.72478296e-02f, 4.48374525e-02f, -4.18736711e-02f, -5.75263239e-02f,
  -1.36117592e-01f, 3.24030519e-02f, -2.97079887e-02f, 1.42406868e-02f, -3.03053018e-02f, 4.85566556e-02f, -6.33060858e-02f, 6.06340356e-02f, -4.23269905e-02f, 1.08053155e-01f,
  3.88365127e-02f, 1.05023474e-01f, -1.75477695e-02f, 7.40309060e-02f, 4.52123992e-02f, -5.57887927e-02f, 8.19337070e-02f, 3.61197032e-02f, 3.30813676e-02f, -2.72723809e-02f,
  7.64886886e-02f, 5.46358759e-03f, -1.37343584e-02f, -2.84508076e-02f, -1.83558557e-02f, 1.26150139e-02f, -5.07916100e-02f, 3.09478752e-02f, -1.01547353e-02f, -2.90486086e-02f,
  6.31903931e-02f, 2.35479251e-02f, 8.70032515e-03f, -3.05990279e-02f, -4.19445820e-02f, -2.56835725e-02f, 3.56467515e-02f, -4.07463685e-02f, 2.15015393e-02f, -2.09753271e-02f,
  -2.94694360e-02f, 6.34282082e-02f, 8.81736428e-02f, 9.27945524e-02f, 3.02350242e-02f, -8.04958940e-02f, 3.71717811e-02f, 1.05515562e-01f, -3.51211452e-03f, -1.69140697e-02f,
  -1.64911710e-03f, -1.20120160e-01f, -5.90480901e-02f, 2.12314706e-02f, 3.33381519e-02f, -5.12424344e-03f, -2.17209645e-02f, -8.34723338e-02f, -9.69356205e-03f, 5.65073341e-02f,
  -2.21739281e-02f, 1.12650646e-02f, -5.59548587e-02f, -1.07778292e-02f, 5.41527048e-02f, -1.38732065e-02f, -7.70192146e-02f, -1.06900223e-01f, -3.10891438e-02f, 1.22127477e-02f,
  5.87034523e-02f, -2.81679891e-02f, 4.28448059e-03f, 2.47048624e-02f, -7.59552345e-02f, -3.77252847e-02f, -7.20980167e-02f, -6.89715892e-02f, -1.76276993e-02f, 3.74538898e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  2.39191160e-01f, -4.54680920e-02f, 2.02254411e-02f, -2.92481035e-02f, 8.79782960e-02f, -3.76658551e-02f, 5.40408716e-02f, 1.55662060e-01f, 1.91264719e-01f, -4.51993011e-03f,
  9.15416032e-02f, 1.44198537e-01f, 1.68361589e-01f, 7.18199909e-02f, 7.19484761e-02f, 1.28656784e-02f, 6.72149509e-02f, 2.28016764e-01f, 1.13391459e-01f, 1.39108256e-01f,
  2.05903187e-01f, 2.30544806e-02f, 1.43048838e-01f, -5.43131866e-02f, 7.67117925e-03f, 1.87977806e-01f, 7.41315037e-02f, 9.50780660e-02f, -4.22685221e-03f, 5.86335436e-02f,
  5.38934059e-02f, 6.39110729e-02f, 8.14751908e-02f, -4.68354207e-03f, 3.34432423e-02f, 7.37619847e-02f, 7.23012686e-02f, 6.83960244e-02f, -5.14862202e-02f, 3.90394032e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.60321633e-03f, 4.58987057e-02f, 4.49524485e-02f, -7.42735118e-02f, 8.29030052e-02f, 8.85867551e-02f, 1.28986225e-01f, -9.53480899e-02f, 1.18997302e-02f, -8.82072225e-02f,
  1.06149316e-01f, 1.39750868e-01f, 1.06736295e-01f, -1.11603245e-01f, -7.18582198e-02f, 1.38522968e-01f, -5.85608222e-02f, 6.35893792e-02f, 5.51410168e-02f, -3.90872248e-02f,
  1.51035143e-02f, -6.28053024e-02f, -1.43827289e-01f, -1.31248102e-01f, 7.74885938e-02f, -1.54006362e-01f, -1.63536575e-02f, 4.80079986e-02f, -1.49776354e-01f, 2.89405249e-02f,
  -2.86908131e-02f, 1.32081538e-01f, -1.28434345e-01f, 1.12730525e-01f, 1.67957157e-01f, 1.26567567e-02f, 1.57599449e-01f, -7.35674845e-03f, 7.21690580e-02f, 9.61730182e-02f,
  1.34972379e-01f, 1.70043260e-01f, 1.47840092e-02f, 1.18669584e-01f, 6.46570921e-02f, -1.57396402e-02f, 6.87298849e-02f, 1.38795137e-01f, -6.15422018e-02f, -5.90490252e-02f,
  5.21708466e-03f, -1.77266687e-01f, 2.07660049e-02f, -5.61303049e-02f, 5.02047241e-02f, -1.07948862e-01f, -1.20709769e-01f, -1.02578022e-01f, 4.39872481e-02f, -1.27288222e-01f,
  -2.38324031e-01f, -1.24630276e-02f, -5.24361357e-02f, -1.01445772e-01f, -8.25325325e-02f, 2.65736766e-02f, 6.94969371e-02f, 4.73422632e-02f, -7.41180405e-02f, -3.15138958e-02f,
  -1.13790907e-01f, -8.22006911e-02f, -1.07578160e-02f, 6.02599084e-02f, 3.09903640e-03f, -1.75296471e-01f, -9.32030827e-02f, 6.29392564e-02f, 7.01352209e-02f, 1.28494382e-01f,
  -8.76476243e-02f, 1.05805509e-01f, -2.16689378e-01f, -1.83978360e-02f, -7.17365667e-02f, -1.72893424e-02f, 6.40341488e-04f, -1.53890237e-01f, 8.82311314e-02f, -5.14193214e-02f,
  5.16047664e-02f, -1.20415032e-01f, -8.10342282e-02f, -8.55290368e-02f, 2.01185793e-01f, 7.13971304e-03f, -1.08246051e-01f, -2.35202573e-02f, 2.09898204e-02f, 1.51767194e-01f,
  1.87648162e-01f, 1.98450871e-02f, 1.82055071e-01f, -1.29960194e-01f, 1.05427057e-01f, 2.56202042e-01f, 8.60331878e-02f, 1.84268981e-01f, -2.17196912e-01f, -3.35427821e-02f,
  1.08071499e-01f, -3.94533649e-02f, -5.42700589e-02f, 4.59153056e-02f, 8.57501701e-02f, -1.94228441e-01f, 5.54217724e-03f, 7.77022913e-02f, -6.30813390e-02f, -1.20175943e-01f,
  5.96440844e-02f, 2.14962382e-02f, 8.88978876e-03f, -1.52676076e-01f, -9.08355601e-03f, 1.10200439e-02f, 8.75705108e-02f, -1.30012184e-01f, -1.76622253e-02f, 1.18871771e-01f,
  1.97827816e-02f, 3.55073884e-02f, 7.28563368e-02f, -1.05423443e-01f, 5.28582223e-02f, 4.13296521e-02f, 8.15098956e-02f, 1.76218823e-01f, 9.93216410e-02f, 7.29912594e-02f,
  9.30169225e-02f, -1.74608782e-01f, -1.40259162e-01f, 1.25761390e-01f, 5.71773127e-02f, 1.45455092e-01f, 1.02299735e-01f, -8.77479091e-02f, -1.26714811e-01f, -3.05474121e-02f,
  -4.86214133e-03f, -2.13913873e-01f, 1.24460936e-01f, 1.94816329e-02f, -8.04396272e-02f, 1.88998818e-01f, -7.02832476e-04f, -2.29319874e-02f, 1.36816467e-03f, 1.42395124e-01f,
  -1.90200105e-01f, -4.55625877e-02f, 1.60592660e-01f, -1.56766281e-01f, 1.04002398e-03f, -3.98497507e-02f, 1.13429248e-01f, -9.36461911e-02f, -1.44003376e-01f, -1.86122864e-01f,
  -5.19460887e-02f, 1.51706740e-01f, -3.04494083e-01f, -9.05182436e-02f, 5.72210737e-02f, -1.38983890e-01f, -1.05388835e-01f, 1.99653357e-02f, 1.16429143e-01f, 3.27167958e-02f,
  -9.60935431e-04f, -4.11720984e-02f, -6.16995469e-02f, -1.67346001e-01f, 2.06742048e-01f, 1.49547279e-01f, 1.39746994e-01f, -4.64276504e-03f, 1.00629181e-01f, 1.09800629e-01f,
  -1.27894282e-01f, -1.70993820e-01f, -1.06838800e-01f, -9.10102054e-02f, -5.53160021e-03f, -5.37309945e-02f, 3.66093963e-02f, -1.11303098e-01f, -7.86867291e-02f, -2.97875293e-02f,
  -8.86480883e-02f, 1.90804321e-02f, 6.75255135e-02f, 2.50416547e-01f, 4.05675322e-02f, -2.14955688e-01f, -3.45860988e-01f, 1.31500512e-01f, 3.08279432e-02f, -1.99859828e-01f,
  1.67092681e-01f, -7.17577012e-03f, 1.39290810e-01f, 7.73521513e-02f, 2.76545212e-02f, -1.57169655e-01f, 2.46523350e-01f, -6.19047210e-02f, -2.45763431e-03f, 1.76035911e-02f,
  -1.09024979e-01f, -9.63896811e-02f, -1.12207174e-01f, 4.03977223e-02f, -3.91196012e-02f, 8.36491399e-03f, 2.43051872e-01f, -5.43016605e-02f, 9.91387293e-02f, 9.61241648e-02f,
  -1.11826444e-02f, -9.22258347e-02f, 1.63204491e-01f, -1.00801818e-01f, 4.32333164e-02f, 1.25358149e-01f, -1.00575067e-01f, 5.54874018e-02f, -1.68890461e-01f, 1.14915788e-01f,
  4.97785173e-02f, -1.07904233e-01f, 1.07736737e-01f, -1.15976349e-01f, -2.20057778e-02f, 9.27941799e-02f, 5.05584627e-02f, 8.41872990e-02f, 1.00095987e-01f, 3.64686474e-02f,
  1.23037256e-01f, 1.06201172e-02f, -2.44916767e-01f, -1.08319908e-01f, 3.92366126e-02f, 1.24210708e-01f, 2.72860937e-02f, -1.76252335e-01f, -1.26935437e-01f, 2.08401699e-02f,
  5.01813442e-02f, 8.61672452e-04f, 2.94990372e-02f, 5.42056300e-02f, 1.19650699e-01f, -1.81674317e-01f, 1.17208801e-01f, 1.21765971e-01f, -1.87865034e-01f, 2.27212355e-01f,
  5.43259606e-02f, -1.17961287e-01f, -1.24812335e-01f, -1.93206936e-01f, -4.89566438e-02f, 6.04542196e-02f, -4.47657658e-03f, -5.65631874e-02f, 2.90839709e-02f, 3.03285569e-01f,
  -1.17447704e-01f, 2.86565907e-02f, -1.15482491e-02f, -6.81005865e-02f, 1.38371035e-01f, -1.03054628e-01f, -9.39585567e-02f, -1.22925654e-01f, 2.84111261e-01f, 7.89310038e-02f,
  -8.56330767e-02f, -7.48241991e-02f, -8.07088986e-03f, 4.83532771e-02f, -1.49644732e-01f, 4.93834205e-02f, 7.82798827e-02f, -1.55568287e-01f, -1.57467633e-01f, 1.22708604e-01f,
  1.88407138e-01f, 1.20664075e-01f, -1.34036914e-01f, 1.17867619e-01f, 9.44506899e-02f, -1.82903528e-01f, -1.36497185e-01f, 1.30439848e-01f, -7.78562054e-02f, 1.20631903e-01f,
  4.82459739e-02f, 5.37781231e-02f, -7.99983218e-02f, -7.80482888e-02f, -8.41767807e-03f, 1.59480438e-01f, 1.28702343e-01f, -1.06370024e-01f, 1.44372270e-01f, 7.38631710e-02f,
  3.11721116e-02f, -4.17827703e-02f, -2.10083444e-02f, 8.96427557e-02f, -4.19667438e-02f, 1.27977118e-01f, 1.27277225e-01f, 3.02337687e-02f, 1.59739926e-01f, 4.74594720e-03f,
  -1.54260276e-02f, 1.76586866e-01f, 7.95883015e-02f, -1.16914688e-02f, -1.83959410e-01f, 6.28366619e-02f, 3.31356972e-02f, -1.12696797e-01f, 1.73327625e-01f, -1.96709558e-02f,
  -6.92572296e-02f, -1.05888054e-01f, 2.84782767e-01f, 6.73656687e-02f, -5.95602617e-02f, -1.66062880e-02f, -1.09087206e-01f, -9.65359509e-02f, -4.30184938e-02f, 4.91837114e-02f,
  1.14259869e-02f, 6.17588758e-02f, -6.42425716e-02f, 3.73647511e-02f, 1.45205155e-01f, -9.18124393e-02f, 2.64960043e-02f, 3.48132709e-03f, -8.29432067e-03f, -8.38036165e-02f,
  -9.41090006e-03f, 8.43432471e-02f, 8.18895921e-02f, -3.58383693e-02f, 2.97456473e-01f, 1.84959590e-01f, -6.94960877e-02f, 1.16386123e-01f, 1.45763859e-01f, -1.57340318e-01f,
  9.93278474e-02f, 1.66204423e-01f, -1.10004202e-01f, -8.44497979e-02f, 6.82459697e-02f, 7.08085671e-02f, 4.98491414e-02f, 2.65701190e-02f, -1.02924459e-01f, 1.41499415e-01f,
  1.37668356e-01f, -9.23803598e-02f, -8.99154991e-02f, -1.46466434e-01f, -1.71048239e-01f, 1.21974953e-01f, 5.92677817e-02f, -7.23153502e-02f, -1.33630350e-01f, -1.47895709e-01f,
  -7.25208607e-04f, -2.02975282e-03f, 3.81540619e-02f, 1.74896330e-01f, 1.02595992e-01f, 2.74490938e-02f, 7.15638623e-02f, -1.02799818e-01f, -2.88300574e-01f, 1.22540876e-01f,
  3.11742630e-02f, 6.51647225e-02f, 7.60007277e-02f, 4.75178920e-02f, -9.79066044e-02f, 1.21961661e-01f, 1.68919474e-01f, -1.71417385e-01f, 1.79872662e-02f, -9.27261412e-02f,
  -1.18281439e-01f, -3.83506529e-02f, -1.47754587e-02f, 1.18560102e-02f, 8.12884718e-02f, 1.19252475e-02f, -2.03807965e-01f, -1.33815855e-01f, 1.64288953e-01f, -4.86764126e-02f,
  -6.72216564e-02f, 1.03701144e-01f, 1.29686847e-01f, 7.23200962e-02f, -6.38613999e-02f, -1.78273082e-01f, -3.70887630e-02f, 1.25943288e-01f, -2.36541286e-01f, -3.15827616e-02f,
  -7.98666775e-02f, 1.02450754e-02f, 9.29749459e-02f, -3.19566242e-02f, 1.19953781e-01f, 3.68425949e-03f, -3.12347878e-02f, 1.57986823e-02f, -5.84994406e-02f, 1.20446254e-02f,
  1.48961216e-01f, 4.61852290e-02f, 8.19444284e-03f, 1.28072321e-01f, 1.12495467e-01f, -1.23355031e-01f, -2.72070337e-02f, -1.10951893e-01f, 1.15926072e-01f, -1.48505524e-01f,
  -6.52760118e-02f, -7.24431947e-02f, 1.97873190e-02f, -1.22412995e-01f, 1.45752225e-02f, 6.42818511e-02f, -1.57288387e-01f, -4.37170900e-02f, 1.20884329e-01f, 1.75764691e-02f,
  -1.53235465e-01f, -2.27446720e-01f, -1.54629305e-01f, -1.58309311e-01f, 1.69995472e-01f, 6.19852953e-02f, 3.41910161e-02f, 2.05102414e-01f, 7.29432628e-02f, 1.44785002e-01f,
  2.23950669e-02f, -2.70866871e-01f, -4.80531044e-02f, 9.89976302e-02f, 1.06843580e-02f, 6.96681291e-02f, 2.80343164e-02f, -1.15407906e-01f, 1.43730476e-01f, -1.14578642e-01f,
  -1.24880873e-01f, 9.45947990e-02f, 8.78378600e-02f, 1.08325332e-01f, -7.67157897e-02f, 5.21546416e-02f, -1.10183842e-02f, 1.46807671e-01f, -9.37991403e-03f, -2.98973322e-01f,
  5.08101173e-02f, 2.46039063e-01f, -2.65873909e-01f, 9.03941020e-02f, 1.12759396e-01f, -9.15277898e-02f, 8.88786167e-02f, 5.05383685e-02f, -2.01041386e-01f, 5.19186296e-02f,
  6.35116473e-02f, 1.26102030e-01f, 1.44281257e-02f, -9.60737094e-02f, -1.97188854e-02f, -1.18287161e-01f, -7.64555633e-02f, -5.67964539e-02f, 1.82090387e-01f, 2.91110184e-02f,
  2.31483895e-02f, 1.11350589e-01f, -2.07021851e-02f, 9.91033986e-02f, -2.61823107e-02f, 1.14557378e-01f, -1.32602841e-01f, 1.04449354e-02f, -6.29889369e-02f, -6.59066439e-02f,
  6.44980222e-02f, 8.34528580e-02f, -6.40213042e-02f, 6.45420253e-02f, -1.63760073e-02f, 9.26910266e-02f, 1.26224101e-01f, 3.28474969e-01f, -1.04676718e-02f, 7.19008595e-02f,
  -2.29801089e-02f, -3.03519927e-02f, 5.44808712e-03f, -2.05502525e-01f, 8.96299481e-02f, 1.52115062e-01f, 4.65510637e-02f, 3.40342522e-02f, 4.99186330e-02f, -7.04982281e-02f,
  7.43939281e-02f, -3.61804068e-02f, 7.96941593e-02f, 2.15265900e-02f, -8.03959593e-02f, -9.80682299e-03f, -2.63285805e-02f, -1.76330715e-01f, 1.88051403e-01f, 1.03217125e-01f,
  1.40426487e-01f, -2.48135421e-02f, 1.43344011e-02f, 2.23959416e-01f, -2.69986857e-02f, 7.52032921e-02f, -1.36392236e-01f, -4.59468700e-02f, 2.23028734e-02f, -7.84020126e-02f,
  1.46054570e-02f, 7.12456331e-02f, 8.35300907e-02f, -4.69640782e-03f, 2.65357760e-03f, -1.35804832e-01f, -1.37646288e-01f, -1.49699450e-01f, 1.55017525e-01f, 3.65009643e-02f,
  -8.48618597e-02f, -2.62666252e-02f, -2.67915726e-02f, 5.93159311e-02f, -2.16925759e-02f, -2.27241203e-01f, 1.21626630e-02f, 1.61177162e-02f, 2.97335740e-02f, -4.23250757e-02f,
  -9.12256762e-02f, 1.47947893e-02f, -4.85823639e-02f, -7.24964440e-02f, -6.25549927e-02f, -6.23761006e-02f, 1.60161525e-01f, -1.56813934e-01f, -2.48863965e-01f, -4.33108434e-02f,
  2.29654416e-01f, -3.18925798e-01f, -2.80522760e-02f, 6.87956810e-02f, 4.23065051e-02f, 1.80665135e-01f, -1.80418268e-02f, 1.50812432e-01f, -2.88322985e-01f, -8.01139772e-02f,
  4.68414761e-02f, 9.10067856e-02f, -1.24404974e-01f, -7.71989673e-02f, 8.02749489e-03f, 8.15812126e-02f, 4.15880829e-02f, -9.05288905e-02f, 2.70166993e-01f, 1.53661668e-01f,
  -2.29972899e-01f, 2.09058970e-02f, -1.84401110e-01f, -1.51280001e-01f, -6.16392680e-02f, 2.69652829e-02f, -8.06180462e-02f, -1.21753998e-01f, 1.04537550e-02f, -6.71864003e-02f,
  -2.53457110e-03f, -8.15768763e-02f, -1.01544008e-01f, 1.35133773e-01f, 4.84494120e-02f, 1.19013853e-01f, -1.80323347e-01f, 4.84877490e-02f, -8.66082758e-02f, 7.75592104e-02f,
  6.05832338e-02f, 1.78735912e-01f, -1.34924456e-01f, -7.68982396e-02f, 1.03324786e-01f, -1.72948942e-01f, 1.13426350e-01f, 1.56970099e-01f, 2.27549687e-01f, 1.76848337e-01f,
  -5.17978966e-02f, 5.43945208e-02f, 3.87693942e-02f, -3.99413407e-02f, -2.82021221e-02f, -1.57200154e-02f, 7.66978189e-02f, -1.02397956e-01f, -3.27039957e-02f, -1.90938674e-02f,
  -1.58967093e-01f, -1.57361850e-01f, -2.73964796e-02f, 5.79887256e-02f, 1.55291513e-01f, 1.43465295e-01f, -1.58876210e-01f, 2.56023612e-02f, 2.17676163e-02f, 1.28606126e-01f,
  6.48796111e-02f, 3.07928752e-02f, -9.54174399e-02f, -9.75370333e-02f, -1.60212200e-02f, -7.27739036e-02f, 1.23446947e-02f, 7.19643086e-02f, -2.84549575e-02f, -1.88257005e-02f,
  1.06166065e-01f, 1.00970797e-01f, -1.12600632e-01f, 9.88778397e-02f, 1.62128925e-01f, 1.84205789e-02f, 1.36742160e-01f, -6.71076551e-02f, 9.78887007e-02f, 6.65026680e-02f,
  1.10964872e-01f, 9.29472670e-02f, -7.82108903e-02f, 6.60554543e-02f, -3.89968753e-02f, -3.96541459e-03f, 1.13795167e-02f, 1.19311325e-01f, -1.20754831e-01f, 5.13152592e-02f,
  -7.20558316e-02f, 4.70101014e-02f, 8.88451487e-02f, -1.01371311e-01f, -9.97221991e-02f, 6.90050330e-03f, -2.12066658e-02f, 3.44964825e-02f, -5.28470241e-02f, -8.12994763e-02f,
  -5.05996384e-02f, -4.45723087e-02f, 1.75812878e-02f, -6.27469420e-02f, -1.60714351e-02f, -1.48613947e-02f, -9.22963992e-02f, 2.36847368e-03f, -5.76805510e-02f, -1.12978533e-01f,
  1.48061916e-01f, 8.85179043e-02f, -7.46368617e-02f, 4.29893136e-02f, -7.75821358e-02f, 3.92682329e-02f, 2.32598931e-01f, -1.71526775e-01f, -1.95313007e-01f, 7.48151867e-03f,
  -1.61679052e-02f, 7.27133229e-02f, 1.39689580e-01f, -1.02494620e-02f, -4.90682535e-02f, 8.30300897e-02f, 1.06944181e-02f, 5.87117067e-03f, 1.61997393e-01f, 1.28967185e-02f,
  1.01907834e-01f, 1.35576390e-02f, 1.27225325e-01f, 1.01389125e-01f, -1.83862954e-01f, 1.79012343e-02f, -4.18106094e-02f, 1.30581155e-01f, -3.62573452e-02f, -1.51112899e-01f,
  -1.22881606e-01f, 8.13894570e-02f, -1.18152522e-01f, 1.60246640e-01f, -8.25742632e-02f, -1.32593736e-01f, -8.08142722e-02f, -2.13821515e-01f, -8.57360289e-02f, 8.51042271e-02f,
  -1.26427025e-01f, 5.66151515e-02f, -1.18762270e-01f, 1.41776830e-01f, -2.90816762e-02f, -7.50037357e-02f, -5.01119234e-02f, -8.44524279e-02f, 1.16610058e-01f, -3.79394069e-02f,
  3.02709676e-02f, 1.32818799e-02f, -1.33761335e-02f, -7.90192187e-02f, -6.79697692e-02f, 1.48420660e-02f, -2.14262605e-02f, 8.30309764e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.16097659e-01f, 3.16981040e-02f, 7.50537543e-03f, 9.07291695e-02f, 8.90222266e-02f, 6.80210963e-02f, 1.75206929e-01f, 4.50317785e-02f, 9.36080515e-02f, 1.20681049e-02f,
  1.13629550e-01f, 1.10099554e-01f, 2.89135307e-01f, -1.31641284e-01f, -1.46258458e-01f, 7.93742314e-02f, 1.04866885e-01f, 1.05217829e-01f, -6.23715371e-02f, -1.70106322e-01f,
  -1.02370299e-01f, -5.56714740e-03f, -4.23688330e-02f, 2.39151027e-02f, 1.38198018e-01f, -5.10046668e-02f, 9.78824049e-02f, 1.06121734e-01f, -1.07217543e-01f, 1.13966949e-01f,
  1.38237223e-01f, 4.95115407e-02f, -5.50964475e-03f, 3.09987925e-02f, 2.06981465e-01f, -1.19129755e-01f, -3.85476835e-02f, 1.89554468e-01f, 1.87340036e-01f, 4.47752848e-02f,
  4.23164181e-02f, 1.80447497e-03f, 3.92764509e-02f, -6.59442842e-02f, -1.38219073e-01f, -3.15793976e-02f, -4.04312275e-02f, 1.13693401e-01f, -1.25151321e-01f, 2.15941176e-01f,
  6.43737763e-02f, -9.09143463e-02f, 7.71255791e-02f, 6.81583863e-03f, -3.20851826e-03f, -9.06080604e-02f, -1.91859948e-03f, 1.11807987e-01f, 1.28207698e-01f, -5.87993003e-02f,
  3.30446921e-02f, 9.77708772e-02f, -1.45246148e-01f, 1.05938176e-02f, 9.51818228e-02f, 1.25317022e-01f, 4.37993631e-02f, 7.13792965e-02f, 7.14773312e-02f, -3.41884643e-02f,
  -5.46456501e-02f, 1.10289425e-01f, 1.09531298e-01f, 9.03937668e-02f, 6.06296025e-02f, -1.37532875e-01f, 7.32194930e-02f, -1.75716914e-02f, 1.13463566e-01f, 8.11156258e-02f,
  4.02268730e-02f, 7.51023442e-02f, 2.98338756e-02f, 7.13238418e-02f, 1.62704781e-01f, -7.83202276e-02f, -1.74661446e-02f, -1.15864702e-01f, 5.23125008e-02f, 1.29075116e-02f,
  1.29506528e-01f, -1.22191824e-01f, -8.62594619e-02f, 1.16722241e-01f, -5.94737865e-02f, 4.98448014e-02f, 2.17967164e-02f, 1.17849745e-01f, 7.99761266e-02f, 1.45460963e-01f,
  1.86179094e-02f, -1.25003800e-01f, 8.16235617e-02f, -1.32221028e-01f, 1.03316590e-01f, 1.47624135e-01f, 2.74797436e-02f, 8.37988630e-02f, -9.45183188e-02f, -7.15522841e-02f,
  5.99505240e-03f, -9.86530483e-02f, 2.33965181e-02f, 8.51966739e-02f, -9.12889466e-02f, -1.12694673e-01f, 1.31308630e-01f, 7.78062940e-02f, -2.76762173e-02f, -7.37478435e-02f,
  -5.58528975e-02f, -4.44166325e-02f, -4.42923084e-02f, -1.46133095e-01f, -1.23417683e-01f, 6.57623187e-02f, 9.91628841e-02f, -5.33400103e-02f, -7.56360888e-02f, -6.61565587e-02f,
  1.08875625e-01f, 8.40984061e-02f, 1.51555359e-01f, 8.27565119e-02f, -9.81842428e-02f, 4.62553538e-02f, 1.64119720e-01f, -5.39355278e-02f, 5.64718321e-02f, 8.63451161e-04f,
  9.96177364e-03f, 1.69836178e-01f, 8.34734663e-02f, 1.28815742e-02f, -1.50191423e-03f, -8.14682171e-02f, -1.69979498e-01f, 3.58014293e-02f, -6.07438721e-02f, -1.02506995e-01f,
  2.18192600e-02f, 1.62171453e-01f, 8.01492855e-02f, -2.06814054e-02f, 1.31456003e-01f, -7.19810799e-02f, 7.80969486e-03f, -8.92418961e-04f, 2.31143422e-02f, -6.04551211e-02f,
  6.69612959e-02f, -5.97011298e-02f, 9.80369672e-02f, 5.33230230e-02f, -5.37191555e-02f, -2.96828058e-02f, -5.03242798e-02f, -2.35658493e-02f, 1.78235292e-01f, 7.09512234e-02f,
  -3.80261615e-02f, -1.23349175e-01f, -3.79457995e-02f, -2.58788522e-02f, -4.11567762e-02f, -3.79877612e-02f, 2.31848918e-02f, -5.56043833e-02f, -4.56987806e-02f, -8.78648087e-02f,
  -4.37624939e-02f, -8.78205448e-02f, 1.28370121e-01f, -3.43257561e-02f, -7.13157058e-02f, -9.25122201e-02f, 3.62652950e-02f, 6.80968836e-02f, -4.20592166e-02f, 1.47481449e-02f,
  1.97503090e-01f, -4.62632105e-02f, -2.77230293e-02f, 7.43616279e-03f, 3.95192169e-02f, 2.10727658e-02f, 7.32898340e-02f, -5.92935123e-02f, 1.10337928e-01f, -3.33867706e-02f,
  -4.43248153e-02f, -4.59912270e-02f, -5.15898280e-02f, -6.37557060e-02f, 9.64919329e-02f, 7.36076757e-02f, -4.78836708e-02f, 6.93101883e-02f, 7.60010555e-02f, 2.96621919e-02f,
  4.68725152e-02f, 5.73549755e-02f, -7.02724829e-02f, 1.25956729e-01f, -1.50838435e-01f, -1.16138451e-01f, 8.00372362e-02f, -2.96620540e-02f, -5.68282343e-02f, 1.12544097e-01f,
  3.34651731e-02f, -7.55879730e-02f, 8.63775387e-02f, -1.15399592e-01f, 5.77769764e-02f, 3.53389904e-02f, 2.59452164e-02f, 8.84403661e-02f, -9.28783417e-02f, -1.27779782e-01f,
  -1.01605631e-01f, -5.47890291e-02f, 4.31995206e-02f, 5.55234179e-02f, 1.25367299e-01f, 1.07394539e-01f, 9.49619040e-02f, 5.00691049e-02f, 4.52059284e-02f, 7.40142465e-02f,
  -5.31395487e-02f, -5.88514842e-02f, -8.61904770e-02f, -8.46300051e-02f, 1.04614355e-01f, -6.50364310e-02f, 5.10061085e-02f, 3.31901424e-02f, 6.74287751e-02f, -7.13575408e-02f,
  3.84981669e-02f, -1.03743702e-01f, 1.13181090e-02f, 3.18449251e-02f, -2.10284851e-02f, 9.84924510e-02f, -5.94900409e-03f, -8.11070800e-02f, 9.07822400e-02f, -9.39458087e-02f,
  5.75865172e-02f, 1.40591964e-01f, -4.15411703e-02f, 9.93176326e-02f, 1.68113291e-01f, -3.94491130e-04f, 2.68052034e-02f, 5.88258766e-02f, 7.93820992e-02f, 6.59833895e-03f,
  1.38648273e-02f, -5.26276231e-02f, 9.64580104e-02f, -9.46946815e-02f, 1.44805536e-01f, 1.26989946e-01f, 7.31885657e-02f, 1.61917612e-01f, 7.07886443e-02f, 1.46374375e-01f,
  2.93583293e-02f, 7.91936442e-02f, 1.07905775e-01f, -3.12905312e-02f, 1.67614311e-01f, 2.28512790e-02f, -1.38367221e-01f, -7.28549361e-02f, 1.18379071e-01f, -4.15155478e-02f,
  4.32780199e-02f, 2.65432019e-02f, -1.93624366e-02f, 9.39138457e-02f, 2.47028507e-02f, -1.04302131e-01f, 1.09392159e-01f, -4.63841595e-02f, -1.08440273e-01f, -1.10098094e-01f,
  2.48757184e-01f, -9.25267637e-02f, 3.58480103e-02f, 1.21619351e-01f, -3.34832072e-02f, 1.00212820e-01f, -2.68963333e-02f, 8.08466226e-02f, -2.73509212e-02f, 2.82373969e-02f,
  5.69339804e-02f, 1.18141789e-02f, -1.11320063e-01f, -4.38114293e-02f, -2.25826260e-02f, 2.11791676e-02f, 6.57144040e-02f, -8.32913294e-02f, 5.78105524e-02f, 1.25943810e-01f,
  1.31010011e-01f, 6.40145913e-02f, 1.91596806e-01f, 1.47697190e-02f, 2.27794468e-01f, 1.32065699e-01f, 4.75127511e-02f, 9.92351100e-02f, 1.11067094e-01f, 1.14030302e-01f,
  2.06227481e-01f, 1.77101418e-01f, -1.26722217e-01f, -8.05088058e-02f, 1.01606764e-01f, -2.75053233e-01f, -8.70664194e-02f, -7.86107555e-02f, 3.01880166e-02f, 1.47718549e-01f,
  1.18019367e-02f, 1.45429596e-01f, 1.08064517e-01f, 1.29968643e-01f, 1.27839997e-01f, -5.62839918e-02f, -5.18195517e-02f, -2.49073524e-02f, 1.01567477e-01f, -4.86873835e-02f,
  -1.11470126e-01f, 9.62875970e-03f, 8.23217034e-02f, 4.44966108e-02f, 2.33422872e-02f, 8.39856789e-02f, -1.16128497e-01f, -1.19585976e-01f, -6.63593188e-02f, 1.36036754e-01f,
  7.24701677e-03f, -4.68000397e-02f, 8.22020248e-02f, 2.20298339e-02f, 3.71131897e-01f, 1.19139165e-01f, -1.24824615e-02f, 8.18760321e-03f, 1.20820768e-01f, 4.73430790e-02f,
  -1.62335262e-01f, 2.85980012e-02f, -2.68592518e-02f, 1.35783002e-01f, 1.86227098e-01f, 6.26043305e-02f, -1.72158126e-02f, 6.42336756e-02f, 7.83668458e-02f, 1.84999332e-01f,
  2.29106143e-01f, -6.72449917e-02f, -3.70237380e-02f, 4.05927487e-02f, 1.59028232e-01f, 9.95440409e-03f, -8.99953917e-02f, 8.48481245e-03f, 1.32999271e-01f, 4.65763994e-02f,
  3.53953689e-02f, 1.32312775e-01f, -6.10688105e-02f, -8.73167813e-02f, 2.75982954e-02f, 1.13381594e-01f, -8.20038840e-02f, 6.32778332e-02f, -5.21206670e-02f, 1.41370580e-01f,
  -1.06851220e-01f, 5.39877824e-02f, -4.51073144e-03f, 6.78734630e-02f, 9.23674852e-02f, 3.62075008e-02f, -4.93625328e-02f, 5.99858239e-02f, -4.13039364e-02f, 1.11757822e-01f,
  1.34636864e-01f, -4.81788181e-02f, -6.49310499e-02f, -3.82884257e-02f, 1.09189585e-01f, 8.07137489e-02f, 9.30610523e-02f, -9.51408148e-02f, 3.88049558e-02f, -2.14832593e-02f,
  1.01744477e-02f, 1.62436105e-02f, 1.10910676e-01f, 1.64936073e-02f, 9.95857120e-02f, 1.53386846e-01f, 1.22747101e-01f, 1.90109625e-01f, -5.03469855e-02f, -6.57719523e-02f,
  4.57486212e-02f, -1.22524835e-02f, 7.83468410e-02f, -1.14536397e-01f, -9.65298638e-02f, -4.28448431e-02f, -1.10378852e-02f, -9.33356807e-02f, -4.26956685e-03f, -3.79944853e-02f,
  -6.35057613e-02f, -4.03052717e-02f, 1.11162350e-01f, -4.64053787e-02f, -2.24390011e-02f, 5.04049584e-02f, -1.21051837e-02f, -1.14515640e-01f, -7.72060230e-02f, -1.86017882e-02f,
  -5.45652509e-02f, 6.74795955e-02f, -4.89802025e-02f, -1.01838252e-02f, -8.40217769e-02f, -4.63759340e-02f, 2.99330447e-02f, -6.58941790e-02f, -5.07372781e-04f, -3.19852941e-02f,
  -1.03782460e-01f, 1.02105148e-01f, -9.46249068e-02f, 2.43787915e-02f, 5.81742823e-02f, 1.23154379e-01f, -7.62532726e-02f, 8.20214599e-02f, 1.14996761e-01f, 3.03402878e-02f,
  -5.66559006e-03f, 5.99565469e-02f, 4.68351692e-02f, -2.43883245e-02f, 1.12510823e-01f, 7.52235502e-02f, -4.00653593e-02f, 5.45218885e-02f, -9.35927778e-02f, 6.06320016e-02f,
  -6.63867742e-02f, -8.67519081e-02f, -6.04978390e-02f, -2.71359812e-02f, -9.29696858e-02f, -3.52010503e-02f, -9.76996720e-02f, -9.65407875e-04f, -3.27955484e-02f, 1.03239727e-03f,
  -8.83812159e-02f, 8.41125995e-02f, 1.10348925e-01f, -1.00767359e-01f, 3.53644080e-02f, -9.40205902e-02f, -1.70781910e-02f, -7.12283477e-02f, -4.52304445e-02f, -1.31929472e-01f,
  7.97573999e-02f, 6.33920878e-02f, -6.82211816e-02f, 9.62495897e-03f, 9.78693366e-02f, 1.24143083e-02f, 8.59229416e-02f, -7.72370696e-02f, 6.66747466e-02f, -4.57068346e-02f,
  6.40579388e-02f, -5.30754514e-02f, 8.57568346e-03f, 2.77344175e-02f, -7.90718645e-02f, 7.29247332e-02f, -2.60979757e-02f, -1.17547341e-01f, 9.11330711e-03f, -1.45715913e-02f,
  -7.89850652e-02f, -1.19304784e-01f, -7.59228468e-02f, -1.06714435e-01f, -2.18892749e-02f, -1.30450338e-01f, 8.28121081e-02f, 4.74888086e-02f, -1.04444988e-01f, 5.63700683e-02f,
  9.08088982e-02f, 1.51168853e-01f, 6.75381860e-03f, -1.64283607e-02f, 5.27364835e-02f, 5.64571992e-02f, 1.05443552e-01f, 6.86578900e-02f, -1.25381216e-01f, -1.14850581e-01f,
  -4.56862003e-02f, 9.44640301e-03f, -7.25536421e-02f, -3.79127748e-02f, -1.13161519e-01f, -7.63575137e-02f, -1.00663975e-01f, 2.19381191e-02f, 1.43973287e-02f, -8.26861113e-02f,
  -9.79365781e-03f, 1.06792443e-01f, -4.78746966e-02f, 1.19119406e-01f, -4.28723134e-02f, 1.22112781e-01f, 1.40910789e-01f, 1.86813660e-02f, -5.67008816e-02f, 1.13330528e-01f,
  3.35151292e-02f, 3.51979323e-02f, -7.09910169e-02f, 2.91716140e-02f, 4.67844456e-02f, 8.89897421e-02f, -5.20062633e-02f, 9.22380388e-02f, -2.86366511e-02f, -3.46432552e-02f,
  9.99279991e-02f, 1.24666564e-01f, -8.32215473e-02f, 5.62912785e-02f, 4.53833975e-02f, -3.21408473e-02f, 7.33405426e-02f, -3.23053002e-02f, -9.19101387e-03f, 7.93000534e-02f,
  -8.56279582e-02f, 6.36452511e-02f, 1.54904472e-02f, -3.71926837e-03f, 3.92063446e-02f, 5.82117587e-02f, 1.52014107e-01f, 9.84545127e-02f, -1.35117993e-01f, 8.83682221e-02f,
  -5.85675351e-02f, 8.93790200e-02f, 2.20315866e-02f, -4.61963415e-02f, -5.38627468e-02f, 8.18734393e-02f, -7.85622895e-02f, -3.04505378e-02f, -9.44146141e-02f, 9.28512439e-02f,
  -3.27046998e-02f, -4.37052026e-02f, 3.22041698e-02f, -1.25566497e-02f, 1.25282314e-02f, -1.12456754e-01f, -1.20409233e-02f, -1.08066618e-01f, -2.68610218e-03f, 6.36458471e-02f,
  7.99343642e-03f, -4.60736826e-02f, -4.69606146e-02f, -7.40989074e-02f, -5.21135665e-02f, -6.43635765e-02f, 1.47168666e-01f, -5.93732335e-02f, 2.93932352e-02f, 1.26692206e-01f,
  -1.50638465e-02f, 1.57827977e-02f, 7.07376450e-02f, 5.16899303e-02f, 5.12205772e-02f, -1.25201166e-01f, -1.17542380e-02f, -5.86691163e-02f, -9.60480794e-02f, 1.47179618e-01f,
  -5.77804819e-02f, 2.75793802e-02f, 1.21878311e-01f, -1.95100307e-02f, -1.20308474e-01f, 5.39895408e-02f, -1.06877717e-03f, 2.37130616e-02f, 1.14479996e-01f, -9.46199819e-02f,
  -1.56490095e-02f, -1.19319722e-01f, -1.27704233e-01f, -6.26080334e-02f, -1.02632865e-01f, -4.83795702e-02f, -3.88659388e-02f, -5.80097921e-02f, 1.15028493e-01f, 4.72942106e-02f,
  -3.30910571e-02f, -3.66958901e-02f, -8.05343390e-02f, -4.66013625e-02f, -4.74564880e-02f, 3.24387178e-02f, 4.29892428e-02f, -1.14519514e-01f, 1.12689734e-01f, 1.85364671e-02f,
  7.86183774e-02f, -5.87565638e-02f, -8.94222930e-02f, 3.56214978e-02f, 5.35437800e-02f, -7.64676780e-02f, -1.10292673e-01f, -7.73223713e-02f, -1.19659044e-01f, -9.52187926e-02f,
  -4.75800112e-02f, -9.49039981e-02f, -5.54462485e-02f, -1.89201236e-02f, 8.48547220e-02f, -1.17781192e-01f, 1.70044287e-03f, 7.15879211e-03f, -2.35079546e-02f, 1.22108191e-01f,
  -4.96288575e-02f, -1.08502135e-02f, -6.49869964e-02f, 1.37142152e-01f, 1.50088118e-02f, -2.11479086e-02f, 1.11636601e-01f, 9.87514630e-02f, -6.81925863e-02f, 1.14559621e-01f,
  1.13164946e-01f, -3.81951705e-02f, -1.00080051e-01f, 1.24794804e-01f, -1.23758398e-01f, 2.54434929e-03f, -9.42559168e-02f, -9.40840542e-02f, -7.82419965e-02f, 2.72744820e-02f,
  -8.21080506e-02f, -9.03964564e-02f, -1.08545145e-03f, -9.66223329e-02f, 1.04279704e-01f, 2.25354303e-02f, -1.69580914e-02f, 1.16518438e-01f, 6.18040413e-02f, 5.39200827e-02f,
  1.25149950e-01f, 1.56706065e-01f, 1.17037542e-01f, 8.34215209e-02f, 1.81451485e-01f, 7.39800408e-02f, -1.49993226e-01f, -5.37582934e-02f, -8.78645331e-02f, -2.22150400e-01f,
  2.75328029e-02f, -9.78216827e-02f, -9.38807440e-04f, 1.49554759e-01f, 1.51010320e-01f, 5.71297333e-02f, 5.87247796e-02f, -1.48001881e-02f, 1.56001702e-01f, 6.69661388e-02f,
  -1.23160601e-01f, -5.51869981e-02f, 5.77179119e-02f, 1.88266877e-02f, -9.97246876e-02f, -8.70000292e-03f, 2.42027789e-01f, -6.26741126e-02f, -8.11231658e-02f, 1.86262980e-01f,
  7.66424388e-02f, -9.07371938e-03f, -8.29533786e-02f, 1.09802514e-01f, 4.26135547e-02f, -1.86162338e-01f, -8.65538046e-02f, 2.30780780e-01f, 2.72939712e-01f, 1.23703144e-01f,
  -2.45942529e-02f, -5.44745699e-02f, -6.02339990e-02f, -8.86218902e-03f, -4.55342680e-02f, 1.73496467e-03f, 9.63967368e-02f, 2.26193517e-01f, 9.34147835e-02f, -1.82460842e-03f,
  -4.50224392e-02f, 4.35978398e-02f, 2.90122610e-02f, 5.46918549e-02f, -5.72321303e-02f, -8.93051252e-02f, 3.45507041e-02f, 1.27990812e-01f, -2.92781071e-04f, -4.33241650e-02f,
  -3.86390239e-02f, -6.13719821e-02f, 1.39122725e-01f, 2.23864496e-01f, -9.04395990e-03f, 1.37619630e-01f, 1.47612855e-01f, 1.38786972e-01f, 2.01454863e-01f, 8.84416550e-02f,
  -4.42834012e-02f, 5.99159580e-03f, -1.62560940e-01f, 2.89724339e-02f, 2.58684661e-02f, -6.29874617e-02f, -1.35608688e-01f, 1.07803814e-01f, 1.85103878e-01f, -5.87059371e-02f,
  -8.76716971e-02f, -1.94586247e-01f, 2.65253812e-01f, -1.56924222e-02f, 6.73953965e-02f, 1.13676652e-01f, 1.52887460e-02f, -1.26010150e-01f, -5.69920242e-02f, -3.28632407e-02f,
  7.73226544e-02f, -6.87705353e-02f, 2.92451054e-01f, 1.15638897e-01f, 4.25942875e-02f, -2.88993362e-02f, -1.06345445e-01f, -8.71024057e-02f, 1.73634782e-01f, -6.77238218e-03f,
  5.47301881e-02f, 3.25234830e-01f, -1.79909825e-01f, -4.44194041e-02f, -4.96529415e-02f, 1.21836223e-01f, 1.14691935e-01f, -1.57142922e-01f, 2.31299754e-02f, -1.48260936e-01f,
  1.00621529e-01f, 1.31721064e-01f, 9.77758989e-02f, 7.24396575e-03f, -1.84394065e-02f, 2.08281670e-02f, -3.80441658e-02f, -1.59947589e-01f, -1.33850172e-01f, -1.11072488e-01f,
  4.22771834e-02f, 1.81278408e-01f, -2.91345082e-02f, 5.69138490e-02f, 7.72491246e-02f, 3.87227610e-02f, 8.54327232e-02f, 1.41765058e-01f, 1.33610472e-01f, 1.40380412e-01f,
  8.28209668e-02f, 1.02776833e-01f, 7.10177496e-02f, -1.27260715e-01f, 1.00238748e-01f, 4.42749336e-02f, -2.62193289e-02f, -1.81160673e-01f, -7.34454021e-02f, 1.69053108e-01f,
  1.27776256e-02f, -5.16261123e-02f, 1.47071555e-02f, -3.84614468e-02f, -2.06278101e-01f, -2.40986869e-01f, -1.01262979e-01f, 6.35430589e-02f, -3.82962748e-02f, -7.38265142e-02f,
  -1.16446055e-01f, 6.02605045e-02f, 6.65638894e-02f, -1.54007496e-02f, -3.04074232e-02f, -1.93519779e-02f, -1.45989537e-01f, 2.13860758e-02f, 7.53434598e-02f, -1.35249704e-01f,
  -1.34684667e-02f, -4.91831116e-02f, -4.45907526e-02f, -8.74575824e-02f, 1.49945632e-01f, -1.20220162e-01f, -5.30755706e-02f, 6.49738461e-02f, 5.29287420e-02f, -7.34332353e-02f,
  1.04276158e-01f, 1.81992233e-01f, 2.75307577e-02f, 2.90247165e-02f, -1.00605555e-01f, -8.89893696e-02f, 1.05921648e-01f, 4.42639217e-02f, -1.78041160e-02f, -1.13863580e-01f,
  1.24768533e-01f, -8.11224282e-02f, 3.91222071e-04f, 4.00571488e-02f, -1.23408802e-01f, 3.10144015e-02f, 8.41310173e-02f, -7.25972503e-02f, -3.48510444e-02f, -2.31796468e-04f,
  -9.43530053e-02f, -8.11431408e-02f, -8.35430548e-02f, 2.80838609e-02f, -4.56472449e-02f, 7.98644423e-02f, -2.58620474e-02f, 5.47973439e-02f, 3.12779583e-02f, 1.19419478e-01f,
  -4.30237912e-02f, 1.29422098e-01f, -5.87311992e-03f, 1.10249840e-01f, -8.04185197e-02f, -9.62648466e-02f, 3.99922915e-02f, -9.11107063e-02f, -9.39911753e-02f, -6.93889558e-02f,
  -7.22157210e-02f, 2.69530714e-02f, -1.10313334e-01f, 5.93237765e-02f, -4.41833511e-02f, -1.11455902e-01f, 2.96212584e-02f, 9.66321453e-02f, -1.09522775e-01f, -5.45928776e-02f,
  1.22743793e-01f, -9.34505463e-03f, 9.29085724e-03f, -8.60310346e-02f, 4.98184375e-02f, -3.54536623e-02f, 1.07688695e-01f, -8.37894157e-02f, 3.46328542e-02f, -5.36707304e-02f,
  2.51950808e-02f, -2.88249701e-02f, -1.23562209e-01f, -8.68041888e-02f, -7.70533271e-03f, -2.15332340e-02f, 1.19094558e-01f, -8.37666541e-02f, 9.93753318e-03f, -8.35933983e-02f,
  4.29507229e-04f, 8.89265835e-02f, 5.58908209e-02f, -1.06488161e-01f, -8.72843992e-03f, -7.09067211e-02f, -1.14444636e-01f, 1.28458381e-01f, -1.23743966e-01f, -1.11264259e-01f,
  6.75379783e-02f, 5.91017939e-02f, 1.18371487e-01f, 4.67373244e-02f, 1.93974540e-01f, 7.84676813e-04f, -8.43231380e-02f, 7.26594357e-04f, 7.36511871e-02f, 3.59478779e-02f,
  1.29583508e-01f, 3.64559926e-02f, -3.43901441e-02f, 1.17350653e-01f, 1.63904041e-01f, -3.21290419e-02f, -2.12000199e-02f, -1.62177965e-01f, -1.51855409e-01f, -1.52198106e-01f,
  8.61091167e-02f, -1.21171422e-01f, 9.29981098e-02f, 7.83136934e-02f, -1.14897683e-01f, -1.80384684e-02f, -5.95865548e-02f, -3.86032313e-02f, 1.05868131e-01f, 9.90322232e-02f,
  -1.07012436e-01f, -8.37921351e-02f, 2.28560641e-01f, 1.10526495e-01f, -1.14485726e-01f, 6.00828901e-02f, -5.27713113e-02f, 5.39112929e-03f, -1.05343878e-01f, -2.77606286e-02f,
  1.83162734e-01f, 2.43200466e-01f, -2.84063779e-02f, -1.04505129e-01f, -6.96300566e-02f, 7.06462115e-02f, -9.30242538e-02f, 2.30370201e-02f, -4.41718064e-02f, -1.31725654e-01f,
  8.69449675e-02f, 5.55348322e-02f, -2.85523869e-02f, 6.23097531e-02f, 6.76335096e-02f, 1.06527798e-01f, 2.53042318e-02f, -5.62704280e-02f, -1.27793342e-01f, -3.31957527e-02f,
  9.32956040e-02f, 1.13704607e-01f, 3.47910710e-02f, 8.37255642e-02f, 1.36843147e-02f, 2.37936862e-02f, 8.90717953e-02f, -8.53306502e-02f, 1.96255911e-02f, 6.90067858e-02f,
  9.28475112e-02f, 1.26757994e-01f, 6.60669729e-02f, -4.29857261e-02f, 1.34746611e-01f, 1.24474771e-01f, -2.63425708e-02f, -1.26719952e-01f, -9.70042944e-02f, 7.55908247e-03f,
  2.10762508e-02f, 1.10656703e-02f, 1.36078387e-01f, 1.66793659e-01f, 7.34467208e-02f, -3.50569934e-02f, -4.13822830e-02f, -1.38236493e-01f, 1.69852942e-01f, -5.09976931e-02f,
  -1.08017884e-01f, -8.88706222e-02f, 5.22767231e-02f, -1.19770572e-01f, 1.35405436e-01f, 1.96135212e-02f, 1.13601640e-01f, 4.24948521e-02f, 9.37424228e-02f, 1.03613831e-01f,
  3.70990559e-02f, -9.25445110e-02f, -6.33682683e-02f, 2.93373205e-02f, -6.81464225e-02f, -2.83066016e-02f, 1.22969775e-02f, 3.55070864e-04f, -1.40192747e-01f, 5.70238642e-02f,
  -4.52674553e-02f, 1.21903524e-01f, 9.93488207e-02f, 7.76642486e-02f, 5.67306057e-02f, -1.19985424e-01f, -8.52634460e-02f, 1.47859827e-01f, 2.02586669e-02f, 1.40873849e-01f,
  2.47366317e-02f, -1.14443205e-01f, -3.98698039e-02f, 7.91544269e-04f, -6.89298287e-02f, -2.69327387e-02f, -1.27610967e-01f, -2.53137667e-03f, -5.77655025e-02f, 2.91456521e-01f,
  1.87967464e-01f, 1.12505242e-01f, 2.68827558e-01f, 1.58883408e-01f, 2.39359647e-01f, 2.78050065e-01f, 2.43383840e-01f, 1.61883995e-01f, -2.28150394e-02f, 1.91464126e-01f,
  3.18025321e-01f, 2.45824054e-01f, 9.70688909e-02f, 3.88870746e-01f, -5.64070344e-02f, -1.79141737e-03f, -5.57876639e-02f, -2.68292755e-01f, -1.69076234e-01f, -2.80590445e-01f,
  3.37896615e-01f, 3.59910548e-01f, 1.37897819e-01f, -1.06469236e-01f, 2.38113791e-01f, 9.28917900e-02f, 1.47481889e-01f, -1.16646662e-01f, -1.55726641e-01f, 2.73767170e-02f,
  9.99005139e-02f, 1.34094954e-01f, 1.67821586e-01f, -7.88261369e-02f, 1.62618130e-01f, 1.39333755e-01f, 1.53031230e-01f, -2.81465277e-02f, 1.68654799e-01f, 3.90633970e-01f,
  -2.54453998e-02f, -2.72003889e-01f, 2.22761944e-01f, 1.63390890e-01f, -8.39902088e-02f, -1.09754160e-01f, -3.50255147e-03f, 6.94525391e-02f, 2.95536518e-01f, -8.90207142e-02f,
  2.81220265e-02f, -1.07466541e-01f, 2.66339332e-02f, -1.34557992e-01f, 4.07242728e-03f, -2.84442157e-02f, -3.72818522e-02f, 1.60247490e-01f, -1.89683825e-01f, 6.23373501e-02f,
  -1.61967874e-02f, -1.29261479e-01f, 9.77983251e-02f, -8.84614885e-02f, -7.41365850e-02f, 3.56240035e-03f, -1.34651773e-02f, -9.16091055e-02f, 2.64842007e-02f, 6.92145824e-02f,
  1.04653969e-01f, -6.77181482e-02f, -1.33312372e-02f, 1.20852008e-01f, 3.94738764e-02f, -9.61682349e-02f, -1.03434809e-02f, -1.07029773e-01f, 3.37870046e-02f, -1.18972450e-01f,
  8.26770440e-02f, 6.68447912e-02f, -9.03465673e-02f, 1.07686743e-02f, 1.27656430e-01f, 1.28885359e-01f, 6.29056320e-02f, 1.06662475e-01f, -1.24672897e-01f, -7.12196529e-02f,
  7.00453818e-02f, 1.10518551e-02f, -2.58357637e-02f, -9.80568007e-02f, 7.45746419e-02f, -6.21557608e-03f, 2.35113651e-02f, -5.37481830e-02f, -1.18118934e-01f, -3.40349562e-02f,
  1.43941343e-02f, -4.89844792e-02f, -1.01267703e-01f, 3.21593694e-02f, 2.21607671e-03f, -8.29301476e-02f, 9.88367107e-03f, 4.11543995e-02f, -8.39665085e-02f, 7.30623305e-02f,
  9.85261891e-03f, -3.23599055e-02f, 2.22932771e-02f, 1.19922675e-01f, 9.03728977e-03f, 1.29578784e-01f, -4.90192212e-02f, -1.17280126e-01f, -6.42279610e-02f, -7.87042603e-02f,
  -8.14843774e-02f, -2.30890587e-02f, 6.91233203e-02f, 5.35107404e-02f, -8.24513361e-02f, -3.66201289e-02f, -1.04570560e-01f, 1.45541862e-01f, 2.62615941e-02f, 2.45831132e-01f,
  -1.18103558e-02f, 1.15607038e-01f, 2.15962291e-01f, 4.06208560e-02f, 1.84886213e-02f, 1.78987175e-01f, 1.89219236e-01f, 7.63573721e-02f, 2.29716867e-01f, 1.19147383e-01f,
  -1.90361261e-01f, 1.70099422e-01f, 3.20532434e-02f, -6.89268559e-02f, 1.51803121e-01f, 6.21417956e-03f, -1.50107726e-01f, 3.77764441e-02f, 4.77281287e-02f, 1.42549947e-01f,
  -7.92280138e-02f, -5.76602183e-02f, 9.71264467e-02f, 1.69677690e-01f, 2.33049653e-02f, 9.77675989e-02f, -3.41056138e-02f, 2.22102776e-02f, -4.93248701e-02f, -5.29243052e-02f,
  8.32719952e-02f, -1.74377501e-01f, -1.30309522e-01f, 2.18207940e-01f, 7.64239877e-02f, 2.93118525e-02f, -2.10195750e-01f, 7.27605000e-02f, -7.46130347e-02f, -1.59661233e-01f,
  -1.20739400e-01f, -1.02712989e-01f, 1.56753659e-01f, -6.61033615e-02f, -7.04316869e-02f, 1.74169037e-02f, 2.06478760e-01f, 1.06947973e-01f, 1.82202216e-02f, 3.69496271e-02f,
  1.08860135e-02f, 7.90460855e-02f, 1.49864137e-01f, 1.95861399e-01f, 9.41874608e-02f, 2.25487158e-01f, 2.74121404e-01f, -6.64527109e-03f, -1.25793919e-01f, -8.40476155e-02f,
  7.93953985e-02f, 1.59644231e-01f, 1.16615064e-01f, 2.16110051e-01f, 1.19559079e-01f, 1.54175237e-01f, 1.66357309e-01f, 1.84518900e-02f, 1.34181559e-01f, 1.95652023e-01f,
  2.88093984e-01f, 3.05878162e-01f, -2.77550686e-02f, 1.50095802e-02f, -2.64079183e-01f, 2.88510174e-02f, 8.59576091e-02f, -1.25444978e-01f, 1.32165641e-01f, 1.05549544e-01f,
  -1.13377824e-01f, 1.92107230e-01f, 4.81968299e-02f, 1.90154597e-01f, 9.50240251e-03f, 1.97658718e-01f, 8.27879533e-02f, 1.49801567e-01f, 1.57927737e-01f, 8.39448906e-03f,
  2.95832634e-01f, 1.28380284e-01f, -1.23883963e-01f, -1.22191101e-01f, 8.62219781e-02f, -3.70471925e-02f, 1.93190239e-02f, 1.16222657e-01f, 6.60112947e-02f, 8.99582356e-02f,
  -4.27889265e-02f, 8.54595471e-03f, -1.49932027e-01f, 1.66845575e-01f, 2.02084571e-01f, 1.30119413e-01f, 1.02390334e-01f, 1.06519669e-01f, 1.57127038e-01f, 7.09153265e-02f,
  7.12180510e-02f, 1.70758054e-01f, 6.11650571e-02f, 1.83762819e-01f, -8.53183120e-02f, 1.44875780e-01f, 8.45178813e-02f, -2.40645222e-02f, 4.15200219e-02f, 8.03574622e-02f,
  4.06879425e-01f, -8.06373060e-02f, -1.31096154e-01f, -7.41235018e-02f, 2.36698955e-01f, 1.00737333e-01f, 1.91383902e-02f, 2.00344831e-01f, 2.38030523e-01f, 1.40577093e-01f,
  2.08876580e-01f, 1.37732476e-01f, 9.80354697e-02f, 9.90043730e-02f, 6.53063208e-02f, -2.24983558e-01f, -1.71150237e-01f, -1.42646685e-01f, 2.77509332e-01f, -1.68584660e-01f,
  3.61506566e-02f, 2.11912081e-01f, -9.53496099e-02f, -6.41562790e-02f, 7.60940090e-02f, -6.19603619e-02f, -3.06064159e-01f, -5.88363074e-02f, -1.46672741e-01f, -2.62501054e-02f,
  6.94961175e-02f, -3.13249156e-02f, -4.16532084e-02f, 1.08416490e-01f, -9.26390365e-02f, 1.09042495e-01f, 1.96514726e-02f, 1.04450338e-01f, -1.04150467e-01f, 5.21744639e-02f,
  2.69286465e-02f, -1.23659112e-01f, 5.14760055e-02f, -8.18558410e-02f, 6.88212831e-03f, 5.59973270e-02f, -3.08585167e-02f, -1.41720802e-01f, -9.97572765e-02f, -1.64979532e-01f,
  1.66424900e-01f, -7.07102939e-02f, 4.53085043e-02f, 1.92756847e-01f, 1.68437827e-02f, 1.20593794e-02f, 7.47049302e-02f, -6.59804121e-02f, -2.27012336e-02f, -8.73672813e-02f,
  -1.25121698e-01f, 2.76314970e-02f, 6.18315600e-02f, -1.89357832e-01f, 2.32891534e-02f, 1.57398716e-01f, 1.76784396e-02f, 1.72316104e-01f, 1.78405508e-01f, 2.17782453e-01f,
  1.78008705e-01f, 5.69977090e-02f, 1.27829477e-01f, 2.20757902e-01f, 2.28909388e-01f, 1.94267914e-01f, 1.88831076e-01f, 3.79141457e-02f, 2.45897636e-01f, 3.87709916e-01f,
  -2.26906985e-02f, -2.03233838e-01f, -5.33524930e-01f, -1.14229791e-01f, 1.61989242e-01f, -2.35882550e-01f, -1.77003294e-02f, 2.89344434e-02f, 5.14808260e-02f, 2.16848850e-01f,
  1.44646615e-01f, -1.31033853e-01f, 3.52402717e-01f, 1.41829610e-01f, 5.86717033e-05f, 1.06599800e-01f, 2.13392358e-02f, -9.42695960e-02f, 2.00260013e-01f, 2.11406231e-01f,
  -7.77318552e-02f, 5.01080379e-02f, 1.25639886e-01f, -1.57756865e-01f, -3.24324425e-03f, 5.60123585e-02f, 1.25049412e-01f, 5.40172718e-02f, 1.16194613e-01f, -2.20902964e-01f,
  -4.46934626e-02f, 3.37654352e-01f, -1.18138939e-01f, 9.88346338e-02f, -2.63919514e-02f, 5.01397178e-02f, 1.97727643e-02f, 3.52096604e-03f, 1.35889113e-01f, 1.03489846e-01f,
  -9.92274210e-02f, 2.86156535e-01f, -4.06353511e-02f, 1.66603580e-01f, 2.17443570e-01f, -6.09352849e-02f, 1.63814470e-01f, 9.69058946e-02f, 3.92797999e-02f, -1.49371326e-01f,
  -1.63400859e-01f, -5.43504842e-02f, -3.18734646e-02f, 1.62521645e-01f, 1.04463883e-01f, 1.12717934e-02f, 1.91444799e-01f, 1.25459358e-01f, 1.67762786e-01f, 1.42902553e-01f,
  2.09856912e-01f, 1.90743893e-01f, 8.88438076e-02f, 1.95540383e-01f, 5.55152148e-02f, -1.57390550e-01f, -2.50264913e-01f, -3.42727490e-02f, 2.09973365e-01f, 1.02270171e-01f,
  2.02914290e-02f, -1.02245815e-01f, 1.37604326e-01f, -3.02124918e-02f, -1.04897663e-01f, -1.61164790e-01f, 1.88749045e-01f, 7.92276561e-02f, -2.60203145e-02f, 4.99344356e-02f,
  -1.13001250e-01f, 5.27853929e-02f, 2.89898599e-03f, 1.98750034e-01f, -6.66054189e-02f, 6.23408966e-02f, 2.52128243e-01f, -5.41509800e-02f, 1.31626353e-01f, -6.37635142e-02f,
  -5.01156524e-02f, 1.12281106e-01f, 5.99301308e-02f, 7.13069811e-02f, 1.22588873e-01f, 1.74078077e-01f, -1.98386952e-01f, 9.84497601e-04f, -9.94146243e-02f, -1.01177961e-01f,
  -2.88056508e-02f, 1.07368894e-01f, 1.43630609e-01f, -1.43097399e-03f, -2.20962670e-02f, 5.54226004e-02f, 1.25625953e-01f, -4.84413020e-02f, 2.06210427e-02f, 7.64931813e-02f,
  5.72434999e-02f, -7.23211677e-04f, -6.79948479e-02f, 3.67719717e-02f, -1.61665291e-01f, 7.27626160e-02f, 1.65238321e-01f, -3.36098112e-02f, 1.62955344e-01f, 6.11998364e-02f,
  2.08869293e-01f, 5.57081066e-02f, -1.95190795e-02f, 1.36904046e-01f, 1.74632281e-01f, 6.13302849e-02f, 2.34319538e-01f, 5.68655096e-02f, 9.21461284e-02f, -6.43361174e-03f,
  -1.61661774e-01f, -1.69887081e-01f, 8.97890553e-02f, -2.49972105e-01f, -1.25756979e-01f, -4.58437167e-02f, 2.11286381e-01f, 7.54179806e-02f, -1.75522059e-01f, 8.33916888e-02f,
  2.23242775e-01f, 1.27953708e-01f, 2.06883311e-01f, 7.85200074e-02f, 1.59544021e-01f, -5.21273315e-02f, 1.87321324e-02f, -1.46326609e-04f, 2.18396440e-01f, 2.10454240e-01f,
  1.07518367e-01f, 2.21741885e-01f, 1.14361487e-01f, -7.48763531e-02f, -7.72729740e-02f, -1.64826259e-01f, 3.89227390e-01f, 1.39020637e-01f, 2.24648878e-01f, 4.94336635e-02f,
  -2.52862796e-02f, 3.75214107e-02f, -1.51224762e-01f, 1.49015918e-01f, 2.78023500e-02f, -1.74090132e-01f, -6.07563592e-02f, -1.45768657e-01f, -6.70256047e-03f, 4.46192101e-02f,
  -5.12864217e-02f, -7.51600508e-03f, -1.56730637e-01f, -7.07904324e-02f, 5.71748475e-03f, -1.94665372e-01f, -1.64500222e-01f, 4.46657324e-03f, 2.52137128e-02f, 1.89565435e-01f,
  -1.58354025e-02f, -8.94077867e-02f, -5.62084876e-02f, -3.20031978e-02f, -1.09101692e-02f, -1.77813170e-03f, -6.82308525e-02f, -3.19380239e-02f, -1.36130527e-01f, -1.30435050e-01f,
  -1.04334198e-01f, -8.79496336e-02f, -6.29177094e-02f, 3.33926193e-02f, 4.44771126e-02f, -6.89669922e-02f, -1.04460642e-01f, 6.38156831e-02f, -2.07557157e-03f, 1.30739333e-02f,
  1.08507372e-01f, -4.41483818e-02f, -7.05438629e-02f, 2.54927878e-03f, -5.51090911e-02f, -4.83767539e-02f, 5.92706017e-02f, -9.82207432e-02f, -4.61334847e-02f, 5.30323461e-02f,
  9.07657892e-02f, 3.09692528e-02f, -3.98307592e-02f, -2.23368183e-02f, 1.15518436e-01f, 1.10390402e-01f, -6.95560426e-02f, -1.12516455e-01f, 1.30017310e-01f, 1.37771770e-01f,
  5.01827486e-02f, -1.48567650e-02f, -2.69221030e-02f, -8.03869665e-02f, 7.70877451e-02f, -6.57221749e-02f, -9.98147652e-02f, -9.54328328e-02f, -5.84249757e-02f, -7.49802962e-02f,
  -4.14563064e-03f, -1.17895201e-01f, 8.38655159e-02f, 7.67298564e-02f, 9.00982171e-02f, -1.01751715e-01f, 8.32030773e-02f, -1.03923894e-01f, 4.59347479e-02f, -1.05926521e-01f,
  1.54543025e-02f, -1.13102973e-01f, 3.85636813e-03f, 6.41793832e-02f, 1.22779854e-01f, 1.88747630e-01f, 1.42057091e-01f, 1.91328064e-01f, 5.57983331e-02f, 1.80932477e-01f,
  1.02346167e-01f, 9.88989770e-02f, -1.72939710e-02f, 2.09580973e-01f, 6.57199183e-03f, 1.28148645e-01f, 1.30921185e-01f, -2.52867788e-02f, -1.87709723e-02f, 5.49258329e-02f,
  1.30904675e-01f, 1.65387318e-01f, -5.37689999e-02f, 9.38394889e-02f, -1.75418988e-01f, 1.34896925e-02f, -1.07363075e-01f, -1.02344453e-01f, 1.17220171e-01f, 1.04458578e-01f,
  5.57602346e-02f, -7.46170357e-02f, -1.61259547e-02f, -3.66158858e-02f, 1.50711864e-01f, 1.27874548e-02f, 2.67594922e-02f, -1.16141349e-01f, 7.67128589e-03f, 1.49317866e-03f,
  -1.11238509e-01f, 1.13948554e-01f, -7.27065951e-02f, 1.25489309e-01f, -1.69289812e-01f, -7.09045604e-02f, -4.16750927e-03f, -3.69499214e-02f, -1.45543084e-01f, -1.88361015e-02f,
  1.52629673e-01f, -1.15367502e-01f, -9.21732411e-02f, 1.30092159e-01f, 3.83218639e-02f, 6.66883960e-03f, 6.08955100e-02f, -8.83594528e-02f, -8.73883367e-02f, 5.41573800e-02f,
  -5.94001152e-02f, 7.08153769e-02f, 7.76545480e-02f, 1.24202080e-01f, 1.68673143e-01f, 1.22746408e-01f, -9.83454958e-02f, -1.09754386e-03f, 9.32050273e-02f, -6.35303557e-02f,
  2.55512516e-03f, -8.11752677e-03f, 9.49429795e-02f, -6.16546497e-02f, 1.06495813e-01f, 1.69824846e-02f, -3.20202336e-02f, -2.27279658e-03f, 2.40263138e-02f, 5.67036271e-02f,
  -1.20167866e-01f, -4.28416654e-02f, -1.60432495e-02f, 6.83728829e-02f, -2.80654244e-02f, -1.45789698e-01f, -5.23832720e-03f, 1.11318920e-02f, 4.54850905e-02f, 7.45209530e-02f,
  9.02571529e-02f, 7.74471983e-02f, 9.25675109e-02f, -7.44685903e-02f, 1.12033561e-01f, -2.82011107e-02f, 1.15205511e-01f, -8.78255740e-02f, 1.76862180e-01f, -6.53946176e-02f,
  1.10069446e-01f, -8.51644203e-02f, -4.12050001e-02f, -6.89384565e-02f, -8.70722607e-02f, -1.09488433e-02f, 3.14876065e-03f, -7.56320953e-02f, -3.13447416e-02f, -6.66387007e-02f,
  -1.96038112e-02f, 1.75244793e-01f, 7.51071721e-02f, 6.11433424e-02f, 1.48541614e-01f, 1.03079975e-01f, 1.32221282e-01f, 6.71706721e-02f, -5.80963343e-02f, -4.04693186e-02f,
  1.16872089e-02f, 3.03599387e-02f, 9.86835584e-02f, -6.32380927e-03f, 6.22677943e-03f, -4.36062254e-02f, -4.27691750e-02f, -8.72798148e-04f, 9.03099179e-02f, -4.66999449e-02f,
  1.03058226e-01f, 1.93419233e-02f, -7.39314556e-02f, 3.87915820e-02f, -7.34910741e-02f, -2.61476245e-02f, 5.90040907e-02f, 1.42019480e-01f, -6.93191914e-03f, -3.20430137e-02f,
  -1.79440947e-03f, 5.26126586e-02f, 1.60736963e-01f, 5.27036302e-02f, -4.45137955e-02f, -5.30347191e-02f, -1.22406110e-02f, -5.35016209e-02f, -5.41254506e-02f, 6.82493076e-02f,
  -2.20262986e-02f, 4.54083569e-02f, 4.04171617e-04f, 1.35696694e-01f, -9.40230675e-03f, -7.05620497e-02f, -8.83489549e-02f, 8.75116512e-02f, 1.04119495e-01f, -4.08289284e-02f,
  7.92218447e-02f, 1.17485367e-01f, 5.53320497e-02f, -4.54639308e-02f, -7.25281760e-02f, 4.07849401e-02f, 8.64145756e-02f, 3.07295583e-02f, -1.50055774e-02f, 2.75046341e-02f,
  -9.53800827e-02f, 5.40859587e-02f, -7.86583573e-02f, -8.43675584e-02f, 5.31535558e-02f, -8.76882002e-02f, 9.20680240e-02f, 1.34945065e-01f, -7.44111557e-03f, 9.81075410e-03f,
  5.70499077e-02f, 6.39114156e-02f, -3.05070058e-02f, 3.38030867e-02f, 8.49312171e-02f, 7.01949820e-02f, -4.74822484e-02f, 1.47244215e-01f, -9.12112147e-02f, 5.17600887e-02f,
  -1.63844414e-02f, 1.66515157e-01f, 8.28753486e-02f, -6.52329773e-02f, -5.46621457e-02f, 5.77509515e-02f, -2.54284311e-02f, 1.26765370e-01f, -3.84021923e-02f, 1.36199877e-01f,
  2.24106871e-02f, 5.59515553e-03f, 4.34911773e-02f, 7.86839947e-02f, 1.49405167e-01f, 2.76699550e-02f, 5.65649532e-02f, 4.62520607e-02f, -1.03924222e-01f, -7.71834180e-02f,
  1.26301765e-01f, 8.43349993e-02f, -5.56135327e-02f, -2.61445474e-02f, -1.92453861e-01f, -8.30838159e-02f, 1.35616049e-01f, 2.07094345e-02f, 1.38073582e-02f, -1.16570301e-01f,
  -9.30784270e-02f, 1.38282806e-01f, 2.80900002e-02f, 1.83856227e-02f, 3.05871833e-02f, -4.57498878e-02f, -1.21283561e-01f, -1.07538112e-01f, 1.39362887e-01f, -5.93957156e-02f,
  1.95331555e-02f, 1.67828172e-01f, 1.26820477e-02f, 1.35268141e-02f, 1.24742626e-03f, 1.24241447e-03f, 2.12621495e-01f, -1.38526354e-02f, -1.38719939e-02f, -3.53490226e-02f,
  -7.12036416e-02f, -4.60803919e-02f, 1.39073199e-02f, 1.16013601e-01f, 8.36322904e-02f, -6.91380128e-02f, -7.96139762e-02f, -1.01692818e-01f, 6.11907104e-03f, 1.44542800e-02f,
  1.81754753e-02f, -1.36380352e-03f, -1.55407250e-01f, 8.99797957e-03f, 6.03135452e-02f, -7.88220316e-02f, -9.10180733e-02f, 1.49292186e-01f, 6.66966066e-02f, 1.39129058e-01f,
  2.08879188e-01f, 1.80074289e-01f, 7.78332576e-02f, -2.62877624e-02f, 1.27568766e-01f, 6.78637549e-02f, -1.00126630e-02f, 8.96114036e-02f, 1.30525440e-01f, 9.99926627e-02f,
  -7.04740658e-02f, 4.83684912e-02f, -6.61276430e-02f, 1.08048320e-01f, 3.47119533e-02f, 2.54208684e-01f, 7.37357000e-03f, 5.63825332e-02f, -1.60135806e-01f, -1.27877982e-03f,
  3.54418680e-02f, -2.18247384e-01f, -5.64813800e-03f, -9.31719244e-02f, 1.09817542e-01f, -9.74421352e-02f, 2.43879985e-02f, -3.82951647e-02f, -1.39910787e-01f, -6.12468049e-02f,
  2.79152691e-02f, 1.35135621e-01f, -1.17498182e-01f, 5.30989207e-02f, 2.55728036e-01f, -8.21480751e-02f, 2.57757604e-01f, 1.48258579e-03f, 1.49701670e-01f, 7.05529824e-02f,
  2.05263361e-01f, 3.11850876e-01f, 1.17265694e-01f, 1.20205268e-01f, 1.25477463e-01f, 1.28557503e-01f, 9.98647884e-03f, 7.35406652e-02f, -4.28819284e-03f, 9.44271535e-02f,
  1.84897836e-02f, 3.27639244e-02f, -2.39397143e-03f, 3.70205492e-02f, -9.46419984e-02f, -5.35164902e-04f, -4.40955497e-02f, -4.55296300e-02f, 1.11038461e-02f, -4.16180305e-03f,
  -7.59104192e-02f, -1.07154645e-01f, 3.03406641e-02f, -1.60210669e-01f, -3.57352085e-02f, 4.34079431e-02f, 8.51535518e-03f, -9.92762148e-02f, 8.06863382e-02f, -7.33515844e-02f,
  -9.99892801e-02f, -9.25727561e-02f, -7.75646195e-02f, 4.70260233e-02f, 6.68815449e-02f, -6.16059192e-02f, -5.67350835e-02f, 4.87288348e-02f, -4.91588414e-02f, -7.21130939e-03f,
  1.18089817e-01f, -2.86776144e-02f, 9.91440117e-02f, 7.53570721e-02f, -1.03296913e-01f, 2.27691513e-02f, 6.72954097e-02f, -5.70932515e-02f, 1.38739660e-01f, -4.66011614e-02f,
  -1.34359254e-02f, -1.75424553e-02f, 6.52087526e-03f, 1.67679135e-02f, -7.50646666e-02f, 9.82373953e-02f, -6.37313873e-02f, 1.12492137e-01f, -3.37232091e-02f, 1.48522943e-01f,
  1.30536929e-01f, 1.06196277e-01f, 3.47279720e-02f, -5.36404476e-02f, 1.63562849e-01f, 4.61337976e-02f, -1.29566975e-02f, 1.64156914e-01f, 7.33414888e-02f, -4.89983782e-02f,
  -4.04854491e-03f, 1.04181670e-01f, -1.20088346e-01f, -3.25998031e-02f, -5.33275455e-02f, -8.68458748e-02f, -2.90837195e-02f, 1.06387027e-01f, 4.39077839e-02f, 3.82405668e-02f,
  -1.10486828e-01f, -5.85167594e-02f, 1.25240192e-01f, -8.69549140e-02f, -9.50007141e-02f, 8.12156796e-02f, 8.39039776e-03f, -8.96499977e-02f, 7.78030157e-02f, 2.29392305e-01f,
  6.24749204e-03f, 2.50246823e-01f, 1.44966781e-01f, -3.11888512e-02f, 1.46753475e-01f, 1.13579907e-01f, 1.48640335e-01f, 2.42635325e-01f, 1.79679468e-01f, 2.36546099e-01f,
  2.63165552e-02f, 3.65194529e-02f, -6.78732768e-02f, 7.68065676e-02f, 1.27967209e-01f, 1.52470708e-01f, 2.08806977e-01f, -1.52832180e-01f, -1.96146250e-01f, 1.13616779e-01f,
  1.07896730e-01f, -1.46305725e-01f, 9.75051671e-02f, -9.43955407e-02f, 4.14689481e-02f, 4.87391055e-02f, -1.19238965e-01f, -2.49550734e-02f, 5.43671399e-02f, -8.81419778e-02f,
  3.22385393e-02f, -9.16192383e-02f, -2.20693558e-01f, -2.05688909e-01f, -1.50054052e-01f, 5.72607331e-02f, -3.09653431e-02f, 8.59262943e-02f, -2.14468703e-01f, 8.21191221e-02f,
  3.41180041e-02f, -2.53262013e-01f, 2.24694386e-01f, -5.22676930e-02f, -7.80205950e-02f, -5.09573855e-02f, -8.44784081e-02f, 2.47996584e-01f, -3.80926020e-02f, -2.26071868e-02f,
  3.62577103e-02f, 3.28245535e-02f, -6.67616203e-02f, -5.55486903e-02f, -3.17250267e-02f, 1.84317470e-01f, 5.33774197e-02f, 9.11892764e-03f, 8.46055001e-02f, 3.06577925e-02f,
  -6.63387179e-02f, -3.28813456e-02f, 1.70178980e-01f, -6.90815523e-02f, -3.49189788e-02f, 8.72998238e-02f, -7.60363564e-02f, -5.91899231e-02f, 7.47077242e-02f, 1.29036522e-02f,
  1.18467756e-01f, 1.45453766e-01f, 1.60925835e-01f, -3.03928927e-02f, -7.31177479e-02f, 1.80145260e-02f, -8.85701999e-02f, 1.00424491e-01f, 1.44100294e-01f, -6.32355139e-02f,
  3.14705446e-02f, -5.06960182e-03f, 2.84293499e-02f, 8.77447575e-02f, -7.31934309e-02f, -9.62668285e-02f, 5.81027158e-02f, -1.26215592e-01f, 5.54531999e-02f, 1.36970699e-01f,
  1.21001410e-03f, 5.95002919e-02f, 2.56833304e-02f, 8.65283161e-02f, -4.95706424e-02f, 3.48041840e-02f, 1.02572097e-02f, 8.39627348e-03f, 2.76148077e-02f, 9.34291705e-02f,
  7.25855306e-02f, -1.61861572e-02f, -7.25054964e-02f, -1.02106154e-01f, 1.21513933e-01f, -1.23089179e-01f, 3.41732800e-02f, -9.90743339e-02f, 4.22799699e-02f, -1.18260734e-01f,
  -1.00318402e-01f, 1.01846129e-01f, -1.04506463e-01f, -3.03750951e-02f, 1.07422546e-01f, 1.65372510e-02f, 5.17140552e-02f, 5.26236743e-02f, 9.69776418e-04f, -5.00955284e-02f,
  7.43890777e-02f, -8.17856938e-02f, -1.23084702e-01f, 8.73312503e-02f, 5.26823699e-02f, 2.12741252e-02f, -1.00016758e-01f, 8.76227990e-02f, 5.52105643e-02f, 1.37642533e-01f,
  5.40959537e-02f, -7.47852176e-02f, -3.66661767e-03f, 1.09196067e-01f, -1.27759287e-02f, -4.13211994e-02f, -1.86681468e-02f, -7.58093968e-03f, 5.04078232e-02f, 8.89856219e-02f,
  -8.96752551e-02f, -4.11461405e-02f, 1.00640699e-01f, -2.33076289e-02f, 7.51133682e-03f, 1.11088008e-01f, -5.97373247e-02f, -2.60394122e-02f, -2.47506034e-02f, -7.03020021e-02f,
  6.00316711e-02f, 1.43402830e-01f, -1.18968099e-01f, 1.00055978e-01f, -8.50186944e-02f, -1.16496474e-01f, 2.87711229e-02f, 7.32889539e-03f, -8.15059394e-02f, 6.90755546e-02f,
  -1.92497261e-02f, -9.04380754e-02f, -8.14589337e-02f, -9.03867409e-02f, 9.38694105e-02f, 3.91036309e-02f, -7.03229606e-02f, -3.50038558e-02f, -7.29959011e-02f, 1.41637117e-01f,
  5.99834360e-02f, -1.00761637e-01f, 9.81669873e-02f, 6.68333322e-02f, 5.67286275e-03f, 5.64638563e-02f, -1.87277701e-03f, -8.16307813e-02f, -6.06049038e-02f, 1.10965431e-01f,
  -1.34843156e-01f, 2.96368264e-02f, -7.30742812e-02f, 5.95861208e-03f, -3.29260603e-02f, -1.43774422e-02f, 2.07113996e-02f, -1.03792794e-01f, 8.95990729e-02f, -1.20864190e-01f,
  1.17028788e-01f, 1.16338268e-01f, 5.02414256e-02f, 1.40378267e-01f, 1.28329769e-01f, 6.88267797e-02f, -2.04546619e-02f, 1.41563401e-01f, -3.90692055e-03f, 1.21103294e-01f,
  1.52381286e-02f, 4.89310734e-02f, 9.81959179e-02f, -1.25068232e-01f, -1.62200921e-03f, 8.96581449e-03f, 8.52217227e-02f, 1.03600487e-01f, 4.49686460e-02f, -1.09353311e-01f,
  6.17249198e-02f, -1.26042932e-01f, -8.00426081e-02f, 4.48495448e-02f, -2.81040333e-02f, 3.24219950e-02f, 9.29118320e-02f, -9.80448201e-02f, -2.55464781e-02f, 4.69896831e-02f,
  -6.65834397e-02f, 1.07450657e-01f, 3.22653987e-02f, -9.13313963e-03f, -1.00711793e-01f, 9.28482935e-02f, -3.38246836e-03f, -3.59666604e-03f, -2.71450989e-02f, 3.04650562e-03f,
  -5.61220162e-02f, 1.70850322e-01f, 4.72068973e-02f, 2.16983892e-02f, -2.75174971e-03f, -8.86083171e-02f, -7.76683688e-02f, -4.22733054e-02f, -1.10655231e-02f, 1.02980152e-01f,
  7.74392262e-02f, -4.38440070e-02f, -8.70470703e-02f, -9.04807597e-02f, -4.50008921e-02f, 1.66404136e-02f, -8.28666613e-02f, 9.71175805e-02f, 1.16755225e-01f, -2.48530637e-02f,
  -3.52667794e-02f, -1.42392209e-02f, -6.60630986e-02f, -1.82954669e-02f, 1.01646766e-01f, 5.61704636e-02f, -4.23086388e-03f, -5.18821478e-02f, 1.10202983e-01f, 7.90332407e-02f,
  5.80144934e-02f, -8.40045325e-03f, 1.28014773e-01f, 5.22318576e-03f, -2.53126882e-02f, -1.12542197e-01f, -8.17787200e-02f, -6.32975698e-02f, 1.05120502e-01f, 3.96984927e-02f,
  -1.34189963e-01f, 4.86165658e-02f, -6.00591674e-02f, 1.77328348e-01f, -6.23992085e-02f, -9.93536562e-02f, 9.63967144e-02f, 5.71241230e-02f, -2.97162514e-02f, 5.36563108e-03f,
  -7.89133161e-02f, 7.97587037e-02f, 4.91133779e-02f, -7.97436163e-02f, 1.83891460e-01f, -5.81758469e-02f, 7.35698268e-02f, 1.81940813e-02f, 3.05185647e-04f, 3.36711705e-02f,
  -1.04153357e-01f, -4.50078510e-02f, 1.48017734e-01f, -1.03588842e-01f, 1.28219381e-01f, -5.31118996e-02f, -7.65297038e-04f, 2.00214908e-01f, -1.16265133e-01f, -2.92696264e-02f,
  2.11605430e-01f, 5.75015247e-02f, 2.19821054e-02f, -8.05929899e-02f, 1.08744524e-01f, -1.00680411e-01f, -5.65619655e-02f, 1.63559839e-01f, 7.21491203e-02f, 7.55337775e-02f,
  -3.56560014e-02f, -1.61558874e-02f, 5.31545058e-02f, -1.08946070e-01f, 1.29004404e-01f, 1.11668788e-01f, 2.45183576e-02f, 9.49597731e-02f, -1.02560557e-01f, 1.59567837e-02f,
  1.64879241e-03f, -1.07387736e-01f, -7.36518204e-02f, 7.41497204e-02f, -8.43351409e-02f, -1.08321123e-01f, 1.39701106e-02f, 7.24820718e-02f, -1.20673001e-01f, -1.38855666e-01f,
  -6.70943186e-02f, -1.31935021e-02f, 5.84898842e-03f, -3.60144973e-02f, 4.97352928e-02f, -7.39414245e-02f, 5.76136373e-02f, -1.05511136e-01f, -3.09081562e-02f, 2.58965581e-03f,
  9.34267268e-02f, -1.26785383e-01f, 3.02383285e-02f, 4.29539680e-02f, 1.88997071e-02f, 8.50304440e-02f, 4.87195402e-02f, -2.00448763e-02f, -2.72036865e-02f, 7.85717517e-02f,
  1.20333977e-01f, -2.94539947e-02f, -8.69801641e-02f, 1.17833406e-01f, 5.17477468e-03f, -2.02268567e-02f, -7.68241212e-02f, -6.32095411e-02f, 9.65648070e-02f, -6.85799122e-02f,
  1.12019077e-01f, -3.58447582e-02f, 6.49231672e-02f, -5.60307642e-03f, -1.83719862e-02f, -1.09950013e-01f, 2.93627544e-03f, 9.28993374e-02f, 1.05548032e-01f, -8.64056796e-02f,
  -3.57215479e-02f, 1.24381119e-02f, 6.01076260e-02f, -4.21562977e-03f, 1.29548892e-01f, -4.30309735e-02f, -8.46651345e-02f, -5.00933118e-02f, -2.16279142e-02f, -1.45946108e-02f,
  1.16553478e-01f, 5.25061740e-04f, 7.71891475e-02f, 5.07420599e-02f, 7.66840428e-02f, 7.17471167e-03f, 6.77845329e-02f, 1.83402121e-01f, -3.97030860e-02f, 4.30567823e-02f,
  1.13001168e-01f, 1.14315271e-01f, 4.99310680e-02f, 8.12003985e-02f, -1.17224313e-01f, -8.94913003e-02f, -6.67550787e-02f, -6.01714328e-02f, 1.38285728e-02f, -7.22648799e-02f,
  8.71884897e-02f, 1.94612026e-01f, -9.18411389e-02f, 2.25599572e-01f, 2.46178173e-02f, 3.82972881e-02f, -7.27169076e-03f, 8.91571678e-03f, 8.35212246e-02f, 8.69580358e-02f,
  7.74823427e-02f, 1.25745609e-01f, 1.13212705e-01f, 6.26165494e-02f, 8.20647646e-03f, -2.52027228e-03f, -1.05815321e-01f, 1.43605202e-01f, -5.08221164e-02f, 4.90746349e-02f,
  -3.53573859e-02f, 3.75401191e-02f, 2.62994086e-03f, -1.68675974e-01f, -1.14219710e-01f, 2.08643407e-01f, 1.10024676e-01f, 9.83344689e-02f, 1.52278930e-01f, -3.68283503e-02f,
  1.90173864e-01f, 1.68873928e-02f, -1.45496666e-01f, 6.66992739e-02f, 2.17672884e-02f, 2.59665042e-01f, 7.83595629e-03f, 1.89205289e-01f, 9.24019665e-02f, -1.12055242e-01f,
  -2.81726988e-03f, 1.46856010e-01f, 2.10796237e-01f, -7.53568709e-02f, 1.07524898e-02f, 1.65921133e-02f, -7.63091817e-02f, -7.13359863e-02f, 1.15038261e-01f, 1.23204239e-01f,
  -7.46349292e-03f, -1.83499269e-02f, 1.83428712e-02f, 1.40290856e-01f, 1.62396520e-01f, 8.97872224e-02f, -9.63564217e-03f, 5.83208166e-02f, -5.86546175e-02f, -1.09288402e-01f,
  -1.72368750e-01f, 1.06202610e-01f, 7.93603212e-02f, -3.23137641e-02f, 2.79728100e-02f, 3.70922573e-02f, 5.23773097e-02f, -1.23603880e-01f, 1.22271299e-01f, -9.26833972e-02f,
  8.01543221e-02f, -6.52322769e-02f, -1.00909367e-01f, -1.97450630e-02f, -5.27844345e-03f, 1.07202865e-01f, 1.63897611e-02f, 1.27286106e-01f, -8.55645761e-02f, -2.09767800e-02f,
  1.51944965e-01f, -2.36057723e-03f, -8.28163251e-02f, 1.58484325e-01f, 3.07244752e-02f, -1.12806991e-01f, 1.54148772e-01f, -3.11658252e-03f, 6.48922920e-02f, -8.23555440e-02f,
  4.88090925e-02f, 1.23082742e-01f, 2.12720037e-02f, -9.59675312e-02f, 9.55571532e-02f, -3.15932706e-02f, 1.65793553e-01f, -8.06539282e-02f, 5.39968833e-02f, -1.31576240e-01f,
  2.11778115e-02f, 3.97580564e-02f, 1.87358037e-02f, -4.90597710e-02f, -3.39609664e-03f, -8.64845291e-02f, -1.31591991e-01f, -6.02732748e-02f, 5.65413907e-02f, 6.30673617e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.55462116e-01f, 4.30477932e-02f, 1.86530858e-01f, 9.53775123e-02f, -2.40552109e-02f, 1.64960057e-01f, 1.75064102e-01f, -1.40637293e-01f, 2.72846222e-02f, 4.31883931e-02f,
  -1.38380816e-02f, 6.72249347e-02f, 9.91745517e-02f, 1.24659427e-01f, 8.38168487e-02f, -2.36424077e-02f, -1.49693089e-02f, 2.35681549e-01f, -1.01689436e-01f, 2.38151789e-01f,
  1.62023604e-01f, 2.36342669e-01f, 4.59032506e-02f, 1.41354958e-02f, 2.23883361e-01f, -4.08454351e-02f, 6.25837371e-02f, 8.22188053e-03f, 1.50096521e-01f, 3.26096974e-02f,
  -1.88696198e-02f, -9.30584520e-02f, 2.60158539e-01f, -4.71159741e-02f, -4.32316810e-02f, 5.64214624e-02f, -1.42624676e-02f, 2.57300548e-02f, 8.30338523e-02f, -7.49945045e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -9.17138979e-02f, 1.01904884e-01f, 1.25561804e-01f, -9.66789871e-02f, -5.79882506e-03f, 7.96021819e-02f, 4.46427651e-02f, 9.11774412e-02f, -1.56817913e-01f, -1.21023886e-01f,
  4.83828522e-02f, 3.03096566e-02f, 1.19724102e-01f, 1.53589830e-01f, -6.33490980e-02f, 2.36274470e-02f, -5.38889319e-03f, -1.93319201e-01f, -2.17747882e-01f, 1.00825407e-01f,
  -1.26872770e-02f, -3.09045780e-02f, -7.09853396e-02f, -5.63812777e-02f, 1.16059005e-01f, 1.11857742e-01f, 7.11301938e-02f, 4.32300456e-02f, -3.88311855e-02f, -7.66575709e-02f,
  3.38661075e-02f, 4.87071350e-02f, 9.17188227e-02f, 1.01143844e-01f, 8.44521523e-02f, -2.40165964e-02f, 1.14501566e-01f, -2.49115042e-02f, 7.82515928e-02f, -4.96388972e-02f,
  -6.31060079e-03f, -1.83191150e-01f, 1.50257247e-02f, -2.50411808e-01f, -2.35935941e-01f, 7.98667148e-02f, 5.59455007e-02f, 1.82958633e-01f, 3.24846894e-01f, 9.18507650e-02f,
  -1.22893013e-01f, 4.46168855e-02f, 2.52620801e-02f, 1.31290451e-01f, -2.17009895e-02f, 6.58282116e-02f, -1.05237439e-01f, 1.30483270e-01f, -1.38293490e-01f, 1.12602204e-01f,
  6.74526161e-03f, 5.63611835e-02f, -7.14956447e-02f, 1.09362930e-01f, -1.58584848e-01f, 1.08506858e-01f, -1.40512586e-01f, -5.49280047e-02f, 1.54620022e-01f, -1.98494986e-01f,
  7.55428001e-02f, 2.97513865e-02f, 7.59036466e-02f, -5.05547151e-02f, -1.36785552e-01f, -6.36175200e-02f, -9.55547690e-02f, 1.30683869e-01f, 2.36379638e-01f, 2.28721146e-02f,
  -6.15177862e-02f, 2.04617023e-01f, 1.88741341e-01f, 4.25558165e-02f, 1.67501241e-01f, -3.71421486e-01f, 5.09804231e-04f, -1.60590857e-01f, 1.33570105e-01f, -9.82712582e-02f,
  -4.13556136e-02f, -4.53712717e-02f, -1.22954659e-01f, -8.46253783e-02f, 5.48197478e-02f, 5.01233228e-02f, 8.09676796e-02f, 9.52988490e-02f, -5.58512732e-02f, -9.34100300e-02f,
  8.09807051e-03f, -1.23285510e-01f, 6.90575838e-02f, 2.75535304e-02f, -7.21995533e-02f, 2.42494866e-01f, 8.40766206e-02f, 2.18081146e-01f, 1.61693573e-01f, -1.77764848e-01f,
  1.01821057e-01f, 1.68462962e-01f, -1.92651689e-01f, 1.16388723e-01f, 1.61807656e-01f, -4.82668057e-02f, -1.35894582e-01f, -6.09445684e-02f, 1.55491397e-01f, 1.15204602e-01f,
  -1.12601645e-01f, -1.41478732e-01f, 2.52705012e-02f, 3.82815697e-03f, -7.72199109e-02f, 1.11315101e-01f, -2.08976548e-02f, 4.73314896e-02f, -1.51167169e-01f, -2.04803776e-02f,
  5.79785593e-02f, -6.92112595e-02f, -1.30108789e-01f, 4.62774225e-02f, -1.72704697e-01f, -8.39767531e-02f, -1.28350198e-01f, -1.55939758e-01f, 9.24385339e-02f, -7.27444515e-02f,
  1.87209528e-02f, 2.22668737e-01f, -1.86264172e-01f, -1.27407119e-01f, -4.85236607e-02f, -5.56091443e-02f, -2.07831919e-01f, -2.03091726e-01f, 8.43804479e-02f, -8.67403746e-02f,
  -3.57006937e-02f, -8.67054015e-02f, 4.15571630e-02f, 8.64633024e-02f, -2.03269608e-02f, 7.68410489e-02f, 1.03751108e-01f, -1.30059063e-01f, 3.62317194e-03f, 5.35654798e-02f,
  -8.60380232e-02f, 8.34828168e-02f, 3.03722024e-02f, -1.69470191e-01f, 9.99295935e-02f, 1.11194411e-02f, 3.39892954e-02f, 1.74467459e-01f, -3.42418551e-02f, 2.32100651e-01f,
  1.02525227e-01f, -1.75706610e-01f, -2.20336318e-01f, -1.58654060e-03f, -3.02152365e-01f, -1.57237813e-01f, 1.35167196e-01f, -4.43407968e-02f, 4.55938093e-02f, -1.31619982e-02f,
  -2.02208981e-02f, 3.83347273e-02f, -1.64352730e-02f, -8.49593505e-02f, -4.11654301e-02f, -1.07479952e-01f, 8.39820653e-02f, -7.81058446e-02f, -6.09373450e-02f, 9.28711072e-02f,
  -1.69621229e-01f, -2.52546184e-02f, -4.51695919e-03f, -2.00962126e-02f, -1.93736702e-01f, 1.69268493e-02f, 9.88596901e-02f, 1.07511625e-01f, 1.25479326e-01f, -2.22334173e-02f,
  -6.71037510e-02f, -7.23657571e-03f, -1.32114619e-01f, -7.41024315e-02f, 1.92844421e-01f, 1.96347088e-01f, 3.59108597e-01f, 1.64371535e-01f, -3.58793020e-01f, -1.42785236e-01f,
  1.77000254e-01f, 7.20997751e-02f, 3.13612111e-02f, -1.10035054e-01f, 4.70601469e-02f, 9.29924324e-02f, 1.50648549e-01f, -1.50755141e-03f, -1.26868621e-01f, -1.35052884e-02f,
  -1.21750623e-01f, -1.81088418e-01f, 8.13518986e-02f, 9.89434943e-02f, -1.07146157e-02f, 1.13428496e-02f, 5.66169098e-02f, -1.11328416e-01f, 1.38235077e-01f, 8.75147060e-03f,
  4.93813567e-02f, -2.12292701e-01f, -4.19330858e-02f, -2.49409582e-02f, 3.93507741e-02f, 2.02158406e-01f, 5.82604948e-03f, -6.55355155e-02f, 1.19986653e-01f, 1.94281846e-01f,
  -2.03120653e-02f, 1.11048020e-01f, 2.36703441e-01f, -4.53323908e-02f, 3.25006880e-02f, -1.42878637e-01f, -8.74351189e-02f, -3.17006633e-02f, 1.14071928e-01f, 4.58743721e-02f,
  4.65029925e-02f, 1.58940889e-02f, -3.49878892e-02f, 1.19429328e-01f, 1.81499310e-02f, 1.06835954e-01f, 7.76272193e-02f, 2.25411523e-02f, 4.42795083e-02f, -6.91079944e-02f,
  -5.30010425e-02f, -1.61898911e-01f, -2.33660880e-02f, 4.70631383e-02f, 5.95208863e-03f, -1.86670586e-01f, 8.25982243e-02f, -1.26523256e-01f, -1.62116304e-01f, 4.20945957e-02f,
  8.10061842e-02f, -2.91300938e-02f, -1.00102283e-01f, 9.69874784e-02f, 6.94225654e-02f, -1.57007128e-01f, -3.54210250e-02f, -9.16075706e-02f, 7.39942119e-02f, 9.15034413e-02f,
  -1.54893724e-02f, -2.15591155e-02f, -7.11568519e-02f, 3.66073959e-02f, 1.20294139e-01f, -1.41720613e-03f, -3.22817564e-02f, 2.08926052e-02f, 1.30189704e-02f, -1.01935398e-03f,
  4.21231650e-02f, -1.50939599e-01f, -1.54453605e-01f, 7.24835740e-03f, 1.87883452e-02f, 1.38064519e-01f, 2.12483648e-02f, 2.59761870e-01f, -7.04425424e-02f, 1.48682863e-01f,
  4.52922396e-02f, -1.01401046e-01f, 4.58237715e-02f, -2.03700196e-02f, 1.07922420e-01f, -4.76089381e-02f, -1.36971017e-02f, -9.73890275e-02f, 3.44866253e-02f, -4.16139746e-03f,
  6.29253760e-02f, -1.01789087e-01f, -1.06205821e-01f, -1.30759344e-01f, 2.02663261e-02f, 3.06748319e-03f, 6.60639331e-02f, -9.56841633e-02f, 2.93536689e-02f, 1.73900463e-02f,
  4.84745502e-02f, 1.45431072e-01f, -5.51914535e-02f, -3.92393768e-02f, -1.01014398e-01f, 5.27257733e-02f, -5.18819839e-02f, 1.14153609e-01f, -1.08928405e-01f, 8.53641778e-02f,
  3.43785286e-02f, -6.80017695e-02f, -1.00284778e-01f, 6.15541898e-02f, -6.89094961e-02f, -7.80078769e-02f, 1.85093403e-01f, -1.37397766e-01f, -8.33549649e-02f, 1.62726656e-01f,
  -1.97675094e-01f, 3.89456779e-01f, 8.53050277e-02f, -1.19912133e-01f, -5.71683794e-02f, 4.76055965e-02f, 1.33177796e-02f, 2.73508262e-02f, 1.04014337e-01f, 1.77928194e-01f,
  8.87864158e-02f, 7.98353031e-02f, 1.21962704e-01f, 2.59431917e-02f, -8.70982781e-02f, 1.68278933e-01f, -1.51358902e-01f, 1.32041976e-01f, -3.47570367e-02f, -5.51457703e-02f,
  -3.85413282e-02f, -2.37497762e-01f, -9.67474952e-02f, -5.17406315e-03f, -9.10545662e-02f, 2.06501886e-01f, -1.56625301e-01f, -1.55293852e-01f, -6.19509555e-02f, -5.24171107e-02f,
  7.42334798e-02f, 1.11870788e-01f, -3.60022439e-03f, 1.03971876e-01f, -1.25521630e-01f, -1.12074614e-01f, 1.14387676e-01f, -4.07080576e-02f, 1.04934521e-01f, 6.83946162e-02f,
  1.78540051e-01f, -1.08797081e-01f, 1.90455005e-01f, -1.74977377e-01f, 1.22520946e-01f, -3.91221466e-03f, -1.06742218e-01f, -5.31847700e-02f, -1.86062641e-02f, 8.95326883e-02f,
  -6.68730261e-03f, -6.15835227e-02f, -5.98032549e-02f, 1.49657577e-01f, 1.17544062e-01f, -4.84835207e-02f, 4.00755368e-02f, 2.75153406e-02f, -3.85248698e-02f, -1.70524508e-01f,
  -1.19186424e-01f, 5.57488389e-02f, -1.65757820e-01f, 5.70287518e-02f, 4.96098585e-02f, 4.19332795e-02f, 2.45510340e-02f, 1.18268445e-01f, 9.02060270e-02f, -1.06379688e-02f,
  -1.11510597e-01f, -7.92073458e-02f, 1.22271441e-02f, -8.90252739e-02f, -5.84767684e-02f, 6.81734607e-02f, 8.25338438e-02f, -2.23127492e-02f, -4.51154672e-02f, -5.79336509e-02f,
  3.90434079e-02f, 8.77144337e-02f, 1.13363668e-01f, -7.55817369e-02f, -5.89776263e-02f, -8.14531818e-02f, 6.50431812e-02f, -1.25792712e-01f, -1.89321995e-01f, 9.81309265e-02f,
  -1.47282079e-01f, 6.43891171e-02f, -1.41736791e-01f, 2.10643783e-02f, 3.88625674e-02f, -3.43637913e-02f, -1.17730893e-01f, -7.62345567e-02f, -1.09013207e-02f, 1.06011726e-01f,
  1.79653078e-01f, -4.85705733e-02f, -1.11240841e-01f, -1.03407539e-02f, 6.40711784e-02f, 1.22048450e-03f, -1.41954059e-02f, -1.95569312e-03f, 1.04122348e-02f, 9.45461616e-02f,
  8.30791071e-02f, -5.70098758e-02f, -1.24534637e-01f, 7.49111027e-02f, -1.77628219e-01f, -9.21660960e-02f, -8.88523981e-02f, 1.06213592e-01f, -9.96081308e-02f, -6.61874935e-02f,
  -1.75242975e-01f, -1.42233029e-01f, -1.56127304e-01f, 1.16758227e-01f, 3.21804464e-01f, -9.37190577e-02f, 1.40007317e-01f, 4.88539077e-02f, -3.42162177e-02f, 2.42343947e-01f,
  -1.91517770e-01f, 2.44767312e-02f, -8.41261968e-02f, -1.51139945e-01f, 1.10428251e-01f, 9.75065748e-04f, 1.17836133e-01f, 1.46839008e-01f, -5.34871109e-02f, 6.00820668e-02f,
  3.50431651e-02f, 5.99434115e-02f, -8.63262489e-02f, 1.03652254e-01f, 6.70763105e-02f, 4.12289612e-02f, 4.34224755e-02f, 1.81574985e-01f, -9.60556939e-02f, -1.69167593e-01f,
  5.75420493e-03f, 5.13687208e-02f, 1.61900640e-01f, -6.51741773e-02f, 1.46801174e-01f, -1.50516808e-01f, -5.67821935e-02f, 7.98566639e-02f, -1.12603836e-01f, 1.24422640e-01f,
  6.73592910e-02f, -3.29358242e-02f, -1.45452365e-01f, 2.28247214e-02f, -1.73727617e-01f, -1.43414512e-01f, 5.56435548e-02f, -1.83209732e-01f, -1.74430851e-03f, 5.98868504e-02f,
  1.40879199e-01f, -1.32644072e-01f, -4.21982817e-03f, -2.81490814e-02f, 5.60944304e-02f, -8.23712423e-02f, -5.37563413e-02f, -9.89307091e-02f, -5.95713481e-02f, 2.28859894e-02f,
  1.08501412e-01f, -3.22826914e-02f, 4.48410362e-02f, -1.78612053e-01f, -3.50173004e-02f, 7.30421767e-02f, 6.91146851e-02f, -1.87966064e-01f, 2.85738241e-02f, -6.31612763e-02f,
  1.73036352e-01f, 1.31805256e-01f, -9.65619758e-02f, 3.80401053e-02f, -9.71083343e-02f, -1.31247416e-01f, 1.87213463e-03f, 4.55655456e-02f, -1.70553803e-01f, 7.05182031e-02f,
  -4.63443547e-02f, -2.00060364e-02f, -1.41590834e-01f, 9.50732902e-02f, -2.28508487e-02f, 1.25667796e-01f, -1.59972385e-02f, 4.32506762e-03f, -1.92209288e-01f, -8.64001215e-02f,
  4.95893247e-02f, 7.60311559e-02f, 1.82660557e-02f, -5.59393950e-02f, 6.05395362e-02f, 1.58840910e-01f, 1.96973369e-01f, -6.94543645e-02f, -6.96309656e-02f, -9.35915336e-02f,
  -2.40984842e-01f, -1.71757899e-02f, 2.91140247e-02f, -6.84297606e-02f, -9.12833512e-02f, -9.52414423e-02f, -2.63437368e-02f, -1.29252091e-01f, 1.00073539e-01f, -9.44253057e-02f,
  8.44280943e-02f, -9.58982706e-02f, 2.69814860e-02f, -4.89246733e-02f, 1.51640996e-01f, -7.12769479e-02f, 2.94805374e-02f, -8.26498773e-03f, 1.12079315e-01f, 1.92584079e-02f,
  -5.14890812e-02f, 1.34920195e-01f, -1.54235922e-02f, -5.84666729e-02f, 1.40549138e-01f, 1.71215892e-01f, 4.54524085e-02f, 7.65713453e-02f, 4.33228053e-02f, 2.63138324e-01f,
  -4.42556068e-02f, -3.04434836e-01f, -1.16764165e-01f, -1.72159821e-01f, -1.58699185e-01f, -1.58365190e-01f, 8.45171064e-02f, 8.72914344e-02f, -1.11961262e-02f, -7.74021447e-02f,
  7.28855953e-02f, -3.12914886e-02f, -1.59509424e-02f, -4.08805683e-02f, -1.84617061e-02f, -1.85433134e-01f, 4.69524860e-02f, -5.60080148e-02f, 1.01346366e-01f, -7.61177018e-03f,
  2.59668101e-02f, -9.43847522e-02f, -7.72687271e-02f, -1.14363544e-02f, -3.65874022e-02f, 1.37758315e-01f, -1.32748932e-01f, 4.09191214e-02f, -7.95565099e-02f, -6.09357841e-02f,
  -2.14193702e-01f, 2.87894726e-01f, -3.80622774e-01f, 1.88958291e-02f, -8.57711807e-02f, 1.26481235e-01f, -5.45723550e-02f, -5.83241694e-02f, -1.25354752e-01f, 9.59502980e-02f,
  3.45826782e-02f, 4.05897424e-02f, 4.62926589e-02f, -1.01887556e-02f, -6.49588257e-02f, -3.45354937e-02f, 7.09475726e-02f, 5.54893017e-02f, 7.78100267e-03f, -8.73089358e-02f,
  -4.55981083e-02f, -1.18584275e-01f, 1.25805840e-01f, 1.27205297e-01f, -1.75258249e-01f, -2.67691575e-02f, -1.59475863e-01f, 6.11056574e-02f, 5.02256006e-02f, 5.47937937e-02f,
  -6.33904785e-02f, 1.86666343e-02f, -9.03455447e-03f, 4.86499071e-02f, -2.10573703e-01f, -1.24788225e-01f, 7.37982690e-02f, 7.78662711e-02f, -8.38592127e-02f, -2.64490992e-01f,
  1.24649607e-01f, -9.37987939e-02f, 8.65195915e-02f, -1.52269781e-01f, -7.32805505e-02f, 8.97963271e-02f, 1.67443767e-01f, -1.14187479e-01f, -7.79493898e-02f, -1.27520829e-01f,
  1.39050364e-01f, 1.07548395e-02f, -9.37339216e-02f, -1.18978485e-01f, -9.92407054e-02f, -3.63393649e-02f, 7.83991721e-03f, -1.38223752e-01f, 8.43115151e-02f, 4.60360684e-02f,
  -7.96514973e-02f, 3.17592382e-01f, -6.79307757e-03f, -6.89909309e-02f, -1.83890924e-01f, -4.91094850e-02f, -3.10433656e-01f, -8.04914758e-02f, -1.31981317e-02f, -8.98182094e-02f,
  -1.42467618e-01f, -1.24877885e-01f, 3.91565599e-02f, -8.92606657e-03f, 1.41627878e-01f, 1.54353753e-02f, -4.87565845e-02f, 1.03629306e-02f, -8.43239576e-02f, -8.28280747e-02f,
  3.93344695e-03f, 1.65677001e-03f, -1.97423100e-01f, -1.36936968e-02f, -7.19395131e-02f, 5.08917794e-02f, 4.81182300e-02f, 5.71331605e-02f, -5.69713600e-02f, 1.04332656e-01f,
  8.15436989e-02f, 4.45703901e-02f, -9.91046876e-02f, 4.96638753e-02f, 1.11988671e-01f, -1.39708951e-01f, 2.03716576e-01f, 3.07627946e-01f, 2.08783016e-01f, -2.32402664e-02f,
  -2.94534504e-01f, -1.83570370e-01f, -9.49957073e-02f, -1.02083176e-01f, 9.49140564e-02f, 1.32305786e-01f, 1.29718319e-01f, 1.11181870e-01f, 3.74724641e-02f, 1.82832003e-01f,
  -4.65062782e-02f, -4.72782515e-02f, -1.78246304e-01f, -7.19660595e-02f, 1.94986016e-02f, -9.85334814e-03f, -7.67542422e-02f, -1.54673353e-01f, 3.78213748e-02f, -2.77064949e-01f,
  -9.53781530e-02f, -5.30885905e-02f, 1.27781779e-01f, -1.34565514e-02f, -1.73969334e-03f, 2.06495933e-02f, -7.90336505e-02f, 5.49759232e-02f, -6.87747896e-02f, 1.92529291e-01f,
  -9.30963904e-02f, 1.01295143e-01f, 1.12394892e-01f, -2.89860950e-03f, 6.58404380e-02f, -1.39360353e-01f, -1.43992086e-03f, 9.42623913e-02f, 1.55818937e-02f, 3.59470770e-02f,
  -8.38976577e-02f, 7.45963976e-02f, 7.94740990e-02f, 1.01474099e-01f, 1.23958118e-01f, 3.35967052e-03f, -1.94409460e-01f, -7.72862434e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.91002670e-02f, 6.32022619e-02f, 4.37986478e-02f, -1.44289866e-01f, -5.10215461e-02f, 1.61263514e-02f, 6.86466247e-02f, -3.60185578e-02f, 1.29876822e-01f, 2.23800287e-01f,
  7.47937560e-02f, 6.02514297e-02f, 1.10682763e-01f, -2.68869828e-02f, -1.65475368e-01f, 3.02394144e-02f, 1.61587089e-01f, 3.99028743e-03f, -1.26501277e-01f, -8.54032412e-02f,
  -1.75999135e-01f, 1.90546408e-01f, -1.20570973e-01f, -7.85475522e-02f, -9.79345366e-02f, -3.43751945e-02f, -4.89434414e-02f, 3.10810935e-02f, 1.81839876e-02f, 2.64596850e-01f,
  1.62853487e-02f, 4.49705645e-02f, 2.58231349e-03f, -7.61243468e-03f, 1.29178330e-01f, 2.66609073e-01f, 1.16601093e-02f, -2.53862105e-02f, 1.18071609e-03f, 4.93551567e-02f,
  6.50672913e-02f, 2.99827801e-03f, 5.19944988e-02f, -1.68071404e-01f, 2.27201641e-01f, -4.50231470e-02f, 2.41413027e-01f, -4.73511703e-02f, -3.54293399e-02f, 1.03528664e-01f,
  1.61035582e-02f, 1.42682612e-01f, 3.18191424e-02f, 3.79200513e-03f, 8.98197815e-02f, 3.28298137e-02f, 1.05443940e-01f, 1.04720294e-02f, 9.57713127e-02f, -9.48616117e-02f,
  3.44963893e-02f, -9.91387293e-02f, 1.12786680e-01f, -6.57479092e-02f, 9.93769392e-02f, 1.09892361e-01f, 8.21641162e-02f, -1.23719923e-01f, -5.26019884e-03f, -3.63925621e-02f,
  6.45093396e-02f, 3.72989215e-02f, -2.46006325e-02f, -7.88577721e-02f, -3.35018784e-02f, -1.46058230e-02f, -1.14712626e-01f, 1.07337497e-01f, 1.21856555e-01f, 8.86481479e-02f,
  1.40078485e-01f, 6.54040501e-02f, 3.47680710e-02f, -4.51989146e-03f, 1.07922465e-01f, -5.78726009e-02f, 6.48153350e-02f, -9.31160152e-02f, -2.19139010e-02f, -2.26120967e-02f,
  1.02294870e-01f, -4.58445549e-02f, -2.61406172e-02f, 5.13313599e-02f, 1.25934616e-01f, -3.51996832e-02f, -2.24933736e-02f, 6.32392541e-02f, 8.71897712e-02f, -9.19160843e-02f,
  -5.12748323e-02f, 2.08679847e-02f, 3.75369303e-02f, -6.00499436e-02f, 6.67318404e-02f, 6.56831115e-02f, 6.37682825e-02f, 1.31279863e-02f, 6.65016174e-02f, -7.14147389e-02f,
  1.28555924e-01f, -9.60288048e-02f, 1.52789935e-01f, -1.01087108e-01f, 4.22515757e-02f, 8.85398388e-02f, 7.61070801e-03f, 5.57117686e-02f, -5.44277355e-02f, -1.01540215e-01f,
  -4.97248992e-02f, -2.66910866e-02f, 1.29219564e-02f, -1.77334920e-02f, 1.02126889e-01f, 7.84324333e-02f, 4.51538078e-02f, 1.01090424e-01f, -4.02283110e-02f, 3.18818609e-03f,
  -8.87149945e-02f, -6.64163008e-02f, 2.83706076e-02f, -1.05296269e-01f, -8.66521224e-02f, -5.31729385e-02f, 7.60957301e-02f, -1.08843863e-01f, -2.69591361e-02f, -7.39247277e-02f,
  -7.02370703e-02f, 7.49171749e-02f, -1.14741579e-01f, -2.14207973e-02f, 6.69378368e-03f, 8.66975486e-02f, -1.01917036e-01f, -5.63123599e-02f, -4.02186327e-02f, 8.68369117e-02f,
  -3.35302204e-02f, -4.61293384e-02f, -1.24401689e-01f, 8.99178237e-02f, -3.41535956e-02f, 1.21282704e-01f, 5.00783361e-02f, 7.48524293e-02f, -7.37075582e-02f, 5.38439900e-02f,
  1.98453832e-02f, 1.04296558e-01f, 9.16700512e-02f, 4.87446673e-02f, -1.24535179e-02f, -1.25232143e-02f, -6.92631230e-02f, 2.11470556e-02f, -6.61838874e-02f, -6.78841472e-02f,
  5.86237647e-02f, 1.99949574e-02f, -7.01826885e-02f, -7.11338967e-02f, -1.97117422e-02f, -1.21375978e-01f, -8.27835947e-02f, -9.98865580e-04f, 7.09501430e-02f, 5.48150800e-02f,
  2.76140403e-02f, 4.84392308e-02f, -7.14620054e-02f, -2.51217727e-02f, -9.43243429e-02f, 8.93695727e-02f, 1.70170628e-02f, 6.04658723e-02f, -2.58737914e-02f, -7.97910020e-02f,
  8.20279419e-02f, -4.15996648e-02f, 1.74130440e-01f, 1.09813903e-02f, -6.74368441e-02f, 1.65737465e-01f, -8.99449661e-02f, 7.13664368e-02f, -6.29973635e-02f, 1.02182634e-01f,
  2.85051763e-02f, 1.74151704e-01f, 1.31331787e-01f, 1.51289068e-02f, 1.77630410e-01f, 1.23109549e-01f, 1.38742216e-02f, -2.28359208e-01f, 3.23258936e-02f, -6.89430088e-02f,
  -9.50153619e-02f, -2.48241156e-01f, 1.51544958e-01f, -3.76498140e-02f, -2.61088610e-02f, -4.70791198e-02f, 3.48588452e-02f, 1.06248446e-01f, 2.05325987e-02f, 8.70366022e-02f,
  -1.30064696e-01f, 1.07300710e-02f, -3.02729243e-03f, -7.70369247e-02f, 3.37862708e-02f, -1.10938614e-02f, 3.74896079e-02f, 5.83420321e-02f, -1.19870305e-01f, -1.65921561e-02f,
  2.34929901e-02f, 1.32541701e-01f, -4.26068865e-02f, 1.28345013e-01f, -7.95476586e-02f, 1.01096034e-01f, 7.31927976e-02f, 2.21904874e-01f, -1.73934236e-01f, 9.18106586e-02f,
  -7.66463578e-02f, -7.46078119e-02f, 2.47005802e-02f, -6.39942288e-02f, 5.58667928e-02f, 9.99612212e-02f, 1.43620536e-01f, 3.20454985e-02f, 9.44483578e-02f, 4.67055850e-02f,
  -2.34920555e-03f, 6.42442554e-02f, -1.18330926e-01f, 9.19365734e-02f, -6.95610046e-03f, 9.87448767e-02f, 7.62845501e-02f, 5.85844480e-02f, 1.90478578e-01f, -2.29438152e-02f,
  2.64033638e-02f, 1.22838272e-02f, 7.57888407e-02f, 7.45182112e-02f, 2.28963494e-01f, 3.05209886e-02f, 2.17159778e-01f, 1.82346746e-01f, 5.90660498e-02f, 1.37003854e-01f,
  1.24714606e-01f, -6.15899041e-02f, -4.42135371e-02f, 9.47982147e-02f, -6.48546740e-02f, -3.36094975e-01f, 3.27194601e-01f, -3.34026247e-01f, 1.42192677e-01f, -1.70464605e-01f,
  2.34816834e-01f, -9.35463421e-03f, 1.94735572e-01f, 1.10929990e-02f, -1.18504629e-01f, -1.37976900e-01f, 1.26320258e-01f, -1.03388987e-01f, -6.65702224e-02f, -8.59738961e-02f,
  -1.41006082e-01f, -1.92405403e-01f, 2.26276759e-02f, -1.56031456e-02f, 4.74578924e-02f, 1.41843647e-01f, -1.35536864e-01f, 5.81045508e-01f, 3.51161882e-02f, 1.46589175e-01f,
  -4.30934690e-03f, 8.10817182e-02f, -1.59796223e-01f, 9.65504535e-03f, -3.49733746e-03f, -7.53799826e-02f, 9.05854627e-02f, 2.42764875e-02f, -9.71768200e-02f, 3.43425684e-02f,
  3.07132661e-01f, -3.80468741e-02f, 1.83084503e-01f, 2.84115244e-02f, -7.57593960e-02f, -7.15616904e-03f, -4.72593158e-02f, -2.22686566e-02f, -1.98060691e-01f, -4.30930778e-02f,
  5.50115220e-02f, -1.24379598e-01f, 8.96425545e-02f, 1.60789952e-01f, -9.03241262e-02f, 4.37710360e-02f, 1.18925916e-02f, 6.78556263e-02f, 1.07999809e-01f, 1.96652710e-02f,
  1.23676611e-02f, 3.36795184e-03f, -1.56010762e-01f, -1.47528097e-01f, -1.13304213e-01f, -1.11580022e-01f, 1.69073805e-01f, 9.70243067e-02f, 8.29395745e-03f, -1.62578657e-01f,
  -1.45208120e-01f, 7.55218789e-02f, -3.05275898e-02f, -1.61442667e-01f, 5.97059056e-02f, -9.43520665e-02f, 1.19610243e-01f, -7.73007646e-02f, 1.79025829e-01f, 1.95288375e-01f,
  1.16138890e-01f, 4.50004227e-02f, 4.48069349e-02f, 2.16119457e-02f, -9.03297067e-02f, 2.54278146e-02f, -1.00134470e-01f, -1.39027044e-01f, 4.17470187e-02f, 5.26973791e-02f,
  -5.30775413e-02f, 5.81036918e-02f, -4.74433117e-02f, 4.63417321e-02f, 1.51310176e-01f, -1.02057457e-01f, -3.76460725e-03f, 2.13193893e-02f, 3.11462805e-02f, 5.00094518e-02f,
  6.03233837e-02f, -1.92132127e-02f, 1.56229049e-01f, -9.79398787e-02f, -9.79686305e-02f, 1.04652852e-01f, -1.91614348e-02f, -9.68519896e-02f, 9.86288674e-03f, -1.71567015e-02f,
  9.26715285e-02f, 8.99429768e-02f, 7.97259361e-02f, 4.18740399e-02f, 5.61553240e-02f, -8.98249522e-02f, 8.41348618e-02f, 1.20432183e-01f, -2.87722517e-02f, 8.52885246e-02f,
  1.38902292e-01f, -6.69701993e-02f, 6.61262777e-03f, 4.16443609e-02f, -9.53089893e-02f, 1.24145418e-01f, -3.73845771e-02f, 8.44478458e-02f, -9.88547970e-03f, 5.97917177e-02f,
  5.66513985e-02f, 1.39328744e-02f, -6.29798248e-02f, 1.12292916e-02f, -1.29318804e-01f, 7.38575608e-02f, 1.21095866e-01f, -3.85666303e-02f, -6.17109686e-02f, -6.17574602e-02f,
  -3.21986824e-02f, 1.13121159e-01f, -7.92363882e-02f, 9.50000733e-02f, -1.96049456e-03f, -1.20913997e-01f, 1.12149410e-01f, 1.24240918e-02f, -2.62402627e-03f, -1.12390265e-01f,
  -7.66983777e-02f, 7.07762986e-02f, 5.29704466e-02f, -1.14001781e-01f, -8.89717788e-02f, 8.08190107e-02f, -3.04053053e-02f, 1.28242597e-02f, -5.57695925e-02f, 3.98822166e-02f,
  -1.94208638e-03f, 9.73518863e-02f, -2.39183865e-02f, 9.00156572e-02f, 8.14335197e-02f, -7.79034272e-02f, 9.95953288e-03f, -1.07836246e-01f, 3.31772380e-02f, -4.20621112e-02f,
  1.37070015e-01f, 2.03810446e-02f, 3.46436724e-02f, 1.06312975e-01f, -1.17809393e-01f, 6.00372553e-02f, 4.30647731e-02f, -1.27278477e-01f, -3.80861163e-02f, -5.82927279e-02f,
  8.86693299e-02f, -1.09065503e-01f, 1.03966787e-01f, -9.78114530e-02f, 1.24777935e-01f, 2.81831473e-02f, 1.45536279e-02f, 2.69854926e-02f, 1.47490367e-01f, -4.74757701e-02f,
  1.32600605e-01f, 2.11173847e-01f, -1.16385430e-01f, -2.14029208e-01f, -1.97184850e-02f, 1.75604001e-01f, -1.13375470e-01f, -6.48433045e-02f, 4.99109812e-02f, -8.10510963e-02f,
  1.15503214e-01f, -2.26915389e-01f, -1.38853058e-01f, 2.34173499e-02f, -4.17900383e-02f, -6.14965335e-02f, 8.51547644e-02f, 1.74248561e-01f, 9.11420882e-02f, 5.84029332e-02f,
  -2.87311208e-02f, -5.63755147e-02f, -2.81368140e-02f, 8.51871744e-02f, 7.18022436e-02f, 9.33184847e-02f, -5.57153374e-02f, -1.78413391e-02f, -8.26113075e-02f, 1.20513782e-01f,
  6.91962764e-02f, -5.84311672e-02f, 1.56822160e-01f, 1.35406792e-01f, -1.46793500e-01f, -8.34716633e-02f, 1.27135813e-01f, 4.71154936e-02f, 1.16816364e-01f, -1.98698752e-02f,
  -6.03499822e-02f, 5.78845106e-02f, 2.55308300e-01f, 2.06830073e-02f, -7.68820047e-02f, -1.22933835e-01f, 1.12386815e-01f, -3.72996717e-03f, 9.13517997e-02f, -4.98902276e-02f,
  4.54811007e-02f, 1.85849126e-02f, 3.03165801e-02f, 5.72706237e-02f, 1.21400863e-01f, -7.76758939e-02f, -1.78090520e-02f, 6.92052171e-02f, -1.25988964e-02f, 4.94885221e-02f,
  1.44605175e-01f, -7.75150880e-02f, 1.35274883e-02f, -1.03040919e-01f, -1.67452827e-01f, 5.23784310e-02f, 8.49327724e-03f, 3.14374082e-02f, 5.69010600e-02f, 1.27234206e-01f,
  9.38921273e-02f, -9.22790095e-02f, -1.05017707e-01f, 1.02753408e-01f, 1.89509746e-02f, -3.41208279e-02f, -4.04080749e-02f, -5.66021986e-02f, 8.97400677e-02f, -2.14475058e-02f,
  -5.93654662e-02f, 9.65994224e-02f, 6.00513481e-02f, 9.65909660e-02f, -7.85738602e-02f, 2.42812056e-02f, 7.75164887e-02f, 1.29726231e-01f, 7.71240368e-02f, -1.54665813e-01f,
  9.25311670e-02f, 6.51964173e-02f, -1.96663458e-02f, 1.92120411e-02f, 1.28791794e-01f, 9.55045670e-02f, 1.84497386e-01f, 6.08477741e-02f, 1.01891473e-01f, -1.06889009e-01f,
  1.41184479e-01f, -6.21400326e-02f, -1.00283800e-02f, 9.83330384e-02f, -6.56975573e-03f, 1.09783679e-01f, -1.03496104e-01f, 2.44098566e-02f, 3.31911705e-02f, -6.10848777e-02f,
  -1.69332977e-02f, 8.56828988e-02f, -1.04658939e-01f, -8.11760128e-03f, -6.14474155e-02f, 4.00821213e-03f, 3.55698504e-02f, -5.42892180e-02f, 1.19384818e-01f, 1.73584282e-01f,
  -1.27125472e-01f, -1.14499360e-01f, 8.02224949e-02f, -4.20860201e-02f, 1.57623619e-01f, 1.00517526e-01f, 1.06680147e-01f, 6.93707615e-02f, 4.44843620e-02f, -2.16230556e-01f,
  -2.17838064e-01f, 5.66934273e-02f, 2.43465364e-01f, 2.32401401e-01f, -1.24961741e-01f, -1.97657898e-01f, 1.10982947e-01f, -1.54193267e-01f, -3.21747251e-02f, 5.62571594e-03f,
  -1.03482082e-01f, 1.92176756e-02f, 8.89846310e-02f, -1.28691211e-01f, -8.63047224e-03f, 1.36212423e-01f, -1.14190757e-01f, -8.14033393e-03f, -5.69521450e-02f, 1.30932674e-01f,
  -5.27370945e-02f, 1.21782839e-01f, -1.01998001e-01f, -1.34901538e-01f, -3.68839800e-02f, -2.55105514e-02f, -9.78695303e-02f, 4.23937231e-01f, 5.77575862e-02f, -2.10865680e-02f,
  1.54467121e-01f, -7.38722384e-02f, -4.57455926e-02f, -9.13099051e-02f, 1.37982488e-01f, 3.24003920e-02f, -1.32110164e-01f, 8.72442219e-03f, 6.54275790e-02f, -9.74357724e-02f,
  1.48657799e-01f, 5.84422648e-02f, 8.33604634e-02f, 1.59769710e-02f, -8.03085119e-02f, -2.79986747e-02f, -1.58718109e-01f, 2.22444739e-02f, -1.89640578e-02f, 1.57726500e-02f,
  7.89577812e-02f, 1.74016848e-01f, 6.07520081e-02f, 2.91313622e-02f, -9.72195789e-02f, 2.42798790e-01f, -3.52115035e-02f, 1.20562144e-01f, 1.69276565e-01f, -4.09367569e-02f,
  1.81857795e-01f, 2.12283894e-01f, -7.20560849e-02f, -5.23158386e-02f, 8.70353281e-02f, -1.14778921e-01f, 4.57276851e-02f, -2.05759615e-01f, -1.11665372e-02f, 4.02167253e-02f,
  1.60178933e-02f, 2.84669608e-01f, -1.13538504e-01f, 9.29851457e-02f, 6.90491917e-03f, 1.41363531e-01f, 3.74633446e-02f, 5.03033586e-02f, -4.93402220e-02f, 6.88027358e-03f,
  -5.73681593e-02f, 4.73883934e-02f, -1.33873239e-01f, -7.82535598e-03f, -2.20642369e-02f, -4.47306819e-02f, -1.08511142e-01f, 3.37292403e-02f, -1.02905333e-01f, 4.15281095e-02f,
  1.33608609e-01f, -1.38473600e-01f, -1.31181404e-01f, 1.08119138e-01f, -8.67452845e-02f, 3.26229662e-01f, -2.13325582e-03f, 2.90471725e-02f, 1.80318624e-01f, -1.03647128e-01f,
  1.77233130e-01f, -1.27003193e-01f, -5.02323173e-02f, -4.40707766e-02f, -2.73980349e-02f, -8.67249221e-02f, 8.34455490e-02f, -3.91878523e-02f, 7.58299157e-02f, 6.50190115e-02f,
  7.79634789e-02f, 9.05235857e-02f, -5.08390367e-02f, -7.05835894e-02f, 6.44915551e-02f, -8.61253962e-02f, 2.25446280e-02f, -8.26314688e-02f, 2.07244363e-02f, 6.20273240e-02f,
  -1.46412969e-01f, 6.30206689e-02f, 2.33089942e-02f, -4.26796488e-02f, 6.45447597e-02f, 5.99960238e-02f, -1.35321274e-01f, 2.03509346e-01f, 8.93503204e-02f, -1.94111653e-02f,
  -5.60099818e-03f, -8.82272050e-03f, 1.27329782e-01f, 1.28244683e-01f, 1.72772482e-01f, -1.14413626e-01f, -9.52076465e-02f, -9.33480039e-02f, 1.65095902e-03f, -2.47265231e-02f,
  8.25191941e-03f, -5.68959080e-02f, -1.39766037e-01f, 1.43801030e-02f, 3.11560323e-03f, -9.62802395e-02f, -1.24769911e-01f, 1.37445167e-01f, 4.47403081e-02f, 1.91048775e-02f,
  8.59651119e-02f, -1.99093167e-02f, 3.57214436e-02f, -7.19749480e-02f, -4.13011834e-02f, 3.30814011e-02f, -1.01611897e-01f, -2.65154094e-02f, 1.87221721e-01f, -6.57181293e-02f,
  1.36050731e-01f, -1.24841839e-01f, -4.01414819e-02f, -1.12448409e-01f, 3.56847569e-02f, 6.30551353e-02f, -1.20384462e-01f, -4.63864803e-02f, -8.83524492e-02f, 4.48167101e-02f,
  -1.43184274e-01f, 7.04654632e-03f, 6.09218739e-02f, 6.80430830e-02f, 1.33889522e-02f, 1.17952518e-01f, 1.26186699e-01f, -1.72434337e-02f, -1.00539804e-01f, 8.24082177e-03f,
  1.54832035e-01f, -3.72060165e-02f, 1.01981819e-01f, -3.12478207e-02f, 1.04070649e-01f, 1.22558832e-01f, -5.13009764e-02f, -9.75956023e-02f, 7.86213726e-02f, 1.91868812e-01f,
  2.34270126e-01f, 8.31316710e-02f, 4.00202489e-03f, 3.32676828e-01f, -3.08205523e-02f, 1.86609074e-01f, -4.32781614e-02f, 8.05692598e-02f, -2.37556733e-02f, -3.08914870e-01f,
  5.17178746e-03f, 1.20668828e-01f, 1.91828758e-01f, 1.10715605e-01f, -2.30758684e-03f, 9.54579413e-02f, 7.02677071e-02f, 3.12005952e-02f, 8.61818343e-02f, -6.38802946e-02f,
  -9.88239199e-02f, -9.45290551e-02f, 1.29722193e-01f, 6.86568767e-02f, 3.48016411e-01f, -4.26367596e-02f, 5.08080199e-02f, -1.66132730e-02f, 1.51892900e-01f, 3.21402460e-01f,
  -1.14785112e-01f, -8.44775513e-03f, -7.60195358e-03f, -1.64313346e-01f, 1.74484774e-01f, 3.47129077e-01f, 4.37770009e-01f, 5.32494001e-02f, -6.38226941e-02f, -1.36073425e-01f,
  -3.51322368e-02f, 1.26291648e-01f, 8.85808319e-02f, 1.08769787e-02f, -2.48466194e-01f, 8.55617374e-02f, -4.22562100e-02f, 1.52464584e-01f, 2.99774259e-02f, 6.81626797e-02f,
  -5.52204140e-02f, 3.76726314e-02f, 1.44201398e-01f, -7.95010105e-02f, 4.99876104e-02f, -6.42763227e-02f, -1.13497995e-01f, -5.85423261e-02f, 1.06738694e-01f, 7.23917410e-02f,
  -2.58197486e-02f, 2.42447145e-02f, 7.70319998e-02f, 1.35489002e-01f, -7.89555535e-02f, -6.60710186e-02f, -5.29340282e-02f, -1.23693101e-01f, 3.14723141e-02f, 1.00043871e-01f,
  9.41945314e-02f, 7.53599405e-02f, 9.81655270e-02f, 6.03137724e-02f, -7.50547796e-02f, 9.08488557e-02f, -6.58908263e-02f, 8.68247375e-02f, -4.13426869e-02f, 3.35300826e-02f,
  1.28139526e-01f, 3.40178907e-02f, -3.65784802e-02f, 8.51985591e-04f, 6.98025599e-02f, 1.00750893e-01f, -1.06062274e-03f, -8.58262181e-02f, -8.94586369e-03f, 2.85308864e-02f,
  8.89141113e-02f, -1.00689627e-01f, -4.16078568e-02f, 1.70508191e-01f, -6.23572990e-02f, -4.16333834e-03f, -8.11268762e-02f, -1.69192664e-02f, -7.85462931e-02f, -1.18135080e-01f,
  -1.37674332e-01f, 7.74909630e-02f, -5.66044934e-02f, 1.29097089e-01f, -1.14801675e-01f, 2.59488486e-02f, -5.72124943e-02f, 1.05945952e-01f, 1.14818580e-01f, 5.23516051e-02f,
  -1.91875882e-02f, -4.24822196e-02f, -1.28075525e-01f, 1.04471393e-01f, -4.22514789e-02f, -1.84034482e-02f, 3.05876844e-02f, 9.53689665e-02f, -3.80185060e-02f, 1.08896084e-01f,
  9.52743068e-02f, 8.68146122e-02f, 1.00151591e-01f, 2.43470613e-02f, 6.58931211e-02f, 5.26491180e-02f, 1.59448281e-01f, 1.09500676e-01f, -2.85344347e-02f, 9.59642455e-02f,
  5.00260405e-02f, 7.59976804e-02f, 1.55834937e-02f, 1.98786762e-02f, 1.57792568e-02f, -1.06252404e-02f, -1.19351558e-02f, 1.70193166e-01f, 1.33137956e-01f, 2.09571104e-02f,
  -8.75279084e-02f, 1.11178026e-01f, -4.69185561e-02f, -7.36761317e-02f, -5.40731661e-02f, -5.16392179e-02f, 1.24307580e-01f, -3.44469249e-02f, 7.05596292e-03f, -1.26311690e-01f,
  1.03363395e-01f, -8.94043669e-02f, -1.37679838e-02f, 1.61094323e-01f, 5.03488118e-03f, -4.65243831e-02f, -7.05387816e-03f, -1.48030430e-01f, -1.35412797e-01f, 4.94782999e-02f,
  -4.38164510e-02f, 9.38198790e-02f, 1.85890496e-01f, -2.44059619e-02f, 1.61625631e-02f, -7.28440285e-02f, 1.68603286e-01f, 2.96844933e-02f, 5.08605652e-02f, -1.68472230e-02f,
  -7.07365423e-02f, -7.78240105e-03f, -2.83922441e-02f, -4.09783050e-02f, 1.21150434e-01f, -3.79116759e-02f, 7.75062591e-02f, 3.92746702e-02f, 3.75096314e-02f, -1.79014839e-02f,
  1.06189042e-01f, 1.69664379e-02f, 8.82195309e-02f, 7.35630468e-02f, 5.70151508e-02f, 1.25586584e-01f, 2.70711724e-02f, -2.69658472e-02f, -8.81820470e-02f, 1.68249421e-02f,
  8.50488096e-02f, -1.74058363e-01f, -1.75064087e-01f, 2.16056794e-01f, -5.68020009e-02f, -1.74616888e-01f, 3.60524245e-02f, 7.33549222e-02f, 1.09542631e-01f, 6.92078173e-02f,
  1.83552727e-01f, -1.46931976e-01f, -2.16722935e-02f, -5.71148098e-02f, -7.07812235e-02f, -6.53471332e-04f, 1.00644469e-01f, 5.97264096e-02f, -1.25457212e-01f, -9.05302018e-02f,
  8.45558122e-02f, -6.57482892e-02f, 1.17776074e-01f, 1.08299166e-01f, 4.85569127e-02f, -1.42360613e-01f, -3.57195996e-02f, 3.38671952e-02f, -4.89745811e-02f, -1.25217542e-01f,
  6.71844482e-02f, 6.44689724e-02f, 3.27047799e-03f, 2.08859921e-01f, 2.71359652e-01f, 3.92867774e-02f, 1.69918910e-02f, -1.06948055e-01f, -1.91416487e-01f, -3.49178091e-02f,
  3.29854712e-02f, 1.46855220e-01f, -1.70132015e-02f, 5.20341424e-03f, 6.24003187e-02f, -1.02431893e-01f, -3.42769474e-02f, -1.35958090e-01f, 7.74914995e-02f, -5.85904121e-02f,
  1.82243422e-01f, -1.24683172e-01f, 1.90683469e-01f, -6.88514560e-02f, -1.17577240e-02f, 4.67257686e-02f, 1.46001011e-01f, -7.50501547e-03f, -1.71749406e-02f, 1.30408600e-01f,
  8.36329907e-02f, 9.62359831e-02f, 1.27548397e-01f, -4.59723100e-02f, -5.96654303e-02f, -8.75430703e-02f, -1.07528023e-01f, 6.47153929e-02f, -1.87332824e-01f, 4.92870174e-02f,
  2.10506946e-01f, -5.72054125e-02f, -8.06333572e-02f, -9.69105363e-02f, 1.11370593e-01f, 4.41492386e-02f, 2.66357586e-02f, -6.31477013e-02f, 5.28789759e-02f, 1.16534099e-01f,
  3.36383060e-02f, -2.62308251e-02f, 1.06284685e-01f, -3.67494524e-02f, 1.11299612e-01f, 9.03901681e-02f, 5.11897765e-02f, 6.97303265e-02f, 8.46126974e-02f, 7.33436272e-02f,
  3.65043171e-02f, -1.26857921e-01f, -2.94795390e-02f, 1.15645967e-01f, 3.47564779e-02f, 1.71023771e-01f, 9.75190327e-02f, -2.06732228e-02f, 1.09919965e-01f, 9.24213529e-02f,
  5.89941777e-02f, -3.69671024e-02f, 1.58028707e-01f, -8.74633193e-02f, -1.00488879e-01f, 1.02175482e-01f, -1.32580221e-01f, 1.09199248e-01f, -6.21215962e-02f, 1.12971045e-01f,
  -1.37126759e-01f, -1.18677035e-01f, -1.32027894e-01f, 8.72005448e-02f, -3.41884419e-02f, -7.19204620e-02f, -4.33373265e-03f, -1.41627369e-02f, -8.54818970e-02f, 7.23138228e-02f,
  -8.39694142e-02f, -2.03602873e-02f, -1.02976859e-01f, 1.27784442e-02f, 1.50205242e-02f, 5.55850044e-02f, -4.53721136e-02f, 9.46763754e-02f, 6.32302761e-02f, -3.38944346e-02f,
  -9.27609876e-02f, -1.35074243e-01f, 1.89865585e-02f, 8.15192759e-02f, 1.23046882e-01f, -7.07896873e-02f, 1.29283546e-02f, -9.96908545e-02f, -3.32910903e-02f, 5.50506860e-02f,
  2.53117252e-02f, -2.08819285e-02f, -6.02051765e-02f, -6.17202967e-02f, 8.66524950e-02f, 1.47524653e-02f, -2.59071328e-02f, -1.20415963e-01f, 4.63341326e-02f, -5.59591725e-02f,
  -6.22325316e-02f, 2.81475913e-02f, -4.80102412e-02f, -7.70523101e-02f, 5.84289059e-02f, -9.05641355e-03f, -1.03946395e-01f, -5.84649369e-02f, 3.54627334e-02f, 6.64765686e-02f,
  9.89626870e-02f, -1.23110704e-01f, -3.66216935e-02f, 6.38327226e-02f, 1.48550572e-03f, 2.12399308e-02f, -5.66373058e-02f, 4.26843204e-02f, 8.97112675e-03f, 2.96294633e-02f,
  6.84287548e-02f, -5.74931093e-02f, -9.40266773e-02f, -9.80871730e-04f, -1.26960799e-01f, 5.02555035e-02f, -9.86458287e-02f, 7.63301179e-02f, -5.01062199e-02f, 5.65912053e-02f,
  -9.45970491e-02f, -1.04386926e-01f, 9.84709039e-02f, 1.79643184e-01f, 1.54909581e-01f, -4.47359793e-02f, 1.71560273e-01f, 4.11591157e-02f, 1.49223506e-01f, 1.21489100e-01f,
  -2.26924345e-02f, 1.53144270e-01f, 1.08465903e-01f, 9.28621218e-02f, -1.53631791e-01f, 6.66678846e-02f, 6.34371191e-02f, 5.00146374e-02f, 2.25944426e-02f, -2.44886093e-02f,
  -1.05845660e-01f, 3.15083206e-01f, -2.20353499e-01f, 2.85313070e-01f, -1.25936404e-01f, -1.66369244e-01f, -1.48545548e-01f, 4.72214818e-02f, -5.38543351e-02f, 3.72487083e-02f,
  -7.83019364e-02f, 2.84466267e-01f, 1.27782553e-01f, -1.15535401e-01f, 4.03676853e-02f, 5.88777661e-02f, 3.81829105e-02f, 5.33946753e-02f, 1.55999258e-01f, 1.22408718e-01f,
  -2.85206996e-02f, -2.78158691e-02f, 1.37623444e-01f, -3.12000364e-01f, 1.08251333e-01f, -7.39985481e-02f, 3.16249907e-01f, 1.55693233e-01f, 1.67475685e-01f, 4.00350094e-02f,
  9.77275297e-02f, -5.99923730e-02f, 1.39025033e-01f, 2.21939534e-02f, 1.69896930e-01f, 7.15195462e-02f, -1.07785672e-01f, -1.46523686e-02f, 4.80361544e-02f, -6.44838214e-02f,
  2.53926106e-02f, -3.08051761e-02f, 4.73327301e-02f, 9.49370023e-03f, 2.03778356e-01f, -8.68155062e-02f, 1.27731547e-01f, 1.15304589e-01f, 1.92333251e-01f, 1.70451626e-01f,
  8.78224745e-02f, 5.75620160e-02f, 7.50555098e-02f, 8.24359283e-02f, 9.80841890e-02f, 1.71795979e-01f, 1.23000845e-01f, 2.22130314e-01f, -1.34099824e-02f, -3.81948292e-01f,
  8.99216831e-02f, 9.53904167e-02f, 1.20907910e-02f, 1.93138957e-01f, 5.13641946e-02f, 1.53640909e-02f, -7.02556446e-02f, -4.29631099e-02f, -2.84734815e-01f, 2.83747703e-01f,
  5.79067096e-02f, -2.08117828e-01f, -1.51274670e-02f, -8.15348700e-02f, 1.85446024e-01f, 3.98656018e-02f, -2.46872846e-02f, 5.59733473e-02f, 8.30851570e-02f, -5.83536327e-02f,
  -1.43827543e-01f, 1.84530109e-01f, -2.13155448e-01f, 1.30486444e-01f, -1.36179656e-01f, -4.71434779e-02f, -8.32416564e-02f, 2.29694530e-01f, -4.38938513e-02f, 3.38533342e-01f,
  1.83240175e-01f, -5.95871313e-03f, 1.91124715e-02f, 3.15708295e-02f, -4.17693481e-02f, -3.11773401e-02f, 2.07781300e-01f, -9.17651579e-02f, 9.40491781e-02f, 3.03021446e-02f,
  -2.33940646e-01f, -1.22661375e-01f, 3.59255493e-01f, 8.42634682e-03f, -3.35089639e-02f, -3.01006511e-02f, -1.90003723e-01f, 1.11933835e-01f, -1.98123269e-02f, 1.03879392e-01f,
  -1.08331360e-01f, -1.12931155e-01f, -4.57439534e-02f, -1.54903173e-01f, -1.28462628e-01f, 3.36858258e-02f, 4.84259054e-02f, 8.09531137e-02f, 5.65305771e-03f, -9.54774991e-02f,
  8.39480609e-02f, -3.21261398e-02f, -1.29418328e-01f, 3.61907929e-02f, 4.88655977e-02f, -1.47653043e-01f, 1.67633295e-01f, 4.34704088e-02f, -7.80061409e-02f, 8.01574588e-02f,
  3.81987356e-02f, 1.06872343e-01f, -8.99272487e-02f, -1.10740393e-01f, -6.96368665e-02f, 9.70485881e-02f, -3.24303582e-02f, 1.10546626e-01f, 5.97601645e-02f, 1.04706541e-01f,
  2.67249700e-02f, -3.58368047e-02f, -1.04848228e-01f, 7.26377964e-02f, -6.72977418e-02f, 6.54199496e-02f, 1.19264685e-01f, -8.95486027e-02f, 1.15595236e-01f, 9.40540358e-02f,
  3.90364714e-02f, 3.92745174e-02f, 6.32655099e-02f, 9.16760862e-02f, 2.19056487e-01f, -8.73816460e-02f, -3.02045513e-02f, 4.97235544e-02f, 1.00323007e-01f, -1.24148443e-01f,
  7.26983175e-02f, 1.77019220e-02f, 1.33086145e-01f, -1.19386939e-02f, -5.95437139e-02f, -3.81092867e-03f, -7.24841431e-02f, -1.14666454e-01f, 6.96718022e-02f, -7.79972374e-02f,
  1.57108173e-01f, -1.02513209e-01f, 1.32570878e-01f, -4.17716941e-03f, 9.15763155e-02f, -4.48818505e-02f, 2.98701990e-02f, 4.82271686e-02f, 1.36952475e-01f, 8.14008415e-02f,
  -6.09398412e-04f, -4.85109128e-02f, 9.53889638e-02f, 1.27757303e-02f, 1.49752796e-01f, 1.42410204e-01f, 5.33390976e-02f, -3.33287753e-02f, -1.20595852e-02f, 8.85803923e-02f,
  1.72420308e-01f, -4.64723855e-02f, -1.04374982e-01f, -1.78256392e-01f, 7.72922765e-03f, -7.70810097e-02f, -3.84443589e-02f, 6.35807961e-02f, 1.09078810e-01f, 1.19158244e-02f,
  1.51137486e-01f, -6.34743571e-02f, -5.17998300e-02f, 2.84236930e-02f, -1.02480464e-01f, -9.34674516e-02f, -1.19772285e-01f, -5.66160157e-02f, 5.89566678e-02f, -7.32749552e-02f,
  -7.84132183e-02f, -4.37451676e-02f, 1.09735951e-01f, 1.64875761e-01f, 4.37115580e-02f, 2.83589810e-01f, -6.49682879e-02f, 8.29440206e-02f, -7.74355829e-02f, -9.27441046e-02f,
  5.14731221e-02f, -2.31607798e-02f, -1.33890007e-02f, 5.42350784e-02f, 1.21019443e-03f, 6.92379028e-02f, 6.27657995e-02f, 8.52163360e-02f, -3.92261054e-03f, -9.00862888e-02f,
  1.38490617e-01f, -5.64009100e-02f, 4.59328517e-02f, -7.80390576e-02f, -9.69078541e-02f, -8.05410892e-02f, -1.55619010e-02f, 1.51306195e-02f, 3.96581972e-03f, -8.40596389e-03f,
  4.99300137e-02f, -4.61104251e-02f, 7.09951371e-02f, 8.94708708e-02f, -6.09138631e-04f, -3.69047783e-02f, 1.58440638e-02f, 1.11903481e-01f, -6.72340393e-02f, -2.98373178e-02f,
  1.05999969e-02f, -1.91960651e-02f, -1.02215074e-01f, -1.44245625e-01f, -2.91916393e-02f, 4.81933206e-02f, 5.80799840e-02f, 1.27049819e-01f, -4.53141220e-02f, 1.10684678e-01f,
  -1.25178292e-01f, 4.45870906e-02f, -8.10643360e-02f, -2.04895716e-02f, 6.13170974e-02f, 1.49068481e-03f, -3.18705402e-02f, 1.99771807e-01f, -1.58573948e-02f, -5.93539476e-02f,
  9.16432440e-02f, 6.63916394e-02f, 1.06175840e-02f, -4.32000980e-02f, 8.33941400e-02f, 5.85847124e-02f, 1.13980770e-01f, -2.76909433e-02f, 6.35828674e-02f, -1.18911155e-01f,
  -1.16116203e-01f, -6.83588628e-03f, 2.10319608e-01f, 1.65860891e-01f, 1.77140966e-01f, -8.99987146e-02f, 9.16215871e-03f, -7.97179639e-02f, 3.75036174e-03f, 1.20325051e-01f,
  5.28115146e-02f, 1.20431162e-01f, -1.20755108e-02f, -8.48320946e-02f, -6.91609085e-02f, 7.36882612e-02f, 6.83346167e-02f, -1.01366855e-01f, 1.40544157e-02f, 4.00049724e-02f,
  2.09861130e-01f, -1.07911043e-01f, -8.27033520e-02f, 1.32296950e-01f, 2.14131456e-02f, -3.04294359e-02f, -1.42302766e-01f, 1.10585555e-01f, 2.28493828e-02f, -1.03562728e-01f,
  2.20425520e-02f, 3.96363921e-02f, 1.05680510e-01f, 7.02781230e-02f, 3.06959804e-02f, -3.35302725e-02f, 7.83521906e-02f, -1.08279124e-01f, -8.80793482e-03f, -2.61176713e-02f,
  1.20602474e-02f, -1.52800113e-01f, 1.16320677e-01f, -1.45962939e-01f, 5.12743853e-02f, 3.10680941e-02f, 1.62548929e-01f, 5.69187105e-03f, 1.36653315e-02f, 7.75151625e-02f,
  2.27958430e-02f, -7.34871812e-03f, -4.63164747e-02f, 1.03013948e-01f, 4.26784121e-02f, -1.66468453e-02f, 9.80060771e-02f, -1.79764666e-02f, 6.96436642e-03f, -1.84805635e-02f,
  6.40648454e-02f, -6.08420484e-02f, -4.68497798e-02f, 8.57328475e-02f, -5.95220588e-02f, 4.28237617e-02f, 1.10389531e-01f, 8.44106004e-02f, -8.56723338e-02f, 1.42684244e-02f,
  -4.00015041e-02f, -8.50575566e-02f, -5.16704209e-02f, 5.81637695e-02f, -4.46725860e-02f, -6.26550987e-02f, 1.02325231e-01f, -1.25325873e-01f, 6.32610917e-02f, -1.91524308e-02f,
  6.66387519e-03f, 8.46027508e-02f, 1.17795996e-01f, -1.08884707e-01f, -6.40287921e-02f, 1.23130567e-01f, 8.70462805e-02f, -2.12916662e-03f, 6.25299513e-02f, 1.46645894e-02f,
  3.36295031e-02f, 8.21402743e-02f, 1.66265219e-01f, -1.08047333e-02f, 5.76060042e-02f, 1.47840753e-01f, -1.49879539e-02f, 6.68756142e-02f, -5.56021631e-02f, -1.32302806e-01f,
  -3.95417213e-02f, 9.60352551e-03f, 9.66165066e-02f, 3.84436697e-02f, -1.59349516e-01f, -1.80928767e-01f, -6.57806545e-03f, 1.20839514e-01f, -6.36675656e-02f, -3.35267596e-02f,
  -1.17283605e-01f, 3.12486757e-02f, -8.11785646e-03f, 2.38794014e-02f, -8.24622586e-02f, 1.81438729e-01f, -8.48258585e-02f, 2.08201949e-02f, -1.94621962e-02f, -5.07650413e-02f,
  5.09783393e-03f, 9.74158272e-02f, 9.35910940e-02f, 9.05249640e-02f, -1.55198006e-02f, 4.73410375e-02f, 3.82922441e-02f, 1.50182217e-01f, -1.32371306e-01f, -1.49187133e-01f,
  -1.08658448e-01f, 1.53543025e-01f, -6.28611371e-02f, -5.11224419e-02f, 2.35963725e-02f, 6.70599639e-02f, -8.77787247e-02f, 7.64741451e-02f, 8.74046385e-02f, -5.13425507e-02f,
  7.69798383e-02f, 1.55938137e-02f, 1.19197071e-02f, -9.08750668e-02f, 9.82938781e-02f, 1.03377149e-01f, 3.13169695e-02f, 1.41320666e-02f, 9.90989953e-02f, 7.21295699e-02f,
  3.87162678e-02f, 9.57066845e-03f, -1.03108078e-01f, -6.29034713e-02f, 3.94487381e-02f, -7.73381665e-02f, 5.14297262e-02f, -7.45548978e-02f, -6.15101308e-02f, -1.12373769e-01f,
  -3.81668061e-02f, 9.19770598e-02f, -1.76904872e-02f, 9.21153203e-02f, -9.31629092e-02f, -2.50024255e-02f, -1.10682324e-01f, 1.10812159e-02f, 9.40361544e-02f, 1.95934307e-02f,
  -5.59240282e-02f, 4.20398116e-02f, 3.34331021e-02f, -5.96772432e-02f, 1.38972104e-02f, 4.33186144e-02f, 5.84450476e-02f, 3.49881090e-02f, 8.38562399e-02f, -4.52255830e-02f,
  -9.40568000e-02f, 3.29355523e-02f, 1.15051856e-02f, -1.10337846e-01f, 3.88388969e-02f, 8.12226161e-02f, 5.46373054e-03f, -3.65649611e-02f, -1.38363382e-02f, 2.87576932e-02f,
  -3.46444659e-02f, -6.75434470e-02f, 3.00663952e-02f, -9.60328802e-02f, -7.89430887e-02f, 6.78101256e-02f, -1.25347987e-01f, -5.08533940e-02f, 5.16497530e-03f, 2.80636344e-02f,
  9.13707763e-02f, -1.11938708e-01f, 6.12760000e-02f, 1.77050810e-02f, 1.12945326e-01f, 4.77741560e-04f, 7.77120516e-02f, 1.02217868e-01f, 7.94779062e-02f, -3.72441411e-02f,
  2.25031413e-02f, 7.07873553e-02f, 8.41355026e-02f, -9.56011415e-02f, 2.65982002e-02f, -8.01512748e-02f, 3.64802778e-02f, -1.85094737e-02f, -1.24398112e-01f, -1.16954252e-01f,
  -5.96821457e-02f, -1.09822199e-01f, -5.58855906e-02f, -9.60379913e-02f, -8.36757123e-02f, -7.59559274e-02f, -1.07262738e-01f, -1.11919463e-01f, 5.43732755e-02f, -9.71953645e-02f,
  2.56677102e-02f, -1.17717482e-01f, 1.13667153e-01f, 5.78522906e-02f, 1.22612505e-03f, 3.03175431e-02f, -7.48419166e-02f, 7.95607120e-02f, -1.19173802e-01f, 8.93392712e-02f,
  -6.05895407e-02f, -1.18952598e-02f, -1.84867205e-03f, -1.05590433e-01f, 1.00429028e-01f, -3.20417737e-03f, 3.81162018e-02f, 8.27149078e-02f, 8.07139128e-02f, 8.87416955e-03f,
  -3.37763689e-02f, -4.67070192e-02f, -5.66705242e-02f, -7.56787658e-02f, -4.32882644e-02f, 8.27585831e-02f, 9.13528427e-02f, 7.74373487e-03f, -3.98923568e-02f, 3.20393383e-03f,
  -7.70258605e-02f, 9.65418741e-02f, -8.92058760e-02f, -1.03994094e-01f, -5.98032176e-02f, -8.66042748e-02f, -5.29187098e-02f, 1.08806282e-01f, -1.25997722e-01f, -4.31542583e-02f,
  4.13546711e-03f, 8.25575832e-03f, 9.84371305e-02f, -1.99994049e-03f, -9.41022560e-02f, 1.00517958e-01f, -3.48287858e-02f, -7.55451396e-02f, 1.17114805e-01f, 1.56734541e-01f,
  2.58454029e-02f, -5.99861203e-04f, 5.12618348e-02f, -8.61418620e-02f, -3.11183296e-02f, -7.44053945e-02f, -1.35032767e-02f, 8.63149911e-02f, 1.60916969e-01f, 1.20097503e-01f,
  -2.29555100e-01f, -5.78924492e-02f, -2.50982523e-01f, -2.08961129e-01f, 3.38031381e-01f, 1.76320121e-01f, -8.81351382e-02f, -7.14802146e-02f, 4.83839307e-03f, 5.09779155e-02f,
  2.49823984e-02f, -2.21489012e-01f, -1.01926118e-01f, -1.15065746e-01f, 9.45290178e-02f, -4.26737405e-02f, 2.24542301e-02f, 2.98009276e-01f, 9.47756842e-02f, -6.02470003e-02f,
  1.34079084e-01f, -2.83155069e-02f, 5.66343628e-02f, 2.01323390e-01f, -1.65213749e-01f, -6.91609681e-02f, -1.19852781e-01f, 7.90876374e-02f, -1.31314650e-01f, 2.78870463e-02f,
  1.07792377e-01f, 1.54742897e-01f, 3.31336379e-01f, -1.21435516e-01f, 1.64962277e-01f, -2.52434641e-01f, 3.67954262e-02f, 3.60706821e-02f, -1.07919909e-01f, 1.30301997e-01f,
  1.14592575e-01f, -9.67799872e-02f, -6.37713820e-02f, -1.23943388e-01f, 1.10561557e-01f, 3.10618244e-03f, -3.36649828e-02f, -7.30064604e-03f, 7.28774816e-02f, -1.64235327e-02f,
  3.00143301e-01f, 6.99245483e-02f, -4.56752554e-02f, 3.83705050e-02f, 6.31465390e-02f, 9.85353366e-02f, 1.74678952e-01f, 2.00077131e-01f, 1.53965876e-01f, -1.02673294e-02f,
  -1.15288973e-01f, 6.18842319e-02f, 9.02652144e-02f, 6.02866374e-02f, 1.18726127e-01f, 6.69998229e-02f, 2.39943042e-01f, 3.31115752e-01f, -3.58165234e-01f, -1.53516429e-02f,
  7.46789202e-02f, 2.51908809e-01f, 2.58427262e-02f, -4.76817787e-02f, -2.10871268e-03f, 4.32820655e-02f, 2.54888237e-01f, 4.57663983e-02f, -7.89134651e-02f, 9.16891545e-02f,
  1.02235600e-02f, -8.92662629e-03f, 6.96301088e-02f, 9.04895142e-02f, -1.24402814e-01f, -5.48246689e-02f, -1.52558861e-02f, 1.69448685e-02f, 1.96529403e-01f, -3.33851166e-02f,
  -1.06922142e-01f, -3.40672620e-02f, 1.57046050e-01f, 3.96411940e-02f, -9.62931588e-02f, -8.45085755e-02f, 2.27561280e-01f, -1.00731291e-02f, 5.28612971e-01f, 3.26105386e-01f,
  2.90991604e-01f, -2.33181175e-02f, 6.03932664e-02f, 8.02840143e-02f, 1.79585116e-03f, -4.53679599e-02f, 1.99324906e-01f, 9.35695246e-02f, -4.32263769e-04f, 9.68409032e-02f,
  1.05561197e-01f, -5.38991988e-02f, 1.64426994e-02f, -1.11756057e-01f, 1.08753912e-01f, 1.48538277e-01f, 5.08510098e-02f, -8.88946801e-02f, 1.55676320e-01f, 1.62968025e-01f,
  3.34001407e-02f, 8.31202865e-02f, 3.86488661e-02f, 5.53516895e-02f, 4.64209691e-02f, 9.79924053e-02f, -1.90301463e-02f, 2.64691133e-02f, -2.17263252e-02f, -2.11765423e-01f,
  -1.07576758e-01f, 1.75461009e-01f, 3.02289337e-01f, 8.83437991e-02f, -5.70026524e-02f, -1.72116190e-01f, -2.36353606e-01f, -1.15789436e-01f, -1.72436580e-01f, 1.79330558e-01f,
  -1.41788229e-01f, -5.25359251e-02f, 5.31304292e-02f, 3.86576802e-02f, 2.21596524e-01f, 2.47915819e-01f, -8.25443342e-02f, -6.97048083e-02f, 1.24525599e-01f, 6.10157549e-02f,
  -9.58703011e-02f, 1.55744001e-01f, -1.01093449e-01f, -1.69654414e-01f, -9.39718336e-02f, 1.91223040e-01f, 1.16720848e-01f, 1.43698767e-01f, 1.71213657e-01f, 8.93344805e-02f,
  3.91617157e-02f, -1.21202752e-01f, 2.07305282e-01f, 7.10259471e-03f, 9.04151574e-02f, 3.42216305e-02f, 1.10245068e-02f, 3.46328653e-02f, -5.27458563e-02f, -4.01026644e-02f,
  -1.13607720e-01f, -1.79816168e-02f, 1.56980321e-01f, 7.39359483e-02f, -3.91671099e-02f, -2.86205653e-02f, -3.16190682e-02f, -1.07816488e-01f, 1.91424400e-01f, -1.04517229e-01f,
  4.28684652e-02f, 4.99455445e-02f, 2.04042450e-01f, 8.63897672e-04f, 1.83025431e-02f, 1.49604931e-01f, -1.29225310e-02f, -3.47439907e-02f, 2.16089748e-02f, 1.58861250e-01f,
  1.97444439e-01f, 1.76765889e-01f, -7.80228451e-02f, 4.03954834e-02f, -2.87346393e-01f, -2.19601750e-01f, 2.27902174e-01f, -1.12665966e-01f, -1.46461695e-01f, -3.20397899e-03f,
  -1.61978811e-01f, 3.24062079e-01f, -4.30470444e-02f, -1.94609195e-01f, -1.98939115e-01f, -7.60545069e-03f, 9.52835456e-02f, -2.92589813e-02f, 1.77050959e-02f, 2.04086989e-01f,
  1.01192705e-01f, -1.00245573e-01f, -5.05053662e-02f, 3.72347161e-02f, -7.63219818e-02f, 1.26999468e-01f, -4.73009422e-02f, -1.03566311e-02f, -6.62535504e-02f, 1.46601617e-01f,
  -4.93077450e-02f, 4.46425937e-02f, -2.45481841e-02f, -1.19522788e-01f, -8.43672901e-02f, 1.90170929e-01f, 7.71035580e-03f, -5.62573560e-02f, 2.02892825e-01f, -7.42576923e-03f,
  2.03969143e-02f, -5.27117550e-02f, 1.12087831e-01f, 1.80842593e-01f, -1.70388579e-01f, 6.22934997e-02f, -1.27042890e-01f, -6.45630136e-02f, -5.16569614e-02f, 4.81508598e-02f,
  6.69709668e-02f, -2.67662518e-02f, 8.28036964e-02f, -1.64654478e-01f, 2.37012088e-01f, -9.92802554e-04f, 1.40754670e-01f, 1.79010898e-01f, 7.73810819e-02f, 4.29830663e-02f,
  2.99395114e-01f, 1.42312795e-01f, 7.10974485e-02f, 1.87766418e-01f, 2.40426093e-01f, 1.78429738e-01f, 2.17751086e-01f, -8.80582482e-02f, 1.94114268e-01f, -1.91610187e-01f,
  -2.63927579e-01f, -6.40566871e-02f, -2.42421720e-02f, -1.05420552e-01f, -1.06852166e-02f, 1.47068739e-01f, 9.69876423e-02f, 1.14960656e-01f, 6.26880676e-02f, 1.80766612e-01f,
  -1.24264002e-01f, 1.22338034e-01f, -1.37167990e-01f, 1.57370478e-01f, -6.77369460e-02f, -1.07608810e-01f, 1.23327896e-01f, -6.71929866e-02f, -9.46447477e-02f, 2.85644755e-02f,
  -1.78911820e-01f, 2.98048258e-01f, -8.56088847e-02f, 1.59758478e-02f, 6.10587113e-02f, -1.66965444e-02f, -8.98481905e-02f, -1.17243752e-01f, -1.96421854e-02f, 3.08189452e-01f,
  -1.27249241e-01f, 7.69971535e-02f, -1.09336734e-01f, 7.50857592e-02f, 1.35551289e-01f, -1.28873974e-01f, -3.36341076e-02f, 5.28440475e-02f, 4.96595679e-03f, -5.48822582e-02f,
  1.97182238e-01f, 1.93097308e-01f, -9.28486958e-02f, 8.03230032e-02f, -1.00738570e-01f, -4.27195765e-02f, -4.02557254e-02f, -9.40710902e-02f, 1.56637311e-01f, 2.61941403e-01f,
  -1.06447421e-01f, 1.44390255e-01f, 3.62064764e-02f, 1.11962877e-01f, 2.14146495e-01f, -2.78149713e-02f, 2.24097028e-01f, 5.92618659e-02f, 2.10549444e-01f, 2.02147067e-01f,
  -1.40739650e-01f, -8.84658620e-02f, 3.94908637e-01f, -1.36645004e-01f, -1.39219567e-01f, 2.24508345e-01f, 2.87257850e-01f, -1.03417680e-01f, 4.26275730e-02f, -2.91178733e-01f,
  -1.65171027e-01f, 1.25346750e-01f, 2.80628949e-01f, -1.80079058e-01f, -2.16580350e-02f, -6.62046894e-02f, -4.18388508e-02f, 1.20978817e-01f, -1.74124137e-01f, 5.05175255e-02f,
  2.35351846e-02f, -1.18074887e-01f, 3.83257158e-02f, -2.14630336e-01f, -2.41702273e-01f, 9.01204199e-02f, 1.21576063e-01f, -1.97172329e-01f, -1.10942572e-01f, 3.55138302e-01f,
  -2.64939945e-03f, 4.56131369e-01f, 2.88422287e-01f, -6.06954359e-02f, 3.09929758e-01f, 1.14282615e-01f, -3.72324318e-01f, -2.65651196e-02f, 2.86450744e-01f, 1.09435380e-01f,
  1.26079291e-01f, -1.77928075e-01f, -1.22920193e-01f, -1.43084973e-01f, 3.89862806e-01f, 4.63023186e-02f, 1.30541638e-01f, 1.44770205e-01f, -6.37973566e-03f, -1.11080557e-02f,
  1.02496229e-01f, -2.02986524e-02f, -4.09458689e-02f, 6.68251067e-02f, -2.06689048e-03f, -1.18655033e-01f, 7.22916052e-02f, 1.48364734e-02f, 2.24992912e-02f, 7.43049383e-02f,
  1.81962490e-01f, 5.40004820e-02f, 1.09827816e-01f, 4.65756468e-02f, 1.74074806e-02f, 4.29228917e-02f, 1.92762718e-01f, 2.44751483e-01f, 1.48555525e-02f, 1.51100859e-01f,
  2.39924327e-01f, 3.25005442e-01f, -8.60185921e-02f, -1.23835847e-01f, 6.89212456e-02f, -3.18744294e-02f, 1.70484260e-01f, -4.59151417e-02f, -6.91623194e-03f, -7.30017573e-02f,
  -1.58242121e-01f, -7.45931342e-02f, 9.93220359e-02f, -9.17968079e-02f, 9.50104296e-02f, 4.57628816e-02f, -9.07379612e-02f, 2.04520166e-01f, 2.81702936e-01f, -4.95213643e-02f,
  6.58276379e-02f, -1.25170842e-01f, 1.55938447e-01f, -1.64776102e-01f, -3.45528349e-02f, -3.13268863e-02f, 2.03160867e-01f, 3.12432274e-02f, 5.54639041e-01f, 3.18834960e-01f,
  1.69710711e-01f, -2.29678899e-02f, 6.49705976e-02f, 1.02244161e-01f, -7.21826032e-02f, 3.45211513e-02f, 1.19772684e-02f, 4.44859751e-02f, -8.04454759e-02f, 8.39844123e-02f,
  1.09758630e-01f, -4.71201651e-02f, 6.11601248e-02f, 5.86270131e-02f, -1.25437118e-02f, -1.30721638e-02f, 4.61279647e-03f, -8.56157914e-02f, 2.71515828e-03f, -1.00134082e-01f,
  5.92564829e-02f, -7.63923898e-02f, 1.48635134e-02f, -1.21244647e-01f, 5.07481322e-02f, -1.36057464e-02f, 6.01935619e-03f, 2.31036507e-02f, 5.26142232e-02f, -6.16066121e-02f,
  6.74934238e-02f, -8.35464988e-03f, 5.38196489e-02f, 4.82049175e-02f, -4.49094223e-03f, -7.41226748e-02f, 2.45822221e-02f, -1.26356587e-01f, 8.38914886e-02f, 3.27601582e-02f,
  -1.18866540e-01f, -7.14763701e-02f, -5.45489341e-02f, 3.37293558e-02f, -5.94828911e-02f, 4.00101542e-02f, 2.53102765e-03f, 6.11129850e-02f, -8.50465521e-02f, 1.07675068e-01f,
  1.01571657e-01f, -4.63038124e-02f, 8.02682340e-02f, -6.72008991e-02f, -9.00137424e-02f, -1.83527526e-02f, 2.82042869e-03f, -4.21756431e-02f, 1.14141032e-02f, 4.51476723e-02f,
  1.19887814e-01f, -3.98467481e-02f, 1.23671487e-01f, -5.37629463e-02f, 3.05546615e-02f, -1.56215467e-02f, -3.93689573e-02f, 6.36865273e-02f, 1.10529497e-01f, -3.37170810e-02f,
  1.50486469e-01f, -2.97199506e-02f, 1.47424908e-02f, -7.79248774e-02f, 8.71353894e-02f, -5.25856502e-02f, 3.89612317e-02f, -6.26066932e-03f, 5.40235341e-02f, 9.12062824e-02f,
  9.93539020e-03f, 5.30388653e-02f, 2.20604446e-02f, 1.09049872e-01f, 7.34044984e-02f, 1.72808781e-01f, 1.07157029e-01f, 1.54854044e-01f, 1.85480714e-02f, 4.92155831e-03f,
  3.54617648e-03f, -7.86438882e-02f, -3.05420570e-02f, 1.62989765e-01f, -1.61934011e-02f, -1.54501498e-02f, 5.46297990e-02f, -1.84341162e-01f, -7.28238076e-02f, 1.50778309e-01f,
  -7.15358481e-02f, 1.52929425e-01f, 9.23019350e-02f, -1.50827318e-01f, -9.74345580e-02f, -1.83443241e-02f, 1.52222291e-01f, 8.45139101e-02f, -1.76818902e-03f, 4.73144390e-02f,
  -6.04703240e-02f, -3.84440027e-05f, -6.74914792e-02f, 4.00733575e-02f, -1.91596765e-02f, 1.47359237e-01f, 2.34886870e-01f, 9.82589796e-02f, -4.16181237e-02f, 1.92053154e-01f,
  -1.35275945e-02f, 2.99476665e-02f, 8.21356624e-02f, -1.03407316e-01f, 3.28859373e-04f, 1.86347410e-01f, -9.83245224e-02f, -3.65282875e-03f, 2.51577884e-01f, -8.42116922e-02f,
  7.70486370e-02f, 1.71339866e-02f, -8.59847441e-02f, 1.71231136e-01f, 4.59419824e-02f, -1.72234233e-02f, -1.61240324e-01f, 3.78683060e-02f, 3.93909216e-02f, 6.87190518e-02f,
  1.95174292e-01f, 1.19263222e-02f, -5.61088435e-02f, -1.90421250e-02f, -6.70495331e-02f, -5.59358932e-02f, -3.84566188e-02f, 2.86429022e-02f, -8.70875940e-02f, 7.08265975e-02f,
  1.82693321e-02f, -1.66283902e-02f, 6.05605617e-02f, -7.31901377e-02f, -5.80212893e-03f, -5.26658669e-02f, 1.77332256e-02f, -3.85403186e-02f, -6.25663474e-02f, -1.20123319e-01f,
  1.69123143e-01f, -3.89025360e-02f, 3.20593901e-02f, -8.44188556e-02f, -9.52142291e-03f, -1.32551983e-01f, 9.42330733e-02f, -9.92075354e-02f, -1.04733149e-03f, 5.47418185e-02f,
  1.35005489e-01f, -6.38426393e-02f, 1.14407398e-01f, 5.08175716e-02f, 1.18573539e-01f, 7.37061277e-02f, -7.44280443e-02f, 1.04371399e-01f, -3.19094583e-02f, -1.90951265e-02f,
  -9.89972278e-02f, 1.13680027e-01f, 4.13886867e-02f, -2.03562882e-02f, -1.68636218e-02f, 7.87585080e-02f, 1.60585362e-02f, -9.61703211e-02f, 2.81874426e-02f, -1.61538627e-02f,
  3.04301865e-02f, -7.85475001e-02f, -8.40406120e-03f, 8.18970799e-02f, 3.55978757e-02f, 8.26736167e-02f, 1.42381834e-02f, -5.72476499e-02f, 1.14987463e-01f, 9.44697484e-02f,
  1.35574220e-02f, -1.31912693e-01f, -1.20991677e-01f, -5.17660845e-03f, -1.19314723e-01f, -8.02906677e-02f, -9.76353288e-02f, -3.18531692e-02f, -4.22242433e-02f, 1.18107408e-01f,
  1.00231782e-01f, -9.09667090e-02f, -1.13109052e-01f, 1.09783530e-01f, -8.02288428e-02f, 3.52558270e-02f, 2.62880698e-02f, 5.80906458e-02f, 1.18710995e-01f, 1.31824195e-01f,
  1.80001095e-01f, 1.93082109e-01f, -1.12642147e-01f, -4.17181142e-02f, 9.20312330e-02f, -6.85194284e-02f, -3.91261168e-02f, -4.89037745e-02f, -2.90814508e-02f, -1.75678417e-01f,
  6.68843538e-02f, -7.64426589e-02f, 1.37220979e-01f, 1.48320794e-01f, 1.84025064e-01f, -5.01591042e-02f, -8.68671834e-02f, 5.48688928e-03f, 2.45132279e-02f, 5.21561783e-03f,
  -5.80982491e-02f, 8.06666017e-02f, -5.63390516e-02f, -7.76069164e-02f, 7.98621550e-02f, -1.22617725e-02f, 6.68777823e-02f, -3.96731794e-02f, 1.61688644e-02f, 2.33471274e-01f,
  -1.55016240e-02f, -9.59224179e-02f, -4.12697196e-02f, -4.94502932e-02f, 2.65288502e-02f, 1.23288110e-01f, 2.41403803e-02f, 2.02785935e-02f, -3.12391799e-02f, -6.90780173e-04f,
  -4.04484123e-02f, 1.14925854e-01f, 2.07449064e-01f, 5.22515550e-02f, -1.04393706e-01f, 2.50361636e-02f, -1.18273340e-01f, 3.20157930e-02f, 8.09580386e-02f, 4.97696847e-02f,
  -1.81613099e-02f, 1.55809792e-02f, 1.34438351e-01f, 3.20188999e-02f, 8.04192945e-02f, 6.58188984e-02f, 1.57449320e-01f, 5.24539873e-02f, 1.39274046e-01f, -1.28943231e-02f,
  1.03307955e-01f, 1.03142656e-01f, 3.34718218e-03f, 2.18646631e-01f, -1.09426051e-01f, -1.18206672e-01f, 3.76927853e-02f, 1.07517431e-03f, -1.19203843e-01f, -6.24333173e-02f,
  -1.13790981e-01f, 7.37065226e-02f, -1.51139840e-01f, 1.25843883e-01f, -3.23335677e-02f, 5.21141978e-04f, 3.58112268e-02f, 1.78920403e-02f, 5.34047559e-02f, 1.21265888e-01f,
  1.34650275e-01f, 1.81216866e-01f, -9.65521187e-02f, -5.35317557e-03f, 2.60711703e-02f, -1.41576737e-01f, 6.36390969e-02f, 3.61050144e-02f, 4.45407405e-02f, 7.95880556e-02f,
  -5.76497912e-02f, 8.68991856e-03f, -3.15242857e-02f, -8.95231590e-02f, -4.59107086e-02f, 1.08889177e-01f, -8.48164186e-02f, 1.37012526e-01f, -6.21400513e-02f, -4.17450443e-02f,
  1.39195547e-01f, 1.00127414e-01f, 9.58305597e-03f, 9.66841131e-02f, -1.85009348e-03f, 1.20297723e-01f, -9.68888775e-02f, -6.24450147e-02f, 9.87042338e-02f, 2.27473099e-02f,
  -1.31784573e-01f, 1.03274196e-01f, -1.22302808e-01f, 9.57375541e-02f, -5.92106255e-03f, 9.79698449e-02f, -6.44142255e-02f, -1.16444655e-01f, 9.18153673e-02f, 9.88811925e-02f,
  1.44074298e-02f, -6.73167557e-02f, 9.05392990e-02f, -7.67139252e-03f, 1.64201707e-01f, -4.41312790e-02f, 1.43421367e-01f, 7.61935338e-02f, 1.66849226e-01f, 1.65498078e-01f,
  -1.62838221e-01f, 3.65829282e-02f, 4.29359339e-02f, 2.06736624e-02f, -1.90894693e-01f, -3.46900702e-01f, 2.82015979e-01f, -2.53650069e-01f, 2.97821872e-02f, -1.53031871e-02f,
  8.92570913e-02f, -1.22638727e-02f, -3.55928726e-02f, 1.18500758e-02f, 1.13101676e-01f, 8.28037336e-02f, 1.45949617e-01f, 9.88730937e-02f, -1.20659925e-01f, 8.23450387e-02f,
  -8.70936438e-02f, -1.66994721e-01f, -1.13759659e-01f, -1.19339876e-01f, 5.80954887e-02f, 1.95360526e-01f, -1.68256894e-01f, 4.81069267e-01f, 6.42196881e-03f, 1.46828741e-01f,
  5.41724972e-02f, 3.64793390e-02f, -6.09490909e-02f, -9.65830758e-02f, 1.42891943e-01f, -9.22115371e-02f, -8.87207920e-04f, -2.63216309e-02f, -1.34179831e-01f, 5.17902710e-02f,
  1.69688836e-01f, -4.43844050e-02f, 7.74576589e-02f, 5.52056320e-02f, -1.13250110e-02f, 1.95839286e-01f, -1.17280185e-01f, 7.36124367e-02f, -1.35014147e-01f, 1.17934085e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  4.34874073e-02f, -1.09146093e-03f, 7.17702806e-02f, -3.84692550e-02f, 1.64774120e-01f, -2.44429391e-02f, -3.75471450e-02f, 3.29768509e-02f, -7.92974383e-02f, 7.83326849e-03f,
  5.02650067e-02f, 7.81349540e-02f, 5.96364513e-02f, 1.38581514e-01f, 1.35819465e-01f, 5.40297441e-02f, 7.86281824e-02f, -9.48489010e-02f, 6.25005960e-02f, -1.30817136e-02f,
  9.61154103e-02f, 9.33167189e-02f, 3.61462347e-02f, 2.74732541e-02f, 3.25299799e-02f, 3.88110466e-02f, -5.14318086e-02f, 4.39548492e-02f, 4.90415953e-02f, -1.01257034e-01f,
  2.40687713e-01f, 1.20357521e-01f, 1.04375072e-01f, 5.29522039e-02f, 2.83610150e-02f, 5.89308962e-02f, 4.48143445e-02f, 1.54780015e-01f, 1.83527902e-01f, 1.36447519e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -6.73873127e-02f, -1.57442331e-01f, 2.69895345e-01f, 3.02498490e-01f, 1.66950241e-01f, -7.69669712e-02f, 3.63618620e-02f, 2.55134851e-01f, 1.54634878e-01f, 3.36135745e-01f,
  1.04428396e-01f, 1.56821430e-01f, 3.42294157e-01f, -6.17910981e-01f, -1.19783372e-01f, -9.67735499e-02f, -1.15598239e-01f, 3.86724770e-01f, -6.74831774e-03f, -2.55799472e-01f,
  -2.52861112e-01f, 1.93709806e-01f, -3.59571934e-01f, 1.61734089e-01f, -1.78120002e-01f, -1.19671248e-01f, -1.01654537e-01f, -1.44998953e-01f, -3.51179808e-01f, -5.40640317e-02f,
  -1.80616826e-02f, -3.04547176e-02f, -3.30901854e-02f, -2.65979618e-01f, 4.01020497e-01f, -7.03305975e-02f, 4.51115854e-02f, 3.85062285e-02f, 1.76785603e-01f, -1.94054842e-01f,
  -3.18717174e-02f, -2.14122119e-03f, 3.87933046e-01f, -9.22826827e-02f, -1.56468153e-01f, -1.86677143e-01f, 2.30893847e-02f, -1.88924119e-01f, 1.80347174e-01f, 6.09930195e-02f,
  -3.03076487e-02f, -1.68656409e-01f, -5.62964156e-02f, -1.67028740e-01f, 3.94297361e-01f, 3.52553189e-01f, -3.32077354e-01f, -8.39198765e-04f, 4.81604628e-04f, 3.49065810e-01f,
  -1.88968219e-02f, -1.14308961e-01f, 3.64970386e-01f, -3.61714572e-01f, 2.08111465e-01f, 2.75698423e-01f, 4.69319403e-01f, 4.16271955e-01f, 2.52212465e-01f, 4.22627538e-01f,
  1.27404451e-01f, -3.74169558e-01f, 2.38289624e-01f, -9.00312439e-02f, 2.94804871e-01f, -2.12131456e-01f, 8.89854282e-02f, -7.78317824e-02f, 2.09555373e-01f, 2.23641261e-01f,
  -9.95664448e-02f, 4.00149934e-02f, 1.64096922e-01f, -3.94252747e-01f, -2.10613877e-01f, 4.35538471e-01f, 2.31953934e-01f, 4.14644539e-01f, -1.22718923e-01f, -5.07561900e-02f,
  -1.46108955e-01f, 3.89477521e-01f, 5.79716563e-01f, -2.50276382e-04f, 1.22368850e-01f, 2.04150155e-01f, -1.87711656e-01f, -1.66949898e-01f, 2.64416169e-02f, -5.20827100e-02f,
  -9.24578980e-02f, 1.14482222e-02f, 5.18512428e-02f, 1.84761137e-01f, 1.39207691e-02f, -1.41379893e-01f, -1.84794337e-01f, -2.35965893e-01f, -1.73854291e-01f, 3.87160107e-02f,
  -9.56172198e-02f, 8.00120905e-02f, 8.61141160e-02f, 2.52459962e-02f, -1.25762150e-01f, -2.57588625e-01f, -1.53058648e-01f, -2.61173934e-01f, 6.90658987e-02f, 5.17127752e-01f,
  -1.14860669e-01f, -3.04102123e-01f, -3.93912233e-02f, 4.08552699e-02f, -8.93186331e-02f, 1.36788845e-01f, 8.59793052e-02f, 2.63433307e-01f, -2.59886116e-01f, 1.11651206e-02f,
  1.29779731e-03f, 9.66544524e-02f, -1.25514299e-01f, -4.60315526e-01f, -6.53531626e-02f, -3.26630771e-01f, -8.10162127e-02f, 1.63625345e-01f, -9.90523770e-02f, -3.66065763e-02f,
  2.91427523e-01f, 3.67129683e-01f, 4.62990671e-01f, -1.97247729e-01f, 8.98453668e-02f, -3.65658581e-01f, -1.57235220e-01f, -2.27596417e-01f, -1.71477627e-02f, 1.10985890e-01f,
  3.86808008e-01f, 1.62315276e-02f, -9.82653499e-02f, 6.43240241e-03f, 1.05527066e-01f, 1.05533563e-01f, 2.93694168e-01f, 1.43377818e-02f, 3.58083355e-03f, 2.47695714e-01f,
  -2.29102885e-03f, 1.48219720e-01f, -1.88693091e-01f, 3.60175520e-02f, 4.42820966e-01f, 1.11267157e-02f, -1.37271062e-01f, -2.94881761e-02f, 2.18912736e-01f, -1.83111448e-02f,
  -1.47584856e-01f, -4.21890736e-01f, 3.18020545e-02f, 5.78271113e-02f, -1.36566907e-01f, -1.29261129e-02f, 6.26554200e-03f, -1.71766747e-02f, 6.49165288e-02f, -5.26111871e-02f,
  1.23218559e-01f, -2.82969661e-02f, -6.16851412e-02f, -2.26333797e-01f, -6.31202340e-01f, -6.09785020e-02f, 1.92066133e-02f, 1.70148477e-01f, 1.84934095e-01f, 2.53563762e-01f,
  -6.56352341e-02f, 4.49396670e-01f, -9.29419473e-02f, 1.00612633e-01f, -2.81617254e-01f, -3.08063537e-01f, 1.22569472e-01f, -4.39738818e-02f, -8.82269666e-02f, -1.99428126e-01f,
  7.68031627e-02f, -1.79095790e-01f, -3.52112427e-02f, -1.72615588e-01f, -1.43763855e-01f, -2.80277699e-01f, -1.26021132e-01f, -3.92245740e-01f, 1.16418272e-01f, 2.55248219e-01f,
  -1.24821909e-01f, 5.63684344e-01f, 2.69258827e-01f, -2.01213017e-01f, -3.53141785e-01f, -1.54593766e-01f, 3.54720891e-01f, 1.72706358e-02f, 1.13217272e-01f, -4.03030403e-02f,
  -4.69948858e-01f, 3.97567272e-01f, 7.24011064e-02f, 2.33981628e-02f, 9.50645059e-02f, 1.71834037e-01f, 2.36581806e-02f, -1.87865719e-01f, -4.08522576e-01f, 7.42360055e-02f,
  -8.05548728e-02f, -8.90969262e-02f, 2.18127165e-02f, -3.70925814e-02f, 1.59005687e-01f, 1.31384850e-01f, 2.31669784e-01f, -1.63379267e-01f, 1.28766373e-01f, -6.28406480e-02f,
  5.50677860e-03f, -6.97650835e-02f, -5.39907143e-02f, 4.51216012e-01f, -2.65755326e-01f, 3.59091401e-01f, 2.43763998e-01f, -3.62283140e-02f, -3.74041647e-02f, -2.38232225e-01f,
  -1.40498159e-02f, -1.74559578e-01f, 7.59974793e-02f, -1.22666679e-01f, 6.56932071e-02f, -9.66434106e-02f, 7.68480971e-02f, 2.89008290e-01f, -2.77944326e-01f, 3.89252126e-01f,
  4.74096835e-02f, 4.01700824e-01f, 7.91876093e-02f, 2.47788936e-01f, -3.95573862e-02f, -3.04474443e-01f, -1.20805643e-01f, 2.29287855e-02f, 6.00454025e-02f, -1.21516131e-01f,
  -3.91806066e-02f, 1.33497059e-01f, -2.23836049e-01f, 1.51437402e-01f, -1.98782831e-01f, 4.35451984e-01f, -1.23150609e-01f, -2.11832285e-01f, -1.15237795e-02f, -2.70155162e-01f,
  3.50881636e-01f, 9.69347171e-03f, -2.80084787e-03f, -2.62516856e-01f, -3.72479916e-01f, 2.83890720e-02f, -8.21124855e-03f, -1.15369044e-01f, 1.53137669e-01f, -1.21654615e-01f,
  -1.01744346e-01f, -1.77198321e-01f, 2.56120235e-01f, -2.34471895e-02f, 2.48067398e-02f, -1.41573370e-01f, 1.60536036e-01f, -1.18853532e-01f, 3.58642280e-01f, 7.47460350e-02f,
  -1.25260934e-01f, 1.05375722e-01f, 6.63723722e-02f, -2.01859564e-01f, 1.05901249e-01f, -7.83722699e-02f, -5.16016074e-02f, 7.78402537e-02f, 3.12889904e-01f, 4.62935746e-01f,
  7.48296827e-02f, -2.94042602e-02f, -2.43741930e-01f, 3.09225380e-01f, -9.12092254e-02f, 9.63474289e-02f, -5.52885560e-03f, -8.00296590e-02f, 1.47147387e-01f, -2.97783643e-01f,
  2.57635713e-01f, 4.39059198e-01f, -1.65282488e-01f, -5.97967394e-02f, 7.26558939e-02f, 1.42430842e-01f, 2.10441947e-01f, -9.04525537e-03f, 9.11682006e-03f, 4.19591188e-01f,
  -1.43424779e-01f, 3.46914795e-03f, 2.53877491e-02f, 5.70502877e-02f, -1.91063672e-01f, 4.83015656e-01f, -2.13423133e-01f, 1.34061938e-02f, 1.76162332e-01f, -1.67957246e-01f,
  2.68761441e-02f, 1.77930016e-02f, -2.99261093e-01f, 2.44770959e-01f, -2.20128777e-03f, -1.25001982e-01f, -2.69120280e-02f, 1.38873160e-01f, -4.26332690e-02f, -1.92644417e-01f,
  1.24350309e-01f, -2.33413920e-01f, -8.98754820e-02f, -2.90138185e-01f, 3.39762688e-01f, -1.04815073e-01f, -2.32477531e-01f, -5.65149076e-03f, 8.16688836e-02f, -1.91201031e-01f,
  -2.71244466e-01f, -5.21784313e-02f, 6.56211674e-02f, 3.29155326e-01f, -6.92429021e-02f, -1.13543369e-01f, 1.56794377e-02f, 2.10532919e-02f, -1.25567704e-01f, -1.08970881e-01f,
  9.37369242e-02f, -3.25526357e-01f, 3.15555155e-01f, -1.87290043e-01f, -3.38728815e-01f, 4.46832001e-01f, 6.12313867e-01f, 5.97192049e-02f, -1.09394781e-01f, -8.27884153e-02f,
  4.24082354e-02f, -2.69344226e-02f, 1.30853280e-01f, -1.86710820e-01f, 1.70491576e-01f, -1.94675326e-01f, 2.08473429e-01f, -8.24766383e-02f, -2.25672290e-01f, -4.73123789e-01f,
  -4.12912853e-02f, -2.63514966e-01f, -1.13682680e-01f, -1.27634527e-02f, 1.56921387e-01f, -3.15781264e-03f, -2.14392934e-02f, 1.97765887e-01f, -2.66764194e-01f, 2.42118195e-01f,
  1.43828973e-01f, -1.84752926e-01f, 1.77930016e-02f, -2.53075123e-01f, -2.27749795e-01f, -4.04833913e-01f, -7.61313811e-02f, 2.26718709e-01f, -3.11628044e-01f, 1.23857409e-01f,
  8.23674500e-02f, -9.37786773e-02f, 3.38181138e-01f, -1.01079233e-01f, -1.23343915e-01f, -2.41649106e-01f, 2.36705169e-02f, 9.87328812e-02f, -5.60209416e-02f, -9.65243280e-02f,
  3.71448874e-01f, -7.75839537e-02f, -4.62536439e-02f, 1.40266661e-02f, 2.51816232e-02f, -9.93436873e-02f, -5.01511335e-01f, -6.03234805e-02f, -1.64670959e-01f, 7.14695305e-02f,
  -2.05997631e-01f, 1.64869517e-01f, -9.88079458e-02f, 5.81132956e-02f, -6.71471208e-02f, -3.07933122e-01f, 2.55280763e-01f, -1.07520655e-01f, -1.44024611e-01f, -5.90729304e-02f,
  4.17678714e-01f, 1.41694844e-01f, -1.24473363e-01f, -2.42055550e-01f, -1.26722634e-01f, 8.63485783e-02f, -6.60184473e-02f, 2.76088208e-01f, -2.23887980e-01f, -2.56065369e-01f,
  -4.97392751e-02f, 1.03926301e-01f, -1.16770985e-02f, 5.66953346e-02f, -5.46124429e-02f, -1.43827796e-01f, -2.90992409e-01f, -3.62975560e-02f, -8.51931348e-02f, 4.19582836e-02f,
  -7.90957212e-02f, 2.66220123e-01f, 1.58603564e-01f, 1.66477580e-02f, 7.51637816e-02f, 3.07488024e-01f, -2.97486242e-02f, 3.18657100e-01f, 3.27738941e-01f, 1.20292678e-01f,
  -7.96336308e-02f, -9.30498391e-02f, 2.71887388e-02f, 1.57035857e-01f, -8.99551287e-02f, -1.28351226e-01f, -2.18735486e-02f, 9.48575214e-02f, -7.44177774e-02f, 1.32144973e-01f,
  1.34767368e-01f, -2.31508791e-01f, 3.02316453e-02f, 2.88839549e-01f, -4.64383811e-01f, 9.00923833e-03f, 1.24315515e-01f, 5.30944943e-01f, 7.45286793e-02f, -1.23277113e-01f,
  3.67485553e-01f, -2.38057286e-01f, 2.07219794e-01f, -1.71552360e-01f, 2.12638959e-01f, -4.16454347e-03f, -2.08804935e-01f, -1.46528725e-02f, -1.49387894e-02f, 3.74758244e-01f,
  -3.64978760e-02f, -1.45165354e-01f, 7.62933493e-02f, -3.13538939e-01f, 3.43029529e-01f, 2.16831505e-01f, 8.58869180e-02f, 7.74099007e-02f, -2.87876427e-02f, -9.44189914e-03f,
  -2.01817825e-01f, -2.12974444e-01f, 2.23292530e-01f, 9.41623375e-02f, 1.55393898e-01f, -3.53466064e-01f, 2.56263483e-02f, 2.44093150e-01f, 1.22164637e-02f, 2.17309281e-01f,
  7.38925040e-02f, 7.28997663e-02f, 1.55025303e-01f, 2.15740532e-01f, 2.62624234e-01f, -4.71128404e-01f, 4.66078252e-01f, -4.52930808e-01f, -1.03031807e-01f, 2.25116342e-01f,
  -3.76873314e-02f, 1.81091473e-01f, -2.00586766e-01f, 4.36202526e-01f, 3.63829553e-01f, 4.40079346e-02f, 6.11710511e-02f, 1.25454307e-01f, 9.25465375e-02f, 1.72344714e-01f,
  2.23186195e-01f, 1.74894065e-01f, -1.59566194e-01f, -1.65065266e-02f, 2.03824610e-01f, 1.66571006e-01f, 2.43857965e-01f, 5.19507229e-02f, -4.66225594e-02f, 3.01076118e-02f,
  -1.26757652e-01f, -5.82634471e-02f, 3.13646942e-01f, -1.13954833e-02f, -1.46003306e-01f, -1.71185166e-01f, 1.51523530e-01f, 1.44913182e-01f, -6.39066994e-02f, -3.63214910e-02f,
  1.86469376e-01f, -1.26090487e-02f, 4.86328825e-02f, 2.00529084e-01f, -4.71703261e-01f, 4.33615148e-02f, 4.93601292e-01f, -2.79197216e-01f, -4.68018591e-01f, -2.30380997e-01f,
  -1.58621415e-01f, 2.98730314e-01f, 8.12401026e-02f, 2.16440409e-01f, 6.80461600e-02f, 1.67764664e-01f, -9.47080478e-02f, -3.24215055e-01f, -2.71383613e-01f, -1.54154256e-01f,
  4.95575666e-02f, -2.07279414e-01f, -7.70765767e-02f, 9.38954502e-02f, 9.28396061e-02f, -3.58689755e-01f, -1.93276018e-01f, 1.93357050e-01f, 1.68057397e-01f, 4.02518541e-01f,
  -1.78502664e-01f, 3.65204424e-01f, -1.53426692e-01f, -2.09842250e-01f, -9.68784466e-02f, -1.34407625e-01f, -1.26594722e-01f, -2.35168919e-01f, -5.28229512e-02f, -1.91781119e-01f,
  1.29811436e-01f, 1.06571048e-01f, -5.63187758e-03f, -1.23964168e-01f, -1.57052562e-01f, -1.14712425e-01f, -4.80533764e-02f, 6.54198751e-02f, 2.39497740e-02f, -1.79068699e-01f,
  -1.24077134e-01f, 7.46037364e-02f, 4.13149863e-01f, 6.66643381e-02f, 2.17792504e-02f, -7.34497309e-02f, -8.14978331e-02f, 5.60145676e-02f, 2.09168941e-02f, -4.56133455e-01f,
  1.05582424e-01f, -1.59635320e-01f, -9.86668915e-02f, -1.59323797e-01f, -7.81354383e-02f, -5.63106164e-02f, 1.14768676e-01f, -1.74419612e-01f, 4.70869094e-01f, -1.53788149e-01f,
  -2.98349023e-01f, -2.88778424e-01f, -2.42437497e-01f, 6.72820985e-01f, 1.41451418e-01f, 7.84149468e-02f, -6.97344020e-02f, 1.18967429e-01f, -1.51737571e-01f, -2.54165709e-01f,
  -1.46143228e-01f, 8.67048129e-02f, 2.33032405e-01f, -2.87426680e-01f, -1.62967853e-02f, 2.41240457e-01f, 8.92348811e-02f, 2.76852310e-01f, 1.50460869e-01f, 3.75859678e-01f,
  2.45630860e-01f, -9.40882340e-02f, -3.56260151e-01f, 2.93126076e-01f, -5.94530329e-02f, -3.86302412e-01f, -3.46182846e-02f, -8.33153203e-02f, 4.91226763e-02f, 7.59001076e-02f,
  5.47931790e-02f, 1.37446274e-03f, 3.64939421e-01f, -3.72182876e-01f, 1.59726173e-01f, 2.96187773e-02f, -9.25796926e-02f, 1.08647242e-01f, 3.24311018e-01f, 8.42064172e-02f,
  -4.84814718e-02f, 2.39481151e-01f, 2.48031002e-02f, 4.74270225e-01f, -2.56810933e-01f, -4.26085144e-02f, -2.31361032e-01f, 2.10279420e-01f, -1.27657488e-01f, 6.07914031e-02f,
  5.68577163e-02f, -8.62156600e-02f, -1.46962002e-01f, 1.47950783e-01f, -1.16631806e-01f, 1.84247285e-01f, -1.85787186e-01f, 9.21452232e-03f, 2.29415610e-01f, 5.22242747e-02f,
  3.51780541e-02f, 3.58000189e-01f, -5.66582799e-01f, 1.00510120e-01f, -4.69667278e-03f, 5.08898757e-02f, 2.01404408e-01f, -3.68805140e-01f, 1.37312219e-01f, -2.48527423e-01f,
  1.44628108e-01f, 4.37335633e-02f, -8.43028203e-02f, 2.59834796e-01f, -8.67596194e-02f, -3.42577010e-01f, -2.62726307e-01f, 1.90785095e-01f, -1.12370998e-01f, -1.10012129e-01f,
  -1.53648734e-01f, 1.89322039e-01f, -1.11823366e-03f, -5.70708774e-02f, 9.26654264e-02f, -3.27711739e-02f, -3.06994021e-01f, 3.17026854e-01f, -1.75492987e-01f, 1.89593762e-01f,
  8.65016282e-02f, -4.67433244e-01f, -1.62652642e-01f, 2.23727329e-04f, 1.38251737e-01f, -1.62804395e-01f, -3.30718189e-01f, -4.06586915e-01f, -2.24733084e-01f, 5.16432412e-02f,
  -1.26399666e-01f, -4.20291871e-02f, 9.99703854e-02f, 1.16132125e-01f, -5.65280207e-04f, -2.84828573e-01f, 1.49207771e-01f, 1.18110277e-01f, -8.10792968e-02f, 1.35519225e-02f,
  7.11676572e-03f, 5.84152006e-02f, -1.40573233e-01f, 7.23686218e-02f, -3.87676023e-02f, 2.22921837e-02f, -1.82527214e-01f, 5.75798631e-01f, -1.19428508e-01f, 1.55911490e-01f,
  -1.69783115e-01f, -9.69159529e-02f, -9.94786173e-02f, 7.29615837e-02f, 4.98430468e-02f, 1.47147570e-02f, -1.36457309e-01f, 3.43506306e-01f, -2.27449760e-01f, -1.30274177e-01f,
  6.27029955e-01f, -6.34125993e-02f, -3.65306251e-02f, -9.72336903e-02f, -7.70322531e-02f, -3.13777357e-01f, 7.34023303e-02f, 1.15374699e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.71048567e-01f, 6.30524978e-02f, -2.04724550e-01f, -4.19269465e-02f, -2.38693487e-02f, -2.82303058e-02f, -1.38878286e-01f, -1.63784027e-01f, 1.81871168e-02f, 6.77205697e-02f,
  -8.97009596e-02f, 1.93156779e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    