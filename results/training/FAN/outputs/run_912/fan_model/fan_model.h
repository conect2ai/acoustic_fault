/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.86047119e-01f, -7.67615065e-02f, 2.11582426e-02f, 3.65019776e-02f, 1.45767108e-02f, 2.33162008e-02f, 1.71336129e-01f, 4.74272594e-02f, 7.23013468e-03f, 6.33227006e-02f,
  -8.15375671e-02f, -1.17803775e-01f, 3.21833752e-02f, -6.49414212e-02f, 2.39160717e-01f, 1.01429060e-01f, 8.35984796e-02f, 1.80268541e-01f, 1.76222637e-01f, -3.17311361e-02f,
  -1.57539710e-01f, -1.38542578e-02f, 1.48768827e-01f, -6.29658103e-02f, -2.38751426e-01f, -9.03572422e-03f, -1.64973047e-02f, -6.07903190e-02f, 1.53008532e-02f, -1.49292782e-01f,
  -6.91972598e-02f, -5.05257770e-02f, -3.02177412e-03f, -4.61177947e-03f, -6.39763698e-02f, 7.73503557e-02f, -5.03623150e-02f, -9.24135968e-02f, -4.26971093e-02f, -1.54443216e-02f,
  1.90931291e-03f, -2.71935910e-02f, 9.31865216e-05f, -8.01449046e-02f, 4.32293266e-02f, 9.03386772e-02f, -3.95486094e-02f, 6.54152930e-02f, 7.59429857e-02f, 1.56352506e-03f,
  -1.37317002e-01f, 1.52993444e-02f, 1.45996988e-01f, 2.54168119e-02f, -6.72696754e-02f, 1.29370660e-01f, 4.76977462e-03f, -1.16105810e-01f, 7.28558227e-02f, 6.06182888e-02f,
  6.28345413e-03f, -1.58306025e-02f, -2.61017755e-02f, -3.31342667e-02f, 2.70275827e-02f, -2.87951734e-02f, 2.52379999e-02f, 1.86112039e-02f, -4.48640995e-03f, -8.65847152e-03f,
  -1.32715451e-02f, -1.53438384e-02f, 4.57485579e-03f, -3.08321081e-02f, 4.70769145e-02f, -2.17075776e-02f, 1.77936666e-02f, -1.72820147e-02f, 7.15001207e-03f, 4.24504578e-02f,
  4.32344936e-02f, -1.39566408e-02f, -6.93950383e-03f, -1.46641433e-02f, -3.68414586e-03f, 7.72054046e-02f, 2.82380171e-02f, -6.30354732e-02f, 3.37272771e-02f, -2.99850889e-02f,
  3.60521339e-02f, 1.05218977e-01f, 1.41369507e-01f, 4.45387140e-02f, 2.04667472e-03f, 3.33258137e-02f, 5.07326163e-02f, -8.17073956e-02f, -2.67698839e-02f, 6.61833957e-02f,
  3.03555783e-02f, 5.78228459e-02f, 1.20913815e-02f, -1.25328645e-01f, 5.79060577e-02f, -3.27100046e-02f, 5.18979169e-02f, -5.48183732e-02f, -3.48075293e-02f, -1.29221631e-02f,
  -3.97448614e-02f, 1.56549677e-01f, 2.49878109e-01f, 9.87079665e-02f, 6.52993738e-04f, 1.33055255e-01f, 1.63000584e-01f, 8.48380476e-02f, 2.58620083e-01f, 9.06773433e-02f,
  -5.32331824e-01f, 7.39007592e-02f, -1.91809535e-01f, -9.06528011e-02f, 3.47130634e-02f, 1.88154355e-02f, 2.30214838e-02f, 1.19572625e-01f, 1.20874040e-01f, 8.38420913e-02f,
  6.34955540e-02f, -1.59313716e-02f, 1.00031182e-01f, -1.56078842e-02f, -2.69186553e-02f, -9.92519483e-02f, -1.12459101e-01f, -3.16472232e-01f, -1.25804797e-01f, -1.22614913e-01f,
  -9.35023054e-02f, -1.76434651e-01f, -2.35541373e-01f, -3.45492773e-02f, 5.74095845e-02f, -2.41173599e-02f, 1.20622136e-01f, -4.56257463e-02f, -3.43766212e-02f, -1.65516838e-01f,
  1.64981902e-01f, -1.76509559e-01f, -1.80479269e-02f, -4.77401167e-02f, 4.40714583e-02f, -4.71086018e-02f, -3.36873792e-02f, -4.01449539e-02f, -6.00540154e-02f, 1.27997985e-02f,
  5.87198921e-02f, 1.18374331e-02f, -3.11344620e-02f, 8.93597528e-02f, -3.75880003e-02f, 5.04981913e-02f, 3.24650668e-03f, -7.23153651e-02f, -3.93177681e-02f, 3.45755778e-02f,
  6.36013597e-02f, -2.01785579e-01f, -1.01620197e-01f, 1.32060334e-01f, 5.80408201e-02f, -5.31889573e-02f, 1.60716940e-02f, -6.40998855e-02f, -3.60843875e-02f, 3.38420793e-02f,
  -8.99006575e-02f, 2.95850318e-02f, -5.50640598e-02f, 1.99901871e-02f, 4.63948734e-02f, 3.76797840e-02f, -6.51620924e-02f, -1.50337173e-02f, 4.15322445e-02f, -2.73274090e-02f,
  -4.05471437e-02f, 5.29595837e-02f, 8.42642784e-03f, 3.85223776e-02f, 8.78620669e-02f, 2.60931589e-02f, -4.66921926e-02f, 8.44909549e-02f, 1.95663087e-02f, 4.24284069e-03f,
  2.54543275e-02f, 3.66194881e-02f, 1.14661241e-02f, 4.89936098e-02f, -4.22547534e-02f, -8.77418146e-02f, 3.56895588e-02f, 3.72490808e-02f, -3.63234393e-02f, -1.05842203e-02f,
  2.92716354e-01f, -7.68820718e-02f, 2.69338917e-02f, -1.73723418e-02f, 3.75660807e-02f, 5.69576025e-02f, 7.09369183e-02f, 5.25830537e-02f, 3.52164172e-02f, -2.44000554e-02f,
  4.80407290e-02f, -5.92710823e-03f, 6.61614165e-02f, 5.12416326e-02f, -4.62651439e-02f, 4.40141447e-02f, -5.08888625e-03f, -8.34489521e-03f, 5.64286672e-02f, 8.65733474e-02f,
  4.03708220e-02f, -4.42465954e-02f, 2.88079213e-02f, 6.36721551e-02f, 8.13734625e-03f, -1.33946195e-01f, 7.38023669e-02f, 1.15148857e-01f, -7.77178332e-02f, 5.70709258e-02f,
  3.25523913e-01f, 3.02459206e-02f, 3.70940790e-02f, 6.41391426e-02f, -2.19290748e-01f, -2.98453480e-01f, -3.58483881e-01f, -1.24282181e-01f, 1.02172066e-02f, -1.05441593e-01f,
  -2.76575778e-02f, 4.60908711e-02f, -2.38657538e-02f, 5.96662685e-02f, -9.60588232e-02f, -3.58978957e-02f, -7.60907456e-02f, 5.96556887e-02f, -6.55277371e-02f, -1.47658899e-01f,
  -1.08193666e-01f, 2.99275052e-02f, 2.26537496e-01f, 1.30380481e-01f, 2.07521051e-01f, 7.29072690e-02f, 1.29529253e-01f, 1.63560435e-01f, -4.61414270e-02f, 2.44983956e-01f,
  2.47575659e-02f, 1.33729577e-01f, -3.70748527e-02f, 1.02652475e-01f, 6.49092272e-02f, 5.11492267e-02f, -5.44742011e-02f, 1.31724089e-01f, 6.32402599e-02f, 5.46659231e-02f,
  7.56184533e-02f, 1.78993903e-02f, 9.06084105e-02f, -1.95463058e-02f, 6.52755201e-02f, -5.59654552e-03f, 7.44099021e-02f, 2.33274195e-02f, 2.48427037e-02f, 1.12650953e-02f,
  -5.70317581e-02f, -3.26985940e-02f, -6.35797456e-02f, -4.21260446e-02f, -7.02282190e-02f, 9.62521434e-02f, 4.73451689e-02f, 1.36385605e-01f, -6.56364933e-02f, 6.92119971e-02f,
  -6.73271120e-02f, 2.60293055e-02f, 1.00308657e-02f, -1.02036144e-03f, -1.42500615e-02f, 5.31424070e-03f, -3.45474109e-02f, -6.30048616e-03f, -4.10623997e-02f, 5.49641997e-02f,
  -4.18062918e-02f, 2.85390597e-02f, -3.08836717e-02f, 8.36424008e-02f, 2.34791008e-03f, 2.11225543e-02f, 2.43295375e-02f, -5.84536083e-02f, -7.82240368e-03f, 3.00639868e-03f,
  9.56509709e-02f, -1.76686458e-02f, 5.69276698e-02f, -6.08029682e-03f, 2.38844305e-02f, -4.16238084e-02f, 1.92672275e-02f, -6.93212030e-03f, 2.55407603e-03f, -3.67956720e-02f,
  3.77681255e-02f, -1.47671193e-01f, 3.56395841e-02f, -1.37241520e-02f, 4.87744473e-02f, -3.03629925e-03f, 4.00123596e-02f, -1.17543212e-03f, -1.80625767e-02f, -3.10710557e-02f,
  -6.10837974e-02f, -1.59327742e-02f, -4.66695875e-02f, 5.08513115e-02f, -7.86034912e-02f, -7.67676234e-02f, -3.17676254e-02f, -1.69926323e-02f, -3.07752192e-02f, -1.03439018e-02f,
  -3.40884961e-02f, -1.77272975e-01f, -1.38606593e-01f, -1.69858575e-01f, -4.46913615e-02f, -5.99659234e-02f, -1.37176007e-01f, -1.17962472e-01f, -2.15609089e-01f, -8.41440186e-02f,
  2.06142113e-01f, -2.01608658e-01f, -2.10347891e-01f, -9.10824910e-02f, -1.42521933e-01f, -2.29331493e-01f, -3.24302673e-01f, 1.33824125e-02f, 8.36970061e-02f, -1.13200434e-01f,
  -8.61379132e-02f, 7.72229359e-02f, 7.84503371e-02f, 7.15107024e-02f, 1.44546181e-01f, -2.63772756e-01f, -1.69055730e-01f, 3.59796658e-02f, 2.24719435e-01f, -6.57345960e-03f,
  8.93887579e-02f, 1.36857420e-01f, 7.51961172e-02f, 1.29504845e-01f, -6.88088089e-02f, -6.26989529e-02f, -1.59875199e-01f, -5.35210781e-02f, -1.29577130e-01f, -1.44087583e-01f,
  -2.47648150e-01f, -1.23350434e-01f, 8.68211389e-02f, 8.09237435e-02f, -1.10150836e-02f, -4.83676344e-02f, 3.32855619e-02f, -3.71937938e-02f, 1.93324704e-02f, 2.03531254e-02f,
  6.50640763e-03f, 7.19911456e-02f, -1.18974233e-02f, 3.55884843e-02f, 1.49123324e-02f, 5.72046712e-02f, 1.84439123e-02f, 1.28241733e-01f, 7.31570497e-02f, 5.91242174e-03f,
  -9.39692184e-02f, -1.73042796e-03f, -8.40896368e-02f, 1.17228534e-02f, -3.95333953e-02f, 2.05104183e-02f, -1.30657047e-01f, 7.60766491e-02f, 1.56264491e-02f, -1.21521711e-01f,
  -5.87742627e-02f, 2.66292505e-03f, -2.26108655e-02f, 2.46727429e-02f, 2.34615430e-02f, -9.27039161e-02f, 1.52762076e-02f, 9.54150863e-04f, 1.66684948e-02f, -1.46875968e-02f,
  7.28527755e-02f, -6.76730573e-02f, 6.00958355e-02f, 6.73021330e-03f, -4.19891216e-02f, -5.77987507e-02f, 1.23850945e-02f, -4.14025746e-02f, -2.90430393e-02f, 4.80375029e-02f,
  8.79600570e-02f, 6.78750873e-02f, -5.48060201e-02f, 4.63247895e-02f, -4.62576710e-02f, 1.81976538e-02f, 2.30667330e-02f, -6.99869543e-02f, 6.72981665e-02f, -4.53346893e-02f,
  7.76741356e-02f, 1.87047631e-01f, -1.50609180e-01f, 6.24367595e-02f, -4.79862392e-02f, 4.09284942e-02f, -2.38716658e-02f, 6.87965527e-02f, 4.56549833e-03f, 2.44655367e-02f,
  5.20171411e-03f, -1.57713443e-02f, -3.27779204e-02f, 2.49514319e-02f, 3.91670540e-02f, -3.36897746e-02f, -6.70737773e-02f, 7.48857437e-03f, 8.52024928e-02f, -1.14920609e-01f,
  6.48735240e-02f, -1.17753617e-01f, 6.94213286e-02f, -6.34737089e-02f, -6.00310341e-02f, 1.31832018e-01f, -8.93443376e-02f, -1.06132612e-01f, 5.96308243e-03f, -1.52409360e-01f,
  2.35617876e-01f, 4.83247906e-01f, 7.67082796e-02f, 1.46160364e-01f, 1.39422953e-01f, 1.37659237e-02f, 1.55480444e-01f, -6.59590513e-02f, 6.65167347e-02f, 1.63539976e-01f,
  2.02047452e-01f, -1.86459288e-01f, -1.94376066e-01f, -2.00617611e-01f, -1.41366154e-01f, 5.02681248e-02f, -4.08966057e-02f, -2.93742925e-01f, -3.81058007e-01f, -1.46118447e-01f,
  -3.90120000e-02f, -5.81562445e-02f, -1.73105653e-02f, -1.24073394e-01f, 1.25338465e-01f, -1.08970264e-02f, 1.43809050e-01f, 2.03757554e-01f, 1.05434738e-01f, 1.00960299e-01f,
  7.19583109e-02f, 3.25110883e-01f, -2.93833286e-01f, 4.42450717e-02f, -5.08218491e-03f, -2.66947635e-02f, -4.66608182e-02f, 4.08534780e-02f, 4.37826663e-02f, 5.54856025e-02f,
  -1.34547446e-02f, -2.43043154e-02f, 6.85840920e-02f, 3.79608870e-02f, 1.87086295e-02f, 7.63435364e-02f, -6.32302910e-02f, -3.67859937e-02f, -2.57263370e-02f, 1.10755615e-01f,
  8.74544606e-02f, 1.26618326e-01f, 1.29256323e-01f, -6.47762194e-02f, -6.78915158e-02f, -1.46495685e-01f, 1.42576411e-01f, 1.14024477e-02f, 5.32079712e-02f, 1.64457038e-01f,
  -1.37768425e-02f, 3.19142081e-02f, 1.32922514e-03f, 1.65921543e-02f, -8.24635923e-02f, -2.39989441e-02f, -1.26999095e-02f, -3.71648856e-02f, -6.81374744e-02f, 4.40778695e-02f,
  -1.62745751e-02f, -1.87951941e-02f, 1.07868947e-02f, 2.87695490e-02f, -2.51146518e-02f, 5.67005295e-03f, 3.03254575e-02f, 6.64482731e-03f, -3.79370376e-02f, 3.44122797e-02f,
  7.73796439e-02f, -5.43097779e-02f, 1.63771603e-02f, -2.24247184e-02f, -3.06691173e-02f, 3.06713544e-02f, 2.56672688e-02f, 1.99728590e-02f, -3.86955473e-03f, -7.14843161e-03f,
  -1.04082964e-01f, -1.22413345e-01f, -3.79165225e-02f, -1.02705523e-01f, 1.42964914e-01f, -2.46081948e-02f, 4.82209176e-02f, 4.13269643e-03f, 2.33418532e-02f, -5.69139197e-02f,
  6.37565851e-02f, -5.22718765e-02f, 6.76502436e-02f, -1.85670052e-02f, -1.69539694e-02f, -1.11986294e-01f, 7.81339481e-02f, -5.74104860e-02f, -4.43605334e-02f, 2.15244032e-02f,
  7.88572878e-02f, -6.97283016e-04f, -1.23884358e-01f, -3.87893356e-02f, 7.77604524e-03f, -7.39346445e-02f, -1.47098035e-01f, -7.23091736e-02f, -1.01781383e-01f, -4.32183146e-02f,
  1.12783298e-01f, 1.40178770e-01f, -1.07794769e-01f, 1.60905644e-01f, 2.55916417e-01f, 1.42042905e-01f, 2.91008830e-01f, 2.10556254e-01f, 1.09355502e-01f, 9.28161666e-02f,
  1.38786510e-01f, -6.44934922e-02f, -5.71137704e-02f, -1.30800888e-01f, 2.24609151e-02f, 1.55688420e-01f, 5.09535037e-02f, -6.91529214e-02f, -1.64870873e-01f, -7.96417072e-02f,
  1.28625318e-01f, 5.35706356e-02f, -9.44717899e-02f, -7.93059319e-02f, 1.05303824e-02f, -5.28077967e-02f, -4.83907238e-02f, 5.91356978e-02f, -5.23640811e-02f, -1.29174501e-01f,
  -3.02126020e-01f, 7.64207840e-02f, -2.28886884e-02f, 6.93202913e-02f, -5.70457093e-02f, -9.89886522e-02f, 3.21448557e-02f, -1.22871988e-01f, -2.93750763e-02f, 1.15617448e-02f,
  9.48692933e-02f, -3.19420546e-02f, -4.93164733e-02f, -7.57127777e-02f, 3.60415727e-02f, 5.21829864e-03f, -6.99949414e-02f, -1.51899710e-01f, -8.84676948e-02f, -8.02094415e-02f,
  5.36107570e-02f, 4.31244038e-02f, -3.61703038e-02f, -1.55892046e-02f, 6.56404495e-02f, 3.50882113e-02f, 3.07380576e-02f, 1.67636517e-02f, -5.12829423e-02f, 7.21748844e-02f,
  -1.53850962e-03f, -9.42507312e-02f, 2.78316485e-03f, -4.86085936e-03f, 3.03666107e-02f, 3.10955010e-02f, -2.03320384e-02f, 4.74765478e-03f, -4.64902781e-02f, 8.03643744e-03f,
  -9.99613851e-03f, 1.93692781e-02f, -2.87365392e-02f, 2.21342463e-02f, -2.97322962e-03f, -5.28831072e-02f, -2.35976689e-02f, 3.37604955e-02f, 1.35608912e-02f, -2.24035513e-02f,
  -1.80398598e-02f, 2.35023592e-02f, 4.50094715e-02f, -9.40875784e-02f, -2.03378927e-02f, 2.07094494e-02f, -6.93134591e-02f, -3.96497697e-02f, -3.20100263e-02f, 5.61668910e-03f,
  -2.68456861e-02f, 4.79380004e-02f, 7.53084198e-02f, 1.97916478e-02f, 8.24126452e-02f, -5.66185378e-02f, 7.56181553e-02f, -4.11420949e-02f, 6.34807199e-02f, 8.39320198e-02f,
  -1.80081055e-02f, 5.65154292e-02f, 7.24118054e-02f, -9.97022726e-03f, 9.40224901e-02f, 4.88307849e-02f, 1.77054122e-01f, 4.26990315e-02f, 3.76155078e-02f, 7.24057183e-02f,
  -8.49667564e-03f, 1.22569680e-01f, 2.06312165e-02f, 8.12659636e-02f, 7.36332610e-02f, 7.06244335e-02f, 3.77982818e-02f, 5.46318181e-02f, -6.18625758e-03f, 1.13820054e-01f,
  -2.89537191e-01f, 7.40378350e-02f, -1.18189394e-01f, 1.29931778e-01f, 1.82567090e-01f, 1.87114656e-01f, 3.84076864e-01f, 2.28600696e-01f, 1.69425949e-01f, -2.29077041e-02f,
  -1.27605423e-01f, -2.79827058e-01f, -2.25381792e-01f, -1.94967657e-01f, -6.40134364e-02f, 1.65647849e-01f, 1.52425274e-01f, -1.14364341e-01f, -9.28500816e-02f, 1.47226229e-01f,
  1.23742856e-01f, 5.77975921e-02f, -1.33581087e-01f, -3.09289899e-02f, 8.63339081e-02f, 6.37777243e-03f, -4.31246012e-02f, -8.83360207e-02f, -6.62966371e-02f, 4.79535386e-02f,
  -2.06979707e-01f, -1.57008186e-01f, 1.50228804e-02f, -3.85166854e-02f, -1.14947766e-01f, -6.27687424e-02f, -9.34982151e-02f, -1.53925657e-01f, -1.24426603e-01f, -4.49519195e-02f,
  -1.40676156e-01f, -4.34109978e-02f, -1.35426790e-01f, 4.18747514e-02f, -3.74163538e-02f, 6.59549162e-02f, 2.67491471e-02f, -7.21018985e-02f, -1.72399506e-01f, 5.22697857e-03f,
  4.40445691e-02f, -6.51898310e-02f, -1.39226213e-01f, 2.32049190e-02f, -1.17416933e-01f, -1.49094954e-01f, 2.27717012e-02f, 2.92678159e-02f, -1.58976391e-01f, 3.41393128e-02f,
  3.03704161e-02f, -5.43202348e-02f, -2.27949042e-02f, -6.21501356e-02f, 6.73070177e-02f, -7.97976460e-03f, 5.81867108e-03f, -3.19493152e-02f, 6.73310235e-02f, -4.20819642e-03f,
  -8.38538166e-03f, -8.09144974e-02f, 3.50791588e-02f, 7.30769522e-03f, 2.64610276e-02f, -7.22204335e-03f, 2.74313837e-02f, 4.51132730e-02f, -5.99161349e-02f, 1.21909231e-02f,
  -5.65951392e-02f, 5.54642417e-02f, -7.68598616e-02f, 1.17441658e-02f, 9.32774600e-03f, 9.61532351e-03f, 7.61886388e-02f, -4.86363992e-02f, -6.61082519e-03f, -1.47140175e-02f,
  1.40436292e-01f, -1.05860308e-01f, 2.51580402e-02f, 3.33660580e-02f, 3.44498940e-02f, 1.12972595e-02f, -8.36813152e-02f, -1.68947447e-02f, -2.64657866e-02f, 6.09567277e-02f,
  -4.32369076e-02f, -3.01805846e-02f, 5.26012294e-02f, 2.22781952e-02f, 6.67895824e-02f, -9.33192729e-04f, 6.02053851e-02f, -7.09484890e-02f, 7.97324330e-02f, 3.94073278e-02f,
  1.00607842e-01f, 1.29503652e-01f, 7.09589869e-02f, 1.43328160e-01f, 2.93972604e-02f, 7.40039647e-02f, 1.15405485e-01f, 8.87978524e-02f, -1.56282652e-02f, 3.83713037e-01f,
  1.71225145e-01f, -3.49047571e-01f, 1.97123289e-01f, -5.69221266e-02f, -1.26366213e-01f, -5.99499457e-02f, -1.56942964e-01f, -1.33152902e-01f, -4.67309430e-02f, -1.55804098e-01f,
  -1.53713003e-01f, 5.25419563e-02f, 5.99829108e-02f, 1.14122808e-01f, 6.50218874e-02f, 3.44145633e-02f, 2.10469831e-02f, 2.93842494e-01f, 3.25611234e-01f, 5.34809381e-02f,
  -9.43306386e-02f, 8.37936327e-02f, 2.00614586e-01f, 3.80811654e-02f, -5.81429116e-02f, -1.38180638e-02f, -1.68836415e-02f, 7.08639249e-02f, 7.75048658e-02f, -3.52606215e-02f,
  1.85757890e-01f, -2.15005383e-01f, 1.86983705e-01f, -1.03608884e-01f, -8.91465992e-02f, -2.36804020e-02f, 4.51649874e-02f, 2.82631051e-02f, -7.57364258e-02f, 8.68083239e-02f,
  2.04463787e-02f, 6.30637119e-03f, -7.13820085e-02f, 8.23888369e-03f, -2.92461757e-02f, -3.23236883e-02f, -1.02498643e-01f, 7.03011453e-02f, 2.56229229e-02f, 1.94115490e-02f,
  -1.16585217e-01f, -3.02366894e-02f, 1.54555961e-01f, -8.67415220e-02f, 5.19182757e-02f, 2.91687101e-02f, -4.80517559e-02f, 1.38969839e-01f, 1.60175323e-01f, 3.24869007e-02f,
  1.89187024e-02f, 2.78782640e-02f, -2.11455747e-02f, 3.93218920e-02f, -2.41300836e-02f, 5.71636437e-03f, 4.20965580e-03f, -4.11555842e-02f, 2.90019866e-02f, 3.13348137e-02f,
  8.86452291e-03f, -2.60513984e-02f, -6.06403984e-02f, -2.28354223e-02f, 1.73977353e-02f, -4.72138263e-02f, -1.40841017e-02f, 1.39146745e-02f, -1.23739075e-02f, 3.87543999e-02f,
  2.97347251e-02f, 9.82282236e-02f, -9.73134860e-02f, 5.33394888e-03f, -2.91846395e-02f, -1.95654072e-02f, 2.47019343e-02f, 3.42168510e-02f, 4.75498326e-02f, -5.50339632e-02f,
  -4.57734391e-02f, -3.47324796e-02f, 6.13942929e-02f, 8.23316872e-02f, -3.42581049e-02f, 7.78986290e-02f, -3.00467853e-02f, 2.11833455e-02f, -5.74249327e-02f, -2.07519941e-02f,
  -5.43834642e-02f, 3.35334055e-02f, -4.61651459e-02f, 2.29807571e-02f, 3.26663740e-02f, 2.60681324e-02f, -6.26816377e-02f, 7.79561996e-02f, 4.08338085e-02f, -1.28776729e-01f,
  -6.32219687e-02f, 2.05138996e-01f, 2.84721106e-01f, 1.16654718e-02f, 7.00116530e-02f, 1.68220535e-01f, 1.22964248e-01f, 1.67012841e-01f, 1.81410804e-01f, 7.05924490e-03f,
  4.15410772e-02f, 1.75270125e-01f, 4.89529938e-01f, 2.20299110e-01f, 1.09633297e-01f, 4.05008085e-02f, -3.33856568e-02f, -5.68696186e-02f, 5.82712423e-03f, 6.45078421e-02f,
  -3.52183990e-02f, -2.04859912e-01f, 1.64875183e-02f, -6.02931343e-02f, -3.61033455e-02f, 1.63612902e-01f, 3.53526354e-01f, 2.88723171e-01f, 2.43327674e-02f, -7.60577917e-02f,
  -1.53135553e-01f, -2.25652754e-03f, 2.97559835e-02f, 1.73061900e-02f, -4.37603481e-02f, -2.86411606e-02f, 1.87878430e-01f, 1.27494410e-01f, 9.03862491e-02f, 1.77988052e-01f,
  2.37531081e-01f, 7.14385360e-02f, -9.47443917e-02f, -9.39207301e-02f, -2.99950596e-02f, -3.54252383e-02f, 7.14660576e-03f, -3.53780529e-03f, -1.28194258e-01f, 3.74489129e-02f,
  5.24520278e-02f, -9.04696509e-02f, 3.54942381e-02f, -6.71307072e-02f, 6.75778687e-02f, -7.29928492e-03f, -6.47838041e-03f, 1.81269616e-01f, 1.21512279e-01f, -2.44098529e-02f,
  3.06202006e-03f, 1.23144481e-02f, 1.16027318e-01f, -1.08403899e-02f, 1.09944232e-01f, -5.74723296e-02f, -5.93057312e-02f, -6.07070215e-02f, 8.91957879e-02f, 1.56318955e-02f,
  -6.27632951e-03f, 1.91360787e-02f, -5.44827506e-02f, -2.40316172e-03f, -1.90889072e-02f, -3.33290659e-02f, 2.14507673e-02f, -5.60445525e-02f, 3.07154413e-02f, -5.21325581e-02f,
  -1.43620763e-02f, 4.08028252e-02f, 2.50442009e-02f, 5.67586049e-02f, 1.18013248e-01f, -3.53360660e-02f, -4.69691679e-02f, -2.17959043e-02f, 3.12639959e-02f, -2.02581496e-03f,
  -6.75338432e-02f, -2.20217519e-02f, 5.56030497e-02f, -6.05066307e-02f, 4.85378020e-02f, 2.17763279e-02f, 5.85846566e-02f, -4.38127853e-02f, -4.77028005e-02f, -8.72227713e-04f,
  -8.27905387e-02f, 3.71459238e-02f, -1.78110078e-02f, -5.94090410e-02f, 8.86765420e-02f, -2.61372328e-03f, -2.05028281e-02f, -1.52708525e-02f, -1.96709763e-02f, 8.60261917e-02f,
  -1.59205534e-02f, -5.06271143e-04f, 2.76335645e-02f, 5.30108176e-02f, -5.86948618e-02f, -1.47796115e-02f, -9.01560672e-03f, -1.60077438e-02f, -8.21438953e-02f, -2.11832821e-02f,
  -6.35214448e-02f, -7.30421990e-02f, -3.97904515e-02f, 6.69701956e-03f, -8.60080123e-03f, -6.51515499e-02f, 4.56631146e-02f, -5.01024760e-02f, -2.75821853e-02f, -7.86942765e-02f,
  1.42638758e-01f, 1.43217281e-01f, -5.86693436e-02f, -4.69521154e-03f, -2.63905879e-02f, -4.52667698e-02f, -1.47585019e-01f, -1.08371131e-01f, -8.57880116e-02f, -3.33631374e-02f,
  2.03939959e-01f, 5.01610339e-02f, -5.22122122e-02f, -4.74572228e-03f, -1.55469432e-01f, -1.41508445e-01f, -1.43555880e-01f, -2.10514814e-01f, -7.14943856e-02f, -3.80436964e-02f,
  -2.93734111e-02f, 3.67208588e-04f, -9.26293135e-02f, -1.23842014e-02f, 4.87754717e-02f, -3.11810505e-02f, 6.91906735e-02f, 1.67632755e-02f, 1.84987858e-02f, 8.40067565e-02f,
  2.20715210e-01f, 8.59059468e-02f, -9.15430635e-02f, 2.51352414e-02f, 7.82121941e-02f, -2.27777306e-02f, 4.65528965e-02f, 5.13582937e-02f, -6.07441999e-02f, 6.32334501e-02f,
  5.03650643e-02f, -4.54892628e-02f, -7.97361955e-02f, -5.73225096e-02f, 6.24088161e-02f, -5.73635884e-02f, -8.91284347e-02f, 4.96156653e-03f, -6.41055927e-02f, 4.68797144e-03f,
  -8.76972675e-02f, -8.97112414e-02f, -9.42121260e-03f, -1.27613135e-02f, -9.00067836e-02f, -9.60984826e-02f, 8.72648358e-02f, -8.55955034e-02f, 6.46632835e-02f, 1.24918431e-01f,
  4.61369939e-03f, 1.44521156e-02f, 6.86666276e-03f, 2.13592444e-02f, -4.34991494e-02f, -4.53270413e-02f, 4.48918492e-02f, -5.70832826e-02f, -4.57082270e-03f, -1.35638425e-02f,
  1.81535538e-02f, -1.41249746e-02f, 1.14755770e-02f, 9.11216065e-02f, -6.68287743e-03f, 8.32843035e-03f, 2.71286946e-02f, -9.90144815e-03f, 6.84608892e-02f, -4.23732549e-02f,
  -3.58895138e-02f, 1.43256830e-02f, 9.81693249e-03f, 8.83804187e-02f, -8.89451802e-02f, -7.24706501e-02f, -5.84997647e-02f, -4.14613187e-02f, -3.00619639e-02f, 3.25866714e-02f,
  3.08739483e-01f, -9.42405462e-02f, 7.32721090e-02f, -3.38731408e-02f, -2.64814775e-02f, 2.56284587e-02f, 5.98588698e-02f, -7.20413849e-02f, 7.99071342e-02f, 2.61590648e-02f,
  -1.21799549e-02f, 3.16072144e-02f, 5.01111895e-02f, -4.21891548e-02f, 7.45538324e-02f, 4.16593999e-02f, -6.07750155e-02f, 2.46560927e-02f, -6.24382645e-02f, -7.20044374e-02f,
  -7.92937540e-03f, -9.50698629e-02f, 6.91860467e-02f, -4.09627408e-02f, 9.13009571e-04f, -2.15938576e-02f, 9.92460176e-02f, 1.01131722e-01f, 2.04848200e-02f, 8.65569115e-02f,
  3.69640589e-02f, -9.64345187e-02f, 8.48062709e-02f, -2.17008442e-01f, -2.02547103e-01f, -1.50632098e-01f, -1.07838765e-01f, -9.67961848e-02f, -3.83376330e-02f, -1.01123750e-01f,
  1.13310918e-01f, 1.92323998e-01f, 2.66137689e-01f, 1.88512117e-01f, 2.22176746e-01f, -3.20456438e-02f, 9.49071662e-04f, 3.16288397e-02f, 9.80875194e-02f, -4.53684703e-02f,
  -1.36151582e-01f, -1.47603706e-01f, 9.06831771e-02f, -1.25720084e-01f, -1.15719952e-01f, 2.47403942e-02f, -8.86000320e-02f, -2.23716348e-02f, -8.38706940e-02f, -2.83133388e-01f,
  1.82941645e-01f, -8.03648978e-02f, 5.93342222e-02f, 1.63500588e-02f, 3.53699620e-03f, 1.09716989e-01f, 1.23185866e-01f, 2.54061557e-02f, -2.08464172e-02f, -4.76409085e-02f,
  -6.65831193e-02f, 1.71234924e-02f, -6.56955002e-04f, 4.11245553e-03f, -1.12416588e-01f, -2.45905686e-02f, 4.60787639e-02f, -7.93543682e-02f, 7.97254518e-02f, -7.51441047e-02f,
  -3.18446569e-02f, -1.03490539e-01f, 2.22683363e-02f, 5.83840348e-02f, 4.78979349e-02f, 1.29475415e-01f, 1.48324552e-03f, -2.47087665e-02f, 1.24110974e-01f, -8.97287652e-02f,
  -2.06173845e-02f, -5.24161719e-02f, 9.50129516e-03f, -7.83105846e-03f, -1.53419897e-02f, 1.51971661e-04f, -2.86149643e-02f, -2.66513675e-02f, 2.69518923e-02f, -8.11983924e-03f,
  1.85374953e-02f, 6.54144809e-02f, -2.95997504e-02f, 4.97721806e-02f, -1.90254375e-02f, 2.58931369e-02f, -9.81905237e-02f, 1.52913602e-02f, 5.10074347e-02f, -3.99338827e-02f,
  -5.51772080e-02f, 4.70508821e-02f, -1.68432388e-02f, -4.28908728e-02f, -1.28390705e-02f, 4.82164230e-03f, -1.07969604e-02f, 7.37706199e-02f, 1.29339052e-03f, -1.30427703e-01f,
  1.07745416e-01f, 2.43141606e-01f, -7.66107161e-03f, 9.06387642e-02f, -6.73861802e-02f, 3.79064307e-02f, 1.16224978e-02f, 4.23873179e-02f, -1.03171669e-01f, -5.86351659e-03f,
  4.84330878e-02f, 8.97019506e-02f, 9.91132334e-02f, -3.39134261e-02f, 6.61509158e-03f, 3.96160632e-02f, -4.43225913e-02f, 5.76662607e-02f, -2.30900552e-02f, 3.43355350e-02f,
  -4.93603162e-02f, -8.14727098e-02f, 1.25442326e-01f, 2.20641233e-02f, -4.73401360e-02f, 1.96503744e-01f, 1.23667173e-01f, 1.42494785e-02f, 1.08476482e-01f, 1.35556296e-01f,
  -2.67606944e-01f, -1.71216801e-01f, -2.86825091e-01f, -1.01000851e-03f, 6.99803084e-02f, -2.40067005e-01f, -3.40186983e-01f, -1.54736355e-01f, -3.52550007e-04f, -4.58032079e-02f,
  2.01126769e-01f, 3.50817651e-01f, 1.42058596e-01f, 1.29507869e-01f, -1.81344271e-01f, -2.46335864e-01f, -2.69889325e-01f, -1.84703320e-01f, 1.67304911e-02f, 4.69270609e-02f,
  1.51308700e-01f, 4.29519452e-02f, 5.05460873e-02f, 1.01453783e-02f, 8.80056396e-02f, 9.09646749e-02f, 2.80037839e-02f, -1.48079293e-02f, -3.25470343e-02f, 1.44362941e-01f,
  3.39419216e-01f, -1.33738205e-01f, -1.77881271e-02f, 1.18004076e-01f, 5.16719408e-02f, -6.09036088e-02f, 2.61037257e-02f, -7.52245486e-02f, -1.05846347e-02f, -3.54920253e-02f,
  2.91922241e-02f, 1.33734241e-01f, -1.11119272e-02f, 3.41617204e-02f, -7.04051880e-03f, 2.11614911e-02f, -3.27658728e-02f, -1.35629371e-01f, -1.44860357e-01f, 9.90869105e-02f,
  1.16307244e-01f, 9.06221122e-02f, -6.50146008e-02f, -3.64707783e-02f, -1.73628375e-01f, -2.20242310e-02f, -3.96494456e-02f, 4.71373275e-02f, -1.68484390e-01f, -9.11722705e-02f,
  7.47504905e-02f, -9.59006995e-02f, 1.09057326e-03f, -4.42335121e-02f, 4.65269759e-02f, 3.58733088e-02f, -3.12235858e-02f, -2.15075118e-03f, -3.16917673e-02f, -1.71746761e-02f,
  6.60240697e-03f, 6.83387071e-02f, -2.38972530e-02f, -6.95893019e-02f, 1.23273619e-01f, -8.31160247e-02f, 1.72752757e-02f, -5.66956296e-04f, 1.52756972e-02f, 1.89398168e-04f,
  4.94599305e-02f, -5.25377579e-02f, -1.22339139e-03f, 4.60140072e-02f, 5.36656491e-02f, 3.66123323e-03f, -4.84758243e-02f, 2.68260092e-02f, 2.04322096e-02f, -1.61689613e-02f,
  1.26407161e-01f, -1.55756235e-01f, 1.27693415e-01f, -2.60171723e-02f, 4.88260482e-03f, 7.20864832e-02f, 5.97064979e-02f, 3.27465939e-03f, 6.34370670e-02f, 5.03795855e-02f,
  4.61470224e-02f, -3.32562253e-02f, 2.90747825e-02f, 3.38540189e-02f, 2.66711432e-02f, 3.15988511e-02f, 4.88630012e-02f, -4.32883836e-02f, -5.41573428e-02f, 8.71174112e-02f,
  -8.53554625e-03f, -1.02582894e-01f, -5.11806719e-02f, -1.18866064e-01f, 4.31230515e-02f, 6.96000308e-02f, 8.57247934e-02f, -3.11286375e-02f, -3.78431380e-02f, -5.59932962e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.10880084e-01f, -3.65524292e-02f, 1.23782404e-01f, -7.34849647e-02f, 3.34754102e-02f, 1.35581911e-01f, 4.62333113e-02f, -4.22499292e-02f, -9.99021903e-02f, -5.89914992e-02f,
  -8.39992315e-02f, -9.69727263e-02f, -5.20984977e-02f, 1.27074877e-02f, -3.75952721e-02f, 1.30481087e-02f, 2.56331582e-02f, 7.39236176e-02f, 3.84416385e-03f, -1.26401752e-01f,
  -1.65309191e-01f, -1.37010247e-01f, -1.03712551e-01f, -8.74521956e-02f, 1.58089809e-02f, 2.02475376e-02f, 3.21316309e-02f, 6.74215779e-02f, 5.49629517e-02f, -4.10036417e-04f,
  -3.05282623e-02f, 1.12466507e-01f, -3.67410742e-02f, -1.44762442e-01f, 5.23577584e-03f, 4.51145321e-02f, -5.18448055e-02f, 5.92652448e-02f, 3.42743583e-02f, -6.56475052e-02f,
  -2.86412928e-02f, -6.66167289e-02f, 2.08938755e-02f, 3.51054333e-02f, 5.41244224e-02f, 8.97065699e-02f, 4.21557054e-02f, -8.11885670e-02f, 5.29972352e-02f, -7.58225396e-02f,
  2.73161940e-02f, 1.05224282e-01f, 4.50838506e-02f, 1.54037317e-02f, 1.33825988e-01f, 2.01841630e-02f, 8.35086033e-02f, -5.37307421e-03f, 1.07657956e-02f, -7.56659433e-02f,
  -6.01209141e-02f, -2.84878723e-02f, -5.57887694e-03f, 3.72736491e-02f, 2.48571429e-02f, 8.11275542e-02f, 1.00733422e-01f, 7.71684851e-03f, -6.50638789e-02f, -2.26175841e-02f,
  -7.96583146e-02f, -1.52706797e-03f, 2.84355017e-03f, -2.92423498e-02f, 1.42873824e-02f, -2.47330014e-02f, 3.29765794e-03f, -7.32783899e-02f, -2.90125627e-02f, 3.76484077e-03f,
  -7.05752000e-02f, 5.57699203e-02f, 3.36897895e-02f, 8.71870071e-02f, 4.26314808e-02f, -1.24150477e-02f, 1.15895823e-01f, 3.01451935e-03f, 9.62469429e-02f, 4.76365723e-02f,
  -1.41310588e-01f, 1.89970613e-01f, 2.44550202e-02f, -3.19207162e-02f, -2.82682832e-02f, 2.81689037e-02f, 1.72707811e-02f, -6.56758854e-03f, 5.40649816e-02f, -5.85253574e-02f,
  3.93323861e-02f, 3.60609181e-02f, 6.88575953e-02f, -2.52588326e-03f, 2.64145527e-02f, 7.58111626e-02f, -4.76271585e-02f, -6.74799532e-02f, -2.56352965e-02f, 3.59321050e-02f,
  -2.65239757e-02f, 6.36703148e-02f, -8.24567303e-02f, 6.64485320e-02f, 6.53038844e-02f, 4.91089970e-02f, -5.83340190e-02f, -4.76228073e-02f, 1.13317519e-01f, -1.07821628e-01f,
  8.01473111e-02f, 4.47311774e-02f, -5.70560768e-02f, -1.54548911e-02f, -4.05068435e-02f, -1.66896638e-02f, 7.96687752e-02f, 5.35603575e-02f, -5.80856875e-02f, 8.25150982e-02f,
  4.69839051e-02f, 1.10344216e-02f, -1.44774271e-02f, -8.23814496e-02f, 1.12450100e-01f, -7.11750090e-02f, -8.51059705e-02f, 1.79340784e-02f, 3.08125820e-02f, 7.07710758e-02f,
  5.60287349e-02f, -5.58975004e-02f, 8.29820409e-02f, 3.46801393e-02f, -3.47413979e-02f, -9.09898952e-02f, -5.40723726e-02f, 2.06304602e-02f, 6.52315542e-02f, -1.47388712e-01f,
  -6.57017827e-02f, 1.70929939e-01f, -5.64539023e-02f, 3.55342440e-02f, 5.09651974e-02f, -4.51635122e-02f, -5.21853901e-02f, 5.17359599e-02f, 1.06681520e-02f, 2.34211180e-02f,
  -9.64261964e-02f, -1.98776145e-02f, -8.93060043e-02f, 7.68074691e-02f, -2.68119480e-02f, 5.17442971e-02f, -8.27853382e-02f, -8.28700066e-02f, -1.98936220e-02f, 7.09866509e-02f,
  -2.42038071e-02f, 8.94501135e-02f, 4.52356711e-02f, -1.98281393e-03f, 8.06277394e-02f, 3.85941900e-02f, 1.75726078e-02f, 5.03915846e-02f, 9.49870199e-02f, -2.92167906e-02f,
  -1.98568571e-02f, -5.17590269e-02f, -3.55595872e-02f, 6.21650182e-02f, 5.85679859e-02f, 6.01125322e-03f, -5.25126420e-02f, -7.00930413e-03f, 2.06088531e-03f, 2.07774919e-02f,
  -5.96849136e-02f, -3.70991081e-02f, -3.96838561e-02f, 2.38857102e-02f, 7.12062605e-03f, 7.77563304e-02f, 9.67802107e-03f, 3.23986933e-02f, -3.75681110e-02f, -5.01853451e-02f,
  2.84525808e-02f, 4.97005954e-02f, 7.82783628e-02f, -3.66794206e-02f, 5.07422052e-02f, 9.06128734e-02f, 9.28988904e-02f, 4.50263396e-02f, 6.12089299e-02f, -5.08462526e-02f,
  -1.52102351e-01f, 5.48617318e-02f, -7.80252516e-02f, 2.49477662e-02f, 2.52204575e-02f, -8.58015963e-04f, -8.31800513e-03f, 1.29052373e-02f, 5.97344339e-02f, -9.80647933e-03f,
  5.08023575e-02f, 8.79387483e-02f, 8.58631805e-02f, -1.00037575e-01f, -8.81698877e-02f, 2.91215722e-02f, -1.01006240e-01f, -1.40174795e-02f, 6.11288399e-02f, -3.90592846e-03f,
  -2.07961947e-02f, -7.09938556e-02f, 2.98569389e-02f, 6.34429380e-02f, -3.55117247e-02f, -6.69386536e-02f, -9.49213803e-02f, -1.00981385e-01f, -2.55977660e-02f, -1.17182776e-01f,
  5.15569970e-02f, 2.33776003e-01f, 8.75843391e-02f, -1.19289160e-02f, 1.17274903e-01f, 1.73984975e-01f, 2.14674786e-01f, -2.60976399e-03f, -1.00340068e-01f, -3.65129188e-02f,
  -2.77585145e-02f, -1.76214591e-01f, -2.10857242e-02f, 2.05708481e-02f, -4.38867584e-02f, 3.84356268e-02f, -5.80829158e-02f, 5.27689308e-02f, 1.48322352e-03f, 5.73100261e-02f,
  -8.84561688e-02f, -9.09705237e-02f, 7.15871248e-03f, -7.00576976e-03f, 3.64096239e-02f, -1.06102586e-01f, -4.45792638e-02f, -5.92222549e-02f, 7.57477134e-02f, 7.76425470e-03f,
  1.76717713e-02f, 9.67553854e-02f, -4.96274605e-02f, -1.56219110e-01f, -1.75122842e-02f, 8.89446680e-03f, -4.76921629e-03f, -7.58370534e-02f, 6.95092604e-02f, 1.46166503e-03f,
  5.49579859e-02f, 9.21380520e-02f, 5.49478456e-02f, -4.93817925e-02f, 9.06763226e-02f, -4.17904034e-02f, -5.19950641e-03f, 9.66716036e-02f, -6.32076012e-03f, 2.19840202e-02f,
  6.31124750e-02f, 4.97784279e-03f, 1.49156541e-01f, -5.05791940e-02f, 5.89604527e-02f, -1.18600227e-01f, -1.68778375e-02f, -7.10523576e-02f, 1.01485685e-01f, -2.57858224e-02f,
  2.69031581e-02f, -4.99678589e-02f, 4.72243764e-02f, 5.28814718e-02f, 5.44715971e-02f, 8.58672038e-02f, 2.40442455e-02f, -3.70947756e-02f, 1.81683078e-02f, 8.91987383e-02f,
  -2.74085347e-03f, 7.94987753e-03f, 7.71430209e-02f, -3.77370007e-02f, -2.59891227e-02f, 4.38428558e-02f, 1.04305200e-01f, 1.95881519e-02f, 1.86077096e-02f, 8.37057009e-02f,
  -6.58463240e-02f, -6.44563064e-02f, 2.67273076e-02f, 4.58292589e-02f, -8.64110440e-02f, 5.68993688e-02f, -9.72078368e-02f, -3.65405455e-02f, -9.12715122e-02f, -4.73055355e-02f,
  -1.75532117e-01f, 6.35529310e-02f, -1.04947850e-01f, -3.66883017e-02f, 8.00650790e-02f, 9.53959674e-03f, -6.15253486e-03f, 1.12474151e-02f, 2.01012064e-02f, -2.02781204e-02f,
  3.64576615e-02f, -6.17850199e-03f, -7.28686713e-03f, 5.57379127e-02f, -3.91993597e-02f, -7.69504309e-02f, -1.19131906e-02f, -8.63838643e-02f, -6.68831915e-02f, 3.74387540e-02f,
  2.79378444e-02f, -5.16598858e-02f, -1.07634738e-01f, -9.95680690e-02f, -4.33567762e-02f, -1.53128281e-01f, 2.56596599e-02f, -3.07958253e-04f, -9.65715423e-02f, -1.26465455e-01f,
  -1.18312016e-01f, -1.54469863e-01f, 1.19718559e-01f, -1.05495099e-02f, 8.58945947e-04f, 1.04333788e-01f, 9.69703645e-02f, -6.10983744e-02f, 3.10773458e-02f, 1.85343623e-02f,
  -1.08378105e-01f, -5.45152202e-02f, -1.12256452e-01f, -1.37835085e-01f, -1.19924091e-01f, 4.05044034e-02f, 1.28496602e-01f, 6.64536953e-02f, 1.78593650e-01f, 9.94024724e-02f,
  -6.67812303e-02f, 1.87770976e-03f, 1.75464787e-02f, 8.67864937e-02f, -3.16865854e-02f, -5.09424843e-02f, 9.48500931e-02f, -5.77440262e-02f, -5.53812534e-02f, -8.56041536e-02f,
  8.12830403e-02f, -1.50447994e-01f, 5.85893588e-03f, -1.28374651e-01f, 4.60133888e-02f, 3.27641331e-02f, 7.03858435e-02f, 8.56781565e-03f, 6.96324091e-03f, -6.26531467e-02f,
  2.71362141e-02f, -1.27756655e-01f, -4.36982745e-03f, -3.69799510e-02f, 3.40418257e-02f, -3.79723944e-02f, -8.17382410e-02f, 6.92900121e-02f, -5.47125153e-02f, -9.57082808e-02f,
  -5.06013632e-03f, -7.09369704e-02f, 5.60765006e-02f, -6.47239611e-02f, 3.03744171e-02f, 9.85151064e-03f, 1.40929595e-02f, -1.58934593e-02f, 6.17619902e-02f, -7.03715235e-02f,
  4.17127348e-02f, 3.01532522e-02f, -7.60384202e-02f, -5.09505533e-02f, 5.82948560e-03f, -3.87581363e-02f, 9.32090729e-02f, -3.69525924e-02f, 5.44638038e-02f, -4.50281911e-02f,
  2.24806070e-02f, -1.04525285e-02f, -7.36649334e-02f, 1.60252191e-02f, -1.35313617e-02f, 2.40542609e-02f, 6.31802827e-02f, 3.23188654e-03f, -9.09174047e-03f, -1.75179169e-02f,
  9.30859074e-02f, -8.44980925e-02f, 5.05102426e-02f, 2.61635520e-02f, 9.54486653e-02f, 3.94021627e-04f, -4.60711159e-02f, -1.54777768e-03f, -6.17098287e-02f, 8.90920386e-02f,
  -4.69739884e-02f, 1.44213354e-02f, -8.21687877e-02f, 4.69449423e-02f, 1.64845580e-04f, -8.31053182e-02f, -1.50480457e-02f, -7.13812858e-02f, 7.53126992e-03f, -5.29100448e-02f,
  8.48862622e-03f, -3.92213240e-02f, -3.83839719e-02f, 3.47929969e-02f, 1.23886406e-01f, 8.95149112e-02f, -1.16562545e-01f, 6.07112758e-02f, 7.04465285e-02f, 1.79378111e-02f,
  -2.82617044e-02f, 6.05454966e-02f, 1.25525594e-01f, 1.32874511e-02f, -4.25086878e-02f, 8.82982388e-02f, 1.07815072e-01f, 4.67951745e-02f, 8.64845216e-02f, 5.09407781e-02f,
  -1.33543119e-01f, -3.09196487e-02f, -1.21914268e-01f, 3.87533149e-03f, -1.84262544e-02f, 8.88086110e-03f, 7.72487670e-02f, 2.36301832e-02f, -6.56790435e-02f, -2.36174315e-02f,
  7.28818402e-02f, 9.09285694e-02f, -5.05711995e-02f, -3.63601483e-02f, 3.22261155e-02f, 2.00426783e-02f, -5.34998253e-02f, -1.95005890e-02f, -4.58295792e-02f, 1.28433714e-02f,
  1.30107310e-02f, 1.05305962e-01f, -8.30772296e-02f, 4.33142930e-02f, -2.25517526e-02f, 4.33704555e-02f, -1.35227945e-02f, -3.36665101e-02f, 6.11956939e-02f, -7.65665323e-02f,
  1.22083619e-01f, -1.26518086e-01f, -9.26442444e-02f, -5.88482991e-02f, -4.77836803e-02f, 2.48916112e-02f, -4.44001816e-02f, -2.83990540e-02f, -1.15301065e-01f, 1.64435040e-02f,
  -8.75858590e-02f, -2.40249317e-02f, -2.81079523e-02f, 4.51542772e-02f, 7.94616044e-02f, 5.11275530e-02f, 5.61397858e-02f, -6.99477717e-02f, -1.33566791e-02f, -6.14569336e-02f,
  5.95753752e-02f, -8.78462493e-02f, 3.64319310e-02f, -5.63635640e-02f, -4.95255291e-02f, -6.65255561e-02f, -5.76790273e-02f, 1.70562305e-02f, 4.90409806e-02f, 9.00064036e-02f,
  -2.94193849e-02f, 5.58417551e-02f, 5.37492195e-03f, 3.79998572e-02f, -8.05245116e-02f, -7.05085844e-02f, 5.22452453e-03f, 7.64419958e-02f, 3.85785513e-02f, 7.87665993e-02f,
  -4.10697497e-02f, -7.59576820e-03f, 9.06043053e-02f, 4.53636870e-02f, -4.18683290e-02f, -3.56702358e-02f, -5.88398911e-02f, 1.95332393e-02f, -9.43350345e-02f, -6.01297691e-02f,
  2.55410634e-02f, -4.91564088e-02f, 1.32905114e-02f, -5.62839443e-03f, -4.05684263e-02f, 4.33711931e-02f, 5.66543080e-02f, -6.40394241e-02f, 7.92462006e-02f, -8.02786201e-02f,
  1.95320234e-01f, -8.37492645e-02f, -3.56611586e-03f, -9.27017704e-02f, -8.06317106e-02f, -5.90372682e-02f, -4.69907280e-03f, -9.22872312e-03f, -8.19638595e-02f, -5.30288555e-02f,
  8.54090452e-02f, 3.87272611e-02f, 4.63562272e-02f, 1.94763821e-02f, 6.62928894e-02f, -4.34994511e-03f, 6.87584132e-02f, -4.43449505e-02f, -5.02750278e-02f, 3.97009328e-02f,
  -3.72577948e-03f, 6.82241842e-02f, 9.21457186e-02f, -6.59506768e-02f, -6.13535680e-02f, -5.01344390e-02f, 5.47033921e-03f, 4.89502437e-02f, 1.53808948e-02f, 1.72312587e-01f,
  -1.18351141e-02f, -2.26181611e-01f, -3.08193564e-01f, 3.41105163e-02f, 3.43002588e-03f, -6.07295521e-02f, -8.50190595e-02f, 3.46574634e-02f, -2.65865289e-02f, -1.26427397e-01f,
  -5.66000715e-02f, -2.87793949e-02f, -7.10188076e-02f, -9.30829067e-03f, -1.02237046e-01f, -1.53312877e-01f, -2.59335250e-01f, -2.07857192e-01f, -2.62824073e-02f, 7.28996024e-02f,
  -4.68792804e-02f, -1.26751617e-01f, -9.45450142e-02f, 1.76329364e-03f, 3.29145277e-03f, -5.29093482e-02f, -1.69352397e-01f, -1.75949767e-01f, -1.41413867e-01f, -2.56616950e-01f,
  -9.29048881e-02f, 1.19698226e-01f, 9.82092246e-02f, 2.11397316e-02f, -8.52666125e-02f, 8.01746268e-03f, -3.08140758e-02f, -6.99495003e-02f, -6.92833588e-02f, -8.73299763e-02f,
  6.80823624e-02f, 8.83108824e-02f, 1.92729607e-02f, 8.00526515e-02f, -1.47834867e-02f, -8.14088807e-02f, 4.47358005e-02f, -1.05316550e-01f, 3.24792750e-02f, -6.34685606e-02f,
  -5.62614910e-02f, -5.73836407e-03f, -1.08734384e-01f, -1.11947404e-02f, 4.20099907e-02f, 2.09154971e-02f, 2.74876300e-02f, 1.02135234e-01f, -9.14154798e-02f, 1.46269919e-02f,
  3.93533260e-02f, 6.06150813e-02f, 9.08483937e-03f, 1.29873201e-01f, -4.20535207e-02f, -5.67419752e-02f, 6.91438392e-02f, 4.34408560e-02f, 8.15378800e-02f, 1.84557661e-02f,
  -4.92294831e-03f, 1.80963967e-02f, -5.06507792e-02f, -3.41907330e-02f, -4.31864560e-02f, 3.93442586e-02f, -8.20718929e-02f, -9.13569778e-02f, -1.04839265e-01f, -5.02243452e-02f,
  -8.37797001e-02f, -5.98647408e-02f, 2.65120659e-02f, -4.19237390e-02f, -6.88907877e-02f, 6.88874796e-02f, 1.92628510e-03f, -7.59996800e-03f, -3.97832319e-02f, 5.30171767e-02f,
  2.70484444e-02f, 2.00352743e-02f, -1.37666494e-01f, 2.40184478e-02f, -3.42074297e-02f, 2.01098882e-02f, -7.10694194e-02f, 2.82710064e-02f, 5.98532930e-02f, 1.81985516e-02f,
  1.40719973e-02f, 4.98241931e-02f, -1.10292509e-01f, 3.25491540e-02f, -3.61186266e-02f, -5.19350134e-02f, -8.43628272e-02f, -6.13382906e-02f, -9.69594792e-02f, -5.19391149e-04f,
  -1.00297011e-01f, -1.19899295e-01f, -9.89691690e-02f, -3.39352041e-02f, -6.75001293e-02f, 1.39462408e-02f, -1.55242801e-01f, -1.04244784e-01f, 5.36204968e-03f, -2.81370189e-02f,
  -1.23823315e-01f, -6.46878928e-02f, 6.85473755e-02f, -1.17278937e-02f, -5.95091796e-03f, -3.74182165e-02f, 8.84529576e-02f, 3.01527679e-02f, -8.83422568e-02f, 2.22330671e-02f,
  -2.54164990e-02f, -5.12968190e-02f, -1.20289363e-01f, -1.14779599e-01f, -8.98236111e-02f, -1.11948021e-01f, -2.32857931e-02f, -1.24777310e-01f, 6.43884316e-02f, 6.51822761e-02f,
  2.21772920e-02f, -6.97215796e-02f, 5.19025773e-02f, -5.23923151e-03f, -4.83398587e-02f, 2.89893746e-02f, -1.97200067e-02f, -9.14520845e-02f, -5.05544916e-02f, -1.45105228e-01f,
  -2.63361447e-02f, 1.59045890e-01f, 1.56139107e-02f, 9.72974226e-02f, 4.28283662e-02f, 7.97456279e-02f, 7.81461373e-02f, 1.26501694e-02f, -5.50803542e-02f, -6.02412969e-02f,
  1.11441568e-01f, 2.87607836e-04f, 1.22536972e-01f, 1.12561345e-01f, 1.28769428e-01f, 9.20147300e-02f, 4.43408787e-02f, -5.42194135e-02f, 8.67724270e-02f, 6.28795400e-02f,
  1.26933411e-01f, -2.63304869e-03f, 4.51572845e-03f, -3.59011665e-02f, -4.14954238e-02f, 2.90024877e-02f, 7.61563182e-02f, -1.64345670e-02f, -7.47700855e-02f, -6.42384365e-02f,
  -4.20491099e-02f, -9.33920741e-02f, -4.21696668e-03f, -4.33269069e-02f, -8.08940306e-02f, 5.39233536e-03f, 4.15475778e-02f, -6.41537905e-02f, -7.78763788e-03f, 9.06931311e-02f,
  -3.35150734e-02f, -7.97246769e-03f, 7.52981380e-02f, -3.45525518e-02f, -6.75241053e-02f, -3.16521712e-02f, -4.36904244e-02f, 4.21698354e-02f, -4.83568609e-02f, -4.81550545e-02f,
  6.48210719e-02f, 6.59828410e-02f, 1.36324232e-02f, 1.40555687e-02f, 2.07179599e-02f, 8.01609829e-02f, 5.92271239e-02f, -2.00052038e-02f, 7.00918883e-02f, -1.93373729e-02f,
  -1.04509279e-01f, 7.88321719e-02f, -4.99386266e-02f, -5.45043033e-03f, 2.98620723e-02f, 3.83648053e-02f, 5.18783294e-02f, -2.47790869e-02f, 1.94894001e-02f, 8.39565918e-02f,
  1.16061673e-01f, 6.86313063e-02f, 2.01234221e-02f, 2.16097459e-02f, 1.28120475e-03f, 8.99936259e-02f, -1.68150309e-02f, -1.58316623e-02f, -3.27826701e-02f, 1.10272139e-01f,
  -7.04463646e-02f, 1.09583605e-02f, -1.55958578e-01f, -7.52197579e-02f, 2.20190659e-02f, 4.34383372e-04f, 2.80736084e-03f, -1.11563139e-01f, -4.73425277e-02f, -1.56949759e-01f,
  -3.04198235e-01f, -6.71705231e-02f, 1.19081773e-01f, -2.34948974e-02f, 7.16530606e-02f, 1.39382482e-01f, 1.07717894e-01f, 1.10086575e-01f, 1.81873608e-02f, 3.56791988e-02f,
  2.56539485e-03f, -9.33998227e-02f, 7.37719983e-02f, 2.81060562e-02f, 3.00883707e-02f, 1.42170072e-01f, 3.23660821e-02f, -6.18004985e-02f, 2.63639865e-03f, 8.97107944e-02f,
  -4.39241715e-02f, -4.17934917e-02f, -1.74973279e-01f, -1.13986544e-02f, -7.35972747e-02f, -6.72095716e-02f, 2.20796671e-02f, -6.02300577e-02f, 2.02382691e-02f, -6.41688481e-02f,
  -1.57861173e-01f, -1.46578312e-01f, 1.12583496e-01f, -9.71834660e-02f, -2.42096148e-02f, -5.68933189e-02f, 4.93210107e-02f, -1.15224391e-01f, -6.89590424e-02f, -4.92155328e-02f,
  -6.18796088e-02f, -2.95668393e-02f, 1.47204110e-02f, -9.14197043e-02f, -3.46628651e-02f, 7.16933161e-02f, 3.76088209e-02f, -4.41430919e-02f, 8.55724420e-03f, -6.40822202e-02f,
  5.06897755e-02f, -2.86546908e-02f, -1.37735948e-01f, -9.25433077e-03f, -6.22447617e-02f, 7.87720829e-03f, -1.06520496e-01f, -2.84470841e-02f, -3.66207510e-02f, -3.77679355e-02f,
  2.02877726e-03f, 7.56639019e-02f, 8.35795775e-02f, -4.08283100e-02f, -4.10833284e-02f, -1.26549555e-02f, -2.82314122e-02f, -3.87734585e-02f, 9.00321677e-02f, -3.15035284e-02f,
  -5.42935655e-02f, 4.09387909e-02f, -6.11103177e-02f, 3.27806063e-02f, 3.62069197e-02f, -4.85806204e-02f, 5.31264916e-02f, -1.31255770e-02f, -3.84983383e-02f, -4.62532751e-02f,
  -8.84712711e-02f, 7.98599198e-02f, -7.14291260e-02f, 3.93941402e-02f, -6.09722808e-02f, 9.22160894e-02f, -6.91350624e-02f, 4.68443260e-02f, -3.18590552e-02f, -2.21528802e-02f,
  -1.57210082e-01f, 1.15257300e-01f, -1.76410303e-02f, -1.23723440e-01f, -5.84621131e-02f, 4.53851968e-02f, 3.65696326e-02f, -1.43118836e-02f, -7.83759169e-04f, -5.47787100e-02f,
  -1.94087364e-02f, -4.55230251e-02f, 2.42200159e-02f, 3.59177440e-02f, 4.02057432e-02f, -7.10830241e-02f, -3.63058932e-02f, -8.63504559e-02f, -1.60112195e-02f, -9.65975970e-02f,
  1.71198826e-02f, -1.72500387e-02f, -8.02627802e-02f, -6.90419376e-02f, -7.09335059e-02f, 4.38080431e-04f, -4.79165725e-02f, 4.59497236e-02f, -2.12809443e-03f, -8.61437395e-02f,
  -6.16663657e-02f, 2.08604988e-03f, -8.67324974e-03f, -1.95024431e-01f, -1.14074774e-01f, 5.58754392e-02f, -9.18243360e-03f, -6.96306750e-02f, -1.42358437e-01f, -7.53839463e-02f,
  8.54555294e-02f, -9.22278315e-02f, -2.37726551e-02f, -1.06756724e-02f, -1.18507082e-02f, 1.07687123e-01f, 5.23274280e-02f, 1.39607623e-01f, 5.84082715e-02f, -7.68871605e-02f,
  -1.22194067e-01f, -4.37951013e-02f, -2.74806302e-02f, -6.68694824e-02f, -6.85083345e-02f, -8.53462368e-02f, 3.03469039e-02f, -8.84970948e-02f, -3.02077308e-02f, -1.30858406e-01f,
  -1.43568113e-01f, 7.02834502e-02f, -4.61747823e-03f, -1.93025358e-02f, 2.87924670e-02f, 5.80919757e-02f, -8.03215876e-02f, 3.33160423e-02f, -8.35418925e-02f, 4.14978750e-02f,
  -3.33196111e-02f, 1.61261521e-02f, -9.11768228e-02f, -3.22025008e-02f, -2.62570214e-02f, -2.72627193e-02f, -5.04877269e-02f, 8.05675983e-02f, 3.42619955e-04f, -2.22933050e-02f,
  -8.80433526e-03f, -1.03745542e-01f, -5.10268770e-02f, 6.04754640e-03f, -1.76726151e-02f, -5.68160005e-02f, 1.30932813e-03f, -6.73640817e-02f, 3.92226018e-02f, -9.80970785e-02f,
  1.22203575e-02f, 5.19308485e-02f, -5.93633987e-02f, -1.98018781e-04f, 4.45386767e-02f, -1.04717016e-01f, 6.52490929e-02f, 7.96300080e-03f, -4.31354195e-02f, 1.16944853e-02f,
  9.25624818e-02f, 1.18772807e-02f, 5.41359782e-02f, -9.03240815e-02f, -3.51427160e-02f, 2.30829176e-02f, 9.30098221e-02f, 7.10993707e-02f, -3.98247316e-02f, -6.95465356e-02f,
  -5.99773824e-02f, -6.94399327e-02f, -7.25253969e-02f, 9.13577992e-03f, 4.83915620e-02f, 1.02266312e-01f, -4.98634577e-02f, -9.07313079e-03f, -3.88033129e-02f, -7.72378445e-02f,
  -1.64064556e-01f, 2.30190575e-01f, -1.29820526e-01f, 1.98988188e-02f, -3.28911394e-02f, -1.36170220e-02f, -8.26599300e-02f, -1.75112076e-02f, 8.12240934e-04f, -5.05898930e-02f,
  7.48984814e-02f, -6.26629293e-02f, -1.78349800e-02f, 2.70218048e-02f, -7.36581907e-02f, 1.06450869e-02f, -8.52642357e-02f, 1.06837815e-02f, -4.85316105e-02f, 1.28791602e-02f,
  -3.74404006e-02f, -8.67383629e-02f, -2.16017645e-02f, -1.30366981e-01f, -9.74358171e-02f, -2.27021482e-02f, -6.05523586e-02f, -1.41614854e-01f, 8.02773237e-02f, -9.45977122e-02f,
  -3.74135971e-02f, -7.91882500e-02f, 5.04987128e-02f, 5.77885583e-02f, -4.91378177e-03f, 2.81691123e-02f, -1.03788853e-01f, 4.43851575e-02f, 9.65438336e-02f, -8.65657777e-02f,
  -1.38110429e-01f, -9.53571349e-02f, -9.09096971e-02f, -1.21392198e-01f, 2.78763175e-02f, -6.91731498e-02f, -8.49864110e-02f, -3.26994620e-02f, -9.71693173e-02f, -1.48362651e-01f,
  -1.33702397e-01f, -8.38191733e-02f, -5.34253679e-02f, -2.13109292e-02f, -6.91469386e-02f, -1.04648978e-01f, 9.86102223e-03f, -3.47982496e-02f, -1.39049128e-01f, -2.13720417e-03f,
  -8.23254138e-02f, 6.94926921e-03f, 5.92100210e-02f, -8.67041871e-02f, 4.13831584e-02f, 3.16996537e-02f, 3.95674109e-02f, 5.54367267e-02f, -3.43320370e-02f, 1.18610384e-02f,
  -7.75350118e-03f, 1.06250895e-02f, -7.00285360e-02f, -1.06435664e-01f, 4.55588885e-02f, -7.83528984e-02f, -2.10217144e-02f, -8.02551955e-02f, -9.10425857e-02f, -1.27270874e-02f,
  1.56539325e-02f, -1.16281128e-02f, -4.73090522e-02f, -7.36983642e-02f, 7.06982091e-02f, -1.12506121e-01f, -8.70687664e-02f, 1.06172718e-03f, -6.64448440e-02f, 5.07001765e-02f,
  -1.11556600e-03f, 3.48909199e-02f, 6.36944845e-02f, -7.34029263e-02f, 5.47366031e-02f, 1.68208051e-02f, 5.38841262e-02f, 2.13815104e-02f, 2.04457510e-02f, -7.35051036e-02f,
  4.35451232e-02f, 9.29034129e-03f, -5.84913418e-03f, 5.02396785e-02f, 4.69200499e-02f, -5.28981611e-02f, 5.26832491e-02f, 1.27911465e-02f, -4.16455651e-03f, 6.49770051e-02f,
  5.04046939e-02f, -7.09251016e-02f, 7.95283318e-02f, -5.13103716e-02f, 2.75846217e-02f, 6.97904155e-02f, 2.38161888e-02f, -6.83635995e-02f, 2.12657526e-02f, 1.43077616e-02f,
  -6.39548898e-02f, -1.02256000e-01f, -4.05635461e-02f, -7.47642070e-02f, -5.88030629e-02f, 6.06210679e-02f, 7.99461454e-02f, -1.82541683e-02f, -4.45460230e-02f, -3.84642445e-02f,
  -2.91712563e-02f, -5.90883009e-03f, -1.90100837e-02f, -5.85791506e-02f, -6.56967834e-02f, 7.58239105e-02f, -8.31152312e-03f, 7.03904778e-02f, -2.04503722e-02f, 5.81093766e-02f,
  8.42639655e-02f, 2.02755164e-02f, 5.47063202e-02f, 1.99699239e-03f, -4.77331541e-02f, 3.89731047e-03f, 1.22667775e-02f, -6.54714629e-02f, -2.50062272e-02f, -2.44861469e-02f,
  -1.63010567e-01f, -2.19161101e-02f, 6.62030578e-02f, -4.84747812e-02f, 8.08787420e-02f, -5.90580180e-02f, -2.99554528e-03f, -6.76525012e-02f, -6.69165105e-02f, 5.15017994e-02f,
  -9.98179242e-03f, -8.91913921e-02f, -5.74711375e-02f, -8.41873214e-02f, -7.76127577e-02f, -6.81027696e-02f, -8.74916464e-02f, -6.16025776e-02f, 5.59388250e-02f, 7.88246542e-02f,
  -4.24923562e-03f, 6.02343353e-04f, -1.30285710e-01f, -3.74875553e-02f, -1.84009038e-02f, 6.76745027e-02f, 6.21130392e-02f, 2.80854963e-02f, -8.42121243e-02f, -8.57150480e-02f,
  1.00893877e-01f, 2.59664729e-02f, 6.98476732e-02f, -8.53996798e-02f, -1.36039034e-02f, 3.18007432e-02f, 4.13303375e-02f, 5.76521829e-03f, 3.23415705e-04f, -2.27587912e-02f,
  -4.56000119e-03f, 3.75313200e-02f, -9.16285664e-02f, 3.50245163e-02f, 6.94416389e-02f, 2.10480914e-02f, 8.31487123e-03f, -4.66677286e-02f, -8.24378580e-02f, 6.82183504e-02f,
  -8.59799087e-02f, -8.97046030e-02f, -5.94876856e-02f, -5.29633760e-02f, -7.73625495e-03f, 5.58984019e-02f, 3.94778699e-02f, -2.68881470e-02f, 9.15888697e-02f, 3.98789309e-02f,
  -5.47389984e-02f, 1.65568627e-02f, 5.86374998e-02f, -5.37752323e-02f, 1.47567913e-02f, 9.38764587e-02f, 8.72146860e-02f, -2.29919422e-02f, 4.82488684e-02f, -8.08569863e-02f,
  -6.52897730e-02f, 6.61562830e-02f, -4.65686880e-02f, 4.47461456e-02f, -9.31307599e-02f, -2.92267296e-02f, -6.46845177e-02f, -4.24017347e-02f, 6.19353652e-02f, -7.36878291e-02f,
  6.02728017e-02f, -3.30016576e-02f, 6.36362210e-02f, -9.16312039e-02f, -9.18887854e-02f, 2.57736761e-02f, 8.29879101e-03f, 2.66302601e-02f, 5.22427410e-02f, 7.85199478e-02f,
  7.55870789e-02f, -3.59963346e-03f, -6.40891790e-02f, -3.96422558e-02f, 9.56815705e-02f, 4.86741588e-02f, -6.87575489e-02f, 3.11110672e-02f, -3.01861633e-02f, -4.37945537e-02f,
  -7.45060220e-02f, -3.27162491e-03f, -6.87463209e-02f, -2.66776066e-02f, -5.36899902e-02f, 8.59052166e-02f, -7.81885162e-02f, -7.39034340e-02f, 8.51348117e-02f, 8.59286711e-02f,
  3.91108207e-02f, 5.74659891e-02f, -1.78949293e-02f, 3.57779115e-03f, 5.81980385e-02f, -1.64584946e-02f, 1.24280393e-01f, 2.80534066e-02f, -4.94837314e-02f, 9.61357206e-02f,
  -2.05410495e-01f, 2.08579674e-02f, 1.82969913e-01f, -6.53748587e-02f, 6.57553300e-02f, -7.25880340e-02f, 5.18761948e-03f, -1.28239512e-01f, -1.16459616e-01f, 2.36214027e-02f,
  6.04838915e-02f, -7.34843612e-02f, 5.79838753e-02f, -4.60793115e-02f, -6.49480671e-02f, 6.17020503e-02f, 8.34789649e-02f, -7.36252591e-02f, -1.24776818e-01f, -2.03807764e-02f,
  2.44272389e-02f, 3.80437449e-02f, 1.45846745e-02f, -5.69704026e-02f, -9.86819789e-02f, -9.52165648e-02f, 8.48283842e-02f, 7.91044310e-02f, -3.22132483e-02f, -4.99859378e-02f,
  3.54443304e-02f, -2.51737945e-02f, -6.21497557e-02f, -6.69596866e-02f, -4.22966406e-02f, -6.65817857e-02f, -3.25605199e-02f, -6.18743263e-02f, 7.79950768e-02f, 5.88232139e-03f,
  -8.59739725e-03f, -4.59934808e-02f, 6.45029396e-02f, -7.10336640e-02f, -3.78911532e-02f, -1.23577587e-01f, -1.72829702e-02f, 7.49728642e-03f, -2.27854159e-02f, 5.72881922e-02f,
  8.94509107e-02f, 1.15241772e-02f, -1.99770946e-02f, 2.71263141e-02f, -9.80742574e-02f, -3.73545140e-02f, 1.76998544e-02f, -7.71696046e-02f, 3.85512263e-02f, -4.26665694e-02f,
  4.53859679e-02f, 5.34406751e-02f, 6.93012103e-02f, -1.13595743e-02f, -5.61066605e-02f, -1.81247126e-02f, 7.52370507e-02f, 5.03948629e-02f, -7.81698525e-02f, -6.68011531e-02f,
  9.03996229e-02f, 6.29671663e-02f, 4.08788733e-02f, -3.05512790e-02f, -7.08449855e-02f, -7.97927007e-02f, 5.48471250e-02f, 2.94785947e-02f, 1.12396749e-02f, 6.35463670e-02f,
  -1.11326128e-01f, -8.93992663e-04f, 5.53836003e-02f, 4.64205537e-03f, 7.40334317e-02f, 4.91411239e-02f, 4.25591096e-02f, 5.62354028e-02f, -1.02362230e-01f, 3.08490135e-02f,
  -5.86721599e-02f, 6.68866262e-02f, -1.16516039e-01f, -9.39885378e-02f, 6.10592067e-02f, 5.25867268e-02f, 1.98800452e-02f, -1.85730420e-02f, -3.97111066e-02f, -8.86681154e-02f,
  -1.41012352e-02f, -2.50063650e-02f, -3.90509740e-02f, -1.82860047e-02f, -3.95663735e-03f, -6.02823235e-02f, -2.94679664e-02f, 2.27389187e-02f, -3.67490388e-02f, -1.11174889e-01f,
  8.86528753e-03f, -1.76923886e-01f, -2.07167327e-01f, -1.52895316e-01f, -1.12495273e-01f, -1.52344465e-01f, -1.15440138e-01f, -9.60740149e-02f, -1.10344157e-01f, -2.16238439e-01f,
  1.22958496e-01f, 8.81875679e-02f, 1.59267522e-02f, -1.24881817e-02f, 5.62630557e-02f, 1.27418220e-01f, 5.92684671e-02f, -4.34714891e-02f, -8.16678628e-02f, 8.64691138e-02f,
  -8.72460231e-02f, 3.62683646e-02f, -2.59614363e-02f, -2.18309164e-02f, 5.54710180e-02f, -2.42252983e-02f, 6.76231384e-02f, -5.08583188e-02f, 2.21971646e-02f, 5.40126907e-03f,
  -1.48188323e-02f, 4.37286422e-02f, 8.16659629e-02f, 2.74539646e-02f, -4.86254990e-02f, 4.80849221e-02f, 5.22784963e-02f, 3.15702595e-02f, -4.97473963e-02f, -1.21219173e-01f,
  -7.58927539e-02f, 7.90077522e-02f, -5.79268001e-02f, -8.58797431e-02f, 2.47051157e-02f, -8.76846351e-03f, 2.72468035e-03f, -2.33197045e-02f, 5.88886254e-03f, -3.48568428e-03f,
  -1.59570780e-02f, -6.53608292e-02f, -5.76719120e-02f, 1.29729612e-02f, 6.04739785e-02f, -4.02267314e-02f, -1.54443411e-03f, 8.79453123e-02f, 4.32967655e-02f, -5.96498847e-02f,
  -7.65738264e-02f, -4.22867648e-02f, 1.57298878e-01f, 3.49053331e-02f, 4.85502854e-02f, 5.88918105e-02f, -2.21087858e-02f, 4.06244099e-02f, -3.13246734e-02f, -5.38926311e-02f,
  1.06343599e-02f, 3.09601501e-02f, -8.87046754e-02f, 5.30906208e-02f, -8.12584981e-02f, 8.58482569e-02f, -2.27812994e-02f, 1.36961164e-02f, 6.23363890e-02f, 4.95457798e-02f,
  -7.51480162e-02f, -2.76600644e-02f, -4.69006831e-03f, 6.63294047e-02f, -6.79863989e-02f, -6.06363565e-02f, 4.86353710e-02f, 3.62520590e-02f, -3.66014391e-02f, 5.31133674e-02f,
  8.28344673e-02f, 4.14146818e-02f, 1.23091698e-01f, 6.01216555e-02f, -5.36257438e-02f, 8.33534226e-02f, 5.88439628e-02f, 9.56514254e-02f, 4.52182703e-02f, 9.64985713e-02f,
  -1.15095995e-01f, 1.00278981e-01f, -9.55750495e-02f, -9.59653482e-02f, 1.00015946e-01f, 1.03480183e-02f, -9.46434364e-02f, 3.57232764e-02f, -2.22311784e-02f, -1.28053138e-02f,
  3.17750163e-02f, -1.85869373e-02f, 5.98506927e-02f, -9.70931351e-02f, 2.52821036e-02f, -4.30158861e-02f, 5.83665352e-03f, 8.91179740e-02f, -2.08054227e-03f, 3.52931358e-02f,
  -4.87325005e-02f, 5.68106994e-02f, 7.14623779e-02f, 4.77918386e-02f, -5.02386764e-02f, 7.37216696e-02f, 5.98324761e-02f, 9.59607121e-03f, 4.05719616e-02f, 8.24829843e-03f,
  2.17249300e-02f, 8.58442560e-02f, 6.48881420e-02f, 2.00810116e-02f, -9.51519608e-02f, -2.26886962e-02f, -4.83674966e-02f, -9.77305919e-02f, -6.52467534e-02f, -1.13090523e-01f,
  -1.30370587e-01f, -8.59437212e-02f, -9.86025631e-02f, 8.28327760e-02f, 1.23285919e-01f, -6.31544739e-02f, 9.41199288e-02f, 1.39892608e-01f, 6.25495166e-02f, -3.58296782e-02f,
  -6.76140562e-02f, 1.12034433e-01f, 7.78337717e-02f, 1.89563893e-02f, -1.06910309e-02f, 7.89653324e-03f, 2.77375113e-02f, -7.48555968e-03f, 6.46417364e-02f, 7.52652362e-02f,
  -8.60677212e-02f, 7.48843178e-02f, -1.36351474e-02f, -7.73471147e-02f, -6.21713931e-03f, -6.11429028e-02f, 2.94112749e-02f, 1.04337251e-02f, -1.86872799e-02f, 8.29960927e-02f,
  -1.37040727e-02f, -2.30588205e-02f, -1.07259586e-01f, -5.55068217e-02f, 1.03615206e-02f, -8.62780511e-02f, 1.52268242e-02f, 8.53292868e-02f, 7.75510296e-02f, -1.72960199e-03f,
  -9.91384611e-02f, -9.71846581e-02f, 9.57855284e-02f, -4.55650548e-03f, 6.56185821e-02f, 6.13653474e-02f, -2.09000893e-02f, -6.60466924e-02f, -1.21090189e-02f, -2.72927396e-02f,
  5.60709573e-02f, 1.63920298e-02f, -2.68043615e-02f, 6.77823797e-02f, -6.56023845e-02f, 4.31913957e-02f, -1.25823254e-02f, 3.00150327e-02f, 7.83914328e-02f, 9.83835235e-02f,
  3.07959653e-02f, 5.59296273e-02f, 1.35752335e-02f, 4.40008603e-02f, 6.57589510e-02f, 7.97590986e-02f, -3.82171050e-02f, -1.18820202e-02f, -4.92048915e-03f, -3.44630666e-02f,
  1.59299206e-02f, -7.02600703e-02f, -7.89776072e-02f, 2.65627746e-02f, 3.72233838e-02f, 2.60557071e-03f, -8.37328583e-02f, -5.59948236e-02f, 4.68579717e-02f, 8.17849208e-03f,
  -3.12965028e-02f, 5.06833754e-02f, -9.68259573e-02f, 2.62305420e-02f, 6.34869188e-02f, -7.60344714e-02f, -8.07691142e-02f, 5.27504794e-02f, -4.50266413e-02f, 7.62523487e-02f,
  -1.94681585e-02f, 1.26167843e-02f, -5.04585654e-02f, -5.40795326e-02f, 5.87114692e-02f, -5.24748452e-02f, 1.26918601e-02f, 4.98386770e-02f, -3.86548485e-03f, -8.08358043e-02f,
  6.82273954e-02f, -7.10833445e-02f, -3.08735017e-02f, 8.53952393e-03f, -6.16963245e-02f, -6.68457970e-02f, -5.18403761e-02f, 6.03063256e-02f, 3.34214568e-02f, -4.26548459e-02f,
  -7.53349904e-03f, 1.33901313e-01f, 1.05135478e-01f, -6.63988804e-03f, -1.25233188e-01f, -8.15161169e-02f, -3.04651130e-02f, -1.39144152e-01f, 3.30627859e-02f, 2.91986205e-02f,
  2.78586615e-02f, -7.51746297e-02f, -4.14205939e-02f, 5.98983318e-02f, -5.68070747e-02f, 2.42251866e-02f, 1.10115670e-01f, -4.79971291e-03f, 3.32852006e-02f, -9.91701186e-02f,
  6.14658073e-02f, -6.44167885e-02f, -2.05989033e-02f, 4.96053929e-03f, 1.78632140e-01f, 3.22234929e-02f, 3.34253558e-03f, 2.79382300e-02f, 9.23484489e-02f, 2.00565234e-01f,
  2.09745407e-01f, 2.95291729e-02f, 3.63643095e-02f, 8.29532370e-03f, 1.70066655e-02f, -1.32656971e-03f, -1.10171633e-02f, -2.93213502e-02f, -4.73249927e-02f, 8.19286108e-02f,
  -1.50884781e-02f, 5.87365814e-02f, 5.63786402e-02f, -8.90388116e-02f, -5.82048707e-02f, -4.77382131e-02f, 2.95474045e-02f, -5.56978732e-02f, -5.18656038e-02f, -3.14237140e-02f,
  7.46259168e-02f, -1.59593504e-02f, 4.43829261e-02f, -2.07563899e-02f, -2.74862386e-02f, -4.90824357e-02f, 5.33442982e-02f, -3.66525352e-02f, -3.62650789e-02f, 9.96610615e-03f,
  -1.87941622e-02f, -2.54668947e-02f, 2.22159605e-02f, -3.93699668e-02f, -9.28279106e-03f, 3.39950025e-02f, -8.07593390e-02f, -2.61331741e-02f, -1.34168370e-02f, 5.23834303e-02f,
  2.51260214e-02f, -4.69603427e-02f, 2.13591661e-02f, -7.05802366e-02f, -8.03504139e-02f, -2.48071384e-02f, 9.37708765e-02f, -2.91772187e-02f, -1.36225848e-02f, 1.01859150e-02f,
  5.36733083e-02f, -2.83599156e-03f, 6.10554367e-02f, 5.02297170e-02f, -6.46492764e-02f, 2.02173796e-02f, -3.19865644e-02f, 2.01106481e-02f, 2.02361010e-02f, 2.59022936e-02f,
  2.33994462e-02f, -1.47434771e-01f, 1.12778276e-01f, 9.92117822e-02f, -5.39804585e-02f, 1.10702336e-01f, -2.99144592e-02f, -2.31359173e-02f, 9.98677611e-02f, -3.70978452e-02f,
  8.87478143e-02f, 5.95055819e-02f, 1.12878028e-02f, 5.10248840e-02f, -7.21483082e-02f, 6.69884086e-02f, -9.85532328e-02f, -3.42353396e-02f, 1.57961342e-02f, 9.17981416e-02f,
  -2.72644833e-02f, 3.76935024e-03f, -9.31219831e-02f, 3.91921848e-02f, -8.32236186e-02f, 2.24126466e-02f, 2.89386325e-02f, -1.93923004e-02f, -5.77277727e-02f, 1.76367648e-02f,
  1.36812076e-01f, -3.56654301e-02f, 9.41876173e-02f, 2.69558094e-02f, 7.82697499e-02f, 1.26545891e-01f, -3.15090381e-02f, -2.66652592e-02f, 2.48474069e-02f, -3.04139648e-02f,
  -2.02370025e-02f, -8.15732628e-02f, -1.30211711e-01f, -3.79055627e-02f, 4.38540950e-02f, 2.98672616e-02f, -2.06607226e-02f, 6.76737875e-02f, -5.62315509e-02f, 2.48895586e-02f,
  1.68351084e-02f, 4.95254435e-02f, -2.20285170e-02f, 8.54007080e-02f, 5.23990132e-02f, -9.21035558e-02f, -5.95530197e-02f, 7.68001825e-02f, 1.93567052e-02f, -5.28763719e-02f,
  -1.07346967e-01f, 2.44661458e-02f, -7.00572282e-02f, 2.95721032e-02f, -3.96600850e-02f, -3.63100134e-02f, 5.67273535e-02f, -5.24901971e-02f, -4.46749330e-02f, -1.87361035e-02f,
  6.49714395e-02f, -2.46386044e-03f, -5.79913780e-02f, -2.90296953e-02f, 2.94540506e-02f, 1.63773131e-02f, 7.48651922e-02f, 7.45035112e-02f, 3.49658951e-02f, 3.13348547e-02f,
  -1.13830999e-01f, 1.16464507e-03f, 5.02749868e-02f, 5.35405129e-02f, 2.31875721e-02f, -4.07914771e-03f, 5.80470869e-03f, -2.28007566e-02f, -1.84921436e-02f, 8.27752426e-02f,
  -1.77862477e-02f, -7.65899941e-02f, -8.54701102e-02f, -3.50957960e-02f, -6.78384155e-02f, 4.63599078e-02f, 3.41038369e-02f, 5.88244125e-02f, 4.88813370e-02f, -2.31874138e-02f,
  8.91078711e-02f, -2.87652127e-02f, 3.46691422e-02f, -1.96631085e-02f, 5.21436147e-03f, -7.16376537e-03f, -2.87258364e-02f, -1.08414823e-02f, -1.19700868e-04f, 9.89074912e-03f,
  3.96646149e-02f, -1.02095334e-02f, -6.94825593e-03f, 4.97503346e-03f, -3.28220017e-02f, 1.04211271e-01f, 1.09252438e-01f, 5.55059873e-02f, 6.01191744e-02f, 7.02966228e-02f,
  -2.32037902e-02f, -4.40604985e-02f, 3.68672460e-02f, 3.38701904e-02f, 7.97314420e-02f, -2.69810688e-02f, -4.86547239e-02f, 1.94261111e-02f, -4.78969775e-02f, -3.18623818e-02f,
  4.01475094e-02f, 2.45799217e-02f, -7.66009325e-03f, 3.84020386e-03f, 3.35695334e-02f, 7.92499334e-02f, -3.22738960e-02f, 3.04953884e-02f, -3.99863720e-02f, -3.45351249e-02f,
  -1.58102773e-02f, 9.04380009e-02f, 3.27354036e-02f, -2.96037719e-02f, -6.96735829e-02f, -2.99915522e-02f, -4.32576574e-02f, -6.95902854e-02f, 7.91611895e-03f, 5.12476228e-02f,
  -4.49504405e-02f, -1.87403150e-02f, -2.11188290e-02f, 9.49881896e-02f, 4.98947091e-02f, -1.31174689e-02f, -1.91386133e-01f, -1.03797182e-01f, -3.91320735e-02f, -4.36880291e-02f,
  8.31093043e-02f, 1.64791383e-02f, -1.07582867e-01f, -1.35714859e-01f, -2.22204074e-01f, -2.16628924e-01f, -2.00377911e-01f, -1.38367638e-01f, -1.19907238e-01f, 1.74468663e-02f,
  5.68753295e-02f, 1.07892349e-01f, -4.64829914e-02f, -1.76741986e-03f, -2.52700737e-03f, 5.83448485e-02f, -9.49191302e-02f, -8.52543265e-02f, 1.82873569e-02f, 2.81454492e-02f,
  6.86230836e-03f, 1.97690818e-02f, 3.08763441e-02f, 5.34889437e-02f, 9.60954279e-02f, -2.33765207e-02f, 2.42902078e-02f, 2.82191113e-03f, -1.39110219e-02f, -1.71597172e-02f,
  3.71351019e-02f, -3.77191529e-02f, -4.89104874e-02f, -8.73401687e-02f, -9.54211652e-02f, -3.62076499e-02f, 4.13454697e-02f, -6.09060703e-03f, -5.86906374e-02f, -2.70595551e-02f,
  7.95917362e-02f, -1.67337141e-03f, -3.22323591e-02f, -1.24565892e-01f, -1.12201653e-01f, -8.82352293e-02f, -5.44890910e-02f, -1.01367004e-01f, -4.90746051e-02f, -5.68915270e-02f,
  -2.58363541e-02f, -7.71854594e-02f, 3.58097926e-02f, 1.87583994e-02f, 7.20745102e-02f, -8.00850391e-02f, -5.03550656e-02f, -6.26446754e-02f, 6.20085299e-02f, -8.18537772e-02f,
  7.84843341e-02f, 6.13864288e-02f, 4.29744041e-03f, -6.63489476e-02f, 1.68367997e-02f, -7.30175078e-02f, -8.71807635e-02f, -1.68358982e-02f, 7.92724732e-03f, -4.04101647e-02f,
  -4.90074009e-02f, -8.42666719e-03f, 1.51793538e-02f, -7.10273311e-02f, -5.19639254e-02f, -1.01115368e-01f, -2.48544123e-02f, -5.66103160e-02f, 5.22779375e-02f, -6.20240010e-02f,
  -1.36573855e-02f, -1.49516925e-01f, -6.31075427e-02f, -9.99338925e-02f, -6.49970770e-03f, -1.90957842e-04f, 1.00913912e-01f, -3.56669649e-02f, -7.53016621e-02f, -4.08912972e-02f,
  9.75678675e-03f, -1.50436698e-03f, 4.20639385e-03f, 1.60658713e-02f, 8.25396553e-02f, -6.16083369e-02f, -5.81234768e-02f, 4.61702198e-02f, -9.53247994e-02f, 2.96868607e-02f,
  -1.73913985e-02f, -5.89056313e-02f, -1.26654550e-01f, -4.62722480e-02f, 2.24308949e-02f, -1.05115958e-01f, -6.81605488e-02f, 4.72549461e-02f, -9.62147340e-02f, -1.01517521e-01f,
  -3.52407247e-02f, -3.25884856e-02f, 1.56062707e-01f, -1.75143331e-02f, 5.51273525e-02f, 1.28165200e-01f, -6.70066476e-02f, -5.60287088e-02f, 2.45000445e-03f, 2.73908358e-02f,
  2.24863030e-02f, -6.04991913e-02f, -1.64322946e-02f, 3.87249403e-02f, -4.90047559e-02f, 8.98699611e-02f, -4.96315211e-03f, 4.30688858e-02f, 2.11395952e-03f, -5.10643646e-02f,
  -8.27306062e-02f, -5.23031540e-02f, 5.68681723e-03f, -5.00099473e-02f, -8.67011324e-02f, -1.48292081e-02f, -6.68685213e-02f, -4.98587713e-02f, -2.42505148e-02f, 1.86395403e-02f,
  1.58178434e-01f, -2.57540159e-02f, -1.02963366e-01f, -4.69055735e-02f, 2.56804023e-02f, 2.98516750e-02f, -3.94682623e-02f, -8.93115029e-02f, -4.12895866e-02f, -5.17589562e-02f,
  5.66030368e-02f, -1.38685508e-02f, 8.24457780e-02f, -2.77288035e-02f, -5.45623340e-02f, -8.22237227e-03f, 2.60931067e-02f, -6.13080747e-02f, -1.57112870e-02f, 3.80391814e-02f,
  -5.76348044e-02f, 1.76975206e-02f, 1.14250951e-01f, 4.28995900e-02f, 9.15370956e-02f, 1.82486605e-02f, 4.16938365e-02f, 4.04459760e-02f, 1.51701691e-02f, -2.95019113e-02f,
  6.79586409e-03f, -6.70505911e-02f, -9.03980508e-02f, -8.03854838e-02f, 2.56504584e-02f, 4.59354036e-02f, -8.53090212e-02f, -4.77132201e-03f, -6.88313367e-03f, 6.00760803e-02f,
  4.56344076e-02f, 3.51596475e-02f, 5.72226420e-02f, -8.54999498e-02f, -2.49817800e-02f, 2.82627195e-02f, 4.49066795e-02f, -9.42795202e-02f, -5.31290732e-02f, -9.14623514e-02f,
  -5.83890006e-02f, -7.28376359e-02f, 3.32410596e-02f, 6.46175817e-02f, -7.04175830e-02f, 4.19402160e-02f, 6.07373519e-03f, 4.66339439e-02f, -9.52786431e-02f, 6.78412020e-02f,
  -8.28191265e-02f, -3.70121039e-02f, -1.54369408e-02f, -9.91552249e-02f, 5.25838137e-02f, 5.57194613e-02f, 7.39381388e-02f, -2.62546241e-02f, -6.41912743e-02f, -6.20012991e-02f,
  -6.45430461e-02f, 5.18334769e-02f, 5.95079176e-02f, 3.75313535e-02f, -3.27396281e-02f, -3.51746492e-02f, 6.59731105e-02f, -1.12524405e-02f, -6.80491701e-02f, -6.05627261e-02f,
  -2.12678257e-02f, 1.44724986e-02f, 1.93655621e-02f, 6.76397793e-03f, -8.21364596e-02f, 2.94099078e-02f, 3.72682214e-02f, 7.16732070e-02f, -7.48168910e-03f, -1.04117291e-02f,
  -1.36727479e-03f, 2.28673350e-02f, -3.08363676e-01f, -1.84337124e-01f, -7.32306987e-02f, 7.65187219e-02f, 1.02611706e-01f, 3.46206352e-02f, -2.06081159e-02f, -3.91233712e-02f,
  -2.34641880e-02f, -4.74155648e-04f, -6.65665045e-02f, -6.54643262e-03f, -1.15024954e-01f, -2.07238756e-02f, -2.12080494e-01f, -2.10212171e-01f, -8.24231207e-02f, 3.20460275e-02f,
  -2.41578463e-02f, -9.98526663e-02f, -6.82707727e-02f, 1.50003424e-02f, -1.28586903e-01f, -1.42066181e-02f, -2.38353267e-01f, -1.43039972e-01f, -5.81033118e-02f, -8.34421217e-02f,
  -4.35880423e-02f, -1.44091383e-01f, 5.14797345e-02f, 3.09510529e-03f, -3.96800265e-02f, -5.41743264e-02f, -6.01729490e-02f, -5.33495694e-02f, -3.14479284e-02f, -5.69375120e-02f,
  -5.91809116e-02f, 2.52709035e-02f, -5.70432693e-02f, -3.79795581e-02f, -5.98759986e-02f, 2.64052786e-02f, 3.70504446e-02f, -1.40923798e-01f, -6.85117021e-02f, 8.86722729e-02f,
  2.03794967e-02f, 4.07037121e-04f, -1.92401625e-04f, -1.46362130e-02f, -1.74050517e-02f, 2.36468390e-02f, -8.14738870e-02f, -6.17063940e-02f, 1.71343249e-03f, 6.25444502e-02f,
  4.10662517e-02f, 5.49860224e-02f, -7.12345466e-02f, 5.37492260e-02f, 7.01018348e-02f, -1.24798425e-01f, 1.72903645e-03f, -4.68148813e-02f, 2.44410057e-02f, 5.34185320e-02f,
  -2.81785633e-02f, 4.49187532e-02f, 3.51675227e-02f, -2.48606820e-02f, -1.40357455e-02f, -6.48335973e-03f, 7.91038126e-02f, -2.96932161e-02f, 5.04949763e-02f, -1.56908557e-02f,
  7.34373555e-02f, -2.74776053e-02f, 2.57784985e-02f, 6.86166063e-02f, -6.49824068e-02f, 5.01463711e-02f, 3.34374346e-02f, 7.27886036e-02f, -2.60303244e-02f, 5.69456033e-02f,
  5.32655492e-02f, -7.76390657e-02f, 2.37840284e-02f, 2.44682916e-02f, -1.98897533e-02f, 7.82769248e-02f, -2.09293421e-02f, -9.46057141e-02f, -2.06297394e-02f, -1.86752547e-02f,
  7.71795660e-02f, -2.50961166e-02f, -9.71826464e-02f, -4.93652932e-02f, 9.99710057e-03f, 5.22675924e-03f, 1.35130314e-02f, -8.12828913e-02f, -7.47022405e-02f, -1.14026759e-02f,
  2.98611969e-02f, 1.01278767e-01f, 3.59105691e-02f, 2.47291103e-02f, -4.68401574e-02f, -3.11174598e-02f, 4.81473505e-02f, 3.64169478e-02f, 9.23839770e-03f, 5.44215962e-02f,
  6.18004724e-02f, -1.20384768e-01f, 3.92281935e-02f, -4.71489169e-02f, 8.45184624e-02f, -2.78194691e-03f, -5.23594245e-02f, -1.15745716e-01f, -3.98134440e-02f, -6.15174584e-02f,
  -7.75547291e-04f, -3.02376766e-02f, -4.63462668e-03f, -1.53377876e-02f, -1.07308045e-01f, 5.89450113e-02f, 1.67410597e-02f, 2.24027615e-02f, 1.13992535e-01f, 8.34004059e-02f,
  -3.31754982e-03f, 1.12785056e-01f, 4.78952788e-02f, -5.88484295e-02f, 7.28486702e-02f, 1.06642783e-01f, -4.53979895e-02f, 6.73565865e-02f, 4.07487452e-02f, 4.17159908e-02f,
  1.56259999e-01f, -1.14868298e-01f, -1.83147620e-02f, 3.77475657e-02f, 3.68049257e-02f, -2.04790495e-02f, -4.86707352e-02f, -1.00366548e-01f, -1.24775231e-01f, 5.75200766e-02f,
  3.10179330e-02f, -9.46145281e-02f, -4.27224413e-02f, -5.80135770e-02f, -5.92360795e-02f, 5.41962590e-03f, 3.15992981e-02f, 4.33840342e-02f, -1.27513051e-01f, -5.31833991e-02f,
  1.83266085e-02f, -5.65189607e-02f, -3.56445648e-02f, -1.01302929e-01f, -1.04639744e-02f, 2.87384577e-02f, 5.33797219e-02f, 7.49658933e-03f, 3.08389701e-02f, -2.32020509e-03f,
  4.02167812e-03f, -1.09660327e-02f, 9.66019277e-03f, 6.78473264e-02f, -1.00096434e-01f, -2.63317265e-02f, 1.08290829e-01f, 5.06252460e-02f, 2.30421014e-02f, -5.99665716e-02f,
  -2.90350057e-02f, 3.15861553e-02f, 5.42535074e-03f, -5.62033663e-03f, -8.08420125e-03f, -6.28493354e-02f, 4.22873981e-02f, -4.40394878e-02f, 1.48317879e-02f, -6.41223462e-03f,
  -8.09783190e-02f, -8.29702765e-02f, 8.20072293e-02f, -3.75876948e-02f, -1.15432933e-01f, 6.20712712e-02f, -5.93827255e-02f, -8.88272226e-02f, -7.28023201e-02f, -7.69434869e-02f,
  7.55345002e-02f, -8.95394087e-02f, 3.81176680e-04f, -1.08444460e-01f, -1.02667836e-02f, -9.45930630e-02f, 7.76964892e-03f, 7.26367086e-02f, -4.22708727e-02f, -3.42754275e-02f,
  -4.71568033e-02f, 3.75820994e-02f, -6.71663955e-02f, 1.96276531e-02f, 1.61194727e-01f, 1.19011715e-01f, 5.93078614e-04f, 1.52062587e-02f, 1.59872332e-04f, -7.96373636e-02f,
  -1.06841475e-02f, 9.72482190e-02f, 7.64627829e-02f, 8.78685489e-02f, 1.87921152e-02f, 8.68980214e-03f, 8.97581503e-02f, 8.42097998e-02f, -2.67828093e-03f, 1.94298308e-02f,
  -2.06421614e-01f, -8.61309692e-02f, 2.27261558e-01f, -2.15232715e-01f, -5.18423766e-02f, -8.94940570e-02f, 2.75663584e-02f, -5.84005453e-02f, -1.03297286e-01f, 2.42142901e-02f,
  -5.29636331e-02f, -1.13412634e-01f, -3.10102962e-02f, 6.60274550e-02f, 1.36574637e-03f, 6.88161030e-02f, 4.28596698e-02f, 6.59288615e-02f, 3.97147611e-02f, -1.12909423e-02f,
  6.52735471e-04f, -1.94478497e-01f, -1.35280237e-01f, -1.06288254e-01f, -1.70300514e-01f, -1.11441344e-01f, 3.69396876e-03f, -2.01074798e-02f, -3.41664478e-02f, -2.81146560e-02f,
  -3.93811241e-02f, -7.39227310e-02f, -1.34304203e-02f, -6.17024228e-02f, 8.84341262e-03f, -7.21053556e-02f, 5.76489046e-02f, -3.84767875e-02f, 1.93151906e-02f, -8.88835415e-02f,
  -8.91368315e-02f, -5.72097711e-02f, -6.41365424e-02f, -7.52611458e-02f, -3.84476408e-02f, 4.67054844e-02f, 1.02120750e-01f, 8.22472721e-02f, 6.39616102e-02f, 8.95513818e-02f,
  5.54839782e-02f, -1.22395165e-01f, -3.48712057e-02f, 4.92945276e-02f, 6.18753396e-03f, 5.70776723e-02f, 4.44563513e-04f, 3.11204866e-02f, -3.85750793e-02f, -9.95970517e-02f,
  -5.03285937e-02f, 4.26529348e-02f, 6.20198101e-02f, 6.41498715e-02f, -5.77518791e-02f, -3.06797642e-02f, 3.16337496e-02f, 3.18660075e-03f, -1.71258673e-02f, -8.36412329e-03f,
  -1.13348057e-02f, 6.98140487e-02f, -7.85595775e-02f, -2.71541439e-03f, 9.36552137e-02f, -1.43837417e-02f, 9.49745774e-02f, -4.95008603e-02f, -1.90561190e-02f, 9.15042758e-02f,
  -5.10663772e-03f, -4.27497998e-02f, -7.04445934e-04f, 1.70724932e-02f, -4.00084183e-02f, 9.20923725e-02f, -7.42562786e-02f, -5.08514196e-02f, 6.58936650e-02f, -4.98957522e-02f,
  -1.48659080e-01f, 2.64643282e-01f, -4.48043384e-02f, -7.04670176e-02f, -6.18340708e-02f, -6.54876083e-02f, -1.44430308e-03f, -3.12186722e-02f, 7.29013532e-02f, -1.12003475e-01f,
  -6.02922998e-02f, -1.10195272e-01f, -9.89377871e-02f, -7.26257116e-02f, -9.64854360e-02f, -1.27594441e-01f, 1.74824949e-02f, -9.16494876e-02f, 8.52685980e-03f, -5.69052882e-02f,
  1.02668367e-02f, -1.25599712e-01f, -9.64965597e-02f, 2.16215793e-02f, -3.79977673e-02f, -7.62782842e-02f, -1.18483029e-01f, -7.84171894e-02f, -5.73215671e-02f, -1.06573917e-01f,
  2.93507487e-01f, -1.03915550e-01f, -3.32936615e-01f, 1.30219698e-01f, -1.42021999e-01f, -6.56490251e-02f, -1.75078064e-01f, -9.58975405e-02f, 9.22416598e-02f, -3.77589650e-02f,
  -2.86147855e-02f, 1.17941588e-01f, -4.31240462e-02f, -1.35717273e-01f, -1.21596880e-01f, -2.61776030e-01f, -2.40510821e-01f, -1.44907624e-01f, -1.09397799e-01f, -1.60401799e-02f,
  3.89520414e-02f, -7.94859529e-02f, 3.40078585e-03f, -1.97510049e-02f, -1.04738094e-01f, -8.13046694e-02f, -1.44210011e-01f, -1.36135474e-01f, -1.86930567e-01f, -1.80753216e-01f,
  -2.33030975e-01f, -3.98543179e-02f, -7.40448758e-02f, 1.90437511e-02f, -1.39274985e-01f, 5.43519333e-02f, -6.47269338e-02f, 9.26430151e-03f, -2.32210457e-02f, -1.14325210e-01f,
  -3.36657348e-03f, -6.17997013e-02f, 2.45753508e-02f, 3.17097642e-02f, -8.36523920e-02f, 6.80688918e-02f, -8.99347737e-02f, -1.23290688e-01f, -7.66772311e-03f, -3.56034786e-02f,
  -3.91824692e-02f, -3.30821276e-02f, 6.22579865e-02f, -1.07716903e-01f, -9.45977271e-02f, 3.75306681e-02f, -1.26802444e-01f, 1.34090660e-02f, -1.08807623e-01f, 1.68311596e-02f,
  -7.36359879e-02f, -4.73545752e-02f, 3.88731025e-02f, -8.72935262e-03f, 7.86748528e-02f, 2.87764687e-02f, -4.21916470e-02f, -1.16440104e-02f, 3.84440534e-02f, -7.33360201e-02f,
  -5.11128977e-02f, -1.41858403e-02f, -8.14315006e-02f, 7.18067959e-02f, -2.80700754e-02f, -6.89754784e-02f, -8.99671614e-02f, -3.39069702e-02f, 2.42007128e-03f, 2.75410675e-02f,
  3.85997221e-02f, -6.29267767e-02f, 4.77360226e-02f, -7.07869679e-02f, -1.07430682e-01f, -7.32885897e-02f, -7.58208185e-02f, 5.88767231e-02f, 7.86061883e-02f, 4.32277098e-02f,
  8.03514123e-02f, -1.39314635e-02f, -2.14056037e-02f, 4.62227128e-02f, -7.71914050e-02f, -3.01239993e-02f, 8.97556767e-02f, -1.08656734e-02f, 8.12066644e-02f, -8.00561309e-02f,
  -9.47575346e-02f, -6.06981516e-02f, -4.86346558e-02f, -2.55046207e-02f, -4.92756888e-02f, 3.70293818e-02f, -3.17167118e-02f, 5.52462116e-02f, 2.78486889e-02f, 5.54288970e-03f,
  -5.86965941e-02f, -6.72916621e-02f, 1.12693839e-01f, -1.64071023e-02f, 1.36152431e-02f, 1.10166147e-01f, -1.16660051e-01f, 3.92821431e-02f, -6.58824220e-02f, 4.23430540e-02f,
  4.50853407e-01f, 2.90868759e-01f, 2.65503913e-01f, 9.15939510e-02f, -1.87329680e-01f, -5.13934717e-02f, 7.01629221e-02f, -6.39839321e-02f, -8.23586956e-02f, 2.07159836e-02f,
  -2.13003885e-02f, -1.74061120e-01f, -3.93410623e-02f, -4.88647111e-02f, 2.69436035e-02f, 9.59676355e-02f, -5.26734106e-02f, 1.25206336e-01f, 9.27453414e-02f, -3.44445594e-02f,
  -7.54074231e-02f, 1.36770099e-01f, 2.37801820e-01f, 3.62955071e-02f, 7.81201273e-02f, -7.38775581e-02f, 9.90595520e-02f, 1.58718914e-01f, 2.67540328e-02f, 1.59524739e-01f,
  2.30501711e-01f, 3.30741853e-01f, -1.65212616e-01f, -2.86745932e-02f, 2.00022887e-02f, -4.14555259e-02f, 6.95021376e-02f, -1.28122894e-02f, -4.85688038e-02f, -1.24640483e-02f,
  -4.02750820e-02f, 4.31796573e-02f, -9.77904499e-02f, -1.59772392e-02f, 7.75725916e-02f, 6.35233298e-02f, 8.69040191e-02f, 2.75896564e-02f, -8.36081430e-03f, 1.33087598e-02f,
  -3.07293423e-02f, -4.87763137e-02f, 4.61964607e-02f, -6.93412274e-02f, 8.59092250e-02f, 2.72610858e-02f, -3.02980989e-02f, 5.97478338e-02f, -2.17003301e-02f, 3.78361307e-02f,
  -5.77063560e-02f, 5.36708944e-02f, -3.48170996e-02f, 1.54777048e-02f, -8.36812332e-03f, -7.86772668e-02f, -5.63280545e-02f, -2.08070651e-02f, -6.21416047e-02f, 9.12526809e-03f,
  -8.14846754e-02f, 2.66223084e-02f, 4.58770841e-02f, 4.79295887e-02f, -1.37902815e-02f, 6.00312240e-02f, 2.03292575e-02f, -1.09978335e-03f, -7.05852211e-02f, -9.20330733e-02f,
  4.64741215e-02f, 1.32129202e-02f, 4.90522087e-02f, -9.01501393e-04f, 2.13989373e-02f, 3.92435826e-02f, -9.43162069e-02f, -8.12702626e-02f, 4.61071730e-02f, -3.16120386e-02f,
  -2.52850860e-01f, -1.44394696e-01f, -4.90698628e-02f, -5.85462488e-02f, 1.83322411e-02f, 2.90083047e-02f, 3.30689475e-02f, -7.71999881e-02f, -2.50842459e-02f, 7.63763487e-02f,
  1.38251726e-02f, -1.12074288e-02f, 6.63770959e-02f, -4.81345393e-02f, -1.14116743e-01f, -1.49719864e-02f, -5.12169003e-02f, -6.29296526e-02f, -1.05979228e-02f, 1.05756901e-01f,
  -1.15732722e-01f, -1.02037765e-01f, -6.29381314e-02f, -5.83885387e-02f, -5.77115603e-02f, -1.62769079e-01f, -2.54859533e-02f, -6.73355982e-02f, -1.60057619e-01f, -1.00344017e-01f,
  1.51180163e-01f, 7.76779279e-02f, -3.16062681e-02f, 6.56241179e-02f, -1.60162687e-01f, -1.06514014e-01f, -7.06836060e-02f, 6.73738793e-02f, 7.36202225e-02f, -2.46684104e-02f,
  -1.55068502e-01f, -2.63856594e-02f, 5.94270937e-02f, 1.31780013e-01f, 6.33999035e-02f, 3.03132255e-02f, 2.52763405e-02f, 7.23818019e-02f, 1.14851177e-01f, 7.05941468e-02f,
  6.12690747e-02f, 8.64183903e-02f, 7.93512091e-02f, 1.13568880e-01f, 1.97511427e-02f, 1.09232947e-01f, 1.24413498e-01f, 5.27640898e-03f, 8.61108303e-02f, 1.07045434e-01f,
  -1.58453763e-01f, -8.61752331e-02f, 3.56584303e-02f, 4.15844843e-02f, 2.47940645e-02f, -1.09570567e-02f, 7.26198182e-02f, -9.48045775e-03f, -2.49004271e-02f, 1.35038048e-01f,
  -3.79994176e-02f, -5.07513322e-02f, 6.86865374e-02f, -3.74420956e-02f, 1.74501780e-02f, -3.93565670e-02f, 8.28205422e-02f, 1.79625347e-01f, 1.06840651e-03f, 3.96839604e-02f,
  -3.66968848e-02f, -8.38322043e-02f, -1.02999985e-01f, -6.96274340e-02f, 6.98830467e-03f, -2.59780884e-02f, 2.88070384e-02f, -4.90016378e-02f, 8.72659683e-02f, 1.61066666e-01f,
  1.43920183e-02f, -3.46884690e-02f, -1.03638452e-02f, -3.23242918e-02f, 2.21934114e-02f, -5.97727150e-02f, -7.01291189e-02f, -7.59210661e-02f, -2.67429743e-02f, -1.89718623e-02f,
  -7.50103891e-02f, -5.99594228e-03f, -2.79408358e-02f, 6.93491921e-02f, -3.10347360e-02f, -8.12825412e-02f, 4.54392359e-02f, -5.55512682e-02f, -1.08731156e-02f, 1.01648998e-02f,
  -7.96206221e-02f, -5.93734980e-02f, 7.85037205e-02f, 2.17566099e-02f, -6.12857426e-03f, 8.77314135e-02f, 7.05882534e-02f, -5.02525270e-02f, -2.30959076e-02f, -1.10476464e-01f,
  7.29918107e-02f, -6.06486015e-02f, 6.10366203e-02f, 7.12649003e-02f, 2.89970953e-02f, -7.25052273e-03f, -7.65293688e-02f, 2.80163949e-03f, 5.50151840e-02f, -3.38938572e-02f,
  2.51261834e-02f, 9.98844281e-02f, -8.78754929e-02f, -8.03108662e-02f, 7.32784048e-02f, 2.23301090e-02f, -1.00087409e-03f, 9.22415629e-02f, -2.36447826e-02f, -6.86073210e-03f,
  1.90508384e-02f, 6.41297698e-02f, -2.08358243e-02f, 4.60234098e-03f, -2.33597122e-02f, -4.70115198e-03f, -8.03646892e-02f, 5.42908497e-02f, 1.12744728e-02f, -9.80200619e-03f,
  -3.96612465e-01f, -5.93380406e-02f, 1.69683620e-01f, 1.46983052e-02f, 4.69105840e-02f, 8.00807104e-02f, -6.61437884e-02f, 7.74650052e-02f, -1.29407287e-01f, 7.69982697e-04f,
  -7.19535872e-02f, 9.71859246e-02f, 1.95836145e-02f, -3.39526646e-02f, -5.01595326e-02f, 9.23888162e-02f, 3.98109201e-03f, -2.79988796e-02f, 7.38629475e-02f, -7.24689662e-02f,
  -2.80171204e-02f, -6.54027984e-02f, 2.24405788e-02f, 2.93043116e-03f, 8.29498991e-02f, 2.28164271e-02f, 1.05736107e-01f, -8.94402619e-03f, -6.68156371e-02f, 4.90857363e-02f,
  2.26358607e-01f, -1.53515562e-01f, 8.52105767e-02f, -9.28137973e-02f, -3.34658436e-02f, -5.73648997e-02f, 2.36335211e-02f, -6.72526732e-02f, -2.99819279e-02f, 7.57291168e-02f,
  1.17508881e-02f, -5.04044630e-02f, 2.80944556e-02f, -8.09755735e-03f, 1.01166159e-01f, -5.14791310e-02f, -7.06246030e-03f, 4.84096594e-02f, 6.70275688e-02f, 6.10976852e-02f,
  4.63406630e-02f, -8.70278664e-03f, 1.04563802e-01f, 3.28996740e-02f, -2.47170348e-02f, 6.08257391e-02f, 1.26472116e-01f, 1.32669210e-02f, 4.45113331e-02f, 6.84124604e-02f,
  1.67517960e-02f, 8.26544017e-02f, 5.00589889e-03f, 3.61643136e-02f, -6.34056702e-02f, -1.37702096e-03f, 1.79721527e-02f, 7.14476332e-02f, -1.80176608e-02f, 2.15392020e-02f,
  1.72121413e-02f, -5.08675724e-02f, 1.91228017e-02f, -8.85727629e-02f, 3.68288718e-02f, -8.37637261e-02f, -7.09576905e-02f, -2.22977921e-02f, 5.58672585e-02f, -7.53226653e-02f,
  6.42483160e-02f, 1.13850227e-02f, -4.42271307e-02f, 1.76752228e-02f, -4.15912010e-02f, 7.00838566e-02f, -4.23454978e-02f, 8.71381685e-02f, 8.60188901e-03f, -5.69054633e-02f,
  1.62448823e-01f, 1.93404201e-02f, 6.97281435e-02f, -5.59083605e-03f, 2.87223551e-02f, 5.56896441e-02f, -2.68440656e-02f, 3.98635343e-02f, 5.85421920e-02f, -5.80375604e-02f,
  -1.40182599e-02f, 6.25697300e-02f, -6.17199242e-02f, 4.16000523e-02f, -2.39428561e-02f, -2.82626022e-02f, -8.50978941e-02f, 1.11085571e-01f, 7.26914499e-03f, 7.82930553e-02f,
  1.77510735e-02f, -3.71068865e-02f, -4.93870303e-02f, 1.22528926e-01f, 3.74917574e-02f, -3.55561897e-02f, 3.07890493e-02f, -5.64702824e-02f, -4.50352170e-02f, -7.02839941e-02f,
  -2.45871395e-03f, -9.25325081e-02f, -1.37327388e-02f, 4.85188030e-02f, 5.26790731e-02f, -8.75009503e-03f, 6.83115274e-02f, 5.16899563e-02f, 9.81141254e-03f, -4.59716953e-02f,
  -1.03688426e-01f, -1.78571958e-02f, -8.83756205e-02f, -1.32805645e-01f, 2.71541206e-03f, -5.83112612e-02f, 4.33170609e-02f, 4.21153754e-02f, 3.98498811e-02f, 6.66935593e-02f,
  -4.40957397e-02f, -5.62866479e-02f, 2.83399560e-02f, -7.74443597e-02f, -5.00837639e-02f, 9.87795764e-04f, 9.11703426e-03f, -3.46009620e-02f, -7.38757476e-02f, -1.25427574e-01f,
  -1.10065609e-01f, 1.01428507e-02f, 6.07874505e-02f, -1.19818002e-02f, -5.38684651e-02f, -5.27882129e-02f, -7.89708123e-02f, 1.09839812e-01f, -1.75332520e-02f, 4.48529609e-02f,
  7.99877644e-02f, -6.57097176e-02f, -3.06840278e-02f, -3.69673898e-03f, 9.80748832e-02f, 9.90395918e-02f, 7.27161840e-02f, 6.12234548e-02f, -1.88862775e-02f, 2.07231869e-03f,
  -4.95217629e-02f, 2.44341735e-02f, -1.80311371e-02f, -3.99090312e-02f, 1.00392260e-01f, -7.80441687e-02f, -1.73050351e-02f, 4.88726534e-02f, 3.72668207e-02f, 1.00457832e-01f,
  -6.73008412e-02f, 1.04601271e-01f, 4.55646291e-02f, 6.27936274e-02f, 6.84700673e-04f, 5.20952418e-02f, 1.29826665e-02f, 3.32230777e-02f, 1.27863800e-02f, -2.93853972e-02f,
  -3.23168151e-02f, 3.36621366e-02f, 1.94195490e-02f, -3.33943740e-02f, 4.40257899e-02f, -8.75005871e-02f, -4.02254649e-02f, 2.97553204e-02f, 7.18757361e-02f, -8.49488452e-02f,
  -1.03605375e-01f, 1.87456748e-03f, 6.96557388e-02f, 7.00341817e-03f, -3.95186022e-02f, -3.75016071e-02f, -5.54967746e-02f, 5.47515973e-02f, -5.91127723e-02f, -9.42967385e-02f,
  -1.02543414e-01f, -1.32620439e-01f, -7.13649467e-02f, 8.85894895e-02f, 4.15867642e-02f, -4.60459143e-02f, 3.27367932e-02f, 7.90590197e-02f, 5.54122031e-02f, 1.10120550e-02f,
  3.13876905e-02f, -4.41868864e-02f, -8.80940259e-02f, -7.18062138e-03f, -8.23308714e-03f, 4.42801742e-03f, -4.15238477e-02f, 6.21654801e-02f, -3.32907289e-02f, -2.42071189e-02f,
  5.69189638e-02f, 3.11590475e-03f, -1.96507294e-02f, -6.94427872e-03f, 7.91877508e-02f, -9.81734395e-02f, -1.71601810e-02f, -1.81792751e-02f, 3.49059589e-02f, -2.67868396e-02f,
  1.73052117e-01f, -1.33123919e-01f, -2.01438162e-02f, 9.12206024e-02f, 3.84066701e-02f, 1.34975195e-01f, 3.15752141e-02f, 4.11749668e-02f, 4.71559316e-02f, 8.55340958e-02f,
  1.88394770e-01f, 2.60643184e-01f, 1.81892097e-01f, 1.09631881e-01f, 6.16283230e-02f, 5.70313148e-02f, -5.71026914e-02f, 8.98718759e-02f, 9.56804156e-02f, 3.29634957e-02f,
  1.51505813e-01f, -6.67559728e-03f, 2.31647603e-02f, 6.80845603e-02f, 2.00580079e-02f, 1.14677981e-01f, -5.33002876e-02f, -7.40784109e-02f, 2.87066698e-02f, -6.61039054e-02f,
  -4.90433872e-02f, 1.66020188e-02f, 1.20053656e-01f, 1.01332255e-01f, -3.84103693e-02f, -3.60823162e-02f, 8.53003003e-03f, -9.38892514e-02f, -5.06055430e-02f, -1.34494618e-01f,
  -5.70661947e-03f, 7.49390107e-03f, -1.13890870e-02f, 2.76151672e-02f, -8.10263976e-02f, 1.52473282e-02f, -1.46130919e-01f, -1.27752647e-01f, 2.45047547e-02f, -9.37851593e-02f,
  2.36139935e-03f, 1.33410711e-02f, -9.63945594e-03f, -9.67110619e-02f, 1.35033792e-02f, 4.04959880e-02f, -6.38998859e-03f, -2.91655064e-02f, 6.75001694e-03f, 4.72678011e-03f,
  8.64880383e-02f, 1.22009002e-01f, 1.30753383e-01f, 6.28928542e-02f, 5.48212901e-02f, -5.63332066e-02f, -3.90983038e-02f, 4.45897765e-02f, 1.04546167e-01f, 5.92393056e-03f,
  2.36610062e-02f, 5.75705729e-02f, 8.36107582e-02f, -4.89949919e-02f, 7.06159174e-02f, -3.36893536e-02f, 5.57422526e-02f, -3.21499668e-02f, 5.70111424e-02f, -2.96048969e-02f,
  4.89116646e-02f, -7.95492381e-02f, 6.21249937e-02f, -7.52859861e-02f, -3.90096568e-02f, 5.27050681e-02f, 7.86016285e-02f, -2.34074797e-02f, -3.86273377e-02f, 2.33805403e-02f,
  1.05991978e-02f, 5.07250056e-02f, 3.80209163e-02f, 3.76683697e-02f, 6.88086450e-02f, -1.19240973e-02f, 6.54281080e-02f, -6.56221062e-02f, -9.09290016e-02f, 1.74761135e-02f,
  -1.70809571e-02f, -6.09147288e-02f, -7.05296397e-02f, -6.30907565e-02f, -5.60880043e-02f, -3.16910744e-02f, 2.39080563e-02f, 1.06358640e-01f, 7.82877579e-02f, 2.49953456e-02f,
  5.58746830e-02f, -5.78365177e-02f, -5.53517928e-03f, 1.14228562e-01f, 1.86307449e-02f, 5.08473068e-02f, -1.70207452e-02f, -5.15789278e-02f, 9.92484912e-02f, -1.30311120e-02f,
  -8.23988691e-02f, -2.73361415e-01f, 2.91266795e-02f, 1.03833266e-02f, 1.76667020e-01f, -1.73950624e-02f, -9.24639925e-02f, 6.35048896e-02f, 3.68600227e-02f, -1.40936542e-02f,
  -5.62348776e-02f, -4.24961559e-02f, 3.11013106e-02f, -4.58360463e-02f, -3.14199999e-02f, 4.54802578e-03f, 1.62410587e-01f, 1.72536448e-01f, 1.23571411e-01f, 2.38322672e-02f,
  1.11444101e-01f, 1.12253606e-01f, 1.36496518e-02f, 6.38212636e-02f, 7.43054450e-02f, 7.89636374e-02f, 1.59212202e-02f, -7.83135593e-02f, -6.85055107e-02f, 1.89334080e-02f,
  -1.20101571e-01f, -4.34220769e-02f, 9.38484967e-02f, -5.46649285e-02f, 3.57537083e-02f, -3.36867496e-02f, -1.14376750e-02f, -4.76987883e-02f, 4.34616357e-02f, -1.02550626e-01f,
  -6.58457652e-02f, -4.04850356e-02f, -2.34601814e-02f, -5.25515750e-02f, 6.92398027e-02f, -1.28746824e-02f, -5.38314767e-02f, 3.78719717e-02f, 4.68922295e-02f, -1.05366282e-01f,
  -7.10303858e-02f, -3.71834897e-02f, -7.09430431e-04f, -4.51856479e-02f, -1.25744447e-01f, 4.77480479e-02f, -1.03790224e-01f, -1.18725121e-01f, -9.66103654e-03f, -4.97630909e-02f,
  5.43824770e-02f, -5.63553050e-02f, -7.90923461e-02f, -4.86653484e-02f, 3.03468797e-02f, 3.08083110e-02f, -4.67615537e-02f, 5.16852997e-02f, -6.96433261e-02f, -4.49937955e-02f,
  8.24031979e-02f, 6.49111718e-02f, 5.28749041e-02f, -2.05706358e-02f, -7.16366917e-02f, 6.96546063e-02f, -8.31603929e-02f, 3.97196878e-03f, 4.99253068e-03f, -5.81930168e-02f,
  -7.11121457e-03f, -4.18634675e-02f, -4.03030701e-02f, -4.39153761e-02f, -6.06224686e-02f, -4.22887877e-02f, 9.63283628e-02f, -5.00092842e-02f, 2.54836828e-02f, -7.06172585e-02f,
  2.71184724e-02f, 1.41881704e-01f, 9.87781286e-02f, -7.78814107e-02f, -6.31391630e-02f, -7.88606033e-02f, 3.65901776e-02f, 2.22122557e-02f, -1.05756950e-02f, -4.31956425e-02f,
  -1.10000424e-01f, -6.02610148e-02f, -3.83511542e-05f, 1.28203891e-02f, 7.38821849e-02f, 6.76625744e-02f, -1.20026292e-02f, 7.75715783e-02f, -9.75619107e-02f, -2.37701572e-02f,
  1.26763796e-02f, 1.37036994e-01f, -9.89818480e-03f, 3.63612664e-04f, 1.56071289e-02f, 9.09407437e-02f, -1.13398973e-02f, 7.21573755e-02f, 1.06191196e-01f, 1.15690030e-01f,
  1.61235541e-01f, -4.16690204e-03f, -8.08922052e-02f, -2.84564905e-02f, -6.80378228e-02f, -8.86275917e-02f, 8.22528675e-02f, 4.95743006e-02f, 8.82417560e-02f, 1.53943729e-02f,
  2.45810393e-02f, 9.15496647e-02f, -4.92595695e-02f, 2.52991039e-02f, 5.66672571e-02f, 2.66725086e-02f, -5.48379011e-02f, 3.35771330e-02f, 2.88116857e-02f, 1.00413382e-01f,
  2.03319956e-02f, 1.04135694e-02f, 6.61658347e-02f, 1.36660011e-02f, -1.30677028e-02f, -8.83115903e-02f, 1.99947376e-02f, 6.90583214e-02f, 6.99652266e-03f, 1.59322098e-02f,
  7.46964067e-02f, 1.40404692e-02f, -1.07375294e-01f, -6.70316909e-03f, -3.76039520e-02f, -7.31627345e-02f, 1.67502428e-03f, 3.17232870e-02f, -2.33928524e-02f, 1.18024265e-02f,
  3.86226289e-02f, -2.25845594e-02f, 1.80340018e-02f, 6.42227903e-02f, -1.02956677e-02f, 6.37123063e-02f, -1.47140436e-02f, -2.73465570e-02f, -6.15776107e-02f, -8.31555426e-02f,
  -3.32444604e-03f, -4.32354771e-02f, -1.25829121e-02f, -1.84165686e-02f, -5.39130950e-03f, 1.62337662e-03f, 4.33003828e-02f, 1.88095625e-02f, -4.12947610e-02f, 2.82129608e-02f,
  -7.20933899e-02f, 8.87966901e-03f, -7.67388940e-02f, 5.32165095e-02f, 3.80501337e-02f, 3.35695110e-02f, -5.97186498e-02f, 2.16921549e-02f, 3.85313630e-02f, -7.07500950e-02f,
  6.16477281e-02f, 2.57378761e-02f, -4.15755734e-02f, -1.21375108e-02f, 5.92022017e-02f, -8.87675807e-02f, 7.46815130e-02f, 5.45937866e-02f, -1.09144384e-02f, 5.49450815e-02f,
  6.14460930e-02f, -1.08597122e-01f, 6.01534173e-02f, -1.02712013e-01f, -9.69709605e-02f, -6.73311576e-02f, -5.85687160e-02f, -2.97872145e-02f, -9.46363900e-03f, 7.49850571e-02f,
  -7.43275359e-02f, -3.16521376e-02f, -6.28214106e-02f, 5.97847141e-02f, -2.30183024e-02f, 4.18882929e-02f, 6.84536770e-02f, -5.88075481e-02f, -7.22364783e-02f, -8.28952864e-02f,
  7.46432692e-02f, -4.86096321e-03f, -7.14866370e-02f, 3.82164046e-02f, -5.44113927e-02f, 3.90875936e-02f, 1.28363315e-02f, -4.19381782e-02f, 6.63373843e-02f, -5.15566021e-03f,
  -7.61713684e-02f, -5.54190949e-03f, 1.99331474e-02f, 4.18757200e-02f, 1.62395444e-02f, -7.33064115e-02f, 1.19249076e-02f, -3.16118263e-02f, 7.49356002e-02f, 9.01454687e-02f,
  9.81902257e-02f, -1.07806042e-01f, 5.99759594e-02f, -6.85613826e-02f, 7.00510815e-02f, 1.33797139e-01f, 1.44592270e-01f, -1.13950847e-02f, -5.30973598e-02f, 1.31730726e-02f,
  5.82309850e-02f, -1.18205622e-01f, -8.73766616e-02f, -8.75235647e-02f, 3.71217579e-02f, 9.88953114e-02f, -6.46572635e-02f, -4.00142148e-02f, 8.69137347e-02f, -3.63878459e-02f,
  -2.83568334e-02f, 6.73574582e-02f, -7.90117308e-03f, 5.14399260e-02f, 2.98714321e-02f, 5.35346381e-02f, -8.81724507e-02f, -6.85828477e-02f, -1.15135618e-01f, -1.02297932e-01f,
  -3.72105162e-04f, 2.18890775e-02f, 9.14975032e-02f, -1.20096438e-01f, -1.03626847e-02f, 3.56103592e-02f, -7.02797472e-02f, -5.42375632e-02f, -1.13396563e-01f, -7.58226365e-02f,
  -6.03481121e-02f, -4.91528101e-02f, -8.85176435e-02f, -7.85209015e-02f, 1.84497219e-02f, 6.42071068e-02f, -8.61517489e-02f, -3.57298106e-02f, 9.97382123e-03f, -5.16566411e-02f,
  1.93674397e-02f, 1.35092065e-02f, 7.68595561e-02f, 4.95095216e-02f, -1.03810333e-01f, 4.89438400e-02f, -9.99232307e-02f, -6.14949912e-02f, 5.91456257e-02f, -4.00685631e-02f,
  2.70468835e-02f, -1.33263757e-02f, 9.35388356e-02f, -2.74221711e-02f, -4.87679280e-02f, 9.17336568e-02f, -5.60474470e-02f, -1.14407167e-02f, 7.91754052e-02f, -3.08746900e-02f,
  -8.11945349e-02f, 3.26185226e-02f, -1.58827752e-02f, 8.50899965e-02f, -8.27727318e-02f, -7.46826679e-02f, -7.24033415e-02f, 5.91765307e-02f, -9.72478837e-02f, 9.97289568e-02f,
  -4.70932052e-02f, -1.16940252e-01f, 1.08134013e-03f, -1.78239681e-02f, -7.24173710e-02f, -5.07436879e-02f, -7.53986239e-02f, -1.03501096e-01f, -7.90331662e-02f, 4.66951095e-02f,
  7.17504397e-02f, -6.01113997e-02f, -3.37907076e-02f, -1.22296624e-01f, -6.37062639e-02f, -7.57065341e-02f, 1.96989197e-02f, -6.07662387e-02f, -9.20908302e-02f, -2.80664749e-02f,
  -3.43608521e-02f, 5.18065542e-02f, -1.70221087e-02f, -3.86241853e-04f, 2.75601186e-02f, 7.62553141e-02f, 2.99599785e-02f, 1.35727460e-02f, 5.60047179e-02f, -7.61367753e-02f,
  -8.02585632e-02f, 6.70758933e-02f, 2.14365453e-01f, 1.36356801e-01f, 6.93644583e-02f, 2.56837029e-02f, 1.26726762e-03f, 6.68161958e-02f, 6.99604750e-02f, 1.63696006e-01f,
  8.72829556e-02f, 7.96223804e-02f, -4.41927798e-02f, 3.39739062e-02f, -1.26199484e-01f, 8.29636380e-02f, 1.13762520e-01f, 8.02329481e-02f, 3.65951867e-03f, -4.44316342e-02f,
  -8.22847486e-02f, -2.60973424e-02f, 6.92978799e-02f, 1.02473386e-02f, -7.05669671e-02f, -6.30204426e-03f, -8.12733695e-02f, 2.59983400e-03f, 3.31580341e-02f, 1.02913231e-01f,
  5.67169255e-03f, 7.82029033e-02f, -3.49538885e-02f, -2.91786436e-02f, 4.11074758e-02f, -8.45799372e-02f, -6.99697882e-02f, 2.91047320e-02f, 5.47367595e-02f, -1.41737208e-01f,
  8.79364684e-02f, -8.67325142e-02f, -1.22035898e-01f, -5.32619692e-02f, 7.30487797e-03f, -6.54357523e-02f, 2.88891066e-02f, -1.21784680e-01f, -2.07832865e-02f, 4.39660661e-02f,
  -7.93226659e-02f, -1.54597079e-02f, -4.38275561e-02f, -6.83160350e-02f, -4.33034375e-02f, 4.40376438e-02f, -6.82959892e-03f, -4.17390391e-02f, -9.73231792e-02f, 1.14468415e-03f,
  -1.36848375e-01f, -9.01450515e-02f, -8.99325982e-02f, -6.37872741e-02f, -5.67165874e-02f, -1.48056224e-01f, -9.62122381e-02f, -1.50017396e-01f, 7.28418585e-03f, 8.02389979e-02f,
  -7.45754093e-02f, -8.30527097e-02f, -4.03772816e-02f, -1.82483904e-03f, 8.51880088e-02f, 1.91371050e-02f, -1.62294004e-02f, 6.15021884e-02f, -5.27186804e-02f, 2.47521233e-02f,
  4.85065356e-02f, 8.29265341e-02f, 3.31529416e-02f, 8.91602412e-02f, -1.84450857e-02f, 4.69826832e-02f, -5.58868982e-02f, 9.53071788e-02f, -4.60138284e-02f, 7.01104999e-02f,
  5.33641987e-02f, -3.04094031e-02f, 1.69220604e-02f, -6.94492757e-02f, 3.93952727e-02f, 1.04157561e-02f, -1.74357276e-02f, 4.97397073e-02f, 4.20089252e-02f, -1.47861307e-02f,
  2.75922716e-01f, -6.78729862e-02f, -8.72911140e-03f, -3.88305783e-02f, -5.66750281e-02f, 2.75220163e-02f, -2.28320360e-02f, -1.00202516e-01f, -1.16920499e-02f, -7.16266930e-02f,
  3.56639065e-02f, 4.20204289e-02f, 8.72186124e-02f, 7.48575628e-02f, 9.02009010e-02f, -6.52190298e-02f, 2.31960844e-02f, -1.74437352e-02f, -3.43969353e-02f, -3.62500292e-03f,
  -2.82917321e-02f, 8.28666911e-02f, 1.41251445e-01f, -1.05309263e-02f, 3.96504775e-02f, 1.05785079e-01f, 1.05970934e-01f, 4.35622896e-05f, 1.11140124e-01f, 2.33480185e-01f,
  -2.87729084e-01f, 1.72205437e-02f, 8.80884975e-02f, -1.42167598e-01f, 8.57790709e-02f, 1.11426845e-01f, 1.40150577e-01f, -7.14693516e-02f, -1.17482707e-01f, 9.54997614e-02f,
  -3.61582190e-02f, -5.94449602e-02f, -9.43084583e-02f, 2.97441557e-02f, -3.18168290e-02f, 1.21901385e-01f, 1.16122551e-01f, 5.63886054e-02f, 4.19659875e-02f, -8.38025734e-02f,
  -1.70961127e-03f, -4.52936850e-02f, -1.75225675e-01f, -9.33649838e-02f, 3.21050570e-03f, -3.39090414e-02f, -2.42403802e-02f, -9.51273367e-02f, -2.92976722e-02f, 3.60502489e-02f,
  1.02675416e-01f, -7.11774006e-02f, 3.51312794e-02f, -7.74904620e-03f, -5.55613227e-02f, 1.58533379e-02f, -4.37862724e-02f, -6.47394508e-02f, 5.53078726e-02f, -3.29485461e-02f,
  -5.23155555e-02f, -2.13366188e-02f, -7.07611395e-03f, 2.94772238e-02f, 2.27151089e-03f, -1.00637734e-01f, -6.73543289e-02f, 3.42035230e-04f, -7.69829676e-02f, 5.07108718e-02f,
  -5.38415350e-02f, 6.83732983e-03f, -1.02741063e-01f, 4.64189276e-02f, 1.30221946e-02f, 3.65429707e-02f, 1.37393642e-02f, -7.73808882e-02f, -5.83763085e-02f, -1.07546225e-02f,
  -1.72976162e-02f, -8.04345906e-02f, 3.95481102e-02f, -8.30267295e-02f, -9.08945128e-02f, -8.59966502e-03f, 4.42354083e-02f, -4.43957038e-02f, -9.64641199e-03f, -7.97832292e-03f,
  -8.59140977e-02f, -1.63875502e-02f, -7.80158490e-02f, 7.35020041e-02f, 6.87385947e-02f, -8.95377900e-03f, 6.75991178e-02f, -4.69926931e-02f, 2.01896206e-03f, 5.69993369e-02f,
  -4.32697758e-02f, -7.69369677e-02f, -3.50884162e-02f, -5.84264360e-02f, 4.16903235e-02f, 4.48635481e-02f, -6.02295846e-02f, 7.96652585e-02f, 4.58023734e-02f, 1.96731649e-02f,
  -8.50917250e-02f, -2.49453466e-02f, -7.99331814e-02f, -7.93786254e-03f, 3.71180661e-02f, 2.90140342e-02f, 5.58585748e-02f, -7.76948258e-02f, -3.15506868e-02f, 5.55467792e-02f,
  -5.30527942e-02f, -9.65910032e-02f, -2.07519140e-02f, -6.79522902e-02f, 4.95430157e-02f, -3.24018188e-02f, -7.01459125e-03f, -2.51367372e-02f, -2.05667242e-02f, -3.26211192e-02f,
  6.66769892e-02f, 2.57489774e-02f, -5.67400195e-02f, -1.57051459e-02f, 9.94913094e-03f, 4.11209799e-02f, -1.83220319e-02f, -1.09022938e-01f, -5.63879684e-02f, -1.42090157e-01f,
  1.58551201e-01f, 1.19014010e-01f, -1.93911325e-02f, 5.39843440e-02f, -1.02656886e-01f, -1.96550846e-01f, -1.28260553e-01f, -6.91193566e-02f, -2.92118471e-02f, -4.45077196e-02f,
  -1.05548576e-02f, -5.76801645e-03f, -3.09558231e-02f, -4.62880060e-02f, 2.16240846e-02f, 3.14360112e-02f, 1.08743049e-01f, 1.24937795e-01f, -5.19671328e-02f, 7.09880069e-02f,
  1.17422342e-01f, 1.09320886e-01f, 4.65239957e-02f, 7.05091879e-02f, 2.45598536e-02f, 9.79478881e-02f, 1.01641119e-01f, 2.20095143e-02f, 6.30623326e-02f, 2.54548848e-01f,
  7.80389309e-02f, 3.29272635e-02f, -6.07858673e-02f, -6.61072358e-02f, -5.07940166e-03f, 5.47435693e-02f, -5.53514436e-02f, 6.14963807e-02f, 2.72199307e-02f, -5.57894073e-03f,
  2.74998620e-02f, -5.25225699e-02f, -4.96126246e-03f, 4.74396423e-02f, 6.28328621e-02f, -3.29613350e-02f, 6.86416104e-02f, -3.02550886e-02f, -9.17745978e-02f, 9.56979464e-04f,
  6.20920956e-02f, -4.59994152e-02f, -2.73196064e-02f, -2.89566852e-02f, -7.49793127e-02f, -8.88110772e-02f, -3.44631001e-02f, -3.09879892e-02f, 1.96369551e-02f, 9.07334909e-02f,
  6.15966208e-02f, -5.99569678e-02f, -7.72737013e-03f, 7.79319555e-02f, 3.87702808e-02f, 6.11557476e-02f, 6.05384037e-02f, 8.33017454e-02f, -6.10542344e-03f, -2.65901107e-02f,
  -3.96453962e-02f, -2.54540741e-02f, -2.07028892e-02f, 6.19033016e-02f, 3.63134034e-02f, 7.10634887e-02f, 7.38035589e-02f, -4.17074896e-02f, -4.82549891e-02f, -3.94640528e-02f,
  -3.34037431e-02f, -2.91662174e-04f, 6.24227384e-03f, -5.78250736e-02f, 8.81671906e-02f, 5.09949140e-02f, 7.79817104e-02f, 9.07425359e-02f, -4.69446555e-02f, 1.68585721e-02f,
  -1.57480747e-01f, -2.68513113e-01f, -3.69696282e-02f, 1.14499163e-02f, 7.50304163e-02f, 4.97009344e-02f, 7.01184571e-02f, 5.13283201e-02f, 1.50576131e-02f, -3.80604006e-02f,
  4.58789729e-02f, 6.82746433e-03f, -2.15775780e-02f, -9.82832611e-02f, -9.16136876e-02f, -6.98264912e-02f, -4.50037643e-02f, -4.33641449e-02f, -6.28971541e-03f, 6.11889660e-02f,
  1.62995160e-02f, -1.32216319e-01f, -1.77768096e-01f, -3.60458232e-02f, -1.50228646e-02f, -8.25362951e-02f, -1.37506723e-01f, 1.98977701e-02f, -3.09498515e-02f, -1.47090599e-01f,
  1.97992101e-01f, -4.23048399e-02f, -1.20935313e-01f, -4.10934761e-02f, -9.12979990e-02f, -1.92212090e-02f, -1.56471148e-01f, 2.64449585e-02f, -4.87185381e-02f, 1.85283273e-02f,
  -4.24711071e-02f, -2.85092741e-02f, -8.82332623e-02f, -6.27700984e-02f, -1.27134025e-01f, -2.33214602e-01f, -1.14235379e-01f, -1.86001644e-01f, -1.34145975e-01f, -5.83351888e-02f,
  -1.76280681e-02f, 5.23230769e-02f, -4.82276715e-02f, -9.41996127e-02f, -1.15396166e-02f, -1.19039156e-01f, -1.45947576e-01f, 3.94230634e-02f, -4.41447459e-02f, -8.01763982e-02f,
  -1.04401201e-01f, 2.06053883e-01f, -4.61044200e-02f, 8.38183239e-03f, 7.17521235e-02f, 6.90800324e-02f, 7.16146901e-02f, 7.12314919e-02f, 1.25352234e-01f, 7.64682423e-04f,
  2.29159351e-02f, -3.55389528e-02f, 7.48648047e-02f, 1.05562858e-01f, 1.00271732e-01f, 3.99598852e-03f, -4.41219546e-02f, 7.70948306e-02f, -1.30203888e-02f, 2.23701671e-02f,
  3.32572497e-02f, 1.11955732e-01f, 9.48826373e-02f, -4.62236032e-02f, 2.07417291e-02f, 8.62996727e-02f, 7.83781260e-02f, -6.46047145e-02f, 1.33470609e-03f, -2.80119143e-02f,
  -6.53834566e-02f, 2.74195671e-02f, 2.28872206e-02f, 3.71314883e-02f, 4.46471870e-02f, -3.38347964e-02f, -1.31551782e-02f, -7.26474449e-02f, 4.29763272e-02f, -4.51353639e-02f,
  -9.13895294e-02f, 2.27397978e-02f, 3.18157822e-02f, 8.58015716e-02f, -2.27906071e-02f, 8.40151310e-02f, 4.63943966e-02f, -9.63202491e-03f, -1.76128410e-02f, 3.56459245e-02f,
  -5.72032034e-02f, 2.71684658e-02f, 8.90986472e-02f, 1.93677749e-02f, 7.97542110e-02f, -6.38031811e-02f, 5.09353094e-02f, -5.32423146e-03f, -4.80654798e-02f, 8.34340155e-02f,
  -6.12714551e-02f, 4.03693952e-02f, -6.30011186e-02f, 4.35535274e-02f, 7.46201118e-03f, 2.40638070e-02f, -4.83741499e-02f, 5.09909242e-02f, 8.32367912e-02f, 6.68495670e-02f,
  1.18202217e-01f, -5.92583418e-02f, 3.07399072e-02f, 1.81651656e-02f, -6.46844879e-02f, 2.95064077e-02f, -2.74915155e-02f, -8.52399468e-02f, -3.53411399e-02f, -7.45391473e-02f,
  -1.11903429e-01f, 4.00886200e-02f, 4.85904552e-02f, -7.46609364e-03f, 9.86891612e-02f, 2.42626779e-02f, -3.66909876e-02f, -5.84755503e-02f, -1.25907764e-01f, -1.57413378e-01f,
  -3.70196968e-01f, 1.21370487e-01f, 1.15606012e-02f, -2.55649775e-01f, -1.15714625e-01f, -2.40506306e-02f, 5.44180535e-02f, -1.25195667e-01f, -1.80853963e-01f, -8.50947350e-02f,
  -1.54594555e-02f, 1.99529659e-02f, -1.33440066e-02f, 1.47883436e-02f, -5.55350333e-02f, -1.21748969e-02f, 7.29916571e-03f, -3.00886873e-02f, -1.32545516e-01f, -4.95560048e-03f,
  -1.48373274e-02f, -1.62506104e-01f, -1.34999335e-01f, -1.85196653e-01f, 2.07356899e-03f, 3.86429615e-02f, -3.93010154e-02f, -1.24254413e-01f, 3.78072858e-02f, -3.70869972e-02f,
  2.92912096e-01f, -2.12458938e-01f, -1.01933870e-02f, -2.67050453e-02f, -8.58783424e-02f, 2.78549045e-02f, -2.21590232e-03f, -8.03648904e-02f, -3.75706442e-02f, -8.27032421e-03f,
  -1.10071637e-01f, -2.48163976e-02f, -1.66732594e-02f, 3.15712318e-02f, -8.15831795e-02f, -1.09874897e-01f, -5.33922054e-02f, -7.15713650e-02f, -5.66602014e-02f, 3.94342095e-02f,
  5.18059125e-03f, 3.24886143e-02f, 7.61975944e-02f, -5.69475489e-03f, 1.61816124e-02f, 3.54399532e-02f, 6.30059019e-02f, -9.96182784e-02f, -7.63769634e-03f, 4.13806643e-03f,
  7.83346519e-02f, 8.80743116e-02f, -5.36741763e-02f, 4.02137972e-02f, 5.72354682e-02f, 8.71683508e-02f, -1.89231578e-02f, 7.77576342e-02f, -5.20272404e-02f, -7.18818158e-02f,
  7.40487650e-02f, -6.63017333e-02f, -4.45730388e-02f, 8.81409869e-02f, -3.21882218e-02f, -9.81331095e-02f, -9.91287455e-03f, 1.08847823e-02f, 4.16096002e-02f, 3.21877934e-02f,
  -9.77266058e-02f, -2.27508415e-02f, -7.13267103e-02f, 8.10417756e-02f, -6.59720227e-02f, -3.37039828e-02f, -7.33219786e-03f, -4.21983339e-02f, -3.06130778e-02f, -5.49591295e-02f,
  1.42993018e-01f, -2.85501368e-02f, 1.85706876e-02f, -6.19598776e-02f, -1.12963609e-01f, -2.25514248e-02f, -8.79729763e-02f, -2.36702021e-02f, -2.32808087e-02f, -2.95165572e-02f,
  5.17446399e-02f, -6.92844689e-02f, -3.72868441e-02f, -8.08363706e-02f, 4.17942591e-02f, 4.80490252e-02f, 1.42916460e-02f, 6.04825467e-02f, 2.42120624e-02f, 3.75463068e-02f,
  6.80610016e-02f, 7.88755417e-02f, 4.72425260e-02f, 5.16057834e-02f, 4.83488664e-02f, 7.06937984e-02f, 1.52875841e-01f, 9.26215574e-02f, 1.33623600e-01f, 1.26399174e-01f,
  1.17719576e-01f, 2.24211752e-01f, 8.10259730e-02f, 1.56968117e-01f, 5.82913682e-02f, 6.97604865e-02f, 1.92801028e-01f, 9.29013640e-02f, -3.18921753e-03f, 1.49693400e-01f,
  8.87461752e-02f, 1.02626294e-01f, -1.81779340e-02f, 9.49733928e-02f, 8.98891538e-02f, 5.64204492e-02f, 1.11005008e-01f, 7.17435312e-03f, -6.27840236e-02f, 1.32873848e-01f,
  1.64128631e-01f, 2.25948021e-02f, 1.20751821e-02f, 8.27603117e-02f, 7.51971006e-02f, 5.99091351e-02f, -8.71285610e-03f, -2.67090425e-02f, -1.45262461e-02f, 1.29130244e-01f,
  -6.23472631e-02f, 1.11931704e-01f, -9.66027752e-02f, 4.15393896e-03f, 5.42982528e-03f, 2.19846107e-02f, -4.15294729e-02f, -1.91870574e-02f, -4.43695150e-02f, 4.64161150e-02f,
  -7.19940439e-02f, -8.71488154e-02f, 8.16598237e-02f, 1.46515155e-02f, -1.12770185e-01f, -8.55847001e-02f, -9.11595896e-02f, 4.38654572e-02f, 8.41860473e-02f, 5.29756658e-02f,
  5.95692545e-02f, -5.26369549e-02f, -2.93046106e-02f, -7.78391063e-02f, 3.84429730e-02f, -7.96359554e-02f, -9.55760553e-02f, -6.77363276e-02f, 1.93816703e-02f, 6.79052174e-02f,
  -9.07283500e-02f, 2.37934645e-02f, -1.54538685e-02f, -8.94346368e-03f, -1.93960941e-03f, 1.47287017e-02f, -1.24488175e-02f, -2.78995223e-02f, 5.13154082e-03f, -6.04332685e-02f,
  -1.74349174e-02f, 2.30363514e-02f, -4.45198733e-03f, 9.33129527e-03f, -2.92578042e-02f, -8.52390081e-02f, 5.47356494e-02f, 1.84772871e-02f, -5.88929094e-02f, 1.81221794e-02f,
  1.98796894e-02f, 3.28879729e-02f, -4.42096405e-02f, 3.12780812e-02f, 3.58831733e-02f, -8.31974298e-02f, 2.35921610e-02f, -7.78677985e-02f, -7.09156543e-02f, 6.74131289e-02f,
  -6.16077632e-02f, -3.03736106e-02f, 5.18357120e-02f, 7.32993409e-02f, -5.53787162e-04f, 7.59120472e-03f, 1.14375129e-02f, 7.22874748e-03f, -1.39448512e-02f, -4.03814726e-02f,
  -9.28263888e-02f, 4.30937856e-02f, 1.06141575e-01f, 4.55528982e-02f, -7.02087507e-02f, -4.93878685e-02f, 1.65249053e-02f, 6.00475539e-03f, 8.66255984e-02f, -1.62090361e-02f,
  6.36113882e-02f, 5.02959185e-04f, -2.41839257e-03f, -6.23841770e-02f, 7.00170696e-02f, -1.01081453e-01f, -3.04538868e-02f, -1.70463026e-02f, -1.04780853e-01f, -1.50384922e-02f,
  3.38289976e-01f, 1.59871891e-01f, -3.09642106e-01f, 6.87646493e-02f, -1.43643335e-01f, -2.32823819e-01f, 5.41093107e-03f, -2.74265893e-02f, 1.07275084e-01f, 7.02336133e-02f,
  -3.85513008e-02f, -2.04068460e-02f, -3.54865119e-02f, -1.82033494e-01f, -2.91576479e-02f, -5.62667213e-02f, -1.31802320e-01f, -1.17832303e-01f, -1.72478929e-01f, -2.02034682e-01f,
  -6.75564408e-02f, 5.12369499e-02f, 7.38251880e-02f, -3.59436162e-02f, -1.65664274e-02f, -4.25065346e-02f, 5.62138706e-02f, -9.14464518e-02f, -1.98222429e-01f, -1.59593239e-01f,
  -2.64230013e-01f, -1.63139880e-01f, -9.56534147e-02f, 4.34958041e-02f, -9.11259800e-02f, 1.09336123e-01f, 4.99778204e-02f, -2.80422680e-02f, 2.89568882e-02f, 7.82764927e-02f,
  -1.61857024e-01f, -2.09158869e-03f, -7.78288469e-02f, -9.26461145e-02f, -7.18266666e-02f, -7.96566010e-02f, 2.46095080e-02f, -1.24647744e-01f, 6.28457498e-03f, -1.27121642e-01f,
  -3.10242586e-02f, -5.42097017e-02f, -4.80834208e-03f, -4.08253670e-02f, -8.81666318e-02f, -6.97323605e-02f, -3.94573994e-02f, -1.36903062e-01f, -1.88573331e-01f, 1.29473239e-01f,
  1.93015691e-02f, 3.19752544e-02f, -3.74081987e-03f, 1.03998795e-01f, 9.63391960e-02f, 1.31965885e-02f, 2.04677265e-02f, 3.26991826e-02f, 4.11098190e-02f, -2.32767966e-02f,
  -2.90671363e-02f, -4.21841554e-02f, 6.61044335e-03f, 1.05363771e-01f, -8.61886814e-02f, -1.49669405e-02f, 4.03408222e-02f, 9.73459855e-02f, 4.65724133e-02f, 4.57995310e-02f,
  -7.68287182e-02f, 1.88512132e-02f, 4.78156693e-02f, 6.48680143e-03f, -8.55426118e-03f, -1.39307240e-02f, -4.00178544e-02f, -4.35707681e-02f, 3.46955396e-02f, -7.51873702e-02f,
  3.38431060e-01f, -1.09064966e-01f, 1.29336461e-01f, -2.13159323e-02f, -3.62377763e-02f, -2.64092106e-02f, -1.35864392e-02f, 8.53910390e-03f, -5.40142171e-02f, 5.17009683e-02f,
  -3.84315960e-02f, -3.56390886e-02f, -4.75332327e-02f, -2.63046268e-02f, -2.71712225e-02f, 2.94200685e-02f, 1.96750313e-01f, 4.29758169e-02f, -1.29540982e-02f, 9.05909482e-03f,
  1.42886534e-01f, 5.36803193e-02f, 1.54836059e-01f, 1.24179140e-01f, 4.86134551e-02f, -6.06036782e-02f, -7.91109633e-03f, 1.09289465e-02f, 7.56363943e-02f, 4.04104978e-01f,
  -3.76439601e-01f, 8.02524984e-02f, 5.57939373e-02f, -5.56605831e-02f, 1.12205029e-01f, 1.47924703e-02f, -6.43625930e-02f, -1.07666306e-01f, 2.67192610e-02f, -2.11248826e-02f,
  -3.39516737e-02f, 3.61709930e-02f, 1.38296932e-01f, 1.57879710e-01f, 1.35835379e-01f, 1.01200402e-01f, 1.18705414e-01f, -3.80107239e-02f, -6.09630905e-03f, -1.00782793e-02f,
  4.75579202e-02f, 4.91511896e-02f, -2.67939977e-02f, 6.32523820e-02f, -1.43415155e-02f, -1.15719822e-03f, 1.20557964e-01f, 1.96279604e-02f, -1.71000548e-02f, 2.29499470e-02f,
  3.10813612e-03f, -1.95676520e-01f, 2.10221801e-02f, -5.57978861e-02f, -4.14765514e-02f, -2.58519072e-02f, -6.69581145e-02f, -8.68178383e-02f, 1.35312686e-02f, -1.16615832e-01f,
  -8.62275902e-03f, -8.74794349e-02f, -6.00904748e-02f, -1.22565180e-02f, -7.33933151e-02f, 4.83805500e-02f, -4.14939150e-02f, -2.91246530e-02f, -6.71312865e-03f, -1.13461986e-01f,
  2.66432762e-02f, -1.02196112e-01f, -9.92241129e-02f, -1.04888789e-02f, -6.51333807e-03f, -4.72025871e-02f, 7.28177000e-03f, -1.50808752e-01f, -1.28851295e-01f, -1.45646602e-01f,
  -1.73321459e-02f, 1.17428638e-02f, 5.14247119e-02f, -1.65461283e-02f, -2.40168329e-02f, -4.43622656e-02f, 9.26538631e-02f, -6.49592131e-02f, 3.50933410e-02f, 3.53939682e-02f,
  5.72176799e-02f, -6.77568763e-02f, -8.58626664e-02f, -1.01029361e-02f, -1.60415936e-02f, 2.00592931e-02f, 4.13364731e-02f, 2.01997161e-02f, -2.85529606e-02f, 3.65838595e-02f,
  6.32561222e-02f, -8.91067758e-02f, -3.06151453e-02f, -3.42444703e-02f, 1.13516813e-02f, -6.54948279e-02f, -3.14784311e-02f, -5.65811321e-02f, 6.34997711e-02f, 4.80244905e-02f,
  -3.49184610e-02f, 9.76136047e-03f, -3.15470411e-03f, -7.31595084e-02f, -6.74738884e-02f, 3.18744183e-02f, 1.71852745e-02f, 1.84118021e-02f, 2.81204190e-02f, -1.27664939e-01f,
  6.15204945e-02f, -9.02802125e-02f, 6.78327605e-02f, -4.12496440e-02f, 6.54760189e-03f, -6.78208247e-02f, -4.00320953e-03f, 9.98857990e-02f, -5.78138977e-02f, 2.09583063e-02f,
  -4.49840948e-02f, -1.48646533e-01f, -9.86705534e-03f, 2.60901116e-02f, -7.49918893e-02f, -9.68824723e-04f, 1.00931227e-02f, -1.08020626e-01f, -7.78621435e-02f, -1.09918863e-01f,
  -1.19918965e-01f, -6.05945997e-02f, 6.63413256e-02f, -1.16219312e-01f, -8.65904018e-02f, -1.06137469e-01f, -1.74950100e-02f, -8.65924209e-02f, 7.86005184e-02f, 6.46851212e-02f,
  -1.04484946e-01f, -1.11229993e-01f, -2.61234455e-02f, -1.08245797e-01f, 5.68362921e-02f, 8.92732963e-02f, -4.90369797e-02f, -3.19229811e-03f, 1.06343245e-02f, -9.62520540e-02f,
  -3.45542058e-02f, -1.11167468e-01f, -3.05187069e-02f, -1.09778017e-01f, -4.29200009e-02f, -1.26455605e-01f, -9.43956152e-02f, 9.80394240e-03f, -1.14447087e-01f, -1.50666714e-01f,
  -1.64905544e-02f, -6.18611760e-02f, -5.41752614e-02f, 3.47247124e-02f, 5.63787110e-02f, -1.11001357e-02f, -7.14303330e-02f, -1.15345921e-02f, -1.39480513e-02f, -6.93010315e-02f,
  -1.45592382e-02f, -1.59822814e-02f, -1.72937303e-04f, -2.79724859e-02f, 6.03784472e-02f, -5.14096357e-02f, 1.71425045e-02f, -4.21671575e-04f, -5.65278642e-02f, -6.79416955e-02f,
  -2.92982943e-02f, -1.25910819e-01f, -6.08154349e-02f, -7.58821964e-02f, 1.21573564e-02f, -2.10373290e-02f, -1.06470063e-01f, 2.30426695e-02f, 2.38869619e-02f, -6.10496700e-02f,
  3.27434912e-02f, -2.01383997e-02f, 1.34674292e-02f, 8.17339029e-03f, 6.18823047e-04f, 7.72672445e-02f, -2.62178406e-02f, 5.56787625e-02f, -8.18575919e-02f, 4.95127961e-02f,
  -1.51842963e-02f, -2.65886970e-02f, 1.79901831e-02f, 1.58514716e-02f, -3.78825404e-02f, -4.17572595e-02f, 9.14879739e-02f, 8.92970562e-02f, 1.28195295e-02f, -2.14651171e-02f,
  -1.88845210e-02f, -3.91061045e-02f, 8.94815326e-02f, -4.18655202e-03f, 6.92080613e-03f, -7.31923655e-02f, -2.06890953e-04f, -3.75968069e-02f, 8.51541981e-02f, -5.46113588e-02f,
  -1.06401466e-01f, -3.46003175e-02f, -2.79832929e-02f, 4.78393584e-02f, -7.24797621e-02f, 4.43476699e-02f, 2.85583902e-02f, -1.06132263e-02f, -3.41595523e-02f, -5.72456159e-02f,
  -2.69446708e-02f, -6.31595179e-02f, 6.06225431e-02f, 5.88250235e-02f, 5.39782532e-02f, 5.13841026e-03f, -5.96113279e-02f, 2.51451530e-03f, 2.06297249e-04f, 1.93424635e-02f,
  4.68075881e-03f, 2.59577483e-02f, -7.80369341e-02f, 1.86496582e-02f, 2.73719598e-02f, -1.10564470e-01f, -8.86199921e-02f, -1.08010300e-01f, -7.37519329e-03f, -6.75765648e-02f,
  -9.20803398e-02f, -5.98412529e-02f, 1.02948345e-01f, -1.39585525e-01f, -5.70590906e-02f, 4.09191437e-02f, -3.94026153e-02f, -3.61492634e-02f, 3.28444988e-02f, 4.02055345e-02f,
  5.07067405e-02f, -1.06470548e-01f, 2.91017536e-02f, 3.89265604e-02f, -7.03613907e-02f, -1.49637284e-02f, -2.15046685e-02f, -3.19528654e-02f, -5.27397655e-02f, -4.60476838e-02f,
  -1.38802424e-01f, -7.36771002e-02f, 1.60407014e-02f, -1.23791009e-01f, 3.94650782e-03f, -6.45699799e-02f, 5.94602292e-03f, -7.78752565e-02f, 2.95677856e-02f, 3.90871875e-02f,
  6.43677935e-02f, -3.12995352e-02f, -5.91261983e-02f, -7.95598514e-03f, 5.03321961e-02f, -5.56836352e-02f, -7.29442537e-02f, 8.83198008e-02f, 2.87549626e-02f, 2.52206009e-02f,
  6.38100207e-02f, 5.51960878e-02f, 1.56794377e-02f, -3.29655558e-02f, 8.14650580e-02f, 5.17797880e-02f, 8.43956787e-03f, -4.43390608e-02f, 8.90221000e-02f, 5.33965267e-02f,
  -2.81751598e-03f, -3.94241512e-02f, -4.60197814e-02f, 1.19984290e-02f, -4.83773212e-04f, 1.93140227e-02f, -3.59511822e-02f, -3.78394984e-02f, 8.41601864e-02f, -7.23944604e-02f,
  4.09071632e-02f, 3.26157100e-02f, 3.01034115e-02f, -9.17525887e-02f, 7.35229999e-02f, -4.64955010e-02f, -1.61497053e-02f, 3.07738949e-02f, 3.39621194e-02f, -2.84671709e-02f,
  -2.51579285e-02f, 3.84532437e-02f, 5.29883429e-02f, -5.63917197e-02f, -7.40199164e-02f, -2.45019626e-02f, -6.03613444e-02f, -6.05955645e-02f, 3.39710042e-02f, -3.14475261e-02f,
  -6.62752688e-02f, 4.18343991e-02f, -1.02976069e-03f, -8.08393583e-02f, 8.15534443e-02f, -4.14208136e-02f, -1.83858648e-02f, -4.45324033e-02f, 3.57040465e-02f, -1.89447571e-02f,
  4.61225100e-02f, 1.03208020e-01f, 5.08584008e-02f, -1.77133717e-02f, -2.48886812e-02f, -1.95121374e-02f, 6.57608435e-02f, -5.55209927e-02f, 6.68461435e-03f, -1.30528240e-02f,
  6.14643134e-02f, -6.25898242e-02f, -4.08488624e-02f, -2.61674151e-02f, -1.05933972e-01f, -1.01620667e-01f, 5.13165966e-02f, 4.60273176e-02f, -7.38660544e-02f, 5.50603643e-02f,
  -5.19798025e-02f, 2.32380442e-02f, -1.27974208e-02f, -7.23119453e-02f, 3.89576182e-02f, -1.04260154e-01f, -9.62146744e-02f, -5.15739694e-02f, 5.53486347e-02f, -3.07269096e-02f,
  3.07981461e-01f, -2.59219944e-01f, 1.47015736e-01f, 1.47433609e-01f, 1.24204881e-01f, 8.53318125e-02f, -1.92395840e-02f, -3.42616551e-02f, 8.69001821e-02f, -1.24707773e-01f,
  -8.63037631e-02f, 1.50774181e-01f, 2.25755516e-02f, 6.89420998e-02f, 9.45429578e-02f, -1.48575813e-01f, 7.67497420e-02f, 2.07478181e-01f, 2.59838015e-01f, 2.96139326e-02f,
  -5.60274869e-02f, -4.74381186e-02f, -2.14264188e-02f, -2.05811169e-02f, -1.62087917e-01f, 7.75012821e-02f, -5.12248538e-02f, -9.25960988e-02f, -1.27882674e-01f, -1.75608024e-01f,
  -8.83900225e-02f, -1.31403469e-02f, 1.48443714e-01f, 5.31739369e-02f, 1.10358221e-03f, -1.02368265e-01f, -4.50866595e-02f, -7.80293643e-02f, 1.54608181e-02f, -6.61576986e-02f,
  5.00763617e-02f, 7.56911933e-02f, -8.86740685e-02f, -1.19464234e-01f, -9.56164300e-02f, -6.45969659e-02f, 3.35892178e-02f, 3.54014114e-02f, 6.75298199e-02f, -6.44222228e-03f,
  -1.63401082e-01f, 6.24983571e-02f, 1.21488608e-02f, -1.00685591e-02f, -3.24623249e-02f, 1.64239466e-01f, 2.33766716e-02f, 2.22173203e-02f, 2.21175551e-02f, -1.48815736e-01f,
  7.77335186e-03f, 1.20958909e-02f, 9.98622328e-02f, -5.03057055e-02f, -4.43272665e-02f, 8.52256566e-02f, -4.41657118e-02f, -5.99959344e-02f, -3.82710584e-02f, -7.20617035e-03f,
  1.94500946e-02f, 3.80612463e-02f, -1.24633368e-02f, 3.24792899e-02f, 7.98988417e-02f, 5.86117357e-02f, 6.23487271e-02f, -3.23895700e-02f, 3.01158638e-03f, 3.18144797e-03f,
  -3.67184393e-02f, 9.64092240e-02f, 5.83014730e-03f, 1.34866815e-02f, 6.52405471e-02f, 1.28981406e-02f, 1.69571489e-02f, -2.09786054e-02f, 3.89272086e-02f, -6.85892105e-02f,
  -1.22258417e-01f, 1.84099734e-01f, 3.18044759e-02f, -4.60466705e-02f, -1.26459347e-02f, 2.60226913e-02f, -5.29413298e-02f, -9.95846093e-02f, -1.08754076e-02f, -3.48658636e-02f,
  -4.28575324e-03f, -6.62589818e-02f, 5.12793064e-02f, -5.50266951e-02f, 3.89569849e-02f, 7.14516491e-02f, -4.52196449e-02f, 3.48790623e-02f, -6.76584467e-02f, -3.82693894e-02f,
  -1.17023423e-01f, -2.58052628e-02f, 1.26747116e-01f, 8.46369639e-02f, -7.90578499e-02f, 2.15309992e-01f, 5.13727143e-02f, 6.38666451e-02f, 1.75112173e-01f, -8.78731608e-02f,
  7.14491010e-02f, 1.17644623e-01f, -1.95278646e-03f, 1.90593645e-01f, 2.45407000e-01f, 2.13652089e-01f, 2.64317065e-01f, 2.17358753e-01f, 1.83430731e-01f, 1.59852669e-01f,
  -4.54213805e-02f, -5.23692220e-02f, 3.23220305e-02f, -6.30500093e-02f, 7.38977119e-02f, 1.37984380e-01f, 1.90841183e-01f, 1.09626710e-01f, 3.24576125e-02f, 1.31284520e-01f,
  3.46428342e-02f, 6.42345101e-02f, -6.40410930e-02f, 8.75429343e-03f, 1.44382104e-01f, -1.30242063e-02f, -2.43313778e-02f, -6.85768342e-03f, 3.97648849e-02f, 7.04944730e-02f,
  -1.37413606e-01f, 6.84444383e-02f, -5.31892180e-02f, -9.01889354e-02f, -4.55756346e-03f, -5.81275411e-02f, 3.14325988e-02f, -1.63385253e-02f, 2.87943799e-02f, -1.65777169e-02f,
  -6.91195205e-02f, 3.80040845e-03f, 1.83486082e-02f, -6.40133843e-02f, -3.04961819e-02f, -8.62308890e-02f, -7.02204183e-02f, 7.10100755e-02f, 1.81610789e-03f, -1.24883009e-02f,
  4.97260876e-03f, -5.31698717e-03f, 8.59458596e-02f, -4.75218706e-02f, -8.63163397e-02f, -9.02607739e-02f, -6.57856390e-02f, -7.90688992e-02f, 1.29694734e-02f, -2.82750074e-02f,
  1.08112969e-01f, -3.17661688e-02f, -6.15186803e-03f, 7.24727064e-02f, -4.99318764e-02f, 7.68083334e-03f, 9.65411514e-02f, -2.83871274e-02f, 6.79876655e-02f, 2.08410546e-02f,
  -5.54574691e-02f, -7.68406689e-02f, 3.83353829e-02f, 1.10933082e-02f, -8.10097307e-02f, 4.81710881e-02f, -4.04312089e-02f, 2.34920643e-02f, 3.84278782e-02f, -2.24230178e-02f,
  -9.48369056e-02f, -1.64585505e-02f, -6.04069792e-02f, -5.94731010e-02f, 3.46441194e-03f, -5.65699860e-02f, 4.89172302e-02f, -3.22828554e-02f, 6.75412267e-02f, -3.81922610e-02f,
  -8.06775689e-02f, -9.18231905e-02f, -2.49932222e-02f, -8.96929875e-02f, 3.12465839e-02f, -6.01326227e-02f, 4.29413803e-02f, -1.38990851e-02f, -1.21577515e-03f, 6.39498904e-02f,
  3.73587795e-02f, -5.66785932e-02f, -1.54714016e-02f, -4.33796979e-02f, 5.90991117e-02f, -5.08651584e-02f, -3.72519083e-02f, -1.33140560e-03f, -7.00299665e-02f, -1.55134723e-02f,
  -7.19806179e-02f, 1.27441823e-01f, -4.53790054e-02f, 4.46502352e-03f, 7.03892186e-02f, 9.73731875e-02f, -5.84173091e-02f, 6.54255450e-02f, 8.50149691e-02f, 7.17494637e-02f,
  5.47012649e-02f, -1.70470983e-01f, -2.12922737e-01f, -1.82234183e-01f, -1.47354215e-01f, -7.98246786e-02f, -1.65616840e-01f, -1.35363594e-01f, -3.26677784e-02f, -1.11848384e-01f,
  -7.49374554e-03f, 2.29423955e-01f, 1.32487237e-01f, 9.51559544e-02f, 1.77951798e-01f, -2.47922778e-01f, -1.43995255e-01f, 2.48665158e-02f, 1.94449753e-01f, -9.81417578e-03f,
  -1.08384185e-01f, -5.54225631e-02f, 7.55432844e-02f, -9.70191061e-02f, -1.93129510e-01f, -1.06244229e-01f, -7.81233534e-02f, -1.37266591e-01f, -8.39802101e-02f, -1.67766705e-01f,
  1.29323304e-02f, 8.10727775e-02f, 6.89173937e-02f, 1.90249905e-02f, 4.15117666e-02f, 6.20295182e-02f, -1.62404757e-02f, 7.76301650e-03f, -3.52708367e-03f, 1.61861535e-02f,
  -6.55871034e-02f, 9.99185741e-02f, 1.08267961e-03f, -7.74221942e-02f, -1.00694306e-03f, -3.86323556e-02f, -1.28227323e-02f, 4.40466478e-02f, 3.89659666e-02f, -2.52698567e-02f,
  -8.57540667e-02f, -7.46820495e-02f, 7.06285834e-02f, 4.65105772e-02f, -1.40531017e-02f, 1.42067865e-01f, -5.28115686e-03f, -3.38039664e-03f, 1.01691000e-01f, -7.07976669e-02f,
  -1.31367505e-01f, 5.17182052e-02f, -8.11107606e-02f, 6.76128548e-03f, -4.60253134e-02f, 3.31412703e-02f, 3.19892317e-02f, -4.62378301e-02f, -6.86874555e-05f, -7.94281885e-02f,
  -5.26734255e-02f, -6.38308227e-02f, 6.85678199e-02f, -5.43137863e-02f, 8.33911896e-02f, -2.64174305e-02f, 5.92885129e-02f, -4.36886437e-02f, 5.52860685e-02f, 2.74163354e-02f,
  -1.75451301e-02f, -3.99162173e-02f, -7.53204599e-02f, 7.64356852e-02f, -1.83584243e-02f, -4.17048447e-02f, -6.92764074e-02f, 1.02078632e-01f, -4.24174406e-02f, 2.88721807e-02f,
  1.33154884e-01f, 1.64188981e-01f, -2.76725218e-02f, 6.18636832e-02f, -1.08814135e-01f, 6.94100233e-03f, -5.73699400e-02f, 5.02980314e-02f, 9.98148024e-02f, 5.76622561e-02f,
  -2.45285667e-02f, -6.48058718e-03f, -6.61652088e-02f, -1.07060492e-01f, 3.60416286e-02f, 5.20927040e-03f, -6.81694672e-02f, 4.91885375e-03f, 7.01023415e-02f, -5.42154573e-02f,
  -1.46597356e-01f, -4.30734940e-02f, 1.40577048e-01f, -2.83553675e-02f, 4.89165373e-02f, 7.12681562e-03f, 9.64754596e-02f, 2.72868853e-02f, 5.91663495e-02f, -2.07950115e-01f,
  -1.74812436e-01f, -2.65855286e-02f, -5.23037240e-02f, -2.27443367e-01f, 5.46662509e-02f, 4.70624380e-02f, -1.22102408e-03f, 6.13218062e-02f, 3.15084937e-03f, -1.01399131e-01f,
  -1.71541926e-02f, -7.20100179e-02f, -5.34157529e-02f, 1.18877195e-01f, 3.57902572e-02f, -2.15801336e-02f, 6.81984946e-02f, -6.88302517e-02f, 9.47908759e-02f, 1.16662398e-01f,
  -4.61428277e-02f, -1.10699184e-01f, -4.75420989e-02f, 3.05256210e-02f, -1.73733965e-01f, -1.05792256e-02f, -5.18118665e-02f, -1.03388941e-02f, 6.30949512e-02f, -5.45184575e-02f,
  -6.83265254e-02f, -1.91670015e-01f, 1.24022178e-01f, -1.13225672e-02f, -9.34502259e-02f, -9.07177329e-02f, -1.07473843e-01f, -4.55380119e-02f, -9.36964750e-02f, -9.03455466e-02f,
  -4.67644185e-02f, 5.17472178e-02f, -1.92502066e-02f, 7.60540217e-02f, -9.19618737e-03f, 1.15422020e-02f, 6.85213059e-02f, -2.44370885e-02f, -2.71326303e-02f, 6.80723414e-02f,
  1.35818440e-02f, -8.39106292e-02f, -7.46197179e-02f, 6.54006191e-03f, 5.35230525e-02f, -5.79115823e-02f, -1.24480657e-01f, -6.26860857e-02f, -1.09875659e-02f, -9.78718847e-02f,
  1.13051713e-01f, 5.14754951e-02f, 1.03307575e-01f, -6.65346952e-03f, -2.62240656e-02f, 6.99832737e-02f, -8.01469758e-02f, -1.51147004e-04f, -4.29290347e-02f, -9.73995030e-02f,
  -6.31539524e-02f, 9.89425406e-02f, 7.06039146e-02f, -7.34500289e-02f, -8.43012556e-02f, 7.52294064e-02f, -9.25485790e-03f, 1.47328451e-02f, -4.83653806e-02f, -6.84977472e-02f,
  4.81751487e-02f, 2.43481882e-02f, -7.65950531e-02f, 1.05795404e-02f, -1.14655225e-02f, -3.63591564e-04f, 2.85497699e-02f, 6.20299317e-02f, -4.38813791e-02f, 1.35743450e-02f,
  -1.42368287e-01f, 1.76561132e-01f, -9.38392282e-02f, -3.40118520e-02f, -5.96442446e-02f, 1.54319024e-02f, -2.79391203e-02f, 5.50929569e-02f, 2.61985902e-02f, 5.91375381e-02f,
  6.15478195e-02f, 6.10311031e-02f, -6.58120401e-03f, 8.82669687e-02f, -7.38332942e-02f, -2.78232563e-02f, 1.20575652e-02f, -6.48952127e-02f, 1.90245211e-02f, -7.84495845e-02f,
  -3.64481360e-02f, -8.85755196e-03f, -5.10664582e-02f, -1.47628633e-03f, 3.36434059e-02f, -1.09069729e-02f, -1.14007592e-01f, -1.12401113e-01f, 6.70407861e-02f, -8.26454833e-02f,
  3.43234017e-02f, -2.22676788e-02f, -2.76908185e-02f, 2.04472870e-01f, -4.07860987e-02f, -2.09522024e-01f, -3.09193552e-01f, -1.72755077e-01f, 6.57771528e-02f, 1.07105248e-01f,
  7.31297955e-03f, 1.49853736e-01f, 2.13820171e-02f, -1.52915537e-01f, -2.28490293e-01f, -1.94990426e-01f, -1.73911527e-01f, -1.08259909e-01f, -2.58926749e-01f, -2.19811082e-01f,
  4.43831310e-02f, 2.54372992e-02f, 1.75965801e-02f, -1.42196581e-01f, 1.84724629e-01f, 4.71923910e-02f, 4.03869972e-02f, 1.24819271e-01f, 7.81207681e-02f, 1.75958231e-01f,
  1.17522761e-01f, -7.48501392e-03f, -3.09081431e-02f, 1.28729129e-03f, 1.24906726e-01f, 3.67708914e-02f, -5.67109846e-02f, -7.33471885e-02f, 4.38183695e-02f, -8.70085284e-02f,
  1.11704439e-01f, 5.37128933e-02f, -3.61161605e-02f, -3.07711661e-02f, -7.20215663e-02f, 2.06757970e-02f, -1.26532003e-01f, -1.82889894e-01f, -1.22593522e-01f, -4.92225178e-02f,
  -2.32139621e-02f, 7.93295577e-02f, -8.96176975e-03f, -1.43644020e-01f, -1.23767201e-02f, 2.06806958e-02f, 4.24823910e-02f, -7.85224326e-03f, -8.23474769e-03f, 4.67799082e-02f,
  6.55646175e-02f, 5.92732020e-02f, 5.24192154e-02f, 2.27000229e-02f, -3.90215381e-03f, 8.29032362e-02f, 4.64313067e-02f, -3.44671085e-02f, -3.93072255e-02f, 8.56823102e-02f,
  -9.82145965e-02f, -7.38089010e-02f, -6.10001897e-03f, -3.05645596e-02f, -2.88695619e-02f, -3.56123187e-02f, 5.39247282e-02f, 1.03366328e-02f, 2.17864402e-02f, -8.69059004e-03f,
  -1.98214827e-03f, -2.76176985e-02f, 9.77465808e-02f, -1.88744627e-02f, -3.84821072e-02f, 1.03409691e-02f, 3.63189839e-02f, -7.07817450e-02f, 9.42828879e-02f, 4.21888158e-02f,
  1.10204816e-01f, -1.76954940e-01f, 2.20556967e-02f, -3.40054408e-02f, 5.08493185e-02f, -4.81748022e-02f, 1.25860363e-01f, -1.81126297e-02f, 1.49926236e-02f, -4.93978569e-03f,
  1.06045268e-02f, -6.41039312e-02f, 6.97666630e-02f, -1.06715858e-02f, 3.31639424e-02f, -9.06862170e-02f, 3.87803726e-02f, -3.72447409e-02f, 2.13289037e-04f, 2.30987314e-02f,
  -8.45729411e-02f, -7.17549725e-03f, -6.42399713e-02f, 2.92185601e-02f, -5.73730003e-03f, -2.35630665e-02f, -8.45653564e-02f, -2.54367082e-03f, -1.01767004e-01f, -1.93436816e-02f,
  9.47619379e-02f, 1.27520874e-01f, 7.85736665e-02f, 5.57361916e-02f, 7.86431730e-02f, 1.10445701e-01f, 1.18564203e-01f, 7.53805973e-03f, 4.92414609e-02f, -5.00917286e-02f,
  -3.39599233e-03f, -1.42722158e-02f, 3.48862410e-02f, -1.60112604e-02f, -4.91110981e-02f, 1.75496750e-02f, -4.42715958e-02f, -3.07064168e-02f, 8.90493467e-02f, 6.51707873e-02f,
  -1.01454355e-01f, 6.10397570e-02f, 1.09035866e-02f, 4.10897583e-02f, -1.27267003e-01f, -9.85120386e-02f, 1.94888245e-02f, 9.88374650e-02f, 7.52110407e-02f, -1.83821768e-01f,
  -5.94952330e-02f, 1.85064390e-01f, 2.90046688e-02f, 1.71339267e-03f, -3.03361733e-02f, 1.21043669e-02f, 2.74284501e-02f, 5.02919443e-02f, 2.57937722e-02f, -2.14178464e-03f,
  -2.09703948e-02f, 8.66238624e-02f, 2.66525634e-02f, 8.98548812e-02f, 1.15460046e-01f, 6.42944574e-02f, -3.19567993e-02f, 4.03529704e-02f, -3.25130783e-02f, 2.95026116e-02f,
  5.42501025e-02f, 6.96336105e-02f, -6.44392800e-03f, -3.69686484e-02f, -1.59340501e-02f, 7.91552141e-02f, 1.08212255e-01f, 4.16741781e-02f, 8.15185681e-02f, -8.86188000e-02f,
  3.71468849e-02f, -4.08790559e-02f, -3.36425267e-02f, -6.35947846e-03f, -2.82622464e-02f, -3.44079779e-03f, -2.89615951e-02f, -1.12965563e-02f, 4.18807566e-02f, 4.55475561e-02f,
  -4.31316644e-02f, -6.60268813e-02f, 9.35274214e-02f, 7.10850284e-02f, -1.13365434e-01f, 6.84611872e-02f, -7.57223293e-02f, 2.65048649e-02f, 9.84584913e-02f, 9.14217308e-02f,
  4.09233384e-02f, -6.85690716e-02f, 4.55851071e-02f, 3.74928080e-02f, -4.64038327e-02f, 3.23870219e-02f, 7.17191538e-03f, 2.98174527e-02f, -8.05109888e-02f, -4.12923843e-02f,
  -1.21672004e-01f, 1.98413283e-01f, -5.41871935e-02f, -1.18251607e-01f, 1.34950280e-02f, 6.01094142e-02f, -5.57673946e-02f, 4.44621779e-02f, -1.03499205e-03f, -9.61457659e-03f,
  -1.94808114e-02f, 8.77307132e-02f, -3.95873412e-02f, -9.68478769e-02f, 6.80042431e-02f, -7.72775942e-03f, -4.88978885e-02f, -8.08585733e-02f, 2.36780103e-02f, -2.07781903e-02f,
  3.14545296e-02f, -9.60083902e-02f, 2.61577219e-02f, -8.65505338e-02f, 1.88030722e-03f, 3.19443122e-02f, 3.07154320e-02f, -7.88906217e-02f, -6.95724785e-02f, -1.35400355e-01f,
  1.30402133e-01f, 1.02003887e-01f, -6.14335248e-03f, 1.26155140e-02f, 9.17469189e-02f, -1.48043513e-01f, -1.12941757e-01f, -9.66351628e-02f, 4.99542579e-02f, 1.26515701e-01f,
  1.81019515e-01f, 3.12057491e-02f, -5.35727590e-02f, -7.56447613e-02f, -1.62150890e-01f, -1.18065283e-01f, 5.79853058e-02f, -4.89234999e-02f, -6.67507201e-02f, -5.53194731e-02f,
  1.60100721e-02f, 3.70998122e-02f, 1.41326770e-01f, 9.30006430e-02f, 1.14199273e-01f, 1.38700485e-01f, 4.12854739e-02f, 5.38708605e-02f, 1.29522860e-01f, 2.71063000e-01f,
  1.38244644e-01f, -2.30764039e-02f, -7.46290982e-02f, 1.31794319e-01f, -3.85023654e-02f, 4.00704332e-02f, 2.91389544e-02f, 3.71195525e-02f, 8.36375952e-02f, 5.00851907e-02f,
  1.33342609e-01f, -2.49375366e-02f, 5.37053011e-02f, 4.12580036e-02f, -7.12178880e-03f, -1.92560647e-02f, 2.38308366e-02f, -1.35953546e-01f, -6.31986931e-02f, -1.38443923e-02f,
  7.46891052e-02f, 1.56484589e-01f, 2.32933871e-02f, -1.74716637e-01f, -9.91755351e-02f, 4.49574552e-03f, -1.19008698e-01f, -8.96928608e-02f, -1.82743996e-01f, 4.89796326e-02f,
  -5.99027462e-02f, -2.91926246e-02f, 5.10383174e-02f, 1.83501970e-02f, -3.06276660e-02f, 4.97501297e-03f, -4.45308723e-03f, -2.66505238e-02f, 5.75598925e-02f, 6.72765896e-02f,
  -2.55153328e-02f, -3.87642309e-02f, 5.31103909e-02f, -9.82859544e-03f, 8.71212929e-02f, -5.36595248e-02f, -8.26800615e-03f, -6.62169009e-02f, -2.96306709e-04f, 5.37304208e-02f,
  6.86758310e-02f, 2.01296862e-02f, 8.95757079e-02f, -1.03576981e-01f, -4.97289486e-02f, 5.08244820e-02f, 7.31708631e-02f, 4.30182368e-02f, -3.28080133e-02f, -5.55503462e-03f,
  5.14178760e-02f, -1.40686214e-01f, 4.42801192e-02f, 1.43923610e-02f, -2.08586976e-02f, 8.35652351e-02f, 1.17425472e-01f, 3.04220784e-02f, 9.52661335e-02f, -4.97917645e-02f,
  4.33766469e-02f, 2.23837164e-03f, 9.05733556e-03f, 3.60559635e-02f, -8.50179791e-02f, -5.07300394e-03f, -2.42824736e-03f, 9.33824852e-03f, -9.68780369e-02f, -5.67476563e-02f,
  2.51181014e-02f, -9.37599503e-03f, -1.04925886e-01f, -1.52588621e-01f, -1.18642457e-01f, -1.27051398e-02f, -3.75803672e-02f, 2.93722213e-03f, -1.42775014e-01f, 1.86520331e-02f,
  -1.46917596e-01f, 1.24501519e-01f, 1.40476272e-01f, -7.25364536e-02f, 4.79558930e-02f, 2.08540648e-01f, 1.89522415e-01f, 8.94355103e-02f, -1.13711961e-01f, -2.36044582e-02f,
  5.56780249e-02f, -9.27015543e-02f, -2.38396786e-02f, -6.64554164e-02f, 5.41901812e-02f, -3.06663625e-02f, -2.53469814e-02f, -6.30501285e-02f, -1.76657259e-01f, -9.77418479e-03f,
  -5.07257134e-02f, -7.25148842e-02f, -9.93707478e-02f, -1.46616980e-01f, 2.41015870e-02f, -1.25776693e-01f, 2.67546587e-02f, -7.18444884e-02f, 2.75568832e-02f, 6.09543659e-02f,
  6.14295192e-02f, 1.12315103e-01f, -1.31156603e-02f, -4.18072380e-02f, 1.32820472e-01f, 3.25774662e-02f, 6.60845935e-02f, -6.41464144e-02f, -6.28182441e-02f, -5.40699624e-02f,
  7.84575492e-02f, -1.04048615e-02f, -6.20983429e-02f, -8.56451690e-02f, 1.53842811e-02f, 4.33974825e-02f, -5.07162921e-02f, -1.28897846e-01f, -5.29454164e-02f, -5.32078408e-02f,
  -1.70573127e-02f, 2.74245162e-02f, 3.33056413e-02f, 4.16926593e-02f, 5.80960959e-02f, -4.06862497e-02f, -7.01107010e-02f, 2.64346730e-02f, -8.01091641e-02f, -1.12976514e-01f,
  -5.26396744e-02f, 5.69222495e-02f, -6.20082505e-02f, -5.40317856e-02f, -2.29848120e-02f, 5.89021994e-03f, -5.22521809e-02f, 6.81928098e-02f, 8.86449870e-03f, 3.32441665e-02f,
  4.02007774e-02f, -3.18751708e-02f, 3.64154615e-02f, 1.30673973e-02f, 2.05474254e-02f, -6.26443997e-02f, -6.56851828e-02f, 6.22053444e-02f, -1.62348314e-03f, 4.72094417e-02f,
  -3.09677869e-02f, -1.90946106e-02f, 5.61612025e-02f, -4.49696220e-02f, -6.84389398e-02f, -4.63085733e-02f, 1.56708565e-02f, 1.53563898e-02f, -2.73646042e-02f, -1.33323600e-03f,
  -2.13952631e-01f, 1.35047555e-01f, -7.68401101e-02f, -9.39335003e-02f, -2.93440535e-03f, -3.77655476e-02f, 5.43703549e-02f, 2.18799766e-02f, 6.07124940e-02f, 1.78772246e-03f,
  9.68592018e-02f, -7.49114454e-02f, -2.63507701e-02f, 2.60622650e-02f, -9.16270241e-02f, 6.57499880e-02f, -9.22047347e-02f, -1.00225210e-01f, 2.51297420e-03f, 5.09449467e-02f,
  -8.59148055e-02f, -1.20446570e-01f, -1.50416821e-01f, -4.84311394e-02f, -1.15491770e-01f, -9.59583148e-02f, -2.73412615e-02f, -1.05966032e-01f, -2.41799895e-02f, -1.59750819e-01f,
  -9.61015671e-02f, 7.27043599e-02f, -5.42260893e-02f, 1.01536967e-01f, 1.25011861e-01f, 1.63119078e-01f, 5.55290766e-02f, -2.15337183e-02f, 6.77146688e-02f, -4.06234013e-03f,
  1.39536500e-01f, -3.48192491e-02f, 5.78727461e-02f, -6.92443084e-03f, -6.37679994e-02f, 7.89067596e-02f, 3.89305949e-02f, -1.84147023e-02f, -1.95348654e-02f, -3.41132656e-02f,
  2.52502523e-02f, 2.89067649e-03f, -2.20050919e-03f, -8.30698609e-02f, 7.59054869e-02f, 3.42030567e-03f, 1.10861547e-01f, 6.82647303e-02f, 5.03227301e-02f, 1.10029005e-01f,
  -6.98129386e-02f, -1.00732192e-01f, -8.67038593e-02f, -7.96744451e-02f, 8.11788514e-02f, -1.59336060e-01f, 5.33155985e-02f, 6.27281144e-02f, -8.25028718e-02f, 3.98297086e-02f,
  1.11659974e-01f, 2.09048856e-02f, 1.31882224e-02f, -2.03466509e-02f, 4.56483588e-02f, 4.23369445e-02f, -1.22943781e-01f, -1.36346072e-01f, -1.27777457e-01f, -6.99272007e-02f,
  2.47028004e-02f, 7.52470493e-02f, 1.86790396e-02f, -9.51234810e-03f, -1.19830862e-01f, -8.20290819e-02f, 6.64293813e-03f, -8.21157768e-02f, -6.46536425e-03f, -1.61035359e-01f,
  -5.81096439e-03f, -6.51318207e-02f, -4.73380759e-02f, -2.71789432e-02f, -6.97609484e-02f, 4.13328856e-02f, -7.16441870e-02f, -4.66368310e-02f, 9.79163777e-03f, -3.84405442e-03f,
  -9.02262628e-02f, 3.36207263e-02f, -5.23488373e-02f, -8.05795267e-02f, 2.62186415e-02f, 9.61546004e-02f, 2.13909037e-02f, -3.56757753e-02f, 3.33509520e-02f, -6.66012391e-02f,
  5.32644428e-02f, 6.23688437e-02f, -9.54226702e-02f, 3.14762979e-03f, -2.68183202e-02f, 2.19905879e-02f, -5.90770505e-02f, -7.11556524e-02f, 2.00694636e-03f, -4.58867475e-02f,
  -7.93988705e-02f, 9.42606777e-02f, -1.32939368e-01f, -5.94312586e-02f, 2.95829903e-02f, 5.20521961e-02f, 2.76767779e-02f, -1.11636538e-02f, 6.09112121e-02f, -1.15550965e-01f,
  4.26337235e-02f, -7.55411759e-02f, 8.55998993e-02f, 2.98767611e-02f, -1.08064242e-01f, -1.00707458e-02f, 8.15374702e-02f, -2.96160076e-02f, -5.22647947e-02f, -2.15948354e-02f,
  5.80330892e-03f, -5.66847920e-02f, -2.27275817e-03f, -8.80430266e-02f, -5.79031482e-02f, -9.22442451e-02f, -1.30422851e-02f, -4.48960327e-02f, 1.14647737e-02f, -8.17840546e-02f,
  -6.49737865e-02f, -7.12846033e-03f, -9.00599360e-02f, 8.57083797e-02f, 6.40540048e-02f, -1.32011503e-01f, -1.24755479e-01f, -8.93287510e-02f, 4.58960533e-02f, -1.65832434e-02f,
  4.19435352e-02f, 8.85090157e-02f, 1.23445265e-01f, 2.65797246e-02f, -2.28300206e-02f, -6.82278723e-02f, -7.65090585e-02f, -5.45421354e-02f, 6.74804822e-02f, 2.12383736e-02f,
  1.15539253e-01f, -3.04682124e-02f, 6.10466711e-02f, 6.90912306e-02f, 1.01848029e-01f, 2.79651098e-02f, -4.68606353e-02f, -2.29209680e-02f, 4.86341044e-02f, 1.11886114e-01f,
  7.76537582e-02f, -1.04760855e-01f, 3.76494043e-03f, 1.42798731e-02f, 5.59025966e-02f, 2.95484532e-02f, -1.00566305e-01f, -6.14438169e-02f, 4.49631512e-02f, -1.01583436e-01f,
  2.84068193e-02f, -1.89856105e-02f, -4.41063605e-02f, 2.96421573e-02f, 6.93675876e-02f, -1.91390198e-02f, -5.09250015e-02f, -2.28544623e-02f, -1.08495101e-01f, -7.22587109e-02f,
  7.14044347e-02f, 6.25077933e-02f, -2.29057688e-02f, -1.22997798e-01f, -1.49645028e-03f, -9.16199237e-02f, -8.90840739e-02f, 3.65764499e-02f, -2.71598287e-02f, -1.78587846e-02f,
  -5.16184904e-02f, 5.08244112e-02f, 7.47802854e-03f, 5.97086847e-02f, -1.53202917e-02f, -3.10683772e-02f, 1.98565107e-02f, 2.68701203e-02f, 6.40303791e-02f, -3.00841462e-02f,
  5.80183417e-02f, 3.90977561e-02f, -5.41546047e-02f, 3.94519754e-02f, 6.92281350e-02f, 2.06553806e-02f, 6.45483136e-02f, 6.08645566e-02f, -7.57957920e-02f, 1.61939524e-02f,
  1.05164954e-02f, -9.29361880e-02f, 6.01716805e-03f, -2.08278256e-03f, -2.80659739e-02f, -7.85692930e-02f, -3.24291885e-02f, 8.85692537e-02f, 2.64894962e-02f, -1.37909111e-02f,
  6.80610314e-02f, 7.62491440e-03f, -9.02939662e-02f, 7.02069029e-02f, 6.77598119e-02f, -6.41890243e-02f, -6.99426234e-02f, -5.99371754e-02f, -8.31852574e-03f, -5.28074093e-02f,
  -1.04644731e-01f, 7.00161308e-02f, 6.19984865e-02f, -4.47435714e-02f, 1.92669109e-02f, -4.15249504e-02f, -9.32586193e-02f, 3.08316518e-02f, 3.16492878e-02f, -9.68346968e-02f,
  -6.03388660e-02f, -3.42866518e-02f, -9.08524692e-02f, -2.99493168e-02f, -6.14801161e-02f, -1.50614548e-02f, -1.14926055e-01f, -1.05813526e-01f, -2.10238551e-03f, -1.08805522e-01f,
  -4.74725943e-03f, -1.15787700e-01f, 9.32831764e-02f, 1.02549665e-01f, 1.82431471e-02f, -1.28977224e-01f, -2.47815251e-01f, -1.46424055e-01f, 2.50112936e-02f, 1.12333549e-02f,
  -1.19245034e-02f, 6.52045086e-02f, 4.63668481e-02f, -4.87190001e-02f, -2.34335750e-01f, -1.41795725e-01f, 8.06328654e-03f, -1.23703949e-01f, -2.22547174e-01f, -2.17539757e-01f,
  -2.02911004e-01f, -6.90331310e-02f, -1.63260728e-01f, -1.21648036e-01f, 8.01937431e-02f, -1.93971712e-02f, 1.60617203e-01f, 1.09918825e-01f, -5.53478189e-02f, 1.46380141e-01f,
  -7.41570909e-03f, 4.95881140e-02f, 3.95744257e-02f, -9.38549116e-02f, -1.44484630e-02f, -7.80795980e-03f, -5.25084361e-02f, 7.79967383e-02f, 3.52915265e-02f, -4.66234563e-03f,
  -5.24502024e-02f, 2.30345391e-02f, 9.64132976e-03f, 1.61375559e-03f, 1.82557125e-02f, -6.96451217e-02f, -4.17995565e-02f, -9.74185690e-02f, 8.13668035e-03f, 1.16759157e-02f,
  -7.20870495e-02f, -5.84294312e-02f, -3.39099765e-02f, -6.07703812e-02f, 5.91420010e-02f, -4.75540431e-03f, 2.19861437e-02f, 4.48601842e-02f, 4.97836098e-02f, -6.72021434e-02f,
  -2.85655987e-02f, 1.20225819e-02f, 4.27950965e-03f, 5.84124923e-02f, -5.38047813e-02f, 1.36831179e-02f, -2.80260686e-02f, 2.41399333e-02f, -9.25240573e-03f, -1.63706746e-02f,
  1.30580990e-02f, 1.50631266e-02f, 1.82154234e-02f, 8.38862211e-02f, -1.26143768e-02f, 2.12744670e-03f, 5.62001169e-02f, -3.85658666e-02f, -2.31387056e-02f, -8.27539936e-02f,
  8.75003859e-02f, 3.57337259e-02f, 7.74010867e-02f, -3.70734110e-02f, -1.90383140e-02f, -6.65834099e-02f, -7.68866614e-02f, -3.14594023e-02f, -7.22370446e-02f, -8.64087418e-02f,
  1.30269945e-01f, -1.10648312e-01f, 4.38508876e-02f, 3.76799889e-02f, 8.02526847e-02f, -1.85719673e-02f, -2.62543224e-02f, -3.25986668e-02f, 1.18836112e-01f, -7.55294114e-02f,
  -4.51977178e-02f, -3.79626378e-02f, 4.45351340e-02f, -4.17666323e-02f, -1.44846141e-01f, -7.73339719e-02f, -1.52294084e-01f, -5.80551662e-02f, -3.59547958e-02f, 2.44088955e-02f,
  -1.29200399e-01f, -7.91367292e-02f, -1.26398116e-01f, 4.36237231e-02f, 2.05937941e-02f, 5.19134663e-02f, 1.74336284e-02f, -1.07266717e-02f, 3.64276320e-02f, -9.41418558e-02f,
  2.10353360e-01f, 1.72268331e-01f, -9.15022045e-02f, -1.94697711e-03f, -6.48154989e-02f, -1.26163334e-01f, 2.70770229e-02f, 1.01455320e-02f, -5.08105010e-02f, 5.73778339e-03f,
  -6.15364052e-02f, -4.41421866e-02f, 2.17963960e-02f, 3.56022604e-02f, 3.99796292e-02f, 9.12401751e-02f, -3.31513770e-02f, -6.77299649e-02f, -5.98740345e-03f, 6.78645298e-02f,
  1.14324681e-01f, 8.92639160e-02f, 7.13252798e-02f, 4.41839881e-02f, 1.23975851e-01f, -1.62872933e-02f, -1.08005302e-02f, 1.47752874e-02f, 6.19030222e-02f, 9.17863473e-02f,
  -8.30602944e-02f, 2.13861279e-02f, 4.47797962e-02f, 6.09179996e-02f, -1.00534864e-01f, 7.93740824e-02f, -3.42741720e-02f, -9.32584852e-02f, 3.16450335e-02f, -7.44299963e-02f,
  -5.40261865e-02f, 4.33165990e-02f, -6.76351935e-02f, 1.09726768e-02f, -9.26653072e-02f, 5.53010665e-02f, -9.03290287e-02f, 1.74590927e-02f, -2.15007998e-02f, -8.31948295e-02f,
  5.83821945e-02f, 3.81303318e-02f, 3.79877351e-02f, -4.53646621e-03f, -4.60988730e-02f, 1.30150234e-02f, -9.39858630e-02f, -6.22823052e-02f, 6.14479780e-02f, 6.71993196e-02f,
  -1.71027537e-02f, 1.93154458e-02f, -5.55208735e-02f, -2.25315876e-02f, -1.37243979e-02f, 6.13648221e-02f, -9.08101276e-02f, -3.27115087e-03f, -2.82686539e-02f, -5.07006198e-02f,
  -5.40356226e-02f, 2.98159290e-02f, -5.47927571e-03f, -7.12369755e-02f, -1.99273340e-02f, -7.09319189e-02f, 4.97219190e-02f, -1.44486222e-02f, -9.82594565e-02f, -6.50989115e-02f,
  4.41983677e-02f, -5.93656637e-02f, 2.27703247e-02f, -1.10123247e-01f, -7.15883374e-02f, -1.02542624e-01f, 6.00971049e-03f, -2.27773618e-02f, 3.57443504e-02f, 8.45292136e-02f,
  2.71870140e-02f, -1.74310967e-01f, 1.34666532e-01f, 5.55408299e-02f, -3.21178921e-02f, 1.83159355e-02f, 4.19100896e-02f, 9.48627815e-02f, 5.28046302e-02f, -2.85929590e-02f,
  -4.77188490e-02f, -3.88853811e-02f, -6.05662279e-02f, -5.41101024e-03f, 1.51394773e-03f, -1.98561326e-03f, -2.94854515e-03f, -5.37123866e-02f, -7.05279186e-02f, -7.30093792e-02f,
  -5.50141037e-02f, 8.26644525e-02f, -6.19192235e-02f, -8.75175148e-02f, 9.83632170e-03f, 8.80875066e-02f, 1.30481999e-02f, 3.38144675e-02f, -1.02624893e-02f, 1.15386337e-01f,
  1.04441039e-01f, -2.40248665e-02f, 8.86857435e-02f, 7.99223110e-02f, 1.21608511e-01f, 1.96608156e-01f, 1.53100595e-01f, 2.29603285e-03f, -6.53611943e-02f, 1.53628523e-02f,
  7.61700347e-02f, -1.10313743e-01f, -2.51037925e-02f, -4.32835668e-02f, 3.68327492e-05f, -7.40622208e-02f, 4.51456904e-02f, -4.72557843e-02f, 5.77439517e-02f, 9.43845436e-02f,
  -1.78826898e-02f, -7.21188262e-02f, 2.56114863e-02f, -3.35970409e-02f, -1.29487976e-01f, -7.43559748e-02f, -3.81087996e-02f, 1.06226563e-01f, 1.14598675e-02f, -6.37241974e-02f,
  -2.44198106e-02f, 7.52320513e-02f, 4.51093987e-02f, -3.37175163e-03f, 1.02294713e-01f, -3.67993899e-02f, -6.08513281e-02f, 2.59906221e-02f, 8.59670490e-02f, 4.66066971e-02f,
  -2.97438372e-02f, 8.76649171e-02f, 7.29923099e-02f, -9.81694907e-02f, 3.32959592e-02f, 3.00040655e-02f, 1.36130834e-02f, -8.31710100e-02f, -1.84635222e-02f, -6.95483163e-02f,
  -5.77031784e-02f, 6.14489913e-02f, 8.68795291e-02f, 5.24129532e-02f, -4.79273945e-02f, -8.78300220e-02f, -4.53060940e-02f, 5.07548898e-02f, 1.40557177e-02f, -6.02513216e-02f,
  -1.52743924e-02f, 3.85360979e-02f, 9.38635543e-02f, 5.69949970e-02f, 4.76198271e-02f, -2.08023395e-02f, -9.92674753e-03f, -8.79439265e-02f, 2.40820851e-02f, 4.24958542e-02f,
  -3.09546348e-02f, 4.42372188e-02f, -2.79110223e-02f, -7.52340630e-02f, 4.58733924e-02f, -3.35127376e-02f, -1.91284379e-03f, -5.08709885e-02f, -9.08249095e-02f, -9.31964591e-02f,
  -6.37767091e-02f, -9.38747898e-02f, 5.33012785e-02f, -2.45556002e-03f, -4.45616879e-02f, -1.05814300e-01f, -6.80161193e-02f, 6.84385076e-02f, -7.85037596e-03f, -8.01853165e-02f,
  -1.73910066e-01f, 1.28293961e-01f, -1.25965908e-01f, -6.84177503e-02f, 2.60979030e-02f, -3.60630676e-02f, -2.97894198e-02f, -7.11975247e-02f, -4.60285880e-03f, -3.67939174e-02f,
  1.58345662e-02f, -8.85968581e-02f, -5.94428107e-02f, -9.81241688e-02f, 5.26469126e-02f, -4.10686024e-02f, 1.29766273e-03f, -2.98391096e-02f, -9.09686461e-02f, 8.11049268e-02f,
  1.50262127e-02f, -3.26491743e-02f, 7.23237395e-02f, 6.37840480e-02f, -5.50660007e-02f, 5.21922065e-03f, 1.08764255e-02f, 2.15830877e-02f, -2.17475183e-02f, -4.48037013e-02f,
  1.54038504e-01f, 4.21138257e-02f, 6.18665479e-03f, 3.73533182e-02f, 4.03937101e-02f, 1.46486908e-01f, 3.67530845e-02f, -1.25861373e-02f, -2.11352686e-04f, 1.13392338e-01f,
  4.29918803e-02f, 1.86040118e-01f, 1.57113761e-01f, 1.30672663e-01f, 6.25201985e-02f, 5.54323792e-02f, 1.37142371e-04f, -4.72279452e-02f, 1.03999190e-01f, 9.05332789e-02f,
  7.17523769e-02f, -1.05661176e-01f, -6.87950775e-02f, -4.62678298e-02f, 6.35099187e-02f, -7.92225599e-02f, -1.50587782e-02f, 6.06081523e-02f, 5.56287095e-02f, -8.11171457e-02f,
  7.27420673e-02f, 8.44684392e-02f, 2.16603130e-02f, 5.54443672e-02f, -9.91767738e-03f, -4.81073968e-02f, -1.14598917e-02f, -3.82678322e-02f, 3.33679914e-02f, -3.31280008e-02f,
  7.12064430e-02f, -9.11841076e-03f, 5.92162125e-02f, 2.91307271e-02f, 6.60021156e-02f, 4.13578451e-02f, 5.45878597e-02f, 1.60867032e-02f, -2.53323391e-02f, -6.54061288e-02f,
  -1.08817294e-02f, -1.07515482e-02f, -8.28740969e-02f, -7.28064403e-02f, -1.66650470e-02f, -3.60967219e-02f, 2.37344839e-02f, 4.96663004e-02f, -1.01206601e-01f, 7.19257584e-03f,
  4.44569741e-04f, 3.71655193e-03f, 3.42440954e-03f, 5.64466882e-03f, -1.15993386e-02f, -9.94419828e-02f, 1.85518488e-02f, 6.63381815e-02f, 9.29985121e-02f, -9.51687247e-02f,
  8.13681036e-02f, 1.07107041e-02f, 2.41787918e-02f, -3.37889008e-02f, -2.36196145e-02f, -9.24600065e-02f, 1.11938966e-02f, 7.51904249e-02f, -5.68937883e-02f, 3.62734161e-02f,
  4.03934047e-02f, -7.24753290e-02f, 1.98884718e-02f, 8.84575546e-02f, 7.50626028e-02f, 4.43530865e-02f, -4.40364592e-02f, 7.24291727e-02f, -1.98971853e-03f, -2.66029760e-02f,
  -8.47946182e-02f, 1.07412644e-01f, 8.21728632e-02f, -6.08667172e-02f, -3.01092677e-02f, -3.93937677e-02f, -6.59148917e-02f, -1.01251870e-01f, 2.35504340e-02f, -6.37717843e-02f,
  -4.59525585e-02f, 3.19610466e-03f, -5.63746179e-03f, -1.06041156e-01f, 1.88514888e-02f, 5.81850344e-03f, 2.49245018e-02f, -6.23944029e-02f, -8.65742415e-02f, -9.64590833e-02f,
  -5.61907887e-02f, -1.01432875e-01f, 2.74065919e-02f, -8.59835744e-02f, -7.93833733e-02f, 4.62137870e-02f, -8.76913592e-02f, -3.24468222e-03f, 6.46202341e-02f, -2.17716433e-02f,
  1.66092943e-02f, 9.45567712e-02f, -2.18259823e-02f, -5.14369132e-03f, 5.93517274e-02f, -4.80291545e-02f, -6.81682900e-02f, -2.84769703e-02f, 1.47436941e-02f, 2.02120002e-02f,
  3.87157537e-02f, 4.05487232e-02f, -1.44524500e-02f, 8.09942111e-02f, 7.87702799e-02f, 4.30558696e-02f, -5.49854301e-02f, -1.24516571e-03f, 3.72310877e-02f, -7.36948922e-02f,
  6.13776706e-02f, 1.68521336e-04f, -2.48169675e-02f, 4.74764071e-02f, -8.84359889e-03f, -5.28611839e-02f, 7.97787905e-02f, 7.73716271e-02f, -1.64332371e-02f, 1.20574851e-02f,
  8.81972611e-02f, -3.10934074e-02f, -8.12117457e-02f, -7.19281733e-02f, 7.34348595e-02f, 1.66201182e-02f, 1.15801785e-02f, 2.22416110e-02f, -1.02311134e-01f, -9.48399827e-02f,
  2.19436623e-02f, -8.05302858e-02f, 4.46980372e-02f, -5.11758588e-02f, -1.13048933e-01f, 4.34264168e-02f, -6.31663054e-02f, -7.50492066e-02f, -7.77546838e-02f, 2.71440148e-02f,
  5.52104414e-02f, -1.03407288e-02f, -1.65453088e-02f, 2.13679895e-02f, -3.01392600e-02f, 3.28026004e-02f, 7.03703389e-02f, 4.94067557e-02f, -5.92826568e-02f, -9.28577557e-02f,
  -6.29896522e-02f, -1.07092693e-01f, -5.87532483e-02f, 1.56349465e-02f, -6.96792081e-03f, 4.18115668e-02f, -1.84541810e-02f, -5.40530533e-02f, -5.41530363e-03f, -9.29197893e-02f,
  -8.02259967e-02f, -4.72671427e-02f, -7.59951696e-02f, -1.16371475e-02f, -2.34829951e-02f, 2.44183931e-02f, -7.27321059e-02f, -1.70138609e-02f, 5.64219728e-02f, -6.01084530e-03f,
  -6.37810454e-02f, -5.54507971e-02f, -3.89127471e-02f, -8.00442770e-02f, -8.71802494e-02f, 1.14235282e-02f, -6.30264357e-02f, -9.39044729e-02f, -8.17397907e-02f, -8.27718079e-02f,
  3.20367552e-02f, -4.29890640e-02f, -2.35862355e-03f, -6.03572652e-02f, 7.01688007e-02f, 1.15518700e-02f, -5.95148429e-02f, -4.33532894e-02f, -3.29439752e-02f, 5.20725697e-02f,
  2.98523698e-02f, 3.36740576e-02f, 6.10244907e-02f, 6.41447008e-02f, 5.19239195e-02f, -8.32340345e-02f, 6.03540242e-02f, 1.64326597e-02f, -1.17347855e-02f, -7.65167410e-03f,
  -1.56805117e-03f, -2.01134793e-02f, -7.48286396e-02f, -9.97199491e-03f, 4.52177003e-02f, 5.28253019e-02f, 1.09059010e-02f, 4.01738519e-03f, -2.53578555e-02f, 4.42347340e-02f,
  1.77025497e-01f, 2.56680161e-01f, 1.53229728e-01f, 1.11851715e-01f, -1.35119846e-02f, 8.72821063e-02f, 1.79771692e-01f, 7.22754002e-03f, 2.01418046e-02f, 1.11800559e-01f,
  9.26047098e-04f, -3.77191491e-02f, 5.91589175e-02f, -2.40200059e-03f, 3.27071734e-02f, 1.65171564e-01f, 5.60444444e-02f, 4.42919247e-02f, 7.39443898e-02f, 1.39758885e-01f,
  2.64687743e-02f, 6.41468074e-03f, 1.68676879e-02f, 4.54388652e-03f, 1.55139402e-01f, 1.99201815e-02f, 1.09998412e-01f, -1.91146880e-02f, 1.35513157e-01f, 1.85675934e-01f,
  7.13911653e-02f, 1.11320406e-01f, -6.43168092e-02f, -3.00437305e-02f, -8.71796981e-02f, -5.31266183e-02f, 1.72703601e-02f, 4.17406783e-02f, -3.48545378e-03f, 1.88806262e-02f,
  -6.43726736e-02f, -8.16529915e-02f, 2.76069436e-02f, 2.37483550e-02f, 1.06553296e-02f, 1.13739399e-02f, 4.68078703e-02f, -1.47161195e-02f, -6.43188134e-02f, -4.96589690e-02f,
  3.67478058e-02f, -3.41949388e-02f, -5.80061637e-02f, -6.38746694e-02f, -1.86429378e-02f, 8.60314630e-03f, -4.43968661e-02f, 2.39423960e-02f, -5.95137402e-02f, 2.14002058e-02f,
  -6.55302405e-02f, -1.96173638e-02f, 6.94895163e-02f, 1.02164648e-01f, -9.34261084e-03f, 8.39780122e-02f, -4.71524261e-02f, -2.19265930e-02f, 1.06547680e-02f, -1.72734503e-02f,
  8.18168446e-02f, 3.88677008e-02f, 5.05319275e-02f, -2.50438098e-02f, -5.49990274e-02f, 1.96317118e-02f, -1.02315389e-04f, -3.77906151e-02f, 9.80625898e-02f, -1.88931786e-02f,
  -4.54547815e-02f, 6.78344741e-02f, -7.33456463e-02f, 3.73563617e-02f, 4.74328808e-02f, -4.82841432e-02f, 5.29976301e-02f, -5.41047640e-02f, -2.31120456e-02f, 5.75485229e-02f,
  -2.07456127e-01f, -1.97599947e-01f, 4.25872905e-03f, -4.45360737e-03f, -9.11054611e-02f, 1.32598318e-02f, 8.88323877e-03f, 2.20256224e-02f, -5.53363673e-02f, 9.72178057e-02f,
  4.06041704e-02f, -3.16457152e-02f, 7.95316473e-02f, 6.47759885e-02f, -1.27803665e-02f, -3.76105942e-02f, -3.85192633e-02f, 4.01738435e-02f, 3.34339067e-02f, -7.94387236e-02f,
  -3.03877965e-02f, -1.33772567e-01f, -8.51901844e-02f, -1.39178380e-01f, -1.19062304e-01f, -1.03859268e-01f, -7.49566853e-02f, -1.21289566e-01f, -6.97437450e-02f, -1.15416557e-01f,
  -1.18322760e-01f, 4.60349694e-02f, -1.29882082e-01f, -4.08182219e-02f, -1.33136353e-02f, 3.52632883e-03f, 9.08028558e-02f, -2.99424287e-02f, -2.97323745e-02f, 2.73579918e-02f,
  1.38264690e-02f, -5.38267158e-02f, -1.09289192e-01f, -2.96235159e-02f, -2.35943124e-02f, 4.91540618e-02f, -3.90585437e-02f, -1.66966319e-01f, -1.40734866e-01f, -2.93057412e-02f,
  -1.12145372e-01f, -1.23739250e-01f, -2.15049028e-01f, -1.52586773e-01f, 1.13608586e-02f, -2.88795829e-02f, -2.05205586e-02f, -5.98883256e-02f, -8.41552466e-02f, -7.17998669e-02f,
  7.53121749e-02f, 9.24394727e-02f, -5.14662685e-03f, -1.05934031e-01f, 1.65565927e-02f, -8.79382789e-02f, 5.67829646e-02f, -4.72814441e-02f, -7.77444765e-02f, 7.24034384e-02f,
  -3.98243181e-02f, -1.27852587e-02f, 3.60609754e-03f, 7.65858069e-02f, 1.56506859e-02f, 1.82082411e-02f, 1.96866207e-02f, 3.95989828e-02f, -5.45262061e-02f, -3.76059823e-02f,
  -7.87884071e-02f, -1.03132933e-01f, 2.33792863e-03f, -3.17214504e-02f, 4.34277542e-02f, -7.10828826e-02f, -7.48346793e-03f, 5.85670546e-02f, 1.49244787e-02f, 7.27865994e-02f,
  4.10322696e-02f, -7.77211487e-02f, 7.50241503e-02f, -7.19031766e-02f, 5.04833786e-03f, -2.55581737e-02f, 2.21400871e-03f, 3.14247459e-02f, 7.49908909e-02f, 9.18723550e-03f,
  3.94107029e-02f, -5.96986525e-03f, 3.73865739e-02f, -1.52371991e-02f, 8.02394524e-02f, -4.82209865e-03f, 8.53167921e-02f, -4.71953563e-02f, -9.25113484e-02f, 7.80115873e-02f,
  4.88258712e-02f, 1.43677080e-02f, -4.38406542e-02f, -1.07063865e-02f, -2.14391053e-02f, 6.25083447e-02f, 2.59253457e-02f, 3.82998809e-02f, 1.40470860e-03f, 1.29609797e-02f,
  2.43804771e-02f, -1.27563655e-01f, 4.56947498e-02f, 1.80139039e-02f, -5.95293939e-02f, -4.77685891e-02f, -6.11828640e-02f, -6.38981611e-02f, 1.55351041e-02f, -9.53660831e-02f,
  -1.63096897e-02f, 1.85787566e-02f, -9.83732492e-02f, -9.30246189e-02f, -5.72290272e-02f, 5.17403074e-02f, -8.97413418e-02f, -4.26639840e-02f, -5.74620217e-02f, 6.42249286e-02f,
  -1.15925744e-01f, -1.77390389e-02f, -1.56512275e-01f, -3.71809341e-02f, 2.87897289e-02f, -8.61817896e-02f, -9.64797810e-02f, -3.15254275e-03f, -9.30816382e-02f, -2.76685674e-02f,
  2.38542512e-01f, -1.53163210e-01f, -3.28050077e-01f, -2.69838125e-02f, -1.21356323e-01f, -9.94028002e-02f, -1.68377757e-01f, -8.63534287e-02f, 5.61152995e-02f, -1.18403219e-01f,
  -1.14273243e-01f, 8.13924447e-02f, -8.01508054e-02f, -1.00821950e-01f, 7.78395087e-02f, -2.00635433e-01f, -2.15269908e-01f, -1.21361792e-01f, -4.13157344e-02f, 9.47309136e-02f,
  -2.82836314e-02f, 4.37684655e-02f, 1.38583586e-01f, -4.44272906e-03f, -1.38140813e-01f, -6.10665642e-02f, -1.64900258e-01f, -7.10338950e-02f, -9.76033658e-02f, -1.05682872e-01f,
  -2.94842035e-01f, 7.39109528e-04f, 7.16894791e-02f, 5.22066951e-02f, -6.22472074e-03f, -3.41220386e-02f, -6.58481047e-02f, 5.36751933e-02f, 1.01195842e-01f, -1.30093336e-01f,
  -4.80553396e-02f, 7.28301331e-02f, 4.12835106e-02f, -2.51802839e-02f, -5.97182661e-02f, 3.44408490e-02f, -6.42472953e-02f, -6.57505840e-02f, 4.38686274e-02f, -8.72302130e-02f,
  -9.69222486e-02f, 2.52136122e-02f, -7.35246837e-02f, -9.16664824e-02f, 2.87773293e-02f, -4.60161380e-02f, -9.39886644e-02f, 1.85890887e-02f, 2.69104578e-02f, -9.07832682e-02f,
  3.55226658e-02f, -5.81919588e-02f, -1.28081571e-02f, -9.99894645e-03f, -6.16058558e-02f, 5.66475578e-02f, 1.92125924e-02f, -5.61199076e-02f, 8.22514370e-02f, 9.66762081e-02f,
  7.08974004e-02f, 3.74969877e-02f, -4.61668037e-02f, 4.92120199e-02f, 4.34919521e-02f, -3.99059169e-02f, 7.19480813e-02f, 9.67627857e-03f, -1.11261355e-02f, 8.56364239e-03f,
  3.53508554e-02f, -1.56056406e-02f, 1.59579776e-02f, 6.76034763e-02f, -7.54835978e-02f, -2.27205995e-02f, 7.29145780e-02f, 8.19289833e-02f, -2.62505151e-02f, 8.14999491e-02f,
  1.04298897e-01f, 5.36984354e-02f, 3.46986130e-02f, 1.17056690e-01f, -7.90847540e-02f, 6.36413917e-02f, -1.71613581e-02f, 7.82383531e-02f, -1.83477886e-02f, 4.73270752e-02f,
  2.66837496e-02f, 9.20804366e-02f, 1.37818679e-02f, 8.90890323e-03f, 3.17233652e-02f, 3.56842354e-02f, -3.25130448e-02f, -3.32803605e-03f, -2.27996055e-03f, -3.33016217e-02f,
  -2.61222087e-02f, 1.43476665e-01f, 1.31549552e-01f, -2.92309988e-02f, -1.05030797e-02f, 1.03363976e-01f, -7.26045445e-02f, 4.71429713e-03f, -2.59375107e-02f, 1.39675885e-01f,
  -8.09157044e-02f, -6.55539781e-02f, 8.99080634e-02f, -1.78442020e-02f, 2.09971070e-02f, 5.33735342e-02f, -4.85058986e-02f, 6.47147670e-02f, 7.67685194e-03f, -1.62603483e-02f,
  7.76872113e-02f, 9.78624523e-02f, 4.71024550e-02f, -5.01007102e-02f, 6.68527037e-02f, -6.30524531e-02f, -4.40025367e-02f, -3.91146280e-02f, -9.06430334e-02f, -6.70399442e-02f,
  -3.60219702e-02f, -2.38213595e-02f, -7.23321587e-02f, 3.80414873e-02f, 4.18799091e-03f, 1.13010395e-03f, -5.33220805e-02f, 6.36915714e-02f, 5.52893095e-02f, -1.18353367e-01f,
  2.21728534e-01f, 3.63732204e-02f, -6.90831468e-02f, -6.16550632e-02f, 3.66207398e-02f, -9.66915488e-02f, 9.84655693e-03f, 3.34867798e-02f, 1.32655231e-02f, 7.05497637e-02f,
  3.33496146e-02f, 3.54061555e-03f, 3.55908498e-02f, 5.21788038e-02f, -7.32940733e-02f, 2.28802790e-04f, -1.17672376e-01f, -1.18367992e-01f, -1.56799275e-02f, -4.01412174e-02f,
  -6.55644685e-02f, 5.26445769e-02f, -1.59221385e-02f, -4.15339731e-02f, 1.95983257e-02f, 5.63293919e-02f, 3.89595293e-02f, 1.99258383e-02f, -9.93771628e-02f, -8.23574439e-02f,
  4.43770736e-02f, 6.97532371e-02f, -3.99991609e-02f, 3.50584351e-02f, 2.30376981e-02f, 7.38627464e-02f, -7.59430677e-02f, 3.55017111e-02f, 7.94321671e-02f, -2.84175649e-02f,
  -3.45763303e-02f, -3.68797295e-02f, -3.86485755e-02f, -7.47635514e-02f, -8.91537070e-02f, 2.42023077e-02f, 4.59407605e-02f, -1.03602428e-02f, -1.48332794e-03f, -4.23955806e-02f,
  -7.15721026e-02f, 7.18944520e-02f, -6.70347288e-02f, -5.68635799e-02f, 1.18337274e-02f, -4.88451496e-02f, 1.70360925e-03f, -7.07468241e-02f, 6.36288077e-02f, 6.03250228e-02f,
  9.75361466e-02f, 5.52170388e-02f, 8.29854310e-02f, 5.53372875e-02f, 1.82161126e-02f, -4.04279009e-02f, -6.37273490e-02f, -2.80990973e-02f, 7.83497060e-04f, 6.78523928e-02f,
  7.08243763e-03f, 1.73585396e-02f, 1.10977642e-01f, 7.70858228e-02f, -6.62367046e-02f, -6.25586882e-02f, -7.30033293e-02f, -5.97853623e-02f, -6.85816109e-02f, -9.60236788e-02f,
  -6.72365874e-02f, -3.76730859e-02f, 1.54459709e-02f, 9.08640847e-02f, -5.66322617e-02f, -6.18076026e-02f, 1.33549705e-01f, -4.09578159e-02f, 1.15335755e-01f, 3.96086536e-02f,
  8.10611248e-03f, 9.65252519e-02f, -8.59771743e-02f, -2.36585066e-02f, -3.08358502e-02f, -1.69816807e-01f, -8.56800601e-02f, 5.24297878e-02f, 2.96698622e-02f, -2.24446021e-02f,
  1.04987741e-01f, 4.12856340e-02f, -2.38216911e-02f, -6.32546321e-02f, -1.29376069e-01f, -1.31134465e-02f, -7.57707879e-02f, -1.13944180e-01f, -2.05394208e-01f, -1.83264807e-01f,
  -1.27674341e-01f, -1.03205077e-01f, -1.39963344e-01f, -4.18351078e-03f, -5.09650968e-02f, 6.56048357e-02f, 6.59491960e-03f, -1.06710896e-01f, -1.07424401e-01f, 7.94695914e-02f,
  -1.07343838e-01f, 2.07112636e-02f, -5.44943847e-02f, 6.83063567e-02f, 1.70650557e-02f, -4.45338562e-02f, -3.86602432e-02f, 1.06007248e-01f, 6.94143549e-02f, 4.45376448e-02f,
  1.47523992e-02f, 2.57815979e-03f, 6.73028529e-02f, 6.23453148e-02f, -1.89717226e-02f, -5.78354225e-02f, 5.11271656e-02f, -3.91835943e-02f, -3.78251858e-02f, -8.30866396e-03f,
  1.00585729e-01f, 3.75154987e-02f, 1.13311574e-01f, 1.09543160e-01f, -1.60924457e-02f, 3.61851952e-03f, 6.66166171e-02f, 6.13581836e-02f, 4.46752273e-02f, -6.67785015e-03f,
  8.60506520e-02f, -2.75460631e-03f, -7.01601729e-02f, 5.38900904e-02f, -7.52121136e-02f, 8.99814218e-02f, 9.36283767e-02f, -4.51803468e-02f, -5.31181209e-02f, -5.84112713e-03f,
  7.21714199e-02f, -3.31039615e-02f, -4.44903150e-02f, 4.59735245e-02f, -9.83608887e-03f, -4.97226454e-02f, -6.81512654e-02f, 6.80475459e-02f, -4.36358824e-02f, 7.86126107e-02f,
  2.08483655e-02f, -5.77715077e-02f, 4.97850664e-02f, 3.75138596e-02f, 6.00742325e-02f, -3.97694148e-02f, -6.34038672e-02f, 2.70904712e-02f, 4.50304970e-02f, -5.06825596e-02f,
  9.51815918e-02f, -5.43126613e-02f, -3.12120817e-03f, -2.11536344e-02f, -3.00696995e-02f, -1.57206170e-02f, 3.06271482e-02f, -8.47045109e-02f, -2.02748887e-02f, 4.42272425e-02f,
  -1.00611866e-01f, -6.68086037e-02f, 7.51754045e-02f, 5.17044142e-02f, -2.90033687e-02f, -1.07556239e-01f, 7.90702477e-02f, 3.24689150e-02f, -3.63368429e-02f, 2.44802423e-02f,
  9.04806703e-02f, 7.81023428e-02f, 1.15063861e-02f, 4.08914611e-02f, 8.32300112e-02f, -7.58101698e-03f, 5.35912998e-02f, 6.85703084e-02f, 7.73790479e-03f, 5.55849299e-02f,
  -1.68014660e-01f, -3.17590982e-02f, -6.85035661e-02f, -2.38942102e-01f, -2.17452824e-01f, -4.43548486e-02f, -1.26577197e-02f, -4.12168913e-02f, -1.11082554e-01f, -3.66523899e-02f,
  -4.77139316e-02f, -8.57351050e-02f, 2.38059592e-02f, 4.60482128e-02f, -1.15890168e-02f, 3.06183416e-02f, -1.33817762e-01f, -6.99282736e-02f, -1.42070562e-01f, -1.71404451e-01f,
  -1.48451775e-01f, -1.23401955e-01f, -8.28281939e-02f, -5.59809841e-02f, -1.56764537e-01f, -6.94840252e-02f, -1.10682927e-01f, -2.60503758e-02f, 4.53291312e-02f, -1.04443319e-01f,
  -4.49306518e-02f, -6.13172129e-02f, -8.49831104e-02f, -3.77227515e-02f, -2.04796959e-02f, -6.48554415e-02f, 5.95057905e-02f, -3.13440748e-02f, 7.65360072e-02f, -8.00095126e-02f,
  -1.77020077e-02f, -7.46642798e-02f, -2.78143566e-02f, -7.93967098e-02f, -5.60603775e-02f, -6.52407408e-02f, -2.22528111e-02f, 6.11319691e-02f, -1.84094179e-02f, -6.99606091e-02f,
  7.21657500e-02f, 9.35514644e-02f, 8.65864679e-02f, 1.05219200e-01f, 4.96891141e-02f, 1.13938726e-01f, -4.01429236e-02f, 7.97093213e-02f, 3.89383920e-02f, -1.17947467e-01f,
  -7.95114264e-02f, 7.19293654e-02f, 4.16003689e-02f, -2.93868501e-03f, -4.57137451e-03f, 2.64822897e-02f, 1.99919823e-03f, -2.63622049e-02f, -7.58132264e-02f, -4.41762917e-02f,
  3.33014689e-02f, -5.72335422e-02f, 2.69402452e-02f, 6.33864254e-02f, 3.07759847e-02f, -5.29298484e-02f, 3.68963405e-02f, 2.92930696e-02f, -3.84426452e-02f, 8.84316415e-02f,
  1.20387308e-01f, 1.45226819e-02f, 2.06820574e-02f, -2.35959515e-02f, 3.81510556e-02f, -2.55789086e-02f, 8.23952556e-02f, 5.35887145e-02f, 6.44323602e-02f, -2.48019141e-03f,
  -9.12632644e-02f, 1.64904863e-01f, -2.83269472e-02f, -9.88900661e-03f, 8.75812173e-02f, -2.68291198e-02f, -6.51491582e-02f, -8.84835841e-04f, -6.17238916e-02f, -1.07109517e-01f,
  8.92015994e-02f, 7.09700584e-02f, -1.69519465e-02f, 2.28126273e-02f, -8.61679092e-02f, 5.67227155e-02f, 6.23244904e-02f, 3.78874913e-02f, 1.16353177e-01f, 7.32743228e-03f,
  -2.72178035e-02f, 9.53988954e-02f, 1.21321328e-01f, 2.88835466e-02f, 1.14319600e-01f, 1.36797920e-01f, -4.07011285e-02f, 5.52552752e-02f, 2.86192540e-02f, 4.06418666e-02f,
  -1.43575951e-01f, 1.41025886e-01f, 1.07491128e-01f, 2.38980204e-02f, 1.48932517e-01f, 1.57552898e-01f, 2.40167260e-01f, -1.98246259e-02f, -7.87568092e-02f, -2.28008605e-03f,
  7.03640208e-02f, 8.06156546e-02f, 1.36655159e-02f, -4.05163988e-02f, -2.63459608e-02f, -3.91246118e-02f, 6.25952035e-02f, -1.82690285e-02f, 1.90019943e-02f, -6.33159205e-02f,
  5.96188903e-02f, -8.31552297e-02f, -1.21040329e-01f, 3.21436971e-02f, 8.14030468e-02f, -7.71825835e-02f, 8.41526836e-02f, 8.58521163e-02f, -6.86599035e-03f, -8.52359273e-03f,
  -2.69088428e-02f, 2.00288128e-02f, -1.07862882e-01f, -6.08570389e-02f, -5.01818489e-04f, 4.02150303e-03f, -3.04995943e-02f, -3.49505655e-02f, 7.31844530e-02f, -3.69645134e-02f,
  -3.74429040e-02f, -6.55607060e-02f, 8.63291025e-02f, -2.76495479e-02f, -6.28394932e-02f, 2.89638359e-02f, -4.22399528e-02f, 1.71598811e-02f, -1.55735128e-02f, 5.60972700e-03f,
  1.04905918e-01f, 5.52525371e-02f, 1.34597123e-01f, 8.69489182e-03f, 2.17889138e-02f, -2.03133170e-02f, 8.70354772e-02f, -7.66484514e-02f, -6.33233786e-03f, -1.20638780e-01f,
  -1.14343688e-01f, -3.50445583e-02f, -4.68437970e-02f, -6.85764179e-02f, 2.96123009e-02f, -5.13499277e-03f, -5.05721197e-02f, 9.59523860e-03f, -3.32334749e-02f, -5.54713346e-02f,
  8.29378441e-02f, -5.42874411e-02f, 5.63125499e-02f, -1.80190243e-02f, -4.07985933e-02f, -2.63809077e-02f, 7.04036430e-02f, -7.57077709e-02f, 4.65876162e-02f, -5.98214641e-02f,
  -8.40799436e-02f, 8.74603912e-02f, 2.70109363e-02f, 3.38939689e-02f, 5.12088016e-02f, 5.89377135e-02f, 6.28017355e-03f, -7.53519610e-02f, 1.65096205e-02f, 2.87659559e-02f,
  -3.07810027e-02f, 1.57550678e-01f, 2.46145520e-02f, -1.31563231e-01f, 5.80380559e-02f, -3.10771577e-02f, 5.78156747e-02f, 5.77610880e-02f, 5.61975427e-02f, 2.10485868e-02f,
  -6.36693463e-02f, -2.70268489e-02f, 6.69991190e-04f, 1.95533736e-03f, 3.58740008e-03f, -1.70674827e-02f, -9.67928320e-02f, 1.17441807e-02f, -8.35818872e-02f, 7.60976225e-02f,
  3.13801356e-02f, 7.78985173e-02f, -1.41622743e-03f, 9.06616542e-03f, 1.83025673e-02f, -1.14611685e-01f, -2.91393567e-02f, -2.82824077e-02f, 3.71985473e-02f, -4.12796736e-02f,
  -3.06183547e-02f, -2.00100482e-01f, -2.38562860e-02f, -8.46645385e-02f, -5.94424158e-02f, -9.77533460e-02f, -2.10517168e-01f, -1.03340700e-01f, -1.27830273e-02f, -1.44558832e-01f,
  2.45144609e-02f, -2.26818100e-02f, -6.50678761e-03f, 5.67780994e-02f, 7.96546116e-02f, -9.38640982e-02f, 3.68441418e-02f, 1.20388858e-01f, 2.30709594e-02f, 1.94293819e-02f,
  -9.60608721e-02f, -7.54451454e-02f, 1.35573789e-01f, -1.42941263e-03f, 9.64505076e-02f, 7.48161897e-02f, 6.15831278e-02f, 2.22226717e-02f, 1.64031330e-02f, -6.92569986e-02f,
  3.54998410e-02f, -6.77372292e-02f, 1.92363579e-02f, 6.88541532e-02f, -1.27209723e-02f, 1.28114177e-02f, -9.09544006e-02f, 1.57802105e-02f, -4.67316136e-02f, -6.17776550e-02f,
  -1.92180648e-02f, -4.77365963e-02f, -6.57521710e-02f, 7.94137791e-02f, -1.11152515e-01f, -1.00160658e-01f, -5.54834269e-02f, 4.15290371e-02f, 1.04523033e-01f, -1.19433351e-01f,
  -8.69686529e-02f, -8.37995633e-02f, -5.13338968e-02f, 3.85512933e-02f, 5.22014424e-02f, 3.83149981e-02f, 5.93897030e-02f, 6.47627488e-02f, 3.46540399e-02f, -5.67564219e-02f,
  6.59167171e-02f, -6.31772876e-02f, 3.99009958e-02f, -5.92013635e-02f, -2.16189176e-02f, 5.18271849e-02f, 3.35742980e-02f, -9.35631618e-03f, 9.96638015e-02f, -6.15843609e-02f,
  3.81503627e-02f, -5.41314259e-02f, 5.37277684e-02f, -4.73464504e-02f, -2.70809084e-02f, -7.72679225e-02f, -8.39090124e-02f, 7.30426759e-02f, 9.24015716e-02f, 1.62937958e-02f,
  3.19508910e-02f, 3.03755067e-02f, 4.67397682e-02f, 7.24662840e-02f, 1.06668624e-03f, -1.37245990e-02f, -1.78428087e-02f, -5.29222675e-02f, -6.14757165e-02f, 7.04274401e-02f,
  -1.06118776e-01f, 9.93569344e-02f, -5.63402800e-03f, -6.26923069e-02f, -1.09946076e-03f, 7.31795207e-02f, 1.88927278e-02f, -5.85861765e-02f, -5.56971245e-02f, -6.86268136e-02f,
  -4.97054309e-02f, -9.20181628e-03f, 3.42282765e-02f, -5.70606925e-02f, 2.71567535e-02f, 2.73958836e-02f, -1.49208317e-02f, 4.98703718e-02f, 4.51781647e-03f, -2.70977244e-02f,
  -2.55045369e-02f, -5.60546555e-02f, -1.64582357e-01f, 1.32936882e-02f, 4.36655879e-02f, -1.25421152e-01f, -6.45045415e-02f, -7.66828656e-02f, -3.94938178e-02f, -4.31024432e-02f,
  1.67838648e-01f, -4.66871783e-02f, -2.43818030e-01f, 7.91140497e-02f, -8.97935778e-02f, -1.51909187e-01f, -4.68020104e-02f, 1.72272846e-02f, 1.30386651e-01f, -4.28167954e-02f,
  -5.54021597e-02f, 6.44093659e-03f, 3.17659602e-02f, -8.18535462e-02f, -1.41560927e-01f, -6.95780888e-02f, -8.06336254e-02f, -3.80022377e-02f, -1.07684145e-02f, -1.68012641e-02f,
  -7.76432008e-02f, -4.59179468e-02f, 3.86930630e-02f, -7.12898448e-02f, -3.89733575e-02f, -1.07334234e-01f, -4.77404594e-02f, 1.74181927e-02f, -1.32796615e-01f, -6.52697636e-03f,
  -3.18609588e-02f, 6.33219182e-02f, -5.40763400e-02f, 3.91310006e-02f, 1.04666119e-02f, 1.18710801e-01f, -2.31768675e-02f, 3.46331820e-02f, 1.20033883e-01f, 6.44093826e-02f,
  -5.32396883e-02f, 4.80297580e-03f, 6.78291395e-02f, -2.40135640e-02f, 8.76629129e-02f, 9.77680683e-02f, 1.06279306e-01f, 7.23528266e-02f, -1.73338801e-02f, 5.85003532e-02f,
  8.28865245e-02f, -8.31719190e-02f, 3.78191210e-02f, 7.29707181e-02f, 4.44123074e-02f, 4.90669534e-03f, 1.23869404e-02f, -3.96359339e-02f, -7.91835040e-03f, -2.06678566e-02f,
  -3.32413539e-02f, -2.31548063e-02f, -3.13547291e-02f, 8.55504125e-02f, -7.72506520e-02f, -6.11337870e-02f, 4.92671505e-02f, -1.52171412e-02f, -6.13950640e-02f, -7.75571447e-03f,
  7.13104010e-02f, -1.04997031e-01f, -7.04882815e-02f, 1.65291838e-02f, 6.31922930e-02f, -6.94580451e-02f, -4.07258840e-03f, 7.51804039e-02f, 4.38254736e-02f, 1.00777382e-02f,
  -6.28587678e-02f, -4.58334722e-02f, -2.15692781e-02f, 3.56536955e-02f, 5.27579226e-02f, -7.27987215e-02f, 5.96986823e-02f, -3.65536660e-02f, 5.32320514e-02f, -8.03808272e-02f,
  1.05254091e-01f, -1.89731270e-01f, 2.34838203e-02f, 1.14343315e-01f, 3.71158607e-02f, 5.56625798e-03f, -4.06649336e-02f, 5.91613054e-02f, 8.61607417e-02f, -4.61550616e-02f,
  4.86598257e-03f, 5.07087894e-02f, -1.96201615e-02f, 7.99926445e-02f, 9.21580866e-02f, -1.15288179e-02f, 7.54934028e-02f, 7.78119937e-02f, 4.19602543e-02f, 7.89535344e-02f,
  -7.15282140e-03f, -8.41940418e-02f, -1.02415169e-02f, -6.20527156e-02f, -4.39228788e-02f, -1.00853734e-01f, -4.39411663e-02f, -2.83370521e-02f, -6.37321500e-03f, 2.95133572e-02f,
  -2.31849793e-02f, 1.33591503e-01f, 7.75277317e-02f, -8.65823925e-02f, -1.13592483e-01f, -1.27307534e-01f, -6.67808801e-02f, -7.47819766e-02f, -1.11695662e-01f, 9.43294317e-02f,
  7.38049373e-02f, -9.21074748e-02f, -3.27264741e-02f, -9.13473219e-02f, -1.47293016e-01f, -1.82895530e-02f, -7.45483041e-02f, -1.52016962e-02f, -2.67181605e-01f, -7.58604929e-02f,
  -1.78615451e-01f, -8.85235816e-02f, -1.40109643e-01f, -2.05463730e-04f, 2.13401411e-02f, 3.74291069e-03f, 6.10714406e-02f, 9.11163259e-03f, 4.45097592e-03f, 2.98979226e-02f,
  1.38522610e-01f, -1.02453351e-01f, 3.60481106e-02f, -2.10983139e-02f, 9.83331278e-02f, 7.93290837e-06f, 3.25428806e-02f, 1.82525907e-03f, 1.16963452e-02f, 6.38939291e-02f,
  8.29657093e-02f, 2.91739963e-02f, 3.49919014e-02f, 5.44547252e-02f, -7.58047700e-02f, -3.09040174e-02f, -1.00747589e-02f, -9.91132483e-02f, 4.64456901e-02f, 9.46475938e-02f,
  8.47169757e-02f, -5.06510921e-02f, -8.13852027e-02f, -5.12964129e-02f, -5.64810522e-02f, -9.77463052e-02f, 9.12086889e-02f, -5.86255752e-02f, -1.89738236e-02f, 1.57787499e-03f,
  4.40526307e-02f, -1.84666123e-02f, -7.61200041e-02f, 6.43598214e-02f, -3.98594178e-02f, -3.99986506e-02f, 7.18354285e-02f, 4.01262939e-02f, -1.94198417e-03f, 5.29421642e-02f,
  2.48215105e-02f, 1.08590722e-01f, 5.12743406e-02f, -2.08522342e-02f, 6.40650913e-02f, 8.94813165e-02f, -2.30280645e-02f, 8.29875022e-02f, -3.10602435e-03f, -5.14303967e-02f,
  -8.20051879e-02f, -5.79663627e-02f, -3.25399935e-02f, 1.16699133e-02f, 2.88802143e-02f, 1.54576395e-02f, -5.61720729e-02f, -4.58479673e-02f, -8.23714361e-02f, -2.61878204e-02f,
  9.86115038e-02f, -6.62818104e-02f, 3.69924121e-02f, 5.75243169e-03f, 6.32100413e-03f, 9.47053954e-02f, 1.30335286e-01f, -4.82761972e-02f, 3.60545591e-02f, 6.63693845e-02f,
  -1.05535969e-01f, 8.60823598e-03f, -3.60994972e-02f, 7.38412887e-02f, -1.03966460e-01f, -1.02713056e-01f, 7.50962719e-02f, -2.54978109e-02f, -2.53782459e-02f, 1.06899291e-01f,
  1.16584554e-01f, 3.37413475e-02f, -3.67948227e-02f, 2.43119467e-02f, 2.91465260e-02f, -9.14511308e-02f, -2.65867822e-02f, -6.54119179e-02f, 7.12910444e-02f, 2.02862248e-02f,
  -4.35461476e-02f, 5.14294347e-03f, -7.45811388e-02f, -1.35150835e-01f, -1.80747911e-01f, -1.38558164e-01f, -8.53074715e-02f, -1.93259846e-02f, -3.79902087e-02f, 1.72424596e-02f,
  -9.55911875e-02f, -1.92724094e-02f, 1.26302196e-02f, 7.45715648e-02f, 2.18015052e-02f, -1.16845384e-01f, -1.79943979e-01f, -1.24817356e-01f, -9.03759450e-02f, -1.76302269e-02f,
  -1.50090521e-02f, -6.47992939e-02f, -3.00949160e-02f, 2.67818458e-02f, -7.63214156e-02f, 6.42334751e-04f, -9.76636484e-02f, -1.12855539e-01f, -2.65852436e-02f, -3.32083292e-02f,
  1.10640071e-01f, -2.21460313e-02f, 9.87602845e-02f, -5.88254258e-02f, 1.78487096e-02f, -1.80427860e-02f, -2.36480664e-02f, 8.08554962e-02f, -6.33205250e-02f, -7.55250603e-02f,
  3.55278142e-02f, -6.15678877e-02f, 7.82910585e-02f, 7.98583869e-03f, 6.50422722e-02f, -3.10975276e-02f, -6.87370524e-02f, 5.84336407e-02f, -9.40111428e-02f, -6.88565671e-02f,
  2.34449636e-02f, -2.55344044e-02f, -7.31309056e-02f, -6.89856112e-02f, -2.57461984e-02f, -1.10473588e-01f, 9.89036411e-02f, -9.02716890e-02f, 6.40156642e-02f, -8.99985060e-03f,
  6.41995892e-02f, -2.19880827e-02f, -3.29568423e-02f, -4.18480895e-02f, -3.53969373e-02f, -5.18758073e-02f, -2.29048971e-02f, 1.05301723e-01f, -2.08461639e-02f, 7.19820037e-02f,
  4.70844768e-02f, -5.41434288e-02f, -4.52339016e-02f, 9.23979748e-03f, 5.01889214e-02f, -6.76820800e-02f, -8.12034383e-02f, -9.55937430e-03f, -3.37268338e-02f, -8.51803124e-02f,
  -3.65014337e-02f, 5.52836210e-02f, 1.12422137e-02f, -3.60945575e-02f, 5.11902124e-02f, -1.21825021e-02f, -7.00978413e-02f, 4.16865088e-02f, 7.88570195e-02f, -6.14661425e-02f,
  2.23340333e-01f, -9.43617523e-02f, -5.38608544e-02f, 1.87910870e-02f, 3.50950956e-02f, -6.41195402e-02f, -5.17023960e-03f, 5.38032874e-03f, 6.74299672e-02f, -4.29856889e-02f,
  -7.28719607e-02f, -2.29089186e-02f, -4.48782146e-02f, -2.96692215e-02f, 4.76078652e-02f, -2.88585909e-02f, -6.77171424e-02f, -8.67847353e-02f, -2.55045891e-02f, 5.18996269e-02f,
  1.09481392e-02f, -8.51003528e-02f, 9.06790327e-03f, 5.88504672e-02f, 9.78215188e-02f, 7.85737187e-02f, 1.13515876e-01f, 1.19552068e-01f, -6.14177994e-02f, 1.39092594e-01f,
  7.51376823e-02f, -4.08003367e-02f, 1.21373266e-01f, -8.49152915e-03f, -1.24004893e-01f, -8.18523318e-02f, -2.61817247e-01f, -9.96118337e-02f, -1.39365956e-01f, -1.18568972e-01f,
  3.84433419e-02f, 3.27331088e-02f, -2.79140845e-02f, 1.27347976e-01f, -1.08850654e-02f, -4.36706282e-02f, 3.73325348e-02f, 9.88642275e-02f, 7.34925494e-02f, 2.57453546e-02f,
  -2.05385257e-02f, 8.82398933e-02f, 1.90401509e-01f, 1.02350920e-01f, 8.17353055e-02f, 7.34895170e-02f, 7.58239850e-02f, -3.30057517e-02f, 5.91893494e-02f, 1.34365097e-01f,
  -4.20985632e-02f, 1.72588769e-02f, 3.74780148e-02f, 3.24270688e-02f, 1.40005052e-01f, 6.01324290e-02f, 3.68240289e-02f, 1.20172746e-01f, 5.14560007e-02f, 5.85084334e-02f,
  -4.13705520e-02f, 1.05806954e-01f, -5.89283481e-02f, 2.46064104e-02f, -2.18812991e-02f, 7.05214441e-02f, 1.58037320e-02f, 1.40926167e-01f, 3.23366076e-02f, 5.38617978e-03f,
  2.43909322e-02f, 6.98418962e-03f, -9.03082639e-02f, -1.18215196e-01f, 5.99392131e-02f, 1.23114444e-01f, 1.18296826e-02f, -2.93819848e-02f, -2.57213898e-02f, -7.51049891e-02f,
  7.56682679e-02f, 2.85855569e-02f, 6.02422208e-02f, -7.25772157e-02f, 5.46366647e-02f, -4.79723588e-02f, -7.85722733e-02f, -2.29580272e-02f, -5.68265431e-02f, -5.69123030e-02f,
  -3.57822552e-02f, 2.13995669e-03f, -5.38246939e-03f, -9.16798189e-02f, 4.23604771e-02f, 4.31819335e-02f, -3.48477392e-03f, 5.33281118e-02f, 9.72968489e-02f, -6.79691136e-02f,
  2.86881663e-02f, -2.28413194e-02f, 3.63089852e-02f, 3.06294523e-02f, 6.97250143e-02f, 3.74589525e-02f, 4.00475562e-02f, -6.34816363e-02f, -6.47424534e-02f, 1.80342067e-02f,
  -1.41372994e-01f, 1.91735327e-01f, 5.29988706e-02f, -1.79911666e-02f, 2.05504727e-02f, 7.68131092e-02f, -3.56540754e-02f, 1.17746748e-01f, 9.59111452e-02f, -7.69514591e-02f,
  3.86444740e-02f, 3.74614890e-03f, 4.62070368e-02f, -7.87837431e-02f, 1.73730007e-03f, 2.08444148e-02f, -4.83871661e-02f, -2.83059292e-02f, 2.08578128e-02f, 2.87348926e-02f,
  -1.42231137e-02f, -1.07310362e-01f, -8.68456289e-02f, -1.58577621e-01f, -8.40718951e-03f, 1.00951362e-02f, -8.69942605e-02f, -3.93614024e-02f, 1.45392669e-02f, -3.88350077e-02f,
  9.92622450e-02f, -3.63046266e-02f, -1.10518709e-01f, -5.35038225e-02f, -1.03317559e-01f, 4.36808020e-02f, -7.08209425e-02f, -8.89381692e-02f, -3.56715173e-02f, -6.62375912e-02f,
  -1.17976088e-02f, 3.68085206e-02f, 2.83305980e-02f, -3.99400527e-03f, -6.25066459e-02f, 4.33187495e-04f, -7.75821656e-02f, 9.72538516e-02f, 1.16701432e-01f, 6.14620410e-02f,
  2.60051973e-02f, 6.58823401e-02f, 3.75305638e-02f, 7.96470270e-02f, 8.56049657e-02f, -2.57818494e-02f, -6.58415556e-02f, 7.94573501e-02f, -1.71437748e-02f, 8.92202556e-02f,
  -7.89714307e-02f, -1.08489551e-01f, 1.28561510e-02f, 2.67020124e-03f, -3.32574509e-02f, 9.12831202e-02f, 8.94956365e-02f, 1.31635033e-02f, -1.82571691e-02f, 6.72087027e-03f,
  9.41349193e-03f, -2.82755177e-02f, -6.24782331e-02f, 9.51434448e-02f, -6.73511624e-02f, 1.58958640e-02f, -5.56234904e-02f, 8.92953724e-02f, 3.00034862e-02f, -4.99373712e-02f,
  3.53315845e-02f, -2.86689624e-02f, 5.72204329e-02f, 2.25247201e-02f, -8.38674977e-02f, -5.74657023e-02f, -9.57714692e-02f, 4.56464142e-02f, -9.96787474e-02f, 1.59321968e-02f,
  8.51840898e-02f, -4.22131382e-02f, 4.38124165e-02f, 2.13386174e-02f, -8.47056732e-02f, -1.06524169e-01f, -1.60074700e-02f, -9.09773167e-04f, 9.28764418e-02f, 2.60035135e-02f,
  -3.65394279e-02f, 2.60829255e-02f, -4.47161868e-02f, -1.55557785e-02f, 5.50335795e-02f, 1.73311289e-02f, 3.75915132e-02f, -3.30170877e-02f, -7.91384801e-02f, 7.71519840e-02f,
  -8.99484977e-02f, -2.57751029e-02f, -8.89579058e-02f, -2.80693714e-02f, -4.29254323e-02f, 7.08505884e-02f, 3.87522504e-02f, 1.41078094e-02f, -3.26712020e-02f, 6.42940477e-02f,
  -6.87730908e-02f, -6.39157742e-02f, 1.90910771e-02f, 5.31020872e-02f, -4.13520075e-02f, 3.81928049e-02f, 1.37987165e-02f, -3.53574636e-03f, 5.96647337e-02f, 5.02370708e-02f,
  9.40103643e-03f, 1.00136951e-01f, -6.76825866e-02f, -5.56635410e-02f, -5.64569868e-02f, -1.71253495e-02f, -4.65083197e-02f, 9.67751443e-02f, -5.38743883e-02f, 3.95118818e-02f,
  -2.19806004e-02f, 5.40502071e-02f, 7.09246919e-02f, -5.87895215e-02f, -7.13576227e-02f, -4.05606255e-02f, 2.77549811e-02f, -5.66207357e-02f, -1.30352064e-03f, -2.89617199e-02f,
  -9.63018239e-02f, 7.55369216e-02f, -8.71756393e-03f, -1.00370143e-02f, 1.79049686e-01f, 2.31535323e-02f, 1.39501197e-02f, -1.01173550e-01f, -4.15215157e-02f, 6.41535828e-03f,
  5.74118830e-02f, -5.10363877e-02f, 8.07925537e-02f, -5.65055087e-02f, -5.04464731e-02f, 6.69111609e-02f, 1.11573979e-01f, 1.44098559e-02f, 1.95041299e-02f, 2.53125131e-02f,
  8.26707780e-02f, 3.50338966e-02f, 1.05782382e-01f, -7.47322440e-02f, 4.36618924e-02f, 8.24168883e-03f, -1.53821129e-02f, 1.17515609e-01f, 9.74001288e-02f, 2.79389471e-02f,
  -1.29532099e-01f, -1.01323105e-01f, -1.34789109e-01f, 8.53590593e-02f, 8.81623700e-02f, -9.79322121e-02f, 2.61380132e-02f, 1.02656633e-02f, -6.05504960e-02f, 1.99260004e-02f,
  7.34363571e-02f, 4.41978760e-02f, -1.87681038e-02f, 4.59277667e-02f, -2.93494649e-02f, -1.21701360e-01f, -3.11713777e-02f, -5.58237116e-05f, -1.19377226e-01f, -6.91960976e-02f,
  1.04598992e-01f, -8.91000405e-03f, -7.90400580e-02f, -1.10594764e-01f, -1.05160095e-01f, 3.10236891e-03f, -2.66243611e-02f, -4.36946526e-02f, -4.61593270e-02f, -1.59251153e-01f,
  -5.83212599e-02f, 3.57960090e-02f, -5.85175939e-02f, 6.65249228e-02f, 1.92924980e-02f, 6.62853792e-02f, -7.43951425e-02f, 8.48307554e-03f, -2.26227231e-02f, -2.34795976e-02f,
  -8.57126527e-03f, 1.40880411e-02f, -4.95576151e-02f, -7.29132444e-03f, -1.22107808e-02f, 8.79702251e-03f, -7.09341019e-02f, 2.38369126e-02f, -1.46594597e-02f, 8.97669420e-03f,
  5.72999492e-02f, 5.11742644e-02f, 5.54615408e-02f, -1.52817862e-02f, -2.32538544e-02f, 2.17848606e-02f, 5.63987792e-02f, -3.54092605e-02f, -7.48565271e-02f, -1.40487067e-02f,
  9.59567726e-03f, 3.32765914e-02f, -1.52825296e-01f, 3.10503170e-02f, -4.55892757e-02f, -7.90945441e-02f, 1.27734868e-02f, 2.61773746e-02f, 5.65244369e-02f, -1.16314419e-01f,
  -2.35262085e-02f, -6.82129264e-02f, -4.00427245e-02f, -5.88648766e-02f, 4.15368229e-02f, -7.43260235e-02f, -6.32899031e-02f, 4.84544076e-02f, 3.25072207e-03f, -4.03781272e-02f,
  -7.03753754e-02f, -8.12596381e-02f, -3.07602286e-02f, -9.35373679e-02f, 6.21113274e-03f, 1.80594611e-03f, -1.16065815e-01f, -1.59981564e-01f, -1.88760236e-01f, -2.00613678e-01f,
  2.56841570e-01f, 1.58020392e-01f, 2.68616647e-01f, -6.06749207e-03f, 1.98870137e-01f, 2.06179678e-01f, 3.15084040e-01f, 2.04221636e-01f, 1.62470657e-02f, 2.34872871e-03f,
  7.20715225e-02f, -2.00915441e-01f, -5.99593073e-02f, -1.75253630e-01f, -4.12051864e-02f, 8.69921036e-03f, -6.97993562e-02f, -2.03350782e-02f, 5.55111542e-02f, 5.07934280e-02f,
  -9.94984284e-02f, 1.53872417e-02f, 5.44119328e-02f, 7.64581412e-02f, 6.26364350e-02f, -1.34464413e-01f, -2.11898834e-02f, 1.08057238e-01f, 9.72036719e-02f, -9.34191421e-02f,
  -5.05768619e-02f, 2.83034980e-01f, -9.34749320e-02f, -8.82098675e-02f, 2.39563528e-02f, -7.72499070e-02f, -8.28256607e-02f, -8.98817405e-02f, -1.39795488e-03f, -3.85165326e-02f,
  -4.69451323e-02f, -4.28714566e-02f, -7.15237781e-02f, 1.84182599e-02f, 2.28145178e-02f, 9.59462002e-02f, 9.88879353e-02f, 4.41942504e-03f, -5.41356318e-02f, -1.08495362e-01f,
  -1.11731872e-01f, 3.04628685e-02f, 1.73144832e-01f, 4.31310795e-02f, 1.70710254e-02f, -4.92677279e-02f, 1.00497253e-01f, 3.31866890e-02f, 2.78424416e-02f, 9.34855416e-02f,
  -8.05314332e-02f, -4.36487757e-02f, -1.58760883e-02f, 8.90017673e-02f, -4.52373810e-02f, 8.06146476e-04f, -6.85406923e-02f, -1.73984785e-02f, 6.05189539e-02f, -4.64189500e-02f,
  5.49795181e-02f, 5.74711263e-02f, 8.03316385e-03f, 3.55420336e-02f, -5.39601631e-02f, 7.38153532e-02f, -1.95723157e-02f, 8.17412697e-03f, 4.28263322e-02f, 3.77276428e-02f,
  -5.37847877e-02f, -5.90614341e-02f, 1.01405069e-01f, -1.74109116e-02f, 2.64981445e-02f, -4.87870909e-02f, -8.71614590e-02f, 6.73013926e-02f, -5.44923125e-03f, -7.03755766e-02f,
  -4.76355217e-02f, 4.42863591e-02f, -2.27839559e-01f, -3.26089785e-02f, 2.22464930e-02f, -1.16644436e-02f, -8.05156976e-02f, 2.95698605e-02f, -7.16628283e-02f, 4.79569286e-02f,
  1.84558723e-02f, -9.00316536e-02f, 8.22282210e-02f, -9.33667496e-02f, 4.64900061e-02f, -1.41983479e-02f, 2.68090069e-02f, 1.82958730e-02f, -2.44246032e-02f, -8.59590918e-02f,
  -8.28058366e-03f, 1.17260041e-02f, -4.09743004e-02f, -1.65681355e-02f, -1.14464089e-01f, 5.78752207e-03f, 6.85883090e-02f, 4.30579521e-02f, -4.06921259e-04f, 9.34808701e-02f,
  1.17463268e-01f, -6.65568188e-03f, 1.81288850e-02f, -2.35082507e-02f, -1.04014881e-01f, -1.13733299e-01f, 3.02180778e-02f, -1.01792663e-01f, 7.65008479e-02f, 5.98978773e-02f,
  1.39891714e-01f, 1.96684506e-02f, 1.43734872e-01f, 1.12666607e-01f, -2.03860700e-02f, -9.63141024e-02f, -6.28484860e-02f, -1.10026971e-02f, 3.53709087e-02f, -1.20488591e-01f,
  5.14116064e-02f, -1.27025424e-02f, -5.30674197e-02f, -2.55576000e-02f, -2.66343579e-02f, -4.54722717e-02f, -9.71067399e-02f, 5.33252396e-02f, -4.11971882e-02f, -9.36149582e-02f,
  -2.16397252e-02f, 9.06672999e-02f, -3.18368524e-02f, 8.07364807e-02f, 3.76154780e-02f, 4.61642593e-02f, 3.26512530e-02f, -3.08973808e-02f, -5.07643968e-02f, -4.14250754e-02f,
  -2.86284462e-03f, -5.43298125e-02f, 5.91209494e-02f, -1.89019702e-02f, -9.11114812e-02f, 4.25844491e-02f, -8.83992296e-03f, -3.37713845e-02f, 3.30377482e-02f, -1.00723870e-01f,
  -6.83281124e-02f, 3.50013971e-02f, -8.41635987e-02f, -1.50741311e-02f, -1.49808750e-02f, 6.02922356e-03f, -2.33267732e-02f, -1.02373064e-01f, -6.19978318e-03f, -7.17027858e-02f,
  1.95610654e-02f, 3.58202606e-02f, -1.03421479e-01f, -2.96667945e-02f, 7.66608641e-02f, 1.78814810e-02f, -1.59733314e-02f, 1.32509554e-03f, -2.93611381e-02f, 9.94953886e-03f,
  3.10363341e-02f, -7.50974342e-02f, -4.18844749e-04f, -8.09533373e-02f, -6.05582148e-02f, 1.96926966e-02f, -9.38002169e-02f, -7.95165151e-02f, 3.59563134e-03f, -4.07024883e-02f,
  -5.44763580e-02f, 5.17331157e-03f, -9.37731117e-02f, -2.02736221e-02f, -7.66270533e-02f, 6.23587929e-02f, -9.39057115e-03f, -5.64188026e-02f, -9.22998935e-02f, -3.38997915e-02f,
  -2.34858617e-02f, 1.49648950e-01f, -2.11985745e-02f, 1.07457697e-01f, -4.67093289e-02f, -1.67944636e-02f, -2.77402662e-02f, 1.24746198e-02f, -7.42171332e-02f, -8.86481926e-02f,
  5.37979081e-02f, 5.63063733e-02f, -2.15776470e-02f, 1.21333934e-02f, -5.45904459e-03f, -1.09617766e-02f, 1.23679256e-02f, 4.11505327e-02f, -1.16967608e-03f, -1.15078529e-02f,
  -3.44558596e-03f, 5.35344370e-02f, 1.08807035e-01f, 1.09394245e-01f, -4.10871487e-03f, 1.45341143e-01f, 3.64663266e-02f, 3.04223560e-02f, 7.09434897e-02f, -1.12448363e-02f,
  9.96808484e-02f, -1.19046412e-01f, 5.49198315e-02f, -2.71760952e-02f, 1.61099404e-01f, 1.69286486e-02f, 8.65531042e-02f, -3.49910036e-02f, -1.12386392e-02f, 6.61267564e-02f,
  -4.84977141e-02f, -1.08996406e-03f, 4.05774973e-02f, 4.83955108e-02f, -1.03294417e-01f, -5.58390096e-02f, -8.13566372e-02f, 2.02347860e-02f, 1.24752983e-01f, 1.03309266e-02f,
  -3.97256389e-03f, -5.80302440e-02f, -8.38858336e-02f, -3.54175195e-02f, -2.79467572e-02f, 4.90138680e-02f, 2.60904171e-02f, -3.23345214e-02f, -7.60176266e-03f, -2.14376543e-02f,
  9.95290652e-02f, -5.14320657e-02f, 1.04111567e-01f, -1.56261325e-02f, 1.49643782e-03f, -9.36290547e-02f, 4.04330641e-02f, 2.21164133e-02f, -6.47434890e-02f, 3.74662178e-03f,
  -7.91824684e-02f, 4.64119241e-02f, -1.62350442e-02f, -7.51715824e-02f, 2.45340224e-02f, -3.14527042e-02f, 4.81949262e-02f, -9.73513052e-02f, 2.14600842e-02f, 3.16038285e-03f,
  -1.14139609e-01f, 4.15601134e-02f, 1.09762829e-02f, 6.50630593e-02f, -1.03742912e-01f, 6.96562231e-02f, 6.72236457e-02f, -8.14675316e-02f, -8.88427123e-02f, -7.65369684e-02f,
  -3.61447930e-02f, -4.49880809e-02f, -8.56117066e-03f, 2.79493071e-02f, 7.35207200e-02f, -4.60108370e-02f, -2.41497485e-03f, -7.74213374e-02f, -4.12567109e-02f, -3.33531648e-02f,
  4.46131565e-02f, -6.03703819e-02f, -9.73455459e-02f, -1.31035028e-02f, -5.73112443e-02f, 3.06581073e-02f, -8.25829506e-02f, -1.12641878e-01f, 1.27538089e-02f, 6.55217022e-02f,
  6.27971143e-02f, -3.35007422e-02f, 3.74005958e-02f, -2.33594831e-02f, -3.68306749e-02f, -4.12650183e-02f, 7.75069892e-02f, 3.75621133e-02f, 3.24283764e-02f, 3.21743228e-02f,
  -5.68369739e-02f, -2.03451086e-02f, -5.32732196e-02f, -1.51421102e-02f, 8.18035230e-02f, -1.71526591e-03f, -1.33920722e-02f, 5.20193996e-03f, -5.72264269e-02f, -7.81364292e-02f,
  -1.15734255e-02f, -1.06709823e-02f, -5.16035594e-03f, 3.40190791e-02f, 9.60206166e-02f, 5.16653201e-03f, 1.25747304e-02f, -4.02645804e-02f, 4.12052460e-02f, 3.58126163e-02f,
  2.38824114e-02f, 3.16268913e-02f, -1.84837244e-02f, -4.31966744e-02f, -7.72303045e-02f, 2.73526218e-02f, -2.54531633e-02f, 3.57718840e-02f, 6.62355423e-02f, 1.17445156e-01f,
  1.74322307e-01f, 1.31594315e-02f, 1.34131446e-01f, 6.80363625e-02f, -9.84863788e-02f, 2.65852083e-02f, 1.34756863e-01f, 1.23022117e-01f, 1.10789157e-01f, -1.15769543e-02f,
  -4.81248423e-02f, 1.07394002e-01f, 7.21616969e-02f, 8.11402425e-02f, 5.31907678e-02f, 6.13948070e-02f, -7.78773054e-02f, 2.23661903e-02f, 5.87252378e-02f, 7.64041543e-02f,
  5.88499717e-02f, 7.53162950e-02f, 8.53149667e-02f, 7.01641142e-02f, -4.38988805e-02f, -7.15243071e-02f, -8.81321356e-02f, -9.23595354e-02f, 6.71561137e-02f, 2.06397064e-02f,
  7.54953921e-02f, 2.31250860e-02f, -5.16933165e-02f, 8.50967318e-03f, 2.69364268e-02f, -5.15184365e-02f, -1.60734206e-02f, 3.16698663e-02f, -7.79451206e-02f, -9.09388065e-02f,
  -4.53796536e-02f, -5.53072840e-02f, -4.29631677e-03f, -2.43134517e-02f, -7.98319466e-03f, -1.07957302e-02f, 4.82383110e-02f, -3.73148061e-02f, -5.70484325e-02f, 3.61673944e-02f,
  -7.37698376e-02f, -1.05127180e-02f, 7.68742561e-02f, 3.86738442e-02f, 3.74516807e-02f, 7.10011646e-03f, -4.93144728e-02f, 5.59101589e-02f, 3.68825831e-02f, 3.34539986e-03f,
  4.44314163e-03f, 1.07722163e-01f, 6.19698502e-02f, -5.63656799e-02f, 3.97067703e-02f, -1.05009656e-02f, 1.89438816e-02f, -4.55086771e-03f, 2.85057854e-02f, -5.57024479e-02f,
  7.51298890e-02f, 1.00683734e-01f, 8.46822485e-02f, 1.22436415e-02f, 8.66605435e-03f, -8.25043023e-02f, 6.95957541e-02f, 2.40381621e-02f, -3.99800651e-02f, 4.04105745e-02f,
  -3.12988870e-02f, 3.12269330e-02f, 5.50891720e-02f, 1.22269634e-02f, -5.38600795e-02f, 4.03380468e-02f, 4.54322658e-02f, -1.29113114e-02f, 5.13960570e-02f, 7.38031715e-02f,
  -9.98758525e-02f, 1.14780627e-02f, 6.65131286e-02f, -3.89832892e-02f, -7.69579858e-02f, 5.35913855e-02f, -4.98348288e-02f, -8.53314400e-02f, 6.14066273e-02f, -8.88730958e-02f,
  1.55183831e-02f, -7.42095187e-02f, -4.02120315e-02f, 4.93886694e-02f, 2.70790700e-02f, 2.99982112e-02f, -1.35425359e-01f, 7.10409060e-02f, -8.68912488e-02f, -8.71225521e-02f,
  4.97062225e-03f, -9.79045331e-02f, 5.95334806e-02f, 4.84077409e-02f, -7.52127692e-02f, 5.32248169e-02f, 3.49888019e-02f, 1.37301804e-02f, -5.28461523e-02f, -2.42530312e-02f,
  7.74455965e-02f, -3.69438455e-02f, 2.07482986e-02f, -7.77268410e-02f, 1.70896426e-02f, -5.82556240e-02f, -5.09733334e-02f, -9.01611242e-03f, -2.76942775e-02f, 1.09973088e-01f,
  7.28504732e-02f, 2.47000352e-01f, 2.20897302e-01f, 1.77208677e-01f, 2.57824585e-02f, -1.20368768e-02f, 4.72543836e-02f, 6.23937473e-02f, -4.78403270e-03f, -7.77330771e-02f,
  -7.01342374e-02f, 3.46344672e-02f, 4.22571152e-02f, -9.41012576e-02f, -6.77773431e-02f, 1.30547374e-01f, -9.28457379e-02f, -4.02828455e-02f, 2.96864007e-03f, -5.16852960e-02f,
  1.42915428e-01f, -9.26815942e-02f, -4.59725633e-02f, 6.21831454e-02f, 6.00662567e-02f, -7.61965960e-02f, -6.82917908e-02f, -7.88986683e-02f, -1.08670304e-02f, -4.89123492e-03f,
  4.01044227e-02f, -6.18525036e-02f, -2.33731661e-02f, -2.55381074e-02f, -1.05367459e-01f, -1.09279789e-01f, -2.93790046e-02f, 8.39662831e-03f, -2.64889430e-02f, 1.44487573e-02f,
  6.81008250e-02f, -6.15576506e-02f, 3.28750834e-02f, 2.94789635e-02f, -8.51271078e-02f, 5.72010688e-02f, 2.00809538e-02f, -1.06599189e-01f, -3.08498293e-02f, -1.16402619e-01f,
  5.53564765e-02f, -1.49683561e-02f, 8.27183947e-02f, -1.72012914e-02f, 4.88643758e-02f, -8.64137933e-02f, 7.47980550e-02f, 7.24189803e-02f, -6.07934967e-02f, 1.90217923e-02f,
  6.20600209e-02f, 6.96942657e-02f, 6.97657093e-02f, 3.72743122e-02f, 6.30272254e-02f, 2.84026600e-02f, -2.23894753e-02f, -2.69349702e-02f, -7.27442950e-02f, 2.51485500e-02f,
  -3.79115380e-02f, 7.26849660e-02f, -1.36515149e-03f, -3.38082276e-02f, -7.12884516e-02f, -8.51349905e-02f, 3.04239932e-02f, -6.99458225e-03f, -7.39086568e-02f, -6.73887506e-02f,
  1.85384259e-01f, 5.36625758e-02f, 4.41713855e-02f, 5.83344214e-02f, -1.05911806e-01f, 5.51733300e-02f, -6.39926270e-02f, -4.47303131e-02f, -5.01971785e-03f, -7.62420520e-02f,
  1.35736382e-02f, -3.75589468e-02f, -3.97650488e-02f, -6.28131703e-02f, -5.60868494e-02f, 2.18171328e-02f, -1.85949095e-02f, -7.53957331e-02f, -4.47046906e-02f, -1.06914327e-01f,
  -1.95346307e-02f, -6.03175126e-02f, 1.32142529e-01f, 5.92020527e-02f, -6.20376179e-03f, 1.05164051e-01f, -2.85982601e-02f, 7.47051761e-02f, 6.39289320e-02f, 1.90829244e-02f,
  1.71972960e-01f, -4.27943189e-03f, -1.71297640e-01f, -3.75045743e-03f, -2.34479066e-02f, -1.41162470e-01f, -3.82613987e-02f, -1.61522778e-03f, 1.20338030e-01f, 1.15935430e-02f,
  -3.77469398e-02f, 1.05454527e-01f, -5.99047504e-02f, -1.30896643e-02f, 5.55328541e-02f, -9.37405005e-02f, 3.27611044e-02f, 4.95339930e-02f, -9.40214097e-02f, 7.95773137e-03f,
  8.74530349e-04f, -1.20519474e-02f, 1.38281360e-02f, 7.31385276e-02f, 5.04887011e-03f, 4.85856831e-03f, -3.53252441e-02f, -4.36198711e-03f, -1.24989681e-01f, -5.15253805e-02f,
  -1.97648033e-01f, -8.93836170e-02f, 7.55038857e-02f, 1.45932764e-01f, 5.66790439e-02f, 1.30001366e-01f, -4.53370810e-02f, -2.02977583e-02f, 6.85147345e-02f, 7.81552345e-02f,
  -9.23799060e-04f, -1.28981313e-02f, -5.59328347e-02f, 1.16285151e-02f, 7.81981796e-02f, -9.55636799e-02f, 4.65472974e-02f, 9.99584794e-02f, 4.55132090e-02f, -1.06105931e-01f,
  -2.27944721e-02f, 1.54388798e-02f, -1.18118778e-01f, 5.17500676e-02f, -1.86033789e-02f, -1.05598941e-02f, 4.39053066e-02f, -7.30845183e-02f, 4.60701846e-02f, 1.43777020e-02f,
  1.59119163e-03f, -6.26965519e-03f, -6.94932416e-02f, -4.95703332e-02f, 2.61942726e-02f, 7.92135298e-02f, 3.59971710e-02f, -1.31374886e-02f, -6.98202327e-02f, -1.58215258e-02f,
  -5.54891415e-02f, -1.17672617e-02f, 2.26510204e-02f, 6.69911131e-02f, 1.06077148e-02f, -4.88870665e-02f, -3.87210511e-02f, -1.82123501e-02f, -5.91793619e-02f, 2.92701442e-02f,
  -4.05629985e-02f, -1.04196735e-01f, -3.66168022e-02f, -4.26354930e-02f, -4.42412794e-02f, -1.19475806e-02f, 4.30730805e-02f, 5.07609285e-02f, -7.41579458e-02f, 9.25608277e-02f,
  -6.30893707e-02f, -3.05586737e-02f, 7.02927932e-02f, 1.11920554e-02f, 9.44620091e-03f, 4.85664643e-02f, -9.70838964e-02f, 5.44994213e-02f, -6.48701489e-02f, -1.15747368e-02f,
  -1.82810314e-02f, -7.30014294e-02f, 1.45342425e-02f, 9.80838295e-03f, -5.25337867e-02f, 6.24465086e-02f, 5.44785373e-02f, -7.28118867e-02f, 6.05271459e-02f, -1.85161904e-02f,
  -2.02147625e-02f, 4.90982309e-02f, 6.31669983e-02f, -2.16447958e-03f, 7.90971890e-02f, 2.87294686e-02f, -2.29034945e-02f, 2.49634832e-02f, 7.64083713e-02f, 1.75967559e-01f,
  -1.69665202e-01f, 7.82419369e-02f, -4.08794731e-02f, -1.16531253e-01f, -1.39095992e-01f, -1.21481970e-01f, -1.45886028e-02f, -1.88781377e-02f, -9.55258235e-02f, 6.15166128e-02f,
  1.49065936e-02f, -6.14832528e-03f, 5.70421331e-02f, 1.18367150e-01f, 1.01727091e-01f, 5.62903360e-02f, 7.89465308e-02f, -7.44712353e-02f, -7.95480609e-02f, -6.19765669e-02f,
  -8.68326500e-02f, 2.40493454e-02f, 3.03188786e-02f, -6.45934343e-02f, 1.54074337e-02f, 7.23391101e-02f, 5.72210327e-02f, -6.69435784e-02f, 5.36949635e-02f, 4.03226092e-02f,
  -7.06564309e-03f, -1.99796140e-01f, 7.28018954e-02f, -1.77913886e-02f, -3.03575955e-02f, -2.99243405e-02f, -7.91104659e-02f, 2.68750116e-02f, -1.09129362e-01f, 6.49869889e-02f,
  -1.00136869e-01f, 1.24490308e-02f, -1.84619296e-02f, -5.96843697e-02f, 1.53831868e-02f, -1.00124821e-01f, 1.60252135e-02f, -2.69181598e-02f, -2.48989719e-03f, -6.72316328e-02f,
  -1.00330478e-02f, -1.59708127e-01f, -9.75211859e-02f, -5.56050315e-02f, -1.03662118e-01f, -9.80137195e-03f, -3.58704589e-02f, 1.07333949e-03f, 7.40460753e-02f, -7.53807127e-02f,
  1.10167370e-03f, -2.59206984e-02f, -3.92474234e-02f, 1.84576772e-02f, -2.30089705e-02f, 7.41973296e-02f, 5.40186046e-03f, 7.10840076e-02f, -3.26516815e-02f, 8.95723999e-02f,
  6.25438243e-02f, 7.72094131e-02f, 7.08458126e-02f, -4.54718918e-02f, 5.71728013e-02f, -5.35206348e-02f, -6.86160848e-02f, 1.14144549e-01f, -4.98889834e-02f, -6.75724521e-02f,
  -7.62119517e-02f, -4.38026264e-02f, -3.59051004e-02f, 7.35047758e-02f, 1.47503093e-02f, -2.74813324e-02f, 7.45279938e-02f, -3.61550860e-02f, -1.75924823e-02f, -1.59731582e-02f,
  1.84862554e-01f, 8.56505707e-02f, 5.10197356e-02f, -2.13647587e-03f, -7.87612200e-02f, -3.38482074e-02f, -8.73481035e-02f, -1.44308414e-02f, 1.98297761e-02f, -7.35873636e-03f,
  -3.39196511e-02f, -6.08448535e-02f, 2.86388211e-02f, 5.63191138e-02f, 1.79043375e-02f, 1.59105994e-02f, 7.30472282e-02f, -9.94372740e-03f, 8.43625143e-02f, 5.98420575e-02f,
  3.66898887e-02f, -8.13388638e-03f, 5.99047691e-02f, 1.38863668e-01f, 6.82822987e-02f, -4.42144014e-02f, 6.75193146e-02f, -7.27503300e-02f, 1.78752374e-02f, 1.65107131e-01f,
  1.06371462e-01f, 1.46657646e-01f, 1.04435779e-01f, 7.43642598e-02f, -1.95089713e-01f, -1.05200224e-01f, -6.46593794e-03f, 5.56172207e-02f, 9.20652822e-02f, -5.12164421e-02f,
  -1.48948461e-01f, 2.56406097e-03f, 6.88765645e-02f, -1.20454036e-01f, 6.23092279e-02f, 4.62509058e-02f, 1.42937690e-01f, -8.96709636e-02f, -9.68684703e-02f, -1.91335589e-01f,
  1.50492387e-02f, -9.17250477e-03f, -3.25820148e-02f, 9.12292674e-02f, 7.36762136e-02f, -3.91139686e-02f, 2.39292881e-03f, -1.45676769e-02f, -6.50237575e-02f, 1.13339778e-02f,
  6.19249940e-02f, 2.75787078e-02f, -1.58765674e-01f, -7.27656409e-02f, -1.37517303e-01f, 8.28592479e-03f, -3.78177152e-03f, -6.74259216e-02f, -1.97589933e-03f, 5.20483181e-02f,
  -1.10024631e-01f, -5.77288903e-02f, -7.23863915e-02f, -7.49583468e-02f, 2.13256311e-02f, -6.28099889e-02f, -6.08425541e-03f, 6.77667782e-02f, -8.22056904e-02f, -6.43261895e-02f,
  -1.30717814e-01f, -1.18818335e-01f, -2.09694542e-03f, 1.16796494e-02f, 6.61080629e-02f, -7.59875327e-02f, 1.08096786e-02f, -7.11227506e-02f, -4.88803610e-02f, 2.48303302e-02f,
  -5.19374236e-02f, 7.01483563e-02f, 2.43625022e-03f, -2.12050648e-03f, -3.78576182e-02f, 1.81689318e-02f, 3.98657061e-02f, -5.09508364e-02f, -7.37224147e-02f, 5.77747934e-02f,
  -9.79708582e-02f, 1.13786701e-02f, 1.71978381e-02f, 1.76700242e-02f, -2.30892077e-02f, 5.11927716e-02f, -4.76969182e-02f, 4.10201680e-03f, -7.75984814e-03f, 8.58954489e-02f,
  -7.38241896e-02f, -1.61419192e-03f, 1.97636802e-02f, 8.48447457e-02f, 4.74163815e-02f, 7.46208662e-03f, -6.96112216e-02f, -1.62819419e-02f, 5.04617132e-02f, 1.11908047e-02f,
  8.74801576e-02f, -2.10244209e-01f, 4.72545400e-02f, -1.82417817e-02f, 3.10383234e-02f, -8.59906822e-02f, -5.03068119e-02f, 4.31232713e-02f, -5.79034686e-02f, -4.25415449e-02f,
  -9.70687419e-02f, 2.03143526e-02f, -2.70694494e-02f, 6.07353896e-02f, -1.14192218e-01f, 3.79122607e-02f, -7.75997564e-02f, -9.81865078e-02f, -5.30148111e-02f, 4.45575602e-02f,
  5.01912273e-02f, 1.77473761e-03f, -1.54482927e-02f, 6.43711686e-02f, -3.98207642e-02f, -3.47341038e-02f, -5.24059460e-02f, -1.00458048e-01f, -8.84938613e-02f, 1.66964293e-01f,
  1.77543700e-01f, 6.76406696e-02f, -1.17151298e-01f, -5.09090349e-02f, 8.40187445e-03f, -9.70569849e-02f, -3.68475914e-02f, -5.41019142e-02f, 6.85883164e-02f, -5.10202795e-02f,
  1.12339258e-01f, -3.69743481e-02f, -1.53165858e-03f, 3.90918329e-02f, 6.81876242e-02f, 1.90193683e-03f, -7.78218731e-02f, -4.82404046e-02f, -2.20008716e-02f, -1.08705193e-01f,
  8.75587016e-02f, -1.10201957e-02f, 1.00905873e-01f, 2.55170688e-02f, -1.55093661e-02f, 6.97402060e-02f, -3.87070701e-02f, -3.75109650e-02f, 5.45561612e-02f, 8.08158368e-02f,
  -6.60204887e-02f, -2.49659065e-02f, -9.44755226e-02f, -1.26445480e-02f, -7.60881677e-02f, -3.15893926e-02f, 8.68546665e-02f, -6.26459196e-02f, 3.98228653e-02f, 6.30889907e-02f,
  -2.96444129e-02f, 2.05528736e-02f, 1.57721173e-02f, -7.13524744e-02f, -6.59067184e-04f, -7.49166086e-02f, 9.21052173e-02f, 3.78095210e-02f, -6.18281364e-02f, -3.99803557e-02f,
  6.70560822e-02f, 7.35633671e-02f, -7.83275813e-02f, -7.87372738e-02f, 5.04134549e-03f, 7.77105018e-02f, 1.37713309e-02f, -9.84813720e-02f, 2.90379580e-02f, -2.41037626e-02f,
  -1.31402388e-01f, -1.82790197e-02f, -7.02633709e-02f, 2.50356682e-02f, 4.39365543e-02f, -1.03675947e-01f, -6.69571161e-02f, 5.12803011e-02f, 5.40334405e-03f, 5.79716600e-02f,
  2.40399279e-02f, -9.75729749e-02f, -8.31907168e-02f, -2.57469770e-02f, 2.38658544e-02f, -1.06201433e-01f, -4.62679490e-02f, -7.69945309e-02f, -1.15372753e-02f, -3.94346155e-02f,
  4.16854722e-03f, -7.60406032e-02f, 8.14499706e-02f, 4.13734280e-02f, -3.69686745e-02f, 1.32680498e-02f, -1.17049433e-01f, -8.71717837e-03f, -6.84671402e-02f, 4.57502306e-02f,
  9.81048793e-02f, -6.25068024e-02f, 2.01594159e-02f, -1.06894802e-02f, -9.61119980e-02f, 6.27472531e-03f, 3.57974321e-02f, -6.49512261e-02f, 1.02328688e-01f, -3.33245546e-02f,
  1.09862983e-02f, 3.28584835e-02f, 7.24027976e-02f, -4.48488779e-02f, 6.44611418e-02f, 1.53186759e-02f, 4.16093618e-02f, 3.15715224e-02f, -4.36258651e-02f, 5.94360828e-02f,
  -4.00709100e-02f, 4.82147001e-02f, 3.50496024e-02f, 5.33994138e-02f, -9.70733538e-02f, 3.96383256e-02f, -6.35339841e-02f, 2.60150936e-02f, 1.31493080e-02f, -3.19643952e-02f,
  -2.32480407e-01f, -2.28778586e-01f, -2.77704895e-01f, -8.52074008e-03f, 7.73424879e-02f, 4.79088444e-03f, -1.03223227e-01f, -3.09389345e-02f, -9.38582271e-02f, 2.63927784e-02f,
  -7.78329046e-03f, 1.07675873e-01f, -5.77173308e-02f, 8.28956962e-02f, -2.49073812e-04f, -2.59638280e-02f, -1.58291794e-02f, -7.47828698e-03f, 1.28315851e-01f, 6.77950382e-02f,
  2.02223599e-01f, 1.02124654e-01f, 5.77453636e-02f, 1.26682058e-01f, 1.60064977e-02f, 8.10916945e-02f, -1.39283575e-02f, -2.70390809e-02f, 1.00213178e-01f, 1.08691081e-01f,
  -2.06893608e-01f, -1.88577235e-01f, -1.47074498e-02f, 3.76546532e-02f, 1.07272817e-02f, -2.98182834e-02f, -4.33611088e-02f, -9.17251185e-02f, 5.32841980e-02f, -8.73011872e-02f,
  8.44394267e-02f, 9.47257504e-02f, 6.50590509e-02f, -2.05263477e-02f, -7.28177503e-02f, -6.21876344e-02f, -3.98335755e-02f, -1.36491716e-01f, -6.82803467e-02f, -7.26919994e-02f,
  1.07499003e-01f, -6.21724240e-02f, -1.37814358e-01f, -1.47148535e-01f, -7.50117153e-02f, -8.97881538e-02f, -2.78998557e-02f, -4.81515517e-03f, -8.59816149e-02f, -9.05589536e-02f,
  -3.39548215e-02f, -7.24011511e-02f, -1.06317855e-01f, 2.56762723e-04f, 3.72272320e-02f, 6.83089942e-02f, -8.98066070e-03f, 8.50357935e-02f, -4.55534086e-02f, -1.63435731e-02f,
  4.01347391e-02f, -1.53275961e-02f, 3.99986468e-02f, 4.02726755e-02f, 5.30603752e-02f, -6.23081699e-02f, 4.96806465e-02f, -6.48511127e-02f, -6.39602765e-02f, 2.25459691e-02f,
  -8.21273029e-02f, 5.18980063e-02f, 3.80855352e-02f, 1.15326121e-01f, 3.94912250e-02f, -1.10023104e-01f, -1.16340462e-02f, -5.61278947e-02f, -3.42710279e-02f, -8.17716271e-02f,
  -1.14514768e-01f, -9.68328193e-02f, -1.47267608e-02f, -6.14422113e-02f, -1.81703549e-02f, -8.18766281e-02f, -2.77315341e-02f, -4.85297143e-02f, -4.87356186e-02f, -5.29228039e-02f,
  2.60609239e-02f, -3.53777260e-02f, -4.75123413e-02f, -1.21404277e-02f, -2.11739037e-02f, -9.44124237e-02f, 4.90618646e-02f, -8.66737813e-02f, -8.11419412e-02f, -4.74037230e-03f,
  -2.57585607e-02f, -9.08705220e-02f, -1.26245528e-01f, -8.55613276e-02f, 1.05435569e-02f, -2.24238373e-02f, -2.35221796e-02f, -4.13671024e-02f, -2.12990746e-01f, -1.49561614e-01f,
  1.64841101e-01f, 4.89681624e-02f, -5.74393161e-02f, -5.34236729e-02f, -6.17159205e-03f, -6.95157517e-03f, -1.36803435e-02f, 6.23585284e-02f, 2.52118614e-02f, 5.29219881e-02f,
  6.05398901e-02f, -1.14033118e-01f, -1.10623576e-01f, 5.00712506e-02f, -3.72408777e-02f, -2.24855654e-02f, -5.23986071e-02f, -1.07663870e-03f, 6.48840815e-02f, 1.69872381e-02f,
  5.52355945e-02f, 8.00927281e-02f, 2.50296034e-02f, 4.79392782e-02f, -8.68176818e-02f, 7.18414336e-02f, -6.74791411e-02f, -6.96445107e-02f, 1.52034452e-02f, -6.80427104e-02f,
  -5.88478409e-02f, -6.44108728e-02f, 2.41179299e-02f, 4.76939641e-02f, -8.05078521e-02f, 4.54162881e-02f, -8.45626071e-02f, 6.39827177e-03f, 7.98948258e-02f, -6.57363757e-02f,
  -1.95054021e-02f, -3.51420939e-02f, -5.55743724e-02f, 5.95566407e-02f, -3.93002070e-02f, 6.18146360e-02f, -3.85192297e-02f, -4.61877324e-02f, 1.74501147e-02f, 6.19481839e-02f,
  3.46148573e-03f, 8.23557600e-02f, -2.72817779e-02f, 7.24495715e-03f, -1.11828092e-02f, 5.86761534e-02f, 1.74376518e-02f, -6.99111596e-02f, -8.81777629e-02f, -5.35978265e-02f,
  7.59067461e-02f, 5.58352992e-02f, 5.16538993e-02f, 3.90189290e-02f, -6.13846965e-02f, -1.18317321e-01f, -6.18727393e-02f, 6.49806857e-02f, -6.28462732e-02f, 2.16506626e-02f,
  -5.73359951e-02f, 5.50045595e-02f, -7.99262375e-02f, 1.16822952e-02f, 6.37435541e-02f, -3.16876243e-03f, -5.13674952e-02f, 7.22352192e-02f, -2.94265095e-02f, 8.11362714e-02f,
  3.54067460e-02f, -1.27681755e-02f, -5.20480722e-02f, -9.91504490e-02f, -3.85852880e-03f, 2.72963718e-02f, 9.01165381e-02f, -5.47367893e-02f, 1.31521737e-02f, -1.74550563e-02f,
  1.06475152e-01f, -5.34126461e-02f, 6.07846417e-02f, -9.32817534e-02f, -4.54194238e-03f, -9.96136591e-02f, -6.94899037e-02f, 5.94701581e-02f, -3.08727603e-02f, -1.08562499e-01f,
  -2.61231791e-02f, 5.16541488e-02f, -3.98195768e-03f, 1.85954645e-02f, -1.09843593e-02f, 3.44181694e-02f, 5.10829687e-02f, -3.97560745e-03f, -1.27979247e-02f, 7.17600733e-02f,
  1.53526152e-02f, -1.30670774e-03f, -8.43574554e-02f, -2.92994380e-02f, -9.63227302e-02f, 3.61508206e-02f, 7.14605972e-02f, -2.82275807e-02f, 8.18756968e-02f, 1.21182173e-01f,
  -7.36263096e-02f, 4.91599031e-02f, 7.40914270e-02f, -1.07609034e-01f, -5.24184108e-02f, 1.90849844e-02f, -1.25814164e-02f, -5.96701168e-02f, 1.10497167e-02f, -8.99512768e-02f,
  5.29666618e-02f, -1.09748818e-01f, -5.80521720e-03f, -4.85308543e-02f, -4.84980233e-02f, -3.06661874e-02f, -1.70982424e-02f, -1.92768559e-01f, -4.75815460e-02f, -1.12725265e-01f,
  -2.10365932e-02f, -3.20784673e-02f, -1.72632456e-01f, -1.81332082e-02f, 3.07356659e-02f, -1.46647235e-02f, -6.22134991e-02f, -1.20644554e-01f, -2.79368670e-03f, -1.23551495e-01f,
  2.77370680e-02f, 1.54867411e-01f, -3.33385020e-02f, -3.23861651e-02f, -3.68488878e-02f, -7.71229193e-02f, -6.72975108e-02f, -4.19164486e-02f, 2.12890580e-02f, -4.93509043e-03f,
  -1.64300222e-02f, 5.70164323e-02f, 6.82120398e-02f, 1.68491155e-02f, 1.22760274e-02f, -5.01794741e-02f, 9.20765568e-03f, 4.07415368e-02f, -7.77671263e-02f, 3.91048864e-02f,
  5.29380441e-02f, -9.60979313e-02f, -1.21082098e-03f, -1.63543839e-02f, -3.24970558e-02f, -2.98505668e-02f, -1.93381589e-02f, 3.12711373e-02f, -2.89075691e-02f, -5.01518473e-02f,
  4.18434240e-04f, 1.21499458e-02f, 2.22955793e-02f, -3.30192186e-02f, -8.21117684e-02f, -1.50154456e-02f, 2.28184070e-02f, -1.64163318e-02f, -2.84751598e-02f, -4.54991199e-02f,
  1.37030492e-02f, 8.98183212e-02f, 1.67160369e-02f, 4.58534285e-02f, -6.67764107e-03f, -3.86582799e-02f, 6.19243346e-02f, 2.44375225e-03f, -6.41110092e-02f, 4.87923361e-02f,
  -4.16834578e-02f, 4.08069650e-03f, -4.36639749e-02f, -5.68879843e-02f, -7.47265061e-03f, 7.98711404e-02f, -3.79762575e-02f, 2.95610633e-02f, -4.53589484e-02f, 7.59906173e-02f,
  -1.24902166e-01f, -6.74806759e-02f, 6.17599227e-02f, -6.72340021e-02f, 7.04136938e-02f, -9.87696350e-02f, 6.27685264e-02f, 2.55670324e-02f, 4.90097255e-02f, 6.41119760e-03f,
  5.39946556e-02f, -9.42774341e-02f, 5.42722344e-02f, -7.09631145e-02f, 2.96120681e-02f, -8.12770799e-02f, -3.38899307e-02f, -1.10429779e-01f, -4.88236211e-02f, 2.99746748e-02f,
  -9.05124843e-02f, 1.88292540e-03f, -6.19468018e-02f, -1.34985000e-01f, 7.14373142e-02f, 1.74660105e-02f, -1.29237041e-01f, -1.81064270e-02f, -1.08785458e-01f, -1.17311999e-01f,
  -2.38142744e-01f, -1.32380694e-01f, -8.74752030e-02f, 4.81258631e-02f, 1.51890311e-02f, -6.85139447e-02f, -2.14642987e-01f, -1.14155285e-01f, 3.73551622e-02f, -6.13419376e-02f,
  7.35093206e-02f, 3.84211577e-02f, -6.63325703e-03f, -9.31171328e-03f, -1.92869619e-01f, -5.66661209e-02f, -5.03352247e-02f, -2.38371808e-02f, -7.68443644e-02f, -1.31876646e-02f,
  -6.70447499e-02f, -1.15360528e-01f, -9.11809877e-02f, -1.15696779e-02f, 8.35510623e-03f, -3.82950306e-02f, -1.01744622e-01f, 8.13386310e-03f, 1.51571194e-02f, -1.27807051e-01f,
  4.33019809e-02f, -1.81091744e-02f, -7.08880201e-02f, 5.47862761e-02f, -1.45321200e-02f, 7.59762758e-03f, 2.39240169e-03f, -3.36203538e-02f, -6.27779588e-02f, -7.94513300e-02f,
  -1.14192339e-02f, -3.33185308e-02f, -3.60841230e-02f, -6.28168583e-02f, -4.62723263e-02f, -4.67304885e-02f, -8.75825435e-02f, -3.15501094e-02f, 4.13933657e-02f, 4.74253446e-02f,
  -1.74023323e-02f, -6.18219338e-02f, -1.10234872e-01f, -1.01006210e-01f, 6.93349093e-02f, -1.07724108e-02f, -1.18662484e-01f, -1.35328332e-02f, -1.21920019e-01f, -1.94146603e-01f,
  -6.65991753e-02f, 1.61700882e-02f, 5.63384891e-02f, 1.31703597e-02f, -7.34852478e-02f, -2.85412800e-02f, 1.21960780e-02f, -9.34723243e-02f, 2.63460446e-02f, -7.25873560e-02f,
  -4.61283885e-02f, -1.42860860e-02f, -4.33805957e-02f, -6.70363829e-02f, 7.99460262e-02f, 4.80129384e-02f, -8.70839357e-02f, -1.90189518e-02f, 1.43411886e-02f, 2.81420387e-02f,
  4.55475152e-02f, -1.69112049e-02f, 5.15256748e-02f, -1.97439212e-02f, 5.99148870e-03f, 4.42306101e-02f, -6.85403571e-02f, 7.58693889e-02f, 3.64471301e-02f, 1.78408273e-03f,
  -1.36275321e-01f, 4.16291952e-02f, -1.08830504e-01f, -1.85434557e-02f, -2.15231720e-02f, 4.24447879e-02f, -7.08128661e-02f, 4.95896898e-02f, -2.32680012e-02f, 3.03902496e-02f,
  2.81343050e-02f, -7.77807832e-02f, -1.98935717e-02f, -5.27867340e-02f, 2.00665984e-02f, 1.50930230e-02f, -1.33384928e-01f, -1.42377630e-01f, -3.37608941e-02f, 6.09523791e-04f,
  -1.66490693e-02f, -2.08143547e-01f, -1.28404289e-01f, -1.39503703e-01f, -6.92894608e-02f, -9.86751169e-02f, -6.90819323e-02f, -1.43416330e-01f, -1.70563459e-01f, -1.41234949e-01f,
  3.30638699e-02f, 9.75000486e-02f, 2.47003604e-02f, 2.09022891e-02f, -7.67264664e-02f, -5.82621470e-02f, -9.20841917e-02f, 3.91627736e-02f, 4.21600677e-02f, 1.97273884e-02f,
  1.21972740e-01f, -3.91600877e-02f, -3.52701657e-02f, -5.19389547e-02f, -1.00059509e-01f, 9.43407696e-03f, -3.19588222e-02f, -1.67840868e-01f, -2.32551619e-01f, -2.32310727e-01f,
  -1.16594523e-01f, -2.21599964e-03f, -1.10554069e-01f, -1.25372827e-01f, -6.73229322e-02f, 6.50367960e-02f, -2.30734404e-02f, 4.56404537e-02f, -4.68204580e-02f, 6.86463118e-02f,
  -3.21034752e-02f, 1.33262590e-01f, -1.48727670e-01f, -4.33099791e-02f, 7.51719400e-02f, 2.17465032e-02f, -4.24105525e-02f, 3.18942890e-02f, -1.75844040e-02f, -9.38647762e-02f,
  7.79413208e-02f, -1.90640967e-02f, 1.28045771e-02f, -9.11861360e-02f, 4.96254973e-02f, -6.85526952e-02f, 5.35716973e-02f, -1.97148155e-02f, -8.78021047e-02f, -3.59149766e-03f,
  -8.85499120e-02f, 6.50668219e-02f, 6.30235374e-02f, -1.99220516e-02f, -5.14440462e-02f, -1.03277065e-01f, 3.49550247e-02f, 5.13100363e-02f, -4.54644822e-02f, 4.00548913e-02f,
  -1.42421409e-01f, -1.87497493e-02f, -7.93840066e-02f, -2.34628003e-02f, -6.19894341e-02f, 5.69738150e-02f, -8.08113888e-02f, 5.38714901e-02f, 1.16927386e-03f, -2.23091841e-02f,
  -4.41212319e-02f, -6.90362230e-02f, -4.57142442e-02f, -5.83135933e-02f, -5.03989235e-02f, -3.82782556e-02f, -8.28466490e-02f, -3.12817246e-02f, 7.72190606e-03f, -1.01953752e-01f,
  1.52973244e-02f, -8.83888453e-03f, 4.36399244e-02f, 6.59224298e-03f, 9.19849500e-02f, -7.37747084e-03f, -4.67248335e-02f, -8.54682103e-02f, -6.46688417e-02f, 2.60519199e-02f,
  -5.93958423e-02f, 3.27050351e-02f, -7.14376941e-02f, 1.46665731e-02f, -2.38843374e-02f, 5.22573963e-02f, 9.30360407e-02f, -2.57189479e-02f, 6.38754070e-02f, -1.06226234e-02f,
  -9.64902341e-03f, 1.54320551e-02f, 6.38907636e-03f, -9.54416841e-02f, -1.06598526e-01f, 6.52195327e-03f, -8.04269090e-02f, 3.40622701e-02f, 3.91597301e-02f, -8.11405480e-02f,
  8.30873549e-02f, -5.20117022e-02f, -3.75764817e-02f, -6.97743446e-02f, -1.68047752e-02f, -6.99720979e-02f, 3.88085507e-02f, 3.37765180e-02f, 5.29119037e-02f, 4.32175733e-02f,
  2.77075358e-02f, 4.95752431e-02f, 3.49056460e-02f, 1.97693050e-01f, 7.71101490e-02f, 1.55167460e-01f, 1.43363923e-01f, 1.60004094e-01f, 8.74313042e-02f, 6.78647161e-02f,
  1.53035566e-01f, 1.43654495e-01f, 1.89163923e-01f, 5.16043566e-02f, -9.18337144e-03f, 5.42511158e-02f, 3.50277461e-02f, 1.02899745e-01f, 5.18859699e-02f, 1.58095613e-01f,
  4.08065878e-02f, 8.05963948e-02f, 2.00647414e-02f, -1.72036923e-02f, 1.43654510e-01f, 4.54695383e-03f, 6.42717853e-02f, 9.75130945e-02f, -4.25511822e-02f, 7.83994794e-02f,
  1.34801036e-02f, -5.39704636e-02f, 4.39396799e-02f, 6.16466254e-02f, -1.11826055e-03f, 3.54956686e-02f, 5.28492406e-02f, -1.44838676e-01f, -6.74833059e-02f, -7.83960968e-02f,
  -1.00227602e-01f, 5.96185103e-02f, -2.55209245e-02f, 2.12723222e-02f, 3.15736681e-02f, 4.74868119e-02f, 1.35609126e-02f, -8.14137459e-02f, 7.37413317e-02f, 4.42850925e-02f,
  2.47729775e-02f, -6.00869209e-02f, 6.09552627e-03f, -5.46705201e-02f, -2.47298963e-02f, -2.36090180e-02f, -1.01135649e-01f, 1.94124617e-02f, -2.03679167e-02f, 5.24668731e-02f,
  7.27417134e-03f, 6.48442805e-02f, 7.77641758e-02f, 8.18922743e-02f, 1.00506760e-01f, 9.47471038e-02f, -1.69997942e-02f, -5.50047755e-02f, 2.04711854e-02f, 7.33112246e-02f,
  7.29533657e-02f, -3.26466048e-04f, 3.31127457e-02f, -7.26851821e-02f, 7.83069879e-02f, -5.39738946e-02f, 5.66640086e-02f, 4.82087806e-02f, 7.56164361e-03f, 6.55031428e-02f,
  -5.24131171e-02f, 6.44791499e-02f, -9.66596827e-02f, 1.08370772e-02f, 1.00805253e-01f, 4.80276272e-02f, -7.87443668e-02f, 7.62643740e-02f, -5.33356406e-02f, 1.32942181e-02f,
  -2.55983360e-02f, -6.36508316e-02f, 9.79717299e-02f, -5.10983951e-02f, 6.27816468e-02f, -1.40599580e-03f, 6.62176460e-02f, -7.96730816e-02f, -5.01134321e-02f, -2.70651765e-02f,
  -2.69837270e-04f, -2.70496812e-02f, 7.44017959e-02f, -1.00210920e-01f, -2.18297187e-02f, 1.31623233e-02f, 2.80112810e-02f, 8.98481980e-02f, 7.77522847e-02f, 2.85598915e-02f,
  8.56987685e-02f, -8.77482668e-02f, -6.41626343e-02f, 9.16612372e-02f, 1.10284518e-02f, -5.04790805e-02f, -4.68724221e-02f, -9.14919451e-02f, -4.96803261e-02f, -4.70359772e-02f,
  -2.66958356e-01f, -1.10744670e-01f, 6.19850419e-02f, 1.09938696e-01f, 6.25756383e-02f, -9.04798880e-02f, -1.22105859e-01f, -1.87642351e-01f, -4.93321568e-02f, 9.72258765e-03f,
  -6.17504045e-02f, 5.02852025e-04f, -3.21333669e-02f, 7.82188773e-02f, -6.28206953e-02f, 5.00114113e-02f, 3.79859991e-02f, 1.01021007e-01f, -2.51331460e-03f, 1.05348639e-01f,
  1.46931469e-01f, 1.33408204e-01f, 2.27686223e-02f, 1.07663676e-01f, 4.84428890e-02f, 6.09092936e-02f, 9.08200592e-02f, 1.48264140e-01f, 1.52606398e-01f, 1.15667410e-01f,
  -1.23575643e-01f, -1.98805913e-01f, 4.49442444e-03f, 1.23615317e-01f, 1.03914946e-01f, -3.39867584e-02f, -8.35783929e-02f, -5.06166182e-02f, -5.47323609e-03f, -3.62974219e-02f,
  -5.81492484e-02f, 5.20048961e-02f, -3.78940022e-03f, -2.10809652e-02f, -1.35060638e-01f, -2.36030184e-02f, -8.83711204e-02f, -1.02703221e-01f, 1.21059064e-02f, -1.12948462e-01f,
  1.57967880e-01f, 1.18177310e-02f, -6.58410490e-02f, -1.41181186e-01f, -7.51747862e-02f, -2.60899924e-02f, -6.81357533e-02f, -1.02549680e-01f, -1.38607487e-01f, -1.76657930e-01f,
  8.21267292e-02f, 3.42777520e-02f, 2.13256180e-02f, -2.53499839e-02f, -4.44616601e-02f, 3.55149843e-02f, 1.69451591e-02f, 8.13642889e-02f, -4.83407676e-02f, 2.87280343e-02f,
  -8.08175653e-02f, -1.96034461e-02f, 6.28804117e-02f, 3.70559134e-02f, 8.25193673e-02f, 3.20122810e-03f, -7.31102424e-03f, -7.16120154e-02f, 4.49876040e-02f, -6.15767352e-02f,
  -6.99542165e-02f, -3.12301777e-02f, 6.38771802e-02f, -1.10701658e-02f, -6.78539425e-02f, 4.96321097e-02f, -4.89075482e-02f, -7.14609921e-02f, 1.32736145e-02f, 5.25644235e-02f,
  -9.79578495e-02f, -1.34830800e-04f, -8.89755785e-02f, -3.79190780e-02f, -7.02887326e-02f, 1.44190213e-03f, -9.03553739e-02f, -5.94333094e-03f, -1.36678414e-02f, -8.12221318e-03f,
  -1.86145250e-02f, -8.59086290e-02f, 2.01002434e-02f, 3.25005986e-02f, 2.87957070e-03f, -2.89094094e-02f, 8.01142156e-02f, -3.18391547e-02f, 2.95096803e-02f, 1.47294458e-02f,
  9.55898464e-02f, -2.64414791e-02f, -9.29735005e-02f, -1.35312870e-01f, -5.96885122e-02f, 5.57355583e-02f, -9.87796634e-02f, -7.96573460e-02f, -1.57101810e-01f, -6.72309101e-02f,
  -2.57709354e-01f, -6.05418533e-02f, -2.52725691e-01f, -2.43758798e-01f, -1.26028117e-02f, 5.61024621e-02f, 1.12017188e-02f, 9.45813954e-02f, -1.21395618e-01f, -1.06115036e-01f,
  -4.82219197e-02f, -8.08641016e-02f, -9.90286842e-02f, -1.31889200e-02f, -8.26873034e-02f, -1.16667695e-01f, -2.18500659e-01f, -1.97014332e-01f, -1.51882410e-01f, -4.33428213e-03f,
  -9.93262306e-02f, -1.53009236e-01f, -1.71647459e-01f, 1.88258104e-02f, -2.88524367e-02f, -7.95363728e-03f, -6.62158206e-02f, -1.48064792e-01f, -1.81694441e-02f, -1.92520376e-02f,
  -1.50584966e-01f, 5.48236445e-02f, -5.33665866e-02f, -6.07802942e-02f, -5.93641363e-02f, -1.54615138e-02f, -3.88697162e-02f, -7.83304498e-02f, -5.92941567e-02f, 2.46260921e-03f,
  -4.31937240e-02f, 9.46687162e-02f, -8.29174835e-03f, 4.64070439e-02f, -3.10011338e-02f, -3.64444293e-02f, -2.83502098e-02f, 2.10718513e-02f, -6.04575872e-02f, 6.68616518e-02f,
  7.60001093e-02f, -4.57727648e-02f, 1.71131156e-02f, 9.17143300e-02f, 4.84538004e-02f, -6.36257455e-02f, 2.87908763e-02f, 5.13721257e-02f, 8.73814449e-02f, 6.91222623e-02f,
  -5.52449701e-03f, 2.18054298e-02f, 4.25731167e-02f, 9.84191820e-02f, -2.58120783e-02f, 4.15122919e-02f, -1.52907223e-02f, -7.12223649e-02f, 1.77261978e-02f, -5.70157357e-02f,
  2.13292260e-02f, 3.63121070e-02f, -8.35164756e-05f, -5.87067083e-02f, 4.59460132e-02f, -3.93938459e-02f, -5.41891940e-02f, 5.52177951e-02f, -5.09156324e-02f, 2.15634350e-02f,
  -1.53840566e-02f, 7.28857296e-04f, 7.85372257e-02f, 5.17997183e-02f, 1.76353622e-02f, 4.88574877e-02f, -5.42961014e-03f, 1.17669053e-01f, -5.01371473e-02f, -5.04171699e-02f,
  -1.49975091e-01f, 8.07631761e-02f, -9.86741409e-02f, 7.57223591e-02f, -8.66114199e-02f, -5.44438101e-02f, -4.76382226e-02f, -5.08099683e-02f, -4.59944569e-02f, 6.91328198e-02f,
  1.14916004e-01f, -4.47209850e-02f, -8.82057026e-02f, 8.73938426e-02f, 4.78053503e-02f, -4.25591432e-02f, -5.12438156e-02f, -1.55923492e-03f, 3.89210734e-04f, 4.51106764e-02f,
  1.11751026e-02f, -8.50869045e-02f, 7.10829394e-03f, -1.43138496e-02f, 1.41675010e-01f, 5.72898798e-03f, -3.62206884e-02f, 8.40882435e-02f, 4.06618416e-02f, -1.16683818e-01f,
  1.07611537e-01f, -2.90104430e-02f, 9.55969617e-02f, 3.99419554e-02f, 5.93595281e-02f, 1.69230118e-01f, 1.54689595e-01f, -1.25962601e-03f, -1.02021582e-01f, -5.31847849e-02f,
  1.99118443e-02f, -1.75525233e-01f, -1.08378321e-01f, -6.09003156e-02f, 3.94688696e-02f, 5.50295152e-02f, 3.51170413e-02f, -4.38459218e-02f, 2.14237049e-02f, -3.78809236e-02f,
  -4.01263637e-03f, 3.94241996e-02f, 1.68465655e-02f, 3.11888512e-02f, -1.61321741e-02f, -2.53289118e-02f, 1.07989416e-01f, 2.36291508e-03f, 6.48730323e-02f, 7.10292086e-02f,
  6.22232817e-03f, 7.65509307e-02f, 7.44859828e-03f, -1.18525565e-01f, 6.56945109e-02f, 3.86637077e-02f, 5.65473139e-02f, -2.86664218e-02f, -7.66640306e-02f, 9.08344015e-02f,
  -2.39809323e-02f, -1.08125664e-01f, -1.07378379e-01f, 9.98809841e-03f, 5.11647481e-03f, -3.25735733e-02f, 4.98506613e-02f, -2.67537776e-02f, -7.50871748e-02f, -5.79109304e-02f,
  -1.28559947e-01f, -4.87151518e-02f, 1.13008860e-02f, -2.46734992e-02f, -4.24464121e-02f, 6.04160363e-04f, 7.03471377e-02f, -5.37183769e-02f, 4.08325568e-02f, -6.45645186e-02f,
  -7.19006062e-02f, -1.18377153e-02f, -8.84264559e-02f, 1.16052590e-02f, 5.49761169e-02f, -1.77030303e-02f, 1.06663108e-01f, 4.67341132e-02f, 1.23987375e-02f, 9.62591264e-03f,
  1.12917116e-02f, 1.12961821e-01f, 1.98523737e-02f, -1.91414133e-02f, 2.86092646e-02f, 9.51631367e-02f, 7.75079876e-02f, -4.59981896e-03f, -4.11052853e-02f, 3.54474597e-02f,
  2.63122264e-02f, 9.26848203e-02f, 6.46784008e-02f, 6.69853166e-02f, 5.24163898e-03f, 7.93359429e-02f, 4.86632288e-02f, 5.98512068e-02f, 2.63912641e-02f, -4.79330756e-02f,
  1.44214138e-01f, -1.88814476e-02f, -2.85136164e-03f, -4.13712561e-02f, 4.03033979e-02f, 2.79599577e-02f, 4.97450866e-02f, -7.56432936e-02f, -2.13923864e-02f, 9.07539576e-02f,
  -7.44488090e-02f, 3.67832221e-02f, -1.79792941e-02f, 8.93223509e-02f, -3.63870747e-02f, 4.06540595e-02f, 3.36066913e-03f, 9.04246643e-02f, -8.75102207e-02f, 2.54816506e-02f,
  5.98419532e-02f, 1.04377031e-01f, 1.02864288e-01f, -3.77201475e-02f, 5.64764850e-02f, -6.63705766e-02f, -3.83664807e-03f, 8.50946903e-02f, 5.19524217e-02f, 1.82898715e-01f,
  2.07215458e-01f, -1.23501169e-02f, 1.29422471e-01f, 1.27187669e-01f, -8.40646252e-02f, -6.00681938e-02f, -1.44595340e-01f, -4.81126346e-02f, 4.44952026e-02f, 1.19849160e-01f,
  -1.77427754e-02f, -6.72878549e-02f, 7.68379420e-02f, 3.98165286e-02f, 6.32866248e-02f, 9.66819301e-02f, -1.51926260e-02f, 1.66414306e-01f, 5.35644665e-02f, 1.18396841e-01f,
  -2.89852917e-02f, 2.54670903e-02f, 9.96007100e-02f, -9.49502923e-03f, 3.52837890e-02f, 1.17387801e-01f, 4.29917499e-02f, 1.27286717e-01f, -1.15015090e-03f, 6.67901039e-02f,
  1.73941538e-01f, 1.19298734e-01f, 2.73258947e-02f, 4.98185530e-02f, -9.02707502e-02f, -1.33366520e-02f, -3.65662090e-02f, -5.07725440e-02f, 5.97157925e-02f, -7.51739666e-02f,
  -6.65044934e-02f, 1.77557990e-02f, 6.82471842e-02f, -6.39419034e-02f, 1.12435129e-02f, 5.64549044e-02f, -4.00431780e-03f, 5.44647053e-02f, -1.82476155e-02f, 7.02457502e-02f,
  -1.92959532e-02f, 8.65876004e-02f, 6.49425164e-02f, -1.08542815e-01f, -4.16850112e-02f, -2.21539997e-02f, 5.11764325e-02f, 7.73810074e-02f, -2.76450831e-02f, 1.34402104e-02f,
  6.98098764e-02f, 2.88025825e-03f, 3.53637896e-02f, 7.43478760e-02f, 3.88705321e-02f, 3.55482213e-02f, -5.22337947e-03f, -6.83679655e-02f, 7.32173994e-02f, -3.85308750e-02f,
  9.86579359e-02f, -1.77901704e-02f, -6.06452674e-03f, 8.84222910e-02f, -4.24832366e-02f, 9.03508905e-03f, -1.05643431e-02f, 1.03392731e-02f, -3.87255214e-02f, 2.45479997e-02f,
  -4.17635636e-03f, 2.71043442e-02f, 5.24232015e-02f, 4.79222052e-02f, -1.90311261e-02f, 8.12924728e-02f, 9.73946527e-02f, 6.50626868e-02f, 3.69469635e-02f, -1.03645613e-02f,
  -1.55706957e-01f, -1.92166165e-01f, 9.26020145e-02f, 9.20977667e-02f, -4.20000069e-02f, -2.22985670e-02f, -4.15587425e-02f, 2.32685376e-02f, -6.07154444e-02f, -3.43761221e-02f,
  4.22795862e-02f, -3.23000289e-02f, -7.65235126e-02f, -6.89962506e-02f, 5.30412421e-02f, -8.09417386e-03f, -8.01255405e-02f, 6.79684132e-02f, 1.58452392e-02f, -7.44423270e-02f,
  -1.16928771e-01f, 6.78908303e-02f, -1.65213738e-02f, -1.24041826e-01f, -1.85917486e-02f, -3.61601412e-02f, -8.87731910e-02f, 1.95155740e-02f, -1.12670481e-01f, 1.80150159e-02f,
  7.42759332e-02f, -7.91223943e-02f, -1.29847890e-02f, 8.94744024e-02f, 6.28948212e-02f, 6.64785951e-02f, -5.84287010e-02f, -2.34689247e-02f, -1.03530418e-02f, 1.38589084e-01f,
  1.59145623e-01f, 1.32605001e-01f, 6.66878447e-02f, -2.67147850e-02f, -1.08200848e-01f, -7.85286129e-02f, 4.08767015e-02f, -5.48776649e-02f, -6.82436163e-03f, 9.49029997e-02f,
  4.29519936e-02f, 8.22436123e-04f, 7.09300339e-02f, 8.17636785e-04f, 1.05600573e-01f, 4.75525968e-02f, 1.20636545e-01f, 2.25908104e-02f, -3.02362572e-02f, 6.05920330e-03f,
  9.39257815e-03f, -5.26862144e-02f, 1.04324862e-01f, 2.92081721e-02f, 5.52649498e-02f, 4.04005796e-02f, 1.14037525e-02f, 1.46212289e-02f, -7.69068524e-02f, 4.70489562e-02f,
  1.22811101e-01f, 6.25336589e-03f, 3.95448320e-02f, -5.82692847e-02f, 8.26649293e-02f, -5.58166429e-02f, -9.20749903e-02f, -8.77012461e-02f, -1.02711301e-02f, 7.77806491e-02f,
  3.05204391e-02f, 1.44222468e-01f, 2.98115034e-02f, -1.46205844e-02f, -8.01368281e-02f, 1.12824827e-01f, 5.44050802e-03f, -7.85457864e-02f, 6.70019686e-02f, 6.89069405e-02f,
  1.33278564e-01f, 8.37692991e-02f, 1.45644299e-03f, -1.24446629e-02f, 1.43222539e-02f, -1.21352216e-03f, -2.42547859e-02f, -3.48973349e-02f, 3.58422957e-02f, 8.42907801e-02f,
  -6.23864532e-02f, -3.38470116e-02f, 9.72472653e-02f, 6.59837648e-02f, 8.92466828e-02f, -4.56512868e-02f, 8.00940320e-02f, -5.76745383e-02f, 2.34151930e-02f, 1.07719064e-01f,
  -1.11467205e-03f, -5.52453510e-02f, 1.28581047e-01f, -6.36862218e-02f, -2.64303815e-02f, 1.16064049e-01f, 1.14547983e-01f, 1.14741363e-01f, 3.00129969e-02f, 1.18374258e-01f,
  6.48958236e-02f, 4.36825268e-02f, 1.36438804e-02f, -2.09731087e-02f, -1.19138621e-02f, -7.27752671e-02f, -4.53907326e-02f, -6.50617480e-02f, -4.53806035e-02f, -3.55981961e-02f,
  8.02305937e-02f, 7.61499107e-02f, -5.64621910e-02f, -4.33003455e-02f, -1.82136502e-02f, 2.20318027e-02f, -9.94207710e-03f, -8.65214244e-02f, -3.70897278e-02f, -8.03291872e-02f,
  3.85618210e-02f, 5.97156882e-02f, 5.69648184e-02f, 3.07244752e-02f, 1.72839742e-02f, 1.70046203e-02f, -4.95977327e-02f, -7.47790262e-02f, -4.79203090e-02f, 6.56306893e-02f,
  -4.30660218e-01f, 1.70924306e-01f, 1.90365016e-02f, -2.00314075e-01f, 3.14819068e-02f, 1.87687457e-01f, 2.09673092e-01f, 9.50097889e-02f, -1.90390870e-02f, 3.59304138e-02f,
  -7.21033290e-02f, -9.06458050e-02f, -8.19507465e-02f, -7.86327869e-02f, 1.09095477e-01f, 1.65678918e-01f, 8.58786777e-02f, -7.91038424e-02f, -1.01309948e-01f, -9.37289819e-02f,
  9.30840969e-02f, -1.97331980e-01f, -1.82579875e-01f, -1.36541441e-01f, -3.95547263e-02f, 3.60856242e-02f, 4.83148172e-03f, -1.01486541e-01f, 6.69204295e-02f, -5.88290766e-02f,
  1.20325066e-01f, -2.26329178e-01f, 8.08623135e-02f, -1.91490930e-02f, 6.00992255e-02f, -5.57551254e-03f, -9.05908570e-02f, -4.53944271e-03f, 5.99126704e-02f, 9.67210829e-02f,
  3.94541491e-03f, -1.16733558e-01f, -3.30236889e-02f, 6.46013767e-03f, -6.78341687e-02f, 4.35207933e-02f, -1.36519641e-01f, -8.19056779e-02f, -1.87273249e-02f, -3.58989537e-02f,
  -6.76530180e-03f, -3.85405459e-02f, 7.49032795e-02f, 1.15933828e-01f, -8.66970196e-02f, -3.74495946e-02f, 5.57324328e-02f, -6.77046552e-02f, -1.27609195e-02f, -5.20421006e-03f,
  6.05721325e-02f, 2.26079281e-02f, 4.38250937e-02f, 1.96952038e-02f, -8.22184533e-02f, -4.36312705e-02f, -7.35795498e-02f, 5.83091453e-02f, -3.73218916e-02f, 5.27243912e-02f,
  -3.28531340e-02f, 9.97490901e-03f, -5.33130318e-02f, -5.94293810e-02f, 6.97874799e-02f, 5.56438342e-02f, -3.93052809e-02f, 2.78662760e-02f, 1.33839957e-02f, 1.56508312e-02f,
  -3.35941985e-02f, 6.13391176e-02f, 4.62541245e-02f, 5.45077473e-02f, -6.65266253e-03f, -9.39960871e-03f, -3.54300998e-02f, 2.10588519e-02f, -3.32024172e-02f, -6.51985407e-02f,
  -1.08836204e-01f, -2.63081398e-02f, -6.92140609e-02f, -4.58643911e-03f, 5.67187788e-03f, -7.04054208e-03f, -1.57737788e-02f, 1.00113556e-01f, -1.80579051e-02f, 8.22555423e-02f,
  3.27797495e-02f, 3.81568596e-02f, -6.06812946e-02f, 8.11195970e-02f, 5.97882308e-02f, 3.49937677e-02f, -4.20141891e-02f, -2.83211712e-02f, 1.21625349e-01f, 2.47747526e-02f,
  1.32552117e-01f, -1.50826024e-02f, -1.32399509e-02f, 3.79632488e-02f, 2.28572972e-02f, -2.18655616e-02f, 2.66971122e-02f, 1.39161900e-01f, -4.97063110e-03f, 1.52982682e-01f,
  2.17004448e-01f, -1.50086395e-02f, 2.78863013e-02f, 8.10396224e-02f, -8.89488235e-02f, -1.30917639e-01f, -6.54222369e-02f, 4.90462482e-02f, 8.09856802e-02f, 2.53784452e-02f,
  1.28681809e-01f, 5.71415294e-03f, 8.31393339e-03f, 1.30164595e-02f, 1.85534265e-02f, -1.16279460e-01f, -9.14694741e-02f, -4.00574096e-02f, -6.65015876e-02f, 8.69734958e-02f,
  -6.19887002e-03f, 7.27600232e-02f, 1.18282303e-01f, 9.25730243e-02f, 7.04656839e-02f, 3.58304046e-02f, 5.79055818e-03f, 4.41034846e-02f, 2.08956003e-02f, 1.64188638e-01f,
  5.93150556e-02f, 1.49225011e-01f, 4.53955717e-02f, -1.66081376e-02f, -5.43321036e-02f, -4.29838113e-02f, 3.86207029e-02f, 5.10119647e-02f, -1.95889664e-03f, 2.59647015e-02f,
  7.48404562e-02f, 7.06069693e-02f, 8.12173337e-02f, -9.40994769e-02f, 3.15057561e-02f, 5.89319244e-02f, -6.86919689e-02f, 3.60272825e-02f, -3.52282114e-02f, 4.19269549e-03f,
  5.50111048e-02f, -4.53153327e-02f, -1.24026351e-02f, -1.10406145e-01f, -1.49132200e-02f, -1.75658166e-02f, -2.09883284e-02f, 8.21281075e-02f, 4.44585234e-02f, 1.00238882e-01f,
  -1.19717345e-02f, 2.74716821e-02f, 7.49775814e-03f, -4.20682766e-02f, -4.77080457e-02f, -8.04885402e-02f, -1.56837124e-02f, -8.83431807e-02f, -8.63535479e-02f, -6.54602125e-02f,
  3.70717123e-02f, 4.90779132e-02f, -2.02807952e-02f, 4.90714572e-02f, -8.66258442e-02f, -9.74173695e-02f, -2.25420985e-02f, -3.63983884e-02f, -4.22304608e-02f, -8.76008198e-02f,
  -6.09450229e-02f, 2.68795881e-02f, 1.73845515e-02f, 6.55006170e-02f, 6.33581430e-02f, 2.83624325e-02f, 6.90275356e-02f, 6.84553683e-02f, 1.47188082e-02f, -3.50967906e-02f,
  1.73112396e-02f, 1.93126462e-02f, -1.79786291e-02f, 6.83245212e-02f, -1.96928494e-02f, 1.01320911e-02f, 4.83346358e-03f, -5.28103523e-02f, -2.42257714e-02f, -4.69033867e-02f,
  -4.66541424e-02f, -3.64868380e-02f, -5.84949367e-02f, 2.65829451e-02f, -5.29268086e-02f, -2.91128792e-02f, 1.23480959e-02f, -4.18044217e-02f, -4.26546633e-02f, -9.30036902e-02f,
  -6.13472462e-02f, 4.50815484e-02f, -1.12199821e-01f, -1.06747441e-01f, -1.10097401e-01f, 6.25710413e-02f, -9.70068127e-02f, -8.22608452e-03f, -6.57636151e-02f, 1.28018549e-02f,
  -6.16924502e-02f, -2.22026587e-01f, 4.00815792e-02f, 9.39817727e-02f, -2.21397784e-02f, -2.07226336e-01f, -2.85435200e-01f, -2.48657480e-01f, -1.05191045e-01f, -1.16972141e-02f,
  3.01850829e-02f, 1.76023960e-01f, 1.47099912e-01f, -2.36735810e-02f, -1.31155267e-01f, -7.05415010e-02f, 6.73125759e-02f, 7.65617862e-02f, 4.51251343e-02f, -5.36593609e-02f,
  9.87518653e-02f, 8.46296251e-02f, 6.99778274e-02f, -2.88338773e-02f, 8.60096365e-02f, 1.79064333e-01f, -6.59837062e-03f, 7.41599351e-02f, 7.16343969e-02f, 1.95507199e-01f,
  8.76391772e-04f, -1.24204546e-01f, 5.13930842e-02f, 9.95295793e-02f, 1.60548598e-01f, -1.06698245e-01f, 2.51247305e-02f, -4.42401767e-02f, -8.86478797e-02f, 3.09299603e-02f,
  4.78429496e-02f, -5.69701828e-02f, 8.56247246e-02f, -2.20227279e-02f, 1.58664193e-02f, -1.24791488e-01f, -7.86644518e-02f, 7.34182540e-04f, 3.43093537e-02f, -1.05069906e-01f,
  -3.60249467e-02f, 1.76734105e-02f, -7.83627257e-02f, -5.28277494e-02f, -4.03033085e-02f, 1.32538289e-01f, 1.10885222e-02f, -7.93911293e-02f, -1.09650619e-01f, -1.06228322e-01f,
  2.17450410e-02f, -7.48769846e-03f, 3.05759124e-02f, 2.43709739e-02f, 5.09019792e-02f, 3.87533791e-02f, 3.50751989e-02f, 6.74767643e-02f, 5.67969680e-03f, -4.54091281e-02f,
  6.30676225e-02f, -3.44897411e-03f, 3.68567891e-02f, -7.64048025e-02f, 1.07849322e-01f, -4.16412856e-03f, 5.67191504e-02f, 1.35910772e-02f, -1.75887942e-02f, 1.28081618e-02f,
  4.28362237e-03f, -3.89128588e-02f, 8.92440081e-02f, 9.10753664e-03f, 1.46999611e-02f, 7.79338852e-02f, 5.48420064e-02f, 2.53718290e-02f, 4.05655131e-02f, 3.48602310e-02f,
  5.58065809e-02f, 1.04472399e-01f, 5.02671786e-02f, -3.50521505e-02f, 9.25794020e-02f, 7.47909993e-02f, 6.16432093e-02f, 6.64760396e-02f, 1.13616951e-01f, 9.54647828e-03f,
  -1.02362558e-01f, -6.91500381e-02f, -1.50789041e-03f, -8.33602399e-02f, 8.44994839e-03f, -4.04333376e-04f, 3.84917408e-02f, 8.25720504e-02f, -1.80872530e-02f, -4.23930883e-02f,
  -4.96470034e-02f, -5.73985614e-02f, -9.51113701e-02f, -1.48404956e-01f, -1.79047212e-02f, 7.21333325e-02f, -1.31845087e-01f, 2.20446624e-02f, -1.49599150e-01f, -2.04397246e-01f,
  -3.01640570e-01f, -1.94943622e-01f, -1.60293326e-01f, -2.34703958e-01f, -4.65528592e-02f, 1.22306412e-02f, 1.72782242e-01f, -6.73682690e-02f, -1.10616989e-01f, -2.29692627e-02f,
  -1.86423119e-02f, -2.69194692e-02f, -6.85025305e-02f, -8.48435014e-02f, 2.54916251e-02f, 2.52175443e-02f, -1.39123723e-01f, -6.81762099e-02f, -3.96233536e-02f, 2.77479142e-02f,
  -4.96746227e-02f, -2.03015298e-01f, -1.60346404e-01f, 1.50071215e-02f, -1.09293178e-01f, -1.42484233e-01f, -1.65411249e-01f, -1.05517335e-01f, -3.53298150e-03f, -1.42746747e-01f,
  -6.79153502e-02f, -1.85172912e-03f, 4.84025925e-02f, 3.82983461e-02f, -5.88885210e-02f, 5.78760803e-02f, 8.26816186e-02f, -1.50477067e-02f, -1.95747651e-02f, -1.03223182e-01f,
  3.14624719e-02f, -4.36834022e-02f, -8.85048509e-02f, 3.84449624e-02f, 2.07594340e-03f, 2.91615222e-02f, -5.80242649e-02f, -6.28327578e-02f, 5.06191850e-02f, 8.90985802e-02f,
  1.24664921e-02f, 9.79488790e-02f, -1.69091653e-02f, 5.28960936e-02f, 1.05629839e-01f, 2.13901382e-02f, 2.14549918e-02f, -2.51657832e-02f, 1.15826741e-01f, -8.87492150e-02f,
  4.12566736e-02f, -4.92969863e-02f, -3.23764570e-02f, 3.61240581e-02f, 7.00706914e-02f, -7.37166107e-02f, -1.77442729e-02f, 2.95537729e-02f, 6.39184320e-04f, -3.41358408e-02f,
  -1.67423617e-02f, -5.07456367e-04f, 5.72219379e-02f, -8.89923330e-03f, -8.40847120e-02f, -7.41990581e-02f, 8.80464911e-02f, 6.39030039e-02f, 7.16488855e-03f, -1.30289122e-02f,
  2.06581261e-02f, -6.11855164e-02f, -8.98007080e-02f, -1.16292899e-02f, 3.47481743e-02f, 4.78531979e-02f, -1.42807076e-02f, -3.79212899e-03f, 3.23435552e-02f, 2.87082489e-03f,
  -2.21598998e-01f, 1.71870723e-01f, -4.69656056e-03f, 3.21610235e-02f, 1.70267688e-03f, 6.44268021e-02f, 1.62781170e-03f, 6.89990865e-03f, -4.35307473e-02f, -8.14668543e-04f,
  -8.91416147e-03f, -7.77113484e-03f, -9.52556878e-02f, 6.64727688e-02f, -5.95032945e-02f, -3.38854082e-02f, 4.92954068e-02f, -8.28897879e-02f, 9.33681950e-02f, -5.56984060e-02f,
  3.59793864e-02f, 2.78055109e-02f, -6.47794921e-03f, -8.13945383e-02f, -2.48020981e-02f, -8.69145915e-02f, -1.05550580e-01f, -7.36560225e-02f, -7.86662027e-02f, -1.17868870e-01f,
  -1.85014546e-01f, -1.51515841e-01f, 5.86312748e-02f, -7.17681870e-02f, 4.06047180e-02f, 4.42209728e-02f, 8.27719793e-02f, 1.90902054e-02f, -1.53895942e-02f, -1.30247116e-01f,
  -8.78185034e-02f, 7.40782097e-02f, -3.68704572e-02f, 3.91842611e-02f, 9.95621011e-02f, -8.33012350e-03f, -7.53562078e-02f, 8.48745555e-02f, 1.08119234e-01f, 4.86678444e-03f,
  -4.09483798e-02f, -2.61704084e-02f, -1.43065050e-01f, -1.43059492e-01f, -2.48641148e-02f, 3.21162269e-02f, 1.42129147e-02f, -1.44138962e-01f, -2.34271027e-02f, -4.53938171e-02f,
  2.10408241e-01f, -1.78169072e-01f, 5.85763380e-02f, -1.10440664e-02f, 5.71795925e-02f, -1.31548913e-02f, 4.71787825e-02f, -1.01370774e-01f, -6.86616823e-02f, -3.39849479e-02f,
  -1.01931803e-01f, -4.23023524e-03f, -3.49781364e-02f, 3.93116102e-03f, -4.53359298e-02f, 3.36543694e-02f, -8.80164802e-02f, -7.84068182e-02f, -2.08661780e-02f, -4.48747389e-02f,
  3.78546491e-02f, 6.38823137e-02f, -2.54064240e-03f, 3.53634208e-02f, -3.77095565e-02f, -4.06916589e-02f, -4.04565409e-02f, 1.65129676e-02f, -3.05992477e-02f, -4.49766703e-02f,
  -4.25339751e-02f, -1.33659001e-02f, 8.44719186e-02f, -1.92851536e-02f, -1.22297732e-02f, -7.87203573e-03f, -6.84931129e-02f, -6.32907450e-02f, 6.46193624e-02f, -1.78269949e-02f,
  -5.83150163e-02f, -2.19471268e-02f, 3.46161462e-02f, -1.57089885e-02f, 4.07204032e-02f, 7.36127868e-02f, 2.21990496e-02f, -5.33208214e-02f, -1.03565156e-02f, 2.27254592e-02f,
  -1.48336738e-02f, -2.85588540e-02f, -2.87293252e-02f, -7.10646063e-02f, 3.68487649e-02f, -2.26904619e-02f, -1.84745975e-02f, 2.30431333e-02f, -6.31246762e-03f, -1.11775063e-02f,
  4.57159840e-02f, 1.26477014e-02f, -2.62246095e-02f, -7.56441010e-03f, 2.31780205e-02f, -7.66581967e-02f, -2.10815351e-02f, -3.65698338e-02f, -5.93153872e-02f, 1.11539647e-01f,
  6.52324632e-02f, -7.72062875e-03f, 2.12964267e-02f, 7.74556845e-02f, 1.49946464e-02f, -3.64612602e-02f, 1.06274467e-02f, -5.36917374e-02f, 4.66729775e-02f, 4.61456999e-02f,
  -6.37269989e-02f, -2.14661025e-02f, 1.05593719e-01f, 7.05599412e-02f, 6.91988021e-02f, 1.53110638e-01f, 1.20584846e-01f, 4.11961377e-02f, 3.19708213e-02f, 7.08049238e-02f,
  9.07792151e-02f, 1.12421080e-01f, 1.02746658e-01f, 1.20976634e-01f, -1.17373064e-01f, -1.43453643e-01f, -1.62106618e-01f, -1.12322241e-01f, 7.37605896e-03f, 2.75306143e-02f,
  7.11825630e-03f, 5.45937149e-03f, -6.56823814e-02f, -3.33254188e-02f, -1.42999232e-01f, 6.82898015e-02f, -4.43530343e-02f, -1.45514324e-01f, -2.12543279e-01f, -1.60051897e-01f,
  -1.35537520e-01f, -3.71761657e-02f, -1.06171615e-01f, -5.52049242e-02f, 1.15334749e-01f, -8.73188302e-02f, 4.14092392e-02f, -3.65948416e-02f, -1.51153803e-01f, 5.11581916e-03f,
  6.37623221e-02f, 4.91540821e-04f, -8.90783817e-02f, -8.73126164e-02f, 4.05947007e-02f, -4.30508191e-03f, -8.62887502e-03f, 9.04816464e-02f, -2.40082722e-02f, -2.84658596e-02f,
  6.85192496e-02f, 6.32650852e-02f, 1.45716174e-02f, 3.80910076e-02f, -6.68663308e-02f, 1.09151360e-02f, -4.31023128e-02f, 9.12193954e-02f, -6.22006841e-02f, 7.52271116e-02f,
  -3.40943001e-02f, -9.99955535e-02f, -2.59989742e-02f, -1.31593058e-02f, -3.62868384e-02f, 5.44707105e-02f, -3.09584495e-02f, -2.33822037e-02f, -3.96797881e-02f, 6.47741109e-02f,
  3.97535190e-02f, -3.51973549e-02f, -8.26164410e-02f, -1.07385572e-02f, -1.00307819e-03f, 4.75971736e-02f, -2.84416426e-04f, -5.11606894e-02f, -4.98970598e-02f, -4.06317152e-02f,
  3.50056738e-02f, 3.52404490e-02f, -5.67162503e-03f, -2.47999597e-02f, -8.64253752e-03f, 6.26492351e-02f, -7.15950504e-02f, -8.28262642e-02f, -9.71004069e-02f, 1.26524372e-02f,
  -8.06261301e-02f, -5.43929152e-02f, -6.36838749e-02f, -9.09555927e-02f, -5.05735278e-02f, 9.99842435e-02f, 7.00727999e-02f, -4.79500182e-02f, 9.99687091e-02f, -5.26072159e-02f,
  5.66596910e-02f, -1.36555851e-01f, 2.97193993e-02f, -4.91265766e-02f, 4.49882820e-03f, -2.01236364e-02f, 7.08511248e-02f, 4.23966348e-02f, -5.87419122e-02f, -4.25841995e-02f,
  -1.18189707e-01f, 2.98939347e-02f, 1.17777601e-01f, -8.18959028e-02f, -1.05131082e-01f, 4.05395478e-02f, 6.68630749e-03f, -9.33069363e-02f, 1.11843795e-02f, -1.77467465e-02f,
  1.46004567e-02f, 6.20967057e-03f, 7.85181765e-03f, -4.08877060e-02f, 7.53980055e-02f, 1.56856216e-02f, -8.14057663e-02f, -3.81597877e-02f, -2.70216316e-02f, 1.11764595e-02f,
  5.56890257e-02f, -1.75957324e-03f, -3.22481245e-02f, 1.03459381e-01f, 1.91053316e-01f, 1.90162539e-01f, 1.84725672e-01f, -5.54440171e-03f, 1.51975706e-01f, 1.73041821e-01f,
  1.00942180e-01f, 1.74035519e-01f, 2.00404316e-01f, 8.34729448e-02f, 6.40166774e-02f, 5.71764074e-02f, 9.87630058e-03f, 7.25405663e-02f, 1.84706654e-02f, 7.16496482e-02f,
  1.50287434e-01f, -1.72378253e-02f, 4.60273661e-02f, 9.47032571e-02f, -1.42274695e-02f, 1.44871399e-01f, 4.41961177e-02f, -1.27056250e-02f, -6.61449134e-02f, -6.49519637e-02f,
  1.16628677e-01f, -5.45861647e-02f, 4.77635907e-03f, 8.65562931e-02f, -2.73588616e-02f, -1.83991026e-02f, -6.04621470e-02f, -1.14151895e-01f, -8.28920752e-02f, -4.63767275e-02f,
  -7.60971010e-02f, 1.77744236e-02f, -3.46082523e-02f, -8.96061361e-02f, 6.23428747e-02f, -1.13510182e-02f, -6.69755414e-02f, 4.20924947e-02f, 5.28484732e-02f, -1.01190113e-01f,
  -1.48483156e-03f, -5.02947792e-02f, -8.31429884e-02f, 3.52363288e-02f, -7.99977705e-02f, -3.43129262e-02f, -2.42717601e-02f, 5.42080849e-02f, 4.35384624e-02f, -7.61876702e-02f,
  -4.27025259e-02f, 8.37061927e-02f, -5.48481531e-02f, -4.04086933e-02f, -2.03018896e-02f, 5.82834780e-02f, -6.32568300e-02f, 8.98361579e-02f, -8.42705742e-02f, 1.72735238e-03f,
  -2.17275377e-02f, 7.73121342e-02f, 5.52494116e-02f, 4.20328192e-02f, 2.13086735e-02f, -3.19114998e-02f, 5.74779958e-02f, -9.36816409e-02f, -1.24973124e-02f, 2.06430275e-02f,
  -7.12631419e-02f, -1.44664226e-02f, -3.20292823e-02f, -2.24674176e-02f, -8.27621901e-04f, 8.33225623e-02f, -4.82070781e-02f, 6.95047854e-03f, 7.90264755e-02f, 6.15680516e-02f,
  6.90029711e-02f, -1.00119021e-02f, -4.40669106e-03f, -1.24683941e-03f, -7.72310868e-02f, -1.16108507e-01f, 8.70249048e-02f, -5.98052852e-02f, -5.83389513e-02f, -1.09409131e-02f,
  7.12182447e-02f, -2.93330830e-02f, -6.16011433e-02f, -6.09263331e-02f, -2.47480795e-02f, 5.73741496e-02f, 3.53570916e-02f, 8.85427184e-03f, -1.00223675e-01f, 1.00100171e-02f,
  5.82525767e-02f, 1.10303141e-01f, 6.42515793e-02f, -1.77140124e-02f, 3.22623998e-02f, 6.68729916e-02f, -8.79085343e-03f, 1.71757657e-02f, -2.39969250e-02f, 3.81340906e-02f,
  -2.92756818e-02f, 4.11765501e-02f, 7.86036700e-02f, -2.01868460e-01f, -7.56700411e-02f, 1.18320748e-01f, 1.28791705e-01f, -9.26850140e-02f, -7.64110172e-03f, -6.40488714e-02f,
  1.36987373e-01f, 5.22869043e-02f, -9.02134925e-02f, -6.49126917e-02f, 2.40859436e-03f, 2.93877665e-02f, -1.22983702e-01f, -6.78093210e-02f, 3.64106782e-02f, -2.69386955e-02f,
  -6.69123381e-02f, 2.79373163e-03f, -1.24650232e-01f, -1.15704186e-01f, -1.19688481e-01f, -3.64592001e-02f, 2.27188673e-02f, -1.31048188e-02f, -1.73294917e-02f, -1.37133285e-01f,
  -1.51781021e-02f, 9.31931585e-02f, 3.72212604e-02f, -6.96944073e-02f, 6.72086030e-02f, 9.28490236e-03f, -5.61041571e-02f, -4.54216786e-02f, 1.99267105e-03f, 1.82380136e-02f,
  -6.13455176e-02f, -5.93089834e-02f, -8.73405412e-02f, -1.35332420e-02f, 4.93447902e-03f, 5.60893938e-02f, 5.98165095e-02f, -8.76770914e-02f, 3.48053910e-02f, 1.22220591e-01f,
  1.85017884e-02f, 1.59476966e-01f, 4.34563421e-02f, -5.51232435e-02f, -3.65337953e-02f, 4.83812839e-02f, 1.05098262e-01f, -1.79106090e-02f, 1.25122115e-01f, -2.75307633e-02f,
  -2.45503038e-02f, 2.93965898e-02f, -2.61267889e-02f, -6.30447716e-02f, -5.23980707e-02f, 2.70121451e-02f, -9.22049433e-02f, 2.89784162e-04f, -1.19847544e-02f, 1.43422922e-02f,
  -3.27376314e-02f, 1.56446788e-02f, -3.40450183e-02f, -2.20344216e-02f, 4.46397439e-02f, 4.27543968e-02f, 4.76822183e-02f, -7.34182447e-02f, 1.39376251e-02f, -3.88495587e-02f,
  6.41085729e-02f, -1.72861814e-02f, 7.18230242e-03f, -2.00053342e-02f, 7.93958753e-02f, 2.70319581e-02f, -5.44407926e-02f, 9.92469564e-02f, 5.84093072e-02f, 2.03317963e-02f,
  -2.00962648e-01f, 1.80448189e-01f, -4.48348336e-02f, 4.93094232e-03f, -6.22441545e-02f, 1.33420350e-02f, 7.85837844e-02f, 4.74985503e-02f, -2.10393835e-02f, 4.23368625e-02f,
  1.19555071e-01f, 9.59939808e-02f, -5.90483397e-02f, 8.28242674e-02f, -9.02598724e-02f, -7.71928485e-03f, 1.26803550e-03f, -4.68903147e-02f, 5.06033003e-02f, -8.95429030e-02f,
  1.03540635e-02f, 3.67587842e-02f, 1.22146020e-02f, -5.03297001e-02f, 4.59242091e-02f, 2.55156737e-02f, -6.29173080e-03f, -4.36573178e-02f, -7.14110583e-02f, -1.08960621e-01f,
  -1.65407538e-01f, -2.14248672e-01f, 1.20065622e-01f, -7.43710697e-02f, 6.81479350e-02f, 1.99213400e-01f, 6.62387013e-02f, 4.22736630e-03f, -3.57297389e-03f, 1.23136658e-02f,
  -1.06831037e-01f, -6.06441721e-02f, -3.63481743e-03f, -9.56608504e-02f, -9.11317021e-02f, -3.29608545e-02f, -5.68727739e-02f, 8.98428485e-02f, 2.16505557e-01f, 1.10031441e-01f,
  5.95094375e-02f, -6.30843192e-02f, -8.58692005e-02f, -1.06460452e-01f, -4.62373495e-02f, -2.23157369e-02f, -4.39632833e-02f, 5.18445633e-02f, -1.06477715e-01f, -1.25927672e-01f,
  2.20122635e-01f, -1.20911442e-01f, 1.39526770e-01f, -6.46152198e-02f, 7.24535808e-02f, -5.36985248e-02f, 7.18261227e-02f, -7.54497871e-02f, -9.13638342e-03f, -1.43100210e-02f,
  -5.17931245e-02f, -8.08594897e-02f, -6.97148591e-02f, 9.82878823e-03f, -1.94923170e-02f, -1.18140690e-02f, -1.20376348e-01f, -8.36282596e-03f, -5.83208306e-03f, -8.54150578e-02f,
  -8.01093802e-02f, -6.83234772e-03f, 1.10053562e-01f, 1.02342628e-01f, -7.07301125e-02f, -2.91128494e-02f, 7.47269914e-02f, 9.11967382e-02f, 4.63104397e-02f, -5.84708042e-02f,
  -7.31900558e-02f, 3.17626707e-02f, -1.36179309e-02f, -7.06790686e-02f, 3.58917266e-02f, 2.34828778e-02f, -5.91801144e-02f, 3.49621065e-02f, 6.05126508e-02f, 5.47306463e-02f,
  7.70509243e-02f, -9.70447510e-02f, 7.47325122e-02f, -1.04011139e-02f, -4.30663005e-02f, -7.30331689e-02f, 3.56011912e-02f, -6.69846311e-02f, 6.57277256e-02f, 2.35498417e-02f,
  2.52970159e-02f, 8.50287080e-02f, -5.02441563e-02f, 3.85937653e-02f, -6.82305545e-02f, -2.36918274e-02f, 4.52018976e-02f, -4.35325466e-02f, 1.99357402e-02f, -4.34992686e-02f,
  6.17183447e-02f, -9.44004674e-03f, -1.76961049e-02f, 1.00871595e-02f, -5.70279174e-03f, -8.10184851e-02f, 4.66698520e-02f, -7.35153630e-02f, 3.97031754e-03f, 3.88832763e-02f,
  6.02531247e-02f, 2.50806101e-02f, -1.94265018e-03f, -2.42940187e-02f, 1.39922053e-01f, -3.28322477e-03f, -9.57691371e-02f, -4.54665758e-02f, -2.20034886e-02f, -7.45080411e-02f,
  -3.30665186e-02f, -1.12903500e-02f, 1.34630576e-01f, -2.11252477e-02f, 1.38505995e-02f, 1.10625148e-01f, 1.29202381e-01f, 1.00695312e-01f, 1.64850280e-01f, 8.89583007e-02f,
  -3.95131409e-02f, -9.52365771e-02f, 8.28417093e-02f, -5.19328937e-02f, -6.89581335e-02f, 2.53530387e-02f, -1.73924826e-02f, 4.62473780e-02f, 3.66182439e-02f, -1.21770039e-01f,
  -1.75096542e-01f, 6.97514787e-02f, -2.81558782e-02f, -3.74214910e-02f, 8.75054449e-02f, -1.33059863e-02f, 1.38324484e-01f, 1.55705422e-01f, 1.17370047e-01f, 6.56407401e-02f,
  -1.35381427e-02f, 9.27563384e-02f, -2.61621270e-02f, 5.81863187e-02f, 7.80569538e-02f, -2.66453959e-02f, -6.31559193e-02f, -5.55317961e-02f, 1.65557507e-02f, -6.01594225e-02f,
  4.95912023e-02f, -1.57829955e-01f, 1.81954149e-02f, -2.95580178e-02f, -1.12011179e-01f, -8.05859640e-02f, 5.69092035e-02f, -5.75490631e-02f, 1.89653393e-02f, -1.93263292e-02f,
  3.36158089e-02f, -6.36836141e-02f, -2.77591497e-02f, -3.94528136e-02f, -3.77592035e-02f, -8.12015682e-02f, 3.26980725e-02f, -1.53325982e-02f, -5.43738483e-03f, -8.15464370e-03f,
  -1.41971976e-01f, -9.96920094e-02f, 2.65284795e-02f, 5.14219329e-02f, -7.85810575e-02f, 8.19674954e-02f, 4.96511646e-02f, -1.03998154e-01f, -4.24782485e-02f, -5.05328216e-02f,
  2.81826109e-02f, 6.11051358e-02f, -8.74841213e-02f, 3.40916999e-02f, 2.24248860e-02f, -6.98141977e-02f, 2.58800015e-02f, 3.62601131e-02f, 1.81226768e-02f, 2.42767995e-03f,
  -4.20200787e-02f, 6.59280047e-02f, 1.03216037e-01f, 9.93582606e-02f, -2.25282479e-02f, -2.55304552e-03f, 5.12535125e-02f, 2.59107985e-02f, 5.97652495e-02f, -8.66017193e-02f,
  -5.20043559e-02f, -1.09702740e-02f, 2.27735173e-02f, -5.03302664e-02f, -7.96635896e-02f, -7.29790404e-02f, 7.32433051e-02f, -6.62218556e-02f, -5.85202649e-02f, -5.48343547e-02f,
  3.31492536e-02f, -4.01213430e-02f, 1.21902108e-01f, -5.42772040e-02f, 7.01838806e-02f, 2.71503069e-02f, -1.72679238e-02f, -4.96383850e-03f, 2.90903486e-02f, 5.81377186e-02f,
  -6.19866280e-03f, 3.09628937e-02f, -2.33509988e-02f, -2.47827265e-03f, 5.01847602e-02f, 3.81884836e-02f, -1.20889336e-01f, 2.80123055e-02f, 7.17462553e-03f, -7.72767663e-02f,
  -4.86024432e-02f, 1.15038075e-01f, 7.40888044e-02f, 5.05613908e-02f, -4.18209136e-02f, 1.37931064e-01f, 7.30956346e-02f, 1.10198118e-01f, 5.79176024e-02f, 1.41216844e-01f,
  1.26932979e-01f, -3.00541580e-01f, -8.41332525e-02f, 3.14456820e-02f, 1.05770692e-01f, 2.70377845e-03f, -1.04871519e-01f, -6.95555136e-02f, 2.15639509e-02f, -1.20487139e-01f,
  -9.14666727e-02f, -4.53200713e-02f, 1.09914113e-02f, -9.40079167e-02f, -9.80169922e-02f, -1.67529449e-01f, -1.40685871e-01f, -4.08306159e-02f, 2.16347158e-01f, 1.41728342e-01f,
  4.32449691e-02f, -1.05820939e-01f, -8.73542111e-03f, -1.60969347e-02f, -1.38861179e-01f, -5.59441000e-02f, -1.61487967e-01f, -8.15500841e-02f, -3.44651826e-02f, -1.27450630e-01f,
  -9.87713933e-02f, 3.76168005e-02f, 1.40539438e-01f, -1.97986700e-02f, 1.17960144e-02f, 2.48124413e-02f, -3.37244608e-02f, 7.91264139e-03f, 5.13662510e-02f, 1.99624617e-02f,
  1.04979835e-02f, 9.07340348e-02f, 1.31425178e-02f, -7.43437037e-02f, -3.53682153e-02f, 4.95024323e-02f, -6.70307428e-02f, -1.94318444e-02f, -8.77879560e-02f, -2.17138175e-02f,
  -9.20621678e-02f, 5.93052134e-02f, -4.04673582e-03f, 4.14357483e-02f, 8.18802193e-02f, 1.31563693e-01f, -1.19202353e-01f, 4.15180922e-02f, 5.00656180e-02f, -5.18854223e-02f,
  1.31956078e-02f, -2.44887564e-02f, 4.11875695e-02f, 7.84497038e-02f, 4.59148772e-02f, 3.38276103e-02f, 2.01321561e-02f, 1.07752846e-03f, -5.00193387e-02f, -2.69420017e-02f,
  -2.70550512e-02f, -5.48044816e-02f, 3.00538018e-02f, -4.50844392e-02f, -2.21177954e-02f, -2.63152998e-02f, 3.39713506e-02f, -6.45700619e-02f, -1.04589006e-02f, -1.54520487e-02f,
  2.20595282e-02f, 3.12980078e-02f, -8.96314010e-02f, -7.55845159e-02f, -6.32176697e-02f, 4.59571593e-02f, -6.74418174e-03f, -1.04531087e-02f, -9.39427838e-02f, -1.97373815e-02f,
  -5.73108578e-03f, 9.49030071e-02f, 8.49204436e-02f, -2.79083438e-02f, -1.43885352e-02f, -2.78876126e-02f, -5.79214022e-02f, -5.12188636e-02f, -6.37017265e-02f, 7.20168650e-02f,
  4.47866954e-02f, -2.51469389e-03f, -3.34346145e-02f, 6.91210106e-02f, 5.27609587e-02f, 9.33915228e-02f, -6.22555204e-02f, 9.43331644e-02f, -1.04643844e-01f, -1.62962358e-02f,
  -1.81305602e-01f, 1.42238230e-01f, 1.37733772e-01f, 7.65185133e-02f, -4.32881713e-03f, 1.93202287e-01f, 5.65682314e-02f, 3.31187285e-02f, 1.61199301e-01f, 5.47156632e-02f,
  5.75760417e-02f, -2.60634511e-03f, 6.16377629e-02f, 7.16049373e-02f, -2.41351686e-02f, -2.96038762e-03f, -1.36753932e-01f, -3.53217386e-02f, 1.03880599e-01f, 2.89529543e-02f,
  -1.16745057e-02f, -5.72192147e-02f, 3.57800722e-02f, 1.15326442e-01f, 1.42572910e-01f, -2.54852921e-02f, 9.63565931e-02f, 1.70010820e-01f, 2.59193461e-02f, 1.13546096e-01f,
  3.16769853e-02f, -8.39402247e-03f, 1.75261095e-01f, 1.16140231e-01f, 9.13654789e-02f, -3.28208157e-03f, 7.48349875e-02f, 3.63360420e-02f, 3.18741053e-02f, 1.81821838e-01f,
  2.45339721e-02f, 1.02004567e-02f, 2.27234755e-02f, 5.79026490e-02f, -1.07978486e-01f, 1.18523195e-01f, -8.45407993e-02f, 8.49897414e-02f, -9.47777703e-02f, 1.36033446e-02f,
  -8.87701511e-02f, -6.02854453e-02f, 1.90064441e-02f, -3.74349058e-02f, 1.42051633e-02f, -1.90058220e-02f, 7.96694607e-02f, 1.30071998e-01f, 8.95314664e-03f, 6.33604527e-02f,
  -9.97551084e-02f, -6.77103028e-02f, -4.08617966e-02f, -3.16603556e-02f, 1.94261186e-02f, -4.46838886e-02f, -8.60116035e-02f, -2.78583728e-02f, -5.36280945e-02f, 9.79233906e-02f,
  2.62715574e-02f, 5.36644720e-02f, 6.12556078e-02f, -5.71603663e-02f, 1.10394314e-01f, -4.98699546e-02f, 1.48091593e-03f, -5.49132638e-02f, -5.86533397e-02f, 2.51789596e-02f,
  1.31566450e-02f, 7.86484107e-02f, -1.47349816e-02f, 1.01218909e-01f, 6.54770285e-02f, -6.68922346e-03f, -4.20408137e-02f, 4.85677533e-02f, -7.32959583e-02f, -5.23572043e-02f,
  -2.45734770e-02f, -8.21821392e-02f, 5.12874983e-02f, -4.44415435e-02f, 7.86428303e-02f, 3.59546170e-02f, 8.49502981e-02f, 4.73629311e-02f, -5.85904345e-02f, -6.88624149e-03f,
  -7.34413564e-02f, -1.08234838e-01f, 3.87114137e-02f, 7.00914115e-02f, -6.74914196e-02f, -9.69572663e-02f, -1.07085714e-02f, -2.52589909e-03f, -7.05505088e-02f, 2.28039734e-02f,
  -9.30561572e-02f, -4.57454547e-02f, -8.67938921e-02f, -3.65298875e-02f, 8.30301568e-02f, 5.13943955e-02f, -6.19772188e-02f, 6.76334128e-02f, -8.65911394e-02f, -8.43546763e-02f,
  -5.78785827e-03f, -9.92319360e-02f, 5.70832528e-02f, -6.97736293e-02f, 1.46931279e-02f, -2.39536772e-03f, -1.07292108e-01f, 6.03459775e-02f, -9.74299982e-02f, -6.10907041e-02f,
  6.27153888e-02f, 9.79483202e-02f, 1.18364707e-01f, 6.67619854e-02f, 1.37652382e-01f, -4.24705558e-02f, -9.20273736e-02f, -1.12688325e-01f, -7.33224750e-02f, 2.19236054e-02f,
  4.44685854e-02f, -1.01251364e-01f, -7.89961666e-02f, -6.96469247e-02f, -2.47081265e-01f, -1.12497509e-01f, -5.97928986e-02f, -1.79683626e-01f, -3.66043210e-01f, -2.94723213e-01f,
  -3.94798331e-02f, -1.58481136e-01f, -2.27130428e-02f, -1.00319602e-01f, 5.01299314e-02f, 2.19868234e-04f, 1.95743486e-01f, -7.67550955e-04f, 1.24925233e-01f, 2.13337377e-01f,
  1.67814419e-01f, 1.42933279e-01f, -1.28478825e-01f, 2.43103188e-02f, -1.52979896e-03f, -3.20061408e-02f, 8.64557177e-03f, -6.15037680e-02f, 7.17569068e-02f, 4.99876402e-02f,
  -1.79956388e-02f, 6.20988607e-02f, -8.19320511e-03f, 7.75147369e-03f, -1.01188280e-01f, 3.15537374e-03f, -1.26625344e-01f, -1.25539247e-02f, -8.56609941e-02f, -5.92601523e-02f,
  -2.93657668e-02f, 3.62313092e-02f, -7.30172321e-02f, -6.89767897e-02f, 5.19560277e-02f, 5.23739345e-02f, 8.59328210e-02f, 1.02266133e-01f, 7.02864304e-03f, 1.30143657e-01f,
  -2.41248030e-02f, 4.28190380e-02f, 7.61566460e-02f, 5.01258001e-02f, 5.08938357e-03f, 1.72442738e-02f, 1.09073617e-01f, -7.70611092e-02f, 3.07891201e-02f, -2.62159966e-02f,
  4.84946445e-02f, 7.91416988e-02f, -4.27741930e-02f, 1.06125399e-02f, 1.18661739e-01f, 1.85851920e-02f, 1.66735258e-02f, -3.21510546e-02f, -7.90926963e-02f, 6.97268173e-02f,
  -6.18420914e-03f, -3.94176990e-02f, -5.12064015e-03f, 2.97743268e-02f, 1.48010161e-02f, 5.32904007e-02f, 3.43177915e-02f, 5.50463460e-02f, 3.82986739e-02f, -5.33158258e-02f,
  -1.09361503e-02f, -8.43892097e-02f, 7.95528591e-02f, -8.68830979e-02f, -2.19161864e-02f, 9.48512405e-02f, 2.85908617e-02f, -2.32540648e-02f, 1.10843807e-01f, -3.94522166e-03f,
  5.17965965e-02f, -3.56663503e-02f, 3.23269819e-03f, -9.55286026e-02f, -9.55995023e-02f, -5.27912304e-02f, -1.11212563e-02f, -1.00438043e-01f, -1.06914133e-01f, 7.03950152e-02f,
  -4.86996472e-02f, -6.07363507e-02f, -1.24412626e-01f, -3.20579000e-02f, -4.63631079e-02f, -1.01425134e-01f, -4.51198630e-02f, -3.25641073e-02f, -7.57648796e-03f, -8.51757675e-02f,
  8.62464681e-02f, -9.45103317e-02f, -1.22555554e-01f, 2.79267486e-02f, -4.61092852e-02f, -3.76473702e-02f, -2.26295024e-01f, -1.11854538e-01f, 9.68042985e-02f, -3.95084880e-02f,
  -4.46082503e-02f, 9.73233283e-02f, -4.44389358e-02f, -6.69343993e-02f, -1.43691093e-01f, -3.08476686e-02f, -5.87544069e-02f, -1.45088816e-02f, -1.61476582e-02f, 5.05803190e-02f,
  9.42611471e-02f, -8.90491717e-03f, 8.24537054e-02f, 9.99131203e-02f, 1.18418761e-01f, 1.08447872e-01f, -3.64144444e-02f, -2.10068952e-02f, 6.15739673e-02f, -1.53415836e-02f,
  3.21164168e-02f, -1.55788492e-02f, -3.93497013e-02f, -2.85869073e-02f, 7.08037764e-02f, -3.66584882e-02f, 2.98470445e-02f, -9.85642299e-02f, 2.02788189e-02f, -7.71420151e-02f,
  1.08175231e-02f, -4.14566658e-02f, 7.51616955e-02f, 2.05258112e-02f, -1.06073944e-02f, -1.03953712e-01f, -2.34249011e-02f, -1.19662985e-01f, -9.68599692e-02f, 2.21212935e-02f,
  -3.73918638e-02f, -7.01083094e-02f, -8.79280046e-02f, -3.27257738e-02f, -1.40805291e-02f, 2.31053634e-03f, -8.65920782e-02f, -2.62475479e-02f, -1.02283306e-01f, -2.98357336e-03f,
  4.13006842e-02f, 6.60247281e-02f, -7.34082684e-02f, -1.09923957e-03f, -7.95266703e-02f, -7.79403597e-02f, -7.68529773e-02f, 9.78735834e-03f, -7.78372809e-02f, -6.26522899e-02f,
  -8.33163559e-02f, 9.00247786e-03f, -1.08378129e-06f, 4.58864793e-02f, 6.99653104e-02f, 7.52930939e-02f, 5.44848666e-02f, -4.25713174e-02f, 9.28820763e-03f, 1.23017188e-02f,
  -3.16766277e-02f, -2.78759263e-02f, 9.10516549e-03f, -3.92365605e-02f, -7.37181008e-02f, -2.42379424e-03f, 8.67505819e-02f, -5.28915823e-02f, -4.80795465e-03f, 5.79132363e-02f,
  5.49774766e-02f, -1.28164604e-01f, -1.68010388e-02f, 2.20026989e-02f, 3.72255892e-02f, 8.49305000e-03f, -4.90544178e-02f, -7.12823644e-02f, 1.75383873e-02f, 8.16490036e-03f,
  -1.20840678e-02f, -7.70125091e-02f, -9.98191386e-02f, -2.42460165e-02f, -5.49799763e-02f, 2.67250882e-03f, 6.40818179e-02f, -6.29753470e-02f, -5.90576716e-02f, 5.52273877e-02f,
  -7.33910874e-02f, -9.53824073e-02f, -1.48869842e-01f, -1.57645658e-01f, -4.01879847e-02f, 2.94155311e-02f, -4.52120602e-02f, -1.21353477e-01f, -1.20413013e-01f, -5.30041978e-02f,
  -3.98049295e-01f, 9.37972218e-02f, -5.06585129e-02f, -3.71895824e-03f, 4.36065532e-02f, 1.98399082e-01f, 2.44735852e-01f, 8.50624442e-02f, -8.29800311e-03f, 4.32987958e-02f,
  9.89403855e-03f, 6.86112195e-02f, -1.09996693e-02f, 4.80297878e-02f, 3.00771222e-02f, 1.94159046e-01f, 5.08349463e-02f, -1.38540670e-01f, -1.69558585e-01f, 4.65637036e-02f,
  1.30734906e-01f, -1.29658639e-01f, -2.70532668e-01f, 1.69451777e-02f, -6.23036027e-02f, 4.71766405e-02f, -6.65126890e-02f, -6.39965609e-02f, 1.27195463e-01f, 1.70995414e-01f,
  -4.82311919e-02f, -1.25532985e-01f, -8.32523704e-02f, -3.67901698e-02f, 1.16416859e-02f, -1.15065999e-01f, 3.04805860e-03f, -9.34737697e-02f, -4.93773036e-02f, 2.66262498e-02f,
  -4.32512201e-02f, 3.97816226e-02f, -3.21378522e-02f, -1.60974506e-02f, -5.77021427e-02f, -6.75384104e-02f, -9.04568285e-02f, -1.81150019e-01f, -3.12804058e-02f, -5.19346446e-02f,
  6.97704926e-02f, 2.21410431e-02f, -5.02886325e-02f, 3.07244086e-03f, -9.62389559e-02f, -4.30535786e-02f, 1.31344311e-02f, -1.44785881e-01f, -2.08911430e-02f, -9.39425975e-02f,
  7.44697824e-02f, 7.49659631e-03f, 4.59006317e-02f, -6.33181185e-02f, 3.42865251e-02f, 6.74928874e-02f, 6.73718378e-02f, 1.20317705e-01f, -4.45260517e-02f, -4.07451987e-02f,
  -7.49340206e-02f, 2.16297042e-02f, -8.06414261e-02f, -2.35771462e-02f, 7.14389309e-02f, -4.13351245e-02f, 3.44435610e-02f, 3.72032039e-02f, -1.01295505e-02f, -5.03547303e-02f,
  -3.31290029e-02f, -6.46217987e-02f, -5.19322678e-02f, 9.22081002e-04f, 2.39474252e-02f, -6.59026504e-02f, 5.51509000e-02f, -2.17262600e-02f, -8.49033706e-03f, 4.64627333e-03f,
  -1.19612850e-01f, -6.06967099e-02f, -3.81513275e-02f, 4.19115424e-02f, -8.34177434e-03f, -7.69630522e-02f, 4.02171090e-02f, -6.42924458e-02f, -4.66512777e-02f, 1.84388347e-02f,
  4.09438312e-02f, -1.01415835e-01f, -6.29563853e-02f, -1.47696640e-02f, -1.08529732e-01f, -1.34712933e-02f, -4.44500931e-02f, -7.69492164e-02f, -9.68454778e-03f, -6.64535463e-02f,
  2.90862154e-02f, -1.02991238e-01f, -1.35453388e-01f, -1.35533750e-01f, -7.41487220e-02f, -1.12663560e-01f, -1.10726632e-01f, -5.84528632e-02f, -1.57580286e-01f, -5.29556796e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  2.30270341e-01f, -5.01040695e-03f, 1.33438319e-01f, 4.54681106e-02f, 2.66386699e-02f, 1.19303793e-01f, 1.21392004e-01f, 1.13425724e-01f, 1.00697845e-01f, 9.40038711e-02f,
  -2.20703557e-02f, 1.46184042e-01f, 9.36698318e-02f, 1.57096237e-01f, 4.82311733e-02f, -2.29653139e-02f, 5.38255321e-03f, 8.02847147e-02f, 1.92080334e-01f, 1.19375385e-01f,
  1.30909592e-01f, 1.92023203e-01f, 1.33324623e-01f, 1.96855441e-01f, 1.77533641e-01f, 1.04483500e-01f, 1.42873615e-01f, 2.13003486e-01f, 5.46834543e-02f, 7.53755271e-02f,
  2.29133561e-01f, 8.21120143e-02f, 1.06025666e-01f, 1.83191709e-02f, 1.67574689e-01f, 1.44899353e-01f, 1.79487780e-01f, 1.67984262e-01f, 4.09922339e-02f, 8.85671228e-02f,
  2.79085487e-01f, 2.31772721e-01f, 3.96700874e-02f, 4.46875095e-02f, 1.94006979e-01f, 1.14489816e-01f, 1.01166680e-01f, 2.98234597e-02f, 8.78266804e-03f, 3.54179442e-02f,
  -2.86745913e-02f, 7.21349642e-02f, 7.43848309e-02f, 2.62718368e-02f, 6.32279217e-02f, 1.22180112e-01f, 8.33158419e-02f, 1.40840009e-01f, -3.50415910e-04f, -4.22495743e-03f,
  7.90445507e-02f, 1.13966577e-01f, 8.23263675e-02f, 7.55993575e-02f, 7.33450055e-02f, 9.51101929e-02f, 1.22229330e-01f, 2.65304465e-03f, 1.10421188e-01f, 1.70718253e-01f,
  3.16307694e-02f, -2.05389317e-02f, 9.35531557e-02f, 1.53701514e-01f, 1.46113351e-01f, 1.55369446e-01f, 1.49082541e-01f, -3.37835103e-02f, 1.03840239e-01f, 2.18286347e-02f,
  8.24243352e-02f, 5.52192107e-02f, 1.52193427e-01f, 5.60618415e-02f, 1.67307451e-01f, 1.05784290e-01f, 3.68649103e-02f, 6.34409115e-02f, 1.12173416e-01f, 2.42473841e-01f,
  1.32954761e-01f, 1.72012806e-01f, 2.53473073e-02f, 6.83088526e-02f, 8.00244045e-03f, 1.07281341e-03f, 1.21435381e-01f, 1.84901163e-01f, 1.91576004e-01f, 1.47502780e-01f,
  1.30668521e-01f, 1.89878225e-01f, 1.22194784e-02f, 1.04603752e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.40569627e-01f, -6.94315927e-03f, -7.18472376e-02f, -4.72448587e-01f, -2.53393203e-01f, -1.43959031e-01f, -9.40356180e-02f, -1.14717325e-02f, -6.00734651e-01f, -1.72627285e-01f,
  -5.09741455e-02f, -3.43276531e-01f, -2.03627750e-01f, 1.39759198e-01f, -9.85725597e-02f, 2.64641076e-01f, -3.19050580e-01f, -7.23704770e-02f, 3.48461196e-02f, -1.84056804e-01f,
  2.66987085e-02f, -1.25741124e-01f, -1.18284352e-01f, 1.75279737e-01f, -9.97080654e-02f, 1.00469135e-01f, -7.33803064e-02f, -3.28966193e-02f, 3.62043381e-02f, 6.63663924e-01f,
  2.28122309e-01f, 2.76094582e-02f, 4.13145162e-02f, 9.00583938e-02f, 6.45836145e-02f, -8.45349133e-02f, -1.75943673e-01f, -6.78855702e-02f, -1.67412207e-01f, 5.51432371e-02f,
  2.19791710e-01f, -1.13226801e-01f, 3.42536032e-01f, -2.55669504e-02f, -2.88678575e-02f, 4.01739091e-01f, -1.54120987e-02f, -6.40827641e-02f, -7.49995932e-02f, 2.03539863e-01f,
  -6.17500581e-02f, 1.35213975e-02f, 3.55833545e-02f, -4.99520004e-02f, -8.92106071e-02f, -1.86040670e-01f, -7.61019662e-02f, 2.77501523e-01f, -1.36192873e-01f, -3.77477854e-02f,
  -4.37686965e-02f, -2.02844650e-01f, 5.23994602e-02f, -3.50505300e-02f, -2.44146064e-02f, -1.48963824e-01f, 2.75640637e-01f, 1.67250574e-01f, -1.21569477e-01f, 6.41158745e-02f,
  -1.84508741e-01f, -1.07985839e-01f, -1.71023309e-01f, 9.25736874e-02f, -1.26137674e-01f, -1.16413847e-01f, 9.34669897e-02f, 3.12629491e-02f, -1.23949274e-01f, -9.33490619e-02f,
  1.96777925e-01f, 4.16768849e-01f, -6.14072159e-02f, -1.32093607e-02f, -3.86004075e-02f, -9.94301215e-02f, 1.20351382e-01f, 2.65209556e-01f, -2.79147714e-01f, 1.46003902e-01f,
  3.66533287e-02f, 6.87030330e-02f, -6.91066235e-02f, 4.22454290e-02f, -1.50018290e-01f, 8.76362100e-02f, -1.10709488e-01f, -1.53606117e-01f, 9.79448408e-02f, -1.79569870e-01f,
  -2.16026545e-01f, -8.16480219e-02f, 3.55284542e-01f, 2.51568593e-02f, 7.97609314e-02f, 3.07711512e-01f, -1.42699555e-01f, -6.91239759e-02f, -9.47297271e-03f, 4.10569668e-01f,
  -1.17502153e-01f, -8.35371092e-02f, -1.07860915e-01f, -2.06024468e-01f, 7.42581934e-02f, -7.48826712e-02f, 3.34519655e-01f, 2.24921983e-02f, -1.32170618e-01f, -4.97801751e-02f,
  3.32940556e-02f, 1.13759868e-01f, -7.51917623e-03f, 2.99853116e-01f, -8.68184790e-02f, -2.72130221e-01f, 1.90654248e-01f, -1.32441252e-01f, -2.24146694e-01f, 2.58366138e-01f,
  1.72759801e-01f, -2.74462163e-01f, -1.42666310e-01f, 6.26653805e-02f, 3.00602674e-01f, 4.38508242e-02f, -2.16318056e-01f, 9.57945213e-02f, -2.47923881e-01f, 1.59960210e-01f,
  4.81559724e-01f, -1.70358554e-01f, -1.38345405e-01f, 3.31145138e-01f, -3.56904179e-01f, 1.70065761e-02f, -4.43231225e-01f, 4.88584071e-01f, -2.64039278e-01f, -2.51847338e-02f,
  5.70118129e-01f, -1.41180484e-02f, -3.11269015e-02f, 1.15259990e-01f, -2.20411107e-01f, -1.26631171e-01f, -1.66899964e-01f, 1.44011840e-01f, -1.85780630e-01f, -2.41346955e-02f,
  1.08444050e-01f, -1.69231035e-02f, -1.01662658e-01f, -1.96571410e-01f, 7.45406225e-02f, -6.53045177e-02f, -1.93006516e-01f, 8.36860668e-03f, -1.66202769e-01f, -5.37129827e-02f,
  6.46857023e-02f, -1.06951527e-01f, 2.75394693e-02f, 4.13380653e-01f, -1.97201055e-02f, 2.52662394e-02f, -1.43328607e-01f, -1.23489924e-01f, 4.80025500e-01f, 6.23298809e-02f,
  8.54024589e-02f, 4.34670858e-02f, -2.07541212e-02f, -1.17298625e-01f, -2.26251602e-01f, 1.64615661e-01f, 1.90815330e-03f, 1.89786106e-01f, 1.12516120e-01f, -5.72402254e-02f,
  -6.26663566e-02f, -1.40504399e-02f, 5.35572648e-01f, 1.13969743e-01f, 5.37793875e-01f, -3.42793539e-02f, -8.32929742e-03f, 5.91670983e-02f, -1.07309982e-01f, -4.97491136e-02f,
  -1.30935490e-01f, -2.91822851e-02f, 3.22698317e-02f, 3.17777842e-02f, -2.03424469e-02f, 3.13913703e-01f, 9.73492488e-03f, 1.70740649e-01f, -1.38794422e-01f, 3.72741908e-01f,
  5.86763285e-02f, 6.40659034e-02f, 3.81382585e-01f, -7.37067088e-02f, 1.57368798e-02f, -5.36804367e-03f, -1.62076533e-01f, 7.93363303e-02f, -2.51234621e-02f, 2.84894109e-02f,
  -1.86178386e-01f, -1.38660818e-01f, 2.86223173e-01f, 1.07000740e-02f, 2.85680026e-01f, 2.92197227e-01f, 1.41456470e-01f, 2.29269955e-02f, -1.34686083e-01f, 8.11535642e-02f,
  -1.81441575e-01f, 2.31062919e-02f, -9.01301354e-02f, -1.62741050e-01f, 4.99828570e-02f, 2.87277728e-01f, -2.60543525e-01f, 3.45278047e-02f, -2.54222274e-01f, 1.58589259e-01f,
  5.26880845e-02f, -3.10244113e-01f, 1.75345138e-01f, -3.65327932e-02f, 5.53852953e-02f, 5.46085387e-02f, 1.04136597e-02f, 2.93400109e-01f, 1.34286582e-01f, -8.93499926e-02f,
  6.39400408e-02f, 3.32797468e-01f, 6.94967210e-02f, -2.38029331e-01f, -1.65390149e-01f, -1.07641950e-01f, 2.25108534e-01f, 2.79534370e-01f, 1.22956336e-01f, -2.12288257e-02f,
  8.15703794e-02f, -1.14621095e-01f, 6.12618327e-02f, 1.09347731e-01f, 2.73003727e-01f, 8.36928487e-02f, 3.68439972e-01f, 2.24732295e-01f, -1.81641385e-01f, -3.06753457e-01f,
  3.76055211e-01f, 5.92906475e-01f, -5.63218951e-01f, -4.34070587e-01f, -4.50702101e-01f, 2.91317105e-01f, 2.55880713e-01f, -2.43465200e-01f, 2.93646127e-01f, -5.06091155e-02f,
  1.64546818e-01f, -5.36374934e-02f, -2.83915345e-02f, 8.14914331e-02f, -1.19624279e-01f, -6.07922338e-02f, 1.22048095e-01f, 1.16178460e-01f, 3.01607609e-01f, 2.13955585e-02f,
  -5.57493046e-02f, 2.88819224e-01f, 3.72243337e-02f, 2.32959092e-01f, -1.03082456e-01f, -4.60383184e-02f, -4.30448614e-02f, 1.85869187e-02f, -3.13993484e-01f, -6.85271283e-04f,
  3.40363055e-01f, -2.16840416e-01f, -8.95465463e-02f, 1.44135743e-01f, 1.36958271e-01f, -7.74169821e-05f, -8.39434639e-02f, 1.83363348e-01f, -1.22354142e-01f, -1.17921591e-01f,
  -1.53377190e-01f, 2.24710256e-03f, -3.01966965e-02f, -1.18199348e-01f, -1.31185472e-01f, -2.58082569e-01f, -2.32102871e-01f, 2.40014657e-01f, 8.36785436e-02f, 6.43327907e-02f,
  2.56667674e-01f, -3.60241503e-01f, 1.27085119e-01f, 2.07670331e-01f, -1.69924065e-01f, 1.35796458e-01f, -1.69824734e-01f, -5.72576225e-02f, -3.67686413e-02f, 8.80108103e-02f,
  -1.47758527e-02f, -2.37879604e-01f, 4.99272160e-03f, -1.05164677e-01f, -4.77357619e-02f, -2.73267508e-01f, -2.03354955e-01f, -4.30801231e-03f, -7.41646737e-02f, -1.92488194e-01f,
  -6.93412796e-02f, -8.33900049e-02f, 3.79318178e-01f, -2.44078301e-02f, -5.83180636e-02f, -8.66008922e-02f, 4.41558033e-01f, 3.19625698e-02f, 1.70871586e-01f, -1.89299196e-01f,
  -7.87016228e-02f, -2.57638134e-02f, -5.46231680e-02f, 5.89715652e-02f, 3.71980667e-02f, 1.05670050e-01f, -8.11674073e-02f, -2.69436091e-02f, 1.21061333e-01f, -4.90143942e-03f,
  -1.21197432e-01f, 1.80386171e-01f, -9.90166813e-02f, -1.97945967e-01f, 3.30414236e-01f, -2.02739656e-01f, -8.95698518e-02f, -9.12848189e-02f, 1.89064536e-02f, -3.10601275e-02f,
  -3.52075100e-02f, 3.81190032e-01f, -5.38044982e-02f, -3.28713283e-02f, -2.42213793e-02f, -2.22679958e-01f, 7.05026556e-03f, -9.74080712e-03f, 1.04202375e-01f, -8.09450895e-02f,
  6.84064999e-02f, -1.67776495e-01f, -1.79686921e-03f, -2.15264961e-01f, -1.34057418e-01f, -2.61518061e-02f, -1.81767255e-01f, 8.96961614e-02f, 1.34593382e-01f, 6.72792345e-02f,
  -3.10983453e-02f, -1.68979555e-01f, 3.64436880e-02f, -1.75073091e-02f, -6.23260252e-02f, 1.03404634e-01f, -1.30694970e-01f, 1.78800181e-01f, -4.29957092e-01f, -1.12096846e-01f,
  1.15193808e-02f, -4.49455343e-02f, 1.51574492e-01f, -2.63159305e-01f, -3.12438458e-01f, -2.03555226e-01f, 6.31041899e-02f, -6.49954453e-02f, 1.94536746e-01f, 6.56114668e-02f,
  1.61302611e-01f, 1.17190018e-01f, -5.88893369e-02f, 8.95665772e-03f, 1.12411469e-01f, 3.27967882e-01f, 3.61902595e-01f, 3.60316411e-02f, 1.04429297e-01f, 2.64916003e-01f,
  -1.02888206e-02f, -4.72288094e-02f, -7.38627762e-02f, -9.68700498e-02f, -5.72926700e-02f, 1.01089820e-01f, 2.00955212e-01f, -1.62722647e-01f, 4.35355753e-01f, -2.85252750e-01f,
  -1.22002676e-01f, -1.35687307e-01f, 1.40305131e-03f, -2.95489244e-02f, -1.81296706e-01f, -1.53145909e-01f, -8.25656727e-02f, 4.68031950e-02f, -1.77754745e-01f, 3.22902709e-01f,
  -4.16661799e-02f, -1.42913640e-01f, 3.62398893e-01f, -8.65723193e-02f, -3.01373750e-01f, 4.39021476e-02f, 1.45658806e-01f, 1.69470787e-01f, -1.26168028e-01f, -1.27324790e-01f,
  -1.51765123e-01f, 2.91751236e-01f, -3.27922434e-01f, -5.98549172e-02f, -7.77676255e-02f, 3.85918707e-01f, -3.38851400e-02f, -1.74379855e-01f, -1.79614708e-01f, -7.91049004e-02f,
  7.46796355e-02f, 6.07366599e-02f, 2.50601172e-02f, -5.42967133e-02f, 2.43580341e-01f, -3.24241102e-01f, -1.93797927e-02f, 7.86525197e-03f, 3.57844561e-01f, 1.13780804e-01f,
  -1.19158234e-02f, -2.72605270e-01f, 1.21202871e-01f, -1.07903019e-01f, 3.07575986e-03f, -1.02394216e-01f, -5.03874570e-02f, -9.63103846e-02f, -5.18652163e-02f, -5.38433008e-02f,
  -2.82095149e-02f, -1.51968315e-01f, -6.38662279e-02f, 8.45260471e-02f, -1.69926748e-01f, -7.44658709e-02f, -2.79425960e-02f, -4.47209598e-03f, 1.78266600e-01f, 1.77392974e-01f,
  3.78534645e-02f, -9.07508880e-02f, 7.80017860e-03f, 3.80783617e-01f, -5.57345226e-02f, -4.29744422e-02f, -5.66130541e-02f, 5.18134952e-01f, -1.99104324e-01f, -2.51685143e-01f,
  5.57554841e-01f, 1.17464013e-01f, -1.45654589e-01f, -1.21201612e-02f, 3.37251067e-01f, -1.10972747e-02f, -1.00831397e-01f, -1.08000025e-01f, -1.72794819e-01f, 1.48067307e-02f,
  -1.97777271e-01f, 4.01938707e-01f, -2.18889982e-01f, -2.47960880e-01f, -1.58471204e-02f, 2.35937536e-01f, -1.53589949e-01f, -1.70099407e-01f, 4.03946862e-02f, -2.98052371e-01f,
  3.24657559e-01f, -1.63791850e-01f, 1.49615034e-01f, -5.89314625e-02f, -2.71580607e-01f, 4.70695019e-01f, 3.50088239e-01f, 1.72328949e-02f, 3.12093258e-01f, -3.59861851e-02f,
  -1.66668177e-01f, -1.61700234e-01f, -3.50654155e-01f, 2.55100697e-01f, -7.40032420e-02f, 1.79505348e-01f, 1.10424578e-01f, -6.99371994e-02f, -6.61804923e-04f, -1.18107930e-01f,
  -1.23866551e-01f, 1.98690131e-01f, 3.03680860e-02f, -8.10043812e-02f, -9.39236805e-02f, 2.50036776e-01f, 1.42940238e-01f, 1.06570974e-01f, 6.48194999e-02f, -6.36226088e-02f,
  9.93942320e-02f, 8.73888507e-02f, 1.68172926e-01f, 8.56246576e-02f, -8.92655328e-02f, -1.05154119e-01f, 9.66941938e-02f, 1.00413725e-01f, -1.50216565e-01f, 8.52847993e-02f,
  2.05019549e-01f, 2.70943902e-03f, -4.85738032e-02f, -8.44943374e-02f, -9.54777971e-02f, -1.58791512e-01f, -2.14784697e-01f, -1.35037029e-04f, 2.40252353e-02f, 1.55616194e-01f,
  -1.56089328e-02f, -7.24820942e-02f, 1.82261895e-02f, -4.60275225e-02f, 8.54688436e-02f, 1.48539156e-01f, -1.24625020e-01f, 2.42592059e-02f, -1.46885052e-01f, -2.62295008e-01f,
  4.24692243e-01f, 2.84527559e-02f, 1.54794287e-03f, 3.65801752e-02f, -4.64336239e-02f, 3.50111984e-02f, 5.77129245e-01f, -1.12032769e-02f, -9.47024003e-02f, -1.37987226e-01f,
  -2.89077889e-02f, -2.08639562e-01f, 2.70585895e-01f, -1.90094277e-01f, 5.26621416e-02f, 2.74226129e-01f, 4.06194255e-02f, 3.33270840e-02f, 1.46066770e-01f, 1.47097915e-01f,
  2.78611183e-01f, 9.52290446e-02f, -2.94461958e-02f, -1.87264040e-01f, -5.87618239e-02f, 1.50296807e-01f, -1.16809778e-01f, -6.14623353e-03f, -1.56417802e-01f, -8.96584541e-02f,
  -4.69032228e-02f, -4.04756032e-02f, 1.99895844e-01f, -3.93540896e-02f, -1.63812518e-01f, -1.88346967e-01f, 2.38415718e-01f, 3.52556437e-01f, 3.41360331e-01f, 9.86278355e-02f,
  -1.48776442e-01f, 1.24149658e-01f, -6.06537238e-02f, -6.29290566e-02f, 1.18704744e-01f, -6.25069290e-02f, 8.22303444e-02f, 7.23023266e-02f, -7.43313134e-02f, -1.19512245e-01f,
  4.31804180e-01f, 6.60548657e-02f, -5.95506988e-02f, -1.36653125e-01f, -1.19156733e-01f, -1.45898685e-01f, -1.65278360e-01f, 5.38638353e-01f, 1.01582050e-01f, -7.70634934e-02f,
  3.56033206e-01f, 1.85521603e-01f, 2.40636557e-01f, 2.64735788e-01f, 4.67720896e-01f, 1.58892721e-01f, 9.13828388e-02f, 3.61960858e-01f, -4.11577672e-02f, 5.72784208e-02f,
  2.76930958e-01f, 2.02926889e-01f, 3.16443235e-01f, 2.80659527e-01f, -6.33958578e-02f, 1.08794257e-01f, 1.12682328e-01f, 3.88029665e-01f, 5.07322669e-01f, -2.91020513e-01f,
  -3.96184027e-01f, 1.29598424e-01f, 9.25998464e-02f, -5.50803468e-02f, -3.12279552e-01f, -8.72117579e-02f, -1.17352992e-01f, -1.93645597e-01f, 1.48035631e-01f, 2.94361208e-02f,
  -1.64823636e-01f, -1.03041373e-01f, -2.98549775e-02f, 1.57888263e-01f, -6.11477382e-02f, -1.71393111e-01f, 2.36634873e-02f, -1.08486749e-02f, -1.44596890e-01f, -9.84925590e-03f,
  3.50272916e-02f, -1.46227062e-01f, 2.90039361e-01f, -2.47024447e-02f, -1.25901893e-01f, 2.71649033e-01f, -2.24402174e-01f, 1.84918866e-01f, -2.90758491e-01f, 6.58296943e-02f,
  3.27169988e-03f, 6.94459379e-02f, 9.62264761e-02f, 1.42876461e-01f, 3.01922888e-01f, -1.97681636e-01f, -6.21201470e-02f, -6.19228669e-02f, 4.06249426e-02f, 1.12102866e-01f,
  9.23462808e-01f, -7.22065940e-02f, 9.66010466e-02f, -8.79574344e-02f, -2.16019437e-01f, 1.86875492e-01f, -3.24551463e-01f, -9.47516505e-03f, 6.75861686e-02f, -3.55263129e-02f,
  1.24238379e-01f, -2.54310608e-01f, -4.66600172e-02f, 5.22192717e-02f, -1.45481765e-01f, 2.13291496e-01f, -3.58126201e-02f, -2.69053294e-03f, 3.87210958e-02f, -8.62495303e-02f,
  7.16253221e-02f, 2.99937546e-01f, -5.13296053e-02f, 1.95904896e-01f, -3.78393941e-02f, -3.90093364e-02f, -1.43691972e-01f, 2.21944869e-01f, 1.50992617e-01f, 1.03385545e-01f,
  -1.48007408e-01f, 2.72734780e-02f, 1.59764774e-02f, 6.81458637e-02f, 1.71242747e-02f, -3.83283123e-02f, 1.24312732e-02f, 7.15555623e-04f, 3.28953743e-01f, 2.08204895e-01f,
  2.25151002e-01f, 2.00968221e-01f, -4.60814871e-02f, 1.90694869e-01f, -1.24426812e-01f, -1.95726499e-01f, 9.73103866e-02f, -2.76949797e-02f, -4.15298156e-02f, -4.78545800e-02f,
  8.95374417e-02f, -1.45030200e-01f, 1.34945631e-01f, 3.97038534e-02f, 6.99508041e-02f, -1.02271758e-01f, -1.28055468e-01f, -2.42533609e-01f, 1.43034443e-01f, 1.30380929e-01f,
  -1.83386862e-01f, -3.32793623e-01f, -2.38440298e-02f, -1.61215886e-01f, 1.11515019e-02f, -6.83696643e-02f, 8.03372413e-02f, -6.92251027e-02f, 1.02828406e-01f, -2.14992583e-01f,
  -2.81513005e-01f, 1.06317721e-01f, 1.53623670e-01f, 1.36353195e-01f, -1.96487643e-03f, 1.07399203e-01f, -1.69894844e-01f, 5.15501015e-02f, -7.62812570e-02f, 2.73762167e-01f,
  5.24489209e-02f, -3.16587955e-01f, 5.03442764e-01f, 5.73985279e-03f, 2.69467801e-01f, -2.62313753e-01f, -1.89763844e-01f, 1.94538236e-01f, 4.66184109e-01f, -4.55159768e-02f,
  -1.48325950e-01f, -3.75999093e-01f, -1.20639369e-01f, 4.45497669e-02f, 8.56339782e-02f, -6.71132877e-02f, -5.59290610e-02f, -1.84216410e-01f, -1.20445281e-01f, -2.92518049e-01f,
  1.49261570e-02f, -6.67224973e-02f, 3.81368701e-03f, -3.02457679e-02f, -5.98741956e-02f, 1.84818327e-01f, 2.57139832e-01f, 9.73806530e-02f, -1.80611417e-01f, -9.90871526e-03f,
  -2.47469306e-01f, -3.21387686e-02f, -5.34541160e-02f, -2.24146336e-01f, 6.81786656e-01f, 3.09686661e-01f, -1.11811370e-01f, -1.35396831e-02f, -1.91159636e-01f, -2.40751386e-01f,
  9.39276293e-02f, -1.68237805e-01f, -3.69306505e-02f, -6.25674725e-02f, 4.68219548e-01f, -6.81158900e-02f, -1.91908106e-01f, 2.01630831e-01f, -1.84783027e-01f, -2.16476545e-01f,
  -1.07839033e-01f, -7.77661502e-02f, -1.81608796e-01f, -3.99315581e-02f, -1.33815229e-01f, -1.61120728e-01f, -9.69376415e-02f, -1.47338897e-01f, 1.26949981e-01f, -1.58278868e-01f,
  -3.16588670e-01f, -8.71122163e-03f, -1.42918542e-01f, 2.35199794e-01f, -2.42340460e-01f, -8.69905949e-02f, 4.24343012e-02f, 3.67207766e-01f, 5.40472195e-02f, -1.87558979e-01f,
  -1.36632964e-01f, -7.04056770e-02f, -8.57625529e-02f, -2.71009177e-01f, 8.68717860e-03f, 7.79096037e-02f, -2.20919028e-02f, -7.42350593e-02f, 1.68558106e-01f, 1.41666725e-01f,
  -9.44135040e-02f, -7.28465840e-02f, -7.12199211e-02f, -1.84343219e-01f, 1.03720568e-01f, -2.23659992e-01f, 5.48965521e-02f, -7.33678639e-02f, 2.50381827e-01f, 8.29535201e-02f,
  -1.72933802e-01f, 3.48920338e-02f, -4.92146946e-02f, -1.35321230e-01f, -8.30574483e-02f, -5.24390973e-02f, -1.77175075e-01f, -1.39235169e-01f, 1.18481107e-02f, 3.72209102e-01f,
  -2.73528874e-01f, -1.60971642e-01f, 2.24085912e-01f, -1.94766432e-01f, -1.34145215e-01f, -1.25859350e-01f, 5.27521856e-02f, -2.88580537e-01f, -1.43036082e-01f, -1.75905347e-01f,
  2.33662371e-02f, -2.33656377e-01f, 3.04148465e-01f, -6.89684739e-03f, 2.15516780e-02f, -1.94175959e-01f, -1.19097814e-01f, 7.53031597e-02f, -1.58106953e-01f, -2.23963648e-01f,
  -3.39789246e-03f, -1.69406056e-01f, -3.21003228e-01f, -1.51772097e-01f, -2.24140789e-02f, -2.89056540e-01f, -4.39766407e-01f, -8.34877044e-02f, -2.66400844e-01f, 6.00015521e-02f,
  -1.61638737e-01f, -8.17189515e-02f, -6.45910129e-02f, 2.41656795e-01f, 4.41225499e-01f, -2.71115571e-01f, 1.10719591e-01f, -2.83117622e-01f, -2.84534901e-01f, -2.31082186e-01f,
  4.20936570e-02f, -1.25336349e-01f, 2.97359172e-02f, -9.22907963e-02f, 5.42725902e-03f, -5.01672924e-02f, -7.36995339e-02f, 2.60147929e-01f, -7.60939792e-02f, -5.12394169e-03f,
  1.46475220e-02f, 1.22114159e-01f, -1.14196494e-01f, -5.48699684e-02f, 8.40017796e-02f, -1.31628020e-02f, -8.13669488e-02f, -1.15644470e-01f, -5.52222840e-02f, -6.33612722e-02f,
  5.09512164e-02f, -1.82625338e-01f, -3.29758197e-01f, 1.18703373e-01f, 2.64230341e-01f, -3.46909463e-02f, 1.06856056e-01f, 1.12935834e-01f, -9.53642204e-02f, -1.30055845e-01f,
  -1.12977691e-01f, 2.06695139e-01f, 4.56278473e-02f, -1.76294651e-02f, 2.68012658e-03f, 2.61949569e-01f, -1.22383498e-01f, 3.76819789e-01f, -4.55687977e-02f, -9.92654711e-02f,
  -1.66256800e-01f, 3.29338789e-01f, 3.85524742e-02f, 1.57893002e-01f, -1.43154144e-01f, -1.27682433e-01f, -8.50424021e-02f, 9.74601805e-02f, 2.08751619e-01f, 1.30566299e-01f,
  -4.00492363e-02f, 1.60119999e-02f, -6.76188543e-02f, -1.55970482e-02f, -2.48620678e-02f, 1.26007766e-01f, 3.51239592e-02f, -1.17301866e-01f, 2.02338723e-03f, -6.94171414e-02f,
  -1.57526150e-01f, 1.96997419e-01f, 2.64764279e-02f, -1.40503302e-01f, -1.33891240e-01f, -5.75612485e-02f, -1.99957639e-01f, 2.62600742e-02f, 2.84641147e-01f, -1.73846394e-01f,
  -1.14103749e-01f, -5.95280528e-02f, -9.43972468e-02f, -4.79415134e-02f, -5.67415904e-04f, 1.41449541e-01f, 4.53805812e-02f, -7.35865384e-02f, 3.46097976e-01f, -8.56683031e-02f,
  -1.17085293e-01f, -4.08612518e-03f, -1.42220452e-01f, 2.20233783e-01f, 2.65247524e-01f, -3.81386317e-02f, -7.97277465e-02f, -1.63080513e-01f, -1.12123631e-01f, 2.35505641e-01f,
  -9.35475379e-02f, -4.28998470e-03f, -1.51267229e-02f, 5.04925475e-02f, -2.14328840e-02f, 1.14431590e-01f, -1.75343558e-01f, 6.08852645e-03f, 1.10523596e-01f, -1.56083882e-01f,
  1.45932788e-03f, -1.68035701e-01f, -2.36338675e-02f, 5.84835649e-01f, -2.40420312e-01f, 1.28841057e-01f, -9.34142172e-02f, 6.32609501e-02f, 8.98851901e-02f, 9.97808278e-02f,
  -7.04900026e-02f, -2.07625985e-01f, 2.34138697e-01f, 1.73161432e-01f, 2.11436898e-01f, -6.62341341e-02f, 2.78943032e-01f, -1.99676588e-01f, -2.89169282e-01f, -2.86920398e-01f,
  -1.51730224e-01f, 3.19911927e-01f, 5.49955547e-01f, 4.50931609e-01f, 2.45396808e-01f, -1.71956405e-01f, -1.95373252e-01f, -4.16030347e-01f, 1.25507876e-01f, -1.13415129e-01f,
  -1.64312553e-02f, 3.49395424e-01f, -1.45845106e-02f, -1.61669508e-01f, -1.31936103e-01f, 8.43324363e-02f, -1.76347911e-01f, 5.24736010e-02f, 1.51745975e-01f, -2.24408939e-01f,
  1.57832980e-01f, 4.52491529e-02f, -6.23396337e-02f, 2.07224339e-01f, -1.14733048e-01f, 1.07015125e-01f, -8.91119763e-02f, 2.50869483e-01f, -5.02194315e-02f, -1.10237800e-01f,
  -1.01568058e-01f, 1.52025325e-03f, -2.95043644e-02f, 1.31990746e-01f, -5.64263016e-03f, 3.54207665e-01f, -4.25492972e-02f, 3.47481251e-01f, 1.08367600e-01f, 1.68372747e-02f,
  -1.59377769e-01f, -1.80187151e-01f, -1.18436674e-02f, -8.77040550e-02f, -8.57838430e-03f, -2.29917303e-01f, -1.31093532e-01f, -5.73294573e-02f, 4.05905157e-01f, 3.07171255e-01f,
  -1.36542901e-01f, -2.83501465e-02f, -9.09522623e-02f, -6.11814074e-02f, -1.22878931e-01f, -6.73953742e-02f, -5.04333042e-02f, -1.60688013e-01f, -5.14454506e-02f, -1.43376235e-02f,
  1.72599673e-01f, -1.84493244e-01f, -7.81817064e-02f, -9.03953835e-02f, -1.28248423e-01f, -1.25048542e-02f, -7.29319314e-03f, -2.24517897e-01f, -1.62337944e-01f, 1.96487214e-02f,
  -6.26691878e-02f, -1.37130156e-01f, -1.77326337e-01f, -1.61412448e-01f, -1.51098758e-01f, 4.72991206e-02f, -1.39131606e-01f, 2.47746289e-01f, -1.07729062e-01f, 2.08488137e-01f,
  5.76321632e-02f, -1.62551641e-01f, -1.15750474e-03f, -1.95275322e-01f, -5.81735186e-02f, -1.07336447e-01f, -7.40028396e-02f, 5.90286404e-02f, -8.76083076e-02f, -1.59615695e-01f,
  -1.63621083e-01f, -7.05138445e-02f, -2.78212689e-03f, -2.65371919e-01f, 2.78827697e-01f, 1.06610768e-01f, 1.32584423e-01f, 8.01195726e-02f, -9.27261710e-02f, -1.11673698e-01f,
  -1.22086853e-01f, 1.39436334e-01f, -1.93882897e-01f, 4.98494320e-02f, -1.17294133e-01f, 3.76046032e-01f, 3.10022682e-01f, 3.84963185e-01f, 8.14067125e-02f, -1.89551935e-01f,
  -7.15572312e-02f, -1.70419827e-01f, -1.53119296e-01f, 1.61375940e-01f, -1.69316977e-01f, 4.91229594e-02f, 1.55996367e-01f, 7.90944472e-02f, 9.27977357e-03f, 3.82093713e-04f,
  2.12958500e-01f, -7.36480877e-02f, 7.98604731e-03f, -2.22493902e-01f, -4.06482786e-01f, -2.38244295e-01f, 2.98873901e-01f, -3.06479819e-03f, 3.48145783e-01f, -6.38558939e-02f,
  -2.95536160e-01f, -1.73407167e-01f, -4.53639543e-03f, 2.14181885e-01f, -3.10889423e-01f, 7.14324474e-01f, -1.32006153e-01f, -5.40611856e-02f, -1.29441708e-01f, -1.24482349e-01f,
  1.12135317e-02f, -7.90983289e-02f, 8.19562078e-02f, -1.99242100e-01f, -1.20779529e-01f, -9.24330801e-02f, 9.04852897e-03f, 1.23562671e-01f, -1.31268606e-01f, -1.69797137e-01f,
  1.68739542e-01f, -6.88375458e-02f, 3.52671444e-01f, 3.24603799e-03f, 2.37946911e-03f, 1.48430139e-01f, -2.83887655e-01f, 1.16153516e-01f, 2.79332120e-02f, -8.71565789e-02f,
  -5.22354096e-02f, -1.70181438e-01f, 1.53694987e-01f, 1.82143264e-02f, -1.54851358e-02f, -1.09803095e-01f, -1.70121655e-01f, 1.46352155e-02f, 2.61253774e-01f, 1.31738365e-01f,
  -1.17151670e-01f, -6.88288454e-03f, -1.36107951e-01f, 3.38420942e-02f, -2.10448816e-01f, -2.61479076e-02f, -6.26689270e-02f, -1.19172029e-01f, -1.28578857e-01f, -1.68895453e-01f,
  4.89410907e-01f, -1.19346388e-01f, 5.29983521e-01f, 4.64764386e-02f, 1.36178732e-01f, 2.66185552e-01f, 7.16509447e-02f, 8.39691833e-02f, -8.81348085e-03f, 2.09975019e-02f,
  1.65318489e-01f, -5.72112575e-03f, -6.88037798e-02f, 3.75940814e-03f, 2.53866874e-02f, -5.55030555e-02f, -1.23018891e-01f, 2.77018100e-02f, -2.86852140e-02f, 2.18716767e-02f,
  8.08413327e-02f, -1.28200099e-01f, 1.61149815e-01f, 1.11999437e-01f, 2.72696048e-01f, -2.65823960e-01f, 2.82630380e-02f, 3.35064791e-02f, -1.21971190e-01f, 8.23289901e-02f,
  1.55988848e-03f, -2.10192069e-01f, -2.09491655e-01f, 1.63075194e-01f, 2.70439237e-01f, 1.83970425e-02f, 7.46026170e-03f, 1.55958354e-01f, 8.21961313e-02f, 4.04928550e-02f,
  3.59124780e-01f, -1.72797680e-01f, -4.81017046e-02f, 1.56763896e-01f, 2.71566361e-01f, -1.49340197e-01f, 1.91354126e-01f, 4.48001057e-01f, -1.34278446e-01f, -1.18592918e-01f,
  3.49360369e-02f, 3.37789953e-02f, 1.69430003e-02f, -8.53674263e-02f, -1.26688555e-01f, 2.39238841e-03f, -2.13361084e-02f, 2.77942240e-01f, 2.93779314e-01f, 6.85181990e-02f,
  1.64471224e-01f, -3.32663596e-01f, 5.66589907e-02f, 1.18594751e-01f, -5.35590611e-02f, -6.22790270e-02f, 5.28133027e-02f, 3.06806099e-02f, 1.56169057e-01f, -9.22508463e-02f,
  -1.88660488e-01f, -1.76466912e-01f, 2.82133427e-02f, 4.87130314e-01f, -3.41408372e-01f, -3.15262377e-01f, -3.43227208e-01f, -2.72676826e-01f, 4.24104519e-02f, 2.94349372e-01f,
  -1.50438324e-01f, 3.52849394e-01f, 3.55288744e-01f, 3.92102540e-01f, -4.90768105e-02f, -1.00866824e-01f, -1.22541644e-01f, 5.48185408e-02f, 2.48951152e-01f, -7.16530904e-02f,
  -9.43475738e-02f, 3.40603329e-02f, -2.14714155e-01f, -1.06408887e-01f, 1.65494546e-01f, -7.40891993e-02f, -1.05035774e-01f, -4.82832901e-02f, 9.12947133e-02f, -1.68963760e-01f,
  -4.68715690e-02f, 7.64442310e-02f, 1.22140460e-01f, 2.01680943e-01f, -1.06883325e-01f, -2.88822353e-01f, -1.49591835e-02f, -9.51019004e-02f, 2.84045458e-01f, -1.15161769e-01f,
  -6.38334602e-02f, 6.73137838e-03f, -1.63359549e-02f, 1.26205519e-01f, 2.83019811e-01f, 2.42561474e-02f, -7.06172660e-02f, -1.87747940e-01f, 6.08442545e-01f, -1.11280784e-01f,
  -1.20116994e-02f, 7.76513815e-02f, -1.09954938e-01f, 5.02649471e-02f, -1.17000371e-01f, -1.74042150e-01f, 1.54585838e-01f, -1.31366029e-02f, 3.54913361e-02f, -6.53517619e-02f,
  -1.00177780e-01f, -1.25488997e-01f, -7.54954442e-02f, 3.09786964e-02f, -1.48313623e-02f, -8.51533711e-02f, -1.69080824e-01f, -7.29607791e-02f, 8.62066746e-02f, -8.26174021e-02f,
  8.89415294e-02f, -1.29533634e-01f, 2.63538629e-01f, 2.11771764e-03f, 2.08545988e-03f, 4.14054729e-02f, -1.85497589e-02f, -1.26570642e-01f, 1.11683197e-01f, 3.11335683e-01f,
  -1.39691725e-01f, 3.38326697e-03f, -1.56461775e-01f, -1.30828723e-01f, -5.70420846e-02f, 6.64908215e-02f, 4.18121666e-02f, 2.30947077e-01f, -2.13299826e-01f, 2.72467017e-01f,
  2.77606789e-02f, -1.10608846e-01f, -4.86743785e-02f, -2.01455373e-02f, -7.64768347e-02f, -1.16598859e-01f, -8.63055512e-02f, -1.52139217e-01f, -1.33009329e-01f, -9.67473537e-02f,
  8.10955912e-02f, -4.77366783e-02f, 2.02006046e-02f, 2.54011810e-01f, -1.37176096e-01f, -2.50446331e-02f, -1.79269880e-01f, 3.41075778e-01f, 4.00775522e-02f, 4.93201949e-02f,
  -5.02659269e-02f, 3.54563355e-01f, 2.17939198e-01f, -9.66581143e-03f, -6.89024758e-03f, -4.66522239e-02f, -6.55304492e-02f, -7.91361704e-02f, 3.80722620e-02f, -9.14057810e-03f,
  2.88160712e-01f, -5.46277016e-02f, -4.46760207e-01f, 2.84694377e-02f, 1.96284860e-01f, 1.20361656e-01f, 3.89047861e-02f, 7.01780468e-02f, -1.48470374e-02f, -1.26479670e-01f,
  2.21724600e-01f, -2.18227118e-01f, -8.84591267e-02f, -2.50418961e-01f, 5.41757405e-01f, 3.47036123e-01f, -5.86445481e-02f, -3.43006432e-01f, 3.40995103e-01f, 1.76556353e-02f,
  -2.01959148e-01f, -3.77419829e-01f, 2.50055164e-01f, 2.37835184e-01f, 3.83546472e-01f, -1.08171567e-01f, -7.73457885e-02f, 1.97877139e-02f, 1.73653185e-01f, -4.13542911e-02f,
  1.41980141e-01f, -3.95556055e-02f, -3.86662893e-02f, 1.77549466e-01f, 2.12524369e-01f, 5.05686626e-02f, -5.62814549e-02f, 1.20176524e-01f, -7.82165397e-03f, 1.00412056e-01f,
  -1.00163125e-01f, -1.19100526e-01f, 3.88057269e-02f, -7.26743415e-02f, 4.23998415e-01f, -3.11416119e-01f, 3.05829849e-02f, 3.45367827e-02f, -1.14645883e-01f, -2.72265106e-01f,
  3.48402187e-02f, 5.76758422e-02f, 4.28548940e-02f, -9.64932889e-02f, -9.88820195e-02f, 2.58249313e-01f, -3.21684666e-02f, 1.55788928e-01f, -1.40015170e-01f, -7.04283193e-02f,
  -1.51245087e-01f, 5.84933683e-02f, 1.35424193e-02f, 1.92931294e-01f, 3.53298187e-02f, -5.50330579e-02f, -1.49327248e-01f, 3.37673813e-01f, -6.68338686e-02f, 3.17084700e-01f,
  1.81761801e-01f, -7.49015883e-02f, -9.15407017e-02f, -7.73149431e-02f, 2.98791677e-01f, 8.15371647e-02f, 1.72954034e-02f, 1.93996981e-01f, 2.10409835e-02f, -7.04640374e-02f,
  1.07938401e-01f, -1.00756157e-02f, -4.99978140e-02f, 2.87861198e-01f, -1.71067581e-01f, -8.92473757e-02f, -4.63640206e-02f, -5.75981997e-02f, -9.20561403e-02f, -1.31215766e-01f,
  1.35022178e-01f, 5.84791541e-01f, -2.88392436e-02f, 4.41184342e-02f, 7.90024549e-02f, -8.49222019e-02f, -2.36177340e-01f, -1.55764520e-01f, -4.39000204e-02f, 1.64047946e-04f,
  -2.81402409e-01f, 4.48994190e-02f, 8.18295851e-02f, -6.88328221e-02f, 1.71702161e-01f, -3.18301469e-02f, -2.18777165e-01f, -3.34645510e-02f, 1.51331693e-01f, -5.89662977e-02f,
  2.17393655e-02f, -3.01510319e-02f, 1.57206431e-02f, -3.01835656e-01f, -5.13321720e-02f, -8.45590755e-02f, 2.74558254e-02f, -5.97728156e-02f, 2.40944102e-01f, -6.34338036e-02f,
  -2.35847458e-01f, -1.37379602e-01f, -2.83229291e-01f, 1.76382780e-01f, -1.62279442e-01f, -4.48500784e-03f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.65052235e-01f, 1.02726206e-01f, 8.20485279e-02f, -4.67192531e-02f, -2.39127241e-02f, 1.57025993e-01f, 5.40133454e-02f, -1.51186734e-01f, 9.74231660e-02f, -9.86086130e-02f,
  4.43186350e-02f, -1.56558640e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    