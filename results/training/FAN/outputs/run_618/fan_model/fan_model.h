/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.88325667e-02f, -3.32489103e-01f, 3.82904947e-01f, -1.67892963e-01f, -1.82308599e-01f, -7.36402199e-02f, -2.27789745e-01f, -2.09484637e-01f, -9.95186120e-02f, -2.28929259e-02f,
  -1.56328157e-01f, 1.19782381e-01f, 3.07893306e-01f, 1.22778393e-01f, 1.07309856e-01f, 8.90599564e-02f, 1.71405211e-01f, 4.84715760e-01f, 1.49649307e-01f, -1.19343631e-01f,
  -1.06617929e-02f, -1.28533602e-01f, -1.23859398e-01f, -4.46814932e-02f, -1.12047158e-01f, 2.50464287e-02f, -6.31632134e-02f, -1.19320832e-01f, -1.71374977e-01f, 5.38480878e-01f,
  1.38197660e-01f, 9.55686066e-03f, 1.41988307e-01f, -1.22936927e-01f, 6.00775657e-03f, 1.38294250e-01f, -7.24403234e-03f, 1.61982607e-02f, -4.00824565e-03f, -1.42629854e-02f,
  -2.24619582e-02f, 5.08162230e-02f, 8.07812661e-02f, 2.34832410e-02f, -4.60268259e-02f, 1.56158032e-02f, 8.24718177e-03f, 1.18968621e-01f, 4.77673784e-02f, -3.81385311e-02f,
  -3.67918909e-02f, -2.35833377e-02f, 4.06901240e-02f, -1.84658006e-01f, 8.66127759e-02f, 1.63857013e-01f, -9.33690593e-02f, 6.39124438e-02f, 4.82153185e-02f, 9.12815928e-02f,
  -4.47865501e-02f, 5.39442450e-02f, -4.91666654e-03f, -1.14298314e-02f, 2.24836767e-02f, -4.90298867e-03f, 8.05176646e-02f, -8.74539986e-02f, 9.74841602e-03f, -8.07194710e-02f,
  1.16189383e-02f, -3.29491943e-02f, -1.16574336e-02f, -6.60878494e-02f, 2.39477567e-02f, 5.48578277e-02f, -1.93017032e-02f, -2.62072426e-03f, -3.30634601e-02f, -3.99345495e-02f,
  5.26696863e-03f, 5.17465770e-02f, -2.90032327e-02f, 5.67922257e-02f, 2.22720113e-02f, 3.51989493e-02f, -8.11721571e-03f, -3.46399955e-02f, -6.14712015e-02f, -2.12898683e-02f,
  -8.95923972e-02f, 6.09258674e-02f, 1.25529066e-01f, 8.18750709e-02f, 4.45799641e-02f, -1.64950248e-02f, 2.87604220e-02f, -1.42417531e-02f, -1.39784990e-02f, 9.43939462e-02f,
  4.24378254e-02f, 2.38787439e-02f, -3.26128267e-02f, 8.10251385e-03f, 3.52574512e-02f, -7.64361024e-02f, -5.49225248e-02f, -4.77431118e-02f, 2.26751771e-02f, 3.04265581e-02f,
  -5.48412129e-02f, -6.74974248e-02f, -5.41568547e-02f, 3.86176035e-02f, -9.30134282e-02f, 7.29626417e-03f, 1.82857625e-02f, -6.99197650e-02f, -7.32936636e-02f, -2.74079293e-01f,
  3.31900775e-01f, -2.72862643e-01f, -1.00638315e-01f, 3.02802145e-01f, 4.22702953e-02f, -1.26077868e-02f, -3.67348343e-01f, -1.84820652e-01f, 1.99553028e-01f, -7.40624443e-02f,
  -2.17363238e-03f, 2.58757889e-01f, 1.58111036e-01f, -8.71938933e-03f, -2.02946007e-01f, -8.77761170e-02f, -2.12655887e-01f, -6.02317341e-02f, 1.49622083e-01f, 1.68875709e-01f,
  2.24640574e-02f, -1.27866179e-01f, -7.89931491e-02f, -5.92770576e-02f, -1.42610427e-02f, 1.70594424e-01f, -2.10449532e-01f, -5.42253815e-02f, -1.86268345e-01f, -2.18956228e-02f,
  1.41704544e-01f, -1.41678348e-01f, 1.04302324e-01f, 1.41219124e-01f, 1.51725961e-02f, 9.65401158e-02f, 8.22429806e-02f, -7.42219854e-03f, 7.19498191e-03f, 3.09005957e-02f,
  1.30400658e-01f, 3.26813608e-02f, 1.74456388e-01f, 8.66639763e-02f, 2.91641578e-02f, 1.96541864e-02f, -7.65077397e-02f, -1.99226648e-01f, 7.24669779e-03f, 1.06115295e-02f,
  1.58087760e-02f, -1.10804647e-01f, -1.26115739e-01f, -1.64476484e-01f, -1.56643733e-01f, -8.26865211e-02f, -1.87821954e-01f, -1.50759771e-01f, -1.59038469e-01f, -1.63538828e-01f,
  -8.92199483e-03f, 1.46766435e-02f, -4.87830490e-02f, -4.13697138e-02f, 8.20735171e-02f, -3.11631262e-02f, 7.71274697e-03f, -1.10141356e-02f, -4.61244360e-02f, -1.07714787e-01f,
  5.85311204e-02f, 1.73735078e-02f, -2.31918786e-02f, 3.73303704e-02f, 9.30889323e-03f, -4.20822874e-02f, 7.05811679e-02f, -3.65177020e-02f, 7.35204443e-02f, 9.13855061e-02f,
  8.84568766e-02f, -1.38160698e-02f, 5.18119708e-02f, -3.89524698e-02f, 4.57753204e-02f, 5.20658083e-02f, 7.25468695e-02f, -6.52545244e-02f, 2.94500627e-02f, 4.87785181e-03f,
  1.01815596e-01f, -8.93563181e-02f, 1.90613165e-01f, 8.11646692e-03f, 1.34842813e-01f, 5.26004545e-02f, 6.71868678e-03f, 8.00747499e-02f, 1.22795567e-01f, 7.34614283e-02f,
  5.93194701e-02f, 4.84450459e-02f, 1.40623963e-02f, 3.66830304e-02f, 1.03136942e-01f, -1.57107357e-02f, 5.21349199e-02f, 1.26153678e-01f, 5.57987988e-02f, 3.06366086e-02f,
  7.00433999e-02f, -4.12089229e-02f, 9.74942446e-02f, 1.00691676e-01f, 1.70883596e-01f, 1.90010726e-01f, 1.26144126e-01f, 1.28134206e-01f, 9.64916274e-02f, 1.86756104e-02f,
  -2.38197014e-01f, 2.19467983e-01f, 7.54598826e-02f, -1.97287142e-01f, -1.75270393e-01f, 2.86212489e-02f, 2.76115417e-01f, 2.76990652e-01f, 7.43349791e-02f, -9.20768725e-05f,
  -2.24731445e-01f, -2.56500542e-01f, -7.39137009e-02f, 1.54824451e-01f, 2.86674827e-01f, 1.78532869e-01f, 2.52438277e-01f, 1.72581136e-01f, -1.59198437e-02f, -1.44366235e-01f,
  9.87896845e-02f, -1.10027634e-01f, -2.52013840e-02f, 5.54447994e-02f, -1.33802906e-01f, -2.56901234e-01f, 2.07414012e-02f, 5.59601858e-02f, 9.77344513e-02f, 2.20886037e-01f,
  -1.24809660e-01f, 1.17654204e-01f, -6.21561194e-03f, -1.44942954e-01f, -9.34568271e-02f, 7.23159909e-02f, 9.25844815e-03f, 3.75063643e-02f, -1.27544224e-01f, -5.95323406e-02f,
  -8.04781988e-02f, -6.45659119e-02f, -3.96261252e-02f, 8.93483460e-02f, 4.29386832e-02f, 3.66827771e-02f, 1.01082377e-01f, 1.66695252e-01f, 2.30096772e-01f, -4.24249917e-02f,
  -1.21816605e-01f, -2.04327166e-01f, -6.06110767e-02f, 6.68018907e-02f, 5.43382391e-02f, -1.63056865e-01f, 7.72401616e-02f, 8.07196125e-02f, 2.42983654e-01f, 2.62381714e-02f,
  3.22243236e-02f, -2.11686697e-02f, 5.74474931e-02f, 1.30598377e-02f, -9.68392752e-03f, -4.47061798e-03f, 2.75712572e-02f, -5.71501292e-02f, 8.06087554e-02f, -8.46715122e-02f,
  6.52814358e-02f, -7.35658407e-02f, 6.04406372e-02f, 2.79151779e-02f, -1.42967269e-01f, 4.45606858e-02f, 5.79510964e-02f, 3.56895500e-03f, -9.42510727e-04f, -1.36104310e-02f,
  8.85628015e-02f, 2.85320189e-02f, -4.74983528e-02f, 8.83525759e-02f, 1.02406606e-01f, 3.68842036e-02f, -2.05620695e-02f, 5.66486716e-02f, -1.95359606e-02f, 3.76178846e-02f,
  -2.56413788e-01f, -2.86708004e-03f, -8.30260143e-02f, 1.29983231e-01f, -5.99985383e-02f, 2.63698101e-02f, 1.56006706e-03f, -4.29380462e-02f, -7.82090351e-02f, 7.60312676e-02f,
  -1.09682336e-01f, 4.37039658e-02f, -3.33640426e-02f, 1.13665901e-01f, -6.78858683e-02f, -1.08578429e-03f, -1.26719236e-01f, 3.37769501e-02f, 6.37045875e-02f, -9.87037048e-02f,
  5.32729290e-02f, -3.70670296e-02f, -1.06622837e-01f, 4.24422324e-03f, -9.86678712e-03f, -1.50749400e-01f, -6.74418136e-02f, -1.03875205e-01f, 2.84289289e-02f, -2.13330820e-01f,
  -4.47751492e-01f, 3.96076560e-01f, 3.46106261e-01f, -3.85329813e-01f, -1.98985022e-02f, -2.31088534e-01f, 4.27509733e-02f, -7.02497363e-02f, -2.39515096e-01f, 2.71533038e-02f,
  5.09527996e-02f, -9.02853608e-02f, 1.55096324e-02f, 4.25213538e-02f, -8.92116502e-02f, -7.49486405e-03f, -6.70038760e-02f, 8.59088078e-02f, -1.86979324e-01f, -3.71078223e-01f,
  -9.22545642e-02f, -5.11524193e-02f, -3.43056284e-02f, 9.00195632e-03f, 2.75797397e-01f, -7.30126500e-02f, 1.33324638e-01f, 8.55334848e-02f, 6.38766363e-02f, 6.44452751e-01f,
  3.42002273e-01f, 4.10474911e-02f, -1.36165008e-01f, -1.19668692e-01f, 1.11629806e-01f, -6.52179122e-03f, 3.43734697e-02f, 8.80244449e-02f, -8.04891661e-02f, 5.74685484e-02f,
  -2.65825614e-02f, -5.55186681e-02f, -6.53881058e-02f, 1.52366757e-02f, 7.09159486e-03f, 1.98213477e-02f, 8.64395425e-02f, 2.61041764e-02f, -3.07801347e-02f, 2.60203388e-02f,
  -2.98833083e-02f, -6.32398725e-02f, 7.12504098e-03f, -5.41404448e-02f, -2.69222510e-04f, -1.26807019e-01f, 1.64673820e-01f, 9.13370401e-02f, 7.75837451e-02f, 2.49841660e-01f,
  -1.59581956e-02f, 4.76254597e-02f, -2.70579476e-04f, 6.12580143e-02f, -3.72044258e-02f, 4.44475114e-02f, 1.24499034e-02f, 2.02581510e-02f, -4.98842597e-02f, 4.82059866e-02f,
  9.21843871e-02f, -4.32912335e-02f, -2.12184694e-02f, 4.63943556e-02f, -2.35558860e-03f, -8.71150848e-03f, -1.98750943e-02f, 1.19526442e-02f, -4.45839800e-02f, 5.98606355e-02f,
  3.51656824e-02f, 4.24228124e-02f, -1.23195713e-02f, 9.86625478e-02f, 3.08918748e-02f, 1.64178181e-02f, 3.43287997e-02f, 1.53816594e-02f, -5.11890762e-02f, 4.10822593e-02f,
  -1.08063683e-01f, -1.53500363e-01f, -8.57389793e-02f, 5.88330664e-02f, -7.69249499e-02f, 5.17967828e-02f, -1.30909104e-02f, -2.79487353e-02f, 7.22202882e-02f, -3.18709910e-02f,
  2.81966198e-02f, -2.79703853e-03f, 2.42361631e-02f, 1.37577623e-01f, -6.15487695e-02f, -1.06054209e-02f, -4.01390009e-02f, -4.91563156e-02f, -1.69935729e-02f, 4.21426743e-02f,
  -3.33164632e-02f, -2.39591032e-01f, -2.28538036e-01f, -8.92479345e-02f, -8.47770739e-03f, -2.34668046e-01f, 3.22620831e-02f, -7.41271526e-02f, -1.26553878e-01f, -1.69875890e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.15264559e+00f, -2.56724745e-01f, 1.58749640e-01f, -7.96901166e-01f, 8.17920193e-02f, -3.11681360e-01f, -3.53686035e-01f, -5.37696302e-01f, -4.44259137e-01f, 9.64459702e-02f,
  2.90584296e-01f, 1.81695685e-01f, 4.31151628e-01f, 3.13447118e-01f, -2.03298703e-01f, 3.75427008e-02f, -3.17253649e-01f, -2.52774119e-01f, -7.29883388e-02f, 1.10495239e-01f,
  1.19150795e-01f, -1.85600325e-01f, -3.93480390e-01f, 1.74068257e-01f, 1.12440467e-01f, 1.08347587e-01f, 1.53229311e-01f, -1.01823576e-01f, 2.55127728e-01f, 1.10568970e-01f,
  5.58729649e-01f, -3.51964414e-01f, 9.36636776e-02f, -1.30259603e-01f, 6.07850663e-02f, -4.90307286e-02f, 2.84121977e-03f, -4.33253944e-02f, 3.31237242e-02f, -1.84227328e-03f,
  2.43347082e-02f, 1.29782587e-01f, -7.39102960e-02f, 1.15693465e-01f, -1.51628882e-01f, -5.92803247e-02f, -7.15595335e-02f, -3.56934145e-02f, 7.61054829e-02f, 1.83034956e-01f,
  2.21578211e-01f, 5.66349030e-02f, -5.07947989e-02f, 1.23653524e-02f, -6.79252297e-03f, -4.74749915e-02f, 7.99253806e-02f, 2.15510782e-02f, 1.17962427e-01f, 2.67872284e-03f,
  -7.17069581e-02f, 1.58988550e-01f, -7.61326402e-03f, 2.58873552e-02f, -6.32992201e-03f, -8.80525857e-02f, 3.18656377e-02f, 8.31669420e-02f, -1.46604478e-02f, -7.85062613e-04f,
  3.23061086e-02f, -3.85628827e-02f, -3.93597372e-02f, -5.24982065e-02f, 1.22475877e-01f, -5.55173196e-02f, -6.57993369e-03f, 7.70009533e-02f, 8.19333270e-02f, -1.19757198e-01f,
  8.87426455e-03f, 8.84151235e-02f, -2.66268440e-02f, 3.46509442e-02f, -1.40774235e-01f, -8.19505751e-03f, 9.67974216e-02f, 7.74420053e-02f, -3.70670334e-02f, 6.49088668e-03f,
  -5.68520948e-02f, 6.40083998e-02f, -4.64553945e-02f, -1.05349766e-02f, 3.06030037e-03f, -5.73734753e-02f, 6.31768033e-02f, 1.24149071e-03f, 9.75247696e-02f, 5.35340831e-02f,
  -1.01917703e-02f, -2.25243215e-02f, 1.21643133e-02f, 9.83467028e-02f, -7.92436674e-02f, 1.14464127e-01f, -1.19230598e-01f, 5.12188002e-02f, 4.65117134e-02f, 3.69546302e-02f,
  -5.73458374e-02f, -1.72153279e-01f, -2.18117997e-01f, -8.72546881e-02f, -1.83645077e-02f, -1.40212834e-01f, 1.27238870e-01f, 7.43704960e-02f, -7.84071758e-02f, -4.63895574e-02f,
  -1.45174101e-01f, 4.46187735e-01f, 1.97476134e-01f, -3.09024155e-01f, 9.57986489e-02f, 3.07352662e-01f, 3.43549937e-01f, 1.40377253e-01f, 3.03067211e-02f, -4.95807603e-02f,
  3.25638592e-01f, -1.25725985e-01f, -2.29021966e-01f, -9.44989473e-02f, -7.22526908e-02f, 1.48661092e-01f, -1.86901033e-01f, -3.64121735e-01f, -1.74516156e-01f, -1.09912023e-01f,
  -1.33088827e-01f, -4.03318375e-01f, -4.03722346e-01f, -2.00101465e-01f, -2.00931713e-01f, -4.37248021e-01f, -5.79151064e-02f, -7.86427967e-03f, 1.89520866e-02f, -6.73878551e-01f,
  4.84968312e-02f, 3.81691635e-01f, -7.63419829e-03f, -2.45981872e-01f, 1.34967804e-01f, 2.97509134e-02f, 5.04004955e-02f, -1.59462076e-02f, 4.90747318e-02f, -4.64673005e-02f,
  -1.40438944e-01f, 1.41308904e-01f, -7.23722801e-02f, 1.14598334e-01f, 1.24201693e-01f, -3.69997248e-02f, 6.26211911e-02f, 1.42707527e-01f, -4.07581851e-02f, 1.77241296e-01f,
  -1.71236262e-01f, 8.83051753e-02f, -3.00358552e-02f, 1.47630900e-01f, 6.06700741e-02f, 3.67697217e-02f, 1.97940528e-01f, -3.76269296e-02f, 3.88963856e-02f, -2.91884661e-01f,
  3.66789959e-02f, -7.44800419e-02f, 1.07927322e-01f, -1.91615876e-02f, -6.04903884e-02f, 2.02995181e-01f, -1.23947524e-01f, -1.29206777e-01f, 2.72822045e-02f, -9.51113924e-03f,
  4.09968793e-02f, 3.85342427e-02f, -1.12732269e-01f, 1.77193098e-02f, -1.12487718e-01f, -1.40047967e-02f, 9.59710777e-02f, -1.54558122e-01f, 1.03170713e-02f, 2.65565943e-02f,
  3.30629386e-02f, 1.21243268e-01f, 5.69485277e-02f, -4.37043197e-02f, 7.19519854e-02f, 8.64009187e-02f, 1.83360472e-01f, -8.14709999e-03f, -1.41920373e-01f, 2.21965656e-01f,
  -3.47984642e-01f, 5.29558808e-02f, -1.58724096e-02f, 1.01018161e-01f, -6.13999218e-02f, 4.65399660e-02f, -3.80778639e-03f, 4.98143733e-02f, -5.56027479e-02f, 6.56803846e-02f,
  3.13365944e-02f, -5.37977144e-02f, 5.78133166e-02f, 4.72353597e-04f, -6.95139244e-02f, -9.11878943e-02f, 8.44080467e-03f, -2.12005898e-01f, -3.87853161e-02f, 1.44190699e-01f,
  2.01711105e-03f, -1.75861135e-01f, -5.73287427e-01f, -1.48680478e-01f, -2.33007982e-01f, -3.67284000e-01f, -1.37879372e-01f, -1.42328456e-01f, -1.44161329e-01f, -4.84101683e-01f,
  8.24185193e-01f, 1.02106802e-01f, -5.47340274e-01f, 2.07374528e-01f, -6.41271353e-01f, -2.38635391e-01f, -3.40218604e-01f, 2.95207530e-01f, 2.00113624e-01f, -2.35380054e-01f,
  -5.59398197e-02f, 2.22216379e-02f, 9.37909260e-02f, 1.51259035e-01f, 3.53234559e-01f, -3.25431973e-01f, -2.27231622e-01f, -3.09189241e-02f, 4.37390618e-02f, 1.33885100e-01f,
  3.80663723e-02f, 1.07838355e-01f, 4.04172838e-01f, 2.98342794e-01f, -3.22547615e-01f, -1.05328798e-01f, -2.68496186e-01f, -1.68833047e-01f, -8.69452506e-02f, -5.85296512e-01f,
  -1.03410080e-01f, -1.17658831e-01f, -8.01313296e-02f, 7.82558322e-02f, -2.14425847e-01f, 5.55071197e-02f, -1.01346612e-01f, 7.55453063e-03f, -1.69277955e-02f, 7.28863627e-02f,
  -1.93315417e-01f, 1.00711305e-02f, -6.65658191e-02f, -4.57438007e-02f, -1.15446053e-01f, -1.25356810e-02f, 4.99282666e-02f, 1.25963107e-01f, 3.29905041e-02f, 5.55273378e-03f,
  -1.59350261e-01f, -1.42406136e-01f, -2.62584358e-01f, 2.46505830e-02f, 8.09579566e-02f, -1.86227590e-01f, 2.09481991e-03f, -2.49044485e-02f, 1.58566562e-03f, 6.70700148e-02f,
  -3.53560410e-02f, -6.28673285e-02f, -1.72298662e-02f, 3.08248773e-02f, 3.08658159e-03f, -4.88223648e-03f, -7.75763439e-03f, 2.41145156e-02f, 1.35684296e-01f, -7.01631187e-03f,
  2.84213312e-02f, -5.43997176e-02f, -4.79517169e-02f, -8.29884224e-03f, 4.14548665e-02f, -5.99332377e-02f, -3.72416116e-02f, 1.02788173e-01f, 5.54405116e-02f, -2.92487144e-02f,
  1.06153674e-02f, 1.90782212e-02f, -6.56135678e-02f, 7.63937682e-02f, -8.81778896e-02f, 9.36072040e-03f, 3.07618454e-02f, 4.34078723e-02f, 7.37109780e-02f, -5.69653511e-02f,
  2.09166229e-01f, 4.01419923e-02f, -8.92525464e-02f, -9.05879959e-03f, 6.33266382e-03f, -7.03416169e-02f, -5.52927256e-02f, -1.36479605e-02f, -1.01211220e-01f, -3.03492155e-02f,
  5.46869300e-02f, 7.83560276e-02f, -8.20484851e-03f, -1.49736169e-03f, 1.40578290e-02f, -1.79758035e-02f, -6.77800775e-02f, -8.21008980e-02f, -3.37857977e-02f, 1.90708656e-02f,
  1.37472212e-01f, 1.33648008e-01f, 6.76912889e-02f, 7.00617656e-02f, -2.15472858e-02f, -3.80386114e-02f, 1.38016967e-02f, -1.22175381e-01f, 8.50817375e-03f, 1.53399989e-01f,
  1.79534420e-01f, -5.70309401e-01f, -7.03023970e-02f, -1.35415932e-02f, 1.57266572e-01f, 3.30384463e-01f, 3.53016168e-01f, 2.03493461e-01f, 9.00376812e-02f, -1.81778103e-01f,
  -4.56416279e-01f, -3.34239781e-01f, -2.88629919e-01f, -1.77782655e-01f, -1.09018423e-01f, 3.55956368e-02f, -2.49959081e-01f, -3.25928703e-02f, 2.01043323e-01f, 2.43725106e-01f,
  7.64910057e-02f, 1.82107184e-02f, -1.30438377e-04f, -3.08976602e-02f, 4.99806628e-02f, 1.67483047e-01f, -3.54730874e-01f, -2.75350422e-01f, -3.04006189e-01f, -5.97696841e-01f,
  -8.99157077e-02f, -3.35577250e-01f, 2.70561315e-02f, -2.31656387e-01f, -6.12756386e-02f, 2.15856731e-02f, 2.33633276e-02f, -4.67518531e-02f, -7.55765364e-02f, 1.72414649e-02f,
  -1.24432087e-01f, -1.39127553e-01f, -3.91191915e-02f, 1.04125373e-01f, 1.66210905e-01f, 1.59849703e-01f, -9.32616517e-02f, -1.80124000e-01f, -1.40852123e-01f, -2.03173190e-01f,
  -2.10071862e-01f, -1.99289709e-01f, -2.05989685e-02f, -4.58093211e-02f, -1.05192073e-01f, -1.28198683e-01f, -2.29748618e-02f, -1.63158119e-01f, -2.74080664e-01f, -1.79079138e-02f,
  2.69440133e-02f, -1.03810867e-02f, -7.70753026e-02f, 8.36577266e-02f, -1.42798927e-02f, -1.44147975e-02f, -5.56421420e-03f, 4.73740734e-02f, 8.61748457e-02f, 1.12802543e-01f,
  1.62083458e-03f, -4.48659509e-02f, -8.44945610e-02f, -3.00856605e-02f, -7.15854317e-02f, -6.22428805e-02f, -6.84099272e-03f, -2.89862324e-03f, -4.04392816e-02f, 9.96849462e-02f,
  4.42239381e-02f, -1.25047760e-02f, -2.70666368e-02f, 5.52034564e-02f, -1.12014487e-01f, -4.48253974e-02f, -7.88381994e-02f, 8.26506242e-02f, 1.14784218e-01f, 2.64037959e-03f,
  3.01666468e-01f, -2.22774953e-01f, 1.63138896e-01f, 5.34055606e-02f, -1.07509278e-01f, -1.12970516e-01f, -1.40017241e-01f, -1.79937005e-01f, -7.18476623e-02f, 3.03393439e-03f,
  -3.01576462e-02f, 1.04049660e-01f, -9.50374082e-02f, 8.21254253e-02f, 1.31149217e-01f, 2.48494335e-02f, -1.72666252e-01f, 1.10507324e-01f, -1.02283128e-01f, 1.25739768e-01f,
  1.40936328e-02f, 1.57146752e-01f, 3.48681897e-01f, 2.66431689e-01f, 1.06181130e-01f, 1.79929763e-01f, 2.89135724e-01f, 3.12602401e-01f, 1.89783335e-01f, 4.21825707e-01f,
  -8.92794669e-01f, -1.09334826e-01f, -4.76432234e-01f, 9.97610390e-02f, 6.03044033e-02f, 2.31911421e-01f, 1.49387509e-01f, 1.56894803e-01f, 2.28347838e-01f, 6.33120760e-02f,
  7.07631260e-02f, 1.62189558e-01f, 1.36120822e-02f, -1.40216246e-01f, -5.40241366e-03f, 1.39854178e-01f, 2.10199878e-01f, -3.74392092e-01f, -2.37348646e-01f, 2.06596479e-01f,
  2.84380168e-01f, -1.62988469e-01f, -4.09109712e-01f, 1.01274975e-01f, -5.26896603e-02f, -1.01284593e-01f, -1.71384558e-01f, -2.44957462e-01f, 1.63788810e-01f, -3.75480890e-01f,
  -4.80972499e-01f, -3.00036728e-01f, 1.97944924e-01f, -2.09641960e-02f, -9.05964931e-04f, 1.03097141e-01f, -1.16003174e-02f, -1.20568033e-02f, 5.92508726e-02f, 3.14207934e-02f,
  -2.04232223e-02f, 1.36721447e-01f, 3.20123769e-02f, -4.13025394e-02f, -8.13700557e-02f, -7.24578202e-02f, -4.10098024e-02f, -7.84960762e-02f, 8.11845660e-02f, 1.87275007e-01f,
  7.99155459e-02f, 1.05856605e-01f, -2.09233031e-01f, 1.92996502e-01f, 9.18415040e-02f, -1.35260131e-02f, -1.14231162e-01f, -7.88987726e-02f, -4.19439450e-02f, -3.59827608e-01f,
  3.83779667e-02f, -4.61784285e-03f, 2.35702023e-02f, -8.10347050e-02f, 1.24107957e-01f, -2.16251668e-02f, -1.27161155e-02f, -3.11393030e-02f, -1.62810553e-02f, -8.21107626e-02f,
  -5.39303645e-02f, 8.33034888e-03f, -4.29565925e-03f, -1.23978063e-01f, 6.65555522e-02f, 9.53870416e-02f, -9.48834717e-02f, 2.20171679e-02f, 5.90498634e-02f, -2.49927603e-02f,
  -1.02802254e-01f, 4.50847857e-02f, 3.34989540e-02f, -1.71545316e-02f, 9.02994424e-02f, -6.94358870e-02f, -1.97677109e-02f, 1.01134486e-01f, -4.37498987e-02f, 1.09836021e-02f,
  9.60433185e-02f, -4.28826064e-02f, -4.61023971e-02f, 4.62025627e-02f, -2.98979525e-02f, 1.71643645e-01f, -8.98615550e-03f, 2.30855029e-02f, 5.80923515e-04f, 2.19865292e-01f,
  1.52141359e-02f, 8.97876360e-03f, 5.58498651e-02f, -9.19522941e-02f, 2.73008626e-02f, 9.52829197e-02f, 3.26951295e-02f, -1.70086071e-01f, 1.45040482e-01f, 2.11273000e-01f,
  1.12539209e-01f, 1.58755302e-01f, -1.22183762e-01f, -2.46051941e-02f, -1.25115737e-01f, -3.95849831e-02f, -1.96241975e-01f, -2.81664968e-01f, -1.26173392e-01f, -2.45720237e-01f,
  3.02254289e-01f, -3.08876723e-01f, 3.46753150e-01f, 5.52248321e-02f, 1.22191794e-01f, 4.81149018e-01f, 1.73561081e-01f, 3.28236669e-02f, -3.61412242e-02f, -1.36771187e-01f,
  -4.75736558e-02f, 1.96549252e-01f, 2.03521878e-01f, 1.00591190e-01f, 9.24604237e-02f, 3.30170207e-02f, 4.58701625e-02f, 2.69029647e-01f, 3.96639436e-01f, 2.43552357e-01f,
  -1.36898920e-01f, -2.76122183e-01f, -1.93410158e-01f, -6.14885613e-02f, -7.20749497e-02f, 2.17788443e-01f, -8.93088877e-02f, -3.10377389e-01f, -1.80225521e-01f, -3.64269048e-01f,
  5.44591069e-01f, -8.67974460e-02f, 3.73689979e-01f, 1.11469142e-01f, 2.05825176e-02f, 9.45342183e-02f, 1.39826894e-01f, -1.55586824e-02f, 3.49671692e-02f, 5.99568747e-02f,
  -4.31374274e-02f, -1.13877859e-02f, 1.29796863e-01f, -1.61479741e-01f, -5.53741232e-02f, 7.18626902e-02f, -1.54940873e-01f, -1.50452301e-01f, -2.96647735e-02f, 1.33063450e-01f,
  -2.11664766e-01f, -1.02784991e-01f, 2.25516841e-01f, 1.06002301e-01f, 3.30070630e-02f, 1.51398137e-01f, -1.02374181e-01f, -1.12324134e-01f, -1.55219985e-02f, -2.24467874e-01f,
  1.29244700e-01f, 1.19911730e-01f, 1.70036852e-02f, -6.57678917e-02f, -3.76635008e-02f, 7.11778253e-02f, 5.95860668e-02f, 1.55947313e-01f, -1.69018563e-02f, -7.18326122e-02f,
  -5.72563037e-02f, -6.33532926e-02f, 3.18268090e-02f, 1.54995486e-01f, -3.87428626e-02f, -3.67836170e-02f, 1.03098033e-02f, 5.37937321e-02f, 1.18529601e-02f, -9.44426209e-02f,
  -8.39427263e-02f, 5.64818867e-02f, -6.68873265e-02f, -1.99911386e-01f, -1.88579485e-01f, 3.76882181e-02f, 1.30493715e-01f, -4.40715700e-02f, 7.01450855e-02f, -8.95376578e-02f,
  1.46982342e-01f, 5.27939647e-02f, 1.70286447e-01f, -4.74699698e-02f, -1.40379861e-01f, -1.14524119e-01f, -5.81544824e-02f, -7.98095465e-02f, -1.06256157e-02f, 3.26439478e-02f,
  6.68678284e-02f, 1.05701961e-01f, -7.37304688e-02f, -8.15290511e-02f, 4.54748720e-02f, -7.02710748e-02f, -1.72867894e-01f, 5.88537790e-02f, -9.61566251e-03f, 8.15041140e-02f,
  -9.73617360e-02f, 5.46827950e-02f, 4.62884426e-01f, 2.07595453e-01f, 8.75611007e-02f, 2.04789564e-01f, 1.43863350e-01f, 5.72342500e-02f, 2.52023309e-01f, 1.78230852e-01f,
  -4.55966145e-01f, -6.31744862e-01f, 1.70426946e-02f, -2.74898022e-01f, -2.98513710e-01f, 4.70198970e-03f, -4.48085487e-01f, 7.43034706e-02f, 1.31194606e-01f, -5.32683194e-01f,
  -3.06701213e-01f, -2.02696398e-01f, -1.65619329e-01f, 7.24685714e-02f, 2.18656495e-01f, -4.84537303e-01f, -1.77642271e-01f, 1.33242160e-02f, 3.94648135e-01f, 1.63592130e-01f,
  -2.10148215e-01f, -1.84303820e-01f, 2.87438720e-01f, 3.57528239e-01f, -3.67845923e-01f, 1.13417869e-02f, -2.99445540e-01f, -4.84346785e-02f, 3.62857990e-02f, -7.20699489e-01f,
  -2.75428444e-01f, -7.41628334e-02f, 1.64511696e-01f, -1.00077353e-01f, -7.54545853e-02f, -2.97252778e-02f, -6.38356656e-02f, -7.37404227e-02f, -6.85020909e-02f, 5.35544939e-03f,
  1.83899549e-03f, 1.38649508e-01f, 3.96679528e-02f, -4.43747453e-02f, 3.46968486e-03f, -4.45066653e-02f, 1.26436517e-01f, 4.08055820e-02f, -7.55703636e-03f, -2.58531928e-01f,
  -8.70679319e-02f, -4.66363095e-02f, -2.32440382e-02f, 1.30630285e-01f, 2.11890340e-01f, 1.86641708e-01f, 1.63988963e-01f, 1.86261237e-01f, 2.62255073e-01f, -5.18761694e-01f,
  3.77235003e-02f, -3.86220627e-02f, -7.63913319e-02f, 1.26212845e-02f, 7.71602914e-02f, -1.08803578e-01f, -4.13743705e-02f, -6.49512261e-02f, -2.92108540e-04f, 1.02435118e-02f,
  3.64338942e-02f, -7.99928457e-02f, -3.53974216e-02f, -1.23281986e-01f, -4.37653176e-02f, 1.95174646e-02f, 1.46925170e-02f, -1.06853016e-01f, 1.56467650e-02f, -1.30623151e-02f,
  9.31430832e-02f, 3.25528570e-02f, 2.35045478e-02f, 1.94331229e-01f, -1.26004726e-01f, -1.30673358e-02f, -8.57022181e-02f, -5.70845185e-03f, -9.80127417e-03f, 8.56290981e-02f,
  -1.75425664e-01f, 4.45479244e-01f, -3.47910702e-01f, 8.12912583e-02f, -9.21597257e-02f, -8.67745951e-02f, -1.08106874e-01f, 6.72204569e-02f, 5.01751304e-02f, -1.44540131e-01f,
  8.20048451e-02f, -1.10917903e-01f, -1.24412686e-01f, 2.97160409e-02f, 5.48388343e-03f, 8.85639265e-02f, -9.64230075e-02f, -5.45732677e-02f, -8.26884992e-03f, -9.32478234e-02f,
  2.78086849e-02f, -1.14442304e-01f, -1.90612987e-01f, -2.79252045e-03f, -9.95820481e-03f, 1.07230507e-02f, 2.20295917e-02f, 1.25679836e-01f, 9.85596180e-02f, -2.98391044e-01f,
  -7.02125728e-01f, 2.36658365e-01f, 5.92792667e-02f, -3.88626069e-01f, 3.87158483e-01f, 4.69398230e-01f, 7.67607450e-01f, 3.65444481e-01f, -1.90237284e-01f, 1.29870251e-01f,
  3.30935046e-02f, -3.32112640e-01f, -8.05069208e-02f, -5.87360561e-02f, 1.06261574e-01f, 3.88514787e-01f, 2.60578901e-01f, -2.45568916e-01f, -3.02478611e-01f, -1.57660395e-01f,
  1.05549768e-01f, -1.34294778e-01f, -4.49584007e-01f, -3.93340379e-01f, -6.84402734e-02f, -2.91234642e-01f, 1.83140859e-02f, -9.66001675e-02f, 1.47043541e-01f, -5.65285832e-02f,
  -2.28237599e-01f, -6.67281896e-02f, 7.50249103e-02f, -2.10140586e-01f, 3.42989378e-02f, -2.34924778e-01f, 5.47582805e-02f, -2.11726457e-01f, 5.82062677e-02f, -4.14409023e-03f,
  2.83325724e-02f, -6.18824130e-03f, 8.74604136e-02f, 3.10470555e-02f, 4.23144409e-03f, -2.95033772e-02f, -1.18492670e-01f, -3.14858913e-01f, -4.82364707e-02f, -4.15723622e-02f,
  2.31617138e-01f, 1.06421717e-01f, 2.43906513e-01f, 1.71514288e-01f, 1.80869356e-01f, -2.27570802e-01f, 1.09630287e-01f, -2.61468384e-02f, 4.72338013e-02f, -2.02399090e-01f,
  6.24934444e-03f, -3.58636118e-02f, 2.17895955e-02f, -1.25751421e-01f, -6.93120435e-02f, 4.19406258e-02f, 5.05280271e-02f, 9.24603716e-02f, -1.87502243e-02f, -2.62840409e-02f,
  1.04628891e-01f, -2.59049200e-02f, -1.40080333e-01f, -7.13721067e-02f, -7.41386637e-02f, -3.49308997e-02f, -2.06135754e-02f, -9.63219851e-02f, 7.09872097e-02f, 7.23842829e-02f,
  6.68828115e-02f, 9.18524414e-02f, 2.46881377e-02f, -1.33540537e-02f, -6.13608360e-02f, -1.39590457e-01f, -3.89925353e-02f, 4.07998934e-02f, 8.83433688e-03f, -3.70194204e-02f,
  -1.40290901e-01f, 2.44642302e-01f, -8.22484717e-02f, 5.77338897e-02f, 8.19214955e-02f, -3.72303575e-02f, -1.92569792e-01f, -6.87844530e-02f, -7.47770863e-03f, -9.34527591e-02f,
  5.53413108e-03f, -8.50816369e-02f, 6.28890917e-02f, 1.74371824e-02f, -2.27749813e-02f, -1.47619750e-02f, -2.28502061e-02f, 6.08816685e-04f, -2.49065161e-02f, -6.57346621e-02f,
  7.57027045e-02f, 3.85164879e-02f, 4.24505845e-02f, 5.90789616e-02f, 2.36208364e-02f, -2.73837298e-02f, 4.57655825e-02f, -6.80934861e-02f, 8.19371641e-02f, -2.60318220e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.00842571e+00f, 1.55597225e-01f, 3.50003392e-01f, 4.62129265e-01f, -2.20384095e-02f, 4.87339534e-02f, 1.96037740e-01f, 4.36647117e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -7.34100118e-02f, 4.68015596e-02f, -1.35816976e-01f, -1.18009366e-01f, -2.42939800e-01f, 1.32348552e-01f, -2.76046067e-01f, -2.69171625e-01f, -2.71926045e-01f, 5.06555401e-02f,
  3.76191884e-01f, -1.21238023e-01f, 5.92330098e-01f, -2.76358694e-01f, 2.98098654e-01f, -5.48093170e-02f, -1.01893567e-01f, -6.59014210e-02f, -3.17185163e-01f, 7.65895173e-02f,
  1.00569621e-01f, 1.11981640e-02f, -1.50456369e-01f, 6.23638570e-01f, -2.46275635e-03f, 1.12268366e-01f, -4.46158797e-01f, -5.58458501e-03f, -5.95208824e-01f, 1.69690818e-01f,
  -5.36321640e-01f, 2.42003798e-01f, -1.50585026e-01f, -1.08750679e-01f, -1.58864215e-01f, 2.64842689e-01f, 4.95288894e-02f, -2.32653543e-01f, -3.10501438e-02f, 2.41309226e-01f,
  -1.26181409e-01f, 2.38888040e-01f, -2.42518038e-01f, -1.67707801e-01f, -6.45033419e-02f, -2.14947477e-01f, -4.91700172e-01f, 2.14790344e-01f, 1.70334145e-01f, 1.21276215e-01f,
  5.40358946e-02f, 6.95872456e-02f, -2.24912211e-01f, -5.11118732e-02f, -1.69434533e-01f, -2.63733238e-01f, -4.75896478e-01f, -1.73527971e-01f, 5.13531506e-01f, 3.06122690e-01f,
  3.16662014e-01f, 2.59476572e-01f, -3.46612871e-01f, 4.71748598e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.56226969e-01f, 5.30020952e-01f, 3.97186488e-01f, 5.32316744e-01f, -2.55303562e-01f, -1.23229861e-01f, -2.62510359e-01f, -4.82310764e-02f, 5.10446072e-01f, 1.09821908e-01f,
  -6.69537425e-01f, 9.79354262e-01f, -2.90433943e-01f, -3.23059380e-01f, -7.49338686e-01f, 4.68753666e-01f, 3.39683473e-01f, -3.99164334e-02f, -2.71953225e-01f, 4.01722401e-01f,
  2.53830682e-02f, -5.48260093e-01f, 4.43084836e-01f, -8.47848952e-02f, 5.35598934e-01f, 4.72016871e-01f, -6.70000851e-01f, -9.47425812e-02f, 5.27334392e-01f, -9.70669016e-02f,
  2.54949272e-01f, 8.37362409e-01f, 1.82323799e-01f, 2.33309209e-01f, 3.39586586e-01f, -1.28481477e-01f, 2.36054659e-01f, 5.47435522e-01f, -2.00018659e-01f, 3.09180245e-02f,
  1.40286624e-01f, -1.51436821e-01f, 4.65860426e-01f, 2.04896510e-01f, -5.27423024e-01f, 3.29232126e-01f, -1.88975215e-01f, 4.38901782e-02f, 2.22751990e-01f, 3.20811749e-01f,
  -8.87003466e-02f, 2.65632480e-01f, 3.61764014e-01f, -5.49827397e-01f, 4.29974169e-01f, 5.09315550e-01f, -6.55900687e-02f, -1.24800630e-01f, 4.00539450e-02f, -3.48688990e-01f,
  6.96881786e-02f, -6.69357896e-01f, 9.47494656e-02f, 6.42127037e-01f, 2.41465569e-01f, 8.50445256e-02f, 2.80587792e-01f, -9.68012661e-02f, -2.18952909e-01f, 7.23955315e-03f,
  2.71255318e-02f, -4.20742333e-01f, -5.59353471e-01f, 2.58174866e-01f, 6.41621575e-02f, 6.64434433e-01f, 2.13881377e-02f, 5.69763705e-02f, 1.09021410e-01f, -1.90776989e-01f,
  8.03370655e-01f, 3.10098380e-01f, 3.29458535e-01f, -9.87612009e-02f, 5.08931875e-01f, 4.62228328e-01f, -4.24738020e-01f, 1.02341130e-01f, 4.94973153e-01f, 1.49102867e-01f,
  -4.14015166e-03f, 5.87892830e-01f, -1.87770829e-01f, -2.14853883e-01f, 2.10506888e-03f, -2.89036393e-01f, -1.82724163e-01f, 1.62001818e-01f, 1.98061969e-02f, 3.25707734e-01f,
  4.61429328e-01f, -4.15669769e-01f, 3.67103845e-01f, 2.78119624e-01f, 8.72432292e-01f, 4.05349940e-01f, -1.83706686e-01f, 1.10006332e-01f, -9.58427147e-04f, -2.59038419e-01f,
  5.48227608e-01f, -7.45686190e-03f, -2.65541822e-01f, 1.86816975e-01f, 1.42680660e-01f, 6.21354103e-01f, -8.55883777e-01f, -3.82000580e-02f, 9.22200363e-03f, -2.32036278e-01f,
  4.25075024e-01f, 9.28247213e-01f, 3.52222398e-02f, 3.95071536e-01f, -9.57770273e-02f, -5.83629727e-01f, -1.81728840e-01f, 7.22998939e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.29398167e-01f, -1.52708907e-02f, 2.68353105e-01f, 3.54316533e-01f, 3.14220816e-01f, 1.16914302e-01f, -6.45261025e-03f, 1.62622109e-01f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  8.60108808e-02f, 9.39200670e-02f, 6.71751648e-02f, 1.85678065e-01f, -3.73896331e-01f, 3.25216055e-02f, 4.81314212e-01f, 2.82977313e-01f, 3.22705954e-01f, 4.42619249e-02f,
  -1.81805760e-01f, 4.16157633e-01f, -2.68660784e-01f, 2.57838905e-01f, -2.66458720e-01f, -2.56678492e-01f, 5.06261513e-02f, 1.44615427e-01f, -2.63510466e-01f, 1.91817328e-01f,
  8.23647901e-02f, 8.33384618e-02f, 8.34519118e-02f, -4.46715504e-01f, -6.01020932e-01f, -3.21266919e-01f, 3.53701204e-01f, 3.41359615e-01f, -1.45820498e-01f, 9.75515619e-02f,
  7.53161013e-02f, -1.27414122e-01f, 4.11318451e-01f, -5.54537736e-02f, -1.44918710e-01f, 3.87857407e-01f, -2.01173514e-01f, 4.95822638e-01f, 6.99466288e-01f, 1.99175760e-01f,
  -1.33688927e-01f, -7.68606812e-02f, 2.34629855e-01f, 4.45832819e-01f, -1.08955100e-01f, 2.61827052e-01f, -4.04304177e-01f, -5.88046648e-02f, -1.76377282e-01f, -2.83077687e-01f,
  5.48773892e-02f, -1.90892994e-01f, 4.09847230e-01f, -2.65895754e-01f, 9.80131626e-02f, 2.16645896e-01f, 4.38390486e-02f, 4.52662706e-01f, 3.36591452e-01f, 1.22791184e-02f,
  2.85595451e-02f, -4.70818520e-01f, -2.57077664e-01f, -1.91616893e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.34651589e-01f, 4.52824961e-03f, 4.78633493e-02f, 2.10322276e-01f, -2.74931282e-01f, -2.37376511e-01f, -6.28815770e-01f, -3.39430124e-01f, -2.65149802e-01f, -2.58599222e-02f,
  -3.15140411e-02f, 8.41402709e-01f, -5.57516098e-01f, 5.49820103e-02f, 1.44401088e-01f, -4.72619206e-01f, 4.92624015e-01f, -3.57148260e-01f, 7.40635395e-01f, -3.62323314e-01f,
  4.77672815e-01f, -1.22382951e+00f, -7.22038627e-01f, -2.13266477e-01f, 8.09666589e-02f, 2.26052061e-01f, -2.18786895e-01f, 2.07051516e-01f, -5.65247118e-01f, 1.04008563e-01f,
  7.62013793e-02f, 8.75968635e-02f, 3.16029787e-01f, 3.45612288e-01f, 1.91743240e-01f, -2.39756614e-01f, -3.19351494e-01f, -1.83124602e-01f, -8.16034019e-01f, 6.84648633e-01f,
  8.62115681e-01f, -5.21714687e-01f, 3.11035156e-01f, -1.07919626e-01f, 2.57220268e-01f, 9.40018713e-01f, -2.11986657e-02f, -6.78522825e-01f, 3.49098176e-01f, -1.46872327e-01f,
  6.79494619e-01f, -4.96743530e-01f, 1.04097679e-01f, -5.97261786e-01f, -1.07336867e+00f, -4.74936217e-01f, 2.08409697e-01f, 2.89860398e-01f, 8.04511607e-02f, 3.78049225e-01f,
  6.49443045e-02f, -8.04692805e-02f, 2.75739163e-01f, 2.40931079e-01f, -3.75350177e-01f, 2.48988748e-01f, 3.32744420e-01f, 4.84097824e-02f, 2.20348448e-01f, -2.72227585e-01f,
  -3.90640825e-01f, -1.47278160e-01f, 7.04941392e-01f, 4.78219569e-01f, -1.49025815e-02f, -5.46085715e-01f, 2.38832399e-01f, 2.39643142e-01f, 1.21325649e-01f, 6.85029328e-01f,
  -6.30105376e-01f, 2.09363505e-01f, 9.28172469e-02f, 3.44102800e-01f, -2.15432927e-01f, -9.18341503e-02f, -6.36330485e-01f, -4.94079828e-01f, 3.76836583e-02f, 2.76097715e-01f,
  5.11585474e-02f, -5.22981048e-01f, -2.80933261e-01f, 7.56531775e-01f, 7.03800619e-01f, 6.74552381e-01f, 5.58503926e-01f, 4.09382045e-01f, 3.96036118e-01f, 6.21454000e-01f,
  -6.61349595e-01f, 6.97507501e-01f, 3.69153947e-01f, -2.11304888e-01f, 5.28230548e-01f, 7.97083378e-01f, 3.09043154e-02f, 9.27027524e-01f, -4.65235889e-01f, 1.96147263e-02f,
  4.08258796e-01f, 5.72434485e-01f, 4.85428602e-01f, 3.57595421e-02f, 5.83863616e-01f, 1.00353085e-01f, -1.37711793e-01f, 3.07157874e-01f, -2.66699970e-01f, -9.83962566e-02f,
  3.37378085e-02f, 2.53033370e-01f, -3.68111557e-03f, 8.71206522e-01f, -6.12414896e-01f, 2.14923739e-01f, 5.65315820e-02f, 2.90569197e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  2.98140138e-01f, 2.96245445e-04f, 3.98470134e-01f, 8.41452926e-02f, 4.61252898e-01f, 7.78087899e-02f, 3.14085960e-01f, 1.40179336e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  3.88440430e-01f, 6.15806699e-01f, 2.91347802e-01f, 1.37766421e-01f, -4.46372598e-01f, 1.10582006e+00f, 1.87592417e-01f, 3.45054865e-01f, 6.02315903e-01f, -4.28344399e-01f,
  -1.80697311e-02f, -5.41870035e-02f, -3.07576180e-01f, 1.80301234e-01f, 1.78522855e-01f, 1.75227642e-01f, -2.02670589e-01f, 1.79611668e-01f, 2.60672182e-01f, -3.54182154e-01f,
  -8.67149889e-01f, 3.44062567e-01f, 2.82158196e-01f, 7.43913352e-01f, 2.77760476e-01f, 3.35306048e-01f, -3.32665920e-01f, 1.67611346e-01f, 1.16697870e-01f, 1.22602686e-01f,
  -2.21626148e-01f, 2.77779579e-01f, 2.82914162e-01f, 9.18193981e-02f, -1.56314835e-01f, 5.96648306e-02f, -7.49530494e-01f, 3.80690545e-01f, -4.13475260e-02f, 5.16442955e-01f,
  3.53221536e-01f, 3.35451543e-01f, -1.93181038e-01f, 2.45799258e-01f, 1.60867363e-01f, -2.54826080e-02f, -2.63437778e-01f, 3.10585171e-01f, 4.10208523e-01f, 1.68544456e-01f,
  3.71015556e-02f, 2.52213217e-02f, -5.13291299e-01f, -2.88402975e-01f, 4.64713993e-03f, -5.08214951e-01f, 1.26890494e-02f, -4.10351157e-01f, 4.28499341e-01f, -5.98780848e-02f,
  -3.21313143e-02f, 2.11932868e-01f, -3.60683165e-02f, -2.16878206e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  7.56042540e-01f, 3.30052912e-01f, 7.78236985e-01f, 5.50692737e-01f, -1.06085277e+00f, -7.53087640e-01f, -7.49479234e-01f, 6.57707572e-01f, -5.93528330e-01f, -2.68994659e-01f,
  9.82531726e-01f, 4.21306074e-01f, 6.90506518e-01f, -2.62465119e-01f, -9.03501809e-01f, -7.81385541e-01f, 8.83856490e-02f, -3.63795757e-01f, -2.09416285e-01f, 6.02303207e-01f,
  1.63078710e-01f, -1.44974267e+00f, -7.64892757e-01f, 7.81505287e-01f, -4.64380890e-01f, 2.66410977e-01f, -4.03839082e-01f, 5.87950587e-01f, 1.09686482e+00f, 7.44807899e-01f,
  7.66665697e-01f, -1.61869898e-01f, 6.18940532e-01f, 3.97332013e-01f, 1.75698116e-01f, 3.66176575e-01f, 4.87605155e-01f, 7.28812158e-01f, 2.07829997e-01f, 4.25895423e-01f,
  7.13917136e-01f, 5.64338267e-01f, 1.87131196e-01f, 6.86065078e-01f, -1.62486315e-01f, -3.29905689e-01f, 6.39328361e-01f, 7.50555813e-01f, 5.06137609e-02f, 2.99038321e-01f,
  -1.17307596e-01f, 4.14094366e-02f, -3.47513467e-01f, -8.05034220e-01f, -8.59372497e-01f, -7.98529387e-01f, -2.43057117e-01f, 5.68205893e-01f, 6.75999820e-01f, 3.37608427e-01f,
  8.50544631e-01f, 1.20737720e+00f, -1.87330499e-01f, -1.24388367e-01f, 6.29669130e-02f, 4.86223668e-01f, 4.65023547e-01f, 2.92294562e-01f, 2.23141044e-01f, 5.77268839e-01f,
  5.39047122e-01f, -5.02034843e-01f, 8.00416052e-01f, -3.31881680e-02f, -2.33311236e-01f, 4.57841575e-01f, -5.08288980e-01f, -4.13711905e-01f, 4.36019808e-01f, 6.41545475e-01f,
  6.76980376e-01f, 4.53356326e-01f, 4.01802123e-01f, 3.27857971e-01f, 4.31343019e-01f, 4.15167123e-01f, 6.84160709e-01f, -8.54827464e-01f, 1.31262481e-01f, -6.60990417e-01f,
  5.64111471e-01f, -2.38600180e-01f, -3.75224739e-01f, 6.86972290e-02f, 2.48339817e-01f, 4.35448527e-01f, 2.42392123e-01f, -2.10213318e-01f, 9.48335901e-02f, -4.62597609e-01f,
  6.50126219e-01f, 2.17617095e-01f, -7.21931517e-01f, -1.14946640e+00f, 1.05626822e+00f, 2.83548862e-01f, 4.34543282e-01f, 4.90444064e-01f, -2.92330056e-01f, 7.35493824e-02f,
  -6.65199086e-02f, 5.19856095e-01f, -5.76625884e-01f, 3.88965517e-01f, 1.26174465e-01f, -8.45764726e-02f, 1.42091870e+00f, -3.74654740e-01f, 1.00993896e+00f, -3.98915052e-01f,
  -1.37535229e-01f, -1.12162900e+00f, 4.70094740e-01f, -3.93496871e-01f, 1.35033131e-01f, 2.45883018e-02f, 8.55998933e-01f, 7.20687568e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  5.82556903e-01f, -8.90288129e-02f, 5.22049107e-02f, 2.94407289e-02f, 1.39853001e-01f, 4.99931604e-01f, -4.34182048e-01f, 1.78841695e-01f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  4.92684782e-01f, 3.47755343e-01f, 6.23039484e-01f, -2.37869769e-01f, 6.93062186e-01f, 9.14338768e-01f, -1.12989672e-01f, 1.41347498e-01f, -4.91954446e-01f, 2.96639651e-01f,
  -1.46374702e+00f, 3.26184362e-01f, -5.12377441e-01f, -4.63866860e-01f, -9.81482387e-01f, 1.84676036e-01f, -1.94123745e-01f, 8.66782784e-01f, 4.89072382e-01f, -9.32906806e-01f,
  1.09805667e+00f, -6.97914898e-01f, -1.07009612e-01f, 5.50887942e-01f, 4.95562017e-01f, -1.26529849e+00f, 1.35664940e-01f, 1.14909373e-01f, -8.14160943e-01f, 4.27848160e-01f,
  -3.98244798e-01f, -2.80978471e-01f, -8.51855040e-01f, -1.54228866e-01f, -3.19020063e-01f, 5.06613612e-01f, 5.36683023e-01f, 4.13072437e-01f, 4.60723758e-01f, 4.49809944e-03f,
  -3.05481225e-01f, -4.31515664e-01f, 1.68378502e-01f, 7.93206468e-02f, 3.24055374e-01f, 2.17239842e-01f, 8.21823537e-01f, -1.22738147e+00f, 4.00037378e-01f, 2.33409926e-01f,
  -4.84340712e-02f, -6.90209150e-01f, 5.44935822e-01f, -6.25284076e-01f, -4.53719825e-01f, -4.89354759e-01f, -4.30962771e-01f, 2.26866707e-01f, 3.28474224e-01f, -5.11313938e-02f,
  -3.11231226e-01f, -7.59468794e-01f, -3.76293749e-01f, -2.88214713e-01f, -5.62964320e-01f, -5.49018383e-01f, -3.28309655e-01f, 7.75155962e-01f, -7.72631049e-01f, 7.56462812e-01f,
  1.17666686e+00f, 2.39859402e-01f, -8.48397434e-01f, 2.93931067e-01f, -2.89360702e-01f, 3.66543263e-01f, -9.38892007e-01f, 6.22133762e-02f, -1.42674610e-01f, -8.90759528e-01f,
  3.55007619e-01f, 5.25807738e-01f, -3.70479882e-01f, 6.95358142e-02f, -7.50400066e-01f, -1.71072558e-01f, 4.37441409e-01f, 1.01796530e-01f, 5.75707674e-01f, 1.31658763e-01f,
  -7.36649156e-01f, 3.86554331e-01f, 1.35602579e-01f, -8.79010022e-01f, -3.07761997e-01f, -1.45403957e+00f, -2.65914977e-01f, 3.34747374e-01f, 5.24359167e-01f, 7.65090466e-01f,
  -1.29194632e-01f, -4.05651212e-01f, 2.79649552e-02f, -2.64829069e-01f, -5.35499692e-01f, -1.48238134e+00f, 4.57407594e-01f, -1.17091775e+00f, 2.97860980e-01f, 3.46015602e-01f,
  4.51549321e-01f, 2.20492750e-01f, 1.22208260e-01f, -2.98092932e-01f, 2.00219259e-01f, -6.59936905e-01f, 1.82104051e-01f, 1.00931883e+00f, 8.82144451e-01f, 3.06722462e-01f,
  3.24473307e-02f, -6.11505657e-02f, 5.76081991e-01f, -8.99223924e-01f, 2.44031981e-01f, -4.89843041e-01f, -2.27010742e-01f, 1.18601359e-01f, 4.11653705e-02f, -1.55448461e+00f,
  2.38390818e-01f, 7.17099369e-01f, -8.54032159e-01f, -3.04736018e-01f, -9.33021367e-01f, 1.15095347e-01f, 5.92563570e-01f, -5.88451803e-01f, -2.39708066e-01f, 1.20014727e-01f,
  -4.86063927e-01f, 7.59145245e-02f, 3.36682260e-01f, -1.45587578e-01f, 7.33810365e-01f, 2.21083667e-02f, -1.22263968e-01f, -5.14836192e-01f, 4.94147122e-01f, -5.18953204e-01f,
  -6.01347029e-01f, 5.28026819e-01f, -1.06874061e+00f, -7.20108747e-01f, 1.99093625e-01f, 1.62749290e-01f, -1.34297803e-01f, 2.71984667e-01f, 3.24458092e-01f, 4.62858647e-01f,
  -1.76743940e-01f, -1.84402779e-01f, -1.14450371e+00f, 1.01671450e-01f, -8.46635282e-01f, -3.40216197e-02f, -1.37613609e-01f, -8.94119680e-01f, -6.07876897e-01f, -2.50845030e-02f,
  -6.25910103e-01f, 2.98634410e-01f, -1.18106794e+00f, 1.30586833e-01f, 3.29256624e-01f, 3.69399816e-01f, 3.19140732e-01f, 5.52104294e-01f, -1.19756728e-01f, 5.13317585e-01f,
  -1.74979314e-01f, -1.22950637e+00f, -1.46679747e+00f, -7.92295516e-01f, -3.96923751e-01f, 2.74977565e-01f, 3.42412181e-02f, -7.39726603e-01f, -1.42662711e-02f, 2.52794683e-01f,
  -1.18136239e+00f, 3.95957559e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.38136049e-02f, 5.78102589e-01f, 2.88490821e-02f, -5.67856133e-01f, 2.84001946e-01f, 1.42392918e-01f, -1.71594992e-02f, 4.62573022e-02f, -1.31615952e-01f, 1.16750792e-01f,
  -5.90493023e-01f, 8.92119780e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    