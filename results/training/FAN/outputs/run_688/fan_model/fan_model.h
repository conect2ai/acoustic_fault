/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.25466616e-03f, 1.33593172e-01f, -2.32849255e-01f, 8.74440596e-02f, -5.54320961e-02f, -7.48263374e-02f, 2.47054007e-02f, 9.15338397e-02f, -1.71829555e-02f, 6.74925968e-02f,
  1.02079026e-01f, 5.98978177e-02f, -3.92718129e-02f, -7.29860589e-02f, -8.00603330e-02f, -1.81679264e-01f, -1.57023057e-01f, -2.56603301e-01f, -9.66674089e-02f, 6.12091646e-02f,
  1.10444628e-01f, 4.34473120e-02f, 5.98248839e-02f, -3.48084383e-02f, 3.30653973e-02f, -5.77708473e-03f, 4.65990379e-02f, -4.74705882e-02f, -6.36670664e-02f, -3.63179632e-02f,
  -4.85120760e-03f, -4.17629480e-02f, -8.10124129e-02f, -5.79946637e-02f, -3.88172530e-02f, -3.21767628e-02f, -8.73022452e-02f, -8.24522674e-02f, -2.06164513e-02f, -1.07435130e-01f,
  -1.02869406e-01f, -8.79612640e-02f, -1.24556102e-01f, -7.44985119e-02f, -1.02465048e-01f, -1.26529977e-01f, -8.57794136e-02f, -2.35959187e-01f, -4.14050259e-02f, -2.09110621e-02f,
  6.50895527e-03f, -1.03459664e-01f, -1.38576806e-01f, -1.34344950e-01f, -2.07442373e-01f, -2.10510895e-01f, -6.46968037e-02f, -1.71135977e-01f, -9.50997695e-02f, -6.82399794e-02f,
  2.82632448e-02f, 8.14990923e-02f, -5.42620616e-03f, 1.31801590e-02f, 2.10022423e-02f, 4.65360191e-03f, -3.09108905e-02f, 2.89232004e-02f, 5.51433451e-02f, 7.52001554e-02f,
  -3.67751047e-02f, 1.47737470e-02f, 3.86046395e-02f, 7.51312226e-02f, 8.14182833e-02f, -5.46112098e-02f, 9.78675559e-02f, 9.90699530e-02f, -1.54375574e-02f, 8.80569741e-02f,
  6.54180571e-02f, 7.29409754e-02f, 7.53485486e-02f, 7.63964504e-02f, 2.60608308e-02f, 4.05262075e-02f, 8.02062154e-02f, 7.42383301e-02f, 4.91380617e-02f, -2.60113762e-03f,
  1.78262725e-01f, -7.49088824e-02f, 1.56490272e-03f, -1.20778188e-01f, -1.24506213e-01f, -1.21920444e-02f, 3.67053486e-02f, -3.87542136e-02f, -9.38820541e-02f, -1.24985583e-01f,
  -5.59378453e-02f, -1.10758901e-01f, -4.03209850e-02f, -8.32482427e-02f, -7.50810951e-02f, -1.34458737e-02f, -1.00003451e-01f, 7.48157874e-03f, -2.02260278e-02f, -4.60478701e-02f,
  -2.92035341e-02f, 8.43386203e-02f, 4.10771556e-02f, -5.89149483e-02f, -1.88754443e-02f, -2.22161580e-02f, -5.91309071e-02f, 6.03289008e-02f, -6.77211955e-02f, 1.44706666e-01f,
  1.90979809e-01f, 1.11055940e-01f, 3.58888432e-02f, 1.54547960e-01f, -5.76783083e-02f, -1.31114334e-01f, -4.49905731e-02f, -1.66055158e-01f, -6.84547052e-02f, 6.90446198e-02f,
  1.31520629e-01f, -6.03833050e-02f, -3.77282314e-02f, -6.78718612e-02f, -1.52869612e-01f, -4.13719490e-02f, -4.79120873e-02f, -1.91389248e-01f, -2.32185870e-01f, -1.68728560e-01f,
  -9.25287604e-02f, 3.07653155e-02f, -4.23333235e-03f, -1.08171597e-01f, 1.84876338e-01f, -3.18285972e-02f, 1.38702050e-01f, 2.02468619e-01f, -1.41858950e-03f, 1.07841522e-01f,
  1.55584589e-01f, 1.45604581e-01f, -1.13761872e-01f, -1.14513680e-01f, 1.59761291e-02f, -2.49156393e-02f, -6.64380342e-02f, 5.96954785e-02f, -6.35799095e-02f, 7.39784837e-02f,
  -1.49843153e-02f, 2.98547614e-02f, -3.06628905e-02f, 6.11941256e-02f, -4.17982489e-02f, 5.85311465e-02f, 1.86462626e-02f, -1.11685172e-01f, -2.98733599e-02f, 1.14647262e-01f,
  3.07147074e-02f, 1.35133341e-01f, 1.20072603e-01f, -3.07750069e-02f, 2.78565945e-04f, -1.54817522e-01f, 1.40813366e-01f, 4.17424589e-02f, -1.61726490e-01f, 1.35394156e-01f,
  3.76025103e-02f, 5.55427326e-03f, -1.80432666e-02f, 7.74510801e-02f, -7.48755038e-02f, -5.41937165e-03f, -1.75648946e-02f, -5.57909603e-04f, -7.23609775e-02f, -5.11657633e-02f,
  4.94493218e-03f, -2.36473139e-02f, 3.64944749e-02f, -5.38490228e-02f, -8.16928409e-03f, 8.64996910e-02f, -9.49791446e-02f, 8.54757130e-02f, -3.31610329e-02f, 2.99052019e-02f,
  -9.87175182e-02f, -3.56683764e-03f, 3.09437849e-02f, -1.00686312e-01f, -4.51221243e-02f, -4.00376841e-02f, -3.27712111e-02f, -7.26809204e-02f, -1.99004617e-02f, -9.36859474e-03f,
  8.57430771e-02f, -2.30578646e-01f, -5.59366532e-02f, -9.52916443e-02f, -1.57107115e-02f, -2.03463603e-02f, 1.69825815e-02f, -2.74748579e-02f, 1.59699731e-02f, 2.45858654e-02f,
  4.60431166e-03f, -4.12158221e-02f, 3.72358784e-02f, -1.07613161e-01f, -5.26990071e-02f, -2.51929499e-02f, 5.73353581e-02f, -1.19171351e-01f, -6.37373179e-02f, 3.09063308e-02f,
  -8.68441015e-02f, -7.46654943e-02f, -1.77087128e-01f, -1.35233581e-01f, -8.80779848e-02f, -2.42072716e-01f, -1.09170243e-01f, -2.04936918e-02f, -1.64783716e-01f, -1.17628545e-01f,
  3.57110083e-01f, -3.38252246e-01f, -1.10148564e-01f, 1.98264435e-01f, -1.01786129e-01f, -2.66309455e-02f, -2.28935242e-01f, 1.28363594e-02f, 2.32210144e-01f, -9.65191945e-02f,
  -8.08526948e-02f, 1.29004017e-01f, 3.51499133e-02f, 1.65674210e-01f, 1.58495843e-01f, -2.45170534e-01f, -2.00334907e-01f, 1.07083142e-01f, 3.36347759e-01f, 1.53307319e-01f,
  2.82173362e-02f, 1.75210740e-02f, 2.19619602e-01f, 1.53077077e-02f, -3.29649113e-02f, -5.03138527e-02f, -9.45213512e-02f, -1.41805872e-01f, -2.13589787e-01f, -2.83544451e-01f,
  -1.81676120e-01f, 4.28122506e-02f, 1.71376169e-01f, 8.77209976e-02f, -4.07629460e-02f, 1.06116936e-01f, -4.55564857e-02f, 4.71981205e-02f, 5.09533547e-02f, -4.76325192e-02f,
  5.25420830e-02f, 1.46487400e-01f, 9.67747718e-02f, 1.02909673e-02f, 1.60367489e-01f, 1.35981157e-01f, 1.12870097e-01f, 1.22041568e-01f, 1.22506775e-01f, -1.04532521e-02f,
  -9.97518003e-02f, 5.56505211e-02f, -7.77790546e-02f, -2.83702947e-02f, 1.06044658e-01f, 1.67104714e-02f, -1.17099732e-01f, -2.71994546e-02f, -1.83603764e-02f, 2.81859003e-02f,
  5.87855279e-02f, 1.92092285e-02f, -5.18119670e-02f, -5.50418831e-02f, 5.07568419e-02f, 3.07568219e-02f, -8.72317106e-02f, -6.06053276e-03f, 2.63759736e-02f, 3.60534079e-02f,
  -6.10514916e-03f, -2.80757397e-02f, -3.18434648e-02f, -7.22666010e-02f, -1.28907412e-02f, -7.21983425e-03f, 3.97618711e-02f, -2.45625097e-02f, -5.79399541e-02f, -2.06389017e-02f,
  -1.47396661e-02f, -3.00232265e-02f, -3.16602737e-02f, -7.96799436e-02f, -6.18835688e-02f, -1.11164398e-01f, -9.64658856e-02f, 2.94822194e-02f, -6.26162440e-02f, -3.41401473e-02f,
  5.62911145e-02f, 5.03425160e-03f, -2.96937441e-03f, 6.07538223e-02f, 1.24987271e-02f, -8.98670629e-02f, 7.43795792e-03f, 3.79618928e-02f, -7.74901882e-02f, 3.80901881e-02f,
  -6.50695665e-03f, -4.14310256e-03f, -1.43546378e-02f, -1.74583532e-02f, 9.69183221e-02f, -4.64522876e-02f, -3.40537876e-02f, 9.91945788e-02f, -7.48876075e-04f, 9.61295292e-02f,
  -8.39973148e-03f, 4.06125598e-02f, 8.03221911e-02f, -8.07887465e-02f, 7.91303962e-02f, -4.48649302e-02f, -1.44456908e-01f, -6.75952286e-02f, -5.61727397e-02f, -1.24603696e-01f,
  -6.95547760e-02f, 4.02625680e-01f, 1.34616137e-01f, 2.34823719e-01f, 1.08121939e-01f, 9.10064671e-03f, 1.27505049e-01f, -2.90277638e-02f, 6.38677478e-02f, 3.38560313e-01f,
  2.72735089e-01f, 1.35185942e-01f, 8.34185854e-02f, 1.61233395e-02f, 2.09417399e-02f, 2.44444042e-01f, 2.73915499e-01f, -8.31118003e-02f, -2.75619864e-01f, 1.35727655e-02f,
  2.28863075e-01f, 1.82408586e-01f, -1.15789644e-01f, -3.10294498e-02f, 2.90258616e-01f, 1.27985746e-01f, 2.95369953e-01f, 1.17364518e-01f, 1.13307253e-01f, 4.08928096e-01f,
  1.31144762e-01f, -4.17173058e-02f, -7.82492086e-02f, 7.11213201e-02f, 1.13122553e-01f, -2.55626440e-02f, 6.41210824e-02f, -3.69605310e-02f, 1.99038498e-02f, 5.34265079e-02f,
  8.16882551e-02f, 4.28862199e-02f, -1.88877585e-03f, 1.65241659e-02f, 9.44529846e-03f, -2.40936764e-02f, 2.24406887e-02f, 5.13055585e-02f, -5.86859435e-02f, 2.85539720e-02f,
  1.56099305e-01f, 5.28792366e-02f, 7.42343813e-02f, 5.51472791e-02f, 8.55838880e-02f, 8.79009813e-02f, 2.34535635e-02f, -1.01756781e-01f, -9.66278240e-02f, 2.67923057e-01f,
  -3.96080315e-02f, -1.84135735e-02f, 1.12383561e-02f, -4.26974855e-02f, 2.78643612e-03f, 3.11949272e-02f, -2.93383084e-04f, 7.32734352e-02f, -1.72935165e-02f, -5.39870188e-02f,
  -6.19128682e-02f, -6.38215765e-02f, -3.46901342e-02f, -1.03248865e-03f, -6.34002984e-02f, -3.16140167e-02f, -5.05064167e-02f, -1.03368133e-01f, -7.21684843e-02f, -7.36877769e-02f,
  -9.51515734e-02f, -4.69584167e-02f, -7.27198198e-02f, -6.62940443e-02f, -2.99516730e-02f, -1.05967291e-01f, -1.03098936e-01f, -1.35089234e-01f, -5.68684600e-02f, -4.40055579e-02f,
  2.79011637e-01f, -1.14389114e-01f, 1.32352799e-01f, -1.23497692e-03f, 1.37862816e-01f, -6.29319053e-04f, 8.48334581e-02f, -3.51689607e-02f, 7.46296719e-02f, 9.86644104e-02f,
  9.06785429e-02f, 1.39049515e-01f, 1.58091620e-01f, 5.38688116e-02f, 7.30173960e-02f, 1.27077520e-01f, 1.92339510e-01f, 9.26306695e-02f, -1.88627536e-03f, 1.26515821e-01f,
  1.38488472e-01f, 1.80554628e-01f, 1.59275442e-01f, 1.44976780e-01f, 7.89833888e-02f, 7.68455341e-02f, 2.49560818e-01f, 1.47024155e-01f, 6.24945648e-02f, 2.06339329e-01f,
  -3.72808665e-01f, 6.09510690e-02f, -1.72444910e-01f, -1.44723743e-01f, -1.09969869e-01f, -1.74194396e-01f, -6.23716787e-02f, -7.35595673e-02f, -1.81491040e-02f, 2.10917089e-02f,
  8.64245147e-02f, 3.76300439e-02f, 1.37042731e-01f, 6.90512285e-02f, 5.92519939e-02f, -1.63338318e-01f, -1.69355497e-01f, -7.63762668e-02f, -1.09413452e-01f, 2.34118477e-02f,
  4.08990085e-02f, -1.37571516e-02f, -2.49043689e-03f, -6.80093840e-02f, -2.46526767e-02f, 9.39666778e-02f, -8.87086913e-02f, -1.47034004e-01f, -1.15802720e-01f, -2.11671114e-01f,
  9.61753353e-02f, -5.09281158e-02f, 1.30236279e-02f, 2.08352897e-02f, -4.53861281e-02f, 4.33012135e-02f, -6.05854765e-02f, 8.55455846e-02f, 6.47442043e-02f, -1.99823678e-02f,
  3.52918096e-02f, 7.65319094e-02f, 3.49952281e-02f, 9.61078331e-02f, 1.72242709e-02f, -5.06933918e-03f, 4.17612307e-03f, 3.50593142e-02f, 4.12293635e-02f, 3.82908806e-02f,
  -8.68551806e-02f, 2.64060684e-03f, -6.29473478e-02f, 7.69983679e-02f, 2.18633879e-02f, -8.70309621e-02f, 1.56736169e-02f, 4.30224463e-02f, -1.59758888e-02f, -2.76760515e-02f,
  -6.90514296e-02f, 3.58486399e-02f, 4.50339215e-03f, 3.75728905e-02f, -1.56155312e-02f, 8.14490244e-02f, 1.21619701e-02f, 3.45838405e-02f, -4.18913104e-02f, 3.20529044e-02f,
  4.11718003e-02f, -5.65583296e-02f, 1.40417945e-02f, -4.72514406e-02f, 8.40029046e-02f, -1.22485161e-02f, -1.18144252e-03f, 9.65779945e-02f, 7.39873797e-02f, -2.36989707e-02f,
  1.01218149e-02f, -2.66922675e-02f, 3.87842283e-02f, -1.11789778e-02f, 5.64831272e-02f, 4.03191112e-02f, 6.04827181e-02f, 3.85249406e-02f, -2.34281365e-02f, -1.13740601e-02f,
  1.14643648e-01f, 6.81058364e-03f, 4.71431836e-02f, -3.81126665e-02f, -4.39843126e-02f, -1.62076708e-02f, -4.29666229e-02f, 2.15802379e-02f, -2.27825604e-02f, 6.19369857e-02f,
  8.93102884e-02f, -1.25732634e-03f, -4.22560647e-02f, 4.96764630e-02f, -6.35732263e-02f, -1.56837627e-02f, -4.53291424e-02f, 3.49814561e-03f, -1.97404642e-02f, 1.83143690e-02f,
  -2.50622891e-02f, -1.10397108e-01f, -7.85780475e-02f, 2.76999585e-02f, -9.59128961e-02f, -7.10625425e-02f, 6.98865438e-03f, 5.81936575e-02f, -3.33167240e-03f, 5.26313335e-02f,
  4.23274487e-01f, 1.07694417e-01f, 2.29229167e-01f, 3.03662479e-01f, 6.95429882e-03f, -3.22863013e-02f, -2.29118526e-01f, -9.30202901e-02f, 1.59032524e-01f, 1.27621830e-01f,
  1.40387565e-01f, 1.28772780e-01f, 1.88353896e-01f, 1.44855201e-01f, -3.82452011e-02f, 5.21067642e-02f, -8.10292258e-04f, 1.45583093e-01f, 9.22907703e-03f, -1.20463550e-01f,
  -2.04607602e-02f, -7.28690391e-03f, 2.63837576e-01f, 1.88957229e-01f, 1.74402922e-01f, 1.46754086e-01f, 1.43321216e-01f, 1.74813867e-01f, 1.11014701e-01f, 2.78040171e-01f,
  2.39252478e-01f, 3.58652204e-01f, 5.64393736e-02f, 1.61790818e-01f, 1.60116374e-01f, 1.34615004e-01f, 7.76862875e-02f, 1.68491825e-01f, 1.12676620e-01f, 1.19433686e-01f,
  2.50305712e-01f, 8.84885266e-02f, 1.76799342e-01f, 1.62429392e-01f, 1.84510902e-01f, 1.33547768e-01f, 1.37592882e-01f, 3.04759562e-01f, 1.92494437e-01f, 1.30204514e-01f,
  1.02841146e-01f, 2.33996212e-01f, 1.26861170e-01f, 1.64335053e-02f, 1.35461718e-01f, 1.28910452e-01f, 2.38873199e-01f, 2.22765610e-01f, 2.10028753e-01f, 1.63692743e-01f,
  -1.98294222e-01f, -3.81119177e-02f, -3.95225883e-02f, -7.85166025e-02f, -4.97976355e-02f, -9.82566774e-02f, -1.54528208e-02f, -7.44463578e-02f, -1.41723469e-01f, -6.24825135e-02f,
  -8.81584287e-02f, -5.67019843e-02f, -1.10029958e-01f, -5.70294634e-02f, -9.52008516e-02f, -8.39432478e-02f, -3.15974988e-02f, -9.22414213e-02f, -3.38789187e-02f, -7.19719604e-02f,
  -6.91986531e-02f, -1.56463962e-02f, -3.08329687e-02f, -8.42063054e-02f, 4.39246744e-02f, -3.63926566e-03f, -1.02345794e-01f, -3.65731679e-02f, -1.08403511e-01f, -5.59537336e-02f,
  -5.16071357e-02f, 1.12104081e-01f, 7.78483003e-02f, 1.41448557e-01f, 1.78833604e-01f, 1.91379011e-01f, 1.39115050e-01f, 1.32704496e-01f, 2.39627421e-01f, 1.16516098e-01f,
  1.14340886e-01f, 2.44376600e-01f, 1.78860411e-01f, 6.15464561e-02f, 1.07309788e-01f, 1.11987449e-01f, 1.11779742e-01f, 1.70635238e-01f, 1.78872705e-01f, 1.32955670e-01f,
  5.53905368e-02f, 2.72903405e-02f, 1.26008494e-02f, 9.45399478e-02f, 1.84608787e-01f, 7.16283917e-02f, 9.20409635e-02f, 3.36629413e-02f, 4.22284827e-02f, -4.94040102e-02f,
  2.74506062e-01f, -7.31034204e-02f, -1.52215794e-01f, 1.85871832e-02f, -4.91123367e-03f, -2.68144041e-01f, -1.86391428e-01f, -1.29109159e-01f, -7.22987577e-02f, -1.34813428e-01f,
  2.55236719e-02f, -1.01149015e-01f, -2.03898966e-01f, -2.19695106e-01f, -2.87175745e-01f, -2.10615054e-01f, -3.50007176e-01f, -2.94951916e-01f, -3.22807550e-01f, -2.64085174e-01f,
  -1.13600127e-01f, -1.12384707e-01f, 9.98068675e-02f, -7.98997954e-02f, -4.80103642e-02f, -2.41206408e-01f, -6.52105510e-02f, 8.19262862e-03f, -1.04108848e-01f, -1.65270135e-01f,
  -1.33892730e-01f, 1.22433014e-01f, -2.19228521e-01f, -2.03567110e-02f, 2.56163534e-02f, -3.48732136e-02f, -1.20897427e-01f, -9.14386958e-02f, -6.18105056e-03f, -5.38138039e-02f,
  7.41898045e-02f, -3.80469970e-02f, -7.56866932e-02f, -7.41705224e-02f, -2.81606242e-02f, -8.46230984e-03f, -5.55565171e-02f, -1.22722469e-01f, -1.49936423e-01f, -4.69267145e-02f,
  -7.09268749e-02f, 4.43667248e-02f, 4.67601046e-02f, -2.07446888e-01f, -6.71897307e-02f, -3.60540561e-02f, -8.90767425e-02f, -5.73891625e-02f, -6.55888990e-02f, -9.17435661e-02f,
  4.17146832e-02f, 8.06749165e-02f, 9.03517306e-02f, -3.24128419e-02f, 7.33213723e-02f, 1.57884508e-02f, -2.80029904e-02f, 7.57297501e-02f, -4.09200527e-02f, 7.58749619e-02f,
  2.45307721e-02f, 8.01436827e-02f, -3.72696221e-02f, 6.83722347e-02f, -3.15010771e-02f, 1.44526035e-01f, 2.31445599e-02f, 4.77285273e-02f, 1.06829204e-01f, 7.08191469e-02f,
  7.14425743e-02f, -1.67207643e-02f, 2.32081916e-02f, 3.28638889e-02f, 1.70899481e-02f, 9.22732875e-02f, 4.07858789e-02f, 1.35387838e-01f, 6.67369515e-02f, 1.22593723e-01f,
  -1.89511720e-02f, -2.48512812e-02f, -1.36257231e-01f, -1.19056880e-01f, -3.57547924e-02f, -7.55790398e-02f, -6.41988311e-03f, -4.96254228e-02f, -8.32611769e-02f, -4.49188650e-02f,
  -1.04001187e-01f, -7.67543986e-02f, -4.48698513e-02f, -8.71085078e-02f, -9.44661796e-02f, -1.40553415e-01f, 3.46529298e-02f, -1.47456199e-01f, -9.76123512e-02f, -1.19012669e-01f,
  -1.03983209e-01f, -7.21251667e-02f, -9.11847204e-02f, -1.47520915e-01f, -1.01803184e-01f, -1.74759492e-01f, -2.46092930e-01f, -1.11248955e-01f, -1.99342042e-01f, -2.60123849e-01f,
  -9.40942168e-02f, 2.88316667e-01f, 8.39867517e-02f, 1.10953404e-02f, -1.94484293e-02f, 1.07650943e-01f, 1.05639301e-01f, 5.32561280e-02f, 7.66674476e-03f, 6.50772676e-02f,
  -6.65060207e-02f, -2.06896156e-01f, -2.08421752e-01f, -1.83779344e-01f, -5.17014489e-02f, 2.01233029e-01f, 1.50701657e-01f, -8.92149657e-02f, -2.24849716e-01f, -9.42845717e-02f,
  7.91801438e-02f, -2.88364217e-02f, -1.10705189e-01f, 4.19939347e-02f, 1.91738933e-01f, -1.10925160e-01f, 1.36896372e-01f, 4.70753349e-02f, 1.76087677e-01f, 3.57576698e-01f,
  -1.02277055e-01f, 1.04521267e-01f, -1.38187453e-01f, 5.58143901e-03f, -1.16695380e-02f, 2.66686808e-02f, -5.54355383e-02f, -4.23858836e-02f, -6.65671974e-02f, 4.39431779e-02f,
  3.60441506e-02f, 1.22945551e-02f, -3.75991128e-02f, -3.72894518e-02f, 7.68465847e-02f, 8.00690204e-02f, 4.31895554e-02f, -2.06549559e-02f, -3.39204865e-03f, 4.62693237e-02f,
  2.49525979e-02f, 6.23978674e-02f, 6.38075098e-02f, 2.14206986e-02f, -3.52640785e-02f, -3.60785164e-02f, -9.40025505e-03f, 9.56267416e-02f, 2.63677742e-02f, 5.28351851e-02f,
  4.50473540e-02f, 1.29980547e-02f, 2.33129356e-02f, 7.75080994e-02f, 2.69598439e-02f, 2.00759992e-02f, -4.59941383e-03f, -1.78563837e-02f, -6.29528686e-02f, -2.02653259e-02f,
  -1.03985528e-02f, 3.60526815e-02f, 3.16485600e-03f, 4.65405285e-02f, -3.51136513e-02f, 5.73331155e-02f, -4.49162014e-02f, 2.15813201e-02f, 3.91074792e-02f, -1.28347864e-02f,
  -7.48376474e-02f, -1.23397773e-02f, 7.22817034e-02f, -6.85131848e-02f, 5.87845221e-02f, -3.34776379e-02f, -5.86467097e-03f, 6.44067898e-02f, -1.42267784e-02f, 3.86200510e-02f,
  -2.59448618e-01f, 3.69672128e-03f, -1.78676583e-02f, -8.73448923e-02f, -3.72040160e-02f, -2.35498697e-02f, -7.66080916e-02f, 4.89789471e-02f, 2.14205985e-03f, -7.47240111e-02f,
  -6.87145144e-02f, -6.92076087e-02f, 2.94280681e-03f, 7.58730900e-03f, -5.69425113e-02f, -2.37428918e-02f, 7.78952688e-02f, -5.40389819e-03f, -5.87189347e-02f, 4.41016592e-02f,
  1.66209601e-02f, -2.20116060e-02f, -2.13940963e-01f, -1.06951315e-02f, -5.71020134e-02f, -1.45364627e-01f, -7.96091631e-02f, -5.40730022e-02f, -1.81111664e-01f, -9.95844323e-03f,
  -5.35759687e-01f, -5.20157635e-01f, -3.06043681e-02f, -2.22107038e-01f, 1.46056097e-02f, -2.14712292e-01f, -4.63328600e-01f, -1.87001601e-01f, -1.14315934e-01f, -1.88409880e-01f,
  -1.36888444e-01f, 3.09496541e-02f, -6.25207648e-03f, -9.64052752e-02f, -3.00478995e-01f, -1.94410682e-01f, -2.24802285e-01f, -8.07950795e-02f, 2.16015503e-02f, -1.61338210e-01f,
  -2.69729793e-01f, -2.55528063e-01f, -2.47293949e-01f, -1.79596394e-01f, -8.17413330e-02f, -1.43705104e-02f, -6.98865578e-02f, -1.53791860e-01f, -7.39813671e-02f, -1.65886104e-01f,
  3.83393988e-02f, -2.96034485e-01f, 2.15878394e-02f, -1.28231093e-01f, -1.44324660e-01f, -9.96933505e-02f, -1.17826998e-01f, -1.04664400e-01f, -8.00442323e-02f, -1.15849078e-01f,
  -1.34189114e-01f, -1.73696652e-01f, -1.94091097e-01f, -9.22875181e-02f, -2.47390673e-01f, -1.80350050e-01f, -9.16608796e-02f, -2.15992779e-01f, -1.19857639e-01f, -1.49600640e-01f,
  -1.67557895e-01f, -1.95497915e-01f, -1.34661078e-01f, -7.37965256e-02f, -8.43968540e-02f, -6.97131529e-02f, -1.17958337e-01f, -8.66775140e-02f, -7.32677504e-02f, -1.98262155e-01f,
  3.47645916e-02f, 1.32619575e-01f, 1.47686481e-01f, 9.24038664e-02f, 2.25938767e-01f, 2.04599932e-01f, 1.12966076e-01f, 8.68034288e-02f, 1.94752738e-01f, 1.41812697e-01f,
  1.73589572e-01f, 1.58116460e-01f, 9.00522470e-02f, 1.45682275e-01f, 1.82467565e-01f, 3.02324481e-02f, 8.41672719e-02f, 6.34394139e-02f, 1.99805424e-01f, 6.69955090e-02f,
  1.14757396e-01f, 1.64920121e-01f, 1.32559180e-01f, 1.38518214e-01f, 1.03828676e-01f, 1.48093686e-01f, 1.14066429e-01f, 1.34587720e-01f, 1.70177490e-01f, 1.49764299e-01f,
  -9.35220066e-03f, -2.25031316e-01f, -1.03884317e-01f, -1.68891564e-01f, -7.00469986e-02f, -3.07871848e-02f, -6.63878396e-02f, -7.27515072e-02f, -1.58261076e-01f, -1.25180304e-01f,
  -1.94917247e-01f, -1.06321350e-01f, -2.00518355e-01f, -8.58530104e-02f, -5.75639084e-02f, -1.37497773e-02f, -1.73182204e-01f, -6.89568967e-02f, -1.86361134e-01f, -1.61948398e-01f,
  -1.59197420e-01f, -1.45835489e-01f, -1.88746542e-01f, -3.64741981e-02f, -1.41989514e-01f, -5.97647317e-02f, -6.89186528e-02f, -8.54158476e-02f, -1.44695267e-01f, -3.50304842e-02f,
  -3.31872612e-01f, 8.18217099e-02f, 3.29707712e-01f, -1.04146898e-02f, -8.95338655e-02f, -5.67908287e-02f, 1.29377753e-01f, -1.12977594e-01f, -6.53366968e-02f, 4.92131040e-02f,
  -3.49435881e-02f, -2.03198995e-02f, 1.83216445e-02f, 7.11268857e-02f, -6.83896570e-03f, 1.63950026e-01f, 2.89602041e-01f, 1.96560994e-01f, 6.00787252e-03f, -4.58294898e-02f,
  -6.61503598e-02f, -4.09997180e-02f, -1.16780430e-01f, 4.02756855e-02f, -4.04780582e-02f, -2.51372848e-02f, 1.50342777e-01f, -3.89011353e-02f, 6.52885064e-02f, 9.16854665e-02f,
  2.74728328e-01f, -1.82443693e-01f, 1.59691498e-01f, -6.87886029e-02f, 1.00677095e-01f, 9.12726820e-02f, 5.46665937e-02f, -1.16477059e-02f, 1.13363201e-02f, 1.45797476e-01f,
  6.92999214e-02f, 4.06486855e-04f, -5.45280091e-02f, -2.53414121e-02f, 2.47102492e-02f, 9.74415988e-03f, 9.03042126e-03f, 1.89328030e-01f, 5.93707338e-02f, 4.77030408e-03f,
  2.59972662e-02f, -3.83488238e-02f, 1.20308854e-01f, 8.46026391e-02f, 4.41526137e-02f, 1.03965603e-01f, 7.25927502e-02f, 1.01968303e-01f, 2.47288104e-02f, 2.33420823e-03f,
  1.42143918e-02f, -1.75407045e-02f, -1.41566932e-01f, -5.49199022e-02f, -7.32862502e-02f, -6.83081821e-02f, -3.36578600e-02f, -8.05282965e-03f, -1.79354638e-01f, -4.73820902e-02f,
  -1.51111215e-01f, -8.91098846e-03f, 5.33540081e-03f, -5.97596355e-02f, -3.77501398e-02f, 1.36572355e-02f, -1.13941759e-01f, -4.93235560e-03f, -2.24816669e-02f, -2.51501910e-02f,
  -7.59583712e-02f, 1.81762688e-02f, -1.12039506e-01f, -8.18439722e-02f, -2.60169152e-02f, -6.39574602e-02f, -2.63014846e-02f, -7.80163780e-02f, -1.13791205e-01f, -1.59585312e-01f,
  5.35847992e-02f, 2.40880340e-01f, 1.56445056e-01f, 7.32393861e-02f, 6.51601627e-02f, 3.31799798e-02f, 1.57581523e-01f, 3.03848628e-02f, 1.11265093e-01f, 4.28028256e-02f,
  3.78103033e-02f, 1.01221055e-01f, 1.24610126e-01f, 1.20292731e-01f, 8.60323459e-02f, 6.49145097e-02f, 1.23184554e-01f, 1.71974316e-01f, 1.09423302e-01f, 5.98373301e-02f,
  1.12675510e-01f, 9.56010297e-02f, 2.32044414e-01f, 1.14239261e-01f, 2.74683777e-02f, 1.20191485e-01f, 1.24486044e-01f, 1.20374806e-01f, 1.13486774e-01f, 1.17193043e-01f,
  5.17194043e-04f, -3.01584415e-02f, 8.94954726e-02f, 1.76159665e-01f, 1.82850987e-01f, 1.85692400e-01f, 2.64529616e-01f, 8.79070610e-02f, 1.48243025e-01f, 9.92455333e-02f,
  1.69443339e-02f, 7.48879388e-02f, 1.57387063e-01f, 1.20132521e-01f, 2.20128998e-01f, 2.27584720e-01f, 1.16809390e-01f, 1.78292215e-01f, 1.81653649e-01f, 8.31335261e-02f,
  1.01627998e-01f, 4.77609709e-02f, 2.72580255e-02f, 6.73388243e-02f, 8.77696797e-02f, 1.41702369e-01f, 1.41464159e-01f, 6.12622611e-02f, 1.83977425e-01f, 9.01977792e-02f,
  -2.47744247e-02f, 1.65599063e-02f, 4.69494686e-02f, 2.44619921e-02f, 1.41334131e-01f, 2.03290656e-02f, 1.38653368e-01f, 1.23889878e-01f, -1.89492516e-02f, 1.09298537e-02f,
  -7.38508580e-03f, 6.31380156e-02f, 9.84694660e-02f, 5.09543866e-02f, 1.54952288e-01f, 1.93910245e-02f, 1.20427236e-01f, 5.31522296e-02f, 1.17728658e-01f, 3.78895551e-02f,
  1.16138406e-01f, 8.27913880e-02f, 1.46221519e-01f, 1.21248722e-01f, 6.01721965e-02f, 1.74127117e-01f, 1.37315214e-01f, 1.60791546e-01f, 1.14553064e-01f, 1.33753672e-01f,
  2.25680619e-02f, -7.86267743e-02f, -1.24731278e-02f, -1.09588886e-02f, 7.43676722e-02f, -3.02642137e-02f, -6.04523718e-03f, 6.24655932e-02f, -5.37089519e-02f, 1.10058058e-02f,
  3.71639021e-02f, -9.62282047e-02f, -1.36577478e-02f, -5.32678366e-02f, -1.59446951e-02f, 6.17198367e-03f, 3.88402194e-02f, -9.18733776e-02f, -5.39822243e-02f, -3.76354903e-02f,
  2.32031904e-02f, -3.94797772e-02f, 8.32641125e-03f, 4.52647172e-03f, -1.32002488e-01f, -4.66057844e-02f, 3.18835005e-02f, -8.05130824e-02f, 4.27053347e-02f, -3.38777266e-02f,
  2.26436600e-01f, -1.66203715e-02f, 1.26980558e-01f, 2.26895630e-01f, 8.94537345e-02f, 1.22036301e-01f, 1.12096772e-01f, 1.28085781e-02f, -5.89054637e-03f, 9.08665285e-02f,
  3.26826908e-02f, 1.04870960e-01f, 1.26251832e-01f, 8.16159695e-02f, 7.00153261e-02f, 6.28212020e-02f, 1.31320968e-01f, 1.33147106e-01f, 1.85595095e-01f, 4.19674404e-02f,
  1.08921431e-01f, 2.19144821e-01f, 2.55318671e-01f, 1.75119221e-01f, 2.17171311e-01f, 9.63553786e-02f, 1.59170553e-01f, 1.01134986e-01f, 2.38558352e-01f, 2.41392076e-01f,
  2.24261895e-01f, 1.12992907e-02f, -1.47909984e-01f, -3.22063337e-03f, -1.73510671e-01f, -1.46024199e-02f, -6.30554557e-03f, 1.14294112e-01f, -9.04722735e-02f, -1.28343115e-02f,
  -1.81870639e-01f, -1.29724100e-01f, -1.67438090e-02f, -8.06314275e-02f, 1.52522594e-01f, 3.44186537e-02f, 1.44991204e-02f, 9.85643640e-03f, 7.59106800e-02f, -1.04744740e-01f,
  -1.16324656e-01f, -3.31894262e-03f, 8.67055431e-02f, -3.76061499e-02f, -1.82049438e-01f, -1.94531903e-01f, -7.92645440e-02f, -1.63117096e-01f, -2.05561295e-01f, -6.84882700e-02f,
  -1.15670666e-01f, -1.58732124e-02f, -1.89965785e-01f, -1.89200073e-01f, -2.01453194e-01f, -4.23862338e-02f, -3.44234928e-02f, -1.41849682e-01f, -1.56906992e-01f, -4.75904755e-02f,
  -1.36015549e-01f, -2.77697444e-02f, -2.16899924e-02f, -5.88018298e-02f, -1.38424620e-01f, -1.40954450e-01f, -1.02298342e-01f, -1.00996435e-01f, -4.73797210e-02f, -1.47914514e-01f,
  -2.52569735e-01f, -1.25072569e-01f, -4.48631793e-02f, -1.68825984e-01f, -1.14900164e-01f, -1.54755786e-01f, -2.28642315e-01f, -2.23609403e-01f, -1.88090935e-01f, -2.06283983e-02f,
  -8.55788682e-03f, 3.90733816e-02f, 8.34723935e-02f, 1.00293294e-01f, 5.48618548e-02f, 1.04183391e-01f, 1.41463757e-01f, 1.62666917e-01f, 7.17706904e-02f, 1.15940407e-01f,
  1.42908603e-01f, 1.54121667e-01f, 1.00464076e-01f, 2.06612885e-01f, 1.42232299e-01f, 4.98475581e-02f, 1.37472704e-01f, 1.08856916e-01f, 1.21359408e-01f, 1.29277423e-01f,
  9.91332605e-02f, 1.15474768e-01f, 4.19030115e-02f, 5.97515628e-02f, 7.57398009e-02f, 1.26671314e-01f, 3.98937650e-02f, 5.27838878e-02f, 8.81889835e-02f, 8.77085999e-02f,
  1.83807388e-02f, -6.29004240e-02f, 6.61393479e-02f, -1.20334756e-02f, -1.54936671e-01f, -1.41209826e-01f, -1.23966128e-01f, -1.20637409e-01f, -1.66186303e-01f, -7.38601461e-02f,
  -1.05326168e-01f, -9.48796645e-02f, 2.51100343e-02f, -1.62551865e-01f, -3.38602327e-02f, -7.41282105e-02f, -2.98306905e-02f, -1.24983251e-01f, -7.91423321e-02f, -1.81088299e-01f,
  -1.30478963e-01f, -9.62087810e-02f, -5.06111458e-02f, -6.83764461e-03f, -7.57920891e-02f, 3.60025130e-02f, -5.00215730e-03f, -1.26349246e-02f, -6.34903759e-02f, 2.66759307e-03f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.87204027e-01f, -3.76713909e-02f, 2.86350399e-01f, 1.07435413e-01f, 3.10273468e-01f, 2.65334278e-01f, 3.12626541e-01f, 8.13618079e-02f, 8.95287246e-02f, -5.99261709e-02f,
  -4.82898094e-02f, -3.16172898e-01f, -3.27847511e-01f, -2.77588844e-01f, -1.14453256e-01f, 7.97339436e-03f, 7.38402382e-02f, -3.79959233e-02f, -1.03689497e-02f, -3.33213918e-02f,
  -2.05189228e-01f, 1.52624607e-01f, 1.05744630e-01f, 5.02604768e-02f, -6.45690262e-02f, -1.31756872e-01f, 3.82846147e-02f, 5.69631942e-02f, 1.42070707e-02f, -9.04382095e-02f,
  -2.71319270e-01f, 1.19585119e-01f, -2.31657639e-01f, -2.59769291e-01f, -5.88336773e-02f, -5.46388254e-02f, -1.48924505e-02f, 5.96780404e-02f, -1.90062379e-03f, -1.25153691e-01f,
  -7.64156133e-02f, 6.06396422e-02f, 4.32994254e-02f, 1.08390003e-01f, 1.02037199e-01f, 3.33041586e-02f, 1.13008730e-02f, 4.10500541e-02f, -4.24112789e-02f, -1.56537652e-01f,
  -6.72917366e-02f, 1.54229641e-01f, 9.37782675e-02f, 2.99520213e-02f, -3.09691299e-02f, -1.03509344e-01f, -7.30725080e-02f, 2.11083479e-02f, 6.56946152e-02f, 6.85996637e-02f,
  -1.23899043e-01f, 5.09892926e-02f, 1.10699885e-01f, 7.53801689e-02f, 1.31284058e-01f, 9.44011360e-02f, 1.25964165e-01f, 1.10170186e-01f, 1.33802205e-01f, 1.34946272e-01f,
  7.19161630e-02f, 1.90155223e-01f, 1.96571141e-01f, 1.19796567e-01f, 6.55664653e-02f, 5.36427721e-02f, 1.62921444e-01f, 5.65151386e-02f, 6.32768348e-02f, 8.84768590e-02f,
  5.32327369e-02f, 1.31838471e-01f, 1.03619754e-01f, 1.49581479e-02f, 1.89245567e-02f, 3.76818446e-03f, 1.58530399e-02f, 5.82880639e-02f, 1.14343017e-01f, 2.93203052e-02f,
  -1.23287976e-01f, -1.31719708e-01f, -1.66740254e-01f, -1.97278902e-01f, 1.38393402e-01f, -4.39237691e-02f, -4.63167839e-02f, -2.05728295e-03f, -9.40773711e-02f, 5.18103503e-02f,
  -7.26630837e-02f, -2.40324587e-02f, -2.18163189e-02f, 2.68638264e-02f, 1.56902373e-01f, 7.88306594e-02f, 2.85784621e-02f, 6.50567487e-02f, -9.00614336e-02f, -2.50923820e-02f,
  1.92556046e-02f, 2.72258054e-02f, 7.18717128e-02f, 3.14286537e-02f, 1.20149227e-02f, 4.74134460e-02f, 6.33830205e-02f, 1.25393756e-02f, 1.70777798e-01f, 1.34976715e-01f,
  -2.36821128e-03f, -5.12943044e-02f, 1.65048748e-01f, 8.85187685e-02f, -1.06104277e-01f, -1.01929873e-01f, -2.22964361e-01f, -1.54539675e-01f, -6.75593391e-02f, -5.09223230e-02f,
  1.69331148e-01f, 2.65586585e-01f, 2.29902357e-01f, 1.27801970e-01f, 1.32942110e-01f, 2.84674559e-02f, 5.16317524e-02f, 1.21647209e-01f, 1.22978993e-01f, 7.05621317e-02f,
  -6.16997816e-02f, -1.41723398e-02f, -6.78652823e-02f, 6.70843720e-02f, -5.31369746e-02f, 1.83755606e-01f, -1.48806451e-02f, -1.22683264e-01f, 2.39490718e-02f, -7.06042647e-02f,
  5.47744453e-01f, 5.52757829e-02f, 7.71436766e-02f, 3.32636051e-02f, -1.14839546e-01f, -1.08888401e-02f, 9.06500220e-02f, 2.11670697e-02f, -1.32957265e-01f, -1.20977536e-01f,
  5.63111752e-02f, -2.91089038e-03f, 1.01751704e-02f, -1.02001011e-01f, -1.41044736e-01f, -2.93879472e-02f, -4.60742489e-02f, -8.89572874e-02f, -4.11716849e-03f, -3.12809870e-02f,
  5.29682226e-02f, -1.12248629e-01f, -9.18115452e-02f, 2.90279910e-02f, 1.00180460e-02f, -5.54394498e-02f, 1.20102125e-03f, -1.44084143e-02f, 2.81564444e-02f, 6.77149370e-03f,
  1.56237036e-01f, 3.72506157e-02f, 5.32287844e-02f, 4.39056940e-02f, -1.12425312e-01f, -5.32150120e-02f, -1.96578186e-02f, -2.01026946e-02f, 2.39868835e-02f, -9.66380388e-02f,
  -8.07570219e-02f, 1.92803256e-02f, -1.19552379e-02f, 1.03628740e-01f, 1.82189018e-01f, -2.67674681e-02f, -6.67592287e-02f, 1.49065405e-01f, -3.00967488e-02f, -1.50320470e-01f,
  2.50771269e-02f, -1.08902164e-01f, 4.82121781e-02f, -4.93367612e-02f, -2.25900710e-02f, 3.10996287e-02f, 6.25078604e-02f, 2.91373767e-03f, -3.83856557e-02f, -3.62579897e-02f,
  2.45939329e-01f, 9.51625481e-02f, 1.18091367e-01f, -4.53533698e-03f, 5.98104438e-03f, -1.85835008e-02f, 1.75574541e-01f, 2.07383111e-01f, 1.23581067e-01f, 1.64918065e-01f,
  8.64323750e-02f, 1.74095541e-01f, -4.57996316e-02f, -1.50220677e-01f, -1.00750709e-02f, 6.78302124e-02f, 3.01035885e-02f, 5.35082519e-02f, 5.84401675e-02f, 6.89832568e-02f,
  -2.31789537e-02f, 3.18753570e-02f, 2.80755609e-01f, 9.63811800e-02f, 1.35689443e-02f, 2.01263547e-01f, 1.89559713e-01f, 2.75550392e-02f, 1.81033581e-01f, -5.95525131e-02f,
  -2.73253888e-01f, -3.43901843e-01f, -2.95883238e-01f, -3.94046396e-01f, -2.25950852e-01f, -6.84157535e-02f, -2.70281821e-01f, -3.85300778e-02f, 4.51787785e-02f, -4.40932244e-01f,
  -2.67571151e-01f, 1.15410380e-01f, -1.00689322e-01f, 1.03101015e-01f, 1.55342549e-01f, -3.45339715e-01f, -3.10971320e-01f, -3.13014984e-02f, 3.56672466e-01f, 2.35090792e-01f,
  -5.10213673e-02f, -7.15192556e-02f, 2.29804665e-01f, 1.16606630e-01f, -2.54147708e-01f, -1.49821758e-01f, -2.69535184e-01f, -1.98126972e-01f, -9.77834985e-02f, -5.38081884e-01f,
  -3.35582674e-01f, -1.90207005e-01f, 3.63536291e-02f, 8.21008384e-02f, -1.78919673e-01f, -4.25376743e-02f, -3.73201892e-02f, 1.01307437e-01f, 3.78313698e-02f, -9.33003873e-02f,
  -1.24075651e-01f, 7.98432603e-02f, -2.65314733e-03f, -1.34886399e-01f, -8.17506984e-02f, 1.00917779e-01f, 1.38835460e-01f, 7.72209913e-02f, 7.27331713e-02f, 2.97902860e-02f,
  -6.44681901e-02f, -1.88102990e-01f, -3.44092362e-02f, -2.41673682e-02f, 9.29697752e-02f, -4.99242023e-02f, 9.18293297e-02f, 1.13798790e-01f, 5.84833287e-02f, -3.40707779e-01f,
  4.88264225e-02f, 2.15585739e-03f, 7.36301169e-02f, 5.74058592e-02f, 1.66771263e-01f, 1.18273534e-02f, -9.95090678e-02f, -7.71867260e-02f, 1.25829995e-01f, 1.58041269e-01f,
  7.56377494e-03f, -2.28535347e-02f, -4.55860543e-04f, -8.63314271e-02f, 6.28180653e-02f, -1.56616175e-03f, -6.62977770e-02f, -1.09321445e-01f, -3.31580685e-03f, -3.91897047e-03f,
  1.10479794e-01f, -4.21388149e-02f, -5.17134704e-02f, 6.37518475e-04f, 9.83710438e-02f, -1.03384860e-01f, 7.05165789e-02f, 4.27102856e-02f, -4.13761474e-02f, 3.40809561e-02f,
  -2.52808094e-01f, 2.41570666e-01f, -2.94111669e-01f, -2.97815036e-02f, -8.59031640e-03f, 3.53200026e-02f, -1.72043353e-01f, 2.79911365e-02f, -1.25622585e-01f, -9.08264667e-02f,
  -3.55019059e-04f, -1.19843833e-01f, 4.39581275e-03f, 2.93816626e-02f, 4.35446538e-02f, 3.17397155e-02f, -6.55745491e-02f, -2.42525905e-01f, 1.27098992e-01f, 1.72532901e-01f,
  -2.40347330e-02f, -1.32413998e-01f, -1.25122711e-01f, -1.06398463e-01f, -5.98462373e-02f, -1.18849427e-01f, 7.07714036e-02f, -2.67377272e-02f, 1.56383403e-03f, -2.55397230e-01f,
  -3.34146172e-01f, -7.16134787e-01f, 4.69398230e-01f, -2.18749374e-01f, 3.26197743e-01f, 2.74973899e-01f, 1.66393369e-01f, -3.32144834e-02f, -2.83714775e-02f, -5.73179796e-02f,
  -4.14205700e-01f, -3.55535239e-01f, -3.52525860e-01f, -1.84859648e-01f, -1.74727321e-01f, 2.08059251e-01f, 3.48101288e-01f, 3.55907708e-01f, 2.52532601e-01f, 2.03195348e-01f,
  -6.26686364e-02f, -9.89350006e-02f, -1.13914557e-01f, -1.84099615e-01f, -1.93790078e-01f, -7.34906495e-02f, -5.87397106e-02f, -1.81545138e-01f, -7.49784783e-02f, -1.46702558e-01f,
  5.90341799e-02f, -2.47105420e-01f, 1.06615663e-01f, -1.89405099e-01f, -9.35284346e-02f, -1.13806948e-01f, -5.13898693e-02f, -1.04071625e-01f, -1.25495464e-01f, 2.50854529e-02f,
  -1.22988895e-01f, 1.83793604e-02f, -8.74301866e-02f, -4.10201028e-02f, -1.44598382e-02f, 3.96233164e-02f, -9.82174054e-02f, -2.31471866e-01f, -8.47339705e-02f, -9.10920277e-02f,
  -2.34096095e-01f, -2.21840981e-02f, 1.10546224e-01f, 4.76051830e-02f, -9.41988453e-02f, 1.07782274e-01f, -8.34834725e-02f, -7.69331679e-02f, 1.13402896e-01f, -1.01939917e-01f,
  1.36504203e-01f, -7.89870620e-02f, -9.53237191e-02f, 6.55797496e-02f, -5.19188168e-03f, 7.88348541e-03f, -7.61805568e-03f, -3.73208262e-02f, -1.02993883e-02f, -9.90185961e-02f,
  -1.03658788e-01f, 3.07367742e-02f, -2.86250561e-02f, 5.92859369e-03f, -1.18686527e-01f, -1.40649393e-01f, 5.38344160e-02f, -1.10542841e-01f, 4.86328080e-03f, -1.69887934e-02f,
  -9.52598527e-02f, -7.54141286e-02f, -2.66999099e-03f, -1.30768627e-01f, 3.62294950e-02f, 7.19844401e-02f, -1.86106302e-02f, -3.03067965e-03f, -6.65507019e-02f, -5.88962473e-02f,
  -3.32485348e-01f, 2.09336162e-01f, 2.57686693e-02f, -1.90109834e-02f, 2.09487770e-02f, -9.65852067e-02f, 3.00427005e-02f, 8.42920840e-02f, -6.64241835e-02f, 1.26265869e-01f,
  3.78340445e-02f, 2.84577794e-02f, -4.40107286e-02f, -7.64303207e-02f, 1.86867312e-01f, 4.15298901e-02f, -1.09693721e-01f, -4.75978432e-03f, 2.78448500e-02f, 1.96476076e-02f,
  -1.15286388e-01f, 1.25923842e-01f, 1.74308762e-01f, 3.27409394e-02f, 5.95733374e-02f, 2.17266247e-01f, 1.30879626e-01f, 2.21851230e-01f, 2.01418489e-01f, 1.45126045e-01f,
  4.96522635e-01f, 3.90254378e-01f, 3.73796523e-01f, -1.36390463e-01f, -3.82887900e-01f, -1.03495777e-01f, 3.17945689e-01f, 1.90114319e-01f, -1.18226938e-01f, 6.92787692e-02f,
  -2.09556282e-01f, -3.51929665e-01f, -1.64782211e-01f, 1.97475143e-02f, 2.80641973e-01f, 2.17289761e-01f, 3.18372548e-02f, 1.83300540e-01f, 1.98643386e-01f, 6.33181781e-02f,
  -1.52105629e-01f, -8.34960490e-03f, 2.55856156e-01f, 1.27824098e-01f, -1.47749828e-02f, -5.57850488e-02f, 1.01551443e-01f, 7.13709369e-02f, 3.12310811e-02f, 7.15549588e-02f,
  8.61724392e-02f, 2.02073991e-01f, -1.48741454e-01f, -1.36828437e-01f, -1.28263310e-01f, -8.64743954e-04f, 3.38122584e-02f, 7.63767436e-02f, -1.04779705e-01f, -2.96626613e-02f,
  -1.50647774e-01f, -2.65713520e-02f, -4.72518951e-02f, 1.34188514e-02f, 6.94032982e-02f, -2.26268582e-02f, -1.24895694e-02f, 2.25929290e-01f, -1.79299284e-02f, 2.73910314e-02f,
  -2.38080800e-01f, -9.49513540e-02f, 9.56080034e-02f, 3.79891098e-02f, 3.80540602e-02f, -2.23885387e-01f, 7.35926330e-02f, 8.62400979e-02f, 1.45355538e-01f, 2.26227686e-01f,
  -1.15576498e-01f, -6.10404834e-02f, 8.27331990e-02f, 1.28606260e-02f, -3.83731127e-02f, -3.14188860e-02f, -7.12056309e-02f, -6.95589781e-02f, -9.00937095e-02f, 6.17123544e-02f,
  -2.74536125e-02f, 2.34580636e-02f, 6.57948181e-02f, -5.27178720e-02f, -1.50096968e-01f, -1.88353695e-02f, -1.03245890e-02f, 1.36059034e-03f, -2.51836237e-02f, -8.28876793e-02f,
  -5.32614030e-02f, 1.36928419e-02f, -8.50941762e-02f, 3.54567915e-02f, -1.19583923e-02f, -5.63467070e-02f, -7.66379386e-02f, -4.04773876e-02f, -9.30661559e-02f, -1.52078182e-01f,
  -2.42370874e-01f, -3.01811397e-01f, 6.76877275e-02f, 1.08654253e-01f, -9.41076316e-03f, -1.24018431e-01f, -6.78918660e-02f, -1.07836887e-01f, -2.16754396e-02f, 1.34890854e-01f,
  -1.33013036e-02f, 4.43169698e-02f, -4.08376046e-02f, -1.06960662e-01f, -1.09240450e-01f, -5.32218292e-02f, -9.32642445e-02f, -8.70489925e-02f, -7.88023174e-02f, -1.06254585e-01f,
  -7.21258745e-02f, 6.11989051e-02f, -1.95862856e-02f, -1.72858592e-02f, -1.20293930e-01f, -1.77899018e-01f, 5.36671467e-02f, -5.92479408e-02f, -3.95986158e-03f, 1.67063326e-01f,
  4.44277972e-01f, 2.06304509e-02f, -2.16864005e-01f, 1.31709278e-01f, -1.88810691e-01f, -6.03655465e-02f, -1.31019816e-01f, -7.25826025e-02f, -6.24682643e-02f, -1.12415239e-01f,
  9.53936502e-02f, 2.59733737e-01f, 1.94396436e-01f, 1.10380694e-01f, 1.04807243e-01f, -2.12953109e-02f, -1.24139264e-02f, -4.64055650e-02f, 4.95517403e-02f, -1.16345346e-01f,
  1.66197494e-02f, 1.66050140e-02f, -7.27865892e-03f, -6.49053380e-02f, -1.21246397e-01f, 9.46747735e-02f, -1.73339814e-01f, -1.58779427e-01f, -1.31664500e-01f, -1.31853893e-01f,
  -4.81872410e-02f, -1.42357856e-01f, 7.46031851e-02f, 9.03124437e-02f, -7.59673044e-02f, -8.59514028e-02f, 5.72560355e-02f, -3.73000205e-02f, -3.33943665e-02f, -1.38543159e-01f,
  -1.24040231e-01f, -2.62036789e-02f, -1.09288752e-01f, -1.20672122e-01f, -4.26349603e-02f, -1.40573218e-01f, -2.70585921e-02f, -1.16847590e-01f, -1.65896509e-02f, -1.80880837e-02f,
  -1.85145834e-03f, -1.27577499e-01f, -1.11793354e-01f, -4.03124355e-02f, -2.68669017e-02f, 2.07655951e-02f, -8.75298828e-02f, -8.17312598e-02f, -4.01918031e-02f, 4.39993758e-03f,
  -2.23380774e-02f, 9.64112654e-02f, 4.04393971e-02f, 3.88582200e-02f, -5.07238728e-04f, 2.54727062e-02f, -4.00201082e-02f, -2.27284711e-02f, -2.08679512e-02f, -9.43710878e-02f,
  -8.57551470e-02f, 5.16111851e-02f, 2.94897743e-02f, 1.11078650e-01f, 6.67072162e-02f, 8.83066095e-03f, -1.19378291e-01f, -1.93680320e-02f, 1.01704895e-01f, -1.40375998e-02f,
  5.83802499e-02f, -2.75005959e-02f, 4.81432043e-02f, 4.92829010e-02f, -2.22844332e-02f, 1.18836369e-02f, 2.33995728e-02f, 2.07429752e-02f, -3.45723182e-02f, -7.72337019e-02f,
  1.19531840e-01f, 9.74173546e-02f, 1.07546508e-01f, 5.14072515e-02f, -1.35251299e-01f, -3.33032683e-02f, -5.19107562e-03f, 3.45043987e-02f, 5.78482412e-02f, 2.79525612e-02f,
  -5.02442867e-02f, -9.60560292e-02f, -5.23071103e-02f, -1.16076283e-01f, -1.05710782e-01f, -3.30450907e-02f, 1.08403713e-01f, 3.85434330e-02f, 1.95080638e-02f, 3.39121334e-02f,
  -7.46217370e-02f, 4.11168113e-02f, 9.30868536e-02f, -4.33692615e-03f, 1.05263004e-02f, 5.05022369e-02f, -4.03223597e-02f, -2.54798401e-02f, -4.42752466e-02f, 3.15648615e-02f,
  -6.45059347e-01f, 3.50749493e-01f, 4.73255143e-02f, -3.54122221e-01f, 3.23688798e-02f, 2.90461093e-01f, 4.59547311e-01f, 9.18439627e-02f, -1.64576843e-01f, -5.02539193e-03f,
  5.50454147e-02f, -1.18599497e-01f, 5.56412665e-03f, 3.92716676e-02f, 1.18395880e-01f, 2.02220187e-01f, 2.41443172e-01f, -7.47063980e-02f, -1.48752034e-01f, -4.79002148e-02f,
  1.23498172e-01f, -1.22457087e-01f, -2.93250889e-01f, -1.82570204e-01f, -1.73394680e-01f, -1.68537050e-01f, -1.79984737e-02f, -4.44468483e-02f, 1.64808467e-01f, 8.09213892e-02f,
  -4.54983592e-01f, -2.36602142e-01f, 6.15148358e-02f, -1.13000229e-01f, -8.96763951e-02f, -1.52951166e-01f, -1.31024299e-02f, -1.01362593e-01f, -1.32543659e-02f, -1.50266543e-01f,
  -1.61754563e-01f, -2.73080748e-02f, -1.93426684e-02f, 6.67665247e-03f, -4.61033881e-02f, -8.94837976e-02f, 7.51732439e-02f, -3.74996439e-02f, -7.27255121e-02f, 9.35622156e-02f,
  2.23040313e-01f, -1.53004844e-02f, -6.69595897e-02f, 2.67237276e-01f, 7.78742060e-02f, 2.35363115e-02f, 2.24390179e-02f, 3.03398520e-02f, 3.14563364e-02f, -1.35912955e-01f,
  6.15560710e-02f, -6.30328953e-02f, 1.12067729e-01f, 1.24384733e-02f, 3.84987406e-02f, -5.91153465e-02f, -4.82557379e-02f, 1.00777008e-01f, 3.17218341e-02f, -1.35976404e-01f,
  8.00390318e-02f, 2.16596480e-02f, 5.68158645e-03f, -1.44748524e-01f, -2.57840510e-02f, -8.53314064e-03f, -1.43415900e-02f, 8.05895701e-02f, -2.99958345e-02f, -5.14055490e-02f,
  -1.14749439e-01f, 7.37975463e-02f, 1.17778163e-02f, -3.33418995e-02f, 1.70590624e-01f, -8.67394805e-02f, 1.96416657e-02f, -7.06134513e-02f, -2.19246522e-02f, 5.31230979e-02f,
  -4.96216059e-01f, 2.26016968e-01f, -1.81904078e-01f, 5.52330129e-02f, -1.79116484e-02f, 1.50772305e-02f, 9.70574841e-02f, 1.23398721e-01f, -2.20985133e-02f, -9.40954611e-02f,
  -4.70960811e-02f, -3.44928540e-02f, 3.80236357e-02f, 2.13422447e-01f, -3.25278938e-02f, -4.33759838e-02f, 6.48812354e-02f, -1.29194498e-01f, 9.31687281e-02f, 1.98531542e-02f,
  1.48752257e-01f, 2.07511635e-04f, -3.06681126e-01f, 1.08872734e-01f, 3.37939933e-02f, -1.70084894e-01f, -1.74042761e-01f, -3.88548337e-02f, 2.27176230e-02f, -2.49484614e-01f,
  -9.78695787e-03f, -3.75269949e-01f, -2.47875825e-01f, -1.37472361e-01f, -1.74074590e-01f, -1.60050258e-01f, -6.09435856e-01f, -2.67314225e-01f, 1.35597186e-02f, -5.91893315e-01f,
  -2.88051188e-01f, 5.18867187e-02f, -1.08083114e-01f, -2.99886391e-02f, -1.79988831e-01f, -4.65731710e-01f, -4.16897535e-01f, -1.00517817e-01f, 2.07912162e-01f, -1.63568094e-01f,
  -2.01221481e-01f, -1.34331197e-01f, 1.44693315e-01f, 2.82202158e-02f, -2.05000013e-01f, 3.65241319e-02f, -2.21184880e-01f, -5.24742231e-02f, -4.10796292e-02f, -2.13335872e-01f,
  -3.02743375e-01f, -2.37503815e-02f, 5.00331167e-03f, 1.27999842e-01f, -1.52574286e-01f, 1.32990867e-01f, -8.19322169e-02f, 2.73101404e-02f, -2.26423219e-02f, 2.43071429e-02f,
  2.77136341e-02f, -2.78466549e-02f, 9.54660773e-02f, -1.14228139e-02f, -1.04634270e-01f, -2.78676040e-02f, -1.55664250e-01f, 8.04197229e-03f, 6.10711705e-03f, -1.05624199e-01f,
  -1.77422881e-01f, -9.00187120e-02f, 7.01658726e-02f, 4.57887650e-02f, 1.93538621e-01f, 6.97512478e-02f, -5.00321295e-03f, 2.78860927e-01f, 1.54067978e-01f, -1.13443233e-01f,
  -1.60350323e-01f, 3.82356276e-03f, -9.85570475e-02f, 6.30490482e-02f, 3.95110715e-03f, -8.17736536e-02f, -2.98139434e-02f, -9.25980806e-02f, 6.89634979e-02f, -6.48931265e-02f,
  -3.12390868e-02f, -1.18068248e-01f, 6.11201189e-02f, -8.80135670e-02f, -9.51207429e-02f, 2.07788888e-02f, -8.15285072e-02f, -7.22110048e-02f, 7.64064565e-02f, -1.71765331e-02f,
  -3.80625832e-03f, 6.17777742e-02f, -3.03094443e-02f, 9.72497165e-02f, -8.80014803e-03f, -7.77676255e-02f, 9.05344486e-02f, 9.24129598e-03f, 5.43795973e-02f, -1.42905369e-01f,
  -4.84713446e-03f, -1.52537562e-02f, -2.11899087e-01f, 4.56815027e-02f, -6.76427931e-02f, -1.93426702e-02f, -5.51772192e-02f, 5.59292100e-02f, 2.10630298e-01f, -9.60422456e-02f,
  7.45709566e-03f, -1.31291717e-01f, -5.23220822e-02f, -2.94345394e-02f, -3.06611992e-02f, -1.86591111e-02f, -1.73221499e-01f, -6.96755424e-02f, 1.98178902e-01f, -2.04105563e-02f,
  -1.74684227e-01f, -8.30384344e-02f, -1.87826157e-01f, 1.08881369e-02f, 7.15572685e-02f, -1.64925922e-02f, -7.89368004e-02f, 4.16360572e-02f, 6.88727666e-03f, -4.11645800e-01f,
  -5.29917538e-01f, -2.82380164e-01f, 6.27449751e-02f, 1.44579560e-01f, 3.18819255e-01f, 3.06822479e-01f, 2.36388564e-01f, 9.10175890e-02f, 2.49435470e-01f, 1.29661947e-01f,
  -2.33101234e-01f, -9.41722244e-02f, -2.88071260e-02f, 9.39373206e-03f, 1.58301607e-01f, 2.39873126e-01f, 3.62242967e-01f, 7.11220503e-02f, 1.31103560e-01f, 1.26730070e-01f,
  1.96531355e-01f, 1.77900895e-01f, -3.54268588e-02f, 8.48812386e-02f, -7.60739762e-03f, 2.31678069e-01f, 1.89281076e-01f, -8.04164726e-03f, 4.66811396e-02f, 2.10787773e-01f,
  -1.34330586e-01f, -2.37128735e-01f, 1.05271079e-01f, -1.04468226e-01f, -2.27878943e-01f, -2.67011195e-01f, -3.90766039e-02f, -1.91319823e-01f, -1.61841393e-01f, 7.80480877e-02f,
  1.41829867e-02f, -1.37232229e-01f, -5.17835654e-02f, -1.20193556e-01f, -2.16301531e-02f, -2.76944246e-02f, -1.48096025e-01f, 2.63928156e-02f, 9.49716344e-02f, -1.67228520e-01f,
  -9.12700742e-02f, -7.96364546e-02f, 9.71224308e-02f, 1.56617329e-01f, 1.17847286e-01f, 1.93009060e-02f, -6.02983236e-02f, -7.90978968e-03f, -3.87615561e-02f, -1.55742867e-02f,
  2.57073611e-01f, 1.01199165e-01f, 7.88440853e-02f, 3.42658237e-02f, 1.84781209e-01f, 4.53629196e-02f, 3.83802988e-02f, 8.25993717e-02f, 1.96681663e-01f, 1.23528071e-01f,
  1.28003269e-01f, 1.45867065e-01f, 3.68450321e-02f, 3.98759777e-03f, 9.14387777e-02f, -4.26123850e-02f, -1.31630033e-01f, -5.51490532e-03f, -5.10898717e-02f, 2.90138666e-02f,
  7.97666460e-02f, -2.29875017e-02f, -1.44655988e-01f, -2.12368257e-02f, -3.45426276e-02f, -8.04805905e-02f, -2.56370567e-02f, -1.54662933e-02f, -1.06574580e-01f, -5.09632342e-02f,
  3.15844476e-01f, 1.00281388e-01f, 9.65709910e-02f, 7.87618235e-02f, -3.50276753e-02f, -1.45212457e-01f, 1.40182506e-02f, -8.67322758e-02f, -4.23280597e-02f, 9.32763517e-02f,
  -9.78940427e-02f, -1.45279467e-01f, -1.28288381e-02f, -2.30939519e-02f, 7.71819949e-02f, 9.63306725e-02f, -1.03918232e-01f, 2.86319922e-03f, 1.30112916e-01f, -8.21161717e-02f,
  -9.22038928e-02f, 2.00897574e-01f, 2.19762638e-01f, 2.26841122e-01f, 2.24623740e-01f, 9.99043435e-02f, 1.17211938e-01f, 6.01022094e-02f, 1.24467701e-01f, 4.55725938e-02f,
  5.79971671e-01f, -2.27031127e-01f, 4.51429114e-02f, 2.05428854e-01f, -5.28321527e-02f, -2.89554577e-02f, -9.78793055e-02f, -3.67384851e-02f, 1.35468751e-01f, 5.15640117e-02f,
  1.35557309e-01f, 1.61153391e-01f, 2.52227485e-01f, 2.13959515e-01f, 1.34416997e-01f, -3.01673040e-02f, -5.17950095e-02f, 2.44597435e-01f, 2.32857466e-01f, 8.12702179e-02f,
  -2.61207856e-03f, -4.02951390e-02f, 1.02244601e-01f, 5.26258489e-03f, -1.67642862e-01f, 1.51833788e-01f, -8.83090496e-02f, 1.29329916e-02f, 1.72965191e-02f, -1.10919185e-01f,
  -1.29573569e-01f, 7.21336976e-02f, 3.44311893e-02f, -2.20175534e-02f, -2.01441143e-02f, 6.93550408e-02f, -5.40500581e-02f, -1.33852363e-01f, -2.56227106e-02f, -6.41287416e-02f,
  -5.36991954e-02f, -1.86476056e-02f, 5.21402806e-02f, -1.03893718e-02f, -9.53423977e-02f, -6.30361810e-02f, -1.25885889e-01f, -2.49045994e-02f, 4.78565022e-02f, 1.63811538e-02f,
  1.24954246e-02f, 5.77695034e-02f, -9.20297056e-02f, -1.06802247e-01f, 7.58742690e-02f, 1.02605879e-01f, 4.72393893e-02f, 4.12930660e-02f, 3.38446237e-02f, 8.73171166e-02f,
  -8.86313617e-03f, 1.96814574e-02f, 4.51783314e-02f, -3.45960408e-02f, -1.04050756e-01f, 9.28675383e-02f, -2.36236919e-02f, 1.48627879e-02f, 3.50472219e-02f, -6.82069585e-02f,
  -5.03919907e-02f, 4.93479483e-02f, 9.89162084e-03f, -1.64942816e-02f, 1.21308737e-01f, 4.97574434e-02f, -2.49674227e-02f, 4.51805182e-02f, 1.99368820e-02f, 3.29400152e-02f,
  -5.14399856e-02f, 7.08526596e-02f, 5.83700184e-03f, 5.57887666e-02f, 5.83420396e-02f, 7.46600032e-02f, 9.59198028e-02f, -3.44367847e-02f, 8.76740441e-02f, 4.64841127e-02f,
  -4.59497094e-01f, 1.64526373e-01f, 8.98707137e-02f, -2.63527632e-02f, -1.11928277e-01f, -1.19892895e-01f, -4.16056849e-02f, -5.47669940e-02f, -1.22504219e-01f, -1.65260836e-01f,
  -1.52902380e-01f, 7.78319314e-02f, -5.31312078e-04f, -7.74163306e-02f, -8.06415901e-02f, -6.03084490e-02f, -6.39985502e-02f, 1.33082841e-03f, -7.01030195e-02f, -3.45626436e-02f,
  -3.18586491e-02f, 8.01233649e-02f, 1.03562362e-01f, -1.63719207e-02f, 1.23083005e-02f, 1.59086287e-01f, -1.57354362e-02f, 3.71309090e-03f, 1.77242622e-01f, -8.99237860e-03f,
  -6.10151812e-02f, -1.96412299e-02f, 1.33213967e-01f, 2.83434868e-01f, -1.08694196e-01f, -1.52500793e-01f, -3.28052551e-01f, -1.37775674e-01f, -4.71359864e-02f, -9.21983719e-02f,
  -1.58049569e-01f, -9.75667685e-03f, -3.43564176e-03f, 5.57972714e-02f, 1.07913062e-01f, 8.88543725e-02f, 4.37270701e-01f, 2.84347296e-01f, 5.75124249e-02f, 7.41040483e-02f,
  5.25473803e-02f, 1.70509428e-01f, 1.31937847e-01f, 1.45487711e-01f, 1.28877506e-01f, 1.03306703e-01f, 7.56568834e-02f, 8.25999677e-02f, -8.62437859e-02f, 5.80423295e-01f,
  1.07432209e-01f, -2.11369842e-01f, 2.60441899e-02f, 5.73889054e-02f, -6.18627220e-02f, 1.52617753e-01f, 1.65437385e-01f, 1.98508173e-01f, 4.38644812e-02f, 1.52238488e-01f,
  1.24461651e-01f, -3.32888961e-02f, 1.49012879e-01f, 8.64356682e-02f, 1.08536154e-01f, 1.01559358e-02f, 1.02286018e-01f, 1.78312793e-01f, 1.82440728e-02f, -2.76739011e-03f,
  2.57010609e-01f, -1.66113988e-01f, -2.83501804e-01f, -2.35041499e-01f, -3.11105628e-03f, 1.07089253e-02f, -1.90318435e-01f, 9.55287181e-03f, -2.52305478e-01f, 1.82284549e-01f,
  -8.06617141e-02f, -9.72233266e-02f, -4.18823846e-02f, 1.58624932e-01f, 5.26054241e-02f, 8.46970826e-02f, 2.18414918e-01f, 1.76286757e-01f, 1.10413857e-01f, 7.10478872e-02f,
  1.25195920e-01f, -3.30006927e-02f, 7.05535412e-02f, -9.72803086e-02f, -4.67564054e-02f, 1.72322039e-02f, 6.39588311e-02f, -5.89010073e-03f, -2.11673841e-01f, -5.16123995e-02f,
  1.85775999e-02f, 4.61506583e-02f, -4.87347431e-02f, 2.74416447e-01f, 1.46939894e-02f, 4.78231832e-02f, 1.43473417e-01f, 2.39594607e-03f, -4.73143309e-02f, -8.53443444e-02f,
  -1.60088375e-01f, -3.45736027e-01f, 5.36480919e-02f, 1.36850387e-01f, -6.18963987e-02f, -1.67340085e-01f, -3.86691745e-03f, -5.89053631e-02f, -6.06533661e-02f, -1.19720204e-02f,
  -1.05896637e-01f, -1.28432170e-01f, -9.15529951e-02f, 1.45128518e-01f, 3.74874473e-02f, -8.44348397e-04f, 1.28683001e-01f, 6.91638663e-02f, 7.47112790e-03f, -9.57380682e-02f,
  1.98493943e-01f, -3.21586877e-01f, -2.61785179e-01f, -2.18604401e-01f, -1.44745380e-01f, -1.16069689e-01f, -1.50446132e-01f, -1.11781679e-01f, -3.38809639e-01f, -2.43959382e-01f,
  -3.44936222e-01f, 3.24301213e-01f, -1.08550772e-01f, -1.72426969e-01f, 2.40319103e-01f, 9.18553211e-03f, -6.51422590e-02f, -3.33807558e-01f, -4.51298840e-02f, 2.24034637e-01f,
  2.91716874e-01f, 2.92881224e-02f, 3.44239026e-02f, -3.74223292e-03f, -2.08944649e-01f, 1.68633208e-01f, 1.23589389e-01f, -1.17940046e-01f, -3.40591252e-01f, -9.67454985e-02f,
  1.36375591e-01f, -8.55854601e-02f, -2.86319464e-01f, -1.93434164e-01f, 3.98813635e-02f, -2.36362517e-02f, -1.40106156e-02f, -6.55084625e-02f, 2.07739934e-01f, 3.00704598e-01f,
  5.21469712e-02f, -1.76455528e-01f, 4.14582305e-02f, 1.53734341e-01f, 7.88286775e-02f, -1.08881749e-01f, 3.46556157e-02f, -1.11967184e-01f, 8.68519098e-02f, 5.84757049e-03f,
  1.30774274e-01f, 7.21426606e-02f, 2.18354568e-01f, -4.46570255e-02f, -1.04051031e-01f, -1.87676966e-01f, -1.85129449e-01f, -2.21642524e-01f, -2.37091511e-01f, -1.91315070e-01f,
  3.22035432e-01f, 5.06456830e-02f, -2.54281074e-01f, -1.63021445e-01f, -2.10316449e-01f, -4.07650433e-02f, -3.08444053e-01f, -1.88140526e-01f, -3.11623663e-01f, -1.38964579e-01f,
  6.35361373e-02f, 3.49912457e-02f, 1.47032633e-01f, -1.36468247e-01f, 9.01984144e-03f, -8.77947372e-04f, 6.58126846e-02f, 8.86437297e-02f, -1.75469276e-02f, -1.06476955e-01f,
  9.87516809e-03f, -1.26485273e-01f, -8.46355185e-02f, -3.16870734e-02f, -1.25380725e-01f, 4.68706228e-02f, 1.55556286e-02f, 6.13663457e-02f, -7.16063082e-02f, -4.71884944e-03f,
  -2.13402440e-03f, 5.86417690e-02f, 1.24071293e-01f, -8.90854001e-02f, 1.01352036e-01f, -4.03576717e-03f, 1.02576524e-01f, -3.58349644e-03f, -7.66952187e-02f, -8.92636366e-03f,
  -2.82193840e-01f, 8.32821280e-02f, 2.40086019e-02f, 4.53550145e-02f, 6.78040832e-03f, -7.67982826e-02f, 6.68837205e-02f, 3.95402722e-02f, 1.17707804e-01f, -1.55701935e-01f,
  3.78968590e-03f, -8.82467851e-02f, -6.46577328e-02f, 4.02183384e-02f, -1.13174647e-01f, -1.02302134e-02f, 1.25856221e-01f, 1.48326159e-01f, -7.54798483e-03f, -1.65021688e-01f,
  2.53195688e-02f, -1.77327901e-01f, -1.33290365e-01f, -1.21804014e-01f, -9.43814516e-02f, -1.15307480e-01f, -1.70147076e-01f, -1.93588406e-01f, -1.30608723e-01f, -2.43400171e-01f,
  5.36307454e-01f, 4.27933156e-01f, 2.27989689e-01f, 1.16595022e-01f, -4.34234254e-02f, 1.12841658e-01f, 1.81462690e-01f, 2.02242807e-01f, 7.14936629e-02f, 1.11395516e-01f,
  2.32698470e-01f, 1.21779174e-01f, 1.60904333e-01f, -2.23630061e-03f, 1.97101891e-01f, 1.12077959e-01f, 5.59779629e-03f, 5.54808192e-02f, -2.28288341e-02f, 7.66325137e-03f,
  -1.29194170e-01f, -5.52601106e-02f, 1.08001806e-01f, -7.45809590e-03f, 1.24614704e-02f, -1.84774697e-02f, 8.08313936e-02f, 6.88011572e-02f, -9.48105473e-03f, 4.93274480e-02f,
  3.38871889e-02f, 2.16985211e-01f, -1.38635069e-01f, -1.15227021e-01f, 2.44789589e-02f, 3.21383104e-02f, -5.21888621e-02f, 9.30564553e-02f, 5.50903641e-02f, -4.93812189e-02f,
  -6.33759350e-02f, -9.41330492e-02f, -1.11831211e-01f, -2.18343046e-02f, 6.80099204e-02f, -1.01726130e-02f, 6.31781667e-02f, 1.15226939e-01f, -1.72595065e-02f, -3.31424177e-02f,
  -8.79908539e-03f, 5.02650766e-03f, 2.44368296e-02f, -2.76861694e-02f, -7.41181243e-03f, 2.77803522e-02f, 5.05390540e-02f, -4.31612395e-02f, 8.70006904e-02f, 5.70387505e-02f,
  -9.43083968e-03f, 1.46923274e-01f, -1.81250423e-02f, -2.80981530e-02f, -4.88515384e-02f, -1.25666380e-01f, 6.67115534e-03f, 1.02021173e-02f, -1.06819429e-01f, -6.86710700e-02f,
  -1.08244464e-01f, -4.93329726e-02f, 9.57801938e-02f, -5.86718284e-02f, 2.53452035e-03f, 7.68749341e-02f, 1.76548868e-01f, -1.69872604e-02f, -1.86288401e-01f, -5.32514714e-02f,
  -1.58974037e-01f, 5.05787544e-02f, 7.54786283e-02f, -4.23597656e-02f, 2.16316842e-02f, 4.80643697e-02f, 1.70587038e-03f, 3.90194319e-02f, -6.08426146e-02f, 1.14075541e-01f,
  -1.89117432e-01f, -3.14477056e-01f, -1.24113470e-01f, -8.68263021e-02f, 1.01116588e-02f, 3.40195149e-02f, -1.06202967e-01f, 1.48621844e-02f, -4.08685766e-02f, -4.89037000e-02f,
  2.64868289e-02f, 7.48635158e-02f, -6.93856739e-03f, -4.74071354e-02f, -1.43592790e-01f, -7.60069489e-02f, 5.04168905e-02f, 7.45344907e-02f, 1.31606862e-01f, 6.01675883e-02f,
  -6.53703418e-03f, 3.78757678e-02f, -3.48845720e-02f, -9.84674226e-03f, -1.31157368e-01f, -1.58599600e-01f, -1.19309440e-01f, 2.91868690e-02f, 1.12300320e-02f, 2.02275831e-02f,
  6.54145539e-01f, -3.42268020e-01f, -1.61620662e-01f, 1.40798002e-01f, -2.93674376e-02f, 2.00705323e-03f, -2.72490621e-01f, 8.34399462e-02f, 1.53557256e-01f, -1.07516699e-01f,
  2.36463666e-01f, 4.40579534e-01f, 3.43885303e-01f, 1.69379994e-01f, 2.07529142e-01f, -2.37260029e-01f, -2.67737120e-01f, 1.88702773e-02f, 2.80039549e-01f, 1.16685882e-01f,
  2.10590754e-02f, -8.51195827e-02f, 2.85268426e-02f, 5.46811484e-02f, -2.32071638e-01f, -7.51774013e-03f, -2.06400618e-01f, -2.26933599e-01f, -2.09031835e-01f, -2.56813943e-01f,
  -1.06580444e-01f, 2.29269668e-01f, 1.36764154e-01f, 1.21222876e-01f, -2.46444307e-02f, 8.22552070e-02f, 2.72586811e-02f, -1.25299558e-01f, -7.97482487e-03f, -1.16322495e-01f,
  2.55419128e-02f, 1.15808391e-03f, -5.06133139e-02f, -3.43175717e-02f, -1.21703185e-01f, 4.17723805e-02f, 4.43731919e-02f, 9.29166526e-02f, 6.14365712e-02f, -7.29830116e-02f,
  -1.05800526e-02f, 9.59362760e-02f, 9.37407240e-02f, 1.19713418e-01f, 4.13716622e-02f, 1.56620756e-01f, -6.51440918e-02f, 1.14337467e-01f, 8.20545331e-02f, -5.52535988e-02f,
  8.47133994e-02f, 6.74051195e-02f, 2.06193715e-01f, 1.32371977e-01f, 1.60109196e-02f, 7.19304606e-02f, 4.63961139e-02f, -1.77128818e-02f, 4.97330353e-02f, -8.97981599e-02f,
  1.86031293e-02f, 1.02307618e-01f, 1.44378349e-01f, 4.13251072e-02f, 1.96895953e-02f, 4.99631949e-02f, -8.18819180e-02f, 2.84590982e-02f, -8.21551215e-03f, -6.66775880e-03f,
  1.19226925e-01f, -6.13000132e-02f, -1.46613851e-01f, -1.33901134e-01f, -2.89782844e-02f, 2.53680833e-02f, -4.64343503e-02f, 7.46659115e-02f, -8.48310888e-02f, -1.79107413e-01f,
  -2.31389508e-01f, 3.64853561e-01f, 4.14845757e-02f, 6.27291203e-02f, -9.09937695e-02f, -7.63084069e-02f, 1.33505255e-01f, -5.52659258e-02f, -2.46789277e-01f, -3.39357853e-02f,
  -3.26801017e-02f, -4.94658761e-02f, -1.93401873e-02f, -6.19275495e-02f, -3.00778337e-02f, 1.98621769e-02f, -1.13577377e-02f, -1.28131919e-02f, -4.10501547e-02f, -2.11106196e-01f,
  -1.18851632e-01f, 1.67860836e-03f, 1.65071934e-01f, 1.13779955e-01f, 1.08196512e-01f, 1.68858469e-01f, -4.21526954e-02f, -5.38465716e-02f, 9.33486596e-02f, -1.55048043e-01f,
  -4.75823373e-01f, -3.26030552e-02f, -5.68130128e-02f, -3.03459615e-01f, 1.82492640e-02f, -6.65997267e-02f, -1.10091649e-01f, -1.85288832e-01f, -3.18707712e-02f, -3.91304269e-02f,
  1.34338722e-01f, 1.02505662e-01f, -1.49342820e-01f, -1.12239346e-01f, -2.18603536e-01f, -1.08693376e-01f, -2.99689710e-01f, -2.78611362e-01f, -1.59686003e-02f, 1.78388178e-01f,
  1.33143693e-01f, -8.70775506e-02f, -7.90994540e-02f, -3.59936524e-03f, 1.27649933e-01f, 3.74230593e-02f, -7.48561174e-02f, -3.84038500e-02f, 1.35135844e-01f, -1.23204842e-01f,
  1.11615486e-01f, -1.64348274e-01f, 1.11347422e-01f, -1.34908691e-01f, 7.21468255e-02f, 7.74135441e-02f, 1.04672350e-01f, -6.71591163e-02f, -5.50693683e-02f, 2.64995620e-02f,
  -6.31935820e-02f, 1.71464980e-01f, -3.51597951e-03f, -1.81384776e-02f, -2.80736666e-03f, -1.62384976e-02f, -1.55777201e-01f, -8.78109410e-02f, -4.68928702e-02f, 7.70377517e-02f,
  -3.54702747e-03f, -1.40962854e-01f, -1.70188248e-01f, -3.01118568e-02f, 8.18111897e-02f, -4.44528908e-02f, 1.90411910e-01f, 1.25495136e-01f, 3.83673683e-02f, -3.55751105e-02f,
  1.36403024e-01f, 3.93036827e-02f, 8.83467868e-03f, -8.69777706e-03f, -7.99615458e-02f, 3.57055850e-02f, -3.21210325e-02f, -7.51479566e-02f, 7.88567737e-02f, 3.06064524e-02f,
  -7.91569799e-02f, 5.08437604e-02f, -2.96407100e-02f, -4.53058742e-02f, -4.31621596e-02f, -2.06811398e-01f, 1.50896376e-03f, 2.09807213e-02f, 4.51483065e-03f, -7.92347919e-03f,
  -7.83876777e-02f, 7.38476664e-02f, -2.92829629e-02f, -7.44805783e-02f, 3.48342694e-02f, -5.74308485e-02f, -1.00644767e-01f, -4.43247072e-02f, -3.93466726e-02f, -1.39592960e-02f,
  -1.04511693e-01f, -4.50414047e-02f, -8.60918371e-04f, -9.63450782e-03f, -1.20457761e-01f, 1.21224634e-01f, -1.21174809e-02f, 2.95618922e-02f, -1.26618981e-01f, 2.80003473e-02f,
  2.53911735e-03f, -6.27267510e-02f, 4.00855988e-02f, -3.82528780e-03f, -7.18936101e-02f, 1.51081022e-03f, -1.78585202e-01f, -3.08349371e-01f, -2.50534624e-01f, 1.57122433e-01f,
  -1.22813560e-01f, -1.54004410e-01f, -2.20529482e-01f, -1.57091066e-01f, 1.71401561e-03f, -1.09087437e-01f, 1.39904514e-01f, 4.91103297e-03f, -9.14588720e-02f, -7.92956278e-02f,
  -1.02459960e-01f, 3.00234407e-01f, -4.79385443e-02f, 2.39064574e-01f, 1.82247296e-01f, 1.15704976e-01f, 1.21649414e-01f, 1.74238160e-01f, 2.14446425e-01f, 1.68690547e-01f,
  2.34395757e-01f, 2.45518744e-01f, 2.89999455e-01f, 2.49754578e-01f, 2.14007914e-01f, 1.53091058e-01f, 1.59393162e-01f, 1.37655893e-02f, 6.36892170e-02f, 5.78188039e-02f,
  2.35375494e-01f, 7.38648921e-02f, -4.74741608e-02f, 1.53152049e-02f, 9.21346471e-02f, 2.07582906e-01f, 1.63734272e-01f, 2.24395186e-01f, 1.20705493e-01f, 3.31040740e-01f,
  -8.51285607e-02f, -9.35161859e-02f, 7.64689595e-02f, -9.23928767e-02f, -2.08909083e-02f, -1.08295590e-01f, -1.09862849e-01f, 1.84007380e-02f, 4.84833941e-02f, -1.12206399e-01f,
  -1.00977987e-01f, -1.58181608e-01f, -1.16386935e-01f, -1.53620377e-01f, -6.15769997e-02f, -1.30965859e-01f, 1.20397815e-02f, 7.14981705e-02f, 2.01437131e-01f, 9.77933034e-02f,
  1.05779348e-02f, -6.81760758e-02f, 4.74980697e-02f, 4.35637198e-02f, -4.39021140e-02f, -2.23507471e-02f, 5.97176887e-02f, 3.86089720e-02f, -6.35284260e-02f, 2.58284230e-02f,
  1.87358782e-01f, -3.80196818e-03f, -7.88109601e-02f, -8.97159278e-02f, -9.05396566e-02f, -9.61943269e-02f, -7.31274998e-03f, 2.04082467e-02f, 2.58234106e-02f, -2.00246409e-01f,
  -2.91045904e-02f, -3.08944024e-02f, -3.61136831e-02f, -1.56565428e-01f, -5.97943813e-02f, -4.42833342e-02f, -1.00517049e-01f, -7.01558292e-02f, -1.06133699e-01f, -8.64737034e-02f,
  -1.22712314e-01f, -4.48762774e-02f, -4.81956378e-02f, -1.49332285e-01f, -1.02176871e-02f, 1.17681315e-03f, -1.01245537e-01f, 1.64366849e-02f, 3.59133705e-02f, 4.70576808e-02f,
  1.55003130e-01f, -2.50102550e-01f, -3.86986546e-02f, 6.76824618e-03f, 2.91945748e-02f, -1.28450124e-02f, -6.84737712e-02f, 7.76930759e-03f, -3.81787634e-03f, -2.47559492e-02f,
  -6.63513243e-02f, -3.10783181e-02f, -1.04072861e-01f, -1.58297226e-01f, -1.31701782e-01f, -1.45744577e-01f, -2.20116973e-02f, 1.88850954e-01f, 1.66403890e-01f, -4.92439419e-02f,
  -6.77401051e-02f, -2.91008614e-02f, -8.30221176e-02f, -7.10279197e-02f, 8.48585088e-03f, 7.12011158e-02f, -1.36269480e-01f, -1.03096604e-01f, -2.56674364e-02f, -1.18361391e-01f,
  2.24754617e-01f, -2.13397190e-01f, 1.84144124e-01f, 1.29834548e-01f, -3.11095625e-01f, -4.13650155e-01f, -5.37971675e-01f, -3.35576147e-01f, -1.00955911e-01f, -9.76693779e-02f,
  -2.73304492e-01f, 1.39019638e-01f, 7.28994235e-02f, 1.77439436e-01f, 6.75448477e-02f, -4.78492938e-02f, 3.00698161e-01f, 3.45744789e-01f, 2.63893872e-01f, 8.45512450e-02f,
  9.01055261e-02f, 1.36071190e-01f, 2.74213761e-01f, 2.62281090e-01f, 1.82647035e-01f, 1.12169525e-02f, -2.12088749e-02f, 1.25811353e-01f, -4.42013107e-02f, 4.86842245e-01f,
  2.59451121e-01f, -1.13140509e-01f, -8.14488754e-02f, 1.09031297e-01f, 4.49704006e-02f, 5.71331196e-02f, -6.50774688e-02f, 8.80147368e-02f, -1.92068759e-02f, 2.46186871e-02f,
  -8.13527312e-03f, 7.19344690e-02f, -2.55812295e-02f, 9.38402787e-02f, -6.16040453e-02f, -1.07921772e-01f, 1.63484976e-01f, 1.10257484e-01f, 1.25615284e-01f, -3.36721353e-02f,
  1.03128597e-01f, -5.51570803e-02f, -1.43252000e-01f, -2.51196444e-01f, -1.15468465e-01f, 4.08212841e-02f, -1.53933123e-01f, -4.05100323e-02f, -6.12741783e-02f, -2.65619881e-03f,
  5.55231050e-02f, 2.07119346e-01f, 8.77626091e-02f, 2.25749444e-02f, 2.68162973e-02f, -3.51693928e-02f, 7.26488680e-02f, 1.17512308e-01f, 4.65390161e-02f, 1.15088254e-01f,
  5.59956431e-02f, 4.04193699e-02f, 6.67670220e-02f, -6.35228530e-02f, 1.77309811e-01f, 2.03969069e-02f, 6.73609748e-02f, 1.68507084e-01f, 1.62640270e-02f, 3.33342999e-02f,
  1.39011383e-01f, 1.36762932e-02f, 4.25582975e-02f, 6.09626770e-02f, 6.09660260e-02f, 1.07962832e-01f, 1.37777701e-01f, 1.38583928e-02f, 2.35257708e-02f, 5.70413806e-02f,
  -2.54128337e-01f, -9.64167342e-02f, -1.14701651e-02f, -2.17171833e-02f, -2.99851689e-02f, -7.21389726e-02f, -7.66019523e-02f, 6.06535859e-02f, -8.09126645e-02f, -3.54497135e-02f,
  -2.46937200e-01f, -1.36699229e-01f, -1.29843161e-01f, -2.04959661e-02f, -3.85718085e-02f, -1.37688607e-01f, 2.46031489e-02f, 1.11398369e-01f, 8.49013310e-03f, 7.00289831e-02f,
  -8.77274852e-03f, -2.72482246e-01f, -1.79329902e-01f, -2.41959214e-01f, -2.58520037e-01f, -2.16136500e-01f, -1.40256837e-01f, -1.19611569e-01f, -3.20142388e-01f, -4.18948621e-01f,
  -3.82960707e-01f, 1.67976186e-01f, 4.68124062e-01f, 3.56331542e-02f, 1.05622850e-01f, 1.75811611e-02f, 1.50028452e-01f, -1.54582202e-01f, -2.11916283e-01f, -6.66352138e-02f,
  2.61082966e-02f, -1.09161280e-01f, 1.54854611e-01f, 6.38394281e-02f, -8.60876683e-03f, 3.96565385e-02f, 2.92451948e-01f, 2.81683832e-01f, 6.72104210e-03f, -1.74416870e-01f,
  -1.25808388e-01f, 2.82705612e-02f, 7.08462372e-02f, -2.54487731e-02f, 7.11140260e-02f, -6.63228258e-02f, 3.17871660e-01f, 1.51247591e-01f, 1.12300791e-01f, 4.41920161e-02f,
  -7.13820457e-02f, 3.17456648e-02f, -7.83557817e-02f, -6.21823743e-02f, 2.19880164e-01f, -2.23629370e-01f, -1.36528760e-01f, 1.32315410e-02f, -3.30638625e-02f, -6.46250844e-02f,
  1.02312937e-01f, -1.30849645e-01f, 8.81984159e-02f, -3.54302898e-02f, 1.61994323e-02f, -1.93089962e-01f, 2.03357652e-01f, 3.37748267e-02f, 1.53805643e-01f, -2.07688272e-01f,
  1.19762132e-02f, 1.23055488e-01f, 1.47753432e-01f, 1.40416265e-01f, 1.13454629e-02f, 2.70399693e-02f, 6.48291856e-02f, -4.92193326e-02f, -1.45436889e-02f, -1.39690593e-01f,
  -8.51780027e-02f, 8.69331956e-02f, 1.39050588e-01f, 1.13079347e-01f, -1.95649657e-02f, -1.01981185e-01f, 2.76808944e-02f, 4.99825776e-02f, -3.41934673e-02f, -1.19412966e-01f,
  -6.35745898e-02f, -1.91799864e-01f, -2.06750482e-02f, 7.20796287e-02f, -3.85401361e-02f, -4.30095978e-02f, -5.53989001e-02f, -6.81276247e-02f, 1.93658397e-01f, -1.02766929e-03f,
  -3.36881131e-02f, -9.90606844e-02f, 5.20733260e-02f, -6.31548166e-02f, -1.55679137e-01f, -3.85266244e-02f, -2.58610874e-01f, 1.92442760e-02f, 1.46681024e-02f, 4.47129533e-02f,
  -3.58045772e-02f, 4.67856735e-01f, -3.36425930e-01f, -7.96022117e-02f, -1.04494188e-02f, 9.08721909e-02f, -1.22182786e-01f, -4.93730828e-02f, 1.24661006e-01f, -1.69142082e-01f,
  -6.68000728e-02f, -2.19613373e-01f, -2.92165577e-03f, 1.76821817e-02f, -2.07541063e-01f, -1.20769501e-01f, 1.17957564e-02f, -6.46121353e-02f, -7.31857941e-02f, -1.39457807e-01f,
  1.27359733e-01f, -3.24195176e-01f, -2.32852936e-01f, -1.12986840e-01f, -3.20981473e-01f, -3.11384827e-01f, -1.99836224e-01f, -2.40546346e-01f, -1.17944479e-01f, -2.49162629e-01f,
  -8.67266178e-01f, 2.76426822e-01f, 1.83416158e-01f, -3.46107453e-01f, -1.09569602e-01f, -6.38672858e-02f, -5.09081781e-03f, -3.38788331e-02f, -9.39573273e-02f, 2.88447678e-01f,
  1.17818065e-01f, -1.69524714e-01f, -1.26060799e-01f, -1.15448646e-01f, -3.56219381e-01f, 3.29038613e-02f, -1.49302572e-01f, -4.60967213e-01f, -6.49095774e-01f, -2.49828145e-01f,
  -3.53174269e-01f, -5.25032222e-01f, -6.13715410e-01f, -2.26012543e-01f, 8.93461797e-03f, -1.87368006e-01f, 7.69695267e-04f, -2.06671834e-01f, -1.06762536e-01f, 3.25367562e-02f,
  2.07309872e-01f, -3.53254080e-02f, -1.30851537e-01f, -2.05263630e-01f, 4.20325920e-02f, -5.00628874e-02f, -6.14169464e-02f, 7.17277601e-02f, 2.06332635e-02f, 1.30432144e-01f,
  -6.67187721e-02f, -2.20197774e-02f, -5.49125262e-02f, 7.09722340e-02f, -7.38826916e-02f, -5.30584902e-02f, 1.57072380e-01f, 4.11173254e-02f, 9.69807580e-02f, 2.86826968e-01f,
  9.20565426e-02f, -5.61674200e-02f, 6.26484975e-02f, 1.99805275e-01f, 2.10292593e-01f, 1.22454399e-02f, 1.32690713e-01f, 1.04331270e-01f, 1.03506066e-01f, 1.09238416e-01f,
  -1.02946218e-02f, -9.85584571e-04f, 4.98308148e-03f, 4.81300130e-02f, -6.48313165e-02f, 5.92143722e-02f, 1.90373939e-02f, -8.47689882e-02f, -5.29239811e-02f, -4.06210311e-02f,
  7.83131421e-02f, 4.20288034e-02f, -3.24200862e-03f, -7.44370371e-03f, 2.05755644e-02f, -6.83555454e-02f, -1.75617430e-02f, 7.14121982e-02f, 5.33090681e-02f, -7.28123933e-02f,
  1.62091833e-02f, 5.68512268e-02f, 9.84642562e-03f, 3.58851105e-02f, 2.00526357e-01f, 8.23353529e-02f, 5.61166778e-02f, 3.37748416e-02f, -4.25488912e-02f, 6.38318211e-02f,
  7.50460774e-02f, -1.65457681e-01f, 3.68438698e-02f, -8.02396238e-02f, 6.34216294e-02f, 9.90268737e-02f, 9.41292122e-02f, 8.92722383e-02f, -1.70170199e-02f, 7.67246038e-02f,
  2.19601337e-02f, -9.65369493e-02f, 5.72180375e-02f, 4.21447679e-02f, -1.01892732e-01f, -1.29100725e-01f, 3.42730246e-02f, -3.01569924e-02f, 1.38900757e-01f, 3.38292271e-01f,
  2.49189839e-01f, 8.52792040e-02f, -1.26616925e-01f, 6.70718700e-02f, 6.81902021e-02f, -1.54136240e-01f, 1.28696963e-01f, 1.05879933e-01f, 1.05404099e-02f, -1.57490894e-02f,
  2.67687738e-01f, -7.47081414e-02f, -6.96574688e-01f, -8.15501362e-02f, -2.89905310e-01f, -2.35455260e-01f, 1.24291852e-02f, 2.10406840e-01f, 1.92817569e-01f, -4.73079868e-02f,
  6.79955706e-02f, 5.93556203e-02f, -3.43629688e-01f, -2.35629961e-01f, -2.25130585e-03f, -2.43556872e-01f, -3.67675871e-01f, -2.55286634e-01f, -8.18962418e-03f, 2.41438821e-01f,
  3.47374380e-01f, 2.68643409e-01f, 2.21250743e-01f, 5.89869265e-03f, -7.66916722e-02f, -8.27318728e-02f, -2.77304143e-01f, -1.47513032e-01f, -1.09049700e-01f, -3.89271498e-01f,
  -5.07980466e-01f, -1.79800466e-01f, -1.13966987e-01f, 8.09706971e-02f, -1.26470283e-01f, 2.35413730e-01f, -2.53128987e-02f, -1.44758567e-01f, -5.83229959e-02f, -1.92170411e-01f,
  -7.48471990e-02f, 4.94906344e-02f, -7.57594630e-02f, 7.13413872e-04f, 3.18675674e-02f, 1.10358670e-01f, -3.54625061e-02f, -3.11529506e-02f, -1.99671924e-01f, 6.61774203e-02f,
  4.96047996e-02f, -1.32234469e-01f, -3.50536495e-01f, -1.26623958e-01f, -2.54701346e-01f, -1.87399119e-01f, -2.10153878e-01f, -3.09598874e-02f, -1.62261367e-01f, -8.36842433e-02f,
  6.15073703e-02f, -7.57723600e-02f, 1.59292724e-02f, 7.17897937e-02f, 2.23120436e-01f, 1.24722077e-02f, -2.21218616e-01f, -1.18471198e-01f, 2.22845487e-02f, -2.18859389e-02f,
  -1.04195081e-01f, -2.73464806e-02f, -6.99005052e-02f, -1.10427134e-01f, -2.46017113e-01f, -8.16317126e-02f, -1.44040182e-01f, -2.17182841e-02f, 3.93352732e-02f, -3.55103053e-02f,
  -1.99116413e-02f, -2.83814706e-02f, -5.00538275e-02f, -2.76221093e-02f, -2.07891762e-02f, 4.27152887e-02f, -2.82060243e-02f, -8.62590317e-03f, -4.87027876e-02f, 1.19558036e-01f,
  1.57932252e-01f, -1.91914186e-01f, -1.12725042e-01f, 2.97538769e-02f, -4.68679778e-02f, -2.41497029e-02f, -3.66099994e-03f, -1.44285271e-02f, -2.81406306e-02f, -4.88089584e-02f,
  -9.24657136e-02f, 8.16664547e-02f, -5.96139207e-02f, -9.97213088e-03f, -1.01968099e-03f, 6.39041588e-02f, 2.53257036e-01f, -1.12520128e-01f, 8.63774419e-02f, 1.46920651e-01f,
  2.69135255e-02f, 1.17426448e-01f, 6.65157214e-02f, -8.23588297e-02f, 6.71829656e-02f, -2.34675650e-02f, -1.71247125e-01f, 6.23308942e-02f, -1.66557357e-01f, 2.27522612e-01f,
  -4.79200453e-01f, 2.61897057e-01f, 1.90532461e-01f, -2.28511959e-01f, 2.53000617e-01f, 3.36050093e-01f, 5.13648093e-01f, 1.30690947e-01f, -1.14565901e-01f, 1.78676099e-02f,
  -2.05763113e-02f, -3.27563107e-01f, -2.37960517e-01f, -2.60971617e-02f, -5.23328371e-02f, 1.79706201e-01f, 1.93118170e-01f, 9.05726179e-02f, -1.46747112e-01f, -1.03370115e-01f,
  -4.90977131e-02f, -1.73656434e-01f, -2.35941917e-01f, -2.17230082e-01f, -1.56533554e-01f, -1.88671842e-01f, 4.79354598e-02f, 1.63054779e-01f, 1.08682558e-01f, -9.52873453e-02f,
  3.36303145e-01f, 2.37120479e-01f, -4.91685793e-02f, -2.31713522e-03f, 4.45595086e-02f, 3.75182815e-02f, 4.57384437e-02f, -2.79008504e-02f, 4.35910299e-02f, 8.78328159e-02f,
  7.80250952e-02f, 1.27592221e-01f, 1.18072489e-02f, 1.41715258e-01f, 1.68694988e-01f, 8.58529136e-02f, 3.57937403e-02f, 6.32143244e-02f, 1.42564535e-01f, 1.78002805e-01f,
  7.83368349e-02f, 2.36220434e-01f, 1.29403234e-01f, 9.34812129e-02f, 6.13025203e-03f, 4.52032685e-02f, 7.18200058e-02f, 9.85730365e-02f, 6.48521781e-02f, -1.23773806e-01f,
  -3.60480957e-02f, 2.15930771e-02f, 1.04719691e-01f, -4.27580886e-02f, 3.03873476e-02f, 2.50742678e-02f, 4.76662815e-03f, 3.80896851e-02f, -4.79835197e-02f, -8.95785764e-02f,
  8.56316555e-03f, 1.25481427e-01f, 3.87241989e-02f, -6.91043735e-02f, -3.35026486e-03f, 1.71220854e-01f, 3.28219086e-02f, 6.85360730e-02f, 5.61869927e-02f, 1.30090088e-01f,
  -6.49095105e-04f, 1.18972227e-01f, 6.40685782e-02f, 1.18097246e-01f, 1.47203684e-01f, 1.70377661e-02f, 7.24118799e-02f, 4.42585982e-02f, 3.26354131e-02f, -8.10230598e-02f,
  8.32794234e-02f, 3.10415357e-01f, -1.58474699e-01f, -1.95280492e-01f, -2.45187785e-02f, 4.46690917e-02f, -2.02690676e-01f, -1.11874707e-01f, 7.07082301e-02f, 7.44455457e-02f,
  5.24525531e-03f, -8.20446461e-02f, -2.58917324e-02f, -6.13726936e-02f, -6.99658915e-02f, -5.60326055e-02f, -4.90455404e-02f, -1.05842009e-01f, -3.71638052e-02f, 6.62436858e-02f,
  6.14490621e-02f, -2.17951015e-02f, -9.60970819e-02f, -9.02266055e-02f, -1.70836553e-01f, -1.30351901e-01f, -9.40349624e-02f, 2.03142837e-02f, 1.68906190e-02f, -1.32155776e-01f,
  -5.19611120e-01f, -6.96618557e-02f, 2.95768648e-01f, -4.14039493e-01f, -2.75334325e-02f, -1.86470691e-02f, -1.90607652e-01f, -1.09197602e-01f, -1.59158185e-01f, -7.13633299e-02f,
  1.65516645e-01f, 9.96579006e-02f, 1.19044065e-01f, 3.34416926e-02f, -4.43858474e-01f, -3.83981377e-01f, -1.89835802e-01f, -2.32870817e-01f, -5.74010350e-02f, -9.59029980e-03f,
  -1.83519319e-01f, -1.59843773e-01f, -1.03000842e-01f, 2.60558147e-02f, -3.68478186e-02f, 1.02256350e-02f, 1.99153736e-01f, 7.96407983e-02f, 8.14918652e-02f, 9.08135548e-02f,
  1.33334339e-01f, -4.32456210e-02f, 2.49205932e-01f, -8.63418430e-02f, 1.21736601e-01f, -1.80203822e-02f, 7.41256215e-03f, 1.97345167e-01f, 4.16332036e-02f, -3.03741675e-02f,
  6.58545122e-02f, 6.15897365e-02f, -9.99282375e-02f, 8.87311697e-02f, -3.29746259e-03f, -6.96970820e-02f, 3.45736975e-04f, -1.10417753e-01f, -7.65152723e-02f, -5.91443591e-02f,
  -1.39726713e-01f, -6.93832859e-02f, -9.54714492e-02f, 5.90381995e-02f, 1.08312361e-01f, -8.00819770e-02f, 2.44818121e-01f, 2.19822824e-01f, 2.15385959e-01f, 5.59063777e-02f,
  9.55365822e-02f, 6.12541884e-02f, 1.79729592e-02f, -5.27679361e-03f, -9.31082815e-02f, 1.64948314e-01f, 1.07224278e-01f, 1.11169368e-01f, -2.23025400e-02f, -3.32544148e-02f,
  8.77817571e-02f, 9.56483781e-02f, 3.49434093e-02f, 7.52922520e-02f, 9.39975902e-02f, -1.61389401e-03f, -6.78282231e-02f, -4.55025956e-03f, -3.46148983e-02f, 1.04813641e-02f,
  -4.15425599e-02f, 7.35689253e-02f, 2.87782494e-02f, -3.90214403e-03f, -1.30950600e-01f, -4.67745587e-02f, 3.16297263e-02f, 1.28139123e-01f, 8.53103548e-02f, -1.14738382e-01f,
  1.00890353e-01f, 1.10536903e-01f, -1.44917816e-01f, 1.12271614e-01f, -7.98819736e-02f, 7.81938508e-02f, -1.35659222e-02f, 8.01138133e-02f, 3.70986238e-02f, -2.25063283e-02f,
  5.29373065e-02f, -9.11232457e-03f, -5.12397140e-02f, 6.55707866e-02f, -8.79365355e-02f, -8.88966545e-02f, -2.74112880e-01f, -6.70457184e-02f, -1.32525846e-01f, -5.39272204e-02f,
  -2.76950151e-01f, -2.61336684e-01f, -4.45078552e-01f, -1.67777121e-01f, 3.64662381e-03f, -1.81670770e-01f, 6.67942166e-02f, 3.03982981e-02f, -6.12647943e-02f, -3.23442400e-01f,
  5.95007837e-01f, -1.89747244e-01f, -2.73854703e-01f, -8.50544423e-02f, -1.79802611e-01f, -7.40096942e-02f, -6.47180304e-02f, -9.17192101e-02f, -6.92283511e-02f, -7.43357092e-02f,
  -1.62209854e-01f, -3.17727476e-02f, -1.36870360e-02f, -1.70028880e-01f, 2.30447203e-02f, -3.00325155e-01f, -2.64403701e-01f, -2.76736803e-02f, -4.87016840e-03f, -3.26464535e-03f,
  -7.00568184e-02f, -1.16168372e-01f, 3.34381103e-03f, -8.89014974e-02f, -2.72096008e-01f, -1.08325921e-01f, -2.27655202e-01f, -1.30505919e-01f, -2.46233493e-01f, -2.98180550e-01f,
  -4.99833196e-01f, -1.43681049e-01f, 1.02383450e-01f, -4.09136564e-02f, 3.66260409e-02f, 1.26202181e-01f, -4.93056513e-02f, 6.23703413e-02f, 2.04322919e-01f, 1.82430769e-04f,
  7.61069125e-03f, -2.60530300e-02f, -3.33915316e-02f, 1.10378176e-01f, 9.48965997e-02f, 4.78149839e-02f, 7.92905837e-02f, 1.11247614e-01f, -6.51570857e-02f, -4.24268171e-02f,
  -6.85096979e-02f, 7.40087479e-02f, 1.36779144e-01f, 1.68704435e-01f, 3.98748415e-03f, 3.26273665e-02f, 3.74731459e-02f, 8.91290382e-02f, 8.82489383e-02f, 2.21043274e-01f,
  -4.62369882e-02f, 2.22535267e-01f, -1.35070812e-02f, 1.29425019e-01f, 2.38426343e-01f, 1.70530707e-01f, 1.19892724e-01f, 1.55805364e-01f, 1.22236438e-01f, 6.89731464e-02f,
  -9.05450433e-02f, -1.69915393e-01f, 1.03548713e-01f, -1.53975040e-02f, -1.67123690e-01f, -9.68570635e-02f, -4.73068580e-02f, 2.13192105e-02f, -9.35550854e-02f, -4.47579511e-02f,
  6.95166236e-04f, -9.30744484e-02f, -1.53674632e-01f, -9.20764357e-02f, -1.72082543e-01f, 8.18363726e-02f, -1.47569537e-01f, -2.89341286e-02f, -9.36022848e-02f, -2.17035085e-01f,
  -2.47397900e-01f, -2.00735420e-01f, -5.88512495e-02f, -6.47838190e-02f, 5.06321937e-02f, 3.11899967e-02f, -1.47378370e-01f, -1.09726958e-01f, 3.85286920e-02f, -1.08225539e-01f,
  6.83257356e-02f, -4.79166359e-02f, -6.00256734e-02f, -7.22661689e-02f, 1.60027742e-01f, 7.65207633e-02f, 1.16947338e-01f, 1.61885127e-01f, -1.38320237e-01f, -6.67773262e-02f,
  5.17714843e-02f, 2.07796469e-01f, 1.27301365e-01f, 2.04115734e-01f, 2.06781700e-01f, 1.25148728e-01f, 7.18726814e-02f, 5.61965965e-02f, 1.80940717e-01f, 2.51411170e-01f,
  4.00022894e-01f, -1.32777184e-01f, -5.85314691e-01f, 2.56071538e-01f, -3.97199184e-01f, -3.08948100e-01f, -2.40405306e-01f, 4.76888083e-02f, 2.63340771e-01f, -1.31749257e-01f,
  -1.21203527e-01f, 1.32878527e-01f, -1.57350320e-02f, -9.03600082e-02f, -5.10214828e-02f, -1.30237579e-01f, -2.66500562e-01f, -2.88625538e-01f, -6.57334179e-02f, -8.30587298e-02f,
  4.77229357e-02f, 1.89096555e-01f, 2.48906091e-01f, -4.67531616e-03f, 3.14561091e-03f, -2.46034060e-02f, -2.66821414e-01f, -1.62740424e-01f, -3.24251980e-01f, -3.20635825e-01f,
  -1.93484992e-01f, -1.94804460e-01f, -2.23424166e-01f, 1.58563375e-01f, -7.86831453e-02f, -5.11740660e-03f, -3.00062243e-02f, 2.33464912e-02f, 1.59573793e-01f, -2.00700737e-03f,
  -8.39482620e-02f, -5.26583940e-03f, 3.79703008e-02f, -1.12182647e-02f, 3.11196540e-02f, 2.93448810e-02f, -1.81222141e-01f, -6.94822893e-02f, -1.39469817e-01f, -1.05176941e-01f,
  7.82427490e-02f, -2.33326375e-01f, -1.85873196e-01f, -2.00648770e-01f, -1.70658767e-01f, -1.88682407e-01f, -1.68263584e-01f, -4.19264510e-02f, -2.40997553e-01f, 5.49125522e-02f,
  1.02257967e-01f, 2.99800243e-02f, -1.86980799e-01f, 3.84177677e-02f, 7.13264868e-02f, 1.80227458e-02f, 7.60323703e-02f, 4.86012809e-02f, 1.26325518e-01f, 6.88075423e-02f,
  -3.40518877e-02f, 4.54745963e-02f, -1.03224115e-02f, 1.89092327e-02f, 4.53789383e-02f, 4.41129319e-02f, 2.80126790e-03f, -3.81292924e-02f, 6.00273833e-02f, 1.47829220e-01f,
  8.32375064e-02f, -6.41549528e-02f, 5.92809319e-02f, 7.02558607e-02f, -1.56365871e-01f, 1.27950162e-01f, 9.26201344e-02f, 5.67804724e-02f, 7.65922815e-02f, 3.05538531e-03f,
  4.20509785e-01f, -2.87431985e-01f, 2.13400528e-01f, 9.87811685e-02f, -1.07571915e-01f, 4.71855737e-02f, 6.48248047e-02f, 1.11742653e-01f, 1.25851989e-01f, 1.12856984e-01f,
  -1.16117597e-02f, 2.85847038e-01f, 9.24255848e-02f, -3.83793786e-02f, -1.54094736e-03f, -3.24363448e-02f, 4.35351068e-03f, -8.47174600e-02f, 1.15943491e-01f, 1.80696040e-01f,
  1.58798054e-01f, 5.61274029e-02f, 1.77816615e-01f, -3.15428488e-02f, 6.91570863e-02f, -6.38362914e-02f, 1.05503656e-01f, 1.14243403e-01f, -1.72620844e-02f, 3.39946389e-01f,
  4.01081145e-01f, 1.60490900e-01f, -1.33763224e-01f, 2.60234535e-01f, 1.90615669e-01f, 9.98353958e-02f, 1.34421200e-01f, 1.44478858e-01f, 2.11251915e-01f, 2.37291172e-01f,
  1.41880646e-01f, 2.64589578e-01f, 2.09974632e-01f, 1.02254130e-01f, -3.47764194e-02f, 5.24820238e-02f, 3.36455135e-03f, 4.50415164e-02f, -6.70131668e-03f, 1.47656173e-01f,
  3.45606893e-01f, 2.48506114e-01f, 1.92736000e-01f, 1.61958724e-01f, 3.24224830e-01f, 2.19458804e-01f, 1.52623907e-01f, 1.11184366e-01f, 1.41424313e-01f, 1.93804115e-01f,
  -6.99366555e-02f, 1.50887489e-01f, -4.72191535e-02f, 3.12573798e-02f, -9.86540243e-02f, -8.35452899e-02f, 1.29170865e-02f, -7.58744925e-02f, 4.90439944e-02f, -4.61686626e-02f,
  -7.61625776e-03f, 7.37118572e-02f, 1.78735316e-01f, 9.13107470e-02f, 3.10331136e-02f, 1.55613991e-03f, -1.50833232e-02f, -1.46967977e-01f, -1.58149600e-01f, -9.79513377e-02f,
  2.19057247e-01f, 3.50546427e-02f, -1.99835330e-01f, -1.20883070e-01f, -8.61884654e-02f, -7.25228712e-02f, -9.56771672e-02f, 5.97781269e-03f, -7.10796192e-02f, -3.85060278e-03f,
  3.14896964e-02f, -7.16945529e-02f, 1.10262439e-01f, 2.16648325e-01f, 1.46760628e-01f, -1.04316818e-02f, -6.22783266e-02f, 6.97196499e-02f, 7.28253573e-02f, -1.42608071e-03f,
  -1.53985858e-01f, -1.17803896e-02f, -1.11842141e-01f, 1.09420024e-01f, 1.62997112e-01f, 2.04348303e-02f, -1.17059322e-02f, -3.54679823e-02f, 4.43535931e-02f, -1.26495168e-01f,
  6.65466413e-02f, -1.22771114e-01f, -6.14535734e-02f, -1.18426047e-01f, -1.39040630e-02f, 3.67291085e-02f, 1.68629527e-01f, 7.18128532e-02f, 6.40126243e-02f, 2.35253528e-01f,
  -2.47775167e-01f, -6.37539327e-02f, 1.30559772e-01f, 8.55982862e-03f, -1.34785235e-01f, -5.04304562e-03f, 4.92311530e-02f, -2.06938908e-01f, -6.91059604e-02f, -7.62923211e-02f,
  1.97311025e-02f, -7.15623721e-02f, -5.27500845e-02f, -9.29078460e-02f, 4.21635620e-02f, -7.05841184e-02f, -1.02024153e-01f, -1.28587350e-01f, -1.43839374e-01f, -2.12624937e-01f,
  -1.22633018e-01f, -1.49230361e-01f, -2.18763143e-01f, -2.36451358e-01f, -3.28187868e-02f, 1.27330897e-02f, -1.35076433e-01f, -1.74426883e-02f, -1.82183087e-01f, -1.86491143e-02f,
  5.31233132e-01f, 3.02639842e-01f, 8.93476382e-02f, -1.14864133e-01f, -5.60830116e-01f, -4.69967276e-01f, -2.71300137e-01f, 4.93316054e-02f, -5.49962148e-02f, 7.44959759e-03f,
  -3.28647971e-01f, -3.59511942e-01f, 8.07394907e-02f, -1.13842331e-01f, 1.60636246e-01f, 2.83690393e-01f, 2.11690679e-01f, 2.39366129e-01f, -2.32199848e-01f, -2.71239340e-01f,
  -2.72386193e-01f, -7.18142241e-02f, 1.01448566e-01f, 1.35942593e-01f, 1.02403060e-01f, -9.59145203e-02f, 7.23714754e-02f, 9.20944288e-03f, -9.46816131e-02f, 3.15537572e-01f,
  7.55383521e-02f, 1.69525579e-01f, -1.64768189e-01f, -3.10254097e-03f, -1.38378754e-01f, 1.46494403e-01f, -2.69612744e-02f, 2.01550126e-02f, -6.51788935e-02f, 6.43037930e-02f,
  -1.28317088e-01f, -1.31940529e-01f, -1.31251678e-01f, -8.11764225e-02f, -1.09423876e-01f, -1.24142088e-01f, 1.39083415e-01f, 1.33801982e-01f, 1.53657096e-02f, 8.96930769e-02f,
  -1.84008136e-01f, -2.51204908e-01f, -5.30969873e-02f, -1.14674337e-01f, -5.80709726e-02f, -1.67126104e-01f, -1.12919010e-01f, 2.25057676e-02f, 7.34671345e-03f, 2.70525247e-01f,
  4.59183194e-02f, 1.30275801e-01f, -5.06068580e-02f, -5.96821830e-02f, -1.16319075e-01f, -2.04520330e-01f, -2.71947589e-02f, 1.03279762e-01f, -1.11338854e-01f, -4.28237244e-02f,
  -1.18621275e-01f, -7.45456815e-02f, -1.07295856e-01f, -5.82087040e-02f, 8.28638524e-02f, 4.79970351e-02f, -1.11549117e-01f, 2.84946710e-02f, -5.23416474e-02f, -6.80271611e-02f,
  -1.12413570e-01f, -9.70405042e-02f, -1.39589995e-01f, 5.68410084e-02f, 5.57193458e-02f, 2.96294354e-02f, -6.99053258e-02f, -9.81411859e-02f, 5.41740768e-02f, -2.34610308e-02f,
  -1.75434396e-01f, -2.95694202e-01f, -3.68136130e-02f, 1.80893585e-01f, 1.27608389e-01f, 9.02625993e-02f, 9.26417038e-02f, -3.22019774e-03f, -9.95777175e-02f, 6.55036466e-03f,
  9.29519068e-03f, 2.61575673e-02f, 6.96759447e-02f, 1.08961411e-01f, -2.06434429e-01f, -1.66552767e-01f, -9.88683384e-03f, -1.38748698e-02f, -6.85090339e-03f, 8.43578801e-02f,
  3.77804898e-02f, -3.99841554e-02f, -1.08568318e-01f, 3.70879173e-02f, -5.23758009e-02f, -1.65773854e-01f, -1.18348058e-02f, -2.21148115e-02f, -6.73736110e-02f, 1.20644979e-01f,
  3.90052229e-01f, 1.37851939e-01f, 2.55383939e-01f, 3.93209718e-02f, 1.86546952e-01f, 1.67385265e-01f, 2.46889055e-01f, 2.07456261e-01f, 2.39166664e-04f, 9.61949304e-02f,
  1.05234481e-01f, -5.39727397e-02f, -2.54321955e-02f, -6.42766878e-02f, 7.46939704e-02f, 1.59593031e-01f, 4.77700904e-02f, 1.20383911e-01f, 1.03449903e-01f, 4.30667251e-02f,
  -6.06178166e-03f, 4.93519828e-02f, 1.18001714e-01f, 1.35524228e-01f, 6.28827745e-03f, 2.00446844e-02f, 1.28373485e-02f, 5.50322421e-02f, 6.62522241e-02f, -2.28087120e-02f,
  -1.38197273e-01f, 2.17590004e-01f, -3.93344536e-02f, -7.91830942e-02f, -2.34745257e-02f, -4.53563593e-02f, 4.21978831e-02f, -1.02997042e-01f, -7.60776177e-02f, -4.33491692e-02f,
  2.27144845e-02f, -3.96442004e-02f, 5.53848185e-02f, 2.35546473e-02f, -1.99739560e-02f, 7.66260847e-02f, 4.80340049e-02f, 2.61613578e-02f, 4.85286005e-02f, 3.03532556e-02f,
  -6.95203766e-02f, 9.51683708e-03f, 6.30427748e-02f, 1.05770767e-01f, 8.29743817e-02f, 2.39266809e-02f, 1.01875514e-01f, 3.27100046e-02f, -6.14699535e-02f, 5.44515736e-02f,
  1.14203572e-01f, 2.02640429e-01f, 7.87010193e-02f, 1.75559241e-02f, 6.91064969e-02f, 4.11154516e-03f, 1.42178526e-02f, 4.16301042e-02f, 2.42713273e-01f, 2.09529355e-01f,
  1.26312271e-01f, 1.39763311e-01f, 7.63769597e-02f, 2.82549020e-02f, -1.11793794e-01f, -1.09848700e-01f, -5.57733327e-02f, -6.83794767e-02f, 7.53071010e-02f, -5.42865209e-02f,
  1.09638907e-01f, 1.32057026e-01f, -8.46129283e-03f, 1.55609936e-01f, -8.95735323e-02f, 3.49497907e-02f, -5.32076582e-02f, 6.30758405e-02f, 8.15526247e-02f, 3.37525085e-02f,
  -4.13788944e-01f, 6.90104589e-02f, -7.66950399e-02f, -1.24874584e-01f, 3.45030911e-02f, -4.49531935e-02f, -4.64524291e-02f, -1.15330249e-01f, -2.93554962e-01f, -1.98434681e-01f,
  -6.51467443e-02f, -3.02285720e-02f, -2.66899504e-02f, 1.21657178e-01f, 2.13644523e-02f, -9.74461883e-02f, -5.41511774e-02f, -4.40557860e-02f, -1.34492114e-01f, -2.26615459e-01f,
  -7.53768459e-02f, -1.05376080e-01f, -1.47497833e-01f, -3.74246910e-02f, -1.88147631e-02f, -8.77155364e-02f, -1.00632906e-01f, 3.41231078e-02f, -4.56426442e-02f, -5.66815957e-02f,
  -4.00239140e-01f, -1.84598431e-01f, -3.72800469e-01f, -5.14300540e-02f, 9.54076797e-02f, -7.35730529e-02f, -2.81247407e-01f, 8.19777474e-02f, 1.21752962e-01f, -3.50084268e-02f,
  4.58569862e-02f, 1.77391231e-01f, 3.34871188e-02f, 1.25387385e-01f, -4.39258013e-03f, -1.68912888e-01f, 6.02663793e-02f, -3.57705429e-02f, 3.42403091e-02f, 2.93218553e-01f,
  2.54370123e-01f, 1.03870921e-01f, 3.64451371e-02f, 1.73706472e-01f, 2.01114550e-01f, 1.27993986e-01f, -3.31382900e-02f, 4.63330075e-02f, -9.45771709e-02f, 2.40709893e-02f,
  -3.43649954e-01f, -3.49620953e-02f, -4.90566576e-03f, 1.37487784e-01f, 6.88689854e-03f, -6.93020523e-02f, 1.37527958e-02f, 2.46246979e-02f, -1.29014645e-02f, -1.90596227e-02f,
  1.00629499e-04f, 9.07919407e-02f, 1.13994829e-01f, 1.30934969e-01f, 1.20098047e-01f, -1.42148184e-02f, -1.16382793e-01f, -3.46237272e-02f, -2.47546539e-01f, 3.19870338e-02f,
  1.73874810e-01f, 1.55269518e-01f, -2.04630926e-01f, -1.78135321e-01f, -1.00321993e-01f, 7.74056911e-02f, -9.98996422e-02f, -8.69387388e-02f, -2.01202378e-01f, -2.28353664e-01f,
  6.20890185e-02f, 7.26601481e-02f, -1.79595381e-01f, -1.27721608e-01f, 8.27055797e-03f, -5.59450164e-02f, -1.43413041e-02f, -3.37521471e-02f, 4.47855284e-03f, -5.75371832e-02f,
  -4.42953967e-02f, -1.26448154e-01f, 6.38160631e-02f, 1.18202362e-02f, 1.00157686e-01f, -8.65057632e-02f, 1.33122616e-02f, -6.31446242e-02f, 1.09976232e-02f, -9.68730077e-02f,
  -4.11740318e-02f, -7.86114782e-02f, -4.02097329e-02f, 1.01134174e-01f, -2.37430837e-02f, -1.05709404e-01f, -2.92435978e-02f, -9.32887718e-02f, -6.05776645e-02f, -1.73666969e-01f,
  -1.21962823e-01f, -7.75180310e-02f, -9.39638391e-02f, 1.43061697e-01f, 4.22264934e-02f, 6.86318502e-02f, -6.88449442e-02f, -1.38716981e-01f, -5.79420365e-02f, -2.38010623e-02f,
  -8.90122578e-02f, -1.17805809e-01f, 1.60361584e-02f, -1.42194524e-01f, 5.48464479e-03f, -5.14052249e-02f, -1.48328498e-01f, -1.21851169e-01f, -1.76923394e-01f, 1.06673852e-01f,
  -4.36871238e-02f, -5.61251156e-02f, -1.68455482e-01f, -2.74820477e-01f, -8.47460255e-02f, -4.94826511e-02f, -1.44633636e-01f, -5.82667552e-02f, -2.53242731e-01f, -3.39300603e-01f,
  -9.54230189e-01f, 2.36323792e-02f, 6.96405843e-02f, -8.86921585e-01f, -3.28369945e-01f, -3.24003026e-02f, 1.44537734e-02f, -2.72803754e-01f, -6.28870785e-01f, -2.92153358e-01f,
  8.98801759e-02f, 2.60209411e-01f, 1.71737392e-02f, 2.48124376e-01f, 1.72754437e-01f, -1.52241394e-01f, -2.66165346e-01f, -1.02027029e-01f, 3.14664066e-01f, 2.39795059e-01f,
  7.68244714e-02f, -1.64755359e-01f, -3.15518439e-01f, -1.39418155e-01f, -1.36818364e-01f, 7.91634247e-03f, -5.48971817e-02f, -8.34235474e-02f, 5.55986837e-02f, -2.56600797e-01f,
  5.25185347e-01f, -2.78986007e-01f, -5.03151082e-02f, -5.28054833e-02f, -3.56644914e-02f, -1.21804461e-01f, -1.72091536e-02f, -1.47907659e-01f, -1.32409111e-01f, -1.49261132e-01f,
  -1.23334698e-01f, -6.93150982e-02f, -1.10103101e-01f, 4.55758013e-02f, -1.80092975e-02f, -8.20387825e-02f, -6.85202777e-02f, 1.81956720e-02f, -9.55088735e-02f, 1.24841660e-01f,
  5.62286340e-02f, 1.75529579e-03f, 1.34509802e-01f, 1.85172379e-01f, 3.68558802e-02f, -5.10838814e-02f, 7.62326047e-02f, -2.15621516e-02f, -9.71881300e-03f, 1.17600635e-02f,
  7.95936957e-03f, 1.17690891e-01f, -1.08123701e-02f, 1.42255835e-02f, 9.83645301e-03f, -6.83407411e-02f, 2.26908829e-02f, 1.76503994e-02f, 1.38832703e-01f, 1.01805776e-01f,
  -1.40649214e-01f, -6.69172257e-02f, 5.22852829e-03f, -1.18117398e-02f, 1.03594335e-02f, -2.13560164e-02f, -8.16106703e-03f, 7.57591277e-02f, -3.18305157e-02f, -1.09319821e-01f,
  -1.15023032e-01f, -3.63121070e-02f, -1.01430364e-01f, 6.04626015e-02f, -1.23128640e-02f, -1.38374701e-01f, -1.82951421e-01f, 9.58223417e-02f, 1.14970282e-01f, -7.71729229e-03f,
  1.32963419e-01f, -2.09913328e-01f, -5.62645420e-02f, 1.80484317e-02f, -9.27522331e-02f, 1.21700475e-02f, -1.13480829e-01f, -9.73030254e-02f, -1.29611701e-01f, 9.83933266e-03f,
  1.17596993e-02f, 1.29339676e-02f, 1.91934425e-02f, 8.16132501e-02f, 1.97249441e-03f, 4.82340828e-02f, -1.86694954e-02f, -2.74988059e-02f, -3.68395485e-02f, 8.56747571e-03f,
  -2.85451598e-02f, 4.20593977e-04f, 8.31831992e-02f, 1.57236829e-01f, -1.66588221e-02f, 9.39209238e-02f, 2.13561729e-01f, 1.50483683e-01f, 5.64310849e-02f, -7.84018263e-03f,
  1.57026887e-01f, 2.09803030e-01f, -3.56977463e-01f, 9.94044095e-02f, -2.22221658e-01f, -2.39002764e-01f, 4.06346433e-02f, -2.45542880e-02f, -1.49737708e-02f, 2.33372346e-01f,
  -1.04049765e-01f, -2.34612152e-01f, -6.81079850e-02f, -1.69831097e-01f, -4.41198349e-02f, 1.59060255e-01f, -2.16818973e-03f, -2.33596697e-01f, -4.83726740e-01f, -2.44349435e-01f,
  7.37340525e-02f, 8.63204747e-02f, 2.38535013e-02f, -6.81214035e-02f, 7.10193440e-02f, 1.39543209e-02f, 7.13494942e-02f, -4.44615595e-02f, -9.05280486e-02f, 1.08757019e-01f,
  -1.28066897e-01f, -2.64318198e-01f, 3.59741747e-02f, 8.32915190e-04f, 5.54175265e-02f, 6.20464273e-02f, -2.64361873e-02f, -2.39455570e-02f, 7.18821166e-03f, 2.34450009e-02f,
  -1.31039517e-02f, -2.30611220e-01f, -1.69009998e-01f, -7.94312507e-02f, -7.16043115e-02f, -1.42846033e-01f, 5.04115596e-03f, -1.30700305e-01f, -5.18833958e-02f, -1.51034147e-01f,
  -1.22628830e-01f, -1.77878052e-01f, -1.43504500e-01f, 5.45826890e-02f, -2.78968304e-01f, -1.78953007e-01f, -7.51185566e-02f, -2.31359243e-01f, -1.78120777e-01f, 2.18474463e-01f,
  5.09465225e-02f, 6.12098947e-02f, -3.11079863e-02f, 6.02408983e-02f, 1.68539450e-01f, 1.76907685e-02f, -3.37159187e-02f, -3.27768736e-02f, -1.22275844e-01f, 7.86511321e-03f,
  5.99601269e-02f, -5.68918623e-02f, -5.80264553e-02f, 6.50463924e-02f, 3.65897990e-03f, -1.11333959e-01f, 4.25228588e-02f, 1.53314129e-01f, 4.48283739e-03f, 8.05613101e-02f,
  -6.76274523e-02f, -6.60890639e-02f, -4.79701534e-02f, 4.25327495e-02f, -9.08962488e-02f, -1.39040530e-01f, -2.75329892e-02f, -1.05122201e-01f, -2.45254710e-02f, -2.05045827e-02f,
  4.11453456e-01f, -1.10013008e-01f, 2.94024080e-01f, 1.11276090e-01f, -2.23793704e-02f, 9.40643903e-03f, -8.97115916e-02f, 1.26163997e-02f, -5.21440059e-02f, -1.16954170e-01f,
  -2.73368210e-01f, -1.30637899e-01f, -1.40278801e-01f, 2.96722837e-02f, -3.09707294e-03f, -2.03754008e-02f, 1.94954336e-01f, -8.43248330e-03f, -8.05463418e-02f, -2.23366749e-02f,
  4.12984826e-02f, 1.33281767e-01f, 2.78757334e-01f, 1.56227365e-01f, 1.11538805e-02f, 1.99810043e-01f, 1.58893824e-01f, 8.54508132e-02f, -1.36658037e-02f, 4.42828357e-01f,
  3.39851826e-01f, 4.35146183e-01f, -2.18027741e-01f, 1.57860070e-01f, 1.56801105e-01f, 1.35195985e-01f, 2.02863783e-01f, 1.34327725e-01f, 1.51363313e-01f, 2.47475520e-01f,
  2.37504989e-01f, 1.44802913e-01f, 8.09973702e-02f, 1.78886000e-02f, -1.01185322e-01f, -6.19508103e-02f, -9.53490958e-02f, -1.07532732e-01f, -6.89259022e-02f, 1.76101938e-01f,
  2.24749967e-01f, 1.88261345e-01f, 1.86315283e-01f, -5.23768272e-03f, 1.61789268e-01f, -8.85718223e-03f, 1.07531101e-01f, 8.25496614e-02f, 2.60800980e-02f, 1.02109928e-02f,
  -3.06137443e-01f, 2.20181912e-01f, -3.23964506e-01f, 6.09859526e-02f, -7.92053491e-02f, 5.97694293e-02f, 1.12323118e-02f, 8.82197767e-02f, 2.92098150e-02f, 5.06698601e-02f,
  -6.38263300e-02f, 1.30481318e-01f, 1.99733123e-01f, 5.56085818e-02f, -4.60352842e-03f, -5.85428625e-03f, 6.38458282e-02f, -1.04576692e-01f, -1.32176787e-01f, -1.70126166e-02f,
  1.68715909e-01f, 1.42490968e-01f, -1.57652199e-01f, -6.59032241e-02f, -1.27893165e-01f, -1.88132748e-01f, -7.39934519e-02f, -6.91612288e-02f, -9.92961302e-02f, 6.39473228e-03f,
  3.58533747e-02f, -5.72129339e-02f, -1.17682278e-01f, -2.35902034e-02f, 3.66864167e-02f, -8.08912218e-02f, -6.71793669e-02f, -1.20646082e-01f, -4.85207066e-02f, 3.25139984e-02f,
  -8.41648951e-02f, -8.45295638e-02f, -4.34031300e-02f, 2.06620190e-02f, 1.03254929e-01f, 2.69848052e-02f, -6.03014901e-02f, -9.27734822e-02f, -4.06899787e-02f, -1.79807916e-02f,
  8.25238451e-02f, -1.76957756e-01f, -5.61071075e-02f, -1.72057115e-02f, -1.54761761e-01f, -1.00370891e-01f, 3.91631238e-02f, 5.16137183e-02f, 1.02068141e-01f, 2.51096904e-01f,
  3.38365026e-02f, 3.58514898e-02f, -2.33148396e-01f, 3.50616407e-03f, -1.22772187e-01f, -3.24117988e-02f, 7.45833218e-02f, -1.18082955e-01f, -5.01033477e-02f, 2.49203853e-02f,
  3.01225763e-02f, -1.23851836e-01f, 3.65925878e-02f, -2.06589662e-02f, -1.05294950e-01f, -1.05239913e-01f, -8.25585797e-02f, -1.67471558e-01f, -1.00017764e-01f, -2.33363003e-01f,
  -3.43241617e-02f, -1.18414067e-01f, -1.40937105e-01f, -2.30385244e-01f, -4.38775010e-02f, -1.45540074e-01f, -1.18105389e-01f, -9.31900591e-02f, -1.22107849e-01f, -1.09853679e-02f,
  -1.77407011e-01f, 3.22700113e-01f, 9.05764922e-02f, -3.38503495e-02f, 1.51725858e-01f, 2.74741463e-02f, 1.52193531e-01f, 7.18223304e-02f, -8.65689293e-02f, 9.03331786e-02f,
  -2.91709881e-02f, -9.77895930e-02f, 3.69276293e-02f, 3.99093293e-02f, 2.18681972e-02f, 1.46910742e-01f, 2.42580116e-01f, 1.69987296e-04f, -2.83977002e-01f, -1.31979004e-01f,
  -1.11718297e-01f, -1.09820776e-01f, -2.04618618e-01f, -9.88342334e-03f, 1.80983454e-01f, -6.66608661e-02f, 6.99186549e-02f, 3.22941840e-02f, 1.74452469e-01f, 3.86402130e-01f,
  -8.32018349e-03f, 8.62847120e-02f, -3.91448349e-01f, -9.76399183e-02f, -4.08490598e-02f, -2.48547066e-02f, -6.49935901e-02f, -1.09701149e-01f, -6.79621696e-02f, -8.02626684e-02f,
  1.46656796e-01f, 1.10069767e-01f, 1.57221198e-01f, 1.56895339e-01f, -1.03356361e-01f, -1.83243603e-01f, 7.00126067e-02f, -6.61368519e-02f, -4.67520282e-02f, -1.46182897e-02f,
  1.48496076e-01f, -3.82494740e-02f, -1.30999042e-02f, 4.90493216e-02f, -3.27667706e-02f, -1.28517419e-01f, -5.17039783e-02f, -6.79877326e-02f, -1.71549067e-01f, 4.68216464e-02f,
  -2.47395679e-01f, -8.58698338e-02f, 9.14853886e-02f, -8.17627162e-02f, -3.23458165e-02f, 2.75072902e-02f, 3.97949815e-02f, 1.18901804e-01f, -1.01760752e-01f, 6.81394106e-03f,
  -9.18071419e-02f, -1.56719536e-01f, -8.35226476e-02f, -9.10678431e-02f, -6.36902303e-02f, 5.75738661e-02f, -7.33177969e-03f, -1.27711380e-02f, -1.41690359e-01f, 1.20723797e-02f,
  5.13425544e-02f, 4.78637628e-02f, -5.77447079e-02f, -5.18829525e-02f, -4.83963527e-02f, -3.73962633e-02f, -1.68384835e-01f, -2.00130984e-01f, -1.35104433e-01f, -4.94854059e-03f,
  -7.55159929e-02f, -1.96893871e-01f, -1.45210832e-01f, 2.22373202e-01f, 2.12634236e-01f, 4.87799272e-02f, 1.17817536e-01f, 6.90322816e-02f, 1.54932976e-01f, -5.09771332e-02f,
  1.12760469e-01f, -2.51795277e-02f, 1.32479578e-01f, 1.00246137e-02f, -1.46104738e-01f, -1.37946263e-01f, -3.97074707e-02f, 2.40221191e-02f, 1.61452629e-02f, 1.30995989e-01f,
  1.79866523e-01f, -1.90014377e-01f, -1.32648125e-01f, -2.03130860e-03f, -6.94510713e-02f, -3.09981823e-01f, -1.72029778e-01f, -1.13095552e-01f, -1.88840717e-01f, -3.12749445e-01f,
  -1.24213003e-01f, 3.13594878e-01f, 2.83313781e-01f, -4.05862331e-01f, 1.78888842e-01f, 2.49151692e-01f, 3.21419537e-01f, 8.68129283e-02f, -7.17229545e-02f, 1.05758622e-01f,
  3.62269878e-01f, 3.15129720e-02f, -1.27759144e-01f, -6.64226487e-02f, -1.99511647e-01f, -2.88523678e-02f, -2.62208790e-01f, -2.13483155e-01f, -2.71393955e-01f, -4.10212800e-02f,
  -1.79098457e-01f, -1.69440180e-01f, -2.24722326e-01f, -1.89306423e-01f, -2.31354013e-01f, -1.78489193e-01f, 3.06706969e-02f, -3.55768390e-02f, -4.32222746e-02f, -2.87296772e-01f,
  -9.56404582e-03f, 1.86088353e-01f, 1.98881906e-02f, -6.01696894e-02f, 1.52477995e-01f, -5.73664941e-02f, 3.57152037e-02f, -1.22772378e-03f, -1.36237722e-02f, 5.31814136e-02f,
  1.69141158e-01f, 1.54838696e-01f, -1.50343195e-01f, -8.90016854e-02f, -4.99069840e-02f, -2.17841864e-02f, 1.19666696e-01f, -9.51150283e-02f, -7.29702860e-02f, 8.79821405e-02f,
  -1.63133547e-01f, 1.19634345e-01f, 2.67273355e-02f, 1.71213374e-02f, 6.11669756e-03f, -2.30373964e-01f, -3.93937668e-03f, -9.62649435e-02f, -2.05514356e-02f, -2.52632707e-01f,
  9.73787308e-02f, 4.72691730e-02f, -8.12048186e-03f, 1.49024772e-02f, -9.03294161e-02f, 3.93948518e-02f, -8.68939087e-02f, 8.75632558e-03f, 4.40046471e-03f, -2.77740695e-02f,
  1.31081775e-01f, 2.78870821e-01f, 3.80674191e-02f, 9.50404778e-02f, -5.62247597e-02f, 2.62769982e-02f, -3.60292643e-02f, -2.48858053e-02f, 1.80469286e-02f, -4.31036651e-02f,
  -1.32444263e-01f, 8.57905075e-02f, 2.83403527e-02f, -1.05786197e-01f, -4.07198183e-02f, -8.72339606e-02f, 4.47262041e-02f, -2.34706737e-02f, -4.70699184e-02f, 1.34236366e-01f,
  -3.50825101e-01f, 2.01288447e-01f, -8.48358050e-02f, -3.14275436e-02f, 6.06497340e-02f, -8.71948339e-03f, -2.08222270e-02f, 8.20865408e-02f, 5.53455800e-02f, 3.47828306e-02f,
  2.28762105e-01f, -1.09584481e-02f, -8.18137750e-02f, 9.44270100e-03f, -1.34111447e-02f, -6.19432889e-02f, -1.00244939e-01f, -3.67620289e-02f, -1.19186848e-01f, -3.82007509e-02f,
  -2.36382455e-01f, -1.51089147e-01f, -3.61653000e-01f, -1.73181787e-01f, -1.28887668e-01f, -2.47655660e-01f, -2.02982202e-01f, -2.33880520e-01f, -1.82197765e-01f, -3.49407226e-01f,
  4.34526920e-01f, -1.09293289e-01f, 1.15805067e-01f, 4.74782556e-01f, -6.91722473e-03f, -4.63407516e-01f, -5.80055594e-01f, -5.08530676e-01f, 3.94343063e-02f, 1.40627578e-01f,
  1.57196537e-01f, 5.91915958e-02f, 6.12295568e-02f, -1.85467944e-01f, -4.68145251e-01f, -2.52185971e-01f, -9.11732484e-03f, -8.53869617e-02f, -4.35460478e-01f, -3.15721810e-01f,
  -1.64245948e-01f, 6.99459463e-02f, -5.20932190e-02f, 1.95317753e-02f, 3.80651325e-01f, 5.92127182e-02f, 1.89702734e-01f, 2.17193156e-01f, -1.16700875e-02f, 3.58750314e-01f,
  3.58182698e-01f, 2.03595594e-01f, -1.81415588e-01f, 4.90602367e-02f, 1.55414477e-01f, -3.85635085e-02f, -6.51742220e-02f, 5.70197068e-02f, 8.35921708e-03f, 5.17646112e-02f,
  2.05123663e-01f, -3.17596979e-02f, 1.65917173e-01f, -4.67438996e-02f, -9.33673531e-02f, -2.35139251e-01f, -8.20939466e-02f, -1.64558500e-01f, -1.03634238e-01f, -4.31611575e-02f,
  -9.37353149e-02f, 1.50965080e-01f, 4.77822646e-02f, -1.48853436e-01f, -9.99736488e-02f, 1.36904791e-01f, -6.22810051e-02f, 2.61447895e-02f, -2.67060608e-01f, 1.19975232e-01f,
  -2.01205760e-02f, 2.74248179e-02f, 2.69506127e-02f, 2.30193641e-02f, -6.04656301e-02f, -1.68488212e-02f, 8.28464478e-02f, -7.76026305e-03f, -8.05089548e-02f, -8.08203444e-02f,
  -8.10443386e-02f, -1.89501774e-02f, 8.05977806e-02f, 6.31144568e-02f, -4.76088896e-02f, 1.30910287e-02f, -9.93024483e-02f, -6.00904413e-02f, 2.02706158e-02f, -5.34683019e-02f,
  -3.66159081e-02f, 7.93900117e-02f, 1.52474180e-01f, 3.48542980e-03f, -6.52665496e-02f, -5.56489266e-02f, 5.03555387e-02f, -1.08143128e-02f, 9.56934225e-03f, 2.32277401e-02f,
  -4.93833721e-02f, -2.64845878e-01f, 1.59834474e-01f, -9.04931724e-02f, 3.15126702e-02f, 2.28308178e-02f, 1.55189693e-01f, -4.02391665e-02f, 1.20917737e-01f, -1.44698113e-01f,
  -1.56460688e-01f, -6.56146482e-02f, 1.57665104e-01f, -6.46166876e-02f, -1.21686593e-01f, -1.19830947e-02f, -1.43221304e-01f, -8.94629657e-02f, -1.63022593e-01f, -4.07807790e-02f,
  -1.37827486e-01f, -3.85493249e-01f, -2.19756261e-01f, -2.44823307e-01f, 1.05070407e-02f, -4.97444384e-02f, -2.03217387e-01f, -1.57906890e-01f, -3.72133404e-01f, -3.07955295e-01f,
  6.91355109e-01f, -1.69443130e-01f, 4.02241081e-01f, 1.38393059e-01f, 2.04063922e-01f, 3.55241388e-01f, 2.46658012e-01f, 1.41941637e-01f, 7.24443421e-02f, 1.49992436e-01f,
  -1.38842285e-01f, -1.12542450e-01f, 2.15541162e-02f, -1.37353670e-02f, 9.23681408e-02f, 9.29605812e-02f, 2.09913179e-01f, 3.42198402e-01f, 2.86664277e-01f, 2.32239440e-01f,
  3.87116931e-02f, 9.44534764e-02f, 1.50736779e-01f, 5.60754389e-02f, 2.34060623e-02f, -4.45181765e-02f, 6.66247681e-02f, 7.85686895e-02f, -9.09388959e-02f, -1.16107114e-01f,
  -2.39403546e-02f, 1.15964331e-01f, -2.62932945e-02f, -2.38610059e-01f, -1.45385787e-01f, -1.36388093e-01f, -4.87389080e-02f, -1.07885465e-01f, -9.13500339e-02f, -2.75095310e-02f,
  -4.44944724e-02f, -6.71253726e-02f, -1.97415184e-02f, -1.11259423e-01f, 3.80576588e-02f, 2.52441241e-04f, 6.12703785e-02f, 1.21718615e-01f, -4.35692593e-02f, 7.54867028e-03f,
  -1.93063289e-01f, 1.38279395e-02f, 4.05963100e-02f, 7.35092461e-02f, 1.11418396e-01f, -7.70195201e-02f, -8.66150856e-02f, -6.91414177e-02f, 1.10415958e-01f, 1.17454290e-01f,
  -7.80921653e-02f, 1.32599249e-01f, 3.38838175e-02f, 6.98364452e-02f, 6.27869219e-02f, 8.78944173e-02f, 6.89662760e-03f, -5.53540550e-02f, 5.53178489e-02f, -2.21438729e-03f,
  -9.09268670e-03f, 4.68403324e-02f, 1.20330930e-01f, -7.96280615e-03f, -2.50480361e-02f, -1.13831051e-01f, -3.44676292e-03f, -8.10897946e-02f, 4.49386165e-02f, 5.96565474e-03f,
  7.06518963e-02f, 1.41035067e-03f, 6.89090565e-02f, 5.72138932e-03f, -5.79996333e-02f, 1.18622435e-02f, 1.06134839e-01f, -9.87301990e-02f, -5.69726378e-02f, -7.65828192e-02f,
  -4.42422509e-01f, 1.04243375e-01f, 3.89005505e-02f, -4.29728590e-02f, -8.52321908e-02f, -4.20370921e-02f, 2.18323562e-02f, -4.06924039e-02f, -1.06710799e-01f, 3.91376466e-02f,
  -1.01283163e-01f, -6.47850856e-02f, -5.25935516e-02f, 2.70675421e-02f, 1.15981586e-01f, -6.99958578e-02f, -1.27077058e-01f, -8.77764300e-02f, -9.45377797e-02f, -1.94181636e-01f,
  -8.04866850e-02f, -3.43244784e-02f, -6.37884438e-03f, 6.56718165e-02f, -1.17165647e-01f, -6.78221881e-02f, 1.89559869e-02f, 5.94887175e-02f, -9.20492969e-03f, 2.04175897e-02f,
  3.83933991e-01f, -2.22032323e-01f, 1.52504191e-01f, -1.49347216e-01f, -3.85587692e-01f, -4.07167912e-01f, -5.71487486e-01f, -3.56387466e-01f, -1.19604483e-01f, -1.16700530e-01f,
  -3.22812319e-01f, 6.06421987e-03f, 4.15812470e-02f, 1.75629213e-01f, 3.59542370e-02f, -1.91972293e-02f, 1.47149771e-01f, 3.28316689e-01f, 3.23749691e-01f, -1.95188522e-02f,
  -5.13402969e-02f, 1.20177284e-01f, 3.63052070e-01f, 1.84989646e-01f, 1.20591268e-01f, 8.92362297e-02f, 8.87641683e-02f, 1.31542057e-01f, 1.37339411e-02f, 2.84809530e-01f,
  2.50613123e-01f, 1.12718984e-01f, 1.53792739e-01f, 1.47966474e-01f, 9.93462205e-02f, 1.34303197e-01f, 8.60716999e-02f, 9.71873924e-02f, -7.63209909e-02f, -6.90106228e-02f,
  1.04788654e-01f, 1.89798623e-02f, -2.55200528e-02f, -3.54644507e-02f, 5.28949872e-02f, -2.56514195e-02f, 5.03906049e-02f, 4.26371209e-02f, -2.93949395e-02f, -7.91089833e-02f,
  -2.84306798e-02f, -1.53322563e-01f, -1.91878289e-01f, -1.37233764e-01f, 4.84057963e-02f, 4.96495143e-02f, 3.78232822e-02f, 6.18898831e-02f, -1.45347398e-02f, 2.11425358e-03f,
  6.39006644e-02f, -7.80461282e-02f, 4.57536243e-02f, -7.85144344e-02f, -8.38974416e-02f, -1.96066592e-02f, -1.67251769e-02f, -2.02271819e-01f, -3.18478681e-02f, 3.67827676e-02f,
  -4.96909097e-02f, -3.72280590e-02f, -1.03948452e-01f, 3.64803150e-02f, 1.11510441e-01f, -5.53914197e-02f, 6.92583174e-02f, 4.95884754e-02f, 1.56912267e-01f, -4.27613501e-03f,
  6.07240871e-02f, -6.51407987e-02f, 1.47117674e-01f, 8.69007558e-02f, 6.56044930e-02f, -4.83563691e-02f, 1.23117961e-01f, -7.52280727e-02f, 5.11007234e-02f, -3.42134349e-02f,
  -2.33131707e-01f, 9.96872708e-02f, 2.46270075e-01f, 1.03341736e-01f, 7.46762156e-02f, 1.66972637e-01f, 1.06644772e-01f, 6.55578524e-02f, 8.20561647e-02f, 3.84337939e-02f,
  1.54560292e-02f, 2.24566296e-01f, -1.43351564e-02f, 6.22565625e-03f, 3.38630229e-02f, 1.67645197e-02f, 4.01983224e-02f, -6.68310523e-02f, -2.90965140e-02f, -9.16742283e-05f,
  -7.96515793e-02f, -2.83905298e-01f, -1.97363541e-01f, -1.47260085e-01f, -4.74986024e-02f, -1.09124314e-02f, -3.50272208e-02f, 5.68793677e-02f, 2.27375161e-02f, -2.00153723e-01f,
  -6.16518199e-01f, -1.49368376e-01f, -3.12533677e-01f, -2.49589652e-01f, 2.69613087e-01f, 3.62191759e-02f, -7.40614831e-02f, -1.75945014e-01f, -4.15629745e-02f, -8.75058696e-02f,
  2.93960124e-02f, 1.78169861e-01f, 6.49624169e-02f, 1.74498588e-01f, 1.24625087e-01f, -4.72910376e-03f, 2.26778790e-01f, 8.04004744e-02f, 7.83654451e-02f, 2.47320503e-01f,
  2.55496919e-01f, -4.35022525e-02f, -8.98976922e-02f, 1.15587823e-01f, 7.71500394e-02f, 1.33524388e-01f, -4.09764349e-02f, 6.88944906e-02f, 1.31690785e-01f, 1.07057713e-01f,
  -3.10245365e-01f, -3.20292532e-01f, 1.63071394e-01f, 1.75761521e-01f, 7.32845962e-02f, -1.47263959e-01f, 1.16809048e-02f, -1.60656258e-01f, -5.08070737e-02f, -8.13798904e-02f,
  3.26892175e-02f, -5.62733114e-02f, 1.68563247e-01f, -7.31880292e-02f, -5.21103963e-02f, -8.20824206e-02f, -9.57199112e-02f, -1.49487495e-01f, -3.00598145e-01f, -1.43866047e-01f,
  3.78262758e-01f, 7.09300265e-02f, -1.55727103e-01f, 5.03591895e-02f, -1.79053739e-01f, 3.28168236e-02f, -1.75710827e-01f, -1.36516646e-01f, -2.78411329e-01f, -3.31664622e-01f,
  -6.31174669e-02f, 2.08865982e-02f, -2.35656109e-02f, -1.15342513e-01f, 4.68523577e-02f, 2.82963924e-02f, 3.50715071e-02f, 1.06264822e-01f, 1.40164182e-01f, -4.67412286e-02f,
  -2.14884640e-03f, -5.16180545e-02f, 8.88641253e-02f, -6.25034645e-02f, 9.95719731e-02f, 4.64738496e-02f, -1.16306162e-02f, -1.50252162e-02f, 3.29453349e-02f, -6.33420274e-02f,
  -1.87988635e-02f, -1.15010403e-01f, -1.55617138e-02f, 9.25594121e-02f, -2.00645812e-02f, -6.58545867e-02f, -8.87153447e-02f, -7.26979449e-02f, 8.41007289e-03f, -8.97542909e-02f,
  -2.46787518e-01f, 1.68927670e-01f, -1.26233414e-01f, 2.48454679e-02f, 5.20056933e-02f, 3.09228078e-02f, 9.83427018e-02f, -7.44314259e-03f, -1.90965638e-01f, -1.27783686e-01f,
  -1.48855537e-01f, -1.80934504e-01f, -1.05285108e-01f, 5.11124788e-04f, -1.21938691e-01f, -3.11844852e-02f, 5.87880872e-02f, 9.01993830e-03f, 2.73307748e-02f, 3.82560976e-02f,
  3.51687409e-02f, 1.87074989e-02f, -1.31950200e-01f, -7.36569166e-02f, -1.01034632e-02f, -7.52337202e-02f, -1.25956386e-01f, -1.35602325e-01f, -2.82461226e-01f, -3.97485435e-01f,
  3.39352697e-01f, -7.69451186e-02f, -6.29754782e-01f, -3.51420224e-01f, -3.27757388e-01f, -2.14323044e-01f, -2.27208212e-01f, 1.24191623e-02f, -3.02171521e-02f, -2.29066044e-01f,
  -8.93757939e-02f, 3.85755077e-02f, -1.42156407e-01f, -6.66443855e-02f, -2.95727607e-03f, -3.05286974e-01f, -3.60578239e-01f, -3.22222412e-01f, -1.54412314e-01f, -7.64425322e-02f,
  -1.78725738e-02f, -2.38095462e-01f, -3.90984155e-02f, -1.55407891e-01f, -1.49142817e-01f, -8.44052732e-02f, -4.15858984e-01f, -2.59977430e-01f, -2.28780985e-01f, -3.29420596e-01f,
  -4.41088378e-01f, -1.99631695e-02f, -3.00710090e-02f, 1.48385853e-01f, -1.61257803e-01f, 1.23929530e-01f, 4.32156362e-02f, -1.15731232e-01f, 8.49876702e-02f, 3.19220982e-02f,
  1.95793845e-02f, 4.89873886e-02f, -3.80447991e-02f, -6.50384128e-02f, 2.10148040e-02f, -7.98524693e-02f, 1.85668133e-02f, -5.70059614e-03f, -5.82448393e-02f, 2.23667417e-02f,
  5.76220825e-02f, 3.53106409e-02f, 1.36122987e-01f, 8.61815587e-02f, 1.09351855e-02f, 1.29971988e-02f, 4.04393533e-04f, 1.20633572e-01f, -1.02597252e-02f, 1.21271089e-02f,
  -5.13491258e-02f, -4.26000431e-02f, 1.10199777e-02f, -7.32564405e-02f, 8.87783468e-02f, -3.61504816e-02f, -5.14326282e-02f, 7.13169426e-02f, 8.16368014e-02f, -2.66924296e-02f,
  7.63825402e-02f, -2.98043131e-03f, -6.17420003e-02f, -2.15456486e-02f, -4.51321751e-02f, -1.97684187e-02f, 1.03785843e-01f, -2.00066157e-02f, 7.42055103e-02f, 5.85840791e-02f,
  1.66108057e-01f, -3.98959741e-02f, -2.39394582e-03f, -6.94253296e-03f, -8.65147188e-02f, -5.10935932e-02f, 1.08291265e-02f, 5.00817597e-02f, -2.83824634e-02f, 4.93360162e-02f,
  -1.96389407e-01f, 1.90635137e-02f, 4.76340987e-02f, 1.36717871e-01f, -9.62429643e-02f, 5.16298264e-02f, -4.53116857e-02f, 7.26933882e-04f, 2.42047329e-02f, -1.49524091e-02f,
  -3.11331581e-02f, -6.01519383e-02f, -2.12090947e-02f, 7.57528916e-02f, 1.00582493e-02f, 2.78918608e-03f, -2.35391222e-02f, 5.34474850e-02f, 5.68604970e-04f, -5.34731746e-02f,
  1.44938692e-01f, 1.52475283e-01f, 2.44306743e-01f, 1.64422557e-01f, 8.10295269e-02f, 7.18950778e-02f, 7.44287148e-02f, 4.64396551e-02f, 8.00105855e-02f, 9.72253978e-02f,
  -4.58889246e-01f, 1.31298646e-01f, -1.70798287e-01f, -1.81445748e-01f, -1.21665359e-01f, -3.04887205e-01f, -2.00373635e-01f, -3.07051271e-01f, -1.82678774e-01f, 1.41101241e-01f,
  2.07892060e-01f, 2.94457376e-01f, 1.61884129e-01f, -4.74047437e-02f, -1.81868479e-01f, -9.91492495e-02f, -3.30637425e-01f, -3.36844385e-01f, -1.71313435e-01f, 1.55082285e-01f,
  1.31007940e-01f, -3.50247435e-02f, -1.51797533e-01f, -9.59727392e-02f, 2.07095847e-01f, 1.56215578e-01f, 8.89871344e-02f, 2.47236770e-02f, -4.96281020e-04f, 2.02469125e-01f,
  2.84489036e-01f, -1.75585657e-01f, 8.70370492e-03f, -1.02972075e-01f, 1.12546608e-01f, -2.98617166e-02f, -6.63709119e-02f, -1.08550442e-02f, 5.26391417e-02f, 3.36974044e-03f,
  -1.00923227e-02f, -9.77638140e-02f, -1.11717880e-01f, 1.38340548e-01f, 8.03557634e-02f, 9.37220082e-02f, 8.56516659e-02f, 2.07923092e-02f, -5.65229766e-02f, 8.93895701e-03f,
  2.35670321e-02f, -1.38707623e-01f, -6.37136102e-02f, 6.30469397e-02f, -5.08244596e-02f, -1.13311931e-01f, 1.44407153e-01f, 9.48971789e-03f, -1.07511885e-01f, 1.41304389e-01f,
  -1.63466245e-01f, -4.12561372e-02f, 7.40556270e-02f, 9.18832943e-02f, -3.86702977e-02f, 6.63646236e-02f, 9.76551771e-02f, 3.77363414e-02f, -1.12175092e-01f, 9.45398659e-02f,
  1.81286290e-01f, -6.37473240e-02f, -1.18667178e-01f, 3.30183730e-02f, -1.61441490e-02f, -1.58896809e-03f, -1.04712248e-01f, 6.04105964e-02f, -1.80006772e-02f, 5.37863793e-03f,
  -8.39926377e-02f, 3.78696658e-02f, 3.37435156e-02f, 5.64595275e-02f, 6.47707060e-02f, 9.55097526e-02f, -1.06214307e-01f, 3.94557416e-03f, 9.13734827e-03f, -1.08776972e-01f,
  1.89496860e-01f, -3.88037235e-01f, -7.01410770e-02f, -1.26629099e-01f, -2.77587790e-02f, -3.68471108e-02f, -6.92599565e-02f, -1.48644391e-02f, 1.53028965e-01f, 1.37117937e-01f,
  -2.11813319e-02f, 5.45568727e-02f, 9.38524306e-03f, 8.57427120e-02f, -1.88146103e-02f, 1.11963935e-01f, 5.45923822e-02f, 1.82865970e-02f, 1.34123573e-02f, 1.44170970e-01f,
  7.81204328e-02f, -4.73955981e-02f, -4.94982824e-02f, 3.54683474e-02f, -8.47639889e-02f, 1.49227614e-02f, 1.89029694e-01f, 1.44966856e-01f, 2.25230977e-02f, 1.59937784e-01f,
  6.19188286e-02f, -3.61065745e-01f, -7.63132870e-02f, -7.03406930e-02f, -2.50076681e-01f, -1.22735910e-01f, -4.51817006e-01f, 5.17957695e-02f, 1.00134395e-01f, -5.27465165e-01f,
  -2.50414133e-01f, 2.97408849e-01f, 8.66584256e-02f, 1.86858699e-01f, 2.35574201e-01f, -4.35745448e-01f, -2.71238476e-01f, 2.32622564e-01f, 5.35539269e-01f, 1.97277650e-01f,
  -9.98097509e-02f, 1.42839849e-01f, 3.59140307e-01f, 1.90433949e-01f, -3.77827525e-01f, -7.02651963e-02f, -3.46079528e-01f, -8.18452090e-02f, -1.45450577e-01f, -5.36308587e-01f,
  -1.52172044e-01f, -6.73979819e-02f, 2.41175247e-03f, 7.77739193e-03f, -1.56126037e-01f, -2.02209055e-02f, -4.61161248e-02f, -1.39805432e-02f, 1.52693698e-02f, 6.66690664e-03f,
  1.90246632e-04f, 5.64478636e-02f, 9.94110331e-02f, -7.15047400e-03f, 2.34506540e-02f, 5.65792583e-02f, -2.71594077e-02f, 2.16506377e-01f, 4.89856526e-02f, -1.57089606e-01f,
  -1.27584785e-01f, -5.22290319e-02f, 2.55006086e-02f, -3.39587890e-02f, 4.23667207e-02f, 1.31656185e-01f, -9.64472517e-02f, 8.21254179e-02f, 1.18528105e-01f, -4.64866936e-01f,
  1.20919376e-05f, -8.36798549e-02f, -1.25477403e-01f, 3.20707187e-02f, -8.69767964e-02f, -9.66162011e-02f, -5.76312188e-03f, -4.94160540e-02f, -1.86108779e-02f, 9.92573425e-03f,
  2.64288876e-02f, -5.27220108e-02f, 2.32535284e-02f, -7.85389096e-02f, -6.51238263e-02f, 3.99203971e-02f, -4.64660302e-02f, -9.53939483e-02f, 7.43453875e-02f, 1.13808643e-02f,
  5.70166074e-02f, -6.20725658e-03f, -1.30303558e-02f, 7.30841756e-02f, -3.42775173e-02f, 1.60673141e-01f, 3.27814706e-02f, -4.73729614e-03f, 9.52642485e-02f, 1.06656872e-01f,
  8.38592499e-02f, 1.88460946e-01f, -3.09119165e-01f, 7.13426769e-02f, -8.85779113e-02f, 1.63977537e-02f, -7.29391575e-02f, -5.46683222e-02f, 8.99540111e-02f, 6.39907867e-02f,
  2.48808041e-02f, 4.07485738e-02f, 3.43214944e-02f, -7.36336857e-02f, 1.30280815e-02f, -6.40694401e-04f, -5.74220307e-02f, 4.97621372e-02f, 1.45148188e-01f, -1.12050049e-01f,
  -1.15737483e-01f, -3.33278179e-02f, -1.02951592e-02f, 3.52608860e-02f, -1.10444680e-01f, 9.21963975e-02f, -9.49111730e-02f, -8.06537494e-02f, 8.58946294e-02f, -3.28503966e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.69771510e-01f, -8.28443170e-02f, 1.48612693e-01f, 5.26378334e-01f, 3.79143894e-01f, 1.51244402e-01f, 4.45889801e-01f, 1.34228036e-01f, 1.16631530e-01f, 3.39951903e-01f,
  3.16035688e-01f, 1.98624745e-01f, -4.28904295e-02f, 1.96871981e-01f, 1.71460971e-01f, 7.11660367e-03f, 2.83192664e-01f, 4.49889481e-01f, 2.86070049e-01f, 3.70075464e-01f,
  2.28989705e-01f, 2.19463065e-01f, -3.65858898e-02f, 2.78906137e-01f, 4.53163505e-01f, 3.08722287e-01f, 1.69981435e-01f, 8.78750011e-02f, 2.80173928e-01f, 4.29122388e-01f,
  4.38117623e-01f, 2.32525453e-01f, 1.17859684e-01f, 6.90386966e-02f, 3.59157830e-01f, 2.73775816e-01f, 2.43107423e-01f, 1.02589451e-01f, 4.11659926e-01f, 8.54299366e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  2.67012101e-02f, 1.07594460e-01f, 6.55240566e-02f, 1.83042839e-01f, 6.55178353e-02f, 9.75743234e-02f, 8.56632292e-02f, 2.55152397e-02f, 4.86824699e-02f, -1.29320845e-01f,
  2.69275140e-02f, 1.30904227e-01f, -1.89478956e-02f, -1.14505149e-01f, 3.92054059e-02f, 5.11131436e-02f, -2.42450591e-02f, 1.50915742e-01f, 1.20504089e-01f, -1.79685831e-01f,
  1.34885967e-01f, 8.14271420e-02f, 1.62094999e-02f, 3.75432782e-02f, 1.83497425e-02f, 1.32203102e-01f, -1.08532898e-01f, -2.45437860e-01f, 5.73233590e-02f, 1.29482612e-01f,
  -2.29274228e-01f, 9.33555793e-03f, -6.83085769e-02f, 1.08713232e-01f, 1.80975959e-01f, -4.80994731e-02f, 2.50235070e-02f, 3.39387268e-01f, 2.22232416e-02f, 1.48938522e-01f,
  2.39053860e-01f, -3.24609391e-02f, -5.78852668e-02f, 1.33207858e-01f, -2.17376323e-03f, -1.71884611e-01f, 4.19165380e-02f, 2.86141127e-01f, -1.19519800e-01f, 1.70082569e-01f,
  6.54086992e-02f, 1.47585824e-01f, -4.04339433e-02f, -1.34493848e-02f, 5.44683002e-02f, -2.03398377e-01f, -2.23234326e-01f, 2.99002409e-01f, -1.09841116e-01f, 1.54141054e-01f,
  -1.06778771e-01f, 1.37630016e-01f, 1.77215129e-01f, 1.53551161e-01f, 1.86322071e-02f, -6.22863993e-02f, -4.05399017e-02f, 2.88293995e-02f, 5.44175431e-02f, 4.75024246e-02f,
  -7.49114901e-02f, 8.63199607e-02f, 1.32740632e-01f, -7.44201541e-02f, -5.43367863e-02f, -2.53634509e-02f, -5.75077087e-02f, -4.11957987e-02f, -2.76086815e-02f, 7.85891414e-02f,
  3.35028842e-02f, -1.63545743e-01f, -3.34627256e-02f, -4.73471396e-02f, 1.27327323e-01f, 7.84189180e-02f, 8.65374580e-02f, -6.75324053e-02f, -4.85943630e-02f, -3.77862193e-02f,
  1.60334244e-01f, 2.44475022e-01f, -2.94353485e-01f, -1.57961845e-01f, 3.14016908e-01f, -6.77603111e-02f, 3.25600237e-01f, -2.80282367e-03f, -1.01609923e-01f, 1.75853729e-01f,
  -1.28214389e-01f, -9.34085548e-02f, 8.92892033e-02f, 8.28126222e-02f, -6.05369778e-03f, 4.38712612e-02f, 1.98222268e-02f, 1.94888070e-01f, -1.77842036e-01f, 9.60477348e-03f,
  5.67131527e-02f, 8.37251097e-02f, -8.87162760e-02f, -2.66932905e-01f, -2.59587020e-01f, 1.42352074e-01f, 1.11911491e-01f, 5.65659301e-03f, 6.02365984e-03f, -1.06336132e-01f,
  -2.64638122e-02f, -2.79302925e-01f, -4.57751602e-02f, -2.56957531e-01f, 2.94322282e-01f, 3.69859822e-02f, -8.73584002e-02f, 1.41550809e-01f, 8.53457376e-02f, -1.08271455e-02f,
  -6.66519478e-02f, -5.16456552e-02f, 1.27091974e-01f, 6.29966632e-02f, 1.22198015e-01f, 2.77652368e-02f, -1.74594088e-03f, 1.52480960e-01f, 1.46576583e-01f, -2.09122356e-02f,
  9.93090644e-02f, -2.68606395e-01f, 1.48053497e-01f, -3.14841494e-02f, 2.48510242e-02f, -1.73904195e-01f, -1.30157337e-01f, -2.24245906e-01f, 5.29437512e-02f, -4.20772657e-02f,
  5.09676635e-02f, 1.19378217e-01f, 8.72192904e-02f, -1.19208038e-01f, 2.43508667e-02f, 1.86510496e-02f, -7.45708048e-02f, 1.05676629e-01f, 1.25037119e-01f, 4.67144139e-03f,
  2.57150363e-02f, 1.25184551e-01f, -2.56623119e-01f, 1.54904667e-02f, -7.06162974e-02f, 2.39538878e-01f, -6.69566020e-02f, 2.49470845e-02f, -3.44215892e-02f, 6.66716546e-02f,
  2.35173907e-02f, 1.54348537e-01f, 3.42327297e-01f, 4.84214984e-02f, 1.11547016e-01f, 6.29430041e-02f, -6.77851066e-02f, -1.51157707e-01f, -2.41945069e-02f, 1.26256803e-02f,
  1.37851790e-01f, 1.12677753e-01f, 4.09037583e-02f, -1.43709779e-01f, 4.92141619e-02f, -4.00762886e-01f, 8.37564096e-02f, -4.75494303e-02f, 1.12293705e-01f, 1.52088016e-01f,
  -2.58783028e-02f, 2.00952128e-01f, -1.18337668e-01f, 1.10233136e-01f, 1.03526264e-02f, 3.89829054e-02f, 6.62592333e-03f, 3.24415490e-02f, 1.08135454e-01f, -1.01724438e-01f,
  -1.28206491e-01f, -1.40840486e-01f, 1.82654545e-01f, 8.58434942e-03f, -1.36037171e-02f, -2.24683192e-02f, 3.84783670e-02f, -1.84152588e-01f, 9.80701670e-02f, -7.99879283e-02f,
  -1.50675848e-01f, -1.27133504e-01f, -2.76020635e-02f, 1.00113168e-01f, -8.21685493e-02f, 8.71954635e-02f, -1.69117704e-01f, 6.67330027e-02f, 1.05630003e-01f, -2.88789362e-01f,
  1.18376948e-01f, -7.68205449e-02f, -1.23654641e-01f, 8.37599710e-02f, -6.59343824e-02f, 4.33094539e-02f, -8.17560107e-02f, -2.02068478e-01f, 5.41032702e-02f, 2.31377468e-01f,
  1.95296049e-01f, -8.61571282e-02f, -5.52721471e-02f, 1.11729361e-03f, 2.42490709e-01f, 1.94556624e-01f, 3.01620979e-02f, 1.11771328e-02f, 1.03291275e-03f, 8.71702656e-02f,
  1.28869573e-02f, 1.86152965e-01f, 7.45137110e-02f, 1.93698257e-01f, 1.89771309e-01f, -6.19644336e-02f, -5.52834431e-03f, -2.54995465e-01f, -6.23765439e-02f, -2.77451426e-01f,
  1.57020614e-01f, -3.94245647e-02f, 1.75379124e-02f, 1.62630565e-02f, -5.49903549e-02f, 2.37562865e-01f, 3.17674428e-02f, -9.30672418e-03f, 1.74014658e-01f, 8.18002522e-02f,
  8.44653249e-02f, -2.60416362e-02f, -2.35013012e-02f, 4.46117446e-02f, 1.14774778e-01f, 1.45144179e-01f, -2.84711644e-02f, 1.51025221e-01f, 5.76050282e-02f, 1.68131456e-01f,
  -2.05251779e-02f, 7.07450584e-02f, -3.92297022e-02f, 2.08250493e-01f, 8.62740427e-02f, -3.24486122e-02f, 5.26337288e-02f, -5.51937707e-03f, 1.04171462e-01f, -1.49858212e-02f,
  2.62100548e-01f, -3.40520381e-03f, -1.45042345e-01f, 1.11345738e-01f, 2.68796921e-01f, -4.99500595e-02f, -2.64220148e-01f, -1.00928843e-01f, -1.27452761e-01f, 1.56079173e-01f,
  1.64276272e-01f, -1.45720541e-01f, 2.49501802e-02f, -1.62401631e-01f, -8.58645327e-03f, -6.11927509e-02f, -1.45022366e-02f, 7.19600730e-03f, -3.66410427e-02f, -1.02620028e-01f,
  -2.85537362e-01f, 1.08577713e-01f, 2.30603397e-01f, 2.18581006e-01f, -4.57827114e-02f, 1.58935934e-01f, -9.84722399e-04f, -1.79248765e-01f, 3.27653512e-02f, 2.34589398e-01f,
  -4.64081652e-02f, -3.20740715e-02f, -5.92752248e-02f, 2.35765576e-01f, 1.91091850e-01f, 2.42190629e-01f, -2.38323018e-01f, -2.05563411e-01f, 2.73619443e-02f, -1.57636538e-01f,
  -6.79319873e-02f, 4.08158824e-02f, 1.52733177e-02f, 7.33260885e-02f, -1.37200411e-02f, -1.41899973e-01f, 2.18967833e-02f, 1.09425187e-01f, 1.52847506e-02f, 8.99628177e-02f,
  -8.70434493e-02f, -6.21224828e-02f, -2.89649889e-02f, 1.35296524e-01f, -2.40938962e-01f, 5.71998395e-02f, 1.77851573e-01f, -5.43231405e-02f, -7.41560683e-02f, 3.33214134e-01f,
  1.29363596e-01f, 8.48133564e-02f, -1.23822100e-01f, -1.43083289e-01f, -1.59527078e-01f, 1.55228555e-01f, -1.54332861e-01f, -1.06536455e-01f, -4.01804447e-02f, -3.60977016e-02f,
  3.19139928e-01f, -1.76904649e-01f, 5.66485599e-02f, -9.37278643e-02f, 1.10015765e-01f, 2.21631318e-01f, 2.58389302e-02f, -2.19587713e-01f, 7.28552565e-02f, 6.88286126e-02f,
  1.80949017e-01f, 2.94719219e-01f, 2.24963337e-01f, -2.32211530e-01f, 7.97772557e-02f, 9.99536589e-02f, -4.84162122e-02f, -2.53885061e-01f, -1.80011109e-01f, 1.73676666e-02f,
  -7.47897401e-02f, 3.25066410e-02f, 1.89850077e-01f, -6.14562677e-03f, -4.03364860e-02f, 1.25841260e-01f, 6.30273223e-02f, 2.53309757e-01f, -1.64572984e-01f, 1.11001648e-01f,
  1.63403466e-01f, -1.16781421e-01f, 2.09916651e-01f, -1.28327876e-01f, 9.95684639e-02f, 7.64989927e-02f, 8.84541348e-02f, 1.34650066e-01f, 1.28281023e-02f, 1.37888595e-01f,
  3.61210555e-02f, 2.02877641e-01f, 6.36560051e-03f, 6.71170130e-02f, 3.83551829e-02f, 1.02892920e-01f, -1.92339439e-02f, -6.27637208e-02f, 1.60014346e-01f, -9.59152803e-02f,
  1.70548424e-01f, -4.48522065e-03f, 4.19875570e-02f, -2.67591536e-01f, -2.84936221e-04f, -1.16491646e-01f, 3.85155194e-02f, 1.28850137e-04f, -3.37890945e-02f, 8.91274586e-03f,
  2.15786383e-01f, -4.79728915e-02f, -7.05479365e-03f, 7.10587725e-02f, -1.47149384e-01f, 1.12355798e-01f, -9.98510420e-02f, -6.09479956e-02f, -1.99614484e-02f, -6.15670271e-02f,
  -9.72714350e-02f, -7.02594295e-02f, 1.14535689e-01f, -6.54583611e-03f, 1.79139987e-01f, -1.02571081e-02f, -2.71376316e-02f, 2.37002775e-01f, -3.80749583e-01f, -5.27354963e-02f,
  1.10821761e-01f, 1.45738721e-01f, 2.57642027e-02f, -2.45570704e-01f, 8.19606334e-02f, 1.70918971e-01f, -8.66920650e-02f, -2.48787878e-03f, 2.26730648e-02f, -2.07038105e-01f,
  1.81400590e-02f, 1.82454325e-02f, -9.23350379e-02f, 7.54681006e-02f, 8.77866372e-02f, 1.59136690e-02f, 1.54264316e-01f, 3.96004379e-01f, -1.43681347e-01f, -1.32403791e-01f,
  8.60748291e-02f, 2.29092315e-02f, -2.25260779e-02f, -1.07073650e-01f, -3.42418998e-02f, 2.39615347e-02f, -4.66805547e-02f, 3.58015820e-02f, -4.43177624e-03f, 1.66574582e-01f,
  5.39240204e-02f, 2.93454587e-01f, -2.11020097e-01f, 2.67749965e-01f, -7.36902952e-02f, 9.53022540e-02f, 1.72720432e-01f, 1.83382094e-01f, -1.23391733e-01f, -1.09876350e-01f,
  -1.33101836e-01f, -3.62903401e-02f, 1.56426430e-01f, -1.96401343e-01f, -3.10629278e-01f, -2.40349621e-01f, -7.19479993e-02f, -8.90205577e-02f, -9.18224826e-02f, -6.16499856e-02f,
  8.57647602e-03f, -8.44747499e-02f, 5.09169549e-02f, 1.80028051e-01f, -8.55826363e-02f, -5.18836007e-02f, -4.81036603e-02f, -8.28101262e-02f, 6.20556176e-02f, 2.99765766e-01f,
  4.91320267e-02f, 4.76456732e-02f, -2.99266186e-02f, -1.25022277e-01f, 2.47119945e-02f, 1.37727648e-01f, 1.30929708e-01f, 1.62289470e-01f, -5.92703074e-02f, -1.71508908e-03f,
  -2.02217311e-01f, 2.07395911e-01f, 1.76009551e-01f, 1.99036375e-01f, -1.19415335e-01f, 4.74195808e-01f, -9.77532119e-02f, -4.90548648e-02f, -1.89229831e-01f, 9.65207368e-02f,
  1.51215553e-01f, -2.61854708e-01f, -5.57667762e-02f, 9.51745287e-02f, -2.35669632e-02f, -7.58405700e-02f, -1.37395710e-01f, 5.52245863e-02f, -8.18400010e-02f, -1.00410238e-01f,
  -9.27280709e-02f, -1.44097803e-03f, 5.00025451e-02f, -5.81661686e-02f, 5.24972640e-02f, -1.60433874e-01f, -5.55297993e-02f, 8.96638259e-02f, -8.70921742e-03f, -1.95275739e-01f,
  -8.23531523e-02f, 7.58957788e-02f, 1.23180360e-01f, -7.29025230e-02f, 8.01805556e-02f, -7.43593350e-02f, -6.22280315e-02f, -1.74159184e-01f, -1.10452019e-01f, 3.04981232e-01f,
  -1.54580668e-01f, -6.44238815e-02f, 1.18436292e-01f, -1.72027901e-01f, 1.93009183e-01f, -1.38805419e-01f, -2.03863978e-01f, 3.31272751e-01f, -2.13705301e-01f, -3.63524668e-02f,
  1.84720367e-01f, -6.63778931e-02f, -2.47941747e-01f, -1.07521012e-01f, 7.88528174e-02f, 1.69250011e-01f, -6.04714174e-03f, 9.20201913e-02f, 5.33828437e-02f, 1.25429973e-01f,
  2.56458968e-02f, -1.33176759e-01f, 3.40314629e-03f, 8.68399665e-02f, 3.76474291e-01f, 1.04176909e-01f, 9.19100344e-02f, -2.11316749e-01f, 4.42782976e-02f, -2.09067360e-01f,
  -2.84354948e-02f, -1.86045930e-01f, 3.69178414e-01f, 3.09184641e-02f, 1.54686108e-01f, -2.26355717e-01f, 6.11743145e-02f, -5.12052216e-02f, -3.99669968e-02f, 4.31041121e-02f,
  1.23828888e-01f, 2.12229975e-02f, -4.05154303e-02f, -7.88994655e-02f, 1.50452871e-02f, -4.66661975e-02f, -6.85693845e-02f, -5.35557629e-04f, -1.04825467e-01f, -5.65242171e-02f,
  -1.18650598e-02f, 6.53860793e-02f, -4.46290299e-02f, -4.70291413e-02f, -2.53607286e-03f, 6.11525439e-02f, -1.28656134e-01f, 5.29113300e-02f, -1.13747410e-01f, 3.63154709e-02f,
  -2.54652556e-02f, -2.37474982e-02f, 1.09103516e-01f, 2.51384228e-01f, 1.36122644e-01f, 6.54345006e-02f, 1.82959259e-01f, -4.42609303e-02f, 3.43459211e-02f, 1.12512447e-01f,
  1.45346299e-01f, -6.35552108e-02f, 1.68332219e-01f, -5.39828278e-03f, 1.87846050e-02f, 6.61399588e-02f, 3.40692252e-02f, 1.12761691e-01f, -2.41541818e-01f, -1.96026817e-01f,
  1.10936888e-01f, -8.45925286e-02f, 1.41148224e-01f, -6.05305247e-02f, -9.67896804e-02f, 1.02465056e-01f, 6.40313998e-02f, -5.25686070e-02f, -1.60411432e-01f, -8.10841471e-02f,
  -2.04563722e-01f, 1.33068427e-01f, -1.08195350e-01f, -3.36807892e-02f, 1.21201485e-01f, 1.43466219e-01f, 1.30364642e-01f, -1.34716555e-01f, -1.92989618e-01f, 2.28963569e-02f,
  7.12940618e-02f, 5.95431179e-02f, 7.12254643e-02f, -3.50945145e-02f, -5.55128641e-02f, 7.28161409e-02f, -1.79844536e-02f, -1.90677732e-01f, -9.80012566e-02f, 1.23024598e-01f,
  7.08322003e-02f, -8.14241096e-02f, 1.32690117e-01f, 9.32878554e-02f, -1.29442334e-01f, 1.90550938e-01f, -1.59671009e-01f, -9.35849175e-03f, -5.96156418e-02f, -1.03096008e-01f,
  -8.42544362e-02f, -2.48289015e-02f, 8.12882632e-02f, 1.10944636e-01f, -1.55621395e-01f, 2.36552060e-01f, -2.29740947e-01f, 1.78202670e-02f, -6.27493784e-02f, 1.69422761e-01f,
  -1.19274929e-01f, -2.19046604e-02f, 7.33138174e-02f, -8.91981274e-02f, -9.43388715e-02f, 1.36230960e-02f, 9.60392430e-02f, 8.87349248e-02f, -4.46050242e-03f, -3.53440754e-02f,
  -1.39807314e-01f, 9.01591331e-02f, 4.85195033e-02f, -1.63489833e-01f, 6.23486415e-02f, -1.18832268e-01f, 2.80007981e-02f, 9.15902853e-02f, -1.07456014e-01f, 1.82873547e-01f,
  -6.28330708e-02f, -1.34282485e-01f, -9.55587476e-02f, 1.73538670e-01f, -2.01253989e-03f, -4.63475473e-02f, -1.14053778e-01f, 1.16289757e-01f, -6.16381243e-02f, -1.28343806e-01f,
  -1.32076755e-01f, 8.85953978e-02f, 1.21019810e-01f, -8.56745839e-02f, -2.40390189e-02f, 4.93340604e-02f, 3.85098606e-02f, -9.38090682e-03f, 1.34967774e-01f, -3.90432738e-02f,
  7.95095563e-02f, -1.63983718e-01f, 1.40569061e-01f, 3.19052562e-02f, 7.04452321e-02f, 1.85202524e-01f, -5.58006652e-02f, -4.93191220e-02f, 7.81298280e-02f, -3.36862430e-02f,
  -3.03517319e-02f, 1.08950853e-01f, -3.05564012e-02f, -1.28494531e-01f, 3.23470980e-02f, -1.16242617e-02f, -1.15736350e-01f, 7.71671608e-02f, 2.89056227e-02f, 1.36396497e-01f,
  1.14586957e-01f, -1.13104880e-01f, -1.42186033e-02f, 8.15679953e-02f, -7.60834292e-02f, 1.42647788e-01f, 7.57459551e-02f, 6.44451380e-02f, 3.22107524e-01f, -9.61195454e-02f,
  -1.60688418e-03f, 2.97626406e-02f, -1.67585120e-01f, 1.95088416e-01f, 1.56973332e-01f, 6.72607198e-02f, -3.60858530e-01f, 1.43406674e-01f, -1.44933179e-01f, 1.55003881e-02f,
  7.85760358e-02f, 8.52113217e-02f, 9.48690698e-02f, -1.62732199e-01f, -6.50207028e-02f, 4.14512232e-02f, -2.71403678e-02f, -1.00479543e-01f, -1.12334549e-01f, 5.66053726e-02f,
  -2.23253831e-01f, -1.58552825e-01f, 1.17788903e-01f, 7.23393932e-02f, 1.36146680e-01f, 3.75291519e-02f, -5.29797748e-02f, 5.01714230e-01f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -5.04461303e-03f, 1.76428586e-01f, 1.69939905e-01f, 7.09520727e-02f, 1.22020580e-01f, 6.63174829e-03f, -8.01107436e-02f, 3.20557743e-01f, 1.81747496e-01f, 2.84025043e-01f,
  7.41565228e-02f, 1.06424086e-01f, 4.10991386e-02f, 3.85468721e-01f, -1.71959445e-01f, 7.24067688e-02f, -1.73092932e-01f, -5.16368784e-02f, 1.97016060e-01f, 2.36790374e-01f,
  -1.59508869e-01f, -4.27295677e-02f, -2.35350326e-01f, -8.42446834e-03f, 2.70156205e-01f, -2.45134324e-01f, -3.05324227e-01f, -1.51701227e-01f, -3.30952369e-02f, 1.42686144e-01f,
  5.74006252e-02f, -1.09346814e-01f, -2.25991592e-01f, -1.33606389e-01f, -4.60705273e-02f, 1.33982927e-01f, -2.15047747e-02f, -1.40170678e-01f, 8.12289417e-02f, -1.53149655e-02f,
  2.44623404e-02f, 1.54478759e-01f, 1.48727879e-01f, 2.51672477e-01f, 2.44414657e-01f, -1.37501240e-01f, 7.17599131e-03f, 7.82635212e-02f, 2.81957865e-01f, 8.10991079e-02f,
  3.48010585e-02f, 3.80829140e-03f, -3.42691660e-01f, 3.50629747e-01f, 3.50821435e-01f, 1.62130237e-01f, -6.14781715e-02f, 2.36060604e-01f, -2.51889706e-01f, -7.40405619e-02f,
  -5.91291972e-02f, 2.38704950e-01f, 1.97285518e-01f, -5.74918807e-01f, 5.02599552e-02f, 2.12533310e-01f, 1.20744981e-01f, 6.23774230e-02f, 9.69307423e-02f, 1.38137326e-01f,
  2.57825796e-02f, 2.65947998e-01f, 1.47777721e-01f, 2.10808828e-01f, -2.88487738e-03f, -3.34929787e-02f, -1.78132001e-02f, 2.38660425e-01f, -2.61330288e-02f, -5.77392383e-03f,
  -1.75632358e-01f, 3.78251597e-02f, 8.41490477e-02f, 1.27593037e-02f, -1.43481866e-01f, -8.22433308e-02f, -3.95155177e-02f, -6.33667484e-02f, 4.36072052e-01f, -1.12736978e-01f,
  -4.90902103e-02f, 2.08896339e-01f, -4.15295176e-02f, -3.62106822e-02f, -1.09276660e-01f, -4.36467454e-02f, 1.23941191e-01f, 1.44250125e-01f, -2.42823824e-01f, 1.27320141e-01f,
  1.30476967e-01f, -1.15230858e-01f, -1.57769412e-01f, 2.01717630e-01f, -9.14645717e-02f, 5.76216429e-02f, -1.36552528e-01f, 3.45208526e-01f, -1.41827449e-01f, -2.22035050e-01f,
  2.55310595e-01f, 3.03607792e-01f, 2.73555070e-01f, -3.74680012e-02f, 9.39832628e-02f, -1.39858574e-01f, -2.33028516e-01f, 2.38856912e-01f, 2.41504833e-01f, -1.52060920e-02f,
  -4.43158718e-03f, 3.44227284e-01f, -2.35631224e-02f, -1.89700007e-01f, -1.93321705e-01f, 1.27793282e-01f, 1.54378274e-02f, -2.70110130e-01f, 1.77851766e-01f, 1.24525458e-01f,
  7.39298239e-02f, 1.57674596e-01f, -2.31056418e-02f, 6.51397929e-02f, 1.41911268e-01f, 8.70553926e-02f, 8.33321363e-02f, 7.69717013e-03f, 1.61293510e-03f, -1.00700527e-01f,
  9.29989517e-02f, 4.22255509e-02f, 6.85379431e-02f, -1.81119099e-01f, 5.67478053e-02f, 1.14563107e-01f, -7.08988979e-02f, -4.35176641e-02f, -8.55400264e-02f, 1.20927170e-01f,
  -1.38706490e-01f, 1.53335914e-01f, -5.74500002e-02f, -4.27428149e-02f, 5.47341350e-03f, 1.30334452e-01f, 2.73438007e-01f, 1.06864654e-01f, -2.48897687e-01f, 3.28508280e-02f,
  -1.06560484e-01f, 2.15821609e-01f, 2.20736921e-01f, -2.52283484e-01f, 1.72960281e-01f, 8.76120478e-02f, -3.41403067e-01f, 6.35802373e-02f, 3.40596527e-01f, -1.31418005e-01f,
  -2.87229210e-01f, 8.74056295e-02f, -4.04743046e-01f, -4.21257854e-01f, 1.38947725e-01f, 3.45767617e-01f, 8.64184201e-02f, 4.24319685e-01f, 1.73468128e-01f, -2.46213019e-01f,
  -1.58566743e-01f, 3.27229470e-01f, 1.96191221e-01f, 3.68526950e-02f, -3.41206253e-01f, 4.71425131e-02f, 2.19137177e-01f, 3.41554582e-01f, -5.01493633e-01f, 2.70207971e-01f,
  -2.58240461e-01f, 2.43599489e-01f, -7.12988600e-02f, 2.21069418e-02f, 1.19777344e-01f, -3.77714187e-02f, 2.26666719e-01f, 4.46428061e-02f, -4.86986674e-02f, 2.11026862e-01f,
  2.75994837e-01f, 2.91654199e-01f, 3.95605043e-02f, 4.47354130e-02f, -1.00676142e-01f, -5.96729927e-02f, -1.33624673e-01f, 1.84105188e-01f, -2.43791007e-02f, 1.02235198e-01f,
  -7.75177330e-02f, 2.38031372e-01f, -5.07029379e-03f, 1.33407414e-01f, -8.54210183e-02f, -4.63695638e-02f, 2.35477760e-02f, -4.75662425e-02f, -1.67770699e-01f, -6.51694462e-02f,
  -2.03537524e-01f, 1.02698840e-01f, -4.64181183e-03f, -8.90781060e-02f, 8.51381663e-03f, 2.04452965e-02f, 4.43100959e-01f, 3.40942144e-01f, -2.57846653e-01f, -3.49174589e-01f,
  -3.59679610e-02f, 5.58281243e-02f, 3.97863597e-01f, 3.26490581e-01f, 4.69522737e-02f, 6.01901710e-02f, -2.21871108e-01f, -1.27444265e-03f, 1.90599307e-01f, 9.22191665e-02f,
  1.18579738e-01f, 1.14080675e-01f, -2.03725230e-02f, 4.37192246e-02f, -2.45640963e-01f, 1.93100199e-01f, 9.90737528e-02f, 2.99953353e-02f, -1.75557673e-01f, 3.32235277e-01f,
  -3.11981946e-01f, 5.52179851e-02f, 2.69669235e-01f, 1.89255923e-01f, 1.07742257e-01f, -1.57512352e-01f, 4.81901923e-04f, -1.24692045e-01f, 1.87082251e-03f, 1.06510371e-01f,
  2.75127083e-01f, -4.27278280e-02f, 8.02658349e-02f, 2.43715823e-01f, 1.09610707e-01f, 1.18249103e-01f, -3.87169868e-02f, 6.33557811e-02f, 3.09798233e-02f, 4.08288538e-02f,
  -8.10322613e-02f, 4.86414321e-02f, -1.20096289e-01f, 2.00876430e-01f, 1.93925172e-01f, 4.81938422e-01f, 3.33500355e-02f, -8.59833956e-02f, -2.85493694e-02f, -6.97647184e-02f,
  -1.84871152e-01f, 1.37186512e-01f, 7.85831288e-02f, 1.27530154e-02f, -2.54407208e-02f, 7.55587146e-02f, 4.42883849e-01f, 7.22735822e-02f, 7.31896311e-02f, -7.38675799e-03f,
  1.39670461e-01f, 3.23472083e-01f, 1.21224508e-01f, -1.98241636e-01f, -1.28661105e-02f, 2.43227571e-01f, 9.87101793e-02f, 2.93190647e-02f, 3.10852945e-01f, 9.22234654e-02f,
  2.86013335e-01f, 1.04367090e-02f, -2.11133748e-01f, -1.45093694e-01f, -8.83085281e-02f, 2.55780607e-01f, -2.10212439e-01f, 2.29686454e-01f, -3.03016722e-01f, -1.27662703e-01f,
  -4.04196084e-02f, 1.88487336e-01f, 2.07077339e-01f, 4.77736086e-01f, -1.68641776e-01f, 2.13900432e-01f, 2.23412022e-01f, 2.87828714e-01f, -1.99502520e-02f, -4.09934461e-01f,
  9.76632163e-02f, 5.84237948e-02f, 1.61847323e-01f, 4.77552339e-02f, 1.70687154e-01f, 1.54514099e-02f, 1.56646054e-02f, 1.71282157e-01f, 8.69258195e-02f, 7.69334137e-02f,
  1.44721821e-01f, 1.51450872e-01f, -1.88866675e-01f, 2.60233939e-01f, -1.17903993e-01f, 6.97016940e-02f, -6.04674816e-02f, 2.28964929e-02f, 4.29197848e-02f, 3.05647016e-01f,
  1.77733488e-02f, -1.05332946e-02f, -1.30126491e-01f, -7.04340637e-02f, 2.08245181e-02f, -1.70219913e-01f, -6.17123768e-02f, -8.48733559e-02f, 8.43718797e-02f, -6.91039395e-03f,
  1.78093031e-01f, -5.62321059e-02f, -9.78243724e-02f, -5.52803241e-02f, 3.63750786e-01f, 1.59803167e-01f, -1.46282673e-01f, -1.68367788e-01f, -2.64178496e-02f, -1.03016272e-01f,
  4.44968730e-01f, 3.36439699e-01f, -1.92801759e-01f, -1.56627670e-01f, 1.01874001e-01f, -1.23604529e-01f, -1.79415748e-01f, -1.77216858e-01f, 4.25781421e-02f, 8.24071467e-02f,
  -4.59075347e-02f, 2.59799242e-01f, -2.42454186e-01f, -2.20084190e-01f, 7.75661319e-02f, 3.66322428e-01f, -1.07916445e-01f, 4.23936784e-01f, -8.88185576e-02f, 2.18056813e-01f,
  3.26445818e-01f, -9.28219482e-02f, -8.20230618e-02f, 1.17892670e-02f, -3.40153761e-02f, -1.10101700e-01f, -4.58482467e-02f, 1.29489815e-02f, 8.45288485e-02f, 9.27572325e-02f,
  -6.93371892e-02f, 4.02535908e-02f, 5.58608351e-03f, -6.00259611e-03f, 2.01693416e-01f, 2.46632304e-02f, 7.90574551e-02f, 1.12193249e-01f, 1.22016743e-01f, 1.85839579e-01f,
  2.93738067e-01f, -6.61278814e-02f, -1.20462738e-01f, -3.17035228e-01f, 6.14724122e-03f, -2.35518832e-02f, 6.22266158e-02f, -2.98650917e-02f, -9.67502296e-02f, 7.54515268e-03f,
  1.40199646e-01f, -3.75158906e-01f, -1.70991555e-01f, 1.55303061e-01f, -3.35553229e-01f, 3.32178980e-01f, 2.68834992e-03f, 2.05771923e-01f, -1.04790628e-01f, -2.12868154e-01f,
  -1.13579519e-01f, 3.54118675e-01f, 1.86497532e-02f, 4.65112291e-02f, 1.39226243e-01f, -2.10900217e-01f, -1.32052422e-01f, 2.94842452e-01f, -2.82481521e-01f, -1.12585975e-02f,
  1.94090694e-01f, 4.20605570e-01f, 2.73988962e-01f, -2.47746840e-01f, 1.34263858e-01f, 3.81177738e-02f, 3.17805082e-01f, 1.13425456e-01f, 2.49208912e-01f, -1.25543356e-01f,
  -2.70942181e-01f, 1.62431285e-01f, -2.39444375e-02f, 3.86989713e-02f, -4.14018668e-02f, 1.09071203e-01f, 2.05435559e-01f, 2.58885235e-01f, 1.59011818e-02f, -2.20274612e-01f,
  -2.01888382e-02f, -3.41995694e-02f, 5.52013665e-02f, 1.87794015e-01f, -1.66212648e-01f, 1.15191013e-01f, 2.17330143e-01f, -2.30206084e-02f, -7.91852921e-02f, 8.44181627e-02f,
  1.73697621e-01f, 7.87099674e-02f, 3.84027772e-02f, 1.14598882e-03f, -3.00527047e-02f, 1.70864254e-01f, 1.42068595e-01f, 2.21232757e-01f, -3.41100283e-02f, 2.73690885e-03f,
  -1.61373451e-01f, -2.22966373e-01f, 1.28265783e-01f, -7.78525397e-02f, 3.65813553e-01f, -2.69709170e-01f, -2.14615971e-01f, 9.84835103e-02f, 2.28679448e-01f, 4.99747634e-01f,
  -7.30177313e-02f, 2.08502516e-01f, -2.74375886e-01f, 3.86364639e-01f, -1.44096157e-02f, 4.65463430e-01f, 3.28287810e-01f, 8.58671218e-02f, -1.46693289e-01f, -9.68972594e-02f,
  5.26949286e-01f, 3.17129225e-01f, 1.48236513e-01f, 1.85483053e-01f, 1.66177973e-01f, -7.03809187e-02f, 1.12970322e-01f, -2.13309959e-01f, 2.29935139e-01f, 2.35658005e-01f,
  -2.05256686e-01f, -7.90453926e-02f, 2.52133105e-02f, 1.43938005e-01f, 4.15475160e-01f, 3.36106926e-01f, 1.32261425e-01f, -1.33739129e-01f, 2.81996876e-01f, 2.91296273e-01f,
  2.72124968e-02f, 6.24155104e-02f, 1.30851910e-01f, 1.70632735e-01f, 3.00759226e-01f, 1.62836626e-01f, 7.51715302e-02f, 4.42387909e-02f, 1.98825926e-01f, 3.97688478e-01f,
  1.72745198e-01f, -1.34228580e-02f, -2.95814779e-02f, -6.87686726e-02f, -3.81294861e-02f, 1.54029533e-01f, 1.42410740e-01f, -1.88663319e-01f, -1.72340702e-02f, 2.10813414e-02f,
  1.50533378e-01f, 1.88205793e-01f, 1.62246395e-02f, -1.51315287e-01f, -8.01023189e-03f, -8.63971412e-02f, 3.83716881e-01f, -2.69017428e-01f, 2.86214143e-01f, -1.65248692e-01f,
  3.58317226e-01f, -2.75770724e-01f, 1.32946059e-01f, 2.19873965e-01f, -1.59249216e-01f, -1.71396896e-01f, 1.62971452e-01f, 1.69968724e-01f, 4.29510213e-02f, -4.25944716e-01f,
  3.89121085e-01f, -8.68171304e-02f, 4.33601201e-01f, 2.84480155e-01f, 2.04812437e-01f, 3.35639775e-01f, 6.63993880e-02f, 4.39553380e-01f, -2.21361965e-01f, 7.72033483e-02f,
  -3.75809893e-02f, 4.78437781e-01f, -4.69252979e-03f, 2.83888280e-01f, -1.87777191e-01f, -9.75903347e-02f, 1.24377362e-01f, 2.86262035e-01f, 4.09732878e-01f, 5.96939743e-01f,
  1.10943271e-02f, 2.83287108e-01f, 1.37239367e-01f, -5.24439923e-02f, 2.06319705e-01f, 1.86967123e-02f, -1.42507166e-01f, 1.00866213e-01f, 8.83046165e-02f, -1.66555196e-02f,
  1.79426596e-01f, 1.91557646e-01f, -9.93633494e-02f, 2.92815149e-01f, 1.58475742e-01f, 3.01781148e-02f, 2.07834914e-01f, 1.14340357e-01f, -9.12811235e-02f, 1.56827241e-01f,
  3.02774142e-02f, 2.97822058e-02f, 1.47494497e-02f, -2.61967555e-02f, 1.57948583e-01f, 1.17205441e-01f, -9.00224596e-03f, 5.53862639e-02f, 1.05554223e-01f, -4.81380522e-02f,
  1.79084003e-01f, -1.85340747e-01f, -3.06702852e-01f, 7.97233209e-02f, -2.96203017e-01f, 2.78312042e-02f, 1.62523205e-03f, 8.04651082e-02f, 1.55438289e-01f, -1.31286547e-01f,
  -1.86760858e-01f, 3.23856354e-01f, -2.95393955e-04f, -9.94592607e-02f, 2.84462478e-02f, 1.81571126e-01f, -8.61989260e-02f, 1.96688995e-01f, 1.25125885e-01f, 3.37577909e-01f,
  -1.04615036e-02f, -5.27946427e-02f, -1.09207928e-02f, 2.27184802e-01f, 1.34659961e-01f, -3.25985461e-01f, -1.12730287e-01f, 2.31776819e-01f, -5.12842119e-01f, 1.77609906e-01f,
  2.89441496e-01f, 1.12222940e-01f, 1.26159387e-02f, 4.06861126e-01f, -2.72991061e-01f, -2.44742259e-02f, 3.39381963e-01f, 9.34158489e-02f, 8.02126527e-02f, -1.53595746e-01f,
  2.36572012e-01f, 2.08029523e-01f, 4.41801874e-03f, 1.90573871e-01f, -1.35655841e-02f, 1.53007999e-01f, 2.15310842e-01f, 1.07338518e-01f, 9.21657160e-02f, 1.55824557e-01f,
  1.17265314e-01f, 4.25781161e-02f, -3.44062708e-02f, -3.07864845e-01f, -1.65870249e-01f, 3.78637314e-02f, 1.25397906e-01f, -1.34619668e-01f, -1.79056361e-01f, -9.97487456e-02f,
  1.24045424e-01f, -3.65261780e-03f, 1.43820733e-01f, 2.19491101e-03f, -1.08517028e-01f, 8.50905664e-03f, 2.48040035e-01f, 4.64375407e-01f, 3.46965976e-02f, 4.74644899e-02f,
  4.43554908e-01f, 3.60096879e-02f, 3.96068782e-01f, -4.08250280e-02f, 8.07969123e-02f, 2.42923453e-01f, -1.92580953e-01f, -4.19959538e-02f, 2.58362114e-01f, -2.70075887e-03f,
  -2.11523436e-02f, 1.47579804e-01f, 2.16264009e-01f, -9.21135396e-02f, 2.32607111e-01f, 2.19858870e-01f, -1.07788734e-01f, -8.63766968e-02f, 1.90869737e-02f, -9.26033705e-02f,
  -9.70880911e-02f, 6.62474409e-02f, 6.89929962e-01f, 2.06197217e-01f, 5.78831919e-02f, -8.85932818e-02f, 2.08146334e-01f, -4.61213380e-01f, 1.17887177e-01f, -1.49889007e-01f,
  2.32332706e-01f, 1.67971566e-01f, 1.55910281e-02f, 1.77840963e-01f, 6.60173818e-02f, 1.78370029e-01f, 2.33932957e-01f, 7.83966780e-02f, 2.13733166e-01f, -6.02402724e-02f,
  8.26862752e-02f, 3.13346654e-01f, 1.79113582e-01f, 1.46299481e-01f, 1.22543778e-02f, 1.52314916e-01f, 2.01117352e-01f, 2.94051707e-01f, -3.31437200e-01f, 2.55830467e-01f,
  1.71832696e-01f, -1.43039953e-02f, -9.37795490e-02f, -1.42994197e-02f, 2.04250917e-01f, -4.52902764e-02f, 1.39643922e-01f, -1.65991813e-01f, 2.83438444e-01f, 6.04014769e-02f,
  -3.49103481e-01f, -2.44127482e-01f, 4.71545421e-02f, 6.80112233e-03f, -4.69079852e-01f, -3.74526531e-02f, -1.12882003e-01f, -2.02248812e-01f, 1.51945069e-01f, 1.55878495e-02f,
  8.03400576e-02f, -2.80725390e-01f, 1.40561894e-01f, 4.03137170e-02f, 2.93458223e-01f, -6.57759681e-02f, 1.98805153e-01f, 2.24221572e-01f, -4.51644927e-01f, 6.10673837e-02f,
  -1.03014812e-01f, 3.06758463e-01f, 2.44969919e-01f, 2.16857120e-01f, -5.96610419e-02f, 1.65934131e-01f, 1.40882939e-01f, 3.28197718e-01f, 2.36825332e-01f, -4.45303954e-02f,
  -8.36812928e-02f, 5.64159691e-01f, -1.14541806e-01f, 1.66313097e-01f, -2.02097833e-01f, -1.08403392e-01f, 2.59795666e-01f, -4.46983993e-01f, 2.68705159e-01f, 1.75975546e-01f,
  1.08045489e-01f, 1.06236987e-01f, 6.95280656e-02f, 1.82559147e-01f, 1.40982419e-01f, 4.20543998e-02f, -6.97056800e-02f, 1.22700013e-01f, 6.50370866e-02f, 1.12273738e-01f,
  -9.44331512e-02f, 9.45071727e-02f, -2.76100606e-01f, 1.45114705e-01f, 1.81019351e-01f, 1.20885640e-01f, -1.27996141e-02f, 1.01015255e-01f, 7.17722103e-02f, 9.44200158e-02f,
  1.07464246e-01f, -1.69974908e-01f, 1.35768224e-02f, 1.41179413e-01f, -1.58702448e-01f, 4.34369415e-01f, 1.05198614e-01f, -1.11983679e-01f, 1.25819575e-02f, -8.16221088e-02f,
  -1.08592488e-01f, 3.93336825e-02f, -1.61262564e-02f, 1.72118694e-01f, -1.28324226e-01f, -1.61629751e-01f, 9.19898301e-02f, -2.42221311e-01f, 2.15684101e-01f, 4.54959571e-01f,
  1.83570445e-01f, -2.99791276e-01f, 5.32785989e-02f, 3.75923395e-01f, -1.89344719e-01f, -1.69372678e-01f, -1.06373981e-01f, 1.75093114e-01f, 1.75482631e-01f, -1.26711175e-01f,
  4.89990860e-01f, -5.28486632e-02f, 1.15718178e-01f, 8.69824663e-02f, 1.57610282e-01f, 3.73951703e-01f, 5.71137778e-02f, 1.54308170e-01f, 6.46588299e-03f, -1.81480616e-01f,
  2.65636265e-01f, -3.35692242e-02f, 8.91334713e-02f, 3.60004641e-02f, -1.06378689e-01f, -1.27952639e-02f, 6.40040413e-02f, 8.69662315e-02f, 1.84422299e-01f, 4.16781977e-02f,
  -2.12360099e-01f, 1.96400717e-01f, 1.70416787e-01f, -5.19868881e-02f, -6.87004924e-02f, -2.98301154e-03f, -2.41771340e-01f, -2.03102484e-01f, 2.05437884e-01f, 1.33190617e-01f,
  -8.90137404e-02f, 8.16309527e-02f, 2.04881191e-01f, -2.61186752e-02f, 1.42751308e-02f, 6.93250149e-02f, 4.09346260e-02f, -1.43446729e-01f, 7.60078952e-02f, -4.75774035e-02f,
  3.57157767e-01f, -7.32790306e-02f, 1.98723584e-01f, 1.27895966e-01f, -6.33579344e-02f, 5.83433807e-02f, 1.42602235e-01f, -1.29658967e-01f, 3.64135355e-02f, -1.20745413e-01f,
  5.46705946e-02f, -6.32741526e-02f, 1.72705442e-01f, 5.36187649e-01f, 1.90646976e-01f, -3.69957507e-01f, -1.27458036e-01f, 3.69849443e-01f, -5.35729975e-02f, -2.22639553e-02f,
  -3.69155407e-01f, 3.88447613e-01f, 9.43250805e-02f, -1.38034657e-01f, -4.89551108e-03f, -3.08837444e-02f, -2.29092553e-01f, 2.23401695e-01f, 1.52621776e-01f, 2.57522941e-01f,
  3.06273788e-01f, 5.74532337e-02f, -3.87409180e-02f, -1.76605687e-01f, -1.36196345e-01f, 1.73365816e-01f, 2.57959757e-02f, 1.99863255e-01f, -8.49336311e-02f, -2.52861846e-02f,
  6.42194822e-02f, -1.63304228e-02f, 3.61387618e-02f, -2.03283474e-01f, 5.65870255e-02f, -4.80386280e-02f, 1.45779535e-01f, 1.24792837e-01f, -2.22492039e-01f, -2.66640484e-01f,
  1.59197286e-01f, -2.24420458e-01f, 4.14149426e-02f, 1.69129699e-01f, -1.24170352e-02f, -5.55513024e-01f, 1.49777070e-01f, 8.01057518e-02f, 1.14158548e-01f, -1.14042014e-01f,
  -1.71068057e-01f, -9.23782960e-02f, 4.00990516e-01f, -6.84549883e-02f, 9.17432159e-02f, -2.04251744e-02f, -3.78673933e-02f, 4.33616996e-01f, -2.35667706e-01f, 1.35263234e-01f,
  1.48769924e-02f, -3.40163946e-01f, 8.21685791e-02f, 3.78349245e-01f, -4.13005203e-02f, -3.64571996e-02f, 1.82771727e-01f, 1.92419633e-01f, -2.05923080e-01f, 6.79932237e-02f,
  -2.10418686e-01f, 9.45996419e-02f, 1.22507885e-02f, 1.50004253e-01f, -1.06324360e-01f, -1.48533598e-01f, -6.22374192e-02f, 1.61375791e-01f, 1.75178289e-01f, -1.85428187e-01f,
  6.75223395e-02f, -2.05761641e-02f, -1.05133511e-01f, -3.14195484e-01f, -2.47832816e-02f, 1.44731343e-01f, 2.67787706e-02f, 1.48588449e-01f, -1.65781960e-01f, 8.00944567e-01f,
  2.29354858e-01f, -3.44673172e-03f, 9.37178358e-02f, 8.13712403e-02f, 1.05048500e-01f, 1.38664380e-01f, 1.90048411e-01f, 1.27684742e-01f, 1.98829934e-01f, 3.80194075e-02f,
  -1.26319289e-01f, 9.79765356e-02f, -1.33190900e-01f, -1.94243282e-01f, 1.12833150e-01f, -1.79127097e-01f, -2.94118196e-01f, 1.74710721e-01f, 8.88446495e-02f, 4.12548110e-02f,
  2.11798429e-01f, -2.98672076e-02f, -1.03485398e-01f, -9.68531892e-02f, 1.45165399e-01f, 1.12060541e-02f, 1.41037449e-01f, 5.50733685e-01f, 3.43444385e-02f, -2.23273374e-02f,
  -9.69506241e-03f, 1.93421662e-01f, 3.81836981e-05f, 2.82170892e-01f, 3.46496761e-01f, 5.78856021e-02f, -8.38322863e-02f, 1.13771833e-01f, -6.57628030e-02f, -2.26820216e-01f,
  4.63629186e-01f, -1.06881522e-02f, -1.31051347e-01f, -2.12257162e-01f, 2.36187819e-02f, -2.99086813e-02f, -2.66075116e-02f, -2.32830092e-01f, 1.82231918e-01f, 1.23802572e-02f,
  5.61805330e-02f, -5.35431840e-02f, -8.19872171e-02f, -1.25992939e-01f, -1.91777095e-01f, -8.06028917e-02f, -4.63605598e-02f, 1.75994888e-01f, 2.31973931e-01f, 5.03420293e-01f,
  1.75608858e-01f, 5.82580417e-02f, 2.47217454e-02f, 2.74342895e-01f, 4.20624353e-02f, -2.70941388e-02f, 7.11525306e-02f, 9.40779075e-02f, 3.99925187e-02f, 1.10268898e-01f,
  4.85659167e-02f, 2.80217677e-02f, 1.33603150e-02f, 1.53254652e-02f, -6.59691840e-02f, -4.13027294e-02f, -1.66837156e-01f, -1.56714216e-01f, 1.93658218e-01f, -3.94077301e-02f,
  -1.51946440e-01f, 1.19645238e-01f, -3.34248543e-02f, 3.44324335e-02f, -2.37929579e-02f, -2.54562758e-02f, -6.36324584e-02f, 1.14977770e-02f, 1.71737269e-01f, 8.66676942e-02f,
  2.60865927e-01f, 2.76989609e-01f, -1.73423011e-02f, -5.50912134e-02f, -2.80813307e-01f, 2.72671103e-01f, -8.31100792e-02f, 1.40272364e-01f, 3.37141424e-01f, 4.27039638e-02f,
  -1.61772415e-01f, 2.80860037e-01f, -1.14665695e-01f, -1.84915960e-01f, 3.69992226e-01f, -3.03338647e-01f, -4.80350405e-02f, 2.67651975e-01f, -9.47647169e-02f, -1.01694763e-01f,
  2.69092798e-01f, -2.66617239e-02f, 2.49161243e-01f, -2.19533592e-02f, 1.14131486e-02f, 3.01277906e-01f, -1.83526695e-01f, -6.42971471e-02f, -3.29340473e-02f, -1.26650214e-01f,
  -4.65177186e-02f, 3.76507663e-03f, 1.87104285e-01f, 2.39073634e-01f, 1.05535649e-01f, 1.63423568e-01f, -4.88734134e-02f, 2.43471265e-01f, 3.66283096e-02f, 1.91334993e-01f,
  -3.59484516e-02f, -3.61965820e-02f, 5.08956350e-02f, -1.15105927e-01f, -3.68739069e-02f, 1.98155991e-03f, -1.33208260e-01f, 8.75860360e-03f, -6.58923313e-02f, 5.91381639e-02f,
  4.74834070e-02f, -1.07942633e-01f, -2.06300065e-01f, -1.23769365e-01f, 3.82467136e-02f, -1.08074017e-01f, -1.39753576e-02f, -2.69223064e-01f, 9.00668725e-02f, -7.42901936e-02f,
  -1.64261684e-02f, -3.79416943e-02f, 1.23046517e-01f, -4.61592479e-03f, -2.17086092e-01f, 1.53288051e-01f, 8.14660266e-02f, 5.58590032e-02f, -1.28410771e-01f, -7.23151192e-02f,
  -3.25759465e-04f, -6.05973937e-02f, 1.56841487e-01f, -3.46415304e-02f, -1.53289288e-01f, -1.10900477e-01f, -3.56772053e-03f, -1.47567853e-01f, 2.92996671e-02f, 6.79944456e-02f,
  5.15895300e-02f, -1.80681467e-01f, 8.76344964e-02f, 9.91256759e-02f, -1.87309176e-01f, 1.04501240e-01f, -5.29273227e-02f, -1.83370151e-02f, 9.96085331e-02f, 3.48508842e-02f,
  1.14222303e-01f, 2.18694016e-01f, 2.58691180e-02f, 7.98789337e-02f, -1.39274061e-01f, 5.22895865e-02f, -3.57012078e-02f, -2.54699230e-01f, 7.09288567e-02f, -1.32737771e-01f,
  9.59177986e-02f, 5.00900531e-03f, -4.02417667e-02f, 2.31261998e-01f, 8.07965025e-02f, 9.67392623e-02f, 1.15002334e-01f, -3.69142294e-02f, -6.85965568e-02f, 2.27147549e-01f,
  1.00935567e-02f, 2.44096920e-01f, 1.51830792e-01f, 2.18037978e-01f, 5.29037677e-02f, -1.41475439e-01f, -1.88569680e-01f, 1.55027911e-01f, 1.04431715e-02f, -3.73384416e-01f,
  -7.33919293e-02f, 5.89439087e-02f, -3.59628946e-02f, -9.57342796e-03f, 1.56907737e-02f, 1.78199664e-01f, -7.90032372e-02f, -8.03901032e-02f, -1.13681210e-02f, -9.43970382e-02f,
  -3.08497176e-02f, 1.30854562e-01f, 2.75764316e-01f, -3.85421604e-01f, 2.51416534e-01f, -2.25735366e-01f, 1.01573594e-01f, 2.10542902e-01f, -1.46040216e-01f, -3.97857487e-01f,
  3.33865024e-02f, 3.17329876e-02f, -1.82328388e-01f, 1.65919691e-01f, 3.20014581e-02f, 3.64564866e-01f, 1.34528503e-01f, -8.33126977e-02f, -1.37166068e-01f, 2.33985528e-01f,
  1.95881426e-01f, 1.28020704e-01f, -7.92689845e-02f, 7.92258978e-02f, 2.50364095e-01f, 4.72229213e-01f, 3.21323514e-01f, -4.14116606e-02f, -1.85172260e-01f, -3.46138537e-01f,
  -1.72798276e-01f, -2.70051330e-01f, 9.09609348e-02f, 5.89797460e-02f, 5.79987951e-02f, -4.65681136e-01f, 2.28398427e-01f, 1.25337899e-01f, 4.16060612e-02f, 1.23939089e-01f,
  2.20895410e-01f, -1.05341161e-02f, 6.73547611e-02f, 3.17614585e-01f, 1.66135088e-01f, 1.96044609e-01f, -1.09478328e-02f, 1.91821590e-01f, 7.67870694e-02f, -4.59184535e-02f,
  -2.37246305e-01f, 1.66614413e-01f, -1.45101890e-01f, -2.63369113e-01f, -1.46789253e-01f, 2.95899156e-02f, 8.76775980e-02f, 2.74742544e-01f, 1.41116291e-01f, -3.76451388e-02f,
  3.77080828e-01f, -1.91322371e-01f, 2.35918202e-02f, 4.40013677e-01f, 1.92017972e-01f, -2.41953507e-03f, 3.97131383e-01f, -6.19487911e-02f, 2.76866078e-01f, -1.82200938e-01f,
  -3.58206183e-02f, 2.58405209e-01f, -2.09829167e-01f, -5.07405043e-01f, 7.19411448e-02f, -2.55554229e-01f, -2.71817178e-01f, 4.99669254e-01f, 2.45612830e-01f, 2.95466296e-02f,
  1.36060193e-01f, 1.76473916e-01f, 1.91803247e-01f, 1.25466928e-01f, 1.31388027e-02f, -1.62494518e-02f, 3.94490547e-02f, 3.00290510e-02f, 5.95099991e-03f, 2.79502600e-01f,
  9.50058326e-02f, 2.30517779e-02f, 1.29615618e-02f, -1.81514025e-01f, 1.53091932e-02f, -2.32969299e-01f, 2.10281938e-01f, 1.25599895e-02f, 6.27966747e-02f, -3.41544896e-01f,
  -3.16834562e-02f, -3.18451822e-02f, 9.76219997e-02f, 1.12693030e-02f, 2.76150405e-01f, 1.33469194e-01f, -1.21230371e-01f, 9.44942459e-02f, 1.04591258e-01f, 9.05036554e-02f,
  9.07073990e-02f, -6.26454875e-02f, 5.03632836e-02f, 5.97421154e-02f, -4.66907211e-02f, -9.69627798e-02f, -6.28093183e-02f, -8.50395560e-02f, -4.93500903e-02f, 2.56248415e-01f,
  1.52715564e-01f, -1.91889852e-02f, -1.07589308e-02f, -1.03369474e-01f, 7.88934901e-02f, -7.16201076e-03f, 3.00903171e-01f, 5.76324388e-02f, -4.30752426e-01f, 6.00314699e-04f,
  1.66205496e-01f, 2.28498489e-01f, 2.46823668e-01f, -6.98385015e-02f, 3.51946503e-02f, 3.42713475e-01f, 3.78018282e-02f, 6.54789433e-02f, 3.75537843e-01f, -1.12636045e-01f,
  -4.29136455e-02f, -6.48427531e-02f, 3.67837936e-01f, 4.16231781e-01f, 9.18454230e-02f, 4.52893615e-01f, 1.96262777e-01f, 2.91971773e-01f, -7.37372637e-02f, -1.84934884e-02f,
  -5.87993041e-02f, 2.39681840e-01f, 1.94717616e-01f, 8.63874257e-02f, -5.92149943e-02f, -6.95819482e-02f, 3.02874148e-01f, 1.67548522e-01f, 2.20345855e-02f, -2.73232590e-02f,
  4.44927543e-01f, 3.09954196e-01f, 1.26700535e-01f, 3.49846184e-02f, -5.12337014e-02f, 7.32020065e-02f, -9.26458612e-02f, -5.16055189e-02f, 1.24145024e-01f, 2.04243958e-01f,
  -7.52583146e-02f, 1.36822522e-01f, 6.10624515e-02f, 3.19196880e-02f, 2.03198455e-02f, 4.89403829e-02f, 2.12508619e-01f, 1.73790082e-01f, -1.79502189e-01f, 2.16979593e-01f,
  2.04849377e-01f, 5.14796637e-02f, -1.27588093e-01f, -1.14815272e-01f, 2.53114760e-01f, 1.71723753e-01f, 1.51204601e-01f, -1.72776401e-01f, -1.22251481e-01f, 6.80808350e-02f,
  -7.46288076e-02f, -2.10714877e-01f, -2.66911592e-02f, 1.01861924e-01f, -2.35053644e-01f, 1.12013504e-01f, 1.50182068e-01f, 2.89745256e-02f, 1.04276173e-01f, 4.58696336e-02f,
  9.22328606e-02f, 1.85521528e-01f, 1.72170565e-01f, 3.61530811e-01f, -4.91234884e-02f, -3.21539283e-01f, 3.72602612e-01f, 2.88846586e-02f, -1.85328528e-01f, 2.59864539e-01f,
  -1.04933105e-01f, 3.27929676e-01f, 2.20283464e-01f, 1.30651459e-01f, 6.22473806e-02f, 1.85584828e-01f, 2.96742499e-01f, 2.76667178e-01f, 1.42491281e-01f, 2.06411287e-01f,
  7.28320703e-02f, 5.48514009e-01f, -1.29089355e-01f, -1.33682936e-01f, 3.46053834e-03f, 8.89626816e-02f, 1.93457097e-01f, -2.34511808e-01f, 9.34617743e-02f, 9.44838896e-02f,
  -2.26292084e-03f, 1.95087835e-01f, 7.89617598e-02f, 6.07450604e-02f, -4.01339196e-02f, 4.30715941e-02f, 8.55317712e-02f, 1.09273508e-01f, 4.78646345e-03f, 7.07380772e-02f,
  -5.89779131e-02f, 7.89752081e-02f, -9.03847590e-02f, -3.58338989e-02f, -1.99971721e-01f, 5.00923507e-02f, 1.06185563e-01f, 3.96121815e-02f, -1.47658587e-02f, -2.13103909e-02f,
  8.24469030e-02f, 1.43808216e-01f, 2.88707972e-01f, 5.94153907e-03f, -3.74426432e-02f, 2.87092596e-01f, 3.67524743e-01f, -1.71547264e-01f, 1.04618907e-01f, -4.67444994e-02f,
  4.66797203e-02f, -4.81077097e-02f, -1.79470792e-01f, -2.06752300e-01f, -6.91170013e-03f, 5.36075793e-02f, -3.47501129e-01f, -2.01885819e-01f, -3.15095156e-01f, 1.87177643e-01f,
  -9.30825807e-03f, -9.96639207e-02f, 4.17679310e-01f, -1.26513556e-01f, 2.43069202e-01f, -2.12781787e-01f, 1.04504898e-01f, 1.18477739e-01f, 1.77510321e-01f, -2.78812617e-01f,
  -1.77905738e-01f, 9.80309173e-02f, 1.76072836e-01f, 1.96842104e-01f, 2.88976163e-01f, -3.88484299e-02f, 3.44694614e-01f, -1.12672612e-01f, -3.42071563e-01f, -1.62486866e-01f,
  -8.46274123e-02f, 8.31794664e-02f, 2.02344298e-01f, 8.39539059e-03f, -4.93929051e-02f, 4.82526906e-02f, -6.85181841e-02f, 3.10634583e-01f, 4.05542031e-02f, 4.54377644e-02f,
  1.88891422e-02f, 1.59537956e-01f, -1.52105942e-01f, -3.83700505e-02f, -1.13621816e-01f, -1.29054323e-01f, 2.74105817e-02f, 6.35757064e-03f, -5.53815346e-03f, 1.71371978e-02f,
  1.18029445e-01f, 3.08586434e-02f, 5.05244955e-02f, 1.86921302e-02f, -1.82462577e-02f, -3.55303884e-02f, 3.49896640e-01f, -9.39120445e-03f, -5.09107951e-03f, 4.19412017e-01f,
  2.01254785e-01f, -3.93600911e-02f, 4.34329361e-01f, 3.02092850e-01f, 3.10548246e-01f, 7.52401203e-02f, -3.66136044e-01f, 1.69294953e-01f, 7.03804120e-02f, 1.70895427e-01f,
  -9.84699801e-02f, 6.67602271e-02f, -4.65932280e-01f, 2.54774749e-01f, 1.74521759e-01f, -1.20491602e-01f, 2.09664345e-01f, 7.95731042e-03f, -1.48510728e-02f, -4.50601354e-02f,
  8.74993764e-03f, -2.02802178e-02f, 2.37866491e-01f, -1.29684299e-01f, -9.27423313e-02f, 3.38762626e-02f, 1.21914661e-02f, 2.04261512e-01f, 4.36305642e-01f, -1.12179197e-01f,
  3.40648264e-01f, -4.04239744e-01f, -8.50393027e-02f, 1.59089789e-01f, -2.60217160e-01f, -2.65044160e-02f, -6.38821200e-02f, 6.27352893e-02f, -1.93186298e-01f, -2.23994225e-01f,
  -2.87140254e-02f, 7.56091103e-02f, -1.34799063e-01f, -1.80995628e-01f, -3.82214859e-02f, -3.34610231e-02f, 1.32670347e-02f, -1.65944889e-01f, -5.92006855e-02f, -7.07723200e-02f,
  -1.95951909e-01f, 3.61144878e-02f, 2.10233219e-02f, -1.27461106e-01f, -1.92929313e-01f, 5.55941202e-02f, 4.17368114e-02f, -5.05839624e-02f, 2.18906030e-02f, 5.82419783e-02f,
  -1.19578335e-02f, -3.30148414e-02f, -2.39941314e-01f, -2.07404733e-01f, -1.32341012e-01f, 1.24620691e-01f, 1.97685331e-01f, -1.28015548e-01f, 3.12029034e-01f, -1.04141710e-02f,
  1.08846292e-01f, 9.40942317e-02f, 1.29692435e-01f, 1.92883387e-01f, -9.14179757e-02f, 2.64770836e-01f, -2.38668397e-01f, 1.27506077e-01f, 1.67543128e-01f, 5.48215136e-02f,
  1.51434392e-01f, -1.45796910e-01f, 4.96426634e-02f, -1.06912963e-01f, 3.03122431e-01f, -1.47901714e-01f, 5.71648553e-02f, 8.20759982e-02f, -3.66082370e-01f, -3.52220088e-01f,
  1.87856466e-01f, 1.86775148e-01f, -8.73686448e-02f, -2.19974071e-01f, 1.02526873e-01f, -1.39757365e-01f, 2.28587836e-01f, -4.90024313e-02f, -2.00470071e-02f, 7.54186362e-02f,
  1.29327804e-01f, 2.69023050e-02f, -9.68455374e-02f, 1.41692087e-01f, 4.89477022e-03f, -1.00206643e-01f, 4.18074615e-02f, 1.02551639e-01f, 1.69955462e-01f, 1.96673558e-03f,
  1.74198434e-01f, 7.16937631e-02f, 1.78073317e-01f, -4.43654507e-03f, 2.85032447e-02f, -3.22978050e-02f, 3.81669439e-02f, -1.97761342e-01f, -2.36127213e-01f, -2.45666727e-01f,
  1.26387239e-01f, 1.57605886e-01f, 7.62359053e-02f, 1.55955911e-01f, -8.57776254e-02f, 1.15804654e-02f, -9.01715085e-02f, 1.14492439e-01f, 6.50768653e-02f, 6.24611005e-02f,
  -2.90129602e-01f, 1.60449192e-01f, 2.57161230e-01f, 1.02066338e-01f, 2.06958145e-01f, -1.15570992e-01f, 7.38579184e-02f, 1.69351041e-01f, -2.29124427e-02f, -4.77236696e-04f,
  -8.58394206e-02f, -2.36085504e-01f, -2.18538150e-01f, 1.85274437e-01f, -3.16286087e-01f, -1.39165968e-01f, 1.77373216e-01f, 3.62556607e-01f, 2.35580578e-01f, -6.57434538e-02f,
  2.21004218e-01f, -9.40464661e-02f, 3.51938128e-01f, 3.40389758e-01f, 1.20540954e-01f, -8.97760168e-02f, -3.18631142e-01f, -3.16734225e-01f, 1.65611342e-01f, 4.78528477e-02f,
  -1.10221513e-01f, 1.66340470e-01f, 1.17198952e-01f, 1.30037189e-01f, 1.76973835e-01f, 8.00225362e-02f, 2.29512695e-02f, 4.42492403e-02f, 4.24487107e-02f, 1.08057171e-01f,
  -7.61888130e-03f, 1.81238294e-01f, 3.19168866e-01f, 1.72474697e-01f, -1.11546129e-01f, -1.93210971e-02f, -6.36098087e-02f, -2.60854691e-01f, -2.20333248e-01f, 1.08254261e-01f,
  -1.00630321e-01f, -1.26783609e-01f, -3.02714258e-01f, 1.14419803e-01f, 1.77593485e-01f, 2.41532892e-01f, 5.84254414e-02f, -9.19234306e-02f, 3.37504707e-02f, -7.79470205e-02f,
  -2.02574600e-02f, 7.18788803e-01f, -9.41421315e-02f, -1.04883887e-01f, 4.07405376e-01f, -7.38519207e-02f, 2.70193994e-01f, 3.95160839e-02f, 3.14595193e-01f, 3.32641751e-01f,
  -1.73531562e-01f, -3.76103014e-01f, 1.28325790e-01f, -5.38740307e-02f, 1.37122720e-01f, 1.76226392e-01f, 1.27372622e-01f, -1.53796479e-01f, -6.76748808e-03f, 8.78666341e-02f,
  4.49405983e-02f, -2.02702522e-01f, -6.59578741e-02f, -5.32551892e-02f, -9.15097073e-02f, -4.20652479e-02f, 2.31809244e-01f, 1.77825883e-01f, -7.68118501e-02f, 2.71776080e-01f,
  -2.36299224e-02f, 1.42448425e-01f, -1.01843830e-02f, -1.19616233e-01f, 2.50928700e-01f, -3.07601900e-03f, 2.33112693e-01f, -3.78632247e-01f, 4.89653535e-02f, 9.84840244e-02f,
  2.61494368e-02f, 1.70290738e-01f, 1.91177785e-01f, 3.31278844e-03f, 3.57050374e-02f, 9.79503617e-03f, 1.84008911e-01f, -2.11951416e-02f, 1.28557399e-01f, 7.00772479e-02f,
  2.19826475e-02f, -2.03385711e-01f, 1.60954952e-01f, -8.45840201e-02f, -7.55391940e-02f, 1.25285587e-04f, -1.29896477e-01f, -3.35700065e-01f, 8.69646445e-02f, 1.88255385e-01f,
  2.10572347e-01f, 1.25010252e-01f, 2.73744911e-02f, -3.35364491e-02f, 1.72278881e-01f, -1.77602321e-02f, 2.27937281e-01f, 1.42239019e-01f, -3.41572911e-01f, 2.26525113e-01f,
  3.10148988e-02f, 1.53633669e-01f, 2.67834902e-01f, -3.19797128e-01f, 1.84934065e-01f, 2.34402597e-01f, 9.71445218e-02f, -1.73534453e-02f, 9.99848992e-02f, -2.06762478e-01f,
  -6.20525628e-02f, 2.53298134e-01f, -2.33909041e-01f, -5.34307361e-02f, 4.54983562e-01f, 3.66343796e-01f, -3.96243371e-02f, 2.14375168e-01f, 2.71876335e-01f, 9.33063626e-02f,
  1.08710323e-02f, 3.36874783e-01f, 9.33047161e-02f, -1.36254847e-01f, -1.93922088e-01f, 1.37196118e-02f, 2.67495662e-01f, 1.07348375e-01f, -1.46169677e-01f, 1.17091671e-01f,
  -6.84030354e-02f, 4.76810455e-01f, 5.33112958e-02f, 6.23358451e-02f, -4.74391393e-02f, -1.94336241e-03f, -1.12201376e-02f, -3.56213562e-02f, 6.70445785e-02f, 3.15940268e-02f,
  -8.51974860e-02f, 1.71038359e-01f, 7.70357177e-02f, 1.08445890e-01f, -1.18162064e-02f, -4.87582646e-02f, -3.01396191e-01f, 1.60998013e-02f, 1.13650657e-01f, -2.05398440e-01f,
  -1.42313898e-01f, 5.30906543e-02f, 5.39694726e-02f, -9.05118510e-02f, 1.40287668e-01f, -6.72693253e-02f, -6.18574433e-02f, -1.72170863e-01f, -1.92102790e-01f, 1.96990788e-01f,
  4.02137637e-01f, -8.84983465e-02f, 5.23318529e-01f, -1.39667541e-01f, -1.59375817e-01f, -1.16188727e-01f, -1.02534071e-01f, 2.22284332e-01f, 4.99335257e-03f, -3.60154420e-01f,
  1.95346877e-01f, 3.33474390e-03f, -1.23815335e-01f, 1.65150717e-01f, 2.64891624e-01f, -2.36308083e-01f, 2.93191373e-01f, 2.12530196e-01f, -2.28171647e-01f, -2.80726701e-01f,
  2.16975566e-02f, 3.51094082e-02f, 2.50902086e-01f, -1.25816077e-01f, 6.59670174e-01f, -9.36996862e-02f, 9.94749889e-02f, 2.18031034e-01f, 2.26688191e-01f, -3.08719426e-01f,
  4.79685552e-02f, -1.56006232e-01f, -1.61866359e-02f, 7.83483833e-02f, 1.18799113e-01f, -3.54748875e-01f, 1.82240948e-01f, 3.53663675e-02f, 2.09788918e-01f, -1.34765878e-02f,
  -6.05753772e-02f, 2.33445674e-01f, 9.64530408e-02f, 1.05278809e-02f, 1.47086084e-01f, 2.30942771e-01f, 1.53858438e-01f, 9.42675024e-02f, -3.59552470e-03f, -2.19099760e-01f,
  -8.84807780e-02f, 6.49465546e-02f, -2.04229467e-02f, 9.84136984e-02f, -2.50845164e-01f, -2.90669501e-01f, 2.72663981e-01f, 1.71002961e-04f, 9.05798599e-02f, 6.71553686e-02f,
  1.97029603e-03f, 1.39684647e-01f, 2.32763980e-02f, 4.73425150e-01f, -1.11267634e-01f, 1.73741445e-01f, -1.43634811e-01f, 2.68625677e-01f, 3.82181942e-01f, 3.08482386e-02f,
  4.94344652e-01f, -1.71909649e-02f, -1.65505901e-01f, 3.33138078e-01f, -2.50432491e-01f, -8.49724635e-02f, 3.88922215e-01f, 2.83712447e-01f, -3.83134633e-01f, -2.52885342e-01f,
  -1.73480093e-01f, -1.93470404e-01f, 2.53632776e-02f, 7.09376335e-02f, 2.82536089e-01f, 4.34968434e-02f, 9.45276320e-02f, 1.12562850e-02f, -1.57040805e-01f, 1.82411429e-02f,
  -1.08897295e-02f, 6.71608280e-03f, -4.67121214e-01f, 6.25922754e-02f, 1.50122777e-01f, 2.73829848e-01f, 2.44797692e-01f, 2.37086508e-02f, -1.82181094e-02f, 3.16281050e-01f,
  1.19063467e-01f, -2.95664966e-02f, -2.20476612e-02f, 8.48031938e-02f, 2.67535567e-01f, 1.79325685e-01f, 1.40977636e-01f, 1.62589923e-01f, -4.62936722e-02f, 7.34227747e-02f,
  -1.26843348e-01f, 1.62004650e-01f, -1.19491398e-01f, 1.90070927e-01f, -9.91668329e-02f, 2.79200953e-02f, 5.85713349e-02f, 2.70747095e-01f, 1.70600444e-01f, 9.52167585e-02f,
  5.82390949e-02f, -1.64898299e-02f, -2.01601088e-01f, -1.14043832e-01f, 1.07406927e-02f, -2.38879323e-02f, -8.72030184e-02f, -3.02345723e-01f, 4.00331803e-02f, 7.78910005e-03f,
  1.00013070e-01f, 2.03940168e-01f, 8.16864669e-02f, 1.65981889e-01f, 2.20330626e-01f, 7.96506330e-02f, 1.53348759e-01f, 2.03970924e-01f, -6.34088926e-03f, 1.87459275e-01f,
  3.18175584e-01f, 5.28925359e-01f, 1.51651233e-01f, -1.39568523e-01f, 2.19594583e-01f, 1.41743109e-01f, -4.19604838e-01f, -8.30318034e-02f, -8.13872647e-03f, 2.85820156e-01f,
  3.59633192e-03f, -1.77786127e-02f, -2.46681392e-01f, -8.46635997e-02f, -1.31546035e-02f, 3.76250058e-01f, 1.51311979e-02f, 4.97532278e-01f, 1.85562894e-02f, 3.18937242e-01f,
  3.24831791e-02f, -1.28299817e-01f, -7.31419325e-02f, 1.50355399e-01f, 1.66537091e-02f, 1.36889324e-01f, 3.66542935e-02f, 2.72494163e-02f, 2.01721743e-01f, 9.36550796e-02f,
  9.92224589e-02f, 3.34385745e-02f, 1.97714582e-01f, 2.90507078e-01f, 1.34482443e-01f, -1.10900827e-01f, -2.60423981e-02f, 1.19314693e-01f, 2.26092711e-02f, 1.18575789e-01f,
  -1.74971414e-03f, 9.36483964e-02f, 2.13894755e-01f, -9.70477462e-02f, -1.02760494e-01f, -7.67738372e-02f, 1.67080730e-01f, -1.13307364e-01f, 2.91023850e-01f, -2.01000899e-01f,
  -6.90002516e-02f, -2.65542902e-02f, 7.80323669e-02f, 5.14197908e-02f, -6.09874763e-02f, -8.36571157e-02f, -1.06760241e-01f, 3.31693947e-01f, -2.99762905e-01f, 6.78805709e-02f,
  5.30755445e-02f, 1.62006140e-01f, -1.11186109e-01f, -7.15186521e-02f, -7.17522204e-02f, 3.35342325e-02f, 2.69748066e-02f, 8.40367824e-02f, 1.06860518e-01f, -2.22426936e-01f,
  1.55651374e-02f, 1.91123765e-02f, 3.04695308e-01f, 4.65506166e-02f, 1.71959892e-01f, -2.54309028e-01f, -4.22843061e-02f, 1.58773661e-01f, 3.74131083e-01f, 1.01729184e-01f,
  1.02022029e-01f, 2.47802988e-01f, 1.52916223e-01f, -4.36199531e-02f, -1.74682692e-01f, 1.41864419e-01f, -1.65192172e-01f, -8.26502442e-02f, 1.45183623e-01f, 1.19068354e-01f,
  8.40486363e-02f, 1.85831055e-01f, 1.08302571e-01f, 4.94442992e-02f, 1.31947696e-02f, 1.30915627e-01f, 1.61088213e-01f, -6.21359749e-03f, 2.69989282e-01f, 5.41925579e-02f,
  5.21132164e-02f, -1.23728909e-01f, 1.26902595e-01f, -1.33862063e-01f, -3.50038856e-02f, -1.53095990e-01f, -2.34164987e-02f, -9.21617746e-02f, -3.15050073e-02f, 1.44046023e-02f,
  -3.36629748e-02f, 3.34372036e-02f, -2.45357677e-01f, 1.12267897e-01f, 3.58450502e-01f, -2.64259309e-01f, -1.35077704e-02f, -7.14513659e-03f, 1.46902427e-01f, 9.99988616e-03f,
  -2.73429930e-01f, -9.28917807e-03f, 5.11758663e-02f, 3.11454702e-02f, -1.11086061e-02f, 1.58752695e-01f, 2.53809184e-01f, -9.74162966e-02f, 3.66341546e-02f, 7.59415030e-02f,
  6.02452718e-02f, 3.68972659e-01f, 8.22163671e-02f, 1.68771178e-01f, 4.47363526e-01f, 3.43062729e-01f, 1.98031709e-01f, -2.05827564e-01f, -1.57583714e-01f, 3.31483424e-01f,
  3.42761844e-01f, 1.90561458e-01f, 1.47598982e-01f, -2.93284416e-01f, 1.31937370e-01f, -2.41010606e-01f, -1.63771048e-01f, 1.54560953e-01f, 1.51086167e-01f, 1.07798241e-01f,
  2.77657628e-01f, 4.08593565e-01f, -6.47843163e-03f, 3.50674577e-02f, -1.88820899e-01f, 9.20058042e-02f, -1.24540053e-01f, 4.15703729e-02f, 1.08888276e-01f, -4.66338322e-02f,
  -4.11729030e-02f, 6.44519329e-02f, 1.50035813e-01f, -1.42148972e-01f, -2.21024066e-01f, -2.00522915e-01f, -3.16704214e-02f, -1.68101471e-02f, -2.15982839e-01f, -5.99653870e-02f,
  -1.52443677e-01f, 2.16343045e-01f, -2.50278085e-01f, 3.95714715e-02f, 1.06764641e-02f, 1.52656093e-01f, -9.70343873e-03f, -1.98037729e-01f, -3.70202251e-02f, 3.17491889e-01f,
  3.86250585e-01f, -1.77638471e-01f, 4.59235907e-01f, -1.41403794e-01f, 2.49317974e-01f, 9.28467512e-02f, -2.55635977e-02f, 3.15876752e-01f, -1.25184149e-01f, 1.15138635e-01f,
  7.25270137e-02f, 4.48902361e-02f, -5.88473827e-02f, 1.40217543e-01f, 1.95942238e-01f, 2.43626237e-02f, 4.03673261e-01f, 6.37084097e-02f, -2.62668818e-01f, -3.49692225e-01f,
  2.43159071e-01f, -7.22972825e-02f, 1.41575694e-01f, -9.63793248e-02f, 2.24879041e-01f, -1.26034558e-01f, -8.69375281e-03f, 1.10154271e-01f, 2.79242218e-01f, -5.01911581e-01f,
  2.37110838e-01f, -7.36883003e-03f, 1.17034957e-01f, 3.62002030e-02f, -4.40586805e-01f, -1.22703001e-01f, 8.69341269e-02f, 3.37160863e-02f, -1.28268987e-01f, 8.24326128e-02f,
  8.01918805e-02f, -6.26567528e-02f, 1.01059318e-01f, -5.72254024e-02f, 9.56463218e-02f, 5.40043712e-02f, -1.11343883e-01f, 1.52796671e-01f, -1.89262986e-01f, -8.21119361e-03f,
  -1.45720914e-01f, -2.86090672e-02f, -6.03011735e-02f, 7.78292567e-02f, -5.56105450e-02f, 1.76131248e-01f, -2.39062741e-01f, 2.64640450e-02f, 3.78761217e-02f, 1.87118948e-01f,
  1.10089153e-01f, 2.09991381e-01f, -2.17239007e-01f, -2.07182109e-01f, 2.61082262e-01f, -5.36791086e-02f, 8.09751637e-03f, -2.69670129e-01f, 3.38084936e-01f, 1.35149330e-01f,
  3.54557306e-01f, -1.16188703e-02f, 3.64633054e-02f, 1.57657877e-01f, -1.24640346e-01f, 2.17522234e-01f, 1.23908222e-01f, -1.77784130e-01f, -7.40272403e-02f, -1.54818773e-01f,
  -2.63185143e-01f, -1.59356996e-01f, -1.94907561e-01f, -7.90822953e-02f, 1.70849726e-01f, 3.75869989e-01f, 1.99820295e-01f, -2.16061659e-02f, 5.18998206e-02f, -1.04280256e-01f,
  1.06064036e-01f, 3.26677263e-01f, -1.76605478e-01f, -1.02063335e-01f, 1.86951548e-01f, 2.39042994e-02f, -3.07759754e-02f, -1.07636161e-01f, -8.92742202e-02f, -2.31289268e-01f,
  1.35449409e-01f, 9.22257230e-02f, 1.58513620e-01f, 4.16144021e-02f, 1.50764585e-01f, 1.21387899e-01f, 1.19598456e-01f, 1.02318220e-01f, -1.02876216e-01f, 2.77518108e-02f,
  9.58870128e-02f, 1.37256786e-01f, -3.11150011e-02f, 1.55695900e-01f, -2.72872038e-02f, -5.42150848e-02f, -2.63615735e-02f, 9.91517007e-02f, 1.71998814e-01f, -1.47818252e-01f,
  -2.18793273e-01f, -7.49712810e-02f, -8.47539231e-02f, 7.08851740e-02f, 2.01380193e-01f, 3.50197665e-02f, 1.09291002e-01f, -3.20541620e-01f, 1.94198549e-01f, 1.20851673e-01f,
  -3.32063705e-01f, 3.28934759e-01f, -2.58330554e-01f, 8.70055333e-02f, 1.02699436e-01f, -3.91890585e-01f, 4.99252975e-02f, 1.95959508e-01f, -8.93807635e-02f, -2.97025330e-02f,
  2.70432919e-01f, 1.92787409e-01f, -3.80804092e-02f, 1.43977568e-01f, 8.15484077e-02f, -2.09704787e-02f, 3.45755517e-01f, 2.96837747e-01f, 1.71136612e-03f, 3.42557728e-01f,
  2.54485816e-01f, -7.93183502e-03f, -2.46659502e-01f, 6.19059578e-02f, 2.68290043e-01f, 7.88219087e-03f, 2.88987905e-02f, 7.09625408e-02f, 2.70721912e-01f, 1.08912788e-01f,
  -3.29377681e-01f, 1.46944419e-01f, -1.49711415e-01f, 5.40467143e-01f, 1.60111189e-01f, 2.42464058e-02f, 5.54218795e-03f, 3.86621915e-02f, 1.13094985e-01f, 1.09906718e-01f,
  -1.59664694e-02f, -3.21585722e-02f, 3.47230844e-02f, -8.50743800e-03f, 2.04425141e-01f, 7.84357265e-02f, 1.48124948e-01f, -6.15581386e-02f, 1.45579008e-02f, -3.19306552e-02f,
  1.02678528e-02f, 2.29453057e-01f, 1.94292903e-01f, -1.87176332e-01f, -1.17689498e-01f, -2.71675557e-01f, -1.12231210e-01f, -3.78424823e-02f, -4.00786325e-02f, -7.64783174e-02f,
  1.61600441e-01f, -4.17653054e-01f, 1.40351936e-01f, 5.81847951e-02f, -7.42867123e-03f, 2.26630315e-01f, -5.69338240e-02f, 2.41936833e-01f, -3.13200444e-01f, -6.52365312e-02f,
  2.29480071e-03f, 2.05873072e-01f, -1.17482588e-01f, 5.46773151e-02f, -1.71238735e-01f, -1.52958840e-01f, -2.23551184e-01f, 4.54687357e-01f, -1.88632622e-01f, -3.08797598e-01f,
  2.15531769e-03f, 4.97850150e-01f, 3.18930417e-01f, 9.97516289e-02f, 2.40876645e-01f, 1.75465792e-02f, 9.24882945e-04f, 2.18040273e-01f, 4.27266389e-01f, 5.49767688e-02f,
  -1.07277259e-01f, 1.24671429e-01f, 6.53495118e-02f, -1.47428706e-01f, -2.45925069e-01f, 3.70913446e-01f, -1.49344489e-01f, 1.14983171e-01f, 1.26771986e-01f, 8.28460678e-02f,
  2.83492990e-02f, 1.51742235e-01f, 2.34681200e-02f, 5.82308024e-02f, 2.60421574e-01f, -1.48436585e-02f, -2.15324298e-01f, -2.15002690e-02f, -3.72839198e-02f, 9.40434858e-02f,
  -1.23977713e-01f, 1.34163484e-01f, -1.82100907e-01f, -2.24326968e-01f, -6.09173030e-02f, -1.28295207e-02f, 2.80240644e-02f, 1.22798942e-01f, -1.96172148e-01f, -2.83353716e-01f,
  4.07138988e-02f, 4.05928455e-02f, 1.07126653e-01f, -2.48604685e-01f, -1.28995404e-01f, -3.53286982e-01f, 6.26945615e-01f, -2.09600464e-01f, 2.82940548e-02f, 4.48762532e-03f,
  -3.49330187e-01f, -7.11484160e-03f, -7.68374279e-02f, -4.51118350e-01f, 3.61591578e-02f, -1.83125302e-01f, -2.71335155e-01f, -1.11669257e-01f, -8.38530660e-02f, 8.90843347e-02f,
  4.92833674e-01f, -2.30407074e-01f, 1.87564656e-01f, -1.17461368e-01f, -5.83351869e-03f, -1.92219228e-01f, 2.00729612e-02f, 4.96946186e-01f, 2.28103831e-01f, -2.84375995e-01f,
  -2.75959909e-01f, -5.16935997e-02f, 1.85949177e-01f, 4.20628071e-01f, 2.25541949e-01f, 1.53362351e-02f, 1.46599159e-01f, -4.61796075e-02f, -5.32630980e-01f, 1.35025710e-01f,
  -5.30386046e-02f, 4.03327383e-02f, 2.67977901e-02f, 1.59155533e-01f, -2.49578860e-02f, -1.43737188e-02f, 8.33556950e-02f, 1.05046839e-01f, 9.23859328e-02f, -1.37503758e-01f,
  2.22021520e-01f, -7.39732161e-02f, 9.68595371e-02f, 1.36604309e-01f, -3.05999905e-01f, -2.50230730e-01f, 2.24104747e-01f, -1.06341928e-01f, -8.12698007e-02f, 1.11350957e-02f,
  -2.26491138e-01f, -1.12011604e-01f, 1.11747449e-02f, 1.90847173e-01f, 5.71348928e-02f, -1.16253935e-01f, -1.51664183e-01f, -1.60960764e-01f, 3.51820320e-01f, 6.81829974e-02f,
  -1.99004486e-01f, 1.28051564e-01f, 4.36376482e-01f, 1.87307119e-01f, -2.61325818e-02f, 2.15987906e-01f, 1.38376534e-01f, 4.92202379e-02f, -1.21399082e-01f, 3.31341594e-01f,
  7.00539500e-02f, -6.89243199e-03f, 1.82880804e-01f, 1.88487023e-01f, -3.02818179e-01f, 5.10585792e-02f, -1.07540563e-01f, 8.50859731e-02f, -6.00570403e-02f, -5.14648389e-04f,
  -2.89851688e-02f, -3.19015622e-01f, 1.07949197e-01f, 2.78866202e-01f, 9.30131450e-02f, -2.38203093e-01f, -6.28514513e-02f, 4.84179370e-02f, -3.62452753e-02f, -2.91691720e-01f,
  -3.75030981e-03f, 9.43255275e-02f, 4.03402776e-01f, 8.23083520e-02f, -1.78444028e-01f, 6.11453056e-01f, 2.87715644e-02f, 1.69920642e-02f, -8.21105689e-02f, 5.51431440e-02f,
  3.98734957e-02f, 2.66246833e-02f, 4.59515415e-02f, 8.18961039e-02f, 1.45895779e-01f, -7.25297853e-02f, 9.68138501e-02f, 3.60038653e-02f, -2.31844541e-02f, 3.74760851e-03f,
  2.38976553e-01f, -5.75575382e-02f, 2.57184021e-02f, 1.25027001e-01f, 1.13454610e-01f, 6.24220967e-02f, 1.50634199e-02f, -7.08693787e-02f, 3.06631252e-02f, -9.26923379e-02f,
  -1.30788609e-01f, -1.48013711e-01f, 4.53365803e-01f, -1.16068169e-01f, -2.95104712e-01f, -2.43396387e-01f, 3.74993682e-01f, 4.23904300e-01f, 6.13074973e-02f, 1.20147645e-01f,
  -1.09009422e-01f, 2.68805921e-01f, -8.00963957e-03f, 3.35538000e-01f, 2.35627994e-01f, -6.45258799e-02f, 1.12119190e-01f, 2.90984631e-01f, 1.45055443e-01f, 2.26779193e-01f,
  1.47786558e-01f, 3.75807911e-01f, -6.75427020e-02f, 3.78081165e-02f, 3.09680793e-02f, -4.49007422e-01f, 4.22246680e-02f, 2.30332986e-01f, -3.24229300e-02f, -2.97247350e-01f,
  -6.79480806e-02f, -2.65119188e-02f, 3.35781544e-01f, 1.27909377e-01f, 1.10630497e-01f, 2.57998586e-01f, 3.41183186e-01f, -2.36813612e-02f, -3.05692349e-02f, 3.91326189e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  2.02557266e-01f, 3.12501907e-01f, 1.60991192e-01f, 2.04364225e-01f, 1.05552539e-01f, 1.74698815e-01f, 1.56909794e-01f, -6.29766881e-02f, 1.25748828e-01f, 1.65436357e-01f,
  -3.68215740e-02f, 3.07761937e-01f, 2.95767874e-01f, -4.89883050e-02f, -2.27382500e-02f, 1.21737324e-01f, 9.16200876e-02f, 7.16603696e-02f, 6.86085224e-02f, 3.30144972e-01f,
  1.03470661e-01f, 2.71456867e-01f, -4.72591929e-02f, 2.58294016e-01f, 1.20700963e-01f, 2.27451295e-01f, 1.88904554e-01f, 2.48028543e-02f, 1.60745770e-01f, 1.23017408e-01f,
  2.09338352e-01f, 1.56663910e-01f, 1.22627988e-01f, 8.39606151e-02f, 1.83284551e-01f, 2.40037769e-01f, 1.72868207e-01f, 1.86137810e-01f, -1.53463101e-02f, -8.07166845e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  1.58117667e-01f, -4.08679307e-01f, -2.20582619e-01f, -3.58737037e-02f, -2.62705863e-01f, 1.38545781e-01f, 8.24588984e-02f, -3.22040588e-01f, -2.35583782e-01f, -5.87353017e-03f,
  -3.19107711e-01f, 2.99722217e-02f, -4.06839699e-02f, 6.30023554e-02f, -1.76515192e-01f, -2.70718008e-01f, -1.69974193e-01f, -2.46761054e-01f, -3.61926645e-01f, 4.86709960e-02f,
  9.36983302e-02f, -1.50049806e-01f, -1.18988104e-01f, 1.07852295e-01f, -3.88218462e-01f, -2.59928674e-01f, -3.95967573e-01f, -4.41482693e-01f, -1.33926600e-01f, -1.76008046e-01f,
  7.36252293e-02f, 2.09075928e-01f, 6.61824867e-02f, -5.23981042e-02f, -7.40358457e-02f, -2.30198786e-01f, -3.87313724e-01f, -2.45622873e-01f, 2.16559753e-01f, -7.64658600e-02f,
  1.23481080e-01f, -2.33130276e-01f, -2.59391010e-01f, -3.46292615e-01f, 2.11912528e-01f, -1.15245685e-01f, 1.58421785e-01f, -2.12841928e-01f, -7.84016401e-02f, -1.25690728e-01f,
  -4.59475011e-01f, 1.49850145e-01f, -3.76912594e-01f, -3.32358211e-01f, -4.22002673e-01f, -2.60567963e-01f, 2.94528157e-01f, -1.55422568e-01f, -5.26929498e-01f, 1.15472198e-01f,
  7.21856672e-03f, 1.88748501e-02f, 2.29168564e-01f, 2.91154504e-01f, -2.69742191e-01f, 1.02966204e-01f, 5.97445294e-02f, -7.41692185e-02f, 2.96931505e-01f, 6.67992309e-02f,
  -1.24544285e-01f, 9.07488242e-02f, -2.46969461e-02f, -9.20307939e-04f, 2.79417962e-01f, -4.93344724e-01f, -8.02850127e-02f, -2.48815175e-02f, -8.47664103e-03f, 1.64765179e-01f,
  7.56833255e-02f, -3.34528029e-01f, -2.96291728e-02f, -5.23983121e-01f, -2.73406386e-01f, 7.17049614e-02f, 4.47831959e-01f, 2.12585717e-01f, -5.14796138e-01f, 4.22673896e-02f,
  2.06124827e-01f, -2.02627435e-01f, -3.58250827e-01f, -3.43899935e-01f, 3.05489868e-01f, 7.82435387e-02f, -8.53035748e-01f, -1.47695050e-01f, -1.33614928e-01f, -3.00189197e-01f,
  -3.79148096e-01f, -2.35364825e-01f, 5.36618829e-01f, -4.11227942e-02f, 5.63271604e-02f, -1.06627256e-01f, -6.43127084e-01f, -8.14897656e-01f, -5.38432151e-02f, -5.53729497e-02f,
  -3.94054018e-02f, 8.17335304e-03f, 1.05507039e-01f, 2.39835948e-01f, -6.42724752e-01f, 2.53404528e-01f, -5.54035902e-02f, 2.01175123e-01f, -1.25446945e-01f, 2.83033192e-01f,
  2.25481503e-02f, 1.62955716e-01f, 2.12347601e-02f, 1.63301915e-01f, 3.60454440e-01f, -2.06635848e-01f, 1.18229374e-01f, -4.03485000e-02f, -2.85609752e-01f, 1.64902732e-01f,
  1.58331141e-01f, 1.51559964e-01f, 3.85281861e-01f, -2.01293349e-01f, -2.98718482e-01f, 1.41552985e-01f, -1.12638764e-01f, 5.30247577e-02f, -3.96759778e-01f, -2.29413882e-01f,
  -2.05862173e-03f, -2.37734653e-02f, 1.58847824e-01f, 3.01195979e-01f, 6.08557351e-02f, 2.86385745e-01f, -4.28391658e-02f, -3.18602808e-02f, -2.54893631e-01f, 3.19337070e-01f,
  -1.78976133e-01f, 1.75200433e-01f, -3.33554476e-01f, -2.27853984e-01f, 1.64817013e-02f, 1.00768574e-01f, -1.15111291e-01f, 1.73340142e-01f, -9.64200422e-02f, -1.88998297e-01f,
  -3.18207368e-02f, -3.48586261e-01f, -7.04584718e-02f, -4.26406175e-01f, 2.36304224e-01f, 5.36115289e-01f, 1.31476402e-01f, 2.18974248e-01f, 2.08463427e-02f, -7.65030831e-02f,
  -2.69894332e-01f, 1.84789337e-02f, -4.20430116e-02f, -5.52898467e-01f, -1.29210381e-02f, -2.54246622e-01f, -8.66515040e-02f, -1.26029655e-01f, -1.61153842e-02f, 5.12033105e-02f,
  -2.95680225e-01f, 2.69112736e-01f, 2.46327281e-01f, -4.33862388e-01f, 1.63824797e-01f, -1.79320410e-01f, -4.12436634e-01f, 1.12984069e-01f, -5.50934434e-01f, -2.98412323e-01f,
  2.59487540e-01f, 1.91853821e-01f, -3.16198170e-02f, -3.04888785e-01f, -3.41633588e-01f, 2.14706454e-02f, -1.58785939e-01f, -1.61547512e-01f, 1.82835355e-01f, -1.24790058e-01f,
  -2.56773084e-01f, 1.65495694e-01f, -1.35543719e-01f, -6.38574585e-02f, -4.56842929e-01f, 1.63864940e-01f, -2.52410233e-01f, 2.25053042e-01f, -3.11247945e-01f, 5.64048737e-02f,
  2.17122138e-01f, -2.55979359e-01f, 1.20196855e-02f, -6.17893040e-02f, -1.16955511e-01f, -1.33900896e-01f, 3.37531082e-02f, -2.09167480e-01f, -1.12208687e-01f, -2.40137830e-01f,
  5.84638119e-02f, -2.26832464e-01f, -4.09950793e-01f, 1.71640351e-01f, -3.29376012e-02f, -3.86740625e-01f, 2.85863101e-01f, -4.94392425e-01f, 3.41951847e-02f, 3.46321724e-02f,
  -2.90975004e-01f, 1.42083655e-03f, -5.83290868e-02f, -4.86512274e-01f, 9.08403769e-02f, 2.60712624e-01f, 1.22377165e-01f, -2.09597558e-01f, -1.86813369e-01f, 2.56293952e-01f,
  -6.19552970e-01f, -3.00273955e-01f, 2.26540357e-01f, -3.77725422e-01f, 3.98810893e-01f, -5.00530660e-01f, -3.05386394e-01f, 4.21315171e-02f, -2.17658002e-02f, 4.51470017e-01f,
  -3.78773272e-01f, -5.91133952e-01f, -3.63228440e-01f, -4.31619883e-01f, -1.30728170e-01f, 1.29501894e-01f, 3.70315522e-01f, 2.85891801e-01f, 2.99866974e-01f, -1.80140868e-01f,
  3.38538617e-01f, 3.85572053e-02f, -2.84898520e-01f, 3.40214133e-01f, 3.75150681e-01f, -2.71773010e-01f, 2.66443882e-02f, -5.84103689e-02f, 2.36085430e-01f, 1.55999288e-01f,
  3.08475733e-01f, 3.38282079e-01f, -2.84007221e-01f, 4.13862348e-01f, 1.48743540e-01f, 2.55602181e-01f, 3.65032494e-01f, -4.43200886e-01f, -2.02854142e-01f, -6.32566035e-01f,
  -3.62280421e-02f, -4.63921353e-02f, -2.92357236e-01f, -6.90773800e-02f, 1.02159843e-01f, -2.02304348e-01f, -7.47731104e-02f, 2.00258210e-01f, 1.31891176e-01f, 3.09350304e-02f,
  -1.64448574e-01f, 1.84521198e-01f, 1.34892270e-01f, 4.06980425e-01f, -2.96115428e-01f, -2.74826348e-01f, -1.55865178e-01f, -4.80786301e-02f, -2.54065186e-01f, 3.69099192e-02f,
  1.40154481e-01f, 2.65842497e-01f, -3.75364311e-02f, 7.48619884e-02f, 7.69387186e-02f, -2.15509325e-01f, -4.27808054e-02f, -4.77516614e-02f, -1.69572949e-01f, -3.18116963e-01f,
  1.35228515e-01f, -1.96403950e-01f, -1.47236481e-01f, -7.00498760e-01f, 7.85261542e-02f, -8.79964828e-02f, -2.38298327e-01f, 3.11550736e-01f, -3.39097917e-01f, 8.50209892e-02f,
  -1.95435435e-01f, 2.26716980e-01f, -1.77601308e-01f, 1.81531221e-01f, -1.10387892e-01f, 8.07759687e-02f, -4.85340431e-02f, 1.64407820e-01f, 2.13148728e-01f, 1.56526402e-01f,
  6.33745939e-02f, 2.84189194e-01f, -2.03596931e-02f, 1.29287109e-01f, 1.05067708e-01f, 4.96871546e-02f, 9.28200409e-02f, -4.19552028e-01f, 5.94681725e-02f, 4.47798193e-01f,
  2.89646536e-01f, -2.46569663e-01f, 3.10245473e-02f, -1.04819834e-01f, 4.08219695e-01f, 3.86780202e-01f, 2.55341798e-01f, 2.23924384e-01f, -1.33382708e-01f, -3.84677619e-01f,
  1.21561252e-01f, -1.56320900e-01f, -2.52797991e-01f, 1.59115061e-01f, -1.98053584e-01f, 3.38670641e-01f, -5.43495536e-01f, -3.37044388e-01f, -4.25015002e-01f, -5.72237670e-01f,
  -8.73913914e-02f, 1.98340937e-02f, 5.06407380e-01f, 3.07293236e-01f, -9.73724667e-03f, 2.30890941e-02f, -1.06044404e-01f, -1.43758357e-01f, 7.70772621e-02f, 2.03672439e-01f,
  -2.92342067e-01f, 1.98160902e-01f, -4.38994408e-01f, -2.29558870e-01f, -3.03000629e-01f, 2.08747923e-01f, 1.57078639e-01f, -2.95218378e-01f, -1.34381667e-01f, 7.91121200e-02f,
  2.84591973e-01f, -2.59226859e-01f, -6.00013435e-01f, -4.07875121e-01f, -1.73675820e-01f, -2.83916712e-01f, -2.75503665e-01f, 6.72649518e-02f, -3.63671571e-01f, 1.43171266e-01f,
  2.28578568e-01f, -8.26821029e-02f, -1.87523380e-01f, -2.25726366e-01f, 4.03491147e-02f, 6.86642453e-02f, -3.29831392e-02f, 1.58345804e-01f, -1.58273160e-01f, -1.21350907e-01f,
  1.37039632e-01f, 1.23063140e-01f, -5.48541034e-03f, 2.45473891e-01f, 8.23432058e-02f, 2.16077581e-01f, -1.62546247e-01f, 5.85332103e-02f, 2.48392709e-02f, -1.62592590e-01f,
  4.43248153e-01f, 4.91826609e-02f, 4.52558249e-02f, 1.45033777e-01f, -1.69077694e-01f, -5.50141871e-01f, 1.61937416e-01f, -6.07093513e-01f, -4.39190000e-01f, 2.53737450e-01f,
  -6.21082485e-02f, 2.08461493e-01f, -1.51301056e-01f, 5.42565584e-02f, 4.82366756e-02f, 1.35113010e-02f, -1.24223009e-01f, -3.67754936e-01f, -6.26343250e-01f, -1.07333511e-01f,
  -2.66031265e-01f, -5.75383127e-01f, -2.07606137e-01f, -4.81213480e-02f, -3.83913517e-01f, 1.04567014e-01f, -2.86707953e-02f, -1.23533038e-02f, 1.48055717e-01f, -4.19540815e-02f,
  -2.29208469e-01f, -8.68601054e-02f, 3.46092492e-01f, 2.31807813e-01f, -1.02971904e-01f, 3.15277666e-01f, -3.70823026e-01f, -5.54238439e-01f, 5.92058115e-02f, 1.00932546e-01f,
  1.96670502e-01f, -2.09645510e-01f, -2.46661514e-01f, -1.85479239e-01f, -1.21434435e-01f, -2.41538689e-01f, -8.05595517e-02f, -5.25480174e-02f, -1.35442987e-01f, -2.22043768e-01f,
  6.95599765e-02f, 1.18077733e-01f, -6.88015623e-03f, -3.37601900e-02f, -3.48637432e-01f, 2.11782426e-01f, -2.68056005e-01f, -9.84279253e-03f, 7.48514086e-02f, 1.32524416e-01f,
  -8.82493705e-02f, 2.51678735e-01f, -4.50323045e-04f, -1.01469576e-01f, -2.45518953e-01f, 2.66779393e-01f, 1.78368986e-01f, 1.80583358e-01f, -1.73941970e-01f, -1.75292924e-01f,
  -3.50575715e-01f, 1.45188659e-01f, 1.73994765e-01f, -3.32093269e-01f, -2.04587013e-01f, -1.44257158e-01f, -1.68368667e-01f, -3.14991951e-01f, -2.98657387e-01f, 2.24855840e-02f,
  3.12353432e-01f, 1.53550923e-01f, -9.07152817e-02f, 3.95331010e-02f, -1.95393533e-01f, 3.19499560e-02f, 2.08260700e-01f, -1.19590536e-02f, 2.51589477e-01f, -4.41798568e-01f,
  1.45663008e-01f, 1.37203455e-01f, 1.03660345e-01f, -2.30865896e-01f, -3.66791666e-01f, 2.36154109e-01f, 1.68014839e-01f, -3.19012254e-01f, -9.02960971e-02f, -3.53335917e-01f,
  1.60307974e-01f, -8.75372663e-02f, 3.54313940e-01f, -8.34310427e-03f, -9.38781537e-03f, 9.56152007e-02f, -2.28249088e-01f, 7.26321489e-02f, 2.05191001e-01f, -6.30331784e-02f,
  2.02845484e-01f, -1.65243044e-01f, 1.81180015e-01f, 1.34978309e-01f, 1.19564787e-01f, 3.41810703e-01f, 2.19790801e-01f, -5.40487409e-01f, 2.21182287e-01f, -3.51306438e-01f,
  -1.47731826e-01f, -1.07019745e-01f, 4.20289099e-01f, 4.13171738e-01f, 1.04127422e-01f, 1.98929816e-01f, -2.89614499e-01f, 1.95745468e-01f, 8.85996148e-02f, -1.42930105e-01f,
  -5.29381752e-01f, -2.05344483e-01f, -3.66093904e-01f, -3.40507090e-01f, -3.20313752e-01f, -6.78975657e-02f, 1.32129088e-01f, -2.55893022e-01f, 3.29834223e-02f, -3.32574606e-01f,
  -1.33750185e-01f, 3.19723785e-01f, 1.37041926e-01f, 2.07136571e-01f, -7.61968121e-02f, 4.67256516e-01f, -1.08741701e-01f, -4.79055882e-01f, 3.18216920e-01f, 3.63661289e-01f,
  -2.21627533e-01f, 1.32576421e-01f, 3.27302188e-01f, 1.86403021e-01f, -1.96128070e-01f, 2.87771732e-01f, -4.69049007e-01f, 5.15861697e-02f, -5.13078570e-01f, 2.03605250e-01f,
  -4.35617343e-02f, -1.63699806e-01f, -3.82618040e-01f, -5.30395508e-01f, 6.80027483e-03f, -2.16613352e-01f, -3.93186688e-01f, 5.74900620e-02f, -6.53199404e-02f, 6.03970326e-02f,
  7.68201947e-02f, -2.00913221e-01f, 2.09181175e-01f, -1.03921108e-01f, 4.61558774e-02f, 5.09904146e-01f, -1.94363820e-03f, 1.45026952e-01f, 1.98019430e-01f, -5.93184233e-01f,
  -4.42191511e-01f, -2.53383398e-01f, 5.24533391e-01f, 2.39381239e-01f, 3.62588376e-01f, 1.24937646e-01f, -6.18087471e-01f, -8.31533410e-03f, -1.76160298e-02f, 2.22181603e-01f,
  2.68698722e-01f, 4.20891568e-02f, -1.95938647e-01f, 2.27321848e-01f, 7.72855729e-02f, 2.39484996e-01f, 6.42169267e-02f, 4.65705320e-02f, 1.23844475e-01f, 3.38595122e-01f,
  -5.19026458e-01f, 3.82016420e-01f, 2.63257146e-01f, -6.60623372e-01f, -7.60197759e-01f, 2.56389916e-01f, 9.01035890e-02f, -1.34169385e-01f, -2.03073785e-01f, -4.42416012e-01f,
  -1.11490950e-01f, 8.14635456e-02f, -6.50421619e-01f, -5.94449043e-01f, -2.43953124e-01f, -1.73319504e-01f, 4.47237752e-02f, -4.04238313e-01f, -2.36581251e-01f, 8.34067166e-02f,
  5.24732731e-02f, 8.62896219e-02f, -8.17197263e-02f, -2.79207498e-01f, -6.82571605e-02f, -1.73918441e-01f, -1.03130907e-01f, -6.41271949e-01f, -5.68574890e-02f, 3.23374476e-03f,
  1.49304509e-01f, 1.87041178e-01f, 1.96546316e-03f, -1.53877318e-01f, 1.50250658e-01f, -6.84393123e-02f, 1.35355636e-01f, 5.63125946e-02f, -2.64302254e-01f, -8.79281089e-02f,
  2.42616788e-01f, 1.42679513e-01f, 3.63891721e-02f, 3.37785572e-01f, 2.38908470e-01f, 1.03807658e-01f, 2.98986822e-01f, 2.42069647e-01f, 2.91264988e-02f, -3.06062251e-01f,
  3.06003243e-01f, -2.76461154e-01f, 1.57310888e-01f, -2.04487428e-01f, -3.47737372e-01f, -3.71684492e-01f, -2.21158430e-01f, -2.73122221e-01f, -7.14914322e-01f, -9.13728476e-02f,
  1.55781329e-01f, -5.24189591e-01f, -3.86313081e-01f, -4.12641674e-01f, 3.60363096e-01f, 2.94410110e-01f, 4.73335564e-01f, -1.11450210e-01f, 1.43337166e-02f, -3.32131058e-01f,
  -4.67217207e-01f, 4.31501061e-01f, 3.60286772e-01f, 1.50309891e-01f, -4.15833890e-02f, 3.28775078e-01f, -2.66622156e-01f, -3.54558796e-01f, -3.50002408e-01f, 2.58325875e-01f,
  2.04873964e-01f, -6.95603574e-03f, 5.60442090e-01f, -6.90659285e-02f, -2.52048790e-01f, -2.25190058e-01f, 7.20371902e-02f, -1.58842608e-01f, -1.16772212e-01f, -3.25345635e-01f,
  -2.49908179e-01f, -4.31124061e-01f, -1.88759357e-01f, -3.60483497e-01f, 4.06029195e-01f, -2.03660816e-01f, 1.65934220e-01f, 1.02196224e-01f, 6.85488433e-02f, 2.63205558e-01f,
  7.99338857e-04f, -1.21037569e-02f, 7.69167319e-02f, 1.94830582e-01f, 2.09425494e-01f, 2.20296562e-01f, -1.58006608e-01f, -3.67167383e-01f, -1.03966057e-01f, -2.69006312e-01f,
  2.22129211e-01f, 2.34413538e-02f, -2.44441003e-01f, 2.63818413e-01f, -2.70879656e-01f, 3.14310133e-01f, -8.09898004e-02f, -2.76129484e-01f, 2.85334766e-01f, 1.78979769e-01f,
  -1.47210225e-01f, -3.21718991e-01f, -1.85032979e-01f, -2.72342172e-02f, -3.22539806e-01f, -6.58557117e-02f, 1.38691798e-01f, 1.29330248e-01f, -2.53317475e-01f, -2.26012766e-01f,
  2.76795238e-01f, 1.35681912e-01f, -6.20919615e-02f, -3.42827141e-01f, -4.52775329e-01f, 6.80833533e-02f, -1.05202377e-01f, 2.41043076e-01f, -4.99211073e-01f, -3.57955247e-01f,
  3.32337141e-01f, 3.42990160e-01f, -6.60260767e-02f, -3.24457318e-01f, -3.47519696e-01f, -4.36135352e-01f, 3.70478690e-01f, -4.15435821e-01f, 3.17986757e-02f, 3.22345018e-01f,
  -3.09196532e-01f, 1.34637743e-01f, -1.22593582e-01f, 1.85148835e-01f, 1.53585806e-01f, 6.03985071e-01f, -3.92889738e-01f, -1.86859630e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.61561698e-01f, -9.09955278e-02f, -1.18014552e-02f, 7.65441277e-04f, -1.29657999e-01f, 1.52177736e-01f, 7.84671381e-02f, -8.51374492e-02f, -3.86670865e-02f, 1.98676530e-02f,
  8.43098983e-02f, 1.06239341e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    