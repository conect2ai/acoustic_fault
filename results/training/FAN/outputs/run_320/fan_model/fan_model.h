/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.24234813e-02f, 1.40520573e-01f, 2.35319093e-01f, -7.06845075e-02f, -5.03428318e-02f, -3.25058438e-02f, 9.18467715e-03f, -1.19330520e-02f, 1.94545791e-01f, -3.66436020e-02f,
  -1.26293465e-01f, 2.35541254e-01f, 8.21031258e-02f, -1.69460431e-01f, 5.90690225e-02f, 8.66277888e-02f, -1.28566608e-01f, 4.95901331e-02f, 7.14774430e-02f, -4.67454307e-02f,
  -1.94124207e-02f, -2.27115229e-01f, 6.15818799e-02f, 2.89555336e-03f, -8.37309584e-02f, 7.60238525e-03f, -1.13529854e-01f, 6.56559244e-02f, -1.37565121e-01f, -1.53101636e-02f,
  -9.97861549e-02f, -1.66641548e-02f, -1.33618815e-02f, 1.27551675e-01f, -1.28081903e-01f, 4.34323251e-02f, 4.86777909e-02f, 3.83865573e-02f, 2.58260071e-02f, 3.24472077e-02f,
  5.47584705e-02f, -4.12394255e-02f, 4.38173749e-02f, -1.23846140e-02f, 8.10376108e-02f, 4.27467935e-02f, 2.54274737e-02f, -2.86299773e-02f, 8.38693082e-02f, -4.47990783e-02f,
  2.87957136e-02f, -7.28928670e-03f, -3.20144668e-02f, 4.66548875e-02f, 9.82707962e-02f, 1.18435444e-02f, 1.47676989e-02f, 1.68669363e-03f, -6.49947301e-03f, -3.88744436e-02f,
  -6.77142059e-04f, 5.89418132e-03f, 5.44587858e-02f, -6.24973923e-02f, 2.87237507e-03f, -2.50962805e-02f, 2.49311700e-02f, -4.48621772e-02f, 3.06455564e-04f, -3.71156111e-02f,
  -8.32237229e-02f, -1.75845269e-02f, -3.14645916e-02f, 3.11286617e-02f, -1.34522654e-02f, -2.93527152e-02f, -3.69830951e-02f, -3.01070921e-02f, -1.15143964e-02f, -2.27581393e-02f,
  1.19543979e-02f, -2.08515283e-02f, 1.72178783e-02f, -4.66776490e-02f, -6.88063493e-03f, 9.90619287e-02f, -1.02885449e-02f, 5.62054254e-02f, -7.62945935e-02f, 3.24327522e-03f,
  -2.09673196e-01f, -3.34472284e-02f, -1.20317899e-02f, -1.25294048e-02f, 7.54783582e-03f, 3.49768922e-02f, 5.49300835e-02f, -2.88689267e-02f, 7.11605744e-03f, -5.10388762e-02f,
  1.83161034e-03f, 9.93707404e-03f, -2.73841936e-02f, -4.23174389e-02f, -4.43884321e-02f, -2.95926556e-02f, 1.97564196e-02f, -4.99846451e-02f, -1.32383496e-01f, -7.44636953e-02f,
  -8.79660994e-03f, 1.12724937e-02f, -1.01400781e-02f, -5.50340451e-02f, -9.05975848e-02f, -8.31150785e-02f, 4.08919416e-02f, 6.47775829e-02f, -1.54901538e-02f, 2.85856184e-02f,
  -2.94012994e-01f, -7.28698224e-02f, -3.26940268e-02f, -1.33466586e-01f, -1.35576338e-01f, 2.93216668e-02f, 1.77875519e-01f, -2.34263092e-01f, -1.02728503e-02f, -7.06015229e-02f,
  8.21825862e-02f, -2.55772378e-02f, 3.26913267e-01f, -6.32183254e-02f, 1.41839623e-01f, 2.97546029e-01f, -6.44685254e-02f, 6.11205399e-02f, 5.25350682e-02f, -1.74264997e-01f,
  3.79128344e-02f, -9.15352702e-02f, 1.46087781e-01f, -1.33304760e-01f, -1.17832132e-01f, -9.33125541e-02f, -1.23976141e-01f, 1.56909689e-01f, -1.89046383e-01f, 1.70264915e-02f,
  2.00280417e-02f, 3.42695192e-02f, 8.59532412e-03f, 8.23699161e-02f, -2.58508306e-02f, -1.17784841e-02f, -2.75160149e-02f, 1.86531484e-01f, 4.95850258e-02f, 7.47664347e-02f,
  -3.46739739e-02f, -5.12110405e-02f, -6.04962707e-02f, -4.68565039e-02f, -1.00854456e-01f, -3.98363732e-02f, 4.36961316e-02f, -1.65159032e-02f, -6.02950454e-02f, 4.01507095e-02f,
  5.02935387e-02f, 8.00008029e-02f, -7.87411109e-02f, -1.69954151e-02f, 1.67195648e-02f, 7.48979971e-02f, 8.60322490e-02f, 7.78563228e-03f, -7.14675412e-02f, -9.81271174e-03f,
  -1.43795935e-02f, 1.12371650e-02f, -4.77624300e-04f, 2.26065796e-02f, -9.15859547e-03f, -5.14585292e-03f, -3.85100581e-02f, 4.60428856e-02f, -3.03168427e-02f, 3.15069743e-02f,
  -5.03801741e-03f, -1.17232464e-02f, -3.74721899e-03f, -3.00985575e-03f, -1.68578122e-02f, 2.00985894e-02f, 3.89415515e-03f, 5.93645051e-02f, -2.77316961e-02f, 3.80622200e-03f,
  6.42890334e-02f, -3.09975725e-02f, 2.57353648e-03f, 2.94367801e-02f, 2.86156107e-02f, -3.04895826e-02f, 4.20018956e-02f, -4.41185497e-02f, 8.48615766e-02f, -1.25938514e-02f,
  -5.62414899e-02f, 3.28305848e-02f, -4.98394854e-03f, -2.37178337e-03f, 3.40952389e-02f, -1.80072114e-02f, 4.64188755e-02f, -1.08243890e-01f, 1.28893377e-02f, 4.07597329e-03f,
  -1.62065902e-03f, 2.09340751e-02f, -5.37997186e-02f, 2.17197277e-02f, 7.83497095e-02f, -8.54065549e-03f, -8.38767085e-03f, 2.34217998e-02f, 1.48321558e-02f, -6.86655417e-02f,
  -4.80691008e-02f, -2.01417580e-02f, 3.93518582e-02f, -8.09321925e-02f, -6.97019696e-02f, -1.04594249e-02f, -7.16217533e-02f, 3.94026488e-02f, -8.06456141e-04f, -2.65699606e-02f,
  -1.32071048e-01f, 1.29969254e-01f, 1.70803100e-01f, 9.57562253e-02f, -3.39773372e-02f, -2.15690017e-01f, -2.21871227e-01f, -5.68514131e-03f, -1.32434532e-01f, 4.29667681e-02f,
  -3.83074768e-02f, 1.98122084e-01f, -7.20786378e-02f, 3.95436399e-02f, -1.39127731e-01f, 2.35753017e-03f, -1.19921662e-01f, 1.12538502e-01f, 9.01220143e-02f, -7.86277931e-03f,
  -1.27521232e-01f, -1.66915819e-01f, 2.22532079e-02f, 3.49112079e-02f, 3.04715522e-02f, 6.58176914e-02f, 4.82714251e-02f, -4.99613099e-02f, 8.35874602e-02f, -2.81169266e-02f,
  -6.62812265e-03f, -4.67687026e-02f, 1.23446863e-02f, -2.64341943e-02f, 4.29543704e-02f, 3.99320908e-02f, 2.79169716e-02f, 1.89862065e-02f, -7.51371682e-02f, 3.80154178e-02f,
  7.02025145e-02f, 3.25297043e-02f, 5.63690923e-02f, -3.78186516e-02f, -8.90024379e-02f, 1.84001345e-02f, 1.07116560e-02f, 3.47622372e-02f, -7.82560781e-02f, 5.53085543e-02f,
  3.24562006e-02f, 1.84719265e-02f, 7.59435445e-02f, 6.41639084e-02f, -1.01586236e-04f, 3.34718972e-02f, 3.84888314e-02f, 3.41899274e-03f, 4.19939309e-02f, 3.82378846e-02f,
  7.60017633e-02f, -2.23900843e-02f, 2.70640533e-02f, 1.07355036e-01f, 2.48328573e-03f, -2.18721703e-02f, -3.07329465e-02f, -6.07067831e-02f, 2.89972425e-02f, -6.63895085e-02f,
  1.25801247e-02f, 4.92364429e-02f, 5.00823073e-02f, 3.88537087e-02f, -4.06202227e-02f, 9.10525396e-02f, 4.92780246e-02f, 1.77281629e-02f, -3.74026154e-03f, -7.87298288e-03f,
  3.77814993e-02f, -4.42894250e-02f, -8.38518981e-03f, 2.08298843e-02f, 4.11136970e-02f, -6.48427531e-02f, 2.29804241e-03f, -5.10234460e-02f, 9.02537629e-02f, -3.15037556e-02f,
  2.43276339e-02f, 6.89642280e-02f, -1.66910701e-03f, -1.67035765e-03f, -1.15923444e-02f, 5.78194857e-02f, 2.18892414e-02f, 9.57117006e-02f, 3.26027200e-02f, -4.20962833e-02f,
  6.35777414e-02f, -5.08712865e-02f, -5.45158014e-02f, 1.85496416e-02f, -1.40956743e-03f, -4.75105410e-03f, 6.60633445e-02f, 3.87244113e-02f, 4.71072309e-02f, 1.58240572e-02f,
  -2.30539986e-03f, 4.21716645e-02f, 1.22213247e-03f, -5.71278557e-02f, -1.38614364e-02f, 3.50837633e-02f, 3.01860962e-02f, 2.03302950e-02f, -6.76458329e-02f, -3.36400233e-02f,
  1.61898792e-01f, 6.72113597e-02f, -1.13760799e-01f, 6.25915602e-02f, 2.43521050e-01f, 2.04748929e-01f, 9.81160328e-02f, 1.72810793e-01f, 2.79336184e-01f, -1.16971023e-01f,
  1.96061097e-02f, -1.71067327e-01f, -1.50997624e-01f, -2.53386982e-02f, -3.33644859e-02f, -3.02223731e-02f, 1.81086510e-01f, 5.92624256e-03f, 1.80970222e-01f, 7.87798688e-02f,
  1.28629848e-01f, 1.23212986e-01f, -1.92129359e-01f, 3.26782614e-02f, 3.96723561e-02f, -5.15961610e-02f, -4.58442830e-02f, -1.87669434e-02f, -8.76494646e-02f, -1.41886706e-02f,
  1.97661892e-01f, 2.30423715e-02f, -7.78242648e-02f, -4.42318544e-02f, 2.79584490e-02f, 3.61617729e-02f, 1.19503839e-02f, -5.49387559e-02f, 2.54332088e-02f, 3.37256566e-02f,
  -5.07135019e-02f, -8.40776041e-02f, 6.69490993e-02f, -2.09352672e-02f, 9.65459868e-02f, -3.23411799e-03f, -3.57528478e-02f, 2.03323513e-02f, -1.32834744e-02f, -5.38664311e-02f,
  -3.57097350e-02f, -6.49302006e-02f, -1.81459486e-02f, 4.04091179e-02f, -1.68505125e-02f, 3.52468602e-02f, -8.68767127e-02f, -1.93538498e-02f, 6.65603206e-02f, 6.85285702e-02f,
  5.96147664e-02f, -1.93076476e-03f, 2.26937402e-02f, -8.22976008e-02f, 5.79249440e-03f, -1.48296598e-02f, -4.96506989e-02f, 2.69424282e-02f, 1.32006081e-03f, -2.23531220e-02f,
  -4.93983831e-03f, 6.99912757e-02f, 1.12698600e-02f, 6.84633851e-02f, -1.12489080e-02f, 4.21428634e-03f, 9.56216268e-03f, 9.12797078e-03f, 3.28066945e-02f, -5.35468273e-02f,
  3.56921069e-02f, 6.51600510e-02f, -7.66270757e-02f, 2.43458562e-02f, 2.24529747e-02f, -3.63202095e-02f, 3.82615142e-02f, 1.59819871e-02f, 5.91180734e-02f, 5.97039936e-03f,
  1.78560853e-01f, 2.69106448e-01f, 3.68051976e-02f, 6.69289380e-02f, 3.97136696e-02f, -1.20783625e-02f, 1.55422278e-02f, -1.19529329e-02f, 9.83161852e-02f, 7.08551630e-02f,
  3.20856124e-02f, 1.45973423e-02f, 3.36941034e-02f, -3.42772342e-02f, -2.31859181e-02f, 6.20695725e-02f, 3.20229791e-02f, 9.91415009e-02f, 7.30903819e-02f, -2.11061398e-03f,
  -6.85196444e-02f, 5.68542443e-02f, -7.58923665e-02f, 1.07552977e-02f, -3.14571522e-02f, -6.77209049e-02f, 8.23054090e-02f, -3.98362279e-02f, -1.54862870e-02f, -1.05390819e-02f,
  -1.05030753e-01f, 1.96415126e-01f, 9.27195724e-05f, 2.51198083e-01f, -8.59837756e-02f, 4.03337657e-01f, 5.00906706e-01f, 2.54027918e-03f, -1.89676124e-03f, 3.12851310e-01f,
  8.63719806e-02f, 3.03729977e-02f, -7.38982335e-02f, 3.30486476e-01f, 3.87108396e-03f, 8.67367312e-02f, 2.87139535e-01f, 1.77503467e-01f, -1.04690850e-01f, -7.98002351e-03f,
  -6.00016303e-02f, 1.14348352e-01f, 6.78609684e-03f, -8.84122252e-02f, 7.41474107e-02f, -8.12011063e-02f, -6.14100359e-02f, -4.45965677e-02f, 9.66132134e-02f, 7.43573252e-03f,
  6.14123680e-02f, -6.45511411e-03f, -7.87375215e-03f, -1.89848933e-02f, 1.06777444e-01f, 6.11749776e-02f, -9.70061217e-03f, -3.64186205e-02f, -3.50975208e-02f, 4.06022668e-02f,
  5.49412370e-02f, -4.85320799e-02f, 1.76807102e-02f, 1.73497964e-02f, -2.87631284e-02f, -5.15967347e-02f, -7.86145031e-02f, -6.00049854e-04f, 3.01273284e-03f, -3.97739895e-02f,
  -7.24698370e-03f, 9.89203993e-03f, 1.38369119e-02f, 2.64693499e-02f, -3.74365710e-02f, -4.23929431e-02f, 4.92834672e-02f, 9.45640076e-03f, 5.22680208e-02f, 2.45087296e-02f,
  9.72750690e-03f, 4.28336449e-02f, 1.76234934e-02f, -3.78133217e-03f, -1.67072564e-02f, 7.19148293e-03f, 3.75273041e-02f, -2.80488059e-02f, -2.91406959e-02f, -2.40512588e-03f,
  1.31656211e-02f, 3.56205292e-02f, -2.28818748e-02f, 5.25696464e-02f, 5.12194298e-02f, 4.17215750e-02f, -3.97945978e-02f, 1.76594742e-02f, 2.66600656e-03f, 1.32767679e-02f,
  2.54908595e-02f, -3.93235385e-02f, 1.73511412e-02f, 5.36206998e-02f, -2.18169782e-02f, -2.37630755e-02f, -3.13956849e-02f, -6.35345355e-02f, -2.41783634e-02f, 3.00522745e-02f,
  1.86877638e-01f, 1.86929647e-02f, -2.73239077e-03f, 3.62715349e-02f, -4.99370173e-02f, -6.13802262e-02f, -1.25978328e-02f, -4.81331274e-02f, 2.98324209e-02f, 1.99783966e-02f,
  -3.90046351e-02f, 6.77936226e-02f, 2.93898415e-02f, -1.89537350e-02f, -2.19751317e-02f, 3.20461616e-02f, 3.74482833e-02f, -2.39439236e-04f, 1.24831432e-02f, 2.55665984e-02f,
  2.90345997e-02f, -2.75602825e-02f, -1.40803298e-02f, 3.69807482e-02f, 3.08197737e-02f, 8.22113082e-02f, -2.43332181e-02f, -1.57241076e-02f, -3.03801969e-02f, 3.47230434e-02f,
  -4.16937232e-01f, 2.21760437e-01f, -2.33972713e-01f, -4.18090634e-02f, 6.05586655e-02f, -1.66638240e-01f, -1.58836871e-01f, 7.98646808e-02f, -2.64876336e-01f, 8.10560659e-02f,
  7.43038878e-02f, -1.01698086e-01f, 1.03508234e-01f, -1.98437814e-02f, -9.36640892e-03f, 1.29554003e-01f, -6.29500821e-02f, -3.79394852e-02f, 3.16872746e-02f, 1.19026871e-02f,
  -1.55461198e-02f, 2.15720594e-01f, 6.12777062e-02f, 2.37069845e-01f, -1.46519735e-01f, -1.11424774e-01f, 1.18311867e-01f, 8.46743062e-02f, 5.91088273e-02f, 1.29360333e-01f,
  -2.14252025e-02f, -4.59280610e-02f, -1.25736341e-01f, -5.13570495e-02f, -6.16750829e-02f, -5.69023937e-02f, -5.46693131e-02f, -1.18262204e-03f, -1.36245144e-04f, 5.89372963e-02f,
  -2.97928844e-02f, 1.15794446e-02f, -3.83440293e-02f, -1.31399827e-02f, -5.65547170e-03f, -1.52057931e-02f, -8.00774375e-04f, -1.23793833e-01f, -2.40935944e-02f, 3.41352038e-02f,
  -3.12569514e-02f, -2.78615151e-02f, -3.32872458e-02f, -2.13257503e-02f, -9.65353195e-03f, 2.15309802e-02f, -7.23120570e-02f, 1.28257228e-02f, 1.30874580e-02f, -3.27222310e-02f,
  4.70828824e-02f, -7.56380111e-02f, 6.09684214e-02f, -5.58907688e-02f, 1.90711208e-02f, -2.71119494e-02f, 1.96732450e-02f, 2.68472172e-02f, -1.54129155e-02f, 4.68105786e-02f,
  8.96953046e-03f, -1.92151479e-02f, -6.36347802e-03f, -1.63334645e-02f, 6.29662164e-03f, -4.32850011e-02f, -2.39512697e-02f, -3.17947380e-02f, 1.38370460e-02f, -4.80918512e-02f,
  -2.54811477e-02f, 2.15310734e-02f, 5.26188053e-02f, -3.45409513e-02f, 4.52476554e-03f, -5.13842003e-03f, 8.39423463e-02f, 3.30906883e-02f, -9.33147129e-03f, 4.35067806e-03f,
  1.18868768e-01f, 1.38179109e-01f, 1.91272050e-02f, -1.15921292e-02f, -1.83395427e-02f, 6.22449676e-03f, 1.61148217e-02f, 3.38983233e-03f, 3.42356460e-03f, -3.59896533e-02f,
  2.91254924e-04f, -4.95233163e-02f, 1.33279441e-02f, -4.72374558e-02f, 3.93730178e-02f, 2.21405234e-02f, 1.77789479e-02f, -7.35732960e-03f, 1.15318364e-02f, 6.77306950e-02f,
  4.07166034e-02f, -8.39102268e-03f, -1.82536822e-02f, 4.01499569e-02f, 3.81053984e-02f, 1.48151880e-02f, -4.12255824e-02f, 1.01870205e-02f, 5.14158532e-02f, 4.03644629e-02f,
  -2.22492918e-01f, 2.53049552e-01f, 1.13251269e-01f, -7.18908757e-02f, -1.80155709e-01f, -1.63644463e-01f, -1.91102505e-01f, 7.01529160e-02f, 5.40318824e-02f, 9.92964059e-02f,
  -1.61108211e-01f, -4.35836315e-02f, -7.03433305e-02f, -8.07280242e-02f, -3.65486890e-01f, 4.59269881e-02f, -1.10180110e-01f, -5.38925678e-02f, 6.61364347e-02f, -7.55810142e-02f,
  -4.51912498e-03f, -2.63145566e-01f, -4.63701524e-02f, -8.92510340e-02f, -1.13848604e-01f, 7.10459054e-02f, -1.32679984e-01f, -7.54900053e-02f, -3.55653875e-02f, -1.41188830e-01f,
  -7.56563470e-02f, 7.86944702e-02f, 6.63247257e-02f, 2.18352955e-02f, 5.51914535e-02f, -1.94565672e-03f, -4.00276072e-02f, -1.06341332e-01f, 6.79684663e-03f, 6.54589664e-03f,
  6.83436990e-02f, 1.23126432e-02f, 4.09523360e-02f, -2.62494013e-03f, -1.10595543e-02f, 4.18734699e-02f, -2.86725070e-02f, -1.93834044e-02f, 5.09383120e-02f, 1.74120930e-03f,
  5.91873415e-02f, 7.76973143e-02f, 2.36374866e-02f, 4.93628196e-02f, 9.14615244e-02f, -2.81810109e-02f, -3.91956605e-03f, -5.75389713e-03f, 1.26157925e-01f, 2.67160367e-02f,
  -7.06165582e-02f, 2.13036072e-02f, 4.43656184e-02f, -4.10907045e-02f, -2.66169794e-02f, -3.07417139e-02f, 6.97678840e-03f, -7.13636428e-02f, -3.37813944e-02f, -8.24959055e-02f,
  3.62099404e-03f, 1.69424491e-03f, -3.23985219e-02f, 1.99416820e-02f, 1.39472466e-02f, 5.78235500e-02f, -1.97380316e-02f, 3.66145857e-02f, 4.57684696e-02f, -1.09868981e-02f,
  -3.42572178e-03f, -6.54472038e-02f, 7.29268556e-03f, -4.48583104e-02f, -1.80774108e-02f, -3.32220905e-02f, 1.13341464e-02f, 3.61979827e-02f, 6.54367134e-02f, -1.14737237e-02f,
  3.56817171e-02f, 2.38391422e-02f, -2.08900850e-02f, -3.12158559e-02f, 1.71777904e-02f, 2.42556669e-02f, -1.91896372e-02f, 8.23284164e-02f, 2.76645720e-02f, 2.45207306e-02f,
  -6.70159981e-02f, 9.27994680e-03f, 4.28886451e-02f, -5.10158576e-02f, -1.56764407e-02f, 3.51756699e-02f, 1.18281459e-02f, 3.19801569e-02f, -3.97513025e-02f, 4.13570888e-02f,
  -6.56366795e-02f, -3.86598408e-02f, 2.91105639e-03f, -5.80231920e-02f, -4.15604375e-02f, 3.06954961e-02f, 9.94769391e-03f, -1.42843230e-02f, -8.21780264e-02f, 3.75624076e-02f,
  1.01281039e-01f, 5.22086807e-02f, 2.84928262e-01f, -3.80724408e-02f, -2.93383636e-02f, 3.64888012e-02f, 3.55990715e-02f, -4.47141193e-02f, 3.86886671e-02f, -1.24169461e-01f,
  -1.75745115e-01f, 2.39772335e-01f, -4.43705283e-02f, 3.88788953e-02f, -4.90843020e-02f, 1.45609854e-02f, 4.84618396e-02f, 5.61765544e-02f, -2.19720434e-02f, -8.70989263e-02f,
  3.06277126e-02f, -2.59433687e-01f, 2.93741599e-02f, -8.88784751e-02f, 8.15351382e-02f, 1.87518969e-02f, -1.88636065e-01f, 2.79395897e-02f, -5.29450318e-03f, -1.13351000e-02f,
  6.48542047e-02f, 5.30886687e-02f, 1.15348667e-01f, 2.53270715e-02f, 1.67856161e-02f, 3.37788090e-02f, 2.48505753e-02f, -2.48872652e-03f, -1.42185036e-02f, 1.87776482e-03f,
  8.40702131e-02f, -3.45569029e-02f, -5.39902821e-02f, 1.32718999e-02f, 4.12568636e-03f, 8.64478201e-03f, -7.56761106e-03f, 1.39884837e-02f, 2.08171140e-02f, 6.51802570e-02f,
  2.56066080e-02f, 2.54693106e-02f, 5.47326505e-02f, -8.46072361e-02f, 1.22901867e-03f, -1.74022336e-02f, -2.68144645e-02f, 6.46641850e-02f, 5.37885502e-02f, -2.36895680e-02f,
  -5.05212657e-02f, -2.99560893e-02f, -5.13221323e-02f, -5.12715168e-02f, -2.00438742e-02f, -8.24608561e-03f, -4.79254052e-02f, -5.60856201e-02f, 1.09941460e-01f, -2.75232252e-02f,
  6.63379161e-03f, 4.83453982e-02f, -1.49151366e-02f, -4.82123457e-02f, -2.97423657e-02f, -3.78683396e-02f, -4.91054244e-02f, -3.28137726e-02f, -1.29689798e-02f, 5.95845729e-02f,
  -3.15746032e-02f, 1.29282707e-02f, -1.56522002e-02f, -7.24789035e-03f, 4.64953855e-02f, -3.32941487e-02f, -3.78249288e-02f, 9.96796861e-02f, 1.71816740e-02f, -1.17375376e-02f,
  -1.65828496e-01f, -1.73013598e-01f, 1.01705594e-02f, -5.25861233e-02f, 4.90290625e-03f, -4.09397781e-02f, -2.54534632e-02f, -4.25403751e-02f, -1.12878298e-02f, -9.72524062e-02f,
  -7.21698254e-02f, -6.79986775e-02f, 1.63617842e-02f, 1.65855587e-02f, 3.44639197e-02f, -5.06789461e-02f, -6.81380552e-05f, -2.23730830e-03f, -4.82544675e-03f, -8.13598465e-03f,
  -6.96962848e-02f, -4.90857512e-02f, 1.20108780e-02f, 2.16919910e-02f, -4.15648334e-02f, 6.17060773e-02f, 2.53377836e-02f, 1.22263553e-02f, -7.35434610e-03f, 5.88940829e-02f,
  -6.04546405e-02f, -1.80991143e-01f, 4.34661098e-02f, -1.06844939e-02f, 2.34292056e-02f, -1.40584961e-01f, -1.29270643e-01f, -4.53214645e-02f, -2.59585798e-01f, -1.16677806e-01f,
  -2.78202388e-02f, -7.03041255e-02f, 1.14636816e-01f, -6.50182143e-02f, 2.10536763e-01f, 4.37317379e-02f, -5.60942627e-02f, 5.02871312e-02f, -3.75085771e-02f, 6.43420918e-03f,
  7.53519014e-02f, -1.70460455e-02f, 1.04867198e-01f, 7.35728219e-02f, -1.40139777e-02f, -5.14534377e-02f, 1.87506422e-01f, -1.16459318e-02f, -1.20818438e-02f, 5.90095408e-02f,
  -7.88331702e-02f, 1.74900610e-02f, 3.61641571e-02f, -8.34537670e-03f, 9.65586677e-02f, 5.00836447e-02f, 1.61905459e-03f, 5.04750162e-02f, -1.38268294e-02f, 7.55888149e-02f,
  1.99764371e-02f, -2.13751178e-02f, 1.25386547e-02f, -1.97194703e-02f, -7.99641907e-02f, -4.85230573e-02f, -3.87360789e-02f, 6.00821078e-02f, 1.45722441e-02f, -2.07865033e-02f,
  -5.00217527e-02f, 1.23980260e-02f, 7.89673924e-02f, -6.34695813e-02f, 6.67372271e-02f, -9.53714997e-02f, -3.91834304e-02f, 9.05607594e-04f, -4.94911009e-03f, 2.56914496e-02f,
  3.94558311e-02f, 2.46168394e-02f, 7.45167360e-02f, 2.86489110e-02f, 7.09811831e-03f, 2.73313578e-02f, 7.17505738e-02f, -3.83604281e-02f, -3.13756391e-02f, -1.59009080e-02f,
  2.09325086e-02f, 4.00768891e-02f, -8.88315123e-03f, 5.41585386e-02f, -8.20297189e-03f, 7.27355899e-03f, 4.94436398e-02f, 5.96390739e-02f, -6.16132133e-02f, 3.74232559e-03f,
  -2.78783962e-04f, -5.37792407e-02f, -6.48512915e-02f, -4.67593856e-02f, 2.63228230e-02f, 7.85339624e-03f, -9.83362459e-03f, 2.93084998e-02f, 4.94383983e-02f, 3.29785794e-02f,
  -7.58459419e-02f, 1.12067945e-01f, -9.43356603e-02f, 2.84146015e-02f, 1.23455189e-03f, -4.47073113e-03f, -2.66446527e-02f, 2.10732035e-02f, 9.94249433e-03f, -5.08697182e-02f,
  4.06857692e-02f, 6.55099470e-03f, -3.03456280e-02f, 5.93315028e-02f, 1.00052662e-01f, -9.21690185e-03f, 4.18792069e-02f, 5.89726046e-02f, -3.86744156e-03f, -4.39412780e-02f,
  -1.66422706e-02f, -2.02633142e-02f, -9.88343637e-03f, -7.61802793e-02f, -1.14414189e-02f, 2.36680284e-02f, -2.77853142e-02f, -3.12083140e-02f, 3.72234732e-02f, 8.87510483e-04f,
  -1.72476977e-01f, -1.14244170e-01f, 8.07130486e-02f, -7.14039356e-02f, 2.10431427e-01f, -1.22706115e-03f, 4.60494421e-02f, 1.12325385e-01f, 1.13462761e-01f, -1.81754678e-01f,
  -5.39254956e-02f, -1.15362391e-01f, 7.59638399e-02f, -9.19105783e-02f, -1.89603288e-02f, 1.48616299e-01f, -9.03855264e-02f, -7.74772391e-02f, 1.96870357e-01f, -5.25159650e-02f,
  -1.22403735e-02f, -7.10180923e-02f, 6.20614290e-02f, -3.24201328e-03f, -1.39578655e-01f, 3.37634385e-02f, -1.06396563e-01f, 1.52386174e-01f, -1.89831018e-01f, 9.67683643e-02f,
  4.95181009e-02f, 8.10448900e-02f, -3.17504592e-02f, -1.16083175e-02f, -1.10060778e-02f, 1.96052566e-02f, -5.41082658e-02f, 1.01194931e-02f, -2.00610701e-02f, 2.08663642e-02f,
  -4.14580069e-02f, 4.36873361e-02f, -4.40990552e-02f, 5.95232695e-02f, -1.57149993e-02f, -4.16001081e-02f, -5.32345138e-02f, -9.96431988e-03f, 7.68947378e-02f, -8.48142151e-03f,
  -3.68157513e-02f, 1.49258254e-02f, 2.99912272e-03f, -6.27957731e-02f, -2.35309377e-02f, 8.83529037e-02f, -5.33765294e-02f, 7.48560652e-02f, 3.72580551e-02f, 2.64135469e-02f,
  -1.88473817e-02f, -6.85545208e-04f, -3.25205363e-02f, 4.04536575e-02f, 1.58876069e-02f, -3.18600424e-02f, 2.38668416e-02f, 1.00504663e-02f, 7.53902271e-02f, 4.66742106e-02f,
  -3.80097795e-03f, 1.34164980e-02f, -1.85195953e-02f, 4.56566922e-03f, -3.49949300e-02f, -1.26206148e-02f, -6.65915152e-03f, -4.97725345e-02f, 7.29329465e-03f, -1.33611877e-02f,
  4.42302669e-04f, -5.72845631e-04f, -1.38149606e-02f, -7.85460100e-02f, -6.26767725e-02f, -3.04266866e-02f, -7.23925233e-02f, -4.76379953e-02f, -2.53740214e-02f, -6.44822866e-02f,
  8.07055905e-02f, -6.69355243e-02f, 6.87261000e-02f, -5.89349344e-02f, -4.35634479e-02f, -8.37820098e-02f, 3.60962451e-02f, 2.34591272e-02f, 2.29627751e-02f, -9.32905972e-02f,
  -5.39734736e-02f, 1.19643547e-02f, 2.27422547e-02f, 3.38897482e-02f, 4.62319925e-02f, -3.46426256e-02f, 3.44824269e-02f, 1.03940265e-02f, -6.29049763e-02f, 6.95333257e-02f,
  -1.17034474e-02f, 1.47816464e-02f, 3.15882750e-02f, 9.97234951e-04f, -1.57849267e-02f, -3.66269797e-02f, -5.85474372e-02f, -1.61473043e-02f, -2.23639701e-02f, 1.00319600e-02f,
  4.44486141e-02f, -1.07485436e-01f, 7.91355073e-02f, 1.71740636e-01f, 2.21286744e-01f, -1.80098370e-01f, -1.55348971e-01f, 1.27345502e-01f, -9.94262546e-02f, -2.22554535e-01f,
  -4.94395010e-02f, -1.01750843e-01f, -2.13004246e-01f, -1.00654401e-01f, -1.01975955e-01f, -2.23580614e-01f, -1.12382777e-01f, -9.47315991e-02f, 6.53399304e-02f, 5.66352643e-02f,
  2.14596987e-01f, 7.45288953e-02f, 2.74222773e-02f, 1.35292739e-01f, 2.28552520e-01f, 2.20088184e-01f, 3.55051570e-02f, 9.23538432e-02f, 1.12762146e-01f, -7.35752285e-02f,
  -4.91343290e-02f, -8.98795649e-02f, 1.13232724e-01f, -8.01229104e-02f, 3.85692865e-02f, -6.50680251e-03f, -4.12198305e-02f, -5.99679574e-02f, 6.63238093e-02f, 1.36627983e-02f,
  -1.28420908e-02f, 1.25203338e-02f, -7.68710971e-02f, -2.68251486e-02f, -1.19882682e-03f, 3.11536454e-02f, 1.07630357e-01f, 5.61240427e-02f, 3.00246980e-02f, 1.82335544e-02f,
  9.05906260e-02f, 7.15487450e-02f, -6.85362786e-04f, -3.81216891e-02f, 3.68973799e-02f, 6.63591623e-02f, -6.40547089e-03f, -2.91695073e-02f, 1.69144422e-02f, 6.42230585e-02f,
  -6.60951957e-02f, -7.75761344e-03f, 5.16153760e-02f, 3.83673944e-02f, -7.11366534e-02f, 1.07479014e-01f, -1.06840722e-01f, -9.64234862e-03f, 1.67114846e-02f, -1.60239730e-02f,
  3.10076214e-02f, -1.07777296e-02f, -3.44649032e-02f, 1.05972756e-02f, 2.22655516e-02f, -9.77487583e-03f, -7.55375251e-02f, 4.66789566e-02f, 8.40829313e-02f, 3.78054343e-02f,
  -5.74507229e-02f, 3.69078037e-03f, 5.40512614e-03f, 9.96064842e-02f, -8.25321600e-02f, 9.83637478e-03f, 6.99566305e-02f, 8.58406536e-03f, 4.66380976e-02f, -5.09725511e-02f,
  -2.36094832e-01f, -1.63353816e-01f, 2.55894698e-02f, 3.91660109e-02f, -1.28100842e-01f, -4.15980294e-02f, -6.73120320e-02f, -9.31434892e-03f, -5.07860892e-02f, -3.11320461e-02f,
  2.50386521e-02f, 5.47962822e-02f, -6.56214729e-02f, -2.98289806e-02f, -4.18118536e-02f, 1.14008933e-02f, -5.50260618e-02f, -5.21764010e-02f, 4.82717529e-02f, -4.48906869e-02f,
  -3.05748079e-02f, -7.08401203e-02f, 1.70490406e-02f, 1.37298465e-01f, 9.12460312e-03f, -4.11350802e-02f, 6.00195378e-02f, 6.33189678e-02f, -1.05662560e-02f, -4.68686149e-02f,
  -2.30609328e-01f, 2.71032494e-03f, -1.24986164e-01f, -1.93558529e-01f, -1.05974078e-01f, 5.82735389e-02f, -1.57757532e-02f, -1.07159585e-01f, -2.45346781e-02f, 7.41127431e-02f,
  -1.49425743e-02f, -5.78452386e-02f, 9.58829373e-02f, -1.66315760e-03f, 1.15926400e-01f, 1.45080298e-01f, 2.34586224e-02f, 8.75709951e-03f, 4.15145978e-02f, -1.54216096e-01f,
  -2.41036955e-02f, -7.61236772e-02f, -2.53775008e-02f, -5.15637659e-02f, -1.10069886e-02f, -1.30815268e-01f, 4.24661040e-02f, 2.07173619e-02f, 5.83231635e-02f, 9.76692140e-02f,
  -1.15406960e-01f, -1.70367986e-01f, -2.55185179e-02f, -6.80819899e-02f, -1.24015182e-01f, -4.61888351e-02f, 5.34018204e-02f, 3.22705656e-02f, -4.54345383e-02f, 3.61621678e-02f,
  3.73080783e-02f, 3.40922326e-02f, -5.80247566e-02f, 8.70434195e-02f, -4.11159452e-03f, -3.56907919e-02f, 4.96012047e-02f, 1.53245090e-03f, -4.02112678e-02f, -1.30116465e-02f,
  6.60569780e-03f, -7.38535002e-02f, -5.01448847e-02f, 4.56880182e-02f, -5.95332049e-02f, -2.60891262e-02f, -3.35359685e-02f, -3.27525958e-02f, 1.77341769e-03f, -4.42267358e-02f,
  -3.84604037e-02f, 2.98707299e-02f, -3.24298777e-02f, 3.52060087e-02f, -5.92008047e-02f, -1.13501912e-03f, 8.92494172e-02f, -1.15129836e-02f, 6.52710348e-02f, -2.45385524e-02f,
  -6.31382987e-02f, -8.71822014e-02f, -4.39064279e-02f, 4.36298884e-02f, -8.16130564e-02f, -8.61215871e-03f, -7.39193782e-02f, 4.88404781e-02f, 4.14085994e-03f, -7.77839050e-02f,
  7.24372864e-02f, 6.88634068e-02f, 1.89925227e-02f, 1.51477382e-02f, 5.49866725e-03f, 4.37817611e-02f, 4.19189483e-02f, -1.15549657e-03f, 1.94695648e-02f, -5.03833480e-02f,
  -6.90950975e-02f, -2.21342847e-01f, 8.69012624e-02f, -8.54512826e-02f, 9.58175659e-02f, 7.53488541e-02f, 5.62810712e-03f, -4.66133915e-02f, -1.26880603e-02f, -6.62403330e-02f,
  -9.29924995e-02f, -4.17429134e-02f, 1.51990345e-02f, 3.45141813e-02f, 2.42376663e-02f, -2.41767969e-02f, -1.75004788e-02f, 5.08406088e-02f, 7.03085512e-02f, 1.69366319e-02f,
  -4.02992181e-02f, 5.01970425e-02f, -2.25424115e-03f, 3.29714827e-02f, -7.22742733e-03f, 3.70379584e-03f, -6.91423342e-02f, 3.97705957e-02f, 8.78051445e-02f, 8.75563398e-02f,
  -2.23756924e-01f, 1.99413493e-01f, -1.02188364e-01f, 2.47859374e-01f, -1.72968671e-01f, -2.13302866e-01f, -2.59678513e-01f, 5.09177856e-02f, 4.18546163e-02f, 9.21269283e-02f,
  -8.07048380e-02f, 2.14405674e-02f, -1.64546847e-01f, 2.37383902e-01f, -2.72336811e-01f, -6.07519113e-02f, 9.96210128e-02f, 2.78283935e-02f, 1.39851123e-01f, 3.75038050e-02f,
  7.86491781e-02f, 5.90676516e-02f, 9.22885537e-02f, 2.89406050e-02f, 2.21932307e-02f, 1.42584234e-01f, 1.67695656e-02f, -5.85944019e-03f, 2.53806505e-02f, -9.51029733e-03f,
  -1.97642133e-01f, 8.18321034e-02f, 2.53141839e-02f, -1.02898814e-02f, -8.14691931e-02f, -5.77578582e-02f, -3.74670923e-02f, -4.81313355e-02f, 1.46921324e-02f, -8.37206654e-03f,
  -9.33397859e-02f, -3.53343077e-02f, 3.89441960e-02f, -4.60044928e-02f, -1.59592722e-02f, 2.34211572e-02f, 4.66131642e-02f, -2.88004708e-02f, -3.39735858e-02f, -2.03431826e-02f,
  3.22984904e-02f, -1.42358057e-02f, 6.17222898e-02f, 8.03825352e-03f, -6.46339133e-02f, 1.39437364e-02f, -1.44080380e-02f, 5.09426929e-02f, 5.12444451e-02f, 8.67341552e-03f,
  -1.99436527e-02f, 4.36027385e-02f, -4.59617972e-02f, 7.31042260e-03f, 3.88632566e-02f, -4.23059613e-02f, -2.70058252e-02f, 3.77936140e-02f, 7.11317873e-03f, -6.27404973e-02f,
  -3.27044018e-02f, 1.11744687e-01f, 9.66342632e-03f, 2.96148155e-02f, 1.45767638e-02f, -1.11321304e-02f, 3.12316325e-02f, 3.89088988e-02f, 7.90400803e-02f, 3.98054905e-02f,
  2.69188844e-02f, 1.81236006e-02f, 7.07938820e-02f, -6.66769817e-02f, -6.03876784e-02f, -8.04786757e-03f, 5.25610745e-02f, 7.26751089e-02f, 4.83826082e-03f, -1.29315499e-02f,
  -9.24754664e-02f, 9.13979560e-02f, -7.30341859e-03f, -6.34784847e-02f, -2.01142654e-02f, -2.71587279e-02f, 2.07082126e-02f, -2.05766018e-02f, 6.40615970e-02f, 1.57240015e-02f,
  -5.79181733e-03f, 2.91784108e-02f, -2.61448491e-02f, 2.24293619e-02f, -5.75264217e-03f, 2.18306016e-02f, -4.72584143e-02f, 7.30210310e-03f, 1.91076659e-02f, 1.26004312e-02f,
  -4.16019000e-02f, -3.20016108e-02f, 3.79641652e-02f, -3.41775604e-02f, 1.11149572e-01f, -1.61964986e-02f, 1.06712785e-02f, 2.72327401e-02f, 1.44704375e-02f, -3.14273499e-02f,
  -2.81215370e-01f, 2.18281314e-01f, 7.24132434e-02f, -2.66453743e-01f, 7.68644884e-02f, -3.50885540e-02f, -1.05643161e-01f, -5.47029972e-02f, -2.05747172e-01f, 1.18420869e-01f,
  -1.62149355e-01f, -4.72276025e-02f, -8.43136106e-03f, -1.86869934e-01f, -4.35538441e-01f, -2.11402863e-01f, -2.53489882e-01f, -7.60860294e-02f, -2.31984675e-01f, -3.82090732e-02f,
  -1.80513144e-01f, -2.09103063e-01f, -1.47279024e-01f, 2.95573249e-02f, 5.25194779e-03f, 2.08399948e-02f, 2.67210882e-03f, 1.40046567e-01f, 8.58123004e-02f, 9.93674770e-02f,
  2.49443296e-03f, -3.74717973e-02f, 4.88495603e-02f, 9.16446522e-02f, 2.79284716e-02f, 1.58749700e-01f, -2.04547634e-03f, -4.86085797e-03f, -9.48897898e-02f, 3.13170068e-03f,
  3.58875096e-02f, -8.46817270e-02f, 2.91542895e-03f, 2.68414896e-02f, 3.58646773e-02f, -3.55090685e-02f, -2.58991420e-02f, 4.56197411e-02f, 7.89484940e-03f, -3.63651961e-02f,
  -6.97179660e-02f, -4.75042919e-03f, 1.10929338e-02f, -3.48064266e-02f, -1.08517334e-01f, -3.39019075e-02f, 4.41885814e-02f, -1.79152414e-02f, 2.74452218e-03f, -7.05566928e-02f,
  3.98253053e-02f, -6.21614233e-03f, 5.02331704e-02f, -4.55531105e-02f, 2.83478256e-02f, -8.78938939e-03f, -1.18999863e-02f, -1.85538139e-02f, -6.78419089e-03f, 8.55209306e-03f,
  -3.00591681e-02f, -1.69176515e-02f, -5.49586453e-02f, -2.22584102e-02f, 7.55133480e-03f, 1.77040640e-02f, 5.22737838e-02f, 2.17487966e-03f, -5.98196983e-02f, -3.75065617e-02f,
  -4.43780012e-02f, -7.16090761e-03f, -1.45237446e-02f, 1.96401980e-02f, 4.11548838e-02f, 2.03907341e-02f, -6.93961084e-02f, 4.90694717e-02f, -3.13262194e-02f, 1.98838636e-02f,
  4.55317795e-02f, -3.64354029e-02f, -1.32694971e-02f, -3.50592770e-02f, -3.31367552e-02f, 4.96453084e-02f, -2.12848466e-03f, -1.74819790e-02f, 6.56277686e-02f, -2.67858952e-02f,
  8.25880244e-02f, 6.17444329e-02f, 4.53630872e-02f, -1.06970472e-02f, -4.11121547e-02f, -8.71896371e-03f, -3.51698734e-02f, 4.94083203e-02f, 4.33002859e-02f, -7.89768994e-02f,
  6.89616427e-02f, 2.27804426e-02f, 7.79724307e-03f, 4.09974046e-02f, 9.81791038e-03f, 4.12111096e-02f, 1.81557275e-02f, 2.63080634e-02f, 4.23771068e-02f, 4.87689115e-02f,
  -1.59339234e-01f, -1.95358366e-01f, -5.59819043e-02f, -2.30587751e-01f, 5.66944778e-02f, -2.20227968e-02f, -9.50789079e-02f, -3.48890349e-02f, -7.25443810e-02f, -1.35454535e-01f,
  -2.15098877e-02f, -1.52656972e-01f, 4.23707664e-02f, -1.87247410e-01f, -7.09377527e-02f, -3.14462706e-02f, -1.52627856e-01f, -1.62750319e-01f, 8.02275240e-02f, -1.72373325e-01f,
  2.30763722e-02f, -7.28408247e-02f, -1.00937653e-02f, 3.40341926e-02f, -8.07276964e-02f, -4.76814322e-02f, -1.18810825e-01f, 1.47767454e-01f, -1.11071520e-01f, 4.01676707e-02f,
  -3.49454917e-02f, -1.57691360e-01f, 4.63241711e-03f, 1.09584359e-02f, 6.63253963e-02f, 1.02760922e-02f, -3.17664742e-02f, 7.38928244e-02f, 6.86973035e-02f, 2.22765878e-02f,
  -5.50343841e-02f, 4.69743535e-02f, 3.54965217e-02f, 4.93212789e-02f, 2.72679999e-02f, 3.94569263e-02f, -3.40302731e-03f, 2.62464676e-02f, 2.96502076e-02f, 6.47440255e-02f,
  -1.34657444e-02f, -2.68883239e-02f, -5.29897064e-02f, 1.90494303e-02f, 1.90416782e-03f, -5.43522835e-02f, -4.44512675e-03f, 5.67094386e-02f, -5.19789197e-02f, 8.58552661e-03f,
  -8.94408673e-04f, -2.02609831e-03f, -4.76233242e-03f, 2.19525378e-02f, -3.54322195e-02f, -2.05498822e-02f, 5.23158498e-02f, 5.33491559e-02f, -6.11060206e-03f, 3.97022851e-02f,
  4.19383757e-02f, 1.16326846e-02f, -2.06270088e-02f, 6.80523068e-02f, -1.03307031e-02f, -1.27758635e-02f, 3.76664475e-02f, 1.30642755e-02f, -8.67547188e-03f, -2.08120067e-02f,
  3.10481600e-02f, -8.15915540e-02f, -6.34481153e-03f, -7.13013066e-03f, 1.06617259e-02f, 4.70927134e-02f, -1.53674362e-02f, 3.71438228e-02f, 8.35824087e-02f, 1.42699759e-02f,
  -5.60106523e-02f, -2.07963705e-01f, -1.34376958e-02f, 7.94057995e-02f, -5.36333770e-02f, 5.01164161e-02f, -4.73481044e-02f, -2.72871368e-02f, 9.66980401e-03f, 3.66741568e-02f,
  -1.69332083e-02f, 1.36696119e-02f, -2.14349432e-03f, -3.37051041e-02f, 2.26303264e-02f, -1.56453084e-02f, -7.71648958e-02f, -1.52505059e-02f, -5.77769950e-02f, -2.21206732e-02f,
  -4.71381545e-02f, -2.13185847e-02f, 3.74084488e-02f, -2.74141245e-02f, -2.92461868e-02f, -4.87532583e-04f, -3.17014121e-02f, 7.91901201e-02f, -2.33133715e-02f, -4.89159487e-02f,
  1.15690671e-01f, -1.43217713e-01f, -8.01463574e-02f, 8.54877681e-02f, 8.88439175e-03f, 1.43365487e-01f, 1.07057810e-01f, -1.14225723e-01f, 1.03033602e-01f, -1.09913386e-01f,
  7.42479712e-02f, 8.92591402e-02f, -7.36654736e-04f, 2.41534457e-01f, 3.50939810e-01f, 1.07890770e-01f, 2.05752969e-01f, -4.99250041e-03f, 6.03151657e-02f, -4.59669307e-02f,
  1.18718632e-02f, 5.83624132e-02f, 2.32540676e-03f, -1.75928056e-01f, -1.07375190e-01f, -2.62900382e-01f, -2.80036598e-01f, -1.75433159e-01f, -2.86688879e-02f, 1.49631515e-01f,
  1.26939397e-02f, 5.87077215e-02f, 1.36973076e-02f, 2.17827614e-02f, 1.42835360e-02f, -2.35187355e-02f, -5.93779199e-02f, -4.33191396e-02f, -6.34563193e-02f, 6.46389229e-03f,
  5.38418954e-03f, 1.29011190e-02f, 1.12583756e-01f, 4.16081510e-02f, 5.55826724e-02f, 5.76688023e-03f, -4.74831015e-02f, -5.67948557e-02f, 2.19883863e-03f, 8.81695300e-02f,
  -5.59489876e-02f, 6.14860747e-03f, 1.05160102e-02f, 2.74976110e-03f, -1.79098435e-02f, 6.09490313e-02f, 4.64755334e-02f, 1.60205958e-03f, -3.59572954e-02f, 9.74715352e-02f,
  -2.25379807e-03f, -7.64150498e-03f, 2.14205147e-03f, -1.32254893e-02f, 4.70114686e-03f, 6.45258790e-03f, -1.30620692e-02f, -2.66701505e-02f, -3.01284790e-02f, 4.71477695e-02f,
  -6.25930876e-02f, 3.89337204e-02f, 1.00133652e-02f, -9.56994072e-02f, 1.03147905e-02f, -4.72295331e-03f, -2.56766137e-02f, 2.03849077e-02f, -6.00340664e-02f, 2.43169605e-03f,
  -4.56918264e-03f, -1.19051514e-02f, -2.60204021e-02f, -5.01583219e-02f, 2.77190898e-02f, -2.29366310e-02f, -1.29434355e-02f, -2.27550082e-02f, -3.13054584e-02f, 8.64449795e-03f,
  -1.70051515e-01f, -2.31487438e-01f, -2.48463526e-02f, -1.39545500e-02f, -6.24708645e-02f, 9.24966559e-02f, 1.33578796e-02f, 1.14553850e-02f, -1.74153969e-02f, -1.53593179e-02f,
  -6.04485050e-02f, -4.95736636e-02f, -4.88544330e-02f, 2.97910925e-02f, -6.14492707e-02f, 1.36415944e-01f, -6.35158792e-02f, -2.74660736e-02f, 2.50274949e-02f, -3.61877158e-02f,
  -1.05384767e-01f, -1.00222901e-02f, 9.97485816e-02f, -1.45562040e-02f, -2.71342732e-02f, 9.01690312e-03f, -1.71832799e-03f, -1.38224224e-02f, 1.28644546e-02f, -1.55077660e-02f,
  1.65086940e-01f, -1.14822917e-01f, 2.80288104e-02f, 4.09626216e-03f, -1.20917477e-01f, -9.56808701e-02f, -1.56558827e-01f, -8.51960108e-02f, -3.11925322e-01f, -8.71094018e-02f,
  -3.34315002e-02f, 8.39748159e-02f, -1.13630630e-02f, -1.66699849e-02f, 2.97187150e-01f, 1.12639345e-01f, 5.42298928e-02f, 4.88228723e-02f, 1.92891266e-02f, 3.88491265e-02f,
  1.23607822e-01f, 8.15868378e-02f, 1.67942807e-01f, 1.76440040e-03f, -6.93663806e-02f, 3.02704256e-02f, 1.76268041e-01f, 2.24149860e-02f, 1.10533342e-01f, 8.24537408e-03f,
  6.07441105e-02f, -8.20680857e-02f, -1.34846093e-02f, -4.51365411e-02f, 3.14397700e-02f, 4.09534313e-02f, 6.46030903e-02f, 3.09971701e-02f, -2.29619816e-02f, -1.01899337e-02f,
  -4.40800674e-02f, 9.36973915e-02f, -5.08853309e-02f, -1.59493167e-04f, -4.17427421e-02f, -5.28035425e-02f, -1.99360177e-02f, 2.49312120e-03f, 8.34338076e-04f, 3.42356116e-02f,
  3.55972052e-02f, -8.93517286e-02f, -9.67906266e-02f, 6.60800422e-03f, 4.56971526e-02f, 3.59525002e-04f, -1.97401382e-02f, -5.22557739e-03f, 8.84099863e-04f, -7.71933272e-02f,
  7.09331781e-02f, -1.82317272e-02f, -2.71571390e-02f, 4.40111086e-02f, 2.19704751e-02f, -1.76588632e-02f, -6.48020506e-02f, 3.67763527e-02f, -1.20185362e-02f, -4.63990197e-02f,
  4.55366187e-02f, 4.19949479e-02f, 1.13431523e-02f, 3.69456820e-02f, 4.18485552e-02f, 2.78080460e-02f, 5.49664125e-02f, 1.22837871e-02f, -8.04122910e-03f, 3.81255336e-02f,
  -1.42976374e-03f, -4.79591154e-02f, 1.08866452e-03f, 2.58457121e-02f, -9.50638056e-02f, 5.35206832e-02f, -1.37506807e-02f, -5.34347929e-02f, -3.23809423e-02f, 1.04963966e-01f,
  -5.88367395e-02f, -1.67181026e-02f, 1.18290959e-02f, -2.88380850e-02f, -1.88531354e-02f, 4.17448813e-03f, -4.86150086e-02f, -4.70056534e-02f, 5.13296463e-02f, -3.93388607e-02f,
  -6.46566600e-02f, -3.69517878e-02f, 4.30354178e-02f, -3.87542173e-02f, -2.99118944e-02f, 5.06910980e-02f, -1.15924403e-02f, 3.98828834e-02f, 1.53779611e-02f, 9.26200822e-02f,
  2.74271891e-02f, 5.29343709e-02f, -1.53051335e-02f, 1.23575907e-02f, -5.16716689e-02f, 1.16738956e-02f, -4.56865467e-02f, 1.72338393e-02f, -1.24558918e-02f, -1.05593316e-02f,
  -7.36839995e-02f, 2.28159606e-01f, -2.07811654e-01f, -1.74829870e-01f, 5.68957254e-02f, -4.47128117e-02f, -3.50299440e-02f, 5.52912336e-03f, -5.05617037e-02f, 1.99904814e-01f,
  7.12605193e-02f, -5.01514710e-02f, 4.74889055e-02f, 1.11811094e-01f, -1.03903584e-01f, -7.30087012e-02f, -4.59091598e-03f, 8.80118459e-02f, -2.95017976e-02f, 1.08619547e-02f,
  -3.15263905e-02f, 1.01993894e-02f, -1.00440308e-01f, 4.98449020e-02f, 1.62073113e-02f, -6.47969395e-02f, 1.14147719e-02f, -7.95839131e-02f, 1.33784264e-01f, -4.49257232e-02f,
  4.19619493e-02f, 6.34679049e-02f, 1.38053745e-01f, 1.14226341e-01f, 5.89872561e-02f, 7.68787414e-02f, 2.83052530e-02f, -5.54813668e-02f, -4.13076840e-02f, 6.53373599e-02f,
  9.53482743e-03f, -1.11459102e-02f, -1.62747838e-02f, -1.54615482e-02f, 6.70923144e-02f, -3.08300368e-02f, -6.48367256e-02f, 9.30378810e-02f, -3.00730299e-02f, 8.03651810e-02f,
  5.81098069e-03f, 5.95412366e-02f, -1.58109572e-02f, 6.00252184e-04f, 2.86211353e-03f, 6.88400585e-03f, -2.91580372e-02f, 1.46567617e-02f, 5.78510053e-02f, -2.02208087e-02f,
  -4.86867279e-02f, 3.97377908e-02f, -3.41091454e-02f, 2.50483677e-02f, 1.56953353e-02f, -3.56815848e-03f, 8.89425874e-02f, -3.39237079e-02f, 3.99941467e-02f, 3.49205211e-02f,
  1.08610146e-01f, 6.21663406e-02f, 5.86527446e-03f, -3.31261307e-02f, 6.68657720e-02f, -1.32967606e-02f, -5.88713475e-02f, -1.01283211e-02f, -1.52633283e-02f, 4.02428545e-02f,
  -4.10636961e-02f, 3.90386470e-02f, -3.52380052e-02f, -5.43984175e-02f, -1.42613128e-02f, 1.06323725e-02f, -1.38283223e-02f, 1.67995952e-02f, -2.54845954e-02f, -1.60923470e-02f,
  2.63367951e-01f, 4.83673885e-02f, 6.16595000e-02f, 7.89968148e-02f, 3.78609337e-02f, 1.02857344e-01f, -1.96082983e-03f, 6.45405129e-02f, -4.31596376e-02f, -7.51639679e-02f,
  5.62998503e-02f, -5.89299668e-03f, 8.23896751e-02f, -6.78318515e-02f, 5.03086522e-02f, 2.02341508e-02f, 4.33815122e-02f, 3.12647372e-02f, 7.48099983e-02f, -2.42623389e-02f,
  3.08563164e-03f, -3.60221416e-02f, -4.84673008e-02f, -2.62505049e-03f, 8.81481022e-02f, 3.50692533e-02f, 2.86061689e-02f, -3.71690560e-03f, -2.80686654e-02f, 2.45494340e-02f,
  2.71273032e-02f, -1.77403256e-01f, -1.90090150e-01f, -5.36519513e-02f, 1.37452185e-01f, 5.06274551e-02f, -4.62314263e-02f, 8.23436901e-02f, 6.24369085e-02f, 2.21945703e-01f,
  1.49424911e-01f, -8.11215118e-02f, -5.25985248e-02f, 1.71427488e-01f, -2.89946675e-01f, -3.00278664e-01f, 1.18184291e-01f, 2.49013770e-02f, -5.00211418e-02f, 1.11022275e-02f,
  -9.29435268e-02f, 7.17705190e-02f, -1.65523008e-01f, 1.12398192e-01f, 1.17672667e-01f, -3.52431685e-02f, 1.88562926e-03f, -1.42699499e-02f, 1.05893247e-01f, 4.19331267e-02f,
  -2.41358709e-02f, 5.12846336e-02f, 1.02299832e-01f, 2.50448417e-02f, -2.61187117e-04f, 9.31639224e-02f, 1.74314193e-02f, -4.67414856e-02f, 1.24318879e-02f, 5.51685318e-02f,
  -7.17191175e-02f, 4.35921624e-02f, 4.37134095e-02f, -1.84709318e-02f, 7.99480006e-02f, -4.24526334e-02f, -2.46955901e-02f, -3.06558385e-02f, 4.38108575e-03f, -2.73013599e-02f,
  -6.55841157e-02f, 2.91381236e-02f, -2.34099030e-02f, -7.16805458e-02f, -5.27826138e-02f, 4.14984040e-02f, -1.58501547e-02f, -6.46415725e-02f, -3.31619494e-02f, -4.98053432e-02f,
  7.01807588e-02f, -2.50862120e-03f, -5.54990172e-02f, 8.21516663e-02f, 2.98129916e-02f, 4.31490354e-02f, 4.93605286e-02f, 2.44347360e-02f, -2.39248411e-03f, 3.41331996e-02f,
  7.42024854e-02f, 5.45443743e-02f, -1.06953108e-03f, 1.07877180e-02f, 3.15220989e-02f, 8.13692808e-02f, -3.46608870e-02f, 4.81098518e-02f, -3.18070985e-02f, 5.06259017e-02f,
  6.68825209e-02f, 1.80565361e-02f, 2.10831407e-03f, 2.31202338e-02f, -2.04180833e-02f, -1.31487194e-02f, 4.40596752e-02f, -1.11821368e-02f, -2.17467975e-02f, -4.46834192e-02f,
  -4.06364463e-02f, -1.06040157e-01f, -1.24940360e-02f, 3.61317471e-02f, -3.64526547e-02f, -1.22707151e-02f, -6.17531836e-02f, -2.99841049e-03f, -2.89540589e-02f, -1.08953379e-02f,
  2.24198494e-02f, -1.91765781e-02f, -4.37901318e-02f, 3.84964868e-02f, -6.72377646e-02f, -1.80257559e-02f, 1.22772800e-02f, 2.14703754e-02f, -4.60993722e-02f, -3.60362567e-02f,
  7.90749639e-02f, 1.57184694e-02f, -2.72801481e-02f, -2.60879174e-02f, 3.54383141e-02f, 4.48368005e-02f, -6.95865080e-02f, -2.69240979e-02f, -2.87887678e-02f, 3.08268908e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.60617307e-02f, 1.16073877e-01f, -2.84445118e-02f, 1.44332841e-01f, -1.63231548e-02f, -1.35788307e-01f, -6.58948049e-02f, 1.10448942e-01f, -8.97768363e-02f, 5.72479591e-02f,
  2.95623317e-02f, -1.20661687e-02f, -3.40896770e-02f, 8.83564055e-02f, 8.97484366e-03f, 1.31260082e-02f, 1.29247338e-01f, 7.19844829e-03f, -6.10839725e-02f, 2.06822574e-01f,
  1.14713296e-01f, 9.17131081e-02f, 5.09683974e-02f, 1.73862129e-02f, 1.39865503e-01f, 1.15587346e-01f, 2.22864360e-01f, -4.91041504e-02f, 1.01620041e-01f, -1.23587688e-02f,
  -3.11536677e-02f, 2.52446383e-02f, -2.15235408e-02f, 5.35893217e-02f, -1.43464655e-02f, 2.26906664e-03f, 1.41411684e-02f, -7.27301389e-02f, -5.11639472e-03f, -3.96924689e-02f,
  3.99627425e-02f, -7.29063153e-02f, 1.24426717e-02f, -3.41158807e-02f, -5.81488200e-02f, -1.01124253e-02f, -4.17043753e-02f, 5.20418398e-03f, 1.07027404e-02f, -3.23059857e-02f,
  2.76163071e-02f, 1.31039806e-02f, -2.85654292e-02f, -8.61088652e-03f, 2.74969339e-02f, -7.69522414e-02f, 3.40284035e-02f, 9.52724740e-02f, -2.05831099e-02f, 9.74120498e-02f,
  8.75242427e-03f, -7.82255083e-02f, -3.92676257e-02f, -1.67296790e-02f, 5.03435824e-03f, -2.14640461e-02f, -4.76974249e-02f, 8.01368442e-04f, -2.53825393e-02f, 7.28403628e-02f,
  -6.54473975e-02f, 1.80924628e-02f, -4.47865932e-06f, 7.22889006e-02f, 5.68521619e-02f, -9.46549177e-02f, -7.46406987e-02f, 4.29127850e-02f, -1.20138172e-02f, 4.06301543e-02f,
  6.20418303e-02f, -3.61254215e-02f, -1.49861444e-03f, -3.18030491e-02f, 3.91372293e-02f, -6.94672391e-02f, -3.24178371e-03f, -5.22079878e-02f, -4.76681255e-02f, -6.68854266e-02f,
  8.21605772e-02f, 1.26961604e-01f, -5.74765950e-02f, -1.60584617e-02f, 6.19668663e-02f, 9.04871970e-02f, -1.81888063e-02f, -2.02087276e-02f, 9.47649553e-02f, 4.32090573e-02f,
  -3.55298743e-02f, 2.13055927e-02f, 4.64102114e-03f, 8.25782716e-02f, -1.97348394e-03f, 2.02099867e-02f, 7.29911327e-02f, 1.75409243e-02f, 7.09439889e-02f, 1.17979214e-01f,
  1.21801153e-01f, -2.89795897e-03f, 5.95627613e-02f, 1.78601891e-02f, -1.72613785e-02f, -4.19783667e-02f, 3.66553478e-02f, 6.74911141e-02f, 5.42472452e-02f, 5.30295484e-02f,
  -2.09137276e-01f, -1.99027248e-02f, -1.05339549e-01f, -7.14828372e-02f, -1.96873650e-01f, 4.50955816e-02f, -6.88056042e-03f, -1.46289840e-01f, -1.89676471e-02f, 2.54454255e-01f,
  1.28082082e-01f, -9.37529206e-02f, 9.43747237e-02f, 4.85558882e-02f, -1.13502324e-01f, 1.47568375e-01f, 9.25256908e-02f, 1.11008368e-01f, -7.35836178e-02f, 4.24330831e-02f,
  -1.62599817e-01f, 1.65896446e-01f, -5.93403764e-02f, 2.48236377e-02f, 1.15064085e-02f, -4.73665521e-02f, 5.67477867e-02f, -5.28320596e-02f, -2.54874881e-02f, 2.54853442e-02f,
  7.07326755e-02f, -5.27481250e-02f, -5.93044271e-04f, -3.74439955e-02f, 2.24768370e-02f, 2.55491473e-02f, 1.67433301e-03f, 2.27764696e-02f, -8.08527246e-02f, -8.26882944e-02f,
  3.54587846e-02f, -6.65845498e-02f, -2.98960395e-02f, -5.66709973e-02f, 2.08274461e-03f, 4.71713208e-02f, -4.22782376e-02f, -1.05012402e-01f, -8.40528589e-03f, -1.00893214e-01f,
  -5.43329306e-02f, 4.03348804e-02f, 4.23118435e-02f, 1.02397867e-01f, -7.51559883e-02f, 7.71449730e-02f, 3.17965448e-03f, -5.39776161e-02f, 4.69598435e-02f, -8.36941823e-02f,
  1.36208767e-02f, -6.68705255e-02f, 1.19098984e-01f, -6.24425337e-02f, 1.07159493e-02f, 9.76990610e-02f, -4.21153493e-02f, 5.94932809e-02f, -1.30198030e-02f, -2.15839897e-03f,
  -5.58670498e-02f, -3.29732038e-02f, -7.33395712e-03f, 1.09176543e-02f, -2.79431660e-02f, -3.75205725e-02f, -2.86888834e-02f, -4.19543236e-02f, -4.90128025e-02f, -2.58855633e-02f,
  4.54337411e-02f, -2.26122383e-02f, -2.30896957e-02f, -1.39084533e-02f, -8.31678584e-02f, -9.93388332e-03f, 9.08041075e-02f, 1.37354499e-02f, -3.43709961e-02f, -7.57674277e-02f,
  -1.79274939e-02f, 2.76616607e-02f, 7.28156492e-02f, 6.30580485e-02f, 1.61486622e-02f, 1.00486353e-01f, 2.05668565e-02f, -1.01427563e-01f, -1.90285724e-02f, -3.14063393e-02f,
  -3.29437144e-02f, -6.44279495e-02f, -7.82754943e-02f, -6.68039694e-02f, -1.95294563e-02f, 7.38638639e-02f, 8.94439816e-02f, -9.36981812e-02f, -3.24607790e-02f, -8.37812573e-02f,
  2.71490272e-02f, 2.08474863e-02f, 4.18828204e-02f, -1.01591177e-01f, -4.59275208e-02f, -5.18453456e-02f, 4.57220059e-03f, 4.84268069e-02f, -7.11354241e-02f, -6.06863238e-02f,
  -8.73424634e-02f, 1.22949764e-01f, 1.06524326e-01f, 4.71852068e-03f, -4.49913591e-02f, -1.29689306e-01f, -9.25950706e-02f, 1.08795926e-01f, -9.32232887e-02f, 2.63264850e-02f,
  -3.13724279e-02f, 1.88220114e-01f, -1.94168315e-04f, 9.51823592e-02f, -5.73662445e-02f, -7.60592595e-02f, -3.95625904e-02f, -7.49267191e-02f, 1.82221998e-02f, 3.49426903e-02f,
  -6.01439103e-02f, 5.98299466e-02f, 3.08407727e-03f, 6.91609904e-02f, 1.07838981e-01f, 7.20042214e-02f, 6.28588349e-03f, 9.92233516e-04f, 5.36403432e-02f, 1.74808074e-02f,
  -8.91713277e-02f, 5.75859398e-02f, 8.47923569e-03f, 1.11246342e-02f, 4.28770063e-03f, 5.02917804e-02f, 3.99440154e-02f, -5.36475517e-02f, -6.76132217e-02f, -5.10274023e-02f,
  8.53202194e-02f, 6.96018785e-02f, 6.03909269e-02f, -3.51596698e-02f, -1.33763170e-02f, 7.52688870e-02f, 6.00489825e-02f, -4.46951166e-02f, 8.56359601e-02f, 7.82831609e-02f,
  1.24449562e-02f, 1.95248984e-02f, 8.33899081e-02f, -7.71038383e-02f, -4.43832576e-02f, -5.03028650e-03f, 5.35354353e-02f, 4.55243550e-02f, -4.90360819e-02f, -2.95435209e-02f,
  3.28696854e-02f, 4.03263457e-02f, 1.22853154e-02f, 1.68035850e-02f, -6.66119680e-02f, 5.09704389e-02f, 4.69595268e-02f, 5.41642420e-02f, -6.61778823e-02f, 4.50057276e-02f,
  1.68137532e-02f, -1.66230779e-02f, 7.32634440e-02f, 1.19702695e-02f, 5.80328293e-02f, 6.85802996e-02f, -9.40866694e-02f, -5.03503419e-02f, -6.13254346e-02f, -6.56599924e-02f,
  -2.77666878e-02f, -8.39052945e-02f, 4.73571345e-02f, 2.38622129e-02f, 1.61616709e-02f, -6.03736117e-02f, 7.33678415e-02f, 7.72860348e-02f, -5.07341437e-02f, 6.27754852e-02f,
  5.40396683e-02f, 1.45171255e-01f, -5.01491502e-02f, -4.76343520e-02f, 1.77002475e-02f, 3.52285206e-02f, 5.18079065e-02f, -7.41626248e-02f, 3.02127656e-02f, 4.01317365e-02f,
  -1.50205633e-02f, -4.28526103e-02f, 9.27545950e-02f, -2.77525112e-02f, -1.25542760e-03f, -9.66507103e-03f, -3.76968905e-02f, -4.74018678e-02f, -3.48471501e-03f, 5.40644303e-02f,
  1.25157714e-01f, -4.92501669e-02f, 3.73637602e-02f, 3.40635143e-02f, -5.57310805e-02f, -8.59016329e-02f, -1.78211126e-02f, 2.03000139e-02f, -4.33301888e-02f, -4.07339185e-02f,
  4.71383221e-02f, -2.60480851e-01f, 1.11550935e-01f, 1.24180876e-01f, 1.11070596e-01f, 1.07351921e-01f, 1.82277784e-01f, 1.37210982e-02f, -6.61125258e-02f, -1.82043344e-01f,
  2.56920289e-02f, -1.39263906e-02f, -4.71584797e-02f, -8.64747390e-02f, 2.58323669e-01f, -5.65122366e-02f, 3.52705903e-02f, -7.71034835e-03f, -7.71358758e-02f, -1.16987221e-01f,
  -5.81361167e-02f, 3.84279266e-02f, 4.44172621e-02f, -1.07956929e-02f, 7.69970715e-02f, -2.15169899e-02f, -5.13722226e-02f, 9.25775245e-02f, -2.31759939e-02f, 1.09444723e-01f,
  3.24151665e-02f, -1.63897201e-02f, 5.60909547e-02f, 2.21690238e-02f, -5.24426363e-02f, -2.91877203e-02f, 2.81066331e-03f, 1.32887468e-01f, 7.03261122e-02f, -8.17658082e-02f,
  8.64134915e-03f, -1.08944876e-02f, 1.97496209e-02f, 1.93742830e-02f, -2.85934731e-02f, 5.15100397e-02f, -5.02506681e-02f, -4.23482433e-02f, -1.10410385e-01f, 3.50492299e-02f,
  -5.23026697e-02f, -1.06217474e-01f, -3.32104005e-02f, -5.94250970e-02f, -2.64297687e-02f, -3.09076142e-02f, -2.60085929e-02f, 1.25049299e-03f, 2.96892971e-02f, -5.29971160e-02f,
  -2.22867914e-02f, 1.71732418e-02f, 8.49556271e-03f, 4.89563169e-03f, -2.94579621e-02f, -8.51542726e-02f, -5.07013313e-02f, 4.65915464e-02f, 6.53354079e-02f, -6.76460117e-02f,
  3.88746895e-02f, 3.31076011e-02f, -2.34610904e-02f, -3.78620140e-02f, -1.98533144e-02f, -9.48260278e-02f, 1.92951187e-02f, -3.26505899e-02f, 3.92650925e-02f, -1.98792312e-02f,
  -4.02317867e-02f, 1.70459431e-02f, 1.06012382e-01f, -4.09558341e-02f, 5.55121042e-02f, -3.05757020e-02f, 6.50465339e-02f, -1.11000845e-02f, -7.83127248e-02f, -6.49515539e-02f,
  3.08842445e-03f, -9.44845602e-02f, 1.44657055e-02f, 6.79051876e-03f, -2.64856759e-02f, 6.56327382e-02f, 5.89737222e-02f, 6.16158508e-02f, 5.67310490e-02f, 4.61769924e-02f,
  -9.59202051e-02f, -5.98792406e-03f, -9.08830464e-02f, 8.17331113e-03f, -3.28650586e-02f, 4.36022170e-02f, 4.33949661e-03f, -7.39082322e-02f, -8.58742595e-02f, -8.15866813e-02f,
  -2.19198316e-03f, 1.17681427e-02f, 7.76657835e-02f, -6.20285384e-02f, 6.06588759e-02f, -3.09310816e-02f, -4.93683256e-02f, 4.15013954e-02f, -7.99696594e-02f, -8.98670312e-03f,
  2.75361203e-02f, -3.74629349e-02f, 7.86142573e-02f, 1.63359009e-02f, 6.95901290e-02f, -8.98127332e-02f, -6.98937243e-03f, -2.34778319e-02f, 1.15856819e-01f, 3.88974361e-02f,
  -2.12201029e-02f, 2.87286136e-02f, -8.47865865e-02f, -1.21394573e-02f, 8.57668445e-02f, 1.17446937e-01f, -4.05787043e-02f, 7.53218308e-02f, 9.32217389e-02f, 9.25132558e-02f,
  -1.96304601e-02f, 4.69800876e-03f, -9.44281742e-03f, 3.71235609e-02f, -9.67263356e-02f, 9.23755765e-03f, -2.26577017e-02f, -7.21606538e-02f, -3.36533748e-02f, 4.73555587e-02f,
  -8.92720371e-02f, 7.29298294e-02f, 7.35924616e-02f, -6.13994524e-02f, 4.23883907e-02f, 7.07231089e-02f, 3.19841690e-02f, 4.20953054e-03f, 3.45179401e-02f, 1.65902227e-02f,
  7.94524141e-03f, 1.39754461e-02f, 3.17291617e-02f, 7.74261951e-02f, -6.64360002e-02f, -2.94416416e-02f, 1.13541335e-02f, -4.61364947e-02f, -3.02497968e-02f, -2.08644643e-02f,
  -8.37580413e-02f, 7.90179148e-02f, -7.23643526e-02f, -5.20905629e-02f, 1.73151251e-02f, -2.06458885e-02f, 5.57088330e-02f, 2.97454167e-02f, 2.56059226e-03f, -2.82554794e-02f,
  -4.62602302e-02f, -2.61495244e-02f, 6.61539063e-02f, 6.93538859e-02f, 9.91209596e-03f, -3.65759023e-02f, 1.23426421e-02f, -6.30357191e-02f, -4.11024783e-03f, 5.25264107e-02f,
  8.84758607e-02f, 9.23947431e-04f, 6.50166348e-02f, -5.27612045e-02f, 5.96099272e-02f, -1.68315377e-02f, -4.66219783e-02f, 1.87426452e-02f, -8.53853151e-02f, -9.52930935e-03f,
  -5.33652194e-02f, 2.04495825e-02f, -1.31764682e-02f, -6.33236989e-02f, 2.99710687e-02f, -5.87991178e-02f, -3.49133536e-02f, -6.85412958e-02f, 1.83847174e-02f, 1.74733978e-02f,
  6.88363090e-02f, 6.56175762e-02f, -1.59780234e-02f, -5.77343721e-03f, -4.48596179e-02f, -6.37119934e-02f, 6.63201734e-02f, 3.61674204e-02f, -4.34266217e-02f, 3.96900512e-02f,
  -3.12147150e-03f, -7.75762051e-02f, 6.95674121e-02f, -3.94493341e-02f, -3.95124555e-02f, 6.93865120e-02f, -8.32432508e-02f, 5.27375042e-02f, 4.30146828e-02f, 4.53584157e-02f,
  1.74307749e-02f, 7.89328367e-02f, -2.68138330e-02f, 1.73233505e-02f, 7.33499601e-02f, 1.09067988e-02f, -6.95111081e-02f, 2.36215461e-02f, 4.82295975e-02f, -4.90974039e-02f,
  -2.64158666e-01f, 9.66653824e-02f, -1.42016187e-01f, -1.02315359e-01f, -4.32689041e-02f, -1.41968325e-01f, -9.20418352e-02f, -1.55260125e-02f, 5.60582150e-03f, 1.22823477e-01f,
  4.20612134e-02f, -1.12841390e-01f, 1.97675735e-01f, -1.03100017e-01f, -1.78454891e-01f, 1.06128201e-01f, -1.24516331e-01f, -1.40825167e-01f, 1.39692705e-02f, -1.19474374e-01f,
  -9.41912755e-02f, -4.98176627e-02f, -1.61802858e-01f, 1.16620190e-01f, -1.09521061e-01f, 6.06758706e-03f, -8.23328644e-02f, 1.57302737e-01f, -3.82840857e-02f, -3.57372910e-02f,
  2.78146975e-02f, 1.76185519e-01f, -3.57805453e-02f, 3.59396935e-02f, -4.29619215e-02f, -4.83995304e-02f, -3.99105065e-02f, 3.52041684e-02f, 5.25850952e-02f, 6.30052062e-03f,
  -6.60737883e-03f, 7.06075504e-02f, -7.78967515e-02f, 1.06575929e-01f, -3.48664708e-02f, 1.83621496e-02f, 3.76049541e-02f, 1.96138136e-02f, 9.78128146e-03f, -2.40150578e-02f,
  5.09457439e-02f, -6.81809857e-02f, -1.55158728e-01f, -3.66967320e-02f, -6.59208745e-02f, -3.04930750e-02f, -8.86937231e-02f, -1.35914003e-02f, -1.26173437e-01f, -7.10661113e-02f,
  2.22499352e-02f, 3.03104892e-02f, -1.18832001e-02f, 1.05442926e-02f, 7.56335035e-02f, 9.33439732e-02f, -2.58835107e-02f, -3.34051512e-02f, 1.35143949e-02f, -4.86469418e-02f,
  -3.17440443e-02f, 6.81858659e-02f, 2.88626794e-02f, -1.22090839e-01f, -2.95634717e-02f, 3.49362940e-02f, -3.93323787e-02f, 3.27953659e-02f, -1.09068044e-01f, 3.27947289e-02f,
  -9.04757343e-03f, 6.09417520e-02f, 1.37841729e-02f, 8.81796777e-02f, -3.89097966e-02f, 1.87574532e-02f, 1.71558689e-02f, -4.79417220e-02f, -1.19635174e-02f, -1.73133928e-02f,
  -5.37492819e-02f, 5.09572551e-02f, 6.93962052e-02f, 9.10101011e-02f, 5.96379973e-02f, -7.76902884e-02f, 3.66979442e-03f, -4.03326079e-02f, -2.84572568e-04f, -4.65510637e-02f,
  -1.17399670e-01f, -1.66771021e-02f, -1.12135671e-01f, 4.24389951e-02f, -7.63058141e-02f, -7.26666749e-02f, 3.30165215e-02f, 1.64426882e-02f, -9.29756761e-02f, -5.98445833e-02f,
  1.64828002e-02f, -4.24217507e-02f, -4.23860997e-02f, 1.02051184e-01f, 9.82262846e-03f, -9.00800750e-02f, -5.35964631e-02f, -7.23190755e-02f, 1.66769717e-02f, -2.71244235e-02f,
  -1.83966663e-02f, -1.48447797e-01f, -4.29007709e-02f, -3.79534662e-02f, 6.54577836e-02f, 1.61224287e-02f, -5.58786020e-02f, -8.10735226e-02f, -1.78255200e-01f, -3.86080965e-02f,
  -1.30044371e-02f, -7.26588219e-02f, -1.65217686e-02f, 6.67223930e-02f, 1.35213554e-01f, 7.75683969e-02f, 9.84193981e-02f, -9.04715247e-03f, -2.53490303e-02f, 2.21917685e-02f,
  9.48029906e-02f, 1.08179979e-01f, 3.51550207e-02f, 6.92419484e-02f, 5.93799315e-02f, 4.76176664e-02f, 5.44224381e-02f, -6.03418946e-02f, 8.27194154e-02f, 4.27874876e-03f,
  9.90830585e-02f, -3.94845530e-02f, 4.32501584e-02f, 3.81530114e-02f, 4.81566377e-02f, 1.23927794e-01f, 1.42186387e-02f, -2.78770272e-02f, 2.29076594e-02f, 3.01070251e-02f,
  7.30644986e-02f, -6.18965700e-02f, 3.57113802e-03f, 1.19792782e-02f, 2.16076467e-02f, -2.02007815e-02f, 5.03388904e-02f, -1.04871221e-01f, -3.13881375e-02f, -5.88840544e-02f,
  -6.00843802e-02f, 6.46800995e-02f, -6.72411472e-02f, -6.52764086e-03f, -1.97497010e-02f, -4.62604426e-02f, -4.00346071e-02f, -7.76922032e-02f, -3.61808054e-02f, -7.87813440e-02f,
  -8.73044133e-03f, 7.33525455e-02f, 2.94394121e-02f, 4.34896089e-02f, 4.85356040e-02f, 2.66630109e-02f, -7.43280798e-02f, -1.06010456e-02f, 5.83174080e-02f, 8.43494982e-02f,
  1.25914384e-02f, 6.10510074e-02f, -3.84394303e-02f, -6.67133194e-04f, 9.87100676e-02f, 3.67671922e-02f, -2.83211423e-03f, 1.75120793e-02f, -9.78465527e-02f, 6.52386099e-02f,
  -2.58273892e-02f, -1.48543520e-02f, -2.11920887e-02f, 2.15311795e-02f, -2.19202247e-02f, -7.16970414e-02f, -4.29193974e-02f, 5.47218509e-02f, -5.91301080e-03f, 1.33689176e-02f,
  9.56657082e-02f, 4.86943359e-03f, 1.41827120e-02f, -1.07992087e-02f, 8.07195753e-02f, -1.13294553e-02f, 3.08805052e-02f, -1.81077365e-02f, -2.10854001e-02f, 4.03873250e-02f,
  -2.50691827e-02f, 5.51101565e-03f, -7.75394738e-02f, -9.53862891e-02f, -8.79329443e-02f, 2.51775663e-02f, 5.40438630e-02f, 5.29384054e-02f, 7.70479534e-03f, 9.29925069e-02f,
  6.23894297e-02f, 5.55614121e-02f, -1.40188420e-02f, -8.69058073e-02f, -8.99943411e-02f, 3.20535116e-02f, 4.13262509e-02f, 2.30615363e-02f, 5.33721820e-02f, -8.42399988e-03f,
  1.68556347e-01f, 2.73937304e-02f, 4.62074578e-02f, 5.51367961e-02f, -1.18331552e-01f, 7.64057189e-02f, 3.20191197e-02f, 3.46603952e-02f, 1.68645903e-01f, 2.66486872e-02f,
  -8.87675807e-02f, 3.67428251e-02f, -6.18717074e-02f, -6.93025440e-02f, -5.54995313e-02f, -4.15588208e-02f, 7.54839228e-03f, -4.27373089e-02f, 6.62435740e-02f, 2.11105011e-02f,
  1.05249425e-02f, -1.13784432e-01f, -1.36848748e-01f, -8.09780881e-02f, 2.92955823e-02f, -1.16539197e-02f, -1.50268033e-01f, -7.56145492e-02f, -9.62634385e-02f, -1.16706580e-01f,
  5.07546142e-02f, 9.99520123e-02f, 8.96249786e-02f, 1.16251692e-01f, 3.28354612e-02f, 5.25577441e-02f, -6.07836023e-02f, -1.30835343e-02f, 5.42286038e-02f, -3.73453484e-03f,
  3.56741101e-02f, -8.42539668e-02f, 1.01483196e-01f, 3.76001634e-02f, 6.77652732e-02f, -2.95341518e-02f, 1.05771273e-01f, 6.52825506e-03f, -2.32770797e-02f, 6.65375888e-02f,
  -6.38649333e-03f, 9.49448794e-02f, -2.02681106e-02f, -7.05277696e-02f, 6.88081831e-02f, 2.45286059e-02f, -6.73258454e-02f, -7.60532767e-02f, -5.59024177e-02f, -5.23106344e-02f,
  -2.48138383e-02f, -4.47437540e-02f, -4.66403142e-02f, 1.85689274e-02f, 2.01485176e-02f, 5.21647297e-02f, 8.40834156e-03f, 3.43047753e-02f, 1.11900154e-03f, -7.79875591e-02f,
  5.83977401e-02f, 9.82517563e-03f, -1.30320545e-02f, 9.42353830e-02f, -2.41447743e-02f, -5.54538006e-03f, -5.66694029e-02f, 6.33484721e-02f, 7.96071589e-02f, -4.00434211e-02f,
  -2.22969074e-02f, -5.68094477e-03f, 6.18827455e-02f, -3.86497453e-02f, 2.52623372e-02f, -5.73578291e-02f, 6.24147281e-02f, -5.84519692e-02f, -1.65077709e-02f, 3.07060331e-02f,
  -8.06187987e-02f, 3.04948594e-02f, 6.69613853e-02f, -3.69994044e-02f, 1.79749019e-02f, 6.07372224e-02f, 5.22429384e-02f, -7.28494972e-02f, 5.68497740e-02f, -5.54665551e-02f,
  -8.29023309e-03f, 5.63938282e-02f, 4.03666161e-02f, 7.05211312e-02f, 1.89187378e-02f, -5.42285480e-02f, -4.96596172e-02f, 2.65749600e-02f, -4.01296839e-02f, 1.70175135e-02f,
  -1.22386729e-02f, -4.03592037e-03f, 1.64996162e-02f, -3.02405488e-02f, 7.40092695e-02f, 1.85458362e-02f, 5.40463887e-02f, 4.27230597e-02f, -9.84435203e-04f, 4.19032015e-02f,
  -6.11850321e-02f, -1.22287013e-01f, -1.20869316e-02f, -1.43500492e-01f, 6.87998682e-02f, 6.58995286e-02f, -6.80627376e-02f, 3.28826793e-02f, -6.05782084e-02f, 7.13273436e-02f,
  1.50894895e-02f, -9.78904963e-02f, 4.73261476e-02f, 4.10187915e-02f, -5.24876416e-02f, 2.41718981e-02f, -8.12341459e-03f, -7.09522739e-02f, -2.71521974e-02f, -2.96654180e-02f,
  -4.18567769e-02f, -6.05476834e-02f, 7.05323368e-02f, 7.99324512e-02f, 1.00305956e-02f, -8.03828016e-02f, -3.16519290e-02f, 3.98319922e-02f, -6.37305602e-02f, 4.60730195e-02f,
  5.07283248e-02f, 1.32112037e-02f, -2.79233232e-02f, 5.87632731e-02f, 1.32416617e-02f, 8.60742703e-02f, -3.95392627e-02f, 5.92538901e-02f, 1.90592557e-02f, -2.79151089e-02f,
  2.80882362e-02f, -3.09345927e-02f, 4.22082022e-02f, -4.63255495e-02f, 5.11237904e-02f, 4.99925800e-02f, 4.36737761e-02f, -6.41336814e-02f, -9.17769969e-02f, -4.27731953e-04f,
  -5.91526274e-03f, 7.75092319e-02f, -5.07220402e-02f, -1.69846192e-02f, 1.67217553e-02f, -1.18094124e-02f, -4.49221954e-02f, -1.87899545e-02f, 9.77834314e-03f, 7.12123811e-02f,
  7.74914101e-02f, 1.18855760e-02f, -5.71436882e-02f, 1.87329750e-03f, 9.43299755e-02f, 3.34536359e-02f, 5.99182956e-02f, -3.30589525e-02f, -6.29150495e-02f, -8.04190934e-02f,
  -2.31386293e-02f, -4.75118496e-02f, -1.47574469e-02f, -8.04793611e-02f, -8.81367102e-02f, 4.93884161e-02f, 2.66070161e-02f, 6.88586161e-02f, 2.97124274e-02f, -6.90972954e-02f,
  -8.30988288e-02f, -3.90984770e-03f, 1.14967693e-02f, 1.74632878e-03f, 4.33394089e-02f, 3.96959409e-02f, 7.79746324e-02f, 2.36999616e-02f, 5.21979332e-02f, -8.59516393e-03f,
  -3.49300615e-02f, 9.90727469e-02f, 3.39997113e-02f, -7.06407335e-03f, -6.09814823e-02f, 1.03175126e-01f, 5.83823323e-02f, -5.99455982e-02f, 6.54927120e-02f, 6.97428640e-03f,
  5.08627929e-02f, 3.05716065e-04f, -2.84085702e-02f, -8.05321485e-02f, -3.19883935e-02f, -6.81070052e-03f, -5.35927676e-02f, -5.08547612e-02f, 1.67376939e-02f, 1.41826936e-03f,
  5.00476621e-02f, 1.95646994e-02f, -3.90989939e-03f, -6.63954811e-03f, -5.67180179e-02f, -5.14153317e-02f, 5.72103262e-02f, 9.22914669e-02f, -6.05136827e-02f, -3.94343734e-02f,
  5.09707863e-03f, -1.79298595e-02f, -6.07429110e-02f, 2.77876679e-04f, 2.29693446e-02f, 5.93515448e-02f, -8.00669286e-03f, -1.21062078e-01f, -9.39042270e-02f, -7.33898804e-02f,
  -1.71964690e-02f, -6.67638145e-03f, -7.53217116e-02f, 8.40693787e-02f, 1.25826254e-01f, -3.10884248e-02f, -1.45301428e-02f, 7.50330091e-02f, -5.04443236e-02f, -8.91657844e-02f,
  5.89951202e-02f, 1.03986241e-01f, -5.27640991e-02f, -8.48285854e-02f, 5.94574735e-02f, -2.80301124e-02f, -6.63537607e-02f, -5.18465973e-02f, -8.38348642e-03f, -4.46271263e-02f,
  1.00983158e-01f, -5.45728356e-02f, -7.01363683e-02f, -6.58372790e-02f, -4.04986814e-02f, 2.95602288e-02f, 1.67456605e-02f, -1.52307777e-02f, -9.09274258e-03f, 1.79232055e-04f,
  8.85764360e-02f, 7.05699548e-02f, 4.02199067e-02f, 1.71758700e-02f, -1.11138821e-02f, 3.89297144e-03f, -1.90955587e-02f, -3.51146702e-03f, 5.73618226e-02f, 4.24606949e-02f,
  9.33177955e-03f, 3.60993668e-02f, 9.13705081e-02f, 9.29637700e-02f, -5.78415766e-03f, 4.76137809e-02f, -5.19704707e-02f, 4.93540280e-02f, 3.77744362e-02f, -1.05006821e-01f,
  -5.11541078e-03f, 6.50859326e-02f, -4.29749526e-02f, 1.56108420e-02f, 4.39269729e-02f, -6.70077354e-02f, 9.26272869e-02f, 3.21989246e-02f, -7.35396296e-02f, -3.37038785e-02f,
  -8.03107619e-02f, 9.63612273e-03f, -3.28811482e-02f, 2.29703002e-02f, -2.35271864e-02f, -6.60691336e-02f, 1.73009858e-02f, -9.84360557e-03f, 1.38348117e-02f, 1.22512889e-03f,
  -3.08578811e-03f, 7.20168352e-02f, -7.57933557e-02f, 4.82789837e-02f, 4.58026975e-02f, -2.11661942e-02f, 6.79918751e-02f, -8.49953592e-02f, 2.00335309e-02f, -2.02870294e-02f,
  1.76040959e-02f, -6.52757660e-02f, 4.12176214e-02f, 8.05134140e-03f, -4.46520187e-02f, -3.09507065e-02f, -5.67165837e-02f, 2.40219440e-02f, 6.66480884e-02f, 5.83353378e-02f,
  -6.77441135e-02f, 5.29653281e-02f, 9.65818539e-02f, -8.18308890e-02f, 1.02761779e-02f, -3.31977904e-02f, 2.00026091e-02f, -1.71540976e-02f, -4.09993194e-02f, -5.49903587e-02f,
  9.13525745e-03f, -6.03520460e-02f, -6.50702640e-02f, -2.00825930e-02f, 8.70383456e-02f, -3.03187547e-03f, 7.40910918e-02f, -8.69607553e-02f, 7.16065317e-02f, -2.07966492e-02f,
  1.61171854e-01f, -1.21465646e-01f, 1.34146005e-01f, 2.16928199e-01f, -1.17347715e-02f, 2.51801852e-02f, -4.33702320e-02f, -7.15999827e-02f, 8.18032473e-02f, -6.75214306e-02f,
  -6.63357154e-02f, 1.35314614e-01f, -1.47941709e-01f, 1.04515627e-01f, 2.36034617e-02f, -8.08544680e-02f, -7.13955015e-02f, 2.41339765e-02f, -7.95465186e-02f, -7.20201666e-03f,
  1.24124907e-01f, -7.72503531e-03f, 8.70401338e-02f, -9.07436460e-02f, 6.36542290e-02f, 1.01824507e-01f, 2.09333729e-02f, -3.56277712e-02f, 1.47833571e-01f, 5.68557903e-02f,
  -8.32564011e-02f, -3.93259943e-05f, -2.23343503e-02f, 7.22571537e-02f, -4.64125210e-03f, -9.05712768e-02f, 7.96135962e-02f, 5.20076826e-02f, -3.11796702e-02f, 3.18160579e-02f,
  -3.32415327e-02f, -3.84199177e-03f, -2.45847423e-02f, -6.45287558e-02f, 6.97993040e-02f, 4.64905463e-02f, 1.22982793e-01f, 1.47256711e-02f, 9.07270797e-03f, -2.42022816e-02f,
  -4.22406606e-02f, -1.71949863e-02f, -4.67536747e-02f, 9.05925855e-02f, -1.22215804e-02f, 5.54151535e-02f, -7.67004043e-02f, -2.72112042e-02f, 2.30068807e-02f, 6.16953187e-02f,
  5.18244170e-02f, 4.77709807e-02f, 5.35487235e-02f, -3.81635763e-02f, 2.38971971e-02f, 1.02954833e-02f, 1.03652976e-01f, -6.57166541e-02f, 2.71862838e-02f, 3.37979458e-02f,
  4.99046296e-02f, 4.97832783e-02f, -1.00475382e-02f, 7.61726797e-02f, -5.30048162e-02f, 2.50841435e-02f, 4.96887416e-03f, -3.66638750e-02f, 2.30277446e-03f, 1.93449482e-02f,
  -1.22676734e-02f, -3.58024202e-02f, -6.17686249e-02f, -4.58973646e-03f, -6.54136762e-02f, -3.07091549e-02f, -4.69656512e-02f, -5.71312606e-02f, -5.79475649e-02f, 6.62589520e-02f,
  -1.46552294e-01f, -1.40999496e-01f, 3.67920063e-02f, 2.02737581e-02f, -4.61669751e-02f, -2.68027396e-03f, 1.81465130e-02f, -3.39687951e-02f, -1.23226695e-01f, -1.47185940e-02f,
  6.52323943e-03f, -1.65776853e-02f, 7.18237236e-02f, 5.29327476e-03f, 5.66634908e-02f, 2.23072786e-02f, 4.79171798e-02f, 2.39803959e-02f, -5.61865754e-02f, -1.32406587e-02f,
  4.46535535e-02f, -1.05789909e-02f, -2.10893508e-02f, 7.68277794e-02f, -4.02810331e-03f, 7.56576508e-02f, -8.91713575e-02f, -6.80689514e-02f, 5.89888021e-02f, -8.76687653e-03f,
  -2.30741635e-01f, -8.53620693e-02f, -1.09679578e-02f, -2.95013040e-02f, -1.09812088e-01f, -6.37638792e-02f, -5.79281785e-02f, -3.63701186e-03f, -9.16341469e-02f, 1.68019786e-01f,
  3.61029655e-02f, -6.35902882e-02f, -1.30845010e-02f, -1.87491172e-03f, 3.47685888e-02f, -2.08871346e-02f, 3.71307805e-02f, 1.53417960e-01f, 3.44764115e-03f, -1.47442147e-01f,
  2.75357272e-02f, 3.44530586e-03f, 7.16403797e-02f, -1.40302787e-02f, -3.84805389e-02f, -2.25598626e-02f, 5.18307872e-02f, -1.00900061e-01f, -7.41198063e-02f, 3.87241021e-02f,
  5.13501884e-03f, -1.09707870e-01f, -9.58890766e-02f, 4.30539176e-02f, -7.41606429e-02f, -5.84101863e-02f, 7.94471875e-02f, 4.33765873e-02f, -4.04329486e-02f, -9.65373814e-02f,
  -2.78763417e-02f, -5.46680242e-02f, -6.38812035e-02f, -5.77823557e-02f, 8.06169435e-02f, -7.73768425e-02f, 2.46275940e-05f, 6.73209922e-03f, 4.59906310e-02f, -7.58071840e-02f,
  -2.57534664e-02f, 5.05651869e-02f, 1.92194041e-02f, -5.10217715e-03f, 3.38070616e-02f, 6.02944195e-02f, -7.61159882e-03f, 2.83496846e-02f, 2.86415163e-02f, 7.19664320e-02f,
  -2.80508748e-03f, 3.57624590e-02f, 1.52989393e-02f, -3.84844355e-02f, -7.89685547e-02f, 9.68459621e-02f, -4.01800312e-02f, -1.29296109e-02f, -5.34916744e-02f, -1.13757206e-02f,
  1.30549716e-02f, 1.89259686e-02f, -4.35227938e-02f, 2.64425036e-02f, -6.68609068e-02f, -6.03207834e-02f, -3.75903398e-02f, 4.26081270e-02f, 5.27635589e-02f, 2.23343144e-03f,
  3.64717469e-02f, -4.50282805e-02f, 2.62365880e-04f, -2.64540315e-02f, 5.46947904e-02f, -7.19379783e-02f, 8.13587452e-04f, 2.97792386e-02f, -5.79613075e-02f, -4.27214429e-02f,
  -9.94513333e-02f, -8.36231485e-02f, 5.91523945e-03f, -3.20651568e-02f, -1.59059670e-02f, -6.47757128e-02f, -5.71243949e-02f, 2.61718761e-02f, -2.09413804e-02f, 2.89722960e-02f,
  1.22689251e-02f, -7.22776493e-03f, 4.46462557e-02f, 7.96487182e-02f, -4.61915992e-02f, 4.10818262e-03f, 1.31269116e-02f, -9.06073600e-02f, -4.40257490e-02f, -5.94734512e-02f,
  1.97555684e-02f, 2.64459811e-02f, 2.23500803e-02f, -4.77174856e-02f, 5.74181564e-02f, 2.13458128e-02f, 4.53799069e-02f, 1.86712656e-03f, 5.83765805e-02f, -5.84878735e-02f,
  -3.11158210e-01f, 1.53302327e-01f, 2.85121575e-02f, -2.20388129e-01f, -7.45334253e-02f, 7.59416223e-02f, -5.27929291e-02f, 9.02324319e-02f, -1.08991573e-02f, -8.77238996e-03f,
  -1.61897279e-02f, -3.85633036e-02f, 7.74341375e-02f, -9.82435346e-02f, -2.84035411e-02f, -2.36071162e-02f, -1.10988617e-01f, -3.34132537e-02f, 1.05077073e-01f, -5.85432537e-02f,
  -5.29338308e-02f, -8.78352523e-02f, -9.00156721e-02f, 1.02341495e-01f, -7.76470676e-02f, -9.27313641e-02f, -1.45699292e-01f, 6.60521686e-02f, 2.31842306e-02f, -4.73521240e-02f,
  -1.22578189e-01f, -7.58394748e-02f, -1.54574784e-02f, 6.66634589e-02f, 3.30890268e-02f, -3.48950587e-02f, 2.12434102e-02f, -1.57297328e-02f, -7.50859305e-02f, 8.75225961e-02f,
  -7.03830644e-02f, -6.26592338e-02f, -1.15223723e-02f, 9.26013198e-03f, -3.01992577e-02f, 5.32391034e-02f, -4.88479622e-02f, -4.87226099e-02f, 1.69905573e-02f, 1.95338838e-02f,
  9.25511867e-02f, 8.80010705e-03f, 3.29702976e-03f, -4.06647399e-02f, -7.20628886e-05f, -6.55554160e-02f, -1.33785338e-03f, -7.30087087e-02f, -8.44576955e-03f, 5.63239753e-02f,
  -6.04089163e-02f, 8.35905448e-02f, 5.52857406e-02f, 7.23873079e-02f, -2.50267666e-02f, 3.45366215e-03f, -8.22740048e-02f, 2.19054427e-02f, -3.89461964e-02f, -2.74438579e-02f,
  -1.19794654e-02f, -6.14834158e-03f, 3.33611555e-02f, -2.12826813e-03f, -2.92408951e-02f, 1.95866055e-03f, 2.94656325e-02f, 7.62550533e-02f, -1.91926323e-02f, 8.54119882e-02f,
  6.31880341e-03f, -2.91960929e-02f, -6.04471378e-02f, 9.39190388e-03f, 1.11007817e-01f, -3.63866352e-02f, 7.56272301e-03f, 7.57707795e-03f, -4.96375188e-02f, -1.07260957e-01f,
  -1.11417778e-01f, -2.08141491e-01f, 6.49192706e-02f, -1.59890000e-02f, 3.07819783e-03f, -4.59411219e-02f, -7.83719718e-02f, -7.15780407e-02f, 2.76995301e-02f, -4.03843857e-02f,
  -4.52820538e-03f, 2.99421791e-03f, -4.97795865e-02f, -5.40868267e-02f, 4.59007770e-02f, 5.20467199e-02f, 3.26692313e-02f, -4.77614217e-02f, -9.52366441e-02f, 6.91314489e-02f,
  -5.96997961e-02f, -2.89193504e-02f, -1.47978608e-02f, 6.25094771e-02f, 4.03818255e-03f, -3.86767983e-02f, -1.10723833e-02f, -3.47339176e-02f, -5.42504191e-02f, 3.45706157e-02f,
  9.95361358e-02f, 1.59061179e-01f, 6.25496805e-02f, 2.32598960e-01f, -5.29600531e-02f, -1.48835734e-01f, -1.10835582e-01f, -3.31666134e-02f, 7.35508129e-02f, 2.07059067e-02f,
  -1.54783577e-02f, 2.91042458e-02f, 7.89196715e-02f, 1.50771976e-01f, 4.71748412e-02f, -4.93266098e-02f, 1.45861506e-01f, 1.04814731e-01f, -2.57519390e-02f, 1.59011185e-01f,
  1.23574778e-01f, -2.71140579e-02f, 1.48292363e-01f, -4.50106151e-02f, 2.17162054e-02f, 1.34690657e-01f, 1.47557128e-02f, -1.08003244e-01f, 1.10259943e-01f, 4.48530689e-02f,
  -4.90409806e-02f, 3.27659696e-02f, 9.94653627e-02f, 3.11291907e-02f, -1.62954908e-02f, -8.46093148e-02f, 2.89711915e-02f, -8.63994434e-02f, 3.06322966e-02f, -5.95901953e-03f,
  -1.06627867e-02f, -3.77631746e-02f, -6.28461689e-02f, 4.62286063e-02f, -3.71536054e-02f, -5.75329848e-02f, 2.68072821e-02f, -4.18094173e-02f, 5.66795953e-02f, -2.04652529e-02f,
  -7.21731856e-02f, -7.10127279e-02f, -2.32064612e-02f, 6.65733591e-02f, -7.77736306e-02f, -5.07121868e-02f, -5.83250560e-02f, -9.58109554e-03f, 5.95028214e-02f, 3.07319760e-02f,
  -6.38863444e-02f, -8.56472701e-02f, -1.11531485e-02f, -6.75467774e-02f, -4.37088721e-02f, -8.04679319e-02f, -1.96666885e-02f, 1.73238642e-03f, 5.83598502e-02f, 1.53480815e-02f,
  3.53457406e-02f, -1.79933999e-02f, -1.77217107e-02f, -2.78421268e-02f, 9.05696973e-02f, -9.08186957e-02f, -6.81997240e-02f, -3.78620587e-02f, 3.46819796e-02f, -7.35371327e-03f,
  -7.16687068e-02f, -7.18795881e-02f, -8.10457766e-02f, -7.14697242e-02f, -6.35176077e-02f, 1.00698564e-02f, 7.89376907e-03f, -4.03725170e-02f, -5.15033398e-03f, 6.26985058e-02f,
  -4.87469025e-02f, 1.51676804e-01f, 4.88207676e-02f, 4.29422706e-02f, 2.04050988e-02f, -5.87573312e-02f, 4.21703700e-03f, 8.22151378e-02f, -3.67358290e-02f, 5.77641726e-02f,
  2.32431833e-02f, -3.73601429e-02f, 6.86876997e-02f, 4.63002138e-02f, 1.98038556e-02f, 6.96828961e-02f, -1.08699678e-02f, 3.86364050e-02f, 1.02790417e-02f, 7.38715902e-02f,
  9.79799684e-03f, -2.30255947e-02f, 7.55934119e-02f, -3.20026726e-02f, 4.58292030e-02f, -8.20879713e-02f, -7.62933791e-02f, 6.38866127e-02f, 6.33717626e-02f, 9.28946063e-02f,
  -1.47527102e-02f, -9.19110477e-02f, 3.33092995e-02f, -1.99226633e-01f, 5.02141193e-02f, -1.78449288e-01f, -1.74612239e-01f, -1.35087520e-01f, -3.11763510e-02f, -7.46050254e-02f,
  -6.64937496e-02f, -2.13982947e-02f, 6.74239174e-02f, -6.06340095e-02f, 7.57738873e-02f, 1.47580460e-01f, -2.55414873e-01f, -1.42476141e-01f, -7.90372863e-02f, -1.52542591e-01f,
  -1.50407758e-02f, -1.68887973e-01f, -7.86922649e-02f, -1.07057124e-01f, -3.69258635e-02f, -8.56778473e-02f, 2.71002762e-02f, -5.75711876e-02f, -4.25006188e-02f, -4.91988286e-02f,
  -2.05045622e-02f, 2.58554257e-02f, -1.82522070e-02f, -1.99071020e-02f, -6.61602393e-02f, -8.14191028e-02f, -5.45712980e-03f, 2.59225927e-02f, 1.83978525e-03f, 4.50832099e-02f,
  6.26839548e-02f, 8.66591260e-02f, 1.57924499e-02f, -4.73627076e-02f, -2.41922098e-03f, -8.86133909e-02f, -8.86514112e-02f, -7.04104081e-02f, 3.53482850e-02f, -1.71775967e-02f,
  3.19873616e-02f, -3.62399854e-02f, -4.89049852e-02f, 4.83748056e-02f, -1.39551014e-02f, -6.83835242e-03f, 8.44767615e-02f, 3.93732265e-02f, -1.91111062e-02f, 5.21253012e-02f,
  -1.03292204e-01f, -5.57378270e-02f, 1.59279853e-02f, -7.30155259e-02f, 1.19370297e-02f, -6.93575442e-02f, 3.81975137e-02f, -7.28980899e-02f, 3.65945846e-02f, 1.89140141e-02f,
  2.70515867e-02f, 5.95766306e-02f, -1.02466792e-01f, 1.31371059e-02f, 4.12324779e-02f, 2.49832626e-02f, -3.81177142e-02f, -7.19313547e-02f, 4.79214080e-02f, -5.63430898e-02f,
  -7.08068684e-02f, 9.83779132e-03f, -1.67479832e-02f, 5.79539090e-02f, -2.03628037e-02f, -4.93563861e-02f, 2.17158236e-02f, -4.17720042e-02f, 5.26022315e-02f, 4.76868972e-02f,
  -6.10418133e-02f, -1.87696904e-01f, -5.41240387e-02f, -2.94072218e-02f, -7.29205878e-03f, -4.02511321e-02f, -4.50088568e-02f, 3.65191959e-02f, 5.23695052e-02f, 5.57488156e-03f,
  -9.39696729e-02f, -3.57931852e-02f, -6.40423689e-03f, -5.47100278e-03f, -1.42830322e-02f, -4.92791831e-02f, -1.02648987e-02f, 8.20442885e-02f, -1.19302410e-03f, 2.27793232e-02f,
  2.67680027e-02f, 4.40095887e-02f, -4.77258228e-02f, -5.55321872e-02f, -6.44228384e-02f, -1.99083127e-02f, -3.51502076e-02f, -7.86222667e-02f, -2.84748189e-02f, 3.48794530e-03f,
  -1.18196271e-01f, -3.37836742e-01f, -2.14403465e-01f, 1.17311897e-02f, 1.57089174e-01f, 7.73918582e-03f, -1.16267361e-01f, 2.70770956e-02f, -2.04007566e-01f, -9.12740901e-02f,
  1.85374469e-02f, -2.87285298e-02f, -2.73926437e-01f, -1.40369637e-02f, 2.05541793e-02f, -2.25456670e-01f, 1.48931578e-01f, 5.32330163e-02f, -1.03715055e-01f, -1.96618512e-02f,
  -5.16849011e-02f, 7.85250738e-02f, 5.67929335e-02f, 1.89994529e-01f, -6.09960989e-04f, 1.25707891e-02f, 2.05698326e-01f, 1.00001372e-01f, 2.36174405e-01f, 9.51951817e-02f,
  -2.85986252e-02f, -9.47488621e-02f, -8.73132125e-02f, 3.52239870e-02f, 6.01108745e-02f, 1.08046874e-01f, 3.78235430e-03f, 1.04832374e-01f, 8.50816630e-03f, -1.86840445e-02f,
  -5.65016679e-02f, -2.83870138e-02f, 6.41324446e-02f, 2.91891173e-02f, -4.91892286e-02f, 3.92311998e-02f, -8.65849778e-02f, -8.35755188e-03f, -6.03193119e-02f, -1.23973235e-01f,
  -1.26036674e-01f, 6.40608221e-02f, 3.43554206e-02f, 2.71989070e-02f, -5.07781096e-02f, 6.02011308e-02f, 6.09681234e-02f, -3.76719679e-03f, 6.33075759e-02f, 7.02123642e-02f,
  -4.51149121e-02f, -7.21873045e-02f, 2.61477707e-03f, -5.65469265e-02f, -6.11859560e-02f, -3.48921493e-02f, 4.79348302e-02f, 4.01873514e-02f, 7.23797008e-02f, -1.63703617e-02f,
  -1.78082213e-02f, 3.12982723e-02f, 1.44922649e-02f, -2.78486386e-02f, -7.52677470e-02f, 3.34690623e-02f, 2.18797419e-02f, 8.32273066e-02f, 6.38005277e-03f, -7.38543794e-02f,
  2.63985395e-02f, 1.93651095e-02f, -1.53861102e-02f, -1.10153276e-02f, -4.09040004e-02f, 9.89980437e-03f, -2.97226794e-02f, 4.53289039e-03f, 5.27145639e-02f, -8.45507625e-03f,
  7.52016716e-03f, -8.36003199e-02f, 1.67773142e-02f, -1.15170693e-02f, -3.87370167e-03f, 6.12419620e-02f, 9.01944861e-02f, 1.37026533e-02f, 2.68998579e-03f, -8.22352171e-02f,
  5.64613566e-02f, 1.19095877e-01f, 5.67238852e-02f, 6.45181015e-02f, 1.69147588e-02f, -6.91281557e-02f, 6.28653243e-02f, 2.71116644e-02f, 1.36349201e-01f, 3.73201333e-02f,
  -1.47321820e-02f, -1.07841520e-02f, 7.28328526e-02f, -1.49559090e-02f, -2.96566393e-02f, -6.55803606e-02f, 2.16348357e-02f, 8.93434510e-03f, 7.75380880e-02f, 1.75841004e-02f,
  -8.74153674e-02f, 8.68704244e-02f, -1.11983167e-02f, 3.89080904e-02f, -6.35997355e-02f, -1.04590468e-01f, 9.67954546e-02f, 1.08767815e-01f, 1.82536751e-01f, 1.19430840e-01f,
  -3.64774093e-02f, -7.52724856e-02f, -3.44621018e-02f, -3.68727930e-02f, 4.97699529e-03f, -2.31265668e-02f, -4.21304815e-02f, -2.06679013e-02f, -2.20934791e-03f, 7.78392015e-04f,
  -5.22123910e-02f, -1.42188538e-02f, -8.05973783e-02f, -2.14840658e-02f, -2.72717550e-02f, 8.17386582e-02f, -7.65794516e-02f, 1.08570019e-02f, 3.81130278e-02f, 1.24834655e-02f,
  3.08366679e-02f, 1.24808244e-01f, -5.89401424e-02f, -2.47585308e-02f, 7.16729611e-02f, -5.85259683e-02f, -2.87570991e-02f, 3.67887281e-02f, -5.96501678e-02f, 1.48380091e-02f,
  -2.75802054e-02f, 2.54938751e-02f, 8.33010450e-02f, -3.13314945e-02f, 8.48926455e-02f, -2.01965533e-02f, -4.06105630e-02f, 8.19785744e-02f, -2.51751821e-02f, -5.48010990e-02f,
  -2.98589915e-02f, -9.09623429e-02f, 6.89921752e-02f, -7.82794971e-03f, -8.77220482e-02f, -2.72696540e-02f, 6.04667999e-02f, -4.68934737e-02f, -1.60759315e-02f, 8.04572031e-02f,
  -2.69140042e-02f, -6.42595291e-02f, -5.21931946e-02f, 7.21979365e-02f, -1.27626574e-02f, 1.50993392e-02f, -7.51193464e-02f, -5.06757125e-02f, -6.20108051e-03f, -1.63283460e-02f,
  -2.08783597e-02f, -3.06391697e-02f, 6.06316626e-02f, -3.85676064e-02f, -6.82989433e-02f, -1.36813717e-02f, 6.37996420e-02f, 1.07795661e-02f, 1.87894478e-02f, 7.72189349e-02f,
  1.83172408e-04f, -1.34294536e-02f, -5.25993146e-02f, -5.43247610e-02f, 9.13609639e-02f, 5.24120145e-02f, 6.44764975e-02f, -4.46146242e-02f, 3.39575596e-02f, -1.93862636e-02f,
  -7.06595257e-02f, 4.83179688e-02f, 4.71809991e-02f, 8.16445127e-02f, 7.44495019e-02f, -5.95826320e-02f, -6.65652379e-02f, 5.69423512e-02f, -3.83133441e-02f, -1.73101071e-02f,
  -8.56785625e-02f, 1.61590036e-02f, -6.09422065e-02f, -6.02055751e-02f, -2.69088522e-03f, -9.81906988e-03f, 1.03209456e-02f, -5.33602238e-02f, -5.42019159e-02f, 9.46575869e-03f,
  7.06689944e-03f, -8.47822800e-03f, -6.80742189e-02f, 8.48823264e-02f, -1.06403209e-01f, 3.63002764e-03f, 7.14437142e-02f, 1.88508201e-02f, -1.35484990e-02f, 3.61077418e-03f,
  1.97366234e-02f, 5.19096628e-02f, 7.07524866e-02f, 1.18053682e-01f, -1.79188520e-01f, -3.77225757e-01f, -3.14171761e-01f, -6.58606365e-02f, 6.17539659e-02f, -5.09653240e-02f,
  -1.62916481e-01f, 2.43618399e-01f, 2.96526961e-02f, -4.44433279e-02f, -5.46976477e-02f, 7.96858128e-03f, -1.40800640e-01f, -6.69254810e-02f, 7.06262961e-02f, -5.03230654e-02f,
  7.53707141e-02f, -3.20784748e-02f, 1.13252588e-01f, -1.04031786e-01f, -5.90818152e-02f, 1.02510549e-01f, 1.54557273e-01f, -3.48503850e-02f, -2.48270277e-02f, 6.75788941e-03f,
  1.87427457e-02f, 1.03132449e-01f, 2.20730249e-02f, -1.10095832e-02f, -6.50617555e-02f, -5.04071265e-03f, 1.52845746e-02f, 6.61768019e-03f, 6.59082308e-02f, 6.12078905e-02f,
  1.94015447e-02f, -1.62760913e-02f, -3.40619683e-02f, 7.41246194e-02f, 1.70931704e-02f, 2.38540452e-02f, 1.23890549e-01f, 1.51176564e-02f, 3.09421439e-02f, -3.69918831e-02f,
  7.48353377e-02f, 9.47182402e-02f, -7.56280671e-04f, 9.90042984e-02f, 6.57883659e-02f, 3.84146310e-02f, -2.51912302e-03f, 1.06048018e-01f, 6.12932583e-03f, -3.20143066e-02f,
  4.32811268e-02f, -7.16119334e-02f, -5.33553846e-02f, 2.89988443e-02f, -2.13865917e-02f, 6.87491819e-02f, 8.25921372e-02f, -2.80687883e-02f, -2.32547708e-02f, -2.83861998e-03f,
  -1.86707992e-02f, 3.85465771e-02f, -4.20420095e-02f, -3.18055637e-02f, 6.49506645e-03f, -2.11510900e-02f, -4.38394397e-02f, 4.08324040e-02f, -3.72665748e-02f, -2.59604920e-02f,
  6.35788813e-02f, -1.54993555e-03f, 8.53632540e-02f, -8.21737051e-02f, -6.05946183e-02f, 4.68344577e-02f, -1.14367856e-02f, 7.33770356e-02f, 5.61321061e-03f, -2.03005616e-02f,
  3.21725644e-02f, 1.54910102e-01f, 1.91548597e-02f, 4.34272885e-02f, -2.35375687e-02f, -3.76480967e-02f, 2.39705909e-02f, -7.09830597e-02f, 4.87132370e-02f, -9.58149787e-03f,
  -7.77179971e-02f, -1.69705730e-02f, -1.83663834e-02f, -2.92081945e-02f, 3.94524820e-02f, -1.29820378e-02f, 5.66041272e-04f, -2.99903527e-02f, 6.17548563e-02f, -4.09986172e-03f,
  9.55759510e-02f, 1.49289872e-02f, -1.93108432e-02f, -1.08277425e-01f, -4.53601517e-02f, 2.94418819e-02f, -2.64043584e-02f, -6.52604625e-02f, 3.60296592e-02f, -7.74734421e-03f,
  -8.78107324e-02f, -4.60867025e-02f, 4.47413251e-02f, -7.44437277e-02f, 1.12189941e-01f, 8.88927504e-02f, -7.04219714e-02f, 1.03207514e-01f, -8.31485689e-02f, -5.74241057e-02f,
  -4.30051647e-02f, -1.40459433e-01f, 6.60095438e-02f, -7.60140875e-03f, -7.41359070e-02f, 1.37423398e-02f, -3.41530493e-03f, -6.03269506e-03f, 7.29892403e-02f, 9.04637501e-02f,
  8.26354921e-02f, 1.06622567e-04f, 5.61932474e-02f, 1.20377682e-01f, 6.66602924e-02f, 2.09973357e-03f, -5.83452992e-02f, 4.40164953e-02f, -2.78756879e-02f, -2.03506071e-02f,
  3.29547040e-02f, -1.00940149e-02f, -4.54617701e-02f, 6.44507706e-02f, 1.18131032e-02f, 2.15568524e-02f, -9.83314738e-02f, 6.16437420e-02f, 1.51487133e-02f, 6.83327317e-02f,
  3.87160592e-02f, -6.49780110e-02f, -3.68428268e-02f, -3.36887203e-02f, 5.11449762e-02f, 4.20836546e-03f, -1.59242854e-03f, -6.04831502e-02f, 8.40881374e-03f, 2.87506683e-03f,
  -5.25787473e-02f, -5.11570945e-02f, -4.00620997e-02f, -2.62900572e-02f, 2.65469234e-02f, 7.20062926e-02f, 6.86424971e-02f, -6.11761510e-02f, -1.14560351e-02f, 1.87748298e-02f,
  1.84854176e-02f, 8.36192146e-02f, -7.93619677e-02f, -7.39079565e-02f, -2.84043979e-03f, -3.35611263e-03f, 4.21396457e-02f, -3.20599624e-03f, 7.87645057e-02f, -7.66803324e-02f,
  1.72235537e-02f, 4.41626497e-02f, -8.86490643e-02f, 5.56153804e-02f, -6.33300766e-02f, -4.02947962e-02f, -5.88097088e-02f, 5.06751984e-02f, -3.15591879e-02f, 3.67654040e-02f,
  -4.33945209e-02f, -7.44790584e-02f, -4.09616269e-02f, 7.69108608e-02f, 6.38662502e-02f, 2.29635108e-02f, 6.77661598e-02f, 6.15670420e-02f, -8.54476914e-03f, -6.01081038e-03f,
  -1.30646545e-02f, 4.41431478e-02f, 2.10837480e-02f, 6.57333359e-02f, 4.09246534e-02f, 7.03354180e-02f, 2.52577309e-02f, -8.52335989e-02f, -4.13285680e-02f, 2.81116329e-02f,
  -2.16662977e-02f, 7.46294335e-02f, 6.68373257e-02f, -2.57214829e-02f, -4.32819780e-03f, 1.75770782e-02f, 2.22899523e-02f, 3.56442519e-02f, 3.93083207e-02f, 5.21502681e-02f,
  -6.88759759e-02f, 2.39255768e-03f, -2.84406319e-02f, -4.28434927e-03f, 2.73551084e-02f, -3.08748577e-02f, -7.29856268e-02f, -3.80995125e-02f, -1.99877620e-02f, -3.20413616e-03f,
  1.05505630e-01f, -3.31529230e-02f, -2.14420244e-01f, -5.72054684e-02f, -1.35609344e-01f, -2.38014292e-02f, 3.63303274e-02f, 2.75564045e-02f, -1.42712086e-01f, 6.68344796e-02f,
  5.82955442e-02f, 1.47065790e-02f, -7.04078078e-02f, 1.46177083e-01f, 8.86512920e-02f, 7.25218877e-02f, 1.70303702e-01f, -6.94687897e-03f, -7.30720609e-02f, -3.01594008e-02f,
  9.39978808e-02f, 2.21696779e-01f, 9.59420800e-02f, 9.12002008e-03f, 4.43528257e-02f, 4.07947004e-02f, 1.64348722e-01f, 7.23544974e-03f, 1.07699491e-01f, 5.39484136e-02f,
  -5.34071028e-02f, 1.04659162e-01f, -7.56228343e-02f, -8.67032111e-02f, -3.18582952e-02f, 9.49851889e-03f, -8.92510042e-02f, -5.11429273e-02f, 2.38310657e-02f, -5.78344129e-02f,
  9.56925191e-03f, 2.68034320e-02f, -1.34245604e-02f, 4.25597001e-03f, 4.13231290e-04f, -8.21149945e-02f, 3.32668759e-02f, 4.85905744e-02f, 5.47583848e-02f, 2.67064869e-02f,
  3.28364745e-02f, 2.83242529e-03f, -3.49035859e-02f, 2.46714167e-02f, 8.88698269e-04f, 6.07683212e-02f, 4.77533378e-02f, -2.73202844e-02f, -7.36917108e-02f, -5.41859679e-03f,
  5.70223387e-03f, 6.55003786e-02f, 7.02872053e-02f, -4.03859466e-03f, -3.86659168e-02f, 3.88992205e-02f, 5.15826717e-02f, -9.81698036e-02f, 2.19184645e-02f, 5.33717684e-02f,
  3.32338735e-02f, -6.77180961e-02f, -5.26172146e-02f, 3.02519538e-02f, -4.63383272e-02f, 6.83858097e-02f, 2.15123761e-02f, 3.65814120e-02f, 4.11894098e-02f, 2.59968899e-02f,
  -6.98919520e-02f, -1.13781570e-02f, 4.22261208e-02f, 4.96387109e-02f, 2.64836960e-02f, 6.28318489e-02f, 4.17733602e-02f, 3.87576371e-02f, -1.59183226e-03f, -3.38785574e-02f,
  1.19234562e-01f, 1.16144411e-01f, -2.67178584e-02f, -4.97380905e-02f, -2.98252031e-02f, 2.68920306e-02f, 2.51133051e-02f, 3.39590721e-02f, -7.94841275e-02f, -3.45418602e-02f,
  7.11591765e-02f, 1.01797353e-03f, 5.26176915e-02f, 2.60767881e-02f, 2.86062919e-02f, 5.83349615e-02f, 5.05939946e-02f, 2.23958679e-02f, -8.73809457e-02f, 6.42160028e-02f,
  -6.44892752e-02f, 2.64599342e-02f, -7.25092664e-02f, -6.07097186e-02f, -8.21966156e-02f, -4.80488464e-02f, 6.03607744e-02f, -1.00502901e-01f, -6.71861991e-02f, 4.29910235e-02f,
  -4.90298979e-02f, -1.20100662e-01f, -1.25679061e-01f, -7.94942081e-02f, 2.15395596e-02f, 6.01258576e-02f, -3.71320434e-02f, 1.14753097e-02f, -1.02097727e-01f, -6.67171329e-02f,
  -4.18458208e-02f, -1.37188196e-01f, -1.51708916e-01f, -8.77500549e-02f, 9.85242203e-02f, -2.87061781e-02f, -2.05411129e-02f, -5.08215241e-02f, 1.90690334e-03f, -9.85814482e-02f,
  6.80083930e-02f, 5.77643476e-02f, 1.69150420e-02f, 1.48465727e-02f, 8.76816958e-02f, 1.25072390e-01f, 1.76472709e-01f, -1.17134629e-02f, 1.08604647e-01f, 1.05217300e-01f,
  6.99979290e-02f, -1.30845964e-01f, 1.74145233e-02f, -2.33585364e-03f, -2.96854563e-02f, 5.69531098e-02f, -2.10017115e-02f, -4.61128317e-02f, 1.91108566e-02f, -7.22607747e-02f,
  -6.59784675e-02f, 8.22472293e-03f, -5.23950383e-02f, 5.79401515e-02f, -6.71579987e-02f, 6.92735836e-02f, -8.84776339e-02f, -7.95795619e-02f, -4.84728478e-02f, 8.64344370e-03f,
  -1.91462766e-02f, -7.13046193e-02f, 4.82885949e-02f, 8.17987472e-02f, 7.13337883e-02f, -2.56517008e-02f, 2.13397085e-03f, 7.53207728e-02f, 5.07451780e-02f, -3.32602710e-02f,
  2.66968068e-02f, -1.51592700e-04f, 5.64559102e-02f, -3.48707698e-02f, -3.43170017e-02f, 4.44785878e-02f, -2.19153836e-02f, -4.45091501e-02f, -1.02624819e-02f, -3.01487055e-02f,
  -2.48385631e-02f, -5.89688541e-03f, -1.62333734e-02f, 1.10652195e-02f, 7.74125308e-02f, 5.86897507e-02f, -4.37314175e-02f, 5.98788029e-04f, 2.98087895e-02f, 7.15746507e-02f,
  6.73134625e-02f, 2.09167004e-02f, 5.21817282e-02f, 3.05275787e-02f, 5.18928468e-02f, -6.52803406e-02f, 7.39162192e-02f, -5.31548895e-02f, -6.23155311e-02f, 8.43603984e-02f,
  1.65489241e-02f, -7.44369477e-02f, 2.79844627e-02f, 2.87614409e-02f, -1.71607062e-02f, -8.43640268e-02f, 8.06570351e-02f, -7.51189366e-02f, -4.12525982e-02f, -2.77732825e-03f,
  4.73519936e-02f, -4.72051762e-02f, 1.06030740e-01f, -4.70751263e-02f, 1.44008454e-02f, -9.32212397e-02f, -2.30098851e-02f, -3.58123556e-02f, -2.25176048e-02f, 1.47864064e-02f,
  6.40998259e-02f, -7.60968253e-02f, -5.83286993e-02f, -2.44027413e-02f, 9.53893140e-02f, 1.06745310e-01f, 1.09603293e-01f, 5.68215363e-02f, 3.90153890e-03f, -3.29894945e-02f,
  -2.54856408e-01f, 7.56388083e-02f, -1.18009103e-02f, 6.43392131e-02f, 2.11434159e-02f, -2.02337191e-01f, -1.78671688e-01f, 3.78391892e-02f, -8.75633582e-02f, -2.24004798e-02f,
  9.91102085e-02f, -5.81217632e-02f, 4.03410606e-02f, -6.11736327e-02f, -1.95368603e-01f, 1.13958493e-02f, 2.21603326e-02f, -1.13508552e-02f, 5.78699335e-02f, 9.75070819e-02f,
  2.89299916e-02f, 3.82403545e-02f, -4.13550138e-02f, 1.62089169e-01f, -5.10997325e-02f, 8.35745409e-02f, 7.54318805e-03f, 1.98863968e-01f, 3.08768339e-02f, -6.35644943e-02f,
  -7.64813200e-02f, 1.02077387e-01f, 6.59268945e-02f, -4.16652560e-02f, 6.51200935e-02f, -1.07743308e-01f, -6.78261966e-02f, -6.42323345e-02f, -1.69245880e-02f, -3.95703986e-02f,
  2.49687135e-02f, -1.58447269e-02f, -2.17432287e-02f, -3.24505605e-02f, -3.53070796e-02f, 7.12587535e-02f, -2.80168317e-02f, -1.19335484e-02f, 8.93308744e-02f, 2.76222602e-02f,
  -7.87145831e-03f, -5.17397933e-02f, -1.14796488e-02f, -5.88100813e-02f, 4.13583666e-02f, -3.08785215e-02f, -5.65175451e-02f, 3.68627161e-02f, 2.10002232e-02f, -5.58806509e-02f,
  -7.70779848e-02f, 3.45128551e-02f, 7.12246224e-02f, 6.39386699e-02f, -7.64990151e-02f, 1.02814347e-01f, 4.86066332e-03f, 8.22709203e-02f, -5.19147180e-02f, 8.64126012e-02f,
  -7.56051987e-02f, 7.41722882e-02f, -3.66024720e-03f, -7.85197541e-02f, 4.87133265e-02f, -4.58998866e-02f, -2.45705768e-02f, 7.98166171e-02f, -3.47151384e-02f, -9.04056337e-03f,
  4.30803113e-02f, -3.26452628e-02f, 1.00172132e-01f, 3.72327268e-02f, -1.48229236e-02f, 6.00245856e-02f, 9.47835296e-03f, -2.77241301e-02f, -2.26213709e-02f, -2.02248413e-02f,
  -6.20680116e-02f, 7.58733675e-02f, 7.77610987e-02f, 3.69388796e-02f, -4.46329750e-02f, -1.05578080e-02f, -5.41330352e-02f, 6.74802959e-02f, 4.86998074e-02f, 6.08100519e-02f,
  1.79955959e-02f, -6.14422783e-02f, 3.59862894e-02f, 7.63606951e-02f, -9.08333510e-02f, -5.13798706e-02f, -2.43935343e-02f, -3.01314201e-02f, -7.03284368e-02f, 3.02035548e-02f,
  4.86436486e-02f, -5.70684625e-03f, -5.25176562e-02f, -7.03943800e-03f, -6.61716014e-02f, -1.64396446e-02f, 3.10773253e-02f, -3.51224765e-02f, -1.82280093e-02f, -5.85417636e-02f,
  -1.24016337e-01f, -5.15101105e-02f, -6.75852448e-02f, -5.39740373e-04f, -7.80979618e-02f, 1.06158286e-01f, 3.32721919e-02f, 3.04872319e-02f, 3.95392217e-02f, 1.97775036e-01f,
  4.49107364e-02f, -3.51800323e-02f, 1.18965439e-01f, 1.96934417e-01f, -9.39901322e-02f, 3.75473276e-02f, 6.99050799e-02f, 1.54358983e-01f, 2.18894389e-02f, -4.37143743e-02f,
  4.41221893e-02f, 9.01709646e-02f, 5.06938845e-02f, 5.91330156e-02f, -7.11627863e-03f, 3.68595533e-02f, 2.88491230e-02f, -6.16483018e-02f, -5.58408722e-02f, -1.04620457e-01f,
  -4.80499044e-02f, -6.82208836e-02f, -3.59312966e-02f, 7.85419345e-02f, -8.34451616e-02f, 3.57240438e-02f, 6.38647079e-02f, 3.14356387e-02f, 5.01780845e-02f, 4.40090671e-02f,
  1.45847378e-02f, 6.74734563e-02f, -3.71291302e-02f, -1.04829900e-01f, -2.61189193e-02f, 2.84895599e-02f, 1.49097582e-02f, 1.12931412e-02f, -6.98793083e-02f, 2.71736737e-02f,
  4.01382931e-02f, -1.18423188e-02f, -6.33883625e-02f, -4.36222926e-02f, -7.36477450e-02f, -4.41760719e-02f, 3.13553922e-02f, -6.80303499e-02f, -9.28925574e-02f, 7.19932914e-02f,
  -6.63791224e-02f, -7.19316006e-02f, -2.37576943e-02f, -1.01173446e-02f, 2.75852345e-02f, -6.72821179e-02f, 3.37497145e-02f, -3.16828210e-03f, 2.35426016e-02f, -3.95920202e-02f,
  7.85392150e-02f, 2.49498114e-02f, -2.83360272e-03f, 7.14625791e-02f, -7.64910802e-02f, 3.74028012e-02f, 8.17114189e-02f, -7.94175118e-02f, -1.86342597e-02f, 6.36566058e-02f,
  3.44119929e-02f, -5.66001125e-02f, 5.37853651e-02f, 7.45174736e-02f, -1.83189400e-02f, -8.25004503e-02f, 1.67255457e-02f, -6.55277371e-02f, 8.10690224e-02f, -2.51333392e-03f,
  4.53520231e-02f, -6.57204092e-02f, 1.03775889e-01f, 6.66812807e-02f, 7.35628083e-02f, -6.95735142e-02f, 3.38923298e-02f, 7.23621994e-02f, 1.32452855e-02f, 1.48394257e-02f,
  -4.89908606e-02f, -6.46827295e-02f, 1.75003409e-02f, 3.53145078e-02f, -6.12746254e-02f, 4.37308587e-02f, 3.48300897e-02f, 1.62549485e-02f, 1.92715344e-03f, -9.02804583e-02f,
  -4.35687713e-02f, 3.96566838e-03f, 8.81453082e-02f, 2.53339726e-02f, 3.15982942e-03f, 8.05280805e-02f, 4.93123522e-03f, 7.20787048e-02f, -4.29745987e-02f, 1.09189227e-02f,
  2.81588491e-02f, -5.77326827e-02f, 1.21053122e-01f, 9.81365740e-02f, -4.38495502e-02f, -1.36744201e-01f, -9.59194750e-02f, 1.24627531e-01f, 9.14182886e-02f, -1.21417314e-01f,
  -1.28183719e-02f, 8.13484788e-02f, -6.04907311e-02f, -1.58683080e-02f, 1.14023186e-01f, -3.71638350e-02f, 1.22420274e-01f, -2.04036683e-02f, 9.63314399e-02f, 4.38332781e-02f,
  5.96548319e-02f, -1.63575634e-02f, 8.32286179e-02f, 3.69431227e-02f, 3.75896953e-02f, 1.07101716e-01f, -8.97707138e-03f, -9.33184549e-02f, 2.03807242e-02f, -8.93321726e-03f,
  -6.90506771e-02f, 7.44911358e-02f, -4.38958220e-02f, -9.64236110e-02f, -5.01243537e-03f, -9.65517983e-02f, -1.00654952e-01f, 5.39488010e-02f, 5.46077937e-02f, 6.81630149e-02f,
  -2.12796591e-03f, -5.51472865e-02f, -4.29442264e-02f, -1.75568704e-02f, 7.82123953e-02f, -1.82030797e-02f, 2.51347199e-02f, 4.09324504e-02f, -8.84048492e-02f, -3.40006091e-02f,
  -5.66385090e-02f, -4.42416705e-02f, -2.35931836e-02f, -8.08941759e-03f, 1.05432555e-01f, 4.85874191e-02f, 7.80761316e-02f, -7.17000514e-02f, 7.09303468e-02f, 5.12704998e-02f,
  -4.95631248e-02f, -3.47839594e-02f, 4.63640057e-02f, -5.72593622e-02f, 1.37747768e-02f, -7.31688784e-03f, -2.98799146e-02f, 7.65752494e-02f, -4.28011790e-02f, 7.38950595e-02f,
  8.89553726e-02f, 5.30550182e-02f, 2.30286364e-02f, 1.43191195e-04f, 1.31402779e-02f, 8.54402184e-02f, -3.35389860e-02f, 7.43517652e-02f, 1.11373151e-02f, -4.14261688e-03f,
  -7.93176740e-02f, -3.78074832e-02f, -3.14587280e-02f, -1.45893320e-02f, 9.75475553e-03f, -2.50043683e-02f, 4.90649007e-02f, 5.22996224e-02f, 8.25195573e-04f, 2.84998808e-02f,
  -5.14572412e-02f, 6.60065189e-02f, 7.39402324e-02f, -4.91664521e-02f, 4.87135574e-02f, 5.38667887e-02f, 5.72728589e-02f, -9.68637597e-03f, 3.76446173e-02f, 8.51269662e-02f,
  1.48133084e-03f, -5.00889421e-02f, -4.38544862e-02f, -9.00368020e-02f, -6.89184666e-02f, 9.86068696e-02f, 6.97871819e-02f, -4.55369800e-02f, -7.98046365e-02f, 1.29957236e-02f,
  1.91549957e-02f, -4.96032722e-02f, -6.43808022e-02f, -7.30367824e-02f, -8.70056171e-03f, 1.41023593e-02f, -4.11683396e-02f, -5.52675501e-02f, 2.92495321e-02f, 1.15994420e-02f,
  -2.31098220e-01f, -7.89644010e-03f, -2.12258831e-01f, -1.72766924e-01f, -1.72448590e-01f, -1.22213639e-01f, -1.61614433e-01f, -1.55098423e-01f, 5.69989532e-03f, 1.42637491e-01f,
  4.16316837e-03f, -1.00373864e-01f, 1.36853278e-01f, -1.08498402e-01f, -9.97351706e-02f, 1.23644039e-01f, -1.24354653e-01f, -3.84301245e-02f, -6.67476235e-03f, -2.07284182e-01f,
  -5.23254871e-02f, -4.74781208e-02f, -1.12418674e-01f, -1.20712087e-01f, -1.84066847e-01f, -1.71053074e-02f, 5.13143912e-02f, -1.68621600e-01f, 1.32882893e-02f, -5.35145849e-02f,
  -1.34139657e-01f, -8.19775313e-02f, -1.49784535e-01f, -2.40569599e-02f, -8.64322633e-02f, 1.33872600e-02f, -1.29877955e-01f, -3.32895517e-02f, -6.34897798e-02f, -9.24021825e-02f,
  1.43044498e-02f, -5.33273630e-02f, 5.01372106e-02f, 4.17743437e-02f, -2.86084581e-02f, 1.82654187e-02f, -1.63146742e-02f, 2.76911873e-02f, -8.09227303e-02f, -3.15923356e-02f,
  -1.26161531e-01f, -5.11837751e-02f, -5.67972567e-03f, 7.50320330e-02f, 3.53845283e-02f, 4.96984273e-02f, 9.34604276e-03f, -6.68515638e-02f, -1.04072141e-02f, -1.01618804e-01f,
  8.23836960e-03f, 9.69808642e-03f, -8.14767852e-02f, -4.55339849e-02f, 3.33124958e-02f, -5.20042107e-02f, -5.06715029e-02f, 1.11062661e-01f, 3.46894972e-02f, 4.27959859e-02f,
  -7.84283202e-06f, 3.43291909e-02f, -2.77017504e-02f, -2.64385082e-02f, 7.09661692e-02f, -5.31384200e-02f, 8.16232152e-03f, -7.41262883e-02f, 7.01142028e-02f, 6.73528388e-02f,
  -5.40076010e-02f, -8.02108832e-03f, -1.90171488e-02f, 5.34045510e-02f, 2.21113749e-02f, 1.65165588e-02f, -6.60380498e-02f, -4.27945219e-02f, 7.10660815e-02f, -3.33629362e-02f,
  -2.19522253e-01f, -1.53403103e-01f, -8.83330852e-02f, -4.42718193e-02f, -4.14093537e-03f, -7.37121180e-02f, 7.43927136e-02f, -3.18302028e-02f, -1.66218840e-02f, 1.55494753e-02f,
  -6.61161765e-02f, 3.90304327e-02f, -7.71721080e-02f, -2.23415438e-03f, 6.88682199e-02f, -2.14517172e-02f, 2.12157592e-02f, 4.84908931e-02f, -1.98031757e-02f, -1.35162985e-02f,
  -2.99249310e-02f, -1.95821263e-02f, 3.81027721e-02f, -1.21190958e-02f, 1.31696844e-02f, -2.99637672e-02f, -4.95770499e-02f, 3.67885008e-02f, -2.25860178e-02f, 5.70542738e-02f,
  -6.06850795e-02f, -8.46597999e-02f, -6.24038726e-02f, 2.96470877e-02f, -1.50471210e-01f, -6.41551241e-02f, -9.32879075e-02f, -8.65913704e-02f, 7.13242963e-02f, 9.66958608e-03f,
  -1.00897983e-01f, -3.28862295e-02f, 5.00297584e-02f, 1.02866478e-01f, -8.12672600e-02f, 8.67076367e-02f, 5.71111329e-02f, 3.20865139e-02f, 2.39117667e-02f, -1.02763467e-01f,
  8.21718574e-02f, 8.64586830e-02f, 1.12275422e-01f, -4.77521978e-02f, 1.16856424e-02f, 4.67370786e-02f, 8.03551227e-02f, -3.64733413e-02f, 2.76365355e-02f, 8.56138617e-02f,
  -1.35773616e-02f, 1.05956933e-02f, -2.08420772e-02f, -7.33753964e-02f, -4.08536233e-02f, 3.29098031e-02f, -3.22467461e-03f, 2.04905588e-02f, -7.10687414e-02f, 6.08339608e-02f,
  6.73632771e-02f, 3.44215371e-02f, 6.25424683e-02f, -5.17736450e-02f, 4.42813896e-02f, -7.93543831e-02f, -8.18676651e-02f, -5.12187928e-02f, 7.69342035e-02f, -5.34526957e-03f,
  2.50536017e-02f, 2.33542267e-02f, -1.53173867e-03f, 8.23404565e-02f, 6.83526546e-02f, -6.17481694e-02f, 2.63881199e-02f, 8.40780139e-02f, 1.54802585e-02f, 1.65046956e-02f,
  1.57670155e-02f, 6.35452121e-02f, 6.36388212e-02f, 9.48843360e-02f, 4.43199873e-02f, 8.11907873e-02f, -7.78990909e-02f, 7.97829404e-02f, 5.53054102e-02f, 1.21851275e-02f,
  5.16660400e-02f, -1.59594733e-02f, -6.39617220e-02f, -5.88069223e-02f, 1.08283595e-03f, 7.97280744e-02f, -2.16274094e-02f, -4.87057753e-02f, 1.85941369e-03f, -6.58616200e-02f,
  -5.70106134e-02f, -7.80624077e-02f, 7.72804916e-02f, 6.77356869e-02f, 5.42809144e-02f, 4.89534326e-02f, 1.36810513e-02f, 5.50860092e-02f, -6.11606054e-02f, -7.39865899e-02f,
  2.18362492e-02f, -6.75094649e-02f, 1.05782403e-02f, 5.67817129e-02f, 2.73215454e-02f, 4.53942344e-02f, 1.15860617e-02f, -1.02272183e-01f, 3.30194682e-02f, -9.05686989e-02f,
  3.56569514e-03f, 9.70256701e-02f, -1.98020712e-02f, -2.59521212e-02f, 9.46773216e-02f, 3.47833298e-02f, -2.30706893e-02f, 8.82014111e-02f, 2.43575126e-02f, 8.30998495e-02f,
  6.92928284e-02f, 4.22094315e-02f, 7.03913951e-03f, 4.42823097e-02f, 2.35292707e-02f, 6.15246892e-02f, 3.16089503e-02f, 3.28741409e-02f, 7.16352370e-03f, 1.41018117e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.05623856e-01f, 4.68027927e-02f, 2.29007769e-02f, 1.23014115e-01f, 7.87675083e-02f, -3.57771968e-03f, 8.82045832e-03f, 3.60258147e-02f, -7.15217963e-02f, -8.45129043e-03f,
  9.84210521e-02f, 5.78022078e-02f, 7.44304433e-02f, 3.16374637e-02f, 4.51751910e-02f, 5.04648946e-02f, 7.82158226e-02f, 1.54384241e-01f, 5.22504598e-02f, 7.67275244e-02f,
  4.06393893e-02f, 1.72413677e-01f, 7.61507601e-02f, -1.37335267e-02f, 6.96557760e-02f, -1.33667625e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -6.99545965e-02f, 1.91801954e-02f, 7.18008056e-02f, -8.26307386e-02f, -1.69086769e-01f, 1.70487426e-02f, 1.04072347e-01f, 9.60983336e-02f, -4.78567071e-02f, 2.43436564e-02f,
  -6.42280057e-02f, -1.62403043e-02f, 1.05614781e-01f, 7.05334097e-02f, -6.76036626e-02f, -1.04909673e-01f, -7.88287446e-03f, 8.48812684e-02f, -4.50975895e-02f, -9.35724378e-02f,
  1.07181400e-01f, -2.12122779e-02f, 1.89262014e-02f, 2.01652631e-01f, 2.05601864e-02f, -9.65196174e-03f, -4.37343419e-02f, -4.01859693e-02f, -4.56210561e-02f, -2.52123475e-01f,
  1.79786921e-01f, 1.45876710e-03f, 1.12218194e-01f, -1.19601376e-02f, 1.21025108e-01f, -1.51002750e-01f, -1.38264168e-02f, 3.33469324e-02f, -8.72684121e-02f, 2.29431555e-01f,
  -9.50771421e-02f, -8.16065446e-02f, -3.37547250e-02f, 2.13280901e-01f, -1.17212400e-01f, 1.05670601e-01f, 1.21186497e-02f, -9.12712887e-02f, -9.88049358e-02f, 1.34768039e-01f,
  1.32316247e-01f, -1.08232461e-01f, -4.81168665e-02f, 8.68833363e-02f, 7.28499815e-02f, -1.07175276e-01f, 4.62316684e-02f, -1.25209883e-01f, -2.47076862e-02f, -2.38319747e-02f,
  9.69291031e-02f, -4.31064069e-02f, 1.31914482e-01f, 6.15076674e-03f, 1.88002065e-02f, -1.91504527e-02f, -1.07626446e-01f, 9.32348743e-02f, 3.18461239e-01f, -5.77804968e-02f,
  -1.54911712e-01f, -4.62660864e-02f, -3.71875167e-02f, -3.74504328e-02f, 4.46509048e-02f, 3.26949991e-02f, 4.10606228e-02f, -6.79986328e-02f, 1.62797004e-01f, -1.54334813e-01f,
  1.23429030e-01f, -8.38677660e-02f, 1.00651152e-01f, 9.44646448e-03f, -7.41536245e-02f, -1.29782096e-01f, -2.39338025e-01f, -1.55866221e-01f, -3.46772045e-01f, -1.54708892e-01f,
  1.11409724e-01f, 2.99261250e-02f, -9.08400640e-02f, 1.75119862e-01f, -1.26629427e-01f, -1.99565858e-01f, -3.28998826e-02f, 7.65355825e-02f, -9.80814621e-02f, 1.26876727e-01f,
  -1.53019294e-01f, 1.54657230e-01f, -1.01605058e-01f, -1.80829331e-01f, -9.43691880e-02f, 1.91887334e-01f, -1.45162120e-01f, -1.87872931e-01f, -8.19610134e-02f, 9.14143864e-03f,
  -2.27744933e-02f, -2.46467758e-02f, 2.34881237e-01f, -8.61043185e-02f, -1.67632177e-01f, -1.01628542e-01f, 6.04365431e-02f, 1.72612458e-01f, -1.12771004e-01f, -8.97997804e-03f,
  -9.86288767e-03f, -1.25474706e-01f, 1.39498994e-01f, -1.39148682e-01f, -3.29061970e-02f, 8.96047056e-03f, -2.06295073e-01f, 1.03428163e-01f, -1.02365706e-02f, 1.30708311e-02f,
  1.33868484e-02f, 4.48931642e-02f, 2.35973760e-01f, -5.86837716e-02f, 1.72753893e-02f, 4.23127115e-02f, -3.12237460e-02f, -6.57609925e-02f, 3.74075212e-02f, -6.36743149e-03f,
  1.18739940e-01f, -2.37200871e-01f, 2.06292216e-02f, -2.11941734e-01f, -1.44815624e-01f, -1.58353616e-03f, -2.84488909e-02f, -2.22044051e-01f, -1.25583932e-01f, -1.40406817e-01f,
  1.53156832e-01f, -2.19058946e-01f, 2.23184541e-01f, -1.02235578e-01f, -1.55342743e-01f, 4.75483984e-02f, 1.83180332e-01f, 2.94607222e-01f, 1.06728636e-02f, 7.39203393e-02f,
  2.00730637e-01f, 2.64109462e-01f, -2.34604791e-01f, -7.78553411e-02f, -2.93947794e-02f, 1.79939166e-01f, -1.48534015e-01f, 1.72099452e-02f, -6.15606010e-02f, 7.93913305e-02f,
  -4.42633927e-02f, 1.68575600e-01f, 1.38809800e-01f, -1.42787963e-01f, 9.85626504e-02f, 1.34340584e-01f, -1.99893359e-02f, 1.13816068e-01f, 1.88628100e-02f, -1.81460008e-01f,
  1.21211866e-02f, 1.91324651e-01f, 1.10506766e-01f, -1.08851843e-01f, 1.19453274e-01f, -1.54838786e-01f, 1.65216744e-01f, -4.64367159e-02f, -5.38079739e-02f, -3.44054140e-02f,
  -2.70491708e-02f, -8.58308449e-02f, -3.85890789e-02f, 3.66974846e-02f, -1.17995262e-01f, 1.10549748e-01f, -4.29999940e-02f, -9.26112533e-02f, -1.72484577e-01f, -5.53522892e-02f,
  -9.11754966e-02f, -4.11493480e-02f, 1.44324064e-01f, 9.39143728e-03f, -1.35682404e-01f, 6.77379146e-02f, -1.28601771e-02f, -9.90804657e-02f, -3.92540097e-02f, -9.20141786e-02f,
  1.12600446e-01f, -7.61156678e-02f, -1.78711131e-01f, 4.02015261e-02f, 5.39003464e-04f, -2.99172401e-01f, 9.13369134e-02f, -9.37834010e-02f, 9.20428634e-02f, 2.48791903e-01f,
  4.33854340e-03f, 1.98180348e-01f, 7.08285049e-02f, -1.27820671e-01f, 8.19578916e-02f, 7.68770278e-02f, -1.28919855e-01f, 2.22719833e-01f, 1.86298788e-02f, -8.87847841e-02f,
  4.18050885e-02f, -3.69204767e-02f, 9.95150357e-02f, -1.01508096e-01f, 1.12424530e-02f, -1.30123049e-01f, 1.30290717e-01f, -3.57915647e-02f, 2.69847494e-02f, 1.18700631e-01f,
  -8.73941630e-02f, -7.37050250e-02f, -8.54612216e-02f, 9.29088369e-02f, 1.05115369e-01f, 1.43133193e-01f, -1.26443624e-01f, 1.73067212e-01f, 1.14308447e-01f, -5.66270463e-02f,
  1.42738909e-01f, 3.32161877e-03f, -1.57540262e-01f, 4.17638719e-02f, -1.52941629e-01f, -3.25851031e-02f, -1.19936004e-01f, -9.17798579e-02f, -1.30419418e-01f, -1.15859546e-01f,
  -1.96957529e-01f, 1.14146948e-01f, -1.71904325e-01f, -5.62512176e-03f, -1.47687316e-01f, -5.41809611e-02f, 3.33447121e-02f, -6.96743131e-02f, 5.10248393e-02f, -9.75376070e-02f,
  -1.28846243e-01f, -1.40945241e-01f, -1.33118078e-01f, 2.24214271e-02f, -1.24776319e-01f, -3.13018680e-01f, -1.99792266e-01f, 1.33405507e-01f, 5.08358479e-02f, 2.04223441e-03f,
  1.96486279e-01f, -1.89787909e-01f, -2.42485240e-01f, 1.23892322e-01f, -2.31421709e-01f, 3.96726094e-02f, 5.62735423e-02f, 8.77758190e-02f, -6.06530085e-02f, -1.13607936e-01f,
  -1.97089743e-03f, 5.53813353e-02f, 1.65077090e-01f, 1.69986814e-01f, 1.12393767e-01f, -7.54333958e-02f, -1.51571808e-02f, 3.83157246e-02f, 9.26130041e-02f, -5.51045574e-02f,
  4.41517234e-02f, -1.89410113e-02f, -9.37297270e-02f, -5.46155944e-02f, 9.89975482e-02f, -1.02305241e-01f, -1.38313234e-01f, 1.06444843e-01f, -1.53291121e-01f, 2.18129605e-01f,
  -6.54418319e-02f, 3.89117487e-02f, 8.91759545e-02f, 2.42058843e-01f, 1.16005696e-01f, 6.66365027e-02f, 1.03064947e-01f, -2.57034749e-02f, -9.47536826e-02f, 8.13051462e-02f,
  -6.55279383e-02f, 1.90351456e-02f, 4.65368517e-02f, 7.52543733e-02f, -2.22905371e-02f, 3.75861786e-02f, -1.55549958e-01f, -5.05017973e-02f, -4.76558097e-02f, 1.42064482e-01f,
  1.06434219e-01f, -1.15964608e-02f, 1.01011731e-01f, -2.20695138e-01f, -9.38836709e-02f, -1.99251056e-01f, 1.00106522e-01f, 1.36946747e-02f, 2.92355232e-02f, -3.13595623e-01f,
  -1.16731092e-01f, -1.19564183e-01f, -2.60556117e-02f, -1.31372854e-01f, 8.47785771e-02f, -1.16181701e-01f, -2.00182393e-01f, 9.13840532e-02f, -1.21723808e-01f, -1.07247137e-01f,
  1.50692657e-01f, -6.95167109e-02f, 2.50904769e-01f, 3.84917855e-02f, -6.13286979e-02f, 7.91213885e-02f, 2.78822839e-01f, 2.99509078e-01f, -7.36519247e-02f, 1.32636964e-01f,
  -9.01940763e-02f, 6.32127672e-02f, -1.12186596e-01f, 8.58558863e-02f, 1.29311785e-01f, -6.75382912e-02f, 5.01184538e-02f, 7.16772974e-02f, -6.23899661e-02f, 3.67988683e-02f,
  4.31714952e-02f, -1.46363363e-01f, 7.35022202e-02f, 2.28118122e-01f, -1.54910758e-01f, -2.14853033e-01f, -3.59903201e-02f, 1.18137144e-01f, 1.69986710e-01f, -1.52062057e-02f,
  2.47006100e-02f, -1.76139772e-01f, 1.60852075e-01f, -1.06042802e-01f, -7.99796507e-02f, -7.55718574e-02f, 4.91407104e-02f, 5.86957112e-02f, -2.51336664e-01f, -1.08235367e-01f,
  4.53944020e-02f, 3.96230109e-02f, -1.96994897e-02f, -2.86488682e-02f, -8.27956870e-02f, -1.50409907e-01f, 4.15417925e-02f, -3.11103202e-02f, -6.54524565e-02f, 1.56765446e-01f,
  -2.15355810e-02f, -9.22709852e-02f, -8.87970328e-02f, 2.02235371e-01f, 2.51036376e-01f, 8.64479095e-02f, -5.70087433e-02f, -4.75601181e-02f, -1.05220610e-02f, 1.42193481e-01f,
  6.04310036e-02f, 3.76963615e-03f, 1.94630638e-01f, -1.30959898e-01f, 5.99334128e-02f, 1.54846758e-01f, 9.42922849e-03f, 1.90714285e-01f, 6.00775741e-02f, 1.20878108e-02f,
  -1.33503929e-01f, -1.85444534e-01f, -1.94060221e-01f, 7.67520666e-02f, -4.84393500e-02f, -1.25289664e-01f, 1.03644617e-01f, 1.30931631e-01f, 3.74421962e-02f, 8.08293466e-03f,
  -7.25950822e-02f, -1.37941062e-01f, -1.09908648e-01f, 1.31281182e-01f, 9.17464271e-02f, -9.56831202e-02f, 1.58108741e-01f, -2.10219070e-01f, -3.26432288e-02f, 2.16146246e-01f,
  4.38467041e-02f, -1.44179091e-01f, 5.01998886e-02f, 6.98254183e-02f, 1.20808735e-01f, -6.94193915e-02f, 2.42952168e-01f, 1.84267953e-01f, -9.64214467e-03f, 8.56924395e-04f,
  -9.03446879e-03f, 1.20326005e-01f, -7.70705268e-02f, 1.46967188e-01f, -1.03415899e-01f, 1.14853121e-01f, 3.99679989e-02f, 3.49549018e-02f, -1.46591946e-01f, 6.88514188e-02f,
  -1.30619869e-01f, 2.03056559e-01f, 1.38780892e-01f, 1.37052864e-01f, -6.00772761e-02f, 1.23506896e-01f, -1.21329203e-01f, -6.59183040e-02f, 1.54984757e-01f, -7.05781430e-02f,
  -1.41224176e-01f, 1.30438015e-01f, 5.96940145e-02f, -2.10065097e-01f, 1.84209365e-02f, 1.16849765e-01f, -8.37597623e-02f, -2.94611961e-01f, 3.06876246e-02f, 2.41932403e-02f,
  -1.83147714e-01f, 5.34900911e-02f, 2.72973597e-01f, 2.81702638e-01f, 1.29036888e-01f, -6.95258602e-02f, 1.22117689e-02f, 1.33731693e-01f, -1.29750356e-01f, 1.02141783e-01f,
  -3.35518569e-02f, 2.89461967e-02f, 1.23822264e-01f, -2.14017168e-01f, 4.92345504e-02f, 1.51814193e-01f, -1.67672196e-03f, 1.62473604e-01f, -6.74759671e-02f, -1.12542890e-01f,
  -4.60024811e-02f, 1.87678829e-01f, -1.04453348e-01f, -5.61336093e-02f, -1.04659528e-01f, 1.84602514e-01f, 8.14921632e-02f, -1.26034334e-01f, 3.29092257e-02f, -1.16269723e-01f,
  8.85355175e-02f, -6.97100013e-02f, 5.60878590e-02f, -2.97261775e-02f, 7.08701387e-02f, 6.25758767e-02f, 2.52302378e-01f, 7.19379410e-02f, 1.25978768e-01f, 6.13330156e-02f,
  9.71624553e-02f, -3.89245041e-02f, 4.83719446e-02f, 3.26030888e-02f, 1.71028584e-01f, 5.47975190e-02f, 1.61138996e-01f, -2.51611602e-02f, -2.95183118e-02f, -1.10521428e-01f,
  6.63276762e-02f, -3.93118383e-03f, 9.47998613e-02f, -1.08522616e-01f, 2.05704212e-01f, 2.89326198e-02f, -1.39423430e-01f, -1.33532688e-01f, -4.66216868e-03f, 2.68148705e-02f,
  1.20182730e-01f, 2.44558956e-02f, -1.27062187e-01f, -1.66046828e-01f, -6.86307177e-02f, 9.52279642e-02f, -5.34799285e-02f, -1.30933225e-01f, 1.35809645e-01f, 1.62841603e-01f,
  -5.32520711e-02f, 8.78651440e-02f, -1.40577599e-01f, -4.40034047e-02f, 9.61637497e-02f, -7.40853697e-02f, 5.26859686e-02f, -4.27700132e-02f, -2.97985617e-02f, -1.16970547e-01f,
  -1.14052892e-01f, -3.76902856e-02f, 5.37077477e-03f, -1.38846397e-01f, -1.50546491e-01f, -1.93091054e-02f, -1.11009069e-01f, -2.00345010e-01f, 1.13417529e-01f, 7.78859947e-03f,
  -6.66847825e-02f, -4.08965768e-03f, 4.60921191e-02f, -6.47271946e-02f, 2.42068321e-02f, -1.04136266e-01f, -1.85303375e-01f, 2.54051518e-02f, -1.60346940e-01f, 7.79876709e-02f,
  -4.53781057e-03f, -6.06006682e-02f, -1.29772708e-01f, -1.07340105e-01f, 5.73869161e-02f, -1.36543915e-01f, 9.19698849e-02f, -3.18399407e-02f, 8.41385797e-02f, -2.55111963e-01f,
  -1.56134471e-01f, -1.80057019e-01f, -6.21506087e-02f, 5.05469460e-03f, -1.64960772e-01f, 1.24426708e-01f, -1.48184225e-01f, 1.65818065e-01f, -2.05255881e-01f, -2.48431072e-01f,
  2.11307615e-01f, 2.95747638e-01f, -6.96598887e-02f, -6.37332574e-02f, -9.96759906e-03f, 1.35762185e-01f, -1.60823390e-02f, 8.15495774e-02f, 1.35121882e-01f, 1.72985107e-01f,
  -1.05457351e-01f, 1.67239327e-02f, -1.15293264e-02f, 1.28431767e-01f, -2.09394153e-02f, -1.11070700e-01f, 1.13420449e-02f, 1.02627911e-02f, 9.07334164e-02f, 4.52524610e-02f,
  -1.22143790e-01f, 7.89586604e-02f, 8.00544322e-02f, -5.91179319e-02f, 8.48165248e-03f, -6.86317086e-02f, -1.65944491e-02f, -9.58874896e-02f, 1.01084568e-01f, 1.29388452e-01f,
  2.45036911e-02f, 1.34128809e-01f, -1.28374733e-02f, 9.15931724e-03f, -2.77120974e-02f, 5.92735112e-02f, -1.26983926e-01f, 9.33397710e-02f, -5.44414893e-02f, -3.17400284e-02f,
  1.07235998e-01f, 1.31473288e-01f, -6.78072274e-02f, -7.81957619e-03f, -1.96745455e-01f, 5.79492934e-02f, 1.74086586e-01f, 1.11465670e-01f, 1.26479790e-01f, -2.13228762e-02f,
  3.05963622e-05f, 7.30303526e-02f, 1.41199619e-01f, -1.85547069e-01f, -1.30384453e-02f, 1.48564773e-02f, 6.67721778e-02f, 8.25433508e-02f, 1.09550126e-01f, -2.67694652e-01f,
  -4.84975353e-02f, -4.18231450e-02f, 2.22735822e-01f, 1.67305960e-04f, 2.38996476e-01f, -2.07757838e-02f, -3.34365278e-01f, -1.02880694e-01f, -7.09339976e-02f, -1.68309852e-01f,
  9.51912440e-03f, 5.31777367e-02f, 5.27371792e-03f, -1.22256771e-01f, -8.16271454e-02f, -2.21280321e-01f, 1.53202057e-01f, 2.38566950e-01f, 7.61782452e-02f, 1.85410306e-01f,
  3.35035510e-02f, -1.39894947e-01f, 8.36671963e-02f, 7.69798458e-02f, 5.09209484e-02f, -5.26997354e-03f, 1.48472607e-01f, 4.08301987e-02f, -1.38294339e-01f, 4.39783558e-02f,
  -1.00257076e-01f, 2.11771578e-03f, -1.29989967e-01f, -1.31961867e-01f, 9.89272967e-02f, -8.26522335e-02f, 5.28920069e-02f, 1.29831180e-01f, 6.62064506e-03f, 1.04846217e-01f,
  4.95638251e-02f, -4.36771028e-02f, -5.44330068e-02f, 6.66947886e-02f, -2.24275030e-02f, -9.61984843e-02f, -1.98933762e-02f, -1.45799696e-01f, -1.08208120e-01f, 4.08494361e-02f,
  1.02843396e-01f, 4.75895442e-02f, -1.17900237e-01f, -8.24350938e-02f, 8.84316340e-02f, 3.46956402e-02f, -9.12259333e-03f, 2.25199878e-01f, -1.32993624e-01f, 2.17990696e-01f,
  5.66866845e-02f, 6.04682267e-02f, -8.97010267e-02f, 1.50034517e-01f, 2.92652786e-01f, -1.29259333e-01f, -4.00455631e-02f, 9.66696292e-02f, -2.06935909e-02f, -4.06354517e-02f,
  -4.51672822e-02f, 3.48167075e-03f, 4.55386117e-02f, -2.30788067e-01f, 1.53952911e-01f, -1.66600898e-01f, -1.23902507e-01f, 2.44113281e-01f, 2.29681581e-01f, -4.88321781e-02f,
  -1.47489682e-01f, -2.15653345e-01f, -2.37272546e-01f, 8.76851287e-03f, -1.51842952e-01f, 1.52535349e-01f, -5.94873913e-03f, 1.49934247e-01f, 7.97816813e-02f, 1.03271216e-01f,
  1.02858126e-01f, -1.24498993e-01f, -1.46759167e-01f, -1.02272868e-01f, 1.37406796e-01f, -9.47203487e-02f, 1.99672714e-01f, -1.52778089e-01f, -2.75217872e-02f, -5.56604676e-02f,
  1.51011767e-02f, -3.00265606e-02f, -2.12156889e-03f, -2.22685598e-02f, -1.25348210e-01f, -1.85274675e-01f, 8.87820274e-02f, -3.86562720e-02f, -8.81591439e-03f, -1.06056571e-01f,
  4.30900455e-02f, -1.58596501e-01f, 1.65417016e-01f, 7.79660419e-02f, -3.42209116e-02f, -1.41768858e-01f, 1.05988599e-01f, -6.58373609e-02f, -1.60563722e-01f, 4.72692773e-02f,
  1.33431535e-02f, 1.23586208e-01f, -3.55511829e-02f, 8.16736221e-02f, 1.67158529e-01f, 3.28952372e-02f, 7.33985286e-03f, 1.51844874e-01f, -1.19093517e-02f, -4.77267765e-02f,
  3.81708033e-02f, 2.83362627e-01f, -2.74444222e-01f, -3.58345062e-02f, 2.71279007e-01f, -1.50478289e-01f, 1.49807124e-03f, -7.83551708e-02f, -6.06379434e-02f, -1.34203061e-01f,
  -5.68911107e-03f, 9.66674611e-02f, 1.76332861e-01f, -1.16612032e-01f, -1.19501270e-01f, -1.67803004e-01f, -7.30829537e-02f, -1.29449680e-01f, -8.00593644e-02f, 9.04061049e-02f,
  9.73622128e-03f, -2.10733861e-01f, -1.02125704e-01f, 1.55755684e-01f, 8.34745839e-02f, 1.12163574e-01f, 1.08221784e-01f, 1.59268584e-02f, 1.32231815e-02f, -6.78358003e-02f,
  5.76456226e-02f, -1.39795691e-01f, -3.49214710e-02f, 2.74845362e-02f, -1.20590717e-01f, -2.51906924e-03f, 5.59595898e-02f, -2.16037959e-01f, -9.39863846e-02f, -8.50450769e-02f,
  -1.33452579e-01f, -1.13258153e-01f, 4.27757651e-02f, 2.24032640e-01f, -9.97759923e-02f, -9.44811553e-02f, -2.06065178e-02f, 2.31289119e-02f, 5.37539460e-02f, 1.43991232e-01f,
  7.70551935e-02f, -2.10264027e-02f, -6.16787747e-02f, 1.52390853e-01f, 8.60048234e-02f, -1.28620863e-01f, -8.50274414e-03f, -6.68074042e-02f, -8.65644366e-02f, 1.92666929e-02f,
  -4.07801196e-02f, 6.68630004e-02f, -1.04026705e-01f, -1.27375508e-02f, 3.07847708e-01f, 3.75341214e-02f, -8.95544048e-03f, 3.02952658e-02f, -1.33377407e-02f, -1.10985085e-01f,
  3.95405153e-03f, 5.93775064e-02f, -2.07559407e-01f, -1.15390584e-01f, 1.89335886e-02f, -1.24968909e-01f, -1.96319297e-01f, -8.46738815e-02f, -3.18687484e-02f, 6.65766820e-02f,
  2.81450227e-02f, -8.06073248e-02f, 5.60110435e-02f, -2.51004323e-02f, -9.43424404e-02f, -5.36655933e-02f, -4.62958701e-02f, 1.66836739e-01f, -1.02423113e-02f, -1.06835037e-01f,
  -1.05643503e-01f, -1.45103246e-01f, 4.23259772e-02f, 1.03246324e-01f, -1.44070029e-01f, -4.55809906e-02f, 1.57546148e-01f, 6.72910456e-03f, 7.85481259e-02f, -4.97208685e-02f,
  -9.69690159e-02f, -6.44966066e-02f, -9.84337330e-02f, 9.41199213e-02f, -3.89771163e-02f, -8.29944983e-02f, 4.52456139e-02f, -9.82394256e-03f, 1.12414330e-01f, 1.77411959e-02f,
  1.59363732e-01f, -5.10123596e-02f, 1.34165213e-01f, -9.75263938e-02f, -1.08775392e-01f, -7.65568540e-02f, -4.84200707e-03f, 6.52454719e-02f, 2.58484315e-02f, -1.15448572e-01f,
  -3.11110150e-02f, -9.87075269e-02f, -9.65483114e-02f, 6.07167147e-02f, -7.52777830e-02f, -1.03632910e-02f, -9.33821648e-02f, 2.82686786e-03f, -1.73284978e-01f, -1.29155591e-01f,
  -5.15131392e-02f, 4.87589538e-02f, 7.59333000e-02f, 5.73997609e-02f, 9.17567387e-02f, 3.42025682e-02f, -7.69305527e-02f, 1.77601621e-01f, 1.06553279e-01f, -8.30511302e-02f,
  -1.68558463e-01f, -1.44910991e-01f, -1.52059317e-01f, -1.40912279e-01f, -3.97997834e-02f, -1.49706379e-01f, -9.10779312e-02f, -1.85076296e-02f, 1.16377912e-01f, 3.05822818e-03f,
  -7.18257129e-02f, -1.93323139e-02f, 7.31278881e-02f, -9.26713347e-02f, 1.18080184e-01f, -5.10306992e-02f, 1.30769238e-01f, 1.71008170e-01f, -9.90585191e-04f, -6.07984839e-03f,
  1.35894373e-01f, 1.09814681e-01f, -5.26338443e-02f, -4.52761054e-02f, -8.22432935e-02f, 1.76005840e-01f, -1.24051772e-01f, -4.35404107e-02f, 6.61755651e-02f, 8.20913911e-02f,
  2.42238864e-02f, -3.95166427e-02f, -1.55344427e-01f, 1.04427546e-01f, 2.42265701e-01f, -2.06905171e-01f, 5.44995219e-02f, -9.71811730e-03f, -1.17739908e-01f, 7.78533965e-02f,
  1.35121690e-02f, -3.45106572e-02f, 8.53408128e-02f, -1.44388795e-01f, -1.19777903e-01f, 1.62567981e-02f, 5.51113077e-02f, 8.23081210e-02f, 1.42403990e-01f, -1.44818321e-01f,
  -3.03860396e-01f, 1.14215631e-02f, -3.22380140e-02f, -2.03033984e-01f, 1.15236901e-01f, -1.01458852e-03f, -2.62450203e-02f, 4.68187034e-02f, -8.12262595e-02f, 3.49499881e-01f,
  -2.55438775e-01f, 1.12031326e-01f, 1.65223181e-02f, 1.51159735e-02f, -6.13153651e-02f, 4.05039936e-02f, -5.07803448e-02f, -1.15601951e-02f, 1.88911617e-01f, 2.41946522e-02f,
  3.05261835e-02f, -1.07779555e-01f, -1.07234623e-02f, -8.11400115e-02f, -3.71514559e-02f, -2.60494221e-02f, -1.31697416e-01f, -4.67025153e-02f, 1.20023206e-01f, -2.07734555e-02f,
  -1.49230316e-01f, 1.23550601e-01f, -1.01968274e-01f, 9.30045545e-02f, -6.36210516e-02f, -2.61391643e-02f, -4.56993096e-02f, -1.66202448e-02f, -2.54423451e-02f, 1.57182381e-01f,
  6.37483969e-02f, 1.03822589e-01f, -2.08967298e-01f, -1.00582406e-01f, 1.16348736e-01f, 2.01473534e-01f, -1.04439758e-01f, -4.02630121e-02f, 4.50623930e-01f, -9.66408029e-02f,
  4.74871360e-02f, -1.09879121e-01f, -6.96867192e-03f, -1.28372207e-01f, 1.29969835e-01f, 1.48987677e-02f, 1.23731166e-01f, -8.73309821e-02f, 1.81409344e-01f, -8.88644010e-02f,
  8.62575918e-02f, -3.41528468e-02f, 4.93907221e-02f, 1.54299796e-01f, 4.65377755e-02f, -4.54359464e-02f, 3.79993543e-02f, 1.88319355e-01f, -2.10995540e-01f, 9.96576473e-02f,
  1.51431769e-01f, -2.65710473e-01f, 2.08886132e-01f, 2.81211674e-01f, -1.51255503e-01f, 4.45677526e-02f, 2.02294916e-01f, 1.88709766e-01f, -6.10441640e-02f, -9.79636461e-02f,
  -2.38949573e-03f, 9.96713862e-02f, -2.24737287e-01f, -1.79502919e-01f, 7.24645332e-02f, -4.66095097e-02f, -2.66603157e-02f, -3.38404328e-02f, -8.08417723e-02f, 1.12234168e-01f,
  -3.21435593e-02f, 1.25936316e-02f, 9.89084020e-02f, -3.83982100e-02f, 1.43234968e-01f, -1.39504880e-01f, -1.38156340e-01f, 1.07152790e-01f, 1.89381521e-02f, -1.56990305e-01f,
  5.74557036e-02f, -1.83680251e-01f, 1.22762382e-01f, 5.29844761e-02f, 3.89577448e-02f, -7.31498450e-02f, -2.03203082e-01f, 1.71514750e-02f, -4.45741341e-02f, -1.84845477e-01f,
  -1.28291994e-01f, -2.33748294e-02f, -1.09906957e-01f, 7.00650513e-02f, -3.88596626e-03f, -2.78013572e-02f, -6.10490181e-02f, -9.80797336e-02f, -4.64485725e-03f, -1.76367134e-01f,
  3.33845317e-02f, 2.16817651e-02f, 6.46358216e-03f, 1.22718342e-01f, 4.22196575e-02f, 1.28529137e-02f, -1.09965049e-01f, 1.43407181e-01f, 1.38750806e-01f, 5.31080961e-02f,
  -2.03243345e-01f, 1.12891987e-01f, -7.12421983e-02f, -3.80327441e-02f, 1.71320513e-01f, -1.33345285e-02f, -9.00438204e-02f, -2.01442149e-02f, 1.87848791e-01f, 2.05799088e-01f,
  1.11374907e-01f, -8.85726213e-02f, 3.87874879e-02f, 1.36738107e-01f, -7.72524402e-02f, -5.49536315e-04f, -5.16448356e-02f, 7.75396377e-02f, 3.39545719e-02f, -1.14780620e-01f,
  -6.48129135e-02f, -1.12436838e-01f, -9.37723666e-02f, 4.30001169e-02f, -9.34099481e-02f, 6.68628663e-02f, 8.25579911e-02f, 7.97909200e-02f, 4.20023650e-02f, 1.03673890e-01f,
  3.76861989e-02f, 1.17692903e-01f, 9.91458744e-02f, 1.73627257e-01f, -2.71127149e-02f, 7.94220865e-02f, -6.17628917e-02f, -8.57214034e-02f, -3.02487016e-02f, -7.94570968e-02f,
  1.52933970e-01f, 1.58922464e-01f, -4.11340669e-02f, 7.24586993e-02f, 9.10465941e-02f, -1.04573570e-01f, -7.26528764e-02f, -6.27049804e-02f, -1.40379280e-01f, -4.00404483e-02f,
  1.27159759e-01f, -1.02669960e-02f, -1.51671842e-01f, 2.20066682e-02f, 1.66031495e-01f, 2.23258555e-01f, 1.25655353e-01f, 3.72767746e-02f, 1.47666037e-01f, -5.20392023e-02f,
  6.98607117e-02f, 1.88894551e-02f, 2.00756922e-01f, -2.47041985e-01f, 3.09268981e-01f, 1.55123144e-01f, -7.47521147e-02f, -2.73598224e-01f, -1.37291282e-01f, -1.24373302e-01f,
  -1.14519764e-02f, -2.12547615e-01f, 7.41945058e-02f, -2.21870959e-01f, -3.55924189e-01f, 1.71389394e-02f, 1.87674403e-01f, 5.36039751e-03f, 3.12851705e-02f, 3.84992063e-02f,
  -7.62237534e-02f, -4.09419462e-02f, -1.84241548e-01f, 2.36582428e-01f, 7.50487745e-02f, -8.87390748e-02f, 1.24015115e-01f, 8.90005901e-02f, 2.12281346e-02f, 7.43205920e-02f,
  4.09819372e-03f, 1.16461873e-01f, -1.48809133e-02f, -1.24400929e-02f, -2.29253843e-02f, 7.51663297e-02f, -1.71929449e-02f, -2.42519870e-01f, -5.20297606e-03f, 1.33754492e-01f,
  -6.14288300e-02f, -1.95224643e-01f, 6.22941889e-02f, -1.06102210e-02f, -1.56221792e-01f, 2.30905637e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.44079728e-02f, -9.44673195e-02f, 1.04109265e-01f, 1.56934038e-01f, 1.42094746e-01f, 3.42910662e-02f, 6.30341917e-02f, 2.56498195e-02f, 1.89345405e-01f, 1.61609471e-01f,
  -1.10885598e-01f, 5.40481135e-02f, 1.48301989e-01f, -2.09153518e-01f, 1.63174853e-01f, -1.48579329e-01f, 1.09496646e-01f, -3.03272344e-02f, 1.44342631e-01f, -1.77526191e-01f,
  2.03655232e-02f, 6.44795150e-02f, -7.31032118e-02f, 8.00780356e-02f, -9.37511548e-02f, 8.63819197e-02f, -7.28140399e-02f, -6.49599060e-02f, -1.06058352e-01f, 9.80950594e-02f,
  -1.26842871e-01f, 1.25672668e-01f, 1.21082418e-01f, -5.04550487e-02f, -5.42683080e-02f, -1.03256315e-01f, -5.20054214e-02f, 2.82982945e-01f, 1.29199615e-02f, 9.21116695e-02f,
  -3.29414196e-02f, -3.81636210e-02f, -5.00432886e-02f, 2.30927840e-02f, 1.82007793e-02f, 7.92920589e-02f, -9.65133384e-02f, 2.45645922e-02f, 1.07452519e-01f, 1.17260545e-01f,
  -1.57550126e-01f, 9.93248299e-02f, -5.20860851e-02f, 2.52846479e-01f, 5.58031574e-02f, -3.93289402e-02f, -1.21268116e-01f, 1.95737872e-02f, 1.75116941e-01f, 9.18025374e-02f,
  -4.22157384e-02f, -4.17254120e-03f, -8.26547761e-03f, 8.42123851e-02f, 8.83620083e-02f, 3.58221605e-02f, 9.67810526e-02f, 2.89257560e-02f, 1.00253269e-01f, -8.01420733e-02f,
  2.40982510e-02f, -3.28890420e-02f, -7.17224777e-02f, -5.35178185e-02f, 6.86819181e-02f, -8.92823339e-02f, -4.88092983e-03f, 6.61647990e-02f, 3.71294022e-02f, 2.93539483e-02f,
  -3.39396484e-02f, 7.05490261e-02f, 8.48520622e-02f, 1.65747374e-01f, 1.15644917e-01f, 5.88396937e-02f, -1.80354148e-01f, 8.69027246e-03f, -1.21754795e-01f, 2.52805487e-03f,
  1.54629186e-01f, 1.07579701e-01f, -8.23458582e-02f, 8.99154320e-02f, 1.09919950e-01f, 1.65893987e-01f, 9.45794880e-02f, -9.49274972e-02f, -8.83148313e-02f, 4.02864106e-02f,
  -4.26591262e-02f, -1.07914716e-01f, 1.13742528e-02f, 3.78459245e-02f, 6.57988654e-04f, -1.09722003e-01f, 7.73817524e-02f, -4.66625579e-02f, -6.71553910e-02f, 1.19902797e-01f,
  -8.87851566e-02f, 1.23595513e-01f, 8.87817815e-02f, 1.44317061e-01f, 9.19093713e-02f, 5.10532893e-02f, -4.95127589e-02f, -8.20590779e-02f, -7.84526616e-02f, 1.23080164e-01f,
  2.15583649e-02f, -5.22769652e-02f, -3.18405405e-02f, 9.91720855e-02f, -3.16726975e-02f, 6.34035617e-02f, 7.21058995e-02f, 7.20686838e-02f, -5.49485497e-02f, -9.72718671e-02f,
  -2.18489766e-02f, -3.61639298e-02f, -4.76337746e-02f, 7.81867653e-02f, 1.55688045e-04f, -1.34413883e-01f, -7.88408294e-02f, -2.15532770e-03f, 2.09609214e-02f, -8.60760137e-02f,
  -5.43969795e-02f, 9.39842612e-02f, -6.00231951e-03f, -3.70907374e-02f, 2.52739768e-02f, 4.52262014e-02f, 1.18333362e-01f, 8.62760246e-02f, -9.68278423e-02f, -1.86117236e-02f,
  2.92180441e-02f, 7.12957140e-03f, 9.75856819e-05f, -3.45410034e-03f, -1.18065201e-01f, -1.09847307e-01f, -1.67355873e-02f, 4.04987335e-02f, 8.04179609e-02f, 3.20641696e-02f,
  1.08206704e-01f, 1.53743876e-02f, -1.07224114e-01f, 5.63014075e-02f, 2.99915411e-02f, 7.61230290e-02f, 9.44015607e-02f, -7.62211382e-02f, -4.13485914e-02f, 6.43488765e-02f,
  8.87606442e-02f, 9.41841304e-02f, -4.48786579e-02f, -1.31537169e-02f, -9.29083079e-02f, 5.50608225e-02f, -4.23452593e-02f, 3.09815258e-02f, -9.70684439e-02f, 6.06015921e-02f,
  -3.37284505e-02f, 5.52569749e-03f, 1.63518619e-02f, 3.72094288e-02f, -3.62731591e-02f, 2.85067447e-02f, -8.10692757e-02f, -2.94562820e-02f, -1.86919961e-02f, -9.16009098e-02f,
  5.23983538e-02f, -1.00121908e-02f, 7.83450305e-02f, 2.11007521e-02f, 5.50290830e-02f, -1.06468916e-01f, -6.37672395e-02f, 3.60275134e-02f, 6.63177967e-02f, 8.61710683e-02f,
  -2.97608431e-02f, 7.44947866e-02f, 7.19650909e-02f, -5.34704402e-02f, -5.71828987e-03f, -2.94277049e-03f, -8.00240338e-02f, 9.49162096e-02f, -8.80868509e-02f, 1.09809056e-01f,
  1.42941713e-01f, 4.43065912e-02f, 5.93011640e-02f, 8.35402012e-02f, 1.47957161e-01f, -1.87483784e-02f, 2.70448662e-02f, 2.22877245e-02f, -9.08379108e-02f, -6.64999485e-02f,
  -1.41789883e-01f, -5.79443935e-04f, 8.96698013e-02f, -1.41845131e-02f, -1.08620636e-01f, -1.18732959e-01f, 6.98470399e-02f, -6.83834106e-02f, -4.18616347e-02f, 8.04773569e-02f,
  -1.41316541e-02f, 5.11618741e-02f, 1.07560478e-01f, 1.05898008e-01f, 3.07520237e-02f, -6.35157004e-02f, 6.73252121e-02f, -5.16525842e-02f, 3.73118967e-02f, -2.53898017e-02f,
  2.40391530e-02f, -4.31383029e-02f, -2.12389752e-02f, 2.54482366e-02f, 7.70560429e-02f, -6.96480423e-02f, 3.11453436e-02f, 7.99290389e-02f, 1.92294121e-02f, 5.72569249e-03f,
  -8.89910199e-03f, -2.59032403e-03f, -7.60019943e-02f, 4.11288487e-03f, -8.77850503e-02f, -8.23930353e-02f, -3.15105207e-02f, -1.16365142e-01f, 1.47507071e-01f, 1.63538232e-01f,
  8.70733559e-02f, -1.82464626e-02f, 1.06800340e-01f, 1.52569011e-01f, 7.54429996e-02f, 1.42320678e-01f, 3.20447460e-02f, 3.37122232e-02f, -7.60181248e-02f, 3.08630522e-02f,
  1.36290938e-01f, -1.06534269e-02f, 1.64622872e-03f, -7.24117756e-02f, -4.66219112e-02f, 1.15544565e-01f, 1.20002866e-01f, -1.30814493e-01f, -5.93543053e-02f, -1.58439860e-01f,
  3.24895717e-02f, -1.04731573e-02f, 6.84580356e-02f, 1.61555558e-01f, 1.14833549e-01f, 9.86898541e-02f, 7.10986108e-02f, 2.93744653e-02f, -4.69688550e-02f, 7.76967034e-02f,
  9.96008795e-03f, 3.94439232e-03f, -1.15862362e-01f, -4.04917076e-02f, 1.79973058e-02f, -1.49307698e-01f, 6.67224973e-02f, -2.75033829e-03f, 7.13210851e-02f, 1.34408787e-01f,
  6.96365982e-02f, -3.30033265e-02f, -3.74163911e-02f, -1.05068542e-01f, 1.09899819e-01f, 2.05343924e-02f, -4.65428084e-02f, -1.00447282e-01f, -4.99573983e-02f, 8.36588442e-02f,
  1.06295288e-01f, -8.97739083e-02f, 1.22176044e-01f, -8.12299624e-02f, 6.56230077e-02f, 1.31314397e-01f, -1.10561550e-02f, 4.43978682e-02f, -1.84945874e-02f, 7.08283931e-02f,
  1.25620469e-01f, 7.98519701e-02f, -6.57057166e-02f, -3.53104831e-03f, 1.99297845e-01f, 9.14039388e-02f, 9.75610465e-02f, 1.44763350e-01f, 1.87254831e-01f, 2.96606515e-02f,
  -1.43134594e-01f, 1.61023155e-01f, 1.61793530e-01f, 4.31630723e-02f, -2.85020098e-02f, -4.15812358e-02f, -3.69990617e-02f, -2.24841479e-02f, 1.16418302e-03f, 4.11433280e-02f,
  5.40705286e-02f, -3.90474796e-02f, 1.76014900e-01f, 1.91300735e-01f, -2.95845777e-01f, -3.77794402e-03f, -6.41740710e-02f, 3.24094743e-02f, 8.07473734e-02f, 1.57511339e-01f,
  -5.73099181e-02f, -2.84146774e-03f, -1.88979208e-01f, -1.61902681e-01f, 1.14137851e-01f, -9.06791911e-02f, -1.15120791e-01f, 3.74520384e-02f, -1.04243435e-01f, -1.83628537e-02f,
  -6.92920983e-02f, 1.74330622e-01f, 1.40376866e-01f, -1.65553421e-01f, 4.22527641e-02f, 1.48613513e-01f, -1.39299050e-01f, 1.06098242e-01f, 1.50747716e-01f, -5.91391921e-02f,
  -8.92848372e-02f, 3.71461660e-02f, -5.23971990e-02f, -3.25298794e-02f, 1.01539075e-01f, -3.68486568e-02f, -5.08166365e-02f, -4.43202741e-02f, 1.04441166e-01f, -8.58719349e-02f,
  1.65951308e-02f, 7.82167390e-02f, 4.83776741e-02f, -1.01286180e-01f, 7.36156031e-02f, -2.99732666e-02f, 8.43663886e-02f, 2.39579491e-02f, -4.58833054e-02f, -4.10251394e-02f,
  9.50284004e-02f, 7.14318901e-02f, 9.35785100e-03f, 4.28955667e-02f, -1.27832144e-01f, 2.82005575e-02f, 1.58367410e-01f, 7.24444762e-02f, -5.87633662e-02f, 1.37577832e-01f,
  -8.52180868e-02f, 4.61041220e-02f, 1.46569774e-01f, 8.36760029e-02f, 5.52134924e-02f, -6.42242357e-02f, 9.00572613e-02f, -3.57450685e-03f, -3.56134251e-02f, -4.89254519e-02f,
  -1.65998086e-01f, -1.14050686e-01f, -5.36362678e-02f, -6.90164194e-02f, 2.50651389e-02f, 1.66316122e-01f, 3.67507041e-02f, -1.38095483e-01f, 3.65212443e-03f, -6.13931194e-02f,
  -2.28343587e-02f, 7.74723142e-02f, -6.41320348e-02f, -3.16746943e-02f, -2.21469589e-02f, -2.76601445e-02f, -7.19939470e-02f, 1.19560726e-01f, -5.44079840e-02f, 1.34035498e-01f,
  6.31556809e-02f, -1.08407217e-03f, 3.49195004e-02f, 5.24785630e-02f, 6.28871545e-02f, -1.00135416e-01f, 2.76373923e-02f, -1.40704975e-01f, 1.41609237e-01f, -6.17361777e-02f,
  4.41172272e-02f, -5.64891025e-02f, -3.27728204e-02f, -9.71020609e-02f, -1.83950197e-02f, 7.46420473e-02f, 1.34873062e-05f, -1.04013160e-01f, -5.11749983e-02f, -1.01170065e-02f,
  -3.02287843e-02f, 6.29795268e-02f, -1.70029804e-01f, -9.37848072e-03f, 1.19920075e-01f, 1.36577403e-02f, -5.21415211e-02f, 1.00678019e-02f, 3.30599733e-02f, -2.71410458e-02f,
  6.12128749e-02f, 1.03475235e-01f, 1.00412734e-01f, 1.69740152e-02f, 2.12097168e-02f, 9.20029581e-02f, 6.98489994e-02f, 1.18159346e-01f, 1.86564535e-01f, -3.70597504e-02f,
  -1.39440164e-01f, 9.32291076e-02f, 1.27126664e-01f, -6.65630260e-03f, -2.28173193e-02f, 1.58975825e-01f, -1.39371186e-01f, -1.25445783e-01f, 6.09612884e-03f, 1.87800199e-01f,
  -1.75909683e-01f, 1.40322186e-02f, 4.02267016e-02f, 1.15387201e-01f, -2.86733801e-03f, -8.71230960e-02f, 3.37364376e-02f, 8.88093039e-02f, -6.38715923e-03f, -8.69262218e-02f,
  -1.05088977e-02f, -3.68198678e-02f, 1.34005234e-01f, 1.15589716e-01f, 4.01631519e-02f, -1.16781577e-01f, 2.68953145e-02f, -4.18339632e-02f, 6.89692348e-02f, 1.61038592e-01f,
  1.33114755e-01f, -6.79815263e-02f, 4.49874960e-02f, 1.60331190e-01f, -6.37049787e-03f, 2.39284169e-02f, 6.52954057e-02f, 1.55084580e-01f, 4.76428308e-02f, 4.50420901e-02f,
  5.14356233e-02f, 9.13174748e-02f, -4.19317521e-02f, -6.04663081e-02f, -4.96792607e-02f, 7.38694966e-02f, 1.58214986e-01f, 4.87764552e-02f, -6.58912659e-02f, -5.87680936e-02f,
  -6.47440180e-02f, -5.90161756e-02f, 8.32139775e-02f, -3.69181260e-02f, 6.87890872e-03f, 2.47398615e-02f, -2.10364349e-02f, -1.58109833e-02f, 7.50696585e-02f, 7.49872103e-02f,
  8.01425874e-02f, 1.47407100e-01f, -1.49104685e-01f, 2.73672566e-02f, 2.02690456e-02f, 3.28170173e-02f, -1.63050458e-01f, 3.47515829e-02f, 1.11014605e-01f, -8.67576376e-02f,
  -6.75726607e-02f, 7.60575011e-02f, 2.44795810e-02f, -3.21358442e-02f, 1.25673175e-01f, -1.30156100e-01f, 9.21309292e-02f, 1.17533781e-01f, 2.83177346e-02f, -9.24211740e-02f,
  7.17319176e-02f, -3.35903168e-02f, -4.73293141e-02f, -6.48541451e-02f, -3.23518626e-02f, -5.99767896e-04f, -5.50371669e-02f, 3.89685109e-02f, -9.20577813e-03f, -7.58521408e-02f,
  -4.19280231e-02f, 4.89755422e-02f, -9.59901214e-02f, 7.06636980e-02f, 1.00171501e-02f, 1.11871459e-01f, -9.91921574e-02f, 3.63839045e-02f, -1.24844080e-02f, -9.24877301e-02f,
  -6.32738322e-02f, -5.52777648e-02f, 4.06466350e-02f, 4.39346023e-02f, 3.16481069e-02f, -6.90986589e-02f, -4.60471325e-02f, 7.04479367e-02f, 1.25676692e-01f, 1.30587995e-01f,
  -2.12328091e-01f, -1.44640096e-02f, -6.27388731e-02f, -5.16855791e-02f, 1.38835132e-01f, 1.23106748e-01f, -2.79964302e-02f, -9.15521309e-02f, 7.61290863e-02f, 1.40798911e-01f,
  1.07197970e-01f, -2.57738330e-03f, 1.02323778e-01f, 1.65798485e-01f, 1.80389378e-02f, 3.16739045e-02f, 1.89729542e-01f, -9.07867588e-03f, 5.55139519e-02f, -4.45134006e-02f,
  1.47921950e-01f, 1.36088401e-01f, 1.99329294e-02f, -1.07659280e-01f, -4.15981635e-02f, -1.74248353e-01f, 3.71775776e-02f, 1.14153162e-01f, -1.25594914e-01f, -1.44546339e-02f,
  3.48098911e-02f, -1.77032885e-03f, 1.31662309e-01f, -8.69710892e-02f, -1.11665959e-02f, 1.37563169e-01f, -9.47921872e-02f, -1.41834244e-01f, -5.13335802e-02f, 9.95915532e-02f,
  -5.19087501e-02f, -1.10752836e-01f, -1.07688405e-01f, -1.31734321e-02f, 1.07688114e-01f, 1.54621556e-01f, 1.09402925e-01f, -2.73978189e-02f, 5.20886034e-02f, 4.45329696e-02f,
  1.40715897e-01f, -9.22198445e-02f, -3.53334658e-03f, -5.64710684e-02f, 4.29216772e-02f, 5.26822545e-03f, 1.33062795e-01f, 9.74518135e-02f, 1.69101208e-01f, 9.70126837e-02f,
  -8.26447308e-02f, -1.12925656e-01f, -1.12452395e-01f, 5.72377816e-02f, 7.36111552e-02f, -1.72296241e-02f, 1.28764957e-01f, -9.41385701e-02f, -1.74606517e-02f, 3.91752310e-02f,
  -1.16454892e-01f, 1.10081866e-01f, -7.43068159e-02f, 1.52359679e-02f, 4.78604063e-02f, 1.69465989e-02f, -5.50280288e-02f, 9.04905889e-03f, 1.01791695e-01f, 1.06282964e-01f,
  -1.82841218e-03f, 5.31580746e-02f, -3.92462984e-02f, -5.94987497e-02f, -6.24237470e-02f, 7.20419809e-02f, 1.36654926e-02f, -6.22161478e-02f, -5.99286072e-02f, -1.22798711e-01f,
  -1.01032173e-02f, 1.01095915e-01f, -2.47398093e-02f, 1.13655291e-01f, -7.08820894e-02f, 6.77135065e-02f, -7.34194219e-02f, -4.52330429e-03f, 7.47024873e-03f, -1.29133780e-02f,
  -4.35699113e-02f, -5.51302247e-02f, 6.21621832e-02f, 7.26737157e-02f, -1.02500268e-03f, 7.50316493e-03f, 7.88611919e-02f, 3.84320691e-02f, -9.95708629e-02f, -5.85738644e-02f,
  -1.21248057e-02f, -1.12971038e-01f, 2.95907762e-02f, 9.99507606e-02f, 2.61807628e-02f, -1.37076452e-02f, 7.84858912e-02f, 6.46797046e-02f, -9.75079536e-02f, 8.10536817e-02f,
  1.07239023e-01f, -1.02384910e-01f, 6.33134469e-02f, 1.17638566e-01f, 4.25341688e-02f, -4.78097796e-02f, -1.00941524e-01f, -1.12907097e-01f, -9.71436128e-02f, -1.18308567e-01f,
  1.17151015e-01f, -1.08529687e-01f, -8.54205340e-02f, -1.08581506e-01f, -1.23605959e-01f, 1.16417773e-01f, 1.10970609e-01f, -6.94744196e-03f, -8.24951157e-02f, 1.03550375e-01f,
  -2.09591519e-02f, -1.18567750e-01f, -9.38202962e-02f, 6.71299361e-03f, 1.77671500e-02f, -9.64279100e-03f, 8.08918327e-02f, -1.01529971e-01f, 6.09991886e-02f, 4.31484058e-02f,
  -4.81951386e-02f, -2.09288318e-02f, -2.66858060e-02f, -7.32685030e-02f, 2.94802338e-02f, -9.29442346e-02f, -6.87413961e-02f, -7.42494091e-02f, 9.67357773e-03f, -5.43423407e-02f,
  2.40206402e-02f, -3.43885459e-02f, -7.00214356e-02f, 3.43712745e-03f, 1.08302347e-01f, -2.27881353e-02f, -3.85797024e-02f, -1.22884043e-01f, 2.72033736e-04f, -9.44927856e-02f,
  -1.31707378e-02f, 8.76194891e-03f, -9.15310159e-02f, -1.12212494e-01f, 1.10571533e-01f, -5.50529696e-02f, -8.96681771e-02f, -1.89702399e-02f, -4.41543525e-05f, -5.01821749e-02f,
  8.68252888e-02f, 5.67345992e-02f, 5.31100854e-02f, 5.96797317e-02f, -1.02926195e-01f, 2.61474773e-02f, -9.63034853e-02f, 1.10708065e-01f, 2.08020523e-01f, 1.20556690e-01f,
  3.68076824e-02f, 2.39360675e-01f, 5.89059405e-02f, 4.49123383e-02f, -2.51238253e-02f, 2.72645392e-02f, 1.17344067e-01f, 2.06617445e-01f, 1.47534981e-01f, 1.85088187e-01f,
  2.42144763e-01f, -6.01112768e-02f, 1.64221466e-01f, 5.00413142e-02f, 5.16001843e-02f, 4.09816615e-02f, 1.55332655e-01f, 1.45255536e-01f, -1.94049582e-01f, 2.26282284e-01f,
  -2.43879810e-01f, -1.21026948e-01f, 4.90284935e-02f, 3.13163280e-01f, 1.85471818e-01f, -1.12927258e-01f, -1.09718807e-01f, 7.26652518e-02f, -2.39015892e-02f, -5.67818526e-03f,
  4.25758183e-01f, 1.10293821e-01f, -2.44603723e-01f, -3.27135265e-01f, 1.99390978e-01f, 2.36143053e-01f, 2.00086869e-02f, 1.05939455e-01f, 1.87224343e-01f, -1.55096158e-01f,
  -6.33278787e-02f, 8.49456340e-02f, -8.98904279e-02f, 1.30516186e-01f, -5.16320355e-02f, -1.72579307e-02f, -1.64877232e-02f, 6.31428584e-02f, 1.11151889e-01f, -4.04307432e-02f,
  1.05500342e-02f, -5.10624424e-02f, 5.37019596e-02f, 9.80239734e-02f, -1.22490421e-01f, -9.72503573e-02f, -8.77906606e-02f, 1.73277050e-01f, 8.63677561e-02f, -6.70875311e-02f,
  2.49698963e-02f, 8.78045857e-02f, -2.93291733e-02f, -1.01987235e-01f, 2.09674209e-01f, 1.20700322e-01f, 2.18110979e-01f, 1.37878537e-01f, -9.30356085e-02f, 5.05937114e-02f,
  1.88696846e-01f, 1.22262500e-01f, 1.34746015e-01f, 1.57741800e-01f, 1.05303302e-01f, 2.15331614e-01f, 3.02891526e-02f, 1.97349891e-01f, 1.16984800e-01f, 3.94264907e-02f,
  5.20001128e-02f, 4.45016548e-02f, 2.12803245e-01f, -1.64724022e-01f, -7.38372356e-02f, -1.00759275e-01f, -1.23397872e-01f, -1.78034723e-01f, 3.60959210e-03f, 2.09598467e-01f,
  1.38183013e-01f, -6.12943992e-02f, 7.66899139e-02f, -2.33387589e-01f, 4.88275252e-02f, 1.54305443e-01f, 1.63787112e-01f, 9.14820209e-02f, -2.47834265e-01f, -2.19661877e-01f,
  -1.31241545e-01f, -8.32235664e-02f, 1.10581098e-03f, 2.76474059e-01f, -1.54389404e-02f, -2.86612730e-03f, -8.90810266e-02f, -3.55764553e-02f, 1.85206477e-02f, 1.20505147e-01f,
  9.50826630e-02f, -2.62315734e-03f, 1.06577910e-01f, -5.71052954e-02f, 1.24610569e-02f, 1.46245673e-01f, -5.90040758e-02f, -7.25843087e-02f, 1.23316318e-01f, -1.01556651e-01f,
  7.79600590e-02f, -1.40420958e-01f, -6.16654567e-02f, 7.01290518e-02f, 8.37879255e-02f, 7.81622529e-02f, -6.64584637e-02f, -6.52934685e-02f, 2.53419112e-02f, 5.64979762e-02f,
  -1.19359847e-02f, -5.79453893e-02f, 1.05598345e-01f, -1.02304757e-01f, -3.15704793e-02f, 7.73241296e-02f, 1.07351407e-01f, -9.74209756e-02f, -5.46594197e-03f, -4.51099500e-02f,
  4.53843772e-02f, 4.82951701e-02f, -2.96284836e-02f, -2.94779781e-02f, -6.79518878e-02f, -4.46027843e-03f, -4.52949852e-02f, -5.79350777e-02f, 4.63549718e-02f, 1.28944054e-01f,
  -5.56802675e-02f, -2.96199434e-02f, 1.88475065e-02f, -1.04614928e-01f, -1.17709868e-01f, 1.24008656e-01f, -4.19977400e-03f, 1.02653086e-01f, -1.13899246e-01f, -1.30590826e-01f,
  -6.69171885e-02f, -2.58963071e-02f, -1.39294922e-01f, -6.54092357e-02f, 6.38256744e-02f, -5.19996397e-02f, -1.04772495e-02f, -5.61772138e-02f, 3.65543030e-02f, -1.19856514e-01f,
  -4.46853004e-02f, -1.25889610e-02f, -8.60316008e-02f, 7.95775950e-02f, -5.60653955e-02f, 6.50321394e-02f, -6.56666383e-02f, -4.49519837e-04f, 9.85971689e-02f, -1.17895767e-01f,
  7.33419359e-02f, 1.17127277e-01f, 6.08419813e-02f, 3.69025134e-02f, 8.13674089e-03f, -6.23151585e-02f, 1.03086889e-01f, 1.36983544e-01f, -4.49169278e-02f, 4.63978015e-02f,
  -8.89353082e-02f, -1.83439385e-02f, 1.00732572e-01f, 1.09062135e-01f, 1.25350744e-01f, -1.94327608e-02f, -1.48911715e-01f, 3.51440571e-02f, 9.89663303e-02f, -3.71901542e-02f,
  4.08243388e-02f, -8.03041086e-03f, -6.36971518e-02f, -1.18638001e-01f, 4.70356755e-02f, -1.31190419e-01f, 4.88333777e-02f, -4.71095778e-02f, 3.35644372e-02f, -1.44451391e-02f,
  1.88292051e-03f, 5.51861525e-02f, 9.03550088e-02f, -7.02814907e-02f, -1.53103411e-01f, -8.67298618e-02f, 2.76659969e-02f, 7.89556876e-02f, -8.41338262e-02f, 2.30375547e-02f,
  9.36335102e-02f, -5.42421192e-02f, -1.01579390e-01f, 2.77675726e-02f, 5.31176999e-02f, 1.90715685e-01f, -1.38891995e-01f, 1.04229569e-01f, 6.38932586e-02f, -1.00478411e-01f,
  3.85650769e-02f, 3.61774154e-02f, 5.20291775e-02f, -2.32712813e-02f, 5.22342063e-02f, -1.10387161e-01f, -1.27071021e-02f, -9.82895568e-02f, 5.75572811e-02f, 3.17467302e-02f,
  -3.94855663e-02f, 1.09872982e-01f, 4.82983142e-02f, 1.86694488e-01f, -4.85613290e-03f, 7.77320564e-02f, -7.81896804e-03f, -4.96789180e-02f, 1.00085393e-01f, -7.54845962e-02f,
  1.24104246e-02f, 7.76015148e-02f, -6.34804368e-02f, 6.98090717e-02f, -3.45732160e-02f, 5.67574948e-02f, 3.80267315e-02f, -7.85047710e-02f, 3.98095101e-02f, 2.39055399e-02f,
  -7.30245411e-02f, -4.68266830e-02f, 7.88717642e-02f, -9.91291180e-02f, 3.87738459e-02f, -7.18759745e-02f, -8.32621939e-03f, 1.42180827e-02f, 2.00137999e-02f, -2.33733412e-02f,
  -6.77964985e-02f, 7.47985393e-02f, -1.19836092e-01f, -1.19147241e-01f, -1.19184125e-02f, 8.27075914e-02f, -1.55562803e-01f, 5.65371774e-02f, 6.45734295e-02f, 9.46182013e-02f,
  -7.80108348e-02f, -2.53752293e-03f, 9.51955002e-03f, 5.93125485e-02f, 1.45139858e-01f, 4.89804074e-02f, 9.18834582e-02f, -4.68227528e-02f, 8.63809288e-02f, 1.20483108e-01f,
  -8.90288036e-03f, -6.80141002e-02f, -3.37623842e-02f, 1.21340103e-01f, -7.62324706e-02f, -7.21468031e-02f, 1.10025138e-01f, 8.38280618e-02f, 5.99502260e-03f, 9.40200388e-02f,
  1.22448906e-01f, 1.04267880e-01f, 9.80866328e-02f, 7.08146021e-02f, 1.06705971e-01f, -1.04763657e-01f, 1.37243256e-01f, -6.67572916e-02f, 8.46681669e-02f, -3.32158096e-02f,
  1.09682530e-02f, -1.72482282e-02f, 1.12938277e-01f, -5.92046715e-02f, 7.45318234e-02f, -5.87430689e-03f, 7.56330192e-02f, 4.38458845e-02f, 6.74939305e-02f, 1.61304727e-01f,
  5.46089597e-02f, 6.02923855e-02f, 2.57427216e-01f, -8.93818811e-02f, 1.87592693e-02f, -4.83572036e-02f, 2.06026539e-01f, 1.24558359e-01f, -4.37355824e-02f, 8.24898258e-02f,
  2.13842526e-01f, -1.14506342e-01f, 8.68763402e-02f, -6.27712905e-02f, 9.01416466e-02f, 1.80218861e-01f, 1.82531133e-01f, 5.42225270e-03f, -1.61950141e-01f, 3.08845527e-02f,
  1.76733255e-01f, -1.93270408e-02f, -1.35343894e-01f, 1.09469220e-01f, 1.32893726e-01f, -1.12789035e-01f, 3.14520411e-02f, -1.34636536e-02f, -1.53065577e-01f, 9.89222378e-02f,
  1.00020006e-01f, 1.82441324e-02f, -2.75705010e-02f, -7.92637989e-02f, -1.40339881e-01f, -1.79130863e-02f, -1.35258781e-02f, -9.24647152e-02f, -4.61051054e-02f, 7.53942356e-02f,
  -1.69751998e-02f, -1.06311552e-01f, -3.06442548e-02f, -1.66652836e-02f, -1.05661593e-01f, -1.25043988e-01f, 3.56403999e-02f, -9.73829851e-02f, 7.18871579e-02f, -7.17581511e-02f,
  -7.86509588e-02f, -8.04473385e-02f, 1.10146485e-01f, 5.53985350e-02f, 1.32680774e-01f, 1.13494974e-02f, -7.85480589e-02f, -2.36204341e-02f, -1.10911496e-01f, 9.67100263e-02f,
  -1.00271404e-01f, -3.07031311e-02f, 9.52425227e-02f, -9.56036225e-02f, 6.95137382e-02f, 1.41565770e-01f, 1.77562073e-01f, -2.56466884e-02f, -7.77754262e-02f, 1.55131407e-02f,
  1.13101117e-01f, 3.27111147e-02f, 1.72675461e-01f, -1.65150072e-02f, 6.11332506e-02f, -2.57649533e-02f, 4.10922244e-02f, -1.77026745e-02f, -8.27495940e-03f, 1.70999467e-01f,
  8.88191443e-03f, -3.14231180e-02f, 1.00779615e-01f, -2.51455326e-02f, -1.68235406e-01f, 1.18090525e-01f, -2.47337535e-01f, -1.65972933e-01f, 3.84841897e-02f, 1.57134295e-01f,
  -2.99847554e-02f, 6.83172420e-02f, -1.02596447e-01f, -1.60051346e-01f, -1.16529740e-01f, -2.89582014e-02f, 3.90679464e-02f, 2.11785629e-01f, -2.36567646e-01f, -5.67525737e-02f,
  -1.26522571e-01f, -1.28376231e-01f, 2.53447294e-02f, 1.31727889e-01f, 9.39093381e-02f, -1.46289825e-01f, 5.54822385e-02f, 8.76387060e-02f, 3.87943462e-02f, 1.04319587e-01f,
  1.63659275e-01f, -4.88125347e-02f, -1.21540926e-01f, -9.80146900e-02f, 4.82807569e-02f, 6.16520829e-02f, -1.49615994e-02f, -1.98892280e-02f, -8.58409256e-02f, 6.15516268e-02f,
  6.83737695e-02f, -6.78038970e-02f, -1.38868228e-01f, 3.01940534e-02f, -1.31871760e-01f, -8.88914764e-02f, -1.10968709e-01f, -6.50245920e-02f, 1.50533110e-01f, -5.14817573e-02f,
  -1.06916681e-01f, 1.25706181e-01f, 5.51958568e-02f, 2.04361510e-02f, -5.16291074e-02f, -9.28750858e-02f, 1.18500488e-02f, 1.05829820e-01f, -1.03619590e-01f, -9.00107324e-02f,
  2.90389284e-02f, 4.77489643e-02f, 5.06804660e-02f, 1.52650222e-01f, -2.36687288e-02f, -1.17391527e-01f, -6.60627894e-03f, -2.05319393e-02f, -7.93928355e-02f, 1.08151361e-01f,
  1.08774953e-01f, -1.62863098e-02f, -1.39670104e-01f, 1.19404465e-01f, 9.12259519e-03f, -9.51868072e-02f, 7.00584203e-02f, 6.04129061e-02f, -1.13534592e-01f, -8.57322589e-02f,
  1.00203693e-01f, 7.19047850e-03f, 8.93623680e-02f, -6.06129505e-03f, 1.11833066e-02f, 1.87798701e-02f, -6.54440150e-02f, 1.85568258e-02f, 6.80420771e-02f, 2.10409537e-02f,
  -3.78542878e-02f, -3.27216573e-02f, 1.12566069e-01f, -4.59062383e-02f, 7.16078281e-02f, -1.78739969e-02f, 2.55852565e-02f, 2.48861033e-02f, -1.31376937e-01f, 1.51007757e-01f,
  4.31574248e-02f, 1.21074189e-02f, 3.05923689e-02f, -5.36753275e-02f, -8.80765393e-02f, 5.31622507e-02f, 1.12881616e-01f, -1.19013023e-02f, -4.94681299e-02f, -4.72044945e-02f,
  4.99340752e-03f, 7.53450617e-02f, 4.44244444e-02f, 1.30768687e-01f, 2.35938445e-01f, 1.64728779e-02f, 4.64327671e-02f, 4.51704115e-02f, -1.33921737e-02f, 1.85277686e-01f,
  3.77216339e-02f, 2.62710098e-02f, 1.51051372e-01f, -7.43716508e-02f, 1.03374064e-01f, -1.60999417e-01f, 1.73912153e-01f, 1.21113263e-01f, 9.06442702e-02f, -1.61197305e-01f,
  -1.15672261e-01f, -7.69251212e-02f, 7.02023953e-02f, -1.72048837e-01f, 5.67394905e-02f, 7.20683411e-02f, 1.63791906e-02f, 1.75377205e-02f, -9.42465067e-02f, 1.91616416e-01f,
  -8.18052813e-02f, -1.63201049e-01f, 1.05851650e-01f, 1.94297403e-01f, -8.30916539e-02f, -8.23672041e-02f, -6.80561066e-02f, 1.94737390e-01f, 2.92242374e-02f, -1.07162163e-01f,
  -1.27172500e-01f, -5.47633320e-02f, 2.07607523e-02f, -8.39480236e-02f, 3.45153995e-02f, 5.75231761e-02f, 1.24871023e-01f, 3.77623364e-02f, -1.37777012e-02f, 1.30402222e-01f,
  -1.04941010e-01f, -5.45097962e-02f, -2.64782570e-02f, 2.62634486e-01f, 6.24929927e-02f, -1.20964400e-01f, 1.36772528e-01f, 5.50917014e-02f, 1.80912435e-01f, 6.80898800e-02f,
  -6.21895194e-02f, -3.04657035e-02f, -1.01588085e-01f, 1.02127619e-01f, 1.62351459e-01f, 6.77828714e-02f, 8.57329741e-02f, 7.51216337e-03f, 1.60068676e-01f, 1.15472324e-01f,
  2.94035506e-02f, 1.13846295e-01f, -2.83489693e-02f, 1.22293130e-01f, 8.60477835e-02f, 7.35301524e-02f, 5.56101017e-02f, 3.84384319e-02f, 1.27630383e-01f, 9.53712538e-02f,
  -5.17197233e-03f, 1.51772276e-01f, 8.75752047e-02f, 2.45626867e-01f, 3.20244959e-04f, -9.59747210e-02f, 1.22183397e-01f, -7.32187629e-02f, 4.25168201e-02f, 2.70654988e-02f,
  9.01967511e-02f, -1.68775424e-01f, 1.88355565e-01f, 4.38917428e-03f, 1.24641791e-01f, 9.87309311e-03f, -1.03834771e-01f, 6.25943094e-02f, 1.04804840e-02f, -1.55041190e-02f,
  3.25712040e-02f, -1.88878253e-01f, -1.31708652e-01f, 1.28886029e-01f, -6.97593763e-02f, -5.81334420e-02f, -4.55421880e-02f, 1.45750508e-01f, 5.02640940e-02f, 4.61858958e-02f,
  -6.42790571e-02f, 3.99411470e-02f, -3.95328812e-02f, 9.24523696e-02f, 1.10747583e-01f, 2.28567440e-02f, -8.01981762e-02f, -2.70536728e-02f, 1.53140575e-01f, -1.51787281e-01f,
  9.03641209e-02f, -1.31360382e-01f, -1.12171449e-01f, 1.40801772e-01f, 1.63246319e-03f, -4.98055555e-02f, -1.01821050e-01f, 7.84310922e-02f, -8.16269293e-02f, -9.49391499e-02f,
  1.46484096e-02f, -7.59501681e-02f, -1.79070547e-01f, 1.35057658e-01f, 4.81306911e-02f, 7.51567855e-02f, -6.65698200e-02f, -7.25059062e-02f, 9.56282392e-02f, 3.90551016e-02f,
  1.21059060e-01f, 2.77494267e-02f, 1.29981011e-01f, 1.45882949e-01f, -4.90825102e-02f, 1.35489881e-01f, -1.46942521e-02f, -9.03925821e-02f, -6.60373969e-03f, -8.76146406e-02f,
  8.62827674e-02f, 8.36123526e-02f, 6.07629642e-02f, 5.88099211e-02f, -1.00460351e-01f, -1.00490473e-01f, 5.37033118e-02f, -1.73815280e-01f, 1.83343947e-01f, 1.26660634e-02f,
  2.47099772e-02f, -3.98013443e-02f, 1.19982325e-01f, -1.47185892e-01f, -4.38355356e-02f, 1.18767038e-01f, 1.13989273e-03f, 1.73523784e-01f, 3.34035642e-02f, 8.31354037e-02f,
  9.31775421e-02f, 6.46063238e-02f, 5.57454452e-02f, -1.15817666e-01f, 4.73918505e-02f, -5.98623557e-03f, -3.74990590e-02f, 1.08705170e-03f, 1.34530008e-01f, 1.31553190e-03f,
  2.17224676e-02f, -6.28367737e-02f, -1.19446060e-02f, -4.73418180e-03f, 5.40051796e-02f, -2.92404927e-02f, 9.57818776e-02f, -7.94626102e-02f, 6.07093237e-02f, -1.26029357e-01f,
  1.22321971e-01f, 6.95577413e-02f, 1.83968559e-01f, 1.85832903e-01f, 2.97194533e-02f, -4.20389250e-02f, -4.76752073e-02f, 7.79779851e-02f, 1.39281437e-01f, 4.21684654e-03f,
  2.08921403e-01f, 9.80826691e-02f, 1.28291935e-01f, 1.02006719e-01f, 9.49595720e-02f, -3.39198043e-03f, 2.89913416e-02f, 1.18389748e-01f, 6.83066174e-02f, 1.07831411e-01f,
  2.04801902e-01f, -1.72150865e-01f, -2.31341779e-01f, -6.70327246e-02f, 2.52528191e-01f, 9.62955579e-02f, -6.88384548e-02f, 3.05736307e-02f, -1.57515004e-01f, -6.61839247e-02f,
  -9.99473631e-02f, 6.25644177e-02f, -1.89878926e-01f, 1.01654790e-01f, -4.44499068e-02f, -1.36302546e-01f, -1.52510107e-01f, -4.80628200e-03f, 9.30548757e-02f, 3.78045291e-02f,
  6.47523627e-02f, 2.71468312e-02f, 8.99527818e-02f, 1.34342507e-01f, -8.30815453e-03f, 3.96853089e-02f, 7.04684388e-03f, 8.69144127e-02f, -1.33368418e-01f, 6.76547661e-02f,
  1.19246632e-01f, -1.23199098e-01f, -9.48130786e-02f, 1.32812992e-01f, -7.94189051e-02f, 1.08263277e-01f, -4.77531664e-02f, 9.26697329e-02f, 1.38286001e-03f, 8.79213437e-02f,
  5.07789515e-02f, 8.87949672e-03f, -2.33492851e-02f, 1.31549403e-01f, 3.37599479e-02f, 7.39643425e-02f, -1.73543952e-02f, 2.58817285e-01f, 2.27035463e-01f, 5.54427877e-02f,
  7.60903675e-03f, 2.34797969e-02f, 1.01901039e-01f, 1.51069149e-01f, 2.92905532e-02f, 2.43817568e-01f, 4.22864445e-02f, 9.34805125e-02f, -1.72829218e-02f, -9.01453383e-03f,
  1.06837042e-01f, 1.58229947e-01f, 4.61625773e-03f, 2.00837538e-01f, 1.06848247e-01f, 1.77632317e-01f, 1.95341796e-01f, 1.65782943e-01f, -2.20144689e-01f, -3.33983690e-01f,
  3.98171186e-01f, 2.62459785e-01f, -1.06767245e-01f, 1.79757010e-02f, 2.72644818e-01f, -9.76995286e-03f, 1.94274530e-01f, 1.69355795e-01f, 2.57487923e-01f, 2.48869240e-01f,
  -1.88230634e-01f, 2.21786369e-03f, -9.24052075e-02f, -3.04935053e-02f, -6.26514405e-02f, -5.03226481e-02f, 8.21150765e-02f, 7.98844174e-02f, -6.96229786e-02f, 3.57743144e-01f,
  -2.91121025e-02f, -6.69243187e-02f, 7.91319907e-02f, -1.08070970e-01f, -4.37312983e-02f, 8.60642418e-02f, 2.91801095e-01f, -1.22478835e-01f, 2.18162403e-01f, -1.10316493e-01f,
  -2.77328454e-02f, 1.32734463e-01f, 1.07201450e-01f, 1.22717120e-01f, -1.49065852e-02f, 1.98184296e-01f, -8.47130716e-02f, -6.44201040e-02f, 2.85417110e-01f, 3.12721506e-02f,
  -1.04014603e-02f, 8.50623325e-02f, 1.46243066e-01f, 6.37864545e-02f, -5.85649870e-02f, 1.15553075e-02f, -8.43658447e-02f, 1.44956857e-01f, 5.09368181e-02f, 4.13912237e-02f,
  7.58183151e-02f, -5.87994084e-02f, -1.00610048e-01f, -6.53134361e-02f, 1.46600559e-01f, 7.92380124e-02f, -2.73688957e-02f, 1.12224407e-01f, -3.56475520e-03f, 7.26485476e-02f,
  7.87525848e-02f, -9.34992358e-02f, -1.47675097e-01f, -2.01578557e-01f, 2.24955797e-01f, -9.71803293e-02f, -1.12295665e-01f, 1.67884603e-01f, -2.02535614e-02f, 3.13229556e-03f,
  3.07929292e-02f, 1.26323104e-01f, -6.33219630e-02f, -1.09225310e-01f, -3.24735157e-02f, 8.94004405e-02f, -5.86448349e-02f, 3.49042527e-02f, -2.10547168e-02f, 1.57277882e-01f,
  1.23468168e-01f, 9.31644216e-02f, -1.10034712e-01f, 9.76820886e-02f, 9.44203511e-02f, -1.51235223e-01f, 4.57041822e-02f, 3.37276869e-02f, -4.82026637e-02f, -9.96359531e-03f,
  -4.75274958e-02f, 1.37200236e-01f, -4.06554667e-03f, 1.18098306e-02f, -8.48921314e-02f, 1.82903901e-01f, -1.10737965e-01f, 1.83024734e-01f, 6.87910914e-02f, 1.08568691e-01f,
  3.67267169e-02f, -6.96640238e-02f, 1.06291227e-01f, 1.33665457e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.97694346e-01f, -2.74991859e-02f, -3.99974696e-02f, -7.53239989e-02f, 7.65708163e-02f, 1.74509004e-01f, -4.71441261e-02f, 1.19296923e-01f, -7.64029324e-02f, -1.52874142e-02f,
  2.71976795e-02f, -1.26163468e-01f, 2.51972415e-02f, -1.07322000e-02f, 4.88495603e-02f, 1.11601628e-01f, 7.26306215e-02f, 2.12369353e-01f, 1.41039997e-01f, 1.42495543e-01f,
  -2.43701972e-02f, 1.38408661e-01f, 1.55666441e-01f, 8.02132636e-02f, 6.77038282e-02f, 5.98967895e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -6.18035384e-02f, 5.36969490e-02f, 1.17048323e-01f, 1.00605212e-01f, 8.23262408e-02f, -1.39765680e-01f, -2.45127037e-01f, -8.98877904e-02f, 1.35708839e-01f, 1.07974544e-01f,
  2.46726181e-02f, -8.35396871e-02f, -7.65303150e-02f, -6.51322380e-02f, -3.20691094e-02f, -1.89380690e-01f, 7.80058280e-02f, 6.84656808e-03f, -2.49954090e-02f, -3.18565927e-02f,
  -8.26986209e-02f, 2.12106593e-02f, 1.69689417e-01f, 3.10704201e-01f, 2.03810886e-01f, -9.72888991e-02f, 1.15638077e-01f, -1.30611926e-01f, 7.24992678e-02f, 1.10848442e-01f,
  -1.41995385e-01f, -2.46612191e-01f, -8.34588483e-02f, 1.17241941e-01f, 1.60590559e-01f, -2.14960709e-01f, 2.79131737e-02f, -1.80204958e-01f, 1.38031945e-01f, 3.91767137e-02f,
  1.14384696e-01f, -2.07351707e-02f, 1.68039855e-02f, -8.78420994e-02f, -5.21595329e-02f, -2.18602791e-02f, -8.28349963e-02f, 4.48348150e-02f, 2.28288565e-02f, -6.68772385e-02f,
  8.26253071e-02f, 3.08681987e-02f, 5.91643751e-02f, -4.04565409e-02f, -1.72016863e-02f, -3.45026888e-02f, -1.03840463e-01f, 2.50288611e-03f, -5.45796491e-02f, -5.54501154e-02f,
  3.37203499e-03f, 6.41935542e-02f, 1.11041822e-01f, 1.34479657e-01f, -2.98843868e-02f, 1.65391177e-01f, -7.66660199e-02f, 2.95645017e-02f, 3.01693683e-03f, -1.65717006e-01f,
  -5.63699454e-02f, -1.86580420e-03f, 4.70411442e-02f, -9.08740088e-02f, -1.63025901e-01f, -1.31862059e-01f, -1.72143966e-01f, -9.96230319e-02f, -3.89894843e-02f, -2.68075317e-02f,
  -1.35076120e-01f, -1.34663641e-01f, -7.91665167e-02f, -8.99298191e-02f, -7.69544905e-03f, 6.01331852e-02f, 6.89554214e-02f, 5.99151105e-02f, 6.34464100e-02f, -6.63443655e-02f,
  -8.08670893e-02f, 2.92753354e-02f, 1.89796805e-01f, 2.09896341e-02f, -1.36613652e-01f, -6.33011162e-02f, 2.19977528e-01f, 1.08768694e-01f, 1.94894239e-01f, -3.96036245e-02f,
  -1.01054110e-01f, -2.66634881e-01f, -8.75976756e-02f, 9.48405489e-02f, -9.29839090e-02f, -8.55593756e-02f, -1.18161477e-01f, -1.19986840e-01f, 6.21627681e-02f, -2.12360006e-02f,
  7.18225762e-02f, 7.95050524e-03f, -5.29455254e-03f, 1.19159572e-01f, 9.28114727e-02f, -2.04236031e-01f, -4.81065251e-02f, -1.24607340e-01f, -7.88465664e-02f, 9.55739096e-02f,
  -4.81732041e-02f, 7.29006007e-02f, -8.30689073e-03f, -1.10325657e-01f, -1.35898799e-01f, 2.12779075e-01f, -2.34384537e-02f, -8.93848762e-02f, -9.51085463e-02f, 9.78626460e-02f,
  2.00401153e-02f, -2.86965728e-01f, -4.83671725e-02f, 5.29654846e-02f, -7.61255026e-02f, 1.36493683e-01f, -2.67878324e-02f, -5.01597859e-02f, 1.06113091e-01f, 1.09926522e-01f,
  -5.52266240e-02f, 1.71542466e-02f, -6.13320582e-02f, -1.27788201e-01f, -1.75468758e-01f, -3.13024037e-02f, -7.93841183e-02f, 1.23169988e-01f, -3.29292059e-01f, -2.98143476e-01f,
  -1.79298297e-01f, 2.05340907e-02f, -1.81814432e-01f, 9.99658182e-02f, -3.93538065e-02f, -1.99292168e-01f, 2.73605604e-02f, 1.71387911e-01f, -1.28756404e-01f, -5.83615340e-02f,
  1.62217572e-01f, 1.30615532e-01f, -1.66618660e-01f, -8.70280787e-02f, 1.42465502e-01f, -1.22356184e-01f, -6.28177673e-02f, 1.32310286e-01f, 5.12576625e-02f, 8.94425660e-02f,
  -1.25739008e-01f, 6.01188391e-02f, 1.35555267e-01f, 1.41336188e-01f, 8.74879062e-02f, 1.48230910e-01f, -9.09773540e-03f, 2.37857960e-02f, 6.97504729e-02f, -2.20924109e-01f,
  1.65297136e-01f, -8.17729160e-02f, 8.44921470e-02f, -5.47695123e-02f, -1.52109861e-01f, 3.11043281e-02f, -2.13277489e-01f, -1.12735286e-01f, 1.40800416e-01f, 1.94372296e-01f,
  1.14216521e-01f, -3.25259343e-02f, -1.85444411e-02f, 1.58338055e-01f, 4.20442484e-02f, 3.39668468e-02f, 4.17768693e-04f, 2.48224125e-03f, -4.53194566e-02f, 1.89269751e-01f,
  -8.31158087e-03f, -3.08071356e-02f, -1.48522496e-01f, 6.03392050e-02f, -9.90185514e-02f, 1.40222937e-01f, -7.37281963e-02f, -1.34659022e-01f, -1.99128706e-02f, -9.53408703e-02f,
  -1.17720306e-01f, -1.19770616e-01f, -3.21295112e-03f, 3.08912992e-01f, 2.05922842e-01f, 1.76268771e-01f, 8.87902081e-02f, -1.61326826e-01f, -1.35494649e-01f, 5.73467240e-02f,
  1.22017354e-01f, 1.20646723e-01f, -1.56170338e-01f, -2.09850997e-01f, 1.57663092e-01f, 7.35007152e-02f, 3.17463219e-01f, -5.51514998e-02f, -2.51528352e-01f, -9.53830034e-02f,
  1.70384981e-02f, -1.56025842e-01f, 7.28787854e-02f, 2.36569066e-02f, 2.68878378e-02f, 8.73986483e-02f, 2.88556945e-02f, -1.32879674e-01f, -8.62192810e-02f, -4.27637110e-03f,
  5.89472800e-02f, -8.13237727e-02f, -2.15028390e-01f, -1.57661483e-01f, 8.44835788e-02f, 8.07134658e-02f, -2.75165904e-02f, 4.02100235e-02f, 4.89830375e-02f, -7.76632801e-02f,
  2.07753107e-01f, -1.11260571e-01f, -8.13718513e-02f, 1.64787814e-01f, 3.71467210e-02f, 2.57868692e-02f, 2.01196924e-01f, -9.98960529e-03f, 1.01802796e-01f, 2.40765736e-01f,
  -7.34244809e-02f, -6.73309192e-02f, -1.25857452e-02f, 1.57575980e-02f, 1.16786584e-02f, 3.78112271e-02f, 2.09054396e-01f, -5.73542379e-02f, 6.80172071e-02f, 1.67219415e-01f,
  2.69183069e-02f, 2.67354012e-01f, -1.44163445e-01f, 8.01767409e-02f, -2.01044697e-02f, -8.46841782e-02f, 3.26591104e-01f, 2.59086519e-01f, -1.09910510e-01f, 5.86313605e-02f,
  1.13862231e-01f, -1.73526511e-01f, 2.08077841e-02f, 2.49166936e-01f, 6.52962700e-02f, -5.75704910e-02f, 7.23215640e-02f, 1.01860128e-01f, 4.83334176e-02f, -6.87805470e-03f,
  1.18106648e-01f, 4.79616761e-01f, -1.55254722e-01f, 1.47797288e-02f, 2.92783007e-02f, -5.27742915e-02f, -1.19106151e-01f, -1.22062221e-01f, -4.17371914e-02f, 1.52421787e-01f,
  3.73867713e-02f, -1.04312532e-01f, 7.05692843e-02f, -1.52511418e-01f, -1.36340126e-01f, 3.22274864e-02f, -6.00749888e-02f, 1.24739364e-01f, -2.23926585e-02f, 8.33915100e-02f,
  2.01248820e-03f, 7.04980493e-02f, 1.32899642e-01f, -1.49505079e-01f, 2.11554930e-01f, 1.03840627e-01f, -8.68703425e-03f, -1.23351417e-01f, -2.04839022e-03f, -1.56456426e-01f,
  1.59971528e-02f, -1.27731964e-01f, 1.35192811e-01f, -1.79396272e-01f, -2.03597788e-02f, 1.27769753e-01f, 2.27581009e-01f, 1.29894480e-01f, 3.29343267e-02f, -2.03830898e-01f,
  2.65015334e-01f, 1.51119739e-01f, 1.25679612e-01f, 4.29320447e-02f, 9.41898897e-02f, 1.29568964e-01f, -3.82533707e-02f, 1.28804937e-01f, -2.68432163e-02f, -5.57643212e-02f,
  2.47463986e-01f, -1.65035009e-01f, -2.19614461e-01f, -2.49066681e-01f, -2.24659890e-01f, -9.74245667e-02f, 1.84994396e-02f, -8.79532192e-03f, -2.60147125e-01f, 4.77847047e-02f,
  4.69805039e-02f, 3.63398790e-01f, 9.21051577e-02f, -6.51014969e-02f, -1.17158256e-01f, 3.02281976e-01f, 1.95181854e-02f, 2.91628033e-01f, -2.51979753e-02f, -1.67823955e-02f,
  -4.32193885e-03f, 7.25892335e-02f, -1.04019672e-01f, 1.24690652e-01f, -1.44802239e-02f, -1.05817728e-02f, 1.03423700e-01f, 1.01258859e-01f, 3.66181768e-02f, 1.19171450e-02f,
  -1.24586299e-01f, 9.35362354e-02f, -2.89015900e-02f, 1.03797745e-02f, -9.68843624e-02f, 1.46087229e-01f, 5.08651249e-02f, -4.54150047e-03f, -7.04213157e-02f, 4.81918231e-02f,
  -8.57922286e-02f, -2.98845898e-02f, -2.62785167e-01f, -1.50714606e-01f, -1.26601204e-01f, -9.34908923e-04f, 6.11902354e-03f, -8.35821107e-02f, 1.53091937e-01f, -1.14345565e-01f,
  1.42887697e-01f, 2.69570109e-02f, -5.16587775e-03f, 2.79530361e-02f, 7.29166567e-02f, -3.85522805e-02f, -9.29683894e-02f, 3.55883827e-03f, 1.92040391e-02f, -9.47596040e-03f,
  1.09908348e-02f, 3.18522416e-02f, -7.62028620e-02f, 1.56407967e-01f, 3.19766104e-02f, -7.80403465e-02f, -1.33120090e-01f, -2.05835670e-01f, -1.47132367e-01f, -1.42837405e-01f,
  -3.36358488e-01f, 1.11581601e-01f, 1.07861049e-01f, 2.61759341e-01f, -2.85125345e-01f, 2.50844546e-02f, 9.14769545e-02f, 7.42878988e-02f, 1.61882579e-01f, 1.20253786e-01f,
  -2.45438684e-02f, -2.26857603e-01f, 2.34494880e-01f, 3.37771215e-02f, 1.08954534e-01f, -8.28815177e-02f, 6.12385047e-04f, 1.65471911e-01f, 1.30399108e-01f, 2.13712286e-02f,
  -9.00124535e-02f, 3.98569591e-02f, 1.06683761e-01f, -8.38537738e-02f, 2.41624609e-01f, -2.70363539e-01f, -5.19806594e-02f, -4.53112163e-02f, -9.84563958e-03f, 1.08405098e-01f,
  -1.25225350e-01f, -1.23414829e-01f, -7.11806640e-02f, 1.99499307e-03f, -1.29967798e-02f, 1.61224931e-01f, -1.49216786e-01f, -1.88231826e-01f, -9.11501646e-02f, 3.30504067e-02f,
  1.26705766e-01f, 1.12390868e-01f, -4.66117226e-02f, 9.27169546e-02f, -3.52218747e-02f, -2.73140855e-02f, 1.34909317e-01f, 9.37416181e-02f, 1.08794674e-01f, -9.66876280e-03f,
  7.44434968e-02f, 1.10000081e-01f, 4.54102643e-02f, -2.58202385e-02f, -2.87389699e-02f, 5.04465774e-02f, 5.03210239e-02f, -1.87212601e-01f, 3.17049354e-01f, -2.80993491e-01f,
  9.06237587e-03f, 1.19531238e-02f, 4.60218973e-02f, -1.13423280e-01f, -6.43569976e-02f, -9.55386236e-02f, 9.97641757e-02f, -3.24012578e-01f, -4.18673716e-02f, 1.66304022e-01f,
  -1.25452191e-01f, 6.90607950e-02f, 1.01776466e-01f, -1.24233402e-01f, 1.81798950e-01f, -5.12639470e-02f, 1.39377341e-01f, 5.76117076e-02f, 9.34851021e-02f, -8.89579505e-02f,
  7.27031007e-02f, 3.43995132e-02f, -5.57267815e-02f, 6.49689212e-02f, 5.39155938e-02f, -1.95274521e-02f, -9.52562764e-02f, -1.45984098e-01f, 1.76786080e-01f, 1.56167775e-01f,
  7.58967176e-02f, 1.65300161e-01f, 5.40859178e-02f, -1.16357647e-01f, 2.07070306e-01f, 1.01392521e-02f, -1.38962397e-03f, -1.83698341e-01f, -7.25740418e-02f, 6.01298884e-02f,
  -1.57704338e-01f, -4.20005694e-02f, 8.99655744e-02f, 2.39735972e-02f, 4.82722465e-03f, 9.68892220e-03f, -6.08233549e-02f, 2.18692467e-01f, 1.34371325e-01f, -1.27241522e-01f,
  3.84037718e-02f, -1.15464069e-01f, 4.23782170e-02f, 5.49778016e-03f, -2.66540181e-02f, 5.84964044e-02f, 1.44863203e-01f, -1.43140882e-01f, 8.16233009e-02f, 6.34332374e-02f,
  5.33785261e-02f, 5.54105677e-02f, -3.16699147e-01f, -2.99063683e-01f, 1.70258456e-04f, -3.83751988e-02f, -6.51412904e-02f, 8.32937658e-02f, 2.89720714e-01f, -1.17974311e-01f,
  -1.92655981e-01f, 4.82599102e-02f, 3.00156415e-01f, 2.79146992e-02f, -9.36929435e-02f, -1.73414886e-01f, -2.49331996e-01f, -4.23810065e-01f, 2.42297980e-03f, 2.35050738e-01f,
  -2.13460460e-01f, 1.30433485e-01f, -1.33828446e-02f, -7.39688799e-02f, 1.45724952e-01f, -1.32132456e-01f, 1.13321699e-01f, 2.10811034e-01f, -1.22959740e-01f, 4.70104516e-02f,
  3.43713872e-02f, 1.00175850e-01f, -2.38305867e-01f, 1.01035096e-01f, 3.59738246e-02f, -1.26933232e-01f, -1.42169744e-02f, -1.31065503e-01f, 1.04221866e-01f, 1.00015238e-01f,
  -2.11469144e-01f, 9.81955752e-02f, 7.53896981e-02f, -1.38367778e-02f, 1.08367346e-01f, 9.75881368e-02f, -1.19286619e-01f, -3.53808254e-02f, -7.17762299e-03f, -6.22611977e-02f,
  8.88425186e-02f, -1.19880792e-02f, 2.25823075e-02f, 1.19081043e-01f, 1.54602332e-02f, -1.02316014e-01f, 1.49769381e-01f, -4.94866595e-02f, 1.33966997e-01f, 6.65342286e-02f,
  -5.48407435e-02f, -1.11796245e-01f, 5.29733300e-02f, -1.82603132e-02f, -6.99575990e-02f, -5.99961914e-02f, 2.46437550e-01f, -1.28653599e-02f, 2.37013604e-02f, 1.56512871e-01f,
  -2.71901488e-02f, -2.03961387e-01f, -2.02309247e-02f, 5.05782776e-02f, -1.25059888e-01f, 6.08542189e-02f, -2.03615665e-01f, 2.63392180e-02f, 1.29823923e-01f, 7.69666880e-02f,
  2.04658762e-01f, 1.48556858e-01f, 2.11987365e-02f, 8.39925408e-02f, 1.84551641e-01f, 1.08436987e-01f, -9.13034528e-02f, -5.95410704e-04f, 6.94519728e-02f, 2.04707712e-01f,
  3.64336446e-02f, 1.80316102e-02f, -5.16291559e-02f, -9.04051773e-03f, -4.71797362e-02f, 5.33698350e-02f, 2.37097070e-02f, -2.34874766e-02f, 1.66545510e-01f, 1.94432754e-02f,
  -1.30504876e-01f, 2.02619210e-01f, 7.15620145e-02f, 2.57749613e-02f, 1.04714945e-01f, -4.86851893e-02f, -1.41778022e-01f, 1.80092156e-01f, -2.70764232e-01f, -1.54669657e-02f,
  -6.22393517e-03f, 5.27290292e-02f, 5.30916527e-02f, 3.07176542e-02f, 2.76229195e-02f, -7.52115902e-03f, 1.79291621e-01f, -4.89729922e-03f, -3.59026864e-02f, -7.16614053e-02f,
  -1.95151567e-02f, 1.69729009e-01f, 1.74648061e-01f, 9.34130847e-02f, 1.62634581e-01f, 1.27529532e-01f, 8.03015009e-02f, 1.02319740e-01f, 6.35276809e-02f, 9.03874189e-02f,
  1.14237599e-01f, -2.28158340e-01f, -1.24375835e-01f, -2.17755258e-01f, 6.23996146e-02f, 1.20905407e-01f, -7.82250986e-03f, 6.82290867e-02f, -1.28363431e-01f, -1.35640511e-02f,
  7.98866004e-02f, 1.15967467e-01f, -7.47808442e-02f, -5.14933327e-03f, -5.81632890e-02f, 1.64228380e-01f, 2.25381017e-01f, 2.53915954e-02f, 7.21784607e-02f, 8.59879553e-02f,
  6.36646233e-04f, -4.92388383e-03f, -4.79368456e-02f, 2.64771953e-02f, 6.34343028e-02f, -1.01300545e-01f, 4.48548570e-02f, 1.09869823e-01f, 1.33539468e-01f, -4.12607417e-02f,
  2.13870168e-01f, -7.01300427e-02f, 5.13627417e-02f, -8.07092488e-02f, -4.00795899e-02f, 1.12625264e-01f, 7.23689273e-02f, -1.21513471e-01f, -1.12263136e-01f, -2.32429132e-02f,
  8.98605511e-02f, 1.02997102e-01f, -1.33167744e-01f, -1.73651576e-01f, 2.59549376e-02f, -2.33316422e-01f, 1.01828292e-01f, -8.20466727e-02f, -1.09203957e-01f, 4.26225476e-02f,
  9.23823118e-02f, -7.91583136e-02f, -2.35463195e-02f, 2.31751315e-02f, 1.64302975e-01f, -9.80663896e-02f, -5.61638065e-02f, 7.42678642e-02f, 1.36432841e-01f, 3.33189964e-02f,
  1.28953546e-01f, 2.32437421e-02f, 3.23262550e-02f, -3.78541537e-02f, 4.33386862e-01f, 4.34126072e-02f, -2.34355181e-02f, -1.58961311e-01f, -3.41376990e-01f, 3.94370873e-03f,
  -4.58112173e-03f, 9.01819915e-02f, -1.29538581e-01f, -3.13239366e-01f, 1.59879461e-01f, 3.65928143e-01f, -2.90722717e-02f, 6.07107989e-02f, 1.03625581e-01f, 4.01148945e-01f,
  -3.77082080e-02f, 2.20826045e-01f, 5.81600517e-02f, -8.54297131e-02f, 6.02592677e-02f, -1.14311472e-01f, 1.15563802e-01f, 1.96917415e-01f, -3.71979130e-03f, -1.22307613e-01f,
  5.25867119e-02f, -1.58766970e-01f, -6.43532444e-03f, -4.22990648e-03f, -1.69525087e-01f, 3.49347666e-02f, 1.33040726e-01f, 1.21763483e-01f, -1.35038540e-01f, 1.39327660e-01f,
  2.27942765e-01f, 2.81197652e-02f, -3.25895920e-02f, -1.16404807e-02f, -7.91479126e-02f, -5.58166355e-02f, -1.21658020e-01f, -1.09100126e-01f, -4.28659730e-02f, -6.38175756e-02f,
  2.05781505e-01f, 8.80425349e-02f, -7.06349239e-02f, 1.48458228e-01f, -1.23708114e-01f, 1.48102701e-01f, 6.97721681e-03f, 1.84196800e-01f, 1.02084279e-01f, -1.39364496e-01f,
  -2.45526396e-02f, 5.17996252e-02f, 5.72643206e-02f, -1.54874399e-01f, -2.46321455e-01f, -8.74070749e-02f, 1.17310680e-01f, -1.25514030e-01f, 1.64206743e-01f, -2.28699133e-01f,
  2.00609565e-01f, 2.45148409e-02f, -1.20361596e-01f, 8.76906738e-02f, -8.51782113e-02f, -1.96905717e-01f, 4.31525037e-02f, -3.13437909e-01f, -8.86559207e-03f, 1.06005721e-01f,
  -6.51193261e-02f, 1.87785607e-02f, 9.79574025e-02f, 4.78879288e-02f, 1.01846829e-01f, -9.01987329e-02f, -1.16894975e-01f, 1.34136016e-02f, -1.60184950e-02f, 1.12758718e-01f,
  6.83780983e-02f, 1.17097721e-02f, 2.14590076e-02f, 1.09061390e-01f, 1.40461087e-01f, 5.37535921e-02f, -4.74106707e-02f, 1.21506326e-01f, -7.49852657e-02f, 7.19249994e-02f,
  1.21641040e-01f, 1.26240715e-01f, -9.41115767e-02f, 1.89351048e-02f, 8.99661183e-02f, 7.02090736e-04f, -8.51514041e-02f, -2.15901490e-02f, -1.88386172e-01f, -2.50171730e-03f,
  -3.84950191e-02f, 8.09716582e-02f, 3.68993636e-03f, -5.03401160e-02f, 1.24734908e-01f, -1.33615248e-02f, -5.51168434e-02f, 4.95670773e-02f, 3.80736366e-02f, 1.26988724e-01f,
  4.76894807e-03f, 2.47529484e-02f, -5.23137487e-02f, 7.60592818e-02f, -8.76893476e-02f, -3.45188938e-02f, -1.58212945e-01f, -9.25810784e-02f, -6.09017052e-02f, 8.31920728e-02f,
  -2.24562034e-01f, -1.25319213e-01f, -6.04709517e-03f, -2.72940129e-01f, 1.65947247e-02f, 4.88540232e-02f, -2.86577821e-01f, -2.49822751e-01f, -1.24334894e-01f, -8.95455033e-02f,
  -1.60067394e-01f, -3.42003219e-02f, 8.68161917e-02f, 1.24651797e-01f, 2.36711681e-01f, 9.80043411e-03f, 7.83240050e-02f, -1.33550039e-03f, -2.86153294e-02f, -1.54825416e-03f,
  -1.47951469e-01f, -1.30947292e-01f, 1.09516330e-01f, 1.08116508e-01f, 1.98137183e-02f, 8.32649395e-02f, 3.91857997e-02f, -1.67758968e-02f, -5.78915961e-02f, -6.18132986e-02f,
  -8.73100832e-02f, 1.99112594e-02f, -4.82086837e-02f, -2.31444389e-01f, 5.32940030e-02f, -1.11692689e-01f, -1.98366091e-01f, 6.25122115e-02f, -9.22338665e-03f, 3.68349031e-02f,
  3.26010361e-02f, 6.74903914e-02f, 6.90266863e-02f, 6.12504221e-02f, -3.06871086e-01f, -9.63637680e-02f, 7.15315491e-02f, -6.38614446e-02f, -1.44773414e-02f, 1.39992207e-01f,
  2.82835402e-02f, 1.68511067e-02f, 8.10530037e-02f, -6.38092384e-02f, -7.00944662e-02f, -1.53491005e-01f, -1.33669749e-01f, 1.25948653e-01f, 7.78581649e-02f, 1.05245367e-01f,
  -4.34410246e-03f, 1.35988817e-01f, 7.25653917e-02f, -7.75117800e-02f, -5.53853177e-02f, 7.41965175e-02f, 1.01147346e-01f, 1.13103464e-02f, -1.48831218e-01f, 1.65430337e-01f,
  2.57220477e-01f, -2.00536519e-01f, 3.11193675e-01f, 2.67470896e-01f, -2.28639767e-01f, -2.04399079e-02f, 1.40246168e-01f, 1.62772790e-01f, 5.31569943e-02f, -1.74826518e-01f,
  -1.08917326e-01f, -1.22416362e-01f, -1.56042725e-01f, 3.46564651e-01f, -4.71932665e-02f, -1.96221441e-01f, -4.47919182e-02f, -2.27744989e-02f, 7.60336593e-02f, -1.25957420e-02f,
  -1.11154377e-01f, -6.34258687e-02f, -9.10691991e-02f, 5.71533628e-02f, -4.09790836e-02f, -1.16032347e-01f, -2.70290911e-01f, 1.33397445e-01f, 2.50303596e-02f, 9.12054777e-02f,
  -3.23662572e-02f, -4.88649867e-02f, 1.14965811e-01f, -3.52062993e-02f, 1.49168581e-01f, 8.99410155e-03f, 3.00031994e-02f, 6.24524131e-02f, -1.87346846e-01f, -1.24077745e-01f,
  5.08163916e-03f, 8.51026028e-02f, -9.99842063e-02f, -1.80311248e-01f, -3.15013453e-02f, -1.28092803e-03f, 8.27580243e-02f, -3.25923264e-02f, -4.21481952e-02f, 2.90907640e-02f,
  8.04657638e-02f, 1.55712485e-01f, 1.73913106e-01f, -1.46668674e-02f, 4.59738588e-03f, 9.65473279e-02f, 5.40548004e-02f, 1.15033023e-01f, -6.81240857e-03f, 1.49944708e-01f,
  -3.08285534e-01f, -2.51726836e-01f, -2.15189531e-01f, -1.34348333e-01f, -1.05257310e-01f, 2.01040596e-01f, -1.42995489e-03f, -6.09713569e-02f, 1.07702397e-01f, 1.51028275e-01f,
  1.75549373e-01f, 1.56613886e-01f, 5.40437885e-02f, 4.09709290e-02f, -1.72465369e-01f, 1.27686962e-01f, 6.50520548e-02f, 1.19657196e-01f, -7.10503310e-02f, 6.13866523e-02f,
  6.06194213e-02f, 1.32064596e-01f, -1.22172415e-01f, -2.03412939e-02f, -3.26068588e-02f, 2.83597428e-02f, 9.99353603e-02f, -2.74120774e-02f, 8.04324970e-02f, -3.14081088e-02f,
  2.59831935e-01f, -1.82135671e-01f, 1.11751497e-01f, -1.82562917e-01f, 4.26490046e-02f, 5.48823886e-02f, -1.66964442e-01f, -9.66790244e-02f, -1.33727282e-01f, 1.82437390e-01f,
  1.23953700e-01f, -1.39830470e-01f, 2.00576901e-01f, -1.60080791e-02f, -5.54000400e-02f, -2.05923304e-01f, -3.71346772e-02f, -1.34145558e-01f, -4.00476996e-03f, 1.28997236e-01f,
  -5.01337051e-02f, 5.74544678e-03f, -1.29002810e-01f, -1.09401003e-01f, 9.15598720e-02f, 2.72982623e-02f, 9.82463285e-02f, -1.66316718e-01f, 5.35493381e-02f, -1.27846628e-01f,
  -2.46574953e-02f, 3.23874019e-02f, -4.97070774e-02f, 7.94769973e-02f, 1.40605122e-01f, -1.97276488e-01f, 1.17471674e-02f, -8.26392025e-02f, -1.88481316e-01f, 1.31960765e-01f,
  2.31848061e-01f, -6.54681846e-02f, -1.45323694e-01f, -1.22126147e-01f, 1.26343086e-01f, 2.93345302e-01f, -4.01740856e-02f, 7.42108673e-02f, -1.86388299e-01f, -7.15148747e-02f,
  2.18255907e-01f, 2.76070446e-01f, 6.50897418e-05f, 1.11137383e-01f, 4.40943651e-02f, -1.16643533e-01f, 7.04544112e-02f, 1.04415506e-01f, -6.44178316e-02f, 1.40793607e-01f,
  -5.84126078e-02f, 1.18600629e-01f, 8.67820531e-02f, -1.05591021e-01f, -2.88975000e-01f, 2.45972663e-01f, 7.51302466e-02f, 1.35292917e-01f, 1.66959781e-02f, -6.38325512e-02f,
  2.23106369e-01f, -6.20659776e-02f, -3.27706663e-03f, -3.47640663e-02f, -9.73903537e-02f, -1.11916021e-01f, -3.80254723e-02f, -6.89579174e-02f, 2.93701515e-02f, 1.24981172e-01f,
  -5.45221427e-03f, 1.68769643e-01f, -5.26298247e-02f, -7.28841648e-02f, -1.94481477e-01f, -2.06541978e-02f, -1.32265165e-02f, 1.95307717e-01f, 1.54943392e-01f, 2.53913533e-02f,
  -1.69751979e-03f, -7.67674521e-02f, 1.00006610e-01f, 3.88099365e-02f, -8.72886702e-02f, -6.51979744e-02f, 6.04622625e-02f, 3.75271700e-02f, -1.15062110e-02f, 3.09101969e-01f,
  2.06922859e-01f, -7.80419856e-02f, 1.17995702e-01f, -9.00323018e-02f, -2.45170727e-01f, -9.67961028e-02f, 2.53465265e-01f, -1.51976243e-01f, -2.98830360e-01f, -1.01690196e-01f,
  7.98996314e-02f, 1.88129805e-02f, 1.82756893e-02f, 2.37910464e-01f, 6.76356778e-02f, -3.32835197e-01f, 1.19756997e-01f, 1.03719048e-01f, -6.90440387e-02f, 8.38152040e-03f,
  7.16050491e-02f, -1.63437933e-01f, -1.55725136e-01f, -1.52452752e-01f, 7.18704537e-02f, 4.40100543e-02f, -8.42320547e-02f, 6.46282593e-03f, 2.86844820e-01f, -3.16203572e-02f,
  -3.83051820e-02f, 1.05493791e-01f, 5.78603223e-02f, 3.49152386e-02f, -1.37617707e-01f, -1.74836665e-02f, 1.94623321e-01f, -5.41540235e-02f, -9.77146626e-02f, -7.50872940e-02f,
  2.27835879e-01f, -3.60714607e-02f, -8.93365145e-02f, 1.00553624e-01f, 2.47569345e-02f, -7.86885396e-02f, 5.66414371e-02f, -3.71843800e-02f, -1.25478938e-01f, 3.62181813e-02f,
  9.16730091e-02f, 9.75706428e-02f, -1.70076072e-01f, -1.53090641e-01f, -1.05720691e-01f, 8.08685198e-02f, 3.00570372e-02f, 1.47909243e-02f, -1.06545672e-01f, 4.27982584e-02f,
  -1.18779577e-02f, 3.12511213e-02f, -2.76070595e-01f, 2.36561686e-01f, 1.37954906e-01f, -2.92470232e-02f, 1.50939256e-01f, -2.68805120e-02f, -2.12720707e-02f, -4.76777554e-03f,
  2.42731906e-02f, 5.35867317e-03f, -1.20463975e-01f, -2.96670139e-01f, -1.13034301e-01f, 7.33620748e-02f, 1.11732550e-01f, -1.61859840e-01f, 1.07967407e-01f, -2.79921681e-01f,
  1.00753196e-01f, -4.88860160e-02f, 9.25891623e-02f, 1.59960482e-02f, 4.64747995e-02f, -1.41951039e-01f, 8.94996151e-03f, 1.31123543e-01f, 2.33303756e-02f, 1.29756838e-01f,
  -3.13743651e-02f, 1.98678691e-02f, 2.26320326e-01f, -1.77304238e-01f, -2.75535826e-02f, 1.13079950e-01f, 2.70954557e-02f, -1.35607302e-01f, -1.17355280e-01f, 1.28803728e-02f,
  1.47534683e-01f, -5.42160198e-02f, 3.89602706e-02f, 3.05266194e-02f, 2.84921288e-01f, 1.06095606e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.78629115e-01f, 7.02490658e-02f, 1.27761677e-01f, 9.16498527e-02f, -7.31603131e-02f, 8.81057680e-02f, 1.78729057e-01f, 1.06113270e-01f, -5.91019541e-02f, -1.23568522e-02f,
  2.12372273e-01f, 8.40379596e-02f, 1.10223703e-02f, 8.96697864e-02f, 1.77340984e-01f, 4.77878004e-02f, -1.01337001e-01f, 6.62949011e-02f, 7.93814957e-02f, -7.41963312e-02f,
  1.48685947e-01f, -7.54861534e-02f, 1.01886049e-03f, -2.82438040e-01f, -2.37204716e-01f, -8.09889510e-02f, -3.79694439e-02f, 1.97189242e-01f, -1.20331682e-01f, -3.11745033e-02f,
  2.52077878e-01f, 1.50662512e-01f, 3.40849832e-02f, 5.25103286e-02f, -3.00559010e-02f, 3.83223146e-01f, -8.86004269e-02f, 1.39214069e-01f, -7.00142980e-02f, 1.12583369e-01f,
  -3.83306332e-02f, -8.71748477e-02f, 1.02127187e-01f, 8.60097036e-02f, -1.94643233e-02f, -2.13715602e-02f, -6.61936104e-02f, -1.58756167e-01f, 1.67870382e-03f, -1.08746551e-01f,
  -7.54247978e-02f, 2.65990496e-01f, 1.31936297e-01f, 5.30592836e-02f, 7.39380810e-03f, 5.67794777e-03f, 1.33556962e-01f, -1.50805801e-01f, -1.86712351e-02f, 1.53897211e-01f,
  3.12995277e-02f, 5.00478111e-02f, 3.94316576e-02f, -1.58772066e-01f, -7.40286559e-02f, 9.83924866e-02f, 8.01785104e-03f, 9.12956819e-02f, -5.09353429e-02f, 9.85131413e-02f,
  -8.96411091e-02f, 5.50767034e-02f, 1.46229967e-01f, 4.92634997e-02f, -8.27593580e-02f, -7.50903115e-02f, 1.67330366e-03f, -2.80920789e-02f, -2.37712055e-04f, 1.28703499e-02f,
  -8.70324746e-02f, 1.99591601e-03f, -1.00109272e-01f, -2.11955085e-02f, -7.14595914e-02f, -1.24908939e-01f, -1.26248067e-02f, 1.92403104e-02f, -1.12249374e-01f, -1.09759070e-01f,
  4.15271409e-02f, 4.48022783e-02f, -1.01041317e-01f, 1.23606391e-01f, -1.97051913e-02f, -9.78109241e-03f, 5.64461760e-02f, -3.27194035e-02f, 1.37117222e-01f, 6.49544969e-03f,
  -1.41453117e-01f, 7.63218850e-02f, 5.29183587e-03f, -9.79801193e-02f, -1.16709530e-01f, -8.81708041e-02f, -1.29606918e-01f, 4.46762852e-02f, -4.87873890e-02f, 1.00232661e-01f,
  4.47394326e-02f, -9.89974663e-02f, -7.24778399e-02f, -1.03970788e-01f, -9.13645625e-02f, -1.07052796e-01f, 1.01097077e-01f, 3.05822473e-02f, -6.67008534e-02f, 1.99702173e-03f,
  2.69293580e-02f, -8.55458528e-02f, -3.24093178e-02f, 8.40951949e-02f, -6.43164217e-02f, 1.96428776e-01f, -3.86078618e-02f, 3.59017961e-03f, 2.26205923e-02f, 9.71304178e-02f,
  1.67296063e-02f, 1.01598270e-01f, -5.22357710e-02f, -6.58207759e-02f, 4.94607762e-02f, -1.19544245e-01f, 1.11682899e-02f, -7.32160956e-02f, -7.03313574e-02f, 2.89395414e-02f,
  -8.81157070e-02f, -5.89586422e-02f, -5.32030910e-02f, 6.29233494e-02f, 6.25740290e-02f, -4.00716849e-02f, -1.25551270e-02f, 1.21338084e-01f, 8.85137543e-02f, -2.43595447e-02f,
  -5.48304319e-02f, -2.76149325e-02f, -1.11342564e-01f, 2.70878524e-03f, 1.63938068e-02f, -7.21600875e-02f, 1.50646279e-02f, 1.64745338e-02f, 2.09751334e-02f, -1.03128321e-01f,
  -1.09688602e-01f, -1.27533115e-02f, -1.02819808e-01f, -9.89222452e-02f, -7.25565478e-02f, -3.53426188e-02f, -6.47976771e-02f, 5.55674583e-02f, -2.95365993e-02f, -8.06859061e-02f,
  -8.01122005e-05f, -4.16795462e-02f, 4.36146446e-02f, 1.16431303e-02f, 6.90117031e-02f, 1.13134928e-01f, -9.45043713e-02f, 4.41836752e-02f, -7.39873275e-02f, -1.21315732e-03f,
  -9.55821723e-02f, -8.19383785e-02f, -5.52871153e-02f, 4.13935333e-02f, -7.63736069e-02f, -8.73396099e-02f, -9.76052731e-02f, 6.97302148e-02f, 7.30223805e-02f, -8.19564313e-02f,
  1.83998104e-02f, -3.62148806e-02f, 1.85720935e-01f, 4.86483462e-02f, 4.87714186e-02f, 1.36597499e-01f, 9.36477538e-03f, -1.15152307e-01f, 9.67028737e-03f, 4.34484407e-02f,
  -8.07031468e-02f, -7.65648186e-02f, 4.55209725e-02f, 2.24583559e-02f, -3.36075313e-02f, 3.08548994e-02f, 1.85050935e-01f, -5.96532151e-02f, 1.40323654e-01f, -7.61477137e-03f,
  -6.72431290e-02f, -3.67395841e-02f, -3.52589041e-02f, 1.10225178e-01f, -5.85061312e-02f, -2.45716702e-03f, -2.22135186e-02f, -1.22995205e-01f, 3.18502598e-02f, 1.74086973e-01f,
  -1.75479487e-01f, 4.68632169e-02f, 1.03637222e-02f, 1.15084693e-01f, 2.01242119e-01f, -1.55889183e-01f, 1.60271496e-01f, 7.44094625e-02f, -2.14270040e-01f, 1.55645937e-01f,
  1.43883467e-01f, -1.20993756e-01f, 4.52537984e-02f, 7.04403892e-02f, -8.16897396e-03f, 1.71712205e-01f, 5.26537932e-02f, -1.45340860e-01f, 9.22113881e-02f, 3.11008319e-02f,
  -2.49538268e-03f, 6.51758090e-02f, 4.36596982e-02f, 4.46206843e-03f, -8.97440836e-02f, 4.59801182e-02f, -1.21617116e-01f, 5.92814013e-02f, -8.58631283e-02f, 3.48844491e-02f,
  5.14037684e-02f, 1.06027745e-01f, 2.92445021e-03f, 9.46497396e-02f, -1.37520820e-01f, -1.58737645e-01f, -3.71934585e-02f, 1.15543880e-01f, 1.42105445e-01f, 1.39455227e-02f,
  9.03984681e-02f, 8.08265731e-02f, -1.02078870e-01f, -1.10606074e-01f, 4.87577692e-02f, 2.52469108e-02f, -1.74946681e-01f, 2.08073929e-02f, 7.18525201e-02f, 3.21561396e-02f,
  -4.77745384e-02f, 1.28103957e-01f, 8.33452418e-02f, 2.11922266e-02f, 1.20967738e-01f, 2.70178467e-02f, -8.66508633e-02f, -6.34964034e-02f, 5.45960516e-02f, 5.11260666e-02f,
  2.34638229e-01f, -1.57079950e-01f, 2.09417656e-01f, 1.45081550e-01f, -1.90075487e-01f, 4.48272638e-02f, -7.52254203e-02f, -1.08757399e-01f, 5.26133142e-02f, -1.21971235e-01f,
  -1.69225872e-01f, -2.48669222e-01f, 1.11070871e-01f, 1.49798051e-01f, 2.44052522e-02f, -1.25971362e-01f, -8.21583569e-02f, 3.09391338e-02f, -1.15914404e-01f, -2.87482422e-02f,
  1.04060434e-01f, 1.28194660e-01f, -1.27894834e-01f, 7.95377120e-02f, -8.23379904e-02f, -3.19879944e-03f, -5.05645685e-02f, -1.03515089e-01f, -3.16063389e-02f, 4.76803519e-02f,
  1.33132767e-02f, -7.03431219e-02f, -5.75140566e-02f, 4.68485206e-02f, 7.00117722e-02f, -6.98615536e-02f, 1.58152297e-01f, 5.97636774e-02f, 1.64532498e-01f, 3.31122354e-02f,
  2.48146877e-01f, 1.43485159e-01f, 1.33543864e-01f, 3.04899424e-01f, 5.00049219e-02f, 7.82103464e-02f, 1.38860688e-01f, 1.67894065e-01f, -2.98499707e-02f, 2.44395837e-01f,
  3.22375633e-02f, 1.24087013e-01f, 1.03971809e-01f, 1.56402022e-01f, 5.18787466e-02f, 1.76269561e-01f, 9.17067826e-02f, 8.29380080e-02f, -2.13731956e-02f, -8.19412321e-02f,
  3.24554682e-01f, 4.39838797e-01f, -9.49612111e-02f, -8.99518095e-03f, 3.23732704e-01f, -2.79038310e-01f, -2.95470297e-01f, 7.21651316e-02f, 3.11798882e-02f, 7.36084804e-02f,
  -4.48525190e-01f, -2.39109308e-01f, 2.49160960e-01f, 3.57963741e-02f, 2.81844765e-01f, 3.90045464e-01f, -8.56284127e-02f, -2.59137809e-01f, 3.64217818e-01f, -1.63944170e-01f,
  -3.09422351e-02f, 5.81167974e-02f, 2.50092931e-02f, 3.92674580e-02f, 7.45918276e-03f, -2.30442286e-01f, -8.42810795e-03f, -1.21399164e-01f, -5.88066243e-02f, 4.10896465e-02f,
  3.80761534e-01f, -1.38938025e-01f, -5.22509683e-03f, -2.77605057e-02f, -1.18719235e-01f, 2.84726948e-01f, 6.85298219e-02f, 6.13863394e-02f, 3.59306425e-01f, 7.20425183e-03f,
  -3.32856700e-02f, 2.27710247e-01f, 6.85457187e-03f, -2.66205519e-02f, -6.90704137e-02f, -7.08223656e-02f, 3.75867523e-02f, 1.46709159e-01f, -5.85407503e-02f, 6.25427887e-02f,
  -2.83013098e-02f, 1.27493525e-02f, 1.12355694e-01f, 4.00967374e-02f, 1.47599369e-01f, -1.16158783e-01f, -1.63045973e-02f, 1.51925227e-02f, -8.19383487e-02f, -5.06931767e-02f,
  1.27736732e-01f, -5.46175949e-02f, -9.19251665e-02f, 1.69521719e-02f, -3.46828960e-02f, -1.40570506e-01f, 8.63938704e-02f, 3.81468721e-02f, 3.36801037e-02f, 4.56595533e-02f,
  -7.37271309e-02f, -1.39087915e-01f, -3.15288156e-02f, 1.16160199e-01f, -8.47939774e-02f, 1.40068144e-01f, 1.64726209e-02f, -5.29850833e-02f, -1.07266195e-01f, -1.09006725e-01f,
  -5.41071221e-02f, 1.07920296e-01f, -6.02440201e-02f, -1.10096842e-01f, 3.52449790e-02f, 3.17962877e-02f, -7.27731064e-02f, 7.71632465e-03f, 2.90091475e-03f, 8.30340609e-02f,
  1.25055417e-01f, 1.22344177e-02f, 2.74808258e-02f, 4.03776430e-02f, -1.81882679e-02f, -3.56544554e-02f, 1.02388419e-01f, -1.09704264e-01f, 4.49294671e-02f, 1.85392238e-02f,
  3.06494832e-02f, -8.20535570e-02f, 5.76056130e-02f, 7.68800676e-02f, 1.11144766e-01f, 3.51401083e-02f, 1.29264861e-01f, 1.13485716e-01f, -2.54559591e-02f, -3.73908058e-02f,
  -8.06682706e-02f, -4.52766977e-02f, 8.96080583e-02f, -7.80533850e-02f, 5.11565357e-02f, 7.98304752e-02f, 5.33590205e-02f, 6.48359135e-02f, 4.28286120e-02f, 8.02514404e-02f,
  5.52653968e-02f, 9.09276828e-02f, -6.00277632e-02f, -8.13297834e-03f, -1.03809580e-01f, 7.09173232e-02f, 1.30234733e-01f, -8.28657672e-02f, 8.02252069e-02f, 4.99645695e-02f,
  -1.38697416e-01f, -2.86292303e-02f, 4.00758237e-02f, -1.83255300e-02f, -1.26997709e-01f, 8.86791199e-02f, -2.12976281e-02f, 8.25949237e-02f, -1.11679144e-01f, 5.52993193e-02f,
  1.50981009e-01f, 7.89981782e-02f, 9.49536785e-02f, 1.16105475e-01f, -7.59064332e-02f, -1.02211144e-02f, -3.61366197e-02f, -1.14327319e-01f, -4.72671315e-02f, 9.93159339e-02f,
  -1.01714619e-01f, 1.17525637e-01f, 5.46333157e-02f, -1.66513205e-01f, -8.53110850e-02f, 8.09882209e-02f, 5.84424585e-02f, -2.68034358e-02f, 1.67802516e-02f, -3.69287878e-02f,
  -9.24438462e-02f, 1.99878588e-02f, -1.65914651e-02f, -1.35164177e-02f, 1.15040585e-01f, 1.70955230e-02f, 1.64513037e-01f, -1.13261053e-02f, -5.16934204e-04f, -2.25817394e-02f,
  -1.08951025e-01f, -1.02588153e-02f, 2.26260326e-03f, 1.03915490e-01f, -1.07631117e-01f, 3.99521030e-02f, 1.12923831e-01f, -7.44732916e-02f, -1.53646335e-01f, 4.15071957e-02f,
  -1.08367838e-01f, 8.16690549e-02f, 1.98530080e-03f, 9.51817725e-04f, -1.09247158e-04f, 4.69995774e-02f, 1.30498841e-01f, 3.68335098e-02f, -1.05704077e-01f, -5.14500812e-02f,
  9.42584425e-02f, 1.24780528e-01f, -5.39409369e-02f, 8.97744223e-02f, -3.58598940e-02f, -4.68370831e-03f, 4.42388467e-02f, 8.39825422e-02f, 9.95295122e-03f, 1.64136458e-02f,
  -1.50421495e-02f, 7.94642717e-02f, 3.01909540e-02f, -1.13966288e-02f, -9.15898941e-03f, 2.26826705e-02f, -5.94527647e-02f, -1.68749124e-01f, -4.70875204e-02f, 1.10114142e-02f,
  3.94017100e-02f, -1.22758217e-01f, 2.85906140e-02f, -5.52683063e-02f, 1.29173149e-03f, 1.11702673e-01f, -3.51780392e-02f, -2.28923503e-02f, 4.05860506e-03f, 1.56920459e-02f,
  -9.68921632e-02f, 3.29987705e-02f, -1.09789474e-02f, 1.12893037e-01f, -9.67279226e-02f, -7.84552917e-02f, 7.98266307e-02f, -1.13896757e-01f, -9.44745094e-02f, -7.02481866e-02f,
  9.88039300e-02f, -5.46868891e-04f, 4.14590240e-02f, 4.06604633e-02f, 2.79990077e-01f, -1.60977393e-02f, 2.14315102e-01f, 1.89432099e-01f, -4.73950803e-02f, -3.84641886e-02f,
  -9.20165926e-02f, -1.29861683e-02f, 1.10256255e-01f, 2.56365031e-01f, 1.18755817e-01f, 1.10181449e-02f, 1.51619479e-01f, 1.49856895e-01f, 1.76805019e-01f, 1.93787038e-01f,
  2.13861279e-02f, 6.86162785e-02f, 2.23925173e-01f, 1.55047968e-03f, 9.25182849e-02f, 6.10248223e-02f, -8.03582277e-03f, -1.41222477e-01f, -6.82283118e-02f, -2.87998587e-01f,
  -3.03629011e-01f, -1.30492732e-01f, 2.23915670e-02f, 2.74735898e-01f, -2.60246277e-01f, -3.56686115e-02f, 3.05683017e-01f, 2.71260202e-01f, 1.58666566e-01f, 5.86024625e-03f,
  -2.04380035e-01f, 2.43845299e-01f, -1.86939523e-01f, 1.86714172e-01f, -1.35799929e-01f, -2.14280542e-02f, -5.23773283e-02f, 1.03025109e-01f, -7.04212114e-02f, 1.06868923e-01f,
  -7.79980719e-02f, -9.26130116e-02f, 1.00900702e-01f, -1.00166589e-01f, -1.30797938e-01f, -3.14631909e-02f, -9.80786458e-02f, 2.14104265e-01f, -1.04508258e-01f, -1.05773188e-01f,
  -4.74067517e-02f, 1.16200320e-01f, 9.16230008e-02f, -5.22613302e-02f, -7.97532722e-02f, 2.16067269e-01f, -8.86002108e-02f, 8.30853581e-02f, -7.95499459e-02f, -2.10320950e-01f,
  -6.83544502e-02f, 1.62658423e-01f, 1.05510809e-01f, 1.02211826e-01f, 1.27571821e-01f, 1.31294489e-01f, 1.79812923e-01f, 7.99598843e-02f, -5.13864420e-02f, -9.19111297e-02f,
  6.08663261e-02f, -5.41450791e-02f, 4.62842546e-02f, 4.67534289e-02f, -1.16704004e-02f, 9.18269828e-02f, 1.08241603e-01f, -3.21037024e-02f, 1.54812664e-01f, -7.19455332e-02f,
  -1.79804638e-01f, -2.30378732e-02f, 6.22226708e-02f, -3.93881649e-02f, 1.59597257e-03f, -3.72395362e-03f, 5.62285930e-02f, 1.81581378e-01f, -1.24488302e-01f, 2.03161493e-01f,
  -1.42516633e-02f, -1.71003193e-01f, 9.54337120e-02f, 8.79673809e-02f, 8.17318931e-02f, 1.34549215e-01f, -1.70684785e-01f, -1.46372959e-01f, -1.38013093e-02f, -8.85485932e-02f,
  3.53998207e-02f, 5.55647090e-02f, 1.20333964e-02f, -6.80248812e-02f, -4.95740995e-02f, 5.11155911e-02f, -1.70199443e-02f, -7.65830055e-02f, -2.30125319e-02f, -9.43582207e-02f,
  1.44000039e-01f, -9.02141333e-02f, 4.63001803e-02f, -1.35182068e-01f, 4.90025152e-03f, 1.33826837e-01f, -9.86399278e-02f, -4.00512852e-03f, -1.02068046e-02f, 2.50349157e-02f,
  4.53744456e-02f, 3.28433216e-02f, -4.43529189e-02f, -8.01100507e-02f, 1.97524458e-01f, 1.09222390e-01f, 7.86076114e-03f, 1.17262952e-01f, 1.36779308e-01f, -6.17839247e-02f,
  -7.27670416e-02f, 2.98919404e-05f, 4.00526077e-02f, 1.07484944e-01f, 6.63216338e-02f, 1.08952492e-01f, 2.54159659e-01f, 2.63053030e-01f, 2.07860887e-01f, 2.08259240e-01f,
  2.10515991e-01f, 3.15539353e-02f, -7.65854046e-02f, 1.49235442e-01f, 2.27915823e-01f, 6.83569312e-02f, -8.11608136e-02f, 2.39062130e-01f, 3.49759519e-01f, -3.16872388e-01f,
  3.32855791e-01f, 1.99230522e-01f, -1.93119213e-01f, 7.46842027e-02f, -1.81171894e-01f, 1.12580322e-01f, -6.64069578e-02f, -1.01484604e-01f, -5.38447648e-02f, 1.06855631e-01f,
  -5.18151559e-02f, 2.31547534e-01f, 1.30273178e-01f, -4.11251262e-02f, 1.27025079e-02f, 6.02438636e-02f, -6.82443231e-02f, 1.40399411e-01f, 1.57525931e-02f, -3.96389328e-02f,
  7.67049938e-02f, -3.87097783e-02f, -7.89719447e-03f, -6.45464137e-02f, -6.48978204e-02f, 1.44636080e-01f, 2.16422100e-02f, 3.14659886e-02f, 1.04436381e-02f, -2.22544000e-02f,
  6.02292977e-02f, 9.84189659e-03f, 1.07752077e-01f, -8.49287212e-02f, 2.64729792e-03f, 2.27294832e-01f, -2.63799995e-01f, 4.32578325e-02f, -3.83132184e-03f, 2.53936611e-02f,
  -9.34862718e-03f, 5.82407415e-02f, -8.01059827e-02f, 1.25035435e-01f, 9.22440588e-02f, -6.56315610e-02f, -2.50244271e-02f, -1.05900228e-01f, -8.26226175e-02f, -5.48142157e-02f,
  -4.11665291e-02f, 5.85893393e-02f, -3.91480103e-02f, -6.75464198e-02f, -2.50453111e-02f, -4.75679822e-02f, -3.50378491e-02f, 7.53149092e-02f, 1.33373281e-02f, 8.27602744e-02f,
  -8.41126740e-02f, -3.22838090e-02f, -1.22579798e-01f, -6.33564070e-02f, 5.46238087e-02f, -2.15349402e-02f, 8.64707585e-03f, -3.48973796e-02f, 6.05007336e-02f, 9.01081972e-03f,
  3.79580483e-02f, 3.25128138e-02f, -1.28766209e-01f, -3.87385152e-02f, -1.26769215e-01f, -6.48785084e-02f, -7.44747892e-02f, 1.08716525e-01f, -8.42252001e-02f, -1.21334055e-02f,
  1.37469530e-01f, -6.46298900e-02f, -6.99172318e-02f, 1.07904404e-01f, 1.40846446e-02f, -1.84785277e-02f, 8.65211487e-02f, 1.10877782e-01f, 1.43548310e-01f, -8.05648789e-02f,
  -5.61768785e-02f, -4.42519896e-02f, -6.26657680e-02f, -1.11282870e-01f, -7.55788386e-02f, -5.71570434e-02f, -4.32454757e-02f, 7.57643878e-02f, -2.13247929e-02f, 5.65327555e-02f,
  2.86015328e-02f, 8.96402523e-02f, -4.20085527e-02f, 1.58158481e-01f, -5.23319980e-03f, -4.55829576e-02f, -5.95179871e-02f, 1.19540893e-01f, -2.65088435e-02f, 1.35913730e-01f,
  -6.06947243e-02f, 1.55992076e-01f, 4.65840511e-02f, -8.57179016e-02f, 3.21134888e-02f, 1.33326212e-02f, 1.56069174e-01f, -6.02011755e-02f, 2.67809648e-02f, 1.81879699e-01f,
  1.29102068e-02f, -8.58747512e-02f, -2.84383055e-02f, -2.91441791e-02f, 1.69250414e-01f, 1.51452631e-01f, -1.64885148e-01f, -6.03543855e-02f, -4.59837765e-02f, -1.37246400e-01f,
  -5.03622293e-02f, -2.47617234e-02f, 5.90453446e-02f, 8.40618461e-02f, 1.05104268e-01f, 8.76859725e-02f, -1.02124196e-02f, -3.95875722e-02f, -5.55046722e-02f, -2.00602636e-02f,
  5.29738963e-02f, -4.27828133e-02f, 8.59161094e-02f, 6.50485605e-02f, 8.90289471e-02f, -7.38724396e-02f, -6.52869046e-02f, -4.20505628e-02f, 6.16873465e-02f, 8.67051110e-02f,
  5.97694963e-02f, -7.29808360e-02f, -2.75812186e-02f, -9.07512680e-02f, 7.79001564e-02f, 7.54398257e-02f, -7.36976936e-02f, 1.37765497e-01f, 1.07168682e-01f, -8.02088678e-02f,
  -2.00947858e-02f, -4.44911681e-02f, -7.73004373e-04f, 1.93258017e-01f, 1.27321228e-01f, 1.15248390e-01f, 3.73496413e-02f, -2.34753985e-04f, 1.54853076e-01f, 1.07481286e-01f,
  -1.20365642e-01f, 1.88164152e-02f, 2.40225390e-01f, 1.73511356e-02f, 7.01169893e-02f, -1.11394010e-01f, -8.22643936e-02f, 2.01297924e-01f, -9.86349285e-02f, -1.31333685e-02f,
  -1.86967235e-02f, 2.14378804e-01f, 1.69621259e-02f, -5.41668124e-02f, -6.88458532e-02f, 1.59500167e-01f, -9.73487794e-02f, 4.30090241e-02f, -1.93985194e-01f, -2.47501239e-01f,
  1.73290044e-01f, 1.29213244e-01f, -1.23154543e-01f, 1.93335816e-01f, 1.12764768e-01f, 1.76160529e-01f, 1.37645558e-01f, 7.89519772e-03f, 4.78821546e-02f, -4.86282818e-03f,
  4.67775539e-02f, 2.00767383e-01f, -1.22086249e-01f, 1.87748875e-02f, 1.18639074e-01f, -8.80574211e-02f, -1.58782136e-02f, 1.40003720e-02f, 3.11364960e-02f, -7.36794546e-02f,
  3.57509144e-02f, -1.00911804e-01f, -6.73026964e-03f, -4.54703532e-02f, -6.18934631e-02f, 7.53606930e-02f, 2.26148099e-01f, -3.98012586e-02f, -1.46760359e-01f, -1.13095410e-01f,
  -6.03097416e-02f, 8.44741613e-03f, -5.67618646e-02f, -2.80337054e-02f, 1.25528336e-01f, 1.68548092e-01f, 5.08421101e-03f, -3.36895101e-02f, 2.81915575e-01f, -1.43772364e-02f,
  -3.31262909e-02f, 9.01613161e-02f, 2.83214729e-02f, -6.05445467e-02f, -5.33736125e-02f, 1.24574348e-01f, 2.69767046e-01f, 2.73001850e-01f, -8.46733619e-03f, 1.46556109e-01f,
  1.49245188e-01f, 2.78430730e-01f, 1.49119776e-02f, -1.03929844e-02f, 8.10412243e-02f, 1.37292117e-01f, -3.09700109e-02f, 7.15027303e-02f, 1.93684503e-01f, 9.56473425e-02f,
  -2.70132124e-01f, 1.51831314e-01f, -2.89871603e-01f, -3.74126971e-01f, -1.19820282e-01f, 3.33764493e-01f, -9.74308625e-02f, 8.44245031e-03f, 1.13903843e-01f, 1.73092619e-01f,
  1.34303465e-01f, -1.58516601e-01f, 1.46175697e-01f, 1.10891104e-01f, -1.48600012e-01f, 2.21745998e-01f, -1.39892772e-01f, -3.22921164e-02f, -1.43953860e-01f, 5.25027439e-02f,
  2.79409438e-02f, -9.98098627e-02f, 1.90008551e-01f, 1.51945008e-02f, 1.25687256e-01f, 5.52082881e-02f, -1.76108897e-01f, 1.43495247e-01f, 1.46517187e-01f, -1.01170138e-01f,
  2.37197757e-01f, 8.68240148e-02f, -5.42614684e-02f, -1.42670706e-01f, -8.03423896e-02f, 8.96572992e-02f, -2.23837063e-01f, -3.68888155e-02f, -3.73938493e-02f, 2.69610196e-01f,
  1.39893061e-02f, -7.07655549e-02f, 3.68584573e-01f, 5.73968291e-02f, 2.96380278e-02f, 1.38882741e-01f, -4.81245369e-02f, 1.10990822e-01f, -6.09359704e-03f, 1.95232294e-02f,
  1.58341363e-01f, 2.91146915e-02f, 2.72173155e-02f, 2.40595601e-02f, 2.17189804e-01f, -1.18667018e-02f, -5.30612543e-02f, 3.43294777e-02f, 8.19352176e-03f, -4.88161445e-02f,
  1.28198802e-01f, 8.23464468e-02f, 9.63734537e-02f, -1.16618469e-01f, 1.40346736e-01f, -1.22467920e-01f, -1.44341111e-01f, -6.39853254e-02f, -2.06978798e-01f, 7.62106711e-03f,
  -1.60494491e-01f, 1.57407881e-03f, -9.16778147e-02f, 4.98108268e-02f, 1.34390876e-01f, 1.23129629e-01f, 1.58623323e-01f, 5.73087521e-02f, -7.19643608e-02f, 1.10981263e-01f,
  -1.01499118e-01f, 4.49210852e-02f, -9.32325721e-02f, -8.99072085e-03f, 4.43716235e-02f, 1.91486385e-02f, 9.14265886e-02f, 2.14083031e-01f, 3.05410642e-02f, -8.68012309e-02f,
  6.08141385e-02f, -4.33289818e-02f, 1.14754580e-01f, 1.03024490e-01f, -7.24270940e-02f, 1.53452352e-01f, 1.84528157e-02f, -7.82847463e-04f, -5.37428483e-02f, 2.20501617e-01f,
  2.17690859e-02f, -4.14299704e-02f, -3.77776213e-02f, 8.28295127e-02f, 5.61227556e-04f, 1.54601485e-01f, 5.34911416e-02f, -3.37202139e-02f, 7.57900774e-02f, 8.94341618e-02f,
  7.73871541e-02f, -7.60330111e-02f, -3.77367511e-02f, 2.05688879e-01f, 1.49916276e-01f, -1.79973960e-01f, 6.95840046e-02f, -1.58179685e-01f, -3.03779021e-02f, 2.07496405e-01f,
  1.43908218e-01f, 1.42531693e-01f, 3.59282792e-02f, 1.16947874e-01f, 9.34165716e-02f, 1.34434253e-01f, 7.40799755e-02f, 5.44689707e-02f, 2.15045691e-01f, -3.52561399e-02f,
  -1.91204935e-01f, 3.52997519e-02f, 1.73812225e-01f, -7.86421746e-02f, 3.33606333e-01f, 2.59331968e-02f, -9.23072919e-02f, -2.93472800e-02f, 1.24368988e-01f, 7.74380192e-02f,
  -9.10119638e-02f, -2.49939293e-01f, -5.73650002e-02f, 4.06458275e-03f, 6.18451796e-02f, 2.84656197e-01f, 2.89176814e-02f, -1.17017971e-02f, -7.49824792e-02f, -7.89940134e-02f,
  8.48158449e-02f, 1.27618238e-01f, -5.13464622e-02f, -2.56338045e-02f, 2.37688087e-02f, 1.07515804e-01f, 3.50731239e-02f, -6.19600900e-02f, 1.99375991e-02f, 5.85792102e-02f,
  3.84346917e-02f, 3.34248655e-02f, -1.64113864e-02f, 2.34911181e-02f, 9.71096754e-02f, 1.35782301e-01f, -1.12515865e-02f, 1.47062419e-02f, 6.34951815e-02f, -7.58011416e-02f,
  -8.48959535e-02f, 1.39325913e-02f, -2.96625085e-02f, -1.06963687e-01f, -7.95326680e-02f, 4.28300649e-02f, 1.42748892e-01f, -8.04837570e-02f, -5.07348105e-02f, -9.49536450e-03f,
  -3.16578634e-02f, -3.14713791e-02f, 1.29397035e-01f, 8.18031132e-02f, -1.27747208e-02f, 3.75499092e-02f, 1.17141299e-01f, -3.91043536e-02f, 6.75583854e-02f, -1.61078926e-02f,
  1.40346792e-02f, -1.04287639e-01f, -3.09320632e-02f, -8.94819722e-02f, -3.86626348e-02f, -1.09917512e-02f, 7.26557821e-02f, -1.40351877e-01f, 4.47949357e-02f, 7.52077401e-02f,
  6.16712729e-04f, 8.76238942e-02f, -1.48717806e-01f, 2.29504500e-02f, -8.66991878e-02f, 4.95579131e-02f, 1.66087195e-01f, 6.38911054e-02f, 1.24590479e-01f, -3.42045054e-02f,
  1.39910057e-01f, 7.34378025e-02f, 2.97593288e-02f, 1.21681958e-01f, -9.06565338e-02f, 7.84394369e-02f, -2.68414207e-02f, -4.39298190e-02f, 5.44103421e-02f, 9.95760667e-04f,
  -7.33793899e-02f, -7.14861453e-02f, 4.80196662e-02f, 5.40686399e-02f, 2.18260847e-02f, -1.08760418e-02f, 1.05542667e-01f, 1.29015282e-01f, 1.65216610e-01f, 1.25929013e-01f,
  -7.07729682e-02f, -7.85499066e-02f, 5.48127778e-02f, 2.73109898e-02f, -8.43344256e-02f, 3.08438465e-02f, 1.41348606e-02f, -5.17376401e-02f, 9.59672853e-02f, -1.74635462e-02f,
  2.80756000e-02f, -5.22904769e-02f, 1.44782782e-01f, 9.32334960e-02f, 2.50846054e-02f, -2.27964297e-02f, 9.99880061e-02f, 9.34134703e-03f, -9.51168835e-02f, -9.90333110e-02f,
  6.25223517e-02f, -6.89688623e-02f, -8.74082670e-02f, 3.61287897e-03f, -1.04364410e-01f, 1.04002237e-01f, 5.24154939e-02f, 1.51394278e-01f, 2.21649576e-02f, -1.23311043e-01f,
  1.58086270e-01f, -1.32566944e-01f, 8.77340212e-02f, 1.33696914e-01f, -1.16680689e-01f, 9.60982125e-03f, -6.51952550e-02f, -9.72738788e-02f, -1.65406540e-02f, 1.01586893e-01f,
  -5.13871163e-02f, 1.16885014e-01f, 6.44994201e-03f, -1.11745238e-01f, -1.02250874e-01f, -3.33543234e-02f, 1.06376253e-01f, 1.00478552e-01f, 2.44846176e-02f, -8.12796280e-02f,
  7.08363056e-02f, 6.70856908e-02f, -9.67536271e-02f, 4.84250952e-03f, 7.06816558e-03f, 6.50150478e-02f, -4.09462340e-02f, -4.90053259e-02f, -1.33661777e-01f, 9.05365422e-02f,
  -7.65249655e-02f, -8.00855681e-02f, -4.81819026e-02f, -1.96425803e-02f, 3.30803171e-02f, -7.03100637e-02f, -4.94209006e-02f, 3.94598618e-02f, -4.80151698e-02f, 5.87718897e-02f,
  3.90122496e-02f, 9.81542468e-03f, -5.34968264e-02f, 1.34006128e-01f, -7.27254432e-03f, 2.16339342e-02f, 7.33239874e-02f, 1.11581869e-01f, 5.99006973e-02f, 3.05244420e-02f,
  -5.93241155e-02f, 1.32338509e-01f, -1.01896442e-01f, -7.01368824e-02f, 9.61580593e-03f, 3.55554186e-02f, 1.52424619e-01f, 1.33226350e-01f, 4.64281850e-02f, 1.20403968e-01f,
  -1.55207172e-01f, 2.34222531e-01f, -7.09189400e-02f, -6.87405467e-03f, 1.29101783e-01f, 1.31372539e-02f, -3.73713449e-02f, -4.72359806e-02f, 9.95269865e-02f, 7.09299520e-02f,
  2.05139220e-01f, 4.36844863e-03f, 8.10125377e-04f, 7.88521301e-03f, -5.88465072e-02f, 1.77368239e-01f, -2.17092689e-02f, 1.16227269e-01f, -2.16803905e-02f, 3.20153916e-03f,
  6.21309457e-03f, 9.35715139e-02f, 2.01224029e-01f, -1.45540997e-01f, -4.94363196e-02f, -9.02293175e-02f, -1.00252397e-01f, 6.83167279e-02f, 3.98114882e-02f, -1.13764822e-01f,
  -6.43279229e-04f, 1.79894418e-01f, -6.83529079e-02f, -3.65169756e-02f, -6.00144863e-02f, 6.51846677e-02f, 2.91560292e-02f, -7.56408498e-02f, -1.21196015e-02f, 7.89157152e-02f,
  1.06221467e-01f, -9.55622494e-02f, 2.89628983e-01f, 1.39619214e-02f, 5.86415455e-02f, -3.67247127e-02f, 8.14778358e-02f, -9.58311856e-02f, 1.51205249e-02f, 1.30960688e-01f,
  1.21539712e-01f, -2.72196475e-02f, 1.09047614e-01f, -3.26080918e-02f, -2.79718172e-02f, 1.11951955e-01f, 9.18510035e-02f, 2.04563320e-01f, 1.52876049e-01f, -4.58189141e-04f,
  3.83063555e-02f, 3.84745114e-02f, 1.90526888e-01f, 2.28497997e-01f, -3.33121717e-01f, -1.06956936e-01f, -1.83974445e-01f, 3.02125746e-03f, 1.02320857e-01f, 3.10962982e-02f,
  1.59346610e-02f, 3.59719316e-03f, -7.59883970e-02f, 2.69198269e-01f, 1.91630587e-01f, -1.02204010e-02f, -1.83920547e-01f, -7.46861026e-02f, -2.50701338e-01f, -1.79627314e-01f,
  1.46264017e-01f, 1.14515588e-01f, -3.17393988e-03f, -2.72920216e-03f, -9.98484120e-02f, 1.09082952e-01f, 5.57108670e-02f, -1.10887989e-01f, 1.70546979e-01f, 8.34088400e-02f,
  7.97891393e-02f, 2.66224742e-01f, -9.66554508e-02f, -1.22570746e-01f, 3.83204850e-03f, 1.05131328e-01f, 4.35754098e-03f, -1.73386753e-01f, 3.29717100e-02f, 2.52700169e-02f,
  -1.02780610e-01f, 1.36974767e-01f, -1.23860575e-01f, 2.12732539e-01f, 1.31766796e-01f, -4.59603928e-02f, 1.37070596e-01f, 1.60905495e-01f, 1.11387342e-01f, 6.80359006e-02f,
  -1.02559924e-01f, 9.99500453e-02f, -2.58808471e-02f, 7.81137049e-02f, 8.74470547e-03f, 4.75481674e-02f, 1.58869788e-01f, -8.17431808e-02f, -6.99203089e-02f, 1.52500510e-01f,
  -2.95602567e-02f, 8.92296806e-02f, 5.17748892e-02f, 1.54985189e-01f, -3.83479111e-02f, -2.78972480e-02f, -4.11456861e-02f, 5.04038855e-02f, 8.52630734e-02f, -1.57799646e-01f,
  1.65835721e-03f, 2.48866109e-03f, -4.20281887e-02f, -1.91660792e-01f, 1.47582799e-01f, 3.80170383e-02f, -7.22034229e-03f, 1.71774015e-01f, -1.20144114e-02f, 1.05755322e-01f,
  2.61406675e-02f, -5.50647303e-02f, -7.91336745e-02f, -1.39774293e-01f, -1.30665675e-01f, -2.26556342e-02f, -9.13057700e-02f, 2.94417907e-02f, 5.22885807e-02f, 4.49355543e-02f,
  -1.00607760e-01f, 1.17170162e-01f, -4.53132354e-02f, 2.61076353e-02f, -7.35761691e-03f, -9.43978801e-02f, -1.30034566e-01f, -2.21080799e-02f, 2.86468714e-02f, 1.07322238e-01f,
  -9.16010588e-02f, 9.05852467e-02f, 5.56341037e-02f, 6.63489178e-02f, 5.93898520e-02f, -5.43012656e-02f, -7.83666521e-02f, -4.66266135e-03f, -1.03899881e-01f, 3.83089185e-02f,
  -1.50546124e-02f, 1.92564763e-02f, 1.60479844e-01f, 2.12304771e-01f, 2.30615169e-01f, 2.72745222e-01f, -1.62879601e-01f, 2.30833963e-01f, 1.25873432e-01f, 1.41059056e-01f,
  1.86369836e-01f, 1.68193564e-01f, 1.83133543e-01f, -3.86409834e-02f, 1.47819787e-01f, 4.70850281e-02f, 1.96887895e-01f, -1.42752919e-02f, 8.02374631e-02f, 1.08389653e-01f,
  2.10419148e-01f, -2.06902578e-01f, 1.61847249e-01f, 1.76469445e-01f, 8.31206664e-02f, -9.30375978e-02f, -7.30548799e-02f, 7.15944543e-02f, -1.97553083e-01f, 6.27204552e-02f,
  -2.36522593e-02f, -2.37229720e-01f, 1.25634819e-01f, 7.66433477e-02f, -4.77106012e-02f, 1.68957427e-01f, 1.45585760e-01f, 3.15416217e-01f, -4.98716310e-02f, -2.84264475e-01f,
  -5.92230782e-02f, 2.14004368e-01f, 7.62634501e-02f, -7.03104436e-02f, 7.37309456e-03f, -1.03192672e-01f, -1.23854153e-01f, -2.75823101e-03f, 1.06969677e-01f, -1.20958447e-01f,
  4.25990149e-02f, -5.93140610e-02f, 3.97348464e-01f, 1.09846272e-01f, 1.67019404e-02f, -1.23818755e-01f, -2.08005216e-03f, 1.87624648e-01f, -3.05941626e-02f, -9.10218507e-02f,
  5.24813011e-02f, 8.73178020e-02f, -1.08813554e-01f, -1.04687393e-01f, 3.64860028e-01f, 4.83969087e-03f, 9.38358977e-02f, 8.95940810e-02f, -3.35182399e-02f, -5.85485436e-02f,
  9.33542028e-02f, -2.95966566e-02f, 2.92944796e-02f, 1.81579262e-01f, -5.05202860e-02f, -5.15417904e-02f, -8.49540159e-02f, 9.83275659e-03f, 9.23827589e-02f, -1.73128098e-02f,
  8.20306130e-03f, 3.93862985e-02f, 5.35406396e-02f, -3.47061530e-02f, 8.19291174e-02f, 1.05407191e-02f, 2.71677766e-02f, 1.96461961e-01f, 8.92860070e-02f, -4.52689230e-02f,
  3.12465783e-02f, 2.79134531e-02f, -4.27150391e-02f, 2.30150204e-02f, 7.94007406e-02f, 1.52182668e-01f, -1.35049611e-01f, -4.53356430e-02f, -3.08011882e-02f, 3.46991941e-02f,
  5.00927642e-02f, -1.16611756e-01f, 8.79242178e-03f, 5.90615831e-02f, 7.15799779e-02f, -9.41349566e-02f, -3.73571888e-02f, -9.85242333e-03f, 1.07619569e-01f, 2.98494566e-02f,
  6.81261197e-02f, 9.15160850e-02f, -6.73704920e-03f, 5.56062683e-02f, -6.59989566e-02f, -4.66455333e-02f, -5.95196709e-02f, 1.23240482e-02f, 7.13347271e-02f, -3.83042768e-02f,
  3.34209055e-02f, 1.14454113e-01f, 7.76594579e-02f, -5.21507300e-02f, 9.70425457e-02f, -9.59176794e-02f, -2.22125016e-02f, 7.02749118e-02f, 2.02068374e-01f, 5.14178649e-02f,
  -1.91610977e-02f, 1.64100185e-01f, 3.38447876e-02f, -4.35090400e-02f, 1.05149582e-01f, 9.93632600e-02f, 1.96301177e-01f, 1.25594735e-01f, 1.40853580e-02f, -1.40907377e-01f,
  -9.36276242e-02f, 2.49935806e-01f, 1.96097463e-01f, 4.10294458e-02f, -4.27178368e-02f, 2.47533202e-01f, 4.52350006e-02f, 2.26814598e-01f, 6.41132817e-02f, 2.76587814e-01f,
  -2.69990504e-01f, 9.62228607e-03f, -2.14080632e-01f, -1.34507060e-01f, 3.63689177e-02f, 3.58919310e-03f, 3.47857326e-02f, 1.58399209e-01f, -9.60219884e-04f, 2.26393119e-01f,
  9.52717513e-02f, -6.31621405e-02f, 4.01363336e-02f, -9.55592096e-02f, -5.05987741e-02f, -1.19315669e-01f, 2.48528365e-02f, 8.18439648e-02f, 1.30642995e-01f, -1.06938601e-01f,
  2.82990374e-02f, 1.11269273e-01f, -1.73408285e-01f, 3.61689702e-02f, 1.59609020e-01f, 4.54934165e-02f, -5.47930896e-02f, 1.94712773e-01f, -1.43060666e-02f, -1.15970150e-02f,
  1.63800359e-01f, -1.77274331e-01f, 3.68368253e-02f, -1.09020703e-01f, -1.07125148e-01f, 2.00032946e-02f, -1.36714667e-01f, 1.39025912e-01f, -8.27943385e-02f, -4.19560559e-02f,
  5.37192374e-02f, 1.07714124e-01f, -1.04602449e-01f, -1.77717730e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  6.17052913e-02f, 1.18146934e-01f, -3.02384850e-02f, 8.65746513e-02f, 1.11483924e-01f, 1.21019579e-01f, -4.11366969e-02f, -8.14739324e-04f, 1.60003617e-01f, 6.91813082e-02f,
  1.11803465e-01f, 2.41016179e-01f, 5.37480926e-03f, -3.35182287e-02f, 9.09036696e-02f, 1.46429405e-01f, 5.57333939e-02f, 1.99881122e-01f, -3.73354964e-02f, 5.91130788e-03f,
  6.88260943e-02f, 1.03486516e-01f, -7.73692653e-02f, 1.58300832e-01f, 2.61433572e-02f, 4.87821456e-03f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  1.32439330e-01f, -2.93464750e-01f, 6.53163642e-02f, -1.40130088e-01f, 2.53673730e-04f, 1.48167178e-01f, 1.85992971e-01f, 1.42354995e-01f, -3.34708899e-01f, 2.27713078e-01f,
  -2.10964456e-01f, -5.13410121e-02f, -3.87748331e-02f, -8.03281665e-02f, 3.23222935e-01f, -8.85731205e-02f, 9.94843896e-03f, -8.63690749e-02f, 8.83655995e-02f, -5.12324050e-02f,
  -4.51581478e-02f, 3.50823313e-01f, -3.20086539e-01f, -5.37412345e-01f, 2.32783169e-01f, 4.00680006e-02f, -8.26395079e-02f, 1.27763256e-01f, -2.25718901e-01f, 2.41294742e-01f,
  -3.52514088e-01f, -2.65688896e-01f, -2.38763168e-01f, 2.46784791e-01f, 2.69941539e-01f, 1.53111085e-01f, -3.16014647e-01f, 3.31289358e-02f, -2.81500965e-01f, -1.61927536e-01f,
  1.09582774e-01f, -2.87047058e-01f, 3.01102400e-01f, -4.83300269e-01f, -4.52372953e-02f, -3.95733975e-02f, 4.39897664e-02f, -3.36396128e-01f, 3.76288854e-02f, -7.96949416e-02f,
  4.25612740e-02f, -1.17116794e-01f, 1.36883423e-01f, 7.69589469e-02f, -2.83242255e-01f, 3.03297102e-01f, 6.35242835e-03f, -8.58718604e-02f, -6.03342690e-02f, 5.91792643e-01f,
  -2.02338025e-02f, -5.10781527e-01f, 3.57046165e-03f, 4.13934678e-01f, 2.62781113e-01f, 1.30045742e-01f, 1.33802414e-01f, 3.31493676e-01f, 3.15176994e-01f, 1.52314916e-01f,
  4.68634926e-02f, 1.79992080e-01f, 1.12499505e-01f, 8.27469602e-02f, 1.32589370e-01f, 1.65685430e-01f, -1.01061307e-01f, 1.84331104e-01f, -4.16450381e-01f, 3.43976319e-01f,
  2.21194014e-01f, 8.86552632e-02f, 7.44819120e-02f, 1.42651483e-01f, -4.08300310e-02f, -4.15523089e-02f, 2.53967434e-01f, 1.58502877e-01f, 9.84171256e-02f, -1.78577259e-01f,
  2.77557294e-03f, 4.47794676e-01f, 2.08202451e-02f, 7.93899223e-02f, -5.16812086e-01f, -1.54607207e-01f, 2.52147019e-01f, 3.68910462e-01f, -1.48195580e-01f, -3.02366555e-01f,
  -3.47115546e-01f, -1.65436476e-01f, -3.09132010e-01f, 1.69164389e-01f, 1.65235680e-02f, 5.81188984e-02f, 4.31485713e-01f, -1.32374838e-01f, 1.52284741e-01f, 2.81709563e-02f,
  1.13892334e-03f, 1.42762167e-02f, 3.06007136e-02f, 5.39326668e-01f, 4.78894785e-02f, -2.36768350e-02f, -1.17318101e-01f, -5.35041928e-01f, -1.75925449e-01f, 1.94050446e-01f,
  -9.24449638e-02f, -2.60416027e-02f, -1.17244050e-01f, 5.54934368e-02f, 2.48185754e-01f, -4.74930793e-01f, -7.92481676e-02f, 2.73573309e-01f, 1.94891632e-01f, -1.12446047e-01f,
  -3.34658056e-01f, 3.08036990e-02f, -2.74022222e-01f, 1.92068011e-01f, 6.80416450e-02f, -1.49063140e-01f, 2.11081237e-01f, -2.85206974e-01f, 5.08302227e-02f, 3.70524973e-02f,
  1.40371071e-02f, -1.06296934e-01f, 3.09004802e-02f, -2.97981203e-01f, 2.69253284e-01f, 1.76326841e-01f, 1.61950275e-01f, 2.36436650e-01f, -2.03542471e-01f, -1.89259946e-01f,
  9.60240811e-02f, 2.29592070e-01f, 3.20873350e-01f, -9.08435807e-02f, 1.85325220e-01f, -4.37149376e-01f, 1.71051860e-01f, -5.40063865e-02f, 4.36978698e-01f, -5.01479097e-02f,
  -2.09071785e-01f, 3.93745929e-01f, -4.29986924e-01f, 6.97644874e-02f, 2.50475943e-01f, -3.70298102e-02f, -2.11115614e-01f, -7.73413852e-02f, 7.11253062e-02f, 4.40984778e-02f,
  1.90596737e-03f, 3.87152463e-01f, -4.97530354e-03f, 1.08740546e-01f, 7.10637448e-03f, -2.92572498e-01f, -2.17527136e-01f, 5.82465291e-01f, -1.60843596e-01f, 5.19111976e-02f,
  -3.70025486e-01f, -4.27073598e-01f, -9.75895226e-02f, 1.99476555e-01f, 1.86016634e-01f, -8.71648416e-02f, -4.54088077e-02f, -1.75455242e-01f, -3.76287177e-02f, -1.73540756e-01f,
  3.58491987e-02f, -2.08003029e-01f, 5.94820082e-03f, 4.78708604e-03f, 6.27806410e-02f, 6.84180707e-02f, 7.48001114e-02f, -4.77413572e-02f, -5.15097193e-02f, -9.84594896e-02f,
  2.67543226e-01f, -4.21199165e-02f, 8.23814198e-02f, -2.16555923e-01f, -2.67515659e-01f, -1.70787424e-01f, -3.04596126e-01f, -3.42916012e-01f, -4.16549712e-01f, -1.41544595e-01f,
  -2.23536894e-01f, -9.66049451e-03f, 2.12330684e-01f, 1.26832619e-01f, 1.71986580e-01f, 1.07151186e-02f, -3.73622775e-01f, 1.17942207e-01f, -3.48232359e-01f, -3.48241895e-01f,
  -3.38263959e-01f, -8.47130194e-02f, -2.51695693e-01f, -2.68640518e-01f, 6.80841953e-02f, -1.87552497e-01f, 2.72553489e-02f, -1.49437904e-01f, 3.98762971e-02f, -2.17232411e-03f,
  -2.28906184e-01f, 6.64475709e-02f, 9.22973156e-02f, -2.16368318e-01f, -1.28545031e-01f, 1.18832402e-01f, -3.00762299e-02f, -9.27768573e-02f, 2.95366459e-02f, -2.08590120e-01f,
  2.71475874e-02f, -4.25561160e-01f, 1.65613934e-01f, -1.26753002e-01f, 4.30248827e-01f, 5.12581944e-01f, -1.46272525e-01f, -1.19857900e-01f, -1.14076860e-01f, 4.30514663e-02f,
  2.80462742e-01f, -7.67573854e-03f, 1.42616415e-02f, 5.55799864e-02f, 3.04661281e-02f, 1.50104403e-01f, 1.41374737e-01f, -3.07512552e-01f, 3.83797213e-02f, -1.84724294e-02f,
  -1.24974355e-01f, 3.53867590e-01f, 1.78359270e-01f, 1.06155120e-01f, 1.89296663e-01f, 7.48386979e-02f, -2.08958499e-02f, 3.77146661e-01f, 1.04862221e-01f, -1.48701489e-01f,
  3.92005056e-01f, -1.33985594e-01f, 1.35484144e-01f, 3.97409290e-01f, 1.98969260e-01f, -3.25139254e-01f, -4.77538183e-02f, -2.91360140e-01f, 4.20366004e-02f, 3.12363505e-01f,
  3.23122144e-01f, -3.22949499e-01f, -2.26649880e-01f, 2.79066205e-01f, -1.99532911e-01f, 1.48266517e-02f, 2.66929209e-01f, -1.92079805e-02f, -1.53135598e-01f, -9.10687223e-02f,
  4.33632284e-02f, -1.57153130e-01f, 2.88432121e-01f, 1.99776012e-02f, 2.04316676e-01f, -8.07979926e-02f, 6.35088161e-02f, -1.33628353e-01f, -1.46709278e-01f, -2.49269724e-01f,
  -3.59035358e-02f, 5.63241355e-03f, -7.35565200e-02f, 2.50281274e-01f, 1.09491155e-01f, -1.85828060e-01f, 1.04384206e-01f, 1.01066902e-01f, 1.81321457e-01f, 4.81422216e-01f,
  9.09796730e-02f, -5.10929599e-02f, -2.02871710e-01f, 7.32238218e-02f, 2.07275435e-01f, 5.82730249e-02f, -1.04034953e-01f, 3.83895487e-01f, -8.60341713e-02f, -1.08360611e-01f,
  -1.62897468e-01f, -4.54088822e-02f, 3.01446319e-01f, -7.10315406e-02f, 3.98267895e-01f, -5.32084465e-01f, 9.40560177e-02f, 1.95045099e-01f, -1.44007191e-01f, 1.66716680e-01f,
  -2.34019279e-01f, 2.75405586e-01f, -1.70231424e-02f, 1.10604592e-01f, 1.58178866e-01f, -2.07204089e-01f, 1.28567562e-01f, -2.41853055e-02f, 3.80410440e-02f, -2.92410880e-01f,
  -8.84819194e-04f, 4.01495695e-01f, -1.40485808e-01f, 6.49126545e-02f, 1.54856592e-01f, 2.31335998e-01f, -2.42302090e-01f, 2.16600180e-01f, 1.32423550e-01f, 1.79025277e-01f,
  5.45690835e-01f, -2.66323745e-01f, 3.08756709e-01f, 2.02645943e-01f, 3.45323652e-01f, 2.97953784e-01f, -4.46773946e-01f, -4.97375518e-01f, 7.04034194e-02f, 8.35727900e-02f,
  2.78816489e-03f, 1.18756622e-01f, -1.18939765e-01f, -3.77734423e-01f, 1.44795895e-01f, -3.38703990e-02f, -3.62920538e-02f, 6.14430904e-01f, 8.72613415e-02f, 3.66515443e-02f,
  7.85166249e-02f, 3.29230018e-02f, -8.94750953e-02f, 1.91699535e-01f, 2.12309748e-01f, -4.91426466e-03f, 8.71801525e-02f, -1.76026523e-01f, -7.65976459e-02f, 1.55269787e-01f,
  1.32664919e-01f, -4.28974032e-01f, -5.34247085e-02f, 2.82395244e-01f, -9.91427526e-02f, -5.46939820e-02f, 2.73884535e-02f, 8.29118788e-02f, -4.22167569e-01f, -4.22278345e-01f,
  9.61222276e-02f, 1.08204111e-01f, 1.15921602e-01f, -3.14141303e-01f, -9.80918258e-02f, -5.09587586e-01f, -4.61638123e-02f, 8.12766328e-02f, 1.10532850e-01f, 1.55458972e-01f,
  1.55974641e-01f, 2.62367725e-01f, -2.27985129e-01f, -3.97957534e-01f, -1.64979771e-02f, -3.21537584e-01f, 2.28237167e-01f, -6.40342431e-03f, -6.84996247e-02f, 2.94333011e-01f,
  1.65619835e-01f, -3.93431902e-01f, 2.80005246e-01f, 1.43183708e-01f, 3.49650979e-01f, 7.57056624e-02f, 3.52616727e-01f, 2.23943859e-01f, -2.15130299e-01f, 1.43276602e-01f,
  -1.30803823e-01f, -3.00623596e-01f, 3.68206352e-01f, 2.08338667e-02f, -6.65975958e-02f, 2.04985529e-01f, -7.50807300e-02f, 2.17564255e-01f, -1.44224450e-01f, 2.56405711e-01f,
  8.15393962e-03f, 2.70258874e-01f, -2.83623021e-02f, -2.24954933e-02f, -5.81473261e-02f, 9.00514610e-03f, 9.80518460e-02f, 3.04765031e-02f, 2.19252467e-01f, -7.94130042e-02f,
  -2.91757062e-02f, 7.90916160e-02f, -1.05490506e-01f, -3.27829003e-01f, -2.29022037e-02f, -8.07635039e-02f, 7.15542361e-02f, -8.91689509e-02f, 4.80998196e-02f, -1.88873559e-02f,
  -1.07993789e-01f, -5.25957234e-02f, 1.68076813e-01f, 7.27683753e-02f, 2.82606166e-02f, 2.04119403e-02f, -2.49279603e-01f, -1.14700012e-01f, 2.29586914e-01f, -3.64592820e-02f,
  1.22357637e-01f, -2.01769933e-01f, -3.72820348e-02f, -8.81387740e-02f, 1.83468342e-01f, 2.00039744e-01f, 5.01767127e-03f, 2.00724423e-01f, -2.40624413e-01f, 3.80883783e-01f,
  -2.61405289e-01f, -4.62466836e-01f, -5.25380135e-01f, -3.59756559e-01f, 1.00478798e-01f, 3.37047040e-01f, -5.09517610e-01f, -4.10259627e-02f, -2.65146136e-01f, 3.17312568e-01f,
  -3.13892454e-01f, -5.04104078e-01f, 3.16310763e-01f, 1.75504476e-01f, 2.39721209e-01f, 3.50950360e-01f, -1.32220343e-01f, -2.03273639e-01f, 4.81233373e-02f, -1.86828613e-01f,
  1.30476862e-01f, -6.04015708e-01f, 1.93204015e-01f, -5.21840565e-02f, 2.80890822e-01f, -2.38336891e-01f, -2.59025127e-01f, -3.15463692e-01f, 4.13381420e-02f, 4.67262156e-02f,
  -1.37783870e-01f, 2.74093181e-01f, -4.81875800e-02f, -3.08472186e-01f, -8.27432424e-02f, -1.48026466e-01f, 5.89976422e-02f, 1.75445899e-01f, -1.09822810e-01f, 1.30726129e-01f,
  9.70720202e-02f, -1.50975242e-01f, -1.56624913e-01f, 3.24760914e-01f, 6.37535378e-02f, -1.02192350e-01f, 2.62307227e-01f, 1.19064689e-01f, 1.66770324e-01f, -1.44548127e-02f,
  3.09695095e-01f, 6.25929907e-02f, 3.89253259e-01f, 2.93824356e-02f, 9.00327861e-02f, 1.98867545e-01f, -5.31468540e-02f, 1.59447461e-01f, -2.09168419e-02f, 2.58777231e-01f,
  -1.36513427e-01f, 3.96212041e-01f, 2.42333427e-01f, 1.81583464e-01f, 5.44255853e-01f, -4.09169436e-01f, -4.60233957e-01f, 2.98946589e-01f, 1.64183363e-01f, 8.67497548e-02f,
  3.24258596e-01f, -3.59955192e-01f, -3.66149634e-01f, 3.89536411e-01f, 1.83839515e-01f, -3.45673680e-01f, -4.89953697e-01f, -2.61303812e-01f, 2.97770232e-01f, 4.04174596e-01f,
  -2.11466670e-01f, 1.95801914e-01f, -5.68977632e-02f, -1.45339891e-01f, 4.32078261e-03f, 1.35720342e-01f, 5.53427972e-02f, -1.33513361e-01f, -7.76025727e-02f, -1.49509206e-01f,
  1.76563159e-01f, -2.28909761e-01f, 7.73362890e-02f, 3.14745009e-01f, -3.42329681e-01f, -1.70379817e-01f, 1.13205165e-02f, -3.22361827e-01f, 5.50255924e-02f, -3.72265689e-02f,
  -2.29856849e-01f, -1.41559005e-01f, 5.04376739e-02f, 1.27194241e-01f, 1.41637325e-01f, -1.81044012e-01f, 1.27480912e-03f, -3.99811208e-01f, -4.35019255e-01f, -1.61396205e-01f,
  -1.82531029e-01f, -3.29251945e-01f, -2.39360094e-01f, -1.41332015e-01f, -2.54960984e-01f, 2.70899624e-01f, -6.98081776e-02f, -3.80904853e-01f, 5.30736819e-02f, 1.54311270e-01f,
  -1.88775495e-01f, 1.52745008e-01f, -3.58261257e-01f, 2.39193235e-02f, -2.38083228e-01f, -3.76968801e-01f, -6.05043806e-02f, -4.20073032e-01f, -2.96089530e-01f, 2.58714736e-01f,
  2.07414925e-01f, -5.62799156e-01f, 3.19801033e-01f, 4.00652170e-01f, 2.46592164e-02f, 8.46917406e-02f, 3.01077396e-01f, 1.26462013e-01f, 4.58831014e-03f, 2.43558660e-01f,
  -2.02943996e-01f, 3.48935843e-01f, -2.66264766e-01f, -3.49539161e-01f, 3.61184716e-01f, -5.28960750e-02f, -5.96091570e-03f, -1.23943239e-01f, -3.55024007e-03f, -5.53393781e-01f,
  6.47314042e-02f, -1.38914466e-01f, -1.42215848e-01f, 4.21309263e-01f, -1.41221851e-01f, 1.62120178e-01f, 7.81003609e-02f, -7.92669430e-02f, -4.82071452e-02f, -3.19269955e-01f,
  8.01298544e-02f, 3.74465227e-01f, -3.58818024e-02f, 3.61548131e-03f, 5.66367172e-02f, -1.44221678e-01f, 1.69209689e-01f, 4.46894253e-03f, -9.10348892e-02f, -3.26805115e-01f,
  -3.80717181e-02f, 2.42729355e-02f, -1.24426000e-01f, -1.62136421e-01f, -2.03288659e-01f, 5.37478961e-02f, -1.75933704e-01f, 1.42394509e-02f, -2.77180433e-01f, 1.17594950e-01f,
  -1.86400209e-03f, 1.09508513e-02f, -2.16179416e-01f, -1.65525049e-01f, 3.58675957e-01f, 1.14022516e-01f, -3.46605211e-01f, -3.60299379e-01f, -1.92669660e-01f, 1.17938243e-01f,
  2.75186688e-01f, -2.75911659e-01f, 2.71812707e-01f, 3.25853854e-01f, -3.29634517e-01f, 3.28841060e-01f, -1.37595281e-01f, -3.28964382e-01f, 2.05942050e-01f, 3.24496953e-03f,
  -2.66386539e-01f, -3.12473863e-01f, -2.03114346e-01f, -1.30163595e-01f, -2.62583047e-01f, 1.86859388e-02f, 3.14048052e-01f, 3.15233469e-01f, -1.86267704e-01f, -6.76573589e-02f,
  -1.43997654e-01f, 1.22099139e-01f, 8.41740519e-02f, 6.55888617e-01f, 1.22094108e-03f, 1.84119239e-01f, 1.61304653e-01f, -3.82921249e-02f, 2.12051228e-01f, 6.88394308e-02f,
  -3.95011231e-02f, -1.71373606e-01f, 1.97532512e-02f, -1.55152842e-01f, -1.71081021e-01f, -2.16293663e-01f, -3.34460922e-02f, 1.52810037e-01f, -3.76312099e-02f, -2.40167886e-01f,
  1.52322846e-02f, -2.54884716e-02f, 1.53114632e-01f, 1.21819958e-01f, 1.03771597e-01f, 2.22683966e-01f, 1.59438536e-01f, 1.50918067e-01f, -1.18328504e-01f, 2.24683300e-01f,
  -3.37268621e-01f, -4.54064399e-01f, -2.29450583e-01f, -4.40891348e-02f, -3.48470658e-01f, 2.19035193e-01f, 6.09149858e-02f, 5.27513549e-02f, -2.04906121e-01f, 6.95677698e-02f,
  6.40966557e-03f, -1.67174250e-01f, 2.46894389e-01f, -1.15314543e-01f, 1.06752917e-01f, 5.14826886e-02f, -2.57089913e-01f, 1.78241417e-01f, 3.07628572e-01f, 3.67072433e-01f,
  3.08378756e-01f, -4.47436720e-01f, 2.61779457e-01f, 1.60313711e-01f, 2.54261434e-01f, 2.90556192e-01f, 1.83181196e-01f, -4.95885670e-01f, 3.84507537e-01f, -3.44830602e-01f,
  3.50064248e-01f, 6.39444068e-02f, 7.38584623e-02f, 3.36753367e-03f, 8.11315998e-02f, -1.92415088e-01f, -1.56576231e-01f, 3.45183045e-01f, 5.70553206e-02f, 7.41260424e-02f,
  -2.08927736e-01f, -1.06408792e-02f, 7.79701546e-02f, -1.20350182e-01f, -3.09587345e-02f, 5.38147278e-02f, -4.80404608e-02f, -7.27108791e-02f, 1.06380992e-01f, -1.24596886e-01f,
  9.08057988e-02f, -1.60119653e-01f, -3.27146858e-01f, -2.75601804e-01f, 5.63705824e-02f, 5.11294782e-01f, -2.27582380e-01f, -1.04495548e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.10683657e-01f, 1.71641722e-01f, -4.84669618e-02f, -1.42240584e-01f, -1.53454781e-01f, -1.17521249e-02f, -2.52569150e-02f, 4.77648750e-02f, 2.39156425e-01f, -9.11428630e-02f,
  -1.59237906e-01f, -1.60839051e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    