/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.06543732e-01f, -1.22388937e-01f, -2.02605743e-02f, -1.18853040e-01f, -2.31695361e-02f, -1.49085119e-01f, -3.07706207e-01f, -3.59318266e-03f, -3.29098590e-02f, -7.03418329e-02f,
  2.18618274e-01f, 2.25571856e-01f, 1.03583969e-01f, 1.36057630e-01f, 6.58727214e-02f, -3.51152927e-01f, -4.50080156e-01f, 5.16388752e-02f, 3.40255111e-01f, 8.98587406e-02f,
  -6.81588799e-02f, -2.52533127e-02f, 9.82572809e-02f, 1.02573216e-01f, -1.53390184e-01f, 6.12323210e-02f, -1.01245999e-01f, 3.02492809e-02f, 2.73477361e-02f, -5.16043246e-01f,
  1.16836779e-01f, 1.48471482e-02f, 1.38559207e-01f, 6.66693002e-02f, 1.14009582e-01f, 1.08961791e-01f, 7.54251406e-02f, 1.04846984e-01f, 4.98672724e-02f, -8.62672776e-02f,
  1.84835326e-02f, 8.62303656e-03f, -3.32782697e-03f, 4.08252440e-02f, 5.95543906e-02f, 8.35533906e-03f, 3.55965970e-03f, -8.84641781e-02f, 8.73379351e-04f, 6.88024163e-02f,
  3.04461848e-02f, 4.40046042e-02f, 1.55200943e-01f, 7.04491362e-02f, 3.03728972e-02f, 1.29777834e-01f, 4.59344015e-02f, 9.03693214e-02f, 1.71572283e-01f, -6.91171661e-02f,
  5.47976717e-02f, -1.64277311e-02f, -8.95742700e-02f, -2.03162618e-02f, -3.20016220e-02f, -3.13476436e-02f, -1.05194815e-01f, -9.79618505e-02f, -3.62689719e-02f, -1.20028898e-01f,
  -6.78993948e-03f, -4.84003797e-02f, -5.64206839e-02f, -1.32356718e-01f, -5.47536314e-02f, -9.48742498e-03f, -1.22769028e-01f, -9.82248858e-02f, -1.80644747e-02f, -4.28782701e-02f,
  -3.65665033e-02f, -1.60522945e-02f, -1.63156781e-02f, -4.57875505e-02f, -9.72586945e-02f, -7.22583979e-02f, -2.19640192e-02f, 1.65001098e-02f, -1.99921504e-02f, -8.23261216e-02f,
  2.56171282e-02f, 1.82258323e-01f, 5.60101531e-02f, 7.74163082e-02f, 5.28362393e-02f, 7.96010792e-02f, 4.02721353e-02f, 5.24389446e-02f, 7.34393159e-03f, 3.15670222e-02f,
  1.10462561e-01f, 6.88551366e-02f, -1.63066722e-02f, -2.66422052e-02f, 6.28525466e-02f, -2.88442541e-02f, -1.32977851e-02f, 1.32624824e-02f, -3.29332333e-03f, -6.03067083e-03f,
  -2.15708539e-02f, 5.72676584e-02f, 1.44934490e-01f, 3.20560411e-02f, 5.02615683e-02f, 1.34766087e-01f, 1.25253737e-01f, 1.66606873e-01f, 1.49494171e-01f, 6.60636351e-02f,
  -7.89346397e-01f, 2.37372011e-01f, 2.76740372e-01f, -4.52284664e-01f, 1.95159256e-01f, -8.05297941e-02f, 2.91111708e-01f, -1.93238884e-01f, -2.51624346e-01f, -4.26632538e-02f,
  1.10706955e-01f, -2.26665139e-01f, -2.14155391e-01f, -1.85621366e-01f, -1.13194183e-01f, 1.63305745e-01f, 1.56667739e-01f, -1.37928039e-01f, -3.19897979e-01f, -1.67022899e-01f,
  8.88201874e-03f, 3.91178811e-03f, -1.72391221e-01f, -2.73719937e-01f, -5.51409200e-02f, -1.82950526e-01f, 9.29729491e-02f, 1.26186073e-01f, 9.43608508e-02f, 1.62393332e-01f,
  -7.97006954e-03f, -2.43901685e-01f, -5.20144179e-02f, -2.16323659e-02f, 2.70225238e-02f, -2.01630324e-01f, -1.38870299e-01f, -4.97446358e-02f, -7.02129528e-02f, -9.73482504e-02f,
  -9.12218243e-02f, -1.22794636e-01f, -1.28907129e-01f, -7.67685249e-02f, -9.14293379e-02f, -9.39031467e-02f, -7.11022764e-02f, -7.54776150e-02f, -9.98004004e-02f, -4.68828790e-02f,
  5.90562001e-02f, -7.42459297e-03f, 6.29620403e-02f, -8.83614272e-02f, -1.54802173e-01f, -2.05340609e-01f, 3.15174311e-02f, -1.08691782e-01f, -5.80968447e-02f, -1.04860000e-01f,
  6.43570498e-02f, 6.65572211e-02f, 3.08392532e-02f, 8.24320614e-02f, 5.57767898e-02f, -2.09609997e-02f, 2.52538007e-02f, 9.45121869e-02f, 1.30120059e-02f, 5.55232428e-02f,
  4.08765860e-02f, 1.13443623e-03f, 1.24482736e-02f, -2.51812562e-02f, 2.46500708e-02f, 8.59821737e-02f, 1.69410035e-02f, 4.81064469e-02f, 4.49804775e-02f, 3.89544405e-02f,
  2.47367881e-02f, 5.65716885e-02f, -3.36919539e-02f, 3.43818441e-02f, 6.47030771e-02f, 5.44936173e-02f, 2.16105618e-02f, 8.08673576e-02f, 1.43352132e-02f, 4.81857024e-02f,
  -2.30705798e-01f, -3.79164889e-02f, -2.35025913e-01f, -1.01640292e-01f, -2.90755201e-02f, -4.70085219e-02f, 1.05998805e-02f, -1.58675015e-02f, -7.92061016e-02f, -1.14191316e-01f,
  -6.66266605e-02f, -1.80094063e-01f, -5.72496466e-02f, -2.24108696e-02f, -8.76666307e-02f, -1.00816898e-01f, 2.19599530e-02f, -1.14918321e-01f, -6.07791469e-02f, -5.58233596e-02f,
  4.77626733e-02f, -1.18312001e-01f, -2.58530974e-01f, -3.84000614e-02f, -6.99047446e-02f, -2.23475069e-01f, -5.63627779e-02f, -1.03363872e-01f, -1.33396968e-01f, -1.55949667e-01f,
  -4.33974713e-01f, 7.43047753e-03f, 1.66871876e-01f, 8.53365064e-02f, 3.45835695e-03f, -1.95479542e-01f, -1.07163236e-01f, -1.43536419e-01f, -1.30126104e-01f, 4.13021035e-02f,
  -2.01798286e-02f, -5.24391271e-02f, 1.20718731e-02f, 4.70496193e-02f, 2.02450156e-02f, 1.29589438e-01f, 2.12323368e-01f, 2.60909230e-01f, 3.12282611e-02f, -5.42176440e-02f,
  6.96612448e-02f, 4.03383635e-02f, 5.95217049e-02f, -4.36144359e-02f, 4.08252805e-01f, 1.32183596e-01f, 1.85747474e-01f, 2.22493902e-01f, 2.24609762e-01f, 8.28102052e-01f,
  3.72785240e-01f, 1.45775259e-01f, 6.62164986e-02f, -1.12424605e-03f, 6.60340786e-02f, 2.49780715e-02f, 7.44710118e-02f, 1.00414902e-01f, -7.50626670e-04f, 3.02671269e-02f,
  7.29288086e-02f, 8.49964004e-03f, 2.21504048e-02f, 1.09726869e-01f, 1.05555113e-02f, 1.56743359e-02f, 4.62980242e-03f, 5.49782552e-02f, 9.51274484e-02f, 7.72014335e-02f,
  5.27428426e-02f, 1.53584108e-01f, 2.05358788e-01f, 5.37416600e-02f, 2.76188627e-02f, 1.83200687e-01f, 1.03633359e-01f, 1.94529235e-01f, 1.68096870e-01f, 2.02023268e-01f,
  5.57283424e-02f, -5.37170805e-02f, -1.28590867e-01f, -7.25263432e-02f, -1.34360343e-01f, -5.67490235e-02f, -1.64392605e-01f, -1.46479066e-02f, -1.15665302e-01f, -8.21214169e-02f,
  -3.39080244e-02f, -7.87253901e-02f, -1.10227764e-01f, -6.60967678e-02f, -2.38171890e-02f, -4.23428515e-04f, -8.08770359e-02f, -1.04955606e-01f, -1.19502805e-01f, -1.18589684e-01f,
  -1.00709707e-01f, -5.84267005e-02f, -5.37398420e-02f, -3.78178246e-02f, -7.45078623e-02f, -4.98651937e-02f, -9.02211666e-02f, -1.09326944e-01f, -5.20031489e-02f, -1.89281139e-03f,
  -1.79353669e-01f, -1.96719855e-01f, 2.65956640e-01f, 1.50783733e-01f, 6.54734522e-02f, 1.85572073e-01f, 7.58229345e-02f, 1.43291697e-01f, 1.06197618e-01f, 1.17292888e-01f,
  5.63220419e-02f, 1.44220695e-01f, 3.81757356e-02f, 6.83849901e-02f, 1.25681295e-03f, 1.19859293e-01f, 1.20067829e-02f, 1.32754698e-01f, 8.33805650e-02f, 6.11619912e-02f,
  3.79631296e-02f, 9.88039374e-02f, 9.57480446e-02f, 9.02891979e-02f, 2.12810397e-01f, 8.64443034e-02f, 2.39032298e-01f, 1.89394385e-01f, 2.92157866e-02f, 4.00980264e-02f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.73029378e-01f, -7.85570085e-01f, -1.96621746e-01f, -8.45035017e-01f, -5.41427970e-01f, -1.70313016e-01f, -5.81811070e-01f, -1.35499209e-01f, -2.28106186e-01f, -7.26097941e-01f,
  -1.48847044e-01f, -6.61518350e-02f, -2.66958535e-01f, 9.83520895e-02f, 5.39139450e-01f, -5.66188514e-01f, -2.42516756e-01f, 5.04860878e-01f, 7.58269727e-01f, 1.03316046e-02f,
  -3.11700076e-01f, -2.32461721e-01f, 4.32041198e-01f, 2.06476301e-01f, -1.02450919e+00f, -3.16389889e-01f, -4.48900908e-01f, -3.57175589e-01f, -8.88842866e-02f, -1.07686281e+00f,
  -6.02894604e-01f, -1.62292019e-01f, 1.72322929e-01f, 2.04847649e-01f, -1.81495667e-01f, 2.10529357e-01f, -7.87375793e-02f, 2.68453360e-02f, 1.81805745e-01f, -1.58424959e-01f,
  -4.72386330e-02f, 2.55859643e-01f, -5.93264736e-02f, 2.62619387e-02f, -1.87892213e-01f, -5.63442782e-02f, 1.25357673e-01f, 2.52201289e-01f, -1.06690843e-02f, 7.69346952e-02f,
  -2.71552205e-01f, -2.77029872e-02f, 5.53721152e-02f, 3.10416427e-02f, 1.33153841e-01f, 7.99800903e-02f, 4.30103391e-02f, -3.54539230e-02f, 3.85774672e-01f, -7.84990251e-01f,
  -4.87631634e-02f, -8.13466907e-02f, -9.61063281e-02f, 1.30609825e-01f, -8.77091754e-03f, 1.74329127e-03f, 9.57451481e-03f, -1.40100569e-01f, 8.59535933e-02f, -1.00085586e-01f,
  -6.66877925e-02f, -4.25568856e-02f, -2.57765744e-02f, -3.99396829e-02f, -1.26799181e-01f, 2.33596340e-02f, -4.01079655e-02f, -3.10248658e-02f, 6.90737665e-02f, -2.59678680e-02f,
  -2.61356235e-02f, 8.27110410e-02f, -1.26652196e-01f, 8.04694593e-02f, 9.33306366e-02f, 7.74144605e-02f, 1.35612413e-01f, 9.71727371e-02f, -6.00910299e-02f, -2.51553357e-02f,
  -3.10684204e-01f, 5.78719795e-01f, -4.13153648e-01f, 1.77258760e-01f, -2.20206939e-02f, -8.04138780e-02f, -2.17882991e-01f, 1.34557292e-01f, -4.92101796e-02f, -1.99681949e-02f,
  1.23257555e-01f, -3.58624160e-02f, -8.83353427e-02f, 2.14616787e-02f, 2.21922677e-02f, -1.09084703e-01f, -8.04997459e-02f, -1.22508757e-01f, 2.49897521e-02f, -1.46863341e-01f,
  -1.18936077e-01f, 1.27832025e-01f, -2.02384531e-01f, -1.54138193e-01f, -3.14362168e-01f, -6.97516501e-02f, -2.81439096e-01f, -2.73002386e-01f, 1.49185613e-01f, -4.41470534e-01f,
  -6.21320248e-01f, 3.09313983e-01f, 6.10093534e-01f, -4.12075013e-01f, 1.81579292e-01f, -3.38787585e-02f, -2.27573767e-01f, -5.78233421e-01f, -3.52118045e-01f, 1.67614505e-01f,
  5.61938286e-01f, 3.30864377e-02f, -2.92180870e-02f, -2.69629471e-02f, -3.29716802e-01f, 7.69903660e-02f, 1.79500505e-01f, 7.14809224e-02f, -2.96808094e-01f, -3.93938124e-01f,
  -5.30813523e-02f, -1.27484053e-01f, -1.59697175e-01f, -1.90055236e-01f, -8.24648291e-02f, -3.12639385e-01f, 3.87470782e-01f, 1.49993196e-01f, 3.14301521e-01f, 1.43861771e-01f,
  2.91346103e-01f, -1.20988220e-01f, 1.40522748e-01f, 1.11472070e-01f, 1.69788525e-01f, -3.22962552e-01f, -4.83285077e-02f, 7.16841519e-02f, -2.10806429e-02f, 4.06305641e-02f,
  1.71374977e-01f, 1.15265302e-01f, -3.01186163e-02f, -4.35909592e-02f, -3.43138188e-01f, -1.91306755e-01f, -2.16305386e-02f, -1.18846215e-01f, -1.98010176e-01f, -1.79131757e-02f,
  1.05667226e-02f, 1.28752664e-01f, -1.21484753e-02f, -2.00400889e-01f, -1.36699110e-01f, -1.14871278e-01f, -9.05800238e-02f, -3.00970703e-01f, -2.27211222e-01f, -5.94439954e-02f,
  2.42449436e-02f, 1.24090649e-01f, 1.03313714e-01f, -5.69524337e-03f, -9.51690897e-02f, -6.77224761e-03f, 5.93282245e-02f, 6.73593357e-02f, -9.24677923e-02f, -5.59528284e-02f,
  8.10581073e-03f, 1.85776632e-02f, 1.15445713e-02f, 6.79870471e-02f, -1.17730126e-02f, -1.90254338e-02f, -1.66459486e-01f, 6.06126850e-04f, 4.82283160e-02f, -7.99254477e-02f,
  -9.20823440e-02f, -1.83751192e-02f, 1.38557374e-01f, -1.21635467e-01f, 2.11068735e-01f, 8.23531523e-02f, -8.02921057e-02f, -3.69293205e-02f, -1.69197559e-01f, 2.71848757e-02f,
  -1.74735054e-01f, 2.05163285e-01f, -3.85056101e-02f, -8.97480845e-02f, -1.70764029e-02f, -5.45127876e-02f, 6.10855483e-02f, 9.03047100e-02f, -4.64655198e-02f, -2.67011702e-01f,
  -2.08734587e-01f, -2.15092331e-01f, 1.23929784e-01f, -1.35190543e-02f, -2.71277457e-01f, -1.57288477e-01f, 1.19667284e-01f, -4.84456681e-02f, -1.36642888e-01f, -2.36579105e-01f,
  -1.86425954e-01f, -2.59922385e-01f, -3.61136317e-01f, -2.81201422e-01f, -2.42768079e-01f, -1.95403874e-01f, -3.69498879e-01f, -2.12970108e-01f, -2.21973717e-01f, -4.83761102e-01f,
  1.10208130e+00f, -1.30128255e-02f, 6.27268910e-01f, 2.36247644e-01f, 1.72917157e-01f, 1.09007724e-01f, 2.43207753e-01f, 9.88203883e-02f, -9.85463336e-02f, 8.47616643e-02f,
  3.93765122e-02f, -9.87841561e-02f, -3.12367501e-03f, 8.92598480e-02f, 1.34717748e-01f, 7.51583427e-02f, -5.77862840e-03f, 3.75436336e-01f, 2.80091673e-01f, 4.02720869e-02f,
  -1.48575366e-01f, -7.66518572e-03f, 1.35083571e-01f, 1.64661258e-01f, 2.09531039e-02f, -9.09710303e-02f, -1.79432221e-02f, -9.89544243e-02f, -1.95922241e-01f, -1.08417317e-01f,
  2.10998014e-01f, 3.15261066e-01f, -6.98504224e-02f, -1.64033741e-01f, 7.18681561e-03f, -2.31545851e-01f, -6.57842606e-02f, -1.38166517e-01f, -7.27038234e-02f, -2.14316592e-01f,
  -9.33122560e-02f, -1.81469601e-02f, 3.76178324e-02f, -2.42738891e-02f, 1.39533589e-02f, -8.16009566e-02f, -3.89898233e-02f, 1.27653956e-01f, 1.29296333e-01f, 2.18581874e-02f,
  -1.15310207e-01f, -6.18622527e-02f, -3.31624970e-02f, 2.17914991e-02f, 2.23691463e-01f, -7.60346185e-03f, -1.68630444e-02f, 6.13822713e-02f, 1.10899568e-01f, 1.52780995e-01f,
  1.42060388e-02f, 1.08330145e-01f, 1.49589837e-01f, -2.86974292e-02f, 4.75006513e-02f, 4.15114798e-02f, -1.96562205e-02f, 3.31585705e-02f, 1.07932024e-01f, -1.16363153e-01f,
  -1.26455724e-01f, 1.59675345e-01f, 5.43890335e-02f, -8.16400070e-03f, 7.01378435e-02f, -6.69885650e-02f, -1.26009256e-01f, -7.14142099e-02f, 1.13929093e-01f, -1.26778528e-01f,
  1.97588988e-02f, 1.03902062e-02f, -1.28974076e-02f, 3.32766399e-02f, -6.32429048e-02f, 1.82647184e-01f, 2.77079865e-02f, 1.83486044e-02f, -1.51409544e-02f, -1.02780417e-01f,
  -7.52865970e-01f, 2.46695891e-01f, 9.37451944e-02f, -1.83177050e-02f, 4.50512357e-02f, -6.45375997e-02f, 1.60506546e-01f, -1.75023243e-01f, -1.37594193e-01f, -8.62911716e-02f,
  -8.71011466e-02f, 1.82252154e-01f, 5.46720847e-02f, 3.30783762e-02f, -8.20544064e-02f, -1.54640064e-01f, 1.58166382e-02f, 8.43955576e-02f, -7.95407295e-02f, -1.78153515e-01f,
  -3.03513501e-02f, -1.85636461e-01f, -1.25364438e-01f, 4.82909754e-03f, -1.58344880e-02f, -1.60266191e-01f, -1.05776161e-01f, -4.32920642e-02f, -3.71971466e-02f, -1.33275166e-01f,
  -1.25276351e+00f, -1.62648454e-01f, 1.28691539e-01f, -8.05814087e-01f, 9.53605771e-02f, 2.71363765e-01f, -1.31254822e-01f, -1.04162335e-01f, 1.40367344e-01f, 7.35846758e-02f,
  1.86149944e-02f, -3.72631818e-01f, -3.26765448e-01f, -2.07307398e-01f, -6.06259763e-01f, 1.54766266e-03f, -2.09675908e-01f, -4.80627865e-01f, -5.96658885e-01f, 3.36112902e-02f,
  4.93796095e-02f, -6.36429667e-01f, -5.91189563e-01f, -2.08654359e-01f, 2.02673763e-01f, -1.21710449e-01f, 1.08172730e-01f, 8.04773904e-03f, 5.24323046e-01f, 1.72515124e-01f,
  8.65052268e-03f, -1.61100160e-02f, 7.67537281e-02f, -1.82087421e-01f, 6.75542140e-03f, 1.10618994e-01f, -7.48022795e-02f, -1.07056297e-01f, 1.11684769e-01f, 1.04363404e-01f,
  -1.66913792e-01f, 6.37985691e-02f, -1.30453438e-01f, -3.53194699e-02f, -1.36504546e-01f, 5.34870028e-02f, 1.23832718e-01f, -1.33528441e-01f, 6.46163821e-02f, 3.48921090e-01f,
  1.58721447e-01f, -1.75735615e-02f, 2.97019668e-02f, 3.09534997e-01f, 3.58833462e-01f, 1.10537997e-02f, 2.13420257e-01f, 2.11905256e-01f, 3.09824109e-01f, -1.40346572e-01f,
  4.14529853e-02f, -1.83540694e-02f, 3.69783118e-02f, 2.19664583e-03f, 1.62097299e-03f, 7.22640846e-03f, -1.51781157e-01f, -1.51745409e-01f, 6.63807467e-02f, 5.15485741e-02f,
  1.23743124e-01f, 4.95836921e-02f, -1.30919993e-01f, -3.92463319e-02f, 9.68643799e-02f, -4.30107787e-02f, 4.97227609e-02f, -1.33729745e-02f, 1.42194536e-02f, 2.83254776e-03f,
  -9.83965117e-03f, 1.40997097e-01f, -6.78598732e-02f, -7.28770494e-02f, 1.19514585e-01f, -1.28233105e-01f, 1.19027428e-01f, 1.46586746e-01f, -8.88024829e-03f, 1.33107662e-01f,
  -7.52622604e-01f, 9.25562084e-02f, -5.59798926e-02f, -2.32838556e-01f, -3.10026221e-02f, 1.04072079e-01f, -5.50124384e-02f, 5.72136007e-02f, 8.15463252e-03f, -2.94777136e-02f,
  1.16793498e-01f, -7.51218274e-02f, -1.11904435e-01f, 1.27406999e-01f, -1.08794235e-01f, -1.47900917e-03f, 9.99952573e-03f, -1.97742969e-01f, 1.26523659e-01f, 1.84272394e-01f,
  1.09046832e-01f, -2.79404521e-01f, -3.35323721e-01f, -6.38746936e-03f, 1.64475963e-01f, -3.02814811e-01f, -1.74482822e-01f, 9.79469493e-02f, -7.92789236e-02f, -4.57453132e-01f,
  -6.52368724e-01f, -2.52201855e-01f, -1.01219177e+00f, 3.25606346e-01f, 3.95632744e-01f, 1.27892286e-01f, 9.29846540e-02f, 5.17490581e-02f, 1.80987209e-01f, -1.82497635e-01f,
  -3.14859092e-01f, 2.50197202e-01f, 7.51463547e-02f, 4.67689373e-02f, -3.98492161e-03f, -3.45687638e-03f, 2.20930099e-01f, -1.77251533e-01f, -3.36005837e-02f, 3.08030903e-01f,
  7.55218029e-01f, 2.48947561e-01f, -1.70549378e-01f, 6.09966330e-02f, 6.70995265e-02f, 2.99557358e-01f, -4.60109189e-02f, -8.53845254e-02f, 2.05274932e-02f, -1.04750939e-01f,
  -7.28367686e-01f, -5.09833276e-01f, 1.50859550e-01f, -1.26646176e-01f, -1.02210745e-01f, -1.69589177e-01f, -1.43543750e-01f, -1.82482228e-01f, -9.71267596e-02f, -2.76578158e-01f,
  -8.89760330e-02f, -1.85808197e-01f, 2.42508799e-01f, -1.20329149e-02f, -5.70906177e-02f, -1.00606650e-01f, 9.93559286e-02f, -2.99579114e-01f, -3.74227107e-01f, -3.25240046e-01f,
  5.03661036e-01f, 2.29518637e-02f, -6.73064232e-01f, -2.10116506e-01f, -3.02961171e-01f, -7.17460588e-02f, -4.85543072e-01f, -3.17914605e-01f, -6.36089802e-01f, -6.02288425e-01f,
  2.42203381e-02f, -1.40141025e-01f, 4.04962525e-02f, 9.70186591e-02f, 1.60203561e-01f, 1.19315691e-01f, -6.14213618e-03f, -1.53336655e-02f, 1.99466094e-01f, -7.28878900e-02f,
  3.52684595e-02f, -5.35595417e-03f, 2.63113081e-02f, -1.16284274e-01f, 1.77876987e-02f, 6.14029877e-02f, 9.59606022e-02f, -6.85830861e-02f, -6.27787858e-02f, 8.06259550e-03f,
  -1.44086540e-01f, -2.60139376e-01f, -7.00729415e-02f, -2.62048524e-02f, -8.70157108e-02f, -5.39853722e-02f, 1.37463734e-01f, 5.05994931e-02f, 7.87604079e-02f, -8.92285034e-02f,
  1.22435816e-01f, 1.22161515e-01f, -6.68730810e-02f, -3.90109792e-02f, 4.01324816e-02f, 3.82449180e-02f, 1.03314988e-01f, -3.62677686e-02f, -1.43231109e-01f, -1.00937359e-01f,
  -6.87652593e-03f, -1.79579273e-01f, -6.86008558e-02f, 2.26077437e-01f, 9.49123576e-02f, -1.02143243e-01f, 7.70988539e-02f, -2.78586941e-03f, 1.97410151e-01f, 1.15518391e-01f,
  1.83104664e-01f, -1.22079335e-03f, -2.67038643e-01f, -2.90889412e-01f, 1.71304673e-01f, -9.66858938e-02f, -2.48727962e-01f, -2.28645816e-01f, -3.66165727e-01f, -1.43234000e-01f,
  2.87759453e-01f, -6.29101545e-02f, 1.55699715e-01f, 1.93732202e-01f, -5.66094220e-01f, -8.45531106e-01f, -9.77486968e-01f, -5.06225467e-01f, -1.20867327e-01f, -1.24526322e-02f,
  -2.99136549e-01f, -8.97877887e-02f, 3.95440236e-02f, 5.90007231e-02f, 1.00085869e-01f, 4.64030765e-02f, 4.18115884e-01f, 4.79222864e-01f, -1.32017219e-02f, -2.42563397e-01f,
  -9.16355550e-02f, 2.72582769e-01f, 4.05774504e-01f, 1.26235425e-01f, 3.76244932e-01f, -1.57898024e-01f, -3.48220170e-02f, 6.45501986e-02f, -1.64036959e-01f, 7.27009773e-01f,
  1.36272952e-01f, -6.74424544e-02f, -7.55179152e-02f, 5.20545579e-02f, 1.48834869e-01f, 1.65602863e-01f, 1.24423370e-01f, 2.14996099e-01f, -5.24143800e-02f, 1.26894459e-01f,
  1.08955719e-01f, -1.13115750e-01f, -1.69120624e-03f, 9.80005190e-02f, 9.90082994e-02f, -1.86412364e-01f, 1.13317005e-01f, 2.05317125e-01f, 1.38850376e-01f, 1.31042665e-02f,
  6.60819784e-02f, -2.81617612e-01f, -3.13838631e-01f, -2.27162659e-01f, 8.17529485e-02f, 7.77518600e-02f, -1.71993822e-01f, 6.51397705e-02f, -1.29615799e-01f, 1.76933184e-01f,
  -1.21188149e-01f, -5.26057333e-02f, -1.84763651e-02f, 2.00229771e-02f, -4.03032340e-02f, -9.27647296e-03f, 6.13587610e-02f, -9.91147906e-02f, 3.39259095e-02f, -4.31388579e-02f,
  -1.61078215e-01f, -4.38739657e-02f, -5.16812131e-02f, 2.21505091e-02f, 5.53778559e-02f, 1.00659497e-01f, -1.87830981e-02f, 3.94693352e-02f, 3.89274172e-02f, -4.72286567e-02f,
  -8.01491668e-04f, -2.83895992e-02f, 7.62209818e-02f, 4.01874855e-02f, 6.49475828e-02f, -5.81155345e-03f, 9.99537185e-02f, 6.62935898e-02f, 5.68853691e-02f, -6.93464577e-02f,
  4.61724661e-02f, -1.74927935e-01f, 1.56059042e-01f, 1.50030285e-01f, 4.25106697e-02f, -4.82538268e-02f, -3.80041497e-03f, -6.86289594e-02f, 6.53357878e-02f, 4.01585326e-02f,
  -1.33021414e-01f, 1.24796145e-02f, 4.36617173e-02f, -1.33256260e-02f, -6.58264235e-02f, -2.72287931e-02f, -8.79486501e-02f, -1.61376327e-01f, 7.93867465e-03f, 8.62846076e-02f,
  -4.40975241e-02f, -2.49571159e-01f, -3.93057615e-01f, -2.51569748e-01f, -1.03231832e-01f, -1.83456302e-01f, -3.11553210e-01f, -1.86329842e-01f, -4.45332944e-01f, -5.59937656e-01f,
  6.06681347e-01f, 4.46203381e-01f, 2.61432946e-01f, -1.10878475e-01f, 1.74181551e-01f, -1.01400718e-01f, 1.73597589e-01f, -1.01682372e-01f, -3.56643826e-01f, 1.23625994e-01f,
  2.21575469e-01f, -2.40841195e-01f, -1.09827191e-01f, -2.72186011e-01f, -9.42527950e-02f, -7.95098841e-02f, 8.51903018e-03f, 1.13470584e-01f, -3.10302228e-01f, -1.15092345e-01f,
  -2.24279240e-01f, 1.90401003e-01f, 1.81246042e-01f, 1.01279374e-02f, 1.81570411e-01f, -1.68354556e-01f, 3.04849356e-01f, 3.99357170e-01f, 2.60481387e-01f, 1.51769295e-01f,
  1.48338571e-01f, 4.30929869e-01f, -4.06819761e-01f, -5.79652749e-02f, 2.03093350e-01f, -2.38703713e-02f, -3.74471918e-02f, -8.16503391e-02f, -5.32081630e-03f, -1.00470833e-01f,
  1.73127413e-01f, 4.88041192e-02f, 3.22688594e-02f, -3.11885565e-03f, 1.81116223e-01f, -1.02543674e-01f, -1.04417037e-02f, -4.64813784e-02f, -2.05283865e-01f, -4.80106995e-02f,
  -7.38790780e-02f, 2.18577176e-01f, 2.41364628e-01f, -2.01172605e-01f, -1.60259038e-01f, -1.19556136e-01f, 1.81471512e-01f, -3.50472925e-04f, 4.33480814e-02f, -5.73613830e-02f,
  -1.66949928e-01f, 1.80629611e-01f, 7.35540614e-02f, -1.99270323e-02f, 7.74305910e-02f, -9.40603539e-02f, 8.55363235e-02f, -6.60919175e-02f, -6.70183301e-02f, 1.38857827e-01f,
  -2.94564404e-02f, -5.81007190e-02f, 2.70126555e-02f, 6.04882278e-02f, -7.19245449e-02f, 1.16763860e-01f, 5.94415404e-02f, -8.39348212e-02f, -6.97526410e-02f, 4.70604748e-02f,
  -2.62419760e-01f, -9.40363705e-02f, 4.60095853e-02f, -7.61293620e-02f, -8.53589773e-02f, -4.47025858e-02f, -8.65526646e-02f, 8.57466552e-03f, 6.49523437e-02f, 4.56236973e-02f,
  -3.41464996e-01f, -1.74946323e-01f, -1.59011975e-01f, 2.90618818e-02f, 2.50906348e-01f, 1.68997213e-01f, -3.52255218e-02f, 8.63339566e-03f, 1.14154465e-01f, 4.92254645e-02f,
  1.15392573e-01f, -1.61437003e-03f, 6.63140118e-02f, -1.95298597e-01f, -1.12118497e-01f, -4.76482697e-02f, 1.76410079e-01f, -1.52353023e-03f, -1.97804287e-01f, 1.07094623e-01f,
  4.27881517e-02f, -3.36403489e-01f, -1.29457340e-01f, -3.10553402e-01f, -2.03618169e-01f, -2.60096937e-01f, -1.48326725e-01f, -2.84058563e-02f, -9.20016915e-02f, -2.77168036e-01f,
  1.06860232e+00f, -6.48506761e-01f, 2.57571965e-01f, 3.45158637e-01f, -1.22536957e-01f, 1.82335213e-01f, 1.45311743e-01f, 1.67196453e-01f, 2.21576825e-01f, 1.04643069e-01f,
  -6.01560831e-01f, -6.57788098e-01f, -5.19166768e-01f, -4.44549501e-01f, -2.32499838e-01f, 1.60141185e-01f, 2.01871470e-01f, 2.56999552e-01f, 2.40246385e-01f, 5.76956011e-02f,
  -2.29004353e-01f, 3.54189217e-01f, 4.10007387e-01f, 7.90224690e-03f, -9.34698358e-02f, 4.12584059e-02f, 1.81541163e-02f, -1.79396078e-01f, -2.88959563e-01f, 9.61472318e-02f,
  2.29645863e-01f, -1.90269306e-01f, 1.22480899e-01f, -1.77141383e-01f, -3.14142764e-01f, 4.38652299e-02f, -2.16067173e-02f, 1.36455014e-01f, -1.93168446e-01f, 5.70985265e-02f,
  -5.37632182e-02f, -1.45500764e-01f, -2.38959149e-01f, -1.05355494e-01f, -4.94204015e-02f, 7.97550827e-02f, 1.28736123e-01f, 3.13390493e-02f, -8.49794671e-02f, -2.35557884e-01f,
  -5.19453883e-01f, -1.79307446e-01f, 8.80321786e-02f, 8.43047630e-03f, -1.19390383e-01f, -1.36076912e-01f, -1.06562160e-01f, -2.47561604e-01f, -1.24332182e-01f, 1.71712711e-01f,
  -3.37343290e-02f, 2.07663521e-01f, -1.71102118e-02f, 7.49532729e-02f, 1.70116529e-01f, 4.31142077e-02f, -4.23049591e-02f, -1.29416421e-01f, 1.20249473e-01f, -1.47925569e-02f,
  -1.98665932e-02f, 8.57967362e-02f, -3.56235020e-02f, 6.97837025e-02f, -1.85802914e-02f, -6.46752119e-02f, -6.60883412e-02f, -4.25547659e-02f, -9.57385153e-02f, 8.94320086e-02f,
  -8.71127248e-02f, -3.11301835e-02f, 1.72258765e-02f, -1.14648469e-01f, -6.60021007e-02f, -8.48447457e-02f, -5.22795832e-04f, -9.64035764e-02f, -1.23900194e-02f, 4.67752218e-02f,
  6.22360520e-02f, -4.35489506e-01f, 1.29551917e-01f, -1.98790848e-01f, 2.63667386e-02f, -2.02533618e-01f, -7.66139179e-02f, -1.26101384e-02f, -7.01653659e-02f, -1.00054041e-01f,
  -1.67347938e-01f, -7.54700229e-02f, -1.24668509e-01f, -4.33686748e-02f, 1.11330546e-01f, 1.22612990e-01f, -1.27196819e-01f, -7.65456539e-03f, -5.74563518e-02f, 1.25264928e-01f,
  -9.09136515e-03f, 2.84095317e-01f, 2.78543532e-01f, 9.61986408e-02f, -5.26343733e-02f, 6.81495219e-02f, 1.92989305e-01f, -2.61226185e-02f, 2.07828209e-01f, 4.93610322e-01f,
  -1.00680602e+00f, -4.59821641e-01f, 3.71097445e-01f, -5.24999797e-01f, -4.84042257e-01f, -5.27389586e-01f, -6.43043101e-01f, -5.74358642e-01f, -4.72985417e-01f, -4.94214296e-01f,
  3.70913595e-02f, 6.76536441e-01f, 5.59995532e-01f, 5.06463826e-01f, 2.88397402e-01f, -5.45662403e-01f, -5.53638875e-01f, 3.14117014e-01f, 6.97821259e-01f, 1.14309616e-01f,
  -4.27454598e-02f, 2.18010861e-02f, 8.92426893e-02f, 1.91193357e-01f, -2.05086321e-01f, 3.30408931e-01f, -1.73800647e-01f, -3.54242891e-01f, -1.67649910e-01f, -5.29324949e-01f,
  5.33039331e-01f, -6.08032644e-01f, 2.19450742e-01f, -1.78159133e-01f, -5.32260686e-02f, -1.06307745e-01f, 7.47721223e-03f, -4.20127660e-02f, -1.00431405e-01f, -5.75233586e-02f,
  -1.19950688e-02f, -3.89124192e-02f, -2.51868758e-02f, 8.88660327e-02f, -8.40098262e-02f, 1.11788429e-01f, -7.59317949e-02f, -3.99121344e-02f, -1.72712818e-01f, 9.04478133e-02f,
  -6.17713891e-02f, -1.72499180e-01f, 4.97023426e-02f, 9.88173187e-02f, 6.38246834e-02f, -9.84558687e-02f, 2.62142658e-01f, -9.16126221e-02f, 1.60403997e-02f, -1.53626993e-01f,
  -6.93846419e-02f, 5.13862707e-02f, 2.33681519e-02f, 7.74343386e-02f, -8.55873618e-03f, 6.31296486e-02f, 5.41357026e-02f, -7.78694823e-02f, -4.15914431e-02f, 2.35533193e-01f,
  -5.61880991e-02f, -6.85826614e-02f, 1.38740093e-01f, -1.37296364e-01f, -7.98820555e-02f, -1.31986320e-01f, -3.63613255e-02f, 1.46347702e-01f, 1.78215355e-02f, -8.54663737e-03f,
  6.16164319e-02f, 3.52281779e-02f, -4.37656865e-02f, 7.78810754e-02f, -5.28849810e-02f, 6.86605573e-02f, -4.71461564e-02f, 5.93705922e-02f, -3.93628143e-02f, -6.85795918e-02f,
  4.14717585e-01f, -2.06758663e-01f, 1.17382877e-01f, 1.56487346e-01f, -7.51096457e-02f, -8.07245597e-02f, -6.27854913e-02f, 1.11649841e-01f, 6.67730719e-02f, -8.81794281e-03f,
  7.13687018e-02f, -4.76443768e-02f, -7.23750740e-02f, 4.18316647e-02f, 4.82177250e-02f, 3.19476239e-02f, -2.23409772e-01f, 4.49398905e-02f, -7.37741217e-02f, -5.92586361e-02f,
  -2.31513217e-01f, -1.65222257e-01f, 7.03665018e-02f, 1.74684718e-01f, -9.75611135e-02f, 4.47037667e-02f, 3.88832867e-01f, 1.62309170e-01f, 8.47101137e-02f, 5.16883377e-03f,
  4.08611536e-01f, 1.25881538e-01f, -9.79459524e-01f, 6.26050830e-01f, -7.67787874e-01f, -9.22920227e-01f, -7.41262734e-01f, -1.44240670e-02f, 4.90887463e-01f, -1.81056708e-02f,
  5.79628674e-03f, 5.72963469e-02f, -5.53970449e-02f, -3.03228408e-01f, -4.88295287e-01f, -5.49612939e-01f, -7.21992850e-01f, -7.16984689e-01f, -7.14748383e-01f, -4.86719936e-01f,
  -2.41690859e-01f, 2.25402266e-02f, -3.48364003e-02f, -1.48111090e-01f, 3.38847339e-01f, 6.83767200e-02f, -4.31196578e-02f, -2.03325357e-02f, -4.27577376e-01f, -3.04078937e-01f,
  -2.67662942e-01f, 4.04752307e-02f, -1.62363887e-01f, 3.96844521e-02f, 1.45542786e-01f, -8.29704776e-02f, -2.09043428e-01f, 1.32545099e-01f, 1.13151362e-02f, 1.26266526e-02f,
  1.13382570e-01f, -1.06124386e-01f, -4.06671949e-02f, -1.03866912e-01f, -1.34020954e-01f, -8.28192607e-02f, 1.10295318e-01f, -2.50097424e-01f, -9.81356874e-02f, -2.72944331e-01f,
  -1.85392201e-01f, -2.72004664e-01f, -2.98324555e-01f, -1.85368672e-01f, -9.41040516e-02f, -3.43225420e-01f, 4.58907848e-03f, -1.20575942e-01f, -1.95868582e-01f, 3.80892217e-01f,
  4.67249379e-03f, 7.52926990e-02f, -3.13701779e-02f, -9.12707523e-02f, 1.55540451e-01f, -3.22447531e-02f, 8.64588991e-02f, 3.64414975e-02f, 5.36171207e-03f, 4.12906669e-02f,
  8.68292078e-02f, -6.94405809e-02f, 8.53887573e-03f, -3.58965360e-02f, -7.43742064e-02f, -2.51171235e-02f, 1.80512015e-02f, -6.74514398e-02f, 1.37347877e-02f, -1.16456397e-01f,
  -4.05081175e-02f, 1.66974757e-02f, 1.66562498e-01f, 1.34162396e-01f, -1.24460377e-01f, 2.67493688e-02f, -5.64504899e-02f, -1.49321496e-01f, 5.56241572e-02f, -1.31416336e-01f,
  4.72375929e-01f, -5.02775729e-01f, 2.76806504e-01f, 8.35240260e-02f, 5.48978634e-02f, 3.63026224e-02f, 1.49822012e-01f, 1.14543177e-01f, 3.06076616e-01f, 2.89455540e-02f,
  -2.12271720e-01f, 2.21137181e-01f, 9.97823551e-02f, -9.62796062e-02f, -2.32571617e-01f, -1.65929869e-01f, -6.46474212e-02f, -3.38068269e-02f, -1.95391148e-01f, 2.21918359e-01f,
  6.14730567e-02f, -9.11634937e-02f, 5.93740083e-02f, -5.98921105e-02f, 6.31402284e-02f, -1.35679349e-01f, 1.12005152e-01f, 4.84666377e-02f, -1.28726780e-01f, 3.86888027e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  7.69007504e-01f, 4.92011458e-01f, 8.72834444e-01f, 5.47931969e-01f, 7.52713561e-01f, 5.44259608e-01f, 5.57113469e-01f, 8.25779021e-01f, 5.92940509e-01f, 4.63698536e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.20052558e-01f, -3.15701999e-02f, -6.08671494e-02f, 1.07116047e-02f, 9.40015614e-02f, -2.61973739e-01f, 2.01159403e-01f, 1.10921219e-01f, -6.83471188e-02f, 1.83169648e-01f,
  3.44260216e-01f, -6.40167236e-01f, -1.30050451e-01f, -5.58237210e-02f, -1.49514243e-01f, 2.59872049e-01f, 9.98052731e-02f, 8.07412118e-02f, -4.49116528e-02f, 1.84098128e-02f,
  -1.16742678e-01f, 4.36411425e-02f, 2.09168736e-02f, 3.78077537e-01f, -9.66561809e-02f, 3.58101994e-01f, -4.10046101e-01f, 7.15363622e-01f, 5.31404853e-01f, 8.27179700e-02f,
  -3.19926441e-01f, -1.56868383e-01f, 2.39394188e-01f, 1.32258683e-01f, -2.18023323e-02f, 2.22409032e-02f, 1.33087382e-01f, 8.49150121e-02f, -3.39459300e-01f, 2.17369258e-01f,
  -3.18966210e-01f, 2.10615084e-01f, -3.21293175e-01f, 2.27943525e-01f, 4.13631946e-01f, 1.29757956e-01f, 1.22699946e-01f, 3.68223339e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  1.10954404e-01f, 4.92523432e-01f, 4.69481587e-01f, -3.78095265e-03f, 1.34182602e-01f, 2.08204970e-01f, -1.84673920e-01f, 1.17314720e+00f, -1.59619257e-01f, 6.86505675e-01f,
  8.67837667e-01f, 3.27501088e-01f, 8.69726956e-01f, -7.24116743e-01f, 9.34481978e-01f, 5.46883419e-02f, 1.62116840e-01f, 1.07827969e-01f, -4.82590776e-03f, 3.74786943e-01f,
  -1.31505057e-01f, -2.54205912e-01f, 1.29658520e-01f, -6.93724379e-02f, 4.88092661e-01f, 1.47131696e-01f, -1.45054594e-01f, -4.39070642e-01f, -1.88243046e-01f, 4.35107142e-01f,
  7.40599215e-01f, 1.03089952e+00f, -1.09863684e-01f, -2.67995838e-02f, 1.26864836e-01f, 1.06809802e-01f, 2.16620620e-02f, 2.11106375e-01f, 7.73022830e-01f, -1.59471467e-01f,
  2.14923352e-01f, 5.20578995e-02f, 5.86037993e-01f, -2.19720826e-02f, -5.33644795e-01f, 5.99631131e-01f, 3.85998599e-02f, -2.62988299e-01f, 3.85897644e-02f, 2.22083122e-01f,
  3.39582264e-01f, 1.12533122e-01f, 1.73142523e-01f, -8.40390995e-02f, 8.22462499e-01f, 3.52440178e-01f, 1.01086152e+00f, -4.24633145e-01f, -4.71290588e-01f, 5.47153950e-01f,
  6.39543116e-01f, 3.18368673e-01f, -5.69331273e-02f, -3.17383200e-01f, 6.22938454e-01f, 3.64886373e-01f, 1.10837080e-01f, -2.58116007e-01f, -1.16799474e-01f, -9.41953436e-02f,
  -2.65197366e-01f, -8.06092620e-02f, -1.94467351e-01f, -1.45990372e-01f, 4.81436759e-01f, 9.17092204e-01f, 1.97515130e-01f, 1.07948613e+00f, -7.00290084e-01f, 8.03416252e-01f,
  2.57744044e-01f, 1.31549984e-01f, 9.39336270e-02f, -2.16246605e-01f, 1.72874019e-01f, 1.01502752e-02f, -3.93310785e-02f, 6.73170269e-01f, 2.66272388e-02f, 6.42053962e-01f,
  -1.34479195e-01f, -3.22934717e-01f, 7.35523224e-01f, 7.13679612e-01f, 2.68105865e-01f, -1.63344339e-01f, 4.03565735e-01f, 2.11083308e-01f, 2.23444119e-01f, 5.18954158e-01f,
  -1.98996402e-02f, 3.46806496e-02f, 5.44740558e-01f, -2.14872375e-01f, -3.15768868e-02f, -5.44250965e-01f, 6.70002341e-01f, 1.10009477e-01f, -4.94735926e-01f, 3.49625498e-01f,
  1.14512134e+00f, 6.22457564e-01f, -1.54768288e-01f, 3.75219248e-03f, 4.50174779e-01f, -2.54013896e-01f, 3.60580653e-01f, 5.49438715e-01f, -1.05472279e+00f, 2.42313519e-01f,
  1.19400367e-01f, -2.82192498e-01f, 6.95410728e-01f, 7.76347816e-01f, -1.72952697e-01f, -2.24199489e-01f, -2.48558879e-01f, -2.78762728e-01f, 2.74712741e-01f, 4.73575056e-01f,
  -7.87133947e-02f, 2.32820272e-01f, -3.78175944e-01f, 1.61824241e-01f, -8.54354143e-01f, 5.46749495e-03f, 7.62853980e-01f, -6.76128447e-01f, -5.71768701e-01f, 5.45521557e-01f,
  8.65630031e-01f, 6.09436989e-01f, -2.22879976e-01f, -7.22280979e-01f, 6.46041512e-01f, 4.77071494e-01f, -1.75340146e-01f, -3.49367820e-02f, -4.00259793e-01f, -4.99319941e-01f,
  9.46638823e-01f, 5.97557843e-01f, -8.45028609e-02f, 7.17276692e-01f, 7.35677242e-01f, -7.53499148e-03f, -2.54638761e-01f, -2.96416640e-01f, -1.53671741e-01f, 4.40988064e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  2.94976622e-01f, 4.55654189e-02f, -1.79059774e-01f, 3.41181219e-01f, -8.44973419e-03f, -1.45169318e-01f, -1.22787111e-01f, 4.85288709e-01f, 3.59319448e-01f, 2.67066211e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  -2.26084441e-01f, 4.74957451e-02f, 3.13906729e-01f, -1.64567247e-01f, 2.32433435e-02f, -1.82915732e-01f, -1.80134997e-01f, -1.16591074e-01f, 4.56111372e-01f, 3.44199121e-01f,
  -1.60113394e-01f, 2.19568729e-01f, 1.13773927e-01f, -2.61623830e-01f, 1.39135748e-01f, -2.06648126e-01f, -1.12834322e+00f, -6.62342012e-01f, -7.67866254e-01f, 5.10738313e-01f,
  1.08067214e-01f, -6.15562275e-02f, -1.03008233e-01f, 1.14204220e-01f, -3.51317003e-02f, -1.47306010e-01f, 3.45882148e-01f, -2.29191795e-01f, 1.70789674e-01f, -8.53648335e-02f,
  1.33369416e-01f, 1.71880290e-01f, -2.21973620e-04f, 4.90764081e-01f, 3.56446207e-01f, 6.92858472e-02f, -4.77671474e-01f, -1.10210076e-01f, -4.59856391e-02f, 1.41387567e-01f,
  6.62034899e-02f, -2.13820934e-01f, -4.15218979e-01f, -4.74821717e-01f, -1.89069629e-01f, 3.26590925e-01f, 3.37144494e-01f, 3.36170286e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  3.53425801e-01f, 3.47481608e-01f, 2.01364145e-01f, 3.81969988e-01f, -6.74383700e-01f, -5.67634404e-01f, 1.93308964e-01f, -3.69499028e-02f, 1.03757906e+00f, 1.60253365e-02f,
  8.19606602e-01f, -4.61726636e-01f, 6.11250579e-01f, 8.27526808e-01f, -2.56889313e-01f, 6.83548450e-01f, -2.83721149e-01f, -1.37884736e+00f, -5.61451972e-01f, -5.93876421e-01f,
  6.32302761e-01f, 8.31066549e-01f, 7.83158779e-01f, -3.14175814e-01f, -4.63442355e-01f, 8.53404775e-02f, 4.38199162e-01f, 6.10785365e-01f, -2.64185518e-01f, 8.97787884e-02f,
  2.56882489e-01f, -9.31803137e-03f, -2.33509108e-01f, 1.10839777e-01f, -7.92225480e-01f, 9.05570567e-01f, -8.48662555e-01f, -6.29509389e-01f, 2.26629004e-01f, 3.85517776e-01f,
  -1.10054858e-01f, 2.95942992e-01f, -6.21549249e-01f, -2.00368594e-02f, 1.88353300e-01f, 4.70404476e-01f, 3.84850979e-01f, -2.92696536e-01f, -2.03145534e-01f, -4.07331496e-01f,
  -5.15608788e-01f, 4.88002151e-01f, -5.47923446e-01f, -5.57719052e-01f, -4.83443737e-01f, 3.73432338e-01f, -1.19330637e-01f, 5.60293198e-01f, -6.45030379e-01f, -8.42779279e-01f,
  6.18690312e-01f, 4.19602007e-01f, 3.70629936e-01f, 1.98924884e-01f, 1.44541353e-01f, -4.85778213e-01f, -2.34629199e-01f, -3.81286502e-01f, 1.15547931e+00f, 5.94777524e-01f,
  9.08681571e-01f, -8.89113098e-02f, -5.63414931e-01f, 2.17507467e-01f, -1.16387695e-01f, 6.65000856e-01f, -1.53518528e-01f, -2.94820398e-01f, -8.82686581e-03f, 6.07304275e-01f,
  -4.58924711e-01f, 3.85135353e-01f, 8.33082497e-01f, 6.28668487e-01f, 5.87692022e-01f, 6.15454763e-02f, -3.76837492e-01f, 4.50894564e-01f, 5.94260395e-02f, 9.29159820e-01f,
  1.25205970e+00f, 3.30495715e-01f, 5.20627983e-02f, 1.74499467e-01f, 9.48709965e-01f, -2.51881093e-01f, -2.70147040e-03f, -2.90253520e-01f, -1.06296599e-01f, 6.14983976e-01f,
  9.09549177e-01f, -5.33341765e-02f, 2.04170108e-01f, 2.32897885e-02f, 5.63637495e-01f, 5.40166676e-01f, -1.11321771e+00f, 1.10307053e-01f, -7.31034353e-02f, -3.81320566e-01f,
  1.51355445e-01f, 7.65504122e-01f, 6.37781858e-01f, 1.60276160e-01f, 3.43843818e-01f, -5.15278220e-01f, 3.12102884e-01f, 1.62692711e-01f, 1.91801041e-01f, 5.58772445e-01f,
  5.04474759e-01f, 3.91879201e-01f, -6.97207332e-01f, 8.35559309e-01f, 7.64433086e-01f, -5.22154987e-01f, 1.64969862e-01f, 1.91505048e-02f, 8.54821563e-01f, -5.43588161e-01f,
  -4.68306512e-01f, -7.03213573e-01f, -6.80419445e-01f, -1.76731110e-01f, 5.91196895e-01f, 8.21994022e-02f, 6.78523332e-02f, 2.10812151e-01f, -1.09706461e-01f, -1.24283090e-01f,
  8.35777104e-01f, 3.86388361e-01f, -1.64895654e-01f, -6.02596939e-01f, -6.57772481e-01f, 2.28777543e-01f, -2.62305677e-01f, 9.02950883e-01f, -6.88592196e-01f, 2.23239824e-01f,
  2.35514298e-01f, 8.09050858e-01f, -6.45220518e-01f, -1.16058815e+00f, 9.77398098e-01f, 5.84228523e-02f, 4.97592986e-01f, -2.18874618e-01f, -6.93456054e-01f, 4.66521859e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -9.41230580e-02f, -1.15262372e-02f, -1.75249949e-02f, 1.45558342e-01f, 2.86393583e-01f, 4.49844152e-01f, 1.60792932e-01f, -2.10604385e-01f, 1.99358255e-01f, 1.75416678e-01f
};

// L3_linear_W (Shape: 12 x 16)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 16;
const float L3_linear_W_data[] = {
  -3.74182351e-02f, -3.29337448e-01f, -5.14177442e-01f, -3.30282062e-01f, 1.14768110e-01f, 6.92872584e-01f, 3.70392263e-01f, -1.38903618e+00f, -5.80209196e-01f, -5.06625436e-02f,
  -2.57487923e-01f, -6.77976727e-01f, 2.68548697e-01f, 3.50229263e-01f, -2.17658132e-01f, 1.11963928e-01f, -4.31898199e-02f, 2.39621684e-01f, 4.62620199e-01f, 5.72177410e-01f,
  1.91214114e-01f, 8.74613345e-01f, -1.05909270e-03f, -8.24757993e-01f, 5.52904725e-01f, 1.02233541e+00f, -1.03264844e+00f, 5.38530611e-02f, 2.82330662e-01f, 1.87280670e-01f,
  -4.53165397e-02f, -2.26110607e-01f, -3.04678455e-02f, 3.52904126e-02f, -4.30111706e-01f, 2.84583420e-01f, -5.61496556e-01f, -5.24450600e-01f, 2.71904260e-01f, -2.49957860e-01f,
  -1.08621573e+00f, 1.18980326e-01f, -3.01690474e-02f, -3.30398262e-01f, 4.06665266e-01f, 4.07542318e-01f, 3.01972091e-01f, -1.12443244e+00f, 1.88415185e-01f, 1.07908261e+00f,
  -8.69451314e-02f, 2.64409870e-01f, 9.58911419e-01f, 6.81478679e-01f, -2.40853190e-01f, -6.49316534e-02f, -8.36273909e-01f, -6.93277419e-01f, 3.75762284e-01f, -1.48902428e+00f,
  6.29521430e-01f, 3.02506983e-01f, -1.02900791e+00f, -1.40637293e-01f, -5.30517578e-01f, -1.05290699e+00f, 4.52453971e-01f, -3.39171022e-01f, -5.89298904e-01f, -4.31540161e-01f,
  -2.71019280e-01f, -2.25514501e-01f, 1.27920300e-01f, -4.74470466e-01f, 2.54426062e-01f, -3.19995284e-01f, 9.92149338e-02f, 1.05398491e-01f, -5.49889207e-01f, 4.47151452e-01f,
  2.90598094e-01f, -2.01494768e-01f, 9.92859975e-02f, -4.18990254e-01f, 4.48293805e-01f, -7.64496485e-03f, 4.76374090e-01f, -1.19566572e+00f, -6.53136730e-01f, -2.47435495e-01f,
  -6.45533502e-01f, 7.81833678e-02f, -8.30283225e-01f, -2.01349989e-01f, -5.01727045e-01f, 6.87943995e-01f, 5.99896431e-01f, 2.57770628e-01f, 6.44391894e-01f, 1.00790441e+00f,
  3.76983106e-01f, -1.28528342e-01f, -5.90013504e-01f, -4.59235720e-03f, 3.69269848e-02f, -1.29118279e-01f, -1.09200150e-01f, 6.34145856e-01f, -1.75782263e-01f, -1.09499490e+00f,
  -1.46516263e-01f, -5.60576141e-01f, -2.50898348e-03f, -1.12019651e-01f, -2.08488926e-02f, -3.17123622e-01f, -5.39468050e-01f, 5.14779508e-01f, 4.18215632e-01f, -2.49179408e-01f,
  5.99847674e-01f, -1.95522994e-01f, -6.64665028e-02f, -5.08963704e-01f, 2.40283042e-01f, -4.97718900e-01f, 3.67011994e-01f, -5.07245362e-01f, -5.90456486e-01f, 4.18415815e-01f,
  -1.49183050e-01f, 1.58739194e-01f, -4.81852144e-01f, -9.06809330e-01f, 1.89194046e-02f, -9.05838490e-01f, -6.68770730e-01f, -9.37680185e-01f, -1.00459111e+00f, 5.79880476e-01f,
  -8.34759831e-01f, 4.49973375e-01f, -2.04632685e-01f, -7.92229474e-01f, 5.25168478e-01f, 6.37364686e-01f, -4.29501198e-02f, -5.76691985e-01f, -5.52931912e-02f, -4.48664635e-01f,
  -1.31290346e-01f, 5.58246493e-01f, -7.89736927e-01f, -4.99388307e-01f, 4.95326817e-01f, -2.81201720e-01f, -5.82683206e-01f, -5.31558812e-01f, 4.14627999e-01f, -5.13179958e-01f,
  6.07612468e-02f, 7.04723835e-01f, -2.48312503e-01f, -8.02828848e-01f, -4.44713235e-01f, -1.11831844e+00f, -3.50832462e-01f, -5.69721520e-01f, 3.58036369e-01f, -2.57900149e-01f,
  -2.96071917e-01f, -1.31049693e+00f, -7.55040944e-01f, 7.19901860e-01f, 7.35009313e-01f, 3.14239919e-01f, -5.42992949e-01f, -6.82590544e-01f, -4.74894464e-01f, 5.71945608e-01f,
  -6.39517188e-01f, 7.09915087e-02f, -1.00750077e+00f, -1.22934811e-01f, 6.36882335e-02f, -4.27261561e-01f, 2.89418370e-01f, 1.79436550e-01f, 3.13311100e-01f, 2.50058591e-01f,
  -2.17826799e-01f, -5.50103247e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.39912769e-01f, -2.01110050e-01f, -2.08275005e-01f, -5.25162756e-01f, 2.21730903e-01f, 1.66368242e-02f, 1.40250131e-01f, 2.56271124e-01f, -7.90831819e-02f, -8.62902626e-02f,
  -2.12482646e-01f, -7.28795752e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        16, 12
    );
    }
    