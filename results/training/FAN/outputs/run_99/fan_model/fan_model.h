/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  5.07007003e-01f, 7.42905810e-02f, 2.93408751e-01f, -6.71022162e-02f, 7.60266781e-02f, 2.49802932e-01f, 7.30276257e-02f, 7.76682049e-02f, 1.89963922e-01f, -1.73321888e-01f,
  -1.68249458e-01f, 1.64009511e-01f, -1.87750414e-01f, -6.06385432e-02f, 7.36110583e-02f, -8.38730764e-03f, -1.25718927e-02f, -3.17215584e-02f, 1.58583477e-01f, 1.01302400e-01f,
  5.67953624e-02f, -1.75029173e-01f, 1.89031269e-02f, -1.60631968e-03f, 6.86183572e-02f, 1.99303608e-02f, -3.62563819e-01f, -2.15702448e-02f, -1.75503001e-01f, -7.41957035e-03f,
  7.93579519e-02f, -8.54927208e-03f, 8.99816006e-02f, 3.49608734e-02f, -3.58376056e-02f, -2.92404764e-03f, -3.71418670e-02f, -3.54969725e-02f, 6.12080693e-02f, 7.29033910e-03f,
  -8.96282196e-02f, -1.63921658e-02f, -2.59962454e-02f, -3.00165564e-02f, 1.03313699e-01f, 1.94192734e-02f, 3.87017790e-04f, 3.75200040e-03f, -1.13166533e-02f, 9.42878202e-02f,
  3.85046452e-02f, -4.73869313e-03f, 5.27768284e-02f, -4.42055911e-02f, 6.13233708e-02f, 2.51426771e-02f, 1.49631209e-03f, -2.99993437e-02f, 6.92722872e-02f, 4.31176051e-02f,
  -2.45537329e-02f, 1.59674753e-02f, -6.74222503e-03f, 3.07385176e-02f, 3.73759260e-03f, -2.30963212e-02f, -5.72601333e-02f, -9.89810452e-02f, -2.63485368e-02f, 1.10483505e-02f,
  -3.72716896e-02f, 3.18291634e-02f, -1.63299609e-02f, 4.19669785e-02f, -4.59200703e-02f, 8.57271850e-02f, 7.10001439e-02f, -3.18699032e-02f, 6.45733401e-02f, 3.55446711e-02f,
  -5.26696108e-02f, 2.86320001e-02f, -1.18697798e-02f, -9.42444652e-02f, 4.46368903e-02f, 3.72262076e-02f, -4.22223471e-02f, 6.85233995e-02f, -1.99897885e-02f, -7.03342482e-02f,
  -1.31734163e-01f, -1.80039331e-01f, 3.29093896e-02f, -2.75119785e-02f, -4.99872304e-02f, 8.43068678e-03f, 1.26695978e-02f, 5.79924658e-02f, 4.98525472e-03f, 4.59736846e-02f,
  2.18345108e-03f, -8.91062897e-03f, -1.62413698e-02f, -9.33514815e-03f, 4.66623269e-02f, 1.87691650e-03f, -7.80749917e-02f, 1.57089215e-02f, -7.46027380e-02f, -5.22627048e-02f,
  -9.21683833e-02f, -2.93961936e-03f, 3.08336578e-02f, -5.73169021e-03f, -2.96917316e-02f, -1.44808531e-01f, 5.02121858e-02f, -6.12153783e-02f, -1.11496121e-01f, -1.23450488e-01f,
  -1.27569810e-01f, 1.33561552e-01f, -9.61352885e-02f, 2.16337651e-01f, -2.06980050e-01f, -1.12757824e-01f, 4.61655743e-02f, 5.06135114e-02f, 2.83895522e-01f, 2.46422693e-01f,
  5.25967218e-02f, 2.97682524e-01f, 1.11069314e-01f, 3.58075321e-01f, 8.53295345e-03f, 2.47121453e-01f, 2.08922058e-01f, 1.93619460e-01f, 1.05399981e-01f, 3.71546447e-02f,
  1.35238662e-01f, 1.57558292e-01f, 1.21424533e-01f, 1.90871637e-02f, -1.64775461e-01f, -7.01870099e-02f, -1.14788286e-01f, -1.59534812e-01f, -1.52988052e-02f, -2.15351097e-02f,
  1.72602339e-03f, 1.52711868e-01f, -1.14302792e-01f, -1.87073685e-02f, -6.13376573e-02f, -1.80195570e-01f, -1.17106691e-01f, -1.06523044e-01f, -1.50057599e-02f, 4.17647772e-02f,
  -1.23618795e-02f, 4.83326567e-03f, 9.49336812e-02f, 5.73154949e-02f, -6.91571012e-02f, -3.29378434e-02f, 1.13282995e-02f, -2.42948420e-02f, 2.11490458e-03f, 5.88020012e-02f,
  1.22039523e-02f, -9.30913817e-03f, 2.58691460e-02f, 1.69787526e-01f, 9.25168581e-03f, 6.23007379e-02f, 6.51117880e-03f, -5.57358339e-02f, -2.38043573e-02f, 4.60025519e-02f,
  6.35830536e-02f, -7.53852073e-03f, -4.60576788e-02f, -8.78340602e-02f, -4.27801944e-02f, -8.05910304e-02f, 5.53874820e-02f, -9.95039195e-02f, -2.66225431e-02f, 1.74881015e-02f,
  -3.34209614e-02f, -1.30650206e-02f, 6.35839552e-02f, 1.22713549e-02f, 2.91576944e-02f, -1.59377716e-02f, -6.89989775e-02f, 1.29756853e-02f, 1.46801053e-02f, -8.52497071e-02f,
  1.32520618e-02f, 7.59987682e-02f, 1.42583987e-02f, -4.00129296e-02f, 7.02390447e-02f, 4.92704771e-02f, 8.94354060e-02f, -6.42876551e-02f, -1.93757880e-02f, -9.75620821e-02f,
  1.94185004e-01f, 1.83185637e-01f, 5.43214232e-02f, -4.27721888e-02f, 7.56477239e-03f, -1.19461164e-01f, -3.23961563e-02f, -2.29747836e-02f, 2.01532748e-02f, 9.83194262e-02f,
  9.93398298e-03f, -3.74780707e-02f, -3.39496285e-02f, 4.56422158e-02f, -5.66410972e-03f, 2.54847035e-02f, 3.46844457e-02f, -1.43878255e-03f, -2.39992086e-02f, -6.55997684e-03f,
  -9.05038640e-02f, 3.37960869e-02f, -2.76551060e-02f, -8.39410573e-02f, 2.11943742e-02f, -3.52549646e-03f, 1.50133230e-04f, 2.39870697e-03f, -1.37025062e-02f, 5.31653650e-02f,
  4.04170007e-01f, -2.59159267e-01f, 3.14607114e-01f, 1.92640442e-02f, 2.40024999e-02f, -1.27317995e-01f, -7.64295012e-02f, 3.98039483e-02f, 8.47016796e-02f, -2.16923580e-01f,
  -1.99663594e-01f, 4.90141697e-02f, -1.09933451e-01f, -2.83544511e-01f, 1.37100384e-01f, -2.54254878e-01f, -1.40734419e-01f, -8.92554820e-02f, 6.52825236e-02f, 1.30163953e-01f,
  7.64778629e-02f, -3.28676969e-01f, 4.89782430e-02f, -1.29376560e-01f, 9.45998952e-02f, 2.12711051e-01f, -4.11931910e-02f, 1.13592371e-02f, -1.69567376e-01f, -1.00944070e-02f,
  1.50721386e-01f, 2.71811903e-01f, 1.39660209e-01f, 8.69840086e-02f, 6.66315630e-02f, 2.89047826e-02f, 5.34119755e-02f, 2.08831709e-02f, 6.41158000e-02f, -5.39785028e-02f,
  1.00281015e-02f, 6.15813546e-02f, -4.10597324e-02f, 1.56235192e-02f, 5.52458316e-03f, -8.60620348e-04f, -1.49418612e-03f, 1.84199363e-02f, 2.51450725e-02f, 5.18060029e-02f,
  -1.96905155e-02f, -2.12041568e-02f, -1.01290485e-02f, -3.51094715e-02f, 3.90723199e-02f, -6.43315315e-02f, 8.70670900e-02f, 8.81626830e-02f, -6.02690391e-02f, 6.73392639e-02f,
  -2.88180839e-02f, 8.80930498e-02f, -5.89812063e-02f, -1.01823241e-01f, 4.43003997e-02f, 1.33100394e-02f, 1.48433773e-02f, 5.92322908e-02f, 1.12877548e-01f, -3.87242362e-02f,
  -1.06000431e-01f, 5.24005741e-02f, -1.86106898e-02f, 6.45779297e-02f, 3.15611437e-02f, 1.62970386e-02f, 2.03903615e-02f, -7.53618265e-03f, -5.26206940e-02f, 9.63097252e-03f,
  -3.64169925e-02f, -2.75472794e-02f, -1.25433117e-01f, 2.93560997e-02f, -8.36476386e-02f, -2.79103778e-03f, -1.57884043e-02f, -6.12003319e-02f, 3.25669833e-02f, 7.31027797e-02f,
  -1.00378925e-02f, 4.16738428e-02f, 5.56406239e-03f, -9.82306525e-02f, 2.40671914e-02f, -2.71426253e-02f, 1.44637248e-03f, 9.03681945e-03f, -4.80001345e-02f, -1.55504346e-02f,
  8.91446508e-03f, 7.05900714e-02f, 8.57890770e-02f, 7.29063898e-03f, -1.19613428e-02f, -5.20527773e-02f, -1.24390861e-02f, 4.20956053e-02f, 3.24446782e-02f, -3.54267508e-02f,
  2.45005246e-02f, -2.90524289e-02f, 7.47349188e-02f, 2.95977201e-02f, 8.57253298e-02f, -8.89785215e-02f, 1.30756259e-01f, 4.76252809e-02f, -1.67037528e-02f, -4.08841409e-02f,
  7.36765862e-01f, -8.38201866e-03f, 1.79092914e-01f, 2.94492453e-01f, -5.42643256e-02f, -4.70398106e-02f, 1.64613754e-01f, 6.12112135e-02f, 3.66237044e-01f, -2.28123069e-01f,
  -1.48709983e-01f, 2.65368223e-01f, 4.46851505e-03f, -7.59148151e-02f, 3.65629375e-01f, -8.05801302e-02f, 6.41563088e-02f, 2.83068046e-02f, 1.73295796e-01f, 1.48316950e-01f,
  2.34030038e-01f, -2.37536639e-01f, -3.49240680e-03f, -1.91411048e-01f, 8.79436582e-02f, 1.46234080e-01f, -9.98074785e-02f, 2.74947248e-02f, -2.14247003e-01f, -7.54380897e-02f,
  5.10053113e-02f, -2.14774273e-02f, -1.98629359e-03f, 1.14913881e-02f, -1.79798156e-02f, -9.64783074e-04f, 3.15017439e-02f, -2.02469137e-02f, 4.25862102e-03f, -1.09689580e-02f,
  7.15648606e-02f, 4.38269079e-02f, -3.28015350e-02f, -1.26409987e-02f, 3.07571478e-02f, 6.73884875e-04f, -7.36823902e-02f, -8.95609036e-02f, 5.00481995e-03f, -3.46470904e-03f,
  6.30235225e-02f, -1.86850224e-02f, -3.68365347e-02f, -8.38864967e-02f, 8.76052119e-03f, -4.16005217e-03f, -7.22104460e-02f, 1.63860619e-02f, -9.90928616e-03f, 4.17405926e-02f,
  -6.48327470e-02f, 1.02694616e-01f, -1.35937156e-02f, 8.72655399e-03f, -6.88203145e-03f, -5.62854931e-02f, 4.64901002e-03f, -9.45975259e-02f, 8.04134272e-03f, -1.65724242e-03f,
  1.29951220e-02f, 2.80360021e-02f, 7.50880083e-03f, 1.19457571e-02f, 1.79579202e-02f, -2.61336248e-02f, -1.14242174e-02f, -2.46610716e-02f, 5.47442026e-02f, -3.88239212e-02f,
  3.27843912e-02f, 9.22399387e-02f, 2.91609168e-02f, -3.71151902e-02f, -1.70929562e-02f, 1.93886496e-02f, 1.47298630e-02f, -6.16201712e-03f, 8.94879550e-02f, 4.28065956e-02f,
  1.34711787e-02f, 7.07920864e-02f, -3.38487066e-02f, -6.09012768e-02f, -5.53366132e-02f, -1.07930072e-01f, -4.15184675e-03f, -4.72442359e-02f, -4.37655747e-02f, -2.17983201e-02f,
  -1.18236467e-02f, -6.53088912e-02f, 1.09013148e-01f, -6.41194358e-02f, 9.36922617e-03f, -2.82701682e-02f, 6.79436848e-02f, -2.28830450e-03f, -2.00398266e-02f, 1.53733219e-03f,
  4.46358602e-03f, 5.50552830e-02f, -4.53560613e-02f, -2.37475950e-02f, -7.20058680e-02f, 1.79152545e-02f, 8.21889043e-02f, 4.21179831e-02f, -7.92254284e-02f, 4.22938690e-02f,
  3.59866768e-01f, -3.22317630e-01f, -6.74534366e-02f, 3.49589169e-01f, -3.23924124e-02f, -9.82403830e-02f, 1.20522797e-01f, -1.22847781e-01f, -8.40043742e-03f, -1.36172414e-01f,
  5.40289171e-02f, 1.82475299e-01f, -2.35525921e-01f, 3.68048698e-01f, 4.09982979e-01f, -9.42971259e-02f, 2.64429659e-01f, 1.54704437e-01f, -2.59344786e-01f, 1.12375274e-01f,
  8.87067094e-02f, 3.21671724e-01f, 6.76043034e-02f, -1.69556260e-01f, -2.76736431e-02f, -2.99147904e-01f, 5.15370481e-02f, -2.62860119e-01f, 1.09860197e-01f, 3.86347994e-02f,
  3.28599103e-02f, 5.30969724e-02f, -1.47939585e-02f, -3.52117382e-02f, 2.64100637e-02f, 4.36356924e-02f, 5.91686144e-02f, 3.59475682e-03f, -3.69415656e-02f, -2.69364808e-02f,
  -7.72043830e-03f, 7.39907995e-02f, 1.13780436e-03f, -2.47421637e-02f, 3.33394110e-02f, -4.68999483e-02f, 4.11295108e-02f, -3.25242579e-02f, -2.60778256e-02f, 5.63419685e-02f,
  -1.73478555e-02f, -1.66194735e-03f, 8.93265530e-02f, 7.52881542e-02f, 2.38226745e-02f, 2.51504444e-02f, -3.58591117e-02f, -3.23943049e-02f, -7.56190047e-02f, 1.41602743e-03f,
  7.33421668e-02f, 4.80072573e-02f, 4.43657301e-02f, 3.05481115e-03f, -8.55997577e-03f, 7.25889718e-03f, 9.26727057e-03f, 6.87221577e-03f, -6.80559799e-02f, 4.36776839e-02f,
  2.33135372e-02f, 1.63886957e-02f, 7.33869150e-02f, 2.88381558e-02f, 3.70289534e-02f, 1.99545790e-02f, 5.78914322e-02f, -2.44867224e-02f, -6.35499582e-02f, -3.78396921e-02f,
  5.57970181e-02f, 5.29864207e-02f, -4.40427922e-02f, -6.70896173e-02f, 1.23712616e-02f, -1.82191879e-02f, 1.85740907e-02f, 2.70335022e-02f, -5.69389760e-02f, 2.14761030e-02f,
  -3.16279419e-02f, 6.04779273e-02f, -8.54242295e-02f, 2.91871969e-02f, -1.83032975e-02f, 2.18572728e-02f, 5.16029447e-02f, -1.84434261e-02f, -3.33519243e-02f, 5.71912639e-02f,
  5.50284088e-02f, -7.80004426e-04f, -2.46765055e-02f, 4.12703156e-02f, -1.00173615e-02f, -2.39066407e-02f, 9.96248871e-02f, 2.76069697e-02f, 3.75067256e-02f, -6.31996170e-02f,
  6.52177352e-03f, 4.95924130e-02f, 5.24344370e-02f, -3.49844433e-02f, 7.61387777e-03f, 2.07218975e-02f, 2.73601934e-02f, -6.30627424e-02f, 1.55823473e-02f, -6.82804286e-02f,
  1.21658817e-01f, 2.79620085e-02f, -1.67385805e-02f, 1.02586783e-01f, -3.30062181e-01f, 1.80651501e-01f, 3.83865595e-01f, -2.12338924e-01f, 1.09562375e-01f, 1.86611250e-01f,
  -3.83134671e-02f, 3.65552381e-02f, 9.73710418e-02f, 3.77030410e-02f, -2.63876736e-01f, 7.52528310e-02f, 2.12385375e-02f, 8.77225921e-02f, -3.62471566e-02f, -1.09426990e-01f,
  -1.73408478e-01f, -2.79837638e-01f, -2.24848509e-01f, -2.91239917e-01f, -1.08029857e-01f, -4.15034220e-03f, -1.43714666e-01f, -1.25967879e-02f, -8.34482759e-02f, -5.95572367e-02f,
  4.67830561e-02f, 1.66685171e-02f, 7.00514168e-02f, 4.74135764e-03f, -3.46219130e-02f, 1.56740919e-01f, 2.02150699e-02f, 7.27800131e-02f, 7.65476525e-02f, -7.14908540e-03f,
  4.87731444e-03f, -1.16088443e-01f, -8.01974609e-02f, 1.62558015e-02f, 9.44323838e-02f, -4.25114259e-02f, -6.21538535e-02f, -1.09093999e-02f, 4.34340313e-02f, 4.14757431e-02f,
  6.49198741e-02f, -2.41704751e-02f, 1.22429967e-01f, 3.80224437e-02f, -9.28996801e-02f, 1.73120182e-02f, 7.01813325e-02f, 3.38839218e-02f, -9.40116495e-02f, -8.23779311e-03f,
  9.79391783e-02f, 5.61939217e-02f, 6.49787039e-02f, -1.50742322e-01f, 2.82953419e-02f, -1.15580205e-02f, 6.45481795e-02f, -9.34224017e-03f, 4.08467546e-04f, -9.39227827e-03f,
  -9.38584879e-02f, -2.18954775e-02f, -6.54912144e-02f, 1.06893182e-01f, 4.05634101e-03f, 9.35447402e-03f, -5.64177614e-03f, 2.48064213e-02f, -7.21013993e-02f, 5.53106843e-03f,
  5.73824197e-02f, 1.01369526e-02f, -7.79921114e-02f, -4.00554873e-02f, 3.05785351e-02f, 3.88100632e-02f, 2.42070705e-02f, 8.83032568e-04f, -8.62154663e-02f, -4.95167933e-02f,
  -1.98440090e-01f, -1.65004700e-01f, -5.89542091e-03f, -1.87143032e-02f, -8.36559851e-03f, -4.67152782e-02f, -4.06624787e-02f, 2.22864095e-02f, 8.65764264e-03f, 7.96283484e-02f,
  9.34020709e-03f, 6.91524372e-02f, -1.48026012e-02f, 3.88820060e-02f, -5.49588501e-02f, -1.02505703e-02f, 3.50543298e-02f, -3.37619521e-02f, -1.10464796e-01f, -5.55917583e-02f,
  -6.59646764e-02f, -8.22418332e-02f, 2.74722427e-02f, -7.30583146e-02f, 8.99732932e-02f, -1.65860392e-02f, -3.61252055e-02f, 2.32078508e-02f, -4.53898124e-02f, -1.63745079e-02f,
  1.12166524e-01f, 8.00560191e-02f, -2.57701755e-01f, -8.95528123e-02f, 3.53965312e-01f, -8.50928277e-02f, -8.23079124e-02f, 2.02095419e-01f, -1.96625575e-01f, 2.14451134e-01f,
  1.23327121e-01f, -1.04967937e-01f, -1.03366248e-01f, 7.28551969e-02f, -3.67863894e-01f, -3.96264941e-01f, -9.64098722e-02f, -3.12745385e-02f, -1.35739952e-01f, 1.88956544e-01f,
  -1.13954008e-01f, 2.54953772e-01f, -8.82464200e-02f, 1.69875681e-01f, 2.27609113e-01f, -3.84201705e-02f, 1.26115113e-01f, -6.41802326e-02f, 1.93982512e-01f, 3.60411182e-02f,
  2.39158440e-02f, 5.11389673e-02f, 4.38051634e-02f, -1.00869179e-01f, 3.83845121e-02f, 2.23203916e-02f, -2.14343965e-02f, -1.07084028e-01f, -3.40598114e-02f, -2.97696386e-02f,
  -1.27746416e-02f, 2.49614622e-02f, -4.82809618e-02f, 3.92540265e-03f, 1.45768493e-01f, -5.72846085e-02f, 1.76697318e-02f, 5.27552366e-02f, -9.15422395e-04f, -2.90934443e-02f,
  -1.01963401e-01f, -5.11323214e-02f, -9.71804410e-02f, 1.24382079e-02f, -5.00968583e-02f, -7.95879308e-03f, -7.20137283e-02f, -7.98070729e-02f, -8.65178555e-02f, 8.84751901e-02f,
  -3.18350904e-02f, -1.91004842e-03f, -3.02993096e-02f, -4.56743352e-02f, 1.79191865e-02f, 3.47903818e-02f, 1.52041679e-02f, 2.81695537e-02f, -1.86406262e-02f, 2.75118500e-02f,
  -1.20572513e-02f, 3.87953073e-02f, -2.31340658e-02f, -1.88300349e-02f, 9.60279033e-02f, -4.69994061e-02f, -7.37532601e-02f, 5.90770738e-03f, 3.66747901e-02f, -2.61542536e-02f,
  -6.86646923e-02f, 7.42027536e-02f, 4.78689708e-02f, 6.29609451e-02f, -1.29396230e-01f, 4.34518494e-02f, 6.28407523e-02f, 2.16290914e-02f, -9.16839689e-02f, -2.03931127e-02f,
  2.44968757e-01f, 5.53060994e-02f, -1.04676827e-03f, 5.65261468e-02f, 9.64561244e-04f, -4.54930849e-02f, -1.18299849e-01f, -7.18876719e-02f, -5.34166433e-02f, -3.04207280e-02f,
  -6.29696548e-02f, 8.49891230e-02f, -2.81633120e-02f, 5.94367534e-02f, 4.03841250e-02f, 3.25938426e-02f, -1.21382773e-02f, 2.60393638e-02f, 5.70427217e-02f, 1.68816268e-01f,
  6.24660924e-02f, 4.84313704e-02f, -7.23252669e-02f, 2.85968892e-02f, 9.47430581e-02f, 8.83265957e-02f, 4.83083278e-02f, -1.78815257e-02f, -2.92608384e-02f, -2.71921698e-03f,
  1.60365671e-01f, -3.26334357e-01f, -3.02891761e-01f, 1.35688603e-01f, 1.06539339e-01f, -3.33117068e-01f, -2.47683123e-01f, 1.93090737e-01f, -4.97307107e-02f, -7.16827512e-02f,
  3.39971960e-01f, -2.28937745e-01f, -1.39055133e-01f, 3.97992611e-01f, 9.28684771e-02f, 3.84959504e-02f, 1.75060958e-01f, -4.77608144e-02f, -2.81713717e-02f, 1.92702711e-02f,
  9.26784277e-02f, 3.65164876e-01f, 2.92186946e-01f, 4.83731776e-02f, 1.32381737e-01f, -6.32250169e-03f, 1.31517693e-01f, -1.67914003e-01f, 1.55145586e-01f, 2.10490171e-02f,
  6.18328117e-02f, 1.43288121e-01f, -2.71826554e-02f, -8.90736580e-02f, 4.34765741e-02f, -3.60039473e-02f, -1.25996888e-01f, -2.77517699e-02f, 4.05163914e-02f, 5.85081347e-04f,
  -1.44217715e-01f, 2.00489517e-02f, -6.71944954e-03f, -1.12405717e-01f, -7.64016658e-02f, -6.96802214e-02f, 5.73485903e-02f, 1.92355970e-03f, -1.65194292e-02f, 4.94881272e-02f,
  -3.99814434e-02f, -4.33110110e-02f, 6.27335459e-02f, -5.53050963e-03f, 4.76671048e-02f, 3.77368890e-02f, -8.84574652e-02f, -1.22468442e-01f, -9.91505757e-02f, -2.65035965e-02f,
  4.62263264e-02f, -5.79101294e-02f, -3.59672792e-02f, 3.02792974e-02f, -6.66682050e-02f, 7.15873688e-02f, -4.11092192e-02f, 5.14909253e-02f, -2.80025392e-03f, -3.97896487e-03f,
  7.99685046e-02f, -7.69230649e-02f, 1.60055552e-02f, -2.60578934e-02f, 4.20817686e-03f, -3.76998335e-02f, -7.87425488e-02f, 5.74487299e-02f, 3.55364494e-02f, 2.87553277e-02f,
  -3.64941661e-03f, 7.12556019e-02f, -7.40599185e-02f, 1.07614314e-02f, -8.38550478e-02f, 2.13706866e-03f, 6.95892721e-02f, -3.36254165e-02f, 6.18420355e-02f, -5.28520830e-02f,
  -9.95276347e-02f, -9.72908884e-02f, 2.85986383e-02f, 3.93495150e-02f, -4.48341556e-02f, -1.01780161e-01f, -3.29319090e-02f, 1.39074683e-01f, -1.15890361e-01f, 1.53161632e-02f,
  3.22820595e-03f, -6.78141937e-02f, -3.63578834e-02f, 7.04402104e-02f, -4.53350581e-02f, 1.08128339e-02f, -4.62725051e-02f, -1.04264677e-01f, 6.15966432e-02f, 2.24683341e-02f,
  -2.12727673e-02f, 2.67750900e-02f, -5.85632212e-02f, 1.95635296e-02f, 7.86382481e-02f, -1.18421726e-02f, -2.35796850e-02f, -2.80055180e-02f, 8.75791721e-03f, -6.35387674e-02f,
  -4.56088722e-01f, 3.61742020e-01f, -3.52151021e-02f, -1.84234574e-01f, -4.39552739e-02f, 1.16389155e-01f, -7.59279355e-02f, 7.93319568e-02f, -1.87425241e-01f, 3.79003793e-01f,
  -1.22518186e-03f, 7.14173494e-03f, -1.08231574e-01f, 1.14355370e-01f, -5.22256017e-01f, -1.37433112e-01f, -3.41756642e-02f, 8.33073556e-02f, -6.03730977e-02f, 1.75718106e-02f,
  -1.51265979e-01f, -9.61544514e-02f, -7.69455060e-02f, 2.09103391e-01f, 1.47206068e-01f, 1.43362805e-01f, -1.05316071e-02f, 9.68190730e-02f, 1.58328071e-01f, -6.08687580e-04f,
  1.70367986e-01f, 3.24707702e-02f, 6.02725558e-02f, 2.03381497e-02f, -6.53042048e-02f, 6.40055835e-02f, 6.79038465e-02f, -3.66787128e-02f, -3.15749794e-02f, 1.79094020e-02f,
  5.24818199e-04f, -3.00936550e-02f, -3.39571834e-02f, -3.06768548e-02f, 8.43222737e-02f, 5.41339628e-02f, -3.15340720e-02f, 5.90611883e-02f, -6.75991271e-03f, 2.50846930e-02f,
  -5.35394019e-03f, -1.13780582e-02f, -7.79704452e-02f, 1.24394204e-02f, -7.97773153e-02f, -1.55154278e-03f, -1.16524622e-02f, 3.74027342e-02f, -1.15015954e-02f, 2.85153314e-02f,
  -1.16058163e-01f, 2.52329595e-02f, 6.62043970e-03f, 8.54310468e-02f, -5.77298738e-02f, -2.59259474e-02f, -2.26371903e-02f, 1.62964780e-02f, -7.79686437e-04f, 3.16257589e-02f,
  -2.23205108e-02f, -1.79048609e-02f, 7.97106326e-02f, -2.03942992e-02f, -2.47971658e-02f, 5.43890223e-02f, 1.12404674e-02f, 8.98535997e-02f, 1.38061522e-02f, 5.15667684e-02f,
  5.11328466e-02f, -1.74307059e-02f, 5.65086082e-02f, 4.03228588e-02f, 1.86547842e-02f, -6.37401342e-02f, -3.84924226e-02f, 1.19543888e-01f, 6.15888797e-02f, -1.22331776e-01f,
  1.80913340e-02f, -1.48668155e-01f, -3.27233635e-02f, 2.61615850e-02f, 2.21905727e-02f, 8.52889344e-02f, 5.14432206e-04f, -2.85051987e-02f, -6.87171519e-02f, -7.89728910e-02f,
  2.92688329e-02f, -2.44489815e-02f, 2.96149515e-02f, 6.60827756e-03f, -6.49508163e-02f, -1.26680769e-02f, -2.99281124e-02f, 3.12382076e-02f, -9.54933167e-02f, -4.15282324e-03f,
  4.47780602e-02f, 4.30489816e-02f, -5.51047251e-02f, -4.26655076e-02f, -8.71688593e-03f, -4.56984043e-02f, 5.43571822e-02f, 2.04170663e-02f, -7.37265218e-03f, 4.56310399e-02f,
  3.10859293e-01f, -5.18469997e-02f, 1.20082282e-01f, 1.27105713e-01f, 7.57032409e-02f, 2.11812481e-01f, 2.10555986e-01f, 3.69151011e-02f, 1.98870078e-01f, -1.62231863e-01f,
  1.05102803e-03f, -7.42414594e-02f, -1.36066720e-01f, -1.85403109e-01f, -1.70673549e-01f, -2.89690614e-01f, -1.71637043e-01f, -1.80641204e-01f, -1.89962760e-01f, -5.12122586e-02f,
  -1.32786557e-01f, -2.45726272e-01f, -2.86940187e-01f, -1.58151805e-01f, 3.53051983e-02f, 1.90984905e-02f, -2.21701130e-01f, -1.16913959e-01f, -1.30419657e-02f, -1.28083606e-03f,
  3.26373428e-02f, -6.51917094e-03f, -4.22061384e-02f, 1.01032510e-01f, -8.23650658e-02f, 1.98238553e-03f, -3.84207778e-02f, 1.06295301e-02f, 1.22484870e-01f, 6.44961149e-02f,
  5.26104756e-02f, 4.27340679e-02f, -3.24377953e-03f, -3.39809386e-03f, 1.26612723e-01f, 1.00152664e-01f, 4.71981987e-03f, 1.50587931e-02f, 4.29359451e-02f, 9.00328625e-03f,
  2.44858321e-02f, -4.51223785e-03f, 8.43647271e-02f, -2.64624692e-02f, 2.14659758e-02f, 6.85836449e-02f, 5.94576858e-02f, -3.57447402e-03f, 2.17032749e-02f, -3.43329906e-02f,
  -6.45918325e-02f, -1.08425887e-02f, 6.97447583e-02f, -4.97876108e-02f, 4.32955241e-03f, 4.65823747e-02f, 6.00480475e-02f, -5.57315499e-02f, 6.18572980e-02f, 4.99364696e-02f,
  -2.51057874e-02f, 3.51765044e-02f, 4.72470149e-02f, 1.52152255e-01f, -2.41225343e-02f, -3.06463242e-02f, 3.39403749e-02f, 2.68914346e-02f, -4.41299565e-02f, -1.34356804e-02f,
  4.68627103e-02f, 5.13003208e-02f, -1.35498255e-01f, 5.96839115e-02f, -1.95596311e-02f, 1.38194291e-02f, 8.76161009e-02f, 9.38827842e-02f, -7.04548582e-02f, -4.12403531e-02f,
  -5.46177626e-02f, -1.99355930e-01f, -1.64816044e-02f, 6.53914884e-02f, -5.22403307e-02f, -6.06838018e-02f, -1.45182628e-02f, 7.32507929e-02f, -4.30472456e-02f, 8.78665820e-02f,
  1.07879806e-02f, 3.92508097e-02f, -5.71438707e-02f, 5.49909994e-02f, -5.74522130e-02f, 6.61742836e-02f, -1.00926897e-02f, 4.51566931e-03f, -8.38818252e-02f, -5.22194020e-02f,
  2.54079066e-02f, -1.83599386e-02f, -1.42897042e-02f, 1.87653454e-03f, -3.86640267e-03f, -2.24387161e-02f, -1.33595653e-02f, 2.25971802e-03f, 3.19887027e-02f, -6.34472743e-02f,
  -3.99836540e-01f, 5.84373735e-02f, 2.23842457e-01f, 2.03518748e-01f, -2.66789317e-01f, -3.16991746e-01f, 3.09478134e-01f, -1.74006641e-01f, -1.52431265e-01f, 3.77108604e-02f,
  2.49005869e-01f, 5.58287464e-02f, 2.03056201e-01f, 5.00827432e-02f, -1.40900731e-01f, 1.32495046e-01f, -8.38514343e-02f, 1.39281943e-01f, 4.95532416e-02f, 3.57376933e-02f,
  -7.13764504e-02f, -1.08330436e-01f, 3.24060053e-01f, -1.07345618e-01f, 1.15756551e-02f, 4.41437066e-02f, 6.84884191e-02f, 2.96499431e-02f, -1.47168115e-01f, 4.32848856e-02f,
  6.15533963e-02f, 1.24644160e-01f, 1.66240767e-01f, 3.42836939e-02f, -5.00233397e-02f, -5.89558631e-02f, 4.73626442e-02f, 4.39191610e-03f, 6.63367659e-02f, 8.41083471e-03f,
  -2.36777011e-02f, -6.93339631e-02f, 2.63917986e-02f, 3.21899503e-02f, -6.75269738e-02f, 4.21643220e-02f, -7.87476301e-02f, 8.62718187e-03f, 3.38556357e-02f, 7.00532719e-02f,
  2.97850929e-02f, -3.36514860e-02f, -7.62559623e-02f, 8.24482515e-02f, -6.41951784e-02f, 3.50435749e-02f, 2.97751240e-02f, 7.26126805e-02f, -7.28917047e-02f, -3.22041623e-02f,
  -4.23195474e-02f, -1.69832721e-01f, -1.16744459e-01f, -5.98625503e-02f, -6.75905049e-02f, 7.30026662e-02f, 1.02898022e-02f, -1.24297384e-02f, 6.95966855e-02f, -9.24714133e-02f,
  -6.19691052e-02f, -4.49625514e-02f, -5.15508689e-02f, -6.05781078e-02f, -8.62139463e-02f, -3.90696377e-02f, 7.22813979e-02f, -7.46773789e-03f, 8.08096603e-02f, -2.16358551e-03f,
  5.76581396e-02f, -1.15629189e-01f, -2.07433105e-03f, 6.09748587e-02f, -5.58883250e-02f, -3.89252715e-02f, 3.66703607e-02f, -2.01435722e-02f, 6.50224462e-02f, -8.51971805e-02f,
  -1.64921060e-02f, -3.57190706e-02f, 1.08202703e-01f, -8.44103191e-03f, 7.55193159e-02f, -1.74129456e-01f, 3.53532881e-02f, -1.21585973e-01f, -3.63370380e-03f, -1.45386353e-01f,
  -1.02387026e-01f, 6.09422848e-02f, -7.48677105e-02f, -2.19793413e-02f, 1.02683812e-01f, 1.77169964e-02f, -5.67876250e-02f, 7.87675530e-02f, 2.08599158e-02f, -1.74405798e-02f,
  -4.62656654e-02f, -5.94194345e-02f, 4.66565741e-03f, -6.20934479e-02f, -6.98032677e-02f, 1.41123697e-01f, -3.07057668e-02f, 1.87721173e-03f, 2.02839989e-02f, 6.87791109e-02f,
  5.88324726e-01f, -1.35927349e-01f, 1.42199188e-01f, 3.44802827e-01f, 8.36170688e-02f, 1.73816234e-01f, 2.46199325e-01f, 8.76909960e-03f, 1.47849306e-01f, -2.58989662e-01f,
  -7.63496608e-02f, 1.67005494e-01f, -2.25941122e-01f, 2.05398917e-01f, 4.27790254e-01f, -1.81036398e-01f, 3.76812905e-01f, 8.83556008e-02f, -1.24300912e-01f, 1.47986338e-01f,
  1.48538589e-01f, 1.38906956e-01f, 4.08005379e-02f, -1.27503842e-01f, 1.38967484e-01f, -5.90239055e-02f, -5.34349494e-02f, -1.75814062e-01f, 5.20582236e-02f, -7.01959711e-04f,
  -7.42440522e-02f, -1.40138283e-01f, -2.82336790e-02f, -1.01144671e-01f, 8.20143148e-02f, -3.91887547e-03f, 4.65766899e-02f, -3.32952701e-02f, -3.14931981e-02f, 1.89235508e-02f,
  1.92482937e-02f, 7.87212476e-02f, 5.99413440e-02f, -2.20235586e-02f, 3.23274136e-02f, 1.49854058e-02f, -1.19539713e-02f, -7.74672162e-03f, -8.88713077e-02f, 1.35132134e-01f,
  -3.70334066e-03f, 3.01820971e-02f, 1.31889582e-01f, 2.67675314e-02f, 8.87785852e-02f, 1.25916889e-02f, 4.89201732e-02f, 1.93352066e-02f, 1.44898938e-02f, 7.53402337e-02f,
  7.74609149e-02f, 7.29728118e-02f, -1.69250779e-02f, -4.97363620e-02f, -5.22163846e-02f, -2.93987393e-02f, -7.70963123e-03f, -7.38081336e-02f, -1.42442835e-02f, 7.63061717e-02f,
  1.26449326e-02f, -2.19713873e-03f, 1.09678786e-02f, -5.57610160e-03f, 3.20128873e-02f, 4.52641584e-02f, 6.42343536e-02f, -7.26343468e-02f, 6.54380545e-02f, -3.25799473e-02f,
  -1.66004375e-02f, 7.94501218e-04f, -8.79761577e-02f, -3.43931839e-02f, 2.49759071e-02f, 2.77249739e-02f, 4.56395112e-02f, 6.27309605e-02f, -9.00702327e-02f, 9.33744237e-02f,
  1.82630736e-02f, 1.26245305e-01f, -2.26327702e-02f, 1.11838887e-02f, -2.74166167e-02f, 3.83926146e-02f, 3.46519612e-02f, 1.19815752e-01f, -3.28856148e-02f, 3.27659631e-03f,
  1.70413002e-01f, -2.95449491e-03f, -3.18823718e-02f, -1.52721405e-02f, 6.44164979e-02f, 1.05393054e-02f, 7.99272384e-04f, -2.32064165e-03f, 6.70593604e-02f, 3.39047574e-02f,
  3.50230397e-03f, 6.41546175e-02f, 7.53082260e-02f, 2.37869541e-03f, 3.51690091e-02f, 5.12019433e-02f, 6.33980557e-02f, -9.87973250e-03f, 3.80623937e-02f, -2.96503212e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.74662572e-01f, 3.19373041e-01f, -8.63253102e-02f, -1.26868084e-01f, -2.29614466e-01f, -3.36800814e-01f, -1.46627486e-01f, -1.49744749e-01f, 7.40813985e-02f, 3.09004366e-01f,
  1.24624399e-02f, 1.02378480e-01f, 1.98730126e-01f, 4.77074124e-02f, -4.36941832e-01f, 2.72797912e-01f, -1.76556513e-01f, -1.85135063e-02f, 5.25587238e-02f, -2.83917397e-01f,
  -1.71878099e-01f, -1.99009120e-01f, -6.18080534e-02f, -8.92900899e-02f, -2.02708632e-01f, 4.59637381e-02f, -3.73434238e-02f, -8.30451548e-02f, -9.69493110e-03f, 1.03431810e-02f,
  -2.50128090e-01f, -1.07601993e-01f, -3.04686241e-02f, -4.36180569e-02f, -1.78945333e-01f, -8.99833292e-02f, -8.23800042e-02f, -6.51054308e-02f, -9.00034159e-02f, -4.17881412e-03f,
  4.37815636e-02f, -4.71935496e-02f, -2.07186323e-02f, 5.58119267e-03f, -1.71618145e-02f, 1.19371619e-02f, 5.87428547e-02f, 5.75520284e-02f, -4.46404368e-02f, 3.42357121e-02f,
  -3.81130800e-02f, 8.00266564e-02f, -1.07852528e-02f, 1.26160428e-01f, 2.72834972e-02f, 2.23119631e-02f, -3.03768199e-02f, -3.22146676e-02f, -9.64387506e-03f, -8.93694013e-02f,
  2.05014553e-02f, -5.60915619e-02f, -2.63851974e-02f, -9.83748585e-04f, -8.31463467e-03f, 4.97807413e-02f, -1.07840132e-02f, -9.19831172e-03f, 1.66467428e-02f, -2.89121899e-03f,
  2.43730494e-03f, 2.40858141e-02f, -3.48383188e-03f, -3.11619118e-02f, 6.98172301e-02f, 2.26642215e-03f, -2.74781026e-02f, -3.83768044e-02f, 2.23725997e-02f, -1.01043489e-02f,
  -7.93612450e-02f, -7.62857124e-02f, 1.01116739e-01f, -6.87422156e-02f, -6.27907291e-02f, -2.56714988e-02f, -1.29597876e-02f, 2.04885770e-02f, 6.12758333e-03f, -1.51458263e-01f,
  -4.83894348e-01f, -4.08708423e-01f, -4.80103157e-02f, -7.94802755e-02f, -8.10056776e-02f, -6.08029068e-02f, -6.89315377e-03f, 2.65505817e-02f, -1.09259307e-01f, -6.60929754e-02f,
  -5.24196997e-02f, 1.67710502e-02f, -1.11306816e-01f, 2.59583052e-02f, -5.74615151e-02f, -8.43888000e-02f, -9.62079167e-02f, 1.36351567e-02f, -1.65771171e-01f, -3.70549634e-02f,
  -4.62539196e-02f, -5.75504452e-02f, -3.96103449e-02f, -3.36782448e-02f, 5.42046800e-02f, -1.89955682e-02f, -9.03025046e-02f, 5.38493618e-02f, -7.19828457e-02f, 1.58916302e-02f,
  -2.87313964e-02f, -2.09589824e-01f, -4.23476309e-01f, -3.57404560e-01f, -4.22925912e-02f, -2.40463883e-01f, -2.38732100e-01f, -6.43208399e-02f, -1.25655130e-01f, 3.19554329e-01f,
  -2.41635870e-02f, -1.47659644e-01f, 1.61377952e-01f, -4.82366264e-01f, -3.53626758e-01f, -7.00521693e-02f, -5.14737248e-01f, -2.85253227e-01f, 9.44528282e-02f, -7.66477361e-02f,
  -5.68750575e-02f, -1.35667220e-01f, -3.47923696e-01f, 1.30139202e-01f, -2.13538378e-01f, 9.67655852e-02f, 2.72603899e-01f, 1.78434044e-01f, -1.06801033e-01f, -7.85961673e-02f,
  -1.29909053e-01f, -6.01687469e-02f, -6.12366572e-02f, 1.88775621e-02f, 4.79520671e-03f, 6.10523038e-02f, 3.78486365e-02f, -6.59812614e-02f, -9.38742189e-04f, -4.99051809e-02f,
  3.48067260e-03f, 3.76359262e-02f, -1.03080794e-01f, 5.62936477e-02f, -7.59074930e-03f, -3.60687287e-03f, 4.14801203e-02f, 4.65887114e-02f, -6.26050681e-02f, -1.03053384e-01f,
  -1.52009487e-01f, -4.56574969e-02f, -1.71987852e-03f, -7.77947828e-02f, -2.18107942e-02f, -3.27961668e-02f, -5.07103018e-02f, -6.72013834e-02f, -6.91871066e-03f, -4.38965075e-02f,
  1.35052474e-02f, 1.61038399e-01f, 1.42371058e-01f, 4.17468213e-02f, 7.58724660e-02f, 8.07975009e-02f, 4.59314808e-02f, 3.21200676e-02f, 7.14497417e-02f, -5.92544861e-02f,
  8.58394429e-02f, -5.55345230e-03f, 5.74380010e-02f, 3.41763236e-02f, -1.88012794e-02f, -5.60487062e-02f, -1.22728013e-02f, 5.17624281e-02f, -1.55621067e-01f, -2.81650759e-02f,
  9.67495665e-02f, 4.78714220e-02f, 3.40726599e-02f, 3.96612333e-03f, -1.01614766e-01f, 9.02418792e-02f, 1.70874417e-01f, -2.24477984e-02f, 2.32359581e-02f, 8.25215206e-02f,
  -8.06569308e-02f, 6.02791943e-02f, -4.93948981e-02f, 1.98416673e-02f, -1.25648873e-02f, 4.40046191e-02f, -5.29328696e-02f, -1.36600867e-01f, -5.62107824e-02f, 1.31885838e-02f,
  6.64400961e-03f, 6.51197731e-02f, 1.83461890e-01f, -1.12910969e-02f, -7.29791075e-02f, -5.87746175e-03f, 3.22571248e-02f, 5.16755097e-02f, -1.39986845e-02f, 1.32634118e-02f,
  9.98133123e-02f, 1.83201060e-01f, -5.97438067e-02f, 4.55663204e-02f, 3.93748879e-02f, 5.46354279e-02f, 6.41008765e-02f, -5.61274774e-03f, 6.31965846e-02f, -1.30812796e-02f,
  -4.20098364e-01f, 4.25755739e-01f, -3.71170347e-03f, -3.59025657e-01f, 1.76516294e-01f, 7.50627369e-02f, -4.42422867e-01f, 1.02266230e-01f, 2.90709175e-02f, -1.37672678e-01f,
  -2.44847372e-01f, 5.52974977e-02f, 1.60700321e-01f, -2.69382060e-01f, 1.80232942e-01f, 2.24360093e-01f, -1.63060293e-01f, -2.45255306e-01f, 2.57377326e-01f, -1.44537911e-01f,
  9.22464952e-02f, -1.84525549e-01f, -5.84821105e-02f, 1.05182610e-01f, -2.40238011e-01f, -2.08315954e-01f, -2.13377133e-01f, 2.41316911e-02f, -2.39712298e-01f, 9.14075375e-02f,
  -1.61129817e-01f, -2.84488887e-01f, -3.63950729e-01f, -9.54094753e-02f, -1.55570552e-01f, -3.43648493e-02f, -1.46409690e-01f, -3.28693539e-02f, -2.62464657e-02f, 7.22356932e-03f,
  3.48944664e-02f, 7.66171739e-02f, 3.59685495e-02f, 2.35204082e-02f, -1.29481708e-03f, -1.06440052e-01f, 3.20452973e-02f, -1.11410119e-01f, -7.62911960e-02f, 1.43634319e-01f,
  5.96670732e-02f, 6.16188124e-02f, -1.07032120e-01f, -2.08876431e-02f, -3.76097187e-02f, -1.32572874e-01f, -7.16887712e-02f, 2.62119360e-02f, -5.94633035e-02f, 3.58785875e-02f,
  4.44610715e-02f, 1.10643230e-01f, -7.87990689e-02f, 2.85675917e-02f, -2.43470687e-02f, -2.07157619e-02f, -1.12039000e-02f, -1.78173780e-02f, -3.70552018e-02f, 2.83496622e-02f,
  -4.39673550e-02f, -7.27886111e-02f, 3.41593064e-02f, 3.38871144e-02f, 4.90284816e-04f, -5.14010973e-02f, -3.94403376e-02f, -7.46186636e-03f, 3.51896584e-02f, 5.68667054e-03f,
  -6.98680654e-02f, 1.53385364e-02f, -3.27433087e-02f, 6.47850148e-03f, 7.57073518e-03f, 4.14250828e-02f, 5.69260381e-02f, -1.50109753e-02f, -4.68312837e-02f, 2.94923298e-02f,
  -1.56911507e-01f, -2.38766983e-01f, -5.15131317e-02f, -8.11985433e-02f, -7.97293615e-03f, 2.09611841e-02f, 4.47523445e-02f, -1.12903928e-02f, -9.75882560e-02f, -2.24479605e-02f,
  3.86785939e-02f, -2.15053465e-02f, 1.13169253e-02f, 6.37141708e-03f, 8.84881243e-02f, -2.01469343e-02f, -9.44264978e-02f, -4.90494445e-02f, -7.92144537e-02f, 1.06051192e-01f,
  3.53821088e-03f, 2.91880574e-02f, 1.34190116e-02f, -4.86894436e-02f, -4.42254394e-02f, -1.21846348e-01f, 7.38382293e-03f, 7.67979696e-02f, 3.95780802e-03f, 6.66484758e-02f,
  1.91026419e-01f, -3.81029397e-01f, 7.36009702e-02f, 4.58352089e-01f, 2.88774580e-01f, 2.02150822e-01f, 3.95761460e-01f, 3.72454710e-02f, 4.25708354e-01f, -4.80656385e-01f,
  -1.68166116e-01f, -3.18577141e-01f, -4.03155088e-01f, 8.51974860e-02f, 3.20514351e-01f, 5.93958015e-04f, 3.18982899e-01f, 2.96367139e-01f, 2.92857140e-01f, -1.03425130e-01f,
  8.79348591e-02f, -1.14342280e-01f, -1.70370147e-01f, -1.35687560e-01f, -1.17953464e-01f, 7.32003674e-02f, -1.05572812e-01f, 1.51694268e-01f, -3.45910154e-02f, 2.43007272e-01f,
  6.40921071e-02f, 7.48582557e-02f, -7.28504881e-02f, -1.79154836e-02f, -5.62723950e-02f, -3.96113284e-03f, 1.08287923e-01f, 9.51328874e-02f, 2.05439508e-01f, -1.15527436e-01f,
  -1.64464667e-01f, -7.36249909e-02f, -3.82988267e-02f, 1.75784901e-02f, 1.55969471e-01f, -1.91453937e-03f, -3.76800075e-02f, -9.79741588e-02f, -3.40811908e-02f, -1.59362793e-01f,
  -7.46991932e-02f, -9.71024185e-02f, -1.49089247e-02f, 4.37660553e-02f, -6.26721606e-02f, 9.41543356e-02f, 9.00356174e-02f, 6.19141869e-02f, -3.17729712e-02f, 9.29366872e-02f,
  -6.67738318e-02f, 1.83131963e-01f, -1.38602078e-01f, 2.55968198e-02f, -1.66611429e-02f, -4.62302864e-02f, -5.60369296e-03f, -5.65462969e-02f, 2.56473478e-02f, -5.83460890e-02f,
  4.28594798e-02f, -2.37394758e-02f, 9.38589722e-02f, 1.59528419e-01f, 8.56461972e-02f, -7.34821369e-04f, 8.01483449e-03f, 7.60727227e-02f, -5.19787557e-02f, -1.79352555e-02f,
  4.70655933e-02f, 1.33444026e-01f, -1.17262922e-01f, -3.85184959e-02f, 1.10534802e-01f, -1.19658113e-01f, -5.24772853e-02f, -4.02708203e-02f, 7.04864785e-03f, -1.00506209e-02f,
  3.59017514e-02f, 1.25137642e-01f, -8.38097930e-02f, -9.12704244e-02f, 8.50054920e-02f, -1.25344485e-01f, 4.50730175e-02f, -5.63185662e-03f, 1.90031976e-01f, -7.56248981e-02f,
  -8.22661817e-02f, -3.44820134e-02f, -4.97367382e-02f, 4.19609398e-02f, -1.10869799e-02f, -2.02588826e-01f, 6.27288744e-02f, 1.19010359e-01f, 1.00915186e-01f, -2.14017332e-02f,
  -5.58460616e-02f, -4.04699817e-02f, -8.76978040e-02f, -3.73284258e-02f, -1.20874695e-01f, -5.44829667e-02f, -2.07532123e-02f, 6.61178827e-02f, -1.73224621e-02f, 5.26717454e-02f,
  2.78105676e-01f, -2.39959523e-01f, 3.76858890e-01f, 1.27370849e-01f, 2.29306057e-01f, 2.24634990e-01f, 3.18166465e-01f, -7.40494356e-02f, -2.48119324e-01f, -4.14520442e-01f,
  -1.17743604e-01f, 2.91517019e-01f, 1.74872622e-01f, -1.95356444e-01f, 2.45333627e-01f, -9.68614966e-02f, -2.38256827e-01f, -1.96909651e-01f, -1.04936399e-01f, -2.18326494e-01f,
  -1.39529049e-01f, -4.07748401e-01f, 1.62594408e-01f, -4.60436612e-01f, 3.22876237e-02f, -8.48937929e-02f, -1.65595368e-01f, 6.56713471e-02f, -1.54638603e-01f, 3.97666804e-02f,
  -5.69329411e-02f, -1.85939759e-01f, 1.37300771e-02f, -7.80357942e-02f, -3.18264440e-02f, 2.02964693e-02f, 2.10333709e-02f, 6.56415746e-02f, -5.24167484e-03f, 6.44524535e-03f,
  7.29966629e-03f, 1.54962754e-02f, -2.75557209e-02f, 5.69101535e-02f, -1.04643116e-02f, 7.28623271e-02f, 6.65262267e-02f, 1.13389529e-01f, 2.45820754e-03f, 2.06747159e-01f,
  1.02356777e-01f, 1.97164118e-01f, 1.52833104e-01f, 5.70289791e-02f, 1.17019251e-01f, 1.28548322e-02f, 5.42776436e-02f, 2.01893136e-01f, 8.58225152e-02f, 1.72387883e-02f,
  -6.14329018e-02f, -7.31809735e-02f, 3.89758907e-02f, -7.59901712e-03f, -2.95898132e-02f, -1.77986119e-02f, 2.39998177e-02f, 2.88563734e-03f, 5.02620265e-03f, 5.48289604e-02f,
  -9.98011697e-03f, 9.48914886e-02f, -3.38175334e-02f, 6.52729198e-02f, -3.21304463e-02f, 4.20397967e-02f, 7.63391033e-02f, 6.34880289e-02f, -3.26412097e-02f, 5.10698929e-02f,
  -5.73411211e-03f, -3.17174047e-02f, 1.23912673e-02f, 4.98749055e-02f, -9.34676751e-02f, 1.03737883e-01f, -3.56115699e-02f, 6.34262636e-02f, -6.11326396e-02f, -2.34306250e-02f,
  -2.59104908e-01f, -4.89558369e-01f, -1.28091604e-01f, -6.73147365e-02f, -7.43611977e-02f, -2.83784550e-02f, -1.56625420e-01f, -3.12686041e-02f, -6.08648509e-02f, -3.36720906e-02f,
  -5.36007062e-03f, 2.19889805e-02f, -3.38602997e-02f, 6.37755170e-02f, -1.49659425e-01f, 3.60758454e-02f, -3.68019231e-02f, -4.01094481e-02f, 2.12963056e-02f, -3.90050337e-02f,
  -5.64580900e-04f, 2.43488867e-02f, 3.67497280e-02f, -8.11666697e-02f, -1.06497765e-01f, 1.11162469e-01f, 2.98518818e-02f, -3.76540571e-02f, -1.27271134e-02f, -6.10851981e-02f,
  -3.50981355e-01f, 4.51516211e-01f, 2.99684227e-01f, -1.29658699e-01f, -1.27694592e-01f, -3.99443582e-02f, 9.70029160e-02f, 3.92465405e-02f, -7.91454036e-03f, 2.81672210e-01f,
  3.23495790e-02f, 4.01858985e-01f, 6.38826638e-02f, -1.54533997e-01f, -3.54175329e-01f, -2.77986854e-01f, -2.99677551e-01f, 7.48331174e-02f, 8.32550824e-02f, -5.03505580e-02f,
  -6.70989007e-02f, -1.89940929e-01f, -2.40006208e-01f, -1.28831878e-01f, 6.74377158e-02f, 1.45085558e-01f, -2.62497813e-01f, 2.25731328e-01f, -5.41811958e-02f, 5.26588187e-02f,
  1.47587797e-02f, 1.73400626e-01f, 2.60683149e-01f, 1.76409274e-01f, -2.18360107e-02f, 1.96103472e-02f, 1.17151968e-01f, 3.43983322e-02f, 4.59651463e-03f, 5.74646108e-02f,
  6.37314655e-03f, 8.25334713e-02f, -5.99824227e-02f, 9.05392095e-02f, 1.01113632e-01f, 7.24629611e-02f, 4.62371483e-02f, 8.63859709e-03f, 1.31237254e-01f, 2.05053072e-02f,
  1.96195632e-01f, 1.04301654e-01f, 4.32551987e-02f, 1.55593986e-02f, 2.89716572e-02f, 2.47273929e-02f, -5.78233115e-02f, 1.03970133e-01f, 1.18024729e-01f, 3.89508791e-02f,
  -1.14652932e-01f, -7.18370676e-02f, 1.67962000e-01f, -4.72147949e-02f, -3.45973822e-04f, -5.88804334e-02f, -2.99876630e-02f, -1.40712494e-02f, 1.18623367e-02f, -5.39269410e-02f,
  -4.88460697e-02f, 1.40092641e-01f, 3.68152908e-03f, -4.60868403e-02f, -8.16983134e-02f, 9.78999864e-03f, 3.83731257e-03f, 1.69751957e-01f, -5.70117049e-02f, 4.52319533e-03f,
  4.78661321e-02f, -3.44497636e-02f, -3.39345634e-02f, -6.14405721e-02f, 6.77941293e-02f, -1.70071721e-02f, 7.45883882e-02f, 7.72153363e-02f, -1.28388256e-01f, 4.41726707e-02f,
  -1.56743050e-01f, -1.24185964e-01f, 1.75992842e-03f, 2.30723858e-01f, 5.27753122e-02f, 1.43481687e-01f, 2.95874081e-03f, -6.24775738e-02f, -1.18317164e-01f, -6.88532442e-02f,
  7.80769577e-03f, -4.53069620e-02f, 5.46710491e-02f, 3.60972993e-02f, -5.78207262e-02f, -9.07975286e-02f, -7.78544471e-02f, -3.49281691e-02f, -4.18364704e-02f, 3.07047460e-02f,
  8.04343075e-02f, 4.02138121e-02f, -1.10005774e-02f, -4.92700972e-02f, 2.95022782e-03f, 8.04872364e-02f, -1.19522430e-01f, 1.56111658e-01f, -2.38455664e-02f, 1.58809237e-02f,
  -1.56251356e-01f, -8.54435265e-02f, 1.83154702e-01f, -2.70843357e-01f, -5.44089675e-02f, 1.96524933e-01f, -2.41825849e-01f, 1.92012146e-01f, -2.36025050e-01f, 9.47585702e-02f,
  -4.10045795e-02f, -3.11716169e-01f, -3.26791522e-03f, -2.94081807e-01f, -1.19067572e-01f, -2.31685132e-01f, 2.16951128e-02f, 1.48747422e-04f, -1.35953054e-01f, 2.82594889e-01f,
  6.66265860e-02f, -3.86357903e-01f, 1.95434317e-01f, 1.51464731e-01f, -2.17362624e-02f, 2.98772782e-01f, 2.75665224e-01f, 1.54055357e-01f, 2.60453314e-01f, -1.18768111e-01f,
  -4.96615730e-02f, -1.77965641e-01f, 3.39747854e-02f, -2.65226862e-03f, 3.08434725e-01f, 7.55818933e-02f, 1.17501818e-01f, -7.31795132e-02f, -8.50670487e-02f, -3.31658572e-02f,
  -1.66621618e-02f, -8.71108919e-02f, -2.89479569e-02f, -6.59326762e-02f, -4.29508314e-02f, -6.06022365e-02f, -1.91358570e-02f, 6.04131147e-02f, -8.89067259e-03f, -1.86071377e-02f,
  2.50398722e-02f, 4.50477041e-02f, -1.81914552e-03f, 2.01375838e-02f, -2.86295675e-02f, -2.31276788e-02f, 7.66940042e-02f, 2.62142092e-01f, -1.15593590e-01f, 1.19520821e-01f,
  1.12624750e-01f, -1.25323176e-01f, -7.51691759e-02f, -2.13318005e-01f, -3.30334716e-02f, -1.45850658e-01f, -1.92891344e-01f, -3.01043577e-02f, 6.82940101e-03f, -3.48296091e-02f,
  -2.15571318e-02f, 5.80561254e-03f, -2.19356254e-01f, -3.15241925e-02f, 1.04437187e-01f, -8.57595131e-02f, -4.65077534e-03f, 1.00964777e-01f, 1.07841320e-01f, 1.02014288e-01f,
  -2.74200320e-01f, -2.38434854e-03f, 2.17282344e-02f, 3.12792808e-02f, -1.10763341e-01f, 1.18912362e-01f, -6.76813424e-02f, 4.62827459e-02f, 1.06927261e-01f, 1.12040462e-02f,
  1.98054850e-01f, 1.97259799e-01f, 1.83167830e-02f, -1.47162244e-01f, -3.68686765e-02f, 1.47407847e-02f, -8.63682255e-02f, -1.22015169e-02f, 7.44879171e-02f, -1.53330471e-02f,
  1.59697071e-01f, 9.21461433e-02f, 3.16874720e-02f, 3.38117182e-02f, 3.11452318e-02f, 1.46122172e-01f, -6.96102977e-02f, -1.52124502e-02f, 8.52976292e-02f, 1.43986747e-01f,
  1.42673463e-01f, -3.19711491e-02f, -1.55080259e-01f, -1.20267859e-02f, -4.49271984e-02f, -1.92214232e-02f, 6.68358058e-02f, 8.46512243e-02f, -1.12019442e-02f, 2.73354575e-02f,
  -6.05640352e-01f, 6.12773478e-01f, -7.94687718e-02f, -2.06174385e-02f, -3.45328748e-02f, 6.32359743e-01f, 3.13825071e-01f, 2.19356090e-01f, 9.11644250e-02f, 3.07769895e-01f,
  8.13665316e-02f, -1.26436248e-01f, 1.48776487e-01f, 2.90192753e-01f, 1.57848924e-01f, 3.96495312e-01f, 3.47359717e-01f, 1.81733921e-01f, 1.25497594e-01f, -9.43666548e-02f,
  1.70501526e-02f, 1.15959033e-01f, 2.44413149e-02f, -9.73222312e-03f, -1.24976538e-01f, -2.53441155e-01f, -2.79610515e-01f, -3.60943340e-02f, 4.22875956e-02f, 6.67933822e-02f,
  2.66915541e-02f, -2.32501939e-01f, -2.24643975e-01f, -3.37442085e-02f, -3.02814972e-02f, -1.04135312e-01f, -1.88821591e-02f, -1.16267309e-01f, -1.11264274e-01f, 2.83417013e-02f,
  -9.93127376e-02f, 4.86589670e-02f, -5.15742302e-02f, 1.96983851e-03f, -7.84659311e-02f, -1.17802039e-01f, 4.60945182e-02f, 8.22985172e-02f, 1.08889081e-01f, 5.08330427e-02f,
  1.53855719e-02f, 1.46722673e-02f, -3.16150188e-02f, 1.22179791e-01f, -6.66894168e-02f, 6.25381321e-02f, 7.20370859e-02f, 1.53917894e-02f, 2.37794202e-02f, 8.79387781e-02f,
  -4.96792868e-02f, 1.56393368e-02f, 2.98125995e-03f, -5.21129407e-02f, -3.78414504e-02f, -6.75090626e-02f, -2.83623161e-03f, -1.42524410e-02f, -2.62107439e-02f, 3.82762142e-02f,
  -4.46544588e-02f, -9.27453637e-02f, -7.06382170e-02f, -4.41717692e-02f, -2.89096925e-02f, -3.30074579e-02f, -5.95648997e-02f, -1.02357730e-01f, -7.84982089e-03f, 1.11173550e-02f,
  -4.05957997e-02f, 1.92753933e-02f, -4.46122177e-02f, 7.89964385e-03f, 6.23751469e-02f, -3.84986624e-02f, -2.26561036e-02f, 6.89124987e-02f, -1.12063019e-02f, -2.47300928e-03f,
  4.13744241e-01f, 1.49957970e-01f, -4.59020585e-02f, -2.66387127e-02f, -1.33304596e-02f, 4.75768000e-02f, 4.37944382e-02f, 5.71604632e-03f, 9.43234339e-02f, -1.25342049e-02f,
  -1.20241299e-01f, -5.80671653e-02f, -4.55227494e-02f, -2.38469895e-02f, -1.61406468e-03f, 1.24226965e-01f, -5.94242550e-02f, -5.15117636e-03f, 4.72994447e-02f, -9.38460827e-02f,
  -1.44917041e-01f, -1.14149014e-02f, -5.12983166e-02f, -4.82342206e-02f, -1.01596221e-01f, -3.18042338e-02f, -5.20799048e-02f, -7.67789185e-02f, -3.84433530e-02f, 5.11878580e-02f,
  -8.15719426e-01f, 2.43626550e-01f, -1.27426088e-01f, -9.78833362e-02f, -4.00027543e-01f, -5.70370294e-02f, 4.36679535e-02f, 5.18584773e-02f, 4.71043624e-02f, 4.27172929e-01f,
  1.95478395e-01f, -1.05684988e-01f, 3.69350314e-01f, 1.36315182e-01f, -2.91867495e-01f, 4.75068092e-01f, 4.62311171e-02f, 5.53060956e-02f, -3.81692015e-02f, -1.13746859e-01f,
  -1.77900508e-01f, -5.80419935e-02f, -3.37303393e-02f, -1.31615242e-02f, -2.82429636e-01f, -2.00497597e-01f, -1.64102331e-01f, -8.16318616e-02f, -1.92778021e-01f, -2.49428838e-01f,
  -3.18233371e-01f, -2.54019558e-01f, -6.95265234e-02f, -1.64527059e-01f, -1.43413499e-01f, -5.35428710e-02f, -8.48644450e-02f, 2.64146049e-02f, -1.59368012e-02f, 4.39330610e-03f,
  4.05997075e-02f, 6.28616959e-02f, 6.99536949e-02f, 8.93696472e-02f, -1.04579940e-01f, -2.65024733e-02f, 3.16571929e-02f, -5.51950634e-02f, -3.00863981e-02f, 1.09484317e-02f,
  1.51108265e-01f, 2.16867235e-02f, -3.84144485e-02f, 3.90059613e-02f, -1.64268807e-01f, -5.12614325e-02f, 5.28270639e-02f, -9.10709128e-02f, -1.37052983e-01f, -1.22134142e-01f,
  -5.06732017e-02f, 3.52282263e-02f, 9.59696770e-02f, -3.42868790e-02f, 4.36165333e-02f, -1.96433309e-02f, 7.34097585e-02f, 3.34760244e-03f, -9.90169868e-03f, -3.87923419e-02f,
  -2.44075358e-02f, -9.59123671e-02f, -5.45272566e-02f, -9.27929208e-03f, 3.58702540e-02f, 5.63574806e-02f, -5.39641120e-02f, -1.47696175e-02f, 7.10295290e-02f, -6.33013099e-02f,
  -6.23208657e-03f, 1.41529376e-02f, -2.00388841e-02f, 3.58887501e-02f, -1.53998639e-02f, -6.01633526e-02f, 1.58620533e-02f, 6.53750002e-02f, -2.31021103e-02f, -1.31291226e-01f,
  -4.80470747e-01f, -4.52598572e-01f, -9.36811417e-03f, -1.17468975e-01f, -8.49968791e-02f, -2.56165694e-02f, 3.89979668e-02f, -7.51496330e-02f, -1.45327300e-01f, -4.27502953e-02f,
  2.81018279e-02f, 9.47594047e-02f, -1.30220145e-01f, 3.28037702e-02f, 8.76646042e-02f, 3.60958464e-02f, 4.30845015e-04f, -9.41745043e-02f, -1.47394016e-01f, -9.86079350e-02f,
  -2.58999132e-03f, 3.94641198e-02f, 1.51464596e-01f, -8.89210089e-04f, -3.98797877e-02f, -8.36906061e-02f, -1.15778886e-01f, -1.59117428e-03f, -1.54159725e-01f, 6.63503259e-02f,
  -1.18120335e-01f, -4.07795936e-01f, -3.22438538e-01f, -2.61916965e-01f, 2.94806123e-01f, 3.33058536e-01f, -3.57442558e-01f, -9.88060981e-03f, -4.15148437e-01f, -1.51263149e-02f,
  1.19181506e-01f, -1.43592954e-01f, -4.17343795e-01f, 6.70596734e-02f, 1.00118116e-01f, -2.43387505e-01f, 2.09183365e-01f, 2.05506220e-01f, -5.30348606e-02f, -4.69963886e-02f,
  -5.14740795e-02f, 3.49923104e-01f, -1.09608814e-01f, 3.72736096e-01f, 1.96002483e-01f, 3.43039661e-04f, 7.37880021e-02f, -5.58416434e-02f, 2.01163515e-01f, 1.95927441e-01f,
  -2.83351708e-02f, -2.02645287e-01f, -7.19194934e-02f, 4.92467582e-02f, -4.35444340e-03f, 8.31528455e-02f, 7.55549297e-02f, 7.24158734e-02f, -1.09778009e-01f, -7.44238272e-02f,
  -2.24663019e-02f, 2.24988405e-02f, 1.04633078e-01f, -5.59062138e-02f, 7.24602938e-02f, 2.63421424e-02f, -1.24340259e-01f, -4.97831032e-02f, -1.92692265e-01f, -1.30778119e-01f,
  -1.66129604e-01f, 9.39549133e-03f, 1.24404076e-02f, 9.47334841e-02f, -6.09654598e-02f, -1.20589854e-02f, -9.70403850e-02f, -1.69012174e-01f, 9.78522971e-02f, -2.06613597e-02f,
  -2.33644135e-02f, 1.21531241e-01f, 1.06255330e-01f, 9.54427868e-02f, -3.66809256e-02f, 5.05581461e-02f, 3.73709723e-02f, 3.86786163e-02f, -5.51643111e-02f, -2.08881255e-02f,
  7.93117583e-02f, -3.91671434e-02f, -8.15575197e-02f, 6.30240366e-02f, 5.28015234e-02f, 6.95702210e-02f, -1.78668760e-02f, 2.15642359e-02f, -6.81442469e-02f, 1.89122986e-02f,
  2.65083853e-02f, 8.43118131e-02f, -2.96869650e-02f, -2.74763554e-02f, 1.61530495e-01f, -4.03032303e-02f, 7.53778294e-02f, -4.67896983e-02f, 2.71421038e-02f, 1.21169955e-01f,
  -2.99601182e-02f, -1.52152687e-01f, -1.01007350e-01f, 6.01016618e-02f, -2.74977963e-02f, 1.49996176e-01f, 3.70014384e-02f, 8.11739266e-02f, 3.03090066e-02f, -5.75869083e-02f,
  7.17071891e-02f, -8.68522003e-02f, 1.29603148e-01f, 5.35289012e-02f, 4.28134017e-02f, -5.36531918e-02f, 3.82052287e-02f, -1.22706369e-02f, 5.09843603e-02f, 1.45724835e-02f,
  6.32856935e-02f, -6.94367588e-02f, 4.07859385e-02f, 1.22179501e-01f, 9.37807187e-02f, -3.58407646e-02f, 3.90869007e-02f, -1.21286474e-01f, 8.82158875e-02f, -1.25664528e-02f,
  -2.85390466e-01f, -2.21377626e-01f, -3.27641338e-01f, 1.16916671e-02f, -4.87729698e-01f, -2.80574590e-01f, 3.40146897e-03f, 1.87353417e-02f, 2.60608643e-01f, 3.58546466e-01f,
  -3.67114171e-02f, 8.03122893e-02f, 3.88637185e-01f, -2.81477153e-01f, -2.07917355e-02f, 3.48144829e-01f, -1.16692215e-01f, 1.75446212e-01f, -1.10346340e-01f, 1.87161401e-01f,
  -1.56547323e-01f, 6.82429895e-02f, -1.59213766e-01f, 1.15459710e-02f, -4.14442092e-01f, -3.25212210e-01f, -1.10127665e-01f, -2.06673741e-01f, -5.01605034e-01f, -3.47320616e-01f,
  -3.01075697e-01f, 1.07840613e-01f, -1.82833612e-01f, -8.32149908e-02f, -1.07195243e-01f, -9.49754100e-03f, -7.33584836e-02f, -2.86948420e-02f, -4.06233221e-02f, -2.92854719e-02f,
  9.08526480e-02f, -5.38226776e-03f, -6.26447871e-02f, 7.43886456e-02f, 4.72833328e-02f, -2.20186442e-01f, -1.85149327e-01f, -8.73029456e-02f, -8.19823295e-02f, -1.74046829e-01f,
  -1.19132325e-01f, -1.05220221e-01f, -8.27841908e-02f, 4.70549688e-02f, -2.02373594e-01f, -6.69390559e-02f, 2.26866249e-02f, -7.89452717e-02f, -5.69637194e-02f, -1.57335058e-01f,
  3.26322275e-03f, 7.82411397e-02f, 5.01277745e-02f, 9.56713706e-02f, -6.35011643e-02f, -1.48361251e-01f, 4.08764072e-02f, 7.83635154e-02f, -5.47978329e-03f, -4.79844138e-02f,
  -4.43968773e-02f, -2.26085307e-03f, -1.20213114e-01f, -6.16657399e-02f, 9.41190752e-04f, 2.29018688e-01f, 1.34550020e-01f, -7.61336312e-02f, -1.47553878e-02f, -9.52149257e-02f,
  6.96802288e-02f, -3.38461846e-02f, 1.41735421e-02f, 3.87963206e-02f, -3.96652892e-02f, 5.76831289e-02f, -4.51672673e-02f, -7.07846973e-03f, 5.37675843e-02f, -2.18149684e-02f,
  -4.28117402e-02f, 1.53357133e-01f, -5.80513058e-03f, -2.76663825e-02f, 4.85906489e-02f, -4.78807501e-02f, 4.85439971e-02f, -2.17728149e-02f, -9.51806381e-02f, 1.43026382e-01f,
  -9.66063421e-03f, 8.37916732e-02f, -1.19501725e-01f, 7.19204638e-03f, 1.77739084e-01f, -1.04604699e-01f, 1.58669770e-01f, 1.87881961e-02f, 4.76397909e-02f, -7.09238499e-02f,
  8.22601989e-02f, 1.59473717e-01f, 2.39587024e-01f, 1.40121564e-01f, 4.54034992e-02f, -3.41613442e-02f, 1.70560479e-02f, -1.09253570e-01f, -1.01459898e-01f, -5.41211106e-02f,
  2.18746930e-01f, -3.17415595e-01f, -8.87980834e-02f, 4.88758147e-01f, 1.01462275e-01f, -3.58729243e-01f, -2.11330950e-01f, 8.61983225e-02f, 5.27680933e-01f, -4.13081944e-01f,
  1.39248922e-01f, -4.25619423e-01f, -3.22876751e-01f, -1.06594688e-03f, 1.63720861e-01f, -9.26522166e-02f, 1.63633913e-01f, -1.91880167e-01f, 2.33091176e-01f, -1.39880359e-01f,
  2.90370971e-01f, 1.95597317e-02f, 2.33214814e-02f, -8.08161944e-02f, -1.09139830e-01f, 1.19802430e-01f, 1.62895247e-02f, -1.94359869e-01f, -6.38491288e-02f, -2.97798086e-02f,
  1.43198937e-01f, 2.37453520e-01f, 3.21853049e-02f, -1.44708138e-02f, 1.43465459e-01f, -7.15505853e-02f, -4.05771062e-02f, -1.76816225e-01f, 1.25885755e-01f, 3.07300091e-02f,
  -1.11259289e-01f, 8.97354111e-02f, -9.60621808e-04f, -1.04793705e-01f, 8.44182074e-02f, 3.78831513e-02f, 1.39298171e-01f, 1.95478559e-01f, 1.11943699e-01f, -1.42105266e-01f,
  5.17573766e-02f, 6.42314479e-02f, 1.32566184e-01f, 4.80856672e-02f, 5.20205833e-02f, 8.57015997e-02f, -4.86971326e-02f, -1.38461545e-01f, -3.39746624e-02f, 1.31201595e-01f,
  -5.45718782e-02f, -5.26442081e-02f, -1.36715680e-01f, 3.17677483e-02f, 1.48813307e-01f, 1.44489944e-01f, 6.90606833e-02f, -3.25237066e-02f, 8.31510425e-02f, -8.79312083e-02f,
  6.32393882e-02f, 2.08802167e-02f, 4.99080345e-02f, 2.73010298e-03f, 8.28405693e-02f, -2.02659741e-02f, -1.67022809e-01f, -9.98499319e-02f, 1.19470917e-01f, 4.90339883e-02f,
  -3.45579237e-02f, 6.26135990e-02f, -6.28065318e-02f, 8.61802325e-03f, -2.92841736e-02f, -7.05669736e-05f, 1.45703435e-01f, -8.63082707e-03f, -2.96213944e-02f, -5.33378683e-02f,
  -2.41602976e-02f, -1.26659706e-01f, -6.61053346e-05f, 5.50642759e-02f, -8.73135552e-02f, -1.15730964e-01f, -1.17573455e-01f, -8.13741386e-02f, 3.30359451e-02f, -1.97560061e-02f,
  -1.10155396e-01f, 3.67619582e-02f, 9.63990286e-04f, 5.24765477e-02f, 4.13059592e-02f, -8.10649917e-02f, 3.12254578e-02f, 1.64506003e-01f, -1.54724624e-02f, -3.32838632e-02f,
  -8.83018896e-02f, -5.56983650e-02f, 3.36147472e-02f, 1.13989718e-01f, 1.03146076e-01f, -2.88714957e-03f, -9.49272811e-02f, 6.80803657e-02f, -3.64408046e-02f, -3.53611133e-04f,
  2.40593165e-01f, -5.30988753e-01f, 5.49975187e-02f, 3.28155518e-01f, 3.52579534e-01f, 3.73364761e-02f, 2.07486752e-04f, 9.09699202e-02f, 1.09683797e-01f, -3.93233508e-01f,
  4.12373729e-02f, -2.65769243e-01f, -3.14360529e-01f, 7.40146637e-02f, 2.75681555e-01f, -1.57994211e-01f, 1.51493266e-01f, -3.92549746e-02f, 1.42328471e-01f, 1.17475837e-01f,
  2.00806513e-01f, 1.83121786e-01f, 1.68628708e-01f, 7.56742209e-02f, 1.27952203e-01f, -8.21355060e-02f, -4.97753546e-03f, -2.97858529e-02f, 6.77922219e-02f, 1.50270201e-02f,
  6.21914156e-02f, -4.04037423e-02f, -5.25016524e-02f, -2.80034170e-02f, -3.65546271e-06f, -8.33085924e-02f, -7.19350502e-02f, 1.34197297e-02f, 1.34789824e-01f, 5.68956956e-02f,
  -2.02502348e-02f, 8.80268365e-02f, 4.12501097e-02f, 8.30562860e-02f, 3.22260074e-02f, 8.65290165e-02f, 5.69770783e-02f, 3.52991261e-02f, 1.08983461e-02f, -3.24063972e-02f,
  -2.01427806e-02f, 6.60880879e-02f, 6.42149374e-02f, -4.44075577e-02f, 7.39539340e-02f, 1.18626934e-02f, -4.59637493e-02f, -1.12316892e-01f, -3.93967628e-02f, -2.65036337e-02f,
  -1.08260825e-01f, -1.22448385e-01f, 4.55236658e-02f, 3.52101997e-02f, 1.23023521e-02f, 2.64318716e-02f, 8.66800472e-02f, -9.93478112e-04f, 1.52011113e-02f, -2.47460064e-02f,
  1.04662023e-01f, 4.09693941e-02f, 7.21568167e-02f, 2.71027312e-02f, 3.37799191e-02f, 4.44314964e-02f, 1.09486915e-01f, -3.80564332e-02f, 1.17448140e-02f, 1.27783976e-02f,
  -3.07601839e-02f, 6.82421327e-02f, -4.10468578e-02f, 3.86946201e-02f, 3.98000143e-02f, -4.51820157e-02f, -6.29175408e-03f, -5.00384718e-02f, 6.29675463e-02f, -2.76486985e-02f,
  -8.85461494e-02f, -3.67593557e-01f, -6.35971501e-02f, 6.91899136e-02f, -8.54137447e-03f, 2.89909896e-02f, -2.95870546e-02f, 1.17727853e-02f, -8.06730613e-02f, 1.27514094e-01f,
  7.45166186e-03f, 7.68214613e-02f, -5.63913919e-02f, 4.94086184e-02f, 2.27532331e-02f, -4.63971570e-02f, -2.89473422e-02f, -9.31435172e-03f, -5.50655574e-02f, -6.18809797e-02f,
  -1.53100332e-02f, 1.27199337e-01f, 4.41218168e-02f, 5.59693389e-02f, 2.16862443e-03f, -1.13881007e-01f, 2.65489612e-02f, -5.60614653e-02f, 2.22540107e-02f, -6.31321594e-02f,
  2.80286938e-01f, -1.47871658e-01f, -3.90070349e-01f, -9.17970091e-02f, 2.84779686e-02f, -8.29762965e-03f, -2.92936444e-01f, 3.83634605e-02f, -4.13401723e-01f, -6.83526322e-02f,
  2.04760760e-01f, -1.51463225e-01f, -1.96065351e-01f, 5.39088786e-01f, 3.26325238e-01f, 1.75922625e-02f, 3.87904018e-01f, 1.91594273e-01f, 2.12416984e-02f, 1.01689905e-01f,
  2.09332332e-01f, 5.66431582e-01f, 1.43624917e-01f, 3.68832439e-01f, 2.65417606e-01f, -8.02195892e-02f, 1.58455849e-01f, -1.98725492e-01f, 2.37469509e-01f, 1.48309216e-01f,
  2.07698360e-01f, 2.90001370e-02f, -3.79484482e-02f, -3.80128771e-02f, 4.43173833e-02f, 3.54445875e-02f, -4.82611693e-02f, 3.99809070e-02f, -1.16189227e-01f, -2.46927384e-02f,
  -7.40078464e-02f, 1.06110677e-01f, 5.47847115e-02f, -5.94156571e-02f, -1.53853009e-02f, -3.08462698e-02f, -7.47221559e-02f, -1.10621877e-01f, -1.88367546e-01f, 8.76074061e-02f,
  -1.63149521e-01f, 6.20426051e-02f, 5.07959463e-02f, 6.35403991e-02f, -1.19186729e-01f, -1.13492861e-01f, -1.82665750e-01f, -1.24208465e-01f, -5.60879894e-02f, -1.73398722e-02f,
  2.03660235e-01f, 5.43421283e-02f, 2.65856050e-02f, 1.12137519e-01f, -1.12474099e-01f, 9.12969746e-03f, 3.77721037e-03f, -1.97191369e-02f, -1.10219441e-01f, 1.27169872e-02f,
  1.10574700e-02f, -3.21062235e-03f, -4.69901413e-02f, -1.05580792e-01f, 1.72840673e-02f, 5.32799326e-02f, 4.47268523e-02f, -7.48126116e-03f, -5.97886369e-02f, -4.89224680e-03f,
  4.29441184e-02f, -2.09049974e-02f, -1.10755213e-01f, 6.53866976e-02f, 1.09741248e-01f, -1.69552863e-01f, 8.05170015e-02f, -9.19928625e-02f, -7.66423047e-02f, 3.95907741e-03f,
  6.80296198e-02f, 3.63351218e-02f, -6.62351623e-02f, 2.86336932e-02f, -1.62598640e-02f, 1.05559919e-02f, 1.01728946e-01f, 1.18735991e-01f, 1.46147907e-02f, -4.57318053e-02f,
  1.27259865e-01f, -1.13833077e-01f, -1.56915486e-02f, 4.29828949e-02f, 6.19915389e-02f, -6.57451153e-02f, -4.21802364e-02f, -7.16200992e-02f, -5.93186505e-02f, 9.01102722e-02f,
  -2.52646543e-02f, 3.17921326e-03f, 6.41642287e-02f, -9.72725227e-02f, -2.13091541e-02f, -1.94998607e-02f, -2.23729759e-02f, -3.27762892e-03f, 1.47398651e-01f, -3.23624872e-02f,
  4.34671566e-02f, 4.93123561e-01f, 2.43613183e-01f, 4.42959398e-01f, -4.18219626e-01f, -1.83765024e-01f, -9.11159068e-02f, 3.07790823e-02f, -8.86580255e-03f, 1.64739102e-01f,
  -3.70296948e-02f, 2.50542998e-01f, -1.76187813e-01f, 4.33034956e-01f, -1.45399764e-01f, -4.79120426e-02f, 3.29314053e-01f, 1.88848183e-01f, -1.86956823e-01f, 9.53197405e-02f,
  4.15432639e-02f, 1.20272048e-01f, 2.88695067e-01f, -1.63092948e-02f, 1.66230142e-01f, 1.68394253e-01f, -3.23717892e-02f, -1.64239004e-01f, 3.29794228e-01f, -8.28439072e-02f,
  1.46422878e-01f, 9.93357971e-02f, 3.76362391e-02f, 8.09822381e-02f, 3.34457122e-02f, 6.39059916e-02f, 5.53444214e-02f, -6.77011535e-02f, -9.09208655e-02f, 8.60069320e-02f,
  1.78015940e-02f, 4.12548368e-04f, 9.29635093e-02f, -9.17339101e-02f, 2.01536827e-02f, 3.34916934e-02f, 2.60206927e-02f, 3.91725563e-02f, 4.23558690e-02f, 1.75783589e-01f,
  7.20751062e-02f, 1.51552156e-01f, 1.32830128e-01f, 1.67790964e-01f, -2.65247133e-02f, -9.29817781e-02f, 1.34940073e-01f, -1.00492863e-02f, 1.13529369e-01f, -8.87448154e-03f,
  9.56984982e-02f, -4.47017746e-03f, -6.69694319e-02f, 2.44024284e-02f, -6.54410049e-02f, -6.40495792e-02f, -6.76849112e-02f, -1.39032742e-02f, -1.35581881e-01f, 5.22584245e-02f,
  -6.34437278e-02f, -3.50004844e-02f, 4.92592789e-02f, 3.30816247e-02f, -1.54716475e-02f, 6.25228509e-02f, -5.15177436e-02f, -6.54334649e-02f, 5.63423522e-02f, -6.98770136e-02f,
  -8.65930784e-03f, -4.77817766e-02f, -8.79855920e-03f, 6.41430020e-02f, 6.73597679e-02f, -6.68001324e-02f, 6.98446780e-02f, 3.25895622e-02f, -1.19846046e-01f, -9.01295096e-02f,
  2.30449602e-01f, 1.74821079e-01f, -5.86118214e-02f, 2.23624930e-02f, -2.78952103e-02f, -3.57033834e-02f, 4.95305024e-02f, 1.32150635e-01f, 9.30638015e-02f, -4.72799838e-02f,
  1.04152553e-01f, -6.17889278e-02f, -6.34389147e-02f, 7.08307326e-02f, 7.12069348e-02f, 2.72650216e-02f, -3.63414153e-03f, -7.50920400e-02f, 1.21128755e-02f, 9.68745500e-02f,
  3.83860022e-02f, -1.13842793e-01f, 8.03780630e-02f, -1.03454135e-01f, 3.49271148e-02f, 1.77540407e-02f, -4.36739363e-02f, 5.83708994e-02f, 8.24925900e-02f, 1.00837231e-01f,
  -5.74420929e-01f, -1.85151502e-01f, 3.76159847e-01f, -5.71561277e-01f, -3.01496815e-02f, 3.06698531e-01f, 3.71332020e-01f, -1.97674409e-01f, -4.44317430e-01f, -2.06622779e-02f,
  -1.21216644e-02f, -1.28093213e-01f, 3.81026626e-01f, -2.24466383e-01f, 3.30270737e-01f, 1.81348935e-01f, -1.82008192e-01f, 6.28254712e-02f, -1.47947386e-01f, -1.38212889e-01f,
  -7.59812817e-02f, -1.22761458e-01f, 2.42144123e-01f, -9.34608802e-02f, -2.09928453e-01f, -1.99673876e-01f, 6.29121661e-02f, 1.86504096e-01f, -1.75732657e-01f, 7.78833181e-02f,
  -1.92985356e-01f, -3.78885239e-01f, -1.51994467e-01f, -8.06521773e-02f, -5.62031381e-02f, 8.01919624e-02f, 1.48425609e-01f, 1.93986699e-01f, -2.58068908e-02f, -3.11676916e-02f,
  4.12621833e-02f, 8.47233906e-02f, -1.67539209e-01f, 4.15235125e-02f, -1.18452951e-01f, -1.43296570e-01f, -5.52264452e-02f, -1.16515249e-01f, -1.35169089e-01f, 4.94285822e-02f,
  2.86678560e-02f, -1.01040475e-01f, 1.24286837e-03f, -3.97338681e-02f, 2.75259167e-02f, -2.97620166e-02f, -2.28293333e-02f, 1.07883684e-01f, -1.42850608e-01f, -7.86489844e-02f,
  4.43334989e-02f, 8.83129612e-02f, -4.98560593e-02f, -7.19188526e-03f, -2.49692556e-02f, 7.26325484e-03f, -2.65536960e-02f, 2.57913359e-02f, -4.39620614e-02f, 6.11256063e-03f,
  -2.62549613e-03f, 6.20837184e-03f, -9.48965549e-02f, 3.86465155e-03f, -1.27382213e-02f, -1.25249699e-01f, 1.20306455e-01f, -3.75957042e-02f, -1.15162469e-02f, 1.04620848e-02f,
  3.17655988e-02f, 8.26497525e-02f, 4.62166853e-02f, 3.50428857e-02f, 6.35081083e-02f, 6.38946844e-03f, -4.66386788e-02f, 4.49084071e-03f, -1.11868940e-02f, 1.06069624e-01f,
  -1.46143779e-01f, -3.12467754e-01f, -7.47259781e-02f, -4.72218283e-02f, -7.49417171e-02f, -4.71276976e-02f, 1.35256797e-02f, -1.01015165e-01f, -1.24718010e-01f, -3.10518313e-02f,
  -4.15541753e-02f, -3.10805929e-03f, -7.24612102e-02f, 1.23961484e-02f, 1.66442811e-01f, 4.31107655e-02f, 6.19553402e-03f, -1.27459317e-01f, -8.51414427e-02f, 2.26289630e-02f,
  -4.92151007e-02f, 2.75711529e-02f, 1.39625266e-01f, -7.77720734e-02f, -2.65616756e-02f, -1.09552499e-02f, -1.56326145e-01f, -3.31713371e-02f, 1.92275252e-02f, 5.82793541e-02f,
  -6.19715452e-01f, -1.81871012e-01f, 1.50168762e-01f, -6.86957389e-02f, -1.27766028e-01f, 2.38001809e-01f, 2.16157272e-01f, -2.78402537e-01f, -1.90908894e-01f, -1.31265642e-02f,
  -9.59322229e-02f, -1.25170574e-01f, -2.22370878e-01f, 4.71623205e-02f, -1.22493394e-01f, -1.01707667e-01f, 2.69497991e-01f, 1.40653700e-01f, -1.48240328e-01f, -1.33929372e-01f,
  -8.11496526e-02f, -1.44884840e-01f, 5.04491143e-02f, -5.77876493e-02f, -7.47936498e-03f, 2.88675457e-01f, 2.29550481e-01f, 1.48849994e-01f, 4.14871275e-01f, 1.55861661e-01f,
  9.52319428e-02f, -2.99171895e-01f, 2.01025549e-02f, 2.00573415e-01f, 6.03839457e-02f, 8.65629837e-02f, 2.81584263e-01f, 1.61201298e-01f, 5.34115992e-02f, -4.80644666e-02f,
  2.59666573e-02f, 5.37378863e-02f, -1.74998511e-02f, -5.00409938e-02f, -8.96568876e-03f, 5.24468385e-02f, 5.88017143e-02f, -5.84783703e-02f, 8.30409452e-02f, -1.03221193e-01f,
  -3.66187980e-03f, 2.14421600e-02f, -2.73841340e-02f, 6.29374161e-02f, 1.71079725e-01f, 8.98559615e-02f, 1.15733884e-01f, 2.20919214e-02f, 1.96425721e-01f, 5.10570221e-02f,
  -1.37128890e-01f, 5.02618477e-02f, 6.02296107e-02f, 5.86448945e-02f, -1.43221095e-01f, 1.25971198e-01f, 6.48025945e-02f, -7.85844401e-02f, 2.70438883e-02f, -3.45909894e-02f,
  1.09860332e-04f, 3.05242650e-03f, 1.08611025e-01f, 7.79556781e-02f, -1.11243762e-01f, -8.15750286e-02f, 7.65410513e-02f, 1.53825479e-02f, 4.66289558e-02f, 1.39091879e-01f,
  -4.93389405e-02f, 1.67678207e-01f, 7.23821297e-02f, 5.69725111e-02f, 3.72426733e-02f, 8.18270221e-02f, 2.86482275e-02f, 3.16887461e-02f, -9.65632964e-03f, 7.77005851e-02f,
  1.82464853e-01f, -1.20862454e-01f, 7.68263042e-02f, 1.31777242e-01f, 1.26151398e-01f, -1.21210225e-01f, 2.32837312e-02f, -3.74350585e-02f, -8.61506611e-02f, -1.81694478e-01f,
  1.03996112e-03f, 1.17779471e-01f, 1.80357188e-01f, 6.13142438e-02f, 1.01500213e-01f, 2.72214934e-02f, 1.24908663e-01f, -4.86325286e-02f, 7.44922683e-02f, -8.23465511e-02f,
  -2.96536721e-02f, 1.25246748e-01f, -4.66759987e-02f, -3.80925015e-02f, 5.95612489e-02f, -1.12273104e-01f, -1.19561426e-01f, -3.90089974e-02f, 1.51718035e-01f, 1.80691987e-01f,
  2.26410165e-01f, -4.43038017e-01f, -3.91923994e-01f, -1.74573641e-02f, -1.47425339e-01f, 3.29504818e-01f, 6.26299798e-01f, -2.50324965e-01f, -2.45338947e-01f, 2.16222242e-01f,
  4.68711734e-01f, -4.22681831e-02f, 4.05924320e-01f, 5.39171696e-01f, 3.14738691e-01f, 4.03964609e-01f, 3.03978443e-01f, 2.96374351e-01f, -2.79437751e-01f, -1.01845473e-01f,
  -7.47651160e-02f, 3.72672200e-01f, 2.25608155e-01f, -3.10819089e-01f, 9.70276222e-02f, -4.09891397e-01f, -1.68988667e-03f, -2.56114248e-02f, 1.15480497e-01f, 2.18902618e-01f,
  1.41458601e-01f, -1.20019495e-01f, -3.57459299e-02f, -1.77262723e-02f, -8.27989951e-02f, 4.54949699e-02f, 7.84767345e-02f, 1.23930953e-01f, 4.93904576e-02f, -8.87000468e-03f,
  8.95966142e-02f, -3.12007964e-02f, 8.94290581e-03f, -1.98609475e-02f, -9.83990133e-02f, -1.07390299e-01f, -1.10061407e-01f, -5.21205887e-02f, -1.11304350e-01f, 5.45684174e-02f,
  8.05882621e-04f, -5.98131791e-02f, 8.32579192e-03f, 2.46758107e-02f, -1.65802357e-03f, -5.38154244e-02f, 3.20970342e-02f, 7.00644776e-02f, -8.52324516e-02f, -1.77589342e-01f,
  3.34365107e-02f, 5.11530563e-02f, 2.21107379e-02f, 3.81038263e-02f, -8.02131370e-03f, 1.67145655e-02f, 5.21378145e-02f, -2.25315820e-02f, -1.25514165e-01f, 3.73630971e-02f,
  -1.29926894e-02f, -4.97486182e-02f, 6.19047806e-02f, 7.55754635e-02f, -1.13946851e-03f, -8.69779754e-03f, 7.52931833e-02f, 5.45630157e-02f, 6.35053823e-03f, -5.87544180e-02f,
  8.72863606e-02f, -7.02491845e-04f, 7.48539791e-02f, 4.28615957e-02f, 1.09523661e-01f, 1.21543489e-01f, 1.02698550e-01f, 6.65208604e-03f, 2.63661798e-02f, 8.91595893e-03f,
  -4.24645469e-02f, -2.84756243e-01f, -8.48213583e-02f, -3.01557593e-02f, -1.12053584e-02f, -9.97338146e-02f, 3.32783768e-03f, -6.54406548e-02f, 4.71430598e-04f, 1.74939411e-03f,
  -3.53316665e-02f, -1.33214165e-02f, -8.80886167e-02f, 4.02891263e-02f, -3.86938043e-02f, 1.54067818e-02f, 1.21531948e-01f, -2.21901909e-02f, 1.07630715e-02f, -7.83744305e-02f,
  -3.71380406e-03f, 5.01868911e-02f, 3.13211381e-02f, -3.85461971e-02f, -7.65545070e-02f, 5.21023721e-02f, -1.91346511e-01f, -5.05354777e-02f, 5.60975913e-03f, -2.49618031e-02f,
  -8.75588655e-02f, -3.70483935e-01f, -1.59719750e-01f, 9.45654809e-02f, 9.00098458e-02f, -1.93747357e-01f, -2.94582188e-01f, -1.37654349e-01f, -1.10746235e-01f, -1.70878768e-01f,
  -1.15443774e-01f, 1.01505525e-01f, -4.16781455e-01f, -7.13119432e-02f, 2.41500442e-03f, -2.42994398e-01f, -7.40557536e-02f, 6.83475509e-02f, 2.17608502e-03f, -1.22007035e-01f,
  8.71496871e-02f, -3.80008332e-02f, -1.51678592e-01f, -1.32322172e-02f, -8.43184814e-02f, 1.67586654e-01f, 2.00083092e-01f, -1.15916561e-02f, 2.34559759e-01f, 1.56074867e-01f,
  -8.85339975e-02f, -3.05230040e-02f, 4.49497737e-02f, 5.39197773e-02f, -3.80050838e-02f, 4.88118678e-02f, 5.06995022e-02f, 3.20772342e-02f, -6.42305333e-03f, 3.74201573e-02f,
  -3.58813293e-02f, 1.12102024e-01f, 1.10673450e-01f, 4.78182398e-02f, -2.89610103e-02f, 5.59696257e-02f, 3.87837924e-02f, -1.50529509e-02f, -1.46416491e-02f, -6.38060737e-03f,
  -2.66301371e-02f, -6.54536113e-02f, 1.06593939e-02f, 4.17605452e-02f, -3.48791555e-02f, -4.94184792e-02f, 1.31070971e-01f, 1.18346877e-01f, 6.51900545e-02f, 4.54460122e-02f,
  -5.31247295e-02f, 5.88083975e-02f, 3.02634649e-02f, -4.45543230e-02f, -1.45789273e-02f, 5.69168963e-02f, -3.33263688e-02f, 8.24115351e-02f, 7.29219392e-02f, -9.41144675e-02f,
  -2.79349983e-02f, -4.08389121e-02f, 4.59757298e-02f, 3.22239324e-02f, -2.18242556e-02f, 2.88086999e-02f, 9.74532031e-03f, 6.02028370e-02f, -2.29219384e-02f, 8.64304155e-02f,
  -9.79861245e-02f, -7.90168941e-02f, -5.77981435e-02f, 1.01778181e-02f, -1.11117974e-01f, 1.09576117e-02f, -4.95634601e-02f, 5.84739493e-03f, -4.52990681e-02f, 2.75256094e-02f,
  -1.64054900e-01f, -2.05120265e-01f, -3.48756574e-02f, 5.50386086e-02f, 2.65470240e-02f, 1.14550725e-01f, 5.45610152e-02f, 2.27449536e-02f, -8.71407762e-02f, -2.91182734e-02f,
  -2.26723552e-02f, 6.80844784e-02f, -1.04606962e-02f, 1.46705657e-01f, -9.90174562e-02f, -1.47117106e-02f, -1.19408779e-01f, -2.03851853e-02f, -8.29297397e-03f, 7.87414089e-02f,
  -3.64113636e-02f, -8.40689167e-02f, 6.90832883e-02f, -5.57471626e-02f, 1.26762941e-01f, -1.01093858e-01f, 7.12779462e-02f, 1.08066171e-01f, 1.07603453e-01f, 7.59457750e-03f,
  -1.40268981e-01f, -1.92832366e-01f, -6.14272296e-01f, -8.48763287e-02f, 3.97417128e-01f, 4.43758339e-01f, 1.71048835e-01f, -4.30669561e-02f, -4.67218429e-01f, 3.78168851e-01f,
  4.25878078e-01f, -5.59222817e-01f, -2.08668858e-01f, 6.60043508e-02f, -2.93186069e-01f, -2.11985931e-01f, 2.35631630e-01f, 1.44901529e-01f, -2.42599756e-01f, -7.35812113e-02f,
  -9.97923240e-02f, 3.73105645e-01f, -2.59847403e-01f, 2.15035230e-01f, 3.11939090e-01f, -2.48391107e-02f, 4.21063960e-01f, -1.34234473e-01f, 2.85869300e-01f, -6.06506132e-02f,
  2.19034962e-02f, -1.69369787e-01f, -1.08013235e-01f, -7.11922124e-02f, 1.31726027e-01f, 2.60688066e-01f, 9.76386070e-02f, 1.73636749e-02f, -6.89672530e-02f, -9.26756263e-02f,
  9.56202000e-02f, 1.78859867e-02f, -1.79570824e-01f, -5.09228259e-02f, 1.64015055e-01f, -7.19803153e-03f, -1.74707666e-01f, 3.31442803e-02f, -5.87148219e-02f, -1.21523440e-01f,
  -1.09926045e-01f, 8.23540464e-02f, 1.57425359e-01f, -3.53850126e-02f, -1.22032218e-01f, -1.53030619e-01f, 3.80536728e-02f, 1.73353832e-02f, 1.19531319e-01f, 4.53259908e-02f,
  6.25241101e-02f, 1.84063047e-01f, 1.25435606e-01f, 5.80385374e-03f, 5.70422374e-02f, -6.16002316e-03f, 2.33462211e-02f, 5.76092824e-02f, -1.78660080e-01f, -5.14130592e-02f,
  -7.96211325e-03f, -4.05811630e-02f, -6.13639057e-02f, 1.10579059e-01f, 9.46602672e-02f, -4.45828494e-03f, 3.58674936e-02f, -9.51698236e-03f, -9.19711888e-02f, 4.71683629e-02f,
  3.17788571e-02f, -6.60743844e-03f, -5.68414927e-02f, 1.32984981e-01f, 7.00431764e-02f, -1.59405366e-01f, 1.26044095e-01f, -6.23629466e-02f, -2.03115642e-02f, 1.62921116e-01f,
  1.10003121e-01f, -8.58543739e-02f, -9.69688669e-02f, 1.26860500e-03f, -1.18228599e-01f, 1.22359075e-01f, -4.86256275e-03f, -6.35282099e-02f, -3.12624648e-02f, 8.37710872e-03f,
  8.75589326e-02f, 1.40317529e-01f, 1.22165568e-01f, -8.51132944e-02f, 1.80998612e-02f, 1.38863340e-01f, 8.41786489e-02f, -7.82088116e-02f, 6.49430826e-02f, 1.97047591e-02f,
  1.57434165e-01f, 6.60242811e-02f, 3.03853154e-02f, 3.18421721e-02f, 7.19646811e-02f, 1.28438994e-01f, 9.73308161e-02f, -7.24140834e-03f, 1.63344800e-01f, -6.49454221e-02f,
  4.58088368e-01f, -3.78467411e-01f, -1.61167070e-01f, -5.83896153e-02f, -1.39606688e-02f, -2.35507771e-01f, 1.51169272e-02f, -2.40740925e-01f, 7.87847713e-02f, -2.62613684e-01f,
  -1.83131963e-01f, 4.82042693e-02f, 2.60164231e-01f, -3.01481098e-01f, 4.44913983e-01f, 2.08261997e-01f, -1.95688874e-01f, -1.14726007e-01f, 4.82991152e-02f, -1.61650613e-01f,
  3.02474592e-02f, -1.78691417e-01f, 7.45932758e-02f, -4.07801896e-01f, -6.08238578e-02f, -1.91094935e-01f, 3.88501957e-02f, 1.55979646e-02f, -3.71353000e-01f, 3.38223316e-02f,
  -3.74104753e-02f, -5.76919056e-02f, -5.82706742e-02f, 3.67357559e-03f, -8.89128372e-02f, -3.00566908e-02f, 1.64770205e-02f, 2.28229687e-02f, 6.37371093e-02f, 3.26519646e-02f,
  2.73984037e-02f, 1.49788111e-01f, -1.55203968e-01f, 6.78845420e-02f, -2.24885829e-02f, -1.51482418e-01f, 5.03782630e-02f, 1.14333956e-03f, 8.40368569e-02f, 1.00930989e-01f,
  5.44461980e-02f, 5.43804280e-02f, 1.10598048e-02f, 4.11755778e-02f, 1.19617376e-02f, 5.50259762e-02f, 6.06494909e-03f, 4.38255481e-02f, -9.93874390e-03f, 5.00500463e-02f,
  -2.45769396e-02f, 1.73896834e-01f, 7.34024122e-02f, -1.96140837e-02f, -4.17561382e-02f, 1.36686340e-02f, 5.03778569e-02f, -8.74388739e-02f, 8.29696879e-02f, -1.54437805e-02f,
  -8.02512933e-03f, -4.23395820e-02f, 4.21677865e-02f, 7.36994147e-02f, -9.49543994e-03f, 1.04883038e-01f, -5.74446358e-02f, -5.38559929e-02f, -1.51392706e-02f, -6.14613593e-02f,
  1.07570440e-01f, 1.05351515e-01f, 7.47455806e-02f, -1.62817829e-03f, -4.44265120e-02f, 5.93608692e-02f, -1.93687938e-02f, -1.59431454e-02f, -3.66807468e-02f, 1.36685539e-02f,
  -4.93711643e-02f, -2.20202386e-01f, -1.23339735e-01f, -9.73014981e-02f, -1.38080716e-01f, -5.19210249e-02f, -8.92521515e-02f, -1.76729605e-01f, 1.97398216e-02f, 4.19474691e-02f,
  -1.24819174e-01f, 8.03406090e-02f, -5.27492873e-02f, -9.00173211e-04f, -5.95113374e-02f, -1.29433706e-01f, 1.25088051e-01f, 2.65104417e-02f, -5.19223511e-03f, -7.70199746e-02f,
  -5.21963183e-03f, 8.14865977e-02f, 4.83848788e-02f, -3.34238112e-02f, -1.07346907e-01f, 1.48294806e-01f, -1.88434627e-02f, 2.94282883e-02f, 4.36407775e-02f, 1.76100098e-02f,
  -4.68787909e-01f, 3.15199018e-01f, -1.59429252e-01f, 9.31985453e-02f, 2.45355040e-01f, -5.68717957e-01f, -1.80955604e-01f, 1.06569059e-01f, -9.31103230e-02f, 1.52067572e-01f,
  3.03558618e-01f, -9.88499448e-02f, 1.87263951e-01f, -2.42026418e-01f, -6.78213775e-01f, -2.97753751e-01f, -3.96617472e-01f, -2.35444427e-01f, -1.19627721e-03f, 1.93327814e-01f,
  -6.92054480e-02f, 1.21635526e-01f, -1.57817870e-01f, 3.84935707e-01f, 4.23448868e-02f, 3.56660604e-01f, 4.23391551e-01f, 3.42630744e-01f, -6.92179501e-02f, 3.08442917e-02f,
  -3.30413789e-01f, 2.46924028e-01f, -2.92580500e-02f, -7.14519769e-02f, -4.34355885e-02f, 3.81387323e-02f, -4.31601889e-02f, 4.90458384e-02f, 1.16659515e-03f, -6.87535256e-02f,
  1.96280982e-02f, -1.11580854e-02f, -1.00156367e-02f, 5.61941490e-02f, 2.12995727e-02f, 5.92607222e-02f, -1.67161748e-01f, -1.19448848e-01f, 7.10311234e-02f, -1.48138478e-01f,
  -6.43619597e-02f, -1.66577414e-01f, -4.19182554e-02f, 8.70278012e-03f, 9.34833381e-03f, -3.94069143e-02f, -4.93379310e-02f, 1.84026230e-02f, 9.64845903e-03f, -4.63880948e-04f,
  -4.34503704e-02f, 7.71631822e-02f, 1.88274197e-02f, 9.60895733e-04f, 4.65462618e-02f, 4.92286496e-03f, 5.28375655e-02f, 3.26033644e-02f, 8.27513926e-04f, 3.81294377e-02f,
  4.57358919e-02f, 5.99033609e-02f, 9.92468968e-02f, -1.37201389e-02f, 3.97576094e-02f, -1.90700404e-04f, -1.55751556e-02f, 2.55667679e-02f, -6.98511750e-02f, -2.05873102e-02f,
  1.05090939e-01f, -9.46382806e-02f, 8.51573125e-02f, 5.35693131e-02f, -7.07848743e-02f, 9.63161588e-02f, 9.35641453e-02f, -7.36030266e-02f, -3.53629105e-02f, 7.69253820e-02f,
  1.00960664e-01f, 4.40596879e-01f, 7.09615052e-02f, 1.89138912e-02f, 5.53881600e-02f, 8.80452394e-02f, -2.11335276e-03f, -1.23270310e-01f, 6.66015670e-02f, 1.66023057e-02f,
  -4.03388701e-02f, 6.46732748e-02f, 4.25838940e-02f, 3.03204488e-02f, -8.99528414e-02f, 4.97458540e-02f, 1.16790839e-01f, 1.13645315e-01f, 1.56578019e-01f, 8.33780915e-02f,
  2.14969918e-01f, 3.66849564e-02f, -8.71776789e-03f, -3.71974595e-02f, 4.02136669e-02f, -3.13959271e-02f, 1.48089277e-02f, 2.96609616e-03f, 5.29290214e-02f, -4.66467842e-04f,
  3.31578851e-02f, -3.34922522e-01f, -1.19927406e-01f, -3.69199105e-02f, -1.63901430e-02f, -2.03751907e-01f, -7.86612034e-02f, -2.54195482e-01f, 1.91774219e-01f, -3.46979350e-01f,
  -7.15211034e-02f, 1.80682555e-01f, 1.91303387e-01f, -2.17658475e-01f, 5.53367794e-01f, 2.71352351e-01f, -1.65052433e-03f, 9.38388556e-02f, 1.52476698e-01f, -1.45337030e-01f,
  -6.12529330e-02f, -2.27343321e-01f, -7.19773397e-03f, -3.34354907e-01f, -3.63334030e-01f, -2.36284360e-01f, 4.53196913e-02f, -1.30354106e-01f, -3.08166951e-01f, 6.41757995e-02f,
  5.87555871e-04f, 2.99973674e-02f, -1.11931823e-01f, -5.66397933e-03f, -5.14451123e-04f, -4.31606658e-02f, -7.04044625e-02f, 8.96899179e-02f, 1.84771165e-01f, 5.38760535e-02f,
  4.17145640e-02f, 1.83374852e-01f, -5.74751012e-02f, 3.59559096e-02f, -9.85715613e-02f, -2.83590723e-02f, 8.54689628e-02f, 7.84214512e-02f, 5.67871705e-02f, -3.78416036e-03f,
  8.09685513e-02f, 7.63361305e-02f, -3.38967331e-02f, 3.82999033e-02f, 2.01225337e-02f, 7.87672177e-02f, 7.87972063e-02f, 4.25950773e-02f, 3.03319860e-02f, 3.70799266e-02f,
  -1.70256808e-01f, 8.06530043e-02f, 1.53462740e-03f, -7.30280131e-02f, 1.05026700e-01f, 1.43178478e-02f, 6.40366673e-02f, 3.91547643e-02f, 9.16014239e-02f, 9.08118859e-03f,
  8.14595222e-02f, -9.69235692e-03f, 1.04058078e-02f, 9.69599709e-02f, 6.81865308e-03f, -5.09812869e-02f, -3.91580462e-02f, -4.43925932e-02f, -1.58146005e-02f, 1.26046604e-02f,
  -3.43788834e-03f, 8.67015868e-02f, 4.14999276e-02f, -4.32826318e-02f, 2.27813795e-02f, 5.17567657e-02f, 4.58010565e-03f, -1.70955747e-01f, 3.91570032e-02f, -2.10904460e-02f,
  7.74819329e-02f, -2.00755224e-01f, 2.97097396e-02f, 7.52143636e-02f, 6.12928271e-02f, -3.78782935e-02f, -1.60896689e-01f, -1.28558099e-01f, -1.44161878e-03f, -4.16862257e-02f,
  -9.67611521e-02f, 7.89741799e-02f, 6.55031279e-02f, 2.23775208e-02f, -1.45945661e-02f, -1.35946512e-01f, 1.39087752e-01f, 1.21428207e-01f, 2.03247229e-03f, -5.87610342e-02f,
  8.39451402e-02f, 8.05489048e-02f, 9.46203694e-02f, 2.78539788e-02f, -5.71561093e-03f, -1.45085296e-03f, 6.16561659e-02f, -9.93923321e-02f, -3.05450079e-03f, 8.94203708e-02f,
  6.00059144e-02f, 2.22669378e-01f, 1.96626157e-01f, 3.21324080e-01f, -9.36589539e-02f, -3.14563625e-02f, -1.26307115e-01f, 3.43000926e-02f, -1.50931180e-01f, -1.80790305e-01f,
  1.34325430e-01f, 3.07244837e-01f, -7.93035924e-02f, 4.14095670e-01f, 6.23729408e-01f, -2.10082214e-02f, 1.35610774e-01f, 8.37663785e-02f, 3.01007181e-04f, 7.31333792e-02f,
  2.30366997e-02f, 2.04995215e-01f, 3.81011009e-01f, 1.64989382e-01f, 3.37638974e-01f, 2.73988426e-01f, 3.16644907e-01f, 1.81295156e-01f, 4.07826662e-01f, 2.45134413e-01f,
  -1.85327411e-01f, -8.31653550e-02f, -1.33925110e-01f, -6.92114308e-02f, -4.04133983e-02f, -1.16204716e-01f, -2.44346038e-02f, 1.86860472e-01f, 3.76356691e-02f, 3.01232021e-02f,
  7.35050738e-02f, 9.05869976e-02f, 1.08964086e-01f, 1.30992159e-02f, -1.49523243e-01f, 7.41878971e-02f, 1.67474486e-02f, -3.66786914e-03f, -1.70187932e-02f, -4.19016294e-02f,
  3.18424627e-02f, 3.10505889e-02f, 9.90060437e-03f, 8.10170099e-02f, 1.32296368e-01f, -8.08945969e-02f, -8.01050812e-02f, -1.90903636e-04f, 9.40494984e-02f, 3.01392805e-02f,
  -9.20542702e-02f, 4.78083044e-02f, -7.81784654e-02f, 3.05818915e-02f, 7.56677911e-02f, -1.83908660e-02f, 3.72232608e-02f, -4.20638658e-02f, -4.78861202e-03f, 3.28994244e-02f,
  1.10014807e-02f, 8.48501921e-02f, -4.90850434e-02f, -4.73520197e-02f, -3.94442454e-02f, -6.41724616e-02f, 2.29298025e-02f, 1.34419218e-01f, -5.57795167e-02f, 4.83887419e-02f,
  -2.81906966e-02f, 5.93272559e-02f, -1.50512159e-02f, -8.13768953e-02f, -6.21386357e-02f, 3.82012874e-02f, 6.27057701e-02f, 2.64476333e-02f, 3.49909887e-02f, 6.03332818e-02f,
  7.41456375e-02f, 2.41310492e-01f, 2.78082327e-03f, -5.89560941e-02f, -7.28169829e-02f, 7.31251836e-02f, 6.75637182e-03f, 2.40730755e-02f, 1.03884503e-01f, 1.94080232e-03f,
  -1.08617961e-01f, -5.17160110e-02f, -1.04464814e-02f, -7.12154284e-02f, 1.22648574e-01f, -8.31816792e-02f, 2.60536578e-02f, -4.31231828e-03f, -1.79451201e-02f, 7.04945102e-02f,
  7.09191114e-02f, 1.28590344e-02f, 1.08035646e-01f, 8.52823164e-03f, -1.00484695e-02f, 2.67585125e-02f, -3.94394957e-02f, -1.01553582e-01f, 5.12357950e-02f, 4.74177673e-02f,
  -5.88583410e-01f, 3.88461947e-01f, 8.45173448e-02f, -2.80070513e-01f, 3.87374014e-01f, -1.11170270e-01f, -4.05149609e-02f, 3.12220663e-01f, 1.04599327e-01f, 9.68778953e-02f,
  -2.28794757e-02f, -1.51535287e-01f, 1.92190081e-01f, -1.02242067e-01f, -3.33837837e-01f, -9.74652544e-02f, -4.03177023e-01f, -2.96708226e-01f, -1.39758056e-02f, -2.68711597e-01f,
  -9.72968638e-02f, 1.36963665e-01f, -2.77289618e-02f, 4.73530740e-01f, 1.43913552e-01f, 1.01040252e-01f, -2.64235049e-01f, 3.94232899e-01f, -1.27445728e-01f, 2.76255786e-01f,
  -1.22388929e-01f, 1.92073405e-01f, 1.28756901e-02f, 8.40129256e-02f, -1.47447705e-01f, -9.56110284e-02f, -2.18501151e-01f, 9.61433575e-02f, 3.64573076e-02f, 4.12154049e-02f,
  -7.23920837e-02f, 6.30247071e-02f, -2.62815952e-02f, 1.09027341e-01f, 1.10914372e-01f, 4.99208719e-02f, 4.70824875e-02f, -9.83800590e-02f, 1.95150360e-01f, 1.62634309e-02f,
  8.11605826e-02f, -2.51251203e-03f, -6.29720539e-02f, -1.88029204e-02f, 6.63488656e-02f, 1.40610680e-01f, -5.09414598e-02f, -6.57410547e-02f, -1.21349385e-02f, 3.69994491e-02f,
  5.48562072e-02f, -4.65192907e-02f, 4.17519500e-03f, 9.05564129e-02f, 6.30650893e-02f, 3.54869999e-02f, -4.39076917e-03f, -7.91119933e-02f, -2.46130358e-02f, -3.80357429e-02f,
  -4.73197326e-02f, -2.54748408e-02f, 1.41271472e-01f, -3.94081958e-02f, -1.03908472e-01f, -2.03754706e-03f, -5.07797711e-02f, -1.89112425e-02f, -5.09671643e-02f, -1.29616469e-01f,
  8.16908479e-02f, -5.25822379e-02f, 1.24772422e-01f, -6.18655887e-03f, 5.16428724e-02f, 8.05182680e-02f, -7.44734630e-02f, -6.88070664e-03f, -5.47894463e-02f, -3.94159704e-02f,
  -4.81792450e-01f, -2.02017754e-01f, 1.94356181e-02f, 1.12512127e-01f, -4.64721955e-02f, -1.56721264e-01f, -5.41362725e-02f, 1.10583296e-02f, -3.99296656e-02f, -2.39705704e-02f,
  -3.34738307e-02f, -4.60816324e-02f, -1.86688200e-01f, -2.05345396e-02f, -5.53144254e-02f, -4.93978895e-02f, -4.93397377e-02f, -6.01680800e-02f, -9.99865085e-02f, -1.33611485e-01f,
  3.11234854e-02f, -7.34991059e-02f, 2.27558091e-02f, 9.58742425e-02f, -8.29341859e-02f, -4.08761203e-02f, -1.43766567e-01f, 7.70281628e-02f, 4.97488072e-03f, -3.02349124e-02f,
  -4.34353530e-01f, -2.48402029e-01f, 4.02977735e-01f, -2.23154053e-01f, -1.13138653e-01f, 2.65487790e-01f, 2.67676294e-01f, -2.53688335e-01f, -4.13215041e-01f, -2.59383142e-01f,
  -5.52745648e-02f, 5.09201512e-02f, 3.14566702e-01f, 5.94559610e-02f, 3.94035250e-01f, 2.48158485e-01f, 3.08686979e-02f, 8.16953108e-02f, -6.81914017e-02f, -1.53307080e-01f,
  2.33921781e-02f, -4.45350744e-02f, 4.13235962e-01f, -1.70372814e-01f, 5.15606776e-02f, -1.23557322e-01f, 5.66906482e-02f, 2.51508206e-01f, 1.75127313e-02f, 1.37161046e-01f,
  -2.23646954e-01f, -3.43579262e-01f, -1.25532627e-01f, -4.31154184e-02f, -2.39268858e-02f, 3.89239751e-02f, 1.43117294e-01f, 1.67570561e-01f, -7.73837278e-03f, 4.13218401e-02f,
  6.65919259e-02f, -9.36885029e-02f, -1.82187289e-01f, -6.66116402e-02f, -1.16786033e-01f, -6.78957403e-02f, 4.69121598e-02f, 7.87010565e-02f, -4.13591079e-02f, 6.79039806e-02f,
  5.14628701e-02f, 1.47725968e-02f, 1.17926849e-02f, 4.22926359e-02f, 5.84099628e-02f, -1.04973085e-01f, 1.48643926e-01f, 1.48423299e-01f, -9.37045515e-02f, -1.27390161e-01f,
  5.16252704e-02f, 2.09492687e-02f, -1.13692256e-02f, -2.60167588e-02f, 6.79846033e-02f, -3.68307494e-02f, 9.64048225e-03f, 5.30587416e-03f, 4.59702015e-02f, 2.14399081e-02f,
  -5.20445406e-02f, -5.45190042e-03f, -1.72248706e-01f, -2.57077422e-02f, -6.92360997e-02f, -5.87347485e-02f, 1.32659793e-01f, -6.34319186e-02f, -8.24149475e-02f, 8.12949892e-03f,
  4.62759361e-02f, -5.73178008e-02f, -1.15153668e-02f, 4.41753026e-03f, -2.72671487e-02f, 6.68922067e-02f, -3.00016478e-02f, -3.05984318e-02f, 2.00611688e-02f, 1.01494700e-01f,
  -3.77094328e-01f, -3.50066751e-01f, -9.51778740e-02f, -1.10621698e-01f, -3.16914544e-02f, -8.01920891e-02f, 9.50320903e-03f, -1.02231324e-01f, -1.13694202e-02f, 4.91565242e-02f,
  -9.67964530e-02f, 5.87901697e-02f, -1.12152465e-01f, -6.92455471e-02f, -1.42634111e-02f, -4.04776819e-02f, -2.87515186e-02f, -1.31181655e-02f, -5.00672683e-02f, -1.37903422e-01f,
  4.92496090e-03f, -5.11239097e-02f, 7.48885423e-02f, -5.60305007e-02f, 3.54097523e-02f, -5.26682101e-03f, -8.18752944e-02f, -9.74481255e-02f, 8.60329494e-02f, 3.37397009e-02f,
  -1.19940765e-01f, 1.15327194e-01f, 3.50144565e-01f, 2.42273986e-01f, 3.15706059e-02f, -2.81506181e-01f, -2.70109564e-01f, 3.29411834e-01f, -4.59099375e-02f, -7.47622475e-02f,
  1.99502766e-01f, -4.22394931e-01f, 2.29741111e-01f, 1.41239569e-01f, 1.34584561e-01f, 3.35865587e-01f, 1.63179740e-01f, -8.27939510e-02f, 1.91948190e-01f, 3.17836940e-01f,
  1.95671290e-01f, 1.55242890e-01f, 4.25331533e-01f, 1.89832687e-01f, 2.89826751e-01f, 5.51816486e-02f, 2.29575306e-01f, 2.22599003e-02f, 2.97191925e-02f, -3.75163287e-01f,
  -2.63533406e-02f, 4.25622389e-02f, 1.08193167e-01f, -7.92760551e-02f, 1.92017674e-01f, -7.10102841e-02f, 4.89146151e-02f, -8.40801522e-02f, 9.56826191e-03f, -5.30576408e-02f,
  -1.08754300e-01f, -1.62169799e-01f, -6.19335324e-02f, 4.38403478e-03f, -1.60742015e-01f, 4.21454981e-02f, 1.79609820e-01f, 3.21979858e-02f, -1.09524034e-01f, 5.47843426e-02f,
  9.12536904e-02f, -4.79197502e-02f, -5.26272468e-02f, -1.31236359e-01f, 4.59769145e-02f, -5.06948419e-02f, -7.90880844e-02f, -7.32114166e-02f, 4.68765758e-02f, -2.29952514e-01f,
  -1.41458914e-01f, 4.14421745e-02f, 1.75368398e-01f, 1.60971329e-01f, 4.94517908e-02f, 1.19328603e-01f, -1.29392877e-01f, -1.45862237e-01f, 2.73696110e-02f, -1.53846070e-02f,
  4.39641095e-04f, 7.76082054e-02f, 5.48985526e-02f, -3.23219374e-02f, -7.12337643e-02f, -2.77722999e-02f, -2.19792258e-02f, 5.72049096e-02f, 2.54856553e-02f, 1.48439452e-01f,
  9.56537500e-02f, -2.70420592e-02f, 5.28904013e-02f, -3.56005542e-02f, -3.54223698e-02f, -3.39657743e-03f, 9.35272425e-02f, 1.91666275e-01f, 2.51674205e-01f, 2.08669379e-02f,
  4.87067141e-02f, 2.08894372e-01f, 6.27601445e-02f, -1.50217205e-01f, 1.05120271e-01f, 1.57665476e-01f, 9.65865999e-02f, -9.77760064e-04f, -3.69153880e-02f, 2.33927276e-02f,
  -2.35316139e-02f, -5.41377738e-02f, 8.39938894e-02f, 5.71096204e-02f, -8.00974220e-02f, 1.73941851e-01f, -1.09437540e-01f, -1.13550968e-01f, -1.93635300e-01f, 7.10359514e-02f,
  5.26622087e-02f, 7.69868717e-02f, -5.78523278e-02f, -4.12435420e-02f, -9.46399197e-02f, -1.72298536e-01f, 4.77346778e-03f, 2.34574266e-02f, 1.07099846e-01f, -3.72271277e-02f,
  3.97614716e-03f, 3.46879333e-01f, 2.16570586e-01f, -1.84267107e-02f, 1.81180894e-01f, 6.11438334e-01f, 2.99738199e-01f, 3.82880509e-01f, 4.28429097e-01f, 9.23063532e-02f,
  -1.41454414e-01f, 3.02897960e-01f, -1.05624311e-01f, -1.23770870e-01f, 2.04848617e-01f, 3.28836218e-02f, 8.34517255e-02f, 3.79350921e-03f, 9.24891979e-02f, -1.07061140e-01f,
  -8.00042376e-02f, -1.47369504e-02f, -4.08291698e-01f, -1.57596245e-02f, -8.08262005e-02f, -1.31230816e-01f, -3.24031264e-01f, -5.41136116e-02f, -1.94215834e-01f, 2.02226952e-01f,
  3.70847695e-02f, 1.10842086e-01f, -2.93799751e-02f, -2.68626660e-02f, -6.57014316e-03f, 7.94208702e-03f, -3.73151153e-03f, 8.08835328e-02f, 3.67931789e-03f, 6.64544851e-02f,
  3.90709192e-02f, 8.15785453e-02f, 1.79496616e-01f, 9.40754786e-02f, 3.06454282e-02f, 8.19221437e-02f, -8.19263384e-02f, 2.66695563e-02f, -2.14249920e-02f, -5.57999089e-02f,
  -1.54639140e-01f, -8.07945579e-02f, -2.53351517e-02f, 1.56211918e-02f, 1.28689775e-04f, 6.57189414e-02f, 3.63991112e-02f, 1.63610857e-02f, -7.30486400e-03f, 1.51339844e-01f,
  5.42436726e-02f, 5.75267449e-02f, 1.21917948e-01f, -6.05164580e-02f, 1.68924406e-02f, -7.53732771e-03f, -2.46247854e-02f, -1.17806427e-01f, -1.35159157e-02f, -8.24678093e-02f,
  -1.44168772e-02f, 4.10059057e-02f, -3.27359773e-02f, -5.94375618e-02f, 3.79878543e-02f, 3.19197476e-02f, 1.02623239e-01f, 9.57984012e-03f, 4.11979519e-02f, 4.96575646e-02f,
  1.32993698e-01f, -6.18514903e-02f, -6.01127930e-02f, -1.13128811e-01f, 1.85647735e-03f, -6.97080269e-02f, 5.27195781e-02f, -6.69121370e-02f, -1.60094500e-01f, 2.63852198e-02f,
  1.90753296e-01f, 4.92736399e-01f, -5.35511672e-02f, -5.03651462e-02f, -6.02248944e-02f, 6.58060089e-02f, 3.75162549e-02f, 2.14303091e-01f, 1.75255582e-01f, 1.64757028e-01f,
  1.71108946e-01f, -3.54836471e-02f, 3.03912666e-02f, -2.49950998e-02f, -2.40029916e-02f, 1.57855451e-01f, -1.43610999e-01f, 1.37221873e-01f, 5.68762198e-02f, 9.36376601e-02f,
  -1.38065770e-01f, 2.71053258e-02f, 8.70309621e-02f, 3.26203890e-02f, -1.87254231e-03f, -2.00865492e-02f, 1.37736619e-01f, -1.41683087e-01f, -2.12690495e-02f, -3.69608514e-02f,
  8.11593235e-02f, 4.09493566e-01f, 1.47205144e-01f, 2.41563901e-01f, 8.80838335e-02f, -6.52437925e-01f, -1.54039323e-01f, 2.23271891e-01f, 1.47993237e-01f, 1.92933917e-01f,
  -1.86642691e-01f, 2.78305918e-01f, -4.90014162e-03f, -2.01048568e-01f, -5.59941053e-01f, -3.87255728e-01f, -1.69665039e-01f, -1.89967379e-01f, 5.60938753e-02f, 1.73089609e-01f,
  1.57182574e-01f, -1.48016393e-01f, 9.04433653e-02f, 1.51626378e-01f, 1.46518305e-01f, 4.04569387e-01f, 2.50847727e-01f, 1.71398446e-01f, 1.43370524e-01f, -1.98496178e-01f,
  -1.91245243e-01f, 9.00376439e-02f, 2.37016872e-01f, -1.24969549e-01f, 4.11359966e-02f, 7.61575624e-02f, 6.22610375e-02f, -1.14523247e-02f, 1.53157618e-02f, -6.10380583e-02f,
  1.46431131e-02f, -7.71056935e-02f, -6.11164458e-02f, -6.15220107e-02f, 3.59886400e-02f, 8.21022242e-02f, 1.90416407e-02f, -7.85585307e-03f, 1.77152112e-01f, -2.50094067e-02f,
  1.43971860e-01f, -3.33125554e-02f, 5.16627692e-02f, -5.13981357e-02f, 7.14913234e-02f, -5.45069994e-03f, -1.21471807e-01f, 7.76028484e-02f, -1.07134180e-03f, 3.43032889e-02f,
  -8.61437118e-04f, 1.28316358e-01f, 8.81012902e-03f, -1.07583934e-02f, -6.59508705e-02f, 9.74772349e-02f, -2.15947405e-02f, -6.55710995e-02f, -1.02380672e-02f, -5.75778298e-02f,
  -5.91254979e-03f, 9.73978862e-02f, -9.64045078e-02f, 3.17778960e-02f, 4.25999351e-02f, 4.49682064e-02f, 3.94874848e-02f, -9.08541679e-02f, 1.92901436e-02f, 6.97057694e-02f,
  3.02469861e-02f, -4.56482694e-02f, 7.49975368e-02f, -2.12674402e-02f, -1.43916413e-01f, 1.32256094e-02f, 1.10940561e-01f, -3.99164818e-02f, 3.50363739e-02f, 2.80282721e-02f,
  -1.18913792e-01f, 2.63195127e-01f, 6.60565943e-02f, -6.11448437e-02f, 2.50056125e-02f, -5.93362050e-03f, -4.72742915e-02f, -6.66460022e-02f, -2.28471891e-03f, -3.21149491e-02f,
  9.77574736e-02f, 7.18521848e-02f, 1.99149307e-02f, -6.36366382e-02f, -4.45531569e-02f, -1.17621962e-02f, 6.47800267e-02f, 1.77664217e-02f, 1.63997665e-01f, 6.92296103e-02f,
  1.99849263e-01f, 6.28877953e-02f, 1.22271538e-01f, 1.81055889e-02f, 8.42126757e-02f, -7.18655437e-03f, -3.44660208e-02f, -1.07072862e-02f, 3.97076085e-02f, -3.99480090e-02f,
  -3.76026630e-01f, 2.61499047e-01f, 4.28089082e-01f, -1.24766722e-01f, 2.57154375e-01f, 4.54065382e-01f, 2.20337771e-02f, 2.28304073e-01f, 1.85021892e-01f, -2.41141170e-01f,
  -1.56809896e-01f, -3.21672827e-01f, 9.78955626e-02f, -7.43491482e-03f, 2.23698065e-01f, 2.46110305e-01f, 1.06808655e-01f, -1.45254284e-01f, 2.66310692e-01f, -3.63917239e-02f,
  1.49846792e-01f, -9.59261954e-02f, 1.09690458e-01f, 3.06575764e-02f, -2.23096665e-02f, -1.13006802e-02f, -1.58764705e-01f, 9.97208059e-02f, -1.28695190e-01f, 6.45740330e-02f,
  5.23851030e-02f, -2.36862954e-02f, 9.57196727e-02f, 1.24408923e-01f, 8.43709428e-03f, -9.80690122e-02f, -8.76928121e-02f, 7.06705265e-03f, -6.30472461e-03f, -2.05706544e-02f,
  -1.64127871e-01f, -3.74645181e-02f, -6.80427104e-02f, -1.18861133e-02f, 9.61179361e-02f, 2.34969072e-02f, 1.57545030e-01f, 1.18960127e-01f, 8.04877728e-02f, 9.24282372e-02f,
  1.15168422e-01f, 1.59382567e-01f, 1.13361649e-01f, 1.92629006e-02f, 1.04086660e-01f, 3.92889939e-02f, 5.47108687e-02f, -5.10673448e-02f, 1.00085817e-01f, -2.21592132e-02f,
  6.00832030e-02f, 1.87394604e-01f, 1.34026948e-02f, -7.21928850e-02f, -3.24490778e-02f, -2.80059986e-02f, 2.33598109e-02f, -8.60352218e-02f, 3.73926423e-02f, -1.48467636e-02f,
  -1.34044662e-01f, -2.97697447e-02f, 1.22274034e-01f, 3.02351471e-02f, -8.24032128e-02f, -4.93935235e-02f, -4.06188518e-03f, -8.26121569e-02f, -4.92030531e-02f, -9.82648358e-02f,
  5.02449647e-03f, 8.40961281e-03f, -1.17039494e-02f, -5.25140241e-02f, 5.34740053e-02f, 7.31100440e-02f, 2.74103712e-02f, 1.99023280e-02f, 6.14006482e-02f, 2.47485749e-03f,
  1.14919893e-01f, -1.56984609e-02f, 9.22377184e-02f, -1.91385690e-02f, -2.31001270e-03f, -2.41697412e-02f, 1.19781621e-01f, 6.13797382e-02f, 5.11560291e-02f, 1.05162272e-02f,
  -4.97196466e-02f, -7.86966309e-02f, -2.37316471e-02f, -2.84153689e-02f, 3.86945903e-02f, 1.07016549e-01f, -3.37837040e-02f, -1.38919689e-02f, -1.09393448e-02f, 6.85716793e-03f,
  -1.19123347e-02f, -5.65208048e-02f, 1.21062351e-02f, -2.40738001e-02f, -7.41305053e-02f, -1.53436154e-01f, -7.48708621e-02f, 6.63990304e-02f, 6.21587336e-02f, 8.73464334e-04f,
  9.55701768e-01f, 1.63309589e-01f, 2.12715775e-01f, 4.17105973e-01f, -3.91552337e-02f, 1.26924291e-01f, 2.53645271e-01f, 5.05333766e-02f, 4.74844247e-01f, -1.31673798e-01f,
  -1.80838630e-01f, 2.59615541e-01f, -1.87689006e-01f, 9.81090069e-02f, -2.49132529e-01f, -1.42425939e-01f, 2.03534752e-01f, 2.21592531e-01f, 5.71384206e-02f, 2.12279499e-01f,
  6.23752996e-02f, -1.76533610e-01f, -1.40225694e-01f, -2.57182091e-01f, 2.32474759e-01f, 1.17656358e-01f, -4.99832869e-01f, -2.20204547e-01f, -1.66175500e-01f, -1.90976977e-01f,
  5.57891876e-02f, 9.27667245e-02f, 7.61891305e-02f, 3.16433124e-02f, 9.91735533e-02f, 8.98762867e-02f, 1.53651563e-02f, -6.37605712e-02f, -3.69386701e-03f, 9.83802080e-02f,
  1.07518472e-01f, 7.61013944e-03f, -4.00192216e-02f, -1.09490313e-01f, 1.18363939e-01f, 5.07413745e-02f, 6.22549765e-02f, 5.07795587e-02f, 3.17102438e-03f, 1.06427126e-01f,
  1.64240360e-01f, 1.22014835e-01f, 6.59302473e-02f, 1.38178689e-03f, -4.89985803e-03f, 4.87785414e-02f, 1.83267333e-02f, -6.71269670e-02f, 7.39655867e-02f, 8.04699436e-02f,
  -4.30987403e-02f, -3.22546847e-02f, 6.53003156e-02f, 4.81608845e-02f, 3.06412298e-02f, -6.83089197e-02f, -3.12531018e-03f, -1.76360846e-01f, 9.50637907e-02f, 2.01135278e-02f,
  1.10476755e-01f, 3.43811810e-02f, -5.81982397e-02f, 2.18387768e-02f, -4.64018341e-03f, 1.62374914e-01f, -3.82890366e-03f, 5.76637127e-02f, 4.00866643e-02f, -7.14158863e-02f,
  -6.39322698e-02f, -4.61448468e-02f, 5.49557693e-02f, 7.60632893e-03f, 3.30638164e-03f, -1.06181940e-02f, -4.44014706e-02f, 1.15851358e-01f, -2.87065450e-02f, -7.07458779e-02f,
  -1.43572450e-01f, -1.75205216e-01f, -7.73175210e-02f, 4.35853004e-02f, -5.04927151e-02f, 1.45972660e-02f, 3.63349132e-02f, 1.16410896e-01f, -4.81018759e-02f, 7.65035227e-02f,
  7.51494542e-02f, 8.26374218e-02f, -4.44827899e-02f, -4.47228700e-02f, -5.14299795e-02f, 1.41339311e-02f, -7.22434595e-02f, -5.76661564e-02f, -2.56727904e-01f, -4.95784320e-02f,
  2.11247876e-02f, 7.70817325e-02f, 6.75201192e-02f, 7.84261674e-02f, 7.68119097e-02f, -1.08204715e-01f, 2.20388416e-02f, 1.60120782e-02f, -8.28050748e-02f, -7.13881478e-02f,
  1.87295422e-01f, -8.87337327e-02f, 8.68838355e-02f, -5.27863622e-01f, -2.89126448e-02f, -8.36649984e-02f, -2.69434273e-01f, -3.50564986e-01f, -4.59315270e-01f, -3.74167323e-01f,
  -3.28312606e-01f, -9.32254121e-02f, 1.91925585e-01f, -2.62887150e-01f, 3.43057901e-01f, 4.07409489e-01f, -2.77865827e-01f, -2.75691867e-01f, 6.38091341e-02f, -2.85560824e-02f,
  -4.32713516e-02f, -1.45436168e-01f, 1.60385996e-01f, 4.27613482e-02f, -1.72631457e-01f, -1.49790019e-01f, -3.09298113e-02f, 6.52041212e-02f, -3.02453220e-01f, -7.16517493e-02f,
  4.83465269e-02f, -1.09143801e-01f, 8.93291552e-03f, 1.16844922e-02f, 2.23630164e-02f, 5.10463379e-02f, -7.22307041e-02f, 1.62132502e-01f, -3.88887599e-02f, 2.20860238e-04f,
  3.44925001e-02f, 7.06582516e-02f, -1.56188488e-01f, 1.85947388e-01f, -1.72433481e-01f, -1.31583244e-01f, -3.96038406e-03f, 1.63609609e-02f, 4.57221828e-03f, 8.60816464e-02f,
  6.91791344e-03f, -4.10572365e-02f, -4.58145030e-02f, -2.32064892e-02f, -2.95416079e-02f, -1.77882060e-01f, 1.74274296e-01f, 3.78107652e-02f, -1.36721730e-01f, -8.18756148e-02f,
  7.97222648e-03f, 1.15914218e-01f, 9.43658650e-02f, -1.00924470e-01f, 4.84343991e-02f, -3.93913276e-02f, 7.99346119e-02f, -2.00660024e-02f, 5.57004102e-03f, -4.82558385e-02f,
  -1.46764800e-01f, -5.59686907e-02f, -9.11362935e-03f, -1.18345246e-01f, -6.42045261e-03f, 1.47755921e-01f, 1.44196883e-01f, 6.91723600e-02f, -1.49030000e-01f, -7.58102983e-02f,
  -4.11088429e-02f, -1.22703081e-02f, -5.90377264e-02f, 4.63538319e-02f, -3.76288407e-02f, -4.16629426e-02f, -1.15987808e-01f, 4.48447056e-02f, 2.27789357e-02f, 8.22408199e-02f,
  -6.04383051e-02f, -6.95156381e-02f, -6.60043359e-02f, -1.13798387e-01f, 1.44948930e-01f, 2.60407440e-02f, 2.47415677e-02f, -1.03426509e-01f, -6.53788373e-02f, 5.34887388e-02f,
  -2.04990521e-01f, 2.35084556e-02f, -1.77974284e-01f, -1.40246013e-02f, -3.78393047e-02f, -1.23125702e-01f, 8.68196413e-02f, -1.02647886e-01f, -4.44182418e-02f, -1.61584184e-01f,
  -6.22680411e-02f, -5.70668839e-03f, 7.98684806e-02f, -1.03731789e-01f, -1.18922815e-01f, -1.35078102e-01f, 1.17471084e-01f, -1.13737248e-01f, 9.72138625e-03f, -2.25536883e-01f,
  1.01261221e-01f, -4.25830364e-01f, 1.39333472e-01f, 1.14843123e-01f, 3.40717286e-01f, 1.93912238e-01f, 1.67096749e-01f, 4.30990495e-02f, 7.89925978e-02f, -4.93774951e-01f,
  -1.70898810e-01f, -2.65704125e-01f, -2.69415557e-01f, -8.58447573e-04f, 3.75729233e-01f, -1.06225565e-01f, 1.09075442e-01f, -1.71986088e-01f, 1.61022976e-01f, 1.32963229e-02f,
  1.90870985e-01f, 1.33696258e-01f, 2.21315548e-01f, 5.63457049e-02f, 1.46373913e-01f, -2.43352782e-02f, -6.63670450e-02f, 1.66558981e-01f, 2.70220358e-03f, 1.11670457e-01f,
  -4.74633425e-02f, -4.27650511e-02f, 8.05951357e-02f, -8.44249651e-02f, -3.97897512e-02f, -1.39846215e-02f, -1.45060876e-02f, 4.03827503e-02f, 1.46187991e-01f, 5.80594549e-03f,
  -7.75735602e-02f, 4.61848155e-02f, 3.49681377e-02f, 8.64193290e-02f, 8.62933099e-02f, 7.71118253e-02f, -3.18262950e-02f, 6.86845230e-03f, 1.59318503e-02f, 2.00917125e-02f,
  2.11173715e-03f, -5.37206791e-02f, 5.18704206e-02f, -7.29457662e-02f, -1.06334891e-02f, 5.93633056e-02f, 1.47285964e-02f, -2.09658332e-02f, -3.58783789e-02f, 7.64317140e-02f,
  1.65563270e-01f, 9.18168873e-02f, 2.84122154e-02f, -1.07772686e-02f, -6.78467080e-02f, 7.69474637e-03f, -7.46637862e-03f, -9.59389191e-03f, -7.26287290e-02f, -1.41713638e-02f,
  9.96697601e-03f, -2.29856726e-02f, 4.78830449e-02f, -4.77768434e-03f, 5.03347721e-03f, 1.88238397e-02f, -3.02412715e-02f, -1.30806938e-01f, 1.04987435e-02f, 6.67390525e-02f,
  2.50437204e-02f, 5.89290038e-02f, -6.82789907e-02f, 6.19734451e-02f, 3.10081076e-02f, 9.09190997e-03f, -5.26764579e-02f, -6.73761368e-02f, 1.51384575e-02f, 2.36872099e-02f,
  -4.17549521e-01f, -4.02499467e-01f, 1.98268592e-02f, -1.15440436e-01f, -1.03344217e-01f, -1.01142958e-01f, -4.06692456e-03f, -4.65479754e-02f, -1.19899586e-01f, 8.62042978e-02f,
  -1.09986831e-02f, -1.52038261e-02f, -7.45445639e-02f, 6.68339506e-02f, 4.95887622e-02f, -1.10474639e-02f, -5.97764850e-02f, -1.41664565e-01f, 3.99158634e-02f, -6.79370910e-02f,
  -1.56264529e-01f, -1.43213514e-02f, 9.79315192e-02f, 1.52664661e-01f, -2.03351505e-04f, -1.42018432e-02f, -7.82871917e-02f, -4.18045521e-02f, -2.05578953e-02f, -2.19989102e-02f,
  3.37801874e-01f, 4.08174396e-01f, 1.40803680e-01f, 2.36181676e-01f, -2.40171522e-01f, 2.69400477e-01f, 1.66052341e-01f, -2.97699645e-02f, 2.27489188e-01f, 2.23828837e-01f,
  -2.49026701e-01f, 3.55060309e-01f, -1.74108475e-01f, 3.20118189e-01f, -1.53897062e-01f, 1.65092405e-02f, 3.57174337e-01f, 2.29288533e-01f, -4.57155891e-02f, 1.75590128e-01f,
  2.39508916e-02f, -5.99994026e-02f, -2.07915872e-01f, -1.94205165e-01f, 9.07607973e-02f, 4.92070019e-02f, -3.82421106e-01f, -2.82629937e-01f, -1.44464578e-02f, -1.92492545e-01f,
  6.94412440e-02f, 6.11682087e-02f, 2.93480325e-02f, 8.74955207e-02f, 8.01000278e-03f, 1.21292360e-02f, 5.78820333e-02f, -3.75356674e-02f, -8.09903741e-02f, -2.81461440e-02f,
  1.45306811e-01f, -2.84523517e-02f, 4.27151807e-02f, -1.65731296e-01f, 2.63963994e-02f, 2.90008485e-02f, 4.72073257e-03f, -1.72937848e-02f, -3.39533053e-02f, -1.09890746e-02f,
  6.53524622e-02f, 5.73936850e-02f, 9.46765095e-02f, 2.93038785e-02f, -9.72719979e-04f, 4.04676460e-02f, -1.37791112e-02f, -6.08444959e-02f, 1.13593236e-01f, 4.04598787e-02f,
  -7.35411141e-03f, 1.86043784e-01f, -1.87970903e-02f, 4.31026183e-02f, 9.11739282e-03f, -8.05852339e-02f, -2.83330791e-02f, -1.50410831e-01f, 3.14490334e-03f, -2.89269220e-02f,
  -4.63425973e-03f, -9.72304773e-03f, -4.20033894e-02f, 1.01265833e-02f, 3.27665545e-02f, 1.00792170e-01f, -5.08841723e-02f, -1.89276598e-02f, 3.19555663e-02f, -6.93431422e-02f,
  -3.77489477e-02f, 3.96986865e-02f, -2.79151611e-02f, -8.72682780e-02f, 2.43959520e-02f, -1.35734960e-01f, 1.84301287e-02f, 3.02896164e-02f, -3.42380293e-02f, -2.65384763e-02f,
  1.15071207e-01f, 1.94107860e-01f, 4.66408245e-02f, -1.65329203e-02f, 1.66946165e-02f, 3.89255323e-02f, 6.69600442e-02f, 4.69858311e-02f, 5.69286011e-02f, -6.93708053e-03f,
  4.60475236e-02f, 6.86225221e-02f, 4.46598381e-02f, -1.08014986e-01f, -4.31248769e-02f, -4.52431776e-02f, 7.90532231e-02f, 1.48391398e-02f, -8.07044953e-02f, 3.36323166e-03f,
  8.40680823e-02f, 7.22164288e-02f, 8.51879716e-02f, 6.35363907e-02f, 7.04437569e-02f, -5.34631200e-02f, 7.49134943e-02f, -2.84336656e-02f, -1.05234515e-02f, 8.06572568e-03f,
  -1.39447778e-01f, -2.65204221e-01f, -9.44044963e-02f, 3.44845690e-02f, -6.69942126e-02f, -6.92420229e-02f, -2.99047202e-01f, -7.23593086e-02f, -3.85330498e-01f, -7.10568130e-02f,
  -1.50694534e-01f, -1.52456447e-01f, -2.84821749e-01f, -3.20746303e-01f, 1.37238717e-02f, -4.23038572e-01f, 2.00426891e-01f, -2.87699457e-02f, -1.11676209e-01f, 3.23700309e-01f,
  1.45825759e-01f, 3.58757079e-02f, 5.90474047e-02f, 2.72049159e-01f, 1.58439185e-02f, 3.86334926e-01f, 4.75931227e-01f, 5.54868989e-02f, 3.30114633e-01f, -4.75009605e-02f,
  -1.79908723e-01f, -1.84844971e-01f, 7.64775695e-03f, -2.60150470e-02f, 2.98114389e-01f, -4.65085022e-02f, 8.74007419e-02f, -8.14516768e-02f, -1.44499866e-03f, -3.06441113e-02f,
  1.39755622e-01f, -4.46081795e-02f, -2.00462118e-02f, -3.48084383e-02f, -3.86500917e-02f, 9.93050337e-02f, 2.12378637e-03f, -7.88549036e-02f, -8.75987113e-02f, -8.25011507e-02f,
  2.88907550e-02f, -2.31084526e-02f, 9.68111083e-02f, 1.75617859e-01f, 1.19001575e-01f, 5.48912212e-02f, 7.46077299e-02f, 1.26426846e-01f, -6.99936459e-03f, 9.33413506e-02f,
  5.43816276e-02f, -4.94896062e-02f, -1.17498338e-01f, -1.86804846e-01f, -3.41482423e-02f, -5.92236854e-02f, 2.27715522e-02f, 7.19252788e-03f, -3.11477259e-02f, -1.09071508e-02f,
  6.66390061e-02f, -1.83413643e-02f, -1.21942624e-01f, 3.66357826e-02f, 9.45562944e-02f, -9.69146118e-02f, -1.44700240e-02f, 7.08948001e-02f, 1.33868247e-01f, -2.02092398e-02f,
  -2.57692754e-01f, -5.87039292e-02f, 9.47335064e-02f, 1.68882553e-02f, -1.42122939e-01f, 2.02122778e-02f, -4.88242842e-02f, -1.81314461e-02f, -7.38291070e-02f, 4.97552007e-02f,
  1.51696637e-01f, 3.37173015e-01f, 4.40846011e-02f, -6.51074350e-02f, -4.07800786e-02f, 7.82174524e-03f, -1.00368924e-01f, 4.57651466e-02f, 1.11585282e-01f, -1.00736313e-01f,
  2.08404765e-01f, 4.81131226e-02f, 4.08252254e-02f, -1.24223297e-02f, 9.27116349e-02f, 2.03361034e-01f, 2.23150048e-02f, 1.03087552e-01f, 1.77057743e-01f, 2.05240324e-01f,
  1.39065236e-01f, -8.27255696e-02f, 1.98896248e-02f, 1.45675302e-01f, 1.00629345e-01f, 1.07195139e-01f, 1.41535373e-02f, 1.58676699e-01f, 3.91839705e-02f, 5.89028522e-02f,
  2.76854366e-01f, -2.43376717e-01f, -4.43142980e-01f, -1.87460929e-01f, 2.27168858e-01f, 3.54868591e-01f, 9.46099758e-02f, 5.58441831e-03f, -3.65801781e-01f, 1.44308768e-02f,
  1.97571680e-01f, -5.33956923e-02f, -1.94039226e-01f, 1.40894443e-01f, 2.19502285e-01f, -2.55234331e-01f, 1.01654276e-01f, 3.55114192e-02f, -2.42985919e-01f, 1.28706723e-01f,
  5.67646734e-02f, 4.59481537e-01f, -1.20267630e-01f, 2.43298560e-01f, 1.67208821e-01f, -6.44506738e-02f, 2.61889577e-01f, 1.21594071e-01f, 2.77608067e-01f, 1.60830215e-01f,
  -1.82649847e-02f, -1.04347594e-01f, -2.20710356e-02f, -1.17213599e-01f, 4.96443361e-02f, 1.52727038e-01f, 1.19499497e-01f, 8.63284618e-02f, -1.07699516e-03f, 4.59547974e-02f,
  1.18328847e-01f, 7.78042749e-02f, 5.97409308e-02f, 1.66800655e-02f, 1.01786748e-01f, 4.06989045e-02f, -7.92369768e-02f, -1.05278321e-01f, -7.91451335e-02f, 1.15823649e-01f,
  -1.38708711e-01f, -6.12355694e-02f, 4.49337997e-02f, -4.95727770e-02f, -6.05834424e-02f, 4.57194000e-02f, -6.86840937e-02f, 2.32261978e-02f, -4.92749177e-02f, 3.51947621e-02f,
  1.39192298e-01f, 3.28969769e-02f, 6.25884682e-02f, -6.36674315e-02f, -4.62480225e-02f, -7.62972757e-02f, -2.58736201e-02f, -5.30115739e-02f, -7.86221027e-02f, 1.52834551e-02f,
  -7.24592805e-02f, 5.30257784e-02f, 2.58236472e-03f, -8.19620327e-04f, 6.88953847e-02f, -2.67662462e-02f, 7.14806244e-02f, 9.71074775e-02f, -1.69574469e-02f, -3.44759412e-02f,
  -6.48088381e-02f, 1.30217057e-02f, 1.48483682e-02f, -1.79047994e-02f, 1.85452495e-02f, 5.37688322e-02f, 7.04237893e-02f, 1.27697647e-01f, -8.16214830e-02f, -4.71683656e-04f,
  1.30972499e-03f, 1.32492587e-01f, -6.02279343e-02f, 4.44959290e-03f, -1.34017542e-01f, 8.78653601e-02f, -2.58318298e-02f, 8.97051468e-02f, 5.51941171e-02f, 6.28216267e-02f,
  2.33678401e-01f, -1.97651945e-02f, -5.76934703e-02f, 1.61981340e-02f, -6.12231866e-02f, 8.68251771e-02f, -1.56906433e-02f, -3.89412493e-02f, -7.65962377e-02f, 1.33098274e-01f,
  4.27991599e-02f, 1.14048697e-01f, -2.93578431e-02f, -2.03882232e-02f, 1.50226960e-02f, 3.50690223e-02f, 6.95503056e-02f, -6.80316612e-02f, 4.32990827e-02f, -6.25969395e-02f,
  6.76964521e-01f, -3.77467215e-01f, -7.85595477e-02f, 9.31936055e-02f, 3.99749845e-01f, 1.40697449e-01f, 2.84686983e-01f, 2.82930341e-02f, 1.96442306e-01f, -3.00285906e-01f,
  1.22295201e-01f, -3.09416056e-01f, -1.43335208e-01f, 1.56988382e-01f, 2.58111358e-01f, -8.61242861e-02f, 6.46004230e-02f, -5.87978587e-02f, 5.36076091e-02f, 1.22395575e-01f,
  2.42949590e-01f, 2.81408042e-01f, 5.02545340e-03f, -2.00035404e-02f, 2.90413320e-01f, -1.92304194e-01f, -1.15136005e-01f, -1.54227898e-01f, -2.09480673e-01f, -7.86346421e-02f,
  6.38867393e-02f, 1.40700474e-01f, 1.74802527e-01f, -8.17924514e-02f, 1.20926492e-01f, 1.75812796e-01f, -6.19879030e-02f, -1.49004059e-02f, -6.59460127e-02f, -4.08847369e-02f,
  -1.03732027e-01f, -9.36981589e-02f, -7.41693750e-03f, -5.21442760e-03f, 1.20326720e-01f, -6.70225918e-03f, -7.56634027e-03f, 1.35219120e-03f, -1.73355132e-01f, 3.07978336e-02f,
  4.42225076e-02f, -7.83680379e-02f, 8.57972801e-02f, -7.70511478e-02f, -1.67875607e-02f, -1.55268619e-02f, -1.67014167e-01f, -1.81382924e-01f, -1.46130502e-01f, 2.39159409e-02f,
  1.44409286e-02f, 4.58784774e-02f, 7.85173625e-02f, 6.01159669e-02f, 1.29457365e-03f, -4.96436693e-02f, -6.47234321e-02f, -1.90081343e-01f, -9.32389647e-02f, 4.97493260e-02f,
  1.90728474e-02f, 1.07638948e-01f, 3.99289913e-02f, -2.57858261e-02f, 7.91449323e-02f, 2.63092630e-02f, 7.09391460e-02f, -1.19207703e-01f, 1.20257422e-01f, -4.07873727e-02f,
  9.09496564e-03f, -5.21720536e-02f, 1.11404426e-01f, -1.21008016e-01f, -3.60544845e-02f, 1.09753244e-01f, 7.16957822e-03f, 1.76297538e-02f, 7.97295291e-03f, 3.07459161e-02f,
  -1.77426517e-01f, -3.69819909e-01f, 8.12845398e-03f, -1.45397663e-01f, -1.02141201e-01f, 2.09183604e-01f, 8.86496603e-02f, 5.24472781e-02f, -1.02664016e-01f, 3.30107138e-02f,
  7.34646246e-02f, -9.28606465e-02f, 2.63528060e-02f, 1.82760302e-02f, -9.83382389e-02f, 1.50920242e-01f, -1.70958877e-01f, -5.02982736e-02f, -5.55450134e-02f, -1.36845499e-01f,
  -9.91942361e-02f, -4.78374735e-02f, -8.08611745e-04f, 5.62212020e-02f, -2.62472909e-02f, -6.97421208e-02f, -6.10920340e-02f, -9.14028063e-02f, -4.11368534e-02f, -1.18449859e-01f,
  3.51269484e-01f, 1.50379673e-01f, 1.59203634e-01f, 2.18034029e-01f, 1.73391730e-01f, -2.49782041e-01f, -2.10436791e-01f, -7.48814200e-04f, 1.14809699e-01f, -1.61080793e-01f,
  -2.00030789e-01f, 3.63823444e-01f, -4.22508746e-01f, 2.25717977e-01f, -4.14873689e-01f, -4.19998586e-01f, 5.04826233e-02f, 1.48661420e-01f, 4.20012092e-03f, 2.04338506e-02f,
  8.58117417e-02f, -1.38750926e-01f, -1.90271642e-02f, 6.57014325e-02f, 2.03195959e-01f, 2.61742711e-01f, -2.42599890e-01f, -1.10583127e-01f, 2.36621335e-01f, 1.19857907e-01f,
  -6.52042776e-03f, 4.26722057e-02f, 4.19623777e-02f, 8.90365168e-02f, -4.73326594e-02f, -8.62121433e-02f, 1.22831743e-02f, -1.26848564e-01f, -1.43800750e-02f, 6.37733638e-02f,
  1.35960551e-02f, 2.66009141e-02f, 1.81302235e-01f, -1.95215363e-02f, 1.47887379e-01f, 1.84911549e-01f, 4.16937172e-02f, 7.20952032e-03f, 1.39126360e-01f, 1.04017973e-01f,
  4.05741073e-02f, 5.93224354e-02f, 2.93430276e-02f, -2.23715287e-02f, -1.38716707e-02f, 4.12047654e-02f, 5.55753000e-02f, 3.30937579e-02f, 8.92173406e-03f, 1.33006215e-01f,
  -1.63462926e-02f, -4.34489064e-02f, 2.82486957e-02f, 1.53451627e-02f, -8.26437473e-02f, 6.79136142e-02f, -3.55629399e-02f, -4.56639938e-03f, 4.12749499e-02f, -8.36528912e-02f,
  -5.34504429e-02f, 1.54772788e-01f, 6.41736481e-03f, -2.13807691e-02f, -1.05399834e-02f, 9.95578691e-02f, -9.28074413e-04f, -4.53591384e-02f, 1.74438953e-02f, 3.82383838e-02f,
  -6.61759125e-03f, -5.22363372e-02f, -3.82859223e-02f, 2.56779231e-02f, -4.67435196e-02f, -1.15133636e-01f, -5.19966222e-02f, 6.12083487e-02f, -4.45853770e-02f, -7.02098161e-02f,
  -5.30259132e-01f, -4.96427566e-01f, -1.64581522e-01f, 4.40083668e-02f, 3.43574099e-02f, 4.99447109e-03f, 3.65514345e-02f, 7.76613131e-02f, -1.71401799e-01f, -7.40267113e-02f,
  8.08878690e-02f, 3.73939089e-02f, -3.14313062e-02f, 2.50376053e-02f, -4.55710329e-02f, -3.17606181e-02f, -9.13690925e-02f, -2.38951221e-02f, -8.28267932e-02f, 1.83980204e-02f,
  2.55863406e-02f, 2.71742865e-02f, 1.15820970e-02f, -5.25975274e-03f, 6.99152891e-03f, 1.01457285e-02f, 4.11488265e-02f, 9.05321687e-02f, -1.06782876e-01f, 7.66512826e-02f,
  -2.07787976e-01f, 1.63439348e-01f, 3.88947040e-01f, 1.08530782e-01f, 1.43175200e-01f, 3.91811639e-01f, 2.73406446e-01f, 2.38933831e-01f, 2.35072449e-01f, 3.63188237e-02f,
  1.13132060e-01f, -1.48509145e-02f, 7.72627890e-02f, 2.02021688e-01f, 8.06949809e-02f, 1.12195678e-01f, 1.82461292e-01f, -4.12959941e-02f, -8.92600417e-02f, -4.81918529e-02f,
  2.25532614e-02f, -1.77576661e-01f, 1.88494056e-01f, -1.79280132e-01f, 1.77784368e-01f, -1.54018447e-01f, -2.17879161e-01f, -9.07082856e-02f, -6.92158518e-03f, 6.01269351e-03f,
  -5.37675098e-02f, -5.28854616e-02f, -1.44262034e-02f, -2.82113384e-02f, 4.41600345e-02f, -5.22844605e-02f, -2.74631027e-02f, -6.06025383e-02f, -7.99997672e-02f, 2.14353874e-02f,
  -1.61459278e-02f, 3.44228595e-02f, -1.21721722e-01f, -4.91830893e-02f, 5.13337599e-03f, 6.10772818e-02f, 1.69174060e-01f, 1.55241609e-01f, 1.58879906e-01f, 2.23854125e-01f,
  1.42496407e-01f, 1.74583569e-01f, 1.65909186e-01f, 2.78585101e-03f, 7.78505802e-02f, 2.24361699e-02f, 7.36735314e-02f, 1.68958884e-02f, 1.31926620e-02f, 5.20702042e-02f,
  -8.10324028e-02f, -9.88009498e-02f, 1.39223151e-02f, 5.78228896e-03f, -2.24991404e-02f, 5.90784624e-02f, 5.99371716e-02f, -2.47816984e-02f, -8.20106044e-02f, 3.61246467e-02f,
  5.58734387e-02f, -5.28955460e-02f, 3.47156040e-02f, 6.73559904e-02f, -4.26001251e-02f, 2.24746694e-03f, -3.32041495e-02f, -5.40909097e-02f, 7.56173059e-02f, 6.11861795e-02f,
  -1.30202789e-02f, 3.38018849e-03f, -5.38640060e-02f, 1.05223656e-02f, 2.41392180e-02f, -3.25156786e-02f, -8.59261379e-02f, 1.43171847e-01f, 1.48929497e-02f, -9.99271125e-02f,
  -2.20119700e-01f, -3.71750593e-01f, -1.47394538e-01f, -1.08598627e-01f, -1.26753956e-01f, -7.58229336e-03f, -1.01632349e-01f, 3.95570807e-02f, -1.37375325e-01f, -4.21298556e-02f,
  2.84687430e-02f, 4.30497937e-02f, -7.92482123e-02f, -6.43082103e-03f, -8.02015066e-02f, 2.52256934e-02f, -7.01120198e-02f, -9.88617912e-02f, -4.84361798e-02f, -8.27348083e-02f,
  -1.69710978e-03f, -8.52463841e-02f, -2.15959139e-02f, 2.60163024e-02f, -7.06817955e-02f, 3.80462483e-02f, -1.53961271e-01f, -2.00942326e-02f, -3.01636998e-02f, -2.50635650e-02f,
  4.80137812e-03f, 3.64858806e-01f, -3.42649847e-01f, -5.05558252e-02f, -7.97670428e-03f, 4.97979015e-01f, 3.45118582e-01f, -3.26602943e-02f, 9.40746721e-03f, 3.79014760e-01f,
  1.59976572e-01f, -5.83819263e-02f, 1.27463087e-01f, 3.22254866e-01f, 6.15467057e-02f, 1.55045643e-01f, 2.95708805e-01f, 1.91774160e-01f, -1.95273638e-01f, 2.84370780e-01f,
  -6.43639266e-03f, 4.10175145e-01f, -2.58062035e-01f, 9.50090364e-02f, 3.77861522e-02f, -3.41746092e-01f, -7.67982230e-02f, -3.21229577e-01f, -7.85754547e-02f, -6.47584572e-02f,
  6.06472604e-02f, 3.38034891e-02f, -7.75274038e-02f, -6.26627803e-02f, 4.67956401e-02f, 1.38593942e-01f, 3.50071164e-03f, -6.56536892e-02f, -1.53199852e-01f, -3.54938209e-02f,
  1.21850573e-01f, -3.85592692e-02f, 1.11526385e-01f, -9.42053571e-02f, -1.36810122e-02f, -8.01176056e-02f, -3.70647907e-02f, -1.08079962e-01f, -7.17131272e-02f, 7.41602108e-02f,
  2.63539166e-03f, -3.78554352e-02f, 1.24076054e-01f, -1.80715043e-02f, -4.78420779e-02f, 6.93040639e-02f, 1.92733351e-02f, 7.84069300e-03f, 9.57677066e-02f, -2.81991381e-02f,
  -1.94047540e-02f, 1.73847929e-01f, 1.33981302e-01f, -7.45240301e-02f, 5.72354794e-02f, -1.31183416e-01f, 3.71800214e-02f, -8.98070261e-02f, -2.94101052e-02f, 1.57171294e-01f,
  2.20169760e-02f, -5.68423644e-02f, 1.32158160e-01f, 9.17344764e-02f, 2.96932855e-03f, 6.65501803e-02f, -7.76569620e-02f, -9.73913167e-03f, -6.41338760e-03f, -3.23422104e-02f,
  -4.48763818e-02f, 2.54820809e-02f, -4.89133485e-02f, -1.21046476e-01f, 3.32889855e-02f, -9.89212319e-02f, 1.01529814e-01f, -7.71205127e-02f, -3.52953151e-02f, -2.00794451e-02f,
  1.34354129e-01f, 3.11364979e-01f, 9.15815774e-03f, 4.85755205e-02f, 4.47930582e-02f, 7.09488168e-02f, 1.53385792e-02f, 1.50824490e-03f, -1.65445525e-02f, 1.19715884e-01f,
  2.10648999e-01f, 7.93872923e-02f, 1.11307807e-01f, -5.25026470e-02f, -4.87643369e-02f, 1.67872667e-01f, 1.42298713e-01f, -6.85386583e-02f, -2.40680780e-02f, 2.74503995e-02f,
  7.51498118e-02f, 1.33310154e-01f, 1.21229552e-01f, -5.80155803e-03f, 1.13359563e-01f, 3.42837162e-02f, -1.01732055e-03f, -4.59759384e-02f, 3.37581672e-02f, 8.44484568e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  3.68357539e-01f, 4.00212049e-01f, 2.68491983e-01f, 4.31074202e-01f, 4.51202005e-01f, 4.11876708e-01f, 3.75586569e-01f, 4.19714391e-01f, 1.68917522e-01f, 2.16232508e-01f,
  1.63730130e-01f, 2.76023537e-01f, 2.01343790e-01f, 2.08334357e-01f, 4.68089402e-01f, 4.58720654e-01f, 5.56588173e-01f, 2.89296180e-01f, 3.63439113e-01f, 4.41272676e-01f,
  2.87404746e-01f, 3.05219084e-01f, 2.77291387e-01f, 3.10557246e-01f, 2.33890623e-01f, 3.50008011e-01f, 2.11330608e-01f, 2.79159874e-01f, 5.74714482e-01f, 3.21600646e-01f,
  4.68555987e-01f, 3.16040695e-01f, 4.06704098e-01f, 4.51917350e-01f, 4.47863430e-01f, 3.44329506e-01f, 2.52210677e-01f, 3.76213104e-01f, 3.69475365e-01f, 3.53043288e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.50113637e-02f, -3.14314127e-01f, -5.59750617e-01f, -4.03253555e-01f, 3.11386853e-01f, -3.17656964e-01f, -1.72661170e-02f, 1.50746211e-01f, -2.15880588e-01f, -1.42627820e-01f,
  -1.88384101e-01f, 7.77354464e-02f, -4.89126891e-01f, 2.25704670e-01f, -5.00216633e-02f, -3.85490507e-01f, 1.05684608e-01f, 3.89679968e-01f, -2.02546194e-01f, 3.41575444e-01f,
  3.77202243e-01f, -2.62510896e-01f, 4.59680796e-01f, -3.82816464e-01f, 4.04382288e-01f, -2.64037400e-01f, -4.17935193e-01f, -4.02730256e-01f, -4.13150609e-01f, -1.92210555e-01f,
  -2.33283311e-01f, 4.12100464e-01f, 6.53511286e-01f, -2.61524826e-01f, 3.27059567e-01f, 8.50358699e-03f, -2.78986603e-01f, 7.05467761e-02f, 3.20638627e-01f, 1.42674536e-01f,
  3.41389090e-01f, 5.27041495e-01f, -8.52850378e-02f, 2.80195236e-01f, -3.46768081e-01f, -2.36435890e-01f, -5.64035438e-02f, -4.95497048e-01f, -3.76333445e-01f, 2.22038224e-01f,
  1.85129672e-01f, -6.37778282e-01f, -2.09780887e-01f, -1.16767123e-01f, -3.55417222e-01f, -4.88856018e-01f, -4.01531368e-01f, 7.11498363e-03f, -3.18638831e-01f, -3.83211851e-01f,
  -3.28222901e-01f, -1.80786282e-01f, 2.59939402e-01f, 2.44161710e-01f, 1.14976935e-01f, -1.43088058e-01f, -4.03932720e-01f, 3.03077072e-01f, -1.43566951e-01f, 3.56069535e-01f,
  -2.06674129e-01f, -1.04622707e-01f, 1.28576636e-01f, 1.70423657e-01f, -1.81540065e-02f, 6.21320531e-02f, 8.36475044e-02f, 5.11130830e-03f, -6.31386995e-01f, -1.44973516e-01f,
  4.87059832e-01f, -2.72382647e-01f, 8.13107848e-01f, 3.56104106e-01f, -1.45487441e-02f, -1.86889604e-01f, -5.38655162e-01f, 4.38957483e-01f, -5.59876561e-01f, 4.62527536e-02f,
  -4.45659310e-01f, -5.29064000e-01f, -3.63127351e-01f, -4.61720943e-01f, -2.00998709e-01f, 3.34583610e-01f, -5.61667025e-01f, 2.60699391e-01f, -4.70736891e-01f, -4.67063606e-01f,
  -1.74706444e-01f, 5.30080318e-01f, 9.93963182e-02f, -6.10749066e-01f, -6.65628254e-01f, 5.06689966e-01f, -6.66048467e-01f, 4.65735734e-01f, 2.52999663e-01f, -4.07892048e-01f,
  -2.41212666e-01f, 1.05788432e-01f, -3.27867240e-01f, -5.55941403e-01f, -1.08850449e-01f, 3.56231779e-01f, -6.34004891e-01f, -2.11074263e-01f, 1.06437346e-02f, 2.91996568e-01f,
  -5.67005277e-01f, 9.48241502e-02f, -2.77411938e-01f, 5.63839614e-01f, 4.71269250e-01f, -2.93347627e-01f, 1.78834889e-02f, 5.21910310e-01f, 7.04388395e-02f, -1.08001582e-01f,
  -7.75999483e-03f, 1.69503465e-02f, -3.21200401e-01f, -1.30880430e-01f, -3.39088663e-02f, -3.70403767e-01f, -7.79725537e-02f, -2.21071416e-03f, -6.76940754e-03f, -2.35138789e-01f,
  -8.58448818e-02f, -1.59563765e-01f, -2.20765751e-02f, -1.74122050e-01f, -2.76410803e-02f, -2.00375885e-01f, -1.89396329e-02f, 1.36672586e-01f, 1.14987403e-01f, 8.28352850e-03f,
  -2.50554442e-01f, 3.37016359e-02f, -2.14679793e-01f, -3.59491706e-01f, -2.10864544e-01f, 3.65356028e-01f, -2.79586971e-01f, -1.79608896e-01f, -1.44828990e-01f, -4.59293455e-01f,
  -1.80305034e-01f, 6.16945863e-01f, -1.47391632e-01f, 2.47745097e-01f, 4.87042397e-01f, 4.21665728e-01f, -2.29761619e-02f, -2.49184132e-01f, 4.16860104e-01f, -9.54352971e-03f,
  5.14747858e-01f, 2.04837859e-01f, -3.80124718e-01f, -3.22290659e-01f, 1.76867962e-01f, 2.69260585e-01f, -2.17063632e-02f, -8.09485093e-02f, -4.27310973e-01f, -5.77842474e-01f,
  -3.21972817e-01f, -4.10815418e-01f, -4.96073633e-01f, -4.38089877e-01f, 3.07445049e-01f, -2.83877283e-01f, 1.55002996e-01f, 3.39061856e-01f, -1.00206420e-01f, 3.59948277e-01f,
  -4.14848924e-01f, -4.87148106e-01f, -3.00397258e-02f, 2.00710207e-01f, -1.39901549e-01f, -1.33323237e-01f, -9.08041075e-02f, -6.10199235e-02f, 1.22475922e-02f, -7.85005018e-02f,
  -7.15289116e-02f, 7.38461018e-02f, 1.33675396e-01f, -4.92400795e-01f, -2.41465911e-01f, 7.62523850e-03f, -3.67383033e-01f, -2.38742843e-01f, -4.22582440e-02f, -4.95229103e-02f,
  4.60052609e-01f, 3.81761007e-02f, 1.81893021e-01f, -5.48912026e-02f, 3.80530149e-01f, 1.31018618e-02f, 3.93596411e-01f, 2.88808286e-01f, 2.19824582e-01f, 3.72296839e-04f,
  -5.75814247e-01f, 4.70095217e-01f, -4.82991815e-01f, -4.10903662e-01f, 3.55901331e-01f, -4.84544903e-01f, 2.41506293e-01f, -1.25037208e-01f, -1.70378983e-01f, -2.72452027e-01f,
  -3.44671130e-01f, 2.33310908e-02f, -4.26789135e-01f, -2.69815505e-01f, -4.40924726e-02f, -3.24440867e-01f, -4.50001895e-01f, 6.99782610e-01f, -4.57686067e-01f, -2.14091927e-01f,
  7.80318916e-01f, -3.83171678e-01f, -1.27976164e-02f, -1.75990146e-02f, 3.62620473e-01f, -2.23930523e-01f, -4.25093472e-01f, 5.88133074e-02f, -2.51722783e-01f, -4.93508846e-01f,
  -7.77368844e-01f, -3.33760023e-01f, -6.10532612e-02f, 1.59478426e-01f, -6.10371947e-01f, -2.49515325e-01f, 5.77495210e-02f, 2.32903302e-01f, 5.37387580e-02f, 1.52042806e-01f,
  -2.39578113e-01f, 3.72279622e-02f, 2.00960711e-01f, -7.74112120e-02f, 3.29299390e-01f, -2.04851955e-01f, 1.74659625e-01f, 1.02888681e-01f, 2.81293809e-01f, -2.94406235e-01f,
  -3.18230093e-01f, -4.38363075e-01f, -6.88413143e-01f, -3.56322587e-01f, -4.54743654e-01f, -2.83617646e-01f, 4.32386398e-01f, -1.75808638e-01f, 4.27855141e-02f, -6.24051630e-01f,
  2.57325210e-02f, -1.88122839e-01f, 4.89175826e-01f, -5.60699105e-01f, 9.17247906e-02f, 1.94025934e-01f, 4.05653358e-01f, 3.55592281e-01f, 2.20291212e-01f, 1.33164927e-01f,
  -7.39844322e-01f, -5.37447989e-01f, -6.53299177e-03f, 7.59629458e-02f, -4.43908393e-01f, 4.42135304e-01f, 1.60770968e-01f, -6.15207911e-01f, -3.04453731e-01f, -3.29384774e-01f,
  -4.09586579e-01f, -7.96506643e-01f, -3.25567693e-01f, 2.04206612e-02f, 3.27251524e-01f, 3.52857739e-01f, 4.95761812e-01f, 1.81795299e-01f, -5.47388911e-01f, 6.87219501e-01f,
  -3.65111798e-01f, 4.06719059e-01f, 1.54716671e-01f, -3.07469666e-01f, -1.16203927e-01f, -1.14307851e-01f, -5.64203896e-02f, -2.73318261e-01f, 4.54435557e-01f, -3.78794909e-01f,
  3.30108255e-01f, -1.11009367e-01f, 5.44799805e-01f, 1.57230183e-01f, 3.36916268e-01f, 2.34374609e-02f, 5.15638255e-02f, 2.02496484e-01f, 3.42767745e-01f, 3.30782503e-01f,
  2.77465612e-01f, 1.68202251e-01f, 3.09633464e-01f, 5.15402436e-01f, -2.95260578e-01f, 6.82870209e-01f, 9.04330313e-02f, 2.86559910e-01f, -5.72481215e-01f, -5.96397519e-01f,
  -3.33134949e-01f, 1.55108357e-02f, -1.72911853e-01f, 3.72926474e-01f, -4.66565162e-01f, -7.11640045e-02f, 1.03687160e-01f, 6.63385749e-01f, -5.45999408e-01f, -1.22586533e-01f,
  -3.05236489e-01f, 3.65555257e-01f, 1.76559836e-01f, -5.79381466e-01f, 7.08099246e-01f, -6.23790100e-02f, -4.37874883e-01f, -6.17192686e-01f, 8.59240890e-02f, -1.15657538e-01f,
  2.10762352e-01f, -3.15153718e-01f, -2.88883269e-01f, -9.02010024e-01f, -1.63813993e-01f, -1.05406977e-01f, 9.51286256e-02f, 1.10136621e-01f, -5.37863672e-01f, -4.05802220e-01f,
  -4.63065773e-01f, 5.65249085e-01f, -4.60244775e-01f, 3.32124352e-01f, 2.88496017e-01f, -2.84068733e-01f, -2.44803280e-01f, 5.43347776e-01f, 2.23751038e-01f, -2.79568851e-01f,
  -4.64440703e-01f, -4.95883971e-01f, -1.05043910e-01f, 3.43317807e-01f, -1.91952989e-01f, 2.42649876e-02f, -1.56741083e-01f, -3.11709702e-01f, 4.55823401e-03f, 3.83593515e-02f,
  6.63346574e-02f, 1.48298606e-01f, 2.80886684e-02f, -2.75806546e-01f, -5.82204945e-03f, -1.96110278e-01f, 3.17035526e-01f, -1.19784258e-01f, 2.30069369e-01f, 1.82139635e-01f,
  -6.92767054e-02f, 6.64486587e-02f, 2.89777126e-02f, 5.36777079e-01f, -4.31242734e-01f, 3.12393278e-01f, -1.68313563e-01f, 8.14193264e-02f, -3.26611996e-01f, -5.54285161e-02f,
  -2.27855906e-01f, 4.98282850e-01f, 1.17691480e-01f, -6.52311265e-01f, -1.81106091e-01f, -4.66532558e-01f, -1.22807458e-01f, -2.73867488e-01f, -3.14970046e-01f, 7.15110064e-01f,
  5.60871005e-01f, -3.91026407e-01f, -5.89116514e-01f, -7.17309356e-01f, -6.14556432e-01f, -2.30711639e-01f, -2.82535963e-02f, 7.44572356e-02f, 1.67525932e-01f, -1.88648641e-01f,
  1.16720632e-01f, -6.83639646e-01f, 2.14368686e-01f, -3.84124905e-01f, 3.27189595e-01f, -1.36428416e-01f, 1.41428247e-01f, 1.28208712e-01f, 5.75742960e-01f, -6.75472140e-01f,
  4.46794450e-01f, -1.61251351e-02f, -1.68497652e-01f, -3.40920597e-01f, 6.69165432e-01f, 2.00648323e-01f, 3.80529106e-01f, -1.01227462e-01f, 8.38952810e-02f, -7.80918747e-02f,
  -2.78974827e-02f, 4.67389971e-02f, 1.15090236e-02f, -1.91165343e-01f, -2.33601451e-01f, -1.72791593e-02f, 3.97355780e-02f, -3.56906950e-01f, 9.62888226e-02f, -1.08779341e-01f,
  -2.15640470e-01f, 8.77490267e-02f, 3.72468889e-01f, -2.72645652e-02f, 8.15668609e-03f, 9.47503652e-03f, -3.23088139e-01f, 1.67879350e-02f, -2.02869385e-01f, -2.34310284e-01f,
  -2.05624402e-01f, -1.65781543e-01f, 3.59611064e-01f, 3.80692691e-01f, 3.43868434e-01f, -2.75864184e-01f, 1.93075500e-02f, -2.04914659e-01f, 1.39393215e-03f, -4.13703591e-01f,
  1.58833757e-01f, 6.01279587e-02f, 3.89262050e-01f, 2.99283415e-01f, -1.77907869e-01f, -1.78769901e-01f, -2.52603203e-01f, 1.17853098e-01f, -2.79787809e-01f, -5.24402440e-01f,
  3.72404456e-01f, -2.42883921e-01f, 4.69513595e-01f, -2.56991208e-01f, 5.74191570e-01f, -8.45609829e-02f, -3.83932114e-01f, -2.33470097e-01f, -2.35049859e-01f, -1.69305742e-01f,
  -8.65374804e-02f, -1.04904413e-01f, -3.28039348e-01f, 3.51351470e-01f, -3.11266422e-01f, -2.58075535e-01f, -6.51645958e-02f, -2.97771364e-01f, -3.62766057e-01f, 1.03187963e-01f,
  -2.99666911e-01f, -2.63676822e-01f, -2.09930763e-01f, -4.56563234e-02f, 1.77099124e-01f, 6.67611603e-03f, -6.05518334e-02f, -4.09447789e-01f, 7.69505054e-02f, -1.98508829e-01f,
  -9.97627378e-02f, -3.68109941e-01f, 6.00797636e-03f, -7.41144568e-02f, -2.53483891e-01f, 2.77598530e-01f, 1.19212493e-01f, 3.39737356e-01f, 3.38078618e-01f, -1.77934319e-01f,
  1.15394898e-01f, 2.66588032e-01f, -4.27616924e-01f, -2.26643458e-01f, 1.70703933e-01f, 2.83799589e-01f, -1.63296163e-01f, -3.71078789e-01f, -2.22489551e-01f, -1.98574781e-01f,
  -1.54540762e-01f, -3.98344517e-01f, 3.12754810e-01f, -2.29245082e-01f, -1.15989484e-01f, -1.98656067e-01f, -9.48992819e-02f, 1.87784165e-01f, 9.74471718e-02f, 2.35807166e-01f,
  4.69616205e-01f, -2.29056850e-01f, -3.70318741e-01f, -5.88055670e-01f, -2.04618797e-01f, -5.57053506e-01f, -1.58193529e-01f, 3.92987520e-01f, -2.88919717e-01f, 6.79249406e-01f,
  -1.42736748e-01f, -3.36368009e-02f, 5.50332904e-01f, -1.06154919e-01f, 5.02253950e-01f, -1.19503057e-02f, -2.60145903e-01f, -1.12916633e-01f, -2.59041905e-01f, -1.42582312e-01f,
  4.09916222e-01f, 4.96233180e-02f, -3.84768754e-01f, -2.13088349e-01f, -2.22716033e-01f, -1.05963141e-01f, 1.06297523e-01f, 1.05614871e-01f, 2.45280620e-02f, 1.77683048e-02f,
  1.91595256e-01f, 1.32552713e-01f, -7.82606378e-02f, -4.83631529e-02f, -2.53214210e-01f, 2.26398632e-01f, -2.66481876e-01f, 1.07856721e-01f, -5.84409311e-02f, -3.88553560e-01f,
  3.59619975e-01f, 3.85830909e-01f, 3.54523093e-01f, 2.52986103e-01f, -3.12035084e-01f, -2.92917639e-01f, -2.14303210e-01f, 2.11648539e-01f, 3.32268953e-01f, 4.47226256e-01f,
  -4.92316127e-01f, -6.33803844e-01f, -3.37972194e-01f, 8.31728131e-02f, 6.06701136e-01f, 1.69888511e-01f, -1.92303613e-01f, -4.94273394e-01f, -3.44923437e-01f, -3.49486440e-01f,
  1.04474369e-02f, -5.43095112e-01f, 1.02693811e-01f, -3.99842471e-01f, -3.82494330e-01f, 6.22187376e-01f, 1.59528434e-01f, 4.96910661e-01f, -5.59685268e-02f, -1.52490392e-01f,
  4.41571295e-01f, -3.29452753e-02f, 3.80799443e-01f, 3.33356798e-01f, -5.07427931e-01f, 6.46869779e-01f, -6.23453438e-01f, -2.55507797e-01f, -2.71746606e-01f, -8.91110301e-02f,
  -2.54390687e-01f, 3.02521795e-01f, 2.27794752e-01f, -5.25635898e-01f, -4.63739872e-01f, 3.62390690e-02f, 3.61525989e-03f, -4.70448524e-01f, -3.18225776e-03f, -4.06724602e-01f,
  -2.40966119e-02f, 2.46423092e-02f, 2.24297851e-01f, 4.07510698e-02f, 1.15297511e-01f, 2.68822163e-01f, -1.43913805e-01f, 1.33932367e-01f, -4.33420986e-02f, 2.76106179e-01f,
  -6.21643886e-02f, 2.24514380e-01f, -3.54382515e-01f, -5.19060016e-01f, 3.78207825e-02f, -3.66874456e-01f, -4.40506190e-01f, -2.47724891e-01f, 3.49986047e-01f, -1.79276660e-01f,
  3.64507586e-01f, 9.83024132e-04f, -3.35003287e-01f, -3.41177613e-01f, -2.83878505e-01f, 4.79037791e-01f, -4.71636176e-01f, -1.70346111e-01f, -1.35007560e-01f, -1.01372391e-01f,
  6.95527971e-01f, -2.50674546e-01f, -6.98984921e-01f, 3.23789418e-01f, -2.09264434e-03f, -2.38733277e-01f, -2.35729173e-01f, -5.67774832e-01f, -3.61289650e-01f, 1.19949572e-01f,
  3.86959881e-01f, -2.24149436e-01f, 1.21470757e-01f, 7.07197368e-01f, -2.86001533e-01f, 4.08550978e-01f, -3.56562972e-01f, -4.63259548e-01f, -3.48867625e-01f, -1.96083769e-01f,
  -2.49207646e-01f, -1.24699853e-01f, 3.35638583e-01f, -2.41004378e-01f, -3.49527836e-01f, -4.36475039e-01f, -3.79323959e-01f, -1.17092915e-01f, 5.19331634e-01f, 3.41323823e-01f,
  -3.44834387e-01f, -5.38610101e-01f, -3.53741467e-01f, 2.22539395e-01f, -6.49478212e-02f, 1.76181749e-01f, 1.40982820e-02f, -2.01969757e-03f, 1.64513543e-01f, -7.74464197e-03f,
  1.95484698e-01f, -4.55191359e-02f, -3.63796540e-02f, 1.33480327e-02f, 1.11534540e-02f, 2.91824192e-01f, 3.90291840e-01f, -4.64255661e-02f, 3.40952456e-01f, 2.60572910e-01f,
  -3.04833978e-01f, 3.25586051e-01f, 1.74141601e-01f, -3.21770519e-01f, 4.48597878e-01f, 1.28829479e-01f, 1.56966206e-02f, 8.56673494e-02f, 2.24564984e-01f, -3.41827840e-01f,
  -2.66067475e-01f, -3.20686519e-01f, 3.51956278e-01f, 4.62671757e-01f, 7.65531063e-02f, -5.23366213e-01f, -2.69856960e-01f, -1.91252276e-01f, -2.64140338e-01f, -3.01079810e-01f,
  -3.33611459e-01f, -2.18543336e-01f, 4.42183912e-01f, -4.15472955e-01f, 1.01551652e-01f, -2.95182317e-01f, 1.59811273e-01f, -3.36820304e-01f, -2.40629941e-01f, -2.08779052e-01f,
  -3.77312720e-01f, 2.45707855e-02f, -1.52640238e-01f, -4.02917564e-02f, -1.82799682e-01f, -4.24380638e-02f, 5.48890293e-01f, -3.45340580e-01f, 5.29560685e-01f, -2.49436691e-01f,
  -3.68851572e-01f, 5.03944814e-01f, -2.67001778e-01f, -2.96022922e-01f, -2.40797669e-01f, 7.57314026e-01f, 1.63401783e-01f, -4.77098793e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.18088941e-02f, -4.04718854e-02f, -1.17332906e-01f, -7.64062554e-02f, 1.26055941e-01f, 1.21408962e-01f, 5.88228852e-02f, -1.34263888e-01f, 1.82279721e-02f, 2.70151328e-02f,
  9.65559930e-02f, 4.52283509e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    