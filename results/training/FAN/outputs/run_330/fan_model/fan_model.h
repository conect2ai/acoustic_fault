/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.85840423e-02f, 3.21582109e-02f, -7.44785517e-02f, 1.52835518e-01f, 8.47159419e-03f, 6.79926500e-02f, 3.45712975e-02f, 9.71177071e-02f, 2.10519537e-01f, 1.27749577e-01f,
  9.59418863e-02f, 1.73543077e-02f, -1.32731751e-01f, 2.06762955e-01f, -4.12052423e-02f, -3.79485562e-02f, 1.35306895e-01f, 1.32108200e-02f, 1.18662022e-01f, -5.29481135e-02f,
  4.21621874e-02f, 1.69386536e-01f, -1.03265904e-01f, 8.43480304e-02f, 2.41240803e-02f, 2.77919006e-02f, -7.10945055e-02f, -7.63696954e-02f, 5.38664311e-02f, 1.05259880e-01f,
  -3.22145745e-02f, -5.18515632e-02f, -5.32205999e-02f, -4.70022447e-02f, -8.43524784e-02f, -2.82544941e-02f, -1.48173515e-02f, 6.52226135e-02f, -3.59214842e-02f, -1.21002523e-02f,
  -7.33747184e-02f, -6.88850731e-02f, 7.54534826e-02f, -5.14810942e-02f, -1.12973573e-02f, -1.66527033e-02f, -1.25281392e-02f, -4.43272628e-02f, 3.25653031e-02f, -4.69727628e-02f,
  -3.49409841e-02f, 6.82864524e-03f, -1.97126791e-02f, -5.19052707e-02f, 1.86116565e-02f, -1.61439274e-02f, -2.37068031e-02f, -3.99624370e-02f, 6.76418617e-02f, 1.85191259e-02f,
  5.29267192e-02f, -4.09427136e-02f, -3.84514369e-02f, 1.89064462e-02f, -2.61770766e-02f, 4.60249372e-02f, 1.15286320e-01f, 2.18265858e-02f, 1.42150298e-02f, 5.93939684e-02f,
  1.19562428e-02f, 2.05498040e-02f, 5.60254836e-03f, 8.27737711e-03f, 8.19168240e-02f, -3.09651978e-02f, -5.94874611e-03f, 4.89606895e-02f, 4.83213514e-02f, -1.48633430e-02f,
  3.19411308e-02f, 5.60498498e-02f, -4.63337591e-03f, 4.40200269e-02f, 2.46588178e-02f, 2.55370792e-02f, 8.95455107e-02f, 6.04050681e-02f, 2.62913704e-02f, 2.45835669e-02f,
  1.36308610e-01f, 1.50566906e-01f, 1.03656791e-01f, 1.44021250e-02f, 1.65703502e-02f, -9.03841108e-02f, -2.55597923e-02f, -5.79100847e-02f, 5.88329732e-02f, -4.89755673e-03f,
  -4.28268164e-02f, -2.00098567e-02f, 3.11862566e-02f, -4.00065035e-02f, 7.88881853e-02f, 1.31697029e-01f, -2.61027459e-03f, 5.05800657e-02f, 5.04633747e-02f, 1.78704560e-02f,
  -8.49236995e-02f, 4.95570824e-02f, -7.34427646e-02f, 5.16684614e-02f, -5.33015318e-02f, 2.73780897e-02f, -3.32144648e-02f, -3.55249755e-02f, 3.99093740e-02f, 4.07423126e-03f,
  8.56099948e-02f, -2.17017438e-02f, -1.17901221e-01f, -4.23041210e-02f, -3.04316096e-02f, 2.31454432e-01f, 1.98564827e-01f, -9.44648385e-02f, -4.62999269e-02f, -6.69345707e-02f,
  1.22878477e-02f, -3.86555269e-02f, -2.58431397e-02f, 1.97499424e-01f, 2.43156329e-01f, 1.32106349e-01f, 1.15080409e-01f, 6.37805983e-02f, 7.25213960e-02f, -1.72854699e-02f,
  4.27038744e-02f, 1.08898908e-01f, 7.17787519e-02f, -4.97286720e-03f, -7.96432123e-02f, -1.20219983e-01f, -9.91192386e-02f, -3.98284234e-02f, -3.49639468e-02f, 9.75915194e-02f,
  9.08201188e-03f, -1.09450229e-01f, -8.30762237e-02f, 2.36679125e-03f, -1.26883015e-02f, 4.96661365e-02f, 6.22082576e-02f, 8.13210607e-02f, -5.84013052e-02f, -7.35091791e-02f,
  3.91010419e-02f, 9.69245210e-02f, 9.33966786e-02f, 5.04804812e-02f, -3.74553632e-03f, -8.31222087e-02f, -7.30236173e-02f, -6.98301271e-02f, -3.12005114e-02f, 5.45720309e-02f,
  1.09051047e-02f, 4.36236560e-02f, -6.64662868e-02f, 5.66192158e-03f, -4.45831940e-02f, 3.18451710e-02f, 1.00243855e-02f, 2.76003797e-02f, -2.07921714e-02f, -4.91407467e-03f,
  3.65569652e-03f, -9.53692049e-02f, -1.83451492e-02f, -9.23582092e-02f, 9.82026942e-03f, -3.86862382e-02f, 1.16353761e-02f, 7.09431525e-03f, -5.93480058e-02f, 6.28949553e-02f,
  1.85975265e-02f, 2.07688157e-02f, 4.21859659e-02f, 6.58382326e-02f, -4.12145816e-02f, -7.89295807e-02f, 1.21671017e-02f, -4.74393833e-03f, 1.27906147e-02f, -4.50383686e-02f,
  1.40667753e-02f, 2.88421270e-02f, -4.95317280e-02f, 6.15268946e-03f, 7.18652606e-02f, 6.55424818e-02f, 2.55906824e-02f, 1.41159799e-02f, -7.91037604e-02f, 6.63000569e-02f,
  -1.00201756e-01f, -1.80972338e-01f, -4.38762307e-02f, 2.17114482e-02f, 3.05486824e-02f, 7.33611546e-03f, -4.68691997e-02f, -2.46119630e-02f, -2.12231893e-02f, 3.72614712e-02f,
  -8.67204666e-02f, -4.09924351e-02f, -1.50688868e-02f, 4.13890108e-02f, 3.25100645e-02f, 3.61398011e-02f, -1.33611811e-02f, -1.92772988e-02f, -3.54917347e-02f, 1.84846297e-03f,
  2.35893205e-03f, -9.82808974e-03f, 2.38499157e-02f, -7.58526251e-02f, 6.38271272e-02f, -5.42462729e-02f, -6.93301633e-02f, -6.00834936e-02f, 6.15860410e-02f, 9.69128963e-03f,
  1.53278813e-01f, -1.14337079e-01f, 1.31553679e-03f, 4.23192419e-03f, -9.23618749e-02f, -2.01929286e-01f, -2.15186879e-01f, 2.16618087e-02f, -2.20432714e-01f, -1.19044334e-01f,
  -4.31502052e-02f, -9.09942538e-02f, -2.21265659e-01f, -4.07353155e-02f, -5.78362830e-02f, -2.59033620e-01f, 3.35750217e-03f, -1.31304124e-02f, -2.59323511e-02f, -1.68072507e-02f,
  9.06512737e-02f, 6.06972203e-02f, 9.96294320e-02f, 2.00815618e-01f, 9.27806571e-02f, 1.92506686e-01f, 2.19099596e-01f, 4.90016825e-02f, 1.83369204e-01f, 8.37863162e-02f,
  -1.22283503e-01f, -1.06474243e-01f, 2.73752511e-02f, -2.08223015e-02f, 1.84881873e-02f, 3.84653434e-02f, 7.93006420e-02f, 4.75588329e-02f, 6.00620322e-02f, -2.04182863e-02f,
  3.85006629e-02f, 4.22500297e-02f, 6.85457066e-02f, 1.57763157e-02f, 8.25380981e-02f, -5.19010462e-02f, 2.60654334e-02f, -7.57043995e-03f, -8.99362117e-02f, 2.24020274e-04f,
  -1.26641214e-01f, 3.67304012e-02f, 1.77598223e-02f, 9.48984874e-04f, -1.04867732e-02f, -3.90173607e-02f, 2.54637264e-02f, -6.74856156e-02f, -1.20442897e-01f, -2.64631808e-02f,
  8.98632687e-03f, 1.98660865e-02f, 3.81194875e-02f, 2.95762476e-02f, 2.10436583e-02f, -3.53320092e-02f, -6.16632588e-02f, 2.95558628e-02f, 1.13002444e-02f, -5.78341223e-02f,
  -4.12292108e-02f, -4.04767357e-02f, -4.72130924e-02f, -5.72141781e-02f, -4.90089878e-02f, -7.21857026e-02f, 1.62192583e-02f, 8.90589040e-03f, -2.62356419e-02f, -7.43419528e-02f,
  -8.97232741e-02f, 5.48079312e-02f, -4.92897769e-03f, 3.65874432e-02f, -5.36404029e-02f, 3.39373350e-02f, 6.81388052e-03f, 1.91363841e-02f, -5.17968461e-03f, -3.70113575e-03f,
  -1.19984867e-02f, 3.60649079e-02f, -4.46943715e-02f, 2.22076215e-02f, -6.91223964e-02f, -1.07930209e-02f, -2.28547379e-02f, -3.97394672e-02f, 2.26500677e-03f, 2.65086424e-02f,
  6.73559755e-02f, 2.08306089e-02f, -2.53678244e-02f, -3.17939185e-02f, -4.16020826e-02f, 3.28889228e-02f, -2.47377399e-02f, 2.66037118e-02f, -2.58122720e-02f, 2.07682997e-02f,
  5.18630147e-02f, -1.30876368e-02f, 6.72792224e-03f, 2.87647936e-02f, -1.57485455e-02f, 7.55341072e-03f, 2.68915799e-02f, 5.99171333e-02f, 4.20737192e-02f, -1.00766599e-01f,
  5.84424473e-02f, -8.01183805e-02f, -8.66764039e-02f, 8.10465068e-02f, 4.77053691e-05f, -9.14275646e-02f, -7.24077970e-02f, -4.87178899e-02f, -3.70194130e-02f, 2.73322985e-02f,
  3.71578373e-02f, -5.50142564e-02f, -5.89150824e-02f, -1.20062456e-02f, 1.24424044e-02f, 5.61359487e-02f, -6.92979768e-02f, -7.21165612e-02f, -1.02637894e-02f, 2.56251562e-02f,
  -7.45991543e-02f, 4.09653261e-02f, 5.47973961e-02f, -3.05688269e-02f, -5.17321303e-02f, 5.59847280e-02f, -7.84090459e-02f, 7.60273188e-02f, 3.17955315e-02f, -1.02206036e-01f,
  1.40665069e-01f, 2.30939351e-02f, 1.01669155e-01f, -1.76543836e-02f, -5.29024340e-02f, -8.25478062e-02f, -3.36607592e-03f, 3.33838575e-02f, -3.75402789e-03f, 3.65397036e-02f,
  -2.29852069e-02f, 4.56507169e-02f, -1.19092479e-01f, 2.94577070e-02f, -6.30357070e-03f, -6.87881634e-02f, 6.65198714e-02f, 7.16830492e-02f, -3.10188881e-03f, -2.06751283e-02f,
  -5.81852272e-02f, 6.51202798e-02f, -5.91353029e-02f, -8.39543194e-02f, -6.75588101e-02f, 1.55591993e-02f, 2.85923444e-02f, -3.38169490e-03f, -4.33584191e-02f, -1.31861481e-03f,
  -2.09688935e-02f, 8.00145194e-02f, -9.07733804e-04f, 6.14724159e-02f, -3.15844268e-03f, 8.83024633e-02f, 5.99956438e-02f, -1.33244228e-02f, 2.02269703e-02f, 1.60585120e-02f,
  9.10720453e-02f, -1.31769385e-02f, -3.87680903e-02f, 5.66069409e-02f, 5.03857210e-02f, 2.30097696e-02f, 1.48711987e-02f, -2.25695148e-02f, 6.84575066e-02f, 1.75714493e-02f,
  -5.23351543e-02f, 2.48059183e-02f, 4.24326137e-02f, -3.60676460e-02f, -8.44989903e-03f, -9.32122245e-02f, -2.35262811e-02f, 6.39949590e-02f, 6.42640591e-02f, 4.30954099e-02f,
  5.96745014e-02f, 5.40071018e-02f, 2.39495095e-02f, -6.22467473e-02f, 1.02801278e-01f, 5.84944561e-02f, -1.57945361e-02f, -4.02629822e-02f, 2.15656143e-02f, -2.88789328e-02f,
  -4.48820218e-02f, 6.33616373e-02f, -5.21793682e-03f, -7.53650889e-02f, -1.02672562e-01f, -6.34944960e-02f, 3.99811044e-02f, -6.96427152e-02f, -2.80997693e-03f, -2.36456487e-02f,
  4.72462811e-02f, -2.11270293e-03f, 6.30720407e-02f, 3.13404165e-02f, -6.29136190e-02f, -3.85909602e-02f, 6.65456802e-02f, 5.73990196e-02f, -2.66570188e-02f, 1.20459292e-02f,
  1.50451690e-01f, -6.97326735e-02f, -1.37267439e-02f, 1.24206513e-01f, -8.59667882e-02f, -1.88724071e-01f, -1.44804284e-01f, 3.65299508e-02f, 9.63673964e-02f, -1.55306429e-01f,
  1.42104179e-01f, 1.49821397e-02f, 8.68340372e-04f, 1.42785847e-01f, 2.53608674e-01f, 1.73286572e-02f, 1.91664398e-01f, 1.76513605e-02f, 4.68076579e-02f, 8.42185598e-03f,
  1.58946350e-01f, 9.46645811e-02f, 7.82012194e-02f, -4.19092830e-03f, -3.80104943e-03f, -3.89920399e-02f, 2.81435177e-02f, -1.01574093e-01f, 6.38940707e-02f, 1.94913484e-02f,
  -6.39334647e-03f, 5.59896268e-02f, 6.73665628e-02f, 2.55085975e-02f, -9.28746983e-02f, 6.11818908e-03f, -2.28649490e-02f, 1.08187214e-01f, 9.11863372e-02f, -1.48048038e-02f,
  6.86984509e-03f, -5.24480492e-02f, -3.40269059e-02f, -6.45824522e-02f, -1.45788221e-02f, 3.84605303e-02f, 2.07048021e-02f, -8.66575539e-02f, -2.69699581e-02f, 2.37146355e-02f,
  -3.41825932e-02f, -6.55365512e-02f, 1.64698176e-02f, 5.49712591e-03f, 7.87905455e-02f, 4.47467007e-02f, -1.09808333e-01f, -3.53244655e-02f, -4.16931398e-02f, 3.63798104e-02f,
  7.62057817e-03f, -2.67494582e-02f, 5.80370724e-02f, 9.07660369e-03f, 3.12642716e-02f, -4.53292504e-02f, 4.96924063e-03f, 6.81691663e-03f, -7.79968407e-03f, 1.42961638e-02f,
  -2.91755274e-02f, 3.07239871e-02f, -6.85225800e-02f, -2.57037431e-02f, 4.09592092e-02f, -1.16256659e-03f, -1.42307505e-02f, -1.20706402e-03f, 5.19199818e-02f, 4.59642224e-02f,
  -5.43034673e-02f, -6.64023012e-02f, 7.42756873e-02f, -4.86122295e-02f, 3.39519698e-03f, 1.40345097e-02f, -1.86187308e-02f, 8.78702179e-02f, 1.68932751e-02f, -5.40355500e-03f,
  1.29412301e-02f, -1.93737680e-04f, 6.29557148e-02f, -5.17949499e-02f, -1.68941077e-02f, -4.69620228e-02f, -1.19483575e-01f, -1.63313877e-02f, 2.29769275e-02f, 7.99459929e-04f,
  -7.20785484e-02f, -5.07679246e-02f, -1.09320767e-01f, 1.20431781e-02f, 4.68157008e-02f, 2.39509847e-02f, 9.16288197e-02f, -2.67527308e-02f, -5.79774491e-02f, 6.91635534e-02f,
  -5.43662235e-02f, -3.53974178e-02f, -5.48351258e-02f, 1.46323803e-03f, -3.69323827e-02f, -2.93157995e-02f, -7.96180665e-02f, 3.41513716e-02f, 1.10772196e-02f, -2.50873957e-02f,
  1.59196094e-01f, -1.69604003e-01f, 5.43941893e-02f, 6.02671914e-02f, 1.48775473e-01f, 1.83326036e-01f, 1.26928657e-01f, -1.54175218e-02f, 5.50095364e-02f, -1.64984480e-01f,
  -7.34490529e-02f, 6.86627179e-02f, -1.70796216e-01f, 1.72544904e-02f, 1.47747934e-01f, 8.21630191e-03f, 4.02623191e-02f, 4.22028825e-02f, 6.67893440e-02f, -6.80842623e-02f,
  -1.18817464e-02f, -1.14529692e-01f, -4.26365063e-02f, -1.26970708e-01f, 3.47491838e-02f, -4.16168682e-02f, -1.32255912e-01f, -8.58917236e-02f, -3.52697000e-02f, 4.75560687e-02f,
  1.17249653e-01f, 2.29046699e-02f, 9.93207656e-03f, 1.43943047e-02f, -7.54727349e-02f, -7.96898305e-02f, -2.65922993e-02f, -8.18512402e-03f, 4.94939052e-02f, 3.85371372e-02f,
  -1.30416583e-02f, -1.25583904e-02f, 1.02280065e-01f, 8.47068503e-02f, 3.40412110e-02f, 1.06332332e-01f, -7.86363799e-03f, 3.01914997e-02f, -6.13945946e-02f, -1.82551797e-02f,
  -4.67930585e-02f, 3.28607038e-02f, 6.33291677e-02f, -8.28341022e-03f, -2.81051733e-02f, 6.81438372e-02f, 3.09839677e-02f, 3.66681605e-03f, 1.21004423e-02f, 5.15453666e-02f,
  -4.12721187e-02f, 5.14732152e-02f, 2.12309472e-02f, 4.86385226e-02f, 9.48151224e-04f, 1.08032271e-01f, 1.63044548e-04f, -3.09123099e-02f, 1.36572057e-02f, -2.66642496e-02f,
  -6.46890625e-02f, 4.74457480e-02f, 2.68271118e-02f, -2.28261128e-02f, 6.04033936e-03f, 7.12561682e-02f, 4.74368269e-03f, 6.94299266e-02f, -5.16419634e-02f, 4.09140177e-02f,
  -1.10404808e-02f, 6.40017465e-02f, 2.25227065e-02f, 3.06182504e-02f, 2.81183086e-02f, -5.84731810e-03f, -3.85165401e-02f, 3.64069976e-02f, 6.21578097e-02f, -7.20594823e-03f,
  -1.40755698e-01f, -2.46966437e-01f, 1.80589836e-02f, 4.27014008e-02f, 1.60091538e-02f, -3.56676173e-05f, 1.79314297e-02f, 9.20188904e-04f, -1.10565059e-01f, 5.86675107e-03f,
  -1.33719994e-03f, 2.85057966e-02f, -2.17262339e-02f, -4.63064760e-02f, -1.74745172e-02f, -6.38456270e-02f, -4.83479612e-02f, -1.12901561e-01f, -9.02122259e-03f, -6.58474863e-02f,
  -3.95731889e-02f, -4.81974706e-02f, 1.19142942e-02f, -6.45291209e-02f, -8.07101205e-02f, -4.65062484e-02f, -1.26711875e-02f, -1.08249541e-02f, 6.21874677e-03f, -3.05442065e-02f,
  -2.53563792e-01f, 1.10624835e-01f, 1.27397418e-01f, -1.45876810e-01f, -5.58022894e-02f, -6.73672929e-02f, 2.59597711e-02f, 3.22221220e-02f, 9.70179308e-03f, 3.41776479e-03f,
  -1.09526798e-01f, -1.33401873e-02f, -8.27455595e-02f, -1.26616299e-01f, -1.23477057e-01f, -2.48866007e-02f, -1.11371405e-01f, -1.27078238e-04f, 3.51487733e-02f, 2.75820326e-02f,
  5.89335784e-02f, -1.88311599e-02f, -2.06689816e-02f, -1.20388046e-02f, -1.18699595e-01f, -1.05164815e-02f, 9.16110724e-02f, 1.11668138e-02f, -9.76267923e-03f, -2.70519592e-02f,
  -6.91464692e-02f, -1.32176086e-01f, 9.29360539e-02f, 7.21753463e-02f, -2.18439251e-02f, 2.09581945e-02f, -2.51277182e-02f, 2.71659084e-02f, -1.13813905e-02f, 2.22195033e-03f,
  -6.09004013e-02f, 6.42699301e-02f, 1.14580393e-02f, 2.52725892e-02f, 1.20966062e-02f, 3.48027833e-02f, 2.94962600e-02f, -3.53639461e-02f, 5.58668077e-02f, 7.76239252e-03f,
  -9.34182666e-03f, -3.41810584e-02f, 3.69585641e-02f, -3.55149284e-02f, 3.49627808e-02f, 1.00311093e-01f, -1.66967101e-02f, -3.13965343e-02f, -9.91765559e-02f, 7.22610950e-02f,
  -7.36970603e-02f, 2.79304525e-03f, -1.19083072e-03f, -5.73152211e-03f, -2.24709976e-02f, 6.04010187e-03f, 1.70790982e-02f, 2.17991564e-02f, 1.58271790e-02f, -1.75364818e-02f,
  -5.22539914e-02f, -5.03161512e-02f, 2.59506213e-03f, 2.37486158e-02f, 5.79034016e-02f, -2.44547948e-02f, -9.57624465e-02f, -1.29357437e-02f, 6.73261844e-03f, 1.16280228e-01f,
  8.51981342e-03f, 1.23038545e-01f, 4.61401744e-03f, -6.93345964e-02f, -1.20276411e-03f, -4.76379842e-02f, 7.69477412e-02f, 3.05260066e-02f, 4.53144573e-02f, -3.06908321e-02f,
  -1.02781370e-01f, -1.86906263e-01f, -5.85671477e-02f, -1.85598079e-02f, -1.75303537e-02f, -6.77788118e-03f, 1.51816232e-03f, -1.85863487e-02f, 1.53678926e-02f, -3.23987119e-02f,
  4.30076495e-02f, -2.96569988e-02f, 3.21389060e-03f, -5.15846768e-03f, -2.90765632e-02f, 2.43558027e-02f, 6.98501468e-02f, 2.14399491e-02f, 1.94462016e-02f, -3.79048884e-02f,
  5.11629172e-02f, 1.27251958e-02f, 1.92698631e-02f, -1.06801033e-01f, -4.18180414e-02f, 7.24082161e-03f, -3.20505425e-02f, -8.14785510e-02f, -4.25025597e-02f, 9.81178693e-03f,
  -2.20182016e-01f, 1.35975555e-01f, -2.44514197e-01f, -1.38077095e-01f, -7.51512730e-03f, -2.74548549e-02f, -3.13993916e-02f, -8.08677226e-02f, -7.55829513e-02f, -1.00313552e-01f,
  6.27294406e-02f, -1.00586504e-01f, 1.56487748e-01f, 1.04625434e-01f, 8.65922589e-03f, 1.48624659e-01f, 1.17573859e-02f, -3.19417156e-02f, 1.16081163e-01f, -9.43081751e-02f,
  8.30901265e-02f, 1.16375409e-01f, 7.05136806e-02f, 7.55412355e-02f, 7.00893998e-02f, -6.46942854e-02f, -3.88318226e-02f, 2.40373269e-01f, -5.33038378e-02f, 1.13221645e-01f,
  -1.93676334e-02f, -1.07205734e-01f, -1.29730910e-01f, -3.49563695e-02f, -5.29142506e-02f, -5.07353134e-02f, 2.42243055e-02f, 1.10032335e-01f, 5.16471453e-02f, 3.68690118e-02f,
  -3.13669331e-02f, -7.17551410e-02f, -1.04711633e-02f, 7.65867680e-02f, 7.97111169e-03f, -3.64023112e-02f, 3.46028456e-03f, -9.65573173e-03f, 2.22728821e-03f, 4.14191969e-02f,
  -8.23328644e-02f, -2.54241768e-02f, -1.18909188e-01f, 3.15267034e-02f, -1.00632748e-02f, -2.62797642e-02f, -8.91956873e-03f, -8.45165029e-02f, -2.05427781e-02f, -1.18757105e-02f,
  9.02633816e-02f, -1.66865140e-02f, -2.64816005e-02f, -3.43287066e-02f, -7.11350963e-02f, 7.72794895e-03f, -1.72176561e-03f, -6.64895177e-02f, 1.64582208e-02f, 4.55532502e-03f,
  2.23128088e-02f, -6.13704659e-02f, -4.66754958e-02f, -2.98757828e-03f, 6.13968037e-02f, 5.61506450e-02f, 1.56715009e-02f, -7.80974478e-02f, 1.67184733e-02f, 8.34774226e-03f,
  -6.36763945e-02f, -6.54335767e-02f, -7.07219988e-02f, 8.35548807e-03f, -5.52071109e-02f, 3.55266854e-02f, -7.03637749e-02f, -3.48770134e-02f, 8.54422152e-02f, 1.20374123e-02f,
  4.10630256e-02f, -6.32497445e-02f, 1.33718133e-01f, -9.74869728e-03f, -5.59379943e-02f, 3.75998951e-02f, 5.40578645e-03f, 2.36070110e-03f, 7.54764825e-02f, 3.85264196e-02f,
  5.26885837e-02f, 2.94685792e-02f, 1.54521596e-02f, -5.93532659e-02f, -6.49413243e-02f, 2.82774568e-02f, 2.36897115e-02f, 2.97635179e-02f, -3.56767960e-02f, -5.39069399e-02f,
  -1.71397962e-02f, 1.78935155e-02f, 2.63226181e-02f, -1.18792066e-02f, 3.02284118e-02f, 3.88992112e-03f, -8.22172835e-02f, 9.06298012e-02f, 6.09400570e-02f, 5.37510030e-02f,
  1.22009769e-01f, -4.70041893e-02f, 1.19743086e-01f, -8.19826871e-02f, -5.32392971e-02f, 1.35509282e-01f, 1.23141065e-01f, -5.39782383e-02f, 2.10890010e-01f, -1.35335878e-01f,
  -1.15647763e-01f, 8.75975937e-02f, -1.28896988e-03f, 7.26227015e-02f, 8.77035856e-02f, 8.11677650e-02f, 1.06738405e-02f, -6.91955313e-02f, 9.25982520e-02f, -1.33294985e-02f,
  1.91463507e-03f, 6.48206449e-04f, 7.55062848e-02f, -1.96849421e-01f, -5.65368272e-02f, -5.67629077e-02f, -2.10905403e-01f, -4.75053638e-02f, -5.33051267e-02f, -1.42372474e-02f,
  1.24267146e-01f, 5.34209311e-02f, 2.92372927e-02f, -3.33198011e-02f, 4.15095408e-03f, -4.22693975e-02f, -9.54371504e-03f, 5.54500474e-03f, 2.16881279e-02f, 5.89354187e-02f,
  -5.38439006e-02f, 7.19171315e-02f, -5.23698665e-02f, 2.98819561e-02f, -2.35940665e-02f, -1.17675355e-02f, 9.48515311e-02f, 2.26660874e-02f, 4.53272387e-02f, 5.66265138e-04f,
  2.63297725e-02f, 7.57852802e-03f, -4.01130207e-02f, -7.29430690e-02f, 7.38881454e-02f, 6.16786852e-02f, 8.80404115e-02f, -6.67461753e-02f, -5.80065586e-02f, 4.38993797e-02f,
  -6.98175952e-02f, -8.76719970e-03f, 4.29651365e-02f, 3.43054235e-02f, -1.88136622e-02f, -1.48632014e-02f, 3.71159576e-02f, -9.38688591e-03f, -2.23123245e-02f, 8.55444558e-03f,
  -7.37521350e-02f, -3.07830498e-02f, 1.46184303e-02f, -6.08961619e-02f, -2.93185953e-02f, 6.64897263e-02f, -6.08818904e-02f, -1.07611660e-02f, -3.88631597e-02f, -1.00815007e-02f,
  -5.71178347e-02f, 5.67544997e-02f, 5.43174967e-02f, -5.28032221e-02f, -9.53750834e-02f, -6.66165398e-03f, 1.48641123e-02f, 9.10862684e-02f, 4.53508925e-03f, -2.71656252e-02f,
  -5.87136187e-02f, -1.72123417e-01f, -3.17905769e-02f, -8.07523821e-03f, -9.35936794e-02f, 7.23978796e-04f, 5.08076698e-02f, -7.25452602e-02f, 3.49247232e-02f, -3.39581631e-02f,
  -3.38998698e-02f, -1.18345059e-02f, 1.59870908e-02f, 5.93565684e-03f, 8.45970884e-02f, -8.10759515e-02f, -2.86676064e-02f, -2.44198851e-02f, -7.19512776e-02f, -7.79425949e-02f,
  -3.06138359e-02f, -2.73017678e-02f, 8.95626470e-03f, 2.35257521e-02f, -6.96876720e-02f, 2.70224530e-02f, 1.41966594e-02f, 3.41550969e-02f, -2.24942565e-02f, 3.60125341e-02f,
  -2.01428249e-01f, 2.99950428e-02f, -3.06777805e-01f, 3.77566367e-02f, -4.90248688e-02f, 1.13800503e-01f, 8.20310414e-02f, -4.26823981e-02f, -9.17426944e-02f, 1.06494516e-01f,
  -3.53920870e-02f, -6.02463558e-02f, 2.22149678e-02f, -7.82222152e-02f, 2.72316001e-02f, 5.27368523e-02f, 4.40406054e-02f, -5.76785319e-02f, -5.45954816e-02f, -5.29280864e-02f,
  1.28835738e-02f, 6.02407977e-02f, -1.24905892e-01f, 4.85008992e-02f, -4.31881584e-02f, -6.01303391e-02f, 3.11798304e-02f, -2.77488213e-02f, 4.54483442e-02f, -1.67280505e-03f,
  9.04925093e-02f, -7.08838403e-02f, -1.94273554e-02f, 3.87789011e-02f, -5.80581240e-02f, 2.90505327e-02f, -1.99332330e-02f, -5.75707965e-02f, -6.00472465e-02f, -2.20999885e-02f,
  4.56079841e-02f, -5.83695211e-02f, -2.97435676e-03f, -2.53429916e-02f, 1.79321337e-02f, -7.21312985e-02f, 1.09248664e-02f, -3.70326713e-02f, -8.76968801e-02f, -7.65774995e-02f,
  -8.74324441e-02f, -4.88835312e-02f, -2.56854631e-02f, 6.38719872e-02f, -8.96027759e-02f, -2.34452561e-02f, 4.11850400e-02f, 2.98373848e-02f, 4.26826924e-02f, 5.81204519e-02f,
  -3.96749005e-02f, -4.79881972e-04f, 1.35240760e-02f, -4.30083387e-02f, 2.57485379e-02f, -2.99596414e-02f, 4.42920439e-02f, 7.04009980e-02f, 2.61089858e-02f, 1.35414852e-02f,
  2.29602307e-02f, 5.26074059e-02f, 6.30733073e-02f, 5.72811300e-03f, -4.08593491e-02f, -1.16154468e-02f, -8.00827816e-02f, 2.03899909e-02f, -2.06405781e-02f, -3.44575606e-02f,
  -7.61220828e-02f, 1.38343787e-02f, 6.86756968e-02f, -1.03594903e-02f, 1.64251607e-02f, -3.33362445e-02f, -9.51839760e-02f, 7.86272585e-02f, -7.40029961e-02f, 5.97958043e-02f,
  2.66859084e-01f, 1.68901742e-01f, 1.51593005e-03f, 3.09299156e-02f, 1.04482800e-01f, -4.47603948e-02f, 5.62065952e-02f, -3.98997739e-02f, 4.40836474e-02f, -6.30364344e-02f,
  -6.70407563e-02f, 7.42100403e-02f, -2.63478309e-02f, -2.09497996e-02f, 6.72205910e-02f, -1.24172177e-02f, 5.83547205e-02f, -2.29547862e-02f, -3.51437889e-02f, 3.08743082e-02f,
  3.04122834e-04f, 9.05434117e-02f, 2.92660929e-02f, 4.72207367e-02f, 6.16830438e-02f, 2.25240756e-02f, -2.28882357e-02f, 3.73414420e-02f, 5.98350093e-02f, -5.39643830e-03f,
  -1.29730791e-01f, 6.33606911e-02f, -2.66918410e-02f, -6.18904866e-02f, 1.07442187e-02f, -1.63852602e-01f, -1.02543302e-01f, -1.05039179e-01f, 3.22456099e-02f, 7.77772143e-02f,
  1.28736317e-01f, 1.66346580e-02f, 5.77455349e-02f, 1.16066180e-01f, -9.62589979e-02f, -8.20290670e-02f, -6.09271675e-02f, 1.21153645e-01f, -3.33469957e-02f, -3.93475406e-02f,
  -1.15840435e-01f, -8.96293968e-02f, -9.84350443e-02f, -9.72403493e-03f, 4.93176281e-02f, -4.04589325e-02f, 7.66573027e-02f, 4.67967317e-02f, 7.32649537e-03f, -7.93906581e-03f,
  4.36229035e-02f, 7.05564916e-02f, -4.50346507e-02f, -5.64139597e-02f, -7.70816021e-03f, 4.21235897e-02f, -5.76441586e-02f, -3.49472836e-02f, 4.19781767e-02f, -4.14546393e-02f,
  6.35948107e-02f, 7.22707286e-02f, 6.60737753e-02f, 2.07695533e-02f, -5.18708304e-02f, 3.53332050e-02f, -6.77316636e-02f, -2.29998417e-02f, -6.68805540e-02f, 6.20007254e-02f,
  -4.56295088e-02f, 3.24597992e-02f, -1.86570513e-03f, -1.16763031e-02f, -4.78691310e-02f, -1.07093053e-02f, -2.64817327e-02f, -1.12853404e-02f, -5.64212836e-02f, 4.10229415e-02f,
  -8.83786231e-02f, 2.07043048e-02f, 3.65449898e-02f, 3.24621461e-02f, -8.50992836e-03f, 6.87402338e-02f, 4.88178758e-03f, 4.49294038e-02f, 4.75612879e-02f, -1.56746935e-02f,
  2.06802459e-03f, 8.37710202e-02f, -1.63670182e-02f, 3.68055701e-02f, 1.62285771e-02f, 5.29038981e-02f, -8.16208078e-04f, 1.03958875e-01f, -7.03528821e-02f, 5.70454076e-03f,
  3.91403250e-02f, 5.89510351e-02f, -1.48713086e-02f, 5.94502278e-02f, 1.95493791e-02f, 6.67251274e-02f, -3.50562520e-02f, 8.46889541e-02f, -6.08148724e-02f, -4.71318662e-02f,
  1.24533974e-01f, 8.13700110e-02f, -4.40227725e-02f, 4.93122488e-02f, 4.21721041e-02f, 4.19909805e-02f, -5.09648137e-02f, -3.06237908e-03f, 1.65064596e-02f, -3.13156955e-02f,
  -2.60696299e-02f, -7.20215738e-02f, 3.21588367e-02f, -4.46098857e-02f, -1.88262016e-02f, -4.39037615e-03f, 1.87494885e-02f, 3.36374268e-02f, 1.63766909e-02f, -7.88926333e-03f,
  4.11644354e-02f, -5.02879433e-02f, -1.81066021e-02f, -3.42865698e-02f, -7.01675713e-02f, -9.97209549e-03f, 1.66563652e-02f, 1.99288763e-02f, -2.34148167e-02f, -1.58476327e-02f,
  -2.44518518e-02f, -1.80965826e-01f, -4.21396047e-02f, -1.02900699e-01f, -4.42543253e-03f, 1.52023196e-01f, 4.14783368e-03f, -1.68439388e-01f, -1.50685951e-01f, -1.11624599e-01f,
  -1.21097073e-01f, -3.80354635e-02f, -7.49838352e-02f, -3.19595486e-02f, 3.50090444e-01f, 2.52492398e-01f, 4.33376990e-02f, 5.92923649e-02f, -2.76195407e-02f, -3.57024781e-02f,
  -2.91513279e-02f, -6.01795362e-03f, 1.46586254e-01f, -6.31252751e-02f, -2.11641230e-02f, -2.66793482e-02f, -7.39829317e-02f, -6.50480241e-02f, 4.65009287e-02f, 9.54060256e-02f,
  1.21787749e-01f, -3.90278026e-02f, -3.34072262e-02f, -2.56774155e-03f, -4.97284755e-02f, -6.53743148e-02f, -1.55780027e-02f, 3.44004072e-02f, -3.96550037e-02f, -6.77744672e-02f,
  4.71797623e-02f, 8.73306300e-03f, 2.42193062e-02f, 4.54977201e-03f, 1.27649410e-02f, 6.08377531e-02f, 4.98613827e-02f, -2.43744496e-02f, -8.44791904e-02f, 6.62560314e-02f,
  -5.50742373e-02f, -2.58108582e-02f, -5.48853055e-02f, 9.34808701e-03f, 1.84367653e-02f, -5.47787510e-02f, 3.51526849e-02f, 2.58056428e-02f, 8.28511547e-03f, 4.02438529e-02f,
  3.63280736e-02f, 2.13738475e-02f, -1.72399892e-03f, 3.35094035e-02f, 2.06683669e-02f, 4.12253030e-02f, -4.27738726e-02f, 2.15005060e-03f, 2.25083176e-02f, -4.05844972e-02f,
  4.97996360e-02f, -2.40483359e-02f, 3.85371856e-02f, -1.55158518e-02f, 5.78376949e-02f, -1.75455604e-02f, 1.65440813e-02f, -3.18643115e-02f, 5.33820353e-02f, 5.05425259e-02f,
  8.65746289e-03f, -2.38357410e-02f, 6.85309470e-02f, -2.46706214e-02f, -6.05318993e-02f, -7.31092319e-02f, -8.33058357e-02f, -1.64681040e-02f, 2.25084950e-03f, -2.70100124e-02f,
  -9.34064388e-03f, -3.38165648e-02f, 4.72951233e-02f, -3.28298584e-02f, 1.77778341e-02f, 6.19727895e-02f, -5.15619060e-03f, -3.78720649e-03f, -8.58762115e-03f, 5.11574633e-02f,
  -7.82090053e-02f, -5.87826371e-02f, -1.94392093e-02f, -3.30254659e-02f, 3.65002118e-02f, 3.17164920e-02f, 1.13787558e-02f, 4.53796089e-02f, -3.76659306e-03f, -3.95902060e-02f,
  1.77882425e-02f, -3.02470494e-02f, -1.56564284e-02f, 8.13025385e-02f, 6.40766025e-02f, -5.02277762e-02f, 1.91261601e-02f, -2.56835520e-02f, 2.37652510e-02f, -6.37532072e-03f,
  3.60407472e-01f, -2.04524468e-03f, -4.62057292e-02f, 3.70244309e-02f, 1.87788904e-01f, 6.76541328e-02f, 6.59548910e-03f, 1.68351576e-01f, 1.64616570e-01f, 1.46569102e-03f,
  -1.53637817e-02f, -2.80895177e-02f, -2.26596728e-01f, -3.66935730e-02f, 4.86976318e-02f, -1.43094286e-01f, 1.48573712e-01f, 4.32227850e-02f, 3.75337712e-02f, 2.07756311e-01f,
  -5.38835414e-02f, 1.03687532e-01f, -2.10676640e-01f, 1.33942189e-02f, 1.12761654e-01f, 1.27261737e-02f, 1.40761629e-01f, -5.83014451e-02f, 4.42226492e-02f, 8.67297724e-02f,
  9.56149921e-02f, 2.05919947e-02f, -7.18424842e-02f, 6.67197183e-02f, 1.71368822e-01f, 9.24852639e-02f, -5.32986484e-02f, -8.01164582e-02f, 8.13939869e-02f, 4.39012051e-02f,
  3.18427905e-02f, 2.65668258e-02f, 2.59599965e-02f, -4.77026738e-02f, 2.32792329e-02f, -3.63262743e-02f, -3.35168606e-03f, -1.01294545e-02f, -1.88915208e-02f, -2.61419569e-03f,
  -3.89260724e-02f, -2.60338467e-02f, 2.56108548e-02f, 2.92004794e-02f, 2.07033977e-02f, 5.47044119e-03f, 4.15246189e-02f, -3.43867987e-02f, 2.92017981e-02f, 1.09296776e-01f,
  7.77083933e-02f, -6.99402541e-02f, -2.80314162e-02f, -4.50788289e-02f, 1.02079222e-02f, 2.96319998e-03f, -6.02793880e-02f, 1.85827296e-02f, -3.46811442e-03f, -4.61771339e-02f,
  -1.45186596e-02f, -1.54039087e-02f, 5.31698987e-02f, -5.40514588e-02f, -1.29870838e-02f, 5.05168363e-02f, -1.67269018e-02f, -5.51387342e-03f, -9.94884130e-03f, 1.43870348e-02f,
  4.31923866e-02f, 3.70609574e-02f, 7.12902471e-03f, 1.71794090e-02f, -6.69782795e-03f, -2.15289509e-03f, -2.67488360e-02f, 5.77034019e-02f, -7.94841126e-02f, -1.39326155e-02f,
  1.53976336e-01f, 1.70458645e-01f, 4.00391929e-02f, -2.16515232e-02f, -1.54639129e-02f, -9.54031050e-02f, 1.02820396e-02f, 4.31765355e-02f, 4.39878181e-02f, -7.74736926e-02f,
  7.74864256e-02f, -1.62239131e-02f, 7.14907721e-02f, -7.07184384e-03f, 5.21871410e-02f, 4.49279277e-03f, 8.50756764e-02f, 8.74887332e-02f, 1.10328071e-01f, 4.46203537e-02f,
  2.93032778e-03f, 4.98459786e-02f, 4.28248346e-02f, 1.17778443e-02f, 1.04704745e-01f, 7.94244707e-02f, -2.27786247e-02f, -1.67082716e-02f, 2.32792981e-02f, -2.50158776e-02f,
  -2.12283403e-01f, 1.09353647e-01f, 1.35742813e-01f, -8.54931325e-02f, -1.09381586e-01f, 2.98356730e-02f, 6.49846196e-02f, -1.08395904e-01f, -1.41335860e-01f, -6.37784600e-03f,
  -5.68281300e-02f, 4.69662761e-03f, 7.92531148e-02f, 8.62615258e-02f, -9.36144590e-02f, 1.13928653e-01f, 1.97740905e-02f, 6.19214699e-02f, 1.01084590e-01f, -2.53311414e-02f,
  -6.19910471e-02f, -9.78057012e-02f, 5.02796024e-02f, 1.96105298e-02f, 5.27352467e-02f, -5.79274297e-02f, -3.80934868e-03f, 1.62306353e-01f, 4.15714085e-02f, 8.89534801e-02f,
  7.20658824e-02f, 9.88481417e-02f, -7.24343359e-02f, 6.09195642e-02f, -5.49981073e-02f, 3.45600322e-02f, 3.83653939e-02f, 3.71576697e-02f, -2.11020056e-02f, 4.24931720e-02f,
  8.14722478e-03f, 6.50847405e-02f, -6.69327239e-03f, -2.68166251e-02f, 4.02159356e-02f, -6.11906126e-03f, -2.20507476e-02f, -2.83378419e-02f, 7.86650777e-02f, 5.95271550e-02f,
  7.49264210e-02f, -1.90438740e-02f, -1.08083561e-01f, -3.95212024e-02f, 2.44174451e-02f, -5.02178185e-02f, -9.20051932e-02f, 6.46881312e-02f, -3.78152542e-02f, 4.80342377e-03f,
  3.01648583e-02f, -2.00068466e-02f, -1.26790218e-02f, 5.58765903e-02f, 9.42689460e-03f, -3.23496200e-02f, -5.16064428e-02f, -3.59916016e-02f, -6.87271953e-02f, -5.49631804e-05f,
  -6.13822155e-02f, 1.80840343e-02f, -1.35656614e-02f, -8.87113139e-02f, -3.10723148e-02f, 5.08127399e-02f, 8.06562230e-02f, -3.22902426e-02f, -1.45988353e-02f, 3.14035155e-02f,
  5.91337420e-02f, -1.38525637e-02f, 3.44479941e-02f, 1.88236218e-02f, 2.30909772e-02f, -2.95641031e-02f, -3.17223705e-02f, 1.12224028e-01f, 9.32829082e-03f, 2.62921527e-02f,
  -5.47861531e-02f, -2.65974477e-02f, 7.14564398e-02f, -3.92036466e-03f, 7.35814348e-02f, 1.58539657e-02f, 5.36498427e-02f, 2.36475654e-02f, 3.02384403e-02f, -3.43180560e-02f,
  -1.04973488e-01f, -5.21977432e-02f, -1.83667466e-02f, 7.33820572e-02f, -2.71138940e-02f, -4.63954955e-02f, 3.18477936e-02f, -1.79299973e-02f, -6.94024786e-02f, 2.90004965e-02f,
  -4.79832888e-02f, 3.33203673e-02f, 3.90208550e-02f, 8.40981584e-03f, 4.43096571e-02f, 5.66917546e-02f, -3.36217172e-02f, -1.00820400e-02f, -1.23986406e-02f, 4.70616110e-02f,
  3.88366841e-02f, -3.23206037e-02f, -1.55096084e-01f, 1.54987453e-02f, -7.27605373e-02f, 4.30075899e-02f, -1.04264542e-01f, 5.28970286e-02f, -1.02388181e-01f, 1.11609839e-01f,
  -6.19825791e-04f, -5.78719564e-02f, 1.14627164e-02f, 8.45831186e-02f, 6.81469310e-03f, 1.02734201e-01f, -3.81085183e-03f, 1.27792254e-01f, 7.47138485e-02f, -8.75754282e-03f,
  3.15690376e-02f, -2.94709858e-03f, -1.43339066e-02f, -4.89072986e-02f, -1.00063615e-01f, -5.57284728e-02f, 8.59973282e-02f, -1.88902751e-01f, 6.28460199e-02f, -1.20615130e-02f,
  -6.21976852e-02f, 7.48852864e-02f, 2.25104019e-02f, 1.07114717e-01f, -3.82089503e-02f, 5.67069687e-02f, -1.06231892e-03f, 3.65372445e-03f, -5.48264273e-02f, -5.61704300e-02f,
  -2.06248928e-02f, 1.00959921e-02f, -1.65399965e-02f, -1.96895674e-02f, -5.27857617e-02f, -2.22162995e-02f, -8.85197986e-03f, 4.14870791e-02f, 2.70809531e-02f, -4.13672961e-02f,
  -3.55617404e-02f, 5.62826060e-02f, 1.12304753e-02f, -6.46623075e-02f, -7.28346631e-02f, -8.30430351e-03f, 2.50900220e-02f, -3.15084308e-02f, 4.63857781e-03f, 6.06713519e-02f,
  -9.43229795e-02f, 1.26784164e-02f, -8.28548372e-02f, -4.30480763e-02f, 3.32909003e-02f, 7.04497248e-02f, 6.42330060e-03f, -2.43226998e-02f, -2.18652338e-02f, 4.01878059e-02f,
  3.60672921e-02f, 1.24912132e-02f, -2.94281188e-02f, -6.59668222e-02f, 4.83027697e-02f, 2.08337624e-02f, -8.16091895e-02f, -7.01667070e-02f, 1.11627458e-02f, 7.85376430e-02f,
  -5.16711210e-04f, 8.28649178e-02f, 3.13831195e-02f, -6.04330562e-02f, -4.18184809e-02f, 1.44853098e-02f, 7.36553147e-02f, -9.67572629e-02f, 6.32100925e-02f, -9.47241038e-02f,
  1.61656123e-02f, 1.08678207e-01f, 3.93516244e-03f, 8.48148689e-02f, -3.99277061e-02f, 4.05404270e-02f, 9.35367644e-02f, 1.02090918e-01f, -7.00229779e-02f, 7.22315609e-02f,
  -2.49763932e-02f, -2.69830003e-02f, 1.03743123e-02f, 4.97316346e-02f, -2.54180375e-02f, 4.51715328e-02f, -8.30745883e-03f, 4.83912081e-02f, 3.87626700e-02f, 7.43162483e-02f,
  1.02493130e-01f, -2.68544573e-02f, -2.41329838e-02f, -3.95124555e-02f, -9.62931605e-04f, -6.25867322e-02f, -2.92840395e-02f, -4.24653739e-02f, -1.28785111e-02f, -5.51586859e-02f,
  1.68194562e-01f, -1.21660449e-01f, -8.60042050e-02f, 1.61370173e-01f, 9.22432840e-02f, -6.69631213e-02f, -2.09676251e-01f, 2.55305972e-02f, -1.73026159e-01f, -6.36729598e-03f,
  3.50832716e-02f, -2.56142467e-01f, -1.71230033e-01f, -7.32474178e-02f, -1.29912108e-01f, -1.99641719e-01f, -1.23698309e-01f, -6.06852733e-02f, -1.35097414e-01f, 1.54894860e-02f,
  -2.27579232e-02f, 1.95242852e-01f, -4.07363847e-02f, 2.62922406e-01f, 8.94412026e-02f, 1.88974023e-01f, 2.04130843e-01f, 3.52409668e-02f, 1.79485813e-01f, -6.69927374e-02f,
  8.54407698e-02f, 4.87572812e-02f, -4.66583185e-02f, 5.63769322e-03f, 7.52539188e-02f, 9.53889173e-03f, -7.69978762e-02f, -6.69385418e-02f, -5.38598895e-02f, -4.21101674e-02f,
  -1.40695378e-01f, -1.52545525e-02f, 6.97451681e-02f, 7.77342543e-02f, -4.65356931e-02f, -9.68075637e-03f, -4.74200025e-02f, -6.14779517e-02f, -3.20245214e-02f, -5.97642660e-02f,
  -1.96195368e-04f, -1.62095502e-02f, 1.22680876e-03f, 3.39841582e-02f, -4.08035219e-02f, 2.70500612e-02f, -7.13631958e-02f, -7.48253390e-02f, 3.39595489e-02f, -3.02207805e-02f,
  5.23719154e-02f, -8.66628364e-02f, -2.13606395e-02f, 3.75389569e-02f, -3.99104133e-02f, 1.45535782e-01f, 4.68929633e-02f, 4.56275232e-02f, -9.20543373e-02f, 1.20997718e-02f,
  7.23570883e-02f, 6.85492763e-03f, -1.56767182e-02f, -1.68887842e-02f, -7.79424282e-03f, -8.79376847e-03f, -1.22416113e-02f, 4.16760333e-02f, 7.52958208e-02f, 1.91469863e-02f,
  1.23624448e-02f, -5.86190410e-02f, 8.04448780e-03f, -6.46836357e-03f, -1.77003052e-02f, -1.19767606e-01f, 4.96713258e-02f, -1.09613694e-01f, 6.86231954e-03f, -1.57208573e-02f,
  6.06890395e-02f, 1.62001193e-01f, -1.82885658e-02f, 6.47852346e-02f, -1.29253836e-02f, 1.73104629e-02f, -9.56005603e-02f, 1.48186572e-02f, -3.54684815e-02f, 2.59803161e-02f,
  8.35843906e-02f, 1.06526865e-02f, 8.66404697e-02f, -3.30965929e-02f, 3.59349959e-02f, 1.92918896e-03f, 1.23477913e-03f, -3.77432257e-02f, 8.66021514e-02f, 3.39509643e-05f,
  7.38387406e-02f, 3.24936844e-02f, -1.15321074e-02f, 9.43822786e-02f, 4.76311855e-02f, 2.89568398e-02f, 2.64627673e-02f, 3.22951302e-02f, 2.89060306e-02f, -2.39837840e-02f,
  7.13039860e-02f, 7.27969781e-02f, -1.16245091e-01f, -3.31879333e-02f, -3.17455381e-02f, 1.64647289e-02f, -3.08177397e-02f, 7.85649382e-03f, 5.64251430e-02f, 6.16835393e-02f,
  2.52008773e-02f, -4.69055846e-02f, -1.31445089e-02f, 9.44237709e-02f, 7.57621452e-02f, 4.04847898e-02f, 1.42920226e-01f, 1.06971845e-01f, 1.43101411e-02f, 2.84670051e-02f,
  2.57748994e-03f, 6.71121255e-02f, -6.73476607e-02f, 4.03065830e-02f, -1.18878305e-01f, -1.40076131e-01f, -1.72094088e-02f, 2.04671398e-02f, 1.11358687e-02f, -5.95346540e-02f,
  3.82634811e-03f, -3.09623741e-02f, -4.13126778e-03f, -9.97115895e-02f, 6.41088048e-03f, 2.67097708e-02f, 2.82701310e-02f, -2.74593290e-02f, -2.23658327e-02f, 2.66961250e-02f,
  -4.28909585e-02f, 8.13066959e-02f, 6.79219738e-02f, -5.72251603e-02f, -1.19205210e-02f, -1.78321991e-02f, -1.27146691e-01f, -2.24278588e-03f, -3.83528844e-02f, 5.52132279e-02f,
  -6.30544201e-02f, -5.21128438e-02f, -2.90786121e-02f, 6.75136298e-02f, -5.17023839e-02f, 4.08936329e-02f, -8.85591842e-03f, -2.41644364e-02f, -4.53655161e-02f, 5.26023433e-02f,
  1.44291129e-02f, -9.06437356e-03f, -3.28604653e-02f, -2.73645315e-02f, -3.84853482e-02f, -6.32985756e-02f, -4.52412665e-02f, 4.02539819e-02f, -6.89297542e-02f, -1.44377062e-02f,
  1.07271811e-02f, -6.32288158e-02f, 3.82513069e-02f, -5.10654710e-02f, -1.55904302e-02f, -1.83154307e-02f, 4.81346846e-02f, -2.19002981e-02f, -1.82101671e-02f, 3.13983783e-02f,
  -4.68806140e-02f, 1.68774482e-02f, -6.08318076e-02f, -6.09935634e-02f, 4.88587283e-02f, -1.01114824e-01f, 6.35239556e-02f, -3.32784839e-02f, 4.98073036e-03f, 9.50532593e-03f,
  1.20704407e-02f, 9.64670107e-02f, -2.50786655e-02f, -3.44642736e-02f, -3.10633946e-02f, 1.44844903e-02f, 6.68052956e-02f, -5.07434756e-02f, -2.53003389e-02f, 6.66102469e-02f,
  7.44788870e-02f, -2.21137498e-02f, 3.54808755e-02f, -3.65726538e-02f, -5.27215116e-02f, 3.59042361e-02f, 6.36358485e-02f, 2.39338190e-03f, 6.01328574e-02f, -7.32219517e-02f,
  -2.19542850e-02f, 3.00165769e-02f, 3.61014297e-03f, 4.10062261e-02f, -1.90837425e-03f, 5.58691360e-02f, 1.17722498e-02f, 9.98482332e-02f, -8.33436921e-02f, -3.85570899e-02f,
  1.48782223e-01f, 1.00612313e-01f, 2.51871217e-02f, 9.46260616e-02f, 1.37808189e-01f, -1.37589335e-01f, -1.19833753e-01f, 4.98862304e-02f, 7.38487542e-02f, -1.14491254e-01f,
  -1.69208854e-01f, 2.27982905e-02f, -1.39862701e-01f, -2.85865534e-02f, -2.03291312e-01f, -3.20185954e-03f, 5.78914396e-02f, 6.80441186e-02f, 1.56057686e-01f, 1.13731526e-01f,
  1.09062709e-01f, -6.06495887e-02f, -6.43748278e-03f, 5.93750700e-02f, 7.90175125e-02f, 3.66828293e-02f, -9.38065648e-02f, 6.36157021e-02f, -2.93065072e-03f, -1.31310942e-02f,
  -1.31109357e-01f, 8.20830166e-02f, 3.65422666e-02f, -9.75141861e-03f, -1.46949843e-01f, -7.79448965e-05f, 3.29960734e-02f, -4.91373204e-02f, -1.08875213e-02f, -4.48584668e-02f,
  -9.11453739e-03f, 2.80580334e-02f, -1.13970172e-02f, -3.92417870e-02f, -2.21712585e-03f, 5.45540564e-02f, 1.93862524e-02f, -1.25181237e-02f, 4.19240333e-02f, -1.23455608e-03f,
  1.97283570e-02f, -3.04884687e-02f, 1.66305192e-02f, -1.29573531e-02f, 6.36170506e-02f, 2.14022901e-02f, -4.19918038e-02f, 3.22029460e-03f, 5.97578958e-02f, 8.09916556e-02f,
  -2.88016126e-02f, -3.36746275e-02f, -1.80269722e-02f, -5.72351255e-02f, -5.65454829e-03f, -3.45842093e-02f, 7.84605043e-04f, -6.08706567e-03f, 7.72635043e-02f, 8.79849643e-02f,
  2.13689953e-02f, 8.43962561e-03f, 1.04318425e-01f, 2.97491513e-02f, 2.22932287e-02f, -4.72367294e-02f, -9.15595610e-03f, -3.29408683e-02f, 6.19642884e-02f, -1.22164879e-02f,
  -1.25364792e-02f, -1.76468659e-02f, -7.34804869e-02f, -9.52323824e-02f, -1.02627881e-01f, 1.72113143e-02f, -6.13278374e-02f, 4.48372960e-02f, 3.30679322e-04f, 2.07511093e-02f,
  4.14091013e-02f, 5.05997380e-03f, -8.46451372e-02f, -3.87107581e-02f, 3.89201306e-02f, 2.47562528e-02f, 2.03817096e-02f, -7.19106421e-02f, -2.46052798e-02f, 3.67250666e-02f,
  4.05551866e-02f, 9.05153807e-04f, 8.11428949e-02f, -7.75652528e-02f, 1.50742261e-02f, -1.07318796e-02f, 4.39200997e-02f, 9.48662870e-03f, 1.40977642e-02f, -1.80214010e-02f,
  4.53554876e-02f, 5.51088117e-02f, -7.52011314e-02f, -7.08864033e-02f, 7.07813026e-03f, -4.18141251e-03f, -4.95302537e-03f, -7.45763350e-03f, 8.25149845e-03f, -2.54696887e-02f,
  5.11253357e-01f, -2.75202066e-01f, -1.71732102e-02f, 4.96422052e-02f, 1.05233662e-01f, -6.37921914e-02f, 1.33183956e-01f, -7.22361505e-02f, -4.82496135e-02f, -1.99523732e-01f,
  3.55565362e-02f, 1.42870158e-01f, 6.08158335e-02f, -1.37389973e-02f, 2.64203250e-01f, -2.25003865e-02f, -4.36721854e-02f, 1.05676102e-02f, -1.06517963e-01f, -6.65113628e-02f,
  7.33770132e-02f, -4.55995686e-02f, 4.59516793e-02f, -1.45428069e-02f, 1.10233255e-01f, -1.57568716e-02f, 1.34413660e-01f, 1.02188572e-01f, -1.80288795e-02f, 3.46493460e-02f,
  4.43845652e-02f, -1.03233293e-01f, 2.39540543e-02f, -9.73064750e-02f, 1.96353272e-02f, -2.79828180e-02f, 2.22643930e-03f, 9.39679369e-02f, 1.27705811e-02f, 3.84370908e-02f,
  9.92057659e-03f, -3.43022693e-04f, -1.36015657e-03f, 4.60465588e-02f, -7.58671295e-03f, 7.90559873e-03f, 8.20379984e-03f, -9.15668905e-03f, -2.00992096e-02f, 8.53866711e-03f,
  -2.59727687e-02f, -7.44080218e-03f, -9.12587270e-02f, -6.87712654e-02f, 1.96411740e-02f, -6.53920397e-02f, -6.95181340e-02f, -8.63850582e-03f, -5.82899414e-02f, -2.83078048e-02f,
  -7.63733834e-02f, -5.30544436e-03f, 2.69407853e-02f, 7.17275264e-03f, 1.64961256e-02f, -8.13049227e-02f, 7.16365129e-02f, -1.61542036e-02f, 2.49223667e-03f, -1.01431273e-02f,
  1.49845751e-02f, 2.54039261e-02f, -4.23163809e-02f, -3.45397592e-02f, 1.26938266e-03f, 2.88076792e-02f, 3.64385471e-02f, -2.59688646e-02f, -3.92262116e-02f, 6.04898445e-02f,
  -1.69493593e-02f, -1.20835565e-02f, -1.89221557e-02f, -2.16148067e-02f, -5.35308458e-02f, 6.12228625e-02f, -1.89822223e-02f, 2.38002874e-02f, 3.18563990e-02f, 4.53626737e-02f,
  -1.33537918e-01f, -1.84650660e-01f, -2.50416044e-02f, -1.64561477e-02f, -4.27099392e-02f, 4.80701141e-02f, -3.14526185e-02f, 2.78101359e-02f, -6.62962124e-02f, 2.59484481e-02f,
  -1.46479066e-02f, 3.20711583e-02f, 9.60916746e-04f, -2.06917580e-02f, -5.96957989e-02f, -5.63620068e-02f, 1.57737522e-03f, -1.73723057e-03f, -2.43165642e-02f, -8.30529407e-02f,
  4.41272259e-02f, -6.08031591e-03f, 3.63842919e-02f, 2.57981569e-02f, -3.74589376e-02f, 6.47054762e-02f, 3.82713266e-02f, 7.97899812e-03f, -2.32196376e-02f, -4.99114580e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.18524817e-02f, 1.60951894e-02f, -1.97891835e-02f, 4.77282368e-02f, -6.96941242e-02f, 1.71037406e-01f, 5.29435650e-02f, 4.40802015e-02f, 1.27411559e-01f, -2.09378246e-02f,
  6.22744113e-02f, 7.51695186e-02f, 7.15154856e-02f, 6.41493723e-02f, 1.51679859e-01f, 7.03347251e-02f, 1.68700945e-02f, 1.69027876e-02f, -5.16359843e-02f, 7.57036433e-02f,
  2.60950122e-02f, 9.39885974e-02f, 2.37386189e-02f, -6.54218495e-02f, -1.20858587e-01f, -1.05608910e-01f, -5.68195470e-02f, -2.17193477e-02f, -8.05795342e-02f, 3.12080681e-02f,
  -6.25220612e-02f, 3.59439664e-02f, 3.52796726e-02f, 4.56664488e-02f, -7.61778280e-02f, -5.06669804e-02f, -9.74480659e-02f, -2.10716687e-02f, 5.97457513e-02f, 1.96944531e-02f,
  -8.19182396e-02f, -5.37958480e-02f, 9.73321795e-02f, -9.77772623e-02f, -8.15514475e-02f, 1.84711944e-02f, 6.92729577e-02f, -6.38789386e-02f, 1.02038093e-01f, 6.35841042e-02f,
  4.40988503e-02f, 6.27648309e-02f, 1.12562589e-02f, -8.58129784e-02f, -1.25605939e-02f, -3.45350280e-02f, 7.11928010e-02f, -4.25710678e-02f, 1.40996287e-02f, 3.30271162e-02f,
  5.06452359e-02f, -8.16873163e-02f, 9.35136527e-03f, -4.52393107e-02f, -7.05053359e-02f, 5.94713204e-02f, -7.43569508e-02f, 9.02471468e-02f, 3.99692655e-02f, 3.27516571e-02f,
  -7.50833005e-02f, -2.13240553e-02f, -3.53156328e-02f, -5.06356880e-02f, 6.70759305e-02f, 6.75164610e-02f, 5.76604307e-02f, -2.64489949e-02f, -2.00515538e-02f, 7.99300075e-02f,
  6.47975653e-02f, -6.08075969e-02f, -4.10245471e-02f, -6.58757240e-02f, 9.81909223e-03f, 7.79660121e-02f, 6.19362779e-02f, 1.57065205e-02f, 2.60640569e-02f, -4.93112318e-02f,
  -2.67855171e-02f, 5.35025634e-02f, -1.01732150e-01f, 8.12867954e-02f, 6.30067289e-02f, 4.08756733e-02f, 3.72657962e-02f, -7.24194758e-03f, 6.58613965e-02f, 4.03179936e-02f,
  4.57027406e-02f, 2.87928223e-03f, 5.25928326e-02f, -2.45789681e-02f, 3.46096116e-03f, 3.79189104e-02f, -5.09475917e-03f, -1.60164814e-02f, 9.63015184e-02f, -6.01713397e-02f,
  -2.14527212e-02f, -9.51095670e-02f, -6.49809763e-02f, 5.40505797e-02f, 5.67501038e-03f, 3.17564793e-02f, -1.48543408e-02f, -7.80686885e-02f, -7.25696161e-02f, 2.37738527e-02f,
  -2.90444177e-02f, 6.91213608e-02f, -1.85372099e-01f, -4.60827927e-04f, -4.78361472e-02f, -3.48143540e-02f, -7.26825520e-02f, 2.23261677e-02f, -2.26526663e-01f, 1.14482537e-01f,
  -6.86816918e-03f, 7.09951818e-02f, -1.77799258e-02f, 2.13158384e-01f, 4.70818020e-02f, 1.23132080e-01f, 1.33144736e-01f, 3.30083854e-02f, -1.16576441e-02f, 1.74749032e-01f,
  8.83901715e-02f, 2.20082983e-01f, 1.11609787e-01f, 1.03414476e-01f, 4.08574827e-02f, -2.40610857e-02f, 1.90987036e-01f, 2.38009379e-03f, 8.32062513e-02f, 1.17471643e-01f,
  2.51980796e-02f, 6.29241168e-02f, -3.29879411e-02f, -2.70380778e-03f, 7.72595257e-02f, 7.05660135e-02f, 5.34204254e-03f, -4.23407517e-02f, -3.06805642e-03f, 2.94359983e-03f,
  4.64232685e-03f, 2.69851796e-02f, 4.47507799e-02f, -3.79512645e-02f, 3.49887908e-02f, 5.92611395e-02f, 1.49951736e-02f, -8.90060440e-02f, -6.64290637e-02f, -5.53715378e-02f,
  4.14722413e-03f, 1.91241857e-02f, -5.65934405e-02f, 6.00815341e-02f, -4.71163727e-02f, -9.16658901e-03f, 6.27491996e-02f, -6.72479048e-02f, 4.03200388e-02f, -4.33700420e-02f,
  2.31603216e-02f, 1.64325698e-03f, 1.26975015e-01f, 3.04668173e-02f, -1.06537519e-02f, 9.71920416e-02f, 1.32704051e-02f, 3.15082632e-02f, 3.89535502e-02f, 3.41863185e-02f,
  4.13419828e-02f, 1.57025307e-02f, 6.07971661e-02f, -5.51431365e-02f, 2.35375259e-02f, 6.88306689e-02f, -1.99943241e-02f, 1.64773203e-02f, -9.58226845e-02f, 6.80414354e-03f,
  7.54371509e-02f, 9.34826359e-02f, 6.57089055e-02f, 1.97706334e-02f, 5.89527451e-02f, -5.45699596e-02f, 7.36733377e-02f, 7.54603595e-02f, -3.07668895e-02f, 5.64535195e-03f,
  1.10518113e-01f, 1.36981253e-02f, 1.98766291e-02f, 8.29196945e-02f, -2.21370909e-04f, 2.78152674e-02f, 1.71663053e-02f, -1.02022793e-02f, -1.38048576e-02f, 6.17902959e-03f,
  -4.11706492e-02f, 6.70449659e-02f, -3.07458057e-03f, -8.81519541e-02f, -1.80991106e-02f, -5.69784490e-04f, -9.18463804e-03f, -8.62498060e-02f, 4.53877412e-02f, -4.62228321e-02f,
  -3.24188806e-02f, -3.03887930e-02f, -1.46332625e-02f, -8.25318098e-02f, 3.98187488e-02f, -3.43796685e-02f, 4.36772183e-02f, -1.73139144e-02f, 4.17731255e-02f, 1.80718116e-02f,
  1.38437599e-01f, -9.22240019e-02f, 9.29699391e-02f, 2.71322578e-02f, -9.37277824e-02f, -4.47456464e-02f, 3.50342095e-02f, -6.34296611e-02f, -1.51718348e-01f, -9.49657708e-02f,
  1.06348887e-01f, 3.99964349e-03f, -2.95465682e-02f, -7.39407465e-02f, 4.41640317e-02f, 8.30911752e-03f, -1.04134187e-01f, 1.09397983e-02f, 6.76133037e-02f, 9.45724696e-02f,
  8.45848247e-02f, 3.89947705e-02f, 1.20126344e-01f, -9.39009525e-03f, -5.54195903e-02f, 2.60264855e-02f, 7.71462470e-02f, 8.32080096e-02f, 9.91659090e-02f, 6.83422089e-02f,
  -2.11442094e-02f, 2.06663590e-02f, 4.55401652e-03f, -8.31700340e-02f, 2.39135567e-02f, 2.72450354e-02f, 1.15025765e-03f, 6.39855340e-02f, -8.41860250e-02f, -7.76106417e-02f,
  -1.18840046e-01f, -3.08586732e-02f, 1.12144351e-02f, 6.95983171e-02f, 2.94059459e-02f, 4.25093584e-02f, -1.83047596e-02f, -5.99252246e-02f, -1.28373429e-01f, 4.25856225e-02f,
  3.61281671e-02f, -8.83553177e-02f, -3.90352798e-03f, -3.57611477e-02f, 4.73788828e-02f, -1.93873812e-02f, -3.11510786e-02f, 3.39901969e-02f, -5.83824329e-02f, -2.87595503e-02f,
  1.38065726e-01f, -3.60486656e-02f, 8.44269469e-02f, -9.46296901e-02f, -4.18851385e-03f, 5.54270409e-02f, -7.37281889e-02f, 1.46522354e-02f, -1.42623950e-02f, 3.61411683e-02f,
  -2.90786065e-02f, -7.58121237e-02f, -1.89494644e-03f, 6.85806796e-02f, -6.88414723e-02f, -7.47982040e-02f, -6.95707556e-03f, 8.45707357e-02f, 7.35817626e-02f, 7.71976449e-03f,
  -4.28157337e-02f, -8.85048416e-03f, -9.25600678e-02f, -1.36448490e-02f, 2.14757323e-02f, -2.23044604e-02f, 6.42461330e-02f, 5.30792773e-03f, 7.08749816e-02f, 2.65120938e-02f,
  -1.09457336e-01f, -4.41761827e-03f, -1.23697016e-02f, -4.88278419e-02f, 3.24252024e-02f, -5.73715195e-02f, 1.03627682e-01f, -8.87706280e-02f, 9.01691839e-02f, 1.37888305e-02f,
  -8.57708454e-02f, 4.70294207e-02f, -9.63195115e-02f, -3.36865112e-02f, 3.39279100e-02f, 3.54024656e-02f, 6.04316331e-02f, 6.95539787e-02f, -1.86685696e-02f, -4.84825633e-02f,
  5.91330491e-02f, -2.49777995e-02f, 3.42804901e-02f, 9.61606111e-03f, -1.23495078e-02f, 5.83251789e-02f, 8.62725377e-02f, 9.65203568e-02f, -3.30277532e-02f, 8.12489539e-02f,
  -2.08787680e-01f, -3.29425819e-02f, -9.62541252e-02f, -4.05223817e-02f, -2.76285876e-02f, 7.28996247e-02f, 1.65012982e-02f, 6.34000776e-03f, -2.06184983e-02f, 1.65859506e-01f,
  1.17311984e-01f, -1.17622837e-02f, 1.07899167e-01f, 7.28090852e-02f, -7.17443451e-02f, 3.06130443e-02f, 7.03459308e-02f, -4.06931676e-02f, -1.14367560e-01f, 1.50700033e-01f,
  -1.09853052e-01f, 1.79070309e-01f, 2.64777374e-02f, -5.54344468e-02f, -1.97094139e-02f, 2.26233825e-02f, 5.35662360e-02f, 3.09821367e-02f, -2.62523033e-02f, -1.02121092e-01f,
  5.34574762e-02f, -2.13305391e-02f, 3.12159508e-02f, 6.98837489e-02f, -2.39942931e-02f, -4.27892432e-02f, -6.19805939e-02f, -1.65554732e-02f, -9.89225972e-03f, 1.05312809e-01f,
  -9.22768377e-03f, 4.62652035e-02f, 2.99324431e-02f, -8.20995774e-03f, 6.64440095e-02f, -5.43696322e-02f, -7.29780830e-03f, -4.50245366e-02f, -1.60170458e-02f, -2.91831233e-02f,
  -2.50760019e-02f, 6.11917675e-02f, 9.65955555e-02f, -3.48299928e-02f, 1.18435053e-02f, 3.42773423e-02f, -6.95442259e-02f, -8.27316046e-02f, 6.73275590e-02f, -6.12277910e-02f,
  8.21854621e-02f, -4.21567559e-02f, 7.33401999e-02f, -2.60287300e-02f, 2.44950354e-02f, 4.20235060e-02f, 7.02060983e-02f, 6.64954353e-03f, -4.46825624e-02f, -3.42571735e-02f,
  1.43355839e-02f, -6.61724433e-02f, 7.08183795e-02f, 6.47446737e-02f, 5.05128801e-02f, 1.44527582e-02f, -1.15321658e-03f, 4.46049012e-02f, -7.83549473e-02f, -5.25320694e-02f,
  8.17196369e-02f, -1.90752931e-02f, -1.25585720e-02f, 2.31597666e-02f, 2.03881487e-02f, -3.38488296e-02f, -4.78434982e-03f, 4.28037308e-02f, -6.86650053e-02f, -7.13394433e-02f,
  1.17627099e-01f, 6.43867329e-02f, -4.47183885e-02f, -5.73795475e-02f, 3.90677340e-02f, 6.22116216e-02f, -1.16101755e-02f, 1.92259047e-02f, -2.14415304e-02f, 6.48368970e-02f,
  8.52607340e-02f, 9.37347636e-02f, 5.75499907e-02f, 1.86481159e-02f, -2.68705636e-02f, 2.36606486e-02f, -3.36970277e-02f, -2.89051346e-02f, -4.01825421e-02f, 2.44335923e-02f,
  7.00133517e-02f, -6.25964180e-02f, -2.07915399e-02f, 2.23750286e-02f, 1.76227912e-02f, 9.52762887e-02f, -1.39311608e-02f, 9.73121896e-02f, -1.18563408e-02f, 6.71886513e-03f,
  -1.49506867e-01f, -6.85392916e-02f, 4.64530103e-03f, 2.44649369e-02f, 5.28226905e-02f, -5.34384772e-02f, 7.44055063e-02f, 3.98147181e-02f, -7.72437500e-03f, 1.19096711e-01f,
  4.13578637e-02f, -9.82900560e-02f, -1.70033537e-02f, 2.22120788e-02f, -1.45540580e-01f, -2.76306644e-02f, -1.01727478e-01f, -1.36845503e-02f, -5.81935346e-02f, -7.03424215e-02f,
  -1.61342490e-02f, -7.08730146e-02f, -9.09718573e-02f, 1.02109546e-02f, -1.09813698e-01f, -3.58178876e-02f, 2.65399590e-02f, -5.43875024e-02f, 2.08573211e-02f, -1.88891403e-02f,
  -5.39569631e-02f, 1.15232542e-01f, 3.53227369e-02f, 8.92949700e-02f, -3.05262581e-02f, -5.74672036e-02f, -1.97353587e-02f, -2.64342111e-02f, 3.89505737e-02f, 7.80202746e-02f,
  7.04510361e-02f, 8.04837421e-02f, -1.07512353e-02f, 5.32055087e-02f, 3.25473994e-02f, -1.47836693e-02f, -5.02386726e-02f, 3.59779596e-02f, -6.10680971e-03f, -4.33407277e-02f,
  6.73075207e-04f, -6.23957627e-03f, -9.24725756e-02f, -5.31087071e-02f, 4.78465017e-03f, 4.01430624e-03f, -3.79072390e-02f, -4.89968583e-02f, 3.93684320e-02f, 1.03769256e-02f,
  4.09820862e-02f, -5.08995466e-02f, 1.89192481e-02f, -1.63010564e-02f, -2.46083699e-02f, -5.50278090e-02f, 6.11497760e-02f, 5.19146770e-02f, -9.87583473e-02f, -9.57301557e-02f,
  -4.67926264e-02f, -1.21741835e-02f, -3.20094228e-02f, -5.48381209e-02f, -7.69218951e-02f, 1.88752171e-02f, 6.87421411e-02f, -3.77417007e-03f, 4.78495322e-02f, -4.01108190e-02f,
  7.54354661e-03f, -3.88491228e-02f, 2.35151760e-02f, 1.56584065e-02f, -4.99319658e-03f, -3.57586481e-02f, -3.58998440e-02f, 2.02167276e-02f, 3.37904282e-02f, -5.50172403e-02f,
  6.45554885e-02f, 9.01635736e-02f, 4.72651795e-02f, -5.49334772e-02f, 8.19043890e-02f, -7.33657405e-02f, 7.43178651e-02f, -5.44548705e-02f, 4.56765778e-02f, 6.63620681e-02f,
  -4.90746573e-02f, 1.74642429e-02f, -1.31662413e-02f, 3.94751094e-02f, 1.78863888e-03f, -5.94870858e-02f, -4.51575182e-02f, 5.84214740e-02f, 4.37534451e-02f, -5.37402891e-02f,
  -2.49752793e-02f, -2.20519938e-02f, -7.57791027e-02f, 6.58977553e-02f, -7.72637054e-02f, 7.21997023e-02f, -7.32019991e-02f, 1.42756132e-02f, -3.69649976e-02f, -4.69412729e-02f,
  -2.90135115e-01f, 1.05650395e-01f, -9.33323205e-02f, 1.28355652e-01f, -3.52532491e-02f, 2.11132452e-01f, 2.01928630e-01f, -9.64122638e-03f, 8.84990916e-02f, 2.44426921e-01f,
  1.83150563e-02f, 5.13254032e-02f, -3.82946953e-02f, 2.71345496e-01f, 4.72856760e-02f, 6.65585473e-02f, 2.68352628e-01f, 1.98780239e-01f, -5.79333724e-03f, -3.48362103e-02f,
  -9.88323763e-02f, 1.78497553e-01f, -2.64433306e-02f, 8.32413957e-02f, -5.93947321e-02f, -5.55847622e-02f, -3.74113256e-03f, -1.07562505e-01f, 1.25561893e-01f, 5.48354648e-02f,
  -2.57652011e-02f, -1.59896463e-01f, 2.58039963e-03f, -6.30460158e-02f, 1.31990958e-03f, -8.49508643e-02f, 6.37417138e-02f, -6.71439394e-02f, -1.72613859e-02f, -5.88209741e-02f,
  -7.04854773e-03f, -1.00090699e-02f, -3.38588655e-02f, 3.54912207e-02f, 2.01121457e-02f, 4.18274775e-02f, -5.70380315e-02f, -2.15461589e-02f, -4.11570892e-02f, 1.90843211e-03f,
  6.07818775e-02f, 7.17612803e-02f, 3.30400839e-03f, 6.87900186e-02f, -3.28569859e-02f, 9.76908207e-02f, 3.50189172e-02f, 1.34957330e-02f, -7.89605007e-02f, 7.49830455e-02f,
  -3.94365415e-02f, -5.08464165e-02f, 1.46707529e-02f, 8.59481171e-02f, -1.72850080e-02f, -1.33706061e-02f, 2.47438233e-02f, -9.07111634e-03f, -5.19452095e-02f, 5.64079285e-02f,
  -9.08564255e-02f, -4.52018902e-03f, -3.00163981e-02f, 4.34711911e-02f, -7.06674755e-02f, 2.44775116e-02f, -2.03605238e-02f, -5.40067116e-03f, 8.17063898e-02f, 5.20296022e-02f,
  2.45533641e-02f, -3.19118286e-03f, -3.31037752e-02f, 1.09389639e-02f, -7.68783391e-02f, -8.24582279e-02f, 2.46986561e-02f, -4.57322113e-02f, 4.95579541e-02f, -1.46645829e-02f,
  5.14127202e-02f, -6.38067871e-02f, -2.22316291e-02f, 1.03206374e-02f, -4.69510034e-02f, 5.45881912e-02f, -2.11101491e-02f, 5.35053127e-02f, -3.58104222e-02f, 1.79907698e-02f,
  7.44098350e-02f, -8.31485912e-03f, 1.20108631e-02f, -7.69635215e-02f, -3.75258774e-02f, -2.89570987e-02f, 7.79156238e-02f, 2.41910759e-02f, 8.18890706e-02f, -1.55749582e-02f,
  8.17943662e-02f, 1.15221180e-02f, 4.49245609e-02f, -1.01024903e-01f, -5.64067140e-02f, -6.23809174e-03f, 1.62997302e-02f, -9.02663693e-02f, -3.29602361e-02f, 4.70265932e-02f,
  1.68511510e-01f, -5.28166704e-02f, 9.20693874e-02f, 1.65320978e-01f, 1.36083156e-01f, -6.84341788e-02f, 1.60866845e-02f, -2.51523983e-02f, -3.40694152e-02f, -6.01554476e-02f,
  -4.38221842e-02f, -5.40659688e-02f, 5.18449843e-02f, 8.73347223e-02f, 8.63906816e-02f, -1.14388958e-01f, -4.27693166e-02f, -1.93894878e-02f, -2.32837014e-02f, -5.27572855e-02f,
  8.65557119e-02f, 7.59429708e-02f, 1.02841156e-02f, -4.89898548e-02f, -2.40880940e-02f, -9.95925963e-02f, -7.39304200e-02f, -2.53727101e-02f, 2.35508662e-02f, 6.46703988e-02f,
  5.95586374e-02f, 1.44258561e-02f, 4.26259451e-02f, 7.92821422e-02f, -1.09633796e-01f, -8.61811787e-02f, 1.36829525e-01f, -4.78590727e-02f, -9.74962674e-03f, -8.74213651e-02f,
  4.96792383e-02f, 7.21471151e-03f, -5.00854664e-02f, -5.28301299e-02f, 4.84405570e-02f, -3.34762372e-02f, -1.94476023e-02f, -4.36660647e-03f, 8.47830623e-02f, 1.99658014e-02f,
  9.59790964e-03f, -5.69371991e-02f, 1.57733746e-02f, 1.55324657e-02f, 2.20732987e-02f, -2.21346412e-02f, -3.72458212e-02f, 7.44975731e-02f, -7.47251837e-03f, 2.50220727e-02f,
  -6.32479638e-02f, 9.60039720e-02f, -7.84352571e-02f, 1.57570019e-02f, 6.48535276e-03f, 3.12466593e-03f, -6.64130524e-02f, -2.48804353e-02f, 4.71207919e-03f, -1.99423209e-02f,
  6.82027414e-02f, 5.75427189e-02f, -1.72877777e-02f, 7.75274485e-02f, 2.25048158e-02f, 6.10934161e-02f, -1.64117832e-02f, -4.47317213e-02f, -1.05739087e-01f, 6.09948449e-02f,
  -2.20853351e-02f, -1.77049041e-02f, -9.19719487e-02f, 3.84195633e-02f, 6.72138762e-03f, 2.84557175e-02f, -5.65328412e-02f, -9.36438218e-02f, -4.69997115e-02f, 1.49635319e-02f,
  -1.30056649e-01f, -6.45772368e-02f, -3.70737053e-02f, 1.36625441e-02f, -4.94002998e-02f, 2.46477459e-04f, 8.98939446e-02f, 1.63902473e-02f, -1.03916600e-01f, -2.68942267e-02f,
  8.67646560e-02f, -6.77872673e-02f, -1.06523260e-01f, 7.29430169e-02f, 3.18281613e-02f, 5.80471708e-03f, -5.16640283e-02f, 5.46628907e-02f, 2.27200636e-03f, 7.70173082e-03f,
  -5.97606450e-02f, 1.05853491e-01f, 4.72305492e-02f, 5.39156385e-02f, 4.06467542e-02f, -8.71136487e-02f, -7.99271390e-02f, -2.43109521e-02f, 2.66680657e-03f, -8.24100935e-05f,
  -1.11505799e-01f, 4.13198769e-02f, -1.13921752e-02f, -9.42064673e-02f, -1.00038961e-01f, -6.24509081e-02f, 1.81769021e-02f, 3.71958874e-02f, 4.90463488e-02f, 4.30805981e-02f,
  1.35233819e-01f, -1.04829051e-01f, 7.76706561e-02f, 1.50166708e-03f, -5.33063225e-02f, -5.91333956e-02f, -6.03160374e-02f, -1.47026265e-02f, 1.09026337e-03f, -3.80636938e-02f,
  -4.70557697e-02f, 2.83563193e-02f, -9.04877335e-02f, 7.65013620e-02f, -6.91537037e-02f, -1.98594071e-02f, -5.83242858e-03f, 1.03636317e-01f, 1.79844722e-03f, 3.51998061e-02f,
  2.33988687e-02f, 1.14191480e-01f, 4.29421589e-02f, -6.82970434e-02f, -8.21634531e-02f, -4.76144850e-02f, 1.45515446e-02f, 3.46120223e-02f, 2.37713587e-02f, -4.36343364e-02f,
  -1.84784289e-02f, 1.84562095e-02f, 2.97079887e-02f, -5.50992414e-03f, -5.54454699e-02f, 7.80923218e-02f, 6.82965294e-03f, 2.38566622e-02f, 2.99566635e-03f, 2.56833378e-02f,
  2.37278454e-02f, 5.19718528e-02f, 2.71554664e-02f, 8.78400169e-03f, 5.03599131e-03f, -6.95091067e-03f, -4.84992489e-02f, -7.59283453e-02f, -9.94722173e-02f, 1.45068625e-02f,
  -6.29510209e-02f, 4.69177179e-02f, 4.28836234e-02f, -5.69827817e-02f, 4.13574614e-02f, 7.91132823e-02f, 8.26254934e-02f, -9.95546766e-03f, -1.47927003e-02f, 9.07835141e-02f,
  -6.42553568e-02f, -4.30854522e-02f, 5.11920974e-02f, 2.15459205e-02f, -9.68807787e-02f, 4.44776006e-02f, -7.16098025e-02f, 1.06294453e-02f, 5.54829426e-02f, 7.23986179e-02f,
  1.89845618e-02f, 8.87814015e-02f, 5.14426045e-02f, -6.76994547e-02f, 5.28640486e-02f, 5.66279031e-02f, 8.54551047e-02f, 8.20652843e-02f, 8.86454433e-02f, 4.52740304e-02f,
  -3.87332253e-02f, -5.34048155e-02f, 4.37717550e-02f, -7.41052628e-02f, -1.03838816e-02f, -4.37539406e-02f, 5.93733080e-02f, 2.35971883e-02f, -5.35912300e-03f, -8.31878632e-02f,
  9.56246164e-03f, -2.85794884e-02f, -1.38087366e-02f, 7.64739737e-02f, 8.04048702e-02f, -4.22690175e-02f, -5.33373766e-02f, -6.99853599e-02f, -2.75338516e-02f, -3.86778861e-02f,
  3.05720940e-02f, -6.62346557e-02f, 6.48167506e-02f, 4.67995740e-02f, -4.98748478e-03f, 2.19734665e-02f, -1.49112232e-02f, -3.65377963e-02f, -6.36807680e-02f, -3.86836790e-02f,
  1.24225281e-01f, -1.83357224e-01f, -2.54698157e-01f, -1.00913644e-01f, -1.06263265e-01f, -2.86633432e-01f, -2.83842385e-01f, -4.69369069e-02f, -6.17890432e-02f, 1.04135662e-01f,
  8.93329550e-03f, 3.70058566e-02f, 2.87664942e-02f, -6.40601143e-02f, 3.69098745e-02f, 1.08285539e-01f, -1.47036538e-01f, -5.78138120e-02f, -4.59498502e-02f, -8.25944021e-02f,
  -6.15085922e-02f, -1.79954112e-01f, -1.20997556e-01f, -1.05957471e-01f, -5.61632328e-02f, 4.89651449e-02f, 7.76263252e-02f, -3.85242663e-02f, -1.68913994e-02f, -7.35689178e-02f,
  -1.35561407e-01f, 8.75871927e-02f, -1.28042370e-01f, 2.52726991e-02f, -1.05948579e-02f, -7.60643883e-03f, 3.47163528e-02f, 6.72659576e-02f, -4.75232117e-02f, 7.42585585e-03f,
  -3.52088735e-02f, -1.24548469e-02f, -4.70405445e-03f, -3.33603136e-02f, 2.51359846e-02f, -5.11089601e-02f, -2.44448893e-02f, 4.10274975e-02f, -1.99854206e-02f, 4.15641107e-02f,
  -9.10739228e-02f, -8.74448866e-02f, -1.87467709e-02f, 3.84969823e-02f, 2.74758171e-02f, -4.99273613e-02f, 2.76161078e-03f, 6.25172183e-02f, 1.84769724e-02f, 4.86860983e-03f,
  2.56825797e-03f, -3.96579467e-02f, -5.93985133e-02f, -4.10984978e-02f, 6.46068901e-02f, -2.51720939e-02f, 1.43508036e-02f, 4.44802046e-02f, 1.56598836e-02f, -6.03373954e-03f,
  1.45283807e-02f, -3.55096385e-02f, -4.04592976e-02f, 2.99776960e-02f, -8.62305239e-02f, 9.07421410e-02f, -5.29756360e-02f, 2.77607664e-02f, -3.03276186e-03f, -8.61273259e-02f,
  5.40565923e-02f, 6.69781268e-02f, 1.06811468e-02f, -4.32236083e-02f, -8.26125517e-02f, 7.61860386e-02f, 4.75837365e-02f, -8.31707474e-03f, 7.85047337e-02f, -2.01286748e-02f,
  -5.30424081e-02f, -5.13329655e-02f, -1.57154130e-03f, -1.70783550e-02f, -5.23924120e-02f, 3.66164260e-02f, -4.58406545e-02f, -8.68127197e-02f, -3.83695401e-02f, -1.61644537e-02f,
  9.17955860e-02f, -1.88677479e-02f, 5.72070628e-02f, -1.26332575e-02f, 1.22683188e-02f, -3.30607779e-02f, 5.34970015e-02f, 5.36568947e-02f, -1.19012268e-02f, -5.15446886e-02f,
  -1.18622994e-02f, 3.73700634e-02f, 3.29836048e-02f, -6.66172802e-02f, 7.68565834e-02f, 3.98041122e-03f, 3.84804308e-02f, 7.44121447e-02f, 3.84065928e-03f, -4.15497161e-02f,
  1.81330591e-02f, -6.35412559e-02f, -3.41052189e-02f, 6.47349376e-03f, -5.16901650e-02f, -7.05712885e-02f, -1.96486160e-01f, 9.70553793e-03f, 4.79852926e-04f, 5.63692227e-02f,
  -7.22943693e-02f, 1.69411495e-01f, -6.38155490e-02f, -3.44043076e-02f, -3.14477049e-02f, -3.05710789e-02f, -2.00814921e-02f, -2.94842571e-02f, -3.10323555e-02f, -6.69443682e-02f,
  -5.39254211e-02f, -9.15963203e-02f, 7.83297196e-02f, -1.02941476e-01f, -6.27720356e-02f, -1.12428125e-02f, -5.38221821e-02f, -2.18819436e-02f, -8.68521929e-02f, 5.48764169e-02f,
  7.40018412e-02f, -7.13396147e-02f, -8.41698945e-02f, 2.45234929e-02f, 4.37258743e-02f, -6.72271401e-02f, 1.74632370e-02f, -4.16743383e-02f, -4.63282354e-02f, -7.46229663e-02f,
  5.85427620e-02f, 2.44380459e-02f, 7.98512474e-02f, -2.78438758e-02f, -8.67773071e-02f, -1.40347509e-02f, -6.51782379e-03f, 9.18942690e-03f, 1.83762843e-03f, 3.76877487e-02f,
  1.11419111e-01f, 8.79742280e-02f, -8.91411304e-02f, 4.59741754e-03f, -5.66865830e-03f, -1.02051962e-02f, 1.00036114e-01f, 1.52761480e-02f, 2.98398882e-02f, -7.92781562e-02f,
  -7.84271806e-02f, -1.17413051e-01f, -4.25122045e-02f, -2.83790138e-02f, 5.41256778e-02f, -5.08214608e-02f, 1.09750498e-02f, 8.09352994e-02f, -1.57170948e-02f, -8.72961581e-02f,
  2.34694537e-02f, -7.20421448e-02f, 6.28337488e-02f, -2.23730151e-02f, -8.48712772e-03f, -7.43805021e-02f, -1.43827014e-02f, -2.21641758e-03f, 5.53911179e-02f, 3.68762165e-02f,
  3.35805528e-02f, 4.76390868e-02f, -7.82617480e-02f, -6.66805357e-02f, -6.65915459e-02f, 3.42946537e-02f, 7.19724298e-02f, -8.57773796e-02f, -8.92929286e-02f, 1.98628884e-02f,
  -1.40040487e-01f, -6.97614923e-02f, 1.86981894e-02f, -1.06951840e-01f, -2.64311042e-02f, -9.68076289e-02f, -7.32966117e-04f, -3.66414674e-02f, -3.47509198e-02f, -5.70144830e-03f,
  -2.00715698e-02f, -2.80540753e-02f, 7.69242048e-02f, -4.86436673e-02f, 5.57050817e-02f, 2.73220558e-02f, 3.25353742e-02f, 4.95049506e-02f, 3.20308357e-02f, -5.01291193e-02f,
  -2.04002373e-02f, 1.37274684e-02f, -6.06435500e-02f, 8.67456198e-02f, -5.67359440e-02f, -3.95226263e-04f, -4.96955812e-02f, -2.27863993e-02f, 1.53207472e-02f, 8.36646631e-02f,
  2.64500201e-01f, -2.43551746e-01f, -3.49266105e-03f, 1.98314145e-01f, 7.14969933e-02f, -4.58335280e-02f, -8.19070488e-02f, 4.05109627e-03f, 6.66594207e-02f, -8.64367187e-02f,
  -1.90964509e-02f, -1.30836204e-01f, -1.90919563e-01f, -2.02038093e-03f, 3.41678858e-02f, -1.35387793e-01f, 1.59246624e-01f, -8.00570026e-02f, -3.08573376e-02f, -1.03506960e-01f,
  1.21438727e-01f, 1.02353372e-01f, 4.77392897e-02f, 3.78070362e-02f, 8.18530992e-02f, 1.02363780e-01f, 2.51375474e-02f, 6.23929827e-03f, 1.88977998e-02f, 1.75506137e-02f,
  -5.11206128e-02f, -5.18173352e-02f, -7.94136152e-03f, -5.71111497e-03f, 1.67769212e-02f, 6.98951399e-03f, -6.28858507e-02f, 4.21225913e-02f, -1.49566336e-02f, -7.18210936e-02f,
  -3.77313234e-02f, 9.17752758e-02f, 1.11135349e-01f, 8.41804221e-02f, 7.76477531e-02f, -1.53706847e-02f, -3.56009640e-02f, 4.44304124e-02f, -8.07361379e-02f, -8.10776278e-02f,
  -9.41914469e-02f, -3.01372614e-02f, -2.61136834e-02f, -1.75705906e-02f, -1.71774477e-02f, 5.93725853e-02f, -1.03638083e-01f, -1.07491963e-01f, 6.97794929e-02f, 3.98660228e-02f,
  -7.70225450e-02f, 2.92850733e-02f, 1.60242356e-02f, 8.05827752e-02f, 1.80986263e-02f, 3.27272825e-02f, 1.82713363e-02f, 3.03550400e-02f, 6.94220662e-02f, 5.47472388e-03f,
  -5.63548133e-03f, 2.89068799e-02f, 7.83521682e-02f, -1.66029036e-02f, 5.85679477e-03f, -1.06373215e-02f, -4.66127731e-02f, -2.22613104e-02f, 4.88879941e-02f, -9.91177782e-02f,
  -1.70584547e-03f, -1.93284766e-03f, -5.80369635e-03f, -2.99610309e-02f, 2.02225670e-02f, 2.81460062e-02f, 7.08592776e-03f, 1.78611260e-02f, -4.04246747e-02f, -6.66997731e-02f,
  -6.44591153e-02f, -8.74334797e-02f, -1.32616013e-02f, 7.06776455e-02f, -1.42574357e-02f, -3.06414906e-03f, 1.91037618e-02f, 8.87409132e-03f, 6.79487139e-02f, -1.19038504e-02f,
  1.52046354e-02f, 3.46823782e-02f, -9.22326595e-02f, 2.30366141e-02f, -4.54676151e-02f, -6.58811480e-02f, 2.31714603e-02f, 5.50307520e-02f, 2.57783961e-02f, 3.55961695e-02f,
  2.74608470e-02f, -3.91177870e-02f, 4.52514328e-02f, 7.11327838e-03f, -5.56334071e-02f, -1.25275731e-01f, 1.88487731e-02f, -5.74638695e-02f, -3.10363248e-02f, -2.90944073e-02f,
  1.18957058e-01f, 3.88552397e-02f, -2.80150604e-02f, 5.22452965e-02f, -4.14824113e-02f, -1.09781086e-01f, -4.42516916e-02f, 2.17644293e-02f, -1.01008490e-02f, 3.59767787e-02f,
  -1.99424792e-02f, -7.19879344e-02f, -4.92685251e-02f, -6.04975596e-03f, 6.26953021e-02f, 3.43096070e-02f, -9.93003920e-02f, -5.30827008e-02f, -4.65232879e-03f, -1.56509485e-02f,
  3.52131166e-02f, -6.49826899e-02f, -7.75863533e-04f, 1.21268909e-02f, -2.37543602e-02f, 4.73645590e-02f, -5.25715314e-02f, -6.56761527e-02f, 4.89870943e-02f, -5.67251667e-02f,
  -3.31525207e-02f, 4.13655024e-03f, 3.46623808e-02f, -7.80777782e-02f, 3.03939562e-02f, 6.03754707e-02f, 9.16039720e-02f, -7.08263293e-02f, 9.91162006e-03f, 2.07521226e-02f,
  -2.19599195e-02f, 3.34440805e-02f, 1.89033542e-02f, 8.54321197e-02f, 2.82472558e-02f, -4.50777188e-02f, 8.29616934e-02f, -1.76623203e-02f, 7.10356608e-02f, -5.05305454e-02f,
  8.49274397e-02f, 6.33199811e-02f, 6.41120523e-02f, 2.03854162e-02f, 1.79219339e-02f, -7.32806325e-02f, 8.22313055e-02f, -6.32224232e-02f, 2.55994406e-02f, -3.79178338e-02f,
  1.62036717e-02f, 8.12990293e-02f, -7.44315684e-02f, -4.81779203e-02f, 6.96313679e-02f, -7.98895508e-02f, 2.00769566e-02f, -2.07913537e-02f, -7.97378868e-02f, -8.07166845e-02f,
  -6.11266606e-02f, -5.62207513e-02f, 1.60024129e-02f, 6.33818731e-02f, 7.33679235e-02f, 1.89640950e-02f, -1.48615325e-02f, 1.92310475e-02f, 8.17686245e-02f, 1.25748124e-02f,
  2.41561513e-02f, -3.07866298e-02f, 3.02867107e-02f, -5.41783795e-02f, 7.63949081e-02f, -8.17132741e-02f, 6.41554072e-02f, -7.09243044e-02f, 1.21244267e-02f, 4.96106111e-02f,
  2.65005976e-02f, 3.71160060e-02f, 6.71300068e-02f, 3.82458232e-02f, -6.99345618e-02f, -3.18987705e-02f, -8.70655198e-03f, 5.14909923e-02f, 9.59482789e-03f, 5.60013503e-02f,
  -8.24848562e-02f, 1.58667918e-02f, -7.75126517e-02f, 4.66058552e-02f, -5.63162677e-02f, 2.52793860e-02f, 1.60624739e-03f, -3.69694233e-02f, 1.04084000e-01f, -1.14907464e-02f,
  -1.42855314e-03f, -5.37903607e-03f, -5.66821871e-03f, -8.45843703e-02f, 5.42632714e-02f, -5.75607792e-02f, -5.13061648e-03f, -6.77821413e-02f, -3.30538377e-02f, -4.89941537e-02f,
  -8.08823109e-02f, -1.31030038e-01f, -3.06747586e-01f, 7.57853314e-02f, -2.30782539e-01f, -1.69607848e-01f, -1.98417261e-01f, -1.89025670e-01f, 4.31451946e-02f, 1.04951829e-01f,
  6.97800368e-02f, 1.11274840e-02f, 4.01186422e-02f, -1.70792975e-02f, 9.78224799e-02f, 1.58795595e-01f, -1.89525470e-01f, -6.08432963e-02f, 2.86746975e-02f, -2.22606346e-01f,
  1.56014850e-02f, -3.69891077e-02f, -7.34400824e-02f, -1.33397669e-01f, -1.34195387e-01f, -2.60602552e-02f, 5.10570630e-02f, -8.40035230e-02f, 3.79926641e-03f, -1.04164295e-01f,
  2.56087165e-02f, -3.21212597e-02f, -9.73779112e-02f, -5.75358570e-02f, -6.65588528e-02f, -1.19292341e-01f, -5.65739274e-02f, 6.04374781e-02f, 2.84202280e-03f, -3.80285941e-02f,
  4.19531129e-02f, 2.31160223e-03f, -4.07382734e-02f, -8.07315297e-03f, -1.02324650e-01f, -5.89489751e-02f, -3.38397622e-02f, -3.24502923e-02f, -4.74536270e-02f, 2.39229910e-02f,
  -4.90835197e-02f, -1.21725090e-01f, 1.49937803e-02f, 1.00044794e-01f, 3.21621336e-02f, -3.70391384e-02f, 1.88889690e-02f, 1.93489771e-02f, 7.61625869e-03f, -6.36110976e-02f,
  -2.21889429e-02f, 1.80970621e-03f, 1.81930177e-02f, 1.76127125e-02f, -8.55001360e-02f, -3.52740996e-02f, -1.80639513e-02f, 4.50459979e-02f, 3.27393971e-02f, 4.00922932e-02f,
  -1.40798567e-02f, 4.39407825e-02f, 4.66581248e-03f, 1.50840245e-02f, 7.53800273e-02f, -2.00539883e-02f, 5.12859263e-02f, -5.56031652e-02f, -4.21224125e-02f, -4.43036342e-03f,
  -5.48646552e-03f, -5.14167920e-03f, -3.97783704e-02f, 6.50398200e-04f, -8.55332464e-02f, 1.07413054e-01f, 6.88375020e-03f, -4.25369889e-02f, 1.43933706e-02f, 6.85989857e-02f,
  -5.00417948e-02f, -8.10914934e-02f, 3.05907801e-02f, -9.66857746e-02f, 5.57244681e-02f, -5.21373153e-02f, -1.76948570e-02f, -1.17473444e-02f, 8.18460286e-02f, -3.24445106e-02f,
  5.14305159e-02f, -9.62962490e-03f, -7.23698456e-03f, -2.03377903e-02f, 6.19040504e-02f, -9.87020758e-05f, 2.49178857e-02f, -3.81735303e-02f, 6.67780340e-02f, -9.90192294e-02f,
  -3.40876915e-02f, -3.29512954e-02f, 9.68501642e-02f, 4.19285707e-02f, -1.12643074e-02f, -3.52622569e-02f, -5.75831048e-02f, -3.28923240e-02f, -2.92293839e-02f, -7.74428323e-02f,
  1.57276765e-01f, -4.60159220e-02f, 6.20345175e-02f, 1.58152759e-01f, -1.00729287e-01f, -2.52187490e-01f, -8.20832923e-02f, 8.27275403e-03f, -4.16933820e-02f, -1.44699454e-01f,
  5.72616719e-02f, -4.83602919e-02f, 1.00202166e-01f, 1.27144814e-01f, 1.55783921e-01f, 5.12982719e-02f, 7.47677609e-02f, -6.53676093e-02f, 4.94390391e-02f, 1.42702788e-01f,
  7.38917664e-02f, 1.47008657e-01f, 1.03556089e-01f, 6.40168861e-02f, 7.90709108e-02f, 5.05645499e-02f, 6.73258156e-02f, -1.30069137e-01f, 1.13980576e-01f, -3.46949063e-02f,
  -8.11155047e-03f, 5.62639907e-02f, 2.86748204e-02f, -3.62957385e-03f, -5.02207316e-02f, 2.69917725e-03f, -6.11170940e-02f, -5.68816848e-02f, -5.93729652e-02f, -1.31274182e-02f,
  1.33411563e-03f, 6.10567182e-02f, 1.21028606e-04f, 9.10368189e-02f, 2.34445836e-02f, 3.44784632e-02f, 1.04787620e-02f, 3.46208317e-03f, 1.73904039e-02f, 5.88829629e-02f,
  4.35020179e-02f, -2.30190549e-02f, -8.97826552e-02f, -5.17057255e-02f, 9.03938562e-02f, -1.04899509e-02f, -1.47572067e-02f, -1.30999601e-02f, -8.58764797e-02f, -5.78152202e-02f,
  -2.66398140e-03f, -3.30532193e-02f, 6.04447164e-02f, 5.24384156e-02f, -3.42299370e-03f, -2.38047298e-02f, -7.46364892e-02f, -2.00077426e-02f, 8.04312062e-03f, 2.84089409e-02f,
  -1.24144159e-01f, 3.24771274e-03f, 5.04933409e-02f, 1.11993011e-02f, 4.89598438e-02f, -7.56542981e-02f, -7.08390959e-03f, 5.33885695e-02f, -3.83675434e-02f, 3.01134884e-02f,
  -5.48602603e-02f, 6.42858967e-02f, -2.89542805e-02f, -8.35624188e-02f, -8.23153257e-02f, -3.50955836e-02f, 8.29051584e-02f, -8.88014119e-03f, -8.95124972e-02f, -4.75706011e-02f,
  6.27423748e-02f, 1.35919109e-01f, -6.52541785e-05f, -7.08960891e-02f, 3.39529552e-02f, -1.73822716e-02f, -1.84065420e-02f, -3.01125739e-02f, 3.46354172e-02f, 2.94925049e-02f,
  -3.92069742e-02f, -6.34735674e-02f, 3.75992209e-02f, 1.09084561e-01f, 4.33467031e-02f, 1.01780994e-02f, -3.44634503e-02f, -3.41659486e-02f, -5.57017326e-02f, -3.49340662e-02f,
  1.44013437e-02f, -7.44985929e-03f, -8.44054297e-02f, -6.84188306e-02f, 6.80875257e-02f, -1.99851692e-02f, 3.72732454e-03f, -5.74500533e-03f, -9.78250150e-03f, 9.61302221e-03f,
  1.07663073e-01f, 2.22076550e-01f, 2.91802513e-04f, 1.29023045e-02f, -3.34991664e-02f, -2.46978983e-01f, -1.41869336e-01f, 9.56136137e-02f, 5.53965755e-02f, 6.50180653e-02f,
  -1.07747220e-01f, 1.74051434e-01f, -8.03660303e-02f, -8.08768198e-02f, -1.75749779e-01f, -1.55588910e-01f, -2.06144214e-01f, 7.05138370e-02f, -4.72120792e-02f, -5.10861725e-02f,
  -1.15386210e-01f, -1.26039743e-01f, -8.20956007e-02f, -4.24059527e-03f, 5.73456893e-03f, 8.50143656e-02f, -6.60097674e-02f, -1.52310086e-02f, 9.50626135e-02f, -3.76733392e-03f,
  1.18789673e-02f, 8.63024294e-02f, 1.19739391e-01f, 1.35023585e-02f, -6.36340380e-02f, 5.67251332e-02f, 1.87053345e-02f, 4.27303053e-02f, 6.55994266e-02f, 2.44379742e-03f,
  -3.19179855e-02f, -4.45245020e-02f, -1.57327317e-02f, 1.07719917e-02f, 2.78895348e-02f, 1.18609637e-01f, -5.60228601e-02f, 2.21591834e-02f, -9.29584168e-03f, 2.45492999e-02f,
  -3.99371535e-02f, -6.65366417e-03f, 3.48663284e-03f, 8.97084177e-02f, -1.97942350e-02f, -1.93721727e-02f, 2.94359550e-02f, 4.60308343e-02f, -1.90333426e-02f, 3.74356844e-02f,
  1.69703346e-02f, -5.90542108e-02f, -2.35189609e-02f, 6.94250613e-02f, -7.17745125e-02f, 9.39311385e-02f, -6.43955842e-02f, 1.26672890e-02f, -8.91434401e-02f, -2.57838871e-02f,
  4.48509455e-02f, 5.65446392e-02f, -4.15490046e-02f, 1.76051185e-02f, -6.40537739e-02f, 9.65273827e-02f, -3.49923484e-02f, 7.20572546e-02f, -3.63508314e-02f, 1.32271377e-02f,
  2.97241732e-02f, -7.56138414e-02f, 3.86094786e-02f, -4.84570861e-02f, -7.26869926e-02f, -4.32212166e-02f, 5.07628135e-02f, 1.90606918e-02f, -3.13688219e-02f, -2.50831079e-02f,
  -2.81026512e-02f, -7.68503621e-02f, 9.43989009e-02f, 5.47538511e-02f, 6.85907379e-02f, -8.22331458e-02f, -1.13235861e-01f, -1.49270678e-02f, -9.25603807e-02f, -6.22823387e-02f,
  -2.29157391e-03f, 4.88877632e-02f, -2.91576479e-02f, 5.94830289e-02f, 4.57246713e-02f, 2.96012834e-02f, -3.71296965e-02f, -4.41197418e-02f, -2.16620471e-02f, 5.25580198e-02f,
  -4.36321236e-02f, -4.30228375e-03f, 4.70403321e-02f, 7.65192462e-03f, 5.01324199e-02f, -1.17934430e-02f, 9.96993557e-02f, 2.77055241e-02f, -9.06344652e-02f, 7.17753693e-02f,
  2.01251477e-01f, -5.97427413e-02f, -2.78328389e-01f, -1.45705506e-01f, 1.59534048e-02f, -3.31703156e-01f, -3.75529945e-01f, -1.02331765e-01f, 4.21877727e-02f, -1.91355348e-01f,
  -1.94908664e-01f, 6.45469651e-02f, 4.68205176e-02f, -2.87216425e-01f, 7.09677860e-02f, 7.88557753e-02f, -2.57241398e-01f, -2.03567550e-01f, 6.93019927e-02f, -4.48545404e-02f,
  8.73625204e-02f, -1.10864513e-01f, -2.51071770e-02f, -8.97298567e-03f, -1.81307942e-01f, 7.94354305e-02f, 1.13151670e-01f, -4.46479917e-02f, -1.83963642e-01f, -3.92162725e-02f,
  -5.52125275e-02f, -6.01221696e-02f, -1.75481960e-02f, -5.29683270e-02f, -1.28241563e-02f, -4.36989367e-02f, -2.40248982e-02f, 3.63854133e-02f, -3.09873838e-02f, -1.31326737e-02f,
  -7.15559721e-03f, -1.73669551e-02f, -4.01436910e-02f, 5.99038647e-03f, 5.50040156e-02f, -3.71404849e-02f, -5.36275357e-02f, -2.76183523e-02f, -7.66190886e-02f, 1.13619352e-02f,
  -1.53030887e-01f, -4.44789827e-02f, -6.84443563e-02f, -6.02027252e-02f, 2.34691706e-02f, -9.70364956e-04f, 1.19484244e-02f, 1.90236997e-02f, -5.56060597e-02f, -2.29213573e-02f,
  6.64104149e-03f, 3.53701077e-02f, -9.57129300e-02f, 2.68505849e-02f, -6.13845047e-03f, -4.00296338e-02f, -5.63412309e-02f, -2.69377348e-03f, 3.36577781e-02f, 1.37293190e-02f,
  8.97445017e-04f, 4.14422192e-02f, 9.27677080e-02f, -7.66764656e-02f, -9.27569494e-02f, -1.59749342e-03f, 5.06481119e-02f, 9.76733118e-03f, -2.82305013e-02f, 3.83430347e-02f,
  -1.73304379e-02f, 8.88722204e-03f, -4.67099808e-02f, 1.76856015e-02f, 5.49094453e-02f, -4.23956243e-03f, 4.07148711e-02f, 4.75399569e-02f, -7.36942142e-02f, 1.61236487e-02f,
  -7.55172297e-02f, -8.83285925e-02f, -9.86678302e-02f, -2.61266846e-02f, 5.22526586e-03f, 1.83497984e-02f, 1.78363100e-02f, 5.17117120e-02f, -1.22392908e-01f, -7.21217096e-02f,
  -1.12938963e-01f, 7.94015899e-02f, -3.53868939e-02f, 6.86732680e-03f, -2.49085687e-02f, -7.51225278e-02f, 3.02809123e-02f, 2.78558694e-02f, -6.72072871e-03f, 1.40630668e-02f,
  6.64750636e-02f, 7.58790448e-02f, 6.98460117e-02f, 2.67964378e-02f, -1.15348073e-03f, -1.81767214e-02f, -2.99256444e-02f, 1.58179365e-02f, 4.09621745e-02f, 3.72962421e-03f,
  1.29965886e-01f, -1.48444638e-01f, 4.22024578e-02f, 4.15543206e-02f, -1.00107612e-02f, 6.84870481e-02f, -3.04261837e-02f, -1.44007191e-01f, -4.75853160e-02f, -3.37504745e-02f,
  -4.25715148e-02f, 2.28583422e-02f, 1.31897017e-01f, -2.14160848e-02f, 9.32570994e-02f, 7.52059966e-02f, -3.77910696e-02f, 6.92885593e-02f, 3.02732699e-02f, -1.76380016e-02f,
  -8.21686164e-02f, -8.86438489e-02f, -7.82446787e-02f, -1.00366972e-01f, -7.76320100e-02f, -1.27838165e-01f, 6.88449740e-02f, -2.49085035e-02f, -1.18127791e-02f, -4.43709679e-02f,
  -5.26325703e-02f, -4.31488007e-02f, -6.70032129e-02f, -7.87824839e-02f, -4.26087566e-02f, 6.18039183e-02f, 7.40811974e-02f, 6.44589886e-02f, 4.06115204e-02f, -3.94801982e-02f,
  -8.29597786e-02f, -6.19524345e-02f, 4.58914824e-02f, 5.38089350e-02f, -9.79117006e-02f, 1.53676188e-02f, 7.95465857e-02f, -4.43077944e-02f, -1.03190064e-01f, 3.90349068e-02f,
  -5.70564605e-02f, 9.14848372e-02f, 5.93828447e-02f, -6.03507906e-02f, -5.88474842e-03f, -5.66099174e-02f, -5.50023317e-02f, 7.46498480e-02f, -7.28774965e-02f, 3.38926204e-02f,
  -8.31105486e-02f, -1.97221525e-02f, -6.70209620e-03f, 4.69047613e-02f, 3.56434546e-02f, -6.17887676e-02f, -1.51642552e-03f, 3.35052498e-02f, -7.53489807e-02f, -7.89197385e-02f,
  7.98640549e-02f, -1.73605792e-02f, 7.00490326e-02f, -6.99113980e-02f, 3.98570336e-02f, -6.89355358e-02f, -1.84880439e-02f, -7.63477683e-02f, 4.96691726e-02f, 2.72714291e-02f,
  6.19424134e-02f, -9.64034423e-02f, 9.66376858e-04f, -1.63383707e-02f, 7.10718557e-02f, -8.44459087e-02f, -4.26392704e-02f, 8.19448233e-02f, 1.80899929e-02f, -1.12656271e-02f,
  -2.41544060e-02f, -1.31728992e-01f, 5.20601459e-02f, 1.79039836e-02f, 1.13953045e-02f, 8.70784074e-02f, 3.23571526e-02f, 4.23492007e-02f, -5.30097559e-02f, 3.61669250e-02f,
  -1.95040684e-02f, -1.23207951e-02f, -2.81333756e-02f, 7.75505751e-02f, 1.63818914e-02f, 7.66799971e-02f, -5.83971143e-02f, 8.94410759e-02f, -1.43569967e-04f, 4.80595753e-02f,
  -3.59528735e-02f, -1.25193940e-02f, -4.62558344e-02f, -6.73826262e-02f, -6.55135140e-02f, -5.16372882e-02f, 6.00101091e-02f, -6.47491813e-02f, 1.54725816e-02f, 4.29888479e-02f,
  9.43415519e-03f, -1.16119474e-01f, -9.58931819e-02f, 6.05267473e-02f, 1.41357899e-01f, 1.03789710e-01f, 2.45854836e-02f, 5.76389469e-02f, -9.33535248e-02f, -8.54343176e-02f,
  2.65041292e-02f, 1.34939142e-02f, -3.42323296e-02f, 9.33185071e-02f, 1.04084775e-01f, -1.01774819e-01f, -2.65280660e-02f, -6.61938637e-03f, -2.03605294e-02f, -2.23512687e-02f,
  -7.44457990e-02f, 1.07313745e-01f, -5.75043894e-02f, 1.59218628e-03f, -2.25783177e-02f, 5.43415174e-02f, 7.86851421e-02f, -4.12303256e-03f, 2.03498825e-02f, 4.97325975e-03f,
  -7.54643325e-03f, -4.45961878e-02f, 8.77821222e-02f, 4.16956358e-02f, 6.47160560e-02f, 2.36773212e-02f, 8.25896412e-02f, -4.90055233e-03f, -3.88296507e-02f, -6.52055591e-02f,
  1.71975717e-02f, -3.91564034e-02f, -9.37488768e-03f, -2.95836758e-02f, -5.52320480e-02f, 3.27716093e-03f, -3.57627124e-02f, 7.23533183e-02f, 4.74458151e-02f, 4.66031432e-02f,
  -5.93560785e-02f, -7.96461850e-02f, 4.44726534e-02f, 3.20752151e-03f, 6.83983266e-02f, -6.99168965e-02f, 9.48830973e-04f, 1.10085486e-02f, 5.13377711e-02f, 5.58343269e-02f,
  -6.91180751e-02f, -5.88089637e-02f, 7.36429468e-02f, 2.15955246e-02f, -3.58953439e-02f, 6.96061924e-02f, 1.24027887e-02f, -2.32360233e-02f, 8.05056095e-02f, -6.00182898e-02f,
  -1.89405419e-02f, -6.76826015e-02f, -5.37498333e-02f, 4.12211418e-02f, 9.65596177e-03f, -4.62380052e-02f, -5.00505827e-02f, -1.41986199e-02f, -8.70632529e-02f, -8.32175836e-02f,
  5.41356616e-02f, 5.61245345e-02f, -6.35552406e-02f, -7.00650588e-02f, -3.22569795e-02f, 2.66781654e-02f, 4.18577865e-02f, 5.92190214e-02f, -8.43193978e-02f, -6.23358227e-03f,
  -3.87156568e-02f, -1.41828051e-02f, -7.43698031e-02f, 1.36707528e-02f, 8.07178095e-02f, 8.17008466e-02f, 7.57103637e-02f, 5.72223961e-02f, -4.64756042e-02f, -8.52999315e-02f,
  -2.04974264e-02f, -6.76608905e-02f, -6.46358076e-03f, 1.74818803e-02f, 2.47762003e-03f, -5.85355759e-02f, -5.38772605e-02f, 2.33571939e-02f, -5.97137213e-02f, 2.30344161e-02f,
  -8.29405114e-02f, -1.05825132e-02f, 3.24222520e-02f, -2.44833715e-02f, 3.66418175e-02f, 2.07527243e-02f, -6.69364706e-02f, 2.60349680e-02f, 2.92767659e-02f, 1.67254210e-02f,
  9.37176123e-02f, 1.95692107e-02f, -3.15265208e-02f, -1.50231626e-02f, -5.97156920e-02f, -9.06347260e-02f, 4.42678705e-02f, 1.50532909e-02f, -9.61687267e-02f, 1.68324113e-02f,
  1.10978596e-02f, -2.57286541e-02f, 2.09364444e-02f, -6.06818944e-02f, 6.39241263e-02f, -5.64184822e-02f, 5.72987944e-02f, -3.90671045e-02f, -1.02491803e-01f, 4.61055618e-03f,
  5.32343378e-03f, 6.54523522e-02f, -1.83210410e-02f, 9.47874710e-02f, 5.91791747e-03f, 4.79553603e-02f, 4.08697166e-02f, 8.56750309e-02f, 5.46481758e-02f, 4.29693498e-02f,
  3.67115550e-02f, -3.52474079e-02f, -7.45324790e-03f, 2.69691721e-02f, -6.24877997e-02f, -2.64230762e-02f, -5.43181933e-02f, 5.77578805e-02f, 6.41911104e-02f, -6.21532239e-02f,
  -1.61866248e-02f, -9.35520753e-02f, 7.38499463e-02f, 1.03927301e-02f, -6.32551461e-02f, -6.37039244e-02f, 3.65668791e-03f, -1.90103520e-02f, -5.32403700e-02f, -2.37664528e-04f,
  6.57633767e-02f, -9.32871271e-03f, 3.19512025e-03f, 9.43507999e-02f, -2.19719484e-02f, -3.45486104e-02f, 6.32903948e-02f, 8.02677050e-02f, -3.44753154e-02f, 2.13888497e-03f,
  6.75730631e-02f, -1.60731133e-02f, -6.30434006e-02f, 7.83993118e-03f, 4.91002612e-02f, -1.59036051e-02f, -9.96328238e-03f, -3.77546549e-02f, -2.33506248e-03f, -1.79658830e-02f,
  -2.99002565e-02f, 7.98878074e-03f, 4.35529798e-02f, 3.73077691e-02f, -1.55815678e-02f, -2.29853075e-02f, 6.20489717e-02f, -5.77495024e-02f, -4.44535818e-03f, -1.25125116e-02f,
  3.73038910e-02f, -5.33049889e-02f, 7.88300857e-02f, 1.39796827e-03f, 5.23916706e-02f, 4.04555760e-02f, -4.84029911e-02f, -5.00881784e-02f, -2.81418557e-03f, 2.55265050e-02f,
  7.69249797e-02f, 9.20572970e-03f, -6.85511250e-03f, 3.27937044e-02f, -5.02733029e-02f, -5.87391816e-02f, -3.82757522e-02f, 5.84397800e-02f, 8.76595229e-02f, 3.51655413e-03f,
  9.31646302e-02f, 1.01316750e-01f, -5.48754521e-02f, 8.49907994e-02f, 2.99225952e-02f, 5.05982749e-02f, -2.58718152e-02f, 4.59405966e-02f, 6.74400032e-02f, -3.82771865e-02f,
  1.11687079e-01f, 7.92411342e-02f, 7.45672360e-02f, 7.35725183e-03f, 8.10722727e-03f, -3.04892771e-02f, 5.06093614e-02f, 9.68736317e-03f, -3.15820687e-02f, 5.70749342e-02f,
  1.69479162e-01f, 4.47366722e-02f, 1.94285080e-01f, 1.48674250e-01f, -7.56125450e-02f, -1.33748874e-02f, 4.27815728e-02f, -7.64897122e-05f, 7.49983788e-02f, -3.88799310e-02f,
  -1.17610097e-01f, 1.84423611e-01f, -2.66917963e-02f, 7.74091259e-02f, -1.61266237e-01f, -1.21396661e-01f, 5.03229955e-03f, 1.50844641e-02f, 7.09036663e-02f, 7.89812803e-02f,
  -6.71416670e-02f, -2.29137361e-01f, 9.45096985e-02f, -1.28400981e-01f, 1.89514607e-01f, 1.27088040e-01f, -1.21555291e-01f, -1.42462859e-02f, -5.46958521e-02f, -2.28637252e-02f,
  2.03443766e-02f, -1.87457763e-02f, 1.34184994e-02f, -4.66646329e-02f, -5.13438284e-02f, 5.73053434e-02f, -8.70357379e-02f, 4.29202628e-04f, -7.63720460e-03f, -5.09211235e-02f,
  6.23972267e-02f, 3.30444276e-02f, 7.64143318e-02f, -5.11029921e-02f, 2.77990405e-03f, -2.39601098e-02f, 3.21537666e-02f, 8.91289636e-02f, 8.69690850e-02f, 8.29865932e-02f,
  -6.35974063e-03f, 5.11199608e-02f, -7.22421482e-02f, 4.50127721e-02f, -5.03845364e-02f, 7.86271021e-02f, 4.39166613e-02f, 8.09407905e-02f, 3.51369753e-02f, 1.83605570e-02f,
  6.96496516e-02f, -6.78137988e-02f, 8.53265971e-02f, -4.93905880e-02f, 2.13757288e-02f, 1.68805309e-02f, -2.24109441e-02f, -5.68039678e-02f, 7.54511803e-02f, -1.55133959e-02f,
  5.28087951e-02f, -1.67801920e-02f, 6.03011586e-02f, -1.25568211e-02f, 8.53347257e-02f, -1.72360311e-03f, 2.53460035e-02f, -4.07392085e-02f, 3.02332845e-02f, 3.48291025e-02f,
  -4.04232666e-02f, 4.44829762e-02f, 6.55567870e-02f, 9.37243775e-02f, 7.75475353e-02f, 7.68987238e-02f, -5.23886271e-02f, 1.34790272e-01f, -4.68616113e-02f, -4.82827574e-02f,
  -1.82372555e-01f, -7.32697099e-02f, -2.07022186e-02f, 2.68095471e-02f, -4.22136262e-02f, -3.18579338e-02f, -2.99164886e-03f, 5.78713715e-02f, -9.67392325e-03f, 2.13544816e-02f,
  3.52543890e-02f, -3.42873670e-02f, 2.54458777e-04f, -5.11510596e-02f, 3.28546972e-04f, -3.39888334e-02f, 3.98393944e-02f, -5.90814538e-02f, -9.96441022e-02f, 1.87715271e-03f,
  2.58591063e-02f, -8.49887542e-03f, 5.61399944e-02f, 6.59283623e-02f, -5.97868627e-03f, 4.63995337e-02f, -2.43238565e-02f, 2.61069797e-02f, 4.85424325e-03f, -5.34344241e-02f,
  4.41967100e-02f, -2.54099909e-02f, 1.40493870e-01f, 2.35353541e-02f, 8.08991715e-02f, 1.66177139e-01f, 1.56772330e-01f, 2.30096523e-02f, 3.50836851e-02f, -6.87742457e-02f,
  -6.86864182e-02f, 9.76027399e-02f, 1.30345657e-01f, 1.82214491e-02f, 7.12922961e-02f, 8.60036165e-02f, 4.10470441e-02f, 4.90256101e-02f, 7.01483339e-02f, -8.28969702e-02f,
  -5.68886660e-02f, -8.74267071e-02f, 1.04657307e-01f, -9.44504216e-02f, 6.80457801e-02f, -7.51142800e-02f, -5.38707711e-02f, 7.38892630e-02f, -1.34539917e-01f, 1.26558784e-02f,
  4.37560230e-02f, 8.80475938e-02f, 8.91497582e-02f, 1.72834174e-04f, 6.15713373e-02f, -4.38547321e-02f, 4.53317091e-02f, 7.90326223e-02f, 1.00494243e-01f, -7.15359449e-02f,
  -9.92938876e-04f, 1.70654170e-02f, -1.94536690e-02f, -4.24054228e-02f, -6.82157725e-02f, -7.51122087e-02f, -7.60433003e-02f, -3.24086361e-02f, -3.78312021e-02f, -4.55984809e-02f,
  5.11204265e-03f, 5.38665317e-02f, 3.22033465e-02f, -2.30171252e-02f, -4.14738357e-02f, 7.00993091e-02f, 3.52506479e-03f, 5.57571128e-02f, -1.88791361e-02f, 3.33186537e-02f,
  -5.63560612e-02f, -9.97224357e-03f, -1.25121260e-02f, -4.49397936e-02f, 2.45148037e-02f, -2.10286565e-02f, 2.54250150e-02f, 5.99612901e-03f, -5.90610355e-02f, 9.14192423e-02f,
  -4.01891917e-02f, 5.84589094e-02f, -1.69324614e-02f, 4.35276255e-02f, -1.04807250e-01f, -6.74269423e-02f, -4.27315105e-03f, -1.23121198e-02f, 8.11570063e-02f, -7.44671002e-02f,
  -1.02645874e-01f, 5.56634851e-02f, 2.09670467e-03f, 4.28262651e-02f, 4.67318334e-02f, -5.81564121e-02f, -3.76302539e-03f, 5.73652834e-02f, -2.79832110e-02f, 6.23757839e-02f,
  -2.51678079e-02f, -6.87668100e-04f, 2.13511679e-02f, 3.76405865e-02f, -1.11997891e-02f, -5.61755002e-02f, 5.12276068e-02f, -6.73909336e-02f, -2.36501154e-02f, -7.71322567e-03f,
  -1.87504049e-02f, -6.67967019e-04f, 5.89225255e-02f, 1.95953529e-02f, -1.46778300e-02f, -3.94890495e-02f, -3.18923593e-02f, 4.05300781e-02f, 6.51463121e-02f, 7.30515197e-02f,
  -4.67160419e-02f, 4.34713364e-02f, -5.03431372e-02f, 3.66137289e-02f, -6.40017465e-02f, 6.36706352e-02f, -7.77793601e-02f, 4.26287912e-02f, 8.99206474e-03f, -4.22949530e-02f,
  8.11845958e-02f, 2.33002543e-01f, 1.23800643e-01f, 1.95969254e-01f, -1.37911633e-01f, -2.30721638e-01f, -2.10201845e-01f, 9.31699295e-03f, 2.56076418e-02f, 4.13417406e-02f,
  -1.60872787e-02f, 1.90255851e-01f, 1.45963104e-02f, -1.88010652e-02f, 1.38704166e-01f, -7.20794946e-02f, 4.41974364e-02f, -7.20169842e-02f, 1.74632482e-02f, 7.98556730e-02f,
  1.20770454e-01f, -5.28360456e-02f, 2.04783514e-01f, 1.31412283e-01f, -3.62200774e-02f, 1.63191751e-01f, 1.08362176e-02f, -8.97972006e-03f, 4.52295467e-02f, 3.16902101e-02f,
  -1.01956710e-01f, -9.60680395e-02f, 5.27223013e-02f, 4.63811867e-02f, 8.13753605e-02f, -4.46366891e-02f, -2.11412795e-02f, -4.06836718e-02f, 1.21135592e-01f, -4.54916731e-02f,
  2.29607467e-02f, 8.96730050e-02f, -3.72897014e-02f, -4.76515517e-02f, -5.61257862e-02f, 3.67021561e-03f, -3.40577587e-02f, 3.06356195e-02f, 6.04843609e-02f, 1.01302616e-01f,
  1.71972066e-02f, 1.88715365e-02f, 3.90210152e-02f, 6.65197074e-02f, -3.25203277e-02f, -1.00001059e-02f, -7.12418510e-03f, -3.32975648e-02f, -1.24660239e-03f, 1.05082080e-01f,
  8.75453278e-03f, -4.32686880e-02f, 5.99025423e-03f, 8.73876065e-02f, 6.84089959e-02f, 1.64805818e-02f, -2.66754422e-02f, 3.60679999e-02f, -6.10055253e-02f, 7.39600956e-02f,
  5.87465800e-03f, -1.40916640e-02f, 3.44241560e-02f, -4.62772418e-03f, -1.40946088e-02f, 7.19049424e-02f, -6.29433291e-03f, -8.99683312e-02f, 3.70377041e-02f, 7.61628449e-02f,
  -1.48544079e-02f, 5.78627847e-02f, 7.72610977e-02f, -7.35047087e-02f, 4.10969146e-02f, 2.88141686e-02f, -5.04488163e-02f, 4.21919599e-02f, 8.03471953e-02f, 1.28343953e-02f,
  6.01026714e-02f, 1.06395386e-01f, -3.15687433e-02f, -5.25617599e-03f, -1.91693455e-02f, 9.81300771e-02f, -4.35671546e-02f, 6.19870722e-02f, 1.17995068e-01f, 5.33062480e-02f,
  -4.99571953e-03f, -8.10815468e-02f, -5.43960519e-02f, 4.10543866e-02f, 3.23729664e-02f, -2.36456469e-03f, 6.54974729e-02f, -1.32930931e-02f, -7.52795041e-02f, 3.33847769e-04f,
  3.37255411e-02f, -9.59150493e-02f, 8.35651234e-02f, 4.52810004e-02f, 6.49027973e-02f, -1.36404648e-01f, -9.37907249e-02f, -5.35166822e-02f, 7.64370942e-03f, 5.74458838e-02f,
  1.21823013e-01f, -2.30715182e-02f, 3.25778089e-02f, -8.43053684e-03f, -3.84110287e-02f, -1.16522893e-01f, 2.30905376e-02f, 1.49688460e-02f, 5.29617891e-02f, 1.63770299e-02f,
  -8.32266062e-02f, -1.50806475e-02f, -9.40440819e-02f, 8.48037675e-02f, 3.02643850e-02f, -9.95262638e-02f, 7.59555548e-02f, -9.26813204e-03f, 7.75780454e-02f, 8.56382474e-02f,
  8.37681890e-02f, 2.35055629e-02f, -9.07869488e-02f, -2.66877431e-02f, -5.27621731e-02f, -7.82852322e-02f, -6.21688552e-02f, -1.03782741e-02f, -4.04852740e-02f, -5.29548861e-02f,
  -3.15575227e-02f, -3.51053551e-02f, 3.71945985e-02f, 5.82891330e-02f, -2.02082638e-02f, -6.48959354e-02f, -4.28744443e-02f, -8.18581432e-02f, 4.11111105e-04f, 5.60252070e-02f,
  8.49883109e-02f, 9.84794833e-03f, 1.03186093e-01f, -5.43712117e-02f, 6.80741966e-02f, 5.88407777e-02f, 6.18131757e-02f, -1.09464869e-01f, 7.15478323e-04f, 5.07871518e-05f,
  -6.15317561e-02f, 7.20154718e-02f, 4.94134836e-02f, 1.38263460e-02f, -5.07510640e-02f, -9.10399631e-02f, 2.93085556e-02f, 6.00803532e-02f, -6.79493025e-02f, -5.53091057e-02f,
  3.68415900e-02f, 1.35766808e-02f, -5.24147451e-02f, -8.63278285e-02f, -2.52190717e-02f, -1.06466478e-02f, 2.23548003e-02f, 1.01624869e-01f, 4.55744080e-02f, -3.21592093e-02f,
  -1.04002832e-02f, -8.66885558e-02f, -3.93453762e-02f, 6.29034266e-02f, 3.54812890e-02f, 5.43753989e-02f, 9.01369750e-02f, -6.58517107e-02f, 3.80549096e-02f, 4.41109911e-02f,
  -1.12312734e-02f, 2.06052307e-02f, -8.09409693e-02f, -4.74532275e-03f, 6.59141392e-02f, -5.77101707e-02f, 8.82464573e-02f, 2.02546120e-02f, 1.05848476e-01f, 5.78670874e-02f,
  4.29650024e-02f, 6.68763518e-02f, 2.00532079e-02f, 7.88364783e-02f, 3.18017043e-02f, 8.79034121e-03f, -2.64942609e-02f, 7.99508765e-02f, -5.46686538e-03f, -6.57811761e-02f,
  -1.14558795e-02f, 5.51468506e-02f, 4.98963296e-02f, 3.83323319e-02f, 3.52177478e-04f, -7.62427077e-02f, -9.77460146e-02f, -1.05216652e-02f, 8.69936347e-02f, 2.80716140e-02f,
  -5.76256253e-02f, 3.82155133e-03f, -9.12062533e-04f, -6.17208369e-02f, 1.22375317e-01f, 6.10706806e-02f, 4.07336839e-02f, 4.47832905e-02f, 1.98990609e-02f, -6.52817562e-02f,
  1.76542029e-02f, -1.01516349e-02f, -9.37926993e-02f, 2.89872549e-02f, 4.99722958e-02f, 2.55376175e-02f, -3.39267142e-02f, 4.70426381e-02f, -3.88485417e-02f, -5.46373986e-02f,
  1.15294810e-02f, -2.76659448e-02f, -1.98830143e-02f, -8.57343674e-02f, 1.92289222e-02f, -6.62877411e-02f, 1.00065082e-01f, -1.51587985e-02f, -6.86695054e-02f, 2.41090283e-02f,
  4.96057943e-02f, -3.15564498e-03f, 4.58791032e-02f, 4.02861573e-02f, 4.14234661e-02f, 6.65218830e-02f, 1.28718615e-01f, 1.40336836e-02f, 1.03166491e-01f, 1.17894471e-01f,
  -6.64117113e-02f, 3.07277702e-02f, 6.85950518e-02f, -2.18295939e-02f, -6.00103401e-02f, -2.01202631e-02f, -4.00674790e-02f, -3.78068932e-03f, -6.16392978e-02f, -1.80583410e-02f,
  -5.04368916e-02f, -6.68859035e-02f, -2.02840865e-02f, 3.36005427e-02f, -2.51318514e-02f, -3.90837677e-02f, -6.51971204e-03f, 5.80161177e-02f, -1.44963979e-03f, -2.38989387e-02f,
  -2.03152075e-02f, -2.41937935e-02f, -4.69020754e-03f, -6.18896484e-02f, 1.45203294e-02f, -2.32078154e-02f, 8.15151259e-02f, 4.82959896e-02f, 2.07270235e-02f, 4.64603975e-02f,
  -1.33660370e-02f, 2.29957551e-02f, -5.74286319e-02f, 2.93920115e-02f, -1.04783438e-01f, -5.73041998e-02f, 1.23002619e-01f, 7.91413058e-03f, 3.80398519e-02f, -8.15043747e-02f,
  6.32797480e-02f, -3.94878425e-02f, 7.33895004e-02f, -1.00502513e-01f, -6.95542023e-02f, -1.48415081e-02f, 2.56436002e-02f, -9.73066129e-03f, -7.36805350e-02f, -2.57183071e-02f,
  1.29751787e-02f, 2.75184810e-02f, -3.21520269e-02f, 8.80758390e-02f, -5.50219156e-02f, -1.75293144e-02f, 1.43809691e-02f, -3.11201848e-02f, -2.00624205e-02f, -4.15833257e-02f,
  -3.82207334e-02f, -2.70900037e-02f, 4.54513030e-03f, 2.38110051e-02f, 6.96777925e-02f, -1.28680781e-01f, 8.03951398e-02f, -2.09609177e-02f, 2.24484876e-02f, 2.39106193e-02f,
  -2.91539561e-02f, -2.73034032e-02f, 8.82789642e-02f, 5.72342463e-02f, -1.61185339e-02f, 4.06759121e-02f, -3.30369882e-02f, -3.43673117e-02f, 1.81879066e-02f, -4.70150188e-02f,
  -7.11105764e-02f, -1.20060764e-01f, 4.55685928e-02f, 1.09839872e-01f, -5.15668616e-02f, 6.08557761e-02f, -1.16699571e-02f, 5.40504120e-02f, -2.13787779e-02f, 7.15119690e-02f,
  -1.66332033e-02f, -1.35979608e-01f, -3.21283415e-02f, -1.18660657e-02f, 5.34603931e-02f, -5.52544044e-03f, 7.49520883e-02f, -1.31344097e-02f, -3.98729695e-03f, -1.15290530e-01f,
  -6.18767738e-02f, -5.40320463e-02f, -9.43164453e-02f, -7.71060437e-02f, 1.08313128e-01f, -2.95060016e-02f, 3.33089824e-03f, -8.67088214e-02f, -3.79437371e-03f, -1.00297868e-01f,
  -5.74767590e-02f, -3.04466896e-02f, 4.32039984e-02f, 1.08693995e-01f, 2.88650822e-02f, 1.07003324e-01f, 4.04363535e-02f, 8.99253115e-02f, 8.42686445e-02f, -4.48965505e-02f,
  -1.22133279e-02f, -1.00206397e-01f, 1.30796190e-02f, -9.90248285e-03f, 5.97320683e-03f, 1.51877990e-02f, 2.19218358e-02f, 5.90034612e-02f, 4.29727286e-02f, 7.84378052e-02f,
  1.11630209e-01f, -8.23067036e-03f, -1.28052263e-02f, 5.86640239e-02f, 7.32653067e-02f, -3.20476517e-02f, 6.31517768e-02f, -1.11035556e-01f, 4.54155952e-02f, 3.56916897e-02f,
  -1.00393623e-01f, 5.25722541e-02f, 4.17297333e-02f, -8.66823271e-02f, 2.28226651e-02f, 7.67315924e-02f, 8.71426687e-02f, 8.36566165e-02f, 2.06526406e-02f, 1.46707008e-02f,
  1.02228470e-01f, -7.00021163e-02f, -2.34141927e-02f, 2.50704512e-02f, 6.85393512e-02f, -1.14275971e-02f, -2.02956703e-02f, 5.72379753e-02f, -4.51579727e-02f, -3.16488855e-02f,
  1.12702057e-01f, 8.69031847e-02f, -5.04151247e-02f, -4.38438058e-02f, 1.64706949e-02f, -6.79875584e-03f, -9.02723521e-02f, -8.27478021e-02f, 6.32491335e-02f, 3.21932882e-02f,
  -2.42245407e-03f, -7.66948331e-03f, -6.74299449e-02f, -2.50883158e-02f, 1.92177389e-02f, 2.75095273e-02f, -1.99012198e-02f, 3.64207588e-02f, 7.55328834e-02f, -4.89305407e-02f,
  2.32097749e-02f, -7.13980421e-02f, -1.81487333e-02f, -1.68689769e-02f, -5.70038185e-02f, 1.82429608e-02f, -3.01898867e-02f, 6.79193363e-02f, 3.95680256e-02f, -5.92866391e-02f,
  -6.98374659e-02f, 8.76218900e-02f, -2.22975737e-03f, -6.56303540e-02f, -7.35516846e-02f, -6.30976930e-02f, 1.82539318e-02f, -6.93692118e-02f, 1.60751306e-02f, 7.70804062e-02f,
  -6.27588257e-02f, -1.92424990e-02f, -9.04440135e-03f, -2.16869805e-02f, 2.39725225e-02f, 3.83380838e-02f, -6.38820454e-02f, -7.48356506e-02f, -4.23709601e-02f, -1.01710474e-02f,
  -5.75670041e-02f, 9.36342180e-02f, -2.31681123e-01f, 4.00786735e-02f, -6.79728761e-02f, 4.93365638e-02f, 3.55499201e-02f, 3.41895223e-02f, -7.82321617e-02f, 1.27362356e-01f,
  8.43312219e-02f, -5.00039421e-02f, -3.83186303e-02f, 2.20578432e-01f, 3.34330164e-02f, -3.39234509e-02f, 1.85880199e-01f, 1.74461931e-01f, -1.09558679e-01f, 1.34984851e-01f,
  -6.17748946e-02f, 2.66956657e-01f, 1.13569722e-01f, 1.67415276e-01f, -2.77481135e-03f, -9.16532651e-02f, 1.84102848e-01f, 7.40550691e-03f, 2.19496772e-01f, 4.21946943e-02f,
  -1.84194520e-02f, 3.38709727e-02f, 1.90220203e-03f, -8.06758478e-02f, -1.86643675e-02f, -5.70429154e-02f, -5.93183972e-02f, -2.80530211e-02f, -5.89914806e-02f, 1.84744075e-02f,
  -3.52283590e-04f, 2.85258368e-02f, 2.98669399e-03f, -1.76607594e-02f, -5.35465293e-02f, -5.16064987e-02f, 4.92181666e-02f, 7.21763149e-02f, 4.19242643e-02f, -3.71952765e-02f,
  5.41157462e-03f, 1.12305479e-02f, 1.56727079e-02f, -1.31012261e-01f, 1.97254885e-02f, 5.48774041e-02f, 7.73683041e-02f, -3.70434746e-02f, 9.46659409e-03f, -1.53391967e-02f,
  -6.69239536e-02f, 6.01864494e-02f, 5.05488627e-02f, 4.44856957e-02f, 3.65806185e-02f, -2.25433763e-02f, 7.21697062e-02f, -7.68017694e-02f, -8.02147537e-02f, 6.99453875e-02f,
  1.37569783e-02f, 1.61645245e-02f, -4.05388363e-02f, 6.33119780e-05f, 6.08309768e-02f, 6.09187558e-02f, -4.15002890e-02f, 6.41672348e-04f, 7.98960403e-03f, 2.87060086e-02f,
  -5.52961044e-02f, -5.88793680e-03f, 8.02411512e-02f, 3.69707756e-02f, -5.56496298e-03f, 2.38421559e-02f, 4.93715256e-02f, 3.74379605e-02f, -8.55806191e-03f, 2.13422291e-02f,
  1.04571432e-01f, -1.13788657e-02f, -6.81813657e-02f, -2.32279096e-02f, -1.87050831e-02f, 7.05790594e-02f, 7.33511001e-02f, -1.95831377e-02f, -1.21840090e-02f, -5.63033670e-02f,
  -1.43716456e-02f, 5.72268665e-02f, -1.43079152e-02f, 3.97985242e-02f, -2.32141726e-02f, -8.18951894e-03f, 5.70090115e-02f, 1.80878062e-02f, 8.44905376e-02f, 3.60031724e-02f,
  1.73344817e-02f, -6.52280822e-02f, 6.54135197e-02f, 4.71273772e-02f, 4.38406765e-02f, 5.17937057e-02f, -3.21213380e-02f, 5.64940348e-02f, -1.07867243e-02f, 4.66467924e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  -6.41894015e-03f, 1.06045797e-01f, 1.13885058e-03f, 6.72092736e-02f, 5.34561276e-02f, 9.83973593e-02f, -3.69721279e-02f, -5.31068351e-03f, 2.97477376e-02f, 9.00898427e-02f,
  5.00749983e-02f, -4.00903523e-02f, 2.71954760e-02f, -5.73936999e-02f, -5.57914330e-03f, -4.37803753e-02f, 1.04310988e-02f, 1.00106597e-01f, -1.06100384e-02f, 3.06410640e-02f,
  1.25000834e-01f, 3.58671248e-02f, -1.98910721e-02f, 2.40070540e-02f, 1.62650123e-02f, 1.67410389e-01f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.31032586e-02f, 4.06696275e-02f, -4.52039717e-03f, -1.47162434e-02f, -5.02994321e-02f, -9.56795886e-02f, 4.09551635e-02f, -1.07086107e-01f, 7.29660168e-02f, -3.64549421e-02f,
  -1.15439974e-01f, 3.34570035e-02f, -3.69213931e-02f, -3.51789445e-02f, -9.32866782e-02f, 1.65273964e-01f, 6.90468624e-02f, 2.96976995e-02f, -1.59831360e-01f, -1.35708123e-01f,
  2.43596546e-02f, -1.61157802e-01f, 3.70756956e-03f, -1.08709641e-01f, 2.18759567e-01f, 6.15781993e-02f, 3.89692523e-02f, 1.54503360e-01f, -2.49641299e-01f, -8.03590752e-03f,
  -1.83462369e-04f, -1.46474198e-01f, 5.64354882e-02f, 3.14594284e-02f, -1.79261118e-01f, -9.66622010e-02f, 1.36333600e-01f, 1.85401499e-01f, 1.15956143e-01f, -1.64933299e-04f,
  7.65368789e-02f, -1.87472165e-01f, -6.84176609e-02f, -2.57411093e-01f, 7.10985810e-02f, 4.17286195e-02f, -1.22593313e-01f, 8.79063457e-02f, -7.84318149e-03f, 1.07218243e-01f,
  3.18921953e-02f, 9.92596447e-02f, 1.06273644e-01f, 4.06442843e-02f, 1.40408009e-01f, 5.76113202e-02f, -3.17707844e-02f, 1.67593122e-01f, 1.73447043e-01f, 1.02793172e-01f,
  -1.93066373e-02f, -1.30135762e-02f, 5.39013296e-02f, -1.93209067e-01f, 1.17844939e-01f, 4.76273037e-02f, -7.03642443e-02f, 1.17006421e-01f, 4.96201292e-02f, -2.85879951e-02f,
  4.59255725e-02f, 1.85457394e-01f, -4.40538563e-02f, 4.62636538e-02f, 3.05578928e-03f, 4.68375459e-02f, 1.84379369e-01f, -1.02909327e-01f, -4.89284061e-02f, -6.45275190e-02f,
  -1.51137011e-02f, 1.29999295e-01f, -1.15966937e-02f, -4.29835767e-02f, 5.23403846e-02f, -4.26320508e-02f, 1.23784319e-02f, 7.27947727e-02f, 9.87877548e-02f, -1.22033946e-01f,
  -2.03593135e-01f, -8.62847716e-02f, -4.73992340e-02f, -1.18042529e-01f, -1.76486179e-01f, 1.18495241e-01f, -1.48179933e-01f, -4.24092896e-02f, 1.07545808e-01f, 5.67595474e-02f,
  1.18106864e-01f, 1.38956413e-01f, 5.81467710e-02f, -1.06013358e-01f, 1.45396680e-01f, -1.17641978e-01f, 2.82632764e-02f, -1.82789922e-01f, 1.35289326e-01f, -1.19381920e-02f,
  -1.63796649e-03f, -8.75443891e-02f, 2.03115612e-01f, 4.15772498e-02f, -1.65944397e-01f, 6.31378544e-03f, 4.78553176e-02f, -3.07261199e-01f, 9.01041180e-02f, -6.25541657e-02f,
  1.35013863e-01f, 1.83894426e-01f, 1.56340078e-02f, 1.54980943e-01f, 1.72420397e-01f, 5.29546440e-02f, 1.05611637e-01f, -1.26756638e-01f, -5.60315140e-02f, 6.66522309e-02f,
  1.13572806e-01f, 2.22555939e-02f, 1.32750243e-01f, -1.35985790e-02f, -1.09764170e-02f, -8.10059234e-02f, -3.02415472e-02f, 9.61456820e-02f, 1.87668689e-02f, -7.48967528e-02f,
  -1.16136536e-01f, -1.54712841e-01f, -6.45653903e-02f, 5.36936708e-02f, -8.82302523e-02f, 1.15353078e-01f, -2.00914666e-02f, -7.13024735e-02f, 1.68058589e-01f, -1.17113955e-01f,
  -7.17602670e-02f, 5.74950390e-02f, 1.11864194e-01f, 9.77895781e-02f, -2.83769630e-02f, 1.00669928e-01f, 1.05450131e-01f, -1.56629249e-01f, 1.44243792e-01f, -7.85320923e-02f,
  4.83993394e-03f, -6.62888512e-02f, -1.68306351e-01f, -1.76967103e-02f, -1.29363135e-01f, 1.87481314e-01f, -8.53596702e-02f, -1.25687242e-01f, 1.43612579e-01f, -1.17252588e-01f,
  -7.41711184e-02f, -9.45949554e-02f, 6.89545041e-03f, -1.75424237e-02f, -1.34539753e-01f, 1.32020652e-01f, -7.98462406e-02f, 6.46642074e-02f, -5.34008816e-02f, -1.16381116e-01f,
  3.40289101e-02f, -1.54664055e-01f, 1.38698429e-01f, 1.16576262e-01f, 3.49407420e-02f, -6.53158948e-02f, -5.49679971e-04f, -4.05117460e-02f, -5.46821989e-02f, 6.00373186e-02f,
  1.25459075e-01f, 6.33822680e-02f, -8.05032626e-02f, 3.43934074e-02f, -1.51112065e-01f, -9.44474339e-02f, -2.38688737e-02f, 4.08852957e-02f, -1.53139494e-02f, -7.96870962e-02f,
  -1.20571908e-03f, 7.09922239e-02f, -4.57872599e-02f, 1.47926705e-02f, 3.89440134e-02f, 8.49649757e-02f, 2.68219020e-02f, 6.28024489e-02f, 8.85187984e-02f, 1.05774635e-02f,
  -3.73869352e-02f, 4.57924381e-02f, 1.51367649e-01f, 3.33175473e-02f, 3.66622768e-02f, 1.08958758e-01f, 1.43865809e-01f, -1.64256975e-01f, -3.02867917e-03f, -2.83693075e-02f,
  -1.26069590e-01f, 4.39274758e-02f, 3.26884873e-02f, 1.56335995e-01f, -1.82359174e-01f, 4.26024571e-03f, -5.22727482e-02f, -3.60005088e-02f, -1.79567672e-02f, 2.80409485e-01f,
  1.29366517e-01f, 6.12307973e-02f, 3.92751768e-02f, -1.37643501e-01f, 7.67039210e-02f, -1.09826244e-01f, -1.72809828e-02f, -9.04985443e-02f, -4.24069241e-02f, 2.77053062e-02f,
  1.60927877e-01f, -3.56535949e-02f, -6.24995306e-03f, 1.04434729e-01f, 8.94925520e-02f, 8.52727219e-02f, 6.66227192e-02f, -1.15145594e-02f, -1.10008374e-01f, 1.07733337e-02f,
  -5.66931404e-02f, 1.14180960e-01f, 1.33301005e-01f, 2.60089375e-02f, 9.49106142e-02f, -5.78197949e-02f, -8.88140202e-02f, 1.03292465e-01f, -4.22768369e-02f, -9.77172330e-02f,
  1.32753864e-01f, 1.73582867e-01f, -2.07116380e-01f, 5.40504642e-02f, 5.08915447e-02f, -4.80927378e-02f, 8.17179307e-02f, -1.37520884e-03f, -4.98568900e-02f, -9.30979624e-02f,
  1.08262748e-01f, -1.95658449e-02f, 6.55262843e-02f, 1.05907097e-01f, 2.60183550e-02f, 1.99441183e-02f, 1.22840300e-01f, -8.28448385e-02f, -4.85492088e-02f, -4.34928909e-02f,
  4.91482057e-02f, -1.12209417e-01f, 1.75453156e-01f, -7.91568682e-02f, 1.00874670e-01f, 3.44645828e-02f, 1.62548408e-01f, -7.32175708e-02f, 1.17996857e-02f, -3.79933082e-02f,
  -1.17788754e-01f, 5.62945865e-02f, -2.27372721e-01f, -1.34197742e-01f, 3.53537239e-02f, 1.40496016e-01f, -5.22808870e-04f, 1.84118092e-01f, 7.17941299e-02f, 1.87586322e-01f,
  4.20260727e-02f, 8.57118964e-02f, 1.66032370e-02f, -1.36436731e-01f, 2.97681093e-02f, -6.53173849e-02f, 1.22698126e-02f, -8.90760198e-02f, -1.77422658e-01f, 5.90388551e-02f,
  5.36331534e-02f, 4.40272968e-03f, -9.44259986e-02f, -1.94299296e-01f, 7.38837197e-02f, -1.41503513e-01f, -4.71462086e-02f, -8.63582417e-02f, 2.74875071e-02f, 8.39466229e-02f,
  1.27458900e-01f, 7.55894035e-02f, 2.45647691e-02f, 3.98495123e-02f, 7.83663541e-02f, 1.03762060e-01f, -3.39879431e-02f, 4.85001467e-02f, -3.36786509e-02f, -3.58013101e-02f,
  -1.54862637e-02f, 1.06627578e-02f, -2.03671977e-02f, -3.80849019e-02f, 3.54686156e-02f, 4.70571406e-02f, 8.69722068e-02f, -7.60357082e-02f, -2.69353837e-02f, -3.61885247e-03f,
  4.63687927e-02f, 7.93163478e-02f, -1.27337752e-02f, -1.25492001e-02f, 9.29181948e-02f, -7.04997629e-02f, 1.15647137e-01f, -2.41908524e-02f, 4.96029593e-02f, -1.09161168e-01f,
  -1.11329466e-01f, -1.46897910e-02f, -4.85639088e-02f, -2.76851486e-02f, 1.02511957e-01f, 6.98532015e-02f, -4.16423194e-02f, -9.94685367e-02f, -2.20074803e-02f, -6.77053481e-02f,
  -8.93410370e-02f, 4.90495451e-02f, 3.80037129e-02f, 9.32080746e-02f, -1.32935792e-01f, 8.35258514e-02f, -1.67248279e-01f, -1.92077793e-02f, 9.55761597e-02f, 1.27240540e-02f,
  -1.27602234e-01f, 1.21863112e-02f, 8.63487795e-02f, 4.92039919e-02f, -1.17758811e-01f, 4.91430834e-02f, -7.24908290e-03f, -3.16382051e-02f, -6.82705119e-02f, -8.38651136e-02f,
  3.10154613e-02f, 1.23626202e-01f, 1.25556573e-01f, 2.29193941e-02f, -2.30483972e-02f, -3.47533040e-02f, -1.47527128e-01f, -1.08400479e-01f, -1.55074429e-02f, -1.63912311e-01f,
  -1.33478358e-01f, 3.14920209e-02f, -1.09164603e-01f, 8.74738842e-02f, 1.02545068e-01f, 1.17768683e-02f, -1.06261969e-01f, 1.73623133e-02f, 6.53932840e-02f, -6.49219826e-02f,
  -2.00357474e-02f, 8.31899866e-02f, 2.69201975e-02f, 1.25021622e-01f, 1.36550382e-01f, -5.76307997e-03f, 1.16796814e-01f, 1.19797334e-01f, -1.95712835e-01f, -1.79582074e-01f,
  7.90996253e-02f, -1.06003791e-01f, 1.06639393e-01f, 6.72428086e-02f, -1.26373619e-01f, 1.50516137e-01f, -6.69705495e-02f, 2.48783603e-02f, 1.77431017e-01f, 1.40148222e-01f,
  3.06147225e-02f, 4.29694392e-02f, 8.87117907e-02f, 2.16778144e-01f, 1.52242705e-01f, 8.50842595e-02f, -9.19919014e-02f, 1.28769809e-02f, 1.16530191e-02f, -7.09891766e-02f,
  -1.64652810e-01f, -2.16649268e-02f, -5.75937070e-02f, 3.15257348e-02f, -2.13126436e-01f, 2.13463739e-01f, -9.48824808e-02f, -8.01542550e-02f, -5.73063120e-02f, 8.59104991e-02f,
  -1.16440933e-02f, -2.27670446e-01f, -6.69843256e-02f, 2.70962995e-02f, 1.33179769e-01f, 5.81383556e-02f, -1.22704268e-01f, 1.96850300e-01f, -3.17785926e-02f, -8.15463886e-02f,
  1.96155936e-01f, 2.97810007e-02f, 1.14109283e-02f, 1.61195189e-01f, -9.30649638e-02f, -4.10941169e-02f, 7.70716090e-03f, -1.19605146e-01f, 1.23419546e-01f, 1.25372573e-03f,
  6.67708218e-02f, 1.18697077e-01f, -7.28853047e-02f, 1.90773845e-01f, -6.54324442e-02f, -3.11083421e-02f, 1.14742719e-01f, -1.03470579e-01f, -3.99497971e-02f, -1.23293668e-01f,
  -1.38166532e-01f, -1.03545845e-01f, -1.08114645e-01f, 1.58613428e-01f, 6.95412681e-02f, -7.26172328e-02f, 8.91943872e-02f, 6.55359179e-02f, 1.19438106e-02f, -1.17472731e-01f,
  1.74247205e-01f, 4.73408028e-02f, -5.87260760e-02f, -3.79699208e-02f, -8.54284093e-02f, -2.82436639e-01f, 8.34574327e-02f, 1.40620656e-02f, 2.01185197e-02f, 2.07110383e-02f,
  1.97673310e-02f, 8.89843777e-02f, -1.70543000e-01f, -3.09017655e-02f, -1.43897757e-02f, -2.60363333e-02f, -8.02148357e-02f, 1.69896856e-02f, 1.49249405e-01f, -3.34980190e-02f,
  1.33378059e-01f, 1.41190216e-01f, -1.30608648e-01f, -1.23196304e-01f, 8.85649174e-02f, 1.22508742e-01f, -7.21575543e-02f, -4.68743481e-02f, -1.17864192e-01f, 5.66552728e-02f,
  -1.03214756e-01f, 8.60322043e-02f, 1.77157149e-02f, -1.18543714e-01f, 5.63761070e-02f, 3.77368964e-02f, 6.74762428e-02f, 7.81483650e-02f, 1.08456537e-01f, -9.66095626e-02f,
  1.05375119e-01f, -1.41996101e-01f, 1.95892490e-02f, 1.01418793e-03f, -1.18801869e-01f, 8.74427962e-04f, 2.74073258e-02f, 1.97159722e-01f, 6.37405068e-02f, -1.51599735e-01f,
  -5.28922044e-02f, -1.67913750e-01f, 7.22714737e-02f, 9.50756893e-02f, -2.30192617e-02f, 1.31156787e-01f, 9.25985277e-02f, -5.95788807e-02f, -3.38390991e-02f, 1.71817198e-01f,
  -4.44489680e-02f, -9.68808029e-03f, 1.02826478e-02f, -1.36317283e-01f, 3.27919014e-02f, 8.29463676e-02f, -8.32757056e-02f, -1.72856823e-01f, 9.40395817e-02f, 3.09360325e-02f,
  -7.22046271e-02f, -3.70617211e-02f, -1.14393704e-01f, 1.04341563e-02f, -1.03529841e-01f, -1.75097331e-01f, -4.10169587e-02f, 1.72634784e-03f, 9.36642736e-02f, 6.40984103e-02f,
  -1.02010608e-01f, -9.69218742e-03f, 9.74285677e-02f, 2.53523737e-02f, 2.07790911e-01f, 9.27632302e-02f, 9.18680355e-02f, -1.70709398e-02f, -1.90849043e-02f, 1.70448527e-01f,
  -4.46101613e-02f, 1.34709641e-01f, -6.02100557e-03f, 8.00542627e-03f, 9.94122252e-02f, -1.00012869e-01f, -8.68447274e-02f, -5.64627461e-02f, -2.59201117e-02f, -1.51827618e-01f,
  -1.09626710e-01f, 4.40517440e-03f, -2.61467136e-02f, 3.08479592e-02f, 1.70784667e-02f, 4.81336862e-02f, -2.32887715e-02f, -1.29131675e-02f, -6.94757774e-02f, -8.14943761e-02f,
  -1.16338357e-01f, 4.82282974e-02f, 7.19746575e-03f, -4.98446636e-03f, -5.49609475e-02f, -1.04492567e-01f, -4.43236530e-02f, -1.48158640e-01f, -8.78280252e-02f, 1.23253800e-01f,
  4.52614804e-05f, -6.80831820e-02f, 1.22800693e-01f, 1.35949031e-01f, 5.44028617e-02f, -8.07292387e-02f, 3.66545990e-02f, -1.43635914e-01f, -1.50612183e-02f, 9.87977311e-02f,
  -1.55945674e-01f, 7.75977597e-02f, 4.48383577e-02f, -6.79947734e-02f, 6.98249564e-02f, 9.70361680e-02f, 4.73460332e-02f, -1.44295003e-02f, 3.55367288e-02f, -4.64666374e-02f,
  -6.98095784e-02f, -6.05863868e-04f, 2.11552471e-01f, 8.96124169e-02f, -1.08097665e-01f, 6.53401166e-02f, 2.17591494e-01f, -5.46642244e-02f, 8.71097296e-02f, 2.80054808e-01f,
  -5.86720780e-02f, -3.49291116e-02f, 5.78157678e-02f, -1.10271692e-01f, -4.27582785e-02f, -3.89085221e-03f, -2.87377164e-02f, -1.41214684e-01f, -1.08501287e-02f, 1.39131611e-02f,
  -6.24050871e-02f, -5.19120321e-02f, -9.22865495e-02f, 8.05646703e-02f, -2.81678215e-02f, -7.13842586e-02f, -1.32134765e-01f, 8.00473318e-02f, 3.24997008e-02f, -5.42276129e-02f,
  7.35734627e-02f, -2.86261570e-02f, -1.58622295e-01f, 6.76643178e-02f, -1.47589296e-02f, -1.35561556e-01f, 7.87076801e-02f, 8.10474902e-02f, -4.76551615e-02f, 1.00230880e-01f,
  2.75613874e-01f, -7.18110055e-02f, 1.59744546e-02f, 7.73534253e-02f, 1.32961065e-01f, -2.14331359e-01f, 1.19534872e-01f, 1.05946645e-01f, -5.62012149e-03f, 1.23331286e-02f,
  1.32598519e-01f, 6.66944832e-02f, -1.22397542e-01f, 1.34879917e-01f, -1.75114647e-01f, 8.70014876e-02f, -1.97295383e-01f, 2.48841107e-01f, -6.59864247e-02f, -4.38294709e-02f,
  -2.81195790e-02f, -6.34897919e-03f, 9.98825952e-03f, 1.21946089e-01f, 5.45242913e-02f, -1.29425630e-01f, -3.20865437e-02f, -1.24488339e-01f, 1.06536351e-01f, -9.88602191e-02f,
  3.67123671e-02f, 6.88140914e-02f, -1.48998186e-01f, 2.03416534e-02f, 1.13945410e-01f, 9.05557647e-02f, 1.35024831e-01f, 2.51719188e-02f, 1.51742682e-01f, -1.57457199e-02f,
  -8.77242628e-03f, 1.19625628e-02f, -2.41417438e-02f, 8.91932324e-02f, 7.04916492e-02f, -5.57037927e-02f, 2.06375867e-01f, -5.74235097e-02f, 9.44376215e-02f, -7.15798587e-02f,
  9.75397676e-02f, -1.59541052e-02f, -1.98419169e-02f, -2.78085284e-03f, -9.63238925e-02f, -5.48712760e-02f, 7.78321326e-02f, 9.13765877e-02f, -5.40200025e-02f, 2.28809826e-02f,
  5.49765117e-02f, 5.28678894e-02f, 5.20668477e-02f, -1.20426089e-01f, -5.73084764e-02f, -1.17984451e-02f, -3.58676538e-02f, -1.19232073e-01f, -9.44240540e-02f, 1.86307088e-01f,
  -6.52181506e-02f, -8.93061757e-02f, -4.22895998e-02f, -9.00316425e-03f, -1.89282019e-02f, -8.04452077e-02f, -7.36190453e-02f, -1.27126545e-01f, -5.81648899e-03f, -8.14170316e-02f,
  -8.20138026e-03f, 2.51008365e-02f, -2.82989498e-02f, -1.75371334e-01f, -1.14944518e-01f, -7.53918812e-02f, -3.93699482e-02f, -2.36516550e-01f, 2.25058440e-02f, 1.01281531e-01f,
  3.59640177e-03f, 3.31356004e-02f, -2.18383614e-02f, -1.04463629e-01f, -3.29546481e-02f, -4.67232391e-02f, 1.70028403e-01f, 6.88057616e-02f, 1.08909376e-01f, -2.04250943e-02f,
  -1.10268608e-01f, 1.51276261e-01f, 2.47694924e-02f, -1.57209307e-01f, 9.25680399e-02f, -6.25332668e-02f, 7.99896643e-02f, -6.20312504e-02f, -3.46720517e-02f, -1.61577277e-02f,
  -1.16829770e-02f, 5.84400706e-02f, -1.08246077e-02f, 1.49862453e-01f, -9.65734422e-02f, 8.72536004e-02f, -4.21010926e-02f, -1.02627516e-01f, 1.04308896e-01f, -2.16972306e-02f,
  -1.03435412e-01f, 6.29853830e-02f, -2.65589915e-02f, 4.08739783e-02f, -5.45537770e-02f, -6.77374704e-03f, 9.06210169e-02f, 7.95833468e-02f, -5.03279418e-02f, 6.39008358e-02f,
  6.72832653e-02f, 2.75471415e-02f, -2.21151441e-01f, 1.90822423e-01f, 3.51863243e-02f, -1.40878707e-01f, 6.97632283e-02f, 1.53032899e-01f, -9.34859067e-02f, 3.36474180e-02f,
  1.49355292e-01f, -8.69900919e-03f, 7.52421543e-02f, 3.88187431e-02f, 9.54251066e-02f, -2.71071434e-01f, -1.56984031e-01f, 5.83421439e-02f, -2.05670640e-01f, -6.32658154e-02f,
  1.54632539e-01f, -2.79182699e-02f, 3.05671934e-02f, 9.66509208e-02f, 4.52093817e-02f, 1.11813173e-01f, -1.65526599e-01f, -5.11899143e-02f, 4.45906669e-02f, 1.48977693e-02f,
  1.67282701e-01f, 2.72336334e-01f, 7.17216730e-02f, 4.54337746e-02f, -8.82567838e-02f, -1.05785355e-01f, -1.16566285e-01f, 4.36961949e-02f, -1.28809944e-01f, 6.79977122e-04f,
  -1.47768989e-01f, 2.04630613e-01f, 8.47436711e-02f, 1.08926736e-01f, -5.39305210e-02f, -5.95635884e-02f, -1.34490961e-02f, -1.16703451e-01f, 1.17783844e-01f, -7.40820989e-02f,
  -1.23515129e-01f, 1.09957755e-01f, 6.51675612e-02f, -1.07609928e-01f, 7.69966766e-02f, 8.97895843e-02f, 6.94520548e-02f, -4.83561866e-02f, 5.90249291e-03f, -3.86935882e-02f,
  7.99545050e-02f, -3.82631868e-02f, -2.24354044e-02f, -6.11669831e-02f, -6.59674257e-02f, -4.59391735e-02f, 1.02980006e-02f, -6.92780614e-02f, 2.99048349e-02f, -1.49895474e-01f,
  4.23137806e-02f, 1.70971945e-01f, -9.18513387e-02f, 1.22089356e-01f, -1.31261468e-01f, 6.16305508e-02f, 1.08453877e-01f, -6.22919854e-03f, 1.17998958e-01f, -7.22665116e-02f,
  -1.28582045e-01f, 8.15177932e-02f, -7.05743432e-02f, -5.72691001e-02f, 1.08872307e-02f, 2.41560657e-02f, -1.01458728e-01f, -5.20330891e-02f, 1.86369270e-01f, 8.55886266e-02f,
  -1.23443797e-01f, 1.36292741e-01f, -4.79209237e-02f, 1.46976739e-01f, 1.83207929e-01f, 1.83633149e-01f, -5.54002784e-02f, -1.88422389e-02f, 2.08005570e-02f, 1.33860931e-01f,
  -1.19935006e-01f, 1.43769294e-01f, 6.12930916e-02f, -7.31991455e-02f, -1.07940719e-01f, 1.50186151e-01f, 1.22647785e-01f, 4.62263525e-02f, 1.87018469e-01f, 5.14311902e-02f,
  -5.56661077e-02f, -1.51680231e-01f, 3.98748182e-02f, -1.81015693e-02f, -6.93259165e-02f, -1.04010239e-01f, 9.42841023e-02f, 5.51619418e-02f, 6.18307739e-02f, -1.27283573e-01f,
  9.65737551e-02f, 1.12205513e-01f, -6.59179315e-02f, -1.33151864e-03f, 6.82649165e-02f, -5.39639629e-02f, -1.74582213e-01f, 1.02223411e-01f, -2.59724278e-02f, 2.33457386e-02f,
  -6.49018139e-02f, 2.11002380e-02f, -1.04471287e-02f, 5.06281853e-02f, -7.12902546e-02f, -4.35441583e-02f, 4.78150360e-02f, -1.34056106e-01f, -6.59569129e-02f, -1.71199158e-01f,
  3.86975892e-02f, -1.56181186e-01f, 1.51812091e-01f, 6.60487711e-02f, -3.99081074e-02f, -6.13056198e-02f, -1.15787014e-01f, -4.22902107e-02f, 1.20113790e-02f, -2.73667902e-01f,
  4.16919030e-02f, -3.26231867e-02f, -2.55903956e-02f, 5.63495196e-02f, 1.59803573e-02f, -3.02071404e-02f, -1.33319259e-01f, -1.14077747e-01f, 2.11446464e-01f, 1.13588065e-01f,
  -5.06592095e-02f, -1.74575876e-02f, -7.18485713e-02f, 1.25928104e-01f, 6.24525324e-02f, 1.38866268e-02f, -1.09412208e-01f, -5.04797548e-02f, -1.11065127e-01f, -1.10746793e-01f,
  -6.39922842e-02f, 1.05297305e-01f, -2.22708546e-02f, 1.46551341e-01f, 9.28960443e-02f, -3.33391055e-02f, 1.51790857e-01f, -6.62719132e-03f, 3.54233906e-02f, -4.50236350e-02f,
  1.48200535e-03f, 1.47565395e-01f, -8.44010338e-03f, 4.95406948e-02f, -5.86215314e-03f, 7.14708194e-02f, -5.96592799e-02f, 1.75041035e-01f, -1.16811275e-01f, -4.88068834e-02f,
  1.07763745e-01f, 1.88891590e-02f, 5.86886369e-02f, -5.43798972e-03f, 2.01106802e-01f, -1.16579965e-01f, -1.19293213e-01f, 8.84349644e-02f, -1.48645286e-02f, 6.95553720e-02f,
  -1.07205898e-01f, 1.63962200e-01f, -1.26708612e-01f, -8.05803612e-02f, -4.56693992e-02f, 7.20804483e-02f, 5.40376976e-02f, 2.00030446e-01f, 3.17454264e-02f, -1.84544444e-01f,
  6.99446797e-02f, -2.31327713e-02f, -1.26267031e-01f, -3.39762494e-02f, 1.43486217e-01f, -1.14542410e-01f, -1.39971197e-01f, -8.88086185e-02f, 1.61794469e-01f, 2.93376576e-02f,
  -2.35175997e-01f, -3.31517793e-02f, 8.39081034e-02f, -2.84480035e-01f, 3.65841761e-02f, 1.21513478e-01f, -3.14930193e-02f, 4.85963654e-03f, 6.75276071e-02f, 4.58811000e-02f,
  5.30764870e-02f, 1.11203074e-01f, 1.36817291e-01f, -8.07755440e-03f, 3.24536152e-02f, 7.98485801e-02f, 9.81798247e-02f, 2.04235855e-02f, -3.97436433e-02f, -1.64953396e-01f,
  -1.27606645e-01f, -2.84010395e-02f, -1.07056096e-01f, -1.12588570e-01f, 4.90133511e-03f, -8.38363320e-02f, -3.98245342e-02f, 5.44285662e-02f, 1.25712715e-02f, 4.97048208e-03f,
  -1.86108593e-02f, 7.74067789e-02f, -2.53808947e-04f, -7.38827810e-02f, -1.24344625e-01f, 7.68317953e-02f, -2.46251784e-02f, -1.06910609e-01f, -6.83661699e-02f, 2.34278925e-02f,
  7.67167434e-02f, -6.48892969e-02f, -1.38784677e-01f, -3.46711725e-02f, -1.55956924e-01f, -1.52815640e-01f, -1.70599259e-02f, -1.22667275e-01f, 2.92400625e-02f, -1.32117629e-01f,
  1.22477688e-01f, -1.17901996e-01f, -6.30210564e-02f, 6.08919263e-02f, -1.36772273e-02f, -2.81994045e-02f, 3.46688405e-02f, -6.15434013e-02f, -2.73029376e-02f, 2.35555153e-02f,
  -9.57181156e-02f, -9.71661583e-02f, -1.27152145e-01f, -1.08713973e-02f, 3.67244445e-02f, -3.80689166e-02f, 1.53969973e-01f, -6.55008778e-02f, -7.30675682e-02f, 5.83664328e-02f,
  6.67869896e-02f, 1.56341612e-01f, 9.06188115e-02f, 6.82402626e-02f, 8.77538603e-03f, 6.40917420e-02f, -5.62601350e-03f, -5.25375605e-02f, 5.98241277e-02f, -1.39782995e-01f,
  1.30083814e-01f, 6.93441480e-02f, 1.47702366e-01f, -4.49311547e-02f, -3.68892564e-03f, -1.99706614e-01f, 8.99442360e-02f, 6.45946525e-03f, -8.39566160e-03f, 3.11944205e-02f,
  -9.92881283e-02f, -1.35867894e-01f, 1.04229688e-03f, 7.24384263e-02f, -5.05777374e-02f, 1.14156259e-02f, -3.48074101e-02f, -1.06403776e-01f, -1.00024253e-01f, 1.59949005e-01f,
  -5.27247116e-02f, -7.22902566e-02f, 4.53625843e-02f, 1.57811016e-01f, -2.17115041e-02f, -1.20600583e-02f, 1.97543427e-02f, 1.28934950e-01f, 3.43181007e-02f, -2.47754246e-01f,
  -5.09387180e-02f, -1.01853706e-01f, -1.20489419e-01f, -1.55836463e-01f, -6.17259042e-03f, -1.91763788e-01f, -1.54515058e-01f, 2.63262317e-02f, 4.05209772e-02f, -1.15651675e-01f,
  1.43553466e-01f, -9.37793776e-02f, -4.78600562e-02f, -5.67939319e-02f, 1.75558135e-01f, 6.75464049e-02f, -1.36685610e-01f, 1.69418938e-03f, 1.05929151e-01f, -1.85673863e-01f,
  1.83898315e-01f, 1.27994746e-01f, 7.82155469e-02f, 3.42061408e-02f, -1.14191860e-01f, 9.17877257e-02f, 6.91035539e-02f, -8.47243425e-03f, 6.20023832e-02f, -9.54102352e-02f,
  9.72024277e-02f, -1.28527403e-01f, 1.87684149e-01f, -1.05630808e-01f, -1.65589582e-02f, 1.29189432e-01f, -1.67264372e-01f, -2.53130514e-02f, 1.04660215e-02f, -9.05232877e-02f,
  -5.22432029e-02f, -8.42637271e-02f, 9.88678783e-02f, 1.71636615e-03f, 3.43822651e-02f, -5.75199462e-02f, 3.23107094e-03f, 7.95320645e-02f, 2.85744332e-02f, 7.81487301e-02f,
  6.33871090e-03f, -1.64937317e-01f, -1.86078906e-01f, 1.68915465e-01f, 1.34576842e-01f, 6.00603549e-03f, -1.62965879e-02f, 7.74545968e-02f, -6.50917813e-02f, -8.14590380e-02f,
  -1.97961539e-01f, 6.30255416e-02f, -1.95140973e-01f, 7.20736310e-02f, -1.15797170e-01f, -9.35839489e-02f, 1.76255718e-01f, 2.23743860e-02f, 2.19958305e-01f, 1.45923570e-01f,
  -9.21055004e-02f, -7.63832685e-03f, 1.31967276e-01f, -1.38281837e-01f, -1.10637747e-01f, -2.48031750e-01f, 1.16506316e-01f, -9.73892659e-02f, -1.11014105e-01f, 2.28858180e-02f,
  -1.06527731e-01f, 3.08138952e-02f, -1.95116669e-01f, 1.30081072e-01f, 5.54050766e-02f, -6.92097619e-02f, 8.51586908e-02f, -1.07748225e-01f, 1.04440734e-01f, 1.44431233e-01f,
  -6.85992911e-02f, 1.69552192e-01f, -6.89891055e-02f, 1.27117604e-01f, -2.64175218e-02f, -5.92771545e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -9.80223939e-02f, 9.76257771e-02f, -1.11763351e-01f, 7.49654770e-02f, -1.20686956e-01f, 7.44412169e-02f, -9.79905501e-02f, 1.34093286e-02f, 2.96114795e-02f, -8.11157227e-02f,
  -9.56237987e-02f, -6.77194446e-02f, -2.04508211e-02f, 4.97933552e-02f, -7.96197951e-02f, -1.26312956e-01f, -1.81528311e-02f, -6.35025203e-02f, -1.63493939e-02f, -7.87225217e-02f,
  6.33547381e-02f, -9.13184136e-02f, -8.60217437e-02f, 1.69193279e-02f, 1.02818713e-01f, 1.61818396e-02f, -4.76828180e-02f, 9.64823738e-02f, 8.04158077e-02f, 6.98504373e-02f,
  -8.87196437e-02f, -1.83190238e-02f, 9.46546569e-02f, -3.90898883e-02f, 7.55707622e-02f, -2.81824283e-02f, -1.18253171e-01f, -1.14849210e-01f, 8.35719481e-02f, 6.83615208e-02f,
  -6.78422302e-02f, 1.67258941e-02f, 5.95473684e-02f, 6.46740347e-02f, -7.20919222e-02f, -9.06194523e-02f, 1.74626112e-02f, 9.04352814e-02f, -1.20475277e-01f, 1.16601996e-01f,
  -1.98804978e-02f, 6.30252287e-02f, -5.53749502e-02f, -1.24031659e-02f, -8.12797025e-02f, 7.77027532e-02f, -6.01587892e-02f, -7.39822090e-02f, -1.87722617e-03f, 1.04793973e-01f,
  -2.02198494e-02f, 8.43399316e-02f, -4.41889428e-02f, 7.96804503e-02f, -4.17726953e-03f, -8.45462531e-02f, -3.59256715e-02f, 6.65238351e-02f, -1.28089279e-01f, -1.25425398e-01f,
  9.79796574e-02f, -6.41872585e-02f, -1.21758878e-01f, 5.85385300e-02f, 1.13581322e-01f, -4.59160618e-02f, 8.45001265e-02f, -6.80078864e-02f, 5.93550019e-02f, 4.50256234e-03f,
  5.91486767e-02f, -1.05398856e-01f, -1.08318239e-01f, -1.15999743e-01f, -5.75955994e-02f, 2.12741666e-03f, -7.44065717e-02f, 7.93783516e-02f, -3.22809480e-02f, -1.13948852e-01f,
  6.54054135e-02f, 2.05983184e-02f, -6.85957298e-02f, -1.01975158e-01f, 1.27992019e-01f, -2.56320294e-02f, 5.28652929e-02f, -2.26922166e-02f, -7.66869336e-02f, -4.26979456e-03f,
  -5.72383776e-02f, 3.94447744e-02f, -2.48077102e-02f, -4.65733605e-03f, -3.36636454e-02f, -7.85863474e-02f, 1.23150483e-01f, -5.80234714e-02f, -5.22999056e-02f, 5.23411483e-02f,
  -4.45425697e-02f, 1.26999235e-02f, 8.72384757e-02f, 2.53327880e-02f, 4.89070453e-02f, -4.63560559e-02f, -5.40780574e-02f, 5.20541780e-02f, -2.43710708e-02f, 1.57469511e-02f,
  3.71772908e-02f, -9.95472446e-02f, -1.34852052e-01f, 2.62882989e-02f, 8.29668790e-02f, -1.14810206e-01f, -9.70318988e-02f, -8.62319246e-02f, 7.10599273e-02f, 8.38598832e-02f,
  1.83143411e-02f, 9.12633687e-02f, -7.85600841e-02f, -9.40687582e-03f, -4.29386869e-02f, -6.44021779e-02f, -9.56807658e-02f, 1.39433280e-01f, 1.06206559e-01f, -5.26202247e-02f,
  1.43483311e-01f, 3.75976898e-02f, 1.01167791e-01f, 1.43038360e-02f, 1.30337238e-01f, -6.02002479e-02f, -6.24672845e-02f, -5.69272693e-03f, -1.19242817e-01f, -1.05148844e-01f,
  5.55201545e-02f, 7.74601474e-02f, -3.72384749e-02f, -9.41480622e-02f, 1.60567854e-02f, -7.03490600e-02f, -1.87461581e-02f, -2.00854614e-02f, -1.58715621e-01f, -5.50953187e-02f,
  -4.85301875e-02f, 8.32985714e-02f, 1.25982910e-01f, 9.48252063e-03f, 5.78191876e-02f, 5.30324504e-02f, 1.48514763e-01f, 6.54397011e-02f, 1.34377286e-01f, 5.54618575e-02f,
  6.89360052e-02f, 1.00732878e-01f, -4.86679114e-02f, -6.15667813e-02f, -9.10770744e-02f, -1.23781107e-01f, 9.83940363e-02f, 1.26971871e-01f, 5.11294045e-02f, 1.24220550e-01f,
  3.79865132e-02f, -3.11236223e-03f, -7.20010102e-02f, -8.53707641e-02f, 9.95375440e-02f, 1.10942116e-02f, 6.47596866e-02f, 9.34586972e-02f, 1.23167388e-01f, 1.11806899e-01f,
  -3.46218348e-02f, -2.55692620e-02f, -5.01820222e-02f, -7.53247142e-02f, 1.18368715e-01f, -7.33371126e-04f, -1.07810743e-01f, -1.19198136e-01f, -1.31347496e-02f, -4.28822339e-02f,
  -1.04978293e-01f, 6.96587637e-02f, -2.76093297e-02f, 6.40257075e-03f, 3.78038622e-02f, -2.75359396e-02f, -6.02457952e-03f, 8.94713104e-02f, 1.33305192e-01f, -9.97432098e-02f,
  -8.94163102e-02f, -6.82466701e-02f, 4.89529818e-02f, 8.09694454e-02f, -1.07047148e-01f, 5.15951291e-02f, -7.79551268e-02f, -1.14757486e-01f, -1.78511012e-02f, -6.13874719e-02f,
  5.18292971e-02f, 9.49171931e-03f, 9.93232876e-02f, 6.03719801e-02f, -1.02985455e-02f, 1.50197838e-02f, -7.77940676e-02f, 1.23930641e-01f, -1.77552644e-02f, 1.40204504e-01f,
  1.06602624e-01f, -6.78885877e-02f, -3.94824632e-02f, 9.87161919e-02f, -6.02216050e-02f, -9.72426459e-02f, -6.40220493e-02f, -7.23463222e-02f, -1.13078184e-01f, -3.88396457e-02f,
  1.94662120e-02f, -5.82051203e-02f, 7.79012740e-02f, -7.95996413e-02f, -9.72401127e-02f, -1.47357378e-02f, 7.63866007e-02f, -6.13280497e-02f, 1.10784516e-01f, -5.55608310e-02f,
  5.11066429e-02f, -8.34336281e-02f, 1.09642647e-01f, 6.18439689e-02f, -9.22826380e-02f, 1.19124003e-01f, 5.41526303e-02f, 1.25080496e-01f, 5.96141778e-02f, 9.82580259e-02f,
  -3.53434160e-02f, 1.17100984e-01f, -1.05777733e-01f, -9.90084931e-02f, -6.05086312e-02f, -5.09627797e-02f, 4.15205061e-02f, 7.23157153e-02f, 3.67861474e-03f, 6.39547184e-02f,
  -3.98750901e-02f, 6.32806355e-03f, 3.80264260e-02f, 1.07979923e-01f, 3.46547877e-03f, 5.08039221e-02f, -1.24963187e-01f, 8.54258910e-02f, -3.55793089e-02f, 6.76604435e-02f,
  -1.36654228e-01f, -6.84922189e-02f, -4.12484370e-02f, -2.59239990e-02f, 9.62092951e-02f, 1.44530848e-01f, -5.31109162e-02f, -1.22448064e-01f, -7.52516091e-02f, 3.59790437e-02f,
  4.87371385e-02f, -4.55732904e-02f, -7.45213851e-02f, -6.49305880e-02f, 3.23489197e-02f, -4.43578698e-02f, -1.23173393e-01f, 4.77128103e-02f, -2.16092914e-02f, -6.33300748e-04f,
  -7.01838434e-02f, 7.84803182e-02f, 1.63291842e-01f, -1.00387059e-01f, -4.61643115e-02f, -1.10577166e-01f, 9.25637707e-02f, -6.25408590e-02f, 9.84743461e-02f, 1.56455949e-01f,
  -3.21867168e-02f, 6.31619617e-02f, 6.80177053e-03f, -7.28857936e-03f, 4.00162302e-02f, -3.15000303e-02f, -2.70309690e-02f, 1.18638137e-02f, -9.96754095e-02f, 1.28176898e-01f,
  6.36789128e-02f, -1.95283815e-02f, 4.82769981e-02f, 1.46635696e-02f, 3.30737606e-02f, -3.99150364e-02f, 6.18163012e-02f, 1.33767202e-01f, -2.50896066e-02f, -7.97208995e-02f,
  1.30911069e-02f, 8.98606256e-02f, 8.10109451e-02f, -6.22860529e-02f, 9.57928412e-03f, 3.92068885e-02f, -3.42705660e-02f, -1.55084729e-02f, -8.00100565e-02f, -8.13132375e-02f,
  -6.87025487e-02f, -1.34886265e-01f, 4.96207476e-02f, 1.16147630e-01f, -3.96991568e-03f, 7.83869624e-02f, 9.63624865e-02f, 1.06428728e-01f, 3.24414037e-02f, -5.33032082e-02f,
  3.72120626e-02f, -3.82948667e-02f, -6.86560385e-03f, -1.14156336e-01f, 9.68119055e-02f, -1.17053382e-01f, -5.93208782e-02f, -3.10405847e-02f, 1.04869880e-01f, -5.42796515e-02f,
  -7.16818571e-02f, -1.21412925e-01f, -1.10801704e-01f, -2.97354683e-02f, -3.84673513e-02f, 5.21720350e-02f, -4.86536361e-02f, 6.28203452e-02f, -4.04202528e-02f, -1.14427336e-01f,
  -7.61276111e-02f, 6.93241805e-02f, 8.57150257e-02f, -7.49228969e-02f, 2.08217427e-02f, 2.90603861e-02f, 1.16214886e-01f, -1.19561208e-02f, 1.62521824e-02f, 9.82707068e-02f,
  9.31086391e-02f, 1.12913549e-01f, -1.65825132e-02f, -9.39520299e-02f, 1.44837275e-01f, 1.05330363e-01f, -4.65963222e-03f, 1.26026750e-01f, -6.58699647e-02f, 3.94810997e-02f,
  1.75480336e-01f, 6.76837489e-02f, 4.90723923e-02f, -5.35732396e-02f, -2.09162431e-03f, 4.55512516e-02f, 8.47402290e-02f, 1.26584664e-01f, 4.74771671e-02f, 9.07290801e-02f,
  2.60693394e-02f, 1.30260780e-01f, 1.32378221e-01f, 8.31448957e-02f, -6.68681487e-02f, -3.99782183e-03f, 3.90548036e-02f, 7.18081370e-02f, 2.61564571e-02f, 1.13321587e-01f,
  -8.29700679e-02f, 5.41438023e-03f, -2.33565837e-01f, -1.91401988e-02f, -4.78130300e-03f, -6.17995225e-02f, -6.88271504e-03f, -1.20048255e-01f, 7.52009824e-02f, 5.35005294e-02f,
  8.96919519e-02f, 1.34502396e-01f, -6.94888551e-03f, -6.10568151e-02f, -1.76749956e-02f, -6.19771294e-02f, -6.70716166e-02f, -1.43911213e-01f, 2.75154226e-02f, -7.74700120e-02f,
  -1.06284298e-01f, 1.40689477e-01f, 1.45616174e-01f, 1.37480378e-01f, -4.86690216e-02f, 1.71476565e-02f, 5.05296998e-02f, -6.67950511e-02f, -8.88679475e-02f, 4.96661216e-02f,
  -9.81138572e-02f, 1.20831817e-01f, 1.49142668e-01f, 1.88736320e-01f, 1.55879125e-01f, -2.77200602e-02f, -4.89798896e-02f, 2.11441834e-02f, -9.24696177e-02f, 5.60523830e-02f,
  7.98891708e-02f, 9.41921324e-02f, 8.39384347e-02f, -4.82632359e-03f, -1.19390428e-01f, 1.26066029e-01f, 8.45351741e-02f, 1.22953039e-02f, 1.43730074e-01f, 1.21595651e-01f,
  -1.43610030e-01f, 3.56627745e-03f, 6.13802597e-02f, 7.94321373e-02f, 1.23344958e-01f, -2.96608880e-02f, 2.51140185e-02f, -1.76489860e-01f, 1.77720025e-01f, 8.48086327e-02f,
  1.58436149e-01f, 9.09511298e-02f, 1.22567125e-01f, -8.87852013e-02f, 8.79896656e-02f, 5.43809310e-02f, 1.69006556e-01f, 1.63300056e-02f, 2.07075536e-01f, 9.23448354e-02f,
  -9.04631540e-02f, 1.62172377e-01f, -8.01339597e-02f, 9.91235971e-02f, -1.21268824e-01f, 1.96862340e-01f, 2.09864341e-02f, 1.83691517e-01f, -7.25874081e-02f, -4.73823585e-02f,
  6.19829707e-02f, -2.00355109e-02f, 5.05270320e-04f, 6.39493614e-02f, 2.12340683e-01f, -7.50325471e-02f, -4.09439243e-02f, 7.52239153e-02f, 1.90484107e-01f, -8.84966459e-03f,
  -1.17454313e-01f, 2.76126713e-01f, 1.87501714e-01f, 1.20477937e-01f, -7.99038038e-02f, -8.81806538e-02f, -7.39783570e-02f, 6.55944049e-02f, 4.02188720e-03f, 6.06402643e-02f,
  -1.95808392e-02f, 4.53408994e-02f, 1.52279511e-01f, 3.34101245e-02f, 1.19811306e-02f, 1.15235940e-01f, 1.81392089e-01f, 1.23514727e-01f, 9.44807082e-02f, -1.40955253e-02f,
  2.29508504e-01f, 1.95938572e-01f, 6.52585700e-02f, 1.27209768e-01f, -9.07898918e-02f, 1.72402978e-01f, 7.55504072e-02f, -8.27456191e-02f, 1.27493620e-01f, 1.26272112e-01f,
  5.26859686e-02f, -1.11106142e-01f, 9.51302126e-02f, -9.15048867e-02f, 4.95822914e-02f, -1.31031156e-01f, -1.14761986e-01f, 1.75102487e-01f, 2.06902370e-01f, 2.55522858e-02f,
  5.41584454e-02f, -4.77602556e-02f, 6.97622821e-02f, -2.89471410e-02f, -2.32847705e-02f, -1.37513548e-01f, -2.02080868e-02f, 9.52763259e-02f, -1.12132363e-01f, -2.12965623e-01f,
  1.12856925e-01f, 1.81607716e-02f, 9.45949275e-03f, 3.17803584e-02f, 1.10375896e-01f, 9.16160271e-02f, 1.02355108e-02f, 9.04796645e-02f, 5.83229624e-02f, 1.51415181e-03f,
  -8.18047002e-02f, -1.09542340e-01f, 2.08218154e-02f, -3.05367112e-02f, -1.32030696e-01f, -7.39487782e-02f, -2.53860708e-02f, 5.92274554e-02f, -9.51758996e-02f, -1.10816874e-01f,
  6.85864240e-02f, -1.16355874e-01f, -7.14218467e-02f, -1.18470013e-01f, 1.55272275e-01f, -5.76421469e-02f, 8.23497772e-02f, -1.13320388e-01f, 1.15659498e-01f, 6.32695407e-02f,
  -1.10858656e-03f, -1.02529213e-01f, -1.83668938e-02f, 4.76535447e-02f, 1.15409091e-01f, -5.43219149e-02f, 2.11979523e-02f, -5.56863323e-02f, -4.98416051e-02f, 2.92234626e-02f,
  1.09273769e-01f, 9.24458876e-02f, 4.61612567e-02f, 9.70449522e-02f, -1.07187726e-01f, 8.66774991e-02f, -9.78999771e-03f, -1.29021436e-01f, -4.48660962e-02f, -1.51513189e-01f,
  -1.00962855e-01f, -1.37022212e-02f, 1.14237353e-01f, -5.61408214e-02f, 8.49783644e-02f, 1.28979832e-02f, -8.16112682e-02f, 3.01861990e-04f, 1.29149526e-01f, -1.03247866e-01f,
  4.79010716e-02f, 4.95665260e-02f, 6.04343228e-02f, 1.13990698e-02f, -8.53073224e-02f, -2.08087289e-03f, 9.32548717e-02f, -7.52758682e-02f, 1.09094866e-01f, -1.02829807e-01f,
  -1.29868791e-01f, 1.10343739e-01f, -5.08380774e-03f, 2.10216045e-02f, 5.76761225e-03f, -1.00035653e-01f, 1.15730330e-01f, -7.90837035e-02f, -4.78158779e-02f, 8.83359537e-02f,
  2.71116327e-02f, -1.07855335e-01f, -7.29042813e-02f, -5.22031561e-02f, -7.18702599e-02f, 3.03518213e-02f, 1.44678336e-02f, 9.94414911e-02f, -1.01235084e-01f, 3.32263932e-02f,
  -1.29151298e-02f, -5.44989705e-02f, -2.55374238e-02f, 8.37094337e-02f, 6.52545989e-02f, 1.46900073e-01f, 1.31598398e-01f, 6.92095235e-02f, 6.45771176e-02f, 1.77339256e-01f,
  7.16900527e-02f, 8.94498751e-02f, -6.23930991e-02f, -1.56562589e-02f, 1.08078243e-02f, -4.67014425e-02f, 4.71106701e-04f, -5.60191013e-02f, 1.99305534e-01f, -1.28487185e-01f,
  -7.87260011e-02f, 9.04835470e-04f, 9.79409292e-02f, 5.83471060e-02f, -1.28265038e-01f, 5.52470051e-02f, 9.19455662e-02f, -1.60873234e-01f, 1.62813768e-01f, 7.22931251e-02f,
  -8.82606581e-02f, -1.19710408e-01f, -2.16062199e-02f, 1.01855628e-01f, 2.52906438e-02f, -1.03177533e-01f, -1.46942422e-01f, -1.64700851e-01f, 6.65736496e-02f, 1.21258937e-01f,
  -1.37734964e-01f, 1.43475279e-01f, 2.59579346e-02f, -3.38810077e-03f, -1.14621475e-01f, 5.50855547e-02f, 2.01004237e-01f, -5.08272573e-02f, -5.57901189e-02f, -1.69623177e-02f,
  1.72730193e-01f, 1.49266543e-02f, 1.28962547e-01f, 7.99334496e-02f, 5.36221005e-02f, -2.25322228e-03f, 7.64280707e-02f, -2.51491684e-02f, -1.23964310e-01f, -1.32924944e-01f,
  -1.25949413e-01f, -9.05875564e-02f, 1.09959096e-01f, 1.03486262e-01f, 6.59917295e-02f, 4.03125063e-02f, -1.08645231e-01f, -6.07831590e-02f, -1.30550146e-01f, -1.00759499e-01f,
  9.85178798e-02f, 1.25102401e-01f, 5.31065911e-02f, 1.02282569e-01f, -3.04020457e-02f, 1.04330473e-01f, 2.48959456e-02f, 1.04257315e-01f, 1.20813720e-01f, 7.07712695e-02f,
  3.61748375e-02f, -5.53230718e-02f, 1.44901201e-01f, 1.73229739e-01f, -1.10487476e-01f, 9.01878253e-02f, -7.49343559e-02f, 1.32459790e-01f, 5.99610060e-02f, 4.38535996e-02f,
  -1.05277905e-02f, -2.30938867e-02f, -1.15362994e-01f, -1.17295638e-01f, 8.52310937e-03f, 1.74443111e-01f, -1.14109674e-02f, 4.25982997e-02f, 1.40356153e-01f, -6.39370084e-02f,
  -9.64383855e-02f, 9.22849104e-02f, -1.02757946e-01f, 1.82267338e-01f, 8.31098482e-02f, 1.59600377e-02f, 2.39114603e-03f, 7.09957257e-02f, 1.29291847e-01f, 1.91140231e-02f,
  8.76553264e-03f, -7.92018138e-03f, 3.18614468e-02f, -3.01346518e-02f, 2.69889701e-02f, 8.64642113e-02f, 7.30985105e-02f, 1.15029924e-01f, 2.77692545e-02f, 8.35789833e-03f,
  1.25146419e-01f, 4.41520587e-02f, -2.30779238e-02f, 4.69735116e-02f, 7.80022889e-02f, 1.34880707e-01f, 1.16306610e-01f, 6.85555860e-02f, 1.52465641e-01f, -7.78335854e-02f,
  1.29896611e-01f, 1.04036339e-01f, 7.39882514e-02f, 1.07376814e-01f, 5.06647751e-02f, -1.45029142e-01f, 1.49361640e-01f, 1.01537615e-01f, 1.14185914e-01f, -3.50821391e-02f,
  -1.06997788e-01f, 2.60730647e-02f, 9.58551019e-02f, 1.52696282e-01f, -6.19652644e-02f, 1.00881390e-01f, -6.48146942e-02f, 8.53455588e-02f, 5.15312850e-02f, 4.54780050e-02f,
  2.70530395e-02f, -1.06291153e-01f, 8.12127516e-02f, 9.37144905e-02f, 9.13371369e-02f, -8.52977037e-02f, 4.31572013e-02f, -2.56277081e-02f, -3.86795811e-02f, -1.52452543e-01f,
  9.31464881e-02f, 6.22549504e-02f, -4.18215729e-02f, 3.08343414e-02f, 1.65479764e-01f, -1.45242354e-02f, -7.09483922e-02f, -1.18059039e-01f, -2.60192491e-02f, -3.14507112e-02f,
  1.28911957e-01f, -2.67752148e-02f, 9.81605873e-02f, 1.17099538e-01f, 1.11059388e-02f, -6.88629374e-02f, 4.96131591e-02f, -6.15033358e-02f, -1.38067737e-01f, -4.07550670e-02f,
  1.14161775e-01f, 8.16397741e-02f, -3.88183333e-02f, -3.53293195e-02f, -1.12580597e-01f, 1.15505353e-01f, -3.12645957e-02f, 1.15683712e-01f, 2.88721640e-02f, 5.94179817e-02f,
  -3.77548710e-02f, -7.12590367e-02f, 6.70455676e-03f, 6.68728724e-02f, 7.68464431e-02f, 1.59878999e-01f, 6.06442466e-02f, 5.11494912e-02f, 1.03233948e-01f, -7.58838281e-02f,
  1.29809156e-01f, 1.64424315e-01f, -4.22303379e-02f, -2.69054212e-02f, 1.52932063e-01f, 4.84761149e-02f, 1.78458303e-01f, 1.31715134e-01f, 1.37918249e-01f, -1.28120380e-02f,
  2.39002258e-01f, 1.64877608e-01f, -9.24701840e-02f, -6.02905452e-02f, 4.66008931e-02f, -1.05933256e-01f, -1.24278992e-01f, 1.51788011e-01f, 9.74065587e-02f, -1.72437206e-01f,
  1.39393225e-01f, 1.05959505e-01f, -1.53173119e-01f, -1.53155163e-01f, -4.57225367e-02f, -6.12833574e-02f, -3.99123281e-02f, 2.71263625e-02f, 2.49531437e-02f, -3.26893032e-01f,
  -8.29905868e-02f, 1.39231712e-01f, -8.90174508e-02f, 1.78495571e-01f, 1.16955005e-01f, 1.14390127e-01f, -1.08604528e-01f, 7.68116415e-02f, 1.35676518e-01f, 6.29218817e-02f,
  -6.69149682e-02f, 6.90259412e-02f, 2.03293279e-01f, 1.23633325e-01f, 3.71485315e-02f, 2.04988316e-01f, 8.87643993e-02f, -4.90208641e-02f, -1.37520209e-01f, -4.17327061e-02f,
  6.97394228e-03f, -2.73152664e-02f, -5.17819636e-02f, -3.83772999e-02f, 7.11194202e-02f, 1.29016951e-01f, -3.61442082e-02f, 2.22561900e-02f, -1.12030976e-01f, -1.00144699e-01f,
  -7.22762570e-02f, -1.10577643e-01f, -1.21038243e-01f, 2.50353524e-03f, -3.43153439e-02f, 1.62845384e-02f, -8.24615881e-02f, 1.76880565e-02f, -8.01227242e-02f, 7.79288337e-02f,
  -5.69675863e-02f, 9.79911685e-02f, -5.68720177e-02f, 5.70998676e-02f, 8.79891366e-02f, -3.22735012e-02f, -1.07677542e-01f, -8.23673978e-02f, -7.98632726e-02f, 8.38472918e-02f,
  1.22002885e-02f, -8.35091248e-02f, -1.11137092e-01f, -7.73161054e-02f, 1.03954226e-01f, 8.24539140e-02f, 9.39685479e-02f, 2.96609069e-04f, 3.70990089e-03f, -2.51629087e-03f,
  -1.14287540e-01f, 1.18748784e-01f, -1.19181551e-01f, 7.98516199e-02f, -6.31867573e-02f, -9.54012945e-02f, -5.36185987e-02f, -9.66882110e-02f, -1.11168385e-01f, 6.51847497e-02f,
  -1.94031396e-03f, -4.23701741e-02f, 9.62424427e-02f, -1.85225029e-02f, 7.98682123e-02f, -4.26583923e-02f, -6.01443648e-02f, 3.63478390e-03f, -7.96110034e-02f, 4.90713231e-02f,
  6.12517186e-02f, -1.84702536e-03f, 5.32335676e-02f, -6.23809397e-02f, 4.29507457e-02f, 9.52995420e-02f, 3.44810523e-02f, -1.17011048e-01f, 8.44137594e-02f, -8.67149383e-02f,
  1.13438945e-02f, 1.06369004e-01f, 3.33108683e-03f, -5.85157946e-02f, 8.48422125e-02f, 6.18374534e-03f, 9.90582928e-02f, 8.39350969e-02f, 1.92166939e-01f, -1.00889457e-02f,
  7.72665080e-04f, 2.50878427e-02f, 7.28795528e-02f, 7.71110281e-02f, 1.49708390e-01f, 1.40725881e-01f, 1.65433392e-01f, -1.89482216e-02f, -2.80190576e-02f, -5.76887615e-02f,
  4.35624495e-02f, 1.41239343e-02f, -4.99611571e-02f, -1.21427067e-02f, 1.97635517e-02f, 1.20622322e-01f, 6.74557835e-02f, 1.49912089e-01f, -1.84906110e-01f, -1.59198970e-01f,
  2.25655138e-01f, -1.89493865e-01f, 4.71600592e-02f, -1.30442426e-01f, -6.58559427e-02f, 6.54116347e-02f, -1.30721301e-01f, 2.39909798e-01f, 7.42408037e-02f, 3.87665257e-02f,
  9.98772904e-02f, -1.33764371e-01f, -7.66369030e-02f, -1.70590550e-01f, 1.32422149e-01f, -6.38267142e-04f, 8.33822414e-02f, 2.17167899e-01f, -9.46686342e-02f, 1.30354971e-01f,
  1.56319827e-01f, -6.23870045e-02f, 1.94524318e-01f, 2.53383934e-01f, 8.08753520e-02f, 6.66471273e-02f, -7.66486973e-02f, 1.26666501e-01f, 1.33122787e-01f, 5.34070507e-02f,
  -7.36826509e-02f, -5.44254109e-02f, 9.43727493e-02f, -1.81261495e-01f, -3.73493098e-02f, -1.82626098e-02f, -6.61849231e-02f, -5.90304881e-02f, 2.63545401e-02f, 1.22211203e-01f,
  -6.99337125e-02f, 2.00368874e-02f, -5.69191948e-02f, -7.37484545e-02f, 1.01709530e-01f, -4.43443544e-02f, 1.45315053e-02f, -2.85896640e-02f, -1.10681482e-01f, 1.27988756e-01f,
  8.43822658e-02f, 1.55563261e-02f, -5.90433925e-03f, 1.00752257e-01f, 4.42948639e-02f, 1.23670258e-01f, -7.54929632e-02f, 8.73707980e-02f, -5.54975271e-02f, 8.89462307e-02f,
  1.08458847e-01f, -5.46823069e-02f, -3.58916409e-02f, -1.47366542e-02f, 1.19041048e-01f, -1.08526520e-01f, -1.64651889e-02f, -1.94501355e-02f, -1.22674540e-01f, -9.98325944e-02f,
  -9.26575810e-02f, -3.48682306e-03f, -1.15574233e-01f, -4.74818125e-02f, 1.07241988e-01f, -4.05517593e-02f, 1.39553428e-01f, -2.45510438e-03f, -1.04215503e-01f, -9.74233001e-02f,
  1.62011728e-01f, 3.96198370e-02f, 1.30101815e-02f, 8.56114104e-02f, 1.95990384e-01f, -3.41589451e-02f, -7.50067011e-02f, 1.46474600e-01f, -4.26950753e-02f, -8.51938874e-02f,
  2.40850337e-02f, 6.67951703e-02f, -1.10905692e-01f, 1.38966113e-01f, -2.39932444e-02f, -2.67998017e-02f, 1.39529817e-02f, 9.60148498e-02f, -3.70163359e-02f, 1.41178435e-02f,
  -4.97972108e-02f, -8.08836073e-02f, 7.07334355e-02f, 6.18813299e-02f, -1.10543475e-01f, -1.04022399e-01f, -4.35593687e-02f, 3.82454209e-02f, -8.36803541e-02f, -3.26462016e-02f,
  -3.93991768e-02f, 4.75096703e-02f, -8.26764107e-02f, 1.82538163e-02f, -3.41577418e-02f, 9.05591175e-02f, 3.17828730e-02f, 2.96272617e-02f, -1.09923214e-01f, -5.56225516e-02f,
  9.07797217e-02f, 8.71989429e-02f, -9.86776426e-02f, -7.70069882e-02f, -1.09951094e-01f, -7.19630346e-02f, -3.73567492e-02f, 8.81285891e-02f, 1.03547893e-01f, -2.61432827e-02f,
  1.07561938e-01f, 2.68852189e-02f, 3.10242586e-02f, 7.53358472e-03f, 8.63538533e-02f, 6.47868067e-02f, -9.64417085e-02f, 1.22566931e-01f, 4.52819802e-02f, 5.91990165e-02f,
  -2.29725279e-02f, 6.74928874e-02f, -1.16879098e-01f, -3.86168882e-02f, -9.10722688e-02f, 4.01295722e-03f, -1.11393437e-01f, 9.38157588e-02f, 9.52499453e-03f, 7.67607763e-02f,
  8.74649286e-02f, -1.12849869e-01f, -3.09949536e-02f, -1.01865102e-02f, 2.39604469e-02f, -2.02431027e-02f, -4.28036368e-03f, -5.44699021e-02f, 9.30850357e-02f, 1.08426958e-02f,
  -6.61459938e-02f, -5.60090691e-02f, 7.50687495e-02f, -8.27358514e-02f, 3.57893258e-02f, 1.34498805e-01f, -2.24178731e-01f, -1.03134304e-01f, 2.31451198e-01f, 2.73110420e-01f,
  -1.43034294e-01f, 7.34706223e-02f, 1.42243207e-01f, 1.48844957e-01f, 1.75510496e-01f, 2.11324096e-01f, 1.16219692e-01f, 9.12134647e-02f, -6.90294802e-02f, 1.53447777e-01f,
  2.26520687e-01f, 2.63536759e-02f, -2.26594388e-01f, 2.15707242e-01f, 1.50803298e-01f, 2.49720551e-02f, -2.67006427e-01f, -9.67166275e-02f, -1.20959446e-01f, -1.94418430e-01f,
  -6.22828081e-02f, -6.18718117e-02f, -1.99364617e-01f, 3.05876076e-01f, -7.77839199e-02f, 1.48541003e-01f, 3.89021039e-01f, -2.95029790e-03f, 1.58399060e-01f, 9.44910347e-02f,
  -6.91665411e-02f, 8.75809640e-02f, 1.58025309e-01f, 5.62411770e-02f, 3.45988162e-02f, 4.90259901e-02f, 7.98231438e-02f, -1.49530903e-01f, -9.88841243e-03f, -1.89365312e-01f,
  -1.72505658e-02f, 9.37502384e-02f, -3.44453529e-02f, 2.26751268e-01f, -3.05773895e-02f, 2.00050138e-02f, -3.94415036e-02f, 1.47800460e-01f, 4.22922969e-02f, -1.05009414e-01f,
  -2.15157330e-01f, 3.40798616e-01f, -2.74714530e-02f, 4.13342044e-02f, 9.04133245e-02f, 1.65574282e-01f, 2.77733412e-02f, 1.47358671e-01f, -1.98598012e-01f, 1.38214752e-01f,
  1.33785913e-02f, 3.99029767e-03f, -7.09642693e-02f, 1.73004100e-03f, 6.92129582e-02f, 3.31605673e-02f, 1.38041049e-01f, 8.56699795e-02f, -4.91157547e-02f, 1.92134276e-01f,
  1.09998435e-02f, -1.37173697e-01f, 1.40408978e-01f, 1.60806134e-01f, 1.13246299e-01f, 1.63510159e-01f, 2.11016417e-01f, 4.44488302e-02f, -6.53698966e-02f, 8.94508138e-02f,
  -9.86766163e-03f, -1.54866129e-01f, 2.90798470e-02f, -1.49166808e-01f, 2.20202878e-02f, 2.53148880e-02f, 9.36523303e-02f, 1.10215515e-01f, -9.36289579e-02f, 2.03190465e-02f,
  1.33501589e-01f, 1.65933102e-01f, -5.06178029e-02f, 1.02983974e-01f, 5.21400273e-02f, 2.23245367e-01f, 6.72691539e-02f, -3.25623751e-02f, -8.78407508e-02f, 2.12145880e-01f,
  2.71065924e-02f, -6.34762049e-02f, -1.70699263e-03f, 2.82064155e-02f, 1.24951594e-01f, -5.17515503e-02f, 1.04922578e-02f, 1.45366713e-01f, -1.82581246e-01f, 3.34743969e-02f,
  1.67378858e-02f, 1.30002171e-01f, 6.23837858e-02f, 1.26574365e-02f, -2.53841318e-02f, 6.21031448e-02f, -6.29194602e-02f, 9.23335552e-02f, 8.56322646e-02f, 1.59427673e-01f,
  8.19713436e-03f, -2.06147674e-02f, 1.22784719e-01f, 1.13917574e-01f, -8.38109199e-03f, 2.72850762e-03f, 8.80448148e-02f, 1.09972497e-02f, -6.70975670e-02f, -1.07259862e-03f,
  4.38730046e-02f, -7.46297324e-03f, -7.12782890e-02f, -3.73288319e-02f, -9.28006023e-02f, -7.17338175e-02f, -4.94779721e-02f, 3.78522575e-02f, 2.28535142e-02f, -1.09915204e-01f,
  -6.20904788e-02f, 1.28253400e-01f, -6.98149204e-02f, -1.24162935e-01f, 9.78647470e-02f, 6.83083832e-02f, 5.54214558e-03f, -2.18507983e-02f, -1.51640084e-02f, 2.82655023e-02f,
  -1.23528086e-01f, -1.90697680e-03f, 6.41032681e-02f, 3.36019136e-02f, 2.43637003e-02f, 7.61852637e-02f, 4.20837961e-02f, -1.43519759e-01f, 8.73864442e-02f, -1.26851603e-01f,
  -7.64761642e-02f, 7.93589726e-02f, 9.49679315e-02f, -1.25925213e-01f, 8.98121521e-02f, -2.11874805e-02f, 1.25324786e-01f, -7.97481313e-02f, 3.83196846e-02f, 1.07991979e-01f,
  9.31515023e-02f, -1.18973954e-02f, 1.35569215e-01f, -1.02734856e-01f, -2.21424028e-02f, 1.21312909e-01f, -1.07855089e-01f, 1.03760943e-01f, 7.19689578e-02f, -1.11519016e-01f,
  9.39179286e-02f, -9.35875997e-02f, 1.08046338e-01f, 1.01050772e-01f, -6.96470141e-02f, -2.26730201e-02f, -1.45504534e-01f, 4.84022051e-02f, -3.78884673e-02f, 1.18956544e-01f,
  1.34883642e-01f, 1.56967670e-01f, 1.31214663e-01f, 7.12382123e-02f, 1.29802704e-01f, 1.30213201e-01f, 1.28037900e-01f, 4.22909670e-02f, -6.18765503e-02f, 6.27998039e-02f,
  5.48600815e-02f, 1.13615625e-01f, 5.07523045e-02f, 1.09345242e-01f, -1.29220128e-01f, 1.56264514e-01f, -3.79907526e-02f, -3.79996933e-02f, -2.42677722e-02f, -9.05041248e-02f,
  9.72686931e-02f, -1.88234121e-01f, 9.43271071e-02f, 7.95055628e-02f, -5.78397624e-02f, 8.46038237e-02f, -1.40170053e-01f, 1.42526984e-01f, 1.33168563e-01f, 1.65695265e-01f,
  -1.17584027e-01f, -4.22322936e-03f, -7.56278932e-02f, 1.27531245e-01f, -4.87152301e-02f, -2.40122620e-02f, 1.13722496e-02f, -3.12967561e-02f, -2.46011410e-02f, -3.39978114e-02f,
  4.60601300e-02f, -1.15784757e-01f, 1.32461578e-01f, -2.93182787e-02f, 2.09879205e-02f, 1.63403034e-01f, 7.90008381e-02f, 1.07175782e-01f, 5.72038405e-02f, 8.32560509e-02f,
  -8.60071406e-02f, -1.17120534e-01f, -2.79816072e-02f, -1.50779355e-02f, 1.22265376e-01f, 1.44575626e-01f, 8.46396759e-02f, 1.97995827e-01f, 1.20326556e-01f, 9.76128783e-03f,
  1.47639170e-01f, 3.89738474e-03f, 8.77806321e-02f, -8.92379880e-02f, -1.09328121e-01f, 1.38565555e-01f, 8.74913484e-02f, -1.87281445e-02f, 2.72835437e-02f, -8.02665725e-02f,
  -7.53321946e-02f, -1.02727555e-01f, -8.25180635e-02f, -4.86746728e-02f, -3.15941647e-02f, 5.72297163e-02f, -1.04743339e-01f, -2.35328241e-03f, -1.01706069e-02f, 8.17276239e-02f,
  4.33153883e-02f, -5.66286128e-03f, -9.15092528e-02f, 9.35678184e-02f, 2.72128731e-02f, 1.02811165e-01f, 6.08611368e-02f, -1.18716106e-01f, 3.18088755e-02f, -1.35188684e-01f,
  9.02751088e-02f, -5.26110642e-02f, 4.18322487e-03f, -1.55802453e-02f, -5.15644401e-02f, 1.34309366e-01f, 1.63392406e-02f, -9.90092307e-02f, 1.02537826e-01f, 1.96910817e-02f,
  -1.00189708e-01f, 6.44850954e-02f, 4.26536277e-02f, -8.07107538e-02f, 3.81371267e-02f, -4.74956743e-02f, -9.89798456e-03f, -6.38869330e-02f, -1.64625552e-02f, -7.23909214e-02f,
  1.19885080e-01f, 1.38713598e-01f, 4.35079262e-02f, 2.37792544e-02f, 6.65158182e-02f, -4.73786555e-02f, 1.96030457e-02f, 7.50252903e-02f, 2.11389503e-03f, 9.69943926e-02f,
  -4.07823769e-04f, 4.41157987e-04f, -6.10903352e-02f, -1.40149817e-02f, -5.20231873e-02f, -9.95183513e-02f, 9.43682641e-02f, 8.43905061e-02f, 2.29066480e-02f, 3.32675129e-02f,
  2.82359682e-02f, 5.21898642e-02f, -8.92205462e-02f, 6.98017031e-02f, 7.09656179e-02f, 1.78547464e-02f, 8.86937901e-02f, -1.05931528e-01f, 4.87054884e-03f, -3.38859372e-02f,
  -6.90890774e-02f, 9.53187570e-02f, -9.63383988e-02f, 1.33967906e-01f, 4.21464778e-02f, 1.02177002e-01f, -1.34013489e-01f, 4.43057716e-02f, -4.96001309e-03f, -1.47440389e-01f,
  8.76806851e-04f, -1.07051125e-02f, -1.45754680e-01f, 1.00071035e-01f, 2.50727348e-02f, -7.98655525e-02f, 7.99693167e-02f, -1.05184510e-01f, 9.90323052e-02f, -7.98783451e-03f,
  3.21625099e-02f, -2.83901766e-02f, -6.88863769e-02f, -8.37001950e-03f, -1.12365566e-01f, 1.76395644e-02f, 9.88837928e-02f, -9.72921401e-02f, 2.83483043e-02f, -6.10790141e-02f,
  -4.67838980e-02f, 7.42889615e-03f, -6.95778206e-02f, 1.33636640e-02f, -5.88303730e-02f, 1.06334522e-01f, 7.56666362e-02f, -1.00630865e-01f, 9.10059512e-02f, -9.54422057e-02f,
  -1.20704047e-01f, 1.88822076e-02f, -4.15331759e-02f, 3.72883193e-02f, -8.84812325e-02f, 7.86135253e-03f, -1.67254929e-03f, -7.74582326e-02f, -7.06793889e-02f, -6.54124320e-02f,
  4.56875339e-02f, -7.41231367e-02f, 1.30844951e-01f, 1.02115639e-01f, 1.06607890e-02f, 7.44300708e-02f, 6.18248321e-02f, 5.19700162e-02f, -7.73956105e-02f, 1.14441879e-01f,
  1.23524047e-01f, 1.78625137e-02f, 4.14042138e-02f, 3.15662883e-02f, 2.33919304e-02f, 1.26216128e-01f, -2.20377296e-02f, -5.59292436e-02f, 2.21139360e-02f, 4.86401804e-02f,
  1.29344568e-01f, -1.56927437e-01f, 1.76378563e-02f, -1.10111035e-01f, 1.16577260e-01f, -1.31801933e-01f, 1.23704687e-01f, -3.27718332e-02f, -1.14823490e-01f, 1.47366285e-01f,
  -5.97194508e-02f, 1.47261128e-01f, 6.35508448e-02f, -1.64815355e-02f, 6.51777461e-02f, 2.74302252e-03f, -1.04497835e-01f, 2.46507116e-02f, -9.15882364e-02f, -3.48264985e-02f,
  8.62205252e-02f, -4.22041351e-03f, 1.07101098e-01f, 1.83511451e-02f, 1.62934378e-01f, -6.28505275e-02f, 7.38255233e-02f, 4.39236723e-02f, -5.56155145e-02f, -1.25858888e-01f,
  9.26905721e-02f, 7.71017894e-02f, 7.02174157e-02f, -6.36494830e-02f, 8.74475911e-02f, 9.38945189e-02f, -3.84163596e-02f, 4.98230234e-02f, 1.37625754e-01f, -3.99064124e-02f,
  -5.42400405e-02f, 9.84724462e-02f, -1.23998955e-01f, 1.06723115e-01f, 2.65111066e-02f, 1.06814034e-01f, 4.37066369e-02f, -2.41323896e-02f, -1.06134191e-01f, 1.73227657e-02f,
  2.17020395e-03f, -1.20145634e-01f, -7.71311224e-02f, 3.71719636e-02f, 9.47018415e-02f, 5.84901012e-02f, -3.68765444e-02f, -5.10711446e-02f, -6.71531111e-02f, 5.31627052e-02f,
  5.36591047e-03f, 1.03297196e-01f, -7.61314929e-02f, 8.08605626e-02f, 1.52799394e-02f, -3.43727926e-03f, -9.16936100e-02f, -6.25792239e-03f, 5.45258299e-02f, 1.15663171e-01f,
  -3.60450596e-02f, 4.14759330e-02f, 1.14670843e-02f, -3.21238525e-02f, 1.96872894e-02f, -3.34781371e-02f, -1.77378138e-03f, -9.75155383e-02f, 9.42197591e-02f, -6.53873086e-02f,
  5.01832329e-02f, -1.05774328e-01f, -1.09995671e-01f, 3.69146205e-02f, 8.29776376e-02f, -1.02786146e-01f, -3.69971767e-02f, 6.17801175e-02f, -1.02951527e-01f, -1.03789195e-01f,
  -1.21921763e-01f, 1.70295057e-03f, -9.55872089e-02f, 7.98013657e-02f, -2.47297324e-02f, -2.58814450e-02f, -1.28712654e-02f, -4.43358496e-02f, -1.10151060e-01f, -1.65667627e-02f,
  -1.01042166e-01f, -2.78116912e-02f, 2.20193136e-02f, -5.68022728e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.74751186e-02f, 8.85965005e-02f, 5.27952723e-02f, 1.22238263e-01f, -1.45504819e-02f, -8.68648216e-02f, 2.06289981e-02f, 7.76900798e-02f, -1.25414561e-02f, -1.16137527e-01f,
  9.20384657e-03f, -5.35563529e-02f, -9.50797275e-02f, 1.09056480e-01f, 1.96671188e-02f, 9.93813947e-03f, 5.19884676e-02f, -3.94432917e-02f, 1.58970803e-01f, 1.31228700e-01f,
  -7.66603500e-02f, -6.46127611e-02f, 1.44500270e-01f, -5.36829308e-02f, 8.35801195e-03f, 2.88483333e-02f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -6.16730899e-02f, 7.55157471e-02f, 2.35025864e-03f, -6.48285523e-02f, -3.85580100e-02f, -1.54473092e-02f, 7.23301619e-02f, 2.84796651e-03f, 1.88981816e-02f, 1.53967559e-01f,
  1.37206754e-02f, -2.59417165e-02f, -1.02152318e-01f, -1.00941747e-01f, 1.16869867e-01f, 1.05042353e-01f, -7.72832185e-02f, 3.57779898e-02f, 2.06236225e-02f, -3.48969325e-02f,
  4.84250374e-02f, 9.51549858e-02f, -9.43096355e-02f, -3.48753817e-02f, 1.56700313e-01f, -1.92153811e-01f, 1.45735785e-01f, -3.27719152e-02f, -1.42704144e-01f, -2.02123910e-01f,
  8.57051983e-02f, 4.96661663e-02f, -1.03707321e-01f, -4.26737219e-02f, 6.23575002e-02f, 1.07479505e-01f, 1.23053990e-01f, 6.33306131e-02f, -7.54378038e-03f, -2.78625581e-02f,
  -1.38680518e-01f, -1.21146299e-01f, 9.11297724e-02f, 9.15903822e-02f, -1.03282176e-01f, -1.60988018e-01f, 1.57635644e-01f, 1.45621076e-01f, 5.83384447e-02f, -1.21567689e-01f,
  -1.28919221e-02f, -4.35733944e-02f, -1.39174014e-01f, 4.23316732e-02f, -6.82407692e-02f, -7.86957368e-02f, -1.62129864e-01f, -1.33203790e-02f, -2.54466515e-02f, 1.63044017e-02f,
  -4.86587398e-02f, 7.86083266e-02f, -1.18436620e-01f, -4.92647067e-02f, 1.04219303e-01f, 1.89286724e-01f, 9.66951847e-02f, 1.09646335e-01f, -4.26801518e-02f, -1.70567550e-03f,
  8.25265050e-02f, 5.18589886e-03f, -7.94515163e-02f, 4.26106341e-02f, -8.97978805e-03f, 9.29639563e-02f, -3.57671715e-02f, -3.21999714e-02f, 8.30404535e-02f, 1.80776119e-01f,
  1.41203497e-02f, 1.79402053e-01f, -2.91200429e-02f, 1.44827604e-01f, -3.77957821e-02f, 1.54969975e-01f, -1.60160989e-01f, 6.13910779e-02f, -1.07087404e-01f, -1.40023783e-01f,
  2.14500099e-01f, -1.48523729e-02f, 1.32023111e-01f, -1.04694642e-01f, 1.91164196e-01f, 6.90498650e-02f, 5.25440797e-02f, 7.00761890e-03f, 7.47857429e-03f, 8.52880850e-02f,
  2.29016960e-01f, 3.40980366e-02f, -6.65000975e-02f, -1.12106480e-01f, -1.20011449e-01f, 7.33918473e-02f, -4.97699641e-02f, 4.30405997e-02f, 1.74464323e-02f, -1.82026401e-02f,
  4.77100015e-02f, 1.46108285e-01f, 1.24994621e-01f, -6.88401386e-02f, -7.51398578e-02f, 3.06983460e-02f, 1.03454327e-03f, 7.36422166e-02f, 3.50315985e-03f, 5.91838397e-02f,
  -2.33856931e-01f, -2.40902975e-01f, 1.01655595e-01f, -6.55901358e-02f, 9.26977322e-02f, -1.21053420e-01f, -1.01420041e-02f, 4.93901893e-02f, 5.24214841e-02f, -5.26869856e-02f,
  1.32379204e-01f, -4.58084308e-02f, -8.12170878e-02f, -1.43693104e-01f, -1.06477179e-01f, -5.09089082e-02f, 6.12674616e-02f, -1.26203611e-01f, -5.29437773e-02f, -1.08212709e-01f,
  -5.37343100e-02f, -1.00951284e-01f, 1.62510574e-02f, -1.68433294e-01f, -9.10705999e-02f, 2.62402762e-02f, 9.42328498e-02f, -1.39802173e-01f, -3.04751545e-01f, 5.78858517e-02f,
  -5.08975750e-03f, 2.68555492e-01f, 2.54967269e-02f, -1.17070414e-02f, 6.47828802e-02f, -5.41709140e-02f, 1.56404689e-01f, 7.46682361e-02f, 2.34768856e-02f, 1.15685835e-01f,
  -7.35489354e-02f, -1.45412400e-01f, -7.89675713e-02f, -1.45616233e-01f, 5.46938404e-02f, -2.32306525e-01f, 1.21313205e-03f, -6.41275868e-02f, -1.30568361e-02f, 1.20169744e-01f,
  1.05072290e-01f, -9.31461602e-02f, -1.83268264e-01f, 1.21760540e-01f, 5.10539627e-03f, 3.17831635e-02f, 1.40993625e-01f, -6.33394253e-03f, -6.97519034e-02f, 4.19146977e-02f,
  -8.66102427e-03f, 3.36030088e-02f, 1.42784387e-01f, -4.43036519e-02f, -2.33617395e-01f, 5.08805476e-02f, 1.04898429e-02f, 3.19363140e-02f, 8.36914927e-02f, -2.08524568e-03f,
  7.82233998e-02f, 1.16148546e-01f, 2.73981616e-02f, 1.12140745e-01f, -2.70891637e-02f, 3.01537719e-02f, 5.43555357e-02f, 3.37305330e-02f, -1.08534452e-02f, -8.14069137e-02f,
  -4.83979993e-02f, 4.83125411e-02f, 3.31862047e-02f, -1.34833619e-01f, 9.81978774e-02f, -4.15996350e-02f, -7.11468682e-02f, 1.55813262e-01f, -1.15168519e-01f, 4.76197451e-02f,
  -1.12422228e-01f, -1.16223328e-01f, -1.31320357e-01f, -7.05651790e-02f, -8.58182088e-02f, -3.40981446e-02f, -2.83888094e-02f, 1.09106474e-01f, 1.43334508e-01f, 1.12918377e-01f,
  5.00845388e-02f, -1.47533193e-01f, -8.17953944e-02f, 2.41647646e-01f, 7.95130730e-02f, 1.55338779e-01f, -9.67032909e-02f, 1.09082453e-01f, 1.89478561e-01f, 1.48477152e-01f,
  4.75362055e-02f, 2.54916232e-02f, -6.57988107e-03f, -1.73330065e-02f, 8.59812722e-02f, 1.21819437e-03f, 4.67127748e-02f, -1.79752797e-01f, -4.81885038e-02f, 4.82656211e-02f,
  -3.82663719e-02f, 2.25907704e-03f, 5.32219149e-02f, 1.28738195e-01f, 9.96689722e-02f, -4.32319008e-02f, 5.90115674e-02f, 8.19390640e-02f, 1.79804429e-01f, -2.52101328e-02f,
  -8.65433645e-03f, -3.02996002e-02f, 9.75241065e-02f, -2.16997098e-02f, -6.46868050e-02f, -1.11675993e-01f, 3.67690176e-02f, 1.75976939e-02f, 5.11367507e-02f, 3.62875238e-02f,
  2.94490275e-03f, 1.07621618e-01f, 1.65168956e-01f, 1.03483275e-01f, -7.48301074e-02f, 1.93111803e-02f, -4.84370030e-02f, 5.09490967e-02f, -3.28313485e-02f, 1.30302042e-01f,
  -7.45942444e-03f, -1.01605587e-01f, -6.52449206e-02f, 1.39765963e-01f, 9.85554904e-02f, -9.92271230e-02f, 1.55777276e-01f, 1.40997052e-01f, 7.06538931e-02f, 1.89527258e-01f,
  6.34598807e-02f, -6.56952187e-02f, -7.14559034e-02f, -1.32544488e-01f, -5.53931855e-02f, 2.65464991e-01f, -1.41591921e-01f, -5.82651831e-02f, -6.81445189e-03f, -1.51399985e-01f,
  2.44979665e-01f, -3.68359722e-02f, -2.18279749e-01f, -2.07870618e-01f, 9.83187109e-02f, -8.86547938e-02f, 2.32439991e-02f, 6.12760894e-02f, -2.48566568e-02f, -5.23849651e-02f,
  4.66173291e-02f, 2.63455324e-03f, 1.03426790e-02f, -6.79802001e-02f, -2.33224090e-02f, 8.35540965e-02f, -4.28183228e-02f, -1.79021046e-01f, -1.07979104e-01f, 8.60546827e-02f,
  1.47726936e-02f, 1.70130264e-02f, -2.11286321e-01f, 3.52868252e-02f, -6.56859055e-02f, -8.90891552e-02f, 7.60371611e-03f, -8.28071460e-02f, 9.41321552e-02f, -6.13211207e-02f,
  -8.16585049e-02f, 3.87054905e-02f, -1.12469524e-01f, -6.06155060e-02f, -1.82339266e-01f, 6.18984699e-02f, -1.44073829e-01f, 6.08134121e-02f, -5.33809774e-02f, -1.08355694e-01f,
  -1.35795146e-01f, -8.22926462e-02f, -1.32927522e-01f, -1.53734148e-01f, -1.80444151e-01f, -6.86394572e-02f, 2.67500207e-02f, -1.87853607e-03f, -2.12795049e-01f, -2.64887601e-01f,
  -2.41784632e-01f, -4.08039130e-02f, 9.35850292e-03f, 1.02779396e-01f, 2.84225885e-02f, 1.77384794e-01f, 1.06385529e-01f, 8.96901339e-02f, 9.59057063e-02f, 1.08217672e-01f,
  -5.16863465e-02f, 2.49796078e-01f, 4.72769216e-02f, 1.05613843e-02f, -1.49846762e-01f, 7.65196308e-02f, 1.02915287e-01f, 1.84029266e-02f, -8.48462656e-02f, 3.23065780e-02f,
  8.70295018e-02f, -1.08432628e-01f, 1.38287395e-01f, -1.15572244e-01f, -1.96781948e-01f, 5.23003936e-02f, -1.36205196e-01f, 1.24389522e-01f, 1.35034174e-01f, 9.28650647e-02f,
  -1.46023864e-02f, 1.04327917e-01f, -1.08733284e-03f, -1.23369783e-01f, 1.74338207e-01f, 7.85838887e-02f, 1.35189950e-01f, -3.02810688e-02f, 2.03581043e-02f, 1.63774967e-01f,
  -1.14063628e-01f, -2.94926902e-03f, -1.37987658e-01f, 7.12967366e-02f, 1.61021411e-01f, 3.35030518e-02f, 1.48110792e-01f, 2.72856932e-02f, -5.74730150e-02f, -2.60510612e-02f,
  -3.45952064e-02f, -8.36101994e-02f, 6.94365129e-02f, -1.38775492e-02f, 1.00964315e-01f, 4.04456211e-03f, -1.47029594e-01f, 1.28603444e-01f, -5.23449434e-03f, -1.17778040e-01f,
  -7.57415406e-03f, -4.01083454e-02f, 2.20990881e-01f, 2.39294171e-01f, -4.15909141e-02f, -3.26779597e-02f, 8.91557708e-02f, -1.59206160e-04f, 6.86078444e-02f, -1.19060569e-01f,
  6.86515076e-03f, 1.85146242e-01f, 8.47593322e-02f, -2.21744195e-01f, 2.30675638e-01f, 2.24770345e-02f, -1.34626729e-02f, 1.55113325e-01f, 3.90705056e-02f, 5.84633499e-02f,
  2.08226830e-01f, 2.74930708e-02f, -1.20058440e-01f, -3.28710279e-03f, 1.48723170e-03f, 8.51150230e-02f, 3.62468064e-02f, 8.96921456e-02f, 1.85574740e-01f, -1.79112434e-01f,
  -1.09248914e-01f, 1.41747314e-02f, -1.69370785e-01f, -1.46347091e-01f, 1.12977870e-01f, -2.14179698e-02f, -1.86416730e-02f, 8.24196786e-02f, -1.12980399e-02f, 7.68662468e-02f,
  -2.26804078e-01f, -1.86165512e-01f, -2.31787842e-02f, -2.45541520e-02f, 5.03149815e-02f, -6.21890910e-02f, -5.85841388e-02f, -1.21833593e-01f, 4.70580310e-02f, 2.73019131e-02f,
  -5.83317280e-02f, 9.33912098e-02f, 6.65961951e-02f, 7.17559904e-02f, 8.51208195e-02f, 9.09442455e-02f, -4.63370979e-03f, 5.54300845e-02f, 4.65119779e-02f, 6.86465874e-02f,
  -1.08862713e-01f, -3.18319164e-02f, -3.41281295e-02f, -1.14341140e-01f, 1.20584071e-01f, 7.76556358e-02f, -5.64231761e-02f, -3.12684290e-02f, -1.43589541e-01f, -4.05005664e-02f,
  -1.08534247e-01f, 1.75422743e-01f, -5.40059246e-02f, -2.33149454e-01f, 3.65947234e-03f, -7.10346699e-02f, 1.19941130e-01f, 8.00635815e-02f, -5.48519269e-02f, -1.33137569e-01f,
  -1.58457085e-01f, 9.82397869e-02f, -1.04211956e-01f, -9.75231305e-02f, 1.43707231e-01f, -1.37908354e-01f, -5.94387464e-02f, 2.95485090e-02f, 7.38881230e-02f, 6.66978862e-03f,
  -1.42070362e-02f, 3.72089595e-02f, -3.47548909e-02f, -7.91649371e-02f, 7.03428611e-02f, 8.98848921e-02f, -5.67933843e-02f, -1.21319957e-01f, 1.29063159e-01f, 1.32672802e-01f,
  -1.23377621e-01f, -3.07166092e-02f, 8.45726281e-02f, 5.21341823e-02f, -1.78672090e-01f, -1.13303445e-01f, 9.10966769e-02f, -1.01974957e-01f, 4.13611680e-02f, 8.48606154e-02f,
  -8.50418583e-02f, -2.35219430e-02f, 8.35982896e-03f, 7.88156018e-02f, -5.96649125e-02f, 3.83300334e-02f, 1.74350336e-01f, 4.50430922e-02f, 6.99977577e-02f, 1.38124630e-01f,
  1.59691975e-01f, 8.20499584e-02f, 7.95963183e-02f, -1.84594411e-02f, 1.18912213e-01f, 8.35194588e-02f, 1.19310878e-01f, -8.53977352e-02f, -5.59655726e-02f, 1.07795015e-01f,
  4.60918844e-02f, 1.80212155e-01f, 2.09808767e-01f, 2.09737495e-01f, -1.40565564e-04f, -1.53275535e-01f, 9.08996463e-02f, -2.08700165e-01f, -9.25275907e-02f, 1.12332411e-01f,
  -1.64887682e-01f, -9.25463885e-02f, 1.08170070e-01f, -1.14815295e-01f, -1.29848883e-01f, 1.65262014e-01f, 1.69622198e-01f, 1.28753245e-01f, 1.56886339e-01f, 8.27382412e-03f,
  -1.38334692e-01f, 2.23111454e-02f, 7.58447498e-02f, -8.40987787e-02f, -7.08331093e-02f, 6.87260330e-02f, 1.90433756e-01f, -1.90295517e-01f, 4.36661988e-02f, 6.18084474e-03f,
  -1.86019361e-01f, -1.42274022e-01f, 7.80415982e-02f, -2.03599244e-01f, -8.16389173e-02f, 9.47449952e-02f, -1.56923667e-01f, -1.23687252e-01f, -1.29237413e-01f, -4.90778647e-02f,
  6.80095702e-02f, -1.11773975e-01f, -8.27634335e-02f, -4.86937501e-02f, -9.80224535e-02f, -3.22763249e-02f, 7.82947615e-03f, -1.06130853e-01f, 4.81544361e-02f, -2.41608303e-02f,
  -3.58549505e-02f, 1.12712301e-01f, 9.06358585e-02f, -7.89194331e-02f, 1.14585064e-01f, 7.18854740e-02f, 7.80424755e-03f, 6.49077296e-02f, 1.03765801e-01f, -2.57619750e-02f,
  3.94195318e-03f, -2.01244024e-03f, -7.73761868e-02f, -5.76236770e-02f, 1.92748439e-02f, 7.00904131e-02f, 2.73255616e-01f, -6.14077523e-02f, 1.27560064e-01f, -5.28872237e-02f,
  -9.42426920e-02f, 1.01418786e-01f, -1.25413999e-01f, 1.90873723e-02f, -5.46250530e-02f, 1.39172122e-01f, -9.63965952e-02f, -2.20975339e-01f, -1.28422007e-01f, 7.88236707e-02f,
  2.45249286e-01f, -8.61715712e-03f, -1.38002113e-01f, 1.10378498e-02f, 5.73256351e-02f, -1.03383409e-02f, 3.44390571e-02f, 3.43248248e-02f, -1.03546910e-01f, 1.20179653e-01f,
  8.84068459e-02f, -2.44661998e-02f, -1.46942809e-01f, 3.10374349e-02f, -2.52325274e-02f, 8.33639130e-02f, 1.11040436e-02f, -2.66071577e-02f, -4.77829687e-02f, 3.53979841e-02f,
  5.74896373e-02f, -5.26137576e-02f, 1.19972333e-01f, 5.56947812e-02f, -9.78109315e-02f, -8.86514559e-02f, 2.58390838e-03f, -5.15557975e-02f, 7.70479292e-02f, -2.16249842e-03f,
  -7.25477934e-02f, 5.09350635e-02f, -1.05670840e-01f, -5.11350036e-02f, 4.03849520e-02f, -7.35205710e-02f, -2.28475649e-02f, 3.41299898e-03f, 4.44996096e-02f, 9.25167128e-02f,
  -1.20933861e-01f, -4.76966091e-02f, -6.03193939e-02f, -1.34330932e-02f, -1.17195219e-01f, 3.03516630e-02f, 8.35881308e-02f, -7.64589906e-02f, -1.17001928e-01f, 9.48865339e-02f,
  3.09610236e-02f, -1.26710802e-01f, -1.56559870e-02f, -1.46727711e-01f, 8.09084028e-02f, -1.16710998e-01f, 1.76589474e-01f, 6.62863208e-03f, 1.26189619e-01f, -1.84014618e-01f,
  -8.89665633e-03f, 1.98408514e-01f, 1.27331033e-01f, 1.38011664e-01f, -9.06086788e-02f, 1.09708972e-01f, 6.45487458e-02f, 9.39195603e-02f, 6.36851117e-02f, -7.98341408e-02f,
  8.16617459e-02f, 1.14211857e-01f, -9.46123805e-03f, -9.47738290e-02f, 3.31625901e-02f, 8.06919709e-02f, -1.26481563e-01f, -1.18801454e-02f, -7.13106096e-02f, 1.17870033e-01f,
  -5.15470803e-02f, 7.42715597e-02f, -3.41832899e-02f, 1.20220974e-01f, 8.95587355e-02f, -5.06309159e-02f, 9.02186781e-02f, -1.59612685e-01f, 1.12264074e-01f, 1.49141699e-02f,
  2.37257686e-02f, 5.73840104e-02f, 1.59825925e-02f, -6.07187264e-02f, 7.20336512e-02f, 4.63157482e-02f, 7.44283199e-02f, -5.31951897e-02f, -8.15157592e-02f, 9.02253836e-02f,
  -8.67448673e-02f, 8.70683566e-02f, -2.85838405e-03f, 1.85591355e-02f, 7.67568648e-02f, -1.38185825e-02f, -2.51845215e-02f, 1.51432782e-01f, -8.82620215e-02f, 1.14211306e-01f,
  -6.64005801e-02f, -4.76327650e-02f, -1.84353083e-01f, -1.53569594e-01f, 1.20986819e-01f, -6.60333857e-02f, 1.18872389e-01f, 1.62024423e-01f, 2.71782316e-02f, 1.67312384e-01f,
  -1.68035720e-02f, -9.71503630e-02f, -4.41382006e-02f, 2.07316559e-02f, -2.06726328e-01f, -1.55850928e-02f, 3.38678658e-02f, -2.19133899e-01f, 1.08486864e-04f, 3.04382443e-02f,
  -2.35312045e-01f, -9.17403847e-02f, 2.15576757e-02f, -5.86478673e-02f, 1.12555876e-01f, -2.12863460e-03f, -7.78371394e-02f, -5.07756025e-02f, -7.82870278e-02f, -9.11846161e-02f,
  -1.36057576e-02f, -1.00684620e-01f, -1.06815882e-01f, 1.22658722e-01f, -1.47200957e-01f, -9.47169363e-02f, 8.42764601e-02f, -2.30989084e-01f, -7.63039216e-02f, -7.89517835e-02f,
  1.33135080e-01f, 1.07755601e-01f, -1.19843669e-01f, 9.67975184e-02f, 2.01085340e-02f, 1.15618743e-01f, 1.38544649e-01f, 3.91803980e-02f, -1.44591918e-02f, -3.87727320e-02f,
  2.02074670e-03f, 1.04357749e-01f, 9.71291736e-02f, -6.65489808e-02f, -6.51834384e-02f, -3.25785391e-02f, -1.42981529e-01f, 1.04151797e-02f, 5.97544126e-02f, 5.32402247e-02f,
  -1.41857311e-01f, -8.05378109e-02f, 1.02057464e-01f, 3.11429761e-02f, 1.23365484e-01f, 1.29532829e-01f, 4.99697290e-02f, 2.56178051e-01f, -7.06610223e-03f, 8.16931278e-02f,
  1.14944741e-01f, -6.70419913e-03f, -7.95619413e-02f, -2.33311802e-01f, 1.22997895e-01f, 2.41100550e-01f, 1.32127285e-01f, -1.46381944e-01f, 2.37224519e-01f, -5.16919717e-02f,
  5.73114939e-02f, 2.29934558e-01f, -1.32631794e-01f, 1.19913176e-01f, -1.01226231e-03f, -3.46171632e-02f, 1.09536678e-01f, -9.07584801e-02f, 3.42831165e-02f, 6.33724555e-02f,
  -9.92067084e-02f, -2.42239404e-02f, -1.26514798e-02f, 3.76478843e-02f, -5.50915413e-02f, 8.97972584e-02f, 9.63059440e-02f, 4.31471244e-02f, -3.26388218e-02f, 1.26741081e-01f,
  -8.94234255e-02f, 2.51680225e-01f, -4.73163724e-02f, -1.16084822e-01f, -1.22223958e-01f, -2.04529747e-01f, 2.83917086e-03f, -1.75681666e-01f, 7.87112638e-02f, -1.17210224e-01f,
  -6.37035966e-02f, -2.58954130e-02f, 2.98931524e-02f, -1.08910449e-01f, -8.86168052e-03f, -4.39346302e-03f, 2.41388101e-02f, 1.10154059e-02f, 3.96079943e-02f, -3.38849463e-02f,
  9.40041244e-03f, -1.25102043e-01f, -8.14383104e-02f, 1.69028598e-03f, 7.91484863e-02f, 1.26700357e-01f, 9.43405554e-02f, -9.41097960e-02f, -8.43148399e-03f, -9.16171446e-02f,
  5.10243177e-02f, 1.52769357e-01f, -9.69898403e-02f, 2.30322272e-01f, 1.66944981e-01f, 8.64390507e-02f, -7.69643039e-02f, -1.08718714e-02f, -3.42918038e-02f, -1.00401714e-01f,
  1.49732783e-01f, 2.90272027e-01f, -7.14993253e-02f, -1.88644096e-01f, -1.57040834e-01f, -1.75597608e-01f, -1.78312585e-02f, -2.09826887e-01f, -6.55071884e-02f, -1.11212969e-01f,
  -9.78374779e-02f, 7.12119192e-02f, -1.50345400e-01f, 5.09852171e-02f, -5.17574623e-02f, 8.62096176e-02f, 7.85412788e-02f, 1.45261988e-01f, 5.09198830e-02f, 1.61208063e-02f,
  -1.25696838e-01f, 6.06050007e-02f, -2.02095769e-02f, -1.73123226e-01f, 5.72318770e-02f, 1.88378751e-01f, 3.52310687e-02f, 9.64015946e-02f, -2.26887450e-01f, 1.44898653e-01f,
  -1.25534236e-01f, -9.29778069e-02f, 1.24538623e-01f, -9.20491386e-03f, 1.81918725e-01f, 5.75371049e-02f, 1.47919387e-01f, -4.59818775e-03f, -4.74157147e-02f, 4.83491737e-03f,
  6.42478606e-03f, 1.03983015e-01f, 6.58810958e-02f, 5.78901209e-02f, -7.43538663e-02f, 9.90544558e-02f, 1.27770290e-01f, 3.35165635e-02f, 1.63417220e-01f, -8.08962993e-03f,
  -5.83365224e-02f, 1.14405222e-01f, -2.56952792e-02f, 8.08497444e-02f, -6.15871884e-02f, -1.52222097e-01f, -1.25530377e-01f, -6.93955645e-02f, -2.04645604e-01f, 2.88751442e-02f,
  4.91243601e-02f, -1.03437975e-01f, 2.37508997e-01f, -1.00248672e-01f, 1.33380905e-01f, -1.84183016e-01f, 1.21353470e-01f, 7.08902255e-02f, 1.28965661e-01f, -9.05211344e-02f,
  -1.28279701e-01f, 1.51293769e-01f, -6.14725240e-02f, -3.67000438e-02f, -9.84982476e-02f, -1.34414583e-01f, 6.70966953e-02f, 3.62383993e-03f, 1.33088395e-01f, -5.35216182e-02f,
  -2.60847080e-02f, -9.01352614e-02f, 1.11620367e-01f, -1.60802957e-02f, 6.68507069e-02f, -1.08775474e-01f, -2.22266614e-02f, 1.98937312e-01f, -2.72011943e-02f, -6.94213212e-02f,
  5.86781465e-03f, 7.13952258e-02f, -1.20086461e-01f, -1.21629506e-01f, -4.91884127e-02f, -6.72885999e-02f, 7.34857470e-02f, -1.13121226e-01f, -1.32293040e-02f, 1.03908312e-02f,
  8.07725042e-02f, -7.60805011e-02f, -2.47849058e-02f, 3.05451490e-02f, -2.92096529e-02f, 5.28382882e-02f, 9.71056670e-02f, 3.35938185e-02f, 9.77823138e-02f, 1.88089862e-01f,
  -9.58688706e-02f, 1.16255684e-02f, -6.68546408e-02f, 5.88588417e-02f, -2.98738610e-02f, 1.27893746e-01f, 7.00227320e-02f, 6.75086211e-03f, 8.10842589e-03f, 8.18126183e-03f,
  1.93611756e-01f, 2.90398113e-02f, 5.72980419e-02f, -1.33160418e-02f, 2.32174341e-02f, 8.75681713e-02f, -1.52976885e-01f, -1.20347708e-01f, -9.60035399e-02f, 6.49960488e-02f,
  1.77723542e-02f, -1.00181617e-01f, -3.30877081e-02f, 1.09821230e-01f, 1.15851663e-01f, 8.72978196e-02f, -8.20418075e-02f, 2.53735393e-01f, -5.15543297e-02f, 9.91011858e-02f,
  1.35180101e-01f, 1.29109502e-01f, 3.82525809e-02f, 4.65265326e-02f, 1.56499609e-01f, -1.72007699e-02f, -1.67716324e-01f, -1.72061827e-02f, -1.02084309e-01f, -8.03911835e-02f,
  1.22015782e-01f, -1.82056636e-01f, 2.38850955e-02f, -6.24131337e-02f, -4.56962595e-03f, 7.38484487e-02f, 2.95754015e-01f, 1.00461319e-01f, -1.05902418e-01f, -2.41736732e-02f,
  5.59430383e-02f, 1.23086043e-01f, 1.28410785e-02f, 2.08856873e-04f, 9.38127041e-02f, 7.13068992e-02f, -3.36931311e-02f, 1.24607660e-01f, -7.52443597e-02f, 2.58549787e-02f,
  1.35063499e-01f, -8.69903192e-02f, -7.85786211e-02f, 3.02803647e-02f, 4.16311212e-02f, 1.54588863e-01f, 1.29039362e-01f, 8.97379518e-02f, -3.18739004e-02f, -7.32155591e-02f,
  1.33145988e-01f, 1.23613581e-01f, 6.15860708e-02f, 1.02152638e-01f, -1.95924222e-01f, 6.48388192e-02f, -1.35464981e-01f, 1.93856210e-02f, 6.85501322e-02f, -6.23671077e-02f,
  1.03380978e-01f, -3.94778214e-02f, -5.29139414e-02f, -9.57499668e-02f, -1.72894765e-02f, -1.01800092e-01f, -3.77290137e-02f, 6.35664612e-02f, -1.03128254e-01f, -5.09419702e-02f,
  1.63345352e-01f, -2.15946168e-01f, 8.97933096e-02f, 1.19770750e-01f, -9.83122811e-02f, 1.49094993e-02f, -8.21529073e-04f, -4.95222537e-03f, 6.84158802e-02f, -1.65440470e-01f,
  9.95861460e-03f, -5.96117266e-02f, -1.12572066e-01f, 9.75437835e-03f, 1.55274317e-01f, 1.91911265e-01f, 3.22209261e-02f, 8.37236270e-02f, -3.81343737e-02f, -1.04625836e-01f,
  -2.70899236e-01f, 6.80766404e-02f, -2.59653479e-02f, -3.43327969e-02f, -6.09012991e-02f, -1.40820280e-01f, -4.75069396e-02f, -4.22441885e-02f, -4.38624341e-03f, 6.34884983e-02f,
  -1.05892919e-01f, -1.15962259e-01f, -2.66314149e-02f, -8.71962085e-02f, 3.52276256e-03f, 1.07030980e-01f, -6.56785443e-02f, 5.45528084e-02f, 1.05359927e-01f, -7.09598586e-02f,
  1.08153135e-01f, -1.05135351e-01f, 1.77686717e-02f, -9.69724208e-02f, 4.36252207e-02f, 8.77167881e-02f, 2.47614714e-03f, 1.27753615e-01f, 2.62756377e-01f, 1.75279394e-01f,
  3.35843191e-02f, 9.40918550e-02f, 7.15958402e-02f, 7.10610896e-02f, -1.48786053e-01f, -2.90628169e-02f, 3.09771001e-02f, 2.59905130e-01f, 4.16913182e-02f, -2.06916153e-01f,
  -1.13139994e-01f, 9.39908251e-03f, 1.16549402e-01f, 6.02954105e-02f, -2.13358536e-01f, -1.42939566e-02f, 1.06366120e-01f, -1.19503118e-01f, 1.33382544e-01f, 1.15720987e-01f,
  -1.72518924e-01f, 1.06767073e-01f, -6.20600171e-02f, -8.25403854e-02f, -7.52892792e-02f, 5.51786982e-02f, -9.13665816e-02f, -9.54119787e-02f, -1.36525750e-01f, -1.65830031e-01f,
  6.40181005e-02f, 1.52047545e-01f, -6.56981319e-02f, -9.47387610e-03f, 1.20601710e-02f, 6.18258631e-03f, -8.29144120e-02f, -1.33965865e-01f, -1.84830502e-02f, 3.05293277e-02f,
  8.62310231e-02f, 6.00603372e-02f, -6.39869191e-04f, 1.69848815e-01f, -3.72803546e-02f, 6.20163120e-02f, 1.04891911e-01f, 5.37980087e-02f, 1.44723123e-02f, 1.36950081e-02f,
  9.01988596e-02f, -2.98772287e-02f, 6.02274351e-02f, 1.03715450e-01f, 1.03149146e-01f, 3.11299320e-02f, 1.36788830e-01f, -9.63954255e-02f, 2.63573062e-02f, -4.87234443e-02f,
  5.82494251e-02f, 9.38456059e-02f, -3.01650882e-01f, 5.35846762e-02f, -1.74045637e-02f, 3.69049579e-01f, 7.58767202e-02f, -9.04315412e-02f, 2.10720122e-01f, 1.78362466e-02f,
  1.26809031e-01f, 1.88848674e-01f, -3.43788862e-02f, -5.31341247e-02f, -8.95864815e-02f, -2.14080021e-01f, -1.82322130e-01f, -7.34588951e-02f, 1.59944430e-01f, -2.91595757e-01f,
  1.41869545e-01f, -1.61820203e-02f, -9.50662643e-02f, 5.33974245e-02f, 1.42359108e-01f, -7.16725215e-02f, -5.11365458e-02f, 2.70033270e-01f, 1.50772452e-01f, 1.15494616e-01f,
  1.18053257e-01f, -1.09351642e-01f, -2.34562661e-02f, 8.05260912e-02f, -1.69424545e-02f, 5.54536954e-02f, 8.54947343e-02f, 1.01429924e-01f, -1.81841657e-01f, 1.59441069e-01f,
  -1.17479555e-01f, 8.37087184e-02f, 4.65977006e-02f, -1.42879426e-01f, 9.04717445e-02f, -1.60860848e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.08009376e-01f, 1.80130452e-01f, -5.02610914e-02f, 4.58412245e-02f, 1.22960314e-01f, 8.84709414e-03f, -1.06931046e-01f, 1.49635062e-01f, -3.57159525e-02f, 7.28752092e-02f,
  1.35875478e-01f, 1.36429802e-01f, 9.88571569e-02f, 1.27482459e-01f, 5.82690053e-02f, -5.39061707e-03f, -2.94790789e-03f, 1.31259352e-01f, 7.50310868e-02f, 1.71524391e-01f,
  -6.82083145e-02f, 5.58484234e-02f, 1.63181983e-02f, 6.82033673e-02f, 1.00838989e-01f, 4.33230661e-02f, 1.20803215e-01f, 1.80596381e-01f, 1.67052105e-01f, -1.74681656e-02f,
  4.93389852e-02f, -4.96027013e-03f, -1.29814312e-01f, 1.04035504e-01f, -1.26006112e-01f, 7.53549561e-02f, 8.99571553e-02f, -2.45750286e-02f, 4.29159142e-02f, 3.79609354e-02f,
  -1.38604060e-01f, 1.15000144e-01f, 1.54471984e-02f, 4.28497717e-02f, -9.82959941e-02f, 1.03656217e-01f, 1.69706777e-01f, -6.07719533e-02f, 2.61839312e-02f, 1.23073801e-01f,
  4.71583754e-02f, -2.39420384e-02f, 1.85105428e-02f, 2.12727949e-01f, -6.16362914e-02f, -1.05037764e-01f, -1.48501769e-01f, 6.78383037e-02f, -5.76486103e-02f, -1.23223484e-01f,
  -8.25273991e-02f, 9.31877829e-03f, -5.54689730e-04f, -7.55213201e-02f, -6.86914474e-02f, 1.43277764e-01f, 6.84740543e-02f, 1.08433636e-02f, -7.06762522e-02f, 8.49978626e-02f,
  -8.80280584e-02f, 3.78955528e-02f, 4.54513878e-02f, -1.03520662e-01f, 8.63711312e-02f, -8.06079730e-02f, 9.52045396e-02f, -6.01813719e-02f, -5.56064537e-04f, 1.36406556e-01f,
  -4.02392037e-02f, -3.77050638e-02f, 1.49662858e-02f, -1.26799271e-01f, 1.06558632e-02f, -6.23955429e-02f, 1.47036642e-01f, -1.51061341e-02f, 1.45863071e-01f, 1.99290410e-01f,
  -1.50310576e-01f, -4.93537337e-02f, 3.96527573e-02f, 1.79312840e-01f, -1.92342430e-01f, 1.17023271e-02f, 1.04678400e-01f, -2.21905157e-01f, -6.35547610e-03f, -1.28325984e-01f,
  -5.83112650e-02f, 8.84669200e-02f, 8.36564004e-02f, 1.87289398e-02f, -5.97908981e-02f, 1.51206637e-02f, 7.00274631e-02f, -1.18466981e-01f, -3.39944400e-02f, 2.35828355e-01f,
  2.82573197e-02f, 5.70316352e-02f, -7.35129863e-02f, 3.38783190e-02f, -1.17712095e-01f, 6.40922859e-02f, 1.20460436e-01f, -1.25923693e-01f, 1.34855568e-01f, -1.30278468e-02f,
  2.60115921e-01f, 1.27344534e-01f, -1.36473849e-01f, 1.78239569e-01f, 1.12721749e-01f, -9.36724842e-02f, -3.15806381e-02f, -5.87382028e-03f, -5.51051088e-02f, 1.00004680e-01f,
  4.80232313e-02f, -7.73569867e-02f, 1.25526898e-02f, 1.45812660e-01f, 1.07340798e-01f, -4.50136326e-02f, 7.44968951e-02f, 9.81882066e-02f, 1.07700199e-01f, -6.98747784e-02f,
  1.40229732e-01f, -4.93525751e-02f, 3.23185436e-02f, 4.29144911e-02f, -3.14615555e-02f, -3.03367823e-02f, -1.34139583e-01f, -2.41313577e-01f, -1.07718073e-01f, -1.73391610e-01f,
  -5.03100641e-02f, 6.06653690e-02f, 7.54432753e-03f, 1.95549250e-01f, 6.56951964e-02f, -2.24859297e-01f, -5.54130524e-02f, 1.83457315e-01f, -2.22069994e-01f, -1.95688903e-02f,
  1.30571038e-01f, -1.80082783e-01f, 3.19470502e-02f, -1.70157701e-01f, -1.89875081e-01f, 2.08308641e-02f, 5.10456332e-04f, -8.24244395e-02f, 1.21831037e-01f, -3.33679244e-02f,
  -9.84206498e-02f, -4.39255089e-02f, 5.79904690e-02f, -4.42602672e-02f, -1.48256728e-02f, -1.22988589e-01f, 1.14935532e-01f, 8.84818733e-02f, -1.49316475e-01f, 1.03710517e-01f,
  -1.00097142e-01f, -2.42091969e-01f, -1.14573851e-01f, -1.04380600e-01f, 3.04049969e-01f, 3.05048347e-01f, -2.85961237e-02f, 1.73138618e-01f, -2.27771550e-02f, -1.17788520e-02f,
  6.12355210e-02f, 5.10459282e-02f, -8.88152346e-02f, 6.04789518e-02f, -8.09352100e-02f, -5.13086207e-02f, 1.00032322e-01f, -1.90893316e-03f, -1.12568177e-01f, 8.28216225e-02f,
  5.14167473e-02f, -2.86201946e-02f, -9.01563466e-02f, -1.08823068e-01f, 6.02631718e-02f, -1.07700743e-01f, 2.63241939e-02f, -1.06910393e-01f, -2.11332794e-02f, -6.19031489e-02f,
  1.22635074e-01f, 1.10026285e-01f, -2.12808140e-02f, -1.15438834e-01f, 3.22010815e-02f, 4.83200438e-02f, -7.11416230e-02f, -3.85772921e-02f, 7.19078258e-02f, 1.06381051e-01f,
  2.85158213e-02f, -3.11056674e-02f, -1.24672070e-01f, -9.74454209e-02f, -1.99309476e-02f, -6.75556809e-02f, -8.33753555e-04f, 9.65769812e-02f, 6.37247786e-02f, -9.70121995e-02f,
  -1.21715218e-01f, -2.04046033e-02f, 1.25651300e-01f, 4.21824753e-02f, 2.73389891e-02f, -6.03815615e-02f, 8.29046369e-02f, -7.17891604e-02f, -1.15457989e-01f, 1.01861976e-01f,
  1.26574233e-01f, -7.06613436e-02f, -7.05323964e-02f, -4.25382853e-02f, -8.45417827e-02f, -1.11740291e-01f, 7.23872185e-02f, -4.90163900e-02f, 8.62361714e-02f, -3.12992893e-02f,
  3.10489964e-02f, 1.27338037e-01f, 4.95078079e-02f, 2.80747991e-02f, -6.22242056e-02f, -6.77528083e-02f, 3.64101902e-02f, -4.16417420e-02f, -6.86263442e-02f, -3.04761287e-02f,
  1.51730422e-02f, -8.57603699e-02f, 1.62130408e-02f, 1.20782331e-01f, 8.72101039e-02f, -1.16443023e-01f, -1.13640644e-01f, -7.91424289e-02f, -6.93289936e-02f, 1.07731419e-02f,
  -2.61720419e-02f, 3.25346962e-02f, 8.04127529e-02f, 2.90809330e-02f, -3.04344017e-02f, 3.94102074e-02f, 1.13799851e-02f, 2.87164133e-02f, -8.34530368e-02f, 4.98360209e-02f,
  7.06827492e-02f, 3.50027271e-02f, 8.77208486e-02f, 1.11730561e-01f, 6.54148534e-02f, 9.29421857e-02f, 1.32647783e-01f, -9.98744369e-02f, 7.50246719e-02f, 1.08630821e-01f,
  -3.90149392e-02f, 1.02099344e-01f, -8.44467133e-02f, 6.57636020e-03f, 8.38635042e-02f, -1.66382492e-02f, 2.35299189e-02f, 8.07157625e-03f, 1.24952585e-01f, 3.73794921e-02f,
  2.51333863e-02f, -9.66674462e-02f, -9.03160200e-02f, -1.17180340e-01f, 3.87868360e-02f, -1.10602416e-01f, 1.90174431e-02f, 9.70039610e-03f, 1.55769326e-02f, -6.63452074e-02f,
  -1.73214618e-02f, 1.23253420e-01f, 1.09886363e-01f, 4.52131145e-02f, 7.19380975e-02f, 3.06231063e-02f, -1.06932826e-01f, 6.69982210e-02f, -3.76644399e-04f, -8.21435302e-02f,
  -1.19542152e-01f, -4.34360318e-02f, 9.09406394e-02f, 4.49795201e-02f, -6.72244504e-02f, 9.67857018e-02f, -2.62658931e-02f, 1.21293850e-01f, 1.40849248e-01f, -6.54515848e-02f,
  -9.31946095e-03f, 2.89596543e-02f, 1.27571046e-01f, -1.02639738e-02f, -8.73094946e-02f, 8.62252712e-02f, -5.99398576e-02f, 3.60966474e-02f, -1.34833798e-01f, -1.58977300e-01f,
  1.60600781e-01f, -8.00025389e-02f, 1.54551879e-01f, -1.97652634e-02f, 6.64455593e-02f, 3.95370051e-02f, -2.01865472e-02f, -2.23269574e-02f, -1.27722263e-01f, 1.91942483e-01f,
  -2.14639809e-02f, -2.92952340e-02f, 1.34985566e-01f, -1.27436250e-01f, 8.75588283e-02f, 2.20362353e-03f, -6.93440363e-02f, 2.18547937e-02f, -1.01578467e-01f, 5.93951754e-02f,
  3.34892310e-02f, 5.65097705e-02f, -9.69334692e-02f, -5.07194325e-02f, 1.29802227e-01f, 6.73325807e-02f, -9.10139158e-02f, -1.20942118e-02f, 4.23118658e-03f, 1.31764546e-01f,
  -6.69528618e-02f, 8.02235305e-02f, -3.33751459e-03f, -5.54300249e-02f, 1.28646083e-02f, -7.21290857e-02f, 1.57907471e-01f, 2.44725958e-01f, 1.07781306e-01f, 1.07132338e-01f,
  -2.64299661e-02f, 1.95061695e-02f, 1.21333815e-01f, -1.04847878e-01f, -1.04784101e-01f, -5.45062609e-02f, -1.38760628e-02f, 5.20152897e-02f, -3.77989225e-02f, -1.20331710e-02f,
  -8.78924653e-02f, 7.82944486e-02f, 5.34933917e-02f, -5.75012527e-02f, 5.93641438e-02f, -3.14324945e-02f, -1.23295628e-01f, -3.04319169e-02f, -5.24746031e-02f, -8.78859684e-02f,
  5.22814766e-02f, -1.28432810e-01f, -2.33175419e-03f, 4.43086736e-02f, -8.39284435e-02f, 1.06952436e-01f, -1.35033419e-02f, 8.20590854e-02f, -9.37052518e-02f, -9.70879346e-02f,
  -3.71348150e-02f, -1.33819589e-02f, 7.20937774e-02f, 9.23124030e-02f, 1.57437120e-02f, 8.26331303e-02f, 6.39717355e-02f, -3.14042121e-02f, -6.41035438e-02f, -4.45982404e-02f,
  -6.57902062e-02f, 1.22739207e-02f, 9.35081691e-02f, -7.84540027e-02f, 1.47730077e-03f, 1.62965208e-02f, 1.26193345e-01f, 9.99746472e-02f, 1.00867800e-01f, 2.56210286e-02f,
  9.60186869e-02f, 3.87677364e-02f, 9.75342691e-02f, 1.15245514e-01f, 1.08031638e-01f, 2.08951347e-02f, 1.03501581e-01f, 3.10052987e-02f, 3.25907655e-02f, -8.41464847e-02f,
  -1.11094862e-01f, 1.98168159e-02f, -7.29304478e-02f, 8.66766945e-02f, -3.00997272e-02f, -6.85555115e-02f, 9.34663415e-03f, -3.23211662e-02f, 6.70986902e-03f, -1.00912176e-01f,
  -4.50393744e-02f, 1.56807125e-01f, 8.25248882e-02f, 2.83661224e-02f, 1.09065305e-02f, -7.26542920e-02f, 1.08810984e-01f, -1.23186871e-01f, 1.64367765e-01f, 1.54755026e-01f,
  1.53012108e-02f, 7.80292749e-02f, 1.67531297e-02f, 3.91041264e-02f, -4.81434576e-02f, -8.64689276e-02f, -4.96787764e-02f, -1.58993602e-01f, -2.66666234e-01f, -1.24733239e-01f,
  -1.81182660e-02f, 4.22604717e-02f, -1.08287163e-01f, -3.08429971e-02f, 7.02105910e-02f, -4.70254198e-03f, 1.18114434e-01f, -4.75534499e-02f, 5.40595502e-02f, 2.20109046e-01f,
  1.54901564e-01f, 1.88657064e-02f, -2.22748384e-01f, -4.06466313e-02f, 1.42326623e-01f, -9.37112495e-02f, -6.01554625e-02f, 5.14885783e-02f, 1.02008022e-01f, 3.92966866e-02f,
  -5.21430513e-03f, -1.01789817e-01f, -7.05095530e-02f, 2.72906303e-01f, -4.25806232e-02f, -4.57317457e-02f, 2.68860847e-01f, -8.33422542e-02f, 3.46075594e-02f, 3.33928347e-01f,
  -7.00338855e-02f, 1.77737996e-01f, -3.04113384e-02f, 1.12570152e-01f, -2.59156264e-02f, 8.51309299e-02f, -7.58082345e-02f, -5.20811882e-03f, 2.87455413e-02f, -3.43507826e-02f,
  -4.79348265e-02f, -4.50963192e-02f, 5.14604971e-02f, 8.67961720e-02f, 1.84128582e-01f, 5.78417368e-02f, 1.00063160e-01f, 1.46295860e-01f, 1.27485961e-01f, 2.17639312e-01f,
  6.87919185e-02f, 1.94007665e-01f, -5.99070312e-03f, 2.15386689e-01f, 1.99829593e-01f, 9.76409689e-02f, 1.63476199e-01f, 2.03473717e-01f, 1.16066270e-01f, 1.70818076e-01f,
  1.35906145e-01f, 1.12414762e-01f, 4.06055838e-01f, -1.51951239e-01f, 3.05203497e-01f, -2.77356595e-01f, 8.38349313e-02f, 1.80363014e-01f, -3.08965951e-01f, -4.46364433e-02f,
  -1.01366885e-01f, 7.00910762e-02f, -4.50351741e-03f, -2.26333529e-01f, 6.42709434e-02f, 7.56183453e-03f, 3.66630346e-01f, -6.02247342e-02f, -1.82935551e-01f, 3.35218430e-01f,
  4.11621258e-02f, 6.90313652e-02f, 1.38097480e-01f, 1.01926103e-01f, -1.05715893e-01f, 6.04835004e-02f, 2.87914395e-01f, -7.28480443e-02f, -1.99484959e-01f, -1.42126098e-01f,
  -1.72251925e-01f, 2.06957310e-01f, 8.06740224e-02f, -7.73881301e-02f, -2.89062057e-02f, -2.66999565e-02f, 7.57352076e-03f, -8.10703114e-02f, 3.94960523e-01f, 1.45452559e-01f,
  1.16953805e-01f, 1.91609368e-01f, -1.36115821e-02f, 4.16151695e-02f, 9.10551399e-02f, 6.43306738e-03f, 3.43718613e-03f, -1.06165953e-01f, 9.16961879e-02f, 7.50521244e-03f,
  -8.65322351e-02f, 3.81567925e-02f, 1.22173633e-02f, -1.08142003e-01f, -7.88307190e-02f, -4.57854941e-02f, -4.35937494e-02f, 1.44043453e-02f, -9.79224741e-02f, 5.47363013e-02f,
  3.73441353e-02f, 1.15869089e-03f, 1.66617930e-02f, 9.74822715e-02f, 3.53287868e-02f, 6.01834208e-02f, 3.36600877e-02f, 2.57280841e-02f, 5.71434461e-02f, 2.58903131e-02f,
  -7.15049636e-03f, 1.30312398e-01f, -8.40971991e-02f, 8.57285634e-02f, -1.20869137e-01f, -6.46992102e-02f, -1.03296563e-02f, 1.02351889e-01f, 1.00246452e-01f, 8.34979340e-02f,
  -1.32803723e-01f, 7.50847235e-02f, -3.98540162e-02f, 7.62853958e-03f, -5.94254546e-02f, 7.35332519e-02f, 4.58120964e-02f, -7.93910548e-02f, 7.57570118e-02f, -1.16294473e-01f,
  6.61256686e-02f, -2.61496287e-02f, 2.91908085e-02f, -3.31254080e-02f, -5.28751910e-02f, -8.81573260e-02f, -3.78924832e-02f, -7.96498507e-02f, 1.15198851e-01f, -1.03547387e-01f,
  6.19751634e-03f, -8.23972970e-02f, 1.64457619e-01f, 4.77293842e-02f, 3.69204395e-02f, 1.15194745e-01f, 5.88840898e-03f, -6.80356026e-02f, 5.93996719e-02f, -4.47503664e-02f,
  -1.05691301e-02f, 8.36952776e-02f, 1.38204485e-01f, 5.49947917e-02f, 4.08578962e-02f, -5.96542768e-02f, -1.00067519e-02f, 8.86074677e-02f, 4.92150262e-02f, -2.43225880e-02f,
  -8.65600705e-02f, 2.44267415e-02f, -5.94961978e-02f, -2.33022552e-02f, -4.98515777e-02f, 4.61973585e-02f, 7.93113708e-02f, 1.32445842e-01f, -9.54145938e-02f, -6.52239174e-02f,
  7.07276305e-03f, -1.57580022e-02f, -1.72762983e-02f, 9.88199562e-02f, -7.19612688e-02f, 1.02493703e-01f, -2.35049836e-02f, -8.43371227e-02f, -7.70851746e-02f, 1.17185846e-01f,
  5.53808222e-03f, 7.18271825e-03f, 1.34701267e-01f, -7.16291815e-02f, 1.14496581e-01f, -1.22478008e-01f, -5.25531657e-02f, -7.49183148e-02f, 1.21574312e-01f, 4.79261242e-02f,
  -6.01864979e-02f, -6.23071045e-02f, 7.04216063e-02f, -9.80083793e-02f, 1.05419070e-01f, -5.49956523e-02f, -7.90505633e-02f, 3.99956405e-02f, 6.77248612e-02f, -9.22614112e-02f,
  3.18981707e-02f, 8.36862922e-02f, 1.62284113e-02f, -7.81984925e-02f, -3.58632803e-02f, -1.08164594e-01f, 6.34869211e-04f, -9.51052010e-02f, 9.85958055e-02f, 1.18517809e-01f,
  -1.30474418e-01f, 1.22746170e-01f, -5.31499945e-02f, 3.96632142e-02f, 1.76590785e-01f, 1.18056163e-01f, 8.45641270e-02f, -2.02555545e-02f, -1.67784262e-02f, 1.59777254e-01f,
  -2.76513621e-02f, -1.80974398e-02f, -1.10763647e-02f, 1.66233003e-01f, 1.65203720e-01f, -5.57045527e-02f, 1.04785979e-01f, 4.40856665e-02f, -5.83487637e-02f, 4.44443524e-02f,
  1.40928581e-01f, -4.33512516e-02f, -6.97269663e-02f, -1.01529889e-01f, -7.58017376e-02f, -2.21170306e-01f, -7.61601254e-02f, -1.18224137e-01f, -3.32858749e-02f, 4.61579077e-02f,
  2.00936601e-01f, 9.28034782e-02f, 1.02963313e-01f, -7.44790360e-02f, 3.67354751e-02f, 2.22175092e-01f, 4.22272719e-02f, -4.52335663e-02f, -5.44852912e-02f, 1.35005862e-02f,
  1.91351771e-02f, -3.47002782e-02f, -2.98100375e-02f, -5.23298867e-02f, 2.43602134e-02f, -1.34659797e-01f, 1.15934514e-01f, -1.25621811e-01f, 6.96102530e-02f, -1.00781433e-01f,
  1.05181225e-02f, 1.06472328e-01f, 1.74036101e-01f, -1.27769671e-02f, 1.38509929e-01f, 2.05722883e-01f, -8.86227116e-02f, -2.59740371e-02f, 6.94593042e-02f, -8.06736127e-02f,
  2.18321875e-01f, 4.27518561e-02f, -2.13807598e-02f, 1.31849453e-01f, -4.52536810e-03f, -3.88326570e-02f, -7.43651902e-03f, -1.17865518e-01f, 1.34937093e-01f, -9.53049436e-02f,
  -3.46120857e-02f, -5.80881275e-02f, 3.85131501e-03f, -7.12839887e-02f, 7.57231191e-02f, -7.20876381e-02f, 9.70341042e-02f, -1.19552858e-01f, -3.27238925e-02f, 9.65832025e-02f,
  3.78582962e-02f, 2.83690337e-02f, -5.39996140e-02f, 3.55223902e-02f, -8.52999985e-02f, -2.05027615e-03f, 7.47627765e-02f, 3.41224559e-02f, -8.30546841e-02f, -8.31511393e-02f,
  7.41253868e-02f, 1.09793851e-02f, -2.19691489e-02f, 7.09524751e-02f, 1.74311846e-02f, 8.95269513e-02f, 4.74064499e-02f, -1.23228461e-01f, 1.41417459e-02f, -4.25014980e-02f,
  9.77272838e-02f, -9.27187130e-02f, -7.98494648e-03f, 1.54024241e-02f, 1.01319320e-01f, -1.36514038e-01f, -6.21382967e-02f, -6.65495396e-02f, -2.08612457e-02f, 7.57609159e-02f,
  -3.44106704e-02f, -9.72175673e-02f, -1.13031082e-01f, 3.28720361e-02f, 8.65409076e-02f, 6.20567650e-02f, 9.66834202e-02f, -5.73385274e-03f, -5.31431027e-02f, 1.44060729e-02f,
  -2.17937399e-02f, -7.41664181e-03f, -4.18812931e-02f, -5.94782643e-02f, -9.75837633e-02f, 1.21250823e-02f, 7.78896138e-02f, 6.29533753e-02f, 4.51229736e-02f, 1.17561333e-01f,
  -7.60342777e-02f, -6.72066063e-02f, 1.15350008e-01f, 1.37330800e-01f, -6.31855503e-02f, 1.03863098e-01f, 1.92335378e-02f, -2.15276014e-02f, -5.74053116e-02f, 8.07209983e-02f,
  -5.82921319e-02f, 1.26631543e-01f, -1.42768687e-02f, 1.00460611e-02f, 1.53447330e-01f, 7.97365755e-02f, 4.79388051e-02f, 2.21292228e-01f, 1.41668111e-01f, 7.95942843e-02f,
  -1.18653968e-01f, 9.92299020e-02f, 2.07895473e-01f, -1.55336350e-01f, -8.19318816e-02f, 3.73269394e-02f, -8.34078714e-02f, 1.49255380e-01f, 2.48257187e-03f, -9.50374529e-02f,
  -1.05969228e-01f, -4.24482115e-03f, -8.71472433e-02f, -1.34383887e-01f, 3.70172560e-02f, -6.08778149e-02f, 1.37875736e-01f, 5.97732887e-02f, -1.05570972e-01f, 1.10547096e-01f,
  -1.12655804e-01f, -8.77960250e-02f, 8.13241079e-02f, 4.51131724e-02f, 3.59654874e-02f, -4.73169722e-02f, 3.32971960e-02f, -1.04844883e-01f, -4.04869132e-02f, -8.49182010e-02f,
  8.99315551e-02f, -1.71454449e-04f, -1.35570884e-01f, 1.14565846e-02f, 2.91428082e-02f, 8.84091258e-02f, -2.33614072e-02f, 6.60630763e-02f, 2.71222144e-01f, 3.81154567e-02f,
  5.98366186e-02f, 6.23974949e-02f, -1.08588971e-01f, 9.82856527e-02f, 1.04205951e-01f, 9.57864523e-02f, -8.42573121e-03f, 2.11344197e-01f, 8.00662041e-02f, 5.21946475e-02f,
  1.27388194e-01f, -1.44730860e-04f, 2.42125154e-01f, 1.33958519e-01f, 2.43480846e-01f, 1.43750280e-01f, 1.16917647e-01f, -3.15458179e-02f, -2.11456921e-02f, 1.08932182e-01f,
  1.76769152e-01f, 1.37722611e-01f, 1.23154357e-01f, 2.01305032e-01f, 1.19262688e-01f, -2.24163875e-01f, 3.98304015e-02f, -2.38867283e-01f, -1.61688626e-01f, 1.21123217e-01f,
  2.02939585e-01f, -5.81838936e-02f, 2.69940067e-02f, -2.55393624e-01f, -5.95429912e-03f, -2.23553091e-01f, 6.09192029e-02f, 1.59094170e-01f, -2.61266846e-02f, 5.16250767e-02f,
  -7.82572478e-02f, 4.30693105e-03f, -7.23318150e-03f, 4.20463160e-02f, 9.14086327e-02f, -8.64575338e-03f, 1.22734770e-01f, 2.30581239e-02f, 7.84821343e-03f, 6.36243299e-02f,
  -7.01869130e-02f, -3.01284492e-01f, 2.41438508e-01f, 1.42017230e-01f, 1.61355317e-01f, 1.56246708e-03f, -8.68476927e-02f, 2.81783670e-01f, -3.19446772e-02f, -3.20130020e-01f,
  -1.72891289e-01f, -7.27711022e-02f, 2.30007932e-01f, -8.58956277e-02f, 1.38640374e-01f, 6.58784211e-02f, -6.61918148e-02f, 1.25181481e-01f, 4.02340181e-02f, 9.14160013e-02f,
  1.18072098e-02f, 2.41341125e-02f, -4.18965742e-02f, -6.53498024e-02f, -2.91373562e-02f, -4.25302163e-02f, 9.90600511e-02f, -1.48347644e-02f, -7.24876970e-02f, -8.51467177e-02f,
  -2.03892626e-02f, 1.24420032e-01f, 1.48685157e-01f, 1.45540538e-03f, 7.08690286e-02f, -7.63070360e-02f, -6.60618246e-02f, -1.85637306e-02f, -8.74451548e-02f, 3.04779653e-02f,
  -1.23321297e-04f, 9.34035610e-03f, 5.48992977e-02f, 1.37588039e-01f, 7.60190710e-02f, 1.17846522e-02f, 5.65275401e-02f, -7.49186575e-02f, 5.50993234e-02f, -4.04663570e-02f,
  -1.46629795e-01f, 1.09131135e-01f, -3.17809582e-02f, 1.38344476e-04f, -9.64880958e-02f, 2.17488427e-02f, 2.17679963e-02f, -6.76997826e-02f, -3.57107408e-02f, -1.12160333e-01f,
  -5.33368960e-02f, -7.08456635e-02f, 7.64067248e-02f, 6.93903416e-02f, -5.80412783e-02f, 2.98303459e-02f, 8.28246027e-03f, 1.97786968e-02f, -1.17076375e-01f, 9.08564255e-02f,
  9.44518298e-02f, 5.30754849e-02f, -1.14325993e-01f, -1.20629504e-01f, -8.69065151e-02f, 1.17770575e-01f, -3.57790850e-02f, -1.00423694e-01f, 2.76688468e-02f, -7.62298331e-02f,
  -1.04048505e-01f, -1.02059774e-01f, -8.43975544e-02f, -5.73781915e-02f, 9.05315503e-02f, -5.41314036e-02f, 1.12176575e-01f, 5.38025163e-02f, 8.60571116e-02f, -2.22542770e-02f,
  1.80424452e-01f, 1.05161235e-01f, 1.96288869e-01f, 8.13717246e-02f, 1.42562212e-02f, 3.40296403e-02f, 2.15897024e-01f, 2.56978005e-01f, 1.15262046e-01f, 6.26056120e-02f,
  1.17924683e-01f, 1.34575471e-01f, 2.06759572e-01f, -7.25918934e-02f, 2.32849956e-01f, 8.51145163e-02f, 1.16573200e-01f, 3.34459282e-02f, -2.98727136e-02f, 1.08352356e-01f,
  -2.37466916e-01f, -1.10084556e-01f, -1.47944346e-01f, 2.06513897e-01f, 9.47617181e-03f, -1.30064979e-01f, -1.19290531e-01f, -8.50457847e-02f, 2.26610094e-01f, -2.12423950e-01f,
  -2.12777719e-01f, 3.25100236e-02f, 6.23906888e-02f, -6.41784072e-02f, 3.59455124e-02f, -1.03294134e-01f, -7.84257203e-02f, 8.86686321e-04f, -7.95298144e-02f, 1.41891047e-01f,
  1.77827522e-01f, -6.27259165e-02f, -8.59072655e-02f, 1.64102182e-01f, -8.27775225e-02f, -1.39138356e-01f, 1.90533642e-02f, -9.43674147e-02f, -1.60228580e-01f, 1.45431911e-03f,
  9.04226974e-02f, 2.47547060e-01f, -8.84545147e-02f, 2.04644650e-01f, 2.05112761e-03f, -9.72645432e-02f, 1.15485966e-01f, -4.63834405e-02f, -2.03455333e-02f, -1.01640187e-02f,
  -8.72949287e-02f, -2.04888731e-02f, 1.30413726e-01f, -1.40418317e-02f, 3.70080397e-02f, -9.83825177e-02f, 4.60649580e-02f, 2.01257598e-02f, 1.11185409e-01f, -9.26832706e-02f,
  7.37838000e-02f, 6.81687370e-02f, -9.76689532e-02f, 8.53012651e-02f, -4.05284539e-02f, 2.37268340e-02f, 6.54591769e-02f, -2.67733764e-02f, -7.86864106e-03f, -3.37954015e-02f,
  -1.08266354e-01f, -6.65429533e-02f, -6.51164725e-02f, -5.23742475e-02f, -1.25591522e-02f, -3.10308505e-02f, -6.91766366e-02f, -2.69742161e-02f, -7.12038428e-02f, 1.38280421e-01f,
  2.11547837e-02f, -2.69293953e-02f, 1.16300300e-01f, 8.24167803e-02f, -4.09563741e-04f, -5.83651327e-02f, -1.03944607e-01f, 3.46511677e-02f, -5.47229946e-02f, -9.13966522e-02f,
  7.36391991e-02f, 1.08087234e-01f, 1.59297083e-02f, -9.37164500e-02f, -2.78342292e-02f, -3.84414271e-02f, 1.40176222e-01f, 3.52936634e-03f, 6.13381639e-02f, -3.21649387e-02f,
  8.24536681e-02f, -1.14461593e-01f, 1.31709017e-02f, -3.79219055e-02f, 1.20286107e-01f, -1.36954546e-01f, 1.45652164e-02f, -7.81003907e-02f, 5.51117547e-02f, 1.07127510e-01f,
  -1.01792686e-01f, 9.96059477e-02f, 8.15780982e-02f, 8.09755772e-02f, -3.65916751e-02f, 2.99123172e-02f, -5.63580506e-02f, -2.24904343e-02f, 5.10840490e-02f, 4.97087799e-02f,
  -4.86860387e-02f, -3.46053280e-02f, -3.83028649e-02f, -6.52689785e-02f, -3.55684683e-02f, -3.76848467e-02f, -1.10974557e-04f, -3.53853106e-02f, 1.27631977e-01f, -5.33239618e-02f,
  1.17934428e-01f, 2.75023058e-02f, -1.08739480e-01f, 5.46231568e-02f, 3.61160189e-03f, 2.11511049e-02f, 2.19041556e-02f, 1.07955737e-02f, -4.57073823e-02f, -1.13880597e-01f,
  3.09445020e-02f, 7.72157684e-02f, -4.82188277e-02f, -6.42366931e-02f, -3.06211710e-02f, 5.01187108e-02f, -4.04486917e-02f, 5.89489453e-02f, -5.86879961e-02f, 1.11527547e-01f,
  -1.12891763e-01f, 3.14920656e-02f, 1.18225530e-01f, -1.06361330e-01f, 3.95949259e-02f, -1.10468738e-01f, -4.48447885e-03f, 1.13134541e-01f, -1.30726527e-02f, 1.12193480e-01f,
  1.76640488e-02f, -1.16513588e-01f, -1.00224324e-01f, -8.86487737e-02f, 1.06828272e-01f, -1.19097680e-01f, -5.90869412e-02f, -5.45852482e-02f, -6.59800619e-02f, 1.29158139e-01f,
  -5.15213460e-02f, -1.10050619e-01f, 6.98111057e-02f, -1.17043413e-01f, 8.23249668e-02f, -2.89414003e-02f, 1.45109966e-01f, 1.53514117e-01f, 5.08250259e-02f, 5.45380786e-02f,
  6.30092099e-02f, 5.39367050e-02f, 2.30800629e-01f, -4.30674180e-02f, 1.40007138e-01f, 1.85029998e-01f, 2.28955343e-01f, 4.38841172e-02f, 2.12602943e-01f, 1.47008330e-01f,
  1.80555254e-01f, 1.35999992e-01f, 8.94240066e-02f, 1.14995353e-01f, 1.03790618e-01f, -1.09398738e-01f, -1.55759960e-01f, 1.28607333e-01f, -1.21325321e-01f, 3.24155182e-01f,
  4.16860655e-02f, 1.02881223e-01f, 1.51878834e-01f, -9.02497023e-02f, -1.04308571e-03f, 2.47439355e-01f, -7.76859820e-02f, -9.30200443e-02f, -1.14799291e-01f, -1.55478388e-01f,
  3.00242100e-02f, -4.14554924e-02f, -1.78576902e-01f, -2.48279169e-01f, -7.85927176e-02f, -1.47346765e-01f, 6.87275678e-02f, 5.38824089e-02f, -2.57373303e-02f, -9.16121751e-02f,
  -1.68670148e-01f, -5.62431216e-02f, 2.78413951e-01f, -7.23200217e-02f, -4.91176955e-02f, 2.10465342e-02f, 5.53135062e-03f, 1.53117046e-01f, 1.30859688e-02f, -2.77354363e-02f,
  3.46800778e-03f, 7.33931288e-02f, -1.73166081e-01f, 9.63179618e-02f, -1.35160908e-01f, -1.22365899e-01f, 9.93557051e-02f, -9.74032581e-02f, -2.89170090e-02f, 3.17031406e-02f,
  -6.51310086e-02f, -5.40210344e-02f, 1.04503848e-01f, 2.68932581e-02f, 8.70067850e-02f, -6.05224408e-02f, -6.49800301e-02f, -5.04982732e-02f, -4.82123569e-02f, 6.26558214e-02f,
  -6.67292327e-02f, 8.24073479e-02f, 1.57553907e-02f, -6.81964830e-02f, 1.24583304e-01f, 1.33160904e-01f, 1.44262975e-02f, 3.54217552e-02f, 1.45073667e-01f, -1.72933526e-02f,
  -2.92193610e-02f, -6.02887683e-02f, -1.10375918e-01f, 1.11848690e-01f, 4.38732579e-02f, -1.05257764e-01f, 3.67006175e-02f, -2.82139778e-02f, 1.04423061e-01f, -3.72259133e-02f,
  1.01677500e-01f, -5.63126914e-02f, -2.21042633e-02f, 1.45891383e-01f, -9.87860411e-02f, 1.36455819e-01f, -2.30517257e-02f, 9.82632637e-02f, -8.17971602e-02f, -9.76060554e-02f,
  -1.08241977e-03f, -1.99936666e-02f, 6.20388575e-02f, 4.91431616e-02f, 9.85263214e-02f, -1.41176075e-01f, 1.10141739e-01f, -9.87486988e-02f, 9.51549783e-02f, 1.24176107e-01f,
  2.03000456e-02f, 6.64324090e-02f, 4.46519814e-02f, -6.36441931e-02f, 6.18890822e-02f, 3.47515568e-02f, -1.25613576e-02f, 5.31183975e-03f, 9.47565064e-02f, -3.18584442e-02f,
  1.24191508e-01f, 4.41270359e-02f, 3.75258774e-02f, -8.41135979e-02f, 1.19480165e-02f, -6.34197369e-02f, -3.04522682e-02f, -3.50163914e-02f, 9.96913761e-02f, 1.28463656e-01f,
  -2.20777206e-02f, -9.06826742e-03f, -7.05222636e-02f, -2.72004418e-02f, -2.90949140e-02f, 1.29938081e-01f, -5.60202785e-02f, 1.14490889e-01f, 5.50405495e-02f, -2.56117098e-02f,
  -8.09796900e-02f, -1.20737024e-01f, 6.74899295e-02f, 5.34807183e-02f, 3.44519764e-02f, -9.32132676e-02f, -4.00572568e-02f, 8.75855982e-02f, -3.32662053e-02f, 6.16576597e-02f,
  -1.08624458e-01f, 9.73351523e-02f, 1.16000846e-01f, 2.18463242e-02f, -4.39758450e-02f, 1.46396652e-01f, 1.50059775e-01f, -8.49555805e-02f, -1.36860207e-01f, -1.07770331e-01f,
  6.46412298e-02f, 6.12689294e-02f, 1.22459136e-01f, 1.18816048e-02f, 5.78746647e-02f, 3.34051214e-02f, 1.29607081e-01f, 9.31152999e-02f, -9.15430784e-02f, 2.28270553e-02f,
  1.69998128e-02f, -2.85319779e-02f, -5.99311553e-02f, 1.24809608e-01f, -8.90162215e-02f, -6.11959174e-02f, 9.21538100e-02f, 8.10559690e-02f, 8.70580450e-02f, -6.96935654e-02f,
  1.68849170e-01f, -3.67748477e-02f, -5.60899936e-02f, -3.68235409e-02f, -8.49782117e-03f, 7.96246305e-02f, 5.82404956e-02f, 5.75693846e-02f, 1.80178314e-01f, -1.80435665e-02f,
  1.19423352e-01f, 6.20884006e-04f, 5.13040572e-02f, 1.66714489e-01f, -5.40634729e-02f, -3.59459631e-02f, 1.61498368e-01f, 2.38755960e-02f, -3.86716090e-02f, 8.59110802e-02f,
  -4.16641198e-02f, -2.46051531e-02f, 1.40425265e-01f, -5.54370061e-02f, 1.64446205e-01f, -1.79351475e-02f, 1.01610348e-01f, -2.14551743e-02f, 1.24474727e-01f, -1.47897929e-01f,
  9.70506445e-02f, -1.89229473e-01f, -7.48873800e-02f, -5.23264194e-03f, 2.38989163e-02f, 1.94660798e-01f, -1.43232778e-01f, -1.28304943e-01f, 1.65974841e-01f, 4.22122180e-02f,
  1.42274886e-01f, 1.50663242e-01f, -1.14875704e-01f, 1.72012106e-01f, 2.39062309e-01f, 1.13002777e-01f, -9.39701870e-02f, -3.89743224e-02f, 1.07911617e-01f, -3.49550024e-02f,
  -2.18096059e-02f, -5.32099903e-02f, 1.79137260e-01f, 7.02693686e-02f, -1.17438875e-01f, -7.37420022e-02f, -1.23400846e-02f, 1.34290248e-01f, 7.98838027e-03f, 1.60786554e-01f,
  -6.18859157e-02f, 1.12250693e-01f, 7.00981542e-02f, 1.18888699e-01f, 9.27891731e-02f, -7.54976645e-02f, 7.43325427e-02f, -9.91347358e-02f, 1.01922646e-01f, 1.17384670e-02f,
  -1.12518571e-01f, 2.39383075e-02f, 4.74829711e-02f, 1.19946133e-02f, 5.34558110e-02f, 2.01608077e-01f, 2.47479938e-02f, 1.62536144e-01f, 1.99498050e-02f, 1.27035439e-01f,
  3.64073762e-03f, 1.49928391e-01f, 3.08100190e-02f, 1.88709661e-01f, -7.05668703e-02f, -1.24139804e-02f, 4.55387123e-02f, 2.86780261e-02f, 1.01413704e-01f, 1.30787969e-01f,
  1.36727750e-01f, 7.90662989e-02f, 2.43356470e-02f, 1.95849195e-01f, 8.32179189e-02f, -3.29000801e-02f, -3.95790748e-02f, -2.07394332e-01f, 3.99759598e-02f, 1.21225804e-01f,
  -7.84226656e-02f, -2.17189752e-02f, -6.28741924e-03f, -8.01227391e-02f, 1.08171608e-02f, 9.91531536e-02f, 1.87258832e-02f, -5.94290197e-02f, 5.42922728e-02f, 1.10855706e-01f,
  -4.10685502e-02f, 5.16197719e-02f, -2.49389131e-02f, -4.56928946e-02f, 5.87467700e-02f, 3.08797378e-02f, 1.64959118e-01f, 5.69048598e-02f, 1.44512832e-01f, -8.92785564e-03f,
  2.01892536e-02f, -9.31008458e-02f, 1.19401261e-01f, -8.12181458e-02f, -7.44878352e-02f, 1.03910394e-01f, -1.46191623e-02f, -1.35714233e-01f, -6.44393265e-02f, -3.06723434e-02f,
  2.35834103e-02f, -1.24731906e-01f, 7.80603886e-02f, 1.32690771e-02f, -9.01506096e-02f, 6.32139817e-02f, 1.01286404e-01f, -1.09573834e-01f, -4.92572263e-02f, -1.19090863e-01f,
  -3.10529023e-02f, -1.10886976e-01f, 6.49875670e-04f, -9.65170283e-03f, -8.45601931e-02f, 9.90875959e-02f, 8.50255936e-02f, -1.03939557e-02f, -2.87452117e-02f, 1.00506552e-01f,
  -2.16307808e-02f, -3.84654962e-02f, -6.81319982e-02f, -5.47407903e-02f, -1.23012669e-01f, 8.27512518e-02f, 3.75569761e-02f, -7.28444234e-02f, 1.15182281e-01f, 7.32951537e-02f,
  4.15891744e-02f, -5.13387695e-02f, 7.37611726e-02f, 6.95578158e-02f, -8.35320652e-02f, -4.62391637e-02f, 3.65711078e-02f, 3.85802165e-02f, -9.81002152e-02f, -5.23411930e-02f,
  -2.90948562e-02f, 1.36407251e-02f, 1.89341395e-03f, -3.55349705e-02f, -3.73718664e-02f, -4.03729379e-02f, -5.33876456e-02f, -3.95638794e-02f, -1.07541062e-01f, -3.11022648e-03f,
  -3.54274698e-02f, -5.75917885e-02f, -3.81011292e-02f, 3.08052339e-02f, -2.27924399e-02f, 8.25567842e-02f, 2.51490176e-02f, 1.68152787e-02f, 1.25111073e-01f, 4.25839014e-02f,
  -1.08249739e-01f, 8.36849138e-02f, -1.63383707e-02f, -1.97232831e-02f, 9.05796289e-02f, -1.18140906e-01f, 5.97392507e-02f, 8.67607519e-02f, 1.08513080e-01f, -9.13740194e-04f,
  -5.65406159e-02f, 1.54785678e-01f, -5.90664297e-02f, -7.12962896e-02f, 1.72520243e-02f, 1.43100973e-02f, 1.85657606e-01f, -2.09605452e-02f, -3.76420729e-02f, 1.07852794e-01f,
  1.59967080e-01f, 7.96312764e-02f, 1.72113016e-01f, 3.02876662e-02f, -9.49404761e-03f, 2.04728276e-01f, 1.24337025e-01f, 1.51541397e-01f, 1.42837584e-01f, 6.50761351e-02f,
  -1.05719112e-01f, -3.70821655e-02f, -7.95143321e-02f, 1.11839190e-01f, 1.19046286e-01f, 8.65595713e-02f, 6.02640547e-02f, -1.07113324e-01f, -1.26918688e-01f, -7.60901794e-02f,
  1.21853411e-01f, 1.12790465e-01f, 7.58826882e-02f, -7.65486248e-03f, 7.77548403e-02f, 1.15169369e-01f, 1.06640913e-01f, -9.46811140e-02f, 1.52308615e-02f, -9.43707749e-02f,
  4.60167183e-03f, 4.01948541e-02f, 3.17281950e-03f, 1.65194720e-02f, -1.17833428e-01f, -3.27812769e-02f, 1.96019873e-01f, 1.03198282e-01f, 1.29439086e-01f, 6.09465502e-02f,
  -1.31575903e-02f, 7.38063455e-02f, -9.95956957e-02f, -1.62720084e-01f, -6.83982298e-02f, -9.53130126e-02f, 6.24577925e-02f, -7.10332626e-03f, -9.97364707e-03f, -8.43791813e-02f,
  5.14298342e-02f, -7.84286112e-02f, 3.86503935e-02f, -2.33112881e-03f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.02602758e-01f, 1.60821632e-01f, 1.56280309e-01f, -5.08050248e-02f, -1.03752501e-01f, 1.36971191e-01f, -7.98106045e-02f, 9.64896008e-02f, 1.84804648e-01f, 1.58346798e-02f,
  4.62834947e-02f, 1.39941141e-01f, -3.50580551e-02f, -1.36937797e-02f, 9.29102004e-02f, 4.89698350e-02f, 1.84511691e-01f, -4.85327765e-02f, -4.42285948e-02f, 1.13198504e-01f,
  -6.28128946e-02f, -9.42689627e-02f, 1.86378494e-01f, 1.14928462e-01f, -1.14902243e-01f, -3.43988463e-02f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  -1.68243855e-01f, -1.90624774e-01f, -1.45273387e-01f, -1.64604023e-01f, 1.10602312e-01f, 1.05294935e-01f, -1.88016713e-01f, 1.60586070e-02f, -6.23469278e-02f, -1.31480590e-01f,
  6.61078542e-02f, -3.50145139e-02f, -5.77420928e-02f, 6.06487785e-03f, -9.22845006e-02f, -4.43944484e-02f, -7.47287944e-02f, -1.72364861e-01f, -5.98646514e-02f, -1.66089267e-01f,
  1.20719291e-01f, 1.37128890e-01f, 2.22140148e-01f, -2.33623892e-01f, 5.79138994e-02f, 9.68802273e-02f, -1.22667499e-01f, -2.28656024e-01f, 1.39446361e-02f, 2.13750124e-01f,
  4.92054857e-02f, 1.52535647e-01f, 6.30443245e-02f, -7.43785352e-02f, -7.07373545e-02f, -1.35325119e-01f, -8.73070583e-02f, 2.25397050e-02f, -7.26220245e-03f, -5.89524545e-02f,
  -9.54825580e-02f, -1.00615270e-01f, 1.08647697e-01f, 2.53219511e-02f, 2.62538232e-02f, 1.53690949e-01f, 4.50366326e-02f, -2.12966837e-02f, -1.08622788e-02f, 1.52912959e-01f,
  9.68062207e-02f, 1.40082404e-01f, -1.12018242e-01f, -8.57016444e-03f, -2.75809377e-01f, 8.29442590e-02f, -6.79525882e-02f, -2.26383239e-01f, 9.80758574e-03f, 9.64551419e-02f,
  1.69332564e-01f, -1.53858587e-01f, 7.81908184e-02f, -8.85815024e-02f, 1.28959846e-02f, -3.73901166e-02f, -7.33077303e-02f, 1.02502309e-01f, -9.66388956e-02f, -1.85628846e-01f,
  1.15836725e-01f, 1.61214527e-02f, 4.61151078e-03f, -3.91159058e-02f, -3.92677784e-02f, 4.52059209e-02f, -9.91824120e-02f, 1.62032142e-01f, 7.55899260e-03f, -4.59414124e-02f,
  1.13885589e-01f, 1.10138141e-01f, -6.59718066e-02f, -8.77101254e-03f, -1.20113403e-01f, -6.34595603e-02f, -1.87454432e-01f, 1.70343369e-01f, 2.68213488e-02f, -1.65852636e-01f,
  -9.45349708e-02f, -1.03055820e-01f, 1.79106578e-01f, -4.20690551e-02f, 1.39621586e-01f, -2.23912388e-01f, 1.97144508e-01f, -1.80398285e-01f, 5.66036478e-02f, -4.94411886e-02f,
  9.83063206e-02f, 1.11447927e-02f, 2.21042912e-02f, 1.55612737e-01f, 7.61884227e-02f, 2.26616883e-03f, -9.81398150e-02f, 8.30073059e-02f, 5.56442440e-02f, 1.11272663e-01f,
  1.10867344e-01f, 5.10097295e-02f, 2.83630136e-02f, -1.26206934e-01f, 4.46475074e-02f, 6.70314506e-02f, -1.66063532e-01f, -6.89434037e-02f, 1.41387591e-02f, -1.01966679e-01f,
  2.21594814e-02f, -3.21744680e-02f, -7.53125474e-02f, 1.12996370e-01f, -5.85772432e-02f, -1.82475802e-02f, 1.03380889e-01f, -1.27333224e-01f, 1.54712707e-01f, 9.83455703e-02f,
  2.12865785e-01f, -9.66369268e-03f, -4.68473732e-02f, 4.64863237e-03f, 1.41592920e-01f, -1.00038193e-01f, -3.72560546e-02f, 8.45309570e-02f, 1.20768845e-01f, 1.12060301e-01f,
  1.27255812e-01f, -1.03390589e-01f, -6.47072271e-02f, 9.50698704e-02f, -5.24276160e-02f, 1.74161419e-02f, 7.50003234e-02f, -1.14590880e-02f, 1.80682212e-01f, -1.00014195e-01f,
  4.18391265e-02f, -1.22296736e-01f, -9.48672071e-02f, 4.47570235e-02f, 1.70597121e-01f, 2.96762157e-02f, -1.09715968e-01f, 1.68769062e-02f, -2.53989995e-01f, 2.46303782e-01f,
  1.15581661e-01f, -2.10100808e-03f, -5.81626371e-02f, 4.94587459e-02f, -5.02990447e-02f, 1.77386433e-01f, 6.73322659e-03f, -4.04658392e-02f, -2.57459134e-01f, 7.26927668e-02f,
  -1.05271384e-01f, -3.09803337e-02f, 1.92886796e-02f, 1.37717187e-01f, -8.83823708e-02f, -6.66113645e-02f, -1.02494456e-01f, -3.96088921e-02f, -7.73815298e-03f, -2.00247645e-01f,
  1.99114472e-01f, -4.08595316e-02f, 3.90217975e-02f, 8.88350382e-02f, -7.14135170e-02f, 1.13805920e-01f, 1.42646715e-01f, -1.33369252e-01f, 7.03390837e-02f, 9.17568505e-02f,
  -4.00567129e-02f, -3.36816758e-02f, 1.38761893e-01f, 3.18834968e-02f, -5.63628189e-02f, 2.99106855e-02f, 5.34184501e-02f, -1.26775056e-01f, 1.53957596e-02f, -4.45854776e-02f,
  -8.70056823e-02f, 1.31522477e-01f, -4.24306355e-02f, -5.10085411e-02f, 5.19487001e-02f, 1.11529544e-01f, 2.89788307e-03f, 1.07033804e-01f, -9.87579450e-02f, 3.75749394e-02f,
  -1.87621251e-01f, -1.16184019e-01f, 7.47241229e-02f, 1.16229899e-01f, -6.88354373e-02f, -9.82113332e-02f, 7.20011964e-02f, 1.71046376e-01f, 1.28362417e-01f, 2.52675954e-02f,
  -1.65221795e-01f, 6.65719882e-02f, -1.73748925e-01f, 2.02278823e-01f, 7.50615969e-02f, 9.44939703e-02f, -6.41147420e-02f, 4.23044451e-02f, 3.84784378e-02f, -2.60970518e-02f,
  9.13340971e-02f, -1.48007497e-01f, -1.37678519e-01f, -6.73656389e-02f, 2.88963541e-02f, -1.40234888e-01f, -8.45744759e-02f, 1.44036025e-01f, -1.36356845e-01f, 9.83006284e-02f,
  -7.60732368e-02f, 6.75674155e-02f, 7.85267055e-02f, -1.44409865e-01f, -1.50841787e-01f, 5.23729308e-04f, -1.86363518e-01f, -4.20065261e-02f, -8.84058028e-02f, -4.31922674e-02f,
  9.39108059e-02f, -1.66175757e-02f, -3.81258428e-02f, 7.51414821e-02f, 8.00731629e-02f, 6.06620871e-02f, -6.81266412e-02f, -6.10984080e-02f, -3.21189091e-02f, 4.47694883e-02f,
  -4.26103324e-02f, -1.14096597e-01f, -1.20844528e-01f, 2.81219482e-02f, -1.48873687e-01f, -2.19479933e-01f, 4.08993214e-02f, 1.80373155e-02f, -5.95788956e-02f, -1.19721420e-01f,
  9.61494446e-02f, -2.23098665e-01f, 1.12417527e-01f, 8.05146098e-02f, 1.02001846e-01f, -9.99797061e-02f, -2.21432835e-01f, 3.49627435e-02f, -1.36746660e-01f, 7.84017965e-02f,
  6.84509426e-02f, 6.70970008e-02f, -1.79697856e-01f, -3.89145389e-02f, -8.18551611e-03f, 9.15875509e-02f, 2.12658599e-01f, -7.24525675e-02f, 2.78220717e-02f, -1.16435111e-01f,
  9.27253440e-02f, -4.59046923e-02f, 2.10778981e-01f, -2.09549010e-01f, -9.94778350e-02f, 7.48456493e-02f, 1.42186373e-01f, 1.08245604e-01f, -2.63522360e-02f, 7.40624405e-03f,
  3.91579531e-02f, -8.28748122e-02f, 2.75902897e-01f, 1.38515374e-02f, -9.69666019e-02f, -6.61012679e-02f, 8.37763920e-02f, 1.10289007e-01f, -1.71752691e-01f, -6.72955066e-02f,
  -7.00243562e-03f, -1.31728798e-01f, 9.70669091e-02f, -1.01563744e-01f, 2.98453625e-02f, 1.44000754e-01f, -5.90452738e-02f, -8.06276947e-02f, 1.66471917e-02f, -4.69258241e-02f,
  -8.41462798e-03f, -3.73783754e-03f, -1.34080067e-01f, 7.07589984e-02f, -3.16629969e-02f, 1.45236298e-01f, -1.54218480e-01f, 1.47777712e-02f, 1.90834235e-02f, -8.17938745e-02f,
  -2.34244647e-03f, -7.14475363e-02f, -2.05643307e-02f, -1.66301534e-01f, 9.72261429e-02f, -1.80384070e-01f, 6.37904406e-02f, 3.91000435e-02f, -4.09412868e-02f, -1.59437612e-01f,
  -1.67200178e-01f, 9.72465947e-02f, -5.71126714e-02f, -1.56654358e-01f, 1.89409226e-01f, -1.37081429e-01f, -7.51947612e-02f, -1.34275287e-01f, 6.03147745e-02f, -5.82012571e-02f,
  2.08648853e-03f, 1.50830839e-02f, 1.23787843e-01f, -2.04575181e-01f, 1.45354897e-01f, -2.04437733e-01f, 1.57974869e-01f, -2.30696052e-01f, -3.46806422e-02f, 1.69769704e-01f,
  -7.60903805e-02f, 4.32298444e-02f, 2.94994470e-02f, 1.38220116e-01f, 7.62475096e-03f, 1.28426701e-01f, 2.30609193e-01f, 1.33219138e-01f, 5.10031395e-02f, -1.41291199e-02f,
  -1.25372767e-01f, 9.67022926e-02f, -1.85916424e-01f, -1.36163160e-01f, 1.05534740e-01f, 1.23337686e-01f, -7.27119967e-02f, -2.46389404e-01f, -1.40010729e-01f, 9.20240358e-02f,
  6.92544430e-02f, 9.51750278e-02f, -5.07764742e-02f, -1.51323504e-03f, -6.29238561e-02f, 4.21844088e-02f, -1.25137391e-02f, -3.69498320e-02f, -5.40059805e-02f, -9.04237777e-02f,
  6.76694065e-02f, -6.88162670e-02f, -5.63982762e-02f, -1.21208102e-01f, 4.07881513e-02f, -1.20318905e-01f, -1.22506961e-01f, -4.38188156e-03f, 6.40773699e-02f, -6.82447478e-02f,
  -2.13078987e-02f, 1.38029099e-01f, 6.21196367e-02f, -4.34929468e-02f, -1.78999096e-01f, -5.52102104e-02f, -5.80823682e-02f, 1.36216596e-01f, -1.65203847e-02f, -1.98090300e-01f,
  -4.79172915e-02f, -2.38960441e-02f, 9.19712987e-03f, -9.93093848e-02f, 1.71383083e-01f, -2.48714179e-01f, 1.40899286e-01f, -4.75044847e-02f, 1.61288142e-01f, -4.45749350e-02f,
  1.02680884e-01f, 3.98532674e-02f, -1.19206414e-01f, 5.55426963e-02f, 1.69061087e-02f, 2.01400518e-02f, 1.17247805e-01f, 2.55263541e-02f, 3.11767720e-02f, -9.98934433e-02f,
  2.79046223e-02f, -1.06301896e-01f, 1.34756729e-01f, -1.01355880e-01f, -7.63627589e-02f, 1.06903531e-01f, -1.04892524e-02f, 1.19374394e-01f, 1.90249562e-01f, 1.84903238e-02f,
  -1.02270551e-01f, -7.42037743e-02f, 8.35755616e-02f, 9.64252278e-02f, -7.45665804e-02f, -3.87795120e-02f, 1.17086194e-01f, 9.44005251e-02f, 1.72795400e-01f, -4.97288927e-02f,
  1.13347337e-01f, -7.82356411e-02f, -7.63627216e-02f, -7.21967444e-02f, 1.62242636e-01f, 1.29483938e-02f, -7.98580348e-02f, 1.61623940e-01f, -8.49999860e-02f, 1.71885759e-01f,
  5.88840917e-02f, 3.36184278e-02f, -5.22621162e-02f, 1.62102744e-01f, 7.73669332e-02f, -1.03363708e-01f, -4.45532463e-02f, 1.84395656e-01f, 1.88326895e-01f, -1.36246309e-01f,
  1.26417711e-01f, -3.12472433e-02f, -6.86611682e-02f, 3.86947803e-02f, 1.61772057e-01f, 2.35586852e-01f, 8.74782354e-02f, 9.97504666e-02f, -2.28730127e-01f, 2.86597401e-01f,
  5.24937548e-02f, -3.66509184e-02f, -6.56927079e-02f, 1.59099489e-01f, -1.07587516e-01f, 2.34283227e-02f, 9.44082886e-02f, -1.46040812e-01f, -1.52624354e-01f, -6.97516557e-03f,
  -6.47466630e-02f, -9.60498154e-02f, 3.22153466e-03f, -5.93169443e-02f, -3.11307535e-02f, -2.50464585e-02f, -1.02096885e-01f, 1.36468206e-02f, -3.49848047e-02f, 1.66240986e-02f,
  6.53070882e-02f, 2.33269129e-02f, -1.04080774e-01f, -9.50025618e-02f, 2.07987297e-02f, -9.67062339e-02f, 8.55589807e-02f, -1.02157518e-02f, 1.76892832e-01f, 1.97901979e-01f,
  -1.77956428e-02f, -4.49468717e-02f, -2.78314501e-02f, -1.07352622e-02f, 4.58455011e-02f, 5.83439097e-02f, 1.40378982e-01f, 3.83900367e-02f, 8.51610824e-02f, 7.60851009e-03f,
  3.09021473e-02f, 6.57961816e-02f, 1.41266197e-01f, 2.90251710e-02f, 1.85365770e-02f, 4.52735461e-02f, 1.65141940e-01f, 7.73658007e-02f, -8.49662870e-02f, 2.12155562e-02f,
  -1.65476844e-01f, 6.34563416e-02f, 7.98144564e-02f, 3.43729835e-03f, -2.34957803e-02f, -1.82684317e-01f, -4.19839919e-02f, 2.32516482e-01f, -2.73372103e-02f, -6.11865669e-02f,
  -1.18867934e-01f, 9.95157287e-02f, -1.46893516e-01f, 1.24816433e-01f, 9.36398506e-02f, 6.41736807e-03f, -1.01028539e-01f, 1.28030451e-02f, -1.49245441e-01f, 2.44109675e-01f,
  2.28848591e-01f, -7.62167424e-02f, -1.82107791e-01f, 1.09280854e-01f, 4.14051209e-03f, -1.61513910e-01f, 4.97287028e-02f, 1.53548121e-01f, -8.37984905e-02f, 6.93939626e-02f,
  -1.31366864e-01f, 4.37493175e-02f, -8.76370743e-02f, 6.04243800e-02f, -5.57736903e-02f, -9.77124944e-02f, -2.30242133e-01f, -1.12913840e-01f, -1.44439703e-02f, 6.23709038e-02f,
  1.31501824e-01f, -1.03366829e-01f, 1.06778316e-01f, -6.58882484e-02f, -7.87137598e-02f, 1.33246422e-01f, -1.43258702e-02f, -3.42634395e-02f, -5.79942428e-02f, 3.93568091e-02f,
  1.73791468e-01f, 3.89150381e-02f, -2.98807006e-02f, 1.21428467e-01f, -1.36991426e-01f, -6.69392347e-02f, 1.39559135e-01f, 1.40591756e-01f, -6.80743577e-03f, -2.06928164e-01f,
  2.08603814e-02f, 1.43169865e-01f, 1.21247858e-01f, 3.42547297e-02f, 9.20579210e-02f, 2.06963226e-01f, -3.65465432e-02f, -1.94101363e-01f, -6.04916783e-03f, -1.94986701e-01f,
  2.81734038e-02f, 2.60786504e-01f, -4.52243052e-02f, 1.95731148e-01f, -1.27475306e-01f, 1.46022573e-01f, -3.05641413e-01f, 1.43942714e-01f, -1.23537593e-01f, -5.62177971e-02f,
  1.33805603e-01f, 3.26442979e-02f, -2.20377758e-01f, -1.78662091e-01f, -4.09492641e-04f, -1.41187549e-01f, -1.40834287e-01f, -8.50961804e-02f, 1.30472407e-01f, -1.29108220e-01f,
  -2.44185943e-02f, 1.40415877e-01f, -5.82459643e-02f, 6.13621324e-02f, 8.09618235e-02f, -3.05146500e-02f, -1.04529150e-01f, -1.15344509e-01f, 7.78378770e-02f, -5.65342195e-02f,
  -1.07343875e-01f, 9.45054367e-02f, 1.02582410e-01f, -1.05285347e-01f, 3.29873599e-02f, -2.38327067e-02f, 1.40016034e-01f, -1.96693838e-02f, -9.89154130e-02f, -6.89459816e-02f,
  -8.34088326e-02f, -1.74897566e-01f, -5.10155165e-04f, 4.90659215e-02f, -7.19996840e-02f, -8.84057209e-02f, -1.34002864e-01f, -6.09203540e-02f, 4.08006012e-02f, -1.21465363e-01f,
  8.51216316e-02f, -4.05993946e-02f, -4.81981747e-02f, -1.76071599e-01f, 5.68661131e-02f, -6.17944635e-02f, 8.03606361e-02f, 3.34266834e-02f, 2.52564907e-01f, -8.56645182e-02f,
  7.83546641e-02f, -2.44547665e-01f, -1.68906897e-01f, 9.82512757e-02f, -9.73340198e-02f, -4.86485586e-02f, -1.92960992e-01f, 2.69690305e-01f, 2.56839573e-01f, -3.19532827e-02f,
  1.13263847e-02f, -3.11939903e-02f, -1.04190305e-01f, -2.35045642e-01f, 1.40896887e-01f, -1.10080823e-01f, 1.43644631e-01f, -2.14585215e-01f, -9.57587808e-02f, 2.84647960e-02f,
  -5.92947714e-02f, -9.82022062e-02f, 2.09262967e-02f, 1.90317556e-02f, 4.09335718e-02f, -2.45690867e-01f, 1.91342697e-01f, -6.18773289e-02f, 1.56469326e-02f, -2.72133946e-03f,
  -1.38146415e-01f, 1.30735084e-01f, -1.62152275e-01f, -1.22343615e-01f, 2.12298095e-01f, 8.75566900e-02f, 2.62736846e-02f, -5.84741719e-02f, 6.37494633e-03f, -6.03734516e-02f,
  9.59385931e-02f, -2.56285425e-02f, 2.58213859e-02f, -5.55250831e-02f, -1.50535032e-01f, 3.35181691e-02f, -1.57686099e-01f, -2.59466544e-02f, -2.61012558e-02f, 1.37193233e-01f,
  -1.23976558e-01f, -9.24620032e-02f, -7.36998543e-02f, 5.41214161e-02f, -1.00372195e-01f, -6.99996725e-02f, -8.17905068e-02f, 8.33582878e-02f, -1.70845792e-01f, -8.98542628e-02f,
  -1.37360960e-01f, 6.19227141e-02f, -9.96710956e-02f, -4.01292108e-02f, -1.31562904e-01f, 2.32214537e-02f, 7.81792253e-02f, 1.69558689e-01f, 1.53427511e-01f, -1.38625339e-01f,
  8.60114470e-02f, -1.75883725e-01f, 6.13379627e-02f, -8.72436985e-02f, 1.21523499e-01f, -1.33366838e-01f, -6.35093525e-02f, 1.05367504e-01f, -1.33601844e-01f, 1.98086426e-02f,
  -4.64978963e-02f, -1.59041405e-01f, 1.06461067e-02f, 1.65435955e-01f, 3.06929857e-01f, -1.15940072e-01f, -1.04428746e-01f, 1.14065468e-01f, -7.36384392e-02f, 4.67291996e-02f,
  -1.20479643e-01f, 3.23470160e-02f, 8.09319243e-02f, 1.06291600e-01f, 3.04304268e-02f, -7.65390024e-02f, -5.52841276e-02f, 1.13105871e-01f, 8.08902606e-02f, 3.85274477e-02f,
  7.43837208e-02f, 8.13496262e-02f, 1.43891871e-02f, 1.07168099e-02f, -1.24360368e-01f, -2.28185013e-01f, 3.37498332e-03f, -1.22818880e-01f, 2.50031240e-02f, 1.44307390e-01f,
  -2.62204297e-02f, 3.68285030e-02f, 1.03242643e-01f, 6.43898770e-02f, 7.06544966e-02f, -7.93533921e-02f, -1.01811819e-01f, 1.00592181e-01f, 1.23336008e-02f, 5.83571196e-02f,
  -2.07041577e-02f, 7.91369900e-02f, 9.24277306e-02f, 3.19305733e-02f, 9.42684188e-02f, 1.08470336e-01f, -1.75655320e-01f, -4.28153574e-02f, 8.52129161e-02f, 1.80654481e-01f,
  -7.80796725e-03f, -2.52532028e-02f, 1.24620378e-01f, -1.47643819e-01f, -1.01021618e-01f, -2.20866650e-01f, -1.37839824e-01f, 3.76184508e-02f, -2.08894350e-02f, -8.65765363e-02f,
  -2.46364879e-03f, 1.28103429e-02f, 1.91722903e-02f, -1.03749782e-01f, 8.61858130e-02f, 7.52978995e-02f, 1.42619014e-01f, 4.20088060e-02f, 7.54621476e-02f, 8.68846849e-02f,
  -9.44074318e-02f, -6.14783168e-02f, 1.19471550e-01f, 1.39233872e-01f, -2.18533501e-02f, -6.73891902e-02f, -4.28827815e-02f, -1.63821764e-02f, 3.71920131e-02f, 3.46655026e-02f,
  -1.71485022e-01f, -5.71207292e-02f, 6.66315481e-02f, 6.69113472e-02f, 4.08043526e-02f, 1.45265192e-01f, -2.28173807e-02f, 8.05363618e-03f, -8.42663273e-02f, -1.26855284e-01f,
  2.87657715e-02f, -3.20555307e-02f, -9.17582884e-02f, 3.41447815e-02f, -7.92210922e-02f, -3.47640403e-02f, 5.78162298e-02f, 2.89898086e-02f, -8.19499269e-02f, -6.50836248e-03f,
  -1.26734167e-01f, 4.37516309e-02f, -1.23186158e-02f, 1.03909753e-01f, 3.71552184e-02f, -1.98277324e-01f, -1.85888670e-02f, 7.51951411e-02f, -1.26189187e-01f, -6.94793537e-02f,
  -4.84575480e-02f, 8.91184211e-02f, 5.92584498e-02f, 1.86081961e-01f, -3.13559920e-02f, -2.05755308e-01f, 1.09610900e-01f, 1.46200389e-01f, 1.52166992e-01f, -1.74807712e-01f,
  -8.79498497e-02f, 7.54001141e-02f, -4.79158163e-02f, 3.33935022e-02f, -9.24464762e-02f, 1.17921263e-01f, -1.79637386e-03f, -3.98039594e-02f, -1.95248142e-01f, 1.52741343e-01f,
  3.71311754e-02f, 2.29897629e-02f, 2.59236004e-02f, -3.38448212e-02f, 1.02429114e-01f, -2.05114000e-02f, -2.88097505e-02f, 2.56889790e-01f, -2.90227950e-01f, 8.73912498e-02f,
  -1.85330231e-02f, 8.95966366e-02f, -7.56501034e-02f, -2.12718651e-01f, 2.92902887e-02f, -5.01821376e-02f, -2.61790663e-01f, 4.45301309e-02f, -6.27325997e-02f, 3.93897928e-02f,
  4.75181900e-02f, -1.58461500e-02f, 1.08333863e-01f, 9.40601155e-02f, -4.50322703e-02f, 1.12659574e-01f, 6.11963980e-02f, 1.77144934e-03f, -5.68705499e-02f, 4.26863730e-02f,
  9.69571695e-02f, 2.02939305e-02f, -3.90032642e-02f, -1.00631982e-01f, -1.12204343e-01f, 1.01302445e-01f, 1.47437319e-01f, 1.80862732e-02f, -4.73855576e-03f, -2.31614206e-02f,
  -3.35714668e-02f, -5.58874644e-02f, -1.24960504e-01f, -1.01184949e-01f, -6.95856139e-02f, -1.16434641e-01f, 1.25736147e-01f, 8.47330540e-02f, 2.06473708e-01f, -1.84861660e-01f,
  2.50623617e-02f, 1.84298053e-01f, 3.21648903e-02f, -1.70461521e-01f, -1.98899060e-02f, -2.90340651e-02f, -1.51575804e-01f, 1.25966564e-01f, -8.77662376e-02f, 4.22469899e-02f,
  -3.39234173e-02f, 1.26465455e-01f, -1.01566680e-01f, -1.81944482e-02f, 7.74938846e-03f, -1.86053608e-02f, -6.10449761e-02f, 5.01756817e-02f, -1.15062147e-01f, -8.82485583e-02f,
  -3.88534032e-02f, 2.11590137e-02f, -2.59770900e-01f, -3.40629034e-02f, -8.06978047e-02f, 1.90146729e-01f, -4.28061560e-02f, -2.83967741e-02f, -2.57485565e-02f, 3.00825518e-02f,
  -2.43615866e-01f, 2.38921903e-02f, -2.16754004e-02f, 9.62673575e-02f, 9.31086913e-02f, 1.22859471e-01f, 1.39564022e-01f, 1.07537605e-01f, 9.69127472e-03f, 2.47491747e-02f,
  -6.18480071e-02f, -4.76964861e-02f, 8.36161897e-02f, -1.18155971e-01f, -2.13209037e-02f, -1.41220599e-01f, 1.75654572e-02f, 9.38087050e-03f, -9.24039185e-02f, -1.29851252e-01f,
  -1.64041251e-01f, 5.71025349e-02f, -1.35106340e-01f, 2.28132829e-01f, 1.31309405e-02f, -2.04292104e-01f, -8.19329396e-02f, 1.19269535e-01f, -4.23473045e-02f, 5.20017929e-02f,
  -9.19548944e-02f, 7.35753328e-02f, -2.31442019e-01f, -1.41706411e-02f, -6.17417227e-03f, -1.40465349e-01f, -4.60724086e-02f, -9.20503363e-02f, -1.77412331e-02f, -6.59185424e-02f,
  1.75623670e-01f, -2.03191936e-01f, 1.18004933e-01f, -2.21366212e-01f, -8.58681425e-02f, -1.03017045e-02f, 1.76584616e-01f, -9.93537381e-02f, 5.71745783e-02f, 1.42194495e-01f,
  5.78580089e-02f, 1.17464423e-01f, -1.18016653e-01f, 1.15567677e-01f, 4.72142063e-02f, 9.20472518e-02f, 9.51486826e-02f, -1.17392547e-01f, -9.80407968e-02f, -1.65447906e-01f,
  -1.10117942e-01f, 5.88093810e-02f, -2.50218391e-01f, -2.59587597e-02f, 1.75845221e-01f, -3.60126905e-02f, -9.83456373e-02f, 7.55731985e-02f, -5.89767396e-02f, -1.10900961e-01f,
  -6.25172257e-02f, 3.56259681e-02f, 5.83910346e-02f, -6.46411628e-02f, -5.32903299e-02f, -4.01915004e-03f, 1.34433210e-01f, -6.85534254e-02f, 1.38155539e-02f, 1.85930267e-01f,
  -2.00524461e-02f, 9.43461582e-02f, -1.18447602e-01f, 1.23663411e-01f, 2.30634660e-02f, 5.05547337e-02f, 2.13420931e-02f, -7.59549215e-02f, 2.45020725e-02f, 7.65262395e-02f,
  -4.15176433e-03f, -1.62280634e-01f, -1.14943311e-01f, -1.95457302e-02f, 1.03836156e-01f, 1.73709944e-01f, 1.08804842e-02f, -4.25757170e-02f, 9.77012888e-02f, 1.32977873e-01f,
  1.26499936e-01f, -1.42707422e-01f, -2.56802827e-01f, 1.27907470e-01f, -6.94777593e-02f, 1.24063790e-01f, -2.43609380e-02f, 7.80733004e-02f, -1.93316817e-01f, 1.36191636e-01f,
  -2.16820642e-01f, 2.78161973e-01f, -5.50005361e-02f, 5.90533763e-02f, -6.50895312e-02f, 1.70105007e-02f, -6.99253427e-03f, -7.90702924e-02f, 7.39447996e-02f, 1.85825989e-01f,
  -2.97135115e-01f, -6.72297999e-02f, 7.42163435e-02f, -1.25700776e-02f, 3.04604582e-02f, -1.69630066e-01f, 1.44722506e-01f, -2.40257196e-02f, -1.32726729e-01f, 3.48598622e-02f,
  -3.01017147e-02f, 1.25103584e-02f, -6.54619336e-02f, -4.92307730e-02f, -6.18882999e-02f, 3.46241072e-02f, -8.57663453e-02f, 6.93488717e-02f, -1.49725422e-01f, 2.35789083e-02f,
  -3.32149938e-02f, -6.44950345e-02f, -1.53040871e-01f, -1.03274295e-02f, -1.48791268e-01f, -9.18923542e-02f, -1.50519192e-01f, -2.91572548e-02f, -1.16689131e-01f, -1.54004276e-01f,
  1.79733895e-02f, 7.88029656e-02f, -5.75359054e-02f, -1.80255145e-01f, -8.28151330e-02f, 9.59196407e-03f, 3.96381244e-02f, -1.18484989e-01f, -2.54316479e-01f, -7.20099509e-02f,
  -1.55343577e-01f, -3.02748866e-02f, 1.61527053e-01f, 7.54600205e-03f, -5.29330559e-02f, -1.11389458e-01f, 1.23317458e-01f, -8.03602673e-03f, 1.90477282e-01f, -2.55874544e-01f,
  1.20538943e-01f, -1.62572980e-01f, 4.80971485e-02f, -9.63694975e-02f, 1.28466517e-01f, -1.04712605e-01f, -7.85259306e-02f, 2.11513653e-01f, 2.18814254e-01f, -5.08527197e-02f,
  7.70202130e-02f, 1.51632860e-01f, -2.96950080e-02f, -1.17371820e-01f, 2.24934265e-01f, -9.19203162e-02f, -8.41789767e-02f, 1.04124155e-02f, -6.20934293e-02f, -3.53492387e-02f,
  2.86549097e-03f, 7.87771717e-02f, 1.56516850e-01f, 6.31878972e-02f, 9.63862091e-02f, -1.61363348e-01f, -1.08768477e-03f, 1.84611548e-02f, 5.37490621e-02f, -1.55989304e-01f,
  -1.15069278e-01f, 1.87126584e-02f, -1.26812771e-01f, 3.41543742e-02f, -1.90670326e-01f, -1.66344151e-01f, -6.71527013e-02f, -2.96823923e-02f, -4.72958833e-02f, -6.31789416e-02f,
  -6.68906197e-02f, -1.35541677e-01f, 7.83473328e-02f, -5.00705019e-02f, -1.19625360e-01f, -1.70466125e-01f, 1.88594181e-02f, -5.22718579e-02f, 7.04474449e-02f, 5.03478236e-02f,
  6.07743561e-02f, -1.09900005e-01f, -8.44767168e-02f, -1.58640608e-01f, 1.73928708e-01f, -1.70910448e-01f, -2.86978092e-02f, -1.52716801e-01f, -1.66354597e-01f, -7.40811154e-02f,
  -8.36559907e-02f, 4.99792136e-02f, 9.60599631e-02f, -4.71039750e-02f, -9.57200900e-02f, -3.58047411e-02f, 7.95109123e-02f, -1.50949985e-01f, -8.48013461e-02f, -2.63909549e-01f,
  -1.97219342e-01f, 1.55454561e-01f, 2.03100458e-01f, -3.06204278e-02f, -1.06928416e-01f, 1.06589802e-01f, 4.89464067e-02f, -1.06838025e-01f, 1.29303396e-01f, -5.64597920e-02f,
  4.62266468e-02f, -6.96817860e-02f, -1.19538978e-02f, 1.82203859e-01f, -1.48094427e-02f, -3.73019371e-03f, -5.34173436e-02f, 5.89930564e-02f, -9.84849557e-02f, -1.98404327e-01f,
  -5.27983233e-02f, 1.67673361e-03f, -5.95480800e-02f, -1.10492982e-01f, -7.81793147e-02f, -7.41336569e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  -3.11289076e-02f, 7.87123367e-02f, 4.82060015e-02f, 2.11434644e-02f, 1.49208963e-01f, 4.87016067e-02f, -6.77046403e-02f, 1.01731054e-01f, -2.54529323e-02f, 1.48886636e-01f,
  1.58642292e-01f, 5.93652390e-02f, -8.94597322e-02f, -1.75524559e-02f, 8.83735567e-02f, 1.33683950e-01f, -5.99028133e-02f, 8.09608996e-02f, -1.66762426e-01f, -1.23985499e-01f,
  1.39539465e-02f, 7.52555653e-02f, 1.38911396e-01f, -6.85733929e-02f, 7.47304261e-02f, -1.11437067e-01f, -5.41133471e-02f, -6.00180477e-02f, -1.22785456e-01f, 9.38845649e-02f,
  1.15333028e-01f, 3.88883539e-02f, -9.85331684e-02f, 2.89744232e-03f, -6.28791079e-02f, 1.11442171e-02f, -1.15257904e-01f, 4.00007106e-02f, -8.51372853e-02f, 1.56366333e-01f,
  4.11837436e-02f, 7.73971006e-02f, 6.50967360e-02f, 1.62774846e-01f, 5.68782426e-02f, 1.31053686e-01f, -1.43698975e-02f, -5.52285612e-02f, -3.93679412e-03f, 2.01106161e-01f,
  2.47784220e-02f, 1.61635995e-01f, 7.17280507e-02f, 8.41602609e-02f, 2.81098709e-02f, -3.00566424e-02f, -1.06558457e-01f, 1.29962504e-01f, -9.45143029e-02f, -3.47593985e-02f,
  -5.87244853e-02f, -2.87787616e-02f, -1.09356552e-01f, -6.12484664e-03f, 1.43886358e-01f, -7.05060512e-02f, -1.48026377e-01f, 6.77799108e-03f, 1.21084467e-01f, 2.43187994e-01f,
  -8.65973756e-02f, 6.18635602e-02f, 1.94545358e-01f, 8.50083008e-02f, 1.79067522e-01f, 1.46682575e-01f, 9.38517302e-02f, -3.60036343e-01f, -7.11893663e-02f, -1.08229242e-01f,
  1.88856527e-01f, -4.58175689e-02f, 3.21179241e-01f, 2.51937918e-02f, -5.91938645e-02f, -1.49725839e-01f, 2.70576179e-01f, -2.75426179e-01f, 8.87699332e-03f, -2.60128956e-02f,
  -1.87019289e-01f, -3.47326808e-02f, 3.26730907e-02f, 1.26305863e-01f, -7.83351213e-02f, -3.99638042e-02f, -3.51144344e-01f, 5.26596140e-03f, 2.46386006e-01f, -9.93829444e-02f,
  -1.78794697e-01f, -2.20549747e-01f, -1.90980449e-01f, 1.91715024e-02f, 1.50920302e-01f, 1.15125492e-01f, -1.14821373e-02f, 5.23305461e-02f, 2.41844617e-02f, -4.45154943e-02f,
  5.11518300e-01f, 1.72463581e-01f, -6.44922927e-02f, 1.58071905e-01f, -6.88972920e-02f, 2.78870344e-01f, 4.15694863e-01f, -1.41191229e-01f, -9.11390991e-04f, -1.08545888e-02f,
  -3.63429040e-02f, -2.72978336e-01f, 1.05449960e-01f, 7.61246979e-02f, 2.19518259e-01f, -5.68818487e-02f, -7.63310045e-02f, 1.50224581e-01f, -2.37651691e-02f, 1.09400511e-01f,
  5.63246794e-02f, 1.17838182e-01f, 1.31048620e-01f, -1.13373198e-01f, 7.52387345e-02f, 1.50112733e-01f, -7.26338774e-02f, 1.95366889e-01f, 2.81807259e-02f, -3.91803356e-03f,
  1.66531011e-01f, 8.46840814e-02f, 1.55099705e-01f, 1.06639259e-01f, 8.70127156e-02f, 1.10350147e-01f, 1.14777982e-01f, 1.03961974e-01f, 8.83197933e-02f, -2.41959095e-01f,
  5.95216975e-02f, 1.38301253e-02f, -1.17942609e-01f, 2.64172226e-01f, 2.90628914e-02f, 3.69055688e-01f, 1.65584609e-01f, 5.53356744e-02f, -1.00263469e-01f, 2.48312935e-01f,
  8.33163783e-02f, 4.78491560e-02f, 2.35120691e-02f, 2.13822022e-01f, 9.93361473e-02f, 7.29389265e-02f, 1.22430786e-01f, -1.18583463e-01f, -1.08671933e-01f, 6.56586289e-02f,
  -1.19887672e-01f, -1.09926000e-01f, -6.28453270e-02f, -1.75222859e-01f, 1.32825762e-01f, -4.11196798e-02f, -5.21849208e-02f, 4.73138615e-02f, -1.45356823e-02f, 2.12446861e-02f,
  -1.84979483e-01f, 2.95384452e-02f, -2.86347345e-02f, -2.48234719e-03f, -7.41239190e-02f, 1.64888397e-01f, -5.31107634e-02f, -7.12880045e-02f, 1.15917549e-01f, 2.65454233e-01f,
  4.79358658e-02f, 7.45495483e-02f, 8.07622969e-02f, -8.29971880e-02f, -1.00586697e-01f, -4.87051234e-02f, 1.14786424e-01f, 1.29275709e-01f, 6.87843263e-02f, 1.69589043e-01f,
  -3.69925648e-02f, 9.46760699e-02f, 1.37570694e-01f, 4.68629189e-02f, -3.20779458e-02f, 8.47001374e-02f, -3.15481350e-02f, 1.00785442e-01f, 2.27324441e-02f, 4.53839786e-02f,
  2.61494428e-01f, 5.28832935e-02f, 5.75171672e-02f, -2.72452444e-01f, 1.13000087e-01f, 1.75116826e-02f, -5.44361807e-02f, 1.43276468e-01f, -1.32094309e-01f, 2.04064459e-01f,
  5.18882126e-02f, 5.13166897e-02f, 2.36441884e-02f, -4.13849130e-02f, -1.17137969e-01f, -8.41968656e-02f, 9.00812522e-02f, 5.16409986e-02f, -2.01779362e-02f, -1.82416156e-01f,
  -1.70861259e-01f, -1.61706895e-01f, -1.27801716e-01f, 9.31143686e-02f, 8.13373625e-02f, 1.76965326e-01f, -8.28800127e-02f, -1.60199180e-01f, 1.91789910e-01f, 1.92964878e-02f,
  -6.45554215e-02f, 1.18803099e-01f, 7.66301826e-02f, 1.87098309e-01f, 6.37229607e-02f, 3.56124416e-02f, -4.44867574e-02f, -3.12248636e-02f, -7.33811408e-02f, -1.29819125e-01f,
  7.78167322e-02f, 9.14869830e-02f, 2.40719035e-01f, 7.18493387e-02f, -6.10171258e-02f, -1.95301287e-02f, -5.10709845e-02f, 9.40006897e-02f, -4.56703119e-02f, 1.53636262e-01f,
  -7.35711232e-02f, -2.00488605e-02f, 7.45476708e-02f, 4.24505100e-02f, 9.49370116e-02f, -7.69933462e-02f, 6.16051219e-02f, 1.98558383e-02f, -4.96058166e-02f, -2.74776574e-03f,
  3.06916200e-02f, 2.62504704e-02f, -6.40454069e-02f, 1.47536144e-01f, -7.95658007e-02f, 1.05633110e-01f, -1.44629136e-01f, -5.52642010e-02f, 8.05394575e-02f, 1.61435694e-01f,
  7.21951574e-03f, -1.31262676e-03f, -9.95617881e-02f, -5.72691038e-02f, 8.20909142e-02f, -3.53546464e-03f, 7.16422275e-02f, -1.83494583e-01f, -8.29935223e-02f, 8.77733976e-02f,
  -3.28817107e-02f, -9.68681201e-02f, -5.58843203e-02f, -6.69293925e-02f, 8.35065618e-02f, 1.43874967e-02f, 2.23360494e-01f, -5.11288568e-02f, -1.01744518e-01f, -1.66512467e-02f,
  5.53157814e-02f, -1.15388714e-01f, 5.43831252e-02f, 1.02688223e-01f, 8.83279368e-02f, 9.28305015e-02f, 1.21417351e-01f, -4.76659797e-02f, 1.78422183e-01f, -9.48933437e-02f,
  1.32245287e-01f, -1.06508441e-01f, 7.19152093e-02f, -1.73305417e-03f, -1.90951880e-02f, -2.85371598e-02f, -1.54460231e-02f, -1.08864807e-01f, -4.54361886e-02f, 1.04586191e-01f,
  1.68903515e-01f, 7.22231492e-02f, 5.54593503e-02f, 4.00207452e-02f, 3.41703071e-06f, 3.38672847e-02f, 1.66915208e-01f, -4.87974398e-02f, -3.77893448e-02f, 1.12323023e-01f,
  1.72086999e-01f, 7.03607723e-02f, 1.38484702e-01f, -3.96444350e-02f, 1.26363248e-01f, 2.17557192e-01f, -9.79966596e-02f, 1.25136105e-02f, -1.18327580e-01f, 2.15806320e-01f,
  1.56572178e-01f, -4.51179817e-02f, 7.73354620e-02f, -4.32096086e-02f, -1.20875344e-01f, 1.05923615e-01f, 3.95575687e-02f, 1.22455105e-01f, -2.23053084e-03f, -1.50297269e-01f,
  -6.24174252e-02f, 2.01188162e-01f, 3.72089781e-02f, -2.80394647e-02f, 8.30660313e-02f, -1.75563861e-02f, 8.41111094e-02f, 1.59710422e-01f, 1.89810738e-01f, -2.54004970e-02f,
  -2.11833298e-01f, -8.81837681e-03f, -1.70381775e-03f, -1.31947964e-01f, -4.94722798e-02f, -1.75373182e-02f, -1.61955848e-01f, -1.03230119e-01f, -5.19003021e-03f, -1.46893889e-01f,
  7.10838959e-02f, 4.58125845e-02f, -8.95426422e-02f, -1.37545206e-02f, 6.08104654e-02f, -7.95423985e-02f, 2.22297944e-02f, 2.23970234e-01f, 1.10208169e-01f, -1.48560658e-01f,
  -1.04569204e-01f, 1.83798540e-02f, -8.97883326e-02f, 8.69126990e-02f, 1.06790904e-02f, -1.03663370e-01f, -8.39526728e-02f, 1.32329732e-01f, -6.81878626e-02f, 2.14947537e-01f,
  -1.12843946e-01f, 8.73138085e-02f, -4.81070429e-02f, 4.28034961e-02f, -1.26553131e-02f, 3.03579178e-02f, -1.84314162e-01f, 8.67377687e-03f, 3.86146866e-02f, -1.13845225e-02f,
  2.01765224e-02f, 1.57191738e-01f, 1.05971485e-01f, -2.20263712e-02f, -1.01927482e-02f, -5.01025654e-02f, 1.29462048e-01f, -7.69759044e-02f, -1.76578145e-02f, -1.34826630e-01f,
  -1.06587917e-01f, -1.55667678e-01f, -3.99507470e-02f, 5.11687994e-02f, 1.26271874e-01f, -2.08348557e-01f, -5.62927760e-02f, -6.94457665e-02f, -2.13339776e-02f, -1.10661224e-01f,
  -1.62517577e-01f, 8.71441141e-02f, 7.83630684e-02f, 1.47770554e-01f, 2.13361651e-01f, 7.17712715e-02f, 1.50053091e-02f, 1.55471861e-01f, -4.30736132e-02f, -7.97250494e-02f,
  1.63951755e-01f, 1.89209711e-02f, -8.00325274e-02f, 2.91358680e-02f, -4.30952497e-02f, -1.98969375e-02f, -5.33641269e-03f, -1.25349443e-02f, 5.60888276e-02f, -5.04444689e-02f,
  6.39881343e-02f, 1.68156207e-01f, 1.09371476e-01f, -1.67030059e-02f, -8.48174244e-02f, -1.03269763e-01f, -1.44562433e-02f, -2.91974545e-02f, 1.39575467e-01f, -4.59862612e-02f,
  3.05209696e-01f, 1.32284030e-01f, 5.21885902e-02f, -2.15672389e-01f, 1.37125030e-01f, -6.50165454e-02f, 7.46195316e-02f, -7.53445178e-02f, -1.78435147e-02f, -2.01795083e-02f,
  1.12400837e-01f, 3.08013022e-01f, 5.59273064e-02f, 1.91752940e-01f, 9.88219902e-02f, 2.06320867e-01f, -3.60453166e-02f, 1.05311319e-01f, 1.74271002e-01f, -9.91207659e-02f,
  -2.11166799e-01f, 2.41055056e-01f, -3.11762542e-01f, -8.50849971e-02f, 8.62888098e-02f, 3.11696172e-01f, -4.15593805e-03f, -1.12762280e-01f, -4.91974829e-03f, -7.16753155e-02f,
  8.91042575e-02f, -4.01854143e-02f, -1.51353041e-02f, 2.11692944e-01f, -3.52311395e-02f, 2.19518378e-01f, 8.20654407e-02f, 2.15768237e-02f, -2.18325511e-01f, -1.36585414e-01f,
  8.99150893e-02f, 3.57810445e-02f, 1.86438803e-02f, -1.54950961e-01f, 2.08262533e-01f, 3.80111821e-02f, -5.96061200e-02f, -1.24913968e-01f, 1.00436442e-01f, 4.84413728e-02f,
  3.66041926e-03f, -2.59503219e-02f, 2.95167893e-01f, -1.48800448e-01f, -4.83939089e-02f, 3.07877749e-01f, -7.39837214e-02f, -1.16215125e-01f, -1.62287548e-01f, 5.63276187e-02f,
  -9.75996479e-02f, 1.20317601e-01f, 3.57006080e-02f, 9.68118198e-03f, -2.02682037e-02f, 7.89559558e-02f, 1.38040066e-01f, 5.72475372e-03f, -2.24784147e-02f, 8.45519975e-02f,
  9.23633203e-02f, -7.56699294e-02f, 4.64362390e-02f, 1.55143708e-01f, 5.26445247e-02f, -2.98385527e-02f, -4.70719896e-02f, -3.04994341e-02f, 6.38015270e-02f, -7.55711794e-02f,
  -7.46098757e-02f, 1.47857830e-01f, 7.81961679e-02f, -1.54773772e-01f, 5.15833944e-02f, 9.77388397e-02f, 8.00606422e-03f, 4.08037007e-02f, -8.65283757e-02f, 6.54197484e-02f,
  -1.15379401e-01f, 5.42493165e-02f, -4.94585335e-02f, -9.16519240e-02f, -1.69140592e-01f, 1.20474547e-01f, -4.72679175e-02f, -1.04805350e-01f, -1.50149763e-01f, -1.28328353e-01f,
  1.02114759e-01f, 7.12274909e-02f, -3.06737311e-02f, -6.06734194e-02f, 9.96870846e-02f, 8.39807466e-02f, -9.09083113e-02f, -4.27333042e-02f, -1.75558738e-02f, -2.14455258e-02f,
  6.57680556e-02f, -7.10639432e-02f, 1.07552625e-01f, 4.11825553e-02f, 1.24976218e-01f, -6.52180891e-03f, -1.03733586e-02f, 1.13767102e-01f, -7.91758001e-02f, -6.96869940e-02f,
  -1.09727688e-01f, -1.12415254e-01f, -3.74068916e-02f, 1.27785161e-01f, 5.68520725e-02f, 1.19868599e-01f, -1.22467592e-01f, -5.24084978e-02f, 4.04096320e-02f, 1.06917553e-01f,
  -3.06612141e-02f, -1.26634553e-01f, -4.59035374e-02f, 6.88622817e-02f, 2.44089756e-02f, -8.66746306e-02f, 2.44485890e-03f, -2.17125639e-02f, -9.71685499e-02f, 9.47515145e-02f,
  1.04854003e-01f, -6.29857481e-02f, -6.93987235e-02f, -6.06076196e-02f, -3.06042861e-02f, -4.52531688e-02f, -1.00497916e-01f, -6.34219944e-02f, 6.73748925e-02f, 1.81078743e-02f,
  1.06775865e-01f, 9.06293690e-02f, 1.61600169e-02f, 9.41034183e-02f, 3.33668292e-02f, 1.14613883e-01f, 6.78902417e-02f, -2.85027362e-03f, 8.68062750e-02f, 1.21743016e-01f,
  1.12302937e-01f, -6.28001168e-02f, 8.30860659e-02f, 1.26437292e-01f, -3.55514288e-02f, 8.25451873e-03f, -8.19194689e-02f, -7.61692822e-02f, -7.19284713e-02f, 9.05319676e-02f,
  -8.64798501e-02f, -2.62815170e-02f, -6.23092465e-02f, 1.10138543e-02f, 4.76800427e-02f, 6.89066201e-02f, -1.11055717e-01f, 3.82018345e-03f, 7.44690746e-02f, 1.54076181e-02f,
  -5.07236086e-02f, 5.26950508e-03f, -1.83711424e-02f, -1.05134755e-01f, 4.46759723e-02f, -1.02253549e-01f, -1.11950509e-01f, -4.87725437e-02f, 1.16399333e-01f, -9.54331681e-02f,
  7.39832297e-02f, 1.01038881e-01f, 1.33600071e-01f, 8.55508894e-02f, 1.50574431e-01f, 1.93880767e-01f, -9.24240872e-02f, 8.02521035e-02f, -5.11630476e-02f, 4.51841624e-03f,
  -5.45083508e-02f, 7.10207410e-03f, 4.55742888e-02f, -1.07369713e-01f, 4.12089331e-03f, -1.10265249e-02f, 7.25048110e-02f, -2.23423578e-02f, -9.40175951e-02f, -2.85825338e-02f,
  6.41957298e-02f, -1.31550878e-02f, 5.20906178e-03f, 5.38264625e-02f, 7.39664445e-03f, -1.72957823e-01f, -6.00165091e-02f, -8.21498856e-02f, -1.33961841e-01f, -9.61849019e-02f,
  -3.52451168e-02f, -1.23935238e-01f, 2.29179002e-02f, 1.62627995e-01f, 1.56783666e-02f, 4.74167094e-02f, -2.02248305e-01f, 1.00489743e-01f, -1.22371987e-01f, 1.96714520e-01f,
  6.15167469e-02f, -3.90765928e-02f, -1.16433077e-01f, 1.33255586e-01f, 9.28518325e-02f, 1.18848294e-01f, -4.65987772e-02f, 1.04436085e-01f, 8.24063569e-02f, 1.45097688e-01f,
  3.19225192e-02f, -4.58360724e-02f, 2.74286002e-01f, 5.67059107e-02f, -4.78259474e-02f, -5.01100123e-02f, 9.85761508e-02f, 1.92974612e-01f, 5.33620548e-03f, -2.05641575e-02f,
  -1.35433525e-01f, 4.63881120e-02f, -9.21275765e-02f, 1.40081525e-01f, -5.10918833e-02f, -8.66788477e-02f, 4.61916700e-02f, 8.57311264e-02f, 1.17351122e-01f, 1.37003824e-01f,
  -8.36936608e-02f, -3.27603007e-03f, 1.40263392e-02f, 1.00275472e-01f, 6.49659485e-02f, 9.37182531e-02f, 8.86072293e-02f, -1.05722524e-01f, -4.34903167e-02f, 1.21168971e-01f,
  6.52560741e-02f, -1.25210524e-01f, 1.73168540e-01f, 1.01483613e-01f, 6.23198412e-02f, -4.16725762e-02f, 1.69858992e-01f, -4.73241620e-02f, -9.22700390e-02f, 1.14030875e-01f,
  -1.07169459e-02f, 9.89425108e-02f, -2.59572137e-02f, 2.13290125e-01f, -1.26188934e-01f, 6.93544596e-02f, -4.87026162e-02f, 2.25762744e-02f, -2.43769847e-02f, -4.77431640e-02f,
  -1.42920390e-01f, 1.42415715e-02f, 7.74130672e-02f, -8.24793335e-03f, -1.31527409e-01f, -4.96030375e-02f, -4.17269394e-02f, 1.14934191e-01f, -4.21714522e-02f, -6.12513982e-02f,
  1.96508288e-01f, -1.94283165e-02f, 2.36554090e-02f, 1.97606653e-01f, 6.22699852e-04f, 5.11562638e-02f, 2.96471789e-02f, 6.70972243e-02f, -1.43358499e-01f, -6.17592297e-02f,
  -8.19069818e-02f, -1.50363103e-01f, 7.88461715e-02f, -7.10587651e-02f, 1.56812802e-01f, -6.18372522e-02f, -1.83597561e-02f, -7.19047487e-02f, 7.62899518e-02f, 3.24236066e-03f,
  1.13587797e-01f, 1.40667960e-01f, 1.95461395e-03f, 1.14880078e-01f, -5.98776639e-02f, 1.50469571e-01f, 5.52506710e-04f, 7.35125989e-02f, 1.38903841e-01f, -7.28894025e-02f,
  -4.12146747e-02f, 1.42029315e-01f, -4.18013567e-03f, -8.74632597e-02f, -8.29500258e-02f, -6.59128977e-03f, -9.12854895e-02f, 1.02210477e-01f, 6.72810078e-02f, -7.72907138e-02f,
  -3.05754095e-02f, -1.06129283e-02f, -9.54068825e-03f, 2.89090499e-02f, 1.28296971e-01f, -1.01991162e-01f, -1.14740163e-01f, 1.09884635e-01f, -1.63542882e-01f, 2.01929167e-01f,
  -4.42357287e-02f, 1.00137480e-01f, -1.29000753e-01f, 8.88625681e-02f, -1.10508427e-01f, -1.15902342e-01f, 1.35451749e-01f, -5.13930954e-02f, -1.56083360e-01f, 8.35447162e-02f,
  -8.96646380e-02f, -7.45600238e-02f, 1.74640305e-02f, 6.71181679e-02f, 1.11893170e-01f, -1.13463819e-01f, 4.75926325e-02f, 1.08312398e-01f, 1.50845957e-03f, 1.10193696e-02f,
  -5.13078831e-02f, -1.02434695e-01f, -1.67078719e-01f, 3.41982059e-02f, 9.88908634e-02f, -9.72050205e-02f, -5.01063056e-02f, 1.09855734e-01f, 2.25872368e-01f, 1.80206701e-01f,
  -8.40588734e-02f, -1.97470672e-02f, 9.65104923e-02f, 2.16229722e-01f, 1.84534058e-01f, 1.23632327e-01f, 9.40729119e-03f, 1.55162662e-01f, 5.65065704e-02f, 1.61038652e-01f,
  7.46789798e-02f, 2.34551668e-01f, 1.06780231e-01f, 2.07981855e-01f, 2.26932406e-01f, 1.72375128e-01f, 1.38203040e-01f, 1.83133751e-01f, 6.34119958e-02f, 4.13116813e-02f,
  -4.93150167e-02f, 1.47448897e-01f, 1.42810702e-01f, -6.75216094e-02f, -1.13992281e-01f, 9.69037563e-02f, 7.29363784e-03f, -2.29755402e-01f, 1.32213116e-01f, -1.31947964e-01f,
  7.56355003e-02f, -2.58329827e-02f, 2.83453912e-01f, -1.66188747e-01f, -4.02192632e-03f, 2.03725129e-01f, -1.54334560e-01f, -1.40379285e-02f, -1.25176951e-01f, 2.37461284e-01f,
  -8.15618634e-02f, -4.07040939e-02f, 6.46006092e-02f, 1.28487227e-02f, 1.13444244e-02f, 5.20992801e-02f, -1.37267202e-01f, -1.10705160e-02f, -2.10929826e-01f, 9.42257605e-03f,
  9.63750780e-02f, 8.70494917e-02f, -1.08297616e-01f, 1.27584428e-01f, 2.10579813e-01f, -2.58002821e-02f, 2.36288849e-02f, 4.23346534e-02f, 4.98193875e-02f, 4.14428800e-01f,
  1.19659370e-02f, -9.35827196e-02f, -1.73865780e-01f, 5.81967458e-02f, 6.90420568e-02f, 1.43289119e-01f, -1.00190520e-01f, -1.52474763e-02f, 1.15790710e-01f, -6.62365109e-02f,
  -5.04009686e-02f, -9.69649553e-02f, 2.86706798e-02f, 1.30735591e-01f, -8.09807777e-02f, 4.80518006e-02f, 5.51153272e-02f, 5.95015809e-02f, -1.15260258e-01f, 2.84382198e-02f,
  -3.35184974e-04f, 2.12236214e-02f, 9.25628543e-02f, 9.58538204e-02f, -7.26742893e-02f, -2.80934423e-02f, -1.89144835e-01f, -3.75219323e-02f, -1.58416286e-01f, 1.98024154e-01f,
  -1.75604030e-01f, 2.04919185e-02f, -1.48282811e-01f, 4.51502614e-02f, 1.63233697e-01f, 4.48100977e-02f, 1.16174169e-01f, 9.93199367e-03f, 1.36457160e-01f, -2.00260311e-01f,
  1.16737284e-01f, -1.04364298e-01f, 1.18821830e-01f, -1.12040997e-01f, -9.63496342e-02f, 8.16561580e-02f, 1.36912629e-01f, -4.19649482e-02f, -1.24971438e-02f, 1.17869928e-01f,
  -4.10481095e-02f, 3.64519320e-02f, 1.46654457e-01f, -9.92281511e-02f, -9.23090503e-02f, -1.29224643e-01f, -8.97932872e-02f, 7.86130726e-02f, 3.10019664e-02f, -1.20189870e-02f,
  2.84616143e-01f, -1.11460954e-01f, 1.16568565e-01f, 2.17083860e-02f, -8.18165690e-02f, 4.67405841e-02f, -9.53026768e-03f, -9.79831740e-02f, -2.28996458e-03f, -4.56888520e-05f,
  -1.16333261e-01f, -5.40585294e-02f, -3.63266692e-02f, 4.66644801e-02f, 2.31075194e-02f, 5.62640727e-02f, -7.66664445e-02f, -5.11408113e-02f, 4.33812924e-02f, -4.20488827e-02f,
  -1.09583192e-01f, -3.02471854e-02f, -2.26167161e-02f, -1.15261883e-01f, -5.33889011e-02f, 1.09011196e-02f, 7.79188052e-02f, -6.96898997e-02f, 1.02280945e-01f, 5.02813198e-02f,
  2.30988804e-02f, 5.87769598e-02f, 6.29236773e-02f, 1.66625828e-02f, -1.54350102e-02f, -3.50149944e-02f, -1.30711840e-02f, 3.22146229e-02f, -4.35856432e-02f, 6.83756620e-02f,
  -1.65474508e-02f, 6.78753257e-02f, 9.24323648e-02f, 4.67389412e-02f, 1.09293163e-01f, -5.24251582e-03f, -3.00979633e-02f, -6.22626580e-02f, 1.97195578e-02f, -9.95089114e-02f,
  4.46308255e-02f, 4.65595685e-02f, 8.53850245e-02f, 4.74207364e-02f, -7.19765499e-02f, -1.14771307e-01f, -6.45146845e-03f, 5.26382811e-02f, -4.46538031e-02f, -8.88438523e-02f,
  -9.36800390e-02f, 3.07011921e-02f, -5.78598231e-02f, 1.22405395e-01f, -4.84060682e-02f, -9.03288200e-02f, -4.66170870e-02f, -4.70171757e-02f, -6.70841197e-03f, 9.23483074e-02f,
  -2.59066969e-02f, -9.80835557e-02f, 6.63288869e-03f, -7.53878355e-02f, 2.86008473e-02f, 2.10696626e-02f, -1.89193967e-03f, 8.35650228e-03f, 5.70506081e-02f, 2.24815356e-03f,
  -9.33725983e-02f, -9.92097706e-02f, -1.11129232e-01f, 1.36123255e-01f, 1.05448207e-02f, -1.31874517e-01f, -4.69327122e-02f, 5.09217083e-02f, 1.45303756e-01f, -3.77937295e-02f,
  -1.82644953e-03f, 3.91494110e-02f, -1.24488011e-01f, -8.26242194e-02f, -1.04867280e-01f, -5.80104366e-02f, 9.84226018e-02f, -1.40663713e-01f, 1.31225109e-01f, 5.32985367e-02f,
  1.59507059e-02f, -1.62839949e-01f, -6.53212070e-02f, 1.01777539e-01f, 2.35671792e-02f, -3.49257030e-02f, -1.42884701e-02f, 5.97062521e-02f, 1.30251706e-01f, -2.25715172e-02f,
  9.81341600e-02f, -4.95107844e-02f, 1.32390350e-01f, 5.30532114e-02f, 1.07241094e-01f, 1.17233030e-01f, 1.14515826e-01f, -6.12691194e-02f, 5.00187352e-02f, 5.70027865e-02f,
  5.26032113e-02f, 6.51078448e-02f, 4.09157909e-02f, 4.08673845e-02f, -1.14409380e-01f, 1.90197393e-01f, -6.55976459e-02f, -1.18192434e-01f, 1.00540422e-01f, -1.05909958e-01f,
  1.25948101e-01f, 3.79797667e-02f, 8.21349919e-02f, -2.41742227e-02f, 7.40244612e-02f, 9.72455591e-02f, -8.77028555e-02f, -1.98517404e-02f, -2.07962226e-02f, -7.58431330e-02f,
  2.08823718e-02f, -7.82015622e-02f, 7.84364939e-02f, 1.07621334e-01f, 1.12862229e-01f, 9.31909159e-02f, 9.36313421e-02f, 9.24167857e-02f, -7.19690472e-02f, -5.12518324e-02f,
  -6.57719746e-02f, -5.04082208e-03f, -2.45752204e-02f, -1.02068171e-01f, 2.94170137e-02f, -1.08277127e-01f, -1.30359456e-01f, -1.41990200e-01f, -7.22443312e-02f, 2.73792562e-03f,
  6.15611579e-03f, 3.49432752e-02f, -1.18493378e-01f, 2.58908253e-02f, -3.19429702e-04f, -5.25795110e-02f, -5.37616909e-02f, -1.34127503e-02f, -8.97218063e-02f, 9.70343575e-02f,
  -6.66885749e-02f, 7.26966709e-02f, 1.96444839e-02f, 1.14375263e-01f, 6.32243156e-02f, 2.98724999e-03f, -5.65411821e-02f, -3.43292095e-02f, -1.14791311e-01f, 5.86866476e-02f,
  -4.52948362e-02f, 6.72348812e-02f, -9.95821208e-02f, 1.57361403e-01f, -8.56692251e-03f, -1.02423236e-01f, 2.34339405e-02f, 1.43149507e-03f, 1.96650345e-02f, 7.41489325e-03f,
  -4.18802202e-02f, 5.56150228e-02f, 4.79359403e-02f, -1.17127031e-01f, -3.82580645e-02f, -5.45621365e-02f, 5.82574401e-03f, 9.19225141e-02f, -4.02613729e-02f, 1.30300283e-01f,
  7.25097302e-03f, -1.40111983e-01f, 1.46077722e-01f, -8.54205415e-02f, -1.83990647e-04f, 1.58604354e-01f, 1.61995113e-01f, 3.75976495e-04f, 1.14197716e-01f, 1.67074233e-01f,
  4.93832752e-02f, 5.35856821e-02f, 4.29421440e-02f, 5.48521280e-02f, -2.13234201e-02f, 1.15452960e-01f, 1.33894339e-01f, -4.19370681e-02f, 5.01045436e-02f, -7.22275376e-02f,
  -7.90661573e-02f, 5.69587424e-02f, -2.56793573e-02f, -7.17889592e-02f, 1.10719442e-01f, -1.66063115e-01f, -1.39660276e-02f, 1.61569789e-01f, -6.93925619e-02f, 4.94745225e-02f,
  -8.98968652e-02f, 1.19463354e-01f, -2.37474427e-01f, 1.19641818e-01f, -1.52583539e-01f, 1.92318141e-01f, -1.29816383e-01f, 4.46040444e-02f, -2.19720870e-01f, -1.11802712e-01f,
  1.69478342e-01f, -1.08585544e-01f, -1.88203499e-01f, -1.04886323e-01f, -7.61896297e-02f, -3.25260349e-02f, 9.67078507e-02f, 2.72816122e-01f, 7.54098594e-02f, -9.02479365e-02f,
  -1.35689870e-01f, 2.29183227e-01f, 1.33256182e-01f, -1.33065566e-01f, -7.38994703e-02f, 2.68618762e-03f, -1.45579055e-01f, 8.85826200e-02f, -6.69754343e-03f, -1.33345947e-01f,
  6.99328706e-02f, 1.27724439e-01f, 1.59579754e-01f, 1.06345359e-02f, 9.78969131e-03f, -7.78493881e-02f, 2.25451346e-02f, -4.31954041e-02f, 5.42898513e-02f, 4.89987358e-02f,
  4.52793650e-02f, -1.19951427e-01f, 1.82620898e-01f, 2.43715912e-01f, 3.06344144e-02f, 1.41209329e-03f, 1.85585961e-01f, 1.09196298e-01f, 1.55223414e-01f, 2.08002359e-01f,
  4.59336303e-02f, -6.17195033e-02f, 8.26060772e-02f, 1.80902049e-01f, 1.26644418e-01f, -1.24066688e-01f, -9.03807282e-02f, -1.73631981e-01f, -1.29655540e-01f, 1.90773442e-01f,
  -2.69714892e-02f, -7.90657382e-03f, -1.02352705e-02f, 1.35023132e-01f, 1.88618481e-01f, -1.43272549e-01f, 1.23000637e-01f, 1.15214931e-02f, 1.73784018e-01f, -1.28852785e-01f,
  2.11078227e-01f, 3.45885493e-02f, 1.75877497e-01f, 1.32655084e-01f, 5.50099872e-02f, 1.69229299e-01f, -3.97522822e-02f, -1.23601817e-01f, -6.85484856e-02f, 1.29958063e-01f,
  -8.08889344e-02f, -1.31456792e-01f, 4.83955085e-01f, 8.29674006e-02f, -4.98600770e-03f, -1.87914774e-01f, -1.19829088e-01f, -2.81854179e-02f, 2.85079814e-02f, -1.48183450e-01f,
  4.06628579e-01f, 4.58558239e-02f, 2.41500363e-02f, 1.57026052e-01f, 1.09592944e-01f, -4.11371961e-02f, -3.54828462e-02f, 1.14101507e-01f, -1.24933816e-01f, -1.08199783e-01f,
  1.23581193e-01f, 2.83250362e-02f, -4.65876460e-02f, 3.93816419e-02f, 1.60799101e-01f, -1.95240080e-01f, 2.49273196e-01f, 1.44687310e-01f, 1.83034867e-01f, 2.55767647e-02f,
  4.63186279e-02f, 2.29490653e-01f, 2.49708772e-01f, 9.48634837e-03f, 1.97777953e-02f, 7.07407892e-02f, -2.66485997e-02f, 2.63438761e-01f, 2.12652132e-01f, -7.68478587e-02f,
  1.54980630e-01f, -1.68957785e-01f, 8.30049962e-02f, -6.08494729e-02f, -2.92773366e-01f, 1.78963885e-01f, 9.97375175e-02f, 3.68424118e-01f, 2.34411940e-01f, 8.19215328e-02f,
  1.41588673e-01f, 1.66898400e-01f, -1.08253159e-01f, 1.03095293e-01f, 1.65537268e-01f, 8.75977147e-03f, -5.68705760e-02f, -3.48350666e-02f, 5.65502271e-02f, -1.79996714e-01f,
  -1.20913371e-01f, 8.36312398e-03f, 6.13332279e-02f, -6.60862848e-02f, -1.05095461e-01f, -1.11980557e-01f, 5.23187339e-01f, -8.27329755e-02f, 7.60283619e-02f, -1.96298566e-02f,
  -1.23323455e-01f, 1.56770349e-01f, 1.28620178e-01f, -1.16532370e-01f, 1.39494866e-01f, 8.62363353e-02f, 5.44180423e-02f, -1.06315270e-01f, 9.85243917e-02f, -1.45753905e-01f,
  8.58398378e-02f, 1.80865645e-01f, -3.76826413e-02f, 3.15358900e-02f, -2.74587106e-02f, 3.35328877e-02f, 1.81686189e-02f, 1.34379596e-01f, -9.34256688e-02f, -2.46421322e-02f,
  -1.30143106e-01f, 1.74161326e-02f, -4.42004316e-02f, 3.34805623e-02f, 7.55857676e-02f, -1.23498499e-01f, 2.04838309e-02f, -6.66239485e-02f, 2.94066258e-02f, 8.14761519e-02f,
  -1.18736878e-01f, -2.21804641e-02f, -8.70084092e-02f, -6.91512898e-02f, 3.83758135e-02f, 5.19794188e-02f, -2.40890887e-02f, 7.03619495e-02f, 6.74530864e-03f, 6.59044161e-02f,
  -3.07169072e-02f, -3.75702009e-02f, 9.07599702e-02f, -6.55755699e-02f, 6.88307136e-02f, 6.53917789e-02f, -3.09822569e-03f, 1.13806546e-01f, -7.63581246e-02f, -4.32736389e-02f,
  4.80365232e-02f, -3.80334929e-02f, -9.44076553e-02f, 1.85959145e-01f, 1.88236848e-01f, -3.92376631e-02f, -3.75254476e-03f, 1.39364436e-01f, 1.31318700e-02f, 1.45560846e-01f,
  -7.51651525e-02f, 4.68923785e-02f, 6.55593127e-02f, 1.11461252e-01f, 1.25773787e-01f, -3.23264371e-03f, 4.26949337e-02f, -4.26459685e-02f, 3.79808061e-02f, -8.51241872e-02f,
  -3.55921052e-02f, 1.51924103e-01f, 5.58697470e-02f, -8.77494290e-02f, -7.41961002e-02f, -8.09243042e-03f, -1.15694709e-01f, 3.88711574e-03f, -3.58500592e-02f, 4.94264960e-02f,
  1.54329911e-01f, -1.14048272e-02f, 8.57934356e-03f, 1.27144158e-01f, -4.84145470e-02f, 7.68027529e-02f, 1.08129054e-01f, -6.98477030e-02f, -2.63672397e-02f, 2.33151708e-02f,
  1.33424476e-01f, 2.08666939e-02f, -1.26795366e-01f, 1.84397906e-01f, -1.82944145e-02f, -1.13622963e-01f, -4.36734110e-02f, 1.43067554e-01f, 1.04919985e-01f, -5.17697483e-02f,
  1.73630044e-01f, -1.50881603e-01f, 2.09074393e-02f, 4.72898595e-02f, -8.27442631e-02f, 4.54889098e-03f, -1.14363432e-01f, 1.60264552e-01f, -1.51462495e-01f, 5.85560389e-02f,
  -2.21578807e-01f, -3.46305147e-02f, 1.29508432e-02f, 1.09248757e-01f, -1.01822667e-01f, 8.06614757e-02f, 9.22673866e-02f, -8.31336975e-02f, -8.05695131e-02f, 8.75978768e-02f,
  7.22781271e-02f, -4.87837605e-02f, -1.06692962e-01f, 2.81164944e-02f, 5.87785840e-02f, -1.02299914e-01f, -1.19254582e-01f, 7.05985501e-02f, -1.15015291e-01f, -1.18574090e-01f,
  2.73123175e-01f, -8.78663659e-02f, -1.31068960e-01f, 1.32353276e-01f, -9.62865055e-02f, -8.80457088e-02f, 7.48641789e-02f, -4.96697761e-02f, 1.61853343e-01f, 4.87752783e-04f,
  -2.36375704e-02f, 1.86766922e-01f, -5.87246865e-02f, -9.53948647e-02f, 6.85799569e-02f, -4.57112975e-02f, 2.70501710e-02f, -1.03538446e-01f, 1.59446001e-02f, -5.05271778e-02f,
  1.59238111e-02f, -8.21950138e-02f, 1.05501369e-01f, 1.22572541e-01f, 8.95643383e-02f, 7.68559203e-02f, 6.24317937e-02f, 6.26812354e-02f, -4.41775881e-02f, -2.85221059e-02f,
  1.15869150e-01f, -7.95729309e-02f, 2.40610167e-02f, -3.11591364e-02f, -3.77930328e-02f, -7.30996653e-02f, -8.53413120e-02f, 6.65979087e-02f, -1.38570264e-01f, -4.00354002e-05f,
  7.00417459e-02f, -1.05233803e-01f, -5.38097136e-02f, 8.16940814e-02f, 1.13940194e-01f, -1.32934645e-01f, -5.03318869e-02f, 7.68468007e-02f, 2.91534588e-02f, 5.75355291e-02f,
  -1.90761480e-02f, -3.48513797e-02f, 3.67250219e-02f, 6.25260100e-02f, 1.18605874e-01f, 7.04346597e-02f, 9.56141874e-02f, -1.02879088e-02f, 2.17685229e-04f, 1.20544754e-01f,
  -7.46325701e-02f, -1.37221903e-01f, 1.07148103e-01f, -8.34542066e-02f, -1.05414972e-01f, -3.83283086e-02f, 2.00549439e-01f, 4.19613719e-03f, 5.47562204e-02f, -9.52220932e-02f,
  5.09686908e-03f, -3.14845406e-02f, 4.69100066e-02f, 1.48864426e-02f, 6.84405714e-02f, 1.06862314e-01f, -3.09722517e-02f, 5.08837812e-02f, 2.76531368e-01f, 6.24027289e-02f,
  1.40495524e-01f, 1.98071539e-01f, -4.14195843e-02f, 5.73945716e-02f, 3.18408877e-01f, 3.85197327e-02f, 9.23934579e-02f, 1.49001569e-01f, 1.80930555e-01f, 8.99545178e-02f,
  -1.51864052e-01f, 2.60299772e-01f, -1.48849398e-01f, 6.30974025e-02f, -2.62958445e-02f, 2.05890924e-01f, 6.10928275e-02f, 2.34368797e-02f, 9.35072005e-02f, -7.83289131e-03f,
  -1.49905264e-01f, 6.58616349e-02f, 2.38785446e-01f, -5.44000715e-02f, -9.99843478e-02f, 3.72436494e-02f, 1.17975950e-01f, 5.49740046e-02f, -2.22757816e-01f, 3.30800056e-01f,
  -9.67724323e-02f, 2.28673279e-01f, -2.32909814e-01f, 3.16184670e-01f, -2.48381682e-02f, -1.37000799e-01f, 2.07397670e-01f, 6.27890006e-02f, -1.10027164e-01f, -9.34259146e-02f,
  -9.43317637e-02f, 1.08333468e-01f, -2.62825161e-01f, -2.18842924e-02f, 8.05077031e-02f, 2.21253753e-01f, -2.02069283e-02f, 9.31323469e-02f, 5.25030136e-01f, 6.39095604e-02f,
  6.51597679e-02f, -3.11208628e-02f, -6.85402900e-02f, 2.34876394e-01f, 9.46034938e-02f, -8.93852040e-02f, -1.08255655e-01f, -1.59185737e-01f, -3.21512595e-02f, 2.18719244e-01f,
  -8.60721245e-03f, 4.25271019e-02f, -8.81864876e-02f, -9.54247490e-02f, 4.85311553e-04f, -3.79531644e-02f, -3.54951899e-03f, -1.09695509e-01f, 8.57133940e-02f, -4.12003286e-02f,
  7.48139173e-02f, -1.52140753e-02f, -2.91116326e-03f, -1.20930038e-01f, 6.51913881e-03f, -6.97707906e-02f, -7.64697194e-02f, 8.64264891e-02f, -8.16919468e-03f, -6.92062452e-03f,
  3.51144113e-02f, -1.20126233e-02f, -3.83381825e-03f, -5.81414811e-02f, -6.63422570e-02f, -1.23532169e-01f, -1.07641317e-01f, 9.71241388e-03f, 2.94501316e-02f, 6.98402897e-02f,
  5.43679707e-02f, 1.13256993e-02f, -3.17141339e-02f, 1.37342745e-02f, 5.45634748e-03f, 3.56258787e-02f, -8.87562614e-03f, -1.15091719e-01f, 3.81320901e-02f, 1.39580041e-01f,
  -8.04352909e-02f, -1.05216861e-01f, 1.01484165e-01f, 8.44483599e-02f, 5.83603568e-02f, -2.25304607e-02f, 4.86618355e-02f, 4.38880660e-02f, -1.52018825e-02f, 1.27329320e-01f,
  -2.56068143e-03f, -5.79336435e-02f, -6.00991361e-02f, 9.26824883e-02f, 1.75308250e-02f, 3.63042131e-02f, -1.03295729e-01f, -9.92691796e-03f, 1.79654621e-02f, -9.78025198e-02f,
  -8.00011307e-02f, -4.75953296e-02f, -7.27355108e-02f, 1.46256322e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.30802348e-01f, 1.15958706e-01f, 1.23029657e-01f, 1.92080200e-01f, 1.13657258e-01f, 9.86925066e-02f, 1.39381275e-01f, 1.29458323e-01f, -8.52705389e-02f, -4.35850918e-02f,
  -1.66414473e-02f, -2.48286258e-02f, 1.39577001e-01f, 3.45289914e-06f, 3.47893834e-02f, 8.39789510e-02f, 1.26269594e-01f, -5.60933724e-02f, 1.32356703e-01f, 1.58945501e-01f,
  1.99399129e-01f, -4.68822047e-02f, -7.61731640e-02f, -7.00947419e-02f, 9.12672505e-02f, 3.93931232e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -5.69621474e-02f, 1.45888790e-01f, 1.35575235e-01f, 1.10954434e-01f, 1.79030595e-03f, 6.06438331e-02f, 7.13507757e-02f, 1.70886964e-01f, 2.33934700e-01f, -1.45962154e-02f,
  -4.41403478e-01f, -5.18641174e-02f, -1.39425486e-01f, 1.96377486e-01f, 1.90400898e-01f, 8.38631094e-02f, 7.74005055e-02f, 1.05314903e-01f, -6.98113022e-03f, -3.11402261e-01f,
  -8.28923807e-02f, 1.12899549e-01f, -1.06534949e-02f, -3.56491417e-01f, -3.70270878e-01f, -5.28413691e-02f, -2.18915462e-01f, 5.84525894e-03f, -3.01175833e-01f, -3.25140268e-01f,
  2.92522967e-01f, 3.78085561e-02f, 3.40105891e-01f, 1.39455974e-01f, 7.54581094e-02f, 3.96660626e-01f, -1.53115258e-01f, -2.00931787e-01f, 2.19499603e-01f, -4.55336541e-01f,
  -2.69120216e-01f, -1.58233032e-01f, 4.47075814e-02f, 1.15727827e-01f, 1.45776605e-03f, -2.13619657e-02f, 6.11737818e-02f, 4.23206985e-02f, 2.91337043e-01f, -1.60928532e-01f,
  -1.49282396e-01f, 5.35256445e-01f, -5.34197278e-02f, 7.61304945e-02f, -2.98432801e-02f, -1.24045461e-02f, -2.32027963e-01f, -3.31525743e-01f, -4.20260012e-01f, 7.89131895e-02f,
  -1.08005829e-01f, 4.98976037e-02f, 4.92706507e-01f, 8.73194486e-02f, -3.03583760e-02f, 4.18323576e-02f, 1.84980854e-02f, -3.89356762e-01f, 1.45783082e-01f, 9.45551023e-02f,
  1.36174664e-01f, -3.08489352e-01f, 5.50730564e-02f, -1.73484996e-01f, 3.35175127e-01f, -9.72151663e-03f, -2.47024387e-01f, 5.40983081e-02f, -2.60580909e-02f, 1.72512949e-01f,
  2.74096817e-01f, -2.81267345e-01f, 3.20232928e-01f, -1.91645145e-01f, 2.91810423e-01f, -3.06505948e-01f, -4.93369773e-02f, 1.76147774e-01f, 3.74045134e-01f, 3.59414995e-01f,
  -2.62055278e-01f, -1.46544576e-01f, -1.71493143e-01f, -8.05511326e-02f, 3.17921937e-01f, 3.03103328e-01f, -2.59800911e-01f, -3.36223453e-01f, 3.26611102e-01f, -2.80895531e-01f,
  3.19877505e-01f, 2.82691032e-01f, 2.22493142e-01f, -7.10338354e-02f, -1.57334700e-01f, -2.21361250e-01f, 1.51366100e-01f, -1.97567403e-01f, 3.69235456e-01f, -1.42594323e-01f,
  -1.33427620e-01f, 1.09392099e-01f, 2.36443415e-01f, -1.15157753e-01f, -6.47740588e-02f, 1.96377531e-01f, 2.08639011e-01f, -1.16764028e-02f, 2.18774498e-01f, 6.28955737e-02f,
  -1.85955361e-01f, 2.78283864e-01f, -4.96543825e-01f, 1.57564610e-01f, -1.41237944e-01f, 5.24141341e-02f, -1.28155380e-01f, 8.00947323e-02f, -7.57986009e-02f, -3.47122014e-01f,
  -4.04909030e-02f, -2.59579837e-01f, -1.50247201e-01f, -4.66154128e-01f, -2.24259347e-01f, -2.57119715e-01f, -3.47801805e-01f, -1.57456174e-01f, -3.21026146e-01f, 3.25649790e-02f,
  1.46678838e-04f, -2.32172608e-01f, -2.96333462e-01f, -2.98058808e-01f, -2.57363647e-01f, -2.00215861e-01f, -2.09209442e-01f, -1.31482601e-01f, 1.48403555e-01f, -3.67836237e-01f,
  2.64012188e-01f, 2.03787461e-01f, 3.33474070e-01f, 1.15090474e-01f, -2.06621721e-01f, -8.80852565e-02f, -2.48575080e-02f, 7.14719296e-02f, 2.56923705e-01f, -1.24739721e-01f,
  2.12514862e-01f, 2.36462265e-01f, 2.20156223e-01f, 7.24576786e-02f, -6.47900999e-02f, 5.57965577e-01f, -1.09946288e-01f, -6.67186528e-02f, -2.65578121e-01f, 8.34503695e-02f,
  9.21238959e-02f, 3.03929877e-02f, 2.45564759e-01f, 2.32719451e-01f, 4.08151234e-03f, 1.00332499e-02f, -9.58658680e-02f, -1.21585667e-01f, -9.17957500e-02f, -2.61728615e-01f,
  3.90452504e-01f, -5.44804558e-02f, -3.56754810e-02f, -4.28048894e-02f, 7.84640089e-02f, 4.10270452e-01f, -5.30578643e-02f, -5.70264496e-02f, -1.33948191e-03f, 1.20041043e-01f,
  -2.56963432e-01f, 6.12680316e-02f, 2.36053005e-01f, -3.53618562e-01f, -2.73272365e-01f, 1.66604087e-01f, -2.27945119e-01f, -1.48180202e-01f, -1.91512391e-01f, -1.07735984e-01f,
  -1.26489937e-01f, -9.75779071e-02f, -1.61885500e-01f, -6.31539077e-02f, 8.69700685e-02f, -2.03280985e-01f, -7.99087211e-02f, -3.95491362e-01f, -1.92940578e-01f, -1.17818087e-01f,
  -2.08082609e-02f, 1.51725084e-01f, -1.74954727e-01f, 1.30293844e-02f, 3.89502645e-02f, -1.38490811e-01f, -3.19446653e-01f, -9.62070152e-02f, 6.95916787e-02f, 1.00680321e-01f,
  2.01169953e-01f, -3.05864900e-01f, -2.09545255e-01f, -2.69903690e-01f, 1.92824304e-01f, 1.44811705e-01f, -5.42479865e-02f, 2.76090205e-01f, -1.23964541e-01f, -2.50937879e-01f,
  3.59468907e-02f, 1.19433612e-01f, -5.22312671e-02f, 9.52590033e-02f, -1.54809043e-01f, 4.56290208e-02f, -2.26382650e-02f, -2.01000750e-01f, 3.52710560e-02f, 3.18014212e-02f,
  1.30740002e-01f, 2.46861562e-01f, 2.10555922e-02f, -9.47408825e-02f, -1.57611549e-01f, 1.60488095e-02f, -4.75218296e-02f, -1.21320114e-01f, 1.33021727e-01f, -4.28344786e-01f,
  -2.18457356e-01f, -1.40162855e-01f, 4.73973066e-01f, 1.10398978e-01f, 5.18257380e-01f, 6.93648756e-02f, -7.41518289e-02f, 3.90142277e-02f, -1.40846014e-01f, 3.01767111e-01f,
  -1.59028009e-01f, -2.02862963e-01f, 6.26437813e-02f, -1.00656822e-01f, -1.81798562e-01f, 2.31375381e-01f, 1.67824402e-01f, 6.20042533e-03f, 1.83018744e-01f, 3.30729395e-01f,
  3.52727443e-01f, 8.67385566e-02f, 3.74256432e-01f, -1.57353148e-01f, -1.44026086e-01f, -3.16893220e-01f, -3.38981271e-01f, 1.21319056e-01f, 2.02364832e-01f, -3.60172056e-02f,
  -2.56350428e-01f, -1.38639331e-01f, 2.07419395e-01f, 3.72012585e-01f, 6.25595450e-02f, -4.33223307e-01f, -2.00760722e-01f, 1.03645697e-01f, 1.90642569e-02f, 2.00032905e-01f,
  -2.15363055e-01f, 1.96802378e-01f, -2.82907486e-01f, -1.82206929e-01f, -5.71474656e-02f, -3.36664408e-01f, 3.30965102e-01f, -1.04108863e-01f, -1.31262869e-01f, 3.70906055e-01f,
  1.37663772e-02f, 3.99410009e-01f, 1.38185561e-01f, 1.15096979e-01f, -1.60663407e-02f, -7.77478814e-02f, 1.23691201e-01f, 8.84369835e-02f, -2.48113900e-01f, -8.44890624e-03f,
  5.05673094e-03f, 1.97540931e-02f, 2.10276507e-02f, 4.28171828e-03f, 1.27623245e-01f, -6.19822182e-02f, 4.07298990e-02f, 6.19877577e-02f, 3.14301312e-01f, -1.16821036e-01f,
  -2.60524917e-02f, 9.23517719e-02f, 1.89486980e-01f, -1.10130608e-01f, 1.28731743e-01f, 1.97227955e-01f, -8.43138620e-03f, 3.01638454e-01f, 1.25641689e-01f, -2.15664446e-01f,
  3.80400300e-01f, 3.86023849e-01f, 1.00977451e-01f, -9.16550159e-02f, -1.48299113e-01f, 1.78187311e-01f, 1.88043490e-01f, 2.57769644e-01f, -2.82390602e-02f, -1.81841478e-02f,
  2.40718499e-01f, 1.35233432e-01f, -1.01490736e-01f, -2.49838397e-01f, -3.47619563e-01f, 1.38386026e-01f, -2.53558517e-01f, -3.58784348e-02f, -3.04930001e-01f, -2.68001825e-01f,
  1.09064311e-01f, -7.59673640e-02f, -3.17600548e-01f, -2.31591448e-01f, 2.82940478e-03f, -2.72351593e-01f, -1.45621262e-02f, -1.90487072e-01f, 2.73136459e-02f, -3.13632816e-01f,
  -3.61502618e-02f, -3.46956290e-02f, 1.12402529e-01f, -9.46112648e-02f, -8.03031623e-02f, 3.90600860e-01f, -1.39696598e-01f, -5.88911660e-02f, 2.27868576e-02f, -2.63513029e-02f,
  -1.70336068e-01f, 4.00872171e-01f, 1.46607896e-02f, 2.01687440e-02f, -1.28561437e-01f, 8.00480619e-02f, -2.47073606e-01f, 1.49205327e-01f, 2.70845979e-01f, -1.11913823e-01f,
  -2.25856408e-01f, -2.66018361e-02f, 3.11056674e-01f, -3.81041095e-02f, -1.74949259e-01f, 1.52658997e-02f, 3.59886169e-01f, -2.26680338e-01f, -1.49073198e-01f, 6.90858439e-02f,
  5.55879846e-02f, 1.33789912e-01f, -9.85792726e-02f, 1.64621547e-01f, -2.47959003e-01f, -6.42731860e-02f, 6.13624975e-02f, -1.51791692e-01f, -2.55050689e-01f, 1.15442485e-01f,
  -3.48300844e-01f, -1.75403263e-02f, 4.08154368e-01f, -1.74865529e-01f, 1.73297077e-01f, -2.64144968e-02f, -1.35813728e-01f, 4.04904127e-01f, 3.66026551e-01f, 2.67976195e-01f,
  -2.53040157e-02f, -1.66861773e-01f, -7.25213289e-02f, 2.43976057e-01f, -1.75811738e-01f, -1.47519276e-01f, -2.23706495e-02f, -2.26106539e-01f, 3.50583076e-01f, -1.27600715e-01f,
  4.78082359e-01f, 2.67430563e-02f, -2.67729700e-01f, -7.63505464e-03f, 7.81418160e-02f, 3.16616446e-01f, -9.10361111e-03f, -2.21862718e-01f, -2.36768007e-01f, 5.68151735e-02f,
  -7.45531321e-02f, 1.11185864e-01f, -2.55559534e-01f, -1.18153421e-02f, 2.53157737e-03f, -2.94277728e-01f, 1.96816415e-01f, 6.61072582e-02f, -7.39135444e-02f, 6.50310889e-03f,
  -5.20871505e-02f, 4.62981164e-01f, 4.30934668e-01f, -9.27582532e-02f, -6.02577217e-02f, 1.68735936e-01f, -4.61133778e-01f, 9.32864994e-02f, 6.97112530e-02f, 2.11723059e-01f,
  -8.28445852e-02f, 2.19132518e-03f, -3.39090526e-02f, 2.29409873e-01f, -2.03883320e-01f, 1.12886697e-01f, -2.11134449e-01f, 4.60471325e-02f, -4.62903887e-01f, 1.47733942e-01f,
  1.08331218e-02f, -1.06913552e-01f, -3.19277565e-03f, 1.20191291e-01f, -1.64318606e-01f, -4.65981290e-02f, -9.66110267e-03f, 3.19595098e-01f, -2.40111932e-01f, 2.26543605e-01f,
  3.82843107e-01f, -4.01166469e-01f, -1.10265138e-02f, -2.21255645e-01f, 1.49975419e-01f, 2.84331173e-01f, 5.51673286e-02f, -1.47379890e-01f, -2.64942776e-02f, 2.40353718e-01f,
  3.27311456e-01f, 3.77239645e-01f, -2.95253038e-01f, 4.50999856e-01f, -2.70967454e-01f, -2.73671746e-01f, 2.41097555e-01f, -2.64836013e-01f, -2.71849424e-01f, -2.93735087e-01f,
  -1.24394499e-01f, -1.64762214e-01f, -1.39846742e-01f, -2.20231876e-01f, -1.29236326e-01f, -2.79826466e-02f, 3.45621035e-02f, 1.52087323e-02f, 3.23421508e-01f, -1.87171027e-01f,
  2.67599616e-02f, -1.07213363e-01f, 1.00481868e-01f, 1.63130835e-01f, 5.07197440e-01f, -3.28553617e-01f, -4.60807681e-01f, -3.60270888e-02f, -1.10640633e-03f, -6.50041401e-02f,
  -4.00450863e-02f, -3.78892086e-02f, 2.55760640e-01f, 6.47641299e-03f, -2.40815848e-01f, -1.70610517e-01f, -3.58646333e-01f, -4.64633316e-01f, 4.70539778e-02f, -1.44125745e-01f,
  1.64903048e-02f, -8.42170268e-02f, -1.75542846e-01f, -9.39526185e-02f, -6.29664958e-02f, -1.60446942e-01f, -7.06276000e-02f, 1.28382400e-01f, -3.12806278e-01f, -6.20445199e-02f,
  -5.65679967e-01f, 3.10262859e-01f, 1.58400357e-01f, -1.86555207e-01f, 9.43474397e-02f, 2.04222560e-01f, -8.42191279e-02f, 1.53531954e-01f, -1.15977637e-01f, -1.39151216e-01f,
  -1.34827316e-01f, 2.52150387e-01f, 1.62346035e-01f, -1.40113523e-02f, -4.77134362e-02f, -1.57212391e-01f, 1.42439082e-01f, 7.69458413e-02f, -2.83531863e-02f, 7.85881355e-02f,
  1.13275409e-01f, 5.72744906e-01f, -1.44866616e-01f, 2.07493141e-01f, -4.12523421e-03f, -4.06793244e-02f, 8.30629542e-02f, -5.18245518e-01f, 7.09644258e-02f, -5.33380620e-02f,
  4.10074778e-02f, 6.97598159e-02f, -1.49448946e-01f, -3.30480963e-01f, 6.12385720e-02f, -2.63976455e-02f, 2.48098925e-01f, -7.92183354e-02f, -9.31193456e-02f, -6.86516687e-02f,
  2.18501851e-01f, 8.11964348e-02f, -9.33852345e-02f, -6.12524450e-02f, -1.43085167e-01f, 1.49774060e-01f, -1.53860793e-01f, 2.39190698e-01f, 4.01256941e-02f, 1.54294565e-01f,
  1.80475011e-01f, 2.60239720e-01f, 1.81042314e-01f, -4.66032550e-02f, 2.74135202e-01f, 2.28352532e-01f, 1.03219181e-01f, -1.59618691e-01f, -4.49196137e-02f, 9.72668529e-02f,
  7.47003406e-02f, 1.78221032e-01f, 7.48893693e-02f, 1.88562587e-01f, -1.48344696e-01f, -1.05284035e-01f, 2.62255758e-01f, 3.19976687e-01f, -1.32716835e-01f, -5.95367476e-02f,
  1.25457913e-01f, -2.11956017e-02f, 3.27682793e-01f, 1.32613033e-01f, -2.12524027e-01f, 3.75458717e-01f, -3.20828438e-01f, 8.69120751e-03f, -3.49929124e-01f, -2.38563284e-01f,
  2.14100286e-01f, -4.49011534e-01f, -1.08146839e-01f, -3.40785772e-01f, -1.51706681e-01f, -5.79918206e-01f, 3.62797052e-01f, -8.12545419e-02f, -1.89025491e-01f, 4.02022779e-01f,
  -2.40820482e-01f, 3.77861679e-01f, -3.71330306e-02f, -8.94553214e-02f, -1.85982615e-01f, -2.22128808e-01f, -1.36098176e-01f, 2.83500589e-02f, 8.84064585e-02f, 6.32283390e-02f,
  6.59349859e-02f, 3.69382091e-02f, -1.68754786e-01f, 3.24436039e-01f, 1.52290836e-01f, -1.71915889e-01f, -1.68140039e-01f, 1.57615080e-01f, -5.32903016e-01f, -8.67670625e-02f,
  -2.18605679e-02f, 2.04969496e-01f, 2.16637589e-02f, -2.77511865e-01f, 6.02094233e-02f, 2.08076742e-02f, 2.71585081e-02f, 1.93086803e-01f, 1.86756968e-01f, 2.44933128e-01f,
  1.80672020e-01f, 4.97019067e-02f, -3.12704258e-02f, 2.08699629e-01f, -1.95089187e-02f, -8.65584239e-02f, 2.47468781e-02f, 2.79476434e-01f, 1.25921845e-01f, -2.20624059e-01f,
  -2.02069104e-01f, 7.02808201e-02f, -1.62183210e-01f, -1.34911805e-01f, 1.60924658e-01f, 4.84374426e-02f, 6.15394972e-02f, -1.97360307e-01f, 2.89540619e-01f, 1.03762694e-01f,
  -9.89002585e-02f, 4.47426969e-03f, -5.80494590e-02f, -1.68793514e-01f, -2.86666095e-01f, -1.33312389e-01f, 1.70518950e-01f, 4.01858181e-01f, 5.01959808e-02f, 6.45973146e-01f,
  -2.70361006e-01f, 1.15325592e-01f, 1.35468736e-01f, -5.73264770e-02f, -4.29989919e-02f, -2.66153902e-01f, 1.95824221e-01f, 9.53150466e-02f, 1.84933692e-01f, -4.47554216e-02f,
  -2.15282574e-01f, 1.88315183e-01f, -2.30511710e-01f, -7.25322664e-02f, 4.41196114e-02f, -4.66384888e-02f, -1.43091902e-01f, -1.85071930e-01f, 1.21497184e-01f, -2.55518667e-02f,
  1.05222210e-01f, 6.72488660e-02f, 1.47613078e-01f, -7.69513077e-04f, 7.13388175e-02f, 1.17269516e-01f, -8.36286694e-03f, 2.18250155e-01f, 5.08676395e-02f, 9.12847891e-02f,
  -1.13674521e-01f, -7.81223327e-02f, 1.53285027e-01f, -2.70312220e-01f, 2.57531792e-01f, -2.17438117e-01f, 2.10684817e-02f, 1.87155589e-01f, 2.55272686e-01f, -8.57556835e-02f,
  2.14806408e-01f, 8.04946050e-02f, 3.71325344e-01f, -4.24864516e-03f, -2.35052794e-01f, -3.75314765e-02f, -2.87583079e-02f, -9.17937905e-02f, 9.31239873e-02f, -1.25299111e-01f,
  1.78627461e-01f, 7.67900124e-02f, 3.30621958e-01f, 2.98974216e-01f, -6.31014407e-02f, -1.78914830e-01f, -1.11682273e-01f, 1.49273410e-01f, -2.43109092e-01f, -2.02407852e-01f,
  -1.66848436e-01f, 8.42557102e-02f, -2.06529512e-03f, 2.04728037e-01f, 4.23146605e-01f, 4.26841795e-01f, -1.35350734e-01f, -4.35911492e-02f, 3.56782116e-02f, -2.21381932e-01f,
  9.19223651e-02f, -8.40145629e-03f, -1.71752170e-01f, 3.24593097e-01f, 1.79043159e-01f, -2.90770590e-01f, 3.45382504e-02f, 1.24174327e-01f, -4.72986512e-02f, 7.39386454e-02f,
  2.60525107e-01f, -1.36408240e-01f, 3.69841903e-01f, -1.50694415e-01f, 6.04998544e-02f, 1.07882641e-01f, -3.18022043e-01f, 8.09572041e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.22474407e-02f, -1.07490951e-02f, 7.17696827e-03f, 4.01462950e-02f, -5.50568216e-02f, 7.35911950e-02f, -3.20640206e-02f, 1.48168638e-01f, -9.33921933e-02f, 1.29855916e-01f,
  7.20079988e-02f, -7.03249499e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    