/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.41705632e-01f, -3.49474430e-01f, -1.99496038e-02f, 9.43683013e-02f, 1.39442965e-01f, 7.28810951e-02f, -3.20494920e-02f, -1.04665555e-01f, -3.74668352e-02f, -5.53910099e-02f,
  1.69870406e-01f, 1.87605008e-01f, 2.26230055e-01f, 1.09020077e-01f, 1.53890252e-01f, -3.35745424e-01f, -3.25071156e-01f, 1.13953076e-01f, 3.20481658e-01f, 2.08365992e-01f,
  -1.20755598e-01f, 1.82423871e-02f, 1.94617316e-01f, -7.30608180e-02f, -2.67640024e-01f, 3.18829529e-02f, -1.92654699e-01f, -3.43218027e-03f, -5.97397275e-02f, -3.89716178e-01f,
  2.25390702e-01f, -2.56751813e-02f, 6.93897605e-02f, 1.25785202e-01f, 9.53787938e-03f, -4.71587759e-03f, 3.02434973e-02f, -7.02916831e-02f, 5.64994663e-03f, -1.87742025e-01f,
  -1.77599285e-02f, 1.03185326e-01f, 7.37469345e-02f, -5.33812381e-02f, -3.71682793e-02f, -6.12958074e-02f, -1.02259435e-01f, 2.51201876e-02f, -2.16105096e-02f, -4.66457270e-02f,
  -1.26733899e-01f, 6.44963086e-02f, 1.14533797e-01f, -1.03577800e-01f, 1.25567699e-02f, 1.93430915e-01f, -3.87548096e-02f, -8.44205394e-02f, 1.49242943e-02f, -2.49358490e-01f,
  -1.74355730e-02f, 9.81535390e-02f, 2.81575248e-02f, 4.92565148e-02f, 4.65769134e-02f, 4.48064730e-02f, 6.72224015e-02f, 8.25961828e-02f, 5.94640970e-02f, -4.44529168e-02f,
  1.20809600e-01f, 4.75197658e-02f, -1.05065042e-02f, 5.19543588e-02f, -1.13127427e-02f, 2.22510993e-02f, 3.81327309e-02f, -2.11435482e-02f, -1.31776119e-02f, -8.54101628e-02f,
  2.03535631e-02f, 1.45314857e-01f, -7.46741472e-03f, 8.01108591e-03f, 2.39371555e-03f, 2.63576838e-03f, -1.06448075e-02f, -1.06531670e-02f, -2.93971263e-02f, 2.50243582e-02f,
  7.68350735e-02f, 2.03655839e-01f, -1.13127725e-02f, -3.36353108e-02f, 1.95103250e-02f, -9.24939066e-02f, -5.28357597e-03f, -4.15770635e-02f, 1.00064792e-01f, 1.71853453e-02f,
  9.58624780e-02f, 9.71318781e-02f, 9.51432157e-03f, -9.39425826e-02f, 8.62715319e-02f, 3.49951163e-02f, -4.96529834e-03f, 9.68020633e-02f, 6.92065805e-02f, -2.92332377e-02f,
  -1.30222484e-01f, 3.49095166e-02f, 1.00259937e-01f, 1.15707487e-01f, -1.48102371e-02f, 3.21686596e-01f, 5.78673705e-02f, 2.61673257e-02f, 3.22449535e-01f, -5.67326955e-02f,
  -1.44177809e-01f, 5.38918912e-01f, 8.56854692e-02f, -5.10277860e-02f, 3.26951206e-01f, 4.51871485e-01f, 5.34893632e-01f, -1.86692346e-02f, -1.02045365e-01f, 1.85058281e-01f,
  1.51671961e-01f, -6.64531589e-02f, -1.91757977e-01f, -8.80745277e-02f, 6.69132695e-02f, 3.68038714e-01f, 2.94123322e-01f, -1.18235454e-01f, -8.24948326e-02f, 1.76571906e-01f,
  9.24848616e-02f, -1.21633463e-01f, -2.17132255e-01f, -1.88019037e-01f, 3.53703350e-02f, -1.74690589e-01f, -2.78262096e-03f, -5.90775572e-02f, 6.49170354e-02f, -7.26680011e-02f,
  -1.78461894e-01f, -1.97629258e-02f, -7.97052234e-02f, 3.83584620e-03f, 4.06634994e-02f, -9.28995162e-02f, -7.03449845e-02f, -7.41215870e-02f, 1.21309282e-03f, -9.92296413e-02f,
  3.22630070e-02f, 4.51543182e-02f, -5.34552857e-02f, 4.42650309e-03f, -2.76815314e-02f, -3.60512286e-02f, -7.39119053e-02f, -1.49402320e-01f, -1.82577241e-02f, -4.69791442e-02f,
  1.26785636e-01f, 1.69970661e-01f, 1.25253722e-01f, 8.04809332e-02f, -1.60152297e-02f, 5.61600700e-02f, 4.89725219e-03f, -8.85709748e-02f, -4.76889610e-02f, -1.12715140e-02f,
  2.98479851e-02f, 1.05451532e-01f, 2.32280269e-02f, -3.76501121e-02f, -5.70003875e-02f, -8.87957439e-02f, -5.59569336e-02f, -2.17127558e-02f, -3.40914652e-02f, 2.19615754e-02f,
  -8.61081332e-02f, -7.28669092e-02f, -1.86455026e-01f, -2.25267019e-02f, -1.64064243e-02f, -2.82957442e-02f, -8.97339284e-02f, -1.06414907e-01f, -1.66925922e-01f, -9.41405818e-02f,
  -5.89092672e-02f, -1.43509030e-01f, -7.96116814e-02f, -5.89049459e-02f, 8.66261646e-02f, -6.52123466e-02f, -8.41558352e-02f, -8.08371007e-02f, -7.37786070e-02f, 4.84515317e-02f,
  -4.50680226e-01f, 6.43705800e-02f, -1.35563491e-02f, -1.71024892e-02f, 6.20488375e-02f, 4.33136709e-02f, -2.93161590e-02f, 2.05353163e-02f, 5.16916886e-02f, -7.55256116e-02f,
  -8.36248044e-03f, 3.44022550e-02f, -7.12849433e-03f, -7.07705170e-02f, 2.27325279e-02f, 5.20287780e-03f, 1.39878213e-01f, 6.24881685e-02f, -2.61620823e-02f, 4.70447764e-02f,
  -1.88578088e-02f, 1.22227222e-01f, 1.55104473e-01f, 4.84336764e-02f, 6.14238568e-02f, 1.23275936e-01f, 2.60528997e-02f, 5.70046678e-02f, 1.13059014e-01f, 1.78558528e-01f,
  6.25131965e-01f, -3.89035136e-01f, 6.35868132e-01f, 6.30231351e-02f, -1.17774993e-01f, 3.99786569e-02f, -3.55719447e-01f, -8.77825245e-02f, 7.60484114e-02f, 2.48267390e-02f,
  -3.82324941e-02f, -9.58995447e-02f, 6.61091655e-02f, -8.89325142e-02f, -3.21463346e-02f, -1.73076212e-01f, 8.81627649e-02f, 3.06438804e-01f, 2.18650565e-01f, -2.32587278e-01f,
  -4.41734403e-01f, -2.89820015e-01f, 2.00528294e-01f, 1.28113359e-01f, 2.36814301e-02f, -1.09433001e-02f, 3.18243235e-01f, 7.72614107e-02f, 6.16748817e-02f, 7.25075882e-03f,
  2.20349029e-01f, 2.78299212e-01f, 9.27967299e-03f, -8.23636260e-03f, 1.25264347e-01f, 7.04207644e-02f, -1.89314559e-02f, 2.03491971e-01f, 3.68804410e-02f, 7.18362406e-02f,
  6.33436739e-02f, 7.41005540e-02f, 1.32178262e-01f, -2.43996233e-02f, 5.53653985e-02f, 9.14152637e-02f, 9.15318578e-02f, 2.85514891e-01f, 1.70858592e-01f, 1.21452749e-01f,
  -2.46998668e-01f, 1.33279935e-01f, 2.85026848e-01f, 1.32045355e-02f, 1.60535246e-01f, 1.96181208e-01f, 1.27887636e-01f, 1.14745513e-01f, 2.45229274e-01f, -8.52863565e-02f,
  -1.42211258e-01f, 7.89379701e-02f, 5.10487109e-02f, 2.12432388e-02f, -3.56191434e-02f, 2.62811333e-02f, 5.00304028e-02f, -1.80345047e-02f, 1.84197351e-02f, -8.74145608e-03f,
  -9.10803210e-03f, -1.03806350e-02f, 2.85277460e-02f, 8.89603887e-03f, -2.33405456e-02f, 1.51251003e-01f, 3.42348628e-02f, -1.49783403e-01f, -1.90543626e-02f, 1.97334681e-02f,
  -5.23114577e-02f, 3.25292000e-03f, 2.26429142e-02f, -1.04967237e-01f, -2.50566308e-03f, 1.51599616e-01f, 1.35304919e-02f, 9.65824537e-03f, -5.04882671e-02f, -1.15359353e-03f,
  -2.33783394e-01f, 7.76169077e-02f, -4.64005992e-02f, 4.82107885e-02f, 8.13922957e-02f, 5.10334298e-02f, -6.04646187e-03f, -1.52028278e-02f, 6.53502941e-02f, -3.45069915e-02f,
  -1.21151740e-02f, -2.34505720e-03f, -5.31910621e-02f, -4.03881595e-02f, -6.86705038e-02f, 3.52965891e-02f, -9.52781662e-02f, -5.96203171e-02f, 3.25338393e-02f, 8.52305256e-03f,
  -7.81407431e-02f, -2.57802382e-02f, -1.30402207e-01f, -1.41388133e-01f, -1.53813427e-02f, -3.26313153e-02f, -1.59534857e-01f, -2.37161107e-02f, 3.26494612e-02f, -4.66950089e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.14544046e+00f, 8.44024539e-01f, 8.83633196e-01f, -1.50299057e-01f, -1.99199617e-01f, -2.47538015e-01f, -3.99480276e-02f, -2.65848249e-01f, -4.58441377e-01f, -1.28231138e-01f,
  -1.79353267e-01f, -8.38339984e-01f, -4.84030247e-01f, -4.92302150e-01f, -5.65613201e-03f, -1.25570387e-01f, 1.09150715e-01f, 5.67579687e-01f, -9.31967348e-02f, -5.35980284e-01f,
  -6.09053254e-01f, 5.53700864e-01f, 8.07570159e-01f, 2.71044523e-01f, -1.02316789e-01f, -5.19446611e-01f, 6.35182321e-01f, 4.71649975e-01f, 2.37091452e-01f, 2.93482691e-01f,
  5.13776243e-01f, 5.70414841e-01f, -8.40894401e-01f, -2.17128038e-01f, 3.13367426e-01f, -5.26340604e-02f, -4.94723171e-02f, 3.24448675e-01f, 5.37691824e-02f, 6.32721335e-02f,
  1.82562731e-02f, 2.71792281e-02f, 7.74504319e-02f, 1.27174351e-02f, 4.78244275e-02f, -2.72773117e-01f, 3.61707926e-01f, 2.76679873e-01f, 2.89194789e-02f, -2.04794370e-02f,
  -3.71807575e-01f, 2.58468330e-01f, 4.63529378e-01f, -2.15746000e-01f, 1.73665211e-02f, -1.76821768e-01f, 1.18223175e-01f, -4.10029516e-02f, 2.85075754e-01f, 5.43190725e-02f,
  -4.11832213e-01f, 1.61153853e-01f, 1.72476411e-01f, 6.09718375e-02f, -1.10598609e-01f, -1.47440629e-02f, 1.27835153e-02f, -1.73381522e-01f, -4.85451929e-02f, 2.69040495e-01f,
  -1.26802087e-01f, -1.53460905e-01f, -9.26507935e-02f, -4.77775000e-03f, -2.26465881e-01f, 2.22144172e-01f, -8.79151002e-02f, 1.87002704e-01f, 1.97184876e-01f, -1.04560540e-03f,
  -9.51206163e-02f, -4.25190702e-02f, 1.42363623e-01f, 9.66043584e-03f, -1.58909217e-01f, -1.08423466e-02f, -2.24764973e-01f, -2.30877236e-01f, -3.04157007e-02f, 7.51242563e-02f,
  -3.88636947e-01f, -6.18148185e-02f, -3.85133386e-01f, 1.40655655e-02f, 3.30938399e-01f, 1.95344925e-01f, 3.75016741e-02f, 1.70402676e-01f, 2.72383720e-01f, 1.71482891e-01f,
  5.74796386e-02f, 5.92898391e-02f, 2.75834769e-01f, 1.06941685e-02f, -3.83415908e-01f, -2.27691323e-01f, 7.54878893e-02f, -1.58168375e-01f, -2.39040479e-01f, 1.88535422e-01f,
  -1.58363469e-02f, -3.90190095e-01f, -7.41386533e-01f, -4.61012125e-01f, -6.14911318e-01f, -9.43261504e-01f, -4.01266068e-01f, -5.02632320e-01f, -3.14496011e-01f, -2.63033301e-01f,
  1.79823244e+00f, 1.74044013e-01f, 2.68166751e-01f, 2.89457649e-01f, -6.62832737e-01f, -3.39117736e-01f, -3.30573291e-01f, -1.27225608e-01f, 2.17077568e-01f, 3.99219960e-01f,
  1.23210989e-01f, 1.96093068e-01f, 1.55109644e-01f, 1.21650957e-01f, 1.43845737e-01f, -6.05175905e-02f, -1.78768650e-01f, 2.52804250e-01f, 3.46479297e-01f, 3.72032344e-01f,
  4.29480663e-03f, 7.83185139e-02f, 3.25100601e-01f, 6.88482523e-02f, 1.62976980e-02f, 1.76479593e-01f, -4.54717539e-02f, -8.23365748e-02f, 1.82497166e-02f, 4.13717538e-01f,
  7.92445958e-01f, 5.49479961e-01f, -1.91176876e-01f, -1.77923188e-01f, -1.26300514e-01f, -4.33266349e-02f, 4.80186520e-03f, -1.45353377e-02f, -2.04148456e-01f, -8.28429610e-02f,
  -1.90223843e-01f, -5.66212423e-02f, -7.54717812e-02f, -7.18872622e-02f, -1.87853709e-01f, -2.82905009e-02f, -3.56394760e-02f, 2.15533555e-01f, -2.55861189e-02f, 5.47961891e-03f,
  -1.32042468e-01f, -8.86238292e-02f, -2.02169478e-01f, -2.73093373e-01f, 1.01142973e-01f, 1.52549557e-02f, -9.44118295e-03f, 1.73515394e-01f, 6.23113289e-02f, 3.54480952e-01f,
  2.04189092e-01f, 1.57084256e-01f, 2.58264840e-01f, 1.79207742e-01f, 3.11321408e-01f, 6.33496568e-02f, -1.71304699e-02f, -5.99451624e-02f, 5.08766621e-02f, -5.45446351e-02f,
  9.87684354e-02f, 2.32609972e-01f, 4.33694152e-03f, -1.73387546e-02f, 6.18225969e-02f, -1.50251329e-01f, -1.95480019e-01f, -1.19819082e-01f, -8.54185224e-02f, -2.63989866e-01f,
  1.29567534e-01f, -7.89582208e-02f, -8.24853480e-02f, -3.40810046e-02f, -6.97242245e-02f, 1.67662308e-01f, 2.71133900e-01f, 2.77291164e-02f, 1.95565224e-02f, 2.43334975e-02f,
  -8.52989316e-01f, -3.26320499e-01f, 5.70195436e-01f, 5.66855744e-02f, -7.00940117e-02f, -1.17342748e-01f, 8.95880908e-02f, -1.37899578e-01f, -3.39763463e-01f, 3.68472822e-02f,
  -8.91353488e-02f, 1.54635549e-01f, 3.76013406e-02f, -6.10608561e-03f, 1.93788894e-02f, -6.45115823e-02f, -5.56820370e-02f, -5.19671887e-02f, -2.25400448e-01f, -9.49994624e-02f,
  -2.17402503e-01f, -1.92179173e-01f, -2.32783891e-02f, -2.40921900e-01f, -1.48636714e-01f, -1.29695252e-01f, -4.40486521e-02f, -7.10005239e-02f, -9.52703804e-02f, 1.59304291e-01f,
  1.95604539e+00f, -1.38198286e-01f, -1.86580765e+00f, 8.01869214e-01f, -3.98024708e-01f, -7.13237405e-01f, -4.41579640e-01f, 3.08374763e-01f, 6.89574122e-01f, -2.46740758e-01f,
  -4.35849756e-01f, 7.58888945e-02f, -3.93326372e-01f, -3.45898688e-01f, -1.18685201e-01f, -8.11334312e-01f, -9.41421568e-01f, -7.35368907e-01f, -2.09874645e-01f, 3.13771248e-01f,
  2.95465440e-01f, 7.93348908e-01f, 8.48355114e-01f, 1.30431414e-01f, -1.26192182e-01f, -2.09256727e-02f, -6.40333116e-01f, -1.60009280e-01f, -5.78784704e-01f, -7.73604631e-01f,
  -8.69318128e-01f, -5.42874157e-01f, -3.04307997e-01f, 1.83400407e-01f, -8.86949971e-02f, 3.66148233e-01f, 1.23642586e-01f, -2.55595539e-02f, 3.49887520e-01f, 6.63159043e-02f,
  -2.01691866e-01f, 8.78161341e-02f, -1.26874834e-01f, -1.03659280e-01f, 2.53093451e-01f, 3.47236358e-02f, -8.56653322e-03f, -6.37130812e-03f, -2.91607112e-01f, -4.79290694e-01f,
  -2.07709014e-01f, -4.28422719e-01f, -4.17118937e-01f, -2.80410409e-01f, -3.38204145e-01f, -1.42802343e-01f, -3.45330775e-01f, -2.65676707e-01f, -3.58209044e-01f, 7.17204139e-02f,
  5.45568392e-02f, 1.14937434e-02f, 3.08579821e-02f, 7.59606436e-02f, 3.98215771e-01f, 1.91409774e-02f, -6.08825684e-02f, -2.75199041e-02f, 1.25300944e-01f, 3.53144556e-02f,
  -2.24643946e-02f, -1.85799718e-01f, 6.03491999e-02f, 8.49009827e-02f, -4.71237488e-02f, -2.45597064e-01f, -8.27693716e-02f, 8.91651809e-02f, -9.51977223e-02f, 1.94262952e-01f,
  1.04398839e-02f, -1.11292154e-01f, 8.42467770e-02f, 4.84762304e-02f, -3.28144491e-01f, -3.32941055e-01f, -1.96349263e-01f, -2.37493287e-03f, 2.10035145e-01f, 5.13566770e-02f,
  7.93739736e-01f, -2.73865938e-01f, 8.33417028e-02f, -5.77320978e-02f, -2.86671191e-01f, 7.12148622e-02f, -1.54957138e-02f, 1.45080417e-01f, 5.03794849e-02f, 2.41450481e-02f,
  -2.26293012e-01f, 1.80857643e-01f, -4.67922911e-02f, 9.18348134e-02f, 1.87613979e-01f, -2.87144277e-02f, 2.63344914e-01f, -2.36700743e-01f, -9.40276086e-02f, -9.63667966e-03f,
  1.97816595e-01f, 2.54765034e-01f, 5.24299800e-01f, 8.83675218e-02f, 2.75243163e-01f, 2.13269651e-01f, -4.19709906e-02f, 2.95124389e-02f, -1.38229921e-01f, 1.02201450e+00f,
  4.90791857e-01f, -4.01675522e-01f, 7.11102724e-01f, 6.08668685e-01f, 5.51404536e-01f, 7.18601346e-01f, 8.62109661e-01f, 5.28857529e-01f, 1.92747653e-01f, 1.40449375e-01f,
  -5.44000208e-01f, -5.78415692e-01f, -3.32245290e-01f, -4.20164764e-01f, 9.82371569e-02f, 4.94348645e-01f, 6.44095778e-01f, 4.12319601e-01f, 2.98603654e-01f, 1.71431348e-01f,
  -5.73014989e-02f, 1.85290098e-01f, -1.30862936e-01f, 1.31824419e-01f, 1.72012687e-01f, 1.13788821e-01f, 1.30467296e-01f, 2.66938936e-02f, -4.12451737e-02f, 7.75437802e-02f,
  -4.39104438e-01f, -6.30355775e-02f, 9.55575630e-02f, -4.12523299e-01f, -4.45360392e-01f, -1.50553897e-01f, 7.90632963e-02f, -1.43064156e-01f, -9.92223993e-02f, 1.62183821e-01f,
  -2.53380954e-01f, -1.75684631e-01f, -1.17066041e-01f, -2.03651145e-01f, 2.00211167e-01f, -4.22771052e-02f, -2.34932721e-01f, 1.23576872e-01f, -1.07055806e-01f, -3.17450196e-01f,
  -3.44562203e-01f, -1.64322868e-01f, 2.13379666e-01f, 1.69757262e-01f, 5.17559573e-02f, -1.62881866e-01f, -9.54081491e-02f, -1.36248767e-01f, 1.27399964e-02f, -8.64220783e-02f,
  9.39610898e-02f, 6.51983265e-03f, 1.86373983e-02f, 5.16540511e-03f, 3.00536789e-02f, 3.16893570e-02f, 2.17343688e-01f, 2.33581290e-02f, 1.11754701e-01f, 2.92214870e-01f,
  -1.04030803e-01f, 4.04526331e-02f, 2.33269691e-01f, 9.31148231e-02f, -1.47824645e-01f, 2.75566764e-02f, 8.02255943e-02f, -2.48037830e-01f, -5.40631935e-02f, 8.85166377e-02f,
  9.41961259e-02f, 1.21164560e-01f, -3.56714800e-02f, 1.50576517e-01f, -8.12710971e-02f, 1.05814956e-01f, 1.42719541e-02f, -2.23923162e-01f, -4.83287200e-02f, 9.25836861e-02f,
  1.95078164e-01f, -1.16646819e-01f, 8.24560970e-02f, 6.26617372e-02f, 8.91053528e-02f, -2.53107607e-01f, -3.53293568e-02f, -1.97569624e-01f, -7.86818638e-02f, 6.78139925e-02f,
  -1.59439772e-01f, -9.93773192e-02f, 6.02469500e-03f, 8.90761539e-02f, 3.23439717e-01f, 1.26845255e-01f, -2.90257543e-01f, 8.77121314e-02f, -1.24546178e-01f, -1.90138966e-01f,
  -2.24963427e-01f, 1.27622411e-01f, 1.58373222e-01f, 2.41589576e-01f, -5.90159297e-02f, 1.14643954e-01f, 4.84690592e-02f, 6.30117059e-02f, 1.28449127e-01f, 1.61707938e-01f,
  -9.35592115e-01f, 6.09699726e-01f, 2.11062521e-01f, 3.03583546e-03f, 9.02706832e-02f, -7.01625645e-01f, -4.26468700e-01f, -8.05015981e-01f, 4.60638152e-03f, 6.29616559e-01f,
  4.21486825e-01f, 2.12581947e-01f, 5.96207619e-01f, -1.20491415e-01f, -9.38613832e-01f, 7.69334063e-02f, 7.29449093e-02f, -5.52249610e-01f, -1.21123147e+00f, -9.14052188e-01f,
  2.53792033e-02f, -1.20975055e-01f, -5.10586977e-01f, -3.32578868e-01f, 6.87212765e-01f, 4.73269522e-01f, 8.46990764e-01f, 1.78111941e-01f, -1.07898638e-01f, 7.01348603e-01f,
  6.42818034e-01f, -5.40771425e-01f, -3.62295926e-01f, -1.22112311e-01f, 3.83406848e-01f, -8.93255249e-02f, -3.11935216e-01f, 5.16895913e-02f, -4.40038219e-02f, 4.26388979e-02f,
  5.43665253e-02f, -2.06654340e-01f, -1.03062361e-01f, 5.00921868e-02f, -6.35847226e-02f, -2.99810022e-01f, 1.00415023e-02f, -5.41918457e-01f, -7.64791295e-02f, 1.58721253e-01f,
  3.25080484e-01f, -1.59219056e-01f, -5.16143963e-02f, -2.21050903e-01f, -5.38312018e-01f, -1.03588058e-02f, -8.90918374e-02f, -5.91457963e-01f, -4.94781971e-01f, 5.05919158e-01f,
  3.23074199e-02f, 1.92140341e-01f, -8.97211209e-02f, -6.74151722e-03f, 6.67026043e-02f, 1.39180794e-01f, 2.45689929e-01f, 8.90646204e-02f, -3.79926898e-02f, 1.26477003e-01f,
  -8.87613297e-02f, 1.38475925e-01f, 2.74565946e-02f, 7.95437768e-02f, 2.77337115e-02f, 2.42339354e-02f, -1.09479772e-02f, 4.16056849e-02f, -1.30421713e-01f, -7.41619840e-02f,
  -5.79061247e-02f, -6.61032051e-02f, 2.82725245e-01f, 8.19719881e-02f, -1.67297542e-01f, -2.06452664e-02f, -1.06131688e-01f, -3.73405963e-02f, -7.52907172e-02f, 7.95396045e-02f,
  7.02891767e-01f, -6.82170093e-01f, 5.71751654e-01f, -2.04041183e-01f, 4.17117663e-02f, 1.68190539e-01f, 1.51686907e-01f, 1.06470548e-02f, 1.70608014e-01f, 8.88651088e-02f,
  -3.95162195e-01f, -1.05007216e-02f, 1.79610983e-01f, 7.02205077e-02f, -1.66283295e-01f, -5.41377664e-02f, -1.97480619e-02f, 2.65010387e-01f, -1.39612928e-01f, 9.80735049e-02f,
  4.00213264e-02f, -2.38360822e-01f, 9.06610414e-02f, 3.70383203e-01f, 9.80899781e-02f, -6.52154014e-02f, 4.69895840e-01f, 3.07973921e-01f, -2.16387004e-01f, 8.62395287e-01f,
  -3.86736870e-01f, -9.07995880e-01f, -2.42900744e-01f, -4.61555302e-01f, -1.08539975e+00f, -6.72226250e-01f, -1.19947815e+00f, -2.26646796e-01f, -5.69009222e-02f, -9.36519623e-01f,
  -1.22655496e-01f, 9.93634820e-01f, 1.15061843e+00f, 5.17902255e-01f, 3.97401482e-01f, -9.70133841e-01f, -7.98436821e-01f, 1.63611606e-01f, 1.71001419e-01f, -8.66478920e-01f,
  -1.21668184e+00f, -8.71407390e-01f, -2.22594649e-01f, -1.29617214e-01f, -5.17556369e-01f, 2.93897659e-01f, -7.51271704e-03f, -3.78069937e-01f, -3.28833520e-01f, -6.48132622e-01f,
  -1.13487676e-01f, -2.07050771e-01f, 2.63813525e-01f, -2.26833945e-05f, -1.24296909e-02f, 1.87575430e-01f, 2.18210146e-02f, 1.22800805e-01f, 4.26207902e-03f, -1.29138827e-01f,
  6.41462356e-02f, -2.00929582e-01f, 2.38531187e-01f, 1.73436806e-01f, 2.38467799e-03f, 5.93473297e-03f, -4.65000309e-02f, -1.91366717e-01f, 1.32588372e-01f, -3.16324741e-01f,
  -5.56886315e-01f, -4.84762907e-01f, 2.82776892e-01f, 2.78378725e-01f, 1.99957892e-01f, 2.79084563e-01f, -1.30638918e-02f, 8.69670063e-02f, 3.53320360e-01f, -1.94461733e-01f,
  -6.55746683e-02f, 1.95759505e-01f, -9.51961651e-02f, -3.25158350e-02f, -4.15112935e-02f, 1.17105804e-01f, 1.46701008e-01f, -4.26728167e-02f, 3.44560593e-02f, 2.55427994e-02f,
  4.09059376e-02f, -2.20455796e-01f, 8.78703371e-02f, -8.89943540e-02f, -1.03020832e-01f, -2.22057611e-01f, -3.38070020e-02f, -8.61282051e-02f, -9.57670882e-02f, -1.11524120e-01f,
  -1.02011383e-01f, -2.28791222e-01f, 1.13869563e-01f, 6.73409626e-02f, -2.80257374e-01f, 1.63068343e-02f, 6.72233477e-02f, 8.44632089e-02f, 1.57343313e-01f, -3.46987396e-01f,
  5.85426271e-01f, 3.14760298e-01f, -7.96707273e-02f, -1.32140070e-02f, -2.67686337e-01f, -3.02784145e-02f, 6.49761558e-02f, 6.01071119e-02f, 1.52017668e-01f, -1.04577160e-02f,
  -1.74516544e-01f, 2.12229639e-01f, 1.61436945e-01f, -9.45490226e-02f, -2.16595661e-02f, 6.59738779e-02f, -1.03928834e-01f, -1.84881046e-01f, -2.00281650e-01f, -3.04152817e-01f,
  -1.92403942e-01f, -2.49560609e-01f, 2.42190987e-01f, 1.73271343e-01f, -3.77264805e-02f, 2.29481637e-01f, 5.75816035e-02f, -2.19007894e-01f, 4.73828077e-01f, -5.55694997e-01f,
  -5.81310809e-01f, 1.22890425e+00f, -3.54978353e-01f, -4.19152111e-01f, 7.17343032e-01f, 7.38944232e-01f, 7.62200832e-01f, 2.81086326e-01f, -4.33402173e-02f, 5.09891868e-01f,
  1.22728276e+00f, -2.50829101e-01f, -9.28939283e-01f, -7.16149807e-01f, -9.10781384e-01f, -1.86123163e-01f, -7.40989804e-01f, -1.49417078e+00f, -1.38221407e+00f, -3.71509306e-02f,
  1.23412430e-01f, -7.36426592e-01f, -1.00833273e+00f, -7.19938695e-01f, -1.30619898e-01f, -8.95489812e-01f, -2.55780816e-01f, -4.62029636e-01f, -5.68294860e-02f, -4.53681439e-01f,
  -4.05525744e-01f, 5.39567828e-01f, -1.76939473e-01f, -1.97500810e-02f, 4.39231753e-01f, 1.59281231e-02f, 2.26403344e-02f, 1.57822862e-01f, 1.25040457e-01f, -2.29030430e-01f,
  4.04757150e-02f, 8.31233263e-02f, 4.83444966e-02f, 6.44027889e-02f, -6.19417289e-03f, -5.64553179e-02f, 5.74257523e-02f, -5.14011741e-01f, -5.48556089e-01f, 1.72501490e-01f,
  4.97356623e-01f, 2.13588223e-01f, -2.68639743e-01f, 6.36247098e-02f, -8.99857562e-03f, -1.41231179e-01f, 4.80420262e-01f, -3.17303725e-02f, -2.16289952e-01f, -4.90666687e-01f,
  3.64519246e-02f, -3.95674482e-02f, 4.03856486e-01f, 2.27413818e-01f, -5.41232601e-02f, 2.27136686e-01f, -1.03750624e-01f, -1.58180907e-01f, -2.06127316e-01f, 8.24428350e-02f,
  1.56743631e-01f, 9.44039226e-02f, -5.90273831e-03f, -3.90336961e-02f, -3.02214473e-01f, 9.30758417e-02f, -7.69873112e-02f, -1.06598392e-01f, -9.40731764e-02f, -1.76855305e-03f,
  -9.96626541e-02f, -8.78638122e-03f, 3.49495150e-02f, -2.48410121e-01f, 2.29949653e-01f, 3.30768488e-02f, 1.58030435e-01f, 2.24647924e-01f, 7.44480290e-04f, 1.86190575e-01f,
  -1.04751909e+00f, 2.88638741e-01f, -5.22331178e-01f, -9.43117812e-02f, 8.32109824e-02f, 9.11008343e-02f, 9.93683264e-02f, 2.47952580e-01f, 7.73954317e-02f, 4.21752520e-02f,
  3.37239385e-01f, -4.00979854e-02f, 2.41450921e-01f, 6.71801940e-02f, -4.55141626e-02f, -4.18004952e-02f, 2.18225300e-01f, -2.45886818e-01f, -1.23619452e-01f, 2.57833123e-01f,
  -2.17874013e-02f, -5.39746940e-01f, -9.99470770e-01f, -6.03184700e-01f, -2.24809930e-01f, -7.42856085e-01f, -7.24740684e-01f, -5.61493754e-01f, -5.32429338e-01f, -9.84663725e-01f,
  -1.15500200e+00f, -1.08911443e+00f, -3.42368484e-01f, 2.77674317e-01f, 2.88045764e-01f, -5.70068717e-01f, -1.50143361e+00f, -7.59567797e-01f, -1.16579197e-01f, -8.78726721e-01f,
  -1.95027232e-01f, 5.47558188e-01f, -8.58971328e-02f, 3.09910119e-01f, -1.58610761e-01f, -6.94713950e-01f, 6.87836483e-03f, 4.05442834e-01f, 7.70255685e-01f, 7.06479132e-01f,
  6.19651735e-01f, 4.86752331e-01f, 4.86728549e-01f, 3.98718685e-01f, 9.68573391e-02f, 1.37453690e-01f, -2.82496870e-01f, 3.05388629e-01f, 2.16604054e-01f, 5.99371612e-01f,
  -1.94971129e-01f, -5.46926081e-01f, 2.59213358e-01f, 5.65131783e-01f, 5.47353566e-01f, -3.79292518e-01f, -2.87755489e-01f, 3.06290686e-01f, 4.42167977e-03f, -2.10303098e-01f,
  2.67614365e-01f, 4.82104421e-02f, 2.37484977e-01f, 2.57674515e-01f, 1.41212940e-01f, -2.62502134e-01f, -1.45624742e-01f, -1.70157507e-01f, -4.75094736e-01f, -3.25731605e-01f,
  5.89444399e-01f, 4.70827609e-01f, -4.31684375e-01f, -3.14714700e-01f, -4.67330933e-01f, 3.39806318e-01f, -2.13650569e-01f, 9.94260088e-02f, -7.61780560e-01f, -5.26248872e-01f,
  -9.38598067e-03f, 3.86823192e-02f, 2.31725201e-01f, -1.93457425e-01f, 1.94239259e-01f, 1.86262682e-01f, 2.30405390e-01f, 1.41095102e-01f, 1.85376644e-01f, -1.06096774e-01f,
  2.27431312e-01f, -3.41199696e-01f, -5.97596504e-02f, -2.98518956e-01f, 4.42453735e-02f, -1.42318830e-01f, 1.55138761e-01f, -1.52008444e-01f, 1.67708591e-01f, -1.10990569e-01f,
  7.80847967e-02f, 1.55658834e-02f, -2.55775414e-02f, 1.43155470e-01f, -2.17128843e-01f, 7.00333416e-02f, -1.34494036e-01f, 6.68779686e-02f, -2.03299180e-01f, -3.92063320e-01f,
  -5.64778209e-01f, 1.72157168e-01f, -4.06804830e-01f, -1.74123805e-03f, 2.24800147e-02f, 1.56023443e-01f, 8.99399742e-02f, 1.87760785e-01f, -6.49332767e-03f, -2.19691724e-01f,
  -2.03199118e-01f, -1.51593521e-01f, -2.49785110e-01f, 5.83892204e-02f, 1.20127909e-01f, -2.98191994e-01f, -2.02957466e-01f, 2.36656703e-02f, -1.96310759e-01f, -1.44907370e-01f,
  -2.00492561e-01f, -2.53747791e-01f, -7.85078168e-01f, -6.73870504e-01f, -3.74053895e-01f, -6.28872931e-01f, -5.08620381e-01f, -5.36102831e-01f, -9.67667997e-01f, -1.59524298e+00f,
  -2.14535639e-01f, 5.03918350e-01f, -3.42808217e-01f, 4.51684415e-01f, 6.37985229e-01f, 4.49935704e-01f, 3.81432444e-01f, 1.49783515e-03f, 1.29979804e-01f, 2.85403103e-01f,
  4.63705420e-01f, 3.89936864e-01f, 2.18102530e-01f, 8.99429396e-02f, 1.16321705e-02f, 1.29410997e-01f, 2.65905648e-01f, -2.18945622e-01f, -4.11464840e-01f, 1.45786807e-01f,
  5.09105861e-01f, 2.18035594e-01f, -1.33999646e-01f, -2.45305337e-02f, 4.85268950e-01f, 3.87129843e-01f, 3.33079845e-01f, 4.84975874e-01f, 4.22168374e-01f, 4.52099800e-01f,
  1.52065843e-01f, 3.92977327e-01f, -3.62338185e-01f, 1.42112300e-01f, 2.16452964e-02f, -5.35416007e-01f, -2.27992028e-01f, -3.40438634e-01f, -9.33578610e-03f, -4.25460674e-02f,
  1.03938073e-01f, -1.79508239e-01f, 1.26728341e-01f, -1.91549852e-01f, 6.37485459e-02f, -1.75710320e-01f, -1.80170074e-01f, -7.09121600e-02f, -1.36977375e-01f, -4.78794686e-02f,
  2.29874805e-01f, 3.21810126e-01f, 1.41716823e-01f, -1.22718103e-01f, -5.24906022e-03f, 9.77988467e-02f, -9.03324410e-03f, 1.63397510e-02f, -1.76451683e-01f, -1.83338761e-01f,
  4.03783051e-03f, -2.13003680e-02f, 7.12707266e-02f, -2.67849490e-02f, 1.04474999e-01f, -8.12236872e-03f, -3.18640098e-02f, 2.07545981e-01f, 8.63393117e-03f, -1.47538006e-01f,
  -5.79502098e-02f, -9.00222957e-02f, -2.68425792e-01f, -3.39104384e-02f, -5.65397702e-02f, -9.13971961e-02f, -1.36321023e-01f, -1.04274340e-01f, 2.54982468e-02f, -8.29308033e-02f,
  -2.84025841e-03f, -1.70280159e-01f, -2.27339894e-01f, -1.29927382e-01f, -7.32185990e-02f, -6.21260926e-02f, -4.16564792e-02f, 5.36582842e-02f, 1.17677078e-01f, 2.23129675e-01f,
  -9.23792273e-02f, -8.52214918e-02f, -9.74803567e-02f, -2.22616166e-01f, 1.55488476e-01f, -1.95654556e-01f, 1.11236207e-01f, -1.38340622e-01f, 1.91791788e-01f, 3.47794667e-02f,
  4.04939428e-02f, -1.92866862e-01f, 8.98207203e-02f, -1.26936808e-01f, -1.90179154e-01f, -1.73109591e-01f, 1.67922392e-01f, 5.13296621e-03f, 4.89875535e-03f, -5.98477572e-02f,
  -1.07431896e-01f, -2.05704570e-01f, -1.18188076e-01f, -1.88282773e-01f, 2.70361155e-02f, 2.54280251e-02f, -2.92729795e-01f, -1.14246197e-01f, -2.32575029e-01f, -4.73452002e-01f,
  -9.07626092e-01f, -4.64225829e-01f, 6.09410107e-01f, -1.44358385e+00f, -3.12511325e-01f, 5.83802879e-01f, 8.51910233e-01f, -2.69965798e-01f, -6.97195113e-01f, 2.53386851e-02f,
  -3.25484693e-01f, -6.32050872e-01f, -6.32067680e-01f, -1.50501758e-01f, 2.62491047e-01f, 5.35514176e-01f, 4.21167523e-01f, 3.57634872e-01f, 8.08705986e-01f, 5.14380097e-01f,
  1.49731219e-01f, -3.75550270e-01f, -2.75602102e-01f, -9.94600654e-02f, -5.49804926e-01f, -2.18073145e-01f, -2.87587315e-01f, -3.96284342e-01f, 1.36152610e-01f, -5.99147260e-01f,
  5.18689573e-01f, -8.88439238e-01f, 1.12593628e-01f, -2.06739888e-01f, -1.38339654e-01f, -4.40150909e-02f, 6.51296824e-02f, -2.65767962e-01f, 4.56264196e-03f, -3.49184275e-02f,
  -3.94822240e-01f, -1.32944271e-01f, -2.58358866e-01f, -7.79463351e-02f, -2.72226721e-01f, -3.77738327e-02f, -1.28407449e-01f, -1.80002406e-01f, -2.19519913e-01f, -5.74044697e-02f,
  -9.62594301e-02f, -2.46508373e-03f, 2.10344777e-01f, 1.95025504e-01f, -5.04391082e-03f, 1.02122813e-01f, -1.19021676e-01f, -2.07913578e-01f, 1.23605736e-01f, -1.81819364e-01f,
  2.35534906e-01f, -8.83340910e-02f, -2.36252397e-02f, 1.45647883e-01f, -6.98603392e-02f, 5.35263494e-02f, 2.42397636e-02f, 1.44409493e-01f, 1.13519713e-01f, -6.30500764e-02f,
  -1.55931665e-02f, 7.25042671e-02f, -1.06373698e-01f, 3.25334594e-02f, -1.55155182e-01f, -2.42112458e-01f, 7.22956881e-02f, -1.00242170e-02f, -2.10261047e-02f, -3.69495191e-02f,
  -9.64998752e-02f, -4.56661172e-02f, -5.28130867e-02f, 5.43644791e-03f, 8.32072720e-02f, -1.08177802e-02f, -1.85008720e-01f, 4.50600460e-02f, -2.36868605e-01f, -1.85883476e-03f,
  -2.28952795e-01f, 3.18661332e-01f, -2.12271690e-01f, -2.53669053e-01f, -1.12470128e-01f, -2.85816211e-02f, -1.68025061e-01f, 6.99065924e-02f, -1.69649228e-01f, 7.96443522e-02f,
  -8.25162977e-02f, -6.46106824e-02f, -4.28895019e-02f, 1.83519814e-02f, 2.12984651e-01f, 3.18584144e-02f, 2.21613143e-03f, -1.18725061e-01f, -3.41571085e-02f, -1.75075769e-01f,
  -5.45569248e-02f, 3.05791050e-01f, 3.99308801e-01f, 2.81120330e-01f, -3.43540683e-02f, 3.69095594e-01f, 3.78405929e-01f, 2.35751599e-01f, 5.40040076e-01f, 6.38833821e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  1.56828809e+00f, 5.22711039e-01f, 9.80869949e-01f, 1.27519631e+00f, 1.15045476e+00f, 7.72837400e-01f, 1.46024776e+00f, 8.66795301e-01f, 4.04511362e-01f, 1.34716535e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -3.12706262e-01f, -4.62644160e-01f, -3.66305262e-01f, 3.21181357e-01f, -2.10568905e-01f, -3.56726944e-01f, -1.87782967e+00f, -1.19097996e+00f, 5.04602373e-01f, -1.14832759e+00f,
  -1.57444620e+00f, 1.67809978e-01f, 1.70714483e-01f, 6.22992575e-01f, -9.73099887e-01f, -4.79124635e-01f, -1.04149759e+00f, 1.47034198e-01f, 4.32301491e-01f, 4.57230240e-01f,
  -3.89165372e-01f, 3.27248424e-01f, -1.70239842e+00f, 1.08557534e+00f, 4.90423441e-01f, -2.42584813e-02f, -1.39708197e+00f, 1.22808754e+00f, -1.87746322e+00f, -8.23912203e-01f,
  1.12841249e-01f, -5.51798403e-01f, 1.12944700e-01f, 1.08997062e-01f, -1.48729896e-02f, 2.27166817e-01f, -3.69562328e-01f, 5.05364060e-01f, 4.00592953e-01f, -9.08222556e-01f,
  -1.41101408e+00f, -5.01573622e-01f, -1.07044029e+00f, 2.71268994e-01f, -1.51360524e+00f, 1.21480501e+00f, -1.59789693e+00f, 3.15205604e-01f, -1.00163035e-02f, 8.44601914e-02f,
  1.77077964e-01f, -7.80129969e-01f, 7.19559550e-01f, -5.65535724e-01f, -9.40884531e-01f, -1.00300658e+00f, -2.16054487e+00f, -3.88100743e-01f, -4.52677995e-01f, -4.05736625e-01f,
  8.11404467e-01f, -2.43210401e-02f, -8.45215023e-01f, 1.20956123e+00f, -2.92409658e-01f, 1.28809601e-01f, 2.85919964e-01f, -6.28965676e-01f, -4.46400076e-01f, 7.58065104e-01f,
  -3.92645687e-01f, -2.94168025e-01f, -9.99318659e-01f, -6.29779994e-01f, 9.35285926e-01f, 5.78213155e-01f, 2.87008375e-01f, -2.45407626e-01f, 2.18270823e-01f, -1.29637516e+00f,
  7.01052785e-01f, 5.06259084e-01f, -3.04679841e-01f, 2.41034925e-01f, -1.04227908e-01f, -9.46150422e-01f, -9.71522331e-01f, -2.46262968e-01f, 1.21461344e+00f, 2.52656136e-02f,
  3.54651153e-01f, -5.39704740e-01f, -3.56346101e-01f, -9.59489763e-01f, 2.94346362e-01f, -4.39174473e-01f, -7.38690048e-02f, 5.77011108e-01f, -1.41396478e-01f, -7.08815694e-01f,
  -6.73675597e-01f, 3.55661005e-01f, 1.02543068e+00f, 7.30048418e-01f, -6.95755959e-01f, -4.68538851e-01f, -5.07279396e-01f, -1.26140213e+00f, -1.80037534e+00f, -2.25052774e-01f,
  -5.78450561e-01f, -1.19103003e+00f, -6.89237714e-01f, -4.54466283e-01f, -6.14746928e-01f, -4.50068146e-01f, 3.49812746e-01f, -4.66698706e-01f, -9.45689201e-01f, -1.22107756e+00f,
  -1.05785394e+00f, 4.03871626e-01f, 7.60831416e-01f, -1.15580142e+00f, 2.32305691e-01f, 4.95756298e-01f, 5.19711196e-01f, -3.84030551e-01f, -1.04137965e-01f, 2.88422734e-01f,
  3.91009599e-01f, 3.01875323e-01f, 1.61106214e-01f, 3.29734862e-01f, -5.40147722e-01f, -4.78926152e-01f, 1.28189951e-01f, 1.14121974e+00f, -1.01064169e+00f, -1.22812462e+00f,
  -1.19023156e+00f, -7.06030726e-01f, -7.05065370e-01f, 9.69414234e-01f, 4.88988549e-01f, -1.00983180e-01f, 3.18796128e-01f, 2.89380640e-01f, -1.63166702e-01f, -3.82111579e-01f,
  -2.12100908e-01f, 1.58866867e-01f, -3.24475437e-01f, -1.30855298e+00f, 1.05296969e+00f, -1.73338044e+00f, -5.47229387e-02f, 9.13059831e-01f, 2.10820526e-01f, -1.58824003e+00f,
  2.28453159e-01f, 3.99120837e-01f, -4.49875623e-01f, 2.00231090e-01f, -2.63542891e-01f, -6.28473282e-01f, -1.05794895e+00f, -6.83093011e-01f, -1.32363439e+00f, -5.08713186e-01f,
  1.10743117e+00f, 3.52432758e-01f, -1.26580679e+00f, -6.89509690e-01f, -7.55359232e-01f, 7.10429311e-01f, 6.01339698e-01f, -5.32821596e-01f, -1.19044676e-01f, 6.05482757e-01f,
  9.04871702e-01f, 5.63901484e-01f, 9.91250873e-01f, -5.35345793e-01f, -1.50101924e+00f, 1.15485238e-02f, -1.07278299e+00f, -6.05349600e-01f, 3.92095089e-01f, -1.47654605e+00f,
  8.71845782e-02f, -2.77208358e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.77561849e-01f, 5.79548776e-01f, 3.64573210e-01f, -1.03417611e+00f, 2.61210203e-01f, 7.70029873e-02f, -7.45764896e-02f, -2.90186763e-01f, -6.80771768e-01f, -4.19726610e-01f,
  -1.24980485e+00f, -4.96466547e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    