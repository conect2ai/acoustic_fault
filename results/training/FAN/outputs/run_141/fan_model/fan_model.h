/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.39771256e-02f, 1.91004902e-01f, 1.78902641e-01f, 7.43442178e-02f, -8.37867148e-03f, -1.97499052e-01f, -9.24157575e-02f, 6.81910478e-03f, 1.08552083e-01f, -1.26532272e-01f,
  -5.37671968e-02f, 2.11435556e-01f, 2.38620155e-02f, 1.20863141e-02f, 1.10404112e-03f, 1.00128457e-01f, -8.04710686e-02f, -5.39478771e-02f, 8.78686756e-02f, 1.40309297e-02f,
  9.24902931e-02f, -4.91443612e-02f, 8.94261748e-02f, -5.95534742e-02f, -7.47505762e-03f, -2.67320108e-02f, -7.81275854e-02f, 4.66631353e-02f, -8.49134549e-02f, -2.42764428e-02f,
  -1.18360147e-01f, 3.19665633e-02f, 1.44861778e-02f, 3.20191197e-02f, -1.17187016e-01f, -5.95881697e-03f, 6.03420660e-02f, 8.77739396e-03f, -8.33845809e-02f, -7.06980675e-02f,
  -4.26658131e-02f, -5.89489527e-02f, 1.94349512e-02f, -2.71596294e-02f, -9.98422038e-04f, -1.95827428e-02f, -6.30449457e-03f, 4.83429581e-02f, 5.54779582e-02f, -3.07218451e-02f,
  4.53256108e-02f, -5.66656291e-02f, -6.34819195e-02f, 1.13803698e-02f, 3.49304676e-02f, -5.12347370e-02f, 2.27568951e-02f, -5.01209833e-02f, 3.42932828e-02f, 2.19663093e-03f,
  6.68511316e-02f, 6.34201169e-02f, 4.29564118e-02f, 1.05027063e-02f, 4.06982824e-02f, 2.80471966e-02f, -1.46676670e-03f, -1.95173509e-02f, 2.09616069e-02f, 1.26883509e-02f,
  -1.00752683e-02f, 7.91925341e-02f, 7.31791109e-02f, -8.06383193e-02f, 5.79186417e-02f, -1.47087369e-02f, 2.30733771e-02f, -2.97040325e-02f, 5.87067418e-02f, 1.13325007e-02f,
  7.81002417e-02f, 4.14205603e-02f, -2.30743010e-02f, 9.33872070e-03f, -5.84346615e-02f, -9.47804283e-03f, -2.61949282e-02f, -8.21676254e-02f, 7.10809007e-02f, -6.06242642e-02f,
  -8.55353698e-02f, 1.24073448e-02f, 1.34935137e-02f, 1.86354388e-03f, -4.52030227e-02f, -6.03608303e-02f, 1.10989988e-01f, -1.03137635e-01f, -5.30774891e-02f, 6.37509301e-02f,
  -5.88125363e-03f, -6.92296624e-02f, 5.36694154e-02f, -6.09698109e-02f, 8.99275094e-02f, -4.18396220e-02f, -3.74747440e-02f, 1.98303834e-02f, -6.66410625e-02f, -2.15437245e-02f,
  -8.13086238e-03f, 2.26027723e-02f, -5.91683872e-02f, -6.39104322e-02f, 6.11463003e-03f, -5.16792685e-02f, -2.75534373e-02f, -1.75919961e-02f, 1.60997994e-02f, -5.45936218e-03f,
  -1.36443943e-01f, -6.72295094e-02f, -2.49933064e-01f, 1.19717106e-01f, -8.05287622e-03f, 3.32986563e-02f, 9.45209991e-03f, -9.26556662e-02f, -1.04800642e-01f, 1.82853505e-01f,
  1.13907635e-01f, -9.45882499e-02f, -7.29628950e-02f, 1.67722896e-01f, -9.78772193e-02f, -1.92373786e-02f, 1.07690230e-01f, 2.42114775e-02f, -1.27568431e-02f, 2.24911571e-02f,
  1.68078486e-02f, 1.64914131e-01f, -2.89517753e-02f, 1.01411320e-01f, 8.36849660e-02f, -5.32346368e-02f, 7.87429959e-02f, -3.24981473e-02f, 1.47962600e-01f, 8.07607174e-03f,
  6.13106228e-02f, -5.38142920e-02f, -5.35770170e-02f, -4.98420894e-02f, -4.16234843e-02f, 6.15395345e-02f, 1.24080312e-02f, 1.56917591e-02f, 1.47377234e-02f, -2.02622209e-02f,
  -1.57183514e-03f, -9.14837494e-02f, -4.73647797e-03f, -1.05165936e-01f, 1.10096205e-02f, 3.94915007e-02f, -1.82896052e-02f, -6.39874563e-02f, -8.01530480e-03f, -1.63551066e-02f,
  2.35834885e-02f, 5.80372550e-02f, 3.46125923e-02f, -4.04925123e-02f, -7.73666799e-02f, 5.89392558e-02f, -1.13272518e-02f, -3.34932208e-02f, 2.56493017e-02f, -1.73523854e-02f,
  -3.31573710e-02f, -1.23823313e-02f, 4.66596745e-02f, -6.11649454e-03f, -1.96845010e-02f, -3.11319828e-02f, 2.51229741e-02f, -2.21334770e-02f, 8.90013389e-03f, 5.95996492e-02f,
  -1.62275368e-03f, -4.20701951e-02f, -4.89643263e-03f, 3.35509181e-02f, 2.77998243e-02f, -2.51369234e-02f, 2.83184927e-02f, 3.31005268e-02f, 5.56744710e-02f, -6.42852671e-03f,
  -6.02371758e-03f, -3.65993418e-02f, 1.43978344e-02f, 6.91310242e-02f, 7.02692717e-02f, -1.86407811e-03f, -3.24283987e-02f, 7.30728060e-02f, 1.80524625e-02f, 2.59626377e-02f,
  1.95371807e-02f, 7.04011992e-02f, -3.38896774e-02f, 2.35442687e-02f, -8.61485153e-02f, 3.13659571e-02f, -2.05462761e-02f, -2.15497445e-02f, -2.10454836e-02f, -9.58214775e-02f,
  3.44334617e-02f, -3.03591378e-02f, 8.15134123e-03f, 7.89658204e-02f, -4.14447114e-02f, 4.31511849e-02f, 4.11412008e-02f, -9.70997941e-03f, 6.60189763e-02f, 5.01510315e-02f,
  1.26653062e-02f, 1.33532239e-02f, -6.89794049e-02f, 7.34158382e-02f, 5.45803048e-02f, -1.46995392e-02f, -3.90133113e-02f, 2.43388396e-02f, 6.88399523e-02f, 1.39210895e-02f,
  3.31424296e-01f, 3.14562730e-02f, -1.59132928e-02f, -5.48739405e-03f, -9.93509367e-02f, -9.51761156e-02f, -1.26178086e-01f, -4.31635641e-02f, 1.42314449e-01f, -8.68498161e-02f,
  -1.18160971e-01f, 8.42622966e-02f, 3.47483344e-02f, -1.21710047e-01f, 5.09347469e-02f, 9.21903402e-02f, -6.72045425e-02f, -5.39772660e-02f, 6.01659231e-02f, 3.35367918e-02f,
  2.84630153e-02f, -1.04567036e-01f, -4.22713682e-02f, -2.26815976e-02f, -4.60744016e-02f, 6.96808025e-02f, -5.57613969e-02f, 5.26786968e-02f, -1.11378476e-01f, -5.19283600e-02f,
  4.21350934e-02f, 2.05880433e-01f, 3.99248907e-03f, 4.10184115e-02f, -6.27532154e-02f, 2.27405000e-02f, -4.10881378e-02f, -9.92353447e-03f, 5.44175468e-02f, 3.42348800e-03f,
  -1.11678550e-02f, 4.96366136e-02f, -4.79846746e-02f, 3.98623571e-02f, 2.66575962e-02f, 2.35368386e-02f, -2.85336822e-02f, -8.23476091e-02f, -7.24269543e-03f, -7.20416056e-03f,
  -7.16340914e-02f, 3.69350687e-02f, -1.38372276e-02f, -8.49203113e-03f, -5.22153676e-02f, -2.55372766e-02f, 1.58211291e-02f, -4.80181463e-02f, 3.53594236e-02f, -9.16613862e-02f,
  -1.98835619e-02f, 3.16389725e-02f, -1.11101493e-02f, -1.84945818e-02f, 5.55821471e-02f, -3.67516428e-02f, 2.24744771e-02f, -2.10868698e-02f, 2.62582023e-02f, -3.38927545e-02f,
  -5.69041409e-02f, -3.15888822e-02f, -4.33695763e-02f, 9.07626282e-03f, 1.46616111e-02f, -5.12614138e-02f, 2.91996589e-03f, -6.99914768e-02f, -3.63902114e-02f, -3.24451551e-02f,
  3.39853242e-02f, -3.08780298e-02f, -1.00494102e-01f, 1.18929381e-02f, -3.30509841e-02f, 3.62942815e-02f, -7.42315128e-02f, 1.74976382e-02f, -7.83478096e-02f, 2.10720561e-02f,
  1.52835622e-01f, 1.33494601e-01f, -8.20032321e-03f, -6.23147674e-02f, 5.88742569e-02f, -2.91327364e-03f, -3.47539131e-03f, 2.20451020e-02f, 3.61496769e-02f, 6.17053418e-04f,
  -5.31166717e-02f, 1.06533784e-02f, 3.81276198e-02f, 5.65935532e-03f, -6.43582735e-03f, -9.19976383e-02f, -8.83280206e-03f, 1.24001820e-02f, -3.30996960e-02f, -6.59907386e-02f,
  -4.52439446e-04f, -4.49915929e-03f, 5.09613985e-03f, 6.96059735e-03f, -1.62383579e-02f, -6.83656707e-02f, 2.68149879e-02f, 6.87179938e-02f, -5.87682007e-03f, -5.71020618e-02f,
  8.89618173e-02f, -5.54474518e-02f, -1.77900061e-01f, 1.12106830e-01f, -3.44821215e-02f, 1.03490993e-01f, 1.85114809e-03f, 6.98677525e-02f, -7.62912184e-02f, 1.24893837e-01f,
  1.82573810e-01f, -1.85146168e-01f, -4.80842218e-02f, 1.32996887e-01f, 1.03812724e-01f, -8.71386528e-02f, 1.09191291e-01f, -7.32973218e-02f, -1.85972393e-01f, 8.27168673e-02f,
  -3.95940803e-02f, 1.13191374e-01f, 4.69972081e-02f, -4.48099663e-03f, -2.96765845e-03f, 3.01811527e-02f, 1.45201534e-01f, 2.45507360e-02f, 9.18655619e-02f, -4.23929803e-02f,
  -7.49004334e-02f, 1.47553552e-02f, -1.05783008e-02f, 3.96967009e-02f, -5.14759608e-02f, 6.34851754e-02f, 2.93729547e-02f, -8.45331252e-02f, -6.27002865e-02f, -3.75465266e-02f,
  4.53138426e-02f, 2.59250216e-03f, -3.36241759e-02f, 1.99881140e-02f, 3.91730294e-02f, -3.99427377e-02f, -3.07446755e-02f, -1.11352722e-03f, 3.94291990e-02f, 1.28772703e-03f,
  2.70284452e-02f, -2.44332701e-02f, 5.14417700e-02f, 1.47757754e-02f, 3.60296555e-02f, -3.32915410e-02f, -9.34621505e-03f, 1.12810582e-02f, -1.94239393e-02f, -8.49114731e-02f,
  3.70708928e-02f, -1.14963846e-02f, 4.59033437e-02f, -8.99807084e-03f, 1.36735048e-02f, 2.30314992e-02f, 1.97159611e-02f, -6.35988684e-03f, 7.24050775e-02f, 4.47910726e-02f,
  4.51597646e-02f, -3.59997182e-04f, 2.19447985e-02f, 7.14746863e-02f, 3.94634902e-02f, -4.24819347e-03f, 3.93584035e-02f, -4.64023165e-02f, -3.93442325e-02f, -2.18784586e-02f,
  1.15676150e-02f, 5.70158102e-03f, -6.18143342e-02f, 1.93697698e-02f, -4.67674993e-02f, 5.39149810e-03f, 5.78164794e-02f, -3.84265222e-02f, -7.40785524e-02f, 7.46279210e-02f,
  2.15617009e-03f, 1.32695004e-01f, -5.57336397e-02f, -9.09503642e-03f, 6.15697959e-03f, 1.97448004e-02f, -1.52902668e-02f, -4.55103591e-02f, -1.45797031e-02f, 4.97807562e-02f,
  -5.29018929e-03f, 5.99314980e-02f, 7.22566666e-03f, 5.33267744e-02f, 1.11825876e-02f, 1.43512117e-03f, 4.41068560e-02f, 2.78432760e-02f, -1.50180981e-02f, -1.03318524e-02f,
  -7.99241196e-03f, 8.16722866e-03f, 4.41100821e-02f, 9.35305953e-02f, 8.25544745e-02f, -1.81538109e-02f, 1.41155571e-02f, 2.43060980e-02f, 1.73765402e-02f, -1.17156636e-02f,
  -7.37930909e-02f, 7.39224628e-02f, 5.72520196e-02f, -1.58249345e-02f, -6.33127913e-02f, 2.94200063e-01f, 2.05096439e-01f, -1.13525562e-01f, -6.03594109e-02f, 7.64489248e-02f,
  2.54886318e-03f, 5.14785871e-02f, 1.03235863e-01f, 1.37130395e-01f, 1.69066906e-01f, 1.42912820e-01f, 1.30806103e-01f, 1.17546506e-01f, -1.06380638e-02f, 4.73142043e-02f,
  -4.82388511e-02f, 1.18804410e-01f, 1.30380481e-01f, 3.92683111e-02f, 1.61499679e-02f, -7.09993243e-02f, -1.29682600e-01f, 6.83850050e-02f, 1.44501803e-02f, 1.21542893e-01f,
  1.31395772e-01f, -2.16256082e-02f, 1.70082916e-02f, 2.50436850e-02f, 1.36080636e-02f, -3.12581435e-02f, 1.07064582e-02f, 1.14588244e-02f, -2.57995948e-02f, 2.46081203e-02f,
  -1.69194024e-02f, -4.45125112e-03f, 1.82839204e-03f, -1.98904872e-02f, 1.65283363e-02f, -6.57053068e-02f, -6.40271418e-03f, -1.05710570e-02f, 5.27469860e-03f, -1.76528189e-03f,
  4.89161871e-02f, 7.58239254e-03f, 9.54637583e-03f, -7.46368850e-03f, -3.71120572e-02f, 7.81834498e-03f, -3.70284356e-02f, 5.48955798e-02f, -2.48488206e-02f, -4.99417223e-02f,
  -8.20495002e-03f, 8.52484349e-03f, 5.30852154e-02f, -4.72972542e-03f, 8.24583024e-02f, 1.31775634e-02f, 8.10812637e-02f, -7.52837805e-04f, 5.65570444e-02f, -3.33684497e-02f,
  -9.55810323e-02f, -3.41981947e-02f, -5.52242249e-03f, -7.78314099e-02f, -4.56527546e-02f, -3.14936303e-02f, 2.97071245e-02f, 4.73977961e-02f, -7.59085938e-02f, -5.39370738e-02f,
  -9.95197520e-02f, -4.23623286e-02f, 5.23306280e-02f, 1.82095903e-03f, 4.70308065e-02f, 1.88771095e-02f, -1.17547743e-01f, 8.95437375e-02f, -4.23005559e-02f, 7.39885494e-03f,
  3.61149311e-02f, -8.25809389e-02f, -8.84835050e-03f, -8.70291367e-02f, 1.13650687e-01f, 4.91150804e-02f, 3.57070006e-02f, -2.23688725e-02f, -1.24620262e-03f, -3.99584584e-02f,
  -1.09642141e-01f, -5.84458224e-02f, 1.73833761e-02f, -3.07157300e-02f, 4.89407703e-02f, -3.47489379e-02f, -3.95793915e-02f, 8.40898827e-02f, -2.52037905e-02f, -3.28474604e-02f,
  -1.56933106e-02f, 4.05157208e-02f, -2.36223061e-02f, -7.09749982e-02f, -5.78168733e-03f, -7.45970057e-03f, -3.52024063e-02f, -5.09539060e-02f, 1.23831434e-02f, -3.21481563e-02f,
  -3.16217154e-01f, -2.01556519e-01f, -2.49459207e-01f, -2.27523595e-01f, 1.03629567e-02f, -2.28040829e-01f, -3.15084934e-01f, -1.09492190e-01f, -1.64463863e-01f, -9.05152932e-02f,
  -7.49643818e-02f, -1.82634965e-01f, 1.63860824e-02f, -9.60884541e-02f, -1.73356339e-01f, 4.02823091e-02f, -2.36125737e-02f, -1.77299848e-03f, 9.36325938e-02f, -1.06808878e-01f,
  1.85873695e-02f, 1.19404182e-01f, 1.48280151e-02f, 1.35298699e-01f, 5.01587940e-03f, 1.72489788e-02f, 1.14835665e-01f, 3.03448673e-04f, 3.43341269e-02f, -2.99565736e-02f,
  -1.46132767e-01f, -5.00885695e-02f, 2.80300919e-02f, -1.69764459e-02f, 3.04142386e-02f, -5.11015765e-03f, 1.28861172e-02f, 1.94930639e-02f, 4.88945991e-02f, 3.38174216e-02f,
  -2.28498764e-02f, 1.53221507e-02f, 4.73331921e-02f, -2.54994016e-02f, -5.51663935e-02f, -4.39646281e-02f, 2.96438616e-02f, 2.41369214e-02f, 6.72028633e-03f, 3.47239636e-02f,
  7.91178085e-03f, 4.04838510e-02f, 3.38356569e-02f, 4.87145560e-04f, 4.44993675e-02f, -1.24999927e-02f, 4.80884649e-02f, 2.07166392e-02f, 1.98731292e-03f, 1.67148300e-02f,
  7.00045452e-02f, 5.06619439e-02f, -3.30390967e-02f, -1.03006409e-02f, -6.01770952e-02f, 3.72911803e-03f, -1.56784989e-02f, 4.94909734e-02f, -6.19793311e-03f, -5.12058847e-02f,
  -9.37370285e-02f, -3.54197137e-02f, 5.65062426e-02f, -5.49892485e-02f, 3.34999822e-02f, 7.17315823e-02f, -2.15793271e-02f, -9.75231454e-03f, -8.23426694e-02f, 3.38101983e-02f,
  3.24530490e-02f, -3.59094292e-02f, -6.32185861e-02f, 2.42800396e-02f, -3.06673311e-02f, -1.86454803e-02f, -5.50569072e-02f, -5.11691300e-03f, -3.31963859e-02f, 3.66736725e-02f,
  -1.90467075e-01f, -5.37172668e-02f, 3.35870534e-02f, -5.85294738e-02f, -1.08716153e-02f, -3.20102461e-02f, 3.12716933e-03f, 1.85161014e-03f, -5.64941242e-02f, -3.25167105e-02f,
  1.57318190e-02f, 5.23580052e-02f, 1.63431745e-03f, -3.70184965e-02f, 5.17600623e-04f, 2.14490686e-02f, -7.02354014e-02f, -5.69049492e-02f, -6.00764826e-02f, 2.60707270e-02f,
  6.13737591e-02f, 6.46832585e-02f, 4.63949181e-02f, 3.17843929e-02f, 4.51688468e-02f, -2.99413363e-03f, -4.25291583e-02f, 2.54230723e-02f, 7.24505112e-02f, 2.19479650e-02f,
  -1.23708934e-01f, -5.96862137e-02f, -1.74791306e-01f, -7.59679750e-02f, 4.23997045e-02f, -1.54612318e-01f, -2.03243151e-01f, 4.51726140e-03f, -2.04770878e-01f, 2.57348213e-02f,
  7.09990636e-02f, -1.69665292e-02f, -1.00797582e-02f, 7.65463039e-02f, 9.24622361e-03f, -1.53477406e-02f, 6.48734644e-02f, -1.40592093e-02f, 2.33830474e-02f, 9.51057747e-02f,
  1.13431131e-02f, 2.41844371e-01f, 4.05096002e-02f, 1.05960265e-01f, 3.34728956e-02f, 1.00948758e-01f, 2.44729385e-01f, 1.36339972e-02f, 2.02001929e-01f, -3.64331948e-03f,
  4.70020138e-02f, 5.63224442e-02f, 3.46561149e-02f, -6.01212643e-02f, 8.03069621e-02f, 2.72858869e-02f, -6.16338803e-03f, -3.52882184e-02f, -3.89989354e-02f, -2.47019064e-02f,
  -1.97898522e-02f, 3.11270431e-02f, 4.92848009e-02f, -1.74012948e-02f, -2.79107485e-02f, -7.92402923e-02f, 1.94316190e-02f, 5.35205286e-03f, -3.50694954e-02f, -8.43404140e-03f,
  -7.55061731e-02f, -4.03341502e-02f, -5.67328222e-02f, -2.78173313e-02f, -6.31546378e-02f, -4.15979363e-02f, -4.32325155e-02f, 2.72981208e-02f, 4.15974529e-03f, 1.58083718e-02f,
  -4.40260917e-02f, -7.95514788e-03f, 1.84545238e-02f, 3.24166343e-02f, 4.06182632e-02f, 4.47878726e-02f, -6.92852400e-03f, 5.88946976e-02f, 1.07145309e-02f, 5.65088093e-02f,
  1.15494959e-01f, -1.75389647e-02f, -1.61001552e-02f, -1.87859070e-02f, -1.12066548e-02f, -1.23089030e-02f, -1.21376887e-02f, -1.33567036e-03f, 6.75659906e-03f, 6.46139011e-02f,
  1.05384011e-02f, -5.43417260e-02f, 2.59114755e-03f, -5.56199532e-03f, -6.87912747e-04f, 1.37663493e-02f, 5.80021972e-03f, -5.03705330e-02f, -4.44860272e-02f, 1.38397189e-02f,
  1.45970687e-01f, 1.10458873e-01f, 3.31865735e-02f, -4.27258248e-03f, 5.08959591e-02f, 5.88625222e-02f, -8.44776258e-03f, 3.88906710e-02f, 2.44880915e-02f, -2.82826163e-02f,
  4.46978211e-03f, 5.10438122e-02f, -2.66809249e-03f, -1.77148525e-02f, -8.06612335e-03f, -3.98707204e-02f, -6.93288166e-03f, 4.37212065e-02f, 3.92445363e-02f, 3.63030136e-02f,
  7.85620064e-02f, -2.42560897e-02f, 2.90854108e-02f, 2.99025271e-02f, 3.12591228e-03f, 5.11017777e-02f, 2.63035274e-03f, -7.06740990e-02f, 4.23604399e-02f, -4.92681339e-02f,
  -1.70706496e-01f, 3.47183459e-02f, -1.28214389e-01f, 1.22414470e-01f, -2.26741478e-01f, -1.59382522e-01f, -6.73739538e-02f, 1.72594488e-02f, 3.19053456e-02f, 1.87961087e-01f,
  1.68777220e-02f, 9.07931700e-02f, 9.13502946e-02f, 1.12071663e-01f, -1.25079766e-01f, 1.58658713e-01f, -1.03624031e-01f, -1.82997081e-02f, -5.89975901e-02f, -1.30006760e-01f,
  -1.36105716e-01f, -1.32590562e-01f, -4.67883535e-02f, -9.35097337e-02f, -1.49100721e-01f, 1.16069010e-02f, -7.88434893e-02f, -1.15803473e-01f, 1.80803314e-02f, -5.75612187e-02f,
  2.03397069e-02f, 4.35056910e-02f, -1.04710169e-01f, 2.08595358e-02f, -1.16914183e-01f, 1.27940476e-02f, 1.27871484e-02f, -1.59876377e-04f, 3.98447961e-02f, 5.77570163e-02f,
  3.37905250e-02f, 3.11374608e-02f, 5.27449772e-02f, -7.75859803e-02f, -1.41512055e-03f, -4.95894719e-03f, 8.63168214e-04f, -5.97570203e-02f, 8.58364850e-02f, -3.16816010e-02f,
  -3.77056003e-03f, 9.19116568e-03f, -6.66703284e-02f, 4.35845964e-02f, -6.75466433e-02f, 4.47305664e-02f, 9.92084369e-02f, 5.19005433e-02f, 1.04046846e-03f, -5.09888195e-02f,
  -4.35974188e-02f, 6.36292547e-02f, -1.69635341e-02f, 1.60339549e-02f, -3.50554436e-02f, -3.24454019e-03f, -9.64127388e-03f, 8.60328451e-02f, -1.24760112e-02f, -3.65791284e-02f,
  6.65325718e-03f, 4.01371829e-02f, -4.05747741e-02f, -1.07375821e-02f, -3.50169081e-04f, 3.01692449e-02f, -1.99486921e-03f, 3.74862887e-02f, -2.40023620e-02f, 4.20993045e-02f,
  5.76974973e-02f, 6.27017405e-04f, 3.80142499e-03f, 3.39472108e-02f, -7.73236379e-02f, -2.19399165e-02f, -4.65310439e-02f, 4.17754762e-02f, 5.68950288e-02f, -8.89197439e-02f,
  7.15467706e-02f, 5.48530743e-02f, 3.26349549e-02f, 9.66807886e-04f, 2.06960714e-03f, -6.57444820e-02f, -5.23310751e-02f, -6.17356338e-02f, 3.23733166e-02f, -4.53811064e-02f,
  -6.33391663e-02f, 3.58746909e-02f, -7.61666149e-02f, -7.72810308e-03f, 4.08514263e-03f, -3.32717858e-02f, 3.76675054e-02f, 6.72265282e-03f, -3.15470807e-02f, -4.41787615e-02f,
  -1.50031401e-02f, 1.21305343e-02f, 1.94862876e-02f, -6.85728295e-03f, -4.32871748e-03f, -5.71976155e-02f, 3.48445438e-02f, 8.25466588e-02f, -4.25207019e-02f, 4.44148947e-03f,
  -4.43348475e-02f, -6.59127533e-02f, -2.37064734e-01f, -1.28126964e-01f, 5.27572958e-03f, 1.77708492e-01f, 2.02307049e-02f, 3.22497301e-02f, -7.72690028e-02f, 1.64153308e-01f,
  2.40396913e-02f, -9.82621610e-02f, -9.72677618e-02f, 1.19133450e-01f, 5.37089109e-02f, -1.71896499e-02f, 1.05711050e-01f, 2.50529088e-02f, -8.95378888e-02f, -6.92352876e-02f,
  -9.16053653e-02f, 1.83367714e-01f, -8.64014477e-02f, 1.48165539e-01f, 1.22029997e-01f, -4.65067290e-02f, 3.66628543e-02f, -1.44625664e-01f, 1.00681603e-01f, 1.85365174e-02f,
  8.23111832e-02f, -3.92391756e-02f, -8.32936913e-02f, -2.75023580e-02f, 3.38120610e-02f, -1.63265839e-02f, -6.31612763e-02f, 1.83028430e-02f, 1.81023534e-02f, -4.79607843e-02f,
  1.61164161e-02f, 3.00497897e-02f, 2.48384029e-02f, -2.60259155e-02f, 6.22608997e-02f, 7.59074837e-02f, -6.25714958e-02f, -3.84533517e-02f, -1.25621529e-02f, 1.75973866e-02f,
  -9.83950496e-02f, -7.46102259e-02f, -3.09939831e-02f, 1.62296612e-02f, -1.04084000e-01f, -4.87619750e-02f, 6.72908500e-02f, -1.01140633e-01f, -7.64626637e-03f, 2.20045401e-03f,
  -3.30708027e-02f, -3.41939107e-02f, -2.23703273e-02f, 1.15082599e-02f, 4.98367026e-02f, -2.64681578e-02f, 6.89746812e-03f, 1.26552777e-02f, -7.29221329e-02f, -6.69652270e-03f,
  -1.52337947e-03f, 1.62119735e-02f, -5.78885041e-02f, -4.71051084e-03f, -2.46110139e-03f, 2.60209106e-02f, -9.32703726e-03f, 1.72390379e-02f, -4.07780744e-02f, -1.21838518e-03f,
  2.09503677e-02f, -3.31331305e-02f, 8.12806711e-02f, 1.08943945e-02f, 2.37017516e-02f, 9.59234312e-03f, -1.61255896e-02f, 2.20903978e-02f, -1.09055247e-02f, -8.54633152e-02f,
  5.28679378e-02f, -6.74263164e-02f, -1.50375916e-02f, -3.56847583e-03f, 9.15627927e-03f, 3.64611037e-02f, -8.67734943e-03f, -1.88548546e-02f, -4.34716791e-02f, 4.90008593e-02f,
  6.42995536e-03f, 3.60886306e-02f, 4.16824184e-02f, -9.50936635e-04f, -2.98142619e-02f, 1.82242207e-02f, -6.17371723e-02f, -2.81319711e-02f, 2.25963444e-02f, -5.78088723e-02f,
  1.37913413e-02f, 4.44206148e-02f, -4.85859290e-02f, -2.08370872e-02f, 2.06033811e-02f, -2.99640819e-02f, -4.69818013e-03f, -2.86220126e-02f, -3.49389901e-03f, -2.35756524e-02f,
  -5.39967231e-02f, -2.30022818e-01f, -1.25875100e-01f, -9.78627726e-02f, 4.81291898e-02f, 1.55912474e-01f, 8.95044059e-02f, -1.43594500e-02f, 1.86999198e-02f, -2.01023713e-01f,
  1.19592823e-01f, -2.61679113e-01f, 9.60362852e-02f, -1.72075689e-01f, 1.91995293e-01f, 2.42217913e-01f, -2.27403536e-01f, -9.37962607e-02f, 4.81452905e-02f, -2.23254144e-01f,
  -3.33006233e-02f, 3.86497192e-02f, 4.26759012e-02f, -2.73623746e-02f, -2.95379758e-02f, -7.43202046e-02f, -9.70121622e-02f, 1.13109879e-01f, -1.56333432e-01f, 2.34377347e-02f,
  2.78227832e-02f, 1.23145044e-01f, -3.95326689e-02f, 2.07643677e-02f, 1.19782872e-02f, -4.38927114e-02f, 1.04283150e-02f, 5.73256873e-02f, -1.54545205e-02f, 3.76428626e-02f,
  -5.51639535e-02f, 5.45951538e-02f, -2.13770811e-02f, 5.24155311e-02f, -7.73691898e-03f, 2.14821324e-02f, 3.52057479e-02f, -2.96995379e-02f, -4.70457114e-02f, -4.18241769e-02f,
  -2.11521871e-02f, 2.58397069e-02f, -1.10909894e-01f, -1.10113025e-01f, -8.43586773e-02f, -3.38049345e-02f, 1.84239987e-02f, -3.15740332e-02f, 1.91376433e-02f, -8.15629661e-02f,
  -6.12172298e-02f, -1.44071132e-02f, 2.27809418e-02f, 4.09836136e-02f, 2.54882313e-02f, 2.90740770e-03f, 3.51861604e-02f, -2.68683136e-02f, -1.14846947e-02f, 1.46623133e-02f,
  -4.11541350e-02f, 1.98369678e-02f, 8.35753977e-02f, -1.35867689e-02f, -1.47313355e-02f, -2.62093786e-02f, -3.89111899e-02f, 3.17224786e-02f, -4.38854210e-02f, 4.53927275e-03f,
  2.45778132e-02f, -3.70589942e-02f, -1.13699713e-03f, -3.84577438e-02f, 3.19845998e-03f, 6.43011853e-02f, -2.52686702e-02f, -2.52821352e-02f, -6.86311908e-03f, 3.67313921e-02f,
  -8.56668130e-02f, -2.05227226e-01f, -1.31801479e-02f, -2.39075106e-02f, -5.41656278e-02f, -8.73639062e-02f, -4.71677855e-02f, -4.48331945e-02f, 3.67937200e-02f, 3.51179391e-02f,
  -7.60393962e-02f, -2.05312017e-02f, 5.20980321e-02f, 4.83847149e-02f, 2.66606733e-02f, -2.62871478e-02f, -7.45748635e-03f, -3.43654528e-02f, -8.11588317e-02f, -4.40318473e-02f,
  1.55417703e-03f, 6.64377958e-02f, 1.72103085e-02f, 7.29651935e-03f, -2.02856362e-02f, 2.17327569e-02f, -6.35251179e-02f, 5.07045910e-02f, 6.16129339e-02f, -6.30819872e-02f,
  -3.17854911e-01f, 1.06260136e-01f, -7.10730702e-02f, -2.60094672e-01f, -7.56039470e-02f, 9.01590288e-02f, -6.23545386e-02f, -8.02378450e-03f, -1.60172656e-01f, 1.68896556e-01f,
  -3.41713876e-02f, -1.72213644e-01f, 9.46503878e-02f, -2.43816555e-01f, -3.08999598e-01f, -3.44741009e-02f, -1.98822990e-01f, -1.48560017e-01f, -7.95907900e-02f, 3.52860265e-03f,
  -7.98585415e-02f, -1.89219207e-01f, -1.39938012e-01f, -5.89706972e-02f, 2.84375548e-02f, 1.05555793e-02f, 1.41760185e-02f, 1.13778569e-01f, -1.18800811e-02f, -1.14504859e-01f,
  2.30705999e-02f, -3.13387252e-02f, -3.24533507e-02f, -4.93732188e-03f, 2.91937515e-02f, 6.16763383e-02f, 4.73816991e-02f, -6.03418350e-02f, -2.49830708e-02f, -6.79182038e-02f,
  2.39810329e-02f, -5.22292629e-02f, -8.58276710e-02f, 2.83381809e-03f, 5.69617897e-02f, -2.45646257e-02f, -4.50059399e-03f, 3.18756886e-02f, -3.05718184e-02f, 2.93614212e-02f,
  -1.48270605e-02f, -8.93648155e-03f, 2.56950147e-02f, 1.85772628e-02f, 2.57105287e-02f, 1.48929125e-02f, -2.94671115e-02f, 3.39505933e-02f, 1.54967112e-02f, -6.54048771e-02f,
  -2.35980283e-02f, -2.13887505e-02f, -6.37548715e-02f, -5.59182540e-02f, -3.85516100e-02f, -1.44783882e-02f, 4.18814644e-02f, -1.86993331e-02f, 1.56036057e-02f, 2.56259758e-02f,
  -4.86750826e-02f, -1.52274873e-02f, 1.58240125e-02f, 3.85568887e-02f, 2.16549728e-02f, 5.04073338e-04f, 1.79874394e-02f, 3.74798104e-03f, 1.45134358e-02f, 7.91222900e-02f,
  7.83157256e-03f, 4.82720137e-03f, 3.79180931e-03f, 3.54100615e-02f, -4.72515933e-02f, 1.17027313e-02f, -1.48801953e-02f, 3.59272249e-02f, 4.36966345e-02f, 7.39610335e-03f,
  1.10125408e-01f, 2.42378353e-03f, -8.50103516e-03f, 1.70550440e-02f, 8.50473344e-03f, -3.02717002e-04f, -5.48052676e-02f, -2.00821105e-02f, 1.63024124e-02f, 1.31956805e-02f,
  1.23347873e-02f, -8.56536068e-03f, 1.04680181e-01f, -4.02814746e-02f, -3.15493047e-02f, 3.86874005e-02f, 6.08778521e-02f, 4.85682748e-02f, -2.93909088e-02f, -5.53681236e-03f,
  5.34731820e-02f, 4.92683388e-02f, -4.35127085e-03f, -2.53862366e-02f, 1.65600993e-03f, 2.71755066e-02f, 6.07272089e-02f, 1.75637305e-02f, 1.46375308e-02f, 3.72056328e-02f,
  2.71227032e-01f, 1.76150918e-01f, 7.44973077e-03f, 1.83210731e-01f, 1.09062530e-02f, -8.75736412e-04f, -2.80031469e-03f, 3.08218803e-02f, 1.46644726e-01f, -3.65299731e-02f,
  1.16981797e-01f, -8.14874470e-03f, -2.04088688e-01f, 1.82082191e-01f, -5.94264157e-02f, -1.39968827e-01f, 1.56646550e-01f, 6.74627572e-02f, 2.39476394e-02f, 3.30307484e-02f,
  6.51064888e-02f, 1.09922223e-01f, -1.02116451e-01f, 9.14211720e-02f, 1.02159426e-01f, 1.13518834e-02f, 1.41852321e-02f, -4.80684787e-02f, 1.35294303e-01f, -1.84036195e-02f,
  8.65182430e-02f, 8.53753742e-03f, 3.83603908e-02f, -4.84777652e-02f, 5.32779470e-02f, 2.73865201e-02f, -9.76039283e-03f, -1.31877601e-01f, -5.30692004e-02f, -5.43981232e-02f,
  -7.87158385e-02f, 2.32321466e-03f, 1.03527382e-01f, -6.31424487e-02f, -3.23646218e-02f, 3.97869870e-02f, -8.91136676e-02f, 6.49609789e-02f, 2.36587990e-02f, -8.30448493e-02f,
  3.44480015e-02f, 5.61356172e-02f, 2.13186294e-02f, -2.08636038e-02f, -7.28277564e-02f, 7.84127228e-03f, 1.62262302e-02f, -8.18605497e-02f, 6.53001992e-03f, 2.00766772e-02f,
  -2.58952305e-02f, 2.26125140e-02f, 1.06966542e-02f, 6.60861209e-02f, 6.87136427e-02f, 7.51399919e-02f, -2.98254308e-03f, -3.50549668e-02f, 4.27513272e-02f, 5.48442267e-02f,
  1.08299486e-01f, 5.65952528e-03f, 1.68086737e-02f, -3.40556242e-02f, -2.97033880e-02f, -8.57016817e-03f, -2.66072173e-02f, 6.14104681e-02f, 1.60416234e-02f, -1.42434025e-02f,
  -1.33052049e-03f, 3.72082740e-02f, 3.95401977e-02f, 2.83953026e-02f, -2.90955696e-02f, -8.21283311e-02f, -1.51170874e-02f, -9.85935610e-03f, -3.58160026e-02f, -3.76657769e-02f,
  1.24275491e-01f, 2.26572856e-01f, 3.11187673e-02f, 5.09816520e-02f, 4.93227877e-02f, -6.68548122e-02f, -1.34049617e-02f, -1.29832244e-02f, 3.49442139e-02f, 5.10349013e-02f,
  -1.29651250e-02f, -5.13514243e-02f, 4.47525010e-02f, -5.30048907e-02f, -1.52513366e-02f, 3.31929475e-02f, 6.66760504e-02f, 1.98078658e-02f, -4.10599746e-02f, -9.46207903e-03f,
  7.19489753e-02f, 2.93206349e-02f, -7.24952593e-02f, 2.64664758e-02f, 8.32150131e-03f, 3.10501666e-03f, 6.87539205e-02f, 1.95501186e-03f, -9.27996337e-02f, -3.30566578e-02f,
  -1.69803113e-01f, -1.10713623e-01f, 3.97419855e-02f, -1.35847911e-01f, 1.14183724e-01f, 1.49150109e-02f, 3.71381844e-04f, 3.39464545e-02f, -1.87041849e-01f, -7.24404976e-02f,
  4.59473208e-02f, -3.53117175e-02f, -1.09086640e-01f, -1.66928619e-02f, -1.01114444e-01f, -1.69215292e-01f, -1.02981113e-01f, -5.82972579e-02f, -8.36996585e-02f, 1.87643187e-03f,
  -1.24207223e-02f, 2.25981083e-02f, 6.19505122e-02f, 1.30747631e-01f, 3.01697385e-02f, 5.41794747e-02f, 1.36997132e-02f, 8.49137753e-02f, 6.82862625e-02f, 4.59647030e-02f,
  9.71346870e-02f, 9.49915312e-03f, 7.67889246e-02f, -6.26982888e-03f, -1.55560179e-02f, 4.87808697e-02f, -3.50044146e-02f, 1.89312585e-02f, 6.79716617e-02f, 6.80715637e-03f,
  -2.95711253e-02f, 1.72039568e-02f, -1.48980645e-02f, -6.83015138e-02f, -2.38981587e-03f, 7.53453514e-03f, -1.03917876e-02f, -2.86958497e-02f, 4.67972495e-02f, -2.07203086e-02f,
  2.56574415e-02f, -2.83130240e-02f, 8.35853256e-03f, -7.90060684e-02f, -1.52752381e-02f, -1.31629445e-02f, -1.41349472e-02f, 8.41338281e-03f, -3.02789081e-02f, -2.69258954e-02f,
  1.64226089e-02f, -3.29085030e-02f, 2.45155804e-02f, 3.56956832e-02f, 3.70854624e-02f, -1.36282276e-02f, 7.99476355e-03f, 7.31083453e-02f, -6.01041913e-02f, 5.86699229e-03f,
  -3.48920934e-02f, 2.08559074e-02f, 4.76155393e-02f, 2.75246594e-02f, -3.63125950e-02f, -8.07568617e-03f, 6.84699342e-02f, 2.04409324e-02f, -3.30547169e-02f, 3.86267304e-02f,
  -7.26139871e-03f, 3.81892510e-02f, -3.61029468e-02f, 3.08917537e-02f, 2.52465215e-02f, -4.08282429e-02f, -3.75667065e-02f, 3.86945121e-02f, 1.44371483e-02f, -4.18780223e-02f,
  -9.86789018e-02f, -7.68657252e-02f, -9.77063552e-03f, 6.56854510e-02f, -5.87370917e-02f, 2.39163954e-02f, 2.03927830e-02f, -7.34754950e-02f, -1.28270956e-02f, 4.47597206e-02f,
  -3.15616131e-02f, -1.15365526e-02f, 2.77333334e-02f, 1.53469425e-02f, 3.29778306e-02f, -2.20464896e-02f, 3.99295278e-02f, 8.16730503e-03f, 2.52680816e-02f, -6.61149323e-02f,
  7.35906092e-03f, 2.64719930e-02f, -2.42611468e-02f, 3.89292352e-02f, -2.17896681e-02f, -4.31563891e-02f, 2.00091321e-02f, -2.88886111e-02f, -5.84462285e-03f, -6.92583919e-02f,
  4.06599283e-01f, -2.03413948e-01f, -9.11491364e-02f, 7.73511454e-02f, 1.08884238e-01f, -2.91336160e-02f, -6.43862113e-02f, -1.01229355e-01f, -1.70736864e-01f, -1.91713661e-01f,
  -1.07643031e-01f, -2.68568248e-02f, -1.40701205e-01f, -8.31577405e-02f, 1.86246365e-01f, -1.73566058e-01f, -2.68672500e-02f, -3.77368145e-02f, 2.83374675e-02f, 1.07467482e-02f,
  6.99559450e-02f, 4.16440330e-02f, 1.85333528e-02f, 6.97552636e-02f, 1.17065012e-01f, 6.96061775e-02f, 4.39205626e-03f, 7.73608908e-02f, -2.16735620e-02f, 7.37754479e-02f,
  -3.20198648e-02f, -7.41542205e-02f, -1.13894921e-02f, -4.31982391e-02f, 2.63813902e-02f, 4.13968749e-02f, 3.10824029e-02f, 1.34218425e-01f, 3.68104652e-02f, 1.57675371e-02f,
  1.03479456e-02f, 6.10802472e-02f, 3.04132402e-02f, -2.59433631e-02f, 9.90176573e-02f, 1.00338701e-02f, -4.69295457e-02f, -7.51223490e-02f, -8.71518701e-02f, 5.20974286e-02f,
  1.02905435e-02f, 2.71876995e-02f, -3.70789021e-02f, -1.96738895e-02f, 5.33732809e-02f, -2.20666938e-02f, -1.58582870e-02f, 1.14659565e-02f, -1.37721254e-02f, 1.19563350e-02f,
  2.40717772e-02f, 4.69767116e-02f, -4.18118648e-02f, -7.74411298e-03f, 1.00979777e-02f, -1.22428741e-02f, -3.62339965e-03f, -4.82757427e-02f, 6.43779635e-02f, 3.58442403e-02f,
  -1.80373676e-02f, 1.15091819e-02f, -6.52669519e-02f, -1.32888863e-02f, 3.92560214e-02f, 2.41934378e-02f, 3.38286236e-02f, -3.58915515e-02f, -1.15877278e-02f, 1.02285147e-02f,
  -5.86766899e-02f, 2.76768412e-02f, -1.15825040e-02f, -8.06643590e-02f, -4.92921751e-03f, 6.82030693e-02f, -8.09211060e-02f, 7.66774686e-03f, -2.44851932e-02f, 2.10190061e-02f,
  -1.19998865e-01f, -4.26319316e-02f, -4.15297970e-02f, 4.63392250e-02f, -3.06782462e-02f, -7.15410477e-03f, -4.17671874e-02f, 7.96919875e-03f, -1.49858389e-02f, -4.47650664e-02f,
  4.61419970e-02f, -5.94451977e-03f, -2.89981533e-02f, 6.43388182e-02f, 9.99312252e-02f, -8.65854248e-02f, -2.13558339e-02f, 4.08325903e-02f, -4.17554304e-02f, -3.92197743e-02f,
  -2.87114419e-02f, 4.13355939e-02f, 5.19605353e-02f, -3.28652710e-02f, -4.67455499e-02f, -2.80218404e-02f, 3.77595238e-02f, 4.03557979e-02f, -2.56816112e-02f, -4.94436435e-02f,
  -2.31425062e-01f, 1.86768755e-01f, -1.43567577e-01f, -1.56494025e-02f, -1.44958362e-01f, 5.37746847e-02f, -4.56099249e-02f, -2.83298120e-02f, 1.16731465e-01f, 1.44915208e-01f,
  -1.27627533e-02f, 1.48747489e-02f, 7.78944511e-03f, 1.45405218e-01f, -5.78911379e-02f, 1.42411694e-01f, 4.91399728e-02f, 7.28096366e-02f, -2.13246271e-02f, 7.61731863e-02f,
  5.63371889e-02f, 9.28807035e-02f, -1.33784935e-01f, -7.70753296e-03f, -1.11056469e-01f, -1.20418780e-01f, -6.41828626e-02f, -1.15594640e-01f, -5.11100963e-02f, 1.70137845e-02f,
  2.08590887e-02f, 6.40015230e-02f, -7.76090622e-02f, -3.60600129e-02f, -6.97707534e-02f, 1.51988333e-02f, 1.90679617e-02f, -5.14599718e-02f, -6.45487532e-02f, -6.28564553e-03f,
  4.52498943e-02f, -1.65186618e-02f, 9.55425501e-02f, -9.40790586e-03f, 4.77665663e-02f, -4.24209284e-03f, 5.77116869e-02f, -5.27332723e-02f, -1.45814428e-02f, 8.72616598e-04f,
  -4.08156812e-02f, 1.72401797e-02f, 1.62865426e-02f, 2.11066660e-02f, 2.16718148e-02f, -1.65804345e-02f, 1.35554867e-02f, -9.87716168e-02f, 5.74949710e-03f, 2.23775152e-02f,
  2.83375625e-02f, -7.46555766e-03f, -4.22641598e-02f, -2.98396405e-02f, 1.37173682e-02f, 7.38340393e-02f, 2.04131640e-02f, 1.31421918e-02f, 1.89288370e-02f, 6.18108287e-02f,
  -6.32042363e-02f, -2.54095327e-02f, 7.11052790e-02f, -1.47689600e-02f, 3.63142639e-02f, 5.32503016e-02f, -2.70431545e-02f, -5.16049340e-02f, -5.30092604e-02f, -2.15531010e-02f,
  3.26439030e-02f, 1.37323132e-02f, -6.54183328e-02f, 1.49825476e-02f, 3.09070554e-02f, -6.62122443e-02f, 1.71842389e-02f, 1.95538402e-02f, -5.58207929e-02f, 4.17769700e-02f,
  1.57583639e-01f, 1.81864917e-01f, 2.31842697e-02f, -4.66404110e-02f, 8.80057290e-02f, -7.96057470e-03f, 9.44801942e-02f, 2.29460932e-02f, 6.57219961e-02f, 3.65874395e-02f,
  9.25206486e-03f, -1.84521973e-02f, 1.74454891e-03f, -2.60445829e-02f, 6.24647029e-02f, -5.25568658e-03f, -3.93542275e-02f, -1.71923898e-02f, 4.57840152e-02f, -1.53089017e-02f,
  -5.86813577e-02f, 3.47752571e-02f, -2.17423979e-02f, -6.12276904e-02f, -3.14235166e-02f, -7.68105984e-02f, -3.84366401e-02f, -6.34912327e-02f, 1.69645529e-02f, 4.93879765e-02f,
  -2.37042621e-01f, 6.10601157e-02f, -1.27494931e-01f, -4.65847552e-02f, -1.15644313e-01f, 1.90869033e-01f, -1.13369506e-02f, -9.70427785e-03f, -1.77523792e-01f, 2.96973344e-02f,
  5.86304441e-02f, -3.95246893e-02f, 1.36737362e-01f, 7.53766224e-02f, 8.74207169e-02f, 5.00997230e-02f, 2.04802193e-02f, -2.58897617e-02f, -4.79546003e-02f, 7.78926834e-02f,
  -2.50653774e-02f, 1.19656093e-01f, -5.10938885e-03f, 1.03770658e-01f, -4.56916951e-02f, -9.93854105e-02f, -3.47780250e-02f, -5.65040149e-02f, -4.29276004e-02f, -5.90818352e-04f,
  7.28240237e-02f, -3.88071612e-02f, -2.15326007e-02f, 3.87374014e-02f, 3.96990515e-02f, 7.69026577e-02f, 7.83208385e-03f, -2.94010947e-03f, -3.65155265e-02f, -1.09457821e-02f,
  -1.72005519e-02f, 4.25037965e-02f, 4.78207730e-02f, 1.49657223e-02f, -2.95447037e-02f, -3.98543701e-02f, -5.93260350e-03f, -1.76173877e-02f, -9.19800892e-04f, 1.47256963e-02f,
  -3.82890627e-02f, -2.34021973e-02f, -2.94333808e-02f, -2.28904840e-02f, 2.05977913e-02f, 2.95852534e-02f, 6.88391626e-02f, -2.78027952e-02f, 8.49983539e-04f, 5.16302623e-02f,
  6.10650964e-02f, -9.86552914e-04f, 2.58073695e-02f, 4.10064049e-02f, -2.29009939e-03f, -5.57921045e-02f, -1.14319497e-03f, -4.15322483e-02f, -8.30487683e-02f, -3.15939523e-02f,
  4.27254885e-02f, -2.04278529e-02f, -4.13723942e-03f, -4.59000061e-04f, 9.93241370e-02f, -9.30311065e-03f, -4.49442044e-02f, -3.02392114e-02f, -9.88122076e-04f, 6.73260959e-03f,
  4.78509590e-02f, 3.79596651e-02f, -1.00867767e-02f, 4.29593213e-02f, -5.71513840e-04f, 1.85906608e-02f, 2.78388616e-02f, -8.80095139e-02f, -6.21059462e-02f, 2.05207877e-02f,
  2.98550259e-02f, -2.05098167e-02f, 2.98259445e-02f, 1.20083140e-02f, -3.73364352e-02f, 3.19126397e-02f, -9.32641793e-03f, -3.01065948e-02f, -3.07499692e-02f, 8.50615427e-02f,
  3.90486866e-02f, -5.78640290e-02f, 1.87071860e-02f, 6.64395886e-03f, -2.19462290e-02f, -5.83434440e-02f, 2.44222172e-02f, 4.51271236e-02f, -5.64093404e-02f, 5.65488189e-02f,
  8.49486440e-02f, 5.38637303e-03f, 3.64748500e-02f, -6.76091313e-02f, -3.26181501e-02f, 5.08304685e-02f, -1.91982382e-03f, -3.92724350e-02f, 7.01204699e-04f, 6.63170144e-02f,
  6.22074381e-02f, 1.35434672e-01f, -9.26985890e-02f, 1.69135258e-01f, -8.32226947e-02f, -1.51517140e-02f, 2.08403636e-02f, 4.80829850e-02f, -2.17696559e-03f, 1.49112567e-01f,
  9.11918804e-02f, 5.99534027e-02f, -9.00029093e-02f, 2.09604591e-01f, -9.11432207e-02f, 5.32440394e-02f, 1.32982060e-01f, 1.29273266e-01f, -4.10743766e-02f, 1.12462424e-01f,
  7.17808083e-02f, 1.50676981e-01f, 5.32767698e-02f, 8.65809694e-02f, 5.30663617e-02f, -4.10852302e-03f, 1.19857639e-02f, -2.52583437e-03f, 5.58330081e-02f, 5.55335954e-02f,
  2.98514143e-02f, 6.52511641e-02f, -4.10236754e-02f, 1.83064200e-03f, -3.07162255e-02f, 9.14419163e-03f, 1.69556253e-02f, -3.74347903e-02f, -7.62516353e-03f, 2.92363632e-02f,
  2.86885514e-03f, 2.40836535e-02f, -4.71921405e-03f, 1.93851683e-02f, 1.35164484e-02f, -3.75071578e-02f, -2.66064461e-02f, 5.52435080e-03f, -4.88868728e-02f, -4.62248735e-02f,
  -3.80265638e-02f, -2.62870546e-02f, 8.56242236e-03f, 2.88625713e-02f, -6.11171965e-03f, -3.35840955e-02f, -1.83719564e-02f, -1.05926546e-03f, 1.72975678e-02f, 5.99729009e-02f,
  1.42987082e-02f, -5.89777604e-02f, 3.51550095e-02f, -1.02490408e-03f, -4.44570929e-02f, 8.32954235e-03f, 1.97580662e-02f, -1.91221759e-02f, -3.76145057e-02f, 9.13967472e-03f,
  -3.36651914e-02f, -1.62506532e-02f, 4.78371903e-02f, -5.36088925e-03f, 7.69873662e-03f, 4.26609665e-02f, -4.37437817e-02f, 2.80865431e-02f, -5.56787774e-02f, -3.08485180e-02f,
  5.64967357e-02f, -4.56649438e-02f, 1.65691879e-02f, -3.60531844e-02f, -5.62935285e-02f, -2.72076037e-02f, 2.74656639e-02f, 3.70144397e-02f, 3.06085590e-03f, -1.25474613e-02f,
  4.94435541e-02f, 6.70104101e-02f, -2.76647080e-02f, 3.67911503e-04f, -7.94655830e-03f, 2.07138062e-02f, -2.13612244e-02f, 2.74180975e-02f, -1.25163319e-02f, 2.97248717e-02f,
  1.02045266e-02f, 2.14732555e-03f, -2.37029847e-02f, 9.63527802e-03f, 1.60772335e-02f, 1.23665286e-02f, -2.82931216e-02f, -2.42041051e-03f, -1.20067094e-02f, 8.81693512e-03f,
  5.54485768e-02f, -3.20110819e-03f, -7.94438459e-03f, -4.75433469e-02f, -2.53241137e-02f, 6.32745028e-02f, 1.33199962e-02f, -1.81006100e-02f, 1.09701268e-02f, -2.73133572e-02f,
  -5.05416505e-02f, 5.35918623e-02f, -3.82798277e-02f, 3.90216932e-02f, 1.01524100e-01f, -1.15590170e-01f, -5.18499576e-02f, 8.70647207e-02f, -9.83100664e-03f, 6.24401644e-02f,
  -4.36671413e-02f, -1.26021817e-01f, -1.41329855e-01f, 2.96920189e-03f, -3.51275563e-01f, -2.31820434e-01f, -1.26133829e-01f, -4.38615121e-02f, -1.42793544e-02f, 5.30148782e-02f,
  -8.08480475e-03f, 2.11786199e-02f, -1.04442112e-01f, 1.13943733e-01f, 9.09797624e-02f, 1.75516501e-01f, 1.87613387e-02f, 8.95368457e-02f, 4.24970090e-02f, -1.33301858e-02f,
  -1.59777645e-02f, 5.86953480e-03f, 2.02256776e-02f, -4.90089841e-02f, -4.69166860e-02f, -6.22173678e-03f, -6.32440150e-02f, 2.86758714e-03f, -4.34836932e-02f, 4.35581012e-03f,
  -6.85990751e-02f, -8.74800235e-03f, 4.34439555e-02f, 1.17030945e-02f, 5.97596914e-02f, -1.54447285e-02f, 8.13024789e-02f, -2.06531379e-02f, -3.52900699e-02f, 5.00739515e-02f,
  -4.96358685e-02f, 8.97855218e-03f, -5.85275777e-02f, -5.04803136e-02f, 1.67168528e-02f, -1.82388853e-02f, 4.65325378e-02f, 4.74157892e-02f, -1.67434532e-02f, -3.15063074e-02f,
  -2.10922509e-02f, -8.45997687e-03f, 7.48692155e-02f, -7.15682507e-02f, 3.39783765e-02f, -4.79347305e-03f, -1.89518612e-02f, -4.23570201e-02f, 6.92787245e-02f, 4.60448563e-02f,
  5.81533611e-02f, -4.01405320e-02f, 3.49563099e-02f, -1.26490714e-02f, 3.61553095e-02f, -3.34873311e-02f, 6.37872005e-03f, 6.23427406e-02f, 6.47286996e-02f, 1.90922711e-02f,
  -9.12219845e-03f, -1.66710187e-02f, 4.92861494e-02f, 1.52711915e-02f, -3.60418856e-02f, 3.83122601e-02f, 6.44535245e-03f, 8.89372732e-03f, -1.05457949e-02f, 7.18728229e-02f,
  -1.07864551e-01f, -2.29530614e-02f, -2.16124896e-02f, 4.33220807e-03f, 1.41654368e-02f, -5.73014095e-02f, -3.23833674e-02f, 6.74584731e-02f, -5.52960709e-02f, -1.21125858e-03f,
  2.09447332e-02f, 3.62487813e-03f, -6.58851936e-02f, 3.36099342e-02f, 4.66293143e-03f, 3.76196802e-02f, -3.50098535e-02f, 4.36094850e-02f, -8.58836249e-03f, -9.26943589e-03f,
  2.36120373e-02f, 1.93005241e-02f, 5.67070432e-02f, 1.92788597e-02f, -3.03933136e-02f, 1.68247148e-02f, -1.39889391e-02f, 4.86701615e-02f, 2.89321691e-02f, -4.55034785e-02f,
  2.02383474e-01f, 1.34357452e-01f, 6.76866472e-02f, -9.66909751e-02f, -2.91977793e-01f, -3.07583064e-01f, -2.64221668e-01f, -8.93415958e-02f, -1.61174029e-01f, -3.75128388e-02f,
  6.57850597e-03f, 8.97863805e-02f, 1.31712362e-01f, -1.81847364e-02f, -9.50378776e-02f, 2.28687525e-02f, -2.14317869e-02f, 1.71353146e-02f, -1.81501452e-02f, 6.14747256e-02f,
  8.72682501e-03f, -1.06813349e-01f, 2.95603722e-02f, 9.32855681e-02f, 1.89547837e-02f, 1.18135922e-01f, 1.13301031e-01f, 5.38940057e-02f, -2.10625306e-02f, -6.85613230e-02f,
  4.25747149e-02f, 8.29239488e-02f, 3.72014530e-02f, -4.13079895e-02f, 5.15595563e-02f, -2.83552078e-03f, 2.21559480e-02f, -3.77410129e-02f, 4.02130820e-02f, -5.63631468e-02f,
  4.74038608e-02f, -6.70519844e-02f, -3.31962779e-02f, -9.56129283e-03f, -1.03196122e-01f, -3.30125093e-02f, -6.06149770e-02f, -4.35501784e-02f, 6.37108460e-02f, 4.42379117e-02f,
  9.28285997e-03f, -2.84842327e-02f, -5.80817722e-02f, 1.37142325e-02f, 1.63282920e-02f, -1.75920911e-02f, -3.30351479e-02f, -1.31282285e-02f, -6.54322654e-02f, -2.17987318e-02f,
  2.81975567e-02f, 2.95885317e-02f, 2.27495749e-02f, -4.82603163e-02f, 8.90386552e-02f, 1.51588991e-02f, -5.39642572e-02f, 5.80065651e-03f, 5.75558878e-02f, 2.53217537e-02f,
  -5.69464490e-02f, -4.23106924e-02f, 3.32044885e-02f, -3.93195376e-02f, -2.06068233e-02f, -4.80327345e-02f, -2.53950190e-02f, -1.80981718e-02f, 3.17542092e-03f, -5.26282564e-02f,
  3.18496861e-02f, 2.36570332e-02f, 4.49949279e-02f, -1.05668288e-02f, 1.49418786e-02f, -4.99945544e-02f, -1.27874576e-02f, -3.11671682e-02f, -3.94591726e-02f, -3.76069616e-03f,
  3.69422100e-02f, 5.34791909e-02f, -5.62777035e-02f, -2.85967905e-02f, 8.08846653e-02f, 1.49521336e-01f, 4.05106880e-02f, 5.99985570e-02f, 2.60079149e-02f, 3.87740955e-02f,
  -3.72182205e-02f, -1.27346888e-02f, -1.71205048e-02f, 1.35870380e-02f, -3.06757651e-02f, -1.41800335e-02f, 2.04894543e-02f, -7.36398343e-03f, -6.94781020e-02f, 4.67514582e-02f,
  6.34516850e-02f, -3.45653668e-02f, 1.39144026e-02f, -9.12185982e-02f, 4.73985672e-02f, 1.05507178e-02f, 3.65027157e-03f, 6.05172617e-03f, -7.89498985e-02f, -9.16625466e-03f,
  -9.10293981e-02f, -1.01840839e-01f, -1.26649037e-01f, 1.71050951e-01f, -7.19819441e-02f, -1.69766191e-02f, 4.31482680e-03f, 1.73623800e-01f, -2.50217263e-02f, 4.28560786e-02f,
  1.95381135e-01f, -1.09992102e-01f, -1.28170801e-02f, 1.08200036e-01f, 7.67569616e-02f, -1.10734608e-02f, 1.75688118e-01f, 4.52570058e-02f, -4.04492244e-02f, 1.44183815e-01f,
  3.62505689e-02f, 1.46123976e-01f, 7.43928850e-02f, 6.21372126e-02f, 7.41715804e-02f, 7.28650317e-02f, 8.82024691e-02f, -6.50159270e-02f, 1.69113696e-01f, -1.87808480e-02f,
  -2.60948408e-02f, -5.83492294e-02f, -6.44150227e-02f, -5.90717681e-02f, -2.54513361e-02f, -2.63945814e-02f, -5.71091212e-02f, -5.03116995e-02f, -7.17478320e-02f, -1.83503740e-02f,
  -7.00206980e-02f, 1.43245095e-02f, -1.08148493e-02f, 7.01327547e-02f, 2.34619379e-02f, -1.82745848e-02f, -1.41737389e-03f, -1.64142866e-02f, -3.07207601e-03f, -5.25364429e-02f,
  -7.29565844e-02f, 6.71296893e-03f, 6.70113713e-02f, -4.51533943e-02f, -5.50838094e-03f, 4.59316373e-03f, -1.16055030e-02f, 2.20754761e-02f, -4.71629202e-02f, -1.81070361e-02f,
  -1.61751490e-02f, -7.54257366e-02f, 2.35278960e-02f, 3.80580835e-02f, -2.78645121e-02f, 1.68691929e-02f, 5.28410301e-02f, 5.60909994e-02f, -4.38427813e-02f, 6.12892285e-02f,
  -3.54929492e-02f, -1.49101540e-02f, 7.83630162e-02f, -4.45970185e-02f, 1.47331273e-02f, -2.10385825e-02f, -2.12031081e-02f, 7.55987968e-03f, 2.11317819e-02f, -2.36182138e-02f,
  2.90274676e-02f, -2.47124173e-02f, -4.66080848e-03f, -2.38968581e-02f, -5.14916480e-02f, -1.66138052e-03f, 4.48951585e-04f, -1.14836041e-02f, 1.53046465e-02f, -8.85814894e-03f,
  1.09856553e-01f, 3.41462009e-02f, 2.25472562e-02f, -2.48158164e-02f, -6.84698224e-02f, 4.50477265e-02f, -2.43047369e-03f, 4.77355272e-02f, 4.09044698e-02f, 2.34959628e-02f,
  1.88579690e-02f, -4.93342802e-03f, -1.07520856e-02f, 7.12846173e-03f, 8.01475346e-02f, 2.93941032e-02f, -6.83103036e-03f, -2.70863306e-02f, 5.79952188e-02f, 1.31021449e-02f,
  -4.08600792e-02f, 8.90869740e-03f, -1.87418927e-02f, -5.10348193e-02f, 9.17480290e-02f, 4.31679823e-02f, 2.85014845e-02f, 2.84621064e-02f, -7.69658433e-03f, 4.42927107e-02f,
  2.63062060e-01f, -6.08045682e-02f, 8.37458298e-02f, -1.86982825e-02f, -8.20270181e-03f, -3.43411148e-01f, -2.99624324e-01f, 3.01006902e-03f, -1.10007294e-01f, -1.93009660e-01f,
  1.42613286e-02f, -1.70351507e-03f, -2.54770964e-02f, -8.90081152e-02f, -7.53645301e-02f, -1.18321411e-01f, -9.44660902e-02f, -6.40883893e-02f, -1.84029080e-02f, 1.11278839e-01f,
  7.09841400e-03f, 2.19654404e-02f, -2.05301456e-02f, 1.00588113e-01f, -2.91886423e-02f, 1.54566184e-01f, 5.42768240e-02f, 4.24552895e-03f, 1.67517662e-02f, -7.09908083e-03f,
  -7.02022165e-02f, 5.75660616e-02f, -1.52804786e-02f, -3.32552567e-02f, 2.78093163e-02f, -1.59618747e-03f, 2.79461802e-03f, -3.14085223e-02f, 2.42124014e-02f, -9.06037688e-02f,
  -4.12621647e-02f, 7.79194161e-02f, -2.74112094e-02f, 1.60756111e-02f, 5.82214855e-02f, 3.69407609e-02f, 3.77490721e-03f, -1.32636596e-02f, 4.83836792e-02f, -1.07884025e-02f,
  3.03078461e-02f, -2.59993002e-02f, 8.42403248e-03f, -1.82923134e-02f, 1.45095848e-02f, -1.60692390e-02f, -4.24252674e-02f, -1.35986889e-02f, -3.40234110e-04f, -5.62985837e-02f,
  -3.37479636e-02f, -1.09579181e-02f, 8.60622735e-04f, -2.09621433e-02f, -5.78929260e-02f, 1.17006386e-02f, -3.07899471e-02f, 1.44533878e-02f, 7.97996297e-03f, 4.38676029e-02f,
  -3.09399609e-02f, 4.08633165e-02f, -1.27400598e-02f, 3.74543816e-02f, -5.99680170e-02f, 2.01356802e-02f, -1.53207732e-02f, -6.64373534e-03f, 4.74458821e-02f, -1.88441295e-02f,
  -5.95654100e-02f, -2.49840436e-03f, -4.90179807e-02f, -1.88002177e-02f, -3.42835076e-02f, -1.48192572e-03f, 1.02170026e-02f, 1.58852693e-02f, 9.24718194e-03f, -3.22294906e-02f,
  -1.42794460e-01f, -1.88012626e-02f, -7.97353983e-02f, 1.08047770e-02f, 2.73710601e-02f, -1.70368254e-02f, -1.02770753e-01f, -3.71770118e-04f, 3.70170884e-02f, -3.77321802e-02f,
  3.96397449e-02f, -2.14399174e-02f, 2.56469082e-02f, -4.28301729e-02f, -1.45730004e-02f, -3.98565270e-02f, 4.36041579e-02f, -2.20858715e-02f, -1.96784642e-02f, 1.56354960e-02f,
  6.43403456e-02f, -1.11507447e-02f, -5.53330295e-02f, -6.12748303e-02f, -2.22780230e-03f, -1.01462556e-02f, 3.48380245e-02f, 3.09936255e-02f, -1.26908859e-02f, -1.73215028e-02f,
  -1.60248786e-01f, 2.01999471e-01f, -2.19078988e-01f, 1.22500613e-01f, -2.04479173e-01f, -9.30642933e-02f, -1.76158428e-01f, 4.35848273e-02f, -1.48242423e-02f, 1.26450971e-01f,
  -5.36015294e-02f, -4.28235233e-02f, -7.02555403e-02f, 1.19040444e-01f, 1.68593135e-02f, 3.13517079e-02f, 1.15110151e-01f, 8.58694687e-02f, 3.27794366e-02f, -5.93613982e-02f,
  -1.23886308e-02f, 1.36752278e-01f, 4.53511160e-03f, 1.40514731e-01f, -5.05974144e-03f, 2.77966689e-02f, 7.26989731e-02f, -6.40402809e-02f, 2.54118182e-02f, 3.01819444e-02f,
  -1.95195377e-02f, 7.49797001e-02f, 7.27075264e-02f, 1.28416009e-02f, 2.83337338e-03f, -2.81918179e-02f, -2.37702765e-03f, 2.88194735e-02f, -8.36733356e-02f, -6.59856200e-02f,
  -1.14658587e-02f, -6.49000611e-03f, 2.37920089e-03f, -5.48934340e-02f, -1.26730569e-03f, -5.41004818e-03f, -4.12905999e-02f, -4.90226746e-02f, -3.73210274e-02f, -4.91942167e-02f,
  -6.49123965e-03f, -1.84158329e-02f, -5.19510061e-02f, -8.48750100e-02f, -3.15745994e-02f, 9.42121353e-03f, -2.35506743e-02f, -9.01166052e-02f, -9.13102925e-03f, -4.70610037e-02f,
  6.42524138e-02f, -5.07343449e-02f, -2.38830410e-02f, -4.12792228e-02f, -2.36175749e-02f, 1.58024747e-02f, 2.39443383e-03f, -6.02975264e-02f, -6.67701662e-02f, 6.21990561e-02f,
  -5.95938601e-03f, -3.49538168e-03f, 2.30741668e-02f, -2.56750062e-02f, -5.93833253e-03f, 6.42941743e-02f, -1.01914303e-02f, -5.18395305e-02f, 5.18384352e-02f, -1.20540103e-02f,
  -6.43853247e-02f, 8.53022560e-03f, 7.79725313e-02f, -6.01275451e-02f, 5.24981841e-02f, -2.03901483e-03f, 2.28232518e-03f, 4.49677883e-03f, -7.00426325e-02f, -4.12839949e-02f,
  1.01803295e-01f, 1.54502138e-01f, 6.09186478e-02f, 4.19011451e-02f, 4.10441682e-03f, 1.85059011e-02f, -2.06076186e-02f, 1.88505575e-02f, 7.87721574e-02f, -6.55666217e-02f,
  1.10040726e-02f, 2.37492733e-02f, 8.05711001e-03f, 5.41172782e-03f, 1.07106321e-01f, -1.69945750e-02f, 4.15916219e-02f, 1.47866982e-03f, 6.93429485e-02f, -6.53722789e-03f,
  -6.34138752e-03f, -2.83936523e-02f, -2.08245553e-02f, 3.97691019e-02f, 6.85021654e-02f, -1.90746523e-02f, -3.12199146e-02f, 5.62619083e-02f, 1.08469212e-02f, 4.19125287e-03f,
  3.29905860e-02f, 1.75643101e-01f, -1.85154974e-02f, -4.17850241e-02f, -8.37443620e-02f, -2.16985524e-01f, -5.33439666e-02f, 3.02319415e-02f, -8.44560936e-02f, 1.61821470e-01f,
  1.82373542e-02f, -1.16877621e-02f, 9.27298814e-02f, -2.44672820e-01f, -3.29522789e-01f, -1.53533638e-01f, -2.55916238e-01f, -1.07797548e-01f, -2.84512173e-02f, -1.25863717e-03f,
  -1.21128999e-01f, -1.25472590e-01f, -1.15778588e-01f, 8.34561512e-02f, 7.51031861e-02f, 1.94360405e-01f, 2.21850261e-01f, 1.12925112e-01f, 2.94897659e-03f, -9.66910273e-02f,
  4.59452569e-02f, 4.96409610e-02f, -3.95980887e-02f, -3.95072326e-02f, 5.63234836e-02f, 1.03233280e-02f, 1.20656841e-01f, 2.70895138e-02f, 5.48779219e-03f, 2.76852474e-02f,
  5.53643033e-02f, 3.09273507e-02f, -8.12609345e-02f, -7.03821555e-02f, -1.94457378e-02f, 1.10729495e-02f, 1.18535385e-02f, -4.71261479e-02f, 4.46454957e-02f, -1.01197131e-01f,
  -2.36620754e-02f, -3.74190249e-02f, -3.39091755e-02f, -5.19516431e-02f, -1.98306814e-02f, 6.68168766e-04f, -7.41184410e-03f, -3.22682112e-02f, 2.83625964e-02f, 1.31061478e-02f,
  -1.30171161e-02f, 7.74842352e-02f, 4.83561158e-02f, 5.95437177e-02f, 3.41793299e-02f, 7.65047129e-03f, -8.81615058e-02f, 2.23279838e-02f, 9.37643722e-02f, -1.90538503e-02f,
  -4.31560120e-03f, 7.23952102e-03f, -1.29140206e-02f, -6.38836436e-03f, 7.87991881e-02f, 1.06951594e-02f, 5.79632670e-02f, -7.48440698e-02f, -5.55877239e-02f, -1.33386478e-02f,
  1.44450879e-02f, -1.38410470e-02f, -1.81560982e-02f, 5.36675192e-02f, 2.11209189e-02f, -1.07831163e-02f, -2.58306172e-02f, -3.83092798e-02f, 3.81435193e-02f, -2.71063149e-02f,
  9.26731080e-02f, 2.53969461e-01f, 2.95805912e-02f, 5.84790818e-02f, 5.93943931e-02f, 6.32472429e-03f, 3.21081430e-02f, -4.27561700e-02f, 1.05909079e-01f, 4.45971638e-03f,
  6.13984512e-03f, 5.09655736e-02f, 7.89815653e-03f, -2.24235915e-02f, -2.10066256e-03f, -6.77537769e-02f, 3.42688113e-02f, 1.21008813e-01f, 8.53799284e-02f, -6.56521227e-03f,
  1.48522288e-01f, 2.44748853e-02f, 6.39714673e-02f, 2.59961616e-02f, 2.21848264e-02f, -7.52287032e-03f, -3.36663537e-02f, -7.39868672e-04f, -4.02286043e-03f, -6.30862638e-02f,
  2.50813186e-01f, 1.95080653e-01f, 6.73846453e-02f, 1.39449254e-01f, -1.70818493e-02f, -4.89077084e-02f, -6.12939261e-02f, 1.86767504e-02f, 1.63334370e-01f, 8.30892846e-02f,
  -8.67580920e-02f, 1.95904493e-01f, -4.80120704e-02f, 1.52091488e-01f, -6.33259490e-02f, 1.75489429e-02f, 9.02276188e-02f, 9.69026461e-02f, 7.97342211e-02f, 3.45624760e-02f,
  2.29454581e-02f, 1.90015901e-02f, 5.52873388e-02f, -4.20747837e-03f, 5.48096783e-02f, 6.38687015e-02f, 1.03235338e-02f, -5.36870845e-02f, -1.91162433e-02f, 5.49650704e-03f,
  -6.35402054e-02f, 8.29509571e-02f, -2.61806976e-03f, 2.74319178e-03f, 5.58671579e-02f, -1.95287149e-02f, -2.64447909e-02f, -9.08334404e-02f, 7.13029504e-03f, -3.40057388e-02f,
  -4.49116863e-02f, 3.47962193e-02f, -1.09753855e-04f, 1.81931332e-02f, 2.46679992e-03f, 3.08278203e-02f, 2.90172454e-02f, 6.54620230e-02f, 3.77463959e-02f, 8.38916749e-02f,
  7.52630783e-03f, 4.36641723e-02f, 7.61262402e-02f, 2.31164228e-02f, 1.85633991e-02f, 2.68362928e-04f, -1.24208648e-02f, -2.70490330e-02f, 5.28561175e-02f, -1.13205612e-02f,
  -2.50298902e-03f, -2.71493644e-02f, 4.94602732e-02f, -9.92895663e-03f, 7.87470117e-03f, -1.43461609e-02f, 4.20637312e-04f, -4.48334254e-02f, 3.06474846e-02f, -7.78793590e-03f,
  -5.63169690e-03f, 2.21004859e-02f, 6.67605363e-03f, 2.39221640e-02f, 2.89962981e-02f, 3.09790764e-02f, -2.07992960e-02f, 1.67735983e-02f, -1.04685212e-02f, 1.00365747e-02f,
  -5.28461225e-02f, -5.03799915e-02f, -2.77357511e-02f, 2.75041871e-02f, -6.03861921e-02f, 2.42889877e-02f, 3.32553051e-02f, 4.69911136e-02f, -4.41150814e-02f, -1.93169210e-02f,
  3.94445732e-02f, 1.85397565e-01f, 2.46182010e-02f, -1.66973136e-02f, -1.12485364e-02f, -3.36949266e-02f, -1.21247210e-02f, 1.98586937e-02f, 1.21374242e-02f, 2.29889713e-02f,
  -5.37331924e-02f, -4.63517159e-02f, 1.66335385e-02f, 3.64415310e-02f, -3.76133509e-02f, 1.77411698e-02f, -2.97443587e-02f, 2.44862419e-02f, 4.32568276e-03f, -5.39172031e-02f,
  -2.88839772e-04f, 1.61513779e-02f, 2.97745243e-02f, 8.60815495e-03f, -2.05017626e-02f, -9.69138928e-03f, 1.37468232e-02f, 3.57853547e-02f, -3.37236412e-02f, -1.52104106e-02f,
  4.66352165e-01f, 6.79535791e-02f, 8.69143605e-02f, 2.54787117e-01f, 4.85946424e-02f, -1.20052056e-04f, 2.70418704e-01f, -4.85677421e-02f, 2.20283076e-01f, 2.17048936e-02f,
  3.48126180e-02f, 1.63056359e-01f, 4.66242917e-02f, 1.66518405e-01f, 1.13756917e-01f, 1.25948917e-02f, 1.27586424e-01f, 9.09446925e-02f, 4.22434993e-02f, 7.62910247e-02f,
  5.97569011e-02f, 4.51326966e-02f, 3.90594825e-02f, -1.78116292e-01f, 1.72126055e-01f, 1.00190500e-02f, -1.59487769e-01f, -8.31529573e-02f, -8.18208009e-02f, -1.08530317e-02f,
  3.02839223e-02f, 3.36035080e-02f, 8.12001526e-02f, -5.61325625e-02f, -1.63526870e-02f, -1.48456069e-02f, 5.80622256e-02f, 4.82786968e-02f, 1.93026718e-02f, -3.04206014e-02f,
  -2.81362236e-02f, 2.40477156e-02f, 2.47092750e-02f, 4.50384151e-03f, 5.73291108e-02f, 2.67113186e-02f, -5.98670589e-03f, 3.43741328e-02f, 5.94538450e-02f, 3.52556519e-02f,
  2.16705957e-03f, -1.12769622e-02f, 3.10517531e-02f, -3.86268795e-02f, -5.04684122e-03f, 4.54111807e-02f, 5.49825467e-02f, 1.76137965e-02f, -1.92977842e-02f, 7.84991402e-03f,
  1.60702225e-02f, -4.56302352e-02f, -4.79376428e-02f, 6.47299131e-03f, -2.79581025e-02f, 2.24950593e-02f, -5.44321053e-02f, 7.85144046e-03f, 3.55658121e-02f, 4.29202579e-02f,
  1.62706841e-02f, -1.11693153e-02f, 1.04904369e-01f, 6.31762436e-03f, 3.17625739e-02f, 4.28337567e-02f, 1.58590171e-02f, -2.73698494e-02f, 2.36485829e-03f, 1.93369091e-02f,
  3.44148055e-02f, 2.31394321e-02f, -1.83152519e-02f, 1.26319062e-02f, -1.79472808e-02f, 2.75344215e-03f, -8.01409408e-02f, 3.58447693e-02f, 2.29251217e-02f, -4.63078283e-02f,
  -1.00482842e-02f, -7.20918402e-02f, 3.18542272e-02f, 3.77863497e-02f, -7.23075867e-02f, -2.73963306e-02f, -1.75703932e-02f, 9.52827651e-03f, -1.33721912e-02f, -6.92760525e-03f,
  3.21280234e-03f, 1.56190824e-02f, -6.02625385e-02f, -2.87295580e-02f, -6.90445304e-02f, 1.31404893e-02f, -9.59110912e-03f, -5.20818904e-02f, -4.42710333e-03f, -6.18175324e-03f,
  2.24100593e-02f, -1.00209443e-02f, 3.04675438e-02f, 3.12594660e-02f, -2.87253037e-02f, -2.35982146e-02f, -3.21295448e-02f, 5.76201566e-02f, -4.69579361e-02f, -7.78096437e-04f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.16615334e-01f, -6.88696979e-03f, -2.07466722e-01f, -1.02964327e-01f, -1.54617935e-01f, 4.35122065e-02f, -7.26271793e-02f, 2.38246587e-03f, 1.95791483e-01f, 8.39635655e-02f,
  -5.62191680e-02f, 2.42294725e-02f, 8.93391445e-02f, -2.08099917e-01f, 1.33864924e-01f, 9.15510952e-02f, 1.20589714e-02f, 3.60951871e-02f, 2.17377376e-02f, -2.85130423e-02f,
  1.13363136e-02f, -8.34924728e-02f, -2.21071064e-01f, -1.87541068e-01f, -2.25785270e-01f, -1.50410175e-01f, -1.20517373e-01f, -1.12828508e-01f, -1.77205652e-01f, -6.00895807e-02f,
  -7.24890456e-02f, -1.03714310e-01f, -1.00535564e-01f, 6.23894446e-02f, 1.97785608e-02f, 2.92871855e-02f, -7.15000331e-02f, -6.87625706e-02f, 2.68686074e-03f, 8.88028741e-02f,
  7.01893419e-02f, -1.08366217e-02f, 5.85507713e-02f, 1.77851617e-02f, 3.71038243e-02f, -5.74764870e-02f, -1.10128429e-02f, -3.90908271e-02f, -5.53277023e-02f, 4.79337806e-03f,
  -3.56214531e-02f, -7.20015541e-02f, -5.84988669e-02f, -4.99810167e-02f, -2.07016356e-02f, -8.70641135e-03f, 1.06649194e-02f, -1.21690538e-02f, -2.21422147e-02f, -9.93816089e-03f,
  1.92692894e-02f, 4.69492935e-02f, 3.07864286e-02f, 2.13502627e-02f, -4.55100387e-02f, -7.73258880e-02f, 4.67187092e-02f, 2.27595102e-02f, -2.57858038e-02f, 4.36720293e-04f,
  5.08954516e-03f, -6.56612078e-03f, -3.90820689e-02f, 6.96873516e-02f, -5.33010485e-03f, 1.60086770e-02f, 4.68602926e-02f, 1.16892699e-02f, 7.19554722e-02f, 1.47063136e-02f,
  4.12528291e-02f, 3.79176321e-03f, -9.54494104e-02f, -1.58553366e-02f, 9.36657749e-03f, 5.38022183e-02f, 1.23410607e-02f, -3.80323492e-02f, 6.87659578e-03f, -8.59817024e-03f,
  -2.75257230e-02f, 5.10306321e-02f, -4.79856692e-02f, 5.62458225e-02f, -1.59668066e-02f, 9.21496749e-03f, -2.30248813e-02f, -3.51280160e-02f, 1.45785157e-02f, 2.64972672e-02f,
  4.94094715e-02f, -2.14185398e-02f, 5.59660085e-02f, 4.05503204e-03f, 7.53907189e-02f, -4.43511717e-02f, 4.58978564e-02f, -7.27094244e-03f, 3.96457873e-03f, 1.70563930e-03f,
  2.38564727e-03f, 4.35175337e-02f, 6.74054474e-02f, -5.89190871e-02f, -1.09514799e-02f, -3.46050784e-02f, 5.98062463e-02f, 4.17951159e-02f, 1.57134775e-02f, 2.27588415e-02f,
  1.92617491e-01f, -6.60412833e-02f, 1.22701488e-01f, 1.87630072e-01f, 2.61487085e-02f, 1.21665830e-02f, 3.02143376e-02f, 7.65729919e-02f, 2.78326035e-01f, -1.62417397e-01f,
  2.75632665e-02f, 2.97829956e-02f, -7.70158693e-02f, -3.71790752e-02f, -1.30634591e-01f, -5.79595454e-02f, 2.40926491e-03f, -2.51214020e-02f, 2.77196523e-02f, 8.66214633e-02f,
  5.29567786e-02f, -1.06397800e-01f, -8.70858729e-02f, -1.74361527e-01f, 9.93867144e-02f, 1.71723124e-02f, -2.07251146e-01f, -1.15607738e-01f, -1.31900579e-01f, -1.35487109e-01f,
  6.15357123e-02f, 2.62846649e-02f, 1.87168047e-02f, -3.19480225e-02f, 4.07022983e-02f, -8.40561986e-02f, -9.96478721e-02f, -1.77541628e-01f, 2.88088131e-03f, 6.58137491e-03f,
  -4.77260037e-04f, -5.58731258e-02f, 9.74953324e-02f, -3.44905779e-02f, 4.75672185e-02f, -1.14357639e-02f, 1.12391613e-01f, -4.28846292e-03f, -8.05754438e-02f, 5.29866293e-02f,
  9.62111875e-02f, 1.38859916e-03f, 2.85488702e-02f, -8.40839446e-02f, 2.40331590e-02f, 7.94744045e-02f, 4.19410206e-02f, -8.03219825e-02f, -7.71846715e-03f, 4.17983159e-03f,
  -1.07213013e-01f, -1.11712217e-01f, -2.01509031e-03f, 8.10059458e-02f, 6.20869435e-02f, 4.43135872e-02f, -1.87928090e-03f, -4.30400893e-02f, -3.02970991e-03f, 7.39419740e-03f,
  -2.17223931e-02f, 8.12371820e-03f, 3.58524658e-02f, 7.44292662e-02f, 4.49152552e-02f, 7.04228282e-02f, -4.12248299e-02f, 2.44128071e-02f, 3.71481739e-02f, 3.62715088e-02f,
  9.35609173e-03f, -3.39468122e-02f, 2.15899069e-02f, 7.82948062e-02f, -3.11313197e-03f, -2.81701032e-02f, 2.98173316e-02f, 4.00494002e-02f, -4.36169356e-02f, -1.29072800e-01f,
  -2.23977305e-02f, -2.14728326e-01f, 1.59251038e-02f, -9.79474485e-02f, -5.03959483e-04f, -1.34535402e-03f, -1.26526738e-02f, -9.23789293e-03f, -4.50440459e-02f, 4.82367091e-02f,
  -7.88801983e-02f, 9.23736545e-04f, -3.21771577e-02f, 2.56640781e-02f, 1.06960842e-02f, -3.44300680e-02f, -5.44842295e-02f, -6.01671683e-03f, -3.65987569e-02f, -9.17037502e-02f,
  -2.84518804e-02f, -1.10807801e-02f, 1.90950371e-02f, -5.24790846e-02f, 4.55527753e-02f, -3.38228084e-02f, 5.33190034e-02f, -3.35375890e-02f, -3.76933701e-02f, 2.52130181e-02f,
  -3.94186610e-03f, 5.83780147e-02f, -6.38901070e-02f, -4.34056483e-02f, 1.76116303e-02f, 4.33051102e-02f, 4.88955975e-02f, 3.37650045e-03f, 4.83983569e-02f, 5.02578318e-02f,
  -1.49403617e-01f, 2.91354954e-02f, -1.18567161e-01f, -1.68610007e-01f, -2.53528059e-01f, -2.32869461e-01f, -8.15116614e-02f, -6.33524284e-02f, -1.08323224e-01f, -4.61844206e-02f,
  -1.14272237e-01f, -1.53743997e-01f, -4.83683497e-02f, 6.51989728e-02f, 1.28551304e-01f, 1.10674985e-01f, 4.58112769e-02f, 2.57057548e-02f, 9.44888368e-02f, -2.31369808e-02f,
  2.38183439e-02f, -1.60148479e-02f, 4.33535092e-02f, 2.23734006e-02f, 1.90797653e-02f, 9.59276482e-02f, 8.88553932e-02f, -3.25860642e-02f, -1.40701793e-02f, -1.62862043e-03f,
  5.27739003e-02f, -6.15851879e-02f, 1.66434553e-02f, -2.61271279e-02f, 7.54425526e-02f, -2.91850939e-02f, -2.83966716e-02f, 2.22482905e-02f, 5.77986613e-02f, -2.18873117e-02f,
  -7.26988167e-02f, 8.95474199e-03f, 7.62757808e-02f, 3.60319279e-02f, -1.45130721e-03f, -2.34334879e-02f, 3.81126702e-02f, 2.29798593e-02f, -6.50027813e-03f, 4.64120470e-02f,
  -2.72444934e-02f, 4.74958401e-03f, -5.04437760e-02f, 2.37623672e-03f, -2.27919612e-02f, 2.63034441e-02f, -1.99713670e-02f, -4.35395725e-02f, 3.64176705e-02f, 1.25537422e-02f,
  7.00873286e-02f, 4.12082579e-03f, -3.31578292e-02f, 4.16351706e-02f, 2.69607846e-02f, 2.43280828e-02f, 5.74032702e-02f, -3.00823543e-02f, -2.80051790e-02f, 2.60931049e-02f,
  8.16438626e-03f, -2.49502994e-02f, 2.84196399e-02f, 6.40624091e-02f, -6.15832508e-02f, -1.63803454e-02f, -4.31140289e-02f, 3.42579223e-02f, -4.08126600e-02f, -3.92556743e-04f,
  -2.48264577e-02f, -9.46825668e-02f, 4.06523682e-02f, 4.00248356e-02f, -3.92309986e-02f, 9.76538658e-03f, -3.94353122e-02f, 2.77505610e-02f, 3.02606449e-02f, 3.73381283e-03f,
  2.17927322e-02f, 1.31510170e-02f, 1.02237009e-01f, -2.27927435e-02f, 4.73847017e-02f, -7.67934183e-03f, -6.09686747e-02f, 7.82954916e-02f, 7.15457350e-02f, 4.17269245e-02f,
  1.83567144e-02f, 4.43989001e-02f, 4.65293378e-02f, 1.20017640e-02f, 2.17451155e-02f, 3.18476036e-02f, -4.21459861e-02f, 2.73181703e-02f, 1.94637254e-02f, -2.36775745e-02f,
  2.31924325e-01f, -8.92227516e-02f, -1.37653440e-01f, -1.19676307e-01f, -1.14963867e-01f, -8.37232694e-02f, -7.49074742e-02f, -1.23593368e-01f, -5.32386340e-02f, -7.57904276e-02f,
  -4.31480892e-02f, 9.27842874e-03f, 7.59658813e-02f, -8.63724500e-02f, 1.17100611e-01f, 1.30442083e-01f, -6.81476817e-02f, -7.32493354e-03f, -9.85236466e-03f, -1.03206262e-01f,
  -2.81182360e-02f, -4.19837497e-02f, -5.89388749e-03f, -7.20274225e-02f, -5.20349033e-02f, 4.40238416e-03f, 4.35377546e-02f, -5.54689504e-02f, -7.24449009e-02f, -1.82386283e-02f,
  1.08026005e-01f, 5.04013756e-03f, -4.97385748e-02f, 8.63597691e-02f, 6.63098320e-02f, -1.67325046e-02f, -1.67375132e-02f, 1.35852946e-02f, -3.32386792e-02f, 8.29841476e-03f,
  7.60126561e-02f, 9.48454533e-03f, 6.94962218e-03f, -5.40024182e-03f, -8.03269520e-02f, -6.10632896e-02f, 2.82873716e-02f, 5.55872638e-03f, -1.51515268e-02f, 2.16006059e-02f,
  2.08142176e-02f, -2.47167516e-03f, -2.62628961e-02f, -3.97990197e-02f, -6.57644421e-02f, -2.90309098e-02f, 5.31730726e-02f, -6.79268502e-03f, -1.13099748e-02f, -2.65549112e-04f,
  1.20633366e-02f, 8.55935179e-03f, 3.84047478e-02f, -3.96080920e-03f, -1.28543535e-02f, 3.39036458e-03f, -1.61142144e-02f, -3.74090187e-02f, -6.13209140e-03f, -4.48262803e-02f,
  -5.01275584e-02f, 1.21203475e-02f, -5.79561479e-02f, -1.88461039e-02f, 6.26428276e-02f, 2.59575937e-02f, 5.27048819e-02f, -2.32755523e-02f, -4.24606986e-02f, 7.09984452e-02f,
  -2.82592196e-02f, 2.38084849e-02f, -7.22455308e-02f, 3.03408932e-02f, 5.29514179e-02f, -4.30016629e-02f, -8.24017301e-02f, 4.61631268e-03f, -4.01808582e-02f, 5.31252511e-02f,
  -1.31960073e-02f, 1.81600766e-03f, 2.50483658e-02f, -3.90701033e-02f, 1.68402866e-02f, -5.81235904e-03f, 1.83235034e-02f, -5.10584041e-02f, -1.35928364e-02f, -1.80682074e-02f,
  1.42348083e-02f, 4.51519452e-02f, 1.38700530e-02f, -3.76284458e-02f, -8.40336084e-02f, -8.66378546e-02f, -2.42326148e-02f, -1.48776425e-02f, -5.56999706e-02f, 6.22143894e-02f,
  1.84824541e-02f, 5.72760627e-02f, -1.56136490e-02f, -2.12185942e-02f, -5.72685041e-02f, 1.00569278e-02f, 4.89628613e-02f, 3.90809663e-02f, -1.50895463e-02f, -2.74454113e-02f,
  -2.90559739e-01f, 3.48816603e-01f, 8.47796425e-02f, -1.79979041e-01f, -1.05289025e-02f, -6.87712729e-02f, -1.42605588e-01f, 1.04241803e-01f, 2.61719339e-02f, 1.73741117e-01f,
  -2.17680372e-02f, 1.30842760e-01f, 3.57444733e-02f, 1.46326295e-03f, -3.84929776e-01f, -1.16199203e-01f, -1.93025708e-01f, 1.48628140e-02f, -1.59811862e-02f, 4.08789478e-02f,
  -1.36906475e-01f, -1.59674898e-01f, -1.59011826e-01f, 1.01604968e-01f, 9.37031209e-02f, 1.79124564e-01f, -1.95506677e-01f, 1.21131912e-01f, 3.07538360e-02f, 3.20906043e-02f,
  3.27184871e-02f, 7.51354918e-02f, 1.24117106e-01f, 1.14976376e-01f, -5.17735966e-02f, 4.62024473e-02f, -2.68602911e-02f, 9.38733760e-03f, -8.43110606e-02f, 1.07548004e-02f,
  1.75088774e-02f, 3.50151658e-02f, -4.77812998e-02f, 2.17728242e-02f, 5.99789955e-02f, 1.07064217e-01f, 1.01921827e-01f, 5.53362183e-02f, 9.37616602e-02f, 8.73611271e-02f,
  1.00140579e-01f, -2.53579725e-04f, 2.79894914e-03f, -3.77571322e-02f, -1.04319073e-01f, 4.37031426e-02f, -5.45999222e-02f, 1.90544315e-02f, 3.58911380e-02f, -5.01688905e-02f,
  -6.97684614e-03f, -8.44417699e-03f, 2.37190854e-02f, 6.74900711e-02f, 2.37680748e-02f, 5.24573140e-02f, -1.13033708e-02f, 2.30415985e-02f, 2.07141545e-02f, 6.02981895e-02f,
  -7.20780492e-02f, 2.85199117e-02f, 9.24438797e-03f, -2.22996790e-02f, -3.79490741e-02f, -3.06449402e-02f, -5.85484654e-02f, -1.40231634e-02f, -4.87096719e-02f, -2.84010172e-02f,
  -3.79064158e-02f, -2.28352789e-02f, -1.46986051e-02f, 2.71226605e-03f, 2.86332462e-02f, -2.37238929e-02f, 5.56462631e-02f, 4.22439091e-02f, -5.83482310e-02f, -7.47509971e-02f,
  -1.65017188e-01f, -1.73969436e-02f, -1.50389355e-02f, 4.63526994e-02f, -3.63150984e-02f, 3.68084125e-02f, -8.36331677e-03f, -1.70675199e-02f, -3.79919522e-02f, 2.05826815e-02f,
  2.29325630e-02f, -5.36632203e-02f, -1.63983144e-02f, -7.41116377e-03f, -5.44874221e-02f, -5.02677001e-02f, -8.21774900e-02f, -6.94422871e-02f, -1.08668372e-01f, 3.02619375e-02f,
  -2.48824945e-03f, -2.05120947e-02f, 6.86206768e-05f, -4.13733954e-03f, -3.70124206e-02f, -7.98026621e-02f, -4.80867624e-02f, 4.63566370e-02f, -9.17979609e-03f, -2.29671374e-02f,
  -1.18664966e-03f, 2.36935802e-02f, -1.52482033e-01f, -1.94236219e-01f, 2.35652961e-02f, -2.53725260e-01f, -2.76303530e-01f, -5.58986329e-02f, 2.31312178e-02f, 1.19345874e-01f,
  -9.01838019e-02f, 6.20949939e-02f, 6.00576364e-02f, -2.48577654e-01f, -1.90826535e-01f, -3.61940823e-02f, -2.75282979e-01f, -1.81890845e-01f, -5.34394607e-02f, -2.23053172e-01f,
  -8.31071511e-02f, -1.38387203e-01f, -1.77552268e-01f, -9.03774276e-02f, -1.35177210e-01f, -3.85739421e-03f, 4.55421545e-02f, -1.96066666e-02f, -1.10006675e-01f, 5.28599955e-02f,
  -1.22930177e-01f, 9.87302586e-02f, -2.01864783e-02f, 4.95304577e-02f, -9.61923972e-02f, -8.23887512e-02f, -1.06019966e-01f, -3.82521152e-02f, 1.44588863e-02f, -1.86512470e-02f,
  1.59208067e-02f, -2.71180104e-02f, -3.75410877e-02f, 7.84562156e-02f, 2.94458084e-02f, 5.99297546e-02f, -3.40115987e-02f, -2.29601259e-03f, -3.78683917e-02f, -1.20917208e-01f,
  -1.77121565e-01f, 1.64336953e-02f, -5.53626306e-02f, 9.73501503e-02f, -2.87650153e-02f, 9.38517042e-04f, -2.08170265e-02f, 6.51464099e-03f, -3.02708577e-02f, 4.23325691e-03f,
  3.14001017e-03f, -5.52601740e-02f, 3.32306623e-02f, 3.79460268e-02f, -3.25179137e-02f, -2.96625420e-02f, -1.58034004e-02f, -3.68320011e-02f, 4.22703382e-03f, -3.80478799e-02f,
  5.38221896e-02f, 1.78906415e-02f, 5.39809391e-02f, -1.16989464e-01f, -9.23697799e-02f, 3.88011187e-02f, -1.70447361e-02f, 2.53138635e-02f, -1.35858044e-01f, -4.41434793e-02f,
  5.77020794e-02f, 1.13084016e-03f, 4.22003167e-03f, -1.06579609e-01f, -2.30185445e-02f, 7.50473142e-02f, -1.01015056e-02f, 1.64423976e-03f, -1.69660582e-03f, -6.94906786e-02f,
  2.47680191e-02f, -2.34529618e-02f, -1.12807760e-02f, 1.53220650e-02f, 9.83406976e-02f, -1.10334735e-02f, -6.80013299e-02f, -5.87569810e-02f, -8.14250782e-02f, -1.66917425e-02f,
  -3.28157507e-02f, 3.59511413e-02f, -2.78616045e-02f, -5.18102869e-02f, -1.14511950e-02f, -6.30426407e-03f, -1.44193945e-02f, 4.87161875e-02f, -3.86316143e-03f, 2.33074035e-02f,
  -3.70824486e-02f, 5.96440136e-02f, 3.14654559e-02f, -3.99611332e-02f, -5.78824095e-02f, 7.88505599e-02f, 7.38192126e-02f, -2.25520208e-02f, -4.54144068e-02f, 4.79715690e-02f,
  1.00427091e-01f, 7.11876005e-02f, 1.45448729e-01f, 2.82411069e-01f, -1.50989369e-02f, -1.76997229e-01f, -1.23000264e-01f, 2.00177267e-01f, 7.12958053e-02f, -1.01148009e-01f,
  9.52567607e-02f, 5.40704746e-03f, -1.57119101e-03f, 1.46252677e-01f, 1.98063925e-01f, -3.89955863e-02f, 1.10828124e-01f, -3.35647687e-02f, 7.15644062e-02f, 5.99221066e-02f,
  1.88696444e-01f, 1.48784623e-01f, 6.86870813e-02f, 1.24713503e-01f, -1.89868137e-02f, 1.27540231e-01f, 1.25769451e-01f, -5.35152778e-02f, 8.38839114e-02f, -1.71263330e-02f,
  -9.02488977e-02f, 8.74751210e-02f, 2.03641765e-02f, -9.27131809e-03f, 7.05802739e-02f, -7.62250721e-02f, -9.64313745e-02f, -5.51071912e-02f, 1.13830799e-02f, 7.40143880e-02f,
  -1.26462206e-01f, -2.62021851e-02f, 2.83806846e-02f, 5.55161536e-02f, -1.96204167e-02f, -1.43170785e-02f, 5.04255481e-02f, -5.60158789e-02f, -5.96594661e-02f, 7.60576278e-02f,
  3.77460346e-02f, -2.18481738e-02f, -9.37293991e-02f, -5.50609343e-02f, 7.13183209e-02f, 5.32747470e-02f, 6.55900175e-03f, -7.90104829e-03f, 5.03521003e-02f, 2.35105939e-02f,
  7.20429942e-02f, 2.78806482e-02f, -5.23658246e-02f, 2.16958858e-03f, 8.47499967e-02f, -8.93075094e-02f, 3.48926224e-02f, 1.55527219e-02f, -6.30679056e-02f, -1.50869871e-02f,
  -6.58022687e-02f, 6.15022369e-02f, 4.47104080e-03f, -1.08017921e-02f, 6.41294494e-02f, -6.61856607e-02f, 6.01371692e-04f, 2.42870077e-02f, 2.09808163e-02f, 2.65870299e-02f,
  -7.83478990e-02f, 5.08934446e-02f, 3.46434042e-02f, -4.93851155e-02f, -1.79321854e-03f, 9.25327912e-02f, 7.63184503e-02f, 6.37769774e-02f, 1.23814074e-02f, -3.36860977e-02f,
  1.61881119e-01f, 1.58674926e-01f, 2.25090757e-02f, -9.77555513e-02f, -2.46779397e-02f, -4.85555492e-02f, -2.74979249e-02f, 1.03969343e-01f, 2.42841896e-02f, 3.54535021e-02f,
  4.46276851e-02f, 1.13376072e-02f, 2.47713979e-02f, -5.37608340e-02f, 1.12325177e-02f, 3.92704606e-02f, 2.48317830e-02f, 3.14845480e-02f, -1.31442249e-02f, 1.05007894e-01f,
  1.20760305e-02f, -6.33966848e-02f, 1.79891661e-02f, -4.95809130e-02f, 1.65277310e-02f, -5.20467572e-02f, 1.53513784e-02f, -2.55230963e-02f, 3.07498989e-03f, 3.38267758e-02f,
  -4.02546167e-01f, 1.47106022e-01f, 1.29139826e-01f, 6.56777695e-02f, -1.92076251e-01f, 1.31679654e-01f, 1.79939806e-01f, -2.51984987e-02f, 7.81097338e-02f, 8.42233300e-02f,
  9.42674801e-02f, -1.20239677e-02f, 1.14549592e-01f, 7.60155246e-02f, -2.47716364e-02f, 4.60428558e-02f, 1.32753626e-01f, 1.07854925e-01f, 4.25377265e-02f, -9.70750749e-02f,
  -8.89590830e-02f, -1.12537511e-01f, -1.93273164e-02f, -1.40626552e-02f, -9.21290740e-02f, -5.10544069e-02f, -3.51469107e-02f, -1.62939206e-02f, -2.62659639e-02f, -5.89929000e-02f,
  -1.38421476e-01f, -1.27388403e-01f, 7.86784738e-02f, 4.63346429e-02f, 9.78942439e-02f, 1.10052181e-02f, 2.55104098e-02f, 3.73131000e-02f, -3.89536694e-02f, -5.06870896e-02f,
  2.32316996e-03f, 4.25376482e-02f, 6.67133480e-02f, 3.34825478e-02f, 1.71191264e-02f, 9.92997736e-02f, -6.49733003e-03f, -1.05184466e-02f, 7.30032548e-02f, 5.59700467e-02f,
  8.53213072e-02f, 8.71257856e-02f, -1.52696669e-02f, 1.91871617e-02f, -7.88347051e-03f, 8.97076428e-02f, 5.53496368e-02f, -8.35998133e-02f, -8.03763047e-04f, -4.46067117e-02f,
  -4.38598245e-02f, 3.91102694e-02f, 4.22667488e-02f, 2.02002786e-02f, 4.34400961e-02f, -7.07598403e-02f, -2.31453287e-03f, 3.11932433e-02f, 4.40239422e-02f, -7.32140057e-03f,
  2.95611937e-03f, -5.41329682e-02f, 4.19847621e-03f, -1.94978602e-02f, 1.72247719e-02f, -3.64736468e-02f, -3.54683050e-03f, 1.16598476e-02f, 4.01063450e-02f, 5.05925938e-02f,
  7.52690434e-02f, 2.52685454e-02f, -3.97383049e-03f, -1.95420496e-02f, -1.13356104e-02f, 6.12209700e-02f, 3.95127982e-02f, 8.13004794e-04f, 8.74217898e-02f, -9.66044590e-02f,
  8.44669621e-03f, -1.06584631e-01f, 2.13049073e-02f, 5.56627810e-02f, 3.81687991e-02f, -4.87229507e-03f, -3.36498511e-03f, -3.10427751e-02f, 3.14659365e-02f, -6.43011257e-02f,
  -5.67161525e-03f, 8.28334875e-03f, -8.54369253e-03f, -9.86986328e-03f, 8.34970921e-02f, 6.70731887e-02f, 4.97183166e-02f, 1.14097223e-02f, -4.31957655e-02f, 1.03365853e-02f,
  2.72559766e-02f, -4.46319170e-02f, -7.32358219e-03f, -1.80340912e-02f, -1.05891414e-01f, 1.63215827e-02f, -2.23572161e-02f, 3.88341807e-02f, -6.15429506e-02f, 3.19187492e-02f,
  1.97360218e-01f, 1.08037777e-02f, -3.69806699e-02f, -9.36628059e-02f, -8.10912251e-02f, -2.77052641e-01f, -2.45841429e-01f, -6.96693435e-02f, -8.61105993e-02f, -7.25026503e-02f,
  -1.19408973e-01f, 9.63242818e-03f, 7.09484443e-02f, -1.22024000e-01f, 9.87895131e-02f, 1.49156183e-01f, -8.39682817e-02f, -1.18954353e-01f, 8.38781595e-02f, -4.45960574e-02f,
  1.13869309e-01f, -8.50964785e-02f, 1.13309063e-01f, -1.29708985e-03f, -7.89682940e-02f, 8.56112465e-02f, 2.02415898e-01f, 8.88851006e-03f, -2.51340214e-02f, -5.91575541e-02f,
  -7.57103935e-02f, -1.51384305e-02f, -4.28955583e-03f, -1.81567576e-02f, 4.47137794e-03f, -4.25939672e-02f, -6.82792673e-03f, -3.98814082e-02f, -3.29874344e-02f, 1.60571039e-02f,
  -1.70737505e-02f, 2.42234338e-02f, -5.77521659e-02f, -1.04996506e-02f, -5.51661476e-02f, -2.67797951e-02f, 6.11472242e-02f, 9.76416934e-03f, 3.03987246e-02f, 5.80812693e-02f,
  2.80254316e-02f, -2.41564736e-02f, 1.72535535e-02f, 4.43974845e-02f, 2.44891513e-02f, 2.29189023e-02f, -3.21658440e-02f, 1.21580092e-02f, 4.19838703e-04f, 5.48199639e-02f,
  4.30247327e-03f, 7.32686790e-03f, 1.59699637e-02f, -2.96076424e-02f, 1.38770966e-02f, 2.02811901e-02f, 2.85134520e-02f, 2.20051426e-02f, -2.84832460e-03f, -1.52099002e-02f,
  -2.08635144e-02f, -2.22140271e-02f, 1.16320262e-02f, -7.44676962e-02f, -1.99142918e-02f, 3.06900647e-02f, -4.08425890e-02f, 3.41346599e-02f, -5.60585223e-02f, -4.45582867e-02f,
  -2.78796162e-03f, 2.90004560e-03f, 3.57264392e-02f, -5.90276644e-02f, -5.16020395e-02f, -2.50241607e-02f, 2.01663747e-02f, 5.61634116e-02f, 1.11194625e-02f, 3.64137404e-02f,
  3.56112868e-02f, 1.42343417e-01f, -2.93271765e-02f, -1.79570410e-02f, -1.01722684e-02f, 5.57374842e-02f, -5.27622700e-02f, 4.23143581e-02f, 9.55601595e-03f, -2.58800779e-02f,
  1.51013723e-02f, -5.75212948e-02f, 1.42905079e-02f, 4.42211470e-03f, 2.19721831e-02f, 5.57733886e-02f, 3.30935381e-02f, -2.01368952e-04f, 9.00686253e-03f, 4.72728014e-02f,
  2.57760361e-02f, 2.50512781e-03f, 2.80222809e-03f, 2.11011060e-02f, -5.91483153e-03f, 2.58202460e-02f, -5.58283031e-02f, 4.60041612e-02f, 7.31210560e-02f, 1.40759051e-02f,
  8.97450149e-02f, 1.30099043e-01f, 2.71386001e-02f, -3.95487249e-02f, -6.42536115e-03f, -5.28712720e-02f, -1.07582979e-01f, 2.22942303e-03f, 4.13051769e-02f, 1.54243439e-01f,
  -1.79722589e-02f, 1.52539894e-01f, -2.36780215e-02f, -4.51801829e-02f, -2.34813690e-01f, -1.40924945e-01f, -7.80150741e-02f, 4.01774868e-02f, -8.80545303e-02f, 2.41131186e-02f,
  -9.86897275e-02f, -1.97076827e-01f, -7.13578090e-02f, -7.47379009e-03f, 1.26966223e-01f, 1.19692691e-01f, -1.09482177e-01f, -1.55806963e-04f, 1.16253823e-01f, -6.95293546e-02f,
  -3.03120408e-02f, -1.94025580e-02f, 2.67457254e-02f, 6.98928460e-02f, 4.68558744e-02f, 7.53300786e-02f, -1.49931265e-02f, 3.89865451e-02f, 2.73932256e-02f, 2.30479464e-02f,
  6.18979782e-02f, 1.42903989e-02f, 2.28759879e-03f, 5.52346483e-02f, 5.61873689e-02f, 7.50933141e-02f, 1.18567934e-02f, 5.76288626e-02f, 8.93005207e-02f, 5.29167689e-02f,
  6.10014088e-02f, 5.57841063e-02f, 3.12869065e-02f, 4.59580980e-02f, -3.10370997e-02f, 3.76206003e-02f, 3.76402587e-03f, 1.18908703e-01f, 4.07467708e-02f, 1.21003715e-02f,
  -1.25311270e-01f, -7.95873404e-02f, 1.94606390e-02f, 1.94379799e-02f, 9.46769044e-02f, 7.19242962e-04f, 9.65156220e-03f, 1.60858817e-02f, 6.55245855e-02f, -5.51417321e-02f,
  1.33477058e-02f, 1.38422698e-02f, -5.83301783e-02f, -3.13101895e-02f, 5.02608158e-02f, 5.71326353e-04f, -1.60663910e-02f, 1.77122578e-02f, 3.80329904e-03f, 3.85860614e-02f,
  -7.72461742e-02f, -6.36416450e-02f, 6.90584853e-02f, 6.28671721e-02f, 1.91581808e-02f, 6.15415052e-02f, 7.33767543e-03f, 1.03314519e-01f, -4.49733995e-02f, 3.58258262e-02f,
  -3.25659849e-02f, -8.63121301e-02f, 1.98052283e-02f, 4.02811579e-02f, -4.21685213e-03f, 6.97792470e-02f, -8.86963084e-02f, 3.05154379e-02f, 2.23513264e-02f, -6.45451024e-02f,
  -3.88279967e-02f, 4.59624566e-02f, -3.61718349e-02f, 2.43070140e-03f, 2.25815512e-02f, -4.65523191e-02f, -3.94520760e-02f, -4.65412103e-02f, -5.29197380e-02f, 6.09563254e-02f,
  4.70923036e-02f, 1.24515034e-02f, 6.65525571e-02f, 3.88916559e-03f, 4.66511697e-02f, 3.06717157e-02f, -2.20968183e-02f, 7.39551336e-02f, -1.36060258e-02f, -7.53472326e-03f,
  -1.93307593e-01f, -2.22782115e-03f, -1.98737636e-01f, -9.18022841e-02f, -1.22004852e-01f, -2.07565188e-01f, -2.36013472e-01f, -8.32485557e-02f, -2.03582458e-02f, -9.62617691e-04f,
  -1.24352083e-01f, -9.85439867e-02f, 4.57014591e-02f, -2.86992099e-02f, -9.23231617e-02f, 2.56085992e-01f, -6.82415217e-02f, -8.12406242e-02f, 9.59766209e-02f, 1.56344194e-02f,
  1.36317536e-02f, 1.09529160e-02f, 1.38766346e-02f, 4.17717174e-02f, -1.45895153e-01f, -6.86410517e-02f, -5.07822409e-02f, -5.43528982e-02f, -1.17923483e-01f, -1.66726381e-01f,
  -2.40424611e-02f, -4.46468964e-02f, -6.72536716e-02f, -7.35321194e-02f, -1.57106623e-01f, -8.86892080e-02f, -4.05162871e-02f, -3.63401026e-02f, 2.13181153e-02f, -1.09435365e-01f,
  1.42384702e-02f, 1.76819377e-02f, -5.25708795e-02f, 7.86746591e-02f, 2.81261420e-03f, -3.63339633e-02f, -1.09072682e-03f, -2.11411398e-02f, 5.31923212e-02f, 2.03994419e-02f,
  -5.83337508e-02f, -4.75925766e-02f, -4.49391678e-02f, 6.43529668e-02f, -9.93186422e-03f, -9.26486775e-02f, -1.61794648e-02f, -9.15679783e-02f, -8.61767009e-02f, -2.08040178e-02f,
  -8.23940858e-02f, 4.51418459e-02f, 5.98982116e-03f, 2.39931941e-02f, -9.40282717e-02f, 7.53035322e-02f, -1.18473722e-02f, -1.06327226e-02f, 1.68203060e-02f, 3.49482074e-02f,
  -9.49232001e-03f, -2.41543595e-02f, -7.29966611e-02f, 6.00356869e-02f, 3.09033506e-02f, 5.30135469e-04f, 3.17564048e-02f, -5.76432012e-02f, -1.16108088e-02f, -4.48433124e-02f,
  1.01356357e-02f, -6.24365322e-02f, 2.62734126e-02f, -2.91814245e-02f, -7.13308668e-03f, 4.80161421e-02f, 1.64641850e-02f, 3.27935442e-02f, -4.00552303e-02f, -6.96621090e-02f,
  -4.09641415e-02f, -2.14567080e-01f, -4.05105241e-02f, -1.21375263e-01f, -9.01529565e-03f, -4.50091287e-02f, -5.01281470e-02f, -1.12531194e-02f, -1.14852160e-01f, -1.27997324e-01f,
  -7.20880255e-02f, -1.59800751e-03f, 2.34704372e-02f, -2.18705344e-03f, 1.84359848e-02f, -1.66975812e-03f, 8.47137272e-02f, 2.97112446e-02f, -7.50063686e-03f, -1.05163701e-01f,
  -2.86231972e-02f, 3.90009433e-02f, 1.08638175e-01f, -7.72934454e-03f, 2.52079107e-02f, -4.58954461e-03f, 1.09865027e-03f, 1.89356152e-02f, 1.01338699e-02f, -1.08784009e-02f,
  2.16093943e-01f, -3.36223394e-01f, -1.19669810e-01f, 2.31894970e-01f, 1.68444499e-01f, -9.04590171e-03f, -9.49236453e-02f, 7.51631781e-02f, 9.71683636e-02f, -1.41121104e-01f,
  -1.56654902e-02f, -1.70869529e-01f, -2.19486207e-01f, 3.78265008e-02f, 5.73961474e-02f, -1.31684974e-01f, 1.25747010e-01f, -3.35505605e-02f, -5.45480438e-02f, 4.36596423e-02f,
  1.32409424e-01f, 9.93533432e-02f, -1.02216877e-01f, 3.63969281e-02f, -1.12027358e-02f, 5.86615084e-03f, 1.24909677e-01f, -9.90475714e-02f, 5.95320724e-02f, 6.49750466e-03f,
  -1.26425922e-02f, -6.81328624e-02f, -5.96884526e-02f, 8.95246714e-02f, 2.39792001e-03f, 2.72166841e-02f, 3.84620950e-02f, -7.60253565e-03f, 1.79148931e-03f, -1.40507460e-01f,
  -4.93624173e-02f, -4.74187955e-02f, 1.63209084e-02f, 6.81345984e-02f, 8.45548436e-02f, 3.85330394e-02f, 2.98165232e-02f, 7.04229549e-02f, -5.78551670e-04f, -5.03848642e-02f,
  -8.13728422e-02f, -3.51790003e-02f, 5.77583201e-02f, 2.99490504e-02f, -1.48430886e-03f, 6.86769420e-03f, -8.62662792e-02f, -1.06385775e-01f, 4.10029851e-02f, -2.77336854e-02f,
  -7.56429657e-02f, 1.45912571e-02f, -6.57213330e-02f, 2.67233001e-03f, -6.08399371e-03f, 3.18419114e-02f, 4.76529151e-02f, 4.94397385e-03f, 6.54571801e-02f, -3.02010607e-02f,
  3.01384320e-03f, 4.07917425e-02f, 5.03154770e-02f, -1.34278182e-02f, 6.98571056e-02f, -3.05595007e-02f, -3.38474149e-03f, -3.60432751e-02f, 1.17873065e-02f, 1.60694420e-02f,
  -6.79599354e-03f, 3.64275426e-02f, -8.61592218e-02f, 2.59018000e-02f, 8.30058381e-02f, -3.52320187e-02f, -2.25271238e-03f, -2.89888643e-02f, -9.45595838e-03f, -3.38567272e-02f,
  -4.46496047e-02f, -1.22043699e-01f, -4.30698246e-02f, 3.22042666e-02f, 2.40805633e-02f, 3.25262174e-02f, 6.41120002e-02f, -5.96781448e-02f, -6.20761514e-02f, -6.14837296e-02f,
  -5.03376983e-02f, 1.98101122e-02f, -4.46452312e-02f, -1.12662381e-02f, 5.25105298e-02f, -5.19495383e-02f, -3.05348989e-02f, 4.98357636e-04f, 4.84862365e-02f, -2.21223594e-03f,
  1.09247537e-02f, -1.38206840e-01f, 3.14496569e-02f, -8.69722106e-04f, -2.24349853e-02f, 4.86521050e-03f, -6.40505254e-02f, -1.23963030e-02f, 1.90862585e-02f, -2.80225370e-02f,
  -4.79194820e-01f, 1.51860669e-01f, -2.89304852e-02f, 6.69536069e-02f, -1.34881452e-01f, -3.26071456e-02f, 7.98063204e-02f, -2.07124501e-02f, -1.34905754e-02f, 1.34994537e-01f,
  5.08282706e-03f, 2.31485423e-02f, 9.26578790e-02f, 1.00421742e-01f, -1.21477939e-01f, 1.15931027e-01f, 2.19357796e-02f, -9.16725099e-02f, -1.03997942e-02f, -4.09345217e-02f,
  -9.81851853e-03f, -4.21735309e-02f, -2.54801158e-02f, -2.56532934e-02f, -1.16400301e-01f, -1.44200800e-02f, -2.39043869e-02f, -3.70541252e-02f, -1.75399370e-02f, -6.63801953e-02f,
  -2.33982310e-01f, -1.57411516e-01f, -1.30596519e-01f, -7.37413168e-02f, -5.99864498e-02f, -4.84717377e-02f, -1.89792516e-03f, -3.53990011e-02f, -4.12266552e-02f, 7.33950436e-02f,
  -2.50500664e-02f, -6.02958985e-02f, 4.82632481e-02f, 8.27539712e-03f, 1.61954900e-03f, -6.33414388e-02f, -7.40486011e-02f, 4.85153273e-02f, -5.97759485e-02f, 5.57627017e-03f,
  7.76415244e-02f, -3.84736923e-03f, -2.30444688e-02f, -7.64538767e-03f, 4.65572486e-03f, -3.70427035e-02f, -2.92030927e-02f, -3.21764819e-04f, -9.33180097e-03f, 5.99946547e-03f,
  -8.33306983e-02f, -1.09161902e-02f, -8.13366920e-02f, 8.74072090e-02f, 7.04499930e-02f, -2.35120617e-02f, 4.49579880e-02f, -5.77919856e-02f, 3.46877538e-02f, -2.75734104e-02f,
  3.12405154e-02f, -3.77432294e-02f, -7.32234269e-02f, 2.92071123e-02f, 3.92945595e-02f, 1.40771056e-02f, 3.28310877e-02f, -3.76754999e-02f, 1.01556860e-01f, -4.81051728e-02f,
  -1.88061222e-02f, -1.79165304e-02f, 2.06505172e-02f, 4.41603959e-02f, -5.61538488e-02f, 2.94724223e-03f, -1.61530580e-02f, -7.53396377e-02f, 2.22952962e-02f, 1.87618639e-02f,
  -2.83187956e-01f, -2.41468057e-01f, -4.56990264e-02f, -3.41657326e-02f, -3.91337499e-02f, 7.25378864e-04f, -1.20531331e-04f, -3.67333516e-02f, 2.04073898e-02f, 1.35951787e-02f,
  -4.57836613e-02f, -7.78040364e-02f, -1.18212305e-01f, 7.92964473e-02f, 7.69120604e-02f, -4.63571437e-02f, -2.60660406e-02f, -3.33844870e-02f, -4.68771458e-02f, 1.68523695e-02f,
  -8.12249165e-03f, -7.72990584e-02f, 5.56858368e-02f, -2.80006956e-02f, 5.84908575e-02f, -2.35044882e-02f, -3.66697572e-02f, -5.41046588e-03f, -1.11278988e-01f, -5.41987941e-02f,
  -2.97070071e-02f, -1.74275950e-01f, 1.47875547e-02f, -1.09210677e-01f, -5.41091450e-02f, -6.89978972e-02f, -1.63478043e-03f, -1.59356311e-01f, -1.43948928e-01f, -1.08493052e-01f,
  -9.22361463e-02f, 1.79411978e-01f, 1.41799510e-01f, -9.46956575e-02f, 3.06843996e-01f, 1.71225935e-01f, -1.81481257e-01f, -5.32394089e-02f, -1.10100411e-01f, -1.73382744e-01f,
  -3.41669321e-02f, -1.65694281e-01f, 9.33379605e-02f, -1.95934027e-01f, -6.39840141e-02f, -1.11792214e-01f, 5.20176366e-02f, 4.90126312e-02f, -5.89281283e-02f, -1.07286836e-03f,
  -2.11039275e-01f, -1.13210499e-01f, -5.66361658e-02f, -4.63277195e-03f, -8.66822340e-03f, 3.35906632e-02f, 2.81804074e-02f, 1.02316961e-01f, -2.31816433e-02f, -9.41461069e-04f,
  8.70615914e-02f, -3.88733856e-02f, -4.66593839e-02f, 3.75115797e-02f, -5.20424619e-02f, -2.82732565e-02f, -9.28610377e-03f, -4.81739827e-02f, 2.88920272e-02f, 3.55309411e-03f,
  -1.70472311e-03f, -7.66425952e-02f, 9.69197229e-03f, -5.00252247e-02f, 7.14496374e-02f, -1.06706828e-01f, 5.39816869e-03f, 1.28849268e-01f, -2.16384567e-02f, -2.21153181e-02f,
  -3.52148376e-02f, -1.58336107e-02f, -7.44145410e-03f, -7.56469369e-02f, -3.94775756e-02f, -8.14301744e-02f, -1.16430940e-02f, -3.42059396e-02f, 6.17057756e-02f, 5.32957492e-03f,
  1.59685835e-02f, -6.46377429e-02f, -2.85307635e-02f, 2.83726323e-02f, -4.08140123e-02f, -3.15250307e-02f, -8.47893607e-05f, -2.45361105e-02f, -3.11009474e-02f, 7.04249833e-03f,
  2.25000712e-03f, 1.59870125e-02f, -4.38528806e-02f, 6.71859905e-02f, -6.17206506e-02f, 8.80594701e-02f, -3.15203033e-02f, -2.35194340e-02f, -3.64290811e-02f, 8.44839737e-02f,
  -1.41129747e-01f, -1.64023638e-01f, -3.03848349e-02f, -5.95004596e-02f, -4.61877584e-02f, 7.25726550e-03f, 5.47832297e-03f, 3.22868605e-03f, -9.91091728e-02f, -1.01622008e-02f,
  -6.12806678e-02f, 6.32067397e-03f, -6.53628558e-02f, -1.45375198e-02f, -1.18811075e-02f, -8.42314735e-02f, -8.02854076e-02f, -7.65456557e-02f, -2.89954338e-02f, -1.80963986e-02f,
  -1.57083198e-02f, 3.11812051e-02f, 6.61072955e-02f, 2.23517325e-03f, 9.97613594e-02f, -1.64988562e-02f, 1.82891078e-02f, 1.20437297e-03f, 4.72609065e-02f, -2.50300299e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.96122965e-02f, 9.57902446e-02f, 6.04260974e-02f, 8.73712078e-03f, 2.24927261e-01f, 1.52882352e-01f, 6.79948851e-02f, 1.09231412e-01f, 3.59840281e-02f, 8.92026201e-02f,
  3.52162123e-02f, 8.42547938e-02f, 1.61555499e-01f, 3.92853692e-02f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  6.20660260e-02f, -1.69097434e-03f, -3.11573651e-02f, 4.79158685e-02f, -4.61873673e-02f, -1.39097283e-02f, -4.09470312e-02f, -6.87762648e-02f, -5.77579588e-02f, 8.25021192e-02f,
  6.57703727e-02f, -2.98870291e-04f, -2.13109981e-02f, -2.16821089e-01f, -9.86274630e-02f, -5.90100959e-02f, 1.67070162e-02f, -5.58787361e-02f, -8.01586604e-04f, -4.97382954e-02f,
  -5.23414761e-02f, 4.00816649e-02f, 8.10217559e-02f, 1.02389865e-01f, 4.17086929e-02f, -1.17117941e-01f, 8.35493729e-02f, -1.20918736e-01f, 7.66788647e-02f, 1.23691432e-01f,
  -3.39728780e-02f, -3.48752877e-03f, 8.96673929e-03f, 1.11799322e-01f, -1.67851802e-02f, -4.86343168e-02f, 1.17621357e-02f, -4.78553725e-03f, -7.67611489e-02f, -1.11081749e-02f,
  1.18582897e-01f, 1.71040669e-02f, -1.37242645e-01f, -1.52544618e-01f, -9.08864569e-03f, -1.38087258e-01f, 5.39910374e-03f, -1.68614745e-01f, -5.66044413e-02f, 4.84009236e-02f,
  -9.26211253e-02f, -1.30330458e-01f, -3.99943441e-02f, -6.84125815e-03f, -5.73570840e-02f, -3.00963372e-01f, -6.42290860e-02f, 1.82366177e-01f, -1.04685776e-01f, 3.93693056e-03f,
  -1.29028121e-02f, 1.07043264e-02f, 6.78705722e-02f, -2.88018901e-02f, 4.86110039e-02f, -8.52256417e-02f, -3.65613885e-02f, 3.54588181e-02f, 1.78508423e-02f, -2.16285381e-02f,
  3.73645611e-02f, -5.61520234e-02f, 2.93591823e-02f, 6.00012019e-02f, -1.23534076e-01f, -2.55239699e-02f, 6.88426942e-02f, -8.20699856e-02f, 3.15173566e-02f, 4.67795972e-03f,
  9.27711744e-03f, -1.38971042e-02f, 7.74426162e-02f, 2.72090826e-02f, 5.79446815e-02f, -3.32016801e-03f, -1.15130115e-02f, 3.87821496e-02f, -4.89694960e-02f, -1.27812877e-01f,
  6.91266507e-02f, -4.18178998e-02f, -1.36742806e-02f, -2.57248636e-02f, 1.57462180e-01f, 1.08017936e-01f, -3.39065157e-02f, 6.53399229e-02f, 1.79564491e-01f, 1.29957721e-01f,
  -1.66719958e-01f, 9.24139321e-02f, 4.61685695e-02f, 1.38867565e-03f, 6.53561801e-02f, -4.26188409e-02f, -2.64584906e-02f, -1.20581277e-01f, 3.27059254e-02f, -2.92893983e-02f,
  -1.85348168e-02f, -8.41375142e-02f, -1.83102891e-01f, -1.17825083e-01f, -3.23405932e-03f, -5.06000593e-02f, -1.64055191e-02f, 6.72915876e-02f, -1.12331589e-03f, 1.77349404e-01f,
  -1.29688963e-01f, 4.11817208e-02f, -4.90287468e-02f, -7.50309452e-02f, 1.44666016e-01f, 6.49414361e-02f, 9.04320329e-02f, 1.85912117e-01f, 1.00830859e-02f, 1.29253659e-02f,
  2.71906033e-02f, -7.75668025e-02f, 1.75886210e-02f, -1.05826659e-02f, -2.89273784e-02f, 4.98992763e-02f, -3.15475203e-02f, -7.16793463e-02f, -3.58273759e-02f, -5.70236780e-02f,
  -4.99303173e-03f, 8.94562081e-02f, 1.29228234e-02f, -7.28564262e-02f, -6.56630620e-02f, 1.61446817e-02f, -1.17149726e-01f, -9.21514705e-02f, 2.31012981e-03f, 1.99156143e-02f,
  -4.93305847e-02f, -5.75997727e-03f, -3.41992937e-02f, 2.49194354e-02f, -1.01670455e-02f, 5.80890924e-02f, 3.45501043e-02f, -1.44706383e-01f, 1.52390627e-02f, 7.33274221e-02f,
  -5.23724556e-02f, -1.45093049e-03f, 7.12579396e-03f, -1.36220351e-01f, 1.32213220e-01f, -1.95630156e-02f, 6.33766130e-02f, -6.60627484e-02f, -1.13028906e-01f, 7.97012879e-04f,
  3.90004553e-02f, 2.30602566e-02f, 1.11200679e-02f, 8.68414715e-02f, -1.26705896e-02f, 9.80036259e-02f, 6.83364049e-02f, -4.05663438e-02f, 1.90200731e-01f, 1.34461403e-01f,
  6.90858290e-02f, 8.34604502e-02f, -7.11042807e-02f, 2.14206688e-02f, 9.92482454e-02f, -1.16602860e-01f, 1.61854923e-01f, -6.07720427e-02f, -2.39332560e-02f, 5.35582788e-02f,
  -1.34942353e-01f, -4.61805984e-03f, 3.25005017e-02f, -7.88893476e-02f, -1.79382011e-01f, -2.60664877e-02f, 3.66857611e-02f, 6.35589585e-02f, 3.08386181e-02f, -8.40961486e-02f,
  -9.70541686e-02f, 7.42631555e-02f, 5.41482829e-02f, 7.45987222e-02f, 3.51895280e-02f, -1.25199705e-01f, 2.77341846e-02f, 2.10346933e-02f, -2.92463917e-02f, -6.60568401e-02f,
  -5.55120222e-02f, -7.74258226e-02f, -2.90405918e-02f, 4.38972423e-03f, 2.94884499e-02f, 1.22244293e-02f, 1.58515405e-02f, -1.71110317e-01f, 1.93227798e-01f, -9.54021513e-02f,
  8.94007981e-02f, 1.65720478e-01f, 1.88230891e-02f, 1.19983591e-02f, 7.68178627e-02f, 1.82562962e-01f, -6.87007457e-02f, -8.80037528e-03f, 1.28797635e-01f, -9.52660739e-02f,
  1.74907949e-02f, 1.14080548e-01f, 1.06187887e-01f, 1.05081543e-01f, -1.39622092e-01f, -1.85808480e-01f, 1.34176821e-01f, -7.04148561e-02f, 1.33819029e-01f, -9.44495052e-02f,
  -2.22820248e-02f, 1.48630053e-01f, -4.11747023e-02f, -1.44709513e-01f, 1.11856768e-02f, 4.95961914e-03f, -6.34467900e-02f, -2.44112417e-01f, -8.82927403e-02f, 6.18061610e-02f,
  -2.03776166e-01f, -8.15446153e-02f, 2.86278110e-02f, 8.82085487e-02f, 9.01023224e-02f, -1.06991261e-01f, -2.83729006e-02f, -6.61798567e-02f, -3.72314379e-02f, 6.02754876e-02f,
  7.22754514e-03f, -2.61674859e-02f, -1.47044789e-02f, -5.11093326e-02f, -2.07255352e-02f, 1.39319062e-01f, 1.18623734e-01f, -2.92906761e-02f, -6.54341578e-02f, -1.53737664e-01f,
  4.84734848e-02f, -4.98009734e-02f, 1.92862656e-02f, 2.42434293e-02f, -9.34326351e-02f, -3.37870084e-02f, -1.45943448e-01f, 1.00947499e-01f, 2.00229764e-01f, 9.40085202e-02f,
  2.32219119e-02f, -1.26310527e-01f, -3.01979668e-03f, -8.98316782e-03f, 4.13486660e-02f, 1.35156587e-01f, -1.49260536e-01f, 4.77095507e-02f, 1.08653000e-02f, 1.14972062e-01f,
  5.77615872e-02f, 1.01081887e-02f, -5.70164025e-02f, -7.02335313e-02f, -1.49199024e-01f, 1.18924223e-01f, 8.78554955e-02f, 4.97878082e-02f, -2.85051148e-02f, -1.36907250e-01f,
  -3.38272378e-03f, -4.52983230e-02f, 5.92512712e-02f, -6.38766587e-02f, 2.11418904e-02f, -1.27615407e-02f, 6.04346991e-02f, -9.38008875e-02f, -7.12236613e-02f, 4.99855950e-02f,
  -9.34366062e-02f, -1.35647908e-01f, -1.54872164e-01f, 1.21448316e-01f, 5.30093573e-02f, -9.13381353e-02f, 6.34472743e-02f, -5.42077534e-02f, 1.21775351e-01f, 7.41305128e-02f,
  1.56677049e-02f, 4.09470536e-02f, 1.46714896e-01f, -7.71428749e-04f, 7.89730996e-02f, 3.47622074e-02f, 4.47539501e-02f, 1.30752966e-01f, 1.46647925e-02f, 3.82555947e-02f,
  2.71412581e-02f, 6.04027286e-02f, 1.25596225e-01f, 1.15954585e-01f, 1.35595024e-01f, 9.72117186e-02f, 1.19722135e-01f, 8.53150114e-02f, 1.33587271e-01f, 7.83170983e-02f,
  9.92231295e-02f, 3.74606741e-03f, -1.24887422e-01f, -3.35217849e-03f, -1.80804599e-02f, -3.61479893e-02f, 3.39893438e-02f, -5.09876572e-02f, -3.41176912e-02f, -2.49358211e-02f,
  1.73561983e-02f, 5.67775555e-02f, -6.19263574e-02f, 2.74667162e-02f, -5.44955805e-02f, 8.13936368e-02f, -2.82084779e-03f, 1.08553909e-01f, -2.31983848e-02f, -7.53396302e-02f,
  -1.56555846e-02f, -6.53320551e-02f, 1.35189548e-01f, -1.55248999e-04f, -8.20178539e-02f, 1.42666297e-02f, -7.87843019e-02f, 3.74004766e-02f, -1.59754977e-02f, 8.41627270e-03f,
  -8.02537873e-02f, 4.53281030e-02f, 1.05928600e-01f, -1.07728489e-01f, 2.49316409e-01f, 5.02326153e-02f, -7.83423185e-02f, -6.35076538e-02f, -1.16941966e-01f, 1.67194396e-01f,
  -3.83223221e-02f, 3.58797126e-02f, -3.39189135e-02f, -1.32120714e-01f, -2.83058155e-02f, -2.30383091e-02f, -2.49044467e-02f, 4.77643386e-02f, -1.24272043e-02f, -1.45405293e-01f,
  5.60825225e-03f, -1.24409832e-01f, 1.16657093e-01f, -6.15233108e-02f, 3.68709229e-02f, -2.32331157e-02f, 1.75680485e-04f, 3.73066291e-02f, -1.12537993e-02f, 1.58129316e-02f,
  -2.81357896e-02f, -3.84035967e-02f, 9.21203047e-02f, 1.14831112e-01f, -6.39298633e-02f, 6.46287948e-02f, 1.61720082e-01f, 5.23701720e-02f, 1.36987954e-01f, 9.11348388e-02f,
  -9.20632854e-02f, 1.46050500e-02f, -2.07830533e-01f, 1.88028917e-01f, -1.14075080e-01f, -1.08413182e-01f, 1.99050784e-01f, -9.18519124e-02f, 6.61031306e-02f, 1.53463319e-01f,
  -1.02347858e-01f, 4.34112921e-02f, -1.14932396e-01f, 4.34160456e-02f, 1.14874654e-02f, 2.73779258e-02f, -1.47370979e-01f, 1.67653132e-02f, -1.78259090e-01f, -1.22593574e-01f,
  -3.43030132e-02f, -1.51251465e-01f, -8.02307650e-02f, 2.94133984e-02f, -4.79329936e-02f, -1.25824004e-01f, -1.08105078e-01f, -1.39604434e-01f, 2.04362869e-01f, 6.06262088e-02f,
  -1.25032514e-01f, 2.12695137e-01f, -1.30220875e-01f, -1.35909510e-03f, 2.08579779e-01f, -2.18996018e-01f, 2.55656987e-01f, 2.05987737e-01f, -6.81830198e-02f, 3.81816290e-02f,
  9.22511332e-03f, 5.72851188e-02f, 1.20041827e-02f, 8.38585291e-03f, 2.43591657e-03f, 9.60749835e-02f, -2.85417531e-02f, 1.59666482e-02f, -1.78438067e-01f, 1.13265507e-01f,
  -3.99816334e-02f, -8.13217834e-02f, -5.94995245e-02f, 4.70126569e-02f, 6.40247837e-02f, -7.08097294e-02f, -1.48060536e-02f, 5.65427616e-02f, 1.83942560e-02f, -5.31172007e-02f,
  -2.02997521e-01f, 1.52399037e-02f, -5.71070202e-02f, -6.57646880e-02f, -1.25474064e-02f, -1.08672185e-02f, 9.19982567e-02f, -4.85171080e-02f, 1.56166196e-01f, 5.04521392e-02f,
  -6.31116554e-02f, 3.14831026e-02f, -5.55262491e-02f, -3.53003889e-02f, 7.06631020e-02f, 2.78897360e-02f, 6.48171529e-02f, -8.36311579e-02f, -3.09629291e-02f, -6.91079115e-03f,
  8.28830153e-02f, 8.83579534e-03f, 6.16814122e-02f, 9.02491063e-02f, -5.14553636e-02f, 1.01364963e-01f, -3.31387185e-02f, -5.58059514e-02f, -9.15365890e-02f, 8.69712606e-02f,
  1.14263870e-01f, -1.21027745e-01f, 3.56479101e-02f, -2.69838031e-02f, 4.62455079e-02f, -1.34200916e-01f, -5.34675941e-02f, -2.91202608e-02f, -1.62265122e-01f, 2.14421749e-01f,
  -1.29746199e-01f, -1.34881020e-01f, -3.02248877e-02f, -5.66169284e-02f, -1.00443423e-01f, -2.33842675e-02f, -3.80508006e-02f, -2.34597288e-02f, 2.95481104e-02f, -1.38419211e-01f,
  -5.19926585e-02f, 1.06270518e-02f, -4.16820757e-02f, -1.72701664e-02f, -2.40851864e-02f, -9.49273780e-02f, -1.14153355e-01f, -5.88425994e-02f, -8.49818140e-02f, 7.03361072e-03f,
  -6.25202730e-02f, -4.98642139e-02f, 2.32657604e-02f, 9.47364897e-05f, 1.03043079e-01f, -5.65862954e-02f, 3.90454829e-02f, -4.21320125e-02f, -8.20380729e-03f, 9.36861932e-02f,
  -4.28712703e-02f, 3.88511382e-02f, -2.91446131e-02f, 1.36056952e-02f, 2.36797091e-02f, 5.23820333e-02f, 7.59564862e-02f, 3.26175243e-02f, -7.03040659e-02f, -7.80310929e-02f,
  2.76427083e-02f, 1.33156776e-02f, 4.41262126e-02f, 1.13016888e-02f, -1.30409613e-01f, -6.82431906e-02f, -7.44670555e-02f, -6.58446774e-02f, -6.83596777e-03f, -8.93985182e-02f,
  1.10340761e-02f, 1.56238656e-02f, 1.26653582e-01f, -7.22828656e-02f, -5.96585907e-02f, 1.89841568e-01f, -1.77402645e-01f, 1.93685070e-02f, -1.57465577e-01f, 7.14276284e-02f,
  1.27686068e-01f, -1.04385830e-01f, 1.09309711e-01f, -3.47914025e-02f, 5.94313331e-02f, 2.09809154e-01f, 2.88017802e-02f, -1.22820092e-02f, -1.19043261e-01f, -3.49193551e-02f,
  -1.57199223e-02f, 2.00448409e-02f, -3.44907865e-02f, -4.76288572e-02f, 1.51141565e-02f, 8.57961364e-03f, 1.21129476e-01f, 1.00270491e-02f, -1.08150005e-01f, -1.96213454e-01f,
  -1.23164177e-01f, -7.40071312e-02f, -2.49559004e-02f, 4.81113009e-02f, -1.32079542e-01f, -2.03551305e-03f, -8.31383169e-02f, 1.21565582e-02f, 1.80951394e-02f, -3.35069150e-02f,
  9.06975046e-02f, -9.82126817e-02f, 1.42740473e-01f, -6.66964427e-02f, 1.26866564e-01f, 7.70534948e-02f, -5.19448631e-02f, 1.34796975e-03f, -4.42474186e-02f, 1.16292387e-01f,
  -4.95647565e-02f, -8.34643021e-02f, 1.30463764e-01f, -5.61514981e-02f, -3.07554808e-02f, 8.89048949e-02f, 7.99576044e-02f, 5.26766069e-02f, -6.01769164e-02f, -5.47983982e-02f,
  8.94432738e-02f, -3.27402130e-02f, 9.53711569e-02f, -8.23697969e-02f, 4.66714501e-02f, 1.46053493e-01f, 7.78519781e-03f, -1.23414800e-01f, -1.65125374e-02f, 1.79090854e-02f,
  -1.46609500e-01f, -2.02756539e-01f, 1.43981352e-01f, 1.58792838e-01f, 5.20256273e-02f, -1.47343978e-01f, 4.54924861e-03f, 4.94542196e-02f, 5.47711588e-02f, -1.11828409e-01f,
  -5.33057302e-02f, 6.14683479e-02f, 1.32039323e-01f, 5.61222844e-02f, -5.44060022e-03f, 3.21011692e-02f, 9.95124038e-03f, 1.20033965e-01f, -8.41301924e-04f, -1.06109560e-01f,
  -7.47119412e-02f, -2.17795298e-02f, 6.33867308e-02f, 6.64607212e-02f, -2.95920763e-02f, -1.79024215e-03f, 9.44540128e-02f, -5.63874729e-02f, 5.87654300e-02f, -1.46635557e-02f,
  3.78060602e-02f, 9.38232616e-03f, -2.41922997e-02f, -1.45903667e-02f, -6.32607415e-02f, 6.32682368e-02f, -4.50646095e-02f, -8.22185259e-03f, 5.18346317e-02f, -5.33536030e-03f,
  7.92554095e-02f, 1.85928270e-02f, -9.49396342e-02f, -5.80377094e-02f, 3.59993204e-02f, -5.31395264e-02f, -3.47358957e-02f, 6.31312504e-02f, 4.72898856e-02f, -1.08791612e-01f,
  -1.11400060e-01f, 1.63039882e-02f, 1.26939556e-02f, 7.08707646e-02f, -5.40017113e-02f, 7.70775005e-02f, -6.00033440e-02f, 9.62967575e-02f, -6.21444508e-02f, 8.74204859e-02f,
  -3.77672650e-02f, 9.88198668e-02f, 7.77629670e-03f, -2.02160716e-01f, 1.45526186e-01f, -5.72001375e-02f, 4.49234359e-02f, -8.59118626e-02f, -1.44581601e-01f, 1.39640346e-01f,
  -1.21603794e-01f, 1.22839004e-01f, -1.16584167e-01f, 2.24914812e-02f, -4.87391166e-02f, 6.50004223e-02f, 7.56692812e-02f, 4.06007655e-02f, 4.84936610e-02f, -6.26289919e-02f,
  1.38623426e-02f, -2.51549501e-02f, 1.39318919e-02f, -1.86808541e-01f, 3.83787416e-02f, -3.70858773e-03f, -9.83755365e-02f, 4.81915884e-02f, -4.61139195e-02f, -5.60280234e-02f,
  1.99903287e-02f, -2.93722879e-02f, -4.54285741e-02f, -1.91885568e-02f, 9.31731053e-03f, 2.07830723e-02f, 1.54078901e-01f, -3.56665738e-02f, -2.60505714e-02f, 8.92419517e-02f,
  -8.87319669e-02f, 1.61709547e-01f, -5.09144440e-02f, -6.73431307e-02f, -2.18162924e-01f, -1.03325099e-01f, 6.11241125e-02f, -1.18175775e-01f, -1.75712243e-01f, -1.37522593e-01f,
  1.16434433e-01f, -2.06803471e-01f, 1.41234085e-01f, -9.76987407e-02f, -1.55520648e-01f, -8.02672748e-03f, -5.92129305e-02f, 1.21293493e-01f, -3.44230346e-02f, 3.36946398e-02f,
  -1.15967415e-01f, 4.26196726e-03f, 1.38416544e-01f, 2.35240102e-01f, 1.82526454e-01f, 1.17179483e-01f, 5.13161235e-02f, 2.32945550e-02f, -1.22457922e-01f, 3.48047577e-02f,
  6.69606626e-02f, -3.66427749e-02f, 1.24478102e-01f, 1.31585300e-01f, -5.57469167e-02f, -4.33315299e-02f, -1.14897244e-01f, 9.67290327e-02f, 2.43758559e-02f, 2.53228862e-02f,
  1.35541588e-01f, -3.47358063e-02f, -5.94333485e-02f, 9.92031470e-02f, -4.29969579e-02f, 1.57773152e-01f, 5.66406138e-02f, -1.43105106e-03f, -9.89544094e-02f, 1.01199627e-01f,
  -3.27892303e-02f, 4.22709621e-02f, -1.06851719e-02f, -3.69799137e-02f, 1.18469074e-01f, -3.32042351e-02f, 1.72010306e-02f, 1.52182877e-02f, -2.58990694e-02f, 4.64511439e-02f,
  -1.64280847e-01f, 1.75904147e-02f, -3.69710959e-02f, -5.80693223e-03f, -2.33375747e-02f, 9.03117657e-02f, 1.19532496e-01f, -2.03454003e-01f, 1.19944759e-01f, -5.62776253e-03f,
  -1.83892231e-02f, -7.34104738e-02f, -1.53358966e-01f, 4.43294598e-03f, 1.40417367e-01f, -5.39144725e-02f, 1.54284611e-01f, -5.18325269e-02f, -5.14538586e-02f, -1.47211663e-02f,
  1.24030776e-01f, 6.15904294e-02f, 1.26291484e-01f, 5.42913899e-02f, -3.93711515e-02f, 2.01515660e-01f, 5.16426340e-02f, 3.65475193e-02f, 4.17468697e-02f, 2.07710549e-01f,
  1.79629490e-01f, 2.55585909e-02f, -1.08405098e-01f, -3.10091432e-02f, 1.75397769e-01f, -1.44126981e-01f, -4.56882231e-02f, -2.40199835e-04f, -1.34115934e-01f, 2.64121354e-01f,
  -1.70869887e-01f, -1.40686333e-01f, -1.88443903e-02f, 7.12416470e-02f, 5.36271650e-03f, -4.48839627e-02f, -5.97724877e-02f, -4.13830541e-02f, 6.77400604e-02f, -5.54889615e-04f,
  -5.98771796e-02f, -9.61962715e-03f, 1.55134931e-01f, 3.09057962e-02f, 2.21137013e-02f, -2.95826439e-02f, -3.44332382e-02f, -1.18108220e-01f, 2.37578470e-02f, 8.98665488e-02f,
  -1.39769658e-01f, 2.26448104e-02f, -3.54754888e-02f, -1.91307522e-03f, 9.31292474e-02f, -1.31683992e-02f, -2.31944434e-02f, 3.95512534e-03f, -4.66446206e-02f, 7.41513968e-02f,
  -1.26205096e-02f, 1.18138954e-01f, -1.84034944e-01f, -1.77860335e-01f, -2.52002850e-02f, -4.24716175e-02f, 9.27894562e-02f, -7.61763975e-02f, -5.57128452e-02f, -6.77898154e-02f,
  -2.03325730e-02f, -3.86403129e-02f, -8.07555839e-02f, -5.73163442e-02f, -1.04767606e-02f, -1.92828085e-02f, -1.15123149e-02f, -1.75138876e-01f, -9.22224373e-02f, -6.61177486e-02f,
  -3.23287211e-02f, 1.14046238e-01f, 1.09947689e-01f, 3.45322900e-02f, -6.54791519e-02f, 4.26108167e-02f, -7.85696283e-02f, -1.68813005e-01f, -1.52432155e-02f, 5.87636679e-02f,
  -4.77525890e-02f, 2.13148203e-02f, -1.55747151e-02f, -1.00749068e-01f, -3.92516553e-02f, 1.23970166e-01f, -2.70947833e-02f, -1.12511851e-01f, -1.52150497e-01f, 6.93120062e-02f,
  -1.00733727e-01f, 2.28830390e-02f, 4.93347757e-02f, -1.45869497e-02f, 5.58359921e-02f, 5.92765361e-02f, -8.55748281e-02f, 1.21679520e-02f, 1.02396030e-02f, -1.23825327e-01f,
  5.98239079e-02f, -5.58535382e-03f, -3.71462340e-03f, -5.69922328e-02f, 5.34780789e-03f, 1.68078765e-02f, 1.05361015e-01f, 3.29072140e-02f, -5.11586815e-02f, -3.87495868e-02f,
  -2.59835143e-02f, -1.51239067e-01f, 1.00566328e-01f, -4.79026623e-02f, -4.23071766e-03f, 7.36905187e-02f, 2.40000293e-01f, 2.12442040e-01f, 8.67913067e-02f, 3.08850929e-02f,
  2.43311271e-01f, 1.75869629e-01f, -2.17413470e-01f, 1.74063578e-01f, 3.14727798e-02f, 9.10378322e-02f, 2.62072086e-02f, -4.85269986e-02f, -5.70542403e-02f, 3.46958898e-02f,
  -5.11781946e-02f, -1.56028308e-02f, -6.66742073e-03f, -4.45462503e-02f, -1.93745762e-01f, -2.23080456e-01f, -5.89376949e-02f, -1.50524795e-01f, -8.08991939e-02f, 1.16487451e-01f,
  -4.56664199e-03f, 2.56502092e-01f, -8.86134654e-02f, 8.81350115e-02f, -3.10605522e-02f, -7.74921924e-02f, 2.53625810e-01f, 3.93257812e-02f, 2.41858095e-01f, 2.42868036e-01f,
  -1.05386833e-02f, 4.03735973e-02f, 6.66859075e-02f, 3.91711257e-02f, 2.52282675e-02f, -6.03325740e-02f, 6.94985986e-02f, -4.69800606e-02f, 2.60126274e-02f, 1.34884631e-02f,
  1.03767298e-01f, -4.34059687e-02f, 5.40427677e-02f, 8.79004151e-02f, -4.50666510e-02f, -1.82967149e-02f, 6.36648238e-02f, -3.99677977e-02f, 1.25074387e-03f, 5.30854128e-02f,
  3.11101675e-02f, 2.68062036e-02f, 9.15273726e-02f, -3.39009240e-02f, -2.36785207e-02f, 1.14787668e-01f, -7.29835927e-02f, 1.74872465e-02f, -8.02853480e-02f, 2.38836054e-02f,
  -2.00072050e-01f, -1.05668537e-01f, -7.20692277e-02f, -8.56845379e-02f, 6.45616427e-02f, -2.03901008e-02f, -1.53110353e-02f, -6.68613836e-02f, 6.39578179e-02f, -4.56129462e-02f,
  -1.27810642e-01f, 4.45778742e-02f, -6.72122985e-02f, 6.58572987e-02f, -1.09286621e-01f, -2.10060682e-02f, -5.09206876e-02f, -1.89911034e-02f, 7.97866508e-02f, 1.43276066e-01f,
  1.25485277e-02f, 6.30193204e-02f, -4.48614694e-02f, 2.58393493e-02f, -1.53693631e-02f, -3.32658701e-02f, -7.70300254e-02f, 3.73517983e-02f, 5.16697811e-03f, 1.25907660e-01f,
  -6.52062520e-02f, -7.48354644e-02f, -7.13568181e-02f, 1.06382936e-01f, -8.20610225e-02f, -3.21961753e-02f, 3.30735780e-02f, -5.20891100e-02f, 5.66124059e-02f, -7.52383545e-02f,
  9.20512248e-03f, 9.51607451e-02f, 8.21283832e-02f, -1.42577738e-01f, -3.89652364e-02f, -1.02583300e-02f, -6.61924388e-03f, 1.80850893e-01f, -4.81006829e-03f, -5.50524667e-02f,
  1.37213962e-02f, -5.35300039e-02f, 1.24841498e-03f, -6.85070828e-02f, -1.01391509e-01f, -4.99454280e-03f, -5.75096458e-02f, -1.34326339e-01f, 1.60894282e-02f, 1.20181940e-01f,
  -5.00069745e-02f, 1.24130651e-01f, -6.63683191e-02f, -1.59360260e-01f, -1.25133609e-02f, -2.26699505e-02f, 8.50190073e-02f, -1.49217546e-01f, -2.40702033e-01f, 3.03771049e-02f,
  1.15723893e-01f, -8.14915448e-02f, -7.60117220e-03f, 6.39386103e-02f, -9.82836038e-02f, 6.09242953e-02f, 1.38699710e-01f, 1.73645720e-01f, 5.25444979e-04f, 1.21342264e-01f,
  6.98882937e-02f, 1.87581688e-01f, 1.13071918e-01f, -1.57541987e-02f, 2.15890165e-02f, 5.68835996e-02f, 3.93189536e-03f, -1.10003166e-01f, 1.12077616e-01f, 2.43589729e-01f,
  7.91777521e-02f, -1.09330058e-01f, 1.21621251e-01f, 7.19895586e-02f, 2.09185928e-02f, -6.08288310e-02f, -1.09133227e-02f, -1.14651538e-01f, 2.20520329e-02f, -8.40982515e-03f,
  -8.81525800e-02f, 2.17823312e-02f, 1.00853266e-02f, -4.22380269e-02f, 6.28341660e-02f, -1.71177581e-01f, 8.40331689e-02f, 6.52932823e-02f, 8.28338414e-02f, -9.55226049e-02f,
  7.54905352e-03f, -1.11853123e-01f, -2.57510487e-02f, 2.21882481e-02f, -5.25427237e-02f, 2.28478480e-02f, 2.38130186e-02f, 4.61035315e-03f, -7.16454312e-02f, -1.39633950e-03f,
  1.48141444e-01f, -2.95816362e-02f, 6.03566468e-02f, 6.51277080e-02f, 2.73256190e-02f, 1.42467720e-02f, -1.05092011e-01f, 4.35733944e-02f, 5.99465668e-02f, -2.24906132e-02f,
  1.45117581e-01f, 3.79996337e-02f, 2.09309354e-01f, 4.84397635e-02f, -2.00287685e-01f, 1.46698030e-02f, -1.65516883e-01f, 1.49042577e-01f, 6.64744452e-02f, -5.78006655e-02f,
  -6.65602759e-02f, 1.07608819e-02f, -1.15866251e-01f, -7.03265592e-02f, 1.23605013e-01f, -9.11441520e-02f, -9.07460451e-02f, -1.27630085e-01f, 5.02250157e-02f, -1.02189690e-01f,
  -1.18714556e-01f, -1.80629250e-02f, 9.70387161e-02f, 1.54031575e-01f, -1.21578023e-01f, 1.49924427e-01f, 1.19156629e-01f, -1.20495729e-01f, 2.76895314e-01f, -9.24668536e-02f,
  2.15970978e-01f, 1.62174299e-01f, 5.74521907e-02f, -8.77383500e-02f, -9.57854316e-02f, -4.99601066e-02f, 1.48689402e-02f, -1.61135737e-02f, -5.11458591e-02f, 2.06525885e-02f,
  1.48747684e-02f, -2.01761927e-02f, 7.91974068e-02f, -3.66932563e-02f, 5.15349396e-03f, -2.25015264e-02f, -3.21015343e-02f, -3.97372022e-02f, -4.32631187e-02f, 5.01243360e-02f,
  -1.47562280e-01f, 4.59622731e-03f, -1.47213265e-01f, 1.42894089e-02f, 1.08077601e-01f, -1.22541632e-03f, 9.14328620e-02f, 6.46762922e-02f, 6.25904053e-02f, 1.14652671e-01f,
  6.97800517e-02f, 5.63091263e-02f, -1.62912756e-01f, -7.56410137e-03f, 6.49811178e-02f, -1.15641616e-02f, -1.66337296e-01f, -6.18709736e-02f, 1.69360906e-01f, -1.07504435e-01f,
  -1.72473326e-01f, 1.17126212e-01f, 6.13234900e-02f, 1.30170166e-01f, -3.82838063e-02f, 7.28034452e-02f, 5.35656698e-03f, -5.12267314e-02f, 1.53755575e-01f, 6.71476796e-02f,
  1.06220707e-01f, 1.11415640e-01f, 2.29671091e-01f, -2.64443457e-02f, -1.60311997e-01f, 5.24915829e-02f, -2.37931117e-01f, -2.10585352e-02f, 1.54484302e-01f, 9.74445492e-02f,
  1.90457627e-01f, -9.00111198e-02f, 9.67565924e-02f, -1.09849356e-01f, -2.29663495e-02f, 3.25943157e-02f, 1.61425993e-02f, -8.27525556e-02f, -5.62637150e-02f, 6.61770105e-02f,
  -5.72092980e-02f, 7.35193938e-02f, 3.80582549e-03f, 3.26973833e-02f, -1.10986002e-01f, 1.79754913e-01f, -5.68813905e-02f, -3.44243869e-02f, 3.95159945e-02f, -1.50395706e-01f,
  -1.44225555e-02f, 5.97256236e-02f, -9.63650197e-02f, 2.96857581e-02f, 3.71486805e-02f, -5.48244454e-02f, -2.81973779e-02f, 7.05544800e-02f, -1.23015448e-01f, 1.00486390e-01f,
  7.95249268e-02f, -1.66371375e-01f, 8.79241228e-02f, -1.49873406e-01f, 6.03778660e-02f, -2.71336697e-02f, 2.22205341e-01f, 1.54818699e-01f, 1.66140758e-02f, 9.11920443e-02f,
  1.19496144e-01f, 1.50115922e-01f, -7.48115107e-02f, 1.80716366e-01f, -8.93292129e-02f, 1.22926645e-01f, 7.49309734e-02f, 1.37647064e-02f, 1.56949963e-02f, -1.19877569e-01f,
  9.43821073e-02f, -6.26016185e-02f, 1.14991680e-01f, 3.51594873e-02f, -1.48358911e-01f, -2.16445610e-01f, -1.45797908e-01f, -1.59381241e-01f, 1.29734864e-02f, 1.04534373e-01f,
  2.58226916e-02f, -3.28214541e-02f, -9.63267125e-03f, 8.42943564e-02f, -1.23633631e-01f, -3.68086360e-02f, 5.08931279e-02f, 9.02157724e-02f, 4.35650311e-02f, -6.71229959e-02f,
  4.46185842e-02f, 3.15303095e-02f, 2.82941572e-02f, 2.34191380e-02f, 2.69324146e-02f, 3.11197783e-03f, -3.19118947e-02f, 4.88046333e-02f, 1.56974047e-02f, 1.22051254e-01f,
  -2.76790671e-02f, 5.72559088e-02f, -3.66487205e-02f, -8.24274942e-02f, -8.82523432e-02f, 5.55797480e-02f, 1.03299059e-02f, 3.25293560e-03f, 2.91451588e-02f, 3.69855836e-02f,
  1.01772100e-01f, -9.44422279e-03f, -1.19982965e-01f, 4.06198278e-02f, -4.58251871e-02f, -1.49784833e-01f, 8.11053589e-02f, -6.45686910e-02f, 4.50842120e-02f, 5.08599216e-03f,
  9.41650122e-02f, 2.08818484e-02f, -5.68434745e-02f, 5.35227321e-02f, 1.44259885e-01f, 6.30409569e-02f, -4.96543422e-02f, -1.40448697e-02f, 1.10629752e-01f, -4.73926365e-02f,
  9.93799791e-03f, -1.29405588e-01f, -7.69108906e-02f, -2.18511939e-01f, -6.57710759e-03f, -1.28705591e-01f, -9.28780586e-02f, -6.25930950e-02f, -1.39114678e-01f, 1.28981965e-02f,
  -1.67334999e-03f, 3.96059118e-02f, 4.69593257e-02f, 1.11752376e-02f, -1.27807841e-01f, -1.68828800e-01f, -8.68757516e-02f, 1.58312339e-02f, -1.18797489e-01f, -9.76936594e-02f,
  -6.15100600e-02f, 1.28284425e-01f, -5.01303673e-02f, 4.78647910e-02f, -3.47390287e-02f, -6.84757009e-02f, 8.97586942e-02f, -4.25669178e-02f, 5.94915561e-02f, 1.19197175e-01f,
  7.02239107e-03f, 7.08963796e-02f, -2.57984083e-02f, 2.57932376e-02f, -1.52500808e-01f, -2.48905197e-02f, 7.90638253e-02f, -3.01434789e-02f, 7.72727281e-03f, -2.19027046e-02f,
  1.95609927e-02f, -8.20915923e-02f, 8.33922848e-02f, -1.67811904e-02f, -4.49596345e-03f, -9.58452448e-02f, -1.74061492e-01f, 3.71514186e-02f, -9.26850811e-02f, -3.50438543e-02f,
  6.66170493e-02f, -3.55943777e-02f, 1.41115636e-01f, -1.30877078e-01f, 1.53248504e-01f, 1.18958682e-01f, -2.33023707e-02f, -1.65737513e-02f, 4.72788066e-02f, -2.82752421e-02f,
  -1.12929968e-02f, 2.13155039e-02f, 5.77776358e-02f, -5.41601069e-02f, 1.90838985e-02f, 1.43407397e-02f, 3.82911111e-03f, 1.50849596e-02f, 1.39880151e-01f, 8.00732225e-02f,
  -3.62014845e-02f, 8.87759849e-02f, -7.11502656e-02f, -1.34446055e-01f, 7.50027038e-03f, 9.64468438e-03f, -1.84678733e-02f, -6.74784631e-02f, -6.04400449e-02f, -5.31006325e-03f,
  1.32747248e-01f, -1.05414741e-01f, 8.69473591e-02f, -8.75240117e-02f, -4.67103198e-02f, 1.21068135e-01f, -5.75684197e-02f, -6.69637695e-02f, -3.98651250e-02f, -2.32196487e-02f,
  2.03561932e-02f, 2.69324984e-02f, 4.40474413e-02f, 2.76067089e-02f, 5.27494103e-02f, 4.32289913e-02f, -3.28825116e-02f, -3.55944037e-02f, -7.28459954e-02f, -7.57489447e-03f,
  8.93896073e-02f, -6.52656108e-02f, -4.03153244e-03f, 3.26631181e-02f, 8.70658457e-02f, -3.72293629e-02f, 1.70482114e-01f, 2.98056472e-02f, 8.76305476e-02f, -9.83751728e-04f,
  -8.52383152e-02f, -9.27424245e-03f, -3.25049758e-02f, -2.96968296e-02f, 8.15752149e-02f, -1.47750661e-01f, 5.30572515e-03f, 8.60223249e-02f, 1.88497901e-01f, 5.16581982e-02f,
  -4.43267822e-02f, 3.21246572e-02f, 1.77574500e-01f, 1.35684177e-01f, -1.84486762e-01f, 1.53872639e-01f, 9.36098993e-02f, -1.07053742e-01f, 6.51725456e-02f, -7.74010792e-02f,
  2.83932425e-02f, -7.83775076e-02f, 2.17022914e-02f, 7.23383427e-02f, -1.06513865e-01f, -4.74148430e-02f, -8.21223110e-02f, -6.11529276e-02f, -2.68778741e-01f, -4.96886633e-02f,
  1.18357204e-01f, 7.29282796e-02f, 1.65334269e-01f, -7.69480616e-02f, -1.32604957e-01f, 6.98981434e-02f, -1.40221730e-01f, 3.30553986e-02f, -2.88270339e-02f, 1.19987354e-02f,
  5.27176186e-02f, 1.09332874e-01f, 6.53613657e-02f, -2.03827899e-02f, 4.65320610e-02f, 1.50126740e-02f, 1.54720349e-02f, -1.68047901e-02f, -8.27770606e-02f, -3.64280865e-02f,
  -2.09025592e-02f, -3.67454663e-02f, -4.11008410e-02f, -8.08314905e-02f, -4.35783230e-02f, 2.63626371e-02f, 1.45028057e-02f, 2.07234640e-02f, 1.41943328e-03f, 1.02072516e-02f,
  -8.67780373e-02f, -2.59480197e-02f, -4.19351906e-02f, -5.49190072e-03f, 1.13382064e-01f, 4.47464641e-03f, 6.84799552e-02f, 1.46356970e-03f, -8.40111449e-02f, 1.24411181e-01f,
  1.51765794e-02f, 3.06899324e-02f, -1.11651748e-01f, -7.50847207e-03f, -8.00051168e-02f, -4.84260730e-02f, 6.00221045e-02f, -1.63598031e-01f, 8.08455702e-03f, -9.09768417e-02f,
  4.86722291e-02f, -3.54242185e-03f, -3.08674928e-02f, -1.22247422e-02f, -1.22894876e-01f, 7.60324346e-03f, -3.85077111e-02f, 5.24933748e-02f, -4.18028571e-02f, 4.61796522e-02f,
  7.29981959e-02f, 5.51053993e-02f, 2.32997462e-01f, -7.52385035e-02f, -5.21526337e-02f, 1.68507010e-01f, -2.04212189e-01f, 8.48208740e-02f, 1.39264558e-02f, -4.98657040e-02f,
  1.90789029e-01f, -9.12710279e-02f, -2.10690722e-02f, -8.47917646e-02f, -1.54562891e-01f, 1.74695447e-01f, 1.05684847e-01f, 2.21505351e-02f, -1.14915788e-01f, 8.93119797e-02f,
  -2.62885988e-02f, -1.33633809e-02f, 4.44032298e-03f, -1.18659891e-01f, -7.35274777e-02f, 1.14236258e-01f, -6.10655658e-02f, -3.34763601e-02f, 3.39850560e-02f, -1.25088423e-01f,
  2.55599408e-03f, 5.04292957e-02f, -5.94310686e-02f, 4.16644178e-02f, -8.64370242e-02f, -6.97424263e-02f, -5.67437299e-02f, -9.00412071e-03f, 1.34203181e-01f, -2.75543425e-03f,
  4.33066338e-02f, -2.68605519e-02f, 3.09494305e-02f, -1.82763766e-02f, 7.98886493e-02f, 1.35182381e-01f, -7.26988912e-02f, -1.29424790e-02f, 4.53776754e-02f, 4.69689332e-02f,
  1.04698524e-01f, -1.91671506e-01f, 1.20941654e-01f, -9.41121653e-02f, 3.39482538e-02f, 7.28542432e-02f, 4.87289354e-02f, 1.26127660e-01f, -2.06799865e-01f, -4.78827693e-02f,
  1.20714992e-01f, 5.00050224e-02f, 1.37536034e-01f, -1.68789729e-01f, 1.24400472e-02f, 5.83957024e-02f, 9.69952121e-02f, -6.80902377e-02f, -1.40631780e-01f, 2.43663788e-01f,
  -3.12493443e-01f, -6.06735013e-02f, 1.64883211e-01f, 8.96782055e-02f, 8.34576637e-02f, -1.76435381e-01f, -1.35326488e-02f, 1.08785212e-01f, 8.05971101e-02f, 8.99083167e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.73187030e-02f, 9.17876586e-02f, 3.74007821e-02f, 4.26748535e-03f, 4.88157608e-02f, -2.44140103e-02f, 7.36020952e-02f, -1.53881209e-02f, 7.56707639e-02f, -4.28145789e-02f,
  1.35042325e-01f, 8.20439830e-02f, 3.98274511e-03f, 1.28280580e-01f, 3.67342085e-02f, 6.09374195e-02f, 6.84952810e-02f, 9.92545858e-02f, -6.03074953e-02f, 2.98001152e-02f,
  1.69463549e-02f, 1.22437842e-01f, 1.88724011e-01f, 1.39980027e-02f, 9.04829577e-02f, 1.00477599e-01f, -3.80259678e-02f, 1.02524370e-01f, -4.50335667e-02f, -2.54117455e-02f,
  -1.42140552e-01f, -1.23319022e-01f, 7.74089918e-02f, -5.33413887e-02f, -1.80478930e-01f, -8.14804249e-03f, 8.45663920e-02f, -1.26610652e-01f, -7.74881542e-02f, 1.19591832e-01f,
  -8.76325890e-02f, 4.80384566e-02f, 4.06618826e-02f, 8.30785483e-02f, 1.23959221e-02f, -6.09503463e-02f, 1.00392178e-01f, 7.18475431e-02f, 1.58366650e-01f, 1.03849262e-01f,
  1.58998743e-01f, 1.13602631e-01f, -1.38979955e-02f, 2.45126821e-02f, 4.39428277e-02f, 1.17497467e-01f, 7.26237074e-02f, 8.03270862e-02f, 3.74099761e-02f, 1.21396206e-01f,
  5.45391403e-02f, -3.69606465e-02f, 7.58013204e-02f, -4.65118960e-02f, 1.76954687e-01f, 8.69414881e-02f, -1.50760543e-02f, 1.25624150e-01f, 5.47817871e-02f, 8.86485577e-02f,
  6.20288104e-02f, -6.26245216e-02f, -6.10650517e-02f, 1.88630000e-01f, 1.48476928e-01f, 9.98402238e-02f, 4.02812846e-02f, -1.64990172e-01f, -1.77102685e-02f, 2.47744727e-03f,
  5.88623397e-02f, -3.79105681e-03f, -4.92672883e-02f, 8.30562189e-02f, 2.91861016e-02f, 1.50677294e-01f, 7.49368072e-02f, 1.44748956e-01f, 1.28574669e-01f, -1.22544482e-01f,
  1.28026307e-01f, -7.50592649e-02f, 1.38617501e-01f, 1.04164995e-01f, -3.31567936e-02f, 8.52040201e-02f, -3.94006409e-02f, 1.87309206e-01f, -5.71090989e-02f, -1.04301453e-01f,
  1.63145363e-01f, 2.65132939e-03f, -8.32874775e-02f, 1.19471200e-01f, 7.43369907e-02f, 1.10718772e-01f, -5.90949468e-02f, -2.30277598e-01f, 6.94635883e-02f, -9.07197148e-02f,
  1.37435243e-01f, -4.20070440e-02f, 4.31707390e-02f, 1.21185713e-01f, 1.06858723e-01f, -7.90590942e-02f, -2.61053685e-02f, 6.18709065e-03f, -1.74862251e-01f, -1.50577769e-01f,
  1.00180402e-01f, 4.84810323e-02f, -9.53425129e-04f, -1.18012615e-01f, 2.51609571e-02f, 8.59066918e-02f, 2.74967495e-02f, -8.89050514e-02f, 1.21529676e-01f, 1.98882772e-03f,
  -8.63589123e-02f, 6.92105815e-02f, -5.09773102e-03f, 1.07734889e-01f, 5.23757041e-02f, -4.31195274e-02f, 9.46684629e-02f, 1.08628854e-01f, 1.52971208e-01f, 1.37127172e-02f,
  1.44899547e-01f, 4.39428501e-02f, 9.52607766e-03f, 6.68785796e-02f, -4.19112295e-02f, 1.26310587e-01f, 4.09864113e-02f, 8.03027973e-02f, 9.44327191e-03f, -3.65363024e-02f,
  1.66637957e-01f, 9.58494470e-02f, 1.63183853e-01f, -5.87397888e-02f, 3.12506920e-03f, -1.01511456e-01f, -8.93815532e-02f, 2.59421140e-01f, -1.58637643e-01f, 1.09236585e-02f,
  -1.83947720e-02f, 2.87766792e-02f, 2.08154947e-01f, 8.00529867e-02f, -1.73501000e-01f, -1.30889099e-02f, -1.45351604e-01f, 7.83766657e-02f, 1.73792928e-01f, -1.53279239e-02f,
  -1.59128085e-01f, -2.49057356e-02f, 2.19605472e-02f, -1.81225374e-01f, 2.17503123e-02f, -1.41076148e-01f, -6.79683760e-02f, -1.05605908e-02f, 7.56116491e-03f, -1.35837778e-01f,
  -1.80654317e-01f, 5.40334173e-02f, 4.67398949e-02f, -1.06992498e-01f, -9.26693156e-02f, 2.15805143e-01f, 9.68209356e-02f, 6.80301385e-03f, 1.29402056e-01f, -2.15811834e-01f,
  1.58749536e-01f, 2.37981841e-01f, 1.48597747e-01f, 1.34834453e-01f, 1.12189002e-01f, 7.23664984e-02f, 9.33943912e-02f, 4.40893807e-02f, 4.49363366e-02f, 6.42302185e-02f,
  1.08028047e-01f, 4.99410294e-02f, 1.65075958e-01f, 2.50296108e-02f, 9.35774744e-02f, 3.88712175e-02f, -2.97375526e-02f, 2.74842344e-02f, 1.43752605e-01f, 1.41980886e-01f,
  -1.80506874e-02f, 1.35896325e-01f, 5.36253341e-02f, 8.43269154e-02f, 1.71465099e-01f, 1.88607007e-01f, 1.20265350e-01f, -4.65148166e-02f, -4.03165296e-02f, -4.79503535e-02f,
  8.39766338e-02f, 1.44179985e-01f, -1.68485314e-01f, -6.12030178e-02f, -1.65047765e-01f, 8.07663202e-02f, 1.09102219e-01f, -1.49287075e-01f, 2.46742535e-02f, -9.94267538e-02f,
  3.12455017e-02f, -2.63288841e-02f, 9.40788165e-03f, -1.25572616e-02f, -1.31130874e-01f, -1.32589877e-01f, 3.74100311e-03f, -1.21315449e-01f, -1.07010633e-01f, -1.39455557e-01f,
  5.45869134e-02f, 2.49326661e-01f, 1.62096813e-01f, 1.42678037e-01f, -2.46341433e-02f, 1.03454534e-02f, -3.75361815e-02f, -1.44861415e-01f, 9.67962891e-02f, 6.62888438e-02f,
  -3.21749086e-03f, 4.81467141e-05f, -1.01414368e-01f, 1.74567059e-01f, -8.45217854e-02f, -8.37355759e-03f, 1.09577276e-01f, 6.71713799e-02f, 1.75427899e-01f, 1.02810860e-01f,
  1.13193385e-01f, 7.11416602e-02f, 1.45050913e-01f, 1.61256772e-02f, 4.74652946e-02f, -7.82765821e-02f, 1.53408661e-01f, 6.81547895e-02f, 1.21175908e-01f, 1.53587192e-01f,
  -1.10539094e-01f, -3.61112095e-02f, 2.15015069e-01f, 8.12235549e-02f, 7.60064572e-02f, 1.69657782e-01f, 1.39619693e-01f, -7.26331621e-02f, 1.48684934e-01f, 8.07166919e-02f,
  -2.03404613e-02f, 9.87344310e-02f, -2.36931011e-01f, 1.67396113e-01f, -1.53322682e-01f, 4.41529341e-02f, -3.02190065e-01f, -3.08842450e-01f, -1.58389658e-01f, -8.41213837e-02f,
  1.26373038e-01f, -8.53577852e-02f, -1.31901473e-01f, -1.49271905e-01f, 9.86870527e-02f, -9.65776071e-02f, -1.70368999e-01f, -1.12483807e-01f, -5.55961542e-02f, -1.10511333e-01f,
  -9.82644111e-02f, -1.60617501e-01f, -2.87326664e-01f, -1.03789240e-01f, 3.61356102e-02f, 3.21087122e-01f, 1.23078696e-01f, 2.68775821e-01f, 3.86261903e-02f, -9.35483258e-03f,
  1.18169049e-02f, -1.72194272e-01f, -1.15340665e-01f, -8.88865965e-04f, -2.12603495e-01f, 5.20888418e-02f, -1.83318093e-01f, 5.20011559e-02f, -7.30545297e-02f, 1.72973499e-01f,
  -9.95668024e-03f, 4.42861654e-02f, 7.47006573e-03f, 5.51389828e-02f, 1.29725486e-01f, 5.69552276e-03f, 4.03756052e-02f, 1.31079378e-02f, 1.65992633e-01f, 4.65996489e-02f,
  1.15862451e-01f, -3.41197811e-02f, 3.15976180e-02f, 7.51551688e-02f, 2.05591545e-01f, 1.02133311e-01f, 1.05319798e-01f, 1.14221483e-01f, 1.64276555e-01f, 1.15254849e-01f,
  -2.14252714e-02f, 1.28753766e-01f, 1.19435653e-01f, 2.87849270e-03f, 1.47437960e-01f, 1.40900850e-01f, -3.76372896e-02f, -1.43289976e-02f, -1.73309639e-01f, -6.49372563e-02f,
  1.68213546e-02f, 1.02484098e-03f, 1.74477592e-01f, -7.63335377e-02f, -3.50949354e-02f, 1.60545021e-01f, -3.85738239e-02f, 1.13497311e-02f, -2.20195383e-01f, 1.83608562e-01f,
  -3.00033540e-02f, 8.55850130e-02f, 9.44673121e-02f, 4.81906459e-02f, -7.52990916e-02f, 1.28342130e-03f, 1.36871979e-01f, 4.26165946e-02f, 5.66556528e-02f, -2.03861102e-01f,
  -2.70374026e-02f, 1.60740744e-02f, 5.32425717e-02f, -5.65465130e-02f, 3.28729659e-01f, 2.30857089e-01f, -4.53495085e-02f, 1.61253721e-01f, 4.65606228e-02f, 1.35356873e-01f,
  2.43189290e-01f, -1.81265980e-01f, 2.60691047e-01f, -3.60951796e-02f, 9.00037400e-03f, -2.20828094e-02f, -5.05408645e-02f, -1.17039718e-02f, -1.95562392e-02f, -1.69511586e-02f,
  -4.91304277e-03f, -1.51877748e-02f, 1.95866041e-02f, -2.59132162e-02f, -2.28501260e-02f, -3.71482559e-02f, -4.85486584e-03f, 3.22473720e-02f, 4.62880433e-02f, 1.37433540e-02f,
  -3.71923521e-02f, 1.25823561e-02f, -2.91009862e-02f, -3.79282199e-02f, -1.69159193e-02f, 8.42853356e-03f, 3.73149067e-02f, -3.04877479e-02f, 1.23143820e-02f, 3.86742093e-02f,
  -4.41522337e-02f, 9.27385911e-02f, -4.27007601e-02f, -8.01917315e-02f, 1.56133333e-02f, 3.47953662e-02f, 5.90477809e-02f, -4.61911112e-02f, 2.98242383e-02f, 8.33512098e-03f,
  -3.71589996e-02f, -4.32190597e-02f, 4.08770479e-02f, 9.80532076e-03f, -2.66215615e-02f, -1.41724590e-02f, -3.94953117e-02f, 6.41678497e-02f, -4.03347909e-02f, 7.79188126e-02f,
  3.12768258e-02f, 3.13864648e-02f, 7.08864769e-03f, -7.18180910e-02f, 1.67329535e-01f, -1.04751387e-04f, -2.23736819e-02f, 9.57587063e-02f, -5.74706793e-02f, 2.16275141e-01f,
  1.13375969e-02f, -2.94869840e-02f, 3.63892019e-02f, -2.49430258e-02f, 1.62565231e-01f, -9.43214260e-03f, 1.88721865e-02f, 1.45329118e-01f, 9.25316587e-02f, 8.46291855e-02f,
  -6.51905313e-02f, 1.34125233e-01f, 7.81666711e-02f, 6.82099611e-02f, -3.21474038e-02f, 4.69015092e-02f, -7.00275600e-02f, 1.68386504e-01f, -1.20491767e-02f, 1.14524722e-01f,
  4.98989858e-02f, -8.64763334e-02f, 5.77559918e-02f, 1.12648770e-01f, 8.65566730e-02f, 9.80008766e-02f, 9.88899078e-03f, -9.01016816e-02f, -1.38652712e-01f, 1.78335682e-01f,
  -2.23564934e-02f, 8.27959180e-02f, 1.60323635e-01f, -1.38693929e-01f, 2.23784626e-01f, -1.31235823e-01f, 1.89676598e-01f, 5.27490601e-02f, 8.73287916e-02f, 2.28823647e-01f,
  6.68937294e-03f, 1.45072356e-01f, -1.29135549e-01f, -1.28718287e-01f, 2.55538762e-01f, -1.48660718e-02f, -5.45027293e-02f, 2.43476816e-02f, 6.32197410e-02f, 1.63899913e-01f,
  -2.27522594e-03f, -3.94874178e-02f, 1.92251250e-01f, 8.15964676e-03f, 1.57654509e-01f, 1.77431069e-02f, 7.77210891e-02f, 7.98880123e-03f, 2.21973285e-02f, -1.39581427e-01f,
  -2.77449917e-02f, 4.30635214e-02f, -1.61128089e-01f, -7.68337026e-02f, 2.36139655e-01f, 1.09433651e-03f, -9.82178468e-03f, -9.13415477e-02f, 1.28746685e-02f, 1.67716518e-01f,
  1.56326648e-02f, -1.76348925e-01f, 5.09043783e-02f, 1.60527900e-01f, 8.97204429e-02f, 1.27351418e-01f, 1.77423768e-02f, -5.85017391e-02f, 1.07800543e-01f, -2.07797922e-02f,
  1.52211547e-01f, 2.02147290e-03f, 1.71700910e-01f, 1.50681548e-02f, 9.04514790e-02f, 1.78084165e-01f, 5.09486012e-02f, 2.68629454e-02f, 1.51178380e-02f, -1.45643502e-02f,
  6.59492239e-02f, 7.21816346e-02f, 6.22947440e-02f, -3.88219431e-02f, 1.75205737e-01f, 1.26360014e-01f, 5.63199930e-02f, 1.45297691e-01f, -1.64941490e-01f, 5.25409095e-02f,
  -1.44717276e-01f, 1.18556924e-01f, -1.25161767e-01f, -2.04417646e-01f, -1.19157471e-02f, -1.43299371e-01f, 2.17591211e-01f, -4.22931984e-02f, -2.07621276e-01f, 3.41535397e-02f,
  3.58426571e-02f, -1.08157992e-01f, -3.81724238e-02f, -1.31152898e-01f, -6.75690100e-02f, -7.97589868e-03f, -1.21884070e-01f, -6.34365231e-02f, -1.18817292e-01f, -1.92641005e-01f,
  -7.85964057e-02f, 2.73398180e-02f, -7.38190711e-02f, 4.84966896e-02f, -2.01927926e-02f, 2.19660792e-02f, 1.27770960e-01f, 7.34334663e-02f, -5.38301952e-02f, 6.26592478e-03f,
  6.03731647e-02f, 1.59602001e-01f, 1.18885096e-02f, -4.21837717e-02f, 4.78370264e-02f, 1.70245409e-01f, 8.98619667e-02f, 8.89773816e-02f, 2.33763345e-02f, 7.13167805e-03f,
  6.92678988e-02f, 6.03937916e-03f, 8.37382227e-02f, -1.79505460e-02f, 1.13748517e-02f, 2.09063534e-02f, 1.45376354e-01f, -9.74636059e-03f, 3.70995924e-02f, 1.02867052e-01f,
  5.89182228e-02f, 7.66690746e-02f, 7.72701800e-02f, 7.79752210e-02f, -8.25142115e-02f, 3.49124311e-03f, -8.73066038e-02f, 7.55544230e-02f, 1.53189346e-01f, 3.31921736e-03f,
  1.35598019e-01f, 2.03917585e-02f, 2.14650854e-02f, 3.27095427e-02f, -1.25378678e-02f, 7.70422220e-02f, -1.35120913e-01f, -8.50693509e-02f, 8.57219771e-02f, -1.31680472e-02f,
  -1.53440684e-01f, -2.61483546e-02f, 4.20198143e-02f, -9.69144031e-02f, -1.33685201e-01f, 1.04551077e-01f, -1.35636013e-02f, 1.09170683e-01f, -8.21098313e-03f, 3.84648256e-02f,
  4.09331312e-03f, -1.03315942e-01f, 8.28335360e-02f, 6.04906166e-03f, 1.05731525e-01f, 1.02582738e-01f, 1.50298670e-01f, -4.80003376e-03f, -8.45308881e-03f, 4.04591002e-02f,
  9.17352661e-02f, 2.01377943e-02f, 5.94019741e-02f, 1.07030004e-01f, 1.17119141e-01f, 1.17687583e-01f, 7.81781599e-02f, -7.06382021e-02f, 1.38530329e-01f, 3.48677137e-03f,
  1.12644620e-01f, 4.65089083e-02f, 2.23028705e-01f, 1.54869765e-01f, 1.17401451e-01f, 7.47636557e-02f, 9.34639480e-03f, 2.12910905e-01f, 1.79902241e-01f, 1.47916183e-01f,
  -1.89151257e-01f, 6.37052208e-02f, 8.54100510e-02f, 1.23846717e-01f, 1.61473930e-01f, 1.46606579e-01f, 1.45797700e-01f, 5.13476916e-02f, 6.46882877e-02f, 6.98412361e-04f,
  2.00374022e-01f, 1.28906533e-01f, -7.49487877e-02f, 2.35192012e-02f, -1.03299553e-02f, 5.79190790e-04f, 6.32643774e-02f, -3.79405171e-02f, -2.00695805e-02f, -2.28386387e-01f,
  1.60197437e-01f, 7.02194348e-02f, -8.79200101e-02f, -2.14880351e-02f, -5.12753986e-02f, 5.18930145e-02f, 4.32140799e-03f, 3.71480845e-02f, 6.60185888e-02f, -8.04467574e-02f,
  -3.63489660e-03f, -9.04827006e-03f, 1.52741030e-01f, -4.07201350e-02f, 1.39630497e-01f, 1.30966261e-01f, -7.56749231e-03f, 1.16897359e-01f, -2.22938154e-02f, -2.02008739e-01f,
  -1.67402457e-02f, 2.12150350e-01f, 2.00092897e-01f, -1.56380609e-01f, 1.37718497e-02f, 6.53688833e-02f, 2.19618052e-01f, -1.45828426e-01f, -2.86001503e-03f, 7.47871175e-02f,
  -2.81088948e-02f, 2.33452737e-01f, -8.91182125e-02f, -1.56330302e-01f, 5.85140884e-02f, 3.83916721e-02f, -5.97106740e-02f, -2.60444339e-02f, 1.79083310e-02f, 1.20582230e-01f,
  1.21437527e-01f, 2.14335714e-02f, 1.16727985e-01f, 1.59666553e-01f, 1.10185176e-01f, 5.63485511e-02f, 1.37246296e-01f, 2.59575266e-02f, 2.09904030e-01f, 1.05892345e-01f,
  3.51144671e-02f, 2.77766064e-02f, 1.25342995e-01f, 1.09564155e-01f, 2.55856235e-02f, 1.66084222e-03f, 4.48343456e-02f, 4.83846217e-02f, 1.88527275e-02f, 7.89822191e-02f,
  1.05307847e-02f, -1.41239673e-01f, -1.54950172e-01f, 6.60498738e-02f, 1.54850647e-01f, 8.30686465e-02f, 8.06260109e-02f, 3.02969273e-02f, 9.84327048e-02f, 2.04249829e-01f,
  -1.70974627e-01f, 2.25055367e-01f, -1.71369731e-01f, 1.67591050e-01f, 4.17633168e-02f, 1.04182005e-01f, 1.57258287e-01f, 1.29516304e-01f, -6.77236915e-02f, 7.16496706e-02f,
  1.54260159e-01f, -8.73317495e-02f, 6.05992367e-03f, -1.71529129e-01f, -2.58838922e-01f, 2.62669493e-02f, 3.78293246e-02f, -2.54946556e-02f, 3.26963812e-01f, 2.16366887e-01f,
  -1.25705421e-01f, 2.01935485e-01f, -4.69731055e-02f, 3.23305801e-02f, 1.76177323e-01f, -8.55285153e-02f, 3.53107303e-01f, -3.81553881e-02f, 7.58750290e-02f, 1.55592456e-01f,
  2.60903656e-01f, 2.13820249e-01f, 6.81766719e-02f, 1.07574038e-01f, 7.23750740e-02f, 2.54891306e-01f, -1.30816447e-02f, 8.52782801e-02f, 7.18088597e-02f, 3.70433629e-02f,
  2.08313704e-01f, 1.33903235e-01f, 1.54315680e-01f, 1.40311211e-01f, 1.28713146e-01f, 7.44122639e-02f, 8.57356936e-02f, 1.62893251e-01f, 2.06875205e-01f, 6.80314451e-02f,
  -1.02182940e-01f, 1.07364342e-01f, 6.98050112e-02f, -5.63096814e-02f, -3.28641981e-02f, -9.97288600e-02f, 1.06807249e-02f, 1.69841014e-02f, -2.69544609e-02f, -2.57704295e-02f,
  -1.67570159e-01f, 3.85728851e-02f, 1.02219492e-01f, -3.22647467e-02f, 6.23746254e-02f, 6.89074099e-02f, 1.48153409e-01f, -2.20383853e-01f, -4.06631455e-02f, -2.59085055e-02f,
  -3.04795280e-02f, -5.80830947e-02f, -9.72788315e-03f, 8.85819495e-02f, -1.79772556e-01f, -2.89201252e-02f, -9.06184614e-02f, 1.34453356e-01f, -6.89240918e-02f, 2.06347957e-01f,
  1.64372846e-01f, -3.81221133e-03f, 6.58064857e-02f, -5.45035452e-02f, 1.07154921e-01f, -1.95790809e-02f, -2.81152409e-02f, 1.31025180e-01f, -1.76339179e-01f, 2.52551645e-01f,
  -7.09129870e-02f, 5.53251691e-02f, 7.56535083e-02f, 4.89506871e-02f, -1.26107107e-03f, 5.54186963e-02f, 9.49614197e-02f, 1.22367768e-02f, 3.30365002e-02f, 6.37741014e-03f,
  5.72814383e-02f, 8.99585411e-02f, 2.58497685e-01f, 5.45464503e-03f, 1.25652760e-01f, -7.54309669e-02f, -2.28120908e-02f, -2.64297763e-04f, -4.52319644e-02f, 1.35002539e-01f,
  -1.49993166e-01f, 8.37940536e-03f, -2.19536245e-01f, 1.31247684e-01f, 1.51753366e-01f, 6.72482029e-02f, 1.54132307e-01f, -5.10738641e-02f, 1.41810268e-01f, 1.71877611e-02f,
  1.29694179e-01f, 1.70730039e-01f, -1.32505715e-01f, 9.61418897e-02f, 7.23221824e-02f, 1.42748758e-01f, -2.17618808e-01f, -9.95170474e-02f, 1.64269611e-01f, -1.52498513e-01f,
  -1.55498788e-01f, 1.64228797e-01f, 1.32143751e-01f, 1.88958749e-01f, -7.60434568e-02f, 1.50762592e-02f, 1.55517265e-01f, -3.32942754e-02f, 1.83816865e-01f, 3.29394303e-02f,
  1.60289466e-01f, 9.48913842e-02f, 1.34923711e-01f, -9.82583016e-02f, -6.48879781e-02f, 1.13880098e-01f, -1.38573050e-01f, -1.46831974e-01f, 1.75018042e-01f, 1.11359075e-01f,
  1.69894338e-01f, -1.21012278e-01f, 3.52329165e-02f, -7.15285838e-02f, 1.26377881e-01f, -1.51533961e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  5.78367934e-02f, 1.59860656e-01f, 1.43443003e-01f, 1.13400929e-01f, 7.52766654e-02f, 9.99524593e-02f, 2.42533982e-02f, 1.63366601e-01f, 7.82791078e-02f, 1.15527160e-01f,
  1.17153488e-01f, 1.00544132e-01f, 9.34638306e-02f, 1.09787442e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -1.23599209e-02f, -5.55593930e-02f, -3.33783701e-02f, -3.14231515e-02f, -1.25766518e-02f, 6.94628060e-02f, -1.80562232e-02f, -7.79076815e-02f, 3.63850109e-02f, 7.29146376e-02f,
  2.29956321e-02f, 6.40755072e-02f, 1.49338515e-02f, -3.48898694e-02f, -1.11003984e-02f, -5.06706573e-02f, 1.52042313e-02f, 1.99540369e-02f, -5.93132749e-02f, 5.69468588e-02f,
  -1.81705007e-04f, -1.11372387e-02f, 1.97415594e-02f, 2.64102258e-02f, 5.50128557e-02f, 1.03128694e-01f, -9.08188522e-02f, 9.29738209e-03f, 1.41232058e-01f, 1.15083084e-01f,
  -5.57716265e-02f, -1.08820852e-02f, -6.73544407e-02f, 4.21918184e-02f, 1.22632280e-01f, -9.22234729e-02f, 3.93230282e-02f, -9.19200107e-03f, 5.81330024e-02f, -4.42815647e-02f,
  -2.62408536e-02f, -5.87367686e-03f, 7.05973431e-02f, 2.08001092e-01f, 1.66118680e-03f, -4.79038246e-02f, -6.50456026e-02f, -1.59505635e-01f, 6.19528741e-02f, 8.39212984e-02f,
  1.15528114e-01f, 5.32482900e-02f, 1.14026658e-01f, 3.69814113e-02f, -2.46531107e-02f, -5.14864363e-03f, -3.50572797e-03f, 8.47021341e-02f, -1.52889192e-01f, 1.25684783e-01f,
  -5.11522405e-02f, -1.36001527e-01f, -1.41840279e-01f, 2.02292293e-01f, -1.75288487e-02f, -7.16487318e-03f, -9.84649062e-02f, 6.33261204e-02f, -9.42590088e-03f, 1.03393570e-01f,
  -9.43355113e-02f, 2.01790147e-02f, 2.22218167e-02f, 3.14869508e-02f, -1.32356975e-02f, 7.51514062e-02f, 1.31262854e-01f, -3.61215398e-02f, 6.32498488e-02f, 3.72634009e-02f,
  -3.33561040e-02f, -2.34386306e-02f, 4.02058568e-03f, 5.13343923e-02f, 5.50802648e-02f, -1.30610578e-02f, -6.19565099e-02f, -1.94368586e-02f, 7.42387325e-02f, 3.83789539e-02f,
  5.36935851e-02f, -6.47938848e-02f, 6.85001835e-02f, 1.16323330e-01f, -3.01293340e-02f, 2.24085212e-01f, -1.10022686e-01f, 1.11682609e-01f, 3.31004411e-02f, -1.13232754e-01f,
  -4.22515161e-02f, -2.05314308e-01f, 6.03582971e-02f, 1.36604980e-01f, 5.25195748e-02f, -1.05749056e-01f, 2.20903799e-01f, 9.85790044e-02f, 3.77994329e-02f, -2.21323278e-02f,
  -6.68932945e-02f, 3.66986431e-02f, 1.18710399e-01f, 1.69508770e-01f, -3.74574214e-02f, 4.08402085e-02f, 2.28378654e-01f, 2.78039661e-04f, -8.85378420e-02f, 3.95485610e-02f,
  4.34376709e-02f, -3.74602787e-02f, 1.83302224e-01f, -6.03076722e-03f, -1.83364168e-01f, 6.92258105e-02f, -1.06541246e-01f, 1.02154844e-01f, -3.78892161e-02f, -1.64417233e-02f,
  5.38643822e-02f, 7.45441094e-02f, 6.06859811e-02f, -1.54621765e-01f, 7.23383948e-02f, 4.72624302e-02f, -7.25430250e-03f, -9.52592120e-02f, -3.17354202e-02f, -9.65246372e-03f,
  6.42630532e-02f, 7.04878420e-02f, 6.14534691e-02f, -5.56681380e-02f, -9.80433151e-02f, 5.44713698e-02f, 8.22212361e-03f, -4.05983888e-02f, 1.18602482e-04f, 2.58588349e-03f,
  -5.34409098e-02f, -3.87783051e-02f, -5.87566979e-02f, -8.41964856e-02f, 3.11604030e-02f, -7.50353485e-02f, -1.32793248e-01f, -6.57468289e-02f, 4.86531258e-02f, 1.16545051e-01f,
  -1.32280905e-02f, -2.27596518e-02f, -1.30106807e-01f, 7.11911693e-02f, -5.29856756e-02f, -5.37150465e-02f, -5.69648147e-02f, 1.54463261e-01f, 3.96499299e-02f, 4.60241316e-03f,
  5.14600277e-02f, -1.91399559e-01f, -1.56657565e-02f, -5.79238310e-02f, -8.30426253e-03f, 1.28435463e-01f, -5.22440635e-02f, -1.47864744e-01f, -8.76509771e-02f, -1.45723894e-01f,
  -1.45539818e-02f, -5.07332832e-02f, -3.95040326e-02f, 3.16005163e-02f, -1.87622104e-02f, -1.76040426e-01f, 1.37528285e-01f, -4.61419299e-02f, -7.05598444e-02f, 1.75782636e-01f,
  6.61383495e-02f, -2.09993839e-01f, -4.83635589e-02f, 2.98290681e-02f, -3.78419608e-02f, -2.25058682e-02f, -1.29323974e-02f, 4.71469834e-02f, -4.50962484e-02f, -5.73449256e-03f,
  1.92960806e-03f, -9.99923795e-03f, 3.30771692e-02f, 6.07001642e-03f, -7.80063346e-02f, -1.60282161e-02f, -9.72588547e-03f, 2.00218856e-02f, 8.33186358e-02f, -2.28562299e-02f,
  -2.92229299e-02f, -1.22678569e-02f, 1.09996600e-02f, -7.46993423e-02f, 2.15613246e-02f, -1.04341218e-02f, 2.48440914e-02f, 3.21278609e-02f, -1.30662188e-01f, 9.32608619e-02f,
  9.36915353e-02f, 2.71482579e-02f, -6.65359292e-03f, -1.22330323e-01f, 2.51611639e-02f, 8.28203280e-03f, 9.71294641e-02f, -5.63297197e-02f, 4.72032726e-02f, 1.32752299e-01f,
  -3.39560695e-02f, -2.00251207e-01f, -6.78922683e-02f, 5.14527112e-02f, -1.54638723e-01f, 1.28818646e-01f, -1.55255776e-02f, 9.65252705e-03f, 3.19604538e-02f, -1.55091733e-01f,
  9.22067836e-03f, 3.62001397e-02f, 4.80674505e-02f, 1.21644557e-01f, -1.34877786e-01f, -1.18937995e-02f, -9.68853161e-02f, -5.84819242e-02f, 9.40695126e-03f, 1.72167569e-01f,
  -1.74213022e-01f, 9.00385752e-02f, 3.67383510e-02f, -1.72881752e-01f, 7.57903140e-03f, 1.84001446e-01f, 7.48216510e-02f, 2.04270780e-02f, 7.62755796e-02f, 7.81493261e-02f,
  5.63720390e-02f, -7.92590082e-02f, 4.68815006e-02f, 7.82684609e-02f, 6.02031872e-02f, -2.07150262e-02f, 6.86184391e-02f, 6.44769898e-05f, 5.77846058e-02f, -1.36990445e-02f,
  5.14116660e-02f, -2.42640823e-03f, 4.64476794e-02f, 4.91237454e-02f, -1.60176933e-04f, 1.31369168e-02f, 4.32781279e-02f, 2.61042104e-03f, -2.48725470e-02f, 1.13216057e-01f,
  -8.30759667e-03f, -4.36061099e-02f, 1.00117512e-01f, -8.20755735e-02f, -5.81449829e-02f, -9.72362608e-02f, 8.50077495e-02f, 5.50831109e-02f, 7.12661669e-02f, -4.94267084e-02f,
  -1.39170676e-01f, 1.15031302e-01f, -4.28282954e-02f, 6.84149191e-02f, 1.33202225e-02f, 9.63613763e-02f, 4.52172151e-03f, -1.21608116e-01f, -2.75215115e-02f, -1.93663061e-01f,
  6.03745058e-02f, 1.21372439e-01f, 5.10722697e-02f, 2.00664341e-01f, -1.00453682e-01f, -1.33023769e-01f, -7.63229504e-02f, -8.88498351e-02f, -3.55326966e-03f, -5.00779822e-02f,
  1.26284689e-01f, -5.50422817e-02f, -8.11290890e-02f, -8.29956308e-02f, 1.21127144e-01f, -9.38304067e-02f, 6.88588992e-02f, 1.35156974e-01f, 1.93936601e-01f, -2.62775958e-01f,
  -2.89574042e-02f, 3.26396450e-02f, -1.04019055e-02f, -8.84586722e-02f, -7.55630359e-02f, -1.28316674e-02f, -4.35219184e-02f, -7.74063542e-02f, 3.36838588e-02f, -1.75870154e-02f,
  1.51447747e-02f, -4.22285683e-02f, -6.29347786e-02f, 2.54006386e-02f, 8.68530273e-02f, -2.36632917e-02f, -4.18422110e-02f, -3.39645706e-02f, -1.62276551e-02f, -5.67201478e-03f,
  -2.85380427e-02f, 4.05370025e-03f, 1.48837622e-02f, 5.11569902e-02f, -1.10823996e-01f, 9.05894861e-02f, 1.07022360e-01f, -6.16585575e-02f, 1.24565847e-01f, 1.25003690e-02f,
  1.04881190e-02f, -2.57612914e-02f, 5.66443503e-02f, -6.24990836e-02f, 3.16647291e-02f, -7.71297887e-02f, -1.45687088e-01f, -4.19455431e-02f, -1.37894243e-01f, 1.79141492e-01f,
  -8.18849057e-02f, -1.56281311e-02f, 8.36314410e-02f, -8.52689743e-02f, 1.73642531e-01f, 4.91259173e-02f, 9.83189642e-02f, 1.36707217e-01f, -1.12680525e-01f, -2.37966720e-02f,
  -6.68509603e-02f, 9.98826697e-02f, -1.94424167e-02f, -7.78640136e-02f, -2.15687424e-01f, -3.00943851e-03f, -1.89257264e-02f, 1.45531148e-01f, -1.02128059e-01f, 2.69659981e-03f,
  7.00763613e-02f, 6.60777539e-02f, -1.60787236e-02f, 9.66992080e-02f, 2.89706215e-02f, 7.16850534e-02f, -3.35842520e-02f, 6.95111826e-02f, -6.88053668e-02f, -3.76528986e-02f,
  -5.22117317e-02f, 6.95883855e-02f, 3.47660594e-02f, 3.61332409e-02f, 2.46849488e-02f, 1.40605252e-02f, 4.45069224e-02f, 4.17447537e-02f, -2.35671760e-03f, -7.34068528e-02f,
  1.48012163e-02f, -3.80011536e-02f, 3.58254984e-02f, -1.67114250e-02f, -8.56061559e-03f, -3.55958901e-02f, 1.87079646e-02f, 2.43338593e-03f, 1.92752574e-02f, 2.05764063e-02f,
  1.86324604e-02f, -5.34766763e-02f, 5.70554361e-02f, 9.11350474e-02f, 4.20391262e-02f, 1.92633346e-01f, -7.43807480e-02f, 1.46918846e-02f, 4.51594964e-02f, 5.22614643e-03f,
  3.51923853e-02f, -8.67474005e-02f, 5.28035760e-02f, 6.04904257e-02f, 7.41355345e-02f, -6.40537515e-02f, 1.17371492e-01f, 3.19941677e-02f, -2.68882867e-02f, -4.05938327e-02f,
  -1.27553999e-01f, 2.62971185e-02f, -1.09706856e-02f, -7.80679038e-05f, 6.54049069e-02f, 3.38941365e-02f, 4.19532135e-02f, 1.14417605e-01f, 1.66846767e-01f, 7.48484060e-02f,
  -6.24896213e-02f, -4.21435274e-02f, 3.29626016e-02f, 4.24543023e-02f, -1.80002436e-01f, 1.10183142e-01f, -4.83486913e-02f, -6.58617169e-02f, -2.16942374e-03f, -1.73004176e-02f,
  7.95582533e-02f, 4.53479961e-02f, -5.07042632e-02f, -6.47102594e-02f, 3.72285061e-02f, -7.79738650e-02f, -5.32903299e-02f, 4.17132452e-02f, 6.02415875e-02f, -4.47221519e-03f,
  -7.50163049e-02f, -4.67048362e-02f, -2.13458799e-02f, 4.57724445e-02f, 1.44006208e-01f, 2.61579100e-02f, -7.34648854e-02f, 3.47523130e-02f, 3.48666497e-02f, -8.61058682e-02f,
  -6.27769902e-03f, 8.97971019e-02f, 1.24865575e-02f, -5.12012243e-02f, -8.98533538e-02f, 9.08492878e-02f, 1.55907748e-02f, -1.83892678e-02f, 5.03000133e-02f, -1.60161227e-01f,
  5.39750159e-02f, -7.89257810e-02f, 4.63832840e-02f, -2.10964642e-02f, 5.42543158e-02f, 1.22124664e-01f, -2.64847931e-02f, -2.17053890e-01f, -5.31471707e-02f, -2.90852375e-02f,
  -1.81127876e-01f, 9.48883593e-02f, -1.48177324e-02f, 5.12350574e-02f, 5.24471514e-03f, -1.57362342e-01f, 1.87677087e-03f, -3.97504307e-02f, 7.61900246e-02f, 7.16858804e-02f,
  -1.42950326e-01f, 1.10997051e-01f, -2.82923225e-02f, 1.93499420e-02f, -2.03968920e-02f, 1.48156965e-02f, -8.99875611e-02f, -3.65793556e-02f, 1.62525654e-01f, -1.25070557e-01f,
  -2.89018080e-02f, 5.64453229e-02f, 7.15198815e-02f, 8.66244137e-02f, -7.35598132e-02f, 5.85676022e-02f, 6.74613751e-03f, 3.93451639e-02f, -5.98738566e-02f, -4.88645844e-02f,
  9.36030895e-02f, -1.71608869e-02f, 1.26748728e-02f, 4.33761925e-02f, 1.06078215e-01f, -5.36279827e-02f, 5.18584810e-02f, 6.88645840e-02f, 3.15151433e-03f, 1.08784206e-01f,
  -1.30215809e-02f, 9.89921093e-02f, -3.07059344e-02f, -1.38431294e-02f, -1.14198923e-02f, 2.73533873e-02f, 2.93455105e-02f, 9.26879570e-02f, 7.62372091e-02f, -9.40913334e-02f,
  1.05415113e-01f, 1.23400763e-01f, 5.85984141e-02f, 1.18359610e-01f, -1.25870839e-01f, 7.92973638e-02f, 1.03779435e-01f, -4.65267971e-02f, -5.44785224e-02f, -1.62266493e-01f,
  6.59634620e-02f, 1.69323906e-01f, -2.32457351e-02f, -1.63700327e-01f, 1.57360420e-01f, -3.05771623e-02f, 6.20825924e-02f, 6.68452531e-02f, -5.98576255e-02f, 1.02212869e-01f,
  1.07256643e-01f, 9.45379809e-02f, -1.01918951e-01f, 9.24800634e-02f, 2.19771147e-01f, 1.93486065e-02f, -2.80441064e-02f, 6.17464771e-03f, -5.21584786e-02f, 7.47492686e-02f,
  9.30835754e-02f, 1.80505719e-02f, -8.90948102e-02f, 8.28775913e-02f, -2.51004612e-03f, 4.65313625e-03f, -5.97956702e-02f, 1.48430215e-02f, -1.39607303e-03f, -2.48485971e-02f,
  2.64420081e-02f, 1.28486797e-01f, -4.20183577e-02f, -3.45134474e-02f, 2.59110723e-02f, 1.61052123e-02f, -2.33438760e-02f, 5.43837901e-03f, 2.32506562e-02f, -2.56322529e-02f,
  3.29086781e-02f, 4.77140024e-02f, -5.79491965e-02f, -6.08109348e-02f, 4.14542593e-02f, 7.49415308e-02f, -7.30197653e-02f, 6.19497076e-02f, 2.50630621e-02f, 3.64472009e-02f,
  7.60851726e-02f, 5.95556572e-02f, -5.89119531e-02f, 1.22176349e-01f, 1.10763885e-01f, -3.81385200e-02f, -6.41146451e-02f, -1.39306769e-01f, 3.78058404e-02f, 9.13098529e-02f,
  1.13975748e-01f, -8.46441649e-03f, 1.35499060e-01f, 9.94849056e-02f, 6.14066496e-02f, -9.80544463e-02f, 4.44829901e-04f, -4.94006509e-03f, -7.32581168e-02f, 1.06271967e-01f,
  -4.22948524e-02f, 5.93624916e-03f, 4.86875363e-02f, -5.61423749e-02f, 7.39010572e-02f, 1.85892060e-01f, 4.00721431e-02f, 1.20679624e-01f, 1.99659523e-02f, 1.55970827e-01f,
  6.90042451e-02f, -1.38605192e-01f, 4.96348664e-02f, 1.81099474e-01f, -3.32680419e-02f, 7.58507475e-02f, -7.73804076e-03f, -8.01753700e-02f, 1.01569472e-02f, 1.28266707e-01f,
  -7.74786845e-02f, -2.90601347e-02f, -3.25865112e-02f, -1.53233007e-01f, -3.17668915e-02f, -3.04388851e-02f, -3.38150114e-02f, -4.38726507e-02f, 2.83648912e-02f, 3.15677095e-03f,
  -2.03969702e-02f, -1.05925847e-03f, 5.81335090e-03f, 1.01243472e-02f, 5.09032384e-02f, 1.01861253e-01f, -4.41701375e-02f, 4.48302366e-02f, -2.55272835e-02f, 4.52294312e-02f,
  -1.12175483e-04f, 4.01715860e-02f, 8.72528702e-02f, -1.90277323e-02f, -1.18703589e-01f, 1.20179258e-01f, 8.09651762e-02f, 5.53118844e-06f, 1.61933333e-01f, 7.89095610e-02f,
  -1.71601754e-02f, -6.42077476e-02f, 6.11481033e-02f, 6.33737072e-02f, 1.14429653e-01f, -4.03326191e-02f, -1.50237337e-01f, 2.72722263e-02f, -1.10873371e-01f, 2.02615187e-01f,
  -1.18027247e-01f, -1.06877439e-01f, -3.50663997e-02f, -6.47843480e-02f, 1.43048629e-01f, 4.65307906e-02f, 1.50675261e-02f, 1.41678751e-01f, -1.18558198e-01f, 3.19797099e-02f,
  -6.74060956e-02f, 1.27929017e-01f, 1.84219386e-02f, -2.13727709e-02f, -2.45324090e-01f, -5.36497347e-02f, 2.35332344e-02f, 2.56300755e-02f, -1.28233656e-01f, -2.36061309e-03f,
  -8.01673383e-02f, 9.24381614e-02f, 4.82991114e-02f, 1.25792429e-01f, 7.14957565e-02f, -2.95696184e-02f, -3.71906497e-02f, 1.35000736e-01f, -4.56482247e-02f, -2.40838788e-02f,
  4.14202623e-02f, -3.24147530e-02f, -3.19442712e-02f, 8.93545374e-02f, -2.92395446e-02f, -3.00776232e-02f, -4.19074390e-03f, -3.16611752e-02f, 1.75309721e-02f, -4.72198464e-02f,
  -6.23253286e-02f, 9.93703455e-02f, 3.73326205e-02f, 5.77348918e-02f, -2.19289754e-02f, -5.12817428e-02f, -5.39776459e-02f, 8.64824280e-02f, 3.25770229e-02f, -8.41502100e-03f,
  -1.80628508e-01f, -3.15408129e-03f, -1.01898864e-01f, -5.72041683e-02f, 3.00728083e-02f, 4.15428951e-02f, -6.81724865e-03f, -1.43709630e-02f, -6.39759898e-02f, 9.41345319e-02f,
  1.97806686e-01f, 6.57043904e-02f, 1.36047855e-01f, -2.18985498e-01f, 1.22940719e-01f, 9.68499482e-02f, -9.84287560e-02f, 6.99284747e-02f, -2.04498634e-01f, -7.76629448e-02f,
  -4.91860136e-02f, -5.18947989e-02f, 9.86905843e-02f, 4.06579748e-02f, 5.92740998e-02f, -5.67259416e-02f, -1.20615598e-03f, 1.53215408e-01f, 2.26595983e-01f, -9.36187059e-02f,
  -7.14320540e-02f, -1.65805802e-01f, -1.70808639e-02f, 7.21677691e-02f, -5.40135838e-02f, -1.81466892e-01f, 9.44022238e-02f, 1.66547056e-02f, 6.47968426e-02f, -2.21849531e-02f,
  4.08954918e-02f, 9.88927931e-02f, 2.38018744e-02f, 7.68533349e-02f, -4.15149517e-02f, -4.88933064e-02f, 6.02205992e-02f, 8.35805163e-02f, 2.94144861e-02f, 4.77681905e-02f,
  3.03480793e-02f, -4.06720936e-02f, 8.79216492e-02f, -4.57744934e-02f, -2.70069018e-02f, 9.65044647e-02f, -2.30556782e-02f, 8.15983191e-02f, -3.48415561e-02f, -3.27248275e-02f,
  2.43944526e-02f, 7.23021850e-02f, 6.93243742e-02f, 6.79071397e-02f, -1.62992124e-02f, 3.30049023e-02f, -1.72983613e-02f, -4.73626778e-02f, 6.66900491e-03f, -3.90660428e-02f,
  6.39482364e-02f, 3.82783078e-03f, -7.62219122e-03f, 1.11756139e-01f, 1.07513361e-01f, 4.35875356e-02f, 3.77945229e-02f, -1.32651225e-01f, 2.17806790e-02f, -9.02497321e-02f,
  -9.59442034e-02f, 2.40209196e-02f, -1.31955549e-01f, 8.71358216e-02f, 3.58157158e-02f, -9.95372701e-03f, 1.21526465e-01f, 1.37104511e-01f, -6.80678189e-02f, -1.98484026e-02f,
  -6.48192763e-02f, 1.59076989e-01f, 1.93176433e-01f, -1.61887720e-01f, -4.55713980e-02f, 3.51388864e-02f, -2.96585653e-02f, 3.06364358e-03f, 1.53019112e-02f, -2.53568351e-01f,
  9.85340551e-02f, -1.46814389e-02f, 5.37373796e-02f, 4.56295423e-02f, 3.45199443e-02f, 3.94292921e-02f, 5.31206578e-02f, 3.48550677e-02f, 8.77681971e-02f, -8.03613067e-02f,
  -2.89849378e-02f, 1.83683112e-02f, -5.51180616e-02f, -4.39703185e-03f, 6.53744861e-02f, -4.06829230e-02f, -4.16872054e-02f, -8.63820910e-02f, 2.91324761e-02f, 4.33438551e-03f,
  2.76386105e-02f, -7.28341192e-02f, -2.81332545e-02f, -3.59050147e-02f, -2.57121660e-02f, -8.81843418e-02f, 1.56883746e-01f, -1.92679167e-02f, -5.04737124e-02f, 4.78351526e-02f,
  -7.02037588e-02f, -5.37162833e-03f, -1.09114125e-02f, 1.24364883e-01f, -7.14248940e-02f, 1.20119654e-01f, -1.22200035e-01f, 2.30834931e-02f, 1.92126513e-01f, -1.89929195e-02f,
  1.40164614e-01f, -1.30372137e-01f, 1.53108135e-01f, -4.90256175e-02f, -9.81063675e-03f, -2.01446544e-02f, -2.12676793e-01f, 2.52980515e-02f, -1.42074019e-01f, -8.32075626e-02f,
  6.77336529e-02f, 7.96385109e-02f, 1.09121948e-01f, -1.20939016e-01f, -3.89459133e-02f, 1.65833965e-01f, 2.71047562e-01f, -2.96986513e-02f, 5.17884456e-02f, -2.29358375e-01f,
  1.34414792e-01f, 4.44227979e-02f, -1.40372574e-01f, -9.42791849e-02f, -3.93722914e-02f, -1.95871174e-01f, -1.59095496e-01f, -4.97238897e-02f, -4.46939729e-02f, -1.42149419e-01f,
  -5.26935272e-02f, -5.81491180e-02f, 1.24128712e-02f, -7.77587816e-02f, -3.33787762e-02f, -5.01057468e-02f, -4.19477001e-02f, -9.78938565e-02f, 1.14141572e-02f, -1.37405004e-02f,
  -3.59250903e-02f, -2.10004020e-02f, -2.94616818e-02f, -5.36003783e-02f, -1.07205184e-02f, -4.43491675e-02f, -6.67650998e-02f, -3.65090407e-02f, -1.18036112e-02f, -5.88412583e-02f,
  -7.82602131e-02f, -1.58742815e-02f, 1.83462370e-02f, 4.14684601e-02f, 6.38050288e-02f, 3.11566181e-02f, -7.47545362e-02f, -1.52581220e-03f, 1.47385439e-02f, 1.47641655e-02f,
  8.40252787e-02f, -1.17400467e-01f, -6.43945858e-02f, -6.81479741e-03f, -8.63573626e-02f, 1.07398666e-01f, -6.94064051e-02f, 8.17250609e-02f, 6.11111820e-02f, 6.16318174e-02f,
  8.62853229e-02f, -7.32037574e-02f, 2.35351026e-02f, -4.96236309e-02f, -7.76643232e-02f, 1.06971003e-02f, 5.66839129e-02f, -5.45046888e-02f, 4.26982567e-02f, -2.14369088e-01f,
  -2.13970691e-01f, 1.31401017e-01f, 8.33702832e-02f, 5.62127903e-02f, -7.22701848e-02f, 3.89975347e-02f, -2.09337156e-02f, 1.16420388e-01f, -1.03524573e-01f, 6.79897293e-02f,
  -3.67561840e-02f, -7.76643082e-02f, 2.66547557e-02f, -1.25314817e-02f, 7.85800889e-02f, -6.64007105e-03f, 1.84633192e-02f, 3.48230787e-02f, -5.60880788e-02f, -8.88437182e-02f,
  1.74444895e-02f, -6.94772974e-03f, 2.59918999e-02f, 3.51845436e-02f, -1.75677687e-02f, 1.74799319e-02f, -2.79182419e-02f, 2.14575185e-03f, -4.02455851e-02f, -4.78907023e-03f,
  -4.28566188e-02f, 6.24076799e-02f, -9.16650333e-03f, -2.70050615e-02f, -4.66894023e-02f, -1.10743389e-01f, 3.67305614e-02f, 1.00783795e-01f, -1.21990860e-01f, -7.73050860e-02f,
  -3.56616564e-02f, -7.91166127e-02f, 6.78694621e-03f, -4.59088869e-02f, -5.97089306e-02f, 2.52487306e-02f, -2.47403961e-02f, 2.95898523e-02f, -1.00467063e-01f, 7.43070319e-02f,
  -2.20453069e-02f, 1.34480864e-01f, -2.03519431e-03f, 2.68579703e-02f, -9.66825895e-03f, -1.18968241e-01f, 1.07641555e-01f, 1.45566054e-02f, 7.61648342e-02f, 8.41056462e-03f,
  -4.79896255e-02f, -1.34246662e-01f, 1.16992481e-02f, -1.01957448e-01f, -9.07886401e-02f, 7.04722777e-02f, 8.41253251e-02f, 5.38347326e-02f, 2.68963221e-02f, -4.88925353e-02f,
  1.33208007e-01f, 7.64617026e-02f, 2.98848599e-02f, -3.89626957e-02f, 1.84243042e-02f, 2.09559891e-02f, -1.04133189e-02f, -4.99968491e-02f, -5.00241481e-02f, -4.50673327e-03f,
  -8.15870464e-02f, -5.96210882e-02f, 9.35572386e-03f, 4.76655923e-02f, 2.70525273e-02f, -1.39908874e-02f, -1.91394542e-03f, 1.75248552e-02f, 4.04036231e-02f, 3.40937674e-02f,
  2.34419517e-02f, 1.62039753e-02f, -1.82088073e-02f, -1.15445386e-04f, 2.62678042e-02f, -4.14664205e-03f, -1.54057574e-02f, 8.73320401e-02f, -4.87905294e-02f, 9.49321613e-02f,
  -7.40172639e-02f, -6.92422912e-02f, 7.37170056e-02f, 9.90069881e-02f, -7.10811792e-03f, 7.30931833e-02f, -2.36422047e-02f, -7.67650595e-03f, 9.68104899e-02f, -7.23069906e-02f,
  -8.00448433e-02f, -5.98413423e-02f, -2.84905937e-02f, -4.14521508e-02f, -2.74612978e-02f, 1.10435709e-02f, 1.08006828e-01f, 7.18029588e-02f, 7.82224014e-02f, 2.02892814e-03f,
  -8.29354748e-02f, -1.37038548e-02f, -7.63684884e-02f, -1.69426315e-02f, 5.87015599e-02f, 1.57368779e-01f, 5.92515394e-02f, 5.33103049e-02f, -9.59619582e-02f, 9.43966433e-02f,
  -7.24766105e-02f, 4.76880670e-02f, -2.31371112e-02f, 2.58560143e-02f, -2.14378778e-02f, 7.22208843e-02f, -1.55997828e-01f, 1.59029335e-01f, -6.45256415e-02f, -3.62206437e-02f,
  -5.03526591e-02f, -1.07972577e-01f, -2.26263776e-02f, 2.55169198e-02f, -6.91200718e-02f, -4.51629758e-02f, -3.41852680e-02f, -4.99109738e-02f, 1.73330046e-02f, 3.83844115e-02f,
  -1.74510702e-02f, -2.24144813e-02f, -4.57833521e-02f, 6.05499335e-02f, 2.65168510e-02f, -8.71958584e-02f, -3.94037440e-02f, -5.71704842e-03f, 2.48544160e-02f, 2.45364290e-02f,
  5.31956367e-02f, 1.90343671e-02f, 1.93134975e-02f, 9.83999297e-03f, 1.04380352e-02f, 3.97182666e-02f, 7.38838688e-02f, 3.51881422e-02f, 9.04653687e-03f, 3.17066419e-03f,
  -3.92742380e-02f, 8.71323515e-03f, 1.03407279e-01f, -8.76355246e-02f, -2.92997025e-02f, -4.76679578e-02f, -2.19337847e-02f, -1.13762654e-02f, -5.83345294e-02f, 1.48019223e-02f,
  5.36632128e-02f, 1.30097538e-01f, 6.25831932e-02f, -7.43492469e-02f, 2.04837881e-02f, -8.33056942e-02f, -1.85275953e-02f, 3.76425236e-02f, 3.48426364e-02f, 6.25567064e-02f,
  -8.77363514e-03f, -7.59725645e-02f, -1.57733619e-01f, 9.25147012e-02f, 5.10903336e-02f, 1.57120198e-01f, 1.41752348e-03f, 6.74343184e-02f, -6.77195471e-03f, 3.21278535e-02f,
  -1.58356234e-01f, 1.13249347e-01f, 1.74892247e-02f, -7.92490542e-02f, -2.46722810e-02f, -7.04117268e-02f, 2.20445357e-02f, -3.34507227e-02f, -8.13290700e-02f, 4.53856215e-02f,
  -1.19886035e-02f, -6.04582876e-02f, -1.53732002e-02f, 4.92252782e-03f, -5.31875975e-02f, -3.88802327e-02f, 2.55638659e-02f, 2.42970604e-02f, -7.88037106e-02f, 7.73623735e-02f,
  -1.74483508e-02f, 1.86578315e-02f, -6.43139780e-02f, -4.77623418e-02f, 5.70911774e-03f, 3.23248208e-02f, -1.40004620e-01f, -2.07001455e-02f, -1.04690855e-02f, 1.73909422e-02f,
  5.10916971e-02f, 8.44742134e-02f, 3.43463272e-02f, -1.48207769e-01f, 5.55604771e-02f, -1.11662328e-01f, 7.03982264e-02f, -5.43908514e-02f, -2.12121844e-01f, 3.10183130e-02f,
  -1.79112166e-01f, 4.21347469e-02f, -1.78017572e-01f, 4.82546054e-02f, -4.82052565e-02f, 3.46232839e-02f, 1.94144115e-01f, -1.14387246e-02f, 1.29918724e-01f, 4.81733531e-02f,
  -1.25601351e-01f, 3.69797237e-02f, -7.87098408e-02f, 1.05392627e-01f, -7.30127320e-02f, -2.90736351e-02f, -2.79479235e-01f, -1.69285778e-02f, -4.86301221e-02f, 2.55201936e-01f,
  -2.19191596e-01f, 3.98120619e-02f, 2.46521328e-02f, 8.42275470e-02f, 8.45745653e-02f, 2.07666263e-01f, 1.32394247e-02f, 9.68299899e-03f, -7.65049644e-03f, -8.44701603e-02f,
  3.33453827e-02f, -1.71575509e-02f, 1.65053941e-02f, 4.09947038e-02f, 6.12335578e-02f, -4.60427776e-02f, 7.17940181e-02f, 2.46126205e-03f, 4.10934212e-04f, 4.72544646e-03f,
  1.05278939e-01f, 4.40588454e-03f, 7.70401359e-02f, 3.30901965e-02f, 5.47481738e-02f, 9.50021949e-03f, 8.16579759e-02f, 5.59472218e-02f, 5.39511554e-02f, 2.80788522e-02f,
  -1.09092042e-01f, 4.50432673e-02f, 1.68508068e-01f, -6.71304017e-02f, 4.64634523e-02f, 6.30296171e-02f, 2.74388641e-02f, -3.98801407e-03f, 7.53690004e-02f, 4.88510448e-03f,
  2.26090718e-02f, -2.87418868e-02f, -2.01978803e-01f, -4.87206355e-02f, -8.98388475e-02f, 1.95189297e-01f, -1.27438292e-01f, -1.31233215e-01f, 5.55941239e-02f, -1.02880560e-01f,
  1.97078213e-01f, 7.23892450e-02f, 5.48345596e-02f, 1.30989417e-01f, -1.04280412e-01f, -7.98550323e-02f, -1.23161107e-01f, 7.80089721e-02f, 1.01209141e-01f, -1.05803736e-01f,
  -1.90994829e-01f, 2.73990892e-02f, -1.73346177e-02f, 1.54617384e-01f, -7.45741203e-02f, -2.02139113e-02f, 8.41422081e-02f, 2.14946762e-01f, -2.72086300e-02f, 4.38044257e-02f,
  -5.07815219e-02f, -4.39524539e-02f, 5.89225888e-02f, -2.85379756e-02f, 6.83443993e-02f, -8.50080997e-02f, 3.11883707e-02f, 8.33226182e-03f, -6.59674034e-02f, -2.12926492e-02f,
  -5.27482331e-02f, -5.88807501e-02f, -6.28677309e-02f, 2.35329028e-02f, -1.29332945e-01f, 1.51882600e-03f, 3.45846675e-02f, -1.19272314e-01f, 6.89976430e-03f, -7.94463828e-02f,
  -5.47872717e-03f, -5.68012744e-02f, -2.92094517e-02f, -7.52728386e-03f, -4.95614968e-02f, -1.64817661e-01f, -7.69080687e-03f, 1.18149742e-01f, -1.05359815e-01f, -1.56505451e-01f,
  -1.54467812e-03f, -1.56980231e-01f, 1.43206492e-01f, -1.13827489e-01f, -2.15884652e-02f, 9.99338329e-02f, 2.80748289e-02f, 1.46048456e-01f, -1.20752804e-01f, -7.27964938e-02f,
  -2.26823594e-02f, 1.63154885e-01f, -1.08964048e-01f, -6.80327863e-02f, -5.07402122e-02f, -5.56952059e-02f, 8.30751732e-02f, -5.21663092e-02f, -7.99480528e-02f, -5.83460815e-02f,
  3.48684937e-02f, -6.90356568e-02f, -2.53813446e-01f, -4.77748439e-02f, -8.50626547e-03f, 6.33636117e-02f, 4.31817546e-02f, 4.23703827e-02f, -3.26323286e-02f, -3.20610628e-02f,
  2.20961958e-01f, -1.83226343e-03f, -3.74096842e-03f, -6.17080927e-02f, 1.25917330e-01f, 6.27067909e-02f, -1.67067517e-02f, 1.08697116e-02f, 7.36994743e-02f, 1.94821544e-02f,
  -3.31641026e-02f, 2.83504315e-02f, 9.56019014e-02f, 8.70367512e-02f, 6.73287660e-02f, 1.01330347e-01f, 6.37360141e-02f, 9.69141275e-02f, 7.00366423e-02f, 1.67257879e-02f,
  5.67567870e-02f, 9.47391912e-02f, 5.86303063e-02f, 5.73159568e-02f, 4.82566617e-02f, 6.71752989e-02f, 9.49868374e-03f, 1.05039142e-01f, 4.28491607e-02f, 1.01979934e-01f,
  6.92793652e-02f, -1.04894228e-01f, 1.26863420e-01f, 1.57519817e-01f, 4.42494117e-02f, 6.19388334e-02f, -8.20998475e-02f, 7.61479288e-02f, 7.26244822e-02f, -6.42336085e-02f,
  -3.85591500e-02f, -1.19336918e-01f, 6.43416196e-02f, 1.50893945e-02f, 5.20750172e-02f, -1.52103990e-01f, 1.03319354e-01f, 1.87668093e-02f, 6.52092844e-02f, 1.28682986e-01f,
  -9.37301442e-02f, 1.06041096e-02f, 4.22378071e-05f, 2.64758114e-02f, -1.67724900e-02f, 6.41054660e-02f, 9.85503793e-02f, 1.62016019e-01f, 1.27276435e-01f, -4.28583883e-02f,
  -3.66739482e-02f, -6.96659647e-03f, 4.99494746e-02f, 5.19572459e-02f, -1.34524897e-01f, -6.20979741e-02f, 3.69701982e-02f, 3.59070897e-02f, 7.86455069e-03f, -5.20872064e-02f,
  2.62962338e-02f, 3.40909660e-02f, 2.72513572e-02f, -4.93308119e-02f, 1.91469362e-03f, 4.71539311e-02f, -3.88842598e-02f, -3.66705023e-02f, 2.14129481e-02f, -2.68674958e-02f,
  1.89176528e-03f, 1.25541622e-02f, -1.63526703e-02f, 3.42179579e-03f, 2.62359204e-03f, 2.52897870e-02f, -7.41563970e-03f, 1.25694359e-02f, -2.04344392e-02f, 2.65891831e-02f,
  -1.66988277e-04f, 2.91106068e-02f, -7.33536780e-02f, -1.05557345e-01f, -8.19996595e-02f, -1.20947585e-02f, -8.26854482e-02f, -5.26771434e-02f, 3.21106873e-02f, 2.55601797e-02f,
  -8.07515904e-03f, -8.87172595e-02f, -3.35658453e-02f, 2.88174674e-02f, -3.69875878e-02f, 1.54875619e-02f, -6.64090812e-02f, -2.09008045e-02f, -3.95656005e-03f, 1.37025625e-01f,
  1.43442648e-02f, 9.35901701e-03f, -2.12316937e-03f, -1.23409003e-01f, 3.72028560e-03f, -2.88135484e-02f, -2.86977757e-02f, -9.27469879e-02f, 5.67107163e-02f, -8.59664157e-02f,
  -2.88479030e-02f, -1.65576562e-02f, -7.49839097e-02f, 1.26212239e-01f, -3.12957838e-02f, 2.55024265e-02f, 1.55115891e-02f, 2.16752551e-02f, 1.76413674e-02f, 1.36356369e-01f,
  -1.74527578e-02f, 1.21066988e-01f, 1.01182431e-01f, 8.65881052e-03f, -5.51116914e-02f, -3.30224745e-02f, -1.87285729e-02f, 1.99799277e-02f, -8.77714828e-02f, 1.36905033e-02f,
  8.51125717e-02f, 1.22499457e-02f, 9.25314333e-03f, 3.09189856e-02f, 6.31347224e-02f, 3.21607217e-02f, 1.20006159e-01f, -4.67398297e-03f, -3.59345647e-03f, 5.23623377e-02f,
  2.40298957e-02f, 4.89255637e-02f, 4.76181433e-02f, -5.36682382e-02f, 3.92984450e-02f, 8.49380810e-03f, -1.27566606e-02f, 1.31468222e-01f, 3.69175076e-02f, -1.20172903e-01f,
  1.03123389e-01f, 1.47576824e-01f, 4.97193709e-02f, 7.73700997e-02f, -4.02894132e-02f, -3.21800937e-04f, 6.56299889e-02f, -9.31933373e-02f, -1.03538983e-01f, -1.48082286e-01f,
  3.06256991e-02f, 7.36208782e-02f, 2.29187422e-02f, -1.66200340e-01f, 1.20142847e-01f, 1.57838613e-02f, 9.73439664e-02f, 7.06498250e-02f, -5.83003275e-02f, 1.70708541e-02f,
  -1.74729675e-02f, 5.70958927e-02f, -3.02149896e-02f, 1.23921022e-01f, 1.03681721e-01f, 2.95543391e-02f, -5.28218821e-02f, 2.94980779e-02f, -7.74130821e-02f, 7.65432119e-02f,
  -5.03442846e-02f, -2.31836904e-02f, -5.35066128e-02f, -2.77764210e-03f, 2.68360935e-02f, 1.14355043e-01f, 9.90811139e-02f, 3.05995159e-02f, 8.37406740e-02f, 4.48141769e-02f,
  8.76886249e-02f, -4.47823294e-02f, 5.65269068e-02f, 4.91131544e-02f, 4.95551750e-02f, -1.92660652e-03f, -3.05745658e-03f, 1.80055648e-02f, -4.30219360e-02f, -4.04848047e-02f,
  5.82846217e-02f, -4.27909894e-03f, -1.45733496e-02f, 4.64160405e-02f, 9.46145505e-02f, 7.43630202e-03f, -2.91768890e-02f, 1.16043007e-02f, 4.40240689e-02f, 8.96565616e-02f,
  6.79289876e-03f, -8.24809354e-03f, 1.10931873e-01f, -1.07588284e-02f, -7.35837147e-02f, -8.80193859e-02f, 8.88325348e-02f, -5.37206121e-02f, 7.60059878e-02f, -7.81843737e-02f,
  -8.43594223e-02f, 1.32256359e-01f, 1.20371301e-02f, 7.81728178e-02f, -2.67694853e-02f, 3.83145548e-02f, 3.80653143e-02f, -1.49000421e-01f, -9.01029781e-02f, -2.06803188e-01f,
  2.11628843e-02f, 1.27762973e-01f, 5.18694967e-02f, 1.86175898e-01f, -2.81964391e-02f, -8.35214555e-02f, -1.29587784e-01f, -1.22336186e-01f, -5.27210794e-02f, 4.07150388e-02f,
  1.38752222e-01f, -1.21973939e-01f, -5.99048100e-02f, -1.11340478e-01f, 1.04474714e-02f, -7.83952400e-02f, 5.72330020e-02f, -3.04650739e-02f, 2.03759789e-01f, -2.03618452e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  1.02777369e-01f, 2.15302240e-02f, 1.10046394e-01f, 7.34945089e-02f, 1.04406819e-01f, -1.67526230e-02f, 5.83057441e-02f, 1.27705827e-01f, 4.21889499e-02f, 2.31481288e-02f,
  9.75411478e-03f, 4.39865552e-02f, 1.41210437e-01f, 1.75083727e-01f, -4.16084714e-02f, 2.57647000e-02f, 4.59897816e-02f, -1.96713675e-02f, 7.54324719e-02f, 1.12142183e-01f,
  1.44023836e-01f, 3.78431454e-02f, 1.24666363e-01f, -1.71658490e-02f, 3.05025955e-03f, -8.95198509e-02f, 7.29302838e-02f, -5.50426506e-02f, -1.60361066e-01f, 5.80589697e-02f,
  6.20611981e-02f, 3.01419228e-01f, -1.98061034e-01f, -3.80735882e-02f, -1.83485121e-01f, 2.35891268e-02f, 4.08761948e-02f, -2.29084656e-01f, 2.52244882e-02f, 5.85026257e-02f,
  1.34865820e-01f, 3.62636372e-02f, 2.02443108e-01f, -6.01501353e-02f, -1.48908287e-01f, -1.48426801e-01f, -1.99891806e-01f, 8.66647884e-02f, -3.83450389e-02f, -5.77259921e-02f,
  1.76268414e-01f, -5.06572127e-02f, 2.68686324e-01f, 4.36614901e-02f, 1.69703513e-01f, 3.54858100e-01f, 9.84687433e-02f, -1.53258294e-01f, 2.85853207e-01f, 1.97222948e-01f,
  5.54396994e-02f, 2.28013322e-01f, 1.28598079e-01f, -1.55662326e-02f, 1.25708029e-01f, 6.14296319e-03f, 1.14032194e-01f, 9.53158811e-02f, 7.84984678e-02f, -1.96206912e-01f,
  9.33702663e-02f, 1.52550980e-01f, 2.52647027e-02f, -1.92630535e-03f, 1.60549544e-02f, -5.66485189e-02f, 2.77270116e-02f, 4.20931838e-02f, 3.96586284e-02f, -1.56290960e-02f,
  3.96741889e-02f, 1.02280103e-01f, -8.72607157e-03f, -1.68755539e-02f, 5.27979881e-02f, 7.45498016e-02f, 1.78809445e-02f, 7.34161660e-02f, -1.05415165e-01f, -1.48026064e-01f,
  -1.48042487e-02f, -1.21879444e-01f, -1.75958440e-01f, -1.45931080e-01f, 1.06660590e-01f, 9.22770575e-02f, -2.03785137e-03f, -1.41558766e-01f, -2.06373408e-01f, 1.58943638e-01f,
  -8.56828690e-02f, 2.65032090e-02f, -7.30506405e-02f, 6.40644506e-03f, 4.55221497e-02f, 2.62867380e-02f, 2.08806042e-02f, -2.40728423e-01f, -1.46115404e-02f, -2.77702287e-02f,
  -4.18776870e-02f, 1.79154426e-01f, -1.58194125e-01f, -2.34164849e-01f, 4.85141715e-03f, -1.86724186e-01f, 2.85940543e-02f, -3.18643381e-03f, 1.83188394e-01f, 2.03057691e-01f,
  -1.20427310e-01f, -1.66117579e-01f, 1.81501687e-01f, -2.79162694e-02f, 1.49193048e-01f, 2.47658208e-01f, 2.26953104e-01f, -1.82344079e-01f, 6.21074885e-02f, 6.86991885e-02f,
  -7.54258335e-02f, -9.56370379e-04f, -6.91311881e-02f, 8.01565200e-02f, -9.41371173e-02f, 1.00457907e-01f, 1.08423308e-01f, 5.89564890e-02f, 6.74578622e-02f, 1.68703392e-03f,
  5.48936520e-03f, 8.29545632e-02f, 2.69289706e-02f, 8.28070939e-02f, 1.85860973e-02f, -6.94435462e-02f, 7.21415281e-02f, 5.68170398e-02f, 5.60389347e-02f, 3.55186276e-02f,
  5.57379201e-02f, 7.26452693e-02f, -2.01551504e-02f, 1.51079789e-01f, 6.83531985e-02f, -2.21132785e-01f, 1.86663583e-01f, 1.43155187e-01f, 5.74747585e-02f, 2.22588629e-01f,
  -1.28347501e-01f, -6.57898039e-02f, 1.68303207e-01f, -1.16655938e-01f, -2.34525204e-01f, -1.51103199e-01f, 3.36658861e-03f, 1.72335103e-01f, -5.25110066e-02f, -1.39895082e-01f,
  2.30287150e-01f, -3.14904610e-03f, 1.81492135e-01f, 4.97249588e-02f, -6.00822270e-02f, 1.25067770e-01f, -1.85656682e-01f, 4.92546707e-02f, 4.18005437e-02f, 1.58834606e-01f,
  1.59458652e-01f, 5.84749058e-02f, -2.07492486e-02f, 2.44158745e-01f, -1.34762004e-01f, 1.03745610e-01f, 2.43295524e-02f, 1.37122706e-01f, -1.43505456e-02f, 3.73439640e-01f,
  -5.44727296e-02f, 1.40824765e-01f, 7.89898112e-02f, 2.98997983e-02f, 1.77899465e-01f, 9.52999294e-02f, 2.16066893e-02f, 3.77757405e-03f, 7.30405152e-02f, 1.47215083e-01f,
  -2.22494807e-02f, 8.45334381e-02f, 8.58882442e-02f, 2.41111144e-02f, 2.53197085e-02f, 6.85756430e-02f, 1.07740639e-02f, 2.12347116e-02f, 8.19483548e-02f, 1.70347184e-01f,
  8.58115628e-02f, 2.91117188e-03f, 7.19125122e-02f, 1.28129516e-02f, 9.57046971e-02f, 1.40210822e-01f, 3.61845866e-02f, -1.65192276e-01f, -3.15470636e-01f, 9.35558975e-02f,
  -1.26506776e-01f, -1.30722523e-01f, 4.49020006e-02f, -3.86528857e-02f, -2.79949568e-02f, -1.16337776e-01f, -6.78384537e-03f, 7.79987052e-02f, 2.71532148e-01f, 1.74285635e-01f,
  1.22805163e-01f, -3.73264283e-01f, 1.28176764e-01f, 2.04425588e-01f, -2.12995693e-01f, 1.86920434e-01f, -2.51316130e-01f, -1.01553187e-01f, -8.13672766e-02f, -2.07715482e-01f,
  1.10507563e-01f, 2.73269285e-02f, 2.97807574e-01f, -2.54093506e-03f, -7.13497698e-02f, 2.10852221e-01f, 2.34620109e-01f, 1.40103526e-04f, -2.93171182e-02f, 1.07327335e-01f,
  9.76140350e-02f, 2.59754300e-01f, 9.29948241e-02f, -1.95270792e-01f, 2.05756485e-01f, 1.18377976e-01f, 5.31920642e-02f, 1.08354725e-01f, 4.83159162e-02f, -6.46880548e-03f,
  1.58871680e-01f, 6.76535293e-02f, 1.43279672e-01f, 8.12278092e-02f, 6.63016215e-02f, 8.27285722e-02f, 1.02384374e-01f, 1.34942681e-01f, -5.83012477e-02f, 1.72254331e-02f,
  1.15741536e-01f, 1.31819889e-01f, 1.21875197e-01f, 1.17913373e-01f, -6.49164915e-02f, 1.03950940e-01f, 9.24609080e-02f, 1.53007299e-01f, 2.36945394e-02f, 1.03041954e-01f,
  5.01393378e-02f, -1.41813532e-01f, 4.62964252e-02f, 2.01038241e-01f, -2.51586083e-02f, -1.29939899e-01f, 1.72908418e-02f, -3.96265596e-01f, 2.18028173e-01f, -1.45685554e-01f,
  4.45364378e-02f, 1.00076891e-01f, -3.20786908e-02f, 3.26321959e-01f, -1.03655078e-01f, -1.24824531e-01f, -7.91319832e-02f, -7.09634796e-02f, -2.55379021e-01f, 1.30118551e-02f,
  1.36960641e-01f, 1.41989276e-01f, 2.71103978e-01f, -5.84081970e-02f, 4.00414765e-02f, 8.02905783e-02f, -1.31012589e-01f, 2.06696108e-01f, -1.29886702e-01f, 1.71114191e-01f,
  -1.00439474e-01f, -2.37132072e-01f, -2.22487152e-02f, 2.67409742e-01f, -1.42378360e-01f, -1.38844579e-01f, 2.66674668e-01f, -1.80422202e-01f, 2.13636726e-01f, 2.15033479e-02f,
  6.42303154e-02f, 6.11238740e-02f, 7.83904269e-02f, 1.22437775e-01f, 6.25961646e-02f, -5.56405559e-02f, 6.86431155e-02f, -6.47265092e-02f, 3.81751135e-02f, 8.29075873e-02f,
  1.30055293e-01f, 1.03919916e-01f, -3.84006947e-02f, -6.27746359e-02f, 5.97644150e-02f, -1.56852771e-02f, 1.65909320e-01f, 1.45064602e-02f, 7.97038823e-02f, -6.76386477e-03f,
  3.85423861e-02f, 2.81440909e-03f, 2.00082026e-02f, 1.46701902e-01f, 4.61361893e-02f, -6.59428835e-02f, 1.18934326e-01f, 5.10295779e-02f, 2.07287241e-02f, -1.77589148e-01f,
  9.47809741e-02f, -2.90239573e-01f, 2.73985237e-01f, -1.38736665e-01f, -1.29117295e-01f, 1.40060365e-01f, -4.67169890e-03f, 3.07451814e-01f, -1.09829284e-01f, 3.44184004e-02f,
  -8.98208693e-02f, -1.34139568e-01f, -1.95384681e-01f, -2.35259622e-01f, 9.87724885e-02f, 3.13192040e-01f, 2.14402378e-01f, 1.20896168e-01f, -7.06526265e-02f, -8.79383907e-02f,
  -1.37263641e-01f, 9.67664644e-02f, -2.23700702e-01f, -3.38450894e-02f, 1.22533672e-01f, -2.19523206e-01f, -2.92751249e-02f, 5.34056760e-02f, -7.44157881e-02f, -2.52739340e-01f,
  3.15374047e-01f, -2.01848879e-01f, 1.78527266e-01f, -2.44527295e-01f, 5.69182634e-02f, 5.28425500e-02f, -8.23589787e-03f, -3.95622663e-02f, 5.73543236e-02f, 1.13809161e-01f,
  -4.40728143e-02f, 1.31082296e-01f, 1.27467945e-01f, 3.58603112e-02f, 1.31937638e-01f, 8.16064626e-02f, 9.70206130e-03f, 8.45665932e-02f, 1.42162308e-01f, 6.71678036e-02f,
  4.60603610e-02f, 6.28927797e-02f, 4.31720316e-02f, 5.56940213e-02f, 9.79278833e-02f, 1.32799521e-01f, 7.79594854e-02f, 7.53318444e-02f, 6.82182088e-02f, 3.58378626e-02f,
  -8.34187493e-02f, 1.33404747e-01f, 1.85119033e-01f, 9.73109081e-02f, 1.07713893e-01f, -2.54998267e-01f, 9.23723578e-02f, -8.20959732e-02f, 2.29426116e-01f, -8.56266767e-02f,
  -4.47135903e-02f, 1.01901695e-01f, -3.55607718e-02f, -1.60863936e-01f, -4.18254770e-02f, -9.77603719e-02f, -1.23103939e-01f, 1.70749947e-01f, 1.36765406e-01f, 1.78259574e-02f,
  9.76200402e-02f, -5.77836744e-02f, 5.79391494e-02f, 1.93971425e-01f, -9.21786204e-03f, 2.55674303e-01f, 2.44160630e-02f, 9.34948027e-02f, -9.84360427e-02f, -1.16322495e-01f,
  -1.70458872e-02f, 3.35245848e-01f, -1.65021062e-01f, 3.18115987e-02f, -5.79369720e-03f, -1.57901570e-02f, 1.51130646e-01f, 2.47941703e-01f, 9.57725868e-02f, 1.25753865e-01f,
  9.38939229e-02f, 1.99379586e-02f, 6.61599934e-02f, 1.71881005e-01f, -2.43997406e-02f, -1.24059673e-02f, 1.45585701e-01f, 1.07889690e-01f, 5.71646951e-02f, 8.65855142e-02f,
  4.66793636e-03f, 1.07648931e-01f, 2.49899626e-01f, 1.11972526e-01f, -2.60181166e-02f, 5.94211258e-02f, 9.50600430e-02f, 9.13916156e-02f, 1.50609463e-01f, 1.15810700e-01f,
  1.36729568e-01f, 7.35702366e-02f, 1.06077582e-01f, 1.51641279e-01f, 2.07919002e-01f, -4.48591821e-02f, 1.55975834e-01f, 1.43034279e-01f, 1.52027756e-01f, 1.31791679e-03f,
  -5.68852164e-02f, 2.73318086e-02f, 7.25189447e-02f, -4.81896736e-02f, -1.35028407e-01f, -1.33895427e-01f, 7.38438442e-02f, 1.68765157e-01f, 6.76336745e-03f, -3.58670831e-01f,
  9.08433571e-02f, -1.22358203e-01f, 1.77402228e-01f, 2.38584846e-01f, 1.69614647e-02f, 1.91017047e-01f, 5.91916544e-03f, 1.33485585e-01f, -1.60345301e-01f, 2.20368445e-01f,
  2.58251458e-01f, 2.39405781e-01f, 1.30258471e-01f, -1.57202840e-01f, -3.89914736e-02f, 1.19424917e-01f, 1.18176855e-01f, -7.70018548e-02f, 7.17089772e-02f, -1.48888035e-02f,
  9.99922231e-02f, -1.18553480e-02f, -1.64741009e-01f, 1.14641208e-02f, 3.69558111e-02f, -8.52215290e-02f, 7.41947666e-02f, 1.43139198e-01f, -1.26715489e-02f, -6.17593043e-02f,
  -8.07871595e-02f, 3.19244862e-02f, 9.41217244e-02f, -1.87113564e-02f, 1.29229844e-01f, 9.92140025e-02f, -1.00337744e-01f, 1.21231101e-01f, 7.15404227e-02f, -1.44830376e-01f,
  9.88779739e-02f, 1.16243877e-01f, 1.20989986e-01f, 1.13612503e-01f, 9.29311812e-02f, -8.73946249e-02f, 5.14885932e-02f, 4.98244427e-02f, 8.45900252e-02f, 6.13621846e-02f,
  1.18668981e-01f, 1.56735882e-01f, -1.05340227e-01f, 1.14749014e-01f, -9.33426768e-02f, 8.18176419e-02f, 5.79281338e-02f, -2.32676297e-01f, 2.66394205e-02f, -1.01406112e-01f,
  -2.60293391e-02f, 1.11905001e-01f, 2.99494769e-02f, 1.23391032e-01f, 1.81439146e-01f, 2.56655157e-01f, -3.04737817e-02f, -1.48789644e-01f, -1.05311953e-01f, -2.30929807e-01f,
  6.78419545e-02f, 1.19940497e-01f, 1.97517738e-01f, 8.34819525e-02f, 1.79607883e-01f, 2.93229446e-02f, -2.04596967e-02f, 3.69716793e-01f, 2.99942642e-01f, 1.17641203e-01f,
  3.91308218e-02f, 2.07942441e-01f, 3.33964191e-02f, 1.83661312e-01f, -1.29195645e-01f, 2.07987607e-01f, 1.87383935e-01f, 1.16161235e-01f, 1.94917381e-01f, 1.40762001e-01f,
  8.83833244e-02f, -3.88602889e-03f, 1.28501013e-01f, 1.32109448e-01f, 1.23783827e-01f, 8.97934660e-02f, 1.62437290e-01f, 1.34925395e-01f, 1.87481884e-02f, 3.31302397e-02f,
  1.34267136e-01f, 9.72893983e-02f, 1.76135004e-02f, 1.32524848e-01f, 1.21138774e-01f, 5.33030853e-02f, 9.25172865e-02f, 1.58988997e-01f, 2.05674451e-02f, 1.29836246e-01f,
  1.10040165e-01f, -1.19920716e-01f, 6.30970374e-02f, -1.31871225e-02f, -1.88594937e-01f, -1.52418032e-01f, 1.65103048e-01f, -7.97461197e-02f, 8.84535611e-02f, -1.49661183e-01f,
  -2.01805219e-01f, 1.77545309e-01f, 7.68094361e-02f, 9.84748751e-02f, -7.60762440e-03f, -5.42291030e-02f, 1.14289522e-01f, -1.58783495e-01f, -1.64496779e-01f, -2.10314155e-01f,
  -8.06363299e-02f, 1.37895674e-01f, 1.89009327e-02f, 1.65937543e-01f, 4.98200394e-02f, -6.12783283e-02f, -5.02249934e-02f, -7.85354748e-02f, -4.72119376e-02f, 1.82572186e-01f,
  2.79002994e-01f, -9.47614089e-02f, -2.89760549e-02f, 1.88982245e-02f, 2.60935366e-01f, -3.02457642e-02f, 2.93168008e-01f, -8.47795829e-02f, 3.90067846e-01f, -1.69783786e-01f,
  1.93004116e-01f, 1.10221244e-01f, 4.70595323e-02f, 1.00439347e-01f, 6.38199896e-02f, 1.44153476e-01f, -3.83257680e-02f, 9.86822397e-02f, 1.56940296e-01f, 1.46334305e-01f,
  1.57321602e-01f, 1.46964312e-01f, 4.74672355e-02f, 6.98884651e-02f, 5.07483855e-02f, 9.44027603e-02f, 9.00105834e-02f, 1.06131315e-01f, 9.70293134e-02f, 8.42548013e-02f,
  1.07128710e-01f, 8.19985271e-02f, 3.79191414e-02f, 1.74773827e-01f, 9.73974541e-02f, 3.29318047e-02f, -8.39072764e-02f, 1.65493600e-02f, 8.75476673e-02f, 1.34021059e-01f,
  1.16744146e-01f, -8.05962607e-02f, -6.09932058e-02f, -5.61606213e-02f, 1.17768392e-01f, 8.96372949e-04f, 8.83324072e-02f, 6.71821311e-02f, 1.27304420e-01f, -2.34712973e-01f,
  8.32974315e-02f, -9.63498950e-02f, -9.07761306e-02f, 1.50312945e-01f, -9.13010687e-02f, 9.45329368e-02f, -2.97513157e-02f, -1.71390176e-01f, 7.44602680e-02f, 1.98622227e-01f,
  1.22482039e-01f, 2.47918934e-01f, 9.93618891e-02f, 3.18632543e-01f, 2.40821019e-01f, -6.65287152e-02f, -8.14571977e-02f, 1.72265634e-01f, 6.57844963e-03f, 1.76763415e-01f,
  7.98675641e-02f, -1.25110641e-01f, 1.89171910e-01f, 2.36321583e-01f, 1.87199742e-01f, 1.10061899e-01f, 1.62628833e-02f, 1.04706854e-01f, 4.62870188e-02f, 2.19928265e-01f,
  -6.20266013e-02f, 7.33591691e-02f, 2.35741481e-01f, 1.62388027e-01f, 5.69906905e-02f, 1.57032460e-01f, 5.10665961e-02f, 6.55931234e-02f, 1.60614818e-01f, 1.52630331e-02f,
  -1.69342030e-02f, 1.18870899e-01f, 8.66153985e-02f, 1.01156950e-01f, 8.11244324e-02f, 7.37484768e-02f, 2.89949290e-02f, 1.02846004e-01f, 2.15685889e-01f, 1.86910331e-01f,
  1.93672821e-01f, -1.37068614e-01f, 1.24212362e-01f, 1.92192540e-01f, 1.30727202e-01f, 4.40676846e-02f, -1.31741822e-01f, 7.36859441e-02f, 8.14340860e-02f, -6.66616261e-02f,
  -2.83967983e-02f, -1.51330844e-01f, 2.27312908e-01f, 1.67162474e-02f, 9.84318033e-02f, -3.83738250e-01f, 1.08602226e-01f, -1.00157417e-01f, 1.84360743e-02f, 2.32607543e-01f,
  -4.03348617e-02f, 9.10013840e-02f, 1.06589504e-01f, 1.22000545e-01f, -9.46768448e-02f, 1.69474080e-01f, 2.81302452e-01f, 3.08555901e-01f, 3.32221866e-01f, -1.60407960e-01f,
  -7.08749294e-02f, 5.99101484e-02f, 2.12149113e-01f, 2.16690730e-03f, -1.27083212e-01f, -1.17839575e-01f, 2.09697530e-01f, 4.38463986e-02f, 3.14542018e-02f, 1.27678411e-02f,
  8.42400491e-02f, 6.60235360e-02f, 2.47437265e-02f, -1.66738957e-01f, 1.06008545e-01f, 1.52577862e-01f, -5.16880602e-02f, -2.23206263e-02f, 8.36879537e-02f, -6.90178871e-02f,
  2.44843215e-02f, 2.73215678e-02f, -7.63979256e-02f, 1.16410859e-01f, 3.49578299e-02f, 5.90207055e-02f, 3.38286012e-02f, -3.94123420e-02f, 3.70279998e-02f, 9.07271430e-02f,
  8.27367902e-02f, 1.14640526e-01f, -8.03372115e-02f, -2.34069020e-01f, -9.91664380e-02f, 3.02678607e-02f, -1.62610054e-01f, -2.13648930e-01f, 6.86197802e-02f, -1.01949826e-01f,
  1.46553338e-01f, -2.56438881e-01f, -1.10161014e-01f, 1.67519480e-01f, -4.78232615e-02f, 2.39710078e-01f, -2.37010956e-01f, -5.55076525e-02f, -4.78757992e-02f, 2.40228668e-01f,
  -1.13222912e-01f, -1.42263293e-01f, -5.17004821e-03f, -5.23309596e-02f, 1.18271850e-01f, 6.31590858e-02f, -1.67432517e-01f, -1.61985412e-01f, 1.33594081e-01f, -5.93288690e-02f,
  -2.38925219e-01f, 4.45534550e-02f, -8.13797191e-02f, 2.95333505e-01f, -1.06398417e-02f, 4.14727554e-02f, -2.45975778e-02f, 4.87053432e-02f, 3.72721970e-01f, 1.65117636e-01f,
  1.44403100e-01f, -5.11771925e-02f, -1.36807645e-02f, 9.52299088e-02f, 1.92148462e-02f, 7.93813355e-03f, 5.06474003e-02f, -1.27954245e-01f, -7.28149526e-03f, 3.47558185e-02f,
  3.61596383e-02f, -8.45766626e-03f, 9.60104018e-02f, -1.84217840e-02f, 7.10631162e-02f, 1.92184746e-02f, 4.37902063e-02f, 1.33462027e-01f, 1.08303405e-01f, -5.04799886e-03f,
  2.84866765e-02f, 4.73261699e-02f, 1.13096230e-01f, 9.06348154e-02f, 9.03281942e-02f, 1.15302153e-01f, -1.08718798e-01f, 5.33551909e-03f, 2.29980901e-01f, -1.45671114e-01f,
  5.54190204e-02f, -3.76735590e-02f, 8.19783136e-02f, -3.74714062e-02f, 9.79179516e-02f, -1.34509504e-01f, -4.70260717e-02f, 1.70290582e-02f, -2.80856490e-01f, -6.28452399e-04f,
  -1.88260317e-01f, 2.66345054e-01f, -1.64833561e-01f, -1.00032009e-01f, 9.12826210e-02f, -1.68976262e-01f, 2.83725947e-01f, 5.44542857e-02f, 6.86962083e-02f, 2.19641298e-01f,
  -2.43417531e-01f, -1.24849118e-01f, -7.42493793e-02f, 1.74730457e-02f, 8.42731539e-03f, -1.83460787e-02f, -1.87908351e-01f, 2.32206330e-01f, -2.80233044e-02f, 1.28850117e-01f,
  -6.02943562e-02f, -5.67645878e-02f, 2.79093087e-01f, 3.80311996e-01f, 1.48229688e-01f, -9.98129547e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  1.46566302e-01f, 5.45020588e-02f, -5.11212274e-03f, 4.81781848e-02f, 9.72336009e-02f, 8.40545148e-02f, 5.50464466e-02f, 1.23588853e-01f, 8.98357034e-02f, 9.18149501e-02f,
  6.29410446e-02f, 4.67681848e-02f, 4.68196124e-02f, 9.32855606e-02f
};

// L3_fan_Wp (Shape: 25 x 64)
const int L3_fan_Wp_rows = 25;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  1.18274666e-01f, 8.58945176e-02f, 1.84365436e-02f, -1.50303230e-01f, -3.10652331e-02f, 6.38314635e-02f, 7.97167271e-02f, 1.95111451e-03f, 8.74865160e-04f, -2.00328305e-02f,
  8.67748782e-02f, 4.39591110e-02f, -3.49416165e-03f, -1.45902047e-02f, -3.80854234e-02f, 5.59010394e-02f, 1.37658909e-01f, 1.35805421e-02f, -6.12225868e-02f, 1.19146332e-01f,
  2.03741770e-02f, 5.24943136e-02f, 5.73254703e-03f, 8.17449093e-02f, 8.35908502e-02f, -2.35050619e-02f, 1.50071964e-01f, 8.38539898e-02f, -4.57631834e-02f, -5.48423901e-02f,
  -1.42615408e-01f, 2.73579303e-02f, -3.75097245e-02f, 4.38664481e-02f, 6.14043884e-03f, -1.57502130e-01f, 8.32796544e-02f, 3.05013582e-02f, 9.05773714e-02f, -5.19479290e-02f,
  1.02993779e-01f, -1.88899711e-02f, 1.93710905e-02f, -5.65954410e-02f, -2.84207352e-02f, -7.35273212e-02f, -6.86596334e-02f, 4.86030765e-02f, -1.55592766e-02f, -3.43971066e-02f,
  1.74076423e-01f, 4.29442637e-02f, -1.31005287e-01f, 1.12891056e-01f, -6.10535033e-02f, -1.62578121e-01f, -5.12135625e-02f, -4.74324562e-02f, 1.29599839e-01f, 4.74573635e-02f,
  -3.49485362e-03f, 1.94041822e-02f, 2.42398437e-02f, -1.34974554e-01f, 2.64197923e-02f, 2.21577697e-02f, -3.75542007e-02f, -3.67161445e-02f, -5.92665859e-02f, 3.56672704e-02f,
  6.66377991e-02f, -1.42573463e-02f, -7.22571462e-02f, 2.54258122e-02f, -3.06972321e-02f, 5.82057349e-02f, -5.02470694e-02f, 7.32105318e-03f, 1.04967214e-01f, -9.97469854e-03f,
  3.43673192e-02f, 1.88578886e-03f, 9.21399426e-03f, -4.58674766e-02f, -6.55423254e-02f, -2.04774248e-03f, -3.23955491e-02f, -4.68805153e-03f, 1.03676645e-02f, -3.89665253e-02f,
  1.37605602e-02f, 9.16492343e-02f, -4.21773046e-02f, 4.25764024e-02f, 6.58078790e-02f, 2.72355657e-02f, -1.76720828e-01f, 9.91599932e-02f, -6.67456388e-02f, 1.38887435e-01f,
  -1.28546536e-01f, -1.61332432e-02f, -1.43335477e-01f, 4.07824181e-02f, 4.54485379e-02f, -5.71907964e-03f, 9.71260443e-02f, 1.39998093e-01f, 1.12531535e-01f, 8.77177063e-03f,
  4.37543206e-02f, 2.37903725e-02f, -3.21889087e-03f, 6.65812194e-02f, -3.48452218e-02f, 7.34855309e-02f, 1.55714557e-01f, -1.37197733e-01f, -1.65176973e-01f, 4.24727835e-02f,
  9.44132283e-02f, 3.72777432e-02f, 6.23680800e-02f, -6.96349144e-02f, -1.15697354e-01f, -3.46206990e-03f, 8.62147510e-02f, 2.01672927e-01f, 5.09020127e-02f, 4.59333323e-02f,
  4.71220873e-02f, -8.51864591e-02f, -9.63576958e-02f, 4.74735685e-02f, 3.70502137e-02f, 3.99401486e-02f, -4.86075729e-02f, 4.81119752e-02f, 4.27363068e-03f, 9.94585827e-02f,
  7.67719224e-02f, 9.72566083e-02f, 9.05161351e-03f, 4.93974276e-02f, 4.08850200e-02f, 1.03888530e-02f, -1.19054737e-02f, 9.52893496e-02f, 9.52188671e-03f, 3.99758480e-02f,
  5.50539009e-02f, -1.08522493e-02f, -2.00152826e-02f, -8.54046345e-02f, 1.74909651e-01f, 1.60565168e-01f, -3.05759106e-02f, 7.27356374e-02f, -1.25378549e-01f, 9.97633412e-02f,
  -1.12750165e-01f, 4.10683230e-02f, -9.18097347e-02f, -3.43204550e-02f, 1.67799015e-02f, -6.15520515e-02f, 1.12132490e-01f, -3.11311800e-02f, 4.62466739e-02f, -3.70651223e-02f,
  -7.79374540e-02f, -1.09366387e-01f, 3.34883444e-02f, -7.71558657e-02f, 2.12642606e-02f, 7.31363744e-02f, 2.28579603e-02f, 5.69881238e-02f, 1.50849923e-01f, 1.06544591e-01f,
  -8.91292468e-02f, 3.36101986e-02f, -9.06357765e-02f, -1.13417469e-01f, -1.00104548e-01f, 7.65443593e-02f, -1.95698738e-02f, 1.03133246e-01f, -7.45124593e-02f, 3.94652486e-02f,
  7.73694832e-03f, -3.82367685e-03f, 5.74558638e-02f, 3.89601961e-02f, -9.58043244e-03f, 5.26509173e-02f, -5.59368655e-02f, -5.54537289e-02f, -2.54106913e-02f, -4.62648198e-02f,
  8.58496502e-03f, 1.82596240e-02f, -2.08960697e-02f, -6.51276112e-02f, -9.16778147e-02f, 2.29055844e-02f, -1.09456599e-01f, 2.79427487e-02f, 1.07998336e-02f, -5.99320158e-02f,
  -5.17924391e-02f, 2.97875125e-02f, -3.15157957e-02f, 2.04760339e-02f, 3.81379351e-02f, 1.09414710e-02f, -8.52930844e-02f, -4.41141203e-02f, -7.54003301e-02f, -1.74240838e-03f,
  8.85776877e-02f, 7.85606652e-02f, 2.13293508e-02f, -8.12459737e-02f, 1.02912307e-01f, -1.09024495e-01f, -1.70440599e-02f, -6.41101897e-02f, 1.21421374e-01f, 8.73591751e-02f,
  1.60028283e-02f, -4.40111682e-02f, -4.76348177e-02f, -2.71297600e-02f, -4.17061113e-02f, -3.48346420e-02f, -1.00224376e-01f, 9.61845964e-02f, 2.01161113e-02f, -6.37594834e-02f,
  -5.08267283e-02f, 6.98529929e-02f, -1.35506898e-01f, 2.28918362e-02f, -1.06960781e-01f, 9.38411281e-02f, 1.25016212e-01f, 2.01836437e-01f, -8.53642821e-02f, -1.03697680e-01f,
  -1.94186836e-01f, 1.15023695e-01f, 8.98564160e-02f, 2.76296381e-02f, 7.86985680e-02f, -2.72487123e-02f, -3.44083318e-03f, -1.60794724e-02f, -2.25072131e-02f, 4.45058942e-02f,
  6.81612194e-02f, -1.24984821e-02f, -3.93578112e-02f, 2.13938709e-02f, 2.88938172e-02f, -1.11643486e-02f, -2.44501792e-02f, 9.84914973e-03f, 2.23364029e-03f, 3.02164480e-02f,
  -5.55410720e-02f, -1.11370152e-02f, -2.12747827e-02f, -1.88642368e-02f, 2.96986997e-02f, 2.96535753e-02f, -2.16133446e-02f, -6.18225373e-02f, 1.15856268e-02f, 2.93859821e-02f,
  8.68455600e-03f, 7.91358203e-02f, -8.27420056e-02f, -5.37640266e-02f, 3.45116854e-02f, -2.60668714e-02f, -8.58843103e-02f, 1.82219036e-02f, 1.40357897e-01f, -1.12880751e-01f,
  8.57785419e-02f, -7.74994045e-02f, 8.42015743e-02f, 8.83921981e-02f, 3.63130458e-02f, 3.79600399e-03f, -7.72967041e-02f, -5.16977627e-03f, -5.80124296e-02f, -1.17217442e-02f,
  -9.15409327e-02f, -2.13659443e-02f, 5.46265803e-02f, 1.81869138e-02f, -6.88979849e-02f, -1.44483000e-02f, -8.83122534e-02f, -1.21275326e-02f, -6.85995743e-02f, 2.16093138e-01f,
  1.15111515e-01f, -9.61300880e-02f, 7.59860277e-02f, -1.01358175e-01f, -1.13390617e-01f, 4.76954691e-02f, 1.87151030e-01f, 9.77661610e-02f, -6.62549958e-02f, -1.85108632e-01f,
  -1.40958102e-02f, -6.06085174e-03f, 3.28306369e-02f, 4.04275060e-02f, 1.16601050e-01f, 3.27557549e-02f, 1.24620264e-02f, -1.69561617e-02f, 7.84448069e-03f, -1.83258019e-02f,
  -4.31003943e-02f, 6.27717525e-02f, 1.94315873e-02f, -4.18813573e-03f, 5.25146089e-02f, -3.98443751e-02f, -8.35323930e-02f, 4.95761707e-02f, -7.43316347e-03f, -5.51478378e-02f,
  2.40943930e-03f, -1.09733343e-01f, -1.20241661e-02f, -9.06045213e-02f, 6.60125837e-02f, 1.47763327e-01f, 2.60138027e-02f, -9.50136185e-02f, 1.07280247e-01f, -1.07360631e-01f,
  5.18545136e-02f, -3.33281159e-02f, 1.43149823e-01f, 4.69511794e-03f, 1.48876850e-02f, 8.28360766e-02f, -4.25195359e-02f, 5.70060946e-02f, -1.47730187e-01f, -1.08170561e-01f,
  -7.51707479e-02f, 9.13534686e-02f, 7.18173683e-02f, 1.78599611e-01f, 7.48840496e-02f, -1.03501119e-01f, 2.77097672e-02f, 5.62822260e-03f, 5.79980090e-02f, -5.54498881e-02f,
  -1.08635962e-01f, -1.33728445e-01f, 1.80649702e-02f, 1.71535574e-02f, 9.09017250e-02f, 3.18059064e-02f, 1.56274334e-01f, 9.50587466e-02f, 6.56934921e-03f, -1.32556096e-01f,
  1.43311813e-01f, 1.26955165e-02f, -7.61258528e-02f, -9.16617811e-02f, -7.75853917e-02f, -1.10392570e-01f, 2.77752616e-02f, 1.61124453e-01f, 8.31426233e-02f, -7.57236257e-02f,
  -6.59134006e-03f, -5.57290809e-03f, 1.06765375e-01f, -2.71972846e-02f, 3.17956950e-03f, -1.15494289e-01f, -1.09531797e-01f, -5.91143817e-02f, -4.85140234e-02f, -1.18567504e-01f,
  -4.52405922e-02f, 1.19421287e-02f, -1.59562118e-02f, 1.04542188e-02f, 2.88539194e-02f, 8.12921748e-02f, 2.06474587e-03f, -2.95792881e-04f, -3.21165062e-02f, 4.85696793e-02f,
  -1.67616978e-01f, -1.47827044e-01f, -4.17274050e-02f, 1.55422743e-02f, -6.40174076e-02f, -4.46422733e-02f, 1.01299956e-01f, -8.73353332e-02f, 1.33056223e-01f, -1.07440434e-01f,
  1.03549913e-01f, 3.70918214e-02f, 1.04333930e-01f, 1.02015227e-01f, -4.05232422e-02f, -2.59306980e-03f, -5.08358292e-02f, -7.64142200e-02f, -1.32242128e-01f, 1.57232672e-01f,
  -7.06017986e-02f, -5.53473011e-02f, -9.22358409e-02f, -6.24046065e-02f, -1.04605891e-01f, -6.30578026e-02f, -6.00163378e-02f, 1.01503879e-01f, -5.16994682e-04f, 1.36116266e-01f,
  -5.91398738e-02f, -8.92221779e-02f, 7.29262978e-02f, 5.38135171e-02f, 4.52488437e-02f, -1.29567638e-01f, 3.69281322e-02f, -1.44620359e-01f, -2.02193437e-03f, -7.67907873e-02f,
  -2.61802296e-03f, 1.15808761e-02f, 1.09591752e-01f, -3.05654407e-02f, -1.66604761e-02f, -1.07123181e-01f, -8.01686719e-02f, -1.38242152e-02f, -2.04803068e-02f, -5.66814328e-03f,
  5.96792698e-02f, 8.46188515e-02f, -1.00913510e-01f, -4.88960035e-02f, 2.55883690e-02f, 7.13908076e-02f, -7.24924076e-03f, 1.72785260e-02f, 3.38141173e-02f, -9.32113454e-02f,
  1.12259537e-02f, -8.11137781e-02f, 2.72976998e-02f, 1.13743305e-01f, 1.95905287e-02f, -7.33276457e-02f, 7.33636171e-02f, -4.65351716e-02f, -1.11979447e-01f, 4.39256616e-02f,
  -1.73651148e-02f, -4.91696596e-02f, -5.66819608e-02f, -1.12295501e-01f, 2.56094076e-02f, -6.34505004e-02f, 1.87701300e-01f, -6.44492134e-02f, -3.74143012e-02f, 7.54051581e-02f,
  9.59329400e-03f, -1.83050230e-01f, -8.93812105e-02f, -8.11995342e-02f, -2.82402383e-03f, 2.91862171e-02f, 5.18292934e-02f, -1.10093663e-02f, 9.83622968e-02f, -1.78734679e-02f,
  5.29452525e-02f, -1.03977472e-02f, -1.84839740e-01f, -1.99933082e-01f, -1.30031779e-01f, -1.00612067e-01f, 1.01894759e-01f, -1.16857179e-01f, -3.60137559e-02f, -5.95709123e-02f,
  -1.52895749e-01f, -1.45494178e-01f, -1.14692330e-01f, -7.18694851e-02f, -7.41355214e-03f, 1.08647667e-01f, 9.51326340e-02f, -5.21207787e-02f, -3.77634503e-02f, -2.86992639e-02f,
  -3.84421609e-02f, 4.21264879e-02f, -1.77645367e-02f, -1.90576985e-01f, -8.50137621e-02f, -2.92345509e-02f, -1.98273119e-02f, -3.49063426e-03f, -9.75288525e-02f, -9.00149569e-02f,
  7.59774223e-02f, -2.83314660e-03f, -1.32294998e-01f, -7.60639906e-02f, -4.83007431e-02f, 2.37456430e-02f, 2.72295350e-04f, 8.70995671e-02f, -5.26482798e-02f, -5.41119128e-02f,
  -4.05539088e-02f, 4.54346798e-02f, -5.86899519e-02f, 3.92455012e-02f, -4.63951863e-02f, -7.95988664e-02f, 1.01568140e-01f, -7.50117823e-02f, 1.79005846e-01f, 3.19960527e-02f,
  9.36539695e-02f, -1.52488900e-02f, -1.16344616e-01f, -3.68853919e-02f, -1.31219774e-02f, -9.96037945e-02f, -1.66223705e-01f, 2.03580204e-02f, -9.55100805e-02f, -2.56666057e-02f,
  -4.21166494e-02f, 3.20549775e-03f, -1.66322757e-02f, -1.36901985e-03f, 1.17922738e-01f, 1.85160071e-01f, -1.03262939e-01f, -1.45023197e-01f, -1.12980574e-01f, -1.33402407e-01f,
  -7.08779991e-02f, -1.24053612e-01f, 8.81123766e-02f, 1.71350464e-02f, 4.82626818e-02f, -1.44317269e-01f, 2.97588226e-03f, 2.53283046e-02f, -3.01443283e-02f, 4.50456962e-02f,
  3.85765657e-02f, 7.71324709e-02f, 6.75900728e-02f, 2.29570530e-02f, 4.21659760e-02f, -1.09649478e-02f, 5.23387939e-02f, 8.50293040e-02f, 1.35408476e-01f, -2.87514627e-02f,
  9.98272002e-02f, 1.89682208e-02f, 3.89072336e-02f, 1.14680063e-02f, 3.72764319e-02f, 8.27434286e-03f, 2.18639541e-02f, 9.61336792e-02f, -2.18094583e-03f, -5.37424395e-03f,
  7.97640681e-02f, 1.69189703e-02f, -8.87517408e-02f, 8.00877064e-03f, 4.46544811e-02f, -4.77391034e-02f, 3.49817127e-02f, -5.32252043e-02f, 1.07915856e-01f, -7.50165284e-02f,
  -6.12870567e-02f, 4.35986593e-02f, -3.83120626e-02f, 2.87007000e-02f, -1.25601307e-01f, -1.29631728e-01f, 4.69019860e-02f, 1.62544195e-02f, -1.40521871e-02f, 1.33205637e-01f,
  -2.27567162e-02f, 6.32435903e-02f, -2.46847719e-02f, 7.70820975e-02f, -7.74823055e-02f, -3.26244459e-02f, -1.98640916e-02f, 8.73163119e-02f, -2.26770081e-02f, 1.58728525e-01f,
  5.60611375e-02f, 2.45974818e-03f, 1.44166127e-01f, -1.80930316e-01f, -1.21038072e-02f, 4.49523479e-02f, 6.70799986e-02f, -2.35879391e-01f, 9.70884711e-02f, 8.48998129e-02f,
  -9.08822846e-03f, -2.61383969e-03f, 3.65482830e-02f, 8.92006382e-02f, 1.12509891e-01f, 3.94816585e-02f, 1.00879492e-02f, 2.85944119e-02f, -2.98934011e-03f, 3.18516344e-02f,
  -2.26700362e-02f, 4.41672914e-02f, 2.14883965e-02f, -3.81351486e-02f, 7.68340304e-02f, 1.83058213e-02f, -5.13225868e-02f, 6.26802966e-02f, -3.16708423e-02f, -6.35503158e-02f,
  -9.57100559e-03f, 1.87025648e-02f, 3.97014692e-02f, 5.90943452e-03f, 7.06303790e-02f, 9.42701101e-02f, -6.93839565e-02f, -1.04199372e-01f, 8.22679400e-02f, -6.75687268e-02f,
  1.17292233e-01f, -6.96581006e-02f, 1.32329226e-01f, -7.70674497e-02f, 2.94358041e-02f, 1.44324869e-01f, -4.98669669e-02f, -2.21780129e-03f, -1.38203517e-01f, -3.98420654e-02f,
  -7.93007668e-03f, 6.82752132e-02f, 3.29029076e-02f, 1.69619277e-01f, 3.42340097e-02f, 2.23494619e-02f, 1.04445117e-02f, -9.89628956e-03f, -1.02947671e-02f, -1.03577077e-01f,
  -1.32355526e-01f, -1.00043550e-01f, 7.26255774e-02f, 5.18231047e-03f, 1.99305534e-01f, 3.82668860e-02f, 1.65865019e-01f, 7.67808408e-02f, 5.35935499e-02f, -1.31165817e-01f,
  1.02251731e-01f, -6.24176189e-02f, 1.12725012e-02f, -5.97771518e-02f, -7.43246675e-02f, 9.40542519e-02f, -1.43743930e-02f, -8.41705129e-02f, -3.33022117e-03f, 2.33632009e-02f,
  -6.19039275e-02f, -4.40060571e-02f, -5.00884950e-02f, -4.66782115e-02f, -6.20562136e-02f, -1.26614794e-01f, -1.81179166e-01f, -7.69249164e-03f, -6.91314265e-02f, -1.09909497e-01f,
  -5.97641952e-02f, -3.22487466e-02f, -6.14323094e-03f, 4.32538986e-02f, -6.63905293e-02f, -4.82087694e-02f, -8.35101604e-02f, 4.08801530e-03f, -1.82933360e-02f, 5.51851988e-02f,
  5.04986122e-02f, -8.77762809e-02f, 2.05374509e-02f, -8.06074440e-02f, -6.69597983e-02f, 2.75768079e-02f, -7.03057945e-02f, 3.02957837e-02f, 1.22395173e-01f, -7.34640062e-02f,
  1.44917026e-01f, 8.67332369e-02f, -4.43892069e-02f, 1.22407451e-01f, -4.77696247e-02f, -1.32715181e-02f, 3.25047560e-02f, 1.57334991e-02f, -5.19840270e-02f, 3.02452203e-02f,
  -8.55960250e-02f, -5.09597324e-02f, 6.18390134e-03f, -1.16891839e-01f, -2.70149186e-02f, -2.90388055e-02f, 8.38686377e-02f, 1.91781446e-02f, -2.65009562e-03f, -1.17919683e-01f,
  7.12329447e-02f, 3.02191637e-03f, -3.66518311e-02f, -8.89712051e-02f, 1.24878868e-01f, 1.08536802e-01f, -4.66555879e-02f, -1.79079503e-01f, -3.87444720e-02f, -2.05306672e-02f,
  3.11987917e-03f, -2.41715349e-02f, 2.22549122e-02f, -2.98626740e-02f, -1.06844092e-02f, 5.31191416e-02f, -7.17321113e-02f, 5.82598820e-02f, 4.93536703e-02f, 1.70148350e-02f,
  5.46702817e-02f, 5.05514331e-02f, -3.88149209e-02f, 4.73395847e-02f, 1.98684987e-02f, 3.53934281e-02f, 4.25344184e-02f, 3.19484584e-02f, -3.25576961e-02f, -2.88674962e-02f,
  -7.83179166e-06f, 3.42263728e-02f, 3.84349450e-02f, -1.50023187e-02f, 1.36454314e-01f, 9.21004787e-02f, -3.45027559e-02f, 4.56183217e-02f, -1.04680181e-01f, 4.89531867e-02f,
  -8.81580487e-02f, 7.45233670e-02f, -2.42008101e-02f, -1.09136932e-01f, -1.18811056e-02f, -4.87239659e-02f, 1.30795226e-01f, -2.51485780e-02f, 5.41220419e-04f, 4.06693369e-02f,
  -3.08637712e-02f, -1.90730035e-01f, -1.01846382e-02f, -5.26150092e-02f, 1.72460862e-02f, 3.49174775e-02f, 8.01346973e-02f, -1.19716171e-02f, 1.74735233e-01f, 2.39701960e-02f,
  8.53889063e-02f, -6.43683076e-02f, -2.43497699e-01f, -1.19070031e-01f, -1.67030901e-01f, 6.62236810e-02f, 1.56910837e-01f, 3.91712114e-02f, -1.10771358e-01f, -4.46577333e-02f,
  -4.25175615e-02f, -1.38374614e-02f, 3.32634039e-02f, -4.68812184e-03f, 5.96956089e-02f, -3.41522433e-02f, -1.14734456e-01f, 4.08666544e-02f, -7.09643811e-02f, -6.46992549e-02f,
  -1.67937465e-02f, 9.08791721e-02f, -3.12354583e-02f, -8.41342509e-02f, 3.09122838e-02f, 5.77383377e-02f, -1.37689179e-02f, 7.45269060e-02f, -3.24381664e-02f, -9.38963667e-02f,
  -2.68481113e-02f, 7.30823576e-02f, -6.53904453e-02f, -4.34244461e-02f, 1.61493458e-02f, 2.28263792e-02f, -7.24905282e-02f, -1.18976973e-01f, 6.16161264e-02f, 1.53234586e-01f,
  -7.99123570e-02f, 4.80444469e-02f, -8.13761055e-02f, 1.06779456e-01f, -1.39168605e-01f, -1.27528887e-02f, -5.06576747e-02f, -1.41625717e-01f, 6.48823977e-02f, -6.82646856e-02f,
  1.30923957e-01f, 2.16869023e-02f, -4.10671532e-02f, -6.10267930e-02f, -8.73484612e-02f, -1.28565520e-01f, -4.27883156e-02f, -5.70583642e-02f, -1.38735650e-02f, 1.25963604e-02f,
  1.45393303e-02f, 4.49169613e-02f, 1.60104811e-01f, 1.40710250e-01f, -4.99672396e-03f, 8.16878453e-02f, -1.79964840e-01f, -1.21094435e-01f, -1.36897743e-01f, 9.63177606e-02f,
  -3.23322192e-02f, 8.27996433e-02f, 7.43316486e-02f, -1.43874912e-02f, -6.44712672e-02f, 2.64580529e-02f, 2.76755914e-02f, -3.75328138e-02f, 5.13184778e-02f, 1.29974321e-01f,
  4.67742644e-02f, -2.55402438e-02f, 1.20699182e-02f, 2.14926191e-02f, 8.62868056e-02f, -4.09113839e-02f, -1.80701278e-02f, 2.14886572e-03f, -5.92069589e-02f, -8.66266154e-03f,
  -9.44892764e-02f, 2.22860221e-02f, 2.27247961e-02f, 2.01729648e-02f, -7.73849785e-02f, 7.95492977e-02f, 5.45492433e-02f, -1.47119509e-02f, 7.44846538e-02f, 4.01452705e-02f,
  1.14115654e-02f, 4.21830155e-02f, -1.30433803e-02f, -7.30585977e-02f, 6.18437454e-02f, -8.00002459e-03f, -7.82075673e-02f, -3.53178903e-02f, 1.26738608e-01f, -6.04584301e-03f,
  9.74538624e-02f, -8.41927826e-02f, 7.64462873e-02f, 5.08420058e-02f, 1.51444092e-01f, 1.48107950e-02f, -6.18896037e-02f, -3.65677546e-03f, -5.53374067e-02f, -1.71285734e-01f,
  -1.14010222e-01f, -3.84200737e-02f, 1.66703500e-02f, -5.52956276e-02f, -1.92011576e-02f, -3.95178236e-02f, -1.91101301e-02f, -5.95920794e-02f, -1.84824169e-01f, 1.58468142e-01f,
  4.57213894e-02f, 1.43556580e-01f, -1.78888980e-02f, -3.62332463e-02f, 7.39108920e-02f, 4.46938388e-02f, 1.35208547e-01f, 1.00254610e-01f, -1.52340597e-02f, -1.41367570e-01f,
  4.60253991e-02f, 1.18820528e-02f, 2.82809641e-02f, -9.98229235e-02f, -6.77063391e-02f, 6.80004060e-02f, -9.30755772e-03f, -1.50739765e-02f, -3.46457548e-02f, -1.15062464e-02f,
  -5.69553338e-02f, 7.95256495e-02f, 4.18738984e-02f, 2.97589991e-02f, 6.22930704e-03f, 1.10775039e-01f, -5.95341139e-02f, -4.74455990e-02f, -3.65943275e-02f, -9.82033014e-02f,
  6.69305921e-02f, -6.74509779e-02f, -1.13948043e-02f, -4.64933366e-03f, -1.31578475e-01f, -8.51267725e-02f, -1.29427006e-02f, -1.32172527e-02f, 3.55900154e-02f, 4.54974994e-02f,
  1.08915202e-01f, -1.06070094e-01f, 5.49581870e-02f, -4.23286296e-02f, -7.02918395e-02f, 1.72878891e-01f, -9.79932919e-02f, -4.22734767e-02f, -1.45385653e-01f, -1.72272865e-02f,
  3.35021392e-02f, -2.55483147e-02f, 1.96048226e-02f, 1.25772744e-01f, 1.38078541e-01f, -6.77201152e-02f, 1.00344665e-01f, -1.28046870e-02f, -2.83093490e-02f, 7.22412542e-02f,
  -1.17224626e-01f, -4.56837006e-02f, 3.54966372e-02f, -1.40281795e-02f, 1.75211966e-01f, 1.52199134e-01f, 1.08342078e-02f, 1.82203859e-01f, -1.69007793e-01f, 8.55256915e-02f,
  -5.97984865e-02f, 1.18968509e-01f, -9.23012346e-02f, 5.25884442e-02f, -4.75599281e-02f, 1.03006018e-02f, -3.59396897e-02f, -3.89480442e-02f, 3.64043899e-02f, 9.72025376e-03f,
  5.78704961e-02f, 6.11740910e-02f, 1.12234503e-02f, -1.92886721e-02f, 5.89041896e-02f, -1.07198223e-01f, -1.95053481e-02f, 2.74404772e-02f, -6.00747727e-02f, -2.72865426e-02f,
  1.55068906e-02f, -3.88534032e-02f, 2.90749054e-02f, 7.64052272e-02f, -6.44677654e-02f, 7.50024691e-02f, -8.85068253e-03f, 7.69845694e-02f, 8.93841386e-02f, 1.06825233e-02f,
  4.78342175e-02f, 9.00226757e-02f, -4.71241586e-02f, -2.64902469e-02f, -1.24771923e-01f, 4.77528721e-02f, -6.67467117e-02f, 3.89174260e-02f, 7.56705254e-02f, -1.69506937e-01f,
  1.19912684e-01f, 5.27427308e-02f, 1.36441529e-01f, 6.63186461e-02f, 5.01554459e-03f, -2.58051837e-03f, 2.51870806e-04f, -1.34921104e-01f, -1.41707569e-01f, -3.62577476e-03f,
  -1.14435002e-01f, 3.26082706e-02f, -1.72058605e-02f, -7.15571083e-03f, 1.33286372e-01f, -3.67271714e-02f, -7.51287192e-02f, 1.47981822e-01f, -1.53953880e-01f, -1.26452163e-01f,
  -8.79653990e-02f, -4.91997004e-02f, 2.31485683e-02f, -5.12169413e-02f, -4.65053059e-02f, 6.48317439e-03f, 7.56251719e-03f, -7.85665512e-02f, -1.88420825e-02f, 1.15997389e-01f,
  -6.67453036e-02f, -5.94284721e-02f, 1.02477245e-01f, 5.31663261e-02f, -4.17084061e-02f, -1.61845032e-02f, -3.56198885e-02f, -5.55692837e-02f, -5.70551343e-02f, 3.46287638e-02f,
  8.71806988e-04f, -5.47390804e-03f, -9.76259355e-03f, -5.14575727e-02f, -7.15372339e-02f, 1.49466787e-02f, 2.90306360e-02f, -1.14016784e-02f, -7.51005858e-02f, -1.78164523e-02f,
  -5.18634170e-02f, -4.10776027e-02f, 1.20785452e-01f, 6.87687099e-02f, 1.02966592e-01f, -9.04828981e-02f, 1.12421677e-01f, -1.47561654e-02f, 4.75172810e-02f, -2.87143607e-02f,
  1.48695912e-02f, 6.92750439e-02f, 3.54033597e-02f, 5.21906167e-02f, 5.72853303e-03f, 8.88098180e-02f, -8.13932493e-02f, -6.90027848e-02f, -4.40333001e-02f, 8.05903897e-02f,
  7.30007365e-02f, 1.42605886e-01f, 2.53647361e-02f, -8.13751891e-02f, -2.71136314e-03f, 1.64486631e-03f, 1.79727023e-04f, -1.02264836e-01f, -1.18551940e-01f, -1.23928532e-01f,
  5.17716147e-02f, 4.51462753e-02f, 1.78712495e-02f, -2.04979554e-01f, 1.70942843e-01f, 2.36949548e-02f, 7.75559098e-02f, -1.88092694e-01f, 1.12821713e-01f, 2.60308683e-02f,
  -1.35083109e-01f, 1.05832918e-02f, 2.39470154e-02f, 1.74759831e-02f, 2.47989558e-02f, 3.03267818e-02f, -6.69089630e-02f, 4.56348956e-02f, 1.23976313e-01f, 2.54965723e-02f,
  9.24222693e-02f, -2.46841852e-02f, 3.66326347e-02f, -4.66759764e-02f, -1.17172068e-02f, 9.71242879e-03f, 5.14364839e-02f, -2.12174151e-02f, 7.50222579e-02f, -3.77126187e-02f,
  6.11185990e-02f, -5.90182981e-03f, 2.10949145e-02f, 1.06334239e-01f, 1.50653990e-02f, -7.09577289e-05f, 4.56204526e-02f, -1.02661699e-01f, -5.07638976e-02f, 1.24620400e-01f,
  -8.96350369e-02f, -2.96361162e-03f, -1.90278459e-02f, 2.53351871e-04f, -2.24200124e-03f, -8.66139159e-02f, -7.59048313e-02f, -7.78201744e-02f, 4.44835285e-03f, -4.83758487e-02f,
  9.09880828e-03f, -7.69605767e-03f, 1.24721333e-01f, -6.64296225e-02f, -9.93557647e-03f, -3.43955941e-02f, -3.35334688e-02f, 5.20906411e-02f, -3.22850496e-02f, 4.21906598e-02f,
  -1.03027076e-01f, 5.95376156e-02f, 4.16379571e-02f, 1.75053507e-01f, -9.48168933e-02f, 1.59234911e-01f, 4.62226011e-02f, 4.01924876e-03f, -8.32348242e-02f, -1.66955799e-01f,
  4.87277471e-02f, 4.25461866e-02f, -5.73936105e-03f, -1.44410893e-01f, 1.37817010e-01f, -4.07740138e-02f, 6.90916600e-03f, 1.49779826e-01f, -7.54639432e-02f, -1.99773267e-01f,
  -1.40663264e-02f, 3.57586071e-02f, 7.01701045e-02f, -3.06267478e-02f, -8.41066912e-02f, -1.23398192e-02f, 2.75304373e-02f, 8.22312608e-02f, 3.98475714e-02f, 2.67846957e-02f,
  -7.31032714e-02f, 6.01277575e-02f, -1.36324065e-02f, -4.65492206e-03f, -1.92270447e-02f, -2.34565157e-02f, 2.00791545e-02f, -1.09513931e-01f, 4.48024832e-03f, -3.31785902e-02f,
  4.95330431e-02f, -6.62918687e-02f, 1.78636655e-01f, 8.33232254e-02f, 1.17427327e-01f, 7.86412135e-02f, 9.45800617e-02f, 7.35401064e-02f, -7.18499422e-02f, 1.87660277e-01f,
  -5.74272573e-02f, 6.64744601e-02f, -8.55612829e-02f, 8.14669486e-03f, -7.04491809e-02f, -8.84833634e-02f, 9.54709295e-03f, 4.02963944e-02f, -3.45327286e-03f, 5.67672364e-02f,
  2.02407628e-01f, -1.51623935e-01f, 2.19618287e-02f, -4.88979779e-02f, 1.46231115e-01f, 6.73725009e-02f, 7.04825670e-02f, 9.85703245e-02f, 2.62632277e-02f, -1.29975975e-01f,
  1.67737212e-02f, -1.07936129e-01f, 1.21630244e-01f, 1.59493253e-01f, -6.52447864e-02f, -4.06179763e-02f, 2.92209815e-02f, 1.29751027e-01f, -1.39649674e-01f, 3.04251183e-02f,
  8.01924895e-03f, -1.52836200e-02f, 6.28098920e-02f, 4.79919538e-02f, -1.62764732e-02f, -3.82672399e-02f, -8.53587873e-03f, -1.65922809e-02f, 1.29054397e-01f, -1.11231571e-02f,
  -4.07247432e-02f, -5.69255464e-02f, -1.52255774e-01f, -1.48756191e-01f, -5.32732205e-03f, -9.43387523e-02f, -5.16498834e-02f, -6.73537701e-02f, 3.35049704e-02f, -4.53200676e-02f,
  -1.82977656e-05f, 9.53331292e-02f, 2.51622852e-02f, 1.12859551e-02f, -5.84713407e-02f, -4.09219414e-02f, -1.46355420e-01f, -1.01084426e-01f, -3.20495144e-02f, -1.90136638e-02f,
  8.53691399e-02f, -9.60742757e-02f, 9.63537544e-02f, -3.36374156e-02f, 3.51651968e-03f, 3.24088819e-02f, -3.71153988e-02f, 3.88860628e-02f, -1.10184073e-01f, 1.23565085e-01f,
  -2.73585729e-02f, -1.03431761e-01f, 1.28020355e-02f, 1.55388042e-01f, -6.49736524e-02f, 1.10922210e-01f, 7.06030009e-03f, -3.44785638e-02f, -7.66396970e-02f, 2.24811714e-02f,
  -1.99320287e-01f, -4.35919426e-02f, -9.70687121e-02f, -5.22714294e-03f, 1.31533667e-01f, 2.70143926e-01f, -1.98727958e-02f, -3.67445312e-02f, -6.13525733e-02f, -4.26778868e-02f,
  4.61718403e-02f, -1.98354386e-02f, 1.13427512e-01f, 6.18605390e-02f, 5.08225039e-02f, 6.97547663e-03f, 3.83024737e-02f, 1.14197031e-01f, 3.33479196e-02f, -3.15415114e-02f,
  7.72338957e-02f, 5.55463061e-02f, 1.04933947e-01f, 5.40817417e-02f, -4.80418354e-02f, -1.88626479e-02f, -3.92582230e-02f, -4.71654087e-02f, -2.02328842e-02f, 1.80270039e-02f,
  -9.15701389e-02f, -5.35380766e-02f, -3.35491523e-02f, -5.32194115e-02f, 7.37265721e-02f, 3.37722618e-03f, 7.90581778e-02f, -5.79760931e-02f, -4.05739807e-02f, 2.59560514e-02f,
  -1.28304705e-01f, -1.21386506e-01f, 6.46799132e-02f, -1.45737352e-02f, 1.04694344e-01f, -1.88313629e-02f, 5.90827279e-02f, -6.88703358e-02f, 1.20573238e-01f, 1.32777199e-01f,
  -9.76481140e-02f, 1.46472007e-02f, -1.29183769e-01f, 1.49428826e-02f, -4.08954658e-02f, -2.81173736e-02f, -8.03559832e-03f, 1.57515064e-01f, -4.61906753e-02f, 8.52700025e-02f,
  9.91980806e-02f, -3.68877836e-02f, -6.42883778e-02f, -3.87559668e-03f, -1.25893801e-01f, -9.22883078e-02f, 5.55434413e-02f, -2.32633743e-02f, 2.26211354e-01f, 1.85776532e-01f,
  1.22611314e-01f, 4.53672186e-02f, -4.45456915e-02f, -1.61877982e-02f, 2.13307720e-02f, -6.81815762e-03f, -2.01311484e-02f, -1.86964627e-02f, 7.10113272e-02f, 9.98657197e-03f,
  5.68425795e-03f, 3.53907049e-02f, 1.02099486e-01f, 4.45937663e-02f, -1.45534836e-02f, 5.41751310e-02f, -5.88441826e-03f, -4.23142314e-02f, 1.99897606e-02f, 8.43542591e-02f,
  4.81050014e-02f, -1.04853660e-02f, 1.34975752e-02f, 3.92992869e-02f, -1.63624249e-02f, 2.88690981e-02f, -2.00136211e-02f, 7.39088580e-02f, 5.31268120e-02f, -1.03265308e-02f,
  8.90883654e-02f, -2.81568132e-02f, 9.49297398e-02f, 1.15255482e-01f, 2.83783525e-02f, -7.32437745e-02f, 9.65546742e-02f, -1.03844255e-01f, -3.61365527e-02f, -8.49257261e-02f,
  5.26713952e-02f, 3.50460075e-02f, 1.15014076e-01f, -4.29540593e-03f, 4.07516807e-02f, 4.88251187e-02f, -3.91342416e-02f, -5.17947525e-02f, -4.02189884e-03f, 4.81656529e-02f,
  4.48118597e-02f, 1.30847961e-01f, 3.60204689e-02f, -1.13894776e-01f, -6.12265728e-02f, 4.57744207e-03f, 2.96745766e-02f, -1.35411128e-01f, -5.63888550e-02f, -1.80770636e-01f,
  -9.77678671e-02f, 9.87300351e-02f, 1.19677775e-01f, -1.24049839e-02f, 1.16209008e-01f, 7.20039150e-03f, 7.07300529e-02f, -1.23469226e-01f, 3.06285862e-02f, 5.83736971e-02f,
  -8.26058090e-02f, -1.43981069e-01f, 2.01121755e-02f, 6.78699762e-02f, 1.86691959e-05f, -1.01291604e-01f, 1.34756360e-02f, -4.50989185e-03f, -6.83684871e-02f, 5.83981499e-02f,
  -5.27482182e-02f, 2.18002405e-02f, 5.74691668e-02f, 1.83825772e-02f, 4.60214447e-03f, 5.06542772e-02f, -7.89789599e-04f, 2.65671555e-02f, 2.85309218e-02f, -1.02978731e-02f,
  2.10460201e-02f, 1.30740970e-01f, -6.40664920e-02f, -7.19229318e-03f, -1.02299890e-02f, 5.90296835e-02f, 7.06026331e-02f, 7.18368813e-02f, 1.22843802e-01f, 3.55905443e-02f,
  1.12240212e-02f, -5.10695316e-02f, -1.57205001e-01f, -9.14312433e-03f, -4.03884500e-02f, 2.49585584e-02f, 6.16840012e-02f, -1.68086752e-01f, 1.70288861e-01f, 1.22221328e-01f,
  6.36230782e-02f, -1.00141577e-01f, -6.15724502e-03f, 1.30486637e-02f, -3.27334180e-02f, -8.79949182e-02f, -7.17423558e-02f, -9.52230915e-02f, -6.22013547e-02f, 3.28468978e-02f,
  4.30372767e-02f, -2.24905610e-02f, 9.31194648e-02f, -2.98477756e-03f, -7.26005733e-02f, 1.13583907e-01f, -6.21122494e-02f, -1.86298624e-01f, 6.54866046e-04f, 7.63587207e-02f,
  -8.48519336e-03f, 1.62360184e-02f, 1.69422999e-01f, 1.41083121e-01f, -8.55440125e-02f, -1.24558039e-01f, 1.53941261e-02f, 9.58987549e-02f, -9.51550752e-02f, 6.81084916e-02f,
  9.07800049e-02f, 4.59881797e-02f, 1.22810476e-01f, 3.37708481e-02f, 2.43891012e-02f, -5.86914681e-02f, -1.87841859e-02f, 6.61414862e-02f, 9.12283314e-04f, 1.39694326e-02f,
  9.56986248e-02f, 1.59088317e-02f, -2.59536598e-02f, 2.50358041e-02f, -1.71541031e-02f, 2.02286150e-02f, 5.22000045e-02f, 1.18827701e-01f, 1.93897653e-02f, -3.11198309e-02f,
  6.44992739e-02f, 1.44819260e-01f, 8.44762847e-02f, -4.92970608e-02f, 3.86871956e-02f, -1.38777778e-01f, 6.50889948e-02f, 2.84174830e-03f, 8.42378382e-03f, -2.31982041e-02f,
  7.68232569e-02f, 1.02089711e-01f, -1.27539054e-01f, -4.66234870e-02f, -1.49783105e-01f, 5.70894182e-02f, 1.00999504e-01f, -1.06289645e-03f, 8.44418779e-02f, 1.28579021e-01f,
  8.80916566e-02f, 8.64477009e-02f, -5.14487401e-02f, 3.22097726e-02f, -1.04314283e-01f, -1.33125335e-01f, 7.58891106e-02f, -1.03322752e-01f, -1.89252775e-02f, -5.72602563e-02f,
  2.72905398e-02f, -1.30890340e-01f, 1.86445400e-01f, -3.24962586e-02f, 1.44116923e-01f, -1.78918555e-01f, 2.49505229e-02f, -1.96149379e-01f, 5.94150014e-02f, 8.29238743e-02f
};

// L3_fan_Wp_bar (Shape: 14 x 64)
const int L3_fan_Wp_bar_rows = 14;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  7.43158385e-02f, -8.87659863e-02f, 1.41577378e-01f, 5.52665442e-02f, -1.25760645e-01f, -1.22343004e-01f, -3.68856266e-02f, -4.20911871e-02f, 1.11051217e-01f, 1.66183803e-02f,
  -7.81222656e-02f, -1.63519710e-01f, -1.97208062e-01f, -1.47788614e-01f, -1.71430737e-01f, 5.35033420e-02f, 6.66082054e-02f, -7.65754879e-02f, -9.30716619e-02f, 5.69270849e-02f,
  1.20687885e-02f, 1.04244813e-01f, 3.42139788e-02f, 1.37220472e-01f, -2.34992132e-01f, -1.81936547e-01f, -2.19149783e-01f, -3.41228000e-03f, -8.60700831e-02f, 1.39426127e-01f,
  -2.90931351e-02f, -6.83922917e-02f, 8.18674490e-02f, -1.30080134e-01f, 1.24184065e-01f, -1.05972424e-01f, 1.34207517e-01f, 1.48343712e-01f, 1.50802702e-01f, 1.15365706e-01f,
  -2.39195637e-02f, -1.77941501e-01f, -1.44861415e-01f, -4.73825522e-02f, -1.91857442e-01f, 1.90525904e-01f, -1.47075430e-02f, -1.27602682e-01f, -7.75238946e-02f, 1.45420834e-01f,
  -7.39209801e-02f, 1.26744300e-01f, -3.03568393e-01f, 1.39237612e-01f, 2.72216439e-01f, 4.48355377e-01f, -1.52555089e-02f, 1.14242703e-01f, -3.33847255e-01f, 3.56245160e-01f,
  1.32194549e-01f, 1.52342230e-01f, 1.18035108e-01f, 6.47087097e-02f, -3.72559833e-03f, 1.58448204e-01f, -1.98427156e-01f, -1.63562745e-01f, 1.48611411e-01f, 1.60598323e-01f,
  -4.62896042e-02f, -1.16781413e-03f, -1.12714700e-01f, -1.61942154e-01f, 8.52228552e-02f, 5.31139113e-02f, 7.97456354e-02f, 7.88105056e-02f, 1.14861250e-01f, -1.29451109e-02f,
  5.82399480e-02f, 2.36093998e-01f, 1.14316441e-01f, -4.84203324e-02f, -4.87249978e-02f, -6.79475293e-02f, -4.95178625e-02f, -5.67618981e-02f, 2.55275190e-01f, 1.46973521e-01f,
  4.61486205e-02f, -9.81069133e-02f, 1.12067252e-01f, -4.74147350e-02f, 7.83520415e-02f, -4.54900861e-02f, 4.77427468e-02f, 1.35334626e-01f, -4.16195393e-02f, 7.02221841e-02f,
  -5.44209443e-02f, 9.29600894e-02f, -2.50000745e-01f, -2.65280545e-01f, 2.11359300e-02f, 2.97500253e-01f, 1.33818060e-01f, 1.30986139e-01f, 1.76513717e-01f, -8.26124661e-03f,
  -4.37143184e-02f, 1.09157637e-01f, 1.68981582e-01f, -1.23717323e-01f, 9.55628604e-02f, 5.40410317e-02f, 5.08647263e-01f, 8.14173296e-02f, 5.01853451e-02f, -2.50768334e-01f,
  2.89831787e-01f, 1.37545511e-01f, 2.35187039e-01f, -2.40818635e-02f, 2.55139351e-01f, 4.03059684e-02f, 1.12493813e-01f, 2.59095818e-01f, 4.05414477e-02f, -5.18980324e-02f,
  1.25786722e-01f, 8.32021758e-02f, -3.34084518e-02f, -4.95868996e-02f, -4.29939628e-02f, 8.71579861e-04f, 8.09754729e-02f, 1.10590398e-01f, -6.86199591e-02f, -7.34108016e-02f,
  3.30379009e-02f, -3.72199565e-02f, -7.86126405e-02f, 1.03190243e-02f, 5.73028512e-02f, -4.49614599e-02f, -2.69658864e-02f, 5.41552790e-02f, -2.62555741e-02f, 7.06050694e-02f,
  5.13248853e-02f, 1.33452863e-01f, -1.25465706e-01f, -8.00061747e-02f, -1.80795044e-01f, 5.31293042e-02f, -1.07655823e-01f, 3.55078503e-02f, -1.58416450e-01f, -1.86476074e-02f,
  8.68313238e-02f, -1.72771394e-01f, 8.81492272e-02f, -2.01849297e-01f, 2.41827846e-01f, 5.50129376e-02f, 1.96805254e-01f, 4.45147008e-02f, -9.45882220e-03f, -1.62477076e-01f,
  -1.06354743e-01f, -1.45627037e-01f, -2.30747938e-01f, 1.28886804e-01f, -2.81490367e-02f, 9.53173451e-03f, -1.34160370e-01f, -1.32145891e-02f, 1.67426690e-01f, 1.27186254e-01f,
  -2.21086010e-01f, 3.92211258e-01f, 1.05785564e-01f, 1.44356370e-01f, -1.36780024e-01f, -3.16930078e-02f, -5.14710471e-02f, 2.61565149e-01f, 1.31575122e-01f, 9.51479673e-02f,
  1.86509401e-01f, -1.35194466e-01f, 6.85230717e-02f, -3.94138321e-02f, 1.25337601e-01f, -1.28157452e-01f, -2.29327098e-01f, 1.41012862e-01f, -4.81869802e-02f, 1.23592177e-02f,
  -1.10845596e-01f, 1.05975546e-01f, 1.64111674e-01f, 1.21116064e-01f, 2.09765253e-03f, -1.54314339e-02f, 4.58041057e-02f, 1.19384147e-01f, 1.11258283e-01f, -2.59419493e-02f,
  4.93169203e-03f, -6.33229688e-02f, -8.24234113e-02f, -1.18838146e-01f, 1.00517571e-01f, 7.08492622e-02f, -8.85097831e-02f, -1.74473450e-01f, 1.51402801e-01f, 1.69757679e-01f,
  -1.50451168e-01f, 4.35020961e-02f, 9.14014056e-02f, 2.40332447e-02f, -1.63141653e-01f, 1.33442044e-01f, -1.84465274e-01f, 2.14512050e-02f, -1.68381572e-01f, -1.39804840e-01f,
  -5.63306771e-02f, -3.22588906e-02f, 4.05497812e-02f, -3.32584716e-02f, -8.51498321e-02f, 4.13919762e-02f, 2.03930527e-01f, -1.44723162e-01f, 1.18996300e-01f, 9.61098913e-03f,
  2.11231560e-01f, 2.00121269e-01f, 8.81416127e-02f, 1.48568332e-01f, 2.21451193e-01f, -2.37339705e-01f, 5.56246080e-02f, 2.20285147e-01f, -4.57429439e-02f, 3.89378518e-01f,
  -7.09173009e-02f, 2.58084983e-01f, -2.23654658e-02f, 3.59495968e-01f, -4.85937782e-02f, 2.73491621e-01f, -3.17038819e-02f, 6.65252050e-03f, -6.93496093e-02f, -2.58500632e-02f,
  1.49324508e-02f, -6.38151960e-03f, -8.38931836e-03f, 4.14826646e-02f, -7.65475854e-02f, 1.64232049e-02f, -5.36898673e-02f, 1.36437966e-02f, 6.50373921e-02f, 1.10991299e-01f,
  -2.23228499e-01f, 1.23102568e-01f, 4.61516678e-02f, 7.12534562e-02f, 2.50100493e-02f, 1.69305235e-01f, 3.22052045e-04f, -1.53219745e-01f, -1.44809140e-02f, -4.68480214e-02f,
  1.18769154e-01f, -1.75227789e-04f, 2.27756742e-02f, 7.41341114e-02f, 7.19931349e-02f, 1.07174449e-01f, -2.58729517e-01f, 1.23064704e-01f, 1.83419332e-01f, 7.37378821e-02f,
  -1.70898102e-02f, -1.64823309e-01f, 2.87229210e-01f, 2.29145691e-01f, 1.88360527e-01f, -2.91912138e-01f, -1.70901194e-01f, 6.32553548e-02f, -1.52721837e-01f, -2.63656855e-01f,
  -1.12386338e-01f, -1.78903952e-01f, 6.95082396e-02f, 3.25410888e-02f, 1.51298329e-01f, 1.14399731e-01f, 1.71934694e-01f, 2.84294784e-01f, -1.40679136e-01f, 4.88268614e-01f,
  3.18333246e-02f, -1.64996088e-01f, 5.13527282e-02f, 3.19698341e-02f, -1.96344078e-01f, 3.20714921e-01f, 3.62433225e-01f, 3.14083040e-01f, 1.08389750e-01f, -2.55997121e-01f,
  9.12211183e-03f, 6.57930747e-02f, 7.03548640e-02f, -6.43811673e-02f, -1.97990373e-01f, 8.16926286e-02f, 1.66223869e-01f, 1.13845751e-01f, 1.07150830e-01f, 7.74721652e-02f,
  9.15784910e-02f, 8.22533816e-02f, 9.21976343e-02f, 9.86421704e-02f, 8.71051028e-02f, 8.59349966e-02f, 1.92623988e-01f, 1.11820064e-01f, 1.15080059e-01f, -2.32971869e-02f,
  2.09939793e-01f, 1.80425584e-01f, -7.81027926e-03f, 1.42636433e-01f, 7.45707657e-03f, -2.58910269e-01f, -6.40981942e-02f, 2.19943941e-01f, -8.17718729e-02f, 1.53522357e-01f,
  -4.12995666e-02f, 5.61800003e-02f, -5.53189814e-02f, -1.90762635e-02f, -2.25976720e-01f, -8.92361253e-02f, -1.25744820e-01f, -1.80336937e-01f, -1.77260488e-02f, -4.09601182e-02f,
  1.92248404e-01f, -3.60932238e-02f, -1.34741589e-01f, -1.17975630e-01f, 7.64653087e-02f, 4.68890406e-02f, 1.06187142e-01f, 1.36713251e-01f, -3.40088606e-02f, 1.56906337e-01f,
  4.05305237e-01f, 4.59830403e-01f, 1.42391929e-02f, 8.47471058e-02f, -6.64557740e-02f, 1.62140042e-01f, -1.93385795e-01f, 3.46857384e-02f, 7.10968859e-03f, 3.56384724e-01f,
  -2.17731863e-01f, -1.53019696e-01f, 4.97066438e-01f, 4.41405058e-01f, 3.55921313e-02f, 6.63683712e-02f, 6.74955398e-02f, 9.93725061e-02f, 1.56709746e-01f, 3.96655649e-02f,
  1.48617640e-01f, 3.82885560e-02f, 1.98870540e-01f, -2.92901229e-02f, 9.72461775e-02f, 1.02043986e-01f, -2.52074506e-02f, -2.84595992e-02f, 2.56275386e-03f, -2.40806099e-02f,
  1.12490661e-01f, 5.86171672e-02f, -6.37813434e-02f, 1.57319173e-01f, 9.47463959e-02f, 1.02244601e-01f, 1.33001119e-01f, 1.04935743e-01f, 6.91102166e-03f, 2.14234427e-01f,
  1.12690769e-01f, -2.15760261e-01f, 5.08530289e-02f, -2.47351900e-01f, -1.70880795e-01f, 2.37858463e-02f, 2.96093654e-02f, 7.22177625e-02f, 2.54001379e-01f, -1.26617789e-01f,
  2.06740107e-02f, 5.85024841e-02f, 5.22120371e-02f, 1.09219447e-01f, 4.68220972e-02f, 1.01743434e-02f, 1.78264886e-01f, -2.40652375e-02f, -1.00298479e-01f, -3.01873721e-02f,
  -1.03109023e-02f, -1.85399987e-02f, -6.22286685e-02f, -2.91727871e-01f, 5.53098209e-02f, -3.70257229e-01f, -1.16711475e-01f, 2.40418702e-01f, 2.46143833e-01f, 5.31476922e-02f,
  2.70775020e-01f, 1.73956640e-02f, 5.70942700e-01f, 2.03838535e-02f, 3.20073217e-01f, 1.87350675e-01f, -1.25765100e-01f, -1.75782204e-01f, -5.10369763e-02f, 1.82343870e-02f,
  3.55231129e-02f, 6.34367988e-02f, 8.33046511e-02f, -1.50145206e-03f, -6.31207377e-02f, 8.73927027e-03f, 1.40700806e-02f, -8.93275067e-02f, 2.77595688e-02f, -5.96400388e-02f,
  -1.44534916e-01f, 7.39954636e-02f, -1.11177035e-01f, 4.71339561e-02f, -1.22596085e-01f, 8.28558952e-02f, 1.17750563e-01f, -3.05963252e-02f, -1.16326502e-02f, -2.36322790e-01f,
  1.19597733e-01f, -1.10093288e-01f, -2.11484153e-02f, -3.54044395e-03f, 1.20378926e-01f, -1.71114683e-01f, 5.01379650e-03f, 1.66386068e-01f, 3.25028636e-02f, 1.62700206e-01f,
  2.06372817e-03f, 1.85231909e-01f, 1.45344049e-01f, 1.48175210e-01f, -2.53780819e-02f, 1.23500496e-01f, -6.89936355e-02f, 6.95760623e-02f, -2.95074940e-01f, 7.27610812e-02f,
  -6.42126752e-03f, -9.68681648e-02f, 8.36436301e-02f, -1.40291527e-01f, 1.90876365e-01f, -1.72386408e-01f, 1.94753498e-01f, 1.26208797e-01f, 1.13581054e-01f, 6.36618137e-02f,
  3.87227654e-01f, -1.13530248e-01f, -1.86722241e-02f, 9.33566317e-02f, 1.79334685e-01f, 4.51465070e-01f, -3.26795317e-02f, 5.55323884e-02f, 2.64956385e-01f, 4.61233228e-01f,
  -1.61369726e-01f, 1.87026039e-01f, 1.27485111e-01f, 1.29467979e-01f, -1.00274738e-02f, -1.37822658e-01f, -2.91197514e-03f, 4.84554954e-02f, 2.12000906e-02f, -2.55013704e-02f,
  -4.67765098e-03f, -8.22636560e-02f, 7.83976689e-02f, 3.95458192e-02f, -8.98092985e-02f, -5.10310978e-02f, -1.09061025e-01f, 2.86845844e-02f, 7.62483329e-02f, 1.04487659e-02f,
  -1.27230629e-01f, 1.88169315e-01f, -5.44829927e-02f, -8.77036992e-03f, 4.02884148e-02f, 5.23527302e-02f, -3.16062532e-02f, 5.78012727e-02f, 5.21107987e-02f, -9.41061154e-02f,
  1.35339975e-01f, -5.70394732e-02f, -7.40955472e-02f, -8.97670388e-02f, 1.26758084e-01f, 8.54542777e-02f, 2.34504640e-01f, -8.78218412e-02f, 2.50545591e-01f, 3.14848304e-01f,
  -2.52338150e-03f, -1.42497132e-02f, -3.02625690e-02f, -4.37896606e-03f, 2.52891611e-02f, 9.13686380e-02f, -8.56343955e-02f, -2.40150429e-02f, -3.44420522e-02f, -1.07855298e-01f,
  9.39511061e-02f, -4.12412174e-02f, -5.58367036e-02f, -2.24869639e-01f, -2.88508862e-01f, 3.14520895e-01f, 2.91974932e-01f, 5.11346012e-02f, 3.32544416e-01f, 2.35253587e-01f,
  -1.88648954e-01f, 2.34212756e-01f, 3.00368935e-01f, 2.24583149e-01f, -5.08842617e-02f, -2.58644849e-01f, -3.28935012e-02f, -7.52299977e-03f, -2.25463696e-03f, 1.38407722e-01f,
  5.11350669e-02f, 1.65142734e-02f, 8.70923474e-02f, 7.13082030e-02f, 1.24005325e-01f, -6.21813647e-02f, 4.35526483e-02f, 1.16273366e-01f, 1.16801858e-01f, -1.11754112e-01f,
  1.85294617e-02f, 5.64018935e-02f, 8.29547420e-02f, 1.11715846e-01f, -2.40177065e-02f, -5.34881391e-02f, 7.75683597e-02f, 2.33082343e-02f, 5.89719191e-02f, 3.98271047e-02f,
  6.83199391e-02f, 1.13919657e-02f, -2.31659651e-01f, -1.63152128e-01f, 2.14963615e-01f, -4.59877066e-02f, 1.50024533e-01f, -2.02500626e-01f, 3.20790380e-01f, 1.14005012e-02f,
  -1.60571113e-02f, 1.83938339e-01f, -8.65858570e-02f, 1.17710590e-01f, -1.90635979e-01f, -1.39705151e-01f, 1.82989314e-02f, 7.19343871e-02f, -5.05096801e-02f, 2.16936037e-01f,
  1.33667320e-01f, 1.05933107e-01f, 4.15998697e-02f, -5.12220757e-03f, 5.87466806e-02f, 7.66904280e-02f, -2.98208594e-01f, -9.51797664e-02f, -2.26150721e-01f, 1.77811608e-01f,
  4.45277035e-01f, 3.50958675e-01f, 2.33690217e-01f, 1.09532528e-01f, -1.07814975e-01f, 1.49552912e-01f, 1.83427498e-01f, -4.03256007e-02f, 2.52062917e-01f, 1.91775292e-01f,
  9.52788442e-02f, -9.97144282e-02f, 1.18517958e-01f, 1.57971308e-01f, 3.94588560e-02f, -4.16815542e-02f, 9.11237523e-02f, 6.85994402e-02f, 5.69103984e-03f, 1.01055309e-01f,
  -1.39893694e-02f, 1.42006502e-01f, 3.64663787e-02f, -5.34020662e-02f, 9.64483544e-02f, 1.13845542e-01f, -3.22838612e-02f, -5.87415881e-02f, -1.69945341e-02f, -3.86404879e-02f,
  4.10648249e-02f, -9.58337740e-04f, 1.99818984e-01f, -6.08150996e-02f, -8.76019374e-02f, 6.47872761e-02f, 4.38963771e-02f, -1.51901975e-01f, -4.08853032e-02f, -3.35770287e-02f,
  1.25643358e-01f, 3.20772342e-02f, -7.96034336e-02f, 5.14380774e-03f, 1.35608688e-01f, 2.05463961e-01f, -2.36497536e-01f, -1.62807435e-01f, -2.79814121e-03f, 8.59296545e-02f,
  -2.87374780e-02f, -4.92427349e-02f, 6.58843741e-02f, 5.57309538e-02f, 6.76402524e-02f, -1.02095835e-01f, 1.28120705e-01f, -7.48733431e-02f, -4.75746356e-02f, -1.26275912e-01f,
  3.67004722e-02f, -1.96947217e-01f, 1.85521916e-01f, -8.15591589e-02f, 1.45070478e-01f, 2.90318161e-01f, 2.75424153e-01f, 3.77194494e-01f, 3.23512495e-01f, 2.60419641e-02f,
  2.02762052e-01f, 2.71112680e-01f, -1.04463264e-01f, 9.06540304e-02f, -7.26748034e-02f, -1.90831460e-02f, -1.68169106e-04f, 8.07262883e-02f, -8.11347961e-02f, 4.29532751e-02f,
  6.38347119e-02f, 3.08213159e-02f, 1.59890056e-01f, -8.42714608e-02f, 3.66692767e-02f, -4.35073078e-02f, -7.43013690e-04f, -1.02928251e-01f, 1.68024108e-01f, 4.89662518e-04f,
  1.36621445e-01f, 4.48753387e-02f, 9.73770171e-02f, -6.80271387e-02f, 1.08229414e-01f, 2.50519335e-01f, -8.10505897e-02f, 1.74940720e-01f, 5.99191245e-03f, -5.12853414e-02f,
  -3.02393466e-01f, 8.92701652e-03f, 3.46111469e-02f, -1.87314134e-02f, 2.58251745e-02f, -1.92866206e-01f, 1.48006827e-01f, -2.35330760e-01f, -9.06302109e-02f, -4.76560295e-02f,
  8.52324534e-03f, -2.41186731e-02f, -1.55574232e-01f, -4.94988821e-03f, 1.81875706e-01f, -6.53419867e-02f, 2.05933172e-02f, 1.61617205e-01f, -1.20601274e-01f, 3.31735194e-01f,
  -1.25844881e-01f, 1.62474960e-01f, -2.27940068e-01f, 5.16893566e-02f, 6.45399988e-02f, 3.27240348e-01f, -1.13179430e-01f, 2.14447886e-01f, 2.82583863e-01f, 2.68386096e-01f,
  4.86924648e-02f, -2.14133903e-01f, 3.38556282e-02f, 2.14331403e-01f, 5.40394634e-02f, -3.27142805e-01f, 5.18186688e-01f, 2.81305015e-01f, 4.10347581e-02f, -7.10049570e-02f,
  8.45480636e-02f, 6.63062334e-02f, 6.77154809e-02f, 3.78250852e-02f, -7.70395473e-02f, 6.46874458e-02f, -8.58614221e-02f, 2.03257158e-01f, 3.59698082e-03f, 1.05179518e-01f,
  2.02373981e-01f, 1.71394423e-01f, -5.71066067e-02f, 8.01601708e-02f, 6.49025813e-02f, -4.64711292e-03f, 2.96458788e-03f, 1.38852566e-01f, -9.06268731e-02f, -1.63757831e-01f,
  1.90853894e-01f, -2.44972277e-02f, 1.22543545e-02f, 9.57394466e-02f, 2.00505093e-01f, 5.54695958e-03f, -1.17487401e-01f, 2.47856192e-02f, -2.14415684e-01f, 2.14308769e-01f,
  -7.82455578e-02f, 6.28205687e-02f, 4.69531454e-02f, -9.69435945e-02f, 6.33174628e-02f, -6.40282482e-02f, 2.78194815e-01f, -8.90462026e-02f, -1.18399292e-01f, 6.36863485e-02f,
  -5.61642237e-02f, -2.27677718e-01f, -6.76219091e-02f, -2.15776339e-01f, 1.35626063e-01f, -3.04095610e-03f, 9.65799168e-02f, -3.37455496e-02f, 4.08383936e-01f, 5.77522889e-02f,
  1.55620307e-01f, 1.62853912e-01f, -2.16955572e-01f, -2.08067372e-01f, -8.90629068e-02f, 1.91871867e-01f, 3.18225026e-01f, 1.23857081e-01f, 2.62301654e-01f, 3.35367978e-01f,
  -2.30460182e-01f, -5.47823273e-02f, 9.07430947e-02f, 9.53698084e-02f, 1.41581699e-01f, -1.77171960e-01f, -2.38451660e-01f, 1.18287198e-01f, 1.18306197e-01f, 5.06152548e-02f,
  -2.71996446e-02f, -4.84766159e-03f, 1.49460316e-01f, 1.40212670e-01f, 2.32709385e-02f, -1.04942024e-02f, -2.39537191e-02f, 1.40863135e-01f, 4.01920974e-02f, -6.55802935e-02f,
  -1.15749046e-01f, 3.76918241e-02f, -4.96238023e-02f, -2.61010565e-02f, 8.40481073e-02f, 6.51399791e-02f, -1.28115833e-01f, -2.09358767e-01f, 5.18582352e-02f, 1.88747525e-01f,
  -3.79294902e-02f, 3.74127403e-02f, 4.27669324e-02f, -1.16185263e-01f, 7.47417985e-03f, 8.66405517e-02f, -3.75418328e-02f, 1.19114168e-01f, -4.47701700e-02f, 4.87612709e-02f,
  -1.66201577e-01f, 5.17895073e-02f, 6.07733689e-02f, -1.32646650e-01f, -6.50862753e-02f, 1.78718373e-01f, 1.37630522e-01f, -1.00934371e-01f, 6.64892495e-02f, -8.78119916e-02f,
  1.03800625e-01f, 9.24256593e-02f, -9.70836058e-02f, 1.11052804e-01f, -1.72560260e-01f, -1.29975542e-01f, 3.82719874e-01f, 2.15193853e-01f, 1.47785053e-01f, 2.39113256e-01f,
  -2.68366128e-01f, 3.25960189e-01f, 1.28407270e-01f, 1.88610613e-01f, -9.86033008e-02f, 7.33632073e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 14)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 14;
const float L3_fan_Bp_bar_data[] = {
  -1.15744984e-02f, 4.41373102e-02f, 2.21085530e-02f, 2.90675052e-02f, 6.74140081e-02f, 9.41030458e-02f, 1.56685561e-01f, 7.34178275e-02f, 6.76351041e-02f, 7.81275108e-02f,
  1.08156309e-01f, 1.25124916e-01f, 1.12445690e-01f, -1.83231719e-02f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -9.70028341e-03f, -2.61339217e-01f, 1.79632202e-01f, -2.32937232e-01f, 1.22376516e-01f, -1.06114715e-01f, -1.69404075e-01f, 1.59168288e-01f, 1.52525842e-01f, 3.42947841e-02f,
  -1.20906442e-01f, 7.85779506e-02f, 1.83174983e-01f, 9.94007885e-02f, 1.66282728e-02f, 1.06648877e-01f, -1.01594537e-01f, -1.30464420e-01f, -2.28185609e-01f, -7.30778128e-02f,
  4.39094342e-02f, 2.17792718e-03f, 1.35798231e-01f, 1.11983307e-01f, 3.00769191e-02f, -2.65302002e-01f, 1.01960957e-01f, -2.59888738e-01f, 6.78328872e-02f, -2.76802808e-01f,
  2.54048347e-01f, -7.52597451e-02f, -7.29308426e-02f, 1.41828479e-02f, -2.19306186e-01f, 2.36804441e-01f, 1.83237195e-01f, 1.60275325e-01f, 2.36731041e-02f, -2.62579530e-01f,
  2.28831396e-01f, -1.51919350e-01f, 2.77193397e-01f, -8.58486891e-02f, 2.22009301e-01f, -1.58993557e-01f, 2.54993856e-01f, 1.12771234e-02f, 7.42513165e-02f, 2.89964229e-01f,
  -1.87659624e-03f, 2.13438913e-01f, -2.03436852e-01f, 8.42555091e-02f, -5.52130640e-01f, -4.48667675e-01f, 1.81206521e-02f, 3.02069634e-01f, -4.02325034e-01f, -3.73005360e-01f,
  3.58968884e-01f, -9.97359306e-02f, 2.01884329e-01f, -3.95203739e-01f, 2.24583089e-01f, 2.60659039e-01f, 7.88750947e-02f, 1.60508826e-01f, -6.87045977e-02f, -1.46897033e-01f,
  -2.22591594e-01f, -3.90697241e-01f, -1.66651085e-01f, 5.80690429e-03f, -2.59919554e-01f, 9.45290625e-02f, -3.87227722e-02f, 8.48109052e-02f, 1.21663295e-01f, -1.32868618e-01f,
  -1.27340719e-01f, -1.47643566e-01f, 4.16532531e-02f, -4.40662429e-02f, 1.50179699e-01f, -2.18060836e-01f, -2.56084949e-01f, -1.19556069e-01f, -6.30141124e-02f, 3.93791590e-03f,
  -8.83422606e-03f, -2.41553802e-02f, -3.29453409e-01f, 2.77032226e-01f, -1.35174975e-01f, -1.65635020e-01f, -1.49214938e-01f, -2.83832073e-01f, 2.32701182e-01f, 3.01525649e-02f,
  7.22137690e-02f, -2.70545512e-01f, -3.67211968e-01f, 2.46513143e-01f, 2.81650782e-01f, -3.24786484e-01f, -2.19649319e-02f, -2.18266681e-01f, -8.64935443e-02f, -1.20453812e-01f,
  2.82120913e-01f, 1.35959342e-01f, 2.14290440e-01f, 2.17916772e-01f, -5.63429415e-01f, 1.96336061e-01f, -5.60747325e-01f, -1.67530909e-01f, 6.79776147e-02f, -3.18616062e-01f,
  2.02722594e-01f, 1.43297195e-01f, 1.28118709e-01f, 1.62337005e-01f, 1.21603079e-01f, -2.86109626e-01f, 1.40248938e-03f, 1.33619979e-01f, -3.90309989e-02f, 1.14726141e-01f,
  5.31333052e-02f, -1.64204523e-01f, 1.49466634e-01f, 5.91265336e-02f, 6.61067665e-02f, 1.44971862e-01f, -1.52046710e-01f, 4.22934914e-04f, -1.50134817e-01f, -5.58709502e-02f,
  -9.84136835e-02f, -1.43204018e-01f, -2.32194780e-05f, -1.06347911e-01f, -2.10470200e-01f, 1.94653392e-01f, 1.83728278e-01f, -1.13371927e-02f, -1.15398005e-01f, -1.51375473e-01f,
  2.61058480e-01f, 1.77752867e-01f, 1.08032547e-01f, -2.39622265e-01f, 1.37448251e-01f, -2.00205997e-01f, 2.35033050e-01f, 6.57333955e-02f, 2.31369570e-01f, -1.18840113e-01f,
  1.20016083e-01f, 1.73136666e-01f, 1.77230507e-01f, 9.39425156e-02f, -1.81433469e-01f, -6.64119096e-03f, -1.30857050e-01f, 8.83040354e-02f, -1.03373140e-01f, 9.64258686e-02f,
  -1.22365855e-01f, -3.06137562e-01f, 1.95693418e-01f, 1.92248330e-01f, -1.27652213e-01f, 1.40055895e-01f, -2.56336361e-01f, -1.27057672e-01f, 2.90899962e-01f, 3.69157083e-02f,
  -2.28529602e-01f, -1.48111945e-02f, -1.72030702e-01f, -7.86753520e-02f, -9.66882035e-02f, 1.23687185e-01f, 8.31675082e-02f, 2.77678490e-01f, 1.69488668e-01f, -5.20594493e-02f,
  -3.71425837e-01f, 6.70689717e-02f, 7.59966299e-02f, -1.15624085e-01f, -8.12703520e-02f, -9.77421701e-02f, -7.35109076e-02f, -2.12724671e-01f, -1.61665589e-01f, -1.99676514e-01f,
  -1.05090775e-01f, 6.71981229e-03f, -5.40455729e-02f, 3.51029187e-02f, -1.17689902e-02f, 2.99324039e-02f, -2.35251635e-01f, 8.73389542e-02f, 1.96703747e-01f, -1.81144908e-01f,
  -1.94602802e-01f, 1.41925678e-01f, 1.68932393e-01f, -1.26974374e-01f, -1.45153865e-01f, 8.94252360e-02f, 6.13423809e-02f, 2.34915793e-01f, -9.13233459e-02f, 1.52322948e-01f,
  -2.54861355e-01f, 1.93162542e-02f, 1.05710462e-01f, -2.30286449e-01f, -1.90613940e-01f, -1.82181656e-01f, 2.08933637e-01f, -1.55254528e-01f, -1.03260607e-01f, 2.05264375e-01f,
  1.89167470e-01f, -1.43314078e-01f, -3.41257423e-01f, 2.48585735e-02f, -2.15651050e-01f, 1.09389767e-01f, 2.62113541e-01f, -3.05896610e-01f, -2.08629414e-01f, 6.99086860e-02f,
  -2.58584559e-01f, 3.91822577e-01f, -4.22629952e-01f, 3.05799723e-01f, -2.00983346e-01f, 7.02687427e-02f, -3.50480765e-01f, 3.28929156e-01f, -1.56970903e-01f, 1.21189002e-02f,
  -1.87770650e-01f, -3.97906452e-01f, -3.83146405e-01f, 2.03816161e-01f, -2.46486321e-01f, -3.11304539e-01f, -1.84887219e-02f, 6.65964484e-02f, -1.36696965e-01f, 1.49601009e-02f,
  7.18646720e-02f, 1.08243257e-01f, -1.42745599e-01f, 1.42838195e-01f, -2.09153235e-01f, 1.52031600e-01f, 6.89917356e-02f, -1.06081732e-01f, -4.15912941e-02f, -1.11114606e-01f,
  2.03013897e-01f, 2.17876453e-02f, 7.11397231e-02f, -1.46718631e-02f, 1.75664425e-01f, -2.26700544e-01f, -1.46641791e-01f, -1.05935544e-01f, -5.61448745e-02f, -3.70267145e-02f,
  7.26286247e-02f, 1.60235733e-01f, 2.86462307e-01f, -1.51212916e-01f, -2.00374559e-01f, -3.31363469e-01f, -1.06378138e-01f, 1.86568841e-01f, 7.29633048e-02f, -7.80380666e-02f,
  -1.14874035e-01f, -5.33317402e-02f, -2.77041823e-01f, -6.83007250e-03f, -1.11692324e-01f, -2.64440924e-01f, 1.96539715e-01f, -1.41304210e-01f, -7.64256790e-02f, 1.78749952e-02f,
  -2.38544885e-02f, 2.06380829e-01f, -1.54767647e-01f, -2.32239768e-01f, 2.78529555e-01f, -4.94750470e-01f, -4.53337669e-01f, 1.34554893e-01f, -2.19295532e-01f, 2.99105227e-01f,
  1.42576531e-01f, 1.85692728e-01f, -3.46040934e-01f, 1.12109117e-01f, -3.86894912e-01f, -1.10161513e-01f, -3.64104286e-02f, -3.33101302e-01f, 2.48963192e-01f, 4.49037291e-02f,
  -4.13357504e-02f, -1.12152182e-01f, 1.12911105e-01f, 1.28144458e-01f, -3.25543247e-02f, 1.07200697e-01f, 1.71453953e-01f, 2.23228022e-01f, 7.38762990e-02f, 7.07685649e-02f,
  2.67969280e-01f, -7.73787722e-02f, 6.12005545e-03f, 2.79298760e-02f, -1.66186765e-01f, 8.39192700e-03f, 7.92555958e-02f, 1.82368055e-01f, -4.57488783e-02f, 1.58094615e-01f,
  -2.90670358e-02f, 3.98224257e-02f, 2.65022460e-02f, -7.54162967e-02f, 1.63663059e-01f, 1.18881412e-01f, -1.59479171e-01f, 8.27770829e-02f, -4.38156426e-02f, 8.69522840e-02f,
  4.70378309e-01f, 2.13724077e-02f, 2.14689910e-01f, 4.37060744e-01f, -9.45921242e-02f, 1.57133818e-01f, 1.79655388e-01f, 1.45069689e-01f, 3.33912849e-01f, -6.88391849e-02f,
  -4.01635736e-01f, 2.98254251e-01f, 3.58198225e-01f, -1.99803799e-01f, 2.47793049e-01f, 6.34409115e-02f, -1.46937922e-01f, 2.69407898e-01f, -2.85947740e-01f, -4.84057248e-01f,
  -1.23967662e-01f, 1.39698759e-01f, -3.09851323e-03f, -1.95490688e-01f, 2.95517832e-01f, -4.03564870e-01f, 2.19924942e-01f, 1.77394360e-01f, 6.61320984e-02f, -1.59948975e-01f,
  -1.15211375e-01f, -3.15006703e-01f, 2.40113780e-01f, -4.37634826e-01f, 1.42210990e-01f, -2.32269928e-01f, 1.41751915e-01f, -9.16262642e-02f, -2.12083116e-01f, 1.90305784e-01f,
  -6.92217872e-02f, -1.49794102e-01f, 8.82308409e-02f, 2.46025249e-01f, 2.38625541e-01f, 6.62716553e-02f, -8.22300464e-02f, -7.59464800e-02f, -6.45989403e-02f, -2.29390431e-02f,
  7.90509060e-02f, -1.63579255e-01f, -9.10287648e-02f, 2.55514324e-01f, -1.94740538e-02f, -9.18359458e-02f, 1.33348271e-01f, 1.15067197e-03f, -1.39386773e-01f, 4.60581435e-03f,
  -6.68641403e-02f, 1.65913016e-01f, -1.24496281e-01f, -2.70726196e-02f, -1.52508885e-01f, 2.56696254e-01f, 1.76395297e-01f, 7.01304451e-02f, 1.62767187e-01f, -1.20496258e-01f,
  4.76219058e-02f, -2.58885264e-01f, 2.32971907e-01f, -2.37110049e-01f, 2.61815459e-01f, -7.90593922e-02f, 1.69108547e-02f, 2.74470896e-01f, -2.33506486e-01f, 3.73559892e-01f,
  3.72536421e-01f, -1.57045081e-01f, 2.04050571e-01f, -3.21468189e-02f, 3.33440542e-01f, -5.52696824e-01f, 1.87261432e-01f, -1.91663668e-01f, 9.25458446e-02f, -6.65220171e-02f,
  1.33840060e-02f, 3.14409807e-02f, 2.18243543e-02f, -4.00342373e-03f, -1.82161015e-03f, 9.78296343e-03f, -8.10881183e-02f, 1.28755674e-01f, -2.20042050e-01f, 1.46499604e-01f,
  -6.59358054e-02f, -2.14501336e-01f, 8.02070424e-02f, 1.47483543e-01f, 2.30799705e-01f, 1.18803158e-01f, 1.34837285e-01f, 2.47084141e-01f, 2.15638444e-01f, 4.62242737e-02f,
  -2.46332556e-01f, 8.27818811e-02f, -2.12917775e-02f, -1.48918495e-01f, -2.20399052e-02f, 1.80334687e-01f, -2.82429717e-02f, 1.65339753e-01f, -7.18532652e-02f, 1.14552557e-01f,
  1.53703272e-01f, 1.45784542e-01f, -1.34397209e-01f, -9.15063769e-02f, -5.89938723e-02f, 1.52805015e-01f, -1.79801941e-01f, -2.43074358e-01f, -2.34138474e-01f, 6.74141943e-02f,
  2.74205685e-01f, -1.84592858e-01f, 7.17820600e-03f, -8.23708996e-02f, -2.20361516e-01f, 2.04984516e-01f, 2.23613814e-01f, 2.52111614e-01f, -1.53906897e-01f, 2.46495202e-01f,
  -1.53906912e-01f, 3.37075442e-01f, -1.07402958e-01f, -2.40540624e-01f, -2.40887001e-01f, 2.00126186e-01f, 1.96784705e-01f, 2.56958783e-01f, -1.15745828e-01f, -2.44372934e-01f,
  3.59659940e-02f, -9.87187177e-02f, -3.77166867e-01f, 1.21903002e-01f, 5.68339884e-01f, -3.31323892e-01f, -2.78013170e-01f, -5.20162284e-02f, 2.69657344e-01f, -1.47626981e-01f,
  3.30411732e-01f, -1.79232121e-01f, -2.54723914e-02f, -5.55764250e-02f, 1.34822235e-01f, -1.36053432e-02f, -2.10179478e-01f, 8.08500797e-02f, 3.54916342e-02f, -7.59163275e-02f,
  1.52064726e-01f, -2.70583659e-01f, -1.77709177e-01f, 9.59083810e-02f, -1.02902494e-01f, 5.03610633e-02f, -2.85008326e-02f, 6.68743625e-02f, 1.76400185e-01f, 1.35660559e-01f,
  -6.58878833e-02f, 5.36381714e-02f, 3.37962769e-02f, 4.78939526e-03f, -1.41695410e-01f, -1.20768189e-01f, 4.04711440e-02f, 2.09916636e-01f, -2.64479965e-01f, -1.98714301e-01f,
  2.27656394e-01f, 6.61752373e-02f, 2.88184285e-01f, 1.02989353e-01f, -1.93514116e-02f, -3.08949798e-02f, -1.87511623e-01f, 1.20834284e-01f, 1.98913977e-01f, 1.87538215e-03f,
  -2.20186621e-01f, 2.13364407e-01f, 3.73433977e-02f, -1.22348428e-01f, 1.92412943e-01f, 2.52621412e-01f, -2.76676416e-01f, 1.71551377e-01f, 1.51422098e-01f, 2.44508490e-01f,
  1.20984860e-01f, 2.98427761e-01f, -1.61654260e-02f, 2.54975617e-01f, 7.14119151e-02f, -4.89286274e-01f, 1.90793518e-02f, -2.17616767e-01f, 2.38960549e-01f, -5.82622826e-01f,
  2.90756673e-01f, 1.34060234e-01f, -1.25838101e-01f, 2.87595481e-01f, -3.42629522e-01f, -3.02377287e-02f, -7.28700012e-02f, 2.15910837e-01f, -3.05180907e-01f, 2.72318929e-01f,
  1.02355041e-01f, 1.60425138e-02f, -9.56504345e-02f, -1.39655858e-01f, 1.61130726e-01f, -2.11659551e-01f, -2.05297291e-01f, -9.06015262e-02f, 1.91451415e-01f, -9.29005370e-02f,
  -1.06342688e-01f, 1.02589235e-01f, 5.28072715e-02f, -7.66477361e-02f, 1.16666690e-01f, -2.76673108e-01f, -5.72707094e-02f, 1.37428328e-01f, 9.91959721e-02f, -1.61966160e-01f,
  -1.24510545e-02f, -6.07917346e-02f, -2.46172652e-01f, -2.77838130e-02f, 2.07549781e-01f, 3.34680200e-01f, -2.64458656e-01f, -3.58851731e-01f, -6.71587363e-02f, 1.03219390e-01f,
  -1.35306060e-01f, -1.26663387e-01f, 1.90776199e-01f, 2.38787785e-01f, -2.32269451e-01f, 2.85301834e-01f, 1.43074885e-01f, 1.96980655e-01f, -2.31598049e-01f, -6.43144622e-02f,
  2.10431769e-01f, -2.03006834e-01f, -2.70920694e-01f, -2.79457152e-01f, -2.39945218e-01f, 5.59897982e-02f, 1.74994826e-01f, -3.29144746e-01f, 1.06719829e-01f, 2.17551947e-01f,
  8.25071335e-02f, -1.74962565e-01f, -8.04580599e-02f, 5.39071672e-02f, 1.73000574e-01f, -4.97162014e-01f, -7.49766007e-02f, -4.92057621e-01f, 1.19185895e-01f, 2.68488348e-01f,
  1.70302868e-01f, -4.72190827e-02f, 8.32582116e-02f, 5.05885258e-02f, -3.63621414e-02f, 6.30825832e-02f, 9.87715870e-02f, 3.01637910e-02f, -1.02896094e-01f, -1.65635213e-01f,
  2.44968489e-01f, -2.31117904e-01f, 7.93860704e-02f, 1.53406650e-01f, 5.70695549e-02f, 5.75253218e-02f, -1.50701225e-01f, -1.71089202e-01f, -1.13914661e-01f, 1.24375500e-01f,
  -1.00648917e-01f, 7.89928585e-02f, -1.82978585e-01f, -3.02893352e-02f, 5.25769666e-02f, -2.04735503e-01f, 2.49033034e-01f, 1.03757717e-02f, 2.33158618e-01f, -2.38075301e-01f,
  -1.88539833e-01f, -1.39680728e-01f, 2.26363882e-01f, 5.77025078e-02f, 1.29974224e-02f, 6.13636822e-02f, 9.37085673e-02f, -1.53845355e-01f, 3.45658790e-03f, -2.36868709e-01f,
  2.95053422e-01f, -2.32210681e-01f, 8.04254562e-02f, 1.34099513e-01f, -1.26188904e-01f, 2.61342853e-01f, 1.17511742e-01f, -1.74318820e-01f, -1.94223106e-01f, -3.60630192e-02f,
  1.65930271e-01f, -1.92380726e-01f, 1.05834506e-01f, 1.72543317e-01f, -3.14828843e-01f, 1.43791214e-01f, -4.29306805e-01f, -3.05667758e-01f, -4.46059793e-01f, 3.20295334e-01f,
  -4.01464999e-02f, 2.92986780e-01f, -3.03428233e-01f, 1.87055245e-01f, -1.67292506e-01f, 1.56198651e-01f, -1.42111719e-01f, 1.03214525e-01f, 7.13529205e-03f, -1.42159000e-01f,
  1.15889385e-01f, 6.62636086e-02f, 2.77280640e-02f, -2.29057774e-01f, -3.38511318e-02f, -1.32574961e-01f, 1.44219652e-01f, -1.35047913e-01f, 8.43713507e-02f, -5.70804588e-02f,
  -7.72098228e-02f, -1.81167021e-01f, -1.57304183e-01f, 6.63615093e-02f, 2.74637211e-02f, 4.64258492e-02f, -9.67052951e-02f, -4.92044259e-03f, 4.24673706e-02f, 6.28425032e-02f,
  -1.92077085e-01f, -6.34900387e-03f, 2.45270222e-01f, 2.41535425e-01f, 2.42716819e-02f, 8.18418041e-02f, -1.66712925e-01f, 2.89759368e-01f, 1.13536075e-01f, -1.76955327e-01f,
  -2.09606811e-01f, 1.35170460e-01f, -2.85778809e-02f, 1.13461480e-01f, -2.94463873e-01f, 2.22449288e-01f, -4.45891432e-02f, -1.08967379e-01f, -2.44567052e-01f, -1.05365098e-01f,
  -1.75461575e-01f, -8.19668993e-02f, 1.54044703e-01f, -2.78986216e-01f, 1.01346940e-01f, -2.08658069e-01f, 2.62275577e-01f, -3.64559084e-01f, 3.60279530e-01f, 2.46427193e-01f,
  -3.74365449e-01f, -3.42577696e-01f, -1.80533841e-01f, -1.95398718e-01f, -3.50950330e-01f, 1.43137038e-01f, 1.22908935e-01f, -2.40529627e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  7.17499107e-02f, -7.36796260e-02f, -9.60243940e-02f, 3.84677239e-02f, -7.42218867e-02f, -4.81986292e-02f, -7.81939179e-02f, 1.56961054e-01f, 2.12151594e-02f, -7.81274512e-02f,
  -4.92688939e-02f, 7.63799027e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    