/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.15986794e-01f, 2.34229892e-01f, -1.73603654e-01f, 2.82037854e-01f, 6.70628622e-02f, -8.64731222e-02f, 1.50378272e-01f, 7.08557516e-02f, 1.28516093e-01f, 1.80547312e-01f,
  -3.50549258e-02f, -1.69074848e-01f, -1.77217394e-01f, -1.70491189e-01f, -5.51366135e-02f, 1.32442102e-01f, 3.64835560e-02f, -2.03161567e-01f, -2.44318530e-01f, -9.48233306e-02f,
  1.32099763e-01f, 1.35178477e-01f, 7.86630288e-02f, -2.60021407e-02f, 2.25183427e-01f, 2.81299022e-03f, 1.67160138e-01f, 2.85659675e-02f, 5.40526323e-02f, 2.14223996e-01f,
  -1.54141560e-01f, 6.26683841e-03f, -1.41636208e-01f, 4.88870516e-02f, -4.92659286e-02f, -1.90428235e-02f, -4.51870747e-02f, 1.08410917e-01f, 1.04229666e-01f, 1.03961863e-01f,
  2.15902440e-02f, -3.17852907e-02f, 9.71510820e-03f, 1.21628605e-02f, 8.41238871e-02f, -3.18528339e-02f, -2.13455781e-02f, -8.93321559e-02f, -7.66259655e-02f, -4.88145314e-02f,
  6.10957444e-02f, -5.14044948e-02f, -1.15594909e-01f, -7.12677389e-02f, -1.24526091e-01f, -4.25719395e-02f, -4.59275693e-02f, -8.90965015e-02f, -7.90266022e-02f, 1.40770599e-01f,
  1.88134108e-02f, -3.47967399e-03f, -7.78617188e-02f, 9.60465148e-03f, 6.49195462e-02f, -7.10331947e-02f, 4.83680479e-02f, 4.04297300e-02f, -2.53128186e-02f, 4.09685969e-02f,
  -5.34011014e-02f, -1.10879419e-02f, -4.07338701e-02f, 6.95453361e-02f, -5.77143021e-02f, -1.16735026e-02f, 1.69243421e-02f, 1.84928086e-02f, -1.81544982e-02f, 2.66019162e-02f,
  -4.45988849e-02f, -4.95485961e-02f, 6.87691718e-02f, -5.61456122e-02f, -1.76908597e-02f, -3.60425375e-02f, 5.68678230e-02f, -1.09059177e-01f, 1.02950642e-02f, 1.04438640e-01f,
  1.62834361e-01f, -2.69163221e-01f, 1.45295978e-01f, 4.34014909e-02f, 2.65787784e-02f, 1.55654959e-02f, 5.96635975e-02f, -7.20391497e-02f, 9.71034111e-04f, -6.17697909e-02f,
  -4.35777046e-02f, 3.01167853e-02f, -3.39272171e-02f, -5.15964348e-03f, -1.60636101e-02f, 2.79333144e-02f, 1.19882651e-01f, -7.42736235e-02f, 2.00426709e-02f, 1.73631851e-02f,
  3.09072081e-02f, 1.04581036e-01f, -2.90313363e-02f, 4.45794091e-02f, -6.11366071e-02f, -6.10152632e-02f, -3.82821746e-02f, 3.73546332e-02f, -1.26100063e-01f, 1.75790593e-01f,
  5.07616639e-01f, -5.45813203e-01f, -1.63101926e-01f, 3.98612879e-02f, -5.61856478e-02f, -1.16186850e-01f, -3.16638887e-01f, 3.06424089e-02f, 1.71622232e-01f, -1.94641709e-01f,
  -1.13329016e-01f, 1.77637655e-02f, 9.03576016e-02f, 1.67916223e-01f, 1.16804436e-01f, -1.52266935e-01f, -1.36391521e-01f, 1.65207252e-01f, 3.69553417e-01f, 5.64385541e-02f,
  -4.72218953e-02f, -9.10814758e-03f, 1.44297421e-01f, 6.77805617e-02f, -2.25709658e-02f, -5.79463728e-02f, -9.11802128e-02f, -1.09204039e-01f, -9.06133577e-02f, -2.78469652e-01f,
  -3.12620759e-01f, 6.58382028e-02f, 3.99575084e-02f, -3.82611863e-02f, -1.36131644e-01f, 8.17527249e-02f, 3.48399170e-02f, 1.37023837e-03f, -2.83559281e-02f, -2.55817696e-02f,
  -1.08859809e-02f, 7.31243044e-02f, -1.11511732e-02f, -1.12986594e-01f, 1.74234267e-02f, -4.77596298e-02f, 7.35749379e-02f, 1.06341265e-01f, 1.24445364e-01f, -7.69222975e-02f,
  -2.31647164e-01f, -1.10622764e-01f, -7.72577673e-02f, -1.07042402e-01f, 7.82174692e-02f, 7.28218555e-02f, -1.27651453e-01f, -3.40786092e-02f, 1.25598520e-01f, -1.03233561e-01f,
  1.99788599e-03f, -3.18052955e-02f, 2.07608901e-02f, 1.47819789e-02f, 3.55522451e-03f, 2.04419699e-02f, -4.93901670e-02f, -3.13767940e-02f, -6.00445177e-03f, 8.32005683e-03f,
  4.76677939e-02f, 2.29061171e-02f, -1.97182298e-02f, -4.21993621e-02f, -5.99333197e-02f, -9.76885781e-02f, -6.36106730e-02f, -2.61698682e-02f, -3.26860230e-03f, 1.38528356e-02f,
  4.52619530e-02f, 2.79789884e-03f, 2.18060929e-02f, 6.53304253e-03f, 2.93920678e-03f, 4.86179292e-02f, 2.10749973e-02f, 3.90885258e-03f, 6.26834184e-02f, -2.86303740e-02f,
  -1.16054416e-01f, 1.67814329e-01f, -2.72242166e-02f, 1.23084910e-01f, -2.13561673e-02f, -3.67980599e-02f, -6.05945550e-02f, 2.81947926e-02f, 3.13138738e-02f, 3.38732786e-02f,
  1.37600005e-02f, 6.28372729e-02f, -3.60996053e-02f, 5.66030666e-02f, 8.42694864e-02f, 6.43454567e-02f, -1.14641413e-01f, 2.49213148e-02f, 1.98645685e-02f, -3.70083377e-02f,
  -5.55129051e-02f, 3.43227014e-02f, 1.93988495e-02f, -8.10049698e-02f, 4.70017903e-02f, 9.43444073e-02f, -1.27782986e-01f, 6.08215593e-02f, 3.20170596e-02f, -1.38336942e-01f,
  8.74469340e-01f, 2.44623587e-01f, -2.42291480e-01f, 2.87428677e-01f, -1.26891226e-01f, -2.86406070e-01f, -2.12776303e-01f, 5.51772155e-02f, 1.31635100e-01f, 1.34566918e-01f,
  4.34745587e-02f, 8.09005275e-02f, 4.23711576e-02f, -1.59638390e-01f, -4.00395319e-02f, -1.13552660e-01f, -1.40552521e-01f, -6.37350231e-02f, -9.85321924e-02f, 1.87090766e-02f,
  -1.02872990e-01f, 1.30965978e-01f, 3.47507179e-01f, 3.52553534e-03f, -2.54374929e-02f, -1.26976773e-01f, -5.94812557e-02f, 1.44517198e-01f, -1.20530479e-01f, 1.14491455e-01f,
  -7.52213830e-03f, 4.24159914e-01f, -1.80073142e-01f, -3.13981734e-02f, -3.31401080e-03f, 4.17199843e-02f, -6.82884175e-03f, 6.04147092e-02f, 3.62878107e-02f, 7.98636377e-02f,
  -1.38945775e-02f, -1.49644110e-02f, 6.93425313e-02f, -5.62015697e-02f, 3.05391513e-02f, 6.06910475e-02f, 7.68122375e-02f, -3.41987386e-02f, 1.24668339e-02f, 3.74524072e-02f,
  -6.96742460e-02f, 4.05779146e-02f, 1.13266654e-01f, -3.38944495e-02f, 1.33575620e-02f, -9.49795470e-02f, -2.29178331e-04f, 8.46441239e-02f, -1.01167455e-01f, 2.59684145e-01f,
  -3.04587698e-03f, 1.31187802e-02f, -4.72226255e-02f, 2.82085296e-02f, -3.11993230e-02f, -2.04066522e-02f, -7.46532017e-03f, -3.49045061e-02f, 4.20573913e-02f, 9.03748628e-03f,
  -5.36262915e-02f, -1.18656307e-02f, -8.36937129e-03f, 8.17993730e-02f, -1.10839391e-02f, -1.31770410e-03f, 3.37395933e-03f, -1.41134728e-02f, 1.26777664e-02f, 1.03183612e-02f,
  4.20133322e-02f, -3.52222323e-02f, 6.02657348e-02f, -3.62726226e-02f, -6.44194782e-02f, -9.96142626e-03f, -1.23387529e-02f, 1.49364546e-02f, 2.30639670e-02f, 4.29528058e-02f,
  1.84108421e-01f, -2.45286807e-01f, 1.03418820e-01f, 2.53429543e-02f, 3.94039638e-02f, 2.24604774e-02f, 9.89960972e-03f, -2.24336386e-02f, -2.16520764e-02f, 1.48793608e-02f,
  1.38837080e-02f, 1.34938896e-01f, 3.81526835e-02f, -8.70854128e-03f, 4.86880206e-02f, -2.27473378e-02f, -2.25909837e-02f, 4.30636220e-02f, -8.84856880e-02f, 4.57781740e-03f,
  4.79837097e-02f, -1.27454530e-02f, 6.21123612e-02f, -1.06436789e-01f, 3.74015905e-02f, -1.35304913e-01f, -1.72365941e-02f, -9.26379189e-02f, -1.11917526e-01f, 4.83478568e-02f,
  3.35527092e-01f, -2.83735126e-01f, -3.60579133e-01f, 1.92463249e-01f, 1.62082881e-01f, 2.61651855e-02f, -2.33703628e-01f, -5.48133813e-02f, 9.11311358e-02f, -5.81356585e-02f,
  2.33242381e-02f, 2.49021977e-01f, 4.06332500e-02f, 7.72676095e-02f, -1.69890106e-01f, -3.34426314e-01f, -3.59440178e-01f, -8.62784311e-02f, 1.81969732e-01f, 1.56548560e-01f,
  -5.37320152e-02f, 1.13768205e-02f, 3.67284566e-02f, 2.63937190e-02f, -4.53160740e-02f, 7.96005800e-02f, -1.10777423e-01f, 3.58238406e-02f, -1.21792413e-01f, -2.91382402e-01f,
  9.66423973e-02f, -3.97714451e-02f, 8.79139751e-02f, -3.92262079e-02f, 8.21668357e-02f, -5.33472076e-02f, 3.89946671e-03f, -1.30267199e-02f, 1.10171415e-01f, -7.44155720e-02f,
  -3.94496508e-02f, 1.03935875e-01f, 4.83588204e-02f, 8.67174845e-03f, -1.30039463e-02f, -1.03474557e-02f, -1.43391356e-01f, -5.04588820e-02f, -8.28911066e-02f, -7.78539628e-02f,
  -2.62977108e-02f, -6.45790622e-02f, 2.87743565e-02f, -1.26248524e-01f, -1.10809110e-01f, 7.95174316e-02f, -3.67037806e-04f, -1.02999568e-01f, -1.01589061e-01f, -2.09445104e-01f,
  -4.59690168e-02f, 3.52133550e-02f, 1.53767914e-02f, 7.65620591e-03f, -1.15158362e-02f, 9.67470370e-03f, 1.14689137e-04f, 5.00607528e-02f, 9.04531032e-03f, -5.17589024e-06f,
  4.05668505e-02f, -4.25219275e-02f, -5.85623421e-02f, 3.53662064e-03f, 2.73071695e-03f, -2.89664101e-02f, -6.27792105e-02f, -6.13648072e-02f, -1.07277241e-02f, 2.71689184e-02f,
  1.76900215e-02f, -1.41201662e-02f, 4.54057269e-02f, 2.25759088e-03f, -2.21031066e-02f, -3.78418155e-02f, -9.80566908e-03f, 5.94829815e-03f, 1.35406181e-01f, 3.25797610e-02f,
  1.54506549e-01f, -8.97736922e-02f, 3.31831165e-02f, 6.01495691e-02f, -3.59817035e-02f, 5.19392546e-03f, -1.40573438e-02f, -4.78750989e-02f, 7.08514675e-02f, 2.98255216e-03f,
  6.80298507e-02f, -4.46859654e-03f, -5.70929563e-03f, -1.64788440e-02f, 5.05136959e-02f, 4.47333045e-02f, -3.39672714e-02f, -1.63002890e-02f, -8.24647211e-03f, 6.48219585e-02f,
  -1.44479454e-01f, -3.48550417e-02f, 2.06734359e-01f, 4.68280949e-02f, 3.75092663e-02f, 2.20365241e-01f, 3.98507304e-02f, 1.38514146e-01f, 6.18265569e-02f, -6.40386939e-02f,
  4.95041728e-01f, -1.13117499e-02f, 2.31584966e-01f, -9.73331276e-03f, 1.27989218e-01f, 1.92273110e-01f, 6.49291575e-02f, 1.64176934e-04f, -9.76543725e-02f, -2.16085259e-02f,
  -4.78490023e-03f, -1.48350941e-02f, -7.30830804e-02f, -1.76842269e-02f, 1.69704601e-01f, -1.07833549e-01f, -4.18057991e-03f, 1.06294706e-01f, 1.89173028e-01f, 1.21954046e-01f,
  -2.90125590e-02f, -4.93612774e-02f, 1.06091544e-01f, 2.76163854e-02f, -1.97556511e-01f, -1.38718978e-01f, -1.48112029e-01f, 2.76810378e-02f, -8.90466571e-02f, -2.64474303e-01f,
  8.31432641e-02f, 1.17253907e-01f, 1.13485858e-01f, 1.86018087e-02f, -1.29335150e-02f, 1.40373670e-02f, 1.16436251e-01f, 6.00237362e-02f, -1.34670241e-02f, 2.75983810e-02f,
  -1.62900779e-02f, 4.17336822e-03f, -2.83856578e-02f, -1.15256913e-01f, -3.81071419e-02f, -5.67441399e-04f, -1.07289359e-01f, 7.46577699e-03f, 3.54979523e-02f, -9.23139136e-03f,
  -7.27680624e-02f, 1.85019657e-01f, 2.56176233e-01f, 4.99400944e-02f, 1.31987073e-02f, 4.26577181e-02f, -2.90578827e-02f, -9.80246346e-04f, 1.14837036e-01f, -1.64717615e-01f,
  7.85181206e-03f, 2.71414164e-02f, 2.34111268e-02f, -6.83646426e-02f, -2.33967267e-02f, -4.98355664e-02f, -1.07651604e-02f, -5.32880332e-03f, -1.83019694e-02f, -1.02603577e-01f,
  4.58875671e-02f, -1.87590457e-02f, 4.02877759e-03f, 3.03498507e-02f, -1.87446587e-02f, -3.21994448e-05f, 1.40582742e-02f, -2.87342835e-02f, -4.22366336e-02f, 1.50088016e-02f,
  6.15480021e-02f, -2.00191587e-02f, -3.99057660e-03f, -5.47329038e-02f, 5.56989014e-03f, -1.80837680e-02f, 4.13316414e-02f, -3.63486856e-02f, -1.99469402e-02f, 2.45050639e-02f,
  -1.92788705e-01f, 2.61611342e-01f, -3.56959887e-02f, -8.55286568e-02f, 1.17747588e-02f, -9.27293152e-02f, -1.74614496e-03f, -1.29712857e-02f, 4.26874962e-03f, 5.35052046e-02f,
  2.12616306e-02f, 1.91015024e-02f, -1.71847958e-02f, -9.31543484e-02f, -7.20435195e-03f, 7.91938324e-03f, -8.65570754e-02f, 5.29585369e-02f, -2.40884759e-02f, -8.55588391e-02f,
  -1.12232454e-04f, 1.30793974e-01f, 2.61322618e-01f, 3.32008786e-02f, 1.22605087e-02f, 2.30977446e-01f, 5.22001134e-03f, 4.30309922e-02f, 2.16519415e-01f, 1.90816447e-02f,
  -7.28870630e-02f, -3.19609672e-01f, -3.30686927e-01f, -1.32523462e-01f, -9.53230709e-02f, -1.48935676e-01f, -1.63740814e-01f, -5.66506246e-03f, 5.46981692e-02f, -9.93411914e-02f,
  1.42720537e-02f, 8.34025443e-02f, 1.06910672e-02f, 1.02658667e-01f, -9.35066491e-03f, -1.66503787e-01f, -1.92116693e-01f, -8.64969715e-02f, 3.46892141e-02f, 7.09803682e-03f,
  1.81590281e-02f, 2.00042985e-02f, 1.34889901e-01f, 3.04048844e-02f, -1.04422480e-01f, 1.74469203e-02f, -1.20177254e-01f, -7.25565255e-02f, -6.88959286e-02f, -3.59549373e-01f,
  -1.71841443e-01f, -1.95658386e-01f, 6.88377321e-02f, 1.49898708e-01f, 2.76885573e-02f, 2.25572996e-02f, 7.53509477e-02f, 1.17520586e-01f, 8.89756009e-02f, -1.57002024e-02f,
  8.18443373e-02f, 4.82718647e-03f, -2.67304201e-02f, 5.52270636e-02f, 1.55065209e-02f, 7.64308870e-02f, 7.70188197e-02f, -1.16166689e-01f, -8.35869163e-02f, 1.90531369e-02f,
  -1.49257272e-01f, -9.68921110e-02f, -1.52758762e-01f, 3.33713330e-02f, -6.52090386e-02f, 3.64371948e-02f, 2.70818621e-02f, -1.92171019e-02f, 1.79987568e-02f, -5.45778088e-02f,
  -2.87836436e-02f, -2.60725971e-02f, 7.77400378e-03f, -5.55625744e-02f, 3.53494920e-02f, 5.34593277e-02f, 1.24315852e-02f, -4.70583439e-02f, -1.21886823e-02f, -1.65744666e-02f,
  1.48216067e-02f, -7.85180479e-02f, -1.68704148e-02f, -2.86584664e-02f, 3.70835066e-02f, -5.00433668e-02f, 4.83157858e-02f, -2.01389343e-02f, 2.67456528e-02f, 2.28743837e-03f,
  4.84095067e-02f, -2.06801761e-02f, -2.55842526e-02f, 6.26793206e-02f, -5.39659485e-02f, -3.91548648e-02f, 7.51077980e-02f, 1.94518045e-02f, 2.01995298e-02f, 6.03676625e-02f,
  2.75912315e-01f, 2.04574078e-01f, -3.90508026e-02f, -1.80875361e-02f, -5.37909614e-03f, 1.60076916e-02f, -6.75540492e-02f, 3.33726173e-03f, 4.45071273e-02f, -3.04987542e-02f,
  -1.15924617e-02f, 3.78406085e-02f, 4.51392075e-03f, 4.61246446e-02f, -2.98839379e-02f, -6.30518608e-03f, -1.89763252e-02f, -5.64976260e-02f, -1.58012118e-02f, -1.11509137e-01f,
  3.53150978e-03f, 2.41520088e-02f, 1.27690718e-01f, 6.05018996e-02f, 4.68489230e-02f, 2.75655184e-02f, 6.70075342e-02f, -4.53718081e-02f, 1.20480753e-01f, -2.17049923e-02f,
  -4.92011845e-01f, 4.61997539e-02f, -1.67023595e-02f, -2.10690483e-01f, 5.56940064e-02f, 8.74286890e-02f, 2.85038799e-01f, -4.24681418e-02f, 6.59482926e-03f, 7.35100135e-02f,
  -2.65370365e-02f, -1.40529778e-02f, -2.05494035e-02f, 2.18006205e-02f, 6.58934712e-02f, 2.09218919e-01f, 1.06078744e-01f, -1.35890812e-01f, -1.80859730e-01f, -9.99008268e-02f,
  -5.40502667e-02f, -2.63864905e-01f, -2.78842449e-01f, -3.16933207e-02f, -4.95797172e-02f, -4.73846868e-02f, -2.87636612e-02f, -3.18824835e-02f, -2.27893852e-02f, -1.17600430e-02f,
  2.00339556e-01f, -1.26281321e-01f, 3.34642432e-03f, -1.63758904e-01f, -4.07207534e-02f, -1.10980850e-02f, -4.49794978e-02f, -1.13672949e-01f, 2.77458169e-02f, 5.20433374e-02f,
  -5.16468696e-02f, -7.51245469e-02f, -3.68393287e-02f, 4.24962826e-02f, -3.98431122e-02f, -2.70292666e-02f, -5.58908097e-02f, -5.24037629e-02f, 6.34544790e-02f, 8.91321227e-02f,
  -2.07095239e-02f, -6.70198649e-02f, -5.87811880e-02f, 5.04394658e-02f, 6.29032962e-03f, -2.59423237e-02f, -4.76190336e-02f, -4.52400967e-02f, 8.71401727e-02f, 2.20283419e-02f,
  -1.78049225e-02f, 7.55474344e-02f, -4.67229821e-02f, -2.11680643e-02f, -3.68301086e-02f, 3.70289721e-02f, -3.79552394e-02f, -4.66773324e-02f, 5.09124137e-02f, 4.06280532e-02f,
  7.73134688e-03f, 1.83062516e-02f, 5.93905188e-02f, 1.79482065e-02f, 4.69641723e-02f, 7.89578166e-03f, 6.16307184e-03f, -3.83738265e-03f, -9.25115682e-03f, 3.45912948e-02f,
  -5.97305112e-02f, -4.94850203e-02f, 1.28851868e-02f, 4.63289097e-02f, -3.31831314e-02f, 1.29874451e-02f, -4.25259359e-02f, 4.89687100e-02f, -2.99531501e-03f, -7.95645714e-02f,
  1.62103567e-02f, -1.98904760e-02f, -5.41761564e-03f, 3.73063833e-02f, -1.63556393e-02f, 5.45617901e-02f, 2.97975633e-02f, 3.08180554e-03f, -5.33902645e-02f, -2.25398745e-02f,
  -3.42262834e-02f, -4.53804433e-02f, 4.73427065e-02f, 2.48235818e-02f, 2.64208317e-02f, 4.89420928e-02f, -2.49957833e-02f, 2.48894619e-04f, -5.31468205e-02f, 3.66890654e-02f,
  6.53368160e-02f, -2.15611197e-02f, -1.55881131e-02f, 5.23819886e-02f, 1.29030809e-01f, 3.70456986e-02f, 1.02639288e-01f, 2.64380686e-02f, 7.47034624e-02f, 7.71896467e-02f,
  -2.30129153e-01f, 3.22065860e-01f, 4.75053713e-02f, 7.53734857e-02f, 1.96755469e-01f, 1.12130694e-01f, 4.66577299e-02f, -7.07229879e-03f, -8.11738297e-02f, 2.41959408e-01f,
  1.59163788e-01f, -4.40269709e-03f, 6.87945709e-02f, 4.02690694e-02f, -1.77506477e-01f, 1.47235870e-01f, -5.86037571e-03f, -1.72636181e-01f, -1.24578260e-01f, -1.11906612e-02f,
  8.04177076e-02f, -1.55697092e-01f, -2.54113674e-01f, -1.61726736e-02f, 1.56975746e-01f, -5.29534891e-02f, 3.76578681e-02f, 1.32255271e-01f, 2.45679796e-01f, 2.30752468e-01f,
  3.55005324e-01f, 1.26690745e-01f, -2.31815260e-02f, 4.78140777e-03f, -2.81565245e-02f, -1.61491521e-02f, 8.10779259e-02f, -3.54297715e-03f, 4.51734848e-02f, 8.45571235e-02f,
  1.25712886e-01f, -9.52934753e-03f, 7.59357866e-03f, 1.17652966e-02f, -2.11606175e-02f, -9.35531408e-02f, -1.99031737e-02f, -1.41401738e-01f, -8.23146924e-02f, 1.23540290e-01f,
  1.70298949e-01f, 1.31689414e-01f, 3.30873355e-02f, -8.06011376e-04f, -3.52598317e-02f, -1.06236581e-02f, 6.32982105e-02f, 1.79382656e-02f, -5.58639579e-02f, 3.60652842e-02f,
  9.54048894e-03f, 2.84829326e-02f, -8.24819435e-05f, -7.14747831e-02f, 3.04169334e-05f, -5.02357595e-02f, -8.21844563e-02f, -1.57517064e-02f, -3.50021087e-02f, -1.84892211e-02f,
  -1.40700983e-02f, 1.63545925e-02f, -7.71910790e-03f, -2.74976045e-02f, 1.21840544e-01f, 2.18733493e-02f, 4.02003005e-02f, -2.78242212e-02f, 5.22739552e-02f, 2.01223250e-02f,
  -1.49555309e-02f, -3.54112238e-02f, -5.50992303e-02f, -4.78700735e-02f, 1.83282066e-02f, 2.44886018e-02f, -1.49827106e-02f, 6.95519596e-02f, -1.64158791e-02f, 8.86107534e-02f,
  -1.42111421e-01f, -3.01803667e-02f, 7.26475641e-02f, -7.88527504e-02f, 1.05657708e-02f, -2.66820919e-02f, 2.98415106e-02f, 9.71932523e-03f, 7.45104849e-02f, 7.82153010e-02f,
  4.64383177e-02f, 1.74828693e-02f, 8.55954662e-02f, 8.03709626e-02f, -1.31487310e-01f, 4.07698639e-02f, -7.36887157e-02f, 6.31549731e-02f, -2.00479757e-02f, 4.63952161e-02f,
  -6.44674152e-02f, -1.70733891e-02f, -2.25322187e-01f, -2.82809585e-02f, -2.59162821e-02f, -1.08703643e-01f, 4.07410040e-03f, 1.91200920e-03f, -2.31623873e-01f, -1.16107590e-01f,
  -8.39287564e-02f, -3.70055407e-01f, -3.22465599e-01f, 7.66537488e-02f, 3.30346152e-02f, -1.27473965e-01f, -2.11980507e-01f, -1.19730130e-01f, 1.78599991e-02f, -1.21227928e-01f,
  1.71368327e-02f, 2.91069835e-01f, 2.67371684e-01f, 1.26968294e-01f, -4.97320704e-02f, -2.33398750e-01f, -1.16858222e-01f, 6.99297786e-02f, 1.44229606e-01f, 1.23042271e-01f,
  1.75936624e-01f, 1.15904272e-01f, 9.14508030e-02f, -1.44786146e-02f, 5.82598038e-02f, 1.86219558e-01f, -1.46819904e-01f, -4.67304252e-02f, -8.93219281e-03f, 7.94856623e-02f,
  1.12723131e-02f, -2.43118867e-01f, 2.13448912e-01f, 1.98995098e-01f, -5.31311408e-02f, -5.49464859e-02f, -2.48447675e-02f, -6.98523819e-02f, -3.95554677e-02f, -9.88255218e-02f,
  7.47752264e-02f, 9.67925638e-02f, 1.30323365e-01f, -5.60703129e-02f, -3.25210206e-02f, -3.25714634e-03f, 3.07167750e-02f, -5.84486276e-02f, -2.59694904e-02f, -4.48431075e-02f,
  6.89730644e-02f, -4.91378829e-03f, -1.23238474e-01f, -7.78546333e-02f, 5.51558146e-03f, 1.84985861e-01f, -2.99226325e-02f, -3.94602939e-02f, -1.37382090e-01f, -1.19436279e-01f,
  -7.76585191e-03f, 1.67228049e-03f, 4.06210460e-02f, -3.73332649e-02f, 7.76049495e-02f, 1.14022559e-02f, -4.07521129e-02f, 6.53855950e-02f, 4.92062010e-02f, 1.36258211e-02f,
  -3.63269746e-02f, -4.68720272e-02f, -6.74553122e-03f, -1.07737165e-02f, 9.77926180e-02f, -9.03428942e-02f, -4.22066934e-02f, -1.19170304e-02f, -1.64045487e-02f, -5.27471229e-02f,
  7.62761980e-02f, -4.79528941e-02f, 3.61193568e-02f, -5.31839253e-03f, 2.09801923e-02f, -1.76403988e-02f, 2.89518200e-02f, -2.05588341e-02f, -3.80865894e-02f, -4.86518489e-03f,
  2.01554820e-01f, 7.33823925e-02f, 1.10951766e-01f, 1.02619082e-01f, -2.97712386e-02f, -4.48484495e-02f, 1.06495485e-01f, 2.56436504e-02f, 9.27290991e-02f, 5.54560311e-03f,
  4.54152673e-02f, -8.96629039e-03f, -4.48745601e-02f, 4.74681631e-02f, 3.83962095e-02f, 4.38621007e-02f, -3.64635959e-02f, 1.07722528e-01f, -6.93021268e-02f, -2.28521600e-02f,
  -7.95124397e-02f, -6.97422028e-02f, -5.09073958e-02f, 1.12505285e-02f, -4.28018123e-02f, 2.00134203e-01f, -6.91437274e-02f, -6.52708784e-02f, -8.05815980e-02f, -1.32702470e-01f,
  -1.03431173e-01f, -8.17129090e-02f, -2.24277630e-01f, 7.47833848e-02f, -3.61218899e-02f, 9.75170434e-02f, 6.80451766e-02f, 1.33642033e-01f, 2.70318333e-02f, -7.30997771e-02f,
  -1.26227245e-01f, 7.95604810e-02f, -1.00741059e-01f, -5.51295727e-02f, 1.86016336e-02f, 5.29720746e-02f, 1.21020533e-01f, 2.83162910e-02f, 1.11389756e-01f, 2.89086103e-01f,
  1.54718161e-01f, 1.90259621e-01f, 9.20796916e-02f, 1.20840788e-01f, -4.64654975e-02f, 3.55373025e-02f, -1.46410972e-01f, -5.03806099e-02f, -1.80394016e-02f, 1.17120378e-01f,
  -1.46395758e-01f, -2.64119655e-01f, 1.01140641e-01f, 4.19967696e-02f, -1.17303744e-01f, -5.60645200e-03f, 3.69601361e-02f, -7.89182931e-02f, -1.16318211e-01f, -1.72719210e-02f,
  -7.67183602e-02f, -9.85610858e-02f, -1.00608810e-03f, 3.65589862e-03f, 3.23520452e-02f, -8.48362148e-02f, -9.93807241e-02f, -1.08361244e-01f, -9.99545604e-02f, 3.80890700e-03f,
  -1.81185249e-02f, -1.47353142e-01f, -1.47245854e-01f, -3.27038132e-02f, -1.51963472e-01f, -1.15585618e-01f, -1.94854587e-01f, -1.91205308e-01f, -1.25224099e-01f, -3.34683992e-02f,
  4.64285463e-02f, -4.82663587e-02f, 1.83067489e-02f, 1.56759433e-02f, 3.40835378e-02f, -1.63366925e-02f, 6.80051744e-03f, 4.08881791e-02f, -6.20675227e-03f, -4.38058823e-02f,
  -3.33945304e-02f, -8.38772207e-02f, 2.38937158e-02f, 7.84122292e-03f, 4.09018137e-02f, -6.14431687e-03f, 8.27455372e-02f, 3.22549082e-02f, -4.81905416e-02f, -7.46956244e-02f,
  2.73084119e-02f, -1.01344310e-01f, -5.40831462e-02f, 4.85526994e-02f, -2.39506457e-02f, -7.70769045e-02f, 1.29924892e-02f, -4.36397232e-02f, 2.60878373e-02f, -3.75109613e-02f,
  2.48493642e-01f, -1.46220595e-01f, 7.66979381e-02f, 5.81343137e-02f, -6.97793216e-02f, -4.55011893e-03f, -4.20840308e-02f, -3.64854150e-02f, -9.38326195e-02f, 1.14912495e-01f,
  -2.76303757e-02f, 5.87387644e-02f, -3.90865803e-02f, 7.18973503e-02f, 1.34282798e-01f, 3.11418641e-02f, -4.08049719e-03f, 7.11779743e-02f, 2.42661647e-02f, -6.33930713e-02f,
  -1.44744078e-02f, 1.75059333e-01f, 1.75836399e-01f, 2.35688221e-02f, -3.02870478e-02f, 1.67215660e-01f, 1.63493723e-01f, 9.82929766e-02f, 7.63984695e-02f, 3.10419381e-01f,
  1.09823756e-01f, -1.33565469e-02f, -5.73345311e-02f, -1.14445522e-01f, 1.29768103e-01f, 3.06040198e-01f, 4.71044719e-01f, 1.92831919e-01f, -2.40498148e-02f, -2.06998419e-02f,
  -2.96624489e-02f, -5.31324521e-02f, -3.90787870e-02f, 6.75171763e-02f, 2.69638240e-01f, 8.48658457e-02f, 4.05164659e-02f, 3.34918313e-02f, 1.38352990e-01f, 7.78622255e-02f,
  -3.96717675e-02f, 4.69884090e-02f, -3.97886820e-02f, -4.09081653e-02f, -2.47576624e-01f, -2.36048132e-01f, -4.64537553e-02f, -2.31103990e-02f, -1.97332073e-02f, -2.21376449e-01f,
  -5.26837587e-01f, 1.45964755e-03f, 4.99080569e-02f, -3.42989340e-03f, -6.68588951e-02f, -2.06558444e-02f, -4.23075967e-02f, -1.30698144e-01f, 2.35472340e-02f, -1.28024900e-02f,
  -4.53126095e-02f, -4.65335250e-02f, 1.91326234e-02f, -3.98178808e-02f, 2.31123175e-02f, 4.30868735e-04f, -5.18173389e-02f, 8.62977281e-02f, 7.80780241e-02f, -1.68661904e-02f,
  -6.55888841e-02f, 6.82568848e-02f, 1.10044330e-01f, 1.15922533e-01f, 1.40241802e-01f, 3.97479795e-02f, 1.10476628e-01f, 1.18646473e-02f, 4.18920033e-02f, -1.19595185e-01f,
  4.46165428e-02f, 7.75231980e-03f, -2.87854970e-02f, 5.86056476e-03f, -4.24719192e-02f, 7.37116253e-03f, 3.71683314e-02f, -3.29527818e-02f, -1.51688950e-02f, -2.06133239e-02f,
  5.52803371e-03f, 3.05664893e-02f, -4.41282755e-03f, 1.68868396e-02f, -5.00379726e-02f, -4.68277559e-03f, 4.79529724e-02f, 4.86707054e-02f, -4.31157872e-02f, -2.23740749e-02f,
  4.27938476e-02f, -5.31689599e-02f, -8.26068074e-02f, 1.13347964e-02f, 2.76255142e-03f, 6.23388998e-02f, -1.89110413e-02f, 4.38076332e-02f, -2.87264511e-02f, -1.20155863e-03f,
  -1.29013151e-01f, 3.20966989e-01f, -1.10096820e-01f, -1.39971748e-02f, -8.93126428e-02f, -2.96584889e-02f, -4.41938303e-02f, -3.53100449e-02f, -2.96649411e-02f, -2.39317957e-02f,
  3.84048261e-02f, 1.31474459e-03f, -1.05645262e-01f, 2.33987421e-02f, 3.87208611e-02f, -3.45027968e-02f, 1.19399019e-02f, -5.70038930e-02f, 4.16614078e-02f, -2.15473026e-02f,
  -4.38018627e-02f, 7.74661377e-02f, -6.12081923e-02f, -1.79361142e-02f, 4.49729385e-03f, 4.61316742e-02f, -5.56603447e-02f, 1.09330062e-02f, 1.49244785e-01f, -3.25939730e-02f,
  4.51934367e-01f, -2.75765091e-01f, -2.21323341e-01f, 6.74309358e-02f, 1.95234977e-02f, -6.44380674e-02f, -8.17937031e-02f, 6.32530823e-03f, 4.64950353e-02f, -5.55910962e-03f,
  9.27309319e-03f, 1.24975041e-01f, 6.47578835e-02f, 2.89267432e-02f, 5.91858476e-02f, -1.59417853e-01f, -1.48118690e-01f, 1.37187421e-01f, 1.87856704e-01f, 1.02049388e-01f,
  -4.54780981e-02f, 1.50582805e-01f, 2.06368312e-01f, 8.88713077e-02f, -2.33304918e-01f, -3.73752005e-02f, -1.69015646e-01f, -1.17119722e-01f, -5.66769093e-02f, -3.33379924e-01f,
  -9.28695351e-02f, -1.19706310e-01f, 1.31687567e-01f, 6.86123371e-02f, -5.14167808e-02f, 4.81134057e-02f, -4.01071869e-02f, -8.84685367e-02f, 8.98063823e-04f, 5.43351024e-02f,
  5.49018048e-02f, -6.18419982e-02f, -6.85380250e-02f, -2.32562125e-02f, 2.45224424e-02f, 8.31447542e-02f, 7.42475390e-02f, 3.62903476e-02f, 2.82187592e-02f, 7.07853632e-03f,
  -2.44638659e-02f, 2.38302648e-02f, 1.55719146e-01f, 3.44369635e-02f, -7.48934969e-02f, 1.21486694e-01f, -6.53865710e-02f, -3.67567921e-03f, -3.96406017e-02f, -2.02246199e-04f,
  4.73726122e-03f, -3.16208750e-02f, -1.81994140e-02f, -6.37226254e-02f, 4.25860807e-02f, -2.81664450e-02f, -8.04874748e-02f, 1.23768905e-02f, -4.45775874e-03f, -3.50827165e-02f,
  2.99421772e-02f, 8.24236572e-02f, -2.92340643e-03f, -1.63310226e-02f, 5.14392257e-02f, -1.12768286e-03f, 6.32804004e-04f, 3.81884426e-02f, 7.47676641e-02f, 9.33911651e-02f,
  2.75218859e-02f, 6.86687708e-04f, 4.65806052e-02f, -8.53123888e-02f, -3.89717706e-02f, 1.01402793e-02f, -2.83257514e-02f, 6.40341863e-02f, -5.88196609e-03f, 4.96704392e-02f,
  2.07915664e-01f, 1.55113935e-01f, 7.59268133e-03f, -3.35753523e-03f, 1.00457007e-02f, 3.64304595e-02f, -5.84753156e-02f, 2.96833422e-02f, -5.44360429e-02f, 2.87707094e-02f,
  -1.02846883e-02f, -1.58730522e-02f, 6.78020269e-02f, -7.56357089e-02f, 1.15106657e-01f, -1.00449687e-02f, 2.89964117e-02f, -3.66642363e-02f, 8.08912888e-02f, 9.24645551e-03f,
  5.30740358e-02f, 1.51403144e-01f, 3.09406906e-01f, 1.47239313e-01f, 4.20966782e-02f, 1.83331415e-01f, 4.53382358e-02f, 7.65470117e-02f, 1.89914197e-01f, 1.70371354e-01f,
  -3.17814052e-01f, -2.20815241e-01f, -3.49388897e-01f, -1.38427224e-02f, 1.02227069e-01f, -9.31122899e-02f, -1.99317530e-01f, 1.68832559e-02f, 4.23197895e-02f, -1.96912568e-02f,
  1.79218218e-01f, 1.24813914e-01f, 9.54977348e-02f, 3.08893472e-02f, -1.55507505e-01f, -9.65196788e-02f, -2.06234783e-01f, -1.30701467e-01f, -2.47003827e-02f, 4.74294238e-02f,
  1.11428827e-01f, -6.55751137e-05f, -1.04313716e-01f, -1.24477213e-02f, 8.10676778e-04f, -3.98777239e-02f, -1.02127500e-01f, 1.46736752e-03f, 1.27817430e-02f, -1.10912986e-01f,
  -2.39113107e-01f, -1.96347356e-01f, 6.29402548e-02f, 1.51106343e-01f, 5.38238585e-02f, -8.53911042e-02f, -2.03033164e-02f, 7.06769386e-03f, 1.21181168e-01f, -9.57737342e-02f,
  1.09748013e-01f, 8.87020156e-02f, 7.17414394e-02f, 2.61008907e-02f, 3.04360688e-02f, -8.68123919e-02f, -1.29309192e-01f, -1.59917533e-01f, -8.98382366e-02f, -4.22912054e-02f,
  1.38771638e-01f, 2.90029701e-02f, -5.12407832e-02f, -6.02945611e-02f, -9.60238203e-02f, 1.82604007e-02f, -1.67197675e-01f, -6.78908825e-02f, -6.91453144e-02f, -2.72747755e-01f,
  -5.13106063e-02f, -2.96767615e-02f, -4.99615595e-02f, 6.46602176e-03f, -1.53159834e-02f, 5.62896170e-02f, -6.52830973e-02f, 1.45795867e-02f, -3.06072887e-02f, -8.98091197e-02f,
  8.13460797e-02f, -2.82344501e-02f, 3.23927589e-02f, -2.83886436e-02f, 6.29095435e-02f, -6.84298435e-03f, 2.72760205e-02f, -5.91450045e-03f, 1.47474594e-02f, 5.88888377e-02f,
  1.14761768e-02f, -7.12696137e-03f, -3.20003331e-02f, 1.93617679e-02f, -1.40379174e-02f, -1.27644045e-02f, 2.79912464e-02f, 6.86127767e-02f, -3.04516964e-02f, -8.43489915e-03f,
  3.39153931e-02f, 1.30770922e-01f, -7.33352676e-02f, -2.35689674e-02f, -4.36563417e-02f, 7.82391429e-02f, 8.15783627e-03f, 1.83265866e-03f, 9.08659678e-03f, -7.38757625e-02f,
  -1.64780777e-03f, -1.44060388e-01f, -3.80550697e-02f, -3.35932225e-02f, -3.85507359e-03f, 1.63860805e-02f, -3.88274342e-02f, -3.45186330e-02f, 2.03762688e-02f, -4.82736826e-02f,
  4.22628075e-02f, 3.31788883e-02f, -1.09436207e-01f, -1.09809913e-01f, -2.17087604e-02f, 2.19285674e-02f, -7.26556219e-03f, -4.19642664e-02f, -9.22561362e-02f, -2.25514442e-01f,
  -1.91863611e-01f, -2.48581126e-01f, -1.16377473e-01f, -1.38035029e-01f, -4.70369533e-02f, -2.22358793e-01f, -3.59280586e-01f, -1.37545258e-01f, -3.30991223e-02f, -1.92316979e-01f,
  3.76580618e-02f, 1.23888105e-01f, -4.74654995e-02f, -1.66290224e-01f, -3.12393695e-01f, -2.40055770e-01f, -1.98965684e-01f, -2.51940370e-01f, -1.77904919e-01f, -2.19951406e-01f,
  -8.95318314e-02f, -1.93450734e-01f, -1.72031060e-01f, -6.17904365e-02f, 1.06791314e-02f, 1.19685225e-01f, 7.21505843e-03f, -1.56808756e-02f, -9.52516645e-02f, -1.40554488e-01f,
  -1.44761845e-01f, -1.72192350e-01f, 1.63294598e-02f, -4.98981355e-03f, -3.12522054e-02f, 6.34714738e-02f, 7.65690207e-03f, 1.62388198e-02f, 4.92504351e-02f, -1.78869180e-02f,
  3.70161869e-02f, -4.76219878e-03f, 6.90288395e-02f, -2.72854064e-02f, -8.49018618e-02f, -6.03726692e-03f, -2.96366271e-02f, -1.07150070e-01f, -6.53006658e-02f, -2.32866723e-02f,
  4.92512435e-02f, -1.21813896e-03f, 4.72327322e-02f, 5.95060140e-02f, -1.85666271e-02f, 1.14660792e-01f, -3.35146785e-02f, -1.06778881e-02f, 1.12236887e-02f, -7.55831972e-02f,
  -1.90159604e-02f, 1.44889369e-03f, 3.70793752e-02f, 7.21103884e-03f, 1.25482613e-02f, -7.53743434e-03f, 5.56920059e-02f, -2.43478417e-02f, 1.46553684e-02f, -2.00548535e-03f,
  -3.94311100e-02f, 1.28699392e-02f, 3.54237691e-03f, 5.40662557e-02f, -3.31951343e-02f, 9.29846335e-03f, 5.81673980e-02f, -7.51099885e-02f, 6.28948957e-02f, -1.80636663e-02f,
  -1.86037284e-03f, 1.00252582e-02f, 4.02437709e-02f, -2.22292244e-02f, -5.06764604e-03f, -6.06187917e-02f, -2.11157184e-02f, -1.18164737e-02f, 3.07131242e-02f, 2.28116065e-02f,
  2.12503299e-01f, -1.79055380e-03f, -1.65605508e-02f, -4.87953722e-02f, 7.45712444e-02f, 4.47686128e-02f, 2.19873786e-02f, 8.29919130e-02f, 9.18696374e-02f, 1.28421346e-02f,
  1.18516227e-02f, -6.94782212e-02f, 6.29142101e-04f, 4.19741459e-02f, 6.35854620e-03f, -4.84962352e-02f, -9.34621412e-03f, 2.50229109e-02f, 1.10138014e-01f, 3.17444168e-02f,
  -7.62605816e-02f, -1.17729120e-02f, 1.48375630e-02f, 9.28456932e-02f, 9.01786163e-02f, 1.46511309e-02f, 1.13850527e-01f, 8.47662166e-02f, 5.41340485e-02f, 4.98469099e-02f,
  1.37740001e-01f, -1.07265815e-01f, 2.06477687e-01f, 7.96938390e-02f, 2.35077262e-01f, 7.17901485e-03f, -1.01691656e-01f, -1.52978659e-01f, 3.61903906e-02f, -9.75111872e-02f,
  9.35926661e-02f, -2.81472169e-02f, -3.76965776e-02f, -3.09222918e-02f, -1.65844575e-01f, -1.54489562e-01f, -2.62499712e-02f, -1.47827882e-02f, 9.32653248e-03f, 4.03504372e-02f,
  3.08833104e-02f, 4.68464941e-02f, 8.69592056e-02f, -4.88702506e-02f, 1.41953276e-02f, 1.26744658e-01f, 6.72424734e-02f, 2.23637193e-01f, 8.59874561e-02f, 1.55838728e-01f,
  2.29039509e-02f, 1.97784454e-01f, 3.02303918e-02f, 7.61699071e-03f, 1.10318735e-01f, -2.88650561e-02f, -4.78763282e-02f, 1.08048566e-01f, -1.53704807e-02f, -5.98904602e-02f,
  6.35695606e-02f, 1.15040597e-02f, 8.51044133e-02f, -5.30972928e-02f, -2.32764445e-02f, 3.85522805e-02f, 3.28027122e-02f, 8.69996380e-03f, -2.40828674e-02f, 4.49786447e-02f,
  -2.84017455e-02f, 2.37372980e-01f, 9.74269509e-02f, -7.60674477e-02f, -3.78014222e-02f, 7.17505068e-02f, 4.96226847e-02f, 5.78311086e-02f, 7.63168335e-02f, -2.19120651e-01f,
  -1.11382287e-02f, -4.24909741e-02f, 6.78315386e-02f, -8.32414627e-02f, -4.87450808e-02f, 4.00177278e-02f, -5.66973947e-02f, -5.78780882e-02f, -2.91737579e-02f, -3.50384973e-02f,
  -6.60866946e-02f, 1.19843641e-02f, -7.52244219e-02f, -7.29986057e-02f, -2.13656817e-02f, 8.24586973e-02f, -1.66896991e-02f, -9.43589732e-02f, 8.38281885e-02f, -1.39868138e-02f,
  5.00141233e-02f, -1.76912844e-02f, 2.75122398e-03f, -4.65762652e-02f, -2.14976408e-02f, -2.42257374e-03f, 8.67483318e-02f, -4.37386446e-02f, 1.93487126e-02f, 1.02219217e-01f,
  -2.62361228e-01f, 2.13437289e-01f, -2.53846007e-03f, -3.30344476e-02f, 2.25706566e-02f, -7.94623233e-03f, 1.17566083e-02f, -4.49521020e-02f, 1.14378169e-01f, -1.11705780e-01f,
  1.31888771e-02f, -3.17695141e-02f, -2.84291729e-02f, -1.69140156e-02f, -5.56999370e-02f, 5.22597954e-02f, -1.25087380e-01f, -2.57598162e-02f, 3.89479809e-02f, -2.08414886e-02f,
  -1.55371085e-01f, -2.65929401e-02f, -7.31229708e-02f, -1.01868160e-01f, -2.33889371e-02f, 9.05611441e-02f, -9.24874917e-02f, -1.06148802e-01f, 4.42951126e-03f, -4.73620027e-01f,
  2.38915712e-01f, -1.77860498e-01f, -3.08924586e-01f, 2.26359386e-02f, -6.01765234e-03f, -6.04375191e-02f, 3.35560888e-02f, 5.06996661e-02f, 5.45488968e-02f, 1.00792542e-01f,
  -1.21989055e-02f, 1.11614726e-01f, -2.35907268e-02f, 6.69340715e-02f, -6.94750398e-02f, -7.98027143e-02f, -2.52228618e-01f, -1.25673503e-01f, -2.52671875e-02f, 6.29996089e-03f,
  9.53767449e-03f, -1.33621708e-01f, 2.10979991e-02f, -2.13373662e-03f, -2.53486577e-02f, 6.82147145e-02f, -7.34030679e-02f, -1.04255572e-01f, -9.31405649e-02f, -1.23630904e-01f,
  9.55880210e-02f, 3.94805074e-02f, 1.04299121e-01f, -4.75293137e-02f, -1.70747917e-02f, 1.08261727e-01f, 8.54047686e-02f, 3.68025936e-02f, 9.81228352e-02f, -1.25185810e-02f,
  -2.80021057e-02f, 2.14247201e-02f, -6.28547817e-02f, 4.83295172e-02f, -2.95932833e-02f, 5.01015410e-02f, -1.05769075e-01f, 2.07391847e-03f, 1.95656139e-02f, 2.38724593e-02f,
  -5.73720150e-02f, -7.21238181e-02f, 1.61596145e-02f, 2.77326796e-02f, 3.36323828e-02f, -9.00499448e-02f, 5.89054227e-02f, 1.22948870e-01f, 1.37539223e-01f, 1.25059023e-01f,
  4.17783111e-02f, 2.89105698e-02f, -1.76515244e-02f, 1.29001439e-02f, -1.23926848e-02f, 2.93236040e-03f, 4.32797382e-03f, -4.75385077e-02f, -4.83234040e-03f, 2.48393603e-02f,
  -3.96944117e-03f, 1.09486043e-01f, -2.10213121e-02f, 9.18189213e-02f, -1.62228364e-02f, 4.57009375e-02f, -3.04799248e-02f, -2.49876790e-02f, -3.75364497e-02f, -4.11035568e-02f,
  -2.48400699e-02f, 6.32931963e-02f, -4.96086851e-02f, -7.73880333e-02f, 2.55093984e-02f, -6.90501854e-02f, -4.58918512e-03f, 8.86951834e-02f, -9.03226726e-04f, 5.12976423e-02f,
  2.32865110e-01f, -1.82983711e-01f, 1.53935835e-01f, 1.48476675e-01f, -7.73148611e-02f, -2.43867561e-02f, -5.15511371e-02f, 6.87502697e-03f, 3.72356665e-03f, -1.37825990e-02f,
  -4.94558699e-02f, -3.92797068e-02f, -1.13940202e-01f, -3.72401774e-02f, 5.52188829e-02f, 4.24519181e-02f, 4.78371931e-03f, -6.89598769e-02f, 2.87297405e-02f, 7.25680515e-02f,
  -4.41852063e-02f, 2.18225718e-02f, 9.03106257e-02f, 2.80129500e-02f, 5.33192940e-02f, 1.23272650e-01f, 1.85574107e-02f, 1.38718188e-01f, 1.18506746e-02f, 1.71881706e-01f,
  1.40180960e-01f, -9.90513861e-02f, 2.01935485e-01f, 6.46814927e-02f, -3.07341740e-02f, 1.80771902e-01f, 2.15600729e-01f, 7.26096183e-02f, 5.65261804e-02f, -4.23446484e-02f,
  -6.30026609e-02f, -7.54240528e-02f, -7.47145265e-02f, 4.89692241e-02f, -6.07079128e-04f, 1.99416161e-01f, 1.55712277e-01f, 1.55607775e-01f, 1.89100698e-01f, -1.04391083e-01f,
  -1.10666998e-01f, -5.36352731e-02f, -4.71714586e-02f, -3.20779569e-02f, -1.47915697e-02f, 4.23847474e-02f, -9.32092145e-02f, -5.00518270e-02f, -4.20532003e-02f, 6.31724671e-02f,
  1.40572682e-01f, -3.44501883e-02f, 8.81921872e-02f, 1.09643238e-02f, -1.13176018e-01f, 4.47072312e-02f, 6.14636485e-03f, 7.36726169e-03f, -9.38230306e-02f, -3.37179676e-02f,
  -2.10507140e-02f, -2.44496800e-02f, 8.07431526e-03f, -3.14845517e-02f, -3.75879258e-02f, -4.29648757e-02f, -6.59420490e-02f, 4.13278565e-02f, 7.35480115e-02f, -7.17322305e-02f,
  -1.12556569e-01f, -3.92388664e-02f, 4.20401134e-02f, 5.61610460e-02f, 7.18980432e-02f, 5.03017083e-02f, -1.20880045e-02f, 7.49825388e-02f, 3.17823328e-02f, 1.98967740e-01f,
  -1.62811100e-03f, 1.73602775e-02f, -2.98514981e-02f, -2.49699354e-02f, 7.06089661e-02f, 3.70780565e-02f, -1.82676017e-02f, -5.97129054e-02f, 2.48572659e-02f, 5.86326309e-02f,
  -3.58109474e-02f, -3.23276035e-02f, -4.78051277e-03f, 8.84165615e-03f, -6.56932294e-02f, -2.45279688e-02f, -7.47529790e-02f, -3.60095836e-02f, -4.71568443e-02f, -7.10560307e-02f,
  1.48312654e-02f, 7.26485997e-02f, -8.92013535e-02f, -7.15847462e-02f, 4.39948849e-02f, -3.84273343e-02f, 8.03160146e-02f, -3.33055444e-02f, 6.94608539e-02f, -6.90006539e-02f,
  1.31269619e-01f, -1.21807463e-01f, 7.97691569e-02f, 1.05467565e-01f, 4.42257598e-02f, -6.15286827e-02f, -6.73989281e-02f, 8.78156070e-03f, -1.06034271e-01f, 3.10724024e-02f,
  -2.94989888e-02f, 3.05772852e-02f, -2.14738809e-02f, 3.23306248e-02f, 5.78757226e-02f, 6.51150793e-02f, 6.55375123e-02f, 6.12840988e-02f, -2.48517822e-02f, 7.89596234e-03f,
  -9.43880994e-03f, 1.40461504e-01f, 3.01688045e-01f, 1.43420354e-01f, 7.47415647e-02f, 1.69275522e-01f, 1.04382515e-01f, 1.20869949e-01f, 2.34486461e-01f, 2.78480023e-01f,
  -1.02950647e-01f, -2.83772554e-02f, -3.27573776e-01f, 1.63909435e-01f, -1.04609221e-01f, -3.11411142e-01f, -4.61925030e-01f, -9.91291106e-02f, 9.42143276e-02f, -2.21713372e-02f,
  1.04734087e-02f, 1.95219174e-01f, 8.82391259e-02f, -2.21570674e-02f, -8.99796262e-02f, -1.38036579e-01f, -1.26249135e-01f, -1.40472651e-01f, -1.12470888e-01f, -1.33982882e-01f,
  4.24524061e-02f, 9.61430743e-03f, 9.25157778e-03f, -3.47637758e-02f, 1.91090107e-01f, 1.48392856e-01f, -3.48477438e-02f, -1.05573069e-02f, -1.04961060e-02f, 1.45349830e-01f,
  -3.81169543e-02f, -6.19738130e-04f, -1.33894950e-01f, 1.76677570e-01f, 5.61667830e-02f, 2.27831118e-02f, -6.84047714e-02f, 3.13944593e-02f, 7.74437413e-02f, -3.36963385e-02f,
  2.11732425e-02f, 1.09140225e-01f, 1.32756280e-02f, 2.08470481e-03f, 2.14050319e-02f, -7.19650090e-02f, -3.86402160e-02f, -5.16940579e-02f, -1.45067815e-02f, -1.03442362e-02f,
  7.66735300e-02f, -4.43741493e-02f, -1.08118191e-01f, -1.07681401e-01f, 5.39908521e-02f, 1.05163334e-02f, -1.29370525e-01f, 4.05105092e-02f, -1.73107326e-01f, -5.94147742e-02f,
  1.15333460e-01f, 3.02230082e-02f, 5.27341105e-03f, 2.19339109e-03f, -1.92555599e-02f, 8.67945049e-03f, -1.23351458e-02f, -3.12089231e-02f, -1.00795729e-02f, 1.16715785e-02f,
  -2.82969661e-02f, 2.05227118e-02f, 6.48743147e-03f, 4.66436101e-03f, -2.93516591e-02f, -7.98116252e-02f, -1.06139304e-02f, -2.59485375e-02f, -1.08474910e-01f, 2.23669652e-02f,
  5.98485442e-03f, -3.30539830e-02f, -6.43169926e-03f, 2.55402997e-02f, 4.47996967e-02f, -4.07936946e-02f, -4.79748510e-02f, 3.53991203e-02f, -2.14353763e-02f, -1.13834754e-01f,
  9.01965275e-02f, -8.29839706e-02f, -8.34418088e-02f, 3.92259210e-02f, -5.21696806e-02f, 6.77056015e-02f, -3.04357894e-03f, -5.24080135e-02f, 7.55166076e-03f, -1.27025351e-01f,
  -9.95035395e-02f, -6.84745014e-02f, -3.27179581e-02f, 2.87905317e-02f, -1.37282580e-01f, -3.98941375e-02f, -4.51302454e-02f, -1.34500908e-02f, -5.79948649e-02f, -5.00773154e-02f,
  -2.63710637e-02f, -1.64369330e-01f, -3.15238908e-02f, -1.57775834e-01f, 3.63374688e-02f, -8.91098827e-02f, -2.16941163e-01f, -1.09556422e-01f, -2.80924231e-01f, -1.88278288e-01f,
  2.40494668e-01f, -1.34329069e-02f, -7.00238049e-02f, -2.20844492e-01f, 3.43500264e-02f, 9.47175473e-02f, 2.15296671e-01f, -8.40375200e-03f, -7.55228698e-02f, -1.40565494e-03f,
  9.64134112e-02f, 4.38592136e-02f, 8.20776820e-02f, 3.96275297e-02f, 1.08963430e-01f, -4.73370813e-02f, -2.27725446e-01f, -5.09959459e-02f, 1.56884436e-02f, 8.13772306e-02f,
  -1.36374058e-02f, -2.86479685e-02f, -3.70675325e-02f, -3.74331251e-02f, -2.87859499e-01f, -4.21415120e-02f, -1.17268778e-01f, -1.49788707e-01f, 6.19678460e-02f, -2.07505286e-01f,
  1.66364491e-01f, 1.62338421e-01f, -9.12034437e-02f, -5.93682751e-02f, -6.67659799e-03f, 9.56686586e-02f, 3.70354913e-02f, 1.78614650e-02f, -2.93291938e-02f, -4.87598144e-02f,
  -1.99869256e-02f, 4.62219082e-02f, 5.21904193e-02f, 5.28123565e-02f, -2.30549145e-02f, -5.17303683e-02f, -8.22101310e-02f, -6.55107796e-02f, -9.31780562e-02f, 5.94482832e-02f,
  -2.89442614e-02f, 1.34175301e-01f, 1.35790199e-01f, 3.14100944e-02f, -3.12315077e-02f, 8.38643312e-02f, 1.08929835e-02f, -7.21121281e-02f, 1.55956835e-01f, -7.77355134e-02f,
  2.47455444e-02f, -2.38264091e-02f, 4.33209687e-02f, 6.54227957e-02f, 1.92567911e-02f, -4.50887717e-02f, -1.34996632e-02f, 1.00577604e-02f, -5.00150174e-02f, -1.65959373e-02f,
  -7.67060230e-03f, 5.57830650e-03f, 5.55651858e-02f, -2.01590941e-03f, -9.26625058e-02f, -6.62691742e-02f, 4.40503135e-02f, -4.23268452e-02f, 1.63794756e-02f, -7.28588700e-02f,
  2.19198149e-02f, -1.30294608e-02f, -6.51162416e-02f, 3.34655978e-02f, 2.72961557e-02f, -2.18536202e-02f, -2.07071435e-02f, -2.69158632e-02f, -4.25441004e-02f, -1.33655057e-03f,
  -9.99621581e-03f, 1.17977925e-01f, 5.43288961e-02f, 9.94858816e-02f, -8.91625211e-02f, -3.72084193e-02f, 5.45398258e-02f, 2.66575683e-02f, 8.60117935e-03f, 2.64116563e-02f,
  1.11446761e-01f, 2.76444834e-02f, -7.74875209e-02f, -8.90353024e-02f, 8.56746212e-02f, 6.63690642e-02f, -1.43628633e-02f, -3.74322664e-03f, -6.72316179e-02f, 2.36840043e-02f,
  -1.39243156e-01f, 7.25097433e-02f, 1.50347069e-01f, 3.46880443e-02f, 6.47040978e-02f, 1.80133387e-01f, -4.85300180e-03f, 6.70561269e-02f, 6.61119446e-02f, -8.30079429e-03f,
  -1.16069965e-01f, -2.44783834e-01f, 3.34583879e-01f, -1.39643103e-02f, -1.54968262e-01f, -2.57433057e-02f, -9.75851566e-02f, 5.92592694e-02f, -1.69629455e-02f, -1.04886189e-01f,
  -3.02221596e-01f, -1.93186089e-01f, 2.01945808e-02f, 7.82473013e-02f, 2.83081681e-01f, 2.80592144e-01f, 4.32640612e-01f, 5.16502082e-01f, 3.83598059e-01f, 5.00444975e-03f,
  -2.42335815e-02f, -4.95362207e-02f, 1.06150635e-01f, 1.52679265e-01f, -1.11712523e-01f, 4.74804838e-04f, -2.98940018e-02f, -1.22260563e-02f, -4.28873301e-02f, 1.44541591e-01f,
  -3.94468568e-02f, -1.92908883e-01f, 1.05614483e-01f, -1.29910842e-01f, -3.98859195e-02f, 6.73939437e-02f, 4.01596576e-02f, 1.61493778e-01f, 6.66127801e-02f, 8.23764727e-02f,
  -1.22642532e-01f, -4.43427488e-02f, 9.43826661e-02f, 3.49890701e-02f, 2.20400598e-02f, 5.81052490e-02f, 1.52939588e-01f, 1.29586816e-01f, 1.75098941e-01f, -5.19439466e-02f,
  -1.88189417e-01f, -1.52926603e-02f, 2.07168441e-02f, 4.60335985e-02f, 9.09900293e-02f, 7.51457214e-02f, -8.07877257e-02f, -2.18567513e-02f, 9.02604461e-02f, -1.11562528e-01f,
  -6.67021843e-03f, 2.52439082e-02f, -3.25300470e-02f, -8.47152472e-02f, -4.69657443e-02f, 1.14569413e-02f, -3.03457361e-02f, -3.86982448e-02f, 2.45363917e-02f, 2.35811807e-03f,
  2.92688087e-02f, 3.67348604e-02f, -2.83256676e-02f, 3.93596627e-02f, 7.31429160e-02f, -6.32370403e-03f, 8.12084507e-03f, -5.71984285e-03f, 3.96675952e-02f, 6.36801124e-02f,
  2.18286086e-02f, -7.57885352e-03f, -1.12095643e-02f, 6.59375414e-02f, 2.07910296e-02f, 3.05477399e-02f, -6.59731477e-02f, -6.16429150e-02f, -2.03994475e-02f, -6.21800944e-02f,
  -1.70900583e-01f, 1.21630035e-01f, 2.98120622e-02f, 6.53484985e-02f, -8.18958133e-02f, -1.49528412e-02f, -1.09399565e-01f, 2.82013528e-02f, -3.27647291e-02f, -3.39781158e-02f,
  -7.00779483e-02f, -6.20970353e-02f, 9.05803870e-03f, -2.39095427e-02f, 5.93250990e-02f, 2.31725127e-02f, -6.96057007e-02f, 8.21475685e-02f, 6.48476407e-02f, -1.34660080e-01f,
  2.23042555e-02f, 8.79667178e-02f, 8.25243071e-02f, 1.02603897e-01f, -5.63319661e-02f, 3.79456058e-02f, 8.22196528e-02f, -1.00034913e-02f, 6.22860491e-02f, 4.27860841e-02f,
  -5.67865670e-01f, 2.31255405e-02f, 3.60124588e-01f, -1.00487076e-01f, 2.28155583e-01f, 3.83590341e-01f, 4.84629869e-01f, 7.54290223e-02f, -1.39877722e-01f, 1.04555242e-01f,
  2.34137978e-02f, -2.66033679e-01f, -1.40590027e-01f, -1.84210360e-01f, -1.39376044e-01f, 1.09744035e-01f, 1.76442832e-01f, -1.46733612e-01f, -1.48490727e-01f, -2.53329165e-02f,
  -7.28155151e-02f, -2.00515538e-01f, -2.37200335e-01f, -1.49692044e-01f, 2.35328525e-02f, -5.94094247e-02f, 2.19883516e-01f, 3.91464904e-02f, 7.57139623e-02f, -1.07451610e-01f,
  4.94992696e-02f, 8.97022989e-03f, -6.86831623e-02f, -1.55277789e-01f, 3.23359892e-02f, -4.26751561e-02f, 4.19881335e-03f, -3.82652991e-02f, -4.07327786e-02f, -1.66619327e-02f,
  -2.93832961e-02f, 3.75279188e-02f, -6.90066665e-02f, -1.76719949e-02f, 8.08482096e-02f, 5.89206629e-03f, -4.56643151e-03f, -9.52420607e-02f, -1.66605208e-02f, 1.70002074e-03f,
  -9.94457584e-03f, 8.05565119e-02f, 1.53766319e-01f, 1.40501425e-01f, -2.37558950e-02f, -7.57597014e-02f, 1.27291009e-01f, -1.70571059e-02f, 3.67792547e-02f, -1.50014097e-02f,
  1.73518136e-02f, 4.54494124e-03f, 3.44830342e-02f, -7.52956793e-02f, 1.93825159e-02f, 4.99979183e-02f, -2.17409190e-02f, 6.21886738e-02f, -5.55328391e-02f, 7.73942098e-03f,
  1.43676810e-02f, 2.41980725e-03f, 4.84445952e-02f, -3.54357101e-02f, -1.79807674e-02f, 9.14505310e-03f, 1.18846884e-02f, -1.25446748e-02f, -3.35212029e-03f, 3.13804310e-04f,
  -9.85294059e-02f, 3.52350585e-02f, 6.59919623e-03f, -1.76956709e-02f, 3.38381454e-02f, 1.85021833e-02f, -5.07498048e-02f, -3.42507325e-02f, 5.41438051e-02f, 1.81609541e-02f,
  -6.02479838e-02f, 8.66156369e-02f, -5.00443764e-02f, -1.04930677e-01f, 7.26408735e-02f, -4.02938500e-02f, -2.39392277e-02f, 2.78967172e-02f, 8.78767017e-03f, -4.44823038e-03f,
  4.39010039e-02f, 9.21268295e-03f, -8.57588649e-03f, -1.24309249e-02f, -4.12605219e-02f, 5.83502948e-02f, -5.63341901e-02f, -9.87349078e-02f, 3.21272947e-02f, -9.86941531e-03f,
  3.47674340e-02f, 2.30212919e-02f, -1.52085554e-02f, 1.18386401e-02f, 4.31019291e-02f, -6.09353930e-02f, 6.44814521e-02f, 8.42949077e-02f, 3.10133584e-02f, 2.76962724e-02f,
  3.59996736e-01f, 2.72520240e-02f, -6.99799061e-02f, 2.46021494e-01f, 9.89873856e-02f, -2.17624679e-01f, -1.32801682e-01f, -7.29814768e-02f, 2.24368989e-01f, 1.29282400e-01f,
  -4.79538925e-02f, -6.70187175e-03f, 5.45365596e-03f, 4.45068534e-03f, -7.64870197e-02f, 2.83994861e-02f, 9.96198356e-02f, 3.29636075e-02f, -1.97511122e-01f, -9.58612040e-02f,
  -1.77663211e-02f, 1.73791960e-01f, 2.32528765e-02f, -4.82279211e-02f, 8.77670646e-02f, 9.11609977e-02f, 1.36571825e-01f, 7.22103119e-02f, -2.99012288e-02f, 1.40391678e-01f,
  -7.81412497e-02f, -1.80097446e-01f, 6.19890988e-02f, 2.96999514e-02f, -4.00533155e-02f, 2.48096827e-02f, -4.59909812e-02f, 3.93270934e-03f, 1.35609051e-02f, 1.88017003e-02f,
  4.98752408e-02f, 6.66074306e-02f, 5.48322350e-02f, 1.33267662e-03f, -2.67029461e-02f, -5.28660230e-02f, 4.94124219e-02f, -7.88955912e-02f, 2.20622495e-02f, -1.93208631e-03f,
  5.93093932e-02f, -2.19858158e-02f, -1.28521830e-01f, -1.19597279e-01f, -1.22578792e-01f, 1.66022256e-02f, -1.63334236e-01f, -1.56472921e-01f, -1.01674080e-01f, 1.39652491e-01f,
  -2.45574806e-02f, -3.44484672e-02f, -1.53407513e-03f, -3.58648673e-02f, 4.56566215e-02f, 3.95930037e-02f, -2.02640276e-02f, 3.04645561e-02f, -9.62156057e-02f, 4.44419831e-02f,
  3.53845954e-02f, 1.74866244e-02f, 4.03191410e-02f, -2.98841167e-02f, 6.67576119e-02f, -3.12924497e-02f, 2.28442997e-02f, -5.11206537e-02f, -6.89708535e-03f, 1.03233699e-02f,
  -1.20597389e-02f, -9.59809795e-02f, 6.41182214e-02f, -6.21060096e-02f, -6.52856007e-02f, 1.39972968e-02f, -3.35325394e-03f, -7.34320236e-03f, -3.81193422e-02f, 5.37179112e-02f,
  1.19283140e-01f, -1.64427072e-01f, 1.83671281e-01f, -4.29167338e-02f, 7.67246112e-02f, -2.23981198e-02f, -1.85693558e-02f, 3.80145311e-02f, -8.26680288e-03f, 1.70044694e-02f,
  -3.96751054e-02f, -7.91837201e-02f, -2.48856675e-02f, -4.99561504e-02f, -1.55171426e-02f, 1.32204834e-02f, 4.41004857e-02f, 3.94128822e-02f, -8.60028416e-02f, -4.75125127e-02f,
  1.79504678e-02f, 2.40344834e-02f, 1.30572334e-01f, -8.63385107e-03f, -1.80862308e-03f, 1.17573202e-01f, 2.97975987e-02f, -3.03661916e-02f, -4.20676544e-02f, 1.79273814e-01f,
  -5.61691403e-01f, -1.04878619e-01f, -1.85183108e-01f, -8.40117335e-02f, 7.95838013e-02f, 1.84410602e-01f, 1.54127479e-01f, 1.12053744e-01f, 7.95161203e-02f, -2.65380945e-02f,
  2.08556160e-01f, 1.86271831e-01f, 2.34542359e-02f, 5.81305735e-02f, -6.54945821e-02f, -7.35581592e-02f, -1.46288440e-01f, -1.84500277e-01f, 5.95971197e-02f, 2.13962067e-02f,
  9.49833766e-02f, -1.38622031e-01f, -1.29531369e-01f, -1.26333848e-01f, -8.71210545e-02f, -6.80640712e-02f, -3.48219052e-02f, -9.54435617e-02f, -9.17533785e-02f, -1.95066869e-01f,
  8.76765326e-02f, -2.48427525e-01f, 1.04211859e-01f, 1.17209891e-03f, 8.67677387e-03f, -8.84814747e-03f, -4.57084104e-02f, -1.18126556e-01f, -1.76087096e-02f, -9.72862095e-02f,
  -1.81211438e-02f, -8.28895811e-03f, -5.21145537e-02f, -6.81844577e-02f, -4.08438630e-02f, 4.36632987e-03f, -1.01325244e-01f, -1.88968256e-01f, -1.03035592e-01f, 1.17666893e-01f,
  4.23408747e-02f, -1.21319465e-01f, -1.40116617e-01f, -2.93976497e-02f, -8.60359743e-02f, 3.44981886e-02f, 8.50097649e-03f, -7.68519565e-02f, -9.11037251e-02f, -1.98575318e-01f,
  -1.47402016e-02f, 1.54604120e-02f, -2.01321412e-02f, -9.84524041e-02f, 3.68493944e-02f, 2.81926524e-02f, -6.40495345e-02f, 4.20617051e-02f, 5.07190078e-02f, -6.74401373e-02f,
  -1.36448685e-02f, 7.15758801e-02f, -5.56807034e-02f, -9.62474346e-02f, 4.91965562e-02f, -3.50026488e-02f, -6.76947311e-02f, 7.24274591e-02f, -3.28792781e-02f, -1.00243732e-03f,
  -9.67769232e-03f, -2.72660982e-05f, 5.28416298e-02f, -3.29988971e-02f, -3.24354880e-02f, 1.35085210e-02f, -5.20007871e-03f, 8.76187459e-02f, 9.72784683e-02f, -1.05183497e-02f,
  1.33973479e-01f, 8.45660791e-02f, -1.21734351e-01f, -9.86803547e-02f, -3.69956233e-02f, 4.19477634e-02f, 5.61695807e-02f, -5.07931449e-02f, -8.58207718e-02f, 1.62634607e-02f,
  3.73618156e-02f, 4.56695724e-03f, -3.27740982e-02f, 4.07356620e-02f, 7.32524619e-02f, 3.10484339e-02f, 9.76473019e-02f, -3.60861570e-02f, 1.87643934e-02f, 8.67222697e-02f,
  1.54167026e-01f, 1.73797552e-02f, 8.80884156e-02f, 1.87320393e-02f, 5.32609150e-02f, -3.84535803e-03f, 1.28290847e-01f, 4.96781096e-02f, -3.45153511e-02f, 1.54534006e-03f,
  7.34644160e-02f, -3.81774992e-01f, 5.50317764e-02f, -6.12811819e-02f, -2.55847216e-01f, -3.36570293e-01f, -4.20837253e-01f, -1.75496131e-01f, -7.28286058e-02f, -9.30269286e-02f,
  -7.77526721e-02f, 9.73265618e-02f, 8.19763318e-02f, 2.16886073e-01f, 9.93095115e-02f, -1.90237373e-01f, -7.05026984e-02f, 1.54160053e-01f, 2.94439673e-01f, 8.55602995e-02f,
  2.21110079e-02f, -7.57608050e-03f, 8.54482502e-02f, 1.62633523e-01f, 1.05724439e-01f, 2.47538626e-01f, 6.25236630e-02f, 9.76048633e-02f, 9.64123309e-02f, 1.03188641e-01f,
  3.74699712e-01f, -2.02402741e-01f, 1.78069338e-01f, 5.67219220e-02f, -4.33443189e-02f, 8.73039588e-02f, 1.89314876e-02f, 1.97348073e-02f, -4.32268530e-02f, 1.05594024e-02f,
  -2.34425776e-02f, -1.28959743e-02f, -5.61130047e-02f, 5.15361456e-03f, -4.93461825e-02f, -2.70135868e-02f, 5.66275837e-03f, 4.83295470e-02f, 3.13662142e-02f, -3.35919783e-02f,
  -1.13592081e-01f, -1.46744549e-01f, -7.64065161e-02f, -1.89257115e-01f, -6.25881851e-02f, 1.83406807e-02f, 5.33050261e-02f, 8.14194754e-02f, 1.24688029e-01f, 1.30318984e-01f,
  7.07580671e-02f, 9.74401180e-03f, 5.63137792e-02f, 1.32661331e-02f, 2.12477017e-02f, -4.46159765e-02f, -1.36537310e-02f, 3.88610549e-02f, -3.02243698e-02f, 2.72753648e-02f,
  5.10440059e-02f, -5.47398068e-02f, 9.80508029e-02f, -5.07927090e-02f, 5.31572364e-02f, -1.33646559e-02f, 2.55786721e-02f, 2.66217310e-02f, -3.04061510e-02f, -1.94312837e-02f,
  4.13839854e-02f, 2.06326135e-03f, -7.39409123e-04f, 3.40788104e-02f, -4.42953594e-03f, -4.71307375e-02f, 3.61435302e-02f, 2.65677292e-02f, -5.62724248e-02f, -1.42247258e-02f,
  1.54056653e-01f, -1.01875938e-01f, 6.03734143e-02f, 1.99374612e-02f, 2.16034688e-02f, 1.43917021e-03f, 2.15746909e-02f, 4.28191423e-02f, -8.78505874e-03f, 7.27003254e-03f,
  -5.88733256e-02f, 4.64979336e-02f, -1.04039758e-01f, 2.88605620e-03f, 8.88745636e-02f, -4.95565534e-02f, -1.24749005e-01f, 4.48910929e-02f, 7.30405971e-02f, -4.98171598e-02f,
  -7.07046241e-02f, -1.19647942e-01f, 1.23718418e-02f, 3.74405347e-02f, -1.43904816e-02f, 1.76113829e-01f, 8.81596655e-02f, 5.33427559e-02f, 5.17435819e-02f, 3.91716436e-02f,
  2.99551129e-01f, -2.98165809e-02f, 5.99409603e-02f, -5.99801764e-02f, -3.44483078e-01f, -2.76726007e-01f, -1.65869296e-01f, 1.31237105e-01f, -3.85088399e-02f, -1.23742476e-01f,
  -1.58128709e-01f, -7.42390975e-02f, 3.38768810e-02f, 5.36410287e-02f, 1.90152183e-01f, -7.48479962e-02f, -1.11717589e-01f, 1.71482056e-01f, 2.11359039e-01f, -4.82377745e-02f,
  -2.08782762e-01f, 2.62920558e-02f, 2.44765863e-01f, 1.71499908e-01f, -1.62291765e-01f, -8.85827467e-02f, -1.99756734e-02f, 1.61681592e-03f, -1.00021482e-01f, -2.58328885e-01f,
  -1.01036347e-01f, 7.02842847e-02f, -2.98703089e-02f, -5.16635785e-03f, -5.63301779e-02f, 1.00323193e-01f, 1.38630252e-02f, 8.82226452e-02f, 1.05937801e-01f, 6.58937097e-02f,
  -7.47102126e-02f, -1.02556897e-02f, -1.63929630e-02f, -2.16531288e-02f, 5.85875511e-02f, 6.14927486e-02f, 4.53396030e-02f, 2.23140985e-01f, 7.03288317e-02f, -1.05657138e-01f,
  -2.01619133e-01f, -2.05149367e-01f, -1.27268245e-03f, 1.10292189e-01f, -2.12197397e-02f, -2.78236978e-02f, 2.46761795e-02f, 5.36788739e-02f, 6.14583082e-02f, 1.11196917e-02f,
  -4.89702821e-02f, -4.23188694e-02f, 2.27925810e-03f, -1.70569438e-02f, 1.21902805e-02f, -1.11545697e-02f, -5.45132756e-02f, -1.58802867e-02f, -1.31235523e-02f, 4.19741347e-02f,
  -3.24219279e-02f, -2.43512746e-02f, 7.42319524e-02f, -1.21201891e-02f, -1.38758542e-02f, -4.94220890e-02f, 2.25128941e-02f, -1.13393357e-02f, 2.54735649e-02f, 3.52811138e-03f,
  -3.77825499e-02f, -4.36259881e-02f, -5.62851876e-03f, -7.60522485e-03f, -6.78935349e-02f, 2.07861345e-02f, -2.02522543e-03f, -3.39582656e-03f, -8.27455241e-03f, 1.45548927e-02f,
  1.58962995e-01f, 1.11125030e-01f, -5.28821200e-02f, 8.54225159e-02f, -1.32688224e-01f, 6.18600547e-02f, -5.43305650e-02f, 7.14926096e-03f, -8.56089815e-02f, -7.02914596e-02f,
  1.64517108e-02f, 1.32675871e-01f, -3.90175320e-02f, 1.33886617e-02f, -7.21051320e-02f, 1.72661443e-03f, -9.66651887e-02f, -9.60588828e-02f, 3.05294618e-02f, -5.01028709e-02f,
  -7.83242285e-02f, -3.23164579e-03f, -4.63263839e-02f, 7.16719702e-02f, 3.41366641e-02f, 6.25038967e-02f, 6.87808767e-02f, -4.72974265e-03f, 6.89529767e-03f, 5.68118244e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.94065695e-02f, -1.56927422e-01f, 1.01960070e-01f, 2.49177441e-01f, 1.87613949e-01f, 2.15426788e-01f, 1.96167856e-01f, 1.03281960e-01f, 1.87279195e-01f, 3.07857562e-02f,
  -3.45881246e-02f, -8.89128074e-02f, -3.28182094e-02f, -7.38094896e-02f, -5.43113723e-02f, 1.85366422e-01f, 2.37737849e-01f, 7.23371655e-02f, 1.13205016e-01f, 1.08247228e-01f,
  5.97681999e-02f, 7.29567409e-02f, -6.24255836e-02f, 2.42615845e-02f, 6.90042302e-02f, 8.65254030e-02f, 3.29826842e-03f, -6.54991791e-02f, 2.45941691e-02f, 5.41202575e-02f,
  -1.18341185e-01f, -1.47735834e-01f, 1.06805332e-01f, -4.54510339e-02f, -1.12798937e-01f, 5.34038013e-03f, 1.48539655e-02f, -1.24500051e-01f, -6.52890503e-02f, -1.32276071e-02f,
  -9.02451575e-02f, -3.16595808e-02f, 1.45534612e-02f, -7.03314766e-02f, 6.00502454e-02f, -5.65034822e-02f, -1.42518044e-01f, 1.74570084e-03f, -2.76312884e-02f, -6.07424565e-02f,
  4.10418473e-02f, 5.75026534e-02f, -4.94350120e-02f, 1.59490295e-02f, -7.34449551e-02f, 5.63151352e-02f, 3.04091237e-02f, 4.74444628e-02f, -6.64185062e-02f, -7.25447387e-02f,
  -2.63941865e-02f, 1.37582505e-02f, 5.94290197e-02f, 8.87523498e-03f, 9.41523686e-02f, -1.13351448e-02f, 2.75194012e-02f, 7.40414560e-02f, 4.60705422e-02f, 8.79272819e-02f,
  -2.95342337e-02f, 4.04288732e-02f, -2.63145212e-02f, -2.20047892e-03f, 8.59243572e-02f, 2.08691582e-02f, 4.94261505e-03f, -5.74746653e-02f, -1.90686472e-02f, 1.71932522e-02f,
  -1.00669703e-02f, 6.76948130e-02f, 4.48790602e-02f, 3.93053666e-02f, -3.44152264e-02f, 4.84797768e-02f, -2.57919598e-02f, -2.91915890e-02f, -7.31048584e-02f, 2.50090472e-02f,
  -8.57542530e-02f, -5.39097153e-02f, 1.64573621e-02f, -4.29130457e-02f, 3.20632244e-03f, -1.31331310e-02f, 7.13078817e-03f, -2.83441767e-02f, -4.00919914e-02f, 3.42892036e-02f,
  -9.83573124e-02f, -9.09922719e-02f, -6.13649515e-03f, -5.11294454e-02f, 6.72936961e-02f, 1.67235453e-02f, -3.70826013e-02f, 3.60851809e-02f, 3.18220295e-02f, -1.13106668e-02f,
  -1.32034272e-02f, 3.22921462e-02f, 1.00614451e-01f, 2.54550613e-02f, -2.82178656e-03f, 1.17328040e-01f, -5.12154885e-02f, 7.25002140e-02f, 9.45927352e-02f, 1.20842621e-01f,
  -2.32117459e-01f, -1.95464373e-01f, -3.61930013e-01f, -2.23429248e-01f, -2.26872340e-01f, -8.05667266e-02f, 3.79754007e-02f, 3.98867764e-02f, -3.76241729e-02f, -2.23591372e-01f,
  -8.87283236e-02f, -1.22131750e-01f, -2.10936904e-01f, -6.77771792e-02f, -3.70653868e-02f, -2.42297933e-01f, -3.20422202e-01f, -2.79141128e-01f, 2.31729653e-02f, 3.34988572e-02f,
  -7.34358386e-04f, -1.01769581e-01f, -1.64630845e-01f, -1.66506216e-01f, -2.53170013e-01f, -2.66430110e-01f, -3.39557648e-01f, -2.62923419e-01f, -2.45246053e-01f, -3.26725215e-01f,
  -3.55581224e-01f, -2.71029845e-02f, 7.99235776e-02f, 6.05720840e-02f, -9.98163521e-02f, 8.24595019e-02f, -6.92646652e-02f, 8.05625692e-03f, 2.41056569e-02f, 1.90458000e-02f,
  -8.19483921e-02f, 3.39907631e-02f, -3.73588316e-02f, 1.47059234e-02f, -6.14309043e-04f, 8.29588808e-03f, 7.33891129e-02f, 3.06014568e-02f, -5.56491427e-02f, 1.37987867e-01f,
  -3.45674492e-02f, -5.56073561e-02f, -1.65760651e-01f, 3.54930200e-02f, 3.06164790e-02f, 2.37213019e-02f, 1.34327188e-02f, -2.99704205e-02f, -1.91417951e-02f, -3.28917578e-02f,
  5.45348823e-02f, -1.80262495e-02f, -3.02934065e-03f, 1.96815878e-02f, 1.68497860e-02f, -1.77951772e-02f, -4.43065241e-02f, -7.55442353e-03f, -2.17065215e-03f, 4.62997854e-02f,
  -3.26007754e-02f, -6.79638460e-02f, 5.49992062e-02f, -8.74768198e-02f, -2.05966216e-02f, 2.58222297e-02f, -2.58138850e-02f, 1.06899373e-01f, -5.40989749e-02f, 3.38240005e-02f,
  -4.59371097e-02f, 3.46143320e-02f, -7.31692314e-02f, -4.16835733e-02f, 3.04797734e-03f, -5.65258600e-02f, -1.85117573e-02f, 2.78029963e-02f, 1.04210213e-01f, -3.36275771e-02f,
  -1.30803138e-01f, -7.76451752e-02f, 1.92976894e-03f, 3.89157310e-02f, -1.12297371e-01f, 4.16671038e-02f, -8.34614113e-02f, 7.78233185e-02f, -6.79845735e-02f, 2.59129554e-02f,
  4.82323542e-02f, 5.19883819e-02f, -7.25706890e-02f, 2.96014547e-03f, -5.92080206e-02f, 7.16854911e-03f, 7.02477843e-02f, -3.13033424e-02f, -5.09572253e-02f, -2.55664275e-03f,
  5.12213707e-02f, -5.34402914e-02f, 1.78581942e-02f, -1.03795581e-01f, 4.12759520e-02f, -1.46330535e-01f, -5.47870211e-02f, -7.45847747e-02f, -3.24074477e-02f, -1.79820079e-02f,
  -3.45853239e-01f, -7.21620442e-03f, -6.25926629e-02f, -7.59308785e-02f, 3.74064557e-02f, 1.26336679e-01f, 2.19864979e-01f, 5.02987728e-02f, -5.47568202e-02f, 1.23857401e-01f,
  5.51344864e-02f, 2.00086936e-01f, 2.28055477e-01f, 1.52124569e-01f, 1.12194300e-01f, 9.87373590e-02f, 2.79471446e-02f, 6.44977763e-02f, -7.00922012e-02f, -8.48482326e-02f,
  8.15617666e-02f, -8.54210183e-02f, -1.33254781e-01f, -1.46877408e-01f, -4.80962321e-02f, 7.56051987e-02f, 6.40650019e-02f, -3.55564989e-02f, 6.87129125e-02f, 1.43203966e-03f,
  2.98631340e-01f, -2.12998405e-01f, 9.90458131e-02f, -1.19148649e-01f, -6.45989180e-02f, -4.27514203e-02f, -2.41500568e-02f, -5.81210814e-02f, -6.86534941e-02f, -6.24057986e-02f,
  -5.67280911e-02f, -1.61185954e-03f, -4.07793187e-02f, -2.42843181e-02f, -1.87432133e-02f, -6.30547467e-04f, -1.97279491e-02f, -4.18950655e-02f, -3.80854122e-02f, 1.60844792e-02f,
  -3.94059047e-02f, -1.45084187e-01f, 7.74503201e-02f, 7.30022341e-02f, -3.12553383e-02f, -2.83951890e-02f, 9.39055085e-02f, -4.12628707e-03f, 5.38069457e-02f, 2.52169333e-02f,
  -4.17803321e-03f, 3.32026444e-02f, 1.22733926e-02f, 2.61581279e-02f, -3.12545337e-02f, -4.60339151e-02f, -9.80140269e-03f, 1.08084582e-01f, -3.17271464e-02f, 5.31518161e-02f,
  3.24659646e-02f, -2.00021137e-02f, 3.47485356e-02f, -3.53252254e-02f, 4.13331836e-02f, -4.88526821e-02f, -3.49245779e-02f, 3.02903783e-02f, -3.41859907e-02f, 2.75021289e-02f,
  -4.76928875e-02f, -5.11649400e-02f, -3.44495550e-02f, -2.30372753e-02f, -7.47155771e-02f, -5.05207554e-02f, 3.75354476e-02f, 1.49063794e-02f, -7.23666251e-02f, -9.44476500e-02f,
  1.69209912e-01f, -2.04510745e-02f, -1.57195032e-02f, -2.96634044e-02f, -4.02873801e-03f, -8.69023278e-02f, -2.63325479e-02f, -5.02666719e-02f, -3.73658165e-02f, 2.58649327e-02f,
  2.16477178e-02f, -3.13645676e-02f, 8.93679708e-02f, -1.11689366e-01f, -4.85677160e-02f, -1.09042674e-01f, 2.42519695e-02f, -1.19502610e-03f, -2.11994518e-02f, -3.54933403e-02f,
  4.51309420e-02f, 7.34670758e-02f, 1.24450311e-01f, 4.44699153e-02f, 1.47507852e-02f, -4.67664301e-02f, 1.62425876e-01f, 2.85170530e-03f, 1.19149387e-01f, -2.76007317e-02f,
  -5.05293980e-02f, 1.83890522e-01f, -7.79183730e-02f, 1.10755563e-01f, -1.76243499e-01f, -3.64211559e-01f, -1.75062045e-01f, -1.68444708e-01f, -8.63476023e-02f, 4.17369679e-02f,
  -3.36839855e-02f, -1.51201356e-02f, -4.33483422e-02f, -8.15626830e-02f, -2.12865263e-01f, -2.71714311e-02f, -1.72617510e-01f, -1.85062289e-01f, -4.79928076e-01f, -3.45894188e-01f,
  -2.15527579e-01f, -1.30907536e-01f, -2.45544925e-01f, -1.76051736e-01f, 1.50648832e-01f, 5.37051372e-02f, 6.05648160e-02f, -1.05237029e-01f, -6.91915974e-02f, 3.70043814e-02f,
  9.03006941e-02f, 8.69169738e-03f, -1.60558850e-01f, -7.85966031e-03f, 2.11409220e-04f, -1.73345301e-02f, 7.63388202e-02f, 7.76170939e-02f, 8.97492021e-02f, -1.20136486e-02f,
  -1.48982089e-02f, -1.06843270e-01f, 6.36561662e-02f, -8.58094841e-02f, -6.74959645e-02f, -4.34075333e-02f, 4.56341403e-03f, -1.12776428e-01f, -3.56500689e-03f, 8.69985819e-02f,
  -5.31852953e-02f, -3.02435234e-02f, -9.56290364e-02f, 9.11889076e-02f, -8.45737681e-02f, -4.07362841e-02f, -5.50763570e-02f, 5.19858720e-03f, -1.45838400e-02f, 2.03741685e-01f,
  9.51314997e-03f, 8.20232928e-02f, -4.36738767e-02f, -1.99774802e-02f, 1.57643966e-02f, 1.08982660e-01f, -6.03178777e-02f, 1.54473372e-02f, -7.58430138e-02f, 5.12149371e-02f,
  -5.68259973e-03f, 1.10296812e-02f, 4.61723506e-02f, 4.19292301e-02f, 8.23941231e-02f, -3.26883458e-02f, -3.78797315e-02f, 5.47904298e-02f, 2.31199097e-02f, 9.43770725e-03f,
  -1.46024330e-02f, -5.96625693e-02f, 6.58424944e-03f, 4.31931764e-02f, -4.08500433e-02f, -4.57907934e-03f, -7.05242157e-02f, -5.82781360e-02f, -5.54736331e-02f, 4.63156179e-02f,
  3.57048482e-01f, -2.28356436e-01f, 2.15087473e-01f, 5.30833099e-03f, -3.18885446e-02f, 3.63532361e-03f, 9.36634466e-02f, 1.26729589e-02f, 3.77843268e-02f, 4.31845263e-02f,
  -9.12501365e-02f, 6.68704733e-02f, 6.90034106e-02f, 1.73256174e-02f, -1.37198761e-01f, -1.24871247e-01f, -1.69096496e-02f, 6.59913719e-02f, -3.58929485e-02f, 1.11134395e-01f,
  1.09292008e-01f, -9.41949114e-02f, 8.29104185e-02f, 6.15667254e-02f, 6.19895756e-02f, 3.14482190e-02f, 2.01498978e-02f, 9.12174061e-02f, 2.92191096e-02f, 1.98222533e-01f,
  -4.85871553e-01f, -1.38542801e-01f, -1.73399244e-02f, -2.31478959e-01f, -1.20393783e-01f, -4.89061736e-02f, -8.36819261e-02f, -7.87231028e-02f, -7.50007406e-02f, -1.35259464e-01f,
  -8.72285478e-03f, -7.25479871e-02f, -1.40018672e-01f, -3.91132012e-02f, 6.67828470e-02f, -2.66409032e-02f, -5.55054620e-02f, 9.17939916e-02f, 1.17603391e-01f, 1.14245057e-01f,
  -5.13466820e-02f, -1.12388454e-01f, -7.95927718e-02f, -4.00790386e-03f, -3.84487864e-03f, -1.61093473e-01f, 2.05692630e-02f, 2.13234033e-02f, 7.32077844e-03f, -1.69559419e-01f,
  -3.65145952e-02f, -2.85133608e-02f, 4.75619882e-02f, -2.09452268e-02f, 1.06766187e-02f, -4.74347658e-02f, -6.31389692e-02f, 8.28233138e-02f, 6.01432286e-02f, -8.32398236e-02f,
  -1.14712175e-02f, -7.80178681e-02f, -6.55407310e-02f, -2.55043749e-02f, -3.98436598e-02f, 1.59681379e-03f, 8.15626234e-02f, -4.42626961e-02f, 9.62113142e-02f, 6.29963949e-02f,
  -2.24147737e-02f, -1.90241918e-01f, -1.92416143e-02f, 2.64668353e-02f, 7.62334168e-02f, -1.26542851e-01f, -1.01076506e-01f, 1.40636945e-02f, -3.86301354e-02f, -2.14666158e-01f,
  6.57786578e-02f, -5.19509800e-02f, 6.93491474e-02f, 1.43585773e-02f, -3.02782115e-02f, -5.16453013e-02f, -8.68771283e-04f, -2.13925019e-02f, 5.52592166e-02f, 6.26630150e-03f,
  -2.79135946e-02f, -1.41760977e-02f, -1.04534887e-02f, 1.85172688e-02f, -5.87708130e-02f, 2.82386523e-02f, -4.26710434e-02f, 6.39034212e-02f, -4.80406657e-02f, 3.28475647e-02f,
  -3.08880042e-02f, -3.58244292e-02f, 1.76075939e-02f, -5.59946615e-03f, 8.22669342e-02f, -2.34642588e-02f, 3.24035250e-03f, -3.44182402e-02f, -2.60771774e-02f, 6.70781313e-03f,
  -2.03082219e-01f, 1.92467406e-01f, -3.99698243e-02f, 8.69391486e-03f, 9.75316763e-03f, -5.17681688e-02f, -1.06101580e-01f, -1.07177440e-02f, 5.14865736e-04f, -7.66990930e-02f,
  2.98011061e-02f, 1.24794878e-02f, -1.41129181e-01f, -6.65985867e-02f, 2.64747683e-02f, -4.44400311e-02f, -4.14767191e-02f, -1.09465525e-01f, -4.23375368e-02f, 5.32599315e-02f,
  -3.83930504e-02f, -1.67147785e-01f, -1.88425601e-01f, -1.60231784e-01f, -3.82655412e-02f, -1.70451835e-01f, -5.42692915e-02f, -1.23554133e-01f, -1.19315460e-01f, -2.37091720e-01f,
  1.98510066e-02f, 1.35654025e-03f, -1.39890730e-01f, 1.43652767e-01f, 5.04022986e-02f, -1.23367995e-01f, -1.90699741e-01f, -1.54928431e-01f, 3.66996601e-02f, 7.12893233e-02f,
  -2.91772390e-04f, 1.06959723e-01f, -7.53152072e-02f, 5.49448393e-02f, 3.15904208e-02f, 1.84389553e-03f, 8.27548876e-02f, -2.03573182e-02f, -3.64430025e-02f, 8.53543952e-02f,
  1.93433344e-01f, 1.66681409e-01f, 1.34528175e-01f, 6.09182604e-02f, 1.23540342e-01f, 1.67036265e-01f, 7.06749856e-02f, 1.54132843e-01f, 8.90955105e-02f, 2.64939904e-01f,
  -3.19993100e-03f, -2.79945433e-02f, -1.40900016e-01f, 3.15522552e-02f, -4.46429923e-02f, -1.02352314e-01f, -7.54652638e-03f, -8.66729617e-02f, 3.38150784e-02f, -7.34805390e-02f,
  6.30893037e-02f, 2.65449826e-02f, 5.93748204e-02f, 4.55831252e-02f, -1.23096223e-03f, -4.17246148e-02f, 1.25103910e-02f, -1.02848858e-01f, -8.44057947e-02f, -6.42057657e-02f,
  3.14550698e-02f, -3.61759961e-02f, -8.85256380e-03f, -5.62058911e-02f, -1.76007897e-02f, -1.35089075e-02f, -3.35250683e-02f, -2.45030802e-02f, -6.06118254e-02f, -2.15744432e-02f,
  6.57420754e-02f, -4.20230515e-02f, -4.33935132e-03f, -4.85823900e-02f, -2.26517767e-02f, 1.82773843e-02f, 8.89490172e-02f, -2.47601848e-02f, -2.46963985e-02f, -3.35098058e-02f,
  -7.89586008e-02f, 5.02154827e-02f, -4.60067540e-02f, -2.34780814e-02f, 7.51138255e-02f, -1.20649971e-02f, 2.12562624e-02f, 7.14508966e-02f, -7.71864504e-02f, -3.09709571e-02f,
  -1.13450075e-02f, 4.03838269e-02f, -8.37829560e-02f, 1.20412633e-02f, -1.30891372e-02f, 7.73557574e-02f, 3.37582864e-02f, -3.70686799e-02f, 3.74981575e-02f, -6.06378447e-03f,
  -7.42229670e-02f, -2.68822849e-01f, 5.21127097e-02f, -4.32169959e-02f, 2.26191599e-02f, -2.12835651e-02f, -1.15825040e-02f, 1.86912343e-02f, -2.13661287e-02f, 4.84712273e-02f,
  -8.46980736e-02f, -3.22224088e-02f, -7.82960653e-02f, -7.78343379e-02f, 3.02561112e-02f, -3.78532410e-02f, 9.82280169e-03f, -1.30660469e-02f, 9.03013069e-03f, -7.21134767e-02f,
  -1.30836284e-02f, 9.58725624e-03f, -1.65502384e-01f, -7.19089508e-02f, -1.14567593e-01f, -1.38679191e-01f, -1.31061345e-01f, -2.82950979e-02f, -2.65361577e-01f, -2.16457471e-01f,
  1.81333348e-01f, 2.07328245e-01f, -1.23281538e-01f, 5.52700460e-02f, 4.36658859e-02f, 3.65146585e-02f, 2.51270235e-01f, 1.65968284e-01f, 1.61327407e-01f, 1.53354034e-01f,
  3.99829634e-02f, -2.20732927e-01f, -7.71507770e-02f, -1.90258309e-01f, -1.30662411e-01f, 1.22351684e-01f, -3.40142809e-02f, -1.70338169e-01f, -2.73098707e-01f, -2.03798097e-02f,
  7.72815123e-02f, 1.80783749e-01f, 1.19947344e-01f, 4.82036918e-02f, -3.04594059e-02f, -1.05121374e-01f, 2.67893802e-02f, -3.34206410e-02f, -2.65136752e-02f, -2.63476633e-02f,
  -3.09848309e-01f, -7.53338188e-02f, -1.02064401e-01f, 4.95281555e-02f, 6.19390346e-02f, 4.98892292e-02f, -2.57274471e-02f, 8.31536129e-02f, 1.27744749e-01f, 2.28769630e-02f,
  -6.12970963e-02f, 3.27458233e-02f, -9.10922363e-02f, -1.39021287e-02f, 2.72017010e-02f, -5.01138382e-02f, 4.37730253e-02f, -7.88641423e-02f, -1.42297357e-01f, -7.75164738e-02f,
  7.20656887e-02f, -7.32049197e-02f, -3.69668826e-02f, -2.83369664e-02f, -5.44933230e-02f, -6.17006496e-02f, -1.38746873e-01f, -6.26520365e-02f, -2.24222057e-02f, 6.83302954e-02f,
  6.00542547e-03f, -6.23085201e-02f, -8.01374391e-03f, 4.72426899e-02f, -1.78889334e-02f, -4.28651879e-03f, -2.61467528e-02f, -8.14973935e-02f, 6.64454792e-03f, 9.02771056e-02f,
  2.91480143e-02f, -2.70690490e-02f, 2.55663283e-02f, 2.36109979e-02f, -6.37096018e-02f, -9.97436643e-02f, 8.50300398e-03f, 6.54355064e-02f, 8.45536683e-03f, 1.37124816e-02f,
  -6.73235729e-02f, -1.17517402e-02f, 3.90079096e-02f, 2.06817221e-02f, -1.37422150e-02f, 2.46381643e-03f, 2.77110133e-02f, -5.96647635e-02f, -3.56501639e-02f, 3.38283740e-02f,
  1.72393695e-01f, -1.54984638e-01f, -2.45110262e-02f, -7.97270238e-02f, -8.88702050e-02f, 2.25652307e-02f, -2.84269881e-02f, 6.47753850e-02f, -2.57673431e-02f, -5.70240691e-02f,
  -8.20481554e-02f, -1.00255303e-01f, 1.83874033e-02f, 1.94944590e-02f, 6.42693462e-03f, -1.45090520e-02f, 9.36493278e-02f, 1.73016936e-02f, 1.35307489e-02f, 9.44158882e-02f,
  1.01406500e-01f, 8.56779963e-02f, 6.81822076e-02f, 8.28658193e-02f, 5.31250937e-03f, -4.76295725e-02f, 5.50845005e-02f, -3.46116312e-02f, 2.93836445e-02f, 3.91929567e-01f,
  -1.17314979e-02f, 6.06019273e-02f, 2.57438570e-02f, 1.69659406e-01f, 7.32041150e-02f, -1.91871762e-01f, -1.17747277e-01f, -4.81532328e-02f, 3.86578776e-02f, -1.80904344e-02f,
  6.34286553e-02f, 1.29216179e-01f, 1.34534031e-01f, -2.80243512e-02f, -5.21525331e-02f, -7.56542906e-02f, 5.34528792e-02f, 8.38025659e-03f, -6.31940961e-02f, -9.34312046e-02f,
  3.26636508e-02f, -1.51645169e-02f, -2.42237076e-02f, 7.76353404e-02f, 1.86070818e-02f, -7.96234608e-03f, 9.94098037e-02f, 1.19086159e-02f, 5.70150763e-02f, -1.01040090e-02f,
  -5.02673574e-02f, 9.77091864e-03f, -9.93354842e-02f, 2.00196411e-02f, 3.82426493e-02f, -9.47428793e-02f, 1.42971128e-02f, -3.56478170e-02f, 1.48882810e-03f, -3.05015668e-02f,
  -5.45971096e-02f, -9.09305811e-02f, -4.40968685e-02f, -7.07602724e-02f, -1.02717333e-01f, -1.24954581e-01f, -5.64190783e-02f, -6.13820888e-02f, -2.15247143e-02f, -4.97559970e-03f,
  -6.72999844e-02f, 6.45020679e-02f, -1.28220180e-02f, -8.87601599e-02f, -1.00535013e-01f, 5.52069061e-02f, -5.72763123e-02f, -1.83309242e-03f, -9.63897333e-02f, -1.11779429e-01f,
  -8.49912176e-04f, -1.71340164e-02f, -5.26499934e-02f, 3.16661708e-02f, 4.25637290e-02f, 5.01912162e-02f, 3.88221741e-02f, -6.14508614e-03f, 5.37209846e-02f, -1.69037357e-02f,
  -4.76559158e-03f, -6.75684884e-02f, 3.33347335e-03f, 7.66736716e-02f, -6.05506189e-02f, -3.22994136e-04f, -1.49643151e-02f, -6.10978948e-03f, -8.41489956e-02f, -8.98075383e-03f,
  3.64906043e-02f, 3.95944118e-02f, 8.50354787e-03f, -5.10592312e-02f, 2.82235034e-02f, -5.43587171e-02f, 3.32475267e-02f, -3.67044434e-02f, 2.20541358e-02f, 3.60828824e-02f,
  1.75331339e-01f, -2.35848222e-03f, -5.15867621e-02f, 9.96473711e-03f, 5.72895594e-02f, 2.81566400e-02f, 3.10986694e-02f, 7.32797161e-02f, -5.04545718e-02f, 2.19753478e-03f,
  -8.07342008e-02f, 5.37894375e-04f, -1.39110852e-02f, -1.02777250e-01f, -5.45116402e-02f, -1.57806277e-02f, 8.05304721e-02f, 5.38289584e-02f, -6.75965846e-02f, -6.84398413e-02f,
  -5.49100041e-02f, -2.30363347e-02f, 3.92467938e-02f, -3.50355878e-02f, 3.60745601e-02f, -2.19747666e-02f, -4.05470207e-02f, -5.76914027e-02f, -1.32782161e-01f, 2.44717263e-02f,
  1.78591430e-01f, 6.36580810e-02f, -6.21142015e-02f, 2.20479220e-01f, 1.38145640e-01f, 1.59150347e-01f, 2.52881467e-01f, 1.95191741e-01f, 1.67122200e-01f, 2.35576689e-01f,
  3.06550503e-01f, 2.91738957e-01f, 3.13138545e-01f, 1.76700801e-01f, 8.62922966e-02f, 1.12731077e-01f, -3.36766355e-02f, 5.57418577e-02f, 8.73547867e-02f, 3.13556492e-02f,
  9.15558115e-02f, -5.65550812e-02f, 3.05122212e-02f, 4.89416346e-02f, 1.11446753e-01f, 5.11817709e-02f, -4.73425388e-02f, 1.19346734e-02f, 6.21371530e-02f, 6.50590286e-03f,
  -5.76721095e-02f, 3.74034345e-02f, -2.12099142e-02f, 4.23207972e-03f, 5.30703887e-02f, -4.69362922e-02f, -7.24797696e-02f, -4.50147539e-02f, 3.91803756e-02f, -1.43571064e-01f,
  -8.22201371e-03f, 1.77235194e-02f, -2.40237527e-02f, -6.56372309e-02f, -5.46485512e-03f, 3.50601487e-02f, -7.20547698e-03f, 1.46053708e-03f, 6.46669045e-02f, 4.99700978e-02f,
  4.24141586e-02f, -7.27816299e-02f, -6.59586070e-03f, 3.05072609e-02f, 9.01934505e-03f, -2.77315360e-02f, 2.97814552e-02f, -8.22679624e-02f, 7.63838971e-03f, -1.05379537e-01f,
  9.60790962e-02f, -1.64730214e-02f, 7.59982392e-02f, 9.18493606e-03f, 5.67764267e-02f, -4.04614769e-02f, -4.05458994e-02f, 1.18713276e-02f, 5.22182249e-02f, 4.27494012e-02f,
  -3.83499227e-02f, 4.42456976e-02f, 4.46998291e-02f, 6.19485304e-02f, -5.83131872e-02f, 1.33811776e-02f, 3.77725996e-02f, -2.76032351e-02f, 4.12997343e-02f, 2.43569911e-03f,
  -3.77182811e-02f, 1.11308051e-02f, -6.09081611e-02f, 7.14042187e-02f, 1.92603394e-02f, 2.50619072e-02f, -9.52263325e-02f, -2.74757110e-02f, -1.68019980e-02f, -1.36988498e-02f,
  9.02531086e-04f, 1.46858081e-01f, 1.10192792e-02f, -3.09836678e-02f, -1.10561550e-02f, -7.31952935e-02f, 6.62968084e-02f, -7.83689991e-02f, -7.49832168e-02f, -4.47288640e-02f,
  -9.91160050e-02f, -4.38242368e-02f, -1.45470006e-02f, -1.05416872e-01f, -1.73536967e-02f, -9.40183327e-02f, -4.34815250e-02f, 6.05708621e-02f, 1.19402688e-02f, -1.47926033e-01f,
  -1.02276690e-02f, 3.39902863e-02f, -1.41055435e-02f, -1.41769508e-02f, 1.54391788e-02f, 1.12646654e-01f, -5.34771569e-02f, -2.29537860e-02f, -5.31136617e-02f, 7.81162456e-03f,
  2.42356524e-01f, -2.18125898e-02f, 6.59459177e-03f, 1.34966180e-01f, 1.37412593e-01f, 1.30168453e-01f, 7.74648637e-02f, 1.26994178e-01f, 2.37024501e-01f, 1.23691365e-01f,
  -3.63606848e-02f, 8.27157050e-02f, 6.85381517e-02f, 8.60311463e-02f, 2.07201149e-02f, 1.21916823e-01f, 7.77522549e-02f, 9.30978283e-02f, 7.76592642e-02f, 5.77264391e-02f,
  6.46980619e-03f, 8.62705559e-02f, -8.74370933e-02f, 5.95827103e-02f, -6.45355210e-02f, 1.20186947e-01f, -3.23493145e-02f, 9.48469713e-03f, -1.22796863e-01f, -4.18687426e-02f,
  -2.76644975e-01f, -1.68229833e-01f, 1.78089663e-01f, -4.73474562e-02f, -1.60322711e-01f, -8.97303596e-02f, -5.14290482e-02f, -9.64693949e-02f, -5.50336540e-02f, -5.87156825e-02f,
  -5.92549853e-02f, -1.11016091e-02f, -1.98169965e-02f, -6.11715689e-02f, 4.42669801e-02f, 3.21602151e-02f, -1.04123369e-01f, 7.77026312e-03f, -5.27834408e-02f, -2.76798885e-02f,
  -7.76961297e-02f, -6.99177980e-02f, -7.67717510e-02f, 7.31126592e-02f, -6.16740696e-02f, 3.31161506e-02f, 1.86033137e-02f, -5.19053191e-02f, 8.25005770e-02f, 7.90739655e-02f,
  -1.82693359e-02f, -6.32481351e-02f, 1.67881418e-02f, -5.73118627e-02f, 8.91604796e-02f, 1.32919783e-02f, 9.64695886e-02f, -5.26636206e-02f, -7.89895467e-03f, 3.85679863e-02f,
  -3.29826586e-02f, 5.13668507e-02f, -4.20492627e-02f, -2.86162328e-02f, -2.16448288e-02f, -4.02349159e-02f, -2.82409135e-02f, 2.82733478e-02f, 1.95169705e-03f, -9.20777172e-02f,
  1.76766589e-02f, -6.88775256e-02f, -5.14647253e-02f, -9.95623916e-02f, 3.77836972e-02f, 9.40610655e-03f, -2.04468728e-03f, -2.33555324e-02f, 8.64854306e-02f, -4.47090343e-03f,
  7.36254975e-02f, -8.09827223e-02f, 8.38168263e-02f, 9.70817655e-02f, -8.74040127e-02f, 2.71450286e-03f, 1.53505290e-02f, -8.20167661e-02f, -9.15171355e-02f, 5.24915941e-02f,
  -7.38459155e-02f, -1.16653569e-01f, -3.31799649e-02f, -3.56392488e-02f, 3.41093875e-02f, 7.59882256e-02f, -3.01896259e-02f, -2.22853329e-02f, -5.69164380e-02f, -7.83477575e-02f,
  -2.81896088e-02f, 2.17900693e-01f, 1.62420735e-01f, 9.76774320e-02f, 1.61762815e-02f, 1.02227889e-01f, -4.05761749e-02f, 5.98286241e-02f, 1.39815271e-01f, 1.13201126e-01f,
  2.94204384e-01f, 2.27217767e-02f, -8.09543952e-02f, -5.61127178e-02f, -2.47005835e-01f, -2.59148657e-01f, -2.37314507e-01f, -1.06632583e-01f, 2.47194897e-02f, -7.85254464e-02f,
  -1.33997396e-01f, -8.35180506e-02f, 5.30370884e-02f, 6.47413507e-02f, 1.02427989e-01f, -3.65414880e-02f, -6.50797859e-02f, 9.55060422e-02f, -6.98108785e-03f, -1.33952707e-01f,
  3.21196690e-02f, 2.16758158e-02f, 1.49834320e-01f, 8.84344205e-02f, -3.65943350e-02f, -8.81685019e-02f, 3.41156721e-02f, -9.36345682e-02f, 2.11631693e-02f, -3.22333723e-02f,
  -1.86451599e-01f, -2.59912033e-02f, -3.84687632e-02f, 1.20972261e-01f, -1.27891660e-01f, 7.29460455e-03f, -9.32835340e-02f, -2.33758111e-02f, 1.01829059e-02f, -6.78832904e-02f,
  -1.30158424e-01f, -6.86676353e-02f, 3.07529084e-02f, -1.90752547e-03f, -3.31808627e-02f, -1.34970704e-02f, 6.99654920e-03f, -2.83573028e-02f, -2.61115357e-02f, -1.01445869e-01f,
  -2.66622603e-02f, -1.18090082e-02f, 2.40633544e-02f, 1.29002165e-02f, -1.51670780e-02f, -3.95438746e-02f, -3.60517018e-02f, -1.27836689e-02f, -6.66840151e-02f, 7.34400153e-02f,
  -1.38027696e-02f, 2.20513809e-02f, 3.10328826e-02f, 4.60462049e-02f, 2.52745003e-02f, -5.85389361e-02f, -6.44223318e-02f, 4.30552810e-02f, -1.10297007e-02f, 1.08016962e-02f,
  1.24091106e-02f, -4.29507392e-03f, -4.91174832e-02f, 2.30760425e-02f, -5.53611154e-03f, 5.51377535e-02f, -2.13000793e-02f, 6.96686059e-02f, -3.98282968e-02f, -1.09555703e-02f,
  5.67289963e-02f, -3.81253362e-02f, -1.49876261e-02f, 8.25763717e-02f, -5.76530620e-02f, 7.61210471e-02f, -4.32948023e-02f, -4.74785715e-02f, 8.03919807e-02f, -1.39077147e-02f,
  1.67523548e-02f, 4.51767351e-03f, -6.00935221e-02f, 8.40617642e-02f, -5.19089811e-02f, 1.59894489e-02f, -5.33181503e-02f, 4.69426252e-02f, 2.98259519e-02f, -1.04135551e-01f,
  -2.40506381e-02f, 6.53055683e-02f, -2.50030551e-02f, -4.53052968e-02f, 1.82771683e-02f, -6.31074384e-02f, 7.72949755e-02f, -3.00780591e-02f, -3.33483703e-02f, -9.34032872e-02f,
  -5.46901720e-03f, 1.15597788e-02f, 1.04532689e-01f, -5.65913655e-02f, -1.08466737e-01f, -1.42632611e-02f, 2.41306657e-03f, 2.40096673e-02f, 2.83361878e-02f, 1.15193337e-01f,
  2.98541542e-02f, 2.30690718e-01f, 3.21705729e-01f, 1.21266291e-01f, -5.65537997e-02f, -7.76895359e-02f, -3.80239598e-02f, -1.10385835e-01f, -6.14968315e-02f, 1.64939035e-02f,
  9.24871266e-02f, -1.19560950e-01f, 5.94389485e-03f, -9.87915546e-02f, -5.76849766e-02f, -2.85579320e-02f, -9.86859296e-03f, -1.28352851e-01f, -2.76904464e-01f, -2.94615060e-01f,
  -8.04419369e-02f, -1.40431672e-01f, -1.33421555e-01f, -1.71256848e-02f, 1.78651765e-01f, -5.83577082e-02f, 1.11208744e-01f, 1.49535015e-01f, 1.52368113e-01f, 2.38580003e-01f,
  7.36966729e-02f, 2.50141621e-01f, -1.27676234e-01f, -1.01333976e-01f, 5.65118752e-02f, -2.42324714e-02f, 7.12928250e-02f, -4.14994312e-03f, 3.60426158e-02f, 3.02783474e-02f,
  9.38388854e-02f, -2.12634802e-02f, -6.61366386e-03f, 9.96156875e-03f, 8.70971568e-03f, -4.14097123e-02f, 3.25260237e-02f, 1.36651313e-02f, 2.75286194e-02f, 5.17031401e-02f,
  -2.88018472e-02f, -8.09372216e-02f, 2.63452847e-02f, 3.52503210e-02f, -3.49460579e-02f, -9.00418684e-02f, 6.71074837e-02f, -5.74400425e-02f, -1.77445598e-02f, 9.98503193e-02f,
  -6.23100512e-02f, 2.77879350e-02f, 2.14167908e-02f, 4.00415994e-02f, -5.95946945e-02f, 9.46368724e-02f, 1.09642230e-01f, -6.15681335e-02f, -1.12245686e-01f, -1.10178599e-02f,
  -3.07497941e-02f, 1.11567171e-03f, -2.43615708e-03f, 7.61502758e-02f, -3.29450183e-02f, 6.54225871e-02f, 8.36748909e-03f, 4.65333052e-02f, -6.86952993e-02f, -1.26012843e-02f,
  2.40860414e-02f, -2.44259089e-02f, 5.62272593e-02f, 5.33287972e-03f, 3.79887559e-02f, 8.87012761e-03f, 2.80735567e-02f, 1.84416510e-02f, 2.35918630e-03f, -8.23953375e-03f,
  -6.20501377e-02f, -1.05743632e-01f, -5.21038882e-02f, -1.33098260e-01f, 2.56794579e-02f, 8.68092328e-02f, -1.13692423e-02f, 4.86092307e-02f, 1.25350021e-02f, -1.09331653e-01f,
  -4.25206609e-02f, -7.45006278e-02f, -7.77759263e-03f, -7.42473230e-02f, -6.84907660e-02f, -1.09997354e-01f, -1.16911329e-01f, -9.17516723e-02f, -1.16409712e-01f, 2.19263770e-02f,
  -9.24473330e-02f, -1.76271826e-01f, -1.47537574e-01f, -1.30616516e-01f, -1.41125515e-01f, -1.42620176e-01f, -7.34892488e-02f, -8.04920346e-02f, -1.85623422e-01f, -1.72654957e-01f,
  -1.27413515e-02f, -3.58061166e-04f, 1.07630743e-02f, 1.09546863e-01f, 7.91653395e-02f, 5.76430000e-02f, -3.84806655e-02f, -3.12859640e-02f, 7.19140936e-03f, -7.29685128e-02f,
  -1.64908454e-01f, -1.68128937e-01f, -7.25887194e-02f, -1.01384453e-01f, -9.96023566e-02f, 1.70296505e-02f, 1.23785488e-01f, 9.18465555e-02f, 1.15854651e-01f, 1.34124786e-01f,
  6.66414648e-02f, 9.89567488e-02f, -5.00655919e-02f, 3.30125131e-02f, -3.47803347e-02f, -3.51653621e-02f, 1.60524454e-02f, 9.00144055e-02f, 3.26222032e-02f, 1.41443461e-01f,
  8.15675780e-02f, -2.49324530e-01f, -6.72110170e-02f, -4.34492528e-02f, -8.96649882e-02f, -2.06060987e-02f, -9.87462774e-02f, 1.31949745e-02f, -1.37615740e-01f, 2.37543602e-02f,
  -2.72575468e-02f, -2.23127510e-02f, -1.13375336e-01f, -5.22223189e-02f, -3.72458436e-02f, 7.01632425e-02f, -4.42608744e-02f, -3.83349066e-03f, 3.28592733e-02f, -2.51980592e-02f,
  2.57785004e-02f, 2.68705208e-02f, -2.86057126e-02f, -3.23391077e-03f, -1.43952057e-01f, 2.59884745e-02f, -5.92136532e-02f, -4.92317043e-02f, -5.29016554e-02f, -4.51897830e-03f,
  8.80323797e-02f, -1.14039838e-04f, -3.36181968e-02f, 3.18524502e-02f, -6.55967370e-02f, -5.05370498e-02f, 8.47948715e-02f, 6.36588782e-02f, 2.29280954e-03f, 9.94624719e-02f,
  -6.50694128e-03f, -5.55969663e-02f, 7.65716583e-02f, 5.69681823e-02f, -7.08761811e-02f, -2.45397240e-02f, 1.17608886e-02f, -2.69713420e-02f, -4.39172573e-02f, -5.41421659e-02f,
  -9.89437848e-02f, 5.50084338e-02f, -1.95267238e-02f, 8.32021981e-02f, -7.38861188e-02f, -1.92969237e-02f, 1.62120927e-02f, -5.59634790e-02f, -1.62569596e-03f, -3.76747847e-02f,
  1.86209068e-01f, -1.29333720e-01f, 4.38339710e-02f, -8.81866738e-02f, -3.90037755e-03f, -9.88168642e-03f, -2.34277640e-02f, 3.89549769e-02f, 5.41150309e-02f, 5.63614480e-02f,
  -7.46765286e-02f, -3.46148945e-02f, -6.20706677e-02f, -1.90920178e-02f, 1.40010163e-01f, 8.50337744e-02f, 4.12462465e-02f, 4.35942644e-03f, -2.41962578e-02f, -2.81661712e-02f,
  1.75200142e-02f, 1.36153847e-01f, 1.19558796e-01f, 6.05486184e-02f, 6.80526868e-02f, -1.33029511e-02f, 1.14335306e-01f, 5.12324758e-02f, 6.09819628e-02f, 2.84755647e-01f,
  5.44083305e-02f, 2.82624196e-02f, -2.59087890e-01f, -1.45757988e-01f, -1.69772178e-01f, -1.36121839e-01f, -6.11479916e-02f, -1.25896484e-02f, -1.13178954e-01f, 3.83894779e-02f,
  -5.96678397e-03f, -4.85254079e-02f, -9.12982821e-02f, 2.82674208e-02f, -2.47166064e-02f, 9.38719080e-04f, -7.22779110e-02f, 9.14074760e-03f, -8.05335641e-02f, -2.59227888e-03f,
  -7.39405900e-02f, -3.18288170e-02f, -7.23008737e-02f, -4.48906533e-02f, -1.34239227e-01f, -4.26755175e-02f, -8.71095732e-02f, -5.54321855e-02f, -7.64043108e-02f, -1.92710996e-01f,
  -3.18913966e-01f, -4.82459962e-02f, -3.52066197e-02f, 7.12027261e-03f, -1.47009224e-01f, -1.20014353e-02f, 5.62320948e-02f, -3.48831452e-02f, -5.86609133e-02f, -1.08561769e-01f,
  3.36030908e-02f, 5.50574735e-02f, 1.67803392e-02f, -9.14920345e-02f, -7.57829845e-02f, -7.19367042e-02f, -5.45955971e-02f, 7.22334161e-02f, 5.52528091e-02f, 6.41874894e-02f,
  2.50988342e-02f, -3.46064940e-02f, 7.89331645e-02f, 1.07654609e-01f, -7.83987865e-02f, 3.16661298e-02f, -1.14115849e-01f, -5.58503121e-02f, 3.14035900e-02f, -6.37235641e-02f,
  2.00488027e-02f, -5.34678623e-02f, 2.60847379e-02f, 5.24491742e-02f, 6.17305711e-02f, -2.53378563e-02f, -1.09976286e-03f, 4.71426733e-02f, -5.60542382e-03f, 4.90205847e-02f,
  -3.23777422e-02f, -6.92286789e-02f, 2.25859359e-02f, 6.58549592e-02f, -1.01636484e-01f, 5.59265353e-02f, 7.55173862e-02f, 4.10710052e-02f, 3.66127938e-02f, 1.51767991e-02f,
  6.47379085e-02f, -6.20162897e-02f, 2.28979392e-03f, -4.39619496e-02f, 4.06743027e-02f, -4.97554280e-02f, 6.18251273e-03f, 1.04080692e-01f, 7.11824521e-02f, -3.51701118e-02f,
  -1.42323390e-01f, 1.51995301e-01f, -1.36058806e-02f, 1.59063898e-02f, 2.17621643e-02f, -3.51489745e-02f, -8.80773552e-03f, -5.75569086e-02f, 4.97991517e-02f, -2.41477489e-02f,
  -6.63162991e-02f, 4.48248871e-02f, 3.24554965e-02f, -4.10451666e-02f, -3.17916162e-02f, 2.04104669e-02f, 8.60567689e-02f, 1.97837763e-02f, 7.07121938e-02f, 5.34204803e-02f,
  8.78619030e-02f, 1.37113258e-01f, 1.29944980e-01f, 1.84082258e-02f, -4.01791744e-02f, 1.31622002e-01f, -2.76200380e-02f, -1.70811806e-02f, 1.78067461e-01f, 7.03293309e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.01882748e-01f, 2.17765421e-01f, 1.93327725e-01f, 3.30265015e-01f, 1.60569102e-01f, 8.76577571e-02f, 2.00176582e-01f, 1.88302204e-01f, -2.94206641e-03f, 1.51490644e-01f,
  1.10796757e-01f, 2.28235587e-01f, 2.56705612e-01f, 1.01848312e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -1.67185053e-01f, -4.59574193e-01f, 1.71404704e-01f, -4.65502053e-01f, 8.40019807e-02f, -4.12022948e-01f, 8.59622359e-02f, -1.64040327e-01f, -1.41923830e-01f, 8.82057175e-02f,
  1.28126234e-01f, 2.49581352e-01f, -4.70762998e-01f, -1.91895828e-01f, 4.85343933e-02f, -2.34991893e-01f, -2.46623963e-01f, -1.85256019e-01f, -1.66668013e-01f, -3.02429795e-01f,
  1.49718687e-01f, -7.04200417e-02f, -2.47543722e-01f, -3.03814393e-02f, -1.14972502e-01f, -1.42288804e-01f, 5.13479173e-01f, -4.40246286e-03f, 3.31012338e-01f, -2.21493766e-01f,
  4.59965365e-03f, -1.05698191e-01f, -3.92749161e-01f, 3.73652279e-01f, 1.23481229e-01f, 2.13140503e-01f, 2.02919200e-01f, 9.29853469e-02f, 1.75425634e-01f, -6.21997826e-02f,
  3.64997923e-01f, -2.76588440e-01f, 1.23298824e-01f, 7.92896301e-02f, -2.18639106e-01f, -2.98390508e-01f, -3.98835778e-01f, 2.05220968e-01f, 1.51295066e-02f, 2.68110454e-01f,
  1.42542906e-02f, 8.59067440e-01f, 1.67806558e-02f, -2.44958922e-01f, 3.30691576e-01f, 9.22327191e-02f, -9.04633179e-02f, -2.11208552e-01f, -1.57692581e-01f, -1.61430031e-01f,
  -1.90692265e-02f, -4.37447786e-01f, -2.04310730e-01f, 1.31717354e-01f, 1.04384281e-01f, -3.83614689e-01f, 1.35522351e-01f, -2.66378105e-01f, -1.50083512e-01f, -3.56962383e-01f,
  1.81391954e-01f, -3.69218349e-01f, -3.98328714e-02f, 2.47616038e-01f, 1.29573569e-01f, -3.60972464e-01f, 6.24209158e-02f, -3.12116683e-01f, 2.53119498e-01f, 2.16325745e-02f,
  2.83881009e-01f, 4.29660589e-01f, -2.02674270e-01f, 3.01333517e-01f, -1.54610053e-01f, 1.74711943e-01f, 3.85185122e-01f, 2.03235358e-01f, -2.83948153e-01f, -3.89066517e-01f,
  5.28352439e-01f, 2.14072481e-01f, 3.15104902e-01f, 6.08696103e-01f, 2.00723544e-01f, -2.19947144e-01f, -1.13957249e-01f, 3.65697920e-01f, -5.49923107e-02f, 2.91817427e-01f,
  4.58812952e-01f, 1.08936317e-01f, 6.22243769e-02f, -5.28399162e-02f, 4.34775442e-01f, 4.38574612e-01f, 1.02132633e-02f, 4.83488262e-01f, 1.87285408e-01f, -5.45276821e-01f,
  1.26333669e-01f, 2.18719114e-02f, 2.86025286e-01f, 1.19339846e-01f, 1.31837696e-01f, 1.81250528e-01f, 1.34193331e-01f, 3.13407741e-02f, -3.03368211e-01f, -1.69172630e-01f,
  -3.10651451e-01f, 2.62437128e-02f, 6.22708142e-01f, 3.62916201e-01f, 3.40982974e-01f, -2.36419976e-01f, -3.04086894e-01f, 4.49346334e-01f, 1.36312246e-02f, -1.04384504e-01f,
  2.06117719e-01f, 2.94364635e-02f, 2.11542532e-01f, 3.20272744e-01f, 1.02014765e-01f, 5.60604930e-02f, 8.61569867e-02f, 1.15567014e-01f, 8.74118060e-02f, 3.72088373e-01f,
  2.90563464e-01f, 5.13037503e-01f, -5.86794037e-03f, -1.70749612e-02f, 1.18775718e-01f, 2.13305473e-01f, 5.92117608e-02f, -6.35329261e-02f, 8.03171843e-02f, 1.94002166e-01f,
  3.88759583e-01f, -5.84934698e-03f, -9.15305465e-02f, -4.92295712e-01f, 4.43572968e-01f, -3.96969438e-01f, -2.04768077e-01f, -3.41193154e-02f, 2.35609710e-01f, -2.11003780e-01f,
  -4.47638959e-01f, 2.78044790e-01f, -1.53085276e-01f, 5.31330667e-02f, 6.27212077e-02f, 2.28110358e-01f, 3.79919633e-02f, 1.63122565e-01f, -4.15069848e-01f, -3.24954480e-01f,
  2.77946264e-01f, -4.20249701e-01f, 6.64723158e-01f, -2.54995823e-01f, -1.40475839e-01f, -2.08086327e-01f, 4.61792678e-01f, 4.28288102e-01f, -2.02884555e-01f, -2.28143513e-01f,
  -2.13045582e-01f, -4.78843153e-01f, 3.55161190e-01f, -1.03580944e-01f, -1.26424521e-01f, 1.08609371e-01f, -2.13978231e-01f, -3.23241800e-01f, 1.49752021e-01f, -7.54478872e-02f,
  3.22613306e-02f, -3.65606919e-02f, -9.91344899e-02f, 2.01890655e-02f, -5.63707650e-01f, 2.80261219e-01f, 3.80043522e-03f, 2.30596706e-01f, -3.20699036e-01f, 4.33556698e-02f,
  -1.41439177e-02f, -8.63198414e-02f, 2.56514996e-01f, -2.18715966e-01f, -1.59550980e-01f, 2.27078259e-01f, -6.33715689e-02f, 1.13694876e-01f, -7.95537233e-02f, 3.00746381e-01f,
  1.04876608e-01f, 1.74905002e-01f, -3.51287693e-01f, -2.50002861e-01f, -2.85619169e-01f, -9.95946825e-02f, 2.00745091e-01f, -3.47055405e-01f, -2.57426530e-01f, -7.57561684e-01f,
  -4.09940898e-01f, -1.04255311e-01f, 5.76610975e-02f, 3.99237692e-01f, 2.09047064e-01f, -4.29381967e-01f, -2.06299320e-01f, 3.55218977e-01f, -3.11678171e-01f, 3.33359987e-01f,
  2.50631213e-01f, -5.01486436e-02f, -9.89250690e-02f, -2.33432740e-01f, 8.33332986e-02f, 2.56823868e-01f, -1.55124575e-01f, 5.51726580e-01f, -3.80398929e-01f, 3.59043896e-01f,
  -4.18652654e-01f, -2.98518538e-01f, -1.17500290e-01f, 4.67418820e-01f, 6.01868294e-02f, -6.59556016e-02f, 5.16133726e-01f, -2.36388043e-01f, 5.72603894e-03f, -3.02716821e-01f,
  -1.11186355e-01f, -4.32735942e-02f, -2.60502487e-01f, 5.69218807e-02f, -7.45940208e-02f, 2.23629713e-01f, 2.20269244e-02f, 2.62175262e-01f, 3.01724166e-01f, 1.21090613e-01f,
  -1.75450042e-01f, 1.73895851e-01f, 1.10816337e-01f, 2.32274070e-01f, -9.53494161e-02f, -3.29463691e-01f, -3.99917036e-01f, -1.04327261e-01f, -1.64178863e-01f, -4.15929466e-01f,
  2.98076779e-01f, -6.24965765e-02f, -9.03629661e-02f, -4.19991612e-01f, 1.23459483e-02f, -2.53008187e-01f, 3.02781433e-01f, 1.84260070e-01f, 1.48426713e-02f, -1.63089052e-01f,
  5.43329231e-02f, 1.24807402e-01f, -2.63502691e-02f, 1.63984805e-01f, 3.38683456e-01f, -3.95412773e-01f, 2.54024029e-01f, 3.53271574e-01f, 7.59112537e-02f, -2.60892510e-01f,
  -6.15023375e-01f, -4.71482933e-01f, -3.39660048e-01f, 1.98968664e-01f, 1.57148227e-01f, 9.03501734e-02f, 7.47676864e-02f, -2.87715465e-01f, 1.26506373e-01f, -3.03139120e-01f,
  -2.98076719e-01f, 2.77369529e-01f, 1.45174330e-02f, 2.72270977e-01f, -8.41317102e-02f, 5.07423952e-02f, -4.09681089e-02f, 3.15849036e-02f, 2.03404687e-02f, 7.46773064e-01f,
  9.29408818e-02f, -1.99613735e-01f, 6.10538665e-03f, 9.09188837e-02f, 9.85995755e-02f, 8.83949995e-02f, -6.53153360e-02f, 5.55302739e-01f, -2.50440687e-01f, -1.59116417e-01f,
  8.80835801e-02f, 3.27427328e-01f, -8.85020196e-02f, 2.67567903e-01f, 2.31219336e-01f, 1.44290039e-02f, -3.02344859e-02f, -1.12790070e-01f, -2.03319564e-02f, -1.47078127e-01f,
  5.45176715e-02f, 9.35394168e-02f, 2.85925061e-01f, 1.67564079e-01f, -4.27082330e-01f, 1.63852312e-02f, 4.57779318e-01f, 2.80431628e-01f, 1.56132117e-01f, 2.64813192e-03f,
  1.79658160e-01f, -2.14596651e-02f, 7.30695575e-02f, 2.20167562e-01f, 1.29831657e-01f, 6.70717478e-01f, 3.13544609e-02f, 4.99611855e-01f, 1.37569115e-01f, -1.61085993e-01f,
  2.84381837e-01f, -3.59806195e-02f, -3.33801031e-01f, -1.25246167e-01f, 2.71043956e-01f, 6.03118092e-02f, 4.97925073e-01f, 7.93344304e-02f, 7.24917203e-02f, -5.41153371e-01f,
  2.13184893e-01f, 1.00033462e-01f, 6.39327765e-02f, -1.03185900e-01f, -4.15480196e-01f, -2.97849953e-01f, 4.69518840e-01f, 1.80385500e-01f, -2.94596791e-01f, 2.32121184e-01f,
  -1.67702615e-01f, 1.69087648e-01f, -1.89786077e-01f, 4.27662224e-01f, -3.20277035e-01f, -1.55021250e-01f, 8.12122762e-01f, 1.37592942e-01f, 1.07684389e-01f, 2.70769298e-01f,
  3.04250956e-01f, -3.68823886e-01f, 1.67948544e-01f, 2.58669347e-01f, -1.06546544e-02f, -5.52397221e-03f, -3.21016133e-01f, -1.69371799e-01f, 1.33330345e-01f, -2.83517241e-01f,
  -1.38959438e-01f, 2.34523207e-01f, 2.60441810e-01f, 2.49398410e-01f, 2.66042739e-01f, 3.58582288e-02f, -2.02921063e-01f, -2.76624471e-01f, 5.49400300e-02f, 1.77308753e-01f,
  2.80194759e-01f, 1.92281514e-01f, -7.47642294e-03f, -7.04878941e-03f, -2.07903862e-01f, -1.38634900e-02f, -6.81156993e-01f, 3.29836935e-01f, 1.71887651e-01f, 1.98831454e-01f,
  1.51288062e-01f, 6.49894476e-01f, -4.52559084e-01f, -1.09544091e-01f, -5.18254399e-01f, -1.27862856e-01f, 1.89214677e-01f, -2.26297140e-01f, -1.13728233e-01f, -3.17338645e-01f,
  -3.22003216e-01f, -6.22151673e-01f, -6.53261065e-01f, 3.90413739e-02f, -1.49269924e-01f, 3.98936542e-03f, 1.05822280e-01f, -1.91239178e-01f, 5.07097840e-01f, -4.29226428e-01f,
  1.43227130e-01f, -4.78717327e-01f, 3.85472596e-01f, 3.38170826e-01f, -9.52746719e-02f, -2.17317730e-01f, -2.09196702e-01f, -1.84094787e-01f, -1.09020479e-01f, 2.51656979e-01f,
  -1.73082709e-01f, -4.71199788e-02f, -1.51323318e-01f, -6.29158542e-02f, 1.71306029e-01f, 2.75393456e-01f, 2.49006990e-02f, -1.92841873e-01f, -1.26685768e-01f, -1.22982197e-01f,
  -2.90469527e-01f, -2.16877371e-01f, -3.50841045e-01f, -1.78485975e-01f, 7.22262189e-02f, -1.45025980e-02f, 1.38426553e-02f, -1.83509499e-01f, -2.15000883e-02f, -4.04653311e-01f,
  9.03147459e-02f, -1.76004663e-01f, 1.66913569e-01f, -2.77563959e-01f, -4.84479778e-02f, 1.54852152e-01f, -3.04070890e-01f, 7.42859840e-02f, 2.68429536e-02f, -6.88974336e-02f,
  1.23039313e-01f, -2.19761550e-01f, -3.29021990e-01f, 2.63990819e-01f, -2.25891367e-01f, -5.46393096e-01f, -4.50592488e-01f, -4.79929715e-01f, -3.07638228e-01f, 2.63549507e-01f,
  2.19395518e-01f, 3.50875527e-01f, 4.16827500e-01f, 2.58725792e-01f, -2.21818134e-01f, 1.96186349e-01f, -3.24725837e-01f, 5.01483679e-02f, -3.60153884e-01f, -1.43493256e-02f,
  8.56906548e-02f, -4.52798814e-01f, 3.02903593e-01f, 9.37133059e-02f, 6.63810298e-02f, 6.23083226e-02f, -5.04311860e-01f, -3.59895438e-01f, 3.36083382e-01f, -2.15225860e-01f,
  3.68563026e-01f, -1.56132758e-01f, 1.06891699e-01f, 2.56923825e-01f, 3.01218703e-02f, 1.32089972e-01f, 1.81614429e-01f, 1.84576944e-01f, -2.11621553e-01f, 4.37953100e-02f,
  9.94605646e-02f, -1.57881394e-01f, 2.35192284e-01f, 2.74244279e-01f, 2.88209021e-01f, 1.60837322e-02f, -2.42022991e-01f, 2.17448175e-01f, 8.22081119e-02f, -6.44084364e-02f,
  1.13820083e-01f, -9.89800394e-02f, 1.97735161e-01f, -3.19840461e-02f, -8.56407732e-02f, 3.31679583e-01f, 2.14556217e-01f, 1.36018738e-01f, -4.90509301e-01f, -4.37301666e-01f,
  2.67134135e-04f, -1.57676220e-01f, -2.20950004e-02f, 1.02490604e-01f, 2.19734564e-01f, 1.33452028e-01f, 6.58124909e-02f, 1.51217744e-01f, 2.21791819e-01f, -2.50600845e-01f,
  2.04400942e-01f, 5.25667608e-01f, -1.08016260e-01f, -3.46240364e-02f, -3.75314772e-01f, -2.53445268e-01f, 4.75346118e-01f, 1.79683611e-01f, 2.36410722e-01f, -3.70085478e-01f,
  -1.53126255e-01f, 3.32344994e-02f, 2.10783526e-01f, 4.21997398e-01f, -3.64923775e-01f, -1.30617674e-02f, 5.16224265e-01f, 4.22685266e-01f, 2.82807380e-01f, -1.69061333e-01f,
  -6.35660142e-02f, -8.95185769e-02f, 5.28377175e-01f, -3.59887064e-01f, -2.13576078e-01f, -2.96134621e-01f, -1.38705224e-01f, -1.24945022e-01f, 1.91434637e-01f, -8.59047547e-02f,
  -3.02671731e-01f, 3.70047510e-01f, -1.03445090e-01f, -1.68464735e-01f, 4.43553239e-01f, -5.80229051e-02f, 7.54006580e-02f, 1.56996593e-01f, 2.08401844e-01f, 2.23677218e-01f,
  5.33655994e-02f, 2.60029018e-01f, 4.92934743e-03f, -1.23295240e-01f, 3.51831652e-02f, -1.70915630e-02f, -2.36855701e-01f, 1.39073119e-01f, 2.13793293e-01f, 4.18597102e-01f,
  -2.24647328e-01f, 9.73015651e-02f, -1.36656746e-01f, -3.87460738e-01f, 9.49597657e-02f, 8.06872770e-02f, -1.60192296e-01f, -8.88633057e-02f, 1.68553323e-01f, 1.51494935e-01f,
  -9.53568593e-02f, 2.21619517e-01f, -2.90040910e-01f, 5.56799591e-01f, 2.07167789e-01f, -2.61024803e-01f, -3.32295209e-01f, -2.77488887e-01f, 4.44623470e-01f, 6.13534689e-01f,
  6.61305676e-04f, -6.29154444e-01f, -2.70492882e-01f, 4.40782249e-01f, 8.72058347e-02f, 3.90961230e-01f, -1.85988843e-01f, -3.26831371e-01f, 5.17476439e-01f, -2.15541974e-01f,
  -6.18544996e-01f, -3.14785719e-01f, 2.99142569e-01f, -3.07821751e-01f, 3.09787542e-01f, -5.54688632e-01f, -3.86293456e-02f, -2.73849040e-01f, -1.60365954e-01f, 4.75685708e-02f,
  -1.85071170e-01f, 5.33054769e-01f, -1.04182541e-01f, 2.38818571e-01f, -4.77579832e-02f, -2.36982912e-01f, -6.49286583e-02f, 1.40077412e-01f, 5.85528277e-02f, -1.35709405e-01f,
  1.10709459e-01f, -1.88351035e-01f, -1.84118934e-02f, 1.01656713e-01f, 2.03582734e-01f, -1.34460069e-03f, -2.34477818e-01f, 2.42276445e-01f, 1.30078375e-01f, 8.44730213e-02f,
  -2.65964419e-01f, 2.21482933e-01f, 2.36652628e-01f, -7.02225119e-02f, -2.69344747e-01f, 5.58846816e-02f, 7.59503171e-02f, 2.44623721e-01f, -3.90344411e-02f, 1.26881301e-01f,
  2.31874231e-02f, 1.02044508e-01f, -1.83165073e-01f, -2.24874705e-01f, 2.09379429e-03f, -1.61204055e-01f, -5.63362181e-01f, -5.09223819e-01f, 3.77136797e-01f, -1.04723945e-01f,
  1.55846223e-01f, 4.28345770e-01f, -9.88345011e-04f, 1.15714990e-01f, 4.45659131e-01f, -4.34024692e-01f, 7.38079697e-02f, -2.85956115e-01f, 2.79598802e-01f, -4.65271115e-01f,
  3.57205063e-01f, 5.00917256e-01f, -3.75384599e-01f, 1.48076251e-01f, -8.03721771e-02f, 1.93970010e-01f, -1.49569571e-01f, 4.03790921e-01f, 5.02743959e-01f, 5.83414361e-02f,
  -2.36814752e-01f, -2.28013769e-01f, 5.66500306e-01f, 4.10662264e-01f, -1.35428071e-01f, -3.39701436e-02f, -1.62885427e-01f, -2.97315083e-02f, -2.44107902e-01f, -1.42654806e-01f,
  -2.22173288e-01f, -1.89570487e-01f, 2.02221021e-01f, -2.78370470e-01f, 7.90296495e-02f, 1.49622276e-01f, 1.07667096e-01f, 8.47897157e-02f, -1.23620100e-01f, -1.47634119e-01f,
  8.47363621e-02f, 2.34272890e-03f, -1.84832007e-01f, -5.60930930e-02f, 2.00126376e-02f, 9.05779749e-02f, -8.27810094e-02f, -2.19954439e-02f, -1.42226368e-01f, 1.03984408e-01f,
  2.90162474e-01f, 1.33372806e-02f, 1.69292614e-01f, 2.12689385e-01f, 7.68298134e-02f, 8.66906345e-02f, 1.02025114e-01f, -3.73185933e-01f, 2.23467186e-01f, 9.31165367e-02f,
  -3.04060608e-01f, 5.16312361e-01f, -2.28316665e-01f, 5.53526580e-01f, -3.53125602e-01f, -1.44605070e-01f, 2.41796881e-01f, -4.71065521e-01f, -5.15355110e-01f, 5.29472530e-01f,
  -1.27568245e-01f, -2.56397158e-01f, -2.44674578e-01f, 4.61809456e-01f, -4.59235907e-01f, -1.45045847e-01f, -5.43629467e-01f, 2.49565914e-01f, -3.38599473e-01f, 5.16220212e-01f,
  -2.56676435e-01f, -2.86506355e-01f, -6.88203454e-01f, -8.78685638e-02f, -5.45328408e-02f, -2.05185860e-01f, -7.95328582e-04f, -2.62205303e-01f, -1.52145505e-01f, -1.43276304e-01f,
  2.02540860e-01f, 4.24936600e-02f, 2.03752264e-01f, -1.87004969e-01f, -2.02021986e-01f, 3.19976479e-01f, -2.74855196e-01f, -4.62146886e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.86720788e-02f, 3.89657952e-02f, 1.70569159e-02f, -6.80818036e-02f, 1.62826292e-02f, -7.03533366e-02f, -9.29521024e-03f, -1.51657434e-02f, 6.33387119e-02f, -2.29494683e-02f,
  1.13752484e-01f, 8.85106698e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    