/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.86286861e-01f, 1.67859718e-01f, -6.91505596e-02f, 2.02660918e-01f, -3.02367717e-01f, -1.51322916e-01f, -1.46031410e-01f, -3.56393717e-02f, -2.97266960e-01f, 1.06567375e-01f,
  2.42150370e-02f, 1.36577576e-01f, -8.26038867e-02f, 2.39084959e-01f, -3.40739191e-01f, -1.42013907e-01f, 1.07780270e-01f, 5.71411476e-03f, -1.60829708e-01f, -5.28568588e-02f,
  -5.22043407e-02f, 5.28079942e-02f, 5.57402819e-02f, 5.83469458e-02f, 1.49578825e-01f, 1.12444080e-01f, 1.06599331e-01f, -9.55827087e-02f, 2.94805735e-01f, 4.28665876e-02f,
  -1.20138275e-02f, -1.52194900e-02f, -1.39871072e-02f, 6.79267123e-02f, 3.24107818e-02f, -3.84182408e-02f, 5.88938706e-02f, -7.28626549e-02f, -1.19948134e-01f, -3.71600315e-02f,
  4.25395072e-02f, -2.09009666e-02f, 1.17644832e-01f, -5.83975576e-02f, -1.22128949e-01f, -9.95317195e-03f, 2.01338343e-02f, 9.68451053e-03f, 7.79631361e-02f, -4.42674011e-02f,
  2.85934303e-02f, 1.17998719e-01f, 5.82514983e-03f, 4.49059308e-02f, 6.76979125e-02f, 7.15461075e-02f, -3.70709621e-03f, -6.32474646e-02f, -3.43886763e-02f, 6.13874895e-03f,
  -2.25962978e-02f, -6.65481165e-02f, -3.03622019e-02f, 4.85956762e-03f, 4.62932587e-02f, -1.42641766e-02f, 2.79831374e-03f, 6.79445192e-02f, 2.09730887e-03f, 7.63335004e-02f,
  4.41261902e-02f, 2.93414425e-02f, 9.49095003e-03f, 6.02683425e-03f, -1.99057255e-02f, 1.45465080e-02f, -5.95958810e-03f, 6.93338811e-02f, 4.55324352e-02f, -3.22170951e-03f,
  3.33819352e-02f, -3.06835845e-02f, 8.74448270e-02f, 5.90187684e-02f, 6.25595450e-03f, -2.57229712e-02f, 5.20269945e-02f, 4.85028699e-02f, 6.81620277e-03f, -3.89431268e-02f,
  7.73691852e-03f, -1.22107193e-01f, 5.31494170e-02f, 7.63053000e-02f, 9.39210877e-03f, 4.00946336e-03f, -4.22145128e-02f, -2.50428505e-02f, 3.30317244e-02f, -7.84438662e-03f,
  2.51529668e-03f, 5.09515852e-02f, -3.42813544e-02f, -1.45111075e-02f, -2.87552848e-02f, -4.37141024e-02f, -1.15155149e-02f, -2.39448585e-02f, -4.99727651e-02f, -2.39528734e-02f,
  1.11174313e-02f, -6.79365695e-02f, -4.94742207e-02f, 6.47254661e-02f, 7.57708326e-02f, 9.03342739e-02f, -5.99264614e-02f, 5.11967875e-02f, 4.21888269e-02f, 8.31511803e-03f,
  4.43283409e-01f, 2.42014639e-02f, 2.86737621e-01f, 3.91953178e-02f, -1.14187256e-01f, 1.14269987e-01f, 1.15797907e-01f, -8.52009207e-02f, 2.21983343e-01f, -2.31432691e-01f,
  -1.43446565e-01f, 3.70841861e-01f, -1.50580764e-01f, -2.20291074e-02f, 2.15924293e-01f, 2.28599738e-02f, -4.15098295e-02f, 6.25288635e-02f, 1.12820990e-01f, 4.18506116e-02f,
  1.03872299e-01f, -3.04080814e-01f, 3.53944637e-02f, -2.43119806e-01f, -5.16659506e-02f, 5.17293513e-02f, -3.33125889e-01f, -3.28092091e-02f, -1.22975685e-01f, -3.83433104e-02f,
  6.71975017e-02f, 1.65970981e-01f, -3.91591787e-02f, 7.08232000e-02f, -6.22033840e-03f, -1.52474269e-02f, 7.77258277e-02f, -5.11154793e-02f, 3.48525904e-02f, 3.83945033e-02f,
  1.32956818e-01f, 3.79588977e-02f, -7.01707304e-02f, -8.01070854e-02f, 8.84481147e-02f, -2.92215906e-02f, 4.73938696e-02f, -6.95277080e-02f, 3.53218205e-02f, 1.44916857e-02f,
  -7.68489158e-03f, 8.05310830e-02f, 7.25807846e-02f, -2.78869700e-02f, 7.59129226e-02f, 7.05927908e-02f, -4.56871055e-02f, 6.01991713e-02f, 5.51745966e-02f, -1.83111511e-03f,
  6.03049714e-03f, -1.85908005e-02f, -4.99139912e-02f, 3.49655049e-03f, -4.74375710e-02f, -4.56657559e-02f, 2.20580585e-02f, -8.73726234e-02f, 1.67664997e-02f, 5.35292039e-03f,
  -4.19102088e-02f, 4.76949811e-02f, -2.07802560e-03f, -4.05543074e-02f, -8.39466229e-03f, -1.64858846e-03f, 4.42532450e-02f, -3.76235023e-02f, 7.84161314e-02f, -6.51507974e-02f,
  1.06498078e-02f, -5.63309900e-03f, 5.14129549e-02f, 6.70014275e-03f, -7.16328807e-03f, -2.06269062e-04f, -6.17112070e-02f, 8.70599970e-02f, 3.71569097e-02f, -2.79506128e-02f,
  1.08982615e-01f, -9.17735621e-02f, -4.35212962e-02f, 5.19528650e-02f, -1.18642626e-02f, -8.04407820e-02f, -7.51142576e-02f, 3.34528834e-03f, -8.40072148e-03f, -4.80265217e-03f,
  7.01938057e-03f, -1.01533912e-01f, 9.60289836e-02f, -6.40555564e-03f, -4.65774871e-02f, -4.17181887e-02f, 4.00237693e-03f, 3.33733037e-02f, -4.92634885e-02f, -1.62912887e-02f,
  -9.96559486e-03f, -3.24425586e-02f, -1.25125544e-02f, -4.41415124e-02f, -1.12374127e-01f, -1.15824891e-02f, 7.34250620e-03f, 1.96126625e-02f, -6.24411441e-02f, 5.57980454e-03f,
  -3.64305168e-01f, 1.05578937e-01f, -1.14993274e-01f, -1.67429402e-01f, 2.16808632e-01f, 3.57097000e-01f, -6.99166507e-02f, 2.83180654e-01f, 1.60190493e-01f, -3.93241271e-02f,
  1.31765112e-01f, -3.39499921e-01f, -3.10638007e-02f, -1.59194525e-02f, -1.47713616e-01f, 2.04663090e-02f, -3.35433036e-02f, -1.09353133e-01f, 1.38921410e-01f, 1.21042177e-01f,
  -5.44116972e-03f, 1.05546556e-01f, -1.72519043e-01f, 2.15533525e-01f, 8.94301161e-02f, -1.94719601e-02f, -6.87022284e-02f, -1.20188482e-02f, -1.31770656e-01f, 2.82595959e-02f,
  9.87965465e-02f, -6.59821779e-02f, -1.02721639e-01f, -6.61441460e-02f, 5.20399474e-02f, -4.81601059e-02f, -4.94704619e-02f, -3.46372277e-02f, 1.04158306e-02f, -2.47495566e-02f,
  -9.93575081e-02f, -3.50097865e-02f, -2.87433825e-02f, 3.15647759e-02f, 2.76199430e-02f, -6.34420365e-02f, -4.44659293e-02f, 7.84777924e-02f, -1.26622757e-02f, -5.39492704e-02f,
  -4.37943228e-02f, 1.91245694e-03f, 7.89286569e-02f, -8.68017673e-02f, -5.89397252e-02f, -2.08495855e-02f, -5.09339310e-02f, -3.88736390e-02f, -8.06989595e-02f, -2.47267019e-02f,
  -1.41085731e-02f, 1.01041272e-01f, -5.73103130e-02f, 1.09551372e-02f, -5.50735230e-03f, 2.13857181e-02f, -4.31052633e-02f, -6.28514588e-02f, 1.46535214e-03f, -2.79717166e-02f,
  -1.50157919e-03f, 3.24104019e-02f, 5.88467866e-02f, 4.81924042e-02f, -2.50517204e-02f, -7.71753443e-03f, 1.80629231e-02f, 1.07205715e-02f, 6.19002134e-02f, -1.71345081e-02f,
  -3.85705158e-02f, 7.07075372e-02f, -4.43509296e-02f, -1.54164424e-02f, -1.33867953e-02f, -2.72773542e-02f, 9.27322209e-02f, 4.33744714e-02f, 1.30503066e-02f, 1.92519203e-02f,
  2.00730503e-01f, 1.67796850e-01f, 2.14934684e-02f, 6.11161441e-02f, -2.01937370e-02f, 2.19365079e-02f, 1.69175807e-02f, 5.55987097e-02f, -8.58174264e-03f, 5.18223010e-02f,
  8.89314115e-02f, 1.83388814e-02f, 8.82889181e-02f, -6.49859430e-03f, -3.16806659e-02f, 5.84333651e-02f, 3.22170183e-03f, -1.24118915e-02f, -2.01074537e-02f, -2.30095237e-02f,
  -1.68829951e-02f, 3.25260987e-03f, -5.64695410e-02f, 1.16222344e-01f, 1.38027025e-02f, -4.70517017e-02f, 1.39967715e-02f, -7.01220753e-03f, 7.31611974e-04f, -1.78520381e-02f,
  -2.25196704e-01f, -5.71030974e-02f, 3.45060378e-02f, -1.47497445e-01f, 2.14600295e-01f, 4.07615572e-01f, 1.54288158e-01f, 8.52699205e-02f, 1.41295403e-01f, -1.26307860e-01f,
  1.00896016e-01f, -8.48276317e-02f, -3.10206953e-02f, 3.59396666e-01f, 2.34496996e-01f, 1.66198194e-01f, 3.40403706e-01f, 1.00239836e-01f, 1.04021057e-01f, -4.36131433e-02f,
  6.99204281e-02f, 4.10356037e-02f, 5.02351485e-02f, -4.99828644e-02f, 8.24076608e-02f, -1.75413206e-01f, -2.38815844e-01f, -1.87589992e-02f, -8.32163468e-02f, 1.71958417e-01f,
  4.50758599e-02f, -6.78699538e-02f, -9.13202390e-03f, 2.12556566e-03f, 1.08206838e-01f, -4.51029427e-02f, -3.72605324e-02f, 1.40502965e-02f, 2.65058689e-02f, -6.80530816e-02f,
  -4.74118926e-02f, 2.78386232e-02f, 6.84432278e-04f, 6.88346522e-03f, 2.64486447e-02f, 4.19916771e-03f, -3.30371293e-03f, 3.91710661e-02f, 3.76420505e-02f, 7.32354224e-02f,
  2.57835276e-02f, 6.79921284e-02f, 8.15265328e-02f, 5.29123284e-02f, 5.92190474e-02f, 6.34352267e-02f, 5.73552325e-02f, 1.57963097e-01f, 1.76858902e-02f, 1.20257616e-01f,
  5.78046329e-02f, 2.97779962e-02f, -9.76276845e-02f, -1.31346852e-01f, 1.14704315e-02f, -9.17506218e-02f, 1.99231543e-02f, -1.21652391e-02f, -8.82132724e-02f, 7.86886588e-02f,
  9.23818443e-03f, -2.39140242e-02f, 4.03248370e-02f, 3.72343138e-02f, -1.94709264e-02f, -2.79309638e-02f, -4.81316335e-02f, -8.32799170e-03f, 1.03254598e-02f, -1.80217950e-03f,
  -6.80908421e-03f, 1.38060842e-02f, -1.22705638e-01f, -4.32508765e-03f, 4.25769202e-02f, 5.83283678e-02f, 3.71589027e-02f, -2.40784399e-02f, 2.08223965e-02f, -2.36265492e-02f,
  5.81407100e-02f, -1.02762051e-01f, -8.91503587e-04f, -2.19510533e-02f, -6.48016483e-02f, -1.30177056e-02f, -6.65262854e-03f, -5.70770577e-02f, -7.75885433e-02f, -8.51327553e-03f,
  1.84011254e-02f, -5.80239147e-02f, -5.34542874e-02f, -8.88840556e-02f, -5.18324673e-02f, -1.34998798e-01f, -6.67178705e-02f, 2.81149764e-02f, 2.85971127e-02f, -2.09129099e-02f,
  -7.17135295e-02f, -5.22414893e-02f, -1.37589481e-02f, -6.36124015e-02f, 3.93894911e-02f, 3.47348629e-03f, -7.54815415e-02f, 9.08154398e-02f, -6.84708133e-02f, 2.61360370e-02f,
  -1.14320092e-01f, -9.21910256e-02f, -1.57694429e-01f, -2.55704224e-01f, 2.34422795e-02f, 3.17253560e-01f, -1.12759329e-01f, 4.25957069e-02f, -3.08139861e-01f, 1.20850876e-01f,
  -1.74388569e-02f, -2.37617150e-01f, -5.49548529e-02f, 1.94136202e-02f, 7.01299310e-02f, -3.11164204e-02f, 1.47193730e-01f, -7.67557621e-02f, -1.93955705e-01f, -2.19480954e-02f,
  -4.11069281e-02f, 1.31410062e-01f, 4.75701727e-02f, 1.65179521e-01f, -6.20380901e-02f, -5.50515577e-02f, 1.15623400e-01f, -1.14829941e-02f, 2.80898839e-01f, 1.10924810e-01f,
  -4.12102379e-02f, -1.07830197e-01f, 1.77688040e-02f, 7.89628774e-02f, 9.37560350e-02f, -1.78177115e-02f, 1.03516422e-01f, 1.25827370e-02f, -3.97152677e-02f, 2.10879184e-02f,
  -5.24458615e-03f, -5.53483069e-02f, -2.72038523e-02f, 1.15331803e-02f, -3.46199311e-02f, 3.06972004e-02f, 1.86361112e-02f, 2.86394246e-02f, -2.30355076e-02f, -5.65623231e-02f,
  -3.14925313e-02f, 9.11401585e-03f, -2.34030001e-02f, 6.36740997e-02f, -3.66257168e-02f, -7.00610429e-02f, 1.40802367e-02f, -4.73845564e-02f, 5.61204143e-02f, -4.72246483e-02f,
  -2.64089555e-02f, -5.21623418e-02f, 1.87456561e-03f, -2.49739401e-02f, 8.44396204e-02f, -2.86115017e-02f, 9.99787524e-02f, 5.84350228e-02f, -9.91585944e-03f, 2.85936310e-03f,
  3.52022015e-02f, -8.44808370e-02f, -6.63379207e-02f, -7.70453736e-02f, -8.29401836e-02f, -4.12969664e-02f, 3.46887088e-03f, -9.09716915e-03f, 6.20525470e-03f, 4.34037261e-02f,
  -6.35386780e-02f, 2.53071152e-02f, 4.16656584e-02f, 2.46114247e-02f, -5.56682656e-03f, -4.80183922e-02f, -1.03537448e-01f, -9.35322512e-03f, -8.07424113e-02f, 1.13772452e-01f,
  1.84268698e-01f, 1.23243534e-03f, 5.58787398e-02f, 1.23963892e-01f, -5.37358318e-03f, 3.44958268e-02f, -1.33247927e-01f, 4.81694564e-02f, 3.29025760e-02f, -8.35082214e-03f,
  -1.86703783e-02f, 3.35657969e-02f, 5.28124571e-02f, 1.04254838e-02f, 3.56161334e-02f, -8.61179531e-02f, -6.20071683e-03f, 6.98333085e-02f, 1.03669085e-01f, 7.46193752e-02f,
  4.91711125e-02f, 1.32643841e-02f, 8.37835595e-02f, 8.14126283e-02f, 2.80680638e-02f, 5.83227389e-02f, -2.93379519e-02f, 7.28369411e-03f, 5.68089820e-02f, 2.54877340e-02f,
  1.66203022e-01f, -2.33623937e-01f, -3.47698480e-01f, 1.47553943e-02f, 2.07518503e-01f, -1.07841901e-01f, -7.05203190e-02f, 9.05486494e-02f, 1.12275250e-01f, -6.83537275e-02f,
  4.07365933e-02f, -7.28912577e-02f, -7.13465437e-02f, -1.20056950e-01f, 2.83432752e-01f, -1.94090962e-01f, 1.09759167e-01f, -7.44065568e-02f, 5.15871793e-02f, 7.16963112e-02f,
  5.77172227e-02f, 1.94545656e-01f, -1.98176369e-01f, 1.01213694e-01f, -1.53194994e-01f, -1.35171264e-01f, 2.14840099e-01f, -1.60113141e-01f, 7.69138942e-03f, 5.83005436e-02f,
  1.49542857e-02f, 6.20681979e-02f, -1.30248904e-01f, -9.26305950e-02f, -2.11178958e-02f, 1.54825449e-02f, 3.88807580e-02f, -1.72271997e-01f, -3.30513641e-02f, -3.06398626e-02f,
  -1.33320494e-02f, 4.62843068e-02f, -4.85522673e-02f, -6.11344278e-02f, 2.15198286e-02f, 2.92386510e-03f, -9.02257338e-02f, -1.09182313e-01f, -3.65577010e-03f, 2.92224810e-02f,
  -6.76271468e-02f, -7.54035786e-02f, 4.63087112e-02f, 4.61750068e-02f, 1.43283757e-03f, 4.30092542e-03f, -2.08520517e-03f, -3.09539791e-02f, 8.48638639e-02f, 1.05277278e-01f,
  3.26564093e-03f, 8.93226266e-02f, -9.89792496e-03f, 2.48329155e-02f, 1.39644137e-02f, 5.72765246e-02f, -5.92940897e-02f, 4.90687005e-02f, -2.43784469e-02f, 3.19617465e-02f,
  1.51965931e-01f, -4.01284429e-04f, 5.42356521e-02f, 5.22075966e-02f, -4.22719344e-02f, 1.83135755e-02f, -2.02140235e-03f, -1.52977901e-02f, -1.45677617e-02f, -1.29970238e-02f,
  2.47690026e-02f, -4.71752137e-03f, -4.35219780e-02f, 6.93217888e-02f, -9.89974663e-03f, -4.76781167e-02f, -3.63130635e-03f, 5.33382222e-03f, 8.69311318e-02f, 2.61330279e-03f,
  2.59294868e-01f, 4.06938016e-01f, 5.13708107e-02f, 4.18808963e-03f, 7.80666843e-02f, 2.57896613e-02f, 3.49702016e-02f, -3.42344376e-03f, -7.15300664e-02f, -4.76931600e-04f,
  -2.54953653e-02f, 1.51854772e-02f, 2.17321813e-02f, -2.16734502e-02f, -4.15195860e-02f, 4.87736277e-02f, 7.64725730e-02f, 1.71370450e-02f, 6.15234673e-02f, 2.07098424e-02f,
  7.02408478e-02f, 3.55334729e-02f, -3.40616554e-02f, 3.68126519e-02f, 3.64922732e-02f, -3.47903483e-02f, 1.36542439e-01f, -1.76857002e-02f, 3.64027768e-02f, -1.12333177e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.06360805e-01f, -5.19670546e-01f, -2.53680557e-01f, 2.43549436e-01f, 4.29141760e-01f, 2.17399865e-01f, 7.37992972e-02f, -7.02574663e-03f, 1.24440528e-01f, -2.45748743e-01f,
  1.04493789e-01f, -1.83568552e-01f, -2.33763725e-01f, 2.28763968e-01f, 2.63205677e-01f, -3.38638514e-01f, 2.24106744e-01f, 1.51006699e-01f, -8.66169408e-02f, 2.14890968e-02f,
  1.29440978e-01f, 2.56480157e-01f, -1.40992433e-01f, -5.09058833e-02f, 1.44436911e-01f, -2.30642393e-01f, -1.31185129e-01f, -2.68576950e-01f, -9.39755812e-02f, 1.33826107e-01f,
  6.90520853e-02f, 3.44359241e-02f, 2.89031714e-02f, -1.49530489e-02f, -2.81978920e-02f, -1.04705386e-01f, -4.41348068e-02f, -6.81856647e-02f, 3.73345874e-02f, 3.60738672e-02f,
  -1.45298183e-01f, 5.09689003e-02f, 1.31502494e-01f, 2.13862043e-02f, 6.53083399e-02f, 8.62034708e-02f, 3.70307197e-03f, 4.24088351e-02f, -4.40843627e-02f, -1.28803447e-01f,
  -8.04609060e-02f, -6.48515895e-02f, 1.07396580e-02f, -1.18204780e-01f, -9.83276870e-04f, -2.12267172e-02f, -1.47800267e-01f, -6.78496286e-02f, -8.28069970e-02f, 2.73243729e-02f,
  -9.07976627e-02f, 1.08911190e-02f, -2.63789459e-03f, 5.83622642e-02f, 5.83258569e-02f, -2.17596423e-02f, -1.34447729e-02f, -5.39278239e-02f, -6.87385872e-02f, 3.46708521e-02f,
  -2.93452255e-02f, 4.02867310e-02f, -1.11279916e-02f, 2.83183586e-02f, -9.65806283e-03f, 4.59399931e-02f, -3.65097970e-02f, -1.14478590e-02f, 7.75551945e-02f, 2.72326376e-02f,
  -5.72223738e-02f, 5.62497228e-02f, 1.29850833e-02f, -1.12271108e-01f, 3.07271834e-02f, 5.83784655e-02f, -3.22672203e-02f, 1.83013342e-02f, -3.53518836e-02f, -4.23550121e-02f,
  -9.09275785e-02f, -2.68475294e-01f, -5.54906018e-02f, 3.25365216e-02f, -3.14303935e-02f, 2.97029056e-02f, -1.54026207e-02f, 1.48231573e-02f, -6.13529189e-03f, -2.97354367e-02f,
  9.89025086e-03f, -5.92812970e-02f, -5.51893339e-02f, 8.81544426e-02f, -1.14369821e-02f, 3.49499770e-02f, -4.97598276e-02f, 2.08851928e-03f, 1.22743342e-02f, -2.31374428e-02f,
  -7.37598091e-02f, -1.47361860e-01f, 4.24938202e-02f, 9.79404449e-02f, 1.25716776e-02f, -6.69641867e-02f, -1.28603131e-01f, -1.05406819e-02f, -1.22832157e-01f, 1.04461201e-02f,
  2.62592703e-01f, -3.65718991e-01f, -1.14978619e-01f, 7.86038339e-02f, -8.82467777e-02f, -4.51734781e-01f, -4.92367744e-01f, 4.50464226e-02f, 2.28977147e-02f, -4.71146256e-01f,
  -2.34096512e-01f, 1.00861460e-01f, -2.68853039e-01f, 2.13923901e-01f, 2.60013491e-01f, -8.16526860e-02f, 1.48447409e-01f, 9.40150321e-02f, 1.71432570e-01f, -2.49789804e-02f,
  1.53161362e-01f, 2.60168344e-01f, 3.29319209e-01f, 1.56768441e-01f, 1.64873645e-01f, 2.21294194e-01f, 1.46440461e-01f, -2.22529285e-02f, 1.25815555e-01f, 2.25038841e-01f,
  -7.54891187e-02f, 8.38696957e-02f, 7.62501061e-02f, 1.08314954e-01f, 1.85412262e-02f, -1.01286322e-01f, -6.21210858e-02f, 3.71607989e-02f, 1.27194613e-01f, 5.98478094e-02f,
  8.99964198e-03f, 7.51049742e-02f, 8.48673955e-02f, 1.38415352e-01f, -7.98724368e-02f, 3.28382477e-02f, 8.99997801e-02f, -3.13507020e-02f, -6.94242492e-02f, 2.64212936e-02f,
  -1.77665308e-01f, -4.22675014e-02f, -6.00051098e-02f, 5.50444983e-02f, -6.84020519e-02f, -2.34382059e-02f, 4.68630269e-02f, 1.73967015e-02f, -1.40908942e-01f, 1.14339828e-01f,
  1.07185982e-01f, -2.09701136e-02f, -9.52116251e-02f, 8.39590728e-02f, -6.02759607e-02f, 8.29594117e-03f, -1.32406754e-02f, -2.85238512e-02f, 1.50125455e-02f, -1.08337142e-01f,
  -6.70097470e-02f, 5.74668422e-02f, 4.35273871e-02f, -1.36358187e-01f, -6.08009771e-02f, 1.88572109e-01f, -6.89282566e-02f, -4.40656170e-02f, -1.15795070e-02f, 7.87029509e-03f,
  1.23246588e-01f, -3.87970768e-02f, 1.64917838e-02f, 8.94945860e-02f, 1.88143123e-02f, -9.58380997e-02f, 3.86337824e-02f, 1.58635322e-02f, -3.40471603e-02f, 3.22015807e-02f,
  -8.77902750e-03f, -2.62143519e-02f, -4.92240451e-02f, 2.77714542e-04f, -7.37245753e-02f, -7.90037513e-02f, 1.25382887e-02f, 1.00470193e-01f, -3.54215875e-02f, 7.46362731e-02f,
  1.38959466e-02f, 2.42090095e-02f, -7.70898610e-02f, 8.93296897e-02f, 9.38199461e-02f, -1.06399417e-01f, -4.55856062e-02f, 3.20716277e-02f, 1.27501767e-02f, 1.08336806e-01f,
  -1.07049011e-02f, -5.49244247e-02f, -7.50663131e-02f, -5.66536225e-02f, -5.25075383e-02f, -3.49158831e-02f, -6.65385500e-02f, -3.33920456e-02f, 4.34190929e-02f, -1.12244122e-01f,
  -1.83435991e-01f, -6.09534308e-02f, -2.78450966e-01f, -4.81553376e-01f, 7.24563748e-02f, -2.67426461e-01f, -3.37642610e-01f, -1.36961639e-01f, -1.24824539e-04f, 9.08313766e-02f,
  -7.57867470e-02f, -3.45762037e-02f, 2.35720634e-01f, -3.00979525e-01f, -2.54456401e-01f, -2.92076971e-02f, -5.07078886e-01f, -2.33512223e-01f, -7.36527368e-02f, -2.04635069e-01f,
  -7.53814057e-02f, -2.57322878e-01f, -2.75256306e-01f, 2.17269972e-01f, -2.49755055e-01f, 3.23852077e-02f, 1.69068594e-02f, 2.35056266e-01f, -1.64602891e-01f, 4.22677621e-02f,
  -3.43418904e-02f, -1.53727108e-03f, 2.01836433e-02f, 3.18596773e-02f, -7.93430358e-02f, 6.56017009e-03f, -5.80715500e-02f, 8.20247382e-02f, -6.27511740e-02f, 3.11512337e-03f,
  8.66577774e-03f, -1.81879327e-02f, 2.99066864e-02f, 1.04818515e-01f, -5.62990410e-03f, 1.54595887e-02f, -1.45376459e-01f, 1.97229572e-02f, -1.72920001e-03f, -1.10642605e-01f,
  -8.91751349e-02f, 5.23397326e-03f, -1.02676429e-01f, -9.30169374e-02f, -2.65858918e-02f, -4.00629193e-02f, -6.07323907e-02f, 5.27269058e-02f, -4.26549762e-02f, -5.58565147e-02f,
  -4.11278047e-02f, -2.35147197e-02f, -7.53448904e-02f, 8.24928880e-02f, 3.10104396e-02f, 3.02624349e-02f, 8.09949040e-02f, 9.91901383e-02f, 2.10357923e-02f, -5.69798648e-02f,
  1.14367073e-02f, 3.81134711e-02f, 5.14019877e-02f, -1.56508967e-01f, -9.40889120e-02f, -8.36793892e-03f, 8.30800533e-02f, 9.99198332e-02f, -8.68379921e-02f, 2.45914217e-02f,
  -1.08182579e-02f, -7.86371604e-02f, 6.43310770e-02f, -1.05464712e-01f, -3.95413265e-02f, -3.83741385e-03f, 7.24986643e-02f, -8.51061791e-02f, 5.47947502e-03f, -5.88502772e-02f,
  -6.06687181e-02f, 1.64913889e-02f, 1.05230920e-01f, 7.20859459e-03f, 2.70777643e-02f, -3.79360244e-02f, -5.78779429e-02f, -6.40757307e-02f, -6.78982213e-02f, -4.86494862e-02f,
  -2.35931911e-02f, 8.92541036e-02f, -1.42743677e-01f, -7.66897574e-02f, 1.67937309e-03f, -3.14448923e-02f, -4.02292609e-02f, 4.90429439e-02f, -3.73017117e-02f, 2.98089925e-02f,
  -1.36086447e-02f, 1.52124420e-01f, -4.88243997e-02f, -4.10778597e-02f, -4.65705469e-02f, 3.15504484e-02f, 4.37843576e-02f, 8.15640166e-02f, -8.54185894e-02f, 8.06939695e-03f,
  1.30013123e-01f, -2.65893877e-01f, -5.09742141e-01f, -1.57248244e-01f, 3.14846128e-01f, 3.14321846e-01f, 1.66242421e-01f, -3.75479497e-02f, -3.34320992e-01f, -1.36393495e-02f,
  2.62934446e-01f, -8.93521234e-02f, 1.85940526e-02f, 3.07283718e-02f, 9.52200592e-02f, -2.45806694e-01f, 1.53238162e-01f, 1.22723304e-01f, -2.18907014e-01f, 7.62868971e-02f,
  -8.05395022e-02f, 2.11855203e-01f, -1.75878122e-01f, 6.04679547e-02f, 1.97123036e-01f, -8.70209485e-02f, 2.74857283e-01f, 4.38213199e-02f, 2.88483232e-01f, 1.56718880e-01f,
  -3.04361507e-02f, -1.42276153e-01f, -1.04156964e-01f, -8.60420614e-02f, 1.23480320e-01f, 6.86871186e-02f, 1.23458588e-02f, 4.06473391e-02f, 3.35776393e-04f, -6.94836900e-02f,
  1.12651385e-01f, 2.31807400e-02f, -5.44345602e-02f, 2.58869957e-02f, -2.33337395e-02f, -2.05203285e-03f, 8.69396515e-03f, -1.08529598e-01f, -6.65572956e-02f, -5.38732111e-03f,
  -1.27271026e-01f, 2.08918750e-02f, -5.28413511e-04f, -3.49573605e-02f, -4.14928943e-02f, -3.21334153e-02f, -6.61425516e-02f, 4.17146087e-02f, -9.71794352e-02f, 6.99637756e-02f,
  1.26315638e-01f, -4.20497060e-02f, 1.66466292e-02f, -8.74294154e-03f, -3.45966555e-02f, -3.70924808e-02f, 8.61147344e-02f, 1.47660011e-02f, -1.81026254e-02f, 5.84746860e-02f,
  2.67814230e-02f, 9.42232162e-02f, 3.01338062e-02f, 8.24719202e-03f, 6.20175861e-02f, -8.73551965e-02f, 4.72877361e-02f, 6.31440952e-02f, 7.34031424e-02f, -3.21588852e-02f,
  2.61345897e-02f, -7.75502471e-04f, 8.47496018e-02f, 3.18194255e-02f, -1.15173897e-02f, -4.68355492e-02f, 2.94115897e-02f, 1.13568399e-02f, -1.25448182e-01f, 7.84701854e-02f,
  1.01453327e-01f, -3.08804344e-02f, -7.53491605e-03f, -4.57543619e-02f, -9.93509144e-02f, 1.33242875e-01f, -1.23110645e-01f, -9.45802629e-02f, 6.55163080e-02f, 4.70871776e-02f,
  1.63863361e-01f, 1.67382173e-02f, 2.87197940e-02f, 6.10194132e-02f, -5.30767441e-02f, 7.60954842e-02f, -9.07601863e-02f, 1.38006937e-02f, 9.78205875e-02f, 2.71026343e-02f,
  1.70721319e-02f, 1.65180579e-01f, -7.71533251e-02f, 5.15510328e-03f, 5.17548546e-02f, 8.08461159e-02f, 9.97019708e-02f, 4.86081019e-02f, 7.69135654e-02f, -9.54181030e-02f,
  9.14077312e-02f, -3.40971351e-01f, 4.06087428e-01f, -1.56731039e-01f, 2.71608293e-01f, 1.87838882e-01f, 9.49080661e-02f, 8.53954032e-02f, 4.35314775e-02f, -4.19906586e-01f,
  -1.92151234e-01f, -2.47587472e-01f, 1.55147016e-01f, -2.34392166e-01f, 3.91549885e-01f, 2.32756957e-01f, -4.92048785e-02f, -1.55398861e-01f, 1.53753385e-01f, -3.40719819e-02f,
  9.58936885e-02f, -2.45588630e-01f, 2.98317194e-01f, -1.10784784e-01f, 1.06302863e-02f, -6.74767494e-02f, -1.81281403e-01f, 1.00474924e-01f, -2.51551509e-01f, 8.13110769e-02f,
  -4.08454612e-02f, -1.59257293e-01f, 5.16993999e-02f, -6.16626255e-02f, 2.98426710e-02f, -4.64973189e-02f, -6.61608502e-02f, -6.18144237e-02f, -3.75264026e-02f, 2.43503749e-02f,
  -6.69610202e-02f, 5.38671874e-02f, -4.85778823e-02f, -2.67083198e-03f, -5.04728779e-02f, -6.01506233e-02f, 9.40231532e-02f, 9.56088305e-02f, 4.80728745e-02f, 1.60397246e-01f,
  1.45381793e-01f, 5.65213263e-02f, 7.67801553e-02f, -4.93009090e-02f, 1.06826708e-01f, 9.86331701e-03f, 5.33893704e-03f, 1.91531777e-02f, -3.63480533e-03f, 5.15896361e-03f,
  3.46461795e-02f, 1.01528436e-01f, 5.52407615e-02f, -3.89000140e-02f, -5.47014959e-02f, 1.26209063e-02f, -1.03067152e-01f, -4.87257391e-02f, 1.74712576e-02f, 4.02050046e-03f,
  3.11926492e-02f, -8.55787843e-02f, 3.03540844e-02f, 5.80486730e-02f, -9.83706638e-02f, 3.91183197e-02f, -8.81323498e-03f, 4.95396107e-02f, 2.68518296e-03f, -1.01329088e-02f,
  3.69398780e-02f, 7.34423893e-03f, 1.05228841e-01f, 8.06106851e-02f, -2.47460809e-02f, 3.37813646e-02f, -1.68908332e-02f, 8.25932026e-02f, 9.36077312e-02f, 5.95084243e-02f,
  -3.32855731e-01f, -4.67927694e-01f, -6.12995140e-02f, -6.74661174e-02f, -7.56779686e-02f, -3.96542512e-02f, 3.23698856e-02f, -9.40216891e-03f, -1.21618912e-01f, 6.57893345e-02f,
  1.69729181e-02f, -1.88939273e-02f, -5.31445891e-02f, 6.71932548e-02f, -8.38834122e-02f, 6.31253235e-03f, -1.64745286e-01f, -1.88715160e-01f, -2.17576325e-01f, -7.12009668e-02f,
  -2.09609233e-02f, -4.19804119e-02f, -6.10681921e-02f, 2.59535890e-02f, -1.11853600e-01f, 5.61788818e-03f, -1.78947803e-02f, -4.54394668e-02f, 8.11800733e-02f, -1.11915193e-01f,
  -8.85109156e-02f, 7.73283513e-03f, -1.53305218e-01f, -3.24984401e-01f, 2.01085620e-02f, -3.98616731e-01f, -3.67868155e-01f, 9.17183980e-02f, -1.02582276e-01f, 8.08989257e-03f,
  -1.00625947e-01f, -2.62775682e-02f, 4.57008518e-02f, -4.84324604e-01f, -3.73830765e-01f, -1.69666961e-01f, -3.94679695e-01f, -3.13017070e-01f, 3.57582271e-02f, -4.06353809e-02f,
  -2.23059192e-01f, -6.63635135e-02f, -1.12962253e-01f, 2.45711610e-01f, -1.75753161e-01f, 2.06378028e-02f, 3.19828182e-01f, 2.46486545e-01f, -1.83713481e-01f, 4.00820263e-02f,
  -2.60844063e-02f, 6.33711293e-02f, -2.87455004e-02f, 2.90501192e-02f, 1.93904713e-02f, -1.95004623e-02f, -9.62024629e-02f, -8.24133903e-02f, -1.38248447e-02f, -6.71089217e-02f,
  1.65871873e-01f, -9.40091349e-03f, -9.60253775e-02f, 5.38147837e-02f, 2.82372860e-03f, -6.10956103e-02f, 1.07890349e-02f, -5.26453033e-02f, 9.10159480e-03f, -7.34267682e-02f,
  -6.87416121e-02f, -9.74530447e-03f, -8.02362058e-03f, 9.96384174e-02f, -7.49148652e-02f, -4.32792678e-02f, -4.13974300e-02f, 8.81040767e-02f, -8.95223841e-02f, -1.37886070e-02f,
  1.56007856e-01f, 1.02805244e-02f, 1.13694914e-01f, -5.77965155e-02f, -1.13602571e-01f, -9.50351134e-02f, -1.55717954e-01f, -4.92254086e-02f, 6.87417015e-02f, -1.04463227e-01f,
  1.37646566e-03f, 9.44675356e-02f, 1.81199890e-02f, -4.06877585e-02f, -5.44046201e-02f, 1.04420818e-01f, -1.15070611e-01f, -3.60546485e-02f, -1.60191625e-01f, -1.17170282e-01f,
  2.11227059e-01f, -4.71957959e-02f, 8.59251767e-02f, -5.71168661e-02f, -5.81237301e-02f, -9.39521589e-04f, 7.46381432e-02f, -6.82273461e-03f, 4.47816364e-02f, 7.90236611e-03f,
  -6.27341047e-02f, 2.34446883e-01f, -1.64569486e-02f, 7.00781867e-02f, -3.24529558e-02f, -3.45431175e-03f, -4.88697924e-02f, -1.01855174e-01f, 1.88329462e-02f, 4.64458205e-02f,
  7.13739246e-02f, 4.91940938e-02f, -4.98048309e-03f, -3.74245420e-02f, -1.04639255e-01f, -1.21886611e-01f, 9.02139246e-02f, 8.11993927e-02f, 2.19510086e-02f, 9.93304476e-02f,
  1.58529505e-01f, -2.82738097e-02f, 8.85203779e-02f, 4.40329500e-02f, 5.50352633e-02f, -7.69504230e-04f, -7.32810795e-02f, -4.02588621e-02f, 1.57493070e-01f, 2.02663653e-02f,
  -5.91899395e-01f, 9.49024931e-02f, 4.08280492e-01f, -2.27709487e-01f, 3.95078987e-01f, 5.49943507e-01f, 2.58617580e-01f, 1.86645910e-01f, 8.88322368e-02f, 1.57104954e-02f,
  8.09743926e-02f, -1.80088475e-01f, 1.60610661e-01f, -1.28276385e-02f, 3.13759744e-01f, 1.85359880e-01f, 1.16686873e-01f, -8.51106737e-03f, 8.85427967e-02f, -3.71152014e-02f,
  -5.76206483e-02f, 4.78943251e-02f, 1.02073275e-01f, 1.92730464e-02f, -4.88313660e-02f, -2.23589450e-01f, -1.03070840e-01f, 4.27260175e-02f, -7.18367249e-02f, 7.80164748e-02f,
  2.72354460e-04f, -2.12241426e-01f, -7.25524873e-02f, 4.87825926e-03f, 5.16460016e-02f, 6.96286038e-02f, -7.83822685e-03f, 1.77108441e-02f, -6.35435581e-02f, 4.37836498e-02f,
  1.63510591e-02f, 6.94759935e-02f, 1.04093328e-02f, 4.83383611e-02f, 1.39239745e-03f, -2.32496765e-02f, 1.00609586e-01f, 1.64554939e-02f, 1.93148926e-02f, 5.23350574e-02f,
  1.29605442e-01f, 7.22587481e-02f, 1.76655389e-02f, -2.05877088e-02f, 7.35950619e-02f, -4.15965989e-02f, -5.99880740e-02f, 8.10656995e-02f, 3.36705931e-02f, 7.96532333e-02f,
  -1.27174333e-01f, 5.46633713e-02f, 7.75921047e-02f, 1.64882410e-02f, -3.75000462e-02f, -3.39632221e-02f, -7.51399919e-02f, 1.48298815e-02f, -7.85296503e-03f, 4.79285866e-02f,
  -7.53603056e-02f, 1.22158732e-02f, -4.32973206e-02f, -5.03077265e-03f, -5.99147789e-02f, -9.30304602e-02f, -4.63154800e-02f, -4.35121879e-02f, -3.28925103e-02f, -2.90101897e-02f,
  -8.76647308e-02f, -5.79124317e-02f, 1.60415396e-02f, -7.65532628e-02f, 4.91928160e-02f, 5.81518114e-02f, 1.92894712e-02f, 4.13230360e-02f, 1.34390108e-02f, -5.24577796e-02f,
  1.95534199e-01f, 5.17514572e-02f, 5.01232371e-02f, -9.17064771e-02f, -4.18176763e-02f, 9.75683257e-02f, 3.42441201e-02f, 5.27702644e-02f, -1.11250707e-03f, 2.12233383e-02f,
  1.51168173e-02f, -2.04153042e-02f, 4.75943945e-02f, -6.54107183e-02f, -6.28813580e-02f, 1.69662401e-01f, -2.64580622e-02f, -4.59631532e-02f, -1.89968515e-02f, -3.92562710e-02f,
  -8.30840915e-02f, -1.22899428e-01f, -6.27283603e-02f, -5.33760749e-02f, -7.97031168e-03f, -5.13964221e-02f, -4.50190492e-02f, -7.36026932e-03f, 3.24181803e-02f, 7.54065216e-02f,
  -3.27183694e-01f, 1.73463270e-01f, -1.45016415e-02f, 2.44928628e-01f, -1.26814544e-01f, -3.87090504e-01f, -2.78219610e-01f, 2.39371091e-01f, -3.26348633e-01f, 2.59319693e-02f,
  6.79959217e-03f, -1.68465242e-01f, 1.39420673e-01f, 2.31522217e-01f, 1.71916455e-01f, 7.03737214e-02f, 1.48432240e-01f, -4.35991697e-02f, 1.09720968e-01f, 1.61220983e-01f,
  2.07565710e-01f, 2.26544708e-01f, 3.79793167e-01f, 2.45544583e-01f, 3.14195491e-02f, 1.44450516e-01f, 2.04035252e-01f, 1.25167981e-01f, 2.25625589e-01f, -4.27456424e-02f,
  -7.06071686e-03f, 7.84693062e-02f, 1.19399548e-01f, -1.36554733e-01f, 1.06048174e-01f, -3.19075212e-02f, -4.26364094e-02f, 1.08625283e-02f, 8.40732921e-03f, 2.84020975e-02f,
  -1.49670124e-01f, 7.88088962e-02f, -5.65306954e-02f, -3.33492383e-02f, -1.11521862e-01f, -6.50485680e-02f, 2.51443516e-02f, -7.99169242e-02f, 8.35792571e-02f, 2.30123606e-02f,
  3.99240814e-02f, -1.52434809e-02f, -7.86248073e-02f, -7.02282861e-02f, 1.69369224e-02f, -1.17663264e-01f, -6.55697286e-02f, 2.18000114e-02f, -4.72168438e-02f, -7.30829835e-02f,
  5.23592345e-03f, -1.20152481e-01f, 8.01356696e-03f, -6.40213266e-02f, -1.77306235e-02f, 2.93931384e-02f, -3.96445803e-02f, -3.25382650e-02f, -2.29011476e-02f, 5.41020334e-02f,
  -2.98108961e-02f, 4.15890031e-02f, -1.36594120e-02f, -9.17731524e-02f, 2.96076257e-02f, -6.37523606e-02f, 1.52656587e-03f, 4.70033800e-03f, 1.93584356e-02f, 1.51998838e-02f,
  -6.01828806e-02f, -3.47208907e-03f, 6.82910010e-02f, -6.10299967e-02f, -6.79912865e-02f, 2.48758774e-02f, -4.57786508e-02f, 2.00029090e-02f, 2.00410280e-02f, 9.61478241e-03f,
  1.49768278e-01f, 3.67072999e-01f, -2.72720903e-02f, -1.32423267e-01f, 3.91809344e-02f, 2.08292343e-02f, 2.33276337e-02f, 9.06923600e-03f, -4.22066972e-02f, -1.01449620e-02f,
  3.69004905e-02f, -4.62626517e-02f, 1.38085068e-03f, -7.07187355e-02f, 4.92752679e-02f, 1.84883084e-02f, -3.97735648e-03f, -4.51859832e-02f, 4.00477313e-02f, 2.02311091e-02f,
  -2.16574445e-02f, -9.10978168e-02f, 9.32150856e-02f, -1.10697143e-01f, -7.24171102e-02f, -5.11994623e-02f, -7.63752982e-02f, -3.16602439e-02f, 4.63251397e-02f, 6.51107505e-02f,
  1.17484219e-01f, 7.90890008e-02f, -4.64595318e-01f, -1.21292733e-01f, -5.49152419e-02f, 1.82309940e-01f, 3.69090229e-01f, 4.58524376e-02f, 2.11240768e-01f, 4.67599839e-01f,
  -1.22039214e-01f, 1.67984679e-01f, 8.34385678e-02f, 8.84057283e-02f, -1.30094603e-01f, 3.91382016e-02f, 2.65472680e-01f, 2.02103391e-01f, 1.10972010e-01f, 1.55228510e-01f,
  -6.08659238e-02f, 2.03517362e-01f, -2.89624572e-01f, 7.85296485e-02f, -1.72846299e-02f, -9.81604010e-02f, 2.12314744e-02f, -7.74720088e-02f, -4.94448915e-02f, 3.01734661e-03f,
  -4.88775447e-02f, 1.40218124e-01f, -1.01273023e-01f, 1.15121081e-02f, -8.43378380e-02f, -5.29002622e-02f, -5.62560335e-02f, -9.63424444e-02f, -6.01051077e-02f, 3.76680531e-02f,
  1.27329439e-01f, -4.44598868e-02f, 3.34487110e-02f, 5.24142385e-02f, -5.38727567e-02f, -4.29864228e-02f, -1.28070742e-01f, -5.15611395e-02f, 3.04087792e-02f, 1.45236347e-02f,
  -7.80855194e-02f, -9.90658104e-02f, -5.67624159e-02f, -3.81426960e-02f, -9.48949084e-02f, 5.70919253e-02f, -2.43688896e-02f, -6.91065565e-02f, 1.61235422e-01f, 5.37468120e-02f,
  1.05741799e-01f, 4.72857654e-02f, -5.50759025e-03f, -3.52151990e-02f, 4.45674844e-02f, -1.25608101e-01f, -3.44541180e-03f, -2.01985110e-02f, -7.97483996e-02f, 5.83627336e-02f,
  -7.63225034e-02f, -4.26059552e-02f, 6.34501278e-02f, 6.41946122e-02f, 7.67544210e-02f, 3.84363569e-02f, 2.35190783e-02f, 4.91932891e-02f, -6.70307130e-02f, -8.52862373e-02f,
  -4.28405292e-02f, -3.38338241e-02f, 4.72935811e-02f, 3.57119814e-02f, 1.55667011e-02f, -9.53966081e-02f, 1.10613741e-01f, -1.54866185e-03f, -3.46767530e-02f, 7.26260245e-02f,
  1.02801032e-01f, 3.48982722e-01f, 1.24116682e-01f, 8.07790011e-02f, 1.04855999e-01f, -6.94547221e-03f, 6.91455305e-02f, 3.58574316e-02f, -5.80433048e-02f, 8.15950260e-02f,
  8.78657252e-02f, -1.86801869e-02f, 9.82551873e-02f, -1.25916172e-02f, 2.54294984e-02f, 9.19813067e-02f, 1.18369728e-01f, -5.25833331e-02f, -3.43606696e-02f, 8.19308385e-02f,
  -2.52704117e-02f, 5.84761128e-02f, 3.51098762e-03f, 4.70170416e-02f, 1.02086522e-01f, -2.00572424e-02f, 4.82362919e-02f, -3.31767239e-02f, 3.16478536e-02f, -2.24465542e-02f,
  4.01475817e-01f, 4.02729921e-02f, 3.21878195e-01f, -1.44977584e-01f, -2.17655838e-01f, 1.24440111e-01f, 3.80348474e-01f, -2.80207038e-01f, -4.85334843e-01f, 1.38431676e-02f,
  -6.55670762e-02f, 3.91276211e-01f, 2.77993113e-01f, -3.97714600e-02f, 1.38684362e-01f, -1.02348290e-02f, -2.91722506e-01f, 1.09713808e-01f, -1.53699487e-01f, 9.69409794e-02f,
  5.70975989e-02f, -9.33898389e-02f, 8.94483924e-02f, -3.57893705e-02f, 1.62436098e-01f, 7.45263789e-03f, -1.92241430e-01f, 1.99844852e-01f, -1.20905573e-02f, -7.00054923e-03f,
  1.30682662e-01f, -6.85483366e-02f, 5.77454008e-02f, 8.66136178e-02f, -6.35540709e-02f, 1.15470886e-01f, 2.68175244e-01f, 9.84812528e-02f, 2.87972037e-02f, -2.55516469e-02f,
  1.82779774e-01f, -4.93753515e-03f, -4.64978069e-02f, 3.45508335e-03f, -2.65844632e-02f, -6.74246848e-02f, -1.59484565e-01f, 3.79799455e-02f, 1.65733993e-02f, 1.21610209e-01f,
  1.19940415e-01f, 3.65944440e-03f, 1.19668609e-02f, -7.84630403e-02f, -7.77814239e-02f, -2.27695301e-01f, 1.52251959e-01f, 9.22360718e-02f, -3.23167928e-02f, -9.56261978e-02f,
  1.58716664e-02f, -3.26260552e-02f, 4.34454195e-02f, 1.36829736e-02f, 1.88201610e-02f, -4.74771857e-02f, -3.60384472e-02f, -8.73492137e-02f, -6.37110472e-02f, 6.09274469e-02f,
  -3.51671390e-02f, 1.23011125e-02f, 9.41791385e-03f, -5.87206818e-02f, -1.39793633e-02f, 2.65051425e-02f, 1.90125406e-01f, 4.27983999e-02f, -3.43848728e-02f, 2.59678531e-02f,
  -8.65720212e-02f, 8.63127634e-02f, 1.19825965e-02f, -4.36207913e-02f, 5.09097129e-02f, 3.69069129e-02f, -6.79765921e-03f, 6.49460685e-03f, -7.05220401e-02f, 1.38792977e-01f,
  -7.24679008e-02f, -8.14708546e-02f, -6.86091334e-02f, 7.41982833e-02f, 3.84597033e-02f, 1.13056572e-02f, 4.82490733e-02f, -1.01377800e-01f, -1.46714240e-01f, -1.37069691e-02f,
  7.62464032e-02f, 1.71762276e-02f, 6.64968416e-02f, 2.72482652e-02f, -1.94520857e-02f, -7.87527561e-02f, 1.23054855e-01f, 3.69836949e-02f, -5.01569919e-03f, 2.24799383e-02f,
  -2.17565391e-02f, 1.08641043e-01f, 9.63487849e-02f, 1.75013375e-02f, 2.24612635e-02f, 2.67006774e-02f, -3.58757079e-02f, 8.20504278e-02f, 9.12191421e-02f, -8.47599003e-03f,
  9.88314897e-02f, -4.02638972e-01f, -1.38314918e-01f, 2.75301367e-01f, 2.55610943e-01f, -5.65308779e-02f, 4.94008288e-02f, 1.25039220e-01f, 5.64294048e-02f, -1.81155369e-01f,
  8.24355483e-02f, -3.54339689e-01f, -3.25766891e-01f, -3.15444022e-01f, -2.03700349e-01f, -3.88162643e-01f, -2.20245067e-02f, -1.35454118e-01f, -3.13086323e-02f, 1.56565309e-01f,
  9.60514396e-02f, -7.50700459e-02f, -8.27746764e-02f, 8.36772919e-02f, 2.83717699e-02f, 3.66016835e-01f, 2.44171754e-01f, 4.65018163e-03f, 1.92268804e-01f, -1.89624220e-01f,
  -7.32386485e-02f, -8.34629610e-02f, -5.99900782e-02f, -9.17526707e-02f, 1.50311261e-01f, 1.48360997e-01f, 2.80483942e-02f, -3.54429632e-02f, -1.61908381e-02f, -7.79847577e-02f,
  -4.54444438e-02f, -1.52880484e-02f, -6.13904446e-02f, 3.64268310e-02f, 3.27422731e-02f, -5.47180027e-02f, -5.20321205e-02f, 6.53460324e-02f, -5.11611216e-02f, -1.46874428e-01f,
  4.43007201e-02f, 4.15008776e-02f, 7.90520310e-02f, -1.10305601e-03f, 8.96750167e-02f, 4.27092575e-02f, 3.01446728e-02f, 4.51785401e-02f, 2.59848535e-02f, 1.00735361e-02f,
  -3.86388823e-02f, 3.24238539e-02f, -9.61311534e-03f, -7.45632574e-02f, -9.52967815e-03f, -9.42305010e-03f, -1.19667470e-01f, -8.81739892e-03f, 5.95818087e-02f, -8.57776403e-02f,
  3.86775658e-02f, -1.02574617e-01f, 9.01348237e-03f, 1.17275689e-03f, 1.11687221e-01f, -4.34197336e-02f, 2.88692024e-02f, 4.52427054e-03f, 1.26363099e-01f, -3.39960568e-02f,
  -1.75114170e-01f, 5.53183397e-03f, -2.55176462e-02f, -2.76723765e-02f, -6.51817992e-02f, 4.50937487e-02f, 1.08918287e-02f, -6.71949163e-02f, 1.10237792e-01f, -5.20797595e-02f,
  -4.75035086e-02f, -5.14307469e-02f, 6.14688881e-02f, -7.20636547e-02f, -7.19694570e-02f, 5.05808508e-03f, -5.92144914e-02f, -6.70909062e-02f, -1.10597856e-01f, -5.59958862e-03f,
  2.60030091e-01f, 1.20900549e-01f, 6.05841838e-02f, 2.43394915e-03f, -5.65463863e-03f, 2.18259785e-02f, -9.87062324e-03f, 5.70580773e-02f, 1.37268156e-01f, 4.12724465e-02f,
  6.98969290e-02f, 8.46624151e-02f, 5.68282157e-02f, 1.01013510e-02f, 4.67493050e-02f, 1.00872032e-01f, 9.24750566e-02f, 1.22410655e-01f, -1.99193619e-02f, -4.66879047e-02f,
  1.04958162e-01f, 1.04087733e-01f, -9.44541767e-02f, 1.29257828e-01f, -2.56099373e-01f, 1.28240272e-01f, 3.23716313e-01f, -1.41460851e-01f, 4.27589476e-01f, 9.90848318e-02f,
  -1.03328891e-01f, 1.23181216e-01f, 1.05398603e-01f, -8.19326341e-02f, 3.04873884e-01f, 1.94816902e-01f, 1.60250261e-01f, 6.01672195e-02f, 2.20712963e-02f, -9.12728347e-03f,
  2.01785136e-02f, -6.47912547e-02f, -2.25883976e-01f, -1.07813925e-01f, -2.67014265e-01f, -1.52829634e-02f, -2.18014911e-01f, -1.03891283e-01f, -1.86519533e-01f, -1.57009270e-02f,
  5.26653901e-02f, 1.30808026e-01f, -1.08087011e-01f, 3.81662548e-02f, 4.19788063e-02f, 1.00860139e-02f, -5.26506416e-02f, -2.09957808e-02f, 5.54185472e-02f, 8.70720968e-02f,
  3.08088250e-02f, -7.68219754e-02f, 2.50597317e-02f, 6.82035610e-02f, -5.68467267e-02f, -1.64492670e-02f, -6.83723763e-02f, -1.83835849e-01f, -2.79857088e-02f, -2.09032193e-01f,
  5.74587286e-02f, -1.26648501e-01f, -7.58738741e-02f, 4.60721515e-02f, 2.51411963e-02f, -4.75581363e-02f, 1.11629702e-01f, -6.81000873e-02f, -2.97890007e-02f, 6.34180754e-02f,
  1.78610776e-02f, 1.09561823e-01f, 2.32656207e-02f, -8.38803351e-02f, 2.64510475e-02f, -8.33477601e-02f, 1.50021762e-02f, -6.07186034e-02f, 5.71471155e-02f, -2.52147391e-02f,
  -2.90533919e-02f, -4.19005267e-02f, 3.37707661e-02f, -8.28099623e-03f, -1.08259241e-03f, 8.23888555e-02f, -1.12169951e-01f, 2.65938304e-02f, 1.03268690e-01f, -1.73389167e-02f,
  3.46117504e-02f, 1.60618350e-01f, 9.06280279e-02f, 1.52246803e-02f, 2.12729303e-03f, 5.90779004e-04f, -2.58548856e-02f, 4.45701927e-03f, -2.12646206e-03f, -4.23578471e-02f,
  9.01526213e-02f, 3.77366722e-01f, 7.37619102e-02f, 5.08785574e-03f, -3.12765688e-02f, -4.16496061e-02f, 1.04760975e-02f, -9.63373780e-02f, 1.15509808e-01f, 5.60450107e-02f,
  -1.46899950e-02f, 7.64390379e-02f, -6.34052902e-02f, -5.07222861e-02f, 1.86622441e-02f, -1.16162689e-03f, 1.18587799e-01f, 1.28724650e-01f, 8.39694962e-02f, -9.27059874e-02f,
  -1.01820797e-01f, 1.65271819e-01f, 9.15201306e-02f, 9.74325929e-03f, -6.23836592e-02f, -1.63073037e-02f, -1.32055711e-02f, 1.00191114e-02f, -6.01543337e-02f, 1.20916508e-01f,
  -3.44487041e-01f, 4.45310384e-01f, -8.05825889e-02f, -4.66120809e-01f, 2.44891886e-02f, -1.09335572e-01f, -4.66443181e-01f, 6.61151111e-02f, -1.42181993e-01f, -1.49258777e-01f,
  -1.23848684e-01f, 9.96791869e-02f, 6.44845068e-02f, -2.90945262e-01f, 3.99614200e-02f, 7.53891692e-02f, -3.57904792e-01f, -2.64695555e-01f, 1.36356130e-01f, -2.07915679e-01f,
  -5.82711734e-02f, -2.67130196e-01f, -7.23538175e-02f, 1.91687867e-01f, -2.09053844e-01f, -6.77761808e-02f, -2.04311326e-01f, 1.17072441e-01f, -2.15142891e-01f, 1.68035865e-01f,
  -3.75251740e-01f, -1.76034406e-01f, -2.49091804e-01f, -7.00441748e-02f, -2.09017158e-01f, -3.63691971e-02f, -1.02724761e-01f, -3.71299461e-02f, -1.32370099e-01f, -2.55384538e-02f,
  -1.40491277e-02f, 2.99979262e-02f, 3.92761687e-03f, 1.75328583e-01f, -6.74933046e-02f, 1.64510775e-02f, 4.40462828e-02f, -7.49071240e-02f, 4.55440721e-03f, 9.36223716e-02f,
  8.12500045e-02f, -8.71542376e-03f, -1.63772970e-01f, -6.18361123e-02f, -8.08412116e-03f, 5.67915989e-03f, -8.64958987e-02f, -2.45952401e-02f, 3.55032608e-02f, 4.71742749e-02f,
  2.32945234e-02f, -1.15614980e-01f, 1.03752478e-03f, -5.99177927e-02f, 4.69544642e-02f, 3.16593423e-02f, 3.09879426e-02f, -6.43052980e-02f, 2.03446597e-02f, -2.00651996e-02f,
  -3.92733365e-02f, -5.24283275e-02f, -4.74364311e-03f, -4.10123765e-02f, 2.56151333e-02f, -3.03714238e-02f, -1.64982434e-02f, -4.57581654e-02f, 1.20552801e-01f, 2.77018100e-02f,
  1.27204892e-03f, 3.17500047e-02f, -6.93814224e-03f, 3.99194919e-02f, -1.95812434e-02f, 5.34927845e-02f, 4.89349514e-02f, 1.36956456e-03f, -2.01435238e-02f, -6.62682801e-02f,
  -3.49395871e-01f, -2.89860040e-01f, -1.35888264e-01f, 1.36620449e-02f, -9.41966008e-03f, -2.80005652e-02f, -2.87910979e-02f, 4.38095480e-02f, -3.25948074e-02f, -3.05722263e-02f,
  -1.74592342e-02f, -7.83339813e-02f, -2.15426721e-02f, 3.70248891e-02f, 5.56416512e-02f, -3.36284153e-02f, -1.48103118e-01f, 5.95097011e-03f, -1.05989203e-01f, 7.79558495e-02f,
  -4.10223939e-02f, -1.58145279e-02f, 1.44062405e-02f, 3.65844555e-02f, 2.65780520e-02f, -1.30952284e-01f, 4.75143790e-02f, 1.22705497e-01f, -2.30452437e-02f, 6.47451123e-03f,
  1.86294958e-01f, -3.71123850e-01f, -9.64746997e-02f, -1.76552609e-01f, -4.36292514e-02f, -2.82293916e-01f, 1.58818930e-01f, -4.18651491e-01f, -3.29188675e-01f, -2.93224841e-01f,
  -7.63415843e-02f, 6.14542365e-02f, 4.24762815e-01f, -3.09590250e-01f, 4.70035285e-01f, 3.27555209e-01f, -2.81200290e-01f, -3.84742990e-02f, -1.76593781e-01f, -3.14662993e-01f,
  1.55582209e-03f, -1.80513605e-01f, 1.48677766e-01f, -3.17706615e-01f, -1.76842377e-01f, -2.08948195e-01f, 2.33869717e-01f, 1.27808124e-01f, -3.04545015e-01f, 1.54873729e-01f,
  -8.73163044e-02f, -1.58795983e-01f, -8.94916356e-02f, -6.33261949e-02f, -5.19583002e-02f, 1.26890764e-02f, 5.49342819e-02f, 2.66520739e-01f, -4.68016490e-02f, -4.83348742e-02f,
  6.27903491e-02f, 4.68087010e-03f, -1.61373138e-01f, 9.21903774e-02f, -7.10003674e-02f, -1.38676018e-01f, -9.45777223e-02f, -3.90213132e-02f, -4.67210524e-02f, 1.70165543e-02f,
  -7.16157556e-02f, -1.23124585e-01f, -1.32698655e-01f, -4.30419669e-02f, 7.01380447e-02f, -1.55906314e-02f, -3.03803757e-03f, 1.55084491e-01f, -1.05686918e-01f, -8.61030221e-02f,
  9.33172703e-02f, 5.59160933e-02f, -1.23714199e-02f, -7.01720417e-02f, 2.19464060e-02f, -7.94200897e-02f, 7.92903304e-02f, 6.96529150e-02f, 7.47844875e-02f, -2.85601858e-02f,
  -4.36705425e-02f, -6.96395636e-02f, -5.35425059e-02f, 7.26382062e-03f, -4.67116851e-03f, 3.16416170e-03f, 5.27858362e-02f, -1.99890267e-02f, -2.91383192e-02f, -4.77933325e-02f,
  5.79870977e-02f, -1.02598615e-01f, -5.91109544e-02f, 2.27390118e-02f, -2.09170934e-02f, 5.03375567e-02f, -9.03240964e-02f, -2.40431894e-02f, -2.15671174e-02f, 1.29989624e-01f,
  1.59508530e-02f, -1.40026256e-01f, -7.70114660e-02f, -2.53062211e-02f, -7.57505791e-03f, -6.57720342e-02f, 2.61938144e-02f, -7.02599213e-02f, 1.19707631e-02f, -3.81477214e-02f,
  -9.07960609e-02f, 7.03240559e-02f, -5.35862446e-02f, 8.31369683e-02f, -4.65396158e-02f, -7.63243660e-02f, 1.49894189e-02f, -3.74230742e-02f, 3.81810330e-02f, -1.52864337e-01f,
  1.36796487e-02f, 2.62442455e-02f, 7.72320330e-02f, -1.15842009e-02f, -1.02867419e-02f, 7.64184743e-02f, -3.88108566e-02f, 1.90577749e-02f, 4.32592928e-02f, -1.31532727e-02f,
  -1.83245525e-01f, -8.00439492e-02f, 4.43536183e-03f, 3.57468456e-01f, -2.54609231e-02f, -1.36659816e-01f, -2.95439094e-01f, 1.04296505e-01f, -1.55056551e-01f, -1.32876858e-01f,
  9.00457576e-02f, -1.35460958e-01f, -5.67114390e-02f, 2.38262728e-01f, 2.33737409e-01f, -1.01021584e-02f, 2.12751478e-01f, 5.01267016e-02f, 2.60227658e-02f, 1.56114146e-01f,
  1.62383094e-01f, 1.89173445e-01f, 1.27027124e-01f, 3.97979245e-02f, 4.44866568e-02f, 1.58354014e-01f, 3.24452609e-01f, -7.02990741e-02f, 2.60535151e-01f, 5.27450033e-02f,
  -3.14217359e-02f, 1.83016464e-01f, -2.30018012e-02f, -1.47147894e-01f, 3.71955521e-02f, -1.03137895e-01f, -6.68406207e-03f, -7.83819780e-02f, -4.23836932e-02f, 8.56587663e-02f,
  2.86192484e-02f, 4.79917862e-02f, 4.39242460e-02f, 8.67352933e-02f, -9.25362781e-02f, -4.74743079e-03f, -8.56431015e-03f, -4.60440777e-02f, -4.80821580e-02f, 4.14647870e-02f,
  -2.56511290e-02f, 8.08268711e-02f, -3.31457779e-02f, 4.26734723e-02f, 8.19623247e-02f, 3.77256013e-02f, 7.15003908e-02f, 2.80543901e-02f, 3.54753882e-02f, 8.01187102e-03f,
  4.83210683e-02f, -3.32229398e-02f, -3.83971967e-02f, -1.73764682e-04f, 1.06658719e-01f, 1.13291025e-01f, -5.52535802e-02f, -3.17018516e-02f, -8.51416364e-02f, 9.25584789e-03f,
  4.44020331e-02f, 4.88294065e-02f, 8.11338648e-02f, -8.89917195e-04f, 7.52009898e-02f, -9.06996429e-02f, -7.20934421e-02f, -3.47958133e-02f, 6.92691058e-02f, -5.46881519e-02f,
  -8.39905143e-02f, 7.63068767e-03f, 4.32276214e-03f, -6.32735491e-02f, 2.84198485e-02f, -2.69903056e-02f, 2.09334210e-01f, -4.15084399e-02f, -1.34639114e-01f, 1.57249309e-02f,
  1.73056647e-01f, 4.31806654e-01f, -3.40885692e-03f, -8.19437504e-02f, 8.75365511e-02f, 2.62424797e-02f, 1.60331186e-03f, 8.10587108e-02f, 8.02548975e-02f, 1.19219072e-01f,
  1.45737469e-01f, 6.39519515e-03f, -6.23501018e-02f, 1.12729393e-01f, 1.14507616e-01f, 1.59810200e-01f, 5.45752868e-02f, 5.83071150e-02f, 8.75570923e-02f, 1.53373301e-01f,
  5.51606305e-02f, -1.41852384e-03f, -6.39842153e-02f, 3.67970951e-02f, 3.72401774e-02f, 2.81419251e-02f, -6.22450560e-02f, 5.88076264e-02f, 1.56358033e-02f, 3.95354889e-02f,
  2.41047129e-01f, 9.02128667e-02f, -4.02908415e-01f, -1.91697180e-01f, 1.96873639e-02f, -2.43863333e-02f, -7.80721903e-02f, 1.14258423e-01f, -2.37812191e-01f, 1.67528436e-01f,
  1.76403165e-01f, 4.60507348e-02f, -4.50232476e-02f, 2.28719279e-01f, 1.65102527e-01f, -2.50795573e-01f, 2.58918583e-01f, 9.54780877e-02f, -9.24117938e-02f, 2.52588093e-01f,
  2.08514612e-02f, 4.26621228e-01f, 1.50754414e-02f, 1.69082835e-01f, 1.22687332e-01f, 8.72665793e-02f, 2.52681583e-01f, -6.41568825e-02f, 3.90312135e-01f, 1.86185632e-02f,
  1.18879542e-01f, 9.84087363e-02f, 1.31015033e-02f, -6.84573874e-02f, 1.44669831e-01f, 1.71241790e-01f, -3.76169197e-02f, 4.09489311e-03f, -5.52276894e-02f, -4.79966542e-03f,
  -8.44900757e-02f, -2.64149234e-02f, -5.73308766e-02f, 6.52952269e-02f, 4.01843712e-02f, -1.66060422e-02f, -7.90278688e-02f, 1.91016588e-02f, -1.02866016e-01f, 6.08997084e-02f,
  -6.68950155e-02f, 2.00598482e-02f, -1.14069588e-01f, -1.58061117e-01f, -9.08272266e-02f, 4.69661364e-03f, 9.84567776e-02f, 1.49548771e-02f, -6.40815794e-02f, 3.04610264e-02f,
  1.25773817e-01f, -7.29505857e-03f, 4.92760316e-02f, -1.61833450e-01f, -1.18575729e-02f, -8.61728936e-02f, 2.98662353e-02f, 6.59100246e-03f, -8.34952369e-02f, 1.39854789e-01f,
  -3.82415280e-02f, -2.99374517e-02f, 7.00600669e-02f, 4.12515812e-02f, 9.12375152e-02f, 1.05230212e-01f, 1.26979975e-02f, 8.89981538e-02f, -7.69267082e-02f, -3.62336785e-02f,
  -8.46064538e-02f, 1.60761431e-01f, 5.84328584e-02f, 1.09968252e-01f, 3.56746651e-02f, -7.95841441e-02f, -1.32034644e-02f, -1.84509922e-02f, -1.18312366e-01f, -6.70785010e-02f,
  1.16097338e-01f, 2.58849412e-01f, -3.99920382e-02f, -1.09847113e-01f, -2.91946251e-02f, 2.55720709e-02f, -4.97399941e-02f, 2.58035120e-02f, 2.49196007e-03f, 1.42818270e-02f,
  1.97445035e-01f, -2.18989160e-02f, 9.11775418e-03f, -9.94031131e-02f, -7.90810883e-02f, 8.43597017e-03f, 3.37980464e-02f, -1.11207021e-02f, 4.85623106e-02f, 1.33678243e-01f,
  9.78800952e-02f, 1.82453748e-02f, -8.51375312e-02f, -2.40307361e-01f, -2.66828518e-02f, 1.01244316e-01f, 3.59318033e-02f, 1.65981259e-02f, 4.90359478e-02f, 2.42995601e-02f,
  -4.36806589e-01f, 6.51096255e-02f, -3.64664316e-01f, 2.81690150e-01f, -3.26837689e-01f, 1.91010773e-01f, 4.79161650e-01f, -1.50102735e-01f, -8.52888450e-02f, 3.98032904e-01f,
  3.40880573e-01f, -1.47767514e-01f, 3.58475268e-01f, 5.45502543e-01f, 1.20663702e-01f, 5.11179626e-01f, 3.92209023e-01f, 2.52577513e-01f, -8.84609893e-02f, -9.57544893e-02f,
  -1.74114496e-01f, 2.21493632e-01f, 2.29199022e-01f, -1.20785370e-01f, -5.35839610e-02f, -3.65767747e-01f, 1.55365601e-01f, -2.39676073e-01f, 6.90948889e-02f, -1.91512465e-01f,
  1.27565205e-01f, -1.72567397e-01f, -7.08310679e-03f, -1.14526302e-01f, -1.20634129e-02f, -4.18314449e-02f, -4.27221172e-02f, -1.33345127e-01f, -1.94968045e-01f, -4.01080362e-02f,
  -4.25443798e-02f, -4.53627901e-03f, 8.65181908e-04f, 7.72531552e-04f, -8.58225450e-02f, -7.22949877e-02f, -1.29903063e-01f, 7.51100713e-03f, -4.23955545e-02f, -1.58438191e-01f,
  -5.69898821e-02f, -1.62914470e-01f, 5.73328137e-02f, -9.91398189e-03f, -2.52473373e-02f, 8.25678743e-03f, 2.32958123e-02f, 3.18086520e-02f, -4.80667241e-02f, -1.46872178e-01f,
  -2.95081586e-02f, 2.76755169e-02f, 1.17307052e-01f, 1.53527744e-02f, 4.86293323e-02f, 6.76134080e-02f, 7.72444010e-02f, -1.00385219e-01f, -5.06066829e-02f, 8.63206238e-02f,
  -1.23751862e-03f, -1.14627026e-01f, -3.62357609e-02f, -2.50414899e-03f, 2.10692454e-03f, 9.80731025e-02f, -7.40504041e-02f, 1.27856787e-02f, -5.38587943e-03f, 2.01846361e-02f,
  2.22047139e-03f, -2.24518795e-02f, 1.96824176e-03f, 1.81269929e-01f, -1.58584192e-02f, -6.57527745e-02f, -4.54953536e-02f, 2.08458882e-02f, 5.33839464e-02f, -1.83110014e-02f,
  6.87656701e-02f, -2.32782830e-02f, 1.65258329e-02f, 8.33362248e-03f, -9.27787367e-03f, -2.85255816e-02f, 4.46864963e-02f, -2.66784672e-02f, -7.55361617e-02f, -4.37120385e-02f,
  8.70753452e-03f, 3.24601419e-02f, -2.55888011e-02f, 5.39731756e-02f, 5.32477163e-02f, 2.07076576e-02f, 6.97917268e-02f, -6.55133501e-02f, -7.00011477e-02f, -6.29322827e-02f,
  2.38012127e-03f, -1.01459950e-01f, 2.65787747e-02f, -5.00447080e-02f, -3.40919830e-02f, -8.59610438e-02f, -7.62396008e-02f, -6.16820082e-02f, -9.63531360e-02f, -4.91384342e-02f,
  -7.72752106e-01f, 4.62016344e-01f, -1.45284623e-01f, -8.53885412e-02f, -1.04419084e-03f, 2.42031455e-01f, 2.80428022e-01f, 9.52924266e-02f, 1.74736008e-01f, 2.71998525e-01f,
  1.09507069e-01f, -8.97864774e-02f, 1.75635695e-01f, 2.13882640e-01f, -1.89128548e-01f, 3.44220340e-01f, 7.13606030e-02f, 1.51431173e-01f, 1.03223354e-01f, 1.18742727e-01f,
  -1.75523739e-02f, 4.30587918e-01f, -2.40663774e-02f, 1.79130003e-01f, -1.94092765e-01f, -1.90806821e-01f, -8.52139294e-02f, 5.24302386e-02f, -1.17016084e-01f, 1.50274243e-02f,
  -4.69080389e-01f, -2.16619864e-01f, -2.24445894e-01f, -6.59028664e-02f, -1.59683377e-01f, -1.64188549e-01f, -1.12362601e-01f, -1.34960441e-02f, -3.64607461e-02f, -9.30079818e-03f,
  -1.08286887e-01f, -1.66313201e-02f, 1.50219975e-02f, 2.47955341e-02f, -7.94996992e-02f, -8.55227858e-02f, 1.12033552e-02f, -1.27367452e-02f, 5.31116016e-02f, -6.64594322e-02f,
  -8.59138593e-02f, 2.19540414e-03f, -3.58018912e-02f, 1.50937691e-01f, -2.19449968e-04f, 8.98182392e-03f, 4.88567026e-03f, -4.97118942e-02f, -6.61115348e-02f, 6.25357032e-02f,
  7.14771152e-02f, 8.58694687e-02f, 5.03432006e-02f, 3.94983180e-02f, 2.19476037e-02f, -1.45449983e-02f, -1.28435651e-02f, -7.06053749e-02f, -3.48709822e-02f, -5.74673563e-02f,
  4.27758619e-02f, -4.38257754e-02f, -1.72104593e-02f, 2.61490215e-02f, 3.45283188e-02f, -4.27033380e-02f, 2.48805266e-02f, -1.35480121e-01f, 3.52563672e-02f, -1.18020773e-01f,
  6.48534149e-02f, 1.23929001e-01f, 1.05207123e-01f, -6.53693303e-02f, -7.22570047e-02f, 7.71479309e-02f, 2.15590112e-02f, 3.97642255e-02f, -2.59755366e-02f, -6.39278144e-02f,
  6.27556518e-02f, -4.84376289e-02f, 5.74037023e-02f, -2.60232966e-02f, 2.16199849e-02f, -7.69329118e-03f, 3.39047983e-02f, -1.11893781e-01f, 6.23881742e-02f, 2.55074166e-02f,
  -3.77068408e-02f, -3.91571224e-02f, -5.20952679e-02f, 5.55337928e-02f, 4.44868430e-02f, 9.79337543e-02f, -4.06204462e-02f, 1.06561571e-01f, -4.20899875e-02f, -5.96726872e-02f,
  -4.40233573e-02f, 6.90591037e-02f, 4.21343446e-02f, 6.76064927e-04f, -6.08969927e-02f, 3.96710038e-02f, -1.00127561e-02f, -2.20844354e-02f, -1.01720117e-01f, 6.29981160e-02f,
  4.31908011e-01f, -3.68438177e-02f, -3.05576801e-01f, -2.54419651e-02f, -2.84216329e-02f, 1.51118398e-01f, -1.64097816e-01f, -7.63277113e-02f, -3.88590127e-01f, -1.22310203e-02f,
  2.65598367e-03f, 6.54084533e-02f, -3.12914610e-01f, 2.64565974e-01f, 3.57295364e-01f, -5.75396828e-02f, 1.71613485e-01f, 7.56685361e-02f, -6.73468113e-02f, -4.63857083e-03f,
  -5.77312894e-02f, 3.59939605e-01f, 1.13346186e-02f, 4.13679659e-01f, 3.03379178e-01f, 5.02536111e-02f, 8.77922401e-02f, -1.24232449e-01f, 2.26684585e-01f, 2.42934346e-01f,
  6.78346008e-02f, -8.86316076e-02f, -7.23366812e-02f, 5.86334951e-02f, -1.05597928e-01f, 1.63806453e-02f, -6.86661620e-03f, 1.55527547e-01f, -1.01041004e-01f, -1.34390324e-01f,
  2.03204602e-02f, 2.79949568e-02f, 8.76272619e-02f, -7.93575346e-02f, 1.02581933e-01f, -8.34944919e-02f, -5.65659888e-02f, -1.13233693e-01f, -1.10528000e-01f, 5.63775823e-02f,
  -7.77440146e-02f, -2.87299678e-02f, -8.56765583e-02f, 5.72655164e-02f, 1.07728103e-02f, 8.51226598e-02f, -4.37147506e-02f, -1.03817165e-01f, -3.29903513e-02f, 5.80474036e-03f,
  3.24112140e-02f, -3.47781479e-02f, 7.92453140e-02f, 1.04603088e-02f, 5.39484024e-02f, -2.52949670e-02f, 6.80804951e-03f, -5.69404028e-02f, -6.26300508e-03f, -9.11390260e-02f,
  -4.08975407e-02f, -7.22708255e-02f, -9.89211127e-02f, -5.44204749e-03f, 9.97888222e-02f, -4.39796189e-04f, 5.53327389e-02f, 9.68527719e-02f, -1.42132163e-01f, -5.69667667e-02f,
  -5.22240885e-02f, 9.75761414e-02f, 2.04427429e-02f, -9.39397961e-02f, -1.13035953e-02f, 4.49386127e-02f, 1.01170041e-01f, -2.42024027e-02f, -5.03154588e-04f, -2.96734683e-02f,
  -1.09414924e-02f, -2.73078997e-02f, -3.09249982e-02f, 5.73542006e-02f, -2.89313383e-02f, 3.76621261e-02f, -8.33208561e-02f, 1.80712610e-01f, 2.56761592e-02f, 1.22250579e-01f,
  -4.44833450e-02f, 9.12733302e-02f, -3.65982614e-02f, 6.13416471e-02f, -2.16767639e-02f, 1.38925137e-02f, -4.72386889e-02f, -6.04723357e-02f, -7.40764067e-02f, -1.24327075e-02f,
  3.38409916e-02f, 3.68831381e-02f, -2.03908868e-02f, -4.95965108e-02f, 2.09551118e-02f, -6.52118260e-03f, 1.28618941e-01f, -1.02512404e-01f, 1.28032817e-02f, -6.94597587e-02f,
  -2.45574549e-01f, -5.51574118e-02f, -2.95010835e-01f, -4.50979441e-01f, 2.27469489e-01f, -8.91067386e-02f, -1.60431296e-01f, 1.44136548e-01f, -2.04701424e-01f, 4.13871557e-01f,
  3.56200546e-01f, -1.09125927e-01f, 2.15582088e-01f, -4.23524249e-03f, -3.96403670e-01f, -1.89673096e-01f, -2.86172748e-01f, 2.18828418e-03f, -1.75290152e-01f, 2.31501479e-02f,
  -2.25396261e-01f, 8.91072676e-02f, -2.59762943e-01f, 3.57193112e-01f, 2.91941874e-02f, 1.09305978e-01f, 3.48056816e-02f, 2.77449429e-01f, 2.58674845e-02f, 5.44064157e-02f,
  6.22406416e-02f, 2.59708196e-01f, 2.35619143e-01f, 3.62248980e-02f, 1.80310439e-02f, 1.17715135e-01f, 1.62936524e-02f, 2.41525881e-02f, 4.72350121e-02f, -9.58851054e-02f,
  3.82258482e-02f, 2.49353852e-02f, -6.56645522e-02f, 5.26543818e-02f, -2.43710466e-02f, -8.16507861e-02f, -1.55302137e-01f, -1.13078944e-01f, 5.44549860e-02f, -8.90636891e-02f,
  6.43986044e-03f, -9.96688083e-02f, -7.97494873e-02f, -1.39343128e-01f, 3.04643027e-02f, 2.34651953e-01f, -2.36554258e-02f, -3.44558130e-03f, -1.30780831e-01f, -4.98994403e-02f,
  4.44757827e-02f, 4.89128940e-02f, 8.41160584e-03f, 2.65379716e-02f, 6.00417405e-02f, 1.89477485e-02f, -3.98039399e-03f, -5.76408766e-02f, -5.45702092e-02f, 8.28558579e-02f,
  -6.69265911e-03f, -8.05492625e-02f, -2.24166345e-02f, -8.87926668e-02f, -9.23765183e-05f, -2.43677758e-02f, -8.92614573e-02f, 2.56434113e-01f, -1.52830005e-01f, -9.01443586e-02f,
  4.31892416e-03f, -2.59351935e-02f, 3.18131559e-02f, 7.15223849e-02f, -1.21742683e-02f, 6.66922405e-02f, -1.40854493e-01f, -3.63142090e-03f, 3.60181890e-02f, -2.93917339e-02f,
  7.97788799e-02f, 1.43617354e-02f, 1.51226088e-01f, 2.45782454e-02f, 1.03573695e-01f, 1.21297762e-01f, 4.84278053e-03f, -5.49942628e-02f, 1.08450027e-02f, 4.12259810e-03f,
  3.52641195e-02f, -6.74095517e-03f, -1.89841818e-02f, -2.42431369e-02f, -1.16047949e-01f, 1.26850054e-01f, -2.09623519e-02f, -1.61786988e-01f, 2.71007176e-02f, -2.73589548e-02f,
  -1.74426027e-02f, 1.35568520e-02f, -7.63030350e-02f, -5.43226451e-02f, -1.44810647e-01f, 9.19255838e-02f, -5.13948351e-02f, -1.08806193e-02f, -1.07402332e-01f, -7.77408183e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.40133241e-01f, 1.66869491e-01f, 3.66163224e-01f, 3.22298706e-01f, 4.35444534e-01f, 4.43859607e-01f, 3.43829155e-01f, 1.06939726e-01f, 3.80399644e-01f, 2.43535265e-01f,
  1.89584032e-01f, 2.92038232e-01f, 2.72304922e-01f, 1.00779617e-02f, 2.57146150e-01f, 1.64036810e-01f, 1.82920337e-01f, 4.37107861e-01f, 1.23770848e-01f, 2.68445402e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.41187057e-01f, 1.50776029e-01f, -1.37431741e-01f, -7.60175437e-02f, -1.07801728e-01f, 1.72721878e-01f, -4.54993099e-01f, 1.45132393e-01f, 1.82598252e-02f, 2.61496931e-01f,
  4.26076539e-02f, 4.32807505e-01f, 3.28729719e-01f, 5.83633967e-03f, -5.51273748e-02f, 2.06870258e-01f, -2.84822118e-02f, -6.35930970e-02f, -6.96764141e-03f, -4.20515299e-01f,
  1.01956934e-01f, -1.25492048e-02f, 1.83319494e-01f, 2.96676397e-01f, 4.71069338e-03f, 1.65467545e-01f, -7.62618631e-02f, -6.26164675e-02f, -1.78231642e-01f, -1.66305840e-01f,
  3.47147524e-01f, -1.42098606e-01f, 1.80789158e-02f, -1.47097290e-01f, 9.97977033e-02f, -4.72944453e-02f, -2.68658519e-01f, -2.41125166e-01f, 1.90342620e-01f, -7.51516521e-02f,
  1.55324876e-01f, -7.83390030e-02f, -5.54702505e-02f, -6.83543459e-02f, 2.39545349e-02f, 2.90337980e-01f, 3.83744597e-01f, 1.20169520e-02f, 1.73954114e-01f, 2.80369163e-01f,
  -4.78393584e-02f, 1.20458081e-02f, -3.49113941e-01f, -1.39235184e-01f, -3.17528062e-02f, -3.76353741e-01f, 4.13464308e-01f, -3.91488761e-01f, -1.64271638e-01f, -2.32482195e-01f,
  -2.00292856e-01f, -1.50940046e-01f, 1.51159227e-01f, 1.33539721e-01f, 7.09244162e-02f, 1.05637185e-01f, 9.41333696e-02f, 1.32590309e-01f, 9.56512913e-02f, -3.79948243e-02f,
  1.14390358e-01f, -8.59215576e-03f, -8.85730907e-02f, 1.20060751e-02f, 1.42580092e-01f, -2.34912202e-01f, -2.78677881e-01f, -2.80988067e-01f, 1.36438102e-01f, 1.77715302e-01f,
  -5.54527938e-02f, 1.73311263e-01f, 1.62971944e-01f, -9.90255773e-02f, 1.15005881e-01f, 2.07269430e-01f, -5.00124454e-01f, -2.03827217e-01f, 2.34357521e-01f, 3.69218558e-01f,
  -4.13128324e-02f, 8.57650936e-02f, -1.18374147e-01f, 4.16721672e-01f, 6.98991790e-02f, 2.28309616e-01f, 8.12093243e-02f, -3.08375843e-02f, 1.16564229e-01f, 1.29665613e-01f,
  1.77617788e-01f, 2.45910361e-01f, -3.07336867e-01f, 3.97225827e-01f, -2.94602215e-01f, -5.87810241e-02f, -3.22673500e-01f, 1.23217158e-01f, -4.73374017e-02f, -1.13149798e-02f,
  8.87875929e-02f, 1.71911821e-01f, -3.27618904e-02f, 9.68769044e-02f, -2.12151185e-01f, -4.20958161e-01f, 3.10125262e-01f, 3.59069049e-01f, 2.00736359e-01f, 1.43615663e-01f,
  -8.00034255e-02f, 3.63149762e-01f, -2.18401268e-01f, -2.13982344e-01f, -1.36897877e-01f, -1.84257299e-01f, -1.13395452e-01f, 5.65016596e-03f, 7.95280114e-02f, 1.79490492e-01f,
  -7.89870545e-02f, 2.31065467e-01f, 1.75840199e-01f, -7.37621933e-02f, 1.34756610e-01f, 2.25964606e-01f, 8.58497992e-02f, -1.61639348e-01f, 5.53027652e-02f, 2.55768690e-02f,
  -2.93687582e-01f, 1.11095542e-02f, 1.84083849e-01f, -1.41382888e-01f, 9.95346457e-02f, -5.47788367e-02f, 1.01059429e-01f, -6.50352463e-02f, -5.91583475e-02f, 2.29278997e-01f,
  -2.06545323e-01f, -9.02731344e-02f, 1.74505696e-01f, 3.17370236e-01f, -1.79976538e-01f, -6.36593774e-02f, -1.92103371e-01f, 9.49865440e-04f, -5.78244030e-02f, 1.20649161e-02f,
  -7.35916048e-02f, 2.68874224e-02f, 1.91556253e-02f, -2.27386542e-02f, 3.66243161e-02f, 1.55815780e-01f, -9.27354842e-02f, -1.02392800e-01f, -1.69743642e-01f, -1.84636742e-01f,
  2.78683037e-01f, 4.66243565e-01f, 3.14899236e-01f, 3.70343849e-02f, 5.09304786e-03f, 3.26825082e-01f, 1.16074793e-01f, 1.97471515e-03f, -1.48520127e-01f, -3.75520028e-02f,
  -1.62564218e-01f, -2.03730986e-02f, 1.73726141e-01f, 5.48688546e-02f, -5.38759585e-03f, 3.93956691e-01f, 1.45429149e-01f, 1.56386733e-01f, -1.27235338e-01f, -3.36480916e-01f,
  1.91266641e-01f, -2.57020235e-01f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.55197406e-01f, 2.44210705e-01f, 8.74887109e-02f, 1.96585193e-01f, -4.25521210e-02f, -7.10191801e-02f, -5.51379137e-02f, -5.19127965e-01f, 4.15438563e-01f, -2.18844458e-01f,
  4.95480806e-01f, 4.26005334e-01f, 4.04839635e-01f, -1.13753192e-01f, 7.58949071e-02f, 5.03332794e-01f, -1.47525176e-01f, 1.15304269e-01f, 6.09139260e-03f, 3.25727873e-02f,
  -2.85935663e-02f, 6.94000116e-03f, 4.69543159e-01f, -3.43218684e-01f, 2.03362182e-01f, -3.03436190e-01f, 7.51030669e-02f, 8.38505551e-02f, 1.52318612e-01f, 7.25420490e-02f,
  9.02344137e-02f, 1.83511347e-01f, 3.69681805e-01f, 6.88133761e-02f, 2.13553235e-01f, 1.41743487e-02f, 1.79452106e-01f, 2.05791667e-01f, 1.47036940e-01f, -5.02927005e-01f,
  3.43908936e-01f, -4.57036048e-01f, -1.46155069e-02f, -2.29661409e-02f, -3.54968131e-01f, -1.16281033e-01f, 6.35664165e-01f, 1.81062043e-01f, -2.11440265e-01f, 5.38120687e-01f,
  -9.30247158e-02f, 3.62416953e-01f, 3.86499763e-01f, 5.58565930e-02f, 1.67527303e-01f, 3.96633707e-02f, 4.41831768e-01f, 1.74593762e-01f, 1.36897609e-01f, 3.21531504e-01f,
  -9.55834016e-02f, 2.74485499e-01f, -2.16876656e-01f, 5.81747472e-01f, 2.97022879e-01f, 9.91779938e-02f, 2.00123519e-01f, 2.35105395e-01f, 2.98564345e-01f, 2.65804142e-01f,
  -1.47353336e-01f, 3.49029601e-01f, 1.51578829e-01f, -2.12594852e-01f, -3.23774666e-01f, 2.00580016e-01f, -2.89804906e-01f, 1.50407208e-02f, 4.13485080e-01f, -1.72087938e-01f,
  -1.92478955e-01f, 2.97253847e-01f, 3.41731496e-02f, -1.16093695e-01f, 4.75252986e-01f, 2.92823136e-01f, -1.79513413e-02f, 4.03444260e-01f, 4.79767501e-01f, -1.81986779e-01f,
  3.96904424e-02f, -2.05127246e-04f, -1.26067892e-01f, 3.30896407e-01f, 2.66727984e-01f, 1.83629692e-01f, 3.22525799e-01f, 1.81469414e-02f, 2.72854179e-01f, 1.18431978e-01f,
  3.78326364e-02f, 3.71504240e-02f, 1.51302218e-01f, -3.22808594e-01f, -2.64898628e-01f, -3.14542979e-01f, 8.44526812e-02f, 1.66235954e-01f, 2.92045057e-01f, 5.17983675e-01f,
  -3.79832163e-02f, 3.73580307e-02f, 9.92816985e-02f, 3.15157294e-01f, -4.13147479e-01f, 2.24110916e-01f, -4.26412262e-02f, -2.87321843e-02f, 4.29387808e-01f, -2.81707138e-01f,
  2.89990574e-01f, -6.26329407e-02f, 4.42453623e-01f, 2.34348997e-01f, -1.62641153e-01f, -3.82155001e-01f, 2.02215105e-01f, -2.80064940e-01f, 4.60389145e-02f, 1.52191520e-01f,
  1.66674629e-01f, 1.17670134e-01f, -1.50335254e-02f, -1.07798785e-01f, 1.64274633e-01f, -9.54663157e-02f, -3.92835289e-01f, -3.84940535e-01f, -3.84706408e-01f, -2.98345059e-01f,
  -4.75346655e-01f, 3.83231461e-01f, 3.21787059e-01f, -3.87173265e-01f, 4.09364045e-01f, 4.23309386e-01f, 7.95472041e-02f, 4.81738985e-01f, -8.96575004e-02f, -7.30902329e-02f,
  -2.30408847e-01f, 2.69643823e-03f, 5.09569466e-01f, 3.79748434e-01f, 2.63005376e-01f, 1.23150609e-01f, -2.45678127e-01f, 1.31374793e-02f, 2.78567392e-02f, 1.01770937e-01f,
  2.36809388e-01f, 2.16735393e-01f, 8.49152729e-02f, 2.10879624e-01f, 3.47692013e-01f, -1.21887870e-01f, 4.86428976e-01f, 2.85442054e-01f, -2.93415487e-01f, 9.13292319e-02f,
  2.63836067e-02f, -4.15022641e-01f, 6.25304207e-02f, 1.18459523e-01f, -4.12153274e-01f, 1.06290974e-01f, -1.40803218e-01f, -1.18029758e-01f, 3.25231552e-01f, 1.37952670e-01f,
  2.09543094e-01f, 6.06589258e-01f, -3.01906824e-01f, 1.79943547e-01f, -2.70286769e-01f, 4.60076600e-01f, 2.85335332e-01f, 2.79403090e-01f, 6.63794398e-01f, 4.55809861e-01f,
  4.53215778e-01f, -9.79418606e-02f, 3.01962405e-01f, -1.24567054e-01f, 1.26563057e-01f, 2.24900737e-01f, 1.95776974e-03f, 2.38953248e-01f, 9.29087579e-01f, 6.75711334e-01f,
  -4.47802514e-01f, -5.20149946e-01f, -6.57167792e-01f, -5.52047253e-01f, -9.74371731e-02f, -1.90972179e-01f, 9.30133909e-02f, -9.12612230e-02f, -3.33077431e-01f, 3.28636169e-01f,
  -9.85855609e-02f, -1.99861452e-01f, 3.60082269e-01f, 2.92071849e-01f, 1.92319006e-01f, 6.08130023e-02f, 1.80497095e-01f, -7.56550133e-01f, -8.21468681e-02f, -1.95982847e-02f,
  -1.44482329e-01f, -1.89777598e-01f, -1.84993699e-01f, 2.96997637e-01f, 2.22384319e-01f, 1.41391024e-01f, 8.52971077e-02f, 5.23019321e-02f, 2.54167587e-01f, -2.72745267e-02f,
  -6.43213391e-01f, 1.14332564e-01f, 5.51322937e-01f, 5.20576656e-01f, 1.60185143e-01f, -2.36516729e-01f, 1.12634018e-01f, 2.10291624e-01f, 2.25738790e-02f, -2.10644946e-01f,
  4.91889209e-01f, -1.89049363e-01f, 3.59323472e-01f, 2.61970252e-01f, -1.23326123e-01f, 8.62666778e-03f, 1.90298423e-01f, -5.87684549e-02f, 3.21073711e-01f, -4.75913197e-01f,
  -1.35508478e-01f, 1.50714308e-01f, -3.26789677e-01f, 1.31182343e-01f, 7.52005130e-02f, 9.47411284e-02f, 1.15188651e-01f, 4.46035177e-01f, 1.03760576e-02f, 5.92347533e-02f,
  2.11513638e-01f, -1.82945728e-01f, -3.54404688e-01f, 3.22400570e-01f, 3.17873061e-01f, 4.27360028e-01f, 7.04601645e-01f, 1.63959906e-01f, 2.06426546e-01f, 1.28415152e-01f,
  1.73908230e-02f, 3.17958266e-01f, 2.16773495e-01f, 1.24168567e-01f, 4.88211989e-01f, -5.70331654e-03f, -1.00411540e-02f, 5.03958941e-01f, -1.36698380e-01f, -9.75104272e-02f,
  1.88855231e-01f, 1.21642657e-01f, 3.52605712e-03f, 3.30934346e-01f, 1.99903741e-01f, 1.76708177e-01f, 5.00243902e-01f, 1.38532966e-01f, 2.57749170e-01f, 3.30138415e-01f,
  -3.49404551e-02f, -5.97084649e-02f, 4.13082056e-02f, 4.26060677e-01f, -1.62021518e-02f, 5.04625797e-01f, 4.27558184e-01f, 2.12869376e-01f, 1.18230768e-01f, 1.53832301e-01f,
  -3.99846315e-01f, -3.46076377e-02f, -1.21509098e-02f, -8.82002637e-02f, -7.35791922e-02f, -3.26267391e-01f, 2.51616299e-01f, 2.33500451e-01f, 2.74222821e-01f, 1.74154565e-01f,
  -3.93673182e-01f, 4.76215303e-01f, 2.08499938e-01f, -2.59303063e-01f, 3.67553353e-01f, 1.65672392e-01f, 1.10819638e-01f, 3.31863999e-01f, 5.00081301e-01f, -2.10780457e-01f,
  2.73503155e-01f, 2.65301336e-02f, 1.87652521e-02f, -8.67769942e-02f, -9.80872437e-02f, 1.13695376e-01f, -1.03539750e-02f, -5.06206274e-01f, 4.03207913e-02f, -4.10404839e-02f,
  2.82180101e-01f, 4.38350856e-01f, 5.01449585e-01f, 5.72834194e-01f, 3.07482923e-03f, 2.62116462e-01f, 2.36113623e-01f, 2.09699884e-01f, 9.11167115e-02f, 5.79791844e-01f,
  5.63730448e-02f, -1.09200016e-01f, 1.76497847e-01f, -2.04813316e-01f, 7.58959576e-02f, -2.89845467e-01f, 2.89063722e-01f, 2.98974603e-01f, 1.81709737e-01f, -8.44950154e-02f,
  2.36643672e-01f, 5.49849011e-02f, -5.34267649e-02f, 1.92447856e-01f, 1.50662318e-01f, 5.14067054e-01f, 2.38625571e-01f, 2.88184315e-01f, -4.12513703e-01f, 3.03723216e-01f,
  -5.50237715e-01f, 2.86072437e-02f, -3.80563557e-01f, -1.07380569e-01f, 7.20587373e-01f, 3.72265100e-01f, 3.83953393e-01f, 5.02459466e-01f, 7.15970993e-01f, 1.88382402e-01f,
  1.57791570e-01f, -2.75047153e-01f, -4.96040694e-02f, 2.87012428e-01f, 4.32009041e-01f, 2.96369106e-01f, 2.67826855e-01f, 5.42907000e-01f, -2.59383082e-01f, 1.09484226e-01f,
  -1.04293466e-01f, -3.33910257e-01f, 9.99004543e-02f, -5.38117290e-02f, -9.48883742e-02f, 7.27362782e-02f, 2.27425292e-01f, -2.11761445e-01f, 9.44149271e-02f, 1.23470612e-01f,
  -2.37012338e-02f, 2.98238862e-02f, 2.26705447e-02f, -3.75270247e-01f, -1.14958309e-01f, 5.52405775e-01f, 1.77868754e-01f, 2.32401371e-01f, 1.15808845e-01f, 1.33686274e-01f,
  -3.77729833e-01f, 3.60038847e-01f, -1.26473680e-01f, 1.94425970e-01f, 5.70979357e-01f, -2.69952476e-01f, -5.55006154e-02f, 3.95542026e-01f, 2.02566087e-01f, 1.44716203e-01f,
  3.47183973e-01f, 3.19702655e-01f, 4.06982422e-01f, 4.32455122e-01f, 7.29099140e-02f, 7.62821436e-02f, 4.06998783e-01f, -9.75633487e-02f, 1.42461255e-01f, 2.57774174e-01f,
  2.76311368e-01f, -1.59300163e-01f, 4.62657601e-01f, -3.97622019e-01f, -1.75425932e-01f, -1.09058656e-01f, -4.05984782e-02f, -6.44919455e-01f, -4.62766439e-01f, 4.91759144e-02f,
  2.80619711e-01f, -1.53938428e-01f, 8.62226263e-03f, 3.07625234e-01f, 1.03299208e-01f, 4.55541700e-01f, -1.53358638e-01f, 7.36397058e-02f, -8.55264291e-02f, -3.37261796e-01f,
  4.16999578e-01f, -5.20617723e-01f, 3.24273109e-01f, -7.02320114e-02f, 4.50587362e-01f, 4.50512588e-01f, -3.85666162e-01f, 3.68558079e-01f, 3.33615005e-01f, 1.97363079e-01f,
  1.31691709e-01f, 3.06130052e-01f, 1.44541651e-01f, 2.31136218e-01f, -4.20938075e-01f, -9.88476202e-02f, 2.84883976e-01f, 1.57141104e-01f, 1.46472037e-01f, -1.37239367e-01f,
  1.40490785e-01f, -4.17664856e-01f, 2.83796936e-01f, 4.09455091e-01f, 3.07852030e-01f, 3.11768234e-01f, 4.13081765e-01f, 6.04766198e-02f, 2.20009327e-01f, 1.01397902e-01f,
  1.30725265e-01f, -1.46097258e-01f, -2.44241953e-02f, 1.50522083e-01f, -1.37740269e-01f, 1.81197539e-01f, 2.43958801e-01f, 1.72921538e-01f, -1.26421392e-01f, 3.87911975e-01f,
  2.44457781e-01f, 2.35244557e-02f, 4.70350171e-03f, -3.83935347e-02f, -1.02041759e-01f, 2.43699133e-01f, 1.28258407e-01f, -5.14258921e-01f, 1.77387878e-01f, -2.84167379e-02f,
  -1.43724363e-02f, 1.55775994e-01f, 5.19036651e-01f, 2.00880781e-01f, -1.64535508e-01f, 1.24170832e-01f, 1.48765996e-01f, 2.76178122e-01f, -1.66646942e-01f, 4.81988937e-01f,
  -1.78479612e-01f, -3.19935173e-01f, 6.00945711e-01f, -1.70905694e-01f, -3.69976044e-01f, -2.34443650e-01f, 4.19166803e-01f, 1.51864007e-01f, 4.36494082e-01f, 8.86153057e-02f,
  -9.25751179e-02f, 8.92873388e-03f, 2.28714421e-01f, -4.04284336e-04f, 9.81806517e-02f, 9.77860987e-02f, 9.09883305e-02f, 1.69200689e-01f, 2.03152210e-01f, -4.14202482e-01f,
  2.35689968e-01f, -1.46465227e-01f, 4.90565658e-01f, 4.49210972e-01f, 4.38698411e-01f, -6.27688831e-04f, 2.18694787e-02f, 5.20580053e-01f, -6.63855493e-01f, -6.28578663e-02f,
  9.18007791e-02f, -1.55372798e-01f, 2.22561255e-01f, 1.53716937e-01f, 3.09505194e-01f, -1.94842860e-01f, -2.40884423e-01f, -2.98636883e-01f, -4.53563742e-02f, 3.48677963e-01f,
  -4.38679419e-02f, 4.09926027e-02f, 4.55860645e-01f, 4.52393360e-05f, 1.73299909e-01f, 1.78858221e-01f, 3.50092381e-01f, -3.39244343e-02f, 2.70085722e-01f, 3.85098666e-01f,
  -6.35118544e-01f, -1.73442848e-02f, 5.03685713e-01f, 1.33249134e-01f, -5.61768830e-01f, 2.48784259e-01f, 2.14300260e-01f, 5.38769104e-02f, 1.86580628e-01f, -4.47128475e-01f,
  2.37882584e-01f, 2.53512591e-01f, 2.38207474e-01f, 1.34135604e-01f, 4.60768677e-02f, -2.68318087e-01f, 2.92959958e-01f, 4.50422943e-01f, 3.56756866e-01f, -1.74608409e-01f,
  3.68240267e-01f, -1.49205193e-01f, -1.31873131e-01f, 3.73501122e-01f, -2.39108399e-01f, 1.62382647e-01f, -5.55675402e-02f, 2.94255167e-01f, 1.73260272e-01f, 2.42805809e-01f,
  2.20366508e-01f, 3.95291477e-01f, -4.88124380e-04f, -2.04695091e-02f, 1.59551278e-01f, 5.55353761e-01f, 7.16209561e-02f, -4.11461651e-01f, -2.68275499e-01f, -7.71161318e-02f,
  -1.07166439e-01f, 1.25208599e-02f, 3.66409607e-02f, -1.18080571e-01f, 4.45295215e-01f, 2.21993378e-03f, 5.62457629e-02f, 1.95399180e-01f, -3.11451077e-01f, 2.78931737e-01f,
  -1.03911191e-01f, 4.23697799e-01f, -9.10996646e-02f, -2.23284513e-01f, 6.25088930e-01f, 5.74299872e-01f, -8.68975669e-02f, 1.02163203e-01f, 4.01656449e-01f, 1.26545355e-01f,
  1.80805903e-02f, -1.58870354e-01f, 1.25647232e-01f, 4.33696955e-01f, 1.84716329e-01f, -1.98395804e-01f, 4.81038183e-01f, -9.34124738e-02f, 2.91384477e-02f, 4.04702306e-01f,
  -3.70980591e-01f, -2.55976170e-01f, 5.51821649e-01f, 1.96095824e-01f, -4.21763688e-01f, 4.68627691e-01f, 2.92002171e-01f, 7.51113519e-02f, 4.38910782e-01f, -1.96463894e-02f,
  -1.08312823e-01f, 2.04687551e-01f, 8.96878242e-02f, -1.22409850e-01f, 3.27763945e-01f, 3.07399124e-01f, 3.74151140e-01f, 4.68141288e-01f, 1.21120792e-02f, 4.13474590e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  5.04652597e-02f, 3.42335820e-01f, 1.29931703e-01f, 4.71031778e-02f, 2.91641384e-01f, 2.37636164e-01f, 5.14000475e-01f, 8.99496153e-02f, 2.71575809e-01f, 9.56647247e-02f,
  -1.98943773e-03f, 4.94180560e-01f, 1.13670528e-01f, 2.43477523e-01f, 9.08441842e-02f, 2.89747834e-01f, -1.00277223e-01f, 3.48281950e-01f, 2.93471336e-01f, 1.45992205e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  6.64641485e-02f, 1.72596797e-02f, -4.64843437e-02f, 1.14577107e-01f, -7.83164874e-02f, -9.38951895e-02f, -3.77617031e-01f, 7.56322220e-02f, -1.43004879e-01f, 1.72367945e-01f,
  -6.43338710e-02f, -7.84322619e-02f, -1.73083246e-01f, 1.18783124e-01f, 5.90360761e-02f, 1.31082565e-01f, 2.32537434e-01f, 1.55698881e-01f, -1.03628702e-01f, -1.65602103e-01f,
  2.04668008e-02f, -2.86528647e-01f, -4.32385206e-02f, -7.83459004e-03f, 2.51073033e-01f, 3.41400623e-01f, -2.41584033e-01f, -1.93350092e-01f, -2.17668846e-01f, -5.78797758e-02f,
  -1.22279420e-01f, -1.78716883e-01f, -4.57948372e-02f, -4.28789714e-03f, -3.02066002e-02f, 9.47039425e-02f, -3.72457094e-02f, 1.35391682e-01f, 3.75736095e-02f, -2.64157265e-01f,
  -2.35593691e-01f, 1.95002601e-01f, -2.05055270e-02f, -7.71221844e-03f, 1.05249338e-01f, 1.13587864e-01f, 5.31829670e-02f, -8.41046721e-02f, 1.34801701e-01f, -2.43973821e-01f,
  -3.96016538e-02f, -3.73767652e-02f, -2.33029187e-01f, -2.76526570e-01f, -1.36591583e-01f, 2.55999267e-01f, 1.92394573e-02f, -1.71471015e-01f, 1.01413846e-01f, 1.26893818e-02f,
  -1.06991231e-01f, 1.47496328e-01f, 6.14466406e-02f, 5.60021475e-02f, 1.00754518e-02f, 6.58293515e-02f, 4.53420840e-02f, 1.35469198e-01f, 1.41244143e-01f, 2.47841701e-01f,
  -3.13608468e-01f, -8.90184045e-02f, -1.17802218e-01f, -1.41458109e-01f, 5.67946471e-02f, -4.54335809e-02f, 7.35740215e-02f, -1.25477510e-02f, -9.52022076e-02f, -1.42087312e-02f,
  -6.98396340e-02f, 5.93677908e-02f, 2.87888432e-03f, 2.45616347e-01f, -1.82089716e-01f, 1.52593091e-01f, 2.33981702e-02f, -2.17198610e-01f, -5.40259015e-03f, 2.39678636e-01f,
  1.01535268e-01f, 1.17754400e-01f, -2.01980352e-01f, 1.86903939e-01f, -7.20284209e-02f, 2.03141019e-01f, 1.89038604e-01f, 1.49114922e-01f, -1.19534746e-01f, 2.68336058e-01f,
  1.64555877e-01f, 3.91394868e-02f, -2.62524486e-01f, -1.97695389e-01f, 7.70659819e-02f, -7.19644129e-02f, 2.39215821e-01f, -3.67868751e-01f, -3.02017242e-01f, 1.26434743e-01f,
  -1.73478141e-01f, -1.78392187e-01f, -1.05866387e-01f, 1.66589916e-01f, 1.83003649e-01f, 1.13308869e-01f, 5.13397790e-02f, 1.16696671e-01f, -7.46213496e-02f, 3.71831022e-02f,
  -8.49201754e-02f, 1.71948835e-01f, -2.27259025e-01f, -1.08580284e-01f, -2.04194054e-01f, 1.29120916e-01f, 2.43149489e-01f, -1.10250756e-01f, -4.64549623e-02f, 2.53663749e-01f,
  -2.15503089e-02f, 1.24373063e-01f, -1.14096060e-01f, -6.38007149e-02f, -1.95165902e-01f, 3.93928617e-01f, -1.53885990e-01f, 1.66672319e-02f, 5.62042259e-02f, -3.96246642e-01f,
  6.93896860e-02f, -3.21301699e-01f, -1.23364516e-01f, 1.84953302e-01f, 1.37421221e-01f, 1.16357379e-01f, 1.31703839e-01f, 1.44257277e-01f, 2.12236922e-02f, -1.54492930e-01f,
  5.91000542e-02f, -2.98592262e-02f, -1.70879915e-01f, 4.37262356e-01f, -2.04874679e-01f, 1.30569577e-01f, -2.16895323e-02f, -4.51134704e-02f, 2.05724105e-01f, -9.76710692e-02f,
  -2.36181781e-01f, -2.09699068e-02f, -2.81483196e-02f, 9.95372683e-02f, 1.88936874e-01f, 9.34224278e-02f, 1.03751808e-01f, -1.47906467e-01f, -6.68767393e-02f, -2.39665862e-02f,
  -1.20259188e-01f, 1.40343485e-02f, 2.96328455e-01f, 9.24430937e-02f, -1.91760331e-01f, -1.62261844e-01f, -2.58082658e-01f, 1.91738024e-01f, 9.63733867e-02f, -3.06546718e-01f,
  -1.10903181e-01f, -4.13297534e-01f, 4.24810201e-02f, 2.30524808e-01f, -7.28761032e-02f, 2.02417657e-01f, 3.21571857e-01f, -6.62989914e-03f, 2.11621165e-01f, -1.81376383e-01f,
  -5.60345594e-03f, -1.04184628e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.56951267e-01f, 4.36441481e-01f, 2.34199643e-01f, -1.26118153e-01f, 2.93550849e-01f, 1.28228456e-01f, 2.74784744e-01f, 1.33763954e-01f, 3.64193529e-01f, 2.96874136e-01f,
  2.54303426e-01f, 2.02449456e-01f, 3.25591654e-01f, -1.57893807e-01f, -7.31554478e-02f, 2.45163098e-01f, 6.37448952e-02f, 2.94489890e-01f, 4.18318391e-01f, 2.60034293e-01f,
  5.18882871e-01f, -1.90800950e-01f, 6.32803738e-02f, 5.15352368e-01f, -1.23411417e-01f, -1.17972054e-01f, 3.09705704e-01f, 4.24313359e-03f, 4.49232966e-01f, -2.90322185e-01f,
  -4.33436483e-02f, -3.11774015e-01f, 1.10342942e-01f, 2.04307303e-01f, 1.61296576e-01f, 2.05619022e-01f, 2.71200240e-01f, 3.19264144e-01f, -2.18723044e-01f, 3.32672447e-01f,
  4.47565019e-01f, -8.34287107e-02f, 2.76042461e-01f, -3.84651095e-01f, -6.18903898e-02f, 2.73670882e-01f, 4.73149121e-01f, -2.63599217e-01f, 1.52924538e-01f, 1.15269251e-01f,
  5.51318467e-01f, 5.64458787e-01f, 3.31155062e-01f, 4.94456202e-01f, -3.53054628e-02f, -2.40479454e-01f, -1.26747206e-01f, 2.88079649e-01f, 9.09127891e-02f, -3.29460859e-01f,
  -3.28433737e-02f, 1.47271067e-01f, 1.17004260e-01f, 2.43581180e-02f, 1.91162098e-02f, -2.36557573e-02f, 1.36776596e-01f, -2.28842366e-02f, -1.26371544e-03f, -3.12495679e-01f,
  6.64196094e-04f, 2.13286355e-01f, -1.94914103e-01f, -4.52507079e-01f, -5.14664948e-01f, -8.87713432e-02f, 2.93431878e-01f, 1.49411842e-01f, -3.11903536e-01f, 3.34506392e-01f,
  -2.82056570e-01f, 3.87927145e-01f, -1.90715477e-01f, -5.54123282e-01f, 5.54384384e-03f, -5.14654852e-02f, 3.12208414e-01f, -3.85383844e-01f, 1.71547621e-01f, 4.10008162e-01f,
  -6.99412078e-02f, 5.22041380e-01f, 3.79006207e-01f, -7.58736655e-02f, 2.70681560e-01f, 7.09668249e-02f, -5.38114011e-02f, 1.78204194e-01f, -1.67752087e-01f, -2.47659415e-01f,
  -1.14715673e-01f, -1.22880191e-01f, -6.41925871e-01f, 1.37068555e-01f, 8.84989649e-02f, 6.23829179e-02f, 1.87975824e-01f, -2.45213360e-02f, -3.53288725e-02f, 5.23773849e-01f,
  3.46873403e-01f, 3.18127990e-01f, 6.25078797e-01f, -1.76639870e-01f, 7.30149865e-01f, -1.41049176e-01f, -3.44355822e-01f, -2.92113662e-01f, 2.09562168e-01f, -8.67244154e-02f,
  2.68896312e-01f, 7.86776423e-01f, 2.51773894e-01f, 3.30125988e-01f, -3.37345928e-01f, 3.66978496e-01f, 3.45136337e-02f, 3.75948131e-01f, 3.27757709e-02f, 5.32074273e-02f,
  2.26851359e-01f, 9.40792412e-02f, 1.57641396e-01f, 2.37669751e-01f, 6.01747692e-01f, -4.22921211e-01f, -2.23951682e-01f, 4.07323390e-01f, 2.13231057e-01f, 6.19153976e-02f,
  -1.44342631e-01f, 1.30541563e-01f, 2.27945670e-01f, -2.14184299e-01f, -3.98706138e-01f, -1.56056657e-01f, -2.78819323e-01f, 6.28591120e-01f, 3.70300442e-01f, 3.09417158e-01f,
  -2.88826525e-01f, 8.86098295e-02f, -1.46005645e-01f, -1.60976157e-01f, 2.71025807e-01f, -3.55874673e-02f, -2.73012549e-01f, 5.74051499e-01f, 4.13592547e-01f, 2.60368258e-01f,
  7.15150684e-02f, 2.21206889e-01f, -4.17211741e-01f, 2.32154086e-01f, -1.45905331e-01f, 2.12487057e-02f, 6.00843243e-02f, 5.58980405e-01f, 7.56405145e-02f, -2.92726010e-01f,
  3.12090158e-01f, -1.56588763e-01f, 3.01858246e-01f, 2.95586675e-01f, 1.52552158e-01f, -5.78431301e-02f, 5.82248978e-02f, -3.94167811e-01f, -6.20202363e-01f, 2.55412996e-01f,
  3.70388210e-01f, 2.09325835e-01f, 1.96465194e-01f, 1.50398195e-01f, 4.31941524e-02f, 4.31460291e-02f, 1.55042648e-01f, -3.50115657e-01f, 1.38891280e-01f, 1.24514885e-01f,
  -1.21446788e-01f, 2.63868183e-01f, 3.10454637e-01f, -2.90656447e-01f, 1.88833892e-01f, -9.65526626e-02f, 6.68371394e-02f, 3.45446408e-01f, 3.75373065e-01f, -4.76226389e-01f,
  7.10240781e-01f, -3.06467712e-01f, 2.82203816e-02f, 3.10817957e-02f, -2.60767378e-02f, -1.57455742e-01f, 1.55729383e-01f, -2.15915889e-01f, -2.42521800e-02f, 5.61768889e-01f,
  -5.41799426e-01f, 9.53344330e-02f, 3.18257332e-01f, 5.05581379e-01f, 1.50707781e-01f, -2.11923227e-01f, 1.19634941e-01f, -2.04042494e-01f, 2.73873895e-01f, -1.51445925e-01f,
  3.96926254e-01f, -1.13642812e-01f, 5.07069767e-01f, 2.67664701e-01f, 3.57529014e-01f, 7.10438415e-02f, 9.20168087e-02f, -1.17999360e-01f, 1.70897543e-02f, 1.97181761e-01f,
  -8.17314088e-02f, -1.37052266e-02f, 4.91693914e-01f, 4.62706447e-01f, 3.49946320e-01f, 4.28081155e-01f, 5.20858318e-02f, 3.08564544e-01f, 3.54415357e-01f, -7.73682073e-02f,
  3.41206826e-02f, -1.74297869e-01f, 4.76303637e-01f, -1.74264051e-02f, 2.67113417e-01f, -6.44853339e-02f, -1.57969326e-01f, 5.24507582e-01f, 3.02854851e-02f, -2.54436076e-01f,
  2.66102701e-01f, -3.84368688e-01f, 2.42573306e-01f, 2.69471467e-01f, -1.48126677e-01f, 1.98456377e-01f, 1.18542045e-01f, 1.77150041e-01f, 1.88003987e-01f, 4.03978348e-01f,
  7.18327090e-02f, 2.80437559e-01f, 1.19946457e-01f, 4.51167487e-02f, -1.01960309e-01f, -2.07065374e-01f, -6.14916086e-01f, 3.63257140e-01f, 4.74694282e-01f, -1.20151713e-01f,
  1.38138190e-01f, 2.28455469e-01f, -2.80337989e-01f, 3.41088146e-01f, -1.16910757e-02f, 1.11859694e-01f, 2.48255134e-01f, 2.54954815e-01f, 3.55977625e-01f, -1.15409449e-01f,
  2.97308385e-01f, -3.05239081e-01f, -7.40023181e-02f, 3.37397367e-01f, 4.68577832e-01f, 2.41526254e-02f, -2.89986491e-01f, 1.12516686e-01f, 1.99335873e-01f, -3.33945811e-01f,
  9.51690972e-02f, 4.22305912e-01f, 2.28025764e-01f, 1.43262833e-01f, -1.53841153e-01f, -4.63418782e-01f, 1.12382352e-01f, 2.43139729e-01f, -2.98930734e-01f, -4.61100996e-01f,
  7.44031072e-02f, 3.85185897e-01f, 4.84837383e-01f, -3.50351363e-01f, -2.21007332e-01f, 3.18922907e-01f, 1.00770366e+00f, -8.54825526e-02f, -4.73311059e-02f, 3.85191053e-01f,
  -1.76179335e-01f, -5.24147272e-01f, 5.39398611e-01f, 2.56487399e-01f, 2.54942685e-01f, -1.33747399e-01f, 2.09425330e-01f, 3.74829978e-01f, 4.40109104e-01f, 5.50932586e-01f,
  2.34147310e-01f, 4.54581350e-01f, 4.59907465e-02f, 4.43390012e-01f, 3.02915990e-01f, 2.04412162e-01f, 4.29393411e-01f, 1.42442390e-01f, -4.45088059e-01f, 2.51929671e-01f,
  -3.60553175e-01f, 2.82382697e-01f, 5.34549952e-01f, 2.49415357e-03f, -1.12058476e-01f, 3.12612295e-01f, -5.30014157e-01f, -4.98867482e-01f, -1.76200911e-01f, 6.07838273e-01f,
  2.20255241e-01f, -2.18999535e-01f, 3.96736234e-01f, 4.11607116e-01f, -2.05912873e-01f, -2.36299470e-01f, 4.11924720e-01f, 5.31617522e-01f, 3.52219403e-01f, 4.47312146e-01f,
  -5.93620241e-02f, -1.32357016e-01f, 1.98840156e-01f, 1.79110527e-01f, -1.56001791e-01f, -1.96721688e-01f, -1.14038989e-01f, -1.50178507e-01f, -1.21782608e-01f, 2.60767609e-01f,
  -9.05647203e-02f, -4.94717419e-01f, -1.64712101e-01f, 3.22562516e-01f, 4.09712017e-01f, 4.13512915e-01f, -1.71289638e-01f, 3.50336015e-01f, 3.82767707e-01f, -1.88681796e-01f,
  -8.66426408e-01f, -7.49939531e-02f, 2.82216012e-01f, 4.95388396e-02f, 6.13809288e-01f, -1.08677074e-01f, 2.98672765e-01f, 7.13593364e-02f, 1.37276128e-01f, 4.22455609e-01f,
  3.73585671e-01f, -1.59219012e-01f, -2.45357826e-01f, 4.02795374e-01f, 1.93745077e-01f, 4.33243930e-01f, 2.52831399e-01f, 1.00722656e-01f, 2.63799459e-01f, 1.52489960e-01f,
  -7.13599205e-01f, -4.64091264e-03f, 5.22648454e-01f, 3.03415228e-02f, 4.49993551e-01f, -6.88299716e-01f, -3.20414841e-01f, -8.08965489e-02f, 1.65046349e-01f, -1.19785435e-01f,
  3.22531104e-01f, 6.69601202e-01f, 1.12979901e+00f, 2.49327540e-01f, 1.87718615e-01f, 1.50814995e-01f, -3.50922585e-01f, 4.45720814e-02f, -1.35059878e-01f, 7.18716145e-01f,
  1.95364162e-01f, -2.12500393e-01f, -3.00836921e-01f, 2.61679050e-02f, 3.87684107e-01f, -1.82848737e-01f, -7.07529262e-02f, 2.37379417e-01f, -2.12991878e-01f, -7.67208934e-02f,
  -1.60391014e-02f, 1.67249158e-01f, 2.08930559e-02f, -5.62966615e-02f, 5.43310165e-01f, -3.00887793e-01f, 3.61177444e-01f, 1.42223835e-01f, -1.20001361e-01f, 9.22451820e-03f,
  -1.77304208e-01f, -3.81623596e-01f, 1.50591731e-01f, 1.83925629e-01f, -8.27701032e-01f, 4.90339935e-01f, 5.45198858e-01f, -1.63955182e-01f, 1.39438972e-01f, 6.20683841e-02f,
  -5.89861274e-02f, 1.09269340e-02f, 3.16448897e-01f, -4.61177342e-02f, -1.23234756e-01f, -7.80556127e-02f, 3.89536679e-01f, 8.44569579e-02f, -5.83531559e-02f, 1.08502589e-01f,
  2.77230144e-01f, 8.83834437e-02f, 9.93035063e-02f, -2.39214972e-01f, 9.72329918e-03f, 8.87237713e-02f, 7.68760368e-02f, -2.47492746e-01f, -2.18449309e-01f, 3.16617966e-01f,
  3.58969718e-01f, 1.31657705e-01f, -1.90642297e-01f, 5.39260030e-01f, -8.93373415e-03f, 1.25335276e-01f, -1.86379030e-01f, -2.90838540e-01f, 2.60902584e-01f, 7.68165216e-02f,
  3.71797591e-01f, -1.84556156e-01f, 9.65981930e-02f, 8.54425505e-03f, -2.76767433e-01f, 1.16621025e-01f, 4.94653553e-01f, -3.20290804e-01f, -4.72319603e-01f, 2.32657477e-01f,
  1.64043561e-01f, 5.44280946e-01f, -2.24807963e-01f, 8.90150964e-02f, 1.77758932e-01f, 3.87985647e-01f, -5.23968399e-01f, 4.70826268e-01f, -1.43708691e-01f, -3.05678546e-01f,
  9.88437906e-02f, 1.62780955e-01f, 4.37095940e-01f, 3.28058839e-01f, -8.50238428e-02f, -1.12578586e-01f, 3.95718068e-01f, -2.39991710e-01f, 4.73079115e-01f, 5.51036716e-01f,
  9.05840099e-02f, -1.74466446e-02f, 3.54948729e-01f, -1.07291818e-01f, -1.78009927e-01f, 6.04336500e-01f, 2.69444168e-01f, 3.93429458e-01f, -4.71187709e-03f, 9.43546221e-02f,
  -1.43160835e-01f, 2.80102901e-02f, -1.85739860e-01f, 2.48300940e-01f, -2.37849787e-01f, 3.81153792e-01f, -7.10305125e-02f, 1.33576334e-01f, -2.29411602e-01f, -5.52881435e-02f,
  -3.60030144e-01f, -3.40948761e-01f, -6.20755315e-01f, 2.32030779e-01f, 3.95120025e-01f, 1.47129089e-01f, -1.38566673e-01f, 2.22576514e-01f, -1.66758627e-01f, 2.06664428e-02f,
  -2.11198747e-01f, 2.23820344e-01f, 2.15991929e-01f, -2.53440768e-01f, 4.13983136e-01f, -1.28780037e-01f, 2.92869419e-01f, 3.12913239e-01f, 1.10998586e-01f, 6.54670119e-01f,
  4.11792129e-01f, 2.22175926e-01f, -9.39167887e-02f, 1.71906635e-01f, 1.62557855e-01f, 2.22573340e-01f, 2.94544846e-01f, -1.37522757e-01f, 8.16336647e-02f, 8.49141181e-02f,
  6.13066077e-01f, -1.76833495e-01f, -4.94582653e-01f, 2.53507018e-01f, -1.13789082e-01f, 6.15853429e-01f, -2.03716338e-01f, -6.03623912e-02f, 2.50920206e-01f, 4.15675938e-01f,
  5.48534691e-01f, 3.47097442e-02f, -3.50401878e-01f, 5.25889099e-01f, -5.97248971e-02f, 3.85737151e-01f, 5.10211825e-01f, 6.31959498e-01f, 3.96492004e-01f, -5.08311808e-01f,
  -1.33414432e-01f, 2.75473744e-01f, -1.46335751e-01f, 6.51044488e-01f, -2.06270982e-02f, -3.58044356e-01f, 3.40332031e-01f, 9.02043507e-02f, 3.95726264e-01f, -3.45418781e-01f,
  2.61175603e-01f, 1.08357802e-01f, -1.19910404e-01f, -3.83863181e-01f, 5.16212463e-01f, 3.39947581e-01f, 4.03498888e-01f, 3.34682196e-01f, -1.60283446e-02f, 2.82640487e-01f,
  1.60647780e-01f, 9.82108936e-02f, 1.50908902e-01f, 4.05352980e-01f, 8.93794119e-01f, -4.18331921e-01f, -8.35300609e-02f, -1.60769328e-01f, -2.84878135e-01f, 3.64093125e-01f,
  1.42112687e-01f, -4.47700620e-02f, 1.38152856e-02f, -1.71125814e-01f, 2.17402264e-01f, 2.32646354e-02f, -4.96960878e-02f, 1.10147610e-01f, -1.75752103e-01f, -3.83603871e-01f,
  3.49900723e-02f, -2.13083982e-01f, 1.89747036e-01f, -2.93068409e-01f, 3.48278910e-01f, -5.84213912e-01f, 3.65068525e-01f, 2.95905233e-03f, 6.14528283e-02f, 1.91060215e-01f,
  -1.58068329e-01f, -3.13321561e-01f, -8.83311182e-02f, 1.14798985e-01f, -1.28146216e-01f, 8.10214221e-01f, -6.53692961e-01f, 7.18281269e-02f, 5.94651043e-01f, 5.17096639e-01f,
  2.69502282e-01f, 2.99210519e-01f, 2.79664487e-01f, -3.68149728e-01f, 9.58924741e-02f, 2.61478070e-02f, 3.33835594e-02f, 2.71908820e-01f, 5.93685925e-01f, 2.68658586e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.16133311e-01f, 6.85516670e-02f, 1.63646072e-01f, -1.25172690e-01f, 4.86081801e-02f, -3.10998429e-02f, 3.05319242e-02f, 1.10485166e-01f, -1.05926050e-02f, -6.20036898e-03f,
  2.31310874e-01f, 7.62550905e-02f, 3.19153607e-01f, 8.58724788e-02f, 3.66068259e-02f, 1.46026015e-01f, -9.54461023e-02f, 1.06710590e-01f, 1.96136713e-01f, 1.76290825e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  3.92742828e-02f, 4.15260009e-02f, -8.27653557e-02f, -1.01128757e-01f, 4.09657955e-02f, 5.66094667e-02f, -1.18081518e-01f, -1.02753870e-01f, 2.46574894e-01f, 4.44256335e-01f,
  1.01002023e-01f, 2.98383772e-01f, -4.80844051e-01f, -1.30322292e-01f, 3.94292504e-01f, -6.62133396e-02f, -1.69735774e-01f, -3.96029145e-01f, 2.78145552e-01f, -4.52479929e-01f,
  -8.85850638e-02f, 3.25399995e-01f, -5.75633287e-01f, -5.51925562e-02f, 2.55871803e-01f, 1.58161610e-01f, -3.20984840e-01f, -1.42982796e-01f, 1.97357237e-02f, -7.69483328e-01f,
  -1.01149296e-02f, 1.39492929e-01f, -2.19516188e-01f, -2.24449933e-01f, 3.70608270e-02f, -2.10489973e-01f, -8.83133709e-02f, -1.08319663e-01f, 3.44089150e-01f, -2.37845838e-01f,
  1.27606630e-01f, -4.92797345e-01f, -4.62990493e-01f, 2.51939118e-01f, 2.03744903e-01f, -1.14095055e-01f, -1.04137242e-01f, -4.56257910e-01f, -3.37473482e-01f, 2.26584971e-01f,
  3.85691673e-01f, 8.62424895e-02f, 2.82880485e-01f, -3.48438732e-02f, -1.66368276e-01f, 1.99196830e-01f, -3.27594399e-01f, 1.34551212e-01f, 1.14184409e-01f, -9.17166248e-02f,
  1.07960016e-01f, -2.63642937e-01f, -1.58165529e-01f, 8.96141231e-02f, 3.72461490e-02f, -1.27612455e-02f, 9.16454047e-02f, -1.93083942e-01f, -2.41073117e-01f, 3.85459550e-02f,
  -4.17510092e-01f, -5.15118420e-01f, -3.96721512e-01f, -2.45281741e-01f, 4.30526853e-01f, 3.42882037e-01f, 2.03615606e-01f, -4.93524700e-01f, 3.49755853e-01f, -7.03755677e-01f,
  -6.25506878e-01f, 1.42816111e-01f, -2.33720466e-01f, -5.29722095e-01f, 2.67590433e-01f, -7.68809795e-01f, 3.39461565e-01f, 2.08581164e-01f, -5.00338674e-01f, -3.50571781e-01f,
  3.49145889e-01f, -3.13708246e-01f, 8.75366703e-02f, 1.77907303e-01f, -4.40272599e-01f, 6.96789026e-02f, -9.45285261e-02f, -2.97293097e-01f, -2.47947454e-01f, 2.63861537e-01f,
  7.32616559e-02f, 1.84923172e-01f, 1.27124831e-01f, 1.56140715e-01f, -3.26225767e-03f, -7.95154199e-02f, -3.03975642e-01f, 1.92317978e-01f, -8.12842607e-01f, 5.97829409e-02f,
  -3.49725395e-01f, 4.60326970e-01f, -3.56446430e-02f, 3.23236257e-01f, -7.51270711e-01f, 5.08388132e-02f, -6.30770683e-01f, 3.24408740e-01f, -2.32343793e-01f, 1.02481907e-02f,
  -3.29686403e-02f, -1.78781509e-01f, -3.01077545e-01f, 1.37635812e-01f, -5.22281858e-04f, -3.80550742e-01f, -1.64396569e-01f, -6.51120484e-01f, 5.50970621e-02f, 8.31384882e-02f,
  -6.02327250e-02f, -2.38684669e-01f, 4.13197465e-02f, -2.17842817e-01f, -2.30832547e-01f, 7.05457330e-02f, 1.11936830e-01f, 3.78367484e-01f, 3.99641871e-01f, -3.38024020e-01f,
  2.95302756e-02f, 3.52074385e-01f, -3.42777699e-01f, -1.71961322e-01f, 1.13458753e-01f, 4.29533452e-01f, -7.35249510e-03f, -4.96220812e-02f, -2.42232665e-01f, -1.62635610e-01f,
  8.05943906e-02f, -2.71760654e-02f, 2.52504289e-01f, 3.57680798e-01f, -1.60497129e-01f, 4.15463924e-01f, -1.46637395e-01f, -1.53866589e-01f, -4.32130963e-01f, -1.68584526e-01f,
  -1.18248478e-01f, 2.96019673e-01f, 1.83296472e-01f, 1.68027893e-01f, -1.95567936e-01f, -3.44727859e-02f, -3.08244824e-01f, -6.11440875e-02f, 2.99049973e-01f, 4.15632218e-01f,
  -5.64572513e-01f, -5.18350780e-01f, -2.77640939e-01f, 1.43009588e-01f, -4.03220683e-01f, -5.15709281e-01f, 4.40512776e-01f, -1.23954765e-01f, 2.90689796e-01f, 7.30963275e-02f,
  1.85874961e-02f, 4.28267807e-01f, -1.29538298e-01f, -4.48950142e-01f, -8.40131938e-03f, -1.93786040e-01f, -2.18931526e-01f, -6.27194285e-01f, -4.30077463e-01f, 1.13060437e-01f,
  -3.68911377e-03f, 2.16615334e-01f, 4.09745350e-02f, -1.47119373e-01f, 3.64722610e-01f, 1.30708903e-01f, 1.74535692e-01f, 2.66378224e-01f, -3.08884650e-01f, 5.61071217e-01f,
  -6.77914470e-02f, -1.81358874e-01f, 4.58221696e-02f, 4.21176195e-01f, 5.28999791e-02f, -3.35639447e-01f, -3.47389847e-01f, -3.05834919e-01f, 1.78765759e-01f, -4.20032479e-02f,
  -4.32069123e-01f, -2.15538312e-02f, 6.10472262e-02f, -2.35383183e-01f, 5.38134158e-01f, -1.22751437e-01f, -2.83820361e-01f, -5.44018187e-02f, -5.21008193e-01f, 1.88183203e-01f,
  1.95330903e-01f, 4.77944911e-01f, -2.55584866e-01f, -8.63880813e-02f, -7.25623220e-02f, -1.35592684e-01f, 6.49784207e-02f, -6.90767020e-02f, -1.10168464e-01f, -3.02282333e-01f,
  3.42604816e-01f, 5.63256592e-02f, -3.53604317e-01f, -2.57921487e-01f, -1.37908518e-01f, -3.55051786e-01f, -3.16025734e-01f, -1.59701571e-01f, -4.56722975e-01f, 1.96354821e-01f,
  -2.60735929e-01f, 3.76622528e-01f, -2.08833307e-01f, 3.49442542e-01f, -4.59693968e-01f, -1.87395930e-01f, -2.87019968e-01f, 2.09383145e-01f, -3.05114746e-01f, -4.63874601e-02f,
  -1.06305286e-01f, -1.94279104e-01f, -3.88037175e-01f, 5.65444410e-01f, 3.28224748e-01f, -2.47333378e-01f, -6.51685297e-02f, -8.07200074e-02f, -1.93898380e-01f, 5.50476126e-02f,
  1.21668056e-01f, 8.02262046e-04f, 4.05234754e-01f, -2.94583857e-01f, 1.33994803e-01f, -2.79201806e-01f, 2.87121326e-01f, -5.02083898e-01f, -3.30334604e-01f, -3.95492882e-01f,
  1.40417233e-01f, 3.39759350e-01f, -3.52631420e-01f, -3.76154155e-01f, -1.14763722e-01f, -4.13317829e-01f, 1.16250582e-01f, -2.95376271e-01f, -2.57113487e-01f, 2.77920663e-01f,
  -2.12399647e-01f, -3.61320853e-01f, 3.01729202e-01f, 1.49754286e-01f, 1.46817744e-01f, 3.33664447e-01f, -1.79969221e-01f, -1.54441163e-01f, -8.53508413e-02f, 2.03790843e-01f,
  3.89861837e-02f, -6.90755472e-02f, 2.39865854e-01f, -1.79918960e-01f, -1.29746512e-01f, 2.92499095e-01f, -5.14765620e-01f, 4.41858657e-02f, -1.59112751e-01f, 3.51987660e-01f,
  4.70248759e-01f, -2.03568742e-01f, -3.18864912e-01f, -5.15378475e-01f, 1.34195462e-01f, -4.06097800e-01f, 2.04700097e-01f, 1.39603496e-01f, -4.68737245e-01f, -5.21135390e-01f,
  -3.88128497e-02f, -4.01926309e-01f, 1.30193397e-01f, 3.78389537e-01f, -2.48737141e-01f, -6.20171010e-01f, -7.05237687e-01f, 9.13538709e-02f, 3.46915454e-01f, 3.90618414e-01f,
  2.81838894e-01f, 2.07764030e-01f, 5.29643963e-04f, -2.00206101e-01f, -1.39390886e-01f, -2.63177872e-01f, -4.06903088e-01f, 3.74270260e-01f, 3.55442077e-01f, -2.63946295e-01f,
  -3.38502198e-01f, 4.32328641e-01f, 4.31638509e-02f, -2.00744510e-01f, 3.78998220e-02f, 1.32725306e-03f, -1.75947219e-01f, 7.43459538e-02f, -1.49173006e-01f, 2.60136366e-01f,
  1.00258164e-01f, 2.27130158e-03f, 4.13055599e-01f, 2.75039881e-01f, -4.13565516e-01f, -3.01034063e-01f, 2.00869650e-01f, 2.62878805e-01f, 9.69537422e-02f, -4.66641873e-01f,
  2.03411087e-01f, -9.39779758e-01f, 2.03563362e-01f, 2.28882566e-01f, 3.37280661e-01f, 1.72942981e-01f, 1.75770015e-01f, 3.14385742e-01f, 5.53763270e-01f, 1.63311392e-01f,
  5.53279184e-02f, 4.08761293e-01f, 4.46657121e-01f, 2.43113324e-01f, 4.33819681e-01f, 1.89115003e-01f, -3.26223403e-01f, 3.59659567e-02f, -5.30822098e-01f, -5.37374556e-01f,
  -3.73034358e-01f, 2.65633792e-01f, -1.16246782e-01f, -1.78204756e-02f, -1.16295330e-01f, -5.10378122e-01f, 4.77759242e-01f, -4.67237741e-01f, -1.41729310e-01f, 1.77869722e-01f,
  -4.81514096e-01f, -1.40881268e-02f, 4.63497430e-01f, -4.93953407e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.09483856e-02f, -8.03428814e-02f, 1.05437011e-01f, -4.74025384e-02f, -1.23279974e-01f, -1.49823397e-01f, 1.31959185e-01f, 1.27503902e-01f, -2.32231781e-01f, -2.16292264e-03f,
  -1.60199285e-01f, 1.23726567e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    