/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.52493909e-01f, -8.96924455e-03f, -1.08832888e-01f, -2.32982159e-01f, -7.55485147e-02f, 4.44142312e-01f, 1.49719492e-01f, -1.12059470e-02f, 3.94953638e-02f, 1.64450601e-01f,
  4.96958978e-02f, -3.51569235e-01f, 2.69001752e-01f, -1.74860775e-01f, 1.00097410e-01f, 2.97174990e-01f, 2.07911897e-02f, -3.62425372e-02f, -3.19780782e-02f, 2.35860571e-02f,
  2.30385456e-02f, 7.67796710e-02f, -1.26900747e-01f, 6.68613687e-02f, -2.43764192e-01f, -1.91157982e-01f, -1.16206467e-01f, 1.77083351e-02f, -2.33968526e-01f, -1.22109562e-01f,
  2.47497205e-02f, -5.91183417e-02f, -6.43106923e-02f, -6.22603744e-02f, 3.17832939e-02f, 1.11798868e-01f, 6.81781620e-02f, 9.92065016e-03f, -9.31828097e-03f, -1.62979506e-03f,
  4.64736223e-02f, 4.19076998e-03f, 9.76683758e-03f, 2.20961589e-02f, -8.20394198e-04f, -4.20253538e-02f, -9.86102074e-02f, 4.70713675e-02f, -6.77725449e-02f, -1.05889395e-01f,
  -6.73898906e-02f, -4.72050235e-02f, -4.98310402e-02f, 5.69567317e-03f, -5.26521951e-02f, -4.43495139e-02f, -9.53943748e-03f, -3.73671874e-02f, -1.01693459e-01f, -6.30962700e-02f,
  9.93653461e-02f, -5.38565069e-02f, -5.50323240e-02f, -6.71274066e-02f, -4.67950925e-02f, -6.22563586e-02f, -2.73072142e-02f, 1.35914544e-02f, -5.40473312e-02f, 3.60403471e-02f,
  5.05315512e-02f, -3.21691297e-02f, -1.72432270e-02f, -6.05997369e-02f, 1.61268394e-02f, -5.12984507e-02f, 9.81654897e-02f, -2.76348721e-02f, -3.49993887e-03f, -9.57917348e-02f,
  5.36727570e-02f, 4.10977378e-02f, 4.53729853e-02f, 4.72847708e-02f, -2.89001851e-03f, -3.28658521e-02f, -1.40177971e-02f, -3.61662284e-02f, 1.84492732e-03f, 6.25957176e-02f,
  1.22690693e-01f, 2.15966910e-01f, 5.19782789e-02f, 1.07019786e-02f, -3.38130444e-02f, 1.16087347e-02f, -3.76523137e-02f, 2.42298115e-02f, 8.26843306e-02f, 8.61020461e-02f,
  5.83376288e-02f, 1.37956720e-02f, 3.26909907e-02f, 9.67341941e-04f, 8.14232416e-03f, 8.08592793e-03f, 3.29456814e-02f, -6.28129989e-02f, -2.15821732e-02f, -4.58659902e-02f,
  1.08315460e-02f, 9.28611010e-02f, 2.23135408e-02f, -4.20733057e-02f, 4.26011980e-02f, -3.37484553e-02f, -3.38612050e-02f, -3.12305503e-02f, 6.30773306e-02f, 7.04021305e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  1.79302797e-01f, -5.67733467e-01f, 2.00152203e-01f, 5.93154550e-01f, 2.78793186e-01f, -1.07291363e-01f, 8.06150436e-02f, 1.69588462e-01f, 3.65525723e-01f, -4.33125615e-01f,
  1.26961380e-01f, -3.08356375e-01f, -2.63556540e-01f, -4.57703732e-02f, 2.23684862e-01f, -1.67119294e-01f, -2.98401974e-02f, 1.56753715e-02f, 4.24194857e-02f, 8.27739686e-02f,
  3.62084925e-01f, 4.64426652e-02f, 5.69167957e-02f, -9.33946744e-02f, 1.68965757e-01f, 5.48172407e-02f, -5.14203906e-02f, -1.35591522e-01f, -1.26208380e-01f, -1.69263795e-01f,
  -1.95069667e-02f, 3.58012319e-02f, -5.86510263e-02f, -6.36584940e-04f, 1.67936347e-02f, -8.35423097e-02f, -1.59507006e-01f, -7.03185424e-02f, 1.26531452e-01f, 5.85404709e-02f,
  -7.18626603e-02f, 2.59937495e-02f, 5.13760857e-02f, 8.81755650e-02f, 7.68396482e-02f, 6.24517649e-02f, 5.21120839e-02f, 8.11223909e-02f, -2.33934727e-02f, -1.66212898e-02f,
  6.88627735e-02f, -4.86299954e-02f, 1.22285411e-01f, -1.01096593e-01f, 1.51432618e-01f, -1.51333017e-02f, -7.77735710e-02f, -4.66616452e-02f, 3.96691114e-02f, 1.91911943e-02f,
  -9.21751261e-02f, -1.08798280e-01f, 6.99498355e-02f, 8.63211900e-02f, 6.47717640e-02f, 8.24631602e-02f, -8.52614362e-03f, 2.35861428e-02f, 4.33079526e-02f, 3.87900732e-02f,
  3.31884772e-02f, 5.70966005e-02f, 1.08075812e-01f, -2.62609366e-02f, 9.80500015e-04f, 3.57273663e-03f, -2.43008304e-02f, 4.83100116e-03f, 4.97743972e-02f, 3.77741605e-02f,
  -8.23203921e-02f, 5.14078960e-02f, -9.13793817e-02f, 2.47036871e-02f, -3.48245725e-02f, 4.58534658e-02f, -2.02478375e-03f, 3.04192528e-02f, 8.52199718e-02f, -7.02834353e-02f,
  -4.51665930e-02f, -1.46518454e-01f, -6.00136891e-02f, -3.77600454e-02f, 1.87294371e-02f, -4.33535241e-02f, 4.08000220e-03f, 2.96341237e-02f, -1.05300397e-01f, 1.21838674e-02f,
  -2.32238602e-02f, 3.56877334e-02f, -9.15937051e-02f, 2.30223928e-02f, -3.75825837e-02f, 1.97931323e-02f, -2.76349261e-02f, -1.49130553e-01f, -1.79663654e-02f, -4.19046581e-02f,
  7.97395501e-03f, -2.07291208e-02f, -2.46790498e-02f, -1.65957827e-02f, -1.65414531e-02f, -1.48421386e-03f, 5.07011786e-02f, -1.32847548e-01f, -5.82771003e-02f, -2.22325828e-02f,
  1.83277532e-01f, -5.06245375e-01f, -7.94769764e-01f, -1.18825018e-01f, 4.78190362e-01f, 4.67754245e-01f, -1.21670589e-01f, 4.49818112e-02f, -5.27338147e-01f, 3.04996446e-02f,
  1.91554695e-01f, -3.65162581e-01f, -4.33888674e-01f, 1.30929559e-01f, 2.27665052e-01f, -4.46968913e-01f, 3.64444822e-01f, 1.00708038e-01f, -2.29640216e-01f, 2.19339831e-03f,
  4.50678617e-02f, 5.75318873e-01f, -2.32231691e-01f, 3.27963293e-01f, 1.77919894e-01f, -1.01598710e-01f, 2.86848515e-01f, -9.23012495e-02f, 5.23395240e-01f, 2.67473072e-01f,
  2.35142708e-02f, -1.67697683e-01f, -1.24543570e-01f, -1.15190633e-01f, 1.04707055e-01f, 1.12428591e-01f, -3.02793575e-03f, 1.65712759e-02f, -3.73564027e-02f, -1.21166341e-01f,
  -6.56955838e-02f, 5.04033491e-02f, 3.05532496e-02f, -8.15038830e-02f, 8.65215361e-02f, -2.20441781e-02f, -2.01894417e-02f, -1.21714540e-01f, -1.35508478e-01f, 1.12189967e-02f,
  -1.88236073e-01f, -2.38462277e-02f, 3.14568952e-02f, 7.95606896e-03f, -1.01258336e-02f, -5.50016798e-02f, 2.16132347e-02f, -9.28225592e-02f, 2.00845841e-02f, 9.98684019e-02f,
  1.65611342e-01f, 1.24827353e-02f, 2.33567785e-02f, -1.44397980e-03f, -2.55598500e-02f, 4.32537869e-02f, 3.91453691e-02f, 7.34930336e-02f, -1.14134789e-01f, 1.74744166e-02f,
  -1.11003565e-02f, 2.65843086e-02f, 7.05020577e-02f, 1.04118258e-01f, 5.27992919e-02f, -1.15850288e-02f, 1.02394130e-02f, 6.76393956e-02f, -1.07974615e-02f, -2.01128908e-02f,
  -9.61168259e-02f, 8.66794586e-02f, -2.23423727e-02f, -9.78104654e-04f, -1.83165874e-02f, 7.86787178e-03f, 1.10462487e-01f, -6.10590018e-02f, -5.34451120e-02f, 6.81175366e-02f,
  1.01475483e-02f, 7.70538598e-02f, -1.24884643e-01f, 3.66281383e-02f, -7.98867419e-02f, 1.78101689e-01f, -4.02678549e-02f, -6.02318086e-02f, 2.22094432e-02f, 3.69152017e-02f,
  1.31616846e-01f, 8.52019116e-02f, 1.32437736e-01f, 9.24504641e-03f, 1.52187599e-02f, 5.18469103e-02f, 1.94812138e-02f, 4.87207174e-02f, 1.52930364e-01f, 1.04890838e-01f,
  3.33267674e-02f, 1.04534961e-01f, 3.11968639e-03f, 8.62729829e-03f, 1.05279975e-01f, 2.77397186e-02f, 6.55427203e-02f, -1.11995591e-02f, 9.39397216e-02f, -1.38991728e-01f,
  -7.06531584e-01f, 3.36989462e-01f, 4.06787097e-02f, -6.60991073e-01f, 3.46771747e-01f, 2.80954177e-03f, -2.53105521e-01f, 3.18867266e-01f, -1.01485267e-01f, 1.07080616e-01f,
  1.50463656e-01f, -4.59163904e-01f, 3.40899378e-01f, -4.00924832e-01f, -5.59309602e-01f, 8.49551614e-03f, -4.43849355e-01f, -3.30348849e-01f, 9.98787731e-02f, -2.26565555e-01f,
  -2.20502138e-01f, -5.59368469e-02f, -6.67726547e-02f, 5.92507124e-01f, -9.71359685e-02f, 6.25040242e-03f, -1.07097283e-01f, 3.80242378e-01f, -2.27602467e-01f, 7.41931945e-02f,
  -1.25906244e-01f, -2.34169029e-02f, -3.20356898e-02f, 4.01587524e-02f, -9.99573246e-02f, -9.89339501e-02f, -1.20416887e-01f, -6.41718041e-03f, -5.52694574e-02f, 1.57803558e-02f,
  -9.38412175e-02f, 8.44860375e-02f, -2.78527103e-02f, 1.17231444e-01f, 4.94182445e-02f, 6.02877103e-02f, 2.77304724e-02f, -2.95859128e-02f, 4.67059985e-02f, 4.57835123e-02f,
  2.41545122e-02f, 4.41732593e-02f, -1.19193032e-01f, -6.55987114e-02f, 9.99728311e-03f, 7.29302615e-02f, -4.66087349e-02f, -1.02515332e-01f, -9.52816084e-02f, -1.67804472e-02f,
  4.09760065e-02f, 2.53412966e-02f, -2.14113314e-02f, 5.85984811e-02f, -8.65152571e-03f, 5.27244695e-02f, -1.85599774e-02f, 6.06168620e-03f, -1.54055445e-03f, -6.12725364e-03f,
  -6.81447610e-02f, -2.23055873e-02f, 9.10072327e-02f, -6.01915717e-02f, -4.35201861e-02f, 1.06021697e-02f, -7.25563243e-02f, -5.06783910e-02f, -3.69998738e-02f, -2.28595082e-02f,
  3.62404846e-02f, -5.54068796e-02f, 3.72554734e-02f, 4.46065841e-03f, 5.92955053e-02f, 7.54046366e-02f, 9.50322449e-02f, -1.15201192e-03f, 2.70836726e-02f, -3.61909643e-02f,
  -2.24334568e-01f, -2.00472921e-01f, 7.60247484e-02f, 8.33195075e-02f, -7.72551820e-02f, 5.14240116e-02f, -3.85577953e-03f, -7.20067248e-02f, -5.20722978e-02f, 2.16381028e-04f,
  -5.72186150e-02f, -8.20826441e-02f, -1.32968619e-01f, -2.40241159e-02f, -6.84615050e-04f, -3.86416912e-02f, -7.51489699e-02f, -1.14696547e-01f, -1.31332010e-01f, -1.59613155e-02f,
  -1.63393486e-02f, -4.01063124e-03f, -2.09129192e-02f, 3.24048139e-02f, -3.78085151e-02f, -7.13506192e-02f, -7.66622350e-02f, 4.54200152e-03f, 2.70918347e-02f, -4.89718206e-02f,
  -4.69214469e-01f, 5.76799631e-01f, 5.01958728e-01f, 9.84610841e-02f, 6.30233297e-03f, 5.77911913e-01f, 2.16334507e-01f, 2.24100858e-01f, 4.46104676e-01f, 1.23009808e-01f,
  -3.68919849e-01f, 2.68493474e-01f, -9.73834470e-02f, 5.76606542e-02f, 2.62750499e-02f, 2.01742694e-01f, 1.27609804e-01f, 1.67924270e-01f, 2.83456177e-01f, -6.18150719e-02f,
  -6.57624230e-02f, -1.52074009e-01f, -5.70347607e-02f, -6.70378283e-02f, -2.34574661e-01f, 6.72345832e-02f, -4.41230476e-01f, -3.74997430e-03f, -7.82456398e-02f, 9.23257843e-02f,
  -5.90579957e-02f, -3.98116894e-02f, -1.77050814e-01f, 1.16325811e-01f, -3.60692069e-02f, 1.34058082e-02f, 2.33132858e-02f, -3.85968806e-03f, 2.82969940e-02f, 4.56875823e-02f,
  -1.44141689e-02f, 2.71172356e-02f, 4.55072522e-02f, 3.40849198e-02f, 1.27773732e-01f, 4.95912619e-02f, 5.03020585e-02f, -3.00390110e-03f, 2.46289670e-02f, 1.30322175e-02f,
  -3.50323394e-02f, 7.02009946e-02f, -7.83800632e-02f, 8.45328942e-02f, -4.16451544e-02f, 3.86281237e-02f, 9.96318161e-02f, 2.50521898e-02f, 7.12985322e-02f, 7.26692751e-02f,
  5.51967062e-02f, 1.27883121e-01f, 4.16529886e-02f, -3.92243848e-04f, 2.20638812e-02f, -8.83872285e-02f, 2.91680731e-02f, -1.16396971e-01f, 3.32278572e-02f, -9.41992477e-02f,
  -8.89771059e-02f, -2.13559397e-04f, 1.83760133e-02f, 1.11066081e-01f, -4.67162393e-02f, 1.04368240e-01f, -1.21106915e-01f, 2.65337154e-02f, 1.72061659e-02f, -5.55897765e-02f,
  -1.94279086e-02f, 5.28095402e-02f, -5.06926961e-02f, -7.98626244e-02f, 4.39781137e-02f, -1.08093880e-02f, -3.04892194e-02f, 2.56215166e-02f, 3.91173586e-02f, -7.58539662e-02f,
  3.81648652e-02f, 1.45082891e-01f, -8.04462656e-02f, -3.45587954e-02f, 3.43075581e-02f, -3.47725190e-02f, 8.55643451e-02f, -6.14918582e-02f, 1.10343389e-01f, 8.15926958e-03f,
  2.28484608e-02f, -2.18072962e-02f, 2.66311038e-02f, -6.93144575e-02f, 5.92111014e-02f, 1.15486301e-01f, 1.45760074e-03f, -5.97669918e-04f, 1.67335887e-02f, -2.02818308e-02f,
  -1.37104765e-01f, -7.91534595e-03f, 1.36837531e-02f, -1.02161095e-01f, -3.81053202e-02f, -9.18302536e-02f, 2.24675443e-02f, 1.70901176e-02f, -1.21049350e-02f, 2.55534351e-02f,
  -7.58188292e-02f, 3.85659218e-01f, 1.01764299e-01f, -7.21847340e-02f, -1.50387496e-01f, -3.74609679e-02f, -2.34604284e-01f, 6.07905500e-02f, -2.23351158e-02f, 1.37732685e-01f,
  -1.70195803e-01f, 2.08171457e-01f, 3.45866904e-02f, 1.07160501e-01f, -2.46899098e-01f, -2.54793838e-02f, -6.62026778e-02f, -2.88955458e-02f, 4.34638225e-02f, -2.49326900e-02f,
  -2.88729537e-02f, -1.94704652e-01f, 7.41132796e-02f, 8.56796876e-02f, -6.99498653e-02f, 6.31194785e-02f, -2.06278637e-01f, -1.20140605e-01f, -6.36768108e-03f, 2.69867443e-02f,
  -1.07306400e-02f, -1.14958599e-01f, 7.70990923e-03f, 8.79147556e-03f, -9.50280800e-02f, -3.33300158e-02f, -1.26706526e-01f, -2.22601704e-02f, -7.65597969e-02f, 6.36226013e-02f,
  5.95292784e-02f, -2.12910660e-02f, 4.11655344e-02f, 8.03359300e-02f, -6.80376366e-02f, 6.13974454e-03f, -1.81251615e-02f, 1.59060918e-02f, 5.96244447e-02f, 1.00921459e-01f,
  8.86140540e-02f, -2.74791270e-02f, -6.91801012e-02f, -5.37271285e-03f, 2.12002802e-03f, -4.74297069e-02f, 5.07561117e-02f, -1.10898860e-01f, -6.19102605e-02f, 2.76505444e-02f,
  -1.60110742e-02f, -1.12568036e-01f, 2.94195041e-02f, 2.44152024e-02f, -5.90530261e-02f, -6.64882213e-02f, -5.94535582e-02f, 1.40649891e-02f, 2.51866747e-02f, -9.62560996e-03f,
  -3.21013853e-02f, -2.83757858e-02f, -2.97460891e-02f, -6.60798252e-02f, 3.77238840e-02f, -3.40944305e-02f, 2.33715307e-02f, -1.95971597e-02f, -5.26583381e-02f, -4.35189940e-02f,
  2.63080597e-02f, 7.09647238e-02f, -4.02430035e-02f, 8.92643537e-03f, 1.26323961e-02f, 6.68006539e-02f, -2.61784648e-04f, 1.09388806e-01f, -9.25564989e-02f, -2.58655008e-02f,
  -2.24302411e-01f, -2.50767469e-01f, -3.46321538e-02f, -1.00883834e-01f, -1.45160789e-02f, -2.55527254e-02f, -1.72464848e-02f, -1.45283574e-02f, -7.24986568e-02f, -5.64945564e-02f,
  2.76219174e-02f, -6.43980652e-02f, -1.45496428e-02f, -5.71182072e-02f, -3.77385840e-02f, -7.17502162e-02f, -9.89304204e-03f, 3.34712751e-02f, -6.66379705e-02f, -5.68147153e-02f,
  7.11492598e-02f, -9.66532808e-03f, 7.50285015e-02f, -1.02423184e-01f, 5.11437934e-03f, -2.19781213e-02f, -2.58699767e-02f, -4.84397598e-02f, 1.37618789e-02f, -3.46018411e-02f,
  -7.81608403e-01f, 3.35458636e-01f, -7.86890760e-02f, -3.39704044e-02f, -2.25069568e-01f, 3.37026775e-01f, 5.10932565e-01f, -1.58131063e-01f, 4.59394008e-02f, 4.87123996e-01f,
  2.88094461e-01f, -2.14635208e-01f, 2.89949745e-01f, 3.45001996e-01f, -2.76953634e-02f, 5.88242650e-01f, 4.29792494e-01f, 3.35032761e-01f, 2.98224855e-02f, -1.13427326e-01f,
  -6.32709488e-02f, 2.37689301e-01f, 2.76997983e-01f, -3.69419679e-02f, -1.03371358e-02f, -2.30598122e-01f, 5.64057678e-02f, -1.30274877e-01f, -7.36979097e-02f, -4.71745618e-02f,
  -1.19968958e-01f, -3.30963969e-01f, -1.82384029e-01f, -3.40353884e-02f, 7.26160267e-03f, -1.61455631e-01f, -3.53376903e-02f, -1.14163019e-01f, -8.90846997e-02f, -5.53961135e-02f,
  -3.86235118e-02f, -7.01547414e-02f, -7.34852925e-02f, -8.85285363e-02f, -9.81656462e-02f, -1.28150448e-01f, -4.66291308e-02f, 3.92392091e-02f, -3.12373713e-02f, -2.46283207e-02f,
  6.12218417e-02f, 5.03626578e-02f, 1.25815839e-01f, 1.21414654e-01f, -2.43819021e-02f, 7.36951828e-02f, 6.77012503e-02f, 2.56279088e-03f, 5.35306055e-03f, -2.87664514e-02f,
  -7.26356506e-02f, -2.06263103e-02f, -7.40427244e-03f, 3.51577215e-02f, -1.90198403e-02f, 4.81378324e-02f, 4.55527492e-02f, 2.70502665e-03f, 6.47030305e-03f, 6.37123957e-02f,
  -8.27155411e-02f, 4.09543775e-02f, -1.31446903e-03f, 6.15886673e-02f, 4.34515849e-02f, 5.84299490e-02f, -1.35511253e-03f, 3.53564997e-03f, 1.36173321e-02f, 4.67229262e-02f,
  4.21551540e-02f, -4.44460325e-02f, 2.56803706e-02f, 6.33543134e-02f, 2.39182990e-02f, 3.03436257e-02f, 3.21284607e-02f, 9.64204967e-02f, 9.90074128e-02f, 5.14928512e-02f,
  2.00185124e-02f, -1.94936305e-01f, -5.08253649e-02f, -5.37890680e-02f, 1.00852819e-02f, 1.15983223e-03f, 7.39949048e-02f, -1.72919910e-02f, -1.25650642e-02f, -3.60488296e-02f,
  -1.12810815e-02f, 2.92060133e-02f, -4.04881351e-02f, -5.99880842e-03f, 3.60026062e-02f, 3.29772457e-02f, 3.80098708e-02f, -2.92948890e-03f, 7.61000961e-02f, 1.06443474e-02f,
  2.62931976e-02f, -2.91828997e-02f, -3.79925296e-02f, 8.17075605e-04f, 1.35875270e-01f, 8.84762108e-02f, -1.42859682e-01f, -1.54153943e-01f, -5.16508706e-02f, -1.99433329e-04f,
  -8.20015594e-02f, 3.34550738e-01f, 3.67912859e-01f, 2.10178792e-01f, -3.08943063e-01f, -3.93025815e-01f, -2.20987856e-01f, 8.15673247e-02f, -1.73278943e-01f, -6.56977966e-02f,
  7.36386003e-03f, 3.66666801e-02f, 2.47309413e-02f, 2.83843130e-01f, 3.21424812e-01f, 1.99000239e-01f, 1.24466896e-01f, 2.58820504e-03f, 8.62386078e-03f, 2.11830646e-01f,
  2.45320767e-01f, 1.64341092e-01f, 5.07604122e-01f, 1.70276836e-01f, 1.56093508e-01f, 1.40649006e-01f, 2.05989197e-01f, -1.59401577e-02f, 8.80029127e-02f, -2.10564006e-02f,
  -7.78750181e-02f, 2.31798410e-01f, 1.25668541e-01f, -6.61683129e-03f, 1.10401653e-01f, -1.39191160e-02f, 4.11232449e-02f, -2.55055502e-02f, -3.79303955e-02f, -7.60226399e-02f,
  8.64488557e-02f, -4.73648980e-02f, -1.82741508e-02f, -8.77190009e-03f, -1.37357369e-01f, -2.15520151e-02f, 7.22380588e-03f, -5.76058216e-02f, -7.96754435e-02f, -3.60100484e-03f,
  6.24486618e-02f, 5.00262231e-02f, 4.34151962e-02f, 7.07910508e-02f, 4.02695313e-02f, 1.27948560e-02f, 2.03676149e-03f, -1.26267718e-02f, 5.27411997e-02f, -1.37356231e-02f,
  4.12078202e-02f, -1.40783101e-01f, -7.15879723e-02f, -4.35093120e-02f, 1.50369825e-02f, 4.30651121e-02f, 1.02031361e-02f, 1.54848825e-02f, -1.02522215e-02f, -4.74114157e-02f,
  -5.72679080e-02f, 6.04704916e-02f, -6.37788102e-02f, -5.22145666e-02f, -1.91635396e-02f, 4.30685654e-03f, 4.30505723e-02f, 4.89530480e-03f, -1.83370765e-02f, 4.84726997e-03f,
  -1.35369981e-02f, -8.18558037e-04f, 2.10572667e-02f, -5.38118407e-02f, -6.72849417e-02f, -1.95717998e-02f, 9.06495452e-02f, 1.25819547e-02f, -4.79297042e-02f, 3.63720618e-02f,
  1.60236999e-01f, 3.40962052e-01f, -6.96025863e-02f, -1.17805108e-01f, 6.66287690e-02f, -4.28336114e-02f, -2.95836814e-02f, 5.91527000e-02f, 6.91528693e-02f, 1.09284066e-01f,
  -1.43146254e-02f, 9.23341233e-03f, 2.15542018e-02f, 1.69860050e-02f, 1.14758126e-03f, 8.61631259e-02f, -5.51881688e-03f, 9.60952342e-02f, 1.18872799e-01f, 1.03450358e-01f,
  7.77387917e-02f, -3.98438796e-02f, 1.24938473e-01f, -4.46769781e-03f, 4.47996818e-02f, -4.89348918e-03f, -2.31479164e-02f, 7.50758797e-02f, 1.07783899e-01f, 6.48598969e-02f,
  9.97477584e-03f, -3.73304456e-01f, 1.72092095e-01f, 3.27455699e-01f, 1.01270229e-01f, -1.22085951e-01f, -1.52122781e-01f, 1.13693699e-01f, -1.97237264e-02f, -3.54965121e-01f,
  -8.10407773e-02f, -1.29920349e-01f, -3.32338512e-01f, 1.71714038e-01f, 4.18993682e-01f, -2.94811409e-02f, 2.61413425e-01f, -6.23293221e-03f, 1.90921888e-01f, 1.60523161e-01f,
  4.45595205e-01f, 2.14790419e-01f, 4.23542500e-01f, 2.51177698e-01f, 2.14645922e-01f, 1.87454239e-01f, 9.09220725e-02f, -2.53764242e-02f, 2.13990614e-01f, -1.46172242e-02f,
  -4.34462316e-02f, -1.07863672e-01f, -1.30177010e-02f, -1.57645089e-03f, -3.10259499e-02f, 1.32055236e-02f, 9.83029511e-03f, -3.20426859e-02f, 3.60774696e-02f, -3.02823111e-02f,
  -4.86047007e-02f, 7.82919079e-02f, 5.40675782e-02f, 3.39859724e-02f, 6.93835393e-02f, 5.98309487e-02f, 8.17071646e-03f, 5.52233262e-03f, 7.59520978e-02f, 1.70015283e-02f,
  1.76730249e-02f, 1.05948351e-01f, -6.01875875e-03f, 1.25407010e-01f, 4.39990778e-03f, 2.78151929e-02f, 3.11520994e-02f, 7.20841298e-03f, 2.62235850e-02f, 5.93365207e-02f,
  4.07578945e-02f, 9.17701870e-02f, -9.09479633e-02f, 3.43082519e-03f, -1.11304425e-01f, -3.35272625e-02f, 3.30450125e-02f, -1.07875906e-01f, -1.28569780e-02f, -4.39457372e-02f,
  1.74877478e-03f, 7.15312064e-02f, 1.66582670e-02f, 5.73083051e-02f, -1.43712359e-02f, 3.63522507e-02f, 1.61252134e-02f, 2.96103638e-02f, -1.53282546e-02f, 8.67693201e-02f,
  4.70863581e-02f, -2.24099979e-02f, 6.75549060e-02f, 5.99839687e-02f, 7.20854709e-03f, 3.00834980e-02f, -2.82727107e-02f, -2.64867656e-02f, 1.13756573e-02f, 6.26025870e-02f,
  -1.09202407e-01f, -2.18889490e-02f, 1.23701841e-02f, 1.95514355e-02f, -6.02705218e-02f, -3.95035073e-02f, 7.73398951e-02f, 6.31600469e-02f, -1.63264573e-02f, -7.66897425e-02f,
  -4.18600757e-05f, 3.30082886e-02f, 2.75944602e-02f, 5.45649119e-02f, 7.23957121e-02f, -2.49047931e-02f, -9.14112199e-03f, 4.48714234e-02f, -3.10333967e-02f, -1.22610368e-02f,
  4.45897840e-02f, -2.63795294e-02f, -4.01189998e-02f, -9.76524409e-03f, 5.84085518e-03f, 1.16439792e-03f, -5.19965019e-04f, 8.64246860e-03f, 9.01126415e-02f, 8.34515542e-02f,
  1.58017082e-03f, -1.10097472e-02f, -1.01053774e-01f, 7.06350580e-02f, 3.72020938e-02f, -1.55666798e-01f, -1.84033766e-01f, 5.23912907e-02f, 4.59437102e-01f, -1.21643357e-01f,
  -1.98670998e-01f, 2.55794048e-01f, -1.02850618e-02f, -2.01339155e-01f, 4.65859734e-02f, -1.19834663e-02f, -4.80781756e-02f, 1.56457558e-01f, 2.78238922e-01f, -6.56839460e-02f,
  2.11474523e-02f, -2.37476632e-01f, -3.35649669e-01f, -2.39710227e-01f, -2.64389366e-01f, -1.26984436e-02f, -1.32630602e-01f, -1.26826882e-01f, -3.18168432e-01f, -7.14249387e-02f,
  9.95351467e-04f, 1.94601685e-01f, -8.11274815e-03f, 2.50363839e-03f, -7.34202266e-02f, -6.43684492e-02f, -5.94430193e-02f, -3.45840305e-02f, 9.83286053e-02f, -1.08330348e-03f,
  4.65854593e-02f, 4.45489250e-02f, -1.09641114e-02f, -1.03131793e-01f, 1.13813497e-01f, -1.07885554e-01f, 7.81083629e-02f, -7.23110838e-03f, -6.57912670e-03f, -8.96849483e-02f,
  -2.34544612e-02f, 7.74676949e-02f, 1.16269268e-01f, 1.60775214e-01f, 3.02388687e-02f, 3.75492759e-02f, -5.12803011e-02f, -1.01475954e-01f, -6.20861836e-02f, 6.34640381e-02f,
  4.63089645e-02f, -1.93846645e-03f, -4.95632887e-02f, -7.03395531e-02f, -4.24623825e-02f, -1.23976846e-04f, -1.63037293e-02f, -1.01997070e-01f, 5.25237992e-02f, -3.53493690e-02f,
  3.22452411e-02f, 2.27863155e-02f, 9.70008597e-02f, 1.06637413e-02f, 3.53678316e-02f, 1.31480291e-01f, 2.68069319e-02f, 4.53424687e-03f, 9.25055072e-02f, 8.34247842e-03f,
  -1.47374310e-02f, -2.06040703e-02f, -1.09595796e-02f, -8.75345618e-02f, -6.15305565e-02f, 1.41291162e-02f, 6.20006875e-04f, 1.19202808e-02f, -1.34312985e-02f, -4.04245593e-02f,
  1.03926077e-01f, 2.88688913e-02f, 3.22276354e-03f, 6.78278599e-03f, 2.37068888e-02f, 3.00227734e-03f, 1.16573693e-02f, -4.81028482e-02f, 1.04148202e-01f, -3.41852307e-02f,
  -7.79206958e-03f, -4.68354719e-03f, -1.96070895e-02f, -6.04051501e-02f, 1.15875356e-01f, -1.17360361e-01f, -3.50951031e-02f, 1.56373590e-01f, 4.64350283e-02f, 3.86243276e-02f,
  -2.79204883e-02f, 4.95675094e-02f, -2.48955470e-02f, 8.06852710e-03f, 3.76753509e-02f, 2.91684759e-03f, -1.62463970e-02f, 4.04276550e-02f, -1.26814261e-01f, 7.79767781e-02f,
  -3.82472165e-02f, 3.34901392e-01f, 1.47354916e-01f, -7.04164952e-02f, 6.57641739e-02f, 1.26763180e-01f, 3.06423176e-02f, -6.25783578e-02f, -1.22911841e-01f, 4.02134180e-01f,
  -2.06939161e-01f, 2.81953394e-01f, -1.44408733e-01f, -2.43890792e-01f, -9.66231704e-01f, -4.60746706e-01f, -2.04073474e-01f, 3.00719664e-02f, -2.40792036e-01f, 1.30536243e-01f,
  -2.27193952e-01f, -3.55450183e-01f, -1.53452963e-01f, -3.42621319e-02f, 2.96720505e-01f, 2.76569545e-01f, -1.74097009e-02f, 9.14241150e-02f, 2.13304386e-01f, -2.18142062e-01f,
  -4.28166315e-02f, -4.28030603e-02f, 1.21786229e-01f, 2.72442792e-02f, 4.56193648e-02f, 5.44339903e-02f, 1.73005298e-01f, -1.37564451e-01f, -4.03511561e-02f, -5.12285344e-03f,
  1.39224902e-01f, 1.83442123e-02f, -1.00412764e-01f, -4.62991260e-02f, 1.82041526e-01f, 4.78851721e-02f, 3.56862023e-02f, 5.17632775e-02f, 1.23181939e-01f, 6.62701158e-03f,
  1.21509291e-01f, 1.66624077e-02f, 1.50114834e-01f, -1.29422331e-02f, -6.56785350e-03f, 5.87535873e-02f, -1.53915221e-02f, 7.28870928e-02f, 1.69035107e-01f, -4.21278104e-02f,
  -6.67329580e-02f, 3.44816335e-02f, -1.01262487e-01f, 6.58763498e-02f, -5.76592013e-02f, -1.18218735e-02f, 5.08540403e-03f, -3.76811028e-02f, -1.71139147e-02f, 3.84099036e-02f,
  2.03170516e-02f, 4.52056080e-02f, -5.09681515e-02f, 4.85510267e-02f, -3.75765599e-02f, 1.76588092e-02f, -1.20433467e-02f, 3.40300351e-02f, 1.86557043e-02f, -3.67126986e-02f,
  -6.72065318e-02f, 2.70288605e-02f, 1.19864556e-03f, 9.41737443e-02f, -6.97664544e-02f, -3.39778848e-02f, -4.24930044e-02f, 7.95493424e-02f, -8.49405527e-02f, -2.85976864e-02f,
  -5.56689920e-03f, 2.87851784e-02f, 5.01313955e-02f, -4.14708480e-02f, 1.76642723e-02f, 1.78615842e-02f, -8.54456127e-02f, -1.56805404e-02f, -1.23777064e-02f, 6.05350873e-03f,
  1.00732684e-01f, 1.17283449e-01f, 3.70527618e-02f, 7.86909461e-03f, -7.38436058e-02f, 3.61894583e-03f, -1.47545859e-02f, -4.20932025e-02f, 2.84055658e-02f, -6.31245896e-02f,
  1.87902719e-01f, 3.40160504e-02f, -2.86285989e-02f, 2.11763624e-02f, 7.33337626e-02f, 3.38228792e-02f, 3.61476019e-02f, 8.92064050e-02f, -2.65643653e-02f, 1.96598954e-02f,
  -1.73211083e-01f, -3.12256098e-01f, 4.49349433e-01f, -1.75138086e-01f, 1.84523284e-01f, 4.87418622e-01f, 3.93588245e-01f, -1.44291356e-01f, -4.32377726e-01f, -4.71142471e-01f,
  -1.83714747e-01f, -8.44593868e-02f, 4.38081563e-01f, -2.40486398e-01f, 5.46515703e-01f, 3.07530761e-01f, -1.79319263e-01f, -1.38963789e-01f, -4.39439230e-02f, -2.71814942e-01f,
  -6.46579415e-02f, -2.34501526e-01f, 3.65328431e-01f, -2.09160998e-01f, -7.26210028e-02f, -2.12585986e-01f, -1.36599153e-01f, 3.37672293e-01f, -1.89386278e-01f, 1.53506771e-01f,
  -4.73942794e-02f, -2.17668787e-01f, 1.18593343e-01f, 1.30967302e-02f, -2.33570356e-02f, 5.64544909e-02f, 1.16050445e-01f, 2.47051507e-01f, 5.22011593e-02f, -2.96250489e-02f,
  4.37517539e-02f, 1.64643526e-02f, -2.06859484e-01f, 2.01869532e-02f, -3.45982313e-02f, -3.41205932e-02f, 1.50911734e-02f, 1.19761601e-02f, 4.55185920e-02f, 9.71969888e-02f,
  1.03208706e-01f, 2.74842121e-02f, 7.30976462e-02f, -3.73208448e-02f, 1.27131566e-01f, -2.08263434e-02f, 4.40063588e-02f, 1.63112015e-01f, -4.05175388e-02f, -1.45149261e-01f,
  -8.45210627e-02f, 2.00587488e-03f, 2.30955295e-02f, -8.34696963e-02f, 1.27077252e-02f, -8.03558156e-02f, -7.65585620e-03f, -2.47438997e-02f, 2.34704223e-02f, -1.82424411e-02f,
  -1.61972679e-02f, -6.31026402e-02f, -1.55953160e-02f, 1.81318186e-02f, -9.92643684e-02f, -5.99526241e-02f, 4.10650857e-02f, 2.74543595e-02f, -5.62788248e-02f, 2.01526415e-02f,
  1.60849746e-02f, 2.94160401e-03f, -2.91638318e-02f, 4.29823995e-02f, -3.34181450e-02f, 6.48993328e-02f, -1.04876071e-01f, -3.18239001e-03f, 1.97184016e-03f, 8.64175037e-02f,
  -1.24215201e-01f, -4.39911604e-01f, -4.78049926e-02f, -4.71482314e-02f, -8.98971185e-02f, -8.18308517e-02f, -3.53016406e-02f, -1.46774471e-01f, -2.84859817e-02f, -5.13612032e-02f,
  -5.74997291e-02f, -3.78112644e-02f, -5.86905256e-02f, -6.50381222e-02f, 3.45179886e-02f, -6.28998056e-02f, -1.59537755e-02f, -7.89749101e-02f, -5.74447364e-02f, -6.33309633e-02f,
  -3.18017304e-02f, 9.30012204e-03f, 4.97178361e-03f, -2.65092999e-02f, -4.03502099e-02f, -1.48625011e-02f, -8.17402601e-02f, -3.48934010e-02f, -6.59560598e-03f, 1.32325282e-02f,
  -7.79588567e-03f, 2.76611894e-01f, -2.57519074e-02f, 3.26380357e-02f, -2.76482075e-01f, 7.02851489e-02f, 9.19728205e-02f, 1.67217478e-02f, -6.56784102e-02f, 1.46229997e-01f,
  1.90121338e-01f, 1.79219507e-02f, 1.01843134e-01f, 3.40844691e-01f, 3.18187252e-02f, 1.17549375e-01f, 1.66929632e-01f, 9.51538086e-02f, 1.26716673e-01f, 1.31931975e-01f,
  1.11124061e-01f, 2.65203446e-01f, 1.48193777e-01f, 9.71963853e-02f, 7.58721232e-02f, -8.78236741e-02f, 7.90219232e-02f, -6.36999756e-02f, 1.39576167e-01f, 5.77644035e-02f,
  8.80638063e-02f, 4.60123718e-02f, -4.96659689e-02f, -9.60613042e-02f, 6.45297095e-02f, -7.84799233e-02f, 2.60183066e-02f, 4.24168371e-02f, -1.39055207e-01f, 3.83137800e-02f,
  -3.51100937e-02f, 6.67157816e-03f, 1.04140185e-01f, -2.26737466e-02f, -5.22762239e-02f, 3.11612319e-02f, -9.31150615e-02f, -2.58215540e-03f, 1.49538843e-02f, 4.99790199e-02f,
  3.70659269e-02f, -1.77668929e-02f, 2.26771683e-02f, -3.86163816e-02f, 6.90916330e-02f, -1.00487888e-01f, 5.02629951e-02f, -5.92407472e-02f, 1.36267310e-02f, 2.87885405e-02f,
  4.32592817e-02f, 6.97654858e-02f, 1.05918549e-01f, -2.71884026e-03f, 9.64924635e-04f, 4.00342718e-02f, 3.19885537e-02f, -3.52834053e-02f, 3.33962105e-02f, 4.69706543e-02f,
  6.99993968e-02f, -9.47842970e-02f, 7.34200552e-02f, -3.52598317e-02f, -3.24967876e-02f, 4.49643470e-02f, -1.13508634e-01f, -3.54355983e-02f, -8.18398222e-02f, -8.46614093e-02f,
  5.48274517e-02f, 2.10991129e-02f, -5.51506924e-03f, -1.91167872e-02f, 1.37098860e-02f, 9.92444158e-03f, 2.17978470e-02f, 1.00013658e-01f, -7.73457065e-02f, -1.65856387e-02f,
  1.74927101e-01f, 1.66703403e-01f, 9.38122794e-02f, 4.78881076e-02f, 4.93802391e-02f, 1.18947342e-01f, -2.74867248e-02f, -4.38990742e-02f, 7.17404410e-02f, 2.01203451e-02f,
  2.69443747e-02f, -2.91198306e-02f, 5.41761667e-02f, 1.36160376e-02f, -2.16535088e-02f, 1.05273798e-01f, 6.94922283e-02f, -8.91228393e-02f, -8.40427727e-02f, -6.69709817e-02f,
  4.28365506e-02f, -1.61380060e-02f, -4.38915938e-02f, 8.06398503e-03f, -8.44020471e-02f, -1.04384627e-02f, 3.13699096e-02f, 5.26131364e-03f, 6.19999729e-02f, 4.50208262e-02f,
  1.06812224e-01f, -2.30999887e-01f, -2.70447522e-01f, -1.68928117e-01f, -1.95092499e-01f, -4.51333940e-01f, -2.32131258e-01f, -1.61760837e-01f, 4.82677743e-02f, -6.44077212e-02f,
  -5.56736104e-02f, 1.79046690e-01f, 2.90730089e-01f, -3.18122417e-01f, 1.38840482e-01f, 2.87130296e-01f, -3.47423851e-01f, -1.56891376e-01f, -5.26645146e-02f, -1.89894497e-01f,
  -5.80238439e-02f, -2.27129579e-01f, -1.09265812e-01f, -2.49232188e-01f, -4.23816323e-01f, -1.88356161e-01f, 7.91714117e-02f, -1.62210599e-01f, -3.82323444e-01f, -6.34289011e-02f,
  -1.74682543e-01f, 1.39168603e-02f, -3.87975760e-02f, 1.20282322e-02f, -5.88748418e-02f, -8.95794556e-02f, -3.46508771e-02f, 5.04526012e-02f, -3.76009680e-02f, 4.50941995e-02f,
  8.94311890e-02f, -1.09379701e-02f, -5.95521508e-03f, 1.38424680e-01f, -8.62476602e-02f, -1.78581197e-02f, -9.00995731e-02f, -1.53383147e-02f, 3.55257466e-02f, -1.50650544e-02f,
  5.67522086e-02f, 8.82885791e-03f, -1.22826397e-01f, -5.76592758e-02f, 2.71737799e-02f, -7.24197254e-02f, -4.66559269e-02f, -3.90428975e-02f, 5.07585937e-03f, 4.52144332e-02f,
  3.89557728e-03f, 4.77942713e-02f, -1.75424851e-02f, -1.18660271e-01f, 3.30474190e-02f, 3.71560548e-03f, 2.89064720e-02f, -2.17361860e-02f, -1.80148166e-02f, 1.76263414e-02f,
  -3.13712023e-02f, 1.32722631e-02f, 5.47903515e-02f, -3.15346122e-02f, -3.58393677e-02f, 5.65623529e-02f, 8.36885627e-03f, 2.30623316e-02f, -6.89704642e-02f, -4.04573940e-02f,
  8.91779363e-02f, 4.31976095e-03f, 4.44054883e-03f, -2.85580102e-02f, -3.75702009e-02f, 1.11136816e-01f, -4.40814197e-02f, -1.56834777e-02f, 3.16300988e-02f, 2.49424521e-02f,
  -8.50476474e-02f, -9.54082385e-02f, -6.65531680e-02f, 1.05743445e-01f, 7.16725783e-03f, -1.77161898e-02f, -2.56465450e-02f, -4.89249788e-02f, -8.27620849e-02f, 2.11283155e-02f,
  -1.09181195e-01f, 2.78628301e-02f, -8.34619328e-02f, 9.14854333e-02f, -4.65619974e-02f, -6.25058636e-03f, -3.50845009e-02f, -4.44230661e-02f, -3.02225687e-02f, -2.52705626e-02f,
  -5.03731519e-03f, -3.88170481e-02f, 7.83208162e-02f, -5.31694181e-02f, -2.05594697e-03f, -3.52100804e-02f, -5.23668081e-02f, 4.35030125e-02f, -3.91103420e-03f, -6.01630881e-02f,
  -7.21252933e-02f, 3.17572355e-01f, 3.24114203e-01f, -9.09584165e-02f, -1.90784335e-01f, 7.69336745e-02f, -2.14793477e-02f, 4.47507165e-02f, -1.08970582e-01f, 1.50322497e-01f,
  -9.05242190e-02f, 2.41922796e-01f, 1.05830565e-01f, -3.14011872e-02f, -2.68032812e-02f, 5.69334486e-03f, -1.72517821e-02f, -6.37264773e-02f, -1.33053452e-01f, -6.60573542e-02f,
  -7.95833170e-02f, -2.32176289e-01f, 3.12472973e-02f, -7.70165175e-02f, -1.42157888e-02f, 3.54855917e-02f, -2.14411184e-01f, -6.50579482e-02f, 5.41589819e-02f, 5.24461046e-02f,
  1.51641457e-03f, -1.54451564e-01f, 3.75575684e-02f, 5.03511503e-02f, 2.09937394e-02f, 3.28568704e-02f, -7.47494549e-02f, -1.12612452e-02f, -2.01886278e-02f, 1.10429535e-02f,
  5.85755296e-02f, 7.46687800e-02f, 3.10361516e-02f, 7.11862147e-02f, -5.11029698e-02f, 1.34838879e-01f, 1.76164098e-02f, -1.14644319e-02f, 7.88432807e-02f, 6.65262118e-02f,
  1.50526822e-01f, -2.47409642e-02f, 3.58665129e-03f, -2.21094601e-02f, 9.97876376e-02f, -7.86376745e-03f, 3.09763495e-02f, -5.45068309e-02f, 1.05472580e-01f, 5.55933453e-02f,
  -9.70382467e-02f, -1.10911869e-01f, 3.52106355e-02f, 2.38630027e-02f, -4.06217873e-02f, -1.83641573e-03f, -2.43011247e-02f, -8.70782360e-02f, 3.19576263e-02f, -1.31955873e-02f,
  -1.11519527e-02f, -4.61321622e-02f, -3.37758996e-02f, -8.71797820e-05f, -7.74154440e-04f, -2.41079722e-02f, 6.70778472e-03f, -2.69802604e-02f, 5.21006547e-02f, 2.63447948e-02f,
  -2.65020281e-02f, -1.84977818e-02f, -4.06751642e-03f, -1.68856848e-02f, -2.29503643e-02f, 5.13753146e-02f, -4.01584543e-02f, 6.05709553e-02f, -9.10827965e-02f, -9.81488973e-02f,
  -7.71345496e-02f, -2.10961401e-01f, -1.74909662e-02f, 7.86017254e-02f, -7.39710256e-02f, 4.39340062e-02f, -6.15735464e-02f, 8.06040764e-02f, -3.83770466e-02f, -1.21011212e-02f,
  -5.80334105e-02f, 1.96536519e-02f, -1.87649708e-02f, 6.08678460e-02f, 2.72456128e-02f, -6.54866770e-02f, -7.81975240e-02f, 4.29200679e-02f, -1.47993006e-02f, -5.13629653e-02f,
  4.35857624e-02f, -2.89990269e-02f, 7.89321959e-02f, -3.47698033e-02f, -2.97277439e-02f, 1.45707456e-02f, -8.56477618e-02f, 4.69830818e-02f, 1.64440740e-02f, -1.08211793e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.79024214e-01f, 5.56632876e-01f, 7.28619814e-01f, 6.13653839e-01f, 2.07938850e-01f, 2.38192260e-01f, 5.08106090e-02f, 4.23147440e-01f, 2.48199612e-01f, 6.52762711e-01f,
  4.12384540e-01f, 2.26842314e-01f, 1.88931718e-01f, 8.94481465e-02f
};

// L1_fan_Wp (Shape: 1 x 16)
const int L1_fan_Wp_rows = 1;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -1.16051771e-01f, -1.05630979e-01f, -1.02110170e-01f, -3.17968816e-01f, -7.55804107e-02f, 3.79512519e-01f, 1.43629864e-01f, -3.83305520e-01f, 5.22703864e-02f, -2.03903899e-01f,
  2.90212095e-01f, 4.05635476e-01f, -4.43965465e-01f, 5.82807139e-03f, 2.42506161e-01f, -3.72783206e-02f
};

// L1_fan_Wp_bar (Shape: 14 x 16)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -3.40970159e-01f, -2.49003336e-01f, -1.44141153e-01f, -2.64274299e-01f, -1.83391482e-01f, 3.89413029e-01f, -8.89872164e-02f, 4.23808396e-02f, 7.04688864e-05f, 8.26190710e-02f,
  2.79062152e-01f, 4.63959537e-02f, 5.79498559e-02f, -1.04278579e-01f, 5.02595305e-01f, 1.13814786e-01f, -3.90216589e-01f, 8.33308697e-02f, -2.23981440e-01f, -2.62355059e-01f,
  -6.38162568e-02f, -7.16052726e-02f, 1.41172677e-01f, 1.89070195e-01f, -1.14690654e-01f, -6.69394135e-02f, 3.00438076e-01f, -2.99319267e-01f, 4.06715810e-01f, -1.50636509e-01f,
  6.72852159e-01f, 1.88816190e-01f, -1.16006844e-01f, 3.84109765e-01f, -2.75915742e-01f, 1.11993980e+00f, -1.75237268e-01f, -3.44557129e-02f, -2.89926678e-01f, 6.21666670e-01f,
  -2.50126034e-01f, -3.40991206e-02f, -1.53443575e-01f, 2.99754679e-01f, -5.01233101e-01f, 2.66303599e-01f, 7.64612108e-02f, -1.07746385e-01f, 9.23546404e-02f, -3.54136676e-01f,
  6.56939030e-01f, -3.27086776e-01f, 1.14765120e+00f, 6.58989623e-02f, 1.93997398e-01f, -1.46099105e-01f, 6.70590043e-01f, 6.18040621e-01f, 3.58597875e-01f, -2.90393680e-01f,
  -2.54520923e-01f, 5.11900596e-02f, 3.62338692e-01f, -1.20804057e-01f, -2.39400879e-01f, -1.69526324e-01f, 1.28040358e-01f, 8.86572242e-01f, -4.18601006e-01f, -2.94092119e-01f,
  1.67347521e-01f, 1.17352560e-01f, 6.71603858e-01f, 7.37168610e-01f, -3.10877234e-01f, -4.02636588e-01f, -1.03374109e-01f, 2.64762163e-01f, -2.64054626e-01f, -1.96616024e-01f,
  -2.52227038e-01f, 5.65626740e-01f, -4.12101656e-01f, -4.18233693e-01f, 1.95053428e-01f, 1.06117225e+00f, 4.17612374e-01f, 6.22021079e-01f, 1.50355577e-01f, 2.81800508e-01f,
  1.93213329e-01f, 7.91523457e-02f, 4.78851311e-02f, 2.52784848e-01f, -2.34981075e-01f, 2.37399980e-01f, 2.74410844e-01f, 2.46043965e-01f, 5.97903430e-01f, 1.19434595e-02f,
  -5.90985268e-02f, 1.89590111e-01f, -2.07343042e-01f, -1.05189577e-01f, -2.49825507e-01f, 1.07329108e-01f, 2.57185042e-01f, -4.88467328e-02f, -4.45440970e-02f, -1.59720927e-01f,
  1.26089245e-01f, -2.62510806e-01f, 4.94368106e-01f, 4.61736381e-01f, 7.23994002e-02f, -9.03979968e-03f, -3.74298513e-01f, 6.61377013e-01f, -2.48500332e-01f, 7.06031382e-01f,
  3.98360103e-01f, 3.27646106e-01f, -3.21148008e-01f, -2.72113740e-01f, 1.32042086e+00f, 3.13575238e-01f, 2.80758619e-01f, 1.00138918e-01f, 4.96362358e-01f, 2.70075858e-01f,
  3.26701343e-01f, 3.05444151e-01f, 9.88675594e-01f, -2.13651076e-01f, -6.34275600e-02f, 7.13899508e-02f, -3.79946321e-01f, 1.55816123e-01f, -1.29997075e-01f, 6.53522134e-01f,
  -6.51316438e-03f, -2.73053169e-01f, -3.90717298e-01f, -1.08062655e-01f, 4.99564797e-01f, -1.46296009e-01f, 3.11176002e-01f, 8.96839976e-01f, 1.96427912e-01f, 2.86278546e-01f,
  -2.17896104e-01f, -2.21623033e-01f, -5.02361655e-01f, 3.44987929e-01f, 4.70851094e-01f, 5.20730495e-01f, -2.45383099e-01f, -9.21075344e-02f, -3.25201750e-01f, -2.85741568e-01f,
  -3.91775146e-02f, -4.01994765e-01f, -2.62999028e-01f, -2.63508797e-01f, 3.19576561e-01f, 5.63245058e-01f, 6.04533672e-01f, -2.63024718e-01f, 1.28709123e-01f, 3.10800169e-02f,
  -5.50100859e-03f, 9.85849917e-01f, -9.57463682e-02f, -4.31287736e-02f, -1.14171043e-01f, 5.54720581e-01f, -1.61701962e-01f, 4.53200489e-01f, -3.15675646e-01f, 4.08342183e-01f,
  -2.64419109e-01f, -3.58828939e-02f, 7.43247494e-02f, 1.09790492e+00f, -4.92881536e-02f, -2.62772799e-01f, -2.87541121e-01f, 6.50540531e-01f, -4.29293483e-01f, 3.42755347e-01f,
  8.14306885e-02f, -1.23395853e-01f, -1.45416543e-01f, -5.58776915e-01f, 6.44234359e-01f, 4.53957975e-01f, 1.28220171e-01f, -2.26203501e-01f, 1.94918051e-01f, -4.39586848e-01f,
  -4.21353370e-01f, 4.64020938e-01f, 5.01764596e-01f, -2.06855312e-03f, 3.41216415e-01f, -4.82794434e-01f, 4.93021458e-01f, -5.07495552e-02f, 6.01263046e-01f, 7.07509756e-01f,
  -3.03318441e-01f, 3.01474273e-01f, 1.03649592e+00f, 1.73358709e-01f, 5.42587861e-02f, 3.39249671e-01f, -9.95532274e-02f, -1.27064511e-02f, -3.47163528e-01f, -8.10572356e-02f,
  4.64575440e-01f, 3.65618803e-02f, 2.34679490e-01f, 1.42127737e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  4.31850433e-01f, -1.40382824e-02f, 4.46251899e-01f, 4.81903791e-01f, -2.77539976e-02f, 2.58321702e-01f, 2.60181129e-01f, 9.03081536e-01f, 1.30170792e-01f, 5.79981208e-01f,
  8.69943425e-02f, 4.38674331e-01f, 2.04527304e-01f, 1.25084087e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -2.56640494e-01f, -4.12388742e-01f, -6.71108812e-02f, 4.64754589e-02f, 3.13611865e-01f, -5.12450874e-01f, -1.70855537e-01f, 5.34612060e-01f, -3.11794817e-01f, 3.51242453e-01f,
  -8.03940669e-02f, -8.70426834e-01f, -2.71389246e-01f, 1.07656980e+00f, -4.61048037e-02f, 2.14059070e-01f, 6.74383566e-02f, -8.16181719e-01f, -3.04581881e-01f, -2.14799821e-01f,
  9.89421844e-01f, -5.90845764e-01f, 3.35627913e-01f, -4.76211399e-01f, 4.41687927e-02f, 7.84438178e-02f, -2.45054960e-01f, 1.75966188e-01f, -3.28873992e-01f, 6.15392566e-01f,
  -3.96945566e-01f, 2.95106888e-01f, -4.70431566e-01f, -3.49226713e-01f, 1.19677875e-02f, 2.06116363e-01f, 4.32044059e-01f, -1.04514547e-01f, 8.02155733e-01f, 1.16005037e-02f,
  -6.79108053e-02f, -5.44699490e-01f, -4.82033566e-02f, 5.02530694e-01f, -6.97189718e-02f, -2.23483548e-01f, 6.21835291e-01f, -3.30060333e-01f, -1.42316043e-01f, 4.97644514e-01f,
  -3.73188965e-02f, -2.79521942e-01f, -4.85872418e-01f, 7.79302537e-01f, -3.42114031e-01f, -1.29074931e-01f, -8.54080990e-02f, -8.05317640e-01f, 5.31446576e-01f, 4.34810529e-03f,
  3.00911665e-01f, -2.47275159e-01f, -2.22250119e-01f, 7.01282918e-01f, -6.20810986e-02f, -3.01361263e-01f, -3.40456992e-01f, -1.60029218e-01f, -3.69959295e-01f, 6.46312758e-02f,
  -8.72338787e-02f, 5.90137303e-01f, -1.36202544e-01f, 4.82827604e-01f, 2.19861537e-01f, -3.71510565e-01f, 1.47414565e-01f, -5.10620415e-01f, -3.20213020e-01f, 1.00660324e+00f,
  6.06365979e-01f, 9.03792441e-01f, 4.78985339e-01f, 1.09963678e-01f, -9.37679559e-02f, -1.79382741e-01f, -4.30339485e-01f, 1.00411284e+00f, 1.54672772e-01f, 5.11042833e-01f,
  -5.06155729e-01f, 1.12963907e-01f, -1.15207881e-01f, 1.04589328e-01f, -6.44428790e-01f, -2.08028212e-01f, 7.71239579e-01f, -5.86389363e-01f, -3.28477360e-02f, -1.98090628e-01f,
  -4.49649990e-01f, 4.90680546e-01f, -4.65826660e-01f, -4.09394681e-01f, 6.60172164e-01f, 1.29056096e-01f, 4.19116527e-01f, 5.82574844e-01f, -3.17945421e-01f, -5.18045306e-01f,
  5.85301578e-01f, -3.02741081e-01f, -1.10800583e-02f, 6.96943760e-01f, 5.26199996e-01f, 7.58327723e-01f, 4.75627854e-02f, 6.21027231e-01f, -1.41311422e-01f, -2.48070687e-01f,
  3.65670584e-02f, -4.47032779e-01f, -3.77523035e-01f, -1.96183562e-01f, -2.71102667e-01f, -2.35023871e-01f, 7.61840701e-01f, 2.04275399e-01f, 1.89691707e-01f, -4.09956276e-01f,
  1.24291159e-01f, 1.18272901e-01f, -1.96574420e-01f, 8.40389013e-01f, 8.96873236e-01f, -4.36138839e-01f, -1.58702865e-01f, 5.24846204e-02f, -2.76813567e-01f, -2.05530033e-01f,
  -1.91187337e-01f, -3.25968385e-01f, -3.12636882e-01f, -5.33458650e-01f, -1.28842965e-01f, -6.07343435e-01f, 2.38923773e-01f, 2.40082949e-01f, -4.29819793e-01f, -7.19457448e-01f,
  -7.90198892e-02f, -4.75457877e-01f, -4.93294559e-02f, 1.22990918e+00f, -2.50955582e-01f, -2.17065439e-01f, -5.25820255e-01f, -3.05385828e-01f, 2.56721139e-01f, 2.32508466e-01f,
  4.02404726e-01f, 2.41380408e-01f, -2.52339989e-01f, -2.07994193e-01f, 4.87735093e-01f, -3.66146326e-01f, -4.72771347e-01f, -3.49614143e-01f, 2.00822800e-01f, -8.15771937e-01f,
  9.49555695e-01f, 7.95029700e-01f, -5.39351888e-02f, 3.08257282e-01f, -8.20665881e-02f, 2.53165662e-01f, -6.19369328e-01f, 6.17740273e-01f, 3.45861286e-01f, -2.57784486e-01f,
  -1.00867279e-01f, -3.63225490e-01f, -3.22927892e-01f, 1.65725559e-01f, -3.08332860e-01f, -4.49129462e-01f, -1.75537407e-01f, 2.44066790e-01f, 1.21207464e+00f, 1.88666090e-01f,
  1.64683521e-01f, -5.00336409e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -5.57601869e-01f, 1.68031722e-01f, -5.51101685e-01f, 3.89010296e-03f, -1.51138604e-01f, 5.76071501e-01f, 3.95049334e-01f, -3.58328447e-02f, -2.01893821e-01f, 2.39823714e-01f,
  1.75103024e-01f, 2.39819035e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 1, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    