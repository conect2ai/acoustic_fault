/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.77192651e-02f, 1.19622543e-01f, 2.47242436e-01f, 1.00778222e-01f, 1.14155650e-01f, 1.86069205e-01f, 1.76111460e-01f, 1.38057634e-01f, 3.98344964e-01f, -2.29646871e-03f,
  -9.72998217e-02f, 2.66324520e-01f, 1.10108204e-01f, -1.16430625e-01f, 3.65285814e-01f, 1.26441807e-01f, -7.54752022e-04f, 8.51399004e-02f, 1.08184844e-01f, 5.12594208e-02f,
  9.95753258e-02f, -6.12468198e-02f, 2.70287991e-02f, -4.27104766e-03f, 9.19739902e-03f, 2.05359794e-02f, -4.98762093e-02f, 1.11350805e-01f, -7.25138858e-02f, 1.25653923e-01f,
  -9.12965909e-02f, -1.63142815e-01f, -2.76288748e-01f, -1.89511657e-01f, -1.51958078e-01f, -1.42204329e-01f, -2.70843711e-02f, -5.85449450e-02f, -5.85946888e-02f, -2.76303086e-02f,
  -6.24138080e-02f, -8.05110037e-02f, 6.25544861e-02f, -2.86086034e-02f, 7.03734681e-02f, -9.23292562e-02f, -9.46477950e-02f, -1.79172859e-01f, -1.94336455e-02f, 5.80276176e-02f,
  8.31962079e-02f, 8.60252082e-02f, 6.89677969e-02f, 4.40501496e-02f, -4.47180569e-02f, 1.02459557e-01f, 5.03518358e-02f, 9.84300375e-02f, 1.33291095e-01f, 5.31103797e-02f,
  8.74440446e-02f, -4.28474024e-02f, -9.41475704e-02f, -6.29342496e-02f, -7.13043213e-02f, -2.13856459e-01f, -6.47084489e-02f, -1.70727700e-01f, -1.64657801e-01f, -1.29712418e-01f,
  -4.59803380e-02f, -1.04109295e-01f, -7.19490275e-02f, 3.37781408e-03f, -7.85212312e-03f, 3.56767885e-02f, -1.96630135e-02f, -9.57693532e-02f, 8.15496221e-02f, -9.40381512e-02f,
  3.29308845e-02f, 8.22264999e-02f, -6.55611679e-02f, -8.37628171e-02f, -2.05766107e-03f, 1.01718225e-01f, -7.36578777e-02f, -1.37631465e-02f, 3.10172029e-02f, -5.47472350e-02f,
  1.01663247e-01f, 2.40419824e-02f, -2.29895234e-01f, -1.86873466e-01f, -1.38488084e-01f, -4.69223559e-02f, -5.74417114e-02f, -8.70268866e-02f, 1.50904795e-02f, 3.46728638e-02f,
  -1.17125511e-01f, -2.40863904e-01f, 4.09103893e-02f, 2.16518005e-04f, -1.78825390e-02f, -3.53168212e-02f, 6.71602339e-02f, -1.62050456e-01f, -5.21586416e-03f, -5.77625409e-02f,
  -9.46242064e-02f, 8.11754391e-02f, -8.35802108e-02f, -5.71432011e-03f, -2.34195009e-01f, 2.99303588e-02f, 8.93364176e-02f, 8.53676051e-02f, 8.52449052e-03f, 6.01154715e-02f,
  -2.03085333e-01f, -1.92477658e-01f, 9.95086655e-02f, -2.21063774e-02f, 1.74377412e-01f, 3.47935617e-01f, 2.24104151e-01f, 1.43156320e-01f, 1.73078805e-01f, -4.82353121e-02f,
  2.61381939e-02f, 1.25096023e-01f, -6.14313632e-02f, 1.41589671e-01f, 4.37859148e-01f, 9.72677320e-02f, 1.55892849e-01f, 2.38152500e-02f, -4.25900109e-02f, -1.59436271e-01f,
  1.14466257e-01f, 3.57313044e-02f, 2.39597112e-02f, -2.42122095e-02f, -6.79618269e-02f, -2.15778559e-01f, -2.30022799e-02f, 6.63168058e-02f, 1.69935096e-02f, 1.77198991e-01f,
  -1.23997234e-01f, -1.12169072e-01f, -3.28377225e-02f, -5.39820194e-02f, -2.73701828e-02f, -1.83406055e-01f, -1.86392024e-01f, -3.45016457e-02f, -5.04342690e-02f, 9.67379846e-03f,
  5.68159707e-02f, -3.06657329e-02f, 1.31599039e-01f, 5.32261431e-02f, -8.86966661e-02f, 7.48412162e-02f, 2.11826321e-02f, 8.84597823e-02f, 3.41692357e-03f, 2.94089857e-02f,
  1.39192104e-01f, -2.72760191e-03f, 3.14712711e-02f, 5.28228544e-02f, 1.45264074e-01f, 1.91219640e-03f, -2.32713427e-02f, 1.66727483e-01f, 8.47940706e-03f, 3.26142833e-02f,
  5.50968088e-02f, -4.08695228e-02f, -5.14389575e-02f, -1.10622890e-01f, 9.89194810e-02f, -4.58358079e-02f, -1.31980598e-01f, -6.83484301e-02f, -1.33748725e-02f, -9.60493740e-03f,
  -7.87199363e-02f, -1.23427130e-01f, -1.07336760e-01f, 1.16702370e-01f, -1.11322857e-01f, -6.03382941e-03f, -9.77562740e-02f, -2.04244480e-02f, 1.39160350e-01f, 6.83421493e-02f,
  -7.34602436e-02f, -9.08266194e-03f, 7.91529939e-02f, -2.30110094e-01f, -1.58684120e-01f, 2.37493992e-01f, -3.11557334e-02f, -2.18543150e-02f, -8.35021511e-02f, -3.60515416e-02f,
  -2.47710690e-01f, -1.70511857e-01f, 1.41926929e-02f, -1.60351753e-01f, -1.00982890e-01f, -3.14540751e-02f, -9.65830684e-02f, -4.95948233e-02f, -4.60218340e-02f, 6.01484105e-02f,
  7.03511462e-02f, -8.31248835e-02f, -4.36123461e-02f, -1.06227621e-02f, 3.73507738e-02f, 5.39556891e-02f, -7.06319809e-02f, 1.55922035e-02f, 7.76762962e-02f, -5.96619099e-02f,
  6.11344427e-02f, 2.23127846e-02f, 1.06244072e-01f, 1.75040245e-01f, 6.72743767e-02f, -1.75408721e-02f, -5.15302494e-02f, 1.12849370e-01f, 2.86726896e-02f, -8.47489759e-03f,
  2.73864157e-02f, -1.49218604e-01f, 9.77010932e-03f, 1.35191232e-01f, -1.00412266e-02f, -3.51650059e-01f, -2.29531005e-01f, -6.24078028e-02f, 8.96608382e-02f, -2.30419412e-01f,
  -2.63952345e-01f, -1.53366029e-01f, -1.51772007e-01f, 1.63959153e-02f, -7.89487064e-02f, 1.77319478e-02f, 1.06562592e-01f, -9.29887146e-02f, 9.51927006e-02f, 1.14634857e-01f,
  2.42926717e-01f, 2.84214709e-02f, 8.48049521e-02f, 1.19029820e-01f, -6.47547422e-03f, 5.46905287e-02f, -1.52474836e-01f, -1.32316679e-01f, -1.10717705e-02f, -2.46014819e-01f,
  -1.11119524e-01f, 3.12380474e-02f, 6.63627833e-02f, -7.10969418e-02f, -1.61901742e-01f, 8.26738253e-02f, -3.87148969e-02f, -1.29747078e-01f, 5.21101914e-02f, -1.25211580e-02f,
  -2.28908472e-02f, 2.06736792e-02f, -7.97418039e-03f, -2.66247671e-02f, -4.33731899e-02f, -1.50417937e-02f, 2.06039753e-02f, -3.11897285e-02f, 8.85948762e-02f, 4.61115576e-02f,
  1.93594061e-02f, -6.15584552e-02f, 5.57405166e-02f, 1.71506032e-02f, -6.97392449e-02f, -7.41996095e-02f, -2.92666722e-02f, -6.96497262e-02f, -5.60944267e-02f, 1.27692580e-01f,
  1.29930705e-01f, 9.24934000e-02f, -3.74227874e-02f, -6.37592077e-02f, -1.49513975e-01f, -1.38812838e-02f, 1.87140666e-02f, -1.62495613e-01f, -4.38365713e-02f, -1.74970016e-01f,
  -5.41015156e-02f, 1.43005466e-02f, 9.07931998e-02f, 3.63851264e-02f, -4.72082989e-04f, -8.27372372e-02f, -8.22263137e-02f, -7.73042664e-02f, -1.20467013e-02f, -5.98753467e-02f,
  -9.96620487e-03f, 1.19024245e-02f, -1.40899317e-02f, 8.72736517e-03f, -2.73365155e-02f, -7.35092238e-02f, 7.36540332e-02f, 2.83412356e-02f, -6.59776106e-03f, 2.60751750e-02f,
  -2.59178549e-01f, -1.36237428e-01f, -6.18849173e-02f, -1.47059560e-01f, -1.13013692e-01f, -3.36783528e-02f, 1.12689465e-01f, -4.71359454e-02f, -1.22186765e-01f, -5.06817363e-03f,
  3.21781114e-02f, -9.07963365e-02f, -1.30744977e-02f, -6.31503612e-02f, -3.48510668e-02f, 1.52356103e-01f, 6.60328940e-02f, -1.16759732e-01f, -2.29247361e-02f, -2.02493101e-01f,
  -7.97412097e-02f, -8.50071311e-02f, -1.77688934e-02f, -7.05711097e-02f, 3.26421410e-02f, -1.40462637e-01f, -3.69595364e-02f, 8.72358754e-02f, 5.36300130e-02f, 5.44475056e-02f,
  -8.13676268e-02f, -8.29575509e-02f, 3.17309260e-01f, 3.63883227e-01f, -1.06554873e-01f, 8.10924098e-02f, 3.76560986e-01f, -4.46643047e-02f, 1.21040650e-01f, -1.59010321e-01f,
  1.25732094e-01f, 1.52254030e-01f, 1.00809328e-01f, 4.09731716e-02f, 3.00445139e-01f, 1.50919706e-01f, 1.89065993e-01f, 1.43951222e-01f, 4.05512117e-02f, 1.21190436e-01f,
  3.31811942e-02f, -1.52107418e-01f, 3.09369922e-01f, -1.28756791e-01f, 9.50928219e-03f, 7.27891549e-02f, 7.67839625e-02f, 3.74636687e-02f, -5.25472537e-02f, 2.65311659e-03f,
  -1.80273950e-01f, -1.82822779e-01f, -1.27430081e-01f, -1.28527880e-01f, -4.28426340e-02f, -8.80559348e-03f, -1.72239151e-02f, 3.66809429e-03f, 6.19105883e-02f, -2.10926924e-02f,
  -3.38486731e-02f, -1.01935878e-01f, 7.48033170e-03f, -2.68735010e-02f, -7.73397908e-02f, -8.80130157e-02f, -1.18679389e-01f, 9.22364369e-02f, -2.83701606e-02f, 2.21431721e-02f,
  6.08848296e-02f, 3.80595103e-02f, -5.16667543e-03f, -3.82032432e-02f, 1.26578603e-02f, 5.22717535e-02f, 3.26131992e-02f, -1.79714467e-02f, 8.81589577e-02f, -2.34541204e-02f,
  -7.73572624e-02f, 1.44482106e-01f, 2.51141042e-02f, 3.08937952e-02f, -1.76848322e-02f, -1.13009647e-01f, 1.70239024e-02f, -5.84943853e-02f, 2.13369597e-02f, 2.59997901e-02f,
  1.31768733e-01f, 3.46036740e-02f, 2.62287701e-03f, 1.45444378e-01f, 9.22004730e-02f, 4.82464693e-02f, 1.12457179e-01f, -9.09459218e-02f, 5.62367700e-02f, 7.43308291e-03f,
  1.00172937e-01f, -9.59978774e-02f, -8.10988396e-02f, -7.15104565e-02f, 2.92693600e-02f, 6.43282533e-02f, -8.91478434e-02f, -2.90662069e-02f, -3.14691551e-02f, 1.01961195e-01f,
  4.95530926e-02f, 8.75965431e-02f, -1.33545712e-01f, -1.66612729e-01f, -3.68960351e-02f, 1.14549538e-02f, -7.03077912e-02f, -1.13072380e-01f, 3.43723372e-02f, -1.57969445e-02f,
  -6.27147183e-02f, -1.75978877e-02f, 1.02839738e-01f, -6.56657964e-02f, -7.85614625e-02f, -5.19827642e-02f, -9.29289963e-03f, 6.76199645e-02f, 5.43087302e-03f, -5.22203632e-02f,
  -9.40271188e-03f, 7.07924962e-02f, 1.83028728e-02f, -4.10108641e-02f, -4.22480293e-02f, 5.11495359e-02f, 2.67369095e-02f, -2.61433292e-02f, -6.87154159e-02f, 2.31312420e-02f,
  -5.56643261e-03f, 3.80121171e-01f, -1.16116568e-01f, -2.19323307e-01f, -6.25353167e-03f, 1.10379025e-01f, -5.40082119e-02f, 1.61937281e-01f, 1.06061466e-01f, 1.08932823e-01f,
  -7.08556548e-02f, -7.67833218e-02f, 1.01185940e-01f, -7.17500746e-02f, -8.03831220e-02f, -7.94312432e-02f, -7.21829310e-02f, -3.66240032e-02f, 5.67733087e-02f, -7.73494169e-02f,
  -1.39684845e-02f, 4.02314542e-03f, -2.39988372e-01f, 9.50762704e-02f, 1.59230810e-02f, 1.36221377e-02f, -5.06153107e-02f, 1.45448511e-02f, -9.07408148e-02f, -5.46796955e-02f,
  9.51209664e-02f, 2.38730405e-02f, -6.77849203e-02f, 4.87717576e-02f, -5.29509746e-02f, -2.20969796e-01f, -9.49566662e-02f, -6.03826158e-02f, -5.78269064e-02f, 7.33429715e-02f,
  4.91148531e-02f, -4.71978309e-03f, -2.88098156e-02f, -5.69457421e-03f, -3.44133154e-02f, 1.35093387e-02f, -1.71729662e-02f, -3.09900362e-02f, -5.80945574e-02f, -9.20094997e-02f,
  -4.66560423e-02f, -1.30609889e-02f, -2.07065754e-02f, 3.41048129e-02f, -2.12385692e-02f, -1.36543410e-02f, 2.66975956e-03f, -5.47156073e-02f, 1.35304444e-02f, -2.23239101e-02f,
  -4.70814668e-02f, 6.59133047e-02f, 5.43817924e-03f, 7.24166334e-02f, 1.60195991e-01f, 6.70497194e-02f, -4.21794914e-02f, -4.16768081e-02f, 1.74806993e-02f, -3.18960799e-03f,
  -3.86878923e-02f, -1.09212488e-01f, -3.89123539e-04f, -4.83253375e-02f, -3.12088504e-02f, -5.35175689e-02f, 5.50817605e-03f, 1.78463221e-01f, -9.03382897e-02f, -2.08308578e-01f,
  -2.41238549e-02f, 2.68877968e-02f, 5.37496060e-02f, -3.23423976e-03f, 9.60755162e-03f, -1.56605933e-02f, 1.24365926e-01f, 5.64661324e-02f, 2.64224745e-02f, -9.30030495e-02f,
  2.89207518e-01f, 2.53524274e-01f, 2.39192806e-02f, 6.15909919e-02f, -2.72944365e-02f, -9.85174924e-02f, -9.15700048e-02f, -9.31390896e-02f, -4.26381547e-03f, 6.43385947e-02f,
  4.23284993e-03f, 7.86011457e-04f, -8.78639147e-02f, -6.89744949e-02f, -2.58202236e-02f, -1.45726586e-02f, -6.11244403e-02f, 1.13551104e-02f, -4.19828370e-02f, 5.10422364e-02f,
  3.46134342e-02f, 6.05786480e-02f, -6.27083033e-02f, -8.84084962e-03f, -6.85286298e-02f, -8.77813175e-02f, 6.81431964e-02f, -3.33499536e-02f, 4.27937470e-02f, -4.49645184e-02f,
  4.55933452e-01f, -2.09045812e-01f, 3.50894891e-02f, 1.94141850e-01f, 6.08388782e-02f, -1.70984894e-01f, -1.20408252e-01f, 7.52972672e-03f, 1.26563877e-01f, -1.15667284e-01f,
  -1.88575268e-01f, 4.42717643e-03f, -2.33083114e-01f, -1.21456556e-01f, 2.14028642e-01f, -2.10213289e-01f, -6.83419704e-02f, -1.61447123e-01f, -5.81438281e-02f, -4.39452901e-02f,
  1.15998149e-01f, -2.09613685e-02f, -4.00694124e-02f, 1.14506679e-02f, 2.49634702e-02f, 1.73937947e-01f, 1.13152698e-01f, 7.89884105e-02f, 2.81561334e-02f, 2.00853646e-02f,
  7.97785223e-02f, 2.05170959e-01f, 3.29398885e-02f, 2.30183955e-02f, 3.95414867e-02f, 5.97036034e-02f, 5.38945794e-02f, 8.79737437e-02f, -7.44484412e-03f, 1.82629600e-02f,
  -8.37643296e-02f, 2.17481628e-02f, 7.35878572e-02f, -5.01102163e-03f, -1.09691299e-01f, 9.90334083e-04f, -1.41275534e-02f, -1.40222922e-01f, -4.73744944e-02f, 5.42053208e-02f,
  -6.93164244e-02f, -5.79197295e-02f, -3.10263466e-02f, -3.93984988e-02f, 1.03124954e-01f, -5.55234924e-02f, 7.23190978e-02f, 6.54210076e-02f, -8.78056791e-03f, 1.02316052e-01f,
  -6.62268922e-02f, 1.64354965e-01f, 7.97278434e-02f, -1.43982247e-02f, 7.84758329e-02f, 1.98631838e-01f, 2.48401240e-02f, 1.17604278e-01f, 1.17500752e-01f, -2.24805903e-02f,
  -4.69113216e-02f, 2.89014615e-02f, 1.34523297e-02f, -6.05772017e-03f, 6.79655597e-02f, 4.71715443e-03f, -1.24901861e-01f, 3.28965969e-02f, 1.58731658e-02f, 8.83338153e-02f,
  -1.04325162e-02f, -3.74866347e-03f, 1.99702615e-03f, -9.61986333e-02f, -1.28414303e-01f, -1.06973723e-01f, -4.57537919e-02f, -1.20687902e-01f, -1.26274144e-02f, 7.43769929e-02f,
  -1.96261215e-03f, 2.04224706e-01f, 6.83836639e-02f, 8.89656693e-02f, 3.56741957e-02f, -2.61905026e-02f, 7.85854533e-02f, 9.87519771e-02f, -4.44791578e-02f, 4.39615250e-02f,
  -1.97388809e-02f, 2.91407742e-02f, -5.95383830e-02f, -2.53485627e-02f, -6.69652149e-02f, 9.29734260e-02f, 6.13765558e-03f, -1.43214818e-02f, 7.61092734e-03f, -1.10958740e-02f,
  -2.87181442e-03f, -2.83098239e-02f, 2.05522422e-02f, 1.56497955e-01f, 1.00994790e-02f, -4.56675887e-02f, 1.26653954e-01f, 5.21367379e-02f, 6.66320696e-02f, -2.14918349e-02f,
  -3.48954469e-01f, 2.80108839e-01f, -4.02786732e-02f, -2.28656262e-01f, 7.47555494e-02f, 1.63321123e-01f, -6.35342523e-02f, 6.00844994e-02f, -6.59911856e-02f, 1.05259515e-01f,
  -1.98323652e-01f, 5.88389710e-02f, -6.54309243e-02f, -1.48164466e-01f, -1.85638085e-01f, -8.88446718e-02f, -4.38120179e-02f, -1.11316152e-01f, 7.86643103e-02f, -8.03204551e-02f,
  -1.11058019e-01f, -1.03749581e-01f, -5.09692580e-02f, 3.53738099e-01f, -2.80240662e-02f, 1.36366531e-01f, -2.23278161e-02f, 1.62112042e-01f, -8.88537169e-02f, 1.16871499e-01f,
  -5.31396046e-02f, -2.40109891e-01f, 1.01183109e-01f, 5.24550229e-02f, -4.62796055e-02f, -1.04045153e-01f, -6.50163218e-02f, 7.12642074e-02f, -2.99140252e-02f, 9.53265578e-02f,
  -3.77411731e-02f, 3.66231124e-03f, 1.10591851e-01f, 6.88532218e-02f, 9.74665657e-02f, 2.75674500e-02f, 1.38825029e-02f, 9.38364714e-02f, 2.17340291e-02f, -2.92829294e-02f,
  1.12092346e-02f, -4.06685546e-02f, -3.76035320e-03f, 2.79649924e-02f, -3.45808901e-02f, 8.03122073e-02f, 7.23131821e-02f, -1.23101706e-02f, -3.51880747e-03f, 4.72674333e-03f,
  -3.58562469e-02f, -2.28161998e-02f, 8.83299764e-03f, -2.10265582e-03f, -3.72239873e-02f, -4.38338891e-02f, 1.24024823e-01f, -1.14328759e-02f, 5.63039072e-02f, -5.84054627e-02f,
  -4.15800139e-02f, -5.01494892e-02f, -5.73198125e-02f, 2.21772417e-02f, -5.83375208e-02f, 4.19820473e-02f, 6.58218190e-02f, -1.06407151e-01f, -6.85134605e-02f, -4.57437616e-03f,
  3.56236361e-02f, -6.39416575e-02f, -2.08355002e-02f, 2.86637917e-02f, 1.19309485e-01f, -4.75166924e-02f, -1.15401208e-01f, -4.00573537e-02f, -1.85638648e-02f, -1.14363149e-01f,
  -1.44875377e-01f, -2.41218075e-01f, 1.99028682e-02f, 1.27189485e-02f, 1.02364093e-01f, 1.77386198e-02f, 4.92539257e-02f, 7.34467804e-02f, 6.95598423e-02f, -1.16439067e-01f,
  -4.19144556e-02f, 3.57543640e-02f, -1.34923579e-02f, 3.33729163e-02f, 1.08683873e-02f, 1.20028080e-02f, -1.31193280e-01f, 8.33690763e-02f, -5.79480268e-02f, 2.64933519e-03f,
  1.34247551e-02f, -1.76426191e-02f, 3.05865966e-02f, -9.53408033e-02f, -1.49336040e-01f, 3.23613212e-02f, -5.93622290e-02f, 5.29361852e-02f, -4.07140553e-02f, -4.27010050e-03f,
  -1.45264938e-01f, -2.09164530e-01f, -1.78275034e-01f, 6.87762583e-03f, 2.10499950e-03f, -1.05440393e-01f, 2.64045417e-01f, -1.71378758e-02f, 1.32292882e-01f, 1.14369556e-01f,
  2.01734483e-01f, 7.27289394e-02f, 1.65058166e-01f, -2.64535695e-02f, -2.93475669e-03f, 2.34875992e-01f, -2.84187663e-02f, 5.30223548e-02f, 1.00958213e-01f, -1.92429394e-01f,
  -5.03174476e-02f, -3.66184898e-02f, -6.36337996e-02f, -1.06510863e-01f, -1.04603596e-01f, -5.66967800e-02f, 4.08474430e-02f, 1.22582912e-01f, -1.45561084e-01f, 1.46005660e-01f,
  -1.08857170e-01f, -7.74756819e-02f, -4.07887846e-02f, -9.80488509e-02f, -1.33753076e-01f, -9.28504206e-03f, 2.04529352e-02f, 4.70318757e-02f, 9.61232781e-02f, 2.71328632e-02f,
  -1.25089074e-02f, -6.64181635e-02f, 5.95737994e-02f, 6.76462892e-03f, 8.45240131e-02f, -4.48460877e-02f, -3.03610954e-02f, -4.98734862e-02f, 2.95980293e-02f, 1.29397333e-01f,
  4.07272987e-02f, -3.99429463e-02f, -4.90721613e-02f, 1.11827098e-01f, 2.30804741e-01f, 8.94164890e-02f, 3.53175215e-02f, -3.76191363e-02f, 4.04956825e-02f, -5.22840135e-02f,
  1.86729640e-01f, -4.67853472e-02f, -1.17826024e-02f, -1.05267830e-01f, -4.94516790e-02f, -4.30769585e-02f, -7.11734369e-02f, -4.65917476e-02f, -3.12798843e-03f, -3.32270935e-02f,
  -2.46821325e-02f, 1.20696025e-02f, -5.70805836e-03f, 5.88568347e-03f, 4.56088893e-02f, -8.26223046e-02f, -1.17663600e-01f, -4.00866494e-02f, 7.26411566e-02f, 3.95332016e-02f,
  4.85612173e-03f, 4.99538481e-02f, -2.79393550e-02f, -8.26822221e-02f, -1.90761760e-02f, 9.87564772e-02f, -1.15438171e-01f, -2.81669889e-02f, -9.08401795e-03f, -2.95904726e-02f,
  -2.75953829e-01f, -2.41830662e-01f, 6.64844960e-02f, -2.25300379e-02f, -1.13912500e-01f, 4.49105576e-02f, -2.11191345e-02f, 2.37764250e-02f, 3.75661924e-02f, 5.56427762e-02f,
  -1.00746296e-01f, -3.33282873e-02f, -1.01842675e-02f, 3.87392119e-02f, 3.95193323e-02f, 9.17410925e-02f, 6.96181506e-02f, -4.04000171e-02f, 3.03414632e-02f, -1.15393572e-01f,
  -6.26775101e-02f, -4.21338081e-02f, -4.46566232e-02f, 8.95671993e-02f, 1.60520792e-01f, 3.12761553e-02f, 1.30033037e-02f, 4.76187654e-02f, 1.13741256e-01f, -2.46807002e-02f,
  2.63245821e-01f, 2.29109854e-01f, 1.33123055e-01f, 1.37271553e-01f, 5.65980971e-02f, -2.34381203e-02f, -5.95884733e-02f, 1.02326617e-01f, 1.78864852e-01f, -1.32236779e-01f,
  -1.84916645e-01f, 1.21919878e-01f, -1.82409674e-01f, -2.34483033e-02f, -9.72442329e-02f, -2.65496016e-01f, -5.72890714e-02f, -6.48961514e-02f, 5.99735370e-03f, 1.98651791e-01f,
  1.17513977e-01f, -1.00762486e-01f, 1.14663029e-02f, 9.91357863e-02f, 1.50652289e-01f, 2.27578223e-01f, -1.37460753e-01f, 1.53323039e-01f, -1.04530230e-02f, -1.16894618e-01f,
  5.87901846e-02f, 1.81859761e-01f, 1.13874286e-01f, 8.09752718e-02f, 2.89890487e-02f, 1.36414796e-01f, 1.06132708e-01f, 2.14662626e-02f, -3.64284031e-02f, -4.30453047e-02f,
  -8.54124799e-02f, -3.60285342e-02f, 5.58501109e-02f, -7.10173994e-02f, -4.63201143e-02f, -2.08837017e-02f, -1.53762447e-02f, -9.95494127e-02f, 8.64340290e-02f, 1.89207457e-02f,
  6.84244633e-02f, 3.77151519e-02f, -8.91974196e-03f, -6.31773397e-02f, -7.89128989e-02f, -6.09043874e-02f, -7.61247352e-02f, -7.14282785e-03f, -1.42136235e-02f, 8.34239721e-02f,
  -5.22990488e-02f, 5.49124219e-02f, 1.56765282e-02f, -5.27289137e-02f, -3.81557532e-02f, 2.52808299e-04f, 2.49463785e-02f, -5.55760674e-02f, -5.50951855e-03f, -4.25599255e-02f,
  1.05929906e-02f, 7.98949301e-02f, 5.46514280e-02f, 1.75727922e-02f, -1.01452820e-01f, 1.31161576e-02f, -3.75730842e-02f, -1.14085473e-01f, -6.19447120e-02f, 3.60958725e-02f,
  7.14398399e-02f, 6.66108057e-02f, -2.00332161e-02f, 1.68940146e-02f, -2.07606070e-02f, -3.08134295e-02f, -7.42666004e-03f, -8.99672955e-02f, 5.22182286e-02f, -1.11442441e-02f,
  9.21313614e-02f, 1.63710251e-01f, 4.32769582e-02f, 9.08531174e-02f, -1.06339827e-02f, 3.24608609e-02f, 1.20712869e-01f, 7.91351870e-02f, -7.98831433e-02f, -1.78915448e-02f,
  -5.22773676e-02f, -2.25071721e-02f, 2.73865322e-03f, 3.77846062e-02f, -4.60972972e-02f, 3.07044964e-02f, 1.19767701e-02f, -6.15503006e-02f, -9.87175480e-03f, -1.76440217e-02f,
  -4.85586599e-02f, -4.47720475e-02f, -3.82464342e-02f, 2.57916134e-02f, -1.19289927e-01f, -8.34950283e-02f, 2.56211534e-02f, 5.99817708e-02f, -8.90274271e-02f, 5.62711444e-04f,
  1.85172260e-01f, -1.93520054e-01f, -1.07131377e-01f, -4.37285937e-02f, 3.17204446e-01f, 2.51248807e-01f, 1.79013789e-01f, 3.35813151e-04f, -1.32517055e-01f, -1.60953462e-01f,
  1.01910301e-01f, -4.71390188e-02f, -5.49751073e-02f, -1.94813281e-01f, 2.04354987e-01f, -7.70287886e-02f, -1.36818578e-02f, 9.69606638e-03f, -4.21123765e-02f, 3.87073904e-02f,
  -4.42319140e-02f, 1.06274158e-01f, -7.03897476e-02f, -2.70395260e-02f, 7.99204186e-02f, -6.74103424e-02f, 3.06901596e-02f, -5.34202829e-02f, -1.46192079e-02f, 1.24827325e-01f,
  9.03481990e-02f, -1.83392972e-01f, -1.30366115e-03f, -9.67575759e-02f, 1.23140253e-01f, -1.85000375e-02f, -3.54604684e-02f, -4.63567376e-02f, -1.85017870e-03f, 3.93509865e-02f,
  -2.58261543e-02f, 4.39845845e-02f, 3.73319648e-02f, -1.15595803e-01f, 8.64760280e-02f, -4.30003777e-02f, 2.06280407e-02f, -6.45366358e-03f, -4.53880653e-02f, -1.42005850e-02f,
  -5.91275692e-02f, -9.25930031e-03f, -1.09431790e-02f, 3.24886441e-02f, 1.02766573e-01f, -3.02302884e-03f, -2.13940833e-02f, 2.84480657e-02f, 9.13887396e-02f, 1.13307238e-01f,
  8.72724652e-02f, -1.38982043e-01f, -9.33026522e-02f, -7.90464580e-02f, -3.71632501e-02f, -1.78222395e-02f, -8.90701041e-02f, -1.80292744e-02f, -1.70665737e-02f, 1.11822061e-01f,
  9.73963290e-02f, 3.63784330e-03f, -3.19268219e-02f, -1.73996240e-01f, 2.43806373e-02f, 6.12079585e-03f, 2.59271003e-02f, -4.90025326e-04f, 3.35900262e-02f, -9.18591861e-03f,
  -9.72325504e-02f, 7.60609508e-02f, 9.17746127e-02f, 7.53633529e-02f, 4.46742103e-02f, 8.62203315e-02f, -1.44561559e-01f, 6.16422482e-02f, -1.01033337e-01f, 4.28240597e-02f,
  2.08068788e-01f, -2.98635978e-02f, -3.41729559e-02f, 5.49750254e-02f, 4.41330438e-03f, -5.13235712e-03f, -1.78022623e-01f, -2.27130745e-02f, 3.38541530e-02f, 2.32258495e-02f,
  -7.56655037e-02f, 9.17274728e-02f, 4.64649461e-02f, 2.27585509e-02f, 3.50357890e-02f, 1.14817977e-01f, 1.34746283e-02f, 6.34047836e-02f, 1.83290184e-01f, 7.58092925e-02f,
  -1.08903751e-01f, -5.27268602e-03f, 7.40883034e-03f, 3.37451324e-02f, 3.90082933e-02f, 1.08301535e-01f, -1.25466585e-02f, -1.13455743e-01f, 2.45097373e-02f, 5.09816594e-02f,
  1.90773711e-01f, -1.83603197e-01f, 8.29147249e-02f, -5.48354983e-02f, 1.39374584e-01f, -9.99364480e-02f, -1.83744449e-02f, 4.91257310e-02f, -4.30098027e-02f, -1.57166094e-01f,
  -1.25288531e-01f, -1.37921333e-01f, -1.33333551e-02f, -3.21804196e-01f, 4.61312360e-04f, -1.98080182e-01f, -2.19715506e-01f, -1.59737483e-01f, 7.04437308e-03f, -1.04713030e-02f,
  6.34607896e-02f, -2.08407659e-02f, -4.23353948e-02f, 1.74833417e-01f, 4.46997629e-03f, 8.86582658e-02f, 1.38134450e-01f, 1.76845342e-01f, -1.52935162e-01f, 6.83800057e-02f,
  -1.48662115e-02f, 1.44554477e-03f, 1.02719530e-01f, 2.63711400e-02f, 6.74541667e-02f, 5.48465587e-02f, 2.56557800e-02f, -1.96149219e-02f, -4.78405096e-02f, 1.03873750e-02f,
  7.30367228e-02f, 6.85869455e-02f, -1.47011876e-02f, 3.56004909e-02f, -1.62612256e-02f, 7.27719814e-02f, -1.37380973e-01f, -7.22563313e-03f, -7.83810243e-02f, 1.55364617e-03f,
  4.67686690e-02f, -4.39091325e-02f, 4.45198268e-02f, -2.29352508e-02f, -1.20350644e-02f, -2.95597930e-02f, 1.35163009e-01f, 9.36957076e-02f, 2.11282652e-02f, 1.11379273e-01f,
  1.21060692e-01f, 3.93195748e-02f, -1.24645594e-03f, 8.14406108e-03f, 4.21618968e-02f, 1.07200732e-02f, -1.03150904e-01f, -2.86763050e-02f, 8.92677009e-02f, -4.65715118e-02f,
  -1.45368427e-01f, -9.03228149e-02f, -4.95930240e-02f, -1.10832020e-03f, 7.89996237e-03f, 6.37118742e-02f, 3.27207632e-02f, -5.87909436e-03f, -4.30607088e-02f, -3.62231843e-02f,
  4.85484675e-02f, -8.32060501e-02f, -1.79524884e-01f, -4.38888036e-02f, -3.50745171e-02f, -5.32444343e-02f, -3.29702236e-02f, -1.21367060e-01f, -3.80906090e-02f, 7.99077749e-02f,
  3.36970687e-02f, 1.90834820e-01f, -2.15140544e-02f, -2.87720934e-02f, 3.51774804e-02f, 1.83630118e-03f, -2.77945995e-02f, -1.16852410e-01f, -7.08448216e-02f, 1.42992049e-01f,
  6.80561066e-02f, -4.66379561e-02f, 6.50700629e-02f, -1.72979459e-01f, -4.11340455e-03f, -3.22897509e-02f, -2.86094882e-02f, -7.39058061e-03f, 2.66170148e-02f, 1.38238287e-02f,
  1.68574825e-01f, -5.03734238e-02f, 1.38811246e-01f, 8.26361552e-02f, -2.17216020e-03f, -7.46089444e-02f, 6.66713193e-02f, 4.93820086e-02f, 1.45196080e-01f, 1.03810690e-01f,
  -2.89537460e-01f, -8.24658126e-02f, -2.07503900e-01f, 3.90947834e-02f, -6.06746338e-02f, -1.89871460e-01f, -1.30372882e-01f, -5.02534471e-02f, -1.75861388e-01f, 2.85789855e-02f,
  -8.03717449e-02f, -1.01142161e-01f, 9.92703736e-02f, 6.93007335e-02f, -5.34846894e-02f, 1.22244515e-01f, 2.18901068e-01f, 1.88792676e-01f, 2.13476121e-01f, 8.81018639e-02f,
  1.90934643e-01f, 2.67284632e-01f, 2.66569436e-01f, 1.85520262e-01f, 2.45419309e-01f, 1.29169837e-01f, 1.79370984e-01f, 1.52108580e-01f, 1.78032681e-01f, 2.18216218e-02f,
  -1.65445339e-02f, -1.47332683e-01f, -1.34117305e-01f, 1.46710929e-02f, 4.23171073e-02f, -4.11333889e-02f, 4.77314703e-02f, -6.86893463e-02f, -2.18725093e-02f, 1.45260707e-01f,
  5.60315177e-02f, 2.76148710e-02f, -2.46856622e-02f, -9.93687883e-02f, -1.59680732e-02f, -9.24101174e-02f, 1.41251728e-01f, -4.92134094e-02f, 2.03392487e-02f, 7.50551524e-04f,
  1.30320536e-02f, 8.40781182e-02f, 6.93049654e-02f, 7.26155564e-02f, -1.20815180e-01f, 2.73942538e-02f, -1.86455864e-02f, -6.29391801e-03f, 1.06633954e-01f, -5.62734976e-02f,
  -7.27785081e-02f, 1.05494499e-01f, 1.25339553e-01f, -1.92572437e-02f, 5.64076100e-03f, 5.97735215e-03f, -1.87695809e-02f, -1.96010489e-02f, -4.64961398e-03f, 5.82550652e-02f,
  7.65328407e-02f, -6.51699677e-02f, -8.70161951e-02f, -6.62034526e-02f, 7.68936872e-02f, -1.12926453e-01f, 5.07395081e-02f, 2.15521246e-01f, 2.96002273e-02f, -7.87459090e-02f,
  -4.84532304e-02f, 4.10906486e-02f, 9.10536423e-02f, 3.59260328e-02f, 4.84333374e-02f, -1.39149025e-01f, 7.47283101e-02f, -2.79165171e-02f, 4.55308035e-02f, 1.70505226e-01f,
  -6.04408905e-02f, -5.88910840e-02f, 9.46049020e-03f, 6.72206357e-02f, 2.54537761e-02f, -3.41935903e-02f, -4.10167277e-02f, -1.31484985e-01f, -1.09904977e-02f, 1.72625799e-02f,
  -3.46691199e-02f, 3.94688025e-02f, 9.38664228e-02f, -1.54385582e-01f, 1.15953192e-01f, -1.72900498e-01f, 1.98376685e-01f, -8.80705789e-02f, 7.35573843e-03f, -2.36476157e-02f,
  -1.95038645e-03f, 8.61101747e-02f, 1.41199067e-01f, 1.05215229e-01f, 2.92943884e-03f, 6.09175190e-02f, -9.70841274e-02f, -6.84812441e-02f, 1.58658385e-01f, 2.57984623e-02f,
  -1.57759771e-01f, 6.62011504e-02f, 1.13385156e-01f, 5.24150729e-02f, 3.37367654e-01f, 2.41850108e-01f, -4.38403971e-02f, 1.96856573e-01f, 6.36259392e-02f, 2.54635769e-03f,
  2.07988322e-02f, 4.70520603e-03f, -2.75884509e-01f, 2.28312910e-01f, -7.02148750e-02f, -1.65876806e-01f, 1.56736910e-01f, -8.64068195e-02f, 1.70865711e-02f, 5.09277098e-02f,
  3.90184000e-02f, 3.52384290e-03f, 9.17460620e-02f, 9.37967226e-02f, 1.77369639e-01f, 2.30062120e-02f, -1.76190451e-01f, -1.28497839e-01f, 1.01931103e-01f, 6.11828007e-02f,
  5.99880703e-02f, 7.22514912e-02f, 1.10064164e-01f, -1.64850038e-02f, 3.84595059e-02f, 3.72173972e-02f, -1.88609492e-02f, -6.09246083e-02f, 4.18480635e-02f, 1.62793007e-02f,
  -3.78646031e-02f, 9.29115713e-02f, -8.42469856e-02f, -1.70426488e-01f, 3.62717994e-02f, 1.75310910e-01f, 9.01683718e-02f, 6.56809062e-02f, 2.32425436e-01f, 5.17364331e-02f,
  6.56478107e-02f, 6.56403601e-02f, 1.69401184e-01f, -1.86597686e-02f, 1.44527376e-01f, 7.83498511e-02f, 4.66687679e-02f, 1.31850177e-02f, 9.07113627e-02f, 2.24362507e-01f,
  4.59723435e-02f, -3.15045305e-02f, -9.42370389e-03f, -8.97230431e-02f, -6.14410341e-02f, -2.61828415e-02f, -9.05488580e-02f, -5.94248995e-03f, 2.17958773e-03f, -2.38380320e-02f,
  2.52468116e-03f, 3.96576449e-02f, -1.12574346e-01f, 4.15854901e-02f, 1.09359659e-01f, 8.98801140e-04f, -7.11659044e-02f, -1.40720740e-01f, 4.43145633e-02f, 1.70543939e-02f,
  1.92331639e-03f, 1.29549697e-01f, -1.44256920e-01f, 9.28980410e-02f, -5.24961017e-02f, 1.13747962e-01f, 2.93923123e-03f, 7.35028982e-02f, -1.77188385e-02f, -2.55688243e-02f,
  -1.50752533e-02f, -3.20758857e-02f, 4.22760323e-02f, -1.75208878e-02f, -1.22771844e-01f, 1.22842699e-01f, 6.84721842e-02f, 1.31896287e-01f, 8.91989246e-02f, 5.95337637e-02f,
  1.02460578e-01f, -3.31174359e-02f, -4.14803475e-02f, -5.97320013e-02f, 1.48706315e-02f, 1.43429399e-01f, -1.61207877e-02f, -6.46548439e-03f, 1.91448972e-01f, -7.54743218e-02f,
  -7.33133638e-03f, -5.72540723e-02f, 8.82211253e-02f, 1.81764439e-01f, 1.19901240e-01f, 4.18200810e-03f, -2.43913922e-02f, 1.49683841e-02f, 2.60229260e-02f, 8.92514884e-02f,
  3.20849299e-01f, 2.59925961e-01f, 2.58343089e-02f, 9.11434293e-02f, -1.42023653e-01f, 1.54807016e-01f, 3.64675522e-01f, -4.34293188e-02f, 3.24950218e-02f, 1.01698190e-01f,
  5.30706765e-03f, 2.00033620e-01f, 1.97200179e-02f, -2.65598167e-02f, -1.01290690e-02f, 1.16139084e-01f, 2.64482014e-02f, 9.17638019e-02f, -3.61169204e-02f, 1.05849445e-01f,
  -1.87445842e-02f, -7.73153231e-02f, -1.81941763e-02f, -1.83811232e-01f, 5.44615090e-02f, -9.82156992e-02f, -9.61445495e-02f, -7.42245466e-02f, -1.17543571e-01f, -4.71693426e-02f,
  1.69607833e-01f, 2.16717143e-02f, 7.20025823e-02f, 4.10097977e-03f, 2.45006662e-02f, -8.11268389e-02f, -5.52234314e-02f, -1.02093972e-01f, -1.23669043e-01f, -4.83726338e-02f,
  1.93380322e-02f, -1.09088823e-01f, -9.24525410e-02f, 2.86896694e-02f, 8.86647031e-02f, -1.85243953e-02f, -1.82639286e-02f, 1.09314844e-01f, -6.48650825e-02f, 9.11021009e-02f,
  9.30556059e-02f, -1.56483538e-02f, -1.02346512e-02f, 9.66414213e-02f, 3.85212339e-02f, 3.27331647e-02f, 8.01775977e-02f, 2.26440467e-02f, 2.42442507e-02f, -3.98243554e-02f,
  -1.28894940e-01f, 2.19706334e-02f, 4.22056392e-02f, 7.90390149e-02f, 8.86196643e-02f, -4.54798788e-02f, -3.50711937e-03f, 8.49124603e-03f, 4.68324162e-02f, 6.55510128e-02f,
  -2.79652681e-02f, 5.15540317e-03f, -1.15467407e-01f, -2.05852799e-02f, -3.79444025e-02f, 6.95474073e-02f, 5.12999594e-02f, 1.24091248e-03f, 1.41843595e-02f, -1.04930386e-01f,
  1.28410626e-02f, -6.47236705e-02f, -2.00568084e-02f, 4.88345958e-02f, -2.21083610e-04f, 2.77411882e-02f, -5.78660406e-02f, 5.99584430e-02f, 5.62136434e-02f, -1.22889243e-01f,
  2.42846459e-01f, 5.92392199e-02f, 6.95449561e-02f, 6.41121417e-02f, -6.58377036e-02f, -7.22385347e-02f, -1.62389114e-01f, -9.06830877e-02f, -6.47056848e-02f, 4.82315570e-03f,
  -1.40975779e-02f, 2.86141578e-02f, 1.09406537e-03f, -5.98000959e-02f, -8.33295844e-03f, -4.43426287e-03f, -2.70121545e-02f, 3.57140265e-02f, -2.20220704e-02f, 3.55614983e-02f,
  6.08972684e-02f, 3.41620259e-02f, -5.40055335e-02f, 1.30843995e-02f, -3.26974019e-02f, 4.95811440e-02f, 8.81722271e-02f, -3.32856439e-02f, -5.31276651e-02f, -7.15851486e-02f,
  9.96553302e-02f, -4.94018681e-02f, 1.99981838e-01f, 2.28649080e-01f, 5.00358827e-02f, -1.30777463e-01f, 6.92944601e-02f, 9.97351669e-03f, 3.27421017e-02f, -2.18291849e-01f,
  -1.71170514e-02f, 3.11745584e-01f, -1.15544133e-01f, -9.05614346e-02f, 1.98927283e-01f, -4.79196124e-02f, -1.49006754e-01f, 2.84838043e-02f, 8.13020021e-02f, -1.95069320e-03f,
  2.47738902e-02f, -1.78229690e-01f, 4.38107997e-02f, -2.18551066e-02f, -1.10203169e-01f, 1.13446377e-01f, 1.03353737e-02f, 8.80847648e-02f, -4.44278270e-02f, 1.39094964e-01f,
  -1.58722356e-01f, -6.51996285e-02f, -9.69023034e-02f, -9.83217955e-02f, -1.04402542e-01f, -6.93528131e-02f, -5.02387658e-02f, 2.24490557e-02f, -3.56378891e-02f, -1.84284002e-02f,
  -1.04896843e-01f, -1.85428351e-01f, 7.42237344e-02f, -7.35874800e-03f, -6.58720508e-02f, -1.98136102e-02f, -1.06585674e-01f, -1.08039409e-01f, -1.22262172e-01f, 1.50098324e-01f,
  -5.43861613e-02f, -6.90377951e-02f, -8.03679600e-02f, -6.43102229e-02f, 6.87041134e-02f, 4.78138216e-02f, 1.20686367e-01f, 9.36719775e-02f, -1.17497435e-02f, 6.51832372e-02f,
  -1.70571283e-02f, 8.72360542e-02f, 4.13620584e-02f, 5.61135598e-02f, 7.36246482e-02f, -2.32418459e-02f, -5.08013666e-02f, 1.74763091e-02f, 9.50654820e-02f, 1.44760935e-02f,
  -9.09013152e-02f, 3.12942229e-02f, 4.10932414e-02f, -4.37643267e-02f, 5.57148941e-02f, 1.18202224e-01f, 7.77965412e-02f, -1.17045447e-01f, -2.41045468e-02f, 6.50707558e-02f,
  5.55441454e-02f, -1.80060007e-02f, -9.94029120e-02f, -1.58866376e-01f, -2.07530055e-03f, 7.04812780e-02f, -2.03365549e-01f, -5.10177538e-02f, 6.27103820e-02f, -5.44356145e-02f,
  -2.85134912e-01f, -5.55646867e-02f, -1.32104591e-01f, -1.63191736e-01f, 2.18655821e-03f, -5.45158647e-02f, 5.11787459e-03f, -5.67953549e-02f, -7.98455104e-02f, -1.81610305e-02f,
  -1.41602054e-01f, -1.33002371e-01f, 1.90330192e-03f, -5.13743982e-02f, -9.69012678e-02f, 1.79753397e-02f, -7.62540922e-02f, -5.47997244e-02f, -8.05973560e-02f, 3.15739512e-02f,
  -1.51791954e-02f, -3.04310508e-02f, -1.23743683e-01f, -7.01573715e-02f, -4.81530465e-02f, -2.30541592e-03f, 1.90537900e-01f, 5.10270558e-02f, 7.88177270e-03f, 2.41427161e-02f,
  -2.63661593e-01f, 4.37466860e-01f, 1.68670848e-01f, 2.85693944e-01f, -2.84879863e-01f, 9.26768556e-02f, 1.63819790e-01f, 7.60647729e-02f, 5.03434688e-02f, 1.85301557e-01f,
  5.03166728e-02f, -4.26059915e-03f, -4.39559529e-03f, 3.05070639e-01f, -1.92370176e-01f, 4.81267497e-02f, 2.73182899e-01f, 2.25405663e-01f, -1.08111829e-01f, 1.23565078e-01f,
  1.77867268e-03f, 4.36242297e-03f, 6.48802221e-02f, -8.30931868e-03f, 2.44798977e-02f, 1.21520132e-01f, -7.73437694e-02f, -3.99490520e-02f, 1.34740353e-01f, -1.39895365e-01f,
  4.71081696e-02f, -4.61657494e-02f, -2.07178276e-02f, 3.40386629e-02f, 4.02166545e-02f, -2.38901898e-02f, 5.04922532e-02f, -2.23335344e-02f, -3.92691456e-02f, -2.76516657e-02f,
  -4.65271734e-02f, -1.48381516e-01f, 1.72576025e-01f, -9.01561603e-02f, -5.97646944e-02f, -2.42751427e-02f, -5.61712459e-02f, -4.64539006e-02f, 7.25981034e-03f, 3.73304996e-04f,
  -2.20920593e-02f, 4.69628125e-02f, -2.09824052e-02f, 1.70947257e-02f, -6.50391579e-02f, -6.97571263e-02f, 1.94933116e-02f, 1.43217612e-02f, 2.91991476e-02f, -7.56549612e-02f,
  -1.18192667e-02f, 5.76275848e-02f, 4.81441803e-02f, -4.65681739e-02f, 3.76438387e-02f, 1.29663786e-02f, 3.27117858e-03f, 2.29655523e-02f, -2.68591847e-02f, 4.68252189e-02f,
  -2.66132113e-02f, 2.70983037e-02f, 5.28462883e-03f, 3.28631811e-02f, -5.22820689e-02f, -9.05482844e-03f, -3.71434763e-02f, -1.93664543e-02f, 4.17099753e-03f, 5.30361794e-02f,
  5.02749998e-03f, 3.41196544e-02f, 5.14636412e-02f, -7.17863739e-02f, 8.70166868e-02f, -6.66489005e-02f, -1.01396583e-01f, -6.86577559e-02f, 1.02471583e-01f, -7.68579589e-03f,
  1.26303449e-01f, 1.86367884e-01f, -2.83520482e-02f, 2.26863790e-02f, -8.89037736e-03f, -5.27603105e-02f, 3.78201827e-02f, 3.34322490e-02f, 4.41668816e-02f, -1.57560818e-02f,
  -7.92137012e-02f, 5.89254610e-02f, 3.54301445e-02f, 3.12469229e-02f, -6.14584237e-03f, 2.55575497e-02f, -1.74708720e-02f, -6.56974539e-02f, -4.69665937e-02f, 2.63513327e-02f,
  -2.53823498e-04f, 8.82939771e-02f, -1.81191433e-02f, 7.24574327e-02f, 1.19230784e-02f, -6.38731718e-02f, 2.14054454e-02f, -2.26345081e-02f, -3.90003286e-02f, 1.53286206e-02f,
  2.19643731e-02f, 2.37646133e-01f, 1.60728946e-01f, -1.05539225e-01f, 9.01954249e-02f, 4.51422520e-02f, -2.33702138e-01f, 1.21744916e-01f, -1.38724327e-01f, -9.34779570e-02f,
  -7.37057179e-02f, -3.56062725e-02f, 2.40564998e-02f, -5.56971617e-02f, 2.36970544e-01f, -5.08165769e-02f, -8.94973502e-02f, -1.01412170e-01f, -2.68940069e-02f, 1.02217279e-01f,
  1.04944319e-01f, -1.06151648e-01f, 1.46852225e-01f, 7.61911720e-02f, -7.13540465e-02f, 6.35019392e-02f, 1.82920203e-01f, -2.45874841e-03f, 1.74975265e-02f, -3.65634561e-02f,
  -1.22244924e-01f, 3.14723365e-02f, -6.55725151e-02f, -6.21411353e-02f, 1.29967973e-01f, -2.37832647e-02f, -7.83960372e-02f, 3.82189676e-02f, -1.18655577e-01f, 7.26987943e-02f,
  -2.56085750e-02f, -2.00903527e-02f, 1.30200582e-02f, 2.63838843e-02f, -4.26692255e-02f, -1.10990971e-01f, 8.78991112e-02f, 1.03460753e-03f, -9.28130746e-02f, 1.08585805e-01f,
  3.80461253e-02f, 6.97267503e-02f, 2.68467702e-02f, -2.69672973e-03f, 8.12727883e-02f, -4.60565910e-02f, 2.18221005e-02f, 1.43989503e-01f, 8.92720148e-02f, 5.44439107e-02f,
  8.60443525e-03f, -1.14603220e-02f, 4.18602005e-02f, -2.37399954e-02f, 8.83975402e-02f, 1.18409013e-02f, -4.81005609e-02f, -1.30817387e-02f, -7.74917230e-02f, 7.82646537e-02f,
  -4.13802639e-02f, 3.63463983e-02f, -8.46736282e-02f, 2.89817713e-02f, -2.67235208e-02f, -4.86361422e-02f, 3.40387449e-02f, 9.70177725e-02f, 5.21723069e-02f, 5.29302061e-02f,
  -7.23783597e-02f, 5.39934859e-02f, 2.32867375e-02f, -1.01077177e-01f, 1.33158602e-02f, 8.44042897e-02f, 4.19984460e-02f, 3.06343921e-02f, 3.47348377e-02f, -8.53507370e-02f,
  1.37063786e-01f, 2.12713689e-01f, -4.30015288e-02f, -1.15969874e-01f, 2.01047659e-02f, -1.11065535e-02f, -8.42276663e-02f, -8.01767106e-04f, -3.83977941e-03f, 6.04073470e-03f,
  6.63174242e-02f, -3.90597582e-02f, 1.57382246e-02f, 4.36110022e-05f, -4.76782024e-02f, 2.95874886e-02f, -7.21899793e-02f, -7.57682696e-02f, -1.00696191e-01f, 2.15509355e-01f,
  -1.03302253e-02f, -3.71656232e-02f, -6.86117336e-02f, -1.20880857e-01f, -3.67537774e-02f, 5.06133772e-02f, 8.01593363e-02f, 4.82827015e-02f, -2.69856919e-02f, -8.46428052e-02f,
  -4.46839035e-02f, -6.28385767e-02f, 1.38541296e-01f, 9.27723348e-02f, -4.63153841e-03f, 3.06840371e-02f, 1.22680046e-01f, 5.81256449e-02f, 1.74973190e-01f, -3.90359610e-02f,
  -1.47123605e-01f, -2.07633395e-02f, 1.08003363e-01f, -1.90753981e-01f, 1.13570854e-01f, 1.42885342e-01f, -1.90629914e-01f, -1.81266606e-01f, -1.53149404e-02f, -1.99361239e-02f,
  -2.01165434e-02f, -1.50283292e-01f, -7.14090914e-02f, -1.78417593e-01f, -2.97666609e-01f, -1.50852740e-01f, -1.00397784e-02f, 2.43425295e-02f, -1.57219872e-01f, -1.20952800e-01f,
  -1.12057097e-01f, 1.20105883e-02f, -1.32215530e-01f, -2.78177168e-02f, -1.71313852e-01f, -5.76721318e-02f, 4.52866741e-02f, 2.66603511e-02f, 1.32550523e-02f, 2.67415424e-03f,
  7.77724534e-02f, -4.57382426e-02f, -1.54699251e-01f, 1.40206188e-01f, 1.21447958e-01f, 3.16812769e-02f, -1.27174169e-01f, 5.49098253e-02f, -7.63901472e-02f, 4.41111326e-02f,
  -1.23299258e-02f, -1.82748586e-02f, -3.64636141e-03f, -2.75053289e-02f, -9.35586840e-02f, -3.32873762e-02f, 1.37419000e-01f, -8.70418549e-02f, -1.52981073e-01f, 1.92018934e-02f,
  1.44452397e-02f, 4.90676379e-03f, -4.45531793e-02f, 9.00401473e-02f, -3.95295694e-02f, -2.11652461e-02f, 1.14462391e-01f, -2.79240254e-02f, -6.85347095e-02f, -2.88512148e-02f,
  -3.79684940e-02f, -9.54955891e-02f, 3.24875042e-02f, 5.46740592e-02f, 9.69270617e-03f, 3.61523442e-02f, 1.16563715e-01f, -3.04423533e-02f, -8.47145021e-02f, -1.02108441e-01f,
  1.22789003e-01f, 2.01817565e-02f, -1.88764423e-01f, 7.78078139e-02f, -2.17589233e-02f, -3.64707075e-02f, 8.52252245e-02f, 6.34130165e-02f, 5.62551469e-02f, -1.13637850e-01f,
  -1.39786437e-01f, 3.19115892e-02f, -1.44066751e-01f, -7.42340833e-02f, -7.30031133e-02f, -6.35384545e-02f, 4.67617763e-03f, -1.30067214e-01f, -2.28991639e-02f, 4.39197794e-02f,
  3.28677222e-02f, -9.31340680e-02f, 1.02736481e-01f, -1.31258545e-02f, -1.29486220e-02f, -2.53953971e-02f, -8.86237621e-03f, 1.18131220e-01f, -4.76973504e-02f, -2.90762316e-02f,
  4.80802655e-02f, 7.36316433e-03f, 4.81642634e-02f, -1.30226508e-01f, -1.20740026e-01f, 1.03228642e-02f, 2.27589682e-02f, -2.00686902e-02f, -7.71150067e-02f, 9.16726515e-03f,
  -2.53274709e-01f, 2.22482815e-01f, 6.64461702e-02f, 3.86126786e-02f, -1.31582767e-01f, -3.04227442e-01f, -1.06018372e-01f, 9.84049067e-02f, 8.96697491e-02f, 3.32880139e-01f,
  -1.39511293e-02f, 1.90088600e-01f, 2.09895477e-01f, -4.05625999e-02f, -3.59082848e-01f, 4.83525582e-02f, 5.19629661e-03f, 1.16881572e-01f, -5.67745455e-02f, 4.27711233e-02f,
  -2.41057985e-02f, -1.37617186e-01f, -2.55001336e-02f, 8.03598985e-02f, 1.17298532e-02f, 1.46964639e-01f, 1.37929805e-02f, 1.22569121e-01f, 5.01499102e-02f, -1.20983355e-01f,
  -1.60936356e-01f, 7.21875057e-02f, 6.89433068e-02f, -5.14914608e-03f, -3.58162820e-02f, 4.93168831e-02f, 4.62557934e-02f, 4.32421826e-03f, 6.56027421e-02f, 8.89102966e-02f,
  1.05923921e-01f, 1.22082397e-01f, 4.18395698e-02f, -5.80548607e-02f, -3.42750847e-02f, 3.91388461e-02f, 9.05446932e-02f, -6.60360083e-02f, 1.80432081e-01f, -7.55726621e-02f,
  3.56036909e-02f, 1.07605243e-02f, -1.30064087e-02f, 1.27220646e-01f, 5.73659828e-03f, 2.40644012e-02f, -7.53616765e-02f, 2.13688519e-03f, 5.87994158e-02f, -5.52040013e-03f,
  7.16263279e-02f, 3.64326499e-02f, 4.63844985e-02f, -6.95490614e-02f, -7.23262355e-02f, -4.94970307e-02f, 2.07515806e-02f, -1.47731109e-02f, 1.74448565e-02f, 7.00375438e-02f,
  3.18837464e-02f, 2.10637711e-02f, 9.10329167e-03f, 4.60911635e-03f, 4.13069781e-03f, -6.91765845e-02f, 8.48266017e-03f, 1.14380762e-01f, -5.58607168e-02f, -1.02525383e-01f,
  1.02587320e-01f, 1.89245250e-02f, 8.74437839e-02f, -1.31863179e-02f, -5.18209115e-02f, 2.33740024e-02f, 1.03356794e-01f, 2.78310329e-02f, -5.17626032e-02f, 9.68143251e-03f,
  4.89029139e-02f, 2.33566076e-01f, 6.59725666e-02f, 2.11771261e-02f, 1.02025896e-01f, -2.74345167e-02f, -3.65702100e-02f, -1.53477984e-02f, 6.56143427e-02f, 1.50022563e-02f,
  2.34571286e-02f, 7.14657456e-02f, -1.76827274e-02f, -5.13402410e-02f, -9.64031927e-03f, -7.24705830e-02f, 1.69890493e-01f, 8.75880122e-02f, 1.00520819e-01f, 1.44077642e-02f,
  7.75646716e-02f, 5.30338995e-02f, 1.06772654e-01f, -4.72976267e-03f, -1.55419037e-02f, 8.09316486e-02f, -9.40981209e-02f, 2.49534193e-02f, 8.32858235e-02f, 9.20338258e-02f,
  -8.14969018e-02f, -7.82859996e-02f, -2.09597647e-01f, -3.03315312e-01f, 4.72965576e-02f, -3.12807530e-01f, -2.13889554e-01f, -2.13717446e-02f, -2.49096096e-01f, -1.86051987e-02f,
  -1.69895634e-01f, -1.71340168e-01f, -7.44563043e-02f, -3.61071199e-01f, -2.94905335e-01f, -3.40732843e-01f, -3.31989020e-01f, -2.49949053e-01f, -1.23365596e-01f, -1.64804142e-02f,
  -1.61735982e-01f, 7.87500069e-02f, -2.56815143e-02f, 2.34358475e-01f, 1.05187245e-01f, 6.89440444e-02f, 1.74828798e-01f, 6.23383373e-02f, -3.30228209e-02f, 4.14662063e-02f,
  -1.76408049e-02f, 1.49081126e-01f, 6.43322915e-02f, 7.79457763e-02f, 5.07196859e-02f, 5.79928905e-02f, 2.65539289e-02f, 3.77804562e-02f, 9.89699643e-03f, -4.67710802e-03f,
  -2.42032260e-02f, 3.84646729e-02f, 7.99379777e-03f, -3.13667804e-02f, -2.26255413e-02f, -1.35871563e-02f, -4.88148294e-02f, -9.30044055e-02f, -4.02315184e-02f, -8.48478228e-02f,
  -1.60183281e-01f, -1.52900040e-01f, -7.51359314e-02f, 3.56983254e-03f, -8.37132409e-02f, -1.46067768e-01f, -9.65409279e-02f, -4.81670201e-02f, -1.26563951e-01f, 1.70230530e-02f,
  7.82236457e-02f, 1.06034251e-02f, -2.87080370e-02f, 4.15898953e-03f, -3.29428688e-02f, 7.06022456e-02f, -8.85041729e-02f, 2.82514859e-02f, -9.46553797e-03f, 5.31735010e-02f,
  3.96855436e-02f, 2.83045769e-02f, 8.94584283e-02f, -1.78820267e-01f, -5.15896827e-02f, 9.48624033e-03f, -2.24875100e-02f, 1.95943732e-02f, 1.70121193e-02f, 6.06263289e-03f,
  5.38751297e-02f, -3.68426181e-02f, 9.74414349e-02f, 8.38687271e-02f, 8.75360053e-03f, -4.50389497e-02f, 4.06185128e-02f, -2.79699266e-03f, -6.96308613e-02f, 2.34904028e-02f,
  -3.77155468e-02f, 1.15964577e-01f, 8.88871625e-02f, 8.98258612e-02f, 1.69223212e-02f, -8.48725662e-02f, -1.09257102e-01f, 3.40385176e-02f, 7.86838606e-02f, -6.77276477e-02f,
  1.10128336e-02f, 6.53581694e-02f, -3.06375530e-02f, -6.13258258e-02f, 6.52156072e-03f, 9.13984254e-02f, -2.38314122e-02f, 5.26172407e-02f, 6.53829575e-02f, 3.52614634e-02f,
  -4.01660055e-02f, -9.41727385e-02f, 1.03638962e-01f, 5.76789752e-02f, 4.12015021e-02f, 2.04418058e-04f, -2.54590157e-02f, -1.02644891e-01f, -4.20152545e-02f, -2.99852546e-02f,
  -1.00345224e-01f, 3.36884797e-01f, -2.15090111e-01f, -1.35967344e-01f, -1.14476338e-01f, -1.59805462e-01f, 1.40180076e-02f, -4.94151451e-02f, -1.65547468e-02f, 3.24691176e-01f,
  6.40963912e-02f, 7.97518343e-02f, 9.47238952e-02f, 4.25256006e-02f, -1.92367032e-01f, -7.89457653e-03f, -9.34597105e-02f, -5.97164296e-02f, -1.84450448e-01f, -2.00119186e-02f,
  -1.55457750e-01f, 2.78084055e-02f, -1.71808422e-01f, -1.61278352e-01f, -7.14227408e-02f, -7.97534510e-02f, -2.65292712e-02f, -1.28152505e-01f, -6.27439469e-03f, 1.71302538e-02f,
  2.11494304e-02f, 3.91911119e-02f, -1.07835280e-02f, -8.04481059e-02f, 3.35482918e-02f, -4.43627499e-02f, -1.80698678e-01f, -1.06044114e-01f, -5.54718375e-02f, 5.41925095e-02f,
  -1.00161046e-01f, -1.56926200e-01f, 1.29054924e-02f, -1.49797816e-02f, -9.57433432e-02f, -4.96359030e-03f, 5.62008284e-02f, -9.76532549e-02f, -4.68857363e-02f, -4.85186726e-02f,
  3.61471921e-02f, 2.17026211e-02f, 1.79504212e-02f, 3.67032771e-04f, -1.11288235e-01f, 3.69735435e-02f, -9.06526372e-02f, -1.06433392e-01f, 1.64510254e-02f, 3.97954844e-02f,
  -8.29222202e-02f, 5.58119789e-02f, 4.55990173e-02f, 9.19868499e-02f, 1.15921974e-01f, 4.08839881e-02f, 7.91538656e-02f, 1.52441545e-03f, 1.12430967e-01f, 8.62028524e-02f,
  2.24916800e-03f, -1.14765903e-02f, -1.11782951e-02f, -1.21040970e-01f, 1.03373863e-01f, 8.25793222e-02f, 8.76054317e-02f, 3.41420919e-02f, -5.27337082e-02f, -3.37972865e-02f,
  5.06027453e-02f, -2.03583930e-02f, 1.61004171e-01f, -8.66484195e-02f, 6.88641816e-02f, 7.84766227e-02f, -1.25787973e-01f, 1.58417281e-02f, 7.17041567e-02f, -2.96156537e-02f,
  1.33900195e-01f, 1.51531264e-01f, 6.97436258e-02f, 2.34718286e-02f, 1.14159711e-01f, 5.84638538e-03f, -9.85007659e-02f, -3.66827101e-02f, -5.71057126e-02f, 5.35511374e-02f,
  -1.53408378e-01f, 3.55395973e-02f, -1.93207748e-02f, 2.96003884e-04f, -6.19981736e-02f, 1.43912703e-01f, 5.44624366e-02f, -4.00112383e-03f, 5.00865765e-02f, 9.81258973e-02f,
  -6.30811155e-02f, 1.06662642e-02f, -3.66289243e-02f, -4.52869311e-02f, -1.85916156e-01f, 7.15747550e-02f, -3.42174359e-02f, -1.21565022e-01f, -2.77778711e-02f, 2.60203760e-02f,
  -1.11889571e-01f, 2.01791823e-01f, -3.05649042e-01f, -1.93331823e-01f, -3.80820781e-02f, 9.25259199e-03f, 1.38980687e-01f, -4.87721860e-02f, -2.77126320e-02f, 2.52976328e-01f,
  1.61638230e-01f, -1.54857218e-01f, 3.57579559e-01f, 3.36366117e-01f, -1.79624155e-01f, 2.46108726e-01f, -1.48351286e-02f, -5.78004159e-02f, -5.97581044e-02f, -3.24150547e-02f,
  2.00337954e-02f, 3.19267482e-01f, 1.36505753e-01f, -7.07493722e-02f, 1.64853744e-02f, -2.40959659e-01f, -3.37653458e-02f, -1.02733165e-01f, 2.50161290e-02f, 1.39210438e-02f,
  4.60940897e-02f, 2.15468079e-01f, 7.07011968e-02f, 4.29657437e-02f, 2.32701544e-02f, 3.60448360e-02f, -3.00582685e-02f, -3.55526097e-02f, -3.96598652e-02f, 8.22698623e-02f,
  1.23256132e-01f, -7.19108060e-03f, -6.20630512e-04f, -2.94749916e-04f, -3.16767208e-02f, -5.06548248e-02f, 7.15100989e-02f, 5.37743755e-02f, 4.39522713e-02f, 6.12825081e-02f,
  9.65272039e-02f, 5.75478040e-02f, 3.13164182e-02f, 8.21526870e-02f, 2.98053734e-02f, -3.74549404e-02f, -8.92389044e-02f, -2.56607924e-02f, 1.44816218e-02f, 3.75864170e-02f,
  1.00981325e-01f, 8.45504645e-03f, -3.49589884e-02f, -1.81100033e-02f, -5.24842925e-02f, 4.20273617e-02f, -1.07151289e-02f, 8.20434652e-03f, -1.88499808e-01f, -5.78095689e-02f,
  -1.17648244e-01f, -1.01678491e-01f, -2.82361135e-02f, -5.41576697e-03f, 6.74951971e-02f, 1.25942752e-02f, -1.36672512e-01f, 1.21278867e-01f, 1.15886927e-01f, -7.70387575e-02f,
  -4.85468544e-02f, -5.82009330e-02f, -6.69919467e-03f, 3.32739204e-02f, -5.62002063e-02f, -1.30543392e-02f, 1.93226412e-01f, 2.87801940e-02f, -1.38937961e-02f, 2.80536991e-02f,
  1.78082231e-02f, 5.55654727e-02f, 1.17137425e-01f, 4.52064723e-02f, 6.74712891e-03f, -5.90433292e-02f, -1.80877149e-02f, -7.77662694e-02f, -1.49984714e-02f, 7.73914158e-02f,
  3.23045366e-02f, -7.55595490e-02f, -1.52265385e-01f, -2.95238066e-02f, 7.14031681e-02f, -1.58873312e-02f, 6.57189190e-02f, -2.70622410e-02f, 4.42908145e-02f, 2.41813306e-02f,
  4.45000529e-02f, 1.19441673e-02f, 9.58029740e-03f, 2.95015089e-02f, 5.97264394e-02f, 9.94251370e-02f, -1.77575022e-01f, 4.37823422e-02f, 5.31027168e-02f, 3.25501785e-02f,
  -1.52625218e-01f, -2.71190852e-02f, -1.02056049e-01f, -3.67107123e-01f, 2.96265241e-02f, 3.44507784e-01f, 1.15223691e-01f, -1.06231742e-01f, -3.50700557e-01f, 3.73423286e-02f,
  7.53717795e-02f, -5.79263829e-03f, 7.82245696e-02f, 2.19823644e-02f, -2.94210808e-03f, 3.20210420e-02f, -1.22751489e-01f, -3.51977237e-02f, -1.57392070e-01f, 3.68744843e-02f,
  -1.11480117e-01f, 4.25759926e-02f, -4.17682193e-02f, 1.65303349e-01f, -5.75710880e-03f, -9.34122056e-02f, -1.39219863e-02f, 9.72243547e-02f, -5.71199395e-02f, 1.60776004e-01f,
  4.41753343e-02f, 2.29328759e-02f, -3.47688720e-02f, 1.51597308e-02f, -2.65154429e-02f, 3.58794332e-02f, 1.01738364e-01f, 8.60644802e-02f, -1.56960025e-01f, -1.33817837e-01f,
  -2.26661880e-02f, -3.29781063e-02f, 1.14305606e-02f, 2.23377105e-02f, -1.48358315e-01f, -5.45957983e-02f, -1.42440543e-01f, -7.75101185e-02f, -6.19275160e-02f, 1.02599256e-01f,
  -1.05840214e-01f, -1.30800486e-01f, -1.86535388e-01f, -4.31644395e-02f, -7.70022627e-03f, -6.80790469e-03f, 2.57512741e-02f, 5.81635348e-02f, -8.82347301e-02f, -8.16492811e-02f,
  7.83539489e-02f, -9.21979770e-02f, 7.62887299e-03f, -4.98215593e-02f, -4.34778631e-02f, -1.51887145e-02f, 6.62036519e-03f, 6.68287203e-02f, -2.85992213e-02f, -4.45029773e-02f,
  -6.17564470e-02f, 3.45889479e-02f, 6.06110729e-02f, -3.15839536e-02f, -6.49444014e-02f, 1.39742056e-02f, 7.93363061e-03f, -2.75633018e-02f, -1.09875798e-01f, 5.83799817e-02f,
  1.87496748e-02f, -1.33961001e-02f, -9.10558775e-02f, 1.40784264e-01f, 4.55575846e-02f, -8.23079869e-02f, -3.85381617e-02f, -4.10455689e-02f, 5.70889236e-03f, 9.98132210e-03f,
  8.32910910e-02f, 3.86499278e-02f, 7.10864440e-02f, 6.24574497e-02f, 5.67000685e-03f, 3.01094484e-02f, 4.30974700e-02f, 6.64375871e-02f, -2.77863573e-02f, 7.50713283e-03f,
  4.94912863e-02f, -5.32674640e-02f, -3.74858105e-03f, 3.53046693e-02f, -8.96678939e-02f, 6.17495477e-02f, -9.34398621e-02f, -9.70004871e-02f, -7.24117234e-02f, 7.00941533e-02f,
  -6.22409917e-02f, -3.42743881e-02f, -1.17477655e-01f, -7.63705000e-02f, -4.19216380e-02f, -3.29468586e-02f, 1.11383133e-01f, -3.35067995e-02f, -1.52964145e-03f, -6.40297234e-02f,
  -1.75453395e-01f, 8.96029547e-02f, 1.93267211e-01f, -2.01315805e-01f, -1.00765295e-01f, -1.94766894e-01f, -2.40164220e-01f, -5.35029434e-02f, -4.36210670e-02f, -2.09107641e-02f,
  -2.10819706e-01f, 1.73686091e-02f, 1.48841888e-01f, -3.26509655e-01f, -3.59311819e-01f, 1.14161864e-01f, -3.10425133e-01f, -6.99508786e-02f, 1.25083998e-01f, -2.34609529e-01f,
  4.84128762e-03f, -2.25608364e-01f, 4.55303863e-02f, 5.61239058e-03f, 2.37275381e-02f, 1.90497011e-01f, 5.93349785e-02f, 1.67518631e-01f, -1.07154533e-01f, -1.20881200e-02f,
  -1.23840064e-01f, -4.06336300e-02f, 5.97776771e-02f, -5.73151782e-02f, -7.21478239e-02f, -1.41464368e-01f, 5.17368224e-03f, 7.66141117e-02f, -2.13456322e-02f, 5.00334846e-03f,
  1.38507888e-01f, 1.99194271e-02f, -8.10161605e-02f, 1.52982876e-01f, 8.59391242e-02f, 6.19887821e-02f, 1.77130792e-02f, 1.36989310e-01f, 2.77158357e-02f, -6.59973780e-03f,
  2.92092282e-02f, 1.23100378e-01f, -2.53192186e-02f, 5.99841103e-02f, 9.89178941e-02f, 5.12232445e-02f, 6.82941303e-02f, 1.19821928e-01f, 5.87007478e-02f, -6.42830133e-02f,
  2.68988721e-02f, -1.23628728e-01f, -3.55523825e-02f, -8.39711260e-03f, -1.07054770e-01f, -5.76067432e-05f, -5.54736294e-02f, 1.38699431e-02f, -2.82045850e-03f, -7.59794563e-02f,
  -1.05583087e-01f, -4.89720330e-02f, -1.57535434e-01f, 3.12546231e-02f, -5.00462167e-02f, -2.29340494e-02f, -2.31379215e-02f, 7.62648284e-02f, 3.09030036e-03f, -5.38315549e-02f,
  -1.18540086e-01f, -1.47362649e-01f, -3.98189761e-02f, 1.98795512e-01f, -1.32237539e-01f, 9.03546065e-02f, 8.22098851e-02f, 4.86948807e-03f, -9.02848989e-02f, -6.70267344e-02f,
  -1.49799973e-01f, -1.45923525e-01f, -2.99595930e-02f, -3.51841077e-02f, -5.26465140e-02f, -1.17032781e-01f, -1.55437663e-02f, 2.47835256e-02f, -5.10166846e-02f, -9.03193355e-02f,
  8.89377967e-02f, 2.30202079e-02f, -5.98871429e-03f, 3.39446068e-02f, 4.06589508e-02f, -1.10665120e-01f, -5.96085526e-02f, 5.31843342e-02f, -1.13882899e-01f, -5.58767132e-02f,
  5.82134202e-02f, 2.73646787e-02f, 2.46661138e-02f, 2.63904687e-03f, -4.06331122e-02f, 8.19898173e-02f, -6.20489679e-02f, 8.48919526e-02f, 4.61859740e-02f, -6.10553520e-03f,
  5.92312450e-03f, -3.40730138e-02f, -5.18462881e-02f, -1.74815193e-01f, 2.68097043e-01f, 1.43959358e-01f, -8.23617801e-02f, 4.63219695e-02f, 2.04837531e-01f, -3.21552217e-01f,
  -4.18467773e-03f, -2.35573754e-01f, 1.29220949e-03f, -2.81155586e-01f, -1.17655613e-01f, 1.84907228e-01f, -5.72515167e-02f, -7.59371892e-02f, 3.12209815e-01f, -1.14991121e-01f,
  1.00308463e-01f, -1.43606499e-01f, -1.39622688e-01f, 4.95596007e-02f, -1.40131295e-01f, 6.90700486e-03f, -1.65956900e-01f, 9.77381691e-02f, -2.80822784e-01f, 1.10417433e-01f,
  5.58349080e-02f, 8.62048864e-02f, -5.38390726e-02f, -1.01428647e-02f, -3.25786583e-02f, -2.34853923e-02f, -1.46602064e-01f, -3.61143686e-02f, 7.00521469e-02f, -3.32882255e-02f,
  -2.24728175e-02f, 1.24166692e-02f, -4.77407612e-02f, 6.30449504e-02f, 1.35661915e-01f, -5.53840026e-02f, 6.40855283e-02f, 7.48819932e-02f, -7.18713254e-02f, 2.13103499e-02f,
  2.96938717e-02f, -8.41080677e-03f, 1.17662493e-02f, 4.19917218e-02f, 9.13276747e-02f, 1.45044938e-01f, -1.93216151e-03f, 1.50313862e-02f, 2.91910507e-02f, 3.56150381e-02f,
  1.17936641e-01f, 4.29384038e-02f, -5.20211868e-02f, -3.66814211e-02f, -8.45578313e-02f, 8.21040105e-03f, -9.88882557e-02f, -2.06961054e-02f, 7.48948604e-02f, -2.56334320e-02f,
  -4.50490601e-02f, 4.14723791e-02f, -4.26302431e-03f, -4.76371758e-02f, 4.42886315e-02f, -5.11380248e-02f, -8.36307928e-02f, -1.67677868e-02f, -4.75805029e-02f, -6.54749274e-02f,
  1.32457046e-02f, -7.21116364e-02f, -1.65150434e-01f, -2.71632075e-02f, -1.60801206e-02f, 3.54564227e-02f, -9.26090106e-02f, -4.17533480e-02f, -1.39878750e-01f, -2.03430634e-02f,
  7.70404935e-02f, 4.92398031e-02f, 1.07926644e-01f, -4.53181043e-02f, 5.38399722e-03f, 2.62112878e-02f, -2.88787652e-02f, 1.01609817e-02f, 4.93157133e-02f, -5.46352454e-02f,
  3.61390710e-02f, -1.02666825e-01f, -3.05277877e-03f, -4.50449400e-02f, -4.56156954e-02f, -1.00922331e-01f, -4.16846126e-02f, 1.04952104e-01f, -4.84263077e-02f, -4.94152494e-02f,
  3.76332691e-03f, -5.44089787e-02f, 6.19916990e-02f, -2.75280327e-03f, 2.69123428e-02f, 1.39728710e-02f, 1.07748285e-02f, 8.68211314e-02f, 6.87156245e-02f, 5.85519113e-02f
};

// L0_fan_Wp_bar (Shape: 78 x 120)
const int L0_fan_Wp_bar_rows = 78;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.34720820e-01f, -2.29566529e-01f, 3.24817061e-01f, 3.86058360e-01f, 8.60663429e-02f, 9.34401602e-02f, 2.86895663e-01f, -5.96836135e-02f, 3.03207904e-01f, -1.86740622e-01f,
  -1.42923832e-01f, 2.19817579e-01f, -1.28757849e-01f, 1.00970753e-01f, 4.26166458e-03f, -1.25753909e-01f, 1.79062933e-01f, 2.02311099e-01f, 4.45647575e-02f, 1.34839728e-01f,
  1.29621774e-01f, -2.52232790e-01f, -1.00345470e-01f, -2.32041270e-01f, 2.21500192e-02f, 8.55220631e-02f, -3.06422651e-01f, -8.55525136e-02f, -3.08727529e-02f, 9.40294191e-02f,
  1.23762768e-02f, 3.94180007e-02f, -1.92497019e-02f, -7.46847168e-02f, 2.20935158e-02f, -9.30989534e-02f, 9.01117362e-03f, -5.97623102e-02f, -7.28073576e-03f, -8.08805823e-02f,
  2.31710169e-02f, -9.64927375e-02f, -1.43584665e-02f, 1.16131604e-02f, -4.55775857e-02f, 3.01322937e-02f, 7.39602447e-02f, -5.02637327e-02f, -4.19655070e-02f, 1.07553452e-01f,
  1.10330187e-01f, 2.62190178e-02f, -5.59606031e-02f, -6.85761347e-02f, -3.82575765e-02f, 8.17370191e-02f, 7.46110976e-02f, 7.27052763e-02f, 7.29473820e-03f, 3.88681032e-02f,
  2.85412073e-02f, -1.35439143e-01f, -6.47532195e-02f, -5.97048253e-02f, 1.30326077e-02f, 3.83836851e-02f, -4.14992217e-03f, -7.15915859e-02f, 2.44655609e-02f, -2.63283234e-02f,
  5.08944355e-02f, -1.35472789e-02f, 1.17267758e-01f, 4.13657464e-02f, 9.27402675e-02f, 3.32111008e-02f, -2.08318662e-02f, 1.55366167e-01f, -5.85030243e-02f, -7.24828839e-02f,
  -5.19366227e-02f, -3.63942534e-02f, -1.30263381e-02f, 9.39767957e-02f, -9.09424387e-03f, -2.07159277e-02f, -7.31299445e-02f, 1.58422470e-01f, -2.19044592e-02f, -1.76436305e-01f,
  -1.98758930e-01f, -2.07006752e-01f, -3.50220464e-02f, -3.00729349e-02f, 3.70935388e-02f, -9.00693014e-02f, 6.99939355e-02f, -3.33198979e-02f, -1.17096484e-01f, -1.05187505e-01f,
  7.12541211e-03f, -1.76893827e-02f, -5.24796546e-02f, 7.13834539e-02f, -2.02315316e-01f, -4.16893512e-02f, 1.39102712e-01f, -1.83838889e-01f, -1.60112932e-01f, 2.71237991e-03f,
  2.69727279e-02f, 5.72457025e-03f, -1.31719396e-01f, -4.40569269e-03f, -7.35697448e-02f, 2.52651870e-02f, 1.79250967e-02f, 2.18806369e-03f, 1.78898778e-02f, -1.92874242e-02f,
  -4.88947242e-01f, 7.20307380e-02f, -1.57246858e-01f, -3.24556768e-01f, 5.61092161e-02f, -4.30700518e-02f, -1.80908352e-01f, 1.86715320e-01f, -9.11192000e-02f, 2.31901690e-01f,
  1.31928921e-01f, -2.66756654e-01f, 3.24902028e-01f, -3.72091204e-01f, -4.47484046e-01f, -1.62128776e-01f, -2.60204136e-01f, -1.19114041e-01f, -1.67407691e-01f, -1.50393387e-02f,
  -1.91411242e-01f, -2.10343033e-01f, -1.57442376e-01f, 1.04715839e-01f, -1.40615135e-01f, 1.52717873e-01f, 1.47059470e-01f, 4.27777022e-02f, -9.37572569e-02f, -1.73084304e-01f,
  7.11069331e-02f, 8.38651136e-03f, 1.17662773e-01f, 3.89671810e-02f, 6.29905164e-02f, -1.56618319e-02f, 1.02885589e-02f, 2.01967265e-02f, -4.22133841e-02f, 1.18532253e-03f,
  7.32141584e-02f, 2.25213207e-02f, -1.32584766e-01f, -9.48301777e-02f, -7.79770734e-03f, -7.84626603e-02f, 2.26249918e-02f, 7.09097609e-02f, 1.21823430e-01f, -2.61471033e-01f,
  -7.07042590e-02f, 5.63309193e-02f, -1.33944582e-03f, 1.80496648e-02f, -6.68269694e-02f, 6.21300377e-02f, -9.41497684e-02f, 5.73974894e-03f, 1.33851375e-02f, -2.29088128e-01f,
  -4.28808406e-02f, 3.09739690e-02f, 5.99310966e-03f, -4.38475283e-03f, -2.69437209e-02f, 2.27039866e-02f, -5.90824336e-03f, -2.48189513e-02f, -1.41065851e-01f, 6.68294579e-02f,
  8.01798031e-02f, 3.67419422e-02f, 4.63231355e-02f, 7.36083090e-03f, -1.14158466e-01f, 1.31476829e-02f, 3.71061191e-02f, 7.62730017e-02f, -1.46207586e-01f, 3.04224379e-02f,
  9.27945599e-02f, 2.34655514e-02f, 8.51700902e-02f, 8.82096440e-02f, 4.46269326e-02f, 2.97460202e-02f, 3.93831171e-02f, -8.97496864e-02f, 8.44738111e-02f, -4.66588475e-02f,
  1.77643448e-01f, 5.07045425e-02f, 1.69952482e-01f, 1.19313896e-01f, 5.06391190e-02f, -5.22874966e-02f, -5.85626885e-02f, -2.60165427e-02f, -6.45999163e-02f, -1.47536486e-01f,
  9.21470020e-03f, 1.19041823e-01f, 6.04053997e-02f, -3.88562563e-03f, 7.59066641e-02f, -6.03135489e-02f, 1.21716939e-01f, 1.75074831e-01f, 8.31508487e-02f, 5.25784567e-02f,
  1.05223894e-01f, 4.34009135e-02f, -3.12350746e-02f, -4.14119065e-02f, -4.44936231e-02f, 1.50147483e-01f, -8.23241249e-02f, 3.23753953e-02f, -3.16299908e-02f, -6.47714213e-02f,
  2.07145050e-01f, 1.89887956e-01f, 2.35685751e-01f, 1.65973842e-01f, -1.50501803e-01f, -6.33617416e-02f, -1.00852370e-01f, -1.49118125e-01f, -8.81874189e-02f, 1.71568822e-02f,
  -2.69799024e-01f, 3.20785224e-01f, -3.69667590e-01f, 2.11173624e-01f, -1.07612006e-01f, -3.26155543e-01f, 2.82991827e-01f, 1.23658143e-01f, -7.19158500e-02f, 2.87723038e-02f,
  -3.68509442e-02f, 3.53051610e-02f, -7.28527755e-02f, -1.97928324e-02f, 2.71090209e-01f, 2.46183351e-01f, -9.73498169e-03f, -3.66431288e-02f, 4.12217647e-01f, 5.93055822e-02f,
  1.52915111e-02f, 1.79088674e-02f, 9.95797068e-02f, 4.75108884e-02f, -2.24742907e-04f, 9.97184366e-02f, 1.58397794e-01f, 1.42406160e-02f, -6.03126781e-03f, 3.03457864e-02f,
  9.63067785e-02f, 6.93216324e-02f, 6.48652241e-02f, 6.58626482e-02f, 5.95844463e-02f, 1.64682761e-01f, 6.06380999e-02f, 2.11708322e-02f, 7.32320994e-02f, 5.83246313e-02f,
  5.87497093e-02f, 5.78166135e-02f, 8.02109838e-02f, 1.80751711e-01f, 8.95897746e-02f, 2.43482962e-02f, 1.35365456e-01f, 1.04527533e-01f, 1.41093910e-01f, 2.04523191e-01f,
  -5.27584068e-02f, 1.46435259e-03f, -3.31497602e-02f, -6.11536540e-02f, 8.45617987e-03f, 6.82203146e-03f, -5.66880666e-02f, -3.43938656e-02f, 3.79037037e-02f, 4.55474555e-02f,
  3.60178500e-02f, 1.00599840e-01f, -1.44442752e-01f, 2.17910372e-02f, 1.04652636e-01f, -4.92518730e-02f, -3.04408371e-02f, 1.41905010e-01f, 3.50085571e-02f, -9.20587257e-02f,
  -1.00576557e-01f, 2.17558723e-03f, -4.82058227e-02f, -9.77483988e-02f, -1.55725271e-01f, -2.89900471e-02f, 7.64376298e-02f, 8.92747268e-02f, -2.15412810e-01f, -9.63180512e-03f,
  7.00587332e-02f, 1.78539217e-01f, -5.13733290e-02f, 4.04834859e-02f, -4.42433022e-02f, 1.20055526e-01f, 3.88692692e-02f, 1.24200910e-01f, 1.27244443e-01f, 3.67774889e-02f,
  9.20208767e-02f, -1.47536192e-02f, -2.10880507e-02f, 6.92096427e-02f, -1.09354518e-02f, -6.71350211e-02f, -1.27157453e-03f, -4.07946594e-02f, 4.68020625e-02f, -9.49562564e-02f,
  -6.26107976e-02f, -7.82815665e-02f, 1.15664639e-01f, 1.68804988e-01f, 1.01324402e-01f, -2.22117286e-02f, 3.90105732e-02f, 1.31926879e-01f, 7.54798651e-02f, 8.32207426e-02f,
  2.66397178e-01f, -3.14686120e-01f, -4.36933398e-01f, -1.83009788e-01f, 3.11383337e-01f, 3.68258566e-01f, -2.05661789e-01f, 2.50144694e-02f, -3.77284110e-01f, 1.82403892e-01f,
  1.58580258e-01f, -5.52955940e-02f, -3.51578951e-01f, 2.06263959e-01f, 8.46504197e-02f, -2.69940674e-01f, 2.46843517e-01f, 1.22208856e-01f, -1.23519413e-01f, 1.38516873e-01f,
  -6.35577319e-03f, 3.69976640e-01f, -2.47322038e-01f, 3.64865243e-01f, 2.46841416e-01f, -1.12765849e-01f, 2.01304063e-01f, -1.00434273e-01f, 2.29891971e-01f, 2.48600811e-01f,
  8.38369038e-03f, -7.59922341e-02f, -2.64171325e-02f, 4.19495776e-02f, -2.48068273e-02f, 1.72347680e-01f, 1.25768721e-01f, 1.10665886e-02f, -1.16224170e-01f, -1.48859039e-01f,
  -8.57373409e-04f, 6.64329827e-02f, 2.49452740e-02f, 1.71015821e-02f, 9.00861397e-02f, 2.47693900e-02f, -1.22645907e-01f, 4.64411303e-02f, -1.62379637e-01f, 3.11011672e-02f,
  -1.71590477e-01f, -2.91032344e-02f, 6.61673844e-02f, -1.23639386e-02f, -1.34962916e-01f, -1.08147472e-01f, 2.30872701e-03f, -1.10842749e-01f, 8.18499401e-02f, 1.11619152e-01f,
  7.46904686e-02f, 1.07617840e-01f, -7.88171776e-03f, 3.70760672e-02f, -9.19991136e-02f, 6.73507340e-03f, 7.87106231e-02f, -4.22242805e-02f, 1.46914285e-03f, -2.09387634e-02f,
  -6.52870163e-02f, -4.82950360e-02f, 5.13691530e-02f, 1.03288136e-01f, 2.62364447e-02f, 1.81842707e-02f, -5.35854185e-03f, -2.98180375e-02f, -1.42413542e-01f, -1.09197125e-01f,
  3.99165601e-02f, 2.65595149e-02f, -1.53993860e-01f, 7.17016086e-02f, 4.67467979e-02f, -1.03275597e-01f, 1.58443153e-01f, -7.22741010e-03f, -2.88934354e-02f, 9.60409120e-02f,
  6.33245111e-02f, 2.84244176e-02f, -1.51030153e-01f, -1.05526036e-04f, -1.16769403e-01f, 2.06063360e-01f, 6.02327026e-02f, -1.47455018e-02f, 9.78736654e-02f, -4.45158891e-02f,
  9.35849920e-02f, -3.65429409e-02f, 1.57952562e-01f, 2.85363067e-02f, -4.59731184e-03f, 8.82024132e-03f, 2.63028461e-02f, 7.04891654e-03f, -4.25811624e-03f, -1.07423179e-01f,
  1.10532761e-01f, -1.16347425e-01f, 1.94684509e-02f, -1.48062194e-02f, 3.70722152e-02f, -1.85037237e-02f, 6.75265566e-02f, -7.90121406e-02f, 5.68985417e-02f, -2.90903226e-02f,
  -5.69538057e-01f, 2.60162234e-01f, 2.87036747e-01f, -4.13343966e-01f, 2.64411330e-01f, 2.22770333e-01f, -2.11463585e-01f, 7.79616982e-02f, -1.64490163e-01f, -7.85848126e-02f,
  -1.66718081e-01f, -1.00621797e-01f, 1.92589045e-01f, -2.38547459e-01f, -1.30434841e-01f, 6.41302392e-02f, -1.86926395e-01f, -2.69317150e-01f, 1.20340966e-01f, -1.16814643e-01f,
  -1.91022441e-01f, -6.31054342e-02f, 1.19223855e-01f, 2.45457962e-01f, 7.28026330e-02f, 5.74383289e-02f, -1.36001602e-01f, 2.44873628e-01f, -3.47614400e-02f, 6.51754513e-02f,
  5.78670157e-03f, -2.03039110e-01f, 7.89099559e-02f, 1.36219896e-02f, 5.33301830e-02f, -1.09342877e-02f, -3.14817578e-02f, 3.58586796e-02f, 3.01377121e-02f, 2.11238172e-02f,
  6.67409366e-03f, 5.58341667e-02f, -5.11842780e-02f, 5.12771793e-02f, 5.76963574e-02f, 1.01471364e-01f, 1.17879815e-01f, 5.02609499e-02f, 1.38792783e-01f, -2.03203224e-02f,
  2.01416444e-02f, 4.54577990e-02f, -2.31623184e-02f, -4.53655459e-02f, 7.71868527e-02f, 3.46210189e-02f, 4.35746089e-03f, -6.22039773e-02f, 3.31428312e-02f, -5.13428152e-02f,
  -3.98791470e-02f, -4.26181518e-02f, 4.17292230e-02f, 7.84711689e-02f, -4.42139804e-02f, 3.11376005e-02f, 2.92386729e-02f, -1.51213165e-02f, 6.71221549e-03f, -4.34398502e-02f,
  -1.09319510e-02f, 5.40366769e-03f, -6.31653592e-02f, 1.83002949e-02f, -5.83426766e-02f, -1.25369668e-01f, 1.58781139e-03f, 8.04616809e-02f, -4.56395149e-02f, -9.08271223e-02f,
  -7.21901879e-02f, -7.62108713e-02f, -7.99924433e-02f, 6.47225082e-02f, 2.30833199e-02f, 1.06226683e-01f, 1.62443653e-01f, 1.39154404e-01f, -8.52676779e-02f, 3.48301791e-02f,
  -1.22963235e-01f, -2.23588467e-01f, 8.44496340e-02f, -3.47734168e-02f, -2.99771819e-02f, 4.58919741e-02f, 5.86787472e-03f, 6.98788762e-02f, 2.83873305e-02f, -1.54726766e-02f,
  -2.72635296e-02f, -5.63197657e-02f, 5.01752272e-03f, -3.62689197e-02f, 9.82802641e-03f, 4.05727960e-02f, -9.26586688e-02f, -7.10477382e-02f, -5.95680326e-02f, -9.94866118e-02f,
  -2.19133887e-02f, -3.84086594e-02f, -6.62881657e-02f, 3.48271020e-02f, -4.20488603e-02f, 2.00138651e-02f, -6.37500137e-02f, 4.25325185e-02f, -5.67662381e-02f, -5.15778139e-02f,
  -1.27434090e-01f, -9.63525251e-02f, -9.50465277e-02f, -2.43541345e-01f, 1.56551689e-01f, 4.80972469e-01f, 1.39603227e-01f, 1.53463578e-03f, -3.21250409e-01f, 2.08068654e-01f,
  2.28996128e-01f, -2.11730927e-01f, 1.43983319e-01f, -4.84503433e-02f, 4.92420886e-03f, -2.79393345e-02f, 8.91896561e-02f, 4.81568761e-02f, -1.08256668e-01f, 2.08248064e-01f,
  -4.52669477e-03f, 1.52105629e-01f, 6.56112954e-02f, 2.08245471e-01f, 1.50362939e-01f, 2.33243257e-02f, 2.13330090e-01f, 5.03054969e-02f, 7.67121390e-02f, -1.16031677e-01f,
  4.17497046e-02f, -1.13309219e-01f, 5.60708083e-02f, -3.38061452e-02f, 1.93534330e-01f, 9.23738256e-02f, 4.92183380e-02f, 3.26522700e-02f, -1.66982278e-01f, -3.24750990e-02f,
  -8.64610821e-02f, -1.18593611e-01f, 5.75849563e-02f, -1.29378274e-01f, -1.05557501e-01f, -1.37424022e-01f, -3.80521081e-02f, -7.09571391e-02f, -7.02389106e-02f, 7.14941025e-02f,
  -3.23540606e-02f, -2.19011940e-02f, -1.12102404e-01f, -1.73886925e-01f, -9.23543200e-02f, 5.99420108e-02f, 7.80495256e-02f, 1.59789518e-01f, -1.28958914e-02f, -2.11854316e-02f,
  2.30725985e-02f, 1.30242795e-01f, 2.49250665e-01f, -2.63393000e-02f, 6.88498840e-02f, -1.23497406e-02f, -6.10040240e-02f, 3.78993787e-02f, -2.65926979e-02f, -6.61713183e-02f,
  -2.82759815e-02f, -1.89076737e-03f, -1.76076721e-02f, 1.22801829e-02f, 1.79957843e-03f, 4.90269577e-03f, -1.38526917e-01f, -4.23846021e-02f, -5.75273223e-02f, 3.57157849e-02f,
  -9.77731124e-02f, 5.47018228e-03f, 5.20070344e-02f, -1.24032795e-02f, 1.43902022e-02f, -3.55075710e-02f, 2.62655504e-02f, -7.34209046e-02f, 3.49380225e-02f, -7.49355331e-02f,
  1.15921699e-01f, 1.70603886e-01f, -2.17731390e-02f, -8.07208642e-02f, 2.86144875e-02f, 8.01818222e-02f, -1.71624105e-02f, -1.28244478e-02f, -4.39184755e-02f, 1.08223862e-03f,
  1.01661995e-01f, -5.03318980e-02f, 8.74468014e-02f, -6.74921498e-02f, -9.13447216e-02f, 1.29910856e-01f, 8.48486274e-03f, -1.24578230e-01f, -1.31713748e-01f, 4.19433266e-02f,
  6.04670644e-02f, 1.33807182e-01f, -2.40863562e-01f, -1.16874546e-01f, -1.42187968e-01f, 3.29238027e-02f, 2.08735272e-01f, 5.08352369e-02f, -1.11988835e-01f, -1.26809344e-01f,
  2.44743571e-01f, 1.53807193e-01f, 3.06013256e-01f, 1.68464750e-01f, 4.71888036e-02f, 1.09216124e-01f, 2.38781236e-03f, 1.72861978e-01f, 2.57637203e-01f, -3.02502234e-02f,
  -1.49703488e-01f, 2.21801832e-01f, -1.77638158e-01f, 8.45670179e-02f, -1.85275972e-01f, -1.01006769e-01f, 4.01764736e-02f, -3.51886488e-02f, -2.82893586e-03f, -2.22747009e-02f,
  -7.64560653e-03f, -2.45291799e-01f, -2.53463238e-02f, -3.27067792e-01f, 1.47665396e-01f, 9.50178578e-02f, -2.47078314e-01f, -1.40781164e-01f, 8.98989849e-03f, -1.06048308e-01f,
  7.16572031e-02f, 2.09647398e-02f, 1.58500493e-01f, 9.45120752e-02f, 3.95582132e-02f, 4.35531065e-02f, 1.76892113e-02f, 5.46254441e-02f, 3.82393338e-02f, 1.05648033e-01f,
  1.08697340e-01f, 2.89634075e-02f, -4.89715450e-02f, -5.27170822e-02f, 1.72052324e-01f, 1.31805867e-01f, 1.96089551e-01f, 1.55270427e-01f, 1.63170367e-01f, 8.61470029e-02f,
  1.22162521e-01f, 2.66867220e-01f, 1.58752769e-01f, -1.30647644e-02f, 1.18479013e-01f, 7.18741789e-02f, 1.00086644e-01f, 6.16438016e-02f, 1.28289655e-01f, 6.12533763e-02f,
  1.30518051e-02f, -5.94966635e-02f, -9.49855372e-02f, 1.35695599e-02f, -1.57387182e-02f, -8.10174420e-02f, -6.10760786e-03f, -5.73562123e-02f, -9.44385380e-02f, -1.96069814e-02f,
  2.73825303e-02f, 1.81357414e-02f, -3.24924663e-03f, 6.04967587e-02f, 2.23200172e-02f, -3.57707334e-03f, 5.06553277e-02f, -3.30782942e-02f, -2.62506660e-02f, -1.65078547e-02f,
  -1.20372750e-01f, -3.86670902e-02f, -1.09042555e-01f, 3.11498977e-02f, 3.63673666e-03f, 3.41849513e-02f, 2.13079825e-02f, 1.16984598e-01f, 5.34077734e-02f, -4.98573184e-02f,
  -1.26235604e-01f, -3.04413825e-01f, -1.75372008e-02f, 2.77387127e-02f, -8.84738341e-02f, 3.75652127e-02f, 1.68198496e-02f, 9.83025357e-02f, -8.33414048e-02f, 4.45531495e-02f,
  6.43501505e-02f, -2.10434273e-02f, -1.65021997e-02f, -1.08563304e-02f, 8.05002451e-03f, 5.87139698e-03f, -5.11957332e-02f, -6.20767325e-02f, 2.48260591e-02f, -5.31829968e-02f,
  9.71105322e-02f, -8.26195404e-02f, -1.29401078e-03f, 5.02436236e-02f, 8.26526284e-02f, -4.35527526e-02f, 1.57268438e-02f, 6.32993057e-02f, 1.39823975e-02f, 4.84181717e-02f,
  -2.32075095e-01f, -1.43224150e-01f, 1.72889214e-02f, 1.10969715e-01f, 8.94042999e-02f, -2.41488382e-01f, -3.54421169e-01f, 1.42709136e-01f, -4.91142832e-02f, -1.56170964e-01f,
  2.21303236e-02f, -4.49814349e-02f, -1.97588086e-01f, -6.64489018e-03f, 2.02560127e-01f, -3.11086863e-01f, 7.68987611e-02f, 5.85527569e-02f, -5.27860522e-02f, 1.15574986e-01f,
  2.10073397e-01f, 9.76753384e-02f, 1.77430853e-01f, 1.91604331e-01f, -1.74163971e-02f, 1.64191142e-01f, 3.71090621e-01f, 1.60877436e-01f, 3.30500424e-01f, -2.77839042e-03f,
  -1.29525259e-01f, -1.23802088e-01f, 1.32779013e-02f, 2.20935680e-02f, 4.94683050e-02f, -4.79727164e-02f, 1.22837378e-02f, 3.76874208e-02f, 3.54221873e-02f, 3.96015458e-02f,
  3.85535434e-02f, 1.28390536e-01f, -8.55167769e-03f, 6.19809851e-02f, -1.13301887e-03f, 6.35791644e-02f, 5.15908748e-03f, 2.37560850e-02f, 4.86171804e-02f, -1.35097876e-01f,
  -8.45524222e-02f, 2.97688367e-03f, -2.80589294e-02f, 4.23951820e-03f, -5.66022061e-02f, -4.58636992e-02f, -2.69941688e-02f, -4.51282039e-03f, -5.37549704e-02f, -3.45214233e-02f,
  -8.31623152e-02f, -5.08166738e-02f, -5.81943952e-02f, -1.48243373e-04f, 3.49780582e-02f, 4.18019219e-04f, 8.04204196e-02f, -5.79980575e-02f, -2.70085912e-02f, 4.10684720e-02f,
  6.41358048e-02f, -1.81193929e-02f, 9.47364722e-04f, 3.32058803e-03f, -7.43463039e-02f, 3.76636721e-02f, 1.16395943e-01f, 1.80942081e-02f, -5.32583073e-02f, -1.01110209e-02f,
  -2.35427469e-02f, 9.42653418e-03f, 9.36413854e-02f, -8.62691831e-03f, -1.62684899e-02f, 8.36424306e-02f, -1.91064272e-02f, -4.59445305e-02f, 8.84596333e-02f, 5.58986962e-02f,
  -2.80249957e-02f, 1.00219280e-01f, 4.78879549e-03f, 2.97695771e-02f, -5.09066926e-03f, -2.46454217e-02f, -4.19463869e-03f, -1.82082262e-02f, -5.42648742e-03f, 1.65995415e-02f,
  7.92550966e-02f, 1.19794242e-01f, -3.64789669e-03f, 4.57460806e-02f, 9.63239595e-02f, -3.67792211e-02f, 6.72234222e-02f, 1.54237211e-01f, 1.47017062e-01f, 1.73646659e-01f,
  2.44219974e-02f, 1.69510196e-04f, 4.85968143e-02f, -3.39578278e-02f, -1.18161306e-01f, -2.59851869e-02f, -7.06698671e-02f, -1.85021926e-02f, -3.16612311e-02f, -5.15870750e-02f,
  7.38648623e-02f, -4.26983833e-02f, -1.59756821e-02f, 2.21389100e-01f, 3.10655266e-01f, -1.19153466e-02f, 2.12209165e-01f, 3.49683702e-01f, 5.38260937e-01f, -7.56832585e-02f,
  2.25514956e-02f, -1.44067451e-01f, -1.00926692e-02f, -9.55406763e-03f, -3.14816833e-01f, 3.88439782e-02f, -1.49248853e-01f, -3.16758603e-02f, 2.17994168e-01f, 7.93049335e-02f,
  8.84915963e-02f, -1.15644790e-01f, -2.82943428e-01f, 7.95532167e-02f, 3.31484317e-03f, 1.19813278e-01f, -3.35546672e-01f, 8.82111415e-02f, -3.24206978e-01f, -1.08934276e-01f,
  -4.07306217e-02f, 2.24333361e-01f, -1.42172351e-01f, 1.08686425e-02f, -1.06168926e-01f, 2.04767082e-02f, -1.03344388e-01f, -6.99621141e-02f, -3.18008997e-02f, 5.87433390e-02f,
  -4.18946818e-02f, -3.85706201e-02f, 2.13310476e-02f, 8.66179466e-02f, 1.32485285e-01f, 1.81133915e-02f, -2.67403442e-02f, 1.56663001e-01f, -1.76343210e-02f, 6.08574376e-02f,
  2.98689231e-02f, 1.78575516e-02f, -1.02164373e-02f, 1.31882762e-03f, -1.56399235e-01f, 1.39840066e-01f, 2.29553245e-02f, -1.32482111e-01f, -4.70454171e-02f, -3.34170386e-02f,
  7.91504085e-02f, 1.87393907e-03f, -3.04462556e-02f, 7.13738129e-02f, -5.22416681e-02f, -6.72324235e-03f, -7.77974874e-02f, -4.20897417e-02f, 8.26582164e-02f, -5.49111627e-02f,
  -2.81052124e-02f, -1.79065298e-02f, 2.87070479e-02f, 1.98429506e-02f, -1.57741085e-02f, 1.17609419e-01f, -6.28485903e-02f, -7.17832446e-02f, -3.28508988e-02f, -5.70376329e-02f,
  1.35659054e-01f, 1.57067589e-02f, -1.60646304e-01f, 1.82228088e-02f, -7.93123469e-02f, 1.37566607e-02f, 1.39634728e-01f, -7.26986583e-03f, 6.30374849e-02f, -9.87645239e-02f,
  -5.66542186e-02f, -3.09748612e-02f, -9.93283913e-02f, 3.33356075e-02f, -1.08715937e-01f, -7.77122751e-02f, 7.75329694e-02f, -1.08807094e-01f, -1.24711074e-01f, 7.43838623e-02f,
  -2.19188835e-02f, 6.55311123e-02f, 6.04852885e-02f, 7.95249939e-02f, -7.84051195e-02f, -5.30271158e-02f, -6.81929812e-02f, 3.47364098e-02f, -1.94286376e-01f, -4.76571405e-03f,
  4.61953841e-02f, 1.07337885e-01f, -1.19966250e-02f, -1.71397328e-02f, -6.04574084e-02f, -6.76791891e-02f, 9.45852622e-02f, -3.02525293e-02f, -3.69465612e-02f, -3.50646228e-02f,
  -8.83204490e-02f, 3.74193221e-01f, 2.15271622e-01f, -2.53350705e-01f, -4.32607308e-02f, -1.69897527e-01f, -2.84661025e-01f, -4.66427468e-02f, -1.35546653e-02f, 8.14277213e-03f,
  -1.64178923e-01f, 2.29024872e-01f, 8.74958560e-02f, -1.85100690e-01f, -1.91517770e-01f, 6.33363575e-02f, -4.27237660e-01f, -1.48983657e-01f, 4.43515442e-02f, -2.45771140e-01f,
  -1.40636370e-01f, -3.13873887e-01f, -4.39044833e-02f, -1.01443984e-01f, -1.17372014e-01f, 1.05367690e-01f, -2.64422242e-02f, 1.15300454e-01f, -1.06062941e-01f, 1.23832889e-01f,
  2.37454548e-02f, -3.38685215e-02f, 2.88507976e-02f, 3.76006998e-02f, -1.14207983e-01f, -9.57169086e-02f, -7.51878023e-02f, -8.80127773e-03f, -8.22503567e-02f, -4.43781093e-02f,
  4.91832197e-02f, 2.89951637e-02f, -3.54101993e-02f, 9.87529233e-02f, 6.06835308e-03f, 8.21990222e-02f, 6.19890168e-02f, 9.96927917e-02f, 1.35092558e-02f, 4.34473529e-02f,
  3.69812064e-02f, 1.17775477e-01f, -3.51182632e-02f, 1.67954918e-02f, -2.45735217e-02f, 3.95142324e-02f, 4.34957445e-02f, 8.61868635e-02f, -3.58009711e-02f, -6.62973672e-02f,
  -1.17567956e-01f, -1.42117277e-01f, 3.00744064e-02f, 6.37763366e-02f, -4.01508473e-02f, 6.39367551e-02f, 4.90997210e-02f, 3.27349305e-02f, -2.46265884e-02f, -4.61116768e-02f,
  -2.22968776e-02f, 2.34077275e-02f, -5.38063310e-02f, -1.03363588e-01f, -1.10384457e-01f, 6.10098802e-03f, 4.46993560e-02f, 5.49109504e-02f, 8.84019490e-03f, -1.16347089e-01f,
  -1.83970500e-02f, -8.26594681e-02f, 3.75531837e-02f, 7.01568127e-02f, -3.23556885e-02f, 2.95513924e-02f, 3.93484123e-02f, 9.78628471e-02f, -1.06731616e-02f, -1.12550817e-01f,
  -2.01897293e-01f, -2.99976319e-01f, -8.19142349e-03f, 8.02596733e-02f, 1.36750350e-02f, -1.10797234e-01f, -2.16671266e-02f, -1.63243376e-02f, -1.11981362e-01f, -1.50805384e-01f,
  -1.06822485e-02f, -3.43702547e-02f, -1.20457709e-02f, 4.57238667e-02f, -7.80296549e-02f, -6.45652190e-02f, -6.42987341e-02f, 7.22159445e-02f, -1.47722438e-01f, 6.72808513e-02f,
  4.06485498e-02f, 5.53364977e-02f, 6.48235157e-03f, -1.82952151e-01f, -1.72274873e-01f, 8.68439153e-02f, -2.06424110e-02f, 5.89803532e-02f, -1.79528967e-01f, -4.64940369e-02f,
  -1.14955001e-01f, -3.82206142e-01f, -1.33315608e-01f, 2.90262140e-02f, 2.36237392e-01f, 1.49711818e-01f, -5.26818484e-02f, -5.72387204e-02f, -3.04067582e-01f, -3.20066861e-03f,
  -1.23363569e-01f, -1.92729235e-01f, -1.72341928e-01f, -2.36664802e-01f, -2.23178223e-01f, -4.27292585e-01f, 4.15011607e-02f, -3.87814976e-02f, -1.67925850e-01f, 1.41330063e-01f,
  5.60828932e-02f, 7.05032349e-02f, -2.20867284e-02f, 2.96144545e-01f, 1.19277470e-01f, 2.93545216e-01f, 3.02263498e-01f, 8.78589824e-02f, 3.27530891e-01f, 1.08213257e-02f,
  -1.42760202e-01f, -1.83748767e-01f, -6.09075353e-02f, -5.27800396e-02f, 1.37439787e-01f, 1.34320438e-01f, 3.37681957e-02f, -8.16242099e-02f, -2.86392439e-02f, 3.56230373e-03f,
  1.82149485e-02f, 2.27649417e-03f, -3.93393859e-02f, -1.08997840e-02f, 4.27411944e-02f, -2.50031687e-02f, -5.77301765e-03f, -9.74310115e-02f, -6.28967732e-02f, -8.33206102e-02f,
  3.77594610e-03f, -2.43266616e-02f, 8.61960799e-02f, 8.13974887e-02f, 8.49420056e-02f, 5.25484346e-02f, 4.30428982e-02f, 1.82854593e-01f, 1.50467455e-02f, 6.28432864e-03f,
  7.47371763e-02f, 4.19138409e-02f, -2.43859235e-02f, -2.31047973e-01f, -8.18021968e-02f, -7.01897815e-02f, -1.21112369e-01f, -3.32053547e-04f, -5.70564419e-02f, -5.76594658e-02f,
  1.32170122e-03f, -2.78989207e-02f, -1.68102384e-01f, 8.70404858e-03f, 7.92995915e-02f, -4.20478955e-02f, -7.01226816e-02f, 6.46060482e-02f, 1.23058811e-01f, -7.97444284e-02f,
  -1.42561987e-01f, -3.13515700e-02f, -1.84317175e-02f, -1.69521738e-02f, -1.64262831e-01f, 1.11584835e-01f, 9.90889817e-02f, -7.42558241e-02f, -8.97321478e-02f, 2.51531843e-02f,
  1.03750452e-01f, 1.99803978e-01f, 2.22665467e-03f, -5.41752838e-02f, -7.69929290e-02f, 2.97294464e-02f, -9.75096747e-02f, -2.54693944e-02f, 8.18972290e-02f, -2.20958311e-02f,
  2.14475766e-01f, 3.60632166e-02f, 8.53629187e-02f, -5.39794005e-02f, -1.60181299e-02f, -8.32977239e-03f, 1.03494443e-01f, -1.47496490e-03f, 1.38696626e-01f, 3.80295962e-02f,
  1.38095856e-01f, 4.79919687e-02f, 2.58792546e-02f, 5.03932722e-02f, 1.19938880e-01f, 1.35367230e-01f, 2.45005358e-02f, 1.56078264e-01f, 1.88525673e-02f, -1.03821598e-01f,
  -5.03357649e-01f, 1.93153679e-01f, -8.98630992e-02f, -1.73510075e-01f, 1.66213438e-01f, 4.48580176e-01f, 2.36370966e-01f, 3.08401696e-03f, -2.10537955e-01f, 1.54779583e-01f,
  2.15812773e-01f, -2.31992099e-02f, 1.27679348e-01f, 1.82108179e-01f, 2.38118142e-01f, 2.82088816e-01f, 1.10217839e-01f, -3.49643826e-03f, 7.90296355e-04f, -1.33128777e-01f,
  -7.48762563e-02f, 2.33419389e-01f, 1.53085008e-01f, -7.88474306e-02f, 1.62915811e-02f, -2.85653621e-01f, -8.35034102e-02f, 3.76335941e-02f, 8.37297440e-02f, 2.72939056e-01f,
  6.45387024e-02f, -3.52134734e-01f, -2.90105194e-02f, -6.70823604e-02f, -9.71754454e-03f, -1.02874920e-01f, -5.23863658e-02f, 1.03824556e-01f, -8.00774712e-03f, -2.88308226e-02f,
  -6.31578416e-02f, -4.08941275e-03f, -1.31838068e-01f, -3.21854800e-02f, -1.48441046e-01f, 9.84476972e-03f, 2.15399310e-01f, 1.56175166e-01f, 1.11577369e-01f, 1.35743693e-01f,
  8.28110725e-02f, 6.39465675e-02f, 7.09946966e-03f, 6.72773421e-02f, 9.64579880e-02f, 5.12888767e-02f, -3.18798982e-02f, -6.71737865e-02f, 1.65135972e-02f, -4.81098443e-02f,
  -1.67739972e-01f, -1.31597267e-02f, 8.67326558e-02f, 6.40888959e-02f, -5.72074726e-02f, 7.52354711e-02f, 2.94507816e-02f, 4.55957837e-02f, 9.57312584e-02f, 9.84868780e-02f,
  1.00342117e-01f, 3.08409426e-02f, -8.69107693e-02f, -1.94009319e-02f, 5.04779071e-02f, 1.60621963e-02f, -1.35852555e-02f, 4.15797122e-02f, -2.51839962e-02f, 8.88265669e-02f,
  1.62443612e-02f, -8.69836286e-02f, 1.74586044e-03f, 4.68488000e-02f, 3.24281380e-02f, 8.57955217e-02f, -1.24042131e-01f, 1.00103483e-01f, 7.28328601e-02f, 7.01853931e-02f,
  7.55909383e-02f, -2.59559363e-01f, 9.52552631e-02f, 6.52997345e-02f, 3.84736694e-02f, 5.62968701e-02f, -6.92530125e-02f, 2.48772353e-02f, 8.39634985e-02f, -1.47212762e-02f,
  -6.54731542e-02f, -6.36038333e-02f, -9.68901142e-02f, -1.61584243e-02f, -7.32061192e-02f, 5.31111993e-02f, 8.77665877e-02f, 9.82294530e-02f, 1.40325740e-01f, 1.02663480e-01f,
  1.07647181e-01f, -1.24212783e-02f, -3.87666114e-02f, -3.63133894e-03f, -6.79112524e-02f, 1.43507868e-01f, -1.25037700e-01f, -1.28280818e-01f, -3.81338149e-02f, -8.78931805e-02f,
  -6.78503454e-01f, 1.63513929e-01f, 1.03116959e-01f, 4.72165346e-02f, -9.87235531e-02f, -1.49292931e-01f, -1.35001138e-01f, -9.96392071e-02f, -1.08396634e-01f, 8.51207301e-02f,
  -1.96114611e-02f, -2.77854383e-01f, 1.53798252e-01f, 2.65632331e-01f, -1.91686004e-01f, 3.02625209e-01f, 1.40122712e-01f, -2.63564046e-02f, 5.05875871e-02f, -6.16351189e-03f,
  -2.42845509e-02f, 1.49052933e-01f, 2.44936898e-01f, 2.47067466e-01f, -6.75386414e-02f, -2.88192555e-02f, 8.97753835e-02f, 7.48525336e-02f, 9.44551826e-02f, -1.49775699e-01f,
  -1.53015777e-01f, -3.05051897e-02f, -1.00072101e-02f, -1.55520022e-01f, -8.09412971e-02f, -6.60543963e-02f, 2.37952303e-02f, 5.82709834e-02f, -3.75271472e-03f, -8.51015523e-02f,
  -8.33390057e-02f, -1.16850194e-02f, 9.03383568e-02f, -9.47193988e-03f, -1.44841969e-01f, 1.15400366e-03f, 2.85776723e-02f, 5.40431142e-02f, -8.94413143e-02f, 1.62636451e-02f,
  2.15097386e-02f, 1.11097008e-01f, -5.48937880e-02f, 7.42015019e-02f, 6.78938208e-03f, -5.47039770e-02f, 4.57890928e-02f, -9.51849297e-02f, -4.15651426e-02f, -7.94308558e-02f,
  2.36046668e-02f, 4.53850850e-02f, 1.23321041e-02f, 9.15724318e-03f, 7.33776540e-02f, 1.72331762e-02f, 7.18439296e-02f, 2.08471771e-02f, 3.31043117e-02f, -8.19710083e-03f,
  -8.92426595e-02f, -5.35630547e-02f, -5.20672873e-02f, 9.75563715e-04f, -3.93319577e-02f, -1.32011687e-02f, 4.19680960e-02f, 1.69343520e-02f, 7.15335384e-02f, 2.19920408e-02f,
  -9.66548324e-02f, -3.64541821e-02f, -3.60565223e-02f, 2.40727756e-02f, 1.79991219e-02f, -6.75675869e-02f, 7.82431960e-02f, 4.51802351e-02f, -6.04738481e-02f, -4.95051369e-02f,
  -3.19770157e-01f, -1.22451149e-01f, -1.65093609e-03f, -2.07594976e-01f, -1.76423707e-03f, -4.53468263e-02f, 8.02125335e-02f, 1.38162896e-02f, -1.44095168e-01f, -9.37818289e-02f,
  -1.08919650e-01f, -7.41472468e-02f, -1.07267927e-02f, 2.98243103e-04f, 7.87281021e-02f, 3.09869070e-02f, -8.42588767e-02f, -1.57826077e-02f, -1.39236510e-01f, -9.08335522e-02f,
  1.17509671e-01f, -1.05125029e-02f, 6.20519966e-02f, 1.59023076e-01f, 6.54700696e-02f, -8.38486850e-02f, -5.06427214e-02f, 1.09249391e-01f, 2.46825069e-02f, 9.93408114e-02f,
  8.01960751e-02f, -2.46870164e-02f, -1.45485058e-01f, -6.92079738e-02f, -2.73459442e-02f, -2.87714005e-01f, -2.50755966e-01f, -1.11338094e-01f, 1.08902417e-01f, 4.85616401e-02f,
  -5.53225502e-02f, 1.11511812e-01f, 8.06386247e-02f, -1.84511587e-01f, 2.13144720e-03f, 2.20956728e-01f, -2.32390329e-01f, -6.41898438e-02f, 1.86219275e-01f, -3.02859038e-01f,
  -3.55427116e-02f, -9.13403854e-02f, -5.02986535e-02f, -1.96706191e-01f, -1.76226437e-01f, -4.53575701e-02f, 1.25991404e-01f, -7.57566243e-02f, -1.25825211e-01f, 4.41224175e-03f,
  -6.06248192e-02f, -5.71992323e-02f, -1.79287717e-02f, -1.47796683e-02f, -8.29653069e-02f, -8.79319310e-02f, 2.83607893e-04f, -6.06838465e-02f, -5.91888838e-02f, 1.71524787e-03f,
  7.31423125e-02f, 1.15333945e-01f, -1.62177041e-01f, 1.01118557e-01f, 6.20359592e-02f, 6.21624216e-02f, 4.57976088e-02f, 7.46492669e-02f, 1.45655433e-02f, 6.23362102e-02f,
  -4.74335859e-03f, 6.33905381e-02f, 6.00164011e-02f, 7.68255070e-02f, 5.30312732e-02f, 2.99032521e-03f, 4.80551496e-02f, 2.03215405e-02f, -2.05248073e-02f, 8.44491422e-02f,
  -4.85132895e-02f, -1.51625089e-02f, -5.73378056e-02f, 5.32749668e-02f, -6.45695329e-02f, -3.81084569e-02f, -4.69275191e-02f, -1.88969169e-02f, -6.35351101e-03f, 3.08699347e-02f,
  1.41629294e-01f, -3.63938883e-02f, -8.77479836e-03f, -8.80227983e-02f, 5.63052893e-02f, 2.83476640e-03f, -1.87013913e-02f, 2.61498187e-02f, 5.08801043e-02f, -4.83256616e-02f,
  -3.67677361e-02f, -9.34320837e-02f, 4.70166877e-02f, 6.08282685e-02f, -2.15104725e-02f, 6.34834170e-02f, 5.88239096e-02f, 3.13998424e-02f, -2.14024279e-02f, -1.60723403e-02f,
  -6.83653653e-02f, -1.67982221e-01f, -3.50158811e-02f, -1.92135200e-02f, -1.88602339e-02f, -2.38354760e-03f, 6.41502021e-03f, -6.75519928e-02f, -1.01617567e-01f, -9.93334576e-02f,
  1.70832556e-02f, 1.92762371e-02f, 3.89314629e-02f, 1.56312995e-02f, 8.48080497e-03f, -4.33667116e-02f, 2.83318572e-03f, 1.03908576e-01f, -1.28314393e-02f, -2.07301881e-02f,
  -1.99388601e-02f, 5.57238497e-02f, 7.55155459e-02f, -1.00053139e-02f, 9.04850778e-04f, 8.29188749e-02f, -5.05258441e-02f, 3.52793187e-02f, -4.27366793e-02f, 5.01135550e-02f,
  3.05306464e-01f, 3.17324102e-01f, 2.62438774e-01f, 2.03972384e-01f, 2.86416888e-01f, 3.28443140e-01f, 1.66964099e-01f, 1.03569329e-01f, 4.25535440e-01f, -3.77210751e-02f,
  -1.08715594e-01f, 1.08159147e-01f, -3.06862533e-01f, 4.56247069e-02f, -9.19952095e-02f, -5.91854379e-03f, 1.50804996e-01f, 5.70217036e-02f, 1.63526818e-01f, -4.74088304e-02f,
  -3.38717103e-02f, -1.26066908e-01f, -3.52578163e-01f, -1.90287858e-01f, 6.69414923e-02f, -4.82991599e-02f, -3.37926835e-01f, -1.08268231e-01f, -2.57806569e-01f, 7.10799918e-02f,
  5.34640253e-02f, 1.56917162e-02f, -2.91951057e-02f, -5.02975248e-02f, 2.99714580e-02f, -3.63688394e-02f, -1.90719441e-02f, -6.62644804e-02f, -5.62708080e-02f, -3.09312101e-02f,
  -6.69480935e-02f, -9.78967324e-02f, 4.72283177e-02f, -6.42170161e-02f, 2.93701012e-02f, -2.45767403e-02f, -4.27673645e-02f, 2.06607915e-02f, -1.94754422e-01f, 6.12863749e-02f,
  -4.03276924e-03f, -5.78877423e-03f, 9.07583907e-02f, -2.34629996e-02f, 8.80437940e-02f, 4.09908853e-02f, 1.62692621e-01f, 3.44357453e-02f, 4.31068428e-02f, 1.13976352e-01f,
  -5.03020734e-02f, 1.67459145e-01f, 8.45841020e-02f, 2.82774977e-02f, 1.51207715e-01f, 5.65360039e-02f, 5.69311678e-02f, 8.60692710e-02f, 1.89701378e-01f, 1.58152860e-02f,
  1.38483858e-02f, 9.95718092e-02f, -3.44906934e-02f, -5.46627715e-02f, 9.01262835e-02f, 4.99223880e-02f, -3.76333334e-02f, -3.85865904e-02f, 9.25973803e-02f, 1.29746690e-01f,
  -3.94629315e-02f, 2.12891418e-02f, -7.71548748e-02f, -1.51003897e-01f, -1.02687180e-01f, -6.51374906e-02f, -1.04379952e-01f, -5.34479991e-02f, -8.63701105e-02f, -2.35639457e-02f,
  1.55737653e-01f, 1.60892472e-01f, -2.63288748e-02f, -9.15919691e-02f, -6.41269535e-02f, 5.73625341e-02f, 6.30505607e-02f, 9.13690329e-02f, 3.00727668e-03f, 8.22415948e-02f,
  -3.46693881e-02f, 3.30249816e-02f, -1.23986118e-02f, -6.59185499e-02f, -7.82487988e-02f, 8.37734491e-02f, -2.00318635e-01f, -9.78316087e-03f, -4.60586958e-02f, -8.92401040e-02f,
  -6.55206814e-02f, -1.86132435e-02f, 5.44226691e-02f, 9.76838991e-02f, 1.42228499e-01f, -8.94024968e-02f, 1.21983103e-01f, -3.31588574e-02f, 7.73514882e-02f, 3.00979763e-02f,
  -1.58240050e-01f, 1.70885578e-01f, -1.57672837e-01f, 3.52656275e-01f, -1.82525977e-01f, 2.58359879e-01f, 2.93402463e-01f, 9.91579983e-03f, 2.19431415e-01f, 3.17830116e-01f,
  9.27399546e-02f, 8.65196660e-02f, -1.44600216e-02f, 4.04215902e-01f, 9.13858488e-02f, 2.69375712e-01f, 4.94997948e-01f, 2.98365712e-01f, 5.18715046e-02f, 1.83361411e-01f,
  7.78534189e-02f, 2.94745952e-01f, -9.36968848e-02f, -3.91205028e-02f, -1.08152859e-01f, -1.90474957e-01f, -1.94849849e-01f, -2.06106186e-01f, 1.29345888e-02f, -8.27335492e-02f,
  2.34289630e-03f, 3.34677286e-02f, -9.31700021e-02f, -2.51209531e-02f, 1.87629648e-02f, 5.17189503e-02f, 3.71771380e-02f, -8.26694444e-02f, -7.58779980e-03f, -3.64233889e-02f,
  7.12239221e-02f, 2.33154763e-02f, 7.12176412e-02f, -1.10278040e-01f, -1.80383101e-02f, -3.03486008e-02f, -2.31638979e-02f, -9.30139869e-02f, 1.53074637e-02f, -2.60255523e-02f,
  -7.61182755e-02f, -6.82459921e-02f, 7.83475768e-03f, 1.59392748e-02f, -8.00995752e-02f, 2.49878298e-02f, 5.16603068e-02f, -6.81777075e-02f, -1.38059296e-02f, 5.72149381e-02f,
  -8.43763202e-02f, 1.03286140e-01f, 1.68884136e-02f, -6.92071542e-02f, -3.32115144e-02f, 3.80740594e-03f, 1.24832420e-02f, 4.42370251e-02f, -1.02978610e-02f, 5.89697249e-02f,
  7.33639598e-02f, -7.60591449e-03f, 3.84285860e-02f, -3.18584591e-02f, 1.17507525e-01f, -9.87946894e-03f, -1.17988288e-01f, 2.82910764e-02f, -1.07478136e-02f, 3.31856101e-03f,
  2.09130184e-03f, 4.54034433e-02f, -1.23298354e-01f, -6.00698357e-03f, 1.22818694e-01f, -1.52209997e-01f, 4.42189835e-02f, -6.68575019e-02f, -5.38240708e-02f, 6.03818754e-03f,
  2.22945228e-01f, 3.07211131e-01f, -1.05003268e-02f, 1.53703918e-03f, 1.05813444e-01f, 5.93186989e-02f, 8.95739719e-02f, -2.90417951e-02f, 1.44320920e-01f, 5.95998950e-02f,
  2.28905659e-02f, -6.49998942e-03f, 3.28749092e-03f, -1.62888467e-01f, 9.99520198e-02f, 5.19079203e-03f, 2.05202535e-01f, 1.21998768e-02f, 9.75081176e-02f, -5.24310023e-02f,
  -5.81222549e-02f, 1.10510634e-02f, 9.79546085e-02f, 8.06577504e-02f, 1.43668249e-01f, -6.93931729e-02f, 7.72820029e-04f, -5.22105284e-02f, 3.70986969e-03f, 9.62908342e-02f,
  -2.81865925e-01f, -3.58982503e-01f, -6.85045719e-02f, 4.90792608e-03f, 1.79483891e-01f, 1.34494528e-01f, 5.60947806e-02f, -1.88617691e-01f, -2.52493471e-01f, -2.14854434e-01f,
  2.22418644e-02f, -3.08751091e-02f, -1.94009140e-01f, 8.80756695e-03f, 2.63283491e-01f, -2.00742930e-01f, 4.39327843e-02f, 5.81183545e-02f, -1.19838484e-01f, -1.38899952e-01f,
  3.59436683e-02f, -5.71132302e-02f, 2.02417187e-02f, 3.08419894e-02f, -7.08175227e-02f, 1.72338143e-01f, 2.44624183e-01f, 1.92105368e-01f, 3.45518559e-01f, 2.22084016e-01f,
  6.01150934e-03f, -1.91012740e-01f, -4.28354405e-02f, -2.68341824e-02f, 3.36905941e-03f, 5.84537424e-02f, 1.96313679e-01f, 2.01785803e-01f, 1.74817160e-01f, -4.79474068e-02f,
  4.00123522e-02f, 1.93382874e-01f, -1.06291100e-01f, 1.13281123e-01f, 8.40636790e-02f, 1.03336833e-01f, 1.63845420e-02f, -6.37250096e-02f, 7.19810184e-03f, -1.10981479e-01f,
  -1.02544211e-01f, -8.49294364e-02f, 7.84789305e-03f, 5.62192723e-02f, 1.98079720e-02f, 1.12523502e-02f, -3.45431305e-02f, 2.89628822e-02f, -5.73186018e-02f, 2.15842184e-02f,
  -2.03620102e-02f, -3.33902948e-02f, -1.27902299e-01f, -8.57627466e-02f, -8.58803764e-02f, 3.07217930e-02f, 1.22230202e-02f, -3.96239981e-02f, 4.63252850e-02f, -5.99546619e-02f,
  -4.51322012e-02f, -9.82804596e-03f, 2.60850936e-02f, 8.19038600e-02f, -8.70311260e-02f, -1.99003190e-01f, 1.23483226e-01f, 4.09501866e-02f, -9.20235515e-02f, -2.07461547e-02f,
  3.97172943e-02f, 9.34017822e-02f, 8.03922676e-03f, 5.06163798e-02f, -1.19413912e-01f, 5.46455756e-02f, 1.25543490e-01f, -5.19752456e-03f, -1.04499990e-02f, 7.03132376e-02f,
  5.67073897e-02f, -1.72709614e-01f, -3.68736796e-02f, 6.34374395e-02f, -2.97418535e-02f, -6.65707290e-02f, 1.54088996e-02f, -2.64126938e-02f, 5.51235005e-02f, -1.88805327e-01f,
  7.27903619e-02f, 1.57832697e-01f, -1.10233165e-01f, 1.04462644e-02f, 1.63224906e-01f, -7.41903186e-02f, 7.75065050e-02f, 6.53479109e-03f, -1.94749120e-03f, -5.72081581e-02f,
  4.37203720e-02f, -4.90028337e-02f, 9.83161200e-03f, -5.13209701e-02f, -6.26051277e-02f, -3.48440325e-03f, -2.75603402e-02f, -1.53460735e-02f, 3.89501713e-02f, 8.64208639e-02f,
  4.70612466e-01f, -1.52083039e-01f, -1.82538971e-01f, 8.28252882e-02f, 2.27710798e-01f, 2.65510321e-01f, 1.13324791e-01f, -1.03597566e-02f, 5.06238788e-02f, -5.43828234e-02f,
  1.00080140e-01f, 9.33023766e-02f, -1.67328596e-01f, 2.72152990e-01f, 4.12831068e-01f, -7.36991614e-02f, 1.99740306e-01f, 5.11412732e-02f, 6.70076162e-03f, 2.05106884e-01f,
  1.21117219e-01f, 3.70164096e-01f, 2.71062590e-02f, 4.33049761e-02f, 1.58845395e-01f, -2.88424253e-01f, -8.54486413e-03f, -1.44155547e-01f, 4.48598713e-02f, 1.46541923e-01f,
  -1.28561528e-02f, 4.81071360e-02f, -6.96704313e-02f, -7.08040372e-02f, -1.94276460e-02f, 7.04362765e-02f, -3.86637338e-02f, -5.33688068e-02f, 3.31343189e-02f, -3.09562124e-02f,
  -2.18072031e-02f, 5.02972640e-02f, -2.67733205e-02f, 6.64953738e-02f, 9.07993838e-02f, 1.10171344e-02f, -5.58377355e-02f, -1.94097403e-02f, -5.39017022e-02f, 1.15575716e-01f,
  2.80277361e-03f, -5.11397608e-02f, 5.46891466e-02f, -3.91303711e-02f, -6.12107106e-03f, -2.63249241e-02f, -2.14444511e-02f, -7.11991116e-02f, -6.34133071e-02f, 1.17982484e-01f,
  6.50278851e-02f, -3.22695524e-02f, 3.79065331e-03f, -9.85762477e-03f, 2.15012906e-03f, -8.05807952e-03f, -1.29173510e-02f, -4.99771051e-02f, 9.66363773e-03f, -2.86000036e-02f,
  -3.36905271e-02f, -2.36703455e-02f, 2.31856480e-02f, 5.60119972e-02f, 3.63740586e-02f, 7.68824364e-04f, 6.63112989e-03f, -6.32982701e-02f, -1.43468808e-02f, -5.96921965e-02f,
  -5.32700829e-02f, 5.82685731e-02f, -5.49346544e-02f, -6.53075129e-02f, -1.37439454e-02f, 2.65348516e-02f, 4.74138968e-02f, 7.42282048e-02f, -6.89068288e-02f, 1.92362648e-02f,
  -1.36445602e-02f, -5.10860607e-03f, -1.10374555e-01f, -6.41516298e-02f, -8.30175504e-02f, 1.44240618e-01f, 2.88232584e-02f, -3.49062644e-02f, 5.86317405e-02f, 9.33344588e-02f,
  1.67400315e-02f, -1.00695930e-01f, 3.58123891e-02f, -2.56631188e-02f, -5.73102850e-03f, 2.27445308e-02f, -4.07167897e-02f, -3.34327295e-02f, -8.01229924e-02f, -1.98266283e-02f,
  -1.37683367e-02f, 3.51393968e-02f, -4.47584577e-02f, -4.09833901e-02f, -1.00201629e-02f, -7.10021183e-02f, 1.20079748e-01f, -3.69079113e-02f, -3.47376168e-02f, -7.37673743e-03f,
  3.13130379e-01f, 5.67781515e-02f, -6.81021288e-02f, 3.67580503e-02f, 1.42274886e-01f, 2.25908365e-02f, -1.41930625e-01f, 3.42088193e-02f, -9.09493491e-02f, -3.64379175e-02f,
  2.33016610e-01f, -1.73709124e-01f, 4.23399769e-02f, 3.38958174e-01f, 2.37157941e-01f, 1.08483702e-01f, 8.12096521e-02f, 1.79450661e-02f, -1.01571195e-02f, 2.20800892e-01f,
  4.61240374e-02f, 3.72404814e-01f, 1.86564520e-01f, 1.31529957e-01f, 2.17386633e-01f, -1.71894714e-01f, 1.68554649e-01f, -7.58841187e-02f, 1.85369924e-02f, 1.23052094e-02f,
  7.36461058e-02f, 1.89491034e-01f, 5.34689389e-02f, -8.62679631e-02f, 1.72495723e-01f, 1.38271097e-02f, -1.25659615e-01f, -8.66569504e-02f, -1.31793335e-01f, -2.41880398e-02f,
  -1.39571473e-01f, -6.54856637e-02f, 9.57657956e-03f, 1.62866071e-01f, 3.67429778e-02f, -4.49128523e-02f, 2.95120087e-02f, -5.89270182e-02f, -2.02149674e-01f, 1.58533335e-01f,
  2.07889434e-02f, -7.41046742e-02f, -7.48826424e-03f, -1.12728949e-03f, -2.58008167e-02f, -5.32958061e-02f, -4.21359763e-02f, 1.19147068e-02f, -4.71162200e-02f, 2.46137176e-02f,
  3.48652527e-02f, -8.20561871e-02f, 3.73633951e-02f, 1.48150129e-02f, 4.78453189e-02f, 2.91439239e-02f, -8.54079276e-02f, -1.96450111e-02f, -8.58412459e-02f, 1.13566136e-02f,
  -6.53719008e-02f, -8.22337791e-02f, -2.59070415e-02f, 1.84669392e-03f, -5.70717901e-02f, -1.78141855e-02f, -5.23337349e-02f, 2.44548861e-02f, 7.01250061e-02f, -7.39598721e-02f,
  -8.95471349e-02f, 2.43331250e-02f, -9.50755626e-02f, -6.07627630e-02f, -6.70051724e-02f, -2.81366929e-02f, 6.62356392e-02f, 7.59924427e-02f, 2.54943427e-02f, -1.78945549e-02f,
  3.96289825e-02f, 1.04840726e-01f, -3.81531902e-02f, -1.22211978e-01f, -2.19876622e-03f, 1.12027526e-01f, 2.76939832e-02f, -3.88409682e-02f, -7.48865828e-02f, 4.93541621e-02f,
  -2.26914026e-02f, -1.18589982e-01f, 7.66565204e-02f, 7.75585324e-02f, -4.03332636e-02f, 7.29374662e-02f, -1.04234196e-01f, -1.65473983e-01f, -2.15327412e-01f, 2.93895677e-02f,
  9.81680825e-02f, 7.99723044e-02f, -1.44211784e-01f, -2.89115570e-02f, -9.39326286e-02f, -1.74840540e-02f, 5.36733866e-02f, -1.08908657e-02f, 8.53803158e-02f, -8.51716697e-02f,
  -1.22793335e-02f, -1.62379324e-01f, -1.54535860e-01f, -2.29692370e-01f, 1.53976917e-01f, 3.32923681e-01f, 9.45313871e-02f, -1.47693485e-01f, -4.01176184e-01f, -2.15587825e-01f,
  3.51135470e-02f, -1.03279285e-01f, -1.08018741e-01f, 8.12622681e-02f, 3.99355531e-01f, 8.57107118e-02f, 4.42883372e-02f, 3.26051712e-02f, 1.54937938e-01f, 1.65522575e-01f,
  1.37414947e-01f, 2.98833728e-01f, 1.39391854e-01f, 2.19491601e-01f, 3.09658498e-02f, -2.39300150e-02f, 8.52873251e-02f, 8.30785185e-02f, 5.87693006e-02f, 5.29011972e-02f,
  1.59480870e-01f, -1.77257046e-01f, 6.13976419e-02f, -1.22265797e-02f, 7.33203366e-02f, 2.36196443e-02f, 1.00606054e-01f, 1.50689498e-01f, -7.89524540e-02f, -1.29792811e-02f,
  -1.78441368e-02f, -7.59788975e-03f, -7.49535337e-02f, 1.48863569e-01f, -1.02330288e-02f, -3.87684405e-02f, 9.51810507e-04f, -8.08884669e-03f, 3.29792500e-02f, 1.90726407e-02f,
  -6.60902262e-02f, 9.09319799e-03f, -1.75485969e-01f, -7.63921365e-02f, -1.33545682e-01f, -2.54481919e-02f, 4.62779924e-02f, -5.63869253e-02f, -8.91995430e-02f, -1.02657996e-01f,
  -5.94903938e-02f, 6.60577193e-02f, 9.85173434e-02f, 1.03071414e-01f, 3.57873067e-02f, 6.26299754e-02f, 6.60681278e-02f, 6.33772388e-02f, -2.49181744e-02f, 2.16196850e-02f,
  -7.42618069e-02f, -2.09994838e-02f, -5.19828929e-04f, 4.10300083e-02f, -8.05365369e-02f, 8.04588646e-02f, 1.79083526e-01f, 1.30684543e-02f, -1.26442850e-01f, 9.15210769e-02f,
  9.21357945e-02f, 6.00272864e-02f, -2.22722050e-02f, 4.94772270e-02f, 7.54022673e-02f, -1.06867932e-01f, -4.13393509e-03f, -5.35311848e-02f, 8.92838091e-02f, 9.09773540e-03f,
  3.53353433e-02f, -2.65111297e-01f, -3.87457944e-02f, -3.10172122e-02f, 1.28968120e-01f, 9.27691013e-02f, 1.10558629e-01f, 2.70156432e-02f, -1.50645837e-01f, -6.17308281e-02f,
  5.98261766e-02f, 1.48215601e-02f, 1.86945759e-02f, 1.09215111e-01f, 6.54006377e-02f, -1.10267913e-02f, 2.83724628e-02f, 5.31832278e-02f, -6.71947151e-02f, 5.28527936e-03f,
  -3.76246050e-02f, -1.59202199e-02f, -2.13338807e-01f, -7.13397861e-02f, -1.32600725e-01f, -7.13319108e-02f, 1.19665548e-01f, -1.04029685e-01f, -1.47550963e-02f, -1.52633160e-01f,
  -2.27911144e-01f, 1.39757603e-01f, -3.10433686e-01f, -1.20211996e-01f, -3.65070730e-01f, -4.28596526e-01f, -9.94980112e-02f, -8.73886421e-02f, 2.60596443e-02f, 3.15480918e-01f,
  8.65417197e-02f, 1.17921960e-02f, 2.80350327e-01f, 3.86703722e-02f, -2.05839902e-01f, 3.40071708e-01f, -8.36712196e-02f, 1.32322237e-01f, -1.09857418e-01f, -1.52826786e-01f,
  -8.77401978e-02f, -4.93590981e-02f, -1.42170846e-01f, -1.07967243e-01f, -3.33163053e-01f, -1.44383013e-01f, -8.76402296e-03f, -2.25467667e-01f, -1.67206690e-01f, -2.05308735e-01f,
  -8.14844221e-02f, -6.37995899e-02f, 4.30763178e-02f, -3.13663557e-02f, -6.02592379e-02f, -3.73971127e-02f, -2.19299216e-02f, 6.97518978e-03f, -1.86217949e-02f, -5.33952601e-02f,
  1.22679047e-01f, -3.53452899e-02f, 8.16982836e-02f, -5.27873933e-02f, -8.42867345e-02f, -5.72689399e-02f, -9.54850242e-02f, -8.21443647e-02f, -5.54289110e-02f, -3.08803692e-02f,
  -6.05435334e-02f, -4.75751944e-02f, -7.41787106e-02f, 6.98007643e-02f, -1.09720320e-01f, -9.29404572e-02f, 5.11489548e-02f, -1.31039813e-01f, -1.27481371e-01f, -1.15359582e-01f,
  -3.51331457e-02f, 9.75472704e-02f, 3.54622230e-02f, 3.22628563e-04f, 6.91129826e-03f, -3.27082314e-02f, 6.27819672e-02f, 9.39609669e-03f, -7.01751411e-02f, -5.15646748e-02f,
  -6.90016896e-02f, -8.41066539e-02f, -8.50215480e-02f, -1.93442747e-01f, -3.49098351e-03f, 6.57381713e-02f, -1.81889068e-02f, -5.60219549e-02f, 2.81271264e-02f, -3.17385271e-02f,
  6.03046827e-02f, -2.57591018e-03f, 1.13798670e-01f, 2.28864029e-02f, 4.00117598e-02f, -1.06625274e-01f, -3.81839909e-02f, -6.73360452e-02f, 1.03341177e-01f, -1.28973633e-01f,
  -1.89223126e-01f, -2.58679539e-01f, 7.16886669e-02f, 2.78992336e-02f, -1.57883333e-03f, -8.63156691e-02f, -4.66962904e-02f, -3.43062216e-03f, -1.98017895e-01f, -6.19898252e-02f,
  -3.82807143e-02f, 1.00402504e-01f, -1.28770396e-01f, -5.69072887e-02f, 7.14303330e-02f, 2.95173861e-02f, 8.73001590e-02f, 2.60154065e-03f, -1.24149412e-01f, -1.35752074e-02f,
  -5.75642008e-03f, -3.63314673e-02f, 6.53109252e-02f, 5.33358268e-02f, 7.90876448e-02f, -6.49146661e-02f, -5.19948117e-02f, -1.64373089e-02f, -7.56412148e-02f, 5.25203235e-02f,
  -5.30895889e-01f, 3.09932560e-01f, -1.56871602e-01f, 8.04540068e-02f, 1.02050357e-01f, -3.69303286e-01f, -1.03643700e-01f, 1.63347885e-01f, -3.74004506e-02f, 3.32938880e-01f,
  3.45784962e-01f, -1.04743853e-01f, 3.42406332e-01f, 2.33005866e-01f, -3.68201792e-01f, -3.51265669e-02f, 4.20877337e-02f, -1.08969519e-02f, -1.27286568e-01f, 1.89830109e-01f,
  -6.94138259e-02f, 2.88764268e-01f, 1.60138577e-01f, 1.66676283e-01f, 3.58322822e-02f, -6.05777130e-02f, 3.23136091e-01f, 7.41885453e-02f, 1.85001820e-01f, -7.61676878e-02f,
  -6.61035255e-02f, 1.87176213e-01f, -4.15985659e-02f, -1.08393744e-01f, 2.17216928e-02f, 7.19226897e-02f, -3.58039252e-02f, -7.67666996e-02f, 6.82649901e-03f, 4.69259918e-02f,
  -2.46582255e-02f, -6.02924787e-02f, -7.89989680e-02f, 5.68052605e-02f, -9.16007981e-02f, -2.84295660e-02f, 3.31303058e-03f, -1.60678461e-01f, -2.79252268e-02f, -8.85025188e-02f,
  -7.13993981e-02f, -6.20309301e-02f, -4.90035340e-02f, -1.49392011e-02f, -1.76011443e-01f, -4.34036553e-02f, -1.63425624e-01f, 4.44022380e-02f, -1.63208079e-02f, -8.98051262e-02f,
  -6.92470819e-02f, 8.96786302e-02f, -3.27906162e-02f, -1.68672800e-02f, -3.49900611e-02f, -2.34326394e-03f, 1.47186229e-02f, -9.32766497e-02f, -1.34629741e-01f, 5.82510605e-02f,
  2.99750771e-02f, 4.45621461e-03f, 1.50412738e-01f, 2.74121780e-02f, -7.85381347e-02f, -1.14080571e-01f, -4.41472679e-02f, 1.68697178e-01f, -4.59825173e-02f, -6.22106232e-02f,
  6.14158586e-02f, -5.30074351e-02f, -4.22312692e-03f, 8.03746842e-03f, 8.34111720e-02f, 4.00965549e-02f, 1.46195054e-01f, 4.46890406e-02f, 7.96195045e-02f, 2.95385700e-02f,
  1.25994742e-01f, 1.94185421e-01f, 7.25354552e-02f, -3.92750837e-02f, 8.62088054e-02f, -4.28680405e-02f, -2.19557900e-02f, -9.59938467e-02f, -7.26044411e-03f, 2.27295533e-02f,
  3.28321457e-02f, -4.43531154e-03f, 2.95590088e-02f, -1.72380209e-02f, -1.65261887e-02f, 9.63809639e-02f, 1.78636402e-01f, -7.04878196e-02f, 4.59422804e-02f, -1.36112561e-04f,
  7.18391612e-02f, 2.50046700e-02f, -4.28861678e-02f, -1.03259213e-01f, -3.47251296e-02f, 1.02578126e-01f, -4.15615141e-02f, 3.05645671e-02f, -1.71477348e-02f, -7.25402460e-02f,
  1.74755782e-01f, 2.35599622e-01f, 2.86557198e-01f, 4.18044746e-01f, 1.37737200e-01f, -4.16540176e-01f, 5.92831336e-02f, 2.31040120e-01f, 3.91005605e-01f, -3.19585443e-01f,
  6.12348376e-04f, -6.34165481e-02f, -8.40129256e-02f, -6.54722080e-02f, -8.39401260e-02f, -9.42626968e-02f, 6.09974600e-02f, -6.12776577e-02f, 1.14928849e-01f, 4.65615243e-02f,
  1.56864762e-01f, -1.47066027e-01f, 1.21242702e-01f, -1.52188689e-01f, 6.92493021e-02f, 2.22079396e-01f, -3.05105355e-02f, 6.36423454e-02f, -1.42583355e-01f, -1.22511841e-01f,
  9.93146673e-02f, 1.64349750e-01f, 4.19018567e-02f, -3.08753438e-02f, 5.93167730e-02f, -2.15382561e-01f, -1.35244444e-01f, -2.26849671e-02f, 1.32339612e-01f, -6.07864633e-02f,
  -1.03037275e-01f, -1.79974556e-01f, 4.12180312e-02f, -1.85599610e-01f, 2.88472846e-02f, 4.56596166e-02f, 7.32256025e-02f, -1.48549238e-02f, 1.64363340e-01f, -1.21269651e-01f,
  6.06381195e-03f, 1.36110885e-02f, 9.80207622e-02f, -8.63685682e-02f, 6.49742261e-02f, 1.47229314e-01f, -1.08226523e-01f, -2.90572420e-02f, 2.11933535e-02f, 4.85568978e-02f,
  -1.83312595e-01f, 1.28544927e-01f, 6.84475079e-02f, 1.60545811e-01f, 1.47988290e-01f, 2.67920084e-02f, -2.12116446e-02f, -5.21466583e-02f, 1.37915477e-01f, 5.67173362e-02f,
  8.85886401e-02f, 1.11015394e-01f, 7.58374576e-03f, -7.92536810e-02f, 1.32596791e-01f, 3.76884639e-02f, -2.16908613e-03f, -1.53451949e-01f, -6.28036857e-02f, 1.21517859e-01f,
  3.30881551e-02f, 1.10588903e-02f, 1.33305684e-01f, -6.61571249e-02f, 9.45685133e-02f, 1.05252534e-01f, -2.26839006e-01f, -7.01919422e-02f, 1.59412771e-01f, 7.64515772e-02f,
  -6.28617173e-03f, 1.08153977e-01f, 1.19575530e-01f, -3.03960163e-02f, 9.43085775e-02f, -5.89112788e-02f, -8.89834762e-02f, -1.60934776e-02f, 1.76189169e-01f, -8.05626363e-02f,
  -1.05475336e-01f, 3.43541987e-02f, -1.01315379e-01f, -1.27535045e-01f, -4.78296801e-02f, 9.35433283e-02f, 7.95723498e-02f, 1.86322012e-03f, 1.46511257e-01f, -1.05047621e-01f,
  -7.32242242e-02f, -4.92474213e-02f, 6.22668341e-02f, 1.22132547e-01f, -8.28456059e-02f, 3.92751135e-02f, -7.60269091e-02f, 3.10748704e-02f, -1.13753381e-03f, -5.10889441e-02f,
  -1.81509256e-01f, 4.22389656e-01f, -1.42628834e-01f, -4.27658670e-02f, 1.29488841e-01f, 3.89783770e-01f, 2.14377344e-01f, 1.40445873e-01f, 2.98346430e-02f, 1.28555804e-01f,
  1.57644600e-02f, 1.10941045e-01f, -7.83026293e-02f, 1.00157276e-01f, -1.97110265e-01f, 6.23183511e-02f, 6.05063606e-03f, 9.98520479e-02f, 1.60636455e-01f, 6.18949234e-02f,
  -8.16128403e-02f, 7.66633376e-02f, -2.18046024e-01f, 1.16355799e-01f, 1.73757710e-02f, 1.66672710e-02f, -1.56960711e-01f, 2.27869544e-02f, -6.48330674e-02f, 1.82965711e-01f,
  4.64573279e-02f, 5.89972287e-02f, 2.65083946e-02f, -3.42524014e-02f, -2.81703696e-02f, 2.70132907e-02f, 8.25311169e-02f, 1.97719093e-02f, -1.53173238e-01f, -2.04012692e-02f,
  -9.66711789e-02f, 9.35162359e-04f, 4.74686772e-02f, -2.74797771e-02f, 1.60390362e-02f, 2.21098252e-02f, -4.31934111e-02f, -6.26441985e-02f, 9.50758904e-03f, 1.21719770e-01f,
  -7.96663240e-02f, -7.73934424e-02f, -9.05285776e-02f, -3.40335518e-02f, 4.17910442e-02f, 6.30658567e-02f, 1.48265287e-01f, -5.12611726e-03f, -5.52866943e-02f, 7.65865818e-02f,
  -1.11374356e-01f, 1.55328870e-01f, 1.24027595e-01f, -1.35870036e-02f, 6.26543760e-02f, 9.64919105e-02f, -4.17963378e-02f, 1.07078470e-01f, 8.67811441e-02f, 2.95726359e-02f,
  -5.57016879e-02f, 1.05817392e-01f, 5.72019406e-02f, -1.97657105e-02f, 8.50678608e-02f, -1.38790601e-05f, -6.67800978e-02f, 3.83711397e-03f, -7.97763169e-02f, -1.26501936e-02f,
  3.49198617e-02f, 2.85102781e-02f, -4.44691107e-02f, -2.88344864e-02f, 5.17760180e-02f, -6.92536831e-02f, 8.01083371e-02f, -9.13383588e-02f, 2.67623495e-02f, -1.91796981e-02f,
  1.40974686e-01f, 2.43708074e-01f, 3.41241732e-02f, 7.77773792e-03f, 1.50056742e-02f, 1.92397013e-02f, 6.04126416e-02f, 5.32144830e-02f, -3.42522375e-02f, 7.24228770e-02f,
  -4.98379730e-02f, 7.30362982e-02f, -2.97181271e-02f, -9.53302085e-02f, -1.06645949e-01f, 1.48201570e-01f, 3.01793450e-03f, -4.47589941e-02f, -1.29084170e-01f, 6.09014109e-02f,
  -4.39925604e-02f, -7.36437365e-02f, -1.10517368e-01f, 2.25567762e-02f, 1.29080340e-01f, -4.08218428e-02f, 2.05806315e-01f, -2.96077728e-02f, -5.05048633e-02f, -2.95348614e-02f,
  -4.52807665e-01f, 4.53282930e-02f, 2.72147119e-01f, -4.09837991e-01f, -3.01093012e-01f, 2.53731787e-01f, 1.95445687e-01f, -3.10655888e-02f, -2.30017081e-01f, 1.27025917e-01f,
  -5.02228960e-02f, -9.47817490e-02f, 3.77502114e-01f, -2.39398792e-01f, 3.36042583e-01f, 4.06494051e-01f, -4.82437946e-03f, 7.26981163e-02f, -1.77228794e-01f, -1.01883732e-01f,
  -1.80845931e-01f, -2.11861193e-01f, 9.09296721e-02f, -1.45314708e-01f, -2.00069860e-01f, -2.28631586e-01f, -1.25951201e-01f, -2.53558382e-02f, -3.15941870e-01f, -1.63350388e-01f,
  -2.40158007e-01f, -2.17719689e-01f, -3.71142104e-02f, 1.18710436e-01f, -1.03655085e-01f, 2.53487993e-02f, 9.21318978e-02f, 1.22031018e-01f, -1.15675092e-01f, -4.25653160e-02f,
  8.23007300e-02f, 1.20711595e-01f, -1.08091101e-01f, -2.37750579e-02f, -1.41122878e-01f, -7.78069869e-02f, -1.04200207e-02f, -3.64482496e-03f, -6.08449578e-02f, -2.34525825e-04f,
  2.25709565e-02f, -5.12254722e-02f, -1.09732620e-01f, -2.28054654e-02f, 1.10154636e-02f, -8.29355940e-02f, 5.22492379e-02f, -4.05514017e-02f, -1.40834391e-01f, -7.28490949e-02f,
  1.45842046e-01f, 2.13741548e-02f, 5.02182841e-02f, -5.09439185e-02f, 3.72639894e-02f, -1.02350011e-01f, -1.46522829e-02f, 2.94467155e-02f, 2.48645730e-02f, -3.61970030e-02f,
  -1.33333191e-01f, 1.11449985e-02f, -6.55560121e-02f, -6.68664947e-02f, 3.40700336e-02f, 9.74210426e-02f, 8.12909529e-02f, -1.43634230e-01f, 4.70633171e-02f, -5.19136526e-02f,
  1.84277259e-02f, 1.47820218e-02f, -7.82091469e-02f, 9.91371870e-02f, 7.14019984e-02f, -2.53443085e-02f, -1.17179923e-01f, -4.70990501e-02f, -4.99131456e-02f, 2.85738986e-02f,
  -2.80152977e-01f, -2.62535512e-01f, -9.97084528e-02f, 3.19432118e-03f, 1.24960253e-02f, 1.34101268e-02f, -2.26694979e-02f, -5.09584211e-02f, -1.05088197e-01f, 3.41478065e-02f,
  -1.39030525e-02f, 5.13979569e-02f, 9.25668355e-05f, 3.16549698e-03f, 1.23651437e-01f, 5.99755496e-02f, -1.46323480e-02f, -1.23901524e-01f, 5.51606948e-03f, -1.35287181e-01f,
  -1.33872246e-02f, 1.53675526e-02f, 1.73049122e-01f, -2.26395987e-02f, 9.46709663e-02f, -5.56820147e-02f, -8.24980736e-02f, 2.94840080e-03f, -1.68555267e-02f, 1.12882085e-01f,
  1.00504078e-01f, -4.15433109e-01f, -2.45020598e-01f, -2.27794588e-01f, -8.23646933e-02f, -3.60461883e-03f, -1.88584477e-01f, -1.43270791e-01f, -1.93810329e-01f, 5.88930622e-02f,
  -1.93794563e-01f, -9.51883867e-02f, 1.08891293e-01f, -3.95603091e-01f, -9.71763283e-02f, 9.69321933e-04f, -3.78358364e-02f, -7.52472952e-02f, -5.54913469e-02f, -1.24060679e-02f,
  -8.07809010e-02f, -8.80164877e-02f, -1.84356332e-01f, 8.31512138e-02f, -6.75063580e-02f, -5.49452603e-02f, 7.87021890e-02f, -2.35666946e-01f, -5.93213588e-02f, -1.81478813e-01f,
  -1.70331508e-01f, -7.31695145e-02f, -4.11556996e-02f, 1.71341977e-04f, 5.94048277e-02f, 9.26086754e-02f, 4.97164158e-03f, -8.54049101e-02f, -7.05195218e-02f, -4.20377180e-02f,
  1.16664231e-01f, 1.25928923e-01f, -9.57348198e-02f, -1.92954279e-02f, -8.20930228e-02f, -1.77934449e-02f, 1.97033049e-03f, -1.85966596e-03f, 1.38979675e-02f, -7.50962272e-03f,
  -7.69522190e-02f, -8.55350047e-02f, 9.09994170e-03f, 2.14549750e-02f, -5.52267171e-02f, 3.17603759e-02f, 6.21827804e-02f, -4.69296565e-03f, 3.62569536e-03f, 1.24193452e-01f,
  4.71230932e-02f, 6.40467107e-02f, 5.66521473e-02f, -1.36263207e-01f, -9.96961743e-02f, 3.62069532e-02f, 1.25516430e-02f, 1.77038182e-02f, -6.63019193e-04f, -3.96423005e-02f,
  8.55132267e-02f, -6.10734858e-02f, -4.94370721e-02f, -4.87811863e-03f, 1.50956035e-01f, -6.41794084e-03f, -5.50624095e-02f, 8.33589397e-03f, -2.57412195e-02f, 9.52694844e-03f,
  -4.25373018e-02f, -4.23741853e-03f, 2.84153726e-02f, 8.53731558e-02f, -7.88381994e-02f, 1.28967743e-02f, 1.14128597e-01f, 5.70263565e-02f, -1.14456713e-01f, 1.23257473e-01f,
  5.44801317e-02f, 1.79195270e-01f, -2.23471262e-02f, -3.88884023e-02f, 2.51910109e-02f, 1.15000919e-01f, -4.98294570e-02f, -4.65171821e-02f, 4.92488332e-02f, 6.59297928e-02f,
  5.61885722e-02f, 3.75997350e-02f, 1.47743061e-01f, -1.21695459e-01f, -7.42602795e-02f, 1.72936020e-03f, 2.33511657e-01f, 1.04976101e-02f, 6.49493113e-02f, 1.93094518e-02f,
  7.63678700e-02f, 5.65008745e-02f, 1.25081107e-01f, -1.05839185e-02f, 6.73765317e-02f, 1.18979923e-01f, 3.51060182e-02f, -1.01973340e-01f, 1.01013333e-01f, 2.42774468e-02f,
  4.07931171e-02f, -2.48695552e-01f, 1.12726517e-01f, 3.67021114e-01f, 3.16760466e-02f, -3.01868081e-01f, -1.99694917e-01f, 1.29443064e-01f, 1.96860000e-01f, -2.78485924e-01f,
  -6.00253195e-02f, -1.90825745e-01f, -2.49925703e-01f, 1.83337092e-01f, 1.81229368e-01f, -1.71956226e-01f, 1.87529534e-01f, -8.19683075e-02f, 9.71446484e-02f, 1.65163483e-02f,
  3.00651759e-01f, 1.88661709e-01f, 2.66156852e-01f, 9.77991894e-02f, 1.01287149e-01f, 2.10808590e-01f, 1.86358213e-01f, 3.49504650e-02f, 1.88263685e-01f, -9.89380926e-02f,
  -1.17321141e-01f, 7.49339536e-02f, 5.81090599e-02f, -5.08515127e-02f, 5.86056523e-02f, -4.75062542e-02f, -7.29629919e-02f, -1.56389430e-01f, 2.56753899e-03f, 3.88391577e-02f,
  -3.38864438e-02f, -9.53025278e-03f, 1.16601191e-01f, 5.70778623e-02f, -5.89540340e-02f, 2.34510247e-02f, 3.26101705e-02f, 1.30000515e-02f, -2.09003147e-02f, -1.63001604e-02f,
  -3.11349449e-03f, 7.59482756e-02f, 3.85290235e-02f, -2.90576015e-02f, 9.46167577e-03f, 4.78352280e-03f, 2.05847174e-02f, 5.94922267e-02f, 5.50181009e-02f, 1.50661319e-01f,
  -4.85165324e-03f, 6.95448816e-02f, -2.29257084e-02f, 3.34400050e-02f, 7.74041489e-02f, 1.16583019e-01f, -1.01122027e-02f, -5.30644655e-02f, -1.01508973e-02f, -2.54710931e-02f,
  6.84703887e-02f, -5.99379744e-03f, 5.28150834e-02f, 3.62038687e-02f, 5.32492585e-02f, 7.85304680e-02f, -4.79194745e-02f, 3.42599154e-02f, 3.55113819e-02f, 1.29449228e-02f,
  -3.69370356e-02f, -8.78148749e-02f, -2.53704060e-02f, -6.27782494e-02f, -1.61568746e-02f, -3.03737782e-02f, 9.02776569e-02f, 1.15096867e-02f, 3.86012569e-02f, 5.73583879e-02f,
  -1.99392512e-01f, 7.63228685e-02f, -2.31142435e-02f, -3.03494036e-02f, 3.91750084e-03f, -2.13176478e-02f, 2.48727575e-02f, -1.27923116e-02f, -1.11053459e-01f, 4.29156609e-02f,
  -1.77756567e-02f, -3.42346467e-02f, -1.24389812e-01f, -2.30988376e-02f, 1.50235677e-02f, -2.86872927e-02f, -1.50942279e-03f, 3.24554034e-02f, 6.91732094e-02f, 7.55186081e-02f,
  3.21821752e-03f, -9.29742604e-02f, 8.58095139e-02f, 1.29084855e-01f, -2.18743868e-02f, -5.15046343e-02f, -6.04204014e-02f, 5.23856767e-02f, 8.85942020e-03f, -3.57175656e-02f,
  -4.00120318e-01f, -9.69539657e-02f, -2.29707621e-02f, -4.86145876e-02f, 8.02480057e-02f, 1.33894742e-01f, -6.36620894e-02f, -1.69303745e-01f, -8.19008946e-02f, -1.56505808e-01f,
  -2.51192212e-01f, 7.24691199e-03f, -3.12314332e-01f, 1.97654948e-01f, 2.11481526e-01f, -6.22352445e-03f, 1.29335165e-01f, -4.04073633e-02f, 8.08124542e-02f, -7.09678531e-02f,
  6.38341233e-02f, 1.66526679e-02f, 6.73726797e-02f, 7.23297894e-02f, 2.72903731e-03f, 1.05587378e-01f, -8.18308592e-02f, 1.30837232e-01f, 2.24268422e-01f, 2.58362502e-01f,
  -5.58501445e-02f, -1.84686393e-01f, -7.14536533e-02f, -6.93959743e-02f, -1.05762385e-01f, -6.71028346e-02f, 1.39834071e-02f, -6.12989366e-02f, 1.02522552e-01f, 6.74138137e-05f,
  -1.35136157e-01f, 4.54853326e-02f, 4.96604927e-02f, 8.53038765e-03f, -5.79096330e-03f, 1.68355945e-02f, 1.06391720e-01f, -6.97252601e-02f, -7.11866245e-02f, -6.54709935e-02f,
  -2.53871772e-02f, -9.48152877e-03f, -9.98545215e-02f, 6.06197566e-02f, -2.42011175e-02f, 2.93224286e-02f, 2.37306282e-02f, -2.83838008e-02f, 1.04263559e-01f, 8.36839899e-02f,
  6.59711137e-02f, -1.01674117e-01f, -1.48664758e-01f, -1.09986460e-03f, 3.56199332e-02f, 1.37240896e-02f, 7.58338198e-02f, -3.40686217e-02f, 4.26050089e-02f, -8.82153362e-02f,
  1.11165028e-02f, 1.56148970e-02f, 6.88600242e-02f, 3.89593653e-02f, 5.83080798e-02f, -1.31697848e-01f, -4.84792553e-02f, 6.52847514e-02f, -1.69770494e-02f, -2.10850453e-03f,
  -2.40618754e-02f, 3.87386493e-02f, -2.53420640e-02f, 1.07999049e-01f, -1.32392244e-02f, 2.27181949e-02f, -7.79116526e-02f, 6.34495765e-02f, 6.03748369e-04f, -7.91635513e-02f,
  -1.73277944e-01f, -9.10404548e-02f, 1.97418761e-02f, -1.13129839e-01f, -4.67850640e-03f, -7.74673522e-02f, 6.82890937e-02f, 2.43994538e-02f, -1.37151387e-02f, 4.05911403e-03f,
  -9.97524932e-02f, -1.67545211e-02f, -8.45883861e-02f, 4.50772494e-02f, 2.09211465e-02f, -6.29672408e-02f, -5.22400439e-03f, -1.02602549e-01f, -5.56538254e-02f, -2.00046413e-02f,
  -9.79394764e-02f, -6.14962121e-03f, -6.23064395e-03f, 7.90134945e-05f, -4.77865711e-02f, -4.52958792e-02f, -1.30966976e-01f, 1.01038292e-01f, 8.09342638e-02f, 6.45876974e-02f,
  4.95944679e-01f, -3.51490736e-01f, -1.78729475e-01f, 2.82663256e-01f, 1.97366908e-01f, 3.21828127e-01f, 3.32701862e-01f, -4.16923724e-02f, 1.17193528e-01f, -1.65757850e-01f,
  1.54672697e-01f, -1.39130309e-01f, -2.56316543e-01f, 3.09368610e-01f, 4.21094626e-01f, -8.19520950e-02f, 2.96079785e-01f, 1.35676667e-01f, 7.42641613e-02f, -2.51064599e-02f,
  1.53919250e-01f, 2.79035747e-01f, -4.61999066e-02f, -1.39692649e-01f, 5.61509281e-02f, -2.43806437e-01f, -1.46207154e-01f, -1.33695200e-01f, 1.03302702e-01f, 1.23751417e-01f,
  1.37853131e-01f, 1.67999268e-02f, 1.67901523e-03f, -1.36653231e-02f, -2.55019888e-02f, 6.57966286e-02f, -1.35224303e-02f, -5.28620072e-02f, 1.52947143e-01f, -1.32149504e-02f,
  -5.92739061e-02f, 8.57221484e-02f, -5.90447262e-02f, -1.16906874e-02f, 1.78006619e-01f, 7.23957270e-02f, 1.03680668e-02f, 4.71248552e-02f, -4.84642871e-02f, -4.62272801e-02f,
  2.73846220e-02f, -7.05191705e-05f, 1.22657053e-01f, -1.03814937e-01f, 1.46374935e-02f, 3.75095122e-02f, -1.73920915e-02f, -1.06230460e-01f, -1.04812542e-02f, 1.22136809e-01f,
  -8.41493532e-02f, 2.37294892e-03f, -9.42390971e-03f, 3.80599909e-02f, 4.23369035e-02f, 1.44336990e-03f, 2.84469463e-02f, -4.60162982e-02f, 9.68672428e-03f, -1.83522701e-02f,
  1.35376588e-01f, 4.53848466e-02f, 3.15001383e-02f, 1.35041311e-01f, 8.43120590e-02f, -8.99179000e-03f, 1.13685355e-02f, -8.73998031e-02f, 4.75692637e-02f, -9.93719231e-03f,
  3.42645459e-02f, 1.11850239e-01f, -7.96591192e-02f, -4.47071716e-02f, 1.83837805e-02f, -4.72347364e-02f, -4.22889926e-03f, 3.76391187e-02f, -4.76385914e-02f, 8.89252797e-02f,
  -1.12744488e-01f, -3.34115863e-01f, -1.00689575e-01f, 2.36030556e-02f, -8.58238786e-02f, 4.83173840e-02f, -1.37145650e-02f, -8.39395374e-02f, 4.23148386e-02f, 8.11804757e-02f,
  -2.83557177e-02f, -3.98226567e-02f, -8.61351658e-03f, -3.89194340e-02f, 1.01560764e-01f, -4.97244857e-02f, 1.94989201e-02f, 1.75707676e-02f, -3.77870165e-02f, -1.26365408e-01f,
  -3.04750372e-02f, -4.32237126e-02f, -9.94118582e-03f, -1.06232828e-02f, 5.89645328e-03f, -5.86786009e-02f, -5.00975214e-02f, 1.86290611e-02f, -9.52800661e-02f, 5.47985472e-02f,
  -1.14253819e-01f, 1.89129829e-01f, -2.34926552e-01f, 5.28222844e-02f, -2.19785869e-02f, 4.21163768e-01f, 4.14963424e-01f, 4.14250717e-02f, 1.06357060e-01f, 4.27421749e-01f,
  1.49190158e-01f, 1.25498533e-01f, 1.49252549e-01f, 2.11700901e-01f, -1.32098109e-01f, 2.74476528e-01f, 2.00495049e-01f, 1.50606588e-01f, 9.73494425e-02f, 1.61303148e-01f,
  -7.08702356e-02f, 2.71296918e-01f, -1.15667187e-01f, 1.56401843e-01f, -1.04409922e-02f, -1.19071715e-01f, -1.05355471e-01f, -1.12679966e-01f, 2.96190623e-02f, 7.18649626e-02f,
  4.66871783e-02f, 1.30683873e-02f, -8.41290578e-02f, -5.51815778e-02f, -1.38831005e-01f, 6.57511652e-02f, 5.14447875e-02f, -1.19627371e-01f, -9.40913567e-04f, -1.53065883e-02f,
  3.07498276e-02f, 6.47592396e-02f, 2.68237498e-02f, 1.05205213e-03f, -1.30014867e-02f, 6.68586278e-03f, -3.48370448e-02f, -5.72239310e-02f, 5.58305606e-02f, 8.76684710e-02f,
  -1.28447443e-01f, -1.76715776e-01f, -4.12880294e-02f, -1.06552150e-02f, 2.43238267e-02f, 7.56537169e-02f, 1.09954998e-01f, -7.53300190e-02f, 2.82529444e-02f, 9.15864706e-02f,
  -2.61894148e-02f, 9.71393585e-02f, 6.60112351e-02f, -4.77163084e-02f, -5.88711165e-02f, -1.51373763e-02f, -1.23880315e-03f, 1.64694386e-03f, -1.63583849e-02f, 6.27601966e-02f,
  4.50931117e-03f, 3.82616334e-02f, 8.14661458e-02f, -1.20657659e-03f, 1.28697902e-01f, -4.72178459e-02f, -1.49110302e-01f, -7.10287131e-03f, -3.70415822e-02f, -4.14489396e-02f,
  2.27528568e-02f, 1.01412581e-02f, 4.30027097e-02f, 1.96093600e-02f, 3.88105437e-02f, -1.21250689e-01f, 6.39611706e-02f, 3.50831673e-02f, 4.08636481e-02f, 4.12549451e-02f,
  1.51289374e-01f, 1.82813078e-01f, -1.09570974e-03f, 2.76584625e-02f, -9.38786343e-02f, 6.50417283e-02f, 4.57093492e-02f, -8.75615776e-02f, 1.21364512e-01f, 1.30318001e-01f,
  -6.69491440e-02f, 5.20590767e-02f, 6.28287345e-03f, -7.19951764e-02f, -4.96577322e-02f, 1.39859080e-01f, 1.47119388e-01f, 1.56486791e-03f, -2.39567533e-02f, -4.06356789e-02f,
  -3.92668359e-02f, 4.17426452e-02f, -7.11143538e-02f, 4.55643870e-02f, 1.25782624e-01f, -1.63097903e-02f, 1.12027317e-01f, -3.47034112e-02f, -8.75531808e-02f, 2.35139132e-02f,
  -1.19434699e-01f, -2.85930812e-01f, 8.65379572e-02f, -2.07498726e-02f, -5.64399511e-02f, -1.38547607e-02f, 1.95768595e-01f, -3.49955052e-01f, -3.84335071e-01f, -2.91722268e-01f,
  -4.08325382e-02f, 2.00353324e-01f, 7.60302246e-02f, -1.28533676e-01f, 3.24662209e-01f, 4.97855358e-02f, -3.89026888e-02f, 1.07428364e-01f, -1.56982824e-01f, -8.28637183e-02f,
  -3.64951156e-02f, -3.18626054e-02f, 1.52998671e-01f, -1.41985893e-01f, -6.67051272e-03f, -2.19972208e-02f, 1.84395209e-01f, 1.38918400e-01f, -1.59479193e-02f, 1.88081026e-01f,
  -1.35499343e-01f, -2.38256454e-01f, -3.82252783e-02f, -9.84341875e-02f, -1.56524941e-01f, 1.03372894e-01f, 1.36081651e-01f, 2.12721094e-01f, 6.43904135e-02f, 4.14100476e-02f,
  1.61270350e-01f, 2.25981250e-02f, -3.98284346e-02f, 1.35235474e-01f, -1.14494309e-01f, -2.01552622e-02f, -9.51050371e-02f, -6.84848726e-02f, -1.03164718e-01f, 3.12169436e-02f,
  -1.97747219e-02f, -9.13419500e-02f, -7.58591965e-02f, 5.98015934e-02f, 2.22609974e-02f, -8.11427683e-02f, 1.14662632e-01f, 2.00284153e-01f, -6.23925254e-02f, 1.02919219e-02f,
  -4.25984478e-03f, 4.49213311e-02f, -1.79051384e-02f, -8.86492133e-02f, 4.51144390e-02f, 2.40606675e-03f, 5.82048669e-03f, 4.56889011e-02f, 9.49330349e-03f, -2.34803073e-02f,
  -3.92982960e-02f, 6.26704618e-02f, -8.44825357e-02f, -4.93223071e-02f, -3.54324505e-02f, -6.07104897e-02f, 1.62623227e-01f, 2.77960300e-02f, -2.00871043e-02f, -5.64786643e-02f,
  4.91090603e-02f, -4.35349420e-02f, -6.67897165e-02f, 5.61942272e-02f, 1.29778069e-02f, 3.07900645e-02f, -5.49126528e-02f, -8.31103846e-02f, -4.82894257e-02f, 8.03205296e-02f,
  -2.22361699e-01f, -2.11801857e-01f, -3.48981507e-02f, -3.80186886e-02f, -2.35216897e-02f, -2.82260915e-03f, -3.05829477e-02f, -4.15969314e-03f, -1.01008035e-01f, 7.48731988e-03f,
  -2.09378172e-02f, 3.87497135e-02f, -4.94227633e-02f, 7.10409954e-02f, 5.17910197e-02f, -1.53542375e-02f, -6.02985732e-02f, -4.58731651e-02f, 4.42367680e-02f, -8.39460194e-02f,
  1.89325735e-02f, 3.95445386e-03f, 6.20150901e-02f, -5.03851995e-02f, 2.31851153e-02f, -3.92778106e-02f, 6.85238764e-02f, 1.02156103e-02f, 1.27628773e-01f, -1.15274126e-02f,
  -4.25184846e-01f, 2.67990500e-01f, 5.39562762e-01f, -8.92438516e-02f, -3.97405535e-01f, 3.53146851e-01f, 2.42819577e-01f, 4.12721373e-02f, -5.52267507e-02f, 1.49380505e-01f,
  -2.70414352e-02f, 7.01284856e-02f, 1.42183408e-01f, -1.52214747e-02f, 2.28441447e-01f, 3.17364216e-01f, 1.05754852e-01f, 8.90558958e-02f, -6.04102500e-02f, -4.96981144e-02f,
  -6.39860928e-02f, -2.54757673e-01f, 8.86181146e-02f, -9.66778770e-02f, -6.88570812e-02f, -1.00053996e-01f, -2.38517776e-01f, 2.87372936e-02f, -1.13266170e-01f, -7.54525699e-03f,
  -6.19332753e-02f, -1.20689534e-01f, -4.92972322e-02f, 1.72798976e-01f, 4.30550892e-03f, 6.64494187e-02f, 4.77850512e-02f, -1.04499077e-02f, -5.63000403e-02f, 7.78725185e-03f,
  3.32264267e-02f, 4.03458811e-02f, -6.00445271e-02f, -3.06900609e-02f, -8.16517975e-03f, -2.64998549e-03f, 1.35022746e-02f, 1.06356367e-01f, 4.71360907e-02f, 1.27401069e-01f,
  1.93790477e-02f, 9.02935341e-02f, 6.33810237e-02f, 3.42622660e-02f, -7.16693923e-02f, 1.02881491e-01f, 9.92745757e-02f, -9.90074128e-02f, -4.00517657e-02f, 6.62567541e-02f,
  -3.25096995e-02f, -5.65720312e-02f, 5.91523014e-04f, -2.24522166e-02f, 1.72412619e-02f, -5.41927703e-02f, 2.40038428e-02f, -6.56045675e-02f, 2.31562052e-02f, -1.03028685e-01f,
  -1.32133424e-01f, -1.03047706e-01f, -6.47188500e-02f, -2.08221376e-02f, -1.31013002e-02f, 4.38116565e-02f, 8.91929120e-02f, -1.04451999e-01f, 8.30794945e-02f, 6.74754381e-02f,
  5.79348430e-02f, 7.87765160e-02f, -1.29146621e-01f, -6.74884841e-02f, 9.59194526e-02f, -2.44634598e-02f, 1.38945915e-02f, 4.21679392e-02f, -5.47597185e-02f, -7.71496892e-02f,
  -7.69893676e-02f, -1.12351276e-01f, -1.70221061e-01f, 5.59399612e-02f, -1.58073343e-02f, 9.14137438e-03f, -1.49509400e-01f, -7.28537068e-02f, 8.90355185e-02f, 8.71300290e-04f,
  3.98598872e-02f, 6.64150864e-02f, 5.86871877e-02f, -3.29169743e-02f, 6.77278489e-02f, 5.51034622e-02f, -1.22833624e-02f, 8.07922916e-04f, -9.63773299e-03f, -5.21101207e-02f,
  1.58949737e-02f, -8.91589746e-02f, 6.51067421e-02f, -6.21478185e-02f, -3.81719470e-02f, -3.01188827e-02f, -1.38466194e-01f, -3.99760194e-02f, 7.11820368e-03f, 1.81594402e-01f,
  -3.42275560e-01f, 2.23528460e-01f, -3.29060294e-02f, -2.87046194e-01f, -1.37334019e-01f, -8.94797966e-02f, -2.29461357e-01f, -8.87714140e-03f, -1.24138974e-01f, 8.31109062e-02f,
  -1.34078324e-01f, -5.46243712e-02f, 1.18538566e-01f, -1.35971591e-01f, 4.35979366e-02f, 2.42827430e-01f, -1.21003985e-01f, -5.07255793e-02f, 8.84622782e-02f, -1.79191127e-01f,
  -1.04021899e-01f, -2.19575644e-01f, -1.49104213e-02f, 1.37993880e-02f, -1.84544206e-01f, -1.55582219e-01f, 3.74553092e-02f, -5.86376972e-02f, -1.71623990e-01f, -5.15927561e-02f,
  -1.14492394e-01f, -1.82871610e-01f, -1.90430328e-01f, -5.33717684e-02f, -1.64787367e-01f, -7.40563422e-02f, -2.13982854e-02f, -1.67383403e-02f, -1.12539142e-01f, -7.23343249e-03f,
  -3.82524431e-02f, 8.02590847e-02f, -4.52355966e-02f, -2.44613364e-02f, -1.02777876e-01f, -3.29411067e-02f, 7.60659110e-03f, -1.42747024e-02f, -7.45554939e-02f, 3.77129205e-03f,
  -1.50400549e-01f, -4.32836115e-02f, -7.31296316e-02f, 2.42988739e-04f, -2.11533830e-02f, -1.11904666e-01f, -5.92225045e-03f, -7.28724524e-02f, -6.75425529e-02f, 1.10477693e-02f,
  1.65809803e-02f, 4.13710885e-02f, -7.72838891e-02f, -3.83898355e-02f, -1.71779990e-02f, -3.01947352e-02f, -3.08224205e-02f, -2.96976347e-03f, 1.99427269e-02f, -1.87961459e-02f,
  -7.09188953e-02f, -2.56142695e-03f, -1.96540076e-03f, -1.97480284e-02f, 1.55110266e-02f, -2.18245797e-02f, -5.16787954e-02f, -6.51624203e-02f, 5.43837100e-02f, 1.58190057e-02f,
  -5.31994924e-03f, -2.66290247e-03f, -7.35246912e-02f, 4.22975458e-02f, -6.00943295e-03f, -1.01886921e-01f, 3.77897434e-02f, -5.32104857e-02f, 7.78858876e-03f, -3.95297743e-02f,
  -1.37235254e-01f, -1.57437429e-01f, -1.81234345e-01f, -9.60853845e-02f, -8.68733898e-02f, 5.22717424e-02f, 9.44891386e-03f, -9.93807614e-03f, -4.48613055e-02f, 1.76601077e-03f,
  -5.79103418e-02f, -3.93986851e-02f, 5.10322154e-02f, -1.98952407e-02f, -2.37721261e-02f, -2.20193155e-03f, -1.55761376e-01f, 2.61807963e-02f, -1.08173974e-01f, -1.22080624e-01f,
  -1.14935860e-01f, -8.43933746e-02f, -2.64201183e-02f, -5.33926748e-02f, 2.87099276e-03f, -6.83358684e-02f, 4.25447784e-02f, -5.19507611e-03f, 1.83621086e-02f, 1.45152420e-01f,
  5.39114058e-01f, -5.57067096e-02f, 3.84430707e-01f, 4.66954499e-01f, -1.09190773e-02f, -2.69900173e-01f, 2.82955199e-01f, -1.33303180e-01f, -6.62930310e-02f, -3.92406166e-01f,
  6.15339875e-02f, 2.60638893e-01f, 1.39111131e-01f, -6.59556463e-02f, 3.34796607e-02f, -1.20976865e-01f, -1.24263540e-01f, 9.01395753e-02f, -6.77348152e-02f, 1.26271769e-01f,
  1.10073939e-01f, -2.83193231e-01f, 1.85763016e-01f, -4.03641760e-01f, 9.93213877e-02f, 5.23289144e-02f, -5.80350682e-02f, 1.27895232e-02f, -9.54570025e-02f, -5.05946465e-02f,
  -3.62707675e-02f, 1.41615257e-01f, 7.17117041e-02f, -9.30262953e-02f, -1.23286666e-02f, -2.93014739e-02f, 4.62902635e-02f, 4.15587276e-02f, 6.01815134e-02f, -2.39938442e-02f,
  5.51568419e-02f, -1.09955460e-01f, -8.37284327e-02f, -5.32130636e-02f, -8.35040677e-03f, 8.26738495e-03f, -3.87073383e-02f, 8.73144600e-04f, -9.75575880e-04f, 1.40646443e-01f,
  1.09985121e-01f, 4.22817133e-02f, 1.40062228e-01f, -1.12498812e-02f, 8.31684843e-02f, -5.45842163e-02f, -4.58449833e-02f, 1.18094876e-01f, -6.34785742e-02f, -8.04140791e-02f,
  -9.06365737e-02f, 3.50294597e-02f, 7.38971159e-02f, 6.62480295e-02f, 5.35985641e-02f, 7.78699964e-02f, -2.93590855e-02f, 2.82057524e-02f, -8.34758673e-03f, 8.28450173e-02f,
  1.07256174e-02f, 1.20456651e-01f, -7.47436732e-02f, -6.68099150e-03f, -1.72464661e-02f, 1.47692099e-01f, 8.30162391e-02f, -5.95746264e-02f, 6.83529377e-02f, 2.10570991e-02f,
  -1.69832055e-02f, -1.06358482e-02f, 3.83443907e-02f, -4.53806370e-02f, 1.84168946e-02f, 3.39818746e-02f, -5.01957089e-02f, 9.75292362e-03f, 1.12665281e-01f, 5.35672046e-02f,
  -1.67707920e-01f, -1.82573333e-01f, -6.18570410e-02f, -3.65748033e-02f, -6.14239424e-02f, -9.92164165e-02f, -5.03681004e-02f, -1.18280657e-01f, 9.14249942e-03f, -3.85907255e-02f,
  -7.75164440e-02f, 4.75593992e-02f, -1.11240491e-01f, -8.24702084e-02f, -8.88761505e-02f, -5.40959165e-02f, -3.16192545e-02f, -6.48893639e-02f, 7.23261014e-02f, -8.87448154e-03f,
  -1.62811056e-02f, 3.54275368e-02f, -2.02333611e-02f, -5.89840375e-02f, -2.52148956e-02f, 2.45148856e-02f, 5.94706386e-02f, -7.99046308e-02f, 1.30766043e-02f, -5.90353161e-02f,
  -2.04119921e-01f, 3.65770608e-01f, -3.40282470e-01f, -1.55149072e-01f, 3.57398093e-01f, 2.64929593e-01f, -1.32190166e-02f, 5.26531823e-02f, -2.88633257e-01f, 3.05471838e-01f,
  2.76684552e-01f, -2.48515233e-01f, -3.91983017e-02f, 1.51355311e-01f, -1.74306750e-01f, -1.60544347e-02f, 2.49116197e-02f, 1.87602192e-02f, -2.10132465e-01f, -8.45982730e-02f,
  -2.53745377e-01f, 2.93499351e-01f, -3.10770452e-01f, 1.75700247e-01f, 1.20099969e-01f, -2.56849736e-01f, 2.95315564e-01f, -1.90757558e-01f, 9.48873088e-02f, 3.43167447e-02f,
  8.44600946e-02f, -6.79649785e-02f, -2.09741071e-01f, -1.89088657e-01f, -8.83471444e-02f, -6.82705343e-02f, -1.59084544e-01f, -6.84537664e-02f, -1.93006366e-01f, -1.04474865e-01f,
  -9.86396987e-03f, -6.68077096e-02f, -1.35639057e-01f, -5.26131131e-02f, 9.06202346e-02f, 4.14750241e-02f, -3.87292542e-02f, 4.33693118e-02f, -1.46681756e-01f, 2.77650170e-02f,
  -9.01649520e-03f, 1.13652702e-02f, 1.37881041e-01f, -9.70616564e-03f, -3.53934616e-02f, 3.37827317e-02f, 7.96145201e-02f, -2.04852968e-02f, 8.79558772e-02f, 3.73310894e-02f,
  -1.06182520e-03f, 8.54976326e-02f, 4.64658178e-02f, 4.37620878e-02f, 8.39869678e-02f, 9.21718078e-04f, -2.53777229e-03f, 2.69578677e-02f, -8.19345489e-02f, 4.80316356e-02f,
  9.90631990e-03f, -7.26062581e-02f, -7.19875395e-02f, -6.80625960e-02f, 3.54901180e-02f, -3.86329405e-02f, 7.56692840e-03f, -7.08669573e-02f, -1.49299994e-01f, -6.75856620e-02f,
  -9.00961645e-03f, -9.85271763e-03f, -1.16673686e-01f, 4.14470397e-02f, 1.33371800e-01f, -6.83816150e-02f, 6.27196804e-02f, 1.78792328e-02f, 3.43125798e-02f, 8.84814411e-02f,
  1.57824948e-01f, 6.95915939e-03f, -1.71687871e-01f, -3.06002540e-03f, -1.23989932e-01f, 2.83358488e-02f, -1.30447268e-01f, -1.38492465e-01f, -7.90282935e-02f, -2.10973583e-02f,
  -4.04228941e-02f, 1.03394426e-02f, 5.31796180e-02f, -1.84249476e-01f, 5.15883639e-02f, 1.56781390e-01f, 6.14702119e-04f, -9.77988914e-02f, -1.17248863e-01f, 5.04945777e-02f,
  1.22380175e-01f, -2.30020024e-02f, -3.35860476e-02f, 2.81832758e-02f, 5.95654547e-02f, 9.00117159e-02f, 1.50119275e-01f, -2.51548085e-02f, 1.34683043e-01f, 4.46556062e-02f,
  3.12873662e-01f, 2.85322607e-01f, 3.01569670e-01f, 1.84955806e-01f, -1.53622618e-02f, -2.95574307e-01f, 6.89657331e-02f, 1.62214339e-01f, 2.45656684e-01f, 8.26726258e-02f,
  -1.41392663e-01f, 3.20618123e-01f, -1.00079097e-01f, -6.82517290e-02f, -4.57893014e-01f, -2.21968725e-01f, -2.56786108e-01f, 8.92373472e-02f, 6.83567226e-02f, -9.50032771e-02f,
  -5.19758388e-02f, -3.64323884e-01f, -2.94869803e-02f, -1.48024540e-02f, 9.32329446e-02f, 2.47907206e-01f, -1.75023809e-01f, 1.60978496e-01f, -3.67029533e-02f, -2.70997453e-02f,
  -6.23078225e-03f, 1.72733590e-01f, 1.15853690e-01f, -1.79568175e-02f, -1.73035532e-01f, -3.49149108e-02f, 7.04425424e-02f, 6.17261557e-03f, -2.38619931e-03f, 1.20064646e-01f,
  1.33261174e-01f, 3.78180146e-02f, 5.40823489e-03f, -2.13891063e-02f, 1.05111249e-01f, 1.10396229e-01f, 5.89086413e-02f, 5.71461730e-02f, 1.40388012e-01f, 1.61146507e-01f,
  7.65525773e-02f, 1.35090232e-01f, -1.11419884e-02f, 8.70592222e-02f, 1.45110935e-01f, 1.37220800e-01f, -2.12061629e-02f, 2.16098316e-02f, 6.65445775e-02f, 7.23152831e-02f,
  1.15254438e-02f, -1.14633135e-01f, -7.66256452e-02f, 5.80074191e-02f, 6.89455168e-03f, 6.69851303e-02f, 9.77069139e-02f, 1.27355918e-01f, 1.00322822e-02f, -9.08058230e-03f,
  -6.60459250e-02f, 7.32714310e-02f, -5.85033698e-03f, 5.68240993e-02f, 2.33091065e-03f, 7.89613053e-02f, 2.72646081e-02f, -1.07403941e-01f, -5.57842217e-02f, 1.48084550e-03f,
  -5.63467154e-04f, -4.16216813e-02f, -6.90030307e-02f, 5.61774522e-02f, -9.81634185e-02f, 1.41786942e-02f, -7.54632801e-02f, -7.15036271e-03f, 3.26063633e-02f, -7.07066283e-02f,
  -3.87856096e-01f, -3.67033005e-01f, -1.37783751e-01f, 9.34017450e-02f, -8.70185569e-02f, -1.09083235e-01f, 3.13891470e-02f, 5.11228703e-02f, -1.14465438e-01f, -1.80942249e-02f,
  3.15406621e-02f, 8.65115374e-02f, -9.46428925e-02f, 1.15933670e-02f, -1.29400402e-01f, -5.14580198e-02f, -5.81775941e-02f, -1.27463862e-01f, -6.08631894e-02f, -6.87172683e-03f,
  -2.42219307e-02f, 7.56264925e-02f, 6.59014890e-03f, 8.50368962e-02f, 5.54554686e-02f, 8.31307694e-02f, 3.46388072e-02f, 8.43546093e-02f, -1.19962115e-02f, -9.26054455e-03f,
  -3.92886519e-01f, 1.46935154e-02f, -3.20032775e-01f, -1.91057160e-01f, 1.44130424e-01f, -2.50266761e-01f, -1.29556477e-01f, 3.43091078e-02f, -9.64363199e-03f, 1.64827734e-01f,
  9.53892469e-02f, -2.77228177e-01f, 3.20451736e-01f, -3.69651884e-01f, -4.06791776e-01f, -2.02740058e-01f, -3.07378650e-01f, -1.85604438e-01f, -3.38064954e-02f, -1.65959492e-01f,
  -1.74005136e-01f, 1.98631361e-02f, -2.34553918e-01f, 2.20760226e-01f, -1.81469899e-02f, 7.35070780e-02f, 1.55961752e-01f, 1.06680796e-01f, -8.03064257e-02f, -1.00667857e-01f,
  5.32529317e-03f, 7.34647438e-02f, 1.34163275e-02f, -9.02250060e-04f, 8.19493271e-03f, 3.22457515e-02f, -1.27401620e-01f, -1.32419681e-03f, 1.50392726e-01f, 6.72276840e-02f,
  6.35279939e-02f, 1.20532408e-01f, -1.39509097e-01f, -1.76248997e-02f, 1.15644373e-01f, -5.48108900e-03f, 8.47926587e-02f, -1.18002798e-02f, 1.15233883e-01f, -2.91989058e-01f,
  -2.61122938e-02f, -4.92526963e-02f, 5.77006750e-02f, 5.14785424e-02f, -1.27420053e-02f, 4.80388030e-02f, -1.19110882e-01f, -5.64492196e-02f, 8.22928026e-02f, -9.29414630e-02f,
  -4.72702011e-02f, 2.16943547e-02f, 3.81485485e-02f, -3.11694317e-03f, 1.19141041e-04f, 1.74056867e-03f, 4.60186675e-02f, -3.59468088e-02f, -6.29962385e-02f, -1.69209689e-02f,
  8.83171558e-02f, -3.88866477e-02f, -4.59722430e-02f, -8.97095874e-02f, -3.23601365e-02f, -1.01831309e-01f, -4.40073423e-02f, 4.08516936e-02f, -3.58242355e-02f, -9.38956663e-02f,
  5.96609041e-02f, -4.55073826e-03f, 1.34253889e-01f, 3.16694342e-02f, -2.09445553e-03f, 1.01726569e-01f, 5.60871698e-02f, -1.15463644e-01f, -1.02218606e-01f, 8.01076815e-02f,
  4.03265090e-04f, 4.35577519e-02f, 9.46498439e-02f, 9.60567445e-02f, 4.82433513e-02f, -6.01306632e-02f, -1.48909569e-01f, -1.30201012e-01f, 7.00851008e-02f, -4.28668521e-02f,
  2.65758741e-03f, 1.00684136e-01f, 3.73937860e-02f, -8.26032907e-02f, 1.33626446e-01f, -1.30651012e-01f, 1.20311499e-01f, 1.30900770e-01f, 1.46485418e-01f, -5.82355969e-02f,
  1.49149626e-01f, 8.35338831e-02f, 1.32353991e-01f, 6.33892193e-02f, -1.94561351e-02f, 1.31495342e-01f, -7.24578276e-02f, 2.70344107e-03f, 3.31269391e-02f, 4.16187830e-02f,
  -5.21923721e-01f, 2.32347935e-01f, 3.79057914e-01f, -1.06418215e-01f, -1.77681282e-01f, 3.37498724e-01f, 8.49623755e-02f, -2.34479420e-02f, -4.93951775e-02f, 2.38536790e-01f,
  -8.78967419e-02f, -9.85946730e-02f, -3.11480649e-02f, 1.08089574e-01f, 1.21792229e-02f, 2.23455817e-01f, 2.18173221e-01f, 1.17907770e-01f, -1.46780228e-02f, -1.18783042e-01f,
  -1.56499714e-01f, -7.95259774e-02f, 1.45325601e-01f, -2.99205650e-02f, -4.34999121e-03f, -1.11159727e-01f, 2.99728964e-03f, -8.63410383e-02f, 8.65122229e-02f, 1.30228922e-02f,
  -1.37262464e-01f, -1.49711072e-01f, -1.33923799e-01f, -2.72931419e-02f, -2.93536782e-02f, -1.11296520e-01f, 2.98605468e-02f, 2.14548968e-02f, -1.11735381e-01f, -6.89552501e-02f,
  -7.92605430e-02f, 4.77580838e-02f, -9.50825512e-02f, -7.97697380e-02f, -2.26561762e-02f, 4.76875864e-02f, 1.04895733e-01f, -6.69198856e-03f, -2.13733632e-02f, 3.69792059e-02f,
  -4.74697426e-02f, 4.40434553e-02f, 7.63612688e-02f, 6.16077147e-02f, -4.57792208e-02f, -2.58756932e-02f, 9.88334119e-02f, 2.05075764e-03f, 1.09162614e-01f, 4.30043302e-02f,
  -1.59302447e-02f, 1.02169074e-01f, -9.68641788e-03f, 3.45635996e-03f, -1.22530935e-02f, 2.79036649e-02f, 5.91477305e-02f, -9.95740518e-02f, -1.09804496e-02f, -3.89986150e-02f,
  -8.22360069e-02f, -5.84468581e-02f, -6.77626655e-02f, 3.55326198e-02f, -1.36942528e-02f, -4.54467982e-02f, -1.43389061e-01f, -8.57820883e-02f, -7.14856782e-04f, 4.82488051e-03f,
  1.39935743e-02f, 1.55535536e-02f, -3.11432015e-02f, 6.00751583e-03f, -9.59258806e-03f, -3.71874608e-02f, -1.82293355e-02f, 5.02787419e-02f, 5.91485761e-03f, -1.97328795e-02f,
  -1.01423129e-01f, -1.06113859e-01f, -1.82430595e-01f, -1.04876548e-01f, -1.91899948e-02f, -5.68624511e-02f, -3.40712965e-02f, -6.21016137e-02f, 6.24840036e-02f, 2.14526337e-02f,
  -5.14184795e-02f, 6.76022172e-02f, -6.05069138e-02f, -7.53256604e-02f, -5.04499348e-03f, 2.61534732e-02f, -9.13633481e-02f, -1.09132700e-01f, 8.92705098e-03f, -1.47798419e-01f,
  -8.24367478e-02f, -3.69145237e-02f, 7.72606134e-02f, 8.04826543e-02f, -4.05145474e-02f, -6.34225756e-02f, -7.30972067e-02f, 1.37458090e-02f, 4.59452793e-02f, 1.79723755e-01f,
  -4.79851216e-02f, 1.30308658e-01f, 2.61667758e-01f, 2.47647062e-01f, -2.74963439e-01f, -2.13788927e-01f, -2.71090902e-02f, -9.43355262e-02f, 5.74554503e-02f, -6.01460375e-02f,
  -9.57179740e-02f, 1.09834976e-01f, -4.32145000e-02f, 7.04666749e-02f, 7.60467863e-03f, 2.46291216e-02f, 1.80521712e-01f, 6.22168146e-02f, 1.44418906e-02f, -4.68225628e-02f,
  4.04926874e-02f, -5.45674227e-02f, 6.01573363e-02f, -7.72185326e-02f, 1.36875033e-01f, 2.39558533e-01f, 5.65764308e-02f, 7.73618147e-02f, 2.10783437e-01f, -1.75892171e-02f,
  -5.52701801e-02f, 3.03779300e-02f, 4.03743386e-02f, 1.29050866e-01f, 5.59977219e-02f, -3.86790410e-02f, 1.25149250e-01f, 5.20418175e-02f, 7.78270513e-02f, 8.06626230e-02f,
  7.41706491e-02f, 4.70513292e-02f, 1.48174942e-01f, -9.85683575e-02f, -1.00353196e-01f, 3.70582528e-02f, 5.36493771e-02f, -7.26370290e-02f, 1.83738053e-01f, -5.47914132e-02f,
  -1.46702649e-02f, -2.15644091e-02f, 3.01535651e-02f, 2.49654517e-01f, 1.35473698e-01f, 2.63930038e-02f, 3.33426408e-02f, 9.28929895e-02f, 1.29900292e-01f, 6.92298487e-02f,
  3.59285474e-02f, 3.80142815e-02f, -4.78028618e-02f, -1.22029804e-01f, -8.73993188e-02f, 1.81662140e-03f, 9.89366136e-03f, -9.96207744e-02f, -1.25004686e-02f, 8.42498913e-02f,
  8.58464316e-02f, 4.09284830e-02f, -9.24075991e-02f, -4.28597666e-02f, 5.08026965e-03f, -6.81991354e-02f, -8.09225813e-02f, 1.09785751e-01f, 2.28352230e-02f, -6.50166199e-02f,
  -1.67189946e-03f, 5.22552431e-02f, 2.07191687e-02f, -1.21333757e-02f, -4.08547856e-02f, -3.39301974e-02f, 7.21322047e-03f, -2.09397208e-02f, -6.91662207e-02f, 6.04755692e-02f,
  1.93292111e-01f, 3.14815283e-01f, 4.46905345e-02f, 7.78694078e-02f, 7.93431513e-03f, -7.96623752e-02f, 3.50360163e-02f, 1.41443506e-01f, 2.00745389e-01f, 7.68667758e-02f,
  -4.75170091e-02f, 5.19263037e-02f, -5.09821735e-02f, -7.65562057e-02f, -2.57330090e-02f, 2.18499061e-02f, 1.15911648e-01f, 7.57821873e-02f, 1.94075108e-01f, -3.00215092e-03f,
  -9.14602205e-02f, -1.51639441e-02f, 1.19319692e-01f, 1.34002775e-01f, 8.81256387e-02f, 2.18422152e-02f, -1.37716651e-01f, 2.78933952e-03f, 1.55739322e-01f, 1.58023372e-01f,
  -2.04889968e-01f, 2.56982625e-01f, -4.20660861e-02f, -9.50808302e-02f, 1.43583104e-01f, -1.49864554e-01f, 5.66051118e-02f, 2.33086944e-01f, 3.14334393e-01f, 6.95486069e-02f,
  6.14441633e-02f, 1.17462263e-01f, 2.20464617e-01f, 3.16366665e-02f, -2.33132973e-01f, 2.18159128e-02f, -2.65171856e-01f, -4.90190648e-02f, 8.63154978e-02f, 7.95781761e-02f,
  6.17038906e-02f, 1.41010925e-01f, -2.04750106e-01f, 8.16375762e-02f, -8.11012462e-02f, 9.46944673e-03f, -2.22659051e-01f, 2.53284752e-01f, -2.55116612e-01f, 9.60459113e-02f,
  -1.32505342e-01f, 2.06882820e-01f, -6.72844201e-02f, 3.64233064e-03f, -1.99266359e-01f, -4.76676635e-02f, -1.24588639e-01f, 1.12872474e-01f, 1.28443554e-01f, -2.53019333e-02f,
  8.27178434e-02f, 1.68933638e-03f, 5.05017117e-02f, 7.84436166e-02f, 1.29426226e-01f, -1.30718965e-02f, -6.43044710e-02f, -1.27171636e-01f, 9.31418389e-02f, -5.36053814e-02f,
  -3.63280177e-02f, -3.95605480e-03f, 1.94708463e-02f, 3.02935615e-02f, -6.56170696e-02f, -2.47957688e-02f, -1.41881838e-01f, -6.15334511e-02f, -4.69847135e-02f, -3.38205360e-02f,
  1.65493816e-01f, 7.25604687e-03f, -3.05265561e-02f, -1.37005802e-02f, 6.16943613e-02f, 5.14468811e-02f, 6.14772514e-02f, -4.29964885e-02f, -3.16783972e-02f, -4.07368736e-03f,
  -4.04748954e-02f, -1.10941879e-01f, -1.51396906e-02f, -4.93526198e-02f, 3.95503603e-02f, 3.77199426e-02f, 5.30220047e-02f, 4.20641042e-02f, -6.16741478e-02f, -9.34878513e-02f,
  1.32198229e-01f, 1.26382969e-02f, 3.08723804e-02f, -4.57346737e-02f, -3.50940600e-02f, -2.78471373e-02f, -4.61517535e-02f, -2.73408485e-03f, 9.15827677e-02f, 3.94574553e-02f,
  -1.06992364e-01f, 1.66421518e-01f, 2.50250921e-02f, 7.43945539e-02f, 2.62537831e-03f, -1.03020974e-01f, -5.21370303e-03f, -1.15590945e-01f, 3.28946821e-02f, 2.61631384e-02f,
  1.02938384e-05f, -7.24510849e-02f, -1.44485861e-01f, -3.36530432e-03f, 1.30790146e-02f, -9.91653800e-02f, 5.51336620e-04f, -1.08379554e-02f, -1.89153180e-02f, -1.91530418e-02f,
  4.62880917e-02f, 6.31999224e-02f, 1.45697325e-01f, -2.40133852e-02f, -1.95005275e-02f, -8.53576660e-02f, 3.97838699e-03f, 9.72612947e-02f, 4.13773321e-02f, -1.56197022e-03f,
  2.65303344e-01f, -1.72487184e-01f, 1.75148994e-01f, 1.66805759e-01f, 1.56733721e-01f, 1.27048105e-01f, 2.29634121e-01f, 5.68223111e-02f, 3.71689111e-01f, -3.12869549e-01f,
  -2.58354992e-01f, -9.02265534e-02f, 9.45143998e-02f, -1.65511474e-01f, 2.39322245e-01f, 1.83563933e-01f, 8.23031440e-02f, 4.14769314e-02f, 1.69664830e-01f, -7.85417035e-02f,
  2.07303818e-02f, -1.94801554e-01f, -1.41530588e-01f, -3.33580315e-01f, -1.67362019e-01f, -9.93960798e-02f, -2.44010538e-01f, 6.57812506e-02f, -3.07695955e-01f, 4.25008908e-02f,
  1.28080789e-02f, -3.26533616e-02f, -1.04215972e-01f, -4.64355610e-02f, -1.88500378e-02f, -5.60618266e-02f, 3.55604384e-03f, 8.16307589e-02f, 9.93052050e-02f, 3.40137705e-02f,
  4.88824770e-02f, -5.97731210e-03f, -1.27529502e-01f, -1.81037076e-02f, 8.33206922e-02f, 2.38690816e-04f, -2.22013425e-02f, -1.23801284e-01f, -7.72241428e-02f, 8.14271271e-02f,
  1.11757098e-02f, 1.79722495e-02f, 9.91113931e-02f, 1.39689883e-02f, -1.44434022e-02f, 4.50424552e-02f, 1.43870920e-01f, 5.23957647e-02f, 5.85960075e-02f, 7.65783489e-02f,
  -5.97366393e-02f, 8.66643265e-02f, -1.11900801e-02f, 5.39385006e-02f, 7.63117000e-02f, 8.35111272e-03f, 6.36829436e-02f, 2.94109378e-02f, 1.19303212e-01f, 2.56424230e-02f,
  -4.59897742e-02f, -5.56268170e-02f, 4.77453843e-02f, 5.43983169e-02f, 2.23729666e-03f, -6.80576786e-02f, -8.22652318e-03f, 5.14781997e-02f, -4.22584917e-03f, -7.69042149e-02f,
  -9.06253457e-02f, 8.27251822e-02f, -4.49648779e-03f, -1.64953433e-02f, 1.69744454e-02f, 7.47652724e-03f, -6.82933331e-02f, 8.32545608e-02f, 7.15260431e-02f, -7.31734186e-03f,
  6.49120361e-02f, 1.21700028e-02f, -8.90197903e-02f, -5.63631617e-02f, -1.43743725e-02f, -1.34506360e-01f, 2.40235999e-02f, -2.84521338e-02f, 9.84107479e-02f, -1.22323325e-02f,
  -1.98916793e-01f, 4.34741825e-02f, -8.77799690e-02f, -6.01816475e-02f, 3.69117642e-03f, -3.85542139e-02f, 4.15320620e-02f, -6.99300915e-02f, -6.78531379e-02f, -7.82261938e-02f,
  -7.34702349e-02f, -7.46435532e-03f, 2.39069536e-02f, -5.59919551e-02f, -5.76048344e-02f, -4.56075221e-02f, 6.19215425e-03f, 2.11859364e-02f, 1.32313326e-01f, 1.31051347e-01f,
  1.30077809e-01f, -4.01621073e-01f, 3.83323818e-01f, -7.44048059e-02f, 2.25896120e-01f, 8.32273588e-02f, 1.78928301e-01f, -1.02750860e-01f, -1.43610328e-01f, -3.37116480e-01f,
  7.47159030e-03f, 3.96564528e-02f, 1.30235448e-01f, -2.20036611e-01f, 2.82807410e-01f, 2.51492616e-02f, -8.04944411e-02f, -4.20124941e-02f, -3.71046760e-03f, -6.36221170e-02f,
  -6.36461899e-02f, -2.59143054e-01f, 6.01121821e-02f, -1.90333635e-01f, 1.15179583e-01f, -1.52743936e-01f, 7.59919314e-03f, 1.64365947e-01f, -1.09350637e-01f, 9.49750245e-02f,
  -9.71892998e-02f, -1.75186530e-01f, -3.17734480e-02f, -6.76618293e-02f, -2.52659917e-02f, 2.96040513e-02f, 8.38184878e-02f, 1.00551665e-01f, -6.85610995e-02f, -7.41084516e-02f,
  4.03771847e-02f, 4.18136045e-02f, -1.30262272e-02f, -8.52674097e-02f, -1.19702041e-01f, -1.22784227e-01f, -4.39411588e-03f, -2.36056410e-02f, -7.06820376e-03f, 2.02896386e-01f,
  2.80182306e-02f, 4.86988090e-02f, 1.79429725e-01f, 4.90569621e-02f, 2.18326822e-02f, -4.95378971e-02f, 4.55227569e-02f, 3.13447379e-02f, -1.36799499e-01f, -3.31226289e-02f,
  7.13125989e-02f, 1.61071599e-01f, -3.66698601e-03f, -5.06964996e-02f, -6.80077821e-02f, -1.82061736e-03f, -3.57114524e-02f, -9.63286683e-03f, 7.21705481e-02f, -4.21023555e-02f,
  4.10763361e-02f, 2.72129662e-02f, 7.34552322e-03f, -4.65258881e-02f, -7.84463137e-02f, 4.84887287e-02f, 3.92606631e-02f, -3.48507799e-02f, 1.00990221e-01f, -4.53133741e-03f,
  2.21491829e-02f, 9.73049644e-03f, -1.75655019e-02f, 3.33582051e-02f, 2.54439786e-02f, 5.22417426e-02f, -4.27371860e-02f, -5.28457854e-03f, -8.38962495e-02f, 1.24874622e-01f,
  -3.55837971e-01f, -4.52829033e-01f, -1.29580781e-01f, -1.25911355e-01f, -1.33752763e-01f, -1.00529172e-01f, -9.43313688e-02f, -1.18255354e-01f, -5.56906760e-02f, 1.72730722e-03f,
  -9.43359882e-02f, 5.94062209e-02f, -6.97226524e-02f, -1.20532319e-01f, -1.06345616e-01f, -8.39543715e-02f, -2.61100866e-02f, -6.88699707e-02f, -5.07743880e-02f, -1.14285886e-01f,
  -5.58573343e-02f, -2.16739774e-02f, 1.53958201e-01f, -7.53415190e-03f, -4.27608341e-02f, 1.64447501e-02f, -9.50780511e-02f, 3.25364210e-02f, -1.75690523e-03f, -3.72805558e-02f,
  3.93561393e-01f, -1.95960924e-01f, -1.24039173e-01f, 2.78968722e-01f, 2.79552966e-01f, -8.76048952e-02f, -1.66022241e-01f, 1.58131793e-01f, 1.28377050e-01f, -1.95303857e-01f,
  1.27090931e-01f, -1.11221462e-01f, -3.90696526e-01f, 4.74625736e-01f, 3.78751546e-01f, -3.00190002e-01f, 3.40745568e-01f, 8.62100720e-02f, -2.68844869e-02f, 2.58494288e-01f,
  2.16884062e-01f, 4.18374985e-01f, 7.65674487e-02f, 1.80190653e-01f, 1.63659006e-01f, -8.42875838e-02f, 7.90532380e-02f, -2.83903182e-01f, 2.41456985e-01f, 5.63189909e-02f,
  5.43096997e-02f, 1.00139163e-01f, 3.22192758e-02f, -7.48061761e-02f, 5.04357517e-02f, 1.39689427e-02f, -7.78981894e-02f, -9.08959806e-02f, -3.78114358e-02f, -1.01375259e-01f,
  -6.97714165e-02f, 2.33844370e-02f, 7.24879876e-02f, 1.10722156e-02f, 4.77567725e-02f, 5.50239682e-02f, 5.80547377e-02f, -6.44929111e-02f, 9.13562439e-03f, 6.90318868e-02f,
  6.93744002e-03f, 1.45643456e-02f, 5.12211397e-02f, 3.49048115e-02f, -1.41707724e-02f, -4.36654426e-02f, -2.85307840e-02f, -1.16861239e-01f, -6.50230050e-02f, 1.07349388e-01f,
  8.41907263e-02f, -1.59786761e-01f, -7.92955384e-02f, -6.80122450e-02f, -8.11474025e-02f, 4.85933051e-02f, -2.44300924e-02f, -7.20301792e-02f, -5.34256995e-02f, -1.43145155e-02f,
  -8.89770628e-04f, -2.70991828e-02f, 4.98951785e-02f, 1.22728441e-02f, 1.09547991e-02f, 1.22569829e-01f, -2.80934479e-02f, 2.53321100e-02f, 4.67054918e-02f, -1.22197708e-02f,
  -5.86079732e-02f, 1.24984995e-01f, -3.29888873e-02f, -2.95226164e-02f, -4.48216312e-02f, -7.15690926e-02f, -2.08942145e-02f, 6.30583167e-02f, 3.52835841e-02f, 7.27620125e-02f,
  -9.32907835e-02f, 3.77099849e-02f, -8.96704122e-02f, 1.32508883e-02f, -6.91390187e-02f, 9.44629386e-02f, 7.19896406e-02f, 1.00929968e-01f, -4.23315316e-02f, 1.04291020e-02f,
  3.71885635e-02f, -6.68471530e-02f, -7.56944641e-02f, 1.40776783e-01f, -2.60231718e-02f, 6.55510351e-02f, -6.27351701e-02f, -7.41211101e-02f, 6.10601269e-02f, 8.15057941e-03f,
  -5.53676300e-02f, 2.20548101e-02f, -1.15449086e-01f, 6.04893677e-02f, 7.42513239e-02f, -1.00842327e-01f, -1.46048358e-02f, -1.02985874e-02f, 1.78682990e-02f, 6.60537183e-02f,
  4.88066256e-01f, -3.93849134e-01f, -3.65606189e-01f, 1.94989637e-01f, 2.18146876e-01f, 3.26310694e-01f, 3.32060874e-01f, 6.51529953e-02f, 7.30709806e-02f, -7.54848635e-03f,
  2.14217559e-01f, -1.22467197e-01f, -1.46954119e-01f, 2.66282111e-01f, 3.74708712e-01f, 3.47005725e-02f, 2.74654895e-01f, 1.69144437e-01f, -1.21847424e-03f, 1.14441521e-01f,
  1.24427073e-01f, 2.85229832e-01f, -5.00185713e-02f, -8.12837556e-02f, 1.70506343e-01f, -2.51132905e-01f, -4.07436490e-02f, -1.74035683e-01f, 3.58996503e-02f, 1.07910335e-01f,
  6.03239462e-02f, 5.45434766e-02f, 4.29556072e-02f, -8.90734699e-03f, -2.14316361e-02f, -2.05786265e-02f, -6.38556927e-02f, 8.10888945e-04f, 1.19111724e-01f, 7.80806169e-02f,
  -1.94399350e-03f, 1.08610980e-01f, -4.59887274e-02f, -2.63709892e-02f, 9.52926874e-02f, 1.10324256e-01f, 4.97277416e-02f, 3.97495329e-02f, -2.01474242e-02f, -1.68286562e-02f,
  -1.33282058e-02f, -2.99692359e-02f, 2.63767242e-02f, -1.01723276e-01f, 2.92716380e-02f, 3.59830037e-02f, -6.57649338e-02f, -8.38980898e-02f, 1.67171396e-02f, 1.14173867e-01f,
  2.35859975e-02f, -8.37009400e-02f, 2.56348178e-02f, 2.48776004e-02f, -4.01306227e-02f, 2.28531733e-02f, 4.60088216e-02f, -3.78784463e-02f, -2.00445130e-02f, 1.98231898e-02f,
  9.92577970e-02f, 6.87167943e-02f, 5.31074218e-02f, 1.19583808e-01f, 9.50671956e-02f, -6.06561266e-02f, -1.15135247e-02f, 1.68870650e-02f, 7.37478659e-02f, 8.52151439e-02f,
  -2.61035021e-02f, 3.20728570e-02f, -2.24592779e-02f, -3.41822691e-02f, 1.33891648e-04f, -6.27813069e-03f, -4.39030863e-02f, 6.81041777e-02f, -3.72546427e-02f, 6.29633591e-02f,
  -3.55572104e-02f, -2.87610084e-01f, -2.30926294e-02f, -2.78887600e-02f, -1.18703172e-01f, 1.24710605e-01f, -1.56245939e-02f, 4.24998328e-02f, 9.16967988e-02f, 1.05261207e-01f,
  8.35274830e-02f, 1.78684737e-03f, -4.12832759e-02f, 4.60154340e-02f, -4.43179384e-02f, 7.21759871e-02f, -2.49856454e-03f, 4.59666252e-02f, 5.96316531e-02f, -1.03872105e-01f,
  -3.57252583e-02f, 5.39095774e-02f, 1.85592547e-02f, 3.67738195e-02f, 3.28616872e-02f, -1.13667436e-01f, -5.53021990e-02f, -5.49153835e-02f, -2.22558472e-02f, 5.61106652e-02f,
  -2.01958403e-01f, 1.42893746e-01f, -1.21359527e-01f, 2.38926098e-01f, -2.58321971e-01f, 2.79089332e-01f, 3.88462484e-01f, 1.71608664e-02f, 2.37046197e-01f, 3.77638787e-01f,
  1.20495856e-01f, 4.45182845e-02f, 1.23968318e-01f, 2.78592914e-01f, 2.42055040e-02f, 3.16332817e-01f, 3.79424542e-01f, 2.37993181e-01f, 7.68690258e-02f, 8.78796130e-02f,
  5.85861802e-02f, 1.96400553e-01f, -5.09731956e-02f, -6.90292194e-02f, -5.70372902e-02f, -1.51991233e-01f, -2.06270114e-01f, -2.11287528e-01f, 1.62870474e-02f, -8.15009922e-02f,
  2.69757565e-02f, 4.23329882e-03f, -9.29540098e-02f, -1.01276869e-02f, -5.47373947e-03f, 2.91233901e-02f, 3.78705673e-02f, -1.10716544e-01f, 4.81157005e-02f, 3.42937522e-02f,
  5.93226068e-02f, -3.95556586e-03f, 8.24889392e-02f, -8.17817524e-02f, -9.52461660e-02f, -4.06747162e-02f, -3.66985542e-03f, -4.79522906e-02f, 3.00781485e-02f, -2.70619476e-03f,
  -6.54201433e-02f, -7.74600282e-02f, -3.76006737e-02f, 5.89682534e-02f, -3.98586467e-02f, 2.13594548e-02f, 8.18069130e-02f, -7.92911351e-02f, 2.75449362e-03f, 3.32397148e-02f,
  -1.88535210e-02f, 1.45737171e-01f, 3.46999206e-02f, -4.24396954e-02f, -5.60671948e-02f, -3.20389830e-02f, 2.81246062e-02f, 2.86742719e-03f, -5.75799309e-03f, 2.18216833e-02f,
  4.64507602e-02f, 3.69309299e-02f, 1.44931599e-02f, -2.99015976e-02f, 1.36271387e-01f, -5.85569665e-02f, -9.09017846e-02f, 7.50265492e-04f, 4.92872037e-02f, 2.18840595e-02f,
  2.87277568e-02f, 7.74004823e-03f, -3.82305756e-02f, 1.51969073e-02f, 6.26445562e-02f, -7.62968734e-02f, 5.88127635e-02f, 2.11995579e-02f, -3.85864489e-02f, 3.02229114e-02f,
  2.24053472e-01f, 2.95876235e-01f, 6.79435804e-02f, -3.35938355e-04f, 3.04436479e-02f, -8.47795326e-03f, 3.55871804e-02f, -1.49260778e-02f, 1.28068969e-01f, 3.92499231e-02f,
  -1.06650097e-02f, 2.84730215e-02f, -2.44164765e-02f, -1.76530957e-01f, -1.02869812e-02f, 9.44077969e-02f, 1.76074818e-01f, 5.11937588e-02f, 5.56620471e-02f, -6.37733713e-02f,
  -2.60745678e-02f, 4.82885167e-02f, 5.84563240e-02f, 6.40831143e-02f, 1.15778834e-01f, -2.13623066e-02f, -2.92804874e-02f, -4.51612510e-02f, 3.39338332e-02f, 1.00434817e-01f,
  1.30478635e-01f, -1.38069123e-01f, 6.31018877e-02f, -2.27601737e-01f, -5.16421720e-02f, -3.29482593e-02f, 4.65268642e-03f, -2.44211584e-01f, -3.30373436e-01f, -2.40434334e-01f,
  -1.16313718e-01f, 2.00739410e-02f, 3.26971173e-01f, -7.83358067e-02f, 2.41796210e-01f, 3.36172789e-01f, -1.83493301e-01f, -1.65478513e-01f, 8.25246647e-02f, 1.79777518e-01f,
  6.04808107e-02f, 7.46157691e-02f, 3.50824833e-01f, -1.24058919e-02f, 1.63723435e-02f, -1.01046570e-01f, 7.44995475e-02f, 1.39168337e-01f, -2.16611013e-01f, 4.13613766e-03f,
  1.46303669e-01f, 6.49512336e-02f, 1.12614363e-01f, 1.99935935e-03f, 9.04235318e-02f, 5.71376570e-02f, 1.13490671e-01f, 6.32407665e-02f, -1.44558713e-01f, 1.09032542e-02f,
  -8.85728281e-03f, -6.05065003e-02f, -7.84297064e-02f, 1.97886288e-01f, -2.06021607e-01f, -1.54484674e-01f, -5.58536835e-02f, 2.81150918e-02f, -3.91695797e-02f, 9.74701792e-02f,
  2.90639568e-02f, -4.76240367e-02f, -6.59571961e-02f, -1.68469008e-02f, -1.48117483e-01f, -1.14536494e-01f, 1.57380536e-01f, 8.31127167e-02f, -1.06917016e-01f, -1.05003558e-01f,
  4.15739827e-02f, 8.22774395e-02f, 5.07689975e-02f, -3.40605341e-02f, 4.06602360e-02f, -1.97011922e-02f, -6.22304529e-02f, 5.70756979e-02f, -3.21990848e-02f, 3.64336558e-02f,
  -1.40061840e-01f, -1.15571961e-01f, 1.07111633e-01f, -1.18134301e-02f, -5.74114285e-02f, 1.14454404e-01f, 1.28896713e-01f, 7.87121877e-02f, -1.14154592e-01f, -6.88090324e-02f,
  -3.54476832e-02f, -7.29676783e-02f, -5.54115660e-02f, 9.13255811e-02f, 4.24846299e-02f, 4.01253030e-02f, 1.03471456e-02f, 9.82419476e-02f, 1.22123055e-01f, -3.20364721e-02f,
  3.32372412e-02f, -8.11906345e-03f, 1.97205506e-02f, -1.20074950e-01f, 1.13393351e-01f, 7.43984431e-02f, 3.95283587e-02f, -1.67799219e-01f, -1.40533268e-01f, 3.24626639e-02f,
  -1.15083158e-01f, -1.85210481e-02f, -2.40627117e-02f, 9.63656530e-02f, -2.10114017e-01f, -7.56722093e-02f, 4.32565436e-02f, -3.42757329e-02f, 1.95694882e-02f, -1.09084509e-01f,
  -3.57499607e-02f, -5.87918311e-02f, -6.91990405e-02f, -1.51483379e-02f, -1.33643731e-01f, -7.85211399e-02f, 5.88946156e-02f, -6.85858503e-02f, -9.57006216e-02f, -1.88190252e-01f,
  2.31684372e-01f, -2.29210988e-01f, 2.53419895e-02f, 2.49757379e-01f, 9.84622911e-02f, -2.78104454e-01f, -2.53586411e-01f, 1.33256361e-01f, 1.59290388e-01f, -2.35987768e-01f,
  6.78456761e-03f, -2.14879513e-01f, -1.86002091e-01f, 1.31835088e-01f, 1.38616085e-01f, -2.26490647e-01f, 1.44343659e-01f, 2.02836771e-03f, 3.61716039e-02f, -7.31038116e-03f,
  1.93478420e-01f, 2.03655913e-01f, 6.55716732e-02f, 3.33369188e-02f, 8.14514756e-02f, 6.54126406e-02f, 1.43605694e-01f, -1.69952959e-01f, 1.76531434e-01f, -6.84963986e-02f,
  3.08817513e-02f, 1.60674870e-01f, 4.09086198e-02f, 1.78251509e-02f, 1.55598000e-01f, 5.52584529e-02f, -8.84366110e-02f, -1.55645739e-02f, -3.96980383e-02f, -7.79376039e-03f,
  2.10629310e-02f, 7.03834072e-02f, 4.47652079e-02f, 2.19663959e-02f, 8.21432695e-02f, 1.16041131e-01f, 1.36955127e-01f, -5.69955818e-02f, 1.96979549e-02f, 3.12213995e-03f,
  8.88202339e-03f, 5.79736643e-02f, -3.16555537e-02f, 3.00651789e-02f, -4.97852117e-02f, -5.83690219e-02f, -8.67167264e-02f, -6.82983696e-02f, -2.17856094e-02f, 6.16255775e-02f,
  5.59390187e-02f, -1.58831507e-01f, -1.89326569e-01f, -9.43565741e-02f, 1.92546081e-02f, 2.92035080e-02f, -8.20864737e-02f, -1.26164079e-01f, -1.26692370e-01f, 2.84728874e-02f,
  6.49080575e-02f, -9.75455437e-03f, 4.22309712e-02f, -1.53291496e-02f, -7.25244358e-02f, 1.16864927e-01f, -2.50528734e-02f, -4.16834764e-02f, 1.67604446e-01f, 5.40773477e-03f,
  -5.61052524e-02f, 3.85608338e-02f, 3.10932882e-02f, 2.65922416e-02f, -2.29147952e-02f, 2.02164389e-02f, 7.82319605e-02f, 2.90145408e-02f, -2.43103914e-02f, 1.17115900e-01f,
  -1.33417360e-02f, 3.52383666e-02f, -2.28304807e-02f, -1.88079476e-02f, 3.08347866e-02f, -4.07362357e-03f, -4.20089513e-02f, 7.24392682e-02f, -3.48308645e-02f, 6.00380190e-02f,
  8.24074596e-02f, -2.24038102e-02f, -5.42510115e-02f, 1.23812310e-01f, 6.31536767e-02f, -4.09746356e-02f, -5.40300971e-04f, 1.63759477e-02f, 1.15824357e-01f, 1.57758325e-01f,
  4.72810306e-03f, -6.25272049e-03f, 2.20487621e-02f, -3.61781791e-02f, 3.04325819e-02f, -2.17366386e-02f, -1.46271095e-01f, -1.37925884e-02f, 1.89404991e-02f, 7.46535137e-03f,
  -6.35093570e-01f, 4.06148359e-02f, 4.79120910e-01f, -2.69733012e-01f, -9.66817439e-02f, 2.43932828e-01f, 1.34712324e-01f, -7.77445547e-03f, -2.54634112e-01f, 1.43267319e-01f,
  -1.35074342e-02f, -1.11472338e-01f, 1.86861500e-01f, 6.66376054e-02f, 8.43130723e-02f, 1.66631937e-01f, 9.42200944e-02f, 1.19287200e-01f, -3.62700969e-03f, -1.87240362e-01f,
  -1.23506002e-01f, -1.82950854e-01f, 2.44715124e-01f, -2.14111488e-02f, 5.53449988e-02f, -1.22791201e-01f, -9.48244799e-03f, 6.34222999e-02f, 5.93783567e-03f, 6.89370483e-02f,
  -1.90284625e-01f, -1.65225849e-01f, -1.00725584e-01f, 6.76736683e-02f, -5.75105697e-02f, -3.77810523e-02f, 4.90663387e-02f, 4.79107089e-02f, -9.40884799e-02f, -3.13793682e-02f,
  2.24052314e-02f, 8.92754346e-02f, -1.07190929e-01f, -8.31374079e-02f, -8.16209689e-02f, 1.16013894e-02f, 1.01362921e-01f, 8.48657116e-02f, -8.42344668e-03f, 1.26566499e-01f,
  5.28072491e-02f, 4.65602092e-02f, 1.16658524e-01f, 2.40310412e-02f, 4.56900112e-02f, -5.13546495e-03f, 1.04916386e-01f, 2.06923857e-02f, -1.01969084e-02f, -7.51320645e-02f,
  3.15642431e-02f, 3.60313393e-02f, -3.03398725e-02f, 2.03580428e-02f, 1.62932258e-02f, 6.16060607e-02f, -2.00319430e-03f, -1.89704578e-02f, 2.12273700e-03f, -5.46511486e-02f,
  -5.92732802e-02f, 4.17368300e-02f, -8.39148536e-02f, -3.99726517e-02f, -2.36675870e-02f, 4.08273935e-02f, -7.82722533e-02f, -5.25705591e-02f, 7.73693100e-02f, -8.69908743e-03f,
  -7.19745818e-04f, -2.55847797e-02f, -5.35507314e-02f, 8.28331038e-02f, 2.66207894e-03f, -4.24235426e-02f, -7.62226898e-03f, 4.01502997e-02f, -5.60296066e-02f, 1.35620935e-02f,
  -4.20026600e-01f, -3.60553652e-01f, -1.22034542e-01f, -7.18063563e-02f, -1.53097168e-01f, -6.40853941e-02f, -3.97794768e-02f, -7.78601468e-02f, -4.72459048e-02f, -1.94135625e-02f,
  1.74518977e-03f, 5.83740547e-02f, -7.88616538e-02f, -2.34208424e-02f, 4.13815007e-02f, 3.01057268e-02f, -5.23168109e-02f, -4.10098955e-02f, -1.13886751e-01f, -1.70687303e-01f,
  -5.25647439e-02f, -7.40614161e-02f, 3.57652046e-02f, -2.61823703e-02f, 6.05249032e-02f, -5.68300374e-02f, -1.59543529e-01f, 4.92129736e-02f, 7.95265511e-02f, 1.03378154e-01f,
  -4.34596390e-01f, 5.63883841e-01f, 2.30110243e-01f, 4.58228076e-03f, -1.31919637e-01f, -4.34849458e-03f, 5.58589660e-02f, 2.82922015e-02f, 3.42707299e-02f, 1.90792650e-01f,
  -9.31446478e-02f, 1.91038072e-01f, 4.05524969e-02f, 1.14082925e-01f, -4.31342542e-01f, 1.10777028e-01f, -2.45628096e-02f, 1.01511709e-01f, 2.88118329e-02f, 8.16411525e-02f,
  -1.64554685e-01f, -1.48103058e-01f, 2.16000006e-02f, 7.00631887e-02f, 6.96022958e-02f, 4.37935442e-02f, -2.00345397e-01f, 5.65158390e-03f, -5.79513423e-03f, -2.08275616e-02f,
  -2.46166930e-01f, -1.54136062e-01f, -1.20667018e-01f, -7.76829422e-02f, -1.27804026e-01f, -8.51993561e-02f, -5.88105991e-02f, -3.69221829e-02f, -8.94367397e-02f, 2.86653675e-02f,
  7.32570663e-02f, -2.63757464e-02f, -4.92360666e-02f, 1.01457722e-02f, 3.54069937e-03f, 4.44933912e-03f, 4.23453264e-02f, 2.40262393e-02f, 1.75705855e-03f, -6.07273402e-03f,
  4.12863344e-02f, -3.27755213e-02f, -2.84726527e-02f, -9.31484532e-03f, -2.52037346e-02f, 4.30955552e-02f, 4.94249016e-02f, -4.36858945e-02f, -4.54536034e-03f, 8.56973114e-04f,
  -2.54824627e-02f, -5.69269024e-02f, 7.52673298e-02f, 4.16552797e-02f, 4.18505259e-02f, 2.35111210e-02f, 5.90655692e-02f, -8.32985044e-02f, -1.76927447e-02f, -4.12934497e-02f,
  -2.18175165e-02f, 5.88931653e-06f, -8.23681056e-02f, -2.72705853e-02f, 6.17077313e-02f, 7.83779845e-02f, -2.59645954e-02f, 1.14617990e-02f, 7.56878639e-03f, -8.03965479e-02f,
  -2.81186942e-02f, -2.76383348e-02f, -3.77133265e-02f, -3.48995812e-02f, 7.71582779e-03f, -2.88435780e-02f, -2.14104187e-02f, 2.89701372e-02f, -8.35499465e-02f, -1.18766829e-01f,
  -3.88628125e-01f, -3.07786673e-01f, -1.97103560e-01f, -1.23085581e-01f, -6.80190995e-02f, -7.28551745e-02f, -5.40261343e-02f, -3.44443023e-02f, -8.93340781e-02f, 3.45546827e-02f,
  -8.98313373e-02f, 4.52842452e-02f, -1.32616386e-02f, -4.30433862e-02f, -8.27320106e-03f, -5.69445938e-02f, -6.27599582e-02f, 1.19248740e-02f, -1.76020205e-01f, -1.23497121e-01f,
  3.11363209e-02f, -8.76846090e-02f, -1.20796077e-02f, -7.38659129e-02f, -8.64759684e-02f, -6.48160875e-02f, -1.17958533e-02f, 1.44325290e-02f, -4.08722498e-02f, 1.29833549e-01f,
  1.40759498e-01f, 3.28406125e-01f, 1.11672185e-01f, -1.46695405e-01f, -1.40870467e-01f, -4.38356623e-02f, -5.37972599e-02f, -7.88411219e-03f, 2.60040700e-01f, 1.46441802e-01f,
  -2.57335395e-01f, 3.14979762e-01f, 3.12744863e-02f, -1.36287630e-01f, 3.81824262e-02f, 2.99345478e-02f, -7.56548345e-02f, -6.44676760e-02f, 5.41751012e-02f, -6.27136752e-02f,
  1.98961664e-02f, -3.21843773e-01f, -4.92064841e-02f, -2.36681297e-01f, -4.92355153e-02f, 1.06124334e-01f, -1.33064434e-01f, 2.99747456e-02f, -1.37608618e-01f, -4.19518119e-03f,
  -1.63608715e-02f, -8.76593292e-02f, 7.99954385e-02f, 1.14287429e-01f, -4.39060619e-03f, -2.28515603e-02f, -5.84725030e-02f, -6.45471364e-02f, -6.86983019e-02f, 6.25395328e-02f,
  1.22704342e-01f, 2.61084866e-02f, 1.43589541e-01f, -2.79635526e-02f, 5.32843545e-02f, -3.74223329e-02f, 1.36977816e-02f, 1.18031062e-01f, 9.01412144e-02f, -1.52618950e-02f,
  1.22277789e-01f, 2.25900546e-01f, 9.99499559e-02f, 7.34357089e-02f, 5.69372764e-03f, -2.16777306e-02f, 5.60114942e-02f, 1.09305851e-01f, 4.59854305e-03f, 7.31318742e-02f,
  -6.71636164e-02f, -3.56027968e-02f, -6.42769262e-02f, -1.01185087e-02f, -2.45410390e-02f, -2.64694057e-02f, 5.75698502e-02f, -8.63346681e-02f, 4.95234504e-02f, 4.23940383e-02f,
  3.75183336e-02f, 6.14719018e-02f, -3.55571955e-02f, 3.74149717e-02f, -6.42506108e-02f, 8.17191303e-02f, 3.33004855e-02f, -5.44864871e-02f, 1.09594889e-01f, 3.70400175e-02f,
  -1.65251240e-01f, -8.36291537e-02f, 1.73168872e-02f, -1.19866773e-01f, -1.57236978e-02f, 1.29162923e-01f, -3.95064466e-02f, 2.70409938e-02f, -1.35066370e-02f, -5.67382239e-02f,
  -7.17968643e-02f, -2.24261299e-01f, 4.84226048e-02f, 8.25951397e-02f, 1.43546872e-02f, 3.50668542e-02f, -1.65089183e-02f, 7.94736482e-03f, -1.00050256e-01f, -5.66591918e-02f,
  2.72037573e-02f, -1.10309981e-02f, 1.22436345e-01f, 5.62735274e-02f, 1.69974398e-02f, -1.38358737e-03f, -3.53348255e-02f, 9.83776003e-02f, -5.75084947e-02f, 6.38825446e-02f,
  1.69525873e-02f, 1.00323290e-01f, 4.63919938e-02f, 1.41312927e-01f, -1.01246864e-01f, 3.56026068e-02f, -1.54792517e-02f, 8.32029954e-02f, -6.49170429e-02f, 2.34207623e-02f,
  -5.54418504e-01f, 3.39943618e-01f, 1.73215587e-02f, -9.77885276e-02f, 1.19741134e-01f, -3.61473374e-02f, -1.82575937e-02f, 1.51672050e-01f, 7.25038629e-03f, 4.64018956e-02f,
  1.70979593e-02f, -1.42647281e-01f, 1.19792774e-01f, -4.56633978e-02f, -2.72909433e-01f, 1.37623712e-01f, -1.05077140e-01f, -6.76508099e-02f, 1.08009271e-01f, -8.74487236e-02f,
  -1.29660770e-01f, 2.30455771e-02f, -1.61210336e-02f, 2.84732252e-01f, 9.00858045e-02f, -8.89927074e-02f, -9.30707753e-02f, 9.53870788e-02f, -6.77822307e-02f, 1.28828496e-01f,
  -2.33133569e-01f, -2.75900334e-01f, -1.80766597e-01f, -1.67711303e-01f, -2.14379936e-01f, -1.87639326e-01f, -4.73700352e-02f, 5.20353355e-02f, -7.91560709e-02f, 3.35511714e-02f,
  1.37723505e-03f, 3.08513008e-02f, 3.25156935e-02f, 9.08938199e-02f, -6.42953888e-02f, 2.33739354e-02f, 3.32376026e-02f, 9.82374186e-04f, 3.59569490e-02f, 6.19572587e-02f,
  -9.30504128e-03f, -5.35481684e-02f, -1.50152773e-01f, -1.10776844e-02f, 2.86635570e-02f, -8.26631393e-03f, -5.41294273e-03f, -1.36894196e-01f, -9.13053900e-02f, -1.25257531e-02f,
  -7.84015954e-02f, -1.20851500e-02f, -1.49245816e-03f, 1.00209927e-02f, 5.91089949e-02f, 7.22801685e-02f, 1.37666368e-03f, -7.55042508e-02f, 3.41085270e-02f, -6.33447096e-02f,
  4.25674841e-02f, -6.06133603e-02f, -9.54414830e-02f, 1.62407290e-02f, 4.02738452e-02f, 2.14676149e-02f, -1.05922505e-01f, 2.58441363e-02f, 1.39446437e-01f, -4.43616807e-02f,
  2.90694218e-02f, -2.02942118e-02f, -6.43077493e-02f, 6.75092936e-02f, -6.01902381e-02f, -4.43305932e-02f, -1.54590476e-02f, 1.84824858e-02f, -5.13075478e-02f, 3.96353519e-03f,
  -4.64023829e-01f, -3.95792872e-01f, -1.61375687e-01f, -8.25922266e-02f, -1.27080709e-01f, -4.16808911e-02f, 1.20109715e-03f, -1.38706686e-02f, -3.76617610e-02f, -1.68824964e-03f,
  -1.00397907e-01f, 4.58344212e-03f, -6.48537353e-02f, -3.13621238e-02f, -3.39164361e-02f, -1.13075702e-02f, -1.05940603e-01f, -5.20859249e-02f, -1.71308517e-01f, -7.86676109e-02f,
  -5.16773388e-02f, -3.19399685e-02f, -5.79241384e-03f, 1.81540214e-02f, 4.42068931e-03f, -5.99979982e-02f, -1.25758037e-01f, 2.52513047e-02f, -3.47590894e-02f, 1.64909005e-01f,
  -1.67442933e-01f, 1.37395665e-01f, 1.01886593e-01f, -2.48995155e-01f, 3.13805230e-02f, 1.63905010e-01f, -1.57126412e-02f, -8.72486681e-02f, -7.46797537e-03f, -2.25800499e-01f,
  -3.75141382e-01f, 1.44774213e-01f, 2.63259232e-01f, -1.42771140e-01f, 3.84708554e-01f, 2.20101938e-01f, -5.56749925e-02f, -3.59651744e-02f, 1.35464579e-01f, -3.95282842e-02f,
  1.04001284e-01f, -1.03213586e-01f, 5.56014366e-02f, -9.76912752e-02f, -1.72874242e-01f, -6.78750575e-02f, -6.52497336e-02f, 3.01478893e-01f, -2.81231046e-01f, 2.35728398e-02f,
  -9.40213203e-02f, -2.09922761e-01f, -3.41493823e-02f, 5.20498715e-02f, -1.09059297e-01f, -1.15088314e-01f, -5.97125776e-02f, 1.03391133e-01f, 1.29698977e-01f, -4.13464345e-02f,
  1.06623478e-01f, -6.97379932e-02f, 1.61079429e-02f, 2.36589506e-01f, -8.66004229e-02f, -4.96236719e-02f, -2.30422360e-03f, -1.08267412e-01f, 7.15414360e-02f, -1.40278302e-02f,
  8.00795294e-03f, 1.05824076e-01f, -4.01392542e-02f, -1.42085794e-02f, 8.03476572e-02f, -1.57749131e-01f, -1.13724187e-01f, 4.91521508e-02f, -5.79510033e-02f, -1.01298958e-01f,
  1.28728077e-01f, 5.70879243e-02f, -1.57126114e-01f, -8.92553329e-02f, -2.82777473e-02f, -6.53952509e-02f, -1.76693574e-02f, -1.54854745e-01f, -1.28936455e-01f, -9.91441086e-02f,
  -1.93316892e-01f, -8.35185871e-02f, -6.06131628e-02f, 1.25706494e-01f, -9.83829945e-02f, -2.53913552e-01f, -7.00777536e-03f, 1.27774188e-02f, -1.83664232e-01f, -2.26212908e-02f,
  -1.52903963e-02f, -2.24854006e-03f, -5.11698537e-02f, 2.01896764e-02f, -7.84397945e-02f, 3.48143727e-02f, 7.66989365e-02f, -1.36185959e-02f, 5.91297224e-02f, 2.53206015e-01f,
  1.51388779e-01f, 2.10516259e-01f, 1.22710995e-01f, -7.99209923e-02f, -3.09836958e-03f, -7.05792978e-02f, 2.34594092e-01f, 1.34366909e-02f, 8.05746391e-02f, -1.07545651e-01f,
  -3.10575850e-02f, -1.04072653e-01f, -8.56008083e-02f, -2.70732287e-02f, 9.34147015e-02f, -5.46979764e-03f, 1.44646451e-01f, -3.96626815e-02f, 1.29357623e-02f, 1.02936924e-01f,
  1.90507963e-01f, 1.89600158e-02f, 6.99067563e-02f, -1.25467911e-01f, -8.72879997e-02f, -1.19781055e-01f, -5.14699221e-02f, 1.14804476e-01f, 1.50407419e-01f, 1.54262139e-02f,
  5.69118783e-02f, 4.35228974e-01f, 1.60333157e-01f, 1.33674189e-01f, -7.62874931e-02f, -4.54536736e-01f, -2.30186343e-01f, 1.21555582e-01f, 1.02503166e-01f, 4.88972925e-02f,
  -9.66359749e-02f, 2.88658351e-01f, -8.19837376e-02f, 1.85703292e-01f, -3.57477725e-01f, -2.75567561e-01f, -9.65289921e-02f, 4.11613323e-02f, -8.29079747e-02f, -1.86233614e-02f,
  -5.93124628e-02f, -1.42442370e-02f, 7.22971186e-02f, 6.76890090e-02f, 1.00780010e-01f, 1.98960468e-01f, -6.12455755e-02f, 8.82850736e-02f, 1.14831954e-01f, -6.37994558e-02f,
  -7.26339743e-02f, 2.67452538e-01f, 8.81888345e-02f, -2.47316994e-03f, -9.75393057e-02f, -1.51635647e-01f, -6.84055611e-02f, -5.33653572e-02f, -4.74740490e-02f, 7.66389817e-02f,
  2.00168602e-02f, -4.12033647e-02f, 1.10120483e-01f, 9.10448283e-02f, -1.08318619e-01f, 8.24236572e-02f, -6.63155457e-03f, -8.59339237e-02f, 1.02514803e-01f, 3.14571708e-02f,
  1.31262362e-01f, 2.49663722e-02f, -4.12918590e-02f, 5.39246202e-03f, -3.40495706e-02f, -4.59581241e-02f, -4.10341136e-02f, 3.40489522e-02f, -1.50378915e-02f, 1.02672614e-01f,
  2.74020936e-02f, 4.80286703e-02f, 9.53563899e-02f, 8.11980516e-02f, 9.90373716e-02f, 1.47468261e-02f, 2.63790302e-02f, -1.00847110e-01f, -1.05442638e-02f, -8.50645155e-02f,
  -9.73597541e-02f, 5.24692237e-02f, -3.84334032e-03f, 9.92891006e-03f, -7.69441053e-02f, 9.25953388e-02f, -2.02725269e-02f, 6.42332584e-02f, -5.44862151e-02f, 3.06947785e-03f,
  5.40282298e-03f, -5.70647828e-02f, 4.33450490e-02f, -1.72414973e-01f, -6.95282295e-02f, 6.34584902e-03f, -5.49136056e-03f, 6.34029834e-03f, 3.11730541e-02f, 2.00524926e-02f,
  -2.13173583e-01f, 4.47232313e-02f, -4.96054292e-02f, -7.13074533e-03f, 2.34616473e-02f, -7.94106275e-02f, 5.65504394e-02f, 2.76458804e-02f, -8.07306394e-02f, 6.65498823e-02f,
  -2.87280865e-02f, -8.59013423e-02f, -1.25729069e-01f, -2.04819255e-02f, -5.62875234e-02f, -3.79383564e-02f, -1.16190035e-02f, -7.49967024e-02f, 2.44817212e-02f, -2.15461086e-02f,
  9.90199149e-02f, 8.13685358e-02f, 4.64977580e-04f, 6.28693309e-03f, -3.60989049e-02f, -8.09949115e-02f, 7.21119717e-02f, 1.42540522e-02f, 7.03629702e-02f, 1.48453359e-02f,
  -1.02032915e-01f, 1.67636454e-01f, 1.99327782e-01f, -6.82649482e-03f, 1.29390106e-01f, -1.17129892e-01f, -1.82929769e-01f, 2.65181214e-01f, 2.48003483e-01f, -3.74732345e-01f,
  -6.27563149e-02f, -3.12161773e-01f, -2.35708654e-02f, 3.04960855e-03f, 9.83331949e-02f, 1.38333648e-01f, 2.49354497e-01f, -6.10680804e-02f, 2.03952625e-01f, 9.26867649e-02f,
  2.78565526e-01f, -7.40096644e-02f, 2.22475320e-01f, 7.67991841e-02f, 1.11547805e-01f, 1.96273267e-01f, -9.95713025e-02f, 1.38135612e-01f, -4.02966663e-02f, 1.00707896e-01f,
  -1.00853465e-01f, 7.05517381e-02f, 5.15584536e-02f, 1.16726071e-01f, 9.76938903e-02f, -1.19036824e-01f, 8.20733048e-03f, -7.54358694e-02f, 7.02644419e-03f, -7.46165439e-02f,
  2.87901349e-02f, -5.16852774e-02f, 1.37259156e-01f, -7.22556636e-02f, 3.84688232e-04f, 3.60604050e-03f, 5.71375825e-02f, 9.86159295e-02f, 1.44631108e-02f, 8.32402334e-02f,
  1.33182734e-01f, 5.95938005e-02f, 9.28336680e-02f, 1.88460216e-01f, 1.52038991e-01f, 5.96418865e-02f, -3.35898064e-02f, 3.06181833e-02f, 3.97690833e-02f, 2.41639595e-02f,
  1.77120432e-01f, 1.17314160e-01f, -8.31704438e-02f, -1.44876882e-01f, 3.54149416e-02f, 5.62769435e-02f, 3.34447362e-02f, -6.38635829e-02f, 9.93343368e-02f, 4.78710644e-02f,
  -3.90039235e-02f, -1.64333191e-02f, 9.51728448e-02f, -2.62074210e-02f, -8.59329253e-02f, -2.15206668e-02f, -3.81195620e-02f, -2.09907163e-02f, 1.01164304e-01f, 5.85383214e-02f,
  -1.02476768e-01f, -4.78400625e-02f, 1.00736497e-02f, -5.48825460e-03f, -1.42948389e-01f, 7.95196043e-04f, 1.16886324e-04f, -8.01284164e-02f, -1.31932748e-02f, 1.06607199e-01f,
  8.74647051e-02f, 1.84958160e-01f, 1.25188574e-01f, -7.80062331e-03f, -9.37477592e-03f, -9.30076167e-02f, 9.84287113e-02f, 1.01043038e-01f, 7.72140995e-02f, 5.38240448e-02f,
  6.80105761e-02f, -1.34692013e-01f, -9.00629684e-02f, 5.93306832e-02f, 7.35848723e-03f, 8.54476728e-03f, -5.82870878e-02f, 3.49822268e-02f, 1.04725875e-01f, 1.31212234e-01f,
  1.35593740e-02f, 5.48340566e-03f, 1.69485924e-03f, 1.83134183e-01f, 1.51997246e-02f, -5.07452935e-02f, -1.14057861e-01f, 6.58784658e-02f, 9.15410817e-02f, 5.72765619e-03f,
  2.01558415e-02f, -3.36700946e-01f, -2.01244190e-01f, -3.18965279e-02f, -2.60107309e-01f, -1.50807247e-01f, -2.50586849e-02f, -2.14584619e-01f, -1.32044807e-01f, 2.92135682e-02f,
  -1.25231057e-01f, 1.83108822e-01f, 2.94702291e-01f, -2.72183657e-01f, 3.13954860e-01f, 3.72374773e-01f, -2.06040852e-02f, 1.64408281e-01f, -5.24748676e-02f, -9.30659994e-02f,
  -4.36227657e-02f, -9.46399719e-02f, 5.50148636e-02f, -3.37869674e-01f, -3.19255799e-01f, -2.03681737e-01f, -5.38102239e-02f, -2.18074396e-01f, -1.96655333e-01f, -2.32579246e-01f,
  -7.38601834e-02f, -9.43710878e-02f, -2.27364469e-02f, 1.22149490e-01f, -9.40920860e-02f, -1.73094886e-04f, 3.96223068e-02f, -1.75602436e-02f, 9.49211568e-02f, 9.75666940e-02f,
  1.43463597e-01f, 1.70825869e-01f, -1.61611721e-01f, -1.36382636e-02f, -1.33924887e-01f, 2.58867186e-03f, 3.78147103e-02f, 1.56131968e-01f, 8.40064585e-02f, -4.32671271e-02f,
  5.15668094e-02f, 1.39273871e-02f, -2.93342266e-02f, 1.57578886e-01f, 2.78470088e-02f, -2.61478871e-02f, 2.41212696e-02f, 6.12424081e-03f, 4.89723943e-02f, -2.01424845e-02f,
  -4.75963913e-02f, 5.83734214e-02f, 3.78722628e-03f, -2.26460025e-02f, -4.76188995e-02f, -1.12559371e-01f, 1.79821234e-02f, -2.21093465e-02f, -1.00835837e-01f, 1.05496310e-02f,
  1.16522655e-01f, -3.18123288e-02f, -4.50480171e-03f, 3.51564400e-02f, -6.00612387e-02f, -5.51683316e-03f, 4.76649888e-02f, 7.83181470e-03f, -3.29826027e-02f, -2.94265077e-02f,
  2.37753764e-02f, -7.90844560e-02f, 1.56664720e-03f, 1.14366740e-01f, 5.04274340e-03f, 4.23570573e-02f, 1.64412260e-02f, 2.65206657e-02f, -5.36406487e-02f, 7.20757172e-02f,
  -4.60787490e-02f, -1.09636545e-01f, -5.15726358e-02f, 1.19023889e-01f, 7.29926080e-02f, -6.00554869e-02f, -8.68517309e-02f, -1.16836414e-01f, 4.72191535e-02f, -1.26931686e-02f,
  6.28383011e-02f, 1.31071344e-01f, 6.95702210e-02f, -7.03792721e-02f, 5.05804382e-02f, -6.28468245e-02f, 1.75761282e-01f, 1.83307722e-01f, 1.03385478e-01f, -2.66006310e-02f,
  1.21490665e-01f, 4.86101881e-02f, 1.21072978e-01f, 1.17444955e-01f, 4.14940678e-02f, 1.24530308e-01f, -9.70169753e-02f, -7.40224421e-02f, 4.08473313e-02f, 5.52279204e-02f,
  1.12380840e-01f, -2.26302549e-01f, -1.74645007e-01f, 8.57891962e-02f, -1.36867628e-01f, -1.12754524e-01f, -8.05957615e-02f, 7.59557867e-03f, 3.79614621e-01f, 1.15622669e-01f,
  -2.51509175e-02f, 6.25280514e-02f, 9.72523540e-02f, -2.50838131e-01f, 7.91451409e-02f, 2.28275880e-01f, -1.68917984e-01f, -1.08393310e-02f, 1.63556531e-01f, -1.38554946e-01f,
  7.64196813e-02f, -9.57335830e-02f, -2.15655312e-01f, -1.05413191e-01f, -1.92123726e-01f, -8.17530900e-02f, -1.81882024e-01f, -2.26199746e-01f, -2.73205012e-01f, -9.82525423e-02f,
  -1.04405563e-02f, 9.72188637e-02f, -2.11351141e-01f, 2.16202419e-02f, 8.23878776e-03f, -9.21072885e-02f, -1.49173796e-01f, -8.20311010e-02f, 7.90235251e-02f, 1.98478222e-01f,
  8.86224732e-02f, 1.84400737e-01f, -6.79487130e-03f, -4.99394126e-02f, -5.26184887e-02f, 7.57348463e-02f, 1.39061287e-01f, 6.38851523e-02f, 2.64766067e-02f, -6.91231415e-02f,
  9.22172423e-03f, 9.01038870e-02f, 7.55090863e-02f, 8.83373916e-02f, -7.13447332e-02f, 8.31104517e-02f, 1.95711125e-02f, -1.35971889e-01f, 3.38724032e-02f, 1.07390679e-01f,
  -1.15048133e-01f, -1.66990720e-02f, -2.12977137e-02f, 3.64823155e-02f, 8.18427578e-02f, -1.44481398e-02f, 5.08038104e-02f, 7.81951249e-02f, 1.07455745e-01f, 5.33504933e-02f,
  1.00297585e-01f, -9.24163014e-02f, -3.09210625e-02f, -4.02120277e-02f, 1.13911465e-01f, 4.80959285e-03f, -7.07744732e-02f, 8.80186260e-02f, 5.81817850e-02f, 4.23775567e-03f,
  -9.80297197e-03f, -9.68337357e-02f, 7.46991187e-02f, -3.42655778e-02f, -9.14075375e-02f, 1.00317553e-01f, -7.43253306e-02f, -3.52084241e-03f, 1.28085297e-02f, -3.99806760e-02f,
  -3.13096009e-02f, -6.64420845e-03f, -1.11993328e-01f, 2.24192888e-02f, -3.93770859e-02f, -1.36287734e-02f, -1.29597425e-01f, -3.16422097e-02f, 3.09758913e-02f, 6.95278347e-02f,
  -9.98889431e-02f, 1.38564602e-01f, 8.37757736e-02f, -1.02222294e-01f, 8.89412537e-02f, 2.23533325e-02f, 9.78365541e-02f, 9.73570868e-02f, 1.27691915e-02f, -1.47177830e-01f,
  -4.74766716e-02f, 1.20414473e-01f, 1.54543012e-01f, 2.21665949e-01f, -1.18506597e-02f, 1.30129969e-02f, 3.25075760e-02f, -6.22392446e-02f, 4.66056615e-02f, 1.06897563e-01f,
  -4.34882998e-01f, -2.52164483e-01f, -2.44069517e-01f, 1.18996978e-01f, -8.43361244e-02f, 2.28688493e-01f, 4.04064000e-01f, -1.43699691e-01f, -1.98094234e-01f, 2.00486556e-01f,
  2.87393153e-01f, 1.47806341e-02f, -1.24172918e-01f, 4.52653229e-01f, 1.73524663e-01f, 1.44145742e-01f, 2.07250863e-01f, 1.76563695e-01f, -5.46801016e-02f, -2.78204113e-01f,
  -7.84456506e-02f, 2.07300395e-01f, 1.84267059e-01f, -2.21403297e-02f, 2.73115803e-02f, -9.04621184e-02f, 2.04335555e-01f, -1.87213253e-02f, 3.39903593e-01f, 2.96483129e-01f,
  -8.35477635e-02f, -2.07346752e-01f, -7.07052276e-02f, -1.18519224e-01f, 4.11998779e-02f, 5.91031983e-02f, -2.67288033e-02f, 9.72811878e-02f, 7.11842179e-02f, -3.56891528e-02f,
  -8.18314105e-02f, -1.39788285e-01f, -9.47338250e-03f, -4.81374599e-02f, -7.10392669e-02f, -4.67981212e-02f, -6.21134341e-02f, -5.20146918e-03f, -9.16275531e-02f, -2.88456050e-03f,
  -7.68095404e-02f, -1.45250717e-02f, 5.37307076e-02f, 1.58067673e-01f, 6.40459284e-02f, -1.22206509e-02f, -3.31155285e-02f, -8.21475908e-02f, 6.46382868e-02f, -6.75324642e-04f,
  3.15880626e-02f, 1.13305391e-03f, 3.53022702e-02f, 9.22471881e-02f, 8.83874763e-03f, 8.11636001e-02f, -1.85457263e-02f, 5.26516922e-02f, 1.45015448e-01f, 3.81571567e-03f,
  -7.75542781e-02f, -1.29227936e-02f, 3.80597338e-02f, -3.47364545e-02f, 2.07189266e-02f, -1.64018162e-02f, -7.16290697e-02f, 1.07343160e-02f, -7.99399242e-02f, 1.16722822e-01f,
  -2.46787113e-05f, -9.67115089e-02f, -2.79665757e-02f, 2.53386106e-02f, -2.49389815e-03f, 5.54927289e-02f, -8.26191902e-02f, -5.24711274e-02f, 5.24956025e-02f, 2.89711840e-02f,
  -1.39831692e-01f, -2.14829147e-01f, 7.21255541e-02f, -3.98655655e-03f, 6.56954199e-02f, 5.18270163e-03f, 4.12149429e-02f, -6.57417625e-02f, -7.08306953e-02f, -3.43242995e-02f,
  -3.69001925e-02f, -2.83930786e-02f, 3.06274630e-02f, -2.51732040e-02f, -1.69601347e-02f, -3.10506783e-02f, -3.57868373e-02f, -1.25336116e-02f, -1.81688964e-02f, 5.06731607e-02f,
  -2.27609016e-02f, 3.09275035e-02f, 4.95377555e-02f, -1.28898034e-02f, 1.51715353e-01f, 9.51367691e-02f, -4.08838168e-02f, -5.27770817e-02f, 6.12758026e-02f, -4.98474017e-02f,
  -4.44680721e-01f, 3.98153186e-01f, 1.28747165e-01f, -3.23322177e-01f, 2.40505472e-01f, 1.60066888e-01f, -1.95632845e-01f, 1.79425031e-01f, -2.93787252e-02f, 2.88643818e-02f,
  -1.95443854e-01f, 4.92429128e-03f, 1.09948665e-01f, -2.00740427e-01f, -2.04327941e-01f, 9.77104232e-02f, -2.31231973e-01f, -2.10749060e-01f, 2.33814731e-01f, -6.57205731e-02f,
  -9.44013149e-02f, -5.36409318e-02f, -5.69559485e-02f, 2.57830143e-01f, 3.29774395e-02f, -1.34414714e-02f, -2.11725056e-01f, 2.04508007e-01f, -1.09560139e-01f, 1.27467677e-01f,
  -3.58392373e-02f, -8.66903514e-02f, 3.90456878e-02f, 1.05621211e-01f, -8.58190097e-03f, -7.84125328e-02f, -4.14630808e-02f, 9.54409018e-02f, 2.59511936e-02f, 9.43915695e-02f,
  5.14628664e-02f, 1.14777498e-01f, 3.33185196e-02f, 5.29226921e-02f, 3.65391038e-02f, 8.71234760e-02f, 1.38173506e-01f, 4.24659364e-02f, 9.10697505e-02f, 3.05349566e-03f,
  5.63439280e-02f, 3.85646932e-02f, -2.15505809e-02f, -4.87242453e-02f, 4.60243374e-02f, -1.43920872e-02f, -2.77485382e-02f, -9.93447825e-02f, -3.24071944e-02f, -1.80014875e-02f,
  -6.82512391e-03f, 5.35893813e-02f, 5.47116157e-03f, 2.63976641e-02f, 1.38962820e-01f, 2.22300049e-02f, 9.33588855e-03f, -4.10696417e-02f, 4.30014282e-02f, -7.55505115e-02f,
  -1.07740149e-01f, -5.03364243e-02f, -8.68677944e-02f, -1.36287082e-02f, -5.44717573e-02f, 1.44407395e-02f, -2.64373329e-02f, -9.51137673e-03f, -6.55947393e-03f, 1.74172316e-02f,
  1.03707917e-01f, -3.64225172e-02f, -4.46536578e-02f, 4.22186824e-03f, 2.37864368e-02f, 8.31733495e-02f, -4.90728617e-02f, -1.28164673e-02f, 2.02822546e-03f, 1.51796034e-02f,
  -2.21637905e-01f, -2.45483160e-01f, 2.71627195e-02f, 8.12884942e-02f, 5.48498370e-02f, 1.79634020e-02f, 1.86192000e-03f, 4.33403626e-02f, 4.06067520e-02f, 8.16186592e-02f,
  3.89442369e-02f, -9.48427618e-02f, -5.52036874e-02f, -1.82527695e-02f, 1.63381267e-02f, -5.56917768e-03f, -6.10560738e-02f, -4.84119542e-02f, -3.12155429e-02f, -3.71610862e-03f,
  4.25838120e-02f, -5.09709343e-02f, -4.81969044e-02f, 4.13045026e-02f, -5.04301079e-02f, -9.26950276e-02f, -1.04139581e-01f, 5.18862903e-02f, -2.82722563e-02f, 1.01201106e-02f,
  1.03181683e-01f, -2.32287526e-01f, 8.74725506e-02f, 3.60582322e-02f, 3.19048971e-01f, 1.39369547e-01f, 4.72367182e-02f, -5.93828689e-03f, -8.69310796e-02f, -4.77685541e-01f,
  -9.27348435e-02f, -1.66158155e-01f, -2.85136580e-01f, -6.45808056e-02f, 2.73870140e-01f, -9.57380757e-02f, 3.61621454e-02f, -5.77523522e-02f, 1.24534525e-01f, 9.42129195e-02f,
  1.37258723e-01f, 3.20601687e-02f, 9.32276845e-02f, 2.43035238e-02f, -8.12178664e-03f, -4.05969955e-02f, 8.92388076e-03f, -4.61859033e-02f, -9.28070694e-02f, 1.78021453e-02f,
  1.05029702e-01f, -9.79626849e-02f, 1.67971980e-02f, -7.75000155e-02f, 1.60844512e-02f, -8.95577744e-02f, -6.85681179e-02f, 9.05099884e-02f, 3.92937101e-02f, -1.47057455e-02f,
  -5.17064780e-02f, -9.98807326e-02f, 2.68837214e-02f, 8.08990002e-02f, 8.84812102e-02f, 6.26293123e-02f, 3.43852006e-02f, 7.21598491e-02f, -8.76375809e-02f, -8.18517581e-02f,
  3.67753133e-02f, -2.51363148e-04f, 7.91566968e-02f, -7.59179611e-03f, 1.63134327e-03f, 1.75877586e-02f, -4.22192067e-02f, -1.14994220e-01f, 3.79950274e-03f, -9.90050733e-02f,
  -1.27958685e-01f, -7.37266764e-02f, 3.59328091e-02f, 1.05212778e-01f, 5.69532812e-02f, 1.91745535e-02f, 1.32079020e-01f, -2.30579562e-02f, -1.80149823e-02f, -2.93354914e-02f,
  -2.82292999e-02f, 4.91310610e-03f, -1.07980454e-02f, 4.57414575e-02f, -6.01155721e-02f, 1.06457591e-01f, 1.65392086e-01f, -8.40529576e-02f, -1.19902328e-01f, 1.29739672e-01f,
  1.52606085e-01f, 9.12231579e-02f, -4.09888849e-02f, -1.53061328e-02f, 1.68951899e-02f, 4.32459917e-03f, -1.13291807e-01f, -8.09125230e-02f, 2.11140990e-01f, -6.90360516e-02f,
  -6.59585074e-02f, -3.42723250e-01f, -3.90645713e-02f, -1.83669664e-02f, 9.50036163e-04f, -2.39214562e-02f, 6.13029599e-02f, 7.67940283e-02f, -1.29374072e-01f, -4.39483020e-03f,
  -4.71644104e-02f, 2.20100377e-02f, -1.90751683e-02f, 1.45337060e-01f, 6.92486838e-02f, 7.05920458e-02f, -1.82086200e-01f, -3.02537270e-02f, 2.04158425e-02f, -3.82008427e-03f,
  -7.88537264e-02f, 1.55689046e-02f, -1.71634316e-01f, -4.70333211e-02f, -4.45136800e-02f, -1.10860370e-01f, 1.19411252e-01f, -4.90008257e-02f, -1.22613879e-02f, -6.13333583e-02f,
  -1.62762981e-02f, 4.58417982e-02f, -1.68636218e-02f, 9.86166000e-02f, -3.96873653e-02f, -2.47589260e-01f, -1.34467691e-01f, 1.42727541e-02f, 8.94222260e-02f, 1.68360606e-01f,
  -1.09546237e-01f, -7.64124095e-02f, 7.64553994e-02f, -2.21540153e-01f, -4.05036211e-01f, -2.25454047e-01f, -6.30309358e-02f, -1.96715747e-03f, -1.06860273e-01f, -1.44220427e-01f,
  -2.90123150e-02f, -2.06160009e-01f, 1.48913953e-02f, -3.94938961e-02f, 2.68925503e-02f, 2.28296742e-01f, 1.87165037e-01f, 8.01948681e-02f, 1.23450391e-01f, -1.70140401e-01f,
  -8.00711662e-02f, 1.10807270e-01f, 1.13665991e-01f, -9.72211361e-02f, 3.36872116e-02f, 1.39453545e-01f, 9.82344970e-02f, -4.61015888e-02f, -1.56666875e-01f, -3.02006379e-02f,
  3.72787341e-02f, -5.22093885e-02f, -6.70422018e-02f, -9.34433416e-02f, 1.30308375e-01f, 7.89338257e-03f, 1.08281173e-01f, 8.44937116e-02f, 3.87323759e-02f, -2.69191973e-02f,
  1.08850718e-01f, 6.88982978e-02f, 1.92337051e-01f, 5.46379611e-02f, 1.38942590e-02f, 2.18987726e-02f, -5.55880740e-02f, 1.47338539e-01f, 1.23842962e-01f, 5.27812541e-02f,
  8.75654742e-02f, -9.04875770e-02f, -6.83685252e-03f, -1.67972565e-01f, -1.42132998e-01f, 5.38753755e-02f, 5.57533130e-02f, 3.58302817e-02f, -7.45886713e-02f, -6.00416809e-02f,
  -1.02276877e-01f, -2.12410800e-02f, -1.49925008e-01f, 2.84937229e-02f, -4.26603518e-02f, -3.56004685e-02f, -4.20145616e-02f, 3.69493216e-02f, 4.85781021e-02f, -4.85933498e-02f,
  -3.68894935e-02f, -2.82859262e-02f, 2.13306248e-02f, 5.80738038e-02f, -1.43907890e-01f, 1.40510583e-02f, 1.20256096e-01f, 6.40491098e-02f, -8.68046004e-03f, 5.38597256e-03f,
  6.35998696e-02f, 4.06656079e-02f, 4.50362414e-02f, -8.20494220e-02f, 3.76624055e-02f, 2.35211290e-02f, -3.24135087e-02f, -1.94493718e-02f, -7.22524822e-02f, -1.40784323e-01f,
  2.55994126e-02f, 1.21397510e-01f, -5.92952315e-03f, -1.14658993e-04f, -1.41293658e-02f, -1.17622681e-01f, 7.24693909e-02f, -2.34702006e-02f, 7.51650706e-02f, 6.32468313e-02f,
  1.66615114e-01f, 5.62635716e-03f, 1.38378710e-01f, 1.21268600e-01f, 2.95824390e-02f, 9.70693827e-02f, -9.45847034e-02f, 6.75620809e-02f, 4.58914563e-02f, -5.58609888e-02f,
  2.38792431e-02f, -2.27352127e-01f, -7.21204430e-02f, 1.54198915e-01f, 2.33789057e-01f, 2.97131035e-02f, 1.10253565e-01f, -9.26492065e-02f, -1.71678752e-01f, -9.89230797e-02f,
  -2.45832782e-02f, -1.32212952e-01f, -9.16344896e-02f, -3.27896297e-01f, -2.53983170e-01f, -3.77575576e-01f, -1.04054876e-01f, -3.11668497e-02f, -1.32280678e-01f, -3.63544933e-02f,
  -2.21025944e-02f, -1.00424252e-01f, -3.38763520e-02f, 2.77460087e-02f, 1.23988234e-01f, 2.11431086e-01f, 2.00366184e-01f, 1.89185157e-01f, 1.49163932e-01f, 3.11909914e-02f,
  3.03543871e-03f, -1.62989363e-01f, 3.26677179e-03f, -8.69232863e-02f, 7.13615343e-02f, 1.12353243e-01f, 2.75168419e-02f, 3.30989659e-02f, 1.95001766e-01f, -3.13481428e-02f,
  6.99065924e-02f, 8.81326497e-02f, -1.89601555e-01f, 3.59829143e-02f, 1.54220998e-01f, 1.71701051e-02f, 1.50893992e-02f, 9.36253462e-03f, 5.73910400e-02f, -9.39094573e-02f,
  -1.31962793e-02f, -6.19168431e-02f, 3.97738293e-02f, 2.69493810e-03f, 5.64654656e-02f, -9.68605932e-03f, -1.06322080e-01f, 1.45687267e-01f, 1.98746435e-02f, -3.40634100e-02f,
  -5.97526543e-02f, -3.76086570e-02f, -6.49594963e-02f, -1.03733175e-01f, -1.73611585e-02f, -7.73660885e-03f, -4.77429070e-02f, -5.03530279e-02f, 7.64501393e-02f, 1.44646419e-02f,
  8.86733532e-02f, 3.34666967e-02f, -9.72302258e-02f, 3.10116392e-02f, 2.36306246e-02f, -1.22458257e-01f, 1.26037858e-02f, 3.26466262e-02f, 8.34963992e-02f, -5.70343100e-02f,
  -1.06558781e-02f, 4.67116013e-02f, 9.81705561e-02f, 1.00726755e-02f, -1.37993082e-01f, 9.18429494e-02f, 1.30891204e-01f, -7.75426254e-02f, -1.09563455e-01f, 4.46828753e-02f,
  1.01856373e-01f, -9.81873348e-02f, -1.28326640e-02f, 8.86756182e-03f, -6.69389069e-02f, -2.96772961e-02f, -2.02509746e-01f, -6.89610764e-02f, 1.00921296e-01f, -1.25913844e-01f,
  1.27051741e-01f, 1.61367625e-01f, -1.29421772e-02f, -2.52971463e-02f, 1.63637668e-01f, -7.17507526e-02f, 6.46183416e-02f, 9.35424417e-02f, 1.51272073e-01f, -4.91771474e-02f,
  3.29780653e-02f, 4.96121123e-02f, -2.26821285e-02f, 5.09552471e-03f, 5.59763163e-02f, 1.03696913e-01f, -4.21862602e-02f, 1.05320230e-01f, 4.19184230e-02f, 4.83791158e-02f,
  -3.48705500e-02f, 6.09610006e-02f, 3.00627768e-01f, -6.95451051e-02f, 1.21912085e-01f, 2.95790642e-01f, 1.93323731e-01f, 2.59459853e-01f, 4.17661428e-01f, -1.76771313e-01f,
  -1.70242175e-01f, -2.93244809e-01f, -1.90472733e-02f, -1.15431726e-01f, 3.44160646e-01f, 2.58227408e-01f, 1.59401596e-01f, -1.11650884e-01f, 1.33418590e-01f, -9.40835550e-02f,
  5.18319644e-02f, -2.08010241e-01f, -1.80299774e-01f, -3.04203361e-01f, -2.21224502e-01f, -1.33157596e-01f, -2.30515212e-01f, 8.97512287e-02f, -2.36250013e-01f, 8.47170427e-02f,
  2.68242918e-02f, -9.23177227e-02f, -1.56385064e-01f, 8.53297412e-02f, -4.76616733e-02f, -2.59889476e-02f, 7.14958599e-03f, 2.79925596e-02f, 8.42530802e-02f, 7.97650218e-03f,
  1.64320841e-02f, 3.82427163e-02f, -9.83515829e-02f, 1.15515798e-01f, 1.25416815e-01f, 7.81215131e-02f, 6.67776987e-02f, 6.85150102e-02f, 6.58555701e-03f, 9.38880816e-02f,
  4.68365811e-02f, 5.50342612e-02f, 8.08750093e-02f, 1.40339017e-01f, -5.22837304e-02f, 2.39644665e-02f, 1.78302396e-02f, 3.24535072e-02f, 4.55861539e-02f, 5.43119609e-02f,
  5.05133234e-02f, 5.23630455e-02f, -1.22994058e-01f, -3.33925895e-03f, -3.63518484e-02f, -1.81746576e-02f, 7.45005235e-02f, -7.08949044e-02f, -2.45378469e-03f, -5.36677912e-02f,
  -6.04757629e-02f, -1.66324362e-01f, 4.10717577e-02f, 8.26514587e-02f, -4.73905317e-02f, 1.76058360e-03f, -1.77862635e-03f, -3.11303716e-02f, -6.66148067e-02f, -1.16534084e-01f,
  -8.45963974e-03f, 8.34766030e-02f, -9.26545784e-02f, -1.22379081e-03f, 5.81343397e-02f, 1.35817509e-02f, 1.00513091e-02f, 5.36275208e-02f, 8.30530673e-02f, -7.37727853e-03f,
  1.04272194e-01f, 5.18855499e-03f, -1.30908012e-01f, 1.23345405e-02f, 1.16825169e-02f, -6.60598353e-02f, 3.23248580e-02f, -3.62738371e-02f, 1.09017007e-01f, 4.00440581e-02f,
  3.00048031e-02f, -4.46593687e-02f, -3.60131152e-02f, 1.03456855e-01f, 5.07053733e-02f, 4.67785262e-02f, 7.49192387e-02f, 1.48360373e-03f, 1.54133700e-02f, -9.52401310e-02f,
  -2.37071812e-02f, 2.43155621e-02f, 9.32405889e-02f, -7.11168870e-02f, -1.45579994e-01f, -1.40296504e-01f, -9.64323655e-02f, 6.98637515e-02f, 1.14415385e-01f, 1.22912444e-01f,
  4.25512910e-01f, -2.09851950e-01f, 1.86024196e-02f, 1.02905810e-01f, 2.49426842e-01f, 1.64775833e-01f, 4.17304724e-01f, -8.58926922e-02f, 8.99770856e-02f, -2.40850121e-01f,
  -1.08289935e-01f, -4.07350250e-02f, 1.94871083e-01f, -2.94671040e-02f, 2.96085030e-01f, 9.64256376e-02f, -7.32769445e-02f, -1.84743181e-01f, 3.18907164e-02f, -9.20278430e-02f,
  7.96661824e-02f, -1.09941624e-02f, 1.48155987e-01f, -1.68619886e-01f, 5.00353687e-02f, -1.59027576e-01f, -4.88552228e-02f, 8.91595110e-02f, -2.65902847e-01f, 1.25543429e-02f,
  1.40735814e-02f, -2.05991268e-02f, 5.10906279e-02f, -1.24403283e-01f, 1.08005717e-01f, 9.43329781e-02f, -1.59906775e-01f, 7.58785196e-03f, 9.72870886e-02f, 4.65335846e-02f,
  -4.33736667e-02f, -1.04642607e-01f, -1.04846053e-01f, 1.26371190e-01f, 9.94886532e-02f, -3.77722224e-03f, 1.08284121e-02f, 7.31311515e-02f, -6.54083341e-02f, -3.42443446e-03f,
  1.27843261e-01f, -4.11687791e-02f, 6.49298131e-02f, -7.58311450e-02f, 2.67190542e-02f, 2.98764966e-02f, -1.35888178e-02f, 1.71411745e-02f, -9.09008533e-02f, 4.42180820e-02f,
  -5.16001768e-02f, 2.79699564e-02f, 2.09010616e-02f, -3.01358048e-02f, 5.99373505e-02f, -4.88984138e-02f, -6.74272254e-02f, -1.19780377e-01f, -1.22030927e-02f, -6.67385012e-03f,
  -4.72134016e-02f, -5.43918721e-02f, 2.11717542e-02f, 1.28064249e-02f, 1.38729038e-02f, -2.85636913e-02f, -5.15448079e-02f, -3.29404115e-03f, 1.44461051e-01f, -1.25197163e-02f,
  -6.40166327e-02f, -8.17304552e-02f, 1.27066508e-01f, -1.07695773e-01f, -6.58320934e-02f, 1.50408730e-01f, -3.32008265e-02f, 3.45274359e-02f, -1.21385463e-01f, 6.63236249e-03f,
  -6.81846440e-02f, -2.43367657e-01f, -3.08211576e-02f, -1.80556282e-01f, -8.62024426e-02f, 8.95504430e-02f, -7.50582293e-02f, -1.83920264e-01f, -9.22934487e-02f, 3.32353711e-02f,
  -8.83880854e-02f, -1.07563019e-01f, 1.31353429e-02f, -2.25899331e-02f, -1.01353049e-01f, 2.30461396e-02f, -7.89518133e-02f, -4.62376848e-02f, -1.62767782e-03f, -1.06430173e-01f,
  -2.22930964e-02f, -1.37329483e-02f, 2.69147512e-02f, -2.00360287e-02f, -1.49605155e-01f, 2.16347110e-02f, 3.94470654e-02f, 5.55132255e-02f, 3.18414792e-02f, -8.99624601e-02f,
  2.59482861e-01f, -1.32614359e-01f, -1.65244833e-01f, -2.30160877e-02f, -4.95556481e-02f, -2.60524508e-02f, -1.85788587e-01f, -5.82392439e-02f, 3.28459637e-03f, 4.58635911e-02f,
  -5.70620969e-02f, 2.46531188e-01f, -3.51626694e-01f, 2.44247034e-01f, 4.30890113e-01f, -1.93340180e-03f, 2.60467201e-01f, 1.22714430e-01f, 1.04674220e-01f, 7.50501752e-02f,
  1.35292605e-01f, 3.27207863e-01f, -1.77746154e-02f, 1.33332342e-01f, 6.28362298e-02f, -1.34443671e-01f, 6.53371662e-02f, -1.25861779e-01f, 1.88731387e-01f, 1.92093015e-01f,
  -3.97446416e-02f, 5.08994497e-02f, -7.43435621e-02f, 5.82664274e-02f, -9.22044441e-02f, -5.65964393e-02f, -3.39500196e-02f, -6.56326339e-02f, 1.14630694e-02f, -6.85634762e-02f,
  4.10819501e-02f, 1.75112456e-01f, 4.46074829e-02f, 7.75090829e-02f, 4.64562662e-02f, 6.15930296e-02f, 4.47490104e-02f, 1.29844472e-02f, 1.54113453e-02f, 3.49979959e-02f,
  -2.65272893e-02f, 3.41516882e-02f, -4.51302249e-03f, 3.52164917e-02f, -8.75472371e-03f, 4.82040718e-02f, 2.43553994e-04f, -9.31559652e-02f, 4.92354706e-02f, 1.89004019e-01f,
  4.80960272e-02f, -3.80559489e-02f, -4.19899411e-02f, -8.16329941e-02f, 1.42249363e-02f, -5.40611148e-02f, 3.15129086e-02f, -7.60824233e-02f, 2.55180225e-02f, 1.97877153e-03f,
  4.41863351e-02f, -5.60787097e-02f, 3.05460719e-03f, 2.28096880e-02f, 4.25127484e-02f, 1.07727811e-01f, 7.26038171e-03f, 1.76460519e-02f, 1.38042113e-02f, -6.51799813e-02f,
  -6.21783845e-02f, 2.61709373e-02f, -4.43788245e-02f, -8.34340826e-02f, -2.80396477e-03f, -3.55408825e-02f, 1.43564465e-02f, 1.18946970e-01f, -1.02207646e-01f, -6.02602679e-03f,
  6.55103922e-02f, 1.11346729e-01f, -1.00693800e-01f, 4.99098301e-02f, -4.13329154e-02f, 1.47637844e-01f, 5.74083440e-02f, 5.31628504e-02f, 1.18088000e-01f, 1.14560977e-01f,
  1.01523004e-01f, -1.05248004e-01f, 2.01893374e-02f, 2.22691894e-03f, 1.86859686e-02f, 8.13423991e-02f, 2.94097196e-02f, 5.93136065e-02f, 5.35392351e-02f, -1.91394649e-02f,
  -8.22395366e-03f, -6.25073910e-03f, 3.21652703e-02f, 6.38778787e-03f, 1.89581793e-02f, -3.03628575e-03f, -8.02364293e-03f, -2.06773356e-02f, -3.85901728e-03f, 6.58269525e-02f,
  1.71102330e-01f, -1.55108154e-01f, -2.48752058e-01f, -1.03436798e-01f, -1.24729894e-01f, -4.23582375e-01f, -2.84960628e-01f, -9.48703215e-02f, 8.47461075e-02f, 8.58314261e-02f,
  1.30897582e-01f, 1.21086910e-01f, 2.64302522e-01f, -1.40595809e-01f, -5.64044975e-02f, 3.76375169e-01f, -3.74548137e-01f, -2.05498070e-01f, 2.01021880e-01f, -1.14299528e-01f,
  -1.30032166e-03f, 1.03608146e-02f, -9.14308727e-02f, 1.07280016e-02f, -1.68593138e-01f, -4.10185605e-02f, 1.48891052e-02f, 8.72764364e-02f, -2.10332513e-01f, -3.29245105e-02f,
  -4.09654789e-02f, 1.50526688e-01f, -7.86769241e-02f, -5.72698116e-02f, -8.44084024e-02f, -1.19330607e-01f, -9.94291827e-02f, -6.73965588e-02f, 1.08670644e-01f, -3.72823398e-03f,
  -8.99347104e-03f, 1.71284884e-01f, -8.57796222e-02f, 1.40593007e-01f, 6.19073994e-02f, 1.58369448e-02f, 6.07395656e-02f, 1.40268132e-02f, -2.36223508e-02f, 7.04210550e-02f,
  -1.36469956e-02f, -2.21480895e-02f, -4.43617366e-02f, 4.08257954e-02f, 1.10664684e-03f, 3.88864242e-02f, -8.24437663e-02f, -1.02751888e-01f, -5.15090749e-02f, 8.18626061e-02f,
  4.41355482e-02f, 1.42827630e-02f, -2.93492340e-02f, -2.20310478e-03f, -2.78479196e-02f, -8.50340500e-02f, 5.81354424e-02f, -2.21934486e-02f, -2.41730623e-02f, 2.88623665e-02f,
  -2.29526870e-02f, -7.59942606e-02f, 2.61764843e-02f, -3.22674029e-02f, -1.79799143e-02f, -1.66462630e-03f, -6.39123917e-02f, -2.99843419e-02f, -1.04037791e-01f, -1.74993560e-01f,
  9.98239517e-02f, 2.60905130e-03f, 2.12298688e-02f, 7.29309991e-02f, 3.11689638e-02f, 2.71591563e-02f, 1.30366281e-01f, 1.36109814e-01f, -6.80900663e-02f, -1.24166891e-01f,
  -1.27746731e-01f, -2.08986830e-02f, -5.10978810e-02f, 1.05101708e-02f, -3.61310132e-02f, -6.77123666e-02f, -1.02102384e-01f, -2.24133089e-01f, 1.10914158e-02f, -2.59121675e-02f,
  -8.88188779e-02f, -8.34247693e-02f, -2.26826444e-02f, -4.13333811e-03f, -8.37778971e-02f, -1.43954858e-01f, 9.30358022e-02f, 7.24722892e-02f, -5.73116466e-02f, -7.06714690e-02f,
  4.98302169e-02f, 2.53312662e-02f, 8.62086415e-02f, -3.50029841e-02f, -4.52757068e-02f, 4.93424237e-02f, -1.10168092e-01f, 4.49783467e-02f, 3.26414965e-02f, 1.39786089e-02f,
  2.59121090e-01f, 3.51246834e-01f, 2.48189673e-01f, 3.22027057e-02f, -1.83885500e-01f, 1.90928996e-01f, 7.55438730e-02f, 9.85963196e-02f, 6.41901568e-02f, 2.02350885e-01f,
  -1.77815244e-01f, 2.36413613e-01f, -2.75402009e-01f, 4.34624031e-02f, -2.05520421e-01f, -2.85809990e-02f, 5.55488430e-02f, 1.08237877e-01f, -1.30327761e-01f, 9.30735767e-02f,
  -1.08630851e-01f, -2.76389033e-01f, -2.00948134e-01f, -2.05098629e-01f, 7.49253854e-02f, 1.81108475e-01f, -3.22600991e-01f, -1.08716875e-01f, -1.75513495e-02f, -9.64113176e-02f,
  4.31521563e-03f, -6.96516633e-02f, 1.30303070e-01f, 1.69464335e-01f, 5.48516773e-02f, 5.40524088e-02f, 3.53314206e-02f, 3.95457856e-02f, -1.28397718e-01f, 1.28971664e-02f,
  3.44419740e-02f, -1.33647397e-03f, 1.47074878e-01f, -2.03537762e-01f, -2.25752033e-02f, 1.30745871e-02f, -4.05169390e-02f, 5.91707975e-02f, 4.53066342e-02f, 1.86660700e-02f,
  8.33771899e-02f, 3.80726298e-03f, -1.79706272e-02f, -3.29008400e-02f, 7.80969113e-02f, 4.78329994e-02f, 1.44201219e-01f, -4.62169107e-03f, 5.99973202e-02f, -5.74671372e-04f,
  -9.54093039e-02f, 8.33319202e-02f, 1.11004211e-01f, 4.37127389e-02f, 2.94016302e-02f, 1.82894226e-02f, -1.38994437e-02f, -6.13712892e-03f, 1.21319965e-01f, -1.21622859e-02f,
  -5.30220978e-02f, 3.76382284e-02f, 1.33956838e-02f, -2.27635652e-02f, 5.17291315e-02f, 8.24954733e-02f, 1.01548445e-04f, -4.50061969e-02f, -2.67470535e-02f, 1.16800703e-01f,
  -4.62104529e-02f, 1.54067464e-02f, -8.47719163e-02f, -1.16840854e-01f, 2.16813274e-02f, -1.01910785e-01f, -1.33849606e-01f, -2.86242645e-02f, -1.36085171e-02f, -1.01397328e-01f,
  4.63678315e-02f, 6.38437420e-02f, 4.33687344e-02f, 3.67016196e-02f, 2.80902535e-02f, 6.60149232e-02f, 3.83054651e-02f, 1.88844889e-01f, -2.85673700e-02f, -1.37839653e-02f,
  -4.57758224e-03f, 4.05133590e-02f, 2.64633354e-02f, -1.45818621e-01f, -9.09573138e-02f, 1.33398905e-01f, -2.34896746e-02f, -5.04556345e-03f, -5.03253080e-02f, -4.67522219e-02f,
  -3.85081135e-02f, -5.34710437e-02f, 5.45985550e-02f, 4.76807915e-02f, 1.09884538e-01f, -4.42558341e-02f, 1.89965367e-01f, 4.35969036e-04f, -7.71317333e-02f, 3.38763967e-02f,
  2.30150372e-02f, -1.28181040e-01f, 2.49139413e-01f, 1.61757603e-01f, -6.22706525e-02f, -3.38498175e-01f, 2.09603887e-02f, -4.36518714e-02f, -2.76935607e-01f, -2.31156498e-01f,
  1.55391470e-01f, 3.17705601e-01f, 2.32673898e-01f, -1.66511089e-01f, 3.48584771e-01f, 1.43600032e-01f, -2.69615650e-01f, 5.99756092e-02f, -9.17518418e-03f, 8.98272842e-02f,
  5.57348765e-02f, -1.40912637e-01f, 2.84977198e-01f, -1.23776585e-01f, 6.43953169e-03f, 1.82904564e-02f, 2.75340021e-01f, 2.63650596e-01f, -1.28879808e-02f, 7.08910264e-03f,
  -2.47463569e-01f, -1.75630283e-02f, -4.37659808e-02f, -1.36960849e-01f, -1.45622417e-01f, -1.26523105e-02f, 5.33933342e-02f, 1.24266975e-01f, 7.04910830e-02f, 2.13728156e-02f,
  -1.91747025e-02f, 8.37059543e-02f, -1.06426753e-01f, -4.38080821e-03f, -1.98891327e-01f, -3.12473569e-02f, -8.19666684e-02f, -9.64242872e-03f, -8.73028785e-02f, 7.42334127e-02f,
  -2.76523512e-02f, -1.48570910e-01f, -8.81164372e-02f, -6.72387630e-02f, 1.09622426e-01f, -1.60551012e-01f, 2.17428263e-02f, 9.80795771e-02f, -1.03586815e-01f, -8.83690827e-03f,
  -3.71037759e-02f, -2.00969842e-03f, 4.86172549e-03f, -5.78717664e-02f, -2.67378055e-02f, 3.06494646e-02f, -9.66565311e-02f, 5.44509068e-02f, 7.76069015e-02f, 5.60515858e-02f,
  -2.62224507e-02f, 1.13052189e-01f, -1.46342620e-01f, -1.47913516e-01f, 3.23179625e-02f, 1.03612086e-02f, 1.07634701e-01f, 2.87865959e-02f, -5.24929464e-02f, -4.63758484e-02f,
  4.15783525e-02f, -1.14568755e-01f, -4.35648253e-03f, 3.12230047e-02f, -1.93247665e-02f, -3.09899654e-02f, -6.70966785e-03f, -5.09137660e-02f, 1.96250435e-02f, 1.42979220e-01f,
  -1.11850590e-01f, 1.15553573e-01f, -1.15104308e-02f, -1.64161101e-01f, -1.27320752e-01f, -5.05026020e-02f, -5.06726243e-02f, -4.31731790e-02f, 7.60232285e-02f, 5.65619878e-02f,
  -6.76634163e-02f, 1.44767882e-02f, -5.61933257e-02f, -9.51904953e-02f, 2.34055016e-02f, 6.11437224e-02f, 9.00563896e-02f, 3.67363989e-02f, -2.40812004e-02f, 2.37368327e-02f,
  2.13356167e-02f, -3.98723874e-03f, -6.71286285e-02f, -1.50718674e-01f, -3.78067791e-02f, -4.57607955e-02f, 5.34591675e-02f, -9.63551998e-02f, 3.43960263e-02f, 1.73400730e-01f,
  2.44054630e-01f, -2.82505661e-01f, 3.21582071e-02f, 3.29880059e-01f, 1.91756248e-01f, 6.34066686e-02f, 2.14647919e-01f, 1.35603081e-02f, 1.94171086e-01f, -2.15706408e-01f,
  -3.25634480e-02f, -5.77709377e-02f, -2.11076349e-01f, 2.30596781e-01f, 3.49977553e-01f, -1.56561166e-01f, 2.48249173e-01f, 9.91587341e-02f, -1.03725391e-02f, -9.38025787e-02f,
  9.45351496e-02f, 9.70075428e-02f, 1.21218991e-02f, -1.09922737e-01f, 3.36411931e-02f, -1.33918718e-01f, -8.20856765e-02f, -4.51520570e-02f, 9.81774330e-02f, 1.55722022e-01f,
  3.78018431e-02f, 7.85893481e-03f, 8.55751056e-03f, -2.82610394e-02f, -4.15245555e-02f, -1.15572875e-02f, 1.21914502e-02f, 5.35561554e-02f, 1.66604027e-01f, -4.91930991e-02f,
  -1.96558069e-02f, 5.10190465e-02f, -5.35166338e-02f, 1.33523028e-02f, 5.93395978e-02f, 8.37331116e-02f, 4.27829102e-03f, -5.75112551e-02f, 1.77263618e-02f, -4.45825644e-02f,
  -1.94457807e-02f, -1.77795570e-02f, 5.48207760e-02f, 2.24473123e-02f, 6.86319098e-02f, 8.57517216e-03f, -5.70358336e-02f, -3.87517624e-02f, -4.14838595e-03f, 1.36326561e-02f,
  2.18411162e-02f, -5.53732291e-02f, -1.01071686e-01f, -5.64998053e-02f, -7.94228725e-03f, 1.67803504e-02f, 1.06017729e-02f, -8.72203186e-02f, 2.31118291e-03f, 3.09801241e-03f,
  4.87581417e-02f, 1.91023257e-02f, 1.37629651e-03f, 7.82165825e-02f, 8.02123249e-02f, -6.38278127e-02f, -2.26158462e-03f, 1.17946090e-02f, 2.97207832e-02f, 1.57155991e-02f,
  -7.78384320e-03f, 6.16947450e-02f, -2.94670146e-02f, -4.73266803e-02f, 5.99382259e-03f, 2.61958688e-02f, -2.24824902e-02f, 8.23536050e-03f, -7.28771761e-02f, 5.00703938e-02f,
  -9.54600764e-05f, -8.97601992e-02f, -3.74324135e-02f, -1.29188225e-03f, -5.99421673e-02f, -7.49216834e-03f, 1.11273276e-02f, 3.98805328e-02f, 1.28887430e-01f, 3.80638428e-02f,
  -2.26541590e-02f, 6.82630530e-03f, -9.44168568e-02f, -7.12885195e-03f, 4.98801135e-02f, -1.02654293e-01f, -1.04407016e-02f, -6.32212544e-03f, 1.64778516e-01f, -1.37974590e-01f,
  -6.53785244e-02f, -4.75163683e-02f, -6.66777324e-03f, 7.04822168e-02f, 7.21594393e-02f, -4.62437496e-02f, -2.34986432e-02f, 2.32790988e-02f, -4.29099472e-03f, 5.98856322e-02f,
  -3.23911846e-01f, 3.20766807e-01f, -3.57865803e-02f, 1.11508884e-01f, -5.50770089e-02f, -1.91153303e-01f, 4.48711738e-02f, 4.73801978e-02f, -1.91208974e-01f, 2.33079523e-01f,
  2.54184812e-01f, -1.86947152e-01f, 2.43971199e-01f, 2.55030185e-01f, -1.58043817e-01f, 2.63509452e-01f, -9.30013973e-03f, 3.24112587e-02f, -1.11159109e-01f, 1.75346315e-01f,
  -5.24843447e-02f, 2.03480586e-01f, 2.16251582e-01f, 1.58918723e-01f, 5.81273474e-02f, -2.81745419e-02f, 2.43694022e-01f, 8.68255720e-02f, 2.60345861e-02f, -5.93173914e-02f,
  3.78715396e-02f, 1.09630473e-01f, 2.82333270e-02f, -1.19307719e-01f, 4.28230083e-03f, -1.31292758e-03f, 3.39166112e-02f, -8.37267116e-02f, -1.30438894e-01f, -9.19716731e-02f,
  -1.37130901e-01f, -9.49507356e-02f, 3.31705697e-02f, 1.37327211e-02f, -5.09193726e-02f, -6.74078315e-02f, -7.51139745e-02f, -1.27847791e-01f, -1.08505152e-01f, 6.54646978e-02f,
  5.02351075e-02f, -1.04563069e-02f, -3.07843145e-02f, 8.18228871e-02f, -1.46745564e-02f, -3.13304998e-02f, 3.24121583e-03f, 4.90669198e-02f, 1.68615803e-02f, -9.21851620e-02f,
  -9.86260083e-03f, -3.76609378e-02f, 5.52177951e-02f, 1.74230076e-02f, 3.14997733e-02f, 7.54281357e-02f, -4.25518751e-02f, -4.03736383e-02f, -5.44771552e-02f, 1.38209620e-03f,
  -1.20555118e-01f, -4.25371602e-02f, 7.79260742e-03f, -7.37894475e-02f, -9.35499966e-02f, -5.43118007e-02f, -8.68357569e-02f, 1.48028350e-02f, 1.52966492e-02f, 3.56449164e-03f,
  1.22358315e-02f, -7.73146600e-02f, -2.06454694e-02f, 7.14423433e-02f, -1.06138103e-02f, -6.94624484e-02f, -1.78478267e-02f, 6.19992912e-02f, 1.41509831e-01f, -7.06874877e-02f,
  3.48834284e-02f, 2.05950718e-02f, 3.33711952e-02f, -4.56641652e-02f, -8.58114380e-03f, -2.00302079e-02f, -9.30991862e-03f, -1.21331826e-01f, -7.91218057e-02f, -7.50252828e-02f,
  -1.02433942e-01f, -4.31771465e-02f, 4.82927635e-02f, 4.93016280e-03f, -5.50809428e-02f, 3.14845406e-02f, -3.94349694e-02f, -1.51331469e-01f, -7.30142221e-02f, 3.58445682e-02f,
  3.25364619e-02f, -3.31985876e-02f, -4.01654504e-02f, 7.85684735e-02f, -1.41190402e-02f, -3.04757385e-03f, 1.30241655e-03f, 5.38809709e-02f, 2.58185193e-02f, -5.73003069e-02f,
  6.40925318e-02f, -3.20635855e-01f, 1.28707752e-01f, 1.48020729e-01f, 2.97729850e-01f, 1.26295507e-01f, 2.12140992e-01f, -1.05663901e-02f, 3.55203301e-02f, -4.29368824e-01f,
  -6.24657087e-02f, -1.22379668e-01f, -1.37702224e-03f, -1.77524343e-01f, 1.81720033e-01f, 3.27103399e-02f, -4.88272943e-02f, -1.12658232e-01f, 1.72460705e-01f, -2.26676874e-02f,
  7.63397515e-02f, -4.53691510e-03f, 2.11888567e-01f, -1.25720024e-01f, 7.50294924e-02f, -6.74119368e-02f, -6.46638870e-02f, 2.39503141e-02f, -2.00090706e-01f, -1.52366739e-02f,
  -1.70773678e-02f, 1.99317243e-02f, 1.28152579e-01f, -6.60114884e-02f, -9.56195500e-03f, -6.11782726e-03f, 3.08947563e-02f, 1.07653029e-01f, 1.25517994e-01f, -8.03306699e-03f,
  -3.52508575e-02f, 3.12492270e-02f, -8.59175399e-02f, -7.64056519e-02f, 1.22979715e-01f, 2.92299911e-02f, 1.02806963e-01f, 6.02747239e-02f, 9.97951254e-02f, 1.81392636e-02f,
  8.53332356e-02f, -1.04642361e-02f, 1.10516779e-01f, -9.61148217e-02f, 1.61498830e-01f, 1.04051001e-01f, 1.26230955e-01f, -5.96198924e-02f, 1.61890425e-02f, -4.34955172e-02f,
  3.49650383e-02f, 6.86613247e-02f, 1.21260537e-02f, -2.87488494e-02f, -2.85322266e-03f, -5.51048554e-02f, 6.85104541e-03f, 2.29631341e-03f, -1.45768737e-02f, 8.47565476e-03f,
  -4.94730584e-02f, 2.10326649e-02f, 3.56937870e-02f, 2.93604173e-02f, 9.64155197e-02f, 2.61662584e-02f, 5.90316989e-02f, -6.76488578e-02f, 4.00555320e-02f, 4.46895659e-02f,
  -2.36522537e-02f, -1.41642997e-02f, -1.60868373e-02f, 1.74061172e-02f, -8.48900620e-03f, 1.04776703e-01f, -1.78074334e-02f, 2.00179201e-02f, 1.71228293e-02f, -3.34104411e-02f,
  -2.19230920e-01f, -4.11547959e-01f, 5.01223393e-02f, -5.93422465e-02f, -1.12490028e-01f, -6.28621578e-02f, 9.22939274e-03f, 4.58739847e-02f, -6.98196739e-02f, 1.50427260e-02f,
  -8.21930468e-02f, -4.18966152e-02f, -9.41956937e-02f, -9.23766568e-03f, 6.87549310e-03f, 5.83511963e-02f, -1.07350357e-01f, -7.33035877e-02f, 6.78030849e-02f, -4.18929905e-02f,
  -3.61674726e-02f, -4.70659547e-02f, -1.01506881e-01f, 9.46648344e-02f, 6.73089698e-02f, -6.71224520e-02f, -4.15726118e-02f, -1.07969735e-02f, -4.66466509e-02f, -8.54331851e-02f,
  1.08014479e-01f, 1.34901837e-01f, -8.30312893e-02f, -2.02227324e-01f, -9.44500566e-02f, -7.89285824e-02f, -1.77986324e-01f, 2.05035627e-01f, -2.55305022e-01f, -3.48128118e-02f,
  -7.16337115e-02f, -2.36607596e-01f, 5.19571155e-02f, -1.35263041e-01f, 1.94978565e-01f, -6.88793808e-02f, 1.22148082e-01f, -8.98844823e-02f, 1.42049000e-01f, 3.99215609e-01f,
  2.34805644e-01f, 1.12817019e-01f, 3.21134597e-01f, 3.99904102e-01f, 1.63484767e-01f, 3.39100301e-01f, 3.52354854e-01f, 1.83074817e-01f, 1.39123872e-01f, 5.70952930e-02f,
  -2.21681525e-03f, -4.91875894e-02f, 2.75441799e-02f, -1.71994731e-01f, 1.65487692e-01f, -1.55644491e-02f, 5.46498522e-02f, -2.98032109e-02f, -1.34985939e-01f, -7.80866668e-02f,
  -6.24548271e-02f, 7.65017932e-03f, -3.44615243e-02f, 1.12013631e-02f, -4.69616130e-02f, -9.73647088e-02f, -2.78226789e-02f, -3.81613374e-02f, -1.37221530e-01f, 7.98758864e-02f,
  8.63116235e-03f, -1.10663585e-01f, -4.04495560e-02f, -2.84362175e-02f, -1.26170322e-01f, 7.65786543e-02f, 1.29630826e-02f, 6.66002333e-02f, -7.23719150e-02f, -2.08452232e-02f,
  1.64583117e-01f, -1.54897692e-02f, 4.71352115e-02f, -7.17031956e-02f, 7.33530056e-03f, -3.31384651e-02f, -1.51043296e-01f, -6.02893941e-02f, 1.98556576e-02f, -8.14476609e-03f,
  -1.49994373e-01f, -2.29702201e-02f, -4.30190749e-02f, -8.79666731e-02f, -2.86970567e-02f, 1.59275122e-02f, 3.91765982e-02f, -9.46955290e-03f, 1.67777520e-02f, -1.21779619e-02f,
  -7.47473761e-02f, 6.82661310e-02f, 5.25270738e-02f, 4.79149930e-02f, -7.08014742e-02f, -1.01690114e-01f, -5.25856651e-02f, -6.78548068e-02f, 9.78535563e-02f, 2.16055587e-02f,
  1.09788179e-02f, 2.05873370e-01f, 4.38707229e-03f, -1.16235688e-01f, -3.21956053e-02f, -1.19648427e-01f, -7.58539736e-02f, 1.68495893e-03f, -4.11692448e-02f, -6.13525920e-02f,
  8.26896727e-02f, 3.05276327e-02f, -7.44506121e-02f, -4.02920274e-03f, 2.93778311e-02f, 6.53539896e-02f, -5.58044799e-02f, -1.14280827e-01f, -9.69512388e-02f, 1.68826342e-01f,
  -1.54915377e-02f, 2.77327038e-02f, -7.28468150e-02f, -9.02474523e-02f, -1.77929133e-01f, -2.20551738e-03f, 1.28088102e-01f, 4.34548631e-02f, 6.60459921e-02f, -1.72746330e-01f,
  6.87676445e-02f, 6.43050969e-02f, -2.56250054e-02f, -9.22673494e-02f, 9.75132063e-02f, -1.01035811e-01f, -1.88628420e-01f, -1.34362504e-01f, -1.73498154e-01f, 8.42312127e-02f,
  -1.74121693e-01f, 1.33111730e-01f, 8.51126611e-02f, -2.26632431e-01f, -4.37200218e-01f, -1.74959108e-01f, -2.10541964e-01f, -5.11217862e-02f, 3.44204828e-02f, -7.28571191e-02f,
  -1.50488019e-01f, -2.38236591e-01f, -2.70353526e-01f, -5.75746149e-02f, 7.92884529e-02f, 1.57183692e-01f, 1.06910825e-01f, 1.79084450e-01f, 7.04569370e-02f, -1.02946118e-01f,
  -2.44515259e-02f, -8.60706493e-02f, 3.96474563e-02f, -5.40822446e-02f, -4.40319441e-02f, 4.85322364e-02f, 5.98065183e-02f, 2.17922684e-02f, -4.63554151e-02f, 3.49690542e-02f,
  1.84997633e-01f, 1.72688514e-01f, -1.08483136e-01f, 8.71258602e-02f, 1.95923820e-01f, 6.13878891e-02f, 1.02993116e-01f, 1.22351721e-01f, 5.20280823e-02f, -1.18902102e-02f,
  -2.77204197e-02f, 1.49706796e-01f, 2.62224432e-02f, -9.71860960e-02f, 1.77044608e-02f, 1.13647960e-01f, 1.09813228e-01f, 2.40706459e-01f, 2.92934328e-02f, -6.16066642e-02f,
  -2.19515339e-02f, -3.05160340e-02f, -1.49125960e-02f, 3.40339318e-02f, -2.98915617e-02f, -1.89819057e-02f, -2.46892851e-02f, 3.32853124e-02f, -7.29155540e-02f, 2.70734378e-03f,
  1.05168760e-01f, 1.00792825e-01f, -2.53123976e-02f, -2.14403257e-01f, 6.98025227e-02f, -1.17435530e-02f, -6.02116343e-03f, 1.03942215e-01f, 6.36917492e-03f, -4.42076214e-02f,
  3.95057164e-03f, -4.73579429e-02f, -1.59431137e-02f, 1.78037986e-01f, -5.48531897e-02f, -6.92447647e-02f, 1.91968083e-02f, 1.03017792e-01f, -2.06450373e-01f, -2.30819620e-02f,
  -6.43282384e-02f, -1.29491553e-01f, -1.32103357e-02f, -6.19461462e-02f, 3.35154287e-03f, 8.22494030e-02f, -7.55919740e-02f, -6.80594146e-02f, -2.01203637e-02f, -7.98911974e-02f,
  1.26068532e-01f, 1.02022752e-01f, 1.54361054e-01f, -1.28009543e-01f, 6.00610375e-02f, -1.86569884e-01f, 6.68973997e-02f, 9.19202045e-02f, -3.40074040e-02f, 2.89664939e-02f,
  4.44783233e-02f, 9.32913870e-02f, -1.10934628e-02f, -1.54452100e-01f, -4.87387404e-02f, 1.53585836e-01f, 6.88114315e-02f, 5.43224588e-02f, 1.04183808e-01f, 4.48989607e-02f,
  1.15681931e-01f, 2.79550433e-01f, 7.00171618e-03f, 1.55798405e-01f, -4.08865400e-02f, 1.66054696e-01f, 1.28787890e-01f, 6.98502809e-02f, 9.54773203e-02f, 2.40025088e-01f,
  -4.19962555e-02f, 1.23457037e-01f, -7.04869926e-02f, 2.14901313e-01f, -6.95093721e-02f, -5.12380078e-02f, 3.45633060e-01f, 1.86481848e-01f, -4.84809875e-02f, 2.59737670e-01f,
  5.51502854e-02f, 2.11029887e-01f, -1.23858958e-01f, -1.00654289e-01f, 7.03367293e-02f, -1.08319171e-01f, -1.70754015e-01f, -2.33263329e-01f, 8.20285603e-02f, -1.16476633e-01f,
  -7.12907910e-02f, 3.97953540e-02f, -7.13791102e-02f, 1.12317940e-02f, 7.87851587e-02f, 1.37281165e-01f, 6.09212853e-02f, -6.89053088e-02f, -9.33807120e-02f, -7.65637308e-03f,
  1.13636449e-01f, -1.17926663e-02f, 9.05592069e-02f, 4.27707545e-02f, 1.98895317e-02f, 3.21774669e-02f, -2.77137235e-02f, 1.04282454e-01f, 8.29674080e-02f, 4.72147055e-02f,
  6.82692379e-02f, 3.54742147e-02f, 1.27667543e-02f, 8.87235776e-02f, 1.02102188e-02f, 1.14285015e-02f, -2.36398131e-02f, 2.20345538e-02f, 7.13046044e-02f, -3.94382216e-02f,
  8.90479833e-02f, 3.13106887e-02f, -1.67402774e-02f, -7.36487359e-02f, -6.91450983e-02f, -2.78209858e-02f, -8.93826503e-03f, -4.05163467e-02f, -6.40931427e-02f, 4.92442399e-02f,
  -6.42740056e-02f, -2.29102820e-02f, 2.61383485e-02f, 7.04181269e-02f, 4.16870005e-02f, 6.38968199e-02f, -6.74175322e-02f, 4.12762053e-02f, 6.70957342e-02f, 5.99551806e-03f,
  2.26699635e-02f, -5.56454286e-02f, -1.35726810e-01f, 2.56341565e-02f, -8.51042122e-02f, -6.54087141e-02f, 4.46883477e-02f, -8.40373919e-04f, -1.53483087e-02f, 5.84867746e-02f,
  2.10561648e-01f, 2.76233524e-01f, 1.24788862e-02f, -1.26171559e-02f, 6.19149581e-02f, 1.29847884e-01f, 1.20774083e-01f, 6.37216792e-02f, 8.66958126e-02f, 1.37146920e-01f,
  1.81997031e-01f, -7.03750253e-02f, 1.49673671e-01f, -1.26494449e-02f, -8.24485645e-02f, -4.64968309e-02f, 5.81300333e-02f, 6.52194619e-02f, 4.76204157e-02f, 1.53781697e-02f,
  1.32304370e-01f, 1.32329598e-01f, 6.09600879e-02f, 1.17528759e-01f, 1.56487003e-01f, 6.74175546e-02f, 5.24272174e-02f, -4.83571514e-02f, 5.37293367e-02f, 1.13046560e-02f,
  2.03236610e-01f, -4.11863960e-02f, -1.80007622e-01f, 2.42993027e-01f, -1.12317793e-01f, 2.96312004e-01f, 4.81248230e-01f, -1.08149759e-01f, 1.47338569e-01f, 1.55440569e-01f,
  1.65155217e-01f, -4.27840054e-02f, 1.03500307e-01f, 3.33688676e-01f, 3.11308224e-02f, 2.38563508e-01f, 2.10980698e-01f, 2.33954430e-01f, -9.15878918e-03f, 1.23345658e-01f,
  4.40358073e-02f, 1.61545500e-01f, 4.58374768e-02f, -2.20968381e-01f, 7.11595118e-02f, -2.55261898e-01f, -1.87159032e-01f, -1.42362803e-01f, -1.23020716e-01f, -3.75161767e-02f,
  7.62385949e-02f, 9.28359630e-04f, -1.85187273e-02f, -1.08528342e-02f, 2.58559324e-02f, 1.17246717e-01f, 1.50858704e-02f, -6.95255920e-02f, 3.95800062e-02f, 6.09807409e-02f,
  1.71588385e-03f, -2.28775502e-03f, -5.54315113e-02f, -7.86045417e-02f, 4.77496088e-02f, -2.22820714e-02f, -9.53418855e-03f, 3.49325053e-02f, -6.27206191e-02f, 1.00313485e-01f,
  7.91714340e-02f, -3.47709246e-02f, 9.15831029e-02f, -1.76125821e-02f, 3.64443287e-02f, 2.82964669e-02f, 2.95743253e-02f, -7.29516372e-02f, -2.48622373e-02f, 6.83334470e-02f,
  -5.43826669e-02f, 5.95588461e-02f, 1.39495790e-01f, -3.11880689e-02f, -2.60239169e-02f, -3.34477834e-02f, -6.29177913e-02f, -3.55754085e-02f, 1.75203979e-02f, 4.69541699e-02f,
  1.92109607e-02f, 1.81301981e-02f, 4.67185006e-02f, 1.93506386e-02f, 9.33177397e-02f, -4.80510443e-02f, -7.27612078e-02f, -1.10961989e-01f, 1.16901383e-01f, -8.46272800e-03f,
  -3.26016848e-03f, 4.65068258e-02f, -2.60085426e-02f, -7.45721534e-02f, 2.29085349e-02f, 1.33659709e-02f, 2.71390937e-02f, 1.10266125e-02f, 4.49291011e-03f, -2.19162144e-02f,
  -5.91779836e-02f, -4.96849455e-02f, 6.70801615e-03f, -2.87096351e-02f, -6.54044449e-02f, 1.31731614e-01f, -7.11125275e-03f, -6.42211139e-02f, 5.21826223e-02f, 9.90342423e-02f,
  -5.56543246e-02f, -5.88211119e-02f, -1.80160638e-03f, -1.68133661e-01f, -1.00751705e-01f, 8.63505900e-02f, 9.98806730e-02f, -6.20942302e-02f, -1.79978125e-02f, -1.29936948e-01f,
  -1.57510731e-02f, -2.40962077e-02f, -8.08157492e-03f, 5.83167151e-02f, 6.76829442e-02f, -4.04407904e-02f, -2.00394448e-02f, -4.24428433e-02f, -3.70918624e-02f, 5.44937178e-02f,
  3.81594151e-01f, 2.77729750e-01f, 7.87364468e-02f, 9.42761600e-02f, -1.93919376e-01f, -1.19259015e-01f, -1.81946069e-01f, 7.72325024e-02f, 1.34392917e-01f, 1.19209237e-01f,
  -9.34728161e-02f, 3.56930345e-01f, -1.57165900e-01f, 1.67724252e-01f, 1.59305021e-01f, -8.07403922e-02f, 2.11892769e-01f, 1.16251633e-01f, 4.26342674e-02f, 1.52524382e-01f,
  2.29148418e-01f, 6.35386929e-02f, 5.99282086e-02f, -5.01280390e-02f, 1.19948663e-01f, -1.37596356e-03f, -8.78590047e-02f, -1.85548872e-01f, 9.42172706e-02f, -6.25487566e-02f,
  -4.53429222e-02f, 3.92167456e-02f, -2.94712130e-02f, 5.76436818e-02f, -8.94689932e-03f, 6.33314438e-03f, -5.60558140e-02f, -1.54478595e-01f, -2.31675953e-02f, 1.30117917e-02f,
  1.68834195e-01f, 4.39801365e-02f, 8.50657672e-02f, 1.96790602e-02f, -1.50130941e-02f, 3.37907039e-02f, 1.07673705e-01f, 6.51009753e-02f, 5.20994850e-02f, 1.48202911e-01f,
  1.33445188e-01f, 1.04465090e-01f, 7.44275376e-02f, 8.04361925e-02f, 3.88000421e-02f, -3.62314135e-02f, -6.15601316e-02f, -2.05302108e-02f, 7.27489293e-02f, 1.50295705e-01f,
  1.61470592e-01f, -7.68754259e-02f, -1.16170362e-01f, -1.29223138e-01f, -2.15358846e-02f, -1.07496709e-01f, 2.11012959e-02f, -8.11588764e-02f, -3.27297598e-02f, -9.32116657e-02f,
  -1.26621842e-01f, -7.50881135e-02f, -9.80116427e-02f, 1.70466676e-02f, 3.01178358e-02f, 2.89069936e-02f, -6.44308925e-02f, 1.82965095e-03f, 2.18620542e-02f, -5.07651130e-03f,
  -4.28494960e-02f, -2.71866703e-03f, -2.67973039e-02f, -2.19627433e-02f, -1.49502277e-01f, 1.82208624e-02f, 4.34164070e-02f, 1.00187287e-01f, -5.97643033e-02f, 5.71970232e-02f,
  -4.69732238e-03f, 2.26333722e-01f, -5.73327430e-02f, -6.03489354e-02f, -7.25245550e-02f, 6.28110990e-02f, -1.83220357e-02f, 4.57891226e-02f, 1.22150041e-01f, 7.39186555e-02f,
  1.12785928e-01f, -1.15427420e-01f, -3.56771722e-02f, 2.07516756e-02f, -3.94456508e-03f, 4.89745885e-02f, 6.44472018e-02f, 1.39052502e-03f, 2.25047581e-02f, 1.16665564e-01f,
  8.19691941e-02f, 8.81347880e-02f, 1.13294050e-01f, 7.17424452e-02f, 8.24427903e-02f, 2.10263878e-02f, 3.78497615e-02f, 4.24389988e-02f, 4.75648791e-02f, 1.15453945e-02f,
  -1.87425956e-01f, -4.11853008e-02f, -2.28621155e-01f, 2.72685528e-01f, -5.59765697e-02f, 1.01777084e-01f, 2.14452505e-01f, 4.88180704e-02f, -3.84905823e-02f, 3.03602278e-01f,
  3.72307897e-01f, -4.26120348e-02f, 8.06533173e-02f, 4.64187771e-01f, 1.33238688e-01f, 2.56253749e-01f, 3.37941855e-01f, 1.52125642e-01f, -1.23556681e-01f, 8.41243044e-02f,
  3.93253639e-02f, 4.28150237e-01f, 2.69095540e-01f, 4.60500736e-03f, 8.05323198e-02f, -1.74354717e-01f, 1.18806861e-01f, -1.78140312e-01f, 2.64698803e-01f, 5.15579917e-02f,
  1.46500424e-01f, 6.73943162e-02f, -1.71355624e-02f, -2.97135953e-02f, 2.19752360e-03f, -7.35954673e-04f, 9.70103033e-03f, -7.26760104e-02f, 5.47910631e-02f, -2.75750197e-02f,
  1.63289160e-02f, 1.26095284e-02f, 2.53856573e-02f, -1.20271305e-02f, -4.37580273e-02f, 3.55827995e-02f, 1.94640122e-02f, 2.84880064e-02f, 1.66314878e-02f, 1.14669718e-01f,
  -5.45256995e-02f, 2.24945392e-03f, -6.92435503e-02f, 9.28604603e-02f, -2.74586771e-02f, -5.38602211e-02f, -1.26374047e-02f, -7.92208239e-02f, -4.29280624e-02f, -3.54376063e-02f,
  2.38931570e-02f, -4.60422076e-02f, -5.18836044e-02f, 6.16198964e-03f, -7.87837207e-02f, 3.35627720e-02f, 1.96839515e-02f, 8.18497501e-03f, -1.21262304e-01f, 6.65398017e-02f,
  5.20725958e-02f, -1.25710946e-02f, 1.36459181e-02f, 3.53399552e-02f, -3.42281833e-02f, -1.73520483e-02f, -7.63280839e-02f, 1.23730026e-01f, 3.29462695e-04f, -2.08611414e-02f,
  4.92305346e-02f, -3.21603231e-02f, -7.51168355e-02f, 1.35735869e-01f, 5.93360402e-02f, -6.99213594e-02f, 1.05870441e-01f, 1.10260181e-01f, 8.75800326e-02f, -4.93292250e-02f,
  1.29507810e-01f, 1.49682881e-02f, 4.51633986e-03f, 8.71782750e-02f, 8.03242344e-03f, -5.20975515e-02f, 8.80098995e-03f, -5.49093634e-02f, 1.07895359e-01f, -3.73625308e-02f,
  4.55104262e-02f, -2.84666885e-02f, 4.14744318e-02f, -2.79871281e-02f, 4.12290208e-02f, 1.98526904e-02f, 1.10710718e-01f, -7.20675364e-02f, 2.11538263e-02f, 2.18733549e-02f,
  9.92246047e-02f, 2.04734616e-02f, -5.23081869e-02f, -3.54168303e-02f, 8.12904090e-02f, -1.65166743e-02f, -2.03309525e-02f, -1.10856965e-01f, -1.99161097e-02f, -2.91090831e-02f,
  -3.17107923e-02f, 2.77655780e-01f, 2.44522989e-01f, 7.62292966e-02f, -1.98576808e-01f, -5.06324926e-03f, -1.09039051e-02f, 1.19896792e-01f, 4.31365520e-03f, 7.78366521e-04f,
  -6.36757612e-02f, 1.29709840e-01f, 5.42574190e-02f, 1.30820528e-01f, 2.17623875e-01f, 7.99892619e-02f, 9.30857062e-02f, 4.75808382e-02f, 3.08242161e-02f, 1.32688358e-01f,
  8.64519030e-02f, -1.76361687e-02f, 1.42847404e-01f, 4.13048128e-03f, 1.56920418e-01f, 9.07160342e-02f, -8.41012597e-02f, 6.15330301e-02f, 8.23309794e-02f, 3.13566327e-02f,
  -8.42250958e-02f, 6.97695240e-02f, -1.77636147e-02f, 8.99871662e-02f, -1.48068778e-02f, 5.61290085e-02f, 1.25824362e-01f, 1.66707970e-02f, 2.96800938e-02f, 7.17678592e-02f,
  6.95768371e-02f, 4.47086506e-02f, 1.32974714e-01f, 3.21758888e-03f, -2.50118487e-02f, 6.61939606e-02f, -1.53634138e-02f, -7.90399220e-03f, 1.27315924e-01f, 4.66637462e-02f,
  2.80807074e-02f, 1.50874451e-01f, 5.49854748e-02f, 2.00069144e-01f, 6.90606534e-02f, -7.24002868e-02f, -9.52010453e-02f, 2.31250413e-02f, 1.26265511e-01f, 1.18860759e-01f,
  1.07014716e-01f, -9.61772725e-02f, -6.61107004e-02f, -8.28258842e-02f, -3.14607774e-03f, -3.81505452e-02f, 3.85576785e-02f, -1.09551705e-01f, 6.59385473e-02f, 6.12050062e-03f,
  -4.24093567e-02f, 2.46949233e-02f, -7.60755762e-02f, 6.28202632e-02f, -6.67429045e-02f, -3.97094190e-02f, 4.91428794e-03f, 4.22783047e-02f, 1.76138002e-02f, -4.01807483e-03f,
  -9.27418619e-02f, 6.57787025e-02f, -2.26665977e-02f, -4.65291925e-02f, -5.17469570e-02f, -9.63236298e-03f, -4.05544713e-02f, 7.29778185e-02f, 1.62571203e-02f, 1.71197444e-01f,
  7.92846307e-02f, 3.62019300e-01f, 3.27521041e-02f, 1.39087409e-01f, -3.88947651e-02f, 1.19402848e-01f, 1.13946691e-01f, 1.78177699e-01f, 1.68017969e-01f, 2.28254288e-01f,
  -5.89647144e-03f, -3.13645005e-02f, -6.76539913e-02f, 6.62544146e-02f, 4.93483096e-02f, 6.93007335e-02f, -2.44250260e-02f, -8.83550663e-03f, 1.18749827e-01f, 1.47143109e-02f,
  5.65565713e-02f, 4.78979126e-02f, 1.58593401e-01f, 1.06860831e-01f, 7.19548240e-02f, -1.82724986e-02f, -1.12374246e-01f, 2.89213983e-03f, 1.26459539e-01f, 1.45548746e-01f,
  2.31036559e-01f, 1.76975250e-01f, -2.59741396e-02f, 1.23688392e-01f, -1.00221552e-01f, 5.82469068e-02f, 4.01943177e-01f, 1.46345928e-01f, 2.66152501e-01f, 3.74006294e-02f,
  -2.94378728e-01f, 2.84416914e-01f, 7.39498213e-02f, -1.96054146e-01f, 3.16999964e-02f, -1.53834209e-01f, 4.74876240e-02f, 1.25336736e-01f, 3.19058239e-01f, 1.42346118e-02f,
  -4.09015939e-02f, -8.54523107e-02f, -2.82035232e-01f, -6.30477518e-02f, 4.62965015e-03f, 3.59155983e-02f, -2.11138263e-01f, 4.22985740e-02f, -1.80978790e-01f, 3.31596546e-02f,
  -5.51801771e-02f, 9.22280326e-02f, -1.97501015e-03f, 5.80269657e-03f, -6.46113679e-02f, -7.97162391e-03f, -6.88083768e-02f, 8.77610128e-03f, 2.06276122e-02f, 8.76826569e-02f,
  1.50995865e-01f, -3.80038172e-02f, -2.81127244e-02f, -1.23419799e-01f, 8.86572450e-02f, 4.68602851e-02f, -5.25280647e-02f, -1.68092400e-01f, -2.96360668e-04f, -1.25074476e-01f,
  -7.85623565e-02f, -1.32273138e-01f, 1.33120338e-03f, -2.22497843e-02f, -2.08718143e-02f, 8.60432237e-02f, 5.67170754e-02f, -3.05044092e-02f, -9.10301581e-02f, 1.28246248e-01f,
  7.12725744e-02f, 7.93868005e-02f, -7.62932524e-02f, 3.94893624e-02f, 5.67770414e-02f, -6.61572069e-02f, -2.85647977e-02f, -7.71096274e-02f, 2.70277672e-02f, -2.34019663e-02f,
  -5.17616346e-02f, -1.49336075e-02f, -7.08188564e-02f, -1.11370943e-01f, 1.22936696e-01f, 3.00556961e-02f, -2.65845675e-02f, -5.72684072e-02f, 8.34669173e-02f, 5.32880938e-03f,
  1.06168613e-01f, 1.05179168e-01f, 5.05826101e-02f, -1.46711424e-01f, 1.01831749e-01f, 1.21822804e-02f, 2.30541769e-02f, -3.80136594e-02f, -4.50386479e-02f, 1.23297116e-02f,
  1.59154776e-02f, 8.47906396e-02f, 2.01773699e-02f, -4.92018808e-05f, 5.32422103e-02f, -3.77786979e-02f, -4.45140935e-02f, -2.04439815e-02f, 7.23230243e-02f, 1.33843333e-01f,
  -7.74958506e-02f, -3.82259525e-02f, -8.26381668e-02f, -1.01827972e-01f, 9.43350270e-02f, -6.35173693e-02f, 1.74426399e-02f, -2.58247126e-02f, 4.42734212e-02f, 3.09002809e-02f,
  -1.58685371e-01f, 1.58081837e-02f, -9.87085514e-03f, 4.50068787e-02f, -8.18957612e-02f, -9.61533561e-02f, 8.30436796e-02f, 1.62769165e-02f, -1.55443056e-02f, 9.39309448e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 78)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 78;
const float L0_fan_Bp_bar_data[] = {
  3.93070757e-01f, 2.99735457e-01f, 3.00849229e-01f, 2.34098464e-01f, 2.17603445e-01f, 3.06570530e-01f, 2.32738867e-01f, 1.56062156e-01f, 3.01375806e-01f, 2.74294138e-01f,
  1.01796679e-01f, 3.29505622e-01f, 1.44259661e-01f, 6.15284406e-02f, 3.38525355e-01f, 2.41948426e-01f, 1.69843718e-01f, 2.62457132e-01f, 1.29650071e-01f, 2.80721843e-01f,
  6.34307340e-02f, 2.67700523e-01f, 1.78226978e-01f, 3.18180591e-01f, 2.99639583e-01f, 2.35159099e-01f, 1.23972110e-01f, 1.16399899e-01f, 3.24339509e-01f, 2.71548867e-01f,
  2.04216614e-01f, 3.14496815e-01f, 2.09475994e-01f, 2.94700265e-01f, 2.15832651e-01f, 2.48042449e-01f, 1.93578973e-01f, 2.29205772e-01f, 1.04516722e-01f, 7.34913051e-02f,
  3.25535655e-01f, 1.86734736e-01f, 2.26658463e-01f, 3.00921470e-01f, 1.44179448e-01f, 1.54987320e-01f, 1.74425811e-01f, 1.46223515e-01f, 2.75780439e-01f, 2.86240995e-01f,
  7.77657479e-02f, 4.25408125e-01f, 2.80031264e-01f, 1.79775819e-01f, 2.08751842e-01f, 1.26358032e-01f, 1.37533739e-01f, 1.49120957e-01f, 2.09883809e-01f, 3.05835187e-01f,
  2.11110443e-01f, 2.94474006e-01f, 2.42191970e-01f, 2.02829227e-01f, 7.35541731e-02f, 2.48309791e-01f, 2.13755041e-01f, 2.15097129e-01f, 1.83794349e-01f, 2.02202410e-01f,
  2.78908551e-01f, 3.37023973e-01f, 2.81084955e-01f, 2.58371890e-01f, 2.79895574e-01f, 1.41481951e-01f, 1.88427344e-01f, 2.55646557e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  7.58999884e-02f, 6.79269657e-02f, 7.62883574e-02f, 2.97652986e-02f, 4.74713445e-02f, -3.62375826e-01f, -3.35936015e-03f, -2.43886635e-01f, -3.20986301e-01f, 6.84844609e-03f,
  -2.96421289e-01f, 8.96150917e-02f, 3.16586122e-02f, 5.75979613e-02f, -1.32406920e-01f, -3.56973857e-01f, -1.46126613e-01f, 1.07501082e-01f, -8.49169567e-02f, -9.78709757e-02f,
  -1.51488274e-01f, -3.52326900e-01f, -8.98446015e-04f, 5.45906201e-02f, -2.96562202e-02f, -2.48152211e-01f, 4.63277102e-02f, -7.62601644e-02f, 1.22391582e-01f, -1.96482837e-01f,
  -4.51917239e-02f, 1.01701804e-01f, 1.85026452e-01f, -2.26417273e-01f, -2.71168977e-01f, -1.04682297e-01f, 3.50453645e-01f, -2.11119026e-01f, 9.29342490e-03f, -1.77929863e-01f,
  3.19235831e-01f, -1.69757172e-01f, -7.87194595e-02f, 1.01335505e-02f, -2.04908520e-01f, 9.69666988e-02f, 2.91997612e-01f, 4.38405387e-03f, -6.14157170e-02f, -2.70757288e-01f,
  -1.67822972e-01f, 7.13861734e-02f, -3.36386830e-01f, -4.10784274e-01f, -3.11043561e-01f, 1.54016063e-01f, -1.40939787e-01f, -1.82078302e-01f, -3.49328160e-01f, -1.75907955e-01f,
  -1.75426885e-01f, 3.09310764e-01f, 4.81986761e-01f, 5.70642157e-03f, -3.81501615e-01f, 3.41200262e-01f, -1.94607720e-01f, -4.31389302e-01f, -4.16050181e-02f, -4.15381677e-02f,
  4.14309651e-01f, 3.51467311e-01f, -8.02989304e-03f, 4.45091985e-02f, 2.68176407e-01f, -2.01611385e-01f, 8.93301505e-04f, -6.85215667e-02f, -7.92874172e-02f, 2.58099020e-01f,
  -7.19391331e-02f, 2.40728021e-01f, 1.46166161e-01f, -6.45293063e-03f, 2.13452488e-01f, -1.09954692e-01f, -7.62477703e-03f, 3.72434109e-01f, 8.77885371e-02f, -2.37282395e-01f,
  -3.23247403e-01f, -2.82983750e-01f, -3.82255465e-01f, -1.48499206e-01f, 4.05431122e-01f, 6.49095252e-02f, -4.48149517e-02f, 3.58096868e-01f, 3.03061604e-01f, -3.38976443e-01f,
  1.23159744e-01f, -4.43779111e-01f, -1.13750950e-01f, -2.92163581e-01f, 1.45485505e-01f, -9.54125263e-03f, 4.44344193e-01f, -2.55569398e-01f, -2.60686129e-01f, 1.42272130e-01f,
  -1.16699159e-01f, -2.10614622e-01f, -3.41182739e-01f, -2.98574537e-01f, -4.89640497e-02f, -5.50179407e-02f, -1.85105562e-01f, -2.21056774e-01f, 4.61990267e-01f, -1.04117438e-01f,
  -3.51073116e-01f, -3.64653468e-01f, 4.85090399e-03f, 2.84421682e-01f, -4.26397771e-01f, 4.40002471e-01f, -1.25140414e-01f, -3.47913623e-01f, 2.28876218e-01f, -2.47864455e-01f,
  -2.08004355e-01f, 6.05775490e-02f, 2.57118735e-02f, 1.50521606e-01f, -8.40971470e-02f, 2.02404678e-01f, 1.05335966e-01f, -2.90265501e-01f, -1.40941173e-01f, 1.16291754e-02f,
  -6.17566407e-02f, -8.08815006e-03f, 1.62539959e-01f, 3.67566347e-02f, -2.41495315e-02f, -1.18217990e-01f, 9.73181427e-02f, 4.71529849e-02f, 1.23972826e-01f, -2.92479079e-02f,
  8.78249109e-02f, -3.15473557e-01f, -4.44506621e-03f, 9.99720693e-02f, -1.29525200e-01f, -3.93276602e-01f, -2.36331180e-01f, 3.29612464e-01f, -3.90174687e-01f, -2.77514127e-03f,
  -5.09410128e-02f, -1.39526099e-01f, 4.05164748e-01f, -3.26475888e-01f, -2.04695910e-01f, 8.14293176e-02f, 3.19512695e-01f, -3.59594703e-01f, 8.31228048e-02f, 1.04282774e-01f,
  -3.88564348e-01f, -3.22127789e-01f, -1.04251020e-01f, 4.81552184e-01f, 3.02831143e-01f, 3.18794936e-01f, -6.18110001e-02f, -7.40677342e-02f, -4.08745319e-01f, -6.66765332e-01f,
  -3.02837193e-02f, 5.10604978e-01f, -1.13881916e-01f, 2.39032343e-01f, -1.85051352e-01f, -3.12767655e-01f, -2.21882924e-01f, -1.80050537e-01f, -1.00527585e-01f, 3.92132282e-01f,
  -2.91509151e-01f, -4.07474339e-02f, 9.29435119e-02f, 1.77840248e-01f, -2.93914557e-01f, 4.11505401e-01f, 3.36545408e-01f, 1.71673119e-01f, -2.26512432e-01f, -5.78051396e-02f,
  -6.24594808e-01f, 2.87347674e-01f, -6.35284066e-01f, -3.04819252e-02f, -3.64897370e-01f, -2.18537733e-01f, 1.97676852e-01f, 3.73355150e-01f, -4.79387403e-01f, -3.88009131e-01f,
  -3.53744060e-01f, -1.79369405e-01f, 4.88295525e-01f, -6.36110678e-02f, -4.82504696e-01f, -1.96870603e-02f, -2.61549860e-01f, -1.19697250e-01f, -3.51198673e-01f, -2.10079491e-01f,
  2.26123571e-01f, 4.56491053e-01f, 1.39823437e-01f, 2.36206144e-01f, -2.56145094e-02f, -3.96092147e-01f, -3.01516920e-01f, -3.41327459e-01f, -3.94940317e-01f, -4.68304157e-01f,
  -2.78422385e-01f, -3.31209153e-01f, -2.26346582e-01f, -1.94861546e-01f, 1.35884151e-01f, -2.63656467e-01f, -7.75873438e-02f, -3.54120672e-01f, -2.84210682e-01f, -2.38909483e-01f,
  1.98208153e-01f, 1.85056835e-01f, 1.81515515e-01f, -6.82752654e-02f, -3.62069100e-01f, -1.36154133e-03f, 9.56059471e-02f, -2.78900415e-01f, 2.48615727e-01f, 6.81860298e-02f,
  1.66142896e-01f, 2.61445165e-01f, 9.83723924e-02f, 2.82677621e-01f, 1.38785793e-02f, -1.52662128e-01f, -1.15341239e-01f, -1.08500317e-01f, -5.12980372e-02f, -1.11682594e-01f,
  -2.30804875e-01f, -1.31872401e-01f, -1.08958147e-01f, -1.30745903e-01f, -2.67872890e-03f, -5.85150756e-02f, -7.24904165e-02f, -2.54993618e-01f, 2.78444383e-02f, -1.75891027e-01f,
  -9.04884264e-02f, 4.37406600e-02f, -5.12453206e-02f, -4.41982895e-02f, -1.72701433e-01f, -1.05131805e-01f, 4.58813235e-02f, -8.39314237e-02f, -2.69580036e-02f, -2.85297573e-01f,
  2.86740102e-02f, -1.38317823e-01f, 2.17229769e-01f, 2.45067939e-01f, -1.79130897e-01f, -3.01227242e-01f, 1.95481762e-01f, 8.91381204e-02f, 4.60316688e-02f, -4.49507125e-02f,
  3.20115462e-02f, 9.69917700e-02f, 1.74909234e-01f, 1.23636849e-01f, -3.01037759e-01f, 1.72378704e-01f, -1.10088266e-01f, -1.84113100e-01f, -1.02355435e-01f, -1.47465110e-01f,
  6.00854531e-02f, -2.06825539e-01f, -3.27921450e-01f, 4.76056561e-02f, -8.56667981e-02f, -1.23004042e-01f, 1.88575312e-02f, -8.78317375e-03f, 1.86560065e-01f, 3.33809823e-01f,
  -1.46808490e-01f, -3.01378280e-01f, -2.68482000e-01f, 4.07523394e-01f, -2.35545039e-01f, -9.01275426e-02f, 2.01100588e-01f, -6.27197102e-02f, -4.25661169e-02f, -1.78636134e-01f,
  -3.15333039e-01f, -7.10092783e-02f, 4.96119589e-01f, 1.14510179e-01f, -9.42460150e-02f, 3.55824441e-01f, -1.74036726e-01f, -4.16945994e-01f, -2.79093236e-01f, -1.34234786e-01f,
  -1.62626073e-01f, -2.90125191e-01f, 3.12342674e-01f, 5.25607646e-01f, 3.93910021e-01f, -3.21771473e-01f, 2.65276223e-01f, -7.36865029e-02f, -1.07288755e-01f, -5.10477901e-01f,
  -7.83022568e-02f, -1.70267060e-01f, -8.04299861e-02f, -1.79516524e-01f, -1.13340668e-01f, -1.26670599e-01f, -2.21883833e-01f, -8.32757503e-02f, 3.06363016e-01f, 2.49109372e-01f,
  -2.55152911e-01f, -2.52773046e-01f, 2.15182260e-01f, -1.69060156e-01f, -1.06509894e-01f, -1.26796484e-01f, 6.37387857e-03f, -2.51654148e-01f, 4.29805294e-02f, -7.64039978e-02f,
  1.62574165e-02f, -2.40851372e-01f, 4.20626402e-01f, -5.64625412e-02f, 3.16212237e-01f, -2.53875911e-01f, 1.77441955e-01f, -2.63658851e-01f, -4.17593479e-01f, 2.49236465e-01f,
  -3.10341239e-01f, -1.10137060e-01f, -2.93808013e-01f, 2.89598316e-01f, -3.05048943e-01f, -1.79778308e-01f, -1.03007250e-01f, -1.38065636e-01f, -2.55536020e-01f, -2.91670442e-01f,
  -1.25360653e-01f, 1.44752964e-01f, -2.72153258e-01f, -3.44677746e-01f, -4.45622578e-02f, -1.47768743e-02f, -2.09719911e-01f, -2.39617437e-01f, -1.92230150e-01f, -6.57471940e-02f,
  -3.45458061e-01f, 3.35055403e-02f, 4.29735743e-02f, -1.64997622e-01f, 5.76847345e-02f, 9.70459729e-02f, 6.61634877e-02f, -7.71784931e-02f, -2.21596332e-03f, 5.35948873e-02f,
  -8.15280825e-02f, 1.38940901e-01f, -2.85187364e-01f, -2.20207050e-01f, -1.48080543e-01f, -1.61893576e-01f, -6.20847233e-02f, -1.25069484e-01f, 2.54055299e-02f, -1.47484876e-02f,
  -1.35396391e-01f, 1.10899590e-01f, -2.10028976e-01f, 8.66423771e-02f, -1.46992743e-01f, 1.28091395e-01f, 3.31910998e-01f, 5.61776124e-02f, -3.58886868e-01f, 4.48111221e-02f,
  -1.30378082e-01f, -2.33890027e-01f, -1.90510303e-01f, 3.60595621e-02f, -2.03783989e-01f, -2.13962346e-01f, 2.18802974e-01f, 1.97288990e-01f, 2.74236023e-01f, 8.74423012e-02f,
  2.40422770e-01f, 2.22723886e-01f, 1.71520397e-01f, 2.53832191e-01f, -3.25390428e-01f, 2.98731834e-01f, -3.25527996e-01f, -4.96978462e-01f, 3.52166384e-01f, -3.81906450e-01f,
  -3.58624786e-01f, -2.51455784e-01f, 3.51666868e-01f, 3.40238899e-01f, -5.34440577e-01f, -3.86134982e-02f, 2.77814507e-01f, 8.64109490e-03f, -4.88683403e-01f, -2.53264219e-01f,
  -2.69009322e-01f, -1.04501821e-01f, 9.10040215e-02f, -2.00175390e-01f, 2.50388414e-01f, 5.09904742e-01f, -1.50562441e-02f, 2.72051066e-01f, -5.96986748e-02f, -3.37557286e-01f,
  -5.37712090e-02f, -1.54368505e-01f, -5.21816202e-02f, 1.70622259e-01f, -1.58749014e-01f, -4.66405094e-01f, 1.47362053e-01f, -1.45887658e-01f, 6.70987368e-02f, 3.10445607e-01f,
  4.66266304e-01f, -2.65567929e-01f, -1.62472740e-01f, 6.92870438e-01f, -4.11851227e-01f, -2.45851725e-01f, -1.10626362e-01f, -1.11865826e-01f, -2.84700245e-01f, -5.59422448e-02f,
  -2.19647184e-01f, -1.48147225e-01f, 3.41437131e-01f, -7.36917406e-02f, 5.07951677e-01f, -2.36387774e-02f, 4.57994819e-01f, -1.93300799e-01f, -5.10619938e-01f, -6.72408715e-02f,
  -1.95236012e-01f, 4.46826220e-01f, -1.87807932e-01f, 1.36761874e-01f, -1.87388912e-01f, -5.99289834e-01f, -2.47651443e-01f, -1.10635974e-01f, 3.83916587e-01f, -3.85297388e-01f,
  -3.86978723e-02f, -8.15478563e-02f, 4.19586450e-01f, -5.36939353e-02f, -4.17425066e-01f, 2.09530637e-01f, -3.41514379e-01f, -2.59578764e-01f, -2.67108798e-01f, -3.75059247e-02f,
  -9.95855406e-02f, 3.45032901e-01f, 9.68928039e-02f, -7.59504139e-02f, -2.38224968e-01f, 2.31803030e-01f, 4.23054099e-02f, 2.19321270e-02f, -1.05090007e-01f, -4.93095368e-02f,
  1.57397076e-01f, -3.98557223e-02f, 5.63119240e-02f, -2.67954201e-01f, 8.41584355e-02f, 9.16817561e-02f, 1.82018019e-02f, 2.14765131e-01f, 1.38545305e-01f, -1.92379698e-01f,
  1.24225728e-01f, 4.16394889e-01f, -2.62979846e-02f, 2.21891716e-01f, 1.51484180e-02f, 1.34759620e-01f, 7.59321079e-02f, 1.69933155e-01f, 3.30539107e-01f, 4.40398753e-02f,
  1.91245191e-02f, 1.86577216e-02f, -3.20111215e-01f, 4.36070263e-01f, -1.78112984e-01f, -2.52263434e-02f, -5.21471025e-03f, -3.27407211e-01f, 3.93605195e-02f, 4.19998109e-01f,
  -2.63743222e-01f, -2.32623473e-01f, -3.11186872e-02f, 2.10265577e-01f, -1.19886376e-01f, -4.48744707e-02f, -1.23540595e-01f, -2.57393837e-01f, 5.21402583e-02f, 1.54180259e-01f,
  4.53203708e-01f, 3.13566923e-01f, -1.85251445e-01f, 6.26233071e-02f, -3.95372033e-01f, -1.37924954e-01f, 4.83554095e-01f, 2.67041445e-01f, 2.17710361e-01f, 1.92444790e-02f,
  -1.64680704e-01f, 2.24889874e-01f, -2.49062866e-01f, 4.04163778e-01f, 2.74743110e-01f, -1.23882763e-01f, 9.42731276e-03f, -4.23161060e-01f, -3.27030160e-02f, -2.42478773e-01f,
  6.58848733e-02f, 3.31883520e-01f, -2.78274775e-01f, -4.10920501e-01f, -3.98373827e-02f, 6.11270852e-02f, 3.63016486e-01f, -7.14685470e-02f, -2.05233768e-01f, 2.68701047e-01f,
  -6.14974380e-01f, -1.93155557e-01f, -1.00338079e-01f, 4.58149374e-01f, 2.67081231e-01f, -3.32795203e-01f, -8.72953236e-02f, -2.10368142e-01f, -2.16204226e-01f, 4.23753858e-01f,
  -1.67006865e-01f, -1.18714914e-01f, -1.11947812e-01f, 1.50488764e-01f, -7.12817237e-02f, -5.71760535e-01f, -2.72613913e-01f, 2.70362347e-01f, -2.32114449e-01f, 4.75848168e-01f,
  2.35938087e-01f, 1.40203401e-01f, 2.74484783e-01f, 4.36708629e-01f, -2.42691442e-01f, 3.04133505e-01f, -2.17407450e-01f, -1.38492033e-01f, -2.14722738e-01f, 3.08089167e-01f,
  2.45933339e-01f, -2.88210988e-01f, -4.31237221e-01f, 2.75876790e-01f, -3.97915170e-02f, -1.45970270e-01f, -4.13364202e-01f, 1.19315930e-01f, -1.75505150e-02f, -3.31354827e-01f,
  2.30132099e-02f, 1.92099452e-01f, 4.10612494e-01f, -1.15521729e-01f, -4.25915241e-01f, -3.69087338e-01f, -1.57116637e-01f, -3.33040446e-01f, 2.02485889e-01f, -2.05915198e-01f,
  -2.99794465e-01f, 3.29237461e-01f, 1.32117957e-01f, -5.61277149e-03f, 3.86610925e-02f, 9.28244740e-02f, 2.79248893e-01f, 2.25052759e-01f, 7.85735399e-02f, 2.90035337e-01f,
  1.51217088e-01f, 1.77039683e-01f, -5.91147505e-03f, -2.71827150e-02f, 1.53339252e-01f, -6.22404777e-02f, 1.77531019e-01f, 5.95325083e-02f, 1.49927586e-01f, -1.13286458e-01f,
  1.54052719e-01f, 1.27531275e-01f, 1.13193202e-03f, 1.83739707e-01f, 1.68847516e-02f, 3.39939952e-01f, 1.30332828e-01f, -2.56660700e-01f, 3.11983496e-01f, 3.81467611e-01f,
  -1.38725430e-01f, -8.12553614e-02f, -1.06316894e-01f, 9.87856090e-02f, 7.24816462e-03f, -2.58000672e-01f, -2.37584352e-01f, -1.66022986e-01f, 2.63444453e-01f, -2.29874086e-02f,
  3.33504289e-01f, 2.25233082e-02f, 4.51010555e-01f, 1.02523535e-01f, -2.96716362e-01f, -4.16561402e-02f, -1.04381062e-01f, -3.04374844e-02f, -5.27698636e-01f, 2.57012039e-01f,
  1.16791993e-01f, -1.10569984e-01f, 2.48237044e-01f, -5.95828950e-01f, -3.94813120e-01f, -7.99570903e-02f, -1.17675625e-01f, -1.71093017e-01f, 2.73344547e-01f, -5.38334787e-01f,
  -7.22629949e-02f, -2.60570019e-01f, -2.51366913e-01f, -2.47394130e-01f, 3.35205466e-01f, 3.98011118e-01f, -1.04292510e-02f, -1.06018260e-01f, -3.64766955e-01f, -4.04921025e-01f,
  2.06535105e-02f, -4.00724322e-01f, 1.52367160e-01f, 2.84181833e-01f, 1.20321207e-01f, 2.04281613e-01f, -7.49579668e-02f, 1.51967093e-01f, -1.58137903e-01f, 2.58749366e-01f,
  -1.18624538e-01f, 2.51939505e-01f, -4.47280146e-02f, -4.45890665e-01f, -6.49383962e-01f, -6.40964746e-01f, -1.22192048e-01f, 6.07340410e-03f, 4.07625675e-01f, 2.63769031e-01f,
  3.11797380e-01f, -5.09175539e-01f, -3.04710984e-01f, -1.76863238e-01f, 3.98211330e-01f, -4.12939787e-01f, -2.87431508e-01f, -2.67216951e-01f, -2.51506194e-02f, 8.71802047e-02f,
  -1.87737525e-01f, 4.27879095e-01f, -2.12889597e-01f, 2.66514927e-01f, 1.70878991e-01f, 2.83128709e-01f, -3.48593473e-01f, -1.65801927e-01f, -3.59818488e-01f, -2.94199377e-01f,
  -2.12333918e-01f, 3.72751445e-01f, -1.36846468e-01f, 1.11759059e-01f, -1.46783173e-01f, 2.98625231e-01f, -6.54241294e-02f, 1.60850510e-02f, -3.02066743e-01f, -3.89099032e-01f,
  -3.53355765e-01f, -4.09688354e-01f, 2.07020000e-01f, 1.53975070e-01f, 2.06490591e-01f, -2.33114272e-01f, 2.16987699e-01f, 4.41428095e-01f, 6.86547905e-03f, -1.45574495e-01f,
  -1.86032020e-02f, 1.90713450e-01f, 4.14549969e-02f, -1.24797389e-01f, -1.22760318e-01f, 6.58022687e-02f, 2.03470178e-02f, 4.15638797e-02f, -1.30823523e-01f, 6.16840720e-02f,
  1.35203507e-02f, 1.07831761e-01f, -2.76863854e-02f, 1.68643758e-01f, 4.97368984e-02f, 3.57826576e-02f, -1.60226852e-01f, -1.10702075e-01f, -1.64129317e-01f, -1.43329501e-01f,
  -1.18017040e-01f, 2.26684641e-02f, 8.73176977e-02f, -6.48243055e-02f, 1.25820190e-01f, 3.61228555e-01f, -1.34746674e-02f, -2.14177907e-01f, 3.11224669e-01f, -8.40148404e-02f,
  9.71288085e-02f, 2.51612216e-01f, 9.66216102e-02f, 6.88631088e-02f, -1.34024501e-01f, 3.35457861e-01f, 6.03080690e-02f, -7.48027191e-02f, -3.15924257e-01f, -1.01809904e-01f,
  1.36037380e-01f, -2.71419942e-01f, 1.11181036e-01f, -2.22613305e-01f, 6.28423616e-02f, -4.54200536e-01f, -6.03219420e-02f, 2.13026315e-01f, 4.80570406e-01f, -3.14853370e-01f,
  -4.51582611e-01f, -4.02759582e-01f, -1.09693617e-01f, -2.88856804e-01f, 2.08740115e-01f, -1.84934795e-01f, 4.70523000e-01f, -3.46269161e-01f, -2.13776220e-05f, -5.66076756e-01f,
  -2.26675987e-01f, -2.03608070e-02f, 2.70989567e-01f, -9.71927419e-02f, -3.81733567e-01f, 1.34326980e-01f, 6.95893019e-02f, -3.26408863e-01f, -1.62200302e-01f, -1.67715997e-01f,
  4.87213820e-01f, -3.86236399e-01f, -5.78209519e-01f, -4.53911185e-01f, 3.77094150e-01f, -2.61175305e-01f, 3.50993842e-01f, -3.14513862e-01f, -3.33280236e-01f, -3.82971674e-01f,
  -1.97894946e-01f, 2.05899104e-01f, -2.08828241e-01f, 2.35307798e-01f, 4.04131189e-02f, -4.05927718e-01f, -2.93997645e-01f, -1.59439176e-01f, 3.27775955e-01f, 2.35259801e-01f,
  2.46427685e-01f, 3.22227538e-01f, -1.49927780e-01f, -4.56072569e-01f, 2.12739527e-01f, -1.98184654e-01f, -2.78762788e-01f, -1.92827918e-02f, 9.90979746e-02f, -4.01285887e-01f,
  -1.48879409e-01f, 2.61411369e-01f, -3.15270633e-01f, 2.53824562e-01f, -6.01802766e-01f, -7.66595602e-02f, 2.51760930e-01f, 7.43544176e-02f, 1.09050997e-01f, 2.05428764e-01f,
  3.94068331e-01f, -1.66789845e-01f, -1.24731004e-01f, -1.23711444e-01f, -4.20696467e-01f, 2.19476968e-01f, -3.58586125e-02f, 4.04721171e-01f, 4.67060544e-02f, -3.87271285e-01f,
  -1.92297176e-01f, 2.22688168e-01f, -6.95769116e-03f, -2.39899516e-01f, -3.16631764e-01f, 1.65214747e-01f, -9.89959538e-02f, 1.02040805e-01f, -1.15100503e-01f, 5.86034730e-02f,
  -1.10079922e-01f, -7.40663856e-02f, 6.78824559e-02f, -2.28979021e-01f, -1.14433579e-01f, -2.21421756e-02f, -3.47580910e-02f, -2.22802192e-01f, -3.25918585e-01f, -1.21681534e-01f,
  -7.45192468e-02f, -2.72482008e-01f, 2.70035155e-02f, -1.69597074e-01f, 7.09693432e-02f, 3.50132324e-02f, 3.78115773e-02f, 3.14489529e-02f, 3.87659147e-02f, -2.16632441e-01f,
  -1.93474472e-01f, 1.00610718e-01f, -2.94224788e-02f, 1.35938674e-01f, -2.81232572e-03f, -1.94461331e-01f, 2.99855292e-01f, -1.99491397e-01f, 1.05578884e-01f, -2.07774654e-01f,
  -1.33607954e-01f, 1.22042663e-01f, 1.07252494e-01f, -1.35440856e-01f, -2.50930279e-01f, 2.14704141e-01f, -1.53892010e-01f, 1.33396849e-01f, -6.32427335e-02f, 7.13320076e-02f,
  4.41349708e-02f, -4.69694212e-02f, -1.12516135e-01f, -1.01759918e-01f, 5.13181165e-02f, 1.20158546e-01f, -1.60530791e-01f, 9.11387056e-02f, -7.99951926e-02f, -9.98753011e-02f,
  -3.94158624e-02f, -1.90994874e-01f, -2.47055426e-01f, 3.17222625e-02f, -7.49742910e-02f, 3.74925554e-01f, -1.30277202e-01f, -3.32166672e-01f, -2.25241438e-01f, 4.73319441e-01f,
  -1.39112443e-01f, -1.63143799e-01f, -7.59409592e-02f, -1.23641275e-01f, -9.16771144e-02f, -2.33821511e-01f, 3.33779544e-01f, -2.42220253e-01f, -1.05834506e-01f, -2.99721926e-01f,
  2.35220477e-01f, 2.88652390e-01f, -4.94263619e-02f, -5.91357909e-02f, -2.14731246e-01f, -1.34262204e-01f, 6.50725365e-02f, -1.48723379e-01f, 4.12386924e-01f, -1.32756278e-01f,
  -2.31520012e-01f, -4.96898331e-02f, 1.27286106e-01f, -2.20189467e-01f, -6.60460070e-02f, -1.71753883e-01f, 9.47855040e-02f, 7.20559657e-02f, -1.09046064e-01f, -2.62125850e-01f,
  -1.23493373e-01f, 1.37018800e-01f, 6.80773631e-02f, -2.18315855e-01f, -2.63060033e-01f, 2.63517469e-01f, -4.14689928e-02f, 3.80901575e-01f, 1.07351234e-02f, -9.85841602e-02f,
  4.28750902e-01f, 4.08248633e-01f, -1.36857599e-01f, -5.76833487e-02f, -1.91092730e-01f, 5.22513390e-02f, -2.04224244e-01f, 1.59745187e-01f, -5.12213213e-03f, 1.68257371e-01f,
  4.25742239e-01f, -1.63015053e-01f, 1.51581481e-01f, -1.99361280e-01f, -1.90707937e-01f, -9.88328457e-02f, -1.87383294e-01f, 1.30736083e-01f, -1.90495849e-01f, -1.55118853e-01f,
  9.39911157e-02f, -2.16098338e-01f, -1.94859400e-01f, 1.67743508e-02f, -1.27461385e-02f, 1.26295537e-01f, -2.21779738e-02f, -2.03103065e-01f, -3.79419923e-02f, 4.61766571e-02f,
  -1.59364641e-01f, -7.31616318e-02f, 5.38244657e-02f, 4.97162417e-02f, 4.97082472e-02f, -1.93554640e-01f, 7.99234807e-02f, -1.62667762e-02f, 1.76725779e-02f, -1.30995303e-01f,
  -2.28352025e-01f, -6.72622323e-02f, -9.77965817e-02f, -4.52307379e-03f, -1.26965284e-01f, -7.23660067e-02f, -2.30993986e-01f, -5.47086298e-02f, -2.05707163e-01f, -2.23141909e-02f,
  -1.64586604e-01f, -3.67771205e-03f, 2.93555647e-01f, -7.14654773e-02f, 2.53788918e-01f, -2.24903718e-01f, -2.20173210e-01f, 1.52344868e-01f, -1.46750972e-01f, 1.40119299e-01f,
  2.77191252e-01f, 1.00352727e-01f, -1.59349069e-01f, 2.19261095e-01f, 8.00273716e-02f, 2.53504694e-01f, 3.17902416e-02f, 2.78848559e-01f, 1.72332317e-01f, 4.12673503e-02f,
  -1.73903883e-01f, -1.93993583e-01f, -2.49178693e-01f, -2.00257391e-01f, -2.46680900e-01f, -2.66634077e-01f, 2.37365410e-01f, -8.55821073e-02f, -1.85535550e-01f, -2.30711505e-01f,
  -1.65759280e-01f, 4.13491815e-01f, -1.68610021e-01f, -8.11305866e-02f, 5.00686839e-02f, -2.03058720e-01f, 2.12266788e-01f, -1.24071382e-01f, -1.95828468e-01f, 6.03391007e-02f,
  -1.98754236e-01f, 7.51012042e-02f, 2.52139032e-01f, -3.84802729e-01f, -2.32580557e-01f, 2.56297201e-01f, 3.11453432e-01f, -2.40079403e-01f, -1.76706575e-02f, -3.34447250e-02f,
  3.39366794e-01f, -2.19586357e-01f, -4.10261512e-01f, -2.25454524e-01f, -9.45063308e-02f, -4.42804433e-02f, 2.57438724e-03f, 1.60557717e-01f, -2.05962926e-01f, -6.44248277e-02f,
  -2.58535445e-01f, -1.92135647e-01f, 3.91984522e-01f, -1.08311092e-02f, -1.93470687e-01f, -4.79289889e-02f, 3.33555758e-01f, -2.49710262e-01f, -2.72212457e-02f, -3.37737589e-03f,
  3.26933831e-01f, -6.06528036e-02f, -2.28389949e-01f, -2.38068253e-01f, -7.70653784e-02f, 5.41025959e-03f, 2.86662281e-01f, 3.37090045e-01f, -2.04352081e-01f, -2.99984455e-01f,
  -1.66373745e-01f, -9.15420055e-02f, -1.64511949e-01f, 1.19213089e-01f, -1.60290763e-01f, -1.79775715e-01f, -2.47217506e-01f, 1.79628745e-01f, 8.18817988e-02f, -2.08215743e-01f,
  4.10190701e-01f, 1.82583146e-02f, 6.91335350e-02f, -1.78162098e-01f, 3.43378454e-01f, -2.85596371e-01f, 2.35097125e-01f, -2.22682461e-01f, 3.31356943e-01f, 1.82079703e-01f,
  2.89448440e-01f, -1.69652641e-01f, -2.33377200e-02f, -9.72434282e-02f, -1.95225738e-02f, -1.64141282e-01f, -1.50156647e-01f, 1.20081365e-01f, 9.78209525e-02f, -8.15873817e-02f,
  1.30865276e-01f, -8.94184336e-02f, 7.73234665e-02f, 1.53665587e-01f, 1.04268529e-01f, 6.46833554e-02f, -1.32204816e-02f, -3.11420355e-02f, 6.17102208e-03f, 2.30637062e-02f,
  -1.21810615e-01f, 1.53308764e-01f, -1.38345771e-02f, 5.78827672e-02f, -2.62047350e-02f, 1.97698027e-01f, 1.36073083e-01f, 7.63261179e-03f, 1.01789035e-01f, -3.25839013e-01f,
  2.71435469e-01f, -3.29047412e-01f, 8.89982805e-02f, -3.59712511e-01f, 2.95619726e-01f, -1.77365243e-01f, 2.41526470e-01f, 2.23070860e-01f, -5.31703122e-02f, -4.36445951e-01f,
  1.32809341e-01f, 2.75332838e-01f, -3.29676658e-01f, -1.12332039e-01f, 2.13263541e-01f, -6.66777343e-02f, -2.76325107e-01f, -2.29709446e-01f, -4.80119921e-02f, 2.51752496e-01f,
  8.25584773e-03f, -1.82278320e-01f, 1.00645535e-01f, -3.88994336e-01f, -1.32635862e-01f, -2.49149874e-01f, -2.45499089e-01f, -4.06944007e-02f, -2.13914365e-01f, -2.43626088e-01f,
  -5.91155708e-01f, -1.15652137e-01f, -1.81637108e-01f, 1.83765367e-01f, -3.10393035e-01f, -6.00247309e-02f, -2.36923918e-01f, -5.67229152e-01f, 4.42377537e-01f, -2.64970656e-03f,
  -2.69116253e-01f, 2.12201774e-01f, -2.33198896e-01f, -1.14516333e-01f, -2.95130372e-01f, -3.66400540e-01f, 4.03460145e-01f, 4.35204618e-02f, -4.28649992e-01f, -2.45464146e-02f,
  2.58845203e-02f, -2.85593510e-01f, 5.66596746e-01f, 2.22383365e-01f, -3.30926001e-01f, 4.20862079e-01f, -2.71621138e-01f, -1.62294105e-01f, -2.78853893e-01f, -2.02349260e-01f,
  5.67023270e-02f, -1.04361929e-01f, 2.68643469e-01f, 5.16587138e-01f, -4.94676799e-01f, 6.28535002e-02f, -3.54137331e-01f, 3.62359166e-01f, -4.59316075e-01f, 1.78056136e-01f,
  -2.91350842e-01f, -2.65572704e-02f, -3.12602460e-01f, 3.33436847e-01f, -2.93894082e-01f, -4.04122144e-01f, 3.64318132e-01f, -1.85943484e-01f, 2.90370911e-01f, -3.71473372e-01f,
  1.41752616e-01f, -2.42872640e-01f, 2.59777725e-01f, 8.32931474e-02f, 3.70056480e-01f, -4.49998260e-01f, -8.89697149e-02f, -3.51120323e-01f, 5.46955705e-01f, 1.03356555e-01f,
  -1.71749368e-01f, 2.70586371e-01f, -3.89412969e-01f, 2.41881520e-01f, -2.71083772e-01f, 6.45950362e-02f, -3.66234571e-01f, -1.34605333e-01f, 8.12149718e-02f, -4.38674577e-02f,
  1.23794243e-01f, -1.18831538e-01f, 2.93576688e-01f, 8.94582197e-02f, 5.17796353e-02f, 2.20817029e-01f, 2.52973646e-01f, 1.20865382e-01f, 1.38228163e-01f, 1.86563373e-01f,
  -1.14897214e-01f, 9.78101343e-02f, 1.57622725e-01f, 2.66906410e-01f, 6.81276470e-02f, 7.41383135e-02f, -8.71701837e-02f, 1.63455814e-01f, 1.28415883e-01f, -2.12699994e-01f,
  1.69706017e-01f, 2.01159403e-01f, -3.34907174e-02f, 1.96354777e-01f, 1.58079028e-01f, -1.76039368e-01f, -3.45683545e-01f, -2.52363175e-01f, -1.92748219e-01f, 3.20977956e-01f,
  1.16111122e-01f, 5.98454028e-02f, -2.97802806e-01f, -4.17015776e-02f, 2.87426949e-01f, 4.14375186e-01f, 1.83086783e-01f, 1.24975317e-03f, -1.44630775e-01f, -2.23583549e-01f,
  -5.43573610e-02f, 5.68587743e-02f, -1.65676419e-02f, 1.77536488e-01f, 3.19268823e-01f, 1.98374838e-01f, -5.85349426e-02f, 8.89589936e-02f, 2.48209506e-01f, -3.92253026e-02f,
  -3.34979862e-01f, 4.40449655e-01f, -3.98650132e-02f, 3.06454480e-01f, -7.94988591e-03f, 4.16647911e-01f, -1.77395672e-01f, 2.56031960e-01f, 3.65032367e-02f, -2.42258370e-01f,
  5.18068373e-01f, -3.67029846e-01f, -3.24649334e-01f, -2.59145528e-01f, -3.29001397e-02f, -1.12033986e-01f, 3.02458525e-01f, -2.95160472e-01f, -4.12684262e-01f, -1.21139482e-01f,
  -3.48695248e-01f, 1.91764608e-01f, -2.77921140e-01f, 8.57089907e-02f, -1.99720040e-01f, 4.03248638e-01f, -1.67003527e-01f, -2.52520621e-01f, -3.89408976e-01f, -4.92307059e-02f,
  -3.43038365e-02f, -2.55295664e-01f, -6.02225885e-02f, -1.87308431e-01f, 3.62773627e-01f, -3.92725527e-01f, 3.74460429e-01f, -2.05364488e-02f, -1.87798947e-01f, -1.81627437e-01f,
  -8.08359087e-02f, -1.80449367e-01f, -3.65400523e-01f, -1.88799888e-01f, -2.00554296e-01f, -4.08310384e-01f, -2.34526303e-02f, -3.07870626e-01f, -2.78737426e-01f, -2.65221685e-01f,
  -3.44859302e-01f, -1.70476720e-01f, -2.17472449e-01f, -1.91959679e-01f, -1.94002181e-01f, -2.32245594e-01f, -9.59136039e-02f, -2.79583275e-01f, -3.43059808e-01f, 3.21622252e-01f,
  4.73592401e-01f, -8.86659250e-02f, -2.56544143e-01f, -3.04577261e-01f, -3.27904701e-01f, -1.05643153e-01f, 6.00137599e-02f, -2.32726172e-01f, -4.38683294e-02f, -1.24542713e-01f,
  2.92949587e-01f, 3.96970272e-01f, 1.33431060e-02f, -2.97158390e-01f, -4.12011325e-01f, -3.65921676e-01f, -3.14812601e-01f, -2.43300334e-01f, 3.68527211e-02f, 3.05519383e-02f,
  3.67670059e-02f, 1.15567528e-01f, 1.59095794e-01f, 7.08225444e-02f, 7.44905695e-02f, -8.57538059e-02f, -1.24731474e-01f, 8.05394053e-02f, 4.52594161e-02f, 1.43205076e-01f,
  -1.21621042e-01f, -3.87938507e-02f, -1.20969601e-02f, 2.96362024e-02f, 1.23360679e-01f, -1.19054150e-02f, -7.21818432e-02f, 1.52111337e-01f, 1.94601625e-01f, 8.55551064e-02f,
  -7.50585422e-02f, -3.55448052e-02f, -6.90459386e-02f, -1.01678446e-01f, -2.00204462e-01f, 1.51483238e-01f, -1.22376740e-01f, -4.72985730e-02f, 8.09775293e-02f, 1.36852562e-01f,
  -2.09483162e-01f, 2.16306627e-01f, -1.81501150e-01f, -1.56929851e-01f, -2.24166274e-01f, 8.45253319e-02f, 2.41642863e-01f, 1.41565427e-01f, 2.44686708e-01f, -1.07337557e-01f,
  -1.74826339e-01f, 1.95012569e-01f, -1.63251936e-01f, 3.96523811e-02f, -2.08922789e-01f, -1.65053457e-01f, 2.02660725e-01f, -2.19071135e-01f, 4.44394886e-01f, -1.71852767e-01f,
  5.58399200e-01f, -1.12866171e-01f, -8.86443034e-02f, -3.41630548e-01f, 4.28647310e-01f, -3.34906340e-01f, -4.56367284e-02f, 2.67397702e-01f, -1.86509550e-01f, -2.72227168e-01f,
  -1.43421888e-01f, 5.16351126e-02f, 2.77573317e-01f, -2.49638572e-01f, -1.81917548e-01f, -2.27577507e-01f, -2.27729693e-01f, -2.14270234e-01f, -1.34825170e-01f, -2.43360028e-01f,
  7.30212182e-02f, -1.65205426e-03f, -3.73685837e-01f, -3.23079109e-01f, -3.64422590e-01f, 3.12233008e-02f, -2.81902015e-01f, -1.61032990e-01f, -6.58997893e-02f, 4.43940684e-02f,
  -2.26996675e-01f, 3.98995668e-01f, -4.03173208e-01f, 5.35879493e-01f, -4.30835456e-01f, 7.89555237e-02f, 8.89844671e-02f, -8.94436762e-02f, -1.91108793e-01f, -1.28071547e-01f,
  -2.48198956e-01f, -2.46623829e-01f, -2.81335026e-01f, -2.59488940e-01f, -1.88636094e-01f, -1.22403845e-01f, 4.12630409e-01f, 3.99852335e-01f, -1.33382291e-01f, -2.66807288e-01f,
  4.36073065e-01f, -3.55595708e-01f, -9.94836167e-02f, -2.54042596e-01f, -1.20938763e-01f, -4.56699766e-02f, -1.86234742e-01f, 3.42494786e-01f, 3.97934616e-02f, -3.96492779e-01f,
  -9.83773395e-02f, -1.97930425e-01f, -1.68507591e-01f, 3.82764161e-01f, -2.13153914e-01f, -2.19622388e-01f, -1.28996104e-01f, -2.15010986e-01f, -2.10766479e-01f, 3.26183647e-01f,
  1.73865214e-01f, -1.32985249e-01f, 2.96181411e-01f, -2.35926718e-01f, 1.32150933e-01f, 2.07622185e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.24481295e-02f, -1.65997129e-02f, -2.47442164e-02f, -2.29488686e-02f, 2.08612084e-02f, 3.60470731e-03f, -6.70247450e-02f, -2.88722329e-02f, -1.01459749e-01f, 3.22213806e-02f,
  8.50140974e-02f, -3.53920623e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 78
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    