/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.20723896e-01f, 2.55710751e-01f, 1.98282763e-01f, 1.25598222e-01f, -6.27930164e-02f, -2.86551386e-01f, -9.68408808e-02f, 9.95063856e-02f, 1.00721769e-01f, -4.62362431e-02f,
  -1.64581224e-01f, 1.06213033e-01f, -5.42048290e-02f, 2.74207033e-02f, -8.84725824e-02f, 2.46267244e-02f, -6.39583617e-02f, -3.09559312e-02f, 1.34681597e-01f, -6.48443773e-02f,
  3.19223367e-02f, -1.77175432e-01f, 3.23943421e-02f, -1.83580015e-02f, 2.28440315e-02f, 5.86365759e-02f, -6.03939965e-02f, 1.15646333e-01f, -7.65473172e-02f, -9.89737958e-02f,
  -6.01052120e-02f, 1.29964530e-01f, 6.90766647e-02f, -2.74490621e-02f, -1.25102282e-01f, -8.72694924e-02f, 3.38359550e-03f, 1.77444983e-02f, 5.25038354e-02f, -5.11899218e-02f,
  -7.83205684e-03f, 3.84396687e-02f, 1.21831438e-02f, 7.52588660e-02f, 4.94806208e-02f, 6.92932755e-02f, -3.19463015e-02f, 1.14054149e-02f, -2.13651825e-02f, -2.37695295e-02f,
  -7.34428763e-02f, -1.18904680e-01f, 6.93563744e-02f, -5.46897426e-02f, 1.15974909e-02f, 6.59088558e-03f, 6.05812110e-03f, -4.96555455e-02f, -6.98317513e-02f, 2.04242737e-04f,
  -3.28905880e-02f, -2.53851190e-02f, -5.78126833e-02f, -4.76826802e-02f, -4.83144373e-02f, -2.32373755e-02f, 4.94786501e-02f, -7.23776892e-02f, -2.83898488e-02f, 4.80157398e-02f,
  -9.49897468e-02f, 2.07216223e-03f, 4.00082693e-02f, 7.59151182e-04f, -6.77998886e-02f, 5.64413220e-02f, 3.26517746e-02f, -5.26885390e-02f, -4.82141711e-02f, -7.76549354e-02f,
  8.37399960e-02f, 5.55633865e-02f, -4.93686013e-02f, -2.91642323e-02f, -1.06273159e-01f, -4.80907895e-02f, 1.13268085e-02f, 4.77177575e-02f, 4.53741662e-02f, -2.70097796e-02f,
  -1.52053952e-01f, 4.60216440e-02f, 3.53718959e-02f, -3.99540961e-02f, -1.75696146e-02f, -7.59179965e-02f, 1.13518856e-01f, -2.23104544e-02f, -3.98803465e-02f, -1.15051316e-02f,
  -9.88951102e-02f, -3.79168428e-02f, -5.16318865e-02f, 1.04678292e-02f, 2.90378574e-02f, -6.97011128e-02f, 6.02588691e-02f, 3.83476019e-02f, 3.19352187e-02f, 2.70254873e-02f,
  3.40921571e-03f, -1.95758622e-02f, 3.93838063e-02f, -2.76493058e-02f, -2.60043498e-02f, 3.83607374e-04f, -7.11970627e-02f, -1.89318955e-02f, 4.01363000e-02f, 6.13001781e-03f,
  -2.18111426e-01f, 1.60396472e-03f, -1.26330346e-01f, -3.93589772e-02f, -3.65042239e-02f, 2.65379958e-02f, 5.10940440e-02f, 7.79612884e-02f, -9.68177617e-02f, 1.51555687e-01f,
  1.29325122e-01f, -2.86755711e-02f, 1.44167185e-01f, 8.03690478e-02f, -1.11232765e-01f, 5.12135737e-02f, 7.50914041e-05f, 7.46743008e-02f, -4.38083373e-02f, 8.03658739e-02f,
  -1.01193160e-01f, 1.13227502e-01f, -5.44389011e-03f, 1.44032076e-01f, 6.49788156e-02f, -1.94671154e-02f, 9.77386907e-02f, 9.06392261e-02f, 1.03048287e-01f, -3.50569421e-03f,
  -2.12506182e-03f, -6.55259565e-02f, -5.44196442e-02f, 7.84086157e-03f, 4.31935210e-03f, -7.07535446e-02f, 8.16541538e-03f, -8.16263817e-03f, -7.81500805e-03f, 1.50645403e-02f,
  -2.41389107e-02f, 6.20446056e-02f, -2.09328327e-02f, -2.83919871e-02f, -6.68910667e-02f, -6.87785633e-03f, 1.98897645e-02f, -5.20067252e-02f, -1.08621549e-02f, 3.76051068e-02f,
  -5.55090085e-02f, -5.32616675e-02f, -2.60797534e-02f, 1.23152118e-02f, -5.66475540e-02f, -6.30306974e-02f, -7.66768381e-02f, -1.67874880e-02f, 3.07520851e-02f, -5.31815924e-02f,
  9.37983394e-02f, -3.62557434e-02f, 5.74770831e-02f, 9.33548808e-02f, -1.87906064e-02f, -1.89104844e-02f, 8.35082494e-04f, -5.50760143e-02f, 4.26891670e-02f, 3.82513227e-03f,
  1.29845331e-03f, -2.51203030e-02f, -2.53232643e-02f, 6.47729635e-03f, -4.47769016e-02f, -3.48908938e-02f, -1.08881108e-01f, 2.24614292e-02f, -2.57347338e-02f, -8.59403238e-02f,
  2.89586484e-02f, -3.32029909e-02f, -2.94499029e-03f, -3.36273946e-02f, -4.67393585e-02f, -5.81067950e-02f, 6.58140704e-02f, 5.83315343e-02f, 2.37503592e-02f, -9.44650825e-03f,
  6.29176795e-02f, 1.10966526e-01f, 5.54023199e-02f, 1.72127578e-02f, -1.88583799e-03f, -2.80244257e-02f, -5.56300245e-02f, 2.47966722e-02f, -2.57223640e-02f, 6.36356100e-02f,
  6.72537535e-02f, -7.92167559e-02f, 8.62363651e-02f, -2.71043964e-02f, 1.71392728e-02f, 7.61138573e-02f, -2.75112269e-03f, 5.60494252e-02f, -2.16281973e-02f, 5.64118065e-02f,
  1.76034973e-03f, -4.51921374e-02f, -8.27317014e-02f, -3.97188962e-02f, -3.46372696e-03f, -7.59845832e-03f, -9.05879866e-03f, -2.77190179e-06f, 5.44471964e-02f, -5.54123009e-03f,
  1.99164644e-01f, -5.28133810e-02f, 1.15173258e-01f, -5.30539732e-03f, -9.26091149e-02f, 7.07887709e-02f, -1.49026327e-02f, 3.68068577e-03f, 1.41003266e-01f, -7.60770449e-03f,
  -7.68197551e-02f, 2.09136203e-01f, -2.61800867e-02f, -4.78894040e-02f, 1.84235170e-01f, 9.35030282e-02f, -1.24965094e-01f, 8.50323290e-02f, 1.00945167e-01f, -5.18599004e-02f,
  2.92390250e-02f, -1.51700869e-01f, -5.37107922e-02f, -1.92756295e-01f, -5.28325737e-02f, 1.93307288e-02f, -9.05219615e-02f, -4.73546013e-02f, -1.98016003e-01f, 2.91748494e-02f,
  1.73346698e-02f, 9.52872708e-02f, 5.26303947e-02f, 9.78109911e-02f, -3.03769484e-02f, -9.97436494e-02f, -8.82990509e-02f, 4.60547656e-02f, 9.62259993e-03f, -3.10082510e-02f,
  -4.96681519e-02f, -6.52570324e-03f, -4.11850847e-02f, 2.24174988e-02f, -4.12377529e-02f, 6.84946552e-02f, -4.67209443e-02f, -3.30092348e-02f, -3.09172664e-02f, 7.73650929e-02f,
  -1.04216440e-03f, 3.33605483e-02f, -3.53856273e-02f, -1.83124878e-02f, 4.57877256e-02f, -3.23878564e-02f, -2.32673213e-02f, 2.34394390e-02f, -4.87135984e-02f, 9.12783891e-02f,
  -9.66838002e-02f, 3.99630368e-02f, -6.95914254e-02f, 4.58948407e-03f, 5.41405976e-02f, -2.02306192e-02f, 7.87234679e-03f, -9.03536752e-03f, -1.33059341e-02f, -8.91268104e-02f,
  -5.95066398e-02f, -7.55607337e-02f, 6.25180453e-02f, 4.98702899e-02f, -3.16746160e-02f, 1.15461294e-02f, -1.27332960e-03f, -8.61150175e-02f, 4.09599952e-02f, -7.35630980e-04f,
  4.65776697e-02f, 5.79453520e-02f, -1.00120284e-01f, -6.89060315e-02f, -5.60959689e-02f, 3.87639962e-02f, -5.93852028e-02f, 7.94818029e-02f, -3.85956541e-02f, 6.27849549e-02f,
  -4.20743898e-02f, -1.73284858e-01f, -6.73491275e-03f, 2.05943510e-02f, 5.06106392e-02f, -9.64127388e-03f, 1.13301329e-01f, -9.02701262e-03f, -9.89399254e-02f, 4.42508236e-02f,
  2.40754168e-02f, -1.83301363e-02f, -2.40344740e-02f, -3.73604819e-02f, 8.41783825e-03f, 3.85164097e-02f, -5.88706210e-02f, 1.00704230e-01f, 6.00858033e-03f, -3.55010927e-02f,
  -8.48167464e-02f, -5.32784909e-02f, -1.46986973e-02f, -6.81316629e-02f, 9.75811761e-03f, -1.50071010e-02f, -5.63390143e-02f, 6.07198337e-03f, -4.43705432e-02f, -3.76052000e-02f,
  -9.02520567e-02f, -9.86563936e-02f, -1.85748592e-01f, 2.67522479e-03f, 9.82924774e-02f, -6.57588989e-02f, -8.36161375e-02f, 5.08565567e-02f, -1.39173537e-01f, 2.27377610e-03f,
  1.21573359e-02f, -1.87494710e-01f, 6.20867424e-02f, -1.32996365e-01f, 6.68313429e-02f, -3.98162305e-02f, -1.64971367e-01f, -7.43696541e-02f, -8.17076787e-02f, -1.04801901e-01f,
  -3.64607722e-02f, 3.08216214e-02f, 3.08203530e-02f, 1.54901713e-01f, -9.81147960e-03f, 2.78449245e-02f, 1.66859835e-01f, 3.72199640e-02f, 1.80885643e-01f, 1.02186561e-01f,
  -2.84750555e-02f, -1.62308346e-02f, 8.30760505e-03f, 1.76122226e-02f, 6.69690315e-03f, 5.65174967e-02f, -1.52795739e-03f, 1.10628009e-02f, -8.62809736e-03f, -2.14146078e-02f,
  -1.41290590e-01f, 6.10691160e-02f, -6.45356700e-02f, 7.50103407e-03f, 5.74262179e-02f, 2.61584241e-02f, -4.82862704e-02f, -6.35528415e-02f, 3.33924778e-02f, 2.00417899e-02f,
  -2.32417397e-02f, -3.75407599e-02f, 2.17089839e-02f, -3.92770544e-02f, -7.11049214e-02f, -7.60280713e-02f, -4.71018115e-03f, -1.00124799e-01f, -1.48252966e-02f, 1.74468197e-02f,
  5.58303930e-02f, -1.06455795e-02f, 4.67834882e-02f, 9.19760540e-02f, 9.71979648e-02f, -9.54941439e-04f, 4.81300205e-02f, -3.18641588e-02f, -1.95828211e-02f, 9.06087644e-03f,
  -1.59007944e-02f, 2.32042782e-02f, 4.86590853e-03f, 5.25504015e-02f, -7.69109353e-02f, 3.60696167e-02f, -1.85717326e-02f, 4.24014498e-03f, -7.28500336e-02f, 2.75003631e-02f,
  5.01317764e-03f, 3.47578004e-02f, 8.87839198e-02f, 2.85325814e-02f, 1.41263884e-02f, 4.56472002e-02f, 6.27930984e-02f, 5.35882302e-02f, -5.50287813e-02f, -6.37707263e-02f,
  2.70480327e-02f, -5.87362684e-02f, -7.14990944e-02f, -5.49460612e-02f, -6.32882491e-02f, -2.84087043e-02f, -9.68407542e-02f, -1.98953748e-02f, -6.38398007e-02f, 5.79252653e-02f,
  -6.85012375e-04f, -9.37363878e-02f, 4.45605814e-02f, -6.02515414e-03f, -3.81162427e-02f, 1.51853964e-01f, 3.99199091e-02f, -1.24368714e-02f, -4.76810262e-02f, 7.93274343e-02f,
  1.51928430e-02f, -5.13637699e-02f, -3.69475298e-02f, -5.89063251e-03f, -3.10128089e-03f, 5.04049547e-02f, -9.01141018e-03f, -2.38592215e-02f, 3.24523114e-02f, -3.23136300e-02f,
  1.21095277e-01f, 2.57672630e-02f, 5.80252893e-02f, 5.48937882e-04f, 5.75467534e-02f, 6.22101389e-02f, -4.17518765e-02f, 8.09400305e-02f, 1.84445292e-01f, 2.92468332e-02f,
  3.47718373e-02f, 1.74675420e-01f, 2.36833282e-02f, 4.87524904e-02f, 1.95441698e-03f, -2.68144067e-02f, -1.19889282e-01f, -7.10795894e-02f, 7.12787211e-02f, 2.48621684e-03f,
  -6.43380061e-02f, -1.18405841e-01f, -2.07156911e-02f, 1.73964668e-02f, 7.69003183e-02f, -2.11381577e-02f, -9.80680436e-02f, -2.81245285e-03f, 8.85007624e-03f, -1.67484917e-02f,
  -4.44248468e-02f, 6.27419800e-02f, -1.13264494e-01f, -3.45593877e-02f, -4.51387800e-02f, 5.44509366e-02f, 6.71777949e-02f, -1.06955878e-02f, 6.15970679e-02f, -3.81420068e-02f,
  8.22953060e-02f, 6.96022809e-02f, 4.31015566e-02f, 7.83530195e-05f, 7.61113390e-02f, 1.14672128e-02f, -1.69778243e-02f, -4.05167267e-02f, 5.76394349e-02f, -2.32418850e-02f,
  2.72768326e-02f, -3.06507237e-02f, 8.82346369e-03f, 7.99648687e-02f, -1.47173330e-02f, -2.83416938e-02f, 1.92570854e-02f, 7.13337734e-02f, 5.57551049e-02f, -3.13822143e-02f,
  -1.35241553e-01f, 5.04603721e-02f, -1.03178027e-03f, -8.18577223e-03f, 4.44798879e-02f, 1.24852918e-02f, -6.56643659e-02f, 5.52158430e-02f, 1.20262384e-01f, 3.20872627e-02f,
  4.17067623e-03f, 4.36934419e-02f, -5.61177768e-02f, -6.47236034e-03f, -2.39274092e-02f, 3.71385664e-02f, 1.00671910e-02f, 4.61201556e-02f, 2.97267232e-02f, -2.08256003e-02f,
  -1.73821282e-02f, -5.68856299e-02f, -3.22705880e-02f, -3.67361121e-03f, -6.99816877e-03f, -3.39865759e-02f, 1.69049352e-02f, -2.69000512e-02f, -7.62120783e-02f, 3.43557410e-02f,
  -1.50348216e-01f, -2.13664547e-01f, -1.49223790e-01f, -6.09137788e-02f, 5.86736575e-02f, -5.90282269e-02f, -1.88177228e-02f, -5.61475754e-03f, 1.58430673e-02f, -2.11198479e-02f,
  4.83532324e-02f, 1.03632570e-03f, 4.63342294e-02f, -9.28835049e-02f, 1.06999744e-02f, -6.78194463e-02f, 9.42502469e-02f, -5.95258698e-02f, -8.86329636e-02f, -6.50589913e-02f,
  -9.48084667e-02f, 3.62536199e-02f, 2.07689274e-02f, -6.70252070e-02f, -1.08623616e-01f, -5.59036806e-02f, -2.73812171e-02f, 3.73046622e-02f, 3.03909853e-02f, -3.46007533e-02f,
  -2.94423133e-01f, 2.28718758e-01f, -1.45184606e-01f, 8.25065449e-02f, -7.93585405e-02f, 1.26296073e-01f, 1.20943762e-01f, -8.73409659e-02f, 1.94135427e-01f, 8.11705813e-02f,
  -4.64595146e-02f, -1.46558438e-03f, -9.31946188e-02f, 2.89375763e-02f, -1.27330408e-01f, 4.40232791e-02f, -2.38252860e-02f, -7.57172108e-02f, 6.56715333e-02f, -2.04588458e-01f,
  3.83593701e-02f, -8.77986699e-02f, -7.09575415e-02f, -1.19772062e-01f, -1.05767347e-01f, -7.16764629e-02f, -2.14933366e-01f, -7.76205957e-02f, -6.27559870e-02f, -1.63572226e-02f,
  -6.41976073e-02f, -1.37110129e-01f, -1.92945853e-01f, -2.68065669e-02f, -6.03867695e-02f, -7.06490576e-02f, -4.33243997e-02f, 3.85700166e-02f, -2.08622552e-02f, 2.71864813e-02f,
  7.46162310e-02f, -8.42260718e-02f, -1.04410574e-01f, -5.10329707e-03f, 3.43358181e-02f, -2.07410511e-02f, -6.42968118e-02f, -8.08293000e-03f, -8.13172199e-03f, -8.38279352e-02f,
  -9.58783180e-02f, 3.82394344e-02f, -1.62618998e-02f, 1.06591368e-02f, 1.75750628e-03f, -3.92680019e-02f, -2.30159853e-02f, -5.87788783e-02f, -1.53528797e-02f, 8.47023167e-03f,
  3.79824033e-03f, -6.23460710e-02f, 1.42413769e-02f, -4.13071401e-02f, -5.83411679e-02f, -4.29314673e-02f, -9.43787687e-04f, -5.37661724e-02f, 5.04619116e-03f, -9.29799005e-02f,
  2.51434445e-02f, 4.20122361e-03f, 1.04705300e-02f, -1.26215210e-02f, 1.18542872e-02f, -1.25510925e-02f, 1.94747038e-02f, -1.14398450e-02f, 7.00732470e-02f, -5.88271627e-03f,
  3.87533568e-02f, -1.95269268e-02f, 4.46928293e-02f, -4.56189997e-02f, -4.45574522e-03f, 2.88779456e-02f, 1.33330645e-02f, -2.49682423e-02f, 3.65824178e-02f, 2.79855896e-02f,
  -1.71416346e-02f, -1.34910598e-01f, -1.83474515e-02f, 5.49162459e-03f, -3.73947285e-02f, -3.34715992e-02f, -3.52307339e-03f, -5.02898432e-02f, -3.85924391e-02f, -5.28636575e-02f,
  -6.75187930e-02f, 1.62541959e-02f, -1.58629753e-02f, 5.33876792e-02f, 3.93653400e-02f, 2.62593292e-02f, -8.77358317e-02f, 1.88134101e-04f, -7.47380853e-02f, -9.07315984e-02f,
  -1.15115851e-01f, -8.88981763e-03f, 4.80088629e-02f, 7.45382952e-03f, -5.21179242e-03f, 3.15391319e-03f, -3.83643582e-02f, 3.97441685e-02f, 6.59169480e-02f, -1.39934905e-02f,
  4.62775119e-02f, -7.37744719e-02f, 1.17364623e-01f, 2.38993376e-01f, -3.87964919e-02f, -2.47075066e-01f, -5.73964119e-02f, -9.14028883e-02f, 4.30712942e-03f, -3.06454469e-02f,
  -3.92166374e-04f, 4.80486751e-02f, 7.66843930e-02f, 1.43222930e-02f, 1.91971257e-01f, 9.36688110e-02f, 5.47576249e-02f, 3.17791924e-02f, 2.51396932e-02f, -1.53785469e-02f,
  4.04198766e-02f, -2.45288033e-02f, 1.76058620e-01f, -1.01398177e-01f, -1.56738739e-02f, 9.53897238e-02f, 1.05899669e-01f, -6.37719035e-02f, 7.28130415e-02f, -7.68370852e-02f,
  -1.79121181e-01f, -6.02824464e-02f, -7.38947093e-03f, -8.30220804e-02f, -4.13712151e-02f, 2.62455903e-02f, 2.12939344e-02f, 2.29698289e-02f, 3.70157138e-02f, -2.15377702e-04f,
  -8.10030922e-02f, -7.07141832e-02f, 4.60686833e-02f, -8.61530900e-02f, -2.14097332e-02f, -2.24902555e-02f, -5.92762530e-02f, -8.15878622e-03f, 5.74874459e-03f, -8.46598763e-03f,
  5.03754802e-02f, -6.07105112e-03f, 9.36726294e-03f, -1.55445710e-02f, -3.94229405e-02f, -7.16235414e-02f, 1.41398357e-02f, 2.41668001e-02f, -5.63877076e-02f, -9.94850248e-02f,
  1.74330585e-02f, -1.83040220e-02f, 2.58135330e-02f, -9.54252630e-02f, -2.56768018e-02f, -1.85229853e-02f, -6.29454702e-02f, 2.44353693e-02f, 1.92689095e-02f, -7.82456994e-02f,
  -3.88446562e-02f, 9.48570017e-03f, 1.12148859e-02f, 2.17055585e-02f, 2.45526806e-02f, 4.56760358e-03f, 2.19505578e-02f, -9.57191810e-02f, -4.82883267e-02f, 6.04164042e-02f,
  1.96168218e-02f, -8.13522041e-02f, 9.52656963e-04f, -4.89399247e-02f, 1.05508110e-02f, 6.62478134e-02f, 7.01187504e-03f, -2.08259970e-02f, 2.95147672e-02f, -2.10302696e-02f,
  -2.59808987e-01f, -2.26345267e-02f, 4.42056060e-02f, -7.17191398e-02f, -2.64154449e-02f, -1.42882066e-02f, 1.88283417e-02f, -6.93562031e-02f, -3.25822867e-02f, -3.20012569e-02f,
  -1.97987873e-02f, -3.69937345e-02f, -4.81898189e-02f, 5.22995032e-02f, 3.83936614e-02f, -6.09486587e-02f, 5.89714125e-02f, -3.22698504e-02f, -4.59192172e-02f, 4.02172655e-02f,
  -1.28121534e-02f, -1.44814234e-02f, -2.10130103e-02f, 1.88443772e-02f, 7.96555504e-02f, 2.82557309e-02f, 2.49902550e-02f, 4.65003550e-02f, -3.75984213e-03f, 2.87824888e-02f,
  -3.12198490e-01f, -5.77416793e-02f, -1.23923302e-01f, -1.88072193e-02f, -3.95035371e-02f, -1.58282101e-01f, -1.21804334e-01f, -1.20146126e-01f, -1.26622260e-01f, 4.73007709e-02f,
  4.14009504e-02f, -1.59234956e-01f, 1.94379687e-01f, -1.00511268e-01f, -2.01440770e-02f, 4.98049147e-02f, -1.80637836e-01f, -9.21129882e-02f, 6.90873191e-02f, -1.37305453e-01f,
  3.65884835e-03f, 1.31960452e-01f, 6.12078793e-02f, 1.39653295e-01f, -4.32656594e-02f, -9.90867168e-02f, 1.77080125e-01f, 1.25510633e-01f, -9.15759355e-02f, -3.54579836e-02f,
  -7.04036430e-02f, 3.11677232e-02f, -2.62593036e-03f, -3.49995643e-02f, -7.35633820e-02f, 7.95196183e-03f, 2.36960184e-02f, 4.03513312e-02f, 1.36251457e-03f, -3.35307755e-02f,
  4.11147028e-02f, 5.74938320e-02f, 2.00452525e-02f, 6.16025180e-02f, -6.80671334e-02f, -9.77092534e-02f, -6.77175447e-02f, -7.48928860e-02f, 3.31794540e-03f, -2.34301090e-02f,
  -9.32361782e-02f, 5.01538105e-02f, -6.80521280e-02f, 4.30455282e-02f, -1.05125480e-03f, 4.24056686e-02f, 1.87624618e-02f, 2.81148273e-02f, -8.04392695e-02f, -2.77490891e-03f,
  3.75332013e-02f, -6.24710210e-02f, 1.59712005e-02f, -2.11083498e-02f, 7.68529065e-03f, 1.79746877e-02f, -1.81374745e-03f, 2.91001908e-02f, 2.00770143e-02f, -2.19580643e-02f,
  4.53901850e-03f, 1.94920804e-02f, -1.89792784e-03f, -1.88923571e-02f, -6.66507781e-02f, -2.40867399e-02f, 1.17897205e-02f, 4.97716367e-02f, -8.74125212e-02f, 1.03169955e-01f,
  1.66092012e-02f, -8.26368481e-02f, 4.16411422e-02f, -2.24350207e-02f, -6.13087974e-02f, 2.37461999e-02f, -1.17272818e-02f, -1.59424767e-02f, -2.30223173e-03f, 2.20826957e-02f,
  6.21838942e-02f, -4.87593189e-02f, -2.73152050e-02f, -7.31668323e-02f, 6.11989945e-02f, 3.42576168e-02f, -2.58686170e-02f, -8.27105194e-02f, -2.54554991e-02f, -2.91020386e-02f,
  -6.06471598e-02f, -8.40400755e-02f, -1.26650929e-01f, 1.68616213e-02f, -5.41147601e-04f, 2.47178152e-02f, 5.15882671e-02f, 6.12326013e-03f, -3.53784747e-02f, -3.73098999e-02f,
  2.32860893e-02f, -4.00871374e-02f, -9.02209710e-03f, -3.58924493e-02f, 2.76959445e-02f, -5.69092147e-02f, -7.10265860e-02f, -5.93518429e-02f, -1.67336166e-02f, -3.27866189e-02f,
  -1.45186223e-02f, -1.08850382e-01f, -1.78314552e-01f, -1.35832950e-01f, 1.14939108e-01f, 2.71407127e-01f, 6.44362047e-02f, -1.01701185e-01f, -1.99124768e-01f, 2.47998871e-02f,
  1.47788316e-01f, -1.53632134e-01f, 1.96858719e-02f, -1.36808887e-01f, 1.02114983e-01f, -1.35477260e-01f, 4.30143587e-02f, -2.31919973e-03f, -8.03659931e-02f, 1.24276597e-02f,
  -9.57707614e-02f, 9.45529416e-02f, -5.40044978e-02f, -9.07942001e-03f, 3.13870907e-02f, -3.27469297e-02f, 1.22865222e-01f, -3.95628950e-03f, 1.26583710e-01f, 7.05212131e-02f,
  4.29183245e-02f, -5.89467809e-02f, 6.84715807e-02f, -7.50821382e-02f, 1.06396593e-01f, 7.19013885e-02f, 1.75882690e-03f, 6.20576553e-02f, 7.11497441e-02f, 2.59025618e-02f,
  -2.39557829e-02f, -6.00199327e-02f, -3.97292934e-02f, -7.36617371e-02f, -4.91872206e-02f, -1.94959308e-03f, -3.77547555e-02f, 6.14008233e-02f, -8.91176686e-02f, -3.84486690e-02f,
  -4.06553708e-02f, 1.20472372e-01f, 1.38732260e-02f, 4.57183085e-02f, -5.88952079e-02f, 7.20850602e-02f, -9.63249244e-03f, 1.86292212e-02f, 3.42194661e-02f, -2.37879977e-02f,
  1.78973749e-02f, -2.41419282e-02f, -7.38929119e-03f, 1.75701524e-03f, 5.58377244e-02f, 5.96457087e-02f, 1.08614340e-02f, 5.26255034e-02f, 4.28794548e-02f, 3.86107117e-02f,
  8.67589787e-02f, -5.26792035e-02f, -1.41661270e-02f, -8.01575929e-03f, -5.07755540e-02f, -4.65446524e-02f, -6.80150976e-03f, 8.29960555e-02f, -1.08855236e-02f, -5.26675843e-02f,
  -3.53614986e-02f, 4.67596948e-02f, 1.36168972e-02f, 1.33985588e-02f, -4.20819124e-05f, -2.35755974e-03f, -8.65515880e-03f, 4.96792048e-02f, -7.96181429e-03f, 3.13814878e-02f,
  1.48928389e-01f, 8.84660706e-02f, 6.62633032e-02f, 6.45252690e-02f, -1.87578499e-02f, 2.33362429e-02f, -6.93206564e-02f, -2.85653844e-02f, 7.54811466e-02f, -2.92005092e-02f,
  8.39983374e-02f, 4.83690798e-02f, 8.17512274e-02f, -3.71222161e-02f, 2.08114646e-02f, 1.42445303e-02f, -4.89520280e-05f, -4.83337715e-02f, 9.02949348e-02f, 2.16719732e-02f,
  5.45004569e-02f, 2.11895313e-02f, 6.59378096e-02f, -3.75473220e-03f, 6.19573481e-02f, 6.45185187e-02f, -1.01381712e-01f, 8.02235026e-03f, 5.76223396e-02f, -2.99784932e-02f,
  -1.62831262e-01f, 4.70463857e-02f, 2.00492442e-01f, 8.06435943e-04f, -1.32847205e-01f, 3.82408760e-02f, 6.12708591e-02f, -1.59355290e-02f, 7.71591961e-02f, -1.06389888e-01f,
  1.83809288e-02f, 5.97214103e-02f, 6.61693141e-02f, 7.35573331e-03f, -9.72405747e-02f, 2.03925431e-01f, -7.51995146e-02f, -7.98733439e-03f, 9.54198688e-02f, -8.99251103e-02f,
  -1.98809635e-02f, -9.60465595e-02f, 5.77693693e-02f, -8.15057680e-02f, -1.73124224e-01f, -1.11453816e-01f, -2.20998317e-01f, 9.38214175e-03f, -1.14469767e-01f, 1.41515536e-02f,
  2.20754873e-02f, -2.38568690e-02f, 6.66266009e-02f, 9.68618095e-02f, 1.26120578e-02f, -8.52549374e-02f, -6.00924268e-02f, 3.83654237e-02f, 3.18210497e-02f, 4.05183882e-02f,
  -9.30869654e-02f, -4.18540388e-02f, -5.97722381e-02f, -6.49054861e-03f, 5.56751415e-02f, -4.25439030e-02f, 4.53298576e-02f, 4.06777970e-02f, 6.38013333e-02f, -1.86832994e-02f,
  2.97826137e-02f, -1.98400784e-02f, -4.79991771e-02f, -8.48338567e-03f, -6.19648807e-02f, 3.22421081e-02f, 4.44565453e-02f, 4.98554483e-02f, -5.83567396e-02f, 2.42144782e-02f,
  1.29006132e-02f, 5.43905683e-02f, 1.49798570e-02f, -3.01764533e-02f, -6.88145589e-03f, -8.24288372e-03f, -7.15240464e-02f, 5.81479780e-02f, 1.55534428e-02f, -2.98787304e-03f,
  5.08888066e-02f, -3.51828374e-02f, -3.04876808e-02f, -2.29193345e-02f, -5.56913354e-02f, -4.45258915e-02f, -2.88274977e-02f, 1.93943493e-02f, -1.48684215e-02f, -4.77516316e-02f,
  -1.81671344e-02f, -3.68464813e-02f, 4.46448810e-02f, -2.78249551e-02f, 2.84898281e-02f, 6.22347146e-02f, 3.54972966e-02f, 8.02970380e-02f, 1.01434458e-02f, -5.12165278e-02f,
  -2.72593591e-02f, -1.50730595e-01f, -5.91373211e-03f, -1.28111038e-02f, 2.40617301e-02f, -9.53083485e-02f, -7.69888144e-03f, 4.31280285e-02f, -5.59303425e-02f, 3.16932872e-02f,
  3.49292508e-03f, 1.65306814e-02f, -5.65643087e-02f, 1.80536881e-02f, -5.08180149e-02f, 4.52745259e-02f, 6.63083699e-03f, -9.72247310e-03f, -8.76850113e-02f, -4.96212877e-02f,
  -6.62012026e-02f, 7.75301130e-03f, 4.85722981e-02f, -2.84301415e-02f, -3.68498191e-02f, -3.94903235e-02f, -2.59134900e-02f, -2.54791807e-02f, -6.02714717e-02f, 6.85771555e-02f,
  3.53985801e-02f, -5.07218577e-02f, -3.74868363e-02f, 1.46999076e-01f, -8.80028531e-02f, -3.72490063e-02f, 1.08742863e-01f, 1.36046350e-01f, 8.52083564e-02f, 6.73080012e-02f,
  1.37161210e-01f, -9.06863660e-02f, -1.02478676e-01f, 2.47446373e-01f, 1.95208728e-01f, -4.71679419e-02f, 2.71606892e-01f, 5.02597578e-02f, 3.90718505e-03f, 1.15881771e-01f,
  1.89934984e-01f, 6.13143072e-02f, 6.31354302e-02f, 5.80471903e-02f, 1.10316910e-02f, -8.55850801e-02f, 6.70209527e-02f, -1.50905806e-03f, 1.33632749e-01f, -2.13490669e-02f,
  -3.76701877e-02f, -2.45360583e-02f, -1.63374431e-02f, -1.14871822e-01f, 9.97157469e-02f, 4.12608720e-02f, 1.69177651e-02f, 1.67703012e-03f, -4.00441810e-02f, -4.78836372e-02f,
  -3.36693376e-02f, 9.61249415e-03f, -4.07906920e-02f, -1.15767783e-02f, -2.44740583e-02f, 3.38966283e-03f, -2.34073270e-02f, -9.05693546e-02f, 2.87640165e-03f, 7.33596599e-03f,
  -1.39578670e-01f, -6.02871999e-02f, 4.60325032e-02f, -4.47466038e-03f, 1.31619973e-02f, -4.10586037e-02f, -2.74433978e-02f, 2.79328250e-03f, -1.71437301e-02f, 5.18612936e-02f,
  -7.64541095e-03f, -5.38565256e-02f, 1.79889984e-02f, -5.79456054e-02f, -9.81247146e-03f, 9.48437024e-03f, 2.83662993e-02f, -2.93424353e-03f, 4.75709401e-02f, 8.46420601e-02f,
  -9.88813713e-02f, 5.25315963e-02f, 8.38427804e-03f, 3.23368907e-02f, 1.79773550e-02f, -4.32190634e-02f, 6.17817603e-03f, -6.81346795e-03f, 5.73679060e-02f, 6.12753779e-02f,
  2.47420873e-02f, -3.77619117e-02f, -7.76845589e-02f, 8.18735827e-03f, 6.28807023e-02f, 1.05538247e-02f, 3.15227471e-02f, 4.26677801e-02f, 3.96105349e-02f, 1.83741115e-02f,
  1.15326427e-01f, 7.09110945e-02f, 7.54634216e-02f, -3.65661047e-02f, -7.61474445e-02f, -6.42919615e-02f, -1.07243378e-02f, 3.69838849e-02f, -5.11505036e-03f, 1.30463736e-02f,
  -3.65901589e-02f, -5.96051067e-02f, 1.72263756e-02f, -5.76508306e-02f, 1.21376691e-02f, 8.01580772e-02f, 7.22199976e-02f, 7.06959218e-02f, 1.40516028e-01f, 1.18088521e-01f,
  -5.12424111e-02f, -7.92817250e-02f, 2.45294888e-02f, -7.61918947e-02f, -1.35530783e-02f, 1.15706511e-02f, -1.47407525e-03f, 1.57031193e-02f, 2.75896899e-02f, 3.82116102e-02f,
  -1.88196078e-01f, 2.30048493e-01f, -2.19816029e-01f, 3.03853974e-02f, 3.90299559e-02f, 1.51063904e-01f, -7.65939057e-02f, 1.67976990e-01f, 7.72907287e-02f, 1.87008187e-01f,
  -1.25470408e-03f, -1.67856887e-02f, -6.83621392e-02f, 1.97171673e-01f, -1.54330060e-01f, 5.52300885e-02f, 9.45791528e-02f, 7.49885365e-02f, 5.30816987e-02f, 9.29615796e-02f,
  3.67853791e-02f, 8.65688995e-02f, -7.73341805e-02f, 9.66571495e-02f, 3.32098231e-02f, 2.97790244e-02f, 5.85907958e-02f, -4.51969542e-02f, 8.90682861e-02f, -9.00447518e-02f,
  6.01521209e-02f, -5.92474826e-02f, -1.14768893e-01f, -6.24988750e-02f, 1.25224609e-02f, -8.35304558e-02f, -7.92469755e-02f, -3.32364701e-02f, -3.71532999e-02f, 2.38006040e-02f,
  -8.18316117e-02f, 1.20556699e-02f, 8.03172365e-02f, 3.44714075e-02f, 5.28605916e-02f, -5.67378886e-02f, 1.57838147e-02f, 1.11673651e-02f, -6.34778813e-02f, -4.52682405e-04f,
  -1.15893539e-02f, -5.43301888e-02f, 1.52752930e-02f, 5.88645134e-03f, 3.08525544e-02f, -3.18053104e-02f, 1.11781016e-01f, 4.37969621e-03f, -5.72046749e-02f, 1.11926287e-01f,
  -1.50638819e-02f, 4.08767238e-02f, -5.07849604e-02f, -5.39590381e-02f, 4.58522104e-02f, -1.91457774e-02f, -1.20398039e-02f, 6.81952313e-02f, -3.69997509e-02f, -2.03770269e-02f,
  4.18948650e-04f, -7.00858608e-02f, 1.00962140e-01f, 4.14544679e-02f, 8.82506073e-02f, 3.13794836e-02f, 2.06128918e-02f, 7.54081905e-02f, 1.11069772e-02f, 9.01347175e-02f,
  -4.19441946e-02f, 4.90590706e-02f, 3.88630256e-02f, 6.64774552e-02f, -1.52352350e-02f, -8.25238526e-02f, 1.73881892e-02f, 1.94416370e-03f, -4.72879112e-02f, -2.71085147e-02f,
  1.41877934e-01f, 1.55894309e-01f, -6.79995958e-03f, 1.96910854e-02f, 1.70209147e-02f, -4.65587415e-02f, -3.88895385e-02f, 4.51801531e-02f, -6.68120906e-02f, -3.36644277e-02f,
  -2.54708715e-03f, -3.04458607e-02f, -3.02233193e-02f, 3.18230465e-02f, 1.70723274e-02f, -7.52995955e-03f, 3.80064249e-02f, 3.80378217e-02f, 7.63154998e-02f, -1.32144783e-02f,
  -7.39558600e-03f, 8.58004764e-02f, -3.07045486e-02f, 4.29029725e-02f, 1.56640097e-01f, 2.73538171e-03f, -3.75528783e-02f, -4.80396347e-03f, 6.27407581e-02f, 4.13296409e-02f,
  -1.25925541e-01f, 7.30651477e-03f, -9.02112499e-02f, -1.18896976e-01f, 3.27542685e-02f, 2.23028332e-01f, 2.16099501e-01f, -8.39508548e-02f, 1.49994463e-01f, 1.32091707e-02f,
  6.15995601e-02f, 1.21652000e-02f, 1.00800581e-01f, 2.39184454e-01f, 3.52357596e-01f, 2.48771608e-01f, 2.15864912e-01f, 1.74001470e-01f, 1.92782637e-02f, -6.59831837e-02f,
  -7.38407448e-02f, 9.14242938e-02f, 9.84419696e-03f, -1.76785365e-01f, -1.08816482e-01f, -2.37256050e-01f, -2.41257146e-01f, -7.63127059e-02f, 9.40696429e-03f, 1.28690545e-02f,
  5.41394241e-02f, 1.76754699e-03f, -1.07827038e-01f, 3.91912945e-02f, -5.36017604e-02f, -1.04880482e-01f, 2.85408348e-02f, 8.35502893e-02f, 1.47866155e-03f, -3.11677568e-02f,
  -5.44333737e-03f, 3.81065160e-02f, -2.48918831e-02f, 8.07850659e-02f, 8.02448019e-03f, 6.25093132e-02f, -5.27600385e-02f, -1.76638402e-02f, 6.79930747e-02f, -3.79668213e-02f,
  -2.33506728e-02f, -5.56745715e-02f, -1.31596690e-02f, -1.96704902e-02f, -1.68478280e-01f, -1.26898829e-02f, 4.01649922e-02f, -6.68609980e-04f, 4.13127244e-02f, -1.49436705e-02f,
  1.04279406e-02f, -4.66872677e-02f, -2.08214950e-02f, 4.48293760e-02f, 7.56707713e-02f, -5.49977235e-02f, 5.72972707e-02f, 3.36714499e-02f, -3.85557278e-03f, 7.63762817e-02f,
  4.02329117e-03f, -7.60534778e-03f, 4.33693044e-02f, 9.95396171e-03f, -5.24466000e-02f, 9.16572101e-03f, -1.65709797e-02f, -1.35338269e-02f, -7.74995014e-02f, -5.95523044e-04f,
  4.91827466e-02f, 2.02790624e-03f, -3.34046856e-02f, -2.53948364e-02f, 9.89515483e-02f, -2.69582570e-02f, 2.12434623e-02f, -2.58308146e-02f, -1.46887563e-02f, 3.02150995e-02f,
  7.21964389e-02f, 4.49285656e-02f, 6.85170069e-02f, -7.05137476e-02f, 1.84815808e-03f, 4.08822596e-02f, 5.95567040e-02f, -2.69325916e-02f, -3.46243195e-02f, 4.61341999e-02f,
  -7.86645934e-02f, -1.19541083e-02f, -1.97500363e-02f, 4.80235973e-03f, 3.85639220e-02f, -2.31272280e-02f, 9.78140812e-03f, 2.00972538e-02f, -5.10543026e-02f, -1.26492660e-02f,
  -1.85191482e-02f, -1.05717778e-02f, 2.10548397e-02f, -1.41076092e-02f, 2.02641767e-02f, 3.32963392e-02f, -4.01638821e-03f, -5.38700148e-02f, 2.50545982e-02f, 3.30136344e-02f,
  -1.37156695e-01f, 3.60432081e-02f, -2.47974321e-01f, -5.94191030e-02f, -3.15388888e-02f, -5.26539162e-02f, -7.38504231e-02f, -8.86601582e-03f, -9.50534195e-02f, 8.91155005e-02f,
  -3.77328172e-02f, -1.69967487e-01f, 2.69564129e-02f, 1.92618147e-01f, 7.06249550e-02f, -3.47309187e-02f, 5.97963072e-02f, 6.84022680e-02f, -5.71620055e-02f, 1.90906793e-01f,
  -5.08054234e-02f, 6.91401511e-02f, 5.82354106e-02f, 1.38790570e-02f, 1.04303449e-01f, -1.29472837e-01f, 1.20749019e-01f, -1.52673557e-01f, -3.42819355e-02f, -3.46280448e-02f,
  1.79643929e-01f, 3.72461975e-02f, -5.65919317e-02f, -1.06071182e-01f, -3.96460928e-02f, -4.44638170e-02f, -9.44755539e-06f, -1.35937482e-01f, 7.22869337e-02f, 3.96989956e-02f,
  1.38022220e-02f, -6.01391159e-02f, -7.32163638e-02f, -7.99821317e-03f, 3.97318415e-02f, -5.34452349e-02f, 1.48267066e-02f, -1.17895827e-02f, -9.20826495e-02f, -1.09174855e-01f,
  7.53325457e-03f, -1.41560864e-02f, -2.80977022e-02f, -4.78840014e-03f, -5.62323071e-02f, -1.57442614e-02f, -6.74696639e-02f, -1.03698503e-02f, 2.73145698e-02f, -8.12187120e-02f,
  5.31137176e-03f, -8.73769373e-02f, 3.02913021e-02f, -2.58939639e-02f, 6.09158576e-02f, -2.59795282e-02f, 4.04576324e-02f, 5.09523749e-02f, -1.76749821e-03f, 1.06320687e-01f,
  1.09573863e-01f, 5.26670143e-02f, 4.89162989e-02f, -6.57193130e-03f, -5.17196320e-02f, -4.34269793e-02f, 1.78237464e-02f, 2.89969407e-02f, -6.34484962e-02f, -8.81130099e-02f,
  6.74966723e-02f, -5.99277020e-02f, -5.86082414e-02f, 5.13315536e-02f, 2.83269510e-02f, -3.02648060e-02f, -1.56885087e-02f, 6.02703402e-03f, 4.33931835e-02f, -4.00183201e-02f,
  2.81431049e-01f, 8.03744569e-02f, 5.13653830e-02f, 2.44400697e-03f, -2.17267107e-02f, -4.69051227e-02f, 5.59368245e-02f, -4.85460237e-02f, 6.31823093e-02f, -3.47932801e-04f,
  8.72244611e-02f, -3.69559005e-02f, 5.21878153e-02f, -4.85528633e-02f, -5.30261770e-02f, 3.72964479e-02f, 9.82782245e-02f, -6.50459528e-03f, 4.78366502e-02f, -1.58446226e-02f,
  -3.24018598e-02f, -3.04387417e-02f, -1.41022587e-02f, 5.10227717e-02f, -7.89162517e-02f, 1.47098433e-02f, 5.32086231e-02f, -8.05796906e-02f, -6.49788752e-02f, -4.05637249e-02f,
  3.75470191e-01f, -6.77047819e-02f, 7.11357743e-02f, 1.38194740e-01f, 5.33657940e-03f, -2.51051307e-01f, 3.47595173e-03f, 2.78864913e-02f, -1.54730588e-01f, -1.92476660e-01f,
  8.03464502e-02f, -1.09399363e-01f, -5.00912517e-02f, -2.21475270e-02f, 1.94433257e-01f, -8.99033248e-02f, 4.34310995e-02f, -8.84034336e-02f, 2.59875078e-02f, 1.03982002e-01f,
  1.44594669e-01f, 7.98037797e-02f, 6.19189367e-02f, 9.58034843e-02f, 1.55790150e-01f, 1.72293603e-01f, 9.73536521e-02f, 1.23647228e-02f, 1.12296991e-01f, 7.54565652e-03f,
  3.77185568e-02f, 1.23876303e-01f, -5.85681610e-02f, -5.27152680e-02f, 4.98721078e-02f, -1.48501573e-02f, -2.62338240e-02f, 1.60379931e-02f, -7.80235138e-03f, 1.19243227e-02f,
  7.92687014e-02f, 5.41873761e-02f, -7.98980296e-02f, -5.56521714e-02f, -5.23629114e-02f, 5.02225161e-02f, -1.70563161e-02f, 4.75634411e-02f, 4.39306162e-02f, -2.83867260e-03f,
  -7.96614215e-02f, -1.47922775e-02f, -1.16284505e-01f, -7.89066330e-02f, -1.03229657e-02f, 6.78195944e-03f, -6.37708884e-03f, 3.66430171e-02f, -5.27188275e-03f, 7.25540519e-02f,
  -5.75199090e-02f, 3.34176421e-02f, 2.03857664e-02f, 3.23525406e-02f, 2.01844107e-02f, 1.23475818e-02f, -7.75789889e-03f, -4.25583124e-03f, 4.86599356e-02f, -6.99487515e-03f,
  -1.06491428e-02f, 2.85090506e-02f, -3.98526192e-02f, -5.49055487e-02f, -5.86247118e-03f, 3.79433185e-02f, 3.48622873e-02f, 4.94252630e-02f, 1.60960220e-02f, -6.41961247e-02f,
  -9.62494686e-02f, -5.50530702e-02f, 4.55897339e-02f, -7.58846328e-02f, 3.78418043e-02f, -1.79428067e-02f, -4.99060377e-02f, -1.08884228e-02f, 7.67266825e-02f, 7.86119476e-02f,
  7.93320984e-02f, 7.69458413e-02f, 1.92184504e-02f, 6.68176590e-03f, -2.01855563e-02f, -2.82164570e-02f, -4.58885506e-02f, -1.66809547e-03f, 6.70929207e-03f, -6.14928976e-02f,
  2.30405871e-02f, 4.91156131e-02f, 3.72027867e-02f, 3.21171023e-02f, -8.28444436e-02f, -2.79703829e-02f, 7.47076655e-03f, 2.46737041e-02f, 3.02676633e-02f, 2.13335548e-02f,
  4.97235507e-02f, 1.28694281e-01f, 9.48561952e-02f, 5.67109138e-02f, -5.08659631e-02f, -1.67905893e-02f, -7.65508041e-02f, 9.90291163e-02f, 3.42345261e-03f, -2.14672834e-02f,
  1.14764579e-01f, -1.61449671e-01f, 4.46539260e-02f, -1.14826582e-01f, 1.31207764e-01f, 9.33289081e-02f, 1.32954314e-01f, -1.11661769e-01f, -5.50634228e-02f, -1.78434014e-01f,
  -1.77913737e-02f, 9.24160555e-02f, -1.31663367e-01f, -9.34601054e-02f, 1.55420497e-01f, 5.33627421e-02f, -5.35093695e-02f, -3.07933558e-02f, -7.23130330e-02f, -1.27338797e-01f,
  -2.79539302e-02f, -7.56590217e-02f, -4.39293049e-02f, 2.50222050e-02f, 3.53605375e-02f, 1.88548379e-02f, -1.36693381e-02f, 5.75117134e-02f, -8.32558572e-02f, 1.43373013e-01f,
  1.05020180e-01f, -1.38403192e-01f, -1.24964371e-01f, 8.96994099e-02f, -8.02060217e-02f, -3.45173664e-02f, -4.59913760e-02f, 1.41173601e-01f, 1.46829020e-02f, 1.11294826e-02f,
  7.78578073e-02f, 8.19913223e-02f, -1.10321143e-03f, 8.92918184e-02f, -3.82078923e-02f, -2.33685356e-02f, -5.75675024e-03f, -2.94056591e-02f, -3.37738753e-03f, 8.81117117e-03f,
  4.12062034e-02f, -5.98714948e-02f, 3.74098006e-03f, 3.73301432e-02f, 4.06778380e-02f, 5.28540835e-02f, -1.84166327e-03f, -2.99432538e-02f, 9.95930657e-03f, 2.86258366e-02f,
  2.49629803e-02f, -6.35974258e-02f, -1.64271463e-02f, -5.28428257e-02f, 3.91323455e-02f, -6.16787337e-02f, -1.47786327e-02f, -1.02743302e-02f, -1.64446998e-02f, -2.78375596e-02f,
  4.72364202e-02f, -4.24994938e-02f, -5.29207848e-02f, 1.30307321e-02f, 1.53949601e-03f, -3.42825614e-02f, 3.63812335e-02f, -5.78899449e-03f, -7.67129734e-02f, -5.17334640e-02f,
  -5.61389886e-03f, -4.56288680e-02f, -8.09846893e-02f, 1.65806636e-02f, 6.53255591e-03f, 5.62385358e-02f, -6.36853129e-02f, -6.61017522e-02f, -1.50506225e-04f, 1.03157535e-02f,
  -3.86586450e-02f, -2.55389214e-01f, 7.89824054e-02f, 3.75901610e-02f, 2.59034541e-02f, -9.56952274e-02f, -6.76552728e-02f, -5.88425994e-02f, -4.76176105e-02f, -9.78952125e-02f,
  2.04164046e-03f, -7.83019885e-02f, -1.54382559e-02f, -1.30788703e-02f, 7.04038963e-02f, 1.33847641e-02f, 2.26736031e-02f, -3.91927250e-02f, 4.38947193e-02f, -5.84342144e-02f,
  -5.10039851e-02f, 2.61318982e-02f, -2.69454289e-02f, -8.01562518e-03f, -6.82225497e-03f, 1.49264885e-02f, -5.07820919e-02f, 1.91925243e-02f, 5.45334779e-02f, -8.68685916e-03f,
  1.36065587e-01f, -2.16617420e-01f, -1.02270946e-01f, 5.47065288e-02f, 1.06971145e-01f, 1.04679175e-01f, 2.18861997e-01f, -5.73451519e-02f, -9.77047235e-02f, -1.08407075e-02f,
  5.16723245e-02f, 6.94909990e-02f, -6.70672860e-03f, 7.37833232e-02f, 2.00721234e-01f, -6.84849247e-02f, 1.14549987e-01f, 2.94577274e-02f, -2.42672805e-02f, 1.16021574e-01f,
  -4.98103872e-02f, 2.38370895e-01f, -5.76894730e-02f, -1.46167697e-02f, 1.21519148e-01f, -1.77356638e-02f, 1.32840157e-01f, 8.24273303e-02f, -9.41348821e-02f, -6.30039489e-03f,
  3.83741222e-02f, -1.26744047e-01f, 1.68526843e-02f, -2.71707457e-02f, -6.24797568e-02f, 2.35993713e-02f, 1.18671115e-02f, 7.25053176e-02f, 5.35539985e-02f, -1.05722964e-01f,
  8.75530913e-02f, 2.45364457e-02f, -3.06601431e-02f, 9.54179913e-02f, -7.94233754e-04f, 8.97158589e-03f, -6.25057146e-02f, -6.71165362e-02f, -2.38551218e-02f, -4.66286130e-02f,
  -7.11690187e-02f, -8.88618976e-02f, -1.75704379e-02f, 1.68774463e-02f, 1.11134900e-02f, -4.84630466e-02f, -4.06699888e-02f, -2.12655701e-02f, -7.87704811e-02f, -6.63664415e-02f,
  1.17632017e-01f, 8.94147232e-02f, -3.08648031e-03f, 2.47428548e-02f, -6.78701028e-02f, 2.91484012e-03f, -4.07323726e-02f, -1.07450653e-02f, -7.55503215e-03f, -4.07766514e-02f,
  1.93017232e-03f, 7.61481896e-02f, 2.79702824e-02f, 4.19205800e-02f, -6.38395734e-03f, -1.94536448e-02f, 8.49576592e-02f, 6.71934627e-04f, 2.01469976e-02f, -6.60711527e-02f,
  -5.39943809e-03f, 2.64653135e-02f, 3.45575735e-02f, 5.41984662e-02f, -8.46720934e-02f, 4.59301323e-02f, -6.25974387e-02f, -5.10157421e-02f, -9.87342186e-03f, -6.68947399e-03f,
  2.67811418e-02f, 2.98337527e-02f, -9.34427381e-02f, 1.14002209e-02f, -4.35063913e-02f, 3.82289663e-02f, 3.50648686e-02f, -8.58580321e-02f, -4.75853831e-02f, 6.14382252e-02f,
  1.92634370e-02f, 3.43608554e-03f, -9.05329175e-03f, 9.71801803e-02f, 6.17680745e-03f, -2.48484854e-02f, 7.23189786e-02f, -1.57663133e-02f, -2.82549635e-02f, -6.06544651e-02f,
  -3.08572105e-03f, 6.71694800e-02f, 4.02315743e-02f, 6.23549260e-02f, 2.07153372e-02f, 2.78026983e-02f, 6.85385540e-02f, -4.46799621e-02f, 6.00483008e-02f, 3.56796421e-02f,
  1.66475505e-01f, -9.31971967e-02f, 1.50199281e-02f, -1.82906553e-01f, 1.99338645e-01f, 1.87496990e-01f, -3.18994280e-03f, 7.22352136e-03f, 4.60078865e-02f, -2.37630934e-01f,
  -1.07215531e-01f, -9.43392068e-02f, 1.28394663e-01f, -2.22506151e-01f, 2.19382599e-01f, 1.70789398e-02f, -8.10301974e-02f, -1.04039408e-01f, 4.92183268e-02f, -3.29745077e-02f,
  7.64848664e-02f, 2.70576123e-02f, 5.30661084e-02f, -3.27387429e-03f, -7.54441544e-02f, -1.88201427e-01f, -6.89346790e-02f, -2.18188018e-02f, -7.50650913e-02f, -1.72693264e-02f,
  -1.23213101e-02f, -1.55850739e-05f, 1.00537483e-02f, -5.79133481e-02f, -7.34680593e-02f, -7.54197538e-02f, 4.50697765e-02f, -7.46796653e-02f, 1.47020584e-03f, 7.06329942e-02f,
  -4.35257442e-02f, -9.02059823e-02f, 2.57617310e-02f, 9.87510197e-03f, 8.15149844e-02f, 3.14909928e-02f, 7.42493272e-02f, 6.42144829e-02f, -8.13350081e-02f, -2.44574361e-02f,
  3.74744684e-02f, -1.25043154e-01f, -5.26871830e-02f, -1.22248068e-01f, -3.53506394e-02f, -7.12109506e-02f, 4.71230969e-03f, -2.94475555e-02f, 5.84045053e-02f, 1.47556039e-02f,
  6.68120235e-02f, 1.09505594e-01f, -1.84767949e-03f, -9.42843035e-02f, -6.70332909e-02f, -2.38499488e-03f, 6.56287223e-02f, 5.55245616e-02f, 1.01308515e-02f, 4.35885303e-02f,
  1.64923761e-02f, -5.88273210e-03f, -3.17317024e-02f, 5.12410365e-02f, 4.67412965e-03f, -7.08538666e-02f, 8.48912168e-03f, -2.66287534e-04f, -8.55976939e-02f, -3.20191905e-02f,
  8.01538303e-02f, 8.56348053e-02f, -3.72037366e-02f, -5.37957400e-02f, -1.32810175e-01f, -2.34650541e-02f, -6.56422451e-02f, -6.45592213e-02f, 1.52108092e-02f, 2.29053367e-02f,
  -2.83741187e-02f, -6.76205084e-02f, -1.64444335e-02f, 5.61315678e-02f, 1.80651452e-02f, -4.12536152e-02f, -5.56076784e-03f, -3.56519371e-02f, 7.27184266e-02f, -5.57989590e-02f,
  -3.84601019e-02f, 1.69775020e-02f, 7.93896243e-02f, -5.15617020e-02f, -4.49456684e-02f, 2.58334484e-02f, -1.01493463e-01f, 8.54100212e-02f, 3.88638489e-02f, -4.71587218e-02f,
  -4.55559455e-02f, 3.23383883e-02f, -5.38572669e-02f, -7.63648972e-02f, 7.36638857e-03f, -3.00838929e-02f, 4.27403711e-02f, -5.43672070e-02f, 1.59089025e-02f, -2.37613395e-02f,
  -2.80918211e-01f, -2.47879773e-02f, -1.52103350e-01f, 2.79601775e-02f, -9.40255821e-02f, -4.35524173e-02f, -2.67544687e-02f, -1.04107723e-01f, -1.75623059e-01f, -5.43452054e-02f,
  -2.15577371e-02f, 5.98235503e-02f, -1.06611513e-01f, 2.26822987e-01f, 1.93593010e-01f, 1.99176252e-01f, 2.58713305e-01f, 2.08064333e-01f, 1.49842441e-01f, 3.96705195e-02f,
  2.13888720e-01f, 2.54778773e-01f, 2.73033977e-01f, 9.62474421e-02f, 1.52530208e-01f, -2.82799508e-02f, 1.24233909e-01f, -3.79233696e-02f, 1.18652806e-01f, 3.77971083e-02f,
  -6.27634451e-02f, -7.90944621e-02f, -4.52933274e-03f, 5.95546269e-04f, 6.27604872e-02f, -4.18426543e-02f, 1.09853961e-01f, -1.30027663e-02f, -5.16909286e-02f, -7.83283450e-03f,
  -3.32168257e-03f, -1.31647885e-02f, 3.24957557e-02f, 4.01528217e-02f, -7.33145475e-02f, -3.32469679e-02f, -2.07727961e-02f, -8.06075800e-03f, 1.74423233e-02f, 3.59802470e-02f,
  2.58098748e-02f, 3.51581685e-02f, -3.35053280e-02f, 1.81057621e-02f, 4.16717911e-03f, -4.93756533e-02f, -4.71231155e-02f, -2.51878928e-02f, 3.80565412e-02f, -1.08006252e-02f,
  -9.02868528e-03f, -2.14698147e-02f, -4.63545658e-02f, -4.29760069e-02f, -3.37321050e-02f, 6.54535815e-02f, -5.14231995e-02f, 5.47169037e-02f, -1.12667270e-02f, 6.34060726e-02f,
  -1.60470419e-02f, 7.12035596e-02f, -4.91269864e-02f, -3.21982205e-02f, 4.66224737e-02f, 7.58437859e-03f, 1.04870312e-02f, 5.38929626e-02f, -2.01719310e-02f, 1.62234865e-02f,
  -4.67059799e-02f, -3.14905718e-02f, 2.10801493e-02f, 3.93572152e-02f, -1.01719899e-02f, -7.14214693e-04f, 1.75544713e-02f, -5.99788874e-03f, 3.58727165e-02f, 7.63171911e-02f,
  1.21022530e-01f, 1.73350886e-01f, -1.25971548e-02f, 2.15657204e-02f, -6.19763415e-03f, -1.15970587e-02f, 2.42944574e-03f, 1.50541756e-02f, 4.31603491e-02f, 5.65243028e-02f,
  6.64129760e-03f, 1.70699805e-02f, 1.98851880e-02f, -3.61903347e-02f, 4.99061495e-02f, 1.28699308e-02f, 1.56614576e-02f, -8.59043561e-03f, 3.57376877e-03f, -1.79513581e-02f,
  -2.78308839e-02f, 4.58416576e-03f, -4.93207350e-02f, 2.84100957e-02f, -1.40974680e-02f, 3.03353462e-03f, -3.81458700e-02f, -3.04023823e-04f, 6.69441149e-02f, -5.45291742e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.10697466e-01f, -1.46784678e-01f, 9.32964087e-02f, 1.54295191e-01f, 1.84902385e-01f, 1.10894710e-01f, 4.17159721e-02f, 2.27500945e-02f, 1.58606887e-01f, -1.34827569e-01f,
  -6.23660237e-02f, -2.29294077e-02f, -2.55561322e-01f, 3.26244570e-02f, -3.33667360e-02f, -8.92444104e-02f, -4.01529707e-02f, 1.06385339e-03f, 5.21597937e-02f, -4.33930941e-02f,
  1.82481557e-01f, -1.59443133e-02f, 1.08814657e-01f, -6.29206607e-03f, 1.83188349e-01f, 1.26798600e-01f, 2.67727580e-02f, 6.05334565e-02f, -3.52196805e-02f, -7.70891309e-02f,
  -5.40768094e-02f, 2.53087524e-02f, 3.59801464e-02f, -8.32867399e-02f, -1.38056586e-02f, -8.63801464e-02f, 4.98892087e-03f, -1.83377806e-02f, 1.13705836e-01f, -5.07038161e-02f,
  -1.17549203e-01f, -6.00544028e-02f, 6.65696636e-02f, 1.03569545e-01f, 5.38720861e-02f, 8.62664208e-02f, 3.83236594e-02f, -3.50877680e-02f, 3.13710794e-03f, 5.62633276e-02f,
  -1.62982065e-02f, 2.42393203e-02f, 4.05309983e-02f, 8.32652450e-02f, -3.59010734e-02f, 4.77317162e-02f, -2.24915072e-02f, -3.77586074e-02f, -1.94577482e-02f, -1.67780891e-02f,
  6.99479431e-02f, -8.23531076e-02f, -4.16790396e-02f, 7.04053417e-02f, -6.98348060e-02f, -1.36987399e-03f, 4.53040153e-02f, -8.27735104e-03f, -7.48948827e-02f, 4.76484559e-03f,
  5.34791052e-02f, 5.68827242e-02f, -4.01447937e-02f, 5.49244918e-02f, 3.94391222e-03f, -3.39159630e-02f, -5.98204732e-02f, 1.37802260e-02f, -7.64815360e-02f, -5.99303693e-02f,
  4.39711921e-02f, 9.00963973e-03f, 5.52014560e-02f, 9.79723781e-02f, 1.92060750e-02f, 5.04572168e-02f, -4.48442921e-02f, 6.29125014e-02f, -1.51755959e-02f, -3.17536406e-02f,
  -4.18845326e-01f, -2.76659310e-01f, -1.48460343e-01f, 7.77802255e-04f, 1.30426176e-02f, 2.13126708e-02f, 4.14388254e-02f, 3.01880464e-02f, -1.14903823e-01f, 9.75759700e-02f,
  -2.30352189e-02f, -3.79424058e-02f, -4.64659259e-02f, -3.94108566e-03f, -8.42393488e-02f, 1.11781925e-01f, -1.06909066e-01f, -8.20618495e-02f, -9.68496129e-02f, -1.82041954e-02f,
  -1.64464470e-02f, 1.93976127e-02f, -7.44228438e-02f, 1.30887032e-01f, -8.64073336e-02f, 6.42229468e-02f, -2.85736248e-02f, -8.68362188e-02f, 6.40256256e-02f, -3.47817466e-02f,
  -9.65987071e-02f, -4.74740230e-02f, 1.09842457e-01f, 1.85641468e-01f, -9.92695689e-02f, -1.73807725e-01f, -3.04835498e-01f, 9.84211713e-02f, -1.28466189e-01f, -1.03845984e-01f,
  -8.77179056e-02f, 8.49418566e-02f, -1.49354339e-01f, 1.51429266e-01f, 1.14444092e-01f, -1.05277345e-01f, 9.42746401e-02f, -8.03890452e-02f, 8.01130533e-02f, 4.07187529e-02f,
  2.07067937e-01f, 1.16791189e-01f, 2.38957107e-01f, 8.97676870e-02f, 8.15114006e-02f, 1.64912000e-01f, 2.64573961e-01f, 2.18504574e-03f, 7.25574866e-02f, 6.92818314e-02f,
  3.54119693e-03f, 9.79045331e-02f, 5.93719259e-02f, -6.48188442e-02f, 4.39773351e-02f, -7.39553124e-02f, -6.19964786e-02f, 5.66975633e-03f, 7.87704811e-02f, -3.93702649e-02f,
  -3.09194624e-02f, 9.90456995e-03f, -1.50715355e-02f, 6.22783378e-02f, 5.58229862e-03f, 1.09398291e-01f, 9.15282667e-02f, -4.25550081e-02f, 2.48506889e-02f, -4.59338278e-02f,
  -2.36640163e-02f, 5.83657213e-02f, 3.50529179e-02f, -8.85244168e-04f, 4.25999090e-02f, 1.11859730e-02f, -1.66213289e-02f, -1.94940083e-02f, 2.23246543e-03f, 1.28282219e-01f,
  4.24716510e-02f, 4.19698805e-02f, -5.60780950e-02f, 3.39681134e-02f, 5.96282184e-02f, -2.18665097e-02f, 1.15031488e-02f, 8.06084871e-02f, 6.30286112e-02f, 2.24051494e-02f,
  -1.57637373e-02f, 4.06530127e-02f, 1.31765753e-03f, 5.27166855e-03f, 3.93957682e-02f, -3.25393453e-02f, 1.97853949e-02f, 4.97602187e-02f, 6.61477745e-02f, -4.61702868e-02f,
  -6.56690598e-02f, 9.05231107e-03f, -1.90756060e-02f, -4.51641604e-02f, -2.16576811e-02f, 7.24481642e-02f, 5.98231405e-02f, 1.62738245e-02f, 7.69354850e-02f, -5.72544597e-02f,
  -2.40612663e-02f, 1.07163303e-01f, -5.42133711e-02f, 7.97026828e-02f, 5.44908503e-03f, -1.05990000e-01f, 1.01754554e-01f, 5.23357466e-02f, -9.40677151e-03f, 1.62179619e-02f,
  -4.28452566e-02f, -2.89354604e-02f, 5.26257120e-02f, 4.51931311e-03f, 1.67832486e-02f, -2.39826925e-02f, 7.78843835e-02f, 7.27264509e-02f, 2.63820160e-02f, 1.18116587e-01f,
  6.08119331e-02f, -6.20612912e-02f, -2.86591966e-02f, -8.75547156e-02f, -4.00287770e-02f, -7.83574954e-03f, -4.03548498e-03f, -1.08930416e-01f, 7.47438222e-02f, 4.82866615e-02f,
  3.50350961e-02f, -3.36202383e-02f, -6.76411316e-02f, -5.74185066e-02f, -5.10351034e-03f, -1.70734510e-01f, -7.68630505e-02f, -1.40290726e-02f, -1.87602222e-01f, 1.93989873e-01f,
  3.24598774e-02f, -2.31544375e-02f, -1.14805982e-01f, -2.80046761e-01f, -3.62320662e-01f, -1.35159686e-01f, -1.76634580e-01f, -1.38887420e-01f, -1.35400191e-01f, 7.62548000e-02f,
  -2.90806368e-02f, -4.56695221e-02f, -2.00548738e-01f, 1.41236588e-01f, 3.76517102e-02f, 1.23848483e-01f, 5.00939339e-02f, 1.49916336e-01f, -2.43959315e-02f, -3.58312465e-02f,
  -2.46606935e-02f, 1.28447190e-02f, 3.53806652e-02f, -5.41916229e-02f, 4.18331623e-02f, 4.90864851e-02f, -4.27334663e-03f, 7.76791871e-02f, -8.42956454e-02f, 5.90569414e-02f,
  -3.80125232e-02f, -2.07220372e-02f, -6.40331879e-02f, -5.31439073e-02f, 3.70552726e-02f, 5.22485822e-02f, -2.68088952e-02f, -3.00011206e-02f, -2.19399016e-02f, 4.22035865e-02f,
  -1.51888698e-01f, -6.59103394e-02f, -7.47178122e-03f, -1.08315006e-01f, -8.91410708e-02f, -1.45130875e-02f, -1.15479082e-02f, -3.90638672e-02f, 1.86303277e-02f, -8.66666511e-02f,
  4.20769267e-02f, 1.71776228e-02f, -9.35936496e-02f, -1.72096454e-02f, -5.05817756e-02f, -8.06647688e-02f, -1.66389737e-02f, -4.57577966e-03f, 4.40753922e-02f, -3.42752002e-02f,
  3.22165452e-02f, -3.81877646e-02f, 2.32227724e-02f, 6.23661792e-03f, -5.15857227e-02f, -2.23758370e-02f, -5.29354513e-02f, 2.62839142e-02f, -3.78176570e-02f, -8.27559903e-02f,
  -4.37150672e-02f, 3.49902511e-02f, 8.91532935e-03f, -2.00225059e-02f, -4.39167246e-02f, -3.66639383e-02f, 7.20292926e-02f, -2.96156835e-02f, -3.35345045e-02f, -5.51872440e-02f,
  6.04862459e-02f, -1.46961231e-02f, 9.12218122e-04f, 1.08752064e-02f, -2.18318077e-04f, 4.51172329e-02f, 2.73460746e-02f, -1.43322609e-02f, -5.85044250e-02f, -4.86756582e-03f,
  3.01534589e-02f, -3.58848460e-02f, 4.62549180e-02f, -1.90722588e-02f, -4.72937099e-04f, 6.75146841e-03f, 4.40642051e-02f, -1.06594048e-01f, 6.78288639e-02f, -1.81512386e-02f,
  1.29883617e-01f, 6.45570159e-02f, 7.05562308e-02f, -1.09109394e-01f, 2.51832586e-02f, 8.32152590e-02f, -3.39734517e-02f, 7.13387728e-02f, 7.31635392e-02f, 2.43167710e-02f,
  -7.03387931e-02f, -1.67481378e-01f, 2.38666639e-01f, -1.97690532e-01f, 6.93939403e-02f, 1.25924662e-01f, 1.73713401e-01f, -8.35611671e-02f, -2.93949544e-01f, -2.16919184e-01f,
  -3.73442546e-02f, 4.75644358e-02f, 1.89977974e-01f, -9.83747467e-02f, 2.63849735e-01f, 9.32519883e-02f, -2.34025791e-01f, -5.58758639e-02f, 5.32363094e-02f, 2.83028800e-02f,
  -1.15032189e-01f, -1.13087654e-01f, 1.69672012e-01f, 2.42095478e-02f, 1.02499858e-01f, -1.25081271e-01f, -3.59651335e-02f, 2.19187945e-01f, -4.15689908e-02f, 1.34943977e-01f,
  9.95131731e-02f, -1.00372583e-02f, 9.96372327e-02f, -6.82164505e-02f, -1.46938926e-02f, 1.33099509e-02f, 6.38593361e-02f, 8.53706449e-02f, -1.32147104e-01f, -7.61064328e-03f,
  -8.94052610e-02f, -3.69952880e-02f, -6.15043938e-02f, -4.31049615e-02f, -2.92956047e-02f, -1.27277613e-01f, -5.93586154e-02f, 5.39641157e-02f, -1.37574747e-02f, 8.46899301e-02f,
  -4.90472373e-03f, 1.09190692e-03f, 1.33231224e-03f, 3.10994647e-02f, -7.97855668e-03f, -9.83106941e-02f, -8.40242431e-02f, 9.43421423e-02f, -4.05030139e-02f, -1.05331324e-01f,
  -7.15256482e-02f, -7.64714554e-03f, -2.09153593e-02f, 1.79298352e-02f, 1.16537310e-01f, -5.70867434e-02f, -6.13474548e-02f, 1.49379962e-03f, -1.74401309e-02f, -6.47827238e-03f,
  6.94405660e-02f, -1.49500901e-02f, 1.04216870e-03f, 5.55528589e-02f, -1.17392473e-01f, -7.31269643e-02f, 4.54538018e-02f, -7.00431019e-02f, -4.09017876e-02f, 3.50886025e-02f,
  -1.00952722e-01f, 4.25176099e-02f, -4.48717847e-02f, 5.26323989e-02f, -4.80875857e-02f, -2.54107695e-02f, 2.28436943e-02f, -2.81573962e-02f, 3.17914411e-02f, 9.94454399e-02f,
  -3.11804339e-02f, -8.88503417e-02f, 7.65745118e-02f, 5.87240979e-03f, 8.04348588e-02f, -6.01365492e-02f, 7.07913786e-02f, -7.71379396e-02f, -1.74034052e-02f, -2.90551828e-03f,
  -4.35089320e-03f, 1.63542293e-02f, 1.01000061e-02f, -4.99186032e-02f, -8.29516202e-02f, -3.83345596e-02f, -7.53921783e-03f, -1.01702712e-01f, -3.91907059e-03f, -1.03398124e-02f,
  -1.68070546e-03f, -3.70920897e-02f, 3.03685497e-02f, -5.48655726e-03f, -9.54052433e-02f, 1.39714219e-02f, 4.32451740e-02f, 9.70344767e-02f, -2.35830396e-02f, 2.87530050e-02f,
  -2.19990969e-01f, 7.96550289e-02f, -1.98300913e-01f, -1.30656838e-01f, 1.71898484e-01f, -1.03639409e-01f, -6.56653345e-02f, 5.48202172e-03f, -7.23691210e-02f, 3.58412117e-02f,
  1.37076452e-02f, 4.10308354e-02f, 3.59402262e-02f, -2.09142953e-01f, -3.78569394e-01f, -1.46784157e-01f, -1.64295182e-01f, -1.26399115e-01f, -8.92672911e-02f, -3.59580107e-03f,
  -1.31351173e-01f, -8.35391581e-02f, -1.93674654e-01f, 1.71271503e-01f, 7.28690252e-02f, 1.77767515e-01f, 1.77909940e-01f, 1.33973569e-01f, 1.10513464e-01f, -6.08731844e-02f,
  -1.10305049e-01f, -6.81909397e-02f, -3.28948162e-02f, -4.17958759e-02f, -3.55853587e-02f, 7.75247589e-02f, 5.16619496e-02f, 1.15306646e-01f, 3.81369963e-02f, 3.21936682e-02f,
  1.30658418e-01f, 6.60359636e-02f, -2.58931201e-02f, 1.95420701e-02f, -6.75304746e-03f, -4.21421900e-02f, 1.62496492e-02f, -5.19116223e-03f, -5.67704812e-02f, -2.33032685e-02f,
  -3.07213403e-02f, 1.37590077e-02f, 7.06451014e-02f, 1.93545874e-02f, -6.95517957e-02f, 2.99958810e-02f, -9.33801979e-02f, -2.19961796e-02f, -4.57480140e-02f, -3.19128372e-02f,
  3.78384106e-02f, 8.67289156e-02f, -1.28249023e-02f, -1.04586687e-02f, 3.24329734e-02f, 3.81904878e-02f, -6.20535482e-03f, 7.53172189e-02f, -8.42575077e-03f, 5.61928935e-03f,
  -5.76522853e-03f, 6.13938384e-02f, -1.82068888e-02f, 4.97115888e-02f, 9.42016020e-03f, 6.74545467e-02f, 1.01115331e-01f, -3.63212675e-02f, 1.06257061e-02f, -1.04510011e-02f,
  7.84165263e-02f, 1.54694887e-02f, -2.41661090e-02f, 9.38473567e-02f, -1.61695667e-02f, 2.25533284e-02f, 3.90212797e-02f, -2.65889000e-02f, 1.65453143e-02f, 8.46432671e-02f,
  9.27765446e-04f, 1.55631835e-02f, 1.98363867e-02f, 6.49063513e-02f, 2.08366588e-02f, 6.64769337e-02f, 1.49673754e-02f, -3.73927392e-02f, -6.40270934e-02f, -3.35291028e-02f,
  3.75436470e-02f, 1.19957924e-02f, 1.39210299e-02f, 6.04552403e-02f, 5.13239242e-02f, -8.62345938e-03f, -1.21124601e-02f, 1.10178351e-01f, -2.26773527e-02f, -4.99821641e-02f,
  4.16426137e-02f, 1.57073736e-02f, 4.37464230e-02f, 1.02258794e-01f, 1.10229790e-01f, 1.03482150e-01f, 1.17965445e-01f, 4.33278307e-02f, 4.86223213e-03f, -1.11755664e-02f,
  -3.45364213e-01f, 7.22247511e-02f, 2.01077655e-01f, -2.21873775e-01f, -2.50684768e-02f, 2.35660076e-01f, 2.25951448e-01f, -4.48881127e-02f, -1.86267078e-01f, -9.34168324e-02f,
  9.36248899e-02f, -1.10434197e-01f, 1.98547155e-01f, -3.01450584e-02f, 2.18591064e-01f, 6.42088279e-02f, -1.64995585e-02f, 3.30995470e-02f, -1.12842359e-01f, -1.37508258e-01f,
  4.94417362e-03f, -7.93075636e-02f, 2.21989840e-01f, -3.38093899e-02f, -8.25057030e-02f, 2.28237454e-02f, -1.09349549e-01f, 1.73720896e-01f, 1.86479278e-02f, -3.13532399e-03f,
  3.36205494e-03f, -2.59592891e-01f, 5.31629138e-02f, 9.50271487e-02f, 7.37840589e-03f, -1.50714992e-02f, 1.19562253e-01f, -5.21544702e-02f, -6.54291436e-02f, -1.32911447e-02f,
  1.70084008e-03f, -7.77177438e-02f, -5.76473512e-02f, 8.99817124e-02f, -1.14454888e-01f, -6.57247603e-02f, 7.37043917e-02f, -1.27516668e-02f, 9.17661877e-04f, 2.37585092e-03f,
  8.98162946e-02f, 1.11653991e-02f, 6.36213571e-02f, 2.22027879e-02f, 9.57536977e-03f, 2.30140239e-02f, 2.80444119e-02f, 4.99888919e-02f, -4.59992625e-02f, -5.34909852e-02f,
  1.97623912e-02f, -8.49415585e-02f, 6.65676594e-02f, -5.30835651e-02f, -3.45206447e-02f, 1.71364620e-02f, 8.39210488e-03f, 1.14558209e-02f, -6.84646145e-02f, 4.44405340e-02f,
  -5.36425263e-02f, -3.53554897e-02f, 5.30649070e-03f, 4.13218653e-03f, -7.84409940e-02f, 4.76692989e-03f, 6.58600032e-02f, 1.56198032e-02f, 5.36886528e-02f, 6.25854209e-02f,
  4.80431728e-02f, 4.83334623e-02f, 3.24584264e-03f, 3.43132652e-02f, 1.05740629e-01f, 2.27396693e-02f, -1.47906481e-04f, 1.86523255e-02f, 1.46630052e-02f, -1.36546148e-02f,
  -1.69822514e-01f, -2.95247942e-01f, -8.23890045e-02f, -9.12634656e-02f, -5.95306186e-03f, 6.26652539e-02f, 7.72258192e-02f, -4.21922617e-02f, 5.16488077e-03f, -2.78418362e-02f,
  -8.01623762e-02f, -9.11904126e-03f, -7.80995935e-02f, 2.07932461e-02f, 5.71280234e-02f, 6.48277402e-02f, 2.75009144e-02f, 2.74727531e-02f, -3.09055764e-03f, -8.10563266e-02f,
  1.31212128e-02f, -8.03592578e-02f, -1.32806487e-02f, -1.94100719e-02f, 3.21152806e-02f, 1.65632591e-02f, -1.28652766e-01f, 1.57987494e-02f, 3.30282785e-02f, -5.48370462e-03f,
  -2.39790529e-01f, -9.47320238e-02f, -1.06159024e-01f, -8.23884085e-02f, -1.81914330e-01f, -2.70831257e-01f, -1.25948220e-01f, -1.54017463e-01f, -2.56622694e-02f, 1.65880919e-01f,
  3.97946984e-02f, -1.65641308e-01f, 1.42529473e-01f, 1.85909793e-02f, -9.83685479e-02f, 2.35429883e-01f, -8.10471252e-02f, -5.37194386e-02f, 1.38504924e-02f, -1.24573991e-01f,
  -2.21606269e-02f, 3.95998992e-02f, -1.02621894e-02f, -1.06155589e-01f, -1.81773424e-01f, -9.52245668e-02f, 1.54725537e-01f, -1.70012638e-01f, -7.10282400e-02f, -8.00301582e-02f,
  -1.34774894e-02f, -9.09153968e-02f, 5.27069205e-03f, -6.19568788e-02f, -6.63772672e-02f, -4.25055176e-02f, -8.15846696e-02f, -2.53028832e-02f, -2.49554068e-02f, -1.27327532e-01f,
  1.86046995e-02f, 3.04684043e-03f, -3.38220634e-02f, 7.63075799e-02f, -1.81406550e-02f, 2.16771346e-02f, 4.47440371e-02f, 5.08995615e-02f, -1.08048275e-01f, 5.39278202e-02f,
  -5.04715741e-02f, -1.28619699e-02f, -2.24258155e-02f, 6.88567385e-02f, 2.96435002e-02f, -4.90998849e-02f, 7.90553764e-02f, 2.20484007e-02f, -6.60264678e-03f, -8.89482256e-03f,
  -4.59679328e-02f, 8.49984884e-02f, 5.04079871e-02f, -6.05023000e-03f, 1.68183073e-02f, 1.93397105e-02f, 8.38252250e-03f, 3.27006658e-03f, 4.48337160e-02f, 6.56172186e-02f,
  2.36075483e-02f, 1.16423741e-02f, -3.74483652e-02f, 8.59438479e-02f, 5.77403754e-02f, -6.49776086e-02f, -3.40943155e-03f, -3.58967716e-03f, 4.15009521e-02f, -5.49036115e-02f,
  4.33502607e-02f, -2.92432513e-02f, 8.69516283e-02f, 2.52725240e-02f, -2.49622539e-02f, -2.83817528e-03f, 9.00026038e-03f, -4.55227494e-03f, 3.10060792e-02f, -5.34269437e-02f,
  -1.48009881e-01f, -1.04095273e-01f, 8.35983828e-02f, -9.02224183e-02f, 7.66456425e-02f, 5.22767231e-02f, -9.24896374e-02f, -3.25429961e-02f, -1.31911352e-01f, -7.65571520e-02f,
  3.67146954e-02f, 7.61695951e-02f, 2.90538725e-02f, -1.49457539e-02f, 1.55557394e-02f, 5.29894121e-02f, -4.35398594e-02f, -3.27108726e-02f, -4.02953662e-02f, -1.48389041e-02f,
  -2.77941418e-03f, 5.17312959e-02f, 1.01808980e-01f, 3.38870212e-02f, -1.61504634e-02f, 2.72420477e-02f, -7.72973523e-02f, 4.61683497e-02f, -7.78804021e-03f, -5.64136170e-02f,
  9.80777740e-02f, 5.93362935e-02f, 9.68783125e-02f, -3.28636691e-02f, 1.88636079e-01f, 2.07406297e-01f, 1.61843464e-01f, 9.57637429e-02f, 9.70883295e-02f, -2.54534215e-01f,
  -2.06955642e-01f, -1.09562337e-01f, -3.74192074e-02f, -9.67021585e-02f, 5.31116836e-02f, 6.31232606e-03f, 3.00789289e-02f, 1.02282323e-01f, 6.93760291e-02f, 1.47448450e-01f,
  1.03763051e-01f, -1.06032722e-01f, 1.26751259e-01f, -2.37503499e-02f, 1.40222654e-01f, 8.55436735e-03f, -5.06734028e-02f, 1.50290370e-01f, -2.29005575e-01f, 1.37507841e-02f,
  1.00880750e-01f, -5.00786193e-02f, 9.65684950e-02f, -1.04422860e-01f, 6.13581762e-02f, -5.28478250e-02f, -4.97347862e-02f, 3.91803905e-02f, -2.18228865e-02f, -3.44321206e-02f,
  -3.20522264e-02f, -1.24876089e-01f, -8.84131789e-02f, 5.22737205e-02f, 2.45807841e-02f, -1.10042147e-01f, 8.61930568e-03f, 1.22919403e-01f, -9.43858624e-02f, 7.26933405e-02f,
  -4.11795219e-03f, 5.11013828e-02f, -1.97222596e-03f, -4.08781096e-02f, -2.18788143e-02f, -8.47885758e-02f, 9.24128890e-02f, -6.27296865e-02f, -1.19067095e-02f, -1.16342437e-02f,
  4.05741259e-02f, 2.37418041e-02f, 2.10615830e-03f, 6.16890565e-03f, -5.58596291e-02f, -3.42989266e-02f, -8.64507537e-03f, 7.72944978e-03f, -1.08815730e-02f, 8.84945393e-02f,
  -3.91249321e-02f, 5.22360057e-02f, 6.70566112e-02f, 1.68612623e-03f, -6.64996952e-02f, -4.96217832e-02f, -1.14309996e-01f, 5.43886423e-02f, -4.52056788e-02f, 1.34495586e-01f,
  -5.95808076e-03f, -7.16411844e-02f, -1.41014718e-02f, -5.36673926e-02f, -5.90641284e-03f, 3.18134762e-02f, 1.35365007e-02f, 4.70293127e-02f, 1.74458064e-02f, -4.01783213e-02f,
  1.98096037e-02f, -7.07582757e-02f, 8.00563842e-02f, -5.53318001e-02f, 6.18977770e-02f, -1.21594980e-01f, -2.66139433e-02f, 3.71416245e-04f, -7.91208744e-02f, -1.52586699e-02f,
  -1.04037851e-01f, 1.62642710e-02f, 3.69273163e-02f, 2.93411687e-03f, -7.75140151e-02f, -1.54767679e-02f, -7.16474205e-02f, -5.56120183e-03f, -4.37494107e-02f, 2.19465792e-02f,
  4.66363020e-02f, -6.81900829e-02f, -8.11503362e-03f, 6.70708492e-02f, -1.28130600e-01f, -9.85520929e-02f, 4.94537354e-02f, -2.05501691e-02f, -5.47816269e-02f, -8.92563760e-02f,
  -2.14137211e-01f, 1.83086991e-02f, 2.38356724e-01f, -2.07373008e-01f, 6.00549132e-02f, 1.80417970e-01f, -1.20411860e-02f, -9.44436640e-02f, -1.31472230e-01f, -6.42157644e-02f,
  -3.49398926e-02f, -1.72613282e-02f, 1.90160960e-01f, -5.74749336e-02f, 1.01658896e-01f, 1.19658865e-01f, -1.58051789e-01f, -1.21096358e-01f, 8.85882154e-02f, -1.15477694e-02f,
  -4.25539911e-02f, -9.88283008e-02f, 1.51455089e-01f, 6.46689758e-02f, 8.69415328e-02f, -1.82913598e-02f, -2.29074731e-02f, 2.05301970e-01f, -4.20242287e-02f, 1.79561272e-01f,
  -1.24040775e-01f, -1.68023035e-01f, -2.11780280e-01f, -1.18580528e-01f, -9.04150903e-02f, -3.02326884e-02f, 8.24127905e-03f, -1.63719859e-02f, -5.02628461e-03f, 6.68288320e-02f,
  6.14320748e-02f, 8.63018706e-02f, -3.55099700e-02f, -6.51012957e-02f, -4.70343567e-02f, -1.36252828e-02f, 1.06233202e-01f, 7.51910452e-03f, -8.43111891e-03f, 1.47597790e-01f,
  6.32786751e-02f, 5.39597198e-02f, -7.50246271e-02f, -5.11623807e-02f, 9.83984470e-02f, -6.30230159e-02f, 1.18571920e-02f, 1.13207139e-01f, 9.41006988e-02f, -6.14954866e-02f,
  -2.32957327e-03f, 9.07717571e-02f, -1.86537281e-02f, -5.24936207e-02f, 5.65367974e-02f, -5.33689521e-02f, -3.71101052e-02f, 8.59467387e-02f, 5.24973460e-02f, 5.80174625e-02f,
  -7.72201717e-02f, -3.75744663e-02f, -4.06669937e-02f, -3.52572650e-02f, 6.95712790e-02f, -3.72124203e-02f, -3.16019133e-02f, 2.64542010e-02f, -4.39155987e-03f, 4.30235602e-02f,
  -5.85018583e-02f, -8.10955986e-02f, 1.05677538e-01f, 1.24147251e-01f, -4.95958030e-02f, 2.76876912e-02f, -1.00744545e-01f, 7.07541183e-02f, 3.99666764e-02f, 1.60337180e-01f,
  -3.09475273e-01f, -2.36398980e-01f, 7.59770116e-03f, -1.52889863e-01f, -7.89476559e-02f, 3.84192877e-02f, 1.75858047e-02f, 1.73495393e-02f, -5.35374470e-02f, -6.10865392e-02f,
  -2.61116195e-02f, -5.55086732e-02f, -1.87944137e-02f, -2.10019271e-03f, 9.87216756e-02f, -1.07504120e-02f, -7.77598247e-02f, -1.20996730e-03f, -8.77606124e-02f, 4.17387486e-02f,
  -3.50853913e-02f, -7.48936310e-02f, 9.63939503e-02f, -3.16067860e-02f, -2.84819538e-03f, 3.13825645e-02f, -4.93385158e-02f, -7.10422620e-02f, 4.11349498e-02f, -5.44438288e-02f,
  2.55101889e-01f, -3.11335415e-01f, 4.68243957e-02f, 1.24028318e-01f, 2.30409145e-01f, 2.45886520e-02f, 2.22984657e-01f, -7.06752166e-02f, -1.46187723e-01f, -1.77364260e-01f,
  5.65272979e-02f, -4.89359200e-02f, -9.01917070e-02f, -6.93722293e-02f, 2.20463753e-01f, -1.24238282e-01f, 3.45548359e-03f, 1.09330341e-01f, 6.08464656e-03f, 6.28675595e-02f,
  4.61589061e-02f, 7.88009018e-02f, -8.49538967e-02f, -3.84575203e-02f, 7.84978196e-02f, -1.69007063e-01f, 5.79850487e-02f, -4.06210963e-03f, 9.85131264e-02f, 6.81120455e-02f,
  -3.57124135e-02f, -8.16166624e-02f, 5.08311763e-02f, -9.32457671e-02f, -3.22750397e-02f, -4.34162303e-06f, 9.18258727e-02f, 1.56591713e-01f, 3.17522027e-02f, -4.08267267e-02f,
  -1.06771834e-01f, -1.77584644e-02f, -5.53388409e-02f, -6.88279094e-03f, -2.04529166e-02f, -4.45477180e-02f, 1.23542817e-02f, -9.31340009e-02f, -6.13695160e-02f, -5.93752153e-02f,
  -6.12273104e-02f, 2.44028531e-02f, 3.60105000e-02f, 3.51495594e-02f, 7.79138459e-03f, -5.19500673e-02f, -5.17078750e-02f, -2.66570970e-02f, 3.27867344e-02f, -2.47507729e-02f,
  4.69795354e-02f, 3.59897614e-02f, 2.82054227e-02f, 7.59390788e-03f, 4.76050861e-02f, 9.58476067e-02f, 3.10733356e-02f, 3.96902999e-03f, 2.32046307e-03f, -2.04424448e-02f,
  4.42392156e-02f, 5.33785634e-02f, 6.19615130e-02f, -3.18013206e-02f, 5.81308408e-03f, 3.30893360e-02f, -2.54117331e-04f, 4.54428904e-02f, -1.09078966e-01f, -8.26735422e-03f,
  2.38079578e-02f, 1.59519929e-02f, -4.04856838e-02f, 9.67226084e-03f, -1.90950949e-02f, 4.15028818e-02f, 5.14047667e-02f, 4.93743755e-02f, -4.14213305e-03f, 6.56451806e-02f,
  2.10763421e-02f, -2.22031057e-01f, -2.19797082e-02f, 9.09415260e-02f, -1.13757484e-01f, -7.23311752e-02f, 6.57046214e-02f, -7.87106529e-03f, -2.06321739e-02f, -3.93085415e-03f,
  -8.00427794e-03f, 4.51064743e-02f, -6.64690062e-02f, 7.32800588e-02f, 5.41604236e-02f, -5.83772026e-02f, 6.44463813e-03f, 1.01725161e-02f, -3.57782096e-02f, 4.24943417e-02f,
  -4.13251780e-02f, -4.67462465e-02f, 1.72080472e-02f, -1.79955978e-02f, -3.47723514e-02f, 4.70580347e-03f, -2.73168124e-02f, -7.98780993e-02f, 2.86700465e-02f, 3.08064539e-02f,
  -3.75596315e-01f, 8.34726989e-02f, -1.38790026e-01f, -6.32170811e-02f, -9.36788693e-02f, -1.85280159e-01f, -3.43826488e-02f, -1.90589115e-01f, -5.04433401e-02f, 1.88452199e-01f,
  1.07918397e-01f, -1.35767370e-01f, 9.64072570e-02f, 2.88785677e-02f, -2.03128293e-01f, 1.72846735e-01f, -5.14372624e-03f, 3.99491191e-02f, 1.74600799e-02f, -1.08680129e-01f,
  -7.02776983e-02f, -7.46519305e-03f, -8.60491171e-02f, -8.55247676e-02f, -1.23263873e-01f, -3.27502899e-02f, 8.94270018e-02f, -1.45170158e-02f, 3.22216284e-03f, -5.89352660e-02f,
  -9.62766930e-02f, -2.04019487e-01f, -7.97247514e-02f, -6.16461188e-02f, -1.06476478e-01f, -9.14656147e-02f, -6.32337779e-02f, 3.72891352e-02f, -1.83583964e-02f, -3.83426845e-02f,
  -8.00257027e-02f, -4.22075428e-02f, 5.63937500e-02f, 6.01747073e-03f, -1.53931538e-02f, -6.78726062e-02f, -2.48268303e-02f, 2.11755559e-02f, -1.99600738e-02f, -8.39233845e-02f,
  -2.88636610e-02f, -7.49429762e-02f, -2.69330330e-02f, -2.12811455e-02f, 7.73817301e-02f, 5.48869148e-02f, 5.06924950e-02f, -1.43757269e-01f, -4.64060307e-02f, -8.61795768e-02f,
  -3.58227603e-02f, 3.01381238e-02f, 1.73672475e-02f, 1.35878667e-01f, -2.77256016e-02f, 5.29180057e-02f, 1.48785114e-02f, 5.38461842e-02f, 2.69899890e-02f, -9.65684801e-02f,
  -7.04286247e-02f, -1.85246989e-02f, 3.29621434e-02f, -3.28697562e-02f, -4.96417172e-02f, 2.45615281e-02f, -3.29226255e-02f, 7.92446453e-03f, 5.44114150e-02f, -1.35230469e-02f,
  2.91511621e-02f, 1.67689566e-02f, 1.92248560e-02f, 4.93127154e-03f, -2.45107785e-02f, 8.83558393e-02f, -4.07194197e-02f, 8.07068544e-04f, 1.22029018e-02f, 5.12429625e-02f,
  -1.36473075e-01f, -2.00390115e-01f, 1.78805552e-02f, 6.48894580e-04f, 3.40352058e-02f, -6.46765009e-02f, -6.75151264e-03f, -5.02131768e-02f, 8.61187875e-02f, -7.43042976e-02f,
  -1.28910430e-02f, 4.93679903e-02f, -7.48333260e-02f, 6.51462972e-02f, -5.89002557e-02f, -2.25483859e-03f, -1.37835937e-02f, -2.70702541e-02f, -1.96001455e-02f, 1.01873083e-02f,
  -2.27488540e-02f, -3.17868916e-03f, -1.21593801e-02f, 9.22212675e-02f, -3.82913812e-03f, -4.48034555e-02f, -8.36346447e-02f, -3.96442525e-02f, -8.79978538e-02f, -5.84404729e-03f,
  -1.48965999e-01f, 1.36641204e-01f, -2.30788842e-01f, 5.61831482e-02f, -9.41686332e-03f, -1.16368383e-02f, 2.31060050e-02f, 1.13653839e-02f, -4.35543656e-02f, 1.24957845e-01f,
  1.24352239e-01f, -2.11552784e-01f, -1.29287466e-02f, 1.66741103e-01f, -2.04325765e-01f, 7.74884038e-03f, 6.35951161e-02f, 1.30616188e-01f, -8.73903260e-02f, 5.63510954e-02f,
  -9.83024463e-02f, 1.87965289e-01f, 3.73134091e-02f, 6.87022731e-02f, -1.83095969e-02f, -8.69070143e-02f, 2.06896409e-01f, -2.92207859e-02f, 1.05633639e-01f, 1.85468059e-03f,
  -2.16853656e-02f, -7.56033063e-02f, -6.92284629e-02f, -1.51110888e-02f, -2.70744767e-02f, -2.29529012e-02f, 1.93984751e-02f, -1.34665087e-01f, -7.56829828e-02f, -4.76273708e-03f,
  -5.17398305e-02f, -9.58979055e-02f, -2.48713959e-02f, -2.69472208e-02f, 5.87813416e-03f, -5.13479626e-03f, -1.06894970e-01f, 1.12148784e-02f, 2.00147144e-02f, 3.27413116e-04f,
  3.28624770e-02f, 2.74189189e-02f, 2.55316570e-02f, 1.74805839e-02f, -1.23037055e-01f, 4.43570018e-02f, 4.34654392e-03f, 2.97735278e-02f, -1.79240368e-02f, 2.86548603e-02f,
  -9.57200527e-02f, 8.99148360e-02f, -2.54586246e-02f, -7.52805769e-02f, -5.41366227e-02f, -6.93965405e-02f, -5.80938421e-02f, 3.39147970e-02f, -1.38706326e-01f, 8.72400627e-02f,
  -1.03220176e-02f, 1.04247062e-02f, 4.98289987e-02f, -9.84189752e-03f, 1.02507606e-01f, 1.79611400e-01f, 5.96352443e-02f, -5.88382445e-02f, -1.25221029e-01f, 3.16741280e-02f,
  -5.46780415e-02f, -2.00153068e-02f, -1.73953306e-02f, -6.06197724e-03f, -1.76618025e-02f, -1.76202003e-02f, 1.33143141e-04f, -6.10370487e-02f, -9.38214436e-02f, 2.62504071e-02f,
  1.34343952e-01f, -3.20526101e-02f, -1.47621959e-01f, 2.54773032e-02f, 6.66406602e-02f, -2.38321275e-02f, -1.12764100e-02f, -1.13367893e-01f, -1.59969795e-02f, 1.04001872e-02f,
  5.44324815e-02f, 3.86339016e-02f, 4.16006818e-02f, -6.05444200e-02f, -1.33619472e-01f, 1.02124989e-01f, 9.22467411e-02f, -4.71597016e-02f, 9.22273770e-02f, -5.41808531e-02f,
  1.29277363e-01f, 4.84354496e-02f, -7.39436746e-02f, 5.47012910e-02f, 7.16814846e-02f, 9.16438028e-02f, -1.09088331e-01f, 2.64474638e-02f, 8.34803190e-03f, -7.92922229e-02f,
  1.92067459e-01f, -2.79448062e-01f, -3.38464044e-02f, 2.56464660e-01f, 1.28066897e-01f, 6.90517351e-02f, 1.77724231e-02f, -5.18045090e-02f, 1.51529968e-01f, -8.41712728e-02f,
  -6.34884322e-03f, -1.36724398e-01f, -2.11383909e-01f, 3.74074429e-02f, 4.82128449e-02f, -1.93365112e-01f, 6.02114499e-02f, -7.90962651e-02f, -1.47469407e-02f, -1.40965089e-01f,
  1.41087715e-02f, -4.35259864e-02f, -6.65740669e-02f, 5.69984466e-02f, 2.27658659e-01f, 8.59435368e-03f, 4.56571393e-02f, 4.73025069e-02f, 7.89646134e-02f, -1.00464633e-04f,
  3.04750688e-02f, -7.25506693e-02f, 2.13738307e-02f, -3.64793353e-02f, 1.27934674e-02f, 1.05938882e-01f, -3.38267139e-03f, -1.12066634e-01f, 4.60752426e-03f, -2.94853691e-02f,
  -4.77481745e-02f, 5.58999069e-02f, 9.04958323e-02f, 3.48152071e-02f, 1.66948438e-01f, 1.36238933e-02f, 8.61273557e-02f, 7.43358582e-02f, -6.77130744e-03f, -6.74631447e-02f,
  -4.98210974e-02f, -5.85761890e-02f, -1.15592973e-02f, -3.26641910e-02f, -5.48114907e-03f, -2.40832772e-02f, 8.48019589e-03f, -8.11070204e-04f, -3.55161354e-02f, -2.18824483e-02f,
  -9.22414288e-02f, 1.46415727e-02f, -2.33371463e-02f, 5.49231358e-02f, 1.38020767e-02f, 1.65314041e-02f, 2.97498871e-02f, 1.96911278e-04f, 4.33587506e-02f, 9.21704769e-02f,
  3.70644853e-02f, 6.64930940e-02f, -1.16447248e-02f, 4.76244874e-02f, 1.20003959e-02f, -3.79320048e-03f, 2.23922562e-02f, -2.59895064e-02f, 5.18524125e-02f, 1.18156530e-01f,
  6.23771129e-03f, -2.46887393e-02f, -2.31776945e-02f, 4.42693755e-02f, -6.35033697e-02f, -4.02938947e-02f, 8.16268623e-02f, 2.04574354e-02f, 4.18493152e-02f, 8.99500959e-03f,
  1.27784396e-02f, -2.37340897e-01f, -2.87288856e-02f, -3.59658003e-02f, 5.59407733e-02f, 4.25774120e-02f, -8.35586712e-02f, 1.94595382e-02f, -7.69950822e-02f, -6.44671991e-02f,
  -2.52157450e-02f, 2.44556293e-02f, -5.66819496e-02f, 4.90604937e-02f, 1.72881503e-02f, -2.03689411e-02f, -1.61370449e-02f, -2.40147989e-02f, 2.02142164e-01f, -8.59186575e-02f,
  -5.49568422e-02f, 3.66925932e-02f, 8.24664682e-02f, -2.50478997e-03f, 1.43188551e-01f, -1.08134687e-01f, -8.96835849e-02f, -1.09563973e-02f, 2.62131337e-02f, -9.92227066e-03f,
  -1.68988869e-01f, 2.71600008e-01f, 2.42481321e-01f, -5.31791672e-02f, 1.33083448e-01f, 1.41861662e-01f, 1.70238107e-01f, -3.26259471e-02f, 9.62814391e-02f, -1.74514800e-01f,
  -1.72475919e-01f, 8.23156238e-02f, -8.01108703e-02f, -3.18109170e-02f, -9.30266678e-02f, -3.52014601e-02f, -3.22813243e-02f, -9.07040015e-02f, 2.47141659e-01f, 1.78336259e-02f,
  2.35005561e-02f, -8.21195096e-02f, 6.27417266e-02f, 7.56621063e-02f, -6.45823404e-03f, 3.04204710e-02f, -1.71434700e-01f, 1.06790222e-01f, 5.99396490e-02f, 5.94748445e-02f,
  6.55806586e-02f, 5.32575771e-02f, 6.18334897e-02f, 8.41374788e-03f, -9.90765020e-02f, 4.46525030e-02f, 4.94604968e-02f, 6.22969270e-02f, 1.38135508e-01f, -2.90623344e-02f,
  -1.13627076e-01f, -7.22958520e-02f, 4.73096408e-02f, -8.40745308e-03f, 1.06908843e-01f, 4.59930766e-03f, 7.62153640e-02f, 5.70281222e-02f, 1.14868090e-01f, 5.94810136e-02f,
  -5.27712628e-02f, 1.64217819e-02f, 7.30151013e-02f, -2.07487270e-02f, 6.23344705e-02f, 7.26270005e-02f, 4.44149077e-02f, -3.56666259e-02f, -3.06674186e-02f, 1.10051297e-01f,
  1.18144006e-02f, 4.03726436e-02f, -1.76511537e-02f, -6.42351806e-02f, 7.52333179e-02f, -1.07582323e-01f, 4.83888993e-03f, -9.60943997e-02f, 9.74046290e-02f, -1.69882700e-01f,
  -9.21853259e-02f, -1.04171187e-02f, -6.03268854e-02f, -5.55005223e-02f, -3.27509046e-02f, -2.59565413e-02f, -4.71738018e-02f, -2.05264054e-02f, -6.59492239e-02f, -5.67578822e-02f,
  2.16688924e-02f, -1.29393749e-02f, -1.27689645e-01f, -5.26872464e-02f, 7.70012587e-02f, 7.88425505e-02f, -1.01279132e-01f, -2.78049614e-02f, -2.12284438e-02f, -2.62878891e-02f,
  1.98220368e-02f, -7.12393150e-02f, 2.38684323e-02f, -8.28315020e-02f, 5.23717627e-02f, -4.16763052e-02f, -6.29990622e-02f, 1.06381131e-02f, 1.61570907e-01f, -5.09714223e-02f,
  8.17808975e-03f, -8.81045535e-02f, 2.51002256e-02f, 5.17696235e-03f, 8.52707028e-03f, 4.70861793e-02f, 4.69975658e-02f, -1.29724434e-02f, 7.25287721e-02f, -8.79790187e-02f,
  -8.01991150e-02f, 1.30925188e-02f, -1.20822318e-01f, -3.12366011e-03f, -2.48361714e-02f, 8.17939490e-02f, -5.12678176e-02f, 5.91341034e-02f, -1.81056547e-03f, 4.89076264e-02f,
  5.42345010e-02f, -1.17066763e-01f, -1.53384328e-01f, -2.74470337e-02f, -1.24408558e-01f, -2.45710075e-01f, -2.34230399e-01f, -6.59715310e-02f, 3.30141820e-02f, -2.94380635e-01f,
  -1.68691933e-01f, 1.20352834e-01f, 2.88654808e-02f, -1.84033617e-01f, 2.45575249e-01f, 6.38106838e-02f, -2.05976784e-01f, -1.43245146e-01f, -9.73864496e-02f, -8.33690614e-02f,
  3.28618549e-02f, -1.97104201e-01f, 2.47500017e-02f, -2.13671416e-01f, -2.06652060e-01f, 1.13000171e-02f, 1.79216713e-01f, -5.75523674e-02f, -4.09783423e-02f, 1.18731810e-02f,
  2.03253441e-02f, 1.98085140e-02f, 4.02412042e-02f, -2.06749495e-02f, -1.90644953e-02f, 1.38261367e-03f, -8.18539932e-02f, 4.68831174e-02f, 1.88104610e-03f, 5.88912219e-02f,
  8.76894221e-02f, 3.16335000e-02f, -3.56970690e-02f, 6.54835701e-02f, 1.89614221e-02f, -3.35794128e-02f, 9.07650366e-02f, 5.39404340e-02f, -8.05607717e-03f, 6.14724075e-03f,
  -4.41674516e-02f, 2.06721146e-02f, -6.62635043e-02f, 1.33062497e-01f, -6.90719206e-03f, -1.03901602e-01f, -3.91019136e-02f, 9.27225947e-02f, 4.97092605e-02f, 5.03002368e-02f,
  5.60597330e-03f, 6.35076733e-03f, -5.66802323e-02f, 4.98276688e-02f, -4.78407219e-02f, 5.84909052e-04f, -8.61435011e-02f, 5.19957319e-02f, 2.34222542e-02f, 2.40831729e-02f,
  5.80388643e-02f, 6.75885603e-02f, -2.85423920e-02f, -7.51724839e-02f, -7.90092126e-02f, 4.07674201e-02f, -2.25650929e-02f, 3.40254121e-02f, -5.01265377e-03f, 1.62652954e-02f,
  3.95182110e-02f, -1.21044144e-01f, -2.24786382e-02f, -1.12084458e-02f, -6.97149634e-02f, 3.88608612e-02f, -2.15777010e-02f, -5.42373359e-02f, 9.74732861e-02f, 4.74426337e-02f,
  3.14345397e-02f, -6.89480603e-02f, -2.77401954e-02f, -1.91851563e-04f, -6.31530285e-02f, 2.90327258e-02f, -5.00361510e-02f, 3.83757018e-02f, 3.87623981e-02f, -1.15200460e-01f,
  7.99138751e-03f, -3.18928771e-02f, 9.09206420e-02f, -8.95084348e-03f, 2.56573763e-02f, 4.22924012e-03f, 4.03101407e-02f, 1.57963857e-02f, 1.01898052e-01f, -1.21040381e-01f,
  -5.51039390e-02f, -2.48160996e-02f, -8.33116472e-02f, -1.89911369e-02f, -2.08475739e-02f, 4.69761565e-02f, 3.32499743e-02f, -3.31349522e-02f, 2.13027094e-02f, -1.31428912e-02f,
  5.27417585e-02f, 1.02695383e-01f, 2.19759345e-02f, -2.33622655e-01f, -1.83493588e-02f, -2.14634314e-01f, -3.01616848e-01f, 1.17800727e-01f, 2.35916942e-01f, 1.21790722e-01f,
  -7.63167515e-02f, -2.81162728e-02f, 9.61067751e-02f, -1.13797463e-01f, 2.99022142e-02f, 9.58944559e-02f, -1.88152298e-01f, -1.58500910e-01f, -1.97463632e-02f, -1.98587596e-01f,
  -8.05292185e-03f, -1.53392509e-01f, -1.42467543e-01f, -1.02760918e-01f, -8.69936720e-02f, -6.20665587e-03f, 4.08477448e-02f, 5.59297204e-02f, 1.07193238e-03f, 1.40368313e-01f,
  -1.65168256e-01f, 8.62847045e-02f, -1.03959374e-01f, 9.52658206e-02f, -3.73809263e-02f, -2.47443677e-03f, -8.02185610e-02f, 6.58410862e-02f, -1.77447684e-02f, 5.19464500e-02f,
  4.14289311e-02f, 9.38981771e-02f, -9.91738364e-02f, 7.68673792e-02f, 5.18700927e-02f, 1.04408890e-01f, 3.42875049e-02f, -2.31488179e-02f, -7.69841895e-02f, 3.02420463e-02f,
  -3.74886394e-02f, 2.12317239e-03f, 1.72816180e-02f, 9.47018061e-03f, 3.83683667e-02f, 8.33612755e-02f, -1.99228507e-02f, 4.24783304e-02f, -4.34085652e-02f, 8.14492926e-02f,
  7.93986842e-02f, -1.36487991e-01f, -4.44478765e-02f, 3.67067978e-02f, 5.50234504e-02f, 1.52507231e-01f, -5.79731166e-02f, -4.04199958e-02f, -2.95019839e-02f, -2.00046916e-02f,
  8.69207531e-02f, -1.44714974e-02f, 3.90847251e-02f, -4.62198723e-03f, -1.17545813e-01f, 2.05312241e-02f, 4.91145998e-02f, 7.80993402e-02f, 3.11798658e-02f, -9.52478051e-02f,
  -1.82620510e-02f, 1.11194635e-02f, 2.04256792e-02f, -4.67140563e-02f, -4.28782217e-02f, 4.13106680e-02f, -3.73740122e-02f, -6.35877857e-03f, -3.07475105e-02f, -9.57084671e-02f,
  -1.54764086e-01f, -6.50730357e-02f, 2.90396046e-02f, 1.62835896e-01f, -5.82637377e-02f, 1.07801044e-02f, -1.32212276e-02f, -6.44966215e-02f, -1.89074308e-01f, -7.57134482e-02f,
  2.40165815e-02f, -2.34551337e-02f, -6.28496846e-03f, -4.19875160e-02f, 3.93350907e-02f, -7.09290355e-02f, -8.25303271e-02f, -8.28829706e-02f, -5.74786365e-02f, 3.85704674e-02f,
  5.27598932e-02f, 3.94026227e-02f, 4.82341014e-02f, -1.40218986e-02f, 8.35768282e-02f, -3.46909389e-02f, -3.21089663e-02f, 6.77584186e-02f, -4.39520404e-02f, -4.89393957e-02f,
  2.21401036e-01f, 9.39476714e-02f, 1.39328331e-01f, 3.00200492e-01f, -1.55938983e-01f, -1.00406893e-01f, -5.34413494e-02f, -4.16637249e-02f, 1.67321235e-01f, -1.15258629e-02f,
  -1.31240934e-01f, 2.35421687e-01f, -1.08517326e-01f, 2.10853368e-01f, -2.56453961e-01f, -1.90325335e-01f, 5.06334193e-02f, 2.51311928e-01f, 2.39286087e-02f, 1.01097427e-01f,
  -4.89395857e-02f, -2.75481522e-01f, 5.91071695e-02f, -1.85922071e-01f, 1.75044760e-01f, 8.72033313e-02f, -1.01136230e-01f, -8.26085731e-02f, 1.36778057e-01f, -1.00317337e-01f,
  1.03592850e-01f, 1.11252882e-01f, 1.20569281e-01f, 5.59062697e-02f, 3.53816003e-02f, 1.85103454e-02f, 7.74625223e-03f, -9.08863470e-02f, -4.35891449e-02f, -3.03122797e-03f,
  1.37842029e-01f, -4.93373275e-02f, -3.25305797e-02f, -5.65264598e-02f, -3.27277035e-02f, 1.04625940e-01f, 1.53891966e-01f, 6.07697926e-02f, 2.04742569e-02f, 9.01426971e-02f,
  1.24110401e-01f, 1.64737210e-01f, 5.56484424e-02f, 7.86189362e-02f, 2.59703360e-02f, -1.51012726e-02f, -1.86405168e-03f, 5.63420914e-02f, 1.57958493e-01f, 1.74811091e-02f,
  -4.41036299e-02f, -3.29594575e-02f, -6.35139197e-02f, 2.46488005e-02f, 4.42028455e-02f, 8.04978013e-02f, -7.96537250e-02f, -7.91668613e-03f, 4.98637073e-02f, 1.67112853e-02f,
  -7.39358878e-03f, 4.97244745e-02f, 9.31022037e-03f, 6.47205561e-02f, 3.09998821e-02f, 1.81596261e-04f, 4.76169251e-02f, 5.25302738e-02f, 2.67450185e-03f, 7.38771558e-02f,
  -5.48940673e-02f, -1.01463571e-01f, 5.12313545e-02f, -6.37789909e-03f, -8.18802137e-03f, 2.69484967e-02f, -1.92199238e-02f, 4.93169911e-02f, 1.93437226e-02f, -6.38156831e-02f,
  -5.14374711e-02f, -5.21992631e-02f, -3.77366282e-02f, 5.35907671e-02f, -3.61792631e-02f, -3.89700313e-03f, -1.24975592e-01f, 3.67336310e-02f, -9.54229757e-02f, -3.45333368e-02f,
  -9.54356641e-02f, 7.93012157e-02f, 3.38933319e-02f, 3.94268744e-02f, 5.16759753e-02f, -6.07590145e-03f, -7.26605281e-02f, -1.66448373e-02f, -2.92794872e-02f, 2.32065395e-02f,
  1.33114485e-02f, -3.84038091e-02f, -7.27161020e-02f, -7.09282421e-03f, -7.24176317e-02f, -2.28650831e-02f, 2.71814838e-02f, 3.49428616e-02f, 2.99833287e-02f, 2.28962651e-03f,
  -8.61810967e-02f, -7.33687282e-02f, -1.30488425e-01f, 7.83131719e-02f, 3.47157381e-02f, -6.00560335e-03f, -1.79614365e-01f, 1.18420891e-01f, -1.44385219e-01f, 1.11265704e-02f,
  -5.22713438e-02f, -1.80761412e-01f, -1.96649984e-01f, -6.12686798e-02f, -1.48129433e-01f, -2.40588948e-01f, -1.11044839e-01f, -1.23196721e-01f, -1.18674576e-01f, -7.32822642e-02f,
  3.57991755e-02f, 1.00535490e-01f, 2.37429943e-02f, 1.64389044e-01f, 1.47499025e-01f, 2.53445059e-01f, 2.34201759e-01f, 9.43503827e-02f, 2.28131473e-01f, 1.06642947e-01f,
  -1.88604016e-02f, 2.97706425e-02f, -2.24766824e-02f, -1.98965631e-02f, 4.61295173e-02f, 2.30107699e-02f, -1.00857597e-02f, -7.02916980e-02f, -8.82716700e-02f, -6.30195998e-03f,
  -1.03360265e-01f, 5.86210042e-02f, 1.00351796e-02f, 3.33025195e-02f, 1.21646617e-02f, -3.99443991e-02f, -2.16151550e-02f, 5.91231957e-02f, -5.25721116e-03f, -6.60080090e-02f,
  -2.92257853e-02f, -4.35916223e-02f, 4.29466479e-02f, 3.01035848e-02f, -7.86673501e-02f, -5.61521798e-02f, 4.54096235e-02f, 8.05293117e-03f, -3.07995882e-02f, 6.53341860e-02f,
  4.91517968e-02f, 7.19529912e-02f, -6.18743673e-02f, -1.04898870e-01f, 6.12374693e-02f, -6.89287623e-03f, 7.38788676e-03f, -6.39558360e-02f, 5.58115058e-02f, 2.36320253e-02f,
  6.77175075e-02f, 7.43048266e-02f, -6.49833456e-02f, 2.15893332e-02f, -2.40528211e-02f, -1.61120091e-02f, -4.22614962e-02f, 3.69953923e-02f, 5.38694523e-02f, -1.70657616e-02f,
  -8.09972063e-02f, 6.02359846e-02f, 1.75825376e-02f, -2.33603008e-02f, -1.63799152e-02f, 9.64733809e-02f, 9.42315385e-02f, 2.58942768e-02f, 4.06466015e-02f, 5.31295948e-02f,
  1.50437877e-02f, 5.34858480e-02f, 1.00003537e-02f, 4.99203056e-03f, 2.46889964e-02f, 8.56920704e-02f, 3.44693661e-02f, -2.33467054e-02f, 2.90997252e-02f, -4.19032909e-02f,
  1.31434470e-01f, -4.18305546e-02f, 4.36827280e-02f, 9.11057964e-02f, 4.36405353e-02f, 7.61198159e-03f, 5.63746914e-02f, 6.83725476e-02f, 6.53379261e-02f, 8.61333162e-02f,
  1.03749342e-01f, -3.69306542e-02f, 4.63855229e-02f, 4.25560661e-02f, 7.48468637e-02f, -2.94026602e-02f, 4.48767133e-02f, 4.87287007e-02f, 3.92829478e-02f, -8.05547088e-02f,
  6.20699935e-02f, -2.34561011e-01f, -1.21104605e-01f, -1.68273509e-01f, 4.28437777e-02f, -1.89467818e-01f, -2.60121822e-01f, -1.54932380e-01f, -3.63721699e-02f, -2.02001616e-01f,
  -1.13849960e-01f, 7.04833046e-02f, -4.15704958e-02f, -1.44272044e-01f, 2.54354000e-01f, 5.70169985e-02f, -1.40295640e-01f, -4.16194499e-02f, 6.21469617e-02f, -4.17762361e-02f,
  1.16797507e-01f, -2.14360487e-02f, 1.36607185e-01f, 9.01554525e-02f, -1.88712925e-01f, 8.95554796e-02f, 1.32899001e-01f, 2.17415206e-02f, -8.35227147e-02f, -2.60119699e-02f,
  5.86452521e-02f, -5.18843234e-02f, 5.07326722e-02f, 5.44540063e-02f, 7.68193379e-02f, -4.07513566e-02f, -6.59502372e-02f, -1.68344844e-02f, -9.59132146e-03f, 9.46366861e-02f,
  -2.76325252e-02f, 6.54347241e-02f, -6.00449480e-02f, 6.66292012e-02f, 4.71587256e-02f, 3.21737975e-02f, 1.43956458e-02f, 2.40158513e-02f, -5.19435853e-02f, 9.36816335e-02f,
  -3.91076356e-02f, 5.32496460e-02f, -6.70271888e-02f, 2.49437001e-02f, 1.36781307e-02f, -1.56212822e-01f, -2.34604087e-02f, -3.06677762e-02f, -3.01256473e-03f, 6.31004348e-02f,
  4.99779619e-02f, 2.89991889e-02f, -5.38329668e-02f, 1.00098811e-01f, 3.95847820e-02f, -2.58210804e-02f, 2.15738155e-02f, 5.19160833e-03f, -8.48411322e-02f, -1.04894385e-01f,
  6.37910236e-03f, -2.28768140e-02f, 9.25251991e-02f, 2.37573171e-03f, 5.38453981e-02f, 4.42535654e-02f, -9.02995318e-02f, 2.85820686e-04f, -2.30187401e-02f, -1.05765715e-01f,
  9.16964933e-02f, 9.91261527e-02f, -1.02221165e-02f, 6.03976324e-02f, 6.64256215e-02f, -7.00911507e-02f, 1.40704112e-02f, -1.08320139e-01f, 1.64820347e-02f, 4.32976820e-02f,
  8.95869136e-02f, 1.36786671e-02f, 2.73113344e-02f, 6.13435172e-03f, 2.99611464e-02f, 9.89395380e-03f, -2.38142386e-02f, 2.08605938e-02f, 2.88730115e-03f, 1.65712414e-03f,
  5.13871619e-03f, -2.83580367e-02f, 3.09610646e-03f, -8.16345494e-03f, 6.77349046e-02f, -9.75539014e-02f, -1.26860654e-02f, 7.20334500e-02f, -1.53653920e-02f, 7.72977024e-02f,
  -9.21770856e-02f, -3.50734591e-02f, -5.66024967e-02f, -3.09328530e-02f, -7.45451674e-02f, -1.28022343e-01f, 4.02630679e-03f, 6.67444617e-02f, 1.23215660e-01f, -7.33028650e-02f,
  -1.00929804e-01f, 1.22695692e-01f, 2.31772326e-02f, 1.82229299e-02f, -3.92503105e-03f, -2.09604576e-01f, 8.01938586e-03f, -5.94567470e-02f, -9.93064865e-02f, 1.34485140e-01f,
  -5.75388744e-02f, 1.84934258e-01f, -7.61190355e-02f, -1.98388755e-01f, -3.89006346e-01f, -1.86247647e-01f, -2.55826890e-01f, -6.22187816e-02f, -7.37654045e-02f, 1.01661995e-01f,
  -1.74616978e-01f, -1.76647138e-02f, -1.12646237e-01f, 1.61192745e-01f, 1.82548910e-02f, 2.06592351e-01f, 1.07316837e-01f, 8.42364952e-02f, 1.35548651e-01f, -6.28388822e-02f,
  -1.14337884e-01f, 4.37900238e-02f, 6.92714155e-02f, 7.31085762e-02f, -6.44597933e-02f, 7.15243667e-02f, 2.92854067e-02f, -4.88387868e-02f, 6.39230534e-02f, -2.24233214e-02f,
  6.13632910e-02f, 5.67179509e-02f, -3.39530446e-02f, -1.20852161e-02f, 4.75713201e-02f, 5.47637343e-02f, -3.87179181e-02f, -3.97996511e-03f, 3.86689119e-02f, 7.82920122e-02f,
  9.90566090e-02f, 3.37008610e-02f, 4.71335687e-02f, -4.25700936e-03f, -7.28864744e-02f, 1.22908922e-02f, 3.27025279e-02f, -3.74148563e-02f, 5.57143800e-02f, -1.14965655e-01f,
  4.83148880e-02f, -1.11296233e-02f, 3.78921479e-02f, -3.02011464e-02f, 6.88574314e-02f, 1.25843538e-02f, -6.99360222e-02f, -1.00696348e-02f, -3.57987848e-03f, -5.87247834e-02f,
  -3.70828062e-02f, -1.05464663e-02f, -3.81497964e-02f, -2.27592383e-02f, 6.23798892e-02f, -3.00257001e-02f, -4.55200523e-02f, -1.02681266e-02f, 8.81634001e-03f, 1.90363936e-02f,
  -4.12891209e-02f, -1.25878289e-01f, 2.65127094e-03f, -2.80361045e-02f, -1.41606241e-01f, 4.77784872e-02f, -2.77407244e-02f, -4.03850935e-02f, -2.29811370e-02f, 5.38726822e-02f,
  -1.33307636e-01f, -3.49772610e-02f, 9.41021219e-02f, -8.34932085e-03f, 6.69305474e-02f, -6.44398332e-02f, -1.22719519e-01f, -8.89314935e-02f, -3.05746426e-03f, -4.95423898e-02f,
  2.98657846e-02f, 5.84228076e-02f, -5.79207875e-02f, 2.11020745e-02f, 4.63588648e-02f, -5.93593381e-02f, -3.11541241e-02f, 4.40564677e-02f, 8.93367156e-02f, -4.77890931e-02f,
  1.37066379e-01f, -3.84462103e-02f, -6.55594468e-02f, 1.29021797e-02f, 3.56203504e-02f, -5.33991791e-02f, -1.73309315e-02f, 7.39766611e-03f, 6.99635409e-03f, -6.94141388e-02f,
  -9.95524786e-03f, 3.18266787e-02f, 6.23568781e-02f, -4.48262170e-02f, -1.45604447e-01f, 4.24350426e-02f, 3.02028302e-02f, 2.99838372e-02f, 1.69556230e-01f, -6.74079880e-02f,
  2.73243990e-02f, -1.13566935e-01f, 7.83133507e-02f, -1.55889958e-01f, 1.59256652e-01f, 1.10034840e-02f, -1.20484881e-01f, -2.91756578e-02f, -2.33758837e-02f, -1.25693321e-01f,
  8.29367898e-03f, -1.59859627e-01f, -1.27539143e-01f, -1.40232310e-01f, -2.18413532e-01f, -1.83960125e-01f, -1.16751127e-01f, -1.17484115e-01f, -1.75289154e-01f, -7.21036121e-02f,
  -2.09270827e-02f, -1.28662482e-01f, -1.74869001e-01f, -1.04031317e-01f, 9.43179522e-03f, 5.70634380e-02f, -7.03979954e-02f, -6.94781989e-02f, 1.95832495e-02f, 1.17427737e-01f,
  -4.99838330e-02f, 3.71204726e-02f, -2.20136847e-02f, -6.77344501e-02f, 3.99100780e-02f, -7.33223036e-02f, -5.32804094e-02f, 1.37542710e-02f, -9.66869742e-02f, 1.03412680e-02f,
  6.51443228e-02f, 3.01260334e-02f, -2.22845525e-02f, 5.31021394e-02f, -1.04169294e-01f, 9.53063294e-02f, 9.37033594e-02f, -1.10491037e-01f, -5.82536533e-02f, 8.99825767e-02f,
  -7.91319013e-02f, -3.14891823e-02f, -5.61366268e-02f, 7.07369745e-02f, -8.88694301e-02f, -7.10016713e-02f, 7.24769682e-02f, 9.19835940e-02f, 4.77208681e-02f, 3.30561376e-03f,
  3.53364907e-02f, 4.08881307e-02f, -2.97134649e-02f, -4.83841076e-02f, -7.35524227e-04f, 2.15661153e-02f, 1.29235443e-02f, 3.96901369e-02f, 7.92192668e-02f, -5.00526503e-02f,
  -6.35529160e-02f, 7.09551200e-02f, -9.84971598e-03f, -6.11355714e-02f, -5.00416532e-02f, -4.29618545e-02f, -3.93978618e-02f, 3.41302492e-02f, 7.43335206e-03f, -1.10754788e-01f,
  -2.97244210e-02f, -1.32280424e-01f, 1.19591309e-02f, 8.44422653e-02f, -8.74848887e-02f, -1.70449186e-02f, 6.06643595e-02f, -7.02113584e-02f, 2.09864248e-02f, -4.94620241e-02f,
  6.40197238e-03f, 5.78066967e-02f, 2.05989257e-02f, 6.38441443e-02f, -3.65943164e-02f, -1.06886718e-02f, -2.62588467e-02f, 9.81448591e-02f, -6.86210990e-02f, 1.31460407e-03f,
  -3.70018817e-02f, 9.48999748e-02f, 8.64382386e-02f, -1.01129279e-01f, -3.58992890e-02f, -2.33800057e-02f, -4.61651422e-02f, -1.77617110e-02f, -6.92622513e-02f, -5.32752387e-02f,
  2.69881725e-01f, -1.75384879e-01f, -5.13680764e-02f, 1.44010961e-01f, 1.85724288e-01f, 1.55862406e-01f, 1.94822878e-01f, -8.17125216e-02f, 8.30663368e-02f, -2.46021703e-01f,
  4.84347567e-02f, -1.09835379e-01f, -9.28730741e-02f, 6.43395679e-03f, 1.78349242e-01f, -1.16041772e-01f, 1.32805342e-02f, 3.75428461e-02f, 2.22654245e-03f, 3.10931504e-02f,
  1.06487677e-01f, 1.04554281e-01f, -3.31528075e-02f, -1.58150852e-01f, -2.69342847e-02f, 1.09389517e-02f, -4.99454141e-02f, -3.65294740e-02f, -2.51979902e-02f, 5.88818304e-02f,
  5.93067259e-02f, 3.70110832e-02f, 6.94560334e-02f, -3.28820497e-02f, 3.74474539e-03f, -5.22359572e-02f, -6.95810048e-03f, -5.74510060e-02f, 4.32101265e-03f, -1.50468275e-02f,
  -5.11133932e-02f, -3.82050201e-02f, 6.35596067e-02f, 8.69994313e-02f, 1.01933904e-01f, 3.44400592e-02f, -1.03355842e-02f, -7.27048963e-02f, -5.51153012e-02f, -4.38702642e-04f,
  -1.07861357e-02f, -4.94911596e-02f, 4.94101979e-02f, -6.86457008e-02f, -2.68747527e-02f, 2.62563918e-02f, 2.09336728e-02f, 4.52282690e-02f, -4.98233065e-02f, 6.29015639e-02f,
  3.32803302e-03f, 1.46273831e-02f, -9.14921227e-04f, 1.62661932e-02f, 1.83766335e-02f, -2.30737794e-02f, -6.64832965e-02f, -2.36804485e-02f, 5.82902916e-02f, -1.36308735e-02f,
  -6.33035451e-02f, -2.31927112e-02f, -2.70206202e-03f, -3.96454930e-02f, -5.63774956e-03f, -9.01967473e-03f, -1.24706700e-02f, -7.96636045e-02f, 1.11065758e-02f, 3.82108614e-02f,
  1.97347067e-02f, 7.69680133e-03f, -2.73753088e-02f, -2.82279868e-02f, 4.51471433e-02f, 7.40073621e-02f, 5.23703508e-02f, -6.43504858e-02f, 1.28187001e-01f, -4.11100164e-02f,
  -3.95188387e-03f, -2.10978538e-01f, -1.33565441e-03f, 1.99872013e-02f, -1.13884367e-01f, -9.38765630e-02f, -1.00568995e-01f, -8.47268626e-02f, -8.24044421e-02f, -1.54735101e-02f,
  9.17795300e-03f, -3.61706316e-02f, 3.29700522e-02f, 1.25461267e-02f, -2.02508830e-02f, 1.54379057e-02f, 2.20308397e-02f, -1.20678963e-02f, -3.05054407e-03f, -5.83942644e-02f,
  -4.82193922e-04f, -7.89509118e-02f, -4.03451361e-02f, 8.36360455e-02f, 2.97424067e-02f, -3.00998818e-02f, 2.26094387e-02f, 1.29379043e-02f, -5.97159751e-02f, -1.02712408e-01f,
  -9.71658677e-02f, -1.07330486e-01f, 5.04128896e-02f, -1.29958883e-01f, -5.30042090e-02f, -1.97359622e-02f, -1.43551797e-01f, -1.66062981e-01f, -1.75412253e-01f, -8.98792893e-02f,
  -2.52058040e-02f, -1.49494067e-01f, 1.25082269e-01f, -2.32805759e-01f, 1.77657038e-01f, 5.84547259e-02f, -4.07066233e-02f, -1.17664136e-01f, 1.55843636e-02f, -2.05990478e-01f,
  -9.11222622e-02f, -2.07939133e-01f, -2.47841589e-02f, -9.70495194e-02f, -1.59525782e-01f, -1.17079020e-01f, -6.34543151e-02f, -7.44477808e-02f, -5.21514192e-02f, -6.78652078e-02f,
  -2.89699398e-02f, -1.10042118e-01f, -5.49261970e-03f, -3.90340993e-03f, -6.71596453e-02f, 4.29829508e-02f, 5.02837077e-02f, 1.15204543e-01f, -3.12460549e-02f, -3.55013311e-02f,
  -8.24909210e-02f, 5.29933460e-02f, -7.42394179e-02f, -5.31298406e-02f, -3.83825563e-02f, 1.63414963e-02f, -3.16353627e-02f, -4.23504412e-03f, 4.87731919e-02f, 1.25751138e-01f,
  8.48335847e-02f, 1.68235879e-03f, 4.12409231e-02f, -3.97281162e-02f, 4.16063853e-02f, 4.68981303e-02f, 8.54575038e-02f, 4.62576263e-02f, -4.42487672e-02f, -9.44798663e-02f,
  -7.40744546e-02f, 8.18502381e-02f, -2.82411203e-02f, -5.86498491e-02f, -8.66069496e-02f, 1.88373011e-02f, 6.77150711e-02f, -6.25942275e-02f, 1.18808122e-02f, -5.45843989e-02f,
  -4.53019626e-02f, 7.55262598e-02f, -1.01991244e-01f, 6.36979118e-02f, 3.10756289e-03f, 4.45982963e-02f, -4.01118696e-02f, -6.30760193e-02f, -7.70775527e-02f, 7.51539841e-02f,
  1.06031686e-01f, 3.08730975e-02f, -9.61653069e-02f, -2.41364986e-02f, 5.67081794e-02f, 1.79533884e-02f, 3.20738717e-03f, 4.12988104e-02f, -2.81899534e-02f, -3.29800136e-02f,
  6.47620112e-02f, -1.27259165e-01f, 3.97490337e-03f, -8.91392604e-02f, 1.13317594e-01f, -1.11521021e-01f, -7.71458298e-02f, -4.88408692e-02f, -2.69760974e-02f, 5.55482879e-03f,
  -1.97791215e-02f, -6.09896779e-02f, -4.40689251e-02f, -3.68949287e-02f, 4.58688848e-03f, 3.78933027e-02f, 6.81541190e-02f, 8.21879059e-02f, 2.44084764e-02f, -4.59328629e-02f,
  -4.76207361e-02f, 3.70420367e-02f, 5.84445754e-03f, -3.18763219e-02f, -7.23871291e-02f, -3.99899781e-02f, 7.35683218e-02f, 8.59903842e-02f, 3.51019092e-02f, -3.39990333e-02f,
  -9.06283222e-03f, -1.79645598e-01f, 6.92298710e-02f, 2.25559622e-01f, 8.07003677e-03f, -1.97362050e-01f, -7.73036405e-02f, 8.46337527e-02f, -6.54380172e-02f, -2.12310344e-01f,
  1.52126327e-01f, 1.14027552e-01f, -3.42765376e-02f, 1.74133331e-01f, 1.70399129e-01f, -8.90685804e-03f, 1.82756130e-02f, 8.03531557e-02f, 6.56093284e-02f, 5.78880310e-02f,
  4.94681895e-02f, 8.18257108e-02f, 2.68108308e-01f, 1.86251447e-01f, -3.11841350e-02f, 2.00282589e-01f, 2.34275430e-01f, 4.42595519e-02f, 2.88891524e-01f, 1.91216901e-01f,
  1.65977348e-02f, 3.50217223e-02f, -2.43167300e-02f, -8.24855939e-02f, 4.30217311e-02f, -5.32860719e-02f, -7.18681365e-02f, 1.38069808e-01f, 7.67735541e-02f, -3.47078815e-02f,
  -2.18014494e-02f, -4.57408000e-03f, -4.11691181e-02f, 9.88760125e-03f, 4.71348725e-02f, -4.43418277e-03f, -4.58178185e-02f, -4.27378714e-02f, -2.96044704e-02f, 7.77745247e-02f,
  -1.19595816e-02f, 2.86177043e-02f, 3.97575088e-03f, -1.55712860e-02f, 1.03973553e-01f, 5.62461242e-02f, 3.71738486e-02f, -3.24638747e-02f, -5.90317883e-02f, -7.73124695e-02f,
  -7.06387535e-02f, -3.56234834e-02f, 1.00161038e-01f, 5.98540567e-02f, -2.76956540e-02f, -9.78657417e-03f, -4.57828827e-02f, -1.43507635e-02f, -8.65632575e-03f, -1.05423093e-01f,
  3.99950370e-02f, -5.29849492e-02f, -2.10003778e-02f, -9.68169048e-02f, -6.02439307e-02f, -4.84254509e-02f, -3.73851247e-02f, -7.31719732e-02f, -7.35001788e-02f, 2.47822814e-02f,
  4.69874851e-02f, -1.85928363e-02f, 5.36199883e-02f, -3.22991386e-02f, 2.88147312e-02f, 2.27228533e-02f, -4.79939617e-02f, -9.21742469e-02f, -1.20811507e-01f, -1.80382747e-02f,
  -9.14555863e-02f, -4.43319082e-02f, -7.97453150e-03f, -4.72506881e-02f, 3.90072353e-02f, -3.23743895e-02f, -7.37597868e-02f, 2.10952796e-02f, -4.01208885e-02f, 7.47210234e-02f,
  -1.40605615e-02f, 1.17964678e-01f, -1.30937677e-02f, -5.60841197e-03f, 5.52684739e-02f, -6.41538724e-02f, -8.07646513e-02f, 1.81978866e-02f, 4.00396660e-02f, -6.87765107e-02f,
  6.09694002e-03f, -9.33957398e-02f, -5.37906028e-02f, -5.76738641e-02f, 6.08360814e-03f, 4.22963798e-02f, 2.00351682e-02f, 2.95552593e-02f, -3.84471342e-02f, -2.30434258e-02f,
  -2.36115322e-01f, -1.73302725e-01f, -1.12417504e-01f, 2.41939840e-03f, 8.95166695e-02f, 2.53334105e-01f, 1.89002335e-01f, -3.71372476e-02f, -1.53131947e-01f, 1.60558701e-01f,
  1.70534387e-01f, -2.99473740e-02f, -1.45515010e-01f, 2.18461812e-01f, 7.15680197e-02f, 5.75658083e-02f, 1.39478505e-01f, 1.43512592e-01f, -8.45094994e-02f, -3.89006957e-02f,
  -5.29042818e-02f, 1.73699424e-01f, 1.09295443e-01f, 5.83676361e-02f, 1.21790148e-01f, -4.62150052e-02f, 1.63294509e-01f, 5.95759880e-03f, 1.60254806e-01f, 2.55104005e-01f,
  1.80167556e-02f, -2.32511908e-01f, -1.77772064e-02f, -4.17507440e-02f, -1.13390498e-01f, -6.86229542e-02f, 1.15555013e-02f, 1.23446047e-01f, -1.27324700e-01f, -3.07717621e-02f,
  -7.70852119e-02f, 4.40981947e-02f, -2.36503650e-02f, -2.84259114e-02f, 5.19539528e-02f, -1.27429413e-02f, -3.59543450e-02f, -1.51864197e-02f, -5.96227013e-02f, 9.81476903e-03f,
  -1.56560242e-02f, 9.18761790e-02f, 8.97257552e-02f, 3.03933322e-02f, -5.68463095e-02f, 8.57899711e-02f, 8.63033012e-02f, -5.21605127e-02f, 4.62710261e-02f, 7.26765692e-02f,
  -1.25668840e-02f, -3.09304185e-02f, 6.20522238e-02f, -4.69796918e-03f, -3.19065992e-04f, 2.25207637e-04f, 7.99971446e-02f, -4.15729359e-02f, 2.97872759e-02f, -3.95396873e-02f,
  -8.59987363e-02f, -2.89176516e-02f, -2.17698291e-02f, -7.26124495e-02f, 8.02680291e-03f, -5.42932227e-02f, -7.35182390e-02f, 6.88874945e-02f, -2.00090650e-02f, -6.53061550e-03f,
  -2.38446556e-02f, -8.83693770e-02f, 3.69705670e-02f, -2.87020989e-02f, -6.47998229e-02f, 6.06978573e-02f, 2.21218579e-02f, -5.30128069e-02f, 3.95021588e-02f, 5.06975427e-02f,
  3.73744182e-02f, -1.77241340e-01f, 1.25907175e-02f, 4.73266318e-02f, -8.23099464e-02f, -4.70755622e-03f, -3.16395722e-02f, 1.06318921e-01f, -3.59631097e-03f, -9.64224264e-02f,
  -1.06230326e-01f, 7.00942427e-02f, 2.68354956e-02f, -7.24090114e-02f, 2.82227565e-02f, -7.73418229e-03f, -3.31764147e-02f, 3.97822000e-02f, -1.74595253e-03f, 3.65760140e-02f,
  7.05949739e-02f, 8.18239301e-02f, 3.91976647e-02f, -1.15671922e-02f, -6.10455908e-02f, 2.59020608e-02f, -9.52393096e-03f, -5.40609695e-02f, 7.31275305e-02f, 7.05712289e-02f,
  -2.89385952e-02f, 1.71526164e-01f, -7.70818591e-02f, -1.32805899e-01f, -1.18592819e-02f, -1.65324122e-01f, -1.64879024e-01f, 1.59173101e-01f, -4.50257398e-02f, 9.48622897e-02f,
  9.10124332e-02f, 1.20423988e-01f, 5.11356853e-02f, -4.67616133e-02f, -3.19330722e-01f, -1.85953468e-01f, -3.07785004e-01f, -2.34692413e-02f, 1.83320418e-02f, -1.03428759e-01f,
  -1.64778620e-01f, -8.84495974e-02f, -1.10738933e-01f, 5.58053143e-02f, 3.83429974e-02f, 4.56126332e-02f, -1.15728468e-01f, 1.81869388e-01f, -8.06427300e-02f, 7.02783167e-02f,
  4.68861051e-02f, 8.90062153e-02f, 1.14248805e-01f, -1.78336948e-02f, -8.94430354e-02f, -6.17217422e-02f, -8.20110515e-02f, 3.85828912e-02f, -7.55833462e-02f, -2.89217196e-02f,
  -1.92852579e-02f, -1.82665717e-02f, -1.72860939e-02f, 9.33161899e-02f, 1.20799104e-02f, 5.20552956e-02f, -2.72227768e-02f, -9.91915986e-02f, 5.42384386e-02f, 2.21477379e-03f,
  -2.39967145e-02f, 4.00096662e-02f, -1.18278652e-01f, -2.30135396e-03f, -8.60571936e-02f, 1.01690367e-03f, -1.33259654e-01f, -9.17006377e-03f, -5.60495816e-02f, 2.19150931e-02f,
  -5.72841428e-02f, 1.52729405e-02f, 6.53068721e-03f, 6.34528622e-02f, 7.60171935e-02f, -3.67449187e-02f, 6.68934174e-03f, 4.49769981e-02f, -7.23407194e-02f, 6.55216575e-02f,
  -4.85439152e-02f, 5.83902113e-02f, -1.67889113e-03f, -1.69261377e-02f, -1.99204832e-02f, 6.59619942e-02f, -4.42631766e-02f, 2.65343133e-02f, -8.33385363e-02f, 2.66464129e-02f,
  -1.75445154e-03f, 3.09423637e-02f, 2.50623282e-02f, 3.98313887e-02f, 7.39494637e-02f, 6.11833781e-02f, 2.93800645e-02f, 1.08922888e-02f, 9.08586383e-02f, -1.71860792e-02f,
  -3.51635320e-03f, -3.68598513e-02f, 6.75716624e-02f, 2.20443914e-03f, -1.31910024e-02f, -5.37980571e-02f, -2.20400766e-02f, -2.70040277e-02f, -1.22682922e-01f, -4.74856980e-02f,
  1.85791589e-02f, 4.77871746e-02f, -1.64730363e-02f, -1.26337903e-02f, -9.78335738e-03f, -1.18313720e-02f, 2.58878730e-02f, -2.08196770e-02f, -1.95852257e-02f, -2.56025326e-02f,
  9.46960691e-03f, 3.55581194e-02f, -8.09356943e-02f, -6.02990575e-02f, -9.02563259e-02f, 2.91936826e-02f, 3.25625315e-02f, -2.32072379e-02f, -2.72920565e-03f, -2.10560113e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  5.05329706e-02f, 8.99879336e-02f, 1.63329132e-02f, 7.74021298e-02f, 7.48797506e-02f, 1.33558705e-01f, -5.24214990e-02f, 1.31937899e-02f, 7.75432363e-02f, 6.52650297e-02f,
  7.22650662e-02f, 8.38128030e-02f, -9.43835068e-04f, 1.04655690e-01f, -7.13734254e-02f, 5.80577329e-02f, -4.03979905e-02f, 1.08157352e-01f, 1.36091128e-01f, 1.00261472e-01f,
  3.40966359e-02f, 9.12218094e-02f, 1.15117297e-01f, 4.86498661e-02f, 1.13759927e-01f, 8.94074887e-02f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.15776613e-01f, -3.93004715e-02f, -5.83989285e-02f, 4.71959338e-02f, 9.81920026e-03f, 4.67424020e-02f, 6.47285432e-02f, -4.22879755e-02f, 1.48554461e-03f, 9.32394043e-02f,
  4.43633199e-02f, 1.63455191e-03f, 6.25899732e-02f, 1.37780741e-01f, -9.45280716e-02f, -1.42538160e-01f, -1.14340521e-01f, -4.66834754e-02f, -7.14985207e-02f, 1.01447947e-01f,
  -1.67919517e-01f, 1.28397226e-01f, 6.93131313e-02f, 1.40805408e-01f, -1.81236252e-01f, 3.40424627e-01f, -6.35463148e-02f, -1.18289649e-01f, -6.39976235e-03f, -2.29516514e-02f,
  -1.03034571e-01f, 4.30990607e-02f, -1.98840439e-01f, 1.80085659e-01f, -3.67397107e-02f, 8.04187655e-02f, 3.58505473e-02f, -1.90120675e-02f, 3.04478347e-01f, 2.09574386e-01f,
  -1.74344137e-01f, 4.12093243e-03f, -1.44681647e-01f, 1.53384894e-01f, 1.20843932e-01f, -1.05853323e-02f, 1.05712168e-01f, 7.43601471e-02f, -6.54569268e-03f, -2.01075282e-02f,
  1.32903516e-01f, 7.26193711e-02f, 1.26172394e-01f, 7.50827342e-02f, 1.83500692e-01f, -7.40682893e-03f, 4.09194781e-03f, -3.09016160e-03f, 1.66250587e-01f, -7.96660502e-03f,
  -1.89423165e-03f, 2.71060079e-01f, -2.49249451e-02f, -1.75556600e-01f, 2.58175116e-02f, -1.84476282e-02f, 1.54217789e-02f, 1.14123575e-01f, 1.56287160e-02f, 7.67037719e-02f,
  -9.49029177e-02f, 1.49165660e-01f, -3.28542218e-02f, 6.28600940e-02f, -1.07542083e-01f, -8.16531703e-02f, -8.67232308e-03f, -9.40344259e-02f, -1.15641564e-01f, -1.42065763e-01f,
  -1.65292457e-01f, -1.09355256e-03f, -1.22242168e-01f, -2.14346185e-01f, 4.46264520e-02f, -2.09963441e-01f, 1.06765784e-01f, -1.01494074e-01f, -9.65959504e-02f, 7.49549195e-02f,
  3.73069569e-02f, 1.91793382e-01f, -4.62964587e-02f, 5.34825921e-02f, -9.83491614e-02f, 1.19915970e-01f, 1.07863143e-01f, -5.44709526e-02f, -5.43895215e-02f, 5.05789295e-02f,
  -1.45107090e-01f, 1.44723594e-01f, -1.06989108e-01f, 1.98143512e-01f, 6.43593818e-02f, 5.61855547e-02f, -4.94331829e-02f, 2.15223059e-01f, 1.68214694e-01f, -2.12411270e-01f,
  -1.18602917e-01f, 1.36938810e-01f, 1.36227056e-01f, 2.59305865e-01f, -4.95711677e-02f, -1.90817118e-01f, 1.08002052e-01f, 3.79748940e-02f, -6.54903799e-02f, 1.01230957e-01f,
  1.16293952e-01f, -1.86617211e-01f, 7.49034435e-02f, -8.09236169e-02f, 2.15016738e-01f, 1.29746422e-01f, 1.59548894e-01f, -9.40387100e-02f, 9.92426649e-02f, -1.60465986e-01f,
  -6.29619136e-02f, 1.33607388e-01f, -7.06481263e-02f, 5.65329678e-02f, -1.68844327e-01f, -9.10785645e-02f, -1.25461828e-03f, 7.29596689e-02f, -3.36314514e-02f, -1.41431302e-01f,
  1.51445016e-01f, -1.39156943e-02f, -1.04107417e-01f, -4.16156873e-02f, -1.46472473e-02f, -3.52772698e-02f, -2.80707348e-02f, 7.74341747e-02f, -1.74260046e-02f, -1.65198937e-01f,
  1.67235613e-01f, -2.98971850e-02f, 1.35514483e-01f, 5.43850996e-02f, 2.09334120e-01f, 2.13463847e-02f, 2.53374558e-02f, -2.16154754e-01f, -8.79206657e-02f, 5.80829270e-02f,
  -2.08899789e-02f, -2.09119022e-01f, 9.71114859e-02f, 2.22640694e-03f, -1.55108169e-01f, 1.53983071e-01f, -2.01564416e-01f, -4.32356633e-02f, -8.98400620e-02f, 2.07657352e-01f,
  -1.23540938e-01f, 3.62483442e-01f, 2.43001267e-01f, 7.50710117e-03f, 3.44590247e-01f, -3.84857766e-02f, 5.64777777e-02f, -2.15112139e-02f, -4.00583968e-02f, 4.70348634e-02f,
  2.18340844e-01f, 8.50045234e-02f, -3.14979434e-01f, -1.69352785e-01f, -3.55646163e-02f, -1.98236942e-01f, 1.12328425e-01f, 6.04227767e-04f, 1.36316031e-01f, -1.00729182e-01f,
  2.07758278e-01f, -8.39019865e-02f, -8.81420076e-02f, -2.44801138e-02f, -4.92997430e-02f, -5.26822777e-03f, -8.65873098e-02f, 1.16717070e-01f, 5.56880888e-03f, -1.47105068e-01f,
  -1.14914261e-01f, 4.43265922e-02f, -5.32860421e-02f, 1.52225435e-01f, 5.52822053e-02f, 3.91348749e-02f, 7.34876990e-02f, -6.37344494e-02f, 1.53983548e-01f, -7.85197411e-03f,
  7.23660365e-02f, 2.00539201e-01f, 3.06966901e-02f, -3.70339975e-02f, -4.04600278e-02f, -3.76456343e-02f, -1.25960484e-01f, 2.07108390e-02f, 4.14209403e-02f, -1.89784393e-01f,
  3.40372063e-02f, -5.95688634e-02f, 7.81026259e-02f, -2.92818695e-01f, 9.25579295e-02f, 6.78611025e-02f, 1.84906535e-02f, 2.75635719e-02f, -1.22935146e-01f, -2.56388634e-01f,
  1.75291315e-01f, 1.61514431e-01f, 1.71902150e-01f, -6.07944168e-02f, 1.93930119e-01f, -6.06794581e-02f, 2.15817778e-03f, -5.50040603e-02f, -1.34467095e-01f, -6.42963797e-02f,
  -6.51420727e-02f, -6.47303015e-02f, 1.30447477e-01f, 3.22206281e-02f, -5.00775836e-02f, -2.02516466e-02f, 2.16967002e-01f, 2.33042672e-01f, -2.12569997e-01f, 2.20293954e-01f,
  -2.11855650e-01f, 4.71028537e-02f, -2.07588553e-01f, -7.39448220e-02f, -1.75981075e-01f, 1.92886144e-02f, 1.15435563e-01f, 7.24689588e-02f, 1.13310039e-01f, 1.34520069e-01f,
  -1.80598423e-02f, 1.17494151e-01f, -5.47203934e-03f, 1.38617873e-01f, 5.49731441e-02f, -6.87871054e-02f, 5.80280349e-02f, -1.36511801e-02f, 1.77315157e-02f, 4.09438685e-02f,
  -9.55379605e-02f, -6.15687482e-02f, 2.09734086e-02f, 9.79053825e-02f, 1.48462221e-01f, -1.49915770e-01f, -6.49250299e-02f, 1.27056716e-02f, -2.20517531e-01f, -1.40316188e-01f,
  -6.04361072e-02f, -2.27156729e-02f, -1.00701600e-01f, 1.12468906e-01f, -1.37100101e-01f, 1.27380028e-01f, 3.33377197e-02f, 1.10308222e-01f, 8.85207951e-02f, 1.43392801e-01f,
  -6.05923384e-02f, 1.92497939e-01f, -2.39956323e-02f, 5.00976481e-03f, 1.31972462e-01f, 2.17084656e-03f, -8.64284933e-02f, -1.59878042e-02f, -5.12003042e-02f, 3.86992912e-03f,
  -1.15262248e-01f, -1.70759894e-02f, 1.04574166e-01f, 1.57240510e-01f, -8.70728791e-02f, -2.43116878e-02f, 1.79860041e-01f, -9.41556096e-02f, -2.25930899e-01f, -1.80707276e-01f,
  -1.93163782e-01f, -9.89386067e-03f, -1.28562286e-01f, 2.65890770e-02f, 6.80545196e-02f, 2.47091562e-01f, -7.57031962e-02f, 4.47705872e-02f, 6.48906047e-04f, -2.63225526e-01f,
  -1.59375802e-01f, -1.32068455e-01f, -1.97916292e-02f, 4.76640351e-02f, -6.11865669e-02f, 4.57855836e-02f, 9.75318626e-02f, 1.28827274e-01f, 6.77826256e-02f, -1.33682445e-01f,
  9.94328186e-02f, -6.84252381e-03f, 9.03900936e-02f, -8.80926028e-02f, -1.12884447e-01f, -2.31333133e-02f, -6.89189807e-02f, 6.09778473e-03f, 5.70670366e-02f, -2.19434708e-01f,
  -1.46882236e-01f, 1.17190674e-01f, -6.69814460e-03f, 5.05426265e-02f, 1.60911027e-02f, 8.09622109e-02f, -4.52271923e-02f, 3.49949524e-02f, -1.35734931e-01f, 1.56404655e-02f,
  -1.67256117e-01f, 9.04143974e-02f, -1.25557035e-01f, 1.51701674e-01f, 1.28884032e-01f, 7.03302249e-02f, 1.67060748e-01f, -1.05709946e-02f, 2.87170976e-01f, -2.57401299e-02f,
  3.85146141e-02f, 1.03458576e-01f, -6.99814856e-02f, 4.24757563e-02f, -1.02467932e-01f, 3.59291285e-02f, -3.94664817e-02f, 2.31561288e-01f, 7.13598030e-03f, -3.62301916e-02f,
  1.26452178e-01f, -9.38503444e-02f, 1.97313756e-01f, 1.19608909e-01f, -1.73747331e-01f, -4.19500098e-02f, 1.60130918e-01f, -1.47371113e-01f, -5.51620834e-02f, 1.59216121e-01f,
  1.68116227e-01f, 2.65252646e-02f, 3.72789539e-02f, -1.10020272e-01f, -1.21786229e-01f, 9.82169285e-02f, -9.42773558e-03f, -9.58570465e-02f, -1.52724646e-02f, -1.05662905e-01f,
  -1.65305231e-02f, -4.07159179e-02f, 3.61979418e-02f, 6.69930503e-03f, 1.51292816e-01f, 5.95175140e-02f, 2.15442795e-02f, -9.50326696e-02f, 1.03083076e-02f, -2.53158789e-02f,
  -7.33661205e-02f, -1.67573821e-02f, 6.88024536e-02f, -1.87018037e-01f, -8.17987919e-02f, 6.54423377e-03f, -7.38405064e-02f, 9.97738540e-02f, 4.27165069e-02f, -5.76880798e-02f,
  -1.44296721e-01f, 1.76800936e-01f, 9.73058715e-02f, 1.27609953e-01f, 6.07107580e-03f, 3.75292391e-01f, -4.01504375e-02f, -2.22824886e-01f, 1.55417502e-01f, 2.26948902e-01f,
  -9.95246395e-02f, 2.17413351e-01f, -2.03518383e-02f, -3.96132730e-02f, -6.98175579e-02f, 8.96881223e-02f, -6.92509562e-02f, 2.85074085e-01f, 5.08169271e-02f, -1.04065768e-01f,
  1.40180308e-02f, -4.91722636e-02f, 1.19428672e-01f, 3.78086120e-02f, 6.75105006e-02f, 8.91199801e-03f, -1.71716869e-01f, -2.19997719e-01f, 6.48912508e-04f, -1.44214362e-01f,
  -6.11104369e-02f, -2.45277628e-01f, 1.66352406e-01f, -1.97043102e-02f, 1.15788698e-01f, -9.82874334e-02f, 2.26985767e-01f, -1.93742946e-01f, 7.95500129e-02f, 5.78153692e-02f,
  -1.21161908e-01f, -4.40623239e-02f, 1.44475296e-01f, 2.50670239e-02f, -6.91820979e-02f, 1.06260277e-01f, 4.13246192e-02f, 1.27657754e-02f, -1.50254518e-01f, 1.32675529e-01f,
  -4.93962578e-02f, 7.83032477e-02f, -2.81717014e-02f, -7.16881528e-02f, -9.73645151e-02f, -1.21727467e-01f, -4.00599167e-02f, 6.27650619e-02f, -1.23830333e-01f, -1.26539886e-01f,
  1.36181042e-01f, -5.14284149e-03f, -1.74535677e-01f, 1.38558581e-01f, 2.10150313e-02f, -6.85400963e-02f, -1.63308501e-01f, -4.99957688e-02f, -1.13342211e-01f, -2.89103597e-01f,
  -1.21980794e-01f, 2.68027633e-01f, 4.51700278e-02f, -7.26644769e-02f, 4.88950573e-02f, -4.19686884e-02f, 1.80661395e-01f, 2.13930368e-01f, -2.37783063e-02f, -2.68316665e-03f,
  9.73118991e-02f, -1.08993642e-01f, -9.02591795e-02f, -4.75837030e-02f, 5.86317219e-02f, 4.98637855e-02f, -2.80686580e-02f, -9.44938287e-02f, -3.05183069e-03f, -7.45918453e-02f,
  2.33669922e-01f, 1.88268632e-01f, 1.75214428e-02f, 8.30790550e-02f, 1.31496444e-01f, 8.53699148e-02f, 1.05201922e-01f, -5.74052595e-02f, -3.38015240e-03f, 2.04867169e-01f,
  -1.46054640e-01f, 5.96576110e-02f, -9.37790330e-03f, 1.34002389e-02f, 4.91834283e-02f, 2.18005124e-02f, -4.51526642e-02f, 5.07313572e-02f, -2.06033457e-02f, 6.31693304e-02f,
  -8.10706615e-02f, 2.10900772e-02f, -1.52165338e-01f, 2.48670690e-02f, -1.56088024e-01f, -4.54934724e-02f, -9.42307189e-02f, -1.28348336e-01f, 2.28681900e-02f, 8.36664140e-02f,
  1.80445183e-02f, -4.89258245e-02f, -6.67907298e-02f, -1.47801393e-03f, -5.66819869e-02f, -9.69417766e-02f, 7.19045699e-02f, -2.12322250e-02f, -1.31568715e-01f, -4.21934202e-02f,
  -6.38064593e-02f, 2.30927333e-01f, 7.89280310e-02f, -5.68881929e-02f, 2.44210716e-02f, 1.05725251e-01f, -1.16241552e-01f, 7.52966776e-02f, -3.31253335e-02f, 1.10083498e-01f,
  -4.32275981e-02f, 1.77929804e-01f, 8.71328712e-02f, -1.40387818e-01f, -1.07691102e-02f, -6.09202832e-02f, -1.94473356e-01f, -1.07809603e-01f, -1.11662172e-01f, 2.30791401e-02f,
  -1.11258015e-01f, 9.42226499e-02f, -6.44557923e-02f, -8.72870758e-02f, 3.14383209e-02f, -3.03005092e-02f, -1.74627192e-02f, 1.18207663e-01f, 6.82648197e-02f, -2.02287193e-02f,
  1.62276626e-01f, 8.57877880e-02f, 3.86971906e-02f, 2.14482293e-01f, -3.21216211e-02f, -1.40905872e-01f, 4.03410122e-02f, 8.41144323e-02f, -3.41204293e-02f, -8.14743787e-02f,
  -5.94611168e-02f, 6.54643252e-02f, -2.54445318e-02f, -9.46656913e-02f, 8.54128823e-02f, 2.68766582e-02f, -1.70710087e-01f, -3.17929219e-03f, -3.49004790e-02f, 1.56022206e-01f,
  1.44975737e-01f, 1.26439556e-01f, 1.20217904e-01f, -9.45991129e-02f, -9.82041238e-04f, 1.42367557e-01f, 6.48301095e-02f, 9.19630006e-02f, 1.61088690e-01f, 6.76516443e-02f,
  -1.42478153e-01f, 1.32277653e-01f, -2.89195944e-02f, -1.04829997e-01f, -7.13103730e-03f, -7.63519406e-02f, -6.80883303e-02f, -2.56344974e-01f, -6.33420199e-02f, 1.26428157e-01f,
  -9.59203579e-03f, -1.27395555e-01f, 1.69141702e-02f, -1.60548896e-01f, 1.34614289e-01f, 1.70396119e-01f, 2.17552990e-01f, -1.83170587e-01f, 2.53230929e-01f, -3.10639054e-01f,
  1.12555392e-01f, 6.77945511e-03f, -1.82461783e-01f, 4.97829951e-02f, -5.86097501e-03f, 7.97892883e-02f, 1.80296659e-01f, 3.62461545e-02f, 6.39733598e-02f, 1.45216346e-01f,
  7.84869194e-02f, 2.16023833e-01f, -3.79997157e-02f, 3.28637272e-01f, -5.02160226e-04f, -7.10566863e-02f, -3.62765323e-03f, -9.49970335e-02f, -1.48297474e-01f, 1.05210682e-02f,
  -4.72270623e-02f, -1.44252554e-01f, -1.41335120e-02f, -1.14738852e-01f, -8.65885094e-02f, -7.03707039e-02f, -9.85273793e-02f, -2.42831185e-02f, -5.61699010e-02f, 1.43572152e-01f,
  4.62604165e-02f, 3.57554257e-02f, 4.53677103e-02f, 6.52397498e-02f, -4.24849205e-02f, 6.15480728e-02f, 5.23646735e-02f, -1.43670008e-01f, -8.91540200e-03f, 2.74395734e-01f,
  2.97337654e-03f, -1.02286451e-01f, -7.46776983e-02f, 4.60284501e-02f, -3.55517026e-04f, 7.35845044e-02f, 9.84328240e-02f, -9.07010958e-02f, 7.23083764e-02f, -8.87349695e-02f,
  -1.49241716e-01f, -1.11846738e-02f, -1.41786411e-01f, -1.70649409e-01f, -9.29469243e-02f, -1.47031248e-01f, -1.44303083e-01f, -5.01825102e-02f, 2.63196998e-03f, 4.40932959e-02f,
  -2.54291408e-02f, -3.50761712e-02f, -2.19070613e-02f, 1.90881610e-01f, 7.22509697e-02f, 1.36354923e-01f, 1.23091035e-01f, -1.28177732e-01f, 2.79586822e-01f, -1.27733767e-01f,
  -8.95573348e-02f, 1.65130988e-01f, 1.40542820e-01f, 1.26524866e-01f, 1.09941199e-01f, -2.02543452e-01f, -9.84189808e-02f, -8.17462876e-02f, -6.82348618e-04f, -7.52095506e-02f,
  1.43509701e-01f, -8.40682760e-02f, -8.80381986e-02f, -2.75765825e-02f, -1.08764470e-01f, 2.00057290e-02f, 3.74645554e-02f, 1.16884381e-01f, -8.25106651e-02f, -2.59703565e-02f,
  2.03323998e-02f, -6.87300935e-02f, -1.22303069e-01f, -6.69429898e-02f, 8.33742544e-02f, 3.85346860e-02f, 9.14763361e-02f, -9.49349254e-02f, 2.23770458e-02f, 4.79051322e-02f,
  -1.10111795e-01f, 1.14551850e-01f, -1.86141342e-01f, -6.18750304e-02f, 2.31442019e-01f, -2.66379416e-01f, 1.14955768e-01f, -1.22627698e-01f, 1.57865867e-01f, -3.07526529e-01f,
  2.28309348e-01f, 1.76571533e-01f, -6.23410121e-02f, -1.09954625e-01f, 7.36989081e-02f, -3.32178595e-03f, -2.66767796e-02f, -2.26108775e-01f, -2.56639943e-02f, 1.08706737e-02f,
  1.87839493e-02f, 1.88882351e-01f, -9.62311998e-02f, 1.23419603e-02f, 5.54227196e-02f, 1.83188364e-01f, 1.57205939e-01f, 1.15693234e-01f, 2.02713132e-01f, 2.92043947e-02f,
  1.40860528e-01f, 3.49337868e-02f, 1.76259980e-01f, 1.68010861e-01f, -2.45231733e-01f, 5.10198846e-02f, -1.25393599e-01f, 1.27262160e-01f, -2.95502543e-01f, -1.31770700e-01f,
  1.59953207e-01f, -1.75835997e-01f, -4.43505608e-02f, -8.46588239e-02f, 1.10857055e-01f, -1.26463786e-01f, 1.25841483e-01f, 9.47349221e-02f, -9.82718021e-02f, -1.10021941e-01f,
  6.90900236e-02f, 5.87724410e-02f, -1.42308012e-01f, -1.15683332e-01f, -4.86498848e-02f, 5.96937500e-02f, 7.52314106e-02f, -1.42465204e-01f, -5.51566519e-02f, -4.75739911e-02f,
  1.97334260e-01f, -1.43945860e-02f, 6.66617751e-02f, -1.26907319e-01f, -1.05114197e-02f, 2.71138810e-02f, -7.21383616e-02f, -4.79187854e-02f, -1.15231313e-01f, 1.65275093e-02f,
  1.91577494e-01f, 6.96550384e-02f, -7.72418827e-02f, 3.00555695e-02f, 6.86897412e-02f, 9.45635140e-02f, 7.40300342e-02f, -1.43879101e-01f, -5.59846535e-02f, 8.23377892e-02f,
  -1.12364300e-01f, -2.58323178e-02f, 1.38223305e-01f, -9.42056552e-02f, 1.33903593e-01f, 1.06404684e-01f, -4.48419712e-02f, -1.16507761e-01f, -1.74861237e-01f, 1.67770028e-01f,
  -1.46750197e-01f, 1.96843818e-01f, 2.59570796e-02f, -7.37302154e-02f, 1.01430327e-01f, -1.69555023e-02f, -1.28200889e-01f, -1.08300522e-01f, -1.68327004e-01f, 1.33750394e-01f,
  2.34111026e-01f, 1.17500521e-01f, -2.09865272e-01f, -5.94039522e-02f, 1.21234827e-01f, -1.66926354e-01f, -6.80817515e-02f, 3.66100408e-02f, 1.68346599e-01f, -1.16077520e-01f,
  2.80023105e-02f, -1.05077110e-01f, -9.73271579e-02f, -1.08463816e-01f, 1.62795544e-01f, 7.94404820e-02f, 5.78908734e-02f, 8.95033777e-03f, 1.98126733e-01f, 8.03628117e-02f,
  -1.78456102e-02f, 1.33079737e-01f, 5.53343780e-02f, 1.56085426e-02f, 1.05251530e-02f, -1.20391496e-01f, 3.68620716e-02f, 2.77603827e-02f, 4.54036631e-02f, -1.51524439e-01f,
  -6.67614043e-02f, -4.11563776e-02f, -1.58704937e-01f, -2.53899880e-02f, 2.77074575e-02f, 1.04244009e-01f, -1.04479283e-01f, -3.28684077e-02f, -1.92020789e-01f, 2.50826869e-03f,
  -6.26798440e-03f, -5.53736240e-02f, 4.75107096e-02f, 1.43446118e-01f, -9.01757851e-02f, -7.70043880e-02f, 1.04568847e-01f, 1.26898363e-01f, 9.71415341e-02f, -4.56974842e-02f,
  7.72889033e-02f, -1.27112702e-01f, -1.24055482e-01f, -1.15001015e-02f, -3.02750133e-02f, 9.77673978e-02f, -3.28802802e-02f, 1.17833756e-01f, 1.57095447e-01f, -9.86187682e-02f,
  -4.29839157e-02f, -6.66284561e-02f, 1.04897745e-01f, 1.62072539e-01f, 8.95782560e-03f, -1.11739868e-02f, 8.97365585e-02f, -1.11900695e-01f, -1.65381134e-01f, -8.50885436e-02f,
  3.39699872e-02f, 9.38703716e-02f, -3.69994529e-02f, -1.13609590e-01f, -3.39282863e-02f, 3.36858421e-03f, -1.06292896e-01f, -9.51560214e-03f, -1.90864075e-02f, -5.11715859e-02f,
  3.70441191e-02f, -1.57198697e-01f, 5.12118749e-02f, -1.14097379e-01f, -4.68554869e-02f, -4.24816534e-02f, -1.29676163e-01f, 3.65489861e-03f, 5.66589125e-02f, 2.80283522e-02f,
  -7.21691502e-03f, -5.42612970e-02f, 9.54964384e-02f, 7.65852258e-02f, -8.28017220e-02f, 9.96914227e-04f, 1.31939068e-01f, -8.43258202e-02f, 5.47799803e-02f, -2.90599782e-02f,
  1.69712573e-01f, 1.10021336e-02f, 1.17652118e-01f, 2.07900777e-02f, -7.10880831e-02f, 2.78795660e-02f, -1.40576726e-02f, -1.06834523e-01f, 3.65456790e-02f, -1.93672106e-01f,
  2.02571582e-02f, 4.31136675e-02f, -1.90137714e-01f, 2.44440511e-02f, -2.38541141e-01f, 1.03515182e-02f, 2.77011812e-01f, -1.22261941e-01f, 2.04469502e-01f, -7.58547429e-03f,
  8.33551288e-02f, -8.94488320e-02f, 2.09281296e-02f, -3.95359099e-02f, 1.17896795e-01f, 1.66294158e-01f, 1.07484553e-02f, 1.33434743e-01f, -1.51344284e-01f, -9.66288596e-02f,
  1.93610117e-01f, -3.13853100e-02f, -9.36557949e-02f, 2.33107015e-01f, -9.46191400e-02f, -2.10067049e-01f, -1.20611638e-01f, -7.39746615e-02f, -1.19922556e-01f, 8.25669169e-02f,
  6.13124669e-02f, -8.56403410e-02f, 1.53691620e-01f, 7.55327195e-02f, 4.18036990e-02f, 1.39663398e-01f, -4.21861373e-02f, -2.73324680e-02f, 1.22964084e-01f, 1.23317577e-01f,
  -3.88992243e-02f, -9.82476678e-03f, 4.06426862e-02f, 8.68858919e-02f, 1.32896900e-01f, -4.63760272e-02f, -1.26527324e-01f, 6.07159846e-02f, -4.84825559e-02f, 1.52823836e-01f,
  -1.32277578e-01f, -3.42374407e-02f, 7.56196082e-02f, 1.80071369e-01f, 5.29212952e-02f, 1.96963623e-01f, 9.53273326e-02f, -2.48703044e-02f, 1.39739409e-01f, -2.20685881e-02f,
  -2.04891890e-01f, -1.14034995e-01f, -1.98716253e-01f, 8.77839401e-02f, 1.49439052e-01f, -7.55079985e-02f, 2.64515262e-02f, -1.03695706e-01f, 2.70198137e-01f, -3.94299701e-02f,
  -5.00468649e-02f, -9.26392227e-02f, -9.53546390e-02f, 1.61883980e-01f, 1.08187906e-01f, 6.75989017e-02f, 2.40540147e-01f, 3.98095138e-02f, 5.00247590e-02f, -1.29911050e-01f,
  1.00682460e-01f, -5.30094700e-03f, 1.14979059e-01f, 1.70390382e-01f, -5.19999750e-02f, -7.42979050e-02f, -6.19813539e-02f, -2.97783334e-02f, 8.82969573e-02f, 2.25191396e-02f,
  9.36618149e-02f, -3.17749232e-02f, -8.99628922e-02f, -7.02755377e-02f, 1.04284890e-01f, -7.05164159e-03f, 1.05690779e-02f, -1.11629575e-01f, 3.01748468e-03f, 1.34598210e-01f,
  -4.24542688e-02f, 7.56498873e-02f, 8.52362141e-02f, 1.24990009e-01f, 1.38037175e-01f, 7.53058195e-02f, 9.91176218e-02f, 6.91403225e-02f, 1.45003155e-01f, -2.67113242e-02f,
  9.42232907e-02f, -1.55197099e-01f, 1.52392751e-02f, 5.18366806e-02f, -5.85538559e-02f, 1.41826019e-01f, 2.47457400e-02f, 2.01867327e-01f, 9.10576731e-02f, 3.23753580e-02f,
  -5.56522459e-02f, -1.68897942e-01f, 1.05613008e-01f, -1.87415779e-01f, -1.55753106e-01f, 3.35557349e-02f, -6.15454428e-02f, -1.07449822e-01f, 1.57332331e-01f, -1.25392586e-01f,
  9.73775461e-02f, -1.55621529e-01f, 2.14230031e-01f, -4.18714359e-02f, -8.23158845e-02f, -7.28894323e-02f, 2.29344890e-02f, -1.01597019e-01f, -1.06984556e-01f, 3.11071873e-01f,
  2.40708858e-01f, -1.44434705e-01f, -6.66436180e-02f, -2.97899634e-01f, -1.24708496e-01f, 2.71175623e-01f, 1.35126069e-01f, 2.65328377e-01f, -1.10128313e-01f, -1.34892151e-01f,
  -1.65387169e-02f, 7.56756440e-02f, 1.74791053e-01f, -7.67925978e-02f, -7.61957243e-02f, -7.41635263e-02f, -2.06457824e-01f, 1.74927518e-01f, -6.01608641e-02f, 3.51630971e-02f,
  -7.10975379e-02f, 8.06212425e-02f, -6.30421040e-04f, -2.02099495e-02f, -5.65314405e-02f, 3.60801183e-02f, -9.15375538e-03f, -1.05689026e-01f, -9.17388946e-02f, -2.91707646e-02f,
  -1.39013246e-01f, 6.13157228e-02f, -2.55436450e-01f, -1.61384374e-01f, -9.93536487e-02f, -5.43536507e-02f, -1.75424054e-01f, 1.77249331e-02f, 1.81894414e-02f, 1.37519643e-01f,
  7.78450370e-02f, -8.02970827e-02f, -1.59830190e-02f, 2.73437560e-01f, 9.09450948e-02f, -8.16845149e-02f, -9.18965414e-02f, 1.43785030e-01f, 6.61619082e-02f, -3.62261720e-02f,
  1.25726253e-01f, -1.09884646e-02f, 2.93090902e-02f, 1.65149663e-02f, -1.19938098e-01f, 2.62247235e-01f, -1.26749530e-01f, 1.63098499e-01f, -1.64169148e-01f, -1.40726790e-01f,
  -1.35800481e-01f, 1.38317086e-02f, 2.09184453e-01f, -1.86019406e-01f, -1.63289353e-01f, -1.29069149e-01f, 1.68216929e-01f, 5.09081036e-02f, 5.85772432e-02f, -1.75153956e-01f,
  2.47362852e-01f, 8.71328861e-02f, 1.33186244e-04f, -2.99790241e-02f, 4.93382709e-03f, -1.45330295e-01f, 1.04975954e-01f, -1.43102212e-02f, 1.34702280e-01f, 1.18360929e-01f,
  9.44544226e-02f, -1.86136618e-01f, -4.71340977e-02f, 3.21145020e-02f, 1.17915154e-01f, 6.08086176e-02f, -1.91002022e-02f, -7.91267008e-02f, -5.45218587e-02f, -4.43441048e-02f,
  1.38109967e-01f, 1.43180326e-01f, 5.79627007e-02f, 2.56221592e-02f, 1.18349142e-01f, -9.20366868e-02f, -4.77875806e-02f, 7.28641376e-02f, -1.69936735e-02f, -1.54869005e-01f,
  3.19804586e-02f, -1.92705989e-02f, 3.09993252e-02f, 6.90762848e-02f, -1.22444525e-01f, -1.56221269e-02f, 6.54539913e-02f, -2.52006780e-02f, -1.16641663e-01f, -1.97695056e-03f,
  9.37917903e-02f, -1.21463627e-01f, 2.34175418e-02f, 7.41282031e-02f, -3.33821997e-02f, -4.79438938e-02f, 8.63950979e-03f, 2.18469799e-02f, 7.34457672e-02f, 1.68719694e-01f,
  9.68053564e-02f, -6.60687163e-02f, -9.78533551e-02f, -2.80190166e-02f, -1.26805514e-01f, 1.75643563e-02f, 1.37583644e-03f, 6.51015788e-02f, 1.90544039e-01f, -1.10153541e-01f,
  3.47543944e-04f, 2.54607778e-02f, -7.65451342e-02f, 2.10214332e-01f, 1.40230015e-01f, 1.06654175e-01f, 7.24017769e-02f, -1.25070736e-01f, -1.32192131e-02f, -8.06243420e-02f,
  8.50677863e-02f, -1.11168675e-01f, -5.42256869e-02f, -1.18784927e-01f, 1.08454578e-01f, 7.68523067e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.38432428e-01f, -6.60812259e-02f, 6.95636645e-02f, -2.13122163e-02f, 1.42796770e-01f, 2.30170622e-01f, 4.37681116e-02f, -2.03465540e-02f, 1.11100832e-02f, 1.94151446e-01f,
  1.46719798e-01f, 1.39957950e-01f, 8.61399099e-02f, 8.96434784e-02f, -2.33831666e-02f, 2.47175425e-01f, 1.25332355e-01f, 8.15508887e-02f, 1.11237951e-01f, 1.05690680e-01f,
  -1.81119502e-01f, 1.35864094e-01f, -4.32667397e-02f, 1.97815359e-01f, -8.88257772e-02f, 8.94877613e-02f, -1.47735521e-01f, -1.87956244e-01f, -1.19654439e-01f, -1.13166757e-01f,
  -1.02427125e-01f, -1.89679995e-01f, -1.86209559e-01f, 3.24483253e-02f, -1.78521410e-01f, -1.29567698e-01f, -1.21579990e-01f, -2.17298001e-01f, 2.41680726e-01f, -1.35312136e-03f,
  1.38160646e-01f, -2.74845630e-01f, 1.29172519e-01f, -3.04055154e-01f, -5.85321011e-03f, 1.05712853e-01f, -2.40530267e-01f, 1.02022111e-01f, -2.77626328e-02f, -1.05814543e-02f,
  5.90500571e-02f, 5.74784987e-02f, 1.65884960e-02f, 7.77015463e-02f, 3.11528325e-01f, 8.96972232e-03f, -1.40775755e-01f, 3.09674233e-01f, 1.58160284e-01f, 1.79242402e-01f,
  -1.14089988e-01f, -2.00193927e-01f, -1.15757734e-01f, 1.62746593e-01f, 2.25319311e-01f, 1.42261356e-01f, 1.44802868e-01f, 2.69018076e-02f, 2.97447555e-02f, 4.87680808e-02f,
  2.44967669e-01f, 3.56668383e-02f, 8.30082670e-02f, 1.80682391e-01f, 7.71337301e-02f, 1.85744211e-01f, 5.45786023e-02f, 3.48954834e-02f, 1.66899443e-01f, 8.06562528e-02f,
  4.82313707e-02f, -6.59989119e-02f, 2.02485472e-01f, 1.04365937e-01f, -1.81447461e-01f, 9.73344967e-02f, -2.31289983e-01f, 7.46704265e-02f, 4.92834076e-02f, 4.94463257e-02f,
  -8.40943605e-02f, -2.72420913e-01f, 1.90404564e-01f, -1.57278106e-01f, -1.41455278e-01f, -1.53124612e-02f, -9.66837704e-02f, 1.02088690e-01f, -2.29443312e-02f, -2.83345971e-02f,
  1.76025242e-01f, -1.38989300e-01f, 1.09744854e-01f, -2.04623088e-01f, -6.44676164e-02f, 1.58694729e-01f, 1.74364578e-02f, -3.95485982e-02f, -4.58280370e-02f, 2.98641026e-01f,
  2.28404507e-01f, 1.01998165e-01f, -1.68530390e-01f, -6.29583076e-02f, -4.44828980e-02f, 3.76512319e-01f, 3.93905975e-02f, 2.67575920e-01f, 2.02387080e-01f, -2.16336176e-01f,
  -7.99259320e-02f, 4.98996787e-02f, 1.20658316e-01f, 1.41227156e-01f, -4.23255451e-02f, -1.89518943e-01f, -1.31308123e-01f, 1.28527835e-01f, -4.56522666e-02f, -4.61161183e-03f,
  -4.03518742e-03f, 2.78038770e-01f, 1.24184422e-01f, 1.12065479e-01f, 6.02677613e-02f, 2.19594494e-01f, 1.11416392e-01f, 4.33113351e-02f, -7.88299441e-02f, 1.54525593e-01f,
  1.88847914e-01f, 6.56161979e-02f, -1.41355112e-01f, 4.44411449e-02f, 1.69915244e-01f, 1.67743489e-01f, -1.27688691e-01f, -1.86500326e-02f, 1.60973161e-01f, -2.38184899e-01f,
  2.55536646e-01f, -1.41038507e-01f, 5.78742921e-02f, 3.01523730e-02f, 2.25045651e-01f, 1.58405617e-01f, -1.27278477e-01f, -4.14898507e-02f, -2.26850342e-02f, -5.90286851e-02f,
  2.60043830e-01f, -9.63607430e-03f, -1.41570657e-01f, -9.06587690e-02f, -9.78949666e-02f, 1.27190739e-01f, -1.95777074e-01f, 2.80095577e-01f, 8.23736861e-02f, 6.90329745e-02f,
  5.91842793e-02f, 8.12868178e-02f, 2.84982156e-02f, -1.72083631e-01f, -8.13905299e-02f, 6.30826727e-02f, 2.69316673e-01f, 2.77779788e-01f, -6.49228320e-02f, -1.91307217e-01f,
  1.73554316e-01f, 1.94502860e-01f, -1.75671011e-01f, 2.07953945e-01f, 1.69233412e-01f, 1.83727682e-01f, 1.14477649e-01f, -1.45328060e-01f, 1.49459675e-01f, 9.49828029e-02f,
  -2.84640696e-02f, 1.68135837e-01f, 2.30056383e-02f, 1.94534555e-01f, 1.70014784e-01f, 1.44374043e-01f, 4.79942523e-02f, 1.83915451e-01f, 2.59487242e-01f, 2.12665454e-01f,
  1.27106696e-01f, 2.34713495e-01f, 1.72032148e-01f, 2.91722059e-01f, 5.23691364e-02f, 2.60111094e-01f, 8.92993715e-03f, 2.69664496e-01f, 3.36366653e-01f, 2.42232963e-01f,
  4.75455411e-02f, -1.39826819e-01f, 1.13547258e-01f, 3.00846342e-02f, 1.55902244e-02f, -4.96961512e-02f, 2.87100852e-01f, -3.21954042e-01f, -1.03217490e-01f, -1.01069227e-01f,
  -9.55556557e-02f, 1.75537556e-01f, 2.06323668e-01f, 7.66288564e-02f, 2.33172372e-01f, -1.21587202e-01f, -1.74231812e-01f, -2.34800088e-03f, 1.12708405e-01f, -6.69407398e-02f,
  2.07268208e-01f, -8.15523192e-02f, 2.21431121e-01f, -2.17861801e-01f, 1.91144213e-01f, -1.57590851e-01f, 8.95869434e-02f, 1.66308299e-01f, -1.34895176e-01f, 8.59081075e-02f,
  6.22590035e-02f, 2.43914768e-01f, 5.11883125e-02f, 6.43791258e-02f, -1.49442166e-01f, -1.25097230e-01f, -1.02850184e-01f, 2.94044971e-01f, 7.34666288e-02f, 1.30272629e-02f,
  7.19315708e-02f, 5.27907796e-02f, 2.09803712e-02f, 3.02333254e-02f, 2.26012349e-01f, 6.38976023e-02f, 1.41272014e-02f, 1.77040756e-01f, 3.58763784e-02f, 1.37790233e-01f,
  1.90629840e-01f, -3.24662142e-02f, 9.48254019e-02f, 2.47271042e-02f, 1.26913711e-01f, 1.96649149e-01f, 9.30148587e-02f, 1.08598806e-01f, 1.50827184e-01f, 3.25293019e-02f,
  1.88205123e-01f, 1.50767192e-01f, 1.47078082e-01f, 3.65076251e-02f, -2.61884872e-02f, 1.66199833e-01f, -4.92500365e-02f, 1.13373645e-01f, -2.26455301e-01f, -7.47989789e-02f,
  1.73415579e-02f, 1.32618323e-01f, -1.89238995e-01f, -1.03952020e-01f, 8.43303278e-02f, 1.40748592e-02f, 1.44365439e-02f, 1.71228006e-01f, -1.07080884e-01f, -1.92986757e-01f,
  -1.09149948e-01f, -1.07392959e-01f, 1.33998124e-02f, 1.00562021e-01f, 1.88431680e-01f, 1.75707936e-01f, -1.41616151e-01f, -1.32735819e-02f, -1.88719973e-01f, 2.15795860e-01f,
  4.86058965e-02f, 2.73649432e-02f, 1.75047129e-01f, -2.03887090e-01f, -4.03232053e-02f, -9.50549319e-02f, -9.70721152e-03f, 1.78537816e-01f, 1.65123731e-01f, 1.06234811e-01f,
  2.38285527e-01f, -5.80871031e-02f, 1.53837398e-01f, 4.17611049e-03f, 6.32970408e-02f, -1.10499926e-01f, 2.00340241e-01f, -5.57545535e-02f, -4.07347130e-03f, -1.58789963e-01f,
  1.02542832e-01f, 2.31330141e-01f, -5.67084120e-04f, 7.55015165e-02f, 1.36729419e-01f, 2.12545812e-01f, 2.29444101e-01f, 1.94415346e-01f, -8.58941823e-02f, 6.39462024e-02f,
  1.06363878e-01f, -7.10722432e-02f, 1.96752951e-01f, 7.76468776e-03f, 2.28704154e-01f, 1.96444780e-01f, 3.56863923e-02f, 4.38698679e-02f, 1.20659344e-01f, -2.92159855e-01f,
  1.18001834e-01f, -2.36655939e-02f, 2.19701320e-01f, 9.17106867e-02f, -9.49597880e-02f, -2.70591080e-01f, 6.03151396e-02f, 3.00710112e-01f, -1.52535215e-01f, 7.70977214e-02f,
  8.08840676e-04f, -4.56035323e-02f, 5.88891730e-02f, 1.38133362e-01f, 7.64819086e-02f, 1.50471076e-01f, 1.52204663e-01f, -3.07720024e-02f, -8.42695460e-02f, -3.88046801e-02f,
  6.00757152e-02f, 1.53924882e-01f, 7.30365235e-03f, 1.80271983e-01f, -1.58527002e-01f, 2.42157236e-01f, 1.69780076e-01f, 6.32103235e-02f, -1.80507407e-01f, 5.04936278e-03f,
  -5.68457879e-02f, 2.34751001e-01f, 3.98448482e-02f, -1.14426449e-01f, -7.74189904e-02f, -1.92743130e-02f, 3.85070443e-02f, 3.83728631e-02f, -9.04322267e-02f, 9.34542045e-02f,
  3.86240752e-03f, -5.79966567e-02f, 9.87564474e-02f, 7.94968456e-02f, 2.13804454e-01f, 7.40467459e-02f, 3.06601264e-02f, 1.53662652e-01f, 1.04616135e-01f, 1.58527181e-01f,
  1.08708896e-01f, -4.08677012e-03f, 8.41002017e-02f, 1.58141963e-02f, 1.43568903e-01f, 5.60489185e-02f, 2.63953030e-01f, 1.51944593e-01f, 1.12140685e-01f, 1.37462676e-01f,
  4.61822599e-02f, -8.96407217e-02f, 2.73638014e-02f, 2.04753861e-01f, 1.36744976e-02f, -1.56917367e-02f, -4.21700217e-02f, 1.77403226e-01f, 1.07873373e-01f, -7.37579986e-02f,
  5.63727273e-03f, -1.63217664e-01f, 7.07823038e-02f, -2.02624217e-01f, 1.51271084e-02f, 4.62720804e-02f, -2.14275777e-01f, 1.54662626e-02f, 7.19912574e-02f, -7.86012486e-02f,
  1.29119113e-01f, -1.25983372e-01f, 1.54289268e-02f, -1.41864410e-02f, -1.32654384e-01f, 1.89622983e-01f, -8.20622444e-02f, 1.15932941e-01f, -3.33407968e-02f, 1.52657464e-01f,
  2.16804057e-01f, -1.14850402e-01f, -1.09315664e-01f, -2.43256912e-01f, -1.98954359e-01f, 3.16929311e-01f, 2.09999457e-02f, 2.20618382e-01f, -4.00186814e-02f, -1.42296776e-01f,
  7.72428289e-02f, 1.35227233e-01f, 1.57013401e-01f, -8.48773420e-02f, 1.96359962e-01f, -4.36407551e-02f, -5.02021350e-02f, 1.83496565e-01f, 4.92523350e-02f, -1.19961658e-02f,
  -4.46908325e-02f, 1.73093617e-01f, 8.20332244e-02f, 2.54906565e-01f, 1.75058484e-01f, 1.28039658e-01f, 5.24766818e-02f, 6.06505461e-02f, -1.06795905e-02f, 1.83609594e-02f,
  2.36378208e-01f, 3.33754085e-02f, 1.01365268e-01f, -9.49149579e-02f, -3.26355584e-02f, 2.27289815e-02f, 6.47963071e-03f, -1.32696629e-01f, 2.98807491e-03f, 1.19702779e-01f,
  -9.02208537e-02f, 9.53923836e-02f, -1.11871101e-01f, 2.11426497e-01f, 5.49378842e-02f, -2.69725211e-02f, 2.49515437e-02f, -7.42357820e-02f, -2.35150367e-01f, 1.27057284e-01f,
  -1.36983052e-01f, 1.64764062e-01f, 1.21261656e-01f, 1.21630579e-01f, 1.46097869e-01f, -2.35734582e-01f, 1.51335001e-01f, -5.20645715e-02f, -2.69865334e-01f, 2.32689261e-01f,
  -1.11422434e-01f, 1.11132331e-01f, -4.37318087e-02f, 1.13017827e-01f, 1.71325922e-01f, 1.52151227e-01f, -1.55373856e-01f, -4.22733165e-02f, 1.27341405e-01f, -7.58801540e-03f,
  4.39032167e-02f, 7.13090301e-02f, -2.39980608e-01f, -8.50641653e-02f, 3.46030183e-02f, -1.36709571e-01f, 3.90127447e-04f, 1.12232596e-01f, 1.82933837e-01f, 6.81037828e-02f,
  1.76776901e-01f, -1.12807609e-01f, 1.63913384e-01f, 1.27965674e-01f, -1.77379977e-02f, -2.51276102e-02f, 2.66759992e-01f, 1.80600900e-02f, 1.30734056e-01f, 7.03017935e-02f,
  2.38613769e-01f, -9.35235992e-03f, 1.27090007e-01f, 1.46055901e-02f, 7.72842914e-02f, 1.35865748e-01f, 1.34180963e-01f, 7.37183467e-02f, 2.80476827e-02f, 1.67756066e-01f,
  2.15264842e-01f, -8.31910744e-02f, -1.05933398e-01f, 1.09575400e-02f, -1.38966382e-01f, -8.66786614e-02f, -3.12542021e-02f, 1.65824860e-01f, -1.51624471e-01f, 2.64488291e-02f,
  -9.44584236e-02f, 1.90954968e-01f, 3.26833047e-04f, 2.38236561e-01f, 1.16871819e-01f, 2.12174252e-01f, 8.40743035e-02f, 1.80263132e-01f, 9.39407870e-02f, -1.24263629e-01f,
  8.00205916e-02f, 2.42342576e-01f, -1.06875338e-01f, 4.59894463e-02f, 4.63686362e-02f, -3.70833017e-02f, -1.07487645e-02f, -1.62979979e-02f, -7.54779726e-02f, 1.73723310e-01f,
  -3.55394334e-02f, 2.70480569e-02f, 2.29259074e-01f, 6.06177300e-02f, -1.59104913e-01f, 1.14103444e-02f, -5.17004058e-02f, 2.04696208e-01f, -7.92548284e-02f, -1.36532649e-01f,
  1.87625587e-01f, 2.40208894e-01f, 1.20640971e-01f, 1.86395049e-01f, 1.32155582e-01f, -1.26261055e-01f, 9.50942189e-02f, 7.85928220e-02f, -5.50204851e-02f, -3.30330729e-02f,
  1.50292903e-01f, 4.79827672e-02f, 1.29060388e-01f, 6.68349490e-02f, 1.59007646e-02f, 9.36201438e-02f, 8.11915472e-02f, 1.24864407e-01f, -7.25027174e-02f, 1.68859079e-01f,
  2.25709423e-01f, 2.33072653e-01f, 1.55377775e-01f, 1.26780704e-01f, 5.71352430e-02f, -1.38159886e-01f, -1.59075052e-01f, 3.03830076e-02f, -7.08521083e-02f, 3.23965377e-03f,
  -6.92383870e-02f, 1.97974116e-01f, -1.48247704e-01f, -6.42745867e-02f, -1.26348749e-01f, 1.89359426e-01f, -7.52894953e-02f, -1.62743226e-01f, -2.07412988e-01f, 1.93565175e-01f,
  9.10102800e-02f, -3.25820073e-02f, 6.31245226e-02f, -2.14633465e-01f, 1.51206896e-01f, 2.23521575e-01f, -8.76388513e-03f, -1.67254999e-01f, 2.32088387e-01f, -2.13435531e-01f,
  -1.79332972e-01f, -6.42005131e-02f, -1.93008974e-01f, 1.68396875e-01f, -1.49344087e-01f, -3.68706323e-02f, 2.44771570e-01f, -1.61164463e-01f, 3.53826098e-02f, -1.33247182e-01f,
  1.47238299e-01f, 3.23831528e-01f, 7.05767656e-03f, 2.40994036e-01f, 5.08293957e-02f, 2.39264786e-01f, 5.13324216e-02f, 1.19256206e-01f, 1.38743043e-01f, -5.87841831e-02f,
  3.43742631e-02f, 5.25529794e-02f, -1.53329074e-02f, -5.16801421e-03f, -7.17328638e-02f, 2.05248728e-01f, -1.46360192e-02f, -3.21967378e-02f, 7.85515308e-02f, 2.62139067e-02f,
  -1.14065431e-01f, 1.18293084e-01f, 5.94739057e-02f, 7.99075663e-02f, 1.58202350e-01f, 1.64091453e-01f, 5.94272837e-02f, -7.48635232e-02f, 1.13616548e-01f, 1.59500569e-01f,
  9.04979408e-02f, -9.13418680e-02f, 7.78201073e-02f, 7.61130527e-02f, 1.01157844e-01f, -1.87276423e-01f, 2.34130502e-01f, -1.31443456e-01f, 1.23006152e-02f, -2.44853616e-01f,
  -5.98343015e-02f, -3.08454305e-01f, -1.30303875e-01f, 1.23006164e-03f, -9.61302891e-02f, -2.53566235e-01f, -1.32620916e-01f, -2.73922056e-01f, -2.04183981e-02f, -9.66876522e-02f,
  2.33714700e-01f, 8.12187120e-02f, 3.16434532e-01f, -1.68930396e-01f, 1.09656580e-01f, -8.30549225e-02f, 2.55772844e-02f, -1.11561328e-01f, 7.58336931e-02f, -1.28915235e-02f,
  -3.84221561e-02f, 1.17946424e-01f, -2.28722412e-02f, 8.01619217e-02f, 1.08949440e-02f, 1.89101845e-01f, -7.24712685e-02f, 2.34689251e-01f, -1.37566611e-01f, -3.78254279e-02f,
  -1.22336112e-01f, -3.45346406e-02f, -8.32380578e-02f, 2.89605796e-01f, -9.81833041e-03f, 1.91364855e-01f, -2.81341393e-02f, 1.93172544e-01f, 4.62848991e-02f, 6.22471683e-02f,
  1.09951355e-01f, 2.76544522e-02f, 3.87839153e-02f, -3.27587361e-03f, 2.33149260e-01f, 6.86462224e-02f, -2.24816892e-02f, 6.47693733e-03f, -4.68130596e-02f, 1.10963665e-01f,
  2.29481667e-01f, 7.54609108e-02f, 1.96213126e-01f, -5.69979474e-02f, 2.46202633e-01f, -1.36845917e-01f, -1.48836449e-01f, 4.41596610e-03f, 1.59806594e-01f, -1.85389891e-01f,
  -7.07997521e-03f, 5.14512472e-02f, 2.14129668e-02f, 8.39657150e-03f, 3.07225585e-01f, 2.42562220e-01f, 1.63522765e-01f, -3.16182703e-01f, -2.43676767e-01f, -1.35595836e-02f,
  -2.26271003e-02f, 4.44608778e-02f, -2.90665507e-01f, -2.57585913e-01f, 2.45547853e-02f, -1.17993847e-01f, 2.04135075e-01f, 1.62017897e-01f, 1.89224452e-01f, -1.66030843e-02f,
  4.63740490e-02f, -1.18456632e-01f, 1.67010710e-01f, 2.65248388e-01f, -6.67842627e-02f, 1.55644953e-01f, -2.32087374e-01f, -7.86877349e-02f, -1.44927159e-01f, 1.07820690e-01f,
  7.01590301e-03f, 1.61933035e-01f, 7.05874488e-02f, -7.38285929e-02f, -3.71460430e-02f, -2.03509316e-01f, 1.51485771e-01f, 2.31898911e-02f, 1.23405382e-01f, 9.49466750e-02f,
  1.42336532e-01f, 1.89701825e-01f, 2.02202886e-01f, -6.86947480e-02f, -1.85862537e-02f, 1.92943793e-02f, -6.15814067e-02f, 8.00669193e-02f, 3.86124998e-02f, 1.83756888e-01f,
  -6.29161447e-02f, 9.72818956e-02f, 1.47907585e-01f, 1.92690417e-01f, 2.04692945e-01f, 1.77960128e-01f, 5.52809052e-02f, 9.81227160e-02f, 7.01491013e-02f, -2.01408148e-01f,
  2.72253715e-02f, -4.90331836e-02f, 1.27604276e-01f, -2.09025115e-01f, 1.03312120e-01f, 9.17827189e-02f, 1.00811437e-01f, -8.11164975e-02f, 1.22222856e-01f, 4.90171127e-02f,
  4.54185680e-02f, -1.19413860e-01f, -1.27696782e-01f, -1.67716444e-01f, -1.35395348e-01f, 7.87770897e-02f, -2.40917146e-01f, 1.76800862e-01f, 1.23740442e-01f, -5.03997058e-02f,
  2.05605313e-01f, 1.77186251e-01f, 8.66835639e-02f, -3.17940190e-02f, -8.66055787e-02f, -2.29449153e-01f, 2.22610250e-01f, 1.90372631e-01f, -2.00807646e-01f, -2.81093679e-02f,
  -1.48043111e-01f, 9.23403725e-02f, -1.92283377e-01f, 8.90593305e-02f, -4.15918604e-02f, 2.06362903e-01f, 1.07607998e-01f, -2.68450469e-01f, 1.75332248e-01f, 1.04247071e-01f,
  1.45571277e-01f, -1.30030606e-02f, 4.17399146e-02f, 1.73299760e-01f, 2.47542523e-02f, 8.86577368e-02f, 2.70908922e-01f, 2.01308187e-02f, 1.21420193e-02f, 1.53769091e-01f,
  2.18513802e-01f, 1.57323644e-01f, 1.85976058e-01f, -2.26576137e-03f, -1.44619774e-02f, 3.88979241e-02f, -8.40532687e-03f, 1.62442382e-02f, 7.83463418e-02f, 1.41879529e-01f,
  9.68346372e-02f, 1.86065286e-02f, 8.42756331e-02f, -8.29292089e-02f, -1.41331196e-01f, -1.03709325e-01f, -2.51946926e-01f, 2.42161468e-01f, 7.29947612e-02f, -1.93416551e-02f,
  -4.66901176e-02f, 2.07919762e-01f, 7.40357935e-02f, 1.58515736e-01f, -1.17087461e-01f, 8.46727192e-02f, 1.03309222e-01f, 1.04229353e-01f, -2.16625165e-02f, 6.54159412e-02f,
  6.81610852e-02f, 2.86754161e-01f, -1.42838046e-01f, 7.33299926e-02f, -3.00659221e-02f, 2.04301074e-01f, -1.03665188e-01f, -3.12659331e-02f, 6.76763281e-02f, 2.33712330e-01f,
  6.53014854e-02f, 4.26632315e-02f, 2.79474407e-01f, -3.73048522e-02f, 1.31268762e-02f, -3.95999812e-02f, -5.11591174e-02f, 2.07308233e-01f, 1.54856928e-02f, -6.42297193e-02f,
  -1.11507392e-02f, 1.09227680e-01f, 4.80711646e-02f, 2.93986797e-01f, 2.02753454e-01f, -1.93818584e-01f, 1.17734283e-01f, 8.99009258e-02f, 5.76672629e-02f, 1.82132512e-01f,
  5.07571697e-02f, 3.27094793e-02f, -9.03436095e-02f, 6.29183799e-02f, 6.79239184e-02f, -8.43964368e-02f, -1.09917574e-01f, 6.39653951e-02f, 1.07046571e-02f, 6.13827817e-02f,
  -3.23790014e-02f, -1.26315067e-02f, 1.12238169e-01f, 2.56464630e-02f, -1.87203303e-01f, 1.53874412e-01f, -8.14553052e-02f, 4.33406346e-02f, 1.89617977e-01f, -4.07498255e-02f,
  -8.87961462e-02f, 1.67941391e-01f, -2.88823852e-03f, 1.68902785e-01f, 4.25402727e-03f, -7.52805322e-02f, -1.92623973e-01f, 2.06633545e-02f, 9.51164067e-02f, 1.10262565e-01f,
  -4.33910824e-02f, -9.50234458e-02f, 1.91043168e-02f, 1.28828660e-01f, -3.15186270e-02f, 3.63108993e-01f, 6.25745952e-02f, 1.57536104e-01f, -1.06744366e-02f, -1.11503061e-02f,
  6.00267947e-02f, -1.71258330e-01f, 1.09224953e-01f, 1.78576976e-01f, 1.20730765e-01f, -5.65160587e-02f, 1.89322494e-02f, -1.88919708e-01f, 3.16968590e-01f, 1.47693278e-02f,
  -1.05876058e-01f, 1.12585172e-01f, 2.57427931e-01f, -6.98219463e-02f, 1.33694530e-01f, 2.00296454e-02f, 1.66451812e-01f, 3.57335120e-01f, 9.81960520e-02f, -1.87239572e-02f,
  2.42469683e-01f, 1.03752211e-01f, -5.96081913e-02f, 2.48523820e-02f, 1.25787314e-02f, -6.44862577e-02f, -9.47778001e-02f, 1.12927645e-01f, 1.92877889e-01f, 1.20067455e-01f,
  -9.92142186e-02f, 4.57320400e-02f, -4.03366648e-02f, 1.27186731e-01f, -1.53542235e-01f, -1.87721163e-01f, 6.05498366e-02f, -6.35040104e-02f, 2.56564585e-03f, 7.60377124e-02f,
  -5.27400263e-02f, -1.52608424e-01f, -1.04238272e-01f, -7.83343539e-02f, -2.86048889e-01f, 3.82972956e-01f, -2.57544480e-02f, -2.13432208e-01f, -1.33795872e-01f, 3.13041583e-02f,
  -2.00041160e-02f, -1.79924622e-01f, 5.87947853e-02f, 2.37264574e-01f, -2.88846400e-02f, -6.44922256e-02f, -7.00988024e-02f, 9.26677436e-02f, -4.95288968e-02f, 2.89650470e-01f,
  2.97353300e-03f, -2.99219768e-02f, -2.37160996e-01f, -3.84025685e-02f, 5.06952628e-02f, -2.76313037e-01f, 6.29553199e-02f, -1.56256631e-02f, -1.09704040e-01f, 1.88853070e-02f,
  2.23965924e-02f, -3.14761341e-01f, 1.92648724e-01f, 1.67335376e-01f, 1.96663886e-02f, 2.19435796e-01f, 1.79559052e-01f, -4.29412797e-02f, -9.47299749e-02f, -1.29494995e-01f,
  -9.76798385e-02f, 2.79623240e-01f, 6.49773255e-02f, -1.32902071e-01f, 6.97665662e-02f, 1.05847999e-01f, -1.03746783e-02f, 2.66192943e-01f, -4.39322889e-02f, 3.70326219e-03f,
  1.06020145e-01f, 1.04134984e-01f, 1.93755507e-01f, 3.13765481e-02f, -1.96270406e-01f, 5.55562228e-02f, 2.11546004e-01f, 5.08183762e-02f, 1.29622698e-01f, -4.98421453e-02f,
  -1.10746287e-01f, 5.64663783e-02f, -2.35110059e-01f, 4.59729880e-02f, 4.44976985e-02f, -1.18647315e-01f, 5.33565693e-02f, 6.36855559e-03f, -1.31829903e-01f, 1.07944332e-01f,
  1.41036466e-01f, 2.77637057e-02f, 6.27803504e-02f, -1.12670295e-01f, -1.63132221e-01f, 6.68175220e-02f, -1.06721390e-02f, -1.16183192e-01f, 2.55524926e-02f, -7.00818002e-02f,
  -3.43441442e-02f, 2.25720033e-01f, 2.31212117e-02f, 3.15517873e-01f, 3.83426696e-02f, 2.59496141e-02f, -1.68299168e-01f, 8.05658773e-02f, 1.70553923e-01f, -3.88238244e-02f,
  1.60587758e-01f, -2.05288351e-01f, 1.81737989e-01f, -1.30734546e-03f, -1.06861241e-01f, -4.07015681e-02f, 2.00301170e-01f, 1.41356558e-01f, 9.98868644e-02f, -6.77088322e-03f,
  1.59576982e-01f, -1.26033604e-01f, 1.76768694e-02f, -6.99371845e-02f, 1.65321052e-01f, 1.87753618e-01f, 8.29652846e-02f, 7.30407760e-02f, 2.43737716e-02f, -3.34372371e-03f,
  -6.34961203e-02f, 5.98859824e-02f, -1.16055598e-02f, 2.25577995e-01f, 2.51982510e-02f, 1.17989648e-02f, 1.32595047e-01f, -6.53480142e-02f, -1.11160748e-01f, 5.98942786e-02f,
  2.25803316e-01f, 1.25466436e-01f, 4.08183075e-02f, 9.66020077e-02f, -1.88588455e-01f, -6.38210475e-02f, 6.09879084e-02f, -7.47994632e-02f, -9.48603228e-02f, 5.60903782e-03f,
  2.22108603e-01f, -3.73707674e-02f, 2.12192275e-02f, 1.49389029e-01f, 2.13788852e-01f, 1.29527450e-01f, 1.25171319e-01f, -2.56789058e-01f, -7.94923455e-02f, -2.05724128e-02f,
  -1.34371728e-01f, -7.83823058e-02f, 1.93133205e-01f, -4.57680635e-02f, 1.58985570e-01f, 1.33782640e-01f, 6.70810193e-02f, 1.52856305e-01f, -1.06011905e-01f, 1.82591021e-01f,
  -1.64697319e-02f, 2.42146865e-01f, 1.14837147e-01f, 4.21540663e-02f, 3.27381521e-01f, 1.12081870e-01f, 5.82781583e-02f, -1.27848595e-01f, -2.29270607e-02f, 6.62930459e-02f,
  9.66332555e-02f, 2.56878823e-01f, -1.65289789e-01f, -9.77537632e-02f, 2.58720890e-02f, -2.78927505e-01f, 6.17233962e-02f, -3.31448913e-02f, 2.46201321e-01f, -4.05868031e-02f,
  9.55006331e-02f, -6.48724437e-02f, 5.39885722e-02f, 1.97270468e-01f, -1.81198232e-02f, 1.50890350e-01f, -4.60825004e-02f, -4.07195166e-02f, 5.45427240e-02f, 1.58979446e-01f,
  1.81930773e-02f, -8.64249095e-02f, -1.27883419e-01f, -2.07595415e-02f, 5.11856079e-02f, 7.28605464e-02f, 1.62626971e-02f, -2.49330158e-04f, 9.72075537e-02f, 3.79192382e-02f,
  1.14426211e-01f, -1.63603470e-01f, -3.17471027e-02f, -1.05271168e-01f, 1.46308243e-01f, 9.08890590e-02f, -2.21238658e-01f, -3.70487794e-02f, 7.23996982e-02f, 2.06122920e-01f,
  -2.59383827e-01f, -1.19231921e-02f, 3.01959328e-02f, -3.05486713e-02f, 8.38821456e-02f, 1.59459919e-01f, 1.33879974e-01f, 1.99172318e-01f, -7.75649911e-03f, 1.82140633e-01f,
  -9.41289309e-03f, 2.59911150e-01f, -6.66502789e-02f, -6.54788837e-02f, 7.36656645e-03f, -5.95059572e-03f, -1.17158949e-01f, -1.04240060e-01f, 5.68748526e-02f, 9.36643258e-02f,
  -1.33880854e-01f, 9.35231447e-02f, 1.29834218e-02f, -1.96926475e-01f, -4.58869822e-02f, 5.82842864e-02f, -1.02984101e-01f, 1.49507761e-01f, 1.27865791e-01f, 4.62450646e-02f,
  -2.30877951e-01f, 5.52116632e-02f, -4.67030108e-02f, 1.07108258e-01f, 2.06679434e-01f, -1.35544688e-01f, -6.13721646e-03f, 1.27463534e-01f, 1.34309247e-01f, 2.10810587e-01f,
  1.49320409e-01f, -8.73367116e-02f, -2.33918428e-02f, -6.02929443e-02f, 9.00069326e-02f, 4.22923081e-02f, -1.13690965e-01f, 1.29072577e-01f, 1.64765358e-01f, -3.17269303e-02f,
  6.36074916e-02f, 6.30337326e-03f, 3.46964039e-02f, 7.02141970e-02f, -1.47653550e-01f, 2.76389748e-01f, 2.78683126e-01f, -2.27246568e-01f, 2.51117796e-02f, -7.21879303e-02f,
  1.08125880e-01f, 1.85607925e-01f, 2.12458983e-01f, -1.63870364e-01f, 2.05660805e-01f, -8.31195489e-02f, 8.03079049e-04f, -3.18290554e-02f, 1.09541364e-01f, -1.14056014e-01f,
  -9.07844529e-02f, -1.59771502e-01f, -1.88143998e-01f, 2.28796974e-01f, -1.74455941e-02f, 1.29311815e-01f, -6.66629001e-02f, -8.59018415e-02f, -1.29594713e-01f, 1.99257165e-01f,
  1.53143108e-01f, 4.81023379e-02f, 1.08746186e-01f, -1.78994507e-01f, 1.90124139e-01f, 1.71322450e-01f, -7.70500451e-02f, 1.94803610e-01f, 5.92513680e-02f, 2.23733589e-01f,
  -3.62764951e-03f, -8.29717889e-02f, 1.34732828e-01f, 8.49325284e-02f, 1.05593801e-01f, -2.80648082e-01f, 7.05087185e-02f, 1.77211687e-02f, 1.31956965e-01f, 1.83385268e-01f,
  3.30933817e-02f, 3.16281505e-02f, -8.86865798e-03f, 1.84729397e-01f, -1.42927757e-02f, 1.41138926e-01f, 1.27086788e-01f, -1.04152681e-02f, 4.92062196e-02f, 4.69761156e-02f,
  -5.52150048e-02f, -9.16218087e-02f, -3.14244479e-02f, 3.05926036e-02f, 1.83857009e-02f, 1.14440471e-01f, 1.14497155e-01f, 2.22013518e-01f, 1.13284528e-01f, -3.25733095e-01f,
  -1.75244585e-02f, -4.49647196e-02f, 1.00103356e-02f, -1.19334169e-01f, -4.60222773e-02f, -1.73729941e-01f, -1.04718104e-01f, 2.78790444e-01f, -2.65681833e-01f, 1.36078596e-01f,
  -8.31338242e-02f, 1.11013791e-02f, -6.74285293e-02f, 2.09309816e-01f, 1.32014185e-01f, 1.73430875e-01f, 1.59126401e-01f, -2.37253644e-02f, 1.99873164e-01f, -1.16679743e-02f,
  -1.34599702e-02f, 3.27509530e-02f, 1.98155358e-01f, -6.95294589e-02f, -8.41415673e-02f, 6.33276552e-02f, 6.43137097e-02f, 2.42984697e-01f, -1.45956397e-01f, 6.94532990e-02f,
  2.49848232e-01f, -1.95981205e-01f, 2.03443393e-02f, -1.96461901e-01f, -2.87289768e-01f, 1.54042095e-01f, 1.63563579e-01f, 6.27929054e-04f, 7.07412958e-02f, 7.54314438e-02f,
  -4.41160053e-02f, 1.42109931e-01f, 1.98943540e-01f, -7.72627220e-02f, 1.18441097e-01f, 1.35332003e-01f, -3.11066266e-02f, 1.18705608e-01f, -5.12112267e-02f, -1.06053419e-01f,
  1.91962689e-01f, -8.11364502e-02f, 9.24325585e-02f, 1.62686080e-01f, 1.58369392e-02f, 5.25846183e-02f, 2.45449230e-01f, 5.60137667e-02f, 2.41090115e-02f, 1.79292053e-01f,
  1.30564091e-03f, 1.38937291e-02f, -1.33494288e-01f, 1.04897454e-01f, 1.09537564e-01f, -5.94730526e-02f, 8.04181844e-02f, -8.50887597e-02f, 2.15244830e-01f, -1.38264805e-01f,
  1.15700640e-01f, -7.86004215e-02f, 2.68864669e-02f, -1.91664979e-01f, 1.24364421e-02f, -7.07989037e-02f, -1.46831229e-01f, -5.71756214e-02f, -9.03256834e-02f, -2.09844515e-01f,
  -2.12489426e-01f, 2.30469331e-01f, -6.68480918e-02f, 1.03233181e-01f, 1.59084827e-01f, 6.22476563e-02f, -2.79515330e-02f, 2.22117141e-01f, 2.77068764e-01f, 1.21092305e-01f,
  2.29836658e-01f, -1.41194776e-01f, 2.65475959e-01f, 8.54898468e-02f, -1.91862717e-01f, 2.44414210e-01f, 1.46353766e-01f, 2.76469231e-01f, 4.66125645e-02f, -3.84196155e-02f,
  1.62654161e-01f, 1.31076220e-02f, -6.74947053e-02f, -1.05343118e-01f, -3.08696292e-02f, -1.26397640e-01f, 1.41922385e-02f, 2.53996998e-01f, 2.67017949e-02f, 1.56472042e-01f,
  1.16656624e-01f, 1.53459236e-01f, 1.20521143e-01f, -1.01861238e-01f, 2.11967528e-02f, -2.91257948e-02f, 1.59621522e-01f, 7.09603727e-02f, 1.10638596e-01f, 2.48780489e-01f,
  -1.12447813e-01f, 1.94277316e-01f, 5.15856482e-02f, 1.63108990e-01f, 1.86937645e-01f, 2.30549797e-01f, 2.11535525e-02f, 2.02041134e-01f, 3.95370424e-02f, -1.03031918e-01f,
  -8.57679173e-02f, -1.56605899e-01f, 2.18339488e-01f, 5.66360317e-02f, 1.74233183e-01f, -1.87943026e-01f, 1.38329784e-03f, 6.83145449e-02f, 1.38026312e-01f, 5.33451438e-02f,
  9.03245956e-02f, -1.91821963e-01f, -1.52240410e-01f, -7.88933635e-02f, -4.58928570e-02f, 7.84897208e-02f, -2.52705842e-01f, 9.90504473e-02f, 4.33922792e-03f, -1.36817992e-01f,
  5.62648848e-02f, -9.02629867e-02f, 2.19547898e-01f, -1.06032692e-01f, 3.38144265e-02f, -1.60299584e-01f, 1.64197177e-01f, 2.07132950e-01f, -2.10800439e-01f, 9.34920758e-02f,
  -8.59533697e-02f, 5.59861809e-02f, -5.05781025e-02f, 1.68063223e-01f, -5.95318377e-02f, 1.96961120e-01f, 1.10927068e-01f, -2.25564092e-01f, 7.79323280e-02f, 3.27822417e-02f,
  3.68073136e-02f, 1.43100530e-01f, 2.30897278e-01f, -3.33849899e-02f, 1.31216168e-01f, -4.61549237e-02f, 7.57154003e-02f, 1.97879598e-01f, 1.85774192e-01f, -1.06838554e-01f,
  1.60386473e-01f, 4.32256125e-02f, 2.77858209e-02f, 2.28383765e-02f, 1.45969659e-01f, 1.22052737e-01f, 8.50138441e-02f, 2.28616446e-01f, 4.87243161e-02f, -3.57444659e-02f,
  1.26945451e-01f, 3.94611247e-02f, -1.84151575e-01f, 1.91916153e-01f, -1.36381567e-01f, 2.21355289e-01f, 1.09138981e-01f, 1.20711535e-01f, -1.07247569e-01f, -2.37625077e-01f,
  3.13501880e-02f, -4.56464989e-03f, -2.15328172e-01f, 2.79333144e-02f, -1.26670584e-01f, 1.53986625e-02f, 5.83264977e-02f, -8.52799490e-02f, 6.56113261e-03f, -1.41495571e-01f,
  2.23507062e-01f, -5.83369285e-02f, -1.86756644e-02f, -1.76437125e-01f, -1.13357924e-01f, -1.95231125e-01f, 1.21714205e-01f, 4.34426516e-02f, -6.64055496e-02f, 2.92912479e-02f,
  -8.18832219e-02f, -1.83749288e-01f, 1.57707214e-01f, 1.52939260e-01f, 1.40949503e-01f, 2.59874493e-01f, 2.83583045e-01f, 4.35215719e-02f, 1.31306481e-02f, 7.26098418e-02f,
  2.63544291e-01f, -8.34753364e-03f, 2.22521275e-02f, -1.26543343e-01f, -2.28854120e-01f, 1.18287742e-01f, 1.44204393e-01f, 1.75295413e-01f, 1.63602635e-01f, 2.26284429e-01f,
  1.84021428e-01f, 1.22627601e-01f, 6.43491149e-02f, 4.78538536e-02f, 7.67446905e-02f, 9.46677551e-02f, -4.48612645e-02f, 9.95205566e-02f, 2.46345282e-01f, 6.14055209e-02f,
  -3.65414098e-02f, 1.43416850e-02f, 1.09414794e-01f, 3.85268731e-03f, -7.08621442e-02f, 1.10738672e-01f, 1.86184332e-01f, -1.65985115e-02f, -7.12504312e-02f, -3.04310191e-02f,
  6.06291629e-02f, 1.78537235e-01f, 7.32140318e-02f, -1.80799395e-01f, 1.08134769e-01f, -9.36436653e-03f, 7.98649937e-02f, -1.06616303e-01f, 9.32643265e-02f, -1.33030623e-01f,
  -2.26837531e-01f, -7.27274418e-02f, -2.73349971e-01f, 2.05606475e-01f, 1.74562056e-02f, 1.17592469e-01f, -7.47708306e-02f, 3.12033724e-02f, -1.13871768e-01f, 5.38622625e-02f,
  2.99565196e-01f, 1.28247187e-01f, 1.19899446e-02f, -3.22913587e-01f, 1.61911905e-01f, 5.77031188e-02f, -2.13324636e-01f, 2.28252664e-01f, 2.82412976e-01f, 1.12533271e-01f,
  3.30311030e-01f, -1.45055920e-01f, 5.44921681e-02f, 1.94052383e-01f, -2.11188048e-02f, -1.38122588e-01f, 2.89537981e-02f, -1.48529494e-02f, 3.57181057e-02f, 2.00403612e-02f,
  3.73568162e-02f, 1.20402060e-01f, 2.56222963e-01f, 1.55150771e-01f, 8.12953413e-02f, 1.12507313e-01f, 1.31498173e-01f, 1.73795804e-01f, 1.04527855e-02f, 1.70616820e-01f,
  1.10700838e-01f, 2.88180381e-01f, 1.74225256e-01f, 1.40177906e-01f, 1.59520566e-01f, 2.15735540e-01f, 1.80452749e-01f, 2.81660408e-01f, 2.04862207e-01f, 2.82969866e-02f,
  6.33653998e-02f, 4.63905595e-02f, 1.62998810e-02f, 1.05008215e-01f, 5.77086098e-02f, -3.44632417e-01f, -1.26056895e-01f, -2.24570720e-03f, 3.86916883e-02f, -7.56335631e-02f,
  2.05728635e-01f, 2.25689579e-02f, -7.08318725e-02f, 1.48050040e-01f, 1.34118482e-01f, 7.47186691e-02f, 2.11458459e-01f, -7.64087960e-02f, 3.25226247e-01f, -1.14056028e-01f,
  4.46734426e-04f, 7.29109570e-02f, 1.61597773e-01f, -5.33650741e-02f, -1.46918237e-01f, 1.44505650e-01f, 8.69634449e-02f, 6.81906119e-02f, 5.92625402e-02f, -8.33547190e-02f,
  2.78807163e-01f, 1.76375806e-01f, -1.58106267e-01f, 8.65059346e-02f, 2.77761389e-02f, 2.94104695e-01f, -9.79236588e-02f, 1.96870297e-01f, 4.81117219e-02f, 3.22587401e-01f,
  -8.50701705e-02f, -7.97495097e-02f, 6.10904545e-02f, 3.57915871e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.31515826e-03f, 1.53221324e-01f, 1.48579225e-01f, 2.67192900e-01f, 6.20347336e-02f, 7.62954429e-02f, 1.38467550e-01f, 1.12035021e-01f, 7.73372827e-03f, 1.87156871e-01f,
  9.00184661e-02f, 2.16623545e-01f, 2.20045745e-01f, 1.73739344e-01f, 3.81964147e-02f, 3.39384675e-02f, 1.90143391e-01f, -8.13080743e-03f, 1.87728956e-01f, 1.19292445e-01f,
  1.75831065e-01f, -7.63885397e-03f, 2.13552803e-01f, 1.26762465e-01f, 1.50676984e-02f, 1.01706207e-01f
};

// L2_fan_Wp (Shape: 19 x 64)
const int L2_fan_Wp_rows = 19;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -6.56820983e-02f, 7.32824653e-02f, -7.71364197e-02f, -3.24537568e-02f, 1.06917836e-01f, -6.97997063e-02f, -7.23359510e-02f, 6.90951571e-03f, -3.39919329e-02f, -7.23328367e-02f,
  7.23022521e-02f, 7.91638717e-02f, 1.22138143e-01f, -3.39709893e-02f, 2.70276014e-02f, 4.65325192e-02f, 6.79341257e-02f, -4.56017219e-02f, 1.12444885e-01f, 1.26298502e-01f,
  1.45245835e-01f, -1.08033605e-02f, -1.10735402e-01f, 2.74679773e-02f, 1.71650887e-01f, 7.35224634e-02f, 9.34108496e-02f, 1.07305035e-01f, -3.66010442e-02f, 7.09822252e-02f,
  -2.78592128e-02f, -1.67254377e-02f, 6.52502924e-02f, -3.02695222e-02f, 1.60984531e-01f, 3.50600481e-02f, -7.54821897e-02f, 9.27996263e-02f, 7.13098003e-03f, 9.15626809e-03f,
  -7.56223425e-02f, 6.64481744e-02f, 6.04130141e-02f, -6.41348585e-02f, 4.84248437e-02f, 2.21490502e-01f, 6.46274770e-03f, 4.27739695e-02f, -1.66727394e-01f, -1.81196302e-01f,
  -1.39549524e-01f, -6.00613058e-02f, 8.20188075e-02f, -1.55246565e-02f, 9.65553448e-02f, 1.58577889e-01f, -3.94478021e-03f, 4.52122577e-02f, -7.37149939e-02f, -9.97211188e-02f,
  1.53377224e-02f, 1.64278790e-01f, 9.00751203e-02f, 3.22456919e-02f, 1.43020183e-01f, -1.63671989e-02f, -5.80687746e-02f, -1.47289872e-01f, -9.94132906e-02f, -9.43809282e-04f,
  -1.83275640e-02f, -1.22308046e-01f, -5.66063374e-02f, 5.82432337e-02f, 1.20304525e-01f, 2.06991956e-01f, -2.38371193e-02f, 9.80473533e-02f, 9.18803662e-02f, 1.10635482e-01f,
  8.16603750e-02f, -7.37405196e-02f, 5.06043211e-02f, 1.41169250e-01f, 1.80341586e-01f, 4.84691411e-02f, -2.34117538e-01f, -3.63835208e-02f, 3.52216884e-02f, 1.93946138e-01f,
  9.97237787e-02f, 1.89717952e-02f, -3.11112702e-01f, -1.44809633e-02f, -3.84326056e-02f, 1.65929422e-01f, -6.99503049e-02f, -1.33775741e-01f, 1.78355002e-03f, -1.52652830e-01f,
  7.90442526e-02f, 1.81546807e-02f, -2.62180328e-01f, -4.45448309e-02f, 2.03580987e-02f, -8.50296468e-02f, 1.71585873e-01f, -8.12797099e-02f, 1.06884301e-01f, 3.54905725e-02f,
  9.84092504e-02f, -1.90552667e-01f, -2.47011513e-01f, 2.63722744e-02f, 7.05326796e-02f, 1.58528462e-01f, 2.01895520e-01f, 1.54082194e-01f, 1.90708145e-01f, 4.97344099e-02f,
  1.38291374e-01f, 1.35318995e-01f, -4.11328347e-03f, 3.74001861e-02f, 2.04545483e-02f, -1.34134404e-02f, 1.12204343e-01f, -1.48237720e-01f, 7.98224658e-02f, -5.05799130e-02f,
  -5.31821363e-02f, 1.14891633e-01f, 5.04162535e-03f, -1.84675939e-02f, -1.11165363e-02f, 1.60159782e-01f, 1.81256533e-01f, 1.28862023e-01f, 1.35961890e-01f, 8.33830759e-02f,
  1.11596286e-01f, 7.00975507e-02f, 2.21391581e-02f, 8.62807333e-02f, -2.91051362e-02f, 1.44000903e-01f, 5.21177538e-02f, -2.87902296e-01f, -3.72436340e-03f, -1.57397166e-01f,
  -1.87636465e-02f, 2.75888480e-02f, -1.63625658e-01f, -5.56061976e-02f, -8.61637890e-02f, -7.04008341e-02f, 2.26922543e-03f, -1.59889683e-01f, 2.01881990e-01f, -1.49624452e-01f,
  1.27554983e-01f, 2.23991033e-02f, -2.64345378e-01f, 4.66170982e-02f, -1.76222593e-01f, 5.46487309e-02f, 6.36127740e-02f, 1.48862973e-01f, -1.02922924e-01f, 1.29823564e-02f,
  -9.89870280e-02f, 2.30167970e-01f, 5.67367710e-02f, -1.10193558e-01f, -1.61220312e-01f, 3.28170583e-02f, 1.19254626e-01f, 1.83348045e-01f, 6.35583177e-02f, -1.36197656e-02f,
  -1.83703274e-01f, -2.64601111e-01f, -1.22435406e-01f, -7.68867955e-02f, -7.90920332e-02f, -9.15384293e-02f, -2.17418466e-02f, 1.13506705e-01f, -1.30433813e-02f, 1.29714431e-02f,
  4.22051027e-02f, 1.16416223e-01f, 1.68117583e-01f, 1.41262755e-01f, -2.19850466e-02f, 2.17868350e-02f, 1.75676420e-01f, -1.20088011e-02f, 1.83386326e-01f, 1.54089732e-02f,
  -1.32912457e-01f, 3.06836274e-02f, 1.16393127e-01f, 1.48347810e-01f, 1.32775486e-01f, 2.18505207e-02f, -1.70360059e-02f, 1.87715050e-02f, -5.39002717e-02f, 1.40110850e-01f,
  -4.23500799e-02f, 7.84560218e-02f, -3.76741955e-04f, -4.01904471e-02f, -2.01979220e-01f, 1.29788682e-01f, -1.27339676e-01f, 5.85388020e-02f, -1.39830828e-01f, -1.09336361e-01f,
  -2.67173916e-01f, -4.70959209e-03f, 1.70305654e-01f, 2.29549393e-01f, 2.18286384e-02f, -1.20950826e-01f, -8.59108195e-02f, 1.43582836e-01f, -1.85612023e-01f, 1.31991968e-01f,
  -4.50900802e-03f, 1.21262930e-01f, -8.54583830e-02f, -2.42839772e-02f, -6.25951439e-02f, 1.65484667e-01f, 1.60857454e-01f, 1.24817885e-01f, 1.27965882e-01f, -2.61574805e-01f,
  -1.00065015e-01f, 3.70279402e-02f, -1.57107651e-01f, -2.89442600e-03f, -4.04110365e-02f, -2.57549323e-02f, -1.01401135e-01f, 3.58332880e-02f, 2.90783904e-02f, -1.26547784e-01f,
  2.44386792e-02f, -3.92359123e-02f, -4.72500809e-02f, -1.84865758e-01f, -8.58168304e-02f, -3.89208086e-02f, 1.14037342e-01f, 1.14239089e-01f, -7.43620172e-02f, 1.40028059e-01f,
  -2.73539051e-02f, 4.14845832e-02f, 9.81694609e-02f, 3.67659517e-02f, 1.19023407e-02f, 1.57319382e-02f, -6.26985058e-02f, -1.54590949e-01f, -5.84352240e-02f, -2.99793156e-03f,
  4.25551124e-02f, -8.44859928e-02f, -8.96556526e-02f, -9.89014581e-02f, -7.40204602e-02f, -1.96734905e-01f, 6.81734309e-02f, -8.38936418e-02f, 5.35375718e-03f, -1.75733075e-01f,
  -7.67455325e-02f, -7.19789416e-02f, -1.28935382e-01f, -3.29211354e-02f, -6.85079722e-03f, 1.05821058e-01f, 2.24619538e-01f, 3.56090292e-02f, 4.31160666e-02f, 1.76086590e-01f,
  -6.69016540e-02f, -1.34729043e-01f, -1.99830443e-01f, -6.39689416e-02f, 1.15224630e-01f, 4.64216210e-02f, 1.02597252e-01f, 1.74083009e-01f, 2.30327528e-02f, 1.17895514e-01f,
  -5.42954579e-02f, -1.71391264e-01f, -1.27618447e-01f, -6.59832135e-02f, 2.88283348e-01f, 1.39325961e-01f, 4.65155095e-02f, -2.00236902e-01f, -3.91505025e-02f, -2.06447318e-01f,
  1.47819057e-01f, -4.15066294e-02f, -6.33823946e-02f, 7.61948526e-02f, -6.00967780e-02f, 1.54836267e-01f, -9.75083113e-02f, 4.02713940e-02f, 1.97565183e-01f, -1.19640976e-02f,
  5.14943451e-02f, -1.01996772e-01f, -8.67543519e-02f, 6.20660856e-02f, 1.78070739e-01f, 3.12858671e-02f, 5.11674918e-02f, -3.43127139e-02f, 9.52390656e-02f, -7.79109448e-02f,
  1.50732636e-01f, -8.80898163e-02f, 3.06100119e-02f, 1.93375982e-02f, -5.79858236e-02f, 1.85154695e-02f, -5.45680174e-04f, 7.84974452e-03f, -7.98745826e-02f, -9.11321549e-04f,
  -1.19343072e-01f, -8.15864205e-02f, 8.99309814e-02f, -1.60375148e-01f, -1.85612470e-01f, -6.28127456e-02f, 6.06165342e-02f, -1.60115078e-01f, 1.11108229e-01f, -1.31386057e-01f,
  7.25541729e-03f, 1.29563296e-02f, -6.74785152e-02f, 1.91826165e-01f, -6.58468157e-02f, 7.51927644e-02f, -1.33287087e-01f, 1.10022545e-01f, -1.20326169e-02f, -8.27287883e-03f,
  -7.41956979e-02f, 8.95194486e-02f, 9.59396511e-02f, 1.69817984e-01f, 9.16300789e-02f, -1.36471435e-01f, -1.62545025e-01f, -1.13069722e-02f, 2.36484006e-01f, 1.27476803e-03f,
  6.95064440e-02f, -8.67379680e-02f, -1.91531509e-01f, -1.39114097e-01f, -1.75729290e-01f, -1.15088262e-01f, 2.19209343e-02f, 3.27873155e-02f, -1.24455139e-01f, -4.65143286e-02f,
  1.80257380e-01f, -6.78367689e-02f, 7.28313178e-02f, 5.31281978e-02f, -8.18973035e-03f, -1.16995551e-01f, -2.64468044e-02f, -1.25668734e-01f, 1.71880007e-01f, -8.19816440e-02f,
  1.01541795e-01f, -7.01895878e-02f, -1.17576320e-03f, -7.00222775e-02f, -4.11881208e-02f, 3.94792715e-03f, 6.41007721e-02f, 1.54240638e-01f, -1.20287985e-01f, 7.77098611e-02f,
  6.35658950e-02f, -4.04498652e-02f, -7.42708743e-02f, 1.32716879e-01f, -1.87037271e-02f, -8.69103223e-02f, 9.26899537e-02f, 2.09504277e-01f, 3.36067453e-02f, 5.65748475e-02f,
  6.85141385e-02f, 1.90017838e-02f, -4.97058928e-02f, 6.36257008e-02f, -2.61562467e-01f, -8.76848251e-02f, -5.20953164e-02f, -7.28906691e-02f, 7.02885091e-02f, 4.40931357e-02f,
  -5.01039103e-02f, -4.06218134e-02f, 1.50587514e-01f, 1.38122246e-01f, -1.75267637e-01f, -7.24144951e-02f, -1.54099092e-01f, -2.32129153e-02f, -1.11002643e-02f, -2.38224328e-03f,
  3.33978273e-02f, 2.07828268e-01f, -1.04628056e-01f, 4.27090600e-02f, -5.03222793e-02f, 1.74984895e-02f, -1.04018673e-01f, -1.29683055e-02f, -1.58590406e-01f, -1.65163577e-02f,
  9.58426148e-02f, -1.86290994e-01f, 1.46513969e-01f, -2.50006139e-01f, -5.42215891e-02f, 1.22097731e-01f, -2.17669122e-02f, -7.82009140e-02f, -9.31890607e-02f, 3.87953185e-02f,
  1.41469926e-01f, 1.04462497e-01f, 4.33063991e-02f, -1.06769927e-01f, -1.38053685e-01f, 1.65152159e-02f, -7.49755204e-02f, -7.98851550e-02f, -1.12958267e-01f, -5.16903028e-02f,
  -4.55443189e-02f, 3.41800526e-02f, -1.18802786e-01f, 1.15054116e-01f, -3.94542143e-02f, 7.88316131e-02f, -5.78654520e-02f, -7.73224160e-02f, -1.29510596e-01f, -2.02172205e-01f,
  2.25178376e-01f, -9.30462149e-04f, 9.29018334e-02f, -1.09395780e-01f, 9.97171775e-02f, 3.09272646e-03f, 2.34378159e-01f, 1.44686103e-01f, -2.05133945e-01f, -1.80938467e-01f,
  -3.36161815e-03f, 7.52619952e-02f, -1.03215612e-01f, 1.08406082e-01f, 7.36462250e-02f, -4.77069467e-02f, 7.65686259e-02f, 2.70505412e-03f, 1.34659767e-01f, 3.82159688e-02f,
  -8.03022012e-02f, -1.51605099e-01f, -1.32861167e-01f, -2.91722640e-02f, 1.19625665e-01f, 1.75243378e-01f, 2.34346181e-01f, -5.73018081e-02f, 1.25042461e-02f, -2.06397427e-03f,
  -1.08345971e-01f, -7.33234212e-02f, -2.32805079e-03f, -8.53272751e-02f, 6.83639869e-02f, -5.21822944e-02f, -9.27456766e-02f, -7.16811791e-03f, 1.43551275e-01f, 9.72135551e-03f,
  -1.39664516e-01f, 5.67060150e-02f, 7.78868347e-02f, -1.20325334e-01f, -1.33019000e-01f, -9.55097228e-02f, 7.45646432e-02f, -2.23806109e-02f, -1.20440103e-01f, -1.55947179e-01f,
  -1.86732281e-02f, -7.95550123e-02f, 1.30674303e-01f, -4.74325828e-02f, 6.08034469e-02f, -5.74689405e-03f, 1.02532350e-01f, -7.51777664e-02f, 1.36668935e-01f, -1.38742194e-01f,
  8.44732448e-02f, 2.59491056e-01f, 8.89805239e-03f, 1.23257317e-01f, 5.36601283e-02f, 5.55005670e-02f, 4.56629507e-02f, 1.49593860e-01f, 5.85128181e-02f, -7.76653066e-02f,
  -1.17125854e-01f, -5.26262447e-02f, -2.18190715e-01f, 2.20169984e-02f, -5.78212691e-03f, 1.14852928e-01f, 2.01523572e-01f, 1.68236170e-03f, 1.73010781e-01f, 4.73349914e-02f,
  8.03674012e-02f, -1.14338910e-02f, 1.01641454e-01f, -3.93715911e-02f, 2.11121321e-01f, -1.88851599e-02f, -8.66508260e-02f, 1.28502563e-01f, 6.31217211e-02f, 3.08824964e-02f,
  -1.06094308e-01f, -6.18994050e-03f, -4.61148582e-02f, 1.89673528e-01f, -7.64149651e-02f, 1.85156614e-01f, 1.12424128e-01f, 8.10490474e-02f, 6.69621825e-02f, 1.39418870e-01f,
  -1.02914564e-01f, -4.34913933e-02f, -1.00837953e-01f, -1.08079752e-02f, 1.57549128e-01f, -1.01921245e-01f, 7.44952336e-02f, -1.75722435e-01f, -1.79628789e-01f, -9.45518836e-02f,
  -9.51632708e-02f, -3.54916602e-03f, 9.23270732e-02f, 7.99732096e-03f, 1.90327282e-03f, -5.25807366e-02f, 1.18391529e-01f, -1.64770231e-01f, 2.50037331e-02f, -1.42542958e-01f,
  -1.83671519e-01f, -7.31150061e-02f, -9.38524008e-02f, -5.76026328e-02f, 3.12827341e-02f, 2.60790318e-01f, -1.63483173e-01f, 1.71103686e-01f, -1.08139865e-01f, -9.99587849e-02f,
  2.02064171e-01f, -1.39155909e-02f, 2.07658440e-01f, -8.59113038e-02f, -1.97132602e-02f, 8.91063362e-02f, -7.05311820e-03f, 4.00237963e-02f, 6.55756891e-02f, -1.92185789e-01f,
  1.63363025e-01f, 1.48655400e-01f, 4.34212536e-02f, 5.22918068e-02f, 6.88074976e-02f, 1.25276536e-01f, -1.19825460e-01f, -7.87446052e-02f, 8.77104029e-02f, 2.44754590e-02f,
  1.18084937e-01f, 1.71091855e-01f, -3.98208871e-02f, 2.44929846e-02f, 7.19183385e-02f, -5.71820624e-02f, -1.97716039e-02f, 2.04750467e-02f, 3.86758447e-02f, 1.19059950e-01f,
  1.82050556e-01f, 2.43048310e-01f, -5.11120353e-03f, -8.45265538e-02f, 1.70395020e-02f, 1.10914253e-01f, -1.59313709e-01f, 9.71017480e-02f, 8.21740180e-02f, -6.37346283e-02f,
  -5.07391505e-02f, -5.36153167e-02f, -1.40785500e-01f, -9.43499506e-02f, 6.46229386e-02f, 3.38159339e-03f, 9.22404900e-02f, -9.62526649e-02f, -1.17212825e-01f, -1.39210047e-02f,
  -9.43154171e-02f, -1.46802038e-01f, 1.09850466e-01f, 5.42671829e-02f, -1.35540888e-02f, 1.14069566e-01f, -4.99679372e-02f, 5.60135469e-02f, 7.18738586e-02f, 6.49536476e-02f,
  -1.18988350e-01f, -2.47363076e-01f, 1.26553535e-01f, 7.23708868e-02f, 8.12289938e-02f, 4.59067859e-02f, 3.78032727e-03f, 6.66811094e-02f, 8.53781775e-02f, -6.56027347e-02f,
  -3.26260060e-01f, -9.09693167e-02f, 5.28849773e-02f, -1.82184041e-01f, 4.12513763e-02f, 8.72249007e-02f, -1.98016390e-02f, 4.35194233e-03f, 2.20997557e-01f, 1.21943496e-01f,
  -1.25428781e-01f, -1.84736736e-02f, 5.90300262e-02f, -1.21395223e-01f, -1.10593833e-01f, -1.68240651e-01f, -6.26527518e-03f, 2.29030801e-03f, 7.45732943e-03f, -1.13473885e-01f,
  -1.97178721e-01f, -7.48845860e-02f, -8.62540901e-02f, 3.53929587e-02f, -2.82131702e-01f, -1.36011153e-01f, -1.52250737e-01f, -4.59659612e-03f, -8.88225958e-02f, -1.02282517e-01f,
  4.54724804e-02f, 1.53986007e-01f, 1.93773266e-02f, 1.36789948e-01f, -1.04299545e-01f, -1.33368805e-01f, 3.94334495e-02f, 3.37613449e-02f, 1.57535762e-01f, 3.39173451e-02f,
  -1.22812167e-01f, -8.11548606e-02f, 4.36006449e-02f, -4.83958796e-02f, 1.22508034e-01f, 3.87828276e-02f, 3.29582058e-02f, -1.24550991e-01f, 9.53433216e-02f, -4.99055684e-02f,
  1.03498669e-02f, 6.69116080e-02f, -4.11538035e-02f, -1.97294354e-01f, -1.09469436e-01f, -5.79954796e-02f, 1.68192551e-01f, -3.42378952e-02f, -1.56205088e-01f, 6.76263589e-03f,
  -5.83435483e-02f, 3.75926904e-02f, -9.09206197e-02f, 4.89275306e-02f, -7.83927180e-03f, -2.75145601e-02f, -1.06037855e-01f, 1.79625496e-01f, 6.88019767e-02f, 2.90871710e-02f,
  -8.76839310e-02f, 7.40462691e-02f, 6.30126372e-02f, -5.83341494e-02f, -2.98161749e-02f, 8.13195854e-02f, -1.03419438e-01f, 7.31434748e-02f, -2.45759115e-02f, -9.87251103e-02f,
  -6.81155175e-02f, -8.44903141e-02f, 1.13921508e-01f, -1.43887606e-02f, 1.56992242e-01f, 3.69371958e-02f, 5.89396944e-03f, -3.09481714e-02f, -4.43750061e-02f, -1.60736844e-01f,
  -1.88702226e-01f, 1.41124994e-01f, -1.15766861e-01f, -4.01106253e-02f, 1.03940599e-01f, 3.50730978e-02f, 2.68366393e-02f, 6.83677942e-02f, 3.92544493e-02f, -1.43049955e-01f,
  -1.35482743e-01f, -1.43837392e-01f, -2.21488744e-01f, -5.25629409e-02f, 1.27578545e-02f, 1.00713529e-01f, -1.17667496e-01f, -1.00574978e-01f, -1.81899324e-01f, -9.83981714e-02f,
  -1.15949307e-02f, -2.78692935e-02f, -1.57475829e-01f, -6.36028349e-02f, -1.48578838e-01f, -1.54889777e-01f, -3.25171463e-02f, 1.32137135e-01f, -7.97185525e-02f, -1.55653566e-01f,
  1.30177632e-01f, -8.08121860e-02f, -2.67950837e-02f, -2.98754066e-01f, 2.24308684e-01f, 3.37294228e-02f, 2.15291560e-01f, -8.56758356e-02f, -1.32431816e-02f, -1.13344833e-01f,
  -8.89681578e-02f, 7.11151659e-02f, -2.99095102e-02f, -2.43766289e-02f, 5.13397977e-02f, -5.87681308e-02f, 1.89181343e-01f, -2.65726820e-02f, 1.00421399e-01f, -8.64607617e-02f,
  3.61168347e-02f, 1.16472598e-02f, -8.16216022e-02f, -8.71069133e-02f, 6.50651287e-03f, 1.75036028e-01f, 2.71836668e-01f, -1.26405299e-01f, -1.55600801e-01f, 8.41396675e-02f,
  -2.01746193e-03f, 2.20855460e-01f, 1.56708419e-01f, 8.90273899e-02f, 7.59189203e-02f, 6.79103732e-02f, -7.66775534e-02f, 1.77095309e-02f, -4.79413532e-02f, 8.11557025e-02f,
  -4.69064154e-02f, 7.49112889e-02f, 1.41604602e-01f, -1.66048408e-02f, 1.39668271e-01f, 1.61300078e-01f, 4.38582711e-02f, -7.00181676e-03f, 3.80402468e-02f, 1.51531234e-01f,
  1.55540645e-01f, 6.62781820e-02f, 1.72917947e-01f, 9.25262421e-02f, -8.24535787e-02f, 8.38970840e-02f, 8.25318396e-02f, -3.48994583e-02f, -1.39326498e-01f, 1.03735067e-01f,
  -5.51185571e-02f, 1.32968491e-02f, -1.56977504e-01f, 5.83468787e-02f, -6.15435839e-02f, -1.40649334e-01f, 1.09274775e-01f, -1.45252675e-01f, -1.90268755e-02f, -9.00862589e-02f,
  -3.86252515e-02f, 1.70229003e-01f, -8.44845176e-02f, 1.35835528e-01f, 1.86908305e-01f, -2.13998288e-01f, 1.96031809e-01f, 2.89055258e-01f, -4.64795269e-02f, 2.08450377e-01f,
  1.67824224e-01f, 2.21732587e-01f, -1.33908346e-01f, -1.80699937e-02f, 1.81575269e-01f, -9.31586251e-02f, 1.53238982e-01f, 6.97319061e-02f, 8.00521448e-02f, -1.73557013e-01f,
  -7.51451310e-03f, 8.73754472e-02f, -8.12599286e-02f, -1.57416403e-01f, -6.09246790e-02f, -7.42408708e-02f, -1.91559363e-02f, 3.98379639e-02f, -1.18204549e-01f, 8.37643966e-02f,
  -1.38067812e-01f, 1.88414484e-01f, 6.52055815e-02f, 2.99892634e-01f, 1.19474858e-01f, 6.02134094e-02f, -1.88617278e-02f, -1.11791417e-01f, 1.99383982e-02f, -8.39344189e-02f,
  -2.54054777e-02f, 1.15291707e-01f, -1.13813475e-01f, 1.31401867e-01f, -1.31588832e-01f, -1.03460163e-01f, 5.87733537e-02f, -1.90644134e-02f, -6.70987517e-02f, -1.26716003e-01f,
  3.60121652e-02f, -3.66998725e-02f, 4.72146943e-02f, -5.55815585e-02f, 2.48471312e-02f, 7.92468805e-03f, -1.39112189e-01f, -1.21416755e-01f, 1.58460781e-01f, -1.01935670e-01f,
  -1.20246843e-01f, -2.55240887e-01f, 2.29738772e-01f, 1.00014649e-01f, 2.56348789e-01f, -5.08562662e-02f, -1.97020173e-01f, -1.21815160e-01f, -5.63391782e-02f, 1.73257093e-03f,
  1.48280397e-01f, 1.18924655e-01f, 3.32742706e-02f, -1.59924060e-01f, 2.12614596e-01f, -4.62139770e-03f, 4.46859002e-02f, 9.56497341e-02f, -1.37901932e-01f, -1.64997309e-01f,
  -8.73216614e-02f, 3.55059355e-02f, 2.55154055e-02f, 1.68629363e-01f, 3.05777788e-01f, -2.08835632e-01f, 3.21438583e-03f, 8.38739127e-02f, 4.66637639e-03f, 1.19891211e-01f,
  6.38522059e-02f, -1.45909294e-01f, 4.16208804e-02f, -8.34263936e-02f, -8.38503689e-02f, -6.27928525e-02f, -5.67598548e-03f, -4.23360020e-02f, 2.39465367e-02f, 7.69945234e-02f,
  1.81636944e-01f, -4.93633263e-02f, 2.92880684e-02f, -3.41370255e-02f, 5.77059686e-02f, 1.03305340e-01f, 2.76283100e-02f, -2.84322668e-02f, -3.19422372e-02f, 1.16808079e-01f,
  2.12560948e-02f, -5.18528111e-02f, -2.54149176e-02f, 8.89509395e-02f, -1.03880219e-01f, -7.56937414e-02f, -1.58678323e-01f, -7.05535263e-02f, -5.63498065e-02f, 4.47051004e-02f,
  -2.25890294e-01f, -7.31905997e-02f, -1.04424566e-01f, -1.23403788e-01f, -6.34165257e-02f, 8.22355673e-02f, 5.96016608e-02f, -3.38844508e-02f, -1.88214518e-02f, 5.80521822e-02f,
  -1.52090997e-01f, 2.01442271e-01f, 9.11112130e-02f, -2.24786893e-01f, 1.21020377e-01f, 2.20415130e-01f, -1.99503928e-01f, 5.28879575e-02f, 1.83357596e-01f, 2.36664087e-01f,
  -1.69204950e-01f, -1.24564581e-01f, 9.36079249e-02f, -2.16842890e-02f, 7.36271515e-02f, 1.54110879e-01f, -2.73795091e-02f, 2.48395987e-02f, 5.44589646e-02f, -2.01744169e-01f,
  -1.48230210e-01f, -2.56015873e-03f, -9.27632451e-02f, 4.14225832e-03f, 3.88970897e-02f, -2.65529640e-02f, 1.51761547e-02f, 8.30993131e-02f, -1.32517532e-01f, 3.93431857e-02f,
  -1.10792764e-01f, 2.61192054e-01f, 1.66470453e-01f, 4.06505801e-02f, -9.14343446e-02f, -1.50980884e-02f, -3.62939201e-02f, -1.11622050e-01f, -6.74259886e-02f, -1.14085525e-02f,
  7.06014782e-02f, 5.19244522e-02f, 9.18125659e-02f, -2.56105624e-02f, 8.08465015e-03f, -1.56429574e-01f, -1.09230436e-01f, -1.01452082e-01f, -5.10145649e-02f, -4.56371531e-02f,
  -8.96892473e-02f, 3.01679857e-02f, 7.15219900e-02f, 6.66988865e-02f, -1.19179875e-01f, -2.15189412e-01f, 2.21896857e-01f, 1.06560074e-01f, -7.04929680e-02f, -2.33737528e-01f,
  2.71733627e-02f, -8.51837248e-02f, 3.28375638e-01f, -2.54363231e-02f, -2.26889048e-02f, -2.20891401e-01f, -7.44515210e-02f, -1.00499295e-01f, 9.25341994e-02f, -2.64167730e-02f,
  -5.72741218e-02f, -1.15961954e-01f, 1.91730574e-01f, 7.15600029e-02f, -6.57771528e-02f, 9.84128192e-03f, -6.44351244e-02f, 4.20944840e-02f, 9.42919031e-02f, -7.09646642e-02f,
  -2.36901231e-02f, 2.20325485e-01f, 2.24776134e-01f, 8.33888501e-02f, -5.15329652e-02f, -1.20557472e-01f, -7.34060705e-02f, -7.61370808e-02f, 1.46551551e-02f, -1.09267319e-02f,
  -8.71351659e-02f, -1.00240462e-01f, 9.59879234e-02f, -6.94284439e-02f, -8.05372298e-02f, 1.08758613e-01f, -1.37296036e-01f, -4.34547588e-02f, 1.05692642e-02f, 1.79310083e-01f,
  1.06380194e-01f, 5.02344929e-02f, 1.27047375e-01f, 1.03241466e-02f, 8.07139203e-02f, 8.22147503e-02f, 6.15746975e-02f, -4.88904342e-02f, 1.44822299e-01f, 1.07456511e-02f,
  8.55423436e-02f, 9.77930650e-02f, -5.71238287e-02f, -9.80767161e-02f, 7.16770580e-03f, 1.24521196e-01f, -1.19454622e-01f, -3.29608858e-01f, 3.43120890e-03f, 1.21729195e-01f,
  -1.54869765e-01f, 7.53386840e-02f, -2.01906729e-02f, 1.13557559e-02f, -1.60413429e-01f, -1.00758690e-02f, -1.63283661e-01f, -1.99487936e-02f, 1.14391282e-01f, -8.34612101e-02f,
  -1.19758703e-01f, 6.02022335e-02f, -2.26393938e-01f, -1.41398534e-01f, -5.12601249e-02f, -1.37071609e-02f, -1.56270564e-01f, 5.85075356e-02f, 9.11158994e-02f, 6.02678508e-02f,
  -1.51505202e-01f, 2.18405407e-02f, -7.97754619e-03f, -3.28595168e-03f, -7.76633397e-02f, -5.16974851e-02f, 9.31985378e-02f, 1.98698357e-01f, 2.03392372e-01f, 2.88531370e-02f,
  -6.14845417e-02f, -1.64661124e-01f, -1.33192152e-01f, -1.95460767e-02f, 5.07890657e-02f, -8.74395370e-02f, -1.27534524e-01f, 1.52561009e-01f, 1.42099395e-01f, -2.49822080e-01f,
  -9.11217406e-02f, 2.04444993e-02f, -7.15550482e-02f, -3.85615006e-02f, -1.21597908e-01f, -5.30986153e-02f, -5.73490448e-02f, -1.78617553e-03f, -4.48626317e-02f, 9.55630243e-02f,
  9.65811759e-02f, -2.82724798e-02f, 1.31895393e-01f, 1.22625623e-02f, -9.49932560e-02f, 2.79261917e-02f, -1.18637577e-01f, -3.86794209e-02f, 1.08959693e-02f, 4.53766398e-02f,
  -4.75625955e-02f, -1.62704345e-02f, 1.56569153e-01f, 2.21126914e-01f, -1.87367335e-01f, 5.68504725e-03f, -1.27777644e-02f, 1.49421081e-01f, 8.85568839e-03f, -1.40498444e-01f,
  -2.26889104e-01f, 7.46719316e-02f, 2.19007924e-01f, 2.15191066e-01f, 1.42500475e-01f, -3.72008197e-02f, 1.39457285e-01f, 1.15423404e-01f, 4.09481041e-02f, 1.96501568e-01f,
  -1.59116060e-01f, 5.02827279e-02f, 3.77102308e-02f, -8.92536044e-02f, -3.35039645e-02f, -2.13463716e-02f, 1.03523888e-01f, -6.94484543e-03f, -1.80720374e-01f, -1.18249513e-01f,
  -8.66267532e-02f, -1.02077626e-01f, -1.31289195e-02f, 2.43975315e-02f, -1.92943886e-02f, -1.19739264e-01f, 1.87294304e-01f, 3.05805355e-01f, -1.04009584e-01f, 1.28779253e-02f,
  1.05015710e-02f, 1.22809872e-01f, -6.69549033e-02f, -9.17422026e-02f, 1.35468794e-02f, -8.88299420e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 64)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  4.07818779e-02f, 7.02176318e-02f, -1.25967022e-02f, -1.23711936e-02f, 1.93242520e-01f, 7.08203670e-03f, 5.25212735e-02f, 5.47540523e-02f, -3.61243002e-02f, 9.03104246e-02f,
  -1.80767134e-01f, 1.82492808e-02f, 1.00972153e-01f, -8.17764667e-04f, 1.25892743e-01f, 1.76498573e-02f, 1.93093091e-01f, 8.34285282e-03f, 2.01771319e-01f, -3.08155030e-01f,
  1.57706156e-01f, -2.93521076e-01f, 2.42328271e-02f, 3.42837833e-02f, 2.86981538e-02f, 3.70105319e-02f, 6.98213577e-02f, 1.62591919e-01f, 1.20963166e-02f, -2.77712137e-01f,
  1.52023450e-01f, -4.48256135e-02f, -2.29127616e-01f, 1.16971709e-01f, -3.02645415e-01f, -3.66679907e-01f, 5.08731008e-02f, -2.02989921e-01f, 8.21348876e-02f, -3.16929787e-01f,
  2.59714246e-01f, 4.47936617e-02f, -1.82120070e-01f, 1.29893512e-01f, -2.99705774e-01f, 3.27073783e-02f, 1.86230820e-02f, 1.57641977e-01f, -3.41440812e-02f, -6.14748988e-03f,
  -1.44793065e-02f, 1.51297480e-01f, 1.47260606e-01f, 4.72325869e-02f, 1.45288287e-02f, -2.10063532e-02f, 2.76977152e-01f, -1.07415996e-01f, 2.54991531e-01f, -6.89323097e-02f,
  7.35458583e-02f, -4.25678551e-01f, -2.28838846e-01f, 1.56618759e-01f, 1.09032348e-01f, 1.25240698e-01f, 2.13070121e-02f, 1.25332430e-01f, 4.39945422e-02f, -5.62148653e-02f,
  7.86777735e-02f, 2.19203651e-01f, 1.96367666e-01f, -3.23385210e-03f, 1.21984854e-01f, 7.07082227e-02f, 1.08450107e-01f, 3.10803931e-02f, -8.72124359e-02f, 1.54877171e-01f,
  -6.11438379e-02f, 1.43118665e-01f, 1.52495280e-01f, 3.31520706e-01f, -3.32372665e-01f, -1.43905684e-01f, -7.65531287e-02f, -1.04806451e-02f, 8.80375504e-02f, -8.07255730e-02f,
  -1.14954803e-02f, 1.07324170e-02f, 8.16475451e-02f, 6.80417009e-03f, -2.74684072e-01f, 1.11572430e-01f, 7.36939237e-02f, -1.23067349e-01f, 2.60096997e-01f, 3.66449445e-01f,
  -1.32900521e-01f, -8.41700938e-03f, 1.12379454e-01f, 3.67555618e-01f, -1.90746218e-01f, 7.06401467e-02f, 2.05956191e-01f, 1.97276935e-01f, 1.11604162e-01f, 3.26370001e-01f,
  1.79267585e-01f, 2.68486768e-01f, -1.00172818e-01f, -1.38725415e-01f, -1.71589777e-02f, 1.23680197e-01f, -1.16025098e-01f, 1.67448167e-02f, -1.47502115e-02f, 7.30869025e-02f,
  -5.55039831e-02f, -1.65851131e-01f, 7.30465678e-03f, 3.74270137e-03f, -1.15896292e-01f, 3.79220843e-01f, 3.64511982e-02f, 1.23542123e-01f, 3.52413766e-02f, 2.28103310e-01f,
  2.55931079e-01f, 1.95818335e-01f, -7.97612872e-03f, 1.18939199e-01f, 1.87844001e-02f, 2.02837318e-01f, 1.46743193e-01f, 7.13956505e-02f, -3.12844501e-03f, 4.75917682e-02f,
  6.98225647e-02f, 4.66694497e-03f, 1.37923181e-01f, 7.13732690e-02f, 8.49507283e-03f, -2.18267608e-02f, 4.65761237e-02f, -1.71887904e-01f, -1.52274027e-01f, -3.01623434e-01f,
  1.81061000e-01f, 9.62636396e-02f, -1.07707851e-01f, -2.65970230e-01f, 5.19398563e-02f, 1.33934423e-01f, 1.55436575e-01f, -2.01574355e-01f, 6.02215854e-03f, -2.42287695e-01f,
  -1.74981505e-01f, -9.92543548e-02f, -2.51620412e-01f, -6.51882738e-02f, -1.36870220e-01f, -1.54655635e-01f, 9.07226130e-02f, 6.57924786e-02f, 2.14572936e-01f, 3.14025074e-01f,
  -9.28959697e-02f, 5.50386310e-02f, -6.37747021e-03f, -1.71185672e-01f, 1.18810602e-01f, 2.90008217e-01f, 1.32038981e-01f, -1.80844043e-03f, 1.78960606e-01f, -1.16248496e-01f,
  6.48564547e-02f, -1.29752934e-01f, -3.14688921e-01f, -3.44680071e-01f, 2.45134085e-02f, -1.11910000e-01f, 5.18710241e-02f, -7.29872063e-02f, 2.10290134e-01f, 5.13292737e-02f,
  -7.51103237e-02f, 2.21411765e-01f, 1.86533794e-01f, 4.15059030e-02f, 1.02736242e-01f, 7.36464411e-02f, 5.18781208e-02f, 2.54044272e-02f, -1.55104585e-02f, 2.25779355e-01f,
  3.39658372e-02f, -2.61160173e-02f, 2.39397869e-01f, 1.03339285e-01f, 2.10963234e-01f, 6.05945326e-02f, -4.05330956e-02f, 1.53640732e-01f, 2.60436852e-02f, 1.20862156e-01f,
  2.08294496e-01f, -2.29831904e-01f, -1.47367567e-01f, -1.06529400e-01f, 1.66711256e-01f, -2.32932046e-01f, -2.55302221e-01f, -2.60644436e-01f, -9.78771076e-02f, -1.11530118e-01f,
  1.89653188e-01f, 7.51838014e-02f, 2.90309697e-01f, -2.37901986e-01f, -2.32536085e-02f, 1.82850510e-01f, -5.93094900e-02f, 1.73971370e-01f, -2.33512849e-01f, -5.70832640e-02f,
  1.50638536e-01f, 6.17468357e-02f, 2.97099024e-01f, 3.06953520e-01f, -6.73917085e-02f, 9.98720154e-03f, 2.15086907e-01f, -1.46737516e-01f, 3.26693919e-03f, -1.06882788e-01f,
  2.33667538e-01f, 3.45221639e-01f, 3.56552958e-01f, -1.20506426e-02f, -1.27273306e-01f, 2.75538489e-02f, -5.10478625e-03f, -7.43365437e-02f, -3.23332520e-03f, 1.87306449e-01f,
  -1.26474679e-01f, 2.29396924e-01f, 3.27228874e-01f, 3.08833588e-02f, 1.08103037e-01f, 2.63951868e-01f, 9.65789557e-02f, 6.28999919e-02f, -5.58494292e-02f, 1.09881833e-01f,
  7.69237056e-02f, 5.88950999e-02f, 1.09910689e-01f, 1.20127946e-01f, 9.66577157e-02f, 1.54310137e-01f, 1.40629739e-01f, 1.62638426e-01f, -3.94284129e-02f, 1.11625241e-02f,
  -6.88181743e-02f, 7.07304999e-02f, 3.38773951e-02f, 1.23596303e-01f, 2.17007101e-01f, 2.64120638e-01f, -2.13702887e-01f, -3.80704850e-01f, 1.18239179e-01f, 2.65496045e-01f,
  9.95599926e-02f, -1.68572832e-02f, 8.07747170e-02f, 2.78768148e-02f, 1.39001459e-01f, 2.68536061e-02f, -3.59039366e-01f, -1.56236649e-01f, 1.72000393e-01f, -1.72349364e-01f,
  2.34685004e-01f, 1.93876084e-02f, 2.08097678e-02f, 9.86357778e-02f, 3.46011162e-01f, 6.01497814e-02f, -1.57264784e-01f, 2.20661059e-01f, 4.85923514e-02f, -8.08436722e-02f,
  5.27529642e-02f, 2.36995712e-01f, 3.03527325e-01f, 2.06640929e-01f, -3.83294001e-02f, -9.38568637e-02f, -3.93406674e-02f, 8.41423199e-02f, -6.39385208e-02f, -7.22783729e-02f,
  -3.15936804e-01f, -1.15703419e-01f, 1.57282174e-01f, -2.81334937e-01f, 1.34799004e-01f, -2.16644570e-01f, -4.29373905e-02f, 2.20615968e-01f, -1.23166777e-01f, 2.00376749e-01f,
  7.90551770e-03f, 7.50424415e-02f, 1.56261951e-01f, 1.04798317e-01f, 1.05465725e-01f, 1.68223143e-01f, -6.94978386e-02f, 8.47721770e-02f, -1.08007930e-01f, 6.42702216e-03f,
  -7.96713680e-02f, 1.73528016e-01f, 1.36561245e-01f, -2.95146983e-02f, 1.40914217e-01f, 1.30552165e-02f, 9.40094665e-02f, 3.32608707e-02f, -7.47603690e-03f, 6.04621209e-02f,
  2.97427565e-01f, -1.95617586e-01f, 2.83997860e-02f, 5.22395149e-02f, -1.24204509e-01f, -2.23867431e-01f, 2.37044960e-01f, 1.27639130e-01f, 5.01873577e-03f, -3.58990729e-02f,
  2.62210462e-02f, -1.87281772e-01f, -1.10958003e-01f, 1.17444461e-02f, -2.15996310e-01f, -2.01191559e-01f, 2.11010575e-01f, -2.36572951e-01f, -4.59005870e-02f, -3.45513254e-01f,
  4.71154898e-02f, 9.56883579e-02f, -1.31766543e-01f, -7.27229342e-02f, -2.80585498e-01f, -2.04469308e-01f, 1.92938298e-01f, 1.31953597e-01f, -3.15033435e-03f, 1.29863778e-02f,
  1.79605618e-01f, 2.11341247e-01f, 2.19799966e-01f, 2.76962310e-01f, 1.92226544e-02f, -1.19049579e-01f, 1.83229193e-01f, -9.92436036e-02f, 1.36884600e-01f, -1.73079014e-01f,
  1.67988256e-01f, -3.60667348e-01f, 8.33057240e-02f, 5.90051599e-02f, 1.36415541e-01f, -7.79284015e-02f, 5.63938767e-02f, 2.62433384e-03f, -8.15527420e-03f, 1.84717700e-01f,
  5.61567470e-02f, -1.07360989e-01f, 1.33155286e-01f, 2.43717115e-02f, 2.38889471e-01f, -3.38097028e-02f, 1.18820652e-01f, 2.38107413e-01f, 1.42845720e-01f, 1.57640606e-01f,
  1.92786783e-01f, 1.09159499e-01f, 2.20121861e-01f, 1.43517777e-01f, -6.51359931e-02f, -1.55290514e-01f, 1.51020497e-01f, -1.59627110e-01f, -1.67898953e-01f, -1.66840196e-01f,
  -9.48323756e-02f, 1.40421167e-01f, 2.09032804e-01f, 1.78169440e-02f, -1.60109296e-01f, -2.40928471e-01f, 9.23750699e-02f, 2.18194146e-02f, 8.57791156e-02f, -1.02361478e-01f,
  1.80760205e-01f, 7.56345317e-02f, 3.01145434e-01f, -7.83079118e-02f, 2.65984446e-01f, 1.57868505e-01f, 2.05177262e-01f, -1.95323169e-01f, -5.12211882e-02f, -1.36765555e-01f,
  4.25830074e-02f, 2.51255095e-01f, 2.00560510e-01f, 2.08007619e-01f, 8.85859728e-02f, 2.34881818e-01f, 3.72149535e-02f, 1.44940376e-01f, 2.82562137e-01f, -4.22066972e-02f,
  6.40809312e-02f, 2.02494159e-01f, -2.10676074e-01f, 1.96464404e-01f, 3.42301846e-01f, 7.18664080e-02f, 4.01307732e-01f, 2.71954965e-02f, 3.60232294e-02f, -6.01536185e-02f,
  -6.05039299e-02f, -5.05220704e-02f, -1.74004897e-01f, 6.53981045e-02f, 8.94142091e-02f, 1.73117295e-01f, 7.77188390e-02f, 2.29128655e-02f, 1.22517303e-01f, -1.49007857e-01f,
  -4.69064713e-02f, 4.88442108e-02f, 7.56800547e-02f, -1.30151346e-01f, 3.60318460e-02f, -1.66468740e-01f, -9.65823606e-03f, 2.19299451e-01f, -5.21882251e-02f, 1.25928015e-01f,
  2.09695145e-01f, -1.46395415e-01f, 5.78611270e-02f, -3.34856242e-01f, 2.53172249e-01f, -2.01585427e-01f, 2.57768959e-01f, -3.65740769e-02f, -8.71144142e-03f, 1.97747096e-01f,
  -4.45083193e-02f, 3.09175998e-02f, 2.98808485e-01f, 3.29035282e-01f, -2.14272678e-01f, 9.99870002e-02f, 2.40760863e-01f, 2.36664191e-01f, 1.15229025e-01f, 4.72203232e-02f,
  -6.00840598e-02f, 1.07806295e-01f, 1.14309296e-01f, 2.85386920e-01f, -1.56778723e-01f, 2.02141479e-01f, 1.90364361e-01f, -2.44194940e-01f, 1.04630128e-01f, -4.00431192e-04f,
  2.84609813e-02f, 1.48410127e-01f, 1.95319399e-01f, 1.19108640e-01f, 4.95937988e-02f, 1.04505301e-01f, -5.29630370e-02f, 1.98178008e-01f, -1.33009553e-01f, 2.08820656e-01f,
  1.43436402e-01f, 1.73984453e-01f, -1.44407796e-02f, 3.80195305e-02f, -8.04902054e-03f, 3.70146870e-03f, -5.87490806e-03f, 1.81585237e-01f, -4.56989482e-02f, -1.49227679e-01f,
  -1.30532980e-01f, 6.04722835e-03f, 1.57049567e-01f, 1.30309582e-01f, -1.36294216e-01f, -6.41068742e-02f, -2.46922038e-02f, 5.98772988e-03f, -2.21873466e-02f, -5.79191372e-02f,
  5.62220775e-02f, 1.95940122e-01f, 6.75339177e-02f, -1.33556068e-01f, 2.41265774e-01f, -1.12031039e-03f, -2.11217627e-01f, -1.62208408e-01f, 2.33761460e-01f, 1.57213673e-01f,
  2.68901080e-01f, 9.23967957e-02f, -2.70091414e-01f, -2.03438267e-01f, -2.56388336e-01f, -3.33393551e-02f, -1.48349805e-02f, -1.14716254e-01f, 2.95147777e-01f, -2.13597313e-01f,
  -4.09254469e-02f, 4.71946336e-02f, 2.10792795e-01f, -1.30584359e-01f, 1.88207969e-01f, -1.14771321e-01f, -8.87447223e-03f, -3.75496969e-02f, 2.10783165e-02f, 2.00241089e-01f,
  8.93228874e-02f, -6.07200824e-02f, 2.37783734e-02f, 1.59541875e-01f, 2.47617647e-01f, 3.43864709e-01f, 1.75954103e-01f, 7.04349112e-03f, -1.09491507e-02f, 1.59741923e-01f,
  -1.44110963e-01f, -8.75767767e-02f, 1.97453395e-01f, -6.62966445e-02f, 1.81377828e-01f, -9.75070447e-02f, 1.22418076e-01f, 1.86239071e-02f, 1.47042645e-03f, 1.34123802e-01f,
  2.08873391e-01f, 1.89325307e-02f, 2.03539833e-01f, 1.73521921e-01f, 2.00577289e-01f, 5.81908189e-02f, 4.82158773e-02f, 9.60546434e-02f, 2.86547933e-02f, 2.00262621e-01f,
  2.83224061e-02f, 5.24417572e-02f, 1.51856601e-01f, 1.95363313e-01f, 2.95900423e-02f, -1.35067195e-01f, 1.19944908e-01f, -1.10644482e-01f, -2.07293674e-01f, 2.03592956e-01f,
  9.70550403e-02f, 1.19352117e-01f, -1.60979956e-01f, -4.17626761e-02f, -1.95297107e-01f, -1.67515859e-01f, 1.71422854e-01f, 7.77216628e-02f, -9.92118344e-02f, 2.15557069e-02f,
  -1.96374997e-01f, -2.24846780e-01f, 1.30100593e-01f, -1.28356004e-02f, -7.84484521e-02f, -5.04915155e-02f, 2.58001834e-01f, 2.85626352e-01f, 1.06494591e-01f, 9.25098956e-02f,
  -4.17649560e-02f, 8.60976577e-02f, 2.58575857e-01f, 2.23787412e-01f, -7.92032555e-02f, 2.71940023e-01f, 1.55417398e-01f, 3.12398881e-01f, 2.18067065e-01f, 9.66653377e-02f,
  1.37227058e-01f, 1.58350304e-01f, 1.89640507e-01f, 9.78922248e-02f, 2.98651576e-01f, 1.12396114e-01f, 8.54364634e-02f, -1.42642185e-01f, 6.10964708e-02f, 2.08786130e-01f,
  8.08586404e-02f, 2.11634412e-02f, 2.01205522e-01f, 1.42897844e-01f, 1.15774386e-01f, 2.34680753e-02f, 1.05188705e-01f, -1.52832950e-02f, 8.30937847e-02f, 1.85396567e-01f,
  -1.28118500e-01f, 1.51973844e-01f, 2.06060618e-01f, 2.04701409e-01f, 1.49390772e-01f, 2.16589510e-01f, 2.06785187e-01f, 1.64435506e-01f, 1.56614289e-01f, -4.22884934e-02f,
  1.60849571e-01f, -1.37349308e-01f, -1.74605072e-01f, 2.56008089e-01f, 5.57299815e-02f, 1.58543319e-01f, -9.94952163e-04f, 1.80463254e-01f, 4.63826582e-02f, -2.58407623e-01f,
  3.94035988e-02f, -2.17427641e-01f, 1.48275550e-02f, -1.19393073e-01f, -5.65126166e-02f, -1.41621813e-01f, 1.67675301e-01f, -2.48036068e-02f, -2.68129967e-02f, -1.13453701e-01f,
  2.08933149e-02f, 2.45423093e-01f, 4.70124073e-02f, 1.36194468e-01f, -1.30047619e-01f, 2.88197696e-02f, 1.07015155e-01f, 1.52967587e-01f, -2.07265884e-01f, 1.91182554e-01f,
  1.69810250e-01f, 8.79785344e-02f, 5.72472997e-02f, -4.70022671e-02f, 4.51019546e-03f, -1.55640498e-01f, 5.85065112e-02f, -1.79576814e-01f, 3.09517622e-01f, -1.93872720e-01f,
  2.30948031e-02f, 1.57747185e-03f, 8.99810996e-03f, 4.42389026e-02f, 5.43276444e-02f, 6.23912588e-02f, -6.41653240e-02f, 3.08853276e-02f, 1.72397301e-01f, 1.58407167e-01f,
  2.13526517e-01f, 2.36601323e-01f, 6.88950047e-02f, 2.03386337e-01f, 3.23028713e-02f, 2.02728827e-02f, 2.21486315e-02f, 1.64187610e-01f, 1.16691880e-01f, 2.11430609e-01f,
  1.92497462e-01f, 3.41668688e-02f, 8.79278928e-02f, 1.82280585e-01f, -2.17536032e-01f, -1.88403189e-01f, -9.86627489e-02f, 2.74861008e-01f, 1.60354108e-01f, 3.04992814e-02f,
  6.55708387e-02f, -8.80225897e-02f, -1.72594234e-01f, -1.11289568e-01f, -2.79782683e-01f, -1.06203318e-01f, 1.65769279e-01f, -2.54762173e-01f, 2.15306953e-01f, 2.58033842e-01f,
  -2.67629772e-01f, 5.82144968e-02f, 1.39551744e-01f, 2.69590795e-01f, -1.74147099e-01f, 1.44477293e-01f, 2.12831184e-01f, 8.13157335e-02f, 2.56560355e-01f, 1.38321206e-01f,
  2.14300558e-01f, 1.73386306e-01f, -1.33867592e-01f, -1.31499991e-01f, -1.12090819e-01f, 2.21185654e-01f, -1.27151132e-01f, -1.55028179e-01f, -1.33814797e-01f, 4.82550859e-02f,
  2.12984439e-02f, -2.18198866e-01f, 2.12622181e-01f, -1.13603786e-01f, -1.29546687e-01f, 2.84547985e-01f, -1.38940290e-01f, 1.95858747e-01f, 2.35688359e-01f, 9.17510241e-02f,
  -1.19801931e-01f, 7.61858672e-02f, 9.30984095e-02f, 1.28241360e-01f, 5.80490567e-02f, 5.49956150e-02f, 2.23096609e-01f, 1.50409311e-01f, 1.74286708e-01f, -5.89249358e-02f,
  9.35800150e-02f, 8.30352828e-02f, 1.78778529e-01f, -8.83256085e-03f, 3.47228572e-02f, 2.29210351e-02f, 5.42911328e-02f, 1.56212658e-01f, 1.47095740e-01f, 3.64272557e-02f,
  -6.42946959e-02f, -1.72786668e-01f, 2.73592919e-02f, 3.26705985e-02f, -1.00482553e-01f, -1.82500198e-01f, 6.46918714e-02f, 3.34215872e-02f, -1.74091592e-01f, 8.31872001e-02f,
  4.52642031e-02f, 1.09847896e-02f, 4.54992577e-02f, 9.08205658e-02f, 1.34741187e-01f, 1.65448546e-01f, 2.56387293e-01f, 2.36280188e-01f, 4.15743329e-02f, 4.55926694e-02f,
  2.82543033e-01f, -3.36181722e-03f, -1.32965324e-02f, 8.37230459e-02f, -4.53847349e-02f, 1.05745006e-04f, -7.35260174e-03f, 1.10148989e-01f, -6.24029413e-02f, -6.09790869e-02f,
  1.02315675e-02f, -3.41100506e-02f, 1.76744968e-01f, -9.60924104e-03f, -1.56912982e-01f, 1.63130105e-01f, -7.97825381e-02f, 1.79824885e-02f, 1.25417054e-01f, 3.40310037e-01f,
  3.29833776e-01f, 1.72864106e-02f, -6.62181675e-02f, 1.24970600e-01f, -7.43156374e-02f, -8.27656835e-02f, -9.93403196e-02f, -8.07738230e-02f, -1.00996152e-01f, -1.26331253e-02f,
  2.48811580e-02f, 3.93310338e-02f, 3.02731656e-02f, 2.19180845e-02f, 4.85313050e-02f, -6.70197606e-02f, -2.54847109e-01f, -1.46855354e-01f, 8.79123807e-02f, 2.09270907e-03f,
  -1.03951897e-02f, 3.15326899e-01f, 1.59530584e-02f, 1.45995408e-01f, 1.54746482e-02f, 1.24171346e-01f, 2.61557817e-01f, 1.51489362e-01f, 1.23948760e-01f, -5.48396856e-02f,
  3.09776943e-02f, -1.20399013e-01f, -3.39367956e-01f, 1.92162931e-01f, 1.62372544e-01f, -2.80313283e-01f, 2.63343871e-01f, -2.17139758e-02f, 8.29753280e-02f, -1.14461333e-01f,
  1.46234721e-01f, 1.61192194e-01f, -1.50318258e-02f, 2.25261170e-02f, -1.13213025e-01f, -7.94914141e-02f, 3.06173519e-04f, 2.96479017e-01f, 2.33133078e-01f, 3.25676799e-01f,
  -1.38181925e-01f, -2.57867724e-01f, -4.01313573e-01f, 3.19733769e-01f, 7.04565644e-02f, 9.58426297e-02f, -9.41413864e-02f, 1.49980232e-01f, 2.48089693e-02f, -3.02673012e-01f,
  1.50722370e-01f, -3.44586670e-01f, -3.68151993e-01f, 6.96244612e-02f, -2.87613004e-01f, 5.79980873e-02f, 1.29537523e-01f, 1.65409863e-01f, 7.29947388e-02f, 1.39096349e-01f,
  -7.76963085e-02f, 2.27524228e-02f, 2.38644734e-01f, 2.07834557e-01f, 1.09729096e-01f, 5.40933684e-02f, -1.17915221e-01f, 1.04206435e-01f, 1.49941519e-01f, 5.40079959e-02f,
  7.01915473e-04f, -3.02119907e-02f, 4.11249930e-03f, 1.55776888e-01f, 1.85638487e-01f, 2.14276776e-01f, 9.29420888e-02f, 2.10422594e-02f, -1.72820136e-01f, 1.70266852e-01f,
  3.14327568e-01f, 2.69131631e-01f, 7.22859651e-02f, -1.60351902e-01f, -9.68606248e-02f, -6.67288005e-02f, 1.90512557e-02f, 1.88499019e-01f, 1.92734629e-01f, -1.10734060e-01f,
  2.06341460e-01f, 1.50288641e-01f, -2.48332128e-01f, 1.46732986e-01f, -4.74446528e-02f, 7.38738403e-02f, -4.32908237e-02f, -8.72206017e-02f, -1.57751068e-02f, 3.48354459e-01f,
  1.34162530e-01f, 1.49185866e-01f, 7.31331632e-02f, 7.94127882e-02f, -1.03473164e-01f, -1.12662040e-01f, 3.97668704e-02f, 2.16162816e-01f, 1.41744912e-01f, 1.55866938e-03f,
  1.34232268e-01f, 2.99639374e-01f, 2.64632016e-01f, -8.05540979e-02f, 9.43196118e-02f, -5.35696819e-02f, -1.88829497e-01f, -8.61728564e-03f, -1.87220171e-01f, 2.31374383e-01f,
  -1.39397815e-01f, -8.65667909e-02f, 8.15427378e-02f, -9.04754624e-02f, -3.86912704e-01f, -1.26732841e-01f, -1.10525254e-03f, -1.71774566e-01f, 1.74960829e-02f, -3.52036506e-02f,
  -1.94935769e-01f, 9.18686762e-02f, -6.00699596e-02f, -4.89521325e-02f, 2.49155369e-02f, 3.75295356e-02f, -1.18058905e-01f, 7.08829015e-02f, 2.88103875e-02f, 2.25522712e-01f,
  3.57736290e-01f, -7.90263154e-03f, -7.67780244e-02f, -1.28568724e-01f, 2.18077287e-01f, -1.17225975e-01f, 2.44479850e-01f, 4.84538116e-02f, 2.63834774e-01f, -6.14532363e-03f,
  -5.91077246e-02f, 1.02389447e-01f, -2.28118196e-01f, -2.87043095e-01f, -5.21269776e-02f, 2.88553108e-02f, 4.62916791e-01f, -3.82343493e-02f, 2.93919183e-02f, -1.88171282e-01f,
  1.09744295e-01f, 3.71362381e-02f, 1.38104662e-01f, -2.91629136e-01f, 3.72382887e-02f, 9.30683240e-02f, 6.79916590e-02f, 1.80768818e-01f, -3.69168930e-02f, -3.54514956e-01f,
  8.29464570e-02f, 1.23016015e-01f, 2.90952981e-01f, 1.86898455e-01f, 3.39455217e-01f, 1.16392992e-01f, -6.57026097e-03f, 1.43051311e-01f, -5.89927770e-02f, 1.60768226e-01f,
  8.56475085e-02f, 2.38706514e-01f, 3.86509448e-02f, -2.31158689e-01f, 1.32152289e-01f, 1.99284092e-01f, 1.83922708e-01f, 9.13357958e-02f, 1.39614576e-02f, 1.52146295e-01f,
  1.20881990e-01f, 2.64974862e-01f, 1.10164404e-01f, 8.08110312e-02f, 2.29949445e-01f, 1.56173825e-01f, 8.22452530e-02f, -2.73601757e-03f, 2.33992279e-01f, -6.25225306e-02f,
  -3.88095342e-02f, 2.48006985e-01f, 9.94721502e-02f, 8.33432898e-02f, -1.62228420e-01f, 2.64305681e-01f, -3.10135156e-01f, 4.36015427e-02f, 1.28043994e-01f, 1.27032176e-01f,
  -1.66526929e-01f, -8.55062157e-02f, -2.51376271e-01f, 1.38674557e-01f, 2.43395627e-01f, 2.07543015e-01f, 2.55112261e-01f, -2.24604011e-01f, 2.28504255e-01f, 1.35507673e-01f,
  -1.06036551e-01f, 3.01427811e-01f, -9.96209122e-03f, 2.43565857e-01f, 1.92210048e-01f, 1.38264909e-01f, 2.08843380e-01f, 2.50523806e-01f, 2.99797803e-01f, 7.38342181e-02f,
  1.16855435e-01f, -1.18853137e-01f, 2.05234028e-02f, 1.58550039e-01f, 5.61051210e-03f, -4.48407382e-02f, 1.70112431e-01f, -5.36076911e-02f, 7.50809461e-02f, 9.65853482e-02f,
  -4.58924398e-02f, 2.22177938e-01f, 8.76040664e-03f, 1.58142254e-01f, 1.80511549e-02f, 1.06219567e-01f, 2.59894937e-01f, 2.98362803e-02f, 1.86265167e-02f, 1.34663016e-01f,
  1.30188152e-01f, 3.25156078e-02f, 1.24806445e-02f, -1.84380636e-02f, -7.43626058e-02f, 4.85577360e-02f, -8.85727480e-02f, 2.37542018e-02f, 2.40366340e-01f, -8.10988992e-02f,
  1.50839821e-01f, 1.25479221e-01f, -6.29134700e-02f, -5.17458422e-03f, 7.71246329e-02f, 9.18634459e-02f, 1.90502420e-01f, 5.49080744e-02f, 1.37638643e-01f, 2.47523919e-01f,
  4.53416444e-02f, -2.04708919e-01f, -1.61671922e-01f, -1.36858761e-01f, -2.90309899e-02f, -2.97974676e-01f, 5.74291497e-02f, 2.19881251e-01f, 2.95245945e-01f, 1.22595899e-01f,
  -1.42059503e-02f, -9.46058799e-03f, 2.95335084e-01f, 1.40874520e-01f, 1.26373768e-01f, 2.20239848e-01f, -9.20522362e-02f, 4.57080714e-02f, 2.17041090e-01f, 2.89361440e-02f,
  1.60757348e-01f, 2.52930671e-02f, 2.85808504e-01f, 1.87061056e-01f, -1.11845568e-01f, -1.55201480e-01f, 2.63976038e-01f, -1.56233506e-02f, 3.49097140e-02f, -4.20804252e-04f,
  2.31880307e-01f, 1.19215697e-01f, 2.94931442e-01f, 3.19810778e-01f, -8.73647705e-02f, 3.38259906e-01f, -2.31081456e-01f, 3.10666084e-01f, 1.80833399e-01f, 2.07747216e-03f,
  1.83699116e-01f, -6.38123378e-02f, 1.68618008e-01f, -5.23966253e-02f, 1.42555952e-01f, -1.14528807e-02f, 2.24097759e-01f, 2.37200812e-01f, 1.57661304e-01f, -1.14323040e-02f,
  5.25232665e-02f, -3.60731059e-03f, 6.05897717e-02f, 1.00603634e-02f, -4.38177353e-03f, 1.18060410e-01f, 1.89426899e-01f, 2.01033309e-01f, 2.01755717e-01f, 3.24964076e-02f,
  1.22319944e-01f, -1.63063914e-01f, -3.43021184e-01f, -3.96284461e-01f, 1.64510980e-01f, -1.12031192e-01f, -1.34396791e-01f, -1.33027751e-02f, -1.53215289e-01f, 6.03186861e-02f,
  4.31990586e-02f, 2.59595979e-02f, -3.40415895e-01f, -2.78055191e-01f, 2.18529582e-01f, 9.55068395e-02f, -7.22369328e-02f, 2.40218043e-01f, -1.19650245e-01f, 2.05381006e-01f,
  1.78470880e-01f, 2.33199224e-01f, -2.74868399e-01f, 6.72346577e-02f, 2.19337061e-01f, 1.54800592e-02f, 8.25055987e-02f, -5.46208844e-02f, -2.29326617e-02f, 2.50966281e-01f,
  5.80533631e-02f, 1.55329525e-01f, 6.57325750e-03f, 2.68492959e-02f, -2.32972071e-01f, -5.30203432e-02f, -1.18640698e-01f, -2.73006767e-01f, -1.69307023e-01f, -6.46601617e-02f,
  -1.87238500e-01f, 8.62244144e-03f, 1.63189083e-01f, 2.48387396e-01f, 2.80996710e-02f, 1.49504244e-01f, -9.79601219e-02f, 1.35839105e-01f, 2.60990802e-02f, 7.40692299e-03f,
  -4.84602619e-03f, 1.01113312e-01f, 9.58265364e-02f, 1.07459985e-01f, 4.13368642e-02f, 8.87196362e-02f, -1.58626243e-01f, 1.61618710e-01f, 2.40705423e-02f, 2.08790209e-02f,
  8.02562162e-02f, 1.17153101e-01f, -4.93446365e-02f, -6.11447208e-02f, 3.50338444e-02f, -8.42896029e-02f, 1.77832201e-01f, -2.94903040e-01f, 2.14537174e-01f, 1.97215036e-01f,
  1.33044541e-01f, -6.31212518e-02f, 2.58035690e-01f, 2.61723518e-01f, 1.37574822e-01f, -1.95785463e-01f, 7.84726888e-02f, -1.40117109e-01f, -1.77090406e-01f, 5.38037084e-02f,
  -2.16369838e-01f, -3.00968170e-01f, -6.18087016e-02f, -1.24371536e-01f, -1.04766935e-01f, -3.02745610e-01f, 1.95947707e-01f, 1.89777762e-01f, -6.11856878e-02f, 1.38842538e-01f,
  -1.00686371e-01f, -2.13576078e-01f, 1.77824721e-01f, 1.66250527e-01f, 1.28944442e-01f, -4.00475040e-02f, -7.66128972e-02f, 1.25712007e-01f, 1.68428451e-01f, 1.53329372e-02f,
  9.15312394e-03f, -1.21267766e-01f, 2.78307080e-01f, -1.53660148e-01f, 2.99324572e-01f, -1.90994397e-01f, 4.90767285e-02f, -3.25601220e-01f, -2.78508157e-01f, -2.56454628e-02f,
  3.76691632e-02f, 7.65080899e-02f, -6.71472102e-02f, 5.40587008e-02f, -3.57377268e-02f, 1.35624737e-01f, -5.20337597e-02f, -1.00609802e-01f, 1.19138137e-01f, 1.29136160e-01f,
  -9.96794924e-02f, 1.30921900e-01f, 1.16678238e-01f, 1.03939369e-01f, 9.93324891e-02f, 3.06279981e-03f, 1.87779620e-01f, 1.70179278e-01f, 1.84563279e-01f, 6.59294724e-02f,
  2.96855032e-01f, -6.72058016e-02f, 7.64740556e-02f, 1.84203625e-01f, -4.56820242e-02f, -1.53311118e-01f, 2.13062748e-01f, 2.42806509e-01f, 1.06467605e-01f, -2.24614423e-02f,
  -8.12910423e-02f, -8.92501399e-02f, -2.19291866e-01f, 2.24003941e-02f, -1.07406333e-01f, -1.12190977e-01f, 3.80506784e-01f, -9.87024605e-02f, -9.81722176e-02f, -1.58501968e-01f,
  2.87991971e-01f, -6.95666373e-02f, 7.45988786e-02f, -9.90819037e-02f, -1.04365889e-02f, -7.36468360e-02f, 2.38559902e-01f, 1.18360808e-02f, -1.17514774e-01f, -1.44383222e-01f,
  1.71290100e-01f, 1.69336572e-01f, 2.64883846e-01f, 3.55126619e-01f, 2.64554501e-01f, 7.58216083e-02f, 1.47888452e-01f, 1.22561567e-01f, 4.90094870e-02f, 3.61771844e-02f,
  5.49025461e-02f, -6.62211776e-02f, 1.05583668e-01f, -1.88062355e-01f, -7.58596277e-03f, -6.00174293e-02f, 5.54741174e-03f, 1.58177823e-01f, 2.44152561e-01f, 1.48237765e-01f,
  5.75773120e-02f, 5.53459823e-02f, 6.33563399e-02f, 7.03635365e-02f, 1.54181406e-01f, -3.53348739e-02f, 2.00066343e-01f, 2.42450535e-01f, 2.01962441e-01f, 1.75980583e-01f,
  3.02044209e-02f, 1.94310755e-01f, 1.74872294e-01f, -1.78014919e-01f, -1.07109666e-01f, -1.12362988e-01f, 4.20207940e-02f, 5.50172366e-02f, -2.01956987e-01f, 1.31600294e-02f,
  -2.38915429e-01f, -1.02723233e-01f, 1.12211548e-01f, 4.16641682e-02f, -1.62134618e-01f, -2.45963633e-01f, 1.19729429e-01f, 2.26786137e-01f, 4.09451425e-02f, -7.38007249e-03f,
  -1.30577356e-01f, 1.04105167e-01f, 3.00990194e-01f, 1.99757919e-01f, 8.36699679e-02f, 3.00356120e-01f, 4.58042044e-03f, -9.75669175e-03f, -3.92378531e-02f, -2.04337344e-01f,
  6.43890351e-02f, 3.95740047e-02f, 8.74278992e-02f, 3.35930437e-01f, 2.96346754e-01f, -6.07522717e-03f, -2.64492899e-01f, -2.07912967e-01f, -2.46679544e-01f, -2.46716440e-01f,
  -1.86006621e-01f, 1.74696296e-01f, 4.25831974e-02f, 1.03746921e-01f, 1.14710927e-01f, 3.45365927e-02f, 1.32999465e-01f, 1.28572747e-01f, 2.75998414e-01f, 5.79894781e-02f,
  9.39055458e-02f, 9.33875665e-02f, 2.21221969e-01f, 1.13388225e-01f, 5.21197580e-02f, 5.88881969e-02f, 2.20339254e-01f, 2.23396063e-01f, 5.37396595e-03f, 5.00691645e-02f,
  6.54772893e-02f, 1.11634266e-02f, 1.46857828e-01f, 1.89135410e-02f, 1.08914953e-02f, 2.36638606e-01f, 1.86942875e-01f, 1.50830522e-01f, -2.32288018e-02f, 2.76872724e-01f,
  -4.65088338e-01f, 2.09109440e-01f, 1.33045718e-01f, 3.60540330e-01f, -3.16639870e-01f, 1.13753609e-01f, -3.30949634e-01f, -3.71111855e-02f, 1.68964699e-01f, 7.29660243e-02f,
  1.37329131e-01f, -2.46081501e-01f, 9.21796486e-02f, -1.40977561e-01f, 6.57277331e-02f, 3.31042439e-01f, -2.10732579e-01f, 1.60327628e-01f, 6.90330714e-02f, 1.80502459e-01f,
  3.08230668e-01f, -5.08941039e-02f, 1.23325936e-01f, 1.87944397e-01f, 1.51557162e-01f, -1.85164750e-01f, -4.48519200e-01f, -7.58708920e-03f, 8.13020468e-02f, 2.64052242e-01f,
  6.16685748e-02f, 8.87249634e-02f, 2.15305179e-01f, 1.32673934e-01f, 2.33660206e-01f, 2.26437792e-01f, 1.03298970e-01f, 9.46154818e-02f, 6.47170749e-03f, -7.68670887e-02f,
  1.33853793e-01f, 5.88971786e-02f, -6.61931932e-03f, 8.27325433e-02f, 1.25307888e-01f, 1.38954177e-01f, 1.04114870e-02f, 2.88935890e-03f, 2.11013719e-01f, 2.86093175e-01f,
  1.32065147e-01f, 1.20767817e-01f, 1.14874974e-01f, 1.17644429e-01f, 6.84607476e-02f, 1.48860008e-01f, 1.58807188e-01f, 1.99570298e-01f, -5.12870103e-02f, 2.55049288e-01f,
  2.39317551e-01f, 5.53530492e-02f, -8.85424688e-02f, -1.11873813e-01f, -2.33773842e-01f, 1.32642761e-01f, 1.61401033e-01f, 9.01249424e-02f, -1.72705829e-01f, -1.62503213e-01f,
  -1.90679476e-01f, -1.08000346e-01f, 9.78279207e-03f, 1.52771682e-01f, 2.27476999e-01f, -5.47482930e-02f, 1.04721054e-01f, 1.81968346e-01f, -3.61648500e-01f, -2.80426778e-02f,
  2.67120637e-02f, 1.21877931e-01f, -1.66559499e-03f, 1.65115818e-01f, -7.39433020e-02f, 2.49229386e-01f, 8.91992748e-02f, 2.60753483e-01f, 2.96209216e-01f, 6.09491803e-02f,
  6.97606057e-02f, 9.19941813e-02f, -9.12547931e-02f, 1.00903988e-01f, 4.19834033e-02f, -2.27850303e-03f, -1.25615835e-01f, 9.29339677e-02f, 1.82360753e-01f, -1.63293853e-01f,
  3.03297251e-01f, -4.66588810e-02f, -7.75338267e-04f, -5.16228266e-02f, -1.22048974e-01f, 3.00516278e-01f, 6.87701181e-02f, -1.11732334e-01f, 8.74035880e-02f, 7.86245018e-02f,
  -1.47167996e-01f, 8.23782757e-02f, -1.81159049e-01f, 5.25123291e-02f, 5.04098386e-02f, -2.06609070e-02f, 1.39777198e-01f, 4.79302220e-02f, 5.11285476e-03f, 1.66835025e-01f,
  1.31493092e-01f, 1.34742051e-01f, 4.35381532e-02f, 7.17967153e-02f, 6.92786202e-02f, 8.43652561e-02f, 1.04115717e-01f, 5.70016019e-02f, 2.15037361e-01f, -1.78967550e-01f,
  -2.12933585e-01f, -9.58310440e-02f, 1.70703426e-01f, -1.86965168e-01f, 1.02006868e-01f, 2.14645773e-01f, 5.94800711e-02f, -1.84140310e-01f, -1.64358929e-01f, 1.80888295e-01f,
  5.51479012e-02f, 4.22759168e-02f, 2.29095027e-01f, 5.17098755e-02f, 2.15313628e-01f, 5.93659058e-02f, 1.38826132e-01f, 1.64180398e-02f, -1.41034806e-02f, -8.14211518e-02f,
  1.84745893e-01f, -1.91637218e-01f, -6.55874535e-02f, 2.38907132e-02f, 1.20826207e-01f, 1.01106420e-01f, 2.31866851e-01f, -5.12505770e-02f, 1.64888203e-01f, 1.70243874e-01f,
  1.30600676e-01f, 2.04445407e-01f, -7.54500628e-02f, 3.22940588e-01f, -1.56301796e-01f, 2.94032127e-01f, 1.59783542e-01f, 1.06191002e-01f, 2.83488214e-01f, -1.02708563e-01f,
  8.19378272e-02f, 1.28347188e-01f, -8.30244869e-02f, 6.56832829e-02f, -3.84659097e-02f, 1.69146985e-01f, 1.35597855e-01f, -4.98571955e-02f, 9.05693844e-02f, 9.57209840e-02f,
  1.47540316e-01f, 9.50442180e-02f, 7.78267756e-02f, 3.12863253e-02f, 7.45279044e-02f, -7.90011045e-03f, 5.41453995e-03f, 9.06517133e-02f, -4.15683128e-02f, 5.55110648e-02f,
  -1.21156231e-01f, -9.06529650e-02f, 1.54187754e-01f, -1.83045313e-01f, 7.76896765e-03f, -2.09740251e-01f, 2.33974352e-01f, -1.99842915e-01f, 2.19221666e-01f, 1.71609268e-01f,
  4.08464409e-02f, 1.45904655e-02f, 6.97094277e-02f, -1.77309848e-02f, 1.56913340e-01f, 2.50177890e-01f, -1.34406269e-01f, 1.28650710e-01f, 1.11751080e-01f, 1.85590535e-01f,
  5.14011048e-02f, 1.26767948e-01f, 1.59023449e-01f, 2.53435802e-02f, 2.97378421e-01f, -1.71747863e-01f, -2.01935545e-01f, -3.44757512e-02f, 2.86188006e-01f, 7.01692700e-02f,
  1.87408850e-01f, -1.04845196e-01f, 2.36286409e-02f, 1.50755495e-01f, 2.20925599e-01f, 2.15802893e-01f, -8.29519182e-02f, 1.60275728e-01f, 5.60216233e-03f, 2.24659920e-01f,
  1.93352371e-01f, 1.94426119e-01f, 2.29108855e-01f, 8.45056996e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.00548282e-01f, 1.43250097e-02f, 3.11351418e-02f, 6.98258430e-02f, 1.22845598e-01f, 1.24021612e-01f, 1.46491691e-01f, 4.70618866e-02f, 7.62770921e-02f, 1.43619135e-01f,
  1.43862844e-01f, 1.72992304e-01f, -7.17791030e-03f, -7.90119246e-02f, 9.04352069e-02f, -1.07853793e-01f, 2.28869528e-01f, 1.71538576e-01f, 2.01126233e-01f, 8.66426155e-02f,
  1.43450186e-01f, 4.62675430e-02f, 2.16538072e-01f, 2.09047258e-01f, -3.24916542e-02f, 1.29490048e-01f
};

// L3_fan_Wp (Shape: 19 x 64)
const int L3_fan_Wp_rows = 19;
const int L3_fan_Wp_cols = 64;
const float L3_fan_Wp_data[] = {
  8.79053175e-02f, -4.22136709e-02f, -1.03303783e-01f, 1.10799931e-01f, 5.29142246e-02f, 3.45807225e-02f, 1.23724461e-01f, 6.41772225e-02f, 9.31350291e-02f, -1.42695278e-01f,
  -1.65419951e-01f, 5.12730181e-02f, 7.13713840e-02f, -1.83486007e-02f, -9.34918672e-02f, -4.12722826e-02f, -1.44126520e-01f, -9.26966146e-02f, -1.51222527e-01f, -1.06996819e-01f,
  -1.28857434e-01f, -1.68034732e-01f, -8.20796266e-02f, 2.41203476e-02f, -2.21586656e-02f, 9.38153639e-02f, 2.02265874e-01f, -5.62139489e-02f, 9.14861113e-02f, 1.25536099e-01f,
  5.81842884e-02f, 2.97058858e-02f, -1.40661761e-01f, 2.73174465e-01f, 8.28328058e-02f, 1.30147576e-01f, -1.54555738e-01f, -1.02977201e-01f, -3.01774181e-02f, 7.83530325e-02f,
  7.15599135e-02f, -6.39872104e-02f, 7.17166215e-02f, 1.41645506e-01f, -6.28061220e-02f, 1.27703115e-01f, 1.30142137e-01f, -9.96231958e-02f, 7.48696998e-02f, 4.99320589e-02f,
  1.08525798e-01f, 8.69382769e-02f, -2.32840832e-02f, 1.57335967e-01f, -1.75334334e-01f, -1.13808043e-01f, -3.08050420e-02f, 7.16757551e-02f, 1.20422833e-01f, -7.07496190e-03f,
  7.67259486e-03f, -1.58032537e-01f, 3.81126329e-02f, 2.32317522e-02f, -3.89076695e-02f, -8.87147617e-03f, -1.21456847e-01f, 1.39070585e-01f, 5.72496839e-02f, -1.22445941e-01f,
  5.93273155e-02f, 6.57902136e-02f, -6.00728346e-03f, 8.27979967e-02f, -9.84490663e-02f, -1.24820709e-01f, 4.72754762e-02f, -7.36699719e-03f, -9.33818743e-02f, 4.84166183e-02f,
  -1.51611537e-01f, -3.16734910e-02f, -4.11820859e-02f, 2.58054473e-02f, 7.45919943e-02f, -1.36097774e-01f, -1.76418453e-01f, -9.26628560e-02f, 8.51836577e-02f, -1.07123815e-02f,
  1.63092166e-01f, 2.51990110e-01f, -1.20344879e-02f, 2.17318207e-01f, 1.10455438e-01f, 1.49298191e-01f, 1.13270961e-01f, 2.00762421e-01f, -2.10755512e-01f, 5.69453277e-02f,
  -2.13152751e-01f, -5.89220077e-02f, 3.30562852e-02f, -4.32842411e-03f, -5.48621900e-02f, -9.52599496e-02f, 1.18583716e-01f, 3.00898645e-02f, 1.68640539e-01f, -8.89323428e-02f,
  -8.36138502e-02f, 3.08038928e-02f, 3.61116752e-02f, -9.25021693e-02f, 1.79099381e-01f, 1.86063290e-01f, -3.96942273e-02f, 1.24876723e-01f, -6.03685677e-02f, -3.10809761e-02f,
  -1.09079760e-02f, -1.12609796e-01f, -3.35979946e-02f, -5.94825856e-02f, 2.07233577e-04f, -1.42023772e-01f, 1.53442711e-01f, -7.37267286e-02f, -6.85506612e-02f, 6.23730421e-02f,
  1.19772740e-01f, -1.37821332e-01f, -1.31027132e-01f, -3.84079549e-03f, -2.32855733e-02f, -7.48121962e-02f, -6.47039190e-02f, 8.08777511e-02f, -5.92152961e-02f, -2.31518107e-03f,
  4.71955352e-02f, 1.74477786e-01f, -3.95063981e-02f, 1.31231034e-02f, 1.44506931e-01f, 2.01244596e-02f, -1.31418601e-01f, 1.41226323e-02f, 1.81420565e-01f, -2.09157050e-01f,
  -3.84008624e-02f, -1.45222962e-01f, -1.32149667e-01f, 1.41334496e-02f, -3.01378090e-02f, 2.16946438e-01f, -4.61822674e-02f, -3.72746214e-02f, -1.29512267e-03f, 3.08281276e-02f,
  -9.05143097e-03f, 3.72949336e-03f, 7.91365746e-03f, -1.19196504e-01f, -5.47817871e-02f, 8.04168284e-02f, -7.28382468e-02f, -8.81068707e-02f, -1.00223452e-01f, -1.69621319e-01f,
  -1.08625842e-02f, 1.95976481e-01f, -7.79000819e-02f, 5.76652698e-02f, 1.54375151e-01f, -8.61057788e-02f, -4.72879522e-02f, 2.43833791e-02f, 4.19319533e-02f, 1.47832885e-01f,
  -6.62739575e-03f, -2.87775826e-02f, 8.12381785e-03f, -4.87827100e-02f, -3.24614793e-02f, 3.17874029e-02f, 1.96386993e-01f, -8.34543034e-02f, 7.02385902e-02f, 1.02120794e-01f,
  9.95100811e-02f, -7.41425380e-02f, -9.26929191e-02f, 1.09677305e-02f, 5.50425909e-02f, 2.16291118e-02f, -6.20105006e-02f, -1.23933926e-01f, -5.70069766e-03f, 8.43204930e-02f,
  -6.78507984e-03f, -1.09014116e-01f, 2.10846998e-02f, -5.97856194e-03f, 1.04086690e-01f, -7.91029930e-02f, 4.71324325e-02f, -3.86562385e-02f, -4.30933535e-02f, -1.19672418e-01f,
  6.11835532e-02f, 3.49396910e-03f, 9.05704126e-02f, -5.59651814e-02f, 1.41261131e-01f, -5.72803877e-02f, 4.74258661e-02f, 1.78444833e-01f, 1.37665957e-01f, -1.50960565e-01f,
  -1.14810303e-01f, 1.03827834e-01f, 8.48278478e-02f, -1.32257594e-02f, -1.15337327e-01f, 1.32437646e-02f, -8.56672321e-03f, -2.04735529e-02f, 7.02733546e-02f, -1.90271497e-01f,
  1.16114326e-01f, 4.95127328e-02f, 9.11208242e-02f, -3.82248908e-02f, 1.25143066e-01f, 1.13477327e-01f, -3.99895608e-02f, -1.84482783e-01f, 7.36968964e-02f, 2.13681143e-02f,
  5.75699508e-02f, 1.86725229e-01f, -6.64000809e-02f, 6.16221875e-02f, -5.75540029e-02f, -5.31982519e-02f, -2.29356457e-02f, 3.91302705e-02f, -1.39545187e-01f, 6.24952689e-02f,
  1.68467581e-01f, 7.58319497e-02f, 1.05398394e-01f, -3.61424349e-02f, -1.66108206e-01f, -1.26122311e-01f, -2.92801932e-02f, 9.65536535e-02f, 1.63162071e-02f, 8.82535521e-03f,
  6.11872226e-02f, -8.21171477e-02f, 9.26327929e-02f, -5.19249029e-02f, -2.08105589e-03f, 3.18883806e-02f, -1.38656870e-01f, 7.51487911e-02f, -8.66527029e-04f, -4.60459031e-02f,
  1.05977535e-01f, 4.28994782e-02f, -1.01346634e-01f, 6.32261531e-03f, -1.19037360e-01f, -7.91114047e-02f, -1.76883966e-01f, 1.06185742e-01f, 7.94008672e-02f, 1.40631706e-01f,
  2.74171047e-02f, 1.71979830e-01f, 1.41365483e-01f, -1.72728673e-01f, 7.52337873e-02f, 9.27259997e-02f, 1.28179580e-01f, 6.80885836e-02f, -6.92425817e-02f, 1.79340079e-01f,
  1.07274771e-01f, 1.40561789e-01f, 1.29842898e-02f, -1.19286887e-01f, -1.06652059e-01f, 1.59148157e-01f, 3.35198753e-02f, 1.55839026e-01f, -2.66221650e-02f, 6.87403902e-02f,
  -1.31746814e-01f, 2.55946182e-02f, 2.34490875e-02f, -8.30406770e-02f, -1.12959199e-01f, 8.20558220e-02f, -8.12076628e-02f, -1.01365589e-01f, -9.94534343e-02f, 1.53330684e-01f,
  6.37375265e-02f, -2.04297621e-02f, 1.63908944e-01f, -6.75821155e-02f, 6.25007153e-02f, 1.31616861e-01f, -1.64445981e-01f, 1.41657004e-02f, -7.10660890e-02f, -1.45638827e-02f,
  -1.39989793e-01f, -5.77645414e-02f, 9.15773287e-02f, 7.31669888e-02f, 4.13846336e-02f, 5.76588064e-02f, -5.66377901e-02f, 2.14003753e-02f, 7.80105293e-02f, 4.07925062e-02f,
  1.41818523e-02f, -1.11087613e-01f, -1.14109330e-01f, 8.62755105e-02f, 9.20623690e-02f, -6.00496270e-02f, -9.48564708e-02f, 3.26332897e-02f, -1.37606099e-01f, -6.58039819e-04f,
  -8.03277716e-02f, -1.39254242e-01f, -1.84707999e-01f, -1.63496301e-01f, 3.39579508e-02f, 1.56967446e-01f, -2.06282157e-02f, -9.20020267e-02f, -1.14371464e-01f, -3.33100185e-02f,
  -1.12551823e-02f, -7.37146065e-02f, -1.44849913e-02f, 1.31479695e-01f, -1.46983042e-01f, 9.11769643e-02f, -9.51700509e-02f, -1.11324601e-01f, 5.14359772e-03f, -2.07706504e-02f,
  2.15607155e-02f, 1.29614994e-02f, 1.22947887e-01f, 9.48733091e-02f, -5.49090579e-02f, -4.15434763e-02f, 8.68180320e-02f, 1.49958402e-01f, 1.18697949e-01f, 4.39609103e-02f,
  -1.02400005e-01f, 1.39809906e-01f, -1.62315518e-01f, 1.19425036e-01f, -6.57942742e-02f, -6.34936467e-02f, 3.54974158e-02f, 9.40884501e-02f, 1.14024699e-01f, 9.78797302e-02f,
  -3.74843404e-02f, -1.06725059e-01f, -4.39687036e-02f, -7.81445950e-02f, 3.20577882e-02f, 8.66906345e-02f, -7.85690621e-02f, 6.84274640e-03f, -5.34277558e-02f, 4.96461503e-02f,
  -1.91945553e-01f, -9.95840877e-02f, -1.15531147e-01f, -1.29161924e-01f, -9.13133249e-02f, -5.07484861e-02f, 1.17350750e-01f, -3.41888182e-02f, 8.72081891e-02f, -1.13608681e-01f,
  -5.34240007e-02f, -1.29791036e-01f, -1.05473727e-01f, -1.28057882e-01f, -2.27136880e-01f, 1.64752439e-01f, -1.19622827e-01f, -2.54437588e-02f, -5.14816716e-02f, 1.65174440e-01f,
  4.29619402e-02f, -1.51757732e-01f, -3.67763750e-02f, 1.02065988e-01f, 6.32031485e-02f, 1.10782869e-01f, -2.88482197e-02f, 1.55358091e-01f, -2.57491857e-01f, 1.26811817e-01f,
  -4.41518100e-03f, -9.98152867e-02f, 2.82267551e-03f, -6.23554848e-02f, 4.26080870e-03f, 6.61613643e-02f, 4.31717262e-02f, 1.02160573e-01f, 4.60417047e-02f, 5.94896413e-02f,
  -1.48666486e-01f, -5.37330657e-02f, 1.07320093e-01f, -5.82618602e-02f, -1.15639903e-01f, 4.39690277e-02f, -8.97075757e-02f, 2.93943547e-02f, -4.05211113e-02f, -2.61686128e-02f,
  2.07852088e-02f, 1.57190427e-01f, -8.99969861e-02f, 1.68165669e-01f, -1.40269831e-01f, 8.63242373e-02f, 2.05980539e-02f, -9.42081362e-02f, -4.83292043e-02f, -4.88361679e-02f,
  -2.22078040e-02f, -9.82597768e-02f, 1.23722792e-01f, -9.90347043e-02f, 1.96154583e-02f, 4.05593961e-02f, -1.02920882e-01f, 7.52729690e-03f, 4.62870598e-02f, 1.18836034e-02f,
  -2.16491967e-02f, 1.01356804e-01f, 1.95908975e-02f, -6.21450208e-02f, 7.39139393e-02f, 1.58719689e-01f, -1.18676320e-01f, -1.77606214e-02f, 1.17360473e-01f, -4.99406457e-02f,
  -1.48548735e-02f, 9.00656581e-02f, -3.37348469e-02f, -3.30948606e-02f, 1.84108857e-02f, -1.20287705e-02f, -4.48398814e-02f, 3.96451019e-02f, -1.39807597e-01f, -2.27929335e-02f,
  -1.62958577e-01f, 4.47231568e-02f, 3.27090062e-02f, -1.30106762e-01f, 3.12677994e-02f, -5.84687330e-02f, 1.07491225e-01f, -4.65315627e-03f, 1.35468841e-01f, -1.54127479e-01f,
  7.56264254e-02f, 4.10428317e-03f, 4.73243967e-02f, -8.79426375e-02f, 1.09944858e-01f, 4.85906415e-02f, 1.16109975e-01f, -1.05776601e-01f, 8.31217468e-02f, -2.22939342e-01f,
  -8.86909068e-02f, 4.12977934e-02f, -1.29329324e-01f, 1.21432068e-02f, 7.02067465e-02f, 1.86261579e-01f, -2.73974054e-02f, -8.32721218e-02f, 1.14710413e-01f, -1.14467025e-01f,
  -2.32091583e-02f, -3.44307199e-02f, 1.47606281e-03f, -1.33999333e-01f, -2.05738842e-03f, -5.91331124e-02f, -1.71625033e-01f, -1.37967244e-01f, -1.69397201e-02f, -7.23695336e-03f,
  4.46106903e-02f, -1.51004985e-01f, -3.68643329e-02f, 6.59911856e-02f, 1.23978956e-02f, 6.63527055e-03f, -6.72085881e-02f, -1.69788659e-01f, -1.75833583e-01f, -8.66989717e-02f,
  -9.30039659e-02f, -1.14185447e-02f, 1.96639188e-02f, -2.12220907e-01f, -6.46104962e-02f, -8.34223777e-02f, -6.77489713e-02f, 2.05842201e-02f, -1.03118092e-01f, 1.51412249e-01f,
  3.44145223e-02f, -3.79920448e-03f, -1.78626701e-02f, 1.33391783e-01f, -7.53680170e-02f, -6.96468540e-03f, -1.03725411e-01f, 5.98685816e-03f, -1.48478523e-01f, -3.63383628e-02f,
  1.94044914e-02f, 9.00957659e-02f, -3.03316191e-02f, -1.98596641e-02f, 6.16935045e-02f, 8.18191916e-02f, -1.11857187e-02f, 6.79927692e-02f, 1.46354511e-01f, -1.56007027e-02f,
  2.15904042e-02f, -7.63403773e-02f, 6.45488277e-02f, 9.53875706e-02f, 5.67852482e-02f, 1.62795097e-01f, -1.08885251e-01f, -1.03538476e-01f, -7.97054917e-02f, 8.90401676e-02f,
  -1.77897792e-02f, -1.69997260e-01f, -1.92962978e-02f, -3.39164697e-02f, -1.21532030e-01f, -1.25589356e-01f, -7.35464469e-02f, -1.00243084e-01f, 1.05422894e-02f, 8.31523016e-02f,
  1.87640384e-01f, 1.43831700e-01f, 4.11938839e-02f, 4.40664627e-02f, 1.07693806e-01f, 7.82208517e-02f, 3.78775857e-02f, 6.11398965e-02f, 9.10012797e-02f, -7.83367380e-02f,
  -6.24670759e-02f, 1.30555212e-01f, -1.58138558e-01f, -8.59555155e-02f, 1.03412926e-01f, 1.67747587e-02f, -1.30567864e-01f, 1.40663236e-01f, 7.68159479e-02f, 7.62210339e-02f,
  1.68793216e-01f, 1.07778810e-01f, -9.25331190e-02f, -6.00170493e-02f, 6.25480041e-02f, 2.80156344e-01f, 1.83314383e-01f, 1.35422781e-01f, 1.03384167e-01f, -3.57982703e-02f,
  1.09879389e-01f, 4.50589359e-02f, -9.77926403e-02f, -9.97849838e-06f, -8.30944031e-02f, 1.24715604e-01f, -2.18209438e-02f, 5.50012402e-02f, 2.06642114e-02f, -8.89039487e-02f,
  8.70347470e-02f, 4.19206619e-02f, 5.96539564e-02f, -8.51901695e-02f, 5.12792170e-02f, 1.20322987e-01f, 2.07182746e-02f, -1.57110333e-01f, -7.29808286e-02f, -1.69208735e-01f,
  -9.98174027e-02f, 4.68306206e-02f, 6.38938919e-02f, -1.37740836e-01f, -5.13681360e-02f, 8.68994072e-02f, 5.68552464e-02f, -8.08591843e-02f, -6.42141327e-02f, 7.54103959e-02f,
  -7.48682842e-02f, -1.43627211e-01f, -1.47489473e-01f, 1.95019022e-02f, 2.09728554e-02f, -1.48324460e-01f, 1.55511588e-01f, -6.23118430e-02f, -8.61957669e-02f, -1.12066463e-01f,
  -9.38978195e-02f, 2.84421593e-02f, 2.77583636e-02f, 1.01718195e-02f, -5.96546382e-02f, 3.78203094e-02f, 1.62389427e-02f, -1.39104918e-01f, -9.27989557e-02f, 7.83811808e-02f,
  -2.30565041e-01f, -1.53350353e-01f, -1.25491932e-01f, 1.12200417e-01f, -4.71831746e-02f, 1.58368379e-01f, -1.09607419e-02f, 1.08284801e-01f, 1.82178229e-01f, 2.31587410e-01f,
  -7.18302578e-02f, 1.95877314e-01f, -5.15221385e-03f, 1.81693286e-01f, 8.57613236e-02f, 2.05544055e-01f, -5.28797992e-02f, 7.24409297e-02f, 3.47266309e-02f, 1.46610230e-01f,
  -1.26808612e-02f, -6.69485405e-02f, 1.47573978e-01f, 8.13981220e-02f, -3.37920301e-02f, 6.54490143e-02f, 1.44984229e-02f, -1.21622942e-01f, 8.81171897e-02f, 1.65513754e-02f,
  5.89070395e-02f, 1.71325743e-01f, -3.72599065e-02f, 8.27046633e-02f, 4.25628982e-02f, 7.00495020e-03f, -3.18351351e-02f, -1.15007192e-01f, -4.02748212e-02f, -1.24246135e-01f,
  -1.59905791e-01f, -1.28704205e-01f, 7.37939104e-02f, -1.26531363e-01f, -4.12153192e-02f, 7.33151212e-02f, -1.38480112e-01f, -4.27731350e-02f, -8.57735332e-03f, -1.82155631e-02f,
  -2.43175924e-02f, 6.05652332e-02f, -7.14657083e-02f, 4.16841507e-02f, -1.36103719e-01f, 5.77626266e-02f, 4.52910326e-02f, -1.12778753e-01f, 2.95579303e-02f, 8.29690397e-02f,
  1.13259070e-01f, 1.84524730e-02f, -2.04942506e-02f, 8.88453722e-02f, -1.14821315e-01f, 1.63164064e-01f, 5.92726730e-02f, 1.14568099e-01f, -3.35187167e-02f, 8.61681476e-02f,
  3.15719889e-03f, -9.78550464e-02f, 1.01244681e-01f, 1.71410874e-01f, 2.74917502e-02f, 5.79266176e-02f, 1.75830692e-01f, 2.62974645e-03f, 1.01106629e-01f, 9.55495462e-02f,
  -1.08413279e-01f, -6.85479771e-03f, -5.87645744e-04f, 8.65923017e-02f, 2.13599261e-02f, 2.53967196e-02f, -4.38259207e-02f, -9.92515460e-02f, -9.95606277e-03f, 1.53989360e-01f,
  -1.15500234e-01f, -1.19226081e-02f, -1.33673728e-01f, 1.80047169e-01f, 8.00877810e-02f, -1.33124694e-01f, -6.49353415e-02f, 5.49037289e-03f, 7.73160160e-02f, -4.09461521e-02f,
  -8.80997442e-03f, -6.84985295e-02f, -1.44167289e-01f, -7.16250613e-02f, -9.51982513e-02f, -2.56795194e-02f, 5.69481328e-02f, 1.08997568e-01f, 1.00008674e-01f, -7.64308721e-02f,
  5.98127320e-02f, 9.47853923e-02f, 1.00338757e-01f, -7.56033212e-02f, 7.85890445e-02f, 8.12044963e-02f, 7.07838908e-02f, 3.35729565e-03f, 1.20946400e-01f, 2.12417804e-02f,
  9.28725153e-02f, -2.64087413e-02f, 1.49034530e-01f, 1.15974300e-01f, 9.99378115e-02f, -8.22818577e-02f, -9.01434273e-02f, -1.87005941e-02f, -2.52424359e-01f, 1.23466596e-01f,
  1.11310035e-01f, 3.17557454e-02f, -7.86837414e-02f, 6.12050369e-02f, 1.04602769e-01f, -6.94452524e-02f, -1.66875780e-01f, 9.15724114e-02f, 2.01366413e-02f, -7.45495483e-02f,
  -1.20192550e-01f, 9.64137726e-03f, -2.66567431e-02f, 1.33968666e-01f, 1.17515817e-01f, -1.76710725e-01f, 1.07876934e-01f, -2.67765969e-02f, 1.40752137e-01f, 2.26827897e-02f,
  2.07242202e-02f, 1.15975104e-01f, -7.71177262e-02f, 5.16105667e-02f, -7.66913891e-02f, 4.39312775e-03f, 1.04160964e-01f, -1.37743354e-01f, 1.53342739e-03f, -1.00524314e-01f,
  8.86861384e-02f, 6.87115490e-02f, -1.39701262e-01f, -1.05252184e-01f, 1.69337541e-01f, -1.24586262e-02f, -9.71964002e-02f, 1.86900407e-01f, -1.96040377e-01f, -1.00549078e-02f,
  1.05904736e-01f, 1.39277011e-01f, 7.33695403e-02f, -3.03556826e-02f, -4.16802764e-02f, 3.46422642e-02f, 1.41580552e-01f, 1.48513824e-01f, -9.81276110e-02f, 7.70305246e-02f,
  1.34627130e-02f, 4.62587997e-02f, 1.69880480e-01f, 8.75455439e-02f, 1.43919557e-01f, -5.87674603e-02f, 1.16548099e-01f, 1.31321087e-01f, 1.14370175e-01f, -2.84320172e-02f,
  3.29828709e-02f, 1.15403622e-01f, 2.00040430e-01f, 2.99307499e-02f, -5.32858111e-02f, -9.26999450e-02f, 7.38499803e-04f, -1.32483944e-01f, -8.63269204e-04f, 2.89163506e-03f,
  2.63995491e-02f, -9.59770009e-02f, -2.04820260e-01f, -2.24585962e-02f, 1.36683494e-01f, -1.49218023e-01f, 1.73935965e-01f, -1.60119712e-01f, 3.51537913e-02f, 7.96829686e-02f,
  6.15813620e-02f, -7.38317519e-02f, 4.38199863e-02f, 9.95517820e-02f, -1.36794239e-01f, -4.62521421e-04f, -1.14674337e-01f, 1.16261765e-01f, 2.70473445e-03f, -9.33566317e-02f,
  -9.98645872e-02f, -8.77114311e-02f, -5.17080463e-02f, 2.66537815e-02f, 5.78892715e-02f, 1.76247850e-03f, 3.66079994e-02f, 1.50338054e-01f, 8.20084438e-02f, -4.55766916e-02f,
  -4.14160229e-02f, -1.86347559e-01f, 8.09129030e-02f, -4.07951139e-02f, 1.13282710e-01f, 1.03374571e-01f, 1.36539908e-02f, 2.11681370e-02f, 1.21036746e-01f, -1.27210453e-01f,
  4.89962026e-02f, -6.99372729e-04f, -9.75185260e-02f, 1.23925958e-04f, 1.44177645e-01f, -5.58577403e-02f, 3.76034118e-02f, -1.01342641e-01f, 3.12495939e-02f, -1.31134212e-01f,
  3.53270322e-02f, 5.91453388e-02f, 1.28775477e-01f, -5.95582351e-02f, -5.36738783e-02f, 7.73387328e-02f, -7.75447637e-02f, 8.06456059e-02f, -3.59710976e-02f, 4.73878458e-02f,
  -4.66874279e-02f, 2.48477701e-03f, -1.17245197e-01f, 4.50988784e-02f, 1.33831933e-01f, 3.13831791e-02f, -3.69948708e-02f, 6.84985891e-02f, 1.26868814e-01f, 9.87905189e-02f,
  -6.65395260e-02f, -1.02556080e-01f, -1.20567538e-01f, -2.97571179e-02f, -2.41450593e-02f, 1.37530625e-01f, -8.93896371e-02f, -1.79585852e-02f, 3.93414237e-02f, -6.08050711e-02f,
  -6.10476993e-02f, 2.07921773e-01f, 8.57498869e-02f, -1.16452709e-01f, -1.85210258e-01f, -4.42019738e-02f, 4.80897650e-02f, 4.83604036e-02f, 1.64151862e-01f, -1.79629624e-01f,
  1.68141834e-02f, 9.10847485e-02f, -1.92656647e-02f, -1.26158386e-01f, -5.39874621e-02f, -9.36131403e-02f, -3.34559977e-02f, 1.28787711e-01f, 2.32771523e-02f, 1.40340358e-01f,
  -4.54698652e-02f, 7.75336474e-02f, 1.25814909e-02f, 4.96967621e-02f, -1.48143396e-01f, -1.07979037e-01f, -3.01077440e-02f, -8.49162862e-02f, 1.06160017e-02f, 3.11302766e-02f,
  9.02862474e-02f, -1.28529757e-01f, -6.78359121e-02f, 3.55917774e-02f, -6.51263148e-02f, 2.30415817e-02f, 5.63400090e-02f, -4.85488288e-02f, 2.14558635e-02f, -8.86709765e-02f,
  2.06168339e-01f, -1.31131813e-01f, -1.39228746e-01f, -2.27539405e-01f, -5.60838021e-02f, -1.32618859e-01f, -5.77345602e-02f, 1.74729496e-01f, 7.14681596e-02f, -2.40202725e-01f,
  -1.92757919e-01f, -2.56339591e-02f, 2.07258120e-01f, -4.79498096e-02f, -2.44989879e-02f, -9.51193050e-02f, -5.21611348e-02f, 1.62094623e-01f, -1.74583737e-02f, 7.79371560e-02f,
  -3.98255624e-02f, 7.83029348e-02f, 3.56632168e-03f, -1.04130425e-01f, -2.36450080e-02f, 1.00606501e-01f, 6.61379769e-02f, 1.86427068e-02f, -7.00397268e-02f, -2.23003224e-01f,
  5.36310077e-02f, 1.65187791e-01f, 1.17663898e-01f, 2.23457236e-02f, -3.05782109e-02f, 1.00270286e-01f, -2.17147961e-01f, -2.33805299e-01f, -6.18541501e-02f, 4.01371457e-02f,
  5.20488434e-02f, -8.28456655e-02f, 1.88058287e-01f, -1.29274085e-01f, 7.96988159e-02f, -6.63500801e-02f, -4.06152494e-02f, -1.03343166e-02f, 7.53390193e-02f, 1.31282553e-01f,
  1.58308968e-02f, -6.12700498e-03f, 2.20967345e-02f, 1.53920231e-02f, -2.50026397e-02f, -6.05850667e-02f, -9.45831537e-02f, 4.48898673e-02f, 6.50204793e-02f, -4.03293520e-02f,
  1.39218524e-01f, 2.02869847e-02f, 4.74676341e-02f, -6.93475753e-02f, -4.91922311e-02f, -6.17461689e-02f, -9.13658291e-02f, -7.37870038e-02f, -2.79976544e-03f, -9.24510807e-02f,
  1.17820799e-01f, 7.42512643e-02f, -1.17297202e-01f, -8.93387645e-02f, 5.14216395e-03f, -1.06162034e-01f, -1.54918253e-01f, -1.89885385e-02f, -7.87022188e-02f, -8.46336111e-02f,
  9.71884429e-02f, -2.17801422e-01f, 4.90389951e-02f, 8.81035253e-02f, 1.30495399e-01f, 2.61591095e-02f, -7.39544630e-02f, 9.31990817e-02f, 4.95260321e-02f, -1.65493160e-01f,
  -7.82005116e-02f, 1.47054613e-01f, 1.60874590e-01f, -1.68197885e-01f, 5.55615686e-02f, -1.06947184e-01f, -1.27947077e-01f, -7.44331032e-02f, -9.83483642e-02f, -4.57275845e-02f,
  3.93346623e-02f, 5.92635497e-02f, 1.53427929e-01f, 1.25695735e-01f, 5.23494557e-02f, -7.57820383e-02f, -9.77494195e-02f, -2.45405268e-02f, 9.93123055e-02f, 2.37340908e-02f,
  -6.12235069e-02f, -1.11393839e-01f, -5.16221039e-02f, -8.88513848e-02f, -5.60348928e-02f, 1.06178388e-01f, 4.61718626e-02f, 1.01476461e-01f, 1.03574365e-01f, 2.87339166e-02f,
  1.06696919e-01f, -1.15312010e-01f, 8.50773603e-02f, 4.90242019e-02f, 1.83877841e-01f, 6.58675581e-02f, 6.14667684e-02f, 4.11839709e-02f, -1.70876328e-02f, 1.39196202e-01f,
  1.38151988e-01f, 1.18324995e-01f, 1.15418613e-01f, -1.28366008e-01f, 4.47849855e-02f, -2.05151975e-01f, 9.52192768e-02f, 2.54350416e-02f, 3.88840288e-02f, -5.54262586e-02f,
  -4.36976254e-02f, -6.30607605e-02f, 5.32300845e-02f, 6.14875183e-03f, 1.49815068e-01f, 2.89189606e-03f, 8.35623816e-02f, 6.06961399e-02f, 7.36691058e-02f, -1.13853160e-02f,
  -1.47768751e-01f, -7.23691508e-02f, -1.66989714e-01f, 1.24561749e-01f, -2.48289928e-02f, -5.90723045e-02f, -1.45028710e-01f, -2.22291742e-02f, -8.33042040e-02f, -2.74654865e-01f,
  1.00394435e-01f, -1.43217787e-01f, 9.92218927e-02f, 1.00918189e-02f, 5.24857566e-02f, -6.09823056e-02f, 3.98181342e-02f, -7.42515028e-02f, 7.89299682e-02f, 1.41877130e-01f,
  4.07340415e-02f, 1.07574157e-01f, -1.36243790e-01f, -8.91794339e-02f, 7.90408477e-02f, -1.41517505e-01f, -1.16582736e-01f, 6.07124083e-02f, -7.98890144e-02f, -1.55961901e-01f,
  5.03244475e-02f, -7.06474483e-02f, -7.61608779e-02f, -9.82414037e-02f, -1.06531337e-01f, 1.33504737e-02f, -1.17276929e-01f, -8.07332471e-02f, 9.16604549e-02f, 9.31660309e-02f,
  -1.55761734e-01f, -1.07632577e-01f, 5.70628196e-02f, -1.29937306e-01f, -1.62740648e-01f, -7.85677433e-02f, 7.00784475e-02f, -3.56061943e-02f, -1.05344824e-01f, -3.21210995e-02f,
  9.38555300e-02f, -4.44354974e-02f, 1.28322504e-02f, 1.03265367e-01f, -1.71040669e-01f, -1.22489706e-01f, -1.42525816e-02f, -1.56108871e-01f, -7.23765269e-02f, -4.47280779e-02f,
  -6.20923098e-03f, 1.39169572e-02f, -2.53017806e-02f, -1.81320850e-02f, -8.38131085e-02f, 1.27045870e-01f, -4.50714305e-02f, 7.79003352e-02f, 1.02365725e-02f, 6.53798953e-02f,
  -1.22977223e-03f, -1.18956700e-01f, 4.94945981e-03f, -1.08361123e-02f, -1.33946627e-01f, 1.45003632e-01f, 7.18555599e-02f, -7.78549165e-02f, -4.47137356e-02f, 1.49868384e-01f,
  1.08682089e-01f, -1.78756222e-01f, -1.35860875e-01f, -5.90310320e-02f, -7.87769333e-02f, -7.99115747e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 64)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 64;
const float L3_fan_Wp_bar_data[] = {
  1.57719418e-01f, 5.71538135e-02f, 3.52033861e-02f, 1.97913259e-01f, 7.80977383e-02f, 2.30962425e-01f, 1.50667608e-01f, 1.86776578e-01f, 1.34308577e-01f, -1.55374810e-01f,
  -1.73457742e-01f, 1.78104162e-01f, -1.01591714e-01f, 2.32086241e-01f, 2.04015560e-02f, -1.35168061e-01f, -3.87549214e-02f, -3.58134098e-02f, 1.72021627e-01f, 1.45467803e-01f,
  2.78510034e-01f, 1.35864660e-01f, -1.06909014e-02f, 2.86733866e-01f, -8.92850384e-02f, -2.29281396e-01f, -2.43857607e-01f, 3.25058997e-02f, -1.34396732e-01f, -1.37769371e-01f,
  1.44305706e-01f, -3.75961244e-01f, -1.10183991e-02f, -3.76296133e-01f, -1.99446484e-01f, -3.27400059e-01f, 7.75651634e-02f, -2.38774400e-02f, 8.83031636e-02f, -1.02601908e-01f,
  -5.49827926e-02f, -6.47392273e-02f, -1.34081572e-01f, 1.33996651e-01f, 1.29528597e-01f, -6.49698125e-03f, -3.92634645e-02f, 1.24155715e-01f, 1.54264286e-01f, 3.92731801e-02f,
  2.53927320e-01f, -4.90107596e-01f, 6.57139122e-02f, -8.45575333e-02f, 2.68329605e-02f, -1.96524449e-02f, 8.20523649e-02f, -4.87917326e-02f, 5.29298410e-02f, 1.04061931e-01f,
  2.47894853e-01f, -7.07456982e-03f, 6.61756545e-02f, 1.08586952e-01f, 1.77233398e-01f, 1.55847266e-01f, 9.46062878e-02f, 2.08116084e-01f, 1.36596888e-01f, 1.93222672e-01f,
  -1.97148360e-02f, 1.74284667e-01f, 7.74412379e-02f, 2.38187388e-02f, -3.74390371e-02f, -1.30122323e-02f, -1.44844735e-02f, 1.32374495e-01f, 7.61384815e-02f, -3.85525785e-02f,
  -5.61668873e-02f, -9.24844369e-02f, 2.14602962e-01f, -1.19490698e-01f, 7.39207417e-02f, 1.03124857e-01f, -1.83656558e-01f, 9.82911140e-02f, -8.76476709e-03f, -2.36266777e-01f,
  5.60885556e-02f, -1.04201145e-01f, -3.26601475e-01f, -1.60490155e-01f, 1.06618069e-01f, -1.56979397e-01f, 9.38176140e-02f, -1.16505139e-01f, -3.10207725e-01f, 1.42573481e-02f,
  1.88907683e-01f, -2.55254686e-01f, 1.71889156e-01f, -2.29620054e-01f, 2.19857529e-01f, 1.92972779e-01f, -9.55935121e-02f, 2.54100174e-01f, 1.37126878e-01f, -2.87825525e-01f,
  -1.61128625e-01f, 3.13550174e-01f, 3.31645131e-01f, -2.59619076e-02f, 1.16197169e-01f, -6.36163354e-02f, -1.80888668e-01f, 8.57920200e-03f, 2.23773960e-02f, -9.27268043e-02f,
  -7.49497339e-02f, 3.09573978e-01f, 2.18735144e-01f, 1.04609750e-01f, 1.48594484e-01f, 6.34261444e-02f, 7.40242973e-02f, -7.74548054e-02f, 1.53031126e-01f, 4.95400243e-02f,
  1.62571315e-02f, 1.82743162e-01f, 7.48517886e-02f, 2.53489703e-01f, -1.41554829e-02f, 3.37342295e-04f, -6.76444992e-02f, 7.37737715e-02f, -1.19680241e-01f, 2.76171237e-01f,
  -8.67649540e-02f, 1.31896079e-01f, -4.02101614e-02f, -1.35335922e-01f, -6.05304949e-02f, -3.14077921e-02f, 9.08941776e-02f, -2.63728313e-02f, 2.70519882e-01f, 2.48489693e-01f,
  1.31068053e-02f, 1.32834271e-01f, 1.49573162e-01f, -2.23857999e-01f, -2.03258663e-01f, 1.47679225e-01f, -1.23795323e-01f, -5.85127398e-02f, 8.29761401e-02f, -2.14459196e-01f,
  -9.40233171e-02f, -2.32543200e-01f, -1.69453859e-01f, -1.97826982e-01f, 2.79911011e-01f, 4.41769743e-03f, 2.10575104e-01f, -1.12195268e-01f, 1.26598431e-02f, 2.22408604e-02f,
  -1.07593365e-01f, 2.17960984e-01f, 5.68482839e-02f, -1.16462901e-01f, -3.79359834e-02f, 1.76758707e-01f, 2.22791895e-01f, 5.08555360e-02f, -1.54996917e-04f, -4.75083709e-01f,
  -3.99992354e-02f, -2.77093351e-01f, 1.18590720e-01f, 1.04792066e-01f, 1.06821738e-01f, -7.42448866e-02f, 5.06959334e-02f, 1.71640113e-01f, 1.22274570e-01f, -3.84643115e-02f,
  1.01466570e-02f, 8.23525060e-03f, 8.26961994e-02f, 1.01860173e-01f, 1.54818490e-01f, 5.13386913e-02f, -4.91353087e-02f, -8.04880485e-02f, -2.00863816e-02f, -5.21420762e-02f,
  4.47514132e-02f, -1.17175626e-02f, -1.09593712e-01f, 2.11907811e-02f, 2.35127602e-02f, 1.85419753e-01f, 5.74012427e-03f, 3.03512309e-02f, 2.62281239e-01f, 1.38261244e-01f,
  4.47436906e-02f, 9.13690925e-02f, 2.00613558e-01f, -6.13305122e-02f, 2.54596919e-02f, 3.18001360e-02f, -2.16761231e-01f, -2.63394773e-01f, -2.21416727e-01f, -4.65181516e-03f,
  9.21337772e-03f, -2.95350522e-01f, -1.53044105e-01f, -3.15901726e-01f, -1.53750867e-01f, -2.42741629e-01f, -8.84091780e-02f, -3.76177639e-01f, 9.77024585e-02f, 1.16617471e-01f,
  1.55459300e-01f, 1.67141501e-02f, -1.54708549e-01f, -1.35082170e-01f, -5.56119531e-02f, 1.64608553e-01f, -1.19658962e-01f, -2.01542750e-01f, -2.38492116e-01f, 2.31978223e-01f,
  1.49211019e-01f, 6.63460419e-02f, -1.27320392e-02f, -1.46932928e-02f, 2.62828976e-01f, -8.32820088e-02f, 1.57490432e-01f, 4.91934270e-02f, -2.02617779e-01f, 2.95163095e-01f,
  1.35391995e-01f, -1.37406841e-01f, 2.16941506e-01f, 2.02904105e-01f, -1.79408178e-01f, -1.60957888e-01f, 5.87354787e-02f, 6.88534975e-02f, -5.89438789e-02f, 1.34572923e-01f,
  -3.94054689e-02f, 7.16303214e-02f, 1.74837530e-01f, 4.99663278e-02f, 1.34370536e-01f, 3.29319984e-02f, 1.30102053e-01f, 9.48294103e-02f, 8.69788602e-03f, 4.16920781e-02f,
  7.70247653e-02f, 1.17497414e-01f, 9.69889313e-02f, 1.43236354e-01f, -1.63909554e-01f, -1.01585902e-01f, -1.60273835e-01f, 5.67858033e-02f, 1.76281929e-02f, -2.37663221e-02f,
  2.21556932e-01f, 8.94716531e-02f, 2.86101907e-01f, -2.83135712e-01f, -9.51856300e-02f, 6.49367869e-02f, -5.77131622e-02f, -1.61549941e-01f, -1.21256441e-01f, 2.97715694e-01f,
  5.75237051e-02f, 2.45420113e-01f, -5.37925363e-02f, -1.57103091e-01f, 1.21269748e-01f, -3.00361076e-03f, 3.26050729e-01f, -1.47472846e-03f, 2.84911811e-01f, 2.16060817e-01f,
  -1.91412065e-02f, -2.81891763e-01f, -1.62868038e-01f, 2.53092557e-01f, 2.57957727e-01f, 2.10934639e-01f, -1.57970309e-01f, 4.65853550e-02f, 1.42379627e-01f, 5.43208234e-02f,
  -3.59585807e-02f, -2.37764686e-01f, 2.33061284e-01f, 1.80511504e-01f, 1.27513232e-02f, 2.30029777e-01f, -9.99442562e-02f, 1.71660870e-01f, -2.21490607e-01f, -3.70769091e-02f,
  1.58831161e-02f, -3.11685473e-01f, 1.79215997e-01f, 2.59148628e-01f, -5.39026335e-02f, 9.35231987e-03f, -3.03015560e-01f, 1.24116749e-01f, -8.73784795e-02f, -5.01927435e-02f,
  -2.49010205e-01f, 1.85027167e-01f, 1.12027321e-02f, -7.82423168e-02f, -2.88201541e-01f, -1.57064602e-01f, -3.98931950e-01f, 6.75441995e-02f, 6.82144910e-02f, 1.86011970e-01f,
  1.12899177e-01f, 1.27220958e-01f, -9.88351479e-02f, 3.80819917e-01f, 1.78132340e-01f, -1.09212734e-01f, -2.39268124e-01f, 3.46823841e-01f, 1.03405312e-01f, 9.93208587e-02f,
  1.99089229e-01f, -1.06606632e-01f, 9.87819359e-02f, -1.33755803e-01f, -4.78643402e-02f, -6.23705648e-02f, -1.56634018e-01f, 2.80673742e-01f, -1.16519198e-01f, -6.65436536e-02f,
  -2.52489597e-01f, 1.53249770e-01f, -6.62896633e-02f, -2.44612038e-01f, 5.99027090e-02f, 1.30313128e-01f, -9.52045619e-02f, 1.24462023e-01f, -1.47678554e-01f, -1.37071326e-01f,
  2.54416198e-01f, -4.15865928e-01f, 4.14433479e-02f, 1.24585174e-01f, 1.52879804e-01f, 1.41482875e-01f, 2.11633719e-03f, -1.79341421e-01f, -4.04049009e-02f, 1.20657943e-01f,
  1.60040379e-01f, -1.45702854e-01f, 2.25730851e-01f, 1.97206780e-01f, -1.70641214e-01f, -8.01447257e-02f, 2.02400327e-01f, -3.29316407e-03f, -3.83053422e-02f, -5.07751368e-02f,
  9.82986242e-02f, -6.54449388e-02f, -4.71577421e-02f, 1.47000616e-02f, -3.50281633e-02f, -6.03023916e-02f, -5.60989492e-02f, 1.19624473e-02f, 9.88855842e-04f, 1.75368208e-02f,
  3.21767665e-02f, 2.39209905e-02f, 8.83274823e-02f, 9.29009616e-02f, 1.00404471e-01f, 2.65575349e-02f, 1.08955853e-01f, -3.16619337e-01f, -1.41902402e-01f, 2.32176498e-01f,
  1.05082821e-02f, 2.86945581e-01f, 2.71155626e-01f, -1.42754123e-01f, -2.81708628e-01f, -1.15228757e-01f, -2.27168277e-02f, -1.65282145e-01f, 9.45359692e-02f, 1.41635165e-01f,
  -2.16482490e-01f, 1.59137771e-01f, -1.01357438e-01f, 2.33982235e-01f, -2.64390141e-01f, -2.78197765e-01f, 2.48134345e-01f, 3.57007943e-02f, -2.65216291e-01f, 7.12348288e-03f,
  1.05722748e-01f, 1.17493436e-01f, -7.53352642e-02f, 2.54422486e-01f, 6.17572740e-02f, 3.55183661e-01f, 1.96786478e-01f, -5.01659401e-02f, 3.07578556e-02f, -6.23973012e-02f,
  -1.73122540e-01f, 1.33506984e-01f, 1.37962580e-01f, -1.63730994e-01f, 2.29143441e-01f, 2.45466858e-01f, -1.50718138e-01f, -6.72775740e-03f, 1.41720045e-02f, 1.95976719e-02f,
  -3.51192541e-02f, 1.82787850e-01f, 6.26270566e-03f, -3.50673459e-02f, -1.85340300e-01f, 1.39489919e-01f, 1.51624694e-01f, -1.30142912e-01f, -9.63230059e-02f, 1.14116333e-01f,
  2.04312891e-01f, 2.07644418e-01f, 1.01379901e-01f, -1.33104071e-01f, -6.74790442e-02f, -4.80126999e-02f, 5.23362048e-02f, -2.48942733e-01f, -1.86285406e-01f, 8.83703902e-02f,
  -2.76595037e-02f, 1.00938775e-01f, 5.00622988e-02f, -1.93223879e-01f, 1.09329239e-01f, -1.58859357e-01f, -2.59880215e-01f, -3.20538670e-01f, 1.35563418e-01f, -1.48156583e-01f,
  -1.55475125e-01f, -6.22420646e-02f, -3.44093770e-01f, -9.99545678e-03f, 1.54794887e-01f, -6.68581352e-02f, 4.13979262e-01f, -3.15953881e-01f, 2.68037200e-01f, 2.20565140e-01f,
  -3.03764045e-01f, 1.75703928e-01f, 9.40948948e-02f, -1.55851901e-01f, -1.75859794e-01f, 2.22219646e-01f, 3.41650367e-01f, -3.01770449e-01f, -1.12807013e-01f, -1.63159966e-01f,
  -2.85987202e-02f, -2.21630260e-01f, 1.75963622e-02f, 1.44804031e-01f, -5.43378964e-02f, 2.34290883e-01f, 1.10844471e-01f, 2.75566936e-01f, 1.56449407e-01f, 2.03820556e-01f,
  3.86458635e-02f, 4.33176868e-02f, 1.62944749e-01f, 1.41952172e-01f, -2.69378815e-02f, 1.54041201e-01f, 3.53192277e-02f, 7.84969702e-02f, 6.69320598e-02f, 1.14638038e-01f,
  3.19027118e-02f, 3.03657264e-01f, -2.37408793e-03f, 1.50367633e-01f, -2.63266414e-02f, -2.40558013e-01f, -3.63802351e-02f, 1.73918009e-01f, -2.94897184e-02f, 2.39562348e-01f,
  1.35822266e-01f, 1.87505856e-01f, 1.47621840e-01f, 1.33130223e-01f, 1.53141111e-01f, 7.41254911e-02f, 3.30534667e-01f, -1.83994681e-01f, -1.69868544e-01f, 9.50900391e-02f,
  4.05802391e-02f, 2.31967136e-01f, 3.11303616e-01f, -5.31345494e-02f, 5.81534840e-02f, -2.42161602e-02f, 1.37214690e-01f, -2.02910185e-01f, 1.46350533e-01f, 8.59434716e-03f,
  -2.25865632e-01f, 1.11311555e-01f, -1.02302969e-01f, 2.41612136e-01f, -1.50161773e-01f, -2.95413315e-01f, 9.10997912e-02f, -4.92980257e-02f, -2.32798815e-01f, -1.05509207e-01f,
  -1.65994897e-01f, 8.23596641e-02f, 2.01451838e-01f, -3.43577802e-01f, -1.13353506e-01f, -3.21927816e-01f, 2.03879550e-01f, 3.52748521e-02f, 3.01822007e-01f, -2.48421863e-01f,
  -2.04685196e-01f, 3.01568538e-01f, 1.65238440e-01f, 4.61568385e-02f, 4.56652865e-02f, 1.12295136e-01f, 1.03456460e-01f, -2.02744156e-02f, 8.62844735e-02f, -4.16344479e-02f,
  1.43655419e-01f, -4.21494283e-02f, -2.47266397e-01f, -2.57665776e-02f, -5.44019695e-03f, -9.11155269e-02f, 1.22838840e-01f, 1.07180104e-01f, 1.71088338e-01f, -1.07195668e-01f,
  -1.89746674e-02f, 2.06194803e-01f, 2.15852872e-01f, 7.52926469e-02f, -1.38097540e-01f, 1.61057208e-02f, 1.59643009e-01f, -1.24362536e-01f, -1.64790437e-01f, -1.83825523e-01f,
  -2.49378011e-01f, -2.31769204e-01f, 1.81300148e-01f, 4.81833518e-02f, -6.16085296e-03f, -2.87164092e-01f, -7.02085346e-02f, 3.29156846e-01f, -1.52541146e-01f, 2.68636465e-01f,
  3.32343169e-02f, 1.48807056e-02f, 1.93229746e-02f, -8.34098533e-02f, 1.86554454e-02f, -1.42970145e-01f, 1.62190184e-01f, 6.92393556e-02f, -2.02698678e-01f, 2.09006101e-01f,
  2.60896266e-01f, 3.73985738e-01f, 3.63128066e-01f, 6.17204905e-02f, -1.40074700e-01f, -3.70131642e-01f, 1.40059754e-01f, -2.82943785e-01f, -2.00817939e-02f, 4.18560445e-01f,
  1.47668719e-01f, 3.02024692e-01f, -2.38889530e-01f, 1.68142915e-01f, 3.08566153e-01f, -9.88478586e-02f, 2.63501443e-02f, -8.55396912e-02f, 3.51163447e-01f, 2.66563356e-01f,
  -5.26542254e-02f, -7.87877813e-02f, -1.93006601e-02f, 2.55121976e-01f, -2.36033238e-02f, -7.19596073e-02f, -1.05932698e-01f, -9.48476736e-05f, 2.05145493e-01f, 3.38118598e-02f,
  -1.23145983e-01f, -6.78633898e-02f, 9.89482403e-02f, 1.07099816e-01f, -7.59106651e-02f, -4.61685248e-02f, -3.05048198e-01f, -2.82018960e-01f, -4.96818498e-02f, -9.33708325e-02f,
  -4.97009456e-01f, 3.12487990e-01f, -3.02959472e-01f, 5.15204184e-02f, 1.11024909e-01f, -7.00039640e-02f, 2.75946617e-01f, -2.30950192e-01f, 6.12027720e-02f, 2.54337434e-02f,
  9.48258191e-02f, 4.08801675e-01f, -1.27536189e-02f, 3.73661965e-01f, -2.38900796e-01f, 2.00056076e-01f, 3.91942151e-02f, -2.85410732e-01f, 3.88472751e-02f, 1.23153448e-01f,
  2.87187397e-01f, 2.28633448e-01f, -7.30001042e-03f, -1.08097054e-01f, 1.83137149e-01f, 2.93303221e-01f, -2.85292536e-01f, 1.13706328e-01f, -8.69221464e-02f, -3.32605615e-02f,
  1.44297898e-01f, 8.04167613e-02f, -1.62765998e-02f, -2.29014456e-01f, 5.87420724e-02f, -7.23271593e-02f, 2.76104897e-01f, 1.11627281e-01f, -2.23692358e-01f, 2.42812991e-01f,
  -3.60318959e-01f, 1.99312195e-01f, 4.51554954e-02f, 1.06624186e-01f, 1.47868991e-01f, 3.29209454e-02f, 1.05700180e-01f, 1.41335145e-01f, 2.33823761e-01f, 8.40150639e-02f,
  -2.13279635e-01f, -7.21510947e-02f, 7.44429752e-02f, -1.00308903e-01f, -4.64376621e-02f, 5.19210771e-02f, 1.39053121e-01f, -2.53250271e-01f, 2.13017657e-01f, -3.69877592e-02f,
  1.06457666e-01f, 6.66746423e-02f, -6.16945364e-02f, 1.11578815e-01f, -1.05786189e-01f, 1.41066741e-02f, 7.31722564e-02f, 2.23538280e-01f, -2.86820326e-02f, -1.90235808e-01f,
  -3.66982594e-02f, -1.29405305e-01f, 4.49923910e-02f, 7.45261312e-02f, -1.16383724e-01f, -4.31830287e-02f, -2.05525935e-01f, -4.23006564e-02f, 1.80701762e-01f, 1.43686784e-02f,
  -7.97431841e-02f, 3.65397334e-02f, 5.06403819e-02f, 9.85356346e-02f, 1.17358819e-01f, 1.55848861e-01f, 7.75663778e-02f, -3.40417325e-02f, -2.11478248e-02f, 2.66782969e-01f,
  -3.44142139e-01f, -8.39407891e-02f, 5.87004386e-02f, -2.36491151e-02f, 1.86522782e-01f, -1.27379283e-01f, -6.59680888e-02f, 1.99384391e-01f, 1.19973741e-01f, -1.57755706e-02f,
  -3.36757228e-02f, 1.33090243e-01f, -2.31788114e-01f, -9.45714675e-03f, 1.10729791e-01f, -6.82276413e-02f, 1.16272837e-01f, 2.23992258e-01f, 1.68874994e-01f, 1.28045738e-01f,
  -2.25723207e-01f, 6.26297519e-02f, 8.40552058e-03f, -1.33465186e-01f, 8.64917878e-03f, -3.01971268e-02f, 1.92667514e-01f, 8.29373673e-02f, 9.41880867e-02f, -7.88810477e-02f,
  4.18973062e-03f, -5.02848811e-02f, 4.51436415e-02f, 1.09993480e-01f, 1.68719053e-01f, -1.16314739e-02f, -8.89851898e-02f, -1.86940849e-01f, -2.57237911e-01f, 1.76257521e-01f,
  -1.18748918e-01f, 8.56310055e-02f, 2.14741141e-01f, 5.16575715e-03f, 1.41563326e-01f, -2.90673465e-01f, 2.19631884e-02f, 3.62847596e-02f, 2.76414752e-01f, 2.54296958e-01f,
  6.17655255e-02f, 2.27645576e-01f, -5.27322700e-04f, 2.43490204e-01f, 1.14579931e-01f, -8.89212415e-02f, -3.86723387e-03f, 7.87447095e-02f, 1.81893021e-01f, 2.90657401e-01f,
  -1.15178034e-01f, 7.19796345e-02f, 1.79403678e-01f, 9.25560966e-02f, -4.03784076e-03f, -1.20888233e-01f, -1.14515632e-01f, 6.94903061e-02f, 3.42612453e-02f, -4.12365288e-01f,
  -2.39352852e-01f, -2.66310990e-01f, -1.11386776e-01f, 1.09042473e-01f, 1.60048425e-01f, 3.80900614e-02f, -9.72442031e-02f, 2.79363632e-01f, -3.15891117e-01f, 1.24271847e-01f,
  2.34731153e-01f, 1.53077379e-01f, -1.22487014e-02f, -1.58640891e-01f, 9.73753259e-02f, -1.20097347e-01f, -2.18258008e-01f, -6.78867921e-02f, -3.48379225e-01f, -1.56668678e-01f,
  1.14585824e-01f, -2.52763629e-01f, 1.28469802e-02f, -7.96506256e-02f, 1.21514767e-01f, 1.49397710e-02f, 4.52619344e-02f, -1.47928894e-01f, -4.62409370e-02f, -4.28156741e-02f,
  -2.07512364e-01f, -4.23944276e-03f, -1.81293096e-02f, 1.01143904e-01f, 3.98455895e-02f, 1.81557149e-01f, 1.79420367e-01f, -2.31782034e-01f, 3.21494117e-02f, -2.07452103e-01f,
  1.63310468e-01f, -2.28099987e-01f, 8.73841569e-02f, 8.06971788e-02f, -2.69213140e-01f, 1.09255858e-01f, 6.51361495e-02f, 1.23130031e-01f, 2.84865219e-03f, 3.42912316e-01f,
  2.73266472e-02f, 7.83725269e-03f, 9.22129378e-02f, 2.53175944e-01f, -2.48594433e-01f, -1.18905619e-01f, -8.54028165e-02f, 3.35919052e-01f, -1.22572310e-01f, 1.40018344e-01f,
  -5.89963309e-02f, -2.38236934e-02f, -4.98172157e-02f, -1.74150735e-01f, 1.94721207e-01f, 7.13672349e-03f, 2.24826381e-01f, 7.93786496e-02f, -9.58826467e-02f, 1.23071730e-01f,
  -1.63711131e-01f, 4.39287303e-03f, -1.15461349e-01f, -1.45000154e-02f, 1.37438893e-01f, 1.18073151e-01f, 6.04894198e-02f, 1.80735826e-01f, 7.15234652e-02f, 2.05145344e-01f,
  -1.07457861e-01f, 9.22826752e-02f, 7.17127547e-02f, 7.85369202e-02f, 2.59959251e-02f, -5.63422814e-02f, 3.15321460e-02f, -2.41188686e-02f, 1.13624655e-01f, -2.72929948e-02f,
  8.59025642e-02f, -2.71927193e-02f, -4.50352859e-03f, 6.61290959e-02f, -1.16331160e-01f, 3.93520226e-04f, -8.11472684e-02f, 3.54496911e-02f, 2.30012223e-01f, -1.10804543e-01f,
  -1.66062281e-01f, 2.13149831e-01f, 1.49348546e-02f, 6.29763911e-03f, -7.02361250e-03f, 1.79767415e-01f, -8.65516216e-02f, 3.86530794e-02f, -1.48648443e-02f, 2.63094474e-02f,
  8.83034170e-02f, 1.30189121e-01f, -5.64975245e-03f, -3.92593294e-02f, 2.85787821e-01f, 2.31520504e-01f, 1.94258302e-01f, -9.44823623e-02f, 4.23584729e-01f, -6.58741668e-02f,
  1.43151404e-02f, 2.13061690e-01f, -2.33194038e-01f, 1.07943766e-01f, 1.75924733e-01f, 3.55962336e-01f, 1.48685947e-02f, 3.73606384e-01f, 3.45901877e-01f, -2.73466446e-02f,
  4.91707679e-03f, -6.25771880e-02f, 6.36660755e-02f, 2.59567231e-01f, -1.31876236e-02f, 1.11278981e-01f, 1.98246781e-02f, 1.71706393e-01f, -1.69632539e-01f, -9.76007208e-02f,
  1.61878049e-01f, -1.00874035e-02f, -5.02525605e-02f, 2.07661875e-02f, 4.71169688e-02f, 8.19781125e-02f, 1.04861982e-01f, 1.67261735e-01f, -1.30074918e-02f, 7.96782225e-02f,
  1.25929773e-01f, 1.11683749e-01f, -3.21663055e-03f, -3.82487662e-02f, 7.27108717e-02f, 1.74056560e-01f, 2.01464016e-02f, 1.21211305e-01f, 2.12036878e-01f, 7.79658109e-02f,
  6.32568374e-02f, 1.78085625e-01f, 8.85861292e-02f, 2.34387983e-02f, 1.27377748e-01f, -2.26357415e-01f, -8.66946280e-02f, 1.61795244e-01f, -2.55964905e-01f, -4.00094613e-02f,
  6.82726037e-03f, -3.12807225e-02f, 2.27184683e-01f, -1.38326660e-01f, -1.50785878e-01f, -1.63518384e-01f, 1.47342294e-01f, -2.09000826e-01f, -7.58568645e-02f, 6.36390448e-02f,
  3.35021019e-02f, 2.77290255e-01f, -2.10085288e-01f, -5.98999187e-02f, 2.91586041e-01f, -1.15173116e-01f, -4.81334329e-02f, 4.94266488e-02f, 1.80355385e-02f, -1.08819783e-01f,
  4.39163372e-02f, -3.74395818e-01f, -1.24018185e-01f, -1.16766036e-01f, 9.98184904e-02f, 2.86405116e-01f, 8.36050436e-02f, 2.22569425e-03f, 2.19944388e-01f, 2.27531925e-01f,
  -4.95766988e-04f, 8.37720484e-02f, 3.11217874e-01f, 1.66937128e-01f, 7.95971304e-02f, -3.47100832e-02f, 9.22742933e-02f, -6.44241795e-02f, -1.66741356e-01f, -1.11869767e-01f,
  2.23747015e-01f, -1.47442315e-02f, 1.83688879e-01f, -4.85078432e-03f, 1.56574532e-01f, 1.31118581e-01f, 2.77148895e-02f, -1.80725589e-01f, -1.72218997e-02f, 2.15646578e-03f,
  2.02364042e-01f, 6.91545010e-02f, -1.97198279e-02f, 1.45703867e-01f, 1.89878628e-01f, -2.77008936e-02f, -1.77734867e-02f, -2.92376071e-01f, -5.37520833e-03f, 5.45725301e-02f,
  6.21986091e-02f, 3.05888951e-01f, 2.22432584e-01f, 1.24731101e-01f, -1.77582726e-01f, -8.10522437e-02f, 1.89684089e-02f, 4.16138545e-02f, 1.26952738e-01f, 1.16752781e-01f,
  -3.23961765e-01f, -2.47511715e-02f, -9.48436782e-02f, 4.27395016e-01f, -1.41497895e-01f, -1.92383870e-01f, 4.31799501e-01f, 4.72995415e-02f, 1.76226705e-01f, 2.12654367e-01f,
  5.88699318e-02f, 1.03642695e-01f, 2.17548043e-01f, 3.98349643e-01f, 1.68073195e-04f, 2.69864887e-01f, 3.87696594e-01f, -1.10576093e-01f, 3.60780507e-02f, -3.25706154e-02f,
  2.13260308e-01f, 7.00030103e-02f, -1.15044843e-02f, -1.96980104e-01f, 1.34199575e-01f, 2.04709068e-01f, -1.72144234e-01f, 1.05207577e-01f, -6.82889000e-02f, 1.23263545e-01f,
  1.41744642e-02f, 7.29170516e-02f, 5.90361133e-02f, 1.26488551e-01f, 1.86605439e-01f, 7.18943551e-02f, 1.13078013e-01f, 2.00657919e-01f, 1.37987826e-02f, 1.92627590e-02f,
  -1.04026303e-01f, -2.34551176e-01f, -2.80083250e-02f, 9.83069837e-03f, 8.29169154e-03f, -1.15240766e-02f, 1.64490908e-01f, 2.18706429e-01f, 5.63175902e-02f, 6.08702330e-03f,
  1.25569969e-01f, -5.45444377e-02f, 1.77265659e-01f, 4.42243367e-03f, -1.42240778e-01f, 2.81788647e-01f, -6.19569868e-02f, 1.18434876e-01f, 6.55588508e-02f, -1.73063412e-01f,
  2.80179501e-01f, 9.17758867e-02f, 2.57502794e-01f, 9.13352743e-02f, -2.21942782e-01f, 3.76539975e-02f, -3.73427719e-01f, 2.69770056e-01f, -4.16891240e-02f, -1.42051885e-02f,
  2.43375748e-01f, -3.33581567e-01f, 1.91818938e-01f, 1.29309580e-01f, -4.64382507e-02f, -7.48990625e-02f, -4.31405939e-03f, 1.63051307e-01f, 2.93092817e-01f, 2.03134388e-01f,
  -2.06617936e-02f, -1.37065619e-01f, 2.36738384e-01f, 1.46191761e-01f, 2.74281323e-01f, -3.32991809e-01f, -9.81520489e-02f, 2.11252302e-01f, 2.20663339e-01f, 7.35006779e-02f,
  2.04044133e-01f, 4.02820706e-02f, 1.02382667e-01f, 2.68900782e-01f, 5.90864196e-02f, -1.70748532e-02f, 2.83935249e-01f, 1.58404306e-01f, -5.16689057e-03f, -1.15091596e-02f,
  6.95067793e-02f, 9.02894512e-02f, 4.09087986e-02f, 1.16855972e-01f, 1.01458393e-01f, -9.79804844e-02f, 2.75460660e-01f, 1.21490605e-01f, 2.19237372e-01f, 1.98895112e-01f,
  1.40718907e-01f, -1.21455872e-02f, 3.14665198e-01f, 2.87836641e-01f, 4.19692516e-01f, 1.12591796e-01f, -4.56005260e-02f, -2.30129495e-01f, -2.80082732e-01f, -1.20805018e-01f,
  4.29694653e-02f, -2.32928678e-01f, 4.62796167e-02f, -3.77989620e-01f, 8.02751556e-02f, -4.43114907e-01f, 2.52038062e-01f, -1.86902955e-01f, 2.75453418e-01f, 1.41128495e-01f,
  -2.02128351e-01f, 1.10434234e-01f, 5.08509874e-02f, 1.56482816e-01f, -9.20236185e-02f, -2.27908328e-01f, -5.04264049e-02f, -6.68453723e-02f, -1.52162164e-01f, 9.02623683e-02f,
  1.30708948e-01f, 2.74751391e-02f, 1.12021536e-01f, -3.09962481e-02f, 2.29285240e-01f, -2.16949046e-01f, 3.07791114e-01f, 6.98250011e-02f, 1.15784556e-01f, -6.73865434e-03f,
  -6.35880232e-02f, -5.78355640e-02f, 3.29031765e-01f, 2.42537513e-01f, -6.90754652e-02f, -5.42357191e-03f, 3.73165943e-02f, 2.14126050e-01f, -6.58267587e-02f, 3.61256339e-02f,
  2.23933503e-01f, 9.29486752e-02f, 2.93387473e-01f, 2.64945120e-01f, 9.62716490e-02f, 1.10014111e-01f, 1.68206654e-02f, 2.34702110e-01f, -1.23690907e-02f, 1.64515570e-01f,
  1.50460184e-01f, 7.65012056e-02f, 1.35318443e-01f, 1.37833729e-01f, 7.48131284e-03f, -5.00881933e-02f, 4.24061343e-02f, -1.28241494e-01f, -3.62892784e-02f, 2.15537418e-02f,
  8.00543502e-02f, -1.05827227e-01f, 1.38021663e-01f, -5.40728383e-02f, -2.64000893e-01f, -2.36290336e-01f, -4.33660746e-02f, -1.44874573e-01f, -1.90635681e-01f, -3.99026126e-02f,
  -1.54803440e-01f, -1.66760311e-02f, 1.42097548e-01f, -1.47328570e-01f, 3.17893595e-01f, -2.89698876e-02f, 1.51583239e-01f, 1.18613131e-02f, 1.67970970e-01f, 3.63906175e-01f,
  2.19300434e-01f, -3.30090284e-01f, 1.01987630e-01f, 1.97035372e-01f, 3.98807049e-01f, -2.29935497e-02f, -4.93404455e-02f, -3.81799489e-01f, -6.73456714e-02f, 1.22058928e-01f,
  -4.26128972e-03f, -2.57558852e-01f, 2.05736943e-02f, 2.94167399e-01f, 3.21398973e-01f, 1.97488606e-01f, 3.66332680e-02f, 7.57710487e-02f, -1.96204777e-03f, -1.67690769e-01f,
  1.01901196e-01f, 2.06634596e-01f, -2.16523595e-02f, -4.94869053e-02f, 1.81065444e-02f, 1.43861443e-01f, 1.89552546e-01f, 6.55072406e-02f, 4.85003032e-02f, 7.91641548e-02f,
  1.59799188e-01f, 1.15613446e-01f, 1.33669868e-01f, 8.05941150e-02f, 2.64933079e-01f, 1.87541395e-01f, 3.17658216e-01f, 2.73722917e-01f, 3.82480919e-02f, 3.43944319e-02f,
  2.43930459e-01f, 7.56450370e-02f, 2.46683627e-01f, -9.98126790e-02f, -9.37650204e-02f, 6.92773908e-02f, -1.79679677e-01f, -1.06225200e-01f, -1.79209635e-01f, -8.16405490e-02f,
  -1.41525403e-01f, -1.16493195e-01f, -6.34745955e-02f, -2.60229677e-01f, 2.95926575e-02f, -9.03402418e-02f, 2.41192281e-01f, -1.72087476e-01f, 1.63281128e-01f, 2.07590640e-01f,
  2.17914190e-02f, -1.34558663e-01f, 1.89883158e-01f, -5.98273650e-02f, -1.74805149e-01f, -1.66808367e-01f, -2.29744032e-01f, 1.51526913e-01f, 2.62954295e-01f, 2.60270387e-01f,
  6.19426295e-02f, 2.12103724e-01f, 3.69714975e-01f, -5.90832625e-03f, 2.26694718e-01f, -1.19598150e-01f, 3.78281884e-02f, 5.48821762e-02f, 7.91964456e-02f, -1.04770362e-01f,
  1.27117917e-01f, 3.03328931e-01f, -2.66499162e-01f, -7.68263936e-02f, 1.20875835e-01f, 5.21374531e-02f, -9.87987891e-02f, 8.68043825e-02f, -7.45544881e-02f, -1.14542350e-01f,
  3.46846022e-02f, -3.06347106e-02f, -8.16778839e-02f, 1.91824928e-01f, 1.25784904e-01f, 9.44379792e-02f, 1.07674059e-02f, -7.16137961e-02f, 8.36876109e-02f, 2.37001833e-02f,
  6.29441738e-02f, 1.56807423e-01f, -3.57524003e-03f, -1.10204950e-01f, -3.13520506e-02f, 5.29891625e-02f, -1.45643905e-01f, 5.05559519e-02f, 2.89523005e-01f, 3.45126167e-02f,
  2.10422203e-01f, -5.53296730e-02f, -1.54674947e-01f, 5.75234219e-02f, 2.97765851e-01f, 2.23716602e-01f, 1.46126583e-01f, 2.60433584e-01f, -2.08238121e-02f, 9.57252234e-02f,
  1.07738294e-01f, -1.48241177e-01f, -1.08159304e-01f, 1.84722664e-03f, 2.40712032e-01f, 3.04395050e-01f, -4.11107130e-02f, -4.31178184e-03f, 1.87938929e-01f, -9.50282323e-04f,
  4.17841822e-01f, 1.14182429e-02f, -1.65358260e-01f, 1.48012424e-02f, 1.47062257e-01f, -2.11817279e-01f, -2.04260558e-01f, -1.24409929e-01f, 5.96657209e-02f, 2.08099112e-01f,
  2.94879287e-01f, -2.82472447e-02f, -4.33744714e-02f, 3.50918949e-01f, -1.16043963e-01f, -2.03957409e-03f, 2.82574534e-01f, 1.58644214e-01f, -1.81015730e-02f, -9.92019325e-02f,
  9.89106745e-02f, -3.90683301e-03f, -1.06524311e-01f, 1.30104259e-01f, -3.28288645e-01f, -5.38558103e-02f, -2.23100148e-02f, 1.48961887e-01f, 2.27107462e-02f, 4.72331829e-02f,
  7.41846934e-02f, -6.14274591e-02f, -1.48158729e-01f, 9.87998471e-02f, -7.32820109e-03f, 1.31273523e-01f, 1.86922461e-01f, 2.42144778e-01f, 2.30810732e-01f, -3.18220198e-01f,
  -2.90326849e-02f, 3.97411846e-02f, -2.65068918e-01f, 1.66148823e-02f, -3.27881396e-01f, 2.02558622e-01f, 6.66803047e-02f, -2.57306248e-01f, -6.95802122e-02f, -1.32478535e-01f,
  1.76476151e-01f, -3.25251341e-01f, 1.32189929e-01f, -2.11570039e-01f, -3.29152830e-02f, 2.54164100e-01f, -2.76859254e-02f, -4.23195586e-02f, -1.33031666e-01f, -4.74859849e-02f,
  -2.24319294e-01f, 1.45469487e-01f, 1.72237277e-01f, 1.39045060e-01f, 2.27499738e-01f, 1.62321910e-01f, -1.71305202e-02f, -1.07162900e-01f, 6.53205439e-02f, 1.66278005e-01f,
  8.37966129e-02f, 2.43775740e-01f, 2.24452227e-01f, 3.83827329e-01f, -1.70912951e-01f, -7.60961697e-02f, 3.19109946e-01f, -7.77179748e-02f, 1.39055118e-01f, 4.49560918e-02f,
  9.64157060e-02f, 2.26324484e-01f, 3.75863910e-02f, -7.72530660e-02f, 2.01468300e-02f, 3.27854715e-02f, -1.24006897e-01f, -4.66799401e-02f, 1.99843809e-01f, 1.39037874e-02f,
  -1.36265695e-01f, 5.82656339e-02f, 8.25491920e-03f, 1.33336037e-01f, -9.82905924e-02f, -1.44972622e-01f, -6.99613169e-02f, -9.27405730e-02f, 1.69284176e-02f, 9.70685557e-02f,
  -3.41648281e-01f, -7.95633122e-02f, -2.62393534e-01f, -2.35752359e-01f, -3.64060491e-01f, 6.91008642e-02f, 6.39570877e-03f, 9.31792706e-03f, 1.61550060e-01f, 1.00321658e-01f,
  1.28808608e-02f, 7.77889490e-02f, 8.06612149e-02f, 3.03284496e-01f, -7.70585239e-02f, 4.30022955e-01f, -1.05410181e-01f, 3.17075640e-01f, -2.49120250e-01f, -5.81068397e-02f,
  1.12693608e-01f, 1.23348586e-01f, 1.54834360e-01f, 5.91619872e-02f, 3.38268161e-01f, 3.25723886e-01f, 2.03064770e-01f, 8.49836394e-02f, 4.58645195e-01f, 4.08902429e-02f,
  1.17159672e-01f, 4.82116863e-02f, 7.77461305e-02f, 2.56365210e-01f, -3.49252559e-02f, 4.75981891e-01f, -7.06088245e-02f, -2.08438709e-01f, 2.00167209e-01f, 1.59384042e-01f,
  2.78410882e-01f, -6.96880557e-03f, -1.92587063e-01f, -7.70939747e-03f, 7.50652328e-02f, 1.68802962e-01f, 6.57869056e-02f, 1.53938517e-01f, 1.33576095e-01f, 2.99560502e-02f,
  -1.40004354e-02f, -3.46686281e-02f, 2.23178715e-01f, 1.26486123e-01f, 6.56902418e-02f, -1.32559121e-01f, 3.42492238e-02f, 7.09539428e-02f, 1.88989893e-01f, -1.38654992e-01f,
  2.29692087e-02f, -1.13477455e-02f, 1.48943424e-01f, 1.36804745e-01f, 1.42074555e-01f, 2.51662314e-01f, 1.39578655e-01f, 2.66003966e-01f, 1.61113262e-01f, -7.80144781e-02f,
  -5.97327948e-02f, 1.77521795e-01f, -4.32192944e-02f, 1.58499092e-01f, 2.33140439e-01f, -1.67570319e-02f, -1.20609544e-01f, -2.45790675e-01f, -7.92925805e-03f, -8.01573992e-02f,
  1.47592425e-01f, 1.12450123e-01f, -9.81981829e-02f, 9.65486541e-02f, -1.43403234e-02f, 3.33345652e-01f, -7.68145323e-02f, -7.22001791e-02f, 2.19861418e-01f, -2.23432094e-01f,
  -9.92116705e-02f, 3.60621750e-01f, -1.77511424e-01f, 6.52649254e-02f, -3.24971303e-02f, 3.91207486e-01f, 1.52053103e-01f, 3.10506850e-01f, 2.50457764e-01f, -2.62881219e-01f,
  1.03779152e-01f, -4.39561680e-02f, 1.20115556e-01f, -5.24073951e-02f, -2.49705866e-01f, 7.36056715e-02f, 3.79038304e-02f, 3.11116189e-01f, -1.35450780e-01f, 1.20208375e-01f,
  7.19573423e-02f, 1.07247412e-01f, 7.24910870e-02f, 1.77772090e-01f, 3.05061340e-01f, 3.10394585e-01f, 9.93326455e-02f, 1.75620258e-01f, 1.29462823e-01f, 1.67122241e-02f,
  -5.42447418e-02f, 5.45143969e-02f, -9.79614183e-02f, -4.36210539e-03f, 1.29241511e-01f, -1.19256720e-01f, -2.02313945e-01f, 7.12616816e-02f, 1.17339559e-01f, 5.40363044e-02f,
  -6.39756694e-02f, 2.28432283e-01f, 2.14629188e-01f, 1.31407753e-01f, 6.40717968e-02f, -8.43238831e-02f, -6.87283352e-02f, 9.10846964e-02f, -7.42027210e-03f, 3.81691098e-01f,
  1.46797985e-01f, -2.18185466e-02f, 1.02718703e-01f, -1.38063133e-01f, -8.92014429e-02f, -3.95923704e-02f, -5.11959828e-02f, -2.05490530e-01f, -9.74243879e-02f, -3.87748629e-02f,
  1.04143277e-01f, -1.19971067e-01f, 1.60921603e-01f, -8.10763687e-02f, 8.11518133e-02f, -2.00308301e-02f, -8.85434300e-02f, 4.29658629e-02f, 8.75740275e-02f, 2.77343579e-03f,
  1.30848199e-01f, -2.21266262e-02f, -1.16575658e-01f, -7.33401030e-02f, 1.79104835e-01f, -1.96026087e-01f, 1.51872694e-01f, -1.59039013e-02f, -8.21570754e-02f, 1.13850683e-01f,
  1.86866477e-01f, -1.71687994e-02f, -8.36274922e-02f, 1.30517378e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  1.72562599e-01f, 8.26511905e-02f, 1.32116571e-01f, 7.28211459e-03f, -1.04865208e-01f, 4.01967671e-04f, 1.27372891e-01f, 2.97914036e-02f, 1.11931942e-01f, 8.17946792e-02f,
  1.90254256e-01f, -8.75042751e-02f, 1.55692309e-01f, 1.38619959e-01f, 2.74730958e-02f, 1.04884043e-01f, 5.05972132e-02f, 7.02127218e-02f, 1.29474714e-01f, 1.89591885e-01f,
  1.59589618e-01f, -2.05042232e-02f, -4.90901507e-02f, 1.38607904e-01f, 4.55871187e-02f, 1.64709210e-01f
};

// L4_linear_W (Shape: 12 x 64)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 64;
const float L4_linear_W_data[] = {
  -1.45541489e-01f, 1.71902195e-01f, -7.33234882e-02f, 1.34682193e-01f, -1.12442762e-01f, 2.54234076e-01f, 1.61668047e-01f, 1.23092525e-01f, -1.38681710e-01f, 7.56197348e-02f,
  -4.03690040e-02f, 1.76546127e-01f, 3.86185385e-02f, 1.12644948e-01f, 2.47909315e-02f, -3.25230397e-02f, -1.34143591e-01f, 6.68957904e-02f, -8.39343369e-02f, -2.00902700e-01f,
  2.51648456e-01f, 8.88992101e-02f, -8.99950415e-02f, -2.68928885e-01f, 2.80703232e-03f, -1.16143294e-01f, -4.00732011e-02f, -4.52767275e-02f, 1.09654300e-01f, -6.15681745e-02f,
  -3.57087880e-01f, -8.39207992e-02f, 4.58001383e-02f, -9.97926891e-02f, 1.93849519e-01f, 1.94283292e-01f, -2.35425726e-01f, -2.30202954e-02f, 2.31978446e-01f, 2.38684341e-01f,
  2.76961088e-01f, -9.45888832e-03f, -3.02621424e-01f, 2.45211542e-01f, -1.47924602e-01f, 1.79719582e-01f, 5.26807718e-02f, -1.80276096e-01f, -3.69748026e-02f, -1.66352242e-01f,
  -1.50727525e-01f, -2.09230229e-01f, -4.16110635e-01f, 1.31239742e-01f, -3.72931570e-01f, 8.38375241e-02f, 1.18147926e-02f, -4.96083312e-02f, -3.14492226e-01f, 1.38896294e-02f,
  1.51624203e-01f, -2.64249653e-01f, -3.86613518e-01f, 1.44028902e-01f, 1.11875527e-01f, -4.64532599e-02f, 1.76900908e-01f, -9.87730622e-02f, 6.09763935e-02f, 6.65314794e-02f,
  1.10596366e-01f, 9.43249837e-02f, 5.99614903e-02f, 2.95071509e-02f, -1.14133574e-01f, 2.71812938e-02f, -9.12361220e-02f, 6.06377311e-02f, 1.80829018e-02f, -2.94906981e-02f,
  -5.77424765e-02f, 1.22428589e-01f, 7.20628425e-02f, -1.88244805e-01f, -1.72455743e-01f, -8.58842134e-02f, 7.54628032e-02f, -1.01811767e-01f, 1.72116339e-01f, 1.45473018e-01f,
  2.82550603e-01f, -1.85671464e-01f, -2.20932752e-01f, -2.95618139e-02f, -1.68570608e-01f, 2.15364560e-01f, 4.71063368e-02f, 3.84311890e-03f, -1.24030650e-01f, 7.06162304e-02f,
  3.37683484e-02f, -8.68312642e-02f, 2.15485275e-01f, 2.50939488e-01f, 1.67601883e-01f, 2.86595553e-01f, 3.23713794e-02f, -3.31750602e-01f, -1.67926908e-01f, 1.81310192e-01f,
  -2.83097953e-01f, -3.45898755e-02f, -7.88693354e-02f, -1.18119095e-03f, -1.36671454e-01f, -2.13760436e-01f, 5.48138581e-02f, -1.29649388e-02f, -1.76066190e-01f, -3.94492239e-01f,
  9.10453722e-02f, 2.05955029e-01f, 2.70259380e-01f, -2.77240753e-01f, -1.75315872e-01f, -2.96874762e-01f, -7.85812289e-02f, 6.40796721e-02f, 5.97658055e-03f, 1.03856377e-01f,
  3.34472628e-03f, -2.41432060e-03f, -1.14959858e-01f, 1.16760153e-02f, -1.28986472e-02f, -2.86988318e-02f, 1.16274012e-02f, -1.14248164e-01f, 1.27777949e-01f, -3.83005738e-02f,
  -1.03313312e-01f, -1.66004702e-01f, 1.12024091e-01f, 3.61160822e-02f, -1.47803407e-02f, -5.10516167e-02f, 1.27878830e-01f, 1.74821854e-01f, 1.92810565e-01f, 1.80433556e-01f,
  -1.10010475e-01f, -1.26844212e-01f, 4.57192808e-02f, 7.31778219e-02f, 6.88859299e-02f, 1.66355148e-01f, -6.97423443e-02f, -1.24145128e-01f, -6.19489849e-02f, -1.14234336e-01f,
  -1.07300375e-02f, -1.79890320e-01f, -1.21947847e-01f, 1.77466094e-01f, -1.86984122e-01f, -5.31185307e-02f, -3.03008437e-01f, 7.91267753e-02f, -2.96428263e-01f, 2.07683578e-01f,
  2.33682796e-01f, 1.59296319e-02f, 1.55205891e-01f, -1.14035197e-02f, -1.71997905e-01f, -5.22780120e-02f, -2.51443475e-01f, -1.04543470e-01f, -2.37011865e-01f, -1.83614194e-01f,
  1.92153633e-01f, -3.83284271e-01f, 1.94353342e-01f, -3.83201331e-01f, -3.22719395e-01f, 5.79756536e-02f, 2.16171309e-01f, -2.51889557e-01f, 4.48193960e-02f, 1.67321861e-01f,
  -1.30012780e-01f, -2.76819348e-01f, 5.92226386e-02f, -8.52819309e-02f, -8.93390104e-02f, -1.59390017e-01f, -1.14687271e-01f, 1.06109388e-01f, -1.93287190e-02f, -1.73378557e-01f,
  3.19480225e-02f, -6.69091418e-02f, -1.30312100e-01f, -1.13435887e-01f, -8.65114182e-02f, -8.25622305e-02f, 5.82610331e-02f, -9.66189802e-02f, 9.09918174e-02f, -2.39896309e-02f,
  -5.77029400e-02f, -2.56945193e-01f, 6.32558390e-02f, 6.52954653e-02f, -1.18648060e-01f, 1.66611105e-01f, -6.00164570e-02f, 1.64221287e-01f, -1.31795034e-01f, 2.03750223e-01f,
  1.14218257e-01f, -1.49238408e-01f, 1.86164379e-01f, 3.22558684e-03f, 2.18421474e-01f, 2.02066526e-01f, 2.21816644e-01f, 1.91276550e-01f, 7.11795166e-02f, 7.68594369e-02f,
  -2.65591472e-01f, -3.24456021e-02f, -1.47964582e-01f, -7.81159550e-02f, -1.21848144e-01f, -5.02290204e-02f, -9.24271941e-02f, 4.29588817e-02f, 5.84868453e-02f, 2.40581468e-01f,
  2.15616569e-01f, -1.93703454e-02f, 2.62924105e-01f, 7.85279647e-02f, -4.01411325e-01f, 1.53077260e-01f, -4.67020571e-01f, -7.23745376e-02f, -7.47556165e-02f, -3.05694371e-01f,
  -1.63950130e-01f, 1.80478796e-01f, -3.71493399e-02f, -1.59995511e-01f, -2.36176848e-01f, -2.60593921e-01f, -1.28672227e-01f, -1.43756360e-01f, 1.26336247e-01f, -2.67170500e-02f,
  -4.83752377e-02f, -2.73623586e-01f, -3.16361487e-02f, 2.39182506e-02f, -1.71546042e-01f, 4.19376530e-02f, -1.65074050e-01f, 1.99970938e-02f, 5.49314655e-02f, -1.59583911e-01f,
  -1.10431254e-01f, 1.64597437e-01f, 1.02910496e-01f, -2.45901108e-01f, -1.39374331e-01f, -1.21253237e-01f, -2.21149310e-01f, -1.61413014e-01f, -2.20568076e-01f, -4.89542307e-03f,
  1.25466520e-02f, -1.36978120e-01f, 2.12331535e-03f, 2.34009270e-02f, 1.94584966e-01f, -8.10790062e-02f, 2.30343923e-01f, -1.94857538e-01f, 2.18947232e-01f, 1.54774189e-01f,
  1.63701281e-01f, -1.12071171e-01f, 9.22308266e-02f, -4.09005620e-02f, 9.30755436e-02f, -2.50504613e-01f, 1.10875025e-01f, 1.09998159e-01f, -4.00354385e-01f, 1.09549612e-01f,
  7.37442821e-02f, -5.64060621e-02f, 1.72270790e-01f, -6.44698888e-02f, -1.27060875e-01f, 1.90499410e-01f, -8.41170028e-02f, 3.23993117e-01f, -8.46206024e-02f, -2.85169259e-02f,
  -2.27850527e-02f, -9.82458144e-03f, 2.21744552e-01f, -4.64622200e-01f, -3.90372723e-02f, -6.81294203e-02f, 1.96690470e-01f, -6.49314642e-01f, 5.93131930e-02f, 5.67247532e-02f,
  6.07368313e-02f, -2.97320895e-02f, -4.48284410e-02f, 1.48984507e-01f, 1.00177281e-01f, 1.86280504e-01f, 5.48364781e-02f, 1.85289457e-01f, -1.76638260e-01f, -1.02282777e-01f,
  -1.14365600e-01f, 1.63775176e-01f, 3.10859960e-02f, 1.33783564e-01f, 2.34623864e-01f, -3.89656462e-02f, 3.95664833e-02f, -2.62261145e-02f, 2.28482187e-02f, -1.36216864e-01f,
  -1.38377503e-01f, -5.37952483e-02f, 1.34531647e-01f, 1.98198214e-01f, -1.77684948e-01f, -2.42957726e-01f, -5.54318354e-02f, 1.10896967e-01f, 5.43089509e-02f, -1.87629700e-01f,
  2.21901491e-01f, 1.67894915e-01f, 6.84527159e-02f, 1.10782370e-01f, -7.75153637e-02f, 2.71616459e-01f, 1.33245513e-01f, 5.93217872e-02f, 3.43124359e-03f, -2.65781246e-02f,
  -1.15131093e-02f, -1.23617172e-01f, 1.55409232e-01f, -1.35639399e-01f, -1.94033906e-01f, -1.94836095e-01f, 1.89564645e-01f, -3.73400718e-01f, -1.13595806e-01f, 5.67443632e-02f,
  4.35875319e-02f, -3.96067828e-01f, -4.33388278e-02f, 5.99398911e-02f, -1.50031096e-03f, 1.72280088e-01f, 2.07174361e-01f, 1.17983863e-01f, 1.71232969e-01f, 4.20912690e-02f,
  -1.40237033e-01f, -5.56720011e-02f, -6.86387718e-03f, 1.38765961e-01f, -9.84430835e-02f, 3.90600935e-02f, 7.93454200e-02f, -1.34780735e-01f, 6.08038716e-03f, 6.47505596e-02f,
  2.21544236e-01f, -1.57690555e-01f, 1.12239309e-01f, -1.93165898e-01f, 3.48151401e-02f, -1.08096555e-01f, 2.17293635e-01f, -8.61077011e-02f, -2.18578316e-02f, 2.36273315e-02f,
  -6.07649609e-02f, 5.75189926e-02f, 1.77963171e-03f, 3.17595750e-01f, -7.97250941e-02f, -1.90105826e-01f, 1.71217546e-01f, 2.10477367e-01f, 2.60438681e-01f, 1.12989321e-01f,
  -9.38991234e-02f, -1.03081822e-01f, 1.72779098e-01f, 1.55257046e-01f, 1.60223842e-01f, 5.14108762e-02f, -1.51079655e-01f, 1.35839596e-01f, -2.48332292e-01f, -1.68155774e-01f,
  -1.06900632e-01f, 4.52390350e-02f, -4.25273776e-01f, -3.26279223e-01f, -3.37727457e-01f, -3.00549060e-01f, 8.16529915e-02f, -3.05925131e-01f, 7.77416900e-02f, -2.09505633e-01f,
  -8.46180767e-02f, -1.00216493e-01f, 2.24442780e-01f, 9.78794470e-02f, -2.88939834e-01f, -1.90669566e-01f, 2.24123657e-01f, -3.72188777e-01f, 1.17540300e-01f, 1.13805160e-01f,
  -5.74421557e-03f, -2.20723182e-01f, 3.50589231e-02f, -2.49370456e-01f, -2.04572022e-01f, 1.17421664e-01f, 1.40232399e-01f, 1.83987588e-01f, 5.97856604e-02f, 1.35157213e-01f,
  7.97596350e-02f, -1.27309754e-01f, -1.64734144e-02f, 5.83685786e-02f, -2.00862586e-01f, 1.02219850e-01f, 1.56982273e-01f, 8.11825916e-02f, 1.23593688e-01f, -5.11621982e-02f,
  1.09669797e-01f, -8.10590237e-02f, -5.06503060e-02f, -1.61683843e-01f, 1.25455812e-01f, 1.46703878e-02f, 4.05102335e-02f, 2.33819187e-01f, 2.37768099e-01f, 1.87612146e-01f,
  -1.67214617e-01f, -1.51849091e-01f, -2.61688411e-01f, -1.06423490e-01f, 1.83522385e-02f, -1.00399345e-01f, 2.61034928e-02f, 1.16782203e-01f, 1.97513402e-01f, -1.63444638e-01f,
  5.52507825e-02f, 2.11058855e-01f, 1.44886285e-01f, -1.21609405e-01f, -1.60690565e-02f, 2.81824321e-02f, 6.70601726e-02f, -1.19934678e-01f, -4.06409830e-01f, -2.24434331e-01f,
  7.30795739e-03f, 1.67137802e-01f, -2.31411442e-01f, -3.15993577e-01f, -2.78175175e-01f, 3.39834124e-01f, -1.49733976e-01f, 2.53301561e-01f, -2.58603036e-01f, 9.66667831e-02f,
  -2.53351599e-01f, 1.61951296e-02f, -1.67073131e-01f, 7.41947368e-02f, -2.92622335e-02f, -2.65890241e-01f, -1.69669449e-01f, -1.44898906e-01f, 2.72367984e-01f, 1.13418691e-01f,
  -2.48288035e-01f, 4.35573235e-02f, -1.61977753e-01f, 5.96081913e-02f, -1.17973566e-01f, -1.74222402e-02f, 1.35562674e-03f, -1.60944626e-01f, 1.04839087e-01f, -1.32262990e-01f,
  7.66137615e-02f, -1.06227383e-01f, -3.36910039e-02f, -1.00313008e-01f, 1.10019185e-01f, 1.66907564e-01f, 6.45259321e-02f, 1.54527426e-01f, -6.99892491e-02f, -1.17791034e-01f,
  -1.71727743e-02f, 1.19780771e-01f, 1.85588434e-01f, 2.50150472e-01f, 2.11640373e-01f, -1.92681462e-01f, 2.28296276e-02f, -1.78703651e-01f, 1.11832164e-01f, 2.29048818e-01f,
  -1.87775403e-01f, -1.62390992e-02f, 2.25519016e-03f, 3.66342179e-02f, 3.63150276e-02f, -1.44468531e-01f, -2.44638119e-02f, 9.22311246e-02f, -1.67817160e-01f, 1.62805453e-01f,
  -5.81097975e-03f, 7.32459426e-02f, 9.63202640e-02f, -6.18402399e-02f, -6.26722649e-02f, -1.68735951e-01f, -1.26242176e-01f, 2.65319012e-02f, -1.90300912e-01f, 2.98906863e-01f,
  -3.32218379e-01f, -2.17548639e-01f, -4.03022952e-02f, -3.74152213e-01f, -1.93413049e-01f, -6.18335605e-02f, -8.46433640e-02f, -5.60272522e-02f, -2.08582014e-01f, 2.02565700e-01f,
  -1.86324582e-01f, 3.58106904e-02f, 7.08299503e-02f, 2.90805697e-01f, -2.11729378e-01f, -1.42779484e-01f, -8.36196095e-02f, -1.46453781e-02f, -9.54033583e-02f, -1.94638632e-02f,
  -6.52224422e-02f, 1.04371130e-01f, -1.31429747e-01f, -1.29574031e-01f, 8.25796351e-02f, 9.98984426e-02f, 1.89969301e-01f, 4.27381657e-02f, -1.08251005e-01f, 1.88651294e-01f,
  -1.74584202e-02f, 7.99307600e-02f, -1.04693219e-01f, 1.53988361e-01f, -8.14774632e-02f, -1.64363921e-01f, -2.28958115e-01f, 3.42757821e-01f, 1.17357165e-01f, -1.22733720e-01f,
  -1.88967273e-01f, 3.60369533e-02f, -1.72152579e-01f, 1.12376824e-01f, -1.68715805e-01f, -2.29888689e-03f, 2.05572564e-02f, -9.90113020e-02f, 3.99518870e-02f, 3.14405151e-02f,
  2.34424338e-01f, -1.39512450e-01f, 1.37250587e-01f, -7.39371851e-02f, -1.84651271e-01f, -2.18062758e-01f, -2.98956692e-01f, 1.45408750e-01f, -2.47962922e-01f, -2.77428359e-01f,
  2.43480593e-01f, -2.17099100e-01f, -1.94259003e-01f, -2.32914820e-01f, -4.41531718e-01f, -1.93990543e-01f, -1.02890819e-01f, -1.00759998e-01f, 6.55490980e-02f, -3.36610436e-01f,
  2.07122028e-01f, 1.17558762e-01f, 1.69907078e-01f, -1.10149011e-01f, 2.47787058e-01f, -2.61482745e-01f, 1.22626729e-01f, -3.19314450e-01f, 2.08666995e-01f, -1.52583390e-01f,
  6.32973090e-02f, -1.29745333e-02f, -1.81563318e-01f, 1.67276949e-01f, 8.78368020e-02f, -5.44125810e-02f, -5.63562028e-02f, 9.01627392e-02f, 8.22503865e-02f, 1.14273123e-01f,
  3.56197618e-02f, 5.01801223e-02f, -1.62775755e-01f, 3.72933336e-02f, -9.00855213e-02f, 3.61705422e-02f, -7.37867206e-02f, 1.13347126e-02f, 1.08455559e-02f, 4.72112969e-02f,
  -1.87515408e-01f, -1.22387849e-01f, 5.26358075e-02f, 2.28333637e-01f, 1.68927908e-01f, 1.35476336e-01f, 5.25504947e-02f, -5.66177890e-02f, -8.57847109e-02f, -7.08225518e-02f,
  -1.14575617e-01f, -1.64272904e-01f, -2.30281413e-01f, -2.12208614e-01f, -1.34958059e-01f, 1.17719121e-01f, -1.03417076e-01f, 7.99671635e-02f, -8.97734463e-02f, 1.04648344e-01f,
  1.87914036e-02f, -1.93334162e-01f, 2.23926663e-01f, -2.79681295e-01f, -5.77626862e-02f, 2.40698770e-01f, -2.08064169e-01f, -9.73214284e-02f, 2.47743905e-01f, 4.25816439e-02f,
  1.93676054e-01f, 2.29447201e-01f, -3.37940082e-02f, -1.03238873e-01f, -2.58146733e-01f, -2.24464759e-01f, -2.19990149e-01f, 1.09894887e-01f, -2.24572197e-01f, 6.71151280e-02f,
  -4.20085639e-01f, 1.97071269e-01f, -1.38326421e-01f, -1.52208671e-01f, -7.40359724e-02f, 2.88414415e-02f, -1.34546578e-01f, -1.18669674e-01f, -1.73203900e-01f, -2.60776021e-02f,
  1.02915809e-01f, 5.48383966e-02f, -1.42571867e-01f, -1.59877151e-01f, 1.94487467e-01f, -1.66601598e-01f, -1.49113119e-01f, 1.79880753e-01f, -7.02417642e-02f, 8.00779238e-02f,
  1.51000142e-01f, 1.35152951e-01f, -1.24877647e-01f, 3.35322410e-01f, 3.17841470e-01f, -1.79651037e-01f, -1.75517827e-01f, -1.84575878e-02f, -1.24472104e-01f, 6.21370301e-02f,
  -8.11331347e-02f, -2.75900811e-01f, -7.53000602e-02f, 2.17300266e-01f, 3.86165269e-02f, 1.74117759e-01f, -9.57233459e-02f, 1.25443816e-01f, -1.50189847e-01f, -9.47947204e-02f,
  1.35069773e-01f, -1.68346539e-02f, -3.47628184e-02f, -3.17384243e-01f, -1.26404032e-01f, -1.20135330e-01f, -1.65372729e-01f, 1.56609118e-01f, -2.58607388e-01f, -3.26360136e-01f,
  9.74654481e-02f, -2.03807965e-01f, 2.18556821e-01f, -6.70378059e-02f, 2.24863738e-01f, -1.32898286e-01f, -3.09793893e-02f, 3.15749533e-02f, 5.03189601e-02f, 1.24055974e-01f,
  -3.60129923e-01f, -1.17666729e-01f, -4.44414020e-01f, 1.34478852e-01f, -3.66518408e-01f, 2.23433286e-01f, 7.01765940e-02f, 8.45934227e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -7.40859881e-02f, -9.37838703e-02f, -5.18128052e-02f, 8.28944147e-02f, 1.17296375e-01f, -3.99049418e-03f, -9.78283882e-02f, -5.75484894e-02f, -4.47053113e-04f, -4.35580611e-02f,
  7.22096637e-02f, 4.82683815e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        64, 12
    );
    }
    