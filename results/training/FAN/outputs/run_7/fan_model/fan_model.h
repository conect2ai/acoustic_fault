/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -5.01517765e-02f, 1.64423436e-01f, 9.20725763e-02f, 2.86432326e-01f, 7.14625642e-02f, -5.14574349e-01f, -4.27254081e-01f, 1.67734444e-01f, 3.75420898e-01f, -2.31268078e-01f,
  -8.37901011e-02f, 2.13382632e-01f, -1.71430662e-01f, 5.11936918e-02f, 1.20248720e-01f, -4.66962829e-02f, -2.25488290e-01f, -1.55517846e-01f, 1.85681239e-01f, -3.46366465e-02f,
  -6.98939189e-02f, 1.82442199e-02f, -8.26423708e-03f, 2.94883221e-01f, 8.99955723e-03f, 1.70433775e-01f, 1.37114152e-01f, 1.47773623e-01f, 1.77443121e-02f, -5.59176132e-02f,
  -1.28633603e-01f, 1.25447869e-01f, 1.73264682e-01f, -2.61453539e-02f, 2.71183834e-03f, -1.08591348e-01f, -2.01951444e-01f, 3.34710032e-02f, 5.74825928e-02f, -2.95955017e-02f,
  -1.09211437e-01f, -1.07738830e-01f, 3.90268415e-02f, 2.61335224e-01f, -9.02419984e-02f, 5.96690513e-02f, 7.06602633e-02f, -1.25803977e-01f, 1.28165051e-01f, -2.91106403e-02f,
  2.25927874e-01f, -6.48890510e-02f, -8.21765289e-02f, -1.34167001e-01f, 4.78095710e-02f, 6.22207038e-02f, -1.55373052e-01f, -2.58522369e-02f, -5.33018336e-02f, 1.17398687e-01f,
  -9.08371881e-02f, 9.99716893e-02f, 7.60758761e-03f, 1.13301620e-01f, 1.38735414e-01f, -1.16360430e-02f, -4.78668232e-03f, -8.99872091e-03f, 1.41732737e-01f, -1.89165063e-02f,
  6.26978874e-02f, -2.09943354e-02f, 3.88976559e-02f, 3.82136437e-03f, 4.71556280e-03f, 7.39488229e-02f, -1.01989381e-01f, 4.17581797e-02f, -1.09688550e-01f, 1.02358051e-01f,
  2.86700819e-02f, -5.56340739e-02f, 1.23836666e-01f, -1.02569774e-01f, 1.85468271e-02f, 4.60028532e-04f, -3.31481434e-02f, 2.35593710e-02f, 9.03527588e-02f, -6.24680258e-02f,
  -2.03720227e-01f, 2.23021060e-02f, 5.26966490e-02f, -1.23965438e-03f, 3.15937735e-02f, 9.88535509e-02f, -2.49989200e-02f, -1.33527992e-02f, 7.42257982e-02f, 6.75565600e-02f,
  -3.12801488e-02f, -3.87097150e-02f, -2.89018508e-02f, -1.13636658e-01f, -4.00486514e-02f, 5.09532988e-02f, -9.91667137e-02f, -8.80229694e-04f, 2.91644596e-02f, -8.82208869e-02f,
  -6.75700679e-02f, -8.75303447e-02f, 2.65074167e-02f, 1.36569394e-02f, -1.58499956e-01f, -9.63164866e-02f, 1.30502984e-01f, -1.15836188e-02f, -9.57455337e-02f, -7.52250627e-02f,
  -3.75755161e-01f, -4.99936193e-01f, 8.08976498e-03f, -3.28612328e-01f, 2.79984087e-01f, 2.07855627e-01f, 4.45085727e-02f, -1.63836524e-01f, -5.21770827e-02f, -3.70891362e-01f,
  1.15613967e-01f, -2.53122628e-01f, -1.52320087e-01f, 1.26718897e-02f, 3.25118005e-01f, 8.00380409e-02f, 7.03686401e-02f, -8.31435844e-02f, -1.27926692e-01f, -5.93616404e-02f,
  -2.03188555e-03f, 1.60204932e-01f, 2.08149865e-01f, 7.28713423e-02f, 1.51176706e-01f, 1.84902921e-03f, -5.77927977e-02f, -3.86682115e-02f, -1.20815970e-01f, 5.96554838e-02f,
  3.29443485e-01f, -1.50746733e-01f, -1.22326717e-01f, 3.91282775e-02f, 3.66527960e-02f, 3.57177667e-02f, 2.20267829e-02f, 4.21185195e-02f, -6.86169043e-03f, 1.23051535e-02f,
  1.20433886e-02f, -1.29398676e-02f, 5.18854745e-02f, -9.20664072e-02f, -2.21881941e-02f, -9.16264579e-02f, 1.73430536e-02f, -6.85560554e-02f, 3.21048014e-02f, -5.00053633e-03f,
  -5.34160621e-02f, 4.63058986e-02f, 4.99153621e-02f, -2.37013064e-02f, 1.25186056e-01f, 7.16356412e-02f, 9.70551372e-02f, 6.72789589e-02f, -9.48221013e-02f, -2.09712505e-01f,
  1.54046779e-02f, 1.14750810e-01f, 8.78052507e-03f, 2.90556457e-02f, -6.96003251e-03f, 1.35916874e-01f, 7.03488663e-02f, -2.56084688e-02f, 1.17036449e-02f, -8.24211985e-02f,
  -2.69837701e-03f, -3.33851874e-02f, -2.24873852e-02f, 9.50106829e-02f, -8.67873710e-03f, -3.45422775e-02f, 1.08141586e-01f, -1.54806942e-01f, 5.77015318e-02f, -1.77624952e-02f,
  1.10549703e-02f, 5.20540327e-02f, -3.22134793e-02f, 7.08370805e-02f, 3.86569910e-02f, 4.81846370e-03f, 5.39445784e-03f, -1.16871506e-01f, 2.64782067e-02f, -1.90226976e-02f,
  -9.27276835e-02f, -3.87756288e-01f, 9.02949795e-02f, -7.16759562e-02f, -5.69139682e-02f, -2.16893137e-01f, 1.25984162e-01f, -5.01367152e-02f, -5.22797257e-02f, -7.00043142e-02f,
  -9.05848816e-02f, 8.34122580e-03f, -2.13068109e-02f, 5.66573292e-02f, 8.17134902e-02f, 1.26967028e-01f, 2.85496525e-02f, -1.53558547e-04f, 2.93417200e-02f, -6.73235506e-02f,
  -4.69464697e-02f, 7.66185746e-02f, -4.84934449e-02f, 1.08811133e-01f, -4.39022370e-02f, -3.34744044e-02f, -4.79123509e-03f, -9.42040309e-02f, 7.88163245e-02f, 9.23947021e-02f,
  -4.54811335e-01f, 1.45648450e-01f, 1.83605865e-01f, 2.82937348e-01f, -3.15020233e-01f, -5.30381680e-01f, -5.07975101e-01f, -3.30018364e-02f, -2.93841243e-01f, -1.11135002e-02f,
  -2.09692150e-01f, -4.75796796e-02f, -2.83793986e-01f, 1.91013917e-01f, -3.78096372e-01f, -2.42602974e-02f, 1.87962651e-01f, 1.25584751e-01f, -4.34933752e-02f, -1.68975115e-01f,
  1.75932199e-01f, -1.48040976e-03f, 2.74428781e-02f, 1.62271468e-03f, -3.78773920e-02f, -1.41789272e-01f, 9.90116596e-02f, -4.09651585e-02f, 4.12946254e-01f, -4.06160876e-02f,
  6.98583648e-02f, -2.05495358e-01f, 7.64381811e-02f, 7.71246180e-02f, -2.99083460e-02f, 2.81255860e-02f, 5.86867742e-02f, -4.41096760e-02f, -7.33226091e-02f, 1.15608275e-01f,
  -2.15800349e-02f, 7.18720928e-02f, -8.81677642e-02f, -4.61877277e-03f, -2.26500228e-01f, 1.87967028e-02f, -8.45600143e-02f, -6.49175886e-03f, -4.29424569e-02f, -1.55262068e-01f,
  -1.69307068e-01f, 2.69292668e-03f, -6.61010966e-02f, 1.88191921e-01f, -1.44946083e-01f, -1.04431726e-01f, 1.14679588e-02f, -6.10383041e-02f, -2.17537545e-02f, -1.09704649e-02f,
  -6.69466481e-02f, 8.18100050e-02f, 5.88090578e-03f, 3.32434010e-03f, -1.05197102e-01f, 4.76666577e-02f, 3.11722700e-02f, 4.51196134e-02f, -4.59049642e-02f, 5.60436994e-02f,
  7.17743188e-02f, 4.89012487e-02f, -9.29472744e-02f, -6.69337288e-02f, -9.31253470e-03f, -1.59336522e-01f, -1.04677819e-01f, 1.31995782e-01f, -3.41501199e-02f, 5.93451634e-02f,
  -6.81867152e-02f, -7.19425529e-02f, -4.85130511e-02f, 3.12012024e-02f, -3.08157839e-02f, 9.77495164e-02f, 1.12415120e-01f, -5.05787134e-02f, -7.60806426e-02f, -1.62141379e-02f,
  -1.63155228e-01f, 8.64994898e-02f, -6.46603927e-02f, -1.04176611e-01f, 1.56443879e-01f, -3.67195271e-02f, -1.32685691e-01f, 3.52058932e-03f, 6.43208027e-02f, -1.05211630e-01f,
  2.91889720e-02f, -6.61936181e-04f, 5.63936867e-02f, 8.69274326e-03f, 1.23076245e-01f, 2.53514126e-02f, 1.16050273e-01f, 2.02578545e-01f, 2.65701637e-02f, 1.35830238e-01f,
  1.38784587e-01f, -3.87697443e-02f, 1.07713573e-01f, -9.01345611e-02f, 1.23752430e-01f, -2.26989333e-02f, -1.41336381e-01f, 3.33371647e-02f, -3.56962085e-02f, 2.01021247e-02f,
  -5.87919913e-02f, -6.22595102e-02f, -2.59961724e-01f, -1.78158149e-01f, -1.32413134e-01f, 5.14280796e-01f, 3.98036152e-01f, -6.52826205e-02f, -1.00313127e-01f, 3.61275852e-01f,
  -1.04438951e-02f, -1.71761990e-01f, 3.22993219e-01f, 5.47297150e-02f, 1.32498607e-01f, 1.95878819e-01f, 2.30458185e-01f, 1.52864471e-01f, -1.76151037e-01f, -6.77916184e-02f,
  -6.78566024e-02f, 1.34651974e-01f, 3.21689956e-02f, -8.26096013e-02f, 1.10428639e-01f, -2.27491692e-01f, 1.99769542e-01f, -8.65326598e-02f, 9.17024761e-02f, -3.70473489e-02f,
  1.52431339e-01f, -3.05751026e-01f, -1.48122162e-01f, 4.56722500e-03f, 4.14621234e-02f, 2.14157835e-01f, 6.18083477e-02f, -1.68325808e-02f, -6.76087588e-02f, 4.53064665e-02f,
  1.23109706e-01f, -1.69325769e-01f, -7.87545219e-02f, -2.68016253e-02f, -3.78577709e-02f, -7.34268874e-02f, -3.12999398e-01f, -1.41070262e-01f, -6.84355572e-03f, 1.72717348e-01f,
  -1.59231141e-01f, -1.08662747e-01f, 5.91260679e-02f, 5.01207402e-03f, -1.70387104e-02f, -6.32535219e-02f, 1.42848575e-02f, -4.50092973e-03f, 4.03790995e-02f, -2.03244686e-02f,
  -1.46813348e-01f, -4.19632113e-03f, -5.69379106e-02f, 8.14276468e-03f, -4.80958335e-02f, 1.12938574e-02f, -9.43291485e-02f, 6.07260317e-02f, -8.72236956e-03f, 7.40491152e-02f,
  1.05217487e-01f, 3.94653156e-03f, 2.62686610e-03f, 3.08090337e-02f, 6.90476745e-02f, 8.99817497e-02f, -4.73504839e-03f, 9.85216200e-02f, 2.37414776e-03f, -8.55513960e-02f,
  -5.51958270e-02f, -2.07185932e-02f, 3.58945429e-02f, 1.73639417e-01f, 5.55554107e-02f, -6.48042262e-02f, 3.96603383e-02f, -2.76830234e-02f, -1.13791503e-01f, 1.30571276e-01f,
  4.66344625e-01f, 3.14747423e-01f, 2.65234634e-02f, -4.47427668e-03f, 3.10048182e-02f, -4.03037928e-02f, -4.50776964e-02f, -5.44457175e-02f, 4.96063381e-02f, -2.32016984e-02f,
  7.24518672e-02f, 1.58590510e-01f, 1.98570341e-01f, 6.64566681e-02f, -8.48130584e-02f, 1.07821055e-01f, 1.75717846e-01f, 3.98121541e-03f, 2.45427829e-04f, -2.66772918e-02f,
  7.06348792e-02f, 1.00441277e-01f, -3.36286314e-02f, 7.08211735e-02f, 7.26512372e-02f, 2.41989326e-02f, 5.25691770e-02f, 7.02317385e-03f, -2.79394072e-02f, 2.43071802e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.79967105e-01f, -2.41057217e-01f, -9.90768373e-02f, 5.61881125e-01f, -1.57923862e-01f, 3.37695837e-01f, -3.27517062e-01f, 1.03773691e-01f, -3.51418346e-01f, -4.72600669e-01f,
  2.94095427e-01f, -4.68409121e-01f, -8.55281532e-01f, 1.03112614e+00f, 1.10587621e+00f, -4.49929126e-02f, 1.10565293e+00f, 3.50200236e-01f, 2.23821625e-01f, 2.44619906e-01f,
  7.56409347e-01f, 1.26949561e+00f, 3.05734992e-01f, 7.47520506e-01f, 4.87794966e-01f, 2.77358174e-01f, 3.87509525e-01f, -2.51123875e-01f, 6.76994383e-01f, 3.75107646e-01f,
  -9.68813747e-02f, 2.09612306e-02f, -6.07056841e-02f, 1.84149407e-02f, -7.89557323e-02f, -5.64390086e-02f, 8.31581205e-02f, -7.43393004e-02f, -2.00290009e-01f, -1.54361024e-01f,
  -1.16412096e-01f, 1.06533587e-01f, 1.80506587e-01f, 7.08857039e-03f, 7.46210590e-02f, 1.09377854e-01f, -1.43598691e-01f, -1.17201291e-01f, -4.42031115e-01f, 3.57839614e-02f,
  -1.57987401e-01f, -2.36723311e-02f, 1.27527863e-01f, -3.40252630e-02f, 5.11353351e-02f, 8.63654241e-02f, -8.66324157e-02f, -3.08134884e-01f, -1.22587271e-01f, 1.31612375e-01f,
  1.90782726e-01f, -2.17193644e-02f, 2.95006465e-02f, 9.54535306e-02f, 1.24062032e-01f, -4.99653928e-02f, 1.21948749e-01f, -7.85788000e-02f, 2.50843037e-02f, -1.00567028e-01f,
  8.94664451e-02f, -9.80354324e-02f, -1.95512827e-02f, 3.19320796e-04f, 1.12179227e-01f, 3.73355597e-02f, 3.22662517e-02f, 2.07083523e-01f, -1.51907066e-02f, -1.22722946e-01f,
  -1.15749590e-01f, 1.15625136e-01f, -1.74682513e-01f, 9.34725851e-02f, 1.10550411e-01f, -1.42672405e-01f, 1.36950210e-01f, 2.07839116e-01f, -3.12177777e-01f, -8.98133032e-03f,
  -9.48593318e-02f, 3.26018900e-01f, -2.62932271e-01f, -1.15491018e-01f, -6.48176819e-02f, 2.85662919e-01f, 2.08854824e-01f, 8.62347633e-02f, 3.23982477e-01f, 1.38211668e-01f,
  1.51895136e-01f, -1.08330779e-01f, -1.29262403e-01f, 3.36477943e-02f, -4.08201851e-02f, 2.08932340e-01f, -7.14334147e-03f, 4.67163846e-02f, 7.03159794e-02f, 9.66813192e-02f,
  -2.27774270e-02f, 9.07836109e-03f, -1.04730472e-01f, -3.51266116e-01f, -5.72448187e-02f, -1.14329688e-01f, -5.37642417e-03f, -3.97470891e-02f, -1.87470438e-03f, -8.64416584e-02f,
  2.07895376e-02f, 9.99460280e-01f, 1.13405693e+00f, -5.87676406e-01f, 4.34639126e-01f, 6.35857463e-01f, -6.54338062e-01f, 6.23360991e-01f, 7.30193511e-04f, 2.54331063e-02f,
  -7.09351599e-01f, 1.97804838e-01f, -3.29221070e-01f, -3.81210595e-02f, -7.82664895e-01f, -4.58862871e-01f, -3.32278311e-01f, -3.03709626e-01f, 1.42177537e-01f, 3.38336751e-02f,
  -5.24380356e-02f, -8.76757622e-01f, 3.21064323e-01f, 1.57634407e-01f, 6.98095083e-01f, 3.47822696e-01f, -8.08314323e-01f, 3.85897607e-01f, -2.58410908e-02f, 5.29196523e-02f,
  4.46300089e-01f, -2.87578672e-01f, 3.47583294e-01f, 1.88344065e-02f, 1.32351786e-01f, 3.71280983e-02f, 6.65574074e-02f, -1.65747240e-01f, -1.41914621e-01f, 3.40052515e-01f,
  4.06124182e-02f, 1.65940955e-01f, -3.58805507e-02f, 7.28362277e-02f, 1.65758908e-01f, 1.84774339e-01f, 2.81631291e-01f, 3.71703506e-01f, 1.82735413e-01f, 4.98660833e-01f,
  2.55091399e-01f, 3.78995299e-01f, 7.59292319e-02f, 2.18374953e-02f, 1.32735416e-01f, -8.80635828e-02f, 2.09860846e-01f, 1.34761289e-01f, 2.10467637e-01f, -1.16198440e-03f,
  -6.56341165e-02f, -1.86263263e-01f, -6.82577044e-02f, -5.35317622e-02f, -9.68616903e-02f, 1.46163955e-01f, -1.23467885e-01f, -1.39190435e-01f, 1.12541337e-02f, -1.69430882e-01f,
  -7.90476520e-03f, 6.26985580e-02f, -1.34914607e-01f, -1.60273572e-03f, -2.24537954e-01f, 2.83338651e-02f, -4.96350266e-02f, -6.46883249e-02f, -3.25508676e-02f, 6.70910403e-02f,
  -1.17099293e-01f, -1.40354261e-01f, -9.06331465e-02f, 1.21367782e-01f, -7.72422180e-02f, 4.07880396e-02f, 1.29549697e-01f, 3.34414452e-01f, -1.66470259e-01f, -2.29310766e-02f,
  -6.85566902e-01f, -1.00769782e+00f, -1.17196657e-01f, 1.33040413e-01f, -1.05500840e-01f, 1.05960384e-01f, -9.53183100e-02f, 1.44668251e-01f, -1.40914097e-01f, 1.09566608e-02f,
  1.02246881e-01f, -3.63975577e-03f, 1.13074780e-02f, 8.03614873e-03f, -1.65113449e-01f, 1.83380142e-01f, -2.75380015e-01f, -2.69428313e-01f, -3.17894310e-01f, 4.27680053e-02f,
  -2.54232176e-02f, -1.30529955e-01f, -2.35719495e-02f, 3.35681140e-02f, -8.01719353e-02f, -1.03903361e-01f, -1.45538747e-01f, 1.37566596e-01f, -1.00317009e-01f, -1.59507748e-02f,
  -3.22702646e-01f, -2.01678351e-01f, -6.92918241e-01f, -2.16025695e-01f, 8.54568660e-01f, -5.67818165e-01f, -1.39537781e-01f, 2.21525386e-01f, -4.15422171e-01f, 4.57014471e-01f,
  2.89235920e-01f, -3.89477342e-01f, -2.42941499e-01f, -8.88945282e-01f, -1.47862458e+00f, -1.28518248e+00f, -8.34374011e-01f, -6.82268441e-01f, -1.63197890e-01f, 1.41813681e-01f,
  -4.24829721e-01f, 7.26372302e-02f, -8.59735489e-01f, 7.98146367e-01f, 6.00030124e-01f, 6.00656569e-01f, 9.44805801e-01f, 7.52590239e-01f, 1.87680960e-01f, -1.55912012e-01f,
  -3.12061340e-01f, -7.31728375e-02f, 5.38829006e-02f, -2.26488769e-01f, -1.67670492e-02f, 1.88446343e-01f, 1.40399352e-01f, -3.71764377e-02f, -3.89055759e-02f, -1.56976003e-02f,
  4.38957363e-02f, 8.24014172e-02f, -1.03269033e-02f, 5.28702773e-02f, 1.39194861e-01f, 3.58251818e-02f, -3.59664708e-01f, -1.83439776e-01f, -1.67389512e-01f, -2.88875669e-01f,
  -2.93104708e-01f, -2.02889189e-01f, 7.90288001e-02f, -1.91888094e-01f, -1.00982390e-01f, -6.79230615e-02f, -1.83085203e-01f, 1.65959567e-01f, -4.02561501e-02f, -2.17154488e-01f,
  1.59762457e-01f, 6.67733699e-02f, -5.09411916e-02f, -3.30014415e-02f, -1.29309162e-01f, 1.06277004e-01f, -4.20929939e-02f, 8.75119716e-02f, 1.93373829e-01f, 1.78096116e-01f,
  1.32701367e-01f, -1.04526110e-01f, 6.05447218e-02f, 6.26996681e-02f, -7.09564835e-02f, -7.08859414e-02f, -5.87536432e-02f, 4.67863493e-02f, -6.42704070e-02f, -3.58077437e-01f,
  1.59406126e-01f, -2.03374714e-01f, 6.21087439e-02f, 5.76941147e-02f, -2.56684273e-01f, 5.29822968e-02f, 2.07064226e-01f, -1.41159117e-01f, 3.85446548e-02f, 1.48951192e-03f,
  -1.82700977e-01f, -4.13273163e-02f, 7.92371482e-03f, -5.42515293e-02f, 1.24768699e-02f, 3.49664278e-02f, -2.14793682e-01f, -8.27883091e-03f, 1.56557590e-01f, 1.18536711e-01f,
  2.04623833e-01f, 1.37338102e-01f, 1.66109130e-01f, -2.05592260e-01f, -4.51579951e-02f, 1.60118759e-01f, 9.18790698e-02f, 2.39561930e-01f, 2.84559220e-01f, 2.02671334e-01f,
  2.20870554e-01f, 2.38561153e-01f, 9.25838575e-02f, 3.85095745e-01f, 2.48952582e-01f, 2.72342235e-01f, 3.88818309e-02f, 7.34651163e-02f, -1.00603335e-01f, -1.65727854e-01f,
  -1.89995241e+00f, 1.45451510e+00f, -6.89926386e-01f, 1.11218612e-03f, 1.04676723e-01f, 7.41317868e-01f, 7.52917290e-01f, 3.56061786e-01f, 5.01584373e-02f, 6.85996175e-01f,
  5.08353531e-01f, 9.72084254e-02f, 6.61617935e-01f, 9.84148741e-01f, -4.64343876e-01f, 7.03059554e-01f, 3.17020148e-01f, 1.87288821e-01f, 2.08796248e-01f, -5.42147048e-02f,
  -3.28782618e-01f, 7.16377020e-01f, -2.39435211e-01f, 1.60104990e-01f, -1.76108796e-02f, -3.26295406e-01f, -2.98813850e-01f, -5.97160757e-02f, 3.21521959e-03f, 4.72636707e-02f,
  -1.23455957e-01f, -2.38400415e-01f, -1.54397279e-01f, -3.11884373e-01f, -4.33942616e-01f, -4.20293033e-01f, -2.03304067e-01f, -2.01396763e-01f, -1.70437112e-01f, 7.09024295e-02f,
  -2.72478536e-02f, 4.90407683e-02f, -6.48857877e-02f, 4.02783975e-02f, -1.06639422e-01f, -5.92961386e-02f, 3.61692831e-02f, 1.06864080e-01f, 1.96384594e-01f, -7.42771849e-03f,
  1.09095737e-01f, 5.55266626e-02f, 1.51073812e-02f, 7.18846396e-02f, -8.73071924e-02f, 7.98888355e-02f, 1.24485232e-02f, 1.07503273e-01f, 1.12629747e-02f, -5.52382953e-02f,
  -2.02636585e-01f, -1.89016648e-02f, 9.99159217e-02f, 1.50965219e-02f, 8.16278085e-02f, 3.09601668e-02f, 3.78010795e-02f, 8.72226804e-02f, -7.77679160e-02f, 9.92076695e-02f,
  4.80835401e-02f, -1.38752675e-02f, -4.91370559e-02f, 5.89867076e-03f, -5.27062900e-02f, -1.22172376e-02f, -1.03288755e-01f, 3.78997587e-02f, 1.38262017e-02f, 2.81725582e-02f,
  -5.25587648e-02f, -2.28599831e-01f, 2.19233930e-01f, -1.03026353e-01f, -1.64503194e-02f, 1.53978586e-01f, 8.21636468e-02f, 1.07759245e-01f, 1.33524507e-01f, -1.09421708e-01f,
  1.75367445e-01f, -4.00225043e-01f, 6.28444850e-02f, 1.20488904e-01f, 1.01587929e-01f, 1.40333518e-01f, -2.07238853e-01f, -1.08604856e-01f, -1.13171395e-02f, -7.81052709e-02f,
  -2.71922857e-01f, -1.96901873e-01f, -2.34472290e-01f, 7.53335580e-02f, -1.95858758e-02f, 1.51256710e-01f, -1.22472987e-01f, -1.64168954e-01f, -8.40279609e-02f, -5.82261086e-02f,
  -2.13816419e-01f, -6.67463690e-02f, -1.12221561e-01f, 1.12573139e-01f, 4.86798031e-04f, -9.38421637e-02f, -1.65980875e-01f, -8.47133342e-03f, -2.24535033e-01f, 8.52256082e-04f,
  1.39711416e+00f, -4.19224575e-02f, 6.28111124e-01f, 8.63384604e-01f, 7.65477836e-01f, 8.77335906e-01f, 1.13474929e+00f, 2.78880566e-01f, 1.57405198e+00f, -6.79390132e-01f,
  -4.75316167e-01f, 2.94920951e-01f, -1.94744051e-01f, 9.30358171e-02f, 3.03655982e-01f, 1.80237964e-01f, 2.82167226e-01f, 1.89534977e-01f, 6.21176898e-01f, 2.55327255e-01f,
  4.06551927e-01f, -5.34141481e-01f, -4.77181017e-01f, -1.01958215e+00f, 1.11597888e-01f, -2.87431926e-01f, -1.18324411e+00f, -1.62339285e-01f, -7.89740086e-01f, 5.66037707e-02f,
  -4.18352261e-02f, 1.01507135e-01f, -2.01377034e-01f, -1.83203444e-02f, -1.07338250e-01f, -1.52132764e-01f, -1.42882824e-01f, -1.89241856e-01f, 4.60048839e-02f, 2.06204727e-01f,
  1.30490065e-01f, -2.73498837e-02f, -7.28753358e-02f, 6.14648033e-03f, 1.19222000e-01f, 8.45582131e-03f, 2.51236320e-01f, 4.89442348e-02f, 5.39583229e-02f, 1.62971094e-01f,
  1.04017824e-01f, 3.98369655e-02f, 1.25646710e-01f, 4.79303002e-02f, -1.58085627e-03f, 1.01492748e-01f, 1.65865600e-01f, 1.21352049e-02f, -6.61927015e-02f, 7.50794709e-02f,
  -6.12340942e-02f, 2.29181528e-01f, -8.41053873e-02f, -4.51191142e-02f, -3.65704298e-02f, 1.34842724e-01f, -2.13997308e-02f, -6.24726191e-02f, 1.54831007e-01f, -6.02963902e-02f,
  2.08822802e-01f, 4.83438820e-02f, 7.27967173e-02f, 3.82955298e-02f, 7.79003948e-02f, 1.27834171e-01f, 8.52812380e-02f, -3.18552032e-02f, 6.03813194e-02f, 7.60546699e-02f,
  -9.34307054e-02f, 9.56043899e-02f, -2.24118829e-01f, -8.81881341e-02f, -1.53823659e-01f, 3.93850030e-03f, 4.80337488e-03f, 1.26144066e-01f, 2.80044805e-02f, -3.46539356e-02f,
  1.07775003e-01f, 1.34816512e-01f, 3.61887831e-03f, 1.37998089e-01f, -2.77334061e-02f, -1.98752940e-01f, 7.06670657e-02f, 1.28237709e-01f, 1.28867090e-01f, 1.48140863e-01f,
  -1.77648932e-01f, 1.51913941e-01f, -1.66569635e-01f, -2.55115349e-02f, -2.11835019e-02f, -7.01208934e-02f, -8.86791423e-02f, 8.31859335e-02f, 7.06884719e-04f, -2.18142584e-01f,
  -2.65281588e-01f, 2.20589399e-01f, 1.47153288e-01f, 1.09204508e-01f, -9.10033360e-02f, -1.09503701e-01f, 3.08111720e-02f, -2.97988802e-02f, -1.15058392e-01f, -6.84948042e-02f,
  -7.73795024e-02f, -9.64349627e-01f, 9.00234282e-02f, -7.22164035e-01f, 4.23635453e-01f, -1.48792639e-01f, -8.97943005e-02f, -3.38417351e-01f, -4.09932882e-01f, -1.27747333e+00f,
  -2.64689714e-01f, 2.05870122e-01f, 5.55600345e-01f, -8.36906850e-01f, 1.46124697e+00f, 2.93582261e-01f, -5.13355136e-01f, -4.60837305e-01f, 1.88404009e-01f, -7.44117200e-01f,
  1.40958540e-02f, -7.58390903e-01f, 2.51943678e-01f, -4.62654114e-01f, -3.86669695e-01f, -5.39523184e-01f, 8.54515955e-02f, 4.35879976e-01f, -6.00295186e-01f, 3.93575519e-01f,
  -1.13059893e-01f, -2.76330143e-01f, -7.28085861e-02f, -1.92722902e-01f, -2.39934623e-01f, -1.64204296e-02f, 1.93221048e-01f, 4.88247782e-01f, 1.32599726e-01f, 6.85028210e-02f,
  9.02852565e-02f, 3.90742496e-02f, -5.16733348e-01f, 2.60087579e-01f, -2.07215101e-01f, 3.15349959e-02f, 4.07743230e-02f, -2.64597118e-01f, 3.80638912e-02f, 2.27265313e-01f,
  2.86425576e-02f, 1.17664412e-01f, -9.15518329e-02f, -2.04214398e-02f, 1.61095068e-01f, -2.93905705e-01f, -7.51356944e-04f, 2.21663043e-01f, -2.22291797e-02f, -5.28959259e-02f,
  -3.46210659e-01f, 1.36288539e-01f, 7.05798864e-02f, 5.00528105e-02f, -3.28490622e-02f, -6.17679283e-02f, 4.74392883e-02f, 2.20021531e-02f, 1.37856111e-01f, 5.85381351e-02f,
  7.13871717e-02f, -2.44256128e-02f, -2.98298858e-02f, -2.24705175e-01f, -8.76953602e-02f, -1.33669659e-01f, 1.64087459e-01f, 8.18011612e-02f, -8.29177648e-02f, 3.82619686e-02f,
  8.09146836e-02f, -1.05225623e-01f, -1.78311784e-02f, -3.66380140e-02f, -4.43084501e-02f, 2.36777678e-01f, -1.24516599e-01f, -6.36513904e-02f, -9.33320075e-02f, 2.24015728e-01f,
  -2.25779995e-01f, -8.81512940e-01f, -2.98938721e-01f, -9.82680842e-02f, 2.84667537e-02f, -4.36723121e-02f, -1.90173686e-02f, -3.03487200e-02f, -6.28645793e-02f, -6.94185719e-02f,
  -1.81400314e-01f, 6.31286353e-02f, -1.83308065e-01f, -3.53055112e-02f, 1.95485204e-02f, -1.27828494e-01f, -2.41191283e-01f, 2.13949736e-02f, -1.92974329e-01f, -2.07890362e-01f,
  -1.10514395e-01f, -6.35478050e-02f, 2.85967439e-01f, -1.89830497e-01f, -1.86595038e-01f, 2.49494538e-02f, -1.06362104e-01f, 1.42253013e-02f, 1.09769426e-01f, -9.64468345e-02f,
  -8.02071929e-01f, 9.73654866e-01f, 1.46090519e+00f, 6.13617480e-01f, -1.16292620e+00f, -3.63866955e-01f, 7.78001070e-01f, -3.33337903e-01f, -4.12983268e-01f, 2.86657304e-01f,
  -1.03500739e-01f, 5.64710140e-01f, 4.65687513e-01f, 3.25928748e-01f, 1.79809958e-01f, 4.47232366e-01f, 2.03286633e-01f, 1.84085563e-01f, 6.74488917e-02f, 1.69973731e-01f,
  5.62486462e-02f, -5.38372517e-01f, 7.65205145e-01f, -3.29481483e-01f, 2.20105037e-01f, 3.19580525e-01f, 7.17625618e-02f, 4.63263035e-01f, -5.70721962e-02f, -1.03052057e-01f,
  -5.57646930e-01f, -1.36434466e-01f, 1.30680934e-01f, 1.69613943e-01f, -2.24545062e-01f, -5.21020070e-02f, 2.46113032e-01f, 1.88247442e-01f, -7.15265376e-03f, 3.17150019e-02f,
  1.47307336e-01f, -1.62607357e-01f, -1.39784515e-01f, -6.46415399e-03f, -1.93319634e-01f, -5.26230372e-02f, -4.42245752e-02f, -9.02996957e-03f, -1.32615030e-01f, 7.89018755e-04f,
  1.11075670e-01f, 6.82348162e-02f, -1.45756779e-02f, 1.60649374e-01f, 1.48840904e-01f, -1.37871310e-01f, 6.42351210e-02f, 1.98823541e-01f, 3.66638638e-02f, -2.43525282e-01f,
  -6.39321888e-03f, -3.38849351e-02f, 7.44482577e-02f, -3.88332494e-02f, -6.69958666e-02f, -5.94976358e-02f, 1.92751423e-01f, -1.19541153e-01f, 9.55331102e-02f, -3.66088673e-02f,
  -2.00371712e-01f, -6.52206615e-02f, 1.40045816e-02f, 6.22175708e-02f, -1.08375996e-02f, -1.80339080e-03f, 1.37750715e-01f, -1.24761790e-01f, 2.99103465e-02f, -1.70857191e-01f,
  1.17068999e-01f, 4.85694259e-02f, 1.17010601e-01f, -1.05649568e-02f, -1.04214616e-01f, -1.67586876e-03f, -1.33806588e-02f, 9.35083181e-02f, 6.08123727e-02f, 2.97684483e-02f,
  7.36642480e-02f, 5.87884724e-01f, 3.10753435e-02f, -1.10610135e-01f, 1.12996474e-01f, 1.85917784e-02f, 4.69058044e-02f, -1.19659550e-01f, 2.54683673e-01f, -3.12662125e-03f,
  -1.24477498e-01f, 9.64128450e-02f, -5.13839442e-03f, -4.21739742e-02f, 1.65186092e-01f, 9.29918662e-02f, 7.69656897e-02f, 2.11820658e-02f, -1.21655241e-02f, 1.01528980e-01f,
  -7.96433538e-03f, 6.84551150e-02f, -3.48564261e-03f, -1.87804595e-01f, -3.52789536e-02f, 8.16660002e-02f, -1.16188720e-01f, 2.88739372e-02f, 4.08507837e-03f, 1.96172804e-01f,
  -2.02926779e+00f, 2.78511316e-01f, -1.46097928e-01f, -9.88185287e-01f, -5.68984747e-01f, -2.48361707e-01f, -4.17602837e-01f, 1.41781271e-01f, 7.23628849e-02f, 5.79171956e-01f,
  -9.22278613e-02f, -9.01759043e-02f, 9.27380323e-01f, -1.77045047e-01f, -2.87926853e-01f, 8.94566774e-01f, -4.21694964e-01f, -1.46477401e-01f, 3.09716731e-01f, -4.88677233e-01f,
  -4.01217997e-01f, -2.44968921e-01f, -2.12606668e-01f, 1.82938740e-01f, -8.65258396e-01f, -3.09223652e-01f, -3.77661884e-01f, 3.27881351e-02f, -9.39685106e-01f, -1.58703625e-01f,
  -5.28679848e-01f, 2.30132923e-01f, -2.45547399e-01f, 2.02378348e-01f, -2.03283563e-01f, -1.40960515e-01f, -2.16347322e-01f, 9.30915698e-02f, 1.96139276e-01f, 1.01476036e-01f,
  -1.46917433e-01f, 7.54298344e-02f, 1.09665267e-01f, 2.45842546e-01f, 1.94023773e-02f, -4.58636321e-02f, -6.66906163e-02f, -2.75147974e-01f, 7.26083443e-02f, 5.11972886e-03f,
  -5.91708794e-02f, -4.96718585e-02f, -2.37802431e-01f, 5.53749837e-02f, -1.56844929e-01f, 2.47204173e-02f, -1.67299639e-02f, -2.72642910e-01f, -1.45607784e-01f, -1.15944751e-01f,
  -5.97804189e-02f, 1.45494193e-01f, 3.37888151e-02f, 2.33262754e-03f, -1.72949255e-01f, 6.74523227e-03f, -1.20149411e-01f, 4.07181233e-02f, -1.37444943e-01f, -2.07775638e-01f,
  -1.52241811e-01f, 3.65936034e-03f, 2.33125314e-02f, -1.88946679e-01f, -3.25849801e-02f, 2.12692581e-02f, 8.60500485e-02f, -7.69450366e-02f, -1.07555360e-01f, -2.09496662e-01f,
  1.86755463e-01f, 4.01707664e-02f, -4.46247943e-02f, -2.79894024e-02f, 5.81181012e-02f, 1.19755929e-03f, 1.43961146e-01f, 1.24964103e-01f, -2.19142959e-02f, -2.74155408e-01f,
  -3.41834873e-01f, -3.23708087e-01f, -2.85039451e-02f, -8.10702667e-02f, 2.46539358e-02f, -5.55989183e-02f, 1.39634833e-01f, -1.22990355e-01f, -9.13632661e-02f, 5.85165098e-02f,
  -6.31395802e-02f, 8.97464156e-02f, -3.36507529e-01f, -1.22221842e-01f, -1.16268933e-01f, 6.07337896e-03f, -2.30242312e-01f, 9.07178149e-02f, -2.27064729e-01f, -1.53119266e-01f,
  -1.16376668e-01f, 7.90299922e-02f, 1.15075387e-01f, -6.25302345e-02f, 7.27421492e-02f, -1.32862940e-01f, -2.06418768e-01f, 4.93115000e-02f, -1.03975490e-01f, 8.62513036e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  8.21155608e-01f, 1.22761524e+00f, 1.02083147e+00f, 7.85830975e-01f, 1.06659496e+00f, 1.19160652e+00f, 1.36428905e+00f, 1.06131625e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.48700702e+00f, 7.14735627e-01f, -2.85131365e-01f, -7.24842787e-01f, -8.51063788e-01f, 6.67095244e-01f, 1.55592871e+00f, 1.24941325e+00f, -5.05255759e-01f, -1.25349665e+00f,
  -1.09061825e+00f, 1.02743864e+00f, -1.59262276e+00f, -1.60605121e+00f, 5.10196328e-01f, 6.63188934e-01f, -4.35355216e-01f, 1.03842044e+00f, -3.37920785e-01f, -1.34417701e+00f,
  -1.73812461e+00f, -6.80281281e-01f, -2.01644921e+00f, 1.05558944e+00f, 8.28075647e-01f, -7.27606177e-01f, -3.03351372e-01f, 1.16386640e+00f, -5.65118194e-01f, -2.17722461e-01f,
  -1.28441989e+00f, -1.81439483e+00f, 7.16657400e-01f, -1.12170696e+00f, 4.90461677e-01f, 2.56803334e-01f, 5.40253162e-01f, 1.68632519e+00f, 1.51994610e+00f, -7.53117085e-01f,
  9.47577059e-01f, -3.72281998e-01f, 1.26228109e-01f, -1.29439485e+00f, -6.89103901e-01f, -1.28134340e-01f, -1.76624835e+00f, -7.94745207e-01f, -5.33515692e-01f, -1.39308453e+00f,
  -1.85174197e-01f, -7.27071881e-01f, 1.47220612e+00f, -2.53233820e-01f, 8.28065444e-03f, -1.50792110e+00f, -1.14258659e+00f, -2.25913092e-01f, 6.21257424e-01f, 4.67543542e-01f,
  -1.40564489e+00f, -8.15302491e-01f, -5.88842452e-01f, 9.12610233e-01f, 1.31157720e+00f, -5.62557697e-01f, 2.10626051e-01f, 1.01959527e+00f, -3.90502274e-01f, 1.57725346e+00f,
  -4.65420276e-01f, -9.93747532e-01f, -3.59707385e-01f, 9.13889885e-01f, -1.41407526e+00f, 2.90590554e-01f, -9.92289126e-01f, 1.67625733e-02f, -6.77062720e-02f, 4.74916637e-01f,
  2.58216321e-01f, 5.93984902e-01f, 1.00847828e+00f, 2.81441122e-01f, 2.45800227e-01f, -1.55087483e+00f, -6.54388011e-01f, 1.68898594e+00f, -3.86795968e-01f, -1.12134981e+00f,
  -1.51183045e+00f, -4.91284072e-01f, 1.00749063e+00f, -1.59625089e+00f, 7.83920228e-01f, 5.79889834e-01f, -2.41283178e-02f, 9.52788949e-01f, -8.27290118e-03f, 2.10070163e-01f,
  8.98522317e-01f, 1.02428484e+00f, -1.02224863e+00f, -1.35281825e+00f, -1.97010532e-01f, -4.23590951e-02f, 2.18328327e-01f, -1.56286979e+00f, 1.29466069e+00f, -4.42856342e-01f,
  -1.99889934e+00f, -1.24707448e+00f, -3.15142691e-01f, 7.05253065e-01f, -9.64210331e-01f, -8.57883394e-01f, 5.62653899e-01f, -1.70361423e+00f, 1.58585504e-01f, -1.29742229e+00f,
  -9.52622533e-01f, -1.02580452e+00f, -8.45516205e-01f, -1.26218474e+00f, -1.00781584e+00f, 1.08622706e+00f, -1.00411189e+00f, 7.67017186e-01f, -8.41861367e-01f, -3.35235715e-01f,
  -9.42121804e-01f, 1.61275834e-01f, 1.59448826e+00f, -1.09281349e+00f, 1.09188581e+00f, -2.66747296e-01f, 6.34855986e-01f, -7.21053421e-01f, -4.37148601e-01f, -1.09108579e+00f,
  -8.31704974e-01f, -1.02626586e+00f, 1.03473890e+00f, -6.85151219e-01f, -3.25345814e-01f, -6.22591674e-01f, 4.22133645e-03f, 4.43133175e-01f, -8.58300745e-01f, 1.20937741e+00f,
  -1.04062176e+00f, 5.65393090e-01f, -8.82618845e-01f, -6.74612641e-01f, -1.13610137e+00f, -1.25905871e+00f, 1.80733614e-02f, 1.28183556e+00f, 7.99572468e-01f, -1.30790985e+00f,
  7.25603282e-01f, 7.25340188e-01f, 4.50914055e-01f, 6.19597454e-03f, -1.12349463e+00f, -7.29258597e-01f, 5.97314596e-01f, 1.32788777e+00f, -1.22615540e+00f, -4.40186858e-01f,
  1.30338454e+00f, -1.13666689e+00f, -9.39286530e-01f, -7.47438312e-01f, -6.32125795e-01f, -5.44764876e-01f, 5.49256429e-02f, -9.42325413e-01f, 4.98346388e-01f, -1.83595642e-01f,
  3.11430633e-01f, -1.18687689e+00f, 1.26641536e+00f, -5.20164728e-01f, -1.59329998e+00f, 1.41260302e+00f, -4.02133733e-01f, -9.47456896e-01f, 1.60561010e-01f, -1.47715616e+00f,
  7.33776033e-01f, -1.08650744e+00f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  1.60532817e-01f, -1.97742805e-02f, -5.88060260e-01f, -5.84007204e-01f, 5.21274328e-01f, 2.92931765e-01f, -3.17297466e-02f, 8.16463113e-01f, -3.47659528e-01f, -3.43825012e-01f,
  -5.99067323e-02f, -1.31201044e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    