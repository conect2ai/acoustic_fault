/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.73628516e-02f, 1.61746413e-01f, 2.06386864e-01f, 1.94027368e-02f, 3.34481239e-01f, 2.63656843e-02f, 5.74250035e-02f, 2.98294246e-01f, 3.73643756e-01f, -2.20362723e-01f,
  -1.75496235e-01f, -2.69909222e-02f, -1.32565260e-01f, -1.21096052e-01f, -1.56289041e-01f, -2.02969730e-01f, -6.56019971e-02f, -5.71383536e-02f, 3.76358658e-01f, 7.65938014e-02f,
  4.08406295e-02f, -1.97427362e-01f, -4.93761599e-02f, 4.82127182e-02f, 4.22695652e-02f, 1.34002268e-01f, -1.11852273e-01f, 1.42796993e-01f, -2.60911826e-02f, 1.65608060e-02f,
  -7.89883807e-02f, 6.34563342e-02f, 2.86313556e-02f, -6.06979430e-02f, -1.02025285e-01f, 9.64567903e-03f, -8.67185444e-02f, -2.14407649e-02f, 6.90166354e-02f, -4.25188281e-02f,
  -1.90477874e-02f, -5.67182973e-02f, 3.06157600e-02f, 6.55163154e-02f, 9.74783897e-02f, 2.16820557e-02f, 1.03626482e-01f, 1.18752912e-01f, 7.37308040e-02f, -1.20259831e-02f,
  1.29724899e-02f, -2.40551848e-02f, 7.88524300e-02f, 5.52665442e-03f, 6.99124858e-02f, 3.83915864e-02f, 8.41193274e-02f, 4.19408269e-02f, -4.44490882e-03f, 9.03286331e-04f,
  4.26843204e-03f, 6.89340085e-02f, -7.83807337e-02f, -5.88080138e-02f, 5.58963455e-02f, -5.90490215e-02f, -2.39361660e-03f, -3.00359707e-02f, 9.95891914e-02f, -1.12282149e-01f,
  4.70677912e-02f, 5.22407405e-02f, 5.49217574e-02f, 6.54576346e-02f, 3.03312931e-02f, -5.99068329e-02f, -6.13530213e-03f, -4.28315103e-02f, 2.41261139e-03f, 6.80322126e-02f,
  -3.07803918e-02f, -3.62143330e-02f, -1.00315288e-02f, -6.28710538e-02f, -3.12740952e-02f, 4.09674421e-02f, -6.26926422e-02f, -3.99214253e-02f, 4.16612588e-02f, -3.99201363e-02f,
  -3.05170398e-02f, 7.67325759e-02f, 9.59758461e-03f, -8.58634189e-02f, 2.83626299e-02f, 1.63479298e-02f, -4.20882786e-03f, -2.74511259e-02f, 1.61098056e-02f, -1.12776391e-01f,
  2.40947977e-02f, -2.19213385e-02f, -3.83832604e-02f, 4.27127592e-02f, -1.05973028e-01f, -1.83222035e-03f, 2.39843782e-02f, 6.21210225e-02f, -3.52089815e-02f, -4.87177968e-02f,
  -5.55088930e-02f, -3.70345660e-03f, 4.39053997e-02f, 7.09639192e-02f, 4.31870371e-02f, -3.76462862e-02f, 6.04240671e-02f, 6.82783350e-02f, -9.15324502e-03f, -5.25718294e-02f,
  4.25093710e-01f, -4.58554357e-01f, 1.10472269e-01f, 4.81844805e-02f, 6.53217882e-02f, -1.49027541e-01f, 1.13951840e-01f, -2.49735042e-02f, 6.49269298e-02f, -2.48489439e-01f,
  -5.36403544e-02f, -9.09504145e-02f, -1.87538937e-01f, -2.21475348e-01f, -5.08768819e-02f, -2.42709711e-01f, -6.00360008e-03f, -8.05036724e-02f, 2.34351344e-02f, -4.27118279e-02f,
  1.51824830e-02f, -5.80264293e-02f, 1.31091801e-02f, 9.58210416e-03f, 3.30238305e-02f, 1.96130052e-01f, -8.16762745e-02f, 1.68767840e-01f, -8.47698897e-02f, -6.32335916e-02f,
  -1.41322482e-02f, 3.84730808e-02f, 8.79018474e-03f, -1.63352266e-02f, 8.29252154e-02f, 8.02226216e-02f, 4.60614301e-02f, -3.68108302e-02f, 1.27230957e-01f, -5.22131696e-02f,
  8.98779463e-03f, -2.15409361e-02f, -2.57169101e-02f, -7.67734423e-02f, 7.50793964e-02f, -4.57539074e-02f, 2.66360305e-03f, 1.79084614e-02f, -1.19581828e-02f, 1.80309024e-02f,
  3.63039644e-03f, -8.89901165e-03f, 6.35906309e-02f, -4.98994365e-02f, 6.00139648e-02f, 5.99081516e-02f, 3.78099689e-03f, -1.70196425e-02f, -7.09082037e-02f, -1.28200054e-01f,
  4.07743640e-03f, 8.57845508e-03f, -1.16807505e-01f, 1.96426846e-02f, -1.41558632e-01f, 1.06562659e-01f, -3.69157828e-02f, 4.35744487e-02f, 1.12939425e-01f, -1.22327562e-02f,
  9.77323279e-02f, 5.75959273e-02f, -4.17654775e-02f, -4.54033278e-02f, 9.72131044e-02f, -3.06726270e-03f, -5.22361957e-02f, -2.26317551e-02f, 2.32438482e-02f, 1.08299814e-01f,
  1.80176627e-02f, -8.42901245e-02f, 4.78923647e-03f, 1.41754430e-02f, 5.24411611e-02f, 5.32979891e-02f, -6.36998340e-02f, -5.49267083e-02f, 4.18846309e-03f, 4.33674492e-02f,
  -1.32525846e-01f, -1.87298521e-01f, -5.52587509e-02f, -2.24868823e-02f, -9.96733680e-02f, 2.33283211e-02f, -5.12442850e-02f, -8.09377711e-03f, -9.67473388e-02f, -3.56465392e-02f,
  4.60385159e-02f, 8.01781658e-04f, -1.80505216e-02f, 9.72266942e-02f, -8.33375528e-02f, 1.43803544e-02f, -3.81273367e-02f, -1.68380830e-02f, -7.00908750e-02f, 1.52144050e-02f,
  -2.52900124e-02f, 4.72091474e-02f, 1.14385471e-01f, 1.14280321e-01f, 6.25911728e-02f, -3.61342728e-02f, -1.91903915e-02f, 6.29213527e-02f, -2.19996255e-02f, -3.38481329e-02f,
  -2.58745253e-01f, -3.02538514e-01f, -3.14556248e-02f, -4.79596816e-02f, -3.05378698e-02f, -1.05987094e-01f, 6.23095818e-02f, -1.29222229e-01f, -4.00230557e-01f, -9.75204073e-03f,
  1.14369072e-01f, -1.28196517e-03f, 4.67578918e-02f, -7.20325857e-02f, 2.24749669e-01f, 1.92910768e-02f, -9.74437371e-02f, 1.41754061e-01f, -1.07445359e-01f, 1.18157104e-01f,
  7.33512864e-02f, -2.21514218e-02f, 2.61593044e-01f, 5.61748780e-02f, -6.36230782e-02f, 1.25791132e-01f, 3.65477145e-01f, 1.69568196e-01f, 1.91064462e-01f, 6.84379935e-02f,
  -1.25454776e-02f, -5.57042249e-02f, -1.06920497e-02f, -1.51772723e-01f, 1.05668150e-01f, -6.31961375e-02f, -3.95062119e-02f, 1.07471906e-01f, 1.24262590e-02f, 3.88163626e-02f,
  -8.18958580e-02f, 4.45180796e-02f, -7.25774318e-02f, 2.52793469e-02f, -6.15834147e-02f, -1.56178912e-02f, 4.68079075e-02f, -7.42368177e-02f, -3.24415304e-02f, 4.84701544e-02f,
  -6.91240234e-03f, -2.59689093e-02f, -9.01814029e-02f, -8.13254416e-02f, -3.15168723e-02f, -1.09529383e-02f, 4.11135890e-02f, 5.62644564e-02f, 2.49865912e-02f, -1.13892397e-02f,
  7.85323419e-03f, -8.52014944e-02f, 9.08542201e-02f, -1.93280086e-03f, 4.45607025e-03f, -8.19509558e-04f, -6.98712096e-02f, 1.71612337e-01f, 4.02904348e-03f, -6.60508871e-03f,
  -4.00243588e-02f, 1.25351250e-01f, 2.91244816e-02f, 5.30267395e-02f, 2.24851612e-02f, -7.35305920e-02f, 1.84187037e-03f, 1.67064480e-02f, 6.67385980e-02f, 4.58139963e-02f,
  -4.33304980e-02f, -1.10763451e-02f, 2.02909738e-01f, -7.24223554e-02f, 3.70908063e-03f, 6.68633878e-02f, -7.64736235e-02f, -3.60041410e-02f, -5.60944481e-03f, 6.93415701e-02f,
  -1.22821545e-02f, 1.11777358e-01f, -4.96174097e-02f, -1.06934972e-01f, 4.04351018e-02f, -1.68535113e-02f, -1.13631912e-01f, -3.77862602e-02f, -7.98614994e-02f, -6.32431405e-03f,
  9.70299076e-03f, 2.04159692e-02f, 1.53407091e-02f, -3.77814695e-02f, 9.83935967e-02f, 7.57964179e-02f, -1.23376120e-02f, -2.23670006e-02f, 4.04249132e-02f, 6.98678866e-02f,
  5.62015399e-02f, 5.73424473e-02f, 1.05464078e-01f, -9.25069228e-02f, -1.18881449e-01f, 1.39839172e-01f, 9.26736146e-02f, 8.40387419e-02f, 3.42933275e-02f, -2.51987353e-02f,
  -2.04770029e-01f, -1.70591250e-01f, -1.26465231e-01f, -3.04778397e-01f, -5.95293641e-02f, -4.24551498e-03f, -6.80549629e-03f, -1.71950445e-01f, -9.51527059e-02f, 6.14704862e-02f,
  3.19386907e-02f, -1.32910803e-01f, 2.94181909e-02f, -8.19913149e-02f, 8.28530267e-02f, 4.48527485e-02f, -1.68913230e-01f, -2.50548478e-02f, 1.30019590e-01f, -1.52986810e-01f,
  1.21947275e-02f, -1.67054590e-02f, 1.15056515e-01f, 8.39039870e-03f, -7.32450420e-03f, -1.06251100e-02f, 2.70400457e-02f, 6.64302632e-02f, -3.91146773e-03f, 7.51275942e-02f,
  5.40342219e-02f, 6.90787584e-02f, -4.77796234e-02f, 4.42278534e-02f, 4.78593931e-02f, 1.46635203e-02f, 1.19914457e-01f, 1.75188720e-01f, -3.93595807e-02f, 1.99235063e-02f,
  7.87736624e-02f, 8.32121596e-02f, 7.94204548e-02f, 1.14401905e-02f, 2.29064170e-02f, -4.93563414e-02f, -2.12449338e-02f, -2.96684355e-02f, 2.78227776e-02f, 2.13498045e-02f,
  -8.56587589e-02f, 1.52508980e-02f, -1.21106535e-01f, 5.51021174e-02f, 1.31901085e-01f, -1.99013855e-02f, 5.19472063e-02f, -1.00117154e-01f, -3.76055650e-02f, -7.64568523e-02f,
  3.12403031e-02f, -6.58252314e-02f, -1.28940539e-02f, 5.10515086e-02f, 1.29436720e-02f, 5.43672182e-02f, -2.95252521e-02f, 4.98976074e-02f, 4.83612828e-02f, -4.95998538e-04f,
  1.98942572e-02f, -3.44905369e-02f, -1.14597462e-01f, 6.55159727e-03f, 7.01675145e-03f, -7.43061975e-02f, -3.49479495e-03f, 1.51860025e-02f, 9.06614587e-03f, 1.59021430e-02f,
  -7.07954690e-02f, 7.36173838e-02f, 1.60774052e-01f, 7.23338947e-02f, -1.02374263e-01f, 1.31469011e-01f, 4.94923182e-02f, -3.20058800e-02f, -1.12408446e-02f, -7.63421506e-02f,
  -6.21227399e-02f, -4.41927388e-02f, 4.70072478e-02f, 7.24028721e-02f, 7.53621757e-02f, -3.94038707e-02f, 1.68330655e-01f, 2.95831989e-02f, -3.16414125e-02f, 4.77402797e-03f,
  1.55947180e-02f, 6.71717301e-02f, -3.49503532e-02f, -4.13090959e-02f, -2.24210378e-02f, 4.84897345e-02f, -9.93035436e-02f, -1.19182626e-02f, -5.00180759e-02f, -3.75869684e-02f,
  -4.91418876e-02f, -3.89113463e-02f, 5.57908900e-02f, 4.91448902e-02f, 1.58153847e-01f, 7.74265006e-02f, 4.94257733e-03f, -3.55241820e-02f, 1.52354926e-01f, 2.44251136e-02f,
  2.40281388e-01f, -5.37323616e-02f, 1.16178825e-01f, 1.31650910e-01f, -1.28156617e-01f, 2.19860494e-01f, 4.20364261e-01f, -6.41496107e-02f, -1.02078535e-01f, 2.84831878e-02f,
  3.11280668e-01f, 8.35148096e-02f, 1.50951326e-01f, 2.36001983e-01f, 2.97980398e-01f, -2.79083177e-02f, 1.62450373e-01f, 1.34989560e-01f, -5.70211187e-02f, 7.38587603e-02f,
  9.07419026e-02f, 2.43304893e-01f, 1.67010888e-01f, -5.97898997e-02f, 1.79852545e-01f, -6.32282197e-02f, -6.28501251e-02f, 2.07715780e-02f, 5.82058467e-02f, 1.77616879e-01f,
  4.83415462e-02f, 2.83042975e-02f, 1.41481124e-02f, 9.46995709e-03f, 2.86891460e-02f, 3.92286740e-02f, 1.38809830e-01f, 1.32371351e-01f, -2.63816509e-02f, 5.18297637e-03f,
  2.93849912e-02f, -9.11241211e-03f, 1.01842768e-01f, -6.04585372e-02f, -7.29277655e-02f, -1.07055373e-01f, -5.88137619e-02f, 1.22432865e-01f, -3.76661718e-02f, 6.73823943e-03f,
  -1.24874692e-02f, 8.87703430e-03f, -6.00955226e-02f, -3.81415710e-02f, -3.73416618e-02f, 5.69503494e-02f, -7.67431920e-03f, -1.01158367e-02f, -3.14178243e-02f, -6.85020834e-02f,
  2.10900679e-02f, 4.26776297e-02f, -2.37043910e-02f, 2.80706305e-02f, 5.03293760e-02f, -4.61331755e-03f, 4.97965589e-02f, -1.01675373e-02f, 3.23342485e-03f, 4.54325825e-02f,
  5.56724321e-04f, -5.21110669e-02f, 1.99720450e-02f, -2.08626725e-02f, -4.90126759e-02f, -2.46312958e-03f, 3.65641415e-02f, -1.36251627e-02f, -5.26362769e-02f, 6.67822286e-02f,
  3.05678416e-02f, 2.47328244e-02f, -2.57312208e-02f, 9.70524400e-02f, -6.61895471e-03f, 1.65782906e-02f, -6.62619472e-02f, -1.96235217e-02f, 4.06832024e-02f, 9.82181579e-02f,
  2.78160609e-02f, -1.76484928e-01f, 2.87386309e-02f, 7.42780976e-03f, -5.75971156e-02f, -1.02834962e-01f, 5.21970913e-02f, -1.78176425e-02f, 5.41812330e-02f, 2.37377621e-02f,
  3.66244987e-02f, 5.68119902e-03f, -8.25923309e-02f, 7.74466014e-03f, -2.21311152e-02f, -8.77274722e-02f, -2.02413760e-02f, -2.76784580e-02f, -3.64180505e-02f, -1.52584642e-01f,
  -5.22897020e-02f, -4.41127978e-02f, -5.68909198e-02f, -2.84133339e-03f, 7.72277068e-04f, 9.63729173e-02f, -2.12146193e-01f, 1.86163152e-03f, -4.11913916e-02f, 2.57927347e-02f,
  -2.14547381e-01f, 2.41656676e-01f, -2.69582748e-01f, -2.83514168e-02f, -1.99420974e-01f, -1.83626860e-01f, 9.39496830e-02f, -6.30196184e-02f, -2.04840213e-01f, 1.36141047e-01f,
  -1.35646805e-01f, -1.25594735e-01f, 1.65168405e-01f, -2.46333648e-02f, -6.54329220e-03f, 1.56286448e-01f, -1.59295574e-02f, -1.53036844e-02f, 1.24796942e-01f, 6.79549426e-02f,
  -5.08146510e-02f, 1.79658607e-01f, 1.20744780e-01f, 2.39673294e-02f, -7.61870146e-02f, -1.56578600e-01f, 4.51995321e-02f, 6.31516278e-02f, -1.20455191e-01f, -5.24443053e-02f,
  -1.79962274e-02f, 7.19850734e-02f, -5.49102351e-02f, -5.63834235e-02f, -2.56190766e-02f, -6.18597828e-02f, -1.00845769e-01f, -4.41543460e-02f, 3.46200466e-02f, -1.25036716e-01f,
  9.74583905e-03f, -1.62389919e-01f, -5.53863309e-02f, -3.14544812e-02f, 2.98789032e-02f, -8.81309137e-02f, -6.63443729e-02f, -6.46396801e-02f, -7.81308711e-02f, 3.14804614e-02f,
  -7.41929039e-02f, -1.22537024e-01f, -1.05639033e-01f, -1.51784167e-01f, -5.37444837e-02f, -1.24458037e-01f, 2.92480011e-02f, -4.18021604e-02f, -5.68212047e-02f, 3.00926768e-04f,
  8.20618495e-02f, 1.37529895e-01f, -1.91182923e-02f, -6.33857250e-02f, -6.88301176e-02f, -5.73117211e-02f, -4.32502963e-02f, -4.68385778e-02f, 3.69264185e-02f, -4.67480682e-02f,
  -9.11278576e-02f, -6.24032281e-02f, -1.44509347e-02f, -2.90815271e-02f, 7.26402029e-02f, 4.50331904e-02f, -6.42322451e-02f, 1.64991536e-03f, 2.11815052e-02f, 4.78689373e-02f,
  5.56067340e-02f, -1.09692320e-01f, 3.43103358e-03f, -9.44745541e-02f, -6.83136210e-02f, 3.19883157e-03f, -5.73517568e-02f, -4.84076627e-02f, 3.20380181e-02f, 4.58432641e-03f,
  1.06207713e-01f, 2.93351769e-01f, 1.60560504e-01f, -1.13345064e-01f, -1.91921741e-02f, -6.83793873e-02f, 1.78527847e-01f, -1.69978179e-02f, 8.76617134e-02f, 4.42824513e-02f,
  1.00635402e-01f, -5.85926995e-02f, -1.82737205e-02f, -9.17950794e-02f, 5.30956686e-02f, 2.58308575e-02f, -4.51813750e-02f, 2.04721875e-02f, 3.27419750e-02f, 1.23149175e-02f,
  -8.73141736e-02f, 1.11446483e-02f, -4.17719083e-03f, -3.96855548e-02f, 3.94409038e-02f, -8.84471685e-02f, 2.16999445e-02f, -6.58831075e-02f, -4.87718694e-02f, -3.33125181e-02f,
  -4.10857648e-02f, 1.69340476e-01f, 3.38909596e-01f, 1.17178328e-01f, -2.55166322e-01f, -3.49794216e-02f, 1.99434116e-01f, -1.66118160e-01f, 9.36986655e-02f, -6.05306812e-02f,
  2.93472949e-02f, 1.77854493e-01f, 2.02479452e-01f, -1.11811765e-01f, -1.50710747e-01f, 1.85651973e-01f, -1.92171454e-01f, -6.14625961e-03f, 1.91397697e-01f, -5.38342334e-02f,
  1.65579300e-02f, -2.39690825e-01f, 9.56533924e-02f, -1.77153975e-01f, -6.07758798e-02f, 2.37024352e-02f, -1.96239397e-01f, 1.55988440e-01f, -2.04527810e-01f, -1.16668321e-01f,
  -1.30522937e-01f, -7.63669703e-03f, 8.62252042e-02f, 1.30183846e-01f, -9.41739827e-02f, 1.09980544e-02f, -1.01204617e-02f, 5.24141788e-02f, 6.36378899e-02f, 9.33546573e-02f,
  1.70548763e-02f, -1.59265287e-02f, -2.44157612e-02f, 9.56216641e-03f, 2.67513283e-02f, -1.60527322e-02f, -3.72512080e-02f, 2.01227646e-02f, 2.21234709e-02f, 1.03824198e-01f,
  6.85051307e-02f, 3.04959677e-02f, -5.03588989e-02f, 2.53718216e-02f, 5.17030507e-02f, 7.87852798e-03f, -1.37557061e-02f, 9.12070051e-02f, -3.02350279e-02f, -7.04218680e-03f,
  -2.93720197e-02f, 1.06964253e-01f, 7.09278286e-02f, -7.70562217e-02f, -1.81946717e-02f, -6.49742857e-02f, -1.56533043e-03f, -7.66172409e-02f, -6.11808896e-02f, -2.61968188e-02f,
  -3.64594124e-02f, 3.19700949e-02f, 9.45540611e-03f, 5.49172275e-02f, 1.09183036e-01f, -1.81236432e-03f, 4.99938354e-02f, -7.87547231e-02f, 7.55602168e-03f, 4.75300476e-02f,
  -2.81279590e-02f, -5.05691115e-03f, 2.59822272e-02f, 6.14694611e-04f, 2.09523812e-02f, -2.41652355e-02f, 2.82725152e-02f, 5.04855812e-02f, 6.28659427e-02f, 6.67344928e-02f,
  -2.32469261e-01f, -2.09454909e-01f, -9.49093178e-02f, -4.38280553e-02f, -6.69742450e-02f, -3.50634120e-02f, 7.52947405e-02f, 6.10831892e-04f, -6.85503846e-03f, 9.87209454e-02f,
  -1.19297216e-02f, -2.30175685e-02f, -9.53320265e-02f, 5.78189194e-02f, 2.51149870e-02f, 1.00412285e-02f, -3.00597548e-02f, -3.93825397e-02f, -5.22012375e-02f, -9.13084447e-02f,
  -1.11003011e-01f, -4.02545221e-02f, -4.74542752e-02f, -3.25795487e-02f, 3.11866379e-03f, -8.36324245e-02f, -5.44930100e-02f, 8.80439058e-02f, -8.19186047e-02f, 5.15819564e-02f,
  1.40188351e-01f, -8.27283412e-02f, -4.08971399e-01f, 8.49405304e-02f, -6.88899904e-02f, 1.06985658e-01f, -9.59626809e-02f, -4.22867388e-03f, -9.39650312e-02f, 1.58300176e-01f,
  1.68320134e-01f, -1.40255526e-01f, -3.86237800e-02f, 9.53707099e-02f, -9.49652269e-02f, -3.22754122e-02f, 1.92955181e-01f, 2.65919380e-02f, -2.78491564e-02f, -5.50753325e-02f,
  -3.10025793e-02f, 1.38284519e-01f, -6.12336434e-02f, 6.75209686e-02f, 1.10027343e-01f, 4.81260866e-02f, 1.51766881e-01f, -1.19453277e-02f, 1.93601653e-01f, 2.05277205e-02f,
  1.45365313e-01f, 1.20055944e-01f, 8.23239610e-02f, 2.35249586e-02f, 1.28794774e-01f, -3.50623168e-02f, -2.81687500e-03f, -4.54297438e-02f, 4.36921902e-02f, -5.57637438e-02f,
  -3.49841267e-02f, -1.17796607e-01f, -6.16963543e-02f, -7.87499920e-02f, 1.50327340e-01f, -1.16894245e-01f, -4.51895297e-02f, 5.24740592e-02f, -1.27968475e-01f, 9.51253984e-04f,
  -8.07897076e-02f, 7.29469908e-03f, 6.33974373e-02f, -7.39383325e-02f, -8.03403482e-02f, 1.09776862e-01f, -1.63023815e-01f, -5.26339747e-02f, 2.00987030e-02f, 1.82318166e-02f,
  5.90684898e-02f, -9.91780609e-02f, 1.92139857e-02f, -6.75977096e-02f, -1.85030373e-03f, -6.84549585e-02f, -1.38700129e-02f, -6.46824166e-02f, 6.87535619e-03f, 7.45715722e-02f,
  2.88033094e-02f, 5.21517731e-02f, 3.42209674e-02f, 8.76215920e-02f, 3.16832475e-02f, 1.39603261e-02f, 3.89328860e-02f, 4.79239598e-03f, 2.53003985e-02f, 2.81658545e-02f,
  -1.36960506e-01f, -3.02705895e-02f, -7.19322115e-02f, -7.30207860e-02f, 6.71599433e-02f, -5.58989085e-02f, -2.40009674e-03f, -3.37557755e-02f, -3.88314687e-02f, 4.28903066e-02f,
  3.37846428e-01f, 1.44516736e-01f, 4.76479568e-02f, 6.67582080e-02f, -1.36841871e-02f, 9.62004811e-02f, -1.29454017e-01f, 6.09650984e-02f, 1.17075108e-01f, 3.81939188e-02f,
  4.95576747e-02f, -1.85862556e-02f, -5.28957471e-02f, 4.05918695e-02f, -2.41276040e-03f, -2.90536210e-02f, -3.06541678e-02f, 3.55023853e-02f, 7.89051503e-02f, 1.47719234e-01f,
  1.64279714e-02f, -7.42370188e-02f, -4.27911542e-02f, -5.99831529e-02f, 3.22026834e-02f, 1.15885049e-01f, 6.00298913e-03f, 5.10077691e-03f, -2.29202746e-03f, -1.83607806e-02f,
  3.87242258e-01f, 2.26539969e-02f, 3.41401488e-01f, 4.70713526e-01f, 3.82307321e-02f, -3.95330727e-01f, -7.32091665e-02f, -1.19320400e-01f, 1.44485697e-01f, -2.19932586e-01f,
  -1.82447210e-01f, 3.62015247e-01f, -7.78270140e-02f, 7.45911896e-02f, 2.41875291e-01f, -1.75437048e-01f, 9.26186610e-03f, 1.36715427e-01f, 1.15354903e-01f, 7.14639621e-03f,
  1.40270680e-01f, -1.93145648e-01f, 2.09427953e-01f, -1.24940753e-01f, 1.05826119e-02f, 1.40583232e-01f, -2.08484363e-02f, -6.11670353e-02f, -7.94273708e-03f, 2.90495902e-02f,
  -3.75119001e-02f, 4.50724550e-02f, 4.62374315e-02f, -6.86148833e-03f, -9.25140530e-02f, -3.75163294e-02f, -3.16360593e-02f, 4.43883091e-02f, 1.25456452e-01f, -2.22150870e-02f,
  5.29848076e-02f, -1.26138795e-02f, -8.57654586e-02f, 3.84788848e-02f, -6.77231094e-03f, 8.57803971e-02f, 2.12328713e-02f, 5.45105198e-03f, 8.95479545e-02f, 2.10359637e-02f,
  6.27270415e-02f, 3.89466137e-02f, -2.58983858e-03f, -7.18615279e-02f, 4.09008712e-02f, 3.74887288e-02f, -2.04520896e-02f, 1.64308529e-02f, -5.64282537e-02f, 5.27858362e-02f,
  -6.73478767e-02f, -7.34237656e-02f, -5.77010997e-02f, 1.22382529e-01f, 2.72594113e-02f, 8.07697549e-02f, 9.77391154e-02f, 3.47685963e-02f, -4.01678681e-02f, 5.25831059e-02f,
  6.20043278e-02f, 7.90534392e-02f, -1.93179566e-02f, 7.54445558e-03f, 6.42279536e-02f, -1.56523250e-02f, 3.80962864e-02f, 7.97944237e-03f, 4.76836748e-02f, 2.25429796e-02f,
  -2.65433779e-03f, -1.49769085e-02f, 8.49921480e-02f, -1.04921415e-01f, -5.29606864e-02f, 5.05910441e-02f, -1.60367843e-02f, 1.11358196e-01f, -3.30259986e-02f, 5.07838503e-02f,
  -1.08377151e-01f, -1.45950496e-01f, 4.27417383e-02f, 6.54407144e-02f, 1.49165699e-02f, -1.30238319e-02f, -3.40957977e-02f, -3.64322588e-02f, 1.21873803e-02f, -1.05415238e-02f,
  -3.51757072e-02f, 6.89642504e-02f, -1.07850634e-01f, 6.90298527e-02f, -1.90841523e-03f, -6.43755570e-02f, -9.05400142e-02f, 8.27144608e-02f, -7.33498260e-02f, -7.07994327e-02f,
  -6.33888738e-03f, -7.22756758e-02f, -2.52297032e-03f, -1.81143079e-02f, -5.42934760e-02f, -8.59714001e-02f, -6.57475069e-02f, 4.91122492e-02f, -5.29880449e-02f, 9.84628405e-03f,
  1.33801758e-01f, 1.62076235e-01f, 3.08749259e-01f, 5.01515567e-01f, -7.49710649e-02f, -1.87684268e-01f, 7.79166296e-02f, 8.76742974e-02f, 3.33474576e-01f, -4.72448058e-02f,
  -2.06705183e-01f, 1.47204027e-01f, 9.30988714e-02f, 5.85670285e-02f, -6.75073713e-02f, 2.02616811e-01f, -5.21615930e-02f, -2.10220404e-02f, 5.87858297e-02f, 1.63586915e-01f,
  1.04239918e-01f, -1.78906266e-02f, 2.88846083e-02f, -3.01330760e-02f, -5.89475557e-02f, 7.91122168e-02f, -1.87734455e-01f, -8.99654180e-02f, -2.00350836e-01f, -1.98077649e-01f,
  1.01943109e-02f, 1.68613881e-01f, -3.43484767e-02f, -6.34268895e-02f, 6.20659366e-02f, -1.21865189e-03f, -3.70441116e-02f, -6.90898895e-02f, 1.56838503e-02f, 3.92447449e-02f,
  6.89593107e-02f, 1.01735197e-01f, -4.57081497e-02f, 9.67372954e-03f, 1.36658587e-02f, -4.85867634e-02f, 4.89254072e-02f, -3.35256346e-02f, -7.11186370e-03f, 3.26077081e-02f,
  2.25086361e-02f, -5.20213693e-02f, 2.68472172e-02f, 2.46059839e-02f, -1.01440072e-01f, 5.12413532e-02f, 2.55910531e-02f, -6.75482908e-03f, -2.79826950e-02f, 6.91435188e-02f,
  -3.31901014e-02f, 2.26039551e-02f, 2.82657356e-03f, 4.42473888e-02f, 1.18983366e-01f, -2.05729660e-02f, 5.63087538e-02f, -6.13801926e-02f, 8.12709630e-02f, -1.89121421e-02f,
  6.29303232e-02f, -2.19889712e-02f, -6.39584567e-03f, 8.30508769e-02f, 2.09642388e-02f, 5.87025732e-02f, 1.98755357e-02f, 6.75237924e-02f, 7.79025303e-03f, -1.96779501e-02f,
  -1.79500263e-02f, -1.99083481e-02f, -4.36609797e-02f, -2.59017497e-02f, -4.00251895e-02f, 2.46303957e-02f, 2.32503712e-02f, 1.22510083e-02f, -4.01814766e-02f, -4.42424938e-02f,
  1.22356880e-02f, 1.82357147e-01f, -8.28467831e-02f, -5.79213798e-02f, 5.77191859e-02f, -6.52892217e-02f, 6.30332157e-02f, 1.61967501e-02f, 4.98377755e-02f, -3.09913605e-03f,
  -2.89139580e-02f, 4.00748737e-02f, -5.12283966e-02f, 2.13101469e-02f, -1.27037629e-01f, -9.24716424e-03f, 1.34859597e-02f, -2.93609221e-02f, -1.00041896e-01f, -5.30376062e-02f,
  -6.94626421e-02f, 8.29370096e-02f, -2.67109200e-02f, -3.64551693e-02f, 1.16283877e-03f, -6.59958944e-02f, -1.03409022e-01f, -7.02829659e-02f, -3.32366265e-02f, 4.76685129e-02f,
  -4.44887251e-01f, 6.98696002e-02f, 9.33205262e-02f, -3.29938471e-01f, 2.66786874e-03f, 1.49153937e-02f, -2.93550175e-02f, -4.55742590e-02f, -1.65582329e-01f, -2.46468820e-02f,
  4.75057364e-02f, -3.22962068e-02f, 1.05523355e-01f, 6.36789799e-02f, 1.16775252e-01f, 1.00902610e-01f, -8.71416833e-03f, -1.20797552e-01f, -4.78331558e-02f, -1.24846846e-01f,
  -3.32927704e-02f, -4.09343988e-02f, 2.24545911e-01f, -3.56684215e-02f, 9.78912264e-02f, -1.90998852e-01f, 7.86837488e-02f, 1.68491863e-02f, 8.47347230e-02f, 4.58995998e-02f,
  -3.48308831e-02f, -2.27910340e-01f, -4.39020386e-03f, 3.58546674e-02f, 1.07111685e-01f, 1.99525636e-02f, -6.28868267e-02f, 3.59962843e-02f, -1.44126061e-02f, -1.26087978e-01f,
  2.23864764e-02f, -1.90101918e-02f, -1.53983673e-02f, 4.99754846e-02f, -1.48642696e-02f, 4.70093302e-02f, 1.71669632e-01f, 5.37021197e-02f, 3.91338021e-02f, 9.44698453e-02f,
  4.94138747e-02f, 5.87285012e-02f, 4.41823527e-02f, -5.72337992e-02f, 5.82458340e-02f, -5.32214865e-02f, -1.08294673e-01f, -9.44303498e-02f, -6.54622354e-03f, -1.81461349e-02f,
  -2.65887077e-03f, -6.22563101e-02f, -5.41914478e-02f, -1.83684491e-02f, -6.91026542e-03f, -1.65452007e-02f, 4.59438898e-02f, 2.73861513e-02f, -3.97558548e-02f, 6.77577332e-02f,
  -2.72372607e-02f, -3.00600249e-02f, -3.92256342e-02f, 1.01620659e-01f, -1.46674141e-01f, -8.91697481e-02f, 4.62273099e-02f, -3.92176695e-02f, -2.11984515e-02f, -5.19635268e-02f,
  -2.56251730e-02f, 4.73088548e-02f, -3.91557962e-02f, 8.32962841e-02f, 3.23161706e-02f, 2.83543393e-02f, -1.06729483e-02f, 5.28725088e-02f, 1.24467656e-01f, 5.11601344e-02f,
  -1.10386945e-01f, -2.88886905e-01f, -4.83344011e-02f, -2.58252714e-02f, 4.96513918e-02f, 4.82346863e-02f, 7.38783106e-02f, 3.46753970e-02f, 8.50951597e-02f, 1.23386970e-02f,
  -8.10358971e-02f, 7.76875671e-03f, 5.46598472e-02f, 9.81831774e-02f, 8.86075106e-03f, 1.23899706e-01f, -7.37393647e-02f, -5.54553084e-02f, -2.79919952e-02f, -2.70592868e-02f,
  -5.51360846e-02f, -5.84257282e-02f, -5.12892120e-02f, 3.20463479e-02f, 4.53109927e-02f, -6.04766747e-03f, -5.45492023e-02f, -5.24807982e-02f, -1.55561781e-02f, 1.11310042e-01f,
  1.66137591e-02f, 4.08391625e-01f, 2.65912056e-01f, 7.05211759e-02f, -3.38507921e-01f, -2.67146111e-01f, -2.21536487e-01f, 1.04410097e-01f, 2.87285358e-01f, 2.87466105e-02f,
  -1.96713090e-01f, 2.58907259e-01f, 8.07619467e-02f, -2.67653055e-02f, -2.68315852e-01f, -7.14702085e-02f, -1.92909136e-01f, 2.56118085e-02f, 1.73348114e-02f, 4.11595069e-02f,
  9.63795260e-02f, -2.26979628e-01f, -5.94032370e-02f, -5.94871193e-02f, -4.14317138e-02f, 1.46010414e-01f, -1.18897900e-01f, -9.20114666e-02f, -9.72948372e-02f, -1.55705661e-01f,
  -9.44123268e-02f, 9.45617631e-02f, 1.09349981e-01f, 1.17865345e-02f, -4.23393510e-02f, -4.24811505e-02f, -9.07583311e-02f, -2.08202928e-01f, -2.69421116e-02f, -5.05024865e-02f,
  -7.10045826e-03f, -5.07799238e-02f, -1.72031168e-02f, -7.40288431e-03f, -1.01042181e-01f, -4.40690219e-02f, 4.10262905e-02f, 2.35629324e-02f, 1.10603273e-02f, 3.29587166e-03f,
  2.79348474e-02f, 7.02668577e-02f, 8.87843966e-03f, -3.91852297e-02f, 3.97484470e-03f, 3.22979428e-02f, -4.14584763e-02f, 4.59343530e-02f, -5.10247201e-02f, -8.84732231e-03f,
  -2.25774422e-02f, 1.42299794e-02f, -9.13686678e-02f, 1.22872880e-02f, -6.97285309e-03f, 3.63367759e-02f, 6.45752475e-02f, -8.98780227e-02f, -1.40206693e-02f, -2.73160338e-02f,
  6.67905286e-02f, -3.11140232e-02f, 2.02894378e-02f, -7.63224363e-02f, -4.53860722e-02f, -4.45071701e-03f, -3.25126648e-02f, 6.95818709e-03f, 5.02926521e-02f, 3.48940454e-02f,
  -8.67998749e-02f, -1.02416545e-01f, 5.36978953e-02f, 2.37535667e-02f, -1.85465775e-02f, -8.10356904e-03f, 5.61007857e-02f, -1.05351945e-02f, -4.05371152e-02f, -7.54252896e-02f,
  9.61740315e-02f, 1.61978394e-01f, 1.80974379e-02f, 1.33583210e-02f, 3.34637240e-02f, -3.06563191e-02f, 2.02069674e-02f, 7.20485076e-02f, 2.12499872e-02f, -2.62639150e-02f,
  -7.64502287e-02f, -1.03295758e-01f, 1.34666311e-02f, -5.58980405e-02f, -3.22059095e-02f, 5.12397885e-02f, 6.69692177e-03f, 5.56328930e-02f, -4.84202988e-02f, 4.72870916e-02f,
  2.40703765e-03f, -3.95635366e-02f, 5.98753057e-03f, -5.54519817e-02f, -3.41118835e-02f, 7.36978501e-02f, -6.34550452e-02f, 3.91545668e-02f, -1.21601641e-01f, 4.31194194e-02f,
  1.02359526e-01f, -8.11686590e-02f, 1.97144389e-01f, 4.45585065e-02f, 6.98342249e-02f, -4.23118860e-01f, -2.03817025e-01f, 1.22642919e-01f, -1.59723431e-01f, -1.07633099e-01f,
  3.08062928e-03f, -1.40073940e-01f, -1.54917300e-01f, -1.65743172e-01f, -2.01383829e-01f, -2.15389550e-01f, -2.21813977e-01f, -2.07056403e-01f, 2.19458528e-02f, 1.53204193e-02f,
  -2.22949371e-01f, -1.48913741e-01f, 1.06749758e-02f, 1.36217013e-01f, 7.77015164e-02f, 2.73462534e-01f, 2.75237471e-01f, 1.69120342e-01f, 1.00080624e-01f, -6.14373246e-03f,
  -2.28242408e-02f, -8.23946893e-02f, -5.90829104e-02f, 4.78442535e-02f, -3.69654745e-02f, 1.19290590e-01f, -3.44524905e-02f, 1.12321731e-02f, 2.32296363e-02f, 7.56600648e-02f,
  -7.82142878e-02f, 1.08413436e-02f, -1.74830239e-02f, 5.63366562e-02f, 2.67742891e-02f, 8.37178379e-02f, 1.72175281e-02f, 4.84266840e-02f, 7.50143453e-02f, -3.48552689e-03f,
  3.14601772e-02f, 1.09328233e-01f, 4.64359485e-02f, -4.03237306e-02f, -4.62647565e-02f, -1.89713817e-02f, -3.88073064e-02f, -2.63689440e-02f, 1.33938938e-01f, -1.14544830e-03f,
  -1.05013393e-01f, -1.46151394e-01f, 6.43162504e-02f, 2.03602180e-01f, 2.58953199e-02f, 3.09287980e-02f, -1.12873986e-01f, 2.12522969e-02f, 8.87818914e-03f, 4.58429679e-02f,
  1.94770657e-02f, 4.65010032e-02f, 3.56283821e-02f, -3.08993794e-02f, -7.44978338e-02f, 3.54253314e-02f, 9.70781446e-02f, 3.35702524e-02f, 3.09381001e-02f, 6.05566055e-02f,
  -7.50171244e-02f, -3.47360261e-02f, 3.95672210e-02f, 5.02245277e-02f, -4.44415724e-03f, -1.04667403e-01f, -1.02988416e-02f, 5.14135435e-02f, 3.65627930e-02f, 4.78685163e-02f,
  -2.13685796e-01f, -1.79088622e-01f, -3.21229883e-02f, -1.78887811e-03f, -5.32808341e-02f, 3.15075926e-02f, -2.29820795e-02f, -3.24403271e-02f, -1.04655772e-01f, -6.64525703e-02f,
  -6.99793175e-02f, -1.70255441e-03f, 4.92140353e-02f, 4.88513485e-02f, 3.30421627e-02f, 4.03838903e-02f, -3.29556665e-03f, -8.22468251e-02f, -4.25160937e-02f, 4.09734482e-03f,
  4.50560004e-02f, 1.75936911e-02f, 7.20855454e-03f, 1.16583548e-01f, 8.25276040e-03f, 1.48002896e-02f, 3.17363814e-02f, 3.80702205e-02f, 1.08445033e-01f, -1.02442198e-01f,
  1.11829132e-01f, -3.30876291e-01f, 1.13840908e-01f, 7.59215057e-02f, 2.11815968e-01f, 1.09249480e-01f, 9.74550471e-02f, 1.54428467e-01f, 1.88009977e-01f, -1.72918886e-01f,
  -9.27468315e-02f, -2.72378415e-01f, -1.06844231e-02f, -1.61508173e-01f, 1.99161083e-01f, 2.63207108e-02f, -3.83766145e-02f, 8.95577520e-02f, -1.16609577e-02f, 1.11192549e-02f,
  -3.38446088e-02f, -1.18941024e-01f, -1.00027353e-01f, -9.75322872e-02f, -9.41759869e-02f, -9.60058793e-02f, -5.06588556e-02f, -7.91619197e-02f, -1.03275090e-01f, 8.01964756e-03f,
  -1.02109276e-01f, -6.73438460e-02f, -1.84897900e-01f, 1.16817225e-02f, -1.76098302e-01f, -1.94424018e-01f, -7.87893310e-02f, -1.96633022e-02f, -1.83732286e-02f, 2.42385771e-02f,
  -4.65661176e-02f, 7.24468194e-03f, -3.88338864e-02f, -5.08869672e-03f, 3.97702344e-02f, 1.18628889e-02f, -9.74190701e-03f, 1.12764621e-02f, -2.59753764e-02f, -2.24110112e-02f,
  -7.87625164e-02f, -3.01159248e-02f, -2.43021622e-02f, -4.09812704e-02f, -1.06314443e-01f, -6.86991140e-02f, 8.32405537e-02f, 5.45252152e-02f, -6.15608767e-02f, -1.44263655e-01f,
  8.49364176e-02f, -3.19480547e-03f, -5.58876134e-02f, -4.54876721e-02f, 8.68437737e-02f, 1.21570781e-01f, -3.17193568e-02f, 1.60862729e-01f, 5.69297634e-02f, 1.38491988e-01f,
  5.03788516e-02f, 9.99674294e-03f, 2.16068789e-01f, 1.22156255e-02f, 1.61566632e-03f, 2.96055265e-02f, -2.66899262e-02f, 1.48626640e-01f, -1.66061074e-01f, -2.35808571e-03f,
  1.04542926e-01f, -4.68867347e-02f, 5.54671399e-02f, -2.06654109e-02f, -1.07731506e-01f, -7.99576938e-02f, -1.74518123e-01f, -2.82264370e-02f, -3.91299874e-02f, 7.56492764e-02f,
  -3.01541805e-01f, -1.79240674e-01f, -8.50860029e-02f, 1.14080869e-02f, 7.48099340e-03f, -7.16562644e-02f, -2.68204957e-02f, -7.69510195e-02f, -7.11735561e-02f, 4.61551026e-02f,
  -2.81757470e-02f, -4.24533151e-02f, -1.79362431e-01f, 3.17264162e-02f, 1.77522246e-02f, -5.62150888e-02f, -4.82523777e-02f, -3.56041789e-02f, -1.64874628e-01f, -5.36554381e-02f,
  -5.96468747e-02f, -2.93441620e-02f, 6.80554733e-02f, -7.54679888e-02f, 2.68035866e-02f, -6.26425967e-02f, 6.10731132e-02f, 9.02368650e-02f, 6.09491207e-02f, -7.96329230e-02f,
  4.07622099e-01f, -7.04612285e-02f, 2.23996416e-01f, -3.29955444e-02f, 7.44923055e-02f, -9.89919081e-02f, -3.57731134e-02f, 8.24697167e-02f, -5.04377782e-02f, -1.69852614e-01f,
  2.23597717e-02f, -8.54447037e-02f, -2.61454005e-03f, -1.04210258e-01f, 7.66348615e-02f, -5.15602343e-02f, 5.32775111e-02f, 6.64756224e-02f, 8.16956237e-02f, 2.62425900e-01f,
  6.08824380e-02f, -2.23587379e-02f, 6.97685555e-02f, 2.82044038e-02f, 2.07894400e-01f, 1.72515124e-01f, 4.56681922e-02f, -9.52875540e-02f, 1.92491170e-02f, -1.06077641e-02f,
  1.51678221e-02f, 3.99527289e-02f, 9.41924304e-02f, 1.11030430e-01f, 8.79273638e-02f, 2.64887679e-02f, 4.86238264e-02f, -3.16021987e-03f, 2.38357540e-02f, 5.18204132e-03f,
  -5.30014336e-02f, 3.32804807e-02f, 2.75842864e-02f, 5.69114164e-02f, 1.88224137e-01f, -5.59891723e-02f, 4.00042310e-02f, 1.68818645e-02f, 1.00275110e-02f, 3.84826101e-02f,
  -3.83951440e-02f, 7.34727457e-02f, 1.66710228e-01f, -2.06979327e-02f, -7.71191418e-02f, 6.54531568e-02f, 1.74403414e-02f, -5.71043007e-02f, 5.92610985e-02f, 7.87757710e-02f,
  5.35834134e-02f, 8.49853605e-02f, -8.26625153e-02f, -1.76153816e-02f, 7.92267993e-02f, 7.31049478e-02f, 4.61874716e-02f, 1.99721176e-02f, -7.30909109e-02f, 1.93925928e-02f,
  -4.16451097e-02f, -5.05980477e-02f, 2.94113234e-02f, -5.54284919e-03f, 1.54366195e-02f, 3.98340728e-03f, 5.95448492e-03f, -5.81419282e-02f, -3.64505723e-02f, -1.88058671e-02f,
  2.11733039e-02f, 9.61695537e-02f, -1.34134129e-01f, -1.49321675e-01f, -2.16819369e-03f, -2.92324275e-02f, -5.96426688e-02f, -1.07035503e-01f, 1.07900374e-01f, 4.41284813e-02f,
  -8.78671184e-02f, -1.23186342e-01f, -9.83949155e-02f, 6.24949709e-02f, -2.80046593e-02f, 5.94025031e-02f, 5.33959456e-03f, 1.60603912e-03f, -7.62888342e-02f, 2.52617337e-02f,
  4.95171808e-02f, -3.27596292e-02f, 1.19007848e-01f, 5.26305325e-02f, -2.17478052e-02f, -5.06685972e-02f, 7.24150613e-03f, -9.58658084e-02f, -3.20330113e-02f, -2.01396178e-02f,
  -6.10940903e-02f, 1.11979812e-01f, -6.70181401e-03f, -6.32776618e-02f, -1.08448088e-01f, -1.84913911e-02f, 9.61712450e-02f, 2.14590039e-02f, 2.52617337e-02f, 2.25263815e-02f,
  3.68472934e-01f, 1.54899538e-01f, 1.11774635e-02f, 1.25797465e-01f, 1.19449861e-01f, -2.25418769e-02f, -2.65402738e-02f, 4.21654470e-02f, 7.02980608e-02f, -8.65707025e-02f,
  -1.06451616e-01f, 1.78510115e-01f, -1.70244247e-01f, 3.91302556e-02f, 2.42655218e-01f, -8.53005201e-02f, 2.35461280e-01f, -1.16803544e-02f, 8.68525505e-02f, 1.47792175e-01f,
  8.80809575e-02f, 7.97770098e-02f, -6.89131021e-02f, -3.73988301e-02f, 7.78436661e-02f, -5.15724421e-02f, -1.09940954e-02f, -1.37227505e-01f, -5.58043867e-02f, 2.09435727e-02f,
  -8.95130448e-03f, -2.99101472e-02f, -4.35193442e-02f, -6.07944988e-02f, 9.66833159e-03f, 7.48822140e-03f, -7.37345964e-02f, -3.49897370e-02f, -4.99890484e-02f, 3.83588746e-02f,
  7.25764409e-02f, 9.18482319e-02f, 6.51750192e-02f, 5.58953546e-02f, 1.68710165e-02f, 4.77514565e-02f, 5.70901185e-02f, 6.88620061e-02f, -7.30372667e-02f, -3.60132493e-02f,
  -4.72433828e-02f, -2.99061351e-02f, -8.02015234e-03f, 5.21045774e-02f, 8.25925078e-03f, 4.21069935e-02f, 4.66903113e-03f, 1.04164757e-01f, -3.99778038e-03f, 1.47825658e-01f,
  6.97566792e-02f, 8.83481055e-02f, -6.57463679e-03f, -5.28868064e-02f, 6.20342679e-02f, -3.03168409e-02f, -2.35110018e-02f, -4.69855443e-02f, -3.98236997e-02f, 9.01970565e-02f,
  4.22290945e-03f, -1.61250867e-02f, 3.80187519e-02f, 3.51171866e-02f, -1.79872531e-02f, -5.73056750e-02f, 3.59759107e-02f, 8.40518773e-02f, 8.02391097e-02f, 8.22876580e-03f,
  -5.25953136e-02f, 1.21153621e-02f, -2.42684800e-02f, -7.34600499e-02f, -2.23781411e-02f, -3.14599834e-02f, -4.15321738e-02f, -8.99762195e-03f, -7.12907547e-03f, 4.25225683e-02f,
  3.09534166e-02f, 1.48804531e-01f, -4.03927155e-02f, 6.55857995e-02f, -1.05186552e-01f, 7.53266513e-02f, 2.91824830e-03f, 8.51177722e-02f, 6.69475794e-02f, 9.98944044e-02f,
  6.81894049e-02f, -1.45672066e-02f, 1.86065268e-02f, 6.78498298e-02f, -6.92608431e-02f, 4.46130112e-02f, -1.91101357e-02f, 1.85162947e-02f, 6.43259212e-02f, -8.86694994e-03f,
  2.57466808e-02f, 3.75445783e-02f, -1.05325300e-02f, -1.56741422e-02f, 2.21029669e-02f, 1.34880953e-02f, 1.35836126e-02f, -7.43090734e-03f, -4.90982495e-02f, 6.10959604e-02f,
  -2.83238795e-02f, -1.63399801e-01f, 1.78871766e-01f, -2.48657852e-01f, 3.75240929e-02f, -3.04001898e-01f, -2.53398418e-01f, 1.23413496e-01f, -1.48894325e-01f, -1.51698008e-01f,
  5.58656901e-02f, 1.58394545e-01f, 3.19826342e-02f, -2.39620760e-01f, -1.48140952e-01f, -1.30459100e-01f, -2.92508483e-01f, -2.68186331e-01f, 3.76784615e-02f, 1.37514234e-01f,
  -2.68695317e-03f, -1.30677849e-01f, 3.77162434e-02f, 2.62411125e-02f, -3.01152822e-02f, 1.18972942e-01f, 1.62947029e-01f, 3.03881347e-01f, 1.29531454e-02f, -1.33799417e-02f,
  -3.13366875e-02f, 2.27437392e-02f, 2.68791895e-02f, 2.08671461e-03f, 9.22014099e-03f, 3.13880257e-02f, 4.95402329e-02f, -2.21447945e-02f, 6.23016991e-02f, -5.15136449e-03f,
  -3.64178531e-02f, -4.68843020e-02f, -4.65580262e-03f, -5.63816875e-02f, -6.25540018e-02f, 6.08177148e-02f, 1.46226622e-02f, -6.34999871e-02f, 5.48298545e-02f, -6.38760179e-02f,
  -9.71885805e-04f, -1.75454393e-01f, -8.33136439e-02f, -1.42229572e-01f, 5.15695326e-02f, -8.62402841e-02f, -8.65904521e-03f, 2.70047970e-02f, -9.02699754e-02f, -4.22636885e-03f,
  -5.97512200e-02f, -2.50158049e-02f, -1.75376739e-02f, -9.11213309e-02f, -6.13461696e-02f, 6.95187896e-02f, -1.03344247e-01f, -1.00984676e-02f, 2.94638071e-02f, 7.06440210e-02f,
  -2.11379640e-02f, -7.04232827e-02f, -1.08879490e-03f, -5.22952862e-02f, -2.33390853e-02f, -3.78791764e-02f, -1.82703566e-02f, 1.42856598e-01f, 6.50619902e-03f, -2.94721145e-02f,
  -6.66120276e-02f, -3.07056531e-02f, -6.63851723e-02f, -3.21606882e-02f, -6.44620731e-02f, 1.75732132e-02f, -2.61476599e-02f, 1.12109356e-01f, 1.19712368e-01f, -6.73259199e-02f,
  3.50145274e-03f, 2.12018341e-01f, 4.38946225e-02f, -4.96899933e-02f, 2.32220460e-02f, -5.62970005e-02f, -1.49460032e-03f, -1.93948466e-02f, 9.11833122e-02f, 3.34315225e-02f,
  2.16059964e-02f, -2.67682802e-02f, 1.18204588e-02f, 2.86196340e-02f, -7.92124793e-02f, 7.05619752e-02f, 7.03520626e-02f, -8.26985762e-02f, -2.87487153e-02f, 2.02711932e-02f,
  1.18837900e-01f, -2.25168969e-02f, -8.47547501e-02f, -3.90522704e-02f, 1.46577302e-02f, -1.54621592e-02f, 1.19466027e-02f, -8.72833945e-04f, -1.52783869e-02f, 1.31069990e-02f,
  2.05899209e-01f, -1.51745290e-01f, 1.08143754e-01f, 1.83258817e-01f, -5.08017540e-02f, 1.53011695e-01f, 1.99421957e-01f, 1.30501986e-02f, 9.84864086e-02f, -1.62639320e-01f,
  2.46653587e-01f, -1.19805578e-02f, 1.52087778e-01f, 1.46291226e-01f, 4.98350561e-01f, 2.63534516e-01f, 1.47057712e-01f, 3.61610427e-02f, 8.92081186e-02f, -1.99061073e-02f,
  1.78712890e-01f, 1.53744519e-01f, 1.80191994e-01f, -6.82810023e-02f, -1.66927293e-01f, -1.11050360e-01f, 1.38661582e-02f, -1.18130995e-02f, -2.00218573e-01f, -1.80583745e-02f,
  -9.47225839e-03f, -3.02583468e-03f, -1.38137951e-01f, -2.63977796e-02f, 1.82706397e-02f, -9.05051678e-02f, -1.03175081e-01f, 8.20680112e-02f, 9.10848752e-02f, -6.77324310e-02f,
  -6.74328133e-02f, 1.40226372e-02f, 5.15300073e-02f, 4.09662239e-02f, -6.13647327e-02f, 1.28358258e-02f, -2.66107526e-02f, -6.91080391e-02f, 4.09359857e-02f, 1.48075540e-02f,
  1.07581243e-02f, -2.25951560e-02f, -5.37114292e-02f, -8.02997649e-02f, 4.41585705e-02f, 4.92421491e-03f, 5.32405265e-02f, -1.06340125e-01f, -9.67883915e-02f, -8.77345055e-02f,
  4.05249298e-02f, 2.60983128e-02f, -2.67012399e-02f, 3.63026634e-02f, 6.83115423e-02f, 4.40359451e-02f, 3.16158123e-02f, 6.38570786e-02f, -2.24230848e-02f, 4.00196165e-02f,
  1.20204017e-02f, 1.19643211e-02f, -2.44400464e-02f, -1.23835122e-02f, -6.28945082e-02f, 1.01707824e-01f, 4.22374941e-02f, -9.17079598e-02f, -6.53501004e-02f, 4.53681201e-02f,
  4.34187613e-03f, 2.38477415e-03f, -1.10006249e-02f, -8.46365169e-02f, 9.00468454e-02f, 1.02432989e-01f, -6.78398684e-02f, -8.14041570e-02f, -5.71533404e-02f, 8.35790951e-03f,
  -6.78596273e-02f, -4.51750569e-02f, 2.53061149e-02f, -8.73777177e-03f, 3.76890898e-02f, 4.11181375e-02f, 8.24987814e-02f, -8.40837061e-02f, 1.04345337e-01f, 5.74311800e-02f,
  -6.51573110e-03f, -4.07882966e-03f, -4.26102355e-02f, -2.51249596e-02f, -1.38433352e-02f, -5.37187345e-02f, 2.97270007e-02f, -3.68586034e-02f, 3.85320596e-02f, 4.27903347e-02f,
  2.15488626e-03f, 2.27917824e-02f, 6.03124406e-03f, 3.11188567e-02f, -5.98715730e-02f, -1.25049844e-01f, -2.66280826e-02f, 4.53362688e-02f, -1.74596950e-01f, 2.46933363e-02f,
  3.20410788e-01f, -1.97433218e-01f, -7.25054145e-02f, 7.02073798e-02f, 1.17804177e-01f, -1.94463789e-01f, 2.95772254e-02f, -3.81061845e-02f, 2.09247749e-02f, -3.20615694e-02f,
  -1.21878095e-01f, 1.63752824e-01f, -1.84294060e-01f, -8.19228962e-02f, 8.60190243e-02f, -3.01990837e-01f, 2.93789487e-02f, -5.53837568e-02f, -1.41895041e-01f, 1.31833911e-01f,
  7.91482404e-02f, 1.57977324e-02f, -5.98881654e-02f, -6.55612797e-02f, -4.26896475e-02f, -6.31974777e-03f, 1.18121147e-01f, -6.45782202e-02f, 6.47787154e-02f, 5.51656215e-03f,
  -2.96713747e-02f, -1.26407087e-01f, 6.05698451e-02f, -3.54427262e-04f, -1.58584323e-02f, -4.95578386e-02f, 1.73495337e-02f, -1.15518156e-03f, -6.28474280e-02f, 7.20151886e-02f,
  4.80696484e-02f, 7.88053647e-02f, 1.14944633e-02f, -6.26384020e-02f, -1.02645688e-01f, -1.38672441e-03f, 1.24188112e-02f, -5.63880131e-02f, 4.10630330e-02f, -5.10696031e-04f,
  -3.28481607e-02f, -7.98430443e-02f, -7.11938888e-02f, 1.01260088e-01f, 5.42786792e-02f, -1.48718227e-02f, -5.24719618e-02f, 4.96992767e-02f, 1.44087672e-02f, 6.16006404e-02f,
  1.09207042e-01f, -5.57344146e-02f, 5.58261685e-02f, -6.07489087e-02f, -2.87109409e-02f, -2.76795495e-02f, -5.44382744e-02f, -1.82004329e-02f, 5.58708534e-02f, 6.71344697e-02f,
  -2.62655448e-02f, -3.69011238e-02f, -9.61672068e-02f, 1.95004269e-02f, 1.49681479e-01f, 3.81310470e-02f, 7.02293590e-02f, 2.00207196e-02f, 8.32261704e-03f, 4.70726527e-02f,
  4.95472066e-02f, 4.15881760e-02f, -4.17587496e-02f, 9.04979110e-02f, -2.49871355e-03f, 1.26175910e-01f, -1.92771349e-02f, 3.59983966e-02f, -6.67034760e-02f, 1.34441946e-02f,
  -1.28369451e-01f, 3.20032192e-03f, -3.37422229e-02f, -2.91892327e-02f, -2.32328046e-02f, -5.02528585e-02f, -2.40762085e-02f, 9.72944498e-02f, -5.43979276e-03f, 1.70358177e-02f,
  8.89760330e-02f, -3.12951058e-02f, -4.27719904e-03f, -3.66931893e-02f, 8.63915533e-02f, -8.94381944e-03f, -9.51412879e-03f, 3.79047245e-02f, 8.92869085e-02f, -2.35192035e-03f,
  6.47391900e-02f, -3.05319782e-02f, 7.39185885e-02f, 9.00971293e-02f, 1.07059650e-01f, -5.57078384e-02f, 1.46721601e-02f, -3.45794894e-02f, 8.14816728e-03f, 7.54545955e-03f,
  -3.17764610e-01f, 5.67874163e-02f, 1.56970918e-02f, 6.89577311e-02f, -6.55858070e-02f, 1.43473759e-01f, 1.90475851e-01f, -3.79860587e-02f, 1.99416444e-01f, 2.31045648e-01f,
  2.59088159e-01f, 4.28031534e-02f, 1.48002610e-01f, 2.62294441e-01f, 1.00185089e-01f, 1.31364495e-01f, 4.22131568e-02f, 3.75581123e-02f, -7.67644495e-02f, -5.94094805e-02f,
  -5.88315800e-02f, 8.47256333e-02f, -1.04600713e-01f, -1.71943665e-01f, -6.72845170e-02f, -1.40764356e-01f, -1.25074014e-02f, -5.91063760e-02f, 3.91563810e-02f, 1.55423179e-01f,
  -8.02843943e-02f, 7.66181350e-02f, 5.67493886e-02f, -1.44313797e-02f, -2.07847022e-02f, 6.62437594e-03f, -8.18932801e-02f, 5.36224209e-02f, 2.87875272e-02f, 8.82968381e-02f,
  -1.04267411e-01f, -5.49421161e-02f, -6.47473102e-03f, 1.40665827e-04f, -8.24160799e-02f, -1.37894982e-02f, -9.46005881e-02f, 5.15002906e-02f, -2.59394478e-02f, -2.73772869e-02f,
  5.67397736e-02f, -3.42673846e-02f, 5.90989478e-02f, 2.31185611e-02f, 3.50011885e-02f, 3.38834338e-02f, -9.09508541e-02f, -8.33844617e-02f, -2.30858773e-02f, 1.10471500e-02f,
  -3.16285454e-02f, 1.13094142e-02f, -2.40255054e-02f, 4.31335494e-02f, 6.84158504e-02f, -5.79390004e-02f, 6.14776276e-02f, -4.12220694e-02f, -1.31295174e-01f, -7.31981965e-03f,
  1.02613434e-01f, 2.74722204e-02f, -2.33054889e-05f, 6.73035905e-02f, -1.07100651e-01f, -1.22071151e-02f, -3.32435407e-02f, -7.24494532e-02f, 9.95294098e-03f, -2.79838797e-02f,
  6.41384274e-02f, 2.10701600e-02f, 1.15947269e-01f, -1.87225826e-02f, 2.44850200e-02f, 1.77105889e-02f, 1.53119281e-01f, -1.57934337e-04f, 1.05741303e-02f, -1.95476934e-02f,
  -9.75741372e-02f, -1.86189683e-03f, 5.23312837e-02f, 1.70586519e-02f, 6.04605442e-03f, 5.35810599e-03f, -2.50226781e-02f, -4.77353949e-03f, 5.09123504e-02f, 4.06445898e-02f,
  -1.34700805e-01f, 3.06472718e-03f, -7.51433223e-02f, -3.85831408e-02f, -6.07909113e-02f, 8.14107135e-02f, -5.05329594e-02f, -4.03157882e-02f, -1.98471434e-02f, -1.63225122e-02f,
  -1.23163611e-01f, 3.17873396e-02f, -9.66804326e-02f, 2.97369622e-02f, -2.21164860e-02f, 5.00846282e-02f, -4.00896892e-02f, -3.50500783e-03f, -5.74851893e-02f, 6.97061196e-02f,
  7.78681859e-02f, 2.07211360e-01f, 8.90474170e-02f, 3.89075935e-01f, 2.78538261e-02f, -1.06905200e-01f, -1.06130034e-01f, 1.01142794e-01f, 4.00910750e-02f, 4.91433106e-02f,
  2.82662231e-02f, 5.51046170e-02f, -1.52461752e-01f, 2.77416557e-01f, -1.91201508e-01f, -1.41216695e-01f, 7.42983297e-02f, 6.41828328e-02f, 5.48324585e-02f, 2.42725550e-03f,
  -4.34078239e-02f, -3.48155461e-02f, 3.40888090e-02f, 7.37920552e-02f, 7.47450665e-02f, 1.05864972e-01f, -6.74631521e-02f, 5.67362271e-02f, 2.63591021e-01f, 3.79545018e-02f,
  -5.95146455e-02f, 9.00251269e-02f, 1.28450185e-01f, -1.15722241e-02f, -6.64426312e-02f, -1.65944826e-02f, 6.46893606e-02f, -6.77562959e-04f, -3.54385860e-02f, 2.30386220e-02f,
  2.89284568e-02f, -1.16570024e-02f, 4.68192585e-02f, -2.37205010e-02f, 1.92867015e-02f, 4.96852063e-02f, 1.32170871e-01f, -3.07616480e-02f, 1.71781391e-01f, 2.75141224e-02f,
  8.00931454e-02f, 8.19896087e-02f, 3.91103178e-02f, -8.53269640e-03f, -2.77556311e-02f, 1.03717707e-01f, -1.05616421e-01f, 1.95470657e-02f, -1.93624455e-03f, -3.45534715e-03f,
  -3.78207527e-02f, 8.06850716e-02f, 4.88937497e-02f, 9.72134769e-02f, 5.22645265e-02f, -1.49923330e-02f, -1.04175806e-02f, 4.03000116e-02f, 7.81274512e-02f, -6.50307536e-02f,
  -1.91402845e-02f, -1.07994571e-03f, 4.15573269e-02f, 3.46500240e-03f, 5.33022657e-02f, 3.85648832e-02f, -1.10298498e-02f, 6.38427883e-02f, 2.01573316e-02f, -6.96187199e-04f,
  1.07537443e-02f, -2.07998268e-02f, 6.60783872e-02f, -7.64379799e-02f, -2.50373911e-02f, -6.66433992e-03f, 6.81108534e-02f, -7.43329152e-02f, -1.73462387e-02f, -1.26813561e-01f,
  -5.72705530e-02f, 6.54528290e-02f, 2.29169838e-02f, 4.18461524e-02f, -6.72769770e-02f, 4.44446616e-02f, -2.40646186e-03f, 1.44785605e-02f, -9.05699283e-02f, -5.23717888e-02f,
  6.55328482e-02f, 6.86881393e-02f, -4.46981080e-02f, -3.04050241e-02f, -8.36343840e-02f, 3.38423997e-02f, 8.41969475e-02f, -2.76179258e-02f, 2.07498893e-02f, 2.11755600e-04f,
  5.85532151e-02f, 5.88972643e-02f, -5.23760393e-02f, -4.62037660e-02f, -4.03734036e-02f, 1.38833094e-02f, -4.26592976e-02f, 9.88444462e-02f, 5.43054715e-02f, -4.39324975e-02f,
  -2.65949011e-01f, 2.06404611e-01f, 2.16869369e-01f, -2.25332126e-01f, -4.74158721e-03f, 5.10065481e-02f, -9.73829813e-03f, -1.14949889e-01f, -2.57653832e-01f, 2.43939720e-02f,
  -1.65336028e-01f, 3.98284830e-02f, 3.82652320e-02f, -2.78214484e-01f, -1.77610740e-01f, -4.60629314e-02f, -2.51897633e-01f, -8.51397216e-02f, -9.22484025e-02f, -7.14548677e-02f,
  -1.78755850e-01f, -2.58571237e-01f, 4.20007901e-03f, -7.56736770e-02f, -2.04431247e-02f, 6.38123155e-02f, 2.92557050e-02f, 1.74739733e-01f, -5.31979613e-02f, 7.96091370e-03f,
  -8.18450302e-02f, 3.27433795e-02f, -8.31834525e-02f, 6.25597164e-02f, 1.00389585e-01f, 8.27935785e-02f, 9.65069756e-02f, 2.71851327e-02f, -7.06907827e-03f, 8.48840177e-02f,
  1.03603721e-01f, -8.61355383e-03f, -2.59335954e-02f, -1.36347841e-02f, -6.89180717e-02f, -4.66176383e-02f, 5.75779490e-02f, 4.26335670e-02f, 6.24643639e-02f, -5.43178208e-02f,
  9.81759056e-02f, 1.43546969e-01f, 2.59915683e-02f, 5.27686253e-03f, -6.68266937e-02f, -6.75997185e-03f, -2.97740139e-02f, 4.02513482e-02f, 3.72120850e-02f, -7.41603747e-02f,
  -2.28053220e-02f, -1.05690369e-02f, 1.29686818e-01f, 7.18454923e-03f, 5.01924418e-02f, 1.52510293e-02f, -9.58934873e-02f, -1.02777788e-02f, -1.05973398e-02f, 1.07922489e-02f,
  -1.04726791e-01f, 3.57783139e-02f, -3.40612582e-03f, -9.44299921e-02f, 1.65451877e-02f, 3.18061076e-02f, 1.40831051e-02f, 1.90103557e-02f, -4.59760278e-02f, 6.76633790e-03f,
  5.02109490e-02f, 7.93694635e-05f, 4.90590325e-03f, -4.68303971e-02f, 5.39758950e-02f, -3.56168486e-02f, -5.72231524e-02f, 5.07940315e-02f, -2.76833610e-03f, -1.12244883e-03f,
  1.61811605e-03f, 5.06358631e-02f, 3.09915245e-02f, -8.92931968e-02f, 3.58816721e-02f, 1.14411749e-01f, -5.30645512e-02f, -3.64597067e-02f, -2.42232289e-02f, 2.80418880e-02f,
  8.03084597e-02f, 9.90549568e-03f, 1.21954404e-01f, -7.43978098e-02f, -3.74005511e-02f, 4.35923487e-02f, 7.00093210e-02f, 3.76464287e-03f, -5.43196648e-02f, -3.74408811e-02f,
  1.88738457e-03f, 2.80564260e-02f, -6.14911057e-02f, 7.95168057e-02f, -1.48047330e-02f, 6.89677522e-02f, 2.44855881e-02f, 1.86450463e-02f, -7.31122075e-03f, 6.19389378e-02f,
  3.99080068e-01f, -3.68102014e-01f, 1.30464628e-01f, -1.45202819e-02f, -7.55915642e-02f, -1.15029663e-01f, 2.48403419e-02f, -1.96319297e-01f, -3.52646001e-02f, -2.02929020e-01f,
  -3.89849134e-02f, 1.67019680e-01f, -3.54238264e-02f, -1.49016127e-01f, 9.99360085e-02f, -7.68023282e-02f, -1.57534778e-01f, -7.39367306e-02f, -1.95745766e-01f, -7.99966678e-02f,
  6.50534872e-03f, -1.21803984e-01f, 5.03109843e-02f, -1.73757851e-01f, -1.20298550e-01f, -5.92353707e-03f, 1.40759230e-01f, -1.20433375e-01f, -1.70463379e-02f, -1.45680144e-01f,
  5.85535020e-02f, 2.72059292e-01f, 1.54258043e-01f, 1.37142837e-01f, 9.79374871e-02f, 5.95998354e-02f, 4.74354327e-02f, 3.75574529e-02f, 8.88294131e-02f, 2.67988145e-02f,
  1.28165353e-02f, 8.45995825e-03f, 2.25747246e-02f, -4.55366299e-02f, 3.11403349e-02f, 8.86838436e-02f, -1.50131518e-02f, -7.52206845e-03f, -1.76042896e-02f, -1.17409103e-01f,
  -1.18901484e-01f, -9.13832989e-03f, -6.34790435e-02f, -4.02972009e-03f, 1.82297546e-02f, -1.09326646e-01f, 6.24486338e-03f, 3.05383317e-02f, -4.05394770e-02f, -4.05817963e-02f,
  -1.83200940e-01f, 2.19091535e-01f, 2.92634144e-02f, 4.82135676e-02f, -3.44267413e-02f, -1.10268861e-01f, 1.07379481e-01f, 1.32967770e-01f, -1.45056956e-02f, 1.08184077e-01f,
  1.12476777e-02f, 1.78657621e-01f, 8.53433236e-02f, 1.69900227e-02f, -5.94710670e-02f, -3.69907869e-03f, -2.61171218e-02f, 2.10225545e-02f, -5.98463006e-02f, -8.72358400e-03f,
  -7.50841200e-02f, -7.46835694e-02f, 2.91008260e-02f, 3.37909535e-02f, -4.90659289e-02f, 1.22002531e-02f, 5.51087111e-02f, -1.55820206e-01f, 3.02224178e-02f, 1.85667425e-02f,
  6.12094142e-02f, 1.15237668e-01f, 1.04135379e-01f, 1.32071435e-01f, 1.02686308e-01f, 5.12266569e-02f, 1.94891430e-02f, 6.87637553e-03f, 3.34822610e-02f, -4.30553891e-02f,
  -4.08700630e-02f, 6.40398040e-02f, 8.52244198e-02f, 2.21483856e-02f, -6.11558445e-02f, -5.58233745e-02f, -9.94384103e-03f, 8.26876014e-02f, 2.51532556e-03f, -1.21304967e-01f,
  -2.42648507e-03f, 2.17552464e-02f, -3.47639918e-02f, 3.62418406e-02f, -8.99024680e-03f, -1.15940310e-02f, 2.85310559e-02f, 3.04315262e-03f, -6.43478846e-03f, -9.72499896e-04f,
  1.70300845e-02f, 2.57386804e-01f, -2.97724572e-03f, -5.73580265e-02f, -1.06172591e-01f, -1.14385806e-01f, -2.26903632e-01f, 9.81348231e-02f, -4.58639897e-02f, 1.04718179e-01f,
  5.17027564e-02f, 6.35595992e-02f, -1.75101683e-02f, 2.72770375e-01f, -2.74184167e-01f, 2.85813045e-02f, 7.35376403e-02f, -5.41876536e-03f, -4.21414636e-02f, -1.94732621e-02f,
  -1.92968978e-03f, 7.87752196e-02f, 4.87909056e-02f, 1.43368065e-01f, 7.12695122e-02f, 1.23872750e-01f, 9.76122767e-02f, -2.69865189e-02f, 1.82609111e-01f, -3.41436863e-02f,
  5.67352399e-02f, 2.45238491e-03f, 3.40973511e-02f, 4.59104739e-02f, 1.39724866e-01f, 3.81294936e-02f, 3.47008109e-02f, -3.54294516e-02f, -1.49958014e-01f, -7.39444569e-02f,
  -3.97739038e-02f, -8.90841261e-02f, -1.55796087e-03f, -9.36693326e-02f, -4.55403924e-02f, -4.65477481e-02f, 1.07866235e-03f, 8.32495615e-02f, 8.99251103e-02f, 5.91536686e-02f,
  -7.00215772e-02f, -5.96194528e-02f, 5.56332096e-02f, 9.17675812e-03f, 3.44493799e-02f, -5.29939085e-02f, -1.59917455e-02f, -1.46163320e-02f, 9.53356083e-03f, 3.10659641e-03f,
  9.05485675e-02f, -7.54108429e-02f, 1.44250942e-02f, -4.63589206e-02f, -2.99414042e-02f, -1.42960072e-01f, -4.36637178e-02f, 4.59775925e-02f, -3.34054977e-02f, -3.54054719e-02f,
  -7.13766739e-02f, -7.77159706e-02f, -6.07668608e-02f, -7.73449242e-02f, -1.03298821e-01f, 4.77303639e-02f, 1.79222189e-02f, 3.32904197e-02f, -3.46474536e-02f, -7.26812854e-02f,
  1.45060746e-02f, 2.99361651e-03f, 1.24821244e-02f, 6.55175420e-03f, 2.54953895e-02f, -1.23012505e-01f, 5.75740775e-03f, -1.84894465e-02f, 3.35467095e-03f, -3.85014378e-02f,
  2.21752793e-01f, 1.67198136e-01f, 3.38271111e-02f, 1.91186909e-02f, 5.79965375e-02f, 4.62381542e-02f, 7.55229071e-02f, -4.98743868e-03f, 1.03858128e-01f, -5.97454282e-03f,
  -2.98487730e-02f, 3.24097648e-02f, -8.82036835e-02f, -6.42624944e-02f, -5.08486554e-02f, 3.39960493e-02f, -4.82661184e-03f, 6.95337076e-03f, 2.77671535e-02f, 9.38885957e-02f,
  2.10203920e-02f, -1.80799067e-02f, 8.34473744e-02f, -2.80900262e-02f, 1.37028456e-01f, 5.19621279e-03f, 4.40836325e-02f, 9.27009806e-03f, 3.54845524e-02f, 6.41252771e-02f,
  2.07620531e-01f, -2.24377245e-01f, -2.42787182e-01f, -1.26027152e-01f, 3.67910236e-01f, 1.58247888e-01f, -8.16246048e-02f, 1.49880409e-01f, -1.44059420e-01f, -3.13215610e-03f,
  1.83589652e-01f, -1.43031865e-01f, -1.61368623e-01f, 9.20049176e-02f, -2.92511992e-02f, -1.86750829e-01f, 9.09335986e-02f, -2.91075334e-02f, 2.31398959e-02f, 1.07120499e-01f,
  8.33638385e-02f, 2.70932764e-01f, -1.41772792e-01f, 2.20462278e-01f, 1.65962607e-01f, 8.46209303e-02f, 4.54698987e-02f, -1.37246996e-01f, 2.28651747e-01f, 2.82508396e-02f,
  1.01471595e-01f, 1.53611461e-03f, -1.47091523e-02f, -6.21983781e-02f, 6.06534854e-02f, -5.69713651e-04f, -1.37474015e-01f, 4.08680663e-02f, 3.17848809e-02f, -5.60468920e-02f,
  3.62948142e-02f, 7.62833133e-02f, -2.59368680e-02f, -4.07382213e-02f, -2.70240139e-02f, -2.20935363e-02f, 9.26008895e-02f, 8.84663239e-02f, -8.04244168e-03f, -1.72416382e-02f,
  -1.07031524e-01f, 7.86975771e-03f, -1.49608687e-01f, 5.45946397e-02f, -1.03157861e-02f, 6.23249523e-02f, -9.46702715e-03f, 3.17289606e-02f, -7.69540742e-02f, 6.29852936e-02f,
  7.06995605e-04f, 1.48530519e-02f, 8.35098233e-03f, 3.43099944e-02f, 1.04333619e-02f, 2.18554703e-03f, -4.97284792e-02f, 4.41558920e-02f, -5.19315936e-02f, 3.40294987e-02f,
  7.61089846e-02f, 5.68991750e-02f, -1.14247845e-02f, 1.31291375e-02f, 3.10297273e-02f, 3.05688521e-03f, -4.10445258e-02f, -8.63354094e-03f, 4.86492626e-02f, 1.82910040e-02f,
  -1.23230264e-01f, -6.99651986e-03f, 2.64487639e-02f, 3.25063244e-02f, 1.54389692e-02f, -1.41197601e-02f, -7.97438994e-02f, -6.96183369e-02f, 2.35242881e-02f, -2.83885300e-02f,
  1.18355855e-01f, 2.71729920e-02f, -1.73120368e-02f, 1.13897957e-01f, -4.97664064e-02f, 4.63866107e-02f, -1.94982588e-01f, 8.47173706e-02f, 3.56859062e-03f, 5.14819324e-02f,
  7.43150562e-02f, -1.95492506e-02f, -5.73786162e-02f, -1.62739609e-03f, -4.29896489e-02f, -1.71074346e-02f, -1.58444047e-02f, -2.51329765e-02f, -5.83190247e-02f, 9.88613069e-02f,
  9.13883280e-03f, 1.21878833e-01f, 3.18242870e-02f, 5.51990755e-02f, 1.11353062e-01f, -2.45740521e-03f, 4.76164706e-02f, 4.85090073e-03f, 7.65068457e-02f, -3.56591269e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.66187459e-01f, -7.56561011e-02f, -1.52762175e-01f, 1.26875520e-01f, -7.33399764e-02f, -1.44089133e-01f, -3.53119433e-01f, 5.46673313e-02f, -2.16535076e-01f, -3.58283371e-02f,
  1.10393688e-01f, -4.53198142e-02f, 4.05878611e-02f, 3.04271817e-01f, 2.25376830e-01f, 1.13591947e-01f, 1.33121654e-01f, 7.53707737e-02f, 4.68091816e-02f, 2.22075447e-01f,
  2.81239092e-01f, 2.98412859e-01f, 1.43253520e-01f, 1.87688917e-01f, 5.49136996e-02f, 1.24692768e-01f, 2.24497139e-01f, 1.03578024e-01f, 1.91942215e-01f, 7.64340535e-02f,
  7.07777441e-02f, 6.29157498e-02f, -5.90525568e-02f, -7.62237534e-02f, 5.59011102e-02f, 3.37672010e-02f, 2.95917913e-02f, 7.49012008e-02f, -3.44775692e-02f, -1.01047633e-02f,
  2.03215647e-02f, 6.61904067e-02f, -5.09067476e-02f, -6.41560182e-02f, -1.09612003e-01f, 4.21056040e-02f, -8.91682208e-02f, -1.25193357e-01f, -1.77249476e-01f, 5.64529374e-02f,
  -3.34330350e-02f, -8.29403289e-03f, -8.61010700e-02f, 7.54621066e-03f, -1.73724513e-03f, 1.21865608e-02f, -8.31329897e-02f, 7.77108669e-02f, 2.03163326e-02f, 3.70774791e-02f,
  7.99116492e-02f, -2.01635770e-02f, 3.05476747e-02f, -3.60024497e-02f, -6.16314933e-02f, -2.58421269e-03f, -2.43751630e-02f, 4.27056216e-02f, -6.04523420e-02f, 1.89197566e-02f,
  4.30484861e-03f, 1.21730389e-02f, 4.81477790e-02f, 2.15649251e-02f, 1.25193167e-02f, 3.53243053e-02f, -2.21462362e-02f, 1.67211685e-02f, -7.89170489e-02f, -3.79136158e-03f,
  2.84419563e-02f, 1.16601132e-01f, -1.14229962e-01f, -6.50396794e-02f, 9.03866291e-02f, 6.42709285e-02f, 4.64931987e-02f, 2.46103425e-02f, -1.50284350e-01f, -6.52296692e-02f,
  3.77807654e-02f, 2.12643877e-01f, -3.13804075e-02f, -3.14585641e-02f, -5.06666899e-02f, 2.37479955e-02f, -4.10237499e-02f, 4.69081886e-02f, 1.47634596e-01f, 1.15835238e-02f,
  9.31327492e-02f, -4.20874506e-02f, 4.01630104e-02f, -2.92696748e-02f, 2.32368559e-02f, 2.09846459e-02f, 7.07355142e-02f, 5.12233153e-02f, -3.70693803e-02f, -2.00887043e-02f,
  1.87107977e-02f, -4.58820760e-02f, 2.44207047e-02f, -2.10039780e-01f, 1.50983436e-02f, -1.11265033e-02f, -5.54585047e-02f, 2.35849265e-02f, 1.04805507e-01f, 4.87523749e-02f,
  1.37449741e-01f, -1.68399382e-02f, -4.96443659e-02f, 3.08616370e-01f, -5.07213287e-02f, -2.39356175e-01f, -2.06110418e-01f, 1.72292471e-01f, -1.74219072e-01f, -9.80463848e-02f,
  1.20057106e-01f, -1.94344163e-01f, -1.73264414e-01f, 2.71454066e-01f, 1.80447668e-01f, -1.12570450e-01f, 1.80353031e-01f, -1.01615861e-02f, -1.25244921e-02f, 4.77233045e-02f,
  2.05232427e-01f, 1.80837438e-01f, 2.30204910e-01f, 3.34383488e-01f, 5.51207066e-02f, 1.21788241e-01f, 2.69663393e-01f, -1.28423804e-02f, 2.93475270e-01f, 5.42924553e-02f,
  3.04575413e-02f, -5.50994836e-02f, -7.53332116e-03f, -6.54298440e-02f, 7.46342987e-02f, -4.16965559e-02f, -9.21678096e-02f, 5.28838411e-02f, -2.88043953e-02f, 1.50532788e-02f,
  -5.30600660e-02f, 4.82873768e-02f, -8.16712447e-04f, 3.40330712e-02f, -7.47273192e-02f, 1.55562237e-02f, -2.75210738e-02f, -4.84719910e-02f, -8.58836472e-02f, -1.49445143e-02f,
  -9.01104510e-02f, 1.95752364e-02f, -7.59041831e-02f, 8.07197168e-02f, 1.14577956e-01f, -6.04373552e-02f, -4.70807254e-02f, -1.13754503e-01f, 5.88636089e-04f, 8.95961747e-02f,
  1.36720832e-03f, -2.94868238e-02f, -8.97243991e-02f, -3.28498520e-03f, -1.13743963e-03f, 7.77091756e-02f, 1.06659241e-01f, 2.74478961e-02f, 3.71370390e-02f, 3.14933509e-02f,
  1.01121284e-01f, 3.48938070e-02f, 5.30290324e-03f, 4.44428436e-02f, -7.64346123e-02f, -5.76806441e-02f, 4.52598296e-02f, 8.91812071e-02f, 2.99723935e-03f, 4.74196337e-02f,
  -1.57198925e-02f, 2.39626132e-02f, -5.93130179e-02f, 8.32961649e-02f, -1.30006028e-02f, 7.81028569e-02f, 3.29251178e-02f, -3.85629497e-02f, -1.20953703e-02f, 8.12652241e-03f,
  -3.17472294e-02f, 6.53825998e-02f, -1.04496516e-01f, 5.13335411e-03f, -6.44551823e-03f, -1.78773832e-02f, -1.75789222e-02f, 2.89925300e-02f, 1.32328764e-01f, -9.69726592e-02f,
  4.54954691e-02f, 5.96932843e-02f, -4.65133153e-02f, 9.17372555e-02f, 4.91057821e-02f, 1.39487954e-02f, -4.33396772e-02f, 1.09026052e-01f, 6.62864279e-03f, -1.15131016e-03f,
  -2.86496393e-02f, -5.67106009e-02f, -6.55487552e-02f, -1.63675752e-02f, 3.98374684e-02f, -7.31314868e-02f, -1.00636914e-01f, 7.68034393e-03f, -3.70804742e-02f, -1.92245748e-02f,
  -4.90701199e-02f, -1.84636146e-01f, -2.61169344e-01f, 1.74536273e-01f, 2.25374281e-01f, 3.29859048e-01f, 2.77871847e-01f, 2.01773211e-01f, 4.22306299e-01f, 2.48389065e-01f,
  9.48704705e-02f, -1.07606709e-01f, -2.04014499e-02f, 1.46537855e-01f, 1.00174677e-02f, 1.23536006e-01f, 1.73771963e-01f, 1.42659560e-01f, 5.31067438e-02f, 3.08751855e-02f,
  2.01994814e-02f, 1.90840602e-01f, -4.83316220e-02f, -1.41973212e-01f, -3.93540077e-02f, -1.28371552e-01f, -6.34595975e-02f, -2.48856172e-01f, -4.51545902e-02f, -4.47683706e-04f,
  -7.79852644e-02f, 4.75281551e-02f, -3.50783914e-02f, -1.52358506e-02f, -3.40586081e-02f, -1.00356238e-02f, -6.76944777e-02f, -1.14794374e-01f, -7.96106011e-02f, 6.72514141e-02f,
  -2.78427843e-02f, -3.70363370e-02f, 7.00576007e-02f, -2.81316079e-02f, 9.88692231e-03f, 3.73782334e-03f, 4.27802503e-02f, 6.77018240e-02f, -4.20998409e-02f, 5.57963625e-02f,
  8.41023680e-03f, -2.33852454e-02f, 7.39062950e-02f, -1.25354053e-02f, -3.97944599e-02f, 5.51817045e-02f, 1.83752719e-02f, 3.60339768e-02f, 5.42494133e-02f, 8.07393193e-02f,
  -2.48059854e-02f, -9.84179601e-02f, 8.92254487e-02f, -4.30855043e-02f, -9.53075886e-02f, -1.31134510e-01f, -4.31357212e-02f, 1.09439334e-02f, -1.71990935e-02f, 6.16302676e-02f,
  2.21393630e-02f, 2.66169421e-02f, 4.25265655e-02f, -6.47592619e-02f, 7.77082071e-02f, 1.49668664e-01f, 4.33312692e-02f, 6.24612607e-02f, 2.35410798e-02f, 8.28380790e-03f,
  -1.41650327e-02f, 4.42263447e-02f, -4.09753993e-02f, 1.84530467e-02f, 4.29590680e-02f, -9.99262631e-02f, 3.42901386e-02f, -3.58061912e-03f, 1.55782759e-01f, -3.64954136e-02f,
  -6.80417661e-03f, -8.95608142e-02f, 1.39498040e-02f, 5.11931442e-02f, -1.13980263e-01f, 5.87888844e-02f, 5.66245755e-03f, 1.00331502e-02f, -8.12217519e-02f, 8.64780694e-02f,
  9.40980688e-02f, 3.55290845e-02f, -1.98324416e-02f, -7.25772008e-02f, -2.45404597e-02f, 6.83769509e-02f, 6.20246977e-02f, -3.66333723e-02f, 9.44370776e-03f, 4.51067351e-02f,
  1.97287705e-02f, 7.67360702e-02f, -1.95218008e-02f, -4.47572656e-02f, 7.83512443e-02f, 9.84774344e-03f, 7.97921512e-03f, 1.69793144e-02f, 4.03100811e-02f, -2.02584472e-02f,
  -3.16597968e-01f, 2.64022052e-01f, -1.93657771e-01f, 2.41727859e-01f, -1.61975235e-01f, 5.56285046e-02f, 1.38367340e-01f, -8.87470320e-02f, -2.09627971e-01f, 2.36808360e-01f,
  2.02924773e-01f, -2.12411955e-01f, 3.20672989e-01f, 3.84202510e-01f, -1.12283781e-01f, 3.22491527e-01f, 2.28738382e-01f, 9.57772359e-02f, -7.23995492e-02f, 1.38457820e-01f,
  -1.34611532e-01f, 4.02068168e-01f, 2.57756978e-01f, 7.80149475e-02f, 7.29094520e-02f, -1.26357526e-01f, 1.53592110e-01f, -1.20233774e-01f, 1.26100168e-01f, -5.06124310e-02f,
  7.04759732e-02f, 8.65727440e-02f, 4.41375449e-02f, -7.32074901e-02f, -4.06498648e-02f, 3.92417498e-02f, 2.07936522e-02f, -5.31571843e-02f, -1.28372729e-01f, -4.59878631e-02f,
  -1.14579089e-01f, -2.80474909e-02f, -2.53584352e-03f, -8.63934085e-02f, -1.03976049e-01f, 2.55525317e-02f, 1.63172912e-02f, -4.14841361e-02f, -4.77497047e-03f, 3.19224298e-02f,
  -6.18180633e-02f, -4.49907146e-02f, -4.83197756e-02f, 1.56436443e-01f, -1.03203449e-02f, -1.51443323e-02f, 7.94876069e-02f, 5.13843261e-02f, 5.13946749e-02f, -8.43685120e-02f,
  -1.22039922e-01f, -4.17985693e-02f, 1.49277166e-01f, 4.84841801e-02f, 1.23152584e-02f, 5.08167334e-02f, 4.85160388e-02f, 6.10674694e-02f, -7.05828890e-02f, 5.83604760e-02f,
  -8.56570899e-03f, 1.20702140e-01f, -3.49671543e-02f, -3.07715666e-02f, -7.53870830e-02f, -3.14941928e-02f, -1.03152797e-01f, 3.48749980e-02f, 1.92224905e-02f, 3.87305692e-02f,
  5.71899116e-02f, -6.74519837e-02f, 6.70287684e-02f, 3.37372608e-02f, 9.23773870e-02f, -3.35967131e-02f, -4.77218702e-02f, 2.50112563e-02f, 1.68055315e-02f, -1.87113453e-02f,
  1.33970708e-01f, 7.49698505e-02f, 9.23371911e-02f, 1.10803107e-02f, 4.20792587e-02f, 8.99802819e-02f, -5.98847903e-02f, -1.42531291e-01f, -1.62475947e-02f, -8.02428648e-03f,
  -1.20883286e-01f, -8.78180377e-03f, 5.80362193e-02f, -4.89397161e-02f, -7.89245591e-02f, 6.84988275e-02f, 1.50360867e-01f, -7.65778720e-02f, 6.43739328e-02f, -7.32688680e-02f,
  4.45087440e-02f, -3.14771533e-02f, -2.55640447e-02f, -6.52896911e-02f, -2.32629990e-03f, -1.43802138e-02f, 3.11319865e-02f, 9.45628062e-03f, -2.65178178e-02f, 2.71203592e-02f,
  -1.79459609e-03f, 1.87626705e-01f, 6.83315378e-03f, 7.42827132e-02f, -2.26634681e-01f, -1.41256854e-01f, -3.94130200e-02f, -7.71178678e-02f, 3.94279331e-01f, 5.05368225e-02f,
  -2.70692796e-01f, 4.64713663e-01f, -1.37319565e-01f, -1.86714277e-01f, -1.19249355e-02f, 1.11409314e-01f, -1.61398217e-01f, 9.18297321e-02f, 3.61069404e-02f, -1.09182611e-01f,
  -6.86162934e-02f, -2.55357981e-01f, -1.89031199e-01f, -2.20207974e-01f, -3.08258414e-01f, 2.51493300e-03f, -2.41553769e-01f, -1.40550002e-01f, -1.73450932e-01f, -2.54750494e-02f,
  4.10211198e-02f, 1.85893908e-01f, -4.52550640e-03f, 9.52038318e-02f, -7.58765787e-02f, -1.11982301e-01f, 2.15224139e-02f, 2.15964150e-02f, 2.02171840e-02f, -8.78693536e-03f,
  7.74956048e-02f, 1.36459349e-02f, 1.16087116e-01f, -9.84516591e-02f, 3.29129174e-02f, -2.67995205e-02f, 6.87103570e-02f, -8.16317871e-02f, 1.20569907e-01f, -1.46035343e-01f,
  -3.60537469e-02f, -3.60260718e-02f, -1.79250274e-04f, 1.23878926e-01f, 8.81965384e-02f, 1.03844449e-01f, 1.78537548e-01f, -3.05998717e-02f, 7.15190619e-02f, 3.83772999e-02f,
  -5.75888902e-02f, -7.45621845e-02f, -7.36953467e-02f, -9.00702178e-03f, 7.41501944e-03f, 1.19214050e-01f, 1.55580258e-02f, 4.17332351e-02f, 1.13694578e-01f, -3.46695334e-02f,
  7.90611431e-02f, 7.91267306e-03f, -1.15399789e-02f, -9.17379186e-02f, -1.39429243e-02f, 7.05117732e-02f, 6.78865165e-02f, 4.55577411e-02f, -5.96000231e-04f, -2.16897093e-02f,
  -2.16288473e-02f, 5.51478080e-02f, 1.18889038e-04f, -7.07185864e-02f, -4.80145887e-02f, -3.05210687e-02f, -1.10178068e-01f, -5.41181071e-03f, -1.19190081e-03f, -8.46619308e-02f,
  7.31270714e-03f, 2.31803834e-01f, 5.57517372e-02f, 1.39793098e-01f, 6.97966665e-02f, -6.40799478e-02f, 2.98653208e-02f, 3.67768258e-02f, 7.30041116e-02f, 2.09867284e-02f,
  -6.40798211e-02f, 5.80318496e-02f, -5.47923036e-02f, -6.99487329e-02f, 5.91134019e-02f, 2.96605323e-02f, 1.06186628e-01f, 1.21058792e-01f, 7.33032748e-02f, -1.06237203e-01f,
  -1.21711582e-01f, 1.35200709e-01f, 8.03183839e-02f, 4.19014245e-02f, -4.90097106e-02f, 9.76519845e-03f, 3.62351201e-02f, 3.60244885e-02f, -5.67925684e-02f, -1.09286709e-02f,
  -4.62640733e-01f, 2.78360397e-01f, -2.44828686e-01f, -2.18261153e-01f, 1.76968694e-01f, -3.55517715e-01f, -1.99453294e-01f, -4.64641042e-02f, -1.34864002e-01f, 6.24821447e-02f,
  1.31991148e-01f, 5.83969131e-02f, 1.05140418e-01f, -7.57067725e-02f, -3.67865950e-01f, -9.52138677e-02f, -3.86826932e-01f, -2.28396729e-01f, 3.57719809e-02f, -3.24514881e-02f,
  -1.49389520e-01f, 1.12268314e-01f, -1.49616599e-01f, 2.92526335e-01f, 2.42394302e-03f, -1.89412832e-02f, -1.85770411e-02f, 3.23222667e-01f, -1.37510985e-01f, 7.97086060e-02f,
  -3.68592031e-02f, 1.14250258e-02f, 2.66554207e-02f, 1.38250273e-02f, -1.27775326e-01f, -9.40881521e-02f, -8.90269410e-03f, 9.91668031e-02f, 1.33751929e-02f, -5.17206080e-02f,
  -2.61290167e-02f, 6.47746846e-02f, -1.94152333e-02f, 1.55627668e-01f, -2.91085131e-02f, 1.12071529e-03f, -3.06880428e-03f, -1.26797155e-01f, 2.19297893e-02f, -5.12609296e-02f,
  -2.37396010e-03f, -8.68933857e-04f, -1.65702626e-01f, -1.13648199e-01f, -1.39895260e-01f, 2.90766470e-02f, -1.73777863e-01f, -6.82378784e-02f, -1.27172649e-01f, -8.24908167e-02f,
  -1.20468266e-01f, -9.07997638e-02f, -4.44835983e-02f, 5.28890714e-02f, -4.43821773e-03f, 1.54803336e-01f, 7.51882140e-03f, 2.26863995e-02f, 6.72245473e-02f, 1.23607116e-02f,
  -9.29186586e-03f, 1.25590205e-01f, 9.69020426e-02f, -1.32293224e-01f, -3.00074778e-02f, -2.96252519e-02f, 7.39062298e-03f, 1.94245577e-02f, -8.23643804e-02f, -2.49377657e-02f,
  2.09258031e-02f, 2.65480056e-02f, 3.64078768e-02f, -2.77219042e-02f, 6.88565373e-02f, -2.81734578e-02f, 2.94189770e-02f, -5.55878915e-02f, -9.16313287e-03f, -1.68631524e-02f,
  -1.41171440e-01f, -1.79467753e-01f, -2.52067726e-02f, 9.44890007e-02f, 8.98514986e-02f, -5.82650080e-02f, -3.91701125e-02f, 2.28049625e-02f, -6.78772479e-02f, 5.77051230e-02f,
  1.46483351e-02f, -6.43528029e-02f, -1.38056204e-01f, -2.18950342e-02f, -6.42576590e-02f, -5.69525659e-02f, 5.60309796e-04f, 5.34081608e-02f, -9.90823433e-02f, 2.98549403e-02f,
  -6.94206804e-02f, 1.31340623e-01f, -1.61672500e-03f, -2.77160201e-02f, -8.43225513e-03f, -3.11012585e-02f, -7.58772343e-03f, 2.30401717e-02f, 3.05257905e-02f, -7.48549355e-04f,
  9.10894647e-02f, -7.51984119e-02f, -1.29867028e-02f, -2.10261028e-02f, -1.21735111e-01f, -1.87440008e-01f, -2.45003253e-01f, 8.67080390e-02f, -5.44913448e-02f, 2.03954503e-02f,
  7.34386072e-02f, 2.39460506e-02f, 5.13282716e-02f, 1.06970429e-01f, -8.18381459e-02f, -1.51222004e-02f, 1.11318836e-02f, -6.39759302e-02f, -2.01352723e-02f, 1.18900411e-01f,
  1.50593296e-01f, 1.42388508e-01f, 1.57933310e-01f, 9.87377241e-02f, -6.90022781e-02f, 1.91971213e-01f, 2.65861064e-01f, 3.83523069e-02f, 2.60919482e-01f, -3.91811656e-04f,
  -5.35723194e-02f, 1.15935907e-01f, 4.81064767e-02f, -2.30413247e-02f, 5.66618294e-02f, -8.87036622e-02f, 4.61783297e-02f, 1.37719437e-02f, -5.37942164e-02f, -2.58057006e-02f,
  9.74258687e-03f, 2.49073468e-02f, -3.45788989e-03f, 1.63497068e-02f, -1.01289421e-01f, 2.20929757e-02f, 7.31957890e-03f, -2.21257284e-02f, -1.50784582e-01f, -4.82920930e-02f,
  9.12116617e-02f, -1.55531531e-02f, -5.31499535e-02f, 6.56268969e-02f, 1.45275787e-01f, -3.45725045e-02f, 1.45760865e-03f, 1.02855384e-01f, 8.99807364e-03f, 6.06448799e-02f,
  -1.78347100e-02f, -2.80374736e-02f, 6.01096563e-02f, -3.62082720e-02f, -3.61107402e-02f, -1.02808706e-01f, 1.49629591e-02f, -2.45785322e-02f, 4.99563143e-02f, 3.44102737e-03f,
  -1.34380892e-01f, -1.90152656e-02f, -7.71290511e-02f, 1.13621078e-01f, 7.50322193e-02f, 2.60779951e-02f, -1.59480814e-02f, 1.05237991e-01f, 5.10132536e-02f, 5.46897277e-02f,
  -4.00094166e-02f, 3.78889330e-02f, -1.68856792e-03f, -5.49697615e-02f, -8.84503275e-02f, 1.28251895e-01f, -5.67695079e-03f, 1.34199068e-01f, -1.30409226e-01f, -1.16607189e-01f,
  5.38653433e-02f, 3.22483480e-01f, 8.26698449e-03f, 1.69996191e-02f, -4.88164909e-02f, -9.94253308e-02f, 1.68176014e-02f, 4.22225110e-02f, 9.49996561e-02f, -4.19759303e-02f,
  1.26042917e-01f, -3.67873795e-02f, 2.23112348e-02f, -3.63392383e-02f, -1.13771208e-01f, 1.01906590e-01f, 1.81770790e-02f, 7.00573474e-02f, -4.71306406e-02f, -3.57750151e-03f,
  1.70178875e-01f, 5.19175753e-02f, -9.69143286e-02f, -9.38259214e-02f, 6.08522221e-02f, 9.40756723e-02f, -8.95271450e-02f, 7.29249343e-02f, 3.64520848e-02f, 1.61282197e-02f,
  2.97210932e-01f, -3.57956767e-01f, -1.35256842e-01f, 3.36265229e-02f, 1.40627816e-01f, -1.28577871e-03f, 8.07544738e-02f, -2.49484330e-01f, -1.99885711e-01f, -3.15580100e-01f,
  -8.00401568e-02f, -1.20186107e-02f, -1.03710636e-01f, 8.41345580e-04f, 3.39698911e-01f, -5.75963631e-02f, 3.52741554e-02f, 6.66345954e-02f, 3.33809271e-03f, -9.91314277e-02f,
  1.56695440e-01f, 1.46513432e-01f, 8.52980986e-02f, -1.43456414e-01f, 7.09670112e-02f, -7.43378848e-02f, -8.36881343e-03f, -5.86319156e-03f, -8.69111791e-02f, 1.10023245e-01f,
  1.84159338e-01f, 4.97302003e-02f, 7.49077797e-02f, 4.79438566e-02f, -7.81637654e-02f, 2.46330332e-02f, 8.74083787e-02f, 1.10410228e-01f, 5.01027368e-02f, -2.91933101e-02f,
  -1.30965292e-01f, 3.53755057e-02f, -4.01547318e-03f, 4.86358330e-02f, -1.37567874e-02f, -1.35765756e-02f, -3.24209966e-02f, 6.12821020e-02f, -1.94780305e-02f, 2.39520408e-02f,
  -1.08629934e-01f, -5.28769456e-02f, -8.54468569e-02f, -8.50766376e-02f, -1.89978890e-02f, -6.26660883e-02f, 5.96565101e-03f, -1.13458812e-01f, -1.02550805e-01f, 3.57538578e-03f,
  1.78405475e-02f, 1.05035961e-01f, -1.61253605e-02f, 3.43465954e-02f, -8.28075781e-02f, 3.43646891e-02f, 5.13760522e-02f, -8.25667754e-02f, -7.39144254e-03f, 3.52730490e-02f,
  -4.64406684e-02f, 3.97466645e-02f, 7.76974261e-02f, 6.66250139e-02f, 9.85412300e-02f, 2.95036864e-02f, 1.73086241e-01f, 4.05137837e-02f, -3.15702148e-02f, 2.79971082e-02f,
  8.76202285e-02f, 1.98437814e-02f, 5.64983897e-02f, 8.24329257e-02f, 2.84877103e-02f, 1.08790256e-01f, 2.84927264e-02f, -5.30147105e-02f, 2.23528203e-02f, 2.16283500e-02f,
  1.75896492e-02f, -2.46185392e-01f, -8.30399394e-02f, 2.16165539e-02f, 6.72220811e-02f, 9.35087260e-03f, 1.40413761e-01f, -3.43494155e-02f, -5.69802597e-02f, -2.19805371e-02f,
  -8.55954662e-02f, 6.51782453e-02f, -7.57222855e-03f, 7.00044036e-02f, 1.23900056e-01f, -8.51627365e-02f, -5.99816330e-02f, 2.00680550e-02f, 2.59266291e-02f, -1.46238253e-01f,
  -9.88000445e-03f, -8.83175507e-02f, -1.11412173e-02f, 5.68681920e-04f, -1.09520443e-01f, -6.29412234e-02f, 7.19563738e-02f, -9.97663066e-02f, -1.29898295e-01f, -2.72479299e-02f,
  -2.07710907e-01f, 3.06878000e-01f, 1.90047368e-01f, -1.66061759e-01f, 1.94093540e-01f, 1.39351651e-01f, 1.97015163e-02f, 1.40759572e-01f, 1.39683828e-01f, -1.98155090e-01f,
  -1.45915776e-01f, -3.61109935e-02f, 6.40166327e-02f, -1.09561406e-01f, -6.77289739e-02f, -3.25180255e-02f, -8.32875259e-03f, -1.40263513e-01f, 2.84094095e-01f, -9.73933004e-03f,
  2.52957847e-02f, 9.72252060e-03f, 1.79906070e-01f, 2.09062785e-01f, 1.94862559e-01f, -1.89832728e-02f, -2.53972650e-01f, 1.06387585e-01f, -1.41120389e-01f, -7.82687624e-04f,
  6.53480962e-02f, -1.50024995e-01f, 9.79852378e-02f, -5.68069406e-02f, 1.47338405e-01f, -8.34472179e-02f, -1.44127458e-01f, -1.55327260e-01f, 2.72870958e-02f, -1.20477207e-01f,
  -1.31755099e-01f, 5.81791997e-02f, 1.80036332e-02f, 5.05437329e-02f, 1.13742417e-02f, -1.49118053e-02f, 9.19377953e-02f, 7.11812004e-02f, -4.85843047e-02f, 5.03330380e-02f,
  5.45402057e-02f, 1.78280413e-01f, 1.14757456e-01f, -1.37896314e-01f, -3.16895880e-02f, -5.76794483e-02f, -9.93630290e-02f, -2.47240812e-02f, 1.53117925e-02f, 2.21217386e-02f,
  1.50037974e-01f, 2.51170006e-02f, -3.33296955e-02f, 9.20573808e-03f, -2.15388909e-02f, -3.72425020e-02f, -1.10232748e-01f, -4.19713743e-02f, -1.09484896e-01f, -2.78251581e-02f,
  4.33169454e-02f, -2.16539670e-02f, 1.04469463e-01f, -1.52329560e-02f, 5.97709827e-02f, -1.10719584e-01f, -6.73600063e-02f, -5.65801710e-02f, 9.51602235e-02f, 8.82744342e-02f,
  -3.85684930e-02f, -1.20813183e-01f, -2.25209165e-02f, -5.31850383e-02f, 4.05776724e-02f, 4.16283458e-02f, -1.04341067e-01f, 2.75788382e-02f, 6.94591254e-02f, 6.12528436e-02f,
  -1.05291910e-01f, -3.78347367e-01f, 1.25069786e-02f, -3.93932015e-02f, 3.42019685e-02f, -7.91159794e-02f, -2.17422917e-02f, -7.81987458e-02f, -5.07231019e-02f, -6.79988787e-02f,
  -9.00233388e-02f, -5.46602607e-02f, -5.30751050e-02f, 3.03347278e-02f, -2.56776549e-02f, -5.68547733e-02f, -9.87369195e-02f, -1.18394718e-01f, -9.97946933e-02f, -4.81186621e-03f,
  -4.70150746e-02f, -2.37292014e-02f, -1.00549221e-01f, 1.33240800e-02f, -1.92168280e-02f, -6.02420010e-02f, -1.82167202e-01f, 4.40409146e-02f, -5.80950182e-05f, 3.30398418e-02f,
  1.93052962e-01f, -2.87039727e-01f, 2.31848955e-02f, -6.01466745e-02f, -1.82597134e-02f, -1.79582193e-01f, 7.85481706e-02f, -2.97214508e-01f, -3.01927906e-02f, -2.36030877e-01f,
  2.19421908e-02f, 2.65250087e-01f, 2.61553168e-01f, -3.25648874e-01f, 4.33383793e-01f, 2.01049775e-01f, -2.56709903e-01f, 3.17254774e-02f, 4.87765372e-02f, -1.94311574e-01f,
  -1.82701554e-02f, -1.56611860e-01f, 1.24443412e-01f, -3.86229247e-01f, -2.20179886e-01f, -2.25089863e-01f, 1.85107529e-01f, 2.49185506e-02f, -2.14272350e-01f, 3.33797410e-02f,
  -8.97352099e-02f, -9.15475786e-02f, -9.57086533e-02f, -7.76351690e-02f, -6.89808354e-02f, -8.34726319e-02f, 1.25965364e-02f, 9.50618014e-02f, -7.37561099e-03f, 7.17555266e-03f,
  6.92063496e-02f, 2.46770885e-02f, -9.26334187e-02f, 3.98991369e-02f, -2.12175455e-02f, -9.21265185e-02f, -1.00616319e-02f, -8.27948600e-02f, -3.01754437e-02f, 2.19276547e-02f,
  7.33328685e-02f, 6.41061785e-03f, 3.42885330e-02f, 8.87668058e-02f, 2.66168900e-02f, -5.42026572e-02f, 3.40926647e-02f, 9.46092531e-02f, 3.40740532e-02f, 9.92557313e-03f,
  -3.88834029e-02f, -6.30046278e-02f, -2.18025241e-02f, 1.93142351e-02f, -7.51860067e-02f, 4.70107906e-02f, -4.56057899e-02f, 5.34685254e-02f, -3.37236114e-02f, -1.13014746e-02f,
  -8.38574991e-02f, -3.07489112e-02f, -1.49888424e-02f, -5.21147773e-02f, 3.48290126e-03f, 8.78750309e-02f, 6.13331459e-02f, 5.60154282e-02f, -7.61298910e-02f, 6.65281489e-02f,
  1.26845300e-01f, 5.07528596e-02f, -1.04581062e-02f, 8.55969638e-02f, -5.46961203e-02f, 1.07878737e-01f, -6.18173815e-02f, -3.26000527e-02f, 1.30057698e-02f, 1.12669282e-01f,
  -3.27234231e-02f, -1.84006706e-01f, -7.97116831e-02f, -1.20237716e-01f, 1.00298813e-02f, -6.94765374e-02f, -1.02723449e-01f, -1.28854543e-01f, -4.02248539e-02f, -4.47504669e-02f,
  -1.17196627e-01f, 5.12359478e-02f, -7.78297707e-02f, -3.78284268e-02f, 4.44799252e-02f, -3.31752673e-02f, 6.01842478e-02f, -1.68516382e-03f, 1.65459607e-02f, -3.74880768e-02f,
  6.11928329e-02f, -3.46051455e-02f, 6.49263635e-02f, -8.10630396e-02f, -2.42374204e-02f, 1.50343046e-01f, 1.67582706e-02f, 1.44529762e-02f, 3.15327570e-02f, 5.06028645e-02f,
  -3.34242046e-01f, 8.69754553e-02f, 2.75143117e-01f, -3.45288306e-01f, 8.27313215e-02f, 1.60880134e-01f, -2.08382513e-02f, -1.79879274e-02f, -1.89725325e-01f, -6.86306283e-02f,
  4.85030841e-03f, 1.57044344e-02f, 2.53350347e-01f, -1.83946580e-01f, 1.76300287e-01f, 1.12791106e-01f, -9.97012481e-02f, -1.67080998e-01f, 7.54425675e-03f, -9.39478576e-02f,
  -6.10604063e-02f, -8.87631252e-02f, 1.49732411e-01f, 6.78685233e-02f, 7.98353478e-02f, -1.29421726e-01f, -1.65660426e-01f, 1.49969220e-01f, -1.01356179e-01f, 8.96237120e-02f,
  1.13073193e-01f, 2.64739394e-02f, 2.01238580e-02f, -1.70065891e-02f, -9.57032740e-02f, -5.03052622e-02f, -7.87665471e-02f, 8.62170681e-02f, -8.35267901e-02f, 3.73543869e-03f,
  -1.02607355e-01f, 9.69040245e-02f, -1.62394837e-01f, 5.29958121e-02f, 8.27288479e-02f, 1.00779412e-02f, 8.27643722e-02f, 9.92828980e-02f, 1.63212866e-02f, 1.62587166e-01f,
  -7.72627536e-03f, 3.07399221e-02f, 1.80733409e-02f, -3.44122313e-02f, 5.99579923e-02f, -2.12671310e-02f, -2.89655179e-02f, 7.92996064e-02f, 9.78097040e-03f, -3.10196914e-02f,
  -4.41631004e-02f, -1.27289832e-01f, -3.15217339e-02f, -7.24531710e-02f, -1.64197050e-02f, -1.44769168e-02f, -3.23596038e-02f, -7.29490817e-02f, -4.18174304e-02f, 6.80569327e-03f,
  -1.88845005e-02f, 2.67181243e-03f, 3.10748387e-02f, -2.94117462e-02f, -7.99853280e-02f, -1.11173399e-01f, 3.56613658e-03f, -6.62530661e-02f, -1.18556552e-01f, -1.38350651e-01f,
  -1.78580396e-02f, -2.36060545e-02f, -1.23677216e-02f, 3.47459465e-02f, 2.59439368e-02f, 4.41982485e-02f, 6.36062920e-02f, 1.33650228e-01f, 1.05525233e-01f, 4.91230041e-02f,
  -6.26589283e-02f, -1.86828911e-01f, -8.03030655e-02f, 1.64046381e-02f, 1.11083910e-02f, -5.64364791e-02f, 3.90483886e-02f, -7.10527822e-02f, -1.11402832e-01f, -4.07205382e-03f,
  -5.81192151e-02f, 4.39029187e-04f, -4.96603213e-02f, 3.97957191e-02f, -8.42474494e-03f, -6.61215112e-02f, -8.00737813e-02f, -2.42699012e-02f, -6.27765357e-02f, -3.95723544e-02f,
  -5.82575891e-03f, -6.00854978e-02f, -2.05477979e-02f, -4.36818674e-02f, -8.09295923e-02f, -6.26198351e-02f, -5.07033728e-02f, -1.23144463e-02f, 7.00975582e-02f, -3.12228166e-02f,
  -5.65946758e-01f, -9.47283506e-02f, -2.88268685e-01f, -5.31675629e-02f, -2.78153449e-01f, -3.23858947e-01f, -2.55421519e-01f, -1.57485560e-01f, -8.56377706e-02f, 1.96106374e-01f,
  3.32789905e-02f, -2.55555153e-01f, 1.52232915e-01f, 5.56219369e-02f, -2.48653293e-01f, 2.53663629e-01f, -9.87469479e-02f, -6.20154142e-02f, 6.99214563e-02f, -2.29173347e-01f,
  -4.48287651e-02f, 9.55609158e-02f, 2.17246683e-03f, -8.81724358e-02f, -2.44540900e-01f, -5.53767243e-03f, 5.14748581e-02f, -5.41126020e-02f, -1.46100923e-01f, -1.68575108e-01f,
  -2.27569848e-01f, -1.18631460e-01f, -1.09239429e-01f, -5.50079979e-02f, -1.36630520e-01f, -7.79081732e-02f, -1.45834476e-01f, -5.33736497e-03f, 3.66956703e-02f, -1.13353238e-01f,
  -8.36063549e-03f, 2.03324687e-02f, -1.05799712e-01f, 9.56190825e-02f, 2.07350701e-02f, -5.34525625e-02f, -2.40036715e-02f, -6.70705512e-02f, 3.37295458e-02f, -2.38195807e-02f,
  -8.25840309e-02f, -3.30365375e-02f, 2.97252610e-02f, 7.25653917e-02f, -3.45105268e-02f, -6.71477839e-02f, 3.05298734e-02f, -3.08578764e-03f, -1.46824002e-01f, -1.50321886e-01f,
  -1.10868774e-01f, 1.71966553e-02f, 1.02081954e-01f, 2.63906643e-02f, -1.74585599e-02f, 1.14803854e-02f, -2.61149984e-02f, 1.62818301e-02f, 6.45453557e-02f, -7.22330669e-03f,
  2.43584886e-02f, -9.07888710e-02f, -3.03369947e-03f, 1.18679404e-01f, 2.12576855e-02f, -1.01958327e-01f, 3.34398486e-02f, -1.10431984e-01f, -5.63780852e-02f, 3.83743048e-02f,
  6.22973479e-02f, -1.51530966e-01f, 4.98869307e-02f, 5.09436578e-02f, -7.16192424e-02f, 1.72406882e-02f, 4.65512984e-02f, 1.16471998e-01f, -4.10530195e-02f, -5.10041304e-02f,
  -2.32951850e-01f, -2.94822961e-01f, -5.57435229e-02f, -9.27152559e-02f, 1.23702800e-02f, -9.47174132e-02f, 7.15161189e-02f, -1.49171501e-01f, -1.50756687e-01f, -1.34507060e-01f,
  3.68517525e-02f, 5.13991639e-02f, 3.17491256e-02f, 2.39657890e-02f, 1.53892413e-02f, -4.43837941e-02f, -3.21038328e-02f, 1.36649478e-02f, -1.57657694e-02f, -5.82440831e-02f,
  4.75532860e-02f, 4.29939479e-02f, 4.00324864e-03f, 1.37627319e-01f, 6.03959225e-02f, 2.85877679e-02f, -1.26798868e-01f, 1.79759134e-02f, -2.74615586e-02f, -3.79087664e-02f,
  1.90960869e-01f, -2.58119226e-01f, -3.38774472e-02f, -1.48888588e-01f, 5.50166937e-03f, -1.13076396e-01f, -1.55979451e-02f, -1.98032007e-01f, -7.64481798e-02f, -2.17961073e-01f,
  1.39135197e-02f, 2.14384109e-01f, 2.57465541e-01f, -2.06215888e-01f, 4.14533883e-01f, 2.26794973e-01f, -1.37332767e-01f, -7.96335414e-02f, -1.10810837e-02f, -1.53245434e-01f,
  -2.61788946e-02f, -1.78163052e-01f, 6.51746914e-02f, -2.77063847e-01f, -1.39987528e-01f, -1.26695961e-01f, 3.27355638e-02f, 3.01510878e-02f, -2.10522503e-01f, 1.11750573e-01f,
  9.43315998e-02f, -7.26192668e-02f, -2.49564797e-02f, 2.95194518e-02f, -1.01858638e-01f, -3.72324474e-02f, 8.33300650e-02f, 1.62315980e-01f, 5.99332377e-02f, 1.42194210e-02f,
  1.75787155e-02f, 1.05745792e-01f, -9.80632529e-02f, -5.90300113e-02f, 2.94737378e-03f, -1.15417287e-01f, -4.10190672e-02f, -4.51696105e-02f, 3.66459265e-02f, 3.45704481e-02f,
  3.21917981e-02f, 1.06730320e-01f, -1.01389624e-01f, -2.36046370e-02f, -1.15012238e-02f, -8.15313533e-02f, 7.38058332e-03f, 1.36583492e-01f, 1.53482771e-02f, -6.10951670e-02f,
  -1.93849560e-02f, -1.02852155e-02f, 1.03088620e-03f, 2.69701369e-02f, -3.27715687e-02f, 1.05434861e-02f, 5.35651147e-02f, 8.78873542e-02f, -1.02915376e-01f, 1.02315411e-01f,
  -1.17032614e-03f, 3.84491798e-03f, -1.02678221e-02f, -5.43271825e-02f, 2.47179139e-02f, 3.59354094e-02f, -2.35938821e-02f, 5.71954735e-02f, -1.20780468e-01f, -4.65741754e-02f,
  1.10219307e-01f, 8.76830667e-02f, -1.56722460e-02f, 2.50478517e-02f, -1.18249170e-02f, 1.10484749e-01f, 1.55985598e-02f, 4.12590429e-02f, -6.54076459e-03f, 1.04600295e-01f,
  -1.13218971e-01f, -2.13272780e-01f, 8.71932320e-03f, 1.48160616e-02f, -3.59159410e-02f, -1.12429477e-01f, -4.60961908e-02f, -1.10141888e-01f, -7.39585534e-02f, -7.09362552e-02f,
  -8.78521949e-02f, -3.81097347e-02f, 2.08600275e-02f, -1.26165411e-04f, 5.07082678e-02f, -1.25216264e-02f, 5.67936115e-02f, 3.24680619e-02f, -5.49194291e-02f, -2.88809766e-03f,
  1.37983924e-02f, 2.70076673e-02f, -4.11077701e-02f, -1.10209972e-01f, -1.15978085e-01f, 4.69604842e-02f, 3.13016237e-03f, 4.55173366e-02f, -5.45158423e-02f, -4.59043533e-02f,
  -2.56362140e-01f, -1.72907978e-01f, -3.14645022e-01f, -2.67770618e-01f, 1.29026875e-01f, -2.60880172e-01f, -2.10682333e-01f, 3.95104177e-02f, -7.60133862e-02f, 2.22384021e-01f,
  -4.22990844e-02f, -9.27883666e-03f, 2.13634595e-02f, -3.88725162e-01f, -3.91170681e-01f, -9.06452537e-02f, -4.09336030e-01f, -2.70772904e-01f, -1.24907576e-01f, 1.63077321e-02f,
  -1.33646935e-01f, -2.49068215e-01f, -2.62201846e-01f, 1.81163941e-02f, -1.10634625e-01f, 5.52355088e-02f, 3.32240045e-01f, 7.86796510e-02f, -6.63397312e-02f, -2.53248625e-02f,
  -1.16204239e-01f, 1.29404813e-01f, -6.34041987e-03f, -7.93234780e-02f, 1.48618203e-02f, 2.35087145e-02f, 5.60672814e-03f, -1.31715601e-03f, -2.66220029e-02f, -1.94252916e-02f,
  7.79327378e-02f, -7.55490595e-03f, -7.09493309e-02f, 3.61825079e-02f, 8.22586939e-03f, -7.64866546e-02f, -4.72123958e-02f, -1.94392372e-02f, -6.29299786e-03f, -6.14174344e-02f,
  -4.32559438e-02f, -1.55221764e-02f, 1.00311050e-02f, -2.57412102e-02f, -4.04569395e-02f, -4.07223329e-02f, 2.08175424e-02f, 1.80906449e-02f, 1.34162139e-02f, -4.45985310e-02f,
  2.59886943e-02f, 8.61347765e-02f, -2.09187511e-02f, 7.46161640e-02f, -4.81754169e-02f, 1.59011763e-02f, -5.90148009e-02f, 1.45891204e-03f, -6.44203126e-02f, 3.42566967e-02f,
  1.79091468e-02f, 1.39664570e-02f, -4.45051603e-02f, 8.32333788e-03f, -1.93238053e-02f, 7.32415216e-03f, 7.47050857e-04f, 8.01238865e-02f, -1.57409683e-01f, -4.18486074e-02f,
  6.91819564e-02f, -6.04679435e-03f, -1.16674388e-02f, 7.30786286e-03f, -4.43441644e-02f, 1.30029144e-02f, 8.25296417e-02f, -3.00247688e-02f, 6.18914142e-02f, 6.75658882e-02f,
  4.75638211e-02f, 1.80707365e-01f, 3.83622199e-02f, 2.15684958e-02f, 3.56962308e-02f, 6.11774400e-02f, -6.96006566e-02f, -5.25700487e-02f, -4.36279923e-02f, -2.77797319e-02f,
  6.70370087e-02f, -2.95255944e-04f, 4.47116606e-02f, -4.51140516e-02f, -5.53661510e-02f, 2.06726696e-02f, 4.95693684e-02f, 2.58983709e-02f, 3.01159322e-02f, 9.75504816e-02f,
  1.18102945e-01f, 3.89582664e-02f, -2.74312105e-02f, -5.19125983e-02f, 1.03566004e-02f, 8.04128721e-02f, 4.48356606e-02f, 1.81106739e-02f, -2.47486954e-04f, -6.43676706e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  9.16943327e-02f, 9.08022448e-02f, 9.88161191e-02f, 1.64288998e-01f, 1.98328435e-01f, 1.27280891e-01f, 3.28183919e-02f, 1.49764732e-01f, 2.05870464e-01f, 9.04442295e-02f,
  8.33725706e-02f, 8.82197693e-02f, 1.42129198e-01f, 1.87603027e-01f
};

// L1_fan_Wp (Shape: 25 x 64)
const int L1_fan_Wp_rows = 25;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.49042621e-01f, 1.05698720e-01f, 1.78725123e-02f, 1.81949791e-02f, -1.43156573e-01f, -6.24439456e-02f, -1.90640211e-01f, -3.93354818e-02f, -7.22549343e-03f, 1.18165366e-01f,
  1.32626086e-01f, -2.82239944e-01f, 4.76741679e-02f, 9.67643484e-02f, 7.90878683e-02f, 7.92872384e-02f, 8.07345137e-02f, -1.57896593e-01f, 3.30614448e-02f, 1.47363096e-01f,
  -8.29012990e-02f, 1.17109260e-02f, -3.57790291e-02f, 6.37684902e-03f, 6.64124340e-02f, -4.38043736e-02f, -7.10102078e-03f, 3.85009199e-02f, -1.11368895e-02f, -1.59981534e-01f,
  -1.04161143e-01f, 4.31575999e-02f, -1.00955561e-01f, 2.37419799e-01f, -5.48372976e-03f, -4.52104285e-02f, 1.66263133e-01f, 1.56370327e-01f, 6.65239431e-03f, 2.01949850e-01f,
  9.33845416e-02f, 1.45202667e-01f, -1.13010958e-01f, 3.92342284e-02f, -3.76413018e-02f, 1.80828556e-01f, 8.35573971e-02f, 7.87839293e-02f, 1.14719458e-01f, 6.59926087e-02f,
  7.35398009e-02f, 9.17740017e-02f, -1.58367604e-01f, -1.24610923e-01f, 9.01695713e-02f, 3.18646640e-01f, 1.31064013e-01f, -5.72151598e-03f, 1.99580137e-02f, 1.34950086e-01f,
  8.60045999e-02f, -3.96093279e-02f, 7.71189183e-02f, 2.04434976e-01f, -1.37596447e-02f, 1.01702988e-01f, 1.26379207e-01f, 3.93868499e-02f, -8.22474509e-02f, 1.01891220e-01f,
  1.24454267e-01f, -4.29889821e-02f, -4.18317690e-03f, 6.15587234e-02f, -1.66909665e-01f, 1.89918041e-01f, 6.01567589e-02f, 4.22983430e-02f, 1.90545488e-02f, 3.73379909e-03f,
  -6.22641109e-02f, 1.04387216e-01f, -2.36821454e-02f, -1.46048637e-02f, -1.37750823e-02f, 9.67781767e-02f, -7.49394065e-03f, 1.31149814e-01f, -5.17298235e-03f, 9.62510556e-02f,
  -1.56176463e-01f, -5.92652149e-02f, 1.15627207e-01f, -1.68788865e-01f, 1.99375898e-01f, -4.80535626e-02f, 9.17910859e-02f, -2.96838731e-01f, -3.64841819e-02f, -5.05210720e-02f,
  1.48828560e-02f, -1.30651817e-01f, -8.40333551e-02f, -1.39555350e-01f, 1.86492689e-02f, -9.86920968e-02f, -1.50214702e-01f, -6.52215183e-02f, -7.60879964e-02f, -9.08702761e-02f,
  1.15333781e-01f, -2.91486960e-02f, -1.00551983e-02f, -4.95698974e-02f, -1.79930374e-01f, -1.42924562e-01f, -2.75969952e-02f, -6.15931377e-02f, 1.44023180e-01f, 1.17929868e-01f,
  -2.61334013e-02f, -1.94805533e-01f, -2.16100216e-05f, -2.44516488e-02f, 1.68041550e-02f, 2.22071424e-01f, -7.84755424e-02f, 2.04174235e-01f, -1.27674639e-01f, -1.02887042e-01f,
  6.67755529e-02f, -6.95844144e-02f, -8.93541574e-02f, -7.28815645e-02f, 6.59272745e-02f, 5.54456227e-02f, -4.75264899e-02f, -6.53753504e-02f, -4.33129184e-02f, 1.50463536e-01f,
  -1.35750219e-01f, -1.59982573e-02f, -4.39095832e-02f, -6.15435801e-02f, -1.79014176e-01f, -5.47138713e-02f, 3.96720208e-02f, -3.91791277e-02f, -6.84969053e-02f, 9.81199220e-02f,
  -3.45364846e-02f, -6.32497743e-02f, 4.62348089e-02f, 1.79781411e-02f, -1.60325393e-01f, -2.07522482e-01f, 5.55575767e-04f, 5.19808792e-02f, 2.46428266e-01f, -5.34804426e-02f,
  7.17156567e-03f, -1.72934234e-02f, 1.57003149e-01f, -1.28248408e-01f, 1.52245998e-01f, -2.75958907e-02f, -2.66968518e-01f, -9.57242027e-02f, 3.21790995e-03f, 8.04519951e-02f,
  6.61226213e-02f, -5.71792712e-04f, 5.02734329e-04f, 5.35697453e-02f, -8.17210227e-02f, 5.87295322e-03f, 1.30453467e-01f, -1.98509648e-01f, 7.39807636e-02f, 1.04335975e-02f,
  3.19855809e-02f, 1.01128958e-01f, 1.45857185e-01f, 1.08421326e-01f, 1.33825108e-01f, -1.13569744e-01f, -2.40609214e-01f, 6.73060864e-02f, -1.73504800e-01f, 1.58419594e-01f,
  5.76902591e-02f, 6.67026863e-02f, 2.52703093e-02f, -6.23687096e-02f, -1.54695004e-01f, 1.51258428e-04f, 1.25154823e-01f, -1.29885092e-01f, -1.27450511e-01f, 1.30022973e-01f,
  -1.77304536e-01f, -7.50528872e-02f, 1.85335579e-03f, -1.19719610e-01f, -4.33199368e-02f, -1.14226177e-01f, 1.10770859e-01f, -9.98061296e-05f, 2.60126498e-02f, -1.30046055e-01f,
  1.22397810e-01f, 9.82669741e-02f, 1.45122344e-02f, -1.25363901e-01f, 7.13716149e-02f, -9.13324058e-02f, 5.81870489e-02f, 1.16250604e-01f, 1.36758313e-01f, -1.55967757e-01f,
  -1.65072069e-01f, -7.37026781e-02f, -1.15521267e-01f, -5.92710159e-04f, 9.02499445e-03f, 2.06068501e-01f, 5.77560514e-02f, -6.76863864e-02f, 2.19198212e-01f, 2.05745697e-01f,
  1.85415745e-02f, 2.17962191e-01f, 9.11799893e-02f, 9.59302634e-02f, 1.33304726e-02f, 1.19054876e-01f, -1.18258633e-01f, 1.46954283e-01f, -1.52725458e-01f, -1.28123581e-01f,
  1.26372308e-01f, 1.08708896e-01f, 1.39084235e-01f, 2.14133546e-01f, -2.29256358e-02f, 1.39389364e-02f, 6.21771906e-03f, -1.91694684e-02f, 6.39337823e-02f, 4.47331220e-02f,
  -4.74118479e-02f, -2.25482598e-01f, -1.22715198e-01f, -1.64206147e-01f, -2.08032727e-01f, 5.89678399e-02f, -1.03648575e-02f, 4.78702933e-02f, 7.79306293e-02f, -1.84496939e-02f,
  -1.25552312e-01f, 1.01197600e-01f, 1.99451685e-01f, -5.61863333e-02f, -1.73963327e-02f, 2.66047171e-03f, -1.10563122e-01f, 2.00874209e-01f, 4.75657843e-02f, 6.03642762e-02f,
  -1.05498724e-01f, -8.15357938e-02f, -1.64980590e-01f, -4.72994186e-02f, 4.15800931e-03f, -2.30150837e-02f, -1.58240497e-01f, 5.18622100e-02f, -1.51571110e-01f, -5.15947454e-02f,
  6.80125728e-02f, -1.93847809e-02f, -6.47648498e-02f, 9.33602676e-02f, 2.36058515e-02f, -4.62822877e-02f, 2.74469316e-01f, 2.90404893e-02f, -2.80986093e-02f, -1.92327514e-01f,
  1.44350559e-01f, 3.20306905e-02f, 3.96127738e-02f, -1.72622040e-01f, -1.76978245e-01f, -2.22864404e-01f, -7.14354813e-02f, 1.02309845e-01f, -5.04657142e-02f, -3.63749601e-02f,
  7.97669590e-02f, -3.04777063e-02f, 9.18299407e-02f, -2.71298848e-02f, 4.70253732e-03f, -1.42858267e-01f, 6.51220977e-02f, -3.56912240e-02f, -3.71915847e-02f, 1.16502903e-01f,
  7.95684680e-02f, 9.68456715e-02f, 9.40435976e-02f, -2.18034208e-01f, -7.16828257e-02f, 7.28491321e-02f, -6.62416741e-02f, 1.95114747e-01f, -1.26050785e-01f, 1.64229348e-01f,
  -2.63590991e-01f, 7.63034122e-03f, 1.83884233e-01f, 6.64764419e-02f, -5.93072027e-02f, -5.93908764e-02f, 1.18280783e-01f, -1.43110767e-01f, 1.08708791e-01f, -6.91305101e-02f,
  -1.75876707e-01f, 1.60724044e-01f, 1.23123527e-02f, 8.82702693e-03f, -8.78486410e-02f, -1.64620325e-01f, -1.24800146e-01f, -4.55473736e-02f, -6.31220043e-02f, -8.44904929e-02f,
  1.44855186e-01f, -5.29700629e-02f, -5.37505336e-02f, 1.06869705e-01f, 3.47683579e-03f, 8.45495909e-02f, -9.07198116e-02f, -4.68548015e-02f, 2.04056390e-02f, 1.03088602e-01f,
  9.49517414e-02f, -5.06868288e-02f, 1.05523720e-01f, -3.42546970e-01f, 9.28029343e-02f, -2.28751078e-02f, -1.25908971e-01f, -1.99259147e-02f, -1.62000328e-01f, -1.26342639e-01f,
  -1.52956992e-01f, 9.54520926e-02f, -3.73072214e-02f, -1.35361210e-01f, 6.70646131e-02f, 1.61196832e-02f, 4.69419435e-02f, -1.21702500e-01f, 1.18675511e-02f, 1.37502253e-01f,
  -9.13248062e-02f, -1.12882592e-01f, 1.30625833e-02f, 2.07906261e-01f, -1.59856707e-01f, 1.29605412e-01f, -1.47361960e-02f, -1.59816757e-01f, 2.35011075e-02f, -2.78914839e-01f,
  -4.46394570e-02f, 8.99455845e-02f, -2.17056528e-01f, 3.73636708e-02f, -5.52050248e-02f, -1.98216423e-01f, -5.70333898e-02f, 2.10809093e-02f, -5.70454039e-02f, 1.85384918e-02f,
  -5.97703904e-02f, 6.16992489e-02f, 1.16715908e-01f, -7.95686543e-02f, 9.44922790e-02f, 2.64263101e-04f, -6.00103401e-02f, 7.28324652e-02f, -9.47679281e-02f, 8.06626454e-02f,
  -5.63755222e-02f, 5.04673421e-02f, -5.35406023e-02f, -1.17258027e-01f, 1.55901045e-01f, -1.00173742e-01f, 5.03217615e-02f, -2.23151222e-02f, -1.40141964e-01f, -2.16843739e-01f,
  2.03212261e-01f, -7.28103658e-03f, 2.52247751e-02f, 1.85386971e-01f, -3.56587283e-02f, -7.37244114e-02f, 6.42111972e-02f, 5.07817119e-02f, -8.46965834e-02f, 3.42620350e-02f,
  -1.67151943e-01f, -3.53582501e-02f, 1.80749178e-01f, 6.47862405e-02f, -1.14621865e-02f, -6.64566606e-02f, 1.59672767e-01f, 7.34006166e-02f, 6.51967674e-02f, -3.35449390e-02f,
  -2.00802863e-01f, -1.60607055e-03f, -1.11521751e-01f, 1.36131302e-01f, -2.73195114e-02f, 9.62104425e-02f, 2.37524256e-01f, 1.11278929e-01f, -7.31937960e-02f, -1.39866605e-01f,
  -5.40017746e-02f, 2.84211159e-01f, -8.93196091e-02f, 1.50739104e-01f, -6.59733117e-02f, -2.75788214e-02f, 1.47220150e-01f, -1.70386061e-01f, 8.78058001e-02f, -2.70468718e-03f,
  -2.37444434e-02f, -1.76768824e-02f, 1.38034940e-01f, 1.26538649e-02f, 1.44448578e-02f, -5.12252785e-02f, 2.81698797e-02f, -4.58635241e-02f, 2.15519890e-02f, -1.95970945e-02f,
  6.04582801e-02f, -1.38007730e-01f, 1.60642654e-01f, 1.17869399e-01f, 3.31519216e-01f, -1.57173462e-02f, 4.14698757e-03f, 2.15140253e-01f, 3.48864570e-02f, -2.82506142e-02f,
  1.90124214e-02f, 7.91864768e-02f, 1.12018295e-01f, 1.00459807e-01f, 4.22710776e-02f, 1.15719296e-01f, 2.86504664e-02f, -1.33819031e-02f, -2.13270620e-01f, 1.09546728e-01f,
  -1.03682637e-01f, 1.13191031e-01f, -5.96234761e-02f, 5.64292781e-02f, -1.24947786e-01f, -7.25361053e-03f, 2.78386921e-01f, 1.13086127e-01f, 4.63726446e-02f, -1.34735644e-01f,
  5.38924970e-02f, 6.74500093e-02f, -1.17729709e-01f, -1.01542033e-01f, 1.00792736e-01f, 1.33097783e-01f, -7.15792701e-02f, 2.26736479e-02f, -1.90289631e-01f, -7.67039061e-02f,
  -6.95802495e-02f, -2.24006400e-01f, -4.26714867e-02f, -2.06270307e-01f, -1.47679061e-01f, 3.84250320e-02f, 2.36217231e-01f, -6.82966039e-02f, 1.41250581e-01f, -2.20790014e-01f,
  -5.27172489e-03f, -2.60594875e-01f, -7.83209037e-03f, 1.49308294e-01f, 8.72997567e-02f, -1.06706552e-01f, 8.76611695e-02f, -9.74288285e-02f, 1.05229832e-01f, -2.10779663e-02f,
  -3.08166146e-02f, 6.73994049e-02f, -5.40875681e-02f, -2.12137382e-02f, 7.31714144e-02f, 8.63849595e-02f, -4.48176339e-02f, -1.92757770e-02f, 1.75030492e-02f, 4.21459228e-03f,
  4.43247557e-02f, -9.61989686e-02f, -1.38746902e-01f, 4.57788780e-02f, -2.34382063e-01f, 1.43828429e-02f, 1.16848357e-01f, 1.06628574e-01f, -1.45767435e-01f, -4.94077653e-02f,
  2.21728869e-02f, -1.18494079e-01f, 5.20105325e-02f, 1.96378589e-01f, -1.16210915e-01f, -7.44500384e-02f, 1.61903754e-01f, 1.64657891e-01f, 2.19747156e-01f, -1.93620294e-01f,
  -1.35367095e-01f, -1.56570554e-01f, -1.15200274e-01f, -2.88144108e-02f, -1.01436451e-01f, -1.09130070e-01f, 9.39803794e-02f, 6.58125877e-02f, 1.71481550e-01f, -7.02547878e-02f,
  4.19769920e-02f, -2.10878730e-01f, 7.82682672e-02f, -1.73262600e-02f, -9.71253142e-02f, 1.94749221e-01f, 1.62678480e-01f, 8.03215504e-02f, 3.84847596e-02f, -1.27940476e-01f,
  7.19123855e-02f, -1.37424141e-01f, 6.16479367e-02f, 2.02627897e-01f, -1.80028126e-01f, -2.94488985e-02f, -3.04688886e-02f, -1.45819530e-01f, -1.17919199e-01f, 9.28854197e-02f,
  4.34155874e-02f, 2.51762401e-02f, -5.37199434e-03f, 9.64651406e-02f, -7.26671144e-02f, -1.20211162e-01f, -3.24977897e-02f, 1.08585231e-01f, -2.26700127e-01f, -1.90531762e-04f,
  -5.92615046e-02f, -5.55166192e-02f, -8.98411423e-02f, 4.14203554e-02f, 6.89285528e-03f, -4.03138474e-02f, 1.05884984e-01f, -8.39469880e-02f, 9.18645635e-02f, -1.37511792e-03f,
  -1.11009531e-01f, -8.99187922e-02f, -1.66229516e-01f, -2.09842607e-01f, -8.17661434e-02f, 1.04254149e-01f, 1.67217165e-01f, -1.17972173e-01f, 1.55654415e-01f, -4.28660773e-02f,
  1.23751536e-01f, -5.37935533e-02f, -6.13591596e-02f, 3.37715521e-02f, -1.78394154e-01f, -3.40745971e-02f, 4.28474918e-02f, -8.41419101e-02f, 2.06489518e-01f, -5.74407540e-02f,
  1.34799272e-01f, 2.20501758e-02f, -1.73056826e-01f, -1.99637741e-01f, 7.79359862e-02f, -1.35595612e-02f, 2.32393488e-01f, 2.16635510e-01f, 1.75174445e-01f, 1.68914154e-01f,
  -1.72568597e-02f, -1.33792877e-01f, 7.38517419e-02f, 2.65908241e-02f, -1.55525446e-01f, -1.69110149e-01f, -1.93154067e-01f, 6.58252016e-02f, -7.44613558e-02f, -1.59425244e-01f,
  1.81399868e-03f, 8.49144161e-02f, -4.07116190e-02f, 4.53894101e-02f, 6.14351816e-02f, 1.18137253e-02f, 2.10936312e-02f, -3.15722749e-02f, 1.93679228e-03f, -7.02726692e-02f,
  1.39025273e-02f, 5.40009961e-02f, -5.22320671e-03f, -3.06687020e-02f, 1.47723526e-01f, 8.80557373e-02f, 1.67454809e-01f, 1.01574361e-01f, 5.55077270e-02f, 6.20767176e-02f,
  -4.83364351e-02f, 7.72744194e-02f, 5.69780469e-02f, -6.67363405e-02f, 1.29180774e-01f, 1.75404444e-01f, 8.27260762e-02f, -1.15126394e-01f, 1.79324718e-03f, -8.36426020e-02f,
  -8.87766331e-02f, 2.45578021e-01f, -1.04494900e-01f, 1.69666812e-01f, 1.03298508e-01f, -5.11796996e-02f, 1.81916133e-01f, -1.40026763e-01f, 1.16432920e-01f, 2.85370219e-02f,
  1.27309829e-01f, -1.81913376e-01f, 1.54830441e-01f, 5.78065999e-02f, -9.63900164e-02f, -2.17320725e-01f, 1.05120894e-02f, 2.17479900e-01f, -1.23817660e-01f, -1.32956654e-01f,
  -2.27911621e-01f, -2.99467981e-01f, -3.84178571e-02f, -3.04468989e-01f, 3.53597850e-01f, -1.10947885e-01f, -7.40621015e-02f, -2.55338997e-02f, 9.29959118e-02f, 1.84575915e-01f,
  2.97676288e-02f, -1.98549569e-01f, 1.69338018e-01f, -5.17762899e-02f, 2.96027083e-02f, 8.82265270e-02f, 1.48998216e-01f, 5.77745177e-02f, 2.10771081e-03f, 1.14154220e-01f,
  9.12489742e-02f, -5.35475537e-02f, -5.00481613e-02f, -5.76472953e-02f, -9.20962170e-02f, 1.75187632e-01f, -8.78572166e-02f, 1.16284974e-01f, -1.37557477e-01f, -1.05322145e-01f,
  -1.90168962e-01f, 2.10649654e-01f, 8.54754373e-02f, -1.21381730e-01f, 3.75303216e-02f, 1.24112226e-01f, -4.65237014e-02f, 3.60525213e-02f, -7.23670051e-02f, 8.73603299e-02f,
  -2.79853582e-01f, -1.41219079e-01f, 2.05734689e-02f, -8.27863514e-02f, 2.25306019e-01f, -1.83155328e-01f, 3.48009095e-02f, -3.21341246e-01f, 3.14044580e-02f, -2.12975778e-03f,
  -5.23466021e-02f, -1.71547189e-01f, -2.20641285e-01f, -1.75055355e-01f, 9.96312052e-02f, 1.84659325e-02f, 7.04052746e-02f, -1.23396091e-01f, 8.93415287e-02f, -1.58080474e-01f,
  -8.57993087e-04f, -1.92173436e-01f, 1.40750900e-01f, 6.17762879e-02f, 1.56391293e-01f, -8.34747553e-02f, 6.34662509e-02f, 1.06733963e-01f, 7.03521296e-02f, 6.68507665e-02f,
  1.54653594e-01f, -9.97261181e-02f, -6.62554279e-02f, -5.32235540e-02f, 3.44448537e-02f, 1.66830108e-01f, 4.66060787e-02f, 1.67545289e-01f, -1.01094969e-01f, -9.51154903e-02f,
  6.45205751e-02f, 6.45786524e-02f, 2.45294362e-01f, -4.04778076e-03f, 5.73290102e-02f, 1.87817350e-01f, -1.08017191e-01f, -6.25064671e-02f, 3.84971648e-02f, 1.89243212e-01f,
  -2.18441710e-01f, -3.98467481e-02f, -5.06858639e-02f, -1.49441928e-01f, 5.15880957e-02f, 8.55316743e-02f, -5.87528246e-03f, 8.54346715e-03f, 6.99998662e-02f, 7.31624067e-02f,
  7.52774924e-02f, 3.61475721e-02f, 3.89146432e-02f, 3.19922306e-02f, -2.55739063e-01f, -1.45626590e-01f, -1.88934073e-01f, 1.09668098e-01f, 6.59173429e-02f, 4.42775935e-02f,
  1.20734796e-01f, 2.77572349e-02f, 2.80840993e-01f, -1.17344201e-01f, 7.26914778e-02f, -6.08931072e-02f, -8.28772634e-02f, -5.58627844e-02f, 9.32130888e-02f, -1.71185941e-01f,
  1.09408110e-01f, -8.00688416e-02f, 1.51803106e-01f, 1.93164200e-01f, -1.42613769e-01f, -1.47518769e-01f, 1.07522115e-01f, -4.53207195e-02f, -5.71041629e-02f, 1.16595820e-01f,
  2.74493605e-01f, 3.96962136e-01f, 5.13646230e-02f, -1.34425297e-01f, 2.31251139e-02f, -1.86602771e-01f, -3.53804678e-02f, -1.94976702e-01f, -1.85639828e-01f, 1.50217220e-01f,
  -2.08953887e-01f, -2.45518193e-01f, 6.35031387e-02f, -6.00646585e-02f, -2.56444737e-02f, -3.19715291e-02f, -2.83504516e-01f, 5.10088503e-02f, -1.53625980e-01f, -8.51186514e-02f,
  -4.66463454e-02f, -2.49746032e-02f, 6.19556978e-02f, -1.28496200e-01f, -4.42842096e-02f, -5.19820722e-03f, -3.05465627e-02f, 4.84034792e-02f, -4.22686189e-02f, -6.15738891e-02f,
  -1.33368865e-01f, -6.06651492e-02f, -1.56929687e-01f, 4.81270701e-02f, 8.65043029e-02f, -9.32195857e-02f, -1.41173899e-01f, -1.50852561e-01f, 1.59741774e-01f, 2.12660611e-01f,
  1.00399576e-01f, 4.51408066e-02f, 1.18212618e-01f, -1.48217067e-01f, 6.27925098e-02f, 8.61223638e-02f, -1.13836698e-01f, -9.32923332e-03f, -1.69779658e-01f, 2.50761099e-02f,
  7.01295957e-02f, -3.26925665e-02f, -1.53390868e-02f, 1.20695211e-01f, 3.49293537e-02f, 1.55441478e-01f, -6.86121359e-02f, -1.50679752e-01f, -6.61855638e-02f, 1.74937069e-01f,
  -1.75147243e-02f, 9.18746926e-03f, 2.01892301e-01f, 1.17004856e-01f, -7.92758316e-02f, -1.60793126e-01f, -1.80254221e-01f, -1.45585880e-01f, 8.95619914e-02f, 1.62376285e-01f,
  -2.43892133e-01f, 3.13398391e-01f, -5.75184859e-02f, 1.44488858e-02f, 2.49270767e-01f, 6.53108442e-03f, -9.80152041e-02f, 1.53406663e-02f, -7.64685348e-02f, -1.09484807e-01f,
  1.24237210e-01f, -2.49346010e-02f, 1.13642663e-01f, 2.17770547e-01f, -1.15768865e-01f, -1.63524952e-02f, 6.83972910e-02f, 1.29028773e-02f, -2.33097374e-01f, 1.45141473e-02f,
  2.46687271e-02f, -1.42903566e-01f, -1.53504917e-02f, -1.31165251e-01f, 2.78961076e-03f, 4.23100516e-02f, -8.24479312e-02f, 6.22310303e-02f, -2.55997740e-02f, -7.40699023e-02f,
  1.26296714e-01f, 1.42747955e-02f, -1.38363943e-01f, -1.37785450e-01f, -8.57427642e-02f, 9.63643193e-02f, 1.30933329e-01f, 1.99624062e-01f, -7.37442374e-02f, 1.61867768e-01f,
  2.92349726e-01f, -1.46614626e-01f, 2.28866369e-01f, -8.98114499e-03f, -1.13832228e-01f, -1.16284117e-01f, 1.07756881e-02f, -1.13079876e-01f, 4.98096906e-02f, -6.43344596e-02f,
  1.33634713e-02f, 1.76586285e-01f, -4.23630700e-02f, 4.39918693e-03f, 6.54407293e-02f, -2.86832750e-01f, -2.00969130e-02f, 1.59738529e-02f, -5.08313440e-02f, 1.51588574e-01f,
  2.16953292e-01f, 1.35313421e-01f, -1.23712188e-03f, -2.12630868e-01f, -7.20065013e-02f, -1.19181708e-01f, -8.80625844e-02f, 9.05943960e-02f, -1.64879158e-01f, -8.68744105e-02f,
  1.44602969e-01f, 8.21085051e-02f, -1.12152502e-01f, -5.08664437e-02f, 3.07077565e-03f, -3.89650278e-02f, -1.31642088e-01f, 4.38926741e-02f, -4.38937172e-02f, -2.20360588e-02f,
  1.63484648e-01f, -2.00144842e-01f, -6.14008717e-02f, -3.15179005e-02f, 7.07994327e-02f, 7.70453438e-02f, 1.41818196e-01f, -6.63092062e-02f, 1.65193621e-02f, 6.78484067e-02f,
  -1.30621657e-01f, -1.38370404e-02f, -4.57244925e-02f, -1.51279598e-01f, -1.08112283e-02f, -5.44311665e-02f, 6.86088353e-02f, 4.09169905e-02f, -6.57876432e-02f, -4.98700067e-02f,
  -1.74952418e-01f, 1.11267477e-01f, -8.98734257e-02f, 3.44034106e-01f, 6.09829929e-03f, 5.60435466e-02f, 1.47457287e-01f, 7.18406737e-02f, 1.12085827e-01f, 2.01497912e-01f,
  1.22291774e-01f, -8.83112103e-02f, 1.08260578e-02f, 1.25232711e-01f, -8.24387595e-02f, 4.94248718e-02f, -4.76952735e-03f, 9.65893343e-02f, -6.88526547e-04f, -3.24853547e-02f,
  8.25550407e-03f, 1.39745429e-01f, -1.01121910e-01f, -1.00030147e-01f, 8.45566094e-02f, -1.68001801e-01f, 1.01547219e-01f, 1.23670816e-01f, 8.09067339e-02f, 1.42941445e-01f,
  4.94445264e-02f, -1.17502347e-01f, 1.59529567e-01f, -1.55449018e-01f, -4.33318838e-02f, -3.86132300e-03f, -2.66667232e-02f, 9.50573161e-02f, -1.59975290e-02f, 1.17472835e-01f,
  -1.37893051e-01f, -3.58523689e-02f, -2.05610059e-02f, -4.74875123e-04f, 1.15994073e-04f, 4.52386364e-02f, 3.32299918e-02f, 9.15926769e-02f, -6.37508035e-02f, -8.87796432e-02f,
  -1.97025597e-01f, 6.35008374e-03f, -4.31035161e-02f, -3.81430648e-02f, 1.34763746e-02f, -1.13224626e-01f, -5.01163397e-03f, 3.51548344e-02f, -5.93563877e-02f, -1.51135428e-02f,
  -4.14837524e-02f, 6.61114678e-02f, -1.78372450e-02f, -6.34999499e-02f, 3.58238071e-02f, -3.32894504e-01f, 1.61487982e-01f, -2.32255310e-01f, -1.46752268e-01f, 5.30930944e-02f,
  -1.61989376e-01f, 1.63908631e-01f, -1.38365015e-01f, -3.70671302e-02f, 7.44228512e-02f, 1.77343592e-01f, -3.32735889e-02f, 2.19757650e-02f, -5.25121689e-02f, 5.91453761e-02f,
  -5.29863127e-02f, -1.86038673e-01f, 1.54159158e-01f, 2.81332582e-01f, 3.08679372e-01f, 3.08011293e-01f, 1.68018881e-02f, 2.12009147e-01f, -3.11700612e-01f, 9.11213607e-02f,
  1.60861924e-01f, -1.60276163e-02f, -1.10897951e-01f, -2.27781683e-01f, -5.40518463e-02f, 4.86876965e-02f, -1.63467497e-01f, 6.30022436e-02f, -2.80456282e-02f, -1.13343112e-01f,
  -4.69461549e-03f, 4.31738235e-02f, -5.94830886e-02f, -3.26690823e-02f, -1.43293962e-01f, 7.17813671e-02f, 7.28074685e-02f, -9.50724408e-02f, 1.55364897e-03f, -4.30449657e-02f,
  -1.60745189e-01f, 5.36749512e-02f, -5.71733341e-02f, -1.14552174e-02f, -6.83373213e-02f, 7.78241530e-02f, 1.98827051e-02f, -1.30965307e-01f, 3.90078202e-02f, -5.46844713e-02f,
  8.76292810e-02f, -7.92050213e-02f, -1.33941755e-01f, -2.74064779e-01f, -8.26094076e-02f, 5.19970898e-04f, 2.63990252e-03f, 2.05160007e-01f, -5.95083125e-02f, -9.95597988e-02f,
  7.94152468e-02f, 7.69989491e-02f, 3.35210096e-03f, 5.77780530e-02f, -2.06206039e-01f, 1.11223776e-02f, 2.90499032e-02f, 4.53195721e-03f, 1.16185330e-01f, -1.14040345e-01f,
  1.78127989e-01f, 4.62252572e-02f, 1.69399828e-01f, 1.00439288e-01f, -2.07569003e-01f, -1.67852283e-01f, 6.62548542e-02f, 4.94214371e-02f, 2.25427836e-01f, 2.38855943e-01f,
  1.85296044e-01f, 1.60010502e-01f, -1.18419550e-01f, -1.72851250e-01f, -7.16221705e-03f, 7.94590265e-02f, -1.36371136e-01f, -1.13687869e-02f, -5.08484654e-02f, -3.14675719e-02f,
  2.66991723e-02f, -2.60354012e-01f, 1.07026398e-01f, 2.15415116e-02f, -2.01741960e-02f, -4.87756822e-03f, 9.17529780e-03f, -3.07022780e-02f, 1.61695078e-01f, 4.75236960e-02f,
  2.54247319e-02f, -6.64493442e-02f, 2.77065653e-02f, -1.63671058e-02f, 4.62070294e-02f, -1.96234807e-02f, 1.66535601e-01f, 1.11454815e-01f, 1.25614136e-01f, -4.71321940e-02f,
  5.56922108e-02f, 8.40163454e-02f, -1.10425964e-01f, 7.28292167e-02f, 8.54722317e-03f, -5.75379319e-02f, 1.04872853e-01f, 1.19372219e-01f, 1.49701461e-01f, -4.95031243e-04f,
  -1.92944650e-02f, -1.24564812e-01f, -6.76878616e-02f, 1.26360655e-01f, -4.53975722e-02f, 8.42944607e-02f, 1.06626756e-01f, -1.08816482e-01f, 1.30886957e-01f, -2.47255564e-01f,
  3.50982659e-02f, 3.69847752e-02f, 5.17554805e-02f, -3.39633264e-02f, 4.68664523e-03f, 6.13193261e-03f, -6.06515072e-02f, -2.22965956e-01f, 3.26682329e-02f, 2.03461573e-01f,
  -1.03016213e-01f, -1.28486723e-01f, -1.15687519e-01f, -2.62438387e-01f, -2.54624821e-02f, -2.86548406e-01f, 2.15819567e-01f, -1.70554012e-01f, -9.04543176e-02f, -1.76715739e-02f,
  2.59739123e-02f, 1.35012999e-01f, -7.13940058e-03f, -2.00602546e-01f, 8.28557834e-02f, 8.91167969e-02f, -1.75776586e-01f, 2.94261631e-02f, 5.87725081e-03f, 1.08022645e-01f,
  2.56782353e-01f, -2.74108946e-02f, 1.48566842e-01f, 4.75283340e-02f, 1.04535833e-01f, -1.69447586e-02f, -6.39055073e-02f, 2.43863136e-01f, -7.94909745e-02f, 5.44293895e-02f,
  -7.64990598e-02f, -6.29507005e-02f, 2.08022743e-02f, 1.67419076e-01f, 7.38644004e-02f, -2.94595975e-02f, 7.93126747e-02f, -6.02844656e-02f, -3.73359136e-02f, 1.30614564e-01f,
  1.39405325e-01f, 1.78305313e-01f, -1.61789253e-01f, -2.03741208e-01f, -5.94750233e-02f, 1.55319981e-02f, -7.23539293e-02f, 1.43751800e-01f, -8.10063556e-02f, -1.64166212e-01f,
  1.37629390e-01f, -3.79319116e-02f, 4.23069187e-02f, -1.07803270e-01f, 6.02560900e-02f, -8.09679255e-02f, 2.74335872e-02f, -2.47096136e-01f, 1.31629750e-01f, -2.27597311e-01f,
  9.95171890e-02f, 8.60263184e-02f, -3.12398933e-02f, -2.07084984e-01f, 7.42526259e-03f, -8.54432490e-03f, -1.55278444e-01f, -3.95471081e-02f, 1.52759999e-01f, 1.84930131e-01f,
  1.56323656e-01f, 2.41501957e-01f, -1.54467508e-01f, -1.66372240e-01f, 2.21087009e-01f, -3.43768626e-01f, 6.69968873e-02f, 1.15291864e-01f, -2.45782390e-01f, -1.82671040e-01f,
  6.81397691e-02f, 2.56350543e-02f, -2.02961549e-01f, 8.82130638e-02f, 7.16735572e-02f, -4.54284921e-02f, -9.58532244e-02f, 4.36830260e-02f, -6.38639480e-02f, -1.17008984e-01f,
  8.96655321e-02f, 9.76158530e-02f, -7.91220069e-02f, -1.07133212e-02f, -5.00517860e-02f, -1.39223579e-02f, -9.49546918e-02f, -1.16719566e-01f, 6.26975670e-02f, 5.31343706e-02f,
  1.52005583e-01f, -1.34588152e-01f, 1.92442432e-01f, 4.55058366e-02f, -1.89561591e-01f, 3.09134778e-02f, 1.46306500e-01f, 1.60635896e-02f, -1.07728332e-01f, -7.66038001e-02f,
  -4.88156080e-02f, -2.88559705e-01f, 1.63729697e-01f, -1.53007754e-03f, -1.04661986e-01f, -4.56715636e-02f, -1.73859775e-01f, 1.57991409e-01f, -8.11150223e-02f, 1.31153107e-01f,
  1.56210274e-01f, 8.36819708e-02f, 2.30023433e-02f, 4.00706530e-02f, -1.21530950e-01f, -6.93426579e-02f, -1.30590513e-01f, -9.80061218e-02f, 7.18578696e-02f, 2.72731334e-01f,
  9.18484032e-02f, 2.35348523e-01f, 7.13579059e-02f, 2.97673400e-02f, -2.05773085e-01f, -1.37950867e-01f, 1.49452567e-01f, -3.00081614e-02f, -1.68461651e-01f, -1.58829227e-01f,
  -1.28959551e-01f, -1.93779349e-01f, -1.15988582e-01f, 6.88902512e-02f, -7.26511702e-03f, -1.28925517e-01f, -1.49196209e-02f, -1.94879379e-02f, 9.59617496e-02f, 4.43324745e-02f,
  1.86997058e-03f, 4.42591235e-02f, 1.81872576e-01f, 6.24886155e-02f, -2.12275609e-02f, 1.02658704e-01f, -1.25091717e-01f, 7.52476826e-02f, -1.66329458e-01f, 8.83348435e-02f,
  6.00243919e-02f, 2.06723288e-01f, -3.71442027e-02f, -1.12883441e-01f, 1.28844634e-01f, -4.51052040e-02f, 3.37736867e-02f, -2.57550217e-02f, -1.18741076e-02f, -1.07091300e-01f,
  -1.05232872e-01f, -1.21595509e-01f, 2.41486933e-02f, 1.90323278e-01f, -5.60513102e-02f, -3.74781974e-02f, -2.61003710e-02f, -9.22836270e-03f, -4.47903248e-03f, 9.48938578e-02f,
  -1.58021316e-01f, -1.36924699e-01f, 1.89257979e-01f, -1.55988634e-01f, 4.15786132e-02f, -1.74295619e-01f, 2.19993725e-01f, -1.22859806e-01f, 2.54420340e-01f, -3.31379771e-02f,
  -1.20306544e-01f, -2.18010545e-01f, -1.43015087e-01f, -1.59590505e-02f, 7.32420683e-02f, 7.51790777e-02f, 2.70266503e-01f, 1.67969152e-01f, -2.18167510e-02f, -2.18578175e-01f,
  -5.85218593e-02f, 2.65826792e-01f, 1.12755194e-01f, -1.53675871e-02f, 9.63660404e-02f, -1.01458848e-01f, 5.29399551e-02f, -2.84480631e-01f, -1.11715510e-01f, -7.91109446e-03f,
  8.16633627e-02f, -6.10521361e-02f, -4.73720357e-02f, -7.31958225e-02f, 1.28924996e-01f, 1.59604370e-03f, -4.57410663e-02f, 2.46142671e-02f, -4.85848524e-02f, -8.57189950e-03f,
  1.00318328e-01f, 7.91938230e-03f, 1.16872313e-02f, -7.11380318e-02f, 5.95554560e-02f, -7.98956025e-03f, -2.70515941e-02f, -6.99559525e-02f, -1.40462279e-01f, 1.70815498e-01f,
  -2.26908475e-01f, 5.93463853e-02f, 1.62041411e-01f, -4.31692824e-02f, -5.80414124e-02f, 1.60145033e-02f, 4.42462228e-02f, 5.18440790e-02f, 6.80378824e-02f, 3.28754961e-01f,
  -2.01982871e-01f, 5.37290871e-02f, 2.13515922e-01f, 1.29185095e-02f, 1.18927471e-01f, -1.97787374e-01f, 4.04742956e-02f, -5.60818836e-02f, -1.77859873e-01f, -9.04648751e-02f,
  3.31969969e-02f, 2.53875479e-02f, 1.20197527e-01f, 1.62902951e-01f, 1.70265123e-01f, 5.31594604e-02f, 7.04891374e-03f, -3.53018761e-01f, -1.81925520e-01f, -6.08545318e-02f,
  -7.26432130e-02f, 6.77437782e-02f, 1.52706549e-01f, 1.20418042e-01f, -1.16220444e-01f, -1.27227321e-01f, 1.58738643e-02f, 2.30075479e-01f, 7.62166232e-02f, 2.60317147e-01f,
  8.99382606e-02f, -5.91009185e-02f, -7.21699968e-02f, -9.33829546e-02f, 4.09296826e-02f, -9.90252867e-02f, 1.98790342e-01f, -1.94628954e-01f, 1.11966684e-01f, 2.34564990e-02f,
  -8.14939011e-03f, -3.30655798e-02f, -4.30110320e-02f, -8.00276697e-02f, -9.08133015e-02f, -7.06539229e-02f, -1.03368163e-01f, -2.35084090e-02f, 1.10859081e-01f, 2.32984661e-03f,
  -4.76113195e-03f, 1.04395501e-01f, 2.35218573e-02f, 5.15951365e-02f, -1.99876744e-02f, -9.12585482e-02f, 1.44830838e-01f, 2.45996803e-01f, 4.04857770e-02f, -2.23667398e-01f,
  -8.25372059e-03f, -2.89806556e-02f, -4.22090963e-02f, 3.81167054e-01f, -1.56390116e-01f, 1.00520298e-01f, 1.78290948e-01f, 1.47694694e-02f, 1.75018758e-01f, 9.68639404e-02f,
  1.43962100e-01f, 7.00615942e-02f, -1.04094520e-01f, -7.29834381e-03f, 2.46615540e-02f, -1.09524876e-01f, 8.93992707e-02f, 1.06111199e-01f, 1.00311197e-01f, -1.11396015e-01f,
  -4.77636606e-02f, -1.15777373e-01f, -2.63348520e-01f, -2.06108615e-01f, -9.85429212e-02f, -1.96188912e-01f, 1.42913342e-01f, 2.62117505e-01f, -1.72348067e-01f, 4.02184576e-02f,
  3.00924867e-01f, -1.75835118e-01f, 8.87086168e-02f, -8.74277875e-02f, -7.97262862e-02f, -5.89567535e-02f, -1.54698594e-02f, 1.06102757e-01f, -8.83379802e-02f, -4.73302864e-02f,
  5.15655708e-03f, 4.86221863e-03f, -1.71463061e-02f, 6.20386079e-02f, -4.45519611e-02f, -7.18820170e-02f, 8.78584012e-02f, -1.88412935e-01f, -2.07767542e-02f, 1.60793662e-01f,
  1.77958965e-01f, 1.53290406e-02f, -6.76398352e-02f, -7.08693787e-02f, -1.42942630e-02f, 1.14924192e-01f, -5.71844205e-02f, -5.97782545e-02f, 2.01489449e-01f, 1.09797806e-01f,
  -8.50645751e-02f, -1.46024972e-01f, -7.46440738e-02f, 1.12728380e-01f, -1.73441675e-02f, -8.82540718e-02f, -1.17056370e-01f, -1.88810661e-01f, 2.67673969e-01f, 9.42638069e-02f,
  -2.19195828e-01f, -2.16537751e-02f, -7.13192075e-02f, 2.36542434e-01f, -1.86754450e-01f, 3.32403481e-02f, 8.28568935e-02f, -4.47786152e-02f, -1.40177131e-01f, 5.64214848e-02f,
  -1.54852644e-01f, 1.18277349e-01f, -6.57434985e-02f, -1.02055790e-02f, 1.69815168e-01f, 9.90517363e-02f, -2.12007035e-02f, 2.02750802e-01f, -1.01213865e-01f, -3.82934995e-02f,
  -1.94907248e-01f, -8.62919986e-02f, 1.45802170e-01f, -2.00501695e-01f, -1.42896146e-01f, -3.86811644e-02f, -1.35707244e-01f, -1.37238160e-01f, -2.66111076e-01f, 1.48725003e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 64)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  -5.29901646e-02f, 1.24907605e-01f, 3.44445765e-01f, 2.73250956e-02f, 2.47707758e-02f, 7.40503967e-02f, 2.32924774e-01f, 2.85580829e-02f, 9.51233357e-02f, 2.85453677e-01f,
  -3.05088628e-02f, 2.17651382e-01f, 1.68162137e-01f, 1.79934353e-01f, 5.83474450e-02f, 1.26602709e-01f, 9.72401723e-02f, 1.66458249e-01f, 2.34199893e-02f, -3.88137624e-02f,
  1.14581920e-02f, 1.94318041e-01f, -1.37711897e-01f, 4.65332381e-02f, 4.22948264e-02f, -2.23996658e-02f, -6.34097680e-02f, 1.04682580e-01f, 1.41971350e-01f, 4.63421308e-02f,
  2.56831735e-01f, 1.62703767e-01f, -1.70142010e-01f, -3.29617411e-01f, 3.47483829e-02f, 2.43500039e-01f, -2.92101130e-02f, -2.69351482e-01f, 1.36914730e-01f, -1.26676798e-01f,
  -2.10556030e-01f, 4.74570729e-02f, -2.68647186e-02f, -1.73616782e-01f, 1.58832014e-01f, -5.79424500e-02f, 1.63545236e-01f, -3.21868509e-02f, -6.17433973e-02f, -1.36135891e-01f,
  -4.81545031e-02f, -4.32537645e-02f, -4.67180498e-02f, 3.35976809e-01f, 1.09243214e-01f, 1.34028435e-01f, 3.83501016e-02f, 6.50449097e-02f, 1.15984082e-01f, 2.03771964e-01f,
  2.50579268e-01f, 3.04001540e-01f, 1.60256907e-01f, 1.59380466e-01f, 2.07756728e-01f, 2.11823490e-02f, -7.21995533e-02f, 5.25213331e-02f, 1.14944339e-01f, 9.98430550e-02f,
  1.39750779e-01f, 9.97333452e-02f, 3.14252041e-02f, -9.08619240e-02f, 1.90619975e-01f, 2.21107349e-01f, -2.35900521e-01f, 6.57244958e-03f, -2.36140587e-03f, -5.14495969e-02f,
  -2.35035911e-01f, 7.85903782e-02f, 1.46648839e-01f, 6.73451349e-02f, 1.42466381e-01f, 2.50291973e-01f, 1.72085837e-01f, 8.01984407e-03f, 5.53677827e-02f, -4.33796570e-02f,
  -3.66004735e-01f, 9.64872073e-03f, -1.28724471e-01f, 1.01288389e-02f, 3.15610826e-01f, -2.49895349e-01f, 4.44337241e-02f, 2.47309939e-03f, 3.28312725e-01f, -2.67264456e-01f,
  6.18383698e-02f, -2.10625783e-01f, -2.90970087e-01f, -1.50647447e-01f, 1.95264354e-01f, 4.79511134e-02f, 2.28496507e-01f, 2.68889703e-02f, 2.48387814e-01f, -6.11973070e-02f,
  -2.09494233e-01f, -1.13815323e-01f, 1.82880044e-01f, -6.69535920e-02f, 3.48568082e-01f, 7.11904988e-02f, 2.25040391e-01f, 1.56264499e-01f, 1.47116436e-02f, -3.31325501e-01f,
  1.96834594e-01f, 3.19918729e-02f, -2.87598640e-01f, -3.12391389e-02f, -1.88912138e-01f, -1.23872653e-01f, 1.21365851e-02f, 7.69485952e-03f, 1.27574936e-01f, 2.01686665e-01f,
  2.00217776e-02f, 9.80140567e-02f, 3.25371861e-03f, 9.15407538e-02f, -3.11892014e-02f, 4.56603989e-02f, -8.49875361e-02f, -6.04405478e-02f, 1.55982465e-01f, -2.19195962e-01f,
  7.45232627e-02f, 1.10630587e-01f, 2.06106275e-01f, 9.59979668e-02f, 5.83696328e-02f, -1.78542331e-01f, 1.34549052e-01f, 1.35617524e-01f, 4.96032536e-02f, 8.06775596e-03f,
  2.21099421e-01f, 1.26402155e-01f, 7.17180073e-02f, 1.26170382e-01f, 4.22051437e-02f, 7.23018125e-02f, -1.78634468e-02f, -7.86707923e-02f, -6.86528906e-02f, -1.35186076e-01f,
  1.39380053e-01f, 5.31636328e-02f, -1.39613017e-01f, -1.52277529e-01f, 1.24637134e-01f, 3.20008487e-01f, -1.50799766e-01f, 6.29495457e-02f, -4.17369902e-02f, 1.99851722e-01f,
  -3.03607255e-01f, 1.15506649e-01f, -1.97307810e-01f, 1.35342136e-01f, 8.91704112e-03f, -1.43116191e-02f, 1.99756786e-01f, 7.50778094e-02f, -2.33600891e-04f, 1.20831102e-01f,
  -2.38181353e-01f, 4.90203267e-03f, -6.69455901e-02f, 3.50619018e-01f, 4.15645801e-02f, -2.28588834e-01f, -5.52111194e-02f, -2.07532346e-01f, -6.85622543e-02f, 6.56928569e-02f,
  -2.13113859e-01f, 2.94642687e-01f, 3.76787484e-02f, 1.46618992e-01f, -7.46913115e-03f, 6.60393909e-02f, 1.70750871e-01f, 2.70355064e-02f, 1.74270913e-01f, 1.95267007e-01f,
  3.02724191e-03f, 4.26307730e-02f, 1.14107266e-01f, 9.60186049e-02f, -8.10044333e-02f, -3.14155151e-03f, 1.47404060e-01f, 3.17235366e-02f, -3.59918661e-02f, -2.05976497e-02f,
  1.13065146e-01f, 2.40181968e-01f, 5.07822149e-02f, 2.00928420e-01f, 3.08224093e-03f, 7.17692748e-02f, 3.15151751e-01f, 1.78092420e-01f, -1.76459506e-01f, -2.47009918e-01f,
  -6.10205494e-02f, -1.09579638e-01f, 1.70402259e-01f, 1.41291872e-01f, -3.83225083e-02f, 8.30227062e-02f, 3.55013758e-01f, -2.04343498e-01f, 3.19544762e-01f, -1.93208922e-02f,
  -1.90255702e-01f, -4.81350981e-02f, 4.79224324e-02f, 7.82915205e-02f, -9.20988545e-02f, -3.76662612e-02f, 1.08582161e-01f, 1.77085921e-01f, 3.25411186e-02f, -3.74907791e-03f,
  1.25007167e-01f, -2.06568450e-01f, 2.26157885e-02f, -1.39896544e-02f, 5.46466336e-02f, 1.15460530e-01f, 3.68540019e-01f, 2.41161913e-01f, 2.24647954e-01f, -2.09717914e-01f,
  4.33054380e-03f, -1.52194932e-01f, -1.10415660e-01f, -1.69317657e-03f, -9.93445441e-02f, 3.03475529e-01f, -4.26451955e-03f, -6.69942796e-02f, 1.74007520e-01f, 1.18273892e-01f,
  1.37690887e-01f, 8.74789059e-02f, 7.45028406e-02f, -3.70231876e-03f, 2.42392570e-01f, 8.28670412e-02f, -1.81371216e-02f, 1.68672100e-01f, 6.40381500e-02f, 7.53864348e-02f,
  -7.70171434e-02f, 1.77544042e-01f, 1.97515249e-01f, 3.50330591e-01f, 1.86828952e-02f, 9.29206796e-03f, 2.36129865e-01f, 1.39141887e-01f, 5.07715456e-02f, 2.57040206e-02f,
  -5.05920202e-02f, -1.16488472e-01f, 8.79324321e-03f, 3.03336140e-02f, 4.44146693e-02f, 2.36077353e-01f, -9.57486778e-02f, -4.81287902e-03f, -2.57748887e-02f, -1.03904404e-01f,
  -3.30275930e-02f, 2.14861423e-01f, -2.28390381e-01f, -1.63665280e-01f, 1.64231718e-01f, -5.98733425e-02f, -7.09359646e-02f, -1.91672057e-01f, 2.30511725e-01f, -9.16652977e-02f,
  1.36532545e-01f, -1.13422126e-01f, -1.07574500e-01f, -1.49178222e-01f, -1.76461369e-01f, 5.07554039e-03f, 2.01258715e-02f, 8.43907073e-02f, 2.32433304e-01f, 3.51698279e-01f,
  -1.80814974e-02f, -1.78889245e-01f, -9.58812684e-02f, 1.80496618e-01f, 1.97526827e-01f, -4.21528481e-02f, 1.76297978e-01f, -2.28260309e-02f, 1.94052532e-02f, -2.75788158e-01f,
  1.40380323e-01f, 1.83818750e-02f, -1.67082787e-01f, 8.42151195e-02f, 2.08444417e-01f, 1.04787573e-01f, -1.38498601e-02f, 1.20395601e-01f, -8.58604610e-02f, -8.35580844e-03f,
  2.64918119e-01f, 3.06864735e-02f, -4.55432534e-02f, 5.32500148e-02f, 2.05460191e-01f, 1.16939005e-02f, 1.03573091e-02f, -8.59134421e-02f, 9.55937803e-02f, 1.32463560e-01f,
  6.31829277e-02f, -4.48349603e-02f, 3.00687879e-01f, 1.21105075e-01f, 1.90356430e-02f, 8.40841830e-02f, 1.06771700e-01f, 6.78708255e-02f, -1.38428867e-01f, -1.08690791e-01f,
  5.30908071e-03f, -1.09200448e-01f, 1.43076152e-01f, 1.52505711e-01f, -2.56276457e-03f, -1.71965718e-01f, 6.66196942e-02f, 9.46892574e-02f, -1.02689058e-01f, 2.11257294e-01f,
  1.57257482e-01f, -1.25326850e-02f, -1.37821510e-01f, 7.06747621e-02f, -1.27494842e-01f, 6.68873917e-03f, -1.05407707e-01f, 6.60434514e-02f, 9.66608599e-02f, 8.75272229e-02f,
  1.42853856e-01f, 8.25428888e-02f, -4.97846585e-03f, -6.54695705e-02f, 1.63583774e-02f, -1.72668248e-01f, 1.43536538e-01f, -9.80193987e-02f, -8.06781724e-02f, -1.83783859e-01f,
  -2.12143287e-01f, -1.55023307e-01f, -1.96568236e-01f, 8.81318599e-02f, 1.31066330e-02f, -1.62030384e-02f, -1.13892287e-01f, 1.64480418e-01f, 3.62029642e-01f, 1.00401032e-03f,
  8.78297910e-02f, 2.04652250e-01f, 3.84928957e-02f, -1.12246417e-01f, 2.31506884e-01f, 9.53808427e-02f, -2.90931612e-01f, -1.82232231e-01f, 5.38753942e-02f, 4.85561751e-02f,
  1.29303828e-01f, 4.93561886e-02f, 3.50536183e-02f, 2.48968184e-01f, 1.79169729e-01f, 1.31121039e-01f, 1.80773839e-01f, -1.66150201e-02f, 6.28039539e-02f, 9.83861983e-02f,
  -2.51975022e-02f, -3.62082660e-01f, -1.39490798e-01f, 9.99153331e-02f, 1.70254521e-02f, 7.43868500e-02f, -6.74057752e-02f, 3.91332597e-01f, 2.93050021e-01f, -3.45553517e-01f,
  2.01572299e-01f, -1.75222158e-02f, 5.44371828e-02f, 1.76581383e-01f, 2.28099108e-01f, -1.91165626e-01f, 2.31920436e-01f, 4.71906289e-02f, 3.10373511e-02f, 7.67707229e-02f,
  -2.16924757e-01f, 1.02335066e-01f, -4.38780524e-03f, -8.29498395e-02f, -1.34911947e-02f, 5.75314797e-02f, 2.58553922e-01f, -1.45234719e-01f, 3.23719680e-01f, -2.29010463e-01f,
  1.10589907e-01f, -3.42684947e-02f, 1.52132474e-02f, -7.52367675e-02f, -2.04872832e-01f, -3.68445307e-01f, 3.40861678e-02f, -1.58219665e-01f, 2.11808041e-01f, 1.59923345e-01f,
  7.36343116e-02f, 1.24827661e-01f, -2.01319560e-01f, 1.50070965e-01f, 3.65165505e-03f, -1.03368955e-02f, 1.69262066e-02f, 2.04525143e-01f, 2.47083589e-01f, -6.59483001e-02f,
  2.55316138e-01f, 2.02605322e-01f, 2.44024783e-01f, 1.80631086e-01f, 1.68855563e-01f, 6.69080317e-02f, 1.30196154e-01f, -1.67008415e-02f, -1.36970818e-01f, 1.58413872e-01f,
  7.79729486e-02f, 1.14560984e-01f, -3.41529213e-02f, -6.85240924e-02f, 1.52078003e-01f, 2.59789795e-01f, 2.17330635e-01f, -1.65296599e-01f, 1.27010262e-02f, 3.97512875e-02f,
  -2.16604937e-02f, 1.92836812e-03f, -2.37255350e-01f, 1.44468561e-01f, -4.93795685e-02f, -6.09979741e-02f, 2.33194649e-01f, -1.90252904e-02f, -6.24085516e-02f, 1.77481286e-02f,
  -1.96594790e-01f, 3.13407183e-02f, -1.68714553e-01f, -1.43384621e-01f, 8.18225443e-02f, 1.88562900e-01f, -9.81028974e-02f, -3.83961163e-02f, -3.27706225e-02f, 5.94663024e-02f,
  -1.44659534e-01f, -1.16954803e-01f, 4.35093306e-02f, 5.24547361e-02f, 8.33175480e-02f, 2.01587737e-01f, 1.91112738e-02f, 4.07656729e-01f, 1.63527548e-01f, 2.39361688e-01f,
  3.24115336e-01f, 2.41161555e-01f, 1.60385773e-01f, 1.66713387e-01f, -9.36555490e-02f, -1.79470778e-02f, 1.66050315e-01f, 2.77055204e-02f, 1.38095558e-01f, 1.68607250e-01f,
  -5.50098419e-02f, -6.19288683e-02f, 2.16717526e-01f, -3.11927833e-02f, -4.67906334e-02f, 2.97661349e-02f, 2.67521590e-01f, 3.33155692e-02f, -2.03849133e-02f, -1.40742376e-01f,
  1.18203416e-01f, 1.48046896e-01f, -1.25708766e-02f, 6.33818060e-02f, 1.75576031e-01f, 1.33489594e-01f, 1.76049992e-01f, 1.72690675e-01f, -3.53962220e-02f, 2.39189789e-02f,
  -1.41824484e-01f, -1.55474484e-01f, 6.39853701e-02f, 2.65319422e-02f, 1.07728563e-01f, 1.89814568e-01f, 1.51080906e-01f, -2.49966398e-01f, 2.94077784e-01f, 1.28199711e-01f,
  -2.97072202e-01f, 1.60289109e-01f, 8.72347876e-02f, 1.54993400e-01f, -2.10445166e-01f, 1.09655321e-01f, -2.32945025e-01f, 1.27788931e-01f, 3.59818675e-02f, 3.47793140e-02f,
  1.03678599e-01f, -1.09175593e-01f, 3.81487831e-02f, 1.45872205e-01f, -2.82291234e-01f, -3.28849927e-02f, -1.13003282e-02f, 4.77693640e-02f, 1.55224890e-01f, -2.10957080e-01f,
  -5.87374419e-02f, -1.25153974e-01f, -1.44867659e-01f, 1.89168472e-02f, -1.78094596e-01f, 2.94673651e-01f, 2.29841843e-02f, 1.49544522e-01f, 2.68086880e-01f, 2.53299356e-01f,
  1.30533904e-01f, 1.54611483e-01f, 3.53170708e-02f, -1.61742672e-01f, 2.42580265e-01f, 1.11247696e-01f, -1.17195927e-01f, 1.53499946e-01f, 2.23336071e-01f, 6.98071495e-02f,
  -6.04469925e-02f, 1.50627837e-01f, 4.49381489e-03f, 2.63750434e-01f, 4.50666547e-02f, 1.32544294e-01f, 2.69631356e-01f, -1.40578160e-02f, 8.72153267e-02f, 2.79667526e-01f,
  -1.96507946e-02f, 1.82725325e-01f, -1.67893633e-01f, -1.49684504e-01f, 6.87057972e-02f, -5.03888316e-02f, -2.95753516e-02f, -2.66420394e-01f, 3.91557962e-02f, -5.16987920e-01f,
  -2.13964030e-01f, 1.23555705e-01f, -1.89510360e-01f, 4.74610329e-02f, -6.59207851e-02f, -2.47022226e-01f, -1.11754268e-01f, 1.54343238e-02f, -3.17169935e-03f, -1.29473463e-01f,
  1.20924152e-01f, -7.01283216e-02f, 6.95839226e-02f, -2.78213978e-01f, 6.21202327e-02f, 3.63986373e-01f, 9.69939157e-02f, -1.77423414e-02f, 4.72901240e-02f, 4.45100442e-02f,
  -1.45313382e-01f, 3.53511721e-01f, -8.83841421e-03f, 2.96868980e-02f, 3.30237836e-01f, -3.95041525e-01f, 1.52360678e-01f, 4.52548303e-02f, -1.47941262e-01f, 2.68519610e-01f,
  -7.49119446e-02f, -5.50511032e-02f, 1.97631672e-01f, 1.18395969e-01f, 2.21768141e-01f, -5.23536578e-02f, 1.70571551e-01f, 1.27589718e-01f, 1.13243148e-01f, 7.10540712e-02f,
  -1.01760492e-01f, 2.23880515e-01f, 1.12689391e-01f, -8.39143470e-02f, -5.75684682e-02f, 1.02654539e-01f, 1.46021649e-01f, 2.09461197e-01f, 6.63375333e-02f, 6.16289116e-02f,
  2.05861762e-01f, 1.60763115e-01f, -2.70980597e-02f, 1.50804773e-01f, 1.90867111e-01f, 2.02703193e-01f, -2.30049044e-02f, -1.68811157e-01f, 5.16532548e-02f, -2.37363782e-02f,
  -6.44694595e-03f, 2.03128740e-01f, -2.37818688e-01f, -7.13305250e-02f, 2.04724863e-01f, 9.96973515e-02f, 1.35536522e-01f, -2.55098287e-02f, 1.88764974e-01f, -1.03460044e-01f,
  -1.17860459e-01f, -4.33442965e-02f, 1.21383667e-01f, -1.78305537e-01f, 2.35663563e-01f, -3.52660827e-02f, 1.36641756e-01f, -1.07027471e-01f, -1.13872737e-01f, -1.06350988e-01f,
  -1.80446252e-01f, -6.86715394e-02f, 7.72934482e-02f, 1.40076712e-01f, 2.12957472e-01f, 2.36402720e-01f, -3.20055820e-02f, 1.02338092e-02f, 3.16420197e-01f, -1.15305617e-01f,
  1.54155672e-01f, 4.83684912e-02f, -9.15074572e-02f, -2.24938756e-03f, 1.76190481e-01f, -1.06977135e-01f, -7.92372599e-03f, 1.68197766e-01f, 3.00343573e-01f, 1.89426504e-02f,
  -4.27337177e-02f, 2.17304081e-01f, 6.52788207e-02f, 4.73773964e-02f, 2.63072103e-01f, 1.94720756e-02f, -6.46287799e-02f, -1.58298582e-01f, 1.33095980e-01f, 1.39766395e-01f,
  2.67850399e-01f, 3.43611874e-02f, 1.59564584e-01f, 2.59701461e-01f, 2.07675919e-01f, 1.41347526e-02f, 2.72069782e-01f, 1.59983560e-02f, 1.19542971e-01f, 3.86809036e-02f,
  2.94373453e-01f, -1.26114398e-01f, -6.07206225e-02f, 1.47109687e-01f, -1.86716512e-01f, 6.97399080e-02f, -1.10776305e-01f, 4.16224837e-01f, 1.60312325e-01f, -1.86247379e-01f,
  1.16519826e-02f, 9.28566381e-02f, 1.64199829e-01f, 3.31470132e-01f, 1.32777736e-01f, -1.24965057e-01f, 2.27170125e-01f, 1.10847585e-01f, -5.09953536e-02f, 1.24446973e-01f,
  -1.70014605e-01f, 1.55964211e-01f, -9.25022215e-02f, 1.77761316e-02f, 5.39433211e-02f, 1.76894620e-01f, 1.70783117e-01f, -9.85903516e-02f, 9.06855091e-02f, -9.64832008e-02f,
  -5.59123140e-03f, 3.09481233e-01f, 1.11116074e-01f, 1.26126736e-01f, -2.61194305e-03f, -3.40788633e-01f, 1.18181303e-01f, -1.98542640e-01f, 7.34974518e-02f, 1.49202824e-01f,
  9.31523815e-02f, 4.76366952e-02f, -8.29226226e-02f, 1.62589684e-01f, 6.69849629e-04f, 7.55209569e-03f, 9.96843278e-02f, 1.52071357e-01f, 4.72631454e-02f, 1.41833916e-01f,
  3.35774012e-02f, 2.15396613e-01f, 2.74422150e-02f, -3.82067356e-03f, -1.22485235e-01f, 1.76183864e-01f, 6.84550107e-02f, -4.08000275e-02f, 1.15774041e-02f, 9.35939774e-02f,
  1.12031065e-01f, 1.80682484e-02f, 5.94593212e-03f, -2.16007799e-01f, -2.24646091e-01f, 8.99866894e-02f, 2.51038116e-03f, 9.33984295e-02f, 2.13104263e-01f, -2.17276007e-01f,
  1.03736125e-01f, -8.35060999e-02f, 6.40638992e-02f, 1.19291553e-02f, -9.66838226e-02f, -1.70828000e-01f, -1.98981985e-01f, -1.27979174e-01f, 1.40266508e-01f, 7.57153705e-03f,
  9.17632803e-02f, -1.24796536e-02f, 3.86222824e-02f, -6.38562441e-02f, -1.13503173e-01f, -9.61740687e-02f, 1.25831872e-01f, -5.77265956e-03f, 2.65897065e-01f, 1.71390191e-01f,
  8.19972083e-02f, 2.10732087e-01f, -7.44468940e-04f, -1.66756853e-01f, 2.58464605e-01f, 1.45652428e-01f, -2.66166180e-01f, 1.69577152e-01f, -7.52613172e-02f, 2.98987538e-01f,
  1.51326075e-01f, 1.30846232e-01f, 1.48001060e-01f, 2.79429972e-01f, 1.25759706e-01f, 6.99001178e-02f, 6.22789934e-02f, -1.58041567e-02f, 9.85927135e-02f, 9.46751535e-02f,
  -6.28222078e-02f, 1.67997390e-01f, 3.62080000e-02f, -5.36515564e-02f, 1.90277830e-01f, 8.49921182e-02f, 2.14382559e-01f, 1.63479447e-01f, 7.18414262e-02f, 1.35253826e-02f,
  1.02117449e-01f, 1.32520810e-01f, -2.67938171e-02f, 6.22886457e-02f, -3.48284207e-02f, 6.42219186e-02f, 2.36972228e-01f, 2.16562152e-01f, -6.26349375e-02f, -5.40828519e-02f,
  -4.88617867e-02f, -1.54952347e-01f, -4.21950966e-02f, 1.93526000e-01f, -8.69235471e-02f, 1.01381958e-01f, 9.01279375e-02f, -2.92171873e-02f, 2.81961292e-01f, 8.01059902e-02f,
  -2.81686261e-02f, 2.08884012e-02f, 4.08555865e-02f, 1.15667947e-01f, -2.16375127e-01f, -3.03286463e-02f, -3.19705382e-02f, 1.44615874e-01f, 2.03453168e-01f, 7.12526441e-02f,
  1.25938207e-01f, -1.35568708e-01f, -6.07235655e-02f, -1.82046741e-02f, -1.83428511e-01f, -6.96729422e-02f, 3.55950505e-01f, 3.35217118e-01f, 1.32307172e-01f, -9.01496336e-02f,
  2.02505618e-01f, 9.64203328e-02f, 1.07366867e-01f, 1.52790472e-01f, 3.56565677e-02f, 3.41881633e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  1.13185726e-01f, 1.24256052e-02f, 1.45014703e-01f, 1.07924290e-01f, 2.02372551e-01f, 6.55062869e-02f, 7.12250546e-02f, 1.53934211e-01f, 1.43773392e-01f, 1.97048217e-01f,
  3.66902240e-02f, 2.17007294e-01f, 1.48784429e-01f, 1.32994980e-01f
};

// L2_fan_Wp (Shape: 25 x 64)
const int L2_fan_Wp_rows = 25;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  4.30364441e-03f, -5.45456000e-02f, 5.35235740e-02f, 5.43957688e-02f, -7.90957659e-02f, 9.04554650e-02f, -8.34486037e-02f, -1.15217613e-02f, -1.24812927e-02f, 1.57232895e-01f,
  7.33114854e-02f, 2.14685276e-02f, 1.70061082e-01f, -1.59319527e-02f, 5.32454774e-02f, 9.35385749e-03f, 7.87805691e-02f, 1.12245539e-02f, 5.50362729e-02f, -3.68349142e-02f,
  3.53356861e-02f, -2.58385446e-02f, 5.04078194e-02f, -6.03435375e-02f, 4.31885831e-02f, 5.89582585e-02f, 7.94255063e-02f, -2.76691467e-02f, 1.31766945e-01f, 3.59906405e-02f,
  4.25306149e-02f, -1.40243709e-01f, 1.82849541e-01f, 9.41166952e-02f, -8.10367540e-02f, 1.62046880e-01f, -5.07165678e-02f, 1.29175559e-01f, -1.49865314e-01f, 1.26177147e-01f,
  -1.67865269e-02f, -5.97051978e-02f, -1.47689611e-01f, 5.15394658e-02f, 2.40749493e-01f, -4.54852693e-02f, -7.35464022e-02f, 2.05889530e-02f, 2.10318059e-01f, 3.91754182e-03f,
  -9.28365514e-02f, -1.45517394e-01f, 2.31697373e-02f, 1.91744506e-01f, -2.95807272e-02f, -4.68701832e-02f, 1.55883640e-01f, -1.75046638e-01f, 5.07405363e-02f, 1.47882953e-01f,
  4.63208593e-02f, 7.25450069e-02f, -2.50200450e-01f, 1.08102582e-01f, 2.86234543e-02f, -3.57838417e-03f, 8.53223875e-02f, -4.91782986e-02f, 7.76857361e-02f, 1.03458017e-01f,
  -4.67147417e-02f, 1.01931460e-01f, 6.50628656e-02f, 6.36712015e-02f, 3.26883346e-02f, 1.21667042e-01f, 1.37582228e-01f, 1.30890217e-02f, 7.32387006e-02f, 9.15818736e-02f,
  3.20440568e-02f, 1.31538452e-03f, 1.07542239e-01f, -1.54860178e-02f, 2.83385850e-02f, 8.51038620e-02f, 4.07037027e-02f, -6.62013367e-02f, 3.88569795e-02f, 1.26653790e-01f,
  -3.86790894e-02f, 1.49290413e-02f, 2.12093264e-01f, -9.57158655e-02f, -1.22525625e-01f, -1.55648693e-01f, 9.77200791e-02f, 3.67409773e-02f, -3.40381898e-02f, 9.09505412e-02f,
  -3.92650627e-02f, 6.71140701e-02f, -1.31077498e-01f, 4.17045355e-02f, 9.16589648e-02f, -4.84816097e-02f, -1.85786635e-02f, 4.79447842e-02f, 1.32368892e-01f, 1.97605975e-02f,
  -1.13451593e-01f, -1.24592297e-01f, 1.87309965e-01f, 7.29640126e-02f, -2.13267833e-01f, 8.66090655e-02f, 9.46987271e-02f, 1.63243622e-01f, -9.97753963e-02f, 1.28041863e-01f,
  2.21014485e-01f, -1.22711785e-01f, 1.41877159e-01f, 1.18906528e-01f, 4.41646539e-02f, 5.37630767e-02f, -1.08250231e-01f, 1.95388049e-01f, 4.31468375e-02f, 1.41517013e-01f,
  6.81696683e-02f, 6.17468506e-02f, 7.23889321e-02f, 1.45786166e-01f, 1.31944045e-01f, 9.50103849e-02f, 1.36874884e-01f, 1.09711528e-01f, 4.30730060e-02f, 4.48591672e-02f,
  4.85436358e-02f, 7.85640106e-02f, 1.03602372e-01f, -2.79056709e-02f, 2.14762427e-02f, 6.64576590e-02f, 9.39534605e-02f, -6.56394511e-02f, 9.57264155e-02f, -6.78061619e-02f,
  1.20167844e-01f, 1.03650123e-01f, 7.69817680e-02f, -2.18869567e-01f, 1.03558928e-01f, 7.40006343e-02f, -4.58394587e-02f, 1.06472662e-02f, 1.64584875e-01f, -3.14961374e-02f,
  8.81518424e-02f, 8.83915424e-02f, 6.65759966e-02f, 7.83186704e-02f, 1.31570935e-01f, 1.56518251e-01f, -2.90468365e-01f, 7.93451816e-02f, -1.46941110e-01f, -1.10161982e-01f,
  -1.00554198e-01f, 1.39224902e-01f, 2.60414660e-01f, -4.69865985e-02f, -1.47752289e-03f, 5.05007990e-02f, 1.32196710e-01f, -4.12310138e-02f, -2.57670246e-02f, 1.34445637e-01f,
  1.76692400e-02f, 1.03060842e-01f, 1.80272773e-01f, 5.85768297e-02f, 2.50787437e-01f, -1.70641765e-01f, 5.57843745e-02f, 7.56125376e-02f, 7.15476498e-02f, -2.90569477e-02f,
  -9.40798894e-02f, 7.05863610e-02f, -5.05283102e-02f, 7.25260098e-03f, -5.27266674e-02f, 9.65233967e-02f, 6.97679892e-02f, -3.81799005e-02f, 4.59867008e-02f, 8.93514138e-03f,
  1.92125533e-02f, -4.83143255e-02f, 2.65371222e-02f, 1.17280670e-02f, -5.75847737e-02f, -7.39553571e-02f, 2.52591446e-03f, -1.22224331e-01f, 3.37041803e-02f, -5.03568072e-03f,
  -3.12563144e-02f, -1.33855447e-01f, -5.75280450e-02f, -8.39807466e-02f, -1.22397803e-01f, -2.29064166e-03f, 3.80398445e-02f, 1.31460037e-02f, 1.85317010e-01f, -6.19707406e-02f,
  -1.25266343e-01f, 9.38734561e-02f, 1.61540776e-01f, -2.73371339e-02f, -3.47932801e-02f, 8.97600874e-02f, -1.29671231e-01f, -1.29474059e-01f, 1.20049722e-01f, -1.21573173e-01f,
  -9.82153043e-03f, -1.51237831e-01f, -5.45673519e-02f, 6.98495135e-02f, -6.24748133e-02f, 3.29353986e-03f, -4.41238135e-02f, -2.49162521e-02f, -3.69609781e-02f, 1.69084948e-02f,
  -1.59716830e-01f, -3.26825120e-02f, 1.06413983e-01f, -3.94855998e-02f, -1.11533515e-03f, -4.27840017e-02f, 8.66750181e-02f, -1.02573894e-01f, -2.50845253e-01f, 1.27619833e-01f,
  -6.43104315e-02f, 1.16690226e-01f, -3.84154283e-02f, -2.17486545e-01f, 6.13498539e-02f, 1.27235688e-02f, -2.24629138e-02f, 9.48217884e-02f, -7.15062097e-02f, 4.76212539e-02f,
  1.16027251e-01f, -1.40726184e-02f, -5.04303686e-02f, 3.13732326e-02f, 8.16055089e-02f, -9.95377675e-02f, 8.91187042e-02f, -2.34089680e-02f, 4.79129441e-02f, -1.34992525e-01f,
  -6.10450581e-02f, -8.15347675e-03f, -1.33617232e-02f, 2.76578311e-02f, 5.93045689e-02f, 7.58591574e-04f, -9.41853039e-03f, 2.54325252e-02f, 1.29389241e-01f, 1.11731909e-01f,
  1.24614462e-02f, 4.31648977e-02f, 1.58975497e-01f, -7.70423636e-02f, -1.27812624e-01f, 4.95837964e-02f, 7.28283301e-02f, -1.56540930e-01f, 1.08662993e-01f, 1.45924464e-01f,
  -1.48401245e-01f, 1.97615400e-01f, 2.64825784e-02f, -2.07757562e-01f, -6.29506707e-02f, -3.82114016e-02f, -3.51996049e-02f, -1.11823112e-01f, -1.99027017e-01f, 1.92272887e-01f,
  -5.49783893e-02f, -1.68068320e-01f, -1.83858439e-01f, 1.04030520e-01f, 1.25144362e-01f, -2.82330420e-02f, 1.23880006e-01f, -9.98994187e-02f, 5.49999438e-02f, 9.81883109e-02f,
  -6.54512942e-02f, -4.39551212e-02f, -1.04838714e-01f, 1.08600885e-01f, -1.96739263e-03f, 6.82776049e-02f, 3.43295117e-03f, -2.12641716e-01f, -1.20655678e-01f, 1.60845488e-01f,
  -3.74273099e-02f, 1.74889326e-01f, -1.26316892e-02f, 9.04416218e-02f, 1.20816685e-01f, 1.00263506e-01f, 6.25891192e-03f, -9.19295847e-02f, 3.30509394e-02f, -2.04803664e-02f,
  8.91451091e-02f, 2.04993994e-03f, -9.99481976e-03f, -1.41551085e-02f, -6.34923354e-02f, 1.30187124e-01f, 5.63214719e-02f, 1.21288121e-01f, 9.19330642e-02f, -1.02486217e-03f,
  5.69638051e-02f, 7.69237056e-02f, 4.02925387e-02f, -2.97148973e-02f, 1.64931759e-01f, 1.17324263e-01f, -8.76491424e-03f, 6.12505116e-02f, -6.25700727e-02f, -2.19056271e-02f,
  -7.67245367e-02f, -1.00330964e-01f, 1.21556304e-01f, 3.20113525e-02f, -1.41599953e-01f, 1.09744690e-01f, 1.42108630e-02f, -1.34809062e-01f, -5.67395836e-02f, -7.28632733e-02f,
  6.03871308e-02f, -1.07151039e-01f, -1.49052426e-01f, 1.09023735e-01f, 1.02644406e-01f, -9.32305008e-02f, -4.46171649e-02f, 1.89619735e-02f, 6.71963319e-02f, -1.25584170e-01f,
  5.60448505e-02f, -1.03546031e-01f, -6.17070794e-02f, 9.49404165e-02f, -8.26783851e-02f, 8.87244288e-03f, 4.99313027e-02f, 4.44252044e-02f, -2.13914714e-03f, 6.50605634e-02f,
  1.54474393e-01f, -6.74556801e-03f, -8.57519060e-02f, 2.03137845e-01f, -4.59722392e-02f, 1.52163608e-02f, 2.28847284e-02f, 2.08731648e-03f, 8.64305273e-02f, 1.27581388e-01f,
  -3.80146801e-02f, 4.72837910e-02f, 1.32168783e-02f, 5.60176931e-03f, 2.96568014e-02f, -1.63050573e-02f, -1.26722276e-01f, -6.44969940e-02f, 5.90653382e-02f, 4.27210033e-02f,
  7.32451538e-03f, -1.70916077e-02f, -1.52745014e-02f, 8.00547749e-03f, 6.66798875e-02f, -9.71984416e-02f, -2.03135367e-02f, -3.62112075e-02f, 1.06470287e-01f, 1.50597366e-02f,
  -2.11853944e-02f, 2.07024306e-01f, 9.86366346e-02f, -3.10040116e-02f, 5.90789802e-02f, 1.43512441e-02f, -2.34255224e-01f, 4.88617048e-02f, 9.33725610e-02f, -1.79023400e-01f,
  1.71033099e-01f, 8.50579664e-02f, -1.42789349e-01f, 1.19557388e-01f, -1.05955461e-02f, 2.70084590e-01f, 1.10214107e-01f, -1.09176032e-01f, -4.41847406e-02f, 1.92502886e-01f,
  -9.11645070e-02f, -1.42584875e-01f, -1.48546636e-01f, 7.94598833e-02f, -3.66475284e-02f, 2.05891624e-01f, -6.88337767e-03f, 1.37762979e-01f, -1.24145150e-01f, 1.17528580e-01f,
  -5.14080264e-02f, -1.45792067e-01f, 1.75260752e-01f, -6.00328669e-02f, -1.41953677e-01f, -1.36343939e-02f, 1.67549178e-01f, -1.46578271e-02f, 3.00357528e-02f, -1.84397679e-02f,
  -3.92988957e-02f, -1.33820325e-01f, -1.01346165e-01f, -3.79765630e-02f, 6.05428889e-02f, -8.95179529e-03f, -9.89051759e-02f, 9.88201126e-02f, -3.85823171e-03f, 5.99637888e-02f,
  1.51154488e-01f, -4.54329588e-02f, 8.82791635e-03f, 2.57500540e-02f, 2.74494495e-02f, 9.03932229e-02f, 3.16630630e-03f, 1.39431655e-02f, -4.03873995e-02f, 1.09536715e-01f,
  -1.45838596e-02f, -1.43143516e-02f, -1.24746434e-01f, -2.38968767e-02f, -4.04491015e-02f, -1.99862376e-01f, 1.93605646e-02f, -7.98567906e-02f, -8.99988636e-02f, 2.79126521e-02f,
  1.67808294e-01f, 2.77529396e-02f, -8.03128034e-02f, 8.98774937e-02f, -2.09543616e-01f, 6.79987967e-02f, -3.27597372e-02f, -1.26564046e-02f, 5.17975315e-02f, -2.24985406e-01f,
  -6.11614957e-02f, 6.04836792e-02f, 9.21265408e-02f, -1.25246748e-01f, 1.59217209e-01f, 1.59569159e-01f, 2.16208696e-01f, 1.86063198e-03f, 5.57146631e-02f, -2.43417263e-01f,
  -4.59615588e-02f, -6.12291135e-02f, 1.47314906e-01f, -6.06469773e-02f, 6.79715425e-02f, -8.08177292e-02f, -1.08378775e-01f, -5.62381148e-02f, 1.32868752e-01f, 8.70174691e-02f,
  -1.54415786e-01f, 1.38717201e-02f, 5.67445345e-02f, 4.23857085e-02f, 5.15987948e-02f, 1.98597647e-02f, 8.66317675e-02f, 1.29341230e-01f, 4.65545170e-02f, -7.40121007e-02f,
  3.06163970e-02f, 2.33371742e-02f, -1.80240832e-02f, -1.72687415e-02f, -7.04090968e-02f, 9.46018994e-02f, 1.55195603e-02f, 1.87088460e-01f, -1.32749856e-01f, 3.22255790e-02f,
  2.69632787e-02f, 1.18700720e-01f, 5.39097227e-02f, 4.33556885e-02f, 4.65641730e-02f, -1.79834124e-02f, 3.52977514e-02f, 5.27108312e-02f, -1.44652694e-01f, 8.01022723e-02f,
  1.41773894e-01f, -2.08688304e-02f, -2.25752011e-01f, 6.87396526e-02f, -2.20603049e-02f, -5.07386811e-02f, 9.36784372e-02f, 8.85827243e-02f, -4.16454626e-03f, 1.52904406e-01f,
  4.30192575e-02f, -2.82039940e-02f, 6.58571273e-02f, -7.72714987e-02f, 1.03902817e-01f, 2.57519875e-02f, -6.12512007e-02f, 8.87356624e-02f, 1.48393974e-01f, -1.05816357e-01f,
  3.36115435e-02f, -3.28102708e-02f, -1.21537618e-01f, 2.04251572e-01f, -4.81065996e-02f, -9.33850110e-02f, 9.53384414e-02f, 1.15733430e-01f, 2.50649691e-01f, 1.55988690e-02f,
  2.07344312e-02f, -1.62902758e-01f, -2.36186832e-02f, 2.49359578e-01f, 2.17266958e-02f, -5.32994196e-02f, -1.85616426e-02f, -1.06416522e-02f, -9.69512016e-02f, -2.63049621e-02f,
  1.38440356e-03f, -4.48621921e-02f, 7.44321719e-02f, -5.10488153e-02f, 2.55639106e-02f, -1.24717131e-01f, -6.87904507e-02f, 1.23360455e-02f, -5.87874427e-02f, -2.26539792e-03f,
  -9.02959108e-02f, -7.54275844e-02f, -2.80953459e-02f, -2.27066446e-02f, -5.31406701e-02f, -7.59193152e-02f, -5.04591726e-02f, 4.06042151e-02f, -3.36481221e-02f, 3.01123746e-02f,
  6.75784722e-02f, -5.16628362e-02f, 2.46997569e-02f, -7.86127895e-02f, -1.68279588e-01f, 1.28205016e-01f, 1.33812487e-01f, 5.30091412e-02f, -1.48345390e-02f, 5.67488596e-02f,
  -1.76603198e-01f, -6.23874702e-02f, 2.50739958e-02f, -1.66117311e-01f, 8.22577924e-02f, -9.75518674e-02f, -8.14081430e-02f, -6.28937259e-02f, 1.55864414e-02f, -2.22949143e-02f,
  -3.72535624e-02f, -9.01126638e-02f, 2.64043733e-02f, 1.73423052e-01f, -3.11108995e-02f, -1.50937170e-01f, 2.85015821e-01f, -1.57564074e-01f, -8.18065628e-02f, -1.82990730e-01f,
  2.30637472e-02f, -2.38288894e-01f, -2.77201027e-01f, 9.33046043e-02f, -1.08402528e-01f, 4.40759100e-02f, 1.24116048e-01f, -8.61499086e-02f, 3.25031504e-02f, 1.29611762e-02f,
  -7.03747272e-02f, -7.94138201e-03f, -7.00453762e-04f, 4.19951789e-03f, -7.93869719e-02f, -4.19943640e-03f, -6.08381294e-02f, 5.39588183e-03f, 3.52553837e-02f, 1.47456646e-01f,
  -2.75322944e-02f, -7.30413711e-03f, -1.37967505e-02f, -8.93241614e-02f, 1.71834212e-02f, -7.90825784e-02f, 6.07788414e-02f, 1.18964359e-01f, 2.06958503e-02f, -1.78529434e-02f,
  1.18420593e-01f, -6.58658892e-02f, 1.04010344e-01f, 1.71652026e-02f, 6.12173509e-03f, -1.13433242e-01f, 1.26969010e-01f, 1.80613697e-01f, 9.25829038e-02f, 1.08242318e-01f,
  1.56849787e-01f, -5.10809906e-02f, -8.14639404e-02f, 2.04739019e-01f, -1.73664233e-03f, 4.96967286e-02f, 2.51640528e-02f, 1.12922452e-01f, -1.05613120e-01f, 1.62362322e-01f,
  -1.06849343e-01f, -1.04774021e-01f, -1.25055417e-01f, 7.88578615e-02f, 9.59830731e-02f, -1.52414337e-01f, -7.03186691e-02f, 1.06303573e-01f, 6.06297664e-02f, -1.11806318e-01f,
  1.25735730e-01f, -9.92048830e-02f, 8.28991458e-02f, 1.73115686e-01f, -1.14984304e-01f, -2.97378786e-02f, -2.83913128e-02f, -4.21944745e-02f, 1.17469981e-01f, -1.11194495e-02f,
  1.06852338e-01f, -6.22734837e-02f, -5.28345816e-02f, 2.00029373e-01f, 6.12609694e-03f, -2.72508711e-02f, -3.89352371e-03f, 1.08182259e-01f, 7.65112936e-02f, -2.49052849e-02f,
  -7.32208695e-03f, -1.16074875e-01f, 5.94990291e-02f, -8.02752376e-02f, 1.02280110e-01f, 5.53110056e-03f, -3.96830915e-03f, 1.48109309e-02f, -1.44982701e-02f, -7.17047676e-02f,
  8.70443583e-02f, -3.43327783e-02f, 1.86589975e-02f, -1.06564745e-01f, -9.84697510e-03f, -1.10885687e-01f, -2.46263482e-02f, -1.55674955e-02f, 6.29799142e-02f, 2.44906209e-02f,
  2.23157685e-02f, -2.57650558e-02f, -9.34352726e-02f, 7.05929473e-02f, 1.40719250e-01f, -5.08696772e-02f, -9.31601301e-02f, 3.89272906e-02f, -7.84645900e-02f, -2.10656285e-01f,
  1.16814740e-01f, -1.87610447e-01f, -3.00774947e-02f, -1.15638368e-01f, -5.61219379e-02f, 2.60307372e-01f, -9.40399803e-03f, -1.40131086e-01f, -2.08865087e-02f, 5.87616041e-02f,
  -1.04989380e-01f, -2.56447513e-02f, -4.62458916e-02f, -6.56828135e-02f, 1.76199168e-01f, -3.02147446e-03f, 6.93302602e-02f, -5.19481227e-02f, -1.21564195e-02f, -6.11056276e-02f,
  -1.95327491e-01f, 6.52690306e-02f, -3.75995114e-02f, 1.73024714e-01f, 7.32383728e-02f, -1.39374539e-01f, 8.92809108e-02f, 1.41739905e-01f, 2.72547007e-02f, 6.37485832e-03f,
  3.01029105e-02f, -7.82015100e-02f, -1.03512004e-01f, 4.10937667e-02f, -7.71053275e-03f, 2.13377122e-02f, -6.52191713e-02f, 5.78192435e-02f, -7.72515386e-02f, 5.18404925e-03f,
  -1.01651987e-02f, 7.32974559e-02f, -1.57803185e-02f, 3.65344458e-04f, 3.99045348e-02f, 1.92770474e-02f, -4.72949061e-04f, -6.02191910e-02f, 4.04874533e-02f, 9.04375985e-02f,
  2.48154048e-02f, -1.29029816e-02f, -3.76951369e-03f, -1.52773514e-01f, -1.38877640e-02f, -6.10329099e-02f, 1.81699153e-02f, 3.45149240e-03f, 2.26361994e-02f, 1.07958771e-01f,
  4.15183939e-02f, -5.80310300e-02f, 9.87214893e-02f, -5.42578734e-02f, -6.15259819e-02f, 1.85734749e-01f, -3.19527946e-02f, 4.88746613e-02f, -7.99342319e-02f, -9.12254825e-02f,
  5.53570315e-02f, -8.93801227e-02f, 9.23054963e-02f, -3.32208094e-03f, 1.78551510e-01f, 6.70592673e-03f, 1.12812251e-01f, -1.15352303e-01f, -1.61730573e-02f, 4.21665795e-02f,
  -1.17529958e-01f, -7.09156245e-02f, 2.40033880e-01f, -4.89057265e-02f, 1.11929014e-01f, -2.26000920e-01f, -1.35416210e-01f, -3.29500213e-02f, 5.08129448e-02f, 5.44405282e-02f,
  -6.54485356e-03f, -6.29301369e-02f, -2.64723338e-02f, -7.28441253e-02f, -5.88389672e-02f, -1.93361705e-03f, 3.04930788e-02f, -1.52118197e-02f, 2.88786273e-03f, -1.02465078e-01f,
  2.36113742e-02f, -3.28334072e-03f, -3.10353152e-02f, -1.90650094e-02f, -1.00597948e-01f, -1.55775426e-02f, -2.88582128e-02f, -1.06340773e-01f, -9.97949541e-02f, -4.08344790e-02f,
  -9.82095376e-02f, -6.49230704e-02f, -6.52445108e-02f, -1.22984856e-01f, -1.13401793e-01f, -1.06810443e-01f, 9.68527570e-02f, -7.81538412e-02f, 1.31773889e-01f, 1.15540981e-01f,
  1.05550152e-03f, 1.46831810e-01f, 1.79564849e-01f, -5.56397811e-02f, -1.66386306e-01f, 6.30306974e-02f, 1.43756241e-01f, -1.04908533e-01f, 1.19304284e-01f, 3.85017064e-03f,
  -7.14711398e-02f, 1.34011477e-01f, -1.03777967e-01f, 7.03752413e-02f, 4.73064184e-02f, 1.69215258e-02f, 1.58336848e-01f, 3.11633870e-02f, -7.52208233e-02f, 1.92147363e-02f,
  -1.81971230e-02f, -2.25585010e-02f, -3.18144672e-02f, 2.59159625e-01f, 3.34190316e-02f, 1.31339476e-01f, -6.89555109e-02f, -3.42988037e-02f, -4.07244079e-03f, -1.42718256e-01f,
  8.57252777e-02f, 8.49399716e-02f, 1.92821457e-03f, -1.59623787e-01f, 6.99264258e-02f, -1.01347990e-01f, -3.43460031e-02f, -3.51558812e-02f, 7.69207545e-05f, -4.14580107e-03f,
  1.20832123e-01f, -1.03743054e-01f, -5.84218763e-02f, -4.09997702e-02f, 1.11757413e-01f, 2.65921839e-02f, 3.83384041e-02f, 3.73126455e-02f, 4.12583463e-02f, 1.27537660e-02f,
  4.19769548e-02f, -2.10332125e-03f, -9.97683033e-03f, -6.99308738e-02f, -2.45109759e-02f, 5.91893196e-02f, -7.95922242e-03f, -1.19320028e-01f, 8.31505749e-04f, 6.70559034e-02f,
  -6.18728772e-02f, 1.79025367e-01f, 3.96204293e-02f, 1.55790020e-02f, -1.11779356e-02f, 1.20915344e-03f, -2.68276166e-02f, -1.15651995e-01f, 3.40200812e-02f, 7.54463747e-02f,
  -9.84822661e-02f, 8.65431130e-02f, -1.40208593e-02f, -1.83710352e-01f, 1.19417958e-01f, -1.01620331e-01f, 1.23210132e-01f, 4.89489064e-02f, -4.80573028e-02f, 9.45247710e-02f,
  -1.12562627e-01f, -5.14924154e-02f, -1.78325325e-01f, 1.81766623e-03f, -5.41590042e-02f, 8.73585939e-02f, 3.10002975e-02f, -1.48034215e-01f, 1.43737331e-01f, 3.96453701e-02f,
  -1.14337996e-01f, 4.36506681e-02f, -1.63419142e-01f, 1.66950688e-01f, 1.07002929e-01f, 7.13071844e-04f, -1.08146630e-01f, -5.78882582e-02f, -2.81847399e-02f, 1.12854242e-01f,
  -7.53712207e-02f, -3.26649621e-02f, -1.03574827e-01f, -4.13964242e-02f, 9.30719152e-02f, 6.18251227e-02f, -1.21870739e-02f, -4.05984372e-02f, 8.00253525e-02f, -8.75163898e-02f,
  4.04443853e-02f, -4.34250720e-02f, -2.58607119e-02f, -4.92642447e-02f, -4.34568524e-02f, -6.23278357e-02f, -1.15401838e-02f, -4.52084802e-02f, -8.48837756e-03f, -1.05562814e-01f,
  -4.63214032e-02f, -7.07904026e-02f, 1.15769334e-01f, -4.83455509e-03f, 5.37876822e-02f, 1.54149026e-01f, 1.25468239e-01f, 1.02381431e-01f, -1.31293565e-01f, 3.09097543e-02f,
  -2.70434786e-02f, -1.74505562e-01f, -8.51994604e-02f, 1.79793745e-01f, -8.25469717e-02f, 1.31890059e-01f, 2.05383882e-01f, -1.24319285e-01f, -9.94987320e-03f, 1.43030971e-01f,
  2.43675802e-02f, 1.03678619e-02f, -1.11539081e-01f, 1.42549291e-01f, 1.19033945e-03f, -6.88699931e-02f, -1.59104228e-01f, -6.50254544e-03f, -1.51518695e-02f, 1.24952637e-01f,
  -6.89600930e-02f, 1.76515684e-01f, 1.06744647e-01f, 2.52629727e-01f, -2.45468959e-01f, -6.71244338e-02f, -3.71001586e-02f, 2.00106092e-02f, 1.17453456e-01f, -2.24015452e-02f,
  -1.09424867e-01f, -3.85678336e-02f, -2.64479741e-02f, 9.91992280e-02f, 4.00459506e-02f, 6.56426847e-02f, 2.84321122e-02f, -4.33141701e-02f, -3.04478798e-02f, 5.79121187e-02f,
  3.53985950e-02f, -3.76094319e-02f, -6.24699406e-02f, 7.20887408e-02f, -4.34508957e-02f, 4.12648208e-02f, 8.37936848e-02f, -2.68251561e-02f, 6.72833398e-02f, 1.61026865e-02f,
  1.98853612e-02f, 9.16347131e-02f, 3.67974378e-02f, -4.26662480e-03f, 8.70921239e-02f, 7.75371939e-02f, 3.43806967e-02f, -1.42657114e-02f, -3.11062355e-02f, -1.03788711e-01f,
  -9.87714529e-02f, -7.34504089e-02f, 6.90358579e-02f, -7.47929187e-03f, -1.06267177e-01f, 8.49580020e-02f, 1.40071809e-01f, 1.00037150e-01f, -3.62143777e-02f, 7.85238296e-02f,
  -1.27542317e-01f, 1.51242256e-01f, -5.86631671e-02f, 5.94734773e-02f, 1.46276895e-02f, -1.91095501e-01f, 4.97516757e-03f, 1.00088352e-02f, 1.32155657e-01f, -1.34549469e-01f,
  1.87400952e-01f, 1.04846008e-01f, 2.06771225e-01f, -1.14413433e-01f, 1.59341663e-01f, -8.74582902e-02f, -1.55482262e-01f, -2.95412634e-02f, 1.89313933e-01f, -8.74868333e-02f,
  3.28470161e-03f, -4.82507274e-02f, -1.13911606e-01f, -4.73592505e-02f, 2.29397357e-01f, 5.00668213e-02f, -8.81312564e-02f, -8.29647332e-02f, 8.03909674e-02f, 3.31537798e-02f,
  4.71431166e-02f, 1.45691549e-02f, -9.02434066e-02f, -7.79675040e-03f, 1.02612441e-02f, -2.55446769e-02f, -1.29070386e-01f, 1.20958321e-01f, -4.15112451e-02f, -2.35077962e-02f,
  1.89865097e-01f, 9.77747701e-03f, -1.52272796e-02f, -4.31000926e-02f, 4.00650799e-02f, 8.26016143e-02f, -3.43108363e-02f, -7.73855895e-02f, -5.73619232e-02f, 1.10704169e-01f,
  7.50880539e-02f, -8.25804099e-02f, 2.40697172e-02f, -4.57517691e-02f, -8.92777275e-03f, -1.64949819e-01f, -1.55817410e-02f, -4.67073172e-03f, 1.09308921e-01f, 2.39274930e-02f,
  2.10708201e-01f, 4.38113231e-03f, -1.57555491e-01f, 7.41010532e-02f, -1.58708662e-01f, -3.06287850e-03f, -1.22054763e-01f, -1.48866296e-01f, -3.57384719e-02f, -6.67999089e-02f,
  -1.49491891e-01f, 4.80203629e-02f, 1.19896293e-01f, 4.76549333e-03f, 3.79119515e-02f, 2.28468757e-02f, 2.61417240e-01f, -1.52970925e-01f, 7.07443506e-02f, -1.71488315e-01f,
  -7.29831085e-02f, -9.21690241e-02f, 5.99475428e-02f, -9.99546051e-02f, -1.76075086e-01f, -1.13296278e-01f, -1.44967467e-01f, 2.73524281e-02f, 1.57755613e-01f, -1.90729108e-02f,
  -1.76896229e-01f, -1.51272397e-02f, -1.57762300e-02f, -8.25324270e-04f, -2.71596089e-02f, -1.44720599e-01f, -1.24246947e-01f, -1.22831918e-01f, -6.63097948e-02f, 3.49265803e-03f,
  -9.60335508e-02f, 4.27119387e-03f, -6.98153749e-02f, 6.01908900e-02f, -3.80389243e-02f, 8.57329369e-03f, -5.68313897e-02f, -6.38567731e-02f, -9.86463428e-02f, -1.45588797e-02f,
  -1.21018685e-01f, 7.01129213e-02f, -2.28358321e-02f, 2.39915047e-02f, -2.48700883e-02f, 5.83019629e-02f, -5.58621809e-02f, -1.11651935e-01f, -1.43942714e-01f, 2.41363980e-02f,
  5.28070964e-02f, 1.79352015e-02f, -5.75554855e-02f, 1.93794921e-01f, -9.75669548e-02f, -6.64442256e-02f, 1.78602412e-01f, -1.67314470e-01f, -1.49836525e-01f, 1.28648505e-01f,
  1.69033453e-01f, 1.32122621e-01f, 1.05204381e-01f, 2.86765080e-02f, 1.79298535e-01f, -6.87784180e-02f, -6.34296164e-02f, 3.71085852e-02f, 1.11696139e-01f, 4.59876582e-02f,
  -1.21395022e-01f, 7.33233290e-03f, -1.01869039e-01f, 1.09694250e-01f, -1.18646123e-01f, -3.82052809e-02f, 1.02926724e-01f, 4.02305238e-02f, 1.50507912e-02f, -5.27066886e-02f,
  -6.54558912e-02f, -1.90600932e-01f, -1.52629972e-01f, 1.35210957e-02f, 8.46967176e-02f, -1.04177728e-01f, -1.09748848e-01f, -1.09373815e-02f, -1.24646397e-02f, -4.91976328e-02f,
  7.01338947e-02f, 3.99514772e-02f, 4.40744832e-02f, -1.61373481e-01f, 2.77142599e-03f, -1.28574995e-03f, -2.58079655e-02f, 6.11209609e-02f, -3.85507867e-02f, -1.97043326e-02f,
  -1.75383799e-02f, -5.65511547e-02f, 3.13095003e-02f, 3.25856656e-02f, -3.93118113e-02f, -1.79805439e-02f, 4.40274831e-03f, -2.27669869e-02f, 9.90459770e-02f, 4.14983034e-02f,
  1.00481529e-02f, -4.45910580e-02f, 9.59124118e-02f, 2.17105404e-01f, 6.02033883e-02f, 1.40189677e-01f, 1.22162580e-01f, -6.73111081e-02f, -1.66831195e-01f, 1.47736788e-01f,
  1.44399792e-01f, -4.98933047e-02f, 3.95467170e-02f, 9.20876339e-02f, -3.68079320e-02f, 1.73824385e-01f, 5.83886318e-02f, 2.48951800e-02f, -9.96921794e-04f, -2.43543321e-03f,
  -6.33247197e-02f, -4.75053750e-02f, -1.17146887e-01f, 8.04851428e-02f, -5.36258779e-02f, 3.56036387e-02f, 1.11940190e-01f, 4.20746878e-02f, 9.39824358e-02f, 2.16766760e-01f,
  -8.26067924e-02f, -8.12105089e-03f, 2.07972415e-02f, -6.14368059e-02f, 1.53493926e-01f, -6.69295862e-02f, 5.57505665e-03f, -7.31484145e-02f, 7.15359822e-02f, 1.20434791e-01f,
  8.19649845e-02f, -4.52188291e-02f, 5.34692667e-02f, 8.15363303e-02f, 3.26294266e-02f, 1.41234875e-01f, 1.14331558e-01f, 7.01785535e-02f, -3.02248392e-02f, 1.62564620e-01f,
  -4.00501676e-02f, 3.93195748e-02f, 3.25196725e-03f, 2.58108471e-02f, 5.23417071e-02f, 5.38298264e-02f, 2.30944231e-02f, 4.70708646e-02f, 9.92518812e-02f, -3.42197274e-03f,
  6.71960860e-02f, 5.87229915e-02f, 7.93753378e-03f, -4.07604687e-02f, -2.28928197e-02f, 1.04273250e-02f, -9.84362960e-02f, 1.07268885e-01f, 8.18726867e-02f, -4.47263494e-02f,
  -1.25404775e-01f, 2.47027036e-02f, -1.62757635e-02f, -4.01671678e-02f, 1.48606569e-01f, -5.49919307e-02f, 7.23937154e-02f, 1.88504264e-01f, -1.20494403e-01f, 1.13605134e-01f,
  -5.51893227e-02f, 7.99443200e-02f, 1.86425120e-01f, -5.00821322e-02f, 1.28421381e-01f, 1.64637953e-01f, 2.15945989e-01f, -1.78994969e-01f, 3.60058174e-02f, 2.20549647e-02f,
  -2.42368177e-01f, 2.43391693e-01f, -1.02340885e-01f, -3.21731940e-02f, 4.54139942e-03f, 8.65200013e-02f, 2.72280574e-01f, -1.34017333e-01f, 8.37400369e-03f, 3.85880172e-02f,
  5.44874109e-02f, 1.36922091e-01f, 2.30909605e-02f, -1.65431038e-01f, 1.07358910e-01f, 4.25166935e-02f, 1.65395856e-01f, 4.37076762e-02f, -3.68305892e-02f, -1.19351577e-02f,
  2.31381655e-02f, 8.24216381e-02f, -4.33248654e-02f, 1.25250444e-01f, 4.07192111e-02f, 8.09132122e-03f, -2.01110486e-02f, 9.46973786e-02f, 1.01748202e-02f, 8.83542374e-02f,
  -9.14664045e-02f, 5.84599078e-02f, 1.32456645e-02f, 8.70096460e-02f, 8.32921267e-02f, -4.97411452e-02f, 3.18429759e-03f, 8.49864036e-02f, -1.47946421e-02f, -4.06729840e-02f,
  -6.35983869e-02f, -1.37858480e-01f, -5.57012111e-02f, -1.38104185e-01f, -1.32213309e-01f, 1.84530407e-01f, 1.83273494e-01f, -2.20611230e-01f, -7.23408826e-04f, 2.15400219e-01f,
  -2.06721604e-01f, 8.42936635e-02f, -6.17681369e-02f, -4.68447059e-02f, 1.73607245e-02f, -1.42656103e-01f, -4.50293571e-02f, 1.60157815e-01f, -4.95445207e-02f, -6.34617060e-02f,
  1.39999270e-01f, -4.95847389e-02f, 4.82128672e-02f, 8.70354399e-02f, -9.84479412e-02f, -1.27778232e-01f, 4.80801761e-02f, -2.42373012e-02f, 4.11969870e-02f, 4.67301421e-02f,
  2.94550568e-01f, 2.46197749e-02f, 1.60111450e-02f, -6.74557909e-02f, -4.37454283e-02f, 1.50269777e-01f, -1.99039608e-01f, -1.22221582e-01f, 7.73046985e-02f, 9.29070562e-02f,
  1.66375954e-02f, 2.46339254e-02f, 6.59468397e-03f, 3.52954790e-02f, -4.66467440e-02f, 4.83763777e-03f, 1.73512045e-02f, 1.00450143e-02f, 5.49301542e-02f, 6.69529513e-02f,
  2.01864824e-01f, -2.68715899e-02f, 7.27145150e-02f, 8.87982175e-02f, 2.71254983e-02f, -7.38620237e-02f, 5.31929806e-02f, -4.00127610e-03f, -3.78008485e-02f, 5.50827831e-02f,
  1.40800029e-02f, -3.64652909e-02f, -4.07183990e-02f, 7.24896565e-02f, -1.30428538e-01f, -1.85842052e-01f, 7.97177702e-02f, -1.72489598e-01f, -7.83919096e-02f, -2.71840002e-02f,
  1.72193721e-01f, 1.39954850e-01f, -4.15147208e-02f, -1.12087876e-01f, -5.10208756e-02f, 4.51896004e-02f, -5.95896505e-02f, -5.87276407e-02f, 1.34569854e-01f, -1.62705947e-02f,
  2.48320494e-02f, -1.80971667e-01f, 1.71801239e-01f, -1.37746949e-02f, 9.56165269e-02f, -6.72249347e-02f, 2.07093209e-01f, -4.71993387e-02f, 7.49128358e-03f, -2.41418317e-01f,
  -9.61717740e-02f, -1.82848454e-01f, 1.06155716e-01f, -1.15964539e-01f, -7.38695487e-02f, -8.28302205e-02f, -1.56917647e-01f, 1.53195992e-01f, 2.10125763e-02f, 5.07436953e-02f,
  -8.11151639e-02f, 9.17189494e-02f, 6.34404495e-02f, 6.24688016e-03f, 6.44858479e-02f, -5.20634018e-02f, -2.34677028e-02f, 7.19300807e-02f, 1.25034768e-02f, -5.30989990e-02f,
  9.59942117e-02f, -7.09253103e-02f, 4.14871313e-02f, 1.48163196e-02f, -1.29242428e-03f, 1.34228170e-01f, -5.12938909e-02f, 9.14334655e-02f, -7.87065178e-02f, -5.77414073e-02f,
  2.33465750e-02f, 6.56110346e-02f, 1.04848906e-01f, 5.15588708e-02f, 5.62008563e-03f, 3.95544656e-02f, -9.05396417e-02f, 1.19544379e-01f, -1.68006867e-01f, -5.19702956e-03f,
  1.88042969e-01f, -1.02891289e-01f, -2.21743420e-01f, 1.08058706e-01f, -6.38575107e-02f, -6.23995103e-02f, 1.72490418e-01f, -1.60444565e-02f, -1.30025014e-01f, 1.43060595e-01f,
  1.12898871e-01f, 4.50246520e-02f, 8.38044584e-02f, 6.62489086e-02f, 1.96433976e-01f, 1.65568050e-02f, -9.39908773e-02f, 1.53500363e-01f, 1.42629415e-01f, -1.47914246e-01f,
  -3.22782733e-02f, 1.18945390e-01f, -1.34486988e-01f, 9.95305032e-02f, 2.35657785e-02f, 6.99270889e-02f, 1.39541820e-01f, 7.82520771e-02f, 2.80163914e-01f, 4.38208058e-02f,
  9.98364091e-02f, -1.92782044e-01f, -8.97818729e-02f, 2.13041887e-01f, 5.68651594e-02f, -1.51383653e-01f, -1.06238000e-01f, 1.18419118e-01f, 6.52306527e-02f, 6.86036870e-02f,
  -6.00169227e-02f, -3.82993333e-02f, -1.57371983e-01f, -1.63611427e-01f, -1.96776423e-03f, -1.53243989e-01f, 5.76085271e-03f, -3.20561752e-02f, 2.54166499e-02f, -1.35179423e-02f,
  3.89595069e-02f, 6.66636880e-03f, -3.55101302e-02f, -6.91543743e-02f, -6.22834302e-02f, 7.93698281e-02f, 8.79163593e-02f, -1.27072498e-01f, 1.01238526e-01f, 7.77266175e-02f,
  1.84141159e-01f, 8.62868503e-02f, -1.28808066e-01f, 4.20620330e-02f, -2.26431116e-02f, -1.97936893e-02f, 7.85559490e-02f, 2.14287460e-01f, -1.72456671e-02f, 5.05065545e-02f,
  -1.56445697e-01f, -1.35778517e-01f, -1.82516336e-01f, -6.82415143e-02f, 1.51913941e-01f, -4.61852886e-02f, 9.80634913e-02f, -3.66558367e-03f, 1.08429110e-02f, -1.18381470e-01f,
  -9.59075391e-02f, -8.79750997e-02f, 2.82506999e-02f, 7.20465630e-02f, 2.37503424e-02f, -1.59764990e-01f, 2.25566491e-01f, -2.14824140e-01f, 1.02909826e-01f, 9.86132119e-03f,
  5.57113439e-02f, -2.03293532e-01f, -2.40719035e-01f, 1.11211009e-01f, -1.50333107e-01f, 1.58171132e-02f, 8.30932111e-02f, 5.30711636e-02f, -5.25303818e-02f, 5.87395541e-02f
};

// L2_fan_Wp_bar (Shape: 14 x 64)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -2.37819478e-02f, 1.15832388e-01f, -6.06182218e-02f, -6.13842085e-02f, 2.18808517e-01f, -2.34311260e-02f, 2.98635960e-01f, 9.48971584e-02f, 1.41467586e-01f, -1.78605132e-02f,
  -1.14135996e-01f, 4.66518849e-02f, -1.85563952e-01f, -5.99845722e-02f, -1.86617032e-01f, 1.26068279e-01f, -2.98270467e-03f, 1.59802720e-01f, 3.33555005e-02f, -1.86908707e-01f,
  4.37555090e-02f, 7.99453408e-02f, -1.30705293e-02f, 1.93314493e-01f, -3.76127139e-02f, -1.21525594e-03f, 3.23249757e-01f, 1.09895751e-01f, -2.76625663e-01f, 1.22932412e-01f,
  -1.48386300e-01f, -1.20200098e-01f, 3.48493941e-02f, 1.56498238e-01f, -5.81711531e-02f, 3.11681181e-01f, 2.20154569e-01f, -1.72064751e-01f, 1.45968392e-01f, 8.05579349e-02f,
  1.73266500e-03f, -3.32851022e-01f, -1.22181483e-01f, 2.53781706e-01f, -2.12418914e-01f, -2.91624188e-01f, 2.01265831e-02f, 2.77975529e-01f, -4.67801578e-02f, -1.47547543e-01f,
  3.97381514e-01f, 2.13487446e-02f, -2.23248959e-01f, 6.70974627e-02f, 1.83604658e-01f, -6.90988451e-02f, -3.60644124e-02f, 4.39271569e-01f, -4.78163324e-02f, -7.07112392e-03f,
  1.82839230e-01f, -1.87204227e-01f, 2.65381485e-01f, 3.16301793e-01f, 1.77973777e-01f, 1.06215544e-01f, 7.68584684e-02f, -6.71128035e-02f, 5.68508022e-02f, 1.36420831e-01f,
  1.12405486e-01f, -3.67645733e-02f, 6.41111135e-02f, -1.11670606e-02f, -3.02687250e-02f, 2.93916818e-02f, 4.34628949e-02f, 1.47256300e-01f, -5.20482734e-02f, 1.47465244e-01f,
  6.28434680e-03f, 2.69602001e-01f, 9.30495486e-02f, -4.12697531e-02f, 8.79559815e-02f, 2.20732361e-01f, 1.07495397e-01f, 7.24024698e-02f, -2.44911276e-02f, -6.95173144e-02f,
  2.03917697e-02f, -8.19144025e-02f, -8.02073851e-02f, -7.77667537e-02f, -9.15429071e-02f, 7.60964155e-02f, 2.05547810e-01f, -1.47434935e-01f, -1.30188450e-01f, 2.47246787e-01f,
  1.59532651e-02f, -9.38165002e-03f, -8.19885358e-03f, -1.82343692e-01f, -7.38020390e-02f, -2.20983490e-01f, -1.47670254e-01f, 1.91095442e-01f, -1.45611707e-02f, -7.56698102e-02f,
  1.95964307e-01f, 6.65067136e-02f, 1.11715369e-01f, -2.25302592e-01f, 2.52405256e-01f, -8.01213235e-02f, -3.20291132e-01f, -1.03173897e-01f, 2.36219913e-01f, -1.32780716e-01f,
  1.02062896e-01f, 2.05266476e-01f, -1.42126977e-01f, 2.74859574e-02f, 3.08799446e-01f, 2.57419288e-01f, -1.91438556e-01f, -7.65532255e-02f, -1.00691922e-01f, -6.18442334e-02f,
  -1.16584286e-01f, -8.94782692e-02f, -1.27812415e-01f, 5.80101646e-03f, -1.10457510e-01f, -1.59954652e-01f, -9.42799076e-02f, 3.69897969e-02f, 1.65550020e-02f, -5.46586849e-02f,
  1.57424472e-02f, -1.45254716e-01f, 5.41579314e-02f, -1.14349857e-01f, 1.41758829e-01f, 3.14427284e-03f, 9.82245430e-03f, -1.56565219e-01f, 1.33050442e-01f, -5.66504411e-02f,
  1.36402875e-01f, 8.94181207e-02f, 1.13013700e-01f, -1.06154516e-01f, 3.90411988e-02f, 1.95785373e-01f, -5.73850609e-02f, 2.10740998e-01f, 1.95955575e-01f, 1.60426851e-02f,
  -1.57937944e-01f, 3.40453744e-01f, -1.91733073e-02f, -5.12785465e-02f, 1.24990404e-01f, 1.08854361e-01f, -1.02924600e-01f, 2.97558695e-01f, -4.94331084e-02f, -1.17373824e-01f,
  2.90329587e-02f, -1.03189617e-01f, 2.31512517e-01f, -2.92509139e-01f, -2.20105480e-02f, 3.42996687e-01f, 1.94129840e-01f, -2.58377284e-01f, 3.14274013e-01f, -5.40575087e-02f,
  1.13498688e-01f, 3.36050600e-01f, 1.07814603e-01f, -2.57609189e-01f, -8.19053128e-02f, -5.11724176e-03f, -1.52723759e-01f, 2.22844824e-01f, 4.08093721e-01f, -2.37507895e-01f,
  -3.31302965e-03f, 1.37809724e-01f, 3.00512612e-01f, 2.41191313e-01f, 2.50336796e-01f, 1.87897518e-01f, 1.17703564e-01f, 2.14246526e-01f, 1.94994703e-01f, 1.45244807e-01f,
  9.38909277e-02f, 1.05594330e-01f, 7.53594488e-02f, 1.17465686e-02f, -3.83197144e-02f, 5.78759946e-02f, 4.90848459e-02f, 6.92572221e-02f, 8.50321725e-02f, 1.41043618e-01f,
  1.35508612e-01f, -1.46499753e-01f, 1.80872425e-01f, 6.16505928e-02f, -2.40036715e-02f, -5.44537269e-02f, 1.96752608e-01f, -2.42478311e-01f, 6.52070045e-02f, -1.75732803e-02f,
  -1.56581357e-01f, -1.60077199e-01f, 5.15500680e-02f, 2.70188272e-01f, 4.95093279e-02f, -1.22285746e-01f, 1.93619847e-01f, -2.38611009e-02f, 2.50752747e-01f, 2.18199030e-01f,
  -3.17522675e-01f, -4.46957685e-02f, -1.93429351e-01f, -4.49913032e-02f, 2.07605079e-01f, -1.24014631e-01f, 3.09790194e-01f, 1.03718229e-02f, 4.14357334e-01f, -1.10700488e-01f,
  6.60571903e-02f, -2.84350008e-01f, 2.45234713e-01f, 1.67083904e-01f, -4.37033236e-01f, 1.71672716e-03f, 5.52150726e-01f, -6.99985996e-02f, 2.84902841e-01f, -1.01001851e-01f,
  -3.52661967e-01f, 4.96303022e-01f, 2.58967400e-01f, 1.68685392e-01f, 1.89566433e-01f, -2.85996199e-01f, 3.02802380e-02f, 1.95175670e-02f, 5.06452285e-02f, -3.70271727e-02f,
  8.71561393e-02f, 7.55255250e-03f, 6.70806989e-02f, -9.12985727e-02f, 1.25044614e-01f, -2.63885818e-02f, 5.67865483e-02f, 1.06338374e-01f, 1.25957534e-01f, -7.40472898e-02f,
  8.11812058e-02f, 1.46148512e-02f, 1.10243015e-01f, 1.50578450e-02f, 1.15257531e-01f, -8.97713080e-02f, 3.85742597e-02f, 1.84522513e-02f, 8.50282907e-02f, 7.22165406e-03f,
  2.35482045e-02f, 7.82293379e-02f, 4.80136126e-02f, -8.30963030e-02f, -1.21624283e-01f, 5.97518869e-02f, 1.04599856e-01f, -1.28219455e-01f, 7.26476731e-03f, 3.25245678e-01f,
  -1.37592003e-01f, -7.67373294e-02f, 1.62868381e-01f, -7.91360959e-02f, -4.82481830e-02f, -4.43445519e-02f, 6.36210591e-02f, -5.82398325e-02f, -7.14925975e-02f, -1.40327767e-01f,
  7.81826377e-02f, -2.42980972e-01f, -4.15713573e-03f, 1.92055970e-01f, 1.13213643e-01f, -2.55578160e-01f, 4.28124219e-01f, -1.48182690e-01f, -5.87232746e-02f, 1.03402033e-01f,
  3.02270561e-01f, -1.77971765e-01f, -2.93509305e-01f, 3.46060276e-01f, -7.26806447e-02f, 3.31744999e-01f, 2.44913995e-01f, -1.93592727e-01f, 2.17790127e-01f, 2.54343450e-01f,
  5.81430569e-02f, 1.00964978e-01f, 1.13555856e-01f, -1.06089804e-02f, 1.76917955e-01f, 2.13895798e-01f, 2.01859936e-01f, 1.22200757e-01f, 1.44784048e-01f, 5.88639155e-02f,
  -3.52742597e-02f, 1.97132900e-01f, 4.62093018e-02f, -5.67844696e-02f, -5.86657263e-02f, 2.43757069e-01f, 3.72702964e-02f, 2.67654926e-01f, 1.02156334e-01f, -1.85551662e-02f,
  9.43688229e-02f, 2.53676325e-01f, 2.10567504e-01f, 7.34323263e-02f, -2.87125204e-02f, 2.69326773e-02f, 1.44371986e-01f, -1.50824885e-03f, 1.09572940e-01f, -6.65036738e-02f,
  -1.54564038e-01f, -3.15869838e-01f, 1.92061707e-01f, 1.94787055e-01f, -7.92845115e-02f, 3.88892502e-01f, -1.48188584e-02f, 1.94080934e-01f, -2.60053068e-01f, 2.79957056e-01f,
  9.11789481e-03f, -2.72613466e-01f, -1.89129651e-01f, 2.90829629e-01f, 1.59095868e-01f, -1.31404072e-01f, -4.45602909e-02f, 4.97575887e-02f, 3.75347555e-01f, -9.81483981e-03f,
  -3.53458151e-02f, 7.49282092e-02f, 4.84372117e-02f, 2.31167063e-01f, -4.95610014e-02f, 1.69807792e-01f, 3.89941365e-01f, -2.71818042e-01f, 2.98048615e-01f, -7.09441230e-02f,
  1.75809190e-01f, 2.38050625e-01f, -1.25302851e-01f, 2.10573211e-01f, -5.29742092e-02f, -6.67235777e-02f, 4.54108715e-02f, -5.12029864e-02f, 1.99216083e-01f, 1.82314850e-02f,
  2.73295432e-01f, 4.54880390e-03f, 1.16028674e-01f, -1.68202780e-02f, -7.06680790e-02f, 2.83599682e-02f, -2.51578361e-01f, 3.20299529e-02f, 1.88965946e-02f, 3.16136405e-02f,
  -1.06115296e-01f, 1.44128338e-01f, 7.38288015e-02f, -1.59404129e-01f, -1.06552721e-03f, -9.33570564e-02f, 6.22217916e-02f, 2.05909777e-02f, 5.98099008e-02f, -4.58193608e-02f,
  2.66807526e-01f, 4.53881502e-01f, -8.87424499e-02f, 3.01128715e-01f, 7.99673125e-02f, -1.35352582e-01f, -3.44040632e-01f, 6.78968132e-02f, 1.34857535e-01f, 8.49082619e-02f,
  4.76370245e-01f, -2.33865287e-02f, -3.33535299e-02f, 1.52093530e-01f, -2.76343912e-01f, 1.91786382e-02f, -5.33195073e-03f, 1.72142729e-01f, -8.47370401e-02f, 5.74899465e-02f,
  -1.88691139e-01f, 1.82346459e-02f, -2.43126169e-01f, -2.88753826e-02f, 2.33912945e-01f, 4.82529968e-01f, 1.46691456e-01f, 3.75733286e-01f, -2.02501908e-01f, 2.49690056e-01f,
  5.57054952e-02f, 2.61992306e-01f, 3.19223315e-01f, 7.45837390e-02f, 5.45119271e-02f, -1.15964100e-01f, 3.58040154e-01f, 2.83978552e-01f, -7.04986453e-02f, 1.24230916e-02f,
  8.97238776e-02f, 1.78449154e-02f, 3.33955176e-02f, 6.67255968e-02f, -7.94449300e-02f, 8.26714933e-02f, 1.22675091e-01f, 6.74401084e-03f, 4.26398814e-02f, 3.15827690e-02f,
  3.44283320e-02f, -1.31742526e-02f, 1.89698040e-02f, -6.82851905e-03f, -6.72812993e-03f, -7.07980320e-02f, 3.34165767e-02f, 9.15227085e-02f, 6.52280152e-02f, -4.56733219e-02f,
  9.33778659e-02f, 1.18044605e-02f, 6.59175636e-03f, 1.56546384e-01f, 1.22943791e-02f, 6.06846660e-02f, 1.13835350e-01f, 3.78294997e-02f, 4.87243757e-02f, -2.81365126e-01f,
  -4.86930422e-02f, 6.30763620e-02f, 3.08221299e-02f, -1.00646608e-01f, -5.49040698e-02f, -3.56108099e-02f, -1.02557369e-01f, 7.69902766e-02f, -2.03618277e-02f, 1.42416492e-01f,
  -5.27944230e-02f, 4.40367684e-03f, -4.39734124e-02f, 1.41675711e-01f, -3.01568478e-01f, -1.07385494e-01f, -8.77806768e-02f, 2.40787297e-01f, -1.90054044e-01f, 1.05254270e-01f,
  4.61499512e-01f, 2.75919437e-01f, -2.30592057e-01f, 2.98964471e-01f, -1.78121682e-02f, -8.86590183e-02f, 4.24511015e-01f, 1.27689809e-01f, -9.01457518e-02f, -4.44320440e-02f,
  -1.14057539e-02f, 1.81544140e-01f, 3.79239060e-02f, -5.37149832e-02f, 1.67350367e-01f, 1.28659353e-01f, -1.23693809e-01f, 1.14001758e-01f, -1.60133615e-01f, 2.99518742e-02f,
  -6.53792080e-03f, 2.58677065e-01f, 5.31910025e-02f, 5.51289022e-02f, 2.91197062e-01f, -7.88481832e-02f, 2.04349011e-01f, 9.02258093e-04f, 1.92339361e-01f, 1.95749756e-02f,
  1.54167131e-01f, -1.69895515e-02f, 1.03174448e-01f, -6.96708485e-02f, 1.17062986e-01f, -1.68468375e-02f, 1.02724321e-01f, 5.80585971e-02f, 9.61964875e-02f, -3.99993509e-02f,
  2.73836792e-01f, 8.91331863e-03f, 7.94522688e-02f, -1.84718445e-01f, 1.90624982e-01f, 1.45249143e-01f, -1.74144477e-01f, 1.82702288e-01f, -1.49949774e-01f, 1.00957319e-01f,
  -3.61276627e-01f, 1.22883752e-01f, -5.43134920e-02f, -1.11984842e-01f, -2.95392573e-01f, 1.69668734e-01f, 3.94406289e-01f, -4.02774476e-02f, -1.43696606e-01f, -2.55738813e-02f,
  3.90345812e-01f, -7.39414766e-02f, -7.20538870e-02f, -2.85902590e-01f, 2.73045003e-01f, 3.44594568e-01f, -1.86098516e-01f, 1.04947336e-01f, 1.76795453e-01f, -9.22859013e-02f,
  2.60851026e-01f, 3.55167478e-01f, 3.66389543e-01f, 9.84155908e-02f, -4.01411027e-01f, 3.83235514e-01f, 1.48745835e-01f, -5.59125543e-02f, 1.50983796e-01f, 2.89312810e-01f,
  1.67512566e-01f, 3.79737429e-02f, -1.72518224e-01f, 2.46453568e-01f, 8.60997066e-02f, 4.32859844e-04f, 1.54400125e-01f, 6.72739595e-02f, 2.38462731e-01f, -2.76412684e-02f,
  6.55104667e-02f, 1.09145038e-01f, 1.83237176e-02f, -3.16206723e-01f, 1.69538334e-01f, 1.32124871e-01f, 7.07211792e-02f, -1.54143840e-01f, -8.10087100e-02f, -2.64233295e-02f,
  1.06874220e-02f, 2.61543363e-01f, -2.03887140e-03f, -2.57512838e-01f, -2.80858260e-02f, -2.03098834e-01f, 3.74809504e-02f, -2.78283339e-02f, -6.44607246e-02f, -1.49402037e-01f,
  2.37206891e-02f, -2.48241663e-01f, 1.38273224e-01f, -2.48963252e-01f, -3.26509923e-02f, -3.24938864e-01f, -4.11743484e-02f, 3.81195277e-01f, -3.78262289e-02f, -2.04950422e-01f,
  5.85697629e-02f, 2.82604247e-01f, -1.06433198e-01f, -3.48383367e-01f, -1.66751206e-01f, 2.27583781e-01f, -1.29684005e-02f, -4.59012091e-02f, 3.07821959e-01f, -1.04930744e-01f,
  2.18751598e-02f, 7.05339313e-02f, -2.40903616e-01f, 3.49971235e-01f, 8.68594050e-02f, 5.41793346e-01f, 1.62576721e-03f, 4.42606164e-03f, 1.79196611e-01f, 1.23539202e-01f,
  3.39415371e-01f, 3.18102203e-02f, 1.86897665e-01f, 2.78957754e-01f, 5.37997298e-02f, 1.12106927e-01f, -4.10879515e-02f, 2.21365973e-01f, 6.11016806e-03f, 1.48412272e-01f,
  2.28736699e-01f, 9.52307582e-02f, 2.30205104e-01f, 1.65945843e-01f, 1.00549340e-01f, 1.25903308e-01f, 8.16064999e-02f, 3.82376537e-02f, 1.98386654e-01f, 1.82108060e-01f,
  -1.63131747e-02f, -6.20790608e-02f, 4.23656870e-03f, -8.54593609e-03f, -1.46676823e-01f, 1.26214340e-01f, 6.68498576e-02f, -4.04831648e-01f, 3.41389631e-03f, -1.65749505e-01f,
  7.48418123e-02f, 4.20899689e-02f, 2.59913772e-01f, -2.63345122e-01f, -1.58319414e-01f, -2.86756735e-02f, -1.11528642e-01f, -2.35542729e-01f, -8.70238096e-02f, -5.34178734e-01f,
  -1.38740480e-01f, 1.92942768e-01f, -1.43110573e-01f, 4.91029099e-02f, -2.82994248e-02f, 2.78979868e-01f, 6.77850619e-02f, -3.13016981e-01f, -9.62702259e-02f, 1.68818235e-01f,
  1.62164308e-02f, -2.68476278e-01f, 1.95194736e-01f, -1.57830581e-01f, 2.74809003e-01f, 2.26741612e-01f, -1.28060609e-01f, 2.49024540e-01f, 2.22200938e-02f, 4.10592586e-01f,
  1.13400586e-01f, 1.91692069e-01f, -1.23935081e-01f, -7.79261142e-02f, -8.01702142e-02f, 3.49386632e-02f, -5.72455227e-02f, 1.05522890e-02f, -2.04963181e-02f, -3.91653255e-02f,
  2.43828520e-02f, -4.72026803e-02f, 1.34167457e-02f, -1.32511547e-02f, -2.83515058e-03f, -1.95081141e-02f, -3.68616097e-02f, 9.32423398e-02f, -7.59694055e-02f, 1.51023328e-01f,
  -9.79042128e-02f, 1.79829538e-01f, 1.08892219e-02f, 9.65671912e-02f, 3.07659935e-02f, 2.00033918e-01f, 2.38086089e-01f, 1.83725402e-01f, 9.12180543e-02f, 1.15533024e-01f,
  -2.28715837e-01f, -4.87733521e-02f, -2.25265920e-02f, -1.25502408e-01f, -3.05305272e-01f, 1.74107894e-01f, 1.48826718e-01f, -1.62551001e-01f, -1.93762537e-02f, 2.78874487e-01f,
  -3.05772305e-01f, 4.25156243e-02f, 1.59580722e-01f, 9.99719799e-02f, 1.52516618e-01f, -2.75709242e-01f, 6.15376327e-03f, 2.65137494e-01f, -1.50695190e-01f, -1.71934173e-01f,
  4.15832140e-02f, 1.05017088e-01f, 2.17846513e-01f, -8.99564326e-02f, -1.34128127e-02f, 1.81307241e-01f, 5.01923710e-02f, 2.24627912e-01f, 1.05056524e-01f, 2.39224490e-02f,
  5.20541310e-01f, 2.33435601e-01f, 9.87346321e-02f, -2.28385642e-01f, 2.09018439e-01f, 5.57764590e-01f, -4.74184193e-02f, 2.11436048e-01f, 6.45423606e-02f, -7.94591615e-05f,
  1.15674451e-01f, -1.33910924e-02f, 2.64859721e-02f, 1.38200700e-01f, -1.94314141e-02f, -2.83626840e-02f, 8.02925415e-03f, -2.61088973e-03f, -2.26375069e-02f, -3.24008390e-02f,
  -1.40326172e-01f, 2.91982014e-02f, -3.92098241e-02f, -6.27944544e-02f, 2.85489783e-02f, -7.14779869e-02f, 1.67193655e-02f, -1.46614043e-02f, 1.40324950e-01f, -9.00306739e-03f,
  -2.20994977e-03f, -4.82519120e-02f, 2.05532297e-01f, -8.53695944e-02f, 2.03685975e-03f, 2.37421840e-01f, -4.38106619e-03f, 3.80542986e-02f, 1.00209370e-01f, 8.83512273e-02f,
  -2.82470286e-01f, 2.26432066e-02f, 3.15221667e-01f, -2.28548855e-01f, 1.89986601e-01f, 2.94551820e-01f, -2.10750803e-01f, 3.46332252e-01f, -1.25840038e-01f, 2.00377792e-01f,
  2.75126427e-01f, -2.30485961e-01f, 2.87554592e-01f, 1.06904551e-01f, 1.71740159e-01f, -4.99094352e-02f, -1.55876592e-01f, 5.47701530e-02f, 2.71735284e-02f, 5.69593787e-01f,
  1.30643636e-01f, 3.67411673e-01f, 3.02469701e-01f, 1.68511316e-01f, 2.47302994e-01f, -1.74723104e-01f, 1.79148242e-01f, 3.05454820e-01f, 9.04292688e-02f, 1.08470581e-01f,
  3.54365438e-01f, -9.22370851e-02f, -7.85140023e-02f, -4.53936197e-02f, 4.83138114e-02f, 7.90949538e-03f, -8.54912549e-02f, -1.00056969e-01f, -6.56969100e-02f, 1.49490565e-01f,
  1.04964368e-01f, -3.56558338e-02f, 1.07594263e-02f, 9.44245830e-02f, 2.01743498e-01f, 2.16339037e-01f, 1.59338266e-01f, 9.67627391e-02f, 2.70933774e-03f, -4.37610336e-02f,
  -1.64950546e-02f, 3.61642480e-01f, -4.35908651e-03f, 3.01020257e-02f, 3.53300609e-02f, 1.68380633e-01f, -1.72153383e-01f, 3.15131724e-01f, -2.99994648e-01f, -1.16360024e-01f,
  3.44290018e-01f, -2.38648579e-01f, -3.79383594e-01f, -3.21791992e-02f, 1.56758234e-01f, -2.51493901e-01f, -1.27991378e-01f, 1.45463601e-01f, -5.14088511e-01f, 7.58319162e-03f,
  3.53069901e-01f, -1.92857310e-01f, 3.79143596e-01f, -1.24693267e-01f, -8.05573538e-02f, 1.66787162e-01f, -4.36826795e-01f, 8.54902491e-02f, -1.91339388e-01f, -3.94499898e-02f,
  -1.51760411e-02f, 2.73596764e-01f, -1.50186121e-01f, -1.88152954e-01f, 2.94335634e-01f, -8.83274898e-03f, -3.65771018e-02f, 2.93515056e-01f, 2.28937224e-01f, 4.66725528e-01f,
  3.00597519e-01f, -2.03763679e-01f, -2.08340853e-01f, 4.95362699e-01f, -6.33876994e-02f, 2.95466840e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  9.99029353e-03f, -1.54556911e-02f, 2.99937781e-02f, 1.67912915e-01f, 8.55998546e-02f, 2.42625829e-02f, 3.89596522e-02f, 9.72385705e-02f, 7.92629048e-02f, 4.03565466e-02f,
  5.67805581e-02f, 1.29616290e-01f, 1.14120856e-01f, 1.56318873e-01f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  -1.29272446e-01f, -1.32368311e-01f, 1.99123863e-02f, -9.43606123e-02f, -1.17862634e-01f, 6.51690736e-02f, 7.74002895e-02f, 1.16308749e-01f, -1.31861806e-01f, -8.21686164e-02f,
  -2.61378121e-02f, -6.20391145e-02f, -1.07617572e-01f, -1.60722472e-02f, -1.45688102e-01f, 3.74564938e-02f, -1.20040670e-01f, 7.67237842e-02f, 1.48223653e-01f, -3.59296985e-02f,
  1.49995983e-01f, -2.52263099e-01f, 8.78719613e-02f, -1.29717842e-01f, 8.06901827e-02f, -1.67839453e-01f, -3.51614594e-01f, 1.76865011e-01f, 2.43993282e-01f, -2.69285679e-01f,
  -3.11850131e-01f, -1.51683286e-01f, 1.65230662e-01f, -3.16118628e-01f, 2.94901818e-01f, 2.30054379e-01f, 1.64552778e-01f, 1.81272820e-01f, 2.12364778e-01f, -2.68961817e-01f,
  -2.26165086e-01f, 2.67734498e-01f, 1.61918476e-02f, 3.01951855e-01f, 1.77338317e-01f, -9.39703956e-02f, -1.87849224e-01f, -7.56321400e-02f, -2.57774681e-01f, 2.23598480e-01f,
  1.42132014e-01f, -7.84790069e-02f, 3.57301027e-01f, 2.20246881e-01f, 2.41099194e-01f, -4.87692744e-01f, 7.13365451e-02f, -4.13144588e-01f, -3.20196688e-01f, -4.40300107e-01f,
  -5.54809332e-01f, -5.95619440e-01f, 2.25875571e-01f, -1.24388203e-01f, -8.39458629e-02f, 2.13580117e-01f, -1.58807650e-01f, 1.76846370e-01f, -1.23192884e-01f, 3.12034003e-02f,
  2.74923950e-01f, 6.70218514e-03f, 8.81928205e-03f, 2.00895295e-01f, -1.95307776e-01f, 2.30377108e-01f, 2.64408272e-02f, -5.59468791e-02f, -8.30800980e-02f, 1.66507959e-01f,
  1.47739798e-01f, -5.48583455e-02f, 1.67600632e-01f, 8.05559158e-02f, -1.51194468e-01f, 8.49295259e-02f, 6.06040023e-02f, 2.19277620e-01f, 1.87368721e-01f, -8.19754303e-02f,
  3.67050432e-02f, -4.78053465e-02f, -1.21244974e-01f, -1.58696711e-01f, -1.25140563e-01f, 2.04412788e-01f, -2.21927017e-01f, 2.70148724e-01f, -2.41447777e-01f, -2.75116563e-01f,
  4.67083752e-02f, 1.15900688e-01f, 1.34207115e-01f, -8.57767016e-02f, -1.23948790e-02f, -5.68697825e-02f, -2.24308982e-01f, 1.02076575e-01f, -3.77441645e-01f, 2.25088954e-01f,
  -8.45608935e-02f, 6.57611787e-02f, 3.07703882e-01f, -1.83785424e-01f, -3.18909377e-01f, -2.38068298e-01f, -2.92653650e-01f, 3.72867316e-01f, -1.46978140e-01f, -4.13002282e-01f,
  -9.09354445e-03f, -1.12934940e-01f, -4.51909095e-01f, 3.59998196e-01f, 5.12033403e-02f, -3.25685799e-01f, 3.42973053e-01f, -6.28692627e-01f, 9.62885246e-02f, 1.41307443e-01f,
  1.98348999e-01f, -1.39268205e-01f, -1.40630558e-01f, -1.38288662e-01f, 3.28801721e-02f, 3.50781786e-03f, -4.37681265e-02f, -2.80997008e-02f, -1.76123172e-01f, -1.87471248e-02f,
  7.70530328e-02f, -1.98265702e-01f, 1.76517576e-01f, -1.57760844e-01f, 9.65780243e-02f, -1.60136670e-01f, 7.45654404e-02f, -1.40462860e-01f, 5.55417240e-02f, -2.23205283e-01f,
  -2.79450249e-02f, -1.59890592e-01f, 7.12838247e-02f, -2.88668334e-01f, 1.38120964e-01f, -3.67134154e-01f, -2.10415691e-01f, -5.14385439e-02f, -2.47431815e-01f, -1.11998215e-01f,
  2.00284630e-01f, 1.54886916e-01f, -2.06344396e-01f, -5.57795279e-02f, -1.75077409e-01f, 1.97275966e-01f, -2.74074078e-01f, -1.73865184e-01f, -2.59916157e-01f, -2.40722019e-02f,
  -1.71186358e-01f, 2.59698004e-01f, -2.05045670e-01f, 2.06810519e-01f, 2.15334311e-01f, 1.28617823e-01f, -1.88814625e-02f, -1.35857105e-01f, -3.84302944e-01f, -3.78985524e-01f,
  -6.17694631e-02f, -1.67075485e-01f, -3.77302259e-01f, -4.69560057e-01f, -6.02751076e-01f, 1.91269175e-03f, -3.32506120e-01f, 3.87146771e-01f, 3.97657007e-01f, 1.60518624e-02f,
  -7.14150220e-02f, 5.02598047e-01f, -1.52765214e-01f, -1.08135909e-01f, -5.20694032e-02f, 1.12841412e-01f, -1.14113037e-02f, -2.54472606e-02f, 2.91586341e-03f, 1.66691884e-01f,
  -2.26616040e-01f, -1.02479003e-01f, -1.98094964e-01f, 1.39126247e-02f, -7.97099024e-02f, 2.29083765e-02f, 1.01172924e-02f, -2.20998541e-01f, 2.12182373e-01f, 1.42386198e-01f,
  -1.25360698e-01f, -2.60037094e-01f, -2.22638808e-02f, -1.79765046e-01f, -5.47172688e-02f, -1.50151491e-01f, -2.79335141e-01f, 2.89036065e-01f, 6.06226549e-02f, 2.70441007e-02f,
  -1.88983604e-02f, 1.88456520e-01f, 1.14901230e-01f, -1.24957420e-01f, -2.09980354e-01f, 6.34145141e-02f, 5.58185466e-02f, -2.64539093e-01f, 1.17966412e-02f, -2.03239247e-01f,
  3.67747843e-01f, 1.78841233e-01f, 8.97047892e-02f, -1.09095693e-01f, 6.15642816e-02f, -2.22547958e-03f, 8.19983184e-02f, -3.93739305e-02f, -5.25234006e-02f, -4.73531038e-02f,
  2.04219967e-01f, 8.34211707e-02f, -1.48767635e-01f, -3.04039896e-01f, 4.35245037e-01f, -3.24348897e-01f, 1.59862995e-01f, -1.04398280e-01f, 5.07032648e-02f, -1.75018348e-02f,
  3.50259155e-01f, 9.47396234e-02f, -2.29695693e-01f, -2.28264913e-01f, 3.35040018e-02f, -4.94575083e-01f, 2.07134299e-02f, 4.36959267e-02f, 5.59357218e-02f, 1.62900612e-01f,
  -1.62031909e-03f, -4.77800854e-02f, -1.10822558e-01f, -8.22365135e-02f, 1.18463963e-01f, -8.34649503e-02f, 1.83133990e-01f, -1.03690885e-01f, 2.97026038e-01f, 8.05690065e-02f,
  3.30618620e-01f, 1.44044340e-01f, -1.67152643e-01f, -1.17575362e-01f, -2.85593569e-01f, 2.35166669e-01f, 2.57837195e-02f, 3.16570938e-01f, -2.28226617e-01f, -2.62780905e-01f,
  4.82882522e-02f, 9.18496549e-02f, 5.57569899e-02f, 1.70091063e-01f, 2.64100462e-01f, 3.17616105e-01f, 1.37804523e-01f, 1.52632162e-01f, 8.03794861e-02f, -3.52144659e-01f,
  1.68411672e-01f, 1.30243078e-01f, 4.48367745e-01f, 2.71240827e-02f, -3.26875657e-01f, 5.07000498e-02f, -7.39440769e-02f, 1.14862457e-01f, 2.49582872e-01f, 5.59286587e-02f,
  -2.50510752e-01f, -2.45502159e-01f, -1.74904749e-01f, 3.90219152e-01f, -3.39197487e-01f, 2.59319246e-01f, 1.47782087e-01f, 1.99830934e-01f, 2.29187720e-02f, 1.80577397e-01f,
  3.47517312e-01f, 1.65474847e-01f, -2.56600678e-01f, -3.72785360e-01f, 8.90870243e-02f, 1.27450183e-01f, 2.68734843e-01f, -2.72162586e-01f, -3.26538801e-01f, -4.34488237e-01f,
  1.72646195e-01f, 4.28223889e-03f, -1.25346079e-01f, 6.11357726e-02f, 2.51593083e-01f, 1.90100864e-01f, -8.32882226e-02f, 3.66849676e-02f, -4.32359101e-03f, 1.99453905e-01f,
  1.10434890e-01f, 4.31542397e-02f, -1.22740371e-02f, 2.31449410e-01f, -1.90383002e-01f, 1.76560402e-01f, -5.43646105e-02f, 9.28402245e-02f, 6.13617674e-02f, 1.02078818e-01f,
  6.25123382e-02f, 2.87161656e-02f, -3.13627832e-02f, 2.49986649e-01f, -6.59151003e-02f, 2.48978809e-01f, 1.67096391e-01f, -2.41594702e-01f, -2.34199017e-01f, -1.08406633e-01f,
  1.15888812e-01f, -1.94860116e-01f, 1.40857518e-01f, 7.36505017e-02f, -6.68207705e-02f, 1.76388368e-01f, -3.27503502e-01f, 1.50798544e-01f, 2.45763093e-01f, -1.59401342e-01f,
  1.61426067e-01f, 5.69969714e-02f, -6.37438074e-02f, -1.96447968e-01f, 6.42443076e-02f, 2.19152391e-01f, 2.75045812e-01f, -1.87636152e-01f, -6.40520547e-03f, -2.79312849e-01f,
  2.56744713e-01f, 9.83305424e-02f, -2.17504874e-02f, 2.06532285e-01f, -1.52772680e-01f, 3.28026861e-01f, 1.71364322e-01f, -1.31971493e-01f, -4.74103801e-02f, -4.38205630e-01f,
  -2.74158359e-01f, 1.44316122e-01f, 1.07590877e-01f, -5.55966854e-01f, -1.40231654e-01f, -1.25002414e-01f, -8.63991976e-02f, -3.35425675e-01f, -8.20335746e-02f, 1.80355906e-01f,
  -1.33489355e-01f, -9.24564824e-02f, -2.06348315e-01f, 1.12744540e-01f, 2.26932660e-01f, -1.78102925e-01f, -1.52809381e-01f, -1.77242309e-01f, -1.68068171e-01f, -1.54419333e-01f,
  -2.16983050e-01f, 1.47434752e-02f, 6.01267733e-04f, -1.60561860e-01f, -5.25591429e-03f, -1.61871418e-01f, -2.95524169e-02f, -4.89863567e-02f, 2.18693331e-01f, 3.49259764e-01f,
  2.74758339e-01f, 3.32194924e-01f, 9.85337496e-02f, -2.64149159e-01f, 1.34462357e-01f, -6.54659346e-02f, 1.93523113e-02f, -4.00958695e-02f, -1.59876093e-01f, -1.49580285e-01f,
  -2.17249289e-01f, 2.18514532e-01f, -2.00130403e-01f, -3.11738282e-01f, -2.70355433e-01f, 1.51766554e-01f, 3.12475175e-01f, -3.05790305e-02f, -2.55554825e-01f, 3.88081968e-01f,
  -1.10928476e-01f, 2.17313975e-01f, 1.36789843e-01f, 1.00276887e-01f, -6.24892414e-01f, 2.20680073e-01f, -3.77439469e-01f, 2.12250233e-01f, -5.33227265e-01f, 1.59683228e-01f,
  -5.42890012e-01f, -2.46693552e-01f, 3.18083286e-01f, -3.56814951e-01f, 1.24559551e-01f, 2.56858647e-01f, -1.12247698e-01f, 1.31094888e-01f, -1.94389924e-01f, 1.13227010e-01f,
  1.34253949e-01f, 2.49749497e-02f, 3.04501615e-02f, 3.16950306e-02f, -5.71310893e-02f, 1.13476776e-01f, 3.00047956e-02f, -6.08160123e-02f, 4.35773246e-02f, -1.64547525e-02f,
  -2.13851020e-01f, 1.33400783e-01f, -1.90356642e-01f, -6.25227243e-02f, 1.79057255e-01f, -1.43288538e-01f, -2.42121774e-03f, 6.94149509e-02f, -3.14192213e-02f, 6.81910058e-03f,
  -8.84665325e-02f, -1.37303695e-01f, 2.35370006e-02f, -1.62114307e-01f, -2.35837147e-01f, -3.61030638e-01f, 1.75538972e-01f, 1.52601421e-01f, 8.52451846e-02f, -1.28870189e-01f,
  -2.54949749e-01f, -9.94000807e-02f, 6.65710866e-02f, 1.67232603e-01f, 1.84623837e-01f, 7.70518882e-03f, -5.14376834e-02f, 3.03460676e-02f, 3.05142134e-01f, -2.84417450e-01f,
  -3.10117573e-01f, -1.30199179e-01f, 1.80255547e-01f, 1.68035358e-01f, -2.33991072e-01f, -3.74251217e-01f, -1.57216743e-01f, 3.61858122e-02f, 4.74387258e-01f, -2.03818809e-02f,
  -1.03578188e-01f, -3.65069598e-01f, 1.31162390e-01f, -2.45176822e-01f, 4.01343137e-01f, -3.48847240e-01f, -3.29775482e-01f, -1.07397966e-01f, -4.28223103e-01f, -1.33330701e-02f,
  -3.22292060e-01f, 2.49116048e-01f, 2.18976345e-02f, -2.42989734e-01f, 2.51114428e-01f, -2.34753728e-01f, -1.41551390e-01f, 9.87122767e-03f, -1.75908476e-01f, -9.53041315e-02f,
  -1.44758463e-01f, -4.62899208e-02f, 9.55611393e-02f, 9.96323526e-02f, 1.98005468e-01f, -5.84287681e-02f, 1.20190047e-01f, -6.84505925e-02f, -1.30923629e-01f, -1.54139712e-01f,
  1.59017861e-01f, -8.05822313e-02f, -1.51778907e-01f, 1.66656524e-01f, -2.19547465e-01f, -2.48249084e-01f, -7.20803812e-02f, -9.14636180e-02f, 1.02472693e-01f, 3.39194909e-02f,
  -1.58742651e-01f, -1.03366628e-01f, -1.79839849e-01f, 2.16745421e-01f, -1.92145497e-01f, 1.28584623e-01f, -5.75374775e-02f, -1.45101264e-01f, -1.43750608e-01f, -1.80292651e-02f,
  1.97716668e-01f, -2.49633402e-01f, 3.14356595e-01f, -1.02641627e-01f, 2.32836828e-01f, 2.12192610e-01f, 2.75927931e-01f, 1.66334495e-01f, -2.01625779e-01f, -1.69071406e-01f,
  5.27247265e-02f, -4.71471846e-02f, -3.12740386e-01f, -3.54046315e-01f, -3.20101529e-01f, -4.05271113e-01f, -3.63143861e-01f, 1.18704930e-01f, 3.16170543e-01f, 2.02104673e-01f,
  -3.92108172e-01f, -1.05649687e-01f, -5.36210418e-01f, 1.21446677e-01f, 2.60632813e-01f, 1.33317947e-01f, 1.11088514e-01f, 7.79880881e-02f, 1.92711011e-01f, 2.80314982e-01f,
  2.87486076e-01f, 2.26302315e-02f, -7.24011064e-02f, -1.11823650e-02f, -2.47697476e-02f, -1.38561532e-01f, 3.75947580e-02f, 3.01430494e-01f, 1.94099456e-01f, -1.89689174e-01f,
  2.24590749e-01f, 7.60688782e-02f, -9.19622555e-02f, 2.07657397e-01f, 1.33959770e-01f, -1.39254570e-01f, -3.01768985e-02f, -1.99747846e-01f, 8.11352730e-02f, 1.34033665e-01f,
  -2.83738613e-01f, -3.36186379e-01f, -3.41089666e-01f, -1.23523422e-01f, -6.31081834e-02f, 3.10780495e-01f, 2.50059009e-01f, 1.04148515e-01f, 2.22547904e-01f, 3.09266329e-01f,
  4.05427039e-01f, -2.65343070e-01f, 8.68135020e-02f, 2.02067848e-03f, 2.37057898e-02f, 8.16681236e-02f, -1.30572617e-01f, 2.16625333e-01f, 1.31546453e-01f, -1.98300481e-01f,
  -1.82378963e-01f, -3.89155149e-01f, 2.34089211e-01f, -6.92042569e-03f, 2.57026255e-01f, 2.15841115e-01f, 2.05688715e-01f, 2.86713481e-01f, -2.39073738e-01f, -1.17950156e-01f,
  -2.18199398e-02f, -1.87258065e-01f, -3.45259041e-01f, -2.63363153e-01f, -6.05179846e-01f, -1.75659984e-01f, 1.59286544e-01f, 3.70148510e-01f, -4.92681682e-01f, 2.26223767e-01f,
  1.70410782e-01f, 2.40980722e-02f, -4.24648635e-02f, 1.08833469e-01f, 1.47621408e-01f, 1.17364295e-01f, 1.32512644e-01f, -4.92063947e-02f, 1.32173384e-02f, 1.11665830e-01f,
  6.28429204e-02f, -8.56404081e-02f, -9.59490463e-02f, -2.57133674e-02f, -2.06717998e-01f, 3.59457657e-02f, -1.04565017e-01f, 3.32380384e-02f, -9.68667567e-02f, 2.68480089e-02f,
  1.56449571e-01f, 1.87823042e-01f, -1.04741909e-01f, 2.39578754e-01f, 7.55062923e-02f, -1.34250090e-01f, 3.15072648e-02f, 8.70865062e-02f, 1.51519462e-01f, 2.11924210e-01f,
  -1.50021166e-01f, 1.74644455e-01f, -1.74632832e-01f, -2.90046960e-01f, -1.76702082e-01f, 2.56547242e-01f, 2.37320632e-01f, -1.22236265e-02f, 9.46897641e-02f, 1.62875995e-01f,
  2.07203582e-01f, -4.80455682e-02f, -9.64839384e-02f, -1.08588949e-01f, 2.04312310e-01f, -1.59158662e-01f, -1.59153268e-02f, -2.18765691e-01f, -2.81644642e-01f, -3.08576971e-01f,
  -2.38374159e-01f, -1.92673653e-01f, -3.55353624e-01f, -3.32150221e-01f, -1.39838338e-01f, -1.50452673e-01f, 2.44066060e-01f, 2.12258652e-01f, 9.63835046e-02f, 3.06724876e-01f,
  4.51121598e-01f, -5.92387497e-01f, -7.33451918e-02f, 5.44992648e-02f, -1.19524352e-01f, -9.34693962e-02f, -1.88472673e-01f, -1.17434144e-01f, -1.89747196e-02f, -6.17050417e-02f,
  1.72674745e-01f, 1.15189523e-01f, 2.28158832e-01f, 1.02930292e-01f, -1.18112370e-01f, 1.30414823e-02f, 1.16547294e-01f, -7.39768818e-02f, 5.72334118e-02f, -2.91128289e-02f,
  1.13661095e-01f, 6.58275485e-02f, -1.26077443e-01f, -5.89433871e-02f, 1.23020135e-01f, -1.04458779e-01f, 2.63031665e-02f, 1.81862459e-01f, 1.47187859e-01f, 1.68948501e-01f,
  -5.49690835e-02f, 7.60518461e-02f, -6.97169304e-02f, 2.98010617e-01f, 9.03003961e-02f, 1.39550315e-02f, 2.22754329e-01f, 6.22634031e-02f, -1.32259816e-01f, 3.38393688e-01f,
  -1.34408563e-01f, -2.57735759e-01f, -1.94534436e-01f, 2.47466147e-01f, 3.26361150e-01f, 1.00056045e-01f, -8.10896605e-02f, -1.96857989e-01f, 2.90106684e-01f, -2.21941113e-01f,
  1.89683333e-01f, 5.36760502e-02f, 5.90200350e-02f, 9.70022976e-02f, -4.41410914e-02f, -2.97943681e-01f, -1.47024989e-01f, -5.36358654e-01f, -1.53627142e-01f, 3.49560142e-01f,
  -2.63799936e-01f, 2.02090740e-01f, 3.07615519e-01f, -2.04949409e-01f, -2.39450216e-01f, 9.88830477e-02f, -2.12149367e-01f, 3.39596599e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.08109400e-01f, 1.12395987e-01f, 4.19896208e-02f, -8.90125930e-02f, 4.07740995e-02f, -1.81909855e-02f, 9.97570455e-02f, 4.17775624e-02f, 8.66564810e-02f, -2.45604757e-02f,
  2.56249458e-02f, -1.17192268e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 25, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    