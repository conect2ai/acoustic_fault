/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.65162289e-01f, 6.32121712e-02f, 2.36042902e-01f, 1.76449686e-01f, -1.11679271e-01f, -3.50093275e-01f, -3.59930515e-01f, -8.59633237e-02f, -1.67180210e-01f, -1.85106203e-01f,
  -7.33976215e-02f, 1.64119117e-02f, -1.09882280e-01f, 3.04326992e-02f, 9.88226086e-02f, -1.08506523e-01f, 1.11588491e-02f, -3.62501643e-03f, -4.00757752e-02f, 8.86688605e-02f,
  4.77376617e-02f, -4.63584177e-02f, 2.03257382e-01f, -3.41932923e-02f, 4.55021709e-02f, 1.21879578e-01f, 2.00811341e-01f, -6.60404563e-02f, 7.91408867e-02f, -1.01732530e-01f,
  -2.32902132e-02f, 7.09025376e-03f, 1.78531054e-02f, -5.30722318e-04f, 3.32494564e-02f, -5.40861450e-02f, -3.19566987e-02f, -4.06715013e-02f, 1.94521248e-02f, -1.04747258e-01f,
  -6.57225773e-02f, -3.51465903e-02f, -3.71938422e-02f, -1.20200804e-02f, 4.49724011e-02f, 7.21536856e-03f, 8.94282460e-02f, 2.55949982e-02f, -9.21610966e-02f, 8.46398771e-02f,
  1.29964590e-01f, -1.26335904e-01f, 8.29646960e-02f, -1.86684616e-02f, 3.27909403e-02f, 1.59633420e-02f, -1.45334825e-01f, 2.62143482e-02f, -9.48783457e-02f, -1.35565264e-04f,
  2.33790837e-02f, -3.72850560e-02f, 3.04086576e-03f, 3.35659236e-02f, 5.52985258e-03f, -3.62446494e-02f, -1.66005157e-02f, -9.24068093e-02f, 6.19584136e-02f, -4.77208346e-02f,
  -5.84229417e-02f, 1.72292814e-02f, 2.51524597e-02f, -1.01721520e-02f, 5.02740033e-03f, -3.94885577e-02f, 1.30986152e-02f, 7.80851692e-02f, -4.14267406e-02f, -3.66087593e-02f,
  -5.81541099e-02f, 2.68825497e-02f, 2.88968384e-02f, 1.74086839e-02f, -5.89294545e-02f, -4.33404632e-02f, 6.45603985e-02f, 1.12960925e-02f, 6.15614243e-02f, -6.71327300e-03f,
  -1.02415614e-01f, -8.30699049e-04f, -8.27411041e-02f, -2.80400012e-02f, -3.63014489e-02f, -3.72583494e-02f, -2.17565775e-01f, 1.32394610e-02f, -3.90507430e-02f, -6.24973141e-02f,
  2.76106875e-02f, -7.83750340e-02f, -3.09186243e-02f, 4.71730381e-02f, -7.98244681e-03f, 1.92363523e-02f, 6.62040561e-02f, -1.40300067e-02f, -8.46783966e-02f, 3.13488506e-02f,
  8.51557627e-02f, -8.10827091e-02f, -1.38707250e-01f, -6.34715483e-02f, -3.42342183e-02f, -1.46313692e-02f, -9.00449231e-02f, 2.62641292e-02f, 2.93993279e-02f, -6.05955422e-02f,
  6.13622069e-02f, 1.39728248e-01f, -7.07667693e-02f, 2.19799891e-01f, -1.66759789e-01f, -1.26498073e-01f, 6.54159188e-02f, 1.40917867e-01f, 1.17148273e-01f, 2.23944038e-01f,
  6.35470822e-02f, 3.78670320e-02f, 5.12824841e-02f, 5.71570219e-03f, -2.83921033e-01f, -5.16205393e-02f, -1.10083483e-01f, 9.16592479e-02f, 6.40395358e-02f, 9.58036706e-02f,
  -1.23124033e-01f, -2.54069269e-02f, -1.58677503e-01f, -4.48529273e-02f, -7.06076846e-02f, 8.72135535e-02f, 3.26889195e-03f, 6.93738135e-03f, 6.80456907e-02f, -6.47622868e-02f,
  -6.36670589e-02f, 1.88215390e-01f, -6.88554570e-02f, -6.82731792e-02f, 2.14904454e-02f, -4.29952145e-03f, -8.50725248e-02f, 2.33989507e-02f, -7.53939822e-02f, 3.77666168e-02f,
  -5.26678152e-02f, -7.02183098e-02f, 4.95117716e-02f, -3.83997522e-02f, -6.23922423e-02f, -3.93310413e-02f, 1.66091304e-02f, -6.74191192e-02f, -1.05616916e-02f, -5.81486411e-02f,
  -1.61849167e-02f, -4.35256250e-02f, -7.13967383e-02f, -3.88748199e-02f, -2.98487060e-02f, 3.18951458e-02f, -5.49285440e-03f, -3.39635015e-02f, 2.16494724e-02f, 9.37440991e-02f,
  1.97124295e-02f, 9.23066959e-03f, 9.79255792e-03f, -2.10951306e-02f, 7.51449987e-02f, -6.05899096e-03f, -7.08076060e-02f, 8.39690343e-02f, 2.56042555e-03f, 1.36166528e-01f,
  3.16982195e-02f, 4.53134477e-02f, 2.59086750e-02f, -7.35565275e-02f, 3.94925848e-02f, 1.86675489e-02f, -7.16821924e-02f, -7.48751238e-02f, -6.68594688e-02f, 3.70722301e-02f,
  7.90192559e-02f, 2.89507266e-02f, 4.47501428e-02f, -8.95921886e-02f, 1.67069845e-02f, 9.21883993e-03f, -1.06923394e-01f, -2.42122281e-02f, 5.77416755e-02f, -9.48688313e-02f,
  9.60731581e-02f, 2.62348533e-01f, 3.46414861e-03f, 1.20939631e-02f, -2.02855635e-02f, -1.55051323e-02f, -2.40371376e-02f, -6.82260394e-02f, 1.13917422e-02f, 1.56797674e-02f,
  -1.02848224e-01f, 4.77882884e-02f, 6.19838610e-02f, -7.63279870e-02f, 1.06673157e-02f, -3.88275087e-02f, 4.09514084e-02f, -1.00484081e-02f, -5.09101897e-02f, 2.07436346e-02f,
  -2.39625834e-02f, 1.93569046e-02f, -2.81647872e-02f, 1.02872126e-01f, -8.72425213e-02f, -4.30337489e-02f, 5.87249883e-02f, 9.08616744e-03f, -9.89440829e-02f, -2.70454753e-02f,
  2.84116030e-01f, -2.20891297e-01f, -3.96019071e-02f, 1.52058154e-01f, 1.67090017e-02f, 1.73911583e-02f, 7.65734017e-02f, -7.99080655e-02f, 1.64434146e-02f, -2.49746919e-01f,
  8.32454860e-02f, -2.14789379e-02f, -1.15989938e-01f, -5.59291989e-02f, 4.16514218e-01f, 1.65993512e-01f, 1.80969164e-01f, -3.53071429e-02f, 2.00967461e-01f, -8.62672850e-02f,
  1.38973117e-01f, 1.90004319e-01f, 1.73113450e-01f, -1.07613131e-01f, -1.21826686e-01f, -2.59703975e-02f, 1.09682404e-01f, -1.42688841e-01f, -9.33216214e-02f, 1.43383248e-02f,
  -1.29280746e-01f, 2.91886758e-02f, -2.42080316e-02f, -7.13872686e-02f, 2.97318958e-03f, -5.23121096e-02f, -6.74333721e-02f, 3.45183201e-02f, 1.02020770e-01f, -3.85905541e-02f,
  -7.05557466e-02f, 1.12242461e-03f, 2.29898784e-02f, 3.82180288e-02f, 2.41329130e-02f, -3.68009903e-03f, 3.17447074e-02f, -1.31701110e-02f, -4.16014828e-02f, 4.25590910e-02f,
  8.14976823e-03f, -2.74333954e-02f, 5.64959161e-02f, -3.17113213e-02f, 4.64365520e-02f, 4.84776832e-02f, 3.61911282e-02f, -2.94452142e-02f, 3.32838558e-02f, 1.18125461e-01f,
  9.18841586e-02f, -6.31082952e-02f, 2.32990533e-02f, -1.18348949e-01f, 9.68405008e-02f, 4.95126881e-02f, 7.67546287e-03f, -3.86395790e-02f, -4.45174426e-02f, 4.54887301e-02f,
  -3.83517630e-02f, -1.69235189e-02f, 5.20679988e-02f, -7.16717914e-03f, 7.90880714e-03f, 4.64709960e-02f, 2.18807664e-02f, -6.58820719e-02f, -2.64641419e-02f, -3.27079855e-02f,
  1.46234417e-02f, -1.99472178e-02f, -3.05720661e-02f, -1.24390591e-02f, 2.07313057e-02f, 2.05107722e-02f, -7.54885599e-02f, -4.25282978e-02f, 2.69454867e-02f, 8.48629028e-02f,
  -2.63126165e-01f, -1.11405313e-01f, -1.12238061e-02f, -1.42762721e-01f, 8.44400972e-02f, -6.42252043e-02f, -3.72780934e-02f, -1.34027861e-02f, -1.05409309e-01f, 8.94134417e-02f,
  -1.06651582e-01f, -1.01507232e-01f, -6.89034835e-02f, -2.67085470e-02f, 4.89833690e-02f, 2.11413093e-02f, -1.70678254e-02f, -7.09775165e-02f, -5.13948910e-02f, -4.06058393e-02f,
  4.09757681e-02f, -6.12406656e-02f, -1.37767931e-02f, 1.17667308e-02f, -5.87842837e-02f, 3.61970887e-02f, -4.06948663e-02f, -7.64694472e-04f, -5.33491783e-02f, 5.75549603e-02f,
  1.49054885e-01f, -1.37076423e-01f, -1.60911992e-01f, 2.97350362e-02f, 1.07524291e-01f, 3.16217303e-01f, 1.65970460e-01f, -2.02435050e-02f, -3.21119577e-02f, -1.67577460e-01f,
  -1.53008820e-02f, -8.28833953e-02f, -3.46456319e-02f, 1.22323662e-01f, 1.38769001e-01f, -2.20018581e-01f, 2.36619949e-01f, 5.62371761e-02f, -9.86030847e-02f, -1.92009695e-02f,
  -2.59050205e-02f, 2.18473673e-01f, -6.77373186e-02f, 1.83548126e-02f, 2.11451277e-02f, -8.27808380e-02f, -1.09960057e-03f, -1.50871411e-01f, 5.53667881e-02f, -8.89564119e-03f,
  5.53716682e-02f, -8.99308845e-02f, -3.70563865e-02f, 1.70379970e-02f, -8.71933103e-02f, 4.32962663e-02f, 1.04968071e-01f, 3.52963284e-02f, -8.92011598e-02f, -2.98757497e-02f,
  9.04373378e-02f, 1.41069600e-02f, 3.03444881e-02f, -3.83579209e-02f, 6.53206259e-02f, -9.76933911e-02f, 3.16957980e-02f, -1.72144249e-02f, -7.68008381e-02f, -3.21344994e-02f,
  2.20716819e-02f, 4.85715866e-02f, 1.18953057e-01f, -3.10434997e-02f, -1.45084886e-02f, 1.63408425e-02f, -1.45280389e-02f, -3.26436646e-02f, -2.53375666e-03f, -1.05456397e-01f,
  6.78901747e-03f, 5.23158209e-03f, -1.96960047e-02f, 4.53262255e-02f, -2.99505740e-02f, 6.00741208e-02f, 2.45706737e-03f, -2.15346590e-02f, -3.16456631e-02f, -4.72798832e-02f,
  -3.80391441e-02f, 4.48465087e-02f, 6.35058433e-02f, 1.71379447e-02f, 8.14400464e-02f, 3.49646956e-02f, -1.15197608e-02f, 1.89711750e-02f, -4.66348976e-02f, 2.99417861e-02f,
  -6.44380366e-03f, -6.12406526e-04f, -1.87563077e-02f, 3.72695923e-02f, 1.37730658e-01f, 5.83066791e-02f, -2.63501611e-02f, -3.16872261e-02f, 3.47798094e-02f, 8.93170312e-02f,
  4.51339893e-02f, -1.93567470e-01f, -6.11844584e-02f, 8.92077088e-02f, -9.18697473e-03f, 5.33909025e-03f, 8.55091736e-02f, -3.57873994e-03f, -1.41415402e-01f, 3.58280120e-03f,
  9.55173746e-02f, 1.84565932e-02f, -1.56699847e-02f, 8.09917152e-02f, 3.36974449e-02f, 4.56581600e-02f, 1.11954555e-01f, -2.03156974e-02f, 4.71531078e-02f, -2.92506311e-02f,
  -5.25105707e-02f, 4.27437723e-02f, 3.79995559e-03f, 4.92315777e-02f, 5.70928268e-02f, 4.41899337e-02f, -7.14194076e-03f, 1.81913543e-02f, 1.00818947e-01f, -7.65641183e-02f,
  1.81611121e-01f, 1.98193803e-01f, 2.55247682e-01f, 9.31350663e-02f, 1.08896479e-01f, 1.73334628e-01f, -9.68768168e-03f, 2.51383990e-01f, 1.65054277e-01f, -1.60259120e-02f,
  -7.32172057e-02f, 1.19932309e-01f, -1.56072497e-01f, -5.09282714e-03f, 1.20763540e-01f, -1.21395677e-01f, 5.46270758e-02f, -4.08804156e-02f, 1.03358075e-01f, 7.93273821e-02f,
  5.41334674e-02f, -8.35485384e-02f, 6.46121949e-02f, 7.12380931e-02f, 9.03320871e-03f, 9.76884514e-02f, -1.68428496e-01f, -2.09869519e-02f, -3.31026874e-02f, 5.68215549e-02f,
  1.44380629e-02f, -1.02461070e-01f, 3.86205432e-03f, 2.11112550e-03f, 4.03829031e-02f, -2.71760542e-02f, -3.26120518e-02f, -2.70466637e-02f, -1.89655880e-03f, 1.81798115e-02f,
  5.22406660e-02f, 1.66043658e-02f, 3.17714214e-02f, 5.85357137e-02f, 1.25939315e-02f, -1.80715565e-02f, 8.15143250e-03f, 1.00308821e-01f, 7.97348469e-02f, 3.16366777e-02f,
  9.04662982e-02f, 2.76123211e-02f, 8.25664103e-02f, -2.42926180e-02f, 9.69521850e-02f, 6.32304996e-02f, -9.10884589e-02f, 5.03838658e-02f, -5.60964011e-02f, 6.31852373e-02f,
  4.41066138e-02f, -1.33310974e-01f, -6.03427477e-02f, -8.48704278e-02f, 2.98918188e-02f, -3.02808862e-02f, 5.24843633e-02f, -1.10558279e-01f, 1.76527910e-02f, -2.53149029e-03f,
  -1.08628362e-01f, -1.04027651e-01f, 3.68535593e-02f, 4.70801666e-02f, 2.09382214e-02f, -2.40313001e-02f, -6.48153424e-02f, 2.72436161e-02f, 5.71445860e-02f, 2.97811069e-02f,
  -1.59049436e-01f, 2.67718080e-02f, -8.37277025e-02f, -1.18145004e-01f, -4.71471660e-02f, -1.18819684e-01f, 8.41825549e-03f, 1.36631224e-02f, -1.56015251e-02f, 9.88952667e-02f,
  -1.35945737e-01f, -9.27806124e-02f, 6.35767654e-02f, -6.30467981e-02f, -9.29976851e-02f, -8.88686702e-02f, -1.82747841e-02f, 1.64861768e-01f, -2.21798606e-02f, 3.63001302e-02f,
  1.27775371e-02f, -8.43439624e-02f, -3.80070545e-02f, 3.93201560e-02f, 5.19538969e-02f, 8.42071623e-02f, -2.49735359e-02f, -4.65827249e-02f, -8.67024809e-02f, 1.74571052e-02f,
  4.86543141e-02f, 2.03444920e-02f, 9.53521486e-03f, -4.66371104e-02f, -5.50707169e-02f, -1.54237868e-02f, 1.12211794e-01f, 7.88034499e-02f, 4.31487039e-02f, -1.46513581e-02f,
  -1.05606042e-01f, 4.38177548e-02f, 7.98861459e-02f, 7.93615207e-02f, 1.39402106e-01f, -5.48372902e-02f, -8.56273919e-02f, 2.03276217e-01f, 5.80644161e-02f, 5.79520352e-02f,
  5.51623143e-02f, 2.15495620e-02f, -1.47785589e-01f, 7.21371099e-02f, -2.15134889e-01f, -2.24291623e-01f, -6.51363879e-02f, -1.12613440e-01f, -6.06290922e-02f, 8.85986239e-02f,
  4.28083353e-02f, 9.99088883e-02f, -4.95984145e-02f, 1.89746886e-01f, 1.59987181e-01f, 8.85502398e-02f, 9.68279690e-03f, -4.68406305e-02f, 6.23996221e-02f, 6.30080374e-03f,
  -9.57916677e-02f, 1.06249951e-01f, 8.21952820e-02f, -2.66001951e-02f, -7.02441111e-02f, 4.95097302e-02f, -1.50834933e-01f, -2.60642804e-02f, -5.44668697e-02f, -2.57538818e-02f,
  -4.14806418e-02f, 4.98654842e-02f, 3.81937250e-02f, -1.90766924e-03f, 8.85293186e-02f, 7.79987872e-02f, -4.02959529e-03f, -1.35631685e-03f, 1.17728457e-01f, 8.63877013e-02f,
  9.18767825e-02f, 3.02563868e-02f, -6.09237002e-03f, -3.66246141e-02f, 1.56109035e-02f, 2.29906980e-02f, -8.50146189e-02f, -3.80170159e-02f, -8.80138204e-02f, 4.16287556e-02f,
  -6.89034238e-02f, 1.22693647e-03f, -4.73368168e-03f, 4.14565988e-02f, -5.25234751e-02f, 7.43832579e-03f, -1.80812757e-02f, 2.21251938e-02f, -8.63379985e-03f, 3.28605957e-02f,
  4.46397625e-02f, -6.00766763e-03f, -4.19830456e-02f, -1.18350296e-03f, 2.19822247e-02f, -1.58712007e-02f, -1.07717283e-01f, 1.10905848e-01f, -2.20493749e-02f, -2.02898914e-03f,
  -3.04244179e-03f, -1.04521690e-02f, 1.51978768e-02f, 1.47675518e-02f, 1.41456714e-02f, 7.36439461e-03f, 7.41506740e-02f, -1.73920505e-02f, -5.13156019e-02f, -3.41020972e-02f,
  -1.88295409e-01f, -3.87001596e-02f, 4.31924053e-02f, 3.14579420e-02f, -5.01437411e-02f, -4.86200675e-02f, -3.91365662e-02f, 8.32230877e-03f, -1.27726778e-01f, 7.73977116e-02f,
  3.09780762e-02f, -1.67482867e-05f, -8.37535560e-02f, -7.40710471e-04f, -4.49950546e-02f, -1.08916648e-02f, -1.11751352e-02f, -6.80653974e-02f, -3.87427993e-02f, -1.23624327e-02f,
  -4.07021306e-03f, -3.76284346e-02f, 8.32292736e-02f, -3.19911204e-02f, -4.05811891e-02f, 7.51579404e-02f, -2.12031566e-02f, -1.08850133e-02f, 9.12475362e-02f, -3.35696973e-02f,
  -1.42396271e-01f, -1.46573365e-01f, -2.92649806e-01f, -1.77298561e-01f, 2.64615826e-02f, 9.66740400e-02f, -2.55817398e-02f, -3.47060673e-02f, -1.08076341e-01f, 1.55655593e-01f,
  6.68715611e-02f, -2.34058961e-01f, -4.75712158e-02f, -2.97754705e-02f, -4.18652177e-01f, -2.14274168e-01f, -2.40696482e-02f, 4.34640385e-02f, -1.60646513e-01f, -2.47484855e-02f,
  -1.43309474e-01f, 1.94630817e-01f, -2.88198203e-01f, 1.97827563e-01f, 1.91314146e-01f, 9.94459447e-03f, 1.37555599e-01f, -1.07995505e-02f, -3.11535429e-02f, 3.23663391e-02f,
  -2.70970091e-02f, -9.53300670e-02f, -6.64450228e-02f, 3.92807946e-02f, -2.55388618e-02f, 7.64604732e-02f, 7.39519298e-02f, 2.11520586e-02f, -5.98801486e-02f, 3.45725543e-03f,
  7.62559995e-02f, -1.63398366e-02f, 4.11779583e-02f, 9.86083690e-03f, -1.76301028e-03f, -6.54376447e-02f, -1.07253775e-01f, 1.82995442e-02f, -2.66614240e-02f, -4.94210683e-02f,
  -6.68325201e-02f, -1.35316774e-01f, 8.24692100e-02f, 9.17592868e-02f, -1.00422919e-01f, -3.02039478e-02f, -6.63577989e-02f, -1.29344286e-02f, 8.00018013e-03f, -1.03795156e-01f,
  1.23260528e-01f, 5.86597510e-02f, -3.46871130e-02f, -7.16961920e-02f, -8.12955648e-02f, 2.40258649e-02f, 2.16444340e-02f, -5.65636940e-02f, -1.34205753e-02f, -3.50248464e-03f,
  -4.84168902e-02f, -3.31218503e-02f, 1.23061230e-02f, -1.07370287e-01f, -2.67755277e-02f, 2.67417375e-02f, -3.63814048e-02f, 4.27067578e-02f, 4.79387213e-03f, -4.16520648e-02f,
  -5.77853844e-02f, -4.57480624e-02f, 3.26350816e-02f, 1.06692523e-01f, 1.06571570e-01f, -9.84445140e-02f, 8.93643312e-03f, -5.56810871e-02f, 2.01532450e-02f, 2.28460762e-03f,
  2.47415416e-02f, -2.29004752e-02f, 1.81358308e-02f, -3.39667909e-02f, -1.90266147e-02f, -4.41423282e-02f, -7.19900727e-02f, 1.00671202e-02f, -7.63328075e-02f, -8.79846066e-02f,
  -7.73439789e-03f, 1.17772296e-01f, -1.86460428e-02f, -3.24537931e-03f, -9.33521688e-02f, 2.92696711e-02f, 1.22097563e-02f, -6.23759534e-03f, -9.50547978e-02f, -7.72530586e-02f,
  3.34474221e-02f, -5.19429259e-02f, 1.73543375e-02f, -5.67084830e-03f, 1.73738468e-02f, 1.70061942e-02f, 3.41283018e-03f, -1.70215908e-02f, 3.29897813e-02f, -1.16710350e-01f,
  -1.06816038e-01f, 1.37765348e-01f, 1.28155529e-01f, -4.81542088e-02f, -5.78635279e-03f, -3.20281893e-01f, -2.82901049e-01f, 6.68258443e-02f, 1.93782464e-01f, 2.30838396e-02f,
  -1.02404229e-01f, 1.33588687e-01f, -5.99329025e-02f, -1.60034955e-01f, -1.34080485e-01f, 1.45170853e-01f, -1.45360857e-01f, -6.69420213e-02f, 1.15758948e-01f, 5.76975057e-03f,
  6.90644607e-02f, -9.34897289e-02f, -3.53675932e-02f, 2.36461475e-03f, -1.40658036e-01f, 2.13501573e-01f, 4.71395105e-02f, -9.99093056e-03f, -2.17176788e-02f, -4.00906801e-03f,
  -6.07193522e-02f, 1.44056408e-02f, -1.82521384e-04f, -1.44217042e-02f, -6.50239512e-02f, -9.17780995e-02f, -9.79884416e-02f, 1.23251909e-02f, 5.67474477e-02f, 5.04588038e-02f,
  -7.86516443e-02f, 2.31911931e-02f, 7.98466131e-02f, 5.85246831e-02f, -2.89778486e-02f, 1.58581182e-01f, 4.89882799e-03f, 4.79934784e-03f, 7.67745674e-02f, -5.24156429e-02f,
  -1.02283694e-02f, 4.58451845e-02f, -7.73696080e-02f, 1.63565781e-02f, -1.08113931e-02f, 2.55097561e-02f, 9.32385400e-03f, 2.49075815e-02f, 3.09353825e-02f, 6.30152524e-02f,
  7.90114794e-03f, 1.61652360e-02f, 2.68565733e-02f, 1.75696090e-02f, 6.08565621e-02f, 1.54231610e-02f, -9.82730463e-02f, -4.58986033e-03f, 1.74972545e-02f, 8.34439695e-03f,
  2.08130758e-02f, 3.01381033e-02f, -1.27146065e-01f, -7.77740330e-02f, -1.19396634e-02f, 1.18582239e-02f, 1.29454909e-02f, 3.99209671e-02f, -7.85977989e-02f, 1.37717780e-02f,
  -2.87141302e-03f, -1.64825507e-02f, -7.12745823e-04f, -5.76116554e-02f, -8.40843320e-02f, -1.12331510e-02f, -3.85867395e-02f, 4.41970117e-02f, 1.25027765e-02f, -7.36170784e-02f,
  1.72049704e-03f, 1.73640609e-01f, 1.15755536e-02f, -4.81676236e-02f, -1.41056981e-02f, -1.79457925e-02f, -4.42122966e-02f, -1.32877044e-02f, 7.72454068e-02f, 5.28095663e-02f,
  -1.19959138e-01f, -3.14344019e-02f, -5.22930212e-02f, -6.55118227e-02f, 7.30202626e-03f, -1.14693716e-02f, -4.77375425e-02f, -8.67302413e-04f, -6.70750812e-03f, 9.98658463e-02f,
  -3.58919092e-02f, 1.65740307e-02f, 9.40602273e-03f, 6.22043610e-02f, -2.34189406e-02f, -7.50439540e-02f, 1.33827124e-02f, -3.42670493e-02f, -3.76913063e-02f, 6.51979297e-02f,
  1.68496415e-01f, -2.00239927e-01f, -6.24300912e-02f, 2.05833875e-02f, 1.89160183e-01f, -1.38584927e-01f, -1.68563396e-01f, 6.02395944e-02f, -2.12125406e-01f, -2.40856707e-01f,
  4.17140201e-02f, -2.18498528e-01f, -4.67544757e-02f, -1.47552326e-01f, 1.23911023e-01f, -4.09495607e-02f, -9.22989845e-02f, -5.75088784e-02f, 5.73538803e-03f, 9.81955901e-02f,
  3.03047877e-02f, 1.00949593e-01f, 5.66085763e-02f, 3.32933478e-02f, 1.54791623e-01f, 1.10908240e-01f, 1.86581224e-01f, 1.61243435e-02f, 2.12959908e-02f, 8.69798288e-03f,
  -5.20211160e-02f, -6.58946410e-02f, 7.80035108e-02f, -4.05276716e-02f, 9.01951939e-02f, -1.72199458e-02f, -1.27594573e-02f, 1.98772997e-02f, 4.38855700e-02f, 1.66239683e-02f,
  -8.34883079e-02f, 8.85295719e-02f, 1.09533325e-03f, -6.03127256e-02f, 2.49019284e-02f, 6.71357475e-03f, -6.51058927e-02f, 2.69077141e-02f, -2.31719725e-02f, -3.34430374e-02f,
  -8.24824199e-02f, 5.28567769e-02f, -1.99890584e-02f, -1.05187930e-01f, -2.46237759e-02f, -3.15855034e-02f, 3.63264757e-04f, -3.04754693e-02f, -3.51846479e-02f, 8.40866640e-02f,
  -1.05508976e-01f, 6.54685199e-02f, -1.69749453e-03f, 2.72209477e-02f, 1.01537751e-02f, -1.47397174e-02f, 1.28879305e-02f, 4.38004248e-02f, 3.01840585e-02f, 4.07777121e-03f,
  7.26278052e-02f, -5.54741034e-03f, -1.20077528e-01f, -7.49709979e-02f, 6.44704029e-02f, 8.17357376e-02f, 1.12215064e-01f, -5.41020595e-02f, -2.02214401e-02f, 9.00160074e-02f,
  2.63409019e-02f, -2.93263588e-02f, 3.07010990e-02f, 4.25474718e-02f, -5.38269291e-03f, 2.60851253e-03f, -9.43371356e-02f, 5.31735495e-02f, -2.33765997e-04f, 3.45699489e-02f,
  7.49541819e-02f, -7.85262734e-02f, -6.43871427e-02f, 4.58242781e-02f, -2.02094158e-03f, 8.26630890e-02f, -2.20290311e-02f, -6.15751557e-02f, 3.08343992e-02f, 9.64926034e-02f,
  3.62998210e-02f, 6.57062605e-02f, 4.51363958e-02f, -2.47485656e-02f, 3.92451808e-02f, -8.44681114e-02f, 2.46986076e-02f, 8.42781514e-02f, 1.28968984e-01f, 8.75461847e-03f,
  1.85997989e-02f, -2.80126426e-02f, -5.66589534e-02f, 1.12148434e-01f, -3.86694968e-02f, 4.06401651e-03f, 4.93642092e-02f, -5.17486595e-02f, 2.37100516e-02f, 2.41675097e-02f,
  2.06066161e-01f, 1.99215174e-01f, -6.13427311e-02f, -5.70214130e-02f, -1.29459649e-02f, -2.10386992e-01f, -1.80987597e-01f, 1.01365214e-02f, -2.16462374e-01f, -1.41194854e-02f,
  1.98562406e-02f, 4.51078871e-03f, -2.54867249e-03f, -1.16562627e-01f, -1.58222347e-01f, -2.06614450e-01f, -1.14367120e-01f, -4.91805933e-02f, -5.64609729e-02f, 1.50894389e-01f,
  -1.76496208e-02f, -8.99070874e-02f, 6.08407333e-02f, 1.68642297e-01f, 4.05110791e-02f, 1.72710180e-01f, 7.85495564e-02f, 1.34317219e-01f, 6.81403950e-02f, -9.99973621e-03f,
  1.05022125e-01f, 5.38453348e-02f, -1.70057062e-02f, -1.27757480e-03f, 8.45290571e-02f, 6.96254820e-02f, 5.18301353e-02f, -9.32624117e-02f, 1.85548998e-02f, -2.41236389e-02f,
  -2.99025308e-02f, -5.58589362e-02f, -4.47283201e-02f, -7.79229254e-02f, 1.84434559e-02f, -1.77863583e-01f, -1.11750782e-01f, 4.79996577e-03f, 9.49336402e-03f, 2.46198066e-02f,
  3.61448526e-02f, -7.61737525e-02f, -3.04899793e-02f, 6.67929426e-02f, 2.28634030e-02f, -5.35144806e-02f, -7.71327987e-02f, 4.26165387e-03f, -3.40124443e-02f, -3.96565758e-02f,
  1.50766363e-02f, 1.08917937e-01f, -2.44843196e-02f, -3.58011089e-02f, -6.07755966e-02f, 8.66878033e-02f, -4.23898213e-02f, -5.51210195e-02f, -3.49470191e-02f, 4.86721396e-02f,
  -4.25181016e-02f, -1.84639134e-02f, 6.82843197e-03f, 3.07467896e-02f, 8.01670402e-02f, 5.49633317e-02f, -3.68444584e-02f, -7.98873231e-02f, 6.23680539e-02f, -7.95432180e-02f,
  -1.56302396e-02f, 5.08464202e-02f, -3.43042538e-02f, 7.52928630e-02f, -4.57715578e-02f, 2.79031899e-02f, -2.61026435e-02f, -1.02365285e-01f, -7.79827684e-03f, 1.46207698e-02f,
  1.34681314e-01f, 1.47291347e-01f, -2.10330319e-02f, -2.77203191e-02f, 5.41288331e-02f, -3.28090377e-02f, -1.64256766e-02f, -1.20866612e-01f, -9.44815017e-03f, -6.46803156e-02f,
  5.98131455e-02f, 1.01122409e-02f, 5.35520762e-02f, 8.71453783e-04f, 1.92969367e-02f, -2.12213006e-02f, 7.73174167e-02f, 3.62600312e-02f, 4.94085699e-02f, 7.67063573e-02f,
  9.74952802e-02f, 7.83807710e-02f, -5.15923612e-02f, -3.27662341e-02f, 6.95166662e-02f, 9.23229009e-02f, 2.21019592e-02f, 4.26670387e-02f, -1.25291914e-01f, -6.14456236e-02f,
  2.59763539e-01f, 9.30318311e-02f, 1.26553969e-02f, 3.29458266e-01f, -1.09070539e-02f, 1.01513434e-02f, 2.77169764e-01f, -1.03023611e-01f, 2.01458797e-01f, 7.88192749e-02f,
  1.13266796e-01f, 1.39782950e-01f, -6.51386194e-03f, 2.45813534e-01f, 4.71031368e-01f, 1.10018380e-01f, 3.12350392e-01f, 1.63649783e-01f, 1.76724613e-01f, 8.68172869e-02f,
  1.61554620e-01f, 1.79478005e-01f, -1.48307439e-02f, -1.39922217e-01f, -7.96654727e-04f, -4.63617891e-02f, -7.67948851e-02f, -9.41416472e-02f, -1.73355043e-02f, -2.65509076e-03f,
  2.80426699e-03f, 4.93313074e-02f, 3.90833206e-02f, -8.61173719e-02f, -6.91212639e-02f, -1.18704557e-01f, -3.91593622e-03f, -2.12006383e-02f, -5.62335290e-02f, -9.85635445e-02f,
  -4.26414572e-02f, 9.15178210e-02f, 3.36602367e-02f, 2.94942446e-02f, -2.14570612e-02f, -1.30024534e-02f, -4.07114178e-02f, 1.66746099e-02f, 9.56816413e-03f, 7.00992420e-02f,
  8.45551416e-02f, 1.09301694e-02f, 9.66592655e-02f, 6.25169724e-02f, 9.72205326e-02f, 1.18359737e-01f, 6.44117594e-02f, -1.29551934e-02f, 1.06739681e-02f, 2.58217137e-02f,
  -3.35219130e-02f, 3.22128832e-02f, -1.87179949e-02f, -7.13282265e-03f, 6.20144717e-02f, 5.26855923e-02f, 9.25031453e-02f, 6.30654301e-03f, -1.36966147e-02f, 8.91591683e-02f,
  8.38557854e-02f, -1.22380309e-01f, -4.88176681e-02f, -5.53419057e-04f, -3.53601538e-02f, -9.50670615e-02f, -1.36894528e-02f, -1.88442487e-02f, 7.40988329e-02f, 1.47401258e-01f,
  -5.78535497e-02f, -5.80917150e-02f, -6.96823075e-02f, -9.09088776e-02f, 4.25425395e-02f, 3.50926146e-02f, 4.83458005e-02f, -8.24933052e-02f, -9.80111212e-03f, -8.75710044e-03f,
  -1.01860277e-01f, 3.32742417e-03f, 8.03645467e-04f, 8.66836123e-03f, -1.48647488e-03f, -1.53474156e-02f, 7.33848438e-02f, 8.39423910e-02f, 1.68353261e-03f, -7.97624886e-02f,
  -6.52484447e-02f, 1.18136615e-01f, -1.35807216e-01f, 2.26989330e-04f, -7.21313655e-02f, 2.79502664e-02f, -4.94930968e-02f, -4.42820368e-03f, -8.17340240e-02f, 1.22334726e-01f,
  -4.12250822e-03f, 3.78069356e-02f, 6.88782632e-02f, 9.57793593e-02f, 1.58509195e-01f, 7.55157024e-02f, 1.20686581e-02f, -2.51022931e-02f, -1.17097706e-01f, 4.68706852e-03f,
  2.88267434e-01f, 1.39462322e-01f, 1.51946366e-01f, 1.49994999e-01f, -1.57045648e-01f, 6.65934160e-02f, 2.69580811e-01f, 4.29424047e-02f, 1.95849553e-01f, -8.40547010e-02f,
  -1.23765357e-01f, 2.70729542e-01f, 2.76486129e-02f, -5.59078641e-02f, -7.76690468e-02f, -1.38060525e-01f, -6.47782609e-02f, 7.50287101e-02f, 6.70203194e-02f, 1.59943681e-02f,
  5.48221841e-02f, -1.45390183e-01f, -1.22435369e-01f, -1.16357639e-01f, -4.62211370e-02f, 4.16352525e-02f, -1.81929722e-01f, -3.17457393e-02f, -1.02323472e-01f, 6.76473752e-02f,
  4.85191261e-03f, -1.73285123e-04f, -1.09447308e-01f, -3.99940088e-02f, -1.14509054e-01f, 6.80093654e-03f, 6.69813603e-02f, -5.28687565e-03f, -5.03201783e-02f, -1.32638123e-02f,
  4.21603434e-02f, 1.72168966e-02f, 6.26785979e-02f, 4.24530171e-03f, 3.95372137e-02f, -2.15169042e-02f, -2.41906829e-02f, -3.58663313e-02f, -2.79903691e-03f, 2.98522878e-02f,
  2.57388707e-02f, -4.25604768e-02f, 2.17845906e-02f, 4.94595850e-03f, -4.33850251e-02f, 8.05742815e-02f, -2.89990157e-02f, 2.56661829e-02f, -5.31446338e-02f, -2.32608188e-02f,
  2.38647629e-02f, 1.60100814e-02f, 8.47780108e-02f, -5.55702262e-02f, -4.33453592e-03f, -2.16082465e-02f, 3.16817164e-02f, -9.15006455e-03f, -7.67245293e-02f, -2.16608904e-02f,
  -5.68713471e-02f, -3.11424527e-02f, -3.01680453e-02f, 6.93726763e-02f, 2.58783437e-02f, 8.32633451e-02f, 1.04587220e-01f, 5.94273210e-02f, 6.67075962e-02f, -6.73468187e-02f,
  -1.37837138e-02f, 1.13924637e-01f, -6.51517585e-02f, 3.77616892e-03f, 1.75668463e-01f, -9.44356993e-02f, 9.30414274e-02f, 1.25541404e-01f, -3.09617203e-02f, 4.82060090e-02f,
  -1.42535567e-01f, -2.71742083e-02f, -9.77749676e-02f, -4.36276458e-02f, -2.04854943e-02f, -8.21779296e-02f, -2.96371914e-02f, 8.46581906e-02f, -1.04597293e-01f, 1.72405615e-02f,
  1.77439228e-02f, -1.59864109e-02f, -2.54746862e-02f, 4.50860150e-02f, -1.05974495e-01f, 1.68139357e-02f, 9.55840722e-02f, -5.81798926e-02f, -1.10253401e-01f, 1.54788494e-02f,
  -1.50807798e-01f, -4.85174060e-02f, 2.60709804e-02f, -5.20359725e-02f, -1.01871513e-01f, 7.90913105e-02f, -1.77337471e-02f, -2.87410207e-02f, 4.07006852e-02f, -2.84285378e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.23707271e-01f, 3.84375826e-02f, -2.92514443e-01f, -1.48854107e-01f, -1.70598343e-01f, -4.01205063e-01f, -4.18863930e-02f, -5.38002811e-02f, -5.52021451e-02f, 2.26898104e-01f,
  4.95902859e-02f, -4.34939042e-02f, 1.67416498e-01f, 6.25604168e-02f, -1.70249954e-01f, 2.59721071e-01f, -1.79644614e-01f, -6.06937185e-02f, 1.07588843e-01f, -6.58518225e-02f,
  -3.17387879e-02f, 1.07020572e-01f, -9.36733931e-02f, 1.46400049e-01f, -1.32453308e-01f, 2.88305096e-02f, 8.50230679e-02f, -4.73053902e-02f, -1.17425978e-01f, -1.94687974e-02f,
  -1.89608306e-01f, -8.82394761e-02f, -6.75354898e-02f, -1.24130495e-01f, -1.38002679e-01f, -1.01286098e-01f, -1.10656790e-01f, -7.46151805e-02f, 2.69250129e-03f, -8.42006505e-02f,
  -1.50238387e-02f, -1.39367650e-04f, 7.28486329e-02f, 6.59655705e-02f, 6.73118830e-02f, 7.47260521e-04f, -1.88825454e-03f, -1.51547849e-01f, 1.06626652e-01f, -4.50133756e-02f,
  -1.09835185e-01f, 5.17619913e-03f, -2.03077067e-02f, 1.98647901e-02f, -6.64369911e-02f, -5.94618320e-02f, -2.39674579e-02f, 3.34222093e-02f, -1.19921796e-01f, -7.67204165e-02f,
  7.35067874e-02f, 1.15493938e-01f, -4.03327495e-02f, -7.79604539e-03f, 2.97458041e-02f, -5.95081486e-02f, -1.06103569e-02f, -6.71356842e-02f, 1.62990279e-02f, -1.49235064e-02f,
  -5.13858767e-03f, -1.14543969e-02f, 4.00643013e-02f, -7.28884432e-03f, -1.07557252e-01f, -2.87794545e-02f, 2.96256728e-02f, 1.19860945e-02f, -1.39550474e-02f, -3.03909238e-02f,
  5.70789026e-03f, -9.40307006e-02f, -1.14183836e-01f, 1.23752570e-02f, 3.33000384e-02f, 1.39919832e-01f, 1.15367785e-01f, -8.10110718e-02f, 4.00791019e-02f, 6.73609450e-02f,
  -2.86425114e-01f, -3.09270650e-01f, 5.24040312e-02f, -6.08343892e-02f, -1.81345865e-02f, -6.30099922e-02f, -1.78018883e-02f, 1.11883231e-01f, -8.14004466e-02f, -4.32263389e-02f,
  -6.77738115e-02f, -2.66086729e-03f, -9.17865634e-02f, 7.25093111e-02f, 1.19901121e-01f, 2.47259922e-02f, 4.03447589e-03f, -1.38923163e-02f, -1.21725440e-01f, 6.55512884e-02f,
  -9.30969045e-02f, -7.48733431e-02f, 1.93663031e-01f, 2.80311517e-02f, 1.57172885e-02f, 9.40918475e-02f, -1.20358571e-01f, -2.98990663e-02f, -1.19620956e-01f, 5.86927645e-02f,
  2.12543413e-01f, -2.08056733e-01f, 1.07489541e-01f, 1.15864851e-01f, 4.82722260e-02f, 5.79285668e-03f, 8.65854323e-02f, -8.62831995e-02f, -6.58734888e-02f, -8.06588978e-02f,
  7.57416710e-02f, 2.78276242e-02f, -2.20912881e-02f, -1.83550548e-03f, 1.64942190e-01f, -8.83230120e-02f, 1.86918527e-02f, 3.60282287e-02f, 1.23763643e-02f, -1.05757117e-02f,
  7.09045082e-02f, -7.08430335e-02f, 1.46569729e-01f, 4.94499281e-02f, 1.71514854e-01f, 5.53739164e-03f, 8.08493351e-04f, 2.13066518e-01f, -5.70772141e-02f, 1.10895351e-01f,
  9.68034491e-02f, -1.39138522e-02f, 1.16847761e-01f, -9.72587708e-03f, -4.02464196e-02f, 5.92266023e-02f, 1.50991842e-01f, 5.84019460e-02f, -1.01119960e-02f, -5.53618781e-02f,
  -8.52420740e-03f, 1.68500636e-02f, -7.28873610e-02f, 8.94994140e-02f, -4.50772680e-02f, -6.93093315e-02f, -1.92150399e-02f, 8.62822980e-02f, 1.02801109e-02f, 5.68074360e-02f,
  3.84114273e-02f, -9.18793771e-03f, -4.95202914e-02f, 4.63989004e-02f, 6.09121146e-03f, -1.57229118e-02f, -3.72327715e-02f, 7.15948194e-02f, -2.59965062e-02f, -4.97439355e-02f,
  -4.36698459e-03f, -1.25005797e-01f, -7.50970915e-02f, -1.90675538e-03f, -5.73320091e-02f, -4.85079177e-02f, -8.16593040e-03f, -1.19511351e-01f, 3.77103947e-02f, -9.58113596e-02f,
  2.11021733e-02f, 9.29172710e-02f, -2.39710417e-02f, -6.35934547e-02f, 4.75631990e-02f, -5.87730035e-02f, 5.96264936e-02f, 2.20989119e-02f, 1.85512193e-02f, 1.29464956e-03f,
  -4.46655415e-02f, 1.02973580e-02f, -2.41793152e-02f, 1.34831443e-01f, -5.47252893e-02f, -2.99766809e-02f, -2.02207938e-02f, 1.61252078e-02f, 1.18200831e-01f, -2.31908839e-02f,
  -1.98870465e-01f, -1.97766781e-01f, -9.30391774e-02f, 3.09280609e-03f, -1.67494789e-02f, -5.23240604e-02f, 4.68215793e-02f, -3.93961109e-02f, -4.03715856e-02f, -2.09009610e-02f,
  7.40554696e-03f, 1.40070058e-02f, -1.15371391e-01f, 3.31807509e-02f, -2.24274807e-02f, -8.40282161e-03f, 5.63443266e-02f, 5.21283736e-03f, -3.08715459e-02f, -3.95696685e-02f,
  7.24094436e-02f, -1.06166683e-01f, 7.07233995e-02f, -3.70128942e-03f, -7.56902322e-02f, 7.14920610e-02f, -2.55955588e-02f, -5.51705360e-02f, -7.07293302e-02f, -7.28535429e-02f,
  5.08805364e-03f, 2.46609285e-01f, 1.05727278e-01f, 1.77424937e-01f, -9.59132332e-03f, -3.61621350e-01f, -1.53889403e-01f, 1.23271748e-01f, -3.15173902e-02f, 1.20365851e-01f,
  -6.76406920e-02f, 1.40438527e-01f, 3.74109074e-02f, -7.41387978e-02f, -2.10036650e-01f, -3.48264813e-01f, -4.13295478e-02f, -9.11495090e-02f, -7.82674551e-02f, 1.71991929e-01f,
  2.83475798e-02f, -8.86687934e-02f, 9.26623866e-02f, 4.73740436e-02f, 6.72941804e-02f, 2.23649457e-01f, 1.52597308e-01f, 1.16788492e-01f, 1.65109426e-01f, -7.17834532e-02f,
  -1.17669307e-01f, -1.32589717e-03f, 2.07972769e-02f, -4.62571345e-02f, 1.94688831e-02f, 6.12478657e-03f, 4.40997146e-02f, -3.83327343e-02f, 3.20483744e-02f, -9.94657353e-02f,
  6.16983771e-02f, 1.00941490e-02f, -6.05062656e-02f, -2.54147556e-02f, 1.06152594e-02f, -1.89769035e-03f, 2.66846158e-02f, 2.83434000e-02f, -4.14496958e-02f, 5.01010753e-02f,
  6.69768900e-02f, 5.98646291e-02f, 3.11011095e-02f, 3.80894616e-02f, -5.15770093e-02f, 5.88517934e-02f, -1.39749572e-01f, -5.24242129e-03f, 3.63833457e-02f, 2.83808634e-02f,
  5.40247522e-02f, -2.68696733e-02f, -2.86328327e-02f, -1.85677484e-02f, -5.81987947e-02f, 4.85113040e-02f, 3.44986580e-02f, -2.47664080e-04f, -2.46080961e-02f, 1.29006980e-02f,
  1.15609363e-01f, 4.33422392e-03f, -4.69718091e-02f, 1.03725912e-02f, 1.14354109e-02f, 1.17808290e-01f, -7.34200282e-03f, -6.97435886e-02f, 2.07108562e-03f, -2.38156058e-02f,
  -8.84992164e-03f, -9.34091210e-02f, -3.03165074e-02f, -3.56193483e-02f, -1.39175549e-01f, 9.04294327e-02f, 4.78196293e-02f, -6.14275709e-02f, 3.94145101e-02f, -7.90535212e-02f,
  -3.69264483e-02f, 1.79223955e-01f, 6.26422390e-02f, -4.07516845e-02f, 2.96996031e-02f, -9.41783711e-02f, -2.62653921e-02f, 3.96601036e-02f, -6.12696959e-03f, 3.71614471e-02f,
  6.80331811e-02f, 7.43561238e-02f, -2.96371579e-02f, -7.47683495e-02f, -7.76909944e-03f, 6.85510272e-03f, 8.13288242e-02f, 6.12345859e-02f, 5.91621473e-02f, 1.59260482e-02f,
  1.71509549e-01f, -5.68590499e-02f, -3.69904377e-02f, -1.79202352e-02f, -2.10310481e-02f, 5.05070128e-02f, -6.81067631e-02f, 5.93291000e-02f, 3.51213701e-02f, -2.46781539e-02f,
  1.64546147e-01f, 9.32628363e-02f, -1.36320502e-01f, 5.41681089e-02f, -6.18871897e-02f, -5.26618883e-02f, -6.84946403e-02f, -5.50645739e-02f, -2.07077697e-01f, 8.43256488e-02f,
  1.36689335e-01f, -1.67951696e-02f, -7.22145021e-04f, 2.86098450e-01f, 2.76209623e-01f, -6.07471801e-02f, 2.63103664e-01f, 1.53678715e-01f, -1.44080237e-01f, 9.87889096e-02f,
  1.83042027e-02f, 3.93867195e-01f, 1.41258389e-01f, 1.34544611e-01f, 1.49091333e-01f, -1.20569468e-01f, 1.87291741e-01f, -1.61422729e-01f, 1.00881331e-01f, 1.21068969e-01f,
  6.40413389e-02f, -6.57875910e-02f, 2.71178689e-02f, -8.43473077e-02f, 8.88136309e-03f, -1.72333512e-02f, 2.19165385e-02f, -3.10156997e-02f, -5.15377037e-02f, -3.85653749e-02f,
  -4.34250757e-02f, -2.24126782e-02f, 9.75798592e-02f, -3.53516117e-02f, 6.68448536e-03f, -1.06467322e-01f, 4.57392037e-02f, -6.83312789e-02f, -8.80910270e-03f, 1.03507498e-02f,
  1.63085572e-03f, -3.42585146e-03f, -1.89945858e-03f, -8.02648254e-03f, -5.73889092e-02f, -4.58673276e-02f, -7.75287747e-02f, 1.92529245e-04f, -7.12668672e-02f, 8.85312930e-02f,
  1.32758841e-01f, -1.91927725e-03f, 1.98827172e-03f, -1.16458826e-01f, 6.81443289e-02f, 4.82983775e-02f, 6.54681623e-02f, -1.66095551e-02f, 3.16044539e-02f, 6.14608824e-02f,
  -3.19420248e-02f, -9.10677668e-03f, 6.38715997e-02f, 8.13895240e-02f, 6.01896308e-02f, -1.89591162e-02f, -5.99260256e-02f, 4.81361859e-02f, -4.61130813e-02f, -2.73260176e-02f,
  6.44868538e-02f, 2.92211492e-02f, -2.78743561e-02f, 4.52004597e-02f, 2.67587081e-02f, -1.07560925e-01f, 1.41906932e-01f, 1.68431960e-02f, -7.09401816e-02f, -2.46553179e-02f,
  1.08884238e-01f, 1.17100000e-01f, -5.57943620e-02f, 1.12635130e-02f, -3.56677324e-02f, 4.29766960e-02f, -2.19070795e-03f, 2.89471224e-02f, 1.01878382e-02f, 7.88433012e-03f,
  5.55243865e-02f, -4.98927832e-02f, -1.73287261e-02f, -6.14159964e-02f, -1.43512934e-01f, 3.32012288e-02f, 8.73172209e-02f, -6.36346415e-02f, -1.10452831e-01f, 7.56254867e-02f,
  -8.03563967e-02f, 1.34835544e-03f, 1.80691686e-02f, -5.19964732e-02f, 7.33997207e-03f, 3.66507620e-02f, -9.89499167e-02f, -3.96143161e-02f, 8.08988810e-02f, -1.01488186e-02f,
  -1.40045300e-01f, -4.30465601e-02f, 1.74887955e-01f, -2.08391115e-01f, -3.64499092e-02f, -1.31410675e-03f, 4.87572625e-02f, -1.51202470e-01f, -1.50253341e-01f, -1.74527869e-01f,
  9.80154797e-02f, 9.80944373e-03f, 1.36410236e-01f, -1.73722416e-01f, 3.23311657e-01f, 7.14717135e-02f, -1.61022499e-01f, -4.58289087e-02f, 2.59880209e-03f, -2.39852801e-01f,
  -4.09517772e-02f, -1.75043002e-01f, 1.20960467e-01f, -1.66279703e-01f, -8.33519921e-02f, -1.45329878e-01f, 9.33799818e-02f, 1.00731611e-01f, -8.42618719e-02f, 8.84955898e-02f,
  -1.92513689e-01f, -1.83368742e-01f, -8.97117257e-02f, -3.82301062e-02f, -2.94882674e-02f, -8.37181434e-02f, 4.05690670e-02f, 1.03859089e-01f, -7.08884671e-02f, -1.10362833e-02f,
  7.41439164e-02f, -7.57898716e-03f, -1.69932097e-01f, 3.07986401e-02f, -1.42049611e-01f, 2.48782579e-02f, -5.28646894e-02f, -4.55601774e-02f, 4.66043800e-02f, 5.50259929e-03f,
  6.07116595e-02f, -1.02843239e-03f, -4.80428785e-02f, -1.28133921e-02f, 2.35572401e-02f, -7.65176415e-02f, 2.72178911e-02f, 1.62245929e-01f, -7.81550780e-02f, -1.36985168e-01f,
  5.73708341e-02f, 4.48601395e-02f, 1.50434271e-01f, 9.53318775e-02f, 4.82505001e-02f, -7.61944428e-02f, 3.28710373e-03f, 3.13950479e-02f, 2.05661859e-02f, -1.36482656e-01f,
  4.46569128e-03f, -7.77086169e-02f, -5.16233742e-02f, -3.71115096e-03f, -7.91568123e-03f, 2.05357783e-02f, -1.05980178e-02f, -3.50786969e-02f, 9.18292329e-02f, 1.22829927e-02f,
  -2.17580833e-02f, 9.70494654e-03f, -8.81511252e-03f, -2.39905193e-02f, 1.20145410e-01f, 7.18481839e-03f, -2.51041036e-02f, 5.86349852e-02f, -1.58126056e-01f, -3.68762314e-02f,
  -1.99850023e-01f, -2.13220701e-01f, 1.46920951e-02f, -2.36033220e-02f, -4.92524989e-02f, -5.73683977e-02f, -2.78250035e-02f, -2.25357227e-02f, -7.12435171e-02f, -6.57816902e-02f,
  -7.23745581e-03f, -3.77954394e-02f, -2.04188004e-03f, 2.63809357e-02f, 5.19255362e-02f, -9.25117731e-02f, -4.44683321e-02f, 6.03864528e-03f, -7.17656128e-03f, 1.80686265e-02f,
  -3.42143252e-02f, 3.46459150e-02f, 6.90906346e-02f, -1.31766856e-01f, -1.91993153e-04f, -8.14958941e-03f, -6.00766279e-02f, 8.40823054e-02f, 1.94408316e-02f, -1.94497108e-02f,
  1.64306238e-01f, -3.27786282e-02f, -7.88855702e-02f, 4.54085469e-02f, -7.66665861e-02f, -2.41210610e-01f, -1.74158856e-01f, 1.53366745e-01f, -1.74760655e-01f, -2.34362617e-01f,
  -9.71415080e-03f, -1.21407397e-01f, -8.32659602e-02f, 3.58608179e-02f, 2.52109438e-01f, -1.86506033e-01f, 1.35799646e-01f, -4.49542701e-02f, 1.88522004e-02f, 1.76324368e-01f,
  2.53663749e-01f, 2.18490005e-01f, 2.09790558e-01f, 3.70108783e-01f, 1.14122108e-01f, 1.23627149e-01f, 1.87532336e-01f, 1.21025331e-01f, 2.43515208e-01f, 9.74848494e-02f,
  -8.60082079e-03f, -2.10689120e-02f, -8.59283004e-03f, -2.18620077e-02f, 1.56627200e-03f, 7.04007670e-02f, 6.36745691e-02f, -2.14862972e-02f, -1.81129538e-02f, -9.10716951e-02f,
  -1.27782449e-02f, 5.43713681e-02f, 6.37995750e-02f, 1.94185618e-02f, 7.35207833e-03f, -5.36333350e-03f, 2.25117207e-02f, -2.90888902e-02f, -8.13494176e-02f, -1.64162237e-02f,
  -3.23418006e-02f, -1.53678849e-01f, 2.32939869e-02f, -5.53884991e-02f, -6.36487305e-02f, 1.82274785e-02f, 1.41741289e-02f, 7.23784976e-03f, -1.88352898e-01f, 1.33942179e-02f,
  6.03962056e-02f, 2.11195517e-02f, -3.08526475e-02f, -2.69618388e-02f, -3.97935659e-02f, -7.43592456e-02f, 2.72816420e-02f, -4.33138795e-02f, 1.04684912e-01f, -2.81819198e-02f,
  -1.11147270e-01f, 3.86282206e-02f, 2.13149302e-02f, -1.09787509e-01f, 3.58307585e-02f, -1.69045702e-02f, 6.14049882e-02f, -4.34496216e-02f, -5.51306270e-02f, -3.44622415e-03f,
  -4.39263172e-02f, -8.61421577e-04f, -2.90128160e-02f, 9.81000811e-02f, 1.10193696e-02f, -1.09000236e-01f, 4.42226306e-02f, -5.21619106e-03f, -2.02753730e-02f, 1.11348584e-01f,
  -8.90999287e-02f, 1.02594562e-01f, -4.24669776e-03f, -5.28484210e-02f, -2.99568027e-02f, 3.58777978e-02f, 8.97358432e-02f, 4.87462580e-02f, 1.03767291e-02f, -4.88692001e-02f,
  9.72003192e-02f, 9.21824276e-02f, -9.31085844e-04f, -1.11552523e-02f, 3.62449605e-03f, 1.72370151e-02f, -4.79791537e-02f, 6.72638370e-03f, 2.09100097e-02f, -1.66539219e-03f,
  -4.50583436e-02f, -1.73318043e-01f, 6.83124438e-02f, -1.45642906e-01f, -1.22939441e-02f, -3.61432396e-02f, 2.73390152e-02f, 6.32705763e-02f, 6.80336803e-02f, -4.97937463e-02f,
  -1.22480169e-01f, 1.60887778e-01f, 1.28192874e-02f, 8.84424374e-02f, 7.63860866e-02f, 2.10508719e-01f, 4.28222567e-02f, 6.30850196e-02f, 7.14524463e-02f, 4.05727141e-02f,
  1.91641733e-01f, 1.42658621e-01f, 1.10853299e-01f, 1.72885850e-01f, 2.43008435e-01f, 1.92469180e-01f, 7.70365596e-02f, -3.80917042e-02f, -8.59238058e-02f, -3.82792056e-02f,
  -1.21671945e-01f, -4.53927107e-02f, 1.35835022e-01f, -4.97699566e-02f, 8.93085077e-02f, -7.92308301e-02f, 4.74074148e-02f, 1.00322649e-01f, 1.29034221e-01f, 1.14147194e-01f,
  -4.81455326e-02f, -1.31932274e-01f, -1.39601454e-01f, -5.26037589e-02f, -8.21610168e-02f, -6.36959299e-02f, -1.20472290e-01f, -1.94883328e-02f, 5.41919842e-02f, -5.40254544e-03f,
  8.23844410e-03f, -3.79174612e-02f, -8.74408614e-03f, 2.78391019e-02f, -2.51188856e-02f, 7.35536823e-03f, 8.56163651e-02f, 1.01835705e-01f, 2.17524469e-02f, 1.18638948e-02f,
  3.42530236e-02f, 4.36362028e-02f, 4.67929728e-02f, 7.10285380e-02f, 1.30933926e-01f, 1.32268175e-01f, -2.73479372e-02f, -3.98928076e-02f, 4.50510345e-02f, 1.02292933e-02f,
  1.32454606e-02f, 1.38221169e-02f, -1.18153870e-01f, -9.19423550e-02f, 6.43180087e-02f, -7.41357654e-02f, -5.14098443e-04f, 1.51550304e-02f, 1.90322045e-02f, 1.15555234e-01f,
  5.93887083e-02f, 6.95860535e-02f, 1.29198721e-02f, -1.21793719e-02f, -6.19785786e-02f, -3.00839618e-02f, -8.03661123e-02f, 4.76581305e-02f, 8.63952339e-02f, 4.47538383e-02f,
  7.80365616e-02f, 2.25227401e-02f, 6.09002076e-02f, -7.81594515e-02f, -2.99745090e-02f, -4.26218957e-02f, -8.27960297e-02f, 1.41293004e-01f, 8.08833241e-02f, -1.42981080e-04f,
  1.51056215e-01f, 1.20591268e-01f, -4.56418246e-02f, -7.95324370e-02f, -6.43806681e-02f, -2.04132907e-02f, -6.37868568e-02f, 2.63857413e-02f, 1.11599185e-01f, -2.30285153e-02f,
  -1.10146575e-01f, 2.52926201e-02f, 5.30226342e-03f, -5.31324707e-02f, 6.56381575e-03f, 1.09029777e-01f, -7.84654357e-03f, -5.37193976e-02f, 1.12371035e-01f, 5.17435521e-02f,
  4.93510105e-02f, 2.24641385e-03f, 4.06785272e-02f, 8.21703523e-02f, -3.85599509e-02f, 8.23129937e-02f, -3.18178050e-02f, -6.70739189e-02f, 1.29358862e-02f, 6.07484803e-02f,
  -3.72705877e-01f, 4.24736321e-01f, -1.60440862e-01f, 2.45923653e-01f, 6.25663325e-02f, 3.91845882e-01f, 3.22907805e-01f, 1.77002158e-02f, 1.49307713e-01f, 2.04306766e-01f,
  3.28546762e-02f, 1.52025204e-02f, -5.44444285e-02f, 1.93275720e-01f, 6.12571537e-02f, 2.10778847e-01f, 2.99162358e-01f, 1.35166556e-01f, -5.06767258e-02f, -6.57743439e-02f,
  -1.78172901e-01f, 1.87334850e-01f, -5.91152906e-02f, -1.55668572e-01f, -1.25235766e-01f, -2.30052784e-01f, -6.76425844e-02f, -2.35608041e-01f, -5.73477633e-02f, 9.03538615e-02f,
  4.62591387e-02f, -1.73580259e-01f, -9.21730325e-02f, -5.12293763e-02f, -4.51962650e-02f, -1.96201801e-02f, -1.06740758e-01f, 2.89907213e-02f, -1.35502532e-01f, 3.45217474e-02f,
  -1.95217505e-02f, -7.58794844e-02f, 3.41276675e-02f, 5.07625975e-02f, 8.41676965e-02f, 6.65143877e-03f, 2.78959442e-02f, 3.31390165e-02f, 3.26295234e-02f, -4.31759432e-02f,
  -2.14378256e-02f, 4.78957035e-02f, 1.26720835e-02f, 3.48749459e-02f, -6.22808449e-02f, 1.69630006e-01f, 1.10283725e-01f, 1.74828451e-02f, 3.81263196e-02f, 1.07246198e-01f,
  -7.19227493e-02f, -4.67467494e-02f, 2.78964788e-02f, -2.50717215e-02f, 6.57989979e-02f, 5.11523113e-02f, -2.43468788e-02f, -4.20302637e-02f, -1.35638982e-01f, 9.85690057e-02f,
  1.03123151e-02f, -3.83639112e-02f, 5.52176386e-02f, 1.04411291e-02f, -4.56897467e-02f, 9.87466127e-02f, -9.35931597e-03f, -9.05399323e-02f, 1.01304606e-01f, 6.04995787e-02f,
  1.54723534e-02f, 2.79126666e-03f, 6.53237551e-02f, -9.46042910e-02f, 5.21126240e-02f, -1.24013610e-01f, -1.37136197e-02f, -9.41385329e-02f, -1.49178766e-02f, -5.64070158e-02f,
  1.59621745e-01f, 1.03562340e-01f, -2.22037896e-03f, 4.72405925e-02f, -1.77343246e-02f, 6.57919571e-02f, 2.02380139e-02f, 6.88953176e-02f, 1.25809051e-02f, -2.33902968e-02f,
  -8.74867588e-02f, -4.54693511e-02f, 8.21692795e-02f, -9.96918511e-03f, 2.85439454e-02f, 1.25927001e-01f, -5.64062260e-02f, -2.33864207e-02f, 6.88550323e-02f, -5.89522496e-02f,
  1.96409710e-02f, -6.82563037e-02f, -9.54809692e-03f, -2.64027482e-03f, -4.33885269e-02f, -3.66674140e-02f, 9.76149514e-02f, -1.47369042e-01f, 1.79564320e-02f, 2.81506162e-02f,
  2.73945294e-02f, -1.55725822e-01f, -7.78417662e-02f, -7.72156194e-02f, -5.41242510e-02f, -1.37397364e-01f, -4.23306562e-02f, -2.59152055e-01f, -8.37045088e-02f, -1.36248380e-01f,
  -9.03994292e-02f, 1.52944937e-01f, 1.75087005e-01f, -2.34716818e-01f, 3.94340158e-01f, 1.72504380e-01f, -1.79998234e-01f, -5.05720712e-02f, 4.88487594e-02f, -1.83510840e-01f,
  -8.12840238e-02f, -2.27086127e-01f, 3.67327854e-02f, -2.12576792e-01f, -2.36600205e-01f, -1.44988641e-01f, -2.16042642e-02f, 4.55747135e-02f, -1.92574248e-01f, 1.75627670e-03f,
  7.85943400e-03f, -4.28815745e-02f, 8.15003216e-02f, 7.30133504e-02f, 4.69901003e-02f, 3.20377052e-02f, -1.98331997e-02f, 1.32700697e-01f, 8.19270834e-02f, 1.34146481e-03f,
  -2.36399099e-02f, -4.86768596e-02f, -5.87844066e-02f, 1.18640937e-01f, -4.90781777e-02f, 3.68401036e-02f, 5.96280396e-02f, 6.68315515e-02f, -5.14238626e-02f, 3.29278670e-02f,
  -2.38325745e-02f, -1.62658207e-02f, -2.81514041e-02f, -6.57034144e-02f, 6.37091324e-02f, -9.18856710e-02f, 1.18701272e-01f, 1.15808271e-01f, 1.40819266e-01f, -2.32909136e-02f,
  -8.54133591e-02f, -3.47984419e-03f, 4.00779024e-02f, -1.82079803e-02f, -2.29470409e-03f, -7.37315640e-02f, -8.47202092e-02f, 9.65590775e-03f, -3.48507538e-02f, 2.07358114e-02f,
  3.62336487e-02f, 5.94591871e-02f, -7.77335092e-03f, 5.14958352e-02f, -9.61355492e-02f, -1.87876876e-02f, 9.82757583e-02f, -4.02336940e-02f, -4.11096849e-02f, -5.11988327e-02f,
  8.09009224e-02f, 6.02742471e-02f, 1.39247125e-03f, 1.90931894e-02f, 1.28117250e-02f, 1.17711790e-01f, 1.49994018e-03f, -1.63899772e-02f, 2.14637984e-02f, -4.13525663e-02f,
  -4.09895591e-02f, -1.58886181e-03f, -4.43593264e-02f, 1.02303833e-01f, 3.26373521e-03f, 5.19487299e-02f, 3.08540147e-02f, -7.62234628e-02f, -1.35328416e-02f, 5.19133024e-02f,
  -1.01431780e-01f, 3.05078011e-02f, -2.28828378e-02f, -7.93983042e-02f, -4.16703671e-02f, -1.31265700e-01f, -1.81365982e-02f, -4.23270427e-02f, 6.24825954e-02f, 1.23330513e-02f,
  2.93277800e-02f, 7.50378594e-02f, -3.09695844e-02f, 1.96133181e-02f, 6.54798513e-03f, 7.48946220e-02f, 4.15256731e-02f, -5.00056800e-03f, 7.83499330e-02f, 4.54171263e-02f,
  2.73524106e-01f, -3.56404632e-01f, 5.73651828e-02f, 3.50936115e-01f, 2.56224424e-01f, -1.71480775e-02f, -1.78686082e-02f, 1.02080375e-01f, 1.12080693e-01f, -2.55971789e-01f,
  5.07002771e-02f, -8.62980336e-02f, -2.45112672e-01f, 9.05203074e-02f, 1.25699967e-01f, -4.49355990e-02f, 2.28581131e-02f, 2.21326612e-02f, 6.23165220e-02f, 1.46777183e-01f,
  1.74616769e-01f, 9.83000100e-02f, 7.18891397e-02f, -1.12863341e-02f, -3.84985073e-03f, 1.29169822e-01f, 1.42530903e-01f, 1.82053968e-02f, 8.84690210e-02f, 1.35613163e-03f,
  -4.04470302e-02f, 8.73131901e-02f, -7.64679313e-02f, -1.02648266e-01f, -4.61704880e-02f, -1.66289598e-01f, -1.28789499e-01f, 2.43050922e-02f, 1.63083803e-02f, -2.37863958e-02f,
  -4.82503213e-02f, 1.47311175e-02f, 1.95705872e-02f, 1.98953715e-03f, 1.09236967e-02f, 1.00360438e-01f, 6.96898997e-02f, 1.09576866e-01f, 5.30076362e-02f, 7.12085189e-03f,
  -2.74030641e-02f, 5.20025603e-02f, 2.14322694e-02f, 7.02269748e-02f, 6.13643490e-02f, 8.23981836e-02f, 3.30770737e-03f, 8.78673941e-02f, -5.30863740e-02f, 1.10620625e-01f,
  -1.45995163e-03f, -1.86682604e-02f, 4.17101271e-02f, 4.60616648e-02f, 3.76974232e-02f, -6.58688173e-02f, 1.16954523e-03f, 9.05100256e-03f, -8.59017000e-02f, -4.96648513e-02f,
  -2.07679011e-02f, 7.63260713e-03f, -3.36707570e-02f, -1.25057548e-01f, -3.79449688e-02f, -1.98322572e-02f, -8.14000443e-02f, 1.45813404e-02f, 2.64614001e-02f, 1.33978590e-01f,
  1.44783622e-02f, 1.44911632e-02f, -7.69253969e-02f, 1.82249293e-01f, 3.53685655e-02f, 5.18718502e-03f, -3.33096134e-03f, 4.71038409e-02f, 8.45665559e-02f, 1.39056297e-03f,
  -3.47345203e-01f, -2.97839701e-01f, -3.49806226e-03f, -4.20772396e-02f, -4.40696394e-03f, -2.67395731e-02f, -5.77414874e-03f, 5.02016619e-02f, -9.81055498e-02f, 7.05126002e-02f,
  -7.44654238e-02f, 8.85424092e-02f, -7.00194240e-02f, 3.73463184e-02f, -5.28460070e-02f, -3.83476280e-02f, 2.28772848e-03f, -1.55734345e-01f, 3.44240554e-02f, 6.93943128e-02f,
  -4.64513898e-02f, -1.72577109e-02f, -1.20688779e-02f, 2.72619631e-02f, 1.64427608e-02f, -6.38796762e-02f, 1.13107912e-01f, -1.10708408e-01f, -6.81931525e-03f, -4.96526957e-02f,
  -6.42555952e-01f, 3.48444074e-01f, 1.99695807e-02f, -6.56546354e-02f, -1.39594331e-01f, -3.44257839e-02f, 4.02475111e-02f, 4.20356840e-02f, -1.22419313e-01f, 1.91805940e-02f,
  -8.95595104e-02f, -2.59665344e-02f, 1.00416787e-01f, 4.86892574e-02f, -1.56032920e-01f, 1.37481824e-01f, 6.83398871e-03f, -2.35637743e-02f, 5.89755662e-02f, -3.69352363e-02f,
  -4.81115393e-02f, 5.05070668e-03f, 5.57344705e-02f, 2.60522366e-01f, -8.46342221e-02f, -2.67065130e-03f, -1.01941146e-01f, 4.58299741e-02f, 2.11231615e-02f, 1.80168971e-02f,
  -8.97168815e-02f, -9.53028426e-02f, -2.18913957e-01f, -1.96966544e-01f, -1.42457858e-01f, -1.66758038e-02f, -6.89175203e-02f, -7.09528401e-02f, -2.72958409e-02f, -6.43402934e-02f,
  -1.07870936e-01f, -5.36143221e-02f, 2.32401155e-02f, 5.87144904e-02f, -1.26679048e-01f, -3.86270359e-02f, 1.20448962e-01f, -1.91900525e-02f, 5.42430840e-02f, 1.63613930e-02f,
  4.02190685e-02f, -6.19415566e-02f, -4.69361395e-02f, 4.53686565e-02f, -9.10675444e-04f, 7.23960400e-02f, 2.53062174e-02f, 4.46695201e-02f, -7.94467106e-02f, -5.24762496e-02f,
  5.12834080e-02f, 1.00548640e-01f, 9.40547138e-02f, -5.18047735e-02f, -5.15244752e-02f, 1.05927303e-01f, 4.91253473e-02f, -1.38868362e-01f, -1.00916728e-01f, -8.77456367e-02f,
  -3.62319686e-02f, -7.27239007e-04f, 3.26683000e-02f, 1.61792357e-02f, -6.38632774e-02f, -2.95303036e-02f, -9.98252630e-02f, -8.61906409e-02f, 9.25383270e-02f, 6.79243207e-02f,
  -1.61652356e-01f, -5.59163503e-02f, 3.79172489e-02f, 4.05540429e-02f, -4.07367162e-02f, 2.07882375e-02f, -2.10778508e-03f, 5.60241863e-02f, 4.70048934e-02f, 1.21365841e-02f,
  -2.03019276e-01f, -1.79635599e-01f, -1.91328302e-01f, -9.03047025e-02f, -5.75877838e-02f, -6.54633492e-02f, -6.21545427e-02f, -3.36022452e-02f, -1.25647694e-01f, -8.72141123e-02f,
  -1.27676263e-01f, 4.84290031e-05f, 1.96448099e-02f, -7.00265318e-02f, -8.81055649e-03f, -2.70510800e-02f, -1.00088045e-02f, -5.84996082e-02f, -8.89312401e-02f, 3.18398960e-02f,
  -2.17029080e-02f, -6.53779879e-02f, 1.71158046e-01f, 5.40425405e-02f, -5.71889207e-02f, 6.38721809e-02f, -1.13050655e-01f, -1.13869719e-01f, -4.97351866e-03f, -3.50840054e-02f,
  -1.93024322e-01f, 2.99141169e-01f, -7.07573518e-02f, -3.11752290e-01f, 1.49618104e-01f, -1.01350002e-01f, -2.37984762e-01f, -7.89455622e-02f, -1.65590361e-01f, -1.48670912e-01f,
  -1.57404676e-01f, -2.71150563e-02f, 1.04053445e-01f, -1.88384905e-01f, -9.62618589e-02f, 6.04741797e-02f, -3.12959343e-01f, -2.44069874e-01f, 1.63679078e-01f, -1.27186298e-01f,
  -1.30858449e-02f, -8.29920545e-02f, 2.53889542e-02f, 1.45469561e-01f, -4.10461836e-02f, -3.00458036e-02f, -2.55416811e-01f, 1.05561003e-01f, -1.41248316e-01f, -2.26674639e-02f,
  4.31693010e-02f, -9.65981632e-02f, 3.02942023e-02f, 4.32159267e-02f, -1.48926854e-01f, -1.05819628e-01f, 5.29580079e-02f, 7.62515143e-02f, -5.81278689e-02f, -7.64478371e-03f,
  5.04667275e-02f, 2.42020451e-02f, -3.23501276e-03f, 6.72299787e-03f, -3.94171402e-02f, -1.73760876e-02f, 6.75501395e-03f, 1.09679043e-01f, -6.73817918e-02f, -8.13954137e-03f,
  1.23199411e-02f, -4.34041023e-02f, -2.01128311e-02f, -1.61777034e-01f, -8.07235986e-02f, -5.02617396e-02f, -6.97707161e-02f, -2.57793050e-02f, -9.09960344e-02f, -9.49791893e-02f,
  -1.93910543e-02f, -5.62654324e-02f, -9.38397553e-03f, 1.72484871e-02f, 2.94269957e-02f, 5.82726300e-02f, -3.45995612e-02f, -6.27182424e-02f, 7.89545998e-02f, 5.51161580e-02f,
  -8.77436027e-02f, -6.28989488e-02f, -3.97282802e-02f, -1.55099422e-01f, -5.07909246e-02f, 5.59285097e-02f, -1.36449942e-02f, 5.25572635e-02f, 5.94023354e-02f, 5.31029627e-02f,
  6.64892048e-02f, 1.08211599e-02f, 5.17897606e-02f, 2.57290117e-02f, -1.01417691e-01f, -6.17246702e-02f, -2.89258156e-02f, 1.71029698e-02f, 7.91047588e-02f, -9.03949142e-03f,
  -7.55627677e-02f, -2.52810150e-01f, 3.92171508e-03f, 4.00399342e-02f, 1.20434597e-01f, -3.76810873e-04f, 4.79136072e-02f, 5.69056682e-02f, -1.42375007e-01f, -1.33329025e-02f,
  -1.93249453e-02f, 2.76300311e-02f, -7.23948032e-02f, 1.19931689e-02f, 5.28665371e-02f, -7.70767555e-02f, -1.16643518e-01f, 3.32176238e-02f, -4.43944484e-02f, 2.72725374e-02f,
  3.20885517e-02f, -4.11580689e-02f, -1.15362242e-01f, -1.58839449e-01f, -1.17104262e-01f, -1.50740417e-02f, 1.36779072e-02f, -5.71622374e-03f, 2.05104984e-02f, 3.59963514e-02f,
  3.12338650e-01f, -1.57848969e-01f, -1.49165988e-01f, 1.13272227e-01f, 3.03292811e-01f, 1.09319687e-01f, 1.34811550e-01f, 1.39484733e-01f, 2.80985087e-01f, -1.26527831e-01f,
  6.39556348e-02f, -2.11826473e-01f, -1.02218501e-01f, -4.54729795e-02f, 1.25212118e-01f, -2.48226672e-01f, 9.41652209e-02f, -6.78256247e-03f, 7.20261484e-02f, 9.34649929e-02f,
  1.62583470e-01f, 1.21554948e-01f, -2.67666608e-01f, -5.32498956e-02f, 7.90844262e-02f, -1.94279656e-01f, -1.17256127e-01f, -1.27722144e-01f, -2.78144151e-01f, -1.42612711e-01f,
  -5.86745515e-03f, -4.08960320e-03f, -6.72432855e-02f, -9.00422409e-02f, -6.82552010e-02f, -1.00495949e-01f, -5.68404607e-02f, -2.19580859e-01f, 5.44962399e-02f, -1.67728648e-01f,
  -2.30678599e-02f, -4.83819842e-02f, -1.53902704e-02f, 3.40065248e-02f, 2.11287700e-02f, -1.97206046e-02f, -7.59505853e-02f, 1.89489499e-02f, -4.10359167e-02f, -6.01927470e-03f,
  3.05689480e-02f, -8.58913884e-02f, 1.15280494e-01f, -2.99430955e-02f, -6.81201667e-02f, -2.00744849e-02f, -9.36883837e-02f, -1.03656583e-01f, 6.65271878e-02f, -8.14707503e-02f,
  -1.39758652e-02f, 4.90899011e-02f, -2.85263807e-02f, -1.64018257e-03f, 3.84069677e-03f, -1.97762102e-02f, 7.01498985e-02f, 2.68234685e-02f, 1.17595948e-01f, 9.52502713e-02f,
  7.12538585e-02f, 3.25100869e-02f, 1.09661818e-01f, 4.22635712e-02f, -4.30724621e-02f, 7.92134628e-02f, 3.58816935e-03f, -8.97230580e-02f, 9.20613781e-02f, 1.98774952e-02f,
  4.38782386e-02f, 4.92730103e-02f, -3.40267681e-02f, -3.91528383e-02f, 1.99839715e-02f, -2.36524362e-02f, 8.64752755e-02f, -1.24450587e-03f, 8.45040083e-02f, 2.40026470e-02f,
  2.66865157e-02f, -1.43869042e-01f, -4.57526110e-02f, -1.18130231e-02f, -1.83464251e-02f, 1.35534689e-01f, 3.06746867e-02f, 1.39999669e-02f, -8.03462267e-02f, 1.08424788e-02f,
  9.67720002e-02f, -1.06420843e-02f, 1.31806359e-02f, -2.79551614e-02f, -1.34323314e-01f, 8.36722031e-02f, -8.41105431e-02f, 4.91722561e-02f, -7.25348368e-02f, -3.94729264e-02f,
  -3.78269260e-03f, 6.59928396e-02f, 1.43591706e-02f, 3.25346664e-02f, -1.54908122e-02f, -1.68545526e-02f, -1.33725628e-01f, -9.69276950e-02f, -2.28629038e-02f, -8.49786252e-02f,
  7.15293572e-04f, 1.24954462e-01f, -2.37147644e-01f, -5.74469790e-02f, -1.40606314e-01f, 1.74706608e-01f, 2.14356631e-01f, -1.04881898e-01f, -1.41987475e-02f, 2.40644395e-01f,
  1.34966999e-01f, 3.11695691e-02f, 1.93598568e-01f, 2.52116084e-01f, -4.68247794e-02f, 5.28314933e-02f, 2.60377467e-01f, 1.42761812e-01f, -8.25626776e-02f, 6.00544885e-02f,
  9.19705257e-02f, 2.95145452e-01f, 3.47225443e-02f, 1.33115239e-02f, 1.37437165e-01f, -2.70826817e-01f, 8.50895979e-03f, -1.55539468e-01f, 4.00668867e-02f, 9.21869129e-02f,
  8.03542808e-02f, -1.38276257e-02f, -6.56114891e-02f, -2.66829412e-02f, -3.82596105e-02f, 4.96387295e-03f, 5.42592444e-02f, -9.72963423e-02f, -3.65131944e-02f, -2.13121101e-02f,
  1.30312175e-01f, 1.96633544e-02f, 2.59009898e-02f, -4.22556922e-02f, -1.24602303e-01f, -3.16712856e-02f, -3.98592539e-02f, -4.59065326e-02f, -3.17764410e-04f, 7.34718516e-02f,
  -6.30309731e-02f, -5.21689691e-02f, 1.04542322e-01f, -6.29349053e-02f, 6.34638742e-02f, -2.43033879e-02f, -7.09455907e-02f, -5.19762048e-03f, -1.29111791e-02f, -1.15493955e-02f,
  -4.47867587e-02f, 9.40421522e-02f, 5.58846183e-02f, 7.88360601e-04f, -2.19608024e-02f, -8.46771970e-02f, 1.11368999e-01f, -6.41477332e-02f, -9.38162878e-02f, 8.57495397e-05f,
  -1.40941748e-02f, 6.55852780e-02f, 4.61650342e-02f, 1.13550492e-01f, 6.06869310e-02f, 5.01658581e-02f, 1.12914352e-03f, 7.68763795e-02f, 3.19844037e-02f, 3.56333964e-02f,
  -4.95395474e-02f, 1.80101898e-02f, -2.71732546e-02f, 9.66452956e-02f, 4.53320052e-03f, -1.12245440e-01f, 1.74631521e-01f, 8.80867094e-02f, -2.20577046e-02f, 1.08596817e-01f,
  1.37373865e-01f, 6.67866617e-02f, -1.39578959e-04f, -3.60969305e-02f, -1.26090035e-01f, 2.02988461e-02f, 2.07452830e-02f, 4.04935181e-02f, 2.03341190e-02f, -1.01371646e-01f,
  1.19332962e-01f, 7.90219307e-02f, 6.77561238e-02f, -4.48439047e-02f, -9.94561464e-02f, 1.26743257e-01f, 4.40349393e-02f, -1.08341642e-01f, -3.91811170e-02f, -1.00350983e-01f,
  -7.32861180e-03f, 5.44601865e-03f, 7.13877231e-02f, -9.21671540e-02f, 4.14909869e-02f, 4.29414473e-02f, -7.67649636e-02f, -6.49203034e-03f, 3.12529691e-02f, -6.83408603e-02f,
  2.36473471e-01f, 2.25216717e-01f, 2.64718294e-01f, 1.95821062e-01f, -1.28746435e-01f, -1.05346344e-01f, 4.70609330e-02f, 5.13054058e-02f, 1.35803640e-01f, 6.73257113e-02f,
  -1.19019397e-01f, 3.11386496e-01f, -1.48425847e-01f, 5.66271432e-02f, -3.63099247e-01f, -2.21153960e-01f, -1.71659306e-01f, 1.10758297e-01f, -6.56042527e-03f, -7.05692312e-03f,
  -2.28576034e-01f, -2.28794709e-01f, -1.41879752e-01f, -8.12687501e-02f, 1.48423567e-01f, 1.59255058e-01f, -2.14928940e-01f, 6.82106661e-03f, 1.46211073e-01f, -1.05781920e-01f,
  -4.80394252e-02f, -2.53231521e-03f, 1.13128506e-01f, 4.72918786e-02f, -1.17720895e-01f, -4.36093546e-02f, -1.43664535e-02f, -3.45145725e-02f, -9.54328924e-02f, 9.81577113e-02f,
  -5.63312620e-02f, 1.73330903e-02f, 8.45786184e-02f, 6.00057803e-02f, 8.90022889e-02f, 1.13440976e-01f, 2.43340991e-02f, -1.73484787e-01f, 4.90388833e-02f, 1.18063137e-01f,
  -9.95305087e-03f, 4.60533425e-02f, 1.96209177e-03f, -1.03944838e-01f, -4.77747992e-02f, 2.27513202e-02f, 3.20558511e-02f, 2.01968309e-02f, 1.15349784e-01f, 4.58434969e-03f,
  -2.88776066e-02f, -6.63351044e-02f, 2.37323027e-02f, 1.00775220e-01f, 5.93263172e-02f, -1.34947356e-02f, -5.22661116e-03f, -1.05356485e-01f, -2.84951571e-02f, -3.63384336e-02f,
  4.71432880e-03f, 5.05859181e-02f, -7.54023204e-03f, 2.37007868e-02f, -9.99336615e-02f, 5.34208193e-02f, -1.04867354e-01f, -6.63092434e-02f, -7.16546997e-02f, 3.17158215e-02f,
  7.55565017e-02f, -1.18620262e-01f, 7.42981806e-02f, -3.10390051e-02f, -3.37660871e-03f, 2.73159277e-02f, 8.34665745e-02f, 4.02738117e-02f, -2.65906565e-02f, -1.74970441e-02f,
  -2.63367116e-01f, -1.98009983e-01f, -1.40241429e-01f, 6.66586170e-03f, -9.73886922e-02f, 3.06714438e-02f, 2.06008665e-02f, 5.82704246e-02f, 6.16225181e-03f, -2.37113261e-03f,
  -6.95457608e-02f, -1.49181299e-02f, -1.20250612e-01f, 3.73037010e-02f, -1.33590132e-01f, -3.89395170e-02f, -1.40013382e-01f, -1.57603160e-01f, -4.70533520e-02f, -2.94311270e-02f,
  8.49841833e-02f, -8.86704326e-02f, -3.97695927e-03f, -9.61984694e-02f, -2.48900186e-02f, -6.97950572e-02f, 8.39174390e-02f, 2.89303493e-02f, 4.99374093e-03f, -9.32631642e-02f,
  2.47292563e-01f, -1.81289718e-01f, -1.96832508e-01f, 1.23296849e-01f, 6.66243136e-02f, 3.83424945e-02f, -1.18662797e-01f, 4.16916795e-02f, -1.41072005e-01f, -5.01082465e-02f,
  1.50334656e-01f, -1.29900649e-01f, -1.07739970e-01f, 2.24624276e-01f, 2.58526295e-01f, -1.56635568e-01f, 8.94161537e-02f, 3.85757796e-02f, -5.50952069e-02f, 7.63523281e-02f,
  7.87714645e-02f, 2.89330572e-01f, -4.13170345e-02f, 2.34817520e-01f, 1.47570655e-01f, 2.41324399e-02f, 1.87473506e-01f, -9.00780410e-02f, 1.60200685e-01f, -5.68525754e-02f,
  -8.37771744e-02f, -4.85389717e-02f, -6.68193772e-02f, -5.52594215e-02f, 4.65130284e-02f, 9.82984784e-04f, 1.73961353e-02f, -6.88407272e-02f, -4.00309823e-02f, -4.94426815e-03f,
  -5.22052981e-02f, -5.76990237e-03f, 4.40675505e-02f, 3.66540579e-03f, 1.26886904e-01f, -4.84764837e-02f, 4.01544459e-02f, -4.49018218e-02f, -5.51188812e-02f, 4.33356464e-02f,
  4.44951802e-02f, -1.03301100e-01f, -3.91623937e-02f, 1.29845338e-02f, 6.93260459e-03f, 2.83544026e-02f, -7.87345916e-02f, -3.70259173e-02f, -6.01005480e-02f, -6.43320754e-03f,
  2.27782764e-02f, -3.80490295e-04f, 3.03532612e-02f, -8.58280808e-02f, -2.12388318e-02f, -2.40199803e-03f, 4.73688282e-02f, 2.07505524e-02f, -2.63526440e-02f, -5.87192737e-02f,
  1.05126649e-01f, -1.51462872e-02f, -1.11120850e-01f, 4.58936095e-02f, 2.46776920e-02f, -6.28959835e-02f, -4.70357090e-02f, -1.07221594e-02f, 1.05141655e-01f, 1.10892005e-01f,
  -2.35610008e-01f, 1.65442988e-01f, -2.43554134e-02f, -3.06011941e-02f, -2.57262983e-03f, 6.19757809e-02f, 1.62726581e-01f, -2.42558736e-02f, -7.67647102e-02f, 1.42403124e-02f,
  2.70025097e-02f, 8.48291889e-02f, -4.29701954e-02f, -4.73935604e-02f, 2.95201316e-02f, 4.70686052e-03f, -4.58673537e-02f, 4.47025001e-02f, -9.51838866e-02f, 4.46290188e-02f,
  6.88657761e-02f, -3.22045013e-02f, 5.89942671e-02f, -1.82952341e-02f, 1.62852518e-02f, 9.52144340e-02f, 9.07194894e-03f, -1.42719060e-01f, -1.49443429e-02f, 8.65848958e-02f,
  4.58619371e-02f, 5.74336275e-02f, 7.18972087e-02f, -5.15473075e-02f, 8.53426158e-02f, 6.16430752e-02f, -1.87938344e-02f, 2.31519137e-02f, 7.88560286e-02f, -1.51952669e-01f,
  4.49551083e-02f, -1.61454856e-01f, 5.44881672e-02f, -3.23925316e-02f, -1.47393391e-01f, -3.20289657e-02f, 1.28703669e-01f, -1.75972328e-01f, -1.93043470e-01f, -4.73754257e-02f,
  7.41962194e-02f, 1.99376598e-01f, 3.23002934e-01f, -1.75257072e-01f, 3.76849771e-01f, 1.82448506e-01f, -1.66826919e-01f, 2.94297840e-02f, -1.43737614e-01f, -1.58274963e-01f,
  -3.83397602e-02f, -6.94897547e-02f, 6.06157146e-02f, -2.82109261e-01f, -1.32500827e-01f, -1.02860332e-01f, 1.10932350e-01f, 1.32198781e-01f, -1.44699067e-01f, 8.00766051e-02f,
  -2.26590186e-01f, -2.40238830e-01f, -7.37217534e-03f, -8.24380368e-02f, -1.25987917e-01f, 2.96334587e-02f, 4.75833304e-02f, 1.57436550e-01f, 2.37245820e-02f, 4.55287360e-02f,
  1.54381573e-01f, -2.88149007e-02f, -9.63501856e-02f, 1.66411698e-02f, -4.69436496e-02f, -5.77798020e-03f, 2.22881641e-02f, 5.34157120e-02f, 4.43625674e-02f, 4.10760492e-02f,
  -1.45757236e-02f, 2.07268558e-02f, -6.21215813e-02f, -8.49928632e-02f, 1.09475493e-01f, -8.69339854e-02f, -1.51390154e-02f, 1.40151545e-01f, -4.93934005e-02f, -1.00951537e-01f,
  -1.58269238e-02f, -2.56691705e-02f, 4.42960002e-02f, -6.68867379e-02f, -6.00895844e-02f, -4.18711305e-02f, -2.87465882e-02f, 5.97965159e-02f, -4.76204380e-02f, 2.25110864e-03f,
  -2.42158379e-02f, -2.92102434e-02f, -2.21684985e-02f, 2.38062479e-02f, -1.88481435e-02f, -5.65597564e-02f, 3.77753899e-02f, -1.61194932e-02f, -2.90157720e-02f, 1.09775804e-01f,
  5.87379299e-02f, -1.10869482e-01f, -7.09344521e-02f, -2.99857669e-02f, 7.93544501e-02f, 9.17749852e-02f, -5.96645065e-02f, -1.71722677e-02f, -4.08088323e-03f, 1.59041002e-01f,
  -2.73984730e-01f, -2.00466618e-01f, -4.06196751e-02f, -6.07236102e-02f, 2.15208177e-02f, -1.68153327e-02f, 1.89553443e-02f, 4.93887849e-02f, -4.30660434e-02f, -9.21444669e-02f,
  -2.43783053e-02f, 1.48520702e-02f, -3.49665433e-02f, -3.47417220e-02f, 6.34477437e-02f, -9.65986475e-02f, -4.75166664e-02f, -1.91220120e-02f, 3.84324864e-02f, -5.80208264e-02f,
  9.32632610e-02f, 6.32415041e-02f, 1.28011674e-01f, -1.11110680e-01f, -4.04382534e-02f, 5.38991950e-02f, -4.00169566e-02f, -2.63720285e-03f, 6.34839311e-02f, -5.44037558e-02f,
  3.80865544e-01f, -3.99462283e-02f, 1.46903053e-01f, 2.39182428e-01f, 2.27804288e-01f, 2.13626266e-01f, 3.38065416e-01f, 5.93496971e-02f, 3.72998923e-01f, -1.01781182e-01f,
  -1.44770920e-01f, -7.17257932e-02f, -3.84490304e-02f, -1.03668995e-01f, 1.32677779e-01f, -6.99611474e-03f, 7.93019980e-02f, -3.02478820e-02f, 1.24848500e-01f, -1.38382524e-01f,
  6.26843888e-03f, -9.10409763e-02f, 3.67428176e-02f, -6.47405311e-02f, 1.04017099e-02f, -5.18904999e-03f, -1.22596011e-01f, 1.78154230e-01f, -1.38174132e-01f, 2.88217887e-02f,
  -1.25932572e-02f, 4.03575636e-02f, -4.64459835e-03f, -9.26887020e-02f, 4.04013991e-02f, 1.08739950e-01f, 6.95015565e-02f, 3.61811668e-02f, 1.13239281e-01f, -4.31120470e-02f,
  -3.75634581e-02f, 3.77238095e-02f, 6.93423897e-02f, 3.28053758e-02f, 5.25065884e-02f, -1.45896235e-02f, -3.99062075e-02f, -1.99384794e-01f, -8.60696360e-02f, -7.97724053e-02f,
  8.68600700e-03f, -1.06774289e-02f, -1.13984384e-01f, 6.97111636e-02f, 3.86984386e-02f, 1.08782455e-01f, -2.51339991e-02f, 2.79668588e-02f, 2.28520241e-02f, 1.20695390e-01f,
  -7.85988122e-02f, 6.77248463e-02f, 1.65292118e-02f, -1.02335185e-01f, -1.85452819e-01f, -8.60609561e-02f, -1.74149387e-02f, -1.02667317e-01f, -2.38842685e-02f, -1.02170907e-01f,
  -6.77719936e-02f, -5.89597560e-02f, 5.94840795e-02f, -5.66426665e-02f, -6.26653060e-02f, -2.50647776e-02f, -3.20425779e-02f, 3.35968994e-02f, 1.89873248e-01f, -2.18359344e-02f,
  -4.59736101e-02f, 9.70342830e-02f, -9.11805928e-02f, 7.37393787e-03f, 5.78082092e-02f, -7.33824819e-03f, 2.32920498e-02f, 1.06292479e-02f, -3.83696854e-02f, -1.16630495e-01f,
  -1.49823828e-02f, 6.99598854e-03f, -2.77817156e-02f, -9.65586752e-02f, -8.57745335e-02f, -1.12177216e-01f, 1.59908652e-01f, 1.91811670e-03f, -1.84345748e-02f, 5.24258986e-03f,
  1.98253468e-02f, -8.58415291e-02f, -4.02833484e-02f, 5.79784103e-02f, -7.44826049e-02f, -1.45689007e-02f, 3.21666077e-02f, -1.15444161e-01f, -6.04980113e-03f, -9.49830487e-02f,
  -5.64235784e-02f, -3.53220701e-02f, -9.39405188e-02f, 4.37709540e-02f, -9.19981301e-02f, 3.78053822e-02f, 2.28756778e-02f, -2.32842024e-02f, -2.48516980e-03f, 3.36469337e-02f,
  9.81958732e-02f, -1.35429025e-01f, -1.20578676e-01f, -1.80558100e-01f, -1.68541655e-01f, -8.42745826e-02f, -1.78484753e-01f, -1.44787440e-02f, -3.39044048e-03f, 1.38594419e-01f,
  -1.20101869e-01f, 6.97957426e-02f, 9.62705016e-02f, -1.97521709e-02f, -7.95578361e-02f, 2.76686132e-01f, -1.46847472e-01f, 3.54699269e-02f, 1.00265563e-01f, -1.39352053e-01f,
  -1.81447212e-02f, -4.34176624e-02f, 7.02642724e-02f, 3.00702006e-02f, -2.45746821e-01f, -4.18551117e-02f, 6.80769735e-04f, -3.59761119e-02f, -9.30650458e-02f, -2.19402071e-02f,
  1.33699030e-01f, 1.48833215e-01f, 2.62101889e-02f, 6.77135289e-02f, 3.64460982e-02f, -5.56964874e-02f, -3.14934663e-02f, 3.09371296e-02f, -4.23478857e-02f, -1.29304193e-02f,
  -9.86045152e-02f, 7.44018983e-03f, 3.55227813e-02f, -1.17581852e-01f, -1.35714978e-01f, 5.20833917e-02f, -1.13212382e-02f, 1.72443327e-03f, -1.51870903e-02f, -4.36229855e-02f,
  -7.86697492e-02f, 2.56349482e-02f, -1.23919509e-01f, 3.63409109e-02f, -6.81537241e-02f, -2.30908748e-02f, 1.03818066e-01f, 4.77799661e-02f, 5.95236830e-02f, -2.57631782e-02f,
  -1.26097733e-02f, -6.54932782e-02f, 2.25899345e-03f, 1.40156653e-02f, 4.41838764e-02f, -2.33820900e-02f, -1.35521993e-01f, 5.50061204e-02f, -4.72529493e-02f, 4.60877381e-02f,
  1.20242067e-01f, 4.63279616e-03f, 4.47073877e-02f, -1.04857847e-01f, -9.22525972e-02f, 3.12373973e-02f, 2.79361214e-02f, -3.59630547e-02f, -6.57736287e-02f, 9.34905466e-03f,
  1.64596677e-01f, 6.27078535e-03f, -8.42780923e-04f, 4.59764861e-02f, 4.50514928e-02f, -6.55118003e-02f, -7.44448556e-03f, -7.19853211e-03f, 7.51478076e-02f, -9.84736234e-02f,
  -1.86318234e-02f, 1.54684693e-01f, 1.00374922e-01f, 6.11800514e-02f, 1.58441942e-02f, 1.83033745e-03f, -1.14006922e-01f, -9.35615152e-02f, -6.49935158e-04f, -1.21548250e-02f,
  -9.35750529e-02f, 3.24697047e-03f, -3.04867048e-02f, -1.33879349e-01f, -7.13507757e-02f, -1.00260219e-02f, -5.14961407e-03f, 1.25764287e-03f, 3.25174108e-02f, -1.16744965e-01f,
  -3.67351994e-02f, 3.79115716e-02f, -2.20334474e-02f, 1.23008989e-01f, 2.44785137e-02f, -4.98525836e-02f, 3.08137294e-02f, 6.29195571e-02f, -6.15213290e-02f, -3.14672403e-02f,
  1.97063416e-01f, 2.96017796e-01f, 3.75202864e-01f, 2.84450263e-01f, -1.45751074e-01f, -4.55862343e-01f, -3.05157572e-01f, 7.30957463e-02f, 9.02795941e-02f, -1.57228306e-01f,
  -2.16953024e-01f, 2.72713244e-01f, -1.38960198e-01f, 1.92989454e-01f, -2.22088899e-02f, -1.35073245e-01f, 1.59269184e-01f, 8.62168595e-02f, 3.62655590e-03f, 9.88947302e-02f,
  1.71355262e-01f, -8.66249725e-02f, 3.39053065e-01f, 1.45145005e-03f, 5.86791635e-02f, 1.64737985e-01f, 2.19090819e-01f, -3.58544327e-02f, 1.66995376e-01f, -6.38643205e-02f,
  -1.49081767e-01f, 6.57415614e-02f, 1.67352960e-01f, 6.38104230e-02f, 1.40640782e-02f, -1.27940506e-01f, 6.12309296e-03f, 5.23195323e-03f, -6.02195077e-02f, -1.26282126e-02f,
  6.92952052e-02f, -7.85493851e-03f, -7.77628124e-02f, 2.70883925e-02f, -8.81358683e-02f, 8.60408396e-02f, 1.42921478e-01f, 1.75840840e-01f, 9.51483697e-02f, 8.93103257e-02f,
  1.47358283e-01f, 5.30351661e-02f, 2.33707763e-02f, 1.51386559e-01f, 1.11350901e-01f, -1.42033147e-02f, -6.10325187e-02f, 1.35446355e-01f, -3.97914536e-02f, 1.19522743e-01f,
  6.95534572e-02f, -9.01395008e-02f, -6.90029338e-02f, -2.96587329e-02f, -1.03292279e-01f, 5.54543473e-02f, -2.63520237e-02f, 3.30560864e-03f, -4.32092361e-02f, -8.22822601e-02f,
  -1.12643037e-02f, 9.25957635e-02f, 6.93584681e-02f, -1.35609016e-01f, 3.12988907e-02f, 1.31647068e-03f, 2.46161912e-02f, -4.21603769e-02f, 4.00436483e-02f, 5.51971421e-02f,
  -3.63180004e-02f, -9.07513276e-02f, -5.83468750e-02f, 2.28515454e-02f, -1.59072950e-01f, 2.24005431e-02f, 1.31862937e-02f, 8.48776288e-03f, -6.22707382e-02f, -2.56358441e-02f,
  8.28089416e-02f, 2.42671892e-01f, 1.62813831e-02f, -4.66359174e-03f, 2.23167147e-02f, -2.96836644e-02f, -1.52286720e-02f, 5.55690117e-02f, 3.17020267e-02f, -3.89918312e-02f,
  6.49340525e-02f, -7.03391060e-02f, 6.54664487e-02f, 3.83836441e-02f, 7.26740807e-02f, 6.68786392e-02f, 6.31953105e-02f, 9.08488594e-03f, 1.23317190e-01f, -4.80844826e-03f,
  -4.84455656e-03f, -9.78595465e-02f, -2.11153235e-02f, -1.06881540e-02f, 3.71500365e-02f, -4.06028796e-03f, -1.28828123e-01f, 3.57466005e-02f, 4.97180112e-02f, -8.75276886e-03f,
  2.76465267e-01f, -2.05869064e-01f, 1.55558363e-01f, 2.38740951e-01f, 3.04839790e-01f, 7.32121989e-02f, 3.10805261e-01f, -1.30180884e-02f, 2.39236966e-01f, -1.76591903e-01f,
  1.23508670e-03f, -1.01614863e-01f, -2.39513442e-02f, -1.28485903e-01f, 1.56880260e-01f, -8.12360272e-02f, 3.93772908e-02f, 5.75919114e-02f, 1.33255482e-01f, -9.80037451e-02f,
  8.74887779e-02f, -4.52182181e-02f, 1.24370240e-01f, -1.00266524e-01f, 6.80368394e-02f, -4.75862361e-02f, -4.30163182e-02f, 1.77410394e-01f, -2.22750500e-01f, 3.03008351e-02f,
  2.37835199e-02f, -7.95264170e-02f, -1.71800368e-02f, -1.26476094e-01f, 2.85642873e-02f, -7.09933490e-02f, -5.19912466e-02f, -1.23682566e-01f, 7.85763264e-02f, -9.22414809e-02f,
  1.83480736e-02f, 5.44098057e-02f, 4.42008115e-03f, 7.11540086e-03f, 8.46330002e-02f, 4.22606431e-02f, 3.27635482e-02f, -8.75650123e-02f, 2.31506806e-02f, 1.07344156e-02f,
  4.89260294e-02f, -2.50172559e-02f, 1.06813744e-01f, -2.20804587e-01f, 1.80011541e-02f, -1.18509941e-02f, -1.22341648e-01f, 1.53351277e-01f, 3.61499526e-02f, -6.28503859e-02f,
  3.08172870e-02f, 1.52972969e-03f, 6.95412606e-02f, 2.29681078e-02f, 7.24040195e-02f, -9.65265464e-03f, 5.78344800e-02f, -5.67722134e-02f, -4.41997275e-02f, 6.87989220e-02f,
  4.18259092e-02f, -7.42612183e-02f, 7.46670691e-03f, -3.79547328e-02f, -2.16795895e-02f, 6.37033954e-03f, -9.42583680e-02f, -1.16993949e-01f, 2.47780047e-02f, 4.14922461e-02f,
  8.85609537e-03f, 3.16595957e-02f, 2.04459298e-02f, 5.81360459e-02f, -6.77965730e-02f, -6.31167693e-03f, -5.26534840e-02f, 3.29400860e-02f, 1.18738726e-01f, 2.17802878e-02f,
  -6.33781552e-02f, -2.08686262e-01f, -2.16929726e-02f, -1.77577853e-01f, -6.59045577e-02f, -1.31188884e-01f, -1.02481790e-01f, -1.83699857e-02f, -2.33450904e-02f, -4.76265661e-02f,
  2.13241447e-02f, -3.47719751e-02f, -6.70364350e-02f, 3.51283903e-04f, -4.66736872e-03f, 3.39950696e-02f, -5.73544055e-02f, -9.85989645e-02f, -8.75411704e-02f, 3.38329524e-02f,
  -4.64818738e-02f, -1.14273153e-01f, 4.71671112e-02f, -4.35402654e-02f, -7.30399564e-02f, 9.71508119e-03f, -6.67804480e-02f, 4.59166057e-02f, -4.01814878e-02f, -7.84545168e-02f,
  -2.64369994e-01f, -2.61827111e-01f, -2.69179970e-01f, -2.88866125e-02f, 2.69851059e-01f, 4.74857502e-02f, -2.80489683e-01f, 1.63260400e-01f, -2.10799873e-01f, 2.20616087e-02f,
  1.21857807e-01f, -1.08115956e-01f, -3.30109626e-01f, 3.31807099e-02f, 8.87896493e-02f, -1.55023038e-01f, 1.82758849e-02f, 4.26465347e-02f, -1.30565017e-01f, -2.52569225e-02f,
  -7.32098147e-02f, 2.42105901e-01f, -4.13141884e-02f, 3.22844833e-01f, 2.57480852e-02f, 6.84801415e-02f, 1.40907750e-01f, -4.24753353e-02f, 2.33695284e-01f, 1.02473520e-01f,
  -7.10212812e-03f, -1.48566574e-01f, -1.02302618e-01f, -4.75966707e-02f, -1.71370506e-02f, 4.20233533e-02f, -1.46051779e-01f, 3.88456509e-02f, -5.65892197e-02f, -6.37273341e-02f,
  -1.03767425e-01f, -2.87005901e-02f, 1.30808605e-02f, 1.53696146e-02f, -8.27401727e-02f, 6.91963136e-02f, -1.08112171e-01f, 6.03940040e-02f, -3.68251130e-02f, -8.13904107e-02f,
  -1.12056553e-01f, 1.50345087e-01f, -3.10458466e-02f, 3.70058976e-02f, 2.44824830e-02f, 6.46476001e-02f, 1.20110521e-02f, 4.45171520e-02f, 6.68814033e-02f, 7.78644904e-02f,
  -9.42882895e-02f, -2.72353981e-02f, 3.23787481e-02f, 1.62917040e-02f, 3.61254322e-03f, 4.79808263e-02f, 6.81897253e-02f, 7.47934356e-02f, -5.75035028e-02f, -8.54861066e-02f,
  8.27782974e-02f, 1.03381900e-02f, 1.93324406e-02f, -7.31608495e-02f, 1.85265616e-02f, 5.57092577e-02f, -3.87376659e-02f, -6.10281862e-02f, -6.64944947e-02f, 4.54412214e-02f,
  -2.57607829e-02f, -2.28088087e-04f, 3.19867283e-02f, -5.95489591e-02f, -9.81142744e-03f, 1.62331969e-01f, 9.48604941e-03f, -4.18988131e-02f, 2.45206542e-02f, -3.42691579e-04f,
  1.20997913e-01f, -8.58210251e-02f, 2.46112840e-03f, 1.15901999e-01f, 4.19206778e-03f, 6.12831898e-02f, 1.74963605e-02f, -3.01718097e-02f, 1.54882921e-02f, -9.17465910e-02f,
  1.79298334e-02f, 7.05371648e-02f, 1.50035322e-02f, 3.69414911e-02f, 2.37348601e-02f, 5.01267910e-02f, -4.84445809e-05f, 1.75452477e-03f, 6.39082910e-03f, 1.32030677e-02f,
  -1.25635900e-02f, 9.58804786e-02f, -3.98954451e-02f, 6.61434755e-02f, -1.13299713e-02f, 3.60598676e-02f, 1.22414418e-01f, -3.68117057e-02f, 6.19968660e-02f, -8.58874023e-02f,
  -1.07477069e-01f, 1.68490678e-01f, -7.77233094e-02f, -8.22581351e-02f, 1.79600492e-01f, -1.64593771e-01f, -9.60332006e-02f, 4.03139591e-02f, -2.35834658e-01f, 8.70568678e-02f,
  -9.90692750e-02f, -2.55319644e-02f, -1.09489327e-02f, -2.81718373e-01f, -3.69572014e-01f, -4.26797599e-01f, -2.00859874e-01f, -1.57066226e-01f, -2.35452265e-01f, 5.68406247e-02f,
  -8.57442617e-02f, -4.84572677e-03f, -1.44546121e-01f, 1.66561022e-01f, 7.85905942e-02f, 6.88922927e-02f, 2.99907446e-01f, 7.45323747e-02f, 1.87519357e-01f, -4.66003008e-02f,
  -1.13022760e-01f, -6.82868622e-03f, 5.87652288e-02f, -2.36596167e-03f, -3.94619107e-02f, 2.72647459e-02f, 1.15301646e-01f, -9.70749483e-02f, -3.32335271e-02f, -9.08933878e-02f,
  2.24520564e-02f, -1.52819529e-02f, -1.54489465e-02f, 1.97677314e-02f, 6.27034530e-02f, -7.23766983e-02f, -2.16318592e-02f, 8.97227824e-02f, 4.11744192e-02f, -1.57427210e-02f,
  -2.51844227e-02f, -1.05798349e-01f, 1.86387673e-01f, -2.19460037e-02f, -2.76699150e-03f, 1.03715006e-02f, 1.19285169e-03f, 9.53629799e-03f, -6.91937096e-03f, -9.34488326e-02f,
  -1.62680838e-02f, 1.84726603e-02f, -4.79946323e-02f, -6.59469962e-02f, -1.95328356e-03f, 3.45475860e-02f, 2.75538452e-02f, 9.08777937e-02f, 7.59504586e-02f, -5.43886013e-02f,
  -1.36356615e-02f, -2.29918603e-02f, -2.54883189e-02f, 2.26740241e-02f, 2.61732889e-03f, -7.84496136e-04f, 2.28767339e-02f, 7.58458227e-02f, -2.61194203e-02f, 7.56223872e-02f,
  -4.60646488e-02f, 7.11815059e-02f, 2.05460582e-02f, 1.28369480e-01f, -9.28503573e-02f, -5.25657460e-02f, 1.42195299e-01f, -6.27416968e-02f, 1.69944521e-02f, 3.32062617e-02f,
  5.67723587e-02f, 1.72059432e-01f, -8.48326311e-02f, 2.20287628e-02f, -3.18206511e-02f, -3.44756134e-02f, -3.71319428e-02f, -1.01469094e-02f, 5.37795722e-02f, 4.16958109e-02f,
  1.56521514e-01f, -4.33130749e-03f, 1.51603088e-01f, -2.97003388e-02f, 2.18554158e-02f, -3.25284973e-02f, 7.77328312e-02f, 4.10664827e-02f, -1.28382854e-02f, 1.82444677e-02f,
  1.64930657e-01f, -2.50331219e-03f, -4.61919904e-02f, -1.09028623e-01f, 5.44894747e-02f, 1.50725573e-01f, -1.98523570e-02f, 1.47311566e-02f, 2.81127598e-02f, 4.24724072e-03f,
  -4.93513495e-01f, 1.00325212e-01f, -1.13257341e-01f, 5.32635860e-02f, -2.60662913e-01f, 2.38499772e-02f, 3.00430536e-01f, -2.53416896e-01f, 5.55899506e-03f, 2.33122528e-01f,
  2.45498255e-01f, -8.39190185e-02f, 3.09631914e-01f, 1.82962745e-01f, -1.04338959e-01f, 1.24458112e-01f, 9.08190161e-02f, 1.64719492e-01f, -9.01122540e-02f, -1.18790917e-01f,
  2.12761620e-03f, 1.83620274e-01f, 2.04272136e-01f, -1.28147468e-01f, -4.46494296e-02f, -1.71821043e-01f, 2.08761636e-02f, -1.09056465e-01f, -7.54286360e-04f, -8.42161998e-02f,
  -2.74529427e-01f, -2.89820433e-01f, -7.25329574e-03f, 1.02476384e-02f, -5.32140173e-02f, -6.77989125e-02f, -7.84850940e-02f, -3.42972316e-02f, -8.88941437e-02f, -1.07936494e-01f,
  1.77917872e-02f, -1.12391576e-01f, -2.65284050e-02f, 3.05000059e-02f, 2.62079053e-02f, -7.01033995e-02f, -5.45457304e-02f, 8.08107015e-03f, 3.76207903e-02f, -2.48192307e-02f,
  1.70885753e-02f, -7.30205551e-02f, 1.03505053e-01f, 6.89415112e-02f, 1.22231739e-02f, -4.41999594e-03f, 4.42527905e-02f, -9.59107876e-02f, -1.24517785e-04f, -4.98150885e-02f,
  -7.23033622e-02f, -2.23150142e-02f, -1.90801993e-02f, 9.97136831e-02f, -4.85898703e-02f, -7.92505816e-02f, 5.21757267e-02f, -6.91362917e-02f, 1.16041578e-01f, 7.03906938e-02f,
  -1.13413125e-01f, -7.72624314e-02f, -6.89139664e-02f, 2.49549579e-02f, 5.44397235e-02f, -1.35847349e-02f, 6.90338537e-02f, -4.68851440e-02f, 5.58920577e-02f, -2.77334619e-02f,
  8.02316740e-02f, 1.97664294e-02f, 1.65426489e-02f, 8.89024884e-02f, -5.35064302e-02f, -1.44718355e-03f, 2.09329892e-02f, 5.98618425e-02f, 1.32104337e-01f, -3.99683192e-02f,
  -2.17106208e-01f, -2.28778481e-01f, 2.99890549e-03f, -1.09992512e-01f, -3.88252991e-03f, -6.96783513e-02f, 2.41719875e-02f, -1.41502127e-01f, -8.12282115e-02f, -3.42577919e-02f,
  2.88343616e-02f, -1.45572312e-02f, -1.05953790e-01f, 5.43039478e-02f, 3.33044007e-02f, 1.22800626e-01f, 4.56230948e-03f, -1.24740731e-02f, 6.97908029e-02f, -3.29371095e-02f,
  5.84200658e-02f, -6.63755909e-02f, -2.03307420e-02f, 1.02505900e-01f, 7.52618387e-02f, 9.14156064e-02f, -3.93437557e-02f, -6.08054996e-02f, -1.09593868e-01f, -2.50989590e-02f,
  1.39061343e-02f, 5.15591241e-02f, -2.22364843e-01f, -1.08025283e-01f, -2.56323248e-01f, 2.51923990e-03f, 5.04304022e-02f, -2.00572550e-01f, 6.86861351e-02f, 1.60807416e-01f,
  2.39746482e-03f, -1.24542350e-02f, 1.38736948e-01f, 1.06242359e-01f, 9.37506855e-02f, 2.84925044e-01f, 2.95716710e-02f, 1.52596846e-01f, -9.21297893e-02f, -3.33323069e-02f,
  -4.04173806e-02f, 1.93442404e-02f, 1.46364763e-01f, -6.48676082e-02f, -7.28342608e-02f, -1.42052755e-01f, 1.61860168e-01f, -5.09826802e-02f, -4.48977835e-02f, -6.83300197e-02f,
  -1.06392406e-01f, -1.74677044e-01f, -1.50899425e-01f, -9.72972587e-02f, -1.01744384e-01f, -6.65858462e-02f, 3.11340615e-02f, -4.26272824e-02f, -1.74959693e-02f, -5.16837910e-02f,
  1.98561504e-01f, -3.12750414e-02f, -3.10669560e-02f, -6.59311265e-02f, 3.74322087e-02f, -1.00385845e-01f, 7.42523149e-02f, -4.30094823e-02f, 1.15978410e-02f, -4.52771820e-02f,
  -4.90677468e-02f, -6.02348149e-02f, -1.33794019e-04f, 5.88260107e-02f, 2.58834120e-02f, -6.95242211e-02f, -1.21694067e-02f, -1.60232931e-02f, -6.71389699e-02f, 4.31405529e-02f,
  -6.03018291e-02f, -1.79510210e-02f, -5.39322644e-02f, -6.57059327e-02f, -3.20778079e-02f, -5.64052835e-02f, 3.24204229e-02f, 6.25120327e-02f, 4.66883071e-02f, 1.01649903e-01f,
  -1.46461995e-02f, -6.73958138e-02f, -6.57215491e-02f, -6.97237700e-02f, 7.76526406e-02f, 1.76553037e-02f, -1.26120731e-01f, 2.03962927e-03f, 3.78403142e-02f, -4.13131602e-02f,
  5.30013368e-02f, -6.54425770e-02f, -4.48175296e-02f, -1.86531264e-02f, -7.75405243e-02f, -3.98792326e-02f, -6.45070672e-02f, -5.27145388e-03f, 5.98551668e-02f, -4.92361225e-02f,
  3.48772071e-02f, -1.00047536e-01f, -6.52602911e-02f, -1.11128896e-01f, -1.15007780e-01f, -1.97166558e-02f, 8.11525956e-02f, 2.59236544e-02f, -2.58265249e-02f, -4.50008996e-02f,
  -5.59593923e-02f, 4.15452123e-02f, -3.15977596e-02f, 2.37502940e-02f, 1.24012074e-02f, 4.19794805e-02f, 5.26496358e-02f, -4.32207361e-02f, 2.30128481e-03f, 3.24998386e-02f,
  -1.26157582e-01f, -2.41006743e-02f, 6.89434707e-02f, 1.64956693e-02f, 2.99909059e-02f, 3.95085961e-02f, -8.35138857e-02f, -4.78741266e-02f, -6.81929067e-02f, 3.73445302e-02f,
  2.08755389e-01f, -2.04036549e-01f, 8.28052238e-02f, 3.46736126e-02f, 3.04793179e-01f, 1.57042086e-01f, 1.86576262e-01f, 1.20616563e-01f, 1.23905137e-01f, -2.64612079e-01f,
  -1.11182012e-01f, -2.04655863e-02f, -1.89573810e-01f, -1.11946084e-01f, 2.67328545e-02f, 2.25940882e-03f, 4.94467765e-02f, -9.02952552e-02f, 1.08020827e-01f, -3.55540924e-02f,
  9.48963687e-02f, 4.09757309e-02f, 1.51306421e-01f, -4.32215407e-02f, -2.64860480e-03f, -4.48044725e-02f, -4.97532934e-02f, 3.42718251e-02f, -9.15917009e-02f, 3.83273438e-02f,
  -4.39179614e-02f, 4.40622196e-02f, -5.53371804e-03f, -2.00878814e-01f, 1.99599992e-02f, -3.93325314e-02f, -4.60437573e-02f, 2.04622056e-02f, 8.55717212e-02f, -5.11289351e-02f,
  -8.89951214e-02f, -5.61784878e-02f, 9.42536145e-02f, 6.17939681e-02f, 1.14335537e-01f, 5.04351556e-02f, -2.97216605e-02f, 6.88247569e-03f, 2.74685435e-02f, 1.08789563e-01f,
  3.14616226e-02f, -1.14119731e-01f, -1.35574816e-02f, -5.49154766e-02f, 2.77589634e-03f, 2.98298318e-02f, 3.20568122e-02f, 7.23668234e-03f, -1.75167173e-02f, 1.91438571e-02f,
  1.49867060e-02f, 1.34349942e-01f, 1.11547131e-02f, -4.39638570e-02f, 2.03894097e-02f, 1.15705438e-01f, 4.88947928e-02f, -2.10828669e-02f, -9.52825025e-02f, 9.84962508e-02f,
  7.55151908e-04f, 4.98039946e-02f, 1.45950087e-03f, 4.36287858e-02f, -3.06818821e-02f, 2.16598026e-02f, -7.94123784e-02f, -1.65777400e-01f, 1.34728653e-02f, -1.02719674e-02f,
  1.21541336e-01f, 2.85890512e-02f, 1.33489654e-03f, -1.06302714e-02f, -8.52161944e-02f, -3.38058881e-02f, -7.36549944e-02f, -7.43795261e-02f, 3.72292921e-02f, -4.50229757e-02f,
  -3.29729706e-01f, -1.87277213e-01f, -4.73613143e-02f, -1.26890630e-01f, -1.19610466e-01f, -9.99778211e-02f, -9.78029072e-02f, -1.12029305e-02f, -6.05152361e-02f, 6.61564618e-02f,
  8.04588795e-02f, 2.68870522e-03f, 1.82215013e-02f, 2.33557224e-02f, 2.90737022e-02f, 2.79763993e-02f, -9.33321193e-02f, -4.60522156e-03f, 5.14140492e-03f, -3.49636972e-02f,
  -6.22293986e-02f, -1.01997063e-01f, -1.58296768e-02f, 7.82307163e-02f, 1.54777905e-02f, 8.71651173e-02f, 7.17985108e-02f, -5.99338450e-02f, 1.39427660e-02f, -3.97629514e-02f,
  7.89680332e-02f, 9.91830453e-02f, -1.33252844e-01f, -8.75926241e-02f, -8.40704367e-02f, -1.11833669e-01f, -2.85616726e-01f, 6.30956888e-02f, 1.48412243e-01f, 3.04513108e-02f,
  -1.07252166e-01f, 1.76436469e-01f, 1.52900904e-01f, -2.24939734e-01f, 9.43640843e-02f, 1.79801255e-01f, -1.96683824e-01f, -1.13213509e-01f, 2.24772647e-01f, -1.11132316e-01f,
  7.11294860e-02f, -1.70606703e-01f, -1.47428453e-01f, -3.09390528e-03f, -2.73169100e-01f, -2.29550496e-01f, -1.62465841e-01f, -1.43307030e-01f, -2.26931736e-01f, -2.16530561e-02f,
  -3.91117856e-02f, -3.54816094e-02f, -4.18812856e-02f, 1.76007685e-04f, -4.58473712e-02f, -8.32650065e-02f, -4.13098224e-02f, -7.52818957e-02f, -1.17341792e-02f, 7.77652636e-02f,
  5.65019548e-02f, 1.04383886e-01f, 2.11717258e-03f, -4.88873795e-02f, -5.64770401e-02f, -1.93299837e-02f, -1.63392738e-01f, -8.57726783e-02f, -7.33976513e-02f, -1.30764022e-01f,
  -1.52995139e-01f, -7.94973597e-02f, -8.60026702e-02f, -9.27273184e-02f, -1.15989625e-01f, -6.74547926e-02f, -3.34116779e-02f, -8.81574899e-02f, -3.60155180e-02f, -5.61915664e-03f,
  1.09934293e-01f, 1.08193740e-01f, -1.36910558e-01f, -1.01837210e-01f, -1.06099404e-01f, -7.01264590e-02f, -6.49605021e-02f, -6.48090169e-02f, -4.90726493e-02f, 1.94188599e-02f,
  2.93201767e-03f, -6.91601112e-02f, -5.10581769e-02f, -1.46021349e-02f, -5.38785905e-02f, -7.04862224e-03f, -1.02595590e-01f, 4.90380712e-02f, 5.76563291e-02f, -3.94875966e-02f,
  -9.36461464e-02f, -2.68513914e-02f, 1.06448762e-01f, -4.48146611e-02f, -6.17457554e-02f, 1.05000008e-02f, 2.35516182e-03f, -1.19916750e-02f, 9.81882587e-02f, 9.45772827e-02f,
  -1.65467020e-02f, -6.42750114e-02f, 1.07421927e-01f, 1.30236909e-01f, 8.72091949e-02f, 1.77931078e-02f, -6.52936250e-02f, -6.83274046e-02f, -9.88866687e-02f, -9.23317042e-04f,
  -5.98057657e-02f, 1.59990676e-02f, -2.21612491e-02f, -1.18139431e-01f, 1.54635862e-01f, -1.11410938e-01f, -7.16773644e-02f, 7.30933920e-02f, -2.00672537e-01f, 9.35903937e-02f,
  -2.02018302e-02f, -5.30648045e-02f, -6.02059141e-02f, -4.25197408e-02f, 9.55215245e-02f, -8.30575302e-02f, -1.02771884e-02f, 3.91110405e-02f, -5.62505610e-03f, 4.63124141e-02f,
  -1.14141360e-01f, 2.30837557e-02f, 3.25016320e-01f, -2.00645119e-01f, 4.77881357e-02f, 1.25831038e-01f, -9.44088697e-02f, -7.41721094e-02f, -7.27415606e-02f, -1.28808171e-01f,
  -5.76789156e-02f, 1.45284578e-01f, -2.48486698e-01f, 1.90843996e-02f, -5.02769276e-02f, -1.43730074e-01f, -1.17673263e-01f, -7.81653598e-02f, 3.06786075e-02f, -7.18764290e-02f,
  -4.05921899e-02f, -2.30535895e-01f, 1.13655590e-02f, 9.71502885e-02f, 8.25435892e-02f, -2.92087253e-02f, -1.13474190e-01f, 7.64846336e-03f, 7.43661225e-02f, -1.51577480e-02f,
  3.47996280e-02f, -1.85465246e-01f, 1.20122246e-01f, 1.39129326e-01f, -4.35876735e-02f, 2.06337702e-02f, 1.11396037e-01f, 1.49743438e-01f, 1.11551322e-01f, -5.94205447e-02f,
  2.84202602e-02f, 6.96483999e-02f, -5.53578213e-02f, 1.51226163e-01f, 9.31393355e-02f, 2.10519657e-01f, -1.19753066e-03f, 4.78393957e-02f, 1.72669604e-01f, -6.63471371e-02f,
  3.24109048e-02f, 1.82340890e-01f, -9.10480693e-03f, 1.13381363e-01f, 1.03005819e-01f, 3.46421972e-02f, 6.32196441e-02f, 8.58988538e-02f, -2.52800547e-02f, -2.26799864e-02f,
  -8.35332423e-02f, -1.72062919e-01f, -4.74512391e-02f, 3.70159522e-02f, -5.44713996e-02f, -4.03439254e-02f, -1.99374910e-02f, 7.31463209e-02f, 8.16474203e-03f, -5.30378446e-02f,
  2.82568466e-02f, 1.96862239e-02f, 3.43607478e-02f, 1.13065407e-01f, -5.44538237e-02f, -1.40885357e-02f, 9.88619626e-02f, 1.77680850e-02f, -4.14191112e-02f, 1.19961351e-02f,
  3.16362604e-02f, 2.04939798e-01f, -1.14558801e-01f, 5.59840091e-02f, -6.28106575e-03f, 4.44908403e-02f, 9.46813002e-02f, 2.67859735e-02f, -5.26768900e-02f, -1.44279912e-01f,
  -4.52263579e-02f, -3.54992181e-01f, -7.15387762e-02f, 9.33460742e-02f, -5.76007813e-02f, 1.00621432e-01f, 1.17284402e-01f, 1.24286972e-01f, -1.23991519e-01f, -1.79274231e-02f,
  8.14873576e-02f, 7.56125897e-02f, -2.39780210e-02f, 4.21146564e-02f, 6.92649465e-03f, 1.85042841e-03f, -2.81906780e-02f, 3.78104933e-02f, 1.17678754e-01f, 6.64678365e-02f,
  9.47751664e-03f, 8.16194713e-03f, 3.60087790e-02f, -8.93538743e-02f, -1.75813194e-02f, 1.72244161e-02f, -6.59640953e-02f, 4.24488075e-03f, -6.78633004e-02f, -1.41136780e-01f,
  -6.11673892e-01f, 6.87153339e-02f, 1.27910808e-01f, -2.47869655e-01f, 1.62504792e-01f, 2.46603027e-01f, -1.09868646e-01f, 1.14916265e-01f, -1.55776754e-01f, -9.96307936e-04f,
  9.11010951e-02f, -2.02299818e-01f, 7.31474832e-02f, -1.35444865e-01f, -2.63188154e-01f, -1.36572331e-01f, -2.34922156e-01f, -1.70471683e-01f, -5.58888167e-02f, -1.20866470e-01f,
  -2.61305481e-01f, 4.22507897e-02f, -1.63262803e-02f, 2.08950281e-01f, 5.42430729e-02f, -3.84756401e-02f, 1.01064574e-02f, 1.53630674e-01f, -2.84194164e-02f, 4.76874486e-02f,
  2.49260291e-02f, -3.58790010e-02f, 6.32006535e-03f, 1.26878053e-01f, -1.39308600e-02f, -1.98589955e-02f, 1.43282106e-02f, 4.96187247e-02f, 8.30417797e-02f, 3.77128944e-02f,
  1.12937033e-01f, 2.76187807e-02f, -1.66473716e-01f, 1.29807845e-01f, 5.09107709e-02f, 9.57611576e-03f, 1.04963623e-01f, 4.29802574e-02f, 3.37544158e-02f, 1.67588130e-01f,
  -5.50972950e-03f, 3.47470790e-02f, 1.88172553e-02f, -4.90504280e-02f, 9.52330083e-02f, 8.49207044e-02f, -7.07270205e-02f, 6.23642877e-02f, -6.47014976e-02f, -1.39748007e-01f,
  1.08634634e-02f, 1.33648957e-03f, 6.69900002e-03f, 5.38193285e-02f, 9.83815640e-03f, 5.46058230e-02f, -4.69996640e-03f, 9.18038562e-03f, 5.66812884e-03f, 8.09033588e-02f,
  1.83923524e-02f, -1.96664091e-02f, 4.15261313e-02f, -2.96742879e-02f, 5.97565472e-02f, 1.16076760e-01f, -6.74249604e-02f, -8.27400237e-02f, 3.59705091e-02f, -4.77027409e-02f,
  1.39800563e-01f, -8.39610212e-03f, 3.38071436e-02f, -1.98254175e-02f, -2.88010519e-02f, 2.71679740e-02f, -1.02462843e-02f, 3.62413377e-02f, -3.35653685e-02f, -6.22519813e-02f,
  -2.04337239e-02f, -8.01074430e-02f, -1.35966213e-02f, 8.19953084e-02f, -1.74571704e-02f, 5.95933683e-02f, -5.95209301e-02f, 2.72822324e-02f, 4.15934436e-02f, -6.51061386e-02f,
  4.49134149e-02f, -7.32712746e-02f, -4.09852304e-02f, 3.25998198e-03f, -1.50729176e-02f, 5.85710704e-02f, 1.36141665e-02f, 1.42468708e-02f, -8.63713026e-03f, 6.01076484e-02f,
  -4.28537838e-02f, -6.16392680e-03f, -7.62526542e-02f, -3.13769244e-02f, -5.18966168e-02f, 3.77887161e-03f, 6.85093924e-02f, -2.38749105e-03f, -1.76728163e-02f, -9.20040086e-02f,
  -3.72952342e-01f, 2.69081533e-01f, -1.02248723e-02f, -2.31870368e-01f, 9.73937288e-02f, -1.55635655e-01f, -1.01661488e-01f, 3.51023600e-02f, -1.69055294e-02f, 2.62115616e-02f,
  3.80507600e-03f, -4.64214832e-02f, 1.16568558e-01f, 1.79124009e-02f, -1.69564083e-01f, 8.87966454e-02f, -2.33472392e-01f, -1.68792859e-01f, 5.83059266e-02f, -8.45957771e-02f,
  -1.43926069e-01f, 5.80470427e-04f, -8.14439133e-02f, 2.00157136e-01f, -4.54431288e-02f, -1.69247873e-02f, -1.16199017e-01f, 1.27498105e-01f, -1.12513028e-01f, 6.54825121e-02f,
  -1.07860237e-01f, -2.87255663e-02f, 2.56843399e-02f, -8.21184367e-02f, -1.22187302e-01f, -7.47720003e-02f, -3.63632999e-02f, -9.01662977e-04f, 8.40301346e-03f, -8.24760795e-02f,
  -9.70769301e-03f, -3.40437313e-04f, -1.21640265e-02f, 7.33526126e-02f, -9.80077609e-02f, 2.36499831e-02f, -3.56173553e-02f, -3.61274444e-02f, -6.27862141e-02f, -4.20316719e-02f,
  -3.63637432e-02f, 3.63396741e-02f, -1.21338561e-01f, -2.30662525e-03f, -5.00692651e-02f, 7.46904910e-02f, -1.01852953e-01f, -5.01824319e-02f, -1.91333100e-01f, -6.46563694e-02f,
  3.47575247e-02f, -3.37127335e-02f, 7.08360374e-02f, -3.03207394e-02f, 2.72700563e-02f, 4.38218080e-02f, 2.94458251e-02f, -6.64389133e-02f, 6.44359291e-02f, 7.44058415e-02f,
  -2.30610818e-02f, -3.34179215e-02f, 5.03449589e-02f, -7.23401085e-02f, 1.68470945e-02f, 4.92540933e-02f, -5.46490587e-02f, -7.14677051e-02f, -9.29030851e-02f, 6.14031367e-02f,
  -9.41311345e-02f, 4.35388573e-02f, 6.50473237e-02f, -1.35778785e-01f, 1.01064399e-01f, 2.85736229e-02f, -3.19890156e-02f, 6.21335097e-02f, 1.62129402e-02f, -2.74859238e-02f,
  -3.32780987e-01f, -1.28751710e-01f, 1.24068838e-02f, -5.06433956e-02f, -1.99656263e-02f, 1.00925211e-02f, 1.88128522e-03f, 1.45717403e-02f, -8.37763771e-02f, -5.34340851e-02f,
  -2.75263935e-02f, -8.88729692e-02f, -1.51488125e-01f, -3.78693379e-02f, 3.78087051e-02f, -7.47351870e-02f, -1.68691063e-03f, -1.30390760e-03f, -1.48894489e-01f, -7.38812983e-02f,
  -4.03926671e-02f, -2.43116785e-02f, 4.22246754e-02f, 5.30155487e-02f, -1.02257870e-01f, 1.43180182e-02f, -6.77207038e-02f, 2.02862862e-02f, -1.29282037e-02f, 1.63134430e-02f,
  3.24335903e-01f, -7.41340145e-02f, 2.03090698e-01f, 3.54992151e-01f, 3.65140885e-02f, -1.87981520e-02f, -2.97040548e-02f, 3.41714174e-02f, 2.20433906e-01f, -7.34753311e-02f,
  -4.42636199e-02f, 1.85495645e-01f, -3.11431646e-01f, -1.51430648e-02f, -2.83717006e-01f, -1.71775743e-01f, 1.05570359e-02f, 1.59162626e-01f, 4.00580745e-03f, 6.01722673e-02f,
  -5.28275152e-04f, -2.61032104e-01f, -1.10617429e-01f, -1.19340219e-01f, 9.44653973e-02f, 1.76214650e-01f, -2.09085479e-01f, -1.02798261e-01f, 1.54883176e-01f, -7.66111910e-02f,
  8.50716159e-02f, 4.26753890e-03f, -5.99065572e-02f, 5.39288558e-02f, 6.65867031e-02f, -1.66799575e-02f, 3.47279869e-02f, -1.09240651e-01f, 6.90131634e-02f, 2.45704576e-02f,
  -2.77307965e-02f, -9.91549250e-03f, 7.65466318e-02f, 2.63035111e-02f, 9.14859772e-02f, 1.37027860e-01f, 4.96548004e-02f, 2.20937058e-02f, 9.22923312e-02f, -2.75041256e-02f,
  7.98817948e-02f, 8.55185986e-02f, 3.58938910e-02f, 8.33875611e-02f, 1.23725459e-02f, 5.46365790e-02f, -4.10124026e-02f, 2.75864433e-02f, 1.23988457e-01f, 1.60985097e-01f,
  -1.31193146e-01f, -9.33219865e-02f, 4.16174829e-02f, 1.03024788e-01f, 2.93758921e-02f, 6.02483861e-02f, -3.89182717e-02f, 4.12438884e-02f, 6.34530857e-02f, 3.42976190e-02f,
  -5.78807816e-02f, 4.97307479e-02f, 1.18395738e-01f, 1.14186920e-01f, 1.07458197e-02f, -6.71071932e-02f, 8.96995887e-02f, 8.71675089e-02f, 3.35321762e-02f, 8.15963559e-03f,
  -1.13417096e-02f, 3.07552312e-02f, -9.50447395e-02f, 2.16622166e-02f, -7.60234799e-03f, 2.60794200e-02f, 4.22746986e-02f, 1.08034581e-01f, 5.49376942e-03f, -5.77145256e-02f,
  -7.23701417e-02f, -3.50328505e-01f, -1.55249104e-01f, 2.22385898e-02f, 2.24509612e-02f, -2.78410986e-02f, 1.78448204e-02f, 2.79700495e-02f, -5.05590364e-02f, -7.59094730e-02f,
  -5.86982183e-02f, 7.70331845e-02f, -4.60569747e-02f, 6.11478426e-02f, -6.08230568e-02f, -4.48373146e-02f, 9.58370641e-02f, -1.34604767e-01f, -6.76809326e-02f, -6.53868020e-02f,
  -3.19269821e-02f, -3.27273309e-02f, -9.29138064e-02f, 2.66208351e-02f, 1.28583666e-02f, 4.14459035e-02f, 5.83703741e-02f, 4.97645885e-02f, 4.72248197e-02f, -4.90087941e-02f,
  2.55682785e-02f, -2.47565761e-01f, 2.17927545e-02f, -1.35795489e-01f, -1.08978458e-01f, -1.97121531e-01f, -7.53767714e-02f, -1.40385002e-01f, -2.04221848e-02f, 7.30712945e-03f,
  -3.90316583e-02f, 1.73890844e-01f, 1.03343792e-01f, -2.71084219e-01f, 1.90619230e-01f, 6.81173876e-02f, -3.23432118e-01f, -7.26374537e-02f, -3.77372801e-02f, -1.97499394e-01f,
  -8.99296030e-02f, -2.29295745e-01f, -8.09010118e-02f, -2.37369314e-01f, -1.84759304e-01f, -3.74501571e-02f, 7.76614994e-02f, 2.78691389e-02f, -1.43199384e-01f, 9.50410962e-02f,
  -3.38531733e-02f, 1.02982759e-01f, -4.25565355e-02f, -3.54223587e-02f, -9.42299888e-03f, 4.12697531e-02f, -2.90655112e-03f, 9.66529399e-02f, 6.31430224e-02f, 5.66519145e-03f,
  6.36548176e-02f, 2.95451526e-02f, -1.47654517e-02f, 1.28248453e-01f, -3.26209255e-02f, 6.15506917e-02f, 2.39202809e-02f, -1.93607956e-02f, 1.90859791e-02f, -2.24398430e-02f,
  5.78731000e-02f, -4.93133664e-02f, -9.62708294e-02f, 3.25318724e-02f, -6.56638369e-02f, 2.08093878e-02f, 1.69875454e-02f, -5.14612123e-02f, 2.82957312e-02f, 1.19222160e-02f,
  9.56166442e-03f, -9.69890784e-03f, -5.03903851e-02f, 1.90338790e-02f, 7.56371766e-02f, 7.24886432e-02f, 3.30480281e-04f, 1.16165243e-01f, -5.78588545e-02f, 1.60982614e-04f,
  -3.08667291e-02f, -1.61999203e-02f, 8.06851685e-03f, -1.40615448e-01f, 4.52472130e-03f, 6.68556020e-02f, 5.21636903e-02f, 7.92261213e-02f, -1.48559093e-01f, 6.17293455e-02f,
  1.24337815e-01f, -4.73586023e-02f, 6.38251379e-02f, -8.70206505e-02f, -5.13926148e-02f, 1.21875945e-02f, 3.51768546e-02f, 8.29374641e-02f, 5.89727052e-03f, -7.06270784e-02f,
  -8.21961761e-02f, -8.47076327e-02f, -2.30456833e-02f, 8.43844116e-02f, 3.50139141e-02f, 2.19937842e-02f, -1.49716169e-01f, -1.72022700e-01f, -6.52308986e-02f, -1.29923433e-01f,
  -1.55153662e-01f, 8.51740316e-03f, -5.22116423e-02f, 2.35566963e-02f, 6.06957041e-02f, -2.69237556e-04f, -2.17624307e-02f, 8.72688647e-03f, -3.60280974e-03f, 2.18641981e-02f,
  -1.91423688e-02f, 8.79902840e-02f, -3.33839543e-02f, 4.70090732e-02f, -4.78931563e-03f, -8.13791677e-02f, 2.50544976e-02f, -4.56896387e-02f, -1.03322486e-03f, -3.57859023e-02f,
  -3.41185153e-01f, -3.46782714e-01f, 3.60091291e-02f, -1.78148761e-01f, 8.16391930e-02f, 1.15713552e-01f, -1.09892063e-01f, -4.52355817e-02f, -2.87768632e-01f, -1.82132140e-01f,
  7.54615590e-02f, 5.68329096e-02f, -2.03645408e-01f, -6.98846653e-02f, 2.14536205e-01f, 1.39410421e-02f, 8.43268558e-02f, -2.32626945e-02f, -5.72297664e-04f, -1.44845262e-01f,
  -3.24087292e-02f, 1.20371953e-01f, 4.20376882e-02f, 1.50545374e-01f, -2.73924936e-02f, 1.04438588e-01f, 5.06565683e-02f, 7.50584900e-02f, 1.41713783e-01f, 2.23064646e-01f,
  -7.59095326e-02f, -1.98142514e-01f, -1.69887289e-01f, 2.50659473e-02f, -1.22978147e-02f, 6.37391256e-03f, 4.42543104e-02f, 8.07073340e-02f, -9.97540820e-03f, 4.63454016e-02f,
  -1.97406281e-02f, 9.82504245e-03f, -4.59632464e-03f, 3.68836187e-02f, -1.04379907e-01f, 3.84777486e-02f, 4.35265638e-02f, 1.45081431e-02f, 3.70666236e-02f, -6.90543130e-02f,
  6.08068192e-03f, -4.49354164e-02f, -1.28953531e-01f, 6.69019148e-02f, 5.61889485e-02f, 1.68745015e-02f, 3.56430374e-02f, 4.81459685e-03f, 2.42660642e-02f, -4.48372923e-02f,
  1.60210252e-01f, 1.76534772e-01f, -9.72274467e-02f, -1.46753332e-02f, -3.12268967e-03f, 7.54295737e-02f, 4.82199788e-02f, -3.40082012e-02f, 7.14688823e-02f, 9.53288935e-03f,
  5.83972633e-02f, -1.36489138e-01f, 5.12037538e-02f, -2.38963850e-02f, 2.08971873e-02f, -3.62085067e-02f, -2.31861360e-02f, 8.47740322e-02f, 5.33872433e-02f, 1.03896916e-01f,
  2.07646452e-02f, 1.35907531e-01f, 3.41091044e-02f, -5.73105142e-02f, -4.02521938e-02f, 3.29834893e-02f, -4.28743754e-03f, -3.33174020e-02f, -2.54436266e-02f, 1.06509021e-02f,
  -4.11922902e-01f, -2.94895500e-01f, -3.26389447e-02f, -6.92765117e-02f, 2.27151830e-02f, -3.42769106e-03f, 4.72350083e-02f, -7.21882954e-02f, -1.26811132e-01f, -1.94018353e-02f,
  1.87993739e-02f, 6.51355535e-02f, -5.78314960e-02f, -3.43405595e-03f, 1.13656737e-01f, -5.83365224e-02f, -7.72788376e-02f, -1.26851991e-01f, -9.34749320e-02f, -3.33171561e-02f,
  4.20774557e-02f, -5.56001998e-02f, 6.59204423e-02f, 5.08430414e-02f, 5.30682281e-02f, 2.75754500e-02f, -4.17522602e-02f, 1.46837579e-02f, 1.05862305e-01f, 2.96301041e-02f,
  -2.60228693e-01f, -2.99115926e-01f, 3.53139699e-01f, -2.31898516e-01f, 1.88414216e-01f, 2.34329820e-01f, 7.89333582e-02f, 3.63376923e-02f, -2.84229815e-01f, -2.45909750e-01f,
  -2.30939463e-02f, -8.11531916e-02f, 2.97718253e-02f, -6.99972808e-02f, 3.54418844e-01f, 5.45964427e-02f, 1.78499687e-02f, -6.64817244e-02f, -6.89971074e-02f, -1.09724343e-01f,
  -8.87455940e-02f, -9.65814441e-02f, 1.77317932e-01f, -3.56445909e-02f, 9.20988247e-02f, -1.13600828e-01f, -3.05975005e-02f, 2.47513533e-01f, -3.63189317e-02f, 5.36546595e-02f,
  -5.13175055e-02f, -2.42974579e-01f, -9.94370729e-02f, -4.92802076e-02f, 3.12889889e-02f, -1.51063371e-02f, 7.98575953e-02f, 1.77735522e-01f, 1.45682553e-02f, 9.30054858e-02f,
  -4.60118204e-02f, 6.61482289e-02f, -6.38756454e-02f, -2.54680105e-02f, -5.93039356e-02f, 4.37471457e-02f, 7.98156038e-02f, 5.73827587e-02f, 8.05995241e-03f, 1.21511444e-01f,
  3.84814516e-02f, -3.80471498e-02f, -5.89396358e-02f, 1.09123043e-03f, 6.82818815e-02f, -1.67161137e-01f, -2.51874831e-02f, 7.85158128e-02f, -1.96020100e-02f, 5.78402774e-04f,
  3.32742929e-02f, 5.45464121e-02f, -2.36288700e-02f, -3.11861839e-02f, -7.17015788e-02f, -5.71073256e-02f, -5.79493418e-02f, -3.49497013e-02f, 9.06359870e-03f, -3.48338149e-02f,
  3.42565328e-02f, -9.95998154e-04f, 7.66432881e-02f, -6.37763785e-03f, -2.85641430e-03f, -8.80316943e-02f, -1.00315876e-01f, 3.85608338e-02f, 4.37192470e-02f, 6.05601408e-02f,
  4.17769179e-02f, 4.64470759e-02f, 9.37880650e-02f, -4.27348427e-02f, -7.62520358e-02f, -2.35351492e-02f, -2.05528662e-02f, -4.07041870e-02f, -2.95028202e-02f, 7.60003701e-02f,
  -3.61077487e-01f, -2.16526777e-01f, -3.89577597e-02f, -1.42477095e-01f, -2.41245665e-02f, 3.61209810e-02f, 2.27709096e-02f, -1.05451465e-01f, -7.47881159e-02f, 4.56533022e-02f,
  7.10174963e-02f, -8.02368522e-02f, 4.96663563e-02f, -6.19824305e-02f, -8.91436590e-04f, 2.53331456e-02f, -7.01995939e-02f, -4.88140546e-02f, -5.88418879e-02f, 1.64997634e-02f,
  2.72378214e-02f, -8.52186084e-02f, 9.77582559e-02f, -7.87115395e-02f, 4.69674617e-02f, -1.00320652e-02f, 7.46753905e-03f, 5.90546057e-02f, 7.67545635e-03f, -5.58810076e-03f,
  1.77073821e-01f, -1.14853844e-01f, -1.90519854e-01f, -1.45143971e-01f, -2.22701877e-01f, -1.66695118e-01f, -2.57053137e-01f, -1.33328587e-01f, -1.65825207e-02f, 2.72193719e-02f,
  -1.02862991e-01f, 1.31483585e-01f, 5.68607338e-02f, -1.46765843e-01f, 1.35206595e-01f, 1.38370559e-01f, -1.18210182e-01f, 1.65274851e-02f, 4.89375703e-02f, -4.66365181e-02f,
  -4.00329158e-02f, -1.10514879e-01f, -8.91712587e-03f, -2.20812216e-01f, -2.25576550e-01f, -8.21861401e-02f, -5.85944541e-02f, -8.25678557e-02f, -5.06186821e-02f, -6.66305646e-02f,
  -7.85438716e-02f, -1.54538332e-02f, -6.40851483e-02f, 5.06816171e-02f, -7.13225408e-03f, 4.47109863e-02f, -1.29705921e-01f, 4.01612930e-02f, 6.41479194e-02f, 6.60547540e-02f,
  4.28760052e-02f, 1.32861793e-01f, 1.01808242e-01f, 3.67963798e-02f, -5.40767610e-02f, 4.85304929e-02f, 6.64112940e-02f, -1.18809929e-02f, 1.72572192e-02f, 7.14594051e-02f,
  -5.01327508e-04f, -2.08220351e-03f, 5.20065315e-02f, 4.52379547e-02f, -6.98237419e-02f, -4.94901687e-02f, 3.50686647e-02f, -6.67678714e-02f, 4.81165387e-02f, 1.27624705e-01f,
  -5.26537299e-02f, 5.57252802e-02f, 1.13081656e-01f, -6.98839203e-02f, -2.86244415e-02f, 5.34563400e-02f, 6.54089674e-02f, 4.49926913e-04f, 3.16339172e-02f, 3.16309631e-02f,
  -3.04583497e-02f, -2.52800826e-02f, -4.85211946e-02f, 1.11572556e-01f, 1.11243576e-01f, 2.48281099e-02f, 4.33929125e-03f, -1.83574215e-01f, 2.06206478e-02f, 9.43394285e-03f,
  6.71947449e-02f, 6.14948496e-02f, -3.79754901e-02f, -6.65013343e-02f, -9.24527720e-02f, 6.92838877e-02f, 3.23279910e-02f, 7.97178075e-02f, 2.79491395e-02f, 1.73068549e-02f,
  -6.45743459e-02f, -3.28007080e-02f, -3.64035778e-02f, 2.98286770e-02f, -9.67540778e-03f, 1.80113204e-02f, -5.38908616e-02f, -1.42588481e-01f, -3.68662365e-02f, -5.29480502e-02f,
  1.44553501e-02f, 7.50374272e-02f, 6.18453957e-02f, -1.01155348e-01f, -1.77123602e-02f, 7.38690048e-03f, 3.64950038e-02f, 6.57137856e-02f, 7.66858757e-02f, 1.21306460e-02f,
  -7.76580721e-03f, 7.43582100e-02f, 7.38401711e-02f, 8.45873728e-02f, -8.39061737e-02f, 4.50542569e-02f, 1.17351376e-02f, -2.12489553e-02f, -1.63555462e-02f, 5.94291165e-02f,
  1.26877308e-01f, -9.87395495e-02f, -2.68864155e-01f, 5.74772246e-02f, -3.29275317e-02f, -5.52240238e-02f, -6.59689605e-02f, 1.78010106e-01f, -1.10236593e-01f, -4.20174189e-02f,
  1.16253696e-01f, -8.79619718e-02f, -1.19710512e-01f, 1.43760934e-01f, 2.48078257e-01f, -1.12538368e-01f, 1.95554525e-01f, 1.00764990e-01f, -8.32182243e-02f, 1.14378490e-01f,
  1.26003295e-01f, 3.53015453e-01f, 3.00987754e-02f, 2.40288392e-01f, 1.47562563e-01f, 1.23962294e-02f, 1.87219858e-01f, -4.62589897e-02f, 2.48043805e-01f, 1.18043646e-01f,
  -2.00232174e-02f, -9.14739743e-02f, 5.47965663e-03f, 3.91268879e-02f, -3.82672697e-02f, 2.12318469e-02f, 6.42810075e-04f, -1.03863463e-01f, -4.07071337e-02f, 1.06836446e-02f,
  -6.63110614e-02f, -8.71392637e-02f, 2.07532477e-02f, 3.50147001e-02f, 2.35153846e-02f, -1.46823004e-01f, -4.16442938e-02f, -5.98017909e-02f, 2.63170153e-02f, 2.99378503e-02f,
  -5.70755303e-02f, -1.21604063e-01f, -3.70762544e-03f, -1.29135877e-01f, -5.02975695e-02f, -8.93558934e-02f, -4.16120254e-02f, 2.70037204e-02f, -3.25004347e-02f, -7.22849220e-02f,
  9.66934040e-02f, -7.36163706e-02f, 1.36056300e-02f, 1.09325983e-02f, -7.59179294e-02f, 2.00925898e-02f, 2.95452941e-02f, -8.42582434e-02f, 4.04454246e-02f, -8.95215943e-02f,
  -4.18911278e-02f, 2.69007869e-02f, 8.73088986e-02f, -3.53807844e-02f, -1.32947136e-02f, -1.16609238e-01f, 2.95619033e-02f, 1.29976153e-01f, 5.04501313e-02f, 9.93368328e-02f,
  -1.26375720e-01f, 1.83273524e-01f, 8.61510709e-02f, 1.05399057e-01f, -4.21284884e-02f, 4.90368418e-02f, 1.25153452e-01f, 4.89187203e-02f, 6.34291256e-03f, -8.74271896e-03f,
  -2.06506681e-02f, 8.53993669e-02f, 3.74779403e-02f, -1.80999422e-03f, -9.20560732e-02f, -1.12047447e-02f, 3.23771611e-02f, -7.00211823e-02f, -6.62051737e-02f, -4.01576087e-02f,
  5.67122102e-02f, -6.29515797e-02f, -7.34128505e-02f, 6.27924129e-02f, 5.51226772e-02f, 9.15168878e-03f, 2.37237327e-02f, -3.51155326e-02f, 4.78664562e-02f, 9.19656605e-02f,
  2.17718259e-02f, -6.37496114e-02f, 4.74282466e-02f, -1.44089594e-01f, -1.84990820e-02f, 1.81412976e-02f, -5.04329018e-02f, -6.26306087e-02f, 1.04491711e-01f, 4.06443104e-02f,
  -1.19371906e-01f, -4.30180728e-02f, -1.25767335e-01f, 1.25269219e-01f, 7.66425878e-02f, -3.46518122e-02f, -5.07683717e-02f, 9.79023054e-02f, -1.29519895e-01f, 7.98793137e-02f,
  9.64103043e-02f, -1.54899299e-01f, 3.72296125e-02f, -2.25439016e-02f, 4.55775158e-03f, -1.73427552e-01f, -3.67341843e-03f, 4.33016522e-03f, -1.18761651e-01f, 1.19854294e-01f,
  6.12758920e-02f, 1.52528599e-01f, 1.00734048e-01f, 2.25387484e-01f, -1.82328338e-03f, 3.74700129e-02f, 2.06967950e-01f, 1.62842616e-01f, 1.72912702e-01f, -5.12731820e-02f,
  -3.04249991e-02f, -4.33475412e-02f, 3.69390310e-03f, -1.90113857e-01f, 4.70151305e-02f, 4.93489057e-02f, 3.32206786e-02f, -2.85048597e-02f, 9.12576076e-03f, 2.90508643e-02f,
  4.20634747e-02f, 5.75504452e-03f, -7.36606820e-03f, -2.56228186e-02f, -3.86072174e-02f, 3.56885903e-02f, 3.02018388e-03f, 5.12044178e-03f, 2.30994262e-02f, -4.07919139e-02f,
  -5.05568180e-03f, -3.74604389e-02f, 4.18689772e-02f, 1.74453687e-02f, 4.54483964e-02f, 1.02523528e-01f, -5.89634925e-02f, 2.54079457e-02f, -1.44008733e-02f, -4.41097803e-02f,
  5.24155796e-02f, -5.78142703e-02f, 1.99205130e-02f, -1.45932421e-01f, -6.69562370e-02f, 8.92054364e-02f, 3.66944410e-02f, 3.59989726e-03f, -2.04739925e-02f, 8.40865374e-02f,
  -4.54279929e-02f, 5.28853014e-02f, -6.62265420e-02f, -3.38057540e-02f, 1.47050675e-02f, 1.59539767e-02f, -7.90328544e-04f, -1.10219484e-02f, 8.23080316e-02f, 1.12271626e-02f,
  -1.31974995e-01f, 1.09916762e-01f, 3.22915092e-02f, 5.24790920e-02f, -6.91700280e-02f, 1.50170615e-02f, -1.05210720e-02f, -2.62431670e-02f, -1.00422315e-02f, -2.08870545e-02f,
  3.90394516e-02f, 5.70207536e-02f, -1.76411904e-02f, -1.10985570e-01f, -3.60667729e-03f, -1.11277914e-02f, -9.89993736e-02f, -5.66418134e-02f, -4.41201553e-02f, 8.88159052e-02f,
  1.76214114e-01f, -7.25096837e-02f, 1.01969115e-01f, 2.01299191e-02f, -9.42730010e-02f, 1.62464961e-01f, 5.03660105e-02f, 9.92278568e-03f, 5.61912246e-02f, 1.26248255e-01f,
  1.11613208e-02f, 5.32268137e-02f, -5.82655333e-02f, -6.89097196e-02f, 6.99351728e-02f, 7.41655678e-02f, 6.44555688e-02f, 1.34623274e-01f, -2.57153902e-02f, -4.06828858e-02f,
  -3.48710120e-01f, 4.97177765e-02f, -1.00989029e-01f, 5.11634648e-02f, -7.01868981e-02f, -1.11556565e-02f, -4.67748493e-02f, -4.23943289e-02f, -3.25225234e-01f, 7.31089488e-02f,
  1.56943843e-01f, -2.42374256e-01f, 1.51927397e-01f, -5.98241016e-03f, -1.66146204e-01f, 1.78193510e-01f, 2.84776296e-02f, 5.29699400e-02f, -5.74825630e-02f, 1.09214321e-01f,
  4.22935225e-02f, 9.59038213e-02f, 1.10361800e-01f, 9.72192958e-02f, 3.13889943e-02f, -1.01804703e-01f, 1.01981319e-01f, 1.11659564e-01f, -7.49417813e-03f, -9.47053507e-02f,
  1.15133254e-02f, 2.68076472e-02f, -2.87199989e-02f, -1.07696287e-01f, -2.61455625e-02f, -5.43016521e-03f, 7.52325654e-02f, -9.15119946e-02f, -6.78021647e-03f, 1.39135611e-03f,
  -6.23824634e-03f, -9.27328616e-02f, 2.57968772e-02f, -1.59734771e-01f, -2.67530000e-03f, 3.59201878e-02f, 2.05269475e-02f, -1.27785102e-01f, 9.63088796e-02f, 6.38175011e-02f,
  -2.23565511e-02f, 2.18061637e-02f, 3.10679656e-02f, 1.07169084e-01f, 6.46163768e-04f, -5.75655745e-03f, -9.32486206e-02f, -6.87507391e-02f, 2.52295472e-02f, -3.29808742e-02f,
  -5.11009581e-02f, 8.53296444e-02f, 2.19369158e-02f, 3.63821909e-02f, -1.19041078e-01f, 1.10936321e-01f, 1.71387251e-02f, 3.25125866e-02f, -9.37624499e-02f, 5.99013194e-02f,
  -3.06451898e-02f, 6.73747733e-02f, 2.71000508e-02f, -2.28080172e-02f, -4.06926088e-02f, -5.69371395e-02f, 7.80441910e-02f, 5.62616512e-02f, 3.22847478e-02f, 4.83397348e-03f,
  8.72081816e-02f, 6.62069842e-02f, -7.27655068e-02f, 6.66207597e-02f, 1.02429748e-01f, -1.14912957e-01f, 8.37196931e-02f, -2.56576519e-02f, 1.17334686e-01f, 1.02428108e-01f,
  1.10468946e-01f, -1.03426911e-01f, 5.23021631e-03f, 1.96519513e-02f, 2.90460251e-02f, 4.04757820e-02f, -8.94432422e-03f, -9.97573361e-02f, 1.39001226e-02f, -8.53439793e-02f,
  -8.44966322e-02f, -7.22432137e-02f, 1.84438229e-01f, -1.91186629e-02f, -1.23564452e-02f, 9.97273177e-02f, 4.93397899e-02f, -1.09934464e-01f, 2.97715236e-02f, 1.01635210e-01f,
  4.13227826e-02f, 2.69102585e-03f, -1.25428155e-01f, 8.45533162e-02f, 5.46416407e-03f, 4.84203827e-03f, -4.34350781e-02f, -1.72684640e-02f, 1.84181966e-02f, -2.77918205e-02f,
  8.30977932e-02f, -2.50275224e-01f, -3.96271050e-02f, 7.05916658e-02f, 2.03870416e-01f, 1.97721645e-01f, 7.10229501e-02f, -1.26569331e-01f, -2.63938159e-01f, -2.11484671e-01f,
  -5.39656123e-03f, -7.08710104e-02f, -1.85046613e-01f, -1.53509220e-02f, 3.67048413e-01f, -8.58711675e-02f, -2.10275035e-02f, -5.29069714e-02f, -7.39967125e-03f, -1.40013590e-01f,
  3.38913277e-02f, 7.21273720e-02f, 9.55885649e-02f, 9.46462341e-03f, -1.59337604e-03f, -6.41541258e-02f, -5.86362816e-02f, -7.88834132e-03f, 8.08466598e-02f, 1.64981097e-01f,
  1.78047776e-01f, -1.08280994e-01f, 8.41085538e-02f, 9.05386955e-02f, -2.70274580e-02f, -1.69096645e-02f, 1.16702355e-01f, 9.13935527e-02f, -2.10168026e-02f, -9.32763740e-02f,
  -4.19955142e-02f, -7.20365765e-03f, -6.61690384e-02f, 6.91244826e-02f, -9.16197821e-02f, -8.87313038e-02f, 4.66266880e-03f, 6.52337447e-02f, -1.19414657e-01f, -2.79115643e-02f,
  -2.18430404e-02f, -2.33226288e-02f, 7.08276266e-03f, -1.41335383e-01f, -1.56854495e-01f, 3.18291187e-02f, 4.70390953e-02f, 3.76941487e-02f, -7.64971897e-02f, 4.94996598e-03f,
  8.24889820e-03f, 1.11911790e-02f, 1.72292460e-02f, 9.54836681e-02f, -7.64095411e-03f, 1.02516867e-01f, 8.76256377e-02f, -6.98317438e-02f, -3.22690792e-02f, -1.54289752e-01f,
  -4.04136702e-02f, 2.62029674e-02f, -5.62674217e-02f, -3.72534357e-02f, 3.99783961e-02f, 7.01104850e-02f, 1.15148015e-01f, -6.51502684e-02f, -8.54783691e-03f, 7.12793991e-02f,
  6.71771914e-02f, 9.90883857e-02f, 3.33198085e-02f, 5.77056929e-02f, -5.09956740e-02f, -6.87210858e-02f, -7.38787651e-02f, -4.22626920e-02f, 5.33046350e-02f, 8.62910300e-02f,
  2.27396321e-02f, -2.89085925e-01f, -4.02105190e-02f, 5.43555804e-02f, 3.04097738e-02f, -5.76394461e-02f, 1.16038330e-01f, -4.53483127e-02f, -7.21084923e-02f, -4.42076772e-02f,
  -2.15371903e-02f, -2.21515354e-02f, -1.18938647e-02f, -4.10966389e-02f, 8.16245228e-02f, -7.44543374e-02f, -6.86555132e-02f, -3.27691436e-02f, -6.44850880e-02f, 5.77120148e-02f,
  3.17177512e-02f, -8.24085847e-02f, -4.34306264e-02f, -1.22452870e-01f, -1.54824018e-01f, -1.05337799e-02f, -7.49774883e-03f, -2.69754995e-02f, -4.76797782e-02f, -3.91549021e-02f,
  2.53377855e-01f, -2.96217594e-02f, -1.26056939e-01f, 1.50949076e-01f, 1.22215785e-01f, -6.17765002e-02f, -7.98713267e-02f, 1.24892397e-02f, 3.40542905e-02f, -1.86021760e-01f,
  3.10885310e-02f, 4.44192812e-02f, -1.28471941e-01f, 2.16335118e-01f, 3.08835179e-01f, -2.30471328e-01f, 3.12498510e-01f, 7.95223862e-02f, -9.70438197e-02f, 1.22264862e-01f,
  1.48223042e-01f, 2.86375433e-01f, 3.06677073e-02f, 1.28593057e-01f, 1.42298833e-01f, -1.40025228e-01f, 1.10758051e-01f, -2.41297469e-01f, 6.17752932e-02f, 1.12072311e-01f,
  -1.24240275e-02f, 5.25658811e-03f, 9.67201293e-02f, -2.94602122e-02f, -1.65937077e-02f, -7.89956972e-02f, -8.26183185e-02f, 5.97738894e-03f, -1.02604761e-04f, -7.41699934e-02f,
  -8.28276947e-02f, 8.99244249e-02f, -4.35419194e-02f, -4.15117107e-02f, 1.00875527e-01f, -3.10057737e-02f, -2.85943169e-02f, -5.95325679e-02f, -6.05277978e-02f, 4.91904374e-03f,
  -3.76655012e-02f, -1.48422092e-01f, 1.17044382e-01f, -2.19945554e-02f, 6.69748262e-02f, 2.68425839e-03f, -1.51569277e-01f, 1.03359921e-02f, -1.84080333e-01f, 1.32882586e-02f,
  5.04210452e-03f, -1.53001603e-02f, -5.15193716e-02f, -6.98045716e-02f, -1.17814064e-03f, -3.10793705e-03f, 4.75611910e-02f, -8.98629725e-02f, -4.34376225e-02f, 5.42275608e-03f,
  -1.08620919e-01f, -5.77649213e-02f, 1.11898994e-02f, 3.23107908e-03f, -1.08660553e-02f, 4.10768436e-03f, -2.09119450e-02f, -8.28734338e-02f, -2.86384709e-02f, -3.35535556e-02f,
  -3.38672698e-02f, 1.01579659e-01f, 2.92967241e-02f, 2.69246241e-03f, -1.18136676e-02f, -5.74107915e-02f, 2.00735740e-02f, 2.05805507e-02f, -9.34974775e-02f, 1.85997915e-02f,
  1.75105128e-02f, 8.07051957e-02f, 2.83703208e-02f, 4.12936322e-02f, -7.78925866e-02f, 6.01994656e-02f, 4.85327654e-02f, 8.52413476e-02f, 2.29897816e-02f, 3.60850394e-02f,
  8.28695223e-02f, 4.92118672e-02f, -2.59673223e-02f, 7.17128515e-02f, 4.43044379e-02f, 4.80172709e-02f, -5.72939739e-02f, -3.26644182e-02f, -7.56539553e-02f, -5.14122695e-02f,
  3.17477062e-02f, -1.16746306e-01f, 6.67276084e-02f, -1.67394001e-02f, -7.27014057e-03f, -6.52574301e-02f, -8.02413747e-03f, -1.91909522e-02f, 1.75885931e-02f, -2.35214643e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  7.06077442e-02f, 1.40224382e-01f, 1.77296996e-01f, 1.10822216e-01f, -5.43857925e-03f, 1.13721699e-01f, 1.15204938e-01f, 1.15719251e-01f, 2.49434542e-02f, -3.99796441e-02f,
  1.00447610e-01f, 1.07404016e-01f, 1.11908428e-01f, 2.03678217e-02f, -2.21122634e-02f, 1.91126317e-01f, 6.55323714e-02f, 1.24977551e-01f, -9.07158852e-02f, 1.82911694e-01f,
  1.31705955e-01f, 1.40142709e-01f, 2.25130454e-01f, -2.79398151e-02f, 6.45140931e-02f, 1.41359493e-01f, 7.94394389e-02f, 7.30805174e-02f, 2.01042503e-01f, 9.04157609e-02f,
  4.00280431e-02f, 1.31200194e-01f, 6.26951680e-02f, 2.02350453e-01f, -3.87989380e-03f, 4.23607379e-02f, 1.09966718e-01f, 9.22092050e-02f, 2.18529813e-02f, 6.31123930e-02f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -1.60122639e-03f, -2.64365063e-03f, 1.85914606e-01f, -1.07575446e-01f, -9.04015005e-02f, -1.25343591e-01f, 5.58028147e-02f, -1.10258274e-01f, -3.27960625e-02f, -1.71704404e-02f,
  5.19045778e-02f, 6.25218004e-02f, -4.28128690e-02f, -2.91822292e-02f, 8.58170912e-02f, 1.31992891e-01f, -6.65653124e-02f, -6.78177252e-02f, -9.88126472e-02f, -1.16211675e-01f,
  -1.41913697e-01f, -9.86683890e-02f, 1.10649288e-01f, 4.56187166e-02f, 3.93209867e-02f, -1.80356466e-04f, -1.37424529e-01f, 1.17607355e-01f, 7.74043351e-02f, -9.80504304e-02f,
  5.89517541e-02f, 1.10675529e-01f, 1.51707008e-01f, -8.29693452e-02f, -1.33174397e-02f, -7.57739246e-02f, -2.17439324e-01f, 1.38045564e-01f, -1.89871863e-01f, -5.41401468e-02f,
  1.85335591e-01f, 9.55026299e-02f, 9.96607244e-02f, -1.13791607e-01f, -1.87935829e-02f, -7.83700719e-02f, -2.19841406e-01f, 2.03457654e-01f, 8.48072544e-02f, -1.05176531e-01f,
  -8.62858593e-02f, -5.66351041e-02f, -2.07953811e-01f, -6.42756522e-02f, -1.96854144e-01f, -1.05365459e-02f, -1.00348279e-01f, 3.96956457e-04f, 1.15326494e-01f, -6.86501637e-02f,
  -1.23481765e-01f, 2.15304159e-02f, -8.00096095e-02f, -1.08468473e-01f, 1.42736048e-01f, -5.73735200e-02f, 8.44306350e-02f, -1.32266423e-02f, 3.88873951e-03f, -7.38425478e-02f,
  8.97860974e-02f, 8.52241516e-02f, -4.40707318e-02f, 1.51463345e-01f, 1.54207855e-01f, -9.92753953e-02f, -8.15560669e-02f, -8.73244628e-02f, -1.06199592e-01f, -1.23453751e-01f,
  3.10394261e-02f, 4.00368795e-02f, 5.55385798e-02f, 7.13190958e-02f, -1.76103026e-01f, -1.62184522e-01f, 3.54476995e-03f, 5.63229322e-02f, 2.42137432e-01f, -3.35351191e-02f,
  -1.03617884e-01f, -3.40584405e-02f, 5.16332835e-02f, -1.72968760e-01f, 1.06485104e-02f, 3.76059376e-02f, -1.68532245e-02f, -2.06783816e-01f, 2.83211917e-01f, 1.39436513e-01f,
  -1.67751923e-01f, -9.92680416e-02f, 9.24368575e-02f, -2.02616751e-01f, 1.54712811e-01f, 5.61674172e-03f, 2.00193986e-01f, -1.42696351e-01f, -5.23741730e-02f, -1.24989875e-01f,
  -4.71752658e-02f, 2.27517128e-01f, 7.17649832e-02f, 4.74855602e-02f, 7.55636543e-02f, 1.60655960e-01f, 7.18425289e-02f, 1.61619037e-01f, -2.25225240e-02f, 1.14684820e-01f,
  1.77416950e-02f, 1.82074726e-01f, 4.51904982e-02f, -1.92860201e-01f, -5.95036410e-02f, 7.01469555e-02f, 8.33961219e-02f, -2.02190116e-01f, 1.35518253e-01f, 3.71456295e-02f,
  9.22338963e-02f, 2.95159835e-02f, 5.76950051e-02f, -1.03258248e-03f, -1.05298027e-01f, 4.73908037e-02f, 1.23164251e-01f, 4.61189151e-02f, -5.04760705e-02f, 1.34621132e-02f,
  -1.24245495e-01f, -2.34782677e-02f, -9.47325677e-02f, 9.59077626e-02f, -5.93056679e-02f, 2.33267456e-01f, 1.81581870e-01f, -1.13362176e-02f, -8.97934288e-02f, -1.18788347e-01f,
  -9.48225036e-02f, -5.45450635e-02f, 1.68008327e-01f, -1.35432661e-01f, 6.01977147e-02f, -8.43334571e-02f, -1.81786269e-01f, -9.11909491e-02f, -7.83278421e-02f, 1.59118399e-01f,
  -1.72023386e-01f, -6.95976764e-02f, 1.75564080e-01f, -8.34409322e-04f, -1.82018518e-01f, 1.21707477e-01f, 1.46583214e-01f, -1.27909677e-02f, -1.84556827e-01f, -7.44081810e-02f,
  4.37292131e-03f, -4.74910103e-02f, -2.14692473e-01f, 1.19651355e-01f, 1.94981709e-01f, 2.42292210e-01f, 4.87600602e-02f, -2.14725602e-02f, -1.37354717e-01f, 1.04732715e-01f,
  1.67034075e-01f, 5.14210127e-02f, 1.07573196e-01f, -1.29946366e-01f, 6.63075373e-02f, -5.07036634e-02f, -2.41137311e-01f, 1.38021577e-02f, 6.15285477e-03f, 1.80366516e-01f,
  -8.10752735e-02f, -1.06213801e-01f, 1.04210392e-01f, 5.65335248e-03f, 4.37816940e-02f, -4.81376145e-03f, -5.15583269e-02f, -1.07468396e-01f, 9.70378965e-02f, -5.20276465e-02f,
  8.47181231e-02f, 2.15789557e-01f, 8.83026794e-02f, -3.64299417e-02f, -4.46457081e-02f, -7.82989562e-02f, -7.53286332e-02f, -2.59261299e-02f, 8.33538827e-03f, -7.80560896e-02f,
  -2.80223861e-02f, 6.27411902e-03f, -1.34983927e-01f, -7.84895197e-02f, -1.93469264e-02f, 1.54506817e-01f, 2.45424986e-01f, 8.79471526e-02f, -1.69030707e-02f, -8.15666616e-02f,
  1.57475471e-01f, -2.01215386e-01f, 5.54593280e-03f, -1.09076664e-01f, 1.68279633e-01f, -1.87537149e-02f, 6.70383498e-02f, 1.79177314e-01f, -2.14661434e-01f, -2.37478921e-03f,
  1.87974200e-01f, -1.78569302e-01f, 2.03096241e-01f, 7.83255622e-02f, 2.03078128e-02f, -5.96445762e-02f, 3.20826508e-02f, -7.07821921e-02f, -6.01712987e-02f, 1.46082416e-01f,
  2.07107384e-02f, 6.36649877e-02f, 1.06685035e-01f, 2.17963383e-01f, 1.15513258e-01f, 1.03372909e-01f, 6.09924383e-02f, 2.11376011e-01f, 9.10345912e-02f, 1.44708648e-01f,
  1.38965994e-02f, -7.74463415e-02f, -9.79475081e-02f, 1.23147778e-02f, 6.88589439e-02f, -1.01157010e-01f, 8.86892807e-03f, -5.83685096e-03f, 4.38385867e-02f, 6.49497956e-02f,
  -6.34364784e-02f, 3.04852482e-02f, 1.52744070e-01f, -4.65715602e-02f, -5.35300858e-02f, 6.70056790e-02f, 1.24751739e-01f, -8.40035677e-02f, -1.01636253e-01f, -9.53274667e-02f,
  3.19372378e-02f, -1.43567085e-01f, -4.99737933e-02f, -8.92648324e-02f, -9.51755494e-02f, 9.22492594e-02f, -1.60167232e-01f, -1.04341365e-01f, 3.58250625e-02f, 6.49793372e-02f,
  2.80476570e-01f, 2.09319498e-02f, -1.44420430e-01f, -1.22075379e-01f, 1.78294778e-01f, -3.63854840e-02f, 3.09066847e-02f, -1.20044962e-01f, 1.95776433e-01f, -1.60211444e-01f,
  1.12820432e-01f, 1.58041790e-01f, -7.29660392e-02f, -5.35716228e-02f, -1.75290719e-01f, -1.99858591e-01f, 1.36588126e-01f, 5.65995611e-02f, 9.12486762e-02f, -1.62240222e-01f,
  9.16980654e-02f, -1.96803719e-01f, -1.69206515e-01f, 7.29958564e-02f, 7.12157711e-02f, -4.55698892e-02f, 1.71160951e-01f, 9.45375860e-03f, 1.27720490e-01f, 1.88058719e-01f,
  -2.60105729e-01f, 1.65295556e-01f, 7.25437775e-02f, 2.18241617e-01f, 1.51844677e-02f, -2.02309474e-01f, -9.91082191e-02f, 7.03872517e-02f, 4.49964637e-03f, -1.72236323e-01f,
  -8.19616914e-02f, 1.24906398e-01f, 1.07094243e-01f, 4.96912450e-02f, -6.22932687e-02f, -4.93647903e-02f, -5.08598015e-02f, -6.88082650e-02f, -8.81099626e-02f, -6.75856546e-02f,
  6.53966069e-02f, 5.25736511e-02f, -1.74194664e-01f, 1.08840749e-01f, -1.24989729e-02f, 1.98525295e-01f, -5.09288199e-02f, -6.53779879e-02f, 1.29528210e-01f, -9.36992168e-02f,
  -2.60601565e-02f, -3.64140384e-02f, 1.53126001e-01f, 2.62358151e-02f, -8.49790946e-02f, -2.53349692e-02f, -9.04661324e-03f, 1.78716674e-01f, -2.00287819e-01f, -5.44297993e-02f,
  1.08578086e-01f, 2.32149899e-01f, -3.60845029e-02f, -2.18286350e-01f, -1.44267395e-01f, -2.74959505e-01f, -4.66187065e-03f, 2.46970922e-01f, -1.66760296e-01f, -2.02453844e-02f,
  -8.67306069e-02f, 7.95025602e-02f, 4.56280075e-02f, -1.49639696e-01f, -4.62781526e-02f, -9.11586210e-02f, -5.43710366e-02f, 2.34047115e-01f, 9.25206393e-02f, -1.81014284e-01f,
  -2.20260412e-01f, -2.12252468e-01f, -2.26926029e-01f, -1.89208731e-01f, -1.55963674e-02f, -1.59121528e-01f, -2.01533884e-01f, -1.44204959e-01f, 4.62130457e-02f, 5.39775752e-02f,
  -2.34069768e-02f, 3.91928963e-02f, -1.02143496e-01f, -3.84035707e-02f, 1.02790475e-01f, -1.01657383e-01f, -9.37440321e-02f, -7.07273483e-02f, -1.32179648e-01f, -1.43999323e-01f,
  1.48130469e-02f, -1.03327692e-01f, -3.78001072e-02f, 1.43342152e-01f, 1.89896598e-02f, -9.37998891e-02f, -3.50449234e-02f, -7.42264539e-02f, 1.13631368e-01f, -8.20039287e-02f,
  -2.81475484e-02f, -6.71937987e-02f, -1.12198755e-01f, 8.54078755e-02f, -1.71336979e-01f, -1.15206882e-01f, 8.80481750e-02f, 2.57817954e-01f, 2.06645161e-01f, -8.64262320e-03f,
  -7.10991696e-02f, -1.03168853e-01f, 9.67530757e-02f, -2.24180222e-01f, -4.47752513e-02f, -8.89263898e-02f, 1.26505867e-02f, -8.19516033e-02f, 3.65226455e-02f, 6.38590679e-02f,
  -2.06951916e-01f, -3.24440487e-02f, -3.68412584e-02f, -2.00500578e-01f, 1.08500049e-01f, 8.40490684e-02f, 1.15155391e-01f, -6.29842430e-02f, 1.15911268e-01f, -1.79042801e-01f,
  -1.43272489e-01f, 1.91799611e-01f, 6.76223785e-02f, -4.02527377e-02f, 6.18091300e-02f, 6.54850975e-02f, -1.77776664e-02f, 1.21395156e-01f, -1.61883030e-02f, 1.02872305e-01f,
  5.00946166e-03f, 1.22853994e-01f, 6.59886897e-02f, -2.25832328e-01f, -9.42497477e-02f, 3.48798721e-03f, 1.57730021e-02f, -8.17413107e-02f, 1.21435992e-01f, 1.57183155e-01f,
  -4.50622998e-02f, -1.57104563e-02f, -2.05320423e-03f, 7.41251484e-02f, 2.09444109e-02f, 8.44385400e-02f, 1.12179659e-01f, -1.06567197e-01f, -1.78502146e-02f, 3.14236283e-02f,
  -2.45167077e-01f, 3.87939736e-02f, 5.15759811e-02f, 9.10209715e-02f, 3.46330740e-02f, 1.31191880e-01f, 4.66867834e-02f, -3.55314352e-02f, -6.47920533e-04f, -2.55389094e-01f,
  1.67185124e-02f, 7.99923670e-03f, -1.75855681e-02f, -1.18726961e-01f, 8.53228776e-05f, -4.45872732e-02f, -5.06178364e-02f, -9.93067026e-02f, -4.06409055e-02f, 2.11635128e-01f,
  -1.88613027e-01f, 4.53382023e-02f, 3.01974360e-02f, -5.72121739e-02f, 1.29746959e-01f, 1.02314666e-01f, -6.95924312e-02f, 4.09160182e-03f, -1.66034967e-01f, 1.71061561e-01f,
  -5.97229227e-02f, -2.21479520e-01f, -4.48588394e-02f, 1.18150517e-01f, 6.11174013e-03f, 7.91573822e-02f, 2.99023534e-03f, 1.45083815e-01f, 6.69999002e-03f, -1.79939847e-02f,
  9.78782475e-02f, -3.68160717e-02f, -1.32502437e-01f, -1.80997208e-01f, -1.98035128e-02f, 7.86663517e-02f, -6.75247759e-02f, 5.52626476e-02f, 1.02487966e-01f, 3.08520515e-02f,
  4.77716066e-02f, 9.37059373e-02f, 1.73531041e-01f, 7.29538649e-02f, 8.95094592e-03f, 8.37233439e-02f, 2.39372682e-02f, -1.47092685e-01f, 3.43318246e-02f, -1.43274844e-01f,
  2.36058552e-02f, 4.46607210e-02f, 3.40543641e-03f, -8.30318332e-02f, -1.73407476e-02f, 6.22585379e-02f, 1.17694743e-01f, 1.40797481e-01f, -1.19617311e-02f, -1.69834360e-01f,
  2.13701669e-02f, -1.70132935e-01f, -7.82456994e-02f, -1.23338610e-01f, 1.96122751e-01f, 3.73784592e-03f, -1.08014792e-01f, 1.22470744e-01f, -1.02730051e-01f, -3.74662541e-02f,
  5.54116555e-02f, -5.85747994e-02f, 4.86601032e-02f, 7.98221752e-02f, 2.06286326e-01f, -1.02172025e-01f, -1.01690471e-01f, -6.78172484e-02f, 3.67588340e-03f, 1.83243036e-01f,
  -2.03896269e-01f, -9.78253484e-02f, 1.47815153e-01f, 1.55282587e-01f, 8.93304124e-04f, -1.95610359e-01f, 5.77476770e-02f, -9.89052653e-02f, -1.42517492e-01f, 1.63648322e-01f,
  1.04180329e-01f, 2.68169455e-02f, -3.13932612e-03f, -1.02086738e-01f, -1.18825093e-01f, -1.10145986e-01f, -1.10781938e-01f, 1.51338041e-01f, -6.06206395e-02f, 9.07601789e-03f,
  1.93682075e-01f, -1.31544381e-01f, -2.67731491e-02f, 1.81175135e-02f, 6.44169142e-03f, -5.40056638e-02f, -1.02007359e-01f, 2.65573561e-02f, -3.45382504e-02f, 6.14990527e-03f,
  -6.56914786e-02f, 3.30193043e-02f, -1.61019579e-01f, -1.82886608e-02f, 3.05958418e-03f, 1.17763486e-02f, -9.69484001e-02f, -5.07462583e-02f, 1.21698134e-01f, 7.43876174e-02f,
  -1.43725155e-02f, -1.18189879e-01f, -1.30257472e-01f, 1.04022764e-01f, 1.08922973e-01f, 1.41662657e-01f, 5.28445058e-02f, 2.37674251e-01f, -1.79362893e-01f, -1.07524641e-01f,
  1.20298274e-01f, -1.21034160e-01f, 1.25243202e-01f, 6.96162730e-02f, -6.65559545e-02f, 2.38477960e-02f, -4.38670777e-02f, -1.22414112e-01f, -5.98227829e-02f, -9.13273916e-02f,
  3.16803306e-02f, 1.31091878e-01f, -1.38097778e-01f, -6.30751029e-02f, 1.28453225e-01f, 1.79253183e-02f, -1.55800954e-01f, -1.84790909e-01f, -2.91397255e-02f, 2.46669963e-01f,
  -2.84656938e-02f, 8.26302692e-02f, 2.49038234e-01f, -1.18223786e-01f, -1.90471318e-02f, -1.46008477e-01f, 4.50843722e-02f, 7.95078278e-03f, 2.09895391e-02f, 8.78001750e-02f,
  -5.69617413e-02f, 7.20454305e-02f, -5.70160374e-02f, -1.81005061e-01f, -1.99168753e-02f, 7.95938224e-02f, 1.35231465e-01f, 6.79347217e-02f, -1.62361428e-01f, 7.92057514e-02f,
  1.77785471e-01f, 9.97542888e-02f, -1.09291524e-01f, 8.31196830e-03f, -6.60717813e-03f, -8.24334100e-02f, -7.12421834e-02f, -4.45414037e-02f, 5.08543588e-02f, -6.64232224e-02f,
  5.04509844e-02f, 9.07739848e-02f, -4.65442985e-02f, -5.11821024e-02f, 1.10624865e-01f, 2.43628591e-01f, -6.07401617e-02f, 1.14499591e-02f, 6.70898054e-03f, -1.83731571e-01f,
  2.29998335e-01f, -8.68773274e-03f, 7.43089765e-02f, 1.98460533e-03f, -1.83078513e-01f, 1.80022359e-01f, -1.17157884e-01f, -1.86079720e-04f, 5.60196899e-02f, -1.49494484e-01f,
  -1.30532026e-01f, -1.82955280e-01f, 1.20396093e-01f, 2.53860444e-01f, -3.01440686e-01f, -1.83258221e-01f, 2.39578933e-01f, -5.62679991e-02f, -1.40447423e-01f, 1.36424646e-01f,
  1.89056307e-01f, 9.35574323e-02f, -1.24284737e-01f, -1.91611156e-01f, 1.21822864e-01f, 8.14441219e-02f, 4.01219092e-02f, -2.09970661e-02f, -5.80349155e-02f, 1.04138501e-01f,
  -1.72569603e-01f, 2.11853758e-02f, -1.42959282e-02f, -1.80012360e-01f, 3.78534794e-02f, 3.88164669e-02f, 7.51081109e-02f, 4.89302948e-02f, -5.70357814e-02f, -5.32484613e-02f,
  1.33858705e-02f, -5.84057979e-02f, 1.36722550e-01f, 9.87763703e-02f, -8.78429264e-02f, -1.13122970e-01f, -3.62118967e-02f, -1.77461535e-01f, 2.71440558e-02f, 7.28240758e-02f,
  -8.56374577e-02f, -1.50396079e-02f, -3.07133459e-02f, -6.40699044e-02f, -1.40180707e-01f, -1.02150708e-01f, -1.19645536e-01f, 1.06407471e-01f, 5.07853590e-02f, -3.47194150e-02f,
  -1.24500156e-03f, 9.94825810e-02f, 5.61845899e-02f, 5.07912412e-02f, 1.98973671e-01f, -3.31351534e-02f, -7.78020099e-02f, -2.37010986e-01f, 8.78347903e-02f, -1.12615258e-01f,
  2.07287967e-02f, 2.24159434e-01f, -5.19051626e-02f, 1.83060035e-01f, 9.52358693e-02f, 2.11373359e-01f, -2.25073412e-01f, 8.88509527e-02f, 8.39630067e-02f, -2.62368564e-03f,
  -6.83512241e-02f, 3.87215838e-02f, -8.02613944e-02f, 6.39773309e-02f, -1.65144309e-01f, -2.39135489e-01f, -1.07997768e-01f, 4.13608886e-02f, -2.32946232e-01f, 2.09577531e-01f,
  3.57455760e-02f, 1.57729253e-01f, -6.76737651e-02f, -6.83433115e-02f, -7.65343159e-02f, -1.50251359e-01f, 1.95017815e-01f, 1.67238563e-01f, -1.58318311e-01f, -2.13690981e-01f,
  7.20835701e-02f, 9.58589464e-03f, -1.80246502e-01f, 1.52188271e-01f, 1.95405215e-01f, 2.26773188e-01f, -6.72228262e-02f, 9.08753574e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  5.06242514e-02f, 1.42289465e-02f, -1.00047678e-01f, 5.31313419e-02f, 1.40162632e-01f, 1.14500269e-01f, -2.14368291e-02f, -2.49330178e-02f, 2.07541455e-02f, 1.20624579e-01f,
  -9.53811035e-02f, 1.98991261e-02f, 2.87757851e-02f, -7.19923824e-02f, -1.04415104e-01f, -8.46336633e-02f, -3.51519622e-02f, 4.39916700e-02f, 6.07208200e-02f, 7.04722553e-02f,
  3.67363589e-03f, 1.01938337e-01f, -1.33506596e-01f, -1.85323641e-01f, 2.10290492e-01f, -3.81982280e-03f, 7.71063715e-02f, 1.24659635e-01f, 6.88539743e-02f, 1.74362347e-01f,
  6.40391782e-02f, 2.23488975e-02f, -2.04331912e-02f, -5.12641342e-03f, 1.31485373e-01f, 1.61364123e-01f, -1.42795935e-01f, -5.13255820e-02f, 1.55359721e-02f, 1.15444064e-01f,
  2.14400282e-03f, -2.09756449e-01f, 7.08554611e-02f, 4.46885712e-02f, -1.44756511e-01f, 2.26095393e-01f, 2.76778758e-01f, -8.24085772e-02f, -2.08067689e-02f, -9.27271545e-02f,
  7.18197599e-02f, 1.24903977e-01f, 1.90968230e-01f, 1.12564296e-01f, -4.78820615e-02f, 1.23604931e-01f, 2.12430686e-01f, 8.93112179e-03f, -3.15936911e-03f, 1.62976995e-01f,
  1.60384446e-01f, 8.63029957e-02f, 1.40551850e-01f, 8.74592289e-02f, 1.41910598e-01f, -5.82925156e-02f, -8.94612595e-02f, 8.94380584e-02f, -1.67281795e-02f, 6.28172979e-02f,
  8.08876380e-02f, 8.73187929e-02f, -3.32515687e-02f, 1.82396993e-01f, 7.10120201e-02f, -1.10519268e-02f, 8.29369482e-03f, -1.97576195e-01f, 1.68198436e-01f, -6.36342764e-02f,
  1.71138704e-01f, 2.50262092e-03f, -3.09717178e-01f, 8.68415162e-02f, 4.37630899e-02f, -7.66214579e-02f, 3.65811437e-02f, 8.19879770e-02f, -1.07037850e-01f, 4.61841114e-02f,
  -5.87287685e-03f, -1.37079179e-01f, 1.48008496e-01f, 1.32934645e-01f, 4.41424511e-02f, -1.49744883e-01f, 1.34045735e-01f, 2.92287290e-01f, 1.09577768e-01f, 1.38350427e-01f,
  1.05972677e-01f, -1.09803356e-01f, 4.90790466e-03f, -4.56337910e-03f, 9.86783430e-02f, 2.10451007e-01f, -3.79125476e-02f, 2.39957571e-01f, 1.98012769e-01f, 1.08433463e-01f,
  -1.49334043e-01f, -4.03983369e-02f, -6.68654889e-02f, 1.47687331e-01f, 9.18453038e-02f, 2.52988249e-01f, 3.48724537e-02f, 3.83990668e-02f, 1.32412046e-01f, 6.68312982e-02f,
  2.49808863e-01f, 3.50786775e-01f, -6.43993020e-02f, -2.16393080e-02f, -3.52089852e-02f, -9.62959677e-02f, 1.15046039e-01f, 3.40529270e-02f, 7.29066925e-03f, 4.06329595e-02f,
  -5.27540687e-03f, -2.39266292e-03f, 8.86643380e-02f, -8.81819613e-03f, 3.66804339e-02f, 1.22471936e-01f, 1.58514008e-02f, 2.03096028e-03f, -9.18716267e-02f, 1.26647383e-01f,
  -5.96462861e-02f, 6.57720715e-02f, -1.98199555e-01f, 6.17994145e-02f, 3.46616805e-02f, 1.19907916e-01f, 2.04114154e-01f, -1.19411089e-01f, 9.58683062e-03f, -9.72535238e-02f,
  -1.96805567e-01f, -1.42185017e-01f, 8.52673426e-02f, 6.54690489e-02f, 4.70631532e-02f, 1.39677390e-01f, -4.90453967e-04f, 7.67316669e-02f, -3.56182200e-03f, 2.16609001e-01f,
  -1.04781203e-01f, -4.97810319e-02f, 1.93363428e-01f, 6.57489970e-02f, -1.60506129e-01f, 1.08922832e-03f, 1.15316480e-01f, 3.17538790e-02f, -9.09324437e-02f, -8.93143937e-02f,
  -1.84432715e-02f, -1.61068469e-01f, -1.93220556e-01f, 2.22257152e-01f, 2.32149273e-01f, 9.32523906e-02f, -4.02714685e-02f, -7.08159059e-02f, -1.57904983e-01f, 1.99401185e-01f,
  2.27960676e-01f, 7.73391873e-02f, 9.50688794e-02f, -9.48053971e-02f, 1.85359582e-01f, 5.46277314e-02f, -9.99103412e-02f, 1.73154473e-01f, 1.00762591e-01f, 9.17983428e-02f,
  8.06528330e-02f, 1.53644681e-02f, 4.01450247e-02f, 1.92373738e-01f, -3.68504575e-03f, 9.66031179e-02f, 4.48334590e-02f, 4.85465117e-02f, -1.96283218e-02f, 3.43253389e-02f,
  5.75109199e-02f, 1.49965644e-01f, 1.25659153e-01f, 9.22711119e-02f, 1.78276315e-01f, -2.10140571e-02f, -1.09926142e-01f, -2.06899773e-02f, -8.55635405e-02f, -1.36417508e-01f,
  7.93379247e-02f, 8.81108940e-02f, -2.31037065e-02f, 2.69987226e-01f, -9.10890773e-02f, -9.67172682e-02f, -4.97403257e-02f, -3.42889950e-02f, 1.01671450e-01f, -3.53437103e-02f,
  6.01838604e-02f, 4.17909883e-02f, -1.10188261e-01f, -1.03953451e-01f, 1.17451765e-01f, -2.02988058e-01f, -1.31177023e-01f, 9.52666923e-02f, 1.36083700e-02f, 7.47982338e-02f,
  5.53966090e-02f, 3.99277173e-02f, 9.27784890e-02f, -3.77911106e-02f, 1.18488483e-01f, 5.65161593e-02f, -5.72888367e-02f, -6.50408119e-02f, 2.95366526e-01f, -1.29491121e-01f,
  1.49984330e-01f, -1.61461577e-01f, 9.25358385e-02f, -8.36784914e-02f, -8.75608176e-02f, -9.10239890e-02f, 1.29883021e-01f, 2.03385130e-01f, -1.24728106e-01f, -2.49412850e-01f,
  2.38299653e-01f, -8.90520066e-02f, 5.32217883e-02f, 1.18975341e-02f, -7.26977810e-02f, 2.36414769e-03f, -1.54574409e-01f, 1.22628644e-01f, 2.15840936e-01f, 9.17330161e-02f,
  3.14426497e-02f, 2.07355171e-01f, 1.14043713e-01f, 1.76836923e-01f, 1.45404801e-01f, 1.14390440e-01f, 1.44260302e-01f, 2.01663554e-01f, -8.50248262e-02f, 1.47348881e-01f,
  -1.46971881e-01f, 1.32766999e-02f, 2.40898788e-01f, -8.43256712e-02f, -1.72637224e-01f, 8.99389908e-02f, -2.84708351e-01f, -3.25189158e-02f, 2.45887205e-01f, 2.66686469e-01f,
  -2.12702990e-01f, -1.26225218e-01f, 5.17686866e-02f, 6.09002002e-02f, -1.30059659e-01f, 3.11288591e-02f, 2.20200866e-01f, 3.67613852e-01f, -6.28442690e-02f, -1.11238807e-01f,
  -7.86063224e-02f, -5.76223508e-02f, 1.47624202e-02f, 4.89204787e-02f, 1.45392776e-01f, -5.23954257e-02f, -2.13889599e-01f, 1.72781661e-01f, 3.34044965e-03f, 2.30834544e-01f,
  -6.04359098e-02f, -1.41982749e-01f, -1.08572803e-01f, -1.55071244e-01f, -5.76785691e-02f, -2.19602156e-02f, 1.51746392e-01f, 3.83316688e-02f, -1.57881305e-01f, -1.27456516e-01f,
  1.85905591e-01f, -1.58053830e-01f, -2.99345195e-01f, -1.62679359e-01f, 6.92977058e-03f, -6.90552741e-02f, -1.49187967e-01f, -1.62100002e-01f, -1.78958029e-01f, 1.31264836e-01f,
  -2.84313969e-02f, 1.43043965e-01f, 2.30993450e-01f, 4.83066961e-02f, 8.64430051e-03f, 1.48160502e-01f, -1.84881333e-02f, -1.25520714e-02f, 1.35113254e-01f, -5.99145517e-02f,
  -1.63730718e-02f, 4.94170971e-02f, 1.35335501e-03f, 2.28872120e-01f, -3.49586047e-02f, 5.31852692e-02f, -1.23554111e-01f, -5.82697168e-02f, 6.28171116e-02f, -3.54665145e-02f,
  6.64410740e-02f, 6.56009419e-03f, 2.54475083e-02f, -2.11687788e-01f, -5.51363304e-02f, 2.37415843e-02f, 8.33121836e-02f, 2.55760133e-01f, -1.67308792e-01f, 1.37952968e-01f,
  1.01423576e-01f, 2.55862594e-01f, -9.82317254e-02f, -1.11561194e-01f, 2.74411626e-02f, -1.97465360e-01f, 8.60005394e-02f, 1.56005487e-01f, -1.37340471e-01f, 1.19096607e-01f,
  -5.23825660e-02f, -1.30640656e-01f, 1.27462849e-01f, 1.40314847e-01f, -1.43155798e-01f, -3.63949500e-02f, 9.60529596e-02f, 9.74080935e-02f, 1.55509621e-01f, -7.77117088e-02f,
  -1.20206393e-01f, -2.66756177e-01f, -2.48281807e-02f, -9.91097316e-02f, -2.02642247e-01f, -1.01406969e-01f, -2.34885991e-01f, -2.27681547e-01f, 8.36517289e-02f, 1.73274219e-01f,
  1.72354162e-01f, 2.29846999e-01f, -7.10331351e-02f, 1.43462986e-01f, 4.83142510e-02f, 4.26773466e-02f, 2.79243171e-01f, 1.23540387e-01f, 8.52878913e-02f, 9.69775692e-02f,
  2.48299628e-01f, 6.72175512e-02f, 9.21190083e-02f, 1.24151655e-01f, 2.52739012e-01f, 1.25547409e-01f, -6.10794425e-02f, 6.94540814e-02f, 1.63869768e-01f, 1.93278044e-02f,
  -6.40057623e-02f, -1.38747513e-01f, -1.75601661e-01f, -5.72530329e-02f, -2.04778224e-01f, -3.18224840e-02f, 2.43233502e-01f, 1.68949381e-01f, 6.93323836e-02f, -4.48125526e-02f,
  -1.02877021e-01f, -3.62633131e-02f, 7.43827596e-02f, -1.40915498e-01f, 7.00905100e-02f, 8.15772787e-02f, 1.50813162e-01f, -3.35547253e-02f, -2.48784982e-02f, -9.10151526e-02f,
  2.80303527e-02f, 1.31174162e-01f, -1.33121550e-01f, -6.07508868e-02f, 2.00235069e-01f, 2.65442193e-01f, 1.26409516e-01f, 1.86637752e-02f, 4.23634611e-02f, -2.10471019e-01f,
  -1.39034986e-01f, 2.18247607e-01f, 1.11702256e-01f, 1.04325540e-01f, 8.87201801e-02f, -2.12736242e-03f, -4.95274030e-02f, -3.90090235e-02f, -5.53493463e-02f, 4.02975455e-03f,
  -3.80514711e-02f, 1.59263182e-02f, 7.87637159e-02f, -1.76733032e-01f, 8.79157893e-03f, 2.33171694e-02f, -5.80429174e-02f, -5.29009029e-02f, 1.66929394e-01f, 2.97335838e-03f,
  1.06618710e-01f, 1.38657838e-01f, -1.30031006e-02f, -3.55793610e-02f, 1.51953578e-01f, 4.74895649e-02f, -4.70534377e-02f, 4.51286621e-02f, 9.48179811e-02f, 5.44971377e-02f,
  -1.77716747e-01f, 1.56280156e-02f, 1.51300818e-01f, 2.59709684e-03f, 8.70232880e-02f, -9.44453031e-02f, -1.61943600e-01f, -3.08860447e-02f, -2.23607957e-01f, -1.67951316e-01f,
  1.85133308e-01f, 1.22020110e-01f, 1.11789122e-01f, -6.59167096e-02f, -5.73318452e-02f, 1.23595325e-02f, 5.32707162e-02f, -9.71801355e-02f, 6.03222698e-02f, 1.19262435e-01f,
  1.82982534e-02f, -1.13210738e-01f, 1.35522857e-01f, -3.38720419e-02f, -2.92465892e-02f, 9.68526676e-02f, -7.96280280e-02f, -6.14935458e-02f, 4.37094122e-02f, 1.46884918e-01f,
  3.81213874e-02f, -5.75785823e-02f, 9.20584425e-02f, -1.17836207e-01f, -1.91930115e-01f, 2.89426327e-01f, 1.67049333e-01f, 6.84843957e-02f, 7.15327188e-02f, -8.45510513e-02f,
  -4.46030311e-03f, 1.26520827e-01f, -8.84538516e-02f, 2.08471989e-04f, -2.80348882e-02f, 1.28192469e-01f, 8.35045576e-02f, -1.00591198e-01f, 4.05586585e-02f, 1.24558069e-01f,
  3.45636420e-02f, -1.57535836e-01f, -1.19755687e-02f, 1.38794959e-01f, -2.13333238e-02f, 2.06693914e-03f, 5.10547636e-03f, 1.15779631e-01f, 4.26736698e-02f, 4.41183560e-02f,
  9.83248800e-02f, -1.01705447e-01f, -2.50995532e-02f, 3.87762152e-02f, -3.30574773e-02f, 5.29029965e-02f, 9.48416665e-02f, 9.51276422e-02f, -4.58106399e-03f, -4.89406176e-02f,
  9.27331671e-02f, -2.76138019e-02f, 2.17692330e-01f, -6.84819818e-02f, 3.77208516e-02f, -1.27068043e-01f, -2.05285117e-01f, 1.25153691e-01f, 1.34562552e-01f, 5.23810498e-02f,
  -4.17378694e-02f, 2.33066976e-01f, -5.40688671e-02f, 1.12050682e-01f, 4.97461706e-02f, 2.55932033e-01f, -5.23572080e-02f, -9.49296504e-02f, 3.29717219e-01f, -2.78108660e-03f,
  -1.87259465e-01f, 2.20927104e-01f, -8.40788782e-02f, 4.47743647e-02f, -7.75058270e-02f, 5.44213317e-02f, 1.38941482e-01f, 1.32400334e-01f, -1.10558495e-02f, -3.91321294e-02f,
  7.08618760e-02f, 1.54850617e-01f, -8.63048434e-02f, -6.05658302e-03f, 1.05038118e-02f, 3.11194151e-03f, 4.82801497e-02f, 1.92243978e-02f, -2.60885879e-02f, 1.55844167e-01f,
  -2.69304924e-02f, 2.03040212e-01f, 1.64790094e-01f, 3.77457850e-02f, 1.35475963e-01f, 1.30825847e-01f, 3.64103690e-02f, 1.33138359e-01f, 1.74807206e-01f, 6.07254878e-02f,
  7.07322955e-02f, 4.96638715e-02f, 1.50968313e-01f, 2.59238705e-02f, -2.17656931e-03f, -1.21965885e-01f, 6.10613674e-02f, 1.06818989e-01f, -2.16477767e-01f, 5.88647500e-02f,
  9.32059437e-02f, 2.17466533e-01f, 1.00945413e-01f, -6.76999316e-02f, 4.12174538e-02f, -1.48707807e-01f, 6.20224997e-02f, -1.56756133e-01f, 1.16271518e-01f, -5.32389842e-02f,
  -1.36311457e-01f, 5.84661737e-02f, -1.33214876e-01f, 1.98201574e-02f, -8.96959603e-02f, 1.22966602e-01f, 6.10941760e-02f, 2.75106370e-01f, -9.79687050e-02f, 1.43831894e-01f,
  -4.85559851e-02f, -1.49624810e-01f, 2.19754875e-01f, 1.10855699e-01f, -1.08516015e-01f, 1.93852976e-01f, -7.24008158e-02f, 1.85447365e-01f, 7.47950077e-02f, -2.21685529e-01f,
  1.07141308e-01f, 1.27845585e-01f, -1.47205457e-01f, -9.76835750e-03f, 7.67425373e-02f, 1.18423440e-01f, -8.75135437e-02f, 9.98073607e-04f, -5.22690006e-02f, -1.42662361e-01f,
  7.89922178e-02f, -7.93913528e-02f, -1.75846815e-02f, 4.20390032e-02f, -8.08799081e-03f, 1.78272605e-01f, 2.39740629e-02f, -4.93167154e-02f, 1.48863032e-01f, 1.49347425e-01f,
  1.70045216e-02f, 1.16453648e-01f, 5.05636558e-02f, 2.44029790e-01f, 1.21024929e-01f, -9.82593466e-03f, 1.63350165e-01f, 2.82563180e-01f, 1.00465909e-01f, 8.49872157e-02f,
  2.11482435e-01f, 5.86360618e-02f, -7.49486014e-02f, 1.00048736e-01f, 2.07958072e-02f, 1.19425654e-02f, 2.17307240e-01f, -1.32165104e-02f, -1.58731222e-01f, -1.62747763e-02f,
  -3.00171465e-01f, 2.85551269e-02f, 2.55074620e-01f, 3.85555863e-01f, -1.38808370e-01f, -1.34611875e-02f, 8.28845650e-02f, -2.57757455e-01f, -1.22654311e-01f, -2.22995520e-01f,
  -1.41908824e-01f, -1.78987551e-02f, -1.43652344e-02f, 9.14545655e-02f, -1.88161030e-01f, -1.16104819e-01f, 3.29068244e-01f, 4.98009846e-03f, 3.20330650e-01f, -1.80092111e-01f,
  -5.03946804e-02f, 2.47583926e-01f, 1.76063944e-02f, 1.18394308e-01f, 3.08658212e-01f, -2.38655701e-01f, -1.16243539e-03f, -1.38946071e-01f, 9.14188102e-02f, 2.14800641e-01f,
  2.13439450e-01f, 1.04008177e-02f, -1.59696221e-01f, -1.12036437e-01f, 3.83461177e-01f, 7.15005258e-03f, -2.10323632e-01f, -7.57428184e-02f, 1.55850649e-01f, -2.15894759e-01f,
  -1.71163827e-01f, -2.10654795e-01f, -1.31716754e-03f, 6.06028810e-02f, -2.50264276e-02f, 1.92221388e-01f, 4.31998260e-02f, -3.85885537e-02f, 1.55532852e-01f, 3.46006383e-03f,
  -1.25720963e-01f, 1.09113008e-01f, 7.96607137e-02f, -1.77250385e-01f, -8.62963647e-02f, 9.06415135e-02f, 2.65953373e-02f, 7.67823532e-02f, -1.54363826e-01f, 1.24912456e-01f,
  -1.89269736e-01f, -4.43659425e-02f, 2.68175244e-01f, -1.39149353e-01f, 2.59720117e-01f, 1.57015353e-01f, -9.49404612e-02f, -2.83761322e-01f, -1.90027624e-01f, 7.03221932e-03f,
  1.28994569e-01f, 1.82351440e-01f, -4.66368645e-02f, 1.11876927e-01f, 3.35240588e-02f, 5.09659089e-02f, -1.36627844e-02f, -3.95314628e-03f, -1.29204080e-01f, -6.36704117e-02f,
  1.05977200e-01f, 8.69482979e-02f, -1.47756115e-01f, 2.54047096e-01f, -5.46856858e-02f, -1.97687641e-01f, -1.09726638e-01f, -4.28978875e-02f, -1.37417614e-01f, 1.29339010e-01f,
  2.62927175e-01f, -3.12300306e-02f, 9.32887755e-03f, -1.50149897e-01f, -1.19246401e-01f, -1.61662117e-01f, 3.45934369e-02f, -1.20029196e-01f, -7.63528943e-02f, -6.93238899e-02f,
  -4.30768821e-03f, -1.06714718e-01f, 3.11928038e-02f, 2.44316429e-01f, 1.19313352e-01f, 1.28280506e-01f, 2.29405575e-02f, 5.60379736e-02f, 1.60726514e-02f, 7.21053481e-02f,
  2.47553840e-01f, 8.16606283e-02f, 5.67077622e-02f, -4.96289432e-02f, 1.75672293e-01f, 1.41967580e-01f, -2.77836900e-02f, 1.09956630e-01f, 4.40237224e-02f, 7.46525452e-02f,
  -2.03906924e-01f, 5.55072352e-02f, -8.22741240e-02f, 7.60210827e-02f, 1.13965318e-01f, -2.34872065e-02f, 1.37157768e-01f, 3.57132331e-02f, -2.13887498e-01f, -1.77849874e-01f,
  -9.65617299e-02f, -9.51476321e-02f, 2.54721045e-01f, -6.44203126e-02f, -1.39963582e-01f, 1.10148810e-01f, -8.07312652e-02f, 2.21064147e-02f, 3.17576528e-02f, 3.65760475e-01f,
  6.20236136e-02f, -2.69795805e-01f, 2.45109901e-01f, 1.71530008e-01f, -9.78905126e-04f, 2.29451105e-01f, -5.13227545e-02f, 1.05194282e-02f, -1.13225542e-01f, -2.12976858e-02f,
  2.97280878e-01f, -2.44576946e-01f, -1.97523415e-01f, -5.84975407e-02f, 1.56052113e-02f, 2.43816450e-01f, 1.79108173e-01f, -5.17389588e-02f, 8.99321586e-02f, -1.40892774e-01f,
  1.49828076e-01f, 9.80068967e-02f, -1.97381034e-01f, 8.79096836e-02f, -8.47145319e-02f, 8.38158652e-02f, 1.58514947e-01f, 9.51814000e-03f, 6.41564876e-02f, 2.26632193e-01f,
  1.92600545e-02f, -8.61443132e-02f, 1.75934002e-01f, -4.04307023e-02f, -5.53931221e-02f, -5.68492375e-02f, -1.48912705e-02f, 8.21497664e-02f, 9.63809937e-02f, 1.19415984e-01f,
  8.75660107e-02f, -5.50456159e-02f, 1.60386576e-03f, 6.94946945e-02f, -3.36406156e-02f, -2.12603912e-01f, -1.08600082e-02f, 2.17353255e-01f, 1.59843728e-01f, 1.29708767e-01f,
  -3.37287560e-02f, -1.96278512e-01f, 1.52249530e-01f, -2.79369831e-01f, -2.01584399e-02f, -1.02227375e-01f, -1.26899391e-01f, 1.58246219e-01f, -1.42645940e-01f, 4.07283120e-02f,
  1.48835212e-01f, 1.37934953e-01f, 2.53157262e-02f, 1.11399777e-01f, 8.50308388e-02f, 1.89459637e-01f, 9.54948887e-02f, 6.61631301e-02f, 7.17277154e-02f, -1.59809306e-01f,
  -1.28155291e-01f, 4.64536771e-02f, 9.09627751e-02f, 5.89382201e-02f, -4.35160752e-03f, -2.38369197e-01f, 1.19659401e-01f, 1.79792956e-01f, -2.21285015e-01f, 5.25937639e-02f,
  -1.05095774e-01f, 1.95403084e-01f, -6.60876557e-02f, 1.64860874e-01f, 1.89123154e-01f, 1.21312015e-01f, 1.12232693e-01f, 1.36908516e-02f, 2.68575758e-01f, 3.67922902e-01f,
  -6.15705512e-02f, 1.52677923e-01f, -2.12657843e-02f, -2.45792791e-02f, 2.90131330e-01f, -5.53107541e-03f, 2.78151948e-02f, -1.43843321e-02f, 2.72840349e-04f, 2.36442201e-02f,
  -7.92604014e-02f, -1.63776167e-02f, 5.59032857e-02f, 1.00991935e-01f, 4.10465524e-02f, 1.00706806e-02f, -9.39885825e-02f, 1.43175330e-02f, -4.22519557e-02f, -2.26349965e-01f,
  -4.31151278e-02f, 1.53972149e-01f, 1.87335789e-01f, 9.78743210e-02f, -2.26130653e-02f, -6.11643754e-02f, -2.06865687e-02f, -2.32676283e-01f, 4.97580394e-02f, 5.90341724e-03f,
  1.71567255e-03f, 2.04841397e-03f, -2.18198135e-01f, 1.72374062e-02f, 1.25553831e-01f, 8.96474272e-02f, 1.17366053e-01f, 1.45189419e-01f, -7.53310695e-02f, 1.52281255e-01f,
  1.66555151e-01f, 1.48545206e-01f, -9.58227366e-02f, -1.04949839e-01f, 7.99775030e-03f, 6.42350167e-02f, -7.15484917e-02f, 5.41399084e-02f, 2.51909457e-02f, -1.56488866e-01f,
  -5.05544841e-02f, 2.26876378e-01f, -1.80555522e-01f, -2.31400976e-04f, -1.96144860e-02f, 9.73311067e-02f, -2.94336826e-02f, 2.51990288e-01f, 9.24797505e-02f, 4.78239134e-02f,
  4.33159024e-02f, -7.18101934e-02f, 2.70184457e-01f, 2.06143305e-01f, -1.08619988e-01f, 2.55824793e-02f, -1.30759329e-01f, 3.23226629e-03f, 2.19149917e-01f, 1.09651312e-01f,
  1.44012064e-01f, -2.29094494e-02f, -9.73750353e-02f, 1.01557739e-01f, 1.04902439e-01f, -3.62898000e-02f, 7.97533151e-03f, 1.39297560e-01f, 1.65208086e-01f, 1.91320837e-01f,
  7.42706880e-02f, -9.69657823e-02f, -1.11684263e-01f, -6.39165193e-02f, -2.39289761e-01f, -1.93391725e-01f, -5.56016192e-02f, 2.37935528e-01f, 1.75364822e-01f, 1.37882948e-01f,
  -1.71592399e-01f, -1.35777583e-02f, -2.48617262e-01f, -8.95079970e-02f, 3.60407978e-01f, -1.28842518e-01f, 1.26455426e-01f, -4.95154299e-02f, 5.79841919e-02f, -7.45336786e-02f,
  -1.65054947e-01f, -7.08328560e-02f, -5.46144955e-02f, -1.82010829e-01f, 1.75730184e-01f, 3.09917241e-01f, -1.14981122e-01f, -3.81138809e-02f, 1.70850560e-01f, -6.97619990e-02f,
  -8.00032839e-02f, -1.50142416e-01f, 1.33507639e-01f, -3.95447239e-02f, -1.43806189e-01f, 8.36089775e-02f, 2.84065157e-01f, 1.30207315e-01f, 8.13250244e-02f, 6.95039798e-03f,
  2.33796194e-01f, 9.04415846e-02f, 3.05586904e-01f, 2.88024932e-01f, 1.11792788e-01f, 2.00851396e-01f, 1.57931119e-01f, -3.55477631e-03f, -3.54740918e-02f, -9.16034654e-02f,
  1.07012898e-01f, 1.41519964e-01f, -6.28485084e-02f, -1.16351530e-01f, 1.79144397e-01f, 1.59482256e-01f, -6.29268438e-02f, -3.91157828e-02f, 6.59824833e-02f, -2.68969685e-02f,
  -1.53461080e-02f, 4.44425605e-02f, 7.98314884e-02f, -4.84474972e-02f, 4.62142825e-02f, 1.57867089e-01f, 9.77592319e-02f, -1.87413052e-01f, 1.56278554e-02f, 2.67777622e-01f,
  -1.49008736e-01f, 4.49435078e-02f, 2.32405886e-01f, -1.58702150e-01f, 2.53161848e-01f, 5.80108538e-02f, -3.10889073e-02f, -2.23386824e-01f, -1.91264138e-01f, 1.59149289e-01f,
  -5.48713431e-02f, 1.11079849e-01f, 1.08554974e-01f, 1.61269322e-01f, -3.08097713e-02f, -7.01269805e-02f, 1.38957545e-01f, 2.30708539e-01f, -1.61279783e-01f, -5.26404493e-02f,
  2.34519541e-01f, -1.14745945e-01f, -1.46299332e-01f, 1.76178515e-01f, 2.16958776e-01f, 7.47572398e-04f, -7.77202770e-02f, -2.70822376e-01f, 8.68778750e-02f, 2.78166175e-01f,
  1.66729942e-01f, -2.06281930e-01f, -3.09397113e-02f, 8.11327472e-02f, -1.19082510e-01f, 1.14752993e-01f, 1.21440075e-01f, -9.11779851e-02f, 4.77661932e-04f, 1.12957723e-01f,
  2.19390407e-01f, 2.44370282e-01f, -3.87250143e-03f, 9.66438130e-02f, 3.96223851e-02f, -1.53664112e-01f, 3.59729022e-01f, 1.37492850e-01f, 1.33304492e-01f, 1.90331832e-01f,
  -1.18789179e-02f, 7.92596936e-02f, 2.90672146e-02f, 1.41073942e-01f, 1.29912362e-01f, 1.34674117e-01f, 1.11556046e-01f, 9.28789098e-03f, 6.70476630e-02f, 1.41390920e-01f,
  -1.53171912e-01f, -1.10545211e-01f, 3.60801496e-04f, 1.51680559e-01f, 5.05951643e-02f, 1.01301678e-01f, 1.02998875e-01f, -1.25654906e-01f, 1.62239000e-01f, -6.03631251e-02f,
  -1.03963532e-01f, -3.54754031e-02f, -1.67330399e-01f, 1.03757121e-01f, -5.90195805e-02f, -9.94721800e-02f, 7.07220286e-02f, 1.07010059e-01f, -4.47822474e-02f, 6.18484691e-02f,
  -6.00070283e-02f, 2.33235121e-01f, -1.25461474e-01f, -7.87803754e-02f, 2.82260805e-01f, -9.30435956e-02f, 4.91619743e-02f, 9.69050154e-02f, -2.49108281e-02f, 2.32427210e-01f,
  -8.79028141e-02f, -2.07581162e-01f, 2.08068848e-01f, 1.83502674e-01f, 4.60676774e-02f, -1.78161904e-01f, 3.12857591e-02f, 2.26994380e-01f, -6.73698410e-02f, 1.71398163e-01f,
  4.60190400e-02f, -9.71876010e-02f, 1.87959254e-01f, 3.02650407e-02f, 1.51127860e-01f, 2.06264392e-01f, -3.12017687e-02f, 9.64541957e-02f, 1.38708860e-01f, -7.06496909e-02f,
  1.90036803e-01f, 1.22301593e-01f, 5.30721173e-02f, 1.06608994e-01f, 2.05722421e-01f, -1.30879506e-01f, 3.15745641e-03f, 3.30763683e-02f, 3.84278456e-03f, -6.40215203e-02f,
  9.30213258e-02f, -1.46642119e-01f, 6.77133873e-02f, 1.93023443e-01f, 2.80967727e-02f, -4.92733978e-02f, -2.50114761e-02f, 2.47558981e-01f, -3.39751281e-02f, -1.26531065e-01f,
  6.51059896e-02f, -1.95496574e-01f, 1.17369637e-01f, -8.44150782e-02f, 1.76033210e-02f, -2.54827231e-01f, -9.42692533e-02f, 1.49905473e-01f, -8.47764015e-02f, 1.25662595e-01f,
  1.58016950e-01f, 9.49447788e-03f, 1.77847341e-01f, 9.21661407e-02f, 7.01019540e-02f, -7.47905523e-02f, -7.31103495e-03f, -1.39516354e-01f, -1.84446231e-01f, 1.41248345e-01f,
  -1.83461517e-01f, 1.60017103e-01f, 2.37499088e-01f, -1.68469593e-01f, 5.81542077e-03f, -8.48277882e-02f, -1.40113667e-01f, 1.88900635e-01f, -5.72517863e-04f, 2.71788061e-01f,
  1.16388157e-01f, -4.89376672e-02f, -2.33444855e-01f, 6.82234913e-02f, 8.37521553e-02f, -6.14308603e-02f, -2.06413284e-01f, 1.34900762e-02f, 1.67466819e-01f, 7.76687786e-02f,
  5.66455200e-02f, 1.62982970e-01f, 3.92447114e-02f, 1.13257296e-01f, 2.36207426e-01f, 1.08290993e-01f, 3.28907669e-02f, -5.72216557e-03f, -6.21079654e-03f, 1.21430025e-01f,
  1.58493355e-01f, 1.33489266e-01f, 4.46309187e-02f, 6.84377775e-02f, 9.64379683e-02f, 2.12926224e-01f, 1.60807073e-01f, -2.37839613e-02f, 1.93397030e-01f, -1.31351560e-01f,
  1.71584383e-01f, -1.56827927e-01f, 5.58842905e-02f, -6.28151745e-02f, -1.92579687e-01f, 1.39839560e-01f, 1.57927051e-02f, 1.77063525e-01f, 7.47526959e-02f, 1.67961031e-01f,
  -7.43351504e-02f, 1.22608915e-01f, 8.88532028e-02f, -3.26352119e-02f, 2.54449904e-01f, 7.26532307e-04f, -5.89246452e-02f, -2.79414862e-01f, 2.01193586e-01f, 5.88152260e-02f,
  -6.76090047e-02f, 1.27389789e-01f, 1.08003624e-01f, -1.20065115e-01f, 1.56787440e-01f, -7.02521876e-02f, 1.20602630e-01f, 8.89752358e-02f, -5.03209382e-02f, 3.26084971e-01f,
  2.87244827e-01f, -3.04353740e-02f, 3.58236730e-02f, -9.66746360e-02f, 8.74459520e-02f, 1.06439099e-01f, 1.80274263e-01f, 3.90862450e-02f, -7.07231760e-02f, 5.82854263e-02f,
  2.12755829e-01f, 2.28783786e-01f, -1.48623642e-02f, 1.11137070e-01f, 1.20945364e-01f, -8.59439820e-02f, 5.43235838e-02f, -9.54035670e-02f, 9.13758948e-02f, -2.05695406e-02f,
  -1.51259854e-01f, 1.19578287e-01f, 1.32419527e-01f, 4.73527461e-02f, 8.89556762e-03f, 1.10402830e-01f, 4.62977029e-02f, 1.41795218e-01f, 1.09902076e-01f, -2.32151616e-02f,
  7.49683529e-02f, 3.29962224e-02f, 5.99386133e-02f, 1.42458931e-01f, -6.96939453e-02f, -2.25834958e-02f, 9.66850966e-02f, 3.52993794e-02f, -1.04757376e-01f, 2.35340614e-02f,
  -8.92055035e-02f, 1.16967164e-01f, 1.11858003e-01f, 1.48865983e-01f, -7.46872425e-02f, 9.26385894e-02f, 1.25869617e-01f, 9.77610052e-02f, -1.28035694e-01f, 1.45956457e-01f,
  2.88368259e-02f, 1.10543966e-01f, -6.83115274e-02f, 3.63822430e-02f, -1.02974862e-01f, -2.91227065e-02f, 1.61814228e-01f, 6.19386882e-02f, 2.64242262e-01f, 8.31680372e-02f,
  -5.34300208e-02f, 9.15788040e-02f, 2.16927473e-02f, 3.50996584e-01f, 1.52797224e-02f, -1.36387274e-01f, 1.65690929e-02f, -1.00399822e-01f, -4.37465198e-02f, 2.82417461e-02f,
  2.26751700e-01f, -6.94044456e-02f, -1.22519135e-01f, -4.60575409e-02f, 1.94472834e-01f, -3.37767564e-02f, -3.00551742e-01f, -1.74904421e-01f, 1.05800785e-01f, -1.21833961e-02f,
  3.12433746e-02f, -2.81615891e-02f, -2.44685456e-01f, 1.73793748e-01f, -1.11465855e-02f, -1.01014644e-01f, -4.42922302e-02f, -9.02967304e-02f, -4.08994034e-02f, 4.63806652e-02f,
  6.16277345e-02f, -2.93006357e-02f, -3.66807617e-02f, 1.17923975e-01f, 2.95001268e-02f, -1.29240066e-01f, 7.99878389e-02f, -1.12369984e-01f, -3.82015598e-03f, -1.92944616e-01f,
  1.89550206e-01f, 8.37289467e-02f, -2.09553346e-01f, 1.43303514e-01f, -1.35590851e-01f, -1.10109314e-01f, -7.95648098e-02f, -2.02433742e-03f, 7.02679157e-02f, -5.28718457e-02f,
  -3.60681415e-02f, 9.79636535e-02f, 9.75480527e-02f, 1.98102027e-01f, 1.14576913e-01f, -1.00388881e-02f, 4.99271974e-02f, 1.11007560e-02f, 2.68317074e-01f, 2.22698376e-01f,
  -1.78321153e-01f, -1.44603383e-02f, 1.27314568e-01f, -3.30986083e-03f, -2.72551626e-02f, -7.67073482e-02f, 1.58673137e-01f, 2.36310348e-01f, -7.16764331e-02f, 8.50946903e-02f,
  -9.46921408e-02f, -5.08914143e-02f, -1.06796801e-01f, 2.08542664e-02f, 1.56891659e-01f, 2.11278424e-01f, 1.36401638e-01f, 2.16897488e-01f, -4.17724514e-04f, 3.64653617e-02f,
  1.85876146e-01f, 2.11880520e-01f, -6.07207492e-02f, 1.35142505e-01f, -8.55447948e-02f, 6.65790960e-02f, 1.69507265e-02f, 4.10680771e-02f, 8.55625495e-02f, 2.80908316e-01f,
  5.99806681e-02f, 4.15179655e-02f, -1.22505957e-02f, 1.56028405e-01f, 8.65854248e-02f, 8.42074677e-02f, 1.71569571e-01f, 1.24801978e-01f, 6.01611808e-02f, 6.04698882e-02f,
  5.64172082e-02f, -4.31062542e-02f, 1.63377732e-01f, 5.54565601e-02f, -2.98762992e-02f, 2.23881993e-02f, -1.95836022e-01f, -3.53995152e-02f, 7.70307779e-02f, 9.20723975e-02f,
  2.34916061e-01f, 1.55087426e-01f, -2.06257939e-01f, 1.60491064e-01f, 1.81007549e-01f, -6.88077300e-04f, 4.97284308e-02f, 1.47927523e-01f, 1.71967372e-02f, -1.13621727e-01f,
  1.18560597e-01f, 2.63740033e-01f, -2.26544455e-01f, -1.02750130e-01f, 2.26876915e-01f, 3.45113315e-02f, 2.27285773e-01f, 6.44049197e-02f, 8.39286819e-02f, 2.92481810e-01f,
  -1.02518857e-01f, 3.65213484e-01f, 2.67919511e-01f, -3.53452712e-02f, -5.18717095e-02f, -1.23411834e-01f, -8.50581750e-02f, 1.66789144e-01f, 1.33481458e-01f, 1.13645621e-01f,
  -2.02618971e-01f, -5.79957291e-02f, 2.71007776e-01f, -1.44246602e-02f, -6.54256344e-02f, 9.89382491e-02f, 3.91927697e-02f, 3.84179433e-03f, -4.71803993e-02f, -1.34288758e-01f,
  7.15354085e-02f, 2.18398720e-01f, 4.65477221e-02f, -5.51296584e-02f, -5.78211918e-02f, -1.28898308e-01f, -2.22779415e-03f, 2.56140567e-02f, -6.39897725e-03f, -8.00897330e-02f,
  -3.24088777e-03f, -3.67105603e-02f, -2.80409325e-02f, 6.31974488e-02f, -2.32793763e-02f, -1.10559367e-01f, -1.02246311e-02f, 8.33812281e-02f, -1.77023839e-02f, 5.14560342e-02f,
  -5.63654043e-02f, -1.20236829e-01f, 9.28010270e-02f, -1.44437268e-01f, -9.83746573e-02f, -1.79106504e-01f, 8.10328126e-03f, 7.27529153e-02f, -5.71585298e-02f, 2.32962966e-02f,
  1.34946823e-01f, 6.01143055e-02f, 6.92170784e-02f, -2.20361296e-02f, -7.51803964e-02f, 1.75925389e-01f, 1.72717765e-01f, -3.75417760e-03f, -9.51828286e-02f, -2.22224277e-02f,
  -8.00925493e-02f, 4.14562821e-02f, 7.81117454e-02f, -1.06350631e-01f, -1.87871587e-02f, -5.40344566e-02f, 2.55939495e-02f, 2.23297864e-01f, -6.77478686e-02f, 1.96277961e-01f,
  -1.72756687e-02f, 6.47347122e-02f, -2.12357640e-01f, 1.30216554e-01f, 1.76357850e-01f, 6.14305064e-02f, -5.82389943e-02f, -4.58350703e-02f, 2.81935811e-01f, 2.14024171e-01f,
  -1.39987424e-01f, 1.48659736e-01f, 1.03428319e-01f, 8.71408805e-02f, 2.04497427e-01f, -2.17199251e-02f, -6.21898063e-02f, 2.26454109e-01f, 1.79261610e-01f, -2.37419223e-03f,
  1.42909035e-01f, 1.75384149e-01f, -5.58861122e-02f, 1.35649040e-01f, 1.84726685e-01f, -4.32363711e-02f, 3.86266550e-03f, 2.17986092e-01f, 1.73688933e-01f, 6.85161725e-02f,
  3.51995565e-02f, 8.20231959e-02f, 8.67282152e-02f, 2.07834933e-02f, -7.30775148e-02f, -2.20650658e-02f, 6.06336780e-02f, 2.31894597e-01f, 1.50523111e-01f, -4.54739965e-02f,
  -2.74681360e-01f, 2.08767295e-01f, 1.61208704e-01f, 2.12702081e-01f, -6.99323565e-02f, 2.20351383e-01f, 2.10232139e-01f, 7.86532983e-02f, 5.45772538e-02f, 1.44112214e-01f,
  -2.60456949e-01f, -9.13744271e-02f, 2.32095495e-01f, 1.15468599e-01f, 7.99482465e-02f, 2.09948853e-01f, -1.71113983e-02f, 6.55886382e-02f, -3.46593149e-02f, 3.41088653e-01f,
  7.13790804e-02f, 1.69707373e-01f, 4.32157740e-02f, -2.05606282e-01f, 6.94685653e-02f, -1.17473556e-02f, 7.99881741e-02f, -3.30514349e-02f, -1.07638165e-01f, -1.03906967e-01f,
  1.59145862e-01f, -1.03814632e-01f, -8.94326493e-02f, -1.54675514e-01f, 1.53979123e-01f, 2.15505436e-01f, 1.10865064e-01f, -1.17781155e-01f, 4.18578722e-02f, 3.36788535e-01f,
  -4.73903157e-02f, 5.52511327e-02f, -4.48460765e-02f, 2.46330202e-02f, -1.62824411e-02f, 1.27068222e-01f, 3.45409326e-02f, 1.87602818e-01f, 3.54465134e-02f, 1.08758837e-01f,
  9.45968777e-02f, 2.41693277e-02f, 2.87293214e-02f, -4.74923253e-02f, -2.57790070e-02f, -2.26543158e-01f, 7.76425079e-02f, 1.19844325e-01f, -1.21799476e-01f, 1.08138226e-01f,
  -9.12472792e-03f, 4.71989959e-02f, -2.38546446e-01f, 2.84970812e-02f, -1.40649313e-02f, -6.26546741e-02f, 2.04421192e-01f, -7.99203292e-02f, -4.50423285e-02f, 1.89929634e-01f,
  7.15284981e-03f, -1.38042450e-01f, -2.43773103e-01f, 8.67412835e-02f, 1.37883231e-01f, 2.04138681e-01f, -3.46053764e-02f, -8.68576393e-02f, 3.05390149e-01f, 9.60961878e-02f,
  -2.17860982e-01f, 6.77288696e-02f, -2.13867083e-01f, 2.73558527e-01f, 1.44477889e-01f, 8.05986896e-02f, 1.76739886e-01f, -8.97822306e-02f, -1.67049408e-01f, 1.66993558e-01f,
  7.14808926e-02f, 1.47391126e-01f, 1.66583642e-01f, 1.50667354e-01f, 1.95589006e-01f, -1.04249425e-01f, 9.45911482e-02f, 5.33290580e-02f, -2.87292823e-02f, 1.01685695e-01f,
  1.25536144e-01f, 1.03836708e-01f, -8.60537812e-02f, -2.32444517e-02f, 2.00727601e-02f, 1.32744193e-01f, -2.05214545e-02f, 1.99114736e-02f, 1.62905008e-01f, 2.01632485e-01f,
  -9.40551013e-02f, 1.39392003e-01f, 6.14981912e-02f, 1.04989357e-01f, -8.90216902e-02f, 1.77108154e-01f, -7.89038911e-02f, -3.29285562e-02f, -6.65816739e-02f, -1.00480253e-02f,
  -7.47253597e-02f, 9.26247761e-02f, 1.98779926e-01f, 2.23502070e-02f, 1.16306454e-01f, 3.10651138e-02f, -2.21389115e-01f, -1.48956642e-01f, 1.52490824e-01f, -8.02686289e-02f,
  1.97094247e-01f, 4.91620526e-02f, -9.52668674e-03f, 1.52152389e-01f, 4.27706689e-02f, 1.48845106e-01f, -2.18428209e-01f, 8.08613282e-03f, 2.01349035e-01f, 1.72200978e-01f,
  -1.31152451e-01f, 2.66480874e-02f, 1.14468589e-01f, 9.55636334e-03f, -1.29187703e-01f, -1.83701575e-01f, -5.95429875e-02f, -1.42197749e-02f, -1.20633148e-01f, 2.21027747e-01f,
  3.17683220e-01f, 5.87005205e-02f, -1.98064297e-02f, -3.95517237e-03f, -1.06837802e-01f, 9.53710750e-02f, 1.48459271e-01f, 1.86080322e-01f, -4.95423935e-02f, -1.17439695e-01f,
  1.80930004e-01f, 1.71431974e-02f, -2.03877464e-01f, 8.57068151e-02f, 7.85294995e-02f, 1.87934607e-01f, -2.18124799e-02f, -2.13853689e-03f, 3.55411433e-02f, 2.05986261e-01f,
  1.96412072e-01f, 1.15682371e-01f, 1.62505910e-01f, -3.71648110e-02f, 5.00574410e-02f, 1.08646795e-01f, 4.63772565e-02f, -8.80494267e-02f, 8.69949162e-02f, 1.54482260e-01f,
  -1.62955821e-01f, 1.13371909e-01f, -4.64864410e-02f, 1.96822688e-01f, -8.42539519e-02f, -8.68441463e-02f, 2.17749879e-01f, -1.21133544e-01f, 8.94380659e-02f, -7.88476616e-02f,
  2.55019069e-02f, -1.71277612e-01f, -1.39360845e-01f, 2.94616185e-02f, -1.35955652e-02f, 4.95304167e-02f, -9.50598568e-02f, 1.10292114e-01f, 1.18605204e-01f, 2.39355221e-01f,
  4.07692976e-03f, -9.44949985e-02f, -1.23709977e-01f, -1.35902047e-01f, 2.08793193e-01f, 1.78234130e-01f, -1.67301193e-01f, 2.04546347e-01f, 2.12484822e-02f, 3.28097492e-02f,
  5.90060093e-02f, -1.31822973e-01f, -1.08692959e-01f, 1.07723072e-01f, 1.23010203e-01f, 1.55297443e-01f, 7.54135922e-02f, -8.32167193e-02f, -6.70841485e-02f, -2.17927635e-01f,
  4.44451906e-02f, -1.07753366e-01f, -5.63186333e-02f, 6.30665570e-02f, -1.28778532e-01f, -7.90160969e-02f, 1.78968132e-01f, 8.56623054e-02f, 8.94138142e-02f, 8.49007517e-02f,
  2.54852120e-02f, 3.95061597e-02f, 5.92163950e-02f, -2.19848892e-03f, 1.58243801e-03f, 1.45119980e-01f, 2.35822471e-03f, 7.28004426e-02f, 1.80120301e-02f, 1.11156940e-01f,
  7.66828284e-02f, 2.00613201e-01f, 1.53498948e-01f, -3.64269838e-02f, -5.88942468e-02f, -3.68399955e-02f, -2.31623754e-01f, -9.73434076e-02f, -1.49284229e-01f, 8.31089765e-02f,
  2.73080647e-01f, 1.79280397e-02f, -1.56943411e-01f, 6.62613362e-02f, -9.51661915e-02f, -4.68935966e-02f, 2.79819876e-01f, -1.13150299e-01f, 1.48028165e-01f, -1.60292551e-01f,
  -6.05565403e-03f, -1.92942247e-01f, -2.40865007e-01f, -2.79887654e-02f, 9.35462490e-02f, -2.19449088e-01f, 1.35831356e-01f, 1.89659461e-01f, -3.10790613e-02f, 5.61273433e-02f,
  2.64735848e-01f, -8.02971423e-02f, -1.22172879e-02f, -1.27302453e-01f, 1.12391159e-01f, -4.32667248e-02f, -1.19064577e-01f, 8.01265836e-02f, 3.41290236e-01f, 1.12270437e-01f,
  1.46972001e-01f, -5.42118736e-02f, 2.00695470e-01f, 4.77251559e-02f, 1.86364889e-01f, 1.68487847e-01f, 1.94576457e-01f, 1.86714202e-01f, 6.85504526e-02f, -1.47367492e-01f,
  9.77114588e-02f, -1.01848200e-01f, 4.07358594e-02f, 3.76200117e-03f, -1.47966057e-01f, -2.20083907e-01f, -5.25717288e-02f, 9.96923074e-02f, 7.79233053e-02f, -3.51664308e-03f,
  7.63270184e-02f, 1.54904902e-01f, -4.98908237e-02f, 3.67473215e-02f, 7.07530081e-02f, 1.50760999e-02f, -8.58053472e-03f, 5.71408123e-03f, 1.03125945e-01f, 6.79882616e-02f,
  -3.21036354e-02f, 1.64100137e-02f, 3.93259386e-03f, 1.71035007e-02f, -5.94985895e-02f, 4.45525013e-02f, 1.12814903e-01f, 1.77639708e-01f, 1.10225501e-02f, -6.87931478e-03f,
  -2.08605394e-01f, 1.43249352e-02f, 1.81728125e-01f, 1.48899511e-01f, -8.06812793e-02f, 2.34289631e-01f, 1.75272614e-01f, -1.27230654e-03f, -1.06079161e-01f, 1.79264788e-02f,
  -8.14798772e-02f, -6.19621389e-02f, 9.51497331e-02f, 3.38743441e-02f, 9.01149958e-02f, 1.52716458e-01f, -1.20238446e-01f, -2.22842321e-02f, -1.25711545e-01f, 3.95315111e-01f,
  1.00617195e-02f, 6.63141981e-02f, 4.60958965e-02f, -1.13086969e-01f, -3.89957167e-02f, 3.36095132e-02f, 1.17579624e-02f, 2.60283127e-02f, -6.57128636e-03f, -7.83340335e-02f,
  1.50419071e-01f, -9.98872593e-02f, -5.42256683e-02f, -1.29541710e-01f, -3.05269994e-02f, 6.34726360e-02f, 3.22529860e-02f, 7.84895644e-02f, -6.03437796e-02f, 1.74304500e-01f,
  5.31700775e-02f, 8.67402479e-02f, 1.93518013e-01f, 9.89855081e-02f, 8.06283057e-02f, 9.97358561e-03f, 1.65826082e-01f, 2.27634180e-02f, 1.08645923e-01f, 8.30054358e-02f,
  1.37996256e-01f, 1.07951693e-01f, -2.71550771e-02f, 1.13462150e-01f, -4.30305712e-02f, 1.55236460e-02f, -1.31926626e-01f, -2.08683237e-01f, 1.55280575e-01f, -2.75910702e-02f,
  -7.30056167e-02f, 4.00333144e-02f, 7.82321990e-02f, -7.07770437e-02f, 2.57769376e-01f, -4.70749624e-02f, -1.00933099e-02f, 3.57136726e-02f, 7.27681443e-02f, 4.62765656e-02f,
  1.99242961e-02f, 3.18529345e-02f, 2.06926927e-01f, -2.32762098e-01f, -5.67342117e-02f, -1.42501546e-02f, 2.19647549e-02f, 1.63429826e-01f, -9.20560211e-02f, 3.56758796e-02f,
  1.88157946e-01f, 1.50283622e-02f, 6.17322847e-02f, -9.10713226e-02f, -4.31552455e-02f, -6.69736415e-02f, 1.43802106e-01f, 1.03533149e-01f, 1.38940156e-01f, -4.38286364e-02f,
  1.19694725e-01f, -1.96138099e-01f, -3.80659685e-03f, 4.59540635e-02f, -1.23086572e-01f, 2.44739592e-01f, -9.09634158e-02f, -5.79526536e-02f, 1.94146588e-01f, -3.45499404e-02f,
  1.47483692e-01f, 7.89181292e-02f, -7.66960680e-02f, 4.19173529e-03f, -1.78303450e-01f, 4.13861275e-02f, 7.07879066e-02f, -2.87360866e-02f, -7.83916283e-03f, 1.77277118e-01f,
  2.82436553e-02f, 1.40457088e-02f, 2.31368262e-02f, -2.22000061e-03f, 3.41555811e-02f, 9.83384401e-02f, 1.69816226e-01f, -7.02992268e-03f, 2.95255519e-02f, -5.04837595e-02f,
  2.32848916e-02f, -1.60807241e-02f, -1.48943946e-01f, 9.72829983e-02f, 1.34534240e-01f, 7.64251202e-02f, -7.45152459e-02f, -6.26418889e-02f, -1.53531805e-01f, 5.84860966e-02f,
  1.44443974e-01f, 1.32150114e-01f, 2.02007629e-02f, 2.42753372e-01f, 1.30274504e-01f, 1.05443513e-02f, -8.68476331e-02f, 8.28484669e-02f, 1.07290298e-01f, 4.54793349e-02f,
  -1.08422458e-01f, 3.97002548e-02f, 1.26865640e-01f, 1.67343482e-01f, -1.21624200e-02f, -1.43920690e-01f, -2.88209077e-02f, 2.52517343e-01f, -7.95720294e-02f, 1.48462340e-01f,
  -5.06144613e-02f, -8.36942866e-02f, -1.01080187e-01f, -3.63829993e-02f, 5.78378141e-02f, 9.17503089e-02f, -1.30719356e-02f, 3.38537097e-02f, 1.60534438e-02f, -1.19977362e-01f,
  3.23273242e-02f, -3.61072011e-02f, -8.72532427e-02f, 1.51082858e-01f, -1.98073331e-02f, 2.69448925e-02f, 4.85185860e-03f, 2.32346356e-01f, -8.05637054e-03f, 4.35043015e-02f,
  1.44077554e-01f, -4.41332068e-03f, 3.65027860e-02f, -2.08856519e-02f, 1.87495127e-01f, -5.17075546e-02f, -4.10679132e-02f, 1.38731375e-01f, 4.49330360e-02f, 5.31418361e-02f,
  -4.66365777e-02f, -3.60180587e-02f, 1.03598952e-01f, -1.10688709e-01f, -1.26402184e-01f, -1.96118832e-01f, -1.59890264e-01f, 2.85121389e-02f, -1.27509788e-01f, -9.42449942e-02f,
  1.29095361e-01f, 4.80431914e-02f, 1.11542530e-01f, -5.19368611e-02f, -7.92170018e-02f, 1.12459332e-01f, 2.09997416e-01f, 6.62814379e-02f, 2.14413702e-01f, 4.75020036e-02f,
  2.13817850e-01f, -1.45755783e-01f, 8.33518580e-02f, 1.73494890e-02f, -1.56660065e-01f, 1.22068092e-01f, -1.75392196e-01f, -7.23215714e-02f, 2.95708239e-01f, 3.01096756e-02f,
  1.60162002e-01f, 5.49170189e-02f, 6.76827831e-03f, -6.87557682e-02f, -1.32266536e-01f, 2.68249542e-01f, 1.21605456e-01f, -2.84747723e-02f, 1.18439980e-01f, -1.11838907e-01f,
  -1.07191600e-01f, -4.37783450e-03f, -2.12821826e-01f, 2.40537733e-01f, 4.51308526e-02f, 2.48842724e-02f, 2.67013341e-01f, -2.62968037e-02f, 5.23540042e-02f, 1.20009847e-01f,
  -2.14254428e-02f, -8.72808695e-02f, 1.12150721e-01f, 1.36253342e-01f, 1.92514569e-01f, 3.21013369e-02f, 3.99805754e-02f, 2.75436919e-02f, 2.24814028e-01f, -3.07055917e-02f,
  4.69998904e-02f, -2.78858691e-02f, 2.14547962e-01f, 1.74986556e-01f, -1.56125113e-01f, 6.98975623e-02f, 1.34752423e-01f, 1.01837814e-01f, -5.53340651e-02f, -2.14242145e-01f,
  -4.01307456e-02f, -1.41721204e-01f, -4.55348864e-02f, -1.44934446e-01f, 5.46787456e-02f, -4.81213117e-03f, -7.96865746e-02f, 1.68003321e-01f, -1.62205279e-01f, 7.83223212e-02f,
  1.08253703e-01f, -3.35280374e-02f, 1.67272940e-01f, 2.27304786e-01f, 2.05903783e-01f, -1.07166305e-01f, 4.88948487e-02f, -1.26488477e-01f, -3.30650397e-02f, 1.70517847e-01f,
  -2.04460844e-01f, 7.60446563e-02f, 2.68340915e-01f, 1.32417500e-01f, 6.44903108e-02f, -2.02358678e-01f, 1.46382868e-01f, -3.32520381e-02f, -1.17553100e-01f, 2.02958524e-01f,
  1.16659418e-01f, 6.11257087e-03f, -8.39513466e-02f, -5.15062027e-02f, -3.08143608e-02f, -1.11698538e-01f, -1.44482672e-01f, 1.81919321e-01f, 6.62080497e-02f, 1.04177259e-01f,
  1.23947278e-01f, -5.47782630e-02f, 3.22974026e-02f, 4.93331626e-02f, 1.71843842e-01f, 1.93825923e-02f, 5.44652306e-02f, 1.40029877e-01f, 1.35534918e-02f, 2.25476146e-01f,
  6.53690100e-02f, 2.07034484e-01f, -1.17883161e-02f, 2.28769675e-01f, 8.22652578e-02f, 7.19652921e-02f, 2.73353886e-02f, -2.24571452e-02f, 3.34722772e-02f, 8.79018530e-02f,
  2.07740217e-02f, -8.98462385e-02f, 4.95403633e-02f, 1.01029351e-01f, -4.09952849e-02f, 6.09426349e-02f, 7.24434480e-02f, 8.99090841e-02f, -1.03526212e-01f, 2.09865272e-02f,
  -4.80650812e-02f, 4.86572348e-02f, 2.09859133e-01f, -9.76944864e-02f, -5.94046041e-02f, 9.56848357e-03f, -9.84097347e-02f, -1.51727453e-01f, -9.81719717e-02f, 1.31667748e-01f,
  3.52815911e-02f, 7.76984021e-02f, 2.34516904e-01f, -4.75360416e-02f, 1.82997510e-01f, -2.67286245e-02f, -1.65967271e-01f, 4.75659780e-02f, -1.14551663e-01f, 1.75819144e-01f,
  2.27654114e-01f, 3.16538699e-02f, 2.16525555e-01f, -1.07397042e-01f, -2.29561552e-02f, 1.13387942e-01f, 3.11215539e-02f, 6.10554181e-02f, 1.59170747e-01f, 3.68357748e-02f,
  2.58208871e-01f, -1.45050943e-01f, -6.81492016e-02f, -2.03266251e-03f, -3.07843443e-02f, 4.70180400e-02f, 1.35425359e-01f, 4.41757441e-02f, -7.90012479e-02f, 5.11140451e-02f,
  3.01558953e-02f, -9.29735154e-02f, 4.22302559e-02f, 2.14834616e-01f, 1.01849332e-01f, 6.05481938e-02f, 2.57105500e-01f, 1.66373238e-01f, 4.85872105e-02f, 2.30185792e-01f,
  1.94502711e-01f, 3.34872073e-03f, -1.37329593e-01f, -8.69088471e-02f, -1.69901475e-02f, -1.20115198e-01f, 2.53387868e-01f, 7.96105415e-02f, -1.58965185e-01f, 3.93598117e-02f,
  -3.21306258e-01f, -1.97558060e-01f, 7.12958276e-02f, 2.23273754e-01f, 1.27888128e-01f, 4.88909297e-02f, -9.59555358e-02f, -1.70836821e-01f, 1.72513053e-01f, -3.27762701e-02f,
  1.30826712e-01f, 1.55061543e-01f, 1.59051180e-01f, -1.41028523e-01f, 3.20729584e-01f, 2.07761899e-01f, -1.51953623e-01f, 3.76215987e-02f, 1.89137384e-01f, -1.72172904e-01f,
  6.96950331e-02f, 1.32273719e-01f, 1.97762474e-01f, 4.31320891e-02f, 1.48498816e-02f, -1.32805958e-01f, -1.66456148e-01f, -5.77404946e-02f, -4.61719297e-02f, 6.16930723e-02f,
  8.01824108e-02f, 2.41144538e-01f, 1.63190395e-01f, 9.16640610e-02f, 2.55356412e-02f, 1.30397856e-01f, 5.65637909e-02f, 2.17067719e-01f, -5.79015948e-02f, -2.06605181e-01f,
  -1.52344018e-01f, 5.27502634e-02f, -5.04906178e-02f, 4.03102441e-03f, -2.97512356e-02f, 5.32275587e-02f, 8.58274847e-02f, 1.64055467e-01f, 1.45411372e-01f, 8.68014246e-02f,
  2.03761056e-01f, 1.46832794e-01f, -2.93473229e-02f, 1.62858263e-01f, 1.64404303e-01f, -1.60365514e-02f, 7.55043849e-02f, -9.99856740e-02f, 7.80670345e-02f, -1.33315489e-01f,
  1.15551934e-01f, -1.09961033e-01f, -2.74231881e-01f, 8.72089937e-02f, -1.12781070e-01f, -7.34694526e-02f, 8.12889338e-02f, 1.67001650e-01f, 7.37141073e-03f, -2.64408309e-02f,
  -2.27166265e-02f, -2.32361108e-02f, 1.95247024e-01f, 1.11492286e-02f, 1.19670741e-01f, -1.81847028e-02f, 2.04622760e-01f, 2.81635392e-03f, 1.03359431e-01f, 1.88177258e-01f,
  -9.23445448e-02f, -6.17318302e-02f, 1.05585083e-01f, -3.21420319e-02f, 2.05270007e-01f, 1.12618580e-01f, -1.27582280e-02f, 1.63714454e-01f, 2.00104713e-01f, -7.78708011e-02f,
  -8.06864873e-02f, 1.46032665e-02f, 7.98575208e-02f, -2.83096521e-03f, 2.42594302e-01f, 1.15227602e-01f, -6.71652928e-02f, 1.70825738e-02f, 9.32132378e-02f, 1.03500843e-01f,
  3.88543047e-02f, 2.01471910e-01f, 1.38123289e-01f, -6.86853677e-02f, -9.65803191e-02f, -9.89823043e-02f, -1.82120502e-02f, -4.63201553e-02f, -8.98851380e-02f, 1.06165141e-01f,
  2.01692253e-01f, -6.97045401e-02f, 1.00434115e-02f, 4.66142185e-02f, -3.28515992e-02f, -3.25347595e-02f, 3.47449705e-02f, -1.78792402e-01f, -7.73745552e-02f, 1.38845831e-01f,
  3.89596596e-02f, 1.81879729e-01f, 5.75574860e-02f, -9.86914150e-03f, -8.31982046e-02f, -1.07260957e-01f, -7.33846799e-02f, 3.08869388e-02f, 1.01993948e-01f, -1.16382772e-02f,
  8.29473883e-03f, -2.05704510e-01f, 3.21674421e-02f, -3.43548730e-02f, 6.83642179e-02f, 2.39913866e-01f, -1.30116239e-01f, 1.02590404e-01f, 8.20668936e-02f, 1.46379530e-01f,
  -1.91384908e-02f, -8.36062506e-02f, -1.99680980e-02f, -1.46646470e-01f, 7.57078603e-02f, 1.46269709e-01f, -1.27077878e-01f, 1.53486297e-01f, 3.32204290e-02f, -1.13900959e-01f,
  7.27939308e-02f, 1.60706654e-01f, -1.21979862e-01f, -1.74316554e-03f, 2.78450474e-02f, 1.65186763e-01f, 1.14197217e-01f, -1.72010183e-01f, -7.58720487e-02f, -2.64925778e-01f,
  -1.26570061e-01f, -1.12141781e-01f, -1.89258188e-01f, 9.60630830e-03f, -1.33257508e-01f, -2.52494752e-01f, 1.17943212e-01f, 1.48495257e-01f, 1.46938816e-01f, 1.79759532e-01f,
  -8.22116584e-02f, 4.99648489e-02f, 1.14272691e-01f, 4.89377901e-02f, 2.51524389e-01f, 8.82427394e-02f, 7.28858113e-02f, -4.47446145e-02f, 1.61160037e-01f, 9.22770500e-02f,
  2.96131335e-02f, -4.45743762e-02f, 1.51206076e-01f, -6.87442496e-02f, -2.95654565e-01f, 1.00425072e-01f, 1.00558810e-01f, 4.31838408e-02f, 6.19758442e-02f, -3.31560634e-02f,
  -5.91828860e-02f, 3.10965441e-03f, -2.52645761e-01f, -3.51516813e-01f, 1.94500804e-01f, 7.52259344e-02f, 8.47916529e-02f, -1.22566417e-01f, -1.54088467e-01f, 2.10741207e-01f,
  -1.34892330e-01f, -1.47832736e-01f, 9.18480009e-02f, 3.94321561e-01f, -1.45016387e-01f, -2.53779173e-01f, 2.40632921e-01f, -8.91049579e-02f, -7.30604604e-02f, 2.27576494e-01f,
  -9.14370120e-02f, -8.21069628e-02f, -3.82668748e-02f, 3.53282243e-02f, 5.27335703e-02f, -5.09786643e-02f, -1.34698063e-01f, -4.67104763e-02f, -1.88140348e-01f, 3.13543141e-01f,
  1.70480773e-01f, -1.49662793e-01f, -2.29278933e-02f, -1.27078071e-01f, -2.42691953e-02f, -5.71909081e-03f, -1.36139303e-01f, -2.01384053e-01f, -1.07481033e-01f, -7.65942559e-02f,
  1.00779179e-02f, -3.60521376e-02f, 6.69803750e-03f, 1.13905728e-01f, 2.66576409e-02f, -1.90264303e-02f, 1.05223380e-01f, -1.45907074e-01f, -6.22736327e-02f, 2.13557240e-02f,
  6.77734390e-02f, -2.17810296e-03f, 1.22739188e-01f, -5.90430349e-02f, 5.85160889e-02f, 1.51742265e-01f, 6.71296567e-02f, -5.41024469e-02f, -3.24147977e-02f, -1.27361715e-01f,
  1.70631651e-02f, -2.13415846e-01f, -1.49706602e-01f, 7.04858825e-02f, 5.16463295e-02f, 1.17826827e-01f, -4.04914729e-02f, -1.40350178e-01f, -1.71509370e-01f, -6.77038208e-02f,
  2.75506973e-01f, -1.85059104e-02f, 3.47832814e-02f, -3.80554050e-02f, 2.34309211e-01f, 7.87653029e-04f, 1.18921604e-02f, -1.10886052e-01f, 1.99242637e-01f, -1.21815018e-02f,
  3.19888771e-01f, 2.40043521e-01f, -2.91427106e-01f, -5.08324802e-02f, 7.22328871e-02f, -6.95278347e-02f, 2.32273892e-01f, -1.50021493e-01f, 4.24799845e-02f, -4.13735956e-03f,
  1.60651803e-02f, 9.66874361e-02f, -7.23737699e-04f, 2.15389580e-01f, 2.99238786e-02f, 4.38723573e-03f, 1.50841828e-02f, 2.17043579e-01f, 2.40223706e-01f, 2.14024499e-01f,
  -1.45046294e-01f, 2.43602052e-01f, 2.66700536e-01f, 2.54123926e-01f, -5.22780679e-02f, -1.04792556e-02f, 1.52660394e-02f, 1.43496439e-01f, 1.95990145e-01f, -1.99452993e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  3.46749946e-02f, 1.12092085e-01f, 1.14421748e-01f, 4.02369946e-02f, 4.30807397e-02f, 8.48741233e-02f, 5.24725467e-02f, 8.69495049e-02f, 7.17399316e-03f, 1.06035076e-01f,
  1.23482548e-01f, 2.24211980e-02f, 1.71041399e-01f, 3.60966325e-02f, 2.21573077e-02f, 2.40844470e-02f, 2.33166628e-02f, 1.14009224e-01f, 5.77120893e-02f, 1.58541024e-01f,
  1.10279575e-01f, -4.90705557e-02f, 5.69945946e-02f, 1.91749930e-02f, 1.10863276e-01f, 3.09524927e-02f, 8.40712786e-02f, 1.84924640e-02f, 1.08854607e-01f, 9.20368880e-02f,
  1.86661243e-01f, -3.59419882e-02f, 1.34187147e-01f, 9.03172642e-02f, 1.42544687e-01f, 3.77215184e-02f, 1.54320508e-01f, 4.43080738e-02f, 1.41108647e-01f, -3.14280838e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -4.12664972e-02f, -1.14046164e-01f, -6.92258105e-02f, -9.28563848e-02f, 1.05823781e-02f, -1.01948544e-01f, -6.37141317e-02f, 9.42241848e-02f, -1.08387433e-01f, -1.16257943e-01f,
  -9.41152424e-02f, -7.41383210e-02f, -1.19452618e-01f, 8.61775130e-02f, 1.19015612e-01f, 1.28102854e-01f, 1.05179131e-01f, -1.23659283e-01f, 1.45738823e-02f, -4.41354737e-02f,
  -1.63802728e-01f, 8.91536027e-02f, -8.69752839e-02f, 1.28605500e-01f, 8.98781121e-02f, -1.62696019e-02f, 1.14883140e-01f, -1.34818971e-01f, -6.26472384e-02f, -4.42962311e-02f,
  -8.42763931e-02f, -1.02553993e-01f, -4.49911803e-02f, -1.14378765e-01f, -1.40025750e-01f, 1.04419580e-02f, -1.44347295e-01f, 3.56911980e-02f, 1.01520255e-01f, 4.26680408e-02f,
  8.27553507e-04f, -5.49737327e-02f, 7.04528838e-02f, -1.06138922e-02f, 4.42490168e-02f, 4.04209159e-02f, -5.41987456e-02f, 1.62235320e-01f, -2.74466835e-02f, 8.10991079e-02f,
  1.67792872e-01f, -1.51126519e-01f, 5.55635691e-02f, 7.25093111e-02f, -1.02441981e-02f, 1.20257087e-01f, -4.92308214e-02f, -1.48100242e-01f, 5.89938201e-02f, 1.92486513e-02f,
  -6.46161363e-02f, 3.63697782e-02f, 5.07001532e-03f, 5.38373590e-02f, 1.63379207e-01f, -3.16232927e-02f, 1.90164074e-01f, 6.08209595e-02f, 2.11733039e-02f, 1.07594095e-01f,
  -1.89735088e-02f, 9.40872133e-02f, 9.77665782e-02f, 1.17785476e-01f, -1.11120027e-02f, 2.00283411e-03f, -4.40893089e-03f, -1.11884557e-01f, -1.37093797e-01f, -2.64758542e-02f,
  3.56869139e-02f, 3.05419210e-02f, -7.12056160e-02f, -3.11517883e-02f, 2.14771647e-02f, -8.32782686e-02f, 9.40129608e-02f, -6.63234517e-02f, -4.10053432e-02f, 2.95119975e-02f,
  2.06678528e-02f, -1.23174101e-01f, 1.19480684e-01f, -5.63769639e-02f, 7.13817179e-02f, -4.21414934e-02f, 7.14613274e-02f, 6.36975244e-02f, 1.27608731e-01f, 5.11633307e-02f,
  -2.58530453e-02f, 8.52630064e-02f, 2.53782719e-02f, -1.10648021e-01f, -2.62019560e-02f, 6.75370172e-02f, 5.57304081e-03f, -4.72817458e-02f, 7.28523135e-02f, 5.25697470e-02f,
  1.19244695e-01f, -2.64093094e-02f, 2.17764661e-01f, 1.20374700e-02f, -7.50986636e-02f, -6.77713826e-02f, -9.48131979e-02f, 2.08274517e-02f, -6.67893440e-02f, 1.12186931e-01f,
  -7.96555728e-02f, -4.70281877e-02f, 4.54009138e-02f, 1.08889200e-01f, 1.57861896e-02f, -9.01654270e-03f, 5.82742319e-02f, -8.90996456e-02f, 3.56264822e-02f, 5.81854098e-02f,
  1.44247204e-01f, 1.05112739e-01f, 6.47731591e-03f, -7.36378953e-02f, -1.10431783e-01f, -3.91792273e-03f, 7.79031077e-04f, 1.13569386e-01f, -2.71601342e-02f, -1.74148194e-02f,
  -1.53452381e-01f, -2.51570791e-01f, 1.02688156e-01f, -5.29141463e-02f, -2.59471625e-01f, -6.12902679e-02f, -7.64759779e-02f, 3.51098888e-02f, -1.83182284e-01f, 4.15048525e-02f,
  5.61256260e-02f, 8.86351764e-02f, -4.29108478e-02f, -7.30131567e-02f, -2.11189557e-02f, -2.21922789e-02f, 8.57830495e-02f, 1.11529872e-01f, -6.83616176e-02f, -2.21246444e-02f,
  1.48334295e-01f, 6.14564605e-02f, 1.41862080e-01f, 1.38081700e-01f, -8.82950798e-03f, 5.26967309e-02f, 2.88469484e-03f, -8.97862762e-02f, -7.23554790e-02f, 5.86316474e-02f,
  -1.25098199e-01f, -9.80288312e-02f, 5.73519468e-02f, 8.31971294e-04f, 1.90863684e-02f, -6.48530722e-02f, 1.86756566e-01f, 1.26085684e-01f, 1.56058684e-01f, 5.33662811e-02f,
  -6.99201599e-02f, 1.50109410e-01f, -1.24221198e-01f, 1.96020529e-02f, -8.01043734e-02f, -1.25871748e-01f, 1.54996589e-01f, -4.55792025e-02f, -2.81260051e-02f, 2.52977367e-02f,
  -4.48301248e-02f, -1.54169559e-01f, -1.83216054e-02f, -1.19330501e-02f, 6.44562468e-02f, -7.60681257e-02f, -8.69731978e-02f, 8.81995112e-02f, -7.14713335e-02f, -7.31891692e-02f,
  2.67613959e-02f, -1.54996797e-01f, -3.04184500e-02f, -6.13610893e-02f, 2.28040200e-02f, -3.91407199e-02f, -1.50226071e-01f, -1.14953712e-01f, 2.60938257e-02f, 1.52357221e-01f,
  2.72713918e-02f, -1.64894357e-01f, 1.13646537e-02f, 1.22299395e-03f, 7.46519119e-02f, -1.41827866e-01f, -1.09892324e-01f, 3.14538330e-02f, -1.37833416e-01f, -5.57487756e-02f,
  2.98379641e-02f, 7.83366412e-02f, 1.00122422e-01f, 8.68420452e-02f, -3.23056839e-02f, -1.98729001e-02f, 2.49690283e-02f, -3.82468887e-02f, -1.71132073e-01f, -1.07490696e-01f,
  -1.60266548e-01f, -4.84382324e-02f, 2.93661784e-02f, -4.19992721e-03f, -3.87120768e-02f, 1.79850414e-01f, 8.54404345e-02f, -7.80705810e-02f, 1.92264885e-01f, -4.15938087e-02f,
  8.37036669e-02f, -4.51869369e-02f, -1.53942600e-01f, 3.81539315e-02f, -8.29605609e-02f, 1.02625623e-01f, 3.35560064e-03f, 3.86172906e-02f, 6.55006245e-02f, 2.78664269e-02f,
  4.33362313e-02f, -1.15869291e-01f, 1.10496491e-01f, -1.30594699e-02f, -7.91657791e-02f, 1.69658493e-02f, -6.89348355e-02f, 8.92265439e-02f, -7.60699436e-02f, 1.65645350e-02f,
  1.06304638e-01f, -1.42483950e-01f, 1.40699014e-01f, -9.71493497e-02f, -7.24056214e-02f, 5.12667838e-03f, -4.33766656e-03f, 4.13287729e-02f, 1.84522003e-01f, 2.65954155e-02f,
  -8.89149308e-02f, 4.32063006e-02f, 6.72288835e-02f, 7.33812898e-02f, 2.77197380e-02f, 8.66231322e-02f, 1.07948981e-01f, -1.90242171e-01f, 2.94919908e-02f, -2.84013264e-02f,
  -1.25142962e-01f, 9.11695808e-02f, -1.66015863e-01f, -1.20440699e-01f, -1.71630487e-01f, 1.84708871e-02f, 1.49000227e-01f, 1.85968831e-01f, 1.05915681e-01f, 7.48228207e-02f,
  1.18279159e-01f, -1.27732381e-01f, -3.02827898e-02f, 1.24128535e-01f, -7.76794925e-02f, 1.69896800e-02f, -1.61459133e-01f, -5.37197366e-02f, -7.09400252e-02f, -3.74445156e-03f,
  4.33649076e-03f, 4.70708683e-02f, 7.20335543e-02f, 5.68359494e-02f, -1.21264756e-01f, -1.21135555e-01f, -1.70825467e-01f, -7.13262782e-02f, -1.20853744e-01f, -4.37072106e-02f,
  6.12290353e-02f, -1.46616563e-01f, 7.13930652e-02f, 5.01298048e-02f, -2.67906804e-02f, 3.12239286e-02f, 7.51476958e-02f, -3.46819707e-03f, 8.12543407e-02f, 3.81078981e-02f,
  -9.23297405e-02f, 1.04443960e-01f, 5.71927801e-02f, -1.56897884e-02f, 4.46815640e-02f, -6.50111884e-02f, 7.45700374e-02f, -2.04296127e-01f, -5.63046150e-02f, -5.59825301e-02f,
  -1.25575028e-02f, -7.93935806e-02f, 2.28696585e-01f, 6.00735471e-02f, 1.12691857e-02f, 1.36937529e-01f, 9.87603590e-02f, 1.86624497e-01f, 1.55505612e-01f, -7.27835223e-02f,
  2.19535753e-01f, -8.31896588e-02f, -8.67926255e-02f, -1.39112294e-01f, -1.64688706e-01f, -1.44018874e-01f, -8.34625307e-03f, 3.19093466e-02f, -1.06141614e-02f, -2.12115352e-03f,
  -2.30127852e-02f, 7.03391666e-03f, -1.73106700e-01f, 4.29473333e-02f, -1.17911950e-01f, -9.70939472e-02f, 1.19005337e-01f, -1.27652451e-01f, 7.13697448e-02f, -8.54841247e-02f,
  -1.12977140e-01f, -5.55897541e-02f, -4.84004542e-02f, -1.78643122e-01f, -9.38830227e-02f, 4.49554920e-02f, -1.66976437e-01f, -5.02348132e-02f, -1.27137266e-02f, -2.65088409e-01f,
  -2.04878330e-01f, -2.16319365e-03f, -6.38431357e-03f, -1.20559044e-01f, -6.04790896e-02f, -1.72706276e-01f, 1.13127030e-01f, 7.16528744e-02f, -1.67375088e-01f, 5.63994944e-02f,
  -1.02742061e-01f, 2.05445774e-02f, 1.67010859e-01f, -3.50227244e-02f, 7.01560304e-02f, -1.34182245e-01f, -1.50158033e-01f, -1.64857119e-01f, -1.29715964e-01f, 5.58142364e-02f,
  -1.34993205e-02f, -8.00736174e-02f, -1.11253653e-02f, -8.06551203e-02f, 3.28500979e-02f, -6.50332645e-02f, -7.35995024e-02f, 6.82453886e-02f, 7.49603435e-02f, -3.19965705e-02f,
  1.62992980e-02f, -1.17882088e-01f, 1.03714272e-01f, -8.69351476e-02f, -3.34522850e-03f, 1.87471826e-02f, -7.35882903e-03f, -1.42704055e-01f, -8.19649547e-02f, -1.05758362e-01f,
  -4.75489721e-02f, 1.88702613e-01f, 3.29724252e-02f, -7.94008896e-02f, -4.48862202e-02f, -1.54284865e-01f, -1.55723155e-01f, -6.08734274e-03f, 1.24215335e-01f, -2.04915311e-02f,
  3.28689963e-02f, -1.23214461e-01f, -6.30821614e-03f, 1.69093296e-01f, 9.23835561e-02f, 4.46967520e-02f, -7.62141645e-02f, 3.22230980e-02f, 3.28223337e-03f, -6.09861407e-03f,
  6.69664294e-02f, -7.19096884e-02f, -1.30438894e-01f, -1.78288035e-02f, 9.84772965e-02f, -1.31916970e-01f, 1.35248855e-01f, 1.99005380e-02f, 9.32315961e-02f, -6.78670630e-02f,
  -5.31471558e-02f, -1.04504526e-01f, 9.18499157e-02f, 6.21343553e-02f, -4.09536660e-02f, -6.80892095e-02f, -1.81172222e-01f, 4.06993032e-02f, -1.74425449e-02f, -1.72021702e-01f,
  1.37212323e-02f, -2.29857508e-02f, -1.81080058e-01f, -8.29220489e-02f, -1.07695594e-01f, -6.23384044e-02f, 4.20639887e-02f, 1.30789936e-01f, 5.63431121e-02f, 3.44317332e-02f,
  1.54404659e-02f, -1.27110377e-01f, 5.99102825e-02f, -5.68229845e-03f, -1.42008424e-01f, 8.29959288e-02f, 4.04138528e-02f, -8.39001834e-02f, -1.18307367e-01f, 2.13914104e-02f,
  -1.05595216e-01f, 2.30330408e-01f, -1.81761719e-02f, -3.48168723e-02f, 2.03974266e-02f, -1.37654811e-01f, 1.17629118e-01f, 1.23497397e-01f, -6.24041855e-02f, -1.39474953e-02f,
  2.84244269e-02f, -3.48176099e-02f, -1.14160948e-01f, -5.51608764e-03f, 1.00040175e-01f, -1.94952625e-03f, 9.90955755e-02f, -1.27950266e-01f, -2.42745414e-01f, -1.52011812e-01f,
  9.94074643e-02f, -8.22993815e-02f, 5.25608473e-02f, 8.16056505e-02f, -1.61338210e-01f, 3.74834239e-02f, -1.33337937e-02f, 4.91455235e-02f, 1.47550315e-01f, -2.84910202e-02f,
  -1.85237229e-01f, 1.20127797e-01f, -1.58811837e-01f, 1.22378081e-01f, -1.28977597e-02f, -6.53799484e-03f, 7.26954360e-03f, -5.12530208e-02f, -3.41745317e-02f, 9.00449753e-02f,
  2.17558965e-01f, -7.02424571e-02f, -2.08108616e-03f, 6.66162670e-02f, -4.23234664e-02f, 1.14391604e-02f, -6.25355542e-02f, 4.38418798e-02f, -1.63557693e-01f, -1.58687886e-02f,
  -7.36960620e-02f, -8.23027939e-02f, 1.09658606e-01f, -1.14627995e-01f, -1.19241111e-01f, -2.11261034e-01f, -1.38771711e-02f, -7.56953359e-02f, -2.06415027e-01f, -1.02916919e-01f,
  -3.81338522e-02f, -9.28220674e-02f, -1.16280057e-01f, 1.47075519e-01f, -2.27739811e-02f, 1.69495746e-01f, 9.25834253e-02f, -1.35028094e-01f, 1.20418044e-02f, -3.81263718e-02f,
  8.78192186e-02f, 7.11200684e-02f, -1.18313789e-01f, -1.99745595e-01f, -1.15369158e-02f, 3.54448985e-03f, -1.14280403e-01f, 1.69185907e-01f, -1.76050812e-01f, -9.22533497e-02f,
  -4.29942571e-02f, -8.61253664e-02f, -1.82854012e-03f, -1.05181150e-01f, 1.83332022e-02f, -8.80577117e-02f, 4.01026905e-02f, -2.87463311e-02f, 2.94171497e-02f, -1.57607272e-02f,
  1.69529513e-01f, 4.79339622e-02f, 1.21944711e-01f, -7.64597356e-02f, -1.35266751e-01f, 1.28135204e-01f, -1.74592771e-02f, 4.08884250e-02f, -4.84008268e-02f, -8.98163915e-02f,
  3.60090211e-02f, -1.95046470e-01f, -5.19373752e-02f, -3.39257456e-02f, -1.49802789e-01f, -1.27604201e-01f, -5.41472845e-02f, -3.11960671e-02f, -3.45144831e-02f, -4.98567102e-03f,
  2.34453045e-02f, -2.74084825e-02f, 7.63696730e-02f, 1.63491480e-02f, -5.99909807e-03f, 2.67822016e-02f, -5.08569330e-02f, 3.39600742e-02f, 3.12384833e-02f, 8.04124251e-02f,
  8.35333169e-02f, 4.66092937e-02f, 1.17848873e-01f, 2.14224849e-02f, -2.79947780e-02f, 2.92694420e-02f, 2.46381927e-02f, -1.33172721e-01f, -2.60118842e-02f, -1.29383877e-01f,
  -6.04973361e-02f, 2.11473461e-02f, -9.32248309e-02f, -1.98205039e-02f, -5.83528355e-03f, 5.51438425e-03f, 6.26199618e-02f, 5.03386818e-02f, -4.39092852e-02f, 2.41641607e-02f,
  1.33898199e-01f, -1.63309142e-01f, 1.16533287e-01f, -7.80109391e-02f, 5.72287710e-03f, 6.30727112e-02f, -1.51730195e-01f, -3.77197601e-02f, -9.18710828e-02f, 1.52503839e-02f,
  8.73062536e-02f, 2.78859064e-02f, -2.28282269e-02f, -6.03105724e-02f, -1.21165782e-01f, 8.84803310e-02f, -9.43392515e-02f, -5.90372682e-02f, 8.31366852e-02f, -8.14055186e-03f,
  -7.83390552e-02f, -1.81922745e-02f, -4.80940454e-02f, -1.26406729e-01f, 5.89390881e-02f, 1.47080466e-01f, 6.73772246e-02f, -1.07918739e-01f, 5.11892959e-02f, 8.48807860e-03f,
  1.72573268e-01f, -2.36562416e-01f, 4.45192307e-02f, -7.89543167e-02f, -4.82869186e-02f, -4.70434278e-02f, 5.03785610e-02f, 7.55420700e-02f, 2.40784548e-02f, -3.99738736e-03f,
  -1.30912125e-01f, 2.42163558e-02f, -1.18962161e-01f, -3.93851995e-02f, 8.51282850e-03f, 4.57194299e-02f, 1.75378561e-01f, -2.76342303e-01f, 8.27409700e-02f, 1.84829603e-03f,
  1.27578871e-02f, -1.10339895e-01f, 2.06319183e-01f, 1.50460042e-02f, -6.38251752e-02f, 5.40169142e-02f, 4.66120616e-02f, -1.70392171e-01f, -1.25132933e-01f, -1.77461088e-01f,
  -1.69448033e-01f, -4.49751727e-02f, 1.32411391e-01f, 5.49148433e-02f, 5.12595363e-02f, -1.75719187e-01f, -2.05089226e-02f, 1.33779764e-01f, 9.18712467e-02f, 9.28042680e-02f,
  1.28430039e-01f, 2.86084972e-02f, -8.33382830e-02f, 2.94445436e-02f, -7.15195835e-02f, 1.04978733e-01f, -4.91825258e-03f, 1.97762232e-02f, -2.09353529e-02f, 7.87421614e-02f,
  7.51237720e-02f, -4.74417247e-02f, -3.58116142e-02f, -1.05260648e-01f, -1.12841278e-01f, -4.47877534e-02f, -5.42895421e-02f, -9.67005193e-02f, 2.32298672e-02f, 3.67576815e-02f,
  -5.56577593e-02f, -1.34104148e-01f, -1.49211928e-01f, 9.09055844e-02f, 7.71842524e-02f, -1.25090256e-02f, -2.80641997e-03f, 1.04572088e-01f, 1.01996794e-01f, 1.15512812e-03f,
  -4.17535342e-02f, 2.04160530e-02f, 1.49262268e-02f, 3.87516618e-02f, 8.72107521e-02f, 1.46249272e-02f, -5.75302653e-02f, 9.92183760e-03f, 5.31817377e-02f, 3.04861274e-02f,
  -4.95587960e-02f, -3.47686675e-03f, -2.05952879e-02f, 1.29558995e-01f, 4.71539982e-02f, 5.83477989e-02f, -2.68706959e-03f, 7.30623007e-02f, 6.71557263e-02f, -1.02269217e-01f,
  1.22906074e-01f, 4.59985062e-02f, -1.34481773e-01f, 5.95397763e-02f, -1.14485346e-01f, 5.32726347e-02f, 1.06873466e-02f, -9.53245326e-04f, -2.38189220e-01f, 1.46921888e-01f,
  1.61166236e-01f, 1.37274545e-02f, 6.59558028e-02f, 1.63917318e-02f, 3.87170017e-02f, 3.63668017e-02f, 7.36981779e-02f, -2.24249557e-01f, -3.51733603e-02f, 5.72468378e-02f,
  -1.69692874e-01f, 9.60403979e-02f, -7.12378398e-02f, -2.78699715e-02f, 1.69822872e-01f, 1.43668968e-02f, 1.39290467e-02f, -6.15197234e-02f, 3.72191891e-02f, -6.60157800e-02f,
  3.42204832e-02f, -4.27978411e-02f, -7.25239366e-02f, -1.03419237e-01f, -5.09439930e-02f, 1.08939223e-01f, 1.01375014e-01f, 4.14906591e-02f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -3.39738652e-02f, 7.82153904e-02f, 5.95941953e-03f, 1.11544803e-01f, 2.76160259e-02f, 2.27654185e-02f, -1.70730978e-01f, 1.41393673e-02f, -5.55408150e-02f, 6.68395832e-02f,
  1.12197444e-01f, -6.73042089e-02f, -1.31042764e-01f, -2.43398488e-01f, 3.23516577e-02f, -1.09668031e-01f, -3.21100652e-01f, 3.55224051e-02f, -1.38435781e-01f, 5.16649410e-02f,
  3.69542018e-02f, 1.02442369e-01f, 1.51752651e-01f, 4.53430004e-02f, 2.29458809e-02f, 6.06971681e-02f, 1.34334818e-01f, 5.86224832e-02f, 1.00522421e-01f, 1.30300343e-01f,
  -8.66574422e-02f, -8.18041340e-02f, 1.54101640e-01f, 2.15236470e-01f, 8.68908316e-02f, 3.01404715e-01f, -1.52296647e-01f, -5.39056472e-02f, -6.90026721e-03f, -2.42046416e-01f,
  1.27387285e-01f, 2.06481382e-01f, 1.29345849e-01f, 1.15277404e-02f, 2.00894922e-01f, -1.23731166e-01f, 2.10005388e-01f, -2.52199266e-03f, 3.18317682e-01f, 1.27038499e-02f,
  1.03734970e-01f, 1.96661994e-01f, -2.84216013e-02f, 2.38593876e-01f, 8.73805732e-02f, 1.36343420e-01f, -9.95234102e-02f, 1.08484969e-01f, 8.62964988e-02f, -9.81188193e-02f,
  -2.70669274e-02f, 1.36524498e-01f, 5.88889681e-02f, -2.82254905e-01f, -9.85552296e-02f, -2.32292693e-02f, 1.16401605e-01f, 6.14538752e-02f, 4.97817900e-03f, 7.85166770e-02f,
  6.96705431e-02f, -5.05508520e-02f, 7.71584883e-02f, 4.15171497e-02f, 2.22405806e-01f, 1.15600578e-01f, 1.52367741e-01f, 8.86770263e-02f, -3.64781246e-02f, 2.96930876e-02f,
  4.88329493e-02f, 2.60717481e-01f, 1.54734373e-01f, 4.42719534e-02f, 9.79590043e-02f, -1.60056606e-01f, -1.26660883e-01f, -9.05490816e-02f, -5.99839464e-02f, 4.85047465e-03f,
  -1.76138341e-01f, 2.68828087e-02f, 2.57039577e-01f, -4.43216264e-02f, 2.56838173e-01f, 1.87786758e-01f, -1.24087222e-01f, -1.57575700e-02f, 1.10375807e-01f, -2.19050303e-01f,
  9.76814851e-02f, -1.35771111e-01f, -1.45633519e-02f, -1.26054343e-02f, -2.93562174e-01f, -8.17888007e-02f, -6.76770061e-02f, 6.84581995e-02f, 2.06456967e-02f, 8.09597038e-03f,
  -4.85601500e-02f, -1.73447579e-01f, 1.40837152e-02f, -1.28006414e-01f, -1.84032261e-01f, 1.31475041e-03f, 9.44329724e-02f, -3.91491465e-02f, 1.02312937e-01f, -8.66016820e-02f,
  2.17985392e-01f, 8.78656358e-02f, -1.69324458e-01f, 1.24597356e-01f, 8.76157060e-02f, 1.18243266e-02f, 2.10957050e-01f, -1.57080442e-02f, -2.26347357e-01f, 7.79892132e-02f,
  -2.32711226e-01f, 5.54981977e-02f, 3.51408683e-02f, -6.37298599e-02f, -5.99289127e-02f, -4.85586077e-02f, -1.38765454e-01f, -1.92645252e-01f, 2.71380506e-02f, -1.05913341e-01f,
  -1.42493039e-01f, -5.48817124e-03f, -6.62161596e-03f, -5.49224801e-02f, -1.62140355e-01f, 2.30648462e-02f, -4.18387502e-02f, -6.25275746e-02f, -6.24920800e-02f, 2.02691182e-01f,
  7.30506852e-02f, 6.33806884e-02f, 2.54029423e-01f, -1.35896817e-01f, 7.06946999e-02f, 3.50760221e-01f, -1.38957247e-01f, 6.73389882e-02f, -7.12715983e-02f, -9.93621349e-02f,
  -5.24809845e-02f, -2.75568366e-01f, 2.34115459e-02f, 1.66890636e-01f, 2.08439399e-02f, -3.01605344e-01f, -2.38714442e-01f, 4.10829723e-01f, 1.90234222e-02f, -7.89123923e-02f,
  -8.63749981e-02f, 1.84276119e-01f, 7.14081004e-02f, -1.11151814e-01f, 3.16203013e-02f, -8.67501721e-02f, 3.31128575e-02f, 9.34139416e-02f, 2.04241142e-01f, 2.69540250e-02f,
  4.65126097e-01f, 8.42473134e-02f, 2.28837997e-01f, -3.15650395e-04f, 3.08790207e-02f, -1.36915967e-01f, 1.78887546e-01f, -2.03614712e-01f, -3.72534357e-02f, 9.75731164e-02f,
  -2.18955562e-01f, 1.25014454e-01f, 1.51090035e-02f, 1.35735303e-01f, 1.17361672e-01f, 6.73102513e-02f, 9.74268243e-02f, 2.38641258e-02f, 1.20436773e-01f, -3.10804248e-02f,
  1.86286226e-01f, 2.14885280e-01f, 1.05771065e-01f, 1.43076539e-01f, 2.22307235e-01f, 5.66331185e-02f, 8.43311623e-02f, 1.10159054e-01f, 4.72503044e-02f, 1.13071255e-01f,
  4.95136790e-02f, 4.52616327e-02f, 1.88800633e-01f, -2.07798138e-01f, 4.92453873e-02f, -1.83122322e-01f, -5.60497530e-02f, 1.90386117e-01f, 1.73644221e-03f, -1.14519093e-02f,
  1.03992097e-01f, -8.55104476e-02f, 2.76358098e-01f, 2.04119712e-01f, 6.92949221e-02f, 2.89446175e-01f, 2.10384145e-01f, -1.48881748e-01f, 1.29124820e-01f, 2.85667926e-01f,
  2.41962612e-01f, -8.86172280e-02f, 7.25185350e-02f, 1.91116497e-01f, 1.03013597e-01f, 5.02430163e-02f, 1.70090469e-03f, 9.27723199e-02f, 1.69694930e-01f, 7.13841096e-02f,
  6.09135441e-02f, -7.57639408e-02f, -1.40839934e-01f, 5.77159114e-02f, -1.37926310e-01f, -1.10111922e-01f, 4.61948812e-02f, -7.07112178e-02f, 9.99329090e-02f, 2.76324958e-01f,
  -8.41807947e-02f, 2.80179262e-01f, 2.14238137e-01f, -1.09141558e-01f, 1.94615752e-01f, 7.66142225e-03f, -2.89028529e-02f, -2.68191755e-01f, 2.25234292e-02f, -9.99881402e-02f,
  -9.60914269e-02f, -7.16746226e-02f, 1.07981749e-02f, 7.19471499e-02f, -3.88375707e-02f, 4.03810665e-02f, 2.29090005e-02f, -1.06897252e-02f, -4.15152572e-02f, -2.04401836e-03f,
  -5.56723773e-02f, -6.75988942e-02f, 6.66638091e-02f, -2.15685576e-01f, 8.83925110e-02f, -1.73974663e-01f, -1.86496437e-01f, 2.29949206e-01f, -1.96409181e-01f, 1.50793090e-01f,
  1.59738019e-01f, 1.70350701e-01f, -1.87904052e-02f, 4.20739762e-02f, -9.04947966e-02f, 4.64934558e-02f, -1.44768521e-01f, -1.24966420e-01f, -8.30246136e-03f, -1.32408157e-01f,
  -3.26224804e-01f, -2.02773288e-02f, 6.26152977e-02f, -8.65446962e-03f, 7.10624531e-02f, 2.06943139e-01f, 2.57949997e-02f, -9.68846977e-02f, 3.68277766e-02f, 1.59090340e-01f,
  3.03710606e-02f, 2.69004583e-01f, 3.23913270e-03f, 1.44692779e-01f, 3.82925235e-02f, 2.06698477e-01f, 1.41104579e-01f, -1.16966143e-01f, 1.45650461e-01f, 1.15156785e-01f,
  -2.96300240e-02f, 1.25750229e-01f, 1.56886652e-01f, -4.85711880e-02f, -1.55209722e-02f, 3.58474888e-02f, 1.95647180e-01f, 1.31452367e-01f, -2.54904181e-01f, 2.52895325e-01f,
  4.49908413e-02f, -4.74085361e-02f, 1.47759825e-01f, 2.42611133e-02f, 6.28949031e-02f, 9.58606303e-02f, 1.82219744e-01f, 8.89197215e-02f, 3.85080688e-02f, -1.54981632e-02f,
  6.95440993e-02f, 1.22260749e-01f, -1.61740810e-01f, 1.02362670e-01f, 1.14150476e-02f, 1.10638388e-01f, 2.51629967e-02f, -2.22536512e-02f, 3.31440046e-02f, -5.34909777e-02f,
  -1.21407852e-01f, 1.77526958e-02f, -1.22772716e-01f, -1.69239640e-01f, -1.94773972e-02f, 1.08449280e-01f, -3.07897683e-02f, 4.64097150e-02f, 2.98207074e-01f, -9.63635277e-03f,
  5.54544963e-02f, 6.14937544e-02f, -4.85994294e-02f, -9.07345563e-02f, 3.93464386e-01f, -1.72782779e-01f, -5.50795496e-02f, -1.55175731e-01f, -4.33016978e-02f, 1.54141456e-01f,
  -2.74764568e-01f, -4.51056734e-02f, -2.37032890e-01f, 1.98103860e-01f, 2.84447759e-01f, 1.27927110e-01f, 1.98423892e-01f, -1.28861472e-01f, 1.10626034e-01f, 2.22216472e-01f,
  3.21815722e-02f, -1.06175214e-01f, 1.78704262e-01f, 1.53323472e-01f, -7.36503117e-03f, 8.41533244e-02f, -3.44355740e-02f, -1.76354706e-01f, 2.03505680e-01f, 1.95510298e-01f,
  1.48505509e-01f, -5.22368811e-02f, -1.73743926e-02f, -9.47387796e-03f, 2.71423515e-02f, -5.73406667e-02f, -7.08797053e-02f, 4.76217344e-02f, 1.14904620e-01f, 6.46125674e-02f,
  4.22607809e-02f, 3.11606023e-02f, -3.42520140e-03f, -1.44502163e-01f, -1.37038499e-01f, 6.27108514e-02f, -2.86122501e-01f, -5.19903339e-02f, 1.61474422e-02f, 3.53600830e-02f,
  -9.44532678e-02f, -1.81477264e-01f, -1.12106949e-02f, 9.27837491e-02f, -1.83372423e-01f, 1.55591935e-01f, -2.72964337e-03f, 2.46071406e-02f, 1.52905164e-02f, 6.04702905e-03f,
  1.15165282e-02f, -5.64358942e-02f, -1.49983853e-01f, -3.83558422e-02f, -1.75012514e-01f, 1.95366219e-02f, 9.90437791e-02f, 4.39821109e-02f, 1.76462457e-01f, 6.45956621e-02f,
  -1.73033983e-01f, -7.82347471e-02f, -1.09187268e-01f, 2.49725133e-01f, -2.81616375e-02f, 1.48221955e-01f, -2.92465895e-01f, 1.41387761e-01f, 1.53932795e-01f, -4.63164076e-02f,
  1.39168903e-01f, 4.54178229e-02f, 5.38819432e-02f, 3.01084042e-01f, 1.98397085e-01f, -2.33687181e-02f, 2.32140779e-01f, 9.33320448e-02f, -1.22910999e-01f, 1.04874775e-01f,
  -3.16845059e-01f, -2.95385540e-01f, 2.18015045e-01f, -1.63416639e-01f, -1.27979487e-01f, 2.06484664e-02f, -1.63869098e-01f, 4.35017981e-02f, -1.09687820e-02f, -7.62043819e-02f,
  -1.41804010e-01f, -2.19143376e-01f, -5.75307645e-02f, -9.30261016e-02f, -1.71686634e-02f, -1.52017102e-01f, -1.05200998e-01f, -6.91746697e-02f, -1.32672712e-01f, -2.11159676e-01f,
  8.20334703e-02f, -5.03635779e-03f, -2.10828498e-01f, -1.11187294e-01f, -6.15473418e-03f, 1.87174547e-02f, 1.04851894e-01f, -2.63974279e-01f, 8.47506672e-02f, 1.23563401e-01f,
  -1.95072324e-03f, -6.33930787e-02f, 1.13624729e-01f, 9.71234590e-02f, -1.47367775e-01f, 1.83424100e-01f, -1.32734910e-01f, 3.35108787e-02f, 8.36450309e-02f, 7.61037273e-03f,
  9.16808657e-03f, -1.06973484e-01f, -6.80794343e-02f, -6.50585294e-02f, 1.18813235e-02f, -7.57107288e-02f, -1.84641499e-02f, 7.84765184e-02f, 4.29415470e-03f, -1.41667828e-01f,
  6.47877455e-02f, 2.28331044e-01f, 6.45289347e-02f, 1.11162946e-01f, 6.99996054e-02f, 3.49069685e-02f, 6.53764606e-02f, -7.88985640e-02f, -1.44901872e-01f, 2.89378688e-04f,
  8.97156745e-02f, 3.85222808e-02f, 2.22352341e-01f, 4.78203930e-02f, 2.28040442e-01f, 5.89715429e-02f, -1.42823383e-01f, 3.54288667e-02f, 1.41429439e-01f, 5.64604178e-02f,
  -2.26260871e-01f, 2.27720901e-01f, -1.34265319e-01f, -3.36360522e-02f, 2.90691946e-03f, 3.11680343e-02f, 4.86112684e-02f, 9.68077853e-02f, 8.71682167e-02f, -1.02368286e-02f,
  1.14213713e-01f, 1.27821073e-01f, 1.67836010e-01f, 8.89794976e-02f, -2.37216949e-02f, 1.60846382e-01f, 2.25483418e-01f, 2.28020418e-02f, 1.45179287e-01f, -1.03854395e-01f,
  6.54838607e-02f, 3.21612321e-02f, -1.15859717e-01f, 2.11700220e-02f, -1.45083383e-01f, -1.05347514e-01f, 1.73546672e-01f, -2.14004219e-02f, 6.13512956e-02f, 3.96213606e-02f,
  5.44879287e-02f, -1.23646952e-01f, -1.92815922e-02f, 1.64507687e-01f, -4.91389073e-02f, -1.08549118e-01f, 5.47845475e-02f, -4.91237119e-02f, 2.62944520e-01f, -5.25660962e-02f,
  9.84228030e-02f, 4.03741300e-01f, -1.84595495e-01f, -1.58028193e-02f, -1.04999289e-01f, 3.98976803e-02f, 7.85390288e-02f, 1.05782270e-01f, -1.89680874e-01f, -3.87758575e-02f,
  -2.37960100e-01f, 1.02387153e-01f, 1.90429389e-01f, 5.55299595e-02f, 3.34837943e-01f, -7.89827630e-02f, 1.41937494e-01f, -3.67315076e-02f, 7.65709113e-03f, -3.26969624e-02f,
  9.00257826e-02f, 1.81209102e-01f, 1.18107311e-01f, -1.32127091e-01f, 8.68310854e-02f, 1.77054763e-01f, 8.59168619e-02f, -1.06210716e-01f, 3.63826826e-02f, 3.51739638e-02f,
  -1.58944458e-01f, -3.16530839e-02f, -8.07045251e-02f, 5.68205751e-02f, 1.16749123e-01f, 5.66124283e-02f, -7.70546049e-02f, 1.46689797e-02f, -3.12457442e-01f, -5.71559444e-02f,
  2.13649094e-01f, -3.96032492e-03f, -1.15326844e-01f, -2.55961478e-01f, -9.55995321e-02f, 1.13083087e-01f, -2.36999303e-01f, 9.30331200e-02f, -8.10378045e-02f, 1.14948735e-01f,
  2.13067383e-01f, 1.07704751e-01f, 2.18512699e-01f, 6.40537143e-02f, -7.00728148e-02f, -1.22750118e-01f, -2.74531901e-01f, -1.58829808e-01f, -3.07363961e-02f, 7.09248185e-02f,
  -1.92797512e-01f, 1.27636060e-01f, 3.38934325e-02f, 1.74466029e-01f, 1.31445944e-01f, 1.47259712e-01f, 1.44434929e-01f, 2.02131525e-01f, -7.51513317e-02f, -4.02075015e-02f,
  -5.25364093e-02f, 8.35787058e-02f, 2.59823501e-02f, 1.25254869e-01f, -4.39100303e-02f, 3.59546691e-01f, 1.99522853e-01f, -3.32001708e-02f, 1.08771794e-01f, 1.73107564e-01f,
  -1.28297612e-01f, 1.32638305e-01f, -2.93372542e-01f, -2.22870320e-01f, 2.42394730e-01f, -1.23644536e-02f, -1.64168812e-02f, -1.26022100e-01f, -2.23106980e-01f, 5.45246378e-02f,
  6.90576807e-02f, 6.28640875e-02f, -2.47457139e-02f, -3.99038643e-02f, 2.96017714e-02f, 7.37428516e-02f, -7.13394955e-03f, 9.88152400e-02f, 1.10645918e-02f, -1.28005490e-01f,
  -1.64616823e-01f, -5.92165254e-03f, -4.83172238e-02f, 4.79264036e-02f, -6.03579804e-02f, 1.91676497e-01f, 2.28261858e-01f, -1.34565607e-01f, 6.87415078e-02f, 2.06435829e-01f,
  -5.86784817e-02f, -1.02040604e-01f, 1.87383667e-01f, 4.91510495e-04f, -2.66612154e-02f, 1.01236202e-01f, 1.68674695e-03f, -2.11089775e-01f, -1.13183580e-01f, -2.67396420e-01f,
  1.19045060e-02f, -2.58655529e-02f, 2.18261294e-02f, 1.06239289e-01f, -2.08510049e-02f, -8.92300308e-02f, -2.69059837e-01f, 2.16938004e-01f, 1.55095920e-01f, 3.18879485e-02f,
  2.05632254e-01f, 2.12868527e-01f, -2.47987602e-02f, -2.09062845e-02f, -2.27345318e-01f, -1.93984471e-02f, 7.39957169e-02f, 5.03903814e-02f, 3.25568877e-02f, 2.83441637e-02f,
  6.35986626e-02f, -5.54873087e-02f, -1.31258722e-02f, -6.07220232e-02f, -1.19365081e-01f, -6.79331496e-02f, -1.14736438e-01f, 3.91132273e-02f, 6.65389672e-02f, -1.58834830e-02f,
  4.30708639e-02f, -1.46461800e-01f, -1.14880472e-01f, 1.07806683e-01f, -1.09486328e-02f, 2.11767122e-01f, 1.21948525e-01f, 1.42809778e-01f, 8.87074843e-02f, 1.02436759e-01f,
  -5.39147779e-02f, 6.79976121e-02f, 9.96678174e-02f, 1.53001562e-01f, 2.52747744e-01f, 1.44879937e-01f, 1.17551282e-01f, 1.38223350e-01f, 2.16663152e-01f, 7.51102567e-02f,
  -1.22133210e-01f, 1.84326217e-01f, -1.37055650e-01f, 2.77229458e-01f, 9.96894762e-02f, -1.40604168e-01f, -2.43912395e-02f, 5.71376309e-02f, -9.29566622e-02f, -1.83831170e-01f,
  9.02243182e-02f, -1.31866068e-03f, 8.68746862e-02f, 2.16179833e-01f, 2.15703711e-01f, 1.81119666e-01f, 8.53725448e-02f, 2.67507136e-01f, 1.56836122e-01f, 5.16254902e-02f,
  2.75748551e-01f, 8.28597844e-02f, 4.83758971e-02f, 1.82977342e-03f, 2.90175267e-02f, 1.75105050e-01f, 6.74425215e-02f, -2.27481648e-01f, -3.84951532e-02f, -2.39004195e-01f,
  -1.41840518e-01f, -3.02253477e-02f, -8.98059681e-02f, -5.44497594e-02f, 7.32681677e-02f, 2.20412195e-01f, 1.18731365e-01f, -5.19239977e-02f, 9.79781821e-02f, -1.86975867e-01f,
  -3.70156616e-02f, 2.52411067e-01f, 9.46494639e-02f, 8.27963054e-02f, -8.85686371e-03f, 6.58953488e-02f, 3.79867047e-01f, -1.61954165e-01f, 1.91976912e-02f, -2.03509659e-01f,
  -5.12195453e-02f, -1.39571682e-01f, -7.08410591e-02f, -1.13660082e-01f, 8.74582976e-02f, 8.08813944e-02f, -4.05158177e-02f, 5.31393476e-02f, -1.15736455e-01f, 1.00536309e-02f,
  -2.88481992e-02f, 1.81260377e-01f, 1.37712076e-01f, 1.30925253e-01f, 2.71719992e-01f, -2.25136995e-01f, 1.23031698e-01f, 6.95997616e-03f, -1.34334028e-01f, -1.80971995e-02f,
  -4.55057099e-02f, 9.97538045e-02f, 2.77984887e-01f, 1.87948719e-01f, 2.95897424e-01f, -1.52058631e-01f, -2.20235601e-01f, -1.55630514e-01f, -9.85544696e-02f, 4.63218428e-02f,
  -5.27616553e-02f, -4.25817743e-02f, -3.16221535e-01f, -7.16029778e-02f, 3.09363659e-02f, 2.60498524e-01f, 2.72866994e-01f, 3.20642024e-01f, 1.14317365e-01f, 3.35194282e-02f,
  1.97778389e-01f, 4.10800576e-02f, -2.57448286e-01f, 2.69613743e-01f, -1.22549921e-01f, 3.16026062e-01f, -2.14098647e-01f, 1.64182708e-01f, 2.49136776e-01f, -1.23067468e-01f,
  2.03154743e-01f, -9.91012305e-02f, -8.35416690e-02f, 6.99883103e-02f, 5.68027310e-02f, 8.99235625e-03f, -2.15912256e-02f, 1.98801473e-01f, 9.71878394e-02f, -1.54475063e-01f,
  -2.67621838e-02f, 4.98457313e-01f, 9.77905914e-02f, 6.20541908e-02f, 1.16441883e-01f, 1.02489941e-01f, 1.23034224e-01f, 7.00012818e-02f, 1.57543823e-01f, 6.32869080e-02f,
  1.23197250e-01f, 1.81831382e-02f, 4.25940729e-04f, 8.21669400e-02f, -1.33800477e-01f, -1.02474140e-02f, -1.44324690e-01f, -1.01699997e-02f, -4.35019359e-02f, -6.30735010e-02f,
  -3.00014857e-02f, -2.69489419e-02f, -3.62226255e-02f, -8.08031932e-02f, -1.28666181e-02f, -2.70143628e-01f, -1.85030058e-01f, 2.28549838e-01f, -2.50533849e-01f, 1.26874134e-01f,
  1.83796272e-01f, -5.82431890e-02f, 1.38128340e-01f, 1.15845039e-01f, 2.02608094e-01f, 7.21214414e-02f, 4.53614771e-01f, 1.55451696e-03f, -1.95322081e-01f, -1.94494128e-02f,
  8.38530064e-03f, -4.47311997e-02f, -6.36647716e-02f, 7.13998824e-02f, -2.37451419e-01f, 3.34276915e-01f, 2.47558981e-01f, -3.30369058e-03f, 2.58653790e-01f, -6.86053932e-02f,
  2.03464776e-01f, 1.95498094e-01f, -8.75986889e-02f, 3.01832287e-03f, 1.28912479e-02f, 1.57907292e-01f, 1.14306258e-02f, 3.65731940e-02f, -4.32937453e-03f, -7.48707578e-02f,
  2.70473182e-01f, 3.02086510e-02f, 1.73005044e-01f, 2.08834708e-02f, -1.18855219e-02f, -1.29793555e-01f, 3.86639945e-02f, -9.66338366e-02f, -2.78310739e-02f, -8.55618343e-02f,
  3.25480700e-02f, -8.75813067e-02f, 1.50990546e-01f, 1.07843585e-01f, -7.37357810e-02f, 1.43208932e-02f, -2.69022379e-02f, 9.49034616e-02f, 8.93648788e-02f, 2.12709889e-01f,
  -2.81497091e-03f, 3.90407369e-02f, 4.01916385e-01f, -6.50517792e-02f, 2.35030606e-01f, 4.61448058e-02f, -3.12412102e-02f, -3.64037557e-03f, -1.49850070e-01f, -7.54456036e-03f,
  7.24981502e-02f, 1.73115730e-01f, -5.37208691e-02f, -1.55657798e-01f, -1.59788683e-01f, 1.08117738e-03f, 1.01939231e-01f, 2.09599957e-01f, -7.73769468e-02f, 8.77484959e-03f,
  -2.35999092e-01f, -2.62019873e-01f, 2.22584069e-01f, 1.30540952e-01f, 1.13672383e-01f, 2.28637323e-01f, -1.17724873e-01f, -1.26753107e-01f, 6.61872402e-02f, 1.60431284e-02f,
  -1.20337747e-01f, 2.39959642e-01f, -2.20850855e-01f, 1.99120402e-01f, -3.05742890e-01f, -1.83985848e-03f, -2.32261848e-02f, -4.03678939e-02f, 1.11898728e-01f, -2.14603573e-01f,
  4.27209958e-02f, -1.67579472e-01f, 1.92338318e-01f, 6.88595772e-02f, -1.30545706e-01f, 2.77506471e-01f, 8.61022547e-02f, -1.17078992e-02f, 2.14994758e-01f, 3.97008300e-01f,
  -1.27014786e-01f, -3.84332947e-02f, 3.76258455e-02f, 1.82508767e-01f, -2.87228283e-02f, 7.04846978e-02f, -1.57378793e-01f, 2.51570717e-02f, -5.45120053e-02f, -1.56922489e-02f,
  1.56252459e-01f, -3.33657442e-03f, 1.20781757e-01f, -1.75363049e-01f, -4.71886434e-03f, -1.60210311e-01f, -1.07212886e-01f, 1.06243342e-01f, -4.69367690e-02f, 6.48885593e-02f,
  6.36041835e-02f, 1.22605145e-01f, -3.23741026e-02f, 2.05209091e-01f, 1.60498306e-01f, -9.64694247e-02f, -4.45273928e-02f, 1.41327173e-01f, 1.27685130e-01f, 2.52695531e-01f,
  1.43598214e-01f, 3.58176380e-02f, 1.59498811e-01f, 6.29231632e-02f, -2.10591033e-01f, 2.27559879e-01f, 9.07784775e-02f, -1.72853082e-01f, -7.74136335e-02f, -1.55573860e-02f,
  1.47193177e-02f, -3.44568677e-02f, 1.50238648e-01f, -8.06417763e-02f, -3.84683646e-02f, -1.08565763e-01f, -5.75821213e-02f, 8.18180852e-03f, 1.41154975e-01f, -5.17597720e-02f,
  6.91385865e-02f, 2.29430377e-01f, 4.89999168e-02f, 1.84298873e-01f, 1.20763667e-01f, 9.42651704e-02f, 2.52212763e-01f, 1.84504643e-01f, -3.02333739e-02f, -1.46576807e-01f,
  4.72915024e-02f, 2.52780855e-01f, 1.56183228e-01f, -1.34283239e-02f, 1.03505127e-01f, -2.06311513e-02f, 7.04075992e-02f, -5.70267923e-02f, 8.02356228e-02f, -2.69784592e-02f,
  1.30868390e-01f, 8.46192315e-02f, -4.75559570e-02f, 6.36788234e-02f, -2.88982037e-02f, 1.14739038e-01f, 1.82070479e-01f, 2.37592891e-01f, -2.99203414e-02f, 1.45044222e-01f,
  2.89861262e-01f, 1.37547269e-01f, 1.73464064e-02f, -7.66670927e-02f, 1.79345906e-01f, -1.37485340e-01f, -7.54254982e-02f, -5.33277541e-02f, 5.30083328e-02f, -3.20484005e-02f,
  5.39442413e-02f, 5.94534054e-02f, 3.44902091e-02f, 7.60585144e-02f, 2.34877646e-01f, 1.52534217e-01f, 2.96807066e-02f, 4.19403091e-02f, -7.08470717e-02f, -4.72986102e-02f,
  2.91547924e-01f, -5.40774912e-02f, 6.45328611e-02f, 5.70011139e-02f, -7.27677345e-03f, -5.88000640e-02f, 1.49001807e-01f, 4.69619893e-02f, -8.44032913e-02f, -4.69453856e-02f,
  -1.08632252e-01f, 2.27912255e-02f, -1.43967345e-01f, -7.26833493e-02f, 6.65926933e-02f, 1.40337333e-01f, 1.10854633e-01f, -1.41105831e-01f, 1.99868008e-01f, -8.93650725e-02f,
  2.25110337e-01f, 2.58880854e-01f, -1.67590693e-01f, 2.69397348e-01f, 1.32253626e-03f, -4.42202464e-02f, 1.76307335e-01f, 2.59533942e-01f, -4.70366180e-02f, 1.20663710e-01f,
  9.56786722e-02f, -8.89504142e-03f, -2.40813363e-02f, 3.70780528e-02f, 1.04810692e-01f, 3.26605774e-02f, 6.38840497e-02f, 7.04754144e-02f, -7.65869245e-02f, -7.62806758e-02f,
  6.28185049e-02f, -9.30386707e-02f, -6.91954941e-02f, 3.52113843e-02f, 5.26856922e-04f, 2.31686756e-02f, 5.80677837e-02f, -1.15856037e-01f, 2.08120747e-03f, -8.97085369e-02f,
  1.94005758e-01f, -2.67256379e-01f, -6.12235768e-03f, 2.71976352e-01f, -5.35510927e-02f, 1.13687433e-01f, 6.06761500e-02f, -2.61371136e-01f, 8.04455951e-02f, -3.15491967e-02f,
  5.21442248e-03f, 3.69074047e-02f, 2.50084639e-01f, -8.11076537e-02f, -2.47154832e-01f, 5.99046387e-02f, 1.49047747e-01f, -1.15844741e-01f, 1.39481857e-01f, 1.39858589e-01f,
  5.94587065e-02f, 2.64998823e-01f, 3.82571183e-02f, 2.12692525e-02f, 2.01488167e-01f, 3.28935049e-02f, 1.92616507e-01f, -2.52532344e-02f, -1.23839051e-01f, -9.74385887e-02f,
  3.89551669e-02f, 5.65621257e-02f, -1.28716186e-01f, -4.31121513e-02f, 1.03515781e-01f, 1.40174374e-01f, -7.34048383e-03f, 4.28590104e-02f, 2.00422406e-01f, -1.57711789e-01f,
  -2.31453538e-01f, 3.27474549e-02f, -2.72580683e-02f, -1.60352997e-02f, -7.09992722e-02f, -1.26467096e-02f, -1.30397435e-02f, -1.39907971e-02f, 1.75865763e-03f, -2.82616280e-02f,
  -2.45484971e-02f, -1.38513483e-02f, -3.25033367e-02f, -3.18212435e-02f, -1.34936988e-03f, 2.01790258e-02f, 7.10124569e-03f, 8.89635552e-03f, 1.13973822e-02f, 2.67054792e-02f,
  -1.25828222e-03f, 5.16905263e-03f, -1.69129018e-02f, 1.63471717e-02f, -8.25403165e-03f, 2.22973023e-02f, -2.17471104e-02f, -6.73896149e-02f, -1.33342408e-02f, -5.40654957e-02f,
  -2.21551675e-02f, -1.73836965e-02f, -6.23617172e-02f, -4.41122614e-02f, -4.25864607e-02f, -3.90119217e-02f, -5.19135110e-02f, -1.98060777e-02f, -2.84367260e-02f, -5.17253540e-02f,
  -3.49928401e-02f, -9.45507921e-03f, -4.83334623e-02f, -4.87976000e-02f, -3.42530608e-02f, -7.12782815e-02f, -3.78221795e-02f, -4.15928774e-02f, -6.61576539e-02f, -2.61087734e-02f,
  -4.57250960e-02f, -3.33074071e-02f, -9.52628162e-03f, -3.47536393e-02f, -1.91051923e-02f, -3.37772034e-02f, -4.83518504e-02f, -3.36091332e-02f, -5.66391647e-02f, -5.72848059e-02f,
  -3.72474566e-02f, -4.65415344e-02f, -7.14931786e-02f, -2.17367355e-02f, 2.96922354e-03f, -2.44533606e-02f, 1.18811294e-01f, -1.85494348e-02f, -1.94020905e-02f, -1.14421256e-01f,
  5.11951782e-02f, -1.65215489e-02f, 1.18183434e-01f, 8.78147930e-02f, -3.10421996e-02f, -5.91460913e-02f, 2.68252604e-02f, 1.07368372e-01f, -2.45707676e-01f, 1.60502940e-01f,
  1.63556397e-01f, 2.34157965e-01f, 1.62743293e-02f, -1.27146378e-01f, -3.20040733e-02f, -7.63095617e-02f, -1.48928151e-01f, 9.52394232e-02f, -1.37780726e-01f, -3.17445137e-02f,
  1.73438806e-02f, 3.78873050e-02f, 9.12696645e-02f, 4.70529348e-02f, 1.84510544e-01f, 2.71209832e-02f, -2.57804291e-03f, 4.93814796e-02f, -2.20605582e-02f, -1.15617603e-01f,
  2.26779476e-01f, -9.21726152e-02f, -7.14258328e-02f, -1.58176571e-01f, -6.34698719e-02f, 1.97363809e-01f, -2.72211164e-01f, -5.89221418e-02f, -2.07693785e-01f, 6.50271624e-02f,
  2.20485255e-01f, 7.88503140e-02f, 1.26857504e-01f, -7.30600134e-02f, 9.61262435e-02f, 2.13533551e-01f, 6.45415410e-02f, -8.31189826e-02f, 1.56831712e-01f, 6.81522638e-02f,
  -4.26281728e-02f, 1.16668036e-02f, -1.37844026e-01f, -2.29564890e-01f, 2.61787146e-01f, 2.16084346e-01f, 8.79536569e-02f, -4.21072841e-02f, -2.07960326e-02f, 5.39250905e-04f,
  3.22044417e-02f, -3.39602381e-02f, 1.81998134e-01f, 1.25338525e-01f, -5.18147796e-02f, 1.82152465e-02f, -9.54929814e-02f, 9.13495719e-02f, 1.32313207e-01f, 1.33847475e-01f,
  1.94338202e-01f, 7.55296871e-02f, 3.14313099e-02f, -1.82460189e-01f, 1.19249381e-01f, -1.22338466e-01f, -6.41212836e-02f, 3.86753213e-03f, -7.46397153e-02f, 4.32816744e-02f,
  -1.09056599e-01f, 1.55456280e-02f, -6.14825226e-02f, 2.12276265e-01f, 1.38795689e-01f, 5.78484572e-02f, 1.59423351e-01f, 2.37246917e-04f, 2.48500600e-01f, 1.94495112e-01f,
  -9.49144512e-02f, -6.34670779e-02f, 2.02586249e-01f, 1.45349890e-01f, -2.09258243e-01f, 2.36506104e-01f, 2.86774449e-02f, -8.48270021e-03f, 1.10992149e-01f, -2.40228444e-01f,
  1.54835522e-01f, 4.13596816e-02f, 2.09278420e-01f, -4.92540114e-02f, 1.51549563e-01f, 1.59436584e-01f, -1.93452928e-03f, 5.68456985e-02f, 2.13832691e-01f, 7.90893883e-02f,
  1.07066043e-01f, 2.10692927e-01f, -2.24857211e-01f, 2.11357102e-01f, 7.51576871e-02f, 2.18410403e-01f, 1.38953896e-02f, 8.18953887e-02f, 4.21083644e-02f, 4.87463623e-02f,
  2.72260793e-02f, 1.77443281e-01f, 1.16978519e-01f, -7.03533441e-02f, 1.01299949e-01f, 1.64935023e-01f, 2.05998793e-01f, -9.06734914e-02f, -1.04087315e-01f, 4.64383559e-03f,
  3.58213596e-02f, -3.28141265e-02f, 1.98215932e-01f, 2.17651725e-01f, 1.95477873e-01f, -3.62462774e-02f, 2.28685681e-02f, 2.33189166e-02f, 9.39896423e-03f, 6.94150552e-02f,
  7.36790826e-04f, -8.92507359e-02f, -8.67754593e-02f, -1.45383418e-01f, 8.58282298e-02f, -1.85350090e-01f, -3.35035808e-02f, -2.93129951e-01f, -8.13084096e-02f, 1.06321067e-01f,
  2.80094743e-02f, 1.11351602e-01f, 2.81846523e-01f, -1.82305455e-01f, 8.91287774e-02f, 1.51996622e-02f, -9.44788009e-02f, 1.03237130e-01f, 2.96678305e-01f, -8.88865367e-02f,
  3.25378999e-02f, 1.69127315e-01f, 1.57648638e-01f, 6.85731997e-04f, 1.38993531e-01f, 2.00086504e-01f, -8.42109099e-02f, 1.67234525e-01f, 9.46264938e-02f, 7.22948313e-02f,
  1.85196266e-01f, -8.47508758e-02f, 1.43661410e-01f, -1.28115891e-02f, -1.77924678e-01f, 7.46769384e-02f, 4.11056802e-02f, 4.23406214e-02f, -3.94048020e-02f, 7.26773739e-02f,
  -2.94117630e-02f, -1.36078475e-02f, 6.96854666e-03f, 3.09519887e-01f, 2.48187736e-01f, -2.62117445e-01f, -1.18662640e-01f, 7.60831218e-03f, 5.78652194e-04f, -5.59178693e-03f,
  -4.69390012e-04f, -6.72010798e-03f, -7.02397386e-03f, -5.70804393e-03f, -3.71825974e-03f, -2.14639632e-03f, -6.08336739e-03f, -5.65995323e-03f, -5.37221832e-03f, -2.77968589e-03f,
  -5.00489259e-03f, 3.67275931e-07f, 5.17704431e-03f, 7.43567507e-05f, 8.17626496e-05f, -1.09883516e-08f, 2.37183738e-03f, 3.03807715e-03f, -6.18681734e-05f, 5.79362904e-06f,
  4.76937683e-04f, 2.13752734e-03f, -1.72516536e-02f, -1.04855383e-02f, -6.85404427e-03f, -1.67354532e-02f, -5.16473455e-03f, -1.46589670e-02f, -3.92961269e-03f, -5.49521392e-05f,
  -1.36625189e-02f, -1.42054157e-02f, -8.67661674e-06f, -1.53889100e-03f, -1.47536136e-02f, -3.29541299e-03f, -9.93850548e-03f, -1.62034167e-03f, -1.33243036e-02f, -2.69355508e-03f,
  -1.04990127e-02f, -1.49712441e-02f, -1.40676908e-02f, -1.55136697e-02f, -1.62484366e-02f, -8.59713554e-03f, -1.82836745e-02f, 5.76109271e-10f, -9.57162047e-06f, -1.47370547e-02f,
  -7.24430938e-05f, -7.78806210e-03f, -1.50814084e-02f, -1.15348874e-02f, -1.55906286e-02f, -1.07188895e-02f, -2.31434516e-09f, -9.93641187e-03f, -1.19179459e-02f, -1.30910110e-02f,
  1.71875414e-09f, -8.48912634e-03f, 6.30277321e-02f, -4.51583639e-02f, -6.71652853e-02f, 4.14714552e-02f, -2.69891806e-02f, 1.12277726e-02f, -7.87858143e-02f, 7.36675709e-02f,
  -2.75005326e-02f, 1.29487485e-01f, 1.04494646e-01f, 6.01465888e-02f, 1.46051437e-01f, 5.97748905e-02f, 2.19186381e-01f, 9.50887147e-03f, -5.61299548e-02f, 9.80004221e-02f,
  -3.64971608e-02f, 1.98494241e-01f, 5.63420132e-02f, 9.25028622e-02f, -6.40762821e-02f, 3.16085726e-01f, 1.41551569e-01f, -1.13550864e-01f, 2.89254695e-01f, -1.17126420e-01f,
  2.48104334e-02f, 3.04323852e-01f, -7.74949268e-02f, 1.86014310e-01f, 1.35540828e-01f, 2.03091249e-01f, -2.96433598e-01f, 1.67735055e-01f, 2.06328452e-01f, 9.68093127e-02f,
  1.43730626e-01f, 8.87663886e-02f, 2.46343948e-02f, 1.25746196e-02f, 2.95909673e-01f, -1.61515564e-01f, 1.35459602e-02f, 5.88274039e-02f, -2.57022232e-01f, 2.79632062e-01f,
  1.18343584e-01f, -7.23018795e-02f, 2.78416693e-01f, 2.37134546e-01f, 7.59327561e-02f, 2.54888069e-02f, 7.22314417e-02f, 1.36627376e-01f, 6.80725873e-02f, 1.26670241e-01f,
  -1.29397243e-01f, -7.85903111e-02f, -1.04731835e-01f, 1.89028338e-01f, 2.67120183e-01f, 9.61958990e-02f, 5.00166528e-02f, -1.86561659e-01f, 1.12110406e-01f, -1.41402245e-01f,
  8.70057344e-02f, 2.15981882e-02f, 1.87793419e-01f, 8.79989490e-02f, 6.45698830e-02f, -2.70931926e-02f, -2.76907515e-02f, 3.07929851e-02f, 4.49234582e-02f, 2.72730678e-01f,
  1.15318224e-02f, 1.50308624e-01f, 2.90683389e-01f, -1.09642938e-01f, 1.60568282e-01f, -1.65430009e-01f, -1.01121388e-01f, 5.42147718e-02f, -1.59587145e-01f, -1.63400307e-01f,
  7.71951824e-02f, -4.69136564e-03f, 5.83383404e-02f, -8.86186659e-02f, 7.59898424e-02f, -2.29270980e-02f, 5.11966646e-02f, 1.56000346e-01f, -1.79530475e-02f, -9.00072604e-02f,
  2.12340299e-02f, -1.93858176e-01f, 7.41794631e-02f, -4.72399443e-02f, 7.75819644e-02f, 1.32577851e-01f, -2.23284557e-01f, -4.69521657e-02f, -1.18954487e-01f, 1.21041089e-01f,
  -7.17187813e-03f, 1.51583537e-01f, -1.73963923e-02f, 1.17240567e-02f, -1.15346223e-01f, 1.56503320e-01f, 2.26683468e-02f, -1.46186545e-01f, 4.91017923e-02f, 3.21367085e-02f,
  8.65817815e-02f, 9.58476737e-02f, 2.18886331e-01f, 4.55555618e-02f, 9.31231230e-02f, 3.18512440e-01f, 2.38420814e-01f, -6.18554503e-02f, 7.91099742e-02f, 3.01476002e-01f,
  -8.45417902e-02f, 8.29749405e-02f, -2.80446596e-02f, 8.23231936e-02f, 1.72277927e-01f, 1.77140478e-02f, 4.00920324e-02f, 8.15572590e-02f, 1.42147154e-01f, 3.10163684e-02f,
  1.89723596e-01f, 1.03419937e-01f, 1.28155604e-01f, 2.18419239e-01f, 1.31261826e-01f, 7.39574954e-02f, 1.09908141e-01f, 2.10990384e-01f, -3.15566957e-02f, 1.58888116e-01f,
  1.56719312e-01f, 4.69856896e-03f, -7.53475055e-02f, -3.50812152e-02f, 4.83847372e-02f, -7.00432137e-02f, 2.06367493e-01f, 4.46960703e-02f, 1.07748182e-02f, 1.23170525e-01f,
  2.77379036e-01f, 1.96494341e-01f, -6.84762374e-02f, 3.31133977e-02f, -1.31235104e-02f, 5.47468252e-02f, 3.93295676e-01f, -7.00253174e-02f, -1.86798163e-02f, 2.26187885e-01f,
  -7.29824007e-02f, 2.06761733e-02f, 1.26945674e-01f, -4.76575568e-02f, -1.10403828e-01f, -1.38780251e-01f, -1.57209203e-01f, -1.05077187e-02f, -1.79679126e-01f, -1.78874768e-02f,
  9.35473293e-02f, 2.38070935e-01f, 1.40350446e-01f, -1.16943412e-01f, 2.98870504e-01f, -1.43550932e-01f, 2.65240163e-01f, 2.52760679e-01f, -5.04047126e-02f, 2.03072265e-01f,
  7.48814866e-02f, 1.39706030e-01f, 3.33499253e-01f, 1.26420990e-01f, 2.58375350e-02f, 1.56655833e-02f, 4.08797450e-02f, -1.79662276e-02f, -1.25465300e-02f, -1.41393989e-02f,
  -3.33381146e-02f, -1.31200179e-02f, 7.44984392e-03f, -4.01672907e-02f, -3.25552337e-02f, -6.90680072e-02f, 8.04253574e-03f, 1.01147750e-02f, -2.00688709e-02f, -2.85048112e-02f,
  2.79559344e-02f, 2.05211528e-02f, 4.74750623e-03f, -1.63920987e-02f, 1.91279966e-02f, 7.75205763e-03f, 2.57440787e-02f, -8.46973713e-03f, -8.34912620e-03f, -2.70148106e-02f,
  -8.63175839e-03f, -1.24311717e-02f, -5.94303645e-02f, -3.35859731e-02f, -1.58556122e-02f, -1.63378157e-02f, -3.01441420e-02f, -2.24191491e-02f, -4.29621860e-02f, 1.81970801e-02f,
  -9.19978227e-03f, -2.08946038e-03f, -4.27839020e-03f, -1.27543164e-02f, 6.54085213e-03f, -2.83744503e-02f, -4.70432965e-03f, -2.44163573e-02f, -8.93098190e-02f, -2.84303501e-02f,
  -5.13467938e-02f, 5.46265626e-03f, -5.59117608e-02f, -4.75954600e-02f, -1.83864199e-02f, -1.90799516e-02f, -8.98077711e-03f, -8.72447640e-02f, -7.03306077e-03f, -7.55768642e-02f,
  -2.78150453e-03f, -4.91276896e-03f, -4.76944186e-02f, -2.83075683e-02f, -2.08712108e-02f, -2.99980417e-02f, -1.41212596e-02f, -9.71140922e-04f, 5.82854003e-02f, 9.57794189e-02f,
  1.59977093e-01f, 5.06884865e-02f, 2.86377482e-02f, 1.36865854e-01f, 6.93822578e-02f, 1.12969808e-01f, 1.00358628e-01f, 9.84678790e-02f, -1.15787879e-01f, 1.75067022e-01f,
  -2.04180237e-02f, 4.06896099e-02f, -8.55884794e-03f, 2.05836996e-01f, 1.81458488e-01f, -1.43740967e-01f, 8.58663768e-02f, 1.38076112e-01f, 6.47709295e-02f, -1.53670132e-01f,
  1.68064326e-01f, -1.88649148e-01f, -5.68149202e-02f, 3.76346648e-01f, -1.28588438e-01f, -9.43145230e-02f, 3.97653952e-02f, -2.86883324e-01f, 1.29256979e-01f, 1.33954540e-01f,
  5.52716516e-02f, 2.23823532e-01f, 2.45773613e-01f, -2.01131359e-01f, -1.17593206e-01f, 3.07905942e-01f, 2.32969731e-01f, -9.15020108e-02f, 2.32435614e-01f, 3.44942570e-01f,
  3.36009637e-02f, 2.69784212e-01f, -1.56532779e-01f, 4.95367274e-02f, 2.48989105e-01f, 6.20943531e-02f, -6.66187927e-02f, 6.59116730e-02f, -1.49208009e-01f, -3.47715020e-02f,
  -3.09029315e-02f, -3.92169096e-02f, -7.29495585e-02f, -1.22531429e-01f, -6.87206835e-02f, 1.66414589e-01f, 9.57024395e-02f, 2.10487500e-01f, 2.23188072e-01f, -2.07858875e-01f,
  -1.59017190e-01f, 2.61336961e-03f, -1.96649358e-02f, 2.02194564e-02f, 1.89845357e-02f, 8.57455377e-03f, 5.75214364e-02f, 7.28347003e-02f, -6.60308031e-03f, 5.00008017e-02f,
  -4.86646816e-02f, 7.62000084e-02f, 1.73803926e-01f, -2.76184380e-02f, 7.22750053e-02f, 5.60341366e-02f, 1.25486061e-01f, 1.90061517e-02f, -1.39078230e-01f, 2.90644109e-01f,
  9.69720725e-03f, 5.62300943e-02f, -4.44999933e-02f, -3.23732086e-02f, -1.14394031e-01f, -4.57709171e-02f, -8.34629908e-02f, -1.44852474e-01f, -3.20939310e-02f, 1.28125802e-01f,
  2.92168200e-01f, 9.25267413e-02f, 2.37511620e-01f, 1.66067883e-01f, -1.42421916e-01f, 4.86564003e-02f, 1.52729005e-01f, 1.99668556e-02f, 7.20795766e-02f, -2.95272619e-01f,
  -2.08531603e-01f, -7.44826123e-02f, -3.46440881e-01f, -2.21924916e-01f, -2.26088557e-02f, 6.87074736e-02f, 2.50421137e-01f, -5.97440526e-02f, 1.19334996e-01f, -1.99128896e-01f,
  1.17017649e-01f, 1.04136325e-01f, 3.93209271e-02f, -5.85041707e-04f, 9.58623365e-02f, 2.01040506e-01f, 1.46190733e-01f, 4.00894210e-02f, 1.01428486e-01f, 7.55505785e-02f,
  6.57707825e-03f, 1.38116442e-03f, 8.03355798e-02f, 1.48435920e-01f, 1.75674930e-01f, -1.74050644e-01f, 1.66045278e-02f, -5.94778694e-02f, -4.39722948e-02f, -2.69117713e-01f,
  -1.60165057e-01f, -1.01356238e-01f, -1.02536507e-01f, -6.92579821e-02f, -5.95058165e-02f, 4.12251502e-02f, -8.87656063e-02f, -2.83914328e-01f, 2.38448963e-01f, -4.71727178e-02f,
  -1.92241907e-01f, -1.76456943e-01f, -3.23357768e-02f, 1.44032091e-01f, 6.34806678e-02f, -2.15775892e-01f, 6.37158677e-02f, 1.47038028e-01f, -6.72031045e-02f, 4.59112376e-02f,
  1.60867378e-01f, 1.77055206e-02f, -8.54119211e-02f, 1.34969831e-01f, -1.03144929e-01f, 9.37770829e-02f, 5.45365103e-02f, 4.21999358e-02f, 5.14260679e-02f, -2.80877799e-02f,
  -2.72562861e-01f, 1.20674632e-01f, 1.69649675e-01f, 5.51547296e-02f, 2.98204441e-02f, -1.38650790e-01f, 1.48516417e-01f, -2.07885299e-02f, 2.39012942e-01f, 1.16744228e-01f,
  1.95477940e-02f, 1.62440121e-01f, 4.30717738e-03f, 1.62753701e-01f, 1.80474043e-01f, -2.34255672e-01f, -8.36537033e-02f, 9.24899057e-02f, -1.47387311e-01f, 1.02263473e-01f,
  1.72578052e-01f, 1.84988588e-01f, 3.53469014e-01f, 2.17584372e-01f, -2.43455455e-01f, 2.75947507e-02f, 1.72219411e-01f, 2.56998837e-01f, -9.77657586e-02f, 1.74680769e-01f,
  1.51847526e-01f, -1.68229803e-01f, 1.43273219e-01f, -1.62882775e-01f, -1.34546056e-01f, -4.06034254e-02f, 9.07336399e-02f, 1.02535367e-01f, -2.06047818e-02f, 1.77195504e-01f,
  -6.34669214e-02f, 5.31478561e-02f, -8.28699842e-02f, -1.80647485e-02f, -1.30050248e-02f, 1.21444605e-01f, 2.47560859e-01f, -2.74206638e-01f, 3.42001095e-02f, -6.46444270e-03f,
  -7.22115934e-02f, -5.13973385e-02f, 1.96823087e-02f, -1.59407362e-01f, 7.30955601e-02f, 3.43087256e-01f, -9.56874043e-02f, -5.96799254e-02f, -4.64128815e-02f, -1.04659468e-01f,
  -2.55038906e-02f, 5.04225530e-02f, 1.51275471e-01f, -5.63574620e-02f, 6.24036342e-02f, -1.12574004e-01f, -2.03153253e-01f, 3.06203008e-01f, 2.05023766e-01f, -7.87616819e-02f,
  1.44029111e-01f, 9.68539044e-02f, -3.79804894e-02f, 3.02965283e-01f, -4.12172861e-02f, 1.71256676e-01f, 2.28615522e-01f, 8.81397426e-02f, 3.00005986e-03f, 2.51037687e-01f,
  -1.48496866e-01f, -1.32664204e-01f, -1.02977879e-01f, 8.04579034e-02f, -1.55976847e-01f, 1.29916430e-01f, 7.65752941e-02f, -1.78283639e-02f, 1.24063015e-01f, 1.76561922e-01f,
  2.36338452e-01f, -1.02012306e-01f, -1.85559034e-01f, 9.48360637e-02f, 2.02141851e-02f, 4.06847522e-02f, 9.84840319e-02f, -3.74740250e-02f, -7.18680304e-03f, 1.34123871e-02f,
  1.04100272e-01f, -6.78693354e-02f, 9.87670347e-02f, 4.83643176e-04f, 1.88088879e-01f, 5.72859421e-02f, -1.82394031e-02f, 1.09441146e-01f, 1.70578554e-01f, -3.51633653e-02f,
  -7.05589056e-02f, 1.13873675e-01f, -3.56531925e-02f, -5.81453815e-02f, -1.24455266e-01f, 8.45680535e-02f, -2.32596964e-01f, -6.00324720e-02f, 2.17096761e-01f, -4.87419479e-02f,
  1.40740618e-01f, 1.37673408e-01f, 3.23196262e-01f, 1.57616094e-01f, 5.44863380e-02f, -1.22944042e-02f, -9.73825008e-02f, -4.16713208e-02f, 1.02367237e-01f, -8.10713246e-02f,
  1.23608679e-01f, -1.00932471e-01f, 2.78965496e-02f, 2.58557886e-01f, -2.11842656e-01f, -1.58518434e-01f, -7.38565922e-02f, 3.29899937e-02f, 1.89747289e-01f, 8.15846622e-02f,
  3.62946675e-03f, -1.71880946e-01f, 1.09023251e-01f, 7.27628693e-02f, 1.83987156e-01f, 3.88786122e-02f, 3.19989711e-01f, 8.06277692e-02f, 2.21530944e-01f, 5.30159138e-02f,
  6.77580759e-02f, -1.40905559e-01f, 2.91463248e-02f, 1.80849850e-01f, 1.39154702e-01f, -9.21027549e-03f, 1.00035951e-01f, 6.95427731e-02f, 1.04193687e-01f, 2.47674182e-01f,
  1.29320875e-01f, 1.25977889e-01f, 9.18150395e-02f, 1.53808996e-01f, 1.17902026e-01f, -1.21484771e-02f, 2.03332864e-02f, -2.91349962e-02f, -3.21516357e-02f, 5.70420995e-02f,
  1.40469611e-01f, -1.22852847e-01f, -2.21441969e-01f, 7.48199448e-02f, 6.91178143e-02f, 1.55330583e-01f, 4.94921952e-02f, 9.74118486e-02f, 2.61663079e-01f, -2.72641480e-01f,
  1.95289418e-01f, -2.32743785e-01f, -3.51486169e-02f, 1.41520351e-01f, -2.43775725e-01f, 3.80090624e-02f, 1.45736292e-01f, -6.53161481e-02f, 2.88308591e-01f, 2.01273903e-01f,
  1.51161358e-01f, 1.91822037e-01f, 3.14465433e-01f, -5.49555235e-02f, 1.40575513e-01f, 1.35748327e-01f, 2.48381868e-02f, -1.48023918e-01f, 2.45963901e-01f, 2.62154341e-01f,
  2.07025316e-02f, 2.22508714e-01f, 4.88776481e-03f, -1.03143193e-01f, 2.85005599e-01f, -7.54952952e-02f, 9.45182741e-02f, -2.33679250e-01f, -1.47526085e-01f, 2.20087335e-01f,
  -3.01239379e-02f, -8.05895478e-02f, 2.35634297e-01f, -1.53566971e-01f, 2.10640967e-01f, 2.34574378e-01f, -8.29864740e-02f, 2.03671426e-01f, 2.69571096e-01f, 6.37270287e-02f,
  4.89902273e-02f, -4.31844071e-02f, 8.62938389e-02f, 5.55935875e-02f, 1.61105737e-01f, 1.80844404e-02f, 2.56417207e-02f, -6.25593364e-02f, -9.90410820e-02f, -2.71588452e-02f,
  1.52874559e-01f, 1.30058646e-01f, -6.39610365e-02f, 7.62665197e-02f, 2.08072532e-02f, -2.97627568e-01f, -7.84185827e-02f, -1.52070418e-01f, -1.15394503e-01f, 2.37454586e-02f,
  -2.74480302e-02f, 1.09610938e-01f, 9.55339638e-04f, -8.02247524e-02f, 3.94895449e-02f, 1.93996936e-01f, 8.19370747e-02f, 1.35070369e-01f, 6.86496571e-02f, -6.93765953e-02f,
  7.53766149e-02f, 2.14712337e-01f, -6.34593666e-02f, 7.30002373e-02f, 3.25228423e-01f, 3.18204343e-01f, -1.31725103e-01f, 1.11925282e-01f, 1.17060490e-01f, 2.59493262e-01f,
  2.36220241e-01f, -1.24513678e-01f, 2.85254329e-01f, 2.08273202e-01f, 1.29739001e-01f, -8.19372833e-02f, 1.15964964e-01f, 1.54620096e-01f, 1.49797082e-01f, 1.71174824e-01f,
  3.12591374e-01f, 1.07271738e-01f, 5.62021881e-02f, 2.43710220e-01f, -2.93861836e-01f, 6.99182823e-02f, 6.82352558e-02f, 1.12043545e-01f, 5.67178987e-02f, 2.14582905e-01f,
  5.44812195e-02f, -9.90908220e-02f, -1.84447169e-02f, 1.59841299e-01f, 1.17660994e-02f, -1.36873037e-01f, 7.77893141e-02f, -1.62513740e-02f, -2.56603509e-02f, -3.91585007e-02f,
  -3.41252759e-02f, 9.65019017e-02f, 6.35108957e-03f, 4.67878319e-02f, -1.25829354e-01f, -1.48280233e-01f, -1.84375852e-01f, -2.17322204e-02f, -9.22093242e-02f, -4.48229117e-03f,
  -2.45462194e-01f, 4.33234498e-02f, 4.35996422e-04f, -9.26085711e-02f, 7.00938255e-02f, -9.85214487e-02f, -7.67350197e-02f, 5.01527078e-02f, 6.13105372e-02f, -5.35208620e-02f,
  -1.19083010e-01f, 2.89680272e-01f, -2.13133350e-01f, 1.81792318e-04f, 6.71107247e-02f, 5.12230098e-02f, 1.44380212e-01f, 7.36553594e-03f, 9.37750489e-02f, -2.55318824e-02f,
  1.53160408e-01f, -2.02400554e-02f, -3.54488790e-01f, -6.30478412e-02f, -6.37473986e-02f, -2.66617835e-01f, -1.39282858e-02f, -6.25953265e-03f, 4.96609472e-02f, 2.79316574e-01f,
  5.41096255e-02f, -2.21408140e-02f, 3.42134297e-01f, 2.49331817e-02f, 2.02304691e-01f, 4.95300032e-02f, -1.69351950e-01f, -7.07289483e-03f, -2.35474065e-01f, 1.96647316e-01f,
  1.50520885e-02f, 1.26441762e-01f, 6.41158968e-02f, -4.21706475e-02f, 2.02721030e-01f, -1.07921353e-02f, 1.49986148e-01f, 5.74756563e-02f, -1.30133763e-01f, -1.69215221e-02f,
  3.23796459e-02f, 2.17868499e-02f, 8.42150599e-02f, 5.41287623e-02f, 6.88130176e-03f, 3.14522814e-03f, 1.19101619e-02f, -1.00927390e-01f, 1.40283018e-01f, 1.78466409e-01f,
  2.26111487e-01f, -2.71838214e-02f, 1.43966526e-01f, -3.98583375e-02f, -2.88264528e-02f, -9.55185145e-02f, -4.34737876e-02f, 2.70371109e-01f, 7.92898759e-02f, -6.83121756e-02f,
  5.09031862e-02f, -6.68927059e-02f, -2.54026145e-01f, -4.27113287e-02f, -4.06831913e-02f, -5.37815206e-02f, -6.27084076e-02f, 6.88279718e-02f, 4.53761995e-01f, 2.09739357e-01f,
  1.80663288e-01f, 1.73551425e-01f, -6.12944663e-02f, 1.02085374e-01f, 2.20052794e-01f, -2.38546599e-02f, 1.91855669e-01f, -1.87497541e-01f, 1.18044190e-01f, -9.38834972e-04f,
  -2.91639626e-01f, -1.89245626e-01f, 1.19407279e-02f, -2.18070354e-02f, 3.23567957e-01f, 2.31155410e-01f, 7.77274668e-02f, -9.25084203e-02f, 2.07943156e-01f, -2.35310700e-02f,
  -8.04219320e-02f, 3.59948650e-02f, 4.64705117e-02f, 1.87257811e-01f, 2.03012154e-01f, 1.38194799e-01f, 2.39767596e-01f, 2.10102182e-03f, -1.29368648e-01f, 1.47812277e-01f,
  2.10171938e-01f, 2.40694612e-01f, 2.71696448e-01f, -1.10980049e-01f, -1.63604096e-02f, 5.31946421e-02f, -5.72939329e-02f, 1.60899580e-01f, -2.82045566e-02f, 1.71086937e-02f,
  -1.89699635e-01f, 1.99959502e-02f, 4.56717759e-02f, 6.75625503e-02f, 8.31297860e-02f, 3.18074413e-02f, -2.25190967e-01f, -1.91690713e-01f, 6.64220601e-02f, -2.07180798e-01f,
  -3.17620903e-01f, -5.23163974e-02f, -1.11631356e-01f, -1.17864423e-02f, -1.28146976e-01f, 1.94012329e-01f, -2.33728103e-02f, 1.87994897e-01f, 2.89732397e-01f, -1.32801786e-01f,
  1.10866457e-01f, 2.73827434e-01f, 4.05651070e-02f, 2.12378308e-01f, -2.23799750e-01f, -2.03815788e-01f, 1.29577011e-01f, 1.60802472e-02f, 5.23720048e-02f, 1.99360043e-01f,
  8.29938725e-02f, -8.59087706e-02f, 4.07566689e-02f, 2.20648497e-01f, 1.05497435e-01f, 5.33333980e-02f, 6.19420409e-02f, 1.85347229e-01f, 1.92151144e-01f, -3.22616287e-02f,
  1.21587425e-01f, -2.42897426e-03f, 2.52999634e-01f, 2.20726117e-01f, 1.76195055e-01f, 9.56651643e-02f, 8.87294635e-02f, 1.93679839e-01f, 1.40019134e-01f, 1.44462079e-01f,
  -1.62901089e-01f, -7.44475871e-02f, 1.46163553e-01f, -1.21186860e-01f, -6.52792538e-03f, 8.63381773e-02f, -1.98572412e-01f, 3.14567089e-02f, -1.86327770e-01f, 2.17770994e-01f,
  -5.20346537e-02f, 4.22609691e-03f, 1.53243586e-01f, 1.49009088e-02f, -1.14987858e-01f, 7.11340681e-02f, 4.87818941e-02f, -8.85881856e-02f, 5.02598323e-02f, 9.56887975e-02f,
  1.23718694e-01f, -5.07598408e-02f, 5.27329221e-02f, -4.13142517e-02f, -6.44320846e-02f, 8.75945315e-02f, -2.24874690e-02f, -9.63804871e-03f, 1.90698132e-01f, 5.46424985e-02f,
  5.83914369e-02f, 2.37626601e-02f, -3.63989547e-02f, 1.10452361e-02f, 5.02466112e-02f, 1.81744829e-01f, -2.31470019e-01f, 1.35245472e-01f, 1.62387863e-01f, 7.52320588e-02f,
  1.77903444e-01f, 9.81353894e-02f, -8.10538456e-02f, 1.93865910e-01f, 1.11507170e-01f, 1.54703543e-01f, -1.59219615e-02f, -2.89051421e-02f, 1.45295307e-01f, 1.83312148e-01f,
  2.26665556e-01f, 1.15900576e-01f, -1.41158149e-01f, -1.36397585e-01f, -3.43605168e-02f, 8.35988075e-02f, -4.46327925e-02f, -3.81358489e-02f, -5.35407513e-02f, 2.02807009e-01f,
  -2.61390358e-02f, -2.75063179e-02f, 1.90615669e-01f, -1.32132024e-01f, 1.30759522e-01f, 1.95985228e-01f, 9.07436907e-02f, -1.44248128e-01f, 8.48679766e-02f, 9.18958932e-02f,
  -3.75926532e-02f, 1.82531420e-02f, -4.68971170e-02f, -1.17719010e-01f, -1.34823561e-01f, -2.45801993e-02f, 6.98629618e-02f, -9.56032053e-02f, 9.00998265e-02f, -5.89330634e-03f,
  -4.46171574e-02f, -2.00801585e-02f, -6.97481558e-02f, -3.85099724e-02f, 7.33713135e-02f, 1.25744194e-01f, 5.95774762e-02f, 8.76984969e-02f, 9.94057730e-02f, 1.01443157e-01f,
  1.21866405e-01f, 5.43685481e-02f, 2.21386161e-02f, -7.15666711e-02f, -2.52338722e-02f, 8.99753422e-02f, 1.65932793e-02f, -1.17329702e-01f, 5.48110120e-02f, -8.95019546e-02f,
  -1.24693967e-01f, 3.69598754e-02f, 2.66474430e-02f, 1.27387404e-01f, -8.87664184e-02f, -4.14547659e-02f, -1.76907957e-01f, -1.02090798e-01f, 1.60179466e-01f, -3.59922498e-02f,
  2.35754363e-02f, 1.54963121e-01f, -1.99777991e-01f, -2.01569527e-01f, 2.56013907e-02f, -1.20664038e-01f, -1.51245192e-01f, 2.89412085e-02f, -2.29833156e-01f, 6.31333441e-02f,
  -2.59833038e-01f, -7.37658367e-02f, 4.60619628e-02f, -2.08653342e-02f, 1.17878944e-01f, -1.65723071e-01f, 5.24324737e-02f, -7.54716918e-02f, 9.11021307e-02f, 8.41786619e-03f,
  -1.17985003e-01f, 3.76730077e-02f, -5.18454462e-02f, 3.01954765e-02f, 1.71768203e-01f, 1.50790989e-01f, -8.59226808e-02f, 1.23653293e-01f, -2.19880491e-01f, -1.81720536e-02f,
  -2.74439510e-02f, -3.99331488e-02f, -3.60380076e-02f, -8.68564937e-03f, -3.65972966e-02f, -9.12030041e-02f, -1.36066124e-01f, -1.53695956e-01f, 1.98954642e-01f, -4.25622351e-02f,
  -2.68312264e-02f, -4.20547724e-02f, -7.60852918e-02f, 2.35510282e-02f, 6.37742952e-02f, -5.85640855e-02f, 1.90857083e-01f, -4.15824167e-02f, 1.60551772e-01f, 3.43532413e-02f,
  1.70692250e-01f, -2.19133049e-02f, 1.86730161e-01f, 4.84841354e-02f, -3.26693118e-01f, -5.83495349e-02f, -9.55703668e-03f, 9.87295136e-02f, 1.13019250e-01f, 1.23079546e-01f,
  -2.62160927e-01f, 2.21044481e-01f, -5.71578704e-02f, 2.34513134e-01f, 1.59821272e-01f, 1.52960103e-02f, 3.49668145e-01f, 1.12980539e-02f, 3.63448918e-01f, 1.17231898e-01f,
  -3.19805384e-01f, -7.74741918e-02f, -1.13434717e-02f, 2.93759465e-01f, 3.58871184e-02f, -1.87741235e-01f, 3.90366800e-02f, 1.83585703e-01f, 1.04154371e-01f, -9.34783220e-02f,
  2.21973047e-01f, -3.91641930e-02f, 1.12248018e-01f, 1.02207392e-01f, -1.71174124e-01f, -1.33497745e-01f, 5.90035170e-02f, 9.73039586e-03f, -2.80471072e-02f, 2.60716617e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  4.53174338e-02f, 1.37347924e-02f, 3.92056443e-02f, 7.35861436e-02f, 1.47911170e-02f, 3.66704278e-02f, 6.96547702e-02f, -1.15396157e-02f, 3.93139124e-02f, 2.05280632e-03f,
  -1.68441236e-02f, 1.34206757e-01f, -7.38846895e-04f, 1.01912595e-01f, 6.38857186e-02f, 4.34173234e-02f, 1.06220514e-01f, -5.59264375e-03f, -3.77218314e-02f, 8.02800879e-02f,
  3.18541266e-02f, 3.11573762e-02f, -5.64613519e-03f, 8.02607983e-02f, 1.06072109e-02f, 1.37436509e-01f, -3.27659622e-02f, 4.42736559e-02f, 9.52749699e-02f, -4.43768613e-02f,
  -2.13183090e-02f, 2.13667825e-02f, 1.07427612e-01f, 3.80166732e-02f, 6.82789087e-02f, 2.90773865e-02f, 9.76259336e-02f, 1.00073516e-01f, -1.49005838e-02f, 5.33081926e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  6.20620847e-02f, 1.20746098e-01f, -1.05237158e-03f, -1.09929852e-01f, -1.92393035e-01f, -2.01346204e-01f, -1.34051830e-01f, 6.90370724e-02f, -1.80192962e-01f, 9.88316089e-02f,
  -9.05758981e-03f, -1.43492416e-01f, -1.59459770e-01f, -8.63917097e-02f, -2.00698480e-01f, -2.16961026e-01f, 1.74598172e-01f, 1.06339335e-01f, -3.02838217e-02f, 2.71679074e-01f,
  7.51815364e-02f, 9.80093852e-02f, -1.63937584e-01f, 7.21467063e-02f, -1.37146100e-01f, 6.47389442e-02f, -5.96492775e-02f, 9.36090201e-02f, -1.66642904e-01f, -3.63264799e-01f,
  -1.41736254e-01f, -1.58973187e-01f, 6.35910779e-02f, -3.97217363e-01f, -1.00098960e-01f, 1.97784826e-01f, 1.14203803e-01f, -5.29170454e-01f, 2.28444889e-01f, 1.56733379e-01f,
  9.41705182e-02f, -3.19393873e-01f, 2.66382657e-02f, -4.01050150e-01f, -6.29557073e-02f, -4.43738610e-01f, -1.24986946e-06f, 2.63136387e-01f, 5.80963828e-02f, 2.49648616e-01f,
  -1.80782434e-02f, -3.01026344e-01f, 6.74096644e-02f, -1.34092364e-02f, -3.89717847e-01f, -1.13064565e-01f, -9.47093591e-02f, -7.46469125e-02f, -1.95919141e-01f, 4.51025553e-02f,
  -2.88188100e-01f, 1.80537492e-01f, 3.26688975e-01f, 1.74040526e-01f, -1.30313545e-01f, -1.12886161e-01f, -5.23313843e-02f, 9.31520462e-02f, 8.62625539e-02f, -1.14907168e-01f,
  -3.34263556e-02f, -1.10006608e-01f, 1.45858511e-01f, -1.53195977e-01f, -3.27503532e-02f, 7.44845271e-02f, -1.59033120e-01f, 1.02160282e-01f, 1.36610389e-01f, -7.45507106e-02f,
  1.81233570e-01f, 2.39126936e-01f, -2.96687596e-02f, 7.35382289e-02f, -4.02045250e-02f, -1.54360801e-01f, -7.20157102e-02f, 2.41508722e-01f, 1.95198119e-01f, -2.89801836e-01f,
  -2.56953835e-01f, 9.50763896e-02f, -2.36322880e-01f, -5.55436730e-01f, -2.64716953e-01f, 2.43116077e-03f, -3.69573027e-01f, -1.37591660e-01f, -2.28162467e-01f, 1.54277354e-01f,
  -5.26303947e-01f, -2.81116575e-01f, -3.20085645e-01f, 1.35644376e-01f, 7.34817833e-02f, -1.59801081e-01f, 2.56019421e-02f, -4.00928527e-01f, 1.95101321e-01f, -1.43712861e-02f,
  -1.93063263e-02f, 1.78385332e-01f, -3.23425114e-01f, 8.10795501e-02f, -1.29831648e-02f, -2.06534117e-01f, -1.13661224e-02f, 1.66411281e-01f, -2.66105294e-01f, -6.25607446e-02f,
  1.12942129e-01f, 2.60914177e-01f, -3.07873935e-01f, 6.39544800e-02f, 1.05131857e-01f, 8.62118229e-02f, -2.35822782e-01f, 8.37481096e-02f, -4.41240706e-02f, -1.90598033e-02f,
  2.76375506e-02f, 3.36434469e-02f, -6.08826391e-02f, -5.23087792e-02f, -1.54761553e-01f, 1.13020875e-01f, 1.92506790e-01f, -2.04285845e-01f, -1.15358852e-01f, 5.41910678e-02f,
  5.82521819e-02f, 4.17066477e-02f, 1.18870035e-01f, -1.38360903e-01f, -1.50376394e-01f, -2.02750012e-01f, 6.21561185e-02f, -3.70247848e-02f, 1.88133255e-01f, 2.51875240e-02f,
  2.07329884e-01f, 6.92999512e-02f, 3.27688903e-02f, -5.77803934e-04f, -2.31793582e-01f, 1.19158356e-02f, -1.79566517e-02f, -3.62424523e-01f, 8.67181644e-03f, -2.58417577e-01f,
  -2.93716520e-01f, 2.59687304e-01f, 1.83086336e-01f, -2.09928453e-01f, 3.51994067e-01f, -1.61061600e-01f, -2.38561407e-01f, 4.84230891e-02f, -2.93385625e-01f, 1.23503439e-01f,
  6.93252729e-03f, -3.19389701e-01f, 1.12968139e-01f, -9.09686685e-02f, -1.10296607e-08f, 1.13517091e-01f, -3.84900123e-01f, -4.01120782e-01f, 3.77715230e-02f, 1.46882609e-01f,
  -4.60591972e-01f, -9.44681987e-02f, 1.36578098e-01f, -3.85778755e-01f, -4.49792296e-02f, 1.76144704e-01f, -4.13302146e-02f, -3.95542592e-01f, 2.77380943e-02f, -8.22414085e-02f,
  -3.44390777e-04f, 2.32363984e-01f, -1.41325399e-01f, -5.30936234e-02f, 3.80198704e-04f, -1.39736414e-01f, -1.09237559e-01f, 4.13586870e-02f, -8.22343603e-02f, -2.71423557e-03f,
  -6.39739856e-02f, -1.15522556e-01f, -5.61572351e-02f, -7.75247142e-02f, 2.50701636e-01f, -1.82564884e-01f, -2.45423019e-01f, -7.10235387e-02f, -2.38607079e-01f, -1.14089467e-01f,
  1.91794038e-01f, -1.17227554e-01f, -3.07068318e-01f, 1.23765819e-01f, 1.21999674e-01f, 1.27266720e-01f, -3.79026651e-01f, -3.47246021e-01f, 3.70942861e-01f, -3.28011602e-01f,
  1.33671403e-01f, 1.52724028e-01f, 1.70964494e-01f, 3.05427667e-02f, 1.75547808e-01f, 6.13904670e-02f, 4.17973399e-02f, -2.53672957e-01f, 3.67128879e-01f, -3.09845209e-01f,
  2.63825506e-01f, -2.23148182e-01f, 1.14967987e-01f, -3.62674087e-01f, 5.11784106e-04f, 2.05930263e-01f, -3.56258333e-01f, -3.36732298e-01f, -1.36469339e-07f, -1.89712625e-02f,
  2.27406070e-01f, 7.63843283e-02f, -4.44571078e-02f, -3.41243446e-01f, -1.05485149e-01f, -2.69954979e-01f, -1.90144598e-01f, 1.78851739e-01f, -5.65828800e-01f, -4.25127447e-01f,
  -1.46243379e-01f, -1.84654236e-01f, 1.72137469e-02f, -2.90700495e-01f, 2.72929400e-01f, -1.17844865e-01f, 1.39810413e-01f, 1.60705656e-01f, 9.27479491e-02f, -9.37131420e-02f,
  2.26662114e-01f, 1.03576586e-01f, 1.23873390e-01f, 1.92662358e-01f, -5.14562167e-02f, -5.85372634e-02f, -1.94657482e-02f, 1.71757460e-01f, 8.26469436e-02f, 1.44712061e-01f,
  -2.74849117e-01f, -3.77591312e-01f, 4.70732227e-02f, -4.33363058e-02f, -5.15508950e-02f, 1.64690912e-02f, 5.10176904e-02f, 1.47190318e-01f, 2.06677392e-01f, 2.40178853e-01f,
  -3.02933246e-01f, -1.21280685e-01f, -7.07789898e-01f, 1.35593683e-01f, 1.85802162e-01f, -9.18403734e-03f, -4.61564846e-02f, -1.82511285e-01f, 1.93398371e-01f, 2.13979259e-01f,
  8.60722885e-02f, -3.71663496e-02f, 5.13001680e-01f, -1.74628705e-01f, 3.19168389e-01f, -1.78229883e-01f, 8.13197419e-02f, -1.25574514e-01f, 3.55968289e-02f, -2.76236329e-02f,
  6.25806451e-02f, 1.73012525e-01f, -3.30992151e-07f, -1.49195306e-02f, 2.21619725e-01f, 3.83685157e-02f, 5.10310289e-03f, 1.34976149e-01f, -2.10535958e-01f, -1.08365022e-01f,
  2.47708872e-01f, -4.97953855e-02f, -1.91787347e-01f, -1.99339222e-02f, -6.07729673e-01f, -9.48124006e-02f, -1.25180990e-01f, -8.41626599e-02f, 3.92918587e-02f, -1.85735062e-01f,
  -1.55535683e-01f, -2.01372087e-01f, 7.82870594e-03f, 1.36666536e-01f, 7.26648793e-03f, 1.50897324e-01f, 6.82567433e-02f, 3.28627914e-01f, -3.72145697e-02f, -2.78597232e-02f,
  -2.55914517e-02f, 1.43602639e-01f, -5.84170073e-02f, 1.00969248e-01f, 1.37505485e-02f, 2.50054240e-01f, 2.42023453e-01f, 1.35512918e-01f, -2.66115785e-01f, -2.48253256e-01f,
  1.08206905e-02f, 1.49807811e-01f, -2.87688076e-01f, -3.83096457e-01f, -1.02820501e-01f, 3.12514871e-01f, -2.43764177e-01f, 1.47943258e-01f, -3.32699358e-01f, 2.39489481e-01f,
  -2.43147373e-01f, -3.09346497e-01f, 2.19422411e-02f, -3.52980524e-01f, -3.49792950e-02f, 1.44669950e-01f, -5.92678487e-01f, 1.00869447e-01f, -1.24459686e-02f, 9.39472765e-02f,
  6.11506850e-02f, -1.65573750e-02f, -5.30010387e-02f, -6.05972819e-02f, -1.00754388e-02f, 1.07558779e-01f, -5.74460893e-04f, -1.36509314e-01f, 8.60877857e-02f, 1.39788881e-01f,
  2.22256798e-02f, 6.02811649e-02f, 2.42848665e-01f, -3.00515801e-01f, -1.24409534e-01f, 7.33249411e-02f, 2.33883902e-01f, -1.08735137e-01f, -5.29725179e-02f, 2.53128439e-01f,
  -2.48862579e-01f, -7.52914399e-02f, -6.85582086e-02f, -4.07355279e-01f, -6.68982491e-02f, -1.88675970e-02f, -1.86156370e-02f, -5.96702062e-02f, 2.33130138e-02f, -1.36522189e-01f,
  8.12883303e-02f, -2.76414394e-01f, -4.08395827e-02f, 1.11165822e-01f, 7.86261633e-02f, -4.70288424e-03f, -1.43316671e-01f, -1.58680394e-01f, 3.15752447e-01f, 2.11312175e-01f,
  2.22137779e-01f, -5.71631119e-02f, -2.07841769e-01f, -1.96484491e-01f, -2.95769274e-01f, -2.59335544e-02f, 1.97849527e-01f, -1.39567241e-01f, 1.22412935e-01f, -4.15091395e-01f,
  -1.91675037e-01f, 9.21307653e-02f, -3.56067538e-01f, 5.23601621e-02f, 2.94602036e-01f, -2.47160226e-01f, -2.65975893e-01f, -2.12004744e-02f, 1.06762812e-01f, -2.68555358e-02f,
  -5.69402575e-01f, 3.39113653e-01f, -4.17778075e-01f, -2.08180636e-01f, -2.59768397e-01f, 1.37707576e-01f, 2.84295492e-02f, -1.55670093e-02f, -1.34725839e-01f, 8.89470428e-03f,
  -4.79245017e-08f, -4.00824517e-01f, -1.52626023e-01f, -2.67440021e-01f, -4.35088724e-02f, 1.88997805e-01f, -1.49647012e-01f, -3.96228194e-01f, 1.31087273e-01f, -4.44092929e-01f,
  1.81827173e-01f, 1.49037629e-01f, 2.01068044e-01f, -1.83039427e-01f, -8.97976980e-02f, 6.11039810e-02f, -1.79530289e-07f, -1.86976433e-01f, -1.32305786e-01f, -1.66570470e-01f,
  -9.60594788e-02f, 8.10604841e-02f, -2.22560707e-02f, 4.65060063e-02f, -3.40473503e-02f, -6.31704330e-02f, -1.77039895e-02f, -1.19491115e-01f, 3.17432173e-02f, -6.40045851e-02f,
  -9.38653648e-02f, -2.07934171e-01f, 7.85143394e-03f, 2.24885672e-01f, 6.06169552e-02f, 2.28531241e-01f, 2.28681415e-01f, 1.30582735e-01f, -4.73993868e-02f, 1.30086346e-02f,
  -1.70623794e-01f, -4.00786549e-02f, -2.39332646e-01f, 1.74900040e-01f, 3.96715760e-01f, -5.40192425e-02f, 1.74818531e-01f, -1.51266688e-02f, -1.58930659e-01f, 3.58745754e-01f,
  1.00856222e-01f, -2.37636924e-01f, -2.26610988e-01f, -3.53342295e-01f, -2.68524606e-02f, 1.41576072e-02f, 5.54019585e-02f, 4.99796048e-02f, -1.75091997e-02f, 6.93078712e-02f,
  2.09941659e-02f, -1.60356581e-01f, -2.24129722e-01f, 6.35651276e-02f, 2.48611514e-02f, -3.25707346e-01f, 1.04160480e-01f, 6.44185254e-03f, -5.13608418e-02f, -1.41935259e-01f,
  -4.76424396e-03f, 2.51116544e-01f, -1.26295462e-02f, 6.67864382e-02f, 6.91810921e-02f, -2.82630771e-01f, -5.77580370e-02f, 1.48849770e-01f, -1.58604775e-02f, 6.97056204e-03f,
  1.79703161e-02f, 1.12810247e-01f, -5.17930277e-02f, -7.43529052e-02f, -1.34391591e-01f, -7.26013780e-02f, 1.69372186e-01f, -1.45795867e-01f, -1.29029766e-01f, 2.73106303e-02f,
  -7.07154721e-02f, -9.50895846e-02f, 3.41851823e-02f, 6.67436868e-02f, 1.74619853e-01f, 1.66551799e-01f, 1.69534996e-01f, 1.63675964e-01f, -1.07476667e-01f, -1.39364406e-01f,
  -1.36051923e-01f, 3.11425388e-01f, 2.35840678e-01f, -1.46268204e-01f, -5.84497228e-02f, -1.32094948e-02f, 1.32657930e-01f, -9.55053195e-02f, 2.10622959e-02f, -3.08438331e-01f,
  2.13654712e-01f, 9.20460820e-02f, 1.00680888e-01f, 8.20294544e-02f, -3.95377964e-01f, -3.03062256e-02f, -3.06670189e-01f, -3.82931441e-01f, -3.14350545e-01f, 1.11449376e-01f,
  -1.15039773e-01f, 1.54961497e-01f, -2.60045499e-01f, -1.25562534e-01f, -1.65240522e-02f, 5.03109470e-02f, 1.90562770e-01f, -2.85567135e-01f, -2.31608357e-02f, -2.84099691e-02f,
  4.99768648e-03f, -2.55909652e-01f, -1.63863841e-02f, -3.16301703e-01f, 9.45972502e-02f, 1.17495224e-01f, 9.70397517e-03f, -7.00488985e-02f, -2.40612686e-01f, 1.08968213e-01f,
  3.13446671e-01f, 9.12771672e-02f, 1.27340049e-01f, -1.06027201e-01f, -8.17371998e-04f, -2.57163286e-01f, 8.96622427e-03f, -1.77753642e-02f, -4.88877557e-02f, -8.71069282e-02f,
  -1.49367869e-01f, -2.52826810e-02f, 2.35994812e-02f, -2.29029611e-01f, -1.04245648e-01f, 5.34119494e-02f, 8.04323032e-02f, -1.30743101e-01f, -1.67570457e-01f, 2.82763630e-01f,
  -4.51134801e-01f, 2.69644052e-01f, 1.16012506e-01f, -2.15176761e-01f, -1.22277796e-01f, 1.22333877e-01f, 9.29162465e-03f, -7.56088346e-02f, 3.24324146e-02f, -2.71060109e-01f,
  -1.21817634e-01f, -2.04299316e-01f, -2.35538676e-01f, 9.37151834e-02f, -1.13496408e-01f, -3.04259688e-01f, -3.59532535e-01f, 1.58064798e-01f, -3.61080140e-01f, -3.40051711e-01f,
  1.65064350e-01f, -1.88111693e-01f, 1.70133948e-01f, -2.41309982e-02f, 1.11651368e-01f, -1.74318254e-01f, 1.56166941e-01f, 1.92873299e-01f, -4.30721231e-02f, -3.01036060e-01f,
  -1.94467098e-01f, 2.18955949e-02f, 2.68531636e-07f, -2.93611139e-01f, 7.29820132e-02f, -4.94043641e-02f, 4.00881618e-02f, 1.63250774e-01f, -2.50296295e-01f, 1.76796019e-01f,
  1.73866674e-01f, -4.55913216e-01f, 1.90926820e-01f, -7.59281367e-02f, 1.99632764e-01f, -3.95860493e-01f, -4.70354915e-01f, 1.53235242e-01f, -2.82711953e-01f, 2.85975128e-01f,
  -2.36592405e-02f, 1.70287058e-01f, -1.55591872e-02f, -1.43706068e-01f, -2.21154362e-01f, 1.16882704e-01f, 2.29205206e-01f, -5.87560935e-03f, 2.09260210e-02f, 3.69352326e-02f,
  7.09561035e-02f, -1.65313110e-01f, 1.18418626e-01f, -2.68219113e-01f, 7.03737214e-02f, -1.59695327e-01f, -1.36730611e-01f, -3.11671291e-02f, 3.15854877e-01f, -1.34732738e-01f,
  1.73202336e-01f, -1.26492262e-01f, -1.36488676e-01f, 3.84782590e-02f, 1.07363120e-01f, -1.58261538e-01f, 5.47068954e-01f, -3.24550867e-01f, 2.09521912e-02f, -1.44584566e-01f,
  2.04718560e-01f, -4.58529145e-01f, 5.29958010e-02f, 2.29678497e-01f, -5.94543805e-03f, 1.47806004e-01f, -1.40283788e-02f, -1.54465929e-01f, -2.39443362e-01f, 1.92753017e-01f,
  -9.97835696e-02f, -2.73379833e-01f, -3.60115618e-02f, -1.64980162e-02f, 4.52487618e-02f, -2.63581663e-01f, -2.95658751e-08f, 7.69952461e-02f, -1.43441141e-01f, 1.63255617e-01f,
  1.27958013e-02f, -1.94550514e-01f, -1.83889104e-04f, -4.18182343e-01f, -3.15586299e-01f, 9.49758757e-03f, -2.46329978e-01f, -1.11185662e-01f, -4.70240325e-01f, -4.32012916e-01f,
  2.76434392e-01f, 2.02440828e-01f, -1.23757243e-01f, 1.31668359e-01f, 1.23367809e-01f, -9.48598534e-02f, 1.24909461e-01f, 1.18373103e-01f, -9.01208818e-02f, -1.90279875e-02f,
  6.35033473e-02f, -7.86602963e-03f, 9.55016166e-02f, -4.30566771e-03f, 7.44573697e-02f, 2.83203032e-02f, 1.42836332e-01f, 7.80709460e-02f, 1.66165352e-01f, 1.49026969e-02f,
  -1.55929476e-01f, -1.45115241e-01f, 2.98353165e-01f, -3.57944556e-02f, -1.25320360e-01f, 1.77041680e-01f, -6.45873770e-02f, -1.63651720e-01f, 3.04046180e-02f, -1.40567571e-01f,
  4.46927808e-02f, 2.68362947e-02f, -6.37298077e-02f, 3.40388298e-01f, 1.14325151e-01f, -4.89840172e-02f, 3.04629467e-02f, 5.33122346e-02f, -1.36628523e-01f, -2.32699051e-01f,
  -3.56377587e-02f, 1.69162244e-01f, -2.82612503e-01f, -3.50824594e-01f, -1.24410816e-01f, 1.78765655e-01f, -1.57421120e-02f, 3.10823083e-01f, -1.69904843e-01f, 2.76604950e-01f,
  -1.14859222e-09f, -3.25442880e-01f, 1.44435361e-01f, -1.87873796e-01f, 2.09638346e-02f, -6.40541092e-02f, 1.29097819e-01f, -3.69729459e-01f, 1.60271689e-01f, 1.58688515e-01f,
  -2.44993731e-01f, -3.66400838e-01f, -1.03442356e-01f, 1.09880734e-02f, 6.63140565e-02f, -3.03974479e-01f, -1.10458128e-01f, -1.97371036e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  5.66748306e-02f, 8.49226192e-02f, -1.39159992e-01f, 4.38736826e-02f, 2.40255166e-02f, -5.03005087e-03f, -9.82905626e-02f, -3.70034017e-02f, 5.98924831e-02f, -8.70453715e-02f,
  1.45676121e-01f, -8.28892291e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    