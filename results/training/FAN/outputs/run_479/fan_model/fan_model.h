/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -9.05391946e-02f, 3.60430814e-02f, 3.21638554e-01f, -4.63147089e-02f, 1.80698007e-01f, 6.21571951e-02f, 1.76334307e-01f, 1.34500042e-01f, 1.41076937e-01f, 2.88528111e-02f,
  2.98643149e-02f, 2.16346011e-02f, -3.67243998e-02f, 1.26088068e-01f, 8.50299075e-02f, -9.32762921e-02f, 2.58037932e-02f, 5.16640767e-02f, 3.31113003e-02f, -8.11573060e-04f,
  8.68329629e-02f, 1.29216723e-02f, 1.79835767e-01f, -2.99766473e-02f, 9.96763334e-02f, -6.81018108e-04f, -1.20330192e-01f, 6.08453192e-02f, 1.83862355e-02f, 2.94687171e-02f,
  -1.87616974e-01f, -1.08462885e-01f, -4.79020737e-02f, -3.40469889e-02f, -5.69139756e-02f, -2.69274190e-02f, 2.73368694e-02f, 1.97431371e-02f, 1.83753632e-02f, 2.17957925e-02f,
  -4.05917019e-02f, 1.06601253e-01f, 6.13252781e-02f, 4.40815613e-02f, -3.27984579e-02f, 6.31496757e-02f, 1.34877056e-01f, 3.07551641e-02f, 8.46645981e-02f, 8.74440819e-02f,
  1.05360791e-01f, 3.60549837e-02f, 1.53422137e-04f, -1.92561485e-02f, 1.46226794e-01f, 4.32106666e-02f, 3.83892581e-02f, -7.13671073e-02f, -4.57413029e-03f, 2.46377569e-02f,
  8.85405461e-04f, -2.55333297e-02f, 2.19421797e-02f, -2.82123722e-02f, 7.85734355e-02f, 3.65022160e-02f, 4.89650927e-02f, 3.63508128e-02f, 8.24166685e-02f, 1.70068070e-02f,
  7.02603310e-02f, -7.88381509e-03f, -1.08369946e-01f, -3.09214331e-02f, 7.93409534e-03f, -6.81240186e-02f, 2.57238727e-02f, 2.43242942e-02f, 2.00846009e-02f, -1.71162821e-02f,
  -1.86807849e-02f, -2.25448366e-02f, 4.55347411e-02f, -5.25841825e-02f, -3.76379453e-02f, -1.27206137e-02f, 3.09177004e-02f, 2.10167803e-02f, -1.12435482e-02f, -6.80167004e-02f,
  -2.82193780e-01f, -1.67104423e-01f, -4.10375372e-03f, 8.04847553e-02f, -2.50007585e-02f, 1.06912302e-02f, -9.90281925e-02f, -2.08970588e-02f, 1.13936942e-02f, 5.48578016e-02f,
  -6.10160157e-02f, -1.62608512e-02f, -9.17245820e-02f, 1.78476125e-02f, -3.86296622e-02f, 4.85872333e-05f, -3.89683396e-02f, -1.34863421e-01f, 5.43806795e-03f, 1.04464225e-01f,
  2.65713427e-02f, 1.44046508e-02f, 6.32185861e-02f, 2.61817016e-02f, -7.85016455e-03f, 3.10855489e-02f, -1.84461642e-02f, 2.33588573e-02f, 4.04089969e-03f, 2.60057230e-03f,
  5.65970182e-01f, 1.82862982e-01f, 1.60539389e-01f, 2.72546470e-01f, -1.12702869e-01f, -3.05185709e-02f, -9.17647183e-02f, 3.90728377e-02f, -9.27252769e-02f, -9.02862251e-02f,
  -1.16537690e-01f, 4.78119776e-02f, -4.33134772e-02f, 2.41234191e-02f, 6.02019019e-02f, -1.37102768e-01f, 1.40720069e-01f, -3.18635139e-03f, 1.25141349e-02f, 7.89209269e-03f,
  5.19963987e-02f, -1.42882876e-02f, 1.35219678e-01f, -2.97440756e-02f, 8.83097872e-02f, 8.78721699e-02f, -2.36681453e-03f, -3.77871841e-02f, 1.27743661e-01f, -1.20389536e-02f,
  -7.13886470e-02f, -9.68714505e-02f, 7.74366334e-02f, 4.32907529e-02f, 1.05460277e-02f, 7.09873512e-02f, 2.47153565e-02f, -2.90757772e-02f, -2.29708571e-02f, -5.75123280e-02f,
  4.77298722e-02f, 6.29467964e-02f, -4.65258248e-02f, -3.13011296e-02f, -1.81769149e-03f, 3.27655151e-02f, 9.11233500e-02f, 5.70148975e-03f, -1.92954242e-02f, 2.89874971e-02f,
  8.03956240e-02f, 2.71820719e-03f, 5.13137020e-02f, 7.68949976e-03f, 1.08120337e-01f, 1.24670763e-03f, -9.09274165e-03f, 5.02239652e-02f, 1.77992340e-02f, -1.14626903e-03f,
  -3.36012952e-02f, -1.68597624e-02f, 5.25749698e-02f, -4.81069423e-02f, 3.75786275e-02f, -1.23553621e-02f, -3.05879791e-03f, -4.36070301e-02f, 2.29448248e-02f, -2.86677871e-02f,
  8.95616412e-03f, -1.85384098e-02f, -3.74546759e-02f, -4.98923436e-02f, -4.79333149e-03f, 3.24115828e-02f, 7.02393288e-03f, -9.69733857e-03f, 8.08226764e-02f, -9.12586041e-03f,
  -2.56934874e-02f, -1.88757386e-02f, 4.07076888e-02f, -3.25727426e-02f, -9.87553149e-02f, 4.20404710e-02f, -1.40423449e-02f, 1.15601078e-01f, -8.23603421e-02f, 9.67627112e-03f,
  -2.64058355e-02f, 2.12731436e-02f, -2.80778669e-02f, 1.01824906e-02f, -6.50975555e-02f, 3.51843052e-02f, -5.14406860e-02f, 7.39807263e-02f, 6.34142314e-04f, -2.98318584e-02f,
  -6.22490309e-02f, -6.99589029e-02f, -1.43982666e-02f, 9.44496039e-03f, -9.75798722e-03f, 3.10733616e-02f, -5.38855530e-02f, 2.31457092e-02f, -4.67457622e-02f, -1.64846461e-02f,
  5.03673665e-02f, -3.00158150e-02f, -6.92191646e-02f, -1.65165658e-03f, 2.66011227e-02f, 3.48643097e-03f, -4.03501429e-02f, 1.31223490e-02f, -1.66126825e-02f, -1.05086742e-02f,
  -3.28380883e-01f, 2.32093528e-01f, 2.45578568e-02f, -5.59136085e-02f, -8.76260847e-02f, -1.12668104e-01f, 1.07956938e-02f, 2.14387011e-02f, -5.61231896e-02f, 2.62444839e-02f,
  -8.60862881e-02f, 5.00980765e-02f, 4.12723683e-02f, -6.53214613e-03f, -2.33479574e-01f, 1.74666345e-01f, -8.28210935e-02f, 1.53360024e-01f, 1.20588139e-01f, -1.47878289e-01f,
  -1.58448331e-02f, -1.71704933e-01f, -1.38513548e-02f, -1.77900150e-01f, -3.78015824e-02f, 9.49198753e-02f, -2.35345110e-01f, 5.00948280e-02f, 1.27691701e-02f, -2.11331118e-02f,
  -9.01801586e-02f, 7.88493305e-02f, -2.27734875e-02f, 9.41881388e-02f, -4.58717998e-03f, 7.22076893e-02f, 1.12832606e-01f, -1.81545932e-02f, 1.12299711e-01f, -1.24404281e-02f,
  1.56702437e-02f, 2.64070113e-03f, 1.65058579e-02f, 2.29642875e-02f, -9.32666436e-02f, 2.58995481e-02f, 8.09108466e-02f, 3.12714465e-02f, 4.95077530e-03f, -5.30179683e-03f,
  -3.07227187e-02f, 3.07563655e-02f, -5.63721731e-02f, 1.17550008e-01f, -2.12480221e-02f, 5.92242321e-03f, 2.67805681e-02f, 5.77616952e-02f, -4.56733890e-02f, 3.86458375e-02f,
  -7.93179348e-02f, 1.78695191e-02f, -7.86604173e-03f, -2.33585332e-02f, -8.23754147e-02f, -2.51280479e-02f, -1.23874471e-01f, -1.85888559e-02f, 6.53350651e-02f, -5.63680306e-02f,
  -2.55747512e-02f, -5.36289364e-02f, -3.26795094e-02f, -2.52129231e-02f, -7.55655393e-02f, -2.17279997e-02f, -1.60466451e-02f, 4.36254814e-02f, 2.22148858e-02f, -1.35192871e-01f,
  -4.32803594e-02f, -3.80732901e-02f, 5.28893620e-02f, -3.22810262e-02f, 3.12255993e-02f, -2.15970930e-02f, -1.06852919e-01f, -7.27998242e-02f, -2.50158329e-02f, -3.04752160e-02f,
  2.10155323e-02f, 5.73673658e-02f, 9.20379385e-02f, 1.02257505e-02f, 3.43130603e-02f, 2.34326087e-02f, 2.73822136e-02f, -3.62027921e-02f, -2.55924165e-02f, 3.79742086e-02f,
  -1.15283336e-02f, 3.54320556e-02f, -3.94172817e-02f, -9.28647220e-02f, -1.23037891e-02f, 2.10549012e-02f, -6.53704926e-02f, 5.55165857e-02f, -1.10781277e-02f, -1.54230446e-02f,
  -6.47135228e-02f, -1.00332029e-01f, 1.23062721e-02f, -5.28317578e-02f, 9.04610306e-02f, -1.03506021e-01f, -1.84853561e-02f, -2.42790505e-02f, 1.99497938e-02f, -5.22964746e-02f,
  -1.60431623e-01f, 3.90114069e-01f, -1.51913673e-01f, 1.84524015e-01f, 4.40167710e-02f, 4.65609953e-02f, 4.45520552e-03f, 1.89087436e-01f, 1.02700442e-01f, 2.08770886e-01f,
  1.10769622e-01f, -1.18349604e-01f, 1.86392635e-01f, 1.60397649e-01f, -9.75155234e-02f, 1.28297403e-01f, 4.07419354e-03f, 1.22885875e-01f, 3.92310172e-02f, 4.54204865e-02f,
  1.57849751e-02f, 1.69702485e-01f, -2.75334460e-03f, 1.04673900e-01f, 3.92445847e-02f, 2.16357615e-02f, -2.45217439e-02f, 7.03123584e-02f, -4.10883464e-02f, 4.26081941e-02f,
  -8.17046314e-02f, 1.13590255e-01f, -4.55787592e-02f, 4.41647694e-02f, -4.02544625e-02f, -3.72593291e-02f, 2.92581320e-02f, -3.42341736e-02f, -9.11291987e-02f, -7.59232650e-03f,
  -6.27663657e-02f, -4.16619852e-02f, 2.10890211e-02f, -1.21206986e-02f, 7.77827129e-02f, -9.01270360e-02f, -6.04878478e-02f, 1.18672801e-02f, 7.61701912e-02f, -3.69940549e-02f,
  5.55105321e-02f, -1.72939077e-02f, -3.34961303e-02f, 1.03330724e-02f, -9.97454743e-04f, 3.85692492e-02f, -7.58118974e-03f, -3.85720022e-02f, -3.50347497e-02f, -2.28343103e-02f,
  1.44970324e-03f, 2.83727888e-02f, 1.67368036e-02f, -8.49526897e-02f, 9.27622840e-02f, -1.46366202e-03f, 4.11640853e-02f, 1.33295367e-02f, -7.53453821e-02f, 8.28703027e-03f,
  -2.91169621e-02f, 5.80684468e-03f, 6.65692165e-02f, -4.21852507e-02f, 1.38816582e-02f, 3.31430249e-02f, 2.34634634e-02f, 6.53302446e-02f, 1.45427920e-02f, -1.62144527e-02f,
  1.91611312e-02f, 5.31032719e-02f, 9.13014170e-03f, -1.92485061e-02f, 2.00684536e-02f, 4.57323249e-03f, -1.23315537e-02f, 1.02927096e-01f, -3.72172222e-02f, -5.75895747e-03f,
  1.32780850e-01f, 2.76115388e-01f, 2.80725956e-03f, -2.73653958e-02f, 4.34682965e-02f, -7.77680874e-02f, -6.98086098e-02f, 7.13360356e-03f, 5.48878051e-02f, 4.57647964e-02f,
  -3.93392220e-02f, 2.75348756e-03f, -4.10210863e-02f, 2.94241533e-02f, -4.35583480e-02f, 7.29455566e-03f, 6.30733147e-02f, 3.92729864e-02f, -1.01515204e-02f, 2.74498556e-02f,
  8.07720888e-03f, 4.59761731e-03f, 3.17323883e-03f, 3.14115360e-02f, 3.24024670e-02f, -8.09580237e-02f, 4.41880636e-02f, 4.59541082e-02f, 2.51703039e-02f, -2.68771313e-03f,
  4.48682643e-02f, -1.35841817e-01f, -1.02124378e-01f, -4.84450795e-02f, 1.11094480e-02f, 2.29140133e-01f, 3.24281275e-01f, -4.90676761e-02f, 9.78805050e-02f, -1.00082211e-01f,
  -2.72691771e-02f, -2.47821450e-01f, -5.79514466e-02f, -1.60313640e-02f, 2.39391625e-01f, 1.11467995e-01f, 1.28693685e-01f, -3.09366230e-02f, 8.53271484e-02f, -9.61240008e-02f,
  1.02471776e-01f, 7.85162300e-02f, 8.25069249e-02f, -1.20872378e-01f, 2.74105892e-02f, -2.22650431e-02f, -5.46916313e-02f, -8.40653405e-02f, -1.36064023e-01f, -8.20700154e-02f,
  2.62606114e-01f, -5.06973229e-02f, -1.29505992e-01f, -1.18373372e-02f, -5.73064247e-03f, -4.56895158e-02f, 6.34949561e-03f, 9.25138034e-03f, 2.01144330e-02f, 1.60922408e-02f,
  -7.57590160e-02f, -6.87325969e-02f, -6.08246885e-02f, -3.01812254e-02f, 1.41703831e-02f, -6.01599701e-02f, -3.94697152e-02f, 6.36833161e-02f, -1.66299473e-02f, 1.14675444e-02f,
  -2.54634060e-02f, 3.77103835e-02f, 2.02043056e-02f, 6.79071993e-02f, -6.91419542e-02f, -4.69408883e-03f, 7.34880939e-02f, -4.01920229e-02f, -8.22318569e-02f, -4.49086726e-02f,
  -5.50945252e-02f, -1.80051476e-02f, 7.92159140e-03f, -3.66088599e-02f, -4.12007719e-02f, -5.22805704e-03f, 2.02975050e-02f, 4.35719937e-02f, 8.08670744e-03f, 3.55305932e-02f,
  1.17952004e-03f, -6.31707115e-03f, -2.19857451e-02f, -3.66990678e-02f, 6.39194343e-03f, 3.73558998e-02f, 5.37907099e-03f, -2.78931279e-02f, 1.09229967e-01f, -9.47168283e-03f,
  -2.59361602e-03f, -5.82995228e-02f, -6.16168156e-02f, 6.24163225e-02f, 2.13866383e-02f, -1.30044846e-02f, -7.16475099e-02f, -2.73222066e-02f, 3.87192634e-03f, -3.43598947e-02f,
  -1.02774851e-01f, -1.66583374e-01f, -5.51712923e-02f, -2.67916322e-02f, -2.00898368e-02f, -2.51133717e-03f, 3.59010622e-02f, -6.94787130e-02f, -3.24853919e-02f, -2.02662516e-02f,
  3.82857174e-02f, -1.99216735e-02f, 1.84620712e-02f, -8.50680564e-03f, -7.17999563e-02f, 2.26681754e-02f, -1.03013525e-02f, -1.28957704e-02f, -1.46627249e-02f, -5.54157645e-02f,
  2.89789680e-02f, -3.32106873e-02f, 2.79197507e-02f, -2.46701222e-02f, 2.96987817e-02f, -1.23153999e-02f, -1.47097241e-02f, 5.95163777e-02f, -2.54810862e-02f, -3.39089781e-02f,
  -3.01763624e-01f, 1.71604618e-01f, 2.65160233e-01f, -6.27365410e-02f, -2.98582524e-01f, -1.57453522e-01f, -1.97662674e-02f, -1.35612443e-01f, 6.87028393e-02f, -3.95423034e-03f,
  -1.27110004e-01f, 1.68276608e-01f, 1.24208450e-01f, -1.78500846e-01f, 3.85274179e-02f, 1.72535837e-01f, -1.77515820e-01f, -4.91139814e-02f, 1.70663781e-02f, -1.63558200e-01f,
  2.45695282e-02f, -3.18416178e-01f, 1.48813948e-01f, -8.54663774e-02f, -1.97013468e-01f, 3.66941094e-02f, -7.04156086e-02f, 1.20291814e-01f, -1.70936987e-01f, -3.63493082e-03f,
  -1.50751397e-01f, -8.49781334e-02f, 2.09530462e-02f, 5.20049185e-02f, -6.43896908e-02f, 2.63809739e-03f, 8.88764560e-02f, 5.84349632e-02f, -5.02543077e-02f, -2.99323238e-02f,
  -4.49371012e-03f, -4.33546342e-02f, -5.17260656e-02f, -1.60073340e-02f, 1.94497034e-02f, -6.32525748e-03f, -4.81789820e-02f, -2.68423352e-02f, 5.17121591e-02f, 2.32307576e-02f,
  6.38678819e-02f, 6.05172701e-02f, 1.24021722e-02f, 2.70796027e-02f, 5.68199344e-02f, 7.21207820e-03f, 1.85101777e-02f, 7.71531835e-02f, -3.83754149e-02f, -3.14446576e-02f,
  -8.35397281e-03f, 5.74144311e-02f, 5.60976304e-02f, -6.58611581e-02f, 1.06233284e-02f, -1.89802591e-02f, -2.01130453e-02f, 8.15435406e-03f, 2.03235243e-02f, 2.26008706e-02f,
  -2.85522286e-02f, -1.94016192e-02f, 2.14970894e-02f, -4.90308506e-03f, 2.13618316e-02f, -1.09783961e-02f, 4.83777374e-02f, -4.73945253e-02f, -1.44198518e-02f, 3.20760198e-02f,
  2.71366946e-02f, 2.99496911e-02f, -1.32288774e-02f, -1.36148371e-02f, 5.76457661e-03f, 5.01760021e-02f, 2.71116383e-02f, 6.78161010e-02f, -4.49166298e-02f, 2.22690143e-02f,
  -2.84700114e-02f, 2.53171455e-02f, 9.70076490e-03f, -6.33946881e-02f, 6.80672377e-02f, -3.40469508e-03f, -2.31410488e-02f, 3.36250365e-02f, 1.13727627e-02f, 5.22463433e-02f,
  2.30477657e-02f, 1.19319819e-02f, 3.04695293e-02f, -1.19220726e-02f, 1.09341405e-02f, 1.49813788e-02f, -7.81461503e-03f, -1.28636695e-02f, -8.80280361e-02f, 3.99236521e-03f,
  -8.27562511e-02f, -5.92115335e-02f, -1.70036368e-02f, -4.12646160e-02f, -1.15482301e-01f, -5.19210054e-03f, -3.13539393e-02f, 3.42028476e-02f, 4.28347662e-02f, -2.24607419e-02f,
  1.50210429e-02f, 2.85571009e-01f, 8.94680172e-02f, 3.04595619e-01f, 6.58941641e-02f, 1.02779023e-01f, 1.64099485e-01f, 3.73545848e-02f, 3.24236900e-01f, 2.27178782e-02f,
  -5.38057201e-02f, 2.70054638e-01f, 8.22799206e-02f, 2.34536812e-01f, -1.51080146e-01f, 7.74455890e-02f, -1.41891494e-01f, 2.73134671e-02f, 2.47998498e-02f, -1.58907678e-02f,
  -1.19786069e-01f, -6.77537452e-03f, 1.57271717e-02f, -1.03875741e-01f, 8.47426504e-02f, 8.17693584e-03f, -2.38051429e-01f, -4.43113446e-02f, -1.39467359e-01f, -1.14621840e-01f,
  -4.56072167e-02f, 1.58999145e-01f, 7.90527090e-02f, 3.39054540e-02f, 1.88133847e-02f, -3.20549123e-02f, -5.06253466e-02f, -3.42136733e-02f, 6.75595254e-02f, 2.30479054e-02f,
  9.45250541e-02f, -1.31791411e-02f, 4.67873551e-02f, 2.31168326e-03f, 1.21312648e-01f, -1.09389927e-02f, 7.05736056e-02f, -7.73043325e-03f, 1.56083420e-01f, 1.90808773e-02f,
  4.24816348e-02f, -3.17121819e-02f, -1.96500272e-02f, -8.08978677e-02f, 3.09600029e-04f, -2.01312583e-02f, 7.90773705e-02f, -2.97743846e-02f, -1.61939990e-02f, 5.16835526e-02f,
  -6.52244464e-02f, -3.62758003e-02f, -6.12223782e-02f, 3.34431627e-03f, 7.31185079e-02f, -4.73859087e-02f, -2.39534723e-03f, -5.59714958e-02f, -1.17431777e-02f, 2.19204109e-02f,
  -1.49720367e-02f, 8.81668851e-02f, -3.30276112e-03f, 6.21989705e-02f, -1.97024886e-02f, 4.28921841e-02f, 5.57170771e-02f, -1.03613241e-02f, 8.54091793e-02f, 3.32254730e-02f,
  2.03090198e-02f, -5.62101677e-02f, 3.57272401e-02f, 1.52066778e-02f, -2.83841696e-02f, 1.27949764e-03f, -1.85492486e-02f, 4.78467010e-02f, 2.00401657e-04f, -7.10795671e-02f,
  1.99544132e-02f, 8.47625639e-03f, 6.24917671e-02f, 1.81412809e-02f, 1.91716813e-02f, -7.74800703e-02f, 1.39960237e-02f, -3.73030305e-02f, -6.85930103e-02f, -2.20896918e-02f,
  -7.91780427e-02f, 6.08270541e-02f, -9.34351385e-02f, -4.21705917e-02f, -3.91951203e-02f, 1.96492895e-02f, -4.54955176e-02f, -3.52493078e-02f, -1.31747544e-01f, -1.27426153e-02f,
  -3.08748763e-02f, -5.21421526e-03f, -3.09286602e-02f, 1.60163399e-02f, -5.90918511e-02f, 3.54818325e-03f, -3.88567299e-02f, 1.09200105e-02f, -4.87928875e-02f, 2.98453420e-02f,
  -8.27265158e-02f, 1.25255674e-01f, -3.21267843e-02f, 3.20843577e-01f, -6.11074045e-02f, -1.00222915e-01f, 9.62477773e-02f, 1.82575304e-02f, 8.31979960e-02f, 8.40681493e-02f,
  -7.98752457e-02f, -7.96648040e-02f, -1.05761938e-01f, 7.10727423e-02f, -2.72510380e-01f, -3.86359021e-02f, 6.07333407e-02f, -4.39990535e-02f, 7.07070976e-02f, 1.83142219e-02f,
  7.63596967e-02f, -1.28316386e-02f, -1.59039050e-01f, 1.27744392e-01f, -5.05022332e-02f, 9.58635285e-02f, -6.80014268e-02f, -4.78140451e-03f, -1.78488288e-02f, 2.80722673e-03f,
  -1.87930465e-01f, -1.39742845e-03f, -6.10010959e-02f, -2.33474318e-02f, -7.79270828e-02f, -5.86677156e-02f, -9.37366206e-03f, -3.12456638e-02f, -4.27661501e-02f, -2.65458040e-03f,
  -6.32151365e-02f, 4.48490232e-02f, 5.20289168e-02f, 3.01270150e-02f, 7.88113400e-02f, 2.13873070e-02f, -6.15748689e-02f, -3.06925587e-02f, 2.83127325e-03f, -1.57417171e-02f,
  -7.63505995e-02f, -5.44731654e-02f, -6.59335731e-03f, 7.43806735e-02f, 1.53386248e-02f, 1.50649827e-02f, 5.91037646e-02f, 2.17805132e-02f, -2.61569349e-03f, 1.97578464e-02f,
  1.25779524e-01f, -4.80100177e-02f, 6.17882004e-03f, 4.54407223e-02f, -1.85483824e-02f, -2.89017502e-02f, -3.07214204e-02f, 3.95173430e-02f, 3.75105999e-02f, -4.98897443e-03f,
  7.49555752e-02f, 1.04510179e-02f, 7.40225762e-02f, 7.72125795e-02f, 1.23271141e-02f, 1.53417781e-01f, -4.43159342e-02f, -7.48625547e-02f, 1.60256810e-02f, 1.79854967e-02f,
  4.24805954e-02f, 2.28223410e-02f, 8.62961113e-02f, 5.82290366e-02f, -5.15924916e-02f, -5.77937532e-03f, 3.15875225e-02f, -5.03108790e-03f, -1.20852366e-01f, -7.08625317e-02f,
  1.73145816e-01f, 1.68700948e-01f, -1.34104397e-02f, -5.83482906e-02f, -1.53068125e-01f, -3.27468514e-02f, -8.16767514e-02f, 2.25991383e-02f, 1.92846935e-02f, -6.62930235e-02f,
  -5.17975241e-02f, -3.01138274e-02f, 1.93021782e-02f, 9.89822671e-02f, 2.41588000e-02f, 3.91080454e-02f, 3.36160511e-03f, 1.28173400e-02f, -9.36417095e-03f, -9.30913985e-02f,
  9.17953402e-02f, 6.15415759e-02f, 4.12888564e-02f, 2.37688329e-02f, -9.64686554e-03f, 7.66825443e-03f, 3.68449986e-02f, 3.16694640e-02f, -5.22002541e-02f, -7.50713050e-02f,
  5.07767439e-01f, 2.64792085e-01f, 2.49318257e-01f, 1.97359934e-01f, 1.16089679e-01f, 1.10214546e-01f, -5.64966388e-02f, 2.56257355e-01f, 3.64504755e-01f, -9.88533497e-02f,
  -1.81297049e-01f, 1.16070539e-01f, -1.58916548e-01f, 1.05189033e-01f, -4.94779684e-02f, -3.53825204e-02f, 1.64325848e-01f, 6.55741543e-02f, 1.69504330e-01f, 1.15392640e-01f,
  1.64986625e-01f, -1.66665480e-01f, -1.14992447e-01f, -4.19430546e-02f, 1.04118951e-01f, 9.11282450e-02f, -2.65228242e-01f, -3.30577828e-02f, -1.40306324e-01f, -6.51091039e-02f,
  -6.30959421e-02f, -5.48742386e-03f, 2.13244669e-02f, 3.74973007e-02f, 3.08361407e-02f, -3.84373628e-02f, -1.11246230e-02f, -7.61080831e-02f, -1.56017039e-02f, 4.12362404e-02f,
  -6.83491081e-02f, -1.16406381e-02f, 1.98514014e-02f, -1.40904970e-02f, 6.71663284e-02f, 4.14776988e-02f, -1.86843071e-02f, 9.53692943e-02f, -1.72264297e-02f, 5.53340046e-03f,
  1.42135266e-02f, -5.25846221e-02f, 4.66432497e-02f, 2.83901189e-02f, -1.46743786e-02f, 1.65812746e-02f, -3.42577621e-02f, -5.49643813e-03f, -4.29135078e-04f, 3.11046671e-02f,
  1.45137412e-02f, 4.14712802e-02f, -5.62194027e-02f, 2.35300530e-02f, -2.80784592e-02f, 2.80438513e-02f, 1.15892300e-02f, -6.89409152e-02f, 8.27006027e-02f, -2.76865624e-02f,
  -3.43646691e-03f, 2.91009396e-02f, 2.47540176e-02f, -1.19924089e-02f, 2.41038408e-02f, -6.15722835e-02f, -5.63373677e-02f, 7.98413157e-03f, 4.17700447e-02f, -3.83789241e-02f,
  -6.80610957e-03f, 1.12125417e-02f, -2.39221007e-02f, -5.54667376e-02f, 1.45584475e-02f, -4.45122682e-02f, 3.67078893e-02f, 9.10341926e-03f, 5.67108579e-02f, -4.95772623e-02f,
  4.82168347e-02f, 7.26540759e-02f, -5.69418771e-03f, -7.59026781e-02f, -3.02111711e-02f, -2.78736521e-02f, 1.39160920e-02f, 3.13348807e-02f, 6.35794625e-02f, -5.67615731e-03f,
  1.10580716e-02f, -5.09539954e-02f, -3.24429269e-03f, -1.07140997e-02f, -3.72030996e-02f, -2.41922364e-02f, -5.48083801e-03f, -1.54029252e-02f, -6.92813005e-03f, -6.42732158e-02f,
  -5.93441501e-02f, 3.04817911e-02f, 5.60344122e-02f, 8.79848562e-03f, 6.05300860e-03f, -7.41480887e-02f, 1.10120542e-01f, 1.97122283e-02f, -3.87840346e-02f, 2.01893188e-02f,
  -3.26892823e-01f, 1.94842711e-01f, -2.82034546e-01f, -3.00908033e-02f, -2.36549944e-01f, -9.58169252e-02f, -1.43678784e-01f, -5.15695103e-02f, -2.15427101e-01f, 1.61012918e-01f,
  1.01764798e-01f, -3.34013142e-02f, 7.64985904e-02f, 2.40499213e-01f, -1.96760997e-01f, 1.57650903e-01f, 5.32646477e-02f, 3.04365600e-03f, 2.13811863e-02f, 4.68712896e-02f,
  -4.99049239e-02f, 1.65829927e-01f, -2.44792420e-02f, 7.06241801e-02f, 1.44290207e-02f, -3.99012417e-02f, 5.30336052e-02f, -8.65854993e-02f, 1.35677263e-01f, -1.27664581e-01f,
  -6.96568564e-02f, -2.58776039e-01f, 4.43616994e-02f, -6.43705875e-02f, -1.04458474e-01f, -1.21262379e-01f, 4.80664186e-02f, 8.70353170e-03f, 2.08854657e-02f, -7.47218281e-02f,
  9.59376320e-02f, -3.81775536e-02f, -2.07892004e-02f, 1.07191270e-02f, -1.04264937e-01f, -1.11792544e-02f, 6.37201071e-02f, 7.03041209e-03f, 6.77696690e-02f, -2.00855192e-02f,
  3.38778533e-02f, -4.02633734e-02f, 8.58218372e-02f, 3.31822187e-02f, -4.73343506e-02f, 2.88626198e-02f, 6.46036351e-03f, -7.36168399e-02f, -1.35929352e-02f, -1.07388236e-01f,
  -4.09109965e-02f, -8.58602766e-03f, -1.49665270e-02f, 1.41301677e-02f, 2.95632076e-03f, 1.15786586e-03f, 7.27050379e-02f, 2.92550586e-02f, 4.02923860e-02f, 8.94863829e-02f,
  2.24014428e-02f, -3.04632448e-02f, -8.26322958e-02f, -2.43166112e-03f, 3.19735669e-02f, -2.21527740e-02f, 2.52012629e-02f, 3.17833573e-02f, 1.48709947e-02f, -7.06079677e-02f,
  -2.41404064e-02f, -1.62676442e-02f, -6.95187896e-02f, -4.25985940e-02f, -2.75197402e-02f, -7.22276652e-03f, 6.27457127e-02f, 6.30071834e-02f, 1.62708890e-02f, -3.93297449e-02f,
  -9.64198858e-02f, -2.21873969e-01f, -2.70096119e-02f, -1.89834815e-02f, -2.15466917e-02f, 3.73927765e-02f, -7.39270970e-02f, 4.94767949e-02f, -2.25745346e-02f, -2.11749580e-02f,
  -1.30641693e-03f, 2.02908143e-02f, -4.87563424e-02f, 1.19270198e-02f, 5.61130457e-02f, 1.04411170e-01f, -9.98451933e-03f, -1.13180708e-02f, -9.61353108e-02f, 6.29560184e-03f,
  2.40806974e-02f, -1.16302930e-02f, 4.46848758e-02f, 1.57357156e-02f, 3.48222479e-02f, 5.03963865e-02f, -3.99305932e-02f, 4.02363017e-02f, -5.41524179e-02f, 3.33363861e-02f,
  -2.00702786e-01f, -1.19058773e-01f, 4.05593030e-02f, -3.16327900e-01f, 2.23410368e-01f, -1.80139259e-01f, -1.41226083e-01f, 3.65292132e-02f, -1.06752198e-03f, -1.45312965e-01f,
  -9.12982896e-02f, 7.92074949e-02f, -1.05522558e-01f, -2.55316913e-01f, -3.07190686e-01f, -2.01695889e-01f, -3.23534966e-01f, -9.87676755e-02f, -2.90804617e-02f, -8.88437629e-02f,
  1.52040843e-03f, -1.62902400e-01f, -1.07151665e-01f, 1.14308409e-01f, 1.26416862e-01f, 1.36268020e-01f, -1.04207337e-01f, 1.00115724e-01f, -2.04894356e-02f, -3.81653085e-02f,
  -2.17410065e-02f, -1.48589924e-01f, 6.06672093e-02f, 8.82638693e-02f, -4.59394231e-02f, 2.48952080e-02f, 3.77588980e-02f, 2.50686035e-02f, 1.52074918e-02f, -7.50075802e-02f,
  -2.74693966e-03f, -6.76031932e-02f, -6.54911995e-02f, 6.69382662e-02f, 1.13070846e-01f, -3.85852940e-02f, 4.87467684e-02f, 9.05839652e-02f, 6.27944693e-02f, 7.57999942e-02f,
  1.53788971e-02f, 4.01228704e-02f, 7.17605948e-02f, -4.71750461e-02f, 7.78209418e-02f, -5.79178371e-02f, -3.28840502e-02f, -3.97414202e-03f, 2.69701015e-02f, -3.54079418e-02f,
  -4.33323048e-02f, -1.18590454e-02f, 7.01281987e-03f, -1.26365460e-02f, 4.95793074e-02f, 1.78356690e-03f, 3.15692127e-02f, -1.29710436e-02f, 2.63122423e-03f, 1.29215280e-03f,
  -1.53879747e-02f, 5.68433329e-02f, 1.97635479e-02f, 2.31805164e-02f, -4.21543531e-02f, -1.82619542e-02f, 3.02494373e-02f, -1.70033947e-02f, 4.21579753e-04f, 3.28719392e-02f,
  -2.60671452e-02f, -5.96558861e-03f, 3.02600954e-03f, 3.48917162e-03f, -5.06254435e-02f, 2.99566053e-02f, 1.20238559e-02f, 1.61912087e-02f, 3.10663525e-02f, 2.66256910e-02f,
  -1.08712412e-01f, -2.89818555e-01f, -6.75190315e-02f, -3.56669426e-02f, -1.04742022e-02f, -6.26364630e-03f, -7.20311478e-02f, -1.20975601e-03f, -8.60862136e-02f, -1.49016771e-02f,
  1.06374726e-01f, 5.66518195e-02f, -2.66165175e-02f, 1.20932404e-02f, -6.15873598e-02f, -6.29436448e-02f, -1.19338661e-01f, -2.87047923e-02f, -1.27676710e-01f, 6.91707130e-04f,
  3.29342894e-02f, -1.16872424e-02f, -1.55361183e-02f, -1.92572027e-02f, 1.53716458e-02f, -1.74967516e-02f, 7.48457154e-03f, 2.43097153e-02f, 1.75014157e-02f, -4.00052518e-02f,
  5.04016578e-01f, 2.57923484e-01f, -2.75694355e-02f, 1.69565871e-01f, -1.11610092e-01f, 5.86618595e-02f, 1.34526625e-01f, 2.95334682e-02f, 2.44238511e-01f, 8.95571560e-02f,
  -6.09257221e-02f, 1.06062375e-01f, -1.11189246e-01f, 7.73252547e-02f, 1.55664131e-01f, 2.86479834e-02f, 3.15504551e-01f, 9.37648937e-02f, 3.93321924e-02f, 1.65512413e-02f,
  -5.71898790e-03f, -6.12263866e-02f, -3.83236678e-03f, -1.42731383e-01f, 5.49707562e-02f, -5.63118309e-02f, -1.91864386e-01f, -1.26002699e-01f, 6.91700503e-02f, 5.46089001e-02f,
  1.15323208e-01f, 8.87653679e-02f, -7.27318525e-02f, 2.57062856e-02f, -7.73568312e-03f, -1.19867548e-02f, -2.61930227e-02f, -3.24395597e-02f, -3.04624420e-02f, 8.82043969e-03f,
  4.85949125e-03f, -9.01845023e-02f, 8.87714047e-03f, 1.14783868e-02f, -4.05053385e-02f, -2.17582658e-02f, -2.58497093e-02f, 4.47583497e-02f, 9.58411116e-03f, -4.31872047e-02f,
  3.28795686e-02f, 1.95014570e-02f, -9.22639016e-03f, -3.44412141e-02f, 2.63311267e-02f, 2.90266369e-02f, -4.23414931e-02f, -5.40668182e-02f, 5.70149422e-02f, 7.50311911e-02f,
  -6.71614558e-02f, 3.74020562e-02f, -3.95010710e-02f, 3.88263315e-02f, 5.16657643e-02f, -7.87134543e-02f, -1.10794837e-02f, 3.00479922e-02f, -2.95960018e-03f, -3.67989615e-02f,
  8.72350112e-02f, 1.67212393e-02f, 1.61474608e-02f, 3.95646021e-02f, 1.86022166e-02f, 3.37498784e-02f, 2.85499338e-02f, -2.68130489e-02f, -1.30995950e-02f, -4.18544151e-02f,
  3.73187438e-02f, 4.98293303e-02f, 1.83125380e-02f, -1.54273808e-02f, 3.41163464e-02f, -7.57599249e-02f, 2.56868899e-02f, -1.46479448e-02f, -2.88956147e-02f, -2.80050505e-02f,
  2.62140095e-01f, 9.17792395e-02f, 2.53675357e-02f, 8.85406975e-03f, -3.82036380e-02f, -1.19816968e-02f, 3.91548835e-02f, -1.78152416e-02f, -3.84502411e-02f, 3.61917429e-02f,
  2.84000449e-02f, 1.04146831e-01f, 2.84809060e-02f, 1.64549742e-02f, 3.78725678e-02f, -2.39986852e-02f, -1.79210175e-02f, 4.95142043e-02f, 5.86607009e-02f, 4.60870154e-02f,
  -3.66037488e-02f, -5.24182841e-02f, -1.60804635e-03f, -7.51705980e-03f, -1.18329087e-02f, -4.94954437e-02f, 2.16748994e-02f, 2.62781885e-02f, -2.24520992e-02f, -2.48201955e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.59906173e-01f, 1.75933704e-01f, -3.14431816e-01f, 5.71605377e-02f, 8.36668983e-02f, 3.08911204e-01f, 2.20317587e-01f, 1.07186034e-01f, -6.68701828e-02f, 2.53923774e-01f,
  1.39822096e-01f, -1.53481802e-02f, 1.25383167e-02f, 2.17212290e-01f, 1.04117006e-01f, 1.00122064e-01f, 2.28649542e-01f, 2.07454637e-01f, 7.26661086e-03f, 6.18123524e-02f,
  2.27627270e-02f, 3.65717292e-01f, -1.95821211e-01f, 1.96544096e-01f, 6.87825903e-02f, -1.39164895e-01f, -1.54990256e-01f, -1.74241930e-01f, -6.19192608e-02f, -3.56419981e-02f,
  3.13439332e-02f, 1.33930072e-02f, 2.07691509e-02f, -3.91079187e-02f, 1.03600398e-01f, 1.57126591e-01f, 1.70208588e-02f, -6.52730614e-02f, -1.31137550e-01f, -5.12536578e-02f,
  -1.02394791e-02f, -4.53550033e-02f, -1.04883080e-02f, -4.43218611e-02f, -1.03569336e-01f, -4.30554263e-02f, -1.01491325e-01f, 3.99346538e-02f, -3.45248766e-02f, 7.97746703e-02f,
  -1.22611254e-01f, -3.65125306e-04f, 1.46033401e-02f, 4.73972186e-02f, -6.70375675e-02f, -8.46776664e-02f, -6.79118857e-02f, 6.79320656e-03f, -4.65598772e-04f, 5.66498376e-02f,
  8.51642042e-02f, 1.79836694e-02f, -4.26350674e-03f, -2.38784365e-02f, 8.27828348e-02f, -3.79436724e-02f, 1.46891950e-02f, 1.90884322e-02f, 2.09160661e-03f, 1.10059477e-01f,
  2.35889689e-03f, -8.99221003e-02f, 1.16836280e-02f, 1.07460208e-02f, 1.43732846e-01f, 3.90462205e-02f, 4.60791364e-02f, 4.30655852e-02f, -5.45536540e-03f, -1.61634922e-01f,
  -1.86218414e-02f, 1.70990434e-02f, 4.76716794e-02f, -1.75421555e-02f, -2.64563579e-02f, 5.98487519e-02f, 1.41730189e-01f, -9.06511769e-03f, -4.77329381e-02f, 7.12654367e-02f,
  1.30145609e-01f, 4.19996940e-02f, 1.57760270e-02f, -1.37836598e-02f, -7.83736780e-02f, 1.57099143e-01f, 7.35585541e-02f, 7.98970163e-02f, -6.24447539e-02f, 1.36366487e-01f,
  7.07240775e-02f, -1.17982710e-02f, 5.44299483e-02f, -1.52271641e-02f, -9.66400132e-02f, 7.15749562e-02f, -8.12954679e-02f, -4.41950820e-02f, -9.13143903e-02f, 6.95963800e-02f,
  1.89085919e-02f, -5.85016832e-02f, -6.93670958e-02f, -4.67312708e-02f, 1.00802546e-02f, -4.00650948e-02f, 2.11371109e-02f, -5.99466898e-02f, 4.89210524e-02f, -4.78336923e-02f,
  -1.62391365e-01f, -6.73452541e-02f, -2.96005011e-01f, -7.04240948e-02f, 7.09497230e-03f, -3.99970442e-01f, -3.93316716e-01f, 1.81637239e-02f, 4.78451401e-02f, 1.23675138e-01f,
  -7.33747631e-02f, 5.03616855e-02f, 9.95609611e-02f, -4.44545478e-01f, -1.56662405e-01f, -1.32216513e-01f, -4.21492726e-01f, -1.48401514e-01f, -2.24558003e-02f, -1.28979743e-01f,
  -2.18075085e-02f, -7.39657804e-02f, -2.60239780e-01f, 1.62631460e-02f, -1.38414994e-01f, 3.14220823e-02f, 2.74214625e-01f, 7.28378743e-02f, -5.12572229e-02f, -9.32894349e-02f,
  -1.24531724e-01f, 5.41015267e-02f, -1.92020517e-02f, -1.80084631e-03f, -2.39520613e-02f, -3.93765010e-02f, 2.56908089e-02f, -4.37192433e-02f, -7.07465596e-03f, -4.15402725e-02f,
  9.51076150e-02f, 6.78848103e-02f, -7.77382255e-02f, -2.42312737e-02f, -8.12330171e-02f, -2.76283026e-02f, -1.21470075e-02f, -2.36575808e-02f, -8.26410353e-02f, -8.92484561e-02f,
  -1.12558201e-01f, 3.22939567e-02f, 5.00110500e-02f, 8.90143029e-03f, -1.04497308e-02f, -9.62416753e-02f, -2.99238507e-02f, -2.45533721e-03f, -4.62965220e-02f, 3.45001183e-02f,
  -5.51917106e-02f, -9.97822208e-05f, 7.83964712e-03f, -1.05706416e-02f, -2.93290056e-02f, -5.85177019e-02f, -3.44158412e-04f, -3.69463935e-02f, -1.65830217e-02f, -2.16802098e-02f,
  2.59093549e-02f, -4.43228744e-02f, -5.34572788e-02f, -4.21785824e-02f, -5.01964763e-02f, -7.88169429e-02f, 2.60099787e-02f, 6.46397546e-02f, -4.65382077e-02f, -4.63319160e-02f,
  3.10146287e-02f, -5.51482886e-02f, 3.09437178e-02f, -4.06652838e-02f, -7.22708479e-02f, 6.01336509e-02f, 5.74340820e-02f, 1.05187111e-02f, 4.14156029e-03f, 2.06015054e-02f,
  2.49163006e-02f, 2.85310417e-01f, 9.12736636e-03f, -2.90179942e-02f, 8.66412651e-03f, 2.61146780e-02f, -1.42213374e-01f, -5.79875372e-02f, 2.10991697e-04f, 1.41868293e-02f,
  2.98971906e-02f, 4.27180529e-02f, 5.16825356e-02f, 6.25618845e-02f, 4.03977633e-02f, 1.64396986e-02f, 1.54351620e-02f, 8.59370083e-03f, 8.86496454e-02f, 1.28863528e-01f,
  7.64415041e-02f, 2.29183566e-02f, -2.07850616e-02f, 9.25935060e-02f, 9.29038674e-02f, -1.90449450e-02f, -8.05934332e-03f, 6.69105425e-02f, 6.86112121e-02f, 3.51529755e-02f,
  -1.65828064e-01f, 1.50967479e-01f, -5.71187772e-02f, 1.92549862e-02f, -1.04217064e-02f, -9.71738324e-02f, -8.95726532e-02f, -2.77289711e-02f, -1.22935951e-01f, 1.44239947e-01f,
  -1.26754791e-01f, 2.51702428e-01f, -1.45237461e-01f, -2.25787252e-01f, -4.70496356e-01f, -3.65479738e-01f, -2.92722762e-01f, 3.87216508e-02f, -1.13461584e-01f, 1.89594299e-01f,
  -1.99316069e-01f, -1.89927325e-01f, -1.12142049e-01f, 9.39561874e-02f, 2.14107230e-01f, 2.56561190e-01f, 1.39217600e-01f, 1.14287429e-01f, 1.54298559e-01f, -1.21115901e-01f,
  -1.35854736e-01f, -2.05330104e-02f, 1.24113038e-01f, -4.38291878e-02f, -1.24682123e-02f, 1.46559998e-01f, 5.10534719e-02f, -7.29655921e-02f, -2.37545706e-02f, 4.52307947e-02f,
  9.35652405e-02f, -6.83701560e-02f, -3.66407670e-02f, -6.71535879e-02f, -1.55344745e-02f, 2.42469348e-02f, -1.70017313e-02f, 5.34245111e-02f, 1.35051936e-01f, -2.92946864e-03f,
  1.43320888e-01f, 1.02167798e-03f, -7.73260519e-02f, -6.02545626e-02f, -6.83880970e-02f, 3.91680449e-02f, 1.75848417e-02f, 3.41431092e-04f, 3.62558849e-02f, -1.34025235e-02f,
  -3.40922587e-02f, 7.30266199e-02f, -5.77975027e-02f, -3.78043465e-02f, 6.50035217e-02f, 5.02724461e-02f, -5.29190153e-02f, 4.52380776e-02f, 6.83284625e-02f, 2.41088271e-02f,
  2.40871795e-02f, 2.15935893e-02f, -2.33779252e-02f, 3.80262509e-02f, 7.90552869e-02f, 6.76549599e-02f, -2.66737342e-02f, 2.87290663e-02f, 2.13253908e-02f, -6.04578741e-02f,
  -8.76104385e-02f, 7.12540757e-04f, 1.35441989e-01f, 4.91549708e-02f, -1.09642439e-01f, 2.25705672e-02f, -8.83442070e-03f, 1.12754367e-02f, 3.78678665e-02f, -3.33731323e-02f,
  1.24161392e-02f, 8.21912438e-02f, -1.46218634e-03f, 1.14788271e-01f, -3.10680433e-03f, -3.52462493e-02f, -3.21424454e-02f, 3.24448235e-02f, -1.92323774e-02f, -1.18838176e-02f,
  1.51038421e-02f, -7.79580267e-04f, 2.84974743e-02f, -8.55188742e-02f, -3.64544466e-02f, 7.91521219e-04f, 5.27523719e-02f, -9.78600606e-03f, 2.47331075e-02f, 2.78336406e-02f,
  1.27709627e-01f, 3.25619318e-02f, 7.93986246e-02f, -5.34954108e-02f, -1.37548214e-02f, 8.16135928e-02f, 6.19143322e-02f, 3.28504406e-02f, -9.67390090e-03f, -5.02089001e-02f,
  2.27059171e-01f, -3.56387734e-01f, 1.62179783e-01f, 1.00244991e-01f, 2.35866502e-01f, 7.56919831e-02f, 3.36264879e-01f, -3.84501778e-02f, -1.07882544e-01f, -3.41663897e-01f,
  1.10560665e-02f, -7.13961571e-02f, 1.00960344e-01f, -1.00545473e-01f, 3.72381836e-01f, -1.01260059e-01f, 2.48159468e-02f, -9.31018442e-02f, 3.90580259e-02f, -1.20852262e-01f,
  -2.01196503e-02f, -1.54821217e-01f, 1.11913890e-01f, -1.39052525e-01f, 1.24079086e-01f, 1.35470703e-02f, 3.86633053e-02f, 1.28085703e-01f, -1.08244851e-01f, 3.08803823e-02f,
  1.34718977e-03f, 2.72267498e-02f, -1.63607742e-03f, -2.40959879e-02f, 8.46210960e-03f, 6.19097091e-02f, 5.00465743e-02f, 1.30218923e-01f, 8.21065605e-02f, 3.46719846e-02f,
  1.74639374e-02f, 2.53006704e-02f, -9.52354819e-02f, 9.14962217e-02f, 1.15959076e-02f, -2.85421056e-03f, -6.33014143e-02f, -3.93832326e-02f, 1.68852173e-02f, -1.53659806e-02f,
  4.90423478e-02f, -9.59465951e-02f, -4.77183983e-02f, -3.34611125e-02f, -1.38416635e-02f, 4.00653556e-02f, 2.05818880e-02f, 2.46404111e-03f, -5.15879579e-02f, -5.91195887e-03f,
  8.54884535e-02f, 3.19732837e-02f, 1.76896472e-02f, 1.16697391e-02f, -3.92234214e-02f, 7.15329275e-02f, -7.78954551e-02f, 7.22533986e-02f, -2.06983108e-02f, 1.01244658e-01f,
  -6.09505922e-02f, 4.15461212e-02f, 6.24364652e-02f, 2.23341864e-02f, 4.69798706e-02f, 8.76076445e-02f, -1.11197293e-01f, -7.22337589e-02f, 6.28871620e-02f, -4.24918532e-02f,
  -2.59239804e-02f, -2.27621500e-03f, 7.46022016e-02f, -5.89640625e-02f, 3.33454162e-02f, 1.05411410e-01f, -4.16340344e-02f, 2.74324305e-02f, 5.54826949e-03f, 2.15389784e-02f,
  -4.29795563e-01f, -3.25964183e-01f, -3.47891971e-02f, -1.39827132e-01f, -5.70199937e-02f, -4.63661142e-02f, -2.90158819e-02f, -1.28112268e-02f, -1.05377421e-01f, -1.28430156e-02f,
  4.30335365e-02f, 1.59176290e-02f, -2.16553789e-02f, 7.68634230e-02f, 1.39610674e-02f, -1.97766777e-02f, -1.22608189e-02f, 2.11941730e-02f, -7.29235336e-02f, -5.39560243e-02f,
  -1.37746260e-02f, -8.42353329e-02f, 6.60577789e-02f, -1.84649555e-03f, 7.90169835e-02f, -6.63316920e-02f, 3.97266187e-02f, 2.93811727e-02f, -3.68348323e-02f, -8.31510052e-02f,
  1.42897204e-01f, 1.13360122e-01f, 7.63604119e-02f, 1.95927963e-01f, -6.86495006e-02f, -4.58471924e-01f, -3.52435440e-01f, 7.13306740e-02f, -3.21249336e-01f, -1.24256000e-01f,
  5.51645309e-02f, -3.13441232e-02f, -1.16709262e-01f, 1.98718861e-01f, 2.27781713e-01f, -1.22975081e-01f, 8.28756914e-02f, -5.68517148e-02f, 3.12525895e-03f, 9.71111208e-02f,
  1.86232790e-01f, 2.13682979e-01f, 3.32392812e-01f, 3.80820185e-01f, 5.38141876e-02f, 1.50774315e-01f, 3.90666127e-01f, 6.84073493e-02f, 3.75434458e-01f, 7.68168122e-02f,
  -8.73881727e-02f, -2.17065308e-02f, 2.83485800e-02f, -1.88549180e-02f, -2.03014612e-02f, -6.59686923e-02f, 3.29167917e-02f, 1.01197764e-01f, -2.10277997e-02f, -5.90450168e-02f,
  -5.94917834e-02f, 1.18793525e-01f, -2.64259037e-02f, 6.13983311e-02f, 3.06161381e-02f, 6.40697703e-02f, -5.69823794e-02f, -6.43514693e-02f, -7.77214486e-03f, 3.22344080e-02f,
  -2.26367414e-02f, -4.46938686e-02f, 7.64905661e-02f, -1.39797395e-02f, -1.56854298e-02f, 1.15429284e-02f, -4.06535119e-02f, -1.83596518e-02f, -1.15976930e-01f, -2.24183556e-02f,
  5.85020594e-02f, -6.45616129e-02f, -6.11005612e-02f, 4.18697894e-02f, 3.74665000e-02f, 1.09131876e-02f, 1.92392077e-02f, -1.81563534e-02f, 3.48442160e-02f, 6.76236227e-02f,
  4.16393566e-04f, 6.27752841e-02f, 4.75906320e-02f, -7.91257992e-02f, 7.79696321e-03f, -2.02186988e-03f, -8.82829260e-03f, 3.93687114e-02f, -2.30700374e-02f, 6.07031547e-02f,
  -5.70185483e-02f, 2.06299201e-02f, 3.59552763e-02f, -4.54578996e-02f, 5.31823337e-02f, -7.30462223e-02f, 1.92203093e-02f, -5.14004976e-02f, 2.34696642e-02f, -3.89564075e-02f,
  -2.14917045e-02f, 2.11324543e-01f, -7.92055428e-02f, -2.77899243e-02f, 4.65520332e-03f, -5.74146621e-02f, 1.26978867e-02f, 2.55116937e-03f, 1.22639135e-01f, 2.36733500e-02f,
  7.38403797e-02f, 4.06601578e-02f, -2.10202653e-02f, -2.97523998e-02f, 3.67757641e-02f, -3.00768334e-02f, 8.73511657e-03f, 2.44326331e-02f, 6.15174845e-02f, 7.07672462e-02f,
  6.18245043e-02f, -7.80020207e-02f, 1.15106069e-02f, -4.17039208e-02f, 6.26641065e-02f, -9.05169770e-02f, 2.36988515e-02f, -3.73145973e-04f, 8.75749812e-02f, -8.38182196e-02f,
  -8.02124143e-01f, 2.99561232e-01f, 1.21594980e-01f, -2.96903491e-01f, -1.16808183e-01f, -9.91698503e-02f, 1.30936742e-01f, 3.93023808e-03f, -1.55895859e-01f, -1.34740081e-02f,
  -2.10440829e-02f, -2.03627832e-02f, 1.83074728e-01f, 3.29283699e-02f, -6.34037182e-02f, 2.37754077e-01f, -1.37015790e-01f, -1.01377919e-01f, 1.36772648e-01f, -4.84211035e-02f,
  -2.03251183e-01f, -7.01333955e-02f, 2.29249313e-01f, 1.17035545e-01f, -2.84104180e-02f, -6.38252944e-02f, -1.07268490e-01f, 2.04773098e-01f, -4.22169417e-02f, 1.32048532e-01f,
  -2.81090975e-01f, -2.32998326e-01f, -1.13396071e-01f, -3.68738323e-02f, -1.12958267e-01f, -5.26576256e-03f, -4.93895411e-02f, -4.51587923e-02f, -1.01044968e-01f, -8.18668678e-02f,
  -1.06666215e-01f, 3.36014107e-02f, -2.63336133e-02f, -8.34857579e-03f, -1.31859466e-01f, -2.22624578e-02f, 1.49407089e-02f, 8.51999677e-04f, 4.09992151e-02f, 9.57454741e-02f,
  1.54788986e-01f, -1.69420801e-02f, -2.65648477e-02f, -5.07715493e-02f, 8.02115425e-02f, -6.87089413e-02f, -1.21040316e-02f, 5.74133173e-02f, -2.49372348e-02f, -4.80948910e-02f,
  6.47378266e-02f, -1.11426692e-02f, 3.18980007e-03f, 2.43331101e-02f, 4.42055874e-02f, -6.68998212e-02f, 5.74094616e-02f, 5.86212017e-02f, -6.87683523e-02f, -5.46816587e-02f,
  -5.72508648e-02f, -8.48656427e-03f, -1.96549483e-02f, -1.51247093e-02f, -6.91826418e-02f, 1.13887107e-02f, 1.63355377e-02f, -3.01770512e-02f, 2.92980373e-02f, -4.73833606e-02f,
  -2.83800345e-02f, 5.54246977e-02f, 9.62746143e-02f, -1.01067394e-01f, -9.99415945e-03f, 2.93033011e-02f, 1.43364724e-02f, 7.27270693e-02f, -2.13894136e-02f, -5.34877088e-03f,
  -4.12808180e-01f, -4.20029640e-01f, -3.70331318e-03f, -1.06622942e-01f, -7.32472390e-02f, -8.09539855e-02f, 4.61912379e-02f, -5.28736180e-03f, -9.10884589e-02f, 2.60171872e-02f,
  -5.55172078e-02f, -7.22000748e-02f, -1.77967343e-02f, 8.94116312e-02f, 2.07248479e-02f, -2.54932251e-02f, -6.71485588e-02f, -4.76940610e-02f, -9.29983556e-02f, -1.76865812e-02f,
  3.65370288e-02f, -3.06043699e-02f, -2.39834632e-03f, -6.31760433e-02f, -4.72288318e-02f, 1.56189585e-02f, -1.34499580e-01f, -1.45979198e-02f, -8.71845707e-02f, 2.24278774e-02f,
  1.53657561e-02f, -4.71774369e-01f, 4.30177413e-02f, -2.00928878e-02f, 1.40074983e-01f, -3.66638079e-02f, 1.56863794e-01f, -1.87076479e-01f, -1.68570802e-01f, -2.26463273e-01f,
  -7.47519918e-03f, 2.07712218e-01f, -1.13156661e-01f, 3.13968584e-02f, 2.99188107e-01f, -2.61992100e-03f, -7.91951492e-02f, 8.92330781e-02f, 1.01148570e-02f, -1.14324428e-01f,
  9.55180973e-02f, 2.30217427e-02f, 8.01439062e-02f, -1.08698253e-02f, 1.78230107e-02f, -6.56880215e-02f, 6.42367080e-02f, 1.36092782e-01f, 5.31564578e-02f, 2.52591819e-01f,
  -7.81768635e-02f, -1.39924958e-01f, 7.18283281e-02f, 2.75593735e-02f, -1.27899513e-01f, -2.75362264e-02f, 4.47419398e-02f, 1.44481450e-01f, -6.00000098e-02f, -1.24980800e-01f,
  -2.07428690e-02f, -4.76352163e-02f, 1.09734982e-01f, -1.70051865e-02f, -6.31868690e-02f, -8.47801119e-02f, -1.65447462e-02f, -1.26682352e-02f, -3.06090619e-03f, -3.90823111e-02f,
  -8.15305486e-02f, -2.93561406e-02f, -2.71432940e-02f, 5.77102490e-02f, 1.94713380e-02f, -6.13227226e-02f, 8.00644699e-03f, 1.75243914e-01f, -3.03972736e-02f, 1.41529562e-02f,
  1.13491684e-01f, 1.94955897e-02f, -7.75805786e-02f, -6.32232204e-02f, 1.49362087e-02f, -9.59245954e-03f, -1.00317709e-01f, 1.43859712e-02f, 2.65079197e-02f, -6.66073859e-02f,
  9.30125359e-03f, -8.02545063e-03f, 3.88315283e-02f, 1.88525058e-02f, -2.75417175e-02f, 1.06428228e-02f, 1.18793741e-01f, 4.91252355e-03f, -2.68626045e-02f, -4.97236624e-02f,
  1.65535305e-02f, 2.94556897e-02f, 9.22455788e-02f, 4.93536852e-02f, -9.73082334e-02f, 2.02530995e-02f, 3.22503373e-02f, 4.38567661e-02f, 8.98261275e-03f, 1.18926270e-02f,
  -3.69366527e-01f, -2.54316479e-01f, 2.84639560e-02f, 2.19227262e-02f, -4.27401587e-02f, -1.38342261e-01f, -7.55062774e-02f, -3.31077576e-02f, -3.39713693e-02f, 5.01776785e-02f,
  -1.24096632e-01f, 5.34397997e-02f, 2.75751605e-04f, 3.86930369e-02f, 1.04796067e-01f, 5.73383318e-03f, -8.19448009e-02f, -7.16300011e-02f, 1.97461825e-02f, -7.18998313e-02f,
  5.64469025e-03f, 6.80028573e-02f, 8.61761644e-02f, -2.34553255e-02f, 1.43094072e-02f, -9.26516578e-03f, -2.29554065e-02f, 4.82794121e-02f, 8.79727025e-03f, -1.40853757e-02f,
  -1.72041774e-01f, 6.52211830e-02f, -3.02076191e-01f, -3.36533576e-01f, -1.09280162e-02f, -3.67747307e-01f, -4.21806425e-01f, -3.80992666e-02f, 2.18479279e-02f, -4.46926430e-02f,
  -1.74182042e-01f, -4.35654074e-02f, 3.83286029e-02f, -1.06788583e-01f, 1.34023055e-01f, 2.09345788e-01f, -2.48632774e-01f, -2.01690033e-01f, 6.68480471e-02f, -3.37070525e-01f,
  -4.50589731e-02f, -2.03626305e-01f, -1.45208329e-01f, -5.35346456e-02f, -2.91262984e-01f, -1.11405857e-01f, 1.54748634e-02f, -1.92731708e-01f, -1.98638633e-01f, 3.50172333e-02f,
  -4.84717786e-02f, 7.97802284e-02f, -1.98041081e-01f, -7.08431378e-03f, -1.71088919e-01f, -1.89586617e-02f, -1.30905390e-01f, -2.44283146e-04f, -6.90727681e-02f, -2.78727282e-02f,
  -4.38182838e-02f, 1.64007954e-03f, -5.77374250e-02f, 1.30063733e-02f, -1.20201183e-03f, 4.78128699e-04f, -6.78040683e-02f, 4.78356220e-02f, 1.19021256e-02f, -1.54405776e-02f,
  -1.07055992e-01f, -1.08481020e-01f, -8.20991993e-02f, 2.80616172e-02f, -8.52718279e-02f, -2.50641312e-02f, 6.52444884e-02f, -3.15599628e-02f, -9.34668332e-02f, -4.27696332e-02f,
  7.91073404e-03f, -7.18261153e-02f, 3.07196733e-02f, 3.49840261e-02f, 7.30531812e-02f, 8.79207775e-02f, -6.40191212e-02f, 2.90943291e-02f, 3.85472216e-02f, 2.31894404e-02f,
  3.08421794e-02f, 3.95111628e-02f, 1.36798685e-02f, -9.76626724e-02f, -4.40841392e-02f, 9.56453606e-02f, -5.61681204e-02f, 4.93160710e-02f, 6.24174029e-02f, 1.98736954e-02f,
  1.12921372e-02f, -3.05260289e-02f, 1.21377252e-01f, -2.44243853e-02f, -8.36927518e-02f, -6.22983538e-02f, 7.96913654e-02f, 6.82229027e-02f, -1.13639310e-01f, -1.19873732e-01f,
  -1.40044883e-01f, -5.83105721e-02f, 5.95493102e-03f, 7.64495283e-02f, 2.46087797e-02f, -5.55149950e-02f, 2.51208209e-02f, -8.04043487e-02f, -1.93221066e-02f, -1.44768320e-02f,
  -1.09416932e-01f, 6.63357005e-02f, -5.93137629e-02f, -6.54945821e-02f, -1.74422022e-02f, 5.04982192e-03f, -8.17924142e-02f, 9.43832006e-03f, -7.99593627e-02f, -1.59510709e-02f,
  3.53990383e-02f, 8.89489576e-02f, 5.03737628e-02f, 2.09580897e-03f, -1.09041715e-02f, -9.61721912e-02f, 8.09753612e-02f, -5.31670526e-02f, -4.28573266e-02f, -5.64181362e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -2.48838197e-02f, 8.40822160e-02f, 1.00279897e-01f, 7.86204189e-02f, 1.19245604e-01f, 1.61184967e-01f, 2.16425415e-02f, 1.41228646e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.99408609e-02f, -6.64899796e-02f, -8.42553303e-02f, 3.39305371e-01f, 9.49347392e-02f, 3.02384943e-01f, -1.93182662e-01f, -2.82743126e-02f, -8.74743834e-02f, -5.04877605e-02f,
  9.90560874e-02f, -1.64214790e-01f, -4.72658016e-02f, -1.13197163e-01f, 2.43614614e-01f, 2.11789808e-03f, 5.41656204e-02f, 5.94348758e-02f, 5.64177483e-02f, 2.93660372e-01f,
  4.15350676e-01f, 6.28360286e-02f, 2.50506431e-01f, 4.44075726e-02f, 8.00990164e-02f, 6.67040125e-02f, 2.72644579e-01f, -1.41070355e-02f, -2.79074639e-01f, -2.79399604e-01f,
  -3.16747278e-01f, 2.29513034e-01f, -9.69653800e-02f, -1.71920881e-01f, 1.75062612e-01f, 1.82817400e-01f, -2.12659538e-01f, 4.14880008e-01f, 9.98854786e-02f, -5.03062122e-02f,
  -1.30604550e-01f, 3.09086591e-01f, 1.58505905e-02f, -7.74101689e-02f, -2.22967282e-01f, 5.85763864e-02f, 1.81726843e-01f, -2.01266393e-01f, -2.84076869e-01f, 3.40979248e-01f,
  6.45501241e-02f, 7.99253359e-02f, -2.49354672e-02f, -3.48864459e-02f, 1.84577435e-01f, -3.30783665e-01f, -1.39200598e-01f, 2.71786958e-01f, 1.84556559e-01f, -3.22425514e-01f,
  1.86049610e-01f, 2.57055491e-01f, -2.46734440e-01f, 2.03516364e-01f, 2.51937836e-01f, -2.39018872e-01f, -7.72138089e-02f, 8.86598974e-02f, 1.46498606e-01f, 9.46145728e-02f,
  -1.19836293e-01f, 1.47957191e-01f, 1.17978022e-01f, -2.32387885e-01f, -3.74431670e-01f, -1.40903890e-01f, -3.09097171e-01f, -1.61207125e-01f, 1.45056948e-01f, 4.80092794e-01f,
  -2.84029216e-01f, -3.71259078e-02f, 1.07434161e-01f, 9.90568027e-02f, -4.48714584e-01f, 2.21386969e-01f, -5.31461656e-01f, 1.97590619e-01f, 2.55637825e-01f, 2.07223389e-02f,
  1.15352102e-01f, -3.41710061e-01f, -1.45912385e-02f, -1.48561209e-01f, -2.76977330e-01f, -1.06368028e-01f, -3.99476700e-02f, -2.88746327e-01f, 1.24681927e-01f, 4.09789756e-02f,
  -2.41940171e-01f, 2.18771935e-01f, -2.19170973e-01f, 7.18018711e-02f, -1.74392089e-01f, 3.75333786e-01f, 8.51816833e-02f, -1.64040655e-01f, 4.02237922e-02f, -6.08462468e-02f,
  2.29910195e-01f, 3.58809009e-02f, -3.08404505e-01f, 2.45867208e-01f, 1.05449282e-01f, 2.60986239e-01f, 1.77546412e-01f, 1.34426087e-01f, 1.33818775e-01f, 1.44619476e-02f,
  -2.37645581e-01f, 5.43741465e-01f, 3.10206562e-01f, -9.23096240e-02f, 2.33840078e-01f, -6.86465800e-02f, -1.78491965e-01f, 2.64043510e-01f, -1.99139312e-01f, 2.45911703e-01f,
  3.59996073e-02f, 2.58336421e-02f, 3.60088758e-02f, -3.82189214e-01f, -1.29019022e-02f, 2.39255708e-02f, 1.77746296e-01f, -5.45267342e-03f, 2.36786619e-01f, 2.13435050e-02f,
  2.26575360e-01f, -2.32377291e-01f, -2.82105152e-02f, -4.53113951e-02f, 1.08330302e-01f, 1.85181275e-01f, -2.47212246e-01f, -1.00977115e-01f, -1.96494505e-01f, 5.25997654e-02f,
  -8.26998055e-02f, -7.48096257e-02f, 1.94585621e-01f, -1.13564566e-01f, -4.45192933e-01f, 1.81420922e-01f, 1.13584839e-01f, 1.90198302e-01f, 2.94565916e-01f, 2.73948222e-01f,
  1.99374571e-01f, 1.48501649e-01f, 1.22147352e-01f, 5.13329990e-02f, 6.01986842e-03f, 4.42264229e-01f, 2.42883101e-01f, 1.28098831e-01f, -3.25345308e-01f, -3.32924575e-01f,
  1.79293871e-01f, 1.07006896e-02f, -1.25959683e-02f, -7.91976973e-03f, 2.43137509e-01f, -1.98296577e-01f, 1.92094445e-01f, 5.37818491e-01f, 2.02918127e-01f, 1.26739502e-01f,
  3.33391935e-01f, -1.95182085e-01f, 8.34840685e-02f, 6.52517974e-02f, -2.33283699e-01f, 1.01691589e-01f, 6.97173700e-02f, 3.03544164e-01f, -4.87496167e-01f, 2.58358687e-01f,
  -9.18042362e-02f, 3.94333363e-01f, -1.45716891e-01f, 1.96708545e-01f, 2.85461303e-02f, 3.67938168e-02f, 8.41445252e-02f, -8.30485597e-02f, 1.87263161e-01f, -2.06331909e-01f,
  4.98286681e-03f, -3.01821500e-01f, 1.47046641e-01f, 2.63288349e-01f, -1.37984678e-01f, -3.00361156e-01f, 1.13246880e-01f, -2.09929645e-01f, 1.16072327e-01f, 1.17656820e-01f,
  -3.51211131e-01f, -1.33715451e-01f, -4.28250104e-01f, 1.48614585e-01f, 7.24397078e-02f, -1.82698846e-01f, -2.85530984e-01f, 5.15355449e-03f, 1.38318807e-01f, 6.09746091e-02f,
  -2.38946185e-01f, 2.61905134e-01f, 1.39676601e-01f, 1.62127689e-01f, -2.02901423e-01f, 1.76867977e-01f, 8.64376351e-02f, -1.06451288e-01f, -7.94466957e-02f, 7.00254506e-03f,
  7.79507905e-02f, -7.81421512e-02f, -7.45527968e-02f, -5.29759936e-02f, 7.61790946e-02f, -6.56840578e-02f, -3.24178010e-01f, -2.96184361e-01f, 1.86647952e-01f, -2.54730642e-01f,
  -1.43428192e-01f, 1.10412635e-01f, -1.25724047e-01f, -1.58457458e-01f, -4.69012201e-01f, 1.13311365e-01f, 4.03084308e-01f, -3.07480007e-01f, -1.96255632e-02f, 2.06043959e-01f,
  1.67077631e-01f, 1.41166255e-01f, -2.46466011e-01f, 1.18484125e-01f, -1.12794705e-01f, 3.30029279e-01f, 1.49962902e-01f, -1.90555118e-02f, -6.59157559e-02f, 6.13581650e-02f,
  -1.01314574e-01f, -2.60543317e-01f, -3.65075655e-02f, 2.08533518e-02f, -1.58114314e-01f, -2.31036544e-01f, 2.96344254e-02f, 2.11957127e-01f, -3.25991325e-02f, 1.91472560e-01f,
  7.83680677e-02f, -8.73412862e-02f, 1.00096919e-01f, 3.50449644e-02f, 3.93008679e-01f, -1.55048817e-01f, 2.20873550e-01f, -1.35385484e-01f, -1.32429183e-01f, 1.69041336e-01f,
  1.18863970e-01f, -9.19885486e-02f, -1.18709579e-01f, 1.49367556e-01f, -8.34148303e-02f, -7.44577497e-02f, 4.86630276e-02f, 1.93890855e-01f, -6.63674846e-02f, 1.65703714e-01f,
  -6.54467717e-02f, 1.88597247e-01f, 2.01482877e-01f, -4.53285187e-01f, -2.12057978e-01f, 6.64978176e-02f, -6.35704622e-02f, 1.26348838e-01f, 3.32798399e-02f, -6.84576556e-02f,
  -1.09491810e-01f, 7.26587847e-02f, 5.68735600e-03f, -4.52543236e-02f, -2.32853554e-02f, -5.00028312e-01f, -3.48740280e-01f, 5.43452390e-02f, 4.62245662e-03f, 9.02272090e-02f,
  2.20660448e-01f, 1.54663309e-01f, 2.32111961e-01f, 1.63258269e-01f, 1.16895519e-01f, -2.31330574e-01f, 3.23534846e-01f, -3.25061440e-01f, -1.14002094e-01f, 8.34886581e-02f,
  -1.84252292e-01f, 1.46430749e-02f, 1.66470021e-01f, -1.11158108e-02f, -6.25784136e-03f, -2.03738958e-01f, -8.65129009e-02f, 9.49469656e-02f, -1.07519418e-01f, -1.21749476e-01f,
  1.21054307e-01f, 1.48253113e-01f, -6.75851926e-02f, -1.62617058e-01f, -2.87062496e-01f, -4.20148492e-01f, 2.37413391e-01f, -2.64788628e-01f, -2.78114051e-01f, -1.58982351e-01f,
  -1.82919383e-01f, -3.78078282e-01f, 4.91527766e-02f, 3.25620212e-02f, -3.02259386e-01f, 1.21574827e-01f, 6.18167371e-02f, 2.48326927e-01f, -2.33320758e-01f, -3.24673206e-01f,
  2.20098466e-01f, 1.74283892e-01f, 1.49575800e-01f, 4.31607477e-02f, -4.43745852e-02f, 4.34018150e-02f, 2.67763138e-02f, -1.13318413e-01f, 3.03024519e-03f, 3.26380022e-02f,
  -5.90778589e-02f, -1.80360287e-01f, 5.60408644e-02f, 1.45339176e-01f, 1.82725772e-01f, -9.24176499e-02f, -2.69538671e-01f, 1.00137442e-01f, 3.43222409e-01f, -3.74072455e-02f,
  2.25393921e-01f, 2.90907938e-02f, -2.91151524e-01f, -2.73442771e-02f, -4.65539157e-01f, 2.62190223e-01f, 2.65913934e-01f, 9.88300424e-03f, -3.42439651e-01f, 9.70595852e-02f,
  2.87507176e-01f, -1.41714409e-01f, 8.59600455e-02f, -3.19254249e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.68646081e-02f, 1.86403051e-01f, 3.05930018e-01f, 3.38451594e-01f, 2.07394436e-01f, 3.89404267e-01f, 2.27793708e-01f, -3.39557556e-03f, 2.56841183e-01f, -9.74910110e-02f,
  2.08047688e-01f, 1.81008145e-01f, -2.26014346e-01f, -4.22843367e-01f, 1.74160600e-01f, 2.61177476e-02f, -2.15035513e-01f, 1.88975781e-01f, 4.05189488e-03f, -4.72040735e-02f,
  -5.60520589e-01f, 2.93042451e-01f, 3.11133146e-01f, -4.53254640e-01f, -1.64651290e-01f, 2.91061401e-01f, 6.29527271e-02f, 1.20978415e-01f, -8.64229724e-02f, 5.04615545e-01f,
  1.14371516e-01f, 3.44513267e-01f, 3.85697216e-01f, 5.14043458e-02f, 8.82242396e-02f, 2.84268677e-01f, 8.85298550e-02f, 3.39607447e-01f, 1.28275529e-01f, 2.09503502e-01f,
  -5.87695353e-02f, 3.61517787e-01f, 8.35887194e-02f, 1.04705520e-01f, -1.37135729e-01f, 3.98397714e-01f, 4.00812645e-03f, -6.55389950e-02f, -2.94141889e-01f, 2.12008551e-01f,
  -2.06094950e-01f, 1.93621397e-01f, 4.60814446e-01f, -1.33141637e-01f, 1.66977003e-01f, 1.76166117e-01f, -1.90746263e-01f, 1.47925824e-01f, 2.65853703e-01f, -3.01723093e-01f,
  3.39367360e-01f, -1.12894177e-01f, -2.70840079e-01f, -2.29853615e-01f, 2.36722648e-01f, 4.41822290e-01f, 3.09348345e-01f, 2.39531875e-01f, 9.90402102e-02f, 1.25076443e-01f,
  4.02173579e-01f, 1.47542179e-01f, 2.07046911e-01f, -1.48599237e-01f, 3.79544020e-01f, 4.45602685e-01f, 3.16329509e-01f, -8.73912126e-02f, -2.40164646e-03f, -1.08313702e-01f,
  4.15129900e-01f, -2.52113730e-01f, 1.87996238e-01f, -1.54102251e-01f, -3.64744425e-01f, 7.35206157e-02f, -4.13100049e-02f, 2.68413834e-02f, -1.53401354e-02f, -6.52906001e-01f,
  -4.92142200e-01f, 4.52814877e-01f, -1.58749506e-01f, 3.46902639e-01f, 4.30792958e-01f, -7.03919083e-02f, -8.64523500e-02f, 3.46603364e-01f, 1.50851801e-01f, 1.39751613e-01f,
  3.80950630e-01f, -2.68647164e-01f, -8.44442844e-02f, -4.35414873e-02f, 1.60181060e-01f, 5.11622548e-01f, 4.56334621e-01f, 3.90556723e-01f, -2.17220336e-01f, 9.54272225e-03f,
  4.27873852e-03f, -6.75085962e-01f, 8.30954034e-03f, 1.70699492e-01f, -6.47837341e-01f, -5.05833149e-01f, -1.40076697e-01f, -8.71240944e-02f, 2.40703583e-01f, -1.05768636e-01f,
  -4.00232643e-01f, 1.32319376e-01f, -1.50366127e-01f, 1.26720384e-01f, -4.17989492e-03f, 2.00786620e-01f, 3.67330402e-01f, 4.37576175e-01f, -1.78696327e-02f, 2.52300322e-01f,
  1.68830618e-01f, 1.45129576e-01f, 6.95067197e-02f, -1.35529697e-01f, 2.11041451e-01f, 1.22194171e-01f, 1.68000475e-01f, 1.89365610e-01f, 1.99016139e-01f, 3.01176578e-01f,
  1.37366235e-01f, 3.37038308e-01f, -2.94762850e-01f, -3.31532687e-01f, 1.53419048e-01f, -2.49246031e-01f, 3.36433984e-02f, -2.71935612e-01f, -2.80622933e-02f, -1.20627634e-01f,
  1.33698627e-01f, -9.99116004e-02f, 1.24927685e-02f, -2.11751148e-01f, 1.97819874e-01f, 3.10574979e-01f, 1.41143292e-01f, 2.06452422e-02f, 1.47131339e-01f, -1.73597455e-01f,
  2.80120194e-01f, 2.46339127e-01f, 4.87899482e-02f, 2.30048478e-01f, 1.02085859e-01f, 1.25691578e-01f, -4.62418376e-03f, 3.74012738e-01f, 5.39509878e-02f, 4.87386376e-01f,
  1.85100421e-01f, 8.78657103e-02f, 9.90622789e-02f, 5.32694578e-01f, -4.97333944e-01f, -2.95536555e-02f, -1.62631720e-01f, -2.51562029e-01f, -4.08409029e-01f, 2.08284166e-02f,
  1.56796470e-01f, -1.63050428e-01f, 1.55980334e-01f, -3.98840234e-02f, -1.28484145e-01f, 1.79575935e-01f, 1.67688832e-01f, 2.74948835e-01f, 4.14549410e-01f, -4.95864004e-01f,
  3.10239375e-01f, -2.60028094e-01f, -7.29245916e-02f, 3.55929345e-01f, 2.26204157e-01f, 1.53637603e-01f, 2.49748100e-02f, 3.84275585e-01f, 4.67287600e-01f, 1.57658942e-03f,
  2.45255008e-02f, -3.11126471e-01f, 1.75385326e-01f, 3.04631144e-01f, -2.09352121e-01f, -4.03240979e-01f, 3.32722098e-01f, 1.40189528e-01f, 1.82195023e-01f, 1.35297060e-01f,
  -3.82895432e-02f, 1.08099483e-01f, -7.14844108e-01f, 2.61156708e-01f, -5.13460338e-02f, -3.77069712e-01f, -1.10445872e-01f, 2.16035739e-01f, 1.43337861e-01f, 1.74421277e-02f,
  -3.31278056e-01f, 5.02591074e-01f, -3.79945934e-02f, 3.71007621e-01f, 2.18020052e-01f, -2.33615078e-02f, 3.05214971e-01f, 1.52672783e-01f, -3.16182263e-02f, 3.57603848e-01f,
  2.62054920e-01f, 3.21431041e-01f, -1.83535237e-02f, 1.72960311e-01f, -1.52227297e-01f, 1.63699865e-01f, -3.20792049e-01f, -5.10235667e-01f, 1.58069938e-01f, 2.28512287e-01f,
  -1.73724920e-01f, -1.34886876e-01f, -4.54971880e-01f, 3.50054890e-01f, -3.11973900e-01f, 2.30486676e-01f, 4.31903601e-02f, -2.84726322e-01f, -2.70453058e-02f, 4.46157008e-01f,
  5.27758487e-02f, -1.15965441e-01f, 2.86900431e-01f, 1.24780998e-01f, -2.02668577e-01f, 3.79296273e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  2.47674033e-01f, 2.76091993e-01f, 2.75749922e-01f, 9.84578207e-02f, 2.84063309e-01f, 4.64251041e-01f, 2.55729765e-01f, 3.84013414e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  2.84828153e-02f, -4.21616808e-02f, -2.89694756e-01f, -4.46693331e-01f, 1.16463393e-01f, 8.09820816e-02f, -1.17870428e-01f, -1.50619254e-01f, 1.12475716e-01f, -1.83093652e-01f,
  -1.93165287e-01f, -4.71576862e-02f, -2.50450969e-01f, -4.97481793e-01f, -3.12804520e-01f, -1.45844549e-01f, 3.56955737e-01f, -1.57892928e-01f, -7.56209530e-03f, -3.53401065e-01f,
  2.07459539e-01f, 3.37787956e-01f, 6.16489708e-01f, 1.79283127e-01f, -1.94643483e-01f, -9.04928669e-02f, 1.80829540e-02f, 2.24720910e-01f, 2.02799156e-01f, 8.06017369e-02f,
  -1.65067181e-01f, -3.10580134e-02f, 1.61700532e-01f, -2.46533439e-01f, 9.85433757e-02f, -1.64564148e-01f, 3.15243483e-01f, -1.91353887e-01f, 3.44850793e-02f, -7.58590326e-02f,
  4.25839312e-02f, -3.74481119e-02f, 2.10085467e-01f, -2.61193454e-01f, -2.98194706e-01f, -3.42319220e-01f, 6.12847388e-01f, -1.64042696e-01f, -6.12461790e-02f, -2.54644841e-01f,
  -1.91258177e-01f, 1.48264244e-02f, 3.39481719e-02f, -1.56995431e-01f, -2.01844171e-01f, 3.35284203e-01f, 1.40386328e-01f, -1.46441087e-01f, -4.92654070e-02f, -5.49402893e-01f,
  -1.67067751e-01f, -1.88496262e-01f, 1.86759621e-01f, 1.61726319e-03f, -6.39899671e-02f, 1.95132330e-01f, -1.89139143e-01f, 1.36083886e-01f, -1.35619164e-01f, 1.29599586e-01f,
  1.78385422e-01f, 1.18694790e-01f, -1.28395304e-01f, 7.89154097e-02f, 1.54883265e-01f, 3.21299404e-01f, 9.90913017e-04f, -1.39757022e-01f, -2.34884337e-01f, -3.99583310e-01f,
  -1.09506413e-01f, 6.79431260e-01f, 2.75101960e-01f, 1.31051466e-01f, 5.20285331e-02f, -6.72090471e-01f, -1.16035171e-01f, 1.80650532e-01f, -9.02255625e-03f, 3.33685651e-02f,
  1.73136666e-01f, -1.91011488e-01f, -1.07816361e-01f, -3.21914852e-01f, 1.59757763e-01f, -1.90255597e-01f, -1.85369164e-01f, 1.97828785e-01f, 2.13139296e-01f, -7.25602880e-02f,
  -2.29361698e-01f, 1.73467696e-02f, 3.51314177e-03f, -1.30680919e-01f, 7.89748803e-02f, -1.95532635e-01f, -1.19959898e-02f, 9.47878137e-02f, -3.19603272e-02f, 1.18192673e-01f,
  -3.58888835e-01f, 6.80260584e-02f, 3.00374091e-01f, -1.80673555e-01f, 3.46231550e-01f, 2.50231009e-02f, -1.90843761e-01f, -2.35874336e-02f, 3.47024351e-01f, 3.12161259e-02f,
  -9.62006114e-03f, -1.37173105e-02f, -8.76516476e-02f, 4.54630822e-01f, 1.20870881e-01f, 1.76083446e-02f, -1.31780952e-01f, -3.01592015e-02f, -1.68163832e-02f, 1.28731638e-01f,
  -1.10558942e-01f, 2.20891550e-01f, 4.75708060e-02f, 3.98952514e-02f, 4.21126299e-02f, 2.56128818e-01f, -1.51481062e-01f, -1.59390301e-01f, 2.22199231e-01f, 2.58131593e-01f,
  3.39476585e-01f, 2.81891018e-01f, -1.17756821e-01f, -1.82821885e-01f, -1.83925390e-01f, 3.08595836e-01f, 2.20007226e-01f, 3.07584256e-01f, 4.47176881e-02f, -9.78290010e-03f,
  2.70511031e-01f, -8.49316865e-02f, -1.04559578e-01f, 2.21211642e-01f, 4.37095612e-02f, 8.42633694e-02f, 2.04172194e-01f, -1.44681230e-01f, 1.68528274e-01f, -1.98299572e-01f,
  2.62503419e-03f, 4.15239893e-02f, 9.99817178e-02f, 1.10455081e-01f, 4.65998724e-02f, -1.14593446e-01f, -8.27412158e-02f, 1.47965699e-01f, 2.08096921e-01f, 8.38641729e-03f,
  -7.33746868e-03f, -4.31379005e-02f, -4.82672930e-01f, -2.88070440e-01f, 2.99383670e-01f, -2.18503684e-01f, 3.25985819e-01f, -3.03263396e-01f, 1.58720523e-01f, -2.60095865e-01f,
  2.46147037e-01f, 4.01161045e-01f, 3.34432900e-01f, 5.01687884e-01f, -8.63236487e-02f, 1.67492413e-04f, -6.61878213e-02f, 1.43726498e-01f, -1.01272389e-01f, 8.05495679e-02f,
  1.90142497e-01f, 1.46048799e-01f, 2.23341092e-01f, 2.05982625e-02f, 8.09759200e-02f, 1.58877373e-01f, 1.80030242e-01f, 6.62596151e-02f, -9.69365090e-02f, 1.27308592e-01f,
  -1.23301074e-01f, 2.51038462e-01f, -1.45009547e-01f, 2.54209220e-01f, 4.26988095e-01f, 2.47924373e-01f, -3.55062932e-02f, 1.16169706e-01f, -2.91245371e-01f, 4.42224711e-01f,
  -1.26236483e-01f, -2.86930025e-01f, 5.04368544e-01f, -2.65322596e-01f, 2.54871756e-01f, 8.80083442e-02f, -6.68775812e-02f, 1.93068370e-01f, -1.75354913e-01f, -3.07224631e-01f,
  -2.12802775e-02f, 2.35778570e-01f, -2.18189403e-01f, -9.07296464e-02f, 2.55515039e-01f, 2.79884905e-01f, 1.39039561e-01f, -1.08485948e-02f, -7.78324530e-02f, 3.23354274e-01f,
  1.37386620e-01f, 2.58720815e-01f, -1.87413156e-01f, -5.58843985e-02f, -6.78626471e-04f, -3.70556265e-02f, 1.22518800e-02f, -4.15443331e-02f, 1.11274675e-01f, -5.52260876e-02f,
  -3.48362118e-01f, 2.71590769e-01f, 2.51045823e-01f, 4.59234536e-01f, -6.61794692e-02f, -2.56325155e-01f, 1.57006860e-01f, -8.20089877e-02f, 2.47248679e-01f, 5.67225143e-02f,
  1.96147248e-01f, -2.56888241e-01f, 1.74580455e-01f, -1.84562169e-02f, 2.13744760e-01f, -5.59334159e-02f, 1.23590957e-02f, 1.64268717e-01f, -2.21550003e-01f, -2.01349363e-01f,
  -2.78267682e-01f, 1.20113321e-01f, 1.42013624e-01f, -1.19080245e-01f, -9.80438292e-02f, -1.23527780e-01f, -3.03219587e-01f, 2.01492190e-01f, 1.21222787e-01f, 1.02624737e-01f,
  -5.25972962e-01f, 1.06541038e-01f, 6.43724203e-02f, 4.43961173e-01f, 6.17732629e-02f, 1.64053932e-01f, 2.90051829e-02f, -2.28351712e-01f, 2.42052153e-01f, -3.23852032e-01f,
  1.03954770e-01f, -3.88353504e-02f, -2.39049211e-01f, 4.65168267e-01f, -1.02106795e-01f, -2.28942648e-01f, -1.80231377e-01f, -1.43136963e-01f, 1.45575022e-02f, 4.93710786e-02f,
  -2.48752050e-02f, -2.21535727e-01f, -1.38649538e-01f, 9.79771540e-02f, -1.72492504e-01f, -7.09517207e-03f, 1.23655103e-01f, -3.43293436e-02f, -1.92948848e-01f, 8.09218455e-03f,
  1.64745063e-01f, 2.78237969e-01f, -1.85424574e-02f, 7.96411261e-02f, -2.17908934e-01f, 4.78629947e-01f, 3.94733965e-01f, 3.06789547e-01f, 1.25863701e-01f, -4.44365174e-01f,
  4.59201038e-02f, -1.77225381e-01f, 2.47900099e-01f, 8.48991498e-02f, 1.24038562e-01f, 4.30840179e-02f, -2.47018710e-01f, -6.54132962e-02f, 3.56092244e-01f, 4.96031530e-02f,
  -1.05173878e-01f, 1.13258369e-01f, -9.52648744e-02f, -3.04809455e-02f, -2.73538381e-01f, -3.37360241e-03f, -3.31789255e-04f, 2.63685018e-01f, 5.60411811e-02f, -4.55639139e-02f,
  1.80029362e-01f, -5.56269027e-02f, -2.60255158e-01f, -9.37080607e-02f, -2.91580379e-01f, -1.71740040e-01f, 2.90794671e-01f, -1.65444672e-01f, 3.30579013e-01f, 3.07660073e-01f,
  -1.42229826e-03f, -1.44844040e-01f, -2.58915812e-01f, -2.32627138e-01f, 1.05619863e-01f, -1.17447011e-01f, 1.06369168e-01f, 9.82898772e-02f, 1.46127343e-01f, -2.69026190e-01f,
  -4.17356975e-02f, -2.46352881e-01f, -1.45609677e-01f, 2.89285004e-01f, 1.21472858e-01f, 1.66789368e-01f, 4.66033779e-02f, 4.03608419e-02f, -2.22871453e-01f, -2.90405080e-02f,
  3.15741122e-01f, 5.05944900e-02f, 1.49992526e-01f, 1.44008128e-02f, -2.04933256e-01f, -2.99861670e-01f, 1.71267897e-01f, 3.43313888e-02f, -1.23814449e-01f, 5.57145178e-02f,
  -4.25943166e-01f, -2.84976482e-01f, 2.57600069e-01f, -2.39566252e-01f, -3.51396590e-01f, 2.00974137e-01f, -1.63638756e-01f, 2.84081548e-01f, 1.69867456e-01f, -9.31221694e-02f,
  5.52716777e-02f, 3.08668822e-01f, -1.34244621e-01f, -2.23193571e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  2.82797575e-01f, -3.11755184e-02f, 4.00942981e-01f, 3.61896940e-02f, 1.76458597e-01f, 5.16187847e-02f, 1.36215866e-01f, -2.83203065e-01f, 3.50786537e-01f, 1.72610685e-01f,
  2.26095319e-01f, 2.26756945e-01f, -1.03645645e-01f, 1.81604370e-01f, 3.08048010e-01f, -1.29877068e-02f, 3.30667704e-01f, -1.78530619e-01f, 3.35728556e-01f, 3.34098548e-01f,
  -1.98031202e-01f, 6.86974451e-02f, -4.43475693e-02f, 8.85107815e-02f, 4.83218819e-01f, -2.50766695e-01f, 6.95414767e-02f, 9.61598232e-02f, -2.63892949e-01f, -1.35718778e-01f,
  5.08885503e-01f, 6.17639422e-01f, 1.37423009e-01f, 7.35302195e-02f, -1.33839116e-01f, -1.03020012e-01f, 1.88401580e-01f, 6.52903542e-02f, 2.53172755e-01f, 1.03458889e-01f,
  3.13821465e-01f, -1.75687611e-01f, -1.11917369e-02f, 4.02917147e-01f, -4.82347846e-01f, -2.76523143e-01f, -5.73543668e-01f, -5.79510629e-01f, 2.90619552e-01f, 2.46804580e-01f,
  3.23054224e-01f, 1.15892179e-01f, 1.39854684e-01f, -1.78684533e-01f, 5.76575577e-01f, 2.62946635e-01f, 1.90646276e-01f, -2.76911199e-01f, 5.63859463e-01f, 6.35670781e-01f,
  3.10383588e-01f, 4.01796639e-01f, 2.06905410e-01f, -3.91996264e-01f, 2.11653095e-02f, -2.24676616e-02f, 3.76526773e-01f, 3.20548639e-02f, 1.13027476e-01f, 3.30517441e-01f,
  1.50993705e-01f, -1.74779654e-01f, -1.73000433e-02f, 3.37008208e-01f, 2.32876956e-01f, 2.03471109e-01f, 3.84035498e-01f, 5.74218690e-01f, -1.34566933e-01f, 7.16607213e-01f,
  -1.36905894e-01f, 1.86858907e-01f, 8.67864415e-02f, -1.76212266e-02f, -5.29306531e-01f, 5.01063347e-01f, 1.08445689e-01f, -6.74786448e-01f, 4.24286455e-01f, 5.13424754e-01f,
  -2.87080973e-01f, 6.28196716e-01f, -8.55594408e-03f, 4.03284013e-01f, 1.88388214e-01f, 4.87515092e-01f, 3.29256088e-01f, 6.30898029e-02f, 2.44386092e-01f, 8.49119350e-02f,
  2.28147984e-01f, 1.39558420e-01f, 2.99127430e-01f, 1.70905724e-01f, 4.51118082e-01f, 4.61628586e-01f, 1.57426655e-01f, -1.26522928e-01f, 1.60077006e-01f, -2.40124241e-01f,
  3.84310931e-02f, 8.98223147e-02f, -1.33646324e-01f, -1.45390138e-01f, -6.98699772e-01f, -6.52176976e-01f, 3.70353460e-01f, 4.63737100e-01f, -4.42206740e-01f, 2.80121386e-01f,
  -3.02651972e-01f, 4.54096854e-01f, 1.36396483e-01f, -1.52658030e-01f, 3.73469323e-01f, 5.15504241e-01f, -5.58817089e-01f, 1.83617063e-02f, -8.47437382e-02f, 5.80775551e-02f,
  1.30848750e-01f, 2.34399568e-02f, 2.36595348e-02f, 1.47692710e-01f, -1.22116305e-01f, -3.69391292e-02f, -3.14472951e-02f, 1.41362056e-01f, -1.63801894e-01f, 7.23270550e-02f,
  -4.03860360e-01f, 4.16118890e-01f, -1.02621228e-01f, 5.26248991e-01f, -2.12356925e-01f, -4.69169289e-01f, 6.44144714e-02f, -9.74283889e-02f, -4.33162153e-01f, 4.47105110e-01f,
  -2.43168429e-01f, -5.90481889e-03f, -4.13560271e-02f, 3.45197350e-01f, -1.32653058e-01f, 9.31225270e-02f, 2.36892074e-01f, 4.01128232e-01f, -3.29890102e-01f, 1.62063017e-01f,
  -4.60815392e-02f, -3.51099819e-02f, 1.57507911e-01f, 8.65631849e-02f, 1.69444516e-01f, -9.56600457e-02f, -1.84775621e-01f, -4.05722558e-01f, -1.63177580e-01f, -2.50847787e-01f,
  -3.38468403e-01f, -3.16562615e-02f, -3.42159212e-01f, 5.80919564e-01f, -3.35290805e-02f, 5.44146001e-01f, -1.35223538e-01f, -6.35744810e-01f, -1.48130342e-01f, -5.06849475e-02f,
  -5.79965293e-01f, 5.02120316e-01f, -2.48421375e-02f, 2.85326485e-02f, 5.19062541e-02f, 4.18361783e-01f, -4.24665399e-02f, 1.08162820e-01f, 7.77291730e-02f, 4.80035275e-01f,
  -9.28241462e-02f, 3.38117808e-01f, 5.47522962e-01f, 2.32953399e-01f, 3.33990484e-01f, 1.70813665e-01f, 4.44081545e-01f, 4.52040322e-02f, 1.74298674e-01f, 1.95853814e-01f,
  2.73836493e-01f, 5.18514633e-01f, 4.77315664e-01f, 3.32111984e-01f, 2.14387430e-03f, -1.22348458e-01f, 6.87177360e-01f, -1.88903198e-01f, 2.21882552e-01f, 3.83247554e-01f,
  -1.61852747e-01f, -1.21751718e-01f, -2.20007315e-01f, -6.13205969e-01f, -7.49648392e-01f, 5.39227068e-01f, 3.95294011e-01f, 8.93773139e-02f, 3.06592435e-01f, -5.38425028e-01f,
  3.78632359e-02f, -1.40097454e-01f, 4.77243751e-01f, 4.35070872e-01f, 2.01916561e-01f, 4.03588057e-01f, -8.27156231e-02f, 5.89058222e-03f, -2.82706693e-02f, 1.04713388e-01f,
  1.59106433e-01f, 3.66918087e-01f, 3.73817056e-01f, -3.76983150e-03f, 2.00768307e-01f, 4.12130326e-01f, -2.47174144e-01f, -3.18789184e-01f, -7.37417817e-01f, -2.31052577e-01f,
  5.76625049e-01f, 4.28799152e-01f, 4.28195775e-01f, -1.98224224e-02f, 4.18413073e-01f, -2.44323388e-01f, 4.61463988e-01f, 3.56866866e-01f, 2.78548121e-01f, -3.74822393e-02f,
  4.78875995e-01f, 5.74105144e-01f, 2.50661612e-01f, 1.87946722e-01f, 2.16409400e-01f, -1.60665691e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  4.14405644e-01f, 2.94244587e-01f, 2.61821210e-01f, 3.80960077e-01f, 4.44893911e-02f, -1.01456411e-01f, 2.23470196e-01f, 2.40276635e-01f
};

// L3_fan_Wp (Shape: 12 x 32)
const int L3_fan_Wp_rows = 12;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  4.98642102e-02f, -2.12412309e-02f, -1.51027024e-01f, 2.02898875e-01f, 9.36621949e-02f, 3.13004285e-01f, -1.30727142e-01f, -2.42289379e-01f, 7.17338994e-02f, 2.91561186e-01f,
  2.27640588e-02f, -9.76074301e-03f, -2.84415692e-01f, 3.77950341e-01f, 2.67186701e-01f, -1.71529427e-01f, -1.82082102e-01f, -7.93778300e-02f, 6.68787807e-02f, 1.15822814e-01f,
  -2.16393203e-01f, 1.47357762e-01f, -2.36578405e-01f, -2.10490644e-01f, 9.78140160e-02f, -5.69326915e-02f, -5.07219741e-03f, -1.36246026e-01f, 1.97525799e-01f, -6.01508468e-02f,
  1.84464112e-01f, -2.73049861e-01f, 2.97203362e-01f, 9.78553072e-02f, -2.08094031e-01f, -5.93082272e-02f, 7.24172965e-03f, 3.37759405e-01f, -1.46063894e-01f, 3.10355812e-01f,
  -1.87669963e-01f, 6.93855733e-02f, 3.78330648e-02f, 3.15310135e-02f, -4.14124697e-01f, -4.94272292e-01f, -1.36029609e-02f, 7.49772117e-02f, 5.05930185e-02f, 3.77978794e-02f,
  1.51379973e-01f, -2.07926363e-01f, 2.17673331e-01f, -1.15403406e-01f, -2.13506132e-01f, -1.21213414e-01f, 3.34250815e-02f, -1.80485353e-01f, 2.00423241e-01f, 4.08506766e-03f,
  1.41943142e-01f, -1.15558423e-01f, -2.27625936e-01f, 6.08108565e-02f, -4.93873172e-02f, 8.30359459e-02f, 3.41783553e-01f, 9.93012860e-02f, 9.94618610e-02f, 1.51412115e-01f,
  7.90930688e-02f, -3.38623486e-02f, 2.02765688e-02f, -1.32619217e-01f, 1.97099641e-01f, 1.29752904e-01f, 4.72508103e-01f, 1.14349663e-01f, -8.88620988e-02f, -4.37025353e-02f,
  1.68952316e-01f, 1.46134630e-01f, 3.21921676e-01f, 6.63148016e-02f, -1.73167139e-02f, -3.15559775e-01f, -8.03225785e-02f, 2.42160931e-01f, -4.74889912e-02f, 9.33851972e-02f,
  -2.24110872e-01f, 2.63697118e-01f, -3.30519117e-02f, -1.73477009e-01f, 3.12269777e-02f, 1.85135394e-01f, 6.10104129e-02f, -7.82205462e-02f, 1.49594590e-01f, 5.35884202e-02f,
  1.40390992e-01f, -1.33625925e-01f, 1.40724272e-01f, 1.93545550e-01f, -2.44854465e-01f, 8.67273435e-02f, 4.77898978e-02f, -1.17779478e-01f, 5.35866439e-01f, 3.45684856e-01f,
  1.07868269e-01f, 1.02753170e-01f, 1.73411980e-01f, 4.40447360e-01f, 2.05135703e-01f, -1.34692341e-01f, -2.03310922e-01f, -2.66092956e-01f, 3.99404541e-02f, 3.61439347e-01f,
  -1.73339397e-01f, 1.42168686e-01f, -1.89601704e-01f, -4.12282050e-02f, -9.42306146e-02f, 1.48996487e-01f, 1.88768521e-01f, 1.11092277e-01f, 6.68714121e-02f, -9.06600282e-02f,
  -1.47314116e-01f, 3.10186118e-01f, 4.61633205e-02f, -5.51929288e-02f, 1.31267309e-01f, -1.74236238e-01f, -1.86379358e-01f, -3.45723689e-01f, 9.26911011e-02f, 8.93580765e-02f,
  -7.92460889e-02f, 2.44668037e-01f, -4.65673864e-01f, -4.66445312e-02f, -1.27686068e-01f, -2.49862343e-01f, -6.04074486e-02f, 1.91240385e-02f, 3.50971252e-01f, -1.41926035e-01f,
  6.86297491e-02f, -8.94598663e-02f, 1.15319945e-01f, 6.00688234e-02f, 2.31431976e-01f, 1.25861883e-01f, 3.88233028e-02f, -9.50263739e-02f, -6.60178140e-02f, -3.48500878e-01f,
  4.49695960e-02f, -3.46386037e-03f, -1.35096833e-01f, -3.72267999e-02f, 8.00324157e-02f, 2.11868525e-01f, -1.85987949e-01f, 3.14307094e-01f, -1.75626092e-02f, 3.97500806e-02f,
  3.89922298e-02f, 4.54400070e-02f, -1.58146825e-02f, -4.51177955e-01f, -9.79652628e-03f, 1.55234546e-03f, 7.85252731e-03f, -7.24575371e-02f, 3.31503749e-01f, -2.16131002e-01f,
  -6.27212673e-02f, -2.40882441e-01f, 2.32398132e-04f, 1.56381771e-01f, -2.23090164e-02f, -8.38866010e-02f, 3.35477479e-02f, 3.25343430e-01f, 1.18086785e-02f, 4.59156968e-02f,
  -5.85594960e-02f, -3.47963050e-02f, -2.69656837e-01f, -2.66094685e-01f, -2.26735458e-01f, -1.00799419e-01f, -2.36474529e-01f, -2.61206567e-01f, 4.55178395e-02f, -4.71276827e-02f,
  -1.76594332e-01f, -2.48607129e-01f, 8.93410966e-02f, 2.14876562e-01f, 3.45740765e-01f, 7.97045007e-02f, -9.54974368e-02f, 1.61989033e-01f, -2.24116400e-01f, 5.03674150e-01f,
  -1.71652257e-01f, -8.10521096e-03f, -1.37567937e-01f, -1.37037784e-01f, 2.67144769e-01f, 1.90477625e-01f, -1.88777760e-01f, -1.78246386e-02f, -8.32086727e-02f, 1.36350170e-01f,
  1.22500144e-01f, 1.53386980e-01f, -1.07514225e-01f, 1.07846849e-01f, -7.83533081e-02f, -1.31677553e-01f, 5.42616695e-02f, -1.84124932e-02f, 3.15693989e-02f, 2.65540052e-02f,
  3.29476260e-02f, -1.25909835e-01f, 8.85812789e-02f, -3.23449890e-03f, -7.53953531e-02f, 1.10159941e-01f, -5.63341044e-02f, -4.08439368e-01f, -3.28028768e-01f, 3.16536538e-02f,
  1.66861385e-01f, -1.93289176e-01f, -1.18912786e-01f, 1.75491840e-01f, 2.51546443e-01f, 4.64663178e-01f, 6.41678795e-02f, -1.44874945e-01f, 9.57090333e-02f, 1.63317919e-01f,
  1.47945523e-01f, -1.39483213e-01f, -7.66368061e-02f, -2.33466495e-02f, -2.30178475e-01f, 9.57662091e-02f, 9.81486216e-02f, -7.62567073e-02f, 1.46468610e-01f, -3.01631868e-01f,
  6.12929929e-03f, 8.14174637e-02f, -4.95032705e-02f, 1.73543382e-03f, -2.06610203e-01f, -1.42285256e-02f, -1.99364036e-01f, -2.37545133e-01f, -2.47544497e-01f, -1.04334548e-01f,
  2.56171107e-01f, 4.76655848e-02f, 1.12941049e-01f, -2.62697954e-02f, -1.98249936e-01f, 2.42515299e-02f, 1.58418566e-01f, 1.99539229e-01f, 9.33983102e-02f, -3.60035509e-01f,
  1.33520544e-01f, 6.85161948e-02f, 7.84222856e-02f, -3.43393296e-01f, -2.90329576e-01f, -6.58582672e-02f, 1.04011394e-01f, 6.86087587e-04f, 1.44759454e-02f, 1.19272813e-01f,
  1.65649988e-02f, 1.72378182e-01f, -1.20137945e-01f, 7.50143304e-02f, 1.13770599e-02f, -1.06218264e-01f, -3.44752342e-01f, -3.00242845e-02f, 7.55810365e-02f, 7.77372196e-02f,
  2.97314227e-01f, 1.86393261e-01f, 3.28248650e-01f, -7.00534880e-02f, 6.68270141e-02f, 5.37938118e-01f, 3.29756886e-01f, -1.49687231e-02f, -2.70024657e-01f, -2.71579266e-01f,
  -1.11722626e-01f, 2.98581153e-01f, -1.09059095e-01f, 6.62358627e-02f, -2.18231753e-01f, 2.08658054e-01f, 9.43820104e-02f, 2.92831082e-02f, 5.55466413e-02f, -6.65661786e-03f,
  -5.24189556e-03f, -1.29493505e-01f, -2.86656655e-02f, 2.29440480e-01f, -1.78039089e-01f, -6.29366636e-02f, 1.44346073e-01f, 6.76411018e-02f, -1.47859797e-01f, -3.88741851e-01f,
  4.47235033e-02f, 3.40595990e-01f, -2.34023184e-01f, 9.28894728e-02f, -3.23730439e-01f, 1.11212209e-02f, 2.61275508e-02f, -3.65844816e-01f, -2.58566231e-01f, 8.30595717e-02f,
  7.47100487e-02f, -4.20798473e-02f, 3.78459513e-01f, 1.41433412e-02f, 4.37483750e-02f, -1.14948981e-01f, -2.99991041e-01f, 1.81508273e-01f, 2.70585716e-01f, 1.33091152e-01f,
  1.88514262e-01f, 1.04691587e-01f, -2.75181949e-01f, 1.95933193e-01f, 1.23345986e-01f, -2.28440180e-01f, 1.11435600e-01f, 1.43966705e-01f, 6.75686598e-02f, 1.10085480e-01f,
  1.83597878e-01f, 2.31930584e-01f, -7.28150383e-02f, 1.39833823e-01f, -1.59372166e-01f, -5.14327049e-01f, 4.49250191e-02f, 8.42982307e-02f, -8.40026140e-03f, -1.88187882e-01f,
  2.23259106e-02f, 2.05480978e-01f, -7.19903782e-02f, -7.22743496e-02f, -3.79272103e-02f, 1.78999469e-01f, -2.23690137e-01f, 1.04822136e-01f, 1.12600945e-01f, 2.16474622e-01f,
  2.37367183e-01f, 5.25822639e-02f, -1.07958317e-01f, -1.07736483e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 32)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  1.08209074e-01f, 9.08693001e-02f, -1.21138290e-01f, 3.16057384e-01f, 3.49820435e-01f, 2.65407413e-01f, 9.70756263e-02f, -1.20468721e-01f, 1.80287376e-01f, -3.01576942e-01f,
  2.68489361e-01f, -3.63856927e-02f, -8.02968681e-01f, 3.64598893e-02f, -6.39159381e-02f, -1.38812870e-01f, 4.85846728e-01f, 2.19376991e-03f, -3.93514961e-01f, 3.19447547e-01f,
  -1.60786882e-01f, 3.64205986e-01f, -3.75435770e-01f, -8.42137039e-01f, 9.16882336e-01f, -1.26243398e-01f, 7.36717641e-01f, -4.76975530e-01f, -3.76485705e-01f, -1.45072892e-01f,
  7.99230814e-01f, 1.72466159e-01f, 4.55402672e-01f, 5.20384789e-01f, 3.44499052e-01f, 4.70480502e-01f, 3.78209114e-01f, 3.22000414e-01f, 1.69505134e-01f, 3.12386423e-01f,
  -6.57790542e-01f, -7.49010546e-03f, 3.77775222e-01f, -6.05842292e-01f, 1.63652599e-01f, 9.35188949e-01f, 2.92501509e-01f, -6.23442650e-01f, -5.18729270e-01f, 5.18505514e-01f,
  2.46359363e-01f, 9.27068144e-02f, -3.64483714e-01f, -7.49353051e-01f, -5.59643269e-01f, 3.25962365e-01f, 4.21310633e-01f, 2.89751012e-02f, -2.13856325e-01f, 4.29537088e-01f,
  -4.42321390e-01f, -5.34937263e-01f, 7.03338563e-01f, -7.25634582e-03f, 5.58412135e-01f, 3.40104371e-01f, -4.28886652e-01f, 6.11960106e-02f, 4.42169905e-02f, 5.18551350e-01f,
  2.87431091e-01f, 3.11240405e-01f, -2.71551460e-01f, 3.47263277e-01f, -3.62535387e-01f, -3.49801570e-01f, -5.24320602e-01f, -4.90710586e-01f, -5.27306795e-02f, 1.93948776e-01f,
  -3.08680534e-01f, 5.36023140e-01f, 2.31016353e-01f, -1.75067082e-01f, -2.96776712e-01f, 7.86096882e-03f, -5.20549119e-01f, -1.69946268e-01f, 3.00675273e-01f, -1.99641436e-01f,
  7.02996492e-01f, 3.94273043e-01f, 4.71204877e-01f, 8.83358240e-01f, 1.30566910e-01f, -3.71311009e-01f, 2.40377963e-01f, 1.53120011e-01f, 6.96573555e-01f, 5.67678332e-01f,
  4.93763328e-01f, 2.11585283e-01f, -1.46803081e-01f, 4.67866689e-01f, 3.25007826e-01f, 4.06514853e-01f, 4.86128479e-01f, -2.24468604e-01f, -4.32856709e-01f, 2.38605425e-01f,
  7.27600679e-02f, -7.18056858e-01f, 9.76503491e-02f, -4.49781299e-01f, 6.31775796e-01f, 1.67468950e-01f, -3.88948858e-01f, -1.15292899e-01f, -5.98338544e-01f, 7.37843633e-01f,
  -3.83309364e-01f, -1.61069095e-01f, 2.37954617e-01f, 6.27582908e-01f, -7.96933379e-03f, -2.73179680e-01f, 5.87000787e-01f, 2.93435398e-02f, 1.81824535e-01f, -3.35796386e-01f,
  -3.69332612e-01f, -5.65087438e-01f, 3.36310089e-01f, -7.59421110e-01f, 1.19349450e-01f, 4.76069242e-01f, -5.44751108e-01f, -5.49398482e-01f, 3.11066538e-01f, -2.30212584e-01f,
  7.33915448e-01f, 5.04622161e-01f, -8.47226977e-01f, 9.85732973e-02f, -6.43433213e-01f, 3.65926206e-01f, -9.05398369e-01f, -4.41113472e-01f, 2.84366190e-01f, -3.30858886e-01f,
  1.77136540e-01f, 6.44452095e-01f, 3.99414241e-01f, 3.41021508e-01f, 1.45600811e-02f, 2.63968349e-01f, 1.32972121e-01f, -2.12408393e-03f, -6.41434714e-02f, 3.69794428e-01f,
  3.78899835e-02f, -9.29861814e-02f, 6.98251501e-02f, -8.18610564e-02f, 2.95816779e-01f, 2.74994016e-01f, 8.36732239e-03f, 2.60275871e-01f, 2.59168744e-01f, 6.60613226e-03f,
  3.89995337e-01f, -9.78016555e-02f, -5.99892326e-02f, -9.40486789e-01f, -2.71950692e-01f, 2.12426469e-01f, 7.63379991e-01f, 8.90695825e-02f, 4.68151033e-01f, 4.07163143e-01f,
  -2.30019435e-01f, 2.21606359e-01f, -4.43462700e-01f, 3.80524218e-01f, -1.90813452e-01f, 4.53837752e-01f, 5.12295127e-01f, 4.29456085e-01f, -1.00886464e-01f, -4.25415725e-01f,
  -3.30104887e-01f, 5.51213980e-01f, -1.13895021e-01f, 6.91958293e-02f, 2.29433373e-01f, -9.93289649e-02f, -9.75121185e-03f, 3.17053109e-01f, 2.65682004e-02f, 1.32689729e-01f,
  2.71558791e-01f, 9.74454805e-02f, -3.87418852e-03f, -2.95488447e-01f, 6.09018147e-01f, -7.47805059e-01f, 4.77854967e-01f, 5.34094751e-01f, 2.85846502e-01f, -1.21042076e-02f,
  2.85413861e-01f, 3.54999155e-01f, 3.16467583e-01f, -3.21777940e-01f, 3.53055507e-01f, 2.51511127e-01f, -2.32920647e-01f, 6.99070156e-01f, 1.49901226e-01f, 1.31417021e-01f,
  -1.35134840e-02f, -1.32701665e-01f, -1.73365101e-01f, 4.80426013e-01f, 1.90327078e-01f, 3.30618948e-01f, 3.80397797e-01f, 1.09166823e-01f, -1.32022128e-01f, 3.48861277e-01f,
  2.70677894e-01f, -3.78727555e-01f, 3.40121001e-01f, 2.22219095e-01f, -1.36168778e-01f, 4.07865494e-01f, 3.45052332e-02f, -4.57284242e-01f, 8.04290056e-01f, 3.80497903e-01f,
  5.87079346e-01f, 2.66511828e-01f, -1.53084591e-01f, 4.93716300e-01f, -1.01336399e-02f, 4.85254765e-01f, 5.67984402e-01f, -1.40889406e-01f, 5.07914051e-02f, 5.99423826e-01f,
  -3.83579463e-01f, -2.98802972e-01f, -4.60569978e-01f, -7.54048228e-01f, 4.49228138e-01f, 6.64389610e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  3.62000316e-01f, 2.14895234e-01f, 8.20333883e-03f, 3.85612726e-01f, 1.63427547e-01f, 3.07063013e-01f, 2.86454380e-01f, 3.83809090e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -1.46764040e-01f, -4.45238709e-01f, 1.24858342e-01f, -2.21310526e-01f, 1.39328450e-01f, -1.04591638e-01f, 2.60990739e-01f, 2.35275239e-01f, -2.76412535e-03f, 2.83102840e-01f,
  -2.90659368e-01f, -2.22170919e-01f, 2.31308788e-01f, -1.85334042e-01f, 1.55394271e-01f, 4.47095394e-01f, -3.31922770e-01f, -3.73037338e-01f, -3.04917961e-01f, -4.51123295e-03f,
  4.07879651e-01f, 3.39169472e-01f, 3.31069738e-01f, 2.60543134e-02f, 2.49537066e-01f, 2.80334264e-01f, -9.33852673e-01f, -2.44619429e-01f, 7.63849448e-03f, -3.81041586e-01f,
  -7.88410664e-01f, 1.36122689e-01f, 2.08729014e-01f, 2.67940257e-02f, -3.31128657e-01f, -2.00227246e-01f, -9.12266672e-02f, 2.49719381e-01f, 1.01317078e-01f, 1.70779601e-02f,
  -3.75412434e-01f, -9.41450447e-02f, -2.58092374e-01f, 1.88178524e-01f, -4.95001137e-01f, -2.70907342e-01f, 2.33213007e-01f, 2.53605574e-01f, 5.08630395e-01f, 2.95721829e-01f,
  5.97539485e-01f, -3.28737050e-01f, -3.29541922e-01f, 2.79094219e-01f, 1.77572310e-01f, -1.72462747e-01f, -5.99336803e-01f, 4.81952369e-01f, -2.20679715e-01f, 1.12517685e-01f,
  7.54831851e-01f, -3.73659074e-01f, -4.41693157e-01f, -3.63838553e-01f, -2.22583547e-01f, 2.19691753e-01f, -3.21677059e-01f, -2.42070913e-01f, 1.67779461e-01f, -3.34613863e-03f,
  -4.19561058e-01f, 2.35845253e-01f, -1.15489535e-01f, 1.25888914e-01f, -9.61577147e-02f, -4.73691374e-01f, -4.14787158e-02f, -2.78096139e-01f, 2.66655713e-01f, 3.60148787e-01f,
  -3.52981299e-01f, 5.17188489e-01f, 1.70441464e-01f, 3.38883668e-01f, -2.10072130e-01f, 2.88128674e-01f, 9.20749232e-02f, 2.39970163e-01f, -9.74428535e-01f, -7.23040640e-01f,
  -9.70417708e-02f, -5.95855534e-01f, 7.80924380e-01f, 2.67647892e-01f, 2.14936987e-01f, -3.08821499e-01f, -4.34588850e-01f, 1.91203251e-01f, 1.15528427e-01f, 5.46084307e-02f,
  -3.24864119e-01f, 1.02698617e-01f, -3.73120159e-01f, 2.84219921e-01f, -1.05100811e-01f, -3.59086961e-01f, 1.31653771e-01f, 1.27777047e-02f, 2.49027327e-01f, -5.23466408e-01f,
  -3.48373115e-01f, -4.67457563e-01f, 4.03063297e-01f, -5.05878389e-01f, 2.87562072e-01f, 9.57278833e-02f, 2.51295447e-01f, -2.56126314e-01f, -5.29214919e-01f, -3.72330964e-01f,
  3.28500837e-01f, 3.18263739e-01f, -2.29630023e-01f, 2.36541778e-02f, -1.64808989e-01f, -6.36944115e-01f, -4.40495640e-01f, -7.57368207e-01f, 3.84861767e-01f, 4.21884626e-01f,
  3.63980711e-01f, 3.30256283e-01f, 3.15967023e-01f, 1.92551672e-01f, -7.12617561e-02f, -2.15063915e-01f, -2.58775592e-01f, 6.05686530e-02f, -2.23463532e-02f, 1.86292946e-01f,
  -4.59739029e-01f, -1.56431019e-01f, 1.70877412e-01f, -2.17647418e-01f, -2.86545396e-01f, -2.05493331e-01f, -4.05965120e-01f, 4.31644082e-01f, 2.79016584e-01f, -5.86405933e-01f,
  3.11820865e-01f, -3.67846966e-01f, 2.70156413e-01f, -5.00962019e-01f, -4.00320202e-01f, -3.65178257e-01f, -5.66265821e-01f, 1.03231845e-02f, 1.41093463e-01f, 3.68886948e-01f,
  1.90623239e-01f, 1.28414795e-01f, -1.96377665e-01f, 1.31516978e-01f, 2.41780486e-02f, 1.67037293e-01f, -2.15869024e-01f, -2.11271405e-01f, 3.80008787e-01f, -1.35417357e-01f,
  7.47495517e-02f, 4.15506303e-01f, 4.41980809e-01f, -6.21480681e-02f, 4.89103466e-01f, 4.02469635e-01f, -5.80926299e-01f, 1.88005254e-01f, -4.04484570e-01f, -3.91769528e-01f,
  -2.59596556e-01f, 4.76073474e-01f, -9.53179449e-02f, 2.19617665e-01f, -1.28586262e-01f, 5.35875082e-01f, -2.48844065e-02f, 4.58632231e-01f, -1.07115519e+00f, -1.14114255e-01f,
  -2.84435719e-01f, -1.84170902e-01f, -7.59964213e-02f, 1.09622747e-01f, 9.03050415e-03f, -3.83670807e-01f, -1.13149203e-01f, -6.31043836e-02f, 2.98165888e-01f, 3.90726477e-01f,
  -5.72406538e-02f, -4.64364856e-01f, 2.15727940e-01f, -2.07932927e-02f, -5.64956248e-01f, -2.66550422e-01f, -3.66869867e-01f, -1.39841422e-01f, -4.20998812e-01f, 2.99810678e-01f,
  3.81298363e-01f, -3.05989366e-02f, -3.87770921e-01f, 1.30621985e-01f, 1.22551229e-02f, 2.04166863e-03f, -6.98605239e-01f, 1.81184977e-01f, -4.78813291e-01f, 1.17874026e-01f,
  -4.86022443e-01f, 2.86897928e-01f, 3.53185534e-01f, 8.46935213e-02f, -8.25050995e-02f, -3.08445245e-01f, 1.20633617e-01f, 2.59173393e-01f, 1.60652939e-02f, -3.18829231e-02f,
  1.34585842e-01f, -1.97528228e-01f, -1.07536905e-01f, -1.76093522e-02f, -2.46497706e-01f, -4.55377921e-02f, -2.41001248e-01f, 3.20823461e-01f, -3.40613395e-01f, -9.60824862e-02f,
  1.75209075e-01f, -4.88591343e-02f, 6.96408853e-04f, 2.56189644e-01f, 1.91162407e-01f, -2.28975177e-01f, -3.43730301e-01f, -2.36088321e-01f, 3.13569270e-02f, -1.54986262e-01f,
  -9.73386690e-02f, -4.84506488e-01f, 5.16760409e-01f, 1.51840240e-01f, -1.86853066e-01f, -5.64933538e-01f, 8.20871517e-02f, -7.02889264e-02f, 1.56180635e-01f, 2.42907122e-01f,
  2.74008308e-02f, -3.06333899e-01f, 7.75534809e-02f, -1.65428996e-01f, -2.68262655e-01f, -1.00270420e-01f, 7.50378668e-02f, -3.50286275e-01f, 1.58590466e-01f, 2.91280389e-01f,
  -2.10440442e-01f, -2.00571418e-02f, 2.79029191e-01f, -6.95477650e-02f, 4.92147863e-01f, -2.73853362e-01f, 6.07411116e-02f, 2.95569450e-01f, 3.15360948e-02f, 1.05436131e-01f,
  -6.35570168e-01f, -1.57828957e-01f, 6.85907185e-01f, -3.61979865e-02f, -1.25867724e-01f, -4.64545459e-01f, -8.20524022e-02f, -3.38270724e-01f, -1.66660294e-01f, -2.11586863e-01f,
  -4.18439031e-01f, -3.62716258e-01f, -1.44941628e-01f, -1.76970437e-01f, 1.12781808e-01f, -3.69452417e-01f, 2.53673643e-01f, 3.31888437e-01f, 1.51147753e-01f, -4.35346598e-03f,
  -1.10841885e-01f, -1.63797528e-01f, -1.39185134e-02f, -5.41085750e-02f, 1.43275214e-02f, -5.63619912e-01f, 5.21523297e-01f, 8.61618742e-02f, 4.88310874e-01f, 2.83211321e-01f,
  -8.55468884e-02f, -2.50977352e-02f, -5.90625703e-01f, -8.27161193e-01f, -1.32893175e-01f, -7.55936146e-01f, 2.05506640e-03f, 6.64498955e-02f, 4.37732965e-01f, 4.55828726e-01f,
  -3.95211279e-02f, 5.78597635e-02f, -1.44890085e-01f, -3.49482954e-01f, -1.39886931e-01f, 2.61028707e-01f, -4.61249724e-02f, -7.64633045e-02f, 3.63485068e-01f, -3.78300026e-02f,
  2.95648128e-02f, 1.13387950e-01f, 2.08182469e-01f, 4.81143326e-01f, 1.02710994e-02f, -1.63172647e-01f, 8.94336477e-02f, -1.51305310e-02f, -1.80253208e-01f, 3.15773696e-01f,
  1.44533142e-01f, -3.67030874e-02f, -4.21218485e-01f, 2.14015752e-01f, 3.30908388e-01f, -8.40752125e-01f, 3.83869857e-01f, -5.04183769e-01f, -7.90450156e-01f, 9.00985301e-02f,
  -6.56069815e-01f, -3.66970688e-01f, 2.28713110e-01f, 1.66140169e-01f, 4.29773092e-01f, -1.32214939e-02f, 2.62001008e-01f, -9.69376937e-02f, 1.04544908e-01f, 2.55712748e-01f,
  -1.31760314e-01f, 4.73664343e-01f, 3.55353981e-01f, -2.02832639e-01f, 1.64656401e-01f, 2.51448601e-01f, 1.35607228e-01f, -6.34091556e-01f, 3.42394352e-01f, 4.04067129e-01f,
  -3.50634754e-01f, 2.94292778e-01f, -4.93918896e-01f, -3.33273858e-01f, -1.31412996e-02f, 1.78876728e-01f, -1.68077007e-01f, -8.66119742e-01f, 1.67791862e-02f, 7.05502331e-01f,
  -6.22522473e-01f, 4.27849859e-01f, -2.26209760e-01f, -5.14296055e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  7.56900311e-02f, 7.30859414e-02f, -7.87484869e-02f, 5.08274399e-02f, 2.82666122e-04f, -1.60638049e-01f, -1.71596520e-02f, -1.75571069e-02f, 2.32734103e-02f, -2.38333881e-01f,
  1.33281842e-01f, -7.54235219e-03f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    