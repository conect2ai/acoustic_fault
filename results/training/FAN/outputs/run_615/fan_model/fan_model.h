/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.95311978e-01f, 8.54460970e-02f, -2.81619370e-01f, -5.82977906e-02f, -3.01016510e-01f, -1.70276493e-01f, -1.25352889e-01f, -1.03692994e-01f, 3.23683843e-02f, -1.93248484e-02f,
  1.06025912e-01f, 2.69465894e-01f, 2.07403973e-01f, 1.41193599e-01f, -4.30412628e-02f, -1.33235276e-01f, -3.40787709e-01f, -2.75028408e-01f, -1.42053992e-01f, -2.16780528e-01f,
  1.43722091e-02f, 3.12889516e-02f, 4.36751805e-02f, 6.46787509e-02f, -2.01835960e-01f, 1.01157576e-01f, 9.27521363e-02f, -1.09622002e-01f, 1.02101170e-01f, -2.69233465e-01f,
  6.63565099e-02f, -2.68936425e-01f, -9.72219631e-02f, -5.03436662e-02f, 3.54596339e-02f, 4.03405651e-02f, 9.73467529e-03f, -1.07982256e-01f, 8.23162124e-03f, 5.24193458e-02f,
  -6.20835572e-02f, 6.28909767e-02f, -1.01270758e-01f, -3.79335284e-02f, -8.35035369e-02f, -9.97017417e-03f, 1.17310271e-01f, -7.25858957e-02f, 7.86997005e-02f, -1.26860226e-02f,
  -3.87294851e-02f, -1.80270165e-01f, -7.93106332e-02f, -2.80417781e-02f, 7.49050756e-04f, -8.18801001e-02f, -7.37687722e-02f, 3.07277106e-02f, 7.30141699e-02f, -2.14512702e-02f,
  1.49784833e-01f, 1.02023922e-01f, 1.36048824e-01f, 4.96095829e-02f, 1.14151523e-01f, 3.46280485e-02f, -3.35666053e-02f, -2.70940317e-03f, 8.72518867e-02f, -3.46467085e-03f,
  1.04180826e-02f, -1.47926016e-02f, 5.64887859e-02f, 7.02232793e-02f, 9.45167840e-02f, -5.82102872e-02f, 1.10584567e-03f, 3.97264622e-02f, 2.76184473e-02f, -3.37182693e-02f,
  -5.23006059e-02f, -7.34011817e-04f, 1.53042600e-01f, -8.01475253e-03f, -7.25342613e-03f, -4.83907722e-02f, 1.31428055e-02f, -6.48519620e-02f, 5.49593866e-02f, -3.34793329e-02f,
  4.63414252e-01f, -8.39164555e-02f, -7.43729696e-02f, -1.08742500e-02f, -3.36039811e-02f, -1.11303749e-02f, -4.92105149e-02f, -2.10328642e-02f, 6.12321869e-02f, -2.65524117e-03f,
  -2.47765891e-02f, 2.95518618e-02f, -1.81277655e-02f, 9.93306190e-02f, -1.47661433e-01f, -1.11231848e-03f, 1.43848488e-03f, -5.67142330e-02f, -6.13991320e-02f, 4.39726561e-03f,
  6.34978712e-02f, -4.13029082e-02f, 5.25276735e-02f, 5.08413613e-02f, -1.31067866e-02f, 1.17981900e-03f, 6.80670794e-03f, -8.08838531e-02f, -4.80182376e-03f, 1.95378125e-01f,
  -1.63854301e-01f, 1.29495889e-01f, 3.09923589e-01f, -1.58974633e-01f, 1.41422883e-01f, -1.82131901e-01f, -2.22455755e-01f, -2.24803090e-01f, -7.10815340e-02f, 5.65214409e-03f,
  5.97338229e-02f, -1.00674890e-01f, -4.33968119e-02f, -1.57582566e-01f, -2.09991887e-01f, 2.68364325e-02f, 8.26937556e-02f, -4.23503518e-02f, -1.88777938e-01f, -2.23353744e-01f,
  -2.81441331e-01f, -1.72195002e-01f, -1.07281268e-01f, 2.02679634e-02f, 1.57976761e-01f, 6.79796189e-02f, 3.82723540e-01f, 1.88309371e-01f, 1.13102421e-01f, 2.02953964e-01f,
  -2.01421250e-02f, 1.22965137e-02f, -3.95159125e-02f, -4.14713733e-02f, 1.00638099e-01f, 1.79677662e-02f, 4.51408103e-02f, 4.95729484e-02f, 2.61746142e-02f, -3.54425870e-02f,
  2.52528712e-02f, -1.18738450e-02f, -4.99003045e-02f, -8.46623257e-02f, -1.34402901e-01f, -1.11937597e-01f, 1.94600113e-02f, -3.44486795e-02f, 1.01213060e-01f, -3.11137550e-02f,
  7.09781796e-03f, 4.68533905e-03f, -4.89642983e-03f, -6.35478124e-02f, 1.63276158e-02f, 1.22892112e-01f, -2.28578807e-03f, 7.48718083e-02f, 8.95671099e-02f, -1.50522888e-01f,
  -4.23081219e-02f, -1.36369774e-02f, 7.56369531e-02f, 1.51244896e-02f, 7.75164813e-02f, 4.66242731e-02f, -1.62068941e-02f, 8.55200458e-03f, -5.36994636e-03f, 4.19025049e-02f,
  7.37939030e-02f, -3.48198018e-03f, -4.06518504e-02f, 1.01374522e-01f, 2.61661857e-02f, 6.18076809e-02f, -2.34958082e-02f, -2.18365230e-02f, 5.06361090e-02f, 5.37024215e-02f,
  -9.90456268e-02f, 4.75630313e-02f, 4.81705926e-02f, -1.19905077e-01f, 3.25491652e-02f, 3.99659760e-02f, 7.71430880e-02f, -3.05955932e-02f, 4.76610474e-02f, 6.05666488e-02f,
  -3.47813725e-01f, 3.34594809e-02f, -2.19867513e-01f, -1.18092775e-01f, -4.51836176e-02f, -1.65379718e-02f, 1.76927429e-02f, -2.38681566e-02f, -2.28047301e-03f, -1.31594524e-01f,
  -6.03515096e-02f, -7.75079355e-02f, -9.02165696e-02f, -1.05870530e-01f, -9.64177027e-02f, -8.59344453e-02f, -9.78002548e-02f, -1.49791718e-01f, -8.67812485e-02f, -8.87515992e-02f,
  -9.45548117e-02f, -1.42689005e-01f, -3.36103797e-01f, -2.11753547e-01f, -1.21117517e-01f, -2.14348644e-01f, -1.75032869e-01f, -2.02719733e-01f, -1.55088633e-01f, -3.69885802e-01f,
  3.46321672e-01f, 4.25905168e-01f, -2.33710948e-02f, 1.42471507e-01f, -9.05956421e-03f, 1.75228789e-01f, 4.51639652e-01f, 2.18000367e-01f, 8.51397216e-02f, 2.02330410e-01f,
  -6.41758069e-02f, -5.81365041e-02f, -3.40359397e-02f, 7.47780204e-02f, 6.93308562e-02f, 3.99959058e-01f, 1.76019982e-01f, -1.50413945e-01f, -8.01200941e-02f, -4.10573976e-03f,
  -1.31758749e-02f, 9.77730751e-03f, -1.80134475e-01f, -1.13623478e-01f, 1.81272417e-01f, 1.35118872e-01f, 1.71363547e-01f, 2.95767412e-02f, 1.31702289e-01f, 1.25667155e-01f,
  6.15073480e-02f, 1.73921604e-02f, -2.26674639e-02f, -2.42817868e-02f, -2.69907080e-02f, 6.97687045e-02f, 4.97380123e-02f, 1.44223878e-02f, -1.10762753e-02f, 6.30954951e-02f,
  3.32421958e-02f, -1.98228769e-02f, 7.68455968e-04f, -3.31206433e-02f, 1.52752608e-01f, -8.42511095e-03f, 8.36210474e-02f, -2.35826299e-02f, 1.31707385e-01f, -1.50735053e-04f,
  -9.45528038e-03f, -1.14317089e-01f, 1.37788996e-01f, 1.12330295e-01f, 4.04129885e-02f, -7.37943649e-02f, -1.23076634e-02f, 2.02987462e-01f, 5.15838712e-03f, 3.09261352e-01f,
  9.01565328e-02f, 1.19755846e-02f, -1.67813256e-01f, -2.02004798e-03f, 1.16348770e-02f, 2.88182925e-02f, -1.47866346e-02f, -2.00740285e-02f, -6.13546409e-02f, 1.11645103e-01f,
  5.43201305e-02f, -2.92202625e-02f, -1.28487289e-01f, 1.05572879e-01f, -4.53216806e-02f, -6.55896738e-02f, 2.06187856e-03f, -7.67892674e-02f, -9.70888287e-02f, 7.21014887e-02f,
  4.26162779e-02f, -1.27354753e-03f, 3.42675447e-02f, -6.80976827e-03f, -5.87274544e-02f, -1.17033459e-01f, -1.12306200e-01f, -5.55053055e-02f, -4.52756025e-02f, -4.66405712e-02f,
  4.38682556e-01f, -1.28459558e-01f, 2.10759282e-01f, 1.03748761e-01f, 5.48696220e-02f, 1.25704631e-01f, -6.81295022e-02f, 1.85751259e-01f, -2.13200562e-02f, 6.93487525e-02f,
  -6.64358586e-02f, 4.88181971e-03f, 1.19482487e-01f, 9.99209136e-02f, 2.87971925e-02f, 2.92394236e-02f, 9.73841399e-02f, 3.20447423e-02f, 7.79756904e-02f, 8.47003683e-02f,
  5.55553921e-02f, 2.78812677e-01f, 2.68260211e-01f, 1.78114742e-01f, 2.15960726e-01f, 9.51952860e-02f, 9.69961733e-02f, 1.76435113e-01f, 2.48916313e-01f, 4.98209953e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.00067931e-01f, -6.60877645e-01f, -4.58474606e-02f, -3.14795762e-01f, -3.87943894e-01f, -2.62690219e-03f, -5.40243208e-01f, 5.54733984e-02f, 8.48657116e-02f, -4.83087271e-01f,
  -2.35645369e-01f, 9.06820223e-02f, 1.04414299e-01f, 1.66764423e-01f, 1.12149306e-02f, -5.09400010e-01f, -3.71383697e-01f, 1.29824832e-01f, 5.35909832e-01f, 3.35036963e-01f,
  7.28584975e-02f, -4.35032845e-02f, 3.74551862e-01f, 4.88206327e-01f, -3.13979924e-01f, -1.56194583e-01f, -2.56354541e-01f, -2.91408122e-01f, -1.11192048e-01f, -1.13645470e+00f,
  -2.86079824e-01f, -4.91624326e-02f, 7.62463883e-02f, -9.64829251e-02f, -2.14227185e-01f, 6.62223101e-02f, -8.98543596e-02f, -2.55339723e-02f, 5.86617775e-02f, 4.03765496e-03f,
  -1.71838608e-02f, 7.33021796e-02f, -1.34375364e-01f, 8.24702978e-02f, -2.18818933e-02f, -4.27466929e-02f, 1.15728222e-01f, 1.88047290e-01f, -8.30252543e-02f, 3.04430183e-02f,
  -1.57314360e-01f, -1.81575999e-01f, -2.90834337e-01f, 2.09638283e-01f, 2.91600257e-01f, 4.12124358e-02f, 1.26945123e-01f, 6.84534609e-02f, 4.68632393e-02f, -5.10499716e-01f,
  -1.21914484e-02f, 3.72456461e-02f, -5.85004240e-02f, 7.55563155e-02f, -4.58781421e-02f, 1.38864312e-02f, 3.37496474e-02f, -1.29473463e-01f, 5.51345274e-02f, -1.14319474e-01f,
  9.21771899e-02f, -1.71464026e-01f, 1.22220308e-01f, -2.03924760e-01f, 8.14914703e-02f, -5.89309670e-02f, -5.51984198e-02f, -2.32926523e-03f, 8.50703046e-02f, -4.49748076e-02f,
  -3.88086028e-02f, 1.63801592e-02f, -1.26924008e-01f, 9.26596299e-02f, 1.80495046e-02f, -4.51702401e-02f, -5.81590161e-02f, -2.29638591e-02f, 6.98502213e-02f, 1.75024226e-01f,
  -1.76539823e-01f, 2.00728789e-01f, -2.20561564e-01f, 1.99182630e-02f, -7.52467290e-02f, 1.09194569e-01f, -5.91975972e-02f, 1.47047296e-01f, -1.06967732e-01f, -1.64144300e-03f,
  3.98179665e-02f, 7.68295452e-02f, -4.96653207e-02f, 4.73457947e-02f, 6.42968761e-03f, 1.17198881e-02f, -1.22321889e-01f, -8.33256096e-02f, -2.91290022e-02f, -7.45102167e-02f,
  4.28763554e-02f, -2.32048497e-01f, -2.69369960e-01f, -1.90072477e-01f, -2.44043600e-02f, -1.65863514e-01f, -4.96485457e-02f, -1.83475301e-01f, -1.36592105e-01f, -4.99628901e-01f,
  6.92218304e-01f, 6.99998915e-01f, 2.21810073e-01f, 2.25860730e-01f, -6.86458498e-02f, -4.50321427e-03f, 1.88665703e-01f, -5.50815975e-03f, -1.97488070e-01f, 1.63561016e-01f,
  5.90057932e-02f, -2.03556269e-01f, -6.18146025e-02f, -1.88008413e-01f, 1.28041744e-01f, 1.30986944e-01f, 1.79140404e-01f, 1.05229884e-01f, -1.05362222e-01f, 7.13013411e-02f,
  8.19567684e-03f, 2.55741924e-01f, 1.38987973e-01f, 1.83283672e-01f, 3.43136340e-01f, -3.09737891e-01f, -1.76892467e-02f, 2.63365149e-01f, 1.04799382e-02f, 4.02515918e-01f,
  -9.57082883e-02f, 4.05572027e-01f, -3.51078510e-01f, -6.53323755e-02f, -1.04165323e-01f, 4.78058048e-02f, 7.44297653e-02f, 8.25099722e-02f, -9.61837173e-02f, 6.44110441e-02f,
  2.11594384e-02f, 1.03546329e-01f, 1.81670561e-01f, 4.92916927e-02f, 9.54775438e-02f, 2.24306770e-02f, 2.05473453e-01f, 2.14337260e-01f, -4.04531211e-02f, 1.69352684e-02f,
  1.37865990e-01f, -3.12050451e-02f, -3.66769200e-05f, -6.86409175e-02f, 2.30146244e-01f, -9.66749266e-02f, -1.48190064e-02f, 1.15717739e-01f, -7.68529326e-02f, 2.58318126e-01f,
  -4.44920585e-02f, 9.79827791e-02f, 3.55738704e-03f, 9.98982638e-02f, -1.01824431e-02f, 1.04382308e-02f, 9.25522577e-03f, -5.54085597e-02f, 1.19121879e-01f, 1.05610527e-01f,
  -9.59738530e-03f, 4.66024987e-02f, 4.54928912e-02f, -8.05393234e-03f, -1.08696468e-01f, -1.68257415e-01f, -1.40277091e-02f, 2.95166625e-03f, 2.20945925e-02f, -1.10722698e-01f,
  -3.81412804e-02f, 1.26695810e-02f, -1.09222174e-01f, 2.28231296e-01f, -4.04506624e-02f, -1.85376406e-02f, 9.10363719e-02f, 1.69567820e-02f, 5.87400869e-02f, 7.62120038e-02f,
  -5.72903395e-01f, -1.83734268e-01f, 4.80313227e-02f, -4.04880159e-02f, 1.48597118e-02f, -1.06653355e-01f, 5.31248488e-02f, -1.20627217e-01f, -1.57098323e-01f, -1.43901780e-01f,
  -5.59459776e-02f, -9.09646749e-02f, 5.26483804e-02f, 3.30875590e-02f, 2.71000303e-02f, -1.49677828e-01f, -2.99586710e-02f, -8.19781050e-02f, -1.69826552e-01f, -9.09342617e-02f,
  1.66015536e-01f, -2.02805638e-01f, -2.96058476e-01f, -1.34649932e-01f, -8.68900344e-02f, -3.89298856e-01f, -1.95586666e-01f, -2.21830085e-01f, -4.16780949e-01f, -3.80356871e-02f,
  1.13715243e+00f, -2.99532682e-01f, -7.22714365e-01f, 2.86706954e-01f, -4.72157836e-01f, 8.02312046e-02f, -4.37106073e-01f, 2.68508904e-02f, 2.89634794e-01f, -3.87486905e-01f,
  -1.84806690e-01f, 2.78615952e-01f, 1.05679847e-01f, -5.91142029e-02f, 2.08725289e-01f, -5.69405317e-01f, -4.33791965e-01f, 2.47708447e-02f, 1.04236074e-01f, -3.93373929e-02f,
  -5.35542592e-02f, 6.39037639e-02f, 2.15287402e-01f, 1.03997342e-01f, -3.36305350e-01f, 4.05211560e-02f, -5.08441865e-01f, 2.58335192e-02f, -2.21654639e-01f, -4.30903792e-01f,
  -2.45842129e-01f, 1.09862024e-02f, 1.41355293e-02f, 1.59343690e-01f, -5.21080121e-02f, 7.31766745e-02f, 4.29128436e-03f, -7.35269189e-02f, 5.26508316e-02f, 1.56832207e-02f,
  7.18400255e-02f, -2.31573116e-02f, 1.71392411e-01f, -7.50930142e-03f, -6.68455362e-02f, 4.55252714e-02f, 1.27140442e-02f, 5.87814972e-02f, 5.75187579e-02f, -1.73664391e-01f,
  -1.99593958e-02f, -3.82109662e-03f, -5.82174063e-02f, -4.07338217e-02f, 5.05653583e-02f, 5.55781536e-02f, -2.52091646e-01f, -1.81339204e-03f, -1.04594126e-01f, -2.72756994e-01f,
  -7.26910457e-02f, 1.06446203e-02f, -6.25588447e-02f, 3.27842892e-04f, 4.14668135e-02f, -1.94496736e-02f, 4.49324735e-02f, -9.60469991e-02f, -1.09572290e-02f, 2.38994453e-02f,
  -1.20113984e-01f, 3.68957967e-02f, -1.92177910e-02f, 1.51567189e-02f, 1.52223650e-02f, -7.71481097e-02f, 6.14803769e-02f, -4.18508537e-02f, 2.41709361e-03f, -4.03356832e-03f,
  8.50121006e-02f, 5.10210730e-02f, -4.94653592e-03f, 2.27259807e-02f, 3.76707725e-02f, 7.71336555e-02f, 4.27466305e-03f, -9.55447257e-02f, 4.16343026e-02f, -3.70621122e-02f,
  1.64596424e-01f, 6.90738484e-02f, -1.58616692e-01f, -7.31252432e-02f, 1.76699851e-02f, 8.01368728e-02f, -6.07711039e-02f, -6.11186307e-03f, 1.66079655e-01f, -6.66732490e-02f,
  5.71428090e-02f, 1.09993167e-01f, -2.75914632e-02f, -7.63462782e-02f, 3.68688665e-02f, 4.27817786e-03f, -1.56554151e-02f, -2.27798498e-03f, -1.85024813e-02f, -4.08894382e-02f,
  -4.11077663e-02f, 1.78167950e-02f, 2.39398573e-02f, 4.18739058e-02f, 3.41827348e-02f, 5.96005730e-02f, -3.82835008e-02f, -1.14701912e-02f, 1.88061729e-01f, -1.13894157e-01f,
  1.31047094e+00f, -5.76515973e-01f, 3.60212684e-01f, 2.87490278e-01f, -1.58608168e-01f, 7.89793208e-03f, -2.73899198e-01f, -1.63452215e-02f, 2.49907061e-01f, 1.37923341e-02f,
  2.67645530e-02f, 1.40576541e-01f, 1.22706376e-01f, 1.13463752e-01f, 2.61236370e-01f, -9.13700610e-02f, 7.33556524e-02f, 3.88892591e-01f, 3.26291144e-01f, -3.48809026e-02f,
  -2.09038585e-01f, -7.85390511e-02f, 3.34562540e-01f, 2.00909063e-01f, -7.71506131e-02f, 1.53238982e-01f, -2.90873870e-02f, -1.44898281e-01f, -3.48980799e-02f, -1.32518727e-02f,
  1.68915629e-01f, 1.42498255e-01f, 3.44444275e-01f, 6.52710646e-02f, -1.53846024e-02f, 1.77097172e-01f, 8.09688047e-02f, 4.89297174e-02f, 2.53509311e-03f, -1.17247261e-01f,
  -4.87262271e-02f, 4.87445183e-02f, 4.06668670e-02f, -1.29219919e-01f, 9.86368954e-03f, -1.79105088e-01f, -1.39967655e-03f, 1.50955766e-01f, 2.42572173e-01f, -2.23987587e-02f,
  -1.86651543e-01f, -1.41608194e-01f, 1.40799791e-01f, -9.03400257e-02f, 1.01822518e-01f, 9.23675578e-03f, -1.00720704e-01f, -5.58776632e-02f, 7.86988214e-02f, 1.57913193e-02f,
  9.79620814e-02f, 7.89374262e-02f, 6.92498758e-02f, -2.03109793e-02f, -8.36723223e-02f, -1.07990861e-01f, 4.24998289e-04f, -4.45204265e-02f, 7.43747279e-02f, -9.68397781e-02f,
  -3.41700539e-02f, 2.19636232e-01f, -2.22223457e-02f, -2.48773489e-03f, -4.12583631e-03f, 1.24256415e-02f, 6.84959721e-03f, -1.09635554e-02f, -4.39249910e-03f, 1.16499379e-01f,
  -8.12494159e-02f, 3.11833825e-02f, -1.25179524e-02f, -1.11772954e-01f, -1.56190991e-02f, 7.18798563e-02f, 9.81030464e-02f, 5.23793064e-02f, -1.51422903e-01f, -1.02388866e-01f,
  -9.02929679e-02f, 2.30837882e-01f, 1.26753494e-01f, 1.83352172e-01f, 7.47986045e-03f, -8.41565281e-02f, 2.64171511e-02f, -4.78016101e-02f, -1.71326339e-01f, -1.05034234e-03f,
  -1.00063473e-01f, 7.81917945e-02f, -1.52394965e-01f, -2.17397101e-02f, -7.02262819e-02f, -7.69598484e-02f, -7.24129453e-02f, 1.00134119e-01f, 1.18705682e-01f, -3.76076028e-02f,
  -6.48444891e-02f, 7.96696618e-02f, 1.90604195e-01f, 1.29699036e-01f, 3.30722705e-02f, 1.56612769e-01f, -1.00889523e-02f, -1.09107502e-01f, 2.17026964e-01f, -7.26106614e-02f,
  -4.08141285e-01f, -6.69508576e-02f, -3.87056887e-01f, 7.51325727e-01f, 4.26075161e-01f, 2.26795539e-01f, 2.91082561e-01f, 1.28073901e-01f, 1.42112777e-01f, 1.09083980e-01f,
  2.81530738e-01f, 3.89978766e-01f, 4.59043324e-01f, 2.65838772e-01f, 9.95611101e-02f, 1.84921324e-01f, 3.49437624e-01f, -1.15145706e-01f, -3.33272181e-02f, 5.74733391e-02f,
  2.93873072e-01f, 1.93112604e-02f, -3.83169711e-01f, 7.28854313e-02f, 2.52595186e-01f, 4.50209320e-01f, 9.30612069e-03f, -1.60666987e-01f, -1.42676771e-01f, 9.49544162e-02f,
  -3.50096911e-01f, 1.10726982e-01f, 2.05221266e-01f, 3.62511396e-01f, 4.26383577e-02f, -1.90928414e-01f, 6.11108094e-02f, -1.30380601e-01f, 6.40493035e-02f, -5.29318638e-02f,
  1.82222784e-03f, -7.93283284e-02f, 2.01433197e-01f, 4.85849977e-02f, -7.37068430e-02f, -1.22465126e-01f, -8.26390013e-02f, -9.10951197e-02f, -6.34961948e-02f, -2.10387353e-02f,
  3.54938149e-01f, -1.01526961e-01f, -3.01671267e-01f, 5.66084050e-02f, 7.59606063e-02f, -5.71444072e-02f, -1.38483196e-01f, -2.02558655e-02f, -1.93132281e-01f, -2.71337599e-01f,
  3.48831192e-02f, -2.91826371e-02f, -3.68329547e-02f, -2.18697563e-02f, 1.31388288e-02f, 5.08557595e-02f, -5.24572954e-02f, -4.17778343e-02f, 5.02881408e-02f, -1.08506247e-01f,
  -3.11740581e-02f, 2.01803278e-02f, -2.47188527e-02f, 9.03084949e-02f, 1.53893039e-01f, 2.21881084e-02f, -1.42299771e-01f, -1.28732771e-01f, -6.31059930e-02f, -5.88442273e-02f,
  -1.07002653e-01f, -2.01238632e-01f, -7.38794804e-02f, -2.44104154e-02f, 1.60432681e-02f, 3.82074490e-02f, 1.35285020e-01f, 1.18887164e-01f, 1.74669817e-01f, 2.12494973e-02f,
  -1.94809094e-01f, 6.94125071e-02f, 7.17608184e-02f, -9.35012847e-02f, -1.60582706e-01f, -5.57033159e-03f, 2.38653362e-01f, -9.41785425e-03f, -7.05359578e-02f, 7.94683993e-02f,
  -1.94415480e-01f, -6.79274052e-02f, -9.10841152e-02f, -1.90592021e-01f, -2.00103417e-01f, -6.16173521e-02f, -2.99649555e-02f, 2.33704913e-02f, 9.72405728e-03f, -2.19886258e-01f,
  4.48383093e-02f, -2.16026664e-01f, -3.69644046e-01f, -1.19316094e-02f, 5.89250401e-02f, 3.18172313e-02f, -7.38914385e-02f, -2.16651559e-01f, -3.30193311e-01f, -2.80764531e-02f,
  8.10038485e-03f, -2.07457542e-02f, 3.44076723e-01f, 1.93153396e-01f, -3.10848765e-02f, -4.92691189e-01f, -8.89581978e-01f, -4.42236871e-01f, 5.98188341e-02f, -1.35536566e-01f,
  -2.76198834e-01f, 4.30396572e-02f, 1.61929667e-01f, 6.18550815e-02f, -5.91909997e-02f, 3.20809148e-02f, 4.67307687e-01f, 5.06408930e-01f, -1.73861101e-01f, -4.89583433e-01f,
  3.85613344e-03f, 1.24932729e-01f, 5.75482771e-02f, -6.19034320e-02f, 1.61187574e-01f, 1.46160528e-01f, 1.22100655e-02f, 9.78865325e-02f, -5.77565189e-03f, 9.50793564e-01f,
  8.04433152e-02f, -2.44537350e-02f, -5.47465011e-02f, -1.54110026e-02f, 9.42959189e-02f, -8.45398679e-02f, -1.04722515e-01f, 2.91242570e-01f, -4.57184389e-02f, 3.03353630e-02f,
  1.59234643e-01f, 9.77575406e-02f, 1.86554208e-01f, 8.24906975e-02f, -1.71450511e-01f, -2.91962653e-01f, 4.08469439e-02f, 4.81864326e-02f, -5.53150252e-02f, -1.54432029e-01f,
  1.57947361e-01f, -8.47237930e-03f, -1.81459337e-01f, -3.48866671e-01f, -9.06856433e-02f, 2.78120846e-01f, -2.29763061e-01f, -1.94302201e-02f, -2.83102244e-01f, 3.33842076e-02f,
  -7.32004270e-02f, 6.91802651e-02f, 2.27091946e-02f, 1.40754355e-03f, -3.39076407e-02f, -2.06948314e-02f, 9.11042616e-02f, -3.00583486e-02f, 8.81256834e-02f, -6.44131228e-02f,
  5.05123474e-02f, -6.47552162e-02f, 4.28081378e-02f, -9.27824304e-02f, 1.90539714e-02f, -2.93822829e-02f, -3.40815745e-02f, -4.73719575e-02f, 8.75891000e-02f, -2.98774950e-02f,
  3.29614021e-02f, 8.40488356e-03f, -1.99005120e-02f, 5.25444038e-02f, 2.11913008e-02f, 2.23381519e-02f, 6.23503588e-02f, -6.76455796e-02f, -4.69812378e-02f, -7.37723932e-02f,
  -1.05369247e-01f, 1.94655031e-01f, 2.15499103e-02f, -4.93579134e-02f, 3.98846976e-02f, 1.02337338e-01f, 8.36682394e-02f, 2.34669838e-02f, -2.07854453e-02f, -8.43736306e-02f,
  -7.75388926e-02f, -2.08239201e-02f, -2.67067049e-02f, 1.05624851e-02f, -3.27462815e-02f, -1.14746831e-01f, 7.42038935e-02f, -7.79403523e-02f, -1.06726028e-01f, -1.07551441e-01f,
  9.32203084e-02f, -2.56912351e-01f, -3.40265810e-01f, -2.02882782e-01f, -1.36049554e-01f, -2.68381774e-01f, -1.88791618e-01f, -2.07935527e-01f, -4.89376545e-01f, -4.88443434e-01f,
  6.18598223e-01f, 8.53480560e-06f, -1.55116450e-02f, 2.49873415e-01f, -8.31221640e-02f, 1.96033418e-01f, 1.65592343e-01f, 2.75762547e-02f, -7.60054290e-02f, -1.17513193e-02f,
  8.30502808e-02f, 1.04600340e-01f, 7.93423951e-02f, 3.37187350e-02f, 2.64538854e-01f, 4.59763110e-02f, -6.40831143e-02f, -1.33091221e-02f, 3.08786333e-01f, 1.32737309e-01f,
  -1.87061317e-02f, -3.23343761e-02f, 2.49224901e-02f, -1.75786000e-02f, -3.39021146e-01f, 2.59846866e-01f, -2.16543734e-01f, -3.20968658e-01f, -1.91442221e-01f, -2.84879267e-01f,
  5.12130737e-01f, -3.79128039e-01f, 6.69285804e-02f, -9.82250571e-02f, -1.76368967e-01f, -5.14007024e-02f, 2.48568766e-02f, -5.65252304e-02f, -9.58818942e-03f, -8.82843435e-02f,
  -1.00431658e-01f, -8.97980332e-02f, 6.66260198e-02f, -7.27096871e-02f, -9.77973565e-02f, -1.25180064e-02f, -2.27039874e-01f, 1.92510430e-02f, -4.99901064e-02f, 1.04673300e-02f,
  1.71469972e-02f, -3.61071154e-02f, -6.85737208e-02f, 1.05765194e-01f, 1.83717549e-01f, -2.29387842e-02f, -1.00326940e-01f, -8.78155008e-02f, -6.99834004e-02f, -1.17229171e-01f,
  6.86343685e-02f, 3.86640728e-02f, 8.08636919e-02f, 3.85431461e-02f, 1.30321383e-01f, 1.06941804e-01f, 6.49896190e-02f, 2.39727180e-02f, 8.32822919e-02f, 3.03416885e-02f,
  5.30361868e-02f, 7.99539872e-03f, 4.00525779e-02f, -9.62628424e-02f, -2.09380567e-04f, -5.29905595e-02f, -2.13409252e-02f, 3.49589102e-02f, -1.38860404e-01f, -2.04638997e-03f,
  3.86477672e-02f, 9.64520033e-03f, -8.82451907e-02f, -1.36193246e-01f, -2.58239686e-01f, -1.08450465e-01f, -2.11080071e-02f, 1.10313907e-01f, 1.64332744e-02f, -4.00830479e-03f,
  6.21457100e-02f, 4.27323617e-02f, 2.75803655e-01f, 1.40594877e-02f, -9.73319337e-02f, -4.11371663e-02f, 9.52563807e-02f, -7.22504333e-02f, -1.08702719e-01f, -4.74089757e-02f,
  -1.57327548e-01f, 9.97284725e-02f, 6.52170181e-02f, 1.72138382e-02f, 1.68630689e-01f, 6.64718226e-02f, -4.36341763e-02f, -8.09353776e-03f, -9.69342738e-02f, 1.53270904e-02f,
  -4.88238744e-02f, 1.21311836e-01f, 2.64714509e-01f, 2.53303200e-01f, 4.57123779e-02f, 2.23225802e-01f, 1.88302189e-01f, 4.00832593e-02f, 1.76910847e-01f, 3.01654279e-01f,
  1.40187025e-01f, 4.54462171e-01f, -9.19421911e-01f, 2.05364347e-01f, -3.50764394e-01f, -5.21294773e-01f, -1.79841980e-01f, 2.25056738e-01f, 1.90628648e-01f, -1.05291978e-01f,
  2.09945858e-01f, 1.97753027e-01f, -1.01747401e-02f, -2.02702001e-01f, -2.55954564e-01f, -4.28060740e-01f, -4.96925741e-01f, -5.94258368e-01f, -4.32381809e-01f, -1.18899889e-01f,
  -1.34548917e-01f, -6.08923554e-04f, -6.52698278e-02f, 2.79389694e-02f, 2.85891090e-02f, 1.27578974e-01f, -1.38136715e-01f, -1.33553073e-01f, -4.59437184e-02f, -4.03388023e-01f,
  -4.39650893e-01f, -6.64294660e-02f, -4.88407835e-02f, 1.10383555e-01f, 2.85562817e-02f, 9.01504830e-02f, 2.00655125e-02f, 1.23520672e-01f, 1.44922704e-01f, -1.76918712e-02f,
  9.23285112e-02f, 1.00561641e-01f, 7.19724894e-02f, 3.02571189e-02f, 1.43693872e-02f, -4.01187763e-02f, -6.22054515e-03f, -6.97678924e-02f, -1.71540499e-01f, 6.24319948e-02f,
  3.17628495e-02f, -1.42195597e-01f, -7.59329647e-02f, 8.40411708e-02f, 6.08274266e-02f, -1.71502411e-01f, 1.16860263e-01f, 9.09550488e-02f, -7.92239979e-03f, 2.20857069e-01f,
  1.10708922e-02f, 5.13954461e-03f, -4.61383685e-02f, 3.65973338e-02f, 1.96083896e-02f, 2.25254875e-02f, -4.71352823e-02f, 4.83271517e-02f, 6.89023584e-02f, -3.65662836e-02f,
  1.34630010e-01f, -6.01433963e-02f, 8.20440799e-02f, -7.51397982e-02f, -1.80164471e-01f, -5.04473746e-02f, -1.68352909e-02f, -7.84660354e-02f, -9.58786055e-04f, 1.77186150e-02f,
  9.09185484e-02f, 2.73393933e-02f, 2.64925268e-02f, 1.03990793e-01f, -1.63236886e-01f, -6.44709393e-02f, -5.61086796e-02f, 6.42170459e-02f, -2.92309895e-02f, -4.76909627e-04f,
  3.89274538e-01f, -1.94109708e-01f, -6.08945191e-02f, 1.29965723e-01f, 2.96320934e-02f, 1.28459313e-03f, -7.45512322e-02f, 2.75972225e-02f, -5.39360158e-02f, -1.22616485e-01f,
  -4.19493169e-02f, -6.04941398e-02f, 6.21361621e-02f, -3.94977592e-02f, 9.66134369e-02f, -1.69670448e-01f, -8.53377208e-03f, -2.70729177e-02f, -4.78907824e-02f, 2.40914803e-02f,
  -8.12582485e-03f, 2.73600947e-02f, 5.25417663e-02f, -4.33133282e-02f, 2.33298279e-02f, -1.23157360e-01f, 4.01380509e-02f, -5.15708365e-02f, -1.59166634e-01f, 2.71488100e-01f,
  3.11472397e-02f, 4.80596274e-01f, 2.89966702e-01f, -4.89972532e-01f, 7.69909397e-02f, 5.93648702e-02f, 5.03523350e-01f, 1.43597186e-01f, -4.52129722e-01f, -3.00403498e-02f,
  -6.10245764e-03f, -2.38349184e-01f, 3.00595760e-02f, 1.31586328e-01f, 3.67141098e-01f, 3.05568486e-01f, 1.18997328e-01f, 2.35232543e-02f, -1.99768886e-01f, -1.93965450e-01f,
  -1.31700128e-01f, -4.57430519e-02f, 5.98404482e-02f, -2.24176105e-02f, -6.27225637e-02f, -2.66021460e-01f, 6.76981211e-02f, 1.15967534e-01f, 2.71493882e-01f, -1.09842636e-01f,
  1.16553426e-01f, 3.14215779e-01f, -1.47455484e-01f, 9.21724066e-02f, 2.30411943e-02f, -2.46219970e-02f, -9.39119086e-02f, 1.17595315e-01f, -1.27244741e-01f, -4.26247269e-02f,
  1.77703500e-02f, 7.03977495e-02f, -1.17364258e-01f, -1.28175244e-01f, -9.80050266e-02f, 3.13865417e-03f, -2.30871215e-02f, 1.90303892e-01f, -1.20191976e-01f, -6.38791844e-02f,
  3.37321796e-02f, -8.54462162e-02f, 1.13034723e-02f, -3.33614424e-02f, 1.32882684e-01f, -8.21976885e-02f, 1.35032117e-01f, 4.23278622e-02f, 2.11883590e-01f, -1.43574625e-01f,
  -2.55053751e-02f, 1.66059524e-01f, 1.31357498e-02f, -4.31070365e-02f, -9.24899876e-02f, -4.06105407e-02f, -3.87698188e-02f, -6.17043599e-02f, -1.37251303e-01f, 1.04946822e-01f,
  -1.73691779e-01f, -7.55011663e-02f, -8.64838436e-02f, 1.00412682e-01f, -5.76139688e-02f, -6.82348153e-04f, -3.43415514e-02f, -2.74689011e-02f, 2.20677257e-02f, -4.70435619e-03f,
  -2.70414036e-02f, -1.10861942e-01f, -1.36117935e-02f, -9.72322151e-02f, 7.67375901e-02f, 4.83864453e-03f, -1.41960636e-01f, -1.10426530e-01f, -3.13606448e-02f, -2.35865172e-02f,
  -1.76841184e-01f, 2.36208841e-01f, -1.99835017e-01f, 5.86949103e-02f, 1.10999413e-01f, 1.09955095e-01f, 9.53005329e-02f, 9.49183255e-02f, -7.55682215e-03f, 1.80700682e-02f,
  1.27351061e-02f, -2.97478139e-02f, 7.07059130e-02f, -8.34895447e-02f, -2.61193454e-01f, -1.63002647e-02f, -5.59647568e-02f, -1.00561522e-01f, -6.44489303e-02f, -1.28179550e-01f,
  -8.21645930e-02f, -2.47492492e-01f, -3.40478987e-01f, -1.46065876e-01f, -3.65165025e-01f, -1.39518052e-01f, 2.19705631e-04f, -1.96473915e-02f, -5.80719635e-02f, -5.97258657e-02f,
  -4.78714675e-01f, 3.78266305e-01f, 4.01305765e-01f, -6.23680174e-01f, 1.31377488e-01f, 2.00073794e-01f, 4.70589280e-01f, 9.01760459e-02f, -1.87706485e-01f, 3.64871502e-01f,
  3.66262048e-01f, -2.46927664e-01f, -1.25703707e-01f, -1.09447390e-02f, -1.96348485e-02f, 1.68695167e-01f, -1.45813271e-01f, -3.40456933e-01f, -3.73899877e-01f, -2.51500998e-02f,
  -1.80546314e-01f, -3.89725804e-01f, -3.77157629e-01f, -3.96237433e-01f, -1.86633274e-01f, -4.82203513e-01f, -5.15764467e-02f, -1.80782959e-01f, 2.05641046e-01f, -1.81273609e-01f,
  8.59925151e-02f, 2.69309551e-01f, 1.28848059e-02f, -1.22100145e-01f, 1.22471582e-02f, -7.79016241e-02f, 2.17079874e-02f, 5.91370165e-02f, 3.15151848e-02f, 5.52350618e-02f,
  9.32484493e-03f, 2.09907010e-01f, 2.81263012e-02f, 1.10699935e-02f, -1.17790233e-03f, -3.04795969e-02f, -5.88211715e-02f, -6.59834072e-02f, 5.88582456e-02f, 2.01178476e-01f,
  1.25691056e-01f, 1.33603886e-01f, 1.46959454e-01f, 2.11716443e-01f, 3.04843068e-01f, 7.51546547e-02f, 1.35328382e-01f, -3.03944722e-02f, 2.08644226e-01f, -2.02480644e-01f,
  6.08430654e-02f, -4.17716093e-02f, 1.09103909e-02f, -3.18133086e-02f, -6.46041473e-03f, -1.25248944e-02f, -5.93035556e-02f, 1.07800171e-01f, 1.01088420e-01f, -2.25603744e-01f,
  1.28796831e-01f, 1.21269546e-01f, 8.73387605e-02f, -5.77536263e-02f, -1.00709498e-01f, -3.05483844e-02f, 1.81158129e-02f, -4.38883230e-02f, -1.34154567e-02f, 8.38076416e-03f,
  -1.40096340e-02f, 1.20294981e-01f, -1.38735324e-02f, -1.21134080e-01f, 5.16778082e-02f, -8.16080719e-02f, 1.94512576e-01f, 9.77374613e-02f, -4.54133488e-02f, -8.17683712e-03f,
  -4.49013442e-01f, 1.41581386e-01f, -1.86189953e-02f, -8.11757296e-02f, -1.19610399e-01f, -4.84255282e-03f, -9.38758403e-02f, -1.73769891e-02f, -1.84315685e-02f, -1.06385358e-01f,
  -1.80997010e-02f, -1.14558555e-01f, 9.71389562e-02f, 1.45437578e-02f, -1.19035296e-01f, -1.53621743e-02f, -1.47173135e-02f, -8.02848041e-02f, 2.35828478e-02f, -8.22170451e-02f,
  7.52119496e-02f, -7.22976923e-02f, -3.44506390e-02f, -1.15730613e-02f, 1.55686112e-02f, -1.09437108e-01f, -1.95416324e-02f, -2.50778347e-02f, -4.61783521e-02f, -1.79739937e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  3.35760713e-01f, 2.62695849e-01f, 2.44019374e-01f, 7.12743938e-01f, 2.30394691e-01f, 2.34422222e-01f, 4.92811501e-01f, 4.36002672e-01f, 3.38527143e-01f, 1.25766233e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  -6.13416620e-02f, 4.76972014e-02f, -3.24826576e-02f, 4.26685244e-01f, -2.08322704e-01f, -1.10575715e-02f, 1.53112248e-01f, -4.47398782e-01f, 1.92250945e-02f, 4.24562208e-02f,
  1.91201821e-01f, -4.45114970e-02f, 2.65328825e-01f, 2.15604484e-01f, -7.85979703e-02f, -1.88173845e-01f, 2.08361037e-02f, 2.21636854e-02f, -1.48054212e-02f, -7.15337396e-02f,
  2.56479919e-01f, -8.14963728e-02f, -2.69799829e-01f, 3.11129898e-01f, -2.49885112e-01f, 1.64327368e-01f, -4.51028734e-01f, 2.02685043e-01f, -2.41246879e-01f, -1.79919377e-01f,
  1.81882218e-01f, 4.05200511e-01f, 1.12053156e-02f, 3.49150002e-02f, -2.18035001e-02f, -1.69811249e-01f, -3.47741437e-03f, -1.53962867e-02f, -2.78310105e-02f, 4.11752090e-02f,
  4.07952607e-01f, 2.89215744e-01f, -1.59762770e-01f, 4.55035746e-01f, -1.62993465e-02f, -4.17803526e-01f, -2.86037326e-01f, -2.46276766e-01f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  6.20184615e-02f, 2.91311532e-01f, 3.12440060e-02f, -3.68052781e-01f, 3.54036063e-01f, 2.44451389e-02f, -7.38294780e-01f, 6.07021153e-01f, 5.68630219e-01f, -6.72083080e-01f,
  5.60442924e-01f, 7.78321862e-01f, -3.46894741e-01f, 5.31517208e-01f, 3.99482816e-01f, -1.03272088e-01f, -1.74666774e-02f, 1.27589688e-01f, 5.48216879e-01f, -1.36361107e-01f,
  2.40636140e-01f, 3.13977301e-02f, -8.10922459e-02f, 4.29883361e-01f, -2.84467548e-01f, 2.67458498e-01f, -3.48966330e-01f, -2.62240261e-01f, 2.17424780e-02f, -4.99234587e-01f,
  6.89458847e-01f, 7.02733874e-01f, 1.43479437e-01f, -6.15102872e-02f, -6.46588802e-02f, 2.72971690e-01f, -5.46889985e-03f, 3.66131157e-01f, 1.64523333e-01f, 3.49629879e-01f,
  -1.34355575e-01f, -2.24366665e-01f, 1.21440619e-01f, -5.29206097e-01f, -2.29752749e-01f, 4.52592760e-01f, 1.47449851e-01f, -8.49460959e-02f, 3.65538418e-01f, 1.17291071e-01f,
  2.87728041e-01f, -5.54024726e-02f, 1.25643134e-01f, -2.75366921e-02f, 2.30832413e-01f, 4.01766330e-01f, 6.49073064e-01f, 3.83263946e-01f, 3.20003256e-02f, 1.67678967e-01f,
  -2.24137440e-01f, -4.52037811e-01f, 5.19907117e-01f, -1.98070213e-01f, -4.98269200e-02f, -1.72008067e-01f, 8.30797926e-02f, 3.18752497e-01f, 1.64070070e-01f, -2.08162501e-01f,
  1.88545570e-01f, 2.02403471e-01f, 8.05221736e-01f, 1.36215985e-01f, 4.72290635e-01f, 6.21046312e-02f, 5.41277118e-02f, 8.21893811e-01f, -1.34008229e-01f, -1.41404063e-01f,
  2.24235758e-01f, 1.41650185e-01f, -1.42474607e-01f, 1.10507108e-01f, 2.15125695e-01f, -1.24052532e-01f, 5.48454046e-01f, -4.76290911e-01f, -2.89001524e-01f, 2.10033089e-01f,
  -1.73024148e-01f, 7.16870308e-01f, -4.58712697e-01f, -2.85240356e-03f, 1.21803649e-01f, 4.31774110e-01f, 6.64284647e-01f, -1.13924138e-01f, -2.56661505e-01f, 3.32506418e-01f,
  -3.15088853e-02f, 1.01183347e-01f, 6.82910085e-01f, -1.60959378e-01f, 6.14122927e-01f, -9.51656103e-02f, 3.05424780e-01f, -1.21163592e-01f, -3.03872168e-01f, 5.65689147e-01f,
  2.87671149e-01f, 2.91873932e-01f, -1.01938993e-01f, 1.87092170e-01f, -2.41056308e-01f, -2.85591871e-01f, 1.64110720e-01f, -2.36074597e-01f, -3.88742208e-01f, -3.04483265e-01f,
  -4.08610284e-01f, 4.35674712e-02f, 4.83807474e-01f, -3.04191560e-01f, 1.91852376e-01f, -1.89276859e-01f, -4.87256348e-02f, 6.95762038e-02f, 6.87251464e-02f, 1.16485581e-01f,
  3.53177935e-02f, 4.34216149e-02f, -3.20627183e-01f, 4.19400930e-01f, 3.82803865e-02f, 2.87900060e-01f, 7.55625606e-01f, 3.19271982e-01f, 1.23654734e-02f, -4.56623375e-01f,
  4.42290813e-01f, 1.49136230e-01f, -1.51758268e-01f, -1.77931488e-01f, -4.80866842e-02f, 2.98183799e-01f, -3.10104638e-01f, -1.38177603e-01f, 3.50592509e-02f, -1.43330574e-01f,
  5.72326422e-01f, 2.69745201e-01f, -2.90002018e-01f, -3.99989903e-01f, 2.62033403e-01f, -3.45184088e-01f, -2.92201102e-01f, 3.72043364e-02f, 5.87844133e-01f, 5.87245226e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  3.23695272e-01f, 1.50992488e-02f, 4.29453909e-01f, 3.54074478e-01f, 2.00942159e-01f, 3.23811024e-01f, 5.02085567e-01f, -5.60979312e-03f, 3.53465647e-01f, 2.22539768e-01f
};

// L2_fan_Wp (Shape: 3 x 16)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  2.81131595e-01f, 7.92218149e-01f, -7.85967242e-03f, -4.85690445e-01f, -1.80138871e-01f, 2.96412498e-01f, 2.94733904e-02f, -1.79962739e-01f, 2.99007118e-01f, -2.68050343e-01f,
  4.02320437e-02f, 4.78054225e-01f, -2.05238342e-01f, -3.13053340e-01f, -3.73451054e-01f, -3.95021178e-02f, -1.46508977e-01f, -1.02221780e-01f, 4.98952091e-01f, 1.34296343e-01f,
  2.19667137e-01f, 4.80331704e-02f, -5.12269676e-01f, -2.54829391e-03f, -3.13632600e-02f, 1.29404247e-01f, 1.65934160e-01f, 2.23729804e-01f, 1.03793874e-01f, 4.10720557e-01f,
  2.82555103e-01f, -2.55780011e-01f, 1.07409067e-01f, -1.36989832e-01f, 3.43487151e-02f, 4.04939801e-02f, -2.05675468e-01f, -4.20039892e-01f, -1.91381499e-01f, -1.49040103e-01f,
  2.96914228e-03f, 2.03672916e-01f, 3.47806782e-01f, -7.98697323e-02f, 2.38059953e-01f, 1.18821606e-01f, -4.83801477e-02f, -3.55990022e-01f
};

// L2_fan_Wp_bar (Shape: 10 x 16)
const int L2_fan_Wp_bar_rows = 10;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  -7.90020764e-01f, -9.66800809e-01f, 2.31534347e-01f, -6.56804502e-01f, 2.23360017e-01f, -5.86409643e-02f, 2.71986961e-01f, 7.70278513e-01f, 6.12447679e-01f, 3.16336989e-01f,
  -3.32564563e-01f, 8.32521319e-02f, 1.00556351e-01f, -5.44071048e-02f, -3.61973435e-01f, 8.77843499e-01f, 2.31781192e-02f, 2.02323139e-01f, -1.99688412e-02f, -3.10396224e-01f,
  5.94406962e-01f, -3.39188933e-01f, -8.21559578e-02f, 3.58446211e-01f, 2.73233533e-01f, 3.15632641e-01f, -1.67438373e-01f, 7.92636871e-01f, 4.14560556e-01f, -5.90912029e-02f,
  -1.22613087e-01f, 5.83334267e-01f, 3.53915125e-01f, -1.51760697e-01f, 9.43392329e-03f, -5.84654450e-01f, 4.45886582e-01f, 1.35358429e+00f, 5.16262352e-01f, -1.79364961e-02f,
  -2.29394451e-01f, 5.60693562e-01f, 5.47011614e-01f, 9.49935392e-02f, 3.05349648e-01f, -6.74444884e-02f, 3.07970047e-01f, -7.26412892e-01f, 6.54356062e-01f, 7.68352509e-01f,
  -4.00284976e-01f, -4.77744401e-01f, 5.58809042e-01f, 4.17105734e-01f, 5.07079899e-01f, -7.85956144e-01f, -2.96212643e-01f, -1.12939700e-01f, 1.84093669e-01f, 7.06530035e-01f,
  -8.83777589e-02f, -2.52594739e-01f, -7.29195356e-01f, 3.43112230e-01f, 5.25372028e-01f, -2.13194087e-01f, 8.97393584e-01f, 1.60721049e-01f, -4.62127507e-01f, -6.11304879e-01f,
  3.19972634e-01f, 2.10613579e-01f, 5.83282769e-01f, -2.05200940e-01f, 5.10973036e-01f, 2.00843111e-01f, 5.50322473e-01f, -2.76059270e-01f, 3.62136215e-01f, 5.71403563e-01f,
  1.22392692e-01f, 1.89777002e-01f, 3.43384862e-01f, -2.71323025e-01f, -6.50435090e-02f, -9.64539722e-02f, 7.29668915e-01f, -1.02594268e+00f, 4.99810502e-02f, -3.02576095e-01f,
  -1.67751163e-02f, -6.81999400e-02f, 2.07809675e-02f, 2.77353376e-01f, -4.95840430e-01f, 2.26008892e-01f, 5.79803884e-01f, 2.00918704e-01f, 7.20095396e-01f, 3.39298010e-01f,
  -5.94098270e-01f, -3.08099657e-01f, 2.79926006e-02f, -1.67839348e-01f, -4.49363887e-02f, 1.22596152e-01f, 4.86320972e-01f, -3.83019447e-01f, 1.89724773e-01f, 4.04301137e-01f,
  4.47373599e-01f, -2.96244025e-01f, 3.06494921e-01f, 1.20675951e-01f, 6.53971434e-01f, 1.29712239e-01f, -2.83494502e-01f, 2.16475248e-01f, 6.33023560e-01f, -2.73669243e-01f,
  -8.70667577e-01f, 2.33541340e-01f, 8.00016001e-02f, -4.90206838e-01f, 9.72619057e-02f, 3.37405622e-01f, 3.59822869e-01f, -3.84011984e-01f, 3.39574188e-01f, -2.93472558e-01f,
  -1.51404053e-01f, -4.97696638e-01f, 4.17990774e-01f, 1.30714083e+00f, 5.15528508e-02f, -1.99790850e-01f, -6.76602781e-01f, 4.81827348e-01f, 7.77663440e-02f, 1.28605634e-01f,
  1.78105593e-01f, 1.15863398e-01f, 1.99998498e-01f, -8.01484585e-01f, 3.05356890e-01f, -4.38255966e-02f, 4.69050109e-01f, -2.55146056e-01f, 3.49655241e-01f, 7.95617461e-01f,
  6.53759122e-01f, 1.27155945e-01f, -7.45165274e-02f, 2.58775484e-02f, -2.87420183e-01f, -3.11739564e-01f, -4.20094073e-01f, 1.98960751e-01f, -1.19000278e-01f, 1.13864288e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 10)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 10;
const float L2_fan_Bp_bar_data[] = {
  -2.08963566e-02f, 4.50490594e-01f, 5.19434571e-01f, 4.47026551e-01f, 3.31736058e-01f, -1.73432995e-02f, 3.82028222e-01f, 4.87592995e-01f, 1.53853193e-01f, 5.53565085e-01f
};

// L3_fan_Wp (Shape: 3 x 16)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -2.43798912e-01f, -4.61120844e-01f, 7.40182644e-04f, -1.28222760e-02f, -2.43200302e-01f, 1.58080786e-01f, 1.12681687e-01f, -2.40970343e-01f, 2.06054270e-01f, 7.60739595e-02f,
  -6.79052472e-02f, -4.44043986e-02f, 1.85248226e-01f, 3.19785863e-01f, 3.03583264e-01f, -1.92272782e-01f, -2.45890811e-01f, -1.98093951e-01f, 3.15553062e-02f, -4.28246826e-01f,
  2.27739498e-01f, 3.51993442e-01f, 1.14556499e-01f, -1.86141491e-01f, -7.93376416e-02f, -2.39883617e-01f, 2.41408944e-01f, 1.12036251e-01f, 2.09485039e-01f, -2.33649865e-01f,
  4.53962982e-02f, -1.81171477e-01f, -4.24977511e-01f, -2.23570779e-01f, -2.46906072e-01f, -2.04492778e-01f, 5.83838880e-01f, 1.00388117e-01f, 7.83580355e-03f, -3.06702197e-01f,
  -1.53568342e-01f, 1.29724562e-01f, 1.78076148e-01f, 1.49505660e-01f, 3.04538608e-01f, 8.79356787e-02f, -3.63114774e-01f, -2.37114221e-01f
};

// L3_fan_Wp_bar (Shape: 10 x 16)
const int L3_fan_Wp_bar_rows = 10;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  -9.67828706e-02f, -7.44274259e-01f, -7.21959770e-01f, 5.43972671e-01f, 1.67643830e-01f, -2.58245170e-01f, -5.42237937e-01f, -1.06931947e-01f, 1.00521398e+00f, 6.93791032e-01f,
  1.34941399e-01f, 1.52826047e+00f, 1.89630941e-01f, 4.29582685e-01f, 1.08517802e+00f, 3.75638127e-01f, 4.23642933e-01f, 4.11705971e-01f, 4.62003142e-01f, -1.00819993e+00f,
  4.31928873e-01f, 4.09897923e-01f, 7.72436678e-01f, -6.68853045e-01f, -2.46426370e-02f, -4.15158510e-01f, 3.89996730e-02f, 2.30148416e-02f, 5.94280899e-01f, 8.01423848e-01f,
  -1.60154209e-01f, 2.88956851e-01f, 6.02337420e-01f, 6.68825448e-01f, 6.01538062e-01f, -7.51852751e-01f, 9.25942123e-01f, 4.60746855e-01f, -1.67120278e-01f, -7.03860164e-01f,
  -2.39343792e-01f, -7.43972301e-01f, 2.97041655e-01f, -7.00600028e-01f, 2.16558382e-01f, 3.34714264e-01f, -5.17372906e-01f, -7.85289779e-02f, -6.78509831e-01f, -1.51658249e+00f,
  -5.74262559e-01f, 3.25201452e-01f, 9.47446376e-02f, 2.78547555e-01f, 1.57560147e-02f, -2.36650497e-01f, 2.55733132e-01f, -5.01012146e-01f, 6.32629514e-01f, -1.07642460e+00f,
  3.62956345e-01f, -2.57643282e-01f, -2.57581868e-03f, -6.14763260e-01f, 7.07681775e-01f, 5.56591392e-01f, 5.91398835e-01f, -8.11452985e-01f, 2.00003907e-01f, 2.58369565e-01f,
  6.98501825e-01f, 4.78429407e-01f, -3.97190489e-02f, -5.39270401e-01f, 4.85987425e-01f, -1.14894772e+00f, -5.95413037e-02f, -1.66416187e-02f, -2.65270442e-01f, 2.55459547e-01f,
  4.13788587e-01f, -4.89906102e-01f, 5.43470383e-01f, 2.80569881e-01f, -5.71036279e-01f, -7.80823648e-01f, 4.30514306e-01f, -6.76241964e-02f, 7.90005326e-01f, 2.88205355e-01f,
  -3.62181783e-01f, -3.33477229e-01f, -5.78878932e-02f, 5.50435603e-01f, 9.08716977e-01f, 9.07739043e-01f, 7.42222786e-01f, 1.00405145e+00f, 2.38896906e-01f, 6.48472130e-01f,
  1.08932841e+00f, 8.84677410e-01f, -3.84212673e-01f, 7.32453465e-01f, 6.92648217e-02f, 1.10129642e+00f, 4.76107359e-01f, -1.02929652e-01f, -2.22378429e-02f, -1.71903938e-01f,
  -1.45683497e-01f, -3.51830810e-01f, -4.56238329e-01f, 7.05647916e-02f, -1.03094190e-01f, 6.65432572e-01f, 4.21635836e-01f, 4.07773077e-01f, 1.16730884e-01f, 2.17192799e-01f,
  -1.09118141e-01f, 6.35098457e-01f, -8.97817407e-03f, -9.31943059e-01f, -6.31424904e-01f, -5.04721940e-01f, 3.41474891e-01f, -7.87207067e-01f, -6.50813341e-01f, -3.85778338e-01f,
  -4.99936223e-01f, -7.98858464e-01f, -4.46993798e-01f, -2.94724345e-01f, 3.82845163e-01f, 4.81160253e-01f, 2.13384897e-01f, -3.85774672e-01f, 4.15742606e-01f, 1.07437563e+00f,
  -2.74557531e-01f, 1.70271814e-01f, 6.23268560e-02f, 6.40248001e-01f, -7.20342100e-01f, -8.16361129e-01f, -4.88750517e-01f, 1.50183931e-01f, 3.06629300e-01f, 1.63818583e-01f,
  -2.14505196e-01f, -5.23268543e-02f, 8.69546756e-02f, -3.35661858e-01f, 5.26430368e-01f, 7.27116823e-01f, 5.35149872e-01f, 6.54419363e-02f, 2.89954785e-02f, 1.12902083e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 10)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 10;
const float L3_fan_Bp_bar_data[] = {
  1.89973876e-01f, 4.62667078e-01f, 3.70244324e-01f, -4.93098572e-02f, 5.35703719e-01f, 2.42214978e-01f, 5.09445667e-01f, -1.47735402e-01f, -2.94981815e-04f, 8.58755335e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  3.02770466e-01f, -3.27381223e-01f, -4.66720223e-01f, -5.40130138e-01f, -3.45847219e-01f, 1.74231365e-01f, -2.15487599e-01f, -9.30020571e-01f, -7.31556937e-02f, 3.70064318e-01f,
  2.95340389e-01f, -4.53249753e-01f, -3.52923721e-01f, 4.78870608e-02f, 4.81713623e-01f, 2.45256424e-01f, 5.65801322e-01f, -8.82412642e-02f, -1.45507634e-01f, -7.90346682e-01f,
  4.48321044e-01f, 7.22033262e-01f, 2.07979649e-01f, 7.29841134e-03f, -4.99698043e-01f, 5.16592622e-01f, -3.78616482e-01f, 1.45136014e-01f, -9.62548554e-01f, 3.06980908e-01f,
  -1.38605624e-01f, 2.94120312e-01f, -1.81833014e-01f, -5.90405464e-02f, 1.33475333e-01f, 4.66670454e-01f, 1.37412414e-01f, -2.87654519e-01f, 7.23214522e-02f, -5.71113288e-01f,
  -4.76798654e-01f, 4.07269225e-02f, -6.15529299e-01f, 1.33076146e-01f, 2.02852517e-01f, 9.56289172e-01f, -1.93984151e-01f, -1.69099912e-01f, -3.08734298e-01f, 2.30496246e-02f,
  5.79961352e-02f, -4.83501315e-01f, -6.34542406e-01f, -5.32345474e-01f, -9.39178228e-01f, -9.50881541e-01f, -9.46900100e-02f, -5.81006467e-01f, 5.00764191e-01f, -6.44860327e-01f,
  4.37926203e-01f, 3.50744337e-01f, 1.37769863e-01f, -6.53224766e-01f, 4.85914022e-01f, 4.48278159e-01f, 4.91945803e-01f, -9.68824923e-01f, 8.11477542e-01f, 7.77435482e-01f,
  1.51324779e-01f, -3.06846231e-01f, -3.58818978e-01f, -2.23663911e-01f, 8.08487833e-02f, -5.20172656e-01f, 5.08391201e-01f, -5.05017400e-01f, -2.49714002e-01f, 1.71029210e-01f,
  -8.58954310e-01f, -2.74953187e-01f, -1.04683802e-01f, -2.57732887e-02f, 7.88334906e-02f, -8.22340846e-01f, 9.13967565e-02f, 3.28399748e-01f, 4.44932938e-01f, 3.79266262e-01f,
  -2.25251764e-02f, -6.47394300e-01f, -2.07395673e-01f, 4.56154756e-02f, -1.34529814e-01f, 9.06236842e-02f, -6.48818791e-01f, -1.79151624e-01f, -5.68334460e-01f, 2.47667119e-01f,
  -4.26053941e-01f, 3.68536830e-01f, 1.04119867e-01f, -4.55534533e-02f, -8.80894661e-01f, -8.07548761e-02f, -1.11808293e-01f, 4.37207073e-01f, -8.68855894e-01f, -1.16032436e-01f,
  3.53889376e-01f, -9.53974366e-01f, -4.72812653e-01f, 1.74457312e-01f, 7.45360494e-01f, -1.91627853e-02f, 3.96281555e-02f, 2.04101443e-01f, 2.21499726e-01f, 1.73555747e-01f,
  -5.76266944e-01f, -4.02180433e-01f, -7.03515708e-01f, -4.76443134e-02f, -4.05507505e-01f, -7.55141601e-02f, 4.10558015e-01f, 2.46674895e-01f, -4.30988252e-01f, 7.65099108e-01f,
  6.65457129e-01f, 9.41544592e-01f, 3.43154192e-01f, 1.06504094e-02f, 5.86796440e-02f, 6.24740124e-01f, 5.85968614e-01f, -5.63362658e-01f, 8.14701840e-02f, 3.24417502e-01f,
  -4.84486908e-01f, 5.45074679e-02f, -7.92514980e-01f, -2.61113226e-01f, 2.88161904e-01f, -5.31283557e-01f, -5.01768589e-01f, 2.63058186e-01f, -3.65487598e-02f, -6.53978884e-01f,
  4.81197357e-01f, -7.30048895e-01f, -5.80452859e-01f, -8.74096453e-01f, -1.28392899e+00f, 4.54488784e-01f, -1.39870107e-01f, -1.37165618e+00f, 6.30201250e-02f, -7.56273925e-01f,
  5.06013572e-01f, 1.73425049e-01f, 3.10581297e-01f, 3.13579232e-01f, 9.45390105e-01f, 7.63025045e-01f, -1.76930976e+00f, 5.40542722e-01f, 9.20832396e-01f, -8.16242546e-02f,
  6.56847417e-01f, -1.07286000e+00f, 3.11606765e-01f, -1.85803577e-01f, -1.35602999e+00f, -8.29956606e-02f, 7.19113827e-01f, 5.52460492e-01f, 4.50860262e-02f, -1.38038173e-01f,
  -1.14961624e-01f, -8.72181773e-01f, -5.90166032e-01f, 2.17831030e-01f, -6.11771047e-01f, -6.82169676e-01f, 6.25333428e-01f, 8.75168014e-03f, -6.81425929e-01f, 1.20733529e-02f,
  3.63438368e-01f, -2.70895422e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -1.49191499e-01f, -1.46224141e-01f, 1.46322891e-01f, -6.17511384e-02f, -3.94277535e-02f, -8.82240385e-02f, -6.63768873e-02f, 1.00376971e-01f, 1.48460925e-01f, 2.62469739e-01f,
  4.07347739e-01f, 2.20238537e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    