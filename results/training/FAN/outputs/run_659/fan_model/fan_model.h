/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.52999747e-01f, -6.62672222e-02f, -3.21509331e-01f, 1.69578075e-01f, -4.46698479e-02f, -1.85143337e-01f, -5.55066586e-01f, -2.73574769e-01f, 1.29772574e-01f, -5.37529737e-02f,
  1.96715519e-01f, 2.99056143e-01f, 1.95182100e-01f, -6.30223602e-02f, -2.98885822e-01f, -3.30509692e-01f, -4.71982777e-01f, -2.41931617e-01f, -2.01334998e-01f, -8.72313231e-02f,
  -7.97132477e-02f, -4.29974645e-02f, 1.01994626e-01f, 1.23472929e-01f, 1.13438107e-01f, 1.93216190e-01f, -6.56008646e-02f, 1.31065324e-01f, 5.80698736e-02f, -2.73681402e-01f,
  1.43275671e-02f, -1.81449577e-01f, -1.14991805e-02f, 1.24966532e-01f, 6.30673692e-02f, 4.68372367e-02f, -4.52254452e-02f, -2.22358648e-02f, 7.54208770e-03f, 6.32048771e-02f,
  4.32972088e-02f, 4.33357358e-02f, -5.47913946e-02f, -1.00347988e-01f, 2.51307879e-02f, 3.21293697e-02f, 8.99220444e-03f, -1.30217507e-01f, -4.68948781e-02f, -2.27383878e-02f,
  3.29155922e-02f, -1.09226480e-02f, -3.49225104e-02f, -1.40515193e-01f, -1.73080951e-01f, 8.03602561e-02f, -8.54159445e-02f, 3.71471345e-02f, 4.94339736e-03f, -1.09372772e-01f,
  -2.20684502e-02f, 3.01387603e-03f, -3.74694727e-02f, 1.29963998e-02f, 1.13655068e-01f, 2.33811811e-02f, -8.66108201e-03f, -2.51136962e-02f, -3.90393436e-02f, 4.60129455e-02f,
  7.40709677e-02f, -4.70239222e-02f, 2.91344989e-03f, 1.10165356e-02f, 3.82026397e-02f, -8.35087225e-02f, -3.28936651e-02f, 2.75296867e-02f, 5.54001704e-02f, -6.57309368e-02f,
  5.69144040e-02f, 7.65426606e-02f, 8.86949822e-02f, -4.49363552e-02f, 1.41432881e-02f, -1.64442677e-02f, -2.28261852e-05f, 5.07048517e-02f, 1.24861293e-01f, -6.39667967e-03f,
  7.37751648e-02f, -6.32528514e-02f, 2.17659604e-02f, -7.70392790e-02f, -1.60376690e-02f, 2.47414596e-02f, 8.57170150e-02f, -3.56557127e-03f, 2.57736519e-02f, -3.70264798e-02f,
  -4.91152070e-02f, -1.19228121e-02f, 6.10950515e-02f, -5.65672107e-03f, 2.17427760e-02f, -4.32300456e-02f, -5.69365034e-03f, -2.35216487e-02f, -6.39458522e-02f, -2.06563771e-02f,
  2.95328163e-02f, 2.17376314e-02f, 3.95140499e-02f, 1.02376845e-02f, -9.00203288e-02f, -2.68314257e-02f, -9.38945785e-02f, -1.10044144e-02f, -6.88515678e-02f, -2.62089949e-02f,
  -2.46940091e-01f, -2.43377656e-01f, -1.49415806e-01f, -3.73127833e-02f, -7.54416138e-02f, -1.36361003e-01f, -2.63435930e-01f, -7.65189230e-02f, 8.27935562e-02f, -1.60630405e-01f,
  -1.79509614e-02f, 2.01012217e-03f, -2.89124660e-02f, 5.67042269e-02f, 2.98429988e-02f, -8.58637169e-02f, -2.57005207e-02f, 8.14348906e-02f, -5.74187301e-02f, -6.30345643e-02f,
  -1.02516115e-01f, -7.26236179e-02f, 1.23874575e-01f, 1.13075987e-01f, -8.53353590e-02f, -8.26028269e-03f, 2.36541778e-02f, 1.97262224e-02f, 6.51408732e-02f, -1.87413357e-02f,
  -1.88210875e-01f, -2.50753090e-02f, -5.60902953e-02f, -2.35992223e-02f, -1.91665273e-02f, -3.58284276e-04f, -1.16952702e-01f, -3.96476984e-02f, -1.07973985e-01f, -2.45694034e-02f,
  1.76437397e-03f, 4.78935316e-02f, 6.84728241e-03f, 2.05326099e-02f, -1.20775260e-01f, -6.45303652e-02f, 1.19025014e-01f, -5.91950193e-02f, 9.20092463e-02f, 6.08683266e-02f,
  -5.95208351e-03f, 1.39114946e-01f, -9.55337361e-02f, 7.63340592e-02f, 5.98193109e-02f, 6.80460632e-02f, -2.02229042e-02f, -1.66773461e-02f, 8.72776657e-02f, -9.09452364e-02f,
  7.09773004e-02f, 3.97679163e-04f, -3.24629843e-02f, -5.82521595e-02f, -1.15613058e-01f, -5.48954383e-02f, -4.92342152e-02f, 6.21371493e-02f, -1.96163561e-02f, -7.49142542e-02f,
  3.07485536e-02f, -5.12484126e-02f, 4.03363705e-02f, -8.67695436e-02f, -3.53910122e-03f, -2.20377520e-02f, -3.13917873e-03f, -3.59554105e-02f, -5.15529560e-03f, 6.99272752e-02f,
  2.69611236e-02f, -2.99139787e-02f, 1.84976421e-02f, -4.94255312e-02f, 3.73124657e-03f, 4.57674339e-02f, 2.96977069e-03f, -1.38764558e-02f, -6.88603744e-02f, 5.97376004e-03f,
  -3.46710265e-01f, 3.64894390e-01f, -1.83950454e-01f, -4.79018502e-03f, 2.86420491e-02f, -1.34158619e-02f, 4.49082367e-02f, 5.30032404e-02f, 6.65465593e-02f, -3.32606770e-02f,
  -3.32583189e-02f, -2.86588985e-02f, -3.12755108e-02f, 2.32758969e-02f, 5.36482688e-03f, -5.73011413e-02f, -4.14598845e-02f, -4.31205705e-02f, 1.33958124e-02f, -3.65050025e-02f,
  -1.16087943e-02f, -8.29773843e-02f, -9.81331989e-02f, -1.54046059e-01f, -9.64964926e-02f, -2.61678454e-02f, -1.15841404e-01f, -1.43479347e-01f, -1.40680298e-01f, -3.43175858e-01f,
  1.34358674e-01f, -1.35081276e-01f, -1.80765626e-03f, -3.76365446e-02f, -2.75733203e-01f, -2.38552511e-01f, -5.04418135e-01f, -1.45479711e-02f, 3.95148620e-02f, -1.31424814e-01f,
  1.26845092e-01f, 3.49948704e-01f, 3.14120829e-01f, 3.30926478e-01f, 1.63801700e-01f, -3.02812845e-01f, -3.34898174e-01f, 8.51909742e-02f, 2.55645931e-01f, -4.36199382e-02f,
  -5.86546622e-02f, -5.44143692e-02f, 1.35161281e-01f, 7.67225176e-02f, -7.96800330e-02f, 2.34102026e-01f, -2.66567767e-02f, -6.71481043e-02f, -5.97412772e-02f, -1.07161850e-01f,
  2.17886180e-01f, -3.38936076e-02f, 5.53606190e-02f, 1.10301562e-02f, -4.29701209e-02f, -1.65518299e-02f, 2.22226810e-02f, 7.80019313e-02f, -2.02532094e-02f, -3.50585729e-02f,
  1.45711666e-02f, -7.62383714e-02f, -5.24109136e-03f, 8.32722709e-02f, -8.68302733e-02f, -8.28921571e-02f, 1.10656925e-01f, 8.44135061e-02f, 2.35853884e-02f, 8.32707658e-02f,
  -3.35955359e-02f, -3.36225815e-02f, -1.10048905e-01f, -4.83946688e-02f, 5.77968806e-02f, 1.35430515e-01f, 5.28280213e-02f, -1.14426333e-02f, 7.29385912e-02f, 3.87734510e-02f,
  -2.20176950e-02f, -3.14047188e-02f, -3.55279073e-02f, -1.73937622e-02f, -1.50149520e-02f, 4.11412306e-03f, -4.04074639e-02f, 3.31805157e-03f, -4.69054952e-02f, -3.19821872e-02f,
  5.32345176e-02f, -9.05668288e-02f, -4.47570607e-02f, -4.96425964e-02f, -2.14077998e-02f, -1.63300876e-02f, -1.08078741e-01f, -2.42411681e-02f, 3.89330760e-02f, -9.68657620e-03f,
  9.55033861e-03f, -3.99364009e-02f, -2.25352892e-03f, 5.57456687e-02f, -6.87394962e-02f, 5.51284365e-02f, 1.51180699e-02f, -4.55128066e-02f, 6.47725211e-03f, -4.32799719e-02f,
  8.24097916e-02f, 5.15691824e-02f, 4.35093306e-02f, 1.26513228e-01f, -5.62533624e-02f, 1.06831074e-01f, 8.35141260e-03f, -2.30785068e-02f, -1.61036551e-02f, 1.53982006e-02f,
  -6.22071885e-02f, -1.31409774e-02f, 3.15784402e-02f, -9.59560927e-03f, -6.37316406e-02f, -3.63053009e-02f, -1.15922593e-01f, 2.61669736e-02f, -5.98781779e-02f, -5.57851233e-02f,
  -3.06144897e-02f, -6.25967830e-02f, 6.33966252e-02f, -2.11996846e-02f, -2.76295748e-02f, -6.04686290e-02f, -7.78125748e-02f, -7.00267330e-02f, -7.18386024e-02f, -1.13052167e-01f,
  -8.16250145e-01f, -1.65264785e-01f, 2.61192769e-01f, -6.58722937e-01f, -2.80710340e-01f, 1.76622242e-01f, -1.11734882e-01f, -3.77502628e-02f, -2.27844119e-01f, -5.00871427e-02f,
  1.46081910e-01f, 8.61778185e-02f, 5.34038134e-02f, 1.11177020e-01f, 2.11883679e-01f, -8.31429064e-02f, -1.82889909e-01f, 9.79943201e-02f, 1.81627631e-01f, -8.06398690e-02f,
  -1.81856677e-01f, -3.62824351e-01f, -8.86473507e-02f, -3.79382744e-02f, -1.30164057e-01f, 1.17455637e-02f, 1.11421987e-01f, -7.88637102e-02f, 2.03034922e-01f, -3.21458161e-01f,
  4.89784479e-02f, -1.28303707e-01f, 1.58210561e-01f, -7.91474879e-02f, -6.46530231e-03f, -7.63973221e-02f, -4.38927114e-02f, -9.27349627e-02f, -1.28740547e-02f, -7.92508572e-02f,
  -2.43875049e-02f, 1.98721327e-02f, -4.60674055e-02f, -2.01420747e-02f, -1.42514378e-01f, 1.66378785e-02f, 4.75228541e-02f, 5.18784374e-02f, 9.72782075e-02f, 5.84264286e-02f,
  -4.39567454e-02f, 9.78256389e-03f, -2.49738377e-02f, 1.85920492e-01f, -3.70518900e-02f, 6.10281341e-02f, 9.00341198e-02f, 8.88202935e-02f, 1.80658728e-01f, -1.78002551e-01f,
  -2.34926417e-02f, 5.91596663e-02f, 1.35313626e-02f, -7.25819319e-02f, 3.82686080e-03f, -2.06483677e-02f, -1.11782309e-02f, -2.22976021e-02f, 6.79820254e-02f, 3.98247736e-03f,
  5.03013209e-02f, -4.18453366e-02f, 4.49452028e-02f, -3.53802070e-02f, 3.49642001e-02f, 1.44735090e-02f, -6.43178960e-03f, 7.72480592e-02f, 2.82495953e-02f, -2.37098709e-02f,
  2.69367788e-02f, 2.35357936e-02f, -4.84788492e-02f, 3.95125225e-02f, 2.16050837e-02f, 3.96127887e-02f, 2.09032539e-02f, 4.21794644e-03f, 4.38907631e-02f, -5.97905666e-02f,
  -1.02221608e-01f, 2.52940029e-01f, -2.02624321e-01f, -1.51538877e-02f, -1.55456439e-01f, 5.48733436e-02f, -7.35820010e-02f, -1.92286689e-02f, -8.75441208e-02f, -5.06625744e-03f,
  -8.30187462e-03f, -1.77814551e-02f, -8.35499987e-02f, 1.94975629e-03f, -4.58386056e-02f, 3.02725434e-02f, -4.08922359e-02f, -3.12074684e-02f, 2.73211906e-03f, 6.87295794e-02f,
  3.70030142e-02f, -1.03481179e-02f, -5.18244915e-02f, 2.53090970e-02f, -8.56835693e-02f, -1.12211399e-01f, -1.04397619e-02f, -1.57768354e-01f, 9.19367187e-03f, -1.59948081e-01f,
  -2.78986186e-01f, 4.52036113e-01f, -5.96831515e-02f, 4.62507419e-02f, 1.99187785e-01f, 5.77725805e-02f, 3.94720793e-01f, 1.31174430e-01f, -1.22021104e-03f, 1.62911668e-01f,
  5.48086017e-02f, -2.90709347e-01f, -1.82981551e-01f, -1.70686528e-01f, -6.84593394e-02f, 2.16754258e-01f, 1.52427256e-01f, -2.74060220e-01f, -5.04183412e-01f, -1.75100297e-01f,
  1.11052372e-01f, 3.70579958e-02f, -2.74409592e-01f, -1.66480646e-01f, 1.73195526e-01f, -2.72043616e-01f, 1.16800867e-01f, 2.32462306e-02f, -3.51160276e-03f, -5.29964492e-02f,
  -1.80147111e-01f, 1.49333745e-01f, -2.15522692e-01f, -3.65385041e-02f, 5.92598645e-03f, -9.13669243e-02f, -4.41238470e-02f, 4.26562354e-02f, 2.49625575e-02f, 2.88555212e-02f,
  1.12485094e-02f, 9.73188803e-02f, 5.71720721e-03f, -1.80622041e-02f, 2.52427422e-02f, -4.67481129e-02f, 1.60119813e-02f, -2.33418699e-02f, 4.06755395e-02f, 3.91962714e-02f,
  7.39003420e-02f, 6.69626817e-02f, 4.94157076e-02f, 1.20839395e-01f, 2.17337385e-02f, -1.09586239e-01f, 8.98535997e-02f, -1.12373732e-01f, -1.00917168e-01f, -9.19652730e-03f,
  -9.48545337e-02f, -9.03318897e-02f, 1.46760996e-02f, -3.70161347e-02f, 6.54007047e-02f, 3.03747188e-02f, -4.25670994e-03f, -1.24182329e-02f, 2.19446030e-02f, -4.81352173e-02f,
  3.40912119e-02f, -3.99385579e-02f, 4.96668331e-02f, 3.96575220e-02f, -6.06092922e-02f, 4.58367318e-02f, -4.75797951e-02f, -3.20537202e-02f, 3.21308859e-02f, -1.50959939e-03f,
  -7.84423947e-03f, 5.14693968e-02f, -1.09547041e-02f, -9.83804837e-03f, 7.21768884e-04f, -1.02264091e-01f, -5.55881634e-02f, -4.71735522e-02f, -2.25939173e-02f, -3.94565612e-02f,
  1.13547757e-01f, -1.04530416e-01f, 1.61721893e-02f, -5.30676730e-02f, 4.54781279e-02f, 7.65963197e-02f, -5.56167364e-02f, 3.64464754e-03f, 7.64252618e-02f, 7.66853103e-03f,
  -5.90806007e-02f, -7.06721470e-02f, 7.08015338e-02f, -3.19329165e-02f, -9.11299065e-02f, 3.49594131e-02f, 6.77854270e-02f, 1.49107752e-02f, 3.22531201e-02f, 3.41152139e-02f,
  6.06735423e-02f, 5.14017083e-02f, -1.00713879e-01f, 5.99551462e-02f, 2.00778227e-02f, -1.02427341e-01f, -5.00451252e-02f, -9.92270187e-03f, -3.81691679e-02f, 9.40881073e-02f,
  5.72597861e-01f, -1.55112758e-01f, 3.00392479e-01f, 1.67368323e-01f, 3.11495876e-03f, -1.38921604e-01f, -4.30296808e-01f, -1.63448244e-01f, 5.69178201e-02f, -1.56265900e-01f,
  4.81875949e-02f, 2.02710807e-01f, 2.09349215e-01f, 1.47162825e-02f, -7.90465698e-02f, -3.16923410e-01f, -7.94709995e-02f, 1.74253926e-01f, -1.27716986e-02f, -2.81071126e-01f,
  -3.93606991e-01f, 3.00914096e-03f, 1.29078254e-01f, -5.35682179e-02f, -4.77762260e-02f, -6.20743558e-02f, -1.17334705e-02f, 6.53699562e-02f, -1.10628650e-01f, 1.07948393e-01f,
  1.88449129e-01f, 1.86955735e-01f, -1.16099849e-01f, 3.24254707e-02f, -9.25286952e-03f, -5.66392057e-02f, -1.48413733e-01f, 9.94882919e-03f, -1.09511241e-02f, -2.08944455e-02f,
  2.81513054e-02f, 7.51293004e-02f, 1.18278667e-01f, -6.01932555e-02f, -1.73264965e-02f, -8.64992589e-02f, -5.33303944e-03f, 2.55696039e-04f, 9.33091119e-02f, -8.13734904e-02f,
  -2.92171184e-02f, 1.32617816e-01f, 1.91796198e-01f, 1.35769381e-03f, -3.03992201e-02f, 1.61323808e-02f, 4.22580726e-02f, 6.86551407e-02f, 1.59482025e-02f, -8.75174105e-02f,
  2.12343130e-02f, 9.89661515e-02f, -7.72577748e-02f, -3.09335459e-02f, -5.71727641e-02f, 4.24620637e-04f, 7.48649985e-02f, -4.33584265e-02f, 9.23441127e-02f, -3.84409577e-02f,
  -2.23981198e-02f, 3.79448868e-02f, 6.59842864e-02f, -7.24093467e-02f, 1.21349795e-02f, 8.28320980e-02f, -2.59752776e-02f, -6.26734123e-02f, 1.38456067e-02f, -1.56225655e-02f,
  3.34719196e-02f, -2.12743017e-03f, 1.07289944e-02f, -7.90717080e-02f, -9.02613439e-03f, 1.40696159e-02f, -5.94583798e-05f, -3.57868373e-02f, 2.10677274e-02f, 1.25043336e-02f,
  -7.24780336e-02f, 3.57218795e-02f, 5.75709306e-02f, -3.26142162e-02f, -5.42774275e-02f, -9.52070281e-02f, 3.34123112e-02f, -1.03015669e-01f, -1.93598866e-02f, -6.52388670e-03f,
  -5.92002384e-02f, -8.58106017e-02f, -1.09569691e-02f, -1.24245808e-01f, -5.76455295e-02f, -8.09541345e-02f, -1.67420089e-01f, -1.07425526e-01f, -1.37151644e-01f, -9.50348973e-02f,
  -1.37299150e-01f, -2.00530693e-01f, -1.15905851e-01f, -9.43356976e-02f, -3.57725495e-03f, -1.24775670e-01f, -2.40275353e-01f, -1.12216771e-01f, -1.39190122e-01f, -4.04962063e-01f,
  -2.83236541e-02f, -2.71305591e-01f, 7.34043717e-02f, -2.92384755e-02f, 1.34712784e-02f, -2.26379968e-02f, -1.92093149e-01f, 5.88632040e-02f, 1.52925804e-01f, -1.52640060e-01f,
  1.82335600e-01f, 3.03583115e-01f, 3.11215430e-01f, 2.77829856e-01f, 2.67457157e-01f, -9.88682732e-02f, -2.82091260e-01f, 9.87539142e-02f, 4.92528468e-01f, 1.74439400e-01f,
  2.35165525e-02f, 2.41007544e-02f, 1.70209378e-01f, 2.18141645e-01f, -1.81334123e-01f, 2.16087148e-01f, -5.14163263e-02f, -7.98702091e-02f, 7.68736750e-02f, -3.71563733e-01f,
  -1.42328322e-01f, -2.00504497e-01f, 1.90898716e-01f, 1.30740838e-04f, 5.04225343e-02f, 4.66593616e-02f, 5.18640392e-02f, 6.25757128e-02f, 1.58746764e-01f, 3.45703773e-02f,
  -1.69939001e-03f, 7.91102350e-02f, 5.55306673e-02f, 1.51005748e-03f, -9.45402682e-03f, -1.03263324e-02f, 2.22401861e-02f, 1.64934918e-01f, 1.23004458e-04f, 7.72373453e-02f,
  -1.18417460e-02f, -1.18185468e-01f, -5.49787804e-02f, 9.11636651e-02f, 1.26312241e-01f, 1.81991830e-01f, 4.80808653e-02f, 7.17769563e-02f, 1.52934521e-01f, -5.57822920e-02f,
  1.97825730e-02f, -4.77291383e-02f, 4.53535118e-04f, -3.81528214e-02f, 9.79661290e-03f, -8.29518363e-02f, 1.41023118e-02f, 5.05404733e-02f, -2.02431828e-02f, 9.09552351e-02f,
  5.68121113e-02f, 8.67555384e-03f, -2.14817617e-02f, 6.96460903e-02f, 5.80135807e-02f, -5.85902259e-02f, -4.53121774e-02f, 2.73252111e-02f, 7.30536459e-03f, -4.19186465e-02f,
  1.44908112e-02f, -4.74874116e-02f, -4.18690667e-02f, -6.74608201e-02f, -2.07928084e-02f, -1.61352530e-02f, -1.10459261e-01f, 3.89906093e-02f, -3.52666341e-02f, -5.11551052e-02f,
  1.82554245e-01f, 1.08647093e-01f, -1.22511303e-02f, 6.78391606e-02f, 2.60448419e-02f, 1.01135299e-02f, -5.96551364e-03f, 3.75392265e-03f, -3.65741574e-03f, 8.37450996e-02f,
  1.64759587e-02f, 1.78480759e-01f, 3.38653699e-02f, -5.12422919e-02f, 7.76598155e-02f, 9.51631293e-02f, 3.37616615e-02f, 6.40950799e-02f, 9.92315784e-02f, -4.08405587e-02f,
  -3.08564324e-02f, -4.97606918e-02f, 5.24507836e-02f, 1.10001415e-01f, 1.23674124e-01f, 1.26006305e-01f, 1.26834139e-01f, 8.39101747e-02f, 1.51571736e-01f, 2.31793262e-02f,
  4.74402979e-02f, 2.89387345e-01f, -2.04469457e-01f, -1.36820719e-01f, -7.01168478e-02f, 5.92712723e-02f, 5.79293907e-01f, 1.34771779e-01f, -6.74377978e-02f, 1.05546445e-01f,
  1.84972342e-02f, 2.13427208e-02f, -4.69042221e-03f, 5.50301559e-02f, 3.12212914e-01f, 3.02214921e-01f, -2.51334403e-02f, -1.33338392e-01f, -4.63921949e-02f, 1.29273340e-01f,
  6.69977069e-02f, -2.55304016e-02f, -1.46935329e-01f, -2.06102263e-02f, -2.00751916e-01f, -1.25271484e-01f, -1.96735218e-01f, -1.90553784e-01f, 1.16207423e-02f, -4.60956037e-01f,
  -3.74726579e-02f, -3.72194014e-02f, 1.24487527e-01f, 1.39879175e-02f, -2.44761846e-04f, -9.03778523e-03f, 1.73624083e-02f, -1.30200788e-01f, -9.41734314e-02f, -3.43299098e-02f,
  -2.83786803e-02f, 7.18845939e-03f, -1.05210885e-01f, -9.60041732e-02f, -3.56149971e-02f, -5.07723261e-03f, -1.63687319e-01f, -5.36014475e-02f, 6.25715926e-02f, 2.87227426e-02f,
  1.66725516e-02f, -2.54355557e-02f, -6.30867928e-02f, 7.92453215e-02f, 4.64589819e-02f, -3.69020738e-02f, -5.17680533e-02f, -1.36627272e-01f, -5.22826575e-02f, -5.43415397e-02f,
  7.52079934e-02f, -2.59216093e-02f, -1.77176744e-02f, 6.40951768e-02f, 3.42420861e-02f, -1.18560214e-02f, -7.52710328e-02f, 4.34602797e-02f, 1.16192140e-01f, 3.19568738e-02f,
  4.10498865e-02f, -1.33900773e-02f, 8.92452300e-02f, 5.58886454e-02f, -1.45489603e-01f, -8.87270793e-02f, -8.18417966e-02f, -9.64713283e-03f, 5.32426592e-03f, -7.78350085e-02f,
  4.87520173e-02f, -2.07737908e-02f, -4.08316068e-02f, 1.29018910e-02f, 2.05770265e-02f, -9.90965217e-03f, -2.89265309e-02f, -3.33945118e-02f, -6.63244948e-02f, 4.56308462e-02f,
  2.24886509e-03f, 1.91441566e-01f, 3.90148610e-02f, 1.97055768e-02f, -3.60626467e-02f, -7.51281157e-02f, -2.09836639e-03f, -7.77779818e-02f, 2.83038355e-02f, 1.03306279e-01f,
  2.66317688e-02f, 1.53439166e-03f, 9.65780914e-02f, -3.47996615e-02f, 8.16617534e-02f, 1.28612351e-02f, 5.64534180e-02f, -5.65027120e-03f, -1.67882082e-03f, -4.37692404e-02f,
  2.78422087e-02f, 9.58829373e-03f, 1.88563839e-01f, 1.63753465e-01f, 4.84796874e-02f, 1.45417780e-01f, 1.35764286e-01f, -2.20151376e-02f, 1.90721065e-01f, 3.96748483e-01f,
  -6.12801850e-01f, -5.25608659e-02f, -1.34250462e-01f, -1.75116807e-01f, 5.72720654e-02f, 1.47907227e-01f, 1.05504125e-01f, -5.67551926e-02f, -2.72575207e-02f, -4.51585241e-02f,
  -1.97930597e-02f, -8.64153653e-02f, -1.02453962e-01f, 2.19604783e-02f, -7.97008425e-02f, 1.64535344e-01f, 2.61044502e-01f, -1.65867120e-01f, 6.75799884e-03f, 1.77540436e-01f,
  2.53054321e-01f, -5.37039414e-02f, -2.36883476e-01f, -1.33794978e-01f, 1.71284154e-01f, 1.27721354e-01f, 1.80865064e-01f, -1.82480980e-02f, 1.57344595e-01f, 7.21483082e-02f,
  -2.60500640e-01f, -1.48224503e-01f, 1.00413403e-02f, 1.74001381e-02f, 4.83915471e-02f, -1.35856003e-01f, -4.68415348e-03f, 3.34465946e-03f, -5.67781180e-02f, -7.89128691e-02f,
  -8.97392258e-03f, -5.22597646e-03f, -1.45158857e-01f, -7.97610823e-03f, -6.29246607e-02f, -3.98768857e-02f, -1.45715494e-02f, -1.17759392e-01f, -5.86398654e-02f, -6.46845251e-02f,
  8.76438022e-02f, 7.29393139e-02f, -1.90949440e-01f, -1.28219626e-03f, 2.55159903e-02f, 4.98151639e-03f, 4.49805111e-02f, 6.27692342e-02f, -1.11674722e-02f, -5.13068736e-02f,
  -2.37076189e-02f, -1.37564853e-01f, -1.32238157e-02f, 2.84512714e-02f, -3.67123112e-02f, 2.04059407e-02f, -1.65560991e-02f, 7.25074112e-02f, -7.81026622e-03f, 1.92600265e-02f,
  -2.86411960e-02f, -3.74721438e-02f, 3.62111628e-02f, -6.14929870e-02f, 5.18027926e-03f, -6.51177391e-02f, 6.10270596e-04f, 1.40581932e-02f, 4.19875532e-02f, -5.94703220e-02f,
  -4.15932350e-02f, -3.14700976e-02f, -1.32064596e-02f, -3.04681808e-02f, 9.70350802e-02f, 1.34279236e-01f, 4.18096446e-02f, 1.87938791e-02f, -6.23268113e-02f, -2.05439441e-02f,
  -1.66817591e-01f, 1.80611253e-01f, -2.29265336e-02f, 2.59949658e-02f, 7.85584077e-02f, 1.39948847e-02f, 7.61136711e-02f, 7.85234869e-02f, -7.12647289e-02f, -2.25163475e-02f,
  4.42254245e-02f, -4.45366390e-02f, 4.30146046e-02f, 3.08199301e-02f, -8.55971724e-02f, 5.15913479e-02f, 9.17586908e-02f, 9.30451509e-03f, 6.82453737e-02f, -4.78768051e-02f,
  -1.27806840e-02f, 5.24920262e-02f, -7.86750242e-02f, -5.20653166e-02f, -1.12550827e-02f, 2.62738746e-02f, -8.24996531e-02f, -2.26270482e-02f, -1.58465337e-02f, -7.10977167e-02f,
  3.90781999e-01f, -3.08854312e-01f, -3.34521793e-02f, 4.21457052e-01f, 1.17181703e-01f, -1.99818954e-01f, -2.91108549e-01f, -2.15277627e-01f, 1.07752033e-01f, -3.83745059e-02f,
  -8.86367038e-02f, 1.41359031e-01f, 1.25460729e-01f, 1.51368883e-02f, 8.75817146e-03f, 4.06465158e-02f, 1.89904481e-01f, 1.31016508e-01f, 2.15545788e-01f, 1.31531715e-01f,
  7.21145496e-02f, 1.84083238e-01f, 2.09031522e-01f, 5.29620349e-02f, 4.64803763e-02f, 1.19883411e-01f, 6.37404695e-02f, 8.82979333e-02f, -1.15398630e-01f, 3.26346636e-01f,
  -1.94638839e-03f, -1.07634023e-01f, 5.88290617e-02f, 7.57467672e-02f, -7.96755701e-02f, -5.66097721e-02f, -7.10665286e-02f, -6.04332089e-02f, -1.93948150e-02f, -1.11495536e-02f,
  1.34438038e-01f, -5.69092529e-03f, -1.00103887e-02f, -5.00035025e-02f, -2.10628342e-02f, 2.31368910e-03f, -2.46881787e-02f, -8.07037055e-02f, -6.86162040e-02f, -1.15782032e-02f,
  -9.32326540e-02f, -2.00509671e-02f, -1.09688476e-01f, -8.99667963e-02f, -1.18671067e-01f, 1.08476393e-01f, -2.08687663e-01f, -1.16216451e-01f, -1.05326168e-01f, -4.05165404e-02f,
  -9.90365352e-03f, -8.41908678e-02f, -1.46841642e-03f, -4.66368832e-02f, 2.65745074e-02f, 8.44628084e-03f, -2.52846442e-03f, 4.75480743e-02f, 5.01835765e-03f, -2.09033024e-02f,
  -2.37962995e-02f, -7.98783526e-02f, -2.87472568e-02f, 1.27386749e-02f, 9.09352005e-02f, 2.15621535e-02f, -2.12618001e-02f, 1.15444742e-01f, 2.83582490e-02f, 8.70518610e-02f,
  6.22971319e-02f, -1.90243162e-02f, 1.05916888e-01f, -3.70880999e-02f, -3.17969769e-02f, 2.92090196e-02f, 6.53348863e-02f, -9.53492336e-03f, 6.47058189e-02f, 4.24085837e-03f,
  1.01396851e-01f, -6.47201538e-02f, 7.03757256e-02f, 8.79626945e-02f, 7.13229850e-02f, -9.27448738e-03f, -2.16193637e-03f, 3.21449898e-02f, -4.82221926e-03f, 7.43220970e-02f,
  4.66626324e-02f, -4.92691703e-04f, 1.57880615e-02f, -3.88251655e-02f, -4.69613001e-02f, 1.27608851e-01f, 8.46594051e-02f, 6.69858158e-02f, 4.76814806e-02f, 1.02220878e-01f,
  -3.50162527e-03f, 3.43279913e-02f, 1.00729009e-02f, -2.59574000e-02f, 3.74094658e-02f, 1.32201448e-01f, -6.32962584e-02f, -4.87066507e-02f, -2.91162711e-02f, -1.47903591e-01f,
  2.62943774e-01f, -3.36364880e-02f, 4.65587705e-01f, 1.67892382e-01f, -8.05290118e-02f, 4.40411717e-02f, 7.47708678e-02f, -1.04385518e-01f, -1.38464198e-01f, -9.53883454e-02f,
  -6.48109540e-02f, -1.63060501e-01f, -6.88749999e-02f, -5.13039306e-02f, 4.27224115e-02f, 1.97751343e-01f, 3.51368994e-01f, 2.03600630e-01f, -8.73830765e-02f, -2.42043003e-01f,
  -2.25259602e-01f, 6.72444850e-02f, 8.92419368e-02f, -2.28980761e-02f, 9.40691587e-03f, -1.71674609e-01f, 9.65519994e-02f, 2.68324353e-02f, -5.74585609e-02f, 3.24531108e-01f,
  8.47574547e-02f, 1.09550871e-01f, -6.03716560e-02f, -1.28563181e-01f, -5.41208833e-02f, -5.25854379e-02f, -4.09479626e-02f, -1.22153107e-02f, 1.62617322e-02f, 1.05968833e-01f,
  -5.50229961e-05f, -9.72759128e-02f, 7.75891617e-02f, -8.61906782e-02f, 9.38498750e-02f, 1.06812708e-01f, -1.29889941e-03f, 5.78512996e-02f, -4.23352979e-02f, -9.72340927e-02f,
  -6.61398396e-02f, -1.28786219e-02f, 2.79914923e-02f, -1.43546355e-03f, -7.54176080e-02f, -3.77752003e-03f, -6.40441030e-02f, -1.68225430e-02f, -1.25344217e-01f, -3.55672613e-02f,
  8.22229385e-02f, 8.76534954e-02f, 5.61867915e-02f, 8.13259110e-02f, 6.95465039e-03f, 4.74320464e-02f, 4.23970632e-02f, 1.30266193e-02f, -4.57253978e-02f, 5.91132157e-02f,
  -6.50682021e-03f, 3.74358632e-02f, -1.00800162e-02f, 3.33043188e-02f, -4.06402387e-02f, -2.86134165e-02f, -5.29378876e-02f, -1.56840105e-02f, 1.21316299e-01f, -2.13311836e-02f,
  6.56367540e-02f, 2.25349162e-02f, 3.71300522e-03f, 4.41292524e-02f, 1.08088739e-01f, 2.40433682e-02f, -4.63320799e-02f, 2.40703835e-03f, -7.16449926e-03f, 9.54174101e-02f,
  -1.28316596e-01f, 3.81521545e-02f, -5.55779226e-02f, -3.15307342e-02f, -1.31721959e-01f, -1.22349143e-01f, -3.12745087e-02f, -4.01645936e-02f, 2.41220314e-02f, -3.64968106e-02f,
  -5.00844754e-02f, 2.67641270e-03f, -6.81084543e-02f, -2.01985263e-03f, -3.16271558e-02f, 1.38051203e-02f, -5.75802214e-02f, 1.36950351e-02f, -3.25313956e-02f, -3.79581228e-02f,
  -1.02879673e-01f, -8.03398490e-02f, 1.55036803e-02f, -4.37696874e-02f, -1.20816737e-01f, -7.99339861e-02f, 1.79615915e-02f, -5.55772632e-02f, -4.26151678e-02f, -2.81917661e-01f,
  3.36113006e-01f, -3.41312885e-01f, 6.63884163e-01f, -1.24107964e-01f, -6.33862093e-02f, 1.34498343e-01f, 5.57888933e-02f, 3.94666865e-02f, -1.75553009e-01f, -3.68229970e-02f,
  -4.50672470e-02f, -1.23965740e-01f, 2.16300264e-02f, 4.02638949e-02f, 1.98138788e-01f, -7.70224184e-02f, 4.12312485e-02f, 4.10253376e-01f, 4.58087921e-01f, -8.33278075e-02f,
  -3.39115977e-01f, -1.45187899e-01f, 1.60676926e-01f, 2.75232233e-02f, -1.40026152e-01f, 1.05405739e-03f, 6.69066980e-02f, -2.06286609e-02f, -7.57482275e-02f, -1.25603780e-01f,
  2.18439117e-01f, 5.72440103e-02f, 5.26035652e-02f, 4.66479221e-03f, 9.87722948e-02f, 1.34916589e-01f, 1.62164927e-01f, 1.61400884e-01f, 7.23612979e-02f, 6.72666505e-02f,
  4.69289608e-02f, 4.31704819e-02f, 3.39510553e-02f, 3.41255330e-02f, 3.06511857e-02f, 5.48272841e-02f, 1.56596396e-02f, 1.46296009e-01f, 2.08126739e-01f, 3.90950255e-02f,
  -1.50033191e-01f, 1.60290897e-01f, 2.42429286e-01f, -1.00008473e-02f, 1.41102612e-01f, 1.00416563e-01f, 8.68336633e-02f, 1.42863899e-01f, 3.06597590e-01f, 5.35233803e-02f,
  -4.20433879e-02f, -1.35714747e-02f, -6.08638972e-02f, -4.73911501e-02f, -3.88887487e-02f, 7.42722722e-03f, -1.09941810e-01f, -3.62681933e-02f, -4.92381416e-02f, 4.13306616e-02f,
  -9.14736558e-03f, 1.86015349e-02f, 2.17641995e-04f, -1.50841533e-03f, -7.95721412e-02f, -9.74937249e-03f, -3.81908170e-03f, -6.19804151e-02f, 2.72393022e-02f, -3.99056524e-02f,
  1.11028902e-01f, -7.22424686e-03f, -5.50103150e-02f, 1.38228701e-03f, 3.15262340e-02f, 1.20298885e-01f, 4.11178730e-02f, -2.97544561e-02f, 3.09294160e-03f, -6.97810277e-02f,
  -1.55868202e-01f, 1.10927790e-01f, 6.36477396e-02f, -3.89822572e-02f, 8.80297348e-02f, -3.93495848e-03f, -7.80269084e-03f, 5.49448431e-02f, 1.51790222e-02f, 1.15159802e-01f,
  4.12613787e-02f, 1.93577465e-02f, 2.16270890e-02f, -8.62271700e-04f, -1.65298600e-02f, -9.94212646e-03f, -6.68114722e-02f, 1.10386059e-01f, 4.61587086e-02f, 8.31350982e-02f,
  -2.02550068e-02f, 7.88850859e-02f, 1.22206934e-01f, 8.88647512e-02f, -1.88585895e-03f, 8.76209214e-02f, 1.70185030e-01f, 7.52127767e-02f, 1.48145884e-01f, -7.69229978e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.90312487e-01f, -8.02636147e-02f, -1.30300596e-01f, -8.18809569e-02f, 5.50523847e-02f, 3.01714987e-01f, -7.72243664e-02f, 9.91125330e-02f, 1.84456244e-01f, -1.50613859e-01f,
  2.88260709e-02f, 1.78243935e-01f, -1.56668454e-01f, -7.58938119e-02f, -9.77125019e-02f, -1.51784420e-01f, -4.04859215e-01f, -2.41290733e-01f, 3.46375316e-01f, 4.78263229e-01f,
  2.62637049e-01f, -1.29080519e-01f, -1.00684039e-01f, 7.74355382e-02f, -3.93367037e-02f, -1.57722309e-01f, -4.87105489e-01f, -3.60939652e-01f, -1.38229210e-04f, -6.59370363e-01f,
  -1.18720435e-01f, 2.93911826e-02f, 1.76139280e-01f, -1.63658082e-01f, -1.26229495e-01f, -4.67512347e-02f, 5.15026376e-02f, -2.56606132e-01f, -7.02503547e-02f, 2.43751071e-02f,
  -4.64011878e-02f, 2.04556897e-01f, -3.15541076e-03f, 1.53660635e-02f, 1.00369699e-01f, 1.37988716e-01f, 5.84665611e-02f, -5.06981462e-03f, 1.56096956e-02f, 2.18454003e-02f,
  1.26340836e-02f, -5.91816008e-02f, -2.34129041e-01f, 3.91897839e-03f, 9.54733044e-02f, -9.73474234e-02f, -7.24652484e-02f, 9.34977271e-03f, -9.71831307e-02f, -2.78099447e-01f,
  -1.96781624e-02f, 4.97418791e-02f, 5.11926673e-02f, -1.46548739e-02f, -2.55307443e-02f, 7.68406615e-02f, -4.37254980e-02f, 2.72463746e-02f, 4.45151962e-02f, -1.24829449e-01f,
  5.85556962e-02f, -4.21131700e-02f, 8.87654051e-02f, -7.91349262e-02f, -7.39325443e-03f, 8.04927945e-02f, -2.69882903e-02f, -6.68548271e-02f, 4.36331369e-02f, 4.08531167e-02f,
  1.19421221e-01f, -1.68128219e-02f, 4.67707701e-02f, 1.11501247e-01f, -3.64965387e-02f, -1.99491419e-02f, 1.46912485e-02f, 5.83089814e-02f, 7.88647681e-02f, -1.31871747e-02f,
  -2.37838313e-01f, -1.59158051e-01f, -1.86102614e-01f, 7.79961124e-02f, 8.59223865e-03f, 9.13966373e-02f, -1.13142982e-01f, 2.22456753e-02f, 2.78993808e-02f, 6.79536685e-02f,
  1.49450108e-01f, 6.49822950e-02f, -9.07101557e-02f, -1.10686314e-03f, 1.06535733e-01f, 1.16717085e-01f, -4.02929783e-02f, -1.29821301e-01f, 1.29726291e-01f, 1.30264804e-01f,
  -6.88950717e-02f, -4.05638069e-02f, -4.45343442e-02f, -2.36924842e-01f, 1.07525131e-02f, -1.43263429e-01f, -2.86089480e-01f, 5.81457727e-02f, -2.27939457e-01f, -5.90604722e-01f,
  -2.74061382e-01f, -1.20996334e-01f, -5.85636675e-01f, -9.91460532e-02f, -3.35969895e-01f, -2.49935046e-01f, -3.95551771e-01f, 1.77951574e-01f, 8.35453868e-02f, -3.31206918e-01f,
  -2.73147345e-01f, 2.16613654e-02f, -1.80697992e-01f, -1.24511778e-01f, -2.46378332e-01f, -5.09613156e-01f, -4.34037268e-01f, -3.65844756e-01f, -1.47711515e-01f, 3.25814486e-02f,
  -1.02582023e-01f, -1.34184197e-01f, -6.18150681e-02f, 3.39105874e-02f, 3.22221033e-02f, -7.41804168e-02f, -2.68437952e-01f, -6.02612905e-02f, -5.55679481e-03f, -3.23594868e-01f,
  -3.20878029e-01f, 3.48933786e-01f, 6.21345006e-02f, 1.72167912e-01f, 5.40098175e-03f, 5.81671074e-02f, -1.29078791e-01f, 3.96769121e-02f, 8.20910484e-02f, -6.80680759e-03f,
  1.70693882e-02f, 6.18175380e-02f, -1.06411897e-01f, 6.65759146e-02f, -1.22995973e-01f, 9.78050455e-02f, 9.09321755e-02f, -5.15856110e-02f, -6.72704261e-03f, 3.23420241e-02f,
  2.71077808e-02f, 1.34917930e-01f, 1.46487042e-01f, 2.45183527e-01f, 2.11663544e-01f, -4.71523553e-02f, 1.33258462e-01f, 2.59812921e-01f, 8.62275437e-02f, 2.25092500e-01f,
  -3.22052576e-02f, -1.94506437e-01f, 1.06652513e-01f, 5.38746975e-02f, 5.45063578e-02f, 2.28085695e-03f, -4.87511009e-02f, -1.15264215e-01f, 4.23995890e-02f, -8.73727631e-03f,
  1.08199026e-02f, 1.34241292e-02f, 2.10709753e-03f, -1.08045243e-01f, 8.10705218e-03f, 4.48132446e-03f, -1.08985655e-01f, 1.11062117e-02f, 6.45305440e-02f, 2.65560076e-02f,
  8.17093849e-02f, -7.57570639e-02f, -7.42751583e-02f, 3.40957530e-02f, -1.92738418e-02f, -3.92608829e-02f, -1.14316680e-02f, 1.42023861e-02f, -4.47737519e-03f, -8.49746838e-02f,
  6.22332618e-02f, 4.89206687e-02f, -1.09385416e-01f, 1.61173925e-01f, -5.80752455e-02f, 6.37160763e-02f, 3.03700678e-02f, 3.48038860e-02f, -1.21341258e-01f, 4.09135260e-02f,
  7.34722093e-02f, -8.75775516e-02f, -1.18519373e-01f, 1.54729620e-01f, 5.55115715e-02f, 8.59632790e-02f, 9.27913561e-02f, -7.52006918e-02f, -6.50012568e-02f, 5.53060845e-02f,
  -9.01260530e-04f, 1.41491935e-01f, 1.07455529e-01f, 1.68235432e-02f, 8.81877914e-02f, -1.83743387e-01f, -1.22585334e-02f, 1.36416391e-01f, -1.38559952e-01f, 6.53528199e-02f,
  -3.31513524e-01f, -4.98220146e-01f, 4.57715631e-01f, -4.59672272e-01f, 1.50308713e-01f, 3.35756153e-01f, 3.95433813e-01f, 7.45259644e-03f, -2.90988892e-01f, 3.31255421e-02f,
  -3.37561965e-01f, -2.78764933e-01f, -2.93857008e-01f, -1.69571966e-01f, -9.99000296e-02f, 2.42091119e-01f, 7.35710114e-02f, 2.30838850e-01f, 5.41162431e-01f, 3.28090578e-01f,
  6.70393258e-02f, -8.73141084e-03f, -1.44218743e-01f, 1.31087722e-02f, -1.70307338e-01f, 1.39314532e-01f, -2.04831749e-01f, -1.59777313e-01f, 1.59371644e-02f, -2.14367792e-01f,
  3.97746980e-01f, -2.76366383e-01f, -2.94024162e-02f, -2.30041429e-01f, -1.53211057e-01f, -2.16746833e-02f, 1.22493677e-01f, -6.69171065e-02f, -3.14312689e-02f, 3.17401327e-02f,
  -1.03911474e-01f, 8.57579056e-04f, -5.79787791e-02f, 1.30643889e-01f, 5.59852123e-02f, 7.39272311e-02f, -5.26706204e-02f, -9.42743756e-03f, -1.70700222e-01f, 3.10159046e-02f,
  -1.27921090e-01f, -6.49934486e-02f, 1.11844413e-01f, 9.43708941e-02f, 1.24396011e-02f, -8.35872069e-03f, 3.45401186e-03f, 4.54185605e-02f, -2.28136200e-02f, -8.26309100e-02f,
  -6.50051311e-02f, 5.41124418e-02f, -2.38911100e-02f, 5.49041433e-03f, 6.19263612e-02f, 5.77433445e-02f, 2.81672515e-02f, -2.19484642e-02f, 9.43600014e-03f, -8.79253168e-03f,
  2.80393828e-02f, -1.02751128e-01f, 5.08011924e-03f, 1.01551153e-02f, -9.00952816e-02f, -6.91929609e-02f, 4.26697172e-02f, -6.33992720e-03f, -1.05181843e-01f, -5.96068501e-02f,
  -1.63970917e-01f, 2.96355356e-02f, -3.13804857e-02f, 7.23371143e-03f, -1.07755937e-01f, 7.09788734e-03f, -3.34943905e-02f, -3.15153934e-02f, -1.79879721e-02f, 4.81892005e-02f,
  -3.68508101e-02f, -1.12650961e-01f, 1.27920672e-01f, -4.44115475e-02f, -2.65786108e-02f, -1.78818107e-01f, -1.45751715e-01f, -8.44097659e-02f, -4.15691994e-02f, 6.10479265e-02f,
  -7.21334368e-02f, 7.55690932e-02f, 7.50618130e-02f, 1.03544071e-02f, 2.46189296e-01f, 4.69776895e-03f, -1.78227827e-01f, -1.53335175e-02f, -6.89986721e-02f, 7.72136450e-02f,
  4.08668816e-02f, 1.41674355e-01f, 1.72169492e-01f, 1.51089504e-01f, 4.09230143e-02f, 2.38254845e-01f, 1.38348550e-01f, 1.08673990e-01f, 1.82129532e-01f, 3.03793341e-01f,
  1.15172362e+00f, 4.71825600e-01f, 4.69520599e-01f, 1.95752122e-02f, -3.53371710e-01f, -2.28759442e-02f, 2.26732954e-01f, 3.25400792e-02f, -1.16120063e-01f, 6.51780814e-02f,
  1.47305712e-01f, -1.71519548e-01f, -9.96255949e-02f, -3.70693393e-02f, 2.16877252e-01f, -9.35486853e-02f, -2.68505961e-01f, 1.16775438e-01f, 2.23547950e-01f, -1.66565645e-03f,
  -2.22523659e-01f, 4.42472100e-02f, 2.84667552e-01f, 1.11017816e-01f, 7.53186410e-03f, -2.82641977e-01f, -2.37248875e-02f, -3.82954106e-02f, -2.69737188e-02f, 1.52524486e-01f,
  2.09898502e-01f, 5.02607405e-01f, -2.51085669e-01f, -8.71597975e-02f, 2.47728196e-03f, 6.54062256e-02f, 5.42285182e-02f, -1.96034852e-02f, -8.24983418e-03f, 2.27646865e-02f,
  -9.69181880e-02f, 2.56178901e-02f, -1.15888059e-01f, 9.74284187e-02f, -1.16880760e-02f, 2.11534068e-01f, 2.69619487e-02f, 1.49102673e-01f, 1.45609766e-01f, 1.27428338e-01f,
  -6.57291636e-02f, 7.32861385e-02f, 3.35732475e-02f, -1.06235467e-01f, 8.14398304e-02f, -2.02721525e-02f, 1.60557464e-01f, 1.24009043e-01f, 1.16518207e-01f, 4.55756709e-02f,
  -2.06191167e-01f, -1.10331103e-01f, 9.29462817e-03f, 7.09184855e-02f, -2.91257370e-02f, -8.32130536e-02f, -1.24901585e-01f, -2.11051963e-02f, -7.54899681e-02f, -6.43642023e-02f,
  -1.25850022e-01f, 5.34943230e-02f, 6.30162358e-02f, 7.80814365e-02f, -2.59649623e-02f, 1.00633383e-01f, -4.61195409e-02f, 1.52813509e-01f, 6.07783757e-02f, 9.96169355e-03f,
  -8.85753985e-03f, -1.87409688e-02f, 1.66149791e-02f, 1.04156904e-01f, -3.32507654e-03f, 2.65315883e-02f, -6.92079514e-02f, 7.46270940e-02f, -6.81678504e-02f, -1.19284630e-01f,
  -3.95692289e-01f, 6.62755221e-03f, -1.24060325e-01f, -3.09560727e-02f, 1.05716750e-01f, 2.06374712e-02f, 1.19345449e-01f, 9.18245614e-02f, -7.56490231e-03f, 9.98316407e-02f,
  1.78867802e-01f, 1.12691857e-01f, 2.97984518e-02f, 2.57035587e-02f, -5.38638234e-03f, 6.71312511e-02f, 5.97599223e-02f, 4.15783525e-02f, 1.86115019e-02f, 7.50742257e-02f,
  -5.31268790e-02f, -3.80467288e-02f, -1.79533646e-01f, -1.75872013e-01f, -5.81135713e-02f, -2.57277071e-01f, -5.23959398e-02f, 3.64995305e-03f, -4.25789505e-02f, -2.71647215e-01f,
  1.04547536e+00f, -5.40006518e-01f, -6.42473161e-01f, 1.14083506e-01f, -2.13640839e-01f, 1.31492808e-01f, -7.10041299e-02f, 2.79523969e-01f, 2.97153771e-01f, -2.00742215e-01f,
  -2.37243339e-01f, 1.06986269e-01f, -7.14347586e-02f, -6.19878210e-02f, 1.05475314e-01f, -2.73172200e-01f, -3.80620122e-01f, 3.93541250e-03f, 4.44756091e-01f, 2.59227663e-01f,
  5.27057089e-02f, 2.41936162e-01f, 2.99329579e-01f, 1.96143806e-01f, -1.80711538e-01f, 6.71499446e-02f, -4.70516473e-01f, -2.81668752e-01f, -3.22230339e-01f, -5.78585982e-01f,
  -2.94614047e-01f, -1.63344830e-01f, -1.62234038e-01f, 3.05187590e-02f, -1.82506472e-01f, 1.00675203e-01f, 9.04155225e-02f, -1.89193692e-02f, -2.58908384e-02f, -1.44562528e-01f,
  -3.23031843e-02f, 9.31575000e-02f, 1.09413348e-01f, -5.03129587e-02f, 2.30675787e-01f, 8.04854557e-02f, -6.41619563e-02f, 4.61413041e-02f, -8.23220462e-02f, -1.16952009e-01f,
  -2.23267287e-01f, -4.17938270e-02f, -4.26581502e-02f, -1.03618026e-01f, -5.58852926e-02f, -7.51065090e-02f, -2.14678317e-01f, -1.68862075e-01f, -5.49405478e-02f, -2.04017818e-01f,
  -1.54357046e-01f, -9.14612710e-02f, -2.57781637e-03f, 3.60587612e-02f, 8.87763724e-02f, 9.11839381e-02f, 1.72118917e-02f, -1.88133232e-02f, 1.38367608e-01f, -1.29984384e-02f,
  -1.00552300e-02f, -7.52860904e-02f, 7.23959953e-02f, -4.18017706e-04f, -7.55495429e-02f, 3.85890417e-02f, 2.25105397e-02f, -9.11968723e-02f, -4.97030169e-02f, 1.04031593e-01f,
  8.21021944e-02f, 2.32899468e-02f, -1.63700001e-03f, 3.64283100e-02f, -1.63388789e-01f, 3.89606575e-03f, -5.40745147e-02f, -7.72450939e-02f, 3.70954387e-02f, 3.47298017e-04f,
  1.65968567e-01f, -8.33515748e-02f, 9.56321284e-02f, 1.31325364e-01f, 1.68577731e-02f, -3.74945030e-02f, -1.06104016e-01f, -1.80552322e-02f, 5.61110787e-02f, 3.73427756e-02f,
  -8.62858817e-02f, 4.30689789e-02f, -6.23306260e-02f, -5.90352826e-02f, 8.57947916e-02f, -9.96978674e-03f, 6.33993447e-02f, 1.86529309e-01f, 1.46793991e-01f, -6.59485087e-02f,
  -2.31101434e-03f, 2.56735712e-01f, 3.32332343e-01f, 1.58018619e-01f, 9.00840983e-02f, 2.31663212e-01f, -3.76894772e-02f, 5.97697757e-02f, 1.60871238e-01f, 2.38045782e-01f,
  9.87048447e-02f, 3.49780351e-01f, 1.13710530e-01f, 6.31475076e-02f, 1.03376620e-01f, 2.72243470e-01f, 5.56338608e-01f, 2.37998903e-01f, -4.44522165e-02f, 6.79348782e-02f,
  4.70747575e-02f, 2.33676005e-02f, -5.28470986e-02f, -4.98894863e-02f, 2.08753407e-01f, 1.68699294e-01f, 1.32851765e-01f, -5.69189936e-02f, 6.12675995e-02f, 6.42514825e-02f,
  1.60120316e-02f, 1.50579602e-01f, 7.94417486e-02f, -7.92900100e-02f, 1.74839571e-01f, -1.22986525e-01f, 3.12005123e-03f, 1.78540528e-01f, 2.00437084e-01f, 2.58506238e-01f,
  -1.07620396e-01f, 3.65764022e-01f, -3.15520436e-01f, -2.29835019e-01f, -3.41369845e-02f, -2.03436047e-01f, -1.03682972e-01f, -8.94196611e-03f, -1.69279724e-01f, -6.59621954e-02f,
  1.29505754e-01f, -2.84183994e-02f, 1.51205093e-01f, 1.18852943e-01f, 8.16858560e-02f, 2.22885758e-02f, 8.35741237e-02f, 1.04483135e-01f, 1.66385800e-01f, 1.24675907e-01f,
  5.03522940e-02f, 6.60023317e-02f, 2.62582511e-01f, 6.46655858e-02f, 1.61880106e-01f, -6.92202151e-02f, 1.59720182e-01f, 7.50908330e-02f, -1.79000944e-02f, 1.11460261e-01f,
  -2.72855997e-01f, -1.92484576e-02f, 2.13498756e-01f, -2.44363397e-02f, 8.99643004e-02f, -1.03092179e-01f, 1.14151007e-02f, 1.75789222e-01f, 1.81469426e-01f, 9.69781578e-02f,
  8.17299485e-02f, -4.62212451e-02f, 1.29044652e-02f, -8.66491497e-02f, -5.08570410e-02f, 1.71216831e-01f, -2.54570376e-02f, -1.15119196e-01f, 1.01127170e-01f, 5.66649362e-02f,
  2.24638537e-01f, 7.76319727e-02f, 2.54639648e-02f, 6.20460361e-02f, 2.84690484e-02f, 5.58524393e-02f, 8.58240947e-02f, -1.53779704e-02f, 5.39114736e-02f, -2.21687257e-02f,
  -1.00740142e-01f, 1.50727248e-02f, -9.90270004e-02f, 5.87306917e-02f, 3.20858285e-02f, -9.06856880e-02f, -6.01260811e-02f, -1.10151827e-01f, -1.61625177e-01f, -1.04841352e-01f,
  5.94593957e-02f, 9.03191343e-02f, 1.27582937e-01f, 4.30818051e-02f, -3.23980190e-02f, -5.99025823e-02f, -1.40130967e-01f, 8.75482336e-04f, -4.18161638e-02f, -1.35597616e-01f,
  -4.79546981e-03f, -1.19863868e-01f, -1.21241637e-01f, -8.82523730e-02f, -8.12685192e-02f, -2.34363288e-01f, -3.94978747e-02f, -9.20193866e-02f, -4.08739150e-02f, -2.38103271e-01f,
  5.60418129e-01f, 2.32721597e-01f, -3.40106227e-02f, 8.00846070e-02f, -3.92806560e-01f, -2.44228080e-01f, -6.57150522e-02f, 1.03217572e-01f, -4.50891331e-02f, -5.51150702e-02f,
  -3.19582105e-01f, -7.51817450e-02f, -5.73107488e-02f, 9.97992605e-02f, 2.23302513e-01f, 3.68446708e-01f, 3.84364158e-01f, 2.26692080e-01f, 1.04078658e-01f, 4.89584468e-02f,
  1.19627468e-01f, 8.74719992e-02f, 1.55035898e-01f, 2.47929633e-01f, 3.14333767e-01f, -1.14290372e-01f, 8.04694646e-05f, -3.95186692e-02f, -4.75795493e-02f, 4.76665318e-01f,
  -2.48047441e-01f, 1.29331082e-01f, 5.65033965e-02f, 1.11540303e-01f, -4.76663299e-02f, 1.25632882e-01f, 6.73732534e-02f, 1.78082418e-02f, -2.28566974e-01f, -4.40051369e-02f,
  -7.03179538e-02f, -1.09855592e-01f, -5.29317334e-02f, 3.19033787e-02f, -5.53927645e-02f, 1.04205525e-02f, 1.83490783e-01f, 1.44160420e-01f, -4.36675809e-02f, 7.82274976e-02f,
  -5.07100038e-02f, -1.42441481e-01f, -2.04277143e-01f, -1.04877435e-01f, 9.74747166e-03f, -1.77989155e-01f, 1.04326699e-02f, 1.18978307e-01f, -1.57880411e-02f, 2.09986091e-01f,
  -1.60069793e-01f, 3.00037060e-02f, 1.51134776e-02f, 4.68555326e-03f, 3.24957222e-02f, 2.66817939e-02f, 1.22566156e-01f, -2.47015506e-02f, -2.97424942e-02f, 1.83167130e-01f,
  -1.05314009e-01f, -7.60563612e-02f, -8.92596915e-02f, -3.72492708e-03f, -1.32452250e-01f, -5.04576154e-02f, 6.24787547e-02f, 1.27584711e-02f, -2.24862769e-01f, -7.71402419e-02f,
  5.03381947e-03f, 3.32107656e-02f, -4.45083110e-03f, 1.84450269e-01f, 6.91919029e-02f, 2.20887270e-02f, -7.31719211e-02f, -1.32642284e-01f, -1.16791781e-02f, -7.14745149e-02f,
  -4.04696882e-01f, -3.99819821e-01f, 1.38637319e-01f, 1.97263524e-01f, 3.55977230e-02f, 3.05004921e-02f, -1.49779871e-01f, -1.25047773e-01f, -2.00804353e-01f, 6.79180399e-02f,
  2.94030854e-03f, 1.14861727e-02f, 3.27064507e-02f, 3.81315425e-02f, -2.59475913e-02f, -1.50508657e-01f, -6.51937735e-04f, 5.92748933e-02f, -7.28540495e-02f, -9.59080905e-02f,
  5.21303676e-02f, 4.28012758e-02f, -1.94987640e-01f, -2.19937302e-02f, 9.16546583e-02f, -2.27181792e-01f, -1.52757987e-01f, -6.99756369e-02f, -8.30606148e-02f, 1.25846222e-01f,
  5.26285581e-02f, 1.65635109e-01f, 2.56580442e-01f, 3.12391996e-01f, 5.57986259e-01f, 5.77133060e-01f, 6.20721459e-01f, 3.25415403e-01f, 7.20439777e-02f, 1.09839678e-01f,
  2.66141266e-01f, 6.03645146e-02f, -3.20005901e-02f, -5.89886867e-02f, 2.06425965e-01f, 1.67600423e-01f, 6.19392507e-02f, -1.19562238e-01f, 1.02205895e-01f, 1.07375078e-01f,
  9.48134065e-02f, 2.98765246e-02f, -1.72646753e-02f, 1.40584656e-03f, -1.36928603e-01f, -1.22790582e-01f, 6.09448254e-02f, 1.57622308e-01f, -3.13951336e-02f, -3.16869885e-01f,
  -8.27772468e-02f, 3.22865009e-01f, 1.23526126e-01f, -1.26802683e-01f, -3.68159190e-02f, -2.00740606e-01f, -9.87749845e-02f, -1.61350861e-01f, -5.45756742e-02f, 5.03274314e-02f,
  7.43200928e-02f, -1.52033567e-01f, -2.54938044e-02f, -4.43094820e-02f, -3.72644775e-02f, -1.73365849e-03f, -1.90465629e-01f, 6.98908838e-03f, -3.83415259e-02f, 3.05383168e-02f,
  1.25435308e-01f, 1.44423485e-01f, 3.96910578e-01f, 1.62294462e-01f, 8.82832147e-03f, 8.07893202e-02f, 1.38021633e-01f, 3.78864184e-02f, -5.28582521e-02f, -1.35800034e-01f,
  2.83569515e-01f, 1.29810378e-01f, -3.18993479e-02f, 8.75964686e-02f, -6.88427389e-02f, -1.97310150e-02f, -1.42550860e-02f, 1.22331910e-01f, 2.41472982e-02f, -1.83160961e-01f,
  2.65867449e-04f, -1.10885486e-01f, 6.13348782e-02f, 2.57325247e-02f, -1.19966775e-01f, 1.30938021e-02f, -2.29385402e-02f, 1.78502984e-02f, 4.39147204e-02f, -2.95805912e-02f,
  -2.10690498e-02f, 6.08602762e-02f, -6.50919601e-02f, -1.45152092e-01f, -2.02417985e-01f, 2.58774962e-02f, 2.96015237e-02f, 5.78812398e-02f, 1.51730804e-02f, -3.07941101e-02f,
  -8.75648558e-02f, 4.29023176e-01f, 4.35598195e-02f, -4.31410968e-02f, -1.24617860e-01f, -1.11901455e-01f, 4.00596112e-02f, -1.04361968e-02f, 1.03914969e-01f, 1.43829048e-01f,
  2.29176298e-01f, 9.54646915e-02f, -4.19865884e-02f, -1.39054820e-01f, -6.60405075e-03f, -5.53698614e-02f, -8.78548250e-02f, -9.77521949e-03f, -4.67910618e-03f, 5.80167733e-02f,
  9.42206680e-05f, 1.58407748e-01f, 2.94393241e-01f, 1.87008351e-01f, 6.08141311e-02f, 1.61394998e-01f, -1.46045731e-02f, -7.26194084e-02f, -6.13617599e-02f, -2.03991473e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -1.63873300e-01f, -5.66744618e-02f, 2.77194411e-01f, -3.46077420e-02f, 5.18458903e-01f, 2.20379248e-01f, 6.80338368e-02f, 6.89971000e-02f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.02195488e-02f, -2.92128827e-02f, 9.13890898e-02f, 5.16617671e-02f, 1.02180548e-01f, -1.60682797e-02f, 1.05121233e-01f, -1.23810053e-01f, 1.37755528e-01f, 6.63199797e-02f,
  -1.49998770e-04f, 7.43572712e-02f, 2.55218953e-01f, 4.17999029e-02f, -1.21478878e-01f, 6.22935705e-02f, 1.86371222e-01f, 1.40380263e-01f, -2.29950860e-01f, -5.11922717e-01f,
  7.36212656e-02f, 8.36193562e-03f, 4.72616144e-02f, -7.94533417e-02f, -6.50190040e-02f, -4.88961600e-02f, -2.39259303e-01f, 1.05653614e-01f, -3.53130311e-01f, 2.28692695e-01f,
  -3.39952186e-02f, 1.72005460e-01f, -1.22530065e-01f, 8.14866945e-02f, -3.31429206e-02f, 2.57490903e-01f, -9.00468677e-02f, 6.32962361e-02f, -2.85004415e-02f, 7.37625510e-02f,
  -3.88798118e-03f, 1.60293490e-01f, 1.24994598e-01f, -2.28040926e-02f, 3.79519284e-01f, -4.76724356e-02f, 4.99026217e-02f, 4.45120074e-02f, 2.95620382e-01f, 1.22101322e-01f,
  -8.14669207e-02f, -1.16138749e-01f, -2.38949105e-01f, -4.09713127e-02f, 3.56543809e-02f, -2.69094318e-01f, -2.28838682e-01f, 6.11768849e-02f, -3.56975079e-01f, 6.23902455e-02f,
  1.09606199e-01f, 1.13239631e-01f, -2.67835647e-01f, 3.69765945e-02f, 2.03453526e-02f, -1.21443896e-02f, -1.40318647e-02f, 8.20709988e-02f, 1.71951622e-01f, 3.23036239e-02f,
  -3.34420428e-02f, 1.38972402e-01f, 9.48481262e-02f, 9.58453193e-02f, -1.21177256e-01f, 4.69532609e-02f, -1.12427510e-01f, -1.01333968e-01f, 1.53353596e-02f, -1.50516316e-01f,
  7.40990266e-02f, -9.52588469e-02f, -4.82143909e-02f, 2.38415658e-01f, -2.68003196e-01f, 1.79103967e-02f, -3.93770561e-02f, 1.65992245e-01f, -6.90671682e-01f, 9.52539314e-03f,
  1.21258736e-01f, 2.47589797e-01f, 3.29973727e-01f, -1.67363316e-01f, -1.81464866e-01f, 1.40009865e-01f, 8.09662417e-02f, -7.63833821e-02f, 7.57367397e-03f, -2.50348598e-01f,
  -2.64144111e-02f, -1.26094073e-02f, -1.72052175e-01f, -2.07214847e-01f, 7.43002212e-03f, -1.52261510e-01f, 2.16911193e-02f, 1.23984531e-01f, -2.89875567e-02f, 6.78848028e-02f,
  2.20843896e-01f, 1.98209509e-01f, -2.77075112e-01f, 6.90054614e-03f, 2.92760760e-01f, -3.08067203e-01f, 2.19770193e-01f, -8.19027945e-02f, -7.07159340e-02f, -2.75040120e-02f,
  5.08411229e-01f, 5.26611954e-02f, 1.09639421e-01f, -1.43565595e-01f, -1.68882594e-01f, -1.21484846e-01f, -3.66078109e-01f, 3.04360479e-01f, 9.91427377e-02f, -4.63489033e-02f,
  -4.84504960e-02f, 3.58937047e-02f, -1.48418888e-01f, -1.96949676e-01f, -1.51072130e-01f, 1.12710007e-01f, 1.21758552e-02f, 1.34412557e-01f, 5.93618043e-02f, 2.67336238e-02f,
  -8.91152322e-02f, 4.77145985e-02f, -4.39178236e-02f, -5.02268635e-02f, 3.24407339e-01f, 5.89246936e-02f, -2.23096654e-01f, -1.21150520e-02f, -6.80721365e-04f, 1.19166784e-01f,
  1.32835999e-01f, -6.94919303e-02f, -8.30549672e-02f, -7.74381757e-02f, 4.67534140e-02f, -1.17311710e-02f, -5.06176233e-01f, 2.98670858e-01f, 2.90217772e-02f, -1.19775504e-01f,
  -1.42006144e-01f, 1.84396595e-01f, 4.43028733e-02f, -1.18766651e-01f, 2.40154058e-01f, 1.10875286e-01f, 1.15210384e-01f, 3.20688635e-02f, -7.63848126e-02f, -1.32439703e-01f,
  7.55764470e-02f, -4.45497310e-04f, 1.52024627e-01f, 4.96660024e-02f, -2.22448990e-01f, -1.85265630e-01f, 2.74324507e-01f, 3.27661890e-03f, -2.80457139e-01f, -9.08812955e-02f,
  2.15979964e-02f, -1.53636513e-02f, -2.72423010e-02f, -1.61133632e-01f, 3.33914101e-01f, 7.39590377e-02f, 1.35842592e-01f, -2.86585450e-01f, -9.04764235e-02f, -7.04657510e-02f,
  2.45929077e-01f, 6.36285469e-02f, -1.89400181e-01f, 8.19534883e-02f, -1.09235197e-02f, 2.44704001e-02f, 1.10455804e-01f, -8.35413858e-02f, -5.21217510e-02f, -2.03454599e-01f,
  -1.12947538e-01f, -1.62088349e-01f, 8.68334845e-02f, -1.04241349e-01f, 4.00900282e-02f, 6.31938726e-02f, -2.63405740e-01f, -4.55426693e-01f, 3.45919102e-01f, -1.41997367e-01f,
  -1.33113503e-01f, 5.23929000e-02f, 2.07526952e-01f, -1.95654318e-01f, -1.12678641e-02f, -3.62927079e-01f, 5.12277663e-01f, 2.29961097e-01f, -3.08736116e-01f, -1.81937769e-01f,
  -7.82141015e-02f, -1.34115711e-01f, -1.72274172e-01f, 2.01721400e-01f, -1.91320792e-01f, 4.24934328e-02f, -4.44321595e-02f, 8.34985226e-02f, -1.03779994e-01f, -1.01333275e-01f,
  3.31240855e-02f, -7.79486680e-03f, -1.18047707e-01f, -7.91415107e-03f, -8.59012231e-02f, -1.44734308e-01f, -1.46643311e-01f, -3.99191156e-02f, -1.86592221e-01f, 1.94527849e-03f,
  -2.65034754e-03f, -1.23479977e-01f, -5.64215295e-02f, -5.93068637e-03f, -7.02628493e-02f, 1.02044292e-01f, 1.72677353e-01f, 3.66194323e-02f, -2.59314150e-01f, -3.34236115e-01f,
  1.46677634e-02f, 2.30530158e-01f, 7.64378905e-02f, 6.18443405e-03f, 1.90580830e-01f, 2.16495633e-01f, 3.48055661e-01f, -1.35966569e-01f, 6.87044784e-02f, -2.81744719e-01f,
  -8.83080624e-03f, 1.32375270e-01f, 1.32215852e-02f, -6.45551756e-02f, 6.47981316e-02f, -1.51637763e-01f, -3.11143883e-02f, 8.84672180e-02f, -1.73648879e-01f, 5.29573672e-03f,
  -2.49392223e-02f, 2.71388739e-01f, -1.75766394e-01f, -1.07240602e-01f, 1.27603158e-01f, 1.44039646e-01f, 1.60977006e-01f, 1.00434646e-01f, 1.18202595e-02f, 1.95635892e-02f,
  -4.23614606e-02f, -1.22810140e-01f, 4.62996572e-01f, -2.11669132e-01f, -3.73044789e-01f, -1.62375525e-01f, 9.88653079e-02f, 2.90611666e-02f, 1.73398152e-01f, 2.11794991e-02f,
  1.90355420e-01f, -2.49913827e-01f, 1.04263917e-01f, 1.00066602e-01f, 1.92498509e-02f, -9.25731510e-02f, -2.71228164e-01f, -2.02286586e-01f, 8.10071826e-02f, 9.68880430e-02f,
  1.50663659e-01f, 4.34942581e-02f, -9.28797945e-03f, -1.26706749e-01f, 4.84041333e-01f, -3.34480226e-01f, 7.94588849e-02f, 3.80254984e-01f, 8.77302736e-02f, -3.29136968e-01f,
  -9.20399800e-02f, -3.01521808e-01f, 3.35678309e-01f, 2.55949408e-01f, -3.89198393e-01f, 8.22918192e-02f, -1.64480284e-01f, 1.98965725e-02f, -2.05554944e-02f, -1.57737240e-01f,
  1.78465918e-01f, -9.25394222e-02f, 3.64625342e-02f, -7.55167753e-02f, 2.69136578e-01f, 1.31778896e-01f, 1.54408172e-01f, -8.12200084e-02f, 1.79731429e-01f, -8.12512711e-02f,
  1.30352050e-01f, 1.52130410e-01f, 1.66699603e-01f, -2.07403705e-01f, -1.17484912e-01f, 1.42350569e-01f, 5.41256964e-01f, -9.53286234e-03f, -2.19131619e-01f, 1.35983706e-01f,
  1.19346991e-01f, -2.39634767e-01f, 1.21222781e-02f, -2.01604620e-01f, -3.52947742e-01f, -5.30102178e-02f, 3.10008705e-01f, -1.21711409e-02f, -3.38031918e-01f, 6.11557253e-02f,
  -3.05889636e-01f, -1.12234257e-01f, 6.34919927e-02f, -6.85151219e-02f, 1.21588901e-01f, 7.17578083e-02f, -5.18194027e-02f, 8.23314041e-02f, 2.36337469e-03f, -1.20560467e-01f,
  1.89525187e-01f, -1.44264445e-01f, 3.35319415e-02f, 1.39213949e-01f, 8.98657069e-02f, -5.49024791e-02f, 2.22302377e-01f, 1.36141464e-01f, -1.41939387e-01f, 2.41941050e-01f,
  -6.31419271e-02f, 1.86960474e-02f, -2.19696656e-01f, -1.03357121e-01f, 1.19311787e-01f, 5.78304380e-02f, 5.32115847e-02f, -6.21827208e-02f, -2.09797159e-01f, 8.39719847e-02f,
  5.16399220e-02f, -9.52580646e-02f, -1.32714257e-01f, 2.32212976e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.22374329e-02f, -4.55987733e-03f, 6.19120039e-02f, 7.30952173e-02f, -1.14382997e-01f, 1.32775053e-01f, 2.31020544e-02f, -1.19856022e-01f, -1.20947629e-01f, 8.06438923e-03f,
  -4.14260030e-02f, 1.95425585e-01f, 1.15011804e-01f, 7.70533979e-02f, 1.49900973e-01f, 4.92398255e-02f, -5.31962514e-01f, 7.74120912e-02f, 3.21895242e-01f, 3.24821383e-01f,
  -8.88775587e-02f, -1.07705399e-01f, -3.61022875e-02f, 6.08528554e-02f, 9.23711136e-02f, 4.73786592e-01f, -4.17801976e-01f, 1.78543076e-01f, 5.29466093e-01f, 1.06793247e-01f,
  3.58415442e-03f, 2.65529424e-01f, 3.03449221e-02f, 1.72715306e-01f, 4.25360262e-01f, 3.33037227e-01f, 1.84280738e-01f, 2.55640507e-01f, 1.46512017e-01f, -1.28399834e-01f,
  4.74615812e-01f, 1.50261581e-01f, 4.21875298e-01f, 4.82115410e-02f, 6.27747536e-01f, 9.87094268e-02f, 3.41560572e-01f, 3.20890129e-01f, -6.96691692e-01f, 4.90981251e-01f,
  3.17014664e-01f, -4.99083430e-01f, -6.87825456e-02f, 2.22515082e-03f, -4.91374321e-02f, -1.37858495e-01f, 1.20702237e-01f, 1.80180103e-01f, -6.14074707e-01f, -3.77626330e-01f,
  2.90057510e-01f, 1.15505062e-01f, -1.03645146e-01f, -1.08850412e-01f, 9.16715339e-02f, 2.72524320e-02f, 1.56681865e-01f, -1.92503799e-02f, 2.26856872e-01f, 4.04502265e-02f,
  1.74662769e-01f, -2.54290611e-01f, 1.37049742e-02f, 3.21081057e-02f, -3.67429890e-02f, 1.37286827e-01f, -1.75976440e-01f, 3.49379145e-02f, 4.78898525e-01f, -2.61738807e-01f,
  -7.54427195e-01f, 2.14341834e-01f, -1.23389205e-03f, -8.98006022e-01f, -2.48191461e-01f, 6.97441816e-01f, 1.22903995e-01f, 2.29835548e-02f, -4.47297335e-01f, -2.15786815e-01f,
  -3.00134927e-01f, 3.81100029e-01f, -2.15606973e-01f, -2.48973548e-01f, 5.00835896e-01f, -5.40476620e-01f, -1.73693419e-01f, 2.41493583e-02f, -1.10891797e-01f, -6.44082809e-03f,
  2.41250366e-01f, 1.66060284e-01f, 1.15272097e-01f, 5.07426560e-01f, -1.04623593e-01f, 2.94349849e-01f, 9.87286046e-02f, -5.33577390e-02f, -4.31845002e-02f, 9.01784748e-02f,
  -3.98720413e-01f, -3.90953481e-01f, 3.56835008e-01f, 1.36068910e-02f, -2.89288402e-01f, 2.34572798e-01f, 2.24311799e-02f, -6.53665792e-03f, 5.94210215e-02f, 2.16487542e-01f,
  -1.99758142e-01f, -2.08273023e-01f, 4.09283519e-01f, -1.33791432e-01f, 3.79244238e-01f, 1.66429907e-01f, -4.42242146e-01f, 2.18043283e-01f, -4.43092734e-01f, 1.52233377e-01f,
  2.15203598e-01f, -3.49777564e-02f, 2.48112634e-01f, 1.36391699e-01f, 2.60597080e-01f, 5.76267183e-01f, -2.07558468e-01f, 1.20973743e-01f, 1.93533435e-01f, 1.16071701e-02f,
  1.23354234e-02f, -6.48349300e-02f, -3.85940373e-01f, -3.50565135e-01f, 4.67785656e-01f, -3.58746201e-01f, 1.98710158e-01f, 3.78782332e-01f, 2.28188217e-01f, 1.77040726e-01f,
  -1.26786232e-01f, -6.06191695e-01f, 1.68619290e-01f, 8.15714449e-02f, -6.56226203e-02f, -8.94509375e-01f, 1.53018117e-01f, -7.69939795e-02f, 9.85134840e-02f, 2.06334576e-01f,
  4.08832857e-04f, -1.53934658e-01f, -1.53034013e-02f, 1.37367412e-01f, 5.69118202e-01f, 2.43752971e-01f, 8.76628608e-02f, 3.34311396e-01f, 3.09705615e-01f, 1.29877388e-01f,
  2.64881492e-01f, 2.75664423e-02f, -1.74052969e-01f, -2.95160800e-01f, 3.15620080e-02f, -2.09555238e-01f, -4.87664491e-01f, -3.91188890e-01f, 2.29823381e-01f, 6.28442168e-01f,
  -2.92569250e-01f, -1.92303181e-01f, -4.32465702e-01f, -2.85846084e-01f, 5.28250597e-02f, -1.12927370e-01f, 4.16949362e-01f, -2.77255923e-01f, 6.42380357e-01f, -3.23984116e-01f,
  -2.13701472e-01f, -8.65808874e-03f, 5.72770834e-02f, 1.68729037e-01f, 1.40811175e-01f, 2.63710380e-01f, 7.89405704e-02f, 2.63033897e-01f, 3.20629030e-01f, 3.64002168e-01f,
  2.00353861e-01f, 3.51519436e-01f, -5.18156355e-03f, 2.30877306e-02f, -3.03904444e-01f, 9.75731537e-02f, 3.26169394e-02f, -3.44489664e-01f, -4.14577611e-02f, 2.24690810e-02f,
  1.11277878e-01f, 4.36991394e-01f, -4.10363585e-01f, 2.10522637e-01f, 8.84214118e-02f, 7.20772743e-02f, -4.31724131e-01f, -1.06043592e-01f, 1.83569431e-01f, 1.56087339e-01f,
  6.26858771e-01f, 3.95601630e-01f, 5.22542536e-01f, 1.17975451e-01f, 4.88795608e-01f, 3.65452692e-02f, 2.73666471e-01f, 1.33917332e-01f, 4.05518442e-01f, 3.63296419e-01f,
  1.95868947e-02f, 1.00308061e-01f, 3.94542426e-01f, 2.63229460e-01f, -5.27033843e-02f, 4.26501542e-01f, 1.57549173e-01f, 4.86554429e-02f, 2.40958199e-01f, 7.02611208e-01f,
  -3.58457789e-02f, -2.99165040e-01f, 1.35984525e-01f, 2.21362874e-01f, 8.59359428e-02f, -7.94232488e-02f, -1.01890936e-01f, 8.55436474e-02f, 3.09338391e-01f, 5.44230521e-01f,
  1.97707519e-01f, -1.48484111e-01f, 3.65399331e-01f, -3.34458798e-01f, -2.19916195e-01f, -4.85683471e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -4.83881012e-02f, 3.32737982e-01f, 3.20100896e-02f, 4.29195344e-01f, 1.40109017e-01f, 7.05452487e-02f, 5.57280421e-01f, 5.58341801e-01f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.69512872e-02f, 4.87408377e-02f, -3.15347075e-01f, -1.92439556e-02f, 4.64051574e-01f, -4.95071821e-02f, -3.27126384e-02f, 1.09596729e-01f, -8.81257188e-03f, -6.77010119e-02f,
  2.63546497e-01f, -2.88934618e-01f, 2.97788709e-01f, 1.73024312e-01f, -8.49894136e-02f, 8.82619247e-02f, 3.21019515e-02f, -2.58544147e-01f, 1.84504181e-01f, 8.98024961e-02f,
  -1.99617535e-01f, 1.15317911e-01f, 6.32363260e-02f, 2.48625457e-01f, -2.23297209e-01f, -2.02968180e-01f, 5.92215538e-01f, -1.63368005e-02f, 2.05486521e-01f, -3.51261199e-01f,
  1.82230353e-01f, -1.88542455e-01f, -3.82262051e-01f, -2.85482081e-03f, 2.69882709e-01f, -3.28672230e-01f, 1.11709749e-02f, -2.32510343e-01f, 2.36834079e-01f, -4.62902427e-01f,
  2.61189103e-01f, 1.05899245e-01f, 1.91192433e-01f, -6.15017973e-02f, 1.87353581e-01f, 1.30481511e-01f, -4.48275208e-01f, 5.45003191e-02f, 6.58589527e-02f, 3.26881051e-01f,
  2.91952759e-01f, -7.36217499e-02f, -1.09272316e-01f, 8.24857503e-02f, 2.23801523e-01f, -1.84872940e-01f, -1.71171829e-01f, -3.64101585e-03f, -2.55174369e-01f, -7.17614368e-02f,
  3.67667913e-01f, -3.07312876e-01f, -1.46616936e-01f, -7.63052329e-02f, -2.17587247e-01f, 2.44005546e-02f, 3.24039072e-01f, -3.00354362e-01f, -3.98411714e-02f, 9.01585147e-02f,
  -1.66351169e-01f, -2.60050595e-01f, -1.65590540e-01f, -2.14357272e-01f, 1.36649266e-01f, 2.02022314e-01f, -1.41319051e-01f, -4.87476774e-03f, 3.29044163e-01f, -1.42795816e-01f,
  2.32544363e-01f, -2.59709775e-01f, -2.96681523e-01f, 2.80962706e-01f, 8.67833868e-02f, -1.05227880e-01f, 1.01497211e-01f, 1.42920926e-01f, -8.96492004e-02f, -3.45461309e-01f,
  1.16290830e-01f, 1.21336617e-01f, -2.70069480e-01f, 2.95902252e-01f, 2.48594448e-01f, -2.20406651e-01f, 4.46449891e-02f, -6.20736964e-02f, -7.07645938e-02f, -3.87140036e-01f,
  -6.95408806e-02f, -2.83586401e-02f, 2.69006371e-01f, -1.10512637e-01f, 6.29415959e-02f, -8.39463547e-02f, 3.06503981e-01f, 1.93722308e-01f, 2.28405371e-01f, 2.34529853e-01f,
  5.61810553e-01f, -3.16792011e-01f, 2.26834014e-01f, 5.28200381e-02f, 1.66037247e-01f, 4.02607918e-02f, -4.04679984e-01f, 4.36911806e-02f, 5.98001033e-02f, 2.54883897e-02f,
  -2.68497705e-01f, -3.26737165e-01f, 1.53686404e-01f, 5.77127142e-03f, 4.90636617e-01f, -1.32111400e-01f, 1.04371712e-01f, -2.43540779e-01f, -1.45104185e-01f, -8.71422067e-02f,
  -1.96523488e-01f, -1.63878158e-01f, 9.05498043e-02f, 9.97031573e-03f, 4.39861752e-02f, -3.99335355e-01f, 1.31554618e-01f, 1.52794823e-01f, 2.65035808e-01f, -9.85001922e-02f,
  2.02610880e-01f, 3.76672484e-02f, -3.09402913e-01f, -2.54753623e-02f, 3.24530751e-02f, 2.50860721e-01f, 6.32941723e-01f, 2.28727221e-01f, -6.55221164e-01f, 3.96372706e-01f,
  -2.20968291e-01f, -2.68206913e-02f, 2.18548104e-01f, -1.03192188e-01f, 6.42682835e-02f, -1.47541519e-02f, 2.27900222e-01f, -5.24790511e-02f, -5.33677265e-02f, -1.57559469e-01f,
  -4.87559773e-02f, -3.01423948e-02f, 5.38103841e-03f, 9.17257294e-02f, 3.55508804e-01f, 1.83118209e-01f, -2.60781437e-01f, 6.20843284e-02f, -1.19307846e-01f, -3.71081263e-01f,
  2.93232389e-02f, 3.83851409e-01f, 1.43267825e-01f, -1.95304200e-01f, -1.43919066e-02f, -1.38895601e-01f, 1.09553628e-01f, -1.19764067e-01f, -3.02430242e-01f, -2.73104720e-02f,
  5.08407652e-01f, -2.20404908e-01f, 3.38620871e-01f, -9.12624747e-02f, -3.04632336e-01f, -2.34052055e-02f, 5.48862755e-01f, 1.26891192e-02f, -3.89899671e-01f, 1.10218555e-01f,
  2.48711873e-02f, -2.33985260e-02f, -6.64103255e-02f, 2.84687057e-02f, 5.65703474e-02f, -2.04049692e-01f, -1.26268119e-01f, 5.91531880e-02f, 1.80955715e-02f, -1.24500498e-01f,
  -5.87878842e-03f, -1.93219349e-01f, 1.45561591e-01f, -4.91217570e-03f, 2.53459718e-02f, 1.68114960e-01f, 3.41209650e-01f, -4.88539070e-01f, 3.69962573e-01f, -8.89137834e-02f,
  -2.89244890e-01f, 4.85054940e-01f, -1.72410365e-02f, -1.32581741e-01f, -1.95784476e-02f, -1.99525226e-02f, 1.19812414e-01f, -2.43194103e-01f, 1.03525862e-01f, 1.92086712e-01f,
  3.01780373e-01f, 1.99833244e-01f, 1.31731287e-01f, -1.13445207e-01f, -2.18252033e-01f, 5.92786968e-02f, -2.57637855e-02f, 1.74081236e-01f, -4.07580361e-02f, 1.06420502e-01f,
  3.24655138e-02f, 3.24559473e-02f, 6.33159429e-02f, 1.10022791e-01f, 2.77181000e-01f, 2.22905606e-01f, 6.85151517e-02f, 2.34987348e-01f, -1.11818515e-01f, -3.49053413e-01f,
  -4.52618748e-02f, -3.87862682e-01f, -1.68708622e-01f, 2.85975695e-01f, 1.75850373e-03f, -1.42080739e-01f, 1.35316700e-01f, 1.19171202e-01f, 1.91974103e-01f, 1.81845456e-01f,
  1.97649926e-01f, 2.02377185e-01f, -4.25212443e-01f, -6.83100820e-02f, 3.38821322e-01f, -2.00048208e-01f, -1.23448148e-01f, -1.77035704e-01f, -3.52331400e-02f, -2.78976738e-01f,
  -1.75627455e-01f, -1.87945798e-01f, 1.38124377e-01f, -2.25980341e-01f, -1.32215098e-01f, 7.00281784e-02f, 1.29169583e-01f, -2.00275406e-01f, -3.41092616e-01f, -4.16399054e-02f,
  1.96066797e-01f, -1.46235719e-01f, -8.01366288e-03f, 3.53013158e-01f, 1.67752072e-01f, 9.93340015e-02f, 1.97360933e-01f, -5.31817079e-02f, 1.25948161e-01f, 6.00329153e-02f,
  1.37757286e-01f, -1.72135338e-01f, -1.87004104e-01f, 2.26607367e-01f, 4.77051109e-01f, 2.34259024e-01f, 1.25551820e-01f, -4.03102815e-01f, 2.16230229e-01f, 6.75750524e-02f,
  -2.50419602e-02f, -9.18525979e-02f, 1.53871760e-01f, -1.26899853e-01f, -1.77596018e-01f, 2.19925016e-01f, -1.27914518e-01f, -1.50651604e-01f, -1.15595132e-01f, 2.11400222e-02f,
  2.85679996e-01f, 1.27535507e-01f, -5.97519100e-01f, 9.03916061e-02f, -3.23276073e-01f, -2.86929924e-02f, 4.05649275e-01f, 2.01833159e-01f, 3.13252091e-01f, 3.09330076e-01f,
  1.41104739e-02f, -3.07862371e-01f, 1.14606321e-01f, 6.45952299e-03f, 3.36579174e-01f, -1.34698540e-01f, 4.20714617e-01f, -1.84295356e-01f, -1.20255508e-01f, 1.38671264e-01f,
  -2.82567114e-01f, 1.73037380e-01f, 3.79964686e-03f, 3.32459733e-02f, -6.44454407e-03f, 1.08661063e-01f, 1.76087856e-01f, -1.02739714e-01f, -8.22962523e-02f, 1.41258746e-01f,
  2.34717578e-01f, 3.21997590e-02f, -3.97482574e-01f, 1.03790104e-01f, 5.73250175e-01f, -2.79966980e-01f, 2.11075038e-01f, -2.86516130e-01f, -2.10129440e-01f, -1.45393372e-01f,
  -1.87551528e-01f, -1.50596187e-01f, 2.61018664e-01f, 9.60525423e-02f, -1.78438097e-01f, -8.76678750e-02f, -2.97387272e-01f, 2.26804346e-01f, -1.12197332e-01f, 2.21132889e-01f,
  1.84855610e-01f, -5.90449683e-02f, -9.24802050e-02f, -4.29140637e-03f, 2.97394514e-01f, -1.09096900e-01f, -3.54502171e-01f, 3.69291119e-02f, -1.91899002e-01f, -1.45903721e-01f,
  3.06250036e-01f, -9.33311507e-02f, -1.80864558e-01f, -1.56531930e-01f, -3.26235622e-01f, -1.70068264e-01f, -2.60199547e-01f, 2.75756180e-01f, 9.80499983e-02f, -3.76328588e-01f,
  -2.16683149e-01f, 5.06243110e-01f, -4.55509080e-03f, -3.44934195e-01f, -4.06239808e-01f, -2.18690783e-01f, 2.06427798e-01f, 1.36961013e-01f, 2.36579433e-01f, 9.95046347e-02f,
  -2.25074738e-01f, -5.92487343e-02f, 6.78099915e-02f, -2.16247663e-02f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  6.01126671e-01f, 5.51474094e-01f, 7.13522956e-02f, 7.10449576e-01f, 9.44421887e-01f, -1.38865501e-01f, 1.40158057e-01f, 6.44551218e-02f, 4.70821440e-01f, -3.11097711e-01f,
  3.46142679e-01f, 3.87852132e-01f, -4.70169075e-02f, -7.40291357e-01f, -1.12422742e-01f, 8.52352083e-01f, -6.26413941e-01f, 1.09120339e-01f, -2.96511985e-02f, -8.36005688e-01f,
  1.25205994e+00f, -5.20471454e-01f, 5.45762241e-01f, 8.47755298e-02f, 4.54358682e-02f, 1.51536033e-01f, -7.45346993e-02f, 3.29942703e-01f, -2.80181438e-01f, 4.69568908e-01f,
  2.96439201e-01f, 6.06232226e-01f, -4.06040363e-02f, 4.64742631e-01f, 8.94895643e-02f, -4.36334431e-01f, -6.96454108e-01f, 3.91203552e-01f, -4.43020761e-01f, -4.61714536e-01f,
  3.39150608e-01f, -1.38022184e-01f, -2.07197204e-01f, 2.21931636e-02f, -7.99134314e-01f, -6.98845208e-01f, 6.49644256e-01f, -1.40783980e-01f, -3.79694514e-02f, 9.69365910e-02f,
  -3.64774168e-01f, 4.69757825e-01f, 6.68174997e-02f, -1.92955777e-01f, -2.10502312e-01f, -1.11811467e-01f, 2.15232760e-01f, 1.46801174e-01f, 3.28901470e-01f, 7.68144652e-02f,
  1.45656765e-01f, 9.50586915e-01f, 2.95220017e-01f, 4.47363913e-01f, 2.36065328e-01f, 2.33073160e-01f, 3.67440313e-01f, 2.75333911e-01f, -3.74414533e-01f, 5.13692677e-01f,
  1.16375104e-01f, 2.94873975e-02f, 2.57468998e-01f, 6.16014123e-01f, -2.54908860e-01f, -3.50465357e-01f, -3.27766448e-01f, 5.64878464e-01f, 8.11620593e-01f, -3.87034789e-02f,
  -3.04656833e-01f, -3.44054550e-01f, -1.40137896e-01f, -4.87712145e-01f, -6.85547709e-01f, 4.55334455e-01f, -4.39255424e-02f, 5.45976043e-01f, 4.07223374e-01f, 5.95289886e-01f,
  -1.05821753e+00f, -1.94329634e-01f, -1.28155351e-02f, 4.49789494e-01f, 2.53975332e-01f, 5.87810159e-01f, 1.18743457e-01f, 1.61717385e-01f, -2.49518231e-01f, -1.47738844e-01f,
  2.06399366e-01f, -1.45212775e-02f, 3.15627784e-01f, 1.96763799e-01f, 1.96503937e-01f, -4.12709340e-02f, 2.56456167e-01f, 1.98038965e-02f, -6.88503459e-02f, -7.38282427e-02f,
  3.21427196e-01f, -4.50170070e-01f, 2.53403157e-01f, 4.13564712e-01f, 4.96472597e-01f, 3.02841336e-01f, -7.01589435e-02f, 2.91086078e-01f, 3.78954232e-01f, -4.01293010e-01f,
  -1.89372152e-01f, -4.19664264e-01f, -7.24773109e-01f, 5.84882319e-01f, 1.24399686e+00f, 2.03008562e-01f, 3.91228229e-01f, 3.60874198e-02f, -1.04216293e-01f, -3.54041047e-02f,
  5.24744689e-02f, 4.61946487e-01f, 1.09865993e-01f, 1.07115693e-01f, 7.73793697e-01f, 5.46479702e-01f, 2.29458183e-01f, 5.46200514e-01f, 6.02272272e-01f, 6.33783221e-01f,
  9.85186458e-01f, 9.16085482e-01f, -2.82397002e-01f, -8.17519188e-01f, -3.39002535e-02f, 5.56340694e-01f, -1.32857472e-01f, -1.89879924e-01f, -1.14724064e+00f, 1.49000019e-01f,
  1.93472460e-01f, 4.60832626e-01f, 3.18885483e-02f, 6.71962976e-01f, 1.89492985e-05f, 1.48287416e-01f, -2.56368697e-01f, -2.23257393e-01f, 1.90806344e-01f, -1.90269276e-02f,
  1.49970278e-01f, 1.15125850e-01f, 9.30757821e-02f, -1.74216613e-01f, 2.09893987e-01f, 4.11169417e-02f, 5.04332781e-01f, 4.41495240e-01f, 2.96212614e-01f, 3.68945748e-02f,
  4.54116762e-01f, 6.71227694e-01f, 3.44094723e-01f, 1.06812552e-01f, 1.13268629e-01f, -8.14414024e-01f, 2.36854956e-01f, 4.03101146e-01f, 2.48965956e-02f, 8.31544399e-01f,
  -6.69926107e-01f, -2.35944837e-01f, 9.07080844e-02f, -3.55671257e-01f, -1.24776147e-01f, -1.75398812e-01f, 5.43910980e-01f, 5.29276609e-01f, 7.72274613e-01f, 3.92845660e-01f,
  4.00590837e-01f, -5.62986553e-01f, 1.43167078e-01f, 4.60394681e-01f, 4.57645535e-01f, -5.20697117e-01f, -6.85114115e-02f, 3.27255338e-01f, -7.72116303e-01f, 2.23930642e-01f,
  -8.11476558e-02f, 6.41065016e-02f, 1.65721118e-01f, 2.29630098e-01f, 2.68780857e-01f, -1.35862250e-02f, -4.80547845e-01f, -1.17510639e-01f, -2.22669199e-01f, -2.67006367e-01f,
  -1.24518812e-01f, 8.12531710e-01f, -4.10224438e-01f, -7.63268247e-02f, -5.64642549e-01f, 4.12954204e-02f, -3.20586562e-01f, -3.39990333e-02f, 8.04024935e-01f, -2.94609845e-01f,
  -4.57216203e-01f, -2.16998979e-01f, 2.08792970e-01f, 2.90842623e-01f, -4.51208264e-01f, -3.27236503e-02f, -3.05822492e-01f, 7.71621943e-01f, 2.00215317e-02f, 2.97623038e-01f,
  1.49161771e-01f, 1.71027929e-01f, 3.51880565e-02f, 1.75517082e-01f, 1.02334864e-01f, -3.68015766e-01f, 5.52093565e-01f, 7.14924693e-01f, -1.46900974e-02f, -8.47503245e-02f,
  6.29935443e-01f, -9.67545211e-01f, -6.11210704e-01f, -1.15981303e-01f, -4.03417945e-01f, -5.56484878e-01f, -2.49652907e-01f, 6.85248792e-01f, 2.81604022e-01f, 6.67099833e-01f,
  -7.02133477e-02f, 8.99077281e-02f, -8.02088082e-01f, -4.12992239e-01f, 4.82999802e-01f, -2.10521854e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  5.03357530e-01f, 1.72333956e-01f, 2.82579452e-01f, 2.22662225e-01f, 4.67260629e-01f, 1.75609395e-01f, 1.31595895e-01f, 3.29555005e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -6.26145244e-01f, 5.66959441e-01f, -4.21598673e-01f, -3.75823766e-01f, -1.43595794e-02f, -3.78464967e-01f, -3.14883053e-01f, -1.61247134e-01f, -3.53635669e-01f, -1.26843557e-01f,
  -3.11568052e-01f, 3.50997239e-01f, 5.73177278e-01f, -6.55181348e-01f, 3.18734437e-01f, 7.96344399e-01f, 6.24946915e-02f, 1.26167476e-01f, -3.99312109e-01f, -5.06545126e-01f,
  -2.82632023e-01f, 5.27200043e-01f, -5.64313352e-01f, -8.31461176e-02f, -3.01845461e-01f, 7.08639085e-01f, 4.18882936e-01f, -4.68964010e-01f, -6.24857664e-01f, -1.06256318e+00f,
  -1.60224900e-01f, -3.60003054e-01f, -2.99724005e-02f, -1.44417435e-01f, 9.68466923e-02f, 1.90747399e-02f, 1.71555698e-01f, -8.43395200e-03f, 1.24890335e-01f, -4.89896923e-01f,
  1.50545463e-01f, -1.80498332e-01f, -2.56746978e-01f, -4.22692299e-01f, 4.60321218e-01f, 7.03653634e-01f, 6.50735721e-02f, 3.40918079e-02f, -3.35794717e-01f, -2.47633114e-01f,
  3.45570445e-01f, 2.33102381e-01f, -6.17721304e-02f, -7.63712466e-01f, 7.46578515e-01f, 9.41419780e-01f, -3.52633335e-02f, 2.68347524e-02f, 4.51362580e-01f, -2.89317578e-01f,
  -1.07173190e-01f, -3.56867313e-01f, -5.67491114e-01f, 3.73381555e-01f, 3.00407827e-01f, -1.01973489e-01f, 2.22378880e-01f, -6.22390330e-01f, -5.38786411e-01f, -4.24365103e-01f,
  2.93567069e-02f, -6.35090590e-01f, -5.88387609e-01f, 3.19938749e-01f, 2.15614274e-01f, -1.59862638e-01f, 1.88489154e-01f, -4.52128321e-01f, -3.22990686e-01f, -2.82063842e-01f,
  -6.03835106e-01f, 5.44663131e-01f, -3.16116720e-01f, 1.85019448e-01f, 3.67520362e-01f, 5.87130129e-01f, -1.59430653e-01f, 5.88158369e-01f, 2.94539005e-01f, -2.05394581e-01f,
  -2.07647264e-01f, -3.99342686e-01f, -3.15270796e-02f, -9.02609766e-01f, 4.03129071e-01f, 3.54604185e-01f, 4.32795405e-01f, 3.75377804e-01f, -2.24910900e-01f, 3.15506756e-01f,
  4.85897392e-01f, 6.77016973e-01f, 3.93357038e-01f, -2.14468196e-01f, 3.55852008e-01f, -4.70224857e-01f, 2.80244231e-01f, -2.18080699e-01f, -2.88418084e-01f, 3.68616760e-01f,
  -7.27505982e-01f, -2.89002210e-01f, -4.56659168e-01f, 7.05661029e-02f, -5.79333127e-01f, -7.37180173e-01f, -3.70562196e-01f, 5.08822620e-01f, -2.50500023e-01f, -6.14779115e-01f,
  5.96653759e-01f, -1.12037688e-01f, -6.18447363e-01f, 3.54955733e-01f, -1.05746615e+00f, -5.17030060e-01f, -3.38954508e-01f, -6.99365199e-01f, 4.96905506e-01f, 7.71702006e-02f,
  -5.19672930e-01f, -9.21156332e-02f, -4.68073636e-02f, 1.49502710e-01f, -7.71051526e-01f, 8.14225018e-01f, -6.80857480e-01f, 1.04303390e-01f, 1.67091355e-01f, 2.34260976e-01f,
  -6.84982836e-01f, 3.79160345e-01f, -1.26172230e-02f, -6.16239846e-01f, 5.84111631e-01f, -7.13156581e-01f, -3.30789983e-01f, 1.29403576e-01f, -6.09933555e-01f, 5.43124020e-01f,
  -5.62864423e-01f, -6.01981103e-01f, 1.74433485e-01f, -4.85473096e-01f, 5.51753342e-02f, -2.49838889e-01f, 4.36504513e-01f, -1.20712161e-01f, -4.37503189e-01f, -1.22918651e-01f,
  -8.08578804e-02f, -2.72315387e-02f, 1.31665707e-01f, 4.08068448e-01f, 5.19229710e-01f, -1.72704786e-01f, 4.35982823e-01f, 5.06588697e-01f, 3.22753638e-01f, 6.22180164e-01f,
  3.30740400e-02f, -3.65786135e-01f, -6.07307673e-01f, -8.73547494e-01f, -4.51093853e-01f, 4.92713973e-02f, 1.66138306e-01f, -6.04633868e-01f, 4.69110042e-01f, 3.01249236e-01f,
  4.17501628e-01f, 1.89357549e-01f, 3.42367619e-01f, -5.90732276e-01f, -1.93832055e-01f, 3.48486565e-02f, 3.91325682e-01f, 2.57868201e-01f, 9.24800336e-02f, -6.45347089e-02f,
  -2.30273351e-01f, -5.01219571e-01f, -3.34096074e-01f, -3.73169422e-01f, -4.83247042e-01f, 4.51167375e-02f, 1.99750900e-01f, -2.00188443e-01f, -3.22814882e-01f, -2.28374466e-01f,
  9.01752934e-02f, 3.98429364e-01f, 4.74670053e-01f, -2.98148870e-01f, -1.16154343e-01f, -2.98780873e-02f, 6.37889266e-01f, 5.36612391e-01f, 4.68265027e-01f, 3.46431918e-02f,
  5.12732327e-01f, -5.53663913e-03f, -4.57535475e-01f, 2.37232796e-03f, 1.10561706e-01f, 2.98647374e-01f, -8.40904176e-01f, 1.91273808e-01f, -1.40017629e-01f, -4.00927365e-01f,
  -1.17605038e-01f, 2.75049120e-01f, 7.15586841e-01f, -1.42770529e-01f, 5.26716874e-04f, -1.98330373e-01f, 1.54948235e-01f, -1.64043456e-01f, -4.05830503e-01f, 1.19755352e-02f,
  -3.17173034e-01f, 4.35505331e-01f, -3.74352992e-01f, 1.25472888e-01f, 4.56686616e-01f, 8.12722445e-02f, 4.64963883e-01f, 1.05017853e+00f, -1.31069124e-01f, 2.71946758e-01f,
  3.74368012e-01f, -5.25313139e-01f, 2.37905711e-01f, 3.90545070e-01f, 2.82891423e-01f, 6.27650559e-01f, 4.89046574e-02f, -3.79956961e-02f, -4.12570179e-01f, -3.74682218e-01f,
  -4.49416041e-01f, 6.51747346e-01f, -2.14290753e-01f, 3.12308848e-01f, -4.06923354e-01f, -6.29095286e-02f, 1.15720496e-01f, 1.83009263e-02f, -5.80238640e-01f, 1.55874774e-01f,
  -3.11837971e-01f, 8.02565888e-02f, -2.71849394e-01f, -6.91778302e-01f, 1.19770199e-01f, -1.30459458e-01f, -4.41957802e-01f, 3.66339743e-01f, -3.60225111e-01f, -1.44880950e-01f,
  2.41884440e-01f, 1.99451640e-01f, -4.32189792e-01f, 8.77120078e-01f, 2.58796476e-02f, 7.54654050e-01f, 1.21749207e-01f, -7.60917485e-01f, 1.51370279e-03f, 9.54510495e-02f,
  1.48687065e-01f, 3.71034205e-01f, -6.59842730e-01f, 2.91067719e-01f, -4.32273239e-01f, 2.93246835e-01f, -2.09740922e-01f, -4.13584262e-01f, -2.99751669e-01f, 2.03025237e-01f,
  8.58583689e-01f, 7.42179394e-01f, 2.88865536e-01f, -3.08333188e-01f, 8.45054567e-01f, -4.97423768e-01f, -3.53739142e-01f, 2.98133373e-01f, 3.20623517e-01f, 4.91306543e-01f,
  6.11617863e-01f, -3.14050257e-01f, -6.81811869e-01f, -1.92857638e-01f, 2.44882554e-02f, 4.99720365e-01f, -1.69740878e-02f, 4.10747290e-01f, -6.00187719e-01f, 4.46535684e-02f,
  -1.68918278e-02f, 1.57951698e-01f, -3.37906986e-01f, -1.16155565e+00f, -6.94943547e-01f, -7.50572562e-01f, 7.60640800e-01f, 1.88591629e-01f, -6.81772754e-02f, 1.89276889e-01f,
  -4.70183283e-01f, -6.02104008e-01f, 5.86366951e-01f, -4.43007201e-01f, -1.13708401e+00f, 2.38179177e-01f, 4.20984596e-01f, 7.22040892e-01f, 5.17633617e-01f, 2.07107142e-01f,
  -4.51325178e-01f, 1.34036452e-01f, -2.10508645e-01f, -1.42831832e-01f, 4.52522874e-01f, -9.93789732e-02f, -4.34422284e-01f, 8.68523419e-01f, -7.02331141e-02f, -2.10398510e-01f,
  -8.45191851e-02f, -9.99257684e-01f, 7.84499109e-01f, -7.09280074e-01f, 5.10183752e-01f, 1.35005757e-01f, 2.12854967e-01f, -2.39318013e-01f, -1.10866714e+00f, -6.75908744e-01f,
  -5.46854019e-01f, -1.05462158e+00f, -8.16975012e-02f, 4.65699077e-01f, -5.86151958e-01f, -2.79185861e-01f, 3.93344194e-01f, 7.94251978e-01f, -5.27649283e-01f, -4.27728981e-01f,
  4.15517479e-01f, -8.72414052e-01f, -1.04126012e+00f, 7.04599798e-01f, 3.24848145e-01f, -4.81320173e-01f, 1.24586806e-01f, 5.55252016e-01f, -6.83544278e-02f, 1.18434623e-01f,
  6.50221705e-02f, -4.99411583e-01f, 5.68124235e-01f, -4.76179034e-01f, 1.32557794e-01f, 2.23499432e-01f, -1.09476721e+00f, -4.85604793e-01f, -1.76710308e-01f, 1.37048274e-01f,
  4.97817039e-01f, 1.18186325e-01f, -2.41812900e-01f, 2.86725968e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -3.16507630e-02f, -5.30809164e-02f, 5.24177849e-02f, 1.77289858e-01f, 1.99764699e-01f, 3.84060293e-02f, -4.05116826e-02f, -4.58118021e-02f, -3.98447812e-01f, 9.57380161e-02f,
  -4.92167883e-02f, -1.69687256e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    