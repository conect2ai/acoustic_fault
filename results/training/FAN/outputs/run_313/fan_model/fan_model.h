/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  1.18071727e-01f, 1.76621407e-01f, 7.01689050e-02f, 1.70024887e-01f, -3.99351418e-02f, -8.90146941e-02f, 5.62891550e-02f, -5.77222966e-02f, 8.76136199e-02f, 5.31977341e-02f,
  -1.18855454e-01f, 1.75704405e-01f, 3.55810784e-02f, 2.30259933e-02f, -3.52390632e-02f, -1.31823719e-02f, 1.33033723e-01f, 9.87193137e-02f, -9.78986025e-02f, -4.19416502e-02f,
  3.00258733e-02f, -1.20845415e-01f, -8.11909139e-03f, -1.13343978e-02f, 3.99897955e-02f, -3.69656980e-02f, -1.85467638e-02f, -4.73546758e-02f, -8.90694857e-02f, -6.88121915e-02f,
  -1.07615486e-01f, 7.29527995e-02f, -4.16027643e-02f, 2.84035262e-02f, 5.42006157e-02f, -2.62358915e-02f, -3.18878442e-02f, 1.96281914e-02f, 7.12158508e-04f, -2.93210130e-02f,
  -2.85788421e-02f, -1.03720482e-02f, -3.29408124e-02f, 3.33307236e-02f, 3.17275077e-02f, -5.76259103e-03f, -4.74694334e-02f, 6.47231610e-03f, -3.15498072e-03f, -1.76666789e-02f,
  4.53672707e-02f, 2.01394549e-03f, -2.87605617e-02f, 1.05736721e-02f, -1.37586836e-02f, 1.85902473e-02f, 6.99795336e-02f, -2.84059849e-02f, 1.30220428e-02f, 7.03304037e-02f,
  9.63580981e-02f, -2.45875883e-04f, -3.04803427e-04f, -2.60475231e-03f, 4.19154800e-02f, -8.77790973e-02f, -4.66244258e-02f, -2.29508132e-02f, 5.08937873e-02f, 5.71570434e-02f,
  -1.93059016e-02f, 4.37691435e-02f, -6.36362210e-02f, 5.34261158e-03f, -4.67371270e-02f, 6.88860491e-02f, 2.96535473e-02f, -3.62429023e-02f, -1.38563076e-02f, -3.89035083e-02f,
  3.24911736e-02f, -3.91380973e-02f, 1.79676432e-02f, -2.82179266e-02f, 6.53475374e-02f, 5.38750784e-03f, 7.71924946e-03f, 1.79835465e-02f, -8.51312801e-02f, 2.14971807e-02f,
  2.73869745e-03f, 9.29215476e-02f, 6.75384179e-02f, -1.56451005e-03f, 2.82654297e-02f, 3.99944410e-02f, 3.86445299e-02f, -1.37802092e-02f, -2.62942985e-02f, 2.26454642e-02f,
  -2.31237486e-02f, 6.93926662e-02f, -5.87198958e-02f, -2.18464583e-02f, 3.50860469e-02f, 2.21543666e-02f, -7.44899511e-02f, 2.31996309e-02f, -1.16394442e-02f, -6.13894016e-02f,
  1.30414991e-02f, 2.49329116e-02f, 3.25039178e-02f, -2.35364097e-03f, 5.99116683e-02f, -1.38757844e-02f, -3.10475305e-02f, 4.10652570e-02f, 3.14901210e-02f, 4.30187173e-02f,
  3.26375008e-01f, 1.19784027e-01f, 1.44428849e-01f, 1.93707079e-01f, -1.41776890e-01f, -1.07994057e-01f, -1.92396436e-02f, -1.01172896e-02f, 1.41653612e-01f, -1.18785910e-01f,
  -6.57062232e-02f, 1.32248318e-02f, 5.26813827e-02f, -1.04413403e-03f, 3.51744331e-02f, 5.77237792e-02f, -2.13416964e-02f, 3.65528129e-02f, 8.82705599e-02f, 6.81711137e-02f,
  4.77165096e-02f, -1.25954747e-01f, -3.73405614e-03f, -2.12496072e-02f, -1.79274380e-02f, 6.21276945e-02f, -1.01369217e-01f, 7.15372991e-03f, -1.04354113e-01f, -2.97455327e-03f,
  6.53047860e-02f, 1.19228415e-01f, -1.46205258e-02f, 7.73707405e-02f, 3.10806409e-02f, -3.47795105e-03f, 6.42179325e-02f, -3.78003158e-02f, -3.33128572e-02f, -3.07890773e-02f,
  3.76550481e-02f, -1.46100819e-02f, -4.92955558e-02f, -3.11886650e-02f, -3.09529919e-02f, -3.34189460e-02f, -2.40664072e-02f, -2.03741211e-02f, -4.95463163e-02f, 2.86774840e-02f,
  -1.94806848e-02f, -8.85239150e-03f, -4.28788923e-02f, -4.84568067e-02f, 3.18646282e-02f, 3.10580200e-03f, 3.69607494e-03f, 1.73673481e-02f, -5.69757000e-02f, -2.92128772e-02f,
  -6.50408715e-02f, 6.35222271e-02f, 3.37036476e-02f, -3.58388834e-02f, 2.42890716e-02f, -5.64056337e-02f, -5.76291345e-02f, 2.86920909e-02f, 5.05423360e-03f, 4.29577082e-02f,
  6.57783076e-02f, -1.96877103e-02f, -1.64339636e-02f, -4.24635783e-02f, -7.01367036e-02f, 6.70696050e-02f, -3.68355983e-03f, 4.25658822e-02f, 2.21498515e-02f, -1.26558812e-02f,
  4.98552807e-03f, 8.51141065e-02f, 3.11873276e-02f, -7.44938627e-02f, 2.74439971e-03f, 1.68594380e-03f, -6.48941174e-02f, -5.40071679e-03f, 1.63202379e-02f, -1.71804838e-02f,
  6.14807382e-02f, -9.59408097e-03f, 4.96104453e-03f, 1.03289690e-02f, -5.93272299e-02f, -2.89891195e-02f, 3.59919704e-02f, 7.45612532e-02f, 2.64955908e-02f, 7.50821084e-02f,
  -4.70065325e-02f, 3.60955074e-02f, 6.38285875e-02f, 1.12563074e-02f, -7.30288727e-03f, -3.44126187e-02f, -1.61239207e-02f, -4.63357121e-02f, -9.23037156e-03f, -5.11892438e-02f,
  -3.11705023e-02f, -4.09701690e-02f, -7.29791075e-02f, -1.66251212e-02f, -3.66787761e-02f, 4.73268889e-03f, -2.50186622e-02f, 4.19135839e-02f, -4.77977358e-02f, 2.84877792e-02f,
  1.61049590e-02f, 1.52256683e-01f, -1.39238134e-01f, -3.95786166e-02f, -1.42375082e-01f, -8.04490522e-02f, 1.57049760e-01f, -1.25122860e-01f, -1.45058939e-02f, 1.37139291e-01f,
  1.15452483e-01f, -2.22441535e-02f, 1.87832832e-01f, 9.59125459e-02f, 9.35477018e-02f, 1.54369086e-01f, 1.12249598e-01f, 2.69725509e-02f, -3.53278182e-02f, -4.81380224e-02f,
  1.42705124e-02f, 8.44956189e-02f, 3.16248201e-02f, -1.62557527e-01f, -1.28660634e-01f, -6.76728189e-02f, 7.29430690e-02f, -9.70756933e-02f, -4.83843610e-02f, -4.98397835e-02f,
  -1.73571594e-02f, -1.06282975e-03f, 1.52162284e-01f, -6.88417032e-02f, 7.12570548e-02f, -9.28202085e-03f, 7.62080550e-02f, -1.60838626e-02f, -7.83238783e-02f, -6.85177892e-02f,
  3.64317186e-02f, -3.21605653e-02f, -2.59358548e-02f, -6.21424615e-03f, -1.88843452e-03f, -2.50595193e-02f, -1.25100389e-01f, -1.00069987e-02f, 7.07056187e-03f, -4.99523580e-02f,
  4.15321141e-02f, -7.16252346e-03f, 1.34198153e-02f, -1.97017211e-02f, -5.29589970e-03f, -4.17254530e-02f, 4.20655943e-02f, -7.18991039e-03f, 9.56649240e-03f, 3.43943073e-04f,
  1.39478669e-01f, 1.02302544e-02f, -1.08654939e-01f, -4.49579246e-02f, -1.08496241e-01f, -2.59607807e-02f, -4.06082608e-02f, -6.26593158e-02f, -3.46470773e-02f, 3.42419483e-02f,
  3.98923922e-03f, 1.88955292e-03f, 2.67155338e-02f, -1.17919995e-02f, -3.56124277e-04f, 8.23278949e-02f, 2.01921482e-02f, -6.63845465e-02f, 2.49059834e-02f, 1.55416764e-02f,
  -1.33532379e-03f, -2.40922812e-02f, 3.87837216e-02f, -1.72542799e-02f, -4.64718454e-02f, 2.00921744e-02f, -1.42179942e-03f, -1.05695976e-02f, 3.79382633e-02f, 4.05058116e-02f,
  1.59013256e-01f, 1.48541912e-01f, -1.21770054e-02f, 4.58855927e-02f, 5.87551035e-02f, 1.37184728e-02f, -4.87749763e-02f, -2.91097425e-02f, 1.00216880e-01f, 4.29190286e-02f,
  6.22743852e-02f, -2.96937991e-02f, -4.22369763e-02f, -6.81919008e-02f, 8.17117840e-03f, -4.27227952e-02f, 6.09655008e-02f, 4.08106707e-02f, 4.46995087e-02f, 1.67467985e-02f,
  -4.84752283e-02f, -3.26445140e-02f, -1.06498338e-01f, -2.60868929e-02f, 4.97608110e-02f, 7.14262575e-02f, -2.06036586e-02f, 3.31091918e-02f, -6.38095066e-02f, -2.86496058e-03f,
  3.78403306e-01f, 2.11324960e-01f, -1.12989537e-01f, 1.86795354e-01f, 8.85936171e-02f, 3.40491422e-02f, -4.97972220e-02f, 9.87601802e-02f, 8.67119506e-02f, 2.40079369e-02f,
  -7.77131924e-03f, 7.07798675e-02f, -1.33623734e-01f, 1.04643464e-01f, 6.65400773e-02f, -1.15172796e-01f, 4.91169170e-02f, 5.52257858e-02f, -4.60657738e-02f, 1.66082248e-01f,
  -1.03827147e-02f, 6.17404543e-02f, -8.82036537e-02f, 1.14234723e-02f, 1.07392907e-01f, -2.70912927e-02f, -8.50316584e-02f, -1.21954851e-01f, 1.54928640e-02f, -3.01301256e-02f,
  1.33424178e-01f, 1.27475470e-01f, -3.27932164e-02f, 3.04136332e-03f, -2.10252274e-02f, -2.26453915e-02f, -5.68997301e-02f, -1.14152499e-01f, -8.68705958e-02f, -6.17127046e-02f,
  6.08956255e-03f, 4.70872298e-02f, 7.58167654e-02f, -7.22836377e-03f, 7.25384206e-02f, 8.84169713e-03f, -5.26588298e-02f, -1.52889509e-02f, 2.54951511e-02f, -9.85183381e-03f,
  -1.60899479e-02f, -8.48643631e-02f, 2.80863624e-02f, 1.61785576e-02f, -4.12627049e-02f, 2.81987675e-02f, 4.90081199e-02f, 5.31567307e-03f, 2.21058298e-02f, 4.60468009e-02f,
  5.83549216e-02f, -1.59344133e-02f, -1.84850041e-02f, 4.92391177e-03f, 4.02294882e-02f, 7.96068832e-03f, 8.88314378e-03f, -4.47692946e-02f, -4.65781391e-02f, 2.65334584e-02f,
  4.94600907e-02f, 1.66583862e-02f, -6.45685755e-03f, 8.62109940e-03f, 1.17886225e-02f, 5.52864037e-02f, 7.36306887e-03f, 7.84960911e-02f, 3.46872136e-02f, -3.20149623e-02f,
  2.14044452e-02f, -1.91116631e-02f, 2.06681825e-02f, -3.93687338e-02f, 2.17619847e-04f, -3.82582285e-02f, 5.12324944e-02f, 2.61718072e-02f, -1.02544047e-01f, -5.65600656e-02f,
  1.82912171e-01f, 3.28869551e-01f, -5.11260703e-02f, 5.29591478e-02f, -1.15718022e-01f, -1.18986592e-01f, 8.91845487e-03f, 1.79194510e-02f, -1.00549655e-02f, -3.59338638e-03f,
  -3.73895355e-02f, 1.89172681e-02f, 2.14567315e-02f, -3.04472037e-02f, -3.67905051e-02f, -5.87881878e-02f, 2.77688727e-02f, 5.00240214e-02f, 2.12306306e-02f, 5.50227165e-02f,
  -1.01983370e-02f, 2.88621802e-02f, -4.24596444e-02f, 9.71302316e-02f, 3.74912769e-02f, -5.89069575e-02f, 1.11042902e-01f, -2.31289025e-02f, 1.55068142e-02f, -7.07700029e-02f,
  -3.51531267e-01f, 3.20612937e-01f, 1.43172788e-02f, -4.41082940e-03f, -8.68906379e-02f, -2.01445982e-01f, -2.12896496e-01f, -2.83281202e-03f, -1.93845794e-01f, 1.10524826e-01f,
  -1.37023658e-01f, 2.36630619e-01f, -4.90802154e-02f, 7.94294756e-03f, -4.13707405e-01f, -5.79616986e-02f, -1.13111943e-01f, 8.38508084e-02f, 3.55955884e-02f, 1.09965727e-01f,
  -1.27376691e-02f, -3.63630964e-03f, -3.53865363e-02f, 9.62467119e-02f, 7.03493953e-02f, 1.59455314e-01f, 6.27192529e-03f, 1.06266387e-01f, 1.58595681e-01f, 6.08118856e-03f,
  -3.73742431e-02f, -6.44238433e-03f, -6.49109995e-03f, 2.77974363e-03f, -4.40869480e-02f, -6.80940505e-03f, 3.08892634e-02f, -7.96490014e-02f, -7.38734975e-02f, 2.10861154e-02f,
  1.57907382e-02f, -6.63008774e-03f, 1.73386224e-02f, -3.68344635e-02f, -6.73624501e-02f, -6.10481389e-02f, 7.58442655e-02f, -2.16862336e-02f, 5.64415492e-02f, 8.36355728e-04f,
  3.84968892e-02f, -1.08941151e-02f, 5.33488300e-03f, 4.78793979e-02f, -4.64557298e-02f, -1.15573723e-02f, -8.86554550e-03f, -1.61026344e-02f, 5.40059358e-02f, -7.21145198e-02f,
  4.85845609e-03f, -6.53964579e-02f, 4.12822850e-02f, -3.05717047e-02f, 2.40096319e-02f, -7.24206343e-02f, 6.69292128e-03f, -2.68786401e-02f, 1.14896670e-02f, -1.11271078e-02f,
  -2.28632465e-02f, 1.40409339e-02f, -5.37799373e-02f, 4.70089586e-03f, -3.68713657e-03f, 1.22046238e-02f, 2.64698919e-02f, 3.80881168e-02f, 2.36868281e-02f, -4.22885865e-02f,
  -2.78878361e-02f, -3.07313222e-02f, 3.07241343e-02f, -1.60519639e-03f, -8.86280909e-02f, -3.37852314e-02f, 8.24512262e-03f, 4.26950753e-02f, 3.61570194e-02f, -2.44057048e-02f,
  7.32660517e-02f, 1.46142796e-01f, 4.94729318e-02f, 3.67261618e-02f, 2.80756820e-02f, -4.75196242e-02f, -2.37515941e-02f, 6.07566610e-02f, 6.55338764e-02f, -1.40617813e-05f,
  4.18892279e-02f, -5.52208051e-02f, 4.55848314e-02f, -3.57715711e-02f, -1.44600952e-02f, 1.32221114e-02f, 2.82455254e-02f, -1.00461934e-02f, 2.18390822e-02f, 2.35497560e-02f,
  -2.30429621e-04f, -1.92784779e-02f, -5.06134406e-02f, -9.64005850e-03f, 1.09744156e-02f, 4.66757780e-03f, -5.92781752e-02f, 3.20165828e-02f, -1.67991279e-03f, 4.34668772e-02f,
  8.78714398e-03f, -9.55089033e-02f, -8.88365973e-03f, -6.54492602e-02f, 2.93116011e-02f, 1.19944908e-01f, 1.62770852e-01f, -1.64228976e-01f, -6.83460981e-02f, -1.30520791e-01f,
  1.07869931e-01f, -4.34022807e-02f, 3.12845707e-02f, 1.37963951e-01f, 1.65542737e-01f, 1.28068225e-02f, 1.46720603e-01f, 2.96442155e-02f, -3.29194926e-02f, -7.95890018e-02f,
  2.97798272e-02f, 6.59545735e-02f, 7.22487718e-02f, -2.43288241e-02f, 1.00002199e-01f, -5.91902584e-02f, 7.12047983e-03f, -3.20517160e-02f, 2.87334062e-02f, 3.06725893e-02f,
  1.75652057e-01f, -7.38558620e-02f, -3.99231426e-02f, 2.98366752e-02f, -1.93918552e-02f, 7.30917305e-02f, 1.15903057e-02f, 2.98858210e-02f, 4.45841923e-02f, -8.93072709e-02f,
  2.43907887e-02f, -3.78040113e-02f, 1.49404788e-02f, 1.65272446e-03f, -4.21134010e-02f, 3.60820964e-02f, -1.21143749e-02f, -2.38341764e-02f, 7.20685497e-02f, 3.03105637e-02f,
  6.62014112e-02f, 3.30724940e-02f, 5.11926822e-02f, -1.10250739e-02f, -1.20067038e-02f, -1.15774283e-02f, 9.60167572e-02f, -6.86623678e-02f, -3.82224843e-03f, 1.97337009e-02f,
  -3.23408190e-03f, 7.15897372e-03f, 5.90750435e-03f, -6.83780015e-03f, 4.27583270e-02f, 1.34404683e-02f, 2.91269589e-02f, 3.51370908e-02f, -7.91436210e-02f, 6.34601787e-02f,
  -9.01251435e-02f, 3.21576297e-02f, -5.29846139e-02f, -1.32716987e-02f, 5.94743248e-03f, 1.62346773e-02f, 4.60198671e-02f, -3.01142968e-02f, -7.16194883e-02f, 9.04786512e-02f,
  5.00261895e-02f, 5.25368191e-02f, -4.77409549e-03f, -3.98848066e-03f, 4.43942510e-02f, -3.34303305e-02f, 2.55384389e-02f, -6.76926896e-02f, -2.95282267e-02f, 1.65593512e-02f,
  -2.42118891e-02f, -2.41353482e-01f, 2.64021400e-02f, 3.18186320e-02f, 4.97116633e-02f, -5.05214334e-02f, 2.53007859e-02f, -6.15914762e-02f, -4.77813557e-02f, 3.69446464e-02f,
  -2.96604377e-03f, 2.52244622e-02f, -1.53632322e-02f, 5.51953353e-02f, 6.38090670e-02f, -4.49826531e-02f, 2.25038342e-02f, -3.97502165e-03f, -8.13462306e-03f, -8.63399636e-03f,
  -6.04272522e-02f, -2.97835302e-02f, -4.28297855e-02f, -2.21500006e-02f, 3.30682471e-02f, -8.29431973e-03f, -8.84955674e-02f, 5.34556881e-02f, 4.96973097e-02f, -7.00924024e-02f
};

// L0_fan_Wp_bar (Shape: 52 x 120)
const int L0_fan_Wp_bar_rows = 52;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.59590930e-01f, 3.28683555e-02f, -6.31972700e-02f, -1.71504200e-01f, 5.58298528e-02f, -8.23314637e-02f, -4.48527522e-02f, -8.07890072e-02f, -3.45337279e-02f, -3.39150354e-02f,
  2.95053329e-02f, 6.93367049e-02f, 7.48796538e-02f, -1.29648238e-01f, 7.48286024e-03f, 8.33208635e-02f, -1.59371272e-01f, -1.05863795e-01f, 4.64757197e-02f, -6.30806461e-02f,
  -2.91556567e-02f, -4.79846150e-02f, -5.92051968e-02f, 8.97005945e-02f, 2.73833182e-02f, -9.31071676e-03f, 3.19786463e-03f, -2.71555483e-02f, -3.96186523e-02f, 9.26411897e-02f,
  -8.86366644e-04f, 4.35274988e-02f, -2.59258784e-02f, 2.41614729e-02f, -4.86401245e-02f, 5.84620284e-03f, -2.73420308e-02f, -7.10576922e-02f, -5.21935485e-02f, -2.81982161e-02f,
  9.39436480e-02f, 4.96760570e-02f, 1.14612365e-02f, -6.23024181e-02f, -2.09893938e-02f, -7.18128830e-02f, 1.49577837e-02f, -3.36475782e-02f, -6.42293766e-02f, 3.55374143e-02f,
  -9.11864340e-02f, -5.46425395e-02f, 4.63652909e-02f, 2.61450503e-02f, 5.77616766e-02f, -1.07056454e-01f, 5.16381525e-02f, 1.88675374e-02f, 6.98762909e-02f, -4.79313843e-02f,
  5.92656471e-02f, 2.12011021e-02f, 4.48516496e-02f, -2.76897550e-02f, -6.07633330e-02f, 6.75953040e-03f, -6.05548136e-02f, -6.49591982e-02f, -3.36699560e-02f, -7.88412616e-02f,
  2.03098692e-02f, -7.02887401e-02f, 2.85427123e-02f, 1.62139325e-03f, 2.88026761e-02f, -3.45506892e-02f, 9.93149076e-03f, 4.55490425e-02f, -2.78981449e-03f, 8.40415061e-02f,
  -9.39087719e-02f, -1.44909313e-02f, 1.00811161e-01f, 5.27381748e-02f, 5.31595908e-02f, 1.90223497e-03f, 7.55041838e-02f, 7.51584098e-02f, -1.57274604e-02f, -6.54285923e-02f,
  -1.46780565e-01f, -8.90722647e-02f, -5.97134344e-02f, 3.82391103e-02f, -7.66050443e-02f, 5.87370731e-02f, -6.99275658e-02f, -6.09439015e-02f, -1.19686602e-02f, 2.53726002e-02f,
  -5.41061051e-02f, 1.51168313e-02f, -1.15210526e-01f, 1.71796996e-02f, 3.14588915e-03f, -1.11665912e-01f, 1.57705992e-02f, 5.15028276e-02f, -7.42832348e-02f, -8.82895738e-02f,
  -2.33480018e-02f, 2.40121800e-02f, -1.66886672e-02f, -4.87174094e-02f, 2.28341315e-02f, -6.39448538e-02f, 2.70273350e-02f, -5.09483665e-02f, -3.80918831e-02f, -6.30604699e-02f,
  -4.30846661e-02f, 1.55637532e-01f, -3.86344106e-03f, 7.03400970e-02f, -7.02620149e-02f, -1.20160207e-01f, 7.04754656e-03f, -5.07741012e-02f, -9.64898467e-02f, 3.04902885e-02f,
  1.53272189e-02f, 3.11065651e-02f, 8.62387717e-02f, 2.16051325e-01f, 2.08817944e-02f, 6.54463693e-02f, 1.32328093e-01f, -6.47671297e-02f, -7.61043727e-02f, 1.35007709e-01f,
  1.43935576e-01f, 1.09844521e-01f, 2.10397944e-01f, 6.06334843e-02f, 1.24827377e-01f, 1.12419009e-01f, 5.20571917e-02f, -4.37986068e-02f, 1.18864469e-01f, -9.07620136e-03f,
  -5.28409742e-02f, 2.15907656e-02f, 2.46142969e-02f, 2.46842708e-02f, -4.25681658e-02f, 4.92620915e-02f, 3.54625732e-02f, -8.21287483e-02f, -8.32913257e-03f, 4.67762686e-02f,
  -8.09501335e-02f, -3.49567309e-02f, -3.61905247e-02f, -6.82078153e-02f, 5.46732657e-02f, 5.05617112e-02f, -2.14632619e-02f, -5.82031682e-02f, -1.34553593e-02f, 8.12152922e-02f,
  3.92862922e-03f, 4.48584445e-02f, -1.90625954e-02f, 1.68572068e-02f, 1.57568213e-02f, 8.08719024e-02f, -1.27101652e-02f, 1.50576131e-02f, -8.36778507e-02f, 5.16970977e-02f,
  -8.01554322e-02f, 7.89199546e-02f, 5.74590340e-02f, -6.90748319e-02f, -2.61461195e-02f, -3.77408490e-02f, 5.87250441e-02f, -7.25197718e-02f, -6.25359789e-02f, 9.11486819e-02f,
  -3.42372693e-02f, -3.75644886e-03f, 6.52898997e-02f, -1.21545894e-02f, -2.12149061e-02f, -3.96341793e-02f, -6.83937892e-02f, 1.30171049e-02f, -5.99073470e-02f, 4.24777456e-02f,
  4.46881838e-02f, -7.17312156e-04f, 9.87113118e-02f, 2.46552713e-02f, -2.44504511e-02f, 3.17511447e-02f, 2.11626664e-03f, 2.56913286e-02f, -3.84138934e-02f, 3.62190194e-02f,
  1.39623240e-01f, 1.96762636e-01f, 4.35410663e-02f, 6.13036705e-03f, -1.94953959e-02f, -7.02588335e-02f, 7.30799232e-03f, -2.11271215e-02f, 2.01442908e-03f, -5.03587946e-02f,
  -2.39501167e-02f, -4.67088930e-02f, 3.84421125e-02f, 3.17625217e-02f, -2.88468022e-02f, 2.44683716e-02f, 5.25215678e-02f, 6.21527843e-02f, 1.23477671e-02f, 1.26975477e-01f,
  5.71449064e-02f, -2.87603438e-02f, 6.86554238e-02f, 2.79295314e-02f, 2.47469246e-02f, 5.40039241e-02f, 1.32897720e-02f, 4.69367541e-02f, -8.02194402e-02f, -1.51054543e-02f,
  1.05969980e-01f, 2.94843176e-03f, -6.65473044e-02f, -1.13700673e-01f, -2.39423607e-02f, -6.41222298e-02f, -1.26644447e-01f, 4.70344722e-03f, 4.90025170e-02f, -1.02896363e-01f,
  2.27496959e-02f, 6.87273815e-02f, -3.94605286e-02f, -3.67151275e-02f, -5.57814650e-02f, 3.48735005e-02f, -6.56986376e-03f, -6.36121407e-02f, -4.39687930e-02f, -9.46432352e-02f,
  -2.36146227e-02f, -4.20894474e-02f, -3.29218358e-02f, -7.09501728e-02f, 1.38217323e-02f, -9.31215286e-02f, -8.30989406e-02f, -3.67898680e-02f, 4.40169452e-03f, -3.47599685e-02f,
  -6.88929930e-02f, -1.49048120e-02f, 1.04677968e-01f, -3.65904905e-02f, 5.70525508e-03f, 5.17613143e-02f, -1.80957038e-02f, -2.21324837e-04f, 5.87563552e-02f, 8.92266780e-02f,
  3.46432440e-02f, -6.22164272e-02f, -3.14418525e-02f, 7.52408355e-02f, -3.72005589e-02f, 6.12013154e-02f, -2.70412955e-02f, -5.37422998e-03f, 4.95263822e-02f, 4.72785495e-02f,
  6.34371117e-02f, 4.83222865e-02f, -3.93840745e-02f, 3.86397019e-02f, -8.79249200e-02f, 2.96888687e-02f, 3.81186907e-03f, 3.93718928e-02f, 3.58319692e-02f, 8.37270450e-03f,
  -2.32421327e-02f, 5.45227453e-02f, -5.05225249e-02f, 4.40727063e-02f, -4.60623465e-02f, -3.83038558e-02f, -6.36457466e-03f, -5.91496415e-02f, 1.32204294e-02f, -3.73835140e-03f,
  2.52629295e-02f, 7.34598041e-02f, 2.21079215e-02f, 4.98023219e-02f, -4.09542993e-02f, -6.18447363e-02f, 6.55903816e-02f, -8.59368742e-02f, 3.54433507e-02f, -8.81751552e-02f,
  -8.37206468e-02f, -2.02230853e-03f, 5.23024462e-02f, 8.30134824e-02f, 6.67502754e-04f, -1.91411786e-02f, 3.00900266e-02f, -6.65734410e-02f, -6.96394742e-02f, -4.80049215e-02f,
  -4.69764322e-02f, -2.31588166e-02f, 8.45447183e-02f, 9.60969105e-02f, 3.10357604e-02f, 1.81052077e-03f, 1.67559814e-02f, 6.19659238e-02f, -9.37383100e-02f, -4.12629917e-02f,
  -8.88494849e-02f, -3.55960056e-02f, 5.93803599e-02f, 1.33884102e-02f, 3.63702439e-02f, -4.93000150e-02f, -7.62520060e-02f, 5.84926493e-02f, -8.81403834e-02f, 5.36501668e-02f,
  -3.29947695e-02f, -4.50060563e-03f, -3.57461385e-02f, 3.69725488e-02f, 4.62013632e-02f, -4.27764207e-02f, -4.86109080e-03f, 7.73143768e-02f, 5.35740703e-03f, -2.19903179e-02f,
  6.17591068e-02f, -1.74640194e-01f, 7.93377385e-02f, 2.21547205e-02f, 1.87520042e-01f, 1.39388576e-01f, 5.16138561e-02f, 9.59736183e-02f, -1.07503235e-01f, -1.59077853e-01f,
  -2.82281241e-03f, -2.67146286e-02f, -1.03259549e-01f, 7.00997263e-02f, 1.57862976e-01f, -8.00079852e-02f, 1.66229289e-02f, 8.07584152e-02f, 1.61167178e-02f, -5.31726703e-02f,
  1.06380835e-01f, 5.76640405e-02f, 1.29396141e-01f, -1.08099252e-01f, -8.44922140e-02f, -9.10440236e-02f, -2.67423084e-03f, -8.72708708e-02f, 9.47695374e-02f, 1.03339709e-01f,
  -4.77361530e-02f, -1.14736699e-01f, 7.45665515e-03f, -1.04338095e-01f, -8.62492621e-02f, -1.35167828e-02f, -2.19819089e-03f, 4.94507439e-02f, 5.00238985e-02f, -7.76631534e-02f,
  7.34201521e-02f, 4.21713069e-02f, 5.93760051e-02f, -5.99254891e-02f, -3.73624265e-02f, 3.92936841e-02f, -4.54904791e-03f, 3.68871610e-03f, 6.86729923e-02f, 5.30450679e-02f,
  -1.21053925e-03f, -5.30567616e-02f, 5.20720296e-02f, -1.49188908e-02f, -4.18496542e-02f, -6.67997152e-02f, 2.69987974e-02f, 5.48864678e-02f, 5.64383604e-02f, 5.44191375e-02f,
  9.35959592e-02f, 3.81285399e-02f, -7.69407675e-02f, 1.20857721e-02f, -1.80148184e-02f, -1.70957781e-02f, 6.79654554e-02f, 6.76107081e-03f, 5.29213995e-03f, 2.33922340e-02f,
  -9.72820073e-03f, -1.88559741e-02f, -1.32878795e-02f, 1.58729628e-02f, -3.96862626e-02f, -6.55376315e-02f, -1.56091098e-02f, -2.88133509e-02f, -3.20274718e-02f, -3.76108103e-02f,
  2.60784030e-02f, -6.03896379e-02f, -1.29277231e-02f, -2.50137467e-02f, 1.62511703e-03f, 4.03033905e-02f, 7.10501224e-02f, -2.76219659e-02f, -4.99415561e-04f, 6.84972033e-02f,
  -2.11827517e-01f, -1.75937533e-01f, 9.95923486e-03f, -2.31839786e-03f, -1.24838866e-01f, -7.46794641e-02f, -2.26716753e-02f, -4.42610122e-02f, -1.33956801e-02f, 7.59422332e-02f,
  -1.20105902e-02f, 2.76073217e-02f, 8.38028546e-03f, -1.46968085e-02f, -5.41825891e-02f, -5.54888099e-02f, 2.03597196e-03f, -6.88893050e-02f, -5.51513247e-02f, -9.90582705e-02f,
  3.60474586e-02f, -2.59871501e-02f, 1.51917189e-02f, -3.51253338e-02f, 8.83615538e-02f, 3.36618978e-03f, -3.97934541e-02f, -4.49139439e-02f, 1.90729890e-02f, -5.85730448e-02f,
  4.34305593e-02f, 1.46261320e-01f, -1.69320181e-02f, -6.89965039e-02f, 8.43314677e-02f, -3.84185351e-02f, 9.91874281e-03f, 8.06426555e-02f, 9.74069536e-02f, 6.76935688e-02f,
  1.37289250e-02f, 1.35013431e-01f, 3.85391675e-02f, 6.35944027e-03f, -3.42676304e-02f, 3.86150926e-02f, -7.31561857e-04f, 6.88392371e-02f, 7.09998794e-03f, -2.05134787e-02f,
  -4.43148352e-02f, -4.00036387e-02f, -3.54887880e-02f, -1.14279121e-01f, 6.00926951e-03f, -8.27305689e-02f, 3.16519327e-02f, 6.13121055e-02f, 9.78791565e-02f, -9.59097687e-03f,
  9.11410898e-02f, 1.33795097e-01f, -1.93303451e-02f, -1.08745517e-02f, -1.85915828e-02f, 3.82664017e-02f, 6.46313652e-02f, 9.31647420e-02f, 4.92772162e-02f, 1.18722968e-01f,
  1.41642764e-02f, -7.39974380e-02f, -1.43263605e-03f, 7.91025441e-03f, -4.00267877e-02f, -1.53452614e-02f, -8.72077644e-02f, 1.41396327e-02f, -5.85840605e-02f, -3.08917109e-02f,
  -7.33335167e-02f, -1.24468934e-02f, 1.48945721e-02f, -3.39409821e-02f, 5.66403456e-02f, -5.75030632e-02f, -5.33527397e-02f, 1.01321816e-01f, -5.65375984e-02f, 2.92034484e-02f,
  -4.66524996e-02f, 7.57439435e-02f, 2.18351837e-03f, -6.24274090e-02f, -5.59664480e-02f, -3.78113836e-02f, -3.86755727e-02f, -1.83133036e-02f, 1.06821824e-02f, -2.79538166e-02f,
  1.35583626e-02f, 4.11361717e-02f, -5.54446951e-02f, -2.22095791e-02f, 1.97703838e-02f, 8.92777070e-02f, -7.78744556e-03f, -6.46418333e-03f, 8.20616633e-03f, -7.78714716e-02f,
  -9.90766436e-02f, -7.29234517e-02f, 8.14851597e-02f, 5.13846353e-02f, 4.29703481e-02f, -7.75447935e-02f, 6.51009679e-02f, -5.71476966e-02f, 5.11019640e-02f, 5.88349402e-02f,
  2.93429848e-02f, 1.68294057e-01f, 6.48446083e-02f, 3.93353142e-02f, 1.85700487e-02f, -1.40450560e-02f, 8.81880596e-02f, 9.13841575e-02f, 6.03453182e-02f, -5.10361344e-02f,
  2.82633603e-02f, 1.06511191e-02f, 1.02467827e-01f, -1.63754169e-02f, -8.44871104e-02f, 1.07237911e-02f, 6.62024766e-02f, -4.71043810e-02f, 3.73102957e-03f, 1.38746621e-02f,
  1.24511365e-02f, -5.68243526e-02f, -8.46631918e-03f, 8.02815184e-02f, -3.89379896e-02f, -4.45641717e-03f, 4.01262715e-02f, -4.59812656e-02f, 3.68212126e-02f, -2.64951382e-02f,
  -7.89876208e-02f, -1.02076761e-01f, -2.55418509e-01f, -1.69829741e-01f, -7.56721124e-02f, -3.25022370e-01f, -2.27629617e-01f, -1.83128759e-01f, 7.34121501e-02f, 8.25717971e-02f,
  1.78669579e-02f, 1.12323552e-01f, 1.68829128e-01f, 7.01639336e-03f, -3.35688628e-02f, 1.29984483e-01f, -1.95222646e-01f, -5.43644801e-02f, 9.81558114e-02f, -2.06323206e-01f,
  -5.18104322e-02f, -6.58405647e-02f, -1.91728622e-02f, -9.17005688e-02f, -1.84031382e-01f, 4.67431992e-02f, 5.15180677e-02f, -5.64614236e-02f, -1.28919840e-01f, 5.45195974e-02f,
  -9.15882438e-02f, -1.77805740e-02f, -8.03725496e-02f, -2.77807768e-02f, -6.57713339e-02f, -9.20134932e-02f, -1.62624702e-01f, -4.51072073e-03f, 3.36749814e-02f, -1.01430513e-01f,
  4.95937914e-02f, 1.91664454e-02f, 2.05239393e-02f, 8.27760100e-02f, -3.86685543e-02f, 6.16133027e-02f, 2.10373979e-02f, 7.89726432e-03f, -7.49748945e-02f, 1.94899645e-03f,
  -5.32753952e-02f, 2.20685042e-02f, 3.06338724e-02f, 1.43247768e-02f, -2.53280252e-02f, -1.09580070e-01f, 5.93251735e-02f, -4.67164479e-02f, -1.08087495e-01f, -7.98884183e-02f,
  -8.51774141e-02f, -8.13069567e-02f, -4.58655208e-02f, -5.38236946e-02f, 8.69010482e-03f, -8.76522064e-03f, 6.59641698e-02f, 2.39805027e-04f, 3.37970927e-02f, -1.25366012e-02f,
  8.19642935e-03f, -2.31728237e-02f, -7.53191113e-02f, -1.20843634e-01f, -7.00450083e-03f, -1.71189066e-02f, 5.79069443e-02f, 4.23978120e-02f, 6.20817430e-02f, -2.43989155e-02f,
  7.00639263e-02f, -4.25723195e-02f, 4.25009169e-02f, -7.47010186e-02f, -5.64468689e-02f, -3.71012315e-02f, -5.00466675e-04f, -3.52234542e-02f, -1.39419362e-02f, -6.63796067e-02f,
  -1.13364257e-01f, -9.83700678e-02f, -4.04980108e-02f, -6.68508408e-04f, -6.65643439e-02f, -1.06536865e-01f, -3.76960300e-02f, -7.13324770e-02f, -7.15439841e-02f, -1.14320025e-01f,
  -6.86503053e-02f, 7.13717043e-02f, -1.08334266e-01f, -5.61111141e-03f, 4.78206538e-02f, 4.20417609e-06f, -1.36632854e-02f, -6.33097738e-02f, -5.72405085e-02f, -1.38720246e-02f,
  4.24744114e-02f, 2.20128093e-02f, 7.11910650e-02f, 7.30713755e-02f, -9.28354263e-03f, 3.30685191e-02f, -4.68977578e-02f, -4.83210459e-02f, -1.76908132e-02f, 7.90235251e-02f,
  -8.79149977e-03f, 4.39325199e-02f, -1.96190462e-01f, -4.87069264e-02f, -7.47476593e-02f, -1.31507933e-01f, -2.22056434e-01f, 3.68351899e-02f, -9.34674516e-02f, -7.03928694e-02f,
  -9.18161422e-02f, 2.66066077e-03f, 1.09013423e-01f, -1.28928110e-01f, 4.07730825e-02f, 6.49785176e-02f, -2.11123690e-01f, 2.24033296e-02f, -1.47159556e-02f, -7.24645779e-02f,
  9.91154090e-02f, -8.92705098e-02f, -7.06426203e-02f, 3.27466801e-02f, -1.23725779e-01f, 6.32747337e-02f, 6.74643591e-02f, -2.56845262e-03f, -1.02191828e-01f, -1.30601779e-01f,
  -4.47015464e-02f, 3.66364070e-03f, 1.94506685e-03f, -2.51644384e-02f, -4.28069197e-02f, -5.27994744e-02f, 2.07193606e-02f, -3.06228530e-02f, -8.59356076e-02f, -5.70742078e-02f,
  1.07316993e-01f, 8.13990310e-02f, -8.39653462e-02f, -2.41432507e-02f, -2.97681987e-02f, -7.71057755e-02f, -2.25568861e-02f, 3.89634967e-02f, -2.21820287e-02f, 1.46738591e-03f,
  5.60154766e-02f, -8.75411928e-02f, -3.88448150e-03f, 7.09903687e-02f, -7.72166029e-02f, -6.30522296e-02f, 2.39559077e-02f, 4.73681539e-02f, -3.00060455e-02f, -7.73226237e-03f,
  2.43825726e-02f, 7.08869249e-02f, 3.38720321e-03f, 2.62010470e-02f, 1.42033142e-03f, -5.45651745e-03f, 5.23542650e-02f, 1.10865179e-02f, -1.40322717e-02f, 5.13406470e-02f,
  4.48547304e-02f, -1.59406625e-02f, 7.70485029e-02f, -6.12496678e-03f, 9.29112509e-02f, 2.09672097e-02f, 1.68765802e-02f, 8.35808441e-02f, -4.69985753e-02f, 9.15842205e-02f,
  8.85603428e-02f, 1.80634949e-02f, 2.01790910e-02f, 9.58374664e-02f, 1.83907654e-02f, -7.05489963e-02f, -4.02897671e-02f, 5.26370332e-02f, 2.03416739e-02f, 8.23337510e-02f,
  -1.85604244e-02f, 5.87695055e-02f, 2.76777358e-03f, 1.70562118e-02f, 5.10511771e-02f, -7.41779283e-02f, -3.66627537e-02f, -9.53596532e-02f, -5.19806743e-02f, -7.40909576e-02f,
  -3.81067321e-02f, -2.95955455e-03f, 7.97824934e-02f, 1.14039779e-02f, -8.76013935e-02f, -1.43270819e-02f, -3.44463252e-02f, 8.89580324e-02f, 1.95647459e-02f, 2.39542220e-03f,
  2.02467218e-02f, -4.86343391e-02f, 7.74080008e-02f, -3.40082534e-02f, -1.54043557e-02f, -3.32258828e-02f, -7.24360496e-02f, 9.94487926e-02f, 1.12636521e-01f, -7.18357787e-02f,
  4.66949306e-02f, -1.31674573e-01f, -3.36642087e-01f, -1.11375190e-01f, 8.47216845e-02f, 3.32297012e-02f, -4.20661271e-02f, -6.40329272e-02f, -1.69656798e-01f, 2.08903220e-03f,
  7.05442801e-02f, 2.23329365e-02f, -2.03755915e-01f, 6.36790246e-02f, 1.37486175e-01f, -6.16396666e-02f, 1.48065731e-01f, 1.14531294e-01f, -6.27594143e-02f, 9.60474908e-02f,
  -3.16462368e-02f, 2.74469703e-01f, -1.05428603e-02f, 2.31808901e-01f, 1.12704866e-01f, 4.34199311e-02f, 1.02347694e-01f, -6.46314621e-02f, 2.16241419e-01f, 1.15545891e-01f,
  7.33598471e-02f, 1.85025260e-02f, -6.25412390e-02f, -4.38609496e-02f, 5.28241172e-02f, 8.92802328e-02f, 6.65784776e-02f, 8.61251429e-02f, -1.53351407e-02f, 1.52170975e-02f,
  1.95894372e-02f, 1.36416256e-02f, -9.13421065e-02f, -4.17319313e-02f, -6.24542423e-02f, -8.10617656e-02f, -1.99987181e-02f, -5.97890615e-02f, -1.10265344e-01f, -1.93280503e-02f,
  -2.24116668e-02f, -1.40219741e-03f, -1.16169691e-01f, -1.51778692e-02f, -1.15063153e-01f, 4.77413945e-02f, -1.10654198e-01f, -6.65521324e-02f, -5.03220856e-02f, 4.90729772e-02f,
  1.00026764e-01f, 1.05803818e-01f, -1.96943246e-02f, 2.62049198e-05f, -3.21832746e-02f, 8.85839090e-02f, 2.16586851e-02f, 2.11613085e-02f, 1.21311629e-02f, 2.16890834e-02f,
  1.72909629e-02f, 8.15925281e-03f, 9.49146748e-02f, -6.29638806e-02f, -9.29164421e-03f, -8.12612416e-05f, 4.71683629e-02f, 1.04665920e-01f, 2.82736477e-02f, -6.87043071e-02f,
  -4.16064672e-02f, 7.68041890e-03f, 8.51386413e-02f, -6.83969706e-02f, 8.49949848e-03f, 4.69347313e-02f, 4.90427762e-02f, 7.36803636e-02f, 6.53025135e-03f, 4.45358679e-02f,
  5.45583442e-02f, -5.16284816e-02f, -1.38111532e-01f, 5.49881645e-02f, -5.06002195e-02f, 9.83456150e-02f, -2.91217379e-02f, -5.47649972e-02f, 5.50312735e-02f, -8.45431313e-02f,
  1.03565685e-01f, -7.56768212e-02f, 2.39694957e-02f, 6.45463467e-02f, -3.72337960e-02f, 1.23808179e-02f, -6.34594709e-02f, 1.03855260e-01f, 8.88491720e-02f, 4.88340668e-02f,
  -1.45916492e-02f, 1.01769613e-02f, -7.18570948e-02f, -3.84294875e-02f, 7.91241229e-03f, 5.33935323e-04f, 6.04916811e-02f, 5.65882735e-02f, 8.71430635e-02f, -1.19389661e-01f,
  -2.94929855e-02f, -1.47366866e-01f, 1.77897111e-01f, 6.63541704e-02f, -3.49254198e-02f, -3.43762059e-03f, -1.05324887e-01f, -5.00217862e-02f, -1.53226554e-01f, -1.60363242e-01f,
  9.15971845e-02f, 8.05548504e-02f, -4.67093959e-02f, 5.82723431e-02f, 2.94998772e-02f, -4.04529013e-02f, -3.32737789e-02f, 4.62407172e-02f, -5.24170361e-02f, 1.07799746e-01f,
  -2.19850754e-03f, 4.13162783e-02f, 1.44611016e-01f, -6.98967651e-02f, 8.29524994e-02f, 5.87988086e-03f, 1.19750343e-01f, 1.45535499e-01f, 8.46842602e-02f, 7.36847147e-02f,
  -1.11753687e-01f, 9.90388840e-02f, -1.59360897e-02f, 3.31151411e-02f, 6.80465158e-03f, 7.06381723e-02f, 4.67054844e-02f, 4.35961150e-02f, -3.56833860e-02f, 6.88176081e-02f,
  -3.50209847e-02f, -4.92945984e-02f, -1.64845362e-02f, -5.74072897e-02f, -3.33042964e-02f, 5.57339899e-02f, 8.27926397e-02f, -2.95796990e-02f, -4.90570161e-03f, -2.36211494e-02f,
  6.17670268e-02f, -9.72810108e-03f, 7.37534165e-02f, -7.74049247e-03f, 9.49380398e-02f, 3.42719778e-02f, 4.97008674e-03f, 2.06819363e-02f, 3.96096669e-02f, -1.73560306e-02f,
  -2.22768635e-02f, -5.34059145e-02f, -1.07305430e-01f, 8.90440494e-02f, -9.74588562e-03f, -6.82462752e-02f, -5.31096160e-02f, -1.91421155e-02f, 9.99695212e-02f, -5.47524169e-02f,
  9.16431844e-02f, 8.85758251e-02f, 8.03276524e-02f, 6.99261427e-02f, 1.73928533e-02f, 1.57054905e-02f, 1.77506963e-03f, 4.83525619e-02f, -3.34556662e-02f, 1.03061631e-01f,
  -3.10401078e-02f, -7.51240402e-02f, -1.33109549e-02f, -6.85000271e-02f, -1.89499762e-02f, 6.47005290e-02f, -5.07146753e-02f, 4.04709578e-02f, -3.23988646e-02f, 2.09407248e-02f,
  -1.36827290e-01f, -5.16874753e-02f, 4.60849740e-02f, -1.25420727e-02f, 6.04011267e-02f, -5.30265551e-03f, 6.20717481e-02f, -7.06885383e-02f, -8.74634646e-03f, -7.40343407e-02f,
  4.83477227e-02f, 4.60056402e-03f, 1.95874739e-02f, 7.85746351e-02f, 7.61423483e-02f, -7.13692307e-02f, -7.19502522e-03f, -7.99185857e-02f, -5.66882826e-02f, 9.82986763e-02f,
  9.10194814e-02f, 6.04797602e-02f, 3.96061130e-02f, 5.52342832e-02f, -4.25480343e-02f, -8.89613554e-02f, 1.49942460e-02f, 1.10969450e-02f, 7.33684599e-02f, 6.03567846e-02f,
  -9.12626833e-02f, 4.90449481e-02f, -6.62313625e-02f, -6.27460852e-02f, -1.35924265e-01f, -2.59542614e-02f, -4.61225584e-02f, -3.13526057e-02f, -9.03325230e-02f, 2.34256145e-02f,
  -2.67137587e-02f, -7.67770261e-02f, 1.14507034e-01f, -6.76440308e-03f, -4.66383025e-02f, 1.17130719e-01f, 1.00391164e-01f, 1.95767507e-02f, -4.66061421e-02f, 6.24134578e-02f,
  9.79830027e-02f, 3.94937173e-02f, 1.30694211e-01f, -3.51458937e-02f, 8.11808184e-02f, 7.07757547e-02f, 4.05508690e-02f, -8.93939808e-02f, 2.88913473e-02f, 7.38335922e-02f,
  8.78461152e-02f, 8.90588090e-02f, -3.27809006e-02f, 5.65621071e-02f, 9.04453695e-02f, 2.73543224e-02f, -7.57016009e-03f, -5.26630320e-02f, -1.18913189e-01f, 7.07764030e-02f,
  2.81434003e-02f, -1.21071776e-02f, 1.39699476e-02f, -8.80947150e-03f, -6.09776787e-02f, -7.53563866e-02f, 9.84674972e-03f, -6.54791445e-02f, -1.58971101e-02f, -5.37396818e-02f,
  4.50285152e-02f, -2.39483882e-02f, -8.88006389e-02f, 6.34769723e-02f, -8.73320829e-03f, 3.34762223e-02f, 1.44289248e-02f, -4.14983109e-02f, 7.27255791e-02f, 1.91772114e-02f,
  6.23215474e-02f, -8.08748454e-02f, -7.02437758e-02f, 1.29456930e-02f, 6.98616914e-03f, -2.58057062e-02f, -7.77255185e-03f, -7.20443800e-02f, 1.59867723e-02f, 8.13178346e-02f,
  -4.32797372e-02f, 3.28008980e-02f, 5.69549389e-02f, -4.61944751e-03f, -3.64906490e-02f, -5.57933971e-02f, -7.53969178e-02f, 2.86975726e-02f, -5.79686873e-02f, -3.52835506e-02f,
  4.15919460e-02f, 4.60006818e-02f, 1.81354722e-03f, 6.77483678e-02f, 8.90892930e-03f, -2.78822538e-02f, 2.05962509e-02f, -5.93993291e-02f, 5.60748950e-02f, 5.18489741e-02f,
  6.17664121e-02f, 6.07572049e-02f, -5.57552986e-02f, -8.15531015e-02f, -2.41449270e-02f, -2.83888914e-02f, 4.54300866e-02f, 4.45751324e-02f, 3.27527560e-02f, -9.87947639e-03f,
  -4.03561816e-02f, -6.78539798e-02f, 6.09883517e-02f, -3.12753418e-03f, -5.61240800e-02f, -6.07466735e-02f, -4.05201130e-02f, 4.65089083e-02f, -7.42580295e-02f, -2.88018845e-02f,
  -4.86326180e-02f, -5.45489118e-02f, -6.69747218e-02f, 5.86857535e-02f, 1.45686762e-02f, -1.12265386e-02f, 4.77084331e-02f, -8.06608871e-02f, -5.19372821e-02f, 3.46051008e-02f,
  2.72346959e-02f, -2.73250073e-01f, 8.77657831e-02f, 1.07409924e-01f, 4.70192321e-02f, 5.26423380e-03f, 9.58465785e-02f, -9.98074561e-02f, -1.89757690e-01f, -1.46633163e-01f,
  -1.40876984e-02f, 1.43598765e-01f, -3.86296958e-02f, 4.87419255e-02f, 2.33163252e-01f, -6.88204840e-02f, -1.73610728e-02f, 4.02581468e-02f, -1.43484604e-02f, 2.33804993e-02f,
  -4.25893394e-03f, 1.37916009e-03f, 5.19984961e-02f, -9.20831133e-03f, 3.10158599e-02f, -5.98551184e-02f, -2.86804587e-02f, 1.13199815e-01f, 2.58182548e-02f, 1.09247975e-01f,
  -4.11541946e-02f, 5.93878841e-03f, -7.78348595e-02f, -2.93680914e-02f, 2.43094633e-03f, 5.60576394e-02f, 7.45886192e-02f, 6.68956786e-02f, 7.82334134e-02f, -1.95381735e-02f,
  4.60131727e-02f, 3.70330326e-02f, -3.28237452e-02f, 4.78720069e-02f, -9.48754326e-02f, -1.49576012e-02f, -1.60278585e-02f, 6.37111217e-02f, -8.98605958e-02f, -5.61556108e-02f,
  -3.26259024e-02f, -1.45685384e-02f, -6.41037002e-02f, 5.69902696e-02f, -5.15207322e-03f, 6.51901513e-02f, -3.77026480e-03f, 6.96678311e-02f, -9.52677894e-03f, -5.86220995e-02f,
  -8.97466391e-02f, -2.95136627e-02f, -3.56228687e-02f, 3.09473202e-02f, -1.19959023e-02f, 3.24521251e-02f, 5.13565652e-02f, 6.43188599e-03f, 6.43772110e-02f, -1.32933231e-02f,
  3.77062373e-02f, -2.54489426e-02f, -7.04360679e-02f, -7.43466541e-02f, -4.14765254e-02f, -2.45260308e-03f, 3.04098595e-02f, -4.87322360e-02f, -1.09450975e-02f, -1.17680831e-02f,
  -3.98698598e-02f, 3.70824933e-02f, 7.98198115e-03f, -3.78077179e-02f, -8.75919871e-03f, -3.99391279e-02f, -4.20714431e-02f, -1.16586000e-01f, -3.60607723e-04f, 4.83640209e-02f,
  -1.38354674e-01f, -1.68866694e-01f, -6.58472925e-02f, -6.41090795e-02f, 1.74638331e-02f, -6.18606471e-02f, -2.86363233e-02f, -1.10579571e-02f, 7.32019730e-03f, -1.78331826e-02f,
  -1.37226479e-02f, 5.57745136e-02f, 3.84046398e-02f, 4.86285761e-02f, -2.74774134e-02f, -5.21069989e-02f, 4.78581962e-04f, 6.39610086e-03f, -1.39376372e-02f, 6.13373518e-03f,
  4.75714654e-02f, 2.35342141e-02f, 1.08528435e-01f, 3.44386138e-02f, 1.08746085e-02f, 2.16890052e-02f, 3.91211659e-02f, 2.90170647e-02f, -5.71714074e-04f, 2.35705003e-02f,
  1.61247462e-01f, -7.50838220e-02f, -1.37461811e-01f, 8.57474431e-02f, -2.00042985e-02f, -6.05994314e-02f, -1.01993576e-01f, 9.16352123e-03f, -1.25795126e-01f, 8.17039087e-02f,
  9.01140720e-02f, -8.93392228e-03f, -1.08777046e-01f, -6.28739642e-03f, 7.22108930e-02f, -1.09216057e-01f, 1.09568931e-01f, 4.64559719e-02f, 4.04824018e-02f, 1.56627610e-01f,
  1.64275378e-01f, 1.99439049e-01f, 5.56657687e-02f, 1.20365858e-01f, 6.44731149e-02f, 6.90478683e-02f, 3.15839291e-01f, 2.86153294e-02f, 1.97427422e-01f, -2.67254040e-02f,
  -1.94862321e-01f, 1.49694569e-02f, -8.77223387e-02f, -8.30470026e-02f, 1.14161745e-01f, -1.98630206e-02f, -5.35013573e-03f, 1.76795367e-02f, 2.75231842e-02f, 1.28227090e-02f,
  -7.36916512e-02f, -6.36956692e-02f, 5.25745749e-02f, -2.14203577e-02f, -1.59597527e-02f, 5.44964671e-02f, -3.12376991e-02f, -5.02092857e-03f, 2.33374313e-02f, -8.68242085e-02f,
  -1.42400503e-01f, 4.18629572e-02f, -2.15122271e-02f, -2.41056681e-02f, 6.25066552e-03f, 3.38147059e-02f, -1.96792390e-02f, 6.61772937e-02f, 6.03379346e-02f, 6.94799051e-02f,
  1.84454247e-02f, -9.33160912e-03f, -3.99941299e-03f, -2.05335673e-02f, 1.05424384e-02f, 1.57601554e-02f, -2.04423256e-02f, 5.16848788e-02f, -4.74707317e-03f, -7.30495667e-03f,
  -5.37029095e-02f, -6.02569506e-02f, -1.20287053e-02f, -1.38319680e-03f, -1.79376435e-02f, 6.09764680e-02f, 1.56318936e-02f, 3.02246176e-02f, 7.78993219e-02f, 2.32820567e-02f,
  -9.99094769e-02f, -3.11840717e-02f, 7.26171583e-02f, -4.32169512e-02f, 1.57478973e-02f, -4.25357893e-02f, 4.40090485e-02f, -3.55790444e-02f, -4.05633403e-03f, -2.36326680e-02f,
  5.71605302e-02f, 1.36655584e-01f, 5.93142733e-02f, -6.66128704e-03f, -2.55781487e-02f, 5.94610386e-02f, -5.68733215e-02f, -4.88877892e-02f, -5.81151359e-02f, 2.97390092e-02f,
  7.77127966e-02f, 2.71229912e-02f, 1.67786200e-02f, 8.00124928e-02f, -9.27636214e-03f, 5.37248664e-02f, 5.70979938e-02f, -1.04082683e-02f, 1.24134310e-01f, 6.89086010e-05f,
  2.71639843e-02f, -9.28620026e-02f, 9.22364742e-02f, -3.78467180e-02f, -1.12709624e-03f, -1.37717649e-02f, 6.21391647e-02f, 6.01812862e-02f, 9.84442420e-03f, -3.50294895e-02f,
  1.47277236e-01f, -8.28097239e-02f, 9.80508178e-02f, 1.67549908e-01f, 1.35183865e-02f, -4.87189367e-02f, 3.77912708e-02f, 3.98857780e-02f, 1.27323568e-01f, -1.14777587e-01f,
  -1.47863850e-02f, 9.57409889e-02f, -1.82439521e-01f, -4.50545736e-02f, 1.08526405e-02f, -7.66852349e-02f, 5.02219088e-02f, 3.32204029e-02f, -3.42808291e-02f, 8.59848931e-02f,
  5.23819728e-03f, 5.51347174e-02f, -2.74678823e-02f, -3.95319685e-02f, 1.17288038e-01f, 3.74160782e-02f, -1.30650356e-01f, -6.96639791e-02f, -8.77021998e-03f, -9.61143374e-02f,
  -2.04533637e-02f, -3.57871987e-02f, 1.04042124e-02f, 3.17267105e-02f, -8.34514722e-02f, -7.30130374e-02f, -7.37577560e-04f, -7.36264661e-02f, 7.86597282e-02f, 6.31018057e-02f,
  1.29172755e-02f, 7.59082213e-02f, 2.41148807e-02f, -2.87755877e-02f, -4.24139686e-02f, 6.03493955e-03f, 4.26131710e-02f, -4.43754867e-02f, -6.38269819e-04f, 8.91152248e-02f,
  -7.23059103e-03f, 3.99935320e-02f, -2.16488522e-02f, -4.43791784e-02f, 9.54424739e-02f, -7.50359660e-03f, -5.47984578e-02f, -1.96118709e-02f, -5.49791977e-02f, 5.40075125e-03f,
  5.20399362e-02f, -4.93386984e-02f, -8.57607573e-02f, 1.86004750e-02f, -5.06055914e-02f, -1.95236324e-04f, 5.26719987e-02f, -6.00102879e-02f, 4.62884735e-03f, 8.14759266e-03f,
  -5.59693687e-02f, 1.14185745e-02f, 9.15471241e-02f, -1.00014359e-03f, 2.78652590e-02f, -4.33372222e-02f, 2.28010602e-02f, 2.11964856e-04f, 3.22690308e-02f, -2.42686979e-02f,
  9.29585949e-04f, -5.24400361e-03f, 8.57833549e-02f, 6.44993484e-02f, 4.94908728e-02f, 3.27014960e-02f, -6.47945255e-02f, -4.98679727e-02f, 5.26248701e-02f, -8.65589157e-02f,
  -1.13236189e-01f, -1.30335525e-01f, 6.50472641e-02f, 4.13629599e-02f, -4.31676069e-03f, -3.05572117e-04f, -2.50211135e-02f, 4.14964445e-02f, -2.65769679e-02f, -3.22327949e-02f,
  -7.57054612e-02f, -3.10234376e-03f, -5.35685867e-02f, -1.02554243e-02f, -6.66926354e-02f, 5.71532436e-02f, 5.30574545e-02f, -9.39425081e-02f, -7.90366679e-02f, 6.12910204e-02f,
  -5.57855517e-02f, 5.52420691e-02f, -7.29514379e-03f, -3.49643826e-02f, -9.94451810e-03f, 2.55641621e-02f, -4.76371050e-02f, 1.92508828e-02f, 3.59758697e-02f, -8.32092836e-02f,
  4.57555316e-02f, -1.09080009e-01f, -9.11255553e-02f, 6.97815120e-02f, 9.10106674e-02f, 8.35539252e-02f, -1.11585274e-01f, -5.76496981e-02f, -1.14670947e-01f, 7.32680922e-03f,
  -3.75931561e-02f, -4.57807183e-02f, -1.13579430e-01f, 4.58665267e-02f, 2.16509635e-03f, -1.55605018e-01f, 3.96172851e-02f, -3.90714640e-03f, -1.05910115e-02f, 3.95475328e-02f,
  1.53058460e-02f, -4.15749885e-02f, -7.23153055e-02f, 1.27112105e-01f, -4.11987826e-02f, 6.10604789e-03f, 9.80282575e-02f, 7.35599324e-02f, 5.53517006e-02f, 8.26444253e-02f,
  -5.05702682e-02f, -1.36029962e-02f, -8.67485553e-02f, 1.34705445e-02f, 1.11495666e-01f, -3.94639596e-02f, -6.84345737e-02f, -9.38120335e-02f, -4.32150476e-02f, -8.30859244e-02f,
  -8.28916859e-03f, -4.25072201e-03f, 7.28070959e-02f, 3.78532186e-02f, 8.19250196e-02f, -4.33335975e-02f, -5.07746600e-02f, -4.80416492e-02f, -7.07009509e-02f, -1.58461668e-02f,
  -9.01854634e-02f, 2.50908658e-02f, -1.47541584e-02f, 3.21744266e-03f, -5.31073383e-05f, -1.05943512e-02f, -3.49402726e-02f, -3.67835052e-02f, -5.71347354e-03f, -2.55487040e-02f,
  -9.43226460e-03f, 8.13017935e-02f, -5.23347259e-02f, 7.11889938e-02f, 3.79627608e-02f, -9.39056054e-02f, 5.66833243e-02f, -1.54324332e-02f, -4.88867275e-02f, -3.87169085e-02f,
  3.60698393e-03f, 8.38123914e-03f, -3.32886465e-02f, 5.16179278e-02f, 7.51088280e-03f, -8.08359534e-02f, -2.94252764e-02f, 6.48820475e-02f, 4.52463813e-02f, 4.93631177e-02f,
  -6.58528507e-02f, -6.87809810e-02f, -3.24556828e-02f, 5.61582744e-02f, -4.49332260e-02f, 2.00856291e-02f, -6.36539906e-02f, -9.69606219e-04f, 7.96845183e-02f, -6.89983517e-02f,
  -4.39464767e-03f, -1.75149143e-02f, -5.34118749e-02f, 1.04795042e-02f, 8.34672600e-02f, 1.04244247e-01f, -2.31231265e-02f, -4.20440696e-02f, 6.25011921e-02f, -8.18690509e-02f,
  7.35572278e-02f, 4.43053804e-02f, -7.19945831e-03f, 3.61438356e-02f, 1.15426667e-02f, 4.44468446e-02f, -6.09725378e-02f, -5.26668653e-02f, -1.57495309e-02f, -1.26536228e-02f,
  2.44093705e-02f, 4.20511551e-02f, 9.85335633e-02f, 3.59150581e-02f, -5.62110655e-02f, -4.49359640e-02f, 3.37499045e-02f, 5.92868477e-02f, -5.11903912e-02f, -3.01841460e-02f,
  -2.71605074e-01f, 6.80878088e-02f, 2.39590928e-01f, -1.26866162e-01f, -1.76287577e-01f, 2.10489780e-01f, 1.46869734e-01f, -2.50306353e-02f, -1.29676417e-01f, 2.59395838e-02f,
  -1.45565420e-02f, 7.71792931e-03f, 2.44841099e-01f, -6.26253784e-02f, 2.17720032e-01f, 1.70348883e-01f, 2.91703213e-02f, 5.74027337e-02f, -9.54933167e-02f, -4.74665873e-02f,
  -8.36349055e-02f, -1.71261355e-01f, 1.86781704e-01f, -1.53998181e-01f, -7.16676712e-02f, -1.70097336e-01f, -5.07623926e-02f, -6.26634061e-03f, -1.06197886e-01f, 3.55584882e-02f,
  -1.42925173e-01f, -1.62929624e-01f, 3.41372192e-02f, 6.01074025e-02f, 5.00970073e-02f, 6.69178590e-02f, 6.01055287e-02f, 8.73100087e-02f, -9.19884741e-02f, -8.62374827e-02f,
  -5.28644919e-02f, 6.46534190e-02f, -3.39975394e-02f, -3.41775455e-02f, -3.60581167e-02f, -1.06224433e-01f, -1.03832465e-02f, -1.75963659e-02f, -3.52931954e-02f, 5.45503534e-02f,
  3.84088047e-02f, -1.10392831e-03f, 1.50077846e-02f, 2.11851560e-02f, 3.01684476e-02f, 7.89379105e-02f, 1.67210605e-02f, 1.04553357e-01f, -1.80028547e-02f, 2.19095740e-02f,
  8.21131840e-02f, 8.55188891e-02f, 4.77825552e-02f, -2.41995603e-02f, -4.92286985e-04f, -5.71908318e-02f, -2.35618167e-02f, 1.63519662e-02f, -1.34093776e-01f, -5.09801134e-02f,
  -5.67692593e-02f, -7.83572495e-02f, 4.50337119e-02f, 6.83349743e-02f, -3.13964933e-02f, 1.65950060e-02f, 1.07815312e-02f, -9.82114952e-03f, 4.77286205e-02f, -1.61858890e-02f,
  4.57923114e-02f, 7.26976991e-02f, 2.46785209e-02f, 3.73167545e-02f, 6.63126037e-02f, 2.11717710e-02f, -9.36181620e-02f, 4.94973063e-02f, 6.52499944e-02f, -1.40911564e-02f,
  -1.61878094e-01f, -1.05777971e-01f, -7.24062771e-02f, -3.47728096e-02f, -5.88893630e-02f, -3.27013656e-02f, 1.51029136e-02f, -4.68907245e-02f, -5.29080369e-02f, -3.56855839e-02f,
  -1.03421258e-02f, -5.94622605e-02f, -3.46099995e-02f, -4.67601493e-02f, 3.67261060e-02f, 6.13615029e-02f, -5.52993007e-02f, -2.13938896e-02f, 2.76449360e-02f, -1.17093213e-02f,
  -7.27386549e-02f, 2.02466249e-02f, -3.40548418e-02f, -1.01346947e-01f, 6.42990042e-03f, 1.44676184e-02f, -8.58863909e-03f, -1.74070559e-02f, -5.39885052e-02f, 8.35568458e-02f,
  2.23195314e-01f, -9.37587842e-02f, -6.20771907e-02f, 1.11893741e-02f, -1.77136093e-01f, -1.06255785e-01f, -7.26599693e-02f, 4.09275852e-02f, 5.71901537e-02f, 7.54262507e-02f,
  1.18661262e-01f, -7.52845139e-04f, 8.69895145e-02f, 1.19988561e-01f, 1.23984776e-01f, 4.21344750e-02f, 1.93111777e-01f, 1.35826007e-01f, -8.36211164e-03f, 7.81339034e-03f,
  1.99868977e-01f, 2.59666890e-01f, 1.73655421e-01f, 7.81090632e-02f, 5.28585576e-02f, -2.60342304e-02f, 1.46843717e-01f, 9.31008533e-03f, 9.55821723e-02f, 3.73349674e-02f,
  -6.03925111e-03f, 3.19262818e-02f, 5.52543290e-02f, -2.68013515e-02f, -8.06246623e-02f, -1.08275272e-01f, -6.54701963e-02f, -6.66847005e-02f, 9.07794107e-03f, -2.67252289e-02f,
  -2.91972011e-02f, -6.55520931e-02f, 5.66478111e-02f, 5.56706861e-02f, -3.49906087e-02f, 1.80592015e-02f, -5.83886877e-02f, 7.09294528e-02f, -3.62287066e-03f, -6.58417419e-02f,
  -7.08369091e-02f, -2.07309257e-02f, 2.54925266e-02f, -6.86628395e-04f, -3.47944200e-02f, -1.52721861e-02f, -7.42971227e-02f, 3.14152390e-02f, -8.48506950e-03f, -6.55487329e-02f,
  3.71448100e-02f, -7.17106462e-02f, 7.76220188e-02f, -2.14424636e-02f, 7.52786696e-02f, 6.80133095e-03f, 4.69947681e-02f, 4.03440632e-02f, 2.05567498e-02f, -5.54938875e-02f,
  -1.22133037e-03f, -1.93487965e-02f, -1.27452808e-02f, -6.44173324e-02f, 7.37126172e-02f, 6.89559092e-04f, -2.97829416e-02f, 3.26462016e-02f, -5.82862608e-02f, -5.78828566e-02f,
  1.70085207e-02f, 6.85702711e-02f, 6.79462925e-02f, 1.03828788e-01f, -5.44021018e-02f, 3.35558574e-03f, -1.30233597e-02f, -1.20700905e-02f, -7.75078908e-02f, -1.46829232e-03f,
  -5.59219792e-02f, 7.83987939e-02f, 2.66651325e-02f, -6.46854043e-02f, -9.28603709e-02f, -6.35251254e-02f, 3.38251144e-02f, 1.00693718e-01f, 1.89104285e-02f, 1.03260964e-01f,
  -4.75967377e-02f, 3.08392812e-02f, 6.12402782e-02f, -3.25856358e-02f, 7.24715739e-02f, 7.77353868e-02f, 3.77280451e-02f, -4.73630577e-02f, 1.83453560e-02f, -1.62850358e-02f,
  8.23573675e-03f, 2.49716565e-02f, 4.02481928e-02f, -1.15365446e-01f, -5.65963145e-03f, 4.54554819e-02f, -4.83611710e-02f, -8.14430416e-02f, -2.76887994e-02f, 7.50115737e-02f,
  -9.69254375e-02f, -1.15791720e-03f, -1.77697450e-01f, -1.57546178e-01f, 1.06960490e-01f, -5.95267080e-02f, -1.53407946e-01f, 2.81074494e-02f, -3.83862145e-02f, 1.01131760e-01f,
  4.18675095e-02f, -1.42217979e-01f, 4.48706299e-02f, -1.50985628e-01f, -2.25314513e-01f, -7.93379992e-02f, -1.56245485e-01f, -1.39370635e-01f, -6.43525645e-02f, -3.86421084e-02f,
  -1.02861620e-01f, -2.96463333e-02f, -1.30793378e-01f, 2.11920850e-02f, -9.42771956e-02f, -3.22663449e-02f, 3.83888371e-02f, 1.15379564e-01f, -8.84729400e-02f, -3.78816985e-02f,
  -8.68417993e-02f, 9.53300223e-02f, -7.90547058e-02f, -6.58064485e-02f, 6.71384390e-03f, -2.44944803e-02f, 4.64377478e-02f, -2.15691305e-03f, 4.92384285e-02f, -2.09549870e-02f,
  4.40985598e-02f, -2.85468139e-02f, -7.52909249e-03f, -1.97518133e-02f, -1.72833484e-02f, 6.05327860e-02f, 3.10832988e-02f, -2.81870533e-02f, 9.25979465e-02f, -1.02742985e-01f,
  2.22618096e-02f, -1.57901868e-02f, -4.15045246e-02f, -7.22624138e-02f, 3.12962458e-02f, 1.38429618e-02f, -6.88765422e-02f, 2.59516705e-02f, -8.30497593e-02f, -4.14050557e-03f,
  -1.01973535e-03f, -7.23942667e-02f, 7.44344480e-03f, 4.02671546e-02f, -9.00402013e-03f, 1.60082802e-03f, -2.24661026e-02f, -4.03744243e-02f, 4.84664217e-02f, 7.80597329e-03f,
  -3.12151182e-02f, -8.81379936e-03f, -4.28976566e-02f, 1.00206851e-03f, -6.90996274e-02f, 1.46570606e-02f, -4.24154997e-02f, -7.21161962e-02f, -5.99101633e-02f, 9.41542909e-03f,
  3.78789045e-02f, 1.08215706e-02f, -3.70083191e-02f, 6.37718812e-02f, 8.35901946e-02f, 3.35471034e-02f, -5.36490753e-02f, 2.76130810e-02f, -1.26184607e-02f, 1.18401984e-03f,
  -4.90750596e-02f, 5.42725734e-02f, 4.74602729e-02f, 7.31049404e-02f, 5.09066135e-02f, -5.25708981e-02f, -4.44756448e-02f, -4.36260998e-02f, -2.46786159e-02f, -4.26980928e-02f,
  -2.36683022e-02f, -1.84429460e-03f, 1.54730640e-02f, 7.92589635e-02f, 1.84502434e-02f, 4.39790916e-03f, 1.55146997e-02f, -1.75884273e-02f, -4.48816419e-02f, 6.86784536e-02f,
  5.03822267e-02f, 3.44612785e-02f, 2.16671601e-02f, -1.67992841e-02f, 8.72821957e-02f, 6.51787668e-02f, 7.28199631e-02f, 7.09983893e-03f, -5.22884503e-02f, -5.29443845e-02f,
  -1.46078408e-01f, 2.21241146e-01f, -5.61862700e-02f, 1.11240558e-01f, -4.88302112e-02f, 2.57811069e-01f, 2.30967090e-01f, 5.35329245e-02f, 1.51072919e-01f, 3.18959773e-01f,
  1.61787525e-01f, 2.33903397e-02f, 6.56474307e-02f, 3.07737827e-01f, 8.85456204e-02f, 1.68968156e-01f, 2.52683103e-01f, 1.89991742e-01f, -4.02670018e-02f, 5.08803166e-02f,
  -5.54055572e-02f, 1.77158177e-01f, -5.46484925e-02f, -1.37896901e-02f, -2.23717000e-02f, -2.05824181e-01f, -9.69502609e-03f, -1.67183772e-01f, 6.75742775e-02f, 1.02009125e-01f,
  -6.24486096e-02f, 5.80500951e-03f, -8.51296186e-02f, 1.02465469e-02f, -4.48466167e-02f, 6.13492774e-03f, -1.05885528e-02f, -9.10218284e-02f, -7.42529631e-02f, 1.54404091e-02f,
  -1.33768721e-02f, -3.27369533e-02f, -2.64271013e-02f, -1.67624671e-02f, -2.58429684e-02f, -3.24568078e-02f, 2.10261624e-02f, -1.97040178e-02f, -4.12204070e-03f, -3.39903012e-02f,
  -1.06013000e-01f, 9.75649513e-04f, 7.37215504e-02f, 4.41996306e-02f, -6.24820516e-02f, 4.84147063e-03f, 8.63562971e-02f, -8.71709660e-02f, 5.96302003e-02f, 2.76425350e-02f,
  -6.81798831e-02f, -4.97680642e-02f, 1.76877230e-02f, -4.22333163e-04f, 1.19502489e-02f, -7.53494799e-02f, 1.06693700e-01f, -6.63892925e-02f, -3.61519121e-02f, 2.24457812e-02f,
  -1.49492258e-02f, 4.56885174e-02f, 3.63258310e-02f, 5.25846751e-03f, 8.85119289e-02f, -3.46995667e-02f, 6.27960414e-02f, -2.62202732e-02f, 6.94137514e-02f, 4.81176451e-02f,
  -2.52296943e-02f, 3.54491323e-02f, -3.41928052e-03f, 1.67374555e-02f, 3.29095200e-02f, 1.75938420e-02f, -5.11636818e-03f, -3.42055075e-02f, -2.52414085e-02f, -7.11366385e-02f,
  9.95785818e-02f, 9.05458406e-02f, -3.62558886e-02f, -4.67932448e-02f, -2.92408955e-03f, -1.84003506e-02f, 1.56637821e-02f, -2.87484843e-02f, 4.55273800e-02f, -6.23563826e-02f,
  4.12681438e-02f, 9.58578475e-03f, 5.37229441e-02f, 2.78675947e-02f, -1.20617989e-02f, 1.51398387e-02f, 6.55079409e-02f, 1.39728487e-02f, -1.46264052e-02f, -8.10706988e-03f,
  3.01058870e-02f, 6.89527467e-02f, 4.03949730e-02f, -7.05126524e-02f, 3.81392166e-02f, 7.72131514e-03f, -1.61464848e-02f, -4.05883193e-02f, 5.43767922e-02f, 7.07851723e-02f,
  5.46022132e-02f, -1.98544431e-02f, -1.70167819e-01f, -7.05367401e-02f, -2.02775355e-02f, -1.09734312e-01f, -9.60348472e-02f, 1.59614738e-02f, -8.76592705e-04f, -2.57305298e-02f,
  -4.73224707e-02f, 7.06209913e-02f, 7.44134188e-02f, -2.07229257e-01f, -7.85448551e-02f, 4.97069471e-02f, -2.02509567e-01f, -4.26302552e-02f, -9.34263784e-03f, -6.22732677e-02f,
  -4.12305407e-02f, -8.77503157e-02f, 4.49898504e-02f, -7.92122558e-02f, -1.64664522e-01f, -9.04807150e-02f, 8.47584847e-03f, 6.43348917e-02f, 3.31939687e-03f, 5.16787954e-02f,
  -7.69240707e-02f, -1.13564916e-02f, -8.86750519e-02f, -3.79504077e-02f, -7.27583840e-02f, -6.81102723e-02f, 7.47007355e-02f, -2.28891689e-02f, 2.03217138e-02f, 8.43959674e-03f,
  -2.99560353e-02f, 7.51649542e-03f, -7.43603408e-02f, 5.04467636e-03f, -5.06464131e-02f, -9.77731571e-02f, 6.12871125e-02f, 4.70274594e-03f, -8.05340428e-03f, 9.99305211e-03f,
  -5.60618937e-02f, -8.86616558e-02f, 4.42926325e-02f, 7.93641657e-02f, 7.62761533e-02f, -4.47665825e-02f, -8.84158835e-02f, -8.65027308e-02f, 4.65241820e-02f, -9.23910961e-02f,
  -1.99445505e-02f, -8.22110474e-02f, -6.00666441e-02f, -3.68801528e-03f, -4.00377298e-03f, 4.13154736e-02f, 6.43515289e-02f, -2.17954488e-03f, 4.85749766e-02f, 3.56460065e-02f,
  2.21532285e-02f, 3.27774659e-02f, -2.57907659e-02f, 4.54874299e-02f, 3.44659165e-02f, 9.88549441e-02f, -2.60807853e-02f, 5.28422445e-02f, 2.02677256e-04f, -3.64812501e-02f,
  -4.21846546e-02f, -6.91701397e-02f, -2.29030289e-02f, 8.25032219e-02f, -4.26736689e-04f, -5.22418022e-02f, 3.89237888e-02f, 3.46229300e-02f, -9.63336229e-02f, 9.53170508e-02f,
  -6.75948663e-03f, 4.41964865e-02f, 5.13590612e-02f, -3.78507599e-02f, -1.93962809e-02f, -1.54693415e-02f, -5.70943393e-02f, 1.01119727e-02f, -6.95521012e-02f, -6.60180822e-02f,
  -3.74585986e-02f, -6.39628526e-03f, 8.69454890e-02f, 5.91890477e-02f, 5.27231507e-02f, -1.02044262e-01f, 1.02628253e-01f, 5.96008860e-02f, 6.02359138e-02f, 7.93842375e-02f,
  5.89032136e-02f, 1.01361029e-01f, -1.40395332e-02f, 9.16343629e-02f, -2.34705545e-02f, -4.57064100e-02f, -1.05489744e-02f, -2.34380066e-02f, -2.38261689e-02f, 2.08103620e-02f,
  -1.26698792e-01f, -7.04540387e-02f, 2.76463963e-02f, -1.21461311e-02f, -4.91627753e-02f, -3.13849747e-02f, -4.57322113e-02f, 1.41476644e-02f, 1.25391275e-01f, 9.61847231e-02f,
  6.60081953e-02f, -1.52352005e-01f, -3.84553187e-02f, -9.70625803e-02f, 1.27409706e-02f, 1.22858129e-01f, 2.65102852e-02f, -2.03760210e-02f, 1.08986702e-02f, -9.76913944e-02f,
  4.54237238e-02f, -6.10678978e-02f, -5.73393591e-02f, -1.98970921e-02f, 2.05457918e-02f, -2.26135477e-02f, -7.26064891e-02f, 4.69690636e-02f, 1.38377410e-03f, -2.75553409e-02f,
  -8.32300037e-02f, -2.15754728e-03f, 1.29001830e-02f, 6.93775192e-02f, 4.13389504e-02f, 5.21035306e-02f, 2.92428005e-02f, 6.43667802e-02f, 4.14343849e-02f, 1.62945911e-02f,
  -6.89973217e-03f, -7.28057474e-02f, 8.26049671e-02f, 1.10799037e-02f, 1.00073867e-01f, 1.39304232e-02f, 3.35553326e-02f, 5.01844510e-02f, -7.49089047e-02f, -5.13253585e-02f,
  -1.68534517e-02f, 3.62041667e-02f, 3.68661210e-02f, 6.77910000e-02f, 4.13016491e-02f, 6.95791245e-02f, 7.58309988e-03f, 3.13943462e-03f, -4.09106016e-02f, 9.22178775e-02f,
  6.90774620e-02f, 5.85439019e-02f, 1.63816102e-02f, 2.98654772e-02f, 5.66151999e-02f, -1.11851795e-02f, 4.94833477e-02f, 5.10421880e-02f, -8.11415091e-02f, -7.98934326e-02f,
  -1.92399928e-03f, -1.19369008e-01f, -2.11521070e-02f, -6.53555095e-02f, 8.01975653e-02f, 3.01875807e-02f, 2.54836455e-02f, 5.59691787e-02f, 3.49022895e-02f, 5.71774505e-03f,
  -5.29195182e-03f, -9.92886722e-02f, -1.91352572e-02f, -5.73749579e-02f, 1.07991172e-03f, -6.98231384e-02f, -4.29488458e-02f, -2.73516905e-02f, -2.43170969e-02f, -1.00053705e-01f,
  6.95838854e-02f, -8.75592753e-02f, 6.47668913e-02f, -5.44918962e-02f, -4.01818119e-02f, -3.75773460e-02f, 1.64017379e-02f, 5.42393439e-02f, -1.46547221e-02f, 5.77931330e-02f,
  -3.89246299e-04f, 5.50321266e-02f, -1.13072814e-02f, 7.08654150e-02f, -6.59951419e-02f, 5.27863763e-02f, -8.71632397e-02f, 5.54064512e-02f, 1.29670100e-02f, -1.20941242e-02f,
  -1.23676462e-02f, -7.34514743e-02f, -2.37215143e-02f, -7.58271515e-02f, -3.66328135e-02f, -8.38285089e-02f, 2.13215165e-02f, -5.98652139e-02f, -5.97264506e-02f, 3.46427527e-03f,
  9.01853219e-02f, 1.26747906e-01f, 9.83484462e-02f, 1.76253006e-01f, -2.09750667e-01f, -2.18837410e-01f, -1.16722062e-01f, 5.90463206e-02f, 6.96794391e-02f, -6.14499412e-02f,
  6.54899031e-02f, 1.70083314e-01f, 4.08139378e-02f, 3.23458761e-02f, -5.27923666e-02f, 1.01263300e-01f, 8.92971903e-02f, 3.55225988e-02f, -1.75436735e-02f, 3.00289541e-02f,
  1.50777489e-01f, -8.11782107e-02f, 1.77180827e-01f, 1.12941712e-01f, 6.48727501e-03f, 1.56488940e-01f, 7.50476420e-02f, -8.95157307e-02f, -5.25165386e-02f, -1.06447250e-01f,
  1.80953611e-02f, -2.89422572e-02f, -6.96471035e-02f, -7.49644712e-02f, 2.58302242e-02f, -9.22433212e-02f, -8.21779892e-02f, 3.40467095e-02f, 8.43742564e-02f, 5.41140698e-02f,
  -2.42002048e-02f, 5.37317693e-02f, 4.11488935e-02f, -1.16215600e-02f, -3.75995599e-02f, 7.92123191e-03f, -6.00335747e-02f, 8.23277384e-02f, 3.38344425e-02f, 4.57444079e-02f,
  1.74114779e-02f, -1.32271685e-02f, -3.01358327e-02f, 1.12619260e-02f, 5.16050830e-02f, 7.68046901e-02f, 1.76422596e-02f, -8.51564389e-03f, -1.32317347e-02f, -4.63372506e-02f,
  1.07249506e-01f, -8.41973647e-02f, -7.31474906e-02f, 9.07883234e-03f, 3.54210027e-02f, 5.98644838e-02f, -4.75312658e-02f, -9.17466171e-03f, -8.78534839e-02f, 7.91074894e-03f,
  -8.80671367e-02f, 4.72929403e-02f, 6.85817227e-02f, -1.56326704e-02f, 1.52655523e-02f, -6.31156340e-02f, -7.42677674e-02f, -1.03121758e-01f, 5.51769026e-02f, 8.93258601e-02f,
  4.37663980e-02f, 8.11744481e-02f, -4.61853482e-02f, -3.37703638e-02f, 2.14356743e-02f, 5.01006842e-02f, 5.30261062e-02f, 2.59774197e-02f, 3.32555175e-02f, 3.56525742e-02f,
  2.67587323e-03f, 2.09590733e-01f, 6.32836372e-02f, -4.79653552e-02f, -3.37187462e-02f, 4.76546027e-02f, -3.87107581e-02f, -3.08285262e-02f, 1.33017465e-01f, 2.80438568e-02f,
  -7.72400722e-02f, -1.34684034e-02f, -4.28183191e-02f, -4.14380394e-02f, 3.64894308e-02f, -5.33630885e-03f, 5.35036996e-02f, 7.97315538e-02f, -2.64165159e-02f, -2.31502112e-02f,
  7.62267932e-02f, 4.01534587e-02f, 6.68526068e-02f, 3.45798545e-02f, 1.10016063e-01f, -2.97079533e-02f, 9.08423122e-03f, -3.28577012e-02f, -9.76707339e-02f, 1.30714297e-01f,
  -4.29677963e-02f, 8.36609453e-02f, -1.79675594e-01f, 1.22115962e-01f, 1.00562587e-01f, 9.21766181e-03f, -1.06254481e-01f, 1.14854857e-01f, -1.52197450e-01f, 1.76980663e-02f,
  1.29976749e-01f, 3.35042998e-02f, -1.43878564e-01f, 7.24827722e-02f, -1.08696381e-02f, -1.55968830e-01f, 1.48711368e-01f, -1.79155432e-02f, -1.98942404e-02f, 1.11891851e-01f,
  -3.05767115e-02f, 2.00982302e-01f, 2.92016324e-02f, 9.64177325e-02f, 1.04538597e-01f, -2.72907913e-02f, 2.20097572e-01f, -1.01560943e-01f, 1.98351577e-01f, 7.52891749e-02f,
  -1.12240620e-01f, -7.95081034e-02f, 2.63113547e-02f, -3.55198910e-03f, -3.47016230e-02f, 9.94383767e-02f, 4.91338037e-02f, -2.02213246e-02f, -6.69899806e-02f, -9.02871937e-02f,
  -8.77564177e-02f, 3.67458500e-02f, -5.67198098e-02f, 7.35319257e-02f, -3.91317420e-02f, 5.10481303e-04f, 8.59329849e-03f, 4.62294556e-02f, -1.05909847e-01f, -3.93606862e-03f,
  -1.03161342e-01f, 4.07681428e-02f, 1.00899383e-01f, 6.65634051e-02f, 7.62430282e-05f, 1.67654008e-02f, 5.00529334e-02f, -6.79876655e-03f, 5.08954041e-02f, 3.73752750e-02f,
  -3.46439928e-02f, 7.23710135e-02f, -5.42703830e-03f, 1.14301462e-02f, 5.78854121e-02f, -2.18044911e-02f, -1.07578300e-02f, 2.27315780e-02f, 3.47006992e-02f, 9.35165435e-02f,
  5.59058525e-02f, -7.47603104e-02f, 1.30473180e-02f, 1.88896507e-02f, 9.77695957e-02f, -2.50401888e-02f, 1.16940332e-03f, -2.53905412e-02f, -4.51142713e-02f, 5.26539721e-02f,
  1.59302205e-02f, -5.74236885e-02f, -2.59834677e-02f, -1.74095109e-02f, -9.01107583e-03f, -4.73608635e-02f, 6.96840212e-02f, 5.20793488e-03f, -2.59675439e-02f, 7.08116218e-02f,
  6.58899993e-02f, 2.08382204e-01f, -1.07259154e-02f, 1.76068321e-02f, 1.86506822e-03f, 9.13902149e-02f, -6.19724281e-02f, -3.32331401e-03f, 3.60020995e-02f, 9.50692818e-02f,
  -7.52421990e-02f, -3.09914094e-03f, 7.53762797e-02f, -9.76664294e-03f, -4.69377413e-02f, 2.58287471e-02f, 6.31167665e-02f, -1.68808158e-02f, 2.28966288e-02f, 7.89394155e-02f,
  3.38326655e-02f, -1.46549493e-02f, -6.93976730e-02f, -4.59833667e-02f, -4.85779196e-02f, 6.58064112e-02f, -1.19424453e-02f, -9.47729796e-02f, 1.06092189e-02f, 3.73966321e-02f,
  2.96840608e-01f, 1.76454559e-01f, 2.44837448e-01f, 3.69335204e-01f, -1.03291675e-01f, -2.59661209e-02f, 1.25257134e-01f, 1.31808877e-01f, 3.69256228e-01f, -6.64105937e-02f,
  -2.21880257e-01f, 2.68062741e-01f, -9.79427844e-02f, 9.84604135e-02f, -1.46218583e-01f, -5.96028231e-02f, 6.52501881e-02f, 8.32299739e-02f, 9.43783820e-02f, 1.65147081e-01f,
  1.32428154e-01f, -2.07901552e-01f, -6.00209460e-02f, -2.12669998e-01f, 4.77982126e-02f, 1.48988321e-01f, -1.59695894e-01f, -8.84251073e-02f, -1.09374681e-02f, -1.17102139e-01f,
  -3.85233536e-02f, 1.38071015e-01f, -4.62006591e-02f, 4.66362424e-02f, -2.88942419e-02f, 6.63470924e-02f, -3.73184681e-02f, -2.70256735e-02f, -3.12838107e-02f, -2.94161569e-02f,
  5.27493581e-02f, -7.69177824e-02f, 2.29486939e-03f, -2.81255133e-02f, 1.51719004e-02f, 7.00940043e-02f, 7.43160397e-02f, 9.60251689e-02f, -2.09268965e-02f, 2.37503182e-03f,
  1.74389686e-02f, 1.38447545e-02f, 3.32424268e-02f, 6.20229989e-02f, -3.28217968e-02f, 3.70010063e-02f, 6.78067207e-02f, 1.84215400e-02f, 2.11839750e-02f, 8.44078735e-02f,
  4.09972966e-02f, 2.53816880e-03f, -4.83292565e-02f, 1.99167375e-02f, 7.18561094e-03f, -6.52430952e-02f, 1.00520393e-02f, -6.73115812e-03f, -1.63886435e-02f, -4.31160741e-02f,
  3.46104032e-03f, -2.72722375e-02f, 4.76575457e-03f, 6.95877243e-03f, 6.74419254e-02f, -4.82156128e-03f, -1.30545665e-02f, 4.51097265e-02f, 1.24132205e-02f, 9.01866034e-02f,
  4.15828153e-02f, -3.05454973e-02f, -2.79862303e-02f, -6.12432137e-02f, -4.49692197e-02f, -2.78181117e-02f, -3.02925054e-02f, 6.13745488e-02f, 5.05415760e-02f, -3.68465930e-02f,
  -1.28387213e-01f, 3.43525372e-02f, -4.43383977e-02f, -1.46197360e-02f, 7.49998353e-03f, -5.23710884e-02f, 4.37528972e-04f, -5.36987791e-03f, 6.76882826e-03f, -3.22577693e-02f,
  2.82588433e-02f, -1.90827958e-02f, -5.92126623e-02f, 4.95102704e-02f, -4.59766053e-02f, -1.11551218e-01f, 3.95724289e-02f, 4.76970412e-02f, -1.95431300e-02f, -3.88744771e-02f,
  -1.64361671e-02f, -1.36869922e-02f, -3.18654440e-02f, -5.03828935e-02f, -6.34781569e-02f, -4.27252334e-03f, 4.12656441e-02f, 3.01605817e-02f, -4.21369262e-02f, -2.58107763e-02f,
  -2.24488109e-01f, 9.30066109e-02f, -6.04283772e-02f, -1.31620109e-01f, 6.76402822e-02f, -1.27213955e-01f, -4.85985018e-02f, -2.29987651e-02f, -2.82645654e-02f, 9.08652097e-02f,
  8.98290798e-02f, -2.75640525e-02f, 5.98248132e-02f, -1.75426617e-01f, -3.17283839e-01f, -1.10060796e-01f, -9.67651680e-02f, -1.29421398e-01f, -4.89049777e-02f, -8.77517164e-02f,
  -1.13886096e-01f, 3.16702910e-02f, -1.46411166e-01f, 6.52701035e-02f, 5.58349043e-02f, 1.25711992e-01f, -5.50818257e-02f, 1.30914286e-01f, -4.38590571e-02f, 7.35959634e-02f,
  2.00732984e-02f, 1.11988068e-01f, 8.36139172e-02f, -4.52088863e-02f, -2.55563390e-02f, 9.47408192e-03f, -6.02209419e-02f, 8.56544916e-03f, 2.44261380e-02f, -4.19533849e-02f,
  7.25276321e-02f, -1.19747452e-01f, 9.03642923e-03f, 7.59208202e-02f, 8.59149694e-02f, 6.42734990e-02f, -1.06965631e-01f, -5.37064634e-02f, -1.06246024e-02f, 5.05998470e-02f,
  9.59403440e-03f, 3.18263508e-02f, -2.13020258e-02f, -3.07965297e-02f, 4.45936285e-02f, 5.12501076e-02f, 4.88397516e-02f, 4.91407551e-02f, 5.57433441e-02f, -6.32648729e-03f,
  -3.92055623e-02f, -4.17664498e-02f, -9.42588225e-02f, -2.19592173e-02f, -2.45786607e-02f, 5.48570454e-02f, -5.89484237e-02f, 9.67935920e-02f, -3.17956321e-02f, 2.45575290e-02f,
  -7.76503459e-02f, 1.39647117e-02f, 4.90784226e-03f, 4.15057596e-03f, -4.45913449e-02f, -2.31299177e-02f, 5.28600886e-02f, 8.20542052e-02f, -5.30121252e-02f, 9.65943094e-03f,
  1.23574257e-01f, 6.46867678e-02f, 1.78784113e-02f, -7.43181184e-02f, 1.23868482e-02f, -3.13956365e-02f, 1.75302774e-02f, -4.17892374e-02f, 1.43796112e-03f, -4.94116172e-02f,
  -3.23450491e-02f, -4.48535569e-02f, 1.04644708e-01f, 9.93911549e-02f, 2.82982681e-02f, -1.35573046e-02f, -3.38572040e-02f, -6.99329749e-02f, -4.62376922e-02f, -6.43452331e-02f,
  -3.83597054e-02f, 1.35298725e-02f, -2.99605820e-02f, 4.21361656e-05f, -7.71067813e-02f, 3.32063958e-02f, -6.53509870e-02f, 4.22996469e-02f, -7.45676085e-02f, 1.46495113e-02f,
  8.32701917e-04f, 4.03514365e-03f, -5.92192337e-02f, -2.93704197e-02f, -9.50076580e-02f, -7.86998272e-02f, -1.84454732e-02f, -5.65626770e-02f, -5.47877066e-02f, 3.50650027e-03f,
  2.31546804e-01f, -1.34434655e-01f, 7.25775436e-02f, 2.19525769e-01f, 2.07809210e-01f, 8.59571844e-02f, 4.04723622e-02f, -8.82732496e-03f, 2.56405145e-01f, -1.99678936e-03f,
  -6.82410076e-02f, -3.03748511e-02f, -1.46007687e-01f, 2.07149554e-02f, -9.54567418e-02f, -7.06117898e-02f, -2.19323561e-02f, 5.87059148e-02f, 6.37224987e-02f, 4.73730378e-02f,
  1.20497786e-01f, 7.62692466e-02f, -1.85423568e-02f, -1.00139380e-01f, -7.23266415e-03f, 1.15348518e-01f, -1.55655136e-02f, -8.39977860e-02f, -4.19145972e-02f, -1.34377554e-01f,
  -7.89009333e-02f, 4.85423394e-02f, 6.87633920e-03f, -4.65168580e-02f, 1.75158437e-02f, -4.28530723e-02f, -1.05196632e-01f, 5.20263193e-03f, 3.05822473e-02f, -3.33675370e-02f,
  -1.03299525e-02f, 3.16334702e-03f, 1.15744732e-01f, 4.15273719e-02f, 9.14475992e-02f, -1.87374596e-02f, 2.04607472e-02f, 7.86121115e-02f, -8.19341280e-03f, -2.53875982e-02f,
  3.79486792e-02f, -3.62211615e-02f, 7.21203908e-02f, 2.22170982e-03f, -2.41319649e-02f, 7.85131231e-02f, -8.30532908e-02f, 5.43548279e-02f, -5.23543023e-02f, 6.15503788e-02f,
  -1.52241727e-02f, 1.37294624e-02f, 3.87653452e-03f, -3.47937606e-02f, -3.01487707e-02f, 4.19345871e-02f, -8.16551223e-03f, -5.29526025e-02f, 2.89659444e-02f, -5.81871904e-02f,
  5.45696542e-02f, 3.61999646e-02f, 2.52235215e-02f, 5.95672429e-02f, -4.75388467e-02f, 7.31334910e-02f, -1.51151242e-02f, 1.12373745e-02f, 5.26270084e-02f, -2.99703125e-02f,
  4.36352193e-02f, -3.39675993e-02f, -1.14366496e-02f, 5.88672748e-03f, -6.84603751e-02f, -7.80373514e-02f, 8.48074332e-02f, -1.39802964e-02f, 8.26069489e-02f, -8.70942324e-02f,
  -1.32720158e-01f, -1.55314639e-01f, 1.92930587e-02f, -7.77861923e-02f, -9.48564857e-02f, 1.29658785e-02f, 5.89704923e-02f, -5.27300127e-02f, -1.22215047e-01f, 2.77157128e-03f,
  2.19934080e-02f, -2.96780728e-02f, -3.19599174e-02f, 4.49082591e-02f, -6.26213402e-02f, -3.32374163e-02f, -3.13475877e-02f, -1.06458247e-01f, -3.58857289e-02f, -4.31180410e-02f,
  -1.41661949e-02f, 4.82275076e-02f, -7.17006847e-02f, 6.86312094e-02f, 1.88877620e-02f, 2.60039512e-02f, -9.59096570e-03f, -1.33479744e-01f, -4.19582799e-02f, -1.45636126e-02f,
  1.34926081e-01f, -9.81131494e-02f, -1.28921509e-01f, -1.26642928e-01f, -8.96532312e-02f, -9.58374292e-02f, -1.89718813e-01f, -1.90282673e-01f, -1.79321945e-01f, -1.37090802e-01f,
  -1.19911671e-01f, -4.27282155e-02f, -4.58029844e-02f, -2.28716046e-01f, 1.60048857e-01f, 1.50352463e-01f, -1.79694906e-01f, -9.53194499e-02f, -2.99118608e-02f, -3.73840258e-02f,
  -7.19752386e-02f, -1.36001751e-01f, -6.71110600e-02f, -1.23885078e-02f, -1.70711800e-01f, -8.08286369e-02f, 4.15840596e-02f, -2.06133202e-02f, -1.33562788e-01f, -8.70009214e-02f,
  -8.83154105e-03f, -3.39155346e-02f, -1.07264154e-01f, -6.31336942e-02f, 5.05601689e-02f, -4.73105274e-02f, 5.92060527e-03f, 8.48063305e-02f, 7.36078545e-02f, -8.86311680e-02f,
  1.12516440e-01f, 8.68056342e-02f, 2.90417578e-02f, -7.12204203e-02f, -1.03451468e-01f, -8.22264925e-02f, 5.14735803e-02f, -3.63343279e-03f, -4.50553447e-02f, 2.44672666e-03f,
  -1.68617722e-02f, -4.10828274e-03f, -8.44439343e-02f, -6.13414608e-02f, -6.57888651e-02f, 3.91876884e-02f, -1.29956538e-02f, -4.16383259e-02f, 1.74306184e-02f, 3.54083553e-02f,
  9.64346454e-02f, 2.49437205e-02f, 7.75207505e-02f, -6.36901986e-03f, -2.93383803e-02f, -1.96144860e-02f, -9.58367065e-02f, -2.03317888e-02f, 7.22315768e-03f, -2.88428366e-02f,
  -2.97704227e-02f, -9.01773944e-03f, 6.16237782e-02f, 7.29342103e-02f, 5.83829284e-02f, -1.74407791e-02f, -2.36753710e-02f, -1.75030939e-02f, -7.15890452e-02f, 6.06790558e-03f,
  4.27918583e-02f, 2.52101850e-02f, 6.85161259e-03f, -2.54436154e-02f, 6.10273480e-02f, 1.48894014e-02f, 4.11841646e-02f, 2.50673704e-02f, 2.92915609e-02f, 7.63008222e-02f,
  -7.42499456e-02f, -1.55007960e-02f, -7.22503290e-02f, -5.03033958e-02f, 1.89675223e-02f, -4.30525932e-03f, -4.27203737e-02f, 7.35064447e-02f, -7.87699968e-02f, 2.26459969e-02f,
  -3.98791805e-02f, -3.76928709e-02f, -2.93906629e-02f, 3.51746157e-02f, -5.37404642e-02f, -5.67080230e-02f, -7.84361288e-02f, -2.63030846e-02f, -3.36820781e-02f, 7.21447021e-02f,
  -1.10924840e-01f, -4.83919159e-02f, 6.56258315e-02f, 1.49741350e-02f, -9.29051265e-03f, 5.30188158e-03f, -7.98233002e-02f, 9.07828137e-02f, 1.28663890e-02f, -9.51176733e-02f,
  -9.31250378e-02f, -3.22601497e-02f, -9.85856354e-02f, 2.21661583e-04f, -2.07642287e-01f, 6.05043769e-02f, -3.40446755e-02f, -4.82389554e-02f, 1.93683863e-01f, 1.65568992e-01f,
  -1.18336044e-01f, 8.38899165e-02f, 1.07633874e-01f, 3.93633246e-02f, 6.59792796e-02f, 2.29902700e-01f, -9.00144689e-04f, -6.31968537e-03f, 5.38172051e-02f, -1.24528483e-01f,
  -7.30770752e-02f, 1.92517061e-02f, -1.61867037e-01f, -1.06525123e-01f, -1.53869793e-01f, -8.99283066e-02f, -4.85687666e-02f, -1.48013711e-01f, -1.20922238e-01f, 2.10048296e-02f,
  -1.24205165e-02f, 1.18954973e-02f, -4.40278836e-02f, 4.37841602e-02f, 3.69946584e-02f, 2.42333878e-02f, -3.54924127e-02f, 4.12061363e-02f, 3.60747613e-02f, 4.49494906e-02f,
  -3.09129655e-02f, -2.59275250e-02f, 3.02175637e-02f, 2.48519629e-02f, -2.45685782e-03f, -3.72348279e-02f, -1.35968812e-02f, -8.22518691e-02f, -5.30670770e-03f, 7.27348728e-03f,
  -3.37533541e-02f, 9.98304877e-03f, -2.06692331e-02f, 1.87567882e-02f, -9.02133584e-02f, -2.53368262e-02f, 5.37999496e-02f, 8.80594105e-02f, 5.79008833e-02f, 1.66828260e-02f,
  -1.36407856e-02f, 4.50129136e-02f, -4.38132416e-03f, 3.73890921e-02f, -5.45566790e-02f, 3.04421578e-02f, 3.70453931e-02f, -5.90576939e-02f, 3.55927311e-02f, -6.07539751e-02f,
  -5.03518358e-02f, -5.23770489e-02f, -3.06793470e-02f, -2.54645906e-02f, -6.15271181e-02f, 5.95517792e-02f, 2.36597490e-02f, -6.24301806e-02f, -1.49847334e-02f, -5.61121516e-02f,
  1.11116126e-01f, -7.16139674e-02f, 1.32989958e-02f, -4.30618525e-02f, -3.06159407e-02f, -2.73985392e-03f, 5.82231469e-02f, -7.00367764e-02f, 5.22024594e-02f, -7.19050020e-02f,
  5.62101193e-02f, 1.65864080e-01f, 6.30764812e-02f, 1.19563147e-01f, 2.71884985e-02f, 3.17461342e-02f, -7.34121120e-03f, -5.79041913e-02f, 1.83562022e-02f, 1.34175584e-01f,
  -4.12650779e-02f, 7.37005770e-02f, -6.83580637e-02f, 1.03980117e-02f, -2.74195988e-02f, -2.40594391e-02f, -8.66537821e-03f, -5.17411605e-02f, -4.24660183e-02f, -9.76707879e-03f,
  -9.45785176e-03f, -1.93364744e-03f, 2.42615417e-02f, 5.93113266e-02f, 5.55188395e-02f, 7.50394091e-02f, -1.93810984e-02f, 6.48038536e-02f, 1.41083449e-02f, 1.83218252e-02f,
  1.29705369e-01f, -2.49135327e-02f, -1.03026502e-01f, -4.24959287e-02f, 8.57661068e-02f, -8.01431313e-02f, -1.72018498e-01f, 3.10834944e-02f, -1.99142292e-01f, 5.67560457e-02f,
  6.82710186e-02f, -1.58033505e-01f, -1.33265108e-01f, 7.12189674e-02f, 5.68424203e-02f, -2.02490076e-01f, 1.56321689e-01f, -3.63848805e-02f, -1.36728048e-01f, 4.74147201e-02f,
  3.70476558e-03f, 2.46400118e-01f, -8.45420957e-02f, 1.43989399e-01f, 6.86312541e-02f, 6.77649677e-02f, 2.14755014e-01f, -7.01409057e-02f, 9.87708196e-02f, 3.22200060e-02f,
  4.26001623e-02f, -6.71821609e-02f, -3.52908820e-02f, -1.25148728e-01f, 9.62269828e-02f, 2.67230850e-02f, -3.08199432e-02f, -9.55943484e-03f, -3.51458713e-02f, 1.61227807e-02f,
  -6.77351430e-02f, -6.79718554e-02f, 7.59861469e-02f, 8.44819769e-02f, 5.65024849e-04f, -3.04983407e-02f, 3.97035759e-03f, -1.37150548e-02f, -1.09112352e-01f, 5.82883097e-02f,
  -5.05063795e-02f, 3.25837582e-02f, -3.04492712e-02f, 4.50563394e-02f, 1.15902955e-03f, 3.04420795e-02f, -3.07727419e-02f, -4.69375588e-02f, -1.16975885e-02f, -1.60130952e-02f,
  6.78452998e-02f, -2.69318596e-02f, -4.53002900e-02f, -7.32384995e-02f, 2.03076191e-02f, -6.07175902e-02f, -3.56218256e-02f, 1.17938723e-02f, -3.54607217e-02f, 1.05667664e-02f,
  5.00814850e-03f, -1.78049412e-02f, -9.43382457e-02f, 6.83281571e-02f, 7.27235079e-02f, 1.01468340e-02f, 1.26535529e-02f, 1.45263113e-02f, -1.07872980e-02f, -9.03438719e-04f,
  -8.32174718e-03f, 8.45988914e-02f, -3.49204540e-02f, 2.63982476e-03f, -4.56088483e-02f, 1.20179271e-02f, 7.80065777e-03f, -5.53813316e-02f, 3.68906669e-02f, -9.96565297e-02f,
  8.48949403e-02f, 1.81984574e-01f, 3.25621641e-03f, 1.13164615e-02f, 2.15533525e-02f, -1.15599902e-02f, -6.03063256e-02f, 5.12746200e-02f, 4.20147367e-02f, 7.77572719e-03f,
  1.14466950e-01f, 3.97555158e-02f, 5.28173707e-02f, 3.43306223e-03f, 2.91221999e-02f, -3.29950446e-04f, -5.53190075e-02f, -5.64547209e-03f, 1.72799677e-02f, 2.10129227e-02f,
  1.19222395e-01f, -3.47778620e-03f, -1.02515511e-01f, -5.93600161e-02f, 8.17732513e-02f, 4.80376072e-02f, 6.82235360e-02f, -6.08575232e-02f, 1.56484377e-02f, -1.63721684e-02f,
  9.38248411e-02f, -6.11816384e-02f, -2.06201747e-02f, -1.52043430e-02f, -6.33545220e-02f, -7.46902749e-02f, -1.10731713e-01f, -4.76848632e-02f, -5.99493571e-02f, -6.21102145e-03f,
  -5.87714016e-02f, -3.32327746e-02f, 1.28924191e-01f, -7.06373006e-02f, 1.10718533e-01f, 7.89771453e-02f, -2.38285381e-02f, 4.48522680e-02f, -7.94480965e-02f, 2.06254516e-02f,
  6.22215681e-02f, 1.59188565e-02f, -5.17474525e-02f, -6.64988533e-02f, 1.08486330e-02f, -5.12039810e-02f, 4.67444323e-02f, -2.91194804e-02f, -1.13540411e-01f, 7.27584437e-02f,
  3.29455286e-02f, -8.83049369e-02f, -5.99269792e-02f, 8.50796252e-02f, -3.51480171e-02f, -2.97188889e-02f, -1.37896938e-02f, -3.01097017e-02f, -1.98869351e-02f, 1.20524764e-02f,
  -5.57196187e-03f, -2.96028256e-02f, -7.46604577e-02f, -2.75595766e-03f, 6.17654361e-02f, 7.30244815e-03f, -8.45447406e-02f, -3.43688242e-02f, 4.09899689e-02f, 8.66102874e-02f,
  -1.69729665e-02f, 9.10502970e-02f, 3.28883678e-02f, -4.64089140e-02f, 6.07058629e-02f, 7.06492960e-02f, 2.63690893e-02f, -3.40521298e-02f, 6.87406957e-02f, 1.59313194e-02f,
  -7.57305976e-03f, -2.17334516e-02f, 1.45981729e-03f, 6.88767359e-02f, -8.25718120e-02f, -4.56498675e-02f, 3.21273529e-03f, -6.61637168e-03f, -6.02460429e-02f, 1.10257464e-02f,
  -5.43445488e-03f, 3.50021617e-03f, 2.67868512e-03f, 7.38476887e-02f, 3.60383801e-02f, 2.73356698e-02f, -2.57813539e-02f, -5.60424291e-02f, 4.52995934e-02f, 5.38954362e-02f,
  6.37302324e-02f, 2.78685093e-02f, -3.46424580e-02f, 8.98671821e-02f, -5.10002412e-02f, 1.95730496e-02f, 1.07994359e-02f, 2.43499819e-02f, 1.72905289e-02f, -3.70863415e-02f,
  -6.07637316e-02f, 1.14818420e-02f, -2.77044531e-02f, -4.87874970e-02f, 8.45904425e-02f, -2.18395470e-03f, 8.45261440e-02f, -1.37910983e-02f, 8.94591399e-03f, -3.61160450e-02f,
  7.00175613e-02f, -6.84425160e-02f, 8.59609097e-02f, -6.71214089e-02f, 5.54552488e-02f, -8.91035423e-02f, -5.63393272e-02f, -7.80611783e-02f, 6.36388212e-02f, 6.69845864e-02f,
  4.97430786e-02f, 6.85067195e-03f, 6.28486350e-02f, -6.47883415e-02f, 4.55771759e-02f, 4.25158953e-03f, -4.68820194e-03f, 1.93043090e-02f, -3.68188135e-02f, 4.87851314e-02f,
  1.57599077e-02f, 1.18476219e-01f, -1.00496493e-01f, 1.17359357e-02f, 1.86577931e-01f, 2.13986650e-01f, 6.00438789e-02f, 8.66583288e-02f, 5.51597252e-02f, 1.52244329e-01f,
  3.03120688e-02f, -5.00768758e-02f, 4.80674095e-02f, 1.33754332e-02f, -7.83979148e-03f, 3.47621664e-02f, 1.09459378e-01f, 1.43483117e-01f, -2.65098866e-02f, 1.41313434e-01f,
  -5.08738309e-02f, 1.31942734e-01f, -1.85929626e-01f, -5.15676616e-03f, -9.86065809e-03f, -1.12363383e-01f, -1.66608226e-02f, -1.45381391e-01f, 6.65940642e-02f, -1.56780742e-02f,
  1.29895927e-02f, -1.95597075e-02f, -3.16676684e-02f, 2.15663053e-02f, 1.10967057e-02f, 6.35249913e-02f, 8.94605124e-04f, -1.30631119e-01f, -1.77268274e-02f, 1.93581823e-02f,
  9.63317677e-02f, -4.79323082e-02f, 3.79667692e-02f, -7.85425305e-03f, -2.44378354e-02f, -1.54375168e-03f, -6.91932440e-02f, -6.78122863e-02f, -6.45884573e-02f, 4.78564501e-02f,
  -5.59802651e-02f, 5.54265566e-02f, -4.85141613e-02f, -3.06866951e-02f, 6.41533732e-02f, -2.21322589e-02f, 9.85693634e-02f, -7.68801495e-02f, -1.09829511e-02f, -3.90721224e-02f,
  6.53332472e-02f, -1.61285698e-02f, 6.47927895e-02f, 5.47849350e-02f, -1.50674330e-02f, 1.92312188e-02f, -1.24788831e-03f, -9.32622850e-02f, -6.52775615e-02f, 5.58750927e-02f,
  -5.59434667e-03f, 2.91674584e-02f, -9.06438082e-02f, -2.82833073e-02f, -5.53849377e-02f, -7.82851651e-02f, -1.18959635e-01f, 3.95399034e-02f, -6.73715472e-02f, -6.57885596e-02f,
  1.20038893e-02f, 6.10680245e-02f, -7.39061460e-02f, 7.24179000e-02f, -5.79274781e-02f, -5.51243536e-02f, -7.01211905e-03f, -3.58182304e-02f, -1.92313548e-02f, -2.52839290e-02f,
  1.24481685e-01f, 2.17543945e-01f, -7.53230080e-02f, -1.10583389e-02f, 5.22022769e-02f, 1.15519226e-01f, 6.74569458e-02f, 2.25844011e-02f, -6.04437329e-02f, -2.41522994e-02f,
  9.35266167e-02f, 4.04634373e-03f, 4.90570329e-02f, -2.36476697e-02f, 8.99379980e-03f, -6.22481108e-03f, 5.91313280e-02f, -5.37478514e-02f, 1.04168631e-01f, -4.36634310e-02f,
  -3.95023078e-02f, 2.04008203e-02f, -4.08349335e-02f, 2.60133445e-02f, -6.78699435e-05f, -3.13478447e-02f, 1.68025512e-02f, 2.98623145e-02f, 6.94879070e-02f, 3.77134271e-02f,
  -8.47236142e-02f, 3.37423384e-03f, -2.15867739e-02f, 1.21197261e-01f, 5.15439473e-02f, -4.54165116e-02f, -7.55150095e-02f, 1.91969126e-02f, -2.99009811e-02f, 9.01720896e-02f,
  -2.42299289e-02f, -1.65996730e-01f, 4.71505783e-02f, -1.28921932e-02f, -1.29281983e-01f, -1.61228329e-01f, -4.77836234e-03f, -3.05541651e-03f, -9.81175005e-02f, 3.85153592e-02f,
  8.84776935e-02f, 2.11474728e-02f, 1.56170484e-02f, 1.30169481e-01f, -3.55664864e-02f, 1.34033710e-01f, 1.63432181e-01f, 5.09294234e-02f, 1.94236245e-02f, -2.38225758e-02f,
  4.44713086e-02f, 4.02265936e-02f, -6.09513782e-02f, -2.35005245e-02f, 9.18270648e-02f, 8.39830488e-02f, -3.08078667e-03f, -1.07964709e-01f, -8.06258060e-03f, 2.29175240e-02f,
  -3.53997271e-03f, 3.79395112e-02f, -6.70353323e-02f, -7.02154413e-02f, -1.84864923e-02f, -6.06813608e-03f, -4.36542882e-03f, -7.79169286e-03f, -2.62408964e-02f, -7.08938166e-02f,
  4.23440970e-02f, -1.89511068e-02f, 8.36439729e-02f, -6.02850914e-02f, 2.27325242e-02f, -1.08413501e-02f, 8.31052195e-03f, 4.69422974e-02f, 8.91562775e-02f, -7.92434886e-02f,
  6.46610036e-02f, -3.28576118e-02f, -1.61696877e-02f, 9.68839414e-03f, -6.51347265e-02f, -2.11239886e-02f, 9.08878669e-02f, 6.10048771e-02f, -2.34915372e-02f, 2.39906134e-03f,
  3.45454141e-02f, 9.06865671e-02f, 5.95408194e-02f, 2.04333966e-03f, 5.35977408e-02f, -5.54133840e-02f, -1.11334054e-02f, -1.85874943e-03f, -5.59412874e-02f, 1.59877893e-02f,
  8.61326754e-02f, 2.04697996e-02f, -3.00591644e-02f, -3.99241224e-03f, 4.75056730e-02f, -8.20567235e-02f, 1.73178909e-03f, -7.81807825e-02f, 6.13230206e-02f, -8.49895272e-03f,
  6.30459860e-02f, 1.42321795e-01f, -3.21777128e-02f, 1.28615806e-02f, 1.61197651e-02f, -4.27930914e-02f, -1.71352532e-02f, 1.23945102e-02f, -3.96472476e-02f, -5.23141138e-02f,
  -1.18765347e-02f, 6.27181605e-02f, 1.14293776e-01f, -2.14908253e-02f, 3.33939455e-02f, -1.87402940e-03f, 9.16154161e-02f, 9.47650671e-02f, 1.16938904e-01f, 8.81906524e-02f,
  1.03762329e-01f, 4.64462973e-02f, 4.57970686e-02f, 8.57210997e-03f, 1.08391559e-02f, 5.66544533e-02f, 7.12060928e-02f, -2.01601558e-03f, 3.11457664e-02f, 6.48922171e-04f,
  -2.42960036e-01f, 2.01328442e-01f, 4.30134088e-02f, 1.59441620e-01f, -6.07234240e-02f, 4.96530533e-02f, 2.35005513e-01f, -6.04693554e-02f, -3.13879587e-02f, 2.69485801e-01f,
  1.42996758e-01f, -5.80710880e-02f, 7.05356225e-02f, 2.15813234e-01f, 9.59790200e-02f, 1.34969488e-01f, 2.74742186e-01f, 1.51850596e-01f, -1.42972618e-01f, 3.66992578e-02f,
  -9.30333659e-02f, 5.14916703e-02f, 1.92124605e-01f, -5.39598688e-02f, 5.95744923e-02f, -5.63810058e-02f, 9.31886062e-02f, -9.87387635e-03f, 7.82172382e-02f, 7.75235668e-02f,
  5.34080081e-02f, -2.54968479e-02f, -4.79052886e-02f, -8.70984420e-02f, -6.24917299e-02f, -5.95577769e-02f, 4.00997177e-02f, -1.49871204e-02f, -9.99468565e-02f, -1.35799237e-02f,
  5.84528260e-02f, -3.27946991e-02f, -5.21760732e-02f, 4.23175097e-03f, -1.11523092e-01f, 3.67620587e-02f, 2.96554398e-02f, -7.71058798e-02f, 3.60673815e-02f, -3.15240324e-02f,
  9.13219433e-03f, -1.03437759e-01f, 1.65063068e-02f, 2.11110916e-02f, 2.45248377e-02f, 1.01650497e-02f, 1.83214003e-03f, 3.59370857e-02f, -3.63848284e-02f, -2.62422282e-02f,
  -5.29969819e-02f, -8.08685794e-02f, -5.33188879e-02f, -3.31388004e-02f, -7.72905797e-02f, 2.14392394e-02f, -1.98358297e-02f, 5.24337217e-02f, 3.66337597e-02f, -3.67011987e-02f,
  7.40535185e-02f, 6.77057505e-02f, 3.91634293e-02f, 2.01017372e-02f, -2.23887898e-02f, 1.94176380e-02f, -3.39296572e-02f, 1.01986425e-02f, -1.10539729e-02f, -6.16112612e-02f,
  5.12804277e-02f, 5.11123054e-02f, 2.17315201e-02f, 2.67369132e-02f, -1.40063455e-02f, 3.27560976e-02f, -1.94588024e-02f, 6.18875772e-02f, -3.38303018e-03f, -8.05207640e-02f,
  3.55557427e-02f, 1.06343746e-01f, 1.02280557e-01f, -8.39703977e-02f, 8.98661371e-03f, -1.13140251e-02f, -1.57614294e-02f, 4.07518819e-02f, 6.67928010e-02f, -8.71689469e-02f,
  -8.26747641e-02f, -3.79032902e-02f, -1.50616933e-02f, -3.24321836e-02f, -2.52248980e-02f, 5.00887819e-02f, 5.38795851e-02f, -4.13804874e-02f, 1.84626002e-02f, -3.71302888e-02f,
  4.29064818e-02f, -2.71167886e-02f, 1.27681978e-02f, 6.37446046e-02f, -7.10866600e-02f, 4.00051624e-02f, -8.95629749e-02f, -5.05166389e-02f, -6.65689409e-02f, -1.95410717e-02f,
  2.32814271e-02f, 1.37299420e-02f, 1.04030848e-01f, -1.10355876e-01f, 8.49597603e-02f, -7.14190081e-02f, -8.57235417e-02f, -6.90139383e-02f, 9.92408022e-02f, -1.06189102e-01f,
  -4.16235290e-02f, -1.05939398e-03f, -7.36893862e-02f, -9.58693251e-02f, -1.13264501e-01f, -1.08298287e-01f, -1.46510109e-01f, 3.64464819e-02f, 4.07212675e-02f, -8.08840990e-02f,
  7.06290652e-04f, -1.32130897e-02f, 1.26564521e-02f, 3.66207957e-02f, 3.66298370e-02f, -6.21306300e-02f, -2.13127118e-02f, -4.40177433e-02f, 5.64231649e-02f, 4.09637727e-02f,
  1.03111014e-01f, -9.23045576e-02f, 1.03361093e-01f, -3.75287421e-02f, -9.76530537e-02f, -8.89236033e-02f, 3.27315964e-02f, -4.86541055e-02f, 9.15823802e-02f, -4.78078052e-02f,
  -5.51491827e-02f, 6.12593405e-02f, -3.53296027e-02f, -6.57212809e-02f, 6.62844628e-02f, 1.96504146e-02f, -6.37749061e-02f, 3.42891552e-02f, -3.12220361e-02f, -3.90859731e-02f,
  -8.62562284e-02f, 7.99114779e-02f, -6.17424883e-02f, -4.71712761e-02f, -3.01788487e-02f, 7.11865257e-03f, -5.47619648e-02f, -7.14252442e-02f, -1.52276708e-02f, -9.94677003e-03f,
  -5.20174904e-03f, -4.51820269e-02f, 3.42521374e-03f, 4.13440205e-02f, -2.32183263e-02f, 4.75700162e-02f, -3.46143544e-02f, -3.57306302e-02f, -4.52895164e-02f, -9.12793130e-02f,
  8.43297914e-02f, -2.34587006e-02f, 1.18649140e-01f, 5.55810370e-02f, 5.75288348e-02f, 6.89797848e-02f, 8.15705210e-02f, 6.97833300e-02f, 2.94031519e-02f, 4.45750169e-02f,
  -2.07411181e-02f, 2.08131429e-02f, -4.19432297e-02f, 8.27715546e-02f, 1.48326065e-02f, 8.61293003e-02f, -3.65823880e-02f, -1.82476677e-02f, 7.92532787e-02f, 7.21083581e-02f,
  6.52161520e-03f, -6.54924586e-02f, 4.71945442e-02f, 1.02260262e-01f, 7.20199347e-02f, 3.32748555e-02f, -6.91906512e-02f, -1.18753510e-02f, -2.01775692e-03f, 2.04354841e-02f,
  -3.01887654e-02f, 4.30270247e-02f, 9.67566576e-03f, 1.00151479e-01f, -6.59811422e-02f, 3.33777443e-02f, -8.14408064e-04f, 4.90029976e-02f, -7.90718421e-02f, 7.40481094e-02f,
  2.05628984e-02f, -6.65103570e-02f, -2.21312209e-03f, 9.00767893e-02f, 2.08057719e-03f, -4.71463986e-02f, 1.02806188e-01f, -4.70611043e-02f, 5.97374104e-02f, 2.42109466e-02f,
  -6.08790666e-02f, 9.66580138e-02f, 7.25015402e-02f, -1.61784161e-02f, 5.80258481e-02f, -1.62418887e-01f, -8.78542066e-02f, -7.45691881e-02f, 2.53567919e-02f, 2.04324558e-01f,
  -1.34150926e-02f, 1.31040504e-02f, 1.90200936e-02f, -6.08612560e-02f, -2.61842102e-01f, -1.47473246e-01f, -1.13833308e-01f, 2.80729565e-03f, -4.38441411e-02f, 6.20908709e-03f,
  -3.59647460e-02f, -1.12809941e-01f, -1.10193439e-01f, 8.14746991e-02f, -2.73318700e-02f, 1.30929053e-01f, -5.99812195e-02f, -1.88037753e-02f, 6.03629090e-02f, -1.80954952e-02f,
  -8.69216174e-02f, 9.32258964e-02f, 1.10513248e-01f, 7.51059130e-02f, 3.34924459e-02f, -1.86704621e-02f, 4.91661653e-02f, -1.07942894e-02f, 1.70064326e-02f, -3.31749246e-02f,
  1.82745382e-02f, -6.68531805e-02f, -3.04510500e-02f, 5.86347096e-02f, 1.55738248e-02f, 5.34715168e-02f, -9.08565819e-02f, 2.79639773e-02f, 1.39495343e-01f, -1.29284300e-02f,
  9.59567428e-02f, 5.52636646e-02f, -2.30930131e-02f, -2.34783478e-02f, 6.84419498e-02f, 1.57851130e-02f, 2.01570280e-02f, -1.14864986e-02f, -8.00086781e-02f, -4.09001410e-02f,
  8.74728560e-02f, 2.35622469e-03f, -6.81776479e-02f, -7.90683553e-03f, -4.48504575e-02f, 2.58158389e-02f, 8.05961043e-02f, 4.18581851e-02f, 2.04263385e-02f, -8.35566968e-02f,
  -3.66301201e-02f, 5.64484037e-02f, 4.01994819e-03f, 7.42805526e-02f, -1.79153010e-02f, -1.28402058e-02f, 4.52537183e-03f, -2.95708403e-02f, -2.84535680e-02f, -3.53639834e-02f,
  -8.57626051e-02f, 5.02272248e-02f, 6.23303000e-04f, -3.82578559e-02f, 3.88800055e-02f, 3.14780930e-03f, 3.57212462e-02f, -4.80507575e-02f, -3.22950222e-02f, -3.26908790e-02f,
  1.80721786e-02f, 8.77009481e-02f, 2.35415064e-02f, -4.90596564e-03f, -7.68577605e-02f, 4.07266505e-02f, -2.86155473e-02f, 3.92251052e-02f, 1.02842543e-02f, -7.16122985e-02f,
  -3.53225023e-02f, -2.50694137e-02f, 4.27678227e-03f, 7.81267136e-03f, 2.40627434e-02f, 1.09042861e-02f, -5.42675480e-02f, 3.35019119e-02f, 2.66420450e-02f, -1.15361344e-02f,
  -4.12339307e-02f, -1.54008316e-02f, -2.35351790e-02f, -7.95179456e-02f, -3.82080749e-02f, -8.67922790e-03f, -5.86697534e-02f, 8.83537754e-02f, 5.09433337e-02f, -1.04962382e-02f,
  8.90569109e-03f, 2.93005556e-01f, 1.37448728e-01f, 1.66565880e-01f, 6.74350485e-02f, -1.63694635e-01f, -1.05075136e-01f, 1.02708548e-01f, 2.80252546e-01f, -3.12789865e-02f,
  -1.38895720e-01f, 1.18015580e-01f, -4.44112495e-02f, -2.49907151e-02f, -5.94630651e-02f, -4.88406010e-02f, 1.44582912e-01f, 3.42547968e-02f, 1.61076993e-01f, 1.06300376e-01f,
  9.37695354e-02f, -9.61061046e-02f, -1.38438828e-02f, -8.24640095e-02f, 4.31892052e-02f, 8.66541043e-02f, -1.22017831e-01f, -6.97004125e-02f, -1.26868069e-01f, 4.60192300e-02f,
  -8.50034207e-02f, 1.34022236e-01f, -2.02508159e-02f, -5.60281239e-02f, 3.01552415e-02f, -3.30474153e-02f, -5.12033515e-02f, -1.99276712e-02f, 2.81698704e-02f, -7.62228817e-02f,
  -9.58682969e-03f, -6.39060363e-02f, 7.29786349e-04f, 2.47877631e-02f, 1.31639196e-02f, 8.35695788e-02f, 1.66286808e-02f, 3.59608829e-02f, 4.94219996e-02f, -2.68102735e-02f,
  -3.28518637e-02f, 2.14999486e-02f, 4.92444001e-02f, -7.34072477e-02f, 3.11957970e-02f, -6.07630722e-02f, -8.67460296e-02f, -5.58253899e-02f, -4.61378172e-02f, 2.11998448e-02f,
  -8.01275074e-02f, 1.14757910e-01f, -2.74452548e-02f, -4.33313213e-02f, 1.39324199e-02f, -2.36070734e-02f, 1.36577254e-02f, 1.74784362e-02f, 5.62310927e-02f, 2.58859489e-02f,
  -7.18546435e-02f, 4.13076058e-02f, 2.65600439e-02f, -7.44608138e-03f, 7.80474693e-02f, 1.92862209e-02f, -2.90385783e-02f, -2.93722600e-02f, 2.37459727e-02f, -3.19651775e-02f,
  -5.58022363e-03f, 1.04088701e-01f, -5.40410914e-02f, 1.95988603e-02f, -5.03641367e-02f, -7.29016028e-03f, 4.98742945e-02f, -4.86062951e-02f, -7.61608453e-03f, 5.59037961e-02f,
  6.07460439e-02f, 1.21682763e-01f, 6.49429858e-02f, -5.72574511e-02f, 9.46589038e-02f, 2.25157794e-02f, -1.23395724e-02f, -3.74082327e-02f, 1.46061301e-01f, -3.34684588e-02f,
  6.86751306e-02f, 1.46123292e-02f, 1.08256690e-01f, 3.13522257e-02f, 4.88408022e-02f, -2.32680235e-02f, 9.35531780e-02f, -4.79939133e-02f, 9.17033181e-02f, -1.14728980e-01f,
  -4.02873829e-02f, -2.69188378e-02f, 1.79964826e-02f, -7.22278282e-02f, -5.44534363e-02f, 1.26486961e-02f, 7.66613036e-02f, -5.11809215e-02f, 1.21474247e-02f, 1.24007473e-02f,
  -1.22208931e-01f, 6.03490584e-02f, -3.71646583e-02f, -6.95878565e-02f, -1.13954730e-01f, -1.85950831e-01f, -1.73461214e-01f, 1.18418112e-02f, 4.98384126e-02f, 1.03749767e-01f,
  -4.12594434e-03f, 4.52188365e-02f, 3.92860696e-02f, -8.08489509e-03f, -1.39080375e-01f, 1.31054252e-01f, -2.05020979e-01f, -9.34834927e-02f, -5.37913479e-02f, -1.21553652e-01f,
  -1.07500836e-01f, 4.34521027e-02f, 1.53769413e-02f, 1.52802300e-02f, -1.09485887e-01f, -8.15236121e-02f, 5.82745448e-02f, -5.63788041e-02f, -9.04248282e-02f, 3.17399576e-02f,
  -3.51537131e-02f, 8.15411434e-02f, -6.54110461e-02f, 7.90894628e-02f, -1.35359228e-01f, 7.71760661e-03f, -2.38135960e-02f, -4.38049510e-02f, -5.92396446e-02f, -5.53557239e-02f,
  -1.53487278e-02f, 5.37356399e-02f, 4.01011705e-02f, 6.36052787e-02f, 3.42040285e-02f, 1.14666611e-01f, -8.58394243e-03f, -5.90332672e-02f, -5.26597798e-02f, -4.36777174e-02f,
  9.30575002e-03f, 2.29534563e-02f, 6.23050593e-02f, -2.86043938e-02f, 1.00418096e-02f, 2.13644598e-02f, -1.87336057e-02f, 2.55139638e-02f, 3.79900858e-02f, -3.38800251e-02f,
  -7.80327842e-02f, 6.15440719e-02f, 2.83086859e-02f, 1.14868499e-01f, -2.74060834e-02f, -6.23454116e-02f, 3.65073942e-02f, 9.59145129e-02f, 2.18224768e-02f, -4.87979725e-02f,
  2.33562607e-02f, 1.03196904e-01f, -8.59194770e-02f, -3.21433954e-02f, -3.63287553e-02f, 4.32430357e-02f, -9.44496691e-02f, 5.53667620e-02f, -1.21305011e-01f, -1.28044244e-02f,
  7.36604333e-02f, 5.49152233e-02f, 1.13431122e-02f, -7.11648390e-02f, -4.05064821e-02f, 8.49422812e-02f, 8.32329467e-02f, -3.67900878e-02f, 8.62983912e-02f, -3.84353176e-02f,
  -1.47695780e-01f, 2.15975586e-02f, 3.02662030e-02f, 4.06080447e-02f, -3.14642414e-02f, -4.00666632e-02f, -2.84080207e-02f, -4.01292415e-03f, -6.32940754e-02f, -6.90972656e-02f,
  -6.57752231e-02f, 2.95740482e-03f, -9.18215048e-03f, -9.01694819e-02f, -3.85153815e-02f, -9.32858437e-02f, 5.48102334e-02f, -3.07324640e-02f, -7.73880556e-02f, 1.19342431e-02f,
  -3.04985605e-02f, 2.03337539e-02f, -7.27295801e-02f, 7.83916935e-03f, -6.41686842e-02f, -3.80201340e-02f, 5.74974269e-02f, -2.98045352e-02f, -2.38540247e-02f, -5.80274016e-02f,
  6.02738140e-03f, 7.52711296e-02f, 1.86539605e-01f, 5.02695665e-02f, 7.83188194e-02f, 1.87246516e-01f, 1.12016708e-01f, 2.64083743e-02f, 1.31340414e-01f, -7.94450268e-02f,
  -6.47081435e-02f, 1.47970524e-02f, 1.64968465e-02f, 8.04286543e-03f, 1.54833362e-01f, -3.70042957e-02f, 7.95818120e-03f, 3.30932178e-02f, 1.66219145e-01f, -4.25682180e-02f,
  -5.89209050e-02f, -2.68822908e-02f, 4.05249596e-02f, -1.43959463e-01f, -4.13485318e-02f, -1.44572258e-01f, -1.33039743e-01f, 6.64003864e-02f, -9.17880237e-02f, 1.11742625e-02f,
  -4.82504927e-02f, 1.58017855e-02f, -6.46863654e-02f, -7.10532740e-02f, -2.92866770e-02f, -1.62255801e-02f, 8.27716589e-02f, 2.34257933e-02f, 2.37547066e-02f, 3.73445414e-02f,
  -7.31757805e-02f, -8.93565938e-02f, 6.67616278e-02f, 6.48546293e-02f, 7.54909590e-02f, -5.30269891e-02f, 5.52337207e-02f, 9.56165940e-02f, 8.33668411e-02f, -4.64033075e-02f,
  8.01451281e-02f, 9.77874547e-02f, -7.87939206e-02f, -5.64439967e-03f, 5.22002170e-04f, -3.73018570e-02f, -4.51031476e-02f, -4.83116247e-02f, -2.05673068e-03f, -4.09720652e-03f,
  8.49518329e-02f, -4.46011648e-02f, -1.26148006e-02f, 3.21919210e-02f, -3.30020003e-02f, -1.03780657e-01f, 5.94638148e-03f, -4.16587776e-04f, 1.48097072e-02f, 3.10725905e-02f,
  2.45422721e-02f, 6.93703890e-02f, 4.26982641e-02f, -1.51946526e-02f, -7.43942708e-02f, -4.41890992e-02f, -2.01242398e-02f, 5.00694439e-02f, 1.01007232e-02f, 2.63706353e-02f,
  -1.34815346e-03f, -7.26535767e-02f, 4.45263349e-02f, 2.36520171e-02f, -3.30354683e-02f, 9.09491628e-02f, -3.30742076e-02f, 1.67841520e-02f, 6.30181432e-02f, -2.45852466e-03f,
  2.75529269e-02f, -7.33699873e-02f, -7.34307989e-02f, -7.83733875e-02f, 5.93167692e-02f, 7.65882954e-02f, 5.65113276e-02f, -4.41864133e-02f, 5.69100790e-02f, -2.76356880e-02f,
  7.73640126e-02f, -5.24130538e-02f, -4.49241586e-02f, 1.99633501e-02f, -1.55440159e-02f, 9.69532207e-02f, -7.73152113e-02f, -1.11442637e-02f, -7.68579766e-02f, -2.26978865e-02f,
  4.21991795e-02f, -4.18885797e-02f, -8.17012042e-02f, 4.17624554e-03f, -1.14306822e-01f, 1.51519440e-02f, 5.93192279e-02f, -6.21080436e-02f, 7.31767491e-02f, -6.01339601e-02f,
  -9.03103277e-02f, -1.31998099e-02f, 6.65129945e-02f, 1.01677075e-01f, -2.29955047e-01f, -3.10277879e-01f, -2.55263150e-01f, -2.86508147e-02f, 8.39177445e-02f, 8.11190084e-02f,
  -1.37523445e-03f, 1.17584430e-01f, 1.44313574e-01f, 6.53124321e-03f, 1.34148924e-02f, 1.77227348e-01f, -1.17530897e-01f, -1.12009302e-01f, -8.00096095e-02f, -3.43809687e-02f,
  -5.98799530e-03f, -4.88016047e-02f, 9.67667475e-02f, -2.97404733e-02f, -9.16172639e-02f, -1.69140415e-03f, 8.88172090e-02f, -8.23331103e-02f, 6.72152191e-02f, -4.75783609e-02f,
  -8.47706050e-02f, 1.66979820e-01f, 5.72005324e-02f, -1.41034853e-02f, -4.28363122e-02f, -6.17870241e-02f, 4.42606956e-02f, 1.59992073e-02f, -7.05496073e-02f, 3.59718315e-02f,
  5.85668758e-02f, 6.65408745e-02f, -7.59181157e-02f, 1.88314321e-03f, -9.80593339e-02f, 2.82246750e-02f, -1.02581225e-01f, 3.15219723e-02f, -2.39000265e-02f, -2.45385873e-03f,
  -4.17220406e-02f, 1.41049484e-02f, -8.18160698e-02f, 1.09298322e-02f, -6.29382208e-02f, -5.92435375e-02f, 4.50062491e-02f, 1.12800638e-03f, 1.10724218e-01f, 6.03547990e-02f,
  9.06786136e-03f, 5.02957730e-03f, 5.29098399e-02f, -5.44901565e-03f, 2.18468625e-02f, 8.40706844e-03f, 9.83231664e-02f, 8.26682150e-02f, -8.14195201e-02f, 2.61368342e-02f,
  -1.19553730e-02f, 2.58046854e-02f, 1.41185243e-02f, 4.24919650e-02f, -6.75146729e-02f, -8.59310944e-03f, -6.00801781e-02f, 8.78418535e-02f, -6.21048212e-02f, -3.14940363e-02f,
  1.74041663e-03f, -1.13839969e-01f, 8.76724049e-02f, 5.90514466e-02f, -4.00320776e-02f, -1.48760891e-02f, -7.91778974e-03f, -2.49055475e-02f, 8.57301429e-02f, -1.79702044e-02f,
  -2.88343877e-02f, 1.80820495e-01f, 1.01241291e-01f, -2.74287350e-02f, -3.28112952e-02f, -4.59040180e-02f, 2.57956889e-02f, 2.80663539e-02f, 6.95885569e-02f, -7.88592827e-03f,
  4.01723012e-02f, -4.85600643e-02f, -2.69314717e-03f, 4.82610390e-02f, 6.58642352e-02f, -2.28599515e-02f, -3.53469737e-02f, 6.15829565e-02f, 8.27692971e-02f, 2.19374131e-02f,
  4.63808253e-02f, -5.21372147e-02f, -4.89478260e-02f, -4.00973158e-03f, 9.66283605e-02f, -2.15650746e-03f, 4.19433750e-02f, 3.29152830e-02f, -4.43990575e-03f, -4.93952893e-02f,
  6.09525107e-02f, 1.83551945e-02f, -3.72977033e-02f, 7.15163425e-02f, -2.38609756e-03f, -1.00289404e-01f, 4.58586216e-02f, -8.97095203e-02f, -1.18290402e-01f, 5.31167835e-02f,
  2.89259125e-02f, 1.79489031e-02f, 6.58292621e-02f, 4.63549495e-02f, -4.05445099e-02f, 5.56386560e-02f, 9.92018059e-02f, 2.77853366e-02f, 7.32800588e-02f, 4.72697727e-02f,
  6.74858615e-02f, 1.46326972e-02f, 8.76803100e-02f, -6.98011229e-03f, 6.22348525e-02f, -2.25083716e-02f, 1.34547241e-02f, -4.14306596e-02f, -7.26865558e-03f, 6.93339929e-02f,
  6.08829632e-02f, 8.09130669e-02f, 1.13677233e-02f, 5.00755012e-02f, -6.06473126e-02f, 9.58934948e-02f, 2.01025233e-02f, 8.72078091e-02f, -5.64948767e-02f, 6.60283165e-03f,
  7.64723029e-03f, 4.75665107e-02f, 3.51746604e-02f, 6.14760704e-02f, -7.51418248e-02f, -4.41683047e-02f, 7.47141019e-02f, 6.67685494e-02f, -2.22513303e-02f, 1.87698323e-02f,
  8.20955709e-02f, -3.06397863e-02f, -6.52603656e-02f, -3.90994959e-02f, -7.48913661e-02f, -3.87134217e-02f, 3.89204100e-02f, -4.65478301e-02f, -1.34215485e-02f, 4.18435112e-02f,
  6.94167614e-02f, 8.80144984e-02f, 7.58272782e-02f, 4.96442765e-02f, 5.24947569e-02f, -6.97130114e-02f, 3.42416875e-02f, 3.14934179e-02f, -6.91081956e-02f, -3.01534366e-02f,
  -6.55666888e-02f, 6.74724281e-02f, -7.52797872e-02f, 6.63959011e-02f, -6.64755926e-02f, 8.64279550e-03f, -2.42468845e-02f, 7.76516274e-03f, -2.65093568e-05f, -3.76512036e-02f,
  2.60230210e-02f, -8.26032013e-02f, -2.31270678e-02f, 5.01575368e-03f, -1.04004517e-02f, -6.08293861e-02f, 7.86149278e-02f, -2.22832821e-02f, -6.46272525e-02f, 7.09340647e-02f,
  7.58835673e-02f, 5.27163446e-02f, 9.83287096e-02f, -9.14962590e-03f, 3.25220823e-02f, 4.38750051e-02f, -3.69094722e-02f, 2.15640571e-02f, -2.40240898e-02f, 5.86885512e-02f,
  -6.92573981e-03f, -5.99359069e-03f, -3.70588228e-02f, 1.44130513e-02f, -3.68143655e-02f, -7.19234645e-02f, 5.63011505e-02f, -1.22406315e-02f, -4.75181639e-02f, -5.13328016e-02f,
  7.45364130e-02f, -6.98057935e-02f, -1.37859602e-02f, -3.15913111e-02f, -2.85490789e-02f, -7.07461685e-02f, 5.30957915e-02f, -2.63406895e-02f, 3.30700818e-03f, 5.14755324e-02f,
  2.84399055e-02f, -1.14662936e-02f, 2.07890958e-01f, -9.55030099e-02f, 2.27468275e-02f, 3.82557996e-02f, 3.22619639e-02f, -4.24374789e-02f, 1.54170888e-02f, -7.20316768e-02f,
  -5.23729995e-02f, 1.99956983e-01f, 1.27423540e-01f, 6.63646683e-02f, -9.98651087e-02f, -6.93286136e-02f, -8.05507153e-02f, 9.63317323e-03f, -1.19467909e-02f, -7.31847063e-02f,
  1.79763846e-02f, -9.97748896e-02f, 2.94287428e-02f, -1.23608366e-01f, 3.74017730e-02f, -5.49121611e-02f, -1.15920633e-01f, 8.43063146e-02f, -7.54643232e-02f, 1.03809023e-02f,
  3.48176397e-02f, 4.89285849e-02f, 7.53449369e-03f, 1.10686034e-01f, -4.01142202e-02f, -7.61642754e-02f, 1.06473580e-01f, 1.14053473e-01f, -2.74971575e-02f, 8.39477032e-02f,
  8.78624097e-02f, 5.86209632e-02f, 5.76590514e-03f, 8.09248537e-02f, 6.87083974e-02f, 2.21747346e-02f, 3.86521742e-02f, 3.13509665e-02f, 1.19861305e-01f, 1.30211487e-01f,
  -2.99727488e-02f, -6.77349120e-02f, 5.20071480e-03f, 1.49586815e-02f, -6.69942936e-03f, 3.99960689e-02f, 7.44836703e-02f, -3.96281341e-03f, 9.15901437e-02f, 3.86186354e-02f,
  -7.80296102e-02f, -1.10569522e-01f, 4.44009565e-02f, -7.17532337e-02f, 5.84183931e-02f, 2.25075781e-02f, -2.00351290e-02f, -8.95093679e-02f, 6.63476139e-02f, 6.29953155e-03f,
  5.31936698e-02f, 4.79031950e-02f, -5.86960316e-02f, -1.06335297e-01f, 5.39784171e-02f, 7.16957971e-02f, -8.12916383e-02f, -1.01484329e-01f, 5.19742519e-02f, -9.23687592e-02f,
  7.35443607e-02f, -6.71505183e-02f, -6.57891482e-02f, 4.87719866e-04f, 4.66454551e-02f, 4.59880419e-02f, 9.02431086e-02f, -5.49687967e-02f, -2.59201862e-02f, -2.34094243e-02f,
  -2.88053919e-02f, -7.79654756e-02f, 4.21721525e-02f, -5.63124791e-02f, -2.35137832e-03f, -8.22850019e-02f, -1.36545841e-02f, -4.00063694e-02f, 7.00825900e-02f, 6.60106465e-02f,
  -7.61087378e-03f, 7.34559149e-02f, 9.13296733e-03f, -1.04156926e-01f, -1.10823281e-01f, -6.24655560e-02f, 3.15795951e-02f, -3.03313024e-02f, -4.90486212e-02f, 4.18036357e-02f,
  -8.02460015e-02f, 9.42983776e-02f, -5.08540869e-02f, 4.62634601e-02f, -8.20839331e-02f, -1.02047779e-01f, -3.97572406e-02f, 7.35113770e-02f, -8.61911848e-03f, -7.55624175e-02f,
  8.76673535e-02f, -8.78688619e-02f, 1.02884695e-02f, -5.43023683e-02f, 6.81952387e-02f, 4.62838337e-02f, -3.33970822e-02f, 4.78450954e-02f, -1.23229496e-01f, -4.25947309e-02f,
  -4.42056917e-02f, 6.98012561e-02f, -1.00020086e-02f, -1.06278688e-01f, 7.45650530e-02f, -2.86952592e-02f, -6.25762194e-02f, 8.01608264e-02f, -7.26829544e-02f, 4.20695916e-02f,
  -3.45102325e-02f, -1.08410612e-01f, -1.04591504e-01f, -4.17783968e-02f, -5.88322729e-02f, -1.65202376e-02f, 8.25050846e-02f, -1.47949979e-02f, -2.15923358e-02f, 4.20661047e-02f,
  3.93345580e-02f, -3.67271490e-02f, 8.59574899e-02f, -7.09671387e-03f, 2.82566063e-02f, 4.68726493e-02f, -6.13816455e-02f, -2.91635599e-02f, -7.65088946e-02f, 7.98007995e-02f,
  1.19309891e-02f, -6.70591975e-03f, -9.42783989e-03f, -7.48044774e-02f, -3.87378708e-02f, -6.27134368e-02f, 7.56341871e-03f, -7.28556961e-02f, 5.97668365e-02f, 8.67511332e-03f,
  -8.82778987e-02f, -6.49727881e-02f, 3.16376872e-02f, 4.77054762e-03f, -8.43806192e-02f, 5.19806370e-02f, 7.21985996e-02f, 2.49897353e-02f, -9.13860425e-02f, -7.63689876e-02f,
  -8.95836875e-02f, 7.48375207e-02f, -1.53076919e-02f, 7.41566792e-02f, 3.46276797e-02f, -7.92604312e-02f, 3.16455290e-02f, -2.66730152e-02f, 4.74145748e-02f, 3.67448339e-03f,
  -2.20854450e-02f, -9.15488899e-02f, 2.13312730e-02f, 7.02782795e-02f, 7.72638172e-02f, 6.71830354e-03f, 1.49606615e-02f, 1.23125091e-02f, 4.12766747e-02f, 7.43657798e-02f,
  1.12921577e-02f, 1.76722743e-02f, 8.54210407e-02f, -7.93764591e-02f, -8.21003243e-02f, -2.87825000e-02f, 4.03325669e-02f, -8.14530626e-02f, 7.66473562e-02f, 4.62162346e-02f,
  1.51677281e-01f, -1.01468258e-03f, 9.09132212e-02f, 4.55311537e-02f, -4.32932423e-03f, -8.57862905e-02f, 2.70879809e-02f, 2.31558480e-03f, -2.29323432e-02f, 8.72914940e-02f,
  -3.36762816e-02f, -8.55929181e-02f, 2.80375057e-03f, 7.15825036e-02f, -4.83103581e-02f, -4.58951518e-02f, -4.20129951e-03f, 5.97843202e-03f, 8.53270665e-02f, 2.74302140e-02f,
  2.44030654e-02f, -8.97153001e-03f, 1.71732996e-02f, 6.51835203e-02f, -4.19699326e-02f, 1.38836130e-02f, -3.15250605e-02f, 1.73000768e-02f, -6.71121404e-02f, 1.35519607e-02f,
  8.06112960e-02f, 1.04167670e-01f, 1.92467228e-01f, 6.08127937e-02f, -7.10266382e-02f, -7.01118261e-02f, -1.07165679e-01f, 7.70574585e-02f, 9.15801674e-02f, 3.10416315e-02f,
  -6.49210438e-02f, 1.95247740e-01f, 2.06444450e-02f, -1.80356726e-02f, -2.47192811e-02f, -1.06721371e-01f, 4.44285572e-02f, -3.87933515e-02f, -1.73044018e-02f, 9.21938792e-02f,
  -5.64619936e-02f, -1.86156318e-01f, 7.03700259e-02f, 3.31748091e-02f, 1.42076433e-01f, -1.31664556e-02f, -1.63346455e-01f, -1.07990354e-01f, 3.83780561e-02f, 3.91963236e-02f,
  7.10564777e-02f, 8.23641289e-03f, -4.23693890e-03f, 9.56882387e-02f, -4.18383256e-02f, -2.05702372e-02f, -6.45428598e-02f, 6.69445843e-02f, 2.87370551e-02f, 1.05250683e-02f,
  -4.02766168e-02f, 3.76583599e-02f, 8.72287080e-02f, 5.07207699e-02f, 6.81125820e-02f, 5.66850603e-02f, 3.29344906e-02f, -2.62966566e-02f, 5.67578431e-03f, 9.75967720e-02f,
  3.64086516e-02f, -1.65778138e-02f, 9.16736107e-03f, 4.85115610e-02f, -5.84767088e-02f, -4.29568775e-02f, -3.22482884e-02f, 4.84244861e-02f, 4.46179323e-02f, 6.42033666e-02f,
  -1.07196443e-01f, -8.04358423e-02f, 5.05667217e-02f, 2.69419746e-03f, 1.95394270e-03f, 4.60385643e-02f, 1.31992437e-02f, -1.12342343e-01f, 8.99358392e-02f, -7.31102750e-02f,
  9.04905945e-02f, -1.08654452e-02f, -4.90706339e-02f, 8.72371569e-02f, 5.07645458e-02f, -3.64679582e-02f, 7.39733130e-02f, -7.99174830e-02f, 4.92866486e-02f, 2.54509822e-02f,
  -2.94510070e-02f, -8.50116834e-02f, 7.63370022e-02f, 1.00147560e-01f, 9.74225719e-03f, -1.37284752e-02f, 7.33868079e-03f, 2.90855882e-03f, -9.21184644e-02f, -2.16929112e-02f,
  -8.75634328e-02f, -3.32492180e-02f, -1.85951050e-02f, -1.65405758e-02f, -1.49861099e-02f, 6.53571449e-03f, -1.79573819e-02f, -9.37289838e-03f, -3.05830948e-02f, 2.50751376e-02f,
  1.08671067e-02f, -2.48204935e-02f, 3.51373926e-02f, -6.33766949e-02f, 6.09528320e-03f, -2.39952002e-02f, 1.98842064e-02f, -1.07844941e-01f, 1.30192973e-02f, -5.18823490e-02f,
  8.13987106e-02f, -2.76130512e-02f, 4.39856648e-02f, 2.67984811e-02f, -2.00470779e-02f, 6.13478683e-02f, 5.98221533e-02f, 5.81867769e-02f, -8.64154249e-02f, -6.39859289e-02f,
  -1.39608130e-01f, 9.54275429e-02f, -6.59039319e-02f, -2.05278441e-01f, 5.77127747e-02f, -6.06762134e-02f, -1.27221748e-01f, 2.22901404e-02f, -9.43312049e-03f, 9.66388434e-02f,
  1.38080820e-01f, -3.13521363e-02f, 1.05263062e-01f, -1.62554622e-01f, -2.75450677e-01f, -1.74659207e-01f, -7.98175409e-02f, -6.63202703e-02f, -1.08853929e-01f, 6.57349601e-02f,
  -9.76009294e-02f, -5.26309460e-02f, -1.00016266e-01f, 1.46736518e-01f, -3.40339914e-02f, 1.27694055e-01f, -6.08392768e-02f, 7.02278689e-02f, 1.62728596e-02f, 3.46604064e-02f,
  -7.22123682e-02f, 2.69148163e-02f, 1.74878985e-02f, 5.31157367e-02f, -2.29043346e-02f, 7.39947408e-02f, -7.36863688e-02f, -1.81537401e-02f, 4.40979423e-03f, -1.77691467e-02f,
  -5.40959835e-02f, 1.03342801e-01f, -3.89840789e-02f, 7.94515535e-02f, 1.01012513e-01f, -3.48147154e-02f, 3.10048554e-02f, -2.57958448e-03f, 3.19901993e-03f, 7.95629248e-03f,
  3.57366018e-02f, -1.28250746e-02f, 3.37786190e-02f, -7.31679350e-02f, -9.18272734e-02f, 7.61953220e-02f, -6.39950708e-02f, -5.65189756e-02f, 7.85847008e-02f, -8.50792229e-02f,
  6.35920390e-02f, -9.02264006e-03f, -9.22398642e-04f, 1.09742597e-01f, -2.90272664e-02f, 6.35963306e-02f, -6.13838658e-02f, -9.65488181e-02f, -8.48626047e-02f, 2.62363944e-02f,
  -1.30827948e-02f, -3.86080779e-02f, 5.84831350e-02f, -4.11920547e-02f, -3.17366607e-02f, -4.34046574e-02f, -2.93432921e-02f, -6.28572255e-02f, 4.50114608e-02f, -5.32450862e-02f,
  5.24323545e-02f, -2.22543683e-02f, 4.48237248e-02f, 5.11829294e-02f, -4.87276986e-02f, 8.75346586e-02f, -4.53881882e-02f, -1.11070545e-02f, -1.07413605e-01f, -3.07297371e-02f,
  -6.17508106e-02f, 1.10965945e-01f, 4.48839366e-02f, -4.03973795e-02f, 1.04992621e-01f, -6.77273348e-02f, 4.52263467e-02f, 3.77477054e-03f, -6.71719387e-02f, 1.27265695e-02f,
  -7.36761000e-03f, -5.13433181e-02f, -2.23120451e-02f, 2.72394028e-02f, 9.97277442e-03f, -9.89152193e-02f, 1.90320723e-02f, -3.88373546e-02f, 5.87883294e-02f, -2.36825775e-02f,
  6.57976642e-02f, 7.77259991e-02f, 4.56558308e-03f, -1.70315411e-02f, 2.09866138e-03f, -7.75615405e-03f, -6.85460865e-02f, -3.82519178e-02f, -5.80476150e-02f, 1.19893299e-02f,
  -5.17228186e-01f, 3.57902408e-01f, 2.55111847e-02f, -2.22979635e-01f, 7.59691279e-03f, -5.98845705e-02f, 4.49833572e-02f, -1.42033608e-03f, -1.16811441e-02f, 1.31463856e-01f,
  -4.01238017e-02f, -1.55079454e-01f, 1.53575197e-01f, 1.80517763e-01f, -1.19734146e-01f, 1.98812544e-01f, 1.04269283e-02f, 3.72747257e-02f, 1.45912603e-01f, -8.47921893e-02f,
  -4.79660928e-02f, -1.79178324e-02f, 1.24423862e-01f, 2.07108006e-01f, -5.50807565e-02f, -1.06046975e-01f, -1.40378609e-01f, 8.28318074e-02f, -2.63284752e-03f, -5.29809250e-03f,
  -1.80623457e-01f, -2.30221495e-01f, -2.26137489e-01f, -1.52082890e-01f, -1.34477854e-01f, -7.52567947e-02f, -7.24671111e-02f, -9.48138908e-02f, -1.68768689e-02f, 5.91271818e-02f,
  -2.30679121e-02f, -5.70246577e-02f, -5.50620258e-02f, -1.74574703e-02f, -1.14853634e-02f, -1.29431644e-02f, -1.40119353e-02f, 5.19422032e-02f, 1.30102821e-02f, 2.66955104e-02f,
  2.13327277e-02f, 4.79127541e-02f, -2.24860553e-02f, 5.53343864e-03f, -7.28904456e-02f, 1.15953479e-02f, -5.55696823e-02f, 3.06215417e-02f, -5.97964078e-02f, 1.48779713e-02f,
  -1.68435443e-02f, -1.86051447e-02f, -7.70173408e-03f, 1.62501428e-02f, 1.94423273e-02f, 1.57583188e-02f, -3.11070252e-02f, -6.06095456e-02f, -3.91449034e-02f, 1.58107169e-02f,
  -8.71834010e-02f, -4.24235128e-02f, -1.92504935e-02f, -5.35495020e-02f, -2.29702145e-02f, -2.55453251e-02f, 4.56589833e-02f, -6.09279014e-02f, 6.02718815e-02f, -2.21483735e-03f,
  -2.12036502e-02f, -1.11681931e-02f, -2.74883211e-02f, -4.17786539e-02f, -7.43611855e-03f, 6.79470822e-02f, 5.53762019e-02f, -2.77792607e-02f, -6.05109334e-02f, 1.51585496e-03f,
  -1.91888765e-01f, -2.29690567e-01f, -7.10662305e-02f, -1.12594210e-01f, 8.69981758e-03f, -4.31796676e-03f, -3.44557017e-02f, 2.05201060e-02f, 1.71428751e-02f, -3.90719101e-02f,
  -7.96153918e-02f, 2.13356670e-02f, -2.28414666e-02f, 3.91755626e-02f, -1.87378004e-02f, 1.59007814e-02f, -2.13337876e-03f, -5.30810095e-02f, -7.90242851e-02f, 2.60866452e-02f,
  -4.02379259e-02f, -5.70323244e-02f, -2.57774983e-02f, -6.44222796e-02f, -3.60556017e-03f, -8.88700634e-02f, 6.57020509e-02f, -5.56723103e-02f, -2.32870746e-02f, 2.40043644e-02f,
  1.85862347e-01f, 1.53691471e-01f, 1.39708206e-01f, 1.67834014e-01f, -3.58119980e-02f, -1.65523887e-01f, -8.71941000e-02f, -3.35455425e-02f, -1.46164820e-01f, 3.88637520e-02f,
  1.58260111e-02f, 1.63229868e-01f, -1.89081386e-01f, 5.81206940e-02f, -4.57598343e-02f, -1.62871405e-01f, 6.56631291e-02f, -3.82785723e-02f, -1.71028320e-02f, 4.16617878e-02f,
  4.08035144e-02f, -2.84996871e-02f, 1.79167226e-01f, 7.42809996e-02f, 1.42768160e-01f, 2.38540933e-01f, 1.49450257e-01f, 3.08458433e-02f, 2.42251247e-01f, 8.85315053e-03f,
  1.03976158e-02f, -4.50615734e-02f, 1.37846768e-02f, 6.34570718e-02f, 2.50840429e-02f, 1.07908184e-02f, 2.86139231e-02f, -5.61797842e-02f, -2.48289183e-02f, 1.31256999e-02f,
  -4.71806936e-02f, 8.64494368e-02f, -2.21821740e-02f, -8.97719618e-03f, 6.38164356e-02f, 3.15795578e-02f, 3.84465195e-02f, 8.73078480e-02f, 1.16784669e-01f, 3.30814123e-02f,
  -1.99324475e-03f, 8.38431902e-03f, -1.99814644e-02f, -3.99871171e-02f, -2.80543342e-02f, -2.03666314e-02f, 5.83152846e-02f, -1.27315591e-03f, 5.85299507e-02f, 3.40340771e-02f,
  2.99269110e-02f, -1.42291356e-02f, 7.06869587e-02f, 3.32091823e-02f, 3.37943770e-02f, -2.12491862e-02f, 8.82435939e-04f, -6.38679340e-02f, -1.34630995e-02f, -5.36789745e-03f,
  9.51105356e-02f, 1.14575133e-01f, 1.73554868e-02f, -5.77504151e-02f, -5.67422472e-02f, -2.68649950e-04f, 1.33983428e-02f, -3.17831337e-02f, 7.34550953e-02f, 3.24713794e-04f,
  -1.90911256e-02f, -1.53327016e-02f, 1.56056015e-02f, -4.42266045e-03f, 1.61243826e-02f, 8.32848474e-02f, 9.57348105e-03f, -2.71701836e-03f, 3.06274612e-02f, -7.57859051e-02f,
  -7.75590912e-02f, 7.45063275e-02f, -5.61480485e-02f, -1.55601846e-02f, -5.13044000e-02f, 3.34624127e-02f, 6.24556430e-02f, 2.66087689e-02f, -9.42912139e-03f, -3.40791009e-02f,
  -2.10508355e-03f, 6.16152771e-02f, -2.52774432e-02f, 5.94436117e-02f, -5.03501482e-03f, -1.92262474e-02f, 2.22750884e-02f, -2.73387935e-02f, 1.65951792e-02f, 1.09097891e-01f,
  1.88540313e-02f, -3.21728066e-02f, -2.84196362e-02f, -8.05779174e-02f, -6.92873402e-03f, 1.00478446e-02f, 5.71619011e-02f, 4.38837409e-02f, -5.80426678e-02f, 3.99470367e-02f,
  -7.71174580e-02f, -6.15505800e-02f, -3.87727469e-02f, -1.13058180e-01f, 1.08210750e-01f, -1.30801260e-01f, -9.89420190e-02f, 5.36299916e-03f, -9.09701362e-02f, 4.95930910e-02f,
  2.74468176e-02f, -5.59715629e-02f, -1.12999387e-01f, -1.57373220e-01f, -1.42313659e-01f, -2.13233963e-01f, -1.19044118e-01f, -8.59097987e-02f, -1.51837781e-01f, 7.96434805e-02f,
  -4.63662297e-02f, 2.11859029e-02f, 1.18875392e-02f, 1.92783251e-01f, 1.23233020e-01f, 1.24863498e-01f, 2.61125177e-01f, 1.22216545e-01f, 1.45171583e-01f, 7.78364167e-02f,
  -6.15173602e-04f, -7.35656470e-02f, -1.39409229e-02f, 2.65691988e-03f, 6.21452630e-02f, 7.57768080e-02f, 2.78287809e-02f, 2.58525591e-02f, 5.73014915e-02f, -8.52779206e-03f,
  5.76438531e-02f, 7.32802004e-02f, -1.42226303e-02f, -7.83543885e-02f, 2.12343279e-02f, -6.53816760e-02f, 3.06322891e-03f, 3.12877633e-02f, -5.53743988e-02f, -6.41177520e-02f,
  -8.48389417e-02f, -3.34641039e-02f, 2.36821938e-02f, 8.91557261e-02f, -7.12026358e-02f, -2.43739188e-02f, -8.86961296e-02f, 5.58846220e-02f, 7.23449106e-04f, 4.14647497e-02f,
  6.46810159e-02f, 2.38436852e-02f, -2.62345783e-02f, -5.59399053e-02f, -8.55258554e-02f, 3.62048298e-02f, -9.74546969e-02f, -1.20370777e-03f, -5.26849777e-02f, -1.44157019e-02f,
  4.43408005e-02f, 4.42187004e-02f, -3.49063501e-02f, -4.45230715e-02f, 4.97446246e-02f, 6.96803629e-02f, 4.17918637e-02f, -8.01522434e-02f, -3.75937559e-02f, 1.26526868e-02f,
  2.75096507e-04f, -4.08683121e-02f, -3.23018171e-02f, 8.67552385e-02f, 1.85241979e-02f, 9.27828439e-03f, 3.07785720e-02f, -1.19850785e-02f, -5.92578836e-02f, 7.08095282e-02f,
  -6.00392558e-03f, 5.83329946e-02f, -5.92557192e-02f, 2.18003597e-02f, -9.05486420e-02f, 4.61388119e-02f, -1.03076808e-01f, 4.42431271e-02f, 2.62973607e-02f, -4.09669690e-02f,
  7.48147294e-02f, 8.99806470e-02f, -3.68933491e-02f, -2.70523503e-02f, 1.69205724e-03f, 9.20228958e-02f, 5.73275350e-02f, 3.15554291e-02f, -5.07437326e-02f, 2.38459986e-02f,
  -4.59188037e-03f, 8.04559663e-02f, -2.97322180e-02f, 7.14588612e-02f, 1.29280224e-01f, 2.94667631e-02f, -4.08502715e-03f, 2.32462492e-02f, -8.91058519e-02f, -2.77977139e-02f,
  1.43264502e-01f, -4.11457926e-01f, 9.14542153e-02f, 1.27285883e-01f, 7.42558613e-02f, 7.66118020e-02f, 1.28051847e-01f, -8.53025690e-02f, -2.52601542e-02f, -1.80467248e-01f,
  -1.06565967e-01f, 8.43940377e-02f, -1.01773336e-03f, -1.23233445e-01f, 3.08751673e-01f, -6.35506138e-02f, 4.17979397e-02f, -1.91622004e-02f, 2.35904008e-02f, 1.60106793e-02f,
  8.31912011e-02f, 5.26033193e-02f, 6.08062521e-02f, -1.12175286e-01f, 3.09317671e-02f, 3.94282378e-02f, -2.92597469e-02f, 1.30148921e-02f, 7.11956620e-02f, 9.18748379e-02f,
  -9.10694972e-02f, -9.80663151e-02f, -3.57890967e-03f, -4.77432646e-02f, -5.66281229e-02f, -5.05566858e-02f, -1.26236887e-03f, 1.31190062e-01f, -3.51433456e-02f, 4.68892343e-02f,
  -4.96049151e-02f, -2.65269075e-02f, 1.68825947e-02f, 3.66308168e-02f, 2.88809109e-02f, -4.54478674e-02f, -2.21530180e-02f, 1.34262070e-02f, -2.06372440e-02f, -1.32764000e-02f,
  -4.33383770e-02f, 2.54947599e-02f, 2.84936070e-03f, -1.02136493e-01f, -7.55114034e-02f, -5.77939581e-03f, 8.56705755e-02f, 6.27986863e-02f, 1.43133402e-02f, -6.77355751e-02f,
  3.01098786e-02f, -2.24919207e-02f, -1.14620263e-02f, -5.49942665e-02f, 2.45067645e-02f, -4.14211154e-02f, -8.09118897e-02f, -2.36987974e-02f, 1.54540045e-02f, -5.03142700e-02f,
  -6.79108799e-02f, 5.62818535e-02f, -2.16155834e-02f, -6.08410984e-02f, -2.00305860e-02f, 1.23883476e-02f, 1.30003679e-03f, 2.06330745e-03f, -1.83352605e-02f, -1.13767041e-02f,
  -3.44466008e-02f, -3.33311148e-02f, -8.34901407e-02f, -2.10432149e-02f, -5.61119355e-02f, 5.21042570e-02f, -6.54674396e-02f, 2.06749253e-02f, 8.41219425e-02f, 9.61665437e-02f,
  -2.53772050e-01f, -2.35365808e-01f, -7.29141161e-02f, -4.03893888e-02f, -1.45685552e-02f, -7.04917014e-02f, 3.92624410e-03f, 4.28165048e-02f, -4.24216986e-02f, -6.08836003e-02f,
  -3.48650776e-02f, 3.46057713e-02f, -8.39436427e-02f, 7.22128749e-02f, -8.76054633e-03f, -7.08985999e-02f, 2.71923803e-02f, -4.44870591e-02f, 7.10922154e-03f, -9.46620256e-02f,
  -7.17025101e-02f, -5.12142777e-02f, 1.67601854e-02f, 2.93273721e-02f, 4.90106232e-02f, -4.71617468e-02f, -8.24089572e-02f, -6.22972250e-02f, -2.58879550e-02f, 5.63065670e-02f,
  -1.59942761e-01f, 2.54576169e-02f, -3.35799791e-02f, -1.38209090e-01f, 1.11009181e-01f, 1.04008198e-01f, -3.14315371e-02f, 3.89412604e-02f, 5.14974669e-02f, 1.58542488e-02f,
  -4.34002420e-03f, -7.45197013e-02f, -1.16515532e-02f, -1.23771071e-01f, -1.32416442e-01f, 2.18084529e-02f, -5.92741510e-03f, -8.03722367e-02f, -3.03250924e-02f, -9.93400160e-03f,
  3.82793993e-02f, 3.06069627e-02f, 9.79946926e-02f, 1.43733352e-01f, 1.01893798e-01f, 2.49079727e-02f, -1.14838175e-01f, -1.23008518e-02f, -1.46104442e-02f, -1.05471499e-02f,
  1.19763603e-02f, 3.27271707e-02f, 2.48598959e-02f, -6.03078417e-02f, 7.22978786e-02f, -5.45741757e-03f, -6.25489876e-02f, -1.16601521e-02f, -3.45076323e-02f, -6.48185760e-02f,
  -8.27960819e-02f, -3.38076577e-02f, -7.00092390e-02f, 4.38810028e-02f, 5.49808443e-02f, -7.16594756e-02f, -4.98938635e-02f, 2.91979313e-02f, 1.03407547e-01f, 4.52653132e-02f,
  -3.77881899e-02f, 1.47215417e-02f, -6.97945654e-02f, -1.05185956e-01f, -4.94540371e-02f, -4.83961627e-02f, 5.75957727e-03f, -8.53729546e-02f, 1.40612954e-02f, -2.51566377e-02f,
  1.14098094e-01f, 6.72429875e-02f, -3.66878584e-02f, -3.74363549e-02f, 3.53161655e-02f, -5.13119735e-02f, 7.92401582e-02f, -2.66269110e-02f, 2.12434735e-02f, 5.16832769e-02f,
  4.71737534e-02f, -9.28739179e-03f, -2.61047371e-02f, -7.55575448e-02f, -2.48542968e-02f, 4.98893671e-02f, -3.66436467e-02f, 3.05568017e-02f, -3.58679378e-03f, -2.48936564e-02f,
  -6.30198121e-02f, 2.58364622e-02f, 8.05703327e-02f, -4.59491313e-02f, -1.32321864e-02f, 4.19905223e-02f, -3.62579860e-02f, 4.22802493e-02f, 8.45020637e-02f, -8.33956152e-02f,
  -5.01458719e-02f, 5.75290844e-02f, -1.50043878e-03f, 5.01655117e-02f, 8.51680264e-02f, 7.02447295e-02f, 6.10718913e-02f, 1.26912340e-03f, -3.81650850e-02f, 1.60936061e-02f,
  3.70837562e-02f, 6.62709679e-03f, 3.96281593e-02f, 2.69433390e-03f, 5.17645329e-02f, -1.15495093e-01f, 1.65909790e-02f, 7.35973865e-02f, -7.68905804e-02f, -8.43716860e-02f,
  -3.24938335e-02f, -1.56319328e-02f, 6.49568141e-02f, 1.33482541e-03f, 6.19008541e-02f, -7.89390355e-02f, -5.60754957e-03f, 6.16004542e-02f, 3.18777040e-02f, -4.38301750e-02f,
  -4.63438444e-02f, 3.11282650e-02f, 8.25583488e-02f, 7.49284700e-02f, -2.07878696e-03f, 6.27508461e-02f, 9.12006348e-02f, 2.34727878e-02f, -1.06564417e-01f, -9.53079537e-02f,
  5.99530078e-02f, 6.25749072e-03f, 6.46482334e-02f, -3.22852470e-02f, 1.44300833e-02f, -4.56554964e-02f, -5.63707724e-02f, -7.84619823e-02f, -6.17697127e-02f, -5.33064753e-02f,
  6.73071519e-02f, -3.50646153e-02f, -7.06037506e-03f, -9.49726999e-02f, -8.71297866e-02f, -7.92141655e-04f, 8.36550444e-02f, 9.18760225e-02f, -7.66611844e-02f, -3.13634127e-02f,
  1.20558754e-01f, -4.42915373e-02f, 9.66111571e-02f, 3.00603583e-02f, 2.89188903e-02f, -7.14277700e-02f, 8.74627382e-02f, -2.51692627e-02f, -3.03324824e-03f, 2.49522850e-02f,
  4.15891781e-02f, -3.69663611e-02f, 4.57578152e-02f, -6.73502758e-02f, 4.42023613e-02f, 7.66089708e-02f, 7.62699023e-02f, 3.48646641e-02f, 8.86536911e-02f, -4.40431163e-02f,
  -2.90988255e-02f, 7.68219829e-02f, 6.54489994e-02f, 4.99112979e-02f, 6.59034103e-02f, -5.77361463e-03f, 6.67983368e-02f, 3.08134817e-02f, -6.82741329e-02f, 5.46284765e-02f,
  -5.61436862e-02f, -4.44665961e-02f, -1.10093303e-01f, -5.49628511e-02f, -7.28076100e-02f, 8.08940157e-02f, -4.41474132e-02f, -4.95207533e-02f, 2.39118189e-02f, 4.44980059e-03f,
  -2.12300979e-02f, -4.36428823e-02f, -8.14975277e-02f, 1.21724838e-02f, -1.27869183e-02f, -2.26773135e-02f, 7.18946159e-02f, 3.43996682e-04f, -3.94077674e-02f, 1.04902573e-02f,
  5.14032282e-02f, -6.21426664e-03f, -3.37343756e-03f, -3.22607867e-02f, -8.41741413e-02f, -5.17515615e-02f, 6.78201988e-02f, 4.94505875e-02f, 2.53795367e-03f, -5.16182743e-02f,
  1.41249716e-01f, 6.81513846e-02f, 4.27158512e-02f, 5.88162951e-02f, -9.72230881e-02f, 8.82378593e-03f, 1.38393249e-02f, -1.37321195e-02f, 3.22993547e-02f, -8.68149847e-03f,
  5.52408919e-02f, -4.39468026e-02f, -2.69959550e-02f, 2.89700702e-02f, 2.02089902e-02f, -2.24897312e-03f, -4.92491871e-02f, -4.24342938e-02f, -2.02635340e-02f, -9.12641883e-02f,
  6.19758144e-02f, 6.82094321e-02f, 1.08124260e-02f, 6.35205582e-02f, 7.37170875e-02f, -9.69590712e-03f, 8.05942416e-02f, 4.05364409e-02f, 7.26905987e-02f, 6.52123913e-02f,
  -1.66018516e-01f, -1.35692477e-01f, 2.62356941e-02f, -1.89663485e-01f, -9.15483311e-02f, -1.30685881e-01f, -1.66824143e-02f, -1.76868662e-01f, -1.21728303e-02f, 7.35811144e-02f,
  4.38276306e-03f, -5.15287519e-02f, 1.39815331e-01f, 2.79250368e-02f, 6.73941746e-02f, 9.71788093e-02f, -1.69076975e-02f, 1.30795464e-01f, 9.45250764e-02f, -1.96322296e-02f,
  -3.80514637e-02f, -1.99638605e-02f, 1.33341119e-01f, 3.06263170e-03f, -3.27237360e-02f, -1.12514801e-01f, 8.44732225e-02f, -6.37014117e-03f, 3.63254757e-03f, -7.55888820e-02f,
  -1.06356598e-01f, -6.22542808e-04f, -1.00946434e-01f, 4.72666062e-02f, -8.91743004e-02f, -2.22971570e-02f, -4.95769307e-02f, -3.34504084e-03f, -2.21868157e-02f, -2.40865847e-04f,
  5.29336045e-03f, -3.81494910e-02f, -6.18751422e-02f, 7.95230642e-02f, 1.62899345e-02f, -2.58005615e-02f, 6.56313524e-02f, 5.25260344e-02f, -6.63917605e-03f, 2.89695654e-02f,
  4.19393042e-03f, -3.76894064e-02f, -7.17250779e-02f, 1.16543680e-01f, 7.91344270e-02f, -6.61202148e-02f, 4.07382622e-02f, 5.93080372e-02f, -1.04232572e-01f, -4.27588001e-02f,
  2.11036485e-03f, -2.40799692e-02f, 3.02572604e-02f, -2.16942336e-02f, -7.43013546e-02f, -4.54892479e-02f, -1.77931134e-02f, 8.60127658e-02f, 3.42507772e-02f, 3.81170474e-02f,
  -2.30096504e-02f, 5.04525332e-03f, -2.48423275e-02f, 4.29030918e-02f, -2.02365089e-02f, -5.05107874e-03f, -5.62331714e-02f, -1.31846610e-02f, 5.78560419e-02f, -1.59782562e-02f,
  -7.79452473e-02f, -9.91033241e-02f, 8.42364877e-02f, 1.48094028e-01f, -7.01717064e-02f, 2.20903456e-02f, -8.09845850e-02f, -3.21862809e-02f, -6.24400117e-02f, -1.41891651e-02f,
  -1.23291127e-01f, -1.76924646e-01f, -6.51883632e-02f, 3.79648246e-02f, -5.15638590e-02f, -4.97025577e-03f, 1.12175364e-02f, -6.11789674e-02f, 2.80766245e-02f, -5.28978854e-02f,
  -3.18119489e-03f, 8.97870213e-02f, 4.39433940e-02f, -6.75303675e-03f, 4.83233556e-02f, -2.79560033e-02f, 1.92482192e-02f, 1.24811521e-02f, -7.74397701e-02f, 5.11751161e-04f,
  1.34691745e-02f, 2.59945579e-02f, 9.78568271e-02f, 2.17371602e-02f, -6.72070384e-02f, 3.15985158e-02f, -8.15164149e-02f, 2.12875288e-02f, 4.96076643e-02f, 1.15651041e-02f,
  -1.51699394e-04f, -1.55305579e-01f, -1.82767957e-01f, -1.40017495e-01f, -3.92704681e-02f, -2.09966093e-01f, -8.04485679e-02f, -4.60440777e-02f, 2.96372897e-03f, 7.06883147e-02f,
  -1.09653790e-02f, -7.36232847e-02f, 2.58257594e-02f, -2.12062225e-01f, 2.77464874e-02f, -1.50985485e-02f, -1.98019370e-01f, -7.37887546e-02f, 5.79230301e-02f, -3.33882533e-02f,
  -1.11003257e-02f, -1.74992010e-01f, -1.35316208e-01f, -5.33146709e-02f, -1.33687407e-01f, -2.13347226e-02f, 1.05282985e-01f, -8.65358561e-02f, -1.20996602e-01f, -1.01591207e-01f,
  -4.93588634e-02f, 1.63280834e-02f, 7.25860223e-02f, 1.14747494e-01f, -1.94878355e-02f, 7.88502488e-03f, 4.40204553e-02f, 4.51141745e-02f, 4.04979698e-02f, 7.93078095e-02f,
  6.28059432e-02f, -1.88486446e-02f, -3.37867178e-02f, -1.89028925e-03f, -2.99272593e-02f, -9.42949727e-02f, 4.67025675e-02f, -3.46149206e-02f, -8.64766538e-02f, -3.17547433e-02f,
  -1.28877312e-01f, -6.14632145e-02f, 2.22179741e-02f, -3.43463174e-03f, -7.92108383e-03f, -1.61951489e-03f, 5.12406379e-02f, 9.79554839e-03f, -6.72028586e-02f, 1.48126637e-04f,
  -5.98473065e-02f, 2.00256389e-02f, -5.45989014e-02f, -8.19382370e-02f, -1.66884959e-02f, 1.93014536e-02f, -6.76928684e-02f, -4.71336506e-02f, -5.82068339e-02f, 3.99874039e-02f,
  7.98116997e-02f, 8.64836946e-02f, 9.34364833e-03f, -2.05149967e-02f, -5.24396785e-02f, -3.86715606e-02f, 3.32332365e-02f, -3.27891782e-02f, -2.57927757e-02f, 1.97773222e-02f,
  3.22743319e-02f, -1.22768516e-02f, 3.32087986e-02f, -8.67253169e-02f, -3.89958695e-02f, -3.47586349e-02f, -8.30374584e-02f, 1.97492857e-02f, 4.43953499e-02f, -6.31091148e-02f,
  1.96964685e-02f, 2.20422670e-02f, -1.88409202e-02f, 3.77017586e-03f, 6.16427101e-02f, 2.56391615e-02f, -6.95243031e-02f, 7.33972639e-02f, 7.27353618e-02f, 6.01069955e-03f,
  5.26086688e-02f, 5.00527360e-02f, 7.68265948e-02f, -6.44254461e-02f, 6.13164268e-02f, -1.19504156e-02f, -6.72932342e-02f, -1.96318794e-02f, -2.55857240e-02f, 7.17469379e-02f,
  -9.43524167e-02f, 4.28271480e-02f, -2.35405210e-02f, 3.12706679e-02f, -3.27124037e-02f, 1.56595800e-02f, 7.33328657e-03f, -7.14967474e-02f, 9.24626589e-02f, 1.51620768e-02f,
  1.69590823e-02f, 9.11498219e-02f, -4.39542718e-02f, 5.44836558e-02f, -1.37847334e-01f, 5.14549837e-02f, 1.95474252e-01f, 6.40715938e-03f, 1.07257478e-01f, 1.60718188e-01f,
  1.20607398e-01f, 5.94458133e-02f, 1.08348951e-01f, 1.82998762e-01f, -8.36470276e-02f, 6.77611232e-02f, 1.97086707e-01f, 1.75134093e-01f, -1.55735854e-02f, 3.92674804e-02f,
  -4.58403453e-02f, 1.20542035e-01f, 6.74994243e-03f, -9.73815620e-02f, -4.11079861e-02f, -1.25619859e-01f, -7.71044567e-02f, -1.68435112e-01f, 8.24388564e-02f, -9.95941386e-02f,
  -5.67054003e-02f, -1.92353688e-02f, 2.23121978e-02f, -2.55748797e-02f, -6.50830939e-02f, -4.98972908e-02f, -8.42856988e-03f, -3.74531071e-03f, 5.56939188e-03f, -5.56869525e-03f,
  2.59252712e-02f, -4.97134067e-02f, -2.88061704e-02f, 5.01113236e-02f, 3.16348895e-02f, -9.11801681e-02f, -5.23678660e-02f, 2.64142524e-03f, -5.97333768e-03f, 1.17613049e-02f,
  -1.93514638e-02f, 3.56954746e-02f, 1.59898065e-02f, -5.05095115e-03f, -5.33258729e-02f, 6.93370402e-02f, -6.95446460e-03f, -7.95678273e-02f, 4.00987873e-03f, -7.23094121e-02f,
  2.17038263e-02f, -8.57376307e-02f, -5.01834042e-02f, -4.26213909e-03f, -2.18228158e-02f, -1.40459659e-02f, -8.03589672e-02f, -3.45604941e-02f, 3.03355772e-02f, -4.33224924e-02f,
  -5.02578057e-02f, -4.08540964e-02f, -7.89649859e-02f, 2.05798410e-02f, 4.07577381e-02f, -1.25759542e-02f, -5.13665155e-02f, 8.13086610e-03f, 5.19700125e-02f, -6.75950721e-02f,
  -1.79524701e-02f, -5.66912368e-02f, -1.35549149e-02f, -5.28602898e-02f, 5.94251156e-02f, 2.06445958e-02f, 3.53857465e-02f, 3.66137712e-03f, 5.55464774e-02f, 2.01932918e-02f,
  7.14170188e-02f, -3.04203536e-02f, 6.37594163e-02f, 4.73388992e-02f, -7.58676380e-02f, 5.03029563e-02f, -4.92980704e-02f, -2.89590824e-02f, 3.67986523e-02f, 8.10010657e-02f,
  -2.36369856e-02f, 3.06209251e-02f, 3.10385302e-02f, 3.24329101e-02f, -8.98168248e-04f, 5.52782265e-04f, 2.30208263e-02f, -4.32265140e-02f, -2.07958044e-03f, -6.08372502e-02f,
  9.94598214e-03f, 3.05779558e-02f, -1.16851050e-02f, 6.19355473e-04f, 1.71261113e-02f, -1.43128894e-02f, 2.34219749e-02f, -7.95605257e-02f, -3.69170569e-02f, 2.62532737e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 52)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 52;
const float L0_fan_Bp_bar_data[] = {
  6.69115484e-02f, -1.37372287e-02f, -2.30914615e-02f, 1.49688721e-01f, 8.70157480e-02f, 6.05913065e-02f, 6.56294748e-02f, 1.06494062e-01f, 1.42749399e-01f, -5.52944951e-02f,
  2.76036877e-02f, 1.52055636e-01f, 1.68932974e-01f, -3.57712284e-02f, 2.71353364e-01f, 1.58681542e-01f, 1.58218786e-01f, 1.22636870e-01f, 9.75531712e-02f, -2.14692950e-02f,
  3.63049321e-02f, 1.45430475e-01f, 3.13699603e-01f, 1.00438960e-01f, 6.21623266e-03f, 2.38034856e-02f, 1.77693069e-01f, 9.06351507e-02f, 9.31563079e-02f, 1.96165562e-01f,
  1.89206060e-02f, 1.63684547e-01f, 1.32186562e-01f, 4.74455841e-02f, 2.38511518e-01f, 1.38020828e-01f, 1.90760836e-01f, 1.06043175e-01f, -2.71290839e-02f, 4.47097272e-02f,
  1.15434758e-01f, 1.79674417e-01f, 8.53909254e-02f, 3.40994716e-01f, 1.38348222e-01f, 2.02008128e-01f, 5.79059571e-02f, 1.30510824e-02f, 7.43263960e-02f, 1.17743708e-01f,
  1.21809095e-01f, 1.17712289e-01f
};

// L1_fan_Wp (Shape: 6 x 64)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  -9.86108333e-02f, 7.00850859e-02f, -4.77118455e-02f, -1.71427894e-02f, 1.05996087e-01f, -1.63838379e-02f, -4.88575250e-02f, -1.82227835e-01f, -4.61345427e-02f, 1.55285984e-01f,
  -4.98920530e-02f, 8.60045403e-02f, -5.88561147e-02f, -7.94631429e-03f, -1.16902426e-01f, 5.34701832e-02f, 5.90817705e-02f, -6.15767129e-02f, 8.07526410e-02f, 2.63301641e-01f,
  6.26318753e-02f, 8.95652920e-02f, 4.96861711e-02f, 2.46732667e-01f, 3.55913118e-02f, -4.13429849e-02f, -4.03652666e-03f, -1.74066261e-03f, 1.23776104e-02f, 3.17541771e-02f,
  -5.49298115e-02f, 3.79463658e-02f, -2.15512626e-02f, 1.39160201e-01f, -2.52339780e-01f, -1.23511478e-01f, -1.59947440e-01f, 5.41721918e-02f, -1.24100015e-01f, 2.22832367e-01f,
  6.50660098e-02f, 1.45031646e-01f, 1.95483714e-01f, -1.20738328e-01f, -2.23769601e-02f, 2.10142024e-02f, -5.56999892e-02f, -2.04555541e-01f, -4.03857091e-03f, -4.55915183e-02f,
  1.24196619e-01f, -1.38055623e-01f, 1.53190553e-01f, -1.27951568e-02f, 7.48746991e-02f, -7.20106289e-02f, -1.03592381e-01f, 1.90724686e-01f, -9.68153849e-02f, -9.54286531e-02f,
  8.09726492e-02f, -1.68774486e-01f, -1.15690917e-01f, -4.24172245e-02f, 1.54153436e-01f, 1.21466354e-01f, 6.20800480e-02f, -7.85654038e-03f, -4.93719652e-02f, 7.30572343e-02f,
  -1.17894806e-01f, -4.48754206e-02f, -2.02427477e-01f, -1.01432778e-01f, 8.51634294e-02f, 4.45214473e-02f, 3.49914096e-02f, -1.94798529e-01f, -3.68630998e-02f, -6.88479990e-02f,
  7.15013742e-02f, 1.45885110e-01f, 5.57597168e-02f, -8.12266767e-02f, 4.09549959e-02f, -8.60909373e-02f, 1.98688749e-02f, 1.30730914e-02f, 9.14896280e-02f, 1.10841483e-01f,
  -1.21265180e-01f, -1.18219011e-01f, 1.73500448e-01f, -2.46437430e-01f, 1.73192888e-01f, -6.83271661e-02f, 8.92944541e-03f, -8.72604102e-02f, 8.61783028e-02f, 1.40623420e-01f,
  -8.89956504e-02f, 1.76863628e-03f, -4.93405014e-02f, -3.38208340e-02f, 1.28301874e-01f, -1.01742454e-01f, -9.78936478e-02f, -1.31941080e-01f, 6.50121942e-02f, 9.60981101e-02f,
  9.92500484e-02f, 1.32744089e-01f, 4.31345813e-02f, 2.51517538e-02f, 3.58441584e-02f, 4.11185287e-02f, 9.47474763e-02f, 5.66136241e-02f, 1.07727081e-01f, -1.09143548e-01f,
  -1.13548050e-02f, 2.00234160e-01f, 1.80019185e-01f, 1.07047461e-01f, 5.63406311e-02f, 1.17721632e-01f, 1.84158772e-01f, -1.76950634e-01f, -6.11405075e-02f, -6.78283870e-02f,
  -1.15242518e-01f, 4.27631587e-02f, 1.04679130e-01f, -7.37854913e-02f, -1.23429678e-01f, -1.57290876e-01f, 1.36287108e-01f, -2.06952274e-01f, -2.92557776e-01f, 2.53644377e-01f,
  -1.30984057e-02f, 3.61241885e-02f, 6.08795471e-02f, 1.13413841e-01f, 1.11250626e-02f, -8.39984566e-02f, -1.44532576e-01f, -3.23970877e-02f, -1.81060918e-02f, -3.04646809e-02f,
  1.06742829e-01f, -7.36336634e-02f, 6.70057535e-02f, -9.16774105e-03f, 1.29536077e-01f, 8.11645389e-02f, -2.75870785e-02f, 2.92496830e-02f, -1.08751923e-01f, -4.85650599e-02f,
  -1.42901599e-01f, -4.33514081e-02f, -1.45339236e-01f, -5.55972904e-02f, 8.91840900e-04f, -6.98144585e-02f, -2.74471343e-02f, 9.24471691e-02f, 6.59959540e-02f, -4.18321677e-02f,
  -1.16561316e-01f, 1.72195747e-01f, 1.09195627e-01f, -1.80887416e-01f, -1.97959810e-01f, 1.07414518e-02f, 1.25480920e-01f, -9.73967090e-02f, 2.62989048e-02f, 4.15455922e-02f,
  4.81630079e-02f, -3.23271900e-02f, 1.91165169e-03f, 2.96688788e-02f, -7.32782483e-02f, -6.87156245e-02f, 2.22134501e-01f, 1.17561743e-01f, -5.93777783e-02f, 8.32471326e-02f,
  -1.66677669e-01f, 5.76823875e-02f, -1.09228544e-01f, -1.02275401e-01f, -2.31014602e-02f, -1.23318406e-02f, 7.26648495e-02f, -1.13298692e-01f, -4.37496342e-02f, -9.26781818e-02f,
  1.09772064e-01f, -1.02673501e-01f, -1.20496601e-01f, 9.04002860e-02f, -3.25477421e-02f, 6.58052787e-02f, 1.35831647e-02f, 5.18756770e-02f, -1.04259163e-01f, 1.59617197e-02f,
  8.04265216e-02f, 1.90742150e-01f, 1.59288198e-01f, 1.18053108e-01f, 3.81769799e-02f, 3.66093181e-02f, 2.00609099e-02f, 6.95182830e-02f, -1.06278330e-01f, 1.92101330e-01f,
  -1.69815626e-02f, 9.76074636e-02f, -1.00329344e-03f, 8.63963068e-02f, 1.34020895e-01f, 1.59189746e-01f, -1.92456096e-01f, -9.05902386e-02f, 6.41576275e-02f, -3.90251540e-02f,
  -5.48791438e-02f, 7.48028830e-02f, 7.55188661e-03f, 8.89664888e-02f, -7.66644925e-02f, 1.80073753e-01f, 8.32761303e-02f, -6.27541021e-02f, -1.05981275e-01f, 6.79324567e-02f,
  -1.32676989e-01f, 4.21595611e-02f, 4.49094251e-02f, -7.14481547e-02f, -1.11538105e-01f, -6.71081187e-04f, -4.39612791e-02f, -7.63970464e-02f, -9.06372666e-02f, 1.08749419e-01f,
  4.89125550e-02f, -1.38860613e-01f, -4.75107878e-02f, 6.75461441e-02f, -1.80197716e-01f, 1.68360607e-03f, 3.80842164e-02f, -1.17919691e-01f, 7.43686920e-03f, -1.15421973e-01f,
  1.31936759e-01f, -1.99864283e-02f, -4.98041697e-02f, -4.76651900e-02f, 7.01454207e-02f, 1.54818505e-01f, 7.44444057e-02f, -1.08686700e-01f, 6.35896921e-02f, 1.64321616e-01f,
  -4.96637225e-02f, -1.65197060e-01f, 8.62869546e-02f, 2.51261331e-02f, 1.72580704e-01f, 1.90659896e-01f, -7.75782391e-02f, 1.09347682e-02f, 5.13585620e-02f, 7.80838728e-02f,
  -7.09093139e-02f, 4.02621962e-02f, -1.37578666e-01f, 1.59925874e-02f, 5.49573600e-02f, 8.29430372e-02f, 1.02226011e-01f, -3.60849523e-03f, 3.85682024e-02f, 1.82442352e-01f,
  -1.83904350e-01f, -1.48743808e-01f, -8.75235721e-02f, 1.77996069e-01f, 1.07976556e-01f, 1.89261839e-01f, 2.42833570e-02f, 2.19331667e-01f, 1.86139554e-01f, -4.63381261e-02f,
  7.32697919e-02f, -1.25442699e-01f, 9.07212570e-02f, -2.40836740e-02f, -5.12728617e-02f, 5.55039346e-02f, -3.60244565e-04f, -1.95114970e-01f, 1.15370609e-01f, -1.03239730e-01f,
  -1.27350271e-01f, -2.02690527e-01f, -1.02037624e-01f, -3.99819873e-02f, -1.12360813e-01f, 5.65748625e-02f, 5.31563461e-02f, 6.85884506e-02f, 2.34878317e-01f, -1.19776778e-01f,
  7.69508034e-02f, 7.71392062e-02f, -5.56192584e-02f, -4.57395390e-02f, -7.98579752e-02f, -5.32872267e-02f, -8.75478163e-02f, -9.45397094e-03f, 9.78850499e-02f, -2.17598453e-01f,
  -1.59140900e-01f, -1.02895260e-01f, 1.53959086e-02f, -1.62319139e-01f, -8.14205110e-02f, -4.22480255e-02f, -1.34924829e-01f, 1.68336272e-01f, 9.60973129e-02f, 1.03790611e-01f,
  -3.35758440e-02f, 1.28129162e-02f, -4.24950868e-02f, 7.79695855e-03f, -9.54997838e-02f, 1.30824158e-02f, -1.11944757e-01f, 3.94366719e-02f, 5.49168624e-02f, -1.05223805e-02f,
  1.42499983e-01f, 7.32525364e-02f, -5.94925135e-02f, -3.26642916e-02f, -2.43878350e-01f, 3.56002785e-02f, -1.02118962e-01f, 2.24157572e-01f, -1.22585222e-02f, -4.61343713e-02f,
  1.32725775e-01f, 1.53458938e-01f, 1.35598913e-01f, -1.19721569e-01f, -5.35210818e-02f, 2.55319830e-02f, -3.67365815e-02f, -4.06557284e-02f, 4.79200594e-02f, -5.59979305e-02f,
  4.27241810e-02f, 6.90344498e-02f, 1.08360417e-01f, -1.14218049e-01f, 8.75051096e-02f, -5.20045049e-02f, -3.40865441e-02f, 1.43804654e-01f, 4.97600920e-02f, -4.37116548e-02f,
  7.38948118e-03f, -7.76931420e-02f, 1.38170630e-01f, -1.26117039e-02f
};

// L1_fan_Wp_bar (Shape: 52 x 64)
const int L1_fan_Wp_bar_rows = 52;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  1.59651846e-01f, 2.05647022e-01f, 1.23126470e-01f, -6.32126108e-02f, 1.45358294e-01f, 2.79141199e-02f, 3.47018465e-02f, -5.20149358e-02f, -6.54757246e-02f, -1.65819108e-01f,
  9.51096416e-02f, -1.45904161e-02f, 5.20151742e-02f, 2.12199129e-02f, 1.25917653e-02f, 4.93148416e-02f, -3.73783484e-02f, 1.58445165e-01f, 1.13708995e-01f, 3.78074460e-02f,
  -6.25605285e-02f, 8.36061984e-02f, 5.85036948e-02f, -1.30719632e-01f, 2.01734388e-03f, -2.32028663e-02f, 3.11532021e-01f, 3.65402773e-02f, 7.48382211e-02f, -2.68844981e-02f,
  1.00455977e-01f, 1.09007293e-02f, -8.48988667e-02f, -1.44577354e-01f, 1.00616952e-02f, -1.58755388e-02f, -1.35522246e-01f, 1.55051202e-01f, 1.33267060e-01f, -1.78171441e-01f,
  4.70806248e-02f, -1.26136631e-01f, -1.71341017e-01f, -3.32571641e-02f, 1.42775252e-01f, 7.34762922e-02f, -5.03509715e-02f, 5.43355606e-02f, 1.14027753e-01f, 1.19569726e-01f,
  -7.18891993e-02f, 1.29275203e-01f, -9.22019631e-02f, 7.29110418e-03f, -6.12211339e-02f, 3.18932891e-01f, 4.17916141e-02f, -1.12453707e-01f, 2.24964619e-02f, 1.91735160e-02f,
  -4.07552682e-02f, 1.48629427e-01f, 1.43502012e-01f, -1.08274393e-01f, -8.69406909e-02f, -1.19370341e-01f, -8.40552822e-02f, 1.12250395e-01f, 4.08646725e-02f, -3.77114955e-03f,
  -1.94238499e-02f, -9.42082778e-02f, -1.14748999e-01f, -1.25581875e-01f, 4.09062244e-02f, 3.05431522e-02f, -1.15959644e-01f, 2.32100859e-02f, -1.05281912e-01f, 2.12695748e-02f,
  -7.91035406e-03f, -4.36493121e-02f, 4.68720831e-02f, -1.01384073e-02f, -4.29667765e-03f, 3.97768728e-02f, -7.30443224e-02f, -5.76146618e-02f, 1.07129693e-01f, 1.58467051e-02f,
  9.00768582e-03f, 1.76324304e-02f, -7.94093311e-02f, 2.44339649e-02f, -6.06442802e-02f, 7.84557611e-02f, -1.10834040e-01f, -1.04751982e-01f, 3.90780792e-02f, -1.04803190e-01f,
  -2.51927730e-02f, -2.67807133e-02f, 5.44483997e-02f, 3.46330255e-02f, -1.19247898e-01f, 1.68617740e-02f, -6.21513650e-02f, 4.18787524e-02f, 3.90935615e-02f, 4.56644930e-02f,
  1.02418318e-01f, -8.22154805e-02f, 5.51121831e-02f, -1.20836824e-01f, 7.67012015e-02f, 5.51723018e-02f, 8.83452371e-02f, -3.00031435e-03f, -3.36966030e-02f, 2.88157724e-02f,
  -8.73870775e-02f, 1.05464295e-01f, -7.78681859e-02f, -4.59698066e-02f, 1.12769447e-01f, -3.05506680e-02f, -8.85936096e-02f, -7.31245577e-02f, 2.03837961e-01f, 2.33790606e-01f,
  1.44355297e-01f, 1.49214357e-01f, 2.05026299e-01f, 2.04853155e-02f, 5.31076975e-02f, 3.61174680e-02f, 3.00027020e-02f, -9.40158740e-02f, 2.19738796e-01f, 8.41439515e-02f,
  1.24679849e-01f, -9.71496701e-02f, 5.04900292e-02f, -4.37522084e-02f, -2.61412952e-02f, 3.61022532e-01f, 4.94050011e-02f, -9.61989015e-02f, -5.12507781e-02f, -8.74421839e-03f,
  -1.00591473e-01f, -6.47477806e-02f, -4.34276946e-02f, -9.18033049e-02f, 2.80169010e-01f, -1.21413611e-01f, 1.86661437e-01f, 2.55401731e-01f, -7.22729191e-02f, 2.05763727e-01f,
  6.15425073e-02f, 1.12707587e-02f, 1.56774461e-01f, 1.74466118e-01f, -2.23205119e-04f, 8.73721391e-02f, 2.46125385e-01f, -1.97958753e-01f, 1.26159638e-01f, 3.03422697e-02f,
  -1.53655037e-01f, 1.98561877e-01f, 6.66344613e-02f, 1.05502538e-01f, 1.66046724e-01f, 1.59279138e-01f, 7.99641572e-03f, 1.71588689e-01f, 8.38334439e-04f, 2.19887290e-02f,
  -1.44922361e-01f, 1.49232045e-01f, 5.68020344e-02f, 3.93725157e-01f, -1.60851017e-01f, -6.58795610e-02f, -9.15847793e-02f, 1.55151412e-01f, -5.15191481e-02f, 2.00160295e-01f,
  4.75036241e-02f, 5.68370149e-02f, 3.46993655e-02f, 1.70217514e-01f, -4.86327633e-02f, 1.09621324e-01f, 3.08978498e-01f, 4.88320477e-02f, 1.05227344e-01f, -8.29338431e-02f,
  2.68999279e-01f, 8.86484459e-02f, 3.24578285e-02f, -4.77061719e-02f, -7.25498796e-02f, 1.42339602e-01f, -9.95260850e-02f, -1.73669130e-01f, 1.76354393e-01f, -3.86813693e-02f,
  1.49190083e-01f, -7.88125992e-02f, -1.62014261e-01f, 1.12614691e-01f, -2.95017827e-02f, 9.34500918e-02f, -5.99600822e-02f, -2.36034710e-02f, 8.73930529e-02f, 1.27079189e-01f,
  -5.76460361e-02f, 3.11240792e-01f, 6.36023283e-02f, 5.07953353e-02f, 1.18959770e-01f, 1.56591311e-01f, -8.67923498e-02f, -9.61502492e-02f, -1.51022866e-01f, 1.32005632e-01f,
  2.16681615e-01f, -7.01377019e-02f, 1.52288675e-02f, 1.31325483e-01f, -1.00963779e-01f, 2.28851616e-01f, -6.55399412e-02f, 4.02861647e-02f, 1.09216809e-01f, -4.51222509e-02f,
  1.28027067e-01f, -3.52158062e-02f, -1.98001415e-02f, 1.19082285e-02f, -1.22329565e-02f, -1.14856869e-01f, -4.01007123e-02f, 2.70834297e-01f, -6.07918575e-02f, -1.26647502e-01f,
  -1.59717709e-01f, 6.05409294e-02f, 7.13470429e-02f, 5.66417873e-02f, 5.14157340e-02f, 2.66402900e-01f, -1.38124585e-01f, -3.57570723e-02f, -1.24643669e-01f, -6.27526417e-02f,
  -1.13739043e-01f, 5.62691651e-02f, 6.67505190e-02f, -5.25373034e-03f, 2.10513975e-02f, 3.94826457e-02f, -4.73358706e-02f, -6.46245107e-02f, -5.84538057e-02f, 1.53490007e-02f,
  -2.08893325e-02f, 1.07885078e-01f, 1.13843329e-01f, 4.10224982e-02f, 2.53418908e-02f, 8.89426246e-02f, 1.60135292e-02f, -4.79144193e-02f, -1.22847468e-01f, -8.31459761e-02f,
  7.68215442e-03f, 7.84272552e-02f, -1.64615978e-02f, 8.25546158e-05f, 8.60902891e-02f, -2.98562329e-02f, -3.13354246e-02f, 1.56750828e-02f, -8.79749805e-02f, 4.18362767e-02f,
  3.17528844e-02f, -8.28109682e-02f, 7.34498277e-02f, -2.80865952e-02f, -1.26855850e-01f, -6.91378489e-02f, 1.09605707e-01f, -1.41690923e-02f, 6.46043662e-03f, 7.07596466e-02f,
  -1.16145827e-01f, -5.24497256e-02f, -1.23631723e-01f, 1.16456663e-02f, 2.96450388e-02f, 3.74371260e-02f, 1.79765988e-02f, 2.91853417e-02f, -8.93192887e-02f, -5.00540286e-02f,
  5.30880019e-02f, 6.37069494e-02f, -8.17433968e-02f, -8.19390863e-02f, -1.85506139e-03f, 8.04994479e-02f, 6.35613054e-02f, 7.61893316e-05f, -1.00510739e-01f, 1.01259805e-01f,
  1.05873816e-01f, 1.23330653e-02f, -9.24688652e-02f, -1.01329505e-01f, -8.13915357e-02f, 5.22306003e-02f, 1.31808938e-02f, -5.44143505e-02f, -5.41799255e-02f, 1.38181865e-01f,
  -1.24216620e-02f, 1.14871621e-01f, -2.27397867e-02f, -2.74779052e-02f, -5.25832139e-02f, -1.05362803e-01f, 9.99112800e-02f, -7.61445239e-02f, 5.70186786e-02f, -2.33982578e-02f,
  3.23814712e-02f, -4.79710400e-02f, -1.28614986e-02f, -1.54983550e-02f, 9.25214961e-02f, -7.35831335e-02f, -2.07395758e-02f, 1.61713138e-02f, -8.91210586e-02f, 1.35191336e-01f,
  -3.95384571e-03f, 3.85588743e-02f, 9.48962942e-02f, -2.78208181e-02f, -1.42002841e-02f, -8.98189023e-02f, -7.21186846e-02f, 1.01058772e-02f, 1.13670617e-01f, 1.61890988e-03f,
  -7.65096992e-02f, -3.41439955e-02f, -9.66699496e-02f, -1.15660705e-01f, -1.16757087e-01f, -5.13640121e-02f, -8.34425166e-02f, 1.21729426e-01f, -4.18915451e-02f, 2.97209416e-02f,
  5.00295609e-02f, -1.06850982e-01f, 1.52812768e-02f, 5.74108362e-02f, -9.97818410e-02f, -8.74329209e-02f, -5.99861033e-02f, 2.41264179e-02f, -6.34569675e-03f, -8.24385509e-02f,
  1.29629429e-02f, -9.73402262e-02f, 2.41212230e-02f, 7.58560523e-02f, -2.07988285e-02f, 8.83226395e-02f, 1.02249585e-01f, 3.24656963e-02f, -7.43966028e-02f, 3.47033399e-03f,
  -1.08022250e-01f, -3.97398435e-02f, 8.82347673e-03f, 6.66470528e-02f, -1.06428847e-01f, -1.33121833e-01f, 7.94720724e-02f, 1.13697261e-01f, -7.64228702e-02f, 1.48055870e-02f,
  -5.49441800e-02f, -2.64705066e-02f, 1.15333609e-01f, -9.40043032e-02f, 1.57755047e-01f, -8.07762221e-02f, 4.58949544e-02f, 2.28852723e-02f, -1.00794122e-01f, -6.90058693e-02f,
  -6.56198561e-02f, -5.72214536e-02f, -9.43660215e-02f, 8.98149014e-02f, -6.88627362e-02f, -9.73035619e-02f, -1.32652465e-02f, 3.15121212e-03f, 8.15295950e-02f, 6.24652468e-02f,
  -1.05922483e-01f, 9.84964818e-02f, 6.17333837e-02f, 5.53162433e-02f, 4.82373089e-02f, 1.70609145e-03f, 6.22375309e-02f, 7.68237412e-02f, -5.22246324e-02f, -3.68790105e-02f,
  4.32023518e-02f, -7.38921538e-02f, 7.32809156e-02f, 1.24700129e-01f, 4.96925488e-02f, 9.76032857e-03f, -1.18139222e-01f, -1.98166948e-02f, -6.09410405e-02f, -1.10652141e-01f,
  4.40513678e-02f, -4.30814698e-02f, 1.25777915e-01f, -7.41486847e-02f, -8.12109336e-02f, -1.08445749e-01f, 7.03759491e-02f, -5.17059565e-02f, 1.97723940e-01f, 1.55871958e-01f,
  1.75821707e-01f, 7.96421617e-02f, 9.02848132e-03f, 1.79185748e-01f, 9.51357484e-02f, 8.22901279e-02f, 1.43285349e-01f, 1.63505614e-01f, -2.49596924e-01f, -1.13601521e-01f,
  -6.31479546e-02f, 1.67386651e-01f, 4.45086360e-02f, 5.49704395e-03f, 9.20842309e-03f, -1.54688984e-01f, -9.04004797e-02f, 1.72108412e-02f, 1.85930114e-02f, -7.45596662e-02f,
  5.25593236e-02f, 1.73239917e-01f, -4.83217090e-02f, 3.84959541e-02f, 6.01002835e-02f, 1.25159845e-01f, 3.25201936e-02f, 1.19620144e-01f, 1.15288936e-01f, 1.21229872e-01f,
  8.01001340e-02f, 4.78046052e-02f, 2.35990789e-02f, -1.20098881e-01f, 1.61104098e-01f, -2.25012824e-02f, 4.16270792e-02f, 1.84625402e-01f, 1.39876097e-01f, 1.69106096e-01f,
  -1.12959377e-01f, 1.24772303e-01f, -7.01764748e-02f, -1.39180705e-01f, 1.18029326e-01f, 8.93318676e-04f, 1.41120270e-01f, -1.07575066e-01f, -4.71378826e-02f, 6.62761778e-02f,
  3.31858173e-02f, 5.12299538e-02f, -4.83204946e-02f, 3.77023667e-02f, 1.64438903e-01f, -7.05969855e-02f, 9.53775644e-02f, -7.89320394e-02f, -9.29789245e-02f, -3.99964191e-02f,
  7.55423382e-02f, 7.16567412e-02f, 1.17308497e-01f, -8.40412732e-03f, 1.95512578e-01f, 4.19196375e-02f, -9.70355868e-02f, -2.12400928e-02f, 2.03331634e-01f, 7.74974599e-02f,
  -1.02385730e-01f, 3.07178468e-01f, 3.01543683e-01f, -1.68803796e-01f, -2.39143204e-02f, 7.56239472e-03f, 8.08069482e-02f, -9.89225730e-02f, 1.56994924e-01f, 1.10668324e-01f,
  1.31079137e-01f, -5.71376495e-02f, 1.00955658e-01f, 7.09280968e-02f, 2.22944226e-02f, 1.06311269e-01f, 2.43430380e-02f, 1.72200128e-02f, -1.47549197e-01f, -3.02260481e-02f,
  1.43301889e-01f, 8.25668275e-02f, 9.70127583e-02f, -9.36564207e-02f, 1.97254360e-01f, 1.43638343e-01f, 2.52396077e-01f, 8.18241090e-02f, 4.40869182e-02f, 8.77583176e-02f,
  7.14289024e-02f, -3.42515809e-03f, 1.98177379e-02f, -4.10901159e-02f, -7.98733607e-02f, 3.43629755e-02f, 1.05610907e-01f, 2.11017996e-01f, 1.55607417e-01f, -4.23004925e-02f,
  7.19521940e-02f, 2.08557397e-01f, -8.18673745e-02f, 1.31985605e-01f, 8.26938599e-02f, 1.75794482e-01f, 2.86926306e-03f, -1.13955796e-01f, 2.86943257e-01f, 2.00058706e-02f,
  3.14426385e-02f, 5.71344867e-02f, -3.30373459e-02f, -8.18859190e-02f, -1.32605638e-02f, 4.02717143e-02f, -9.24237520e-02f, -4.27608788e-02f, 1.06398584e-02f, -4.44607101e-02f,
  1.20955840e-01f, -6.99420134e-03f, 9.34574828e-02f, -3.94423716e-02f, 7.34225065e-02f, -1.21503070e-01f, 3.00502242e-03f, 8.17367658e-02f, -1.94680330e-03f, 3.58010456e-02f,
  -1.14587016e-01f, -2.48818770e-02f, -2.68209260e-02f, 3.55869457e-02f, 4.64764461e-02f, 5.93320280e-02f, -3.01620830e-02f, -4.83140200e-02f, 8.99814889e-02f, -2.92778667e-02f,
  -7.07491934e-02f, 8.47151577e-02f, -2.32663956e-02f, -8.77157822e-02f, 1.46650122e-02f, 8.26409459e-02f, -9.81052890e-02f, 6.34413213e-02f, -4.81327921e-02f, 4.79929857e-02f,
  6.35274425e-02f, -8.52671172e-03f, 1.48017835e-02f, -1.05819136e-01f, 1.26304239e-01f, -5.79313487e-02f, -6.40044585e-02f, 3.53478119e-02f, 3.57492715e-02f, 9.61578190e-02f,
  3.53065021e-02f, 5.10758720e-02f, 1.89965230e-03f, 9.43399966e-02f, -1.17712699e-01f, -1.10646620e-01f, -6.47567213e-02f, -8.71605203e-02f, -1.00443147e-01f, -6.72410009e-03f,
  1.13554418e-01f, 6.17536567e-02f, -7.32870847e-02f, -1.00383349e-01f, 1.07046954e-01f, 7.97308162e-02f, 9.66170430e-02f, -7.39799887e-02f, 6.24566711e-02f, 1.47150457e-01f,
  1.93691440e-02f, 6.94375485e-02f, 7.30740875e-02f, 6.86375573e-02f, 1.38014764e-01f, 4.02327329e-02f, 7.16893151e-02f, -4.64111492e-02f, 8.03497285e-02f, 5.91977462e-02f,
  1.70035250e-02f, 6.08866028e-02f, -2.22892663e-03f, -1.16217978e-01f, -6.80219904e-02f, -7.10672513e-02f, 1.17423646e-01f, 8.31843093e-02f, 1.54509326e-03f, -1.10768512e-01f,
  -4.00683656e-03f, -1.14342324e-01f, -5.19600734e-02f, 6.53463155e-02f, -1.16465025e-01f, 1.16310053e-01f, -1.48559390e-02f, -6.17233589e-02f, -1.08467408e-01f, 1.49862379e-01f,
  -4.06543650e-02f, -2.31942050e-02f, 7.97711220e-03f, -7.66030774e-02f, -7.11231381e-02f, 4.47043628e-02f, -6.03396297e-02f, 3.35525163e-02f, 8.21861923e-02f, 3.64657156e-02f,
  8.40070471e-02f, 8.97480771e-02f, -4.27509136e-02f, -3.79004814e-02f, 2.11961903e-02f, 1.10333726e-01f, -3.90605368e-02f, -1.19002789e-01f, -3.81893627e-02f, 1.22519709e-01f,
  -1.08043797e-01f, -2.72277799e-02f, -1.05067171e-01f, 7.52937347e-02f, 7.10114241e-02f, -1.04615569e-01f, 5.30518740e-02f, -9.49096773e-03f, 6.86756568e-04f, 9.52794999e-02f,
  4.85183820e-02f, -1.22192293e-01f, -9.99896005e-02f, -7.08312243e-02f, 6.72620311e-02f, 1.20361131e-02f, -1.06481891e-02f, -5.37907891e-02f, 3.60209197e-02f, 1.87649459e-01f,
  -7.84450956e-03f, -4.05953117e-02f, 2.17817980e-03f, 1.49113089e-01f, -2.05868129e-02f, 2.17042957e-02f, 1.38059095e-01f, 6.61455914e-02f, 1.22687571e-01f, 3.15519013e-02f,
  7.91047886e-02f, 3.58763617e-03f, 9.57010612e-02f, 1.45611808e-01f, -7.06549920e-03f, 1.31760389e-01f, -9.26722139e-02f, -5.15102111e-02f, -1.20493159e-01f, 3.84240150e-02f,
  4.32463437e-02f, -2.39057876e-02f, -8.70697871e-02f, 9.15700868e-02f, -1.62127521e-02f, 1.33208096e-01f, -1.19421862e-01f, 4.40922640e-02f, -4.07833867e-02f, 1.58838797e-02f,
  -4.81456816e-02f, 1.42810583e-01f, 1.46447897e-01f, -2.10361388e-02f, -6.41537607e-02f, 2.03929573e-01f, -4.61435318e-02f, 1.58448175e-01f, -2.73900889e-02f, -9.41057205e-02f,
  9.85884145e-02f, 3.49531472e-02f, 4.30228040e-02f, -9.82410461e-02f, 6.21176399e-02f, -6.76933080e-02f, 9.66089070e-02f, -8.65157545e-02f, 8.65715835e-03f, 1.46990582e-01f,
  7.24689886e-02f, -1.22680932e-01f, -1.48829728e-01f, -8.42704400e-02f, -9.85572636e-02f, -5.96642941e-02f, 1.62002221e-01f, -2.89119259e-02f, 1.67651728e-01f, 1.18484549e-01f,
  1.53617710e-01f, -3.98930628e-03f, 2.18662471e-01f, 1.81647286e-01f, -3.95171158e-02f, -1.79694936e-01f, 3.67778577e-02f, 2.98865382e-02f, -2.12256968e-01f, 1.37483120e-01f,
  9.41719115e-03f, -4.17951681e-02f, -1.18095435e-01f, 1.68054983e-01f, -1.11180477e-01f, -6.89886045e-03f, 7.51246959e-02f, 1.32486194e-01f, -7.43312165e-02f, 9.05314684e-02f,
  -7.91763291e-02f, 1.41282380e-01f, 6.75778911e-02f, 5.92144988e-02f, -1.03332996e-01f, 1.75032809e-01f, 4.93433326e-02f, 2.49274194e-01f, -7.78800100e-02f, 6.24593832e-02f,
  1.15597226e-01f, 5.60814738e-02f, -1.38020888e-01f, -9.96541977e-02f, 1.21346354e-01f, -7.57186040e-02f, 1.10496178e-01f, 1.82820901e-01f, -6.91141114e-02f, 1.35610446e-01f,
  1.85077578e-01f, 9.54472646e-02f, -7.45642558e-02f, -1.43516868e-01f, 1.45750847e-02f, -1.14657834e-01f, -3.60933095e-02f, -4.44669044e-03f, 2.13297773e-02f, -1.91904932e-01f,
  -8.95362496e-02f, -8.47955942e-02f, 3.20502706e-02f, -6.93685412e-02f, 7.59754926e-02f, 1.80892929e-01f, 1.04058941e-03f, 1.31162986e-01f, -6.88455775e-02f, 1.06847696e-01f,
  -1.33740983e-03f, 1.44178852e-01f, 6.05247580e-02f, -4.71528023e-02f, -8.98960903e-02f, 4.56015207e-02f, -6.81240782e-02f, 6.41668364e-02f, 7.67891034e-02f, 4.78874408e-02f,
  1.64522722e-01f, -9.19018388e-02f, 5.19685866e-03f, -7.12784426e-03f, -7.25412220e-02f, 6.54900372e-02f, -2.06050184e-02f, -9.02718753e-02f, -9.84862074e-02f, 1.47850916e-01f,
  1.88233823e-01f, 1.03325397e-01f, 7.18858987e-02f, 2.14840774e-03f, -1.01936953e-02f, 1.37508392e-01f, -1.19026050e-01f, 4.33909446e-02f, -1.49006965e-02f, 7.86963105e-02f,
  4.40220349e-02f, 1.02616802e-01f, 3.85012776e-02f, 2.49227583e-02f, 1.36934832e-01f, 1.22904070e-01f, -8.78320411e-02f, -1.18715271e-01f, -3.95740755e-02f, 1.59357011e-01f,
  -7.83725902e-02f, -3.86479385e-02f, 1.71442162e-02f, 8.03505629e-02f, 1.43497571e-01f, 7.80241117e-02f, -7.97054470e-02f, 8.09342116e-02f, 2.86044180e-02f, 1.81638494e-01f,
  5.63927293e-02f, 1.63500965e-01f, 1.28397807e-01f, 4.24118526e-02f, 7.05133751e-03f, -5.44359982e-02f, -1.78994983e-02f, -1.00379951e-01f, -3.48144993e-02f, 1.40103906e-01f,
  -7.18869269e-02f, -6.55246601e-02f, 6.06654324e-02f, 1.43000528e-01f, 8.72762278e-02f, 7.07431370e-03f, -2.54501533e-02f, 3.32580805e-02f, 1.27063453e-01f, -4.78099920e-02f,
  4.79095103e-03f, 1.35058463e-01f, 8.48400742e-02f, -1.01583987e-01f, -1.38138682e-01f, -9.13909078e-02f, 2.59843588e-01f, 5.00143617e-02f, 6.82226792e-02f, 3.89549136e-02f,
  1.26891240e-01f, -6.20125271e-02f, 1.41371703e-02f, 1.03893038e-02f, 6.61511570e-02f, 4.94421236e-02f, 1.36327937e-01f, 9.57769379e-02f, -9.74980891e-02f, -6.03253916e-02f,
  4.69095446e-02f, 5.08055240e-02f, 1.42491102e-01f, -9.81026143e-02f, 1.03670791e-01f, -1.51383236e-01f, 6.07684292e-02f, -7.73278414e-04f, -8.74903947e-02f, -4.15290333e-02f,
  -5.83818890e-02f, 1.10334553e-01f, -1.13600321e-01f, -8.18336755e-02f, 5.58382720e-02f, 4.25322019e-02f, 1.21909976e-01f, -4.39297408e-02f, 4.27271286e-03f, 7.99889490e-02f,
  1.10093668e-01f, 1.13022342e-01f, 7.43611380e-02f, 1.33797497e-01f, 6.88190311e-02f, 4.79300283e-02f, -2.51435097e-02f, 1.69430643e-01f, 1.67714879e-02f, 1.25180572e-01f,
  -4.63407747e-02f, 2.82361135e-02f, 1.14907131e-01f, 1.28083816e-02f, -1.19492993e-01f, 6.26628171e-04f, -2.82048341e-03f, -3.44501808e-02f, 1.31463289e-01f, -5.25939949e-02f,
  -1.34909339e-02f, -1.52280610e-02f, 8.22577477e-02f, 1.35029525e-01f, -4.46398482e-02f, 4.50934023e-02f, 7.68216280e-03f, 6.68640435e-02f, -1.25633162e-02f, -1.11957202e-02f,
  5.65807857e-02f, -8.10617656e-02f, -6.30702004e-02f, -7.23767728e-02f, 7.95638636e-02f, -1.01678282e-01f, 2.80400831e-02f, 2.32357718e-02f, -1.20734036e-01f, -7.93992952e-02f,
  6.80103973e-02f, -2.64727231e-03f, 2.94973794e-03f, 7.12370081e-03f, 1.10617010e-02f, -9.05578360e-02f, -8.66744295e-02f, -6.00076355e-02f, -7.19341859e-02f, -1.76216364e-02f,
  -1.71087142e-02f, -7.10845068e-02f, 4.72414382e-02f, -1.74142718e-02f, 1.30668342e-01f, -1.35293230e-02f, 1.07477196e-01f, -3.55609842e-02f, -4.56628613e-02f, -8.35784972e-02f,
  -9.36866328e-02f, -1.08646423e-01f, 1.06874771e-01f, -6.22257777e-02f, 4.56510000e-02f, -1.02763455e-02f, -8.17632601e-02f, 6.02244176e-02f, 1.39398858e-01f, -6.91722035e-02f,
  3.35151255e-02f, 9.25981998e-02f, 8.45732689e-02f, -5.86347207e-02f, -1.21848248e-01f, 3.46164368e-02f, 2.87332591e-02f, 2.48439386e-02f, -4.48984094e-02f, -1.09847784e-01f,
  2.68979371e-02f, -7.54160583e-02f, 1.06344342e-01f, -7.06031024e-02f, 9.44389552e-02f, 2.51514733e-01f, 2.28898734e-01f, 1.94398120e-01f, 1.69129726e-02f, 2.59518951e-01f,
  2.07322277e-02f, 2.02889979e-01f, -2.22892150e-01f, -4.26941626e-02f, -3.18505913e-01f, 1.10078327e-01f, 7.75750726e-02f, -8.30296502e-02f, 1.15499608e-02f, 2.00269982e-01f,
  7.61383176e-02f, -1.49967983e-01f, -3.96246351e-02f, -8.00573677e-02f, 1.65448517e-01f, -3.97429727e-02f, 1.25638708e-01f, -8.33902881e-03f, 2.55832076e-01f, 1.41834721e-01f,
  1.32190228e-01f, -9.75413844e-02f, -2.19643954e-03f, -1.98109299e-01f, 1.09155826e-01f, -7.83557966e-02f, 6.43186271e-02f, -1.38983011e-01f, 2.93591619e-01f, -4.49778093e-03f,
  3.00775200e-01f, 9.14273318e-03f, 9.30930674e-02f, 6.72409683e-02f, -9.00872052e-02f, -2.57485807e-02f, -7.24380836e-02f, -3.43917385e-02f, 5.03374636e-02f, 6.23712987e-02f,
  2.30407342e-01f, -7.21078739e-02f, 1.88039020e-01f, -3.52721699e-02f, -6.00213818e-02f, 9.53042284e-02f, 5.90017810e-02f, 1.48903638e-01f, -7.16710240e-02f, -1.19971864e-01f,
  1.95318341e-01f, 1.01535060e-01f, 1.23798512e-01f, 6.36222735e-02f, 1.75174341e-01f, 3.70701067e-02f, 6.54917508e-02f, -5.36387265e-02f, 1.31132826e-01f, 1.82586133e-01f,
  1.67666271e-01f, 1.73632309e-01f, 6.22670352e-02f, 8.07064325e-02f, -1.58920258e-01f, -1.43700689e-01f, -1.31837755e-01f, 1.10134929e-01f, 1.83864981e-01f, -1.41606227e-01f,
  -6.87740520e-02f, 1.55748025e-01f, -7.63170496e-02f, -7.57533684e-02f, -2.73764543e-02f, -4.96232125e-04f, 1.03247404e-01f, 2.17752203e-01f, 1.62466839e-01f, 4.32945378e-02f,
  -6.89692795e-03f, 2.24982455e-01f, 3.47513184e-02f, 1.00026369e-01f, -1.80779219e-01f, 2.21585780e-01f, 1.67213172e-01f, -2.09924355e-02f, -3.57498862e-02f, -1.24335155e-01f,
  9.87641513e-02f, 1.09823704e-01f, -1.51768118e-01f, 1.89807251e-01f, 5.36567084e-02f, -1.28679216e-01f, 1.98323689e-02f, 2.32061848e-01f, 6.47648051e-02f, 3.85340266e-02f,
  2.28736371e-01f, 9.53192636e-02f, 3.41395102e-02f, 6.13085032e-02f, 1.33038908e-01f, 1.36159202e-02f, -1.11652844e-01f, 1.61426410e-01f, -1.30747363e-01f, -9.25467387e-02f,
  -9.60770324e-02f, -9.27785486e-02f, 9.36395302e-02f, 7.39563853e-02f, 2.38868207e-01f, 3.01250756e-01f, -9.43129435e-02f, 1.10557489e-01f, -6.52061328e-02f, 8.86405259e-02f,
  -1.26662195e-01f, -8.16401094e-02f, -5.08718491e-02f, -1.79325771e-02f, 9.37748104e-02f, 7.78174624e-02f, 8.62022936e-02f, 1.71405524e-01f, -6.23868331e-02f, -1.22096695e-01f,
  -2.16191206e-02f, -1.21317305e-01f, 2.68950224e-01f, -9.86491144e-02f, 1.30825430e-01f, 3.37231643e-02f, -3.92787904e-02f, 5.79053871e-02f, -4.14744616e-02f, -4.97419126e-02f,
  6.32740930e-02f, 1.07840262e-01f, 1.41937286e-01f, 2.08179858e-02f, -1.30721316e-01f, -1.29735038e-01f, 1.14968628e-01f, 4.00966406e-02f, 9.38995406e-02f, -1.41223252e-01f,
  1.79226145e-01f, -8.68560299e-02f, 1.21143870e-01f, -6.65685162e-02f, -6.03561811e-02f, 1.24861605e-01f, 1.31861502e-02f, 8.52058828e-02f, 3.50644812e-02f, -1.76007852e-01f,
  -1.54055925e-02f, 6.01707026e-02f, -1.46704689e-01f, 3.79583389e-02f, 1.67883679e-01f, -9.28297266e-02f, -2.58929785e-02f, 1.35576501e-01f, 1.40118361e-01f, 8.54770988e-02f,
  7.11791962e-02f, 9.56293643e-02f, 1.09946139e-01f, 5.68012670e-02f, -1.30352341e-02f, -3.67089137e-02f, 3.02792162e-01f, 2.67542034e-01f, 3.53430696e-02f, 7.88550451e-02f,
  -1.06681272e-01f, 1.43429577e-01f, -3.03407176e-03f, -2.02843025e-02f, 2.38867328e-02f, 1.96388308e-02f, 1.43450618e-01f, 1.46977812e-01f, 1.97481737e-01f, 3.32018249e-02f,
  1.47951320e-01f, 5.30744307e-02f, -7.83253536e-02f, -6.89317882e-02f, -1.91270877e-02f, -3.03812861e-01f, 2.83710241e-01f, -1.29209533e-02f, 2.37690032e-01f, -9.33981389e-02f,
  9.91761610e-02f, 1.14909880e-01f, 8.89732540e-02f, 3.61712962e-01f, 2.09333241e-01f, -4.04370725e-02f, 2.34593153e-02f, 3.27374749e-02f, 1.06070571e-01f, 4.60031293e-02f,
  -1.15436345e-01f, 4.09093164e-02f, 1.06368549e-01f, -9.61470753e-02f, 2.76271790e-01f, -1.73045427e-01f, 2.12496847e-01f, 9.70718712e-02f, -7.15086386e-02f, -1.58831012e-02f,
  -1.11878909e-01f, 2.29062960e-01f, -2.48530339e-02f, 2.67552972e-01f, 8.67882296e-02f, 4.64078188e-02f, 5.36443442e-02f, -8.33576471e-02f, 1.42013639e-01f, -1.09927386e-01f,
  8.65848288e-02f, 1.54988378e-01f, -2.54305955e-02f, 2.59241790e-01f, -1.11838244e-01f, 1.40593842e-01f, -1.10181563e-01f, 2.77120676e-02f, 2.07060408e-02f, -8.60923454e-02f,
  2.09592909e-01f, 1.57670483e-01f, -3.44319418e-02f, 4.86141331e-02f, 1.40055697e-02f, -1.02746077e-02f, 3.63127999e-02f, 2.25547537e-01f, 9.36330408e-02f, -1.85612842e-01f,
  2.18189433e-01f, 1.00544408e-01f, 6.12654947e-02f, 6.83766007e-02f, 1.19649120e-01f, 1.18092321e-01f, -5.05044311e-02f, 3.44046913e-02f, 1.69132188e-01f, -8.05208534e-02f,
  -3.45617086e-01f, 2.40748674e-01f, 1.18081257e-01f, 7.43365195e-03f, -1.11465111e-01f, 5.47550246e-02f, 7.29405954e-02f, 7.35394983e-03f, 7.82141089e-02f, 2.74379551e-01f,
  1.61473989e-01f, 9.02290270e-03f, 1.01036362e-01f, -2.56240517e-02f, 8.03288221e-02f, 9.43986978e-03f, 1.61221445e-01f, 1.94774985e-01f, -2.07903106e-02f, 2.32528463e-01f,
  1.02151334e-01f, 6.86138794e-02f, -7.53200427e-02f, 8.27550441e-02f, -1.73362315e-01f, -1.33773610e-01f, 1.33293286e-01f, 1.80923238e-01f, -7.01818615e-02f, 4.17745858e-02f,
  9.74500105e-02f, 1.95663571e-02f, -9.53386799e-02f, 2.37647980e-01f, 1.42900482e-01f, -1.65629610e-01f, -8.27210397e-02f, -1.19343668e-01f, 1.65511116e-01f, -8.72594304e-04f,
  8.00136998e-02f, 1.23142675e-01f, -3.10474616e-02f, -6.84887543e-02f, -7.44637549e-02f, 5.83039150e-02f, -6.68535605e-02f, -1.46073122e-02f, 2.42943570e-01f, -2.03166790e-02f,
  1.28452495e-01f, 1.49116591e-01f, 6.00607879e-02f, 1.03311785e-01f, -2.14132108e-02f, 1.08289026e-01f, 8.84788390e-03f, -9.24256220e-02f, 3.17134038e-02f, -1.52729293e-02f,
  1.59273855e-02f, -2.19801236e-02f, 8.67116265e-03f, -6.79401308e-02f, -6.51069656e-02f, 1.19457543e-01f, 8.63162130e-02f, 1.01475716e-01f, -9.32520404e-02f, 8.45265239e-02f,
  -6.40016869e-02f, -1.02042429e-01f, 2.28519402e-02f, -8.49726573e-02f, 2.47386936e-02f, 1.13583289e-01f, -1.56802475e-03f, -3.70114930e-02f, -8.62426013e-02f, -1.13368839e-01f,
  1.71943292e-01f, 9.71998870e-02f, -1.11848049e-01f, 1.70929488e-02f, -7.30862617e-02f, 3.60972881e-02f, 3.18145752e-02f, -1.24948816e-02f, 5.40460721e-02f, -9.15295705e-02f,
  -7.04095960e-02f, 1.85966957e-03f, 8.96593332e-02f, -1.93213932e-02f, -1.07913963e-01f, -3.43867987e-02f, 7.76172355e-02f, 1.17476940e-01f, -8.33847187e-03f, 1.11920848e-01f,
  -8.81272703e-02f, -2.85656266e-02f, 1.26915678e-01f, 1.26383593e-02f, 7.71649405e-02f, 3.67290713e-02f, 7.69181773e-02f, -5.44582345e-02f, -4.56620334e-03f, 1.39491245e-01f,
  -1.12216480e-01f, 4.51226979e-02f, 3.34582403e-02f, -2.02175453e-02f, 1.02833763e-01f, 6.11383915e-02f, -2.14013327e-02f, -1.29498050e-01f, 1.29761830e-01f, 1.39456745e-02f,
  2.15505734e-02f, 1.69899851e-01f, -1.39872819e-01f, -1.96783766e-02f, -4.72860374e-02f, 8.73487443e-02f, 4.05236036e-02f, 9.23910812e-02f, -4.83982712e-02f, -6.42903894e-02f,
  1.23795167e-01f, 7.17422813e-02f, 5.79730757e-02f, -4.17689197e-02f, -8.61102268e-02f, 7.65804127e-02f, 1.31394193e-01f, -9.12008658e-02f, 9.61539447e-02f, 5.59045039e-02f,
  4.64047641e-02f, 1.75621957e-01f, 1.08651422e-01f, -8.29141289e-02f, -6.12234650e-03f, 5.16510010e-02f, 6.66012615e-02f, -1.15185030e-01f, 7.50911757e-02f, 5.42482063e-02f,
  1.75242245e-01f, 9.02417228e-02f, 1.21863388e-01f, 5.60747534e-02f, -6.45556673e-02f, 1.38970092e-01f, 1.16987852e-02f, -6.76852390e-02f, -5.87671474e-02f, -5.75972609e-02f,
  -1.83964092e-02f, -1.42376181e-02f, 1.23302974e-01f, 1.02347739e-01f, 6.85502291e-02f, -2.98645217e-02f, 3.80877480e-02f, -5.78706106e-03f, 7.42169470e-02f, -9.30634439e-02f,
  -7.04555362e-02f, 9.15609226e-02f, 8.84897262e-02f, -7.08565488e-02f, 2.03840464e-01f, 2.13902786e-01f, 5.25793945e-03f, -1.26586586e-01f, 4.43039909e-02f, -4.64407057e-02f,
  1.48085415e-01f, -3.71472836e-02f, -5.10351062e-02f, -3.59173045e-02f, -8.32017958e-02f, 1.42237499e-01f, 6.73584864e-02f, 8.38727355e-02f, -3.90349999e-02f, -7.08308890e-02f,
  1.06296092e-01f, 1.64381519e-01f, 5.43205962e-02f, 8.46806467e-02f, 1.72161739e-02f, -9.85932425e-02f, -6.77497983e-02f, 2.83903535e-02f, -5.24520501e-02f, -1.38241658e-02f,
  -9.37388763e-02f, -9.46671050e-03f, -3.23449150e-02f, 6.66015074e-02f, 4.52480316e-02f, 5.43775521e-02f, -1.79382879e-02f, 1.21019715e-02f, 1.70329940e-02f, 1.31299749e-01f,
  -1.65611983e-03f, 5.88692836e-02f, 2.68814173e-02f, 1.34342879e-01f, 7.46921152e-02f, 1.34414043e-02f, -1.08129859e-01f, 7.12824007e-03f, -7.57499859e-02f, -3.00792418e-02f,
  -8.89820978e-02f, 1.29442170e-01f, 8.26759040e-02f, 1.49702206e-01f, 1.46784529e-01f, 1.29707262e-01f, 1.35758176e-01f, 1.10078685e-01f, 1.19174734e-01f, 6.23946860e-02f,
  -6.76635504e-02f, 2.95985285e-02f, -1.02558069e-01f, 4.51733470e-02f, -6.25319630e-02f, -1.09493300e-01f, -1.82633735e-02f, 1.76818843e-03f, 7.28548095e-02f, -5.41418372e-03f,
  -1.27147771e-02f, 2.64017340e-02f, -2.73715314e-02f, -7.43625537e-02f, 1.61966439e-02f, 4.25957404e-02f, 1.66326314e-01f, 2.17377499e-01f, 1.26638534e-02f, 1.48574352e-01f,
  8.33722129e-02f, 1.62473306e-01f, -8.09108168e-02f, 2.49879453e-02f, -1.37821242e-01f, 8.54379162e-02f, 1.96681172e-01f, -8.08091462e-02f, -7.70467669e-02f, -1.06469147e-01f,
  -7.33406544e-02f, 8.10336024e-02f, 9.20287743e-02f, -1.30689427e-01f, 1.17116787e-01f, -8.80361274e-02f, -1.40084550e-01f, 4.74178977e-02f, -1.19764611e-01f, -1.09215729e-01f,
  6.25058189e-02f, -6.66832402e-02f, -1.75629050e-01f, -5.68797300e-03f, 1.82794109e-01f, 4.30414639e-02f, 1.43066183e-01f, 1.99972349e-03f, 5.03873304e-02f, 1.18199557e-01f,
  1.66933775e-01f, 9.62565914e-02f, 5.18011041e-02f, 1.47741213e-02f, -4.47140075e-03f, -3.12683955e-02f, -1.74228139e-02f, 1.90655082e-01f, 3.45040336e-02f, -7.99475238e-02f,
  3.29565108e-02f, -4.48945910e-02f, 1.74134895e-01f, -5.82637973e-02f, 1.09130919e-01f, -1.36958033e-01f, 1.52976485e-02f, -7.53497183e-02f, -6.83604926e-02f, 1.41673699e-01f,
  1.58491835e-01f, 1.40086651e-01f, -1.09183244e-01f, 1.31367475e-01f, -1.11189308e-02f, 4.66249362e-02f, 3.88127007e-02f, -1.07644357e-01f, -5.70521057e-02f, -6.64743334e-02f,
  1.06956452e-01f, -1.99485589e-02f, 1.55200541e-01f, 1.23268344e-01f, 7.83043653e-02f, 1.56239778e-01f, 8.91691446e-02f, 1.89356357e-02f, 2.27251366e-01f, 5.88405430e-02f,
  3.45458299e-01f, -2.59939879e-02f, 9.66266394e-02f, 6.60733506e-02f, 1.50763065e-01f, -9.61937308e-02f, 2.00887337e-01f, 1.30969644e-01f, 2.54903227e-01f, 1.30400047e-01f,
  -1.05608985e-01f, 1.43039361e-01f, -1.66349918e-01f, -1.41578242e-02f, 3.27361636e-02f, 5.17352112e-02f, 1.63218833e-03f, 1.52955577e-01f, 1.73556089e-01f, 1.19520411e-01f,
  1.76429257e-01f, 4.50245626e-02f, 5.44361845e-02f, 2.67803781e-02f, 5.46788238e-02f, 1.21670201e-01f, -1.02397226e-01f, 1.97406739e-01f, 2.04956591e-01f, 1.50609463e-01f,
  3.87397944e-03f, 2.27342620e-01f, -8.22266564e-02f, 1.96450159e-01f, -8.03460553e-02f, -4.74552587e-02f, 7.05537722e-02f, 2.37189576e-01f, 1.39825150e-01f, 2.55027831e-01f,
  -6.10859692e-02f, -6.62782341e-02f, 8.12771916e-02f, -1.21317404e-04f, 1.85866371e-01f, 2.57408917e-01f, 6.11118302e-02f, 9.62978229e-02f, -2.76366740e-01f, -2.81632245e-02f,
  -3.86198722e-02f, -6.56250045e-02f, 1.90854341e-01f, 6.99475557e-02f, 7.92455766e-03f, 1.36010870e-01f, 2.27199271e-01f, 9.43002403e-02f, -1.21084228e-01f, 1.64160341e-01f,
  1.15351137e-02f, -7.49879256e-02f, -2.32147783e-01f, -1.53435513e-01f, 4.53372926e-01f, -6.33936748e-02f, 1.84504032e-01f, -3.23468819e-02f, -2.97522601e-02f, -4.78357486e-02f,
  1.46950364e-01f, -6.94472119e-02f, 1.96977030e-03f, -5.35266325e-02f, 4.84741293e-03f, -1.10018268e-01f, -5.67022935e-02f, -1.05018131e-01f, -1.97032038e-02f, -3.23450640e-02f,
  -1.53589353e-01f, -1.19057439e-01f, 1.13722183e-01f, -9.93376076e-02f, 7.71872140e-03f, 1.06165268e-01f, 8.45847130e-02f, 3.08857560e-02f, 7.80415088e-02f, 3.08301836e-01f,
  8.55351705e-03f, -1.65925678e-02f, -1.22550584e-01f, -6.58609197e-02f, 2.85986997e-03f, 2.29949616e-02f, -7.42384000e-03f, -1.26101613e-01f, 6.56437650e-02f, 2.59289294e-01f,
  4.60921116e-02f, 1.32490128e-01f, 1.22001372e-01f, -3.97965983e-02f, 5.49880862e-02f, 1.60715282e-01f, 5.60474209e-02f, 2.15730816e-01f, 3.11373681e-01f, 3.35455000e-01f,
  1.77508980e-01f, 2.07897618e-01f, -9.10890475e-02f, 1.85923427e-01f, 1.19925991e-01f, 7.27113932e-02f, 6.14098087e-02f, -3.08647323e-02f, 1.24786817e-01f, 1.61617473e-02f,
  -6.05651401e-02f, -9.37314481e-02f, 1.24319069e-01f, -5.18672727e-02f, -6.48438632e-02f, -1.98370349e-02f, -5.71580464e-03f, -1.14749400e-02f, -1.25916272e-01f, 1.50510296e-01f,
  8.78839046e-02f, 8.42429996e-02f, -5.43536171e-02f, 1.61545992e-01f, 1.12610020e-01f, 1.33290529e-01f, 6.43536597e-02f, 2.26181358e-01f, 7.42495134e-02f, -7.23413611e-03f,
  7.97457621e-02f, 1.61020815e-01f, -5.23100458e-02f, 3.05724405e-02f, 9.91314203e-02f, 1.66702747e-01f, 8.61133710e-02f, 1.57630816e-01f, 2.10244786e-02f, -9.59099308e-02f,
  -3.10964673e-03f, 7.60787502e-02f, -1.26401186e-01f, 4.97988425e-02f, -5.82959391e-02f, 9.78593603e-02f, -1.98474173e-02f, 1.96989179e-01f, -5.57886660e-02f, 2.61592399e-02f,
  -1.02429152e-01f, -3.99921909e-02f, 4.89050858e-02f, -1.17312245e-01f, -8.15600753e-02f, -1.05465189e-01f, -2.59329546e-02f, 7.99554959e-02f, 4.38626446e-02f, 6.58259913e-02f,
  1.14955649e-01f, -6.25839829e-02f, -1.30547397e-02f, 5.84667847e-02f, 1.02466986e-01f, -6.51991889e-02f, 1.31621853e-01f, 1.14848427e-01f, -2.00337470e-02f, 1.85018480e-02f,
  8.50106627e-02f, 1.45857230e-01f, 5.08247539e-02f, -2.01271214e-02f, 1.34869829e-01f, 1.93955172e-02f, 1.16011407e-02f, 9.73776579e-02f, 1.32531837e-01f, 2.39194129e-02f,
  2.93677580e-02f, 7.96088129e-02f, 2.51842644e-02f, -1.82489548e-02f, -2.32333341e-03f, 3.73397432e-02f, -5.27687036e-02f, 9.66649279e-02f, 1.10573526e-02f, -5.93385957e-02f,
  -1.69472639e-02f, 6.24297336e-02f, 1.16804443e-01f, 2.25316100e-02f, 1.46379471e-01f, -9.83709022e-02f, -9.56557468e-02f, -1.29980952e-01f, 2.52617568e-01f, -8.84489939e-02f,
  -1.40699148e-01f, 2.66136955e-02f, 1.05387017e-01f, -5.45856319e-02f, 1.46648541e-01f, -1.25818714e-01f, 1.69756003e-02f, 2.86354888e-02f, -9.42316279e-02f, -2.35376582e-02f,
  -7.16763064e-02f, -1.90068912e-02f, 1.23096937e-02f, 8.25561509e-02f, -6.63362956e-03f, 1.69573203e-01f, 6.05645366e-02f, -4.30864282e-02f, 8.15226957e-02f, -5.01463525e-02f,
  5.69326989e-02f, 1.12230420e-01f, 1.42413285e-02f, 4.69140224e-02f, 1.01411223e-01f, 1.78034678e-01f, -1.04117356e-01f, -5.19138053e-02f, 6.69628605e-02f, -3.62991840e-02f,
  1.51016369e-01f, 1.44126185e-04f, 1.20773658e-01f, 1.14755556e-01f, -9.40567553e-02f, -7.17176795e-02f, 1.36477381e-01f, 8.58556554e-02f, 2.00121533e-02f, 1.43034130e-01f,
  -1.25852495e-01f, 1.57983210e-02f, -3.04455850e-02f, -1.45193502e-01f, -2.42751777e-01f, -1.17130883e-01f, 1.87797442e-01f, -5.43995155e-03f, 4.53320481e-02f, -1.69181207e-03f,
  -8.31397325e-02f, 3.39697227e-02f, 5.13661765e-02f, -1.30468115e-01f, 2.41893735e-02f, 9.62232649e-02f, -1.75098446e-03f, 9.29865837e-02f, 1.81075469e-01f, -6.91990852e-02f,
  2.06586141e-02f, 6.88195750e-02f, 4.36657332e-02f, -1.53137865e-02f, 5.01808189e-02f, -1.34545684e-01f, -5.71420044e-02f, 5.35339601e-02f, 9.32967141e-02f, 1.08940311e-01f,
  9.35465023e-02f, 1.06741019e-01f, 4.61264253e-02f, 5.05040251e-02f, -1.67341024e-01f, 1.23430692e-01f, -1.27829064e-03f, -8.55457112e-02f, 7.49046057e-02f, 6.24359548e-02f,
  1.58158913e-01f, -4.67254072e-02f, 2.59037782e-02f, 8.74554515e-02f, -1.08503044e-01f, -4.90638986e-02f, 9.33761820e-02f, 1.62557691e-01f, -2.59868857e-02f, 1.68390468e-01f,
  7.18993321e-02f, 2.74564922e-01f, 1.93590134e-01f, 6.95984205e-03f, -1.20371720e-02f, 1.06511079e-01f, -1.14859361e-02f, -4.12681997e-02f, -1.38803003e-02f, -4.72999830e-03f,
  3.08533274e-02f, -4.51146625e-02f, -1.23519607e-01f, 9.01803821e-02f, -5.31395823e-02f, -1.21295795e-01f, 8.39331448e-02f, 1.01971135e-01f, -7.66972080e-02f, 1.27829388e-02f,
  -1.09816439e-01f, -5.73715614e-03f, -7.83050731e-02f, 1.67877469e-02f, 1.01927273e-01f, -4.24192213e-02f, -9.92451906e-02f, -8.31997767e-02f, 6.07350795e-03f, -9.71872061e-02f,
  -4.87431837e-03f, -1.05816357e-01f, 6.80781454e-02f, -8.19773227e-02f, 5.70737086e-02f, 5.10152942e-03f, -6.47393242e-02f, 1.20107353e-01f, -2.66585290e-03f, -2.28237193e-02f,
  6.11521862e-02f, -2.53277086e-02f, -3.49205732e-02f, -1.03487708e-01f, -1.05774924e-01f, 9.15914550e-02f, 6.75969720e-02f, 5.67458617e-03f, -1.01560161e-01f, -1.18502423e-01f,
  -7.65462220e-02f, 3.84566672e-02f, 9.78595987e-02f, -3.35309394e-02f, -4.54823971e-02f, 9.22973081e-03f, 3.16398218e-03f, -5.17011844e-02f, -1.98004488e-02f, -1.12036064e-01f,
  1.33488206e-02f, 8.41651857e-02f, 1.61851551e-02f, -1.19788319e-01f, 7.21972808e-02f, -1.16072454e-01f, 6.81059659e-02f, 8.96481648e-02f, -1.23545930e-01f, -2.54219119e-02f,
  6.14485368e-02f, -7.67066106e-02f, 8.61708000e-02f, -1.05996147e-01f, 1.37514144e-01f, 9.99076888e-02f, 5.46814762e-02f, 6.65272996e-02f, -5.10475375e-02f, -2.21457761e-02f,
  -1.38076186e-01f, -5.23625389e-02f, 2.88532046e-03f, 9.04952362e-02f, -6.17106371e-02f, 2.20506668e-01f, -2.49927510e-02f, 1.37036055e-01f, -9.30475444e-02f, 1.87396660e-01f,
  -1.31356776e-01f, 4.37202379e-02f, -5.12019591e-03f, 2.89813221e-01f, 1.59804389e-01f, -7.56842270e-02f, 4.48596515e-02f, 7.66185522e-02f, -7.97450021e-02f, 2.02798709e-01f,
  -2.44010873e-02f, 1.51686862e-01f, 4.13384847e-02f, 4.58012186e-02f, -1.04111955e-02f, -8.21598545e-02f, -1.14965998e-01f, 2.46277869e-01f, -3.12059075e-02f, -3.04818386e-03f,
  -1.28775416e-02f, 8.01550597e-02f, -2.13062558e-02f, 2.02741221e-01f, 1.06581368e-01f, 5.66096455e-02f, 6.95343688e-02f, 9.50359777e-02f, 1.03213511e-01f, -3.42349634e-02f,
  -2.07508326e-01f, -8.21274705e-03f, 3.60258892e-02f, -2.59826779e-02f, 3.98103967e-02f, -1.14196181e-01f, -5.26910983e-02f, -3.01440228e-02f, -8.81194174e-02f, 8.04858934e-03f,
  1.51826605e-01f, 1.19783267e-01f, 1.77686498e-01f, -1.11585274e-01f, -1.15687571e-01f, 7.69481063e-02f, -3.96391377e-02f, 1.06581457e-01f, 2.25825645e-02f, -3.09410319e-02f,
  6.15258217e-02f, -8.52144659e-02f, 1.39600903e-01f, 2.90089268e-02f, -8.57595876e-02f, 6.07371666e-02f, -7.04798624e-02f, -7.48709068e-02f, 3.32613513e-02f, -2.22568754e-02f,
  2.36335788e-02f, 9.90288407e-02f, -9.53326672e-02f, 1.26700282e-01f, 1.29427323e-02f, 2.17655435e-01f, 1.14545740e-01f, 4.72361445e-02f, 1.42683715e-01f, -9.02014435e-04f,
  4.60151536e-03f, -1.13698095e-01f, -5.94942681e-02f, -1.27527639e-01f, 1.21261537e-01f, -8.97117406e-02f, -6.63494989e-02f, 1.38834538e-02f, 6.42000064e-02f, -5.76039664e-02f,
  1.09939672e-01f, -1.10753924e-01f, 3.31562683e-02f, -1.50940781e-02f, -1.02607243e-01f, 1.46547019e-01f, 2.27562282e-02f, -1.15709864e-01f, 1.10228397e-01f, 1.67128053e-02f,
  -1.05111554e-01f, 1.80345073e-01f, 3.70304286e-02f, -7.71066621e-02f, -6.70781583e-02f, 1.50368854e-01f, 6.90519437e-02f, 1.21537380e-01f, 1.21243998e-01f, 7.60387480e-02f,
  1.13011472e-01f, 8.65264758e-02f, -3.91749591e-02f, 2.64153987e-01f, -2.44675577e-03f, -4.61459085e-02f, -2.33911760e-02f, -4.49284986e-02f, 6.48738667e-02f, 1.71455041e-01f,
  -2.77831238e-02f, -8.56882036e-02f, 8.54397286e-03f, 5.86342216e-02f, 7.61933923e-02f, 9.07531455e-02f, 1.10087417e-01f, -5.11460751e-02f, 1.04959002e-02f, -1.07522085e-01f,
  -9.98586938e-02f, -9.99555066e-02f, 1.01526931e-01f, -1.56408057e-01f, 1.02273166e-01f, -3.09589971e-02f, 9.97083075e-03f, 4.32142466e-02f, -4.21352461e-02f, -8.05429146e-02f,
  2.84399148e-02f, 2.13830888e-01f, -2.09433995e-02f, -2.62469873e-02f, -7.03357458e-02f, 1.74976602e-01f, -7.98554346e-02f, 6.03627525e-02f, 2.39812657e-02f, -4.70253527e-02f,
  4.05810662e-02f, 7.68168271e-03f, 1.18663937e-01f, -3.66804488e-02f, -1.25016943e-01f, 2.14083046e-01f, -1.55351639e-01f, 8.89477953e-02f, -1.13794193e-01f, 5.06036729e-02f,
  9.45433378e-02f, 1.10687017e-01f, -3.42052579e-02f, -1.94674032e-03f, -2.34630145e-02f, -6.45557642e-02f, 1.24560423e-01f, 5.52551225e-02f, -4.51345200e-04f, 8.25364590e-02f,
  -5.28729334e-02f, 3.59424651e-02f, 5.45253009e-02f, -1.35706946e-01f, 9.97012183e-02f, -6.57390356e-02f, 5.95501959e-02f, -8.58189315e-02f, 8.46141130e-02f, 9.06090587e-02f,
  7.68535733e-02f, 1.17829420e-01f, 1.01912156e-01f, -8.87263715e-02f, 1.14727758e-01f, -1.08203165e-01f, 2.08525658e-01f, 8.11340362e-02f, 4.48709168e-02f, 2.07566857e-01f,
  3.54612544e-02f, 1.77857623e-01f, 5.15224561e-02f, 6.17611371e-02f, -5.56754023e-02f, 1.70988962e-01f, -4.15478170e-01f, 2.22982660e-01f, 8.02206434e-03f, -5.30730523e-02f,
  1.15655430e-01f, 1.69348836e-01f, -4.31926036e-03f, 2.86676865e-02f, -2.63535627e-03f, 2.82664537e-01f, -3.47164609e-02f, -3.39220688e-02f, 2.09268272e-01f, 2.23477975e-01f,
  3.62475328e-02f, 1.24772415e-01f, 1.38648957e-01f, 2.20079005e-01f, -1.39626160e-01f, 2.21646816e-01f, -1.59016289e-02f, -1.12033278e-01f, 9.22794640e-02f, 6.45243749e-02f,
  1.21872135e-01f, 1.00657893e-02f, -3.36803086e-02f, 1.92813724e-01f, -1.01363011e-01f, 2.08534211e-01f, 1.91599965e-01f, 1.66125759e-01f, 5.89692853e-02f, -1.53903607e-02f,
  1.06645338e-02f, -5.62187806e-02f, 2.05153134e-03f, 4.15754989e-02f, 2.08496928e-01f, -1.44197136e-01f, 9.05481875e-02f, 1.61648899e-01f, -2.33529159e-03f, 7.95948505e-02f,
  -3.74393016e-02f, -2.00106606e-01f, 7.17389397e-03f, 1.34974986e-01f, 1.99319109e-01f, -7.87000731e-02f, 6.70684874e-02f, -7.99752325e-02f, 3.67009155e-02f, 1.35188341e-01f,
  1.57753974e-02f, 2.05090046e-01f, 5.82600087e-02f, -2.19829343e-02f, 1.66731104e-01f, 1.20675750e-01f, -7.07035065e-02f, -1.18618324e-01f, 2.05462798e-01f, -2.93338418e-01f,
  -1.15365647e-01f, 6.60697520e-02f, 1.13372311e-01f, -4.38384265e-02f, 1.31870180e-01f, 6.43344373e-02f, 3.52868140e-02f, 2.68276840e-01f, 1.77496701e-01f, 5.24662100e-02f,
  -4.75901216e-02f, 1.65867940e-01f, -7.60816317e-03f, -3.28953490e-02f, -1.10364184e-01f, -1.33162528e-01f, 4.11207438e-01f, 1.17064305e-01f, -5.07869609e-02f, 1.29358128e-01f,
  1.50460899e-01f, 1.17597722e-01f, -6.95138648e-02f, -8.46210942e-02f, -6.76560868e-03f, 1.10415377e-01f, -8.82746354e-02f, 2.46543497e-01f, 2.38853216e-01f, -7.31578171e-02f,
  2.64738742e-02f, -4.31530701e-04f, -5.87410405e-02f, 2.45766178e-01f, -8.44288617e-02f, -1.29542679e-01f, -3.28154340e-02f, 2.14998454e-01f, 7.36365616e-02f, 9.78033096e-02f,
  1.72846541e-01f, 1.65757969e-01f, 8.77031833e-02f, -1.08886421e-01f, -1.15367798e-02f, 3.69664818e-01f, -1.90048978e-01f, -2.39431083e-01f, 1.48402825e-01f, 4.64866422e-02f,
  4.79790103e-03f, 1.76054984e-01f, 1.70777306e-01f, 1.01039030e-01f, 1.43314168e-01f, 1.26381382e-01f, 1.06612742e-01f, 1.51243657e-01f, 1.36809707e-01f, 1.17396511e-01f,
  -1.50295064e-01f, -1.68718234e-01f, -7.56522939e-02f, -1.07386805e-01f, -3.52773890e-02f, 1.69092163e-01f, 1.42468184e-01f, -2.00995747e-02f, -2.05110423e-02f, 7.76105002e-02f,
  -3.93760242e-02f, 8.79327953e-02f, -9.23771784e-02f, 1.18980452e-01f, 2.63730567e-02f, -8.53945464e-02f, 1.56636372e-01f, -1.23050949e-02f, 1.01842232e-01f, -4.49615195e-02f,
  6.35952204e-02f, -8.56887773e-02f, 1.23909481e-01f, 3.44516002e-02f, 3.71416658e-02f, -4.98984456e-02f, -9.62363780e-02f, 4.65345345e-02f, -6.74789473e-02f, 1.67874366e-01f,
  -1.00400299e-01f, 4.47233804e-02f, -1.51071563e-01f, 8.66608769e-02f, -1.09667063e-01f, 2.53624190e-02f, -4.27609496e-02f, 9.73536074e-02f, 5.38753308e-02f, 2.41878331e-02f,
  -5.27529493e-02f, -5.56796864e-02f, 5.74324206e-02f, -5.70576712e-02f, -9.23800245e-02f, -2.40989891e-03f, -1.25022708e-02f, 3.80369788e-03f, 1.72129311e-02f, 2.07365915e-01f,
  -1.54339671e-01f, 1.11768842e-01f, 1.13972276e-01f, 1.60379842e-01f, -2.82466505e-02f, -3.41933332e-02f, 7.15441555e-02f, -7.65868947e-02f, 7.76654780e-02f, -2.00027716e-03f,
  4.65921015e-02f, 1.30851761e-01f, 6.48367107e-02f, 1.76042870e-01f, 1.19370192e-01f, 9.41675622e-03f, -1.41095951e-01f, 2.40246922e-01f, -1.26843140e-01f, -1.05345212e-01f,
  8.27410594e-02f, -1.31839037e-01f, -3.85675877e-02f, -8.90612695e-03f, 8.26081727e-03f, -1.42924771e-01f, 6.67202994e-02f, 1.44307055e-02f, -1.23678610e-01f, -1.32919818e-01f,
  -6.96742013e-02f, -6.87942430e-02f, 1.92750007e-01f, 7.60448799e-02f, -1.50109604e-01f, 4.23580557e-02f, -5.83111644e-02f, 6.40091300e-02f, -5.46546951e-02f, 3.59302387e-02f,
  2.98173316e-02f, -1.10601440e-01f, 3.51868957e-01f, 9.97322798e-02f, 2.69431740e-01f, -1.01180479e-01f, 6.90807849e-02f, -1.35832399e-01f, -1.10114314e-01f, 8.36662501e-02f,
  5.08826040e-02f, -7.99253359e-02f, 1.68944448e-01f, -4.94734533e-02f, 2.78837472e-01f, -9.24588814e-02f, 1.20465413e-01f, -1.05086565e-01f, -4.70647216e-02f, 6.27882108e-02f,
  1.70653075e-01f, 1.83213130e-01f, -1.23757198e-02f, 2.23028604e-02f, 6.35060435e-03f, 1.92855410e-02f, 7.10762441e-02f, 9.48252454e-02f, 1.49912732e-02f, -1.70722350e-01f,
  1.29720122e-01f, 1.41131267e-01f, 1.08078271e-01f, -1.38897924e-02f, 1.39493227e-01f, 2.12292802e-02f, 3.46607529e-02f, 2.29582623e-01f, 2.37873778e-01f, 1.71234667e-01f,
  2.40950108e-01f, 4.08861816e-01f, 6.60140216e-02f, -1.80582017e-01f, -3.45770046e-02f, 1.93835497e-01f, 6.52138814e-02f, -6.25440851e-02f, 5.12797013e-02f, -8.38840157e-02f,
  -3.43969949e-02f, -9.93093625e-02f, 6.91320673e-02f, 1.23175411e-02f, -1.78353786e-01f, 2.40833625e-01f, 1.10553592e-01f, 2.24172696e-02f, -2.63644326e-02f, 2.98492193e-01f,
  -1.28969029e-01f, 2.88975894e-01f, 7.97668248e-02f, -4.04661223e-02f, 3.69236887e-01f, 2.17366949e-01f, 3.88422400e-01f, -2.06366122e-01f, 1.18262663e-01f, 1.18687861e-01f,
  1.28291413e-01f, 8.63079801e-02f, 1.26306370e-01f, 1.14605017e-01f, 4.08002026e-02f, 2.61146843e-01f, -1.10776410e-01f, -4.21045683e-02f, 2.43006781e-01f, 3.39077823e-02f,
  1.26186535e-02f, 2.31992409e-01f, 1.78408444e-01f, -1.11089041e-03f, -9.18211266e-02f, 8.57825503e-02f, -5.35469763e-02f, 1.66076589e-02f, 2.94370353e-01f, 1.14689730e-01f,
  -2.09482774e-01f, -3.47862504e-02f, -3.75387929e-02f, -1.38476908e-01f, -5.41152991e-02f, 1.17371999e-01f, 1.46630377e-01f, 1.54566661e-01f, -4.54638228e-02f, -4.31577377e-02f,
  -1.14790604e-01f, -6.94763735e-02f, 2.87703574e-02f, 3.19920480e-02f, -1.23748988e-01f, -7.09608570e-02f, -6.29987121e-02f, -6.09047264e-02f, -7.84009546e-02f, 1.61859483e-01f,
  4.38071638e-02f, 1.57019004e-01f, 5.97420521e-02f, 5.93453599e-03f, -3.85684706e-02f, 5.00823446e-02f, -3.95202264e-02f, -5.42216152e-02f, -6.56180158e-02f, 2.03105196e-01f,
  6.83710799e-02f, -1.29706468e-02f, -1.45313084e-01f, 9.88799240e-03f, -8.38427842e-02f, -9.36060846e-02f, 7.77022168e-02f, -1.07053006e-02f, 1.18528783e-01f, 1.80444688e-01f,
  -8.03873390e-02f, -9.26447939e-03f, 1.33204818e-01f, -1.16584629e-01f, -8.50026086e-02f, 2.53380667e-02f, 2.13494990e-02f, -6.22380003e-02f, 1.57240644e-01f, -5.50879166e-02f,
  1.16592005e-01f, -6.85910583e-02f, 9.10306796e-02f, 5.62788174e-02f, -3.73196579e-03f, -5.99277765e-02f, 6.40467405e-02f, -1.13039903e-01f, 7.67676160e-02f, -1.08780101e-01f,
  2.33511254e-02f, -1.02897555e-01f, 8.65118727e-02f, 2.18235880e-01f, 1.48132399e-01f, -2.15595663e-02f, 1.33320406e-01f, -7.84073621e-02f, 9.03075039e-02f, 5.01975454e-02f,
  4.48471727e-03f, 1.38837054e-01f, -4.14180234e-02f, -1.48236817e-02f, 1.19979978e-01f, 1.13188997e-01f, -1.36153296e-01f, -1.63660899e-01f, -1.68938413e-02f, 5.23369201e-02f,
  1.80106387e-02f, 9.20124948e-02f, -5.56089496e-03f, 1.47400424e-02f, 1.72014199e-02f, 4.50043706e-03f, -1.06582344e-01f, -1.79770421e-02f, -1.27808318e-01f, 1.35868102e-01f,
  3.81269045e-02f, -2.55581774e-02f, 5.67484237e-02f, 1.81924134e-01f, 1.16662458e-01f, 1.05485409e-01f, -1.14397094e-01f, -4.72956477e-03f, -9.86003280e-02f, -1.14455566e-01f,
  -4.70557390e-03f, -7.33144907e-03f, 7.47274831e-02f, 7.97001868e-02f, -1.25263512e-01f, -6.34970814e-02f, 3.13130803e-02f, 2.48981677e-02f, -5.99419177e-02f, 1.50434598e-01f,
  -2.87029259e-02f, -4.81832400e-02f, -7.05469772e-02f, 1.04760095e-01f, -3.99755985e-02f, -5.96598983e-02f, -4.28590961e-02f, 3.28040719e-02f, -1.40772507e-01f, 9.87172574e-02f,
  -1.18245088e-01f, -1.20667115e-01f, -2.70607471e-02f, -7.83290267e-02f, 7.71175101e-02f, -7.66824931e-02f, 1.05291039e-01f, 5.24290130e-02f, -2.33655842e-03f, 1.62865520e-02f,
  2.02567987e-02f, -2.40436681e-02f, 1.30649626e-01f, -2.18917169e-02f, 6.38592094e-02f, 1.87037662e-01f, 6.63858876e-02f, -1.52430227e-02f, -7.17153847e-02f, 9.13738161e-02f,
  -4.25513051e-02f, -6.07584789e-02f, -8.39248598e-02f, 7.14265108e-02f, -2.08249211e-01f, -2.79228464e-02f, 8.82458761e-02f, -1.28320336e-01f, 1.03898428e-01f, 1.86670497e-01f,
  5.31028621e-02f, -5.20394817e-02f, 1.08728327e-01f, 1.57516412e-02f, 1.95383728e-01f, -9.43536535e-02f, 2.68288434e-01f, 2.62844539e-03f, 1.16448417e-01f, 5.43861650e-02f,
  1.96136072e-01f, 1.08363569e-01f, -1.07157588e-01f, 2.06456818e-02f, -2.85776611e-02f, -6.46456406e-02f, -6.22720942e-02f, 3.44547406e-02f, 1.29583225e-01f, -9.78585482e-02f,
  1.60808936e-01f, -3.12683098e-02f, 1.02458067e-01f, -9.20864753e-03f, 6.96716551e-03f, -5.07905185e-02f, -8.11685026e-02f, -2.05296441e-03f, 8.08794331e-03f, -1.08645961e-01f,
  -2.67335232e-02f, -1.01096697e-01f, 8.86815339e-02f, -1.04848549e-01f, 4.72944323e-03f, 7.86818340e-02f, 1.77621171e-01f, 1.86038688e-02f, 5.72284982e-02f, -1.27942190e-01f,
  -1.66394543e-02f, -5.69310002e-02f, 1.79654822e-01f, -1.10883504e-01f, 1.04463451e-01f, 2.41256095e-02f, -6.12630248e-02f, -4.15286571e-02f, 1.13246121e-01f, 6.89269453e-02f,
  1.22942723e-01f, -4.92279939e-02f, 5.43215824e-03f, -4.02672067e-02f, 4.24870476e-02f, 1.60577714e-01f, 6.96876496e-02f, -1.25476364e-02f, -1.02539271e-01f, 3.16748470e-02f,
  4.21456881e-02f, -1.15363404e-01f, 6.69264570e-02f, 1.05785280e-01f, 7.73457736e-02f, 1.05458118e-01f, -4.46675904e-02f, 1.15224995e-01f, 3.72410528e-02f, -8.71774554e-02f,
  -2.75041871e-02f, 8.28292891e-02f, -4.98335175e-02f, -4.20114910e-03f, 1.31407201e-01f, -1.02782987e-01f, 3.42716899e-04f, -8.73634517e-02f, 2.99507063e-02f, 1.61667578e-02f,
  8.69301260e-02f, -6.77555054e-02f, -5.30719571e-02f, 1.37919197e-02f, -1.01738639e-01f, 5.39156981e-02f, 1.00076869e-01f, -1.57083068e-02f, 4.47777174e-02f, -6.41451925e-02f,
  -6.41606003e-02f, -5.66496402e-02f, 1.31509811e-01f, -4.87691909e-02f, -8.71018618e-02f, 5.10205775e-02f, 6.03622869e-02f, 2.39605680e-02f, 3.40981148e-02f, -5.27846143e-02f,
  3.98197025e-02f, 8.20095930e-03f, -1.11483775e-01f, -9.83936787e-02f, 5.19229798e-03f, -7.33703151e-02f, 1.32812217e-01f, -3.72071899e-02f, -9.54554649e-04f, 1.34457007e-01f,
  1.04723305e-01f, -4.53391410e-02f, 2.51011439e-02f, 6.63349181e-02f, 1.68149069e-01f, 5.06120175e-02f, 1.38104290e-01f, -1.82119012e-02f, 5.01909740e-02f, 1.69308204e-02f,
  9.23835188e-02f, 9.25960615e-02f, -4.25767414e-02f, -2.11271755e-02f, 1.07682697e-01f, -1.08314574e-01f, -7.16643035e-02f, 5.94870336e-02f, 6.32362440e-02f, -1.32055774e-01f,
  5.65050207e-02f, 3.87510061e-02f, -5.64121865e-02f, -1.03164889e-01f, 3.03219259e-02f, 4.26781997e-02f, 4.00809348e-02f, 1.24382585e-01f, 5.98129965e-02f, -8.34785774e-02f,
  1.07095927e-01f, 1.45976007e-01f, 2.72417031e-02f, -1.13610357e-01f, 4.58033383e-02f, 1.68168247e-01f, -1.38246819e-01f, 1.23103179e-01f, -1.10998508e-02f, 1.24548882e-01f,
  4.97849882e-02f, 4.06869911e-02f, -9.15243998e-02f, 9.45362225e-02f, 5.55072688e-02f, -7.91914091e-02f, 8.01147521e-03f, -1.91637687e-02f, -9.71017182e-02f, -1.65530376e-03f,
  1.30175471e-01f, -1.23587623e-01f, -3.79678165e-03f, 7.03975037e-02f, 9.51416790e-02f, -3.47921951e-03f, 5.42385131e-02f, 8.86148959e-02f, -2.43281685e-02f, 5.22848666e-02f,
  -1.22628860e-01f, 1.34318089e-02f, -9.64479446e-02f, -1.08862579e-01f, 6.78122416e-02f, 2.11116895e-02f, 9.31612402e-02f, 9.16102082e-02f, -2.42746696e-02f, 1.49184167e-01f,
  -5.00566363e-02f, 1.47153111e-02f, -1.30471876e-02f, -9.41712223e-03f, -1.39289051e-01f, 2.46590711e-02f, -2.01777041e-01f, 2.11625963e-01f, -5.24586700e-02f, -8.37422609e-02f,
  9.71296504e-02f, 2.11509794e-01f, -3.44653726e-02f, 9.39415619e-02f, 7.83786252e-02f, 1.09616846e-01f, 2.13808054e-03f, 2.53838021e-02f, 1.27267867e-01f, -7.88075104e-02f,
  1.85691670e-01f, 1.19591527e-01f, -6.30497709e-02f, 5.94498590e-02f, -8.02308728e-04f, 6.14709817e-02f, -1.21140875e-01f, 5.00463806e-02f, 5.08157760e-02f, -1.77482851e-02f,
  -1.64590273e-02f, -1.66954808e-02f, 1.23867162e-01f, -7.22748414e-02f, -1.32638872e-01f, -5.21993376e-02f, -8.36071000e-02f, 7.63752311e-02f, -1.70432311e-02f, -8.93959254e-02f,
  -2.43188813e-02f, -7.97330514e-02f, 2.06467696e-02f, -3.03429533e-02f, -2.79887822e-02f, -6.27833828e-02f, -1.52916238e-02f, -8.04630741e-02f, 1.24218658e-01f, 1.30571306e-01f,
  -8.49345699e-02f, -6.60961494e-02f, 1.24793023e-01f, 2.98312288e-02f, 1.17319390e-01f, -1.07407376e-01f, -6.05968647e-02f, 5.04789911e-02f, 1.31959751e-01f, -1.20132148e-01f,
  -1.09921709e-01f, 8.56401697e-02f, -8.36647153e-02f, -9.75741968e-02f, 1.25986770e-01f, -6.05617277e-02f, -1.17866755e-01f, 1.15605280e-01f, 2.27322895e-02f, 9.30585861e-02f,
  -5.30284196e-02f, -8.38732719e-02f, -8.86408910e-02f, -4.28543538e-02f, 4.05621901e-02f, -1.25017807e-01f, 4.69453931e-02f, -7.75709599e-02f, -2.03842893e-02f, 9.38808098e-02f,
  -8.40934366e-02f, -8.14855993e-02f, 5.26330769e-02f, -3.65214869e-02f, 7.61996210e-02f, 1.06075063e-01f, -1.19550824e-01f, 1.64738875e-02f, -1.00574307e-01f, 3.08600813e-02f,
  -1.20303616e-01f, 4.83263172e-02f, 5.68488464e-02f, 7.34698325e-02f, 5.33149727e-02f, 5.84679395e-02f, -1.64499748e-02f, 1.42697260e-01f, 3.60118076e-02f, 9.18352678e-02f,
  8.35306123e-02f, -9.56127942e-02f, 6.23550750e-02f, -3.62410396e-02f, -7.11190477e-02f, -1.26828058e-02f, -7.99537301e-02f, 9.09294635e-02f, 1.75854880e-02f, -6.90708458e-02f,
  8.40330198e-02f, -7.02294260e-02f, -1.99374314e-02f, -9.58960652e-02f, 1.20155871e-01f, -1.05371512e-01f, -1.58196520e-02f, -9.68698636e-02f, 1.76477730e-02f, -1.14886321e-01f,
  3.56608182e-02f, -1.06238522e-01f, 5.92611358e-02f, -1.11426316e-01f, -1.07495658e-01f, -1.05189934e-01f, 4.87877987e-02f, -1.18223295e-01f, 4.20357287e-02f, -1.15962431e-01f,
  6.11888319e-02f, -2.15724539e-02f, 8.12003836e-02f, 1.27779081e-01f, -4.20178846e-02f, -1.26553714e-01f, -4.40111123e-02f, -1.07437000e-01f, -7.73762539e-02f, 4.49554063e-02f,
  -7.13184699e-02f, -1.18934877e-01f, -4.19583991e-02f, -1.86754800e-02f, -1.23430893e-01f, -4.42667902e-02f, 1.20437212e-01f, 1.61556546e-02f, -1.95489898e-02f, -5.16009107e-02f,
  5.42213209e-02f, -3.81042692e-03f, -4.28100042e-02f, 7.96528831e-02f, 1.05449200e-01f, 1.73701327e-02f, 6.97712153e-02f, -1.19685993e-01f, -9.82824117e-02f, 9.85570028e-02f,
  5.34282140e-02f, -1.17842704e-01f, 1.29453823e-01f, -7.85369873e-02f, -6.62878975e-02f, 4.77813296e-02f, 1.65026337e-02f, -1.07423984e-01f, -5.90692423e-02f, 4.85212468e-02f,
  1.21725492e-01f, 4.35511163e-03f, 7.67380595e-02f, 6.98434487e-02f, -1.09986044e-01f, -1.13188721e-01f, -9.94880050e-02f, 2.62170509e-02f, -3.16284858e-02f, -3.52416150e-02f,
  -1.01096444e-01f, 6.64056540e-02f, -9.85274017e-02f, -1.24201447e-01f, 1.11514576e-01f, 5.51194698e-02f, -9.68147367e-02f, 6.18798360e-02f, -4.64401096e-02f, -1.03503704e-01f,
  4.41499241e-02f, 1.35966614e-01f, -1.09912157e-01f, 5.20436652e-02f, -5.21273315e-02f, 5.06543964e-02f, -6.91687018e-02f, -3.84013169e-03f, 5.31389043e-02f, -7.11246431e-02f,
  -1.15392856e-01f, 1.44501373e-01f, 5.71518764e-02f, 9.93316621e-02f, -4.81456593e-02f, 1.10493619e-02f, -9.97538939e-02f, -4.94464003e-02f, 1.58508793e-02f, -1.15178511e-01f,
  -6.49102172e-03f, 4.96793427e-02f, 8.28774124e-02f, 3.10572051e-02f, -1.58905443e-02f, 9.58862975e-02f, -8.42035487e-02f, 8.70850012e-02f, -5.14020445e-03f, -6.02113083e-02f,
  1.65937617e-02f, 9.84596740e-03f, 1.10915221e-01f, -8.31334293e-02f, 1.02054724e-03f, 1.02015985e-02f, 4.65216413e-02f, -1.64065827e-02f, 1.14148542e-01f, -9.72970650e-02f,
  5.53252436e-02f, -7.30193630e-02f, -8.02597478e-02f, -8.44789378e-04f, 1.75425082e-01f, -6.23895563e-02f, 5.67683317e-02f, 1.67774513e-01f, 4.17562090e-02f, 7.43505284e-02f,
  1.36379842e-02f, -2.70101111e-02f, 2.28776596e-02f, -5.46222627e-02f, -1.66035239e-02f, 2.74560950e-03f, -2.94501297e-02f, -1.07024960e-01f, 9.52242240e-02f, -4.92336862e-02f,
  7.97155127e-02f, 1.12240560e-01f, 1.77863589e-03f, 1.38871521e-01f, -4.37460020e-02f, 7.00502023e-02f, 7.24226981e-02f, 1.39615819e-01f, 5.96656278e-03f, 1.67500541e-01f,
  -1.62947759e-01f, 5.09859920e-02f, -7.66511336e-02f, 6.40471354e-02f, 4.80063111e-02f, -9.44856852e-02f, 1.53768780e-02f, 1.13013878e-01f, 9.92861856e-03f, -9.16768014e-02f,
  -9.98075530e-02f, -1.24155916e-01f, 9.37329456e-02f, -1.17181316e-01f, -1.34347528e-01f, -3.35985906e-02f, 1.54171631e-01f, -5.13605587e-02f, 4.75145616e-02f, 1.09007451e-04f,
  2.40314733e-02f, -1.79632362e-02f, -4.82035540e-02f, 1.54183567e-01f, 1.72581652e-03f, -8.26233551e-02f, 2.04868376e-01f, -5.21864109e-02f, 1.31868422e-01f, 8.18327144e-02f,
  -3.29743959e-02f, -1.33560717e-01f, -8.49466026e-02f, 9.00300592e-02f, 2.23593507e-02f, -9.09706205e-02f, 1.15037046e-01f, 1.38572752e-01f, 1.21617459e-01f, 6.78955615e-02f,
  1.96361914e-01f, -3.25856321e-02f, 4.75984737e-02f, -9.91276205e-02f, -7.61661753e-02f, 1.17299691e-01f, 2.01290497e-03f, 1.19969033e-01f, -8.03662688e-02f, -6.06887080e-02f,
  -5.52508645e-02f, 1.27054140e-01f, -7.14029595e-02f, -9.48872939e-02f, -9.89111140e-02f, 7.40939453e-02f, 6.79328963e-02f, 1.38507530e-01f, 6.27988428e-02f, 1.41315952e-01f,
  7.97382742e-02f, 1.67507127e-01f, 7.37329870e-02f, 2.31421322e-01f, 1.34656787e-01f, 1.69944596e-02f, -1.07307136e-01f, 4.54182411e-03f, -5.25990278e-02f, 1.34249166e-01f,
  -4.27053496e-02f, -1.48036316e-01f, -4.95055355e-02f, 1.88773572e-01f, 4.57571968e-02f, -1.08802766e-01f, 6.26042709e-02f, 9.75993201e-02f, -6.98774904e-02f, -7.83620924e-02f,
  1.17724515e-01f, -8.54185969e-02f, 1.01600088e-01f, 1.67628109e-01f, 8.23729336e-02f, -2.73046885e-02f, -1.25955157e-02f, 1.21410685e-02f, 2.08597928e-01f, -1.18087813e-01f,
  3.13230634e-01f, -1.04751162e-01f, 1.63848713e-01f, -6.55416697e-02f, 1.05014831e-01f, -5.31288758e-02f, 8.39805603e-02f, -5.60893789e-02f, 8.19283351e-02f, 5.60629889e-02f,
  1.11588679e-01f, -1.78905185e-02f, 2.28832722e-01f, -3.91123071e-02f, 1.38803661e-01f, 2.32250392e-01f, -2.56830994e-02f, 6.16479963e-02f, -4.40606847e-02f, 1.53585449e-01f,
  3.89560685e-02f, -3.16359252e-02f, 1.52323484e-01f, -1.05733790e-01f, -1.21887781e-01f, -1.16626889e-01f, 8.18078518e-02f, 9.79048107e-03f, 1.65644258e-01f, 7.95093849e-02f,
  1.75344069e-02f, 1.03116907e-01f, -3.54779959e-02f, -1.05111614e-01f, -4.82933894e-02f, -7.10358769e-02f, 3.93139236e-02f, -1.22263648e-01f, 1.20110549e-01f, -5.03963269e-02f,
  5.74983805e-02f, 9.82904434e-02f, 4.99990918e-02f, 5.25828786e-02f, -5.17881438e-02f, -2.28888653e-02f, 4.60675508e-02f, -6.68257922e-02f, -1.00894652e-01f, -2.41188910e-02f,
  7.77356401e-02f, 1.13948237e-03f, -2.16631982e-02f, 4.63747466e-03f, 5.05908346e-03f, -3.17852534e-02f, -9.90903676e-02f, -5.92393018e-02f, 3.66005749e-02f, 3.87652800e-03f,
  7.68287107e-02f, 1.06704652e-01f, -1.02733165e-01f, -3.11519671e-02f, -8.58835578e-02f, -9.39294696e-02f, -1.20920181e-01f, 1.75420679e-02f, 1.13476343e-01f, 7.58031197e-03f,
  1.20243691e-01f, 2.45170556e-02f, -7.93625265e-02f, 9.93294567e-02f, 6.01723865e-02f, 6.13800921e-02f, -8.30970332e-02f, -1.77389160e-02f, -1.10736229e-01f, 6.45192116e-02f,
  1.02319792e-01f, -6.05227947e-02f, 3.00666299e-02f, 1.43194403e-02f, -1.23779185e-03f, 4.06202525e-02f, 9.93243307e-02f, -9.10195112e-02f, 6.04298618e-03f, -6.29486665e-02f,
  -5.92670813e-02f, -3.51404883e-02f, -1.49448281e-02f, -7.86758140e-02f, -7.33167902e-02f, -6.10141940e-02f, -2.70925704e-02f, 9.28202048e-02f, 4.68652174e-02f, 1.45158216e-01f,
  6.09536730e-02f, 6.45056292e-02f, 1.24799266e-01f, -1.83655992e-01f, 8.63141418e-02f, 1.16468832e-01f, 1.29438818e-01f, 7.69397393e-02f, 1.14532776e-01f, -1.03039876e-01f,
  8.42139050e-02f, 2.06583798e-01f, -1.02184393e-01f, -1.12342216e-01f, -8.60579684e-02f, 7.80443698e-02f, 2.51770075e-02f, 8.20106640e-02f, -1.08393803e-01f, -3.98292616e-02f,
  1.67485282e-01f, -3.11371312e-02f, -5.93413971e-03f, 1.95478901e-01f, 1.90201942e-02f, -8.20724964e-02f, 4.62171920e-02f, 2.98349094e-02f, -9.02332086e-03f, 4.07389440e-02f,
  5.72358109e-02f, -7.53564388e-02f, 6.05881065e-02f, -8.77364352e-02f, -7.00923875e-02f, 8.92156363e-02f, 8.58940780e-02f, 2.50865966e-01f, 2.78154407e-02f, 8.43393654e-02f,
  5.67456670e-02f, 5.83642535e-02f, 3.28335576e-02f, 8.35002810e-02f, -7.47440308e-02f, -1.05796695e-01f, 9.28270668e-02f, -1.16346337e-01f, -7.70745054e-02f, 2.40899101e-01f,
  5.40531017e-02f, -9.66219082e-02f, -4.06559445e-02f, -9.32573751e-02f, 1.02950767e-01f, 4.59533855e-02f, -4.92903814e-02f, 1.76759213e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 52)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 52;
const float L1_fan_Bp_bar_data[] = {
  2.13548169e-01f, -1.15033992e-01f, 7.22956210e-02f, 4.90439460e-02f, -1.36602774e-01f, 7.25463554e-02f, 7.26903006e-02f, 1.05721451e-01f, 1.22097265e-02f, -3.71858180e-02f,
  4.95467521e-02f, 3.19859223e-03f, 1.89296231e-01f, 7.03232884e-02f, 1.83580831e-01f, 9.50267911e-02f, 2.06592217e-01f, 1.67276025e-01f, -1.38695911e-02f, -3.37154679e-02f,
  2.71171689e-01f, 1.22734375e-01f, -6.71828464e-02f, 6.18364550e-02f, 1.14069663e-01f, 4.76033054e-02f, 1.62654683e-01f, -3.80556174e-02f, 1.14442110e-01f, 8.89357701e-02f,
  -8.21696818e-02f, -1.25706764e-02f, 1.34256527e-01f, 2.02843994e-01f, 2.63573766e-01f, 5.79868704e-02f, 2.21990615e-01f, 1.54020861e-01f, 1.22426152e-01f, 1.26711205e-01f,
  6.09147958e-02f, 1.62678629e-01f, 1.16962351e-01f, 2.61846371e-02f, 1.46273136e-01f, -9.80102122e-02f, 3.78706865e-02f, 3.96784693e-02f, 7.57445097e-02f, -2.15887725e-02f,
  -8.16841945e-02f, 4.86239642e-02f
};

// L2_fan_Wp (Shape: 6 x 64)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  1.29041955e-01f, -1.60304699e-02f, -9.54495072e-02f, -3.61230671e-02f, 4.83780913e-02f, -9.41525996e-02f, -7.11112544e-02f, 1.54341400e-01f, 9.17832647e-03f, -1.21353656e-01f,
  8.71855244e-02f, 1.60688818e-01f, 1.96924016e-01f, 1.01354837e-01f, 1.98061898e-01f, 4.58182022e-02f, -1.74654517e-02f, -3.31649445e-02f, 6.94909617e-02f, -1.29745215e-01f,
  -1.02932103e-01f, -1.02422059e-01f, -2.28359643e-02f, 1.29790362e-02f, -1.38815477e-01f, -9.72386450e-02f, 8.89095739e-02f, -1.32836625e-01f, -3.28236297e-02f, -6.78694919e-02f,
  -4.37330129e-03f, 2.13824302e-01f, 1.40171582e-02f, 6.47753105e-02f, -3.36665884e-02f, -1.36890620e-01f, 4.87283766e-02f, 7.49356393e-03f, -1.11679643e-01f, -6.95123598e-02f,
  1.16472542e-01f, 1.55464904e-02f, -1.68803297e-02f, -4.18544523e-02f, 5.63119687e-02f, 8.72929487e-03f, -8.15302730e-02f, 2.51008630e-01f, -4.04511169e-02f, -1.12162381e-01f,
  -2.06029207e-01f, -7.45050311e-02f, -1.09266773e-01f, 8.74500200e-02f, 2.09890958e-02f, -6.66046217e-02f, 3.23405936e-02f, 9.27133039e-02f, -5.29639535e-02f, -9.60680321e-02f,
  -8.86294842e-02f, -3.72048616e-02f, -9.26188454e-02f, -4.27936539e-02f, 4.15952988e-02f, 3.83326411e-02f, 7.51811117e-02f, -1.27796486e-01f, -1.34209275e-01f, 2.17401870e-02f,
  -2.51154780e-01f, 1.10844910e-01f, -1.89864248e-01f, -4.78668921e-02f, -6.46526739e-02f, -6.09667674e-02f, 6.60156608e-02f, 1.15127780e-01f, 1.80082053e-01f, -6.32093474e-03f,
  -6.43709451e-02f, 1.34243080e-02f, -8.38630274e-02f, -1.02573507e-01f, 1.38894811e-01f, 3.64148011e-03f, 4.82365377e-02f, 6.53844401e-02f, -8.55275989e-03f, 6.10995293e-02f,
  6.18199222e-02f, -1.53300306e-02f, -4.46194634e-02f, -2.39766359e-01f, -1.12400763e-01f, 6.81023225e-02f, -5.46962544e-02f, -1.05222844e-01f, 6.32625967e-02f, 4.88000456e-03f,
  -2.38965675e-02f, 5.32818064e-02f, -8.35825596e-03f, -5.68801872e-02f, -3.90917435e-03f, -1.53142065e-01f, 1.18242495e-01f, -4.21979986e-02f, -1.00480067e-02f, -1.24276750e-01f,
  -1.43371582e-01f, 1.03302650e-01f, -6.55500591e-02f, 2.13143140e-01f, 4.72393408e-02f, 2.28683967e-02f, -9.23595279e-02f, -1.92912687e-02f, 1.23886816e-01f, -1.07161917e-01f,
  6.66707754e-02f, -1.05422705e-01f, -1.48118557e-02f, -4.78174761e-02f, 8.76595527e-02f, 6.46541864e-02f, 8.13111737e-02f, 1.14297561e-01f, 4.10968214e-02f, 5.28031215e-02f,
  -4.97081801e-02f, 2.38911882e-02f, 1.07728234e-02f, 1.27317071e-01f, -1.37705013e-01f, -8.91105831e-02f, -1.44684881e-01f, -1.76597834e-01f, -4.27916041e-03f, -1.51167750e-01f,
  -5.69850169e-02f, -2.96006370e-02f, 2.43356153e-02f, 4.60552424e-02f, -8.83510336e-02f, 8.20263997e-02f, -7.98406526e-02f, 9.36266258e-02f, 1.92610770e-01f, -1.04320027e-01f,
  1.66270062e-02f, 2.39013974e-02f, -1.15224369e-01f, -1.08762488e-01f, 7.25683346e-02f, 5.73084503e-02f, -2.84456764e-03f, 3.72190550e-02f, 1.57485120e-02f, -1.26196131e-01f,
  -1.77371845e-01f, 1.01578504e-01f, -3.41937393e-02f, 1.46979941e-02f, 1.92588091e-01f, 1.11704186e-01f, 1.46085858e-01f, -1.97017491e-01f, -3.34288739e-02f, 1.62226170e-01f,
  -5.49848489e-02f, 1.67249795e-02f, 2.81512421e-02f, -3.90675431e-03f, -2.36908063e-01f, -1.33963645e-01f, 3.54254059e-02f, 5.61077669e-02f, 1.82712182e-01f, -7.78607428e-02f,
  5.90606034e-03f, 3.63684036e-02f, -1.74108446e-01f, -6.14662319e-02f, -1.65644921e-02f, 5.05935960e-03f, 1.17845364e-01f, 7.50003234e-02f, 1.07849650e-02f, 5.16159013e-02f,
  4.40837368e-02f, 1.03799529e-01f, -2.26890184e-02f, -1.11749545e-01f, 2.10167319e-02f, 7.14471415e-02f, 1.19455941e-02f, -1.25687554e-01f, -6.01672046e-02f, 1.86535016e-01f,
  -1.93786129e-01f, 9.27565061e-03f, -3.42615508e-02f, -2.00682767e-02f, 1.92621559e-01f, -8.12443793e-02f, 5.77095486e-02f, -1.15470275e-01f, 1.01436660e-01f, -4.17462774e-02f,
  -2.34852210e-02f, -5.19910343e-02f, 8.37943181e-02f, 2.08477583e-02f, -9.61409435e-02f, 3.88308465e-02f, -4.06211317e-02f, 8.51867124e-02f, 1.51947066e-01f, 1.13824241e-01f,
  -2.62069348e-02f, -5.51103093e-02f, 1.25934064e-01f, 2.95977890e-01f, -1.26932979e-01f, 2.39671320e-02f, 4.17636037e-02f, 2.25672107e-02f, 1.17252901e-01f, 3.54466327e-02f,
  2.38873094e-01f, -7.49915913e-02f, 3.33480015e-02f, 2.85066701e-02f, 5.40276356e-02f, -1.59392506e-01f, 8.35825056e-02f, 9.27063897e-02f, -1.52568847e-01f, -2.08675396e-02f,
  6.92668110e-02f, -1.28460368e-02f, -1.37648433e-01f, -8.18142146e-02f, 3.30012594e-03f, -1.95849761e-01f, 5.44474497e-02f, -1.15508862e-01f, 2.57081795e-03f, 6.21067397e-02f,
  -7.51142437e-03f, 5.30904122e-02f, 3.73108089e-02f, -6.78982809e-02f, 1.18120141e-01f, -1.24717645e-01f, -9.32062324e-03f, -6.62504956e-02f, -1.45814698e-02f, -4.34738696e-02f,
  -1.13455623e-01f, -2.88551375e-02f, -1.86621189e-01f, 1.08956330e-01f, -1.13614954e-01f, 3.66228372e-02f, -1.44695714e-01f, -8.65890384e-02f, 7.43973777e-02f, -1.23094320e-01f,
  1.16738558e-01f, -4.22951579e-02f, 9.59761813e-02f, -4.21777032e-02f, 9.42768902e-02f, -1.78089306e-01f, 1.42176554e-01f, -6.27357364e-02f, -8.30095820e-03f, -1.34961694e-01f,
  -1.14751831e-02f, 9.32831392e-02f, 9.59390551e-02f, 8.42159521e-03f, -1.67133540e-01f, -4.79709804e-02f, 7.46430084e-02f, 1.28429741e-01f, -8.11167136e-02f, -1.07217118e-01f,
  1.75208077e-01f, -6.82527944e-02f, -1.57949388e-01f, 9.86399725e-02f, 1.75615698e-01f, 2.80517023e-02f, 4.38825972e-02f, -2.34746840e-02f, -5.86946495e-03f, -1.18373506e-01f,
  9.11096409e-02f, 2.61965189e-02f, -9.68324393e-02f, -1.09831698e-03f, 1.37165999e-02f, -1.66719362e-01f, 8.25508386e-02f, 9.54794046e-03f, -1.33465705e-02f, -8.00549239e-02f,
  2.52472404e-02f, -6.38509169e-02f, -7.13424683e-02f, -4.98929173e-02f, 1.65666023e-03f, 8.62667859e-02f, -1.36059299e-01f, 2.12949011e-02f, 1.92887392e-02f, 1.16117544e-01f,
  -2.98632961e-02f, 1.40779940e-02f, -1.15815647e-01f, -1.24796934e-01f, -1.96287569e-04f, 3.79663482e-02f, -9.91029665e-02f, 2.14846998e-01f, 1.14585862e-01f, -2.86045186e-02f,
  -1.31650567e-01f, -6.05543936e-03f, 1.63789615e-01f, -3.38946171e-02f, 1.36871859e-01f, -1.54861748e-01f, -5.01489155e-02f, 4.18136194e-02f, 3.74301802e-03f, -1.97677448e-01f,
  -8.39928612e-02f, 8.46697241e-02f, 3.28686601e-03f, -4.17650975e-02f, -1.71953872e-01f, 2.81587504e-02f, -5.03171608e-02f, -6.14470094e-02f, 1.66499734e-01f, -9.40773115e-02f,
  9.45949480e-02f, 2.00000837e-01f, -7.65373036e-02f, 9.67215076e-02f, -1.11688944e-02f, 3.44008650e-03f, 7.31739178e-02f, -8.74000788e-02f, 2.28937998e-01f, -1.21545553e-01f,
  -1.12981021e-01f, -3.95469256e-02f, -8.95747617e-02f, 1.33421747e-02f, 1.29451394e-01f, 1.53685696e-02f, -5.58891408e-02f, 1.11002348e-01f, 1.56808030e-02f, -5.27544972e-03f,
  -2.69532412e-01f, -3.26920040e-02f, -1.28715396e-01f, -7.92087018e-02f, 8.77719223e-02f, -1.85901836e-01f, 2.77384259e-02f, 4.00335863e-02f, 7.30759427e-02f, 6.25954568e-03f,
  1.33698389e-01f, 1.16894364e-01f, -9.37006995e-02f, 5.18926866e-02f
};

// L2_fan_Wp_bar (Shape: 52 x 64)
const int L2_fan_Wp_bar_rows = 52;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  5.44457547e-02f, -3.71528305e-02f, 6.66213408e-02f, 1.44034341e-01f, 1.21564038e-01f, 1.45028606e-01f, -2.32030600e-02f, 3.13104615e-02f, 9.65518057e-02f, 8.30934271e-02f,
  4.36516926e-02f, -1.55781597e-01f, -1.86516868e-03f, -6.34744689e-02f, -6.58046976e-02f, -1.04806401e-01f, -1.99295767e-02f, 4.87201996e-02f, 1.27252871e-02f, -2.37547960e-02f,
  2.04208001e-01f, 4.89471573e-03f, -1.18008040e-01f, -3.03342957e-02f, -2.01870166e-02f, -1.08450510e-01f, 3.96468639e-02f, 6.22372031e-02f, 3.31399947e-01f, 1.37616754e-01f,
  4.00340669e-02f, -9.01084319e-02f, 1.02104999e-01f, -1.46539763e-01f, 2.24037707e-01f, 1.27761811e-01f, -1.01142734e-01f, -1.48949966e-01f, 6.96072951e-02f, -4.80980836e-02f,
  9.26492661e-02f, 1.35927796e-01f, 1.04510166e-01f, 1.41795471e-01f, -9.55421627e-02f, 3.34823243e-02f, 2.24811062e-01f, -1.96487024e-01f, 5.34530263e-03f, 1.35297045e-01f,
  1.92551330e-01f, 1.75799847e-01f, 5.77345416e-02f, 2.22017482e-01f, 1.36412337e-01f, -2.88794991e-02f, 2.37722546e-01f, 9.66432095e-02f, -7.31085688e-02f, 1.54501513e-01f,
  -5.93480952e-02f, 2.34887749e-03f, -1.68467779e-02f, -1.54871866e-01f, -1.24299392e-01f, 1.12372927e-01f, 4.55117710e-02f, -2.86559761e-02f, -7.75728747e-02f, -6.55104965e-02f,
  1.16678476e-01f, -7.79373869e-02f, -7.14799622e-03f, 1.92130476e-01f, 3.26245606e-01f, -4.97790538e-02f, 4.80637513e-02f, -1.05686851e-01f, 1.37396753e-01f, 3.26452702e-01f,
  -1.08383551e-01f, -2.08639540e-02f, 5.89675792e-02f, 1.04508907e-01f, 4.95095477e-02f, 2.96784774e-03f, 6.38095587e-02f, 9.68217328e-02f, 3.09574991e-01f, 1.40794262e-01f,
  -1.57420978e-01f, -7.85322264e-02f, -3.35324138e-01f, 1.49728239e-01f, 5.81244528e-02f, -1.28367797e-01f, 2.29677111e-01f, 1.23718232e-01f, -1.54406661e-02f, 1.15378782e-01f,
  -1.21509723e-01f, 2.31261954e-01f, -8.24973881e-02f, 1.15393862e-01f, -3.83215658e-02f, 3.42128873e-02f, 4.93738204e-02f, 1.67704448e-01f, 3.49133499e-02f, 9.23333392e-02f,
  1.40593261e-01f, 1.62011385e-01f, -8.42793062e-02f, -1.93934999e-02f, 3.72502208e-01f, -1.33563995e-01f, -5.62773719e-02f, -2.12054074e-01f, -5.25204800e-02f, 2.32141893e-02f,
  6.69527287e-03f, 2.43326742e-02f, 1.03987865e-01f, -5.30867986e-02f, -2.02955142e-01f, 7.85908028e-02f, 5.51486500e-02f, 1.60103261e-01f, -1.06763221e-01f, -1.91656537e-02f,
  4.27164808e-02f, -4.06578332e-02f, -3.03136762e-02f, -7.46511072e-02f, 3.11555061e-02f, 9.62274969e-02f, 6.86072633e-02f, -2.73974314e-02f, 2.73813456e-02f, -6.31476417e-02f,
  -4.23056819e-02f, -7.17991516e-02f, -8.87075365e-02f, 3.45374132e-03f, -1.22267619e-01f, -1.22146774e-02f, -1.01466671e-01f, -4.49497215e-02f, 2.36317925e-02f, 1.54481465e-02f,
  -7.28828460e-02f, 4.55725603e-02f, 8.61727074e-02f, -4.53475714e-02f, 1.74522568e-02f, 2.09988784e-02f, 5.45428917e-02f, -7.13972300e-02f, 6.71000481e-02f, 1.15473285e-01f,
  -9.09084827e-02f, -3.15439217e-02f, -1.32326568e-02f, 7.12381005e-02f, 5.34913018e-02f, 6.03567660e-02f, -1.04483902e-01f, 1.34120271e-01f, -2.71022841e-02f, 8.12357217e-02f,
  7.67573938e-02f, -1.15174815e-01f, 5.14877203e-04f, 6.51680753e-02f, -1.75233018e-02f, -1.36956936e-02f, -9.42700263e-03f, -2.29405388e-02f, -7.00900927e-02f, 6.89918175e-02f,
  -2.56459713e-02f, 1.20149560e-01f, -1.00210514e-02f, -1.08161017e-01f, -8.73893648e-02f, -8.97776783e-02f, -9.05693546e-02f, 7.13240206e-02f, 2.69220285e-02f, -2.66266130e-02f,
  -4.39468771e-02f, 3.81283462e-02f, 1.40929176e-02f, -1.20304048e-01f, 1.58770345e-02f, 9.06352606e-03f, -1.28815636e-01f, -5.74308969e-02f, -6.91695698e-03f, 8.76116753e-02f,
  1.37362238e-02f, -8.91146809e-02f, 2.86779851e-02f, 9.78254378e-02f, -1.32946000e-02f, 1.13336578e-01f, 7.90164471e-02f, 2.03344077e-02f, -7.29696173e-03f, -1.07346177e-02f,
  7.73110166e-02f, -8.92801210e-02f, 9.44439620e-02f, -1.90784205e-02f, 1.11699343e-01f, -1.74490046e-02f, 9.09722075e-02f, -1.38527155e-01f, -7.13973343e-02f, 2.35605538e-02f,
  -1.36119770e-02f, -1.39752045e-01f, -5.15215881e-02f, -2.75684614e-02f, 2.01949794e-02f, -5.77047467e-02f, 8.90948251e-02f, -2.98050009e-02f, 6.36764914e-02f, 4.58354922e-03f,
  2.84020286e-02f, -7.37781003e-02f, -1.82078034e-02f, -1.25776589e-01f, -3.74454036e-02f, 1.10713653e-01f, 3.78484726e-02f, -7.44693652e-02f, -3.14838961e-02f, -7.22982511e-02f,
  2.03105733e-02f, -4.55805957e-02f, 7.76341408e-02f, 7.89678171e-02f, 5.48455007e-02f, -8.27151909e-02f, -7.69828632e-02f, 2.62646396e-02f, 2.41276976e-02f, 4.65963874e-03f,
  -3.85920294e-02f, 2.28357259e-02f, -2.11787932e-02f, 8.64689499e-02f, 4.49862108e-02f, -6.24578595e-02f, 2.14799959e-02f, -2.91381963e-02f, -2.41320655e-02f, 3.23075764e-02f,
  -2.56370641e-02f, 1.02716371e-01f, -6.24320395e-02f, 4.56516194e-04f, -8.05480853e-02f, 1.17785066e-01f, 9.96677801e-02f, -6.80607334e-02f, -6.74319745e-04f, -7.88862258e-03f,
  -7.46076107e-02f, -6.86021522e-02f, -7.34835789e-02f, 1.13956675e-01f, 1.45690471e-01f, -2.26491280e-02f, 1.17576897e-01f, -1.24508776e-02f, 1.15635633e-01f, -6.14301860e-02f,
  -1.73778236e-02f, 9.41380113e-02f, -3.32116149e-02f, 1.06446691e-01f, 7.27756768e-02f, 1.31273001e-01f, -1.40247002e-01f, -1.02408782e-01f, 1.96816131e-01f, 4.84103896e-02f,
  -2.58592516e-02f, -3.79888564e-02f, 5.20912558e-02f, 1.06959820e-01f, -6.86367378e-02f, 7.12676644e-02f, -2.31473651e-02f, -9.70097929e-02f, 1.11734718e-01f, -5.43877594e-02f,
  8.87122601e-02f, 2.62885913e-02f, 2.07881883e-01f, -5.64531311e-02f, -5.84129579e-02f, -2.20782869e-02f, 1.08540416e-01f, 1.33021437e-02f, -4.30794954e-02f, 1.40582412e-01f,
  -3.84992398e-02f, -2.42292173e-02f, 1.20955333e-01f, -1.07994303e-02f, -8.60949308e-02f, -1.07300945e-01f, -9.68099087e-02f, -5.76602994e-03f, -4.62388732e-02f, 4.10797559e-02f,
  6.64513931e-02f, 1.20750397e-01f, -4.85501699e-02f, -5.26440516e-02f, -4.67914939e-02f, -7.75947645e-02f, -3.54927629e-02f, -7.74774030e-02f, 3.49923931e-02f, -7.70318732e-02f,
  -4.64785770e-02f, -1.44740222e-02f, 1.26681954e-01f, 2.69938484e-02f, 6.09457493e-02f, 2.17541277e-01f, -3.05118989e-02f, 9.61107165e-02f, -4.45471108e-02f, 1.33090571e-01f,
  1.79064311e-02f, -1.19782120e-01f, 6.27787411e-03f, 4.66970131e-02f, 5.33528253e-02f, -3.52047682e-02f, -2.19088700e-02f, -4.10342924e-02f, -1.14234775e-01f, 2.60471608e-02f,
  -1.25135958e-01f, 1.14850931e-01f, 3.88482735e-02f, -8.20923522e-02f, -8.18142369e-02f, 1.82654671e-02f, 4.39465828e-02f, 1.90020844e-01f, -1.54226512e-01f, 1.02986336e-01f,
  -9.20893922e-02f, -1.54773951e-01f, 7.38695487e-02f, 5.06266654e-02f, 4.94881421e-02f, 2.88563855e-02f, -2.81474702e-02f, 1.27913564e-01f, 4.55641709e-02f, -4.36144136e-02f,
  2.02968225e-01f, -1.16675064e-01f, -1.01763226e-01f, 3.41866282e-03f, -2.94700731e-02f, -6.58026710e-02f, -1.21702932e-01f, -1.59587320e-02f, 1.94602720e-02f, 1.11659966e-01f,
  1.26564786e-01f, 5.82777485e-02f, 7.32903853e-02f, -4.86879982e-02f, -5.60652725e-02f, 5.47249019e-02f, 1.37560263e-01f, -4.01586257e-02f, 8.83557573e-02f, 1.32219493e-01f,
  -9.24789831e-02f, 8.71034339e-02f, 7.12926388e-02f, -1.02662966e-01f, -5.10589294e-02f, 5.96932806e-02f, 2.18612999e-01f, 1.06237791e-01f, 1.89632252e-01f, 9.98883918e-02f,
  -1.03925362e-01f, -1.01396099e-01f, 9.19031575e-02f, 4.43333685e-02f, -1.16945868e-02f, 1.17215678e-01f, -4.87849563e-02f, 4.00467440e-02f, -1.29171371e-01f, -7.31664151e-02f,
  1.22932270e-01f, -7.76230097e-02f, 2.02263184e-02f, -1.42107561e-01f, -1.13999233e-01f, 6.85639307e-02f, 1.92841396e-01f, -2.03110911e-02f, 2.85948068e-02f, -2.21030731e-02f,
  -1.15539141e-01f, 3.62758599e-02f, -1.17259026e-01f, -7.96119776e-03f, -6.49616048e-02f, -1.28602669e-01f, 5.09257428e-02f, 7.61212409e-02f, 1.94826379e-01f, -3.93627137e-02f,
  -6.13924228e-02f, 2.89035201e-01f, 6.62991330e-02f, 5.34536317e-02f, -4.93288413e-02f, 6.55650422e-02f, -1.41429827e-01f, -5.67312166e-02f, 9.10645798e-02f, -8.67300257e-02f,
  1.02121241e-01f, -8.85673091e-02f, -6.09278083e-02f, 7.86211416e-02f, 1.58039406e-01f, 1.64111182e-01f, 1.11458868e-01f, 1.76138386e-01f, 7.93208256e-02f, 1.60190964e-03f,
  -4.98943329e-02f, 5.09303287e-02f, 2.99386643e-02f, -1.11422338e-01f, 4.45718579e-02f, -8.72389525e-02f, -1.23232426e-02f, -6.35705665e-02f, -3.37725924e-03f, -8.85310024e-02f,
  -9.40079708e-03f, 6.51051551e-02f, -1.08079769e-01f, 1.07103705e-01f, 9.49006677e-02f, 8.47660527e-02f, -7.32658757e-03f, -8.29121023e-02f, -2.59480886e-02f, 6.88795596e-02f,
  7.59679228e-02f, 1.26042292e-01f, -2.76045427e-02f, 3.53996158e-02f, 1.53437220e-02f, 5.37125859e-03f, 3.68302828e-03f, -7.16914684e-02f, 7.02788383e-02f, 3.01111620e-02f,
  -6.10445254e-03f, 2.26230230e-02f, 1.17739560e-02f, 2.31517777e-02f, 1.05874762e-01f, 6.68201828e-04f, 1.03630595e-01f, 4.93257642e-02f, 2.35940013e-02f, -8.76606479e-02f,
  7.38956854e-02f, 8.38530958e-02f, -5.34830615e-02f, -6.53650314e-02f, -2.61949133e-02f, 3.85615751e-02f, -8.47045407e-02f, 4.15110514e-02f, -1.68990400e-02f, -1.16674706e-01f,
  4.53735404e-02f, 4.76858690e-02f, -7.52327964e-04f, -2.63392162e-02f, -2.55301665e-03f, 2.28662323e-02f, -1.13148294e-01f, 3.73494029e-02f, -7.90380985e-02f, -3.88166979e-02f,
  8.11336786e-02f, -1.10468604e-02f, 1.07548639e-01f, 1.47613779e-01f, 7.98343271e-02f, 5.81356883e-02f, -2.55157729e-03f, 1.18495330e-01f, 1.55726120e-01f, 4.32222616e-03f,
  1.37552470e-01f, 2.09604442e-01f, -3.35148983e-02f, -2.15549581e-02f, 2.15809211e-01f, 7.32893571e-02f, -9.39297825e-02f, -9.87867266e-02f, 1.16742902e-01f, 1.75920576e-02f,
  -6.35889068e-04f, -5.95704129e-04f, -5.90265989e-02f, -9.71760005e-02f, -9.42709297e-02f, 1.53934611e-02f, 2.21284442e-02f, -2.94067524e-02f, 5.52007817e-02f, -7.75899813e-02f,
  -8.49059038e-03f, -1.87991336e-02f, -3.23487595e-02f, 1.93850294e-01f, 1.40481040e-01f, 4.86042500e-02f, -6.61531985e-02f, -1.21309750e-01f, -1.32546768e-01f, 1.58897340e-02f,
  -1.76131688e-02f, 1.35448113e-01f, 1.96955219e-01f, 6.66917935e-02f, -1.02750979e-01f, 2.24860609e-01f, 1.17773388e-03f, -8.19456130e-02f, 1.51807144e-01f, 6.96544498e-02f,
  1.16213724e-01f, -1.94446310e-01f, -9.36589092e-02f, -5.87481074e-02f, 5.30667491e-02f, -2.98758335e-02f, 7.19538406e-02f, -2.48165559e-02f, -2.81855855e-02f, 1.05878534e-02f,
  -4.34724195e-03f, -7.11154863e-02f, -1.61957771e-01f, -8.14430639e-02f, -7.13799372e-02f, 6.99672922e-02f, 1.82725877e-01f, 1.20077446e-01f, 6.84155747e-02f, 1.00940622e-01f,
  1.06352001e-01f, 1.52840853e-01f, -1.44185945e-01f, 8.37252066e-02f, 5.57541847e-02f, -1.31154601e-02f, 1.06740091e-02f, 1.78421382e-02f, -3.06379218e-02f, 7.86833540e-02f,
  1.53657719e-01f, 1.48486132e-02f, 4.13780287e-02f, 5.52730486e-02f, 7.18763396e-02f, 8.33095834e-02f, -1.39205873e-01f, 1.27479106e-01f, -1.16239198e-01f, -9.89889279e-02f,
  1.27155125e-01f, 4.23451029e-02f, -1.70872480e-01f, 6.34546727e-02f, 2.08226129e-01f, 8.44305828e-02f, -1.19652197e-01f, -3.69854793e-02f, 1.17337452e-02f, 4.77383062e-02f,
  1.32458240e-01f, -7.62373954e-02f, -8.22882354e-02f, -9.95598882e-02f, -1.85740873e-01f, -7.93147907e-02f, -3.68465558e-02f, -1.02492392e-01f, -8.35542530e-02f, -1.38650700e-01f,
  5.53097762e-02f, -7.74364322e-02f, -4.55799513e-03f, 7.27885514e-02f, 3.58227437e-04f, 1.64291516e-01f, 3.12578641e-02f, -2.72808522e-02f, -1.09614007e-01f, 8.97265412e-03f,
  -4.58693802e-02f, -2.26328485e-02f, -2.01020092e-02f, -1.48338666e-02f, -5.28705381e-02f, -1.93390790e-02f, 1.14910379e-01f, 2.36126170e-01f, 5.41131943e-02f, -3.97691652e-02f,
  -1.08432509e-01f, -1.19226806e-01f, -1.12117738e-01f, 1.23634927e-01f, 1.33468844e-02f, 1.24281526e-01f, 8.57907608e-02f, -1.06531397e-01f, -1.58483768e-03f, 5.10263443e-02f,
  -8.46228227e-02f, -4.60478961e-02f, -8.55459943e-02f, 2.86374483e-02f, -6.22022599e-02f, -7.60780424e-02f, 1.01685181e-01f, -8.74863341e-02f, -7.35230744e-02f, 2.38856003e-02f,
  1.16217919e-01f, 7.60442913e-02f, -5.84639311e-02f, -1.19784512e-02f, -3.90689448e-02f, -2.79361475e-02f, -2.12614774e-03f, 9.41953659e-02f, -6.46702945e-02f, 7.74191320e-02f,
  -1.02816122e-02f, 1.19345672e-02f, -4.28077020e-02f, -4.54824567e-02f, -6.41652793e-02f, 4.66764420e-02f, -9.43118632e-02f, -1.18446067e-01f, -1.90317743e-02f, -4.88369614e-02f,
  2.53072456e-02f, 6.68635890e-02f, -4.44555469e-02f, 3.09873670e-02f, -5.81102856e-02f, -4.03456874e-02f, -5.53210638e-02f, -8.25240985e-02f, -6.24215901e-02f, -7.54234940e-02f,
  -8.88159648e-02f, 6.45810217e-02f, -1.13410115e-01f, -1.13323003e-01f, 2.86362041e-03f, 3.88007835e-02f, 4.85170912e-03f, 1.19535714e-01f, 1.93635486e-02f, 4.03554775e-02f,
  -4.71736640e-02f, -6.95398524e-02f, -6.26863390e-02f, -1.82203315e-02f, 9.18511376e-02f, -1.04440404e-02f, 1.05658598e-01f, 1.15332544e-01f, -1.08984280e-02f, 9.47506577e-02f,
  1.18160360e-01f, 1.11311175e-01f, -2.54058093e-01f, -1.88697055e-01f, 2.95649737e-01f, 7.80301690e-02f, -1.06188372e-01f, -6.56070113e-02f, 3.10204085e-02f, 1.03828562e-02f,
  9.70446914e-02f, -4.84044626e-02f, -9.40719396e-02f, 1.27052799e-01f, 2.46264338e-01f, -1.01750642e-01f, 1.20206520e-01f, 9.46194157e-02f, -5.46445027e-02f, -1.24287624e-02f,
  -5.92333265e-02f, 1.13189951e-01f, 1.37582690e-01f, -6.22513853e-02f, -1.04290217e-01f, 1.18904375e-01f, -8.36202502e-02f, 3.39587638e-03f, 1.17436819e-01f, -1.92098841e-02f,
  2.04841897e-01f, 2.49939486e-01f, 1.51681819e-03f, 9.08878818e-02f, -9.23366472e-02f, -1.37716815e-01f, -1.21851824e-02f, -1.62707288e-02f, 3.69544402e-02f, 1.33144721e-01f,
  8.78351033e-02f, -1.13468662e-01f, -1.60462707e-01f, 2.40361303e-01f, 1.70401022e-01f, -8.67184997e-02f, 8.46698582e-02f, -2.40313709e-02f, 1.06109239e-01f, 9.05750915e-02f,
  -7.65511692e-02f, -6.55983090e-02f, 6.06441386e-02f, 7.21352994e-02f, 1.20592982e-01f, 9.19393972e-02f, 4.91444804e-02f, -5.89691997e-02f, 1.67782843e-01f, 2.77815968e-01f,
  1.83078930e-01f, 1.93513244e-01f, -3.19080986e-02f, 1.17313646e-01f, -7.64826089e-02f, 2.77844798e-02f, 3.29719126e-01f, -2.27934681e-02f, -1.57176837e-01f, 1.89579334e-02f,
  2.51362503e-01f, 1.31452173e-01f, 1.50109798e-01f, 4.93286289e-02f, 1.04188047e-01f, -5.63929789e-02f, 4.60187579e-03f, 2.42377177e-01f, -2.57245719e-01f, 8.03787932e-02f,
  -8.02962184e-02f, -2.00811811e-02f, 9.70344245e-02f, -1.19338587e-01f, 2.00863723e-02f, 2.97909696e-02f, 1.74492449e-01f, -2.93837249e-01f, -1.57246917e-01f, -2.12697536e-02f,
  4.95116413e-01f, 1.94199607e-01f, -1.00160226e-01f, -1.46800324e-01f, -1.22024752e-01f, 1.17902004e-03f, -1.32093146e-01f, 1.95191965e-01f, 1.78693831e-01f, 5.00798188e-02f,
  5.68091199e-02f, 5.15130572e-02f, 2.33301327e-01f, 7.52808377e-02f, 3.56091052e-01f, 4.89749968e-01f, 2.35935956e-01f, 4.73452210e-02f, -3.04688424e-01f, 8.61140713e-02f,
  -1.18327783e-02f, 2.90072024e-01f, 2.08647236e-01f, 4.19448502e-03f, 1.93035737e-01f, 9.35841128e-02f, -3.96201946e-02f, -8.61553848e-02f, 9.77939814e-02f, -3.12964618e-02f,
  -3.30622979e-02f, 1.11296766e-01f, -1.15419887e-01f, -1.90191828e-02f, 8.81826803e-02f, -6.47464097e-02f, -5.76660298e-02f, 4.41888161e-02f, -4.34276946e-02f, -5.77356480e-02f,
  2.82310788e-02f, -3.49870585e-02f, -4.94808257e-02f, -1.09640621e-01f, -6.94242641e-02f, 2.23664436e-02f, -1.08234018e-01f, 2.35970840e-02f, 1.17049128e-01f, -7.22146034e-02f,
  2.35132203e-02f, 2.50274166e-02f, -2.31285915e-02f, -1.20356314e-01f, 6.64499924e-02f, 5.17401844e-02f, 6.65111318e-02f, -7.32221603e-02f, -1.21413141e-01f, 5.49746153e-04f,
  -4.52853478e-02f, -5.66162430e-02f, 4.72536385e-02f, 3.33169661e-02f, -7.63764679e-02f, 3.89656797e-02f, -2.09798757e-02f, 8.93423185e-02f, -9.75768715e-02f, 9.13268887e-03f,
  3.26929949e-02f, -3.82487699e-02f, 2.49846503e-02f, 9.83138382e-02f, 1.27582587e-02f, -6.06546737e-03f, -3.06500066e-02f, -8.73333737e-02f, -4.38933112e-02f, -5.71780726e-02f,
  4.44788076e-02f, -3.56463008e-02f, -7.02378377e-02f, -4.00415100e-02f, 4.81562316e-02f, -4.20332737e-02f, 8.21515694e-02f, 8.84482916e-03f, 1.50680793e-02f, 1.01369154e-03f,
  2.27954760e-02f, -3.93014774e-03f, 3.96329835e-02f, 1.68241542e-02f, 6.27832413e-02f, 1.21482551e-01f, -1.79620087e-02f, -9.39441696e-02f, -1.12560287e-01f, -1.13297440e-01f,
  2.54462641e-02f, 3.12506258e-02f, 1.23759665e-01f, 4.42955159e-02f, -8.60619545e-02f, 1.91377044e-01f, -5.12810498e-02f, 5.13136461e-02f, -4.64490540e-02f, 2.95400061e-02f,
  -1.78430632e-01f, 6.45937175e-02f, -4.77187186e-02f, -5.86671904e-02f, -4.31013629e-02f, 1.16453335e-01f, 1.50529444e-01f, -9.41846799e-03f, -1.25743434e-01f, -7.14224055e-02f,
  1.03311203e-01f, 5.46681061e-02f, -8.93723518e-02f, -7.73932710e-02f, -1.25464559e-01f, 9.94198769e-02f, -7.99646880e-03f, -5.68311550e-02f, -7.29340594e-03f, 5.14056943e-02f,
  1.49740338e-01f, 2.06740629e-02f, -1.82354674e-01f, 3.52131738e-03f, -3.05785667e-02f, 4.95468788e-02f, -3.09468582e-02f, 1.06645904e-01f, 6.64577335e-02f, 2.12210327e-01f,
  1.14485892e-02f, 7.96167552e-02f, 1.14150234e-01f, -6.09505549e-03f, -7.58809149e-02f, -2.99518593e-02f, 2.09326133e-01f, 1.57173842e-01f, 5.31235263e-02f, 9.46447700e-02f,
  -1.07644103e-01f, -1.60682425e-01f, 3.05986479e-02f, -1.15041234e-01f, -2.66437768e-03f, 1.05956696e-01f, -1.51861086e-01f, 5.62206469e-02f, -6.00149073e-02f, 3.64387350e-04f,
  -1.33103039e-02f, 8.17960724e-02f, -7.93853328e-02f, 8.81822128e-03f, -4.10776287e-02f, -6.35263994e-02f, -1.14070466e-02f, -4.38111313e-02f, -2.85880100e-02f, -3.38354595e-02f,
  1.09522477e-01f, 1.16811402e-01f, 3.42531741e-01f, 6.68663979e-02f, 4.30168360e-01f, 2.37427413e-01f, -7.00059310e-02f, 1.15477011e-01f, 7.98624530e-02f, -1.29638448e-01f,
  1.75835118e-02f, 5.81182428e-02f, 2.60173585e-02f, 2.24393964e-01f, 6.28354326e-02f, 7.79159218e-02f, 1.79499358e-01f, -1.00139186e-01f, -1.95955157e-01f, -2.17430200e-03f,
  2.17557713e-01f, 4.35151309e-01f, 1.31903201e-01f, -4.29523513e-02f, -3.10311373e-02f, 8.56345221e-02f, 1.12900488e-01f, 3.44528973e-01f, 1.32379651e-01f, 1.97006702e-01f,
  -1.23093352e-01f, 1.12052739e-01f, -1.17418036e-01f, 2.29578074e-02f, 2.06024870e-01f, 1.36455849e-01f, -8.64794999e-02f, 4.44786638e-01f, 1.56398326e-01f, -1.51454195e-01f,
  -4.72159646e-02f, -1.03458323e-01f, -1.34433270e-01f, -1.59462139e-01f, -1.14596738e-02f, 3.77232730e-02f, -1.12530939e-01f, 4.51375097e-02f, 9.42333862e-02f, -1.38380602e-01f,
  4.61449809e-02f, 7.45189711e-02f, -2.82304958e-02f, 4.19817343e-02f, -6.06550276e-02f, 7.74845332e-02f, -1.08931370e-01f, -1.08820312e-01f, 4.96934056e-02f, -1.28861777e-02f,
  1.95318207e-01f, -6.63220733e-02f, -1.04211785e-01f, 8.46943259e-02f, 2.48079255e-01f, 3.99416387e-02f, -1.66234016e-01f, 9.70834941e-02f, -9.99032557e-02f, 5.33030629e-02f,
  -1.10611834e-01f, 5.35135493e-02f, 1.10374741e-01f, 1.05186529e-01f, 1.04282826e-01f, 1.53145939e-02f, 6.84912801e-02f, 9.58108529e-02f, -1.72564725e-03f, 1.32696167e-01f,
  1.32546052e-01f, -1.22247264e-02f, -7.55198300e-02f, 3.04080844e-01f, 1.06861696e-01f, 1.59667507e-01f, -3.99753600e-02f, -4.82813045e-02f, 1.34416074e-01f, 6.18154183e-02f,
  1.56123340e-01f, 1.46897361e-01f, 2.05624908e-01f, 1.98935606e-02f, -1.43387821e-03f, -2.90225470e-03f, 8.52379389e-03f, 8.33181664e-02f, -7.37972036e-02f, 1.94622979e-01f,
  7.99870938e-02f, -1.59273148e-01f, 8.35909918e-02f, 3.15830857e-02f, 1.72035933e-01f, 1.28330484e-01f, 1.77183419e-01f, 3.67783196e-02f, 1.77957769e-02f, 9.97639075e-02f,
  1.41577777e-02f, -1.11072361e-01f, -5.95443808e-02f, 3.34651321e-02f, -1.29394820e-02f, -1.56717777e-01f, -7.14199841e-02f, -1.46379927e-02f, -6.42222688e-02f, 5.99676743e-02f,
  -9.61309522e-02f, -1.13594197e-01f, -3.92752849e-02f, 8.88402387e-02f, -1.15672961e-01f, 7.48542175e-02f, -1.33783258e-02f, -4.14087512e-02f, -7.72601739e-02f, 4.02668566e-02f,
  -1.21932076e-02f, -3.94353867e-02f, -8.12089443e-02f, 3.90210487e-02f, 9.55405086e-02f, 3.79252769e-02f, -7.04490840e-02f, 1.06602823e-02f, -1.21263247e-02f, -1.05104595e-01f,
  1.18431868e-02f, 8.60437080e-02f, 2.21091378e-02f, 1.19155921e-01f, 3.00151296e-02f, -8.24005008e-02f, -9.93508380e-03f, -2.72390917e-02f, 6.36798739e-02f, -5.38598467e-03f,
  -7.65926912e-02f, 6.76995665e-02f, 2.89479848e-02f, 5.13209635e-03f, -5.00196330e-02f, -5.78147136e-02f, -6.37763878e-03f, 5.59634808e-03f, -4.70966510e-02f, -9.06617939e-02f,
  -3.73555049e-02f, -6.67363182e-02f, 9.77337640e-03f, 9.49901640e-02f, 1.09439217e-01f, -7.61969611e-02f, -9.60433334e-02f, 6.01422675e-02f, -3.92025970e-02f, -7.08916113e-02f,
  -6.40922934e-02f, 1.07132390e-01f, -9.46976542e-02f, -1.12074807e-01f, -5.48223555e-02f, -2.69288365e-02f, 5.56082278e-02f, -5.90205565e-03f, -5.94317261e-03f, 2.33335905e-02f,
  6.21876419e-02f, -7.14026913e-02f, 3.21191140e-02f, -8.08419064e-02f, -1.39621571e-01f, 7.97549114e-02f, 7.63661563e-02f, -8.08682814e-02f, -4.59837914e-02f, -1.36601686e-01f,
  6.64395541e-02f, 5.61418124e-02f, -5.83582222e-02f, 1.74295790e-02f, -6.59086928e-03f, 1.12242050e-01f, 1.19114913e-01f, 4.85994704e-02f, 1.04619376e-01f, 4.31361534e-02f,
  -1.73783656e-02f, -1.10162094e-01f, 8.87481198e-02f, 7.41711631e-02f, 8.03330317e-02f, 6.26565889e-02f, 1.45960778e-01f, 4.93276156e-02f, -9.94665623e-02f, -3.07695940e-02f,
  -1.92858309e-01f, 6.05772212e-02f, -1.02473378e-01f, -1.29867494e-01f, 1.48833618e-01f, -6.27415627e-02f, -4.91760857e-02f, -5.08104414e-02f, 6.46404997e-02f, 8.27792436e-02f,
  -4.66384776e-02f, -2.34395005e-02f, -1.23141289e-01f, -8.86669159e-02f, -1.12734646e-01f, 6.15214333e-02f, 7.32065737e-02f, -8.54532942e-02f, -1.12211719e-01f, 6.07236326e-02f,
  1.25812441e-01f, -5.32794446e-02f, 5.90854092e-03f, 9.36922804e-02f, 1.57738850e-02f, 5.82924262e-02f, -1.33771747e-01f, -9.85231772e-02f, 1.48397414e-02f, -4.30878215e-02f,
  6.76028952e-02f, 1.68054830e-02f, 7.63964653e-02f, 4.19533290e-02f, 1.13425575e-01f, -7.52881393e-02f, 1.56840861e-01f, 2.32150748e-01f, 2.57362276e-01f, 8.46759155e-02f,
  4.39541377e-02f, 1.53944373e-01f, 1.08716421e-01f, -1.01312131e-01f, 1.55075625e-01f, 5.31012043e-02f, 1.70240521e-01f, 1.45135775e-01f, 1.21873327e-01f, 6.30702004e-02f,
  8.33468419e-03f, 3.21732461e-01f, -9.16192755e-02f, 6.26256391e-02f, -3.01576387e-02f, 2.83712238e-01f, -2.53294855e-02f, 9.99700427e-02f, -6.54403958e-03f, 1.81114465e-01f,
  1.16831824e-01f, 4.51543145e-02f, -1.71415880e-01f, 1.81066673e-02f, 1.52608112e-01f, -1.55437499e-01f, -2.10925564e-01f, -1.33362651e-01f, 3.15286070e-01f, 6.66203797e-02f,
  -1.12148501e-01f, 7.89021403e-02f, -3.88621837e-02f, 1.43007770e-01f, -1.69613257e-01f, -3.38887237e-02f, 1.28686473e-01f, -2.25858629e-01f, -7.75560439e-02f, -1.14121526e-01f,
  -3.71640362e-02f, -2.42151623e-03f, 3.53875577e-01f, 1.85028240e-01f, 6.61773011e-02f, -2.53574867e-02f, 2.55395651e-01f, -1.62814662e-01f, -1.22742146e-01f, 6.20481335e-02f,
  1.62771299e-01f, 1.35137424e-01f, 2.77229939e-02f, -4.93110530e-03f, -1.14768930e-01f, 2.42011230e-02f, -3.83907855e-02f, 1.61775172e-01f, -1.02921166e-02f, 8.77637416e-02f,
  4.96461093e-02f, 1.41611457e-01f, 1.96469799e-01f, 5.06035499e-02f, -2.01299619e-02f, 3.33978422e-02f, -1.55889347e-01f, -1.28021032e-01f, -2.14305460e-01f, -1.57961667e-01f,
  -1.65121660e-01f, -1.93100929e-01f, -2.67549902e-02f, -2.98217162e-02f, 1.84049308e-01f, 1.02381684e-01f, -6.14706427e-02f, 5.21881394e-02f, 1.02052100e-01f, 2.30831400e-01f,
  2.20160231e-01f, -9.89011005e-02f, 5.41249104e-02f, 9.45322290e-02f, -4.78402823e-02f, -9.70988497e-02f, -1.18557401e-01f, 8.00610557e-02f, -8.14513583e-03f, -3.86127718e-02f,
  -6.27430379e-02f, -2.55765051e-01f, -4.10216115e-02f, -9.03398618e-02f, -5.94117306e-02f, 7.41052106e-02f, 1.88924700e-01f, 1.13384828e-01f, -8.88168663e-02f, -1.07090831e-01f,
  1.43722326e-01f, -1.23894759e-01f, 7.11186081e-02f, -1.02141008e-01f, 7.68406168e-02f, -2.86893863e-02f, 6.78634793e-02f, -5.29014245e-02f, -1.73469052e-01f, 2.94324905e-01f,
  4.43867415e-01f, -2.21144184e-02f, 4.24796641e-02f, -8.88593495e-02f, 8.95493403e-02f, 5.38953170e-02f, -6.03675693e-02f, -1.10221386e-01f, 1.21276177e-01f, -5.88479340e-02f,
  1.31879583e-01f, 2.91171461e-01f, -1.10698156e-01f, -7.24160485e-03f, -3.02539468e-02f, -4.97091487e-02f, -6.52188733e-02f, -1.01508245e-01f, -5.38902059e-02f, 5.94933890e-02f,
  7.93857053e-02f, -5.76791652e-02f, 1.94945559e-01f, -5.24237752e-02f, 3.46616209e-02f, 7.42942616e-02f, 4.99113183e-03f, 9.54335630e-02f, 1.54782057e-01f, -1.96994711e-02f,
  2.21678205e-02f, -4.64092530e-02f, 1.03930913e-01f, 2.15751231e-02f, -1.33845612e-01f, 6.86259270e-02f, -1.39028570e-02f, -1.20190851e-01f, -1.22498646e-01f, -9.75862378e-04f,
  3.74626033e-02f, -1.89682581e-02f, 3.05205397e-02f, 5.78054227e-02f, -2.08714418e-02f, 6.33976310e-02f, 2.04196334e-01f, -4.35824431e-02f, 1.03590250e-01f, -8.42972398e-02f,
  -1.25174418e-01f, -9.41213295e-02f, 6.00624606e-02f, -8.74020755e-02f, 9.85512361e-02f, 1.00009546e-01f, 8.71723518e-02f, 4.79260795e-02f, 6.36207610e-02f, -6.03051223e-02f,
  8.26377347e-02f, 1.19753592e-01f, 1.46173701e-01f, -1.24784693e-01f, -4.59382422e-02f, -6.93148673e-02f, 7.29945153e-02f, 1.59450874e-01f, -4.57828417e-02f, 9.77755561e-02f,
  4.43728045e-02f, 9.08777956e-03f, -1.98790170e-02f, 9.62782428e-02f, -8.94857198e-02f, -5.92634529e-02f, 2.54653464e-03f, -6.14807233e-02f, -3.63272913e-02f, 2.39228737e-02f,
  5.29832765e-02f, -9.28236917e-02f, -9.23904479e-02f, -1.18450336e-01f, 2.51393411e-02f, 8.56029913e-02f, -4.66322154e-02f, -4.08361247e-03f, 3.12318746e-02f, 6.49476573e-02f,
  -1.20340683e-01f, 3.67389396e-02f, 5.55762798e-02f, 3.14673521e-02f, 1.01818696e-01f, 1.11003987e-01f, -6.53759539e-02f, -1.01280950e-01f, 8.60415399e-02f, -9.54366326e-02f,
  -3.75450850e-02f, 2.92970520e-03f, -6.27086759e-02f, 1.12562664e-01f, 4.77939136e-02f, -8.60247239e-02f, -7.16264546e-02f, 8.69885180e-03f, 6.54701144e-02f, 4.60399054e-02f,
  -6.94883913e-02f, -2.91684195e-02f, -2.27854284e-03f, -4.82140630e-02f, 1.11127272e-01f, -5.00004254e-02f, 5.45788594e-02f, 6.54978752e-02f, -6.37593120e-02f, -1.28380105e-01f,
  -9.82496440e-02f, 3.38765676e-03f, -1.25247598e-01f, -9.61151272e-02f, -4.88228956e-03f, 9.66340154e-02f, 7.67467171e-02f, -9.15897489e-02f, 6.23289682e-02f, 6.81108460e-02f,
  -8.46415311e-02f, 9.99653414e-02f, -4.52628965e-03f, 7.72153810e-02f, -1.16583146e-01f, -3.23464349e-03f, 1.96054690e-02f, 7.91106373e-03f, -7.14690983e-03f, 2.79516280e-02f,
  -1.78868305e-02f, 1.18367098e-01f, 4.36471477e-02f, 2.98566371e-02f, 1.81057945e-01f, 1.26626745e-01f, 1.83216408e-01f, 2.14735880e-01f, 4.88870256e-02f, 1.80534735e-01f,
  5.01585938e-02f, -4.38247947e-03f, -2.95997728e-02f, -9.33882743e-02f, 9.36741531e-02f, -2.59792320e-02f, -7.64823705e-02f, -2.04555973e-01f, 5.85464016e-02f, 1.17732324e-01f,
  4.48388867e-02f, 1.35562778e-01f, 1.13590240e-01f, -1.10838329e-02f, -1.12949073e-01f, 1.28228348e-02f, 5.64999990e-02f, -1.72479704e-01f, 1.06546506e-01f, 2.01510433e-02f,
  1.98691204e-01f, -2.20373645e-02f, -7.30991587e-02f, 2.89490558e-02f, 1.31764591e-01f, 3.20396237e-02f, 2.19575697e-04f, -6.12438424e-03f, -7.72809684e-02f, -1.72854573e-01f,
  1.39204711e-01f, 1.79384649e-01f, 4.42843027e-02f, 1.92412689e-01f, 8.03891271e-02f, 2.61113495e-01f, 5.94274290e-02f, 3.38294618e-02f, 2.68408328e-01f, -1.31682456e-01f,
  1.51551023e-01f, 1.39172450e-01f, -1.77672878e-01f, -2.77676377e-02f, 1.58339053e-01f, 2.61471421e-01f, 1.21072866e-01f, 1.25249133e-01f, 2.09696472e-01f, -9.13730413e-02f,
  -2.84926835e-02f, 3.79743129e-02f, -3.49040590e-02f, -6.16829544e-02f, 1.17511071e-01f, -7.18820021e-02f, 1.85862601e-01f, 2.85852343e-01f, 2.86048412e-01f, 1.16371803e-01f,
  1.66667148e-01f, 3.15594733e-01f, 1.66232079e-01f, 2.92213768e-01f, 4.67229076e-02f, -4.91602123e-02f, -1.72414511e-01f, 1.50028512e-01f, 1.40891522e-01f, -7.42392568e-03f,
  -1.00006238e-01f, -1.95396990e-01f, 6.49962500e-02f, 3.62069793e-02f, -2.09138356e-02f, -6.30409718e-02f, -1.70797899e-01f, -6.69160560e-02f, 5.59580028e-02f, -8.04247633e-02f,
  2.70006120e-01f, -1.72851279e-01f, -4.02624672e-03f, -5.06243408e-02f, 2.02777162e-01f, 2.64862597e-01f, 2.12630734e-01f, 6.88806102e-02f, 1.52616188e-01f, 9.40744281e-02f,
  -1.11378931e-01f, 2.84341425e-02f, 1.54411986e-01f, -1.74177960e-01f, 2.75781125e-01f, 6.96778148e-02f, -1.40538082e-01f, 2.28664547e-01f, 3.52741852e-02f, 1.63815230e-01f,
  7.88088068e-02f, 2.27098852e-01f, 6.61107600e-02f, -8.70116055e-02f, 3.26217532e-01f, 1.12043843e-01f, -3.09762269e-01f, 1.20422408e-01f, 1.40827060e-01f, 3.55635658e-02f,
  2.85903066e-02f, 3.42351720e-02f, 2.44652465e-01f, -7.24318475e-02f, 4.09710668e-02f, -1.06073111e-01f, 5.54198911e-03f, -2.01585025e-01f, 9.08537954e-03f, -1.86978608e-01f,
  1.39262110e-01f, 3.49775739e-02f, 1.61805749e-01f, 1.88610449e-01f, -6.79460494e-03f, 1.65772989e-01f, -4.01580743e-02f, 1.83055416e-01f, 7.54823163e-02f, -1.09804548e-01f,
  -2.67320156e-01f, -7.76817724e-02f, -7.55597427e-02f, -1.18111536e-01f, 9.27610882e-03f, -2.18782812e-01f, -1.00972779e-01f, 7.79455751e-02f, 1.14178829e-01f, 7.83262029e-03f,
  1.47922143e-01f, 9.99778584e-02f, 3.21777463e-02f, -4.28904518e-02f, -1.36899874e-01f, -1.80934131e-01f, -1.23358201e-02f, -3.13754529e-02f, 3.15011978e-01f, 1.64602101e-01f,
  1.84274063e-01f, -5.58530074e-03f, -6.31202711e-03f, -3.37674730e-02f, 6.44580722e-02f, 2.91828437e-05f, 1.11364625e-01f, -5.08521460e-02f, 3.02193671e-01f, 7.30064288e-02f,
  -4.05690372e-02f, 2.09608078e-01f, 2.87339427e-02f, -1.03704005e-01f, -1.96665339e-02f, 2.60349102e-02f, 7.83449113e-02f, -6.47648498e-02f, 1.57028973e-01f, 2.24427104e-01f,
  -1.10624112e-01f, -7.21302181e-02f, -1.24843128e-01f, 1.55135423e-01f, -1.73039436e-02f, -1.68192852e-02f, 1.06585495e-01f, -6.59945756e-02f, -9.48875546e-02f, 1.14219181e-01f,
  1.94613561e-01f, 6.81217462e-02f, 1.67514887e-02f, -5.16893230e-02f, 1.62829369e-01f, 3.43311056e-02f, 8.96986797e-02f, 1.75358012e-01f, 2.23671213e-01f, -1.69603061e-02f,
  -1.27011776e-01f, 4.16863039e-02f, -1.88622460e-01f, -1.99169472e-01f, 1.38816908e-02f, 9.02037397e-02f, 1.68231249e-01f, -1.93347558e-02f, 4.00435776e-01f, 1.61224544e-01f,
  1.67986732e-02f, -1.04460843e-01f, 6.61310256e-02f, -1.03703804e-01f, 2.08464831e-01f, 5.50210401e-02f, 5.36230989e-02f, 3.85575891e-02f, -1.15992494e-01f, 4.55114851e-03f,
  1.52952343e-01f, -6.28973395e-02f, -1.22507937e-01f, 2.59788781e-01f, 3.19156915e-01f, 3.91804397e-01f, -1.94641173e-01f, -2.61222664e-02f, -7.10495934e-02f, 1.04617022e-01f,
  8.65234062e-02f, 3.93001914e-01f, 3.61293942e-01f, -7.94087946e-02f, -4.97863479e-02f, 9.93276387e-02f, -6.44995943e-02f, -1.90341115e-01f, 2.57691182e-02f, 1.18055582e-01f,
  -2.47926146e-01f, 8.30741078e-02f, -4.29376438e-02f, 8.91489815e-03f, -7.94488564e-03f, 4.60986048e-02f, 1.50771718e-02f, -1.58828393e-01f, -8.62473547e-02f, -1.23957302e-02f,
  -1.58941954e-01f, -6.92076609e-02f, -3.16166878e-02f, 1.14133872e-01f, 4.54202034e-02f, 6.11615144e-02f, 4.46941098e-03f, 2.31431827e-01f, -5.82545847e-02f, -9.23990905e-02f,
  -5.52072152e-02f, 9.90253165e-02f, 7.70971924e-02f, -1.83932483e-03f, -5.79514392e-02f, -7.74224550e-02f, 1.09958626e-01f, -3.89112569e-02f, -6.34843782e-02f, -4.60368916e-02f,
  1.69597231e-02f, -4.67756949e-02f, 6.29447177e-02f, 2.80696694e-02f, 4.19794284e-02f, -9.74643826e-02f, 1.07638806e-01f, 1.70070753e-02f, -4.61313948e-02f, 1.18680388e-01f,
  5.43442145e-02f, -9.18425024e-02f, 7.02442527e-02f, 5.31914495e-02f, -1.12232342e-01f, -1.05597869e-01f, -7.67245516e-02f, 2.01729741e-02f, -1.13076776e-01f, 6.89506009e-02f,
  -2.79841777e-02f, 8.72879997e-02f, 6.05848618e-02f, 3.08212936e-02f, -6.56155869e-02f, -1.05879433e-01f, -1.10298812e-01f, 2.43869349e-02f, 3.42334658e-02f, -2.57065445e-02f,
  -1.09183078e-04f, -3.67422961e-02f, 1.19530782e-01f, -7.76628330e-02f, 1.32905051e-01f, 5.25911041e-02f, 5.81267625e-02f, -5.51425703e-02f, -2.15285048e-02f, -1.06627382e-01f,
  1.31476671e-01f, 1.02874953e-02f, 4.37752791e-02f, -2.97271670e-03f, 3.79821961e-03f, 2.12639440e-02f, 2.23024655e-03f, -5.75073287e-02f, 2.78033186e-02f, -1.22798737e-02f,
  -6.61565587e-02f, 1.46080377e-02f, 3.37073207e-02f, 4.66946103e-02f, -6.58534095e-02f, 7.36979470e-02f, -2.85540838e-02f, -1.24242164e-01f, -7.97291771e-02f, 4.38026823e-02f,
  2.69032409e-03f, 1.17848821e-01f, -1.06430314e-01f, -7.62287304e-02f, 1.19459871e-02f, -7.39178360e-02f, -4.15129252e-02f, 5.77460192e-02f, -5.22059796e-04f, -1.92536153e-02f,
  -6.76778704e-02f, -9.99169424e-02f, -1.15996972e-02f, 5.87073378e-02f, 4.65525948e-02f, -1.02678835e-01f, -6.14812225e-02f, -1.06692307e-01f, -1.12509215e-02f, 2.67044138e-02f,
  1.96386352e-02f, 4.63407673e-02f, 6.68995008e-02f, 5.37737012e-02f, -9.48107094e-02f, 3.63835506e-02f, 6.28804639e-02f, -5.44562042e-02f, -9.73993763e-02f, -8.56353343e-03f,
  -1.15931660e-01f, -4.63849567e-02f, 3.33960019e-02f, -7.93938935e-02f, 4.67482843e-02f, 6.26187548e-02f, 3.82702835e-02f, -6.74696043e-02f, 1.09957598e-01f, -1.12713903e-01f,
  -3.76008376e-02f, 5.47296852e-02f, -1.00390345e-01f, 2.84000020e-02f, -1.18713140e-01f, -4.58881743e-02f, 2.79182084e-02f, 4.30111960e-02f, -3.61880958e-02f, -9.23168659e-02f,
  -8.43404159e-02f, -1.20012768e-01f, 7.54263848e-02f, -5.14158458e-02f, -3.85601656e-03f, 3.79658118e-02f, -1.05395526e-01f, 5.38082700e-03f, 4.97834794e-02f, 2.54280958e-02f,
  -1.65349059e-02f, 3.92053947e-02f, 1.28946796e-01f, -8.76831561e-02f, 2.40800772e-02f, 4.15310562e-02f, 1.44243553e-01f, 3.38894427e-02f, 9.52913091e-02f, -3.55690308e-02f,
  8.47180039e-02f, 8.66148397e-02f, -1.81143265e-02f, -2.60213669e-03f, 4.55180928e-02f, 1.42110988e-01f, -8.55512694e-02f, 9.03186128e-02f, -1.78065840e-02f, -3.05760019e-02f,
  1.44491270e-01f, 1.18874356e-01f, 4.53283377e-02f, 5.36078066e-02f, -8.37878510e-02f, 1.69042900e-01f, -9.49695632e-02f, -4.01034057e-02f, 3.48082557e-02f, -6.00574985e-02f,
  1.42636895e-02f, 3.69641595e-02f, 4.23936322e-02f, 1.96142003e-01f, -1.41382277e-01f, -1.71902049e-02f, 5.85462488e-02f, -1.11327857e-01f, -5.74102364e-02f, 3.04153990e-02f,
  1.27046734e-01f, -3.81062478e-02f, 1.97470397e-01f, -2.57767830e-02f, 1.15535878e-01f, -1.39372066e-01f, 9.92223695e-02f, -8.44288468e-02f, -4.94634472e-02f, -2.81763654e-02f,
  -1.13587685e-01f, -3.91336121e-02f, -9.48799923e-02f, 7.39440098e-02f, 1.03991799e-01f, 5.18582724e-02f, -7.67656937e-02f, 6.07315861e-02f, -1.16948493e-01f, -5.41572878e-03f,
  1.06638953e-01f, -8.91047418e-02f, 1.14882067e-01f, -6.77390546e-02f, 1.91379897e-02f, 4.55174707e-02f, 2.95784511e-02f, 1.29933298e-01f, -1.80001050e-01f, -5.40124811e-02f,
  1.75538883e-01f, 2.46604726e-01f, 7.29392245e-02f, 2.19216291e-02f, 4.08586934e-02f, 2.36442313e-03f, 4.78288829e-02f, 1.08594775e-01f, -3.67824137e-02f, 2.77560130e-02f,
  -9.12073851e-02f, -4.88939993e-02f, -7.89286345e-02f, 1.36201009e-01f, -5.60186692e-02f, -7.43739307e-02f, 2.16417909e-02f, 1.17537968e-01f, -1.26236886e-01f, 4.78622764e-02f,
  -4.71996851e-02f, 2.74285704e-01f, -9.49467197e-02f, -1.29738450e-01f, 1.02434821e-01f, -9.54488739e-02f, 1.86372697e-01f, 2.78193206e-01f, 2.49285959e-02f, 1.37383074e-01f,
  -6.95214197e-02f, -8.45228694e-03f, -2.57050432e-02f, 8.99261758e-02f, -6.21735193e-02f, 1.77657858e-01f, 7.53727928e-02f, 2.54659262e-02f, 3.93106416e-02f, -8.63194913e-02f,
  -1.72059655e-01f, 5.03919497e-02f, -1.33911688e-02f, -1.21725246e-01f, -2.72426270e-02f, 1.91464230e-01f, -4.89351340e-03f, -1.04380220e-01f, 4.66098450e-02f, 6.65033311e-02f,
  5.09810261e-02f, 1.78043451e-02f, -6.47476166e-02f, -5.24015985e-02f, -3.60267833e-02f, 9.35927778e-02f, 1.15319677e-01f, 2.34948080e-02f, 1.72898650e-01f, 1.47057340e-01f,
  2.90287614e-01f, 1.59520283e-01f, 8.97387117e-02f, 2.14493260e-01f, 2.47951701e-01f, 1.62341222e-01f, -2.10425302e-01f, -9.51347277e-02f, -2.96498120e-01f, -1.74964741e-01f,
  -7.42686912e-02f, -7.93905482e-02f, 1.31672263e-01f, 1.35205328e-01f, 4.35298607e-02f, -1.44698508e-02f, 7.49067888e-02f, -3.64494398e-02f, 2.93544859e-01f, 7.86936656e-02f,
  -9.64394733e-02f, -4.94537838e-02f, 9.02973413e-02f, 3.69248867e-01f, -3.89526300e-02f, -1.49277719e-02f, 1.33353755e-01f, -1.02693178e-01f, 1.19597442e-01f, 1.57940283e-01f,
  1.54835939e-01f, 2.97787674e-02f, 1.80198196e-02f, 5.47314121e-04f, -1.50720626e-01f, 4.26309071e-02f, -2.20028479e-02f, 2.05642968e-01f, -2.00356096e-01f, 1.96906388e-01f,
  2.33367026e-01f, -1.79645151e-01f, 4.24886085e-02f, 1.35475278e-01f, 9.66183990e-02f, 2.44655654e-01f, 2.53995620e-02f, -4.53593396e-02f, -1.39923945e-01f, -3.19530219e-02f,
  9.83862951e-03f, -1.02695666e-01f, -5.65678254e-02f, -3.90906595e-02f, -3.60584556e-04f, -8.37226287e-02f, 2.62006093e-03f, -1.30725458e-01f, 7.10784718e-02f, 1.46211330e-02f,
  2.97223963e-02f, 5.56260385e-02f, -3.72407399e-02f, -7.11955726e-02f, 8.00878033e-02f, -9.37003717e-02f, 7.31158555e-02f, 4.18626405e-02f, 4.12583575e-02f, -1.46569619e-02f,
  -1.17940374e-01f, -2.46513765e-02f, 4.17020470e-02f, 4.88324389e-02f, -5.25436364e-02f, 2.99171973e-02f, -1.16631705e-02f, 4.27209511e-02f, 1.49830475e-01f, -8.00641552e-02f,
  -2.14354158e-03f, -4.06037606e-02f, -8.12573079e-03f, -5.65123111e-02f, -3.40322442e-02f, -1.61732156e-02f, 6.79446459e-02f, 1.90600201e-01f, 2.91347876e-02f, -4.07035798e-02f,
  -8.89117867e-02f, -7.62714297e-02f, 1.11983821e-01f, -8.27899799e-02f, 8.43623951e-02f, -5.45520745e-02f, -1.84799284e-02f, 1.05961561e-01f, 2.48518344e-02f, -5.88965863e-02f,
  -7.15413466e-02f, 8.09131712e-02f, 5.70574142e-02f, 1.27632052e-01f, 9.21628475e-02f, -1.00529224e-01f, -1.16593085e-01f, 1.45470440e-01f, 2.64598966e-01f, 1.78235129e-01f,
  7.23663643e-02f, 1.16155699e-01f, 1.01730809e-01f, -6.22563856e-03f, 5.32845780e-02f, -9.64996740e-02f, -7.61156203e-03f, -3.63392420e-02f, 1.23030134e-02f, 2.13419814e-02f,
  1.15988910e-01f, -1.45576701e-01f, 1.16940670e-01f, 1.88474759e-01f, 1.60909686e-02f, 9.34140086e-02f, -6.59210887e-03f, 5.24810962e-02f, 8.72048438e-02f, -2.74481475e-02f,
  -1.95299774e-01f, -1.52017623e-01f, -3.58053148e-02f, -1.97415963e-01f, -3.81067954e-02f, -3.27088311e-02f, 5.33030741e-02f, 1.70257598e-01f, -1.65169721e-03f, -6.89215660e-02f,
  5.19423857e-02f, 2.08791867e-01f, 2.33963758e-01f, -4.43185940e-02f, 4.50445972e-02f, 1.37795443e-02f, 1.41037077e-01f, 1.40088508e-02f, 1.70418739e-01f, 1.28196791e-01f,
  5.10403290e-02f, 2.32668087e-01f, 8.54327604e-02f, -2.03647584e-01f, -1.67277575e-01f, -9.30648595e-02f, 1.29401572e-02f, -1.50128826e-02f, 1.60738945e-01f, 2.71146983e-01f,
  7.17462450e-02f, -2.99969465e-02f, 1.52434632e-02f, 1.35756716e-01f, -1.65259764e-02f, -1.39746502e-01f, -1.00193590e-01f, -6.06482327e-02f, 1.78004473e-01f, -1.73693359e-01f,
  -7.19071925e-02f, 1.56391919e-01f, 5.27383745e-01f, 1.07943103e-01f, -1.06859542e-01f, -1.45081356e-01f, -1.08069420e-01f, -5.78954397e-03f, 3.09919044e-02f, 8.50583538e-02f,
  4.88377102e-02f, 1.12379812e-01f, 2.12624595e-01f, 1.97623074e-01f, -1.12522468e-01f, -9.19451416e-02f, -4.30349447e-03f, -1.23898178e-01f, -9.39720124e-02f, 6.01378754e-02f,
  -1.05736025e-01f, 7.82589838e-02f, 3.01231295e-02f, -2.34610811e-02f, -6.64880639e-03f, -7.76428506e-02f, 1.90043841e-02f, -5.84865622e-02f, -9.40152705e-02f, 5.62975593e-02f,
  1.50844762e-02f, 7.45596513e-02f, 9.04900730e-02f, -3.54194641e-02f, 4.26565520e-02f, 5.32085225e-02f, 1.07112065e-01f, -4.64862064e-02f, 2.17530522e-02f, 2.56365277e-02f,
  -9.94979143e-02f, 2.34473050e-02f, -1.16963498e-01f, 6.75709620e-02f, -2.05294229e-03f, -8.66689086e-02f, 5.60828298e-02f, 6.65904507e-02f, -2.86795255e-02f, -3.23106460e-02f,
  -5.97237423e-02f, -6.37879223e-02f, -5.75160570e-02f, 4.12430689e-02f, 2.41557769e-02f, 1.65736154e-02f, 1.01642236e-01f, 1.94367133e-02f, -7.33118271e-03f, -2.43610069e-02f,
  3.61967459e-02f, -1.25281572e-01f, -7.81393424e-02f, -1.02471538e-01f, -7.25525469e-02f, -6.10446036e-02f, 5.68401664e-02f, -6.73938021e-02f, -1.04199432e-01f, 1.05029985e-01f,
  -2.61559952e-02f, 1.98761839e-02f, -1.13181569e-01f, -1.18327543e-01f, 9.22992155e-02f, -2.15829946e-02f, -9.36257020e-02f, -8.25031381e-03f, 3.96409556e-02f, 1.09396175e-01f,
  -6.59491420e-02f, -2.89143771e-02f, -7.35291392e-02f, 4.37917635e-02f, 7.87971467e-02f, 6.18286580e-02f, -1.00602537e-01f, 2.34857723e-02f, -1.24575764e-01f, 3.80579755e-03f,
  -4.78464775e-02f, -1.15305416e-01f, 1.19286850e-01f, -1.20667905e-01f, -6.76827133e-02f, 5.71313947e-02f, 6.46222159e-02f, -1.02885127e-01f, -1.74916331e-02f, -9.82442871e-02f,
  4.81644720e-02f, -1.90118607e-02f, -2.45748218e-02f, -5.17322756e-02f, -4.70598526e-02f, 2.31906287e-02f, 3.60949785e-02f, -8.77030119e-02f, 1.42156959e-01f, -4.80357744e-03f,
  7.33240023e-02f, -6.57124817e-02f, -7.73877352e-02f, -3.67832556e-02f, 6.41762912e-02f, -8.32104906e-02f, 2.26802099e-02f, 1.12727351e-01f, 1.65628433e-01f, 7.56849274e-02f,
  1.32903799e-01f, 3.40205617e-02f, 7.51597509e-02f, -1.81412287e-02f, 1.36140034e-01f, -1.48446311e-03f, -3.12224496e-02f, -8.10688809e-02f, -7.79896677e-02f, -8.00290480e-02f,
  -4.32673059e-02f, -7.75383562e-02f, -9.11680311e-02f, 1.30224288e-01f, 2.36251205e-03f, 8.25970396e-02f, 7.77001828e-02f, 1.13706239e-01f, -7.14229196e-02f, -1.03663675e-01f,
  -5.44931069e-02f, -1.02149248e-01f, -9.55094174e-02f, -2.35316567e-02f, -8.40822533e-02f, -1.01875238e-01f, -8.81936103e-02f, 1.61491446e-02f, -1.14858836e-01f, -6.69476390e-02f,
  2.71766055e-02f, -9.69062075e-02f, -7.98445102e-03f, -4.84575033e-02f, 6.49175718e-02f, -1.10141329e-01f, -1.33711072e-02f, -4.10451964e-02f, -9.26498175e-02f, -1.56024834e-02f,
  -1.03110015e-01f, 9.21318904e-02f, 4.86256145e-02f, -1.11253820e-01f, 4.67695482e-02f, -6.45598993e-02f, -1.21541023e-01f, -6.84461072e-02f, -6.09481670e-02f, 2.62199212e-02f,
  -5.08190133e-02f, -7.33241253e-03f, -2.04042792e-02f, 4.30130213e-03f, 9.42065492e-02f, -1.25383392e-01f, -1.05164729e-01f, -2.90196985e-02f, -5.74672855e-02f, 3.44937630e-02f,
  -6.97535947e-02f, 6.64724484e-02f, 5.60975187e-02f, 5.86444326e-02f, 1.22428440e-01f, -5.45606166e-02f, -1.08051347e-02f, -1.14554344e-02f, -5.01034074e-02f, 1.22386359e-01f,
  -4.33573350e-02f, 1.78089086e-02f, -7.68094137e-02f, 1.23803586e-01f, -3.06412578e-02f, -8.81280527e-02f, 3.27636115e-02f, -4.83563058e-02f, 3.70946825e-02f, 1.01273857e-01f,
  -8.97393003e-02f, -5.33353463e-02f, -8.88095573e-02f, -4.17244025e-02f, -6.37392849e-02f, 6.57785088e-02f, -5.75797856e-02f, 7.85265639e-02f, -5.98186962e-02f, -3.20304967e-02f,
  -9.62455943e-02f, -6.18555658e-02f, 1.96891255e-03f, 1.94046665e-02f, -6.88625500e-02f, -6.68149889e-02f, -8.98182988e-02f, 6.12604916e-02f, 4.96804863e-02f, -1.41151259e-02f,
  -1.38713241e-01f, 9.89240408e-03f, -1.43350750e-01f, -5.56902885e-02f, -3.72309983e-02f, -6.42339364e-02f, -3.93502936e-02f, -3.97979654e-02f, 5.57205677e-02f, 1.00901708e-01f,
  2.89377533e-02f, 1.11142993e-01f, 1.06899336e-01f, 5.37028871e-02f, -7.32810050e-02f, 5.81592061e-02f, 1.19931795e-01f, 2.57244799e-02f, 1.02627821e-01f, -1.01691289e-02f,
  1.10709384e-01f, -7.98586458e-02f, 2.27828976e-02f, -9.00228545e-02f, -3.38984355e-02f, 3.10113169e-02f, -1.05857275e-01f, -2.52105109e-02f, 2.61240490e-02f, 1.10832088e-01f,
  -1.19374990e-01f, -6.46088179e-03f, 9.97671932e-02f, -1.14268281e-01f, -6.31411672e-02f, 5.29035218e-02f, -7.55192339e-02f, 8.13188478e-02f, 9.01383441e-03f, 3.91380265e-02f,
  4.74896915e-02f, 9.01677907e-02f, 9.95366350e-02f, -4.97872122e-02f, 3.87506969e-02f, 1.12923589e-02f, -1.13562653e-02f, 1.11128390e-01f, 1.17431380e-01f, -2.67067701e-02f,
  9.30000022e-02f, 1.10138662e-03f, 1.04278669e-01f, 9.12589058e-02f, 1.66129265e-02f, 1.88817107e-03f, 9.16882232e-02f, 9.76426993e-03f, -2.16213182e-01f, 6.81334287e-02f,
  1.39515251e-01f, 9.99801531e-02f, -1.81590140e-01f, -2.95030084e-02f, 1.71154290e-01f, -8.47307816e-02f, 3.23914468e-01f, 6.71366155e-02f, 9.71426144e-02f, -4.99405786e-02f,
  -9.04976130e-02f, -1.70691088e-01f, -5.68513870e-02f, -9.21251550e-02f, -5.41098490e-02f, 6.39723688e-02f, -1.14263512e-01f, 9.37388986e-02f, 1.33731797e-01f, 1.01596713e-01f,
  -1.28646016e-01f, -4.99295294e-02f, -5.27770026e-03f, 2.79840410e-01f, -7.69427270e-02f, 2.82356646e-02f, -1.50511831e-01f, -4.43542860e-02f, -9.35695041e-03f, 1.40412569e-01f,
  1.40882209e-01f, -1.59374196e-02f, 1.48586810e-01f, 1.60429046e-01f, 1.21438377e-01f, -2.23988183e-02f, 2.51820415e-01f, -7.06559792e-02f, -1.77169830e-01f, 3.35750282e-01f,
  2.21958607e-02f, -2.21955292e-02f, 3.65606248e-02f, -3.15349214e-02f, -3.55283394e-02f, -6.34516776e-02f, 1.21098325e-01f, -4.83440794e-02f, 8.82167742e-02f, -3.88798229e-02f,
  -2.49800012e-02f, 4.09050807e-02f, -7.40371048e-02f, 9.50666890e-03f, 1.48004899e-02f, 1.21031754e-01f, 5.02647124e-02f, -2.51654796e-02f, -7.33865947e-02f, -1.20480984e-01f,
  -9.64000449e-02f, 9.03258622e-02f, 3.67590860e-02f, -1.12638086e-01f, -4.12349664e-02f, 1.18088692e-01f, 4.67073023e-02f, 8.82737413e-02f, 3.46078165e-02f, 4.60194461e-02f,
  1.89604051e-02f, 1.18283927e-01f, -1.03422433e-01f, -7.05591682e-03f, 1.04364172e-01f, 2.61083823e-02f, 2.66443547e-02f, -9.80486199e-02f, 1.24874465e-01f, -2.05968730e-02f,
  -4.80779819e-02f, 1.17342267e-02f, -7.62896389e-02f, 4.07175235e-02f, -1.36858836e-01f, -1.07140101e-01f, -5.99708520e-02f, -3.03266589e-02f, -2.38501243e-02f, -3.12392320e-02f,
  -8.05401430e-02f, -6.59793615e-02f, 8.63167048e-02f, -6.46816799e-03f, -2.50900015e-02f, 1.05236404e-01f, 8.86299759e-02f, 1.09684557e-01f, -9.81861874e-02f, 9.51414183e-02f,
  -4.73710746e-02f, -9.60816443e-02f, 8.09852928e-02f, -3.37928757e-02f, 6.92400057e-03f, 6.14458732e-02f, 2.42975857e-02f, 1.05884708e-01f, -2.53856573e-02f, 5.80359846e-02f,
  8.21655765e-02f, -7.88181275e-02f, -1.02718674e-01f, 1.13925770e-01f, 1.24942429e-01f, 1.47905489e-02f, 4.51979646e-03f, -2.74190661e-02f, -5.07363826e-02f, -1.16618603e-01f,
  -3.39094140e-02f, -4.77483235e-02f, -7.64764322e-04f, 1.90664567e-02f, -8.66353661e-02f, 1.08221136e-02f, -1.40794292e-01f, 1.06988497e-01f, -9.04115103e-03f, -2.42814198e-02f,
  4.95829992e-02f, 1.10586248e-01f, 1.36445919e-02f, 2.01735459e-03f, 2.19676971e-01f, 8.75998288e-02f, -1.15891024e-01f, -6.84020594e-02f, 3.09597105e-02f, 3.97903137e-02f,
  -1.23901181e-01f, -7.85038471e-02f, -1.56345926e-02f, 4.70163561e-02f, -1.96676031e-02f, 1.42396651e-02f, 8.20059851e-02f, 9.34670195e-02f, -5.87568954e-02f, 5.04208319e-02f,
  1.40719533e-01f, 2.44772449e-01f, -2.99078766e-02f, 7.03649446e-02f, 1.21443227e-01f, -6.20999895e-02f, -1.06376328e-01f, 2.11821124e-01f, 7.64458720e-03f, -3.04457732e-02f,
  -1.24967694e-01f, 1.65857244e-02f, -7.31976843e-03f, -7.51818866e-02f, -1.19801573e-02f, -4.36449125e-02f, -3.39960568e-02f, 7.75465742e-02f, 8.84675309e-02f, 5.00527360e-02f,
  3.50733474e-02f, 1.12963259e-01f, 9.86301154e-02f, -9.12142079e-03f, -8.95154327e-02f, 4.50708792e-02f, -1.00160860e-01f, -8.89227986e-02f, -8.27492326e-02f, -7.92272612e-02f,
  -9.47086513e-02f, 8.20300654e-02f, 7.41618723e-02f, 1.72786172e-02f, 1.12700149e-01f, -5.84753528e-02f, 6.06061295e-02f, 1.58863276e-01f, 4.44322191e-02f, -1.73085239e-02f,
  7.41542429e-02f, -2.37697750e-01f, 1.78558558e-01f, 2.39621252e-01f, 1.11553436e-02f, -1.30277127e-01f, -7.20858946e-02f, -5.85161932e-02f, 7.05820695e-02f, 9.84748155e-02f,
  6.87753856e-02f, -8.29150230e-02f, 2.63228249e-02f, 2.08787888e-01f, -1.03757590e-01f, -3.36167938e-03f, 4.70835045e-02f, 1.39178917e-01f, 1.26160428e-01f, 1.72044098e-01f,
  -1.48634821e-01f, 2.95975036e-03f, 6.56709075e-02f, -3.87129113e-02f, -1.17805779e-01f, -1.99656740e-01f, 2.77788371e-01f, 3.62819736e-03f, -6.71221465e-02f, 5.94806783e-02f,
  -1.04736798e-01f, 7.03526139e-02f, -2.55160958e-01f, 2.08066195e-01f, -2.93872934e-02f, -6.79583773e-02f, -1.16460718e-01f, 2.16412678e-01f, 6.68911859e-02f, -6.50651082e-02f,
  2.01179400e-01f, 1.97144359e-01f, -1.31862601e-02f, 2.02600770e-02f, 2.31085569e-01f, 1.55562311e-01f, -6.30215034e-02f, 1.16391741e-01f, 7.51127452e-02f, -1.48085922e-01f,
  1.63171053e-01f, 6.69168010e-02f, 1.10064030e-01f, 2.07118578e-02f, 6.68388680e-02f, 1.42401144e-01f, -5.23113869e-02f, 1.82438567e-01f, 3.20549011e-02f, 7.12216794e-02f,
  1.23114549e-01f, -3.26643791e-03f, 1.35039330e-01f, 1.81540817e-01f, 2.07917448e-02f, -2.08017737e-01f, 1.35941401e-01f, 1.27097650e-03f, -1.88915193e-01f, -1.23422585e-01f,
  -8.58865771e-03f, -9.44924280e-02f, 3.45824748e-01f, 3.45011383e-01f, -9.74094793e-02f, -1.16443008e-01f, -1.49609894e-01f, -3.73116806e-02f, -1.78490847e-01f, 1.65299863e-01f,
  -5.39572015e-02f, 1.70788780e-01f, 1.94312662e-01f, -7.09758922e-02f, -1.11412928e-01f, -8.22073445e-02f, -3.04588079e-01f, 1.21791005e-01f, 2.16587171e-01f, -1.20645761e-01f,
  -2.00650524e-02f, 5.74124902e-02f, -8.14519823e-02f, 7.26003870e-02f, 9.71323252e-02f, 1.82042867e-01f, 1.77645564e-01f, 6.54872134e-02f, 2.54810639e-02f, 2.82317325e-02f,
  3.31396200e-02f, -5.07312343e-02f, 1.64694220e-01f, -8.71714130e-02f, -1.36172950e-01f, 2.83910811e-01f, 6.45880699e-02f, -4.73958254e-02f, -2.75671873e-02f, -9.24319476e-02f,
  -1.26613602e-01f, -3.25039215e-02f, -1.86636314e-01f, 1.32443547e-01f, -1.38989508e-01f, 2.81007960e-02f, 1.00812905e-01f, -1.31174326e-01f, 3.67395859e-03f, -3.53524387e-02f,
  1.37936011e-01f, 2.55990833e-01f, -1.07980870e-01f, 2.07762178e-02f, 2.16856021e-02f, 5.23752905e-02f, -2.14849971e-02f, -1.23191416e-01f, -5.91817917e-03f, -1.01292260e-01f,
  4.16175649e-03f, 5.83384000e-03f, 2.18360871e-02f, -6.78183511e-02f, 8.53488147e-02f, -1.04762159e-01f, -4.38885130e-02f, -7.19125122e-02f, -7.59509057e-02f, -4.14262265e-02f,
  3.27187777e-02f, 1.13499478e-01f, -7.77757121e-03f, -4.92349900e-02f, -4.26428020e-02f, 1.14528783e-01f, -8.88570175e-02f, -1.12362159e-02f, -9.58319083e-02f, 1.09848259e-02f,
  -7.53622428e-02f, 1.05042048e-01f, -2.62166727e-02f, 2.96285711e-02f, 8.10492486e-02f, -4.93938737e-02f, -3.23864743e-02f, -6.66327626e-02f, -1.01114184e-01f, 1.31413639e-01f,
  -8.34221095e-02f, 9.85456035e-02f, -7.93730915e-02f, 7.12991506e-02f, 5.19381240e-02f, -4.18155342e-02f, 1.17993481e-01f, 3.92949991e-02f, 2.33390741e-02f, 1.16524287e-01f,
  -1.21873006e-01f, -1.21638492e-01f, -7.32175261e-02f, 3.77158145e-03f, 1.86252873e-02f, 7.06484988e-02f, 5.40206255e-03f, -1.13869309e-01f, -1.30175045e-02f, 1.07738063e-01f,
  3.00197862e-02f, -2.66498458e-02f, -8.62755533e-03f, -2.99006943e-02f, 8.72554928e-02f, 2.20841020e-02f, 1.37253210e-01f, -4.12295163e-02f, -9.41042751e-02f, 1.22838236e-01f,
  6.67533353e-02f, -8.29795226e-02f, -1.40152141e-01f, 1.62456363e-01f, -5.04258201e-02f, -1.65804192e-01f, -3.11276149e-02f, -4.85710241e-02f, 4.04169336e-02f, 5.60457408e-02f,
  1.72796741e-01f, -1.13697164e-01f, 4.70464565e-02f, 3.98464762e-02f, 1.08095810e-01f, 5.21016493e-02f, 3.26081395e-01f, -1.06700920e-01f, 8.57205503e-03f, 1.49302848e-03f,
  -1.92635626e-01f, 1.23835430e-01f, -8.40146840e-03f, 3.65675874e-02f, 2.44565398e-01f, 1.28606439e-01f, -4.25651930e-02f, 1.71101570e-01f, -4.50625308e-02f, 7.03161806e-02f,
  2.60104567e-01f, -1.33859172e-01f, -3.03402524e-02f, 8.62829760e-02f, 1.35885969e-01f, -2.89370678e-02f, 1.62096113e-01f, 1.56684756e-01f, 9.34303999e-02f, -1.38965890e-01f,
  2.26613343e-01f, -1.31255552e-01f, -2.10077073e-02f, 1.77172750e-01f, -1.65846914e-01f, 4.06194590e-02f, 2.59821057e-01f, -7.14519694e-02f, -9.81744751e-02f, 1.85286757e-02f,
  7.76179433e-02f, -3.74447703e-02f, -6.97136670e-02f, 6.69559985e-02f, -2.78899744e-02f, 1.47158787e-01f, -2.58298144e-02f, 3.10100317e-01f, 9.53698978e-02f, -9.04444605e-02f,
  5.46070840e-03f, -9.54982489e-02f, -9.30688605e-02f, -8.20922926e-02f, 1.14425033e-01f, -9.67248455e-02f, 1.72006544e-02f, 9.52609107e-02f, 1.32180691e-01f, 9.06071514e-02f,
  -9.91633981e-02f, -2.58704070e-02f, 2.87882499e-02f, 5.97891584e-03f, -1.77013595e-02f, -4.68846932e-02f, 8.46823454e-02f, -4.91470136e-02f, -1.10454082e-01f, -9.94116142e-02f,
  3.61156501e-02f, -5.06605022e-03f, 2.87673827e-02f, -3.61915529e-02f, -1.16321497e-01f, 1.33472821e-03f, 8.07564333e-02f, 6.87594712e-02f, 8.85232612e-02f, 9.43708420e-02f,
  1.09075509e-01f, 4.05280255e-02f, 7.50815719e-02f, -6.30565807e-02f, -3.01681720e-02f, -6.33130893e-02f, -4.20994908e-02f, 5.06088771e-02f, -3.03770043e-02f, -3.24505568e-02f,
  -1.10673100e-01f, 5.08039258e-02f, 5.57678454e-02f, -1.05316825e-01f, 1.07472308e-01f, -3.12358364e-02f, 5.20387106e-03f, 2.10248604e-02f, 6.94940686e-02f, 9.56529826e-02f,
  -9.50376168e-02f, 3.69560979e-02f, -2.44453438e-02f, -1.22136883e-01f, -1.14958458e-01f, -3.30811292e-02f, -9.02190208e-02f, 1.91836599e-02f, -6.03602119e-02f, 1.13263391e-01f,
  5.27400821e-02f, -1.28143907e-01f, 9.52156857e-02f, 9.30558071e-02f, 7.01299831e-02f, 3.02600443e-01f, 3.07005912e-01f, 2.07365006e-01f, 2.68061370e-01f, 9.40725803e-02f,
  -1.84624314e-01f, 5.40676489e-02f, -1.56815693e-01f, -2.52134413e-01f, -2.68770993e-01f, -1.31451726e-01f, 1.32158399e-01f, -6.35290816e-02f, 1.16253085e-01f, 6.42126426e-02f,
  8.65045190e-02f, 1.11209061e-02f, -1.48493471e-02f, 9.26800817e-02f, 4.30380739e-03f, -4.00607437e-02f, 1.26221955e-01f, 1.33223727e-01f, 4.39389311e-02f, -2.07918584e-01f,
  -5.49661517e-02f, 9.25445482e-02f, 4.03647393e-01f, -2.53805935e-01f, 1.09235652e-01f, -2.04414979e-01f, -1.12183347e-01f, -9.58143249e-02f, -7.07413331e-02f, -8.84131715e-02f,
  1.78380474e-01f, 1.59847178e-02f, 1.20952763e-01f, -2.23705277e-01f, -6.88571995e-03f, 4.46943492e-02f, -7.60173565e-03f, -1.64152369e-01f, -1.19923145e-01f, -4.99476530e-02f,
  2.29111537e-01f, -1.10218182e-01f, 2.39566667e-03f, 4.42417830e-01f, 7.84139559e-02f, -9.45868492e-02f, -1.52135119e-01f, 1.79288074e-01f, -8.75682235e-02f, -9.94134918e-02f,
  1.00085638e-01f, -1.15986139e-01f, 4.88312989e-02f, 1.32845342e-01f, 2.49325648e-01f, 1.08152449e-01f, 1.05076144e-03f, -4.22431119e-02f, -1.01763934e-01f, -1.25032458e-02f,
  1.37960792e-01f, 1.56981975e-01f, 7.27256536e-02f, 1.01932757e-01f, 4.55082022e-02f, -1.05407704e-02f, -5.18251471e-02f, 1.65348928e-02f, 1.15497053e-01f, 1.05474859e-01f,
  -1.73753992e-01f, 9.45732072e-02f, -4.16645873e-03f, 2.68404856e-02f, -4.38305847e-02f, 5.97532727e-02f, -6.81728423e-02f, 9.55862254e-02f, 5.19662052e-02f, 4.42098342e-02f,
  5.16609140e-02f, 9.84869599e-02f, 3.07470858e-01f, 1.54950529e-01f, -6.84231054e-03f, -8.67744461e-02f, 3.71260159e-02f, 1.36347979e-01f, -4.47939485e-02f, 4.01084088e-02f,
  2.43090540e-01f, -3.62050422e-02f, -2.24108230e-02f, 1.36012599e-01f, -7.84243941e-02f, -5.91227785e-03f, -1.70829430e-01f, 5.55700483e-03f, -3.59332114e-02f, 5.27306721e-02f,
  -5.96995614e-02f, 2.45059744e-01f, -1.40670270e-01f, 5.56459352e-02f, 1.40608206e-01f, 3.45337391e-02f, 5.03448546e-02f, 2.18377654e-02f, 1.05779193e-01f, 8.10908452e-02f,
  4.01082672e-02f, -8.10456183e-03f, -5.67159755e-03f, 2.29152143e-02f, 1.03198081e-01f, 1.28051698e-01f, -1.09857008e-01f, 5.82901388e-02f, -1.04380041e-01f, -1.91308334e-01f,
  -7.66962692e-02f, -9.74610522e-02f, -1.45462314e-02f, 2.45126244e-02f, -8.89851749e-02f, -9.65836346e-02f, 1.18215553e-01f, -8.39698315e-02f, 5.70360124e-02f, 9.50960293e-02f,
  -3.66885103e-02f, -2.21496522e-02f, 1.18757755e-01f, 6.94658095e-03f, -8.69587511e-02f, 1.72355548e-02f, 4.20530550e-02f, -8.97117928e-02f, 4.90157902e-02f, -1.00935861e-01f,
  -5.56066744e-02f, -6.37255237e-02f, 3.57137136e-02f, 2.16418523e-02f, -7.05367252e-02f, 2.80827023e-02f, -1.22556515e-01f, 1.21781297e-01f, 1.07796369e-02f, 1.10630579e-02f,
  9.91888717e-02f, -1.10994793e-01f, -1.08835153e-01f, -1.07110187e-01f, -6.04604445e-02f, -3.65112796e-02f, -6.67794794e-02f, -1.05907664e-01f, -2.82582901e-02f, -2.52050757e-02f,
  -2.77622119e-02f, 4.85098409e-03f, -6.71575814e-02f, -9.66430530e-02f, -3.94174159e-02f, 6.10099286e-02f, 3.39386351e-02f, 2.56395824e-02f, -6.74453303e-02f, 2.42854729e-02f,
  7.49752223e-02f, 1.03140749e-01f, 1.10939205e-01f, -1.21330827e-01f, -1.08671203e-01f, -1.63299572e-02f, -3.64235453e-02f, -5.21973670e-02f, 3.48575339e-02f, 4.10918333e-02f,
  -2.73256376e-02f, 3.27371173e-02f, 5.10208867e-02f, -9.00335014e-02f, -7.05965608e-02f, -3.61174680e-02f, 1.35508448e-01f, 1.28820598e-01f, 6.71338895e-03f, -6.08510710e-02f,
  3.80226709e-02f, 2.93734446e-02f, -2.00485989e-01f, 1.66199312e-01f, -7.20292032e-02f, -1.59542039e-01f, -1.95784017e-01f, -1.25459045e-01f, 1.52631655e-01f, -8.54727700e-02f,
  7.14916512e-02f, 1.16182275e-01f, -1.10177435e-01f, -5.01164198e-02f, -3.16736251e-02f, 1.74774248e-02f, 1.78305924e-01f, -3.36452164e-02f, 2.34604743e-03f, -1.16640866e-01f,
  -2.17113540e-01f, 7.63028786e-02f, 1.56783879e-01f, -7.27371573e-02f, 1.98941112e-01f, -3.35653052e-02f, 2.11592108e-01f, -7.00124279e-02f, -3.29097407e-03f, 8.13401639e-02f,
  -1.81054734e-02f, 5.17702699e-02f, 1.05476429e-04f, -9.10477526e-03f, 2.68254906e-01f, -4.20017317e-02f, 1.01834893e-01f, 1.35732129e-01f, 5.31942286e-02f, 1.82587728e-02f,
  -5.12929447e-02f, -1.03919052e-01f, -8.29101503e-02f, -6.19080365e-02f, -6.16850192e-03f, 5.34834489e-02f, 2.11248279e-01f, -1.11585471e-03f, 7.17823133e-02f, -3.11365444e-02f,
  7.09576309e-02f, -1.04022473e-01f, -9.62315574e-02f, -2.92684752e-02f, 1.02309108e-01f, 1.38306856e-01f, 5.23721892e-03f, 2.43121162e-01f, 8.74930173e-02f, 3.26623358e-02f,
  -7.87393972e-02f, -9.62120369e-02f, 1.14612624e-01f, 1.42275356e-02f, 4.59298417e-02f, -3.06954179e-02f, 1.32956970e-02f, 1.32192209e-01f, -2.49097556e-01f, -7.44815022e-02f,
  7.80597404e-02f, 1.22177944e-01f, 1.25712305e-01f, 5.93111403e-02f, 2.02486709e-01f, -9.65063199e-02f, 1.10082917e-01f, 1.09752633e-01f, 3.67313549e-02f, -1.13668002e-01f,
  2.53104717e-01f, -3.88107784e-02f, 8.72177482e-02f, -1.03559848e-02f, -2.62386873e-02f, 4.32043858e-02f, 4.41814959e-02f, 2.03460976e-02f, 3.48221511e-02f, 1.78727791e-01f,
  2.23916247e-01f, 2.94226676e-01f, -1.76745936e-01f, -1.36697546e-01f, 1.25102043e-01f, 7.16494173e-02f, 1.52764887e-01f, 2.67619759e-01f, 3.65545511e-01f, -8.81946012e-02f,
  -1.46520466e-01f, 1.28462344e-01f, -7.57214502e-02f, -1.05277911e-01f, -1.12008713e-01f, 1.57134816e-01f, -1.61100626e-01f, 1.24191204e-02f, 1.47400901e-01f, -7.57011697e-02f,
  -7.83829391e-02f, 2.59714834e-02f, -1.22238524e-01f, 9.14745405e-02f, 4.98855338e-02f, 1.09274328e-01f, -1.05546691e-01f, -1.06318770e-02f, 1.02379888e-01f, 8.17449838e-02f,
  -7.87708312e-02f, -9.06404573e-03f, -9.91820917e-03f, -3.89939919e-02f, 6.55546635e-02f, 1.06725469e-03f, 1.51082724e-01f, 4.15445231e-02f, 1.49503112e-01f, 3.36019695e-02f,
  2.24841803e-01f, 1.52693875e-02f, -5.08403406e-02f, 1.01869069e-01f, 6.55342685e-03f, 1.00297734e-01f, 1.57413594e-02f, -4.60544489e-02f, 1.32760489e-02f, 1.34930849e-01f,
  4.51476499e-02f, 2.11848225e-02f, -1.06084213e-01f, 7.96901658e-02f, 2.75597721e-02f, -6.68344423e-02f, -4.35504541e-02f, 6.42434657e-02f, -6.33577853e-02f, 4.44376357e-02f,
  1.48652103e-02f, 1.52206626e-02f, -4.14085165e-02f, 8.19948167e-02f, 1.27839252e-01f, -6.75960034e-02f, 3.80834006e-02f, -8.64443928e-02f, -2.95714773e-02f, -3.59544009e-02f,
  -3.51941660e-02f, 1.73087925e-01f, -7.15841576e-02f, -2.04094648e-02f, 1.15642786e-01f, -7.50307813e-02f, 1.78262051e-02f, 1.62293822e-01f, 1.39644872e-02f, -3.00638191e-02f,
  1.70625538e-01f, 1.07056610e-01f, 1.91881552e-01f, -1.43151164e-01f, -3.75400558e-02f, -1.34794891e-01f, -5.44393808e-02f, 8.97150561e-02f, -6.09447248e-02f, 1.87016368e-01f,
  -1.00754119e-01f, 9.54238772e-02f, -1.18047379e-01f, -7.83550292e-02f, -3.64638157e-02f, -1.65079609e-01f, 4.54570912e-02f, -1.14251405e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 52)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 52;
const float L2_fan_Bp_bar_data[] = {
  1.81459457e-01f, -8.27122554e-02f, -1.13072999e-01f, -3.95637639e-02f, 6.49979396e-04f, -5.72638474e-02f, 9.24123973e-02f, -7.59699494e-02f, 8.24447647e-02f, 8.97830054e-02f,
  -1.16776317e-01f, 2.28830595e-02f, 3.70949768e-02f, -8.11791644e-02f, -2.40166429e-02f, 4.38774191e-03f, 1.21999621e-01f, 2.59682424e-02f, 1.84558071e-02f, 7.35146180e-02f,
  1.91599518e-01f, 1.15641870e-01f, -3.89973968e-02f, -4.17588167e-02f, 1.86828628e-01f, 1.77418530e-01f, 4.85347770e-02f, -2.14899834e-02f, -1.98330861e-02f, -4.01683860e-02f,
  7.66660720e-02f, 5.20923436e-02f, -6.54761717e-02f, -8.00882000e-03f, 2.96814181e-02f, 1.25209004e-01f, -1.13932773e-01f, -7.53524825e-02f, 5.91202006e-02f, 4.13429784e-03f,
  5.34540378e-02f, 1.53295606e-01f, 3.51221897e-02f, -3.67882140e-02f, 4.08658870e-02f, 3.33756879e-02f, 9.07472968e-02f, 9.58127156e-03f, 6.67839572e-02f, 1.58991873e-01f,
  1.10167176e-01f, -3.89790125e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  9.68586430e-02f, 6.59266412e-02f, -5.54572158e-02f, 1.52442455e-01f, 1.13885395e-01f, 1.22581124e-01f, 7.53139332e-02f, 1.37784123e-01f, -2.56208796e-02f, -1.89096093e-01f,
  1.95210263e-01f, -1.26022771e-01f, -3.10040116e-01f, 4.65031475e-01f, 1.08649313e-01f, -9.81267914e-02f, -1.74241498e-01f, 5.05037308e-02f, 2.15220824e-01f, 2.85436157e-02f,
  5.22877760e-02f, 7.38503039e-02f, -3.89468744e-02f, -4.01020169e-01f, 1.39595091e-01f, 3.66264507e-02f, -8.32980871e-02f, 2.55807132e-01f, -2.33911574e-01f, 5.74860387e-02f,
  2.27390915e-01f, 3.61999050e-02f, -2.36011278e-02f, 7.47227967e-02f, 5.57574406e-02f, -3.98563564e-01f, -3.12006652e-01f, -3.38956982e-01f, 1.48732290e-01f, 9.50905904e-02f,
  8.06664377e-02f, 9.70245972e-02f, -2.38853201e-01f, -1.74849138e-01f, -1.97402239e-01f, -1.50750205e-01f, -7.71205947e-02f, -9.09915939e-02f, 6.31410480e-02f, -1.09514311e-01f,
  3.05607975e-01f, -7.93447495e-02f, 2.03626409e-01f, 4.01443154e-01f, 5.76929927e-01f, -3.72029655e-02f, -1.97988078e-01f, -9.16898176e-02f, -3.46909195e-01f, 1.20078370e-01f,
  -4.53386195e-02f, -7.04778880e-02f, -2.99565226e-01f, -1.12418696e-01f, -6.95775971e-02f, 1.38777948e-03f, 2.28914749e-02f, 5.06481901e-02f, -1.18833467e-01f, -2.97185957e-01f,
  -2.93860793e-01f, -1.92728534e-01f, -1.17352456e-01f, -1.07460149e-01f, -2.54145503e-01f, -2.66243726e-01f, -1.00095995e-01f, 4.10424441e-01f, -6.74092546e-02f, 7.61239976e-02f,
  5.75515367e-02f, 1.86183080e-01f, -1.70569181e-01f, 9.55129191e-02f, 3.64992046e-03f, -2.60254890e-01f, 4.23035808e-02f, 1.39564022e-01f, -4.01366092e-02f, 8.30718037e-03f,
  -3.04177273e-02f, 9.04204845e-02f, 1.17806591e-01f, 1.23281674e-02f, 1.44111171e-01f, 4.57381517e-01f, 7.41508529e-02f, -8.17299411e-02f, 3.85815091e-02f, 1.77628975e-02f,
  -1.89520404e-01f, -2.36968338e-01f, -4.64172840e-01f, -5.04914261e-02f, -3.61683667e-02f, 1.45401359e-01f, 1.69000685e-01f, 2.33434275e-01f, -3.31319310e-02f, 1.26288265e-01f,
  2.62099672e-02f, 1.69957711e-04f, -2.46834066e-02f, 7.95544237e-02f, -2.28413835e-01f, 1.43534586e-01f, -1.77551806e-01f, 2.82725692e-01f, 1.75108910e-01f, 4.27545235e-02f,
  -3.25041115e-01f, 2.62621511e-02f, -1.90214381e-01f, 3.02051067e-01f, -8.11982974e-02f, -4.10784245e-01f, -2.18716934e-01f, 2.99532086e-01f, -2.17846390e-02f, -1.87843710e-01f,
  -3.26347835e-02f, -3.28923832e-03f, 3.09820287e-02f, -1.39495671e-01f, -2.53712505e-01f, -1.21552438e-01f, -1.33976087e-01f, -2.21606612e-01f, -1.48622334e-01f, -3.05024207e-01f,
  3.29283178e-01f, -1.90242231e-02f, 6.04644902e-02f, 7.28756487e-02f, 8.76855329e-02f, -1.09774783e-01f, -2.41237268e-01f, -1.20129570e-01f, 2.65294671e-01f, -1.70804054e-01f,
  5.44536971e-02f, -1.76942512e-01f, 1.32077470e-01f, 1.14684723e-01f, 2.45497271e-01f, -4.03705895e-01f, 1.96672231e-01f, 3.17993052e-02f, -3.80919985e-02f, -1.35465309e-01f,
  -3.62023681e-01f, 1.46105632e-01f, 6.62257001e-02f, 4.91476119e-01f, 4.99452710e-01f, 3.26303095e-02f, -3.67858917e-01f, 1.13782898e-01f, 8.68146867e-02f, 4.52375561e-02f,
  -1.21208295e-01f, 4.72069860e-01f, 1.59223720e-01f, -2.52528280e-01f, -5.93020320e-02f, -6.13548346e-02f, -8.86089355e-02f, -1.93526726e-02f, -1.29128903e-01f, 1.11717872e-01f,
  -2.88059831e-01f, 1.86621323e-01f, -2.13559151e-01f, -2.80938633e-02f, -4.05385941e-01f, -1.02204800e-01f, -2.23404333e-01f, 3.03987533e-01f, -6.53778017e-02f, -2.93524772e-01f,
  -1.97003007e-01f, 5.20254672e-03f, -1.70028940e-01f, 8.15896243e-02f, -1.02505989e-01f, -2.85685778e-01f, -2.73734450e-01f, -2.35613093e-01f, 2.60255486e-01f, 1.45134568e-01f,
  1.42680749e-01f, -1.60921454e-01f, 2.56084144e-01f, 2.90609866e-01f, -3.57134044e-01f, -2.96524107e-01f, 1.23170227e-01f, -9.08792615e-02f, -5.64785786e-02f, -7.92188868e-02f,
  -7.84957856e-02f, 5.13642989e-02f, -1.19055316e-01f, -2.09583566e-01f, -9.60181991e-04f, -1.77804276e-01f, -3.77389193e-01f, -3.16929966e-02f, 1.00064473e-02f, 2.27526262e-01f,
  5.80993183e-02f, -1.08580388e-01f, -9.20029506e-02f, -5.43484628e-01f, -1.24110781e-01f, 4.60756645e-02f, -2.44011432e-02f, -9.72251669e-02f, 8.90434459e-02f, 2.73373127e-01f,
  6.01424813e-01f, 2.32051928e-02f, 2.19668597e-02f, -1.97695836e-01f, 2.46679008e-01f, -3.39351445e-01f, -1.63247138e-01f, -1.97786346e-01f, 2.49971207e-02f, 5.99633083e-02f,
  -4.85731103e-02f, 6.29733279e-02f, 3.24058771e-01f, -7.01059848e-02f, 1.30994052e-01f, -2.70498455e-01f, 3.04118335e-01f, -1.33484125e-01f, 7.99264684e-02f, 1.60101295e-01f,
  -1.97563708e-01f, -2.40126491e-01f, 3.69586200e-02f, 7.15917870e-02f, 5.19035459e-01f, -1.05231702e-01f, 8.35716352e-02f, 6.64425120e-02f, 1.49271786e-01f, -4.90466915e-02f,
  1.94571912e-01f, 4.93310951e-02f, 3.88858169e-01f, -3.20885493e-03f, 1.52853593e-01f, 5.12080371e-01f, 5.96315935e-02f, 2.90344894e-01f, -1.93323612e-01f, -2.05067158e-01f,
  1.30157769e-01f, 9.56847146e-02f, -2.19826490e-01f, 4.12758887e-02f, 1.11064017e-01f, 7.52225146e-02f, 1.72053054e-01f, -1.65791325e-02f, 9.27324891e-02f, -1.77252114e-01f,
  4.47724372e-01f, 4.16940935e-02f, -1.39151722e-01f, 3.53465050e-01f, -1.55985832e-01f, 1.35621075e-02f, 6.29573986e-02f, -1.19035356e-01f, -8.31790268e-02f, 1.06816910e-01f,
  -1.56594217e-01f, 5.01654111e-02f, 4.27840710e-01f, 1.49751827e-01f, 1.58497289e-01f, -1.18324146e-01f, 8.81423056e-02f, -1.84596151e-01f, -6.55487627e-02f, -1.51314914e-01f,
  -1.57079905e-01f, -3.63050513e-02f, 3.87674496e-02f, 9.36944410e-03f, 5.76694347e-02f, 4.71798107e-02f, 3.67373824e-01f, 1.09582700e-01f, -3.94551866e-02f, -2.65892535e-01f,
  3.07829678e-01f, -5.78577220e-02f, 3.08625810e-02f, 1.02041431e-01f, 1.86081752e-01f, -2.63680100e-01f, 4.65604812e-02f, 1.47631347e-01f, -5.64683080e-02f, 4.56762649e-02f,
  2.26410136e-01f, 4.69876714e-02f, 5.81955537e-02f, 1.46133095e-01f, 2.26962999e-01f, -4.15604934e-03f, -4.11725231e-02f, 2.32275411e-01f, 2.16669008e-01f, -1.30822346e-01f,
  -2.19953939e-01f, -3.86008322e-01f, -1.77023202e-01f, 1.00901447e-01f, -1.54512830e-03f, 5.52966483e-02f, 3.02221403e-02f, 2.43429035e-01f, 9.47055668e-02f, -1.17544215e-02f,
  -3.02078396e-01f, 1.96401939e-01f, 5.61855212e-02f, 2.24200621e-01f, 3.64403464e-02f, -9.24715959e-03f, -2.40037128e-01f, -1.64120659e-01f, -5.97681627e-02f, 2.90009975e-02f,
  -6.52800277e-02f, 4.50195611e-01f, 5.71110368e-01f, -1.10438466e-01f, 1.05731338e-01f, -1.96815044e-01f, -3.81580919e-01f, -8.47098231e-02f, 1.16746597e-01f, -1.69312339e-02f,
  9.59163681e-02f, 1.58512108e-02f, -1.58140153e-01f, -2.35780761e-01f, 5.84544875e-02f, 2.12742060e-01f, -5.23057133e-02f, -1.28192082e-01f, -3.23901549e-02f, -1.18860714e-01f,
  -6.53866902e-02f, -6.40427843e-02f, -6.28252327e-02f, 9.61570889e-02f, 1.72988176e-01f, -1.18674472e-01f, 1.55547597e-02f, -2.21756054e-04f, 4.75376606e-01f, -9.10542011e-02f,
  -2.81656533e-02f, 7.48479217e-02f, -1.32630363e-01f, -7.39670023e-02f, 1.56619221e-01f, 2.00978622e-01f, 2.93911934e-01f, 3.06213796e-02f, 3.65402251e-02f, 8.87599811e-02f,
  -2.83056021e-01f, 1.81480706e-01f, 1.36857539e-01f, -5.01505770e-02f, -2.55528033e-01f, 6.93665072e-02f, 3.05719763e-01f, -4.18203473e-01f, -8.39692075e-03f, 4.05863933e-02f,
  -5.39430864e-02f, -1.28887847e-01f, 3.72516699e-02f, 9.80416429e-04f, -2.83831358e-01f, 3.41144949e-01f, -2.97679473e-03f, 7.25442171e-02f, 1.31749243e-01f, 4.19466831e-02f,
  -1.74078792e-01f, -5.49838066e-01f, -2.65845776e-01f, -5.04442938e-02f, -4.46981788e-02f, 1.23690076e-01f, 2.52246469e-01f, -1.03636891e-01f, 1.63654052e-02f, 1.50044829e-01f,
  2.87207186e-01f, 4.32646751e-01f, -4.04709190e-01f, -1.33956343e-01f, 6.92843320e-03f, -2.63968706e-01f, -7.56805688e-02f, 3.16530049e-01f, 1.23550855e-01f, 9.60265398e-02f,
  -4.56955135e-02f, -1.38720885e-01f, 1.32657383e-02f, 1.14956394e-01f, -2.74677604e-01f, 1.52315525e-02f, -7.88548961e-03f, 2.32326731e-01f, -2.31869027e-01f, 1.00617856e-01f,
  -8.58177338e-03f, 8.38155597e-02f, 5.32475710e-01f, 5.86106628e-02f, 3.56634483e-02f, -1.94154382e-02f, -1.77740365e-01f, -3.26124758e-01f, -4.68471140e-01f, -3.16598088e-01f,
  -6.86256364e-02f, -3.72004569e-01f, -2.51371473e-01f, -1.50780573e-01f, 1.61489442e-01f, 1.81143001e-01f, -1.96453080e-01f, -3.22072282e-02f, 1.69409797e-01f, 1.88402936e-01f,
  -1.02165051e-01f, 7.92947039e-02f, 1.02030419e-01f, -1.01258941e-01f, 4.34537195e-02f, 1.40436351e-01f, 2.51989514e-01f, 4.05671895e-02f, -5.76159800e-04f, -7.78913647e-02f,
  8.85539278e-02f, 2.00084060e-01f, 8.37243199e-02f, 1.60756856e-02f, -5.44241928e-02f, 5.58868229e-01f, -1.18800335e-01f, -1.57970004e-02f, 2.40515899e-02f, -9.14710611e-02f,
  -1.28525645e-01f, 9.56080183e-02f, -2.97314115e-02f, -3.16563934e-01f, -5.32589972e-01f, -3.23082536e-01f, 1.84402183e-01f, -4.98386770e-02f, -2.51740068e-02f, 1.82660185e-02f,
  2.05116749e-01f, -1.23367734e-01f, 3.35787833e-02f, -2.63858110e-01f, -2.65756231e-02f, -3.82210054e-02f, 2.03977190e-02f, -2.98682991e-02f, 2.78143406e-01f, 2.28761770e-02f,
  2.10286081e-01f, -1.61582083e-02f, -2.08848447e-01f, 1.59626976e-02f, 3.26491714e-01f, -1.02877989e-01f, -4.64475602e-01f, -3.95445302e-02f, -1.06792398e-01f, -1.77285820e-01f,
  1.72236934e-01f, -5.41000329e-02f, -2.23473147e-01f, -1.63496640e-02f, -1.55469090e-01f, 6.61562160e-02f, 2.54766233e-02f, -2.56177545e-01f, -5.49022630e-02f, -9.27172527e-02f,
  1.71222508e-01f, -6.08786866e-02f, 1.24765582e-01f, -2.54989982e-01f, 1.60958320e-01f, 2.44433507e-01f, -2.95155998e-02f, -2.56796479e-02f, 1.25448823e-01f, 7.67299831e-02f,
  -2.12052807e-01f, -7.70375729e-02f, -2.54104659e-02f, 5.48203140e-02f, 7.93010145e-02f, 4.32005934e-02f, -6.61839783e-01f, 6.75806776e-02f, 3.63249332e-01f, -2.68678486e-01f,
  2.88026363e-01f, 1.23102941e-01f, 4.57147993e-02f, 2.72928681e-02f, 2.37746581e-01f, -1.19052120e-01f, -7.50843063e-02f, -1.88830063e-01f, -3.01304162e-01f, -1.55799717e-01f,
  7.62496982e-03f, -6.22838736e-02f, -1.55192232e-02f, 7.68278614e-02f, -2.09827617e-01f, 2.59913832e-01f, 2.29826123e-01f, 4.94120836e-01f, -2.32879054e-02f, -1.14748895e-01f,
  2.49750484e-02f, 8.40411335e-02f, -8.35418627e-02f, -1.23318955e-01f, -1.65523887e-02f, 1.09939449e-01f, -2.10938796e-01f, -1.06456392e-01f, 3.74148935e-01f, 1.19438574e-01f,
  -3.17661285e-01f, -6.18336257e-04f, 1.07121050e-01f, 1.80852473e-01f, -8.26812014e-02f, -1.10366069e-01f, 1.38254628e-01f, 9.15855318e-02f, -4.15925356e-03f, 2.75327116e-01f,
  1.98683873e-01f, 2.65173882e-01f, 2.10334033e-01f, -6.27662912e-02f, -3.06756079e-01f, -1.29914090e-01f, -7.84305930e-02f, 1.75233275e-01f, 6.67659938e-02f, -3.63336295e-01f,
  -4.56160717e-02f, -9.80751440e-02f, 9.64914635e-02f, -9.56211686e-02f, 1.83526129e-01f, 1.36251291e-02f, 3.29225242e-01f, 1.00348666e-01f, -1.11331694e-01f, -2.96753675e-01f,
  7.32796133e-01f, 1.05997950e-01f, -1.51860975e-02f, -2.38098487e-01f, -2.53430605e-01f, 1.22308008e-01f, -1.24907941e-01f, 3.21497917e-01f, -2.63464242e-01f, 3.20240676e-01f,
  -1.06379904e-01f, 3.18492949e-01f, 1.06461547e-01f, 1.74974754e-01f, -3.88249695e-01f, 4.37942892e-02f, -8.76767412e-02f, -1.07032098e-01f, -9.18418542e-02f, -2.10147157e-01f,
  -2.07370147e-01f, -5.13306558e-01f, -9.83367041e-02f, 1.24378502e-01f, 9.11533237e-02f, 8.13835263e-02f, 1.12093594e-02f, -4.13948372e-02f, -5.84047846e-02f, 1.43017322e-01f,
  -2.83785909e-01f, -9.03461277e-02f, 1.42595127e-01f, -2.40497501e-03f, -7.84522593e-02f, 3.48109044e-02f, -7.30081946e-02f, 2.81496104e-02f, -2.17497543e-01f, 7.08228946e-02f,
  6.47745579e-02f, 6.83927238e-02f, 1.93132609e-01f, -5.45823202e-02f, 1.50189742e-01f, 1.73381418e-01f, 4.35905941e-02f, -7.44183362e-02f, 5.04630990e-02f, 2.44708583e-01f,
  1.74156740e-01f, -3.98406796e-02f, -3.23845036e-02f, -4.52837534e-02f, 1.05172701e-01f, -4.91912365e-02f, -6.29402623e-02f, -1.59324646e-01f, -2.74858773e-01f, 5.93759492e-02f,
  -9.66543034e-02f, -4.24129777e-02f, 7.09417090e-02f, 2.94295549e-01f, -3.95831823e-01f, -2.97618601e-02f, -9.70756263e-02f, 9.01938379e-02f, 3.96329790e-01f, 1.07992090e-01f,
  7.53747821e-02f, -2.62856126e-01f, -2.74380505e-01f, -1.74916927e-02f, -2.06733271e-02f, -4.46042605e-02f, 4.43605691e-01f, 1.36825576e-01f, 3.80121559e-01f, 3.93912457e-02f,
  4.48686397e-03f, 4.07889634e-02f, 3.42210561e-01f, 4.26049799e-01f, -6.38520345e-02f, 1.70415770e-02f, -1.84251778e-02f, 5.13486639e-02f, 9.95828509e-02f, -5.97657152e-02f,
  -2.25991458e-01f, -1.13888159e-01f, 1.93380564e-01f, -4.57681268e-01f, -1.20057687e-01f, -1.33091331e-01f, -1.88834414e-01f, -7.28810504e-02f, -1.86714351e-01f, 2.01402947e-01f,
  -5.54939546e-02f, -4.30949032e-02f, 3.73487979e-01f, 1.01232752e-01f, 9.26256273e-03f, -7.60935014e-03f, -1.49170324e-01f, -7.52584562e-02f, -6.47999421e-02f, 1.12516925e-01f,
  -1.49716362e-01f, 2.24645048e-01f, 2.47665435e-01f, 2.33752772e-01f, 1.65416598e-01f, 1.04105882e-01f, 2.56351650e-01f, -3.22688699e-01f, -9.58928093e-02f, 1.19268954e-01f,
  -1.03669450e-01f, -1.67608678e-01f, -3.76113108e-03f, -9.24676508e-02f, -3.29936631e-02f, -2.31227085e-01f, -3.22960783e-03f, 2.32839450e-01f, -3.91196638e-01f, 4.86862361e-02f,
  -1.11335911e-01f, -2.28951514e-01f, 2.15508491e-02f, -8.04009438e-02f, 9.70890149e-02f, -3.40505660e-01f, 3.33812088e-01f, 6.61743879e-02f, -2.90673859e-02f, 9.12138522e-02f,
  -2.88876235e-01f, 3.62126559e-01f, 1.90366820e-01f, -5.25543019e-02f, -1.04697779e-01f, -1.26864746e-01f, -1.02726966e-01f, -3.00190598e-01f, 5.52133881e-02f, 4.21820611e-01f,
  1.05821772e-03f, 1.92324728e-01f, 1.29856821e-02f, 3.09568569e-02f, 4.53481674e-02f, -1.13773696e-01f, -1.38099194e-01f, -3.02716523e-01f, -1.82415381e-01f, -6.50122166e-02f,
  3.69972229e-01f, -2.64430158e-02f, 3.81955147e-01f, -2.42442966e-01f, -6.77369013e-02f, 3.74964476e-01f, 1.80067345e-01f, -9.58272070e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.05115667e-01f, -1.28969267e-01f, -1.10996747e-02f, 3.10131758e-02f, 1.87552840e-01f, 1.61294103e-01f, 1.13494761e-01f, -2.84535289e-01f, -3.60734691e-03f, 3.04975007e-02f,
  1.79342523e-01f, 1.27087450e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 52
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 6, 52
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    