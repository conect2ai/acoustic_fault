/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 51 x 120)
const int L0_fan_Wp_rows = 51;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.62187928e-01f, 1.58723935e-01f, 2.22834066e-01f, -1.16415657e-01f, 3.37689556e-02f, -2.66025402e-02f, 2.21249506e-01f, -2.05404647e-02f, -3.85398191e-04f, -4.82354872e-03f,
  -1.75415665e-01f, 1.50260359e-01f, 4.16075662e-02f, -3.15133214e-01f, -1.89848632e-01f, -1.43928066e-01f, -1.65178597e-01f, -3.46069783e-02f, -1.34964511e-01f, 9.42288041e-02f,
  -1.43153876e-01f, -9.96513218e-02f, -5.65755647e-03f, 4.75750975e-02f, 1.47874758e-01f, 8.21041986e-02f, 5.18352911e-02f, 1.66229874e-01f, -3.78667824e-02f, -5.66683933e-02f,
  -6.48698583e-02f, -5.02340868e-02f, 2.13010013e-01f, 1.00971714e-01f, 1.09498210e-01f, 1.45961776e-01f, 1.51858374e-01f, 6.15655482e-02f, 4.12461534e-03f, 5.89987524e-02f,
  6.88839257e-02f, 3.06815114e-02f, -1.09483160e-01f, -2.15148851e-02f, 1.05264015e-01f, 4.20930870e-02f, -5.71364686e-02f, 8.07308406e-02f, 1.16975335e-02f, -8.97232145e-02f,
  2.05854047e-02f, -1.30124584e-01f, -7.77892694e-02f, -1.03643928e-02f, -7.12200776e-02f, -6.10567369e-02f, -2.00443622e-02f, 5.84185943e-02f, 3.52218561e-02f, -5.51682189e-02f,
  4.19949405e-02f, 1.19942091e-01f, 6.81817112e-03f, 1.21592805e-01f, 4.54248339e-02f, -4.46867943e-02f, 3.96836549e-02f, -3.32895517e-02f, 5.26033062e-03f, -2.57918499e-02f,
  -9.65786800e-02f, -6.89576715e-02f, -6.16976097e-02f, 3.51875015e-02f, -7.46536301e-03f, -2.75227055e-02f, 4.58842143e-02f, -7.87568912e-02f, -3.05146296e-02f, -5.21883331e-02f,
  1.16007298e-01f, -1.76882967e-02f, -9.09731090e-02f, 6.72509074e-02f, -2.62098797e-02f, 1.32809449e-02f, -3.37223895e-02f, -7.11659640e-02f, -1.04591446e-02f, 6.37397841e-02f,
  2.56468177e-01f, 2.30172649e-01f, 7.77549669e-02f, 6.19203039e-03f, 4.35855649e-02f, -4.70656902e-02f, 1.04917435e-03f, -5.72633632e-02f, 1.48078635e-01f, -2.97057768e-03f,
  2.47484650e-02f, 1.92595460e-02f, 7.60521814e-02f, -5.55896014e-02f, -4.92424257e-02f, -2.20556594e-02f, 5.22322543e-02f, 1.45558224e-04f, 1.32888198e-01f, 5.48197478e-02f,
  1.18116789e-01f, 2.53286096e-04f, -3.57504115e-02f, -3.47778760e-02f, 1.62378531e-02f, -8.51580948e-02f, 1.81268584e-02f, -5.75728565e-02f, -7.30455145e-02f, 2.98932157e-02f,
  3.24583858e-01f, 3.60128760e-01f, -2.39892945e-01f, 1.62150621e-01f, 1.36088401e-01f, 2.99929436e-02f, -1.08549083e-02f, 1.32783592e-01f, 1.70925975e-01f, 2.44784653e-01f,
  -9.83032882e-02f, 2.12295428e-01f, -2.62836874e-01f, -5.09348661e-02f, -3.56800199e-01f, -2.87801564e-01f, 1.67382866e-01f, 9.56508219e-02f, 2.09324099e-02f, 2.72825003e-01f,
  -6.20368347e-02f, 8.13000277e-02f, -2.50974953e-01f, 2.10711241e-01f, 1.26566231e-01f, 1.08638443e-01f, -9.63713080e-02f, -4.40275930e-02f, 6.39221519e-02f, -4.72837500e-02f,
  -1.56984538e-01f, 9.36322510e-02f, -1.31313140e-02f, -3.76465470e-02f, 5.88760562e-02f, 3.61212865e-02f, -2.11603008e-02f, -1.08608492e-01f, -1.35748848e-01f, -2.04304047e-02f,
  1.40945297e-02f, -3.57822925e-02f, 1.06427796e-01f, 6.93453923e-02f, 2.07494959e-01f, 6.67422339e-02f, -7.76489601e-02f, -8.64591673e-02f, 6.38575107e-02f, -6.40552714e-02f,
  -1.05838124e-02f, -6.26604334e-02f, 1.36419684e-01f, 8.16356391e-03f, -4.56507206e-02f, 2.21563522e-02f, -4.24210317e-02f, -6.03280924e-02f, -4.22180854e-02f, 8.97164643e-02f,
  7.03436285e-02f, 8.34904686e-02f, -7.82443956e-03f, -2.91341785e-02f, 4.74357605e-02f, 3.11145396e-03f, 3.77698094e-02f, -2.03905553e-02f, 3.97290327e-02f, 6.63297949e-03f,
  -9.99115221e-03f, 1.83795393e-02f, 3.38900611e-02f, 5.99107444e-02f, 4.89685945e-02f, 4.47766371e-02f, -1.12460591e-02f, 5.15452623e-02f, 3.41522209e-02f, -7.50476941e-02f,
  -4.42194492e-02f, 2.23212093e-02f, 4.01337129e-05f, -5.79620004e-02f, -5.10757528e-02f, -4.70797159e-02f, 4.52433266e-02f, 5.28835617e-02f, -5.28702289e-02f, -2.07492206e-02f,
  -1.53741203e-02f, 2.20544249e-01f, 2.42803097e-02f, -3.34460638e-03f, 8.42044950e-02f, 9.81564745e-02f, 9.59484093e-03f, 2.78137829e-02f, 5.71096018e-02f, 1.43897057e-01f,
  1.08201183e-01f, 5.83799370e-02f, 7.76212849e-03f, 4.31332812e-02f, -4.03097905e-02f, -5.62123172e-02f, -2.05737371e-02f, 7.98764266e-03f, 1.05665147e-03f, 6.12559495e-03f,
  4.28189449e-02f, 7.24384189e-02f, 4.64838813e-04f, 9.73570794e-02f, 9.37582739e-03f, -1.49258468e-02f, 3.22109945e-02f, 8.54651630e-03f, -8.69866926e-04f, -6.50649192e-03f,
  -1.69534981e-01f, -5.04478455e-01f, 1.06987491e-01f, -6.89219609e-02f, 1.16038412e-01f, 9.51616019e-02f, -1.33938134e-01f, -6.93680197e-02f, -3.64752620e-01f, -2.79647708e-01f,
  -9.83953699e-02f, 5.51300216e-03f, -1.75814286e-01f, -2.08143368e-01f, 3.59500468e-01f, -3.49719733e-01f, -4.33061980e-02f, -6.40173182e-02f, -7.68155158e-02f, 1.82293907e-01f,
  8.66545960e-02f, 5.54675236e-02f, 2.41616696e-01f, 1.30916953e-01f, 2.17310842e-02f, 2.07146406e-01f, 2.89493531e-01f, 2.05767334e-01f, 1.56908184e-01f, -4.11238931e-02f,
  -1.91729799e-01f, -2.05106452e-01f, -3.53125036e-02f, -1.65839717e-02f, 6.19886853e-02f, 6.30508289e-02f, 8.01771060e-02f, -1.67828444e-02f, 1.32549768e-02f, 2.02286188e-02f,
  -1.83613021e-02f, 8.44924673e-02f, -5.45366108e-02f, -3.34293693e-02f, -7.08820149e-02f, 3.46257351e-02f, 2.77845487e-02f, -7.25290477e-02f, 1.07035949e-03f, 7.20721716e-03f,
  4.84264717e-02f, 5.16289473e-02f, 4.04080003e-03f, 3.47220376e-02f, 8.07122514e-02f, -3.22645716e-02f, 1.00970782e-01f, 1.59973532e-01f, -5.55600859e-02f, 7.92538673e-02f,
  -7.90847689e-02f, 6.50459602e-02f, 7.14983493e-02f, -1.26548097e-01f, 9.79581475e-03f, -2.60709692e-02f, -4.35436554e-02f, 4.80154939e-02f, 3.37516260e-03f, -6.62454590e-02f,
  5.40003888e-02f, -7.48956129e-02f, -1.61089208e-02f, 4.16164473e-02f, 7.35317394e-02f, -8.66336152e-02f, 4.50505801e-02f, 3.68930139e-02f, 4.83407266e-02f, -2.29591969e-02f,
  -1.10421382e-01f, -7.74885481e-03f, 1.11250192e-01f, 3.72951031e-02f, -5.63583523e-02f, 1.30529970e-01f, 2.25192010e-02f, -8.33207965e-02f, 4.60814126e-02f, 1.33100048e-01f,
  -2.11670827e-02f, 1.03602335e-01f, -4.03287867e-03f, -3.95553783e-02f, -1.61211282e-01f, -4.48936597e-02f, -7.99628943e-02f, 1.98734179e-03f, 1.62442657e-03f, -7.83888809e-03f,
  3.14830765e-02f, 1.12352865e-02f, -1.22846048e-02f, 4.16500680e-02f, 7.62108788e-02f, -3.11491955e-02f, 2.07995102e-02f, 4.08597551e-02f, 2.18662452e-02f, 4.98374328e-02f,
  6.99725002e-02f, 4.42297533e-02f, 5.56418719e-03f, 9.16954502e-02f, 1.71629095e-03f, 3.76625210e-02f, 4.58563305e-02f, 4.86803502e-02f, 4.48430143e-03f, -8.03795010e-02f,
  4.30818886e-01f, -1.24979205e-01f, -2.00701520e-01f, 1.20200559e-01f, 2.99986064e-01f, 3.12726229e-01f, 8.94511789e-02f, 2.18818665e-01f, 2.32011452e-01f, -2.03674603e-02f,
  1.91181675e-01f, -3.63182843e-01f, -1.64738968e-01f, 6.79612812e-03f, 1.39102057e-01f, -1.72580734e-01f, 1.03112623e-01f, -3.81323285e-02f, -8.00021738e-02f, 1.26137108e-01f,
  1.32983819e-01f, 2.22892255e-01f, -2.80367553e-01f, -1.81354918e-02f, 7.71050081e-02f, -6.73972741e-02f, -9.29640979e-02f, -1.74800739e-01f, -1.13090850e-01f, -8.34117830e-02f,
  -1.83706135e-02f, 1.64592505e-01f, 6.46409988e-02f, -5.41613437e-03f, 1.21726461e-01f, 2.22933907e-02f, -3.94573063e-02f, -9.71971005e-02f, -4.85208817e-02f, -1.18013984e-02f,
  -8.71468782e-02f, -3.02919168e-02f, -1.01989299e-01f, -6.68762252e-02f, 1.57999963e-01f, -1.90331470e-02f, 2.07268577e-02f, -1.24816205e-02f, -6.35242090e-02f, 1.10021979e-01f,
  -5.28942272e-02f, 7.02047497e-02f, 1.47694334e-01f, -1.66168679e-02f, 2.43534371e-02f, 9.53143612e-02f, -4.83135320e-02f, -9.25792456e-02f, 1.42311612e-02f, 1.09502859e-01f,
  7.07983449e-02f, -8.20349678e-02f, 1.07633173e-02f, -1.14584856e-01f, 7.76022598e-02f, 2.95116138e-02f, -4.49862368e-02f, 2.80315634e-02f, -4.22672704e-02f, 8.47099647e-02f,
  2.76328437e-02f, -4.29162793e-02f, 7.93299451e-03f, 1.81747675e-02f, 5.02544977e-02f, 1.72506981e-02f, -1.61738005e-02f, -7.63203353e-02f, 9.29248985e-03f, -5.30101955e-02f,
  5.77171566e-03f, -3.59078385e-02f, -5.74616194e-02f, -3.74875031e-02f, -4.49924693e-02f, 8.77394527e-02f, -3.28709148e-02f, -3.11141089e-03f, -8.12568292e-02f, -1.78075209e-02f,
  2.52490211e-02f, 1.33136004e-01f, -6.29736111e-02f, -1.32746056e-01f, -1.23578861e-01f, 6.79172501e-02f, -4.01111366e-03f, 6.30621240e-02f, -2.75664274e-02f, 3.65157798e-02f,
  1.39749320e-02f, -1.76615696e-02f, 1.00480959e-01f, -4.51011695e-02f, -1.12705059e-01f, 6.53636307e-02f, -9.52629074e-02f, -5.79265058e-02f, 1.45906433e-02f, -4.75743413e-02f,
  -3.54371071e-02f, 2.13243756e-02f, -5.40264584e-02f, 2.37217862e-02f, 8.31714272e-02f, 3.19189322e-03f, 4.81941625e-02f, 4.62589487e-02f, 8.15298930e-02f, -5.17252879e-03f,
  -2.97782511e-01f, 1.52685195e-01f, -2.58467555e-01f, -2.31558904e-01f, 2.62655150e-02f, 1.89922377e-01f, -2.42677152e-01f, -1.55481651e-01f, -4.01459008e-01f, -6.82263961e-03f,
  1.04355946e-01f, -2.27766901e-01f, 3.93149769e-03f, 3.82199176e-02f, 1.86590180e-01f, 2.41362527e-01f, 2.36140415e-01f, -2.08523944e-02f, 1.65151618e-02f, -4.91376258e-02f,
  1.02464914e-01f, 3.63902956e-01f, 2.24033266e-01f, 2.45056659e-01f, 1.09002367e-02f, -1.42432839e-01f, 2.32441649e-01f, -3.67666669e-02f, 1.71979591e-01f, 9.94375274e-02f,
  1.14548884e-01f, -2.59877026e-01f, -9.49932113e-02f, -8.11643004e-02f, 7.43555790e-03f, -3.05993091e-02f, 1.62056331e-02f, 3.10772355e-03f, -1.07776850e-01f, -2.11323481e-02f,
  -7.09884018e-02f, -3.25536244e-02f, -1.00655900e-02f, 2.12491378e-02f, -7.65962228e-02f, -1.07740596e-01f, -2.53473371e-02f, 4.13155556e-02f, -7.25188628e-02f, -3.17527950e-02f,
  -4.38755788e-02f, -1.45219639e-02f, 8.80096387e-03f, 1.13740349e-02f, -1.40211526e-02f, -7.11756423e-02f, -3.27846222e-02f, 4.91923019e-02f, 5.58476103e-03f, -4.37831469e-02f,
  7.22636282e-02f, 6.62648380e-02f, 4.22563590e-02f, 2.57497113e-02f, -5.92337288e-02f, 1.76723152e-02f, 3.59470211e-02f, 2.26314217e-02f, -7.60225859e-03f, 5.14624044e-02f,
  -4.93961498e-02f, -7.12611154e-02f, -7.54231885e-02f, -6.81412145e-02f, 3.70481573e-02f, 5.61067509e-03f, 3.08222137e-02f, 2.78084781e-02f, 4.16953079e-02f, 5.52319512e-02f,
  -4.12064046e-02f, -2.39519477e-02f, 1.71200819e-02f, -3.11116669e-02f, 3.00291274e-02f, -5.48036257e-03f, -3.58755067e-02f, -7.12471874e-03f, -2.90889456e-03f, 5.58336675e-02f,
  1.60299629e-01f, 1.39979944e-01f, 2.39263866e-02f, -1.44789042e-02f, -3.52035975e-03f, 4.36075851e-02f, 2.54495051e-02f, 6.56774119e-02f, 3.25617157e-02f, -4.60705832e-02f,
  4.72533889e-02f, -7.40767494e-02f, 3.56060341e-02f, 1.55648878e-02f, 1.44545868e-01f, 6.82831649e-03f, -2.05649789e-02f, 2.53480896e-02f, 6.53641224e-02f, 6.22103587e-02f,
  3.06841210e-02f, 6.55940734e-03f, 2.69580223e-02f, 3.84430215e-02f, -8.46391823e-03f, 8.77346247e-02f, 1.05220331e-02f, -4.37830538e-02f, 1.40353039e-01f, 5.75916469e-03f,
  -1.96488515e-01f, 1.00015298e-01f, -2.58913726e-01f, -4.29353178e-01f, 1.79238632e-01f, 2.80386239e-01f, 4.26451080e-02f, 3.13886032e-02f, -1.29874840e-01f, 2.68152565e-01f,
  1.52079359e-01f, -3.23996842e-01f, 8.93608555e-02f, 1.03825547e-01f, -3.31760138e-01f, 3.32049839e-02f, 2.03116417e-01f, -2.38714591e-02f, -2.37196863e-01f, 8.37768801e-03f,
  1.16095133e-01f, 1.27153546e-01f, -3.28249633e-02f, 5.79098314e-02f, 2.86797345e-01f, -2.25950316e-01f, 2.73182485e-02f, -1.66652367e-01f, 5.67749375e-03f, -2.16593947e-02f,
  1.36726484e-01f, -1.08971313e-01f, 1.30718678e-01f, 4.54568081e-02f, 1.63800046e-01f, 9.56428349e-02f, -4.10136487e-03f, -1.59510840e-02f, -1.07118517e-01f, -3.50829810e-02f,
  1.12515934e-01f, 2.09604595e-02f, -2.10423619e-02f, -1.61269901e-03f, 2.34216657e-02f, -2.62323711e-02f, 3.56543995e-03f, 1.67425722e-01f, -3.68549339e-02f, 8.53878260e-02f,
  1.01333432e-01f, 8.96112397e-02f, 6.25351667e-02f, 1.27215097e-02f, -2.05296315e-02f, 5.64171709e-02f, -1.02367718e-04f, -5.75700728e-03f, 6.97565898e-02f, -2.33885199e-02f,
  -5.62925339e-02f, -9.82876942e-02f, -8.00684094e-03f, -9.10346583e-02f, -6.35719672e-02f, 5.27655706e-02f, 7.25178495e-02f, 2.96345185e-02f, 5.23635244e-04f, 5.55628240e-02f,
  1.28894821e-01f, 6.17028661e-02f, 2.93520801e-02f, 8.97745714e-02f, -9.96041670e-03f, -2.46468391e-02f, -3.53263505e-02f, 5.20448312e-02f, 5.82628064e-02f, 1.45761920e-02f,
  -5.87082841e-02f, 5.00266030e-02f, 3.65594104e-02f, 1.12190306e-01f, -6.21118471e-02f, -1.08037770e-01f, 2.13993937e-02f, 6.55571222e-02f, 4.93225195e-02f, 2.80639972e-03f,
  1.95696220e-01f, -1.72526702e-01f, 3.28564346e-02f, 1.36794403e-01f, -6.69148415e-02f, 1.25243232e-01f, -7.38233030e-02f, 4.49840911e-02f, 5.11188805e-03f, 7.87058175e-02f,
  -1.32428175e-02f, 7.99857453e-02f, -5.68254180e-02f, -1.16401995e-02f, -6.05126880e-02f, 1.91789176e-02f, -4.75681350e-02f, 2.04212982e-02f, 1.61641836e-02f, 7.80185163e-02f,
  1.09175190e-01f, 5.42545598e-03f, 8.19368362e-02f, 1.06332257e-01f, 4.11905348e-02f, 1.55440727e-02f, -1.61090255e-01f, -3.66101600e-02f, -1.75418742e-02f, -5.53767383e-02f,
  -2.54611492e-01f, 2.99501896e-01f, -1.12155251e-01f, -3.13890576e-01f, 1.22203991e-01f, 2.49608159e-01f, -2.45818481e-01f, 2.16953218e-01f, 2.98252672e-01f, 4.35075462e-02f,
  -1.73127159e-01f, -7.12460130e-02f, 9.77043286e-02f, -1.54137775e-01f, -3.44736099e-01f, 3.69293988e-02f, -8.11248571e-02f, 1.26702664e-02f, 2.64701307e-01f, -4.76675928e-02f,
  1.31807458e-02f, -1.76986724e-01f, -2.71443963e-01f, 6.71595410e-02f, -2.12572142e-02f, 1.38332367e-01f, -2.82098204e-01f, 7.67356604e-02f, -1.50328949e-01f, 3.29511985e-03f,
  1.46887347e-01f, 7.74922594e-03f, -1.20182119e-01f, 5.06349280e-02f, 2.09374630e-04f, 6.31772503e-02f, -7.53592253e-02f, -1.44296706e-01f, -4.16968130e-02f, 3.74319442e-02f,
  7.77346035e-03f, -4.24951091e-02f, 2.40897145e-02f, 5.29911667e-02f, 1.70887426e-01f, 8.94646570e-02f, 1.77503396e-02f, 2.93881800e-02f, 1.43302130e-02f, -5.18143140e-02f,
  -2.21533678e-03f, 2.28356048e-02f, -1.10412464e-02f, 1.60233751e-02f, -5.89934401e-02f, 6.57828748e-02f, -6.32746369e-02f, -6.40358403e-02f, 1.35608176e-02f, 2.26949318e-03f,
  -4.78395494e-03f, 1.08010851e-01f, -4.71705496e-02f, -5.16991429e-02f, 6.60443353e-03f, -1.97515823e-03f, -2.95984577e-02f, -1.25329122e-01f, 8.15979987e-02f, -6.80537075e-02f,
  1.94117501e-02f, -9.27020423e-03f, 7.63385743e-02f, 6.06175251e-02f, -5.34197986e-02f, -5.64202555e-02f, -8.34895447e-02f, 6.60056323e-02f, 6.25866130e-02f, -6.20725080e-02f,
  -1.61848906e-02f, 1.04730316e-01f, 3.29164863e-02f, 2.96578612e-02f, 4.20815386e-02f, -8.54932442e-02f, 1.08195417e-01f, -9.09324456e-03f, 8.27535149e-03f, -5.09518832e-02f,
  2.68968463e-01f, 1.74237594e-01f, 8.67727399e-03f, 3.34904641e-02f, -1.66400115e-03f, -4.91496101e-02f, -1.82333891e-03f, 6.40660077e-02f, 1.22215755e-01f, -5.13899401e-02f,
  4.83911950e-03f, 7.79894516e-02f, 3.52496393e-02f, 2.27793641e-02f, -7.83917233e-02f, -7.53159821e-02f, -6.17311820e-02f, 2.43257005e-02f, -7.80623555e-02f, 9.85218436e-02f,
  -1.54914156e-01f, -5.43327294e-02f, -6.09598309e-02f, 3.50157730e-02f, 8.98009574e-04f, -3.98977213e-02f, 5.57118244e-02f, 3.44102383e-02f, -2.56326534e-02f, 1.01782702e-01f,
  -3.88069212e-01f, -8.24160874e-02f, -7.29093999e-02f, -2.51907051e-01f, -1.66886419e-01f, 1.58044785e-01f, 3.17768216e-01f, -2.33542964e-01f, -2.05693468e-01f, 2.46431440e-01f,
  9.16433409e-02f, -2.64389902e-01f, 3.42843056e-01f, -2.64379561e-01f, -2.03887329e-01f, 2.35509753e-01f, -1.56588972e-01f, -2.53631379e-02f, -2.55754553e-02f, -1.88687533e-01f,
  -1.44953668e-01f, -1.50663376e-01f, -1.05307348e-01f, -8.34605098e-02f, -3.09335411e-01f, -1.39371112e-01f, 9.48426351e-02f, 1.67383149e-01f, -1.97466925e-01f, -5.70575371e-02f,
  -1.60026595e-01f, -1.37807399e-01f, 3.68504822e-02f, -6.53017387e-02f, -8.35091919e-02f, 5.92590086e-02f, -1.24077061e-02f, 6.32333085e-02f, 6.15527146e-02f, -7.28049204e-02f,
  4.94979583e-02f, -9.26145837e-02f, -1.13380320e-01f, 1.41600743e-01f, -6.74766824e-02f, -9.23666731e-02f, -4.78730351e-02f, -3.66762057e-02f, -1.14489399e-01f, 1.43847140e-02f,
  -3.66454385e-02f, -1.42162085e-01f, -3.10781840e-02f, -3.33991684e-02f, -8.13863054e-02f, -9.75406729e-03f, -1.38332564e-02f, -1.00132264e-02f, -1.57927215e-01f, -9.21820849e-02f,
  6.75584450e-02f, 9.92674157e-02f, -4.22464460e-02f, -2.40789969e-02f, -1.11421263e-02f, -5.02670594e-02f, 3.89476158e-02f, -3.60076502e-02f, -1.69921536e-02f, -2.54689846e-02f,
  -7.97617063e-02f, -2.46726871e-02f, -8.02008435e-02f, 7.87962601e-02f, 1.90439932e-02f, -1.46039370e-02f, 1.05462357e-01f, 5.53561840e-03f, -7.88016170e-02f, -2.21869443e-02f,
  2.77813524e-02f, 1.57952141e-02f, -6.83727860e-03f, -4.28100117e-02f, -4.81059328e-02f, -3.02128401e-02f, -5.18991724e-02f, -4.34024958e-03f, 9.99542996e-02f, 6.01784475e-02f,
  -4.74301837e-02f, -1.17802203e-01f, 7.00504929e-02f, 7.24161568e-04f, 7.99343064e-02f, -1.60732437e-02f, -4.19420330e-03f, -2.49733645e-02f, -4.09230068e-02f, 4.44236770e-02f,
  -5.51386084e-03f, 3.84971383e-03f, -2.22751293e-02f, 1.08670527e-02f, 3.94214876e-02f, -1.76896974e-02f, 1.70372091e-02f, -3.12239975e-02f, 1.95990019e-02f, -6.17085099e-02f,
  -7.26273842e-03f, 2.78439634e-02f, 4.73663695e-02f, -4.28622626e-02f, 8.54118913e-03f, -5.72676351e-03f, -2.71997899e-02f, 1.11216055e-02f, 4.56915013e-02f, -5.43968659e-03f,
  3.02137733e-02f, 4.30124439e-02f, 3.43709826e-01f, 2.16112472e-02f, -1.70590624e-01f, -2.72114187e-01f, -1.84121728e-01f, -5.83499111e-02f, 3.09474409e-01f, -1.53197899e-01f,
  -1.47441760e-01f, 2.43967950e-01f, 5.23324087e-02f, -1.96888998e-01f, 2.14542653e-02f, 1.27792329e-01f, -2.00627983e-01f, -1.20118111e-01f, 2.31302842e-01f, -7.90828913e-02f,
  2.96214186e-02f, -2.57441133e-01f, -7.61355739e-03f, -1.35185376e-01f, -2.60862857e-01f, 3.52829769e-02f, -3.08408976e-01f, 1.42280862e-01f, -2.91143239e-01f, 7.55530968e-02f,
  -1.22934930e-01f, 9.49658751e-02f, 3.91450450e-02f, 3.99864987e-02f, -2.14376554e-01f, -3.03125978e-02f, -6.41455650e-02f, 1.09682754e-01f, 9.09485109e-03f, 6.00393116e-02f,
  1.61041748e-02f, 6.08604252e-02f, -3.27369198e-02f, 8.38106945e-02f, 3.93139720e-02f, 1.10680930e-01f, 4.78321128e-02f, -5.91785423e-02f, 8.89035612e-02f, 2.06088368e-02f,
  1.02362745e-01f, 2.52400357e-02f, -6.11357316e-02f, 5.80282919e-02f, 3.02577186e-02f, 4.84885909e-02f, 3.30275334e-02f, -1.76250543e-02f, 2.60889567e-02f, -5.77219937e-04f,
  4.61575985e-02f, -7.31987529e-05f, -1.96610913e-02f, 1.38255712e-02f, 1.48435244e-02f, 3.70109198e-03f, 1.11628659e-02f, -1.84564386e-02f, 4.21030931e-02f, -6.64213821e-02f,
  -9.67779011e-02f, 2.18108818e-02f, 4.40538637e-02f, -3.23506594e-02f, -6.65566921e-02f, 5.03491051e-02f, -2.24872176e-02f, -4.69566584e-02f, -9.80506986e-02f, -2.13910546e-03f,
  5.47862947e-02f, -1.79066532e-03f, -1.40020787e-03f, -2.00745910e-02f, 2.92912833e-02f, 8.41954350e-03f, 1.72567368e-02f, 5.35543449e-02f, 5.70238680e-02f, 1.36245843e-02f,
  -3.58079106e-01f, -1.20586768e-01f, 1.13902595e-02f, -1.99029129e-02f, 1.77006740e-02f, -3.78571674e-02f, 1.35978431e-01f, 8.37012529e-02f, -8.67071897e-02f, 1.09513804e-01f,
  -2.75143944e-02f, -1.27885610e-01f, -8.71299431e-02f, -4.33780290e-02f, -7.10742606e-04f, -1.31926566e-01f, -1.33077085e-01f, -3.20554376e-02f, -1.20072030e-01f, -7.77321681e-02f,
  -5.21057695e-02f, -3.77796106e-02f, 1.20077878e-01f, -8.72237757e-02f, -2.51047648e-02f, -1.22352645e-01f, -2.16661729e-02f, 7.31075704e-02f, -1.05172815e-02f, 1.32842576e-02f,
  -5.41103780e-01f, -2.88693219e-01f, -2.72704810e-01f, -1.64181530e-01f, -5.19296788e-02f, -2.18137838e-02f, -1.22835562e-01f, -2.85993129e-01f, -3.12503815e-01f, 1.13986328e-01f,
  8.67772251e-02f, -2.04427242e-01f, -8.69450271e-02f, 2.63251632e-01f, -1.42275676e-01f, 9.10181478e-02f, -1.06873408e-01f, 1.54721010e-02f, -5.44710197e-02f, -2.32349753e-01f,
  -9.98899713e-03f, 9.16408151e-02f, 6.86794817e-02f, -7.83309434e-03f, -3.38995606e-02f, -2.51789987e-01f, 9.33828857e-03f, 1.71601330e-03f, 2.25346327e-01f, 1.13760568e-01f,
  -5.13930209e-02f, -2.54134893e-01f, -1.30931810e-01f, -1.26553727e-02f, -7.79038221e-02f, 8.41544382e-03f, -3.99501808e-02f, 3.60575356e-02f, 5.11798263e-03f, -2.94512343e-02f,
  3.13842855e-02f, 1.11631937e-02f, 7.82228410e-02f, 6.10561185e-02f, -6.88585490e-02f, -4.81315218e-02f, 6.26804978e-02f, -2.41268948e-02f, -3.42105702e-02f, -2.31731180e-02f,
  -4.49756533e-02f, 9.58451852e-02f, -8.30514207e-02f, 2.58585904e-02f, -8.31770822e-02f, -1.58228837e-02f, 8.98986124e-03f, 2.88873492e-03f, -1.13019705e-01f, -1.09566614e-01f,
  1.43827312e-02f, 9.59001705e-02f, -1.32131264e-01f, 9.63118076e-02f, -3.38692293e-02f, 1.05333522e-01f, -4.61289100e-02f, 4.62958142e-02f, -8.52948502e-02f, -5.00985002e-03f,
  7.77613670e-02f, -6.60338178e-02f, -4.64332923e-02f, 7.31872395e-02f, -3.89192663e-02f, -4.52596843e-02f, 5.07893041e-02f, -2.02242117e-02f, 9.87241939e-02f, 2.47418904e-03f,
  -4.23040949e-02f, -2.05259714e-02f, -3.34548615e-02f, 2.71029100e-02f, -2.87975883e-03f, -3.71076167e-02f, -4.80219349e-02f, -1.20159678e-01f, 4.27969433e-02f, -3.21771801e-02f,
  -2.57983297e-01f, -3.94793391e-01f, -4.44191694e-02f, -1.26414234e-02f, 7.98546448e-02f, -4.34332639e-02f, 5.38625568e-02f, -1.23918541e-01f, -6.37579411e-02f, -1.17871955e-01f,
  -4.59575318e-02f, 7.57474080e-02f, -2.07511149e-02f, -2.08088139e-04f, 9.23278928e-03f, -2.87993643e-02f, 7.48276617e-03f, -1.25099700e-02f, -2.53675170e-02f, -1.98519547e-02f,
  -7.87694827e-02f, -6.13181181e-02f, 1.33583033e-02f, -5.73442057e-02f, 9.49877873e-02f, 8.71891677e-02f, -8.68743360e-02f, 1.15947574e-02f, 2.55566072e-02f, 2.18589362e-02f,
  -6.48000240e-01f, -2.24907875e-01f, -2.35006645e-01f, -1.71575099e-01f, -9.44941267e-02f, -3.85172106e-02f, -7.90421367e-02f, -3.55820358e-01f, -3.53544444e-01f, -7.85381272e-02f,
  -3.41387466e-02f, -2.38893434e-01f, -5.07604070e-02f, -1.42425388e-01f, 1.15575055e-02f, 8.95750672e-02f, 3.09696719e-02f, -9.49883014e-02f, -4.65373769e-02f, -1.55510366e-01f,
  -4.30499427e-02f, 1.23593159e-01f, 1.46504745e-01f, 1.68716073e-01f, -2.60099679e-01f, -1.19193226e-01f, 1.54075176e-01f, 1.67594820e-01f, 1.22732125e-01f, 3.47221680e-02f,
  -1.37268752e-01f, -2.65561968e-01f, -1.18235745e-01f, 4.66026179e-02f, -5.34709878e-02f, 2.13674139e-02f, 4.57057543e-02f, -2.34860042e-03f, 3.92770171e-02f, -2.08081771e-02f,
  -1.49257109e-03f, -7.47347102e-02f, 3.86413559e-02f, 6.42122477e-02f, -8.94396752e-02f, -6.65996894e-02f, -9.62597430e-02f, 3.80632258e-03f, -1.28641278e-01f, -2.37751473e-02f,
  -1.03451513e-01f, -4.49642539e-03f, 2.71003582e-02f, 3.41117382e-02f, -4.53493558e-02f, -5.47607131e-02f, 3.92949991e-02f, 4.26649256e-03f, -6.06487133e-02f, -4.96095605e-02f,
  1.14888541e-01f, -3.30736749e-02f, -7.03700678e-03f, -7.45198801e-02f, -3.77999879e-02f, 4.95655574e-02f, 3.26374755e-03f, 7.69558176e-02f, 1.87148787e-02f, 5.10020368e-03f,
  5.21625765e-02f, -1.20343216e-01f, 1.73506625e-02f, -1.35746249e-03f, 1.55632319e-02f, -2.15012394e-02f, 6.05407581e-02f, -1.65985152e-02f, -3.03770192e-02f, 2.86690854e-02f,
  -4.64108437e-02f, 1.96782984e-02f, -5.10030836e-02f, 2.35209297e-02f, 1.12868566e-02f, -1.25184525e-02f, -4.94402647e-02f, -8.87728781e-02f, 1.50716482e-02f, 2.92335469e-02f,
  -1.32058784e-01f, -1.10343948e-01f, 1.53681664e-02f, -3.27457003e-02f, 9.85833332e-02f, 1.80938765e-02f, -2.49643344e-03f, 1.30663021e-03f, -1.51772527e-02f, 1.28740817e-02f,
  1.20871430e-02f, 1.40068345e-02f, 4.78782766e-02f, 3.67104588e-03f, 3.24327871e-02f, -1.95871070e-02f, 1.13102131e-01f, -4.22728397e-02f, 1.72083862e-02f, 6.66414350e-02f,
  5.55675514e-02f, 4.25958484e-02f, 7.40058348e-02f, 8.71051475e-03f, 6.18639961e-02f, 6.76872060e-02f, -2.03274712e-02f, 1.47748021e-02f, 9.55768973e-02f, 2.10184976e-02f,
  -2.49868378e-01f, 2.22764686e-01f, -2.54523516e-01f, 1.15799215e-02f, 9.36568249e-03f, 3.14562917e-01f, 1.48691997e-01f, 2.21289799e-01f, 2.80516028e-01f, 3.85196567e-01f,
  1.96751535e-01f, 4.79291715e-02f, -7.16597065e-02f, 1.53888643e-01f, -6.50250539e-02f, -4.70056236e-02f, 1.23682395e-01f, -1.87654346e-02f, -4.27793972e-02f, -5.57372980e-02f,
  -1.04515277e-01f, 1.48287177e-01f, -3.40652436e-01f, 1.17709428e-01f, -1.33996636e-01f, -4.21921257e-03f, -1.27897248e-01f, -3.45321298e-02f, 1.52519019e-02f, 8.96247774e-02f,
  5.94590083e-02f, 1.16619892e-01f, -2.11389929e-01f, -1.30303338e-01f, -7.71750808e-02f, -6.89823776e-02f, -3.06145642e-02f, -7.77341127e-02f, -2.36846115e-02f, 7.90639967e-03f,
  2.85504246e-03f, -1.32666193e-02f, 6.19872622e-02f, -1.71647593e-02f, -1.23469923e-02f, -8.07963964e-03f, -1.87459782e-01f, 6.15930669e-02f, 1.53082167e-03f, -1.86087996e-01f,
  -2.03061141e-02f, 7.60078430e-03f, 2.01454517e-02f, 3.31507176e-02f, -8.79040733e-02f, 1.32796064e-01f, 1.92018729e-02f, 4.20503058e-02f, 1.74224610e-03f, 6.45440370e-02f,
  3.95047665e-02f, 1.99258570e-02f, -9.30257812e-02f, -5.19855926e-03f, -1.20584422e-03f, -2.21836511e-02f, 5.84466457e-02f, -6.31416962e-02f, -1.75469443e-01f, -4.49886434e-02f,
  2.69213039e-02f, -1.75265111e-02f, 6.93891793e-02f, -5.45053445e-02f, 3.47776264e-02f, 1.34252563e-01f, -3.60322371e-02f, 2.46252934e-03f, 5.75487539e-02f, -4.43864148e-03f,
  1.24464661e-01f, 8.79144073e-02f, -9.30149332e-02f, 4.78384122e-02f, 7.28801861e-02f, -6.13046810e-02f, -9.07811597e-02f, 1.21757202e-01f, -1.26622111e-01f, -1.06441550e-01f,
  1.37522072e-01f, 1.87305450e-01f, -1.01568267e-01f, 7.68864006e-02f, -1.43231526e-02f, -9.23736244e-02f, -4.69411649e-02f, 4.81058396e-02f, 5.42114675e-02f, -6.95065185e-02f,
  -6.45447150e-02f, -6.64308071e-02f, 5.87630346e-02f, 3.33993547e-02f, 3.55766863e-02f, 5.08663207e-02f, 3.67066972e-02f, 4.05443683e-02f, 1.56040639e-01f, 4.94783856e-02f,
  -6.11104444e-02f, 2.29792707e-02f, 1.00140711e-02f, -8.89449473e-03f, -9.59326252e-02f, 4.48794067e-02f, 6.37883022e-02f, 3.01963557e-02f, 3.64432596e-02f, 1.26224793e-02f,
  -8.91081393e-02f, 1.93341970e-01f, 1.33293301e-01f, 3.86518687e-02f, -2.67007977e-01f, -6.48450032e-02f, 4.27885234e-01f, -1.76468715e-01f, 1.77089006e-01f, 2.36790553e-01f,
  -1.28638476e-01f, 2.48718172e-01f, 2.44753659e-01f, -4.24163043e-02f, -2.27174550e-01f, 1.65035248e-01f, -1.75119415e-01f, 1.33496989e-02f, 3.49616222e-02f, -1.22883312e-01f,
  -1.10350072e-01f, -2.72178799e-01f, -1.46611780e-01f, -1.58776075e-01f, -1.79121122e-01f, -3.83165479e-02f, -2.51763880e-01f, 1.36788100e-01f, -1.77629665e-01f, -1.32982433e-01f,
  -1.15779616e-01f, -1.52399736e-02f, 1.33796915e-01f, -1.65075641e-02f, -2.20756186e-03f, 6.13150485e-02f, 5.11018671e-02f, 1.06266439e-01f, 1.51780784e-01f, 9.24348310e-02f,
  1.40360266e-01f, -1.12375751e-01f, 6.51971549e-02f, 2.94087864e-02f, -5.26675619e-02f, 5.32411551e-03f, -1.17161488e-02f, -9.25884768e-03f, 5.52583672e-02f, -5.40451892e-02f,
  9.72986445e-02f, -9.09378901e-02f, -2.44423822e-02f, 3.75195895e-03f, -1.13105383e-02f, 3.33402008e-02f, 7.79645443e-02f, -2.60651717e-03f, -1.15511365e-01f, -6.80134296e-02f,
  -1.31396782e-02f, 1.57027121e-03f, 1.71420276e-02f, -8.78507495e-02f, 6.94469213e-02f, -3.21333259e-02f, 4.60992754e-03f, -6.03665374e-02f, 2.17658598e-02f, -7.77051151e-02f,
  -4.70055342e-02f, -9.11648106e-03f, -1.15422029e-02f, 5.93303032e-02f, 6.81561530e-02f, 2.05204133e-02f, 2.54047066e-02f, -1.06679901e-01f, -2.91711017e-02f, -6.10500984e-02f,
  1.44112045e-02f, -3.17580514e-02f, -5.84855378e-02f, -6.10373020e-02f, -2.85886135e-02f, 4.63913241e-03f, 9.97888041e-04f, -2.17954740e-02f, 4.60419580e-02f, -3.37372012e-02f,
  -1.77827686e-01f, -2.98071891e-01f, 3.13231982e-02f, -1.45130113e-01f, -6.51029646e-02f, -9.73569378e-02f, 1.05231911e-01f, 1.52820372e-03f, 1.20509295e-02f, -2.50320844e-02f,
  2.51526926e-02f, 4.81421836e-02f, -1.59416318e-01f, 2.09345780e-02f, 6.77128062e-02f, 7.32196542e-03f, 1.76701229e-02f, 3.34107615e-02f, -5.56422435e-02f, -4.39454950e-02f,
  -4.46883775e-02f, 3.58620547e-02f, 7.29181096e-02f, -7.68001005e-02f, -2.70300247e-02f, -2.93957572e-02f, -8.47929940e-02f, 1.98767334e-02f, -8.61256719e-02f, 4.03368324e-02f,
  2.05814525e-01f, -9.36627984e-02f, -1.20231379e-02f, 1.52631355e-02f, 5.54909259e-02f, -2.74554908e-01f, -3.10497582e-01f, 3.37360725e-02f, -2.39736274e-01f, -2.85924207e-02f,
  -5.37966229e-02f, 1.56664014e-01f, -1.36658311e-01f, -1.01177722e-01f, -2.65615195e-01f, -2.29095265e-01f, -8.86095911e-02f, 1.86977908e-02f, -8.33437219e-02f, -1.32527687e-02f,
  1.63308568e-02f, -2.37659827e-01f, -3.14050950e-02f, 3.42412069e-02f, 2.84852475e-01f, 2.90194720e-01f, 2.05651984e-01f, 1.24297589e-01f, 1.65356293e-01f, 4.24171351e-02f,
  1.11556211e-02f, -5.12026139e-02f, 1.06187820e-01f, -8.58749226e-02f, -1.85767990e-02f, -5.91381860e-04f, 2.18826875e-01f, 4.61625941e-02f, 7.34269321e-02f, 4.12423201e-02f,
  7.68295974e-02f, 3.77073027e-02f, 6.85334264e-04f, -1.13796376e-01f, -1.66327599e-02f, 7.68955098e-03f, -5.92387766e-02f, 1.21387914e-01f, -5.78451343e-02f, -4.99042459e-02f,
  -6.86556175e-02f, 7.84121305e-02f, 5.74440323e-02f, 2.68575139e-02f, -3.92189771e-02f, -8.57000723e-02f, -3.86286601e-02f, 1.05715580e-01f, -1.73472445e-02f, -1.05468687e-02f,
  -3.51369195e-02f, -8.55059829e-03f, -6.32985011e-02f, -1.58178303e-02f, -1.27476707e-01f, 2.37691104e-02f, -7.79136224e-03f, 1.42113771e-02f, 4.59439531e-02f, 2.18220078e-03f,
  -4.29301150e-02f, -3.31937261e-02f, 6.21580556e-02f, -9.65937302e-02f, -7.66561367e-04f, 4.37223427e-02f, 7.44784176e-02f, 8.62774700e-02f, -7.74175376e-02f, 8.62332508e-02f,
  -2.06516907e-02f, -5.43639511e-02f, -6.22082576e-02f, 4.08906676e-03f, -3.93316783e-02f, -4.01005298e-02f, 5.12354299e-02f, 3.78100201e-02f, 4.99866344e-02f, 3.27545255e-02f,
  -1.48536697e-01f, -9.76194143e-02f, -1.09183900e-01f, -3.72921415e-02f, -8.37250128e-02f, -5.80959022e-03f, -8.78230929e-02f, -4.37242240e-02f, -7.99274817e-02f, -1.24577090e-01f,
  7.96423629e-02f, 1.11596854e-02f, 8.11450183e-02f, 7.52392283e-04f, 6.48481622e-02f, -6.78047761e-02f, 1.51773198e-02f, 1.27676383e-01f, 1.31107733e-01f, -2.40813522e-03f,
  7.86806345e-02f, 4.45827693e-02f, 1.03576474e-01f, -1.48520023e-01f, 1.31168425e-01f, 6.97556883e-02f, -8.13259631e-02f, 5.05032775e-04f, -1.30345849e-02f, 1.72719378e-02f,
  1.22380793e-01f, -3.49461995e-02f, 2.37052813e-01f, 5.05083382e-01f, -2.12751538e-01f, -3.06400359e-01f, 3.91806751e-01f, -5.24587259e-02f, 3.33958447e-01f, 3.78087610e-02f,
  -1.78173911e-02f, -1.34873062e-01f, 2.93797970e-01f, 1.32657439e-01f, -1.75319061e-01f, 5.08238487e-02f, 2.56554782e-01f, 7.46714941e-04f, 2.72844508e-02f, 1.70075372e-01f,
  5.06566912e-02f, -1.55758411e-01f, 3.23382437e-01f, -2.93295324e-01f, 1.76937982e-01f, 1.95125174e-02f, 7.57596120e-02f, -5.94890043e-02f, -1.69701591e-01f, -2.91435689e-01f,
  9.49123409e-03f, 6.66708350e-02f, 8.75933766e-02f, -6.57353774e-02f, 7.14052096e-02f, -3.49772945e-02f, 3.25228907e-02f, -3.46832201e-02f, 1.59778297e-02f, -1.57033894e-02f,
  3.72034945e-02f, -8.81787911e-02f, 4.63014729e-02f, -2.33364999e-02f, 2.62537245e-02f, -4.42288741e-02f, -1.93710215e-02f, 1.09589607e-01f, 1.12461178e-02f, 2.15156414e-02f,
  8.10515732e-02f, 1.23960003e-02f, 9.84575674e-02f, -2.25690175e-02f, 1.58317629e-02f, -5.07820491e-03f, 7.06010014e-02f, -3.79510038e-02f, -3.13859098e-02f, -6.08046390e-02f,
  -7.83827156e-02f, 8.16757903e-02f, 9.24003590e-03f, 8.63526091e-02f, 2.50490624e-02f, 1.91772766e-02f, -1.57329496e-02f, -6.80141747e-02f, 1.90594811e-02f, -7.72425265e-04f,
  2.97781751e-02f, -5.58407605e-02f, -3.53624788e-03f, 4.16483358e-02f, 5.73368883e-03f, 5.06823249e-02f, -6.43711537e-03f, -4.39718887e-02f, 9.81631055e-02f, 9.96648520e-03f,
  1.40248449e-03f, -2.91749015e-02f, 3.62945274e-02f, 6.93270564e-03f, -3.89058958e-03f, 2.33806800e-02f, -1.59906410e-02f, 4.77390783e-03f, 1.26754209e-01f, -8.05873331e-03f,
  -6.68498725e-02f, -4.04251553e-02f, 4.67304997e-02f, -1.10778928e-01f, -3.61811817e-02f, -4.65571098e-02f, -4.59990203e-02f, -5.80434017e-02f, -5.39498078e-03f, 5.04906662e-02f,
  4.54326579e-03f, 8.14115629e-02f, 2.86055934e-02f, -7.07246959e-02f, -6.49721827e-04f, 7.06078634e-02f, 7.35563263e-02f, -1.47136915e-02f, -1.62784923e-02f, -1.65463373e-01f,
  7.85064846e-02f, 1.31579314e-03f, -6.27937689e-02f, 8.16093162e-02f, -1.97206461e-03f, 5.25917783e-02f, -1.48300126e-01f, -1.72085874e-02f, -6.52832314e-02f, -4.13283519e-02f,
  -3.46922636e-01f, 4.68917847e-01f, -7.17991441e-02f, 7.04530180e-02f, -2.46908441e-01f, -2.36277878e-01f, -1.27261147e-01f, 8.30842704e-02f, 8.26092809e-02f, 2.97515392e-01f,
  -5.54755516e-03f, 2.50592351e-01f, 1.83500707e-01f, 3.45959097e-01f, -2.17090130e-01f, 2.94831514e-01f, 1.06524572e-01f, 1.85461596e-01f, 1.31457716e-01f, -2.45854370e-02f,
  -6.55185548e-04f, 5.91250211e-02f, 8.60540718e-02f, 1.01837024e-01f, -8.30266699e-02f, -1.17837042e-02f, -7.19077289e-02f, -1.82918441e-02f, 3.62913869e-02f, -2.51181386e-02f,
  -9.27807689e-02f, -1.08994555e-03f, -9.30987578e-03f, -1.40928961e-02f, -1.13849960e-01f, -8.22083652e-02f, -6.21276051e-02f, -3.59712839e-02f, -1.23439446e-01f, -3.42935026e-02f,
  3.10982694e-03f, -3.42501397e-03f, 9.31248721e-03f, 2.52797250e-02f, -1.14320191e-02f, 2.16507334e-02f, 2.89039724e-02f, -2.43746229e-02f, 5.20967022e-02f, -2.38295868e-02f,
  -5.51382042e-02f, -4.76663113e-02f, -5.36329001e-02f, 8.99915993e-02f, -2.09542550e-02f, -3.36415842e-02f, 7.90355355e-03f, -8.01338106e-02f, 1.10282242e-01f, -1.31225027e-02f,
  -9.83030200e-02f, 2.08586026e-02f, 1.62896439e-02f, 2.36970074e-02f, 1.11187007e-02f, -1.39020756e-02f, 6.68154359e-02f, 2.38695890e-02f, -3.50701958e-02f, 2.05509234e-02f,
  -6.18445650e-02f, -4.30294499e-03f, 3.82972956e-02f, -5.38182631e-02f, -4.16104235e-02f, 3.44608277e-02f, -4.86821383e-02f, 4.77279872e-02f, -9.79734436e-02f, -2.50681490e-02f,
  5.11115678e-02f, -1.01807192e-02f, -2.08247174e-02f, -3.51906903e-02f, 8.47301111e-02f, -3.68913710e-02f, 5.54873012e-02f, -1.11828251e-02f, -9.95904114e-03f, -4.22869287e-02f,
  7.23054707e-02f, 2.25998729e-01f, 6.76239580e-02f, 6.63934788e-03f, 1.23880707e-01f, -3.04098297e-02f, 1.57904234e-02f, 3.62536907e-02f, 1.11694112e-01f, -1.16318157e-02f,
  -1.26822025e-01f, -1.73302721e-02f, 2.31593642e-02f, 1.20681655e-02f, -2.32782011e-04f, 2.88404105e-03f, -6.12833025e-03f, -6.05845228e-02f, -4.87268008e-02f, 5.62386727e-03f,
  -3.08935381e-02f, -6.62175789e-02f, 1.64058693e-02f, -8.28146935e-02f, -7.02988647e-04f, -6.84639364e-02f, -3.18805613e-02f, 2.89384322e-03f, 2.31123473e-02f, 8.63516480e-02f,
  -1.93998709e-01f, -4.38212484e-01f, -3.42713058e-01f, 9.58363563e-02f, 1.87793314e-01f, 1.41545862e-01f, 4.41493429e-02f, -2.35822462e-02f, -2.47292355e-01f, 3.65500804e-03f,
  1.84241578e-01f, -2.97124922e-01f, -1.05330482e-01f, 2.69916922e-01f, -2.04048678e-01f, -2.25091010e-01f, 1.41237929e-01f, 7.46701360e-02f, -1.04973599e-01f, -1.59327611e-02f,
  1.70755927e-02f, 1.91995159e-01f, 3.06905014e-03f, 1.42000780e-01f, 1.10196128e-01f, -4.76062000e-02f, 1.70935825e-01f, 8.58779531e-03f, 1.85990810e-01f, -7.24871596e-03f,
  9.03795660e-02f, -1.13680787e-01f, 1.80088151e-02f, -6.33414835e-02f, 8.66627470e-02f, 1.03778645e-01f, 7.11653233e-02f, 9.56993084e-03f, 4.93891388e-02f, -1.85892843e-02f,
  7.39261741e-03f, 2.31103622e-03f, -5.07757179e-02f, -3.40032242e-02f, 2.15949416e-02f, -2.36260518e-02f, 2.40057986e-02f, 5.96066639e-02f, 2.85000820e-02f, -7.68352970e-02f,
  -9.84611511e-02f, -3.59092234e-03f, 3.22740152e-02f, -1.97244342e-02f, -6.10660203e-02f, -1.96344089e-02f, -5.79099171e-02f, -8.82382244e-02f, 5.94533086e-02f, -5.98327294e-02f,
  4.48132753e-02f, -5.92336478e-03f, -8.28694105e-02f, 6.30884543e-02f, -2.72557809e-04f, 1.04409903e-01f, 5.77330776e-02f, 9.65344161e-02f, -6.18478432e-02f, 2.11556051e-02f,
  5.35601377e-02f, 7.69918226e-03f, 1.22111186e-01f, -3.33703756e-02f, -4.13011014e-03f, 1.38635347e-02f, 2.64526587e-02f, -8.32219273e-02f, -1.81876030e-03f, 4.00674306e-02f,
  1.47353746e-02f, 4.48240303e-02f, -2.08476484e-02f, 9.12850574e-02f, -5.25214039e-02f, -9.09910649e-02f, 4.77142408e-02f, -5.68170138e-02f, 3.48854549e-02f, 1.00658117e-02f,
  -2.58801598e-02f, -3.09835196e-01f, -1.99426450e-02f, 3.53018381e-03f, -7.10541476e-03f, -3.77500318e-02f, -2.30330285e-02f, -5.90149537e-02f, -3.89746986e-02f, -2.02062391e-02f,
  5.62031195e-02f, 8.06006044e-02f, -3.39701287e-02f, 7.73501024e-02f, 4.05879840e-02f, -8.23418051e-03f, -2.82488577e-02f, 2.77796481e-02f, 3.43569592e-02f, 4.22791280e-02f,
  4.30502230e-03f, 9.94137228e-02f, -1.12041928e-01f, 3.60685140e-02f, 7.22784325e-02f, 1.46334702e-02f, -2.52322033e-02f, -3.50120254e-02f, 2.20815055e-02f, 2.70948056e-02f,
  5.42822361e-01f, -3.46462876e-01f, 2.36690044e-02f, 1.00390032e-01f, 1.83034569e-01f, -5.66654503e-02f, 1.15747422e-01f, -1.64354533e-01f, 2.43719090e-02f, -2.69604713e-01f,
  -1.51102230e-01f, 6.35189265e-02f, -2.74684131e-01f, -4.09817278e-01f, 1.04331233e-01f, -3.12040567e-01f, -9.20763612e-02f, 2.69750282e-02f, -9.77227688e-02f, 1.70035269e-02f,
  -2.40093656e-02f, -3.23673278e-01f, 7.71518704e-03f, -2.01592237e-01f, 1.58926696e-01f, 2.18339115e-01f, 6.54162243e-02f, 8.09193105e-02f, 8.44401047e-02f, -4.70347852e-02f,
  -7.19262287e-02f, -1.54546708e-01f, 1.00000754e-01f, 1.38462177e-02f, 1.92396149e-01f, 7.65790567e-02f, 8.33136514e-02f, 5.08313626e-02f, 5.56094013e-02f, -2.07524318e-02f,
  -3.07449754e-02f, 1.71956588e-02f, -6.81626052e-02f, -5.76176159e-02f, 2.95319632e-02f, 3.06112389e-03f, -2.73750462e-02f, 1.23491706e-02f, -4.38017324e-02f, 8.06947052e-03f,
  6.74604699e-02f, 7.72648454e-02f, 2.46969536e-02f, 4.54000942e-03f, 5.83876446e-02f, 4.46613356e-02f, 9.04879125e-04f, 1.43815041e-01f, 1.37155605e-02f, 1.33426487e-01f,
  5.11303768e-02f, 2.96704508e-02f, -2.63234787e-02f, -1.19876536e-02f, -4.61987853e-02f, -1.42539982e-02f, -9.93847921e-02f, -6.21425733e-03f, 2.36321390e-02f, 6.56108838e-03f,
  5.83727472e-02f, 9.38533843e-02f, -1.10849567e-01f, 8.64179730e-02f, 4.94759083e-02f, -2.76121078e-03f, 1.83421709e-02f, 6.60012588e-02f, 1.21347561e-01f, -2.28076335e-02f,
  -8.36299434e-02f, -2.79223230e-02f, 2.46235896e-02f, 6.64236862e-03f, -9.44917575e-02f, 1.53733194e-01f, -4.39788029e-02f, 7.38419145e-02f, 1.29691772e-02f, -1.66642834e-02f,
  -7.50925019e-02f, -1.77216828e-01f, -4.85429280e-02f, -4.10901308e-02f, -1.84097588e-01f, -1.05696239e-01f, -1.36348739e-01f, -1.96973216e-02f, -5.72303571e-02f, -1.75651349e-02f,
  1.26340821e-01f, -1.00954482e-02f, -4.57675867e-02f, 4.62230220e-02f, -5.15010580e-02f, -1.37140006e-02f, 3.42695862e-02f, 7.26120770e-02f, -6.11500407e-04f, 8.63798186e-02f,
  3.23356129e-02f, 7.68850148e-02f, -4.95750159e-02f, 1.30109591e-02f, -3.08133997e-02f, 7.75013417e-02f, 1.39387893e-02f, -1.93449911e-02f, -4.68722321e-02f, -9.17955264e-02f,
  1.19400948e-01f, -4.88909423e-01f, 9.73817706e-02f, 1.01838924e-01f, -3.74446511e-01f, -4.47758287e-01f, 2.00244471e-01f, -3.02427858e-01f, -2.63924092e-01f, 1.96248382e-01f,
  -3.84252518e-02f, 2.51779914e-01f, 1.28457665e-01f, -1.55768678e-01f, -1.40853137e-01f, -3.62024084e-02f, -1.42730147e-01f, 5.41885383e-02f, -2.19978064e-01f, 2.81129824e-03f,
  -1.75584510e-01f, -5.73522598e-02f, 9.17991325e-02f, -8.94433632e-02f, -1.00221066e-02f, 1.02870166e-01f, 1.03280783e-01f, 3.70368664e-03f, 2.08012104e-01f, -1.02303885e-01f,
  2.77455859e-02f, -1.46575481e-01f, 3.48795094e-02f, 2.40530875e-02f, -7.11367792e-03f, 9.36893672e-02f, 1.16892397e-01f, 8.27475488e-02f, 8.85869265e-02f, -6.50716871e-02f,
  1.39416501e-01f, 6.62004948e-02f, -8.61626212e-03f, -9.47283208e-02f, -3.32829170e-02f, 2.76024118e-02f, -4.57978770e-02f, -1.58107542e-02f, 1.75439678e-02f, -6.04557469e-02f,
  2.35988647e-02f, -1.04578562e-01f, -5.39873727e-02f, 4.38396586e-03f, -2.03655288e-02f, -3.00427116e-02f, 2.50620507e-02f, 4.04164940e-02f, -7.48682991e-02f, -5.75330518e-02f,
  -3.03438623e-02f, -1.98880513e-03f, -4.43141572e-02f, 8.56375471e-02f, -1.33288711e-01f, -8.64336565e-02f, 4.50956263e-02f, -3.00299153e-02f, -2.45814375e-03f, -2.81659588e-02f,
  1.07970601e-02f, 6.03208132e-03f, 1.20951198e-02f, -3.82874571e-02f, 4.54426110e-02f, 5.89432605e-02f, -6.82266951e-02f, 2.91990843e-02f, -6.45653764e-03f, 2.75642890e-02f,
  4.51406129e-02f, 1.68742519e-02f, -3.46733369e-02f, -1.00879939e-02f, -2.79096588e-02f, -3.42558958e-02f, -5.52759394e-02f, 6.16688468e-02f, -3.88810039e-02f, -8.40078574e-03f,
  -1.75408289e-01f, -3.55530471e-01f, 5.46442978e-02f, 8.08673352e-03f, -1.02760829e-02f, -9.05041918e-02f, 3.50092016e-02f, -1.92787215e-01f, 2.52114832e-02f, -9.64418799e-02f,
  -4.39574532e-02f, 6.85762763e-02f, -2.03946345e-02f, 5.86950816e-02f, 1.46696670e-02f, -1.39170766e-01f, 1.61219344e-01f, -1.51985288e-02f, 1.14518382e-01f, 5.24451211e-02f,
  3.88932042e-02f, 5.49411252e-02f, 1.30610764e-01f, -1.85779363e-01f, -1.91732461e-03f, 1.60646796e-01f, -6.67987838e-02f, -2.58045061e-03f, 1.08653277e-01f, -2.56634410e-03f,
  4.95210826e-01f, -2.49669343e-01f, 1.13675274e-01f, 4.66630906e-01f, -1.99940190e-01f, -1.35810584e-01f, 2.73583949e-01f, -1.35110721e-01f, 3.54521185e-01f, -2.75406748e-01f,
  -2.83384160e-03f, 1.52582362e-01f, 1.15313403e-01f, -3.91385891e-02f, 3.77401173e-01f, 2.30292514e-01f, 2.08334863e-01f, 1.01624131e-01f, 1.01018570e-01f, 5.92532977e-02f,
  1.74326688e-01f, -6.46935254e-02f, 4.98548448e-02f, -4.09361452e-01f, -1.38256075e-02f, -4.41589095e-02f, -3.70910726e-02f, -1.68421671e-01f, -1.72756612e-01f, -6.12711720e-02f,
  -1.10109411e-01f, 8.51772502e-02f, -8.19930360e-02f, -4.18471098e-02f, 9.49628279e-02f, -5.13062812e-02f, -3.16872983e-03f, -2.69654486e-02f, 7.13430811e-03f, -2.34134197e-02f,
  6.54989034e-02f, 5.18235117e-02f, -7.05750100e-03f, -3.51733156e-02f, -9.35587212e-02f, 1.19930021e-02f, 2.29568966e-02f, 1.17403036e-02f, -9.75276828e-02f, 1.04929425e-01f,
  -3.59552763e-02f, 2.20699031e-02f, 6.51317984e-02f, 4.43422869e-02f, 9.14383307e-02f, 8.22265539e-03f, 4.37923707e-02f, 1.11309858e-02f, 3.53721865e-02f, -1.16372053e-02f,
  1.82490163e-02f, 1.55345770e-03f, 2.43905988e-02f, -3.97663787e-02f, 6.32569985e-03f, -1.29434578e-02f, -5.12899719e-02f, -2.09080093e-02f, 2.16480177e-02f, 5.98572977e-02f,
  1.74895842e-02f, 4.62382752e-03f, -6.33419380e-02f, 3.54245119e-02f, 1.87807716e-02f, -4.02745651e-03f, 2.91455053e-02f, -1.64396372e-02f, 8.55912864e-02f, -3.61779928e-02f,
  -2.67395005e-02f, -2.55910028e-03f, -6.88601211e-02f, -1.46294087e-02f, -4.78695408e-02f, 2.74088793e-02f, 5.01689129e-02f, 1.84062514e-02f, -2.22120825e-02f, 3.43293510e-02f,
  -1.28218969e-02f, 1.42056808e-01f, 3.63506302e-02f, -7.99968392e-02f, -6.52456656e-02f, 3.58449146e-02f, 3.34622525e-02f, 3.16527002e-02f, -3.47019024e-02f, 3.44817191e-02f,
  6.00730069e-03f, -3.19599025e-02f, 6.05104119e-02f, 2.72754356e-02f, 2.92432792e-02f, 2.50425469e-02f, 7.17592612e-02f, -1.96682587e-02f, 2.75518210e-03f, 7.35704263e-04f,
  3.45086753e-02f, -3.29015846e-03f, -4.56878394e-02f, -7.33215511e-02f, -1.56715252e-02f, 2.65804417e-02f, 5.40586933e-02f, -4.59828004e-02f, -1.19606666e-02f, 2.75559146e-02f,
  1.83219150e-01f, 1.56586543e-01f, -1.87580898e-01f, 1.39548391e-01f, 1.18463688e-01f, -3.16337585e-01f, 1.60215590e-02f, 2.20646739e-01f, 2.20148876e-01f, 2.34131411e-01f,
  2.33339280e-01f, 3.11900489e-02f, -1.96456872e-02f, 3.21350336e-01f, -4.23476160e-01f, -1.40167579e-01f, 2.04589784e-01f, 5.24746403e-02f, 5.21805771e-02f, 1.35795832e-01f,
  -1.14342859e-02f, 3.62861603e-01f, -1.57139584e-01f, 1.68242484e-01f, 1.68481976e-01f, -6.51688427e-02f, -2.15965435e-01f, -1.01722963e-01f, 1.16238311e-01f, -6.63233325e-02f,
  4.51290868e-02f, 2.81013995e-01f, 7.56403655e-02f, 1.42586057e-03f, -8.56285915e-02f, 2.17324100e-03f, -1.68196589e-01f, -1.45693585e-01f, 4.81658019e-02f, 7.09224567e-02f,
  -5.92396595e-02f, -1.46262655e-02f, 8.64601061e-02f, 8.68933648e-02f, 9.00522023e-02f, 4.17094491e-02f, 6.77266121e-02f, -2.38541104e-02f, 3.49579602e-02f, 1.18630640e-02f,
  1.75772086e-02f, -5.76286688e-02f, -3.07465773e-02f, -6.63158372e-02f, -1.02272414e-01f, 1.25566989e-01f, -8.50100890e-02f, -1.01309448e-01f, -5.48684001e-02f, 2.32378636e-02f,
  7.76726380e-02f, -2.11303569e-02f, -1.69984829e-02f, 1.73917010e-01f, -4.28831717e-03f, -3.32690310e-03f, 1.39977625e-02f, -3.37044485e-02f, -3.79957519e-02f, -4.74895090e-02f,
  3.69070843e-02f, 3.01635582e-02f, 1.27349839e-01f, -1.48950145e-02f, 1.16385542e-01f, 1.54579252e-01f, -2.66986843e-02f, 7.04820827e-02f, 1.36560444e-02f, 5.49331829e-02f,
  -5.50405635e-03f, 1.02360873e-02f, 3.66127938e-02f, -5.99057861e-02f, 4.87381332e-02f, -5.16063832e-02f, 8.22670981e-02f, 4.31995140e-03f, -2.86873188e-02f, -1.01663738e-01f,
  -1.31357223e-01f, -1.16744995e-01f, -2.07799021e-02f, 4.85358760e-02f, -1.09957553e-01f, -1.54912611e-03f, 9.95138362e-02f, 7.97534063e-02f, -4.42965291e-02f, -5.99641958e-03f,
  5.76451309e-02f, -1.95377413e-02f, -1.51028022e-01f, 4.21833023e-02f, -1.01775192e-01f, -2.85395551e-02f, -5.39629273e-02f, -2.36620754e-02f, -4.69533540e-02f, -5.64613789e-02f,
  -8.37499648e-02f, 7.78544247e-02f, -8.00580531e-02f, 6.47840602e-03f, -4.89153787e-02f, -4.43090759e-02f, -1.22217331e-02f, -1.79680437e-02f, -6.80813715e-02f, 1.89034622e-02f,
  3.00010473e-01f, -1.60702333e-01f, -1.03961818e-01f, -9.57859829e-02f, 2.61777401e-01f, 4.24415231e-01f, 6.91330656e-02f, 2.52343893e-01f, 1.86434150e-01f, -2.78667361e-01f,
  8.99477229e-02f, -2.75098175e-01f, 4.69448343e-02f, -2.64339689e-02f, 3.19482565e-01f, 1.43787563e-01f, 5.47935143e-02f, 9.33277886e-03f, 1.91798300e-01f, 6.86034262e-02f,
  1.29561558e-01f, 2.81605069e-02f, -2.24118792e-02f, -2.52569336e-02f, -1.12107031e-01f, -1.05228946e-01f, -2.15105280e-01f, -1.14336066e-01f, -2.64939249e-01f, 4.99178795e-03f,
  2.17268065e-01f, 5.20032160e-02f, -1.20641664e-01f, 1.51268654e-02f, 4.50469591e-02f, -2.24211551e-02f, -9.28775594e-02f, -3.03854384e-02f, -5.79316262e-03f, 1.85218230e-02f,
  -3.22878696e-02f, 1.66195571e-01f, 2.21460089e-02f, -1.03691667e-02f, 6.43109009e-02f, -5.10135628e-02f, 5.05738035e-02f, -7.18552545e-02f, -2.66891476e-02f, 5.06654382e-02f,
  6.37214258e-02f, 1.06874891e-01f, -4.97274436e-02f, -1.05379120e-01f, 5.41273542e-02f, -2.00145487e-02f, -4.74198833e-02f, 9.31026321e-03f, 4.34950739e-02f, 2.66741235e-02f,
  4.58024107e-02f, -9.64901596e-03f, -7.55499229e-02f, 4.52280566e-02f, 7.07030203e-03f, -4.14564041e-03f, -5.67051247e-02f, 5.41924126e-03f, -4.74613383e-02f, 6.95546716e-02f,
  8.10370445e-02f, -7.03897513e-03f, 4.53026369e-02f, 6.01143502e-02f, -1.04248067e-02f, -1.67557988e-02f, -3.90990004e-02f, -4.83322106e-02f, 2.74415826e-03f, 5.35463318e-02f,
  9.09509696e-03f, 8.49510729e-02f, -4.83763739e-02f, -9.39708352e-02f, 4.48735617e-02f, 1.10010803e-02f, -8.92022848e-02f, -5.10954577e-03f, -7.47199357e-02f, 1.38662076e-02f,
  1.23215742e-01f, -1.66660428e-01f, -3.87707632e-03f, 5.97933866e-02f, -1.27412349e-01f, -4.26528081e-02f, 2.77107628e-03f, -8.57820455e-03f, 1.08389184e-01f, 4.22753841e-02f,
  2.78332159e-02f, -9.05575752e-02f, -1.73497777e-02f, -4.25299592e-02f, 2.87848897e-02f, 4.67636548e-02f, -2.26386860e-02f, 3.66849340e-02f, -2.30495464e-02f, -3.79792675e-02f,
  -6.91400766e-02f, -3.28080542e-02f, -1.02456650e-02f, 3.47296484e-02f, 1.37121333e-02f, -4.87524783e-04f, -4.39846143e-02f, 1.92872807e-02f, 2.33529545e-02f, -3.97905707e-02f,
  -4.76926059e-01f, 3.28530669e-01f, 1.21745214e-01f, -2.10417628e-01f, -3.10016051e-02f, -3.48747373e-01f, -3.25244993e-01f, 1.56441003e-01f, -1.34370819e-01f, 3.08455408e-01f,
  -1.40925914e-01f, -8.38573650e-02f, 2.03741789e-01f, -4.06958729e-01f, -3.29182118e-01f, 1.72927063e-02f, -2.18142271e-01f, -2.14331746e-01f, 1.58636887e-02f, 7.36979826e-04f,
  -5.82158267e-02f, -1.12000518e-01f, 7.15483800e-02f, 2.30456725e-01f, -1.69407815e-01f, 1.88776314e-01f, 3.26474309e-01f, 1.73686996e-01f, -1.00168735e-02f, -5.27171753e-02f,
  -3.44087146e-02f, -3.53653394e-02f, 6.61732778e-02f, -2.93341279e-03f, -9.85100958e-03f, 1.01431916e-02f, 5.26341908e-02f, 7.61775905e-03f, 7.76865333e-03f, -2.21026763e-02f,
  -3.70027088e-02f, -4.10114089e-03f, -8.81642774e-02f, -2.89206952e-02f, -6.37616515e-02f, 7.23930597e-02f, -8.73529240e-02f, -7.78640434e-02f, 3.15424986e-04f, -9.47607979e-02f,
  6.46482408e-03f, -1.96752325e-02f, -6.87583908e-02f, 7.56711811e-02f, 3.80330496e-02f, -3.01663410e-02f, -7.24939778e-02f, 5.74928671e-02f, -3.30221765e-02f, -7.97598660e-02f,
  1.78407021e-02f, -2.25929562e-02f, 1.84735078e-02f, 3.94330447e-04f, -1.10646375e-01f, 3.82152461e-02f, -2.03583837e-02f, -3.74001525e-02f, 9.22409259e-03f, -5.15103862e-02f,
  -3.39358672e-02f, -2.17781053e-03f, -8.77521113e-02f, -1.70009527e-02f, 6.95102988e-03f, -7.43873930e-03f, 1.42904148e-02f, -4.72744973e-03f, -4.26379777e-02f, -5.80822071e-03f,
  7.92198703e-02f, -6.07526153e-02f, 2.46750992e-02f, 4.39037569e-02f, 4.07566540e-02f, 3.69092375e-02f, -5.96839376e-03f, -3.59899290e-02f, 8.75696633e-03f, -7.97124356e-02f,
  6.67344108e-02f, 1.47576064e-01f, 7.41199404e-02f, -1.59952249e-02f, -1.25939734e-02f, 8.35104566e-03f, -2.59511620e-02f, -3.22000124e-02f, 1.42715853e-02f, -8.18038359e-02f,
  5.40324859e-02f, 1.88037399e-02f, 1.06044427e-01f, -9.84132886e-02f, -2.19464507e-02f, -7.92408921e-03f, 1.29189091e-02f, 2.55336761e-02f, 6.58172220e-02f, 4.72604035e-04f,
  3.57498191e-02f, -1.99596137e-02f, 3.01407911e-02f, -3.58008407e-02f, -6.19054995e-02f, 8.96125510e-02f, -3.70017290e-02f, -1.59866344e-02f, 4.24579298e-03f, 5.70244156e-02f,
  2.94960350e-01f, 2.97713399e-01f, 3.59003514e-01f, -2.13189032e-02f, 6.60951808e-02f, 3.46722811e-01f, 2.01841697e-01f, 5.93965538e-02f, 1.73485219e-01f, -1.47570357e-01f,
  -1.00040220e-01f, 3.22776325e-02f, 8.81803595e-03f, -1.41628802e-01f, 4.84039001e-02f, 6.14323542e-02f, -2.32789442e-02f, -1.45299673e-01f, 1.10039890e-01f, 1.06629848e-01f,
  -5.58860637e-02f, -3.46265763e-01f, 9.01715551e-03f, -1.48245543e-01f, 1.77482888e-01f, -3.66320927e-03f, -3.11682522e-01f, -3.31040546e-02f, -1.46788388e-01f, -7.11170956e-02f,
  4.22046846e-03f, -2.32066717e-02f, 1.03432007e-01f, -7.32343830e-03f, 8.94182175e-02f, 9.81674939e-02f, -3.87886749e-03f, -1.59801042e-03f, 4.63717394e-02f, 1.96878240e-02f,
  1.69987734e-02f, -1.82647593e-02f, -2.64052376e-02f, 2.47737430e-02f, 1.00570448e-01f, 1.70467962e-02f, -7.29871215e-03f, 1.59622073e-01f, -1.25832751e-03f, 7.19800144e-02f,
  1.76291332e-01f, 1.18779406e-01f, -3.14216837e-02f, -2.21746229e-02f, -1.29699875e-02f, 3.96222509e-02f, 1.57525279e-02f, 1.58208180e-02f, 1.25716664e-02f, 3.94047052e-02f,
  1.67805851e-02f, -5.75185716e-02f, 6.86794370e-02f, 7.86475372e-03f, 3.01576871e-02f, -1.00725621e-01f, -3.75566967e-02f, -1.06410168e-01f, 3.34158391e-02f, -6.95262700e-02f,
  -2.53599044e-02f, -2.52824947e-02f, -5.21362834e-02f, 5.76906875e-02f, -2.51343306e-02f, -1.81440264e-02f, -6.57360107e-02f, -4.93521243e-02f, 3.90951186e-02f, -3.74159031e-02f,
  -1.02325007e-01f, -4.97729704e-02f, 3.00887097e-02f, -4.83411774e-02f, -3.20871100e-02f, 6.24421844e-03f, -6.76967427e-02f, 1.15906656e-01f, 2.71574371e-02f, -3.28351930e-03f,
  7.80884176e-03f, -1.64984569e-01f, 2.81584729e-02f, -5.47324773e-03f, -9.12859440e-02f, 2.67395191e-02f, -1.90042146e-02f, 3.01740337e-02f, -2.59778537e-02f, 1.26805361e-02f,
  -1.51442224e-02f, -3.46559435e-02f, 7.25224754e-03f, -4.23384160e-02f, -3.02510038e-02f, 9.59801748e-02f, -6.30942360e-03f, -9.14159045e-02f, -3.71152796e-02f, -8.76713917e-02f,
  -1.16041988e-01f, -9.16968584e-02f, -3.65782417e-02f, -5.93784004e-02f, -4.56001125e-02f, -8.91425163e-02f, 8.46616179e-03f, 2.04876270e-02f, -4.00648713e-02f, -2.68980619e-02f,
  2.14226902e-01f, 1.66654158e-02f, 2.48599470e-01f, 8.44779760e-02f, 1.55121312e-01f, 6.56962022e-02f, 2.43880913e-01f, 3.17420140e-02f, 1.19512334e-01f, -4.49628979e-02f,
  -2.05266386e-01f, 1.73543632e-01f, -1.80038810e-01f, -2.53634155e-01f, -1.77902937e-01f, -3.28531861e-01f, 5.89041561e-02f, -4.56743920e-03f, -1.25437006e-01f, 2.83098519e-01f,
  2.32744683e-02f, -1.64762631e-01f, -8.62797573e-02f, 7.39588514e-02f, 4.08547595e-02f, 1.89443886e-01f, -1.13785721e-01f, 1.72318608e-01f, 1.87924306e-03f, -6.49882406e-02f,
  -6.65140226e-02f, -5.67092225e-02f, -6.11513443e-02f, 5.11200130e-02f, -2.86841933e-02f, -4.13430762e-03f, 7.46101141e-02f, 3.42738293e-02f, -5.60765862e-02f, -4.87997122e-02f,
  3.74207012e-02f, -1.11545641e-02f, 1.11734644e-02f, 5.26377372e-02f, 6.40297309e-02f, 6.54145926e-02f, -3.56230512e-02f, -9.81957931e-03f, 3.99633981e-02f, -5.97468689e-02f,
  -4.08590473e-02f, 3.13875452e-02f, 7.55544528e-02f, 2.94779595e-02f, 6.25896901e-02f, 2.47694682e-02f, 8.23921040e-02f, -7.39643872e-02f, -4.62846644e-02f, -3.39433290e-02f,
  7.11922050e-02f, 3.57291400e-02f, -8.13073665e-02f, -6.55037388e-02f, 1.46137932e-02f, -2.74356604e-02f, 1.13365963e-01f, -4.05715667e-02f, 1.48250526e-02f, 4.42790985e-02f,
  -1.21495705e-02f, 2.70477850e-02f, 1.27483839e-02f, 8.69136676e-03f, -1.91237088e-02f, 6.54292703e-02f, 8.61484408e-02f, -1.52303521e-02f, 2.23781802e-02f, -1.12844899e-01f,
  1.86112039e-02f, -2.47425027e-03f, 8.06684024e-04f, 1.14895385e-02f, -1.96953472e-02f, -9.02424082e-02f, 4.67231730e-03f, -4.39609867e-03f, 5.97804599e-03f, 3.81824225e-02f,
  -3.77752744e-02f, 2.18625143e-01f, -2.79003289e-05f, -1.29027851e-02f, 4.32127118e-02f, -3.92950955e-04f, 3.38135473e-02f, -1.13769602e-02f, 4.74641249e-02f, 5.10040000e-02f,
  6.52607977e-02f, 6.86224401e-02f, 9.15790573e-02f, -3.34794000e-02f, 3.47762257e-02f, -5.82307838e-02f, 1.42797641e-02f, 2.41617206e-02f, 8.09998885e-02f, 9.88731384e-02f,
  3.81106734e-02f, 4.37015928e-02f, -8.22423957e-03f, 6.01996481e-02f, 5.01781292e-02f, 2.95931008e-02f, 1.22809947e-01f, 9.01445299e-02f, 1.32864388e-02f, -2.73741726e-02f,
  -3.25457752e-01f, -1.41461613e-02f, 5.15451767e-02f, -2.85954565e-01f, -1.17840670e-01f, 6.45398274e-02f, -2.00055093e-01f, 3.06896567e-02f, -9.54398438e-02f, 1.67298093e-01f,
  -9.78254750e-02f, 1.32170990e-01f, 1.93788514e-01f, -2.11233944e-01f, -9.93903279e-02f, 2.87758648e-01f, -2.29047388e-01f, 7.53568485e-02f, -9.06631202e-02f, 3.55853550e-02f,
  -1.51413456e-01f, -1.56251535e-01f, 1.08192958e-01f, 3.59650441e-02f, -3.16691101e-01f, -1.75657779e-01f, -2.39413112e-01f, -1.08159833e-01f, -2.18660563e-01f, -1.32972822e-01f,
  -1.12619385e-01f, -1.21209703e-01f, 5.62706068e-02f, 5.44776469e-02f, -1.72250438e-02f, 5.32505251e-02f, -2.42517274e-02f, 1.74406931e-01f, -3.32476459e-02f, 7.48773441e-02f,
  9.32327583e-02f, 6.15488403e-02f, -1.17958143e-01f, 4.64468561e-02f, -1.12681083e-01f, -8.57143551e-02f, 1.39186764e-02f, 9.38846357e-03f, 3.53040993e-02f, 3.46108414e-02f,
  8.93687923e-03f, 7.92291854e-03f, -8.23270679e-02f, -2.30666921e-02f, -9.83425900e-02f, -1.64413169e-01f, 1.14884607e-01f, 1.27872769e-02f, -3.06015350e-02f, -1.25544488e-01f,
  6.53687119e-02f, 6.65000975e-02f, 4.49094102e-02f, 4.52100746e-02f, -3.08183506e-02f, -2.12407950e-02f, -1.36366272e-02f, 1.47911519e-01f, -8.74108300e-02f, 1.63978580e-02f,
  -9.54018254e-03f, -4.06350270e-02f, 9.02674440e-03f, -2.69295797e-02f, 8.57799500e-03f, -5.63157350e-02f, 5.46447746e-02f, -2.18523927e-02f, -3.46884467e-02f, -1.38058867e-02f,
  3.89292948e-02f, -3.81575078e-02f, -9.35133360e-03f, 1.20686650e-01f, -1.85512900e-02f, -1.95626467e-02f, 1.45767909e-02f, 9.10027474e-02f, -3.94205935e-03f, -1.26797169e-01f,
  -2.34959602e-01f, -3.36394012e-01f, -3.82340550e-02f, -3.97257581e-02f, -5.21727949e-02f, 3.81072201e-02f, 1.02570906e-01f, 7.07699731e-02f, -2.21683890e-01f, 2.92346403e-02f,
  -4.37196298e-03f, 1.37429107e-02f, -4.06505093e-02f, 5.81597425e-02f, 4.53362241e-02f, -2.34260596e-02f, -8.09488669e-02f, -1.09059066e-01f, -7.67129809e-02f, -5.43197393e-02f,
  -1.06446361e-02f, 7.93038979e-02f, 6.51062652e-02f, -3.18358950e-02f, -1.79218210e-03f, -7.07766935e-02f, -7.25868940e-02f, 7.36365169e-02f, -3.84115726e-02f, 1.43692940e-01f,
  -3.89429867e-01f, 1.98797062e-01f, 7.11642727e-02f, 1.05119804e-02f, -7.11548179e-02f, -3.69787276e-01f, -2.74261892e-01f, 1.08033262e-01f, 2.32673749e-01f, 1.77041516e-01f,
  -1.55816555e-01f, -4.41048518e-02f, 1.08765550e-01f, -1.56223819e-01f, -4.40623969e-01f, 3.39358412e-02f, -8.31334069e-02f, -1.24098301e-01f, 1.78051353e-01f, 5.02676293e-02f,
  3.70415598e-02f, -2.22434253e-01f, -2.02308923e-01f, 1.69464663e-01f, -2.02458665e-01f, 2.06361070e-01f, 9.90499780e-02f, 1.09744415e-01f, -1.20730214e-01f, -2.08033070e-01f,
  -2.09312975e-01f, 9.96922404e-02f, -4.66053747e-03f, 3.00702378e-02f, 2.38894299e-02f, -6.33397996e-02f, -5.21365292e-02f, -9.92133394e-02f, -4.82473224e-02f, 4.12804373e-02f,
  3.22596915e-02f, -1.01085491e-01f, 5.12159988e-02f, 2.16255840e-02f, -2.27950211e-03f, -2.31143087e-02f, 1.83251929e-02f, -5.72171286e-02f, 7.90105835e-02f, -1.07624911e-01f,
  -1.82451564e-03f, -6.00961596e-02f, -1.68256443e-02f, 3.14732976e-02f, 3.25909350e-03f, -1.47701157e-02f, -7.05237687e-02f, 1.69987101e-02f, -2.72991415e-02f, 2.50518378e-02f,
  -1.98076759e-02f, 1.04538679e-01f, -2.27790717e-02f, -2.72006858e-02f, -4.03453335e-02f, 3.79580706e-02f, -6.18240573e-02f, -3.15764844e-02f, 5.01710624e-02f, -9.57226977e-02f,
  5.37084229e-02f, -8.97964090e-02f, -1.97510440e-02f, -6.47516027e-02f, -4.48863767e-02f, 4.72556148e-03f, 1.30137317e-02f, 2.06000824e-02f, 8.23730752e-02f, -4.46801893e-02f,
  8.41859654e-02f, -2.52714497e-03f, -4.07154039e-02f, -9.94767644e-04f, 4.70606005e-03f, -4.24737297e-03f, 4.29121852e-02f, 1.27418721e-02f, 5.41916257e-03f, -1.80938188e-02f,
  1.31563321e-01f, 3.67792040e-01f, 8.50830376e-02f, 3.12182549e-02f, 1.37673030e-02f, 4.12872853e-03f, 7.38058388e-02f, 2.49332264e-02f, 8.54464546e-02f, -3.36859049e-03f,
  -4.69684973e-02f, 8.61192271e-02f, 3.17384116e-02f, -1.48472235e-01f, 1.17688775e-02f, 2.07299795e-02f, -7.07043242e-03f, 4.00119498e-02f, -2.77959760e-02f, 3.14364699e-03f,
  -5.75857311e-02f, -2.21245103e-02f, -6.29758136e-03f, 3.43079902e-02f, 1.78219955e-02f, 3.75145301e-03f, 6.89542666e-02f, -4.93683433e-03f, -4.29234132e-02f, 2.18005553e-02f,
  3.69962186e-01f, 1.64223984e-01f, 1.85023427e-01f, 7.01709390e-02f, -4.27651033e-02f, 4.67298299e-01f, 4.03831363e-01f, 3.42265144e-02f, 7.05929771e-02f, -1.02216102e-01f,
  -1.16413288e-01f, 8.63861963e-02f, -6.74543381e-02f, 2.06033468e-01f, 2.93001145e-01f, 1.88977450e-01f, 3.41193438e-01f, 1.69154122e-01f, 6.60243153e-04f, 5.58481589e-02f,
  1.47604924e-02f, -4.79427762e-02f, 9.15262550e-02f, -1.91392645e-01f, 1.11728601e-01f, -1.47243753e-01f, -1.84427440e-01f, -8.17832351e-02f, -1.75849557e-01f, -1.83862485e-02f,
  4.36271131e-02f, -7.35763311e-02f, 1.05092805e-02f, 1.45917330e-02f, 1.13266103e-01f, 2.28752494e-02f, -9.36782286e-02f, 3.08422688e-02f, -5.72043136e-02f, 2.22029723e-02f,
  7.24885687e-02f, -4.43348438e-02f, -4.03709635e-02f, -2.13482045e-02f, 1.36294561e-02f, 1.93200342e-03f, 2.13409439e-02f, 3.85240675e-03f, -4.90124710e-02f, 5.42169809e-02f,
  1.42995700e-01f, -2.15383004e-02f, 9.13601443e-02f, -2.41172593e-02f, 6.49866508e-03f, -1.15881469e-02f, 4.47033197e-02f, 2.44301818e-02f, 7.87943453e-02f, 4.67271805e-02f,
  -3.84345315e-02f, 7.31093287e-02f, 8.53473619e-02f, -6.64093625e-03f, 4.55817021e-02f, -1.53074414e-01f, 4.61088344e-02f, -8.94240066e-02f, -3.36856917e-02f, 4.68723252e-02f,
  -2.63827015e-02f, -9.82259121e-03f, -1.58446692e-02f, -3.50583456e-02f, -4.55503911e-02f, -2.51483284e-02f, 2.11748425e-02f, 7.57846935e-03f, 5.01479022e-02f, 5.86680248e-02f,
  -8.57692137e-02f, 4.38088514e-02f, 1.76378805e-02f, -5.84620014e-02f, 1.35076903e-02f, 4.46880236e-02f, -8.35283473e-02f, 6.21171072e-02f, 4.68652649e-03f, 4.44633998e-02f,
  9.23174098e-02f, 8.06961805e-02f, 1.27308043e-02f, -4.12376970e-02f, -7.11104646e-02f, -2.32179631e-02f, 6.50392324e-02f, 8.99283960e-02f, 7.59327859e-02f, 4.63078590e-03f,
  -2.09480152e-02f, -5.96436262e-02f, 3.75078395e-02f, -5.64793497e-02f, -5.21992706e-02f, 4.82958741e-02f, -1.94955822e-02f, -8.85658488e-02f, 8.26574117e-03f, -4.99732196e-02f,
  -6.58515543e-02f, 8.52641743e-03f, -6.79634362e-02f, -1.05117261e-02f, -1.59006361e-02f, -3.63807529e-02f, 6.34864271e-02f, 5.93550596e-03f, -9.14232358e-02f, -2.08981391e-02f,
  2.15886325e-01f, -1.73672698e-02f, 8.12310725e-02f, 2.29713753e-01f, -2.11073503e-01f, -2.33095601e-01f, 9.80025083e-02f, -3.91242921e-01f, 3.32222432e-01f, 1.09936081e-01f,
  -2.15175338e-02f, 3.97116870e-01f, 6.36219978e-02f, -2.21832003e-02f, 6.34509921e-02f, 1.19626425e-01f, 1.37391239e-01f, 1.38960779e-01f, 1.05472654e-01f, -1.24941185e-01f,
  9.84689873e-03f, -2.71377593e-01f, -3.02056000e-02f, -3.09482068e-01f, -2.82557160e-01f, 3.29552740e-02f, -2.76965737e-01f, -2.03326836e-01f, -1.59008071e-01f, 2.68029328e-02f,
  -9.63305682e-02f, 1.56624720e-01f, -6.00855611e-02f, 1.62329040e-02f, -1.02913119e-01f, -8.44736993e-02f, 3.74370553e-02f, -6.29075663e-03f, -3.65620330e-02f, -4.70351912e-02f,
  8.76257122e-02f, -4.58082296e-02f, 1.17178885e-02f, -4.90407981e-02f, -1.82383899e-02f, -9.19605866e-02f, -7.00951889e-02f, 1.02436459e-02f, 4.50402237e-02f, -3.72605808e-02f,
  6.86876625e-02f, 8.02708417e-02f, 8.59963447e-02f, -2.42025405e-02f, 1.18175177e-02f, 1.55678079e-01f, 1.33628249e-01f, 1.12582810e-01f, 3.75799602e-03f, -2.25263811e-03f,
  4.57798615e-02f, -3.13261747e-02f, -9.04246606e-03f, -1.61876872e-01f, 3.97192165e-02f, 7.03174621e-02f, -1.92766692e-02f, 5.87377585e-02f, 4.47873101e-02f, -1.66184567e-02f,
  -7.45745227e-02f, -3.11228912e-02f, -1.01196449e-02f, -1.07966140e-02f, 6.78109843e-03f, 9.97568667e-02f, 1.61888544e-02f, -1.06471106e-01f, 3.48614193e-02f, -1.20944403e-01f,
  1.47878856e-03f, 1.28879651e-01f, -1.12233572e-02f, -5.83122037e-02f, -1.19625162e-02f, 9.41068456e-02f, 3.18357069e-03f, -1.94347445e-02f, 4.77698855e-02f, -7.85134658e-02f,
  5.14886668e-03f, 1.40907979e-02f, -8.70246813e-02f, 6.16530451e-05f, 5.12517989e-02f, 5.02719767e-02f, 5.35592102e-02f, 1.66413877e-02f, -6.33944897e-03f, 4.63811159e-02f,
  5.72771672e-03f, 3.54436636e-02f, 7.56828999e-03f, 5.71003295e-02f, -5.83691038e-02f, -3.51059474e-02f, 1.27020881e-01f, -2.02777777e-02f, -1.08564444e-01f, -3.63402739e-02f,
  -2.71845572e-02f, 6.54598791e-03f, 5.87507989e-03f, -1.29571617e-01f, 1.77985001e-02f, -1.06662214e-02f, 4.87029459e-03f, 1.64275728e-02f, -6.79374635e-02f, 5.20180762e-02f,
  -2.11947188e-01f, -1.55829832e-01f, 5.12110032e-02f, -2.77650118e-01f, 1.80860251e-01f, -1.43847317e-01f, 1.15613632e-01f, -1.16997257e-01f, 5.55768050e-02f, -2.32971370e-01f,
  -5.25236577e-02f, -1.47371935e-02f, 3.58673185e-01f, -4.47897971e-01f, 6.31858259e-02f, 9.36369523e-02f, -3.57657671e-01f, -1.50995120e-01f, 3.32125500e-02f, -1.24961615e-01f,
  -9.68295559e-02f, -1.83074445e-01f, -4.00522165e-03f, -9.13864151e-02f, -1.16737910e-01f, -5.06834723e-02f, -1.24645475e-02f, 2.82927871e-01f, -3.34951133e-01f, 3.54231521e-02f,
  -5.18934913e-02f, 2.50828881e-02f, -1.51524157e-03f, -6.31714091e-02f, -5.10379039e-02f, 9.74645838e-02f, -2.77514979e-02f, 1.78390145e-01f, 1.23972729e-01f, -2.60829814e-02f,
  4.49871942e-02f, 3.44785266e-02f, -8.12229738e-02f, 1.17843054e-01f, -1.72874890e-02f, -7.34162703e-02f, -4.38868366e-02f, -9.83325299e-03f, 4.86029536e-02f, 5.46208918e-02f,
  -2.78484523e-02f, -3.67816277e-02f, -4.78936024e-02f, -5.24145626e-02f, 4.73882817e-02f, 2.50340514e-02f, -5.18118031e-02f, 6.62955567e-02f, -2.83543719e-03f, -5.78297302e-02f,
  -2.29276288e-02f, 4.28839447e-03f, -1.12674162e-02f, 1.55468723e-02f, -2.59645144e-03f, -2.84939297e-02f, -1.93897588e-03f, -6.22996278e-02f, 4.46488932e-02f, -5.68947233e-02f,
  -4.79018688e-02f, -3.13097681e-03f, -4.86527868e-02f, -1.06226187e-03f, -1.05022289e-01f, -6.29543886e-02f, 4.30804789e-02f, 1.42085254e-02f, -7.58627132e-02f, -1.95691716e-02f,
  6.78204000e-02f, -4.84873913e-02f, 5.08664362e-02f, -3.87761593e-02f, -2.03536320e-02f, 5.92523366e-02f, -6.46920353e-02f, -6.32527471e-02f, 6.29557520e-02f, 1.16599299e-01f,
  -3.06540988e-02f, 3.97689454e-02f, 5.62248938e-02f, 3.32315043e-02f, 3.21968272e-02f, -2.04343367e-02f, -1.73396934e-02f, -1.43857032e-01f, -4.74108458e-02f, 3.49181183e-02f,
  -1.19952701e-01f, -6.24608211e-02f, -6.99137375e-02f, -4.65642251e-02f, -5.04485145e-03f, 7.75670335e-02f, 1.71334222e-02f, -1.66034978e-03f, -4.61408459e-02f, -3.30491848e-02f,
  2.09575202e-02f, 4.84591797e-02f, 3.64264324e-02f, -5.98605275e-02f, -1.44312810e-02f, 3.89447692e-03f, 3.48569602e-02f, -7.70279579e-03f, 1.25009276e-04f, 8.20505712e-03f,
  5.64237177e-01f, -4.29955482e-01f, 7.78365731e-02f, 2.91283548e-01f, -2.07444336e-02f, 1.86804399e-01f, 3.92354846e-01f, -1.21715404e-01f, 3.67061019e-01f, -1.67029932e-01f,
  1.27713904e-01f, -4.52090427e-03f, -6.15595430e-02f, 1.50498152e-01f, 4.53628808e-01f, -1.24358207e-01f, 2.87488043e-01f, 1.21620931e-01f, 6.89656660e-03f, -4.35597776e-03f,
  1.31816506e-01f, 1.11207783e-01f, 3.05880010e-02f, -2.48566568e-01f, 1.24813259e-01f, -7.00029358e-02f, -1.84340224e-01f, -1.95230082e-01f, -3.85436900e-02f, -1.09480515e-01f,
  -4.00007367e-02f, 1.28133059e-01f, 1.14584528e-02f, -7.84185678e-02f, 1.28422216e-01f, 1.03925914e-02f, 1.48502551e-02f, -2.20678141e-03f, 5.18710390e-02f, 1.48612568e-02f,
  -5.97960129e-02f, 1.53339878e-02f, 9.03295875e-02f, -3.38035598e-02f, 5.65603226e-02f, 2.23294292e-02f, 1.04689728e-02f, -4.39778809e-03f, -4.24787924e-02f, 2.12847907e-02f,
  4.42130165e-03f, 2.72153807e-03f, 1.44051369e-02f, -1.78159438e-02f, 5.51003329e-02f, 8.96341130e-02f, 6.11130856e-02f, -3.16326059e-02f, 5.51599776e-03f, 1.13477655e-01f,
  5.71334399e-02f, 6.07509874e-02f, -1.13542512e-01f, -5.51477261e-02f, 5.84900118e-02f, -3.75243053e-02f, 1.92760620e-02f, -7.69262668e-03f, 2.99368221e-02f, 2.08527828e-03f,
  -2.46452307e-03f, -5.47852293e-02f, 3.76058705e-02f, 7.91838989e-02f, -3.17302607e-02f, 6.45632371e-02f, -6.40272573e-02f, -1.07252695e-01f, 7.54177338e-03f, -7.47039728e-03f,
  1.46414526e-03f, -6.19919896e-02f, -3.37423310e-02f, -7.20795840e-02f, 2.78631784e-03f, 2.90854722e-02f, -2.28676740e-02f, -8.49704966e-02f, -7.84652606e-02f, 5.83292805e-02f,
  -6.22214470e-03f, -5.24148624e-03f, 5.93104458e-04f, 1.23734614e-02f, 1.04019884e-03f, -3.69603597e-02f, 1.11873103e-02f, -2.64270492e-02f, 1.71870403e-02f, 1.17640002e-02f,
  9.37371477e-02f, -9.63755883e-03f, -7.53149316e-02f, 7.21180663e-02f, -8.81742965e-03f, -6.33003488e-02f, -5.01778210e-03f, 5.75568341e-02f, 3.87266017e-02f, 1.32326717e-02f,
  3.59425768e-02f, 1.05504226e-03f, 7.63758197e-02f, 3.21402065e-02f, 2.15787515e-02f, 2.79512946e-02f, -1.65174659e-02f, -3.02983429e-02f, 1.38093131e-02f, -1.29773272e-02f,
  -6.75558299e-02f, 1.75551269e-02f, -2.58055359e-01f, -1.88673586e-01f, -2.24315807e-01f, 2.66488373e-01f, 3.74616861e-01f, -1.85897619e-01f, -1.41924890e-02f, 2.59606451e-01f,
  2.84549389e-02f, 3.51694673e-02f, 1.82402685e-01f, -1.41421407e-01f, -4.37999628e-02f, 2.22231150e-01f, -7.58860335e-02f, 2.64278892e-02f, -1.26980692e-01f, -2.16806993e-01f,
  -2.25646913e-01f, -5.82580529e-02f, -2.03484237e-01f, -1.88580185e-01f, -2.12802127e-01f, -1.61791772e-01f, 1.27851113e-03f, -2.79658996e-02f, -1.04062714e-01f, 7.39143714e-02f,
  4.00446281e-02f, -5.10457084e-02f, -1.47620872e-01f, 4.70446907e-02f, 3.33128609e-02f, 3.73161845e-02f, 6.35242015e-02f, -9.21074592e-04f, -4.76817787e-02f, 6.59646913e-02f,
  8.66216868e-02f, -4.76380289e-02f, -5.69056757e-02f, 3.51752900e-03f, -8.23571011e-02f, -6.22741990e-02f, -1.10788405e-01f, 3.32551450e-02f, -1.04353115e-01f, -7.64856860e-02f,
  -1.72089338e-02f, -1.43359264e-03f, -5.41580357e-02f, -1.82754174e-02f, -1.69491023e-02f, -3.03790998e-02f, 3.29616629e-02f, 5.01738898e-02f, 4.56328280e-02f, 5.55583164e-02f,
  2.51873713e-02f, -8.58837441e-02f, 1.89132728e-02f, -4.43227850e-02f, 5.77678420e-02f, -5.69094270e-02f, 3.11369728e-02f, -3.57962772e-02f, -1.36528919e-02f, 6.14563525e-02f,
  -1.24864699e-02f, -1.13976568e-01f, -2.78374385e-02f, 4.82953037e-04f, -2.05813181e-02f, -8.10460839e-03f, -7.69147975e-03f, -1.31740421e-03f, -3.56406942e-02f, -1.25703365e-02f,
  1.15355430e-02f, 3.15633602e-02f, 1.46649557e-03f, -8.86692107e-02f, 1.25358373e-01f, 3.86479050e-02f, -1.10626712e-01f, 2.90620048e-02f, -9.68307108e-02f, 1.95686743e-02f,
  1.96050048e-01f, 1.40826687e-01f, -3.72653194e-02f, -3.05484552e-02f, 5.97795695e-02f, 9.62272898e-05f, -5.80625199e-02f, 1.25103081e-02f, 1.33738130e-01f, -3.41660380e-02f,
  -6.98578060e-02f, -2.33390480e-02f, 1.55811191e-01f, 4.82554436e-02f, -1.43035408e-02f, -3.06432950e-03f, 6.67894036e-02f, -1.29826469e-02f, 2.12215707e-02f, -7.14745466e-03f,
  -2.10293643e-02f, 4.77473736e-02f, -3.31362449e-02f, 1.01544037e-02f, 3.10738795e-02f, 8.90308470e-02f, 8.53593946e-02f, 6.60055205e-02f, -5.98305836e-02f, -3.98803428e-02f,
  1.48531467e-01f, -2.85498530e-01f, -2.33419359e-01f, 6.53976053e-02f, -1.16879441e-01f, -5.02928309e-02f, 5.74007211e-03f, -1.03530489e-01f, 1.82480384e-02f, 1.11505434e-01f,
  6.05563000e-02f, -2.12180093e-01f, -2.24254012e-01f, 3.06372195e-02f, -3.87410074e-01f, -6.41218722e-02f, 4.90564713e-03f, 1.43561661e-01f, -7.96952993e-02f, -1.92658186e-01f,
  -1.69066172e-02f, -2.23122820e-01f, -1.06188916e-01f, -1.47260070e-01f, -1.62237883e-01f, 1.85017765e-01f, 3.92826647e-02f, -2.39979357e-01f, 8.50907713e-02f, -9.48494598e-02f,
  1.46681055e-01f, -1.07945345e-01f, -7.84286112e-02f, 7.25285262e-02f, 1.11335509e-01f, 9.78151560e-02f, 1.47835299e-01f, -1.88376904e-01f, -4.88720499e-02f, 4.70028259e-02f,
  5.72147332e-02f, -7.63286054e-02f, -5.19720884e-03f, -9.54670012e-02f, 7.69260973e-02f, 2.76410896e-02f, 6.17980957e-02f, 1.15320511e-01f, -1.37566939e-01f, -3.21027637e-02f,
  1.63084269e-02f, 1.18528374e-01f, 1.40675932e-01f, 6.09927587e-02f, 2.37635933e-02f, 5.33702523e-02f, 1.53583325e-02f, -1.03182700e-02f, 1.07533701e-01f, 8.28236416e-02f,
  9.24449693e-03f, -5.55297099e-02f, -5.71577735e-02f, -9.46428701e-02f, -9.82217565e-02f, 5.45869879e-02f, -4.66696434e-02f, -6.71903184e-03f, 2.01085191e-02f, -8.14330205e-02f,
  6.45631403e-02f, 1.43804764e-02f, 5.37682660e-02f, 1.07118711e-02f, 2.66897939e-02f, -4.39672638e-03f, -2.87867934e-02f, 5.75629715e-03f, 6.78866953e-02f, 5.44209071e-02f,
  -1.10954568e-01f, 2.56816000e-02f, -9.87584591e-02f, 1.21698372e-01f, -3.41629772e-03f, 9.60334763e-03f, 1.58078708e-02f, -4.34756801e-02f, 6.44320995e-02f, -1.05172336e-01f,
  -4.95688152e-03f, -2.57905960e-01f, -9.17722359e-02f, -1.63171310e-02f, -1.18468493e-01f, -1.25392959e-01f, -5.37247285e-02f, -2.51206234e-02f, -3.98873687e-02f, -1.35424109e-02f,
  1.36215121e-01f, 4.53383364e-02f, 1.26499489e-01f, 3.11113112e-02f, 5.49432002e-02f, -5.60776964e-02f, 1.39899075e-01f, -2.06420720e-02f, 4.40039113e-02f, -1.34185040e-02f,
  -2.04345733e-02f, 4.57832590e-02f, -2.45058108e-02f, 7.24203512e-02f, 3.05624250e-02f, 6.03507869e-02f, 4.80856653e-03f, 3.93392257e-02f, -3.20667960e-02f, 4.17032628e-04f,
  -3.47824723e-01f, 2.39246994e-01f, 7.44914114e-02f, -2.03913599e-01f, -1.76326737e-01f, -2.22362056e-01f, 6.66940585e-02f, -3.94686013e-02f, 7.25626722e-02f, 3.18604916e-01f,
  2.46807896e-02f, 9.83961970e-02f, 1.87674209e-01f, -2.88537174e-01f, -4.25325513e-01f, 1.28115878e-01f, -2.77628720e-01f, -1.52192088e-02f, -3.65231000e-02f, -1.59992784e-01f,
  -2.22709566e-01f, -3.34410369e-01f, -1.17856458e-01f, -1.63416460e-01f, -1.98525742e-01f, 1.14218049e-01f, 3.75652872e-02f, 4.32300158e-02f, -2.08745286e-01f, -6.69325367e-02f,
  1.52199902e-02f, 5.37959933e-02f, 4.14247364e-02f, -1.08741224e-03f, -7.57431984e-02f, 2.44712327e-02f, 1.34379677e-02f, 1.31546324e-02f, -5.47674391e-03f, 6.69188797e-02f,
  7.77059793e-02f, -1.34254610e-02f, -6.65091202e-02f, 3.62101272e-02f, -5.82250841e-02f, 4.61703949e-02f, -1.94225404e-02f, -5.24820276e-02f, 3.23602669e-02f, -3.51824313e-02f,
  6.72665760e-02f, 8.64423160e-03f, -7.42112547e-02f, 9.55636203e-02f, -5.31111620e-02f, 5.20030223e-02f, 1.30476663e-02f, 1.86246876e-02f, 1.70999188e-02f, -3.31260674e-02f,
  -5.18375672e-02f, -1.42997885e-02f, 1.09304702e-02f, -6.87422743e-03f, -3.64125632e-02f, 3.62077914e-02f, -3.02060097e-02f, -3.10206264e-02f, 3.43388692e-02f, -1.59229785e-02f,
  7.75417462e-02f, -2.50290334e-03f, 1.21426620e-02f, 4.58910912e-02f, 1.78486202e-02f, -2.29937397e-02f, 1.92296648e-04f, 1.01780407e-01f, -7.78342597e-03f, 2.76418310e-03f,
  6.54805750e-02f, -3.11751245e-03f, 7.57810026e-02f, -6.55291602e-03f, -1.82021856e-02f, -6.11825613e-03f, 3.50869149e-02f, 2.58391500e-02f, 2.45198898e-04f, -4.50612456e-02f,
  -5.62917851e-02f, 1.29741924e-02f, 6.87917545e-02f, 9.38957930e-02f, 1.03835531e-01f, -5.36552891e-02f, -2.02960474e-03f, -5.04224747e-02f, -1.42798312e-02f, -1.05470829e-01f,
  -4.32542413e-02f, 2.35184859e-02f, 3.85966934e-02f, -2.57298090e-02f, 2.50178445e-02f, 2.03599893e-02f, 3.26180235e-02f, 6.66711703e-02f, -1.91681162e-02f, 9.86325555e-03f,
  -3.86560671e-02f, 2.14884095e-02f, 3.05388570e-02f, -5.57807162e-02f, -1.89447775e-02f, -6.11327169e-03f, -2.24032290e-02f, 9.75621492e-02f, -4.69625443e-02f, 1.53825749e-02f,
  1.73378736e-01f, -4.89930123e-01f, 5.20291962e-02f, -1.39059111e-01f, -1.30363703e-01f, -1.06686160e-01f, -8.89512822e-02f, -2.05089986e-01f, -3.73325139e-01f, -1.65089995e-01f,
  -1.00019708e-01f, 1.84283985e-04f, -1.32893741e-01f, -3.63628954e-01f, 3.41519266e-01f, -7.01925829e-02f, -2.50524372e-01f, -1.23653464e-01f, -1.14079081e-01f, -3.29020545e-02f,
  -1.85605958e-02f, -1.58675060e-01f, 7.50006959e-02f, -1.61332861e-02f, -1.99749336e-01f, 7.96029195e-02f, 3.09952885e-01f, 8.72119963e-02f, 1.38409734e-01f, -3.60672139e-02f,
  -6.18062988e-02f, -1.64509609e-01f, -7.40244985e-02f, 1.09086275e-01f, -1.18893990e-02f, 9.85838100e-02f, 5.41214347e-02f, 1.15140133e-01f, 1.15622349e-01f, -1.63593981e-02f,
  -2.18689293e-02f, 8.09617937e-02f, -5.77496737e-02f, -2.49193255e-02f, -1.21506043e-01f, 3.64053994e-02f, -2.15844698e-02f, -6.21597543e-02f, -1.14076450e-01f, 1.32247144e-02f,
  -5.60927168e-02f, -4.01826622e-03f, -3.00191455e-02f, -8.21172539e-03f, 1.70080718e-02f, -3.33414897e-02f, -2.48206961e-05f, 1.13079406e-01f, 2.35946141e-02f, -3.87483649e-02f,
  4.92061377e-02f, 4.95822448e-03f, -4.36709709e-02f, -5.34936003e-02f, -5.11261448e-02f, 5.29207708e-03f, -2.88330298e-02f, -5.66600077e-02f, -2.85907928e-02f, -5.48827387e-02f,
  2.04537082e-02f, -6.54800683e-02f, -9.19394866e-02f, 4.81257588e-02f, -6.39499053e-02f, -5.42435795e-02f, 3.88639458e-02f, -2.00588349e-02f, 1.10550942e-02f, 1.83888264e-02f,
  -7.08020553e-02f, -3.79592925e-02f, 5.58630424e-03f, -3.35198641e-02f, -9.73115936e-02f, 5.71680441e-02f, -2.80417292e-03f, -7.82738382e-04f, -1.40561992e-02f, 3.62106562e-02f,
  -1.73618272e-01f, -1.04688406e-01f, -7.19106719e-02f, -2.43924875e-02f, -2.85801981e-02f, -1.58025064e-02f, -1.27971945e-02f, -2.59158947e-02f, 1.00936054e-03f, -3.19546498e-02f,
  7.83185735e-02f, -2.62070335e-02f, 6.30403832e-02f, 4.51622494e-02f, 1.37083545e-01f, -2.88749579e-02f, 6.44761622e-02f, 1.81721635e-02f, 2.47386619e-02f, 1.20034218e-01f,
  6.94920495e-02f, 6.03749081e-02f, 5.33923842e-02f, -3.91630195e-02f, 1.94550548e-02f, 6.28020167e-02f, -6.25537410e-02f, 5.63347861e-02f, -3.04764844e-02f, 1.39657995e-02f,
  5.48341088e-02f, 1.80641249e-01f, 1.23115154e-02f, -2.52738714e-01f, -2.96528578e-01f, 2.99415916e-01f, -3.15066911e-02f, -2.06887692e-01f, -2.66157500e-02f, 2.49124467e-02f,
  -1.35487586e-01f, 3.00486326e-01f, 1.85078140e-02f, -3.12575474e-02f, 3.94869775e-01f, 2.84188718e-01f, 1.67756513e-01f, 1.83737934e-01f, 7.41811916e-02f, -3.64914611e-02f,
  -3.52186933e-02f, -1.60225302e-01f, -4.98414673e-02f, -1.57317474e-01f, -3.12396646e-01f, -1.52727544e-01f, -2.23794118e-01f, -1.29987687e-01f, -5.46060391e-02f, 1.05179258e-01f,
  -1.22037176e-02f, -1.42834306e-01f, -9.21962261e-02f, 6.54724315e-02f, -1.90465536e-03f, -4.54158224e-02f, -2.00169515e-02f, 3.46350968e-02f, 1.83060002e-02f, 2.69973278e-02f,
  -5.45005221e-03f, -7.19739881e-04f, 1.60166509e-02f, -2.37300377e-02f, -3.43608521e-02f, -8.70548282e-03f, 4.82184775e-02f, -6.09160550e-02f, -1.01265907e-01f, 2.12570801e-02f,
  -5.51148131e-02f, -1.17332861e-02f, 5.10872621e-03f, 4.46387380e-02f, -3.26524712e-02f, 4.37041223e-02f, 1.01761974e-01f, 1.06175840e-01f, -2.55518463e-02f, 3.21514085e-02f,
  1.91671271e-02f, -2.33137868e-02f, -3.10355481e-02f, -3.31682004e-02f, -6.32534251e-02f, -1.43573865e-01f, 1.91235952e-02f, -6.70135021e-03f, -8.82280350e-04f, 3.10755409e-02f,
  -3.01274043e-02f, -7.54964799e-02f, -5.85957579e-02f, -2.73100901e-02f, 5.06201573e-03f, -6.38900027e-02f, 4.90620248e-02f, 1.12022497e-02f, -7.78454989e-02f, -5.09540029e-02f,
  -5.33632264e-02f, 8.79080147e-02f, -7.55048310e-03f, 6.47369015e-04f, 4.59683239e-02f, -2.87695620e-02f, 2.53305156e-02f, -1.71958711e-02f, -5.96140102e-02f, 7.68247619e-03f,
  1.59893289e-01f, 2.07237720e-01f, -3.39106470e-02f, -1.06734503e-02f, -1.49923256e-02f, 7.79904649e-02f, 4.12126295e-02f, 4.58542630e-02f, 7.14015365e-02f, 3.44625562e-02f,
  3.76570597e-03f, -7.56355599e-02f, 1.13128617e-01f, -1.64860301e-02f, 2.12677922e-02f, -2.48966180e-02f, -2.31009573e-02f, 1.78058597e-03f, 4.82537076e-02f, -4.91765812e-02f,
  -9.47209448e-02f, -2.19599586e-02f, 6.78602606e-02f, 2.20102118e-03f, -2.41442360e-02f, -1.88573655e-02f, -3.58837890e-03f, -4.25101109e-02f, 4.73766625e-02f, 1.06218802e-02f,
  -4.62658077e-01f, 4.78036493e-01f, 1.93821087e-01f, -2.68811345e-01f, 1.37201294e-01f, 1.66686028e-02f, -3.24635118e-01f, 1.92778185e-01f, -1.51880711e-01f, 6.62121475e-02f,
  6.66730031e-02f, 6.50133332e-03f, 2.74257977e-02f, 1.16271037e-03f, -3.71039808e-01f, -2.01038584e-01f, -2.02286810e-01f, -1.35165095e-01f, 6.07338995e-02f, 9.13206339e-02f,
  -2.91152224e-02f, -3.20196114e-02f, -1.08144827e-01f, 3.02604288e-01f, 7.86094740e-02f, 1.13019370e-01f, -1.98894572e-02f, 1.50315642e-01f, 6.64409325e-02f, -4.87963110e-03f,
  -6.06389157e-02f, 3.62318493e-02f, -3.24706286e-02f, 2.80855014e-03f, -1.67958997e-02f, -5.16579933e-02f, -8.70635137e-02f, -4.97106574e-02f, -8.49636570e-02f, 2.75637470e-02f,
  3.89416441e-02f, -4.07309830e-03f, 1.37493741e-02f, -8.09640437e-02f, 2.60102637e-02f, -7.77455512e-03f, -8.22024327e-03f, -5.37422188e-02f, 1.53862368e-02f, 1.87452640e-02f,
  4.17392552e-02f, 5.10579869e-02f, 5.46921641e-02f, -8.88076029e-05f, 1.61143392e-02f, -4.47366722e-02f, -7.23693669e-02f, -2.90951524e-02f, 8.08967929e-03f, 3.33006158e-02f,
  2.82303686e-03f, -5.40666990e-02f, -1.56073105e-02f, 6.49160473e-03f, 3.01386323e-02f, 6.14479482e-02f, -6.26723692e-02f, 1.73163284e-02f, -6.99700713e-02f, 4.01611850e-02f,
  4.21052985e-03f, 1.88839063e-02f, -1.27574559e-02f, -3.02634351e-02f, 3.85871180e-03f, -5.52703291e-02f, -1.14077143e-03f, 2.77669299e-02f, 1.27294790e-02f, -5.94534464e-02f,
  1.81172090e-03f, -2.14334913e-02f, 1.34774940e-02f, -1.56111931e-02f, -9.49107707e-02f, -2.18595918e-02f, 5.14690541e-02f, 4.43409979e-02f, -1.32837007e-02f, -3.09710726e-02f,
  1.69987008e-01f, 3.69990587e-01f, 4.63302210e-02f, 1.97354592e-02f, 5.20043634e-03f, 9.20154974e-02f, 1.74786281e-02f, 6.99823946e-02f, 9.22851823e-03f, 1.85638219e-02f,
  -2.74566077e-02f, -9.57683772e-02f, 2.30595637e-02f, -3.84762138e-03f, 3.39750089e-02f, 9.81944427e-02f, -4.12980057e-02f, -2.48148069e-02f, -8.38800892e-03f, 4.46986035e-02f,
  -1.80568360e-02f, -5.32131605e-02f, -1.61601678e-01f, 2.72678640e-02f, -6.46982715e-03f, -7.06402808e-02f, 7.05514625e-02f, -7.03534577e-03f, 8.97934288e-02f, -5.24414517e-02f,
  2.20391244e-01f, -2.80116409e-01f, 1.93702340e-01f, 5.36749288e-02f, 1.83513567e-01f, 2.61659622e-01f, -1.22300968e-01f, 1.78557575e-01f, 2.65178323e-01f, -4.25912827e-01f,
  -2.28579968e-01f, -2.24840045e-01f, -1.87824458e-01f, -1.62409678e-01f, 3.48705739e-01f, 1.13394178e-01f, 1.20604709e-01f, 3.49312946e-02f, 1.89301178e-01f, -3.36153917e-02f,
  1.89695016e-01f, -1.37904003e-01f, -1.30434617e-01f, 3.87827354e-03f, -2.66407251e-01f, -2.07347609e-02f, -2.96001375e-01f, 1.07841201e-01f, -2.52552330e-01f, 1.27889842e-01f,
  2.12884098e-02f, -7.43426532e-02f, -4.81086597e-02f, 8.06725770e-03f, -1.31636336e-01f, -1.15518637e-01f, -8.50440562e-02f, -2.25481484e-02f, 9.90427583e-02f, -2.67841183e-02f,
  -1.57277152e-01f, 2.29466148e-02f, -6.15847930e-02f, 9.11822263e-03f, 3.03886235e-02f, 7.81781133e-03f, -3.25470464e-03f, 2.82079238e-03f, -3.38156149e-02f, 1.13144971e-01f,
  4.99687679e-02f, -2.14579068e-02f, -2.63121650e-02f, -4.97448035e-02f, 1.18942015e-01f, 1.43144941e-02f, -1.18825305e-03f, 4.57660593e-02f, -5.22518298e-03f, 6.23434521e-02f,
  8.04562345e-02f, 1.69989690e-01f, -1.51833156e-02f, 2.39914525e-02f, -1.45907020e-02f, -2.78023537e-02f, 5.79048274e-03f, -1.40440896e-01f, 9.08139870e-02f, -3.76505181e-02f,
  -5.08984849e-02f, 2.91930307e-02f, 1.09475978e-01f, -4.94102165e-02f, -3.39611433e-02f, -4.66934964e-02f, 8.41819972e-04f, -3.04543413e-02f, -5.91361150e-03f, -4.04558703e-02f,
  -4.08768505e-02f, 1.06310323e-01f, -7.75905252e-02f, -7.48887807e-02f, 4.21628468e-02f, 2.20978800e-02f, -8.99102092e-02f, 8.72100666e-02f, -2.28057299e-02f, -6.01560716e-03f,
  9.36721861e-02f, -6.54165894e-02f, 6.08401820e-02f, 3.55954207e-02f, 5.06683774e-02f, 2.28194129e-02f, 7.21421167e-02f, 1.43988341e-01f, 3.45389247e-02f, -5.05468547e-02f,
  2.79450715e-02f, -6.45955205e-02f, -7.88208395e-02f, 3.76679711e-02f, -1.72694754e-02f, -9.25225317e-02f, -5.47885261e-02f, -3.68112661e-02f, -9.69770700e-02f, -1.99806485e-02f,
  -3.70880440e-02f, -9.52381734e-03f, 1.16766002e-02f, -1.54944211e-01f, -4.24579307e-02f, -7.75462016e-02f, 7.10698171e-03f, 7.54741132e-02f, -1.54091809e-02f, -5.18813310e-03f,
  -6.25274852e-02f, 1.88315138e-01f, -7.09714964e-02f, -3.51216346e-01f, -6.18428253e-02f, 4.84911025e-01f, 3.23248982e-01f, -1.20188832e-01f, -1.38595119e-01f, 1.48324251e-01f,
  2.52266228e-02f, -1.84378587e-02f, 2.03493431e-01f, -1.83683679e-01f, 2.98564434e-01f, 2.54741132e-01f, -2.58305706e-02f, -2.93350201e-02f, -8.63527358e-02f, -1.00333214e-01f,
  -9.18490365e-02f, -3.92636955e-02f, 3.23677659e-02f, -1.53186932e-01f, -4.66072857e-02f, -1.62603959e-01f, -9.20075625e-02f, 1.55681044e-01f, -1.39625564e-01f, 8.68469551e-02f,
  3.32797915e-02f, -1.93707049e-01f, -5.53861223e-02f, 6.96554631e-02f, 2.92992517e-02f, -2.09444240e-02f, 9.61874798e-03f, 9.43787023e-02f, -5.52908890e-03f, -2.19952594e-02f,
  2.84104468e-03f, -6.42031804e-02f, -1.48854807e-01f, 2.21637543e-02f, -6.04633382e-03f, -1.01348661e-01f, -7.11772544e-03f, -1.08841524e-01f, -3.80893536e-02f, -2.45683789e-02f,
  -3.38316597e-02f, -3.45554613e-02f, -1.85799561e-02f, -3.38696241e-02f, -3.71768139e-02f, -1.01400413e-01f, -5.08767888e-02f, 6.10083826e-02f, 6.20366447e-02f, -5.16285710e-02f,
  3.48497741e-02f, 4.20713425e-02f, 4.12665447e-03f, -4.67493832e-02f, -5.07314503e-02f, -3.25097814e-02f, 3.43777314e-02f, 7.06685260e-02f, -1.15654450e-02f, 1.50196010e-03f,
  -3.66717950e-02f, 3.67736481e-02f, -5.09105176e-02f, -1.04816563e-01f, -6.75745383e-02f, -1.40055284e-01f, 4.92009297e-02f, -8.91485587e-02f, -2.48783343e-02f, -7.32138231e-02f,
  5.68429939e-02f, 7.77217746e-02f, 8.22898522e-02f, 6.26848787e-02f, 7.27323592e-02f, 4.48515639e-02f, -5.10996468e-02f, 2.94637866e-03f, 2.57760864e-02f, 9.76127908e-02f,
  3.04563850e-01f, 1.53398484e-01f, 1.31296918e-01f, -1.38459858e-02f, 5.50482906e-02f, 5.52821606e-02f, -1.86709519e-02f, -3.14788520e-02f, 1.01321332e-01f, 9.65087861e-03f,
  -5.20037999e-03f, -3.44303846e-02f, 1.37172397e-02f, -7.59177878e-02f, 9.54803452e-02f, 2.69850418e-02f, 1.83343347e-02f, 7.05011860e-02f, 1.39043972e-01f, -3.80731672e-02f,
  -2.15154272e-02f, -1.32967066e-02f, -6.31067604e-02f, -6.68027401e-02f, -1.28995540e-04f, 1.45259174e-02f, -1.13862604e-01f, -4.87944223e-02f, -7.76666328e-02f, -6.34716963e-03f,
  -1.31279200e-01f, 3.38808089e-01f, -2.60517985e-01f, -1.11540757e-01f, -8.72473139e-03f, -2.17506438e-02f, 4.51607406e-02f, -9.28203110e-03f, 3.32153253e-02f, 3.60749513e-01f,
  2.18130350e-01f, -4.16613966e-02f, 1.30910233e-01f, 2.77115032e-02f, -5.85122071e-02f, 1.19581604e-02f, 7.80351609e-02f, 1.28038317e-01f, -1.15036823e-01f, 8.11925307e-02f,
  -1.13362141e-01f, 2.70871490e-01f, -2.56528348e-01f, 6.48109242e-02f, -5.33261187e-02f, -1.56175837e-01f, 2.31648043e-01f, -9.31050032e-02f, 9.74815264e-02f, -3.92958671e-02f,
  1.00726612e-01f, -7.31459409e-02f, -8.20167065e-02f, 2.47976165e-02f, -4.43996908e-03f, 5.12648635e-02f, -4.05807607e-02f, -1.99558493e-02f, -4.30573113e-02f, -1.27354013e-02f,
  -2.90688854e-02f, 1.04054287e-02f, -6.62729442e-02f, 3.73505726e-02f, -6.50545442e-03f, -8.39675814e-02f, -4.20679711e-02f, -8.27954337e-03f, -2.71314904e-02f, -1.22499339e-01f,
  -9.55857411e-02f, -6.85609579e-02f, -6.65969551e-02f, 5.99464914e-03f, -7.13464618e-02f, -6.31564781e-02f, 7.98933150e-04f, -2.94180270e-02f, 1.17248101e-02f, 4.02596220e-02f,
  -5.84986880e-02f, 2.34211925e-02f, -4.74775992e-02f, -3.68430689e-02f, 2.33189072e-02f, -7.71245435e-02f, 7.19754994e-02f, 5.80725335e-02f, -4.09608334e-03f, 5.56540154e-02f,
  -8.85292329e-03f, -5.27099296e-02f, -2.96779647e-02f, 2.58229729e-02f, 8.36119950e-02f, -2.08404418e-02f, -5.47869503e-03f, 7.13453814e-02f, -9.06876661e-03f, -6.12760484e-02f,
  -5.35913557e-03f, -3.31192091e-02f, 1.14808213e-02f, 5.21983542e-02f, 1.38707543e-02f, 3.38313431e-02f, 1.45010669e-02f, 1.14452164e-03f, -6.54934719e-02f, 2.87202634e-02f,
  3.81461263e-01f, 4.04483706e-01f, 8.09084028e-02f, 4.61030342e-02f, 6.93689808e-02f, 2.59562731e-02f, 7.26240501e-02f, 1.82723459e-02f, 3.19444127e-02f, 2.18892866e-03f,
  7.99084306e-02f, 3.92630808e-02f, 5.90183288e-02f, -4.84389216e-02f, -1.51443612e-02f, 7.50450790e-02f, 1.45457417e-01f, 1.13194034e-01f, 1.50424227e-01f, 1.10427178e-01f,
  6.67914003e-02f, 1.48506895e-01f, -8.61360654e-02f, -6.33922964e-02f, 8.87877773e-03f, 8.08151811e-02f, 1.86279621e-02f, -4.64526042e-02f, 4.80862036e-02f, 8.47385302e-02f,
  1.12221748e-01f, -1.66955128e-01f, -2.46033952e-01f, -1.31738171e-01f, 1.40322059e-01f, 3.37242216e-01f, 1.58969969e-01f, 1.74728796e-01f, 1.39150182e-02f, 1.21573231e-03f,
  2.13548303e-01f, -2.18167499e-01f, -3.24757360e-02f, 3.67348611e-01f, 2.30114013e-01f, 2.20882669e-01f, 2.28172004e-01f, -1.29953716e-02f, 2.10668985e-02f, 4.28947899e-03f,
  9.40226540e-02f, 3.22021008e-01f, 1.06906392e-01f, 1.49364159e-01f, -2.43536439e-02f, -1.51861414e-01f, -1.11791641e-01f, -1.08087100e-01f, 3.28439176e-02f, 1.21328115e-01f,
  1.33842945e-01f, -3.85504477e-02f, -9.83418301e-02f, -2.91184988e-02f, -3.93619128e-02f, -6.04938306e-02f, -6.66153803e-02f, -2.62713488e-02f, 5.08117564e-02f, 1.90446049e-03f,
  -4.25425321e-02f, 4.32154201e-02f, 3.16306464e-02f, -6.29499927e-02f, -3.11558694e-02f, 2.39739604e-02f, 5.69678992e-02f, -9.00931831e-04f, 2.13483293e-02f, -4.12599742e-02f,
  -9.30651091e-03f, -5.41031770e-02f, -9.39601753e-03f, 1.26171466e-02f, -4.82479595e-02f, 8.40526819e-02f, -7.49911293e-02f, -1.52074143e-01f, 5.09559084e-03f, 4.28166837e-02f,
  -1.93219278e-02f, -5.48389973e-03f, 2.12796275e-02f, 6.99758679e-02f, -1.59074820e-03f, 4.36052978e-02f, 4.81655337e-02f, 3.95374261e-02f, -1.11889444e-01f, 3.45845446e-02f,
  1.08344659e-01f, -7.13407472e-02f, 4.42941561e-02f, 2.13223416e-02f, 1.98067594e-02f, -4.49271277e-02f, -6.85983375e-02f, -2.46650795e-03f, -3.41045596e-02f, -2.38259826e-02f,
  -1.92051679e-02f, 5.54340705e-02f, -3.96802165e-02f, -2.05091815e-02f, 8.40638578e-02f, -2.96094902e-02f, -1.44189997e-02f, 3.05773560e-02f, 3.25341448e-02f, -1.17619075e-02f,
  7.89985508e-02f, -7.48783350e-02f, 1.05877817e-02f, 6.85552955e-02f, -9.31979790e-02f, 8.35019723e-03f, 6.60222769e-03f, 7.75330886e-02f, -1.74224898e-02f, 1.19356886e-01f,
  -1.22301495e-02f, -4.02373374e-02f, -3.60649265e-02f, 2.85930596e-02f, 3.37607809e-03f, 1.82690825e-02f, -5.01427539e-02f, -1.10716335e-01f, -4.82346565e-02f, -1.41910389e-02f,
  -7.21308887e-02f, 2.35256925e-02f, -8.04451033e-02f, 2.57694833e-02f, -1.42969843e-02f, 3.07508986e-02f, 1.11309215e-02f, 1.84854437e-02f, 4.72954810e-02f, -9.80425104e-02f,
  7.92813599e-02f, -9.60837677e-02f, -1.75687239e-01f, -3.97823416e-02f, 1.38688698e-01f, 1.34858087e-01f, 5.35235852e-02f, 5.32757156e-02f, -3.17308307e-01f, -8.96342397e-02f,
  1.84433594e-01f, -9.49482992e-03f, 2.60613319e-02f, 3.37437809e-01f, 3.16774100e-01f, 1.53787136e-01f, 1.36260867e-01f, 1.06499657e-01f, 5.19007631e-02f, 1.36060566e-01f,
  1.14669897e-01f, 3.33986163e-01f, 1.08669288e-01f, 1.70511454e-01f, 1.72407210e-01f, -3.16193491e-01f, 1.33876994e-01f, -3.02132126e-03f, 2.06493318e-01f, 2.01132134e-01f,
  6.15044683e-02f, -5.64512052e-02f, -3.59116681e-02f, -1.69057539e-03f, -2.20954674e-03f, -5.47048636e-02f, -4.17118371e-02f, 4.61524017e-02f, -9.10717994e-02f, -1.30022699e-02f,
  -1.14264458e-01f, 2.50263549e-02f, 3.27401534e-02f, 4.10918007e-03f, -2.31487658e-02f, 1.87433586e-02f, -2.46544052e-02f, -6.54171333e-02f, 2.53171921e-02f, 3.86575088e-02f,
  -4.78536300e-02f, 2.10424121e-02f, -1.16244219e-02f, -8.04707408e-02f, -5.01152165e-02f, 2.38811634e-02f, -8.78755152e-02f, 1.30037041e-02f, -5.92437573e-02f, -3.02580855e-04f,
  7.07570091e-02f, 7.30707776e-03f, 5.50310761e-02f, -1.03986701e-02f, 1.27875730e-02f, 2.60809790e-02f, -1.79042965e-02f, 7.09430352e-02f, -3.41300629e-02f, 4.39592935e-02f,
  3.27276513e-02f, 2.59995237e-02f, 4.42751311e-02f, -4.89742160e-02f, 3.86744402e-02f, -4.35253866e-02f, -1.28726019e-02f, 4.31769714e-02f, 3.01437471e-02f, 2.74680201e-02f,
  -1.15116416e-02f, 1.01351701e-01f, -1.43370312e-02f, 2.79877800e-02f, 9.16730799e-03f, -4.02791910e-02f, 5.81536815e-02f, -2.46024504e-02f, -6.75364882e-02f, 2.80882027e-02f,
  3.49211879e-02f, 2.68673040e-02f, -4.60094362e-02f, -2.18357332e-02f, -1.43271722e-02f, 5.93622737e-02f, 3.11299637e-02f, 1.87022388e-02f, 3.03464364e-02f, 2.33313572e-02f,
  6.98974803e-02f, -8.82839691e-03f, -2.55667176e-02f, 2.84444876e-02f, 2.06123888e-02f, 6.73442482e-05f, -4.07638913e-03f, -1.23545393e-01f, -3.96535248e-02f, 5.07396385e-02f,
  -9.02045425e-03f, -4.08910438e-02f, 2.33035162e-02f, -4.06054966e-02f, 5.17717265e-02f, -2.81095877e-02f, 2.49224878e-03f, 5.65128634e-03f, 8.27946588e-02f, -1.64093561e-02f,
  1.02037020e-01f, -3.67265016e-01f, -2.70743370e-01f, -1.52969345e-01f, 1.72956139e-01f, 2.72494018e-01f, 3.41709293e-02f, -1.60508692e-01f, -3.83220583e-01f, -5.75174019e-02f,
  4.74040434e-02f, -1.00304663e-01f, -2.89511144e-01f, 9.16174874e-02f, 5.59339039e-02f, -3.07671726e-01f, 9.43766609e-02f, 7.35768974e-02f, -1.82641953e-01f, 1.53629659e-02f,
  -5.78041710e-02f, 6.39718920e-02f, -1.64623797e-01f, 5.23312762e-02f, 1.63265452e-01f, 9.78198368e-03f, 2.29651719e-01f, -3.97210643e-02f, 2.83757955e-01f, 7.32234940e-02f,
  -4.06409986e-02f, -1.73017070e-01f, -2.97026616e-02f, 3.55452932e-02f, 1.38101513e-02f, 6.10306375e-02f, 1.73252165e-01f, 1.51977083e-02f, -4.49447855e-02f, -6.18933402e-02f,
  5.10205030e-02f, 6.90737590e-02f, -8.12912360e-02f, -1.17352530e-01f, 7.21156448e-02f, -2.50636246e-02f, 6.27259836e-02f, 4.92067374e-02f, -6.82104155e-02f, -2.87288632e-02f,
  -3.66687216e-02f, -1.26633164e-03f, 1.35028455e-03f, 6.15939945e-02f, 1.21859126e-01f, -1.18479058e-01f, 1.00120656e-01f, 5.34388050e-02f, 1.10418797e-01f, 2.19004117e-02f,
  -1.54842273e-03f, 2.23084390e-02f, 3.49703878e-02f, -3.33735570e-02f, -6.16766028e-02f, 1.63472705e-02f, 1.13094181e-01f, 4.21893001e-02f, -1.32799670e-02f, -4.46319953e-02f,
  -3.06852022e-03f, 1.71593744e-02f, 2.83933468e-02f, 4.65701483e-02f, -3.92892621e-02f, -1.86535306e-02f, 4.51786853e-02f, -5.56652946e-03f, -5.71441427e-02f, 1.91404112e-02f,
  -1.11865044e-01f, 1.06254771e-01f, -4.79755178e-02f, 1.23136692e-01f, 4.65388503e-03f, 4.77240868e-02f, 7.44831376e-03f, -8.99004191e-02f, -6.04534894e-02f, 1.19591191e-01f,
  1.14849299e-01f, -4.65814620e-02f, -6.19821437e-02f, 7.68799111e-02f, -8.00347254e-02f, 4.00443114e-02f, -1.51466355e-01f, 9.64842066e-02f, -6.78410083e-02f, -7.36948941e-03f,
  1.10625014e-01f, -1.33720785e-02f, 1.56693891e-01f, 4.79849577e-02f, 1.14236940e-02f, -8.72676596e-02f, -2.12821271e-02f, 5.68836071e-02f, 3.81480902e-02f, 3.10361963e-02f,
  4.66941595e-02f, 1.63778141e-02f, 1.36432201e-02f, -4.18268703e-02f, 1.10666389e-02f, 7.28197247e-02f, 4.08392400e-02f, 3.05559076e-02f, 1.43417343e-01f, -7.94941485e-02f,
  -2.48155370e-01f, -2.31974676e-01f, -1.13376781e-01f, -1.08723134e-01f, -1.24294251e-01f, 8.01348314e-02f, 3.07106584e-01f, -2.79687643e-01f, -1.09233737e-01f, 2.29447320e-01f,
  2.15659514e-01f, -1.20391257e-01f, 2.74176151e-01f, 1.25124454e-01f, 1.52444303e-01f, 3.22413653e-01f, 6.61610588e-02f, 1.41422406e-01f, -1.25109524e-01f, -1.17138602e-01f,
  -1.71876833e-01f, 2.59959489e-01f, 5.81586966e-03f, -1.92898184e-01f, -1.21449180e-01f, -2.13578403e-01f, 1.70400620e-01f, 1.20700836e-01f, -1.65848643e-01f, 6.69124350e-02f,
  2.64471788e-02f, -1.31318346e-01f, -1.19849719e-01f, -6.21311553e-02f, -4.37608659e-02f, 7.56919160e-02f, 7.31458813e-02f, 1.10743716e-01f, 5.60180694e-02f, -1.09829269e-02f,
  8.23541507e-02f, -6.59050643e-02f, 4.89090383e-03f, 8.87570670e-04f, -7.59034790e-03f, -3.05878911e-02f, -1.70846611e-01f, -7.74672329e-02f, 4.27075336e-03f, -6.36040047e-02f,
  -5.70777990e-02f, -4.42548431e-02f, -1.83966123e-02f, 4.22306880e-02f, -6.18248992e-02f, -7.10904524e-02f, 1.00801243e-02f, 3.39121372e-02f, -4.73829499e-03f, -1.72363356e-01f,
  -3.01752239e-02f, 1.79147199e-02f, 4.06514443e-02f, 3.76070142e-02f, 8.21841508e-02f, 1.51824029e-02f, 7.97729865e-02f, 6.41386434e-02f, 1.09650230e-03f, 3.28494795e-02f,
  -7.93889165e-03f, -6.25325218e-02f, 1.08092139e-02f, 3.72975692e-02f, 6.31325319e-02f, 1.98521316e-02f, 5.90575300e-02f, 1.94987442e-04f, -4.06033322e-02f, -8.01066831e-02f,
  4.03652862e-02f, 4.49096859e-02f, 7.03572556e-02f, 5.67286685e-02f, 6.95521832e-02f, 4.36418578e-02f, -3.70669886e-02f, -3.64167728e-02f, 1.45670930e-02f, 8.58585685e-02f,
  1.08697407e-01f, 5.00276983e-02f, 8.02543312e-02f, 5.58481850e-02f, 1.06347047e-01f, -7.01851770e-02f, 2.72160093e-03f, -7.34690353e-02f, 4.13900055e-02f, -2.21095094e-03f,
  -5.92576899e-02f, 6.92354813e-02f, -4.35910933e-02f, 5.18664382e-02f, 6.35731295e-02f, -1.88503210e-02f, 1.76626444e-01f, 4.68100980e-02f, -3.41204950e-03f, -8.77701715e-02f,
  3.71805690e-02f, 5.52349016e-02f, 2.84011364e-02f, 1.18968857e-03f, 7.62167340e-03f, 2.21978184e-02f, -5.13529666e-02f, -7.26657882e-02f, 2.62157060e-02f, 3.47602852e-02f,
  -2.01581329e-01f, -2.11167783e-01f, -1.31452650e-01f, -2.33109802e-01f, -3.18324745e-01f, 3.43306601e-01f, 1.32954881e-01f, -2.71962315e-01f, -6.29414693e-02f, 1.31377742e-01f,
  3.58244404e-02f, 4.08330932e-02f, 1.09522268e-01f, -5.13423122e-02f, 3.68278682e-01f, 3.15176517e-01f, 3.53284627e-01f, 3.13757248e-02f, -6.35161102e-02f, 2.21877582e-02f,
  5.16821407e-02f, -5.33619784e-02f, -9.12258402e-02f, -2.44877651e-01f, -3.63035738e-01f, -1.73792228e-01f, 1.07473932e-01f, -1.79434150e-01f, -2.27874443e-02f, 8.61859992e-02f,
  2.28101090e-02f, -1.53182879e-01f, -1.31106585e-01f, -4.69423719e-02f, 9.55233276e-02f, 6.50315806e-02f, 8.52590874e-02f, 7.94121847e-02f, -8.95541981e-02f, -8.30532536e-02f,
  6.53125122e-02f, -5.18302396e-02f, -1.25507966e-01f, -1.50328636e-01f, -6.03458323e-02f, -1.57161742e-01f, -1.65059149e-01f, -2.07523368e-02f, -1.09741591e-01f, -1.60501078e-02f,
  -1.37051474e-02f, -3.24445404e-02f, 1.08450539e-01f, 9.51022375e-03f, 9.71258730e-02f, -4.08401042e-02f, 1.35044912e-02f, 4.62029204e-02f, 5.64390644e-02f, 5.92872277e-02f,
  -8.69242623e-02f, 1.00261949e-01f, 7.77950510e-03f, -8.85649100e-02f, 3.18926126e-02f, -8.02948177e-02f, -2.24712398e-03f, 3.29576842e-02f, 1.19307868e-01f, -1.45703536e-02f,
  5.16062276e-03f, -5.30568361e-02f, -5.78816272e-02f, -8.38056114e-03f, 7.15681911e-02f, -1.09368868e-01f, 6.93158153e-03f, 1.10898107e-01f, -8.10253620e-02f, 1.52210202e-02f,
  -1.05695508e-01f, 1.14709683e-01f, -1.00694418e-01f, -1.53697270e-03f, -6.33140840e-03f, -6.26546964e-02f, -6.12010211e-02f, -9.94851813e-02f, 7.37247691e-02f, 2.54002810e-02f,
  4.00055140e-01f, 1.19827904e-01f, -1.43468576e-02f, -3.98370437e-02f, 4.37893420e-02f, -3.24509980e-04f, 5.27617708e-02f, -7.05213547e-02f, 5.61735407e-02f, 3.16974930e-02f,
  2.83418577e-02f, 6.10467196e-02f, 5.22376820e-02f, -4.37013665e-03f, 3.61639634e-02f, 6.86748847e-02f, 9.89687890e-02f, -3.51984948e-02f, 5.51671870e-02f, -1.05678625e-01f,
  -1.08981803e-02f, -3.20254378e-02f, 2.10625282e-03f, 1.02840168e-02f, -5.28339371e-02f, 3.49710546e-02f, 8.94803926e-03f, -2.08950639e-02f, -2.75711510e-02f, 4.05553505e-02f,
  -2.02081397e-01f, 4.16232437e-01f, -2.56399661e-01f, -5.16269207e-02f, -2.07779050e-01f, -5.60316965e-02f, 3.00638527e-02f, 4.41555574e-04f, 3.85600179e-02f, 3.72255623e-01f,
  1.12171359e-01f, -1.44853100e-01f, 1.39890298e-01f, 2.60021061e-01f, -2.61190981e-01f, 1.02297984e-01f, 1.88838646e-01f, 1.39107093e-01f, -5.85002638e-02f, 1.43940628e-01f,
  -1.52037665e-01f, 2.58707076e-01f, -2.09496692e-01f, 1.69015512e-01f, -1.07145630e-01f, -1.33824080e-01f, 1.52738407e-01f, -1.25289187e-01f, 8.80051777e-03f, -1.26499042e-01f,
  -4.65881936e-02f, 9.85315815e-02f, 2.01691105e-03f, -4.80797216e-02f, 6.52731583e-03f, -3.19511481e-02f, -2.51172706e-02f, -1.34080827e-01f, -9.91829038e-02f, -3.30123045e-02f,
  -5.17774150e-02f, -1.29408345e-01f, 1.66313350e-02f, -4.69100736e-02f, 3.32197994e-02f, -7.79383406e-02f, -6.89188316e-02f, -7.96632245e-02f, -8.10275972e-02f, -1.63413048e-01f,
  -9.97190699e-02f, -1.18500926e-01f, 2.38922127e-02f, 6.34009892e-04f, -1.63127407e-01f, -1.51928002e-02f, -8.44344124e-02f, -5.39384857e-02f, 1.50322868e-02f, -2.59694178e-02f,
  3.59197939e-03f, 1.05185300e-01f, -6.00658543e-02f, -2.16195825e-02f, 6.18471671e-03f, -4.62657362e-02f, 3.84649783e-02f, -6.23475946e-02f, -2.28194781e-02f, 2.21018996e-02f,
  -4.50364724e-02f, -2.91745998e-02f, -2.26335581e-02f, -6.09851740e-02f, 3.86481993e-02f, -1.86377410e-02f, -7.45324045e-02f, -4.99416031e-02f, 6.29269630e-02f, -1.17692061e-01f,
  4.55228463e-02f, -2.51034386e-02f, 1.16182342e-01f, -9.50451568e-02f, 8.60840175e-03f, -6.19270001e-03f, 2.17649853e-03f, -1.05605721e-01f, -2.59817485e-02f, -9.43887234e-02f,
  2.63598621e-01f, 4.40102279e-01f, 6.16701841e-02f, -4.03418168e-02f, 4.57995012e-02f, 2.81711225e-03f, -5.69551922e-02f, 1.31568769e-02f, 1.33586451e-01f, 6.05632104e-02f,
  2.73809619e-02f, 2.61936057e-02f, 4.04294021e-02f, -4.39140387e-02f, 4.48061451e-02f, 3.78175527e-02f, 3.41810957e-02f, 5.66814095e-02f, 1.09771170e-01f, 6.35469779e-02f,
  3.17232050e-02f, 3.50615494e-02f, -9.68704894e-02f, -1.36244418e-02f, 8.94106179e-03f, 3.98313366e-02f, 8.70032702e-03f, -2.02943361e-03f, -7.89262429e-02f, 6.18660860e-02f,
  -4.02120322e-01f, 2.36674517e-01f, -3.79525065e-01f, -1.27427829e-02f, 5.69369644e-02f, 1.11925356e-01f, 1.93230808e-02f, 1.32123485e-01f, -5.78122996e-02f, 3.23444486e-01f,
  2.74877578e-01f, -1.70889661e-01f, 1.13484666e-01f, 3.05514842e-01f, 1.74240470e-01f, 1.27150908e-01f, 3.48538458e-01f, 2.64398903e-02f, -4.03741002e-03f, 1.74834669e-01f,
  -7.41865560e-02f, 3.51489305e-01f, -9.34149623e-02f, 3.08348417e-01f, 5.34131657e-03f, -1.24639310e-01f, 1.50760993e-01f, -4.16711681e-02f, 2.60267377e-01f, 8.72897059e-02f,
  -1.48778543e-01f, -1.11192361e-01f, -8.86970460e-02f, -1.43547267e-01f, 2.42895018e-02f, -1.18537553e-01f, -6.59421608e-02f, -3.71831656e-02f, -2.67611276e-02f, 2.52096485e-02f,
  -7.16152787e-02f, 3.22859176e-02f, 6.96621984e-02f, -4.01391648e-02f, -9.17321742e-02f, -8.48669037e-02f, -4.43557277e-02f, -9.84471198e-03f, 4.26008254e-02f, -1.02118224e-01f,
  -4.98507656e-02f, -2.18838081e-02f, -4.97167036e-02f, 5.87281287e-02f, -5.25394008e-02f, 2.01531556e-02f, -4.41667289e-02f, -1.13331310e-01f, 5.26724309e-02f, 4.12839837e-02f,
  2.06600428e-02f, 1.57275982e-02f, 6.51246607e-02f, 1.45205092e-02f, 4.99797575e-02f, 2.44667772e-02f, 2.13552490e-02f, 1.66198686e-02f, -7.51112762e-04f, 5.21725304e-02f,
  9.97441486e-02f, -1.71022806e-02f, -3.88164818e-02f, -2.60630697e-02f, -3.68196331e-02f, -5.60165606e-02f, -8.10814649e-02f, 3.04625053e-02f, -3.86983752e-02f, 8.69654864e-03f,
  -3.59476381e-03f, 2.37893611e-02f, 8.57141986e-02f, -1.18991528e-02f, 2.88481452e-02f, 1.98777113e-02f, 3.84950303e-02f, -9.48626827e-03f, 3.74280177e-02f, 1.89456884e-02f,
  1.95833892e-01f, 3.09462935e-01f, -1.64059771e-03f, 1.05446823e-01f, 1.18594775e-02f, 7.38615841e-02f, -1.55849254e-03f, 9.64874681e-03f, 4.71973270e-02f, 8.14885274e-02f,
  -9.00602937e-02f, -4.76019643e-02f, -1.67861786e-02f, 2.66582817e-02f, 1.12875380e-01f, 2.98243035e-02f, 9.70923305e-02f, -3.54416408e-02f, 9.06300247e-02f, 5.28772548e-02f,
  1.52498065e-03f, 8.50690976e-02f, 8.02677032e-03f, 4.37467992e-02f, 5.01012728e-02f, 5.92261106e-02f, 1.12783313e-02f, -1.18972221e-03f, 3.50706950e-02f, 5.90451770e-02f,
  2.67314345e-01f, -2.11290985e-01f, -2.81968445e-01f, 1.42302677e-01f, 3.19152504e-01f, -3.99487376e-01f, -4.68044519e-01f, 1.27763405e-01f, 1.80279575e-02f, -1.74896404e-01f,
  2.77922690e-01f, -1.83492288e-01f, -2.35964283e-01f, 1.40635297e-01f, 1.54274374e-01f, 1.26082674e-01f, 3.43790613e-02f, -2.20027596e-01f, -2.93265656e-02f, -8.88706744e-02f,
  6.72019720e-02f, 2.99098074e-01f, 1.47011414e-01f, 2.56610271e-02f, 6.57720342e-02f, -6.69609010e-02f, 1.20886341e-01f, -2.49164119e-01f, 1.07352242e-01f, 8.11510086e-02f,
  -6.34245127e-02f, 2.15163857e-01f, 3.84953618e-02f, -1.02162972e-01f, 1.58550724e-01f, -4.91810516e-02f, -1.01108886e-01f, -1.92446224e-02f, 8.20991583e-03f, -2.53778417e-02f,
  -1.22867160e-01f, 6.23071007e-02f, 3.84912863e-02f, 8.85498896e-03f, 1.17715700e-02f, -6.13144673e-02f, 4.65245061e-02f, 5.70082180e-02f, -4.10015918e-02f, 6.70887977e-02f,
  -6.89601898e-02f, 6.50780573e-02f, 1.29534930e-01f, -3.08570947e-04f, 8.65162686e-02f, 1.50386440e-02f, -6.87461421e-02f, -2.41069254e-02f, 7.16634793e-03f, -8.99758190e-03f,
  7.03646336e-03f, -3.45423706e-02f, -6.72360929e-03f, -1.21671865e-02f, 5.98850623e-02f, 1.12786166e-01f, -3.19346327e-05f, -1.91952717e-02f, -4.79300618e-02f, 8.18438642e-03f,
  3.78950313e-02f, -4.56658751e-02f, 8.36633071e-02f, 2.79750355e-04f, 5.40330447e-03f, -6.14979817e-03f, -5.01563889e-04f, 1.83142982e-02f, 8.08573142e-02f, 4.06937860e-02f,
  -5.54774217e-02f, -1.58288609e-02f, -8.19271952e-02f, 2.40053628e-02f, -9.20892060e-02f, 8.85098353e-02f, -7.52770994e-03f, 1.54527146e-02f, 1.82119058e-03f, -2.72767544e-02f,
  -1.58321187e-01f, -8.90950114e-02f, -1.12718023e-01f, 5.42570166e-02f, -1.12196155e-01f, -1.32224467e-02f, -1.00896522e-01f, -7.67625915e-03f, -1.14165969e-01f, -2.01856084e-02f,
  6.06618356e-03f, 3.36249061e-02f, -3.75036970e-02f, 5.15160002e-02f, -3.56798396e-02f, 4.54953127e-02f, -1.04249589e-01f, -1.51031375e-01f, 6.01614080e-02f, 6.63391650e-02f,
  7.90646970e-02f, -6.11523427e-02f, -1.49901742e-02f, 3.34337982e-03f, 6.59101224e-03f, 2.70723514e-02f, -1.98846813e-02f, -6.31716549e-02f, 2.11488791e-02f, -1.04443709e-04f,
  -4.36566114e-01f, 2.15622261e-01f, -2.82675236e-01f, -2.14753851e-01f, -2.96986550e-01f, 1.72884792e-01f, -2.57288907e-02f, 1.24073640e-01f, -1.49884194e-01f, 4.33285207e-01f,
  -2.65077446e-02f, 1.29403964e-01f, -5.01504168e-02f, 1.87614396e-01f, -3.12448502e-01f, -3.15022588e-01f, 1.01994038e-01f, 2.29664177e-01f, -1.57912187e-02f, -3.74890454e-02f,
  -1.90310255e-01f, 3.83022875e-02f, -2.74942160e-01f, 1.09783106e-01f, -8.89241174e-02f, 1.50557831e-01f, 1.01993280e-02f, -6.47658035e-02f, 2.75032908e-01f, 4.79782298e-02f,
  -8.76231194e-02f, 1.56248566e-02f, -4.23354432e-02f, 5.10761747e-03f, -2.11468507e-02f, 5.27269579e-03f, 7.27029890e-02f, -3.61047089e-02f, -1.34522364e-01f, 6.98472783e-02f,
  -3.02467998e-02f, 3.49923819e-02f, 9.31009799e-02f, -1.49276312e-02f, 1.33826714e-02f, 7.88836330e-02f, 5.72374417e-03f, -1.41740441e-02f, 8.65196437e-03f, -2.00041924e-02f,
  -5.03876768e-02f, -8.35466140e-04f, -3.71367522e-02f, 6.32793680e-02f, -5.59313856e-02f, 3.39915454e-02f, 1.20794484e-02f, -8.51925537e-02f, 9.96093825e-02f, 4.06566411e-02f,
  8.08247365e-03f, 9.90296714e-03f, -1.01337567e-01f, -2.35865489e-02f, -5.14097372e-03f, -8.31683446e-03f, 7.42891356e-02f, 3.20363306e-02f, 2.23447420e-02f, 2.24736501e-02f,
  -4.88848388e-02f, 2.84575224e-02f, -4.02239384e-03f, 4.90602329e-02f, -2.31519621e-02f, 6.10138662e-02f, -1.00229904e-01f, 4.13233116e-02f, -1.66771729e-02f, -1.44370897e-02f,
  1.07626952e-02f, 3.51211168e-02f, 2.04035956e-02f, -3.09945364e-02f, 4.61915508e-03f, -6.77562654e-02f, -7.53125735e-03f, -4.43678536e-02f, -5.82322516e-02f, -5.45897298e-02f,
  8.53963271e-02f, 1.77285612e-01f, 2.27388088e-02f, 1.18625015e-01f, 7.40162209e-02f, 4.82153110e-02f, -4.20789383e-02f, -1.64612662e-02f, 4.20559347e-02f, -3.07429433e-02f,
  1.15284234e-01f, 2.17878446e-02f, -6.32192120e-02f, -5.11012673e-02f, -1.61648300e-02f, -2.64623631e-02f, -2.19050683e-02f, 3.28757763e-02f, -1.88631061e-02f, 1.45169050e-01f,
  8.66714492e-02f, 4.06976603e-03f, 9.42790788e-03f, 9.37187225e-02f, 6.50852397e-02f, 6.27939254e-02f, -8.35221072e-05f, 5.67304343e-02f, -2.00649002e-03f, 1.09864138e-02f,
  -1.56648040e-01f, -4.69535775e-02f, -2.39345193e-01f, -2.01465357e-02f, 1.37466164e-02f, 4.29098219e-01f, 2.74021327e-01f, -2.58641150e-02f, -2.02668324e-01f, 2.67991453e-01f,
  1.57684132e-01f, -2.38690898e-01f, 1.16553985e-01f, 3.51209193e-01f, 3.75122547e-01f, 2.52221286e-01f, 3.54052246e-01f, 2.83668656e-02f, -1.53518513e-01f, -1.07127570e-01f,
  -4.63993289e-02f, 3.57096136e-01f, 1.26676664e-01f, -7.38178939e-02f, 3.15187797e-02f, -1.49559453e-01f, 2.12409958e-01f, -9.59804431e-02f, 2.29109347e-01f, 1.17032796e-01f,
  1.66228086e-01f, -1.07721105e-01f, -1.27500534e-01f, 2.30648499e-02f, 3.35606630e-03f, 2.94873468e-03f, 1.06906556e-01f, 4.24045324e-02f, -6.52640089e-02f, -1.68387312e-02f,
  -5.11120725e-03f, 5.34458272e-02f, -2.56326539e-03f, -5.72296083e-02f, -4.92310338e-02f, -3.44535522e-02f, -5.53418882e-02f, 1.76907815e-02f, -5.82117178e-02f, -4.65445332e-02f,
  -5.85597306e-02f, -1.23412386e-02f, 6.81972206e-02f, 1.39640290e-02f, 4.63209348e-03f, -1.18956007e-02f, -1.15080667e-03f, -3.50355431e-02f, -3.60277575e-03f, -1.16489053e-01f,
  2.77373064e-02f, 5.40543571e-02f, 3.75069045e-02f, 5.30176647e-02f, 8.97974242e-03f, -1.78500488e-02f, -2.32242839e-03f, 5.13857566e-02f, -2.89000515e-02f, 9.01574641e-02f,
  1.89830270e-02f, -1.44356228e-02f, 2.47551147e-02f, -2.89336476e-03f, -1.89478770e-02f, 2.54926290e-02f, 2.03753803e-02f, 3.06300614e-02f, 8.28098319e-03f, -2.08714772e-02f,
  -4.37736064e-02f, 7.55350366e-02f, -8.29824880e-02f, -1.24266641e-02f, 2.78116819e-02f, 8.28322209e-03f, 6.37862161e-02f, 3.59572954e-02f, 7.17263520e-02f, -2.21123248e-02f,
  1.18230388e-01f, 3.40718366e-02f, -2.95676626e-02f, -9.50490404e-03f, -1.62460059e-02f, -1.00046284e-02f, -2.47055590e-02f, -3.20331715e-02f, 1.82213094e-02f, 5.71846776e-02f,
  3.80669497e-02f, -8.80252793e-02f, 1.27008054e-02f, 3.12516396e-03f, 2.52795275e-02f, 3.79300974e-02f, 6.26496971e-02f, -1.85870230e-02f, 4.86502945e-02f, 1.77002745e-03f,
  1.20421210e-02f, 2.14594863e-02f, -9.13351998e-02f, -4.00450677e-02f, 1.26750246e-02f, 4.03644368e-02f, -6.68122992e-02f, -2.01045796e-02f, -2.66062387e-04f, 2.92855632e-02f,
  -3.51089329e-01f, -1.31525993e-01f, -1.90662622e-01f, -4.02776778e-01f, 1.70284465e-01f, 2.50786990e-01f, 7.41582140e-02f, 6.89851772e-03f, -1.69861719e-01f, 9.34903920e-02f,
  1.94514364e-01f, -3.38970244e-01f, 2.57784933e-01f, -1.23452075e-01f, -1.18309334e-01f, 2.13705599e-01f, -2.33207509e-01f, -7.69931823e-02f, 1.89915523e-02f, -1.38302594e-01f,
  -1.77100182e-01f, 3.55637446e-02f, -8.57067034e-02f, 9.11067426e-02f, -3.96050811e-02f, -2.63362914e-01f, -8.18136111e-02f, 1.78600714e-01f, -1.43836409e-01f, 1.15074746e-01f,
  9.50215012e-02f, 2.96377912e-02f, 2.98622390e-03f, -5.37626185e-02f, -7.73833841e-02f, -1.22419419e-03f, -1.96126401e-02f, 7.36530721e-02f, 1.64676663e-02f, -2.33917963e-02f,
  -2.55344585e-02f, 2.21507996e-02f, -4.69576083e-02f, 8.91125798e-02f, 2.75976975e-02f, -1.00321047e-01f, 6.15889467e-02f, -1.36783361e-01f, -3.80081981e-02f, 6.21647649e-02f,
  -5.01880608e-02f, 1.19611016e-02f, -1.25831366e-01f, -1.08563334e-01f, -7.71758556e-02f, -1.93402637e-02f, 5.07843075e-03f, -6.01341464e-02f, -7.07007274e-02f, -9.02948454e-02f,
  -2.59971004e-02f, 4.20300895e-03f, -2.90003754e-02f, 6.82195500e-02f, 6.54683858e-02f, -4.31587659e-02f, 1.45400325e-02f, 5.65487556e-02f, -5.88527247e-02f, 5.23875691e-02f,
  -4.36761007e-02f, -2.01893095e-02f, 9.47572514e-02f, -2.95388587e-02f, -3.91680710e-02f, -5.52185439e-02f, 1.53525695e-02f, 8.60845298e-02f, -9.16914269e-02f, -2.01831553e-02f,
  6.83483258e-02f, -5.38572930e-02f, 4.04917337e-02f, 1.50922611e-02f, 6.82148337e-02f, 1.75079219e-02f, -7.97939003e-02f, -8.30342695e-02f, 7.51014948e-02f, 1.27244815e-02f,
  -8.58067349e-02f, -1.22971795e-01f, -1.99112799e-02f, 5.75759672e-02f, -1.11057078e-02f, -1.27177993e-02f, 2.22902503e-02f, -1.21882288e-02f, -8.00474659e-02f, 4.69558872e-02f,
  -7.88928941e-02f, 1.44535420e-03f, -4.52544056e-02f, -1.08608529e-02f, -5.27947657e-02f, 2.57590599e-02f, -1.12376057e-01f, -1.38278455e-01f, -1.10355407e-01f, -5.02634831e-02f,
  -7.90917687e-03f, -1.41849238e-02f, -7.40879588e-03f, 4.07703817e-02f, -7.60045275e-02f, -4.64604571e-02f, -8.54633152e-02f, -1.06360065e-02f, -4.51353291e-04f, -6.74510226e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  4.81015176e-01f, 3.70787561e-01f, 4.22174275e-01f, -2.54788250e-02f, -5.71313679e-01f, -5.47093928e-01f, -6.53989375e-01f, -5.08529842e-02f, -3.99338871e-01f, -1.26892999e-01f,
  -3.42102259e-01f, 2.47726530e-01f, 1.94768056e-01f, 8.45494121e-02f, -1.47150353e-01f, 9.11952034e-02f, 1.31159395e-01f, 1.11451536e-01f, 3.40666324e-01f, 4.73292142e-01f,
  3.44406903e-01f, -2.63904542e-01f, 4.47252363e-01f, 2.28384882e-01f, 4.77711648e-01f, 4.36642379e-01f, 2.99865276e-01f, 2.16511935e-01f, 1.58055007e-01f, -3.41821849e-01f,
  -3.17859352e-02f, 2.37585567e-02f, 1.45922855e-01f, -4.09246348e-02f, 2.68953025e-01f, 1.78616554e-01f, 1.35116622e-01f, -1.70760587e-01f, -5.79507230e-03f, -5.49542643e-02f,
  1.13119356e-01f, 8.70511588e-03f, -4.96000685e-02f, -1.08999535e-01f, -1.37012154e-01f, -1.27648944e-02f, 1.39191672e-01f, 9.32556763e-02f, -2.87441127e-02f, 2.71782517e-01f,
  1.40715465e-01f, 3.26457433e-02f, 4.48693708e-02f, 3.66936736e-02f, 8.14758018e-02f, -1.63340926e-01f, -5.24282157e-02f, 1.36904538e-01f, -4.57006320e-02f, 7.63252527e-02f,
  1.46561682e-01f, -1.16848173e-02f, -6.20578304e-02f, -2.38381163e-03f, -4.35293354e-02f, 1.09593319e-02f, -8.20630714e-02f, -8.27357173e-02f, -4.83022723e-03f, 5.40184453e-02f,
  -8.00208002e-02f, 1.13750987e-01f, -1.73329771e-01f, -8.20739046e-02f, 6.44097626e-02f, 6.21491857e-02f, 1.85224824e-02f, 4.61564846e-02f, -3.14481072e-02f, -7.24001676e-02f,
  -9.79173034e-02f, -7.43544400e-02f, -4.60056700e-02f, -1.09472238e-01f, -1.98507696e-01f, -3.48889902e-02f, 2.75098030e-02f, 1.92759205e-02f, 7.46889263e-02f, 4.13939580e-02f,
  6.92110285e-02f, 2.53546834e-01f, -3.14531252e-02f, -1.45396054e-01f, 7.17337728e-02f, 1.43323243e-01f, -2.15791408e-02f, -4.91641536e-02f, 1.30375355e-01f, 1.79382190e-02f,
  1.00984387e-01f, 6.13748282e-02f, -1.46475822e-01f, 7.19110817e-02f, -1.21953115e-01f, 5.26947863e-02f, -2.92524919e-02f, -9.90979895e-02f, -6.16193041e-02f, 2.56723404e-01f,
  -9.80989891e-04f, -3.28790173e-02f, 3.01513039e-02f, -5.58362529e-02f, -8.73925611e-02f, -3.23341079e-02f, -5.94577305e-02f, 3.81648540e-02f, 4.67412956e-02f, 1.14545459e-03f,
  9.81146321e-02f, 2.88971692e-01f, -3.21918815e-01f, 3.99518430e-01f, -5.52590370e-01f, 3.64128917e-01f, 5.06559432e-01f, -1.85122073e-01f, 1.41508803e-01f, 5.29559135e-01f,
  5.31616986e-01f, -1.92157105e-01f, 2.13525012e-01f, 8.73458803e-01f, -4.88713205e-01f, 4.96184796e-01f, 5.03567874e-01f, 4.04240251e-01f, -1.31551757e-01f, 1.47995219e-01f,
  3.28469910e-02f, 4.20726895e-01f, 6.67044669e-02f, -3.23879898e-01f, 1.52209654e-01f, -2.15848267e-01f, -1.05222881e-01f, -5.36212444e-01f, 1.46722332e-01f, -3.24774325e-01f,
  1.34088054e-01f, 1.61327422e-01f, -2.57807933e-02f, -4.03878689e-02f, 1.63098946e-02f, 8.60005766e-02f, -1.92331132e-02f, -2.68323183e-01f, -1.52441442e-01f, 1.31352246e-01f,
  9.26170573e-02f, -8.31881911e-02f, 7.73767428e-03f, -1.34145960e-01f, -5.57522513e-02f, -1.51389316e-01f, -2.09800154e-03f, 1.15654320e-01f, -2.33791322e-02f, 3.52597497e-02f,
  4.80773747e-02f, 1.67701751e-01f, 8.42968673e-02f, 1.12135932e-01f, -1.03640452e-01f, -2.35940535e-02f, -1.31843403e-01f, -1.11735903e-01f, 1.26127601e-02f, -6.18095919e-02f,
  -1.03921322e-02f, 6.78807199e-02f, 1.95515946e-01f, 1.51076540e-01f, -6.72776401e-02f, 2.77744494e-02f, 3.00807990e-02f, -3.63335349e-02f, -1.09406449e-01f, -9.74379072e-04f,
  -9.76273119e-02f, -3.33369561e-02f, -1.37875518e-02f, 8.66317004e-02f, 2.06361651e-01f, 4.63886224e-02f, -6.24913871e-02f, -4.31973636e-02f, 1.28156804e-02f, 1.92615576e-02f,
  4.00615782e-02f, -6.53898865e-02f, 6.95172250e-02f, 6.82492778e-02f, -7.28252484e-03f, -1.29114971e-01f, 1.48503542e-01f, 1.05347551e-01f, 6.15076348e-03f, -9.95885953e-02f,
  9.61176455e-02f, -6.57991618e-02f, 1.29771948e-01f, -7.05285072e-02f, -8.77153799e-02f, 1.54759258e-01f, -7.52960816e-02f, 3.89092863e-02f, -8.68861377e-02f, -4.83858623e-02f,
  -2.83624809e-02f, 1.22774526e-01f, 2.71991659e-02f, -1.16356082e-01f, -4.09999602e-02f, 7.74288252e-02f, 1.48652345e-01f, -7.94532150e-03f, -1.99525952e-01f, -2.37882398e-02f,
  4.88497503e-02f, 5.95522225e-02f, -1.08775366e-02f, 4.04842459e-02f, 1.16201662e-01f, -8.69928971e-02f, -8.23077857e-02f, -1.02816522e-01f, -1.02665320e-01f, 3.36447731e-02f,
  2.76122600e-01f, -3.82690012e-01f, -6.14859402e-01f, -1.56777695e-01f, 4.31523472e-01f, 3.57998639e-01f, -1.24777280e-01f, 2.78621495e-01f, -3.91469181e-01f, 2.15648264e-01f,
  2.78666735e-01f, -2.74784952e-01f, -4.45883185e-01f, 3.03951278e-02f, -1.13119401e-01f, -5.71941912e-01f, 2.78204560e-01f, 7.85255805e-02f, -1.81741223e-01f, 1.96712628e-01f,
  -3.85817140e-02f, 5.16534448e-01f, -3.69253427e-01f, 3.53926629e-01f, 4.77673292e-01f, 1.69650227e-01f, 5.01501083e-01f, -1.17191888e-01f, 4.12894160e-01f, 2.71336824e-01f,
  3.97753045e-02f, -1.95731968e-01f, -7.04301968e-02f, -1.06057204e-01f, 3.62310223e-02f, 2.59917378e-01f, 4.29490507e-02f, -4.10743291e-03f, -1.39442712e-01f, -1.51010871e-01f,
  2.90339831e-02f, 9.07620415e-02f, 1.04227714e-01f, 3.52060907e-02f, 5.15580475e-02f, -2.13352013e-02f, -1.65231466e-01f, -5.24475016e-02f, -3.17351148e-02f, -2.08847269e-01f,
  -1.96963280e-01f, 5.97530790e-02f, 1.36412248e-01f, 1.76328234e-02f, -1.78053826e-01f, 4.40829545e-02f, -4.79671285e-02f, 2.91391481e-02f, 1.65069953e-01f, 4.53552864e-02f,
  1.28228143e-01f, 4.93197925e-02f, 6.68637156e-02f, -7.43666068e-02f, -1.60299465e-01f, 2.01774994e-03f, 1.27453104e-01f, -4.27742079e-02f, -9.23955441e-02f, -9.68228374e-03f,
  -2.99253734e-03f, 8.09535012e-03f, 7.69480243e-02f, -4.92787361e-02f, -2.66022030e-02f, 4.82203849e-02f, -1.35649843e-02f, 2.55768076e-02f, -1.16481885e-01f, -1.44739419e-01f,
  -2.08478551e-02f, 4.69654286e-03f, -1.82939845e-03f, 5.43958470e-02f, -5.21213114e-02f, -3.71573567e-02f, 2.82243062e-02f, -5.38212135e-02f, -1.27289668e-01f, 9.35367495e-02f,
  5.18433936e-02f, 8.27947706e-02f, -6.88168779e-02f, -6.28936738e-02f, -1.80192515e-01f, 1.64311498e-01f, -9.02265161e-02f, 1.57607466e-01f, -7.08313007e-03f, -1.63181145e-02f,
  1.90664887e-01f, 1.25936657e-01f, 2.02061862e-01f, -9.39351134e-03f, -3.21108997e-02f, 5.02464212e-02f, 4.05720472e-02f, 5.81729971e-02f, 2.40029395e-01f, 3.52331586e-02f,
  4.07914147e-02f, 3.27188000e-02f, 8.61601532e-02f, 1.54204108e-02f, 1.47830069e-01f, 3.95825692e-02f, 1.45476207e-01f, -4.80122380e-02f, 1.90517586e-02f, 1.29038165e-03f,
  1.49696032e-02f, -3.11856449e-01f, -2.89672911e-01f, -4.72317636e-01f, 4.19469506e-01f, 6.91457450e-01f, -2.25193232e-01f, 7.02907667e-02f, -4.84959364e-01f, -4.86193337e-02f,
  1.26000941e-01f, -5.49308360e-01f, -4.39559519e-01f, -1.42062545e-01f, -8.95667225e-02f, -2.80491292e-01f, 5.32398075e-02f, -1.10544987e-01f, -3.10040563e-02f, 3.87599431e-02f,
  -1.27881303e-01f, 4.56489980e-01f, -1.23934135e-01f, 4.68943268e-01f, 2.74176478e-01f, -1.70670897e-02f, 1.00612633e-01f, -1.95150170e-03f, 2.05390632e-01f, 9.54970717e-02f,
  4.77607436e-02f, -1.23940691e-01f, 1.09322928e-01f, 8.64618123e-02f, 1.91695988e-01f, 1.57994986e-01f, 6.46503456e-03f, -6.92076162e-02f, -5.85018769e-02f, -5.92166670e-02f,
  -2.28597537e-01f, -1.45358130e-01f, 2.20110975e-02f, -6.45489469e-02f, 2.10509703e-01f, 2.32133511e-02f, 2.92826705e-02f, 7.50733688e-02f, -2.51077056e-01f, -1.75980814e-02f,
  -1.86721832e-01f, -1.90816894e-01f, -1.73701849e-02f, -5.48925847e-02f, -1.52685773e-02f, -8.63877982e-02f, -4.71774936e-02f, -1.03632599e-01f, -3.08664292e-02f, 1.04604820e-02f,
  1.91396754e-02f, 9.28292274e-02f, 1.27311021e-01f, -1.96900275e-02f, 1.52861983e-01f, 1.00201450e-01f, -5.14772162e-03f, -3.69365923e-02f, -8.08197185e-02f, 4.36392650e-02f,
  1.59451831e-02f, -1.15572758e-01f, -1.15711734e-01f, 1.34955823e-01f, 1.64317250e-01f, 8.13180283e-02f, 2.72809993e-02f, -1.29457992e-02f, -1.48488298e-01f, 2.18146406e-02f,
  -7.19372258e-02f, -3.52724921e-03f, 1.29922172e-02f, -9.09820199e-02f, 7.81424195e-02f, 2.96193026e-02f, 9.31472927e-02f, 5.63732460e-02f, 1.12836152e-01f, 2.70648785e-02f,
  1.01328015e-01f, 2.13025976e-02f, 8.38836953e-02f, -3.81513946e-02f, 8.96448866e-02f, 2.63697892e-01f, 1.74397543e-01f, -4.59336443e-03f, 1.05959363e-01f, 1.21846169e-01f,
  8.00301656e-02f, -4.54642028e-02f, 7.83938989e-02f, 3.63635942e-02f, -8.52040574e-02f, 1.86909989e-01f, -1.07429877e-01f, -7.23469704e-02f, 6.06292821e-02f, 5.72863817e-02f,
  5.54003045e-02f, 5.74208200e-02f, -1.17184550e-01f, 1.01109385e-01f, -3.47066559e-02f, -1.77346185e-01f, 9.09412652e-02f, -2.50136048e-01f, -9.45010856e-02f, 3.20769293e-04f,
  3.72976720e-01f, -7.51674548e-02f, 1.11350231e-01f, 3.22291285e-01f, -2.42143378e-01f, 4.29004669e-01f, 7.43547618e-01f, -3.60949486e-01f, -1.16732173e-01f, 6.79138526e-02f,
  -8.68474096e-02f, 4.11467195e-01f, 2.29903936e-01f, 2.52890527e-01f, 4.39625353e-01f, 8.27356279e-02f, 3.20759386e-01f, 5.48580408e-01f, -4.73480448e-02f, 1.42822236e-01f,
  -1.89152017e-01f, 7.90531412e-02f, -1.98599711e-01f, -4.70327944e-01f, -2.61575654e-02f, -2.66427249e-01f, -2.41308853e-01f, -4.12988961e-02f, -8.00444782e-02f, 1.27345428e-01f,
  1.10771045e-01f, -1.30689934e-01f, -1.10288663e-02f, 5.24705499e-02f, -3.38840275e-03f, 9.38270390e-02f, 2.32542634e-01f, 2.42243245e-01f, -5.12001030e-02f, 3.80937457e-02f,
  9.26554650e-02f, -6.59421161e-02f, -1.06528446e-01f, 5.43923490e-02f, 2.49285437e-02f, -5.64149767e-02f, -1.91218451e-01f, -1.10059604e-01f, -4.25176769e-02f, 1.28871268e-02f,
  9.60128158e-02f, -2.52180714e-02f, 6.73673078e-02f, 1.26453266e-01f, -5.51965497e-02f, 5.44513911e-02f, 4.82720025e-02f, 7.63876736e-02f, 1.16089225e-01f, -1.44493487e-02f,
  -2.28931308e-02f, 6.55515939e-02f, 1.20174857e-02f, -3.49732563e-02f, 5.52347861e-03f, -9.35469270e-02f, -2.43867207e-02f, -6.92528859e-02f, 9.08883736e-02f, 3.64325382e-02f,
  -3.72391939e-02f, -6.90477714e-02f, -1.00498246e-02f, 7.22379610e-02f, 3.25965397e-02f, -3.42945606e-02f, 1.68468580e-01f, -3.26588228e-02f, 6.73609450e-02f, -1.22680157e-01f,
  1.19212918e-01f, -2.28467006e-02f, 7.77688771e-02f, 4.06331085e-02f, -2.77327001e-03f, -1.89384054e-02f, -1.02034345e-01f, 2.09625959e-02f, -8.06026384e-02f, 3.33184637e-02f,
  8.82176831e-02f, 6.03183955e-02f, -3.27199847e-02f, 9.17364806e-02f, 4.62679565e-02f, -8.71892422e-02f, 1.23027086e-01f, -9.73196700e-02f, 7.92253204e-03f, 1.91356223e-02f,
  -8.38561635e-03f, 9.57759395e-02f, -1.35999829e-01f, 3.96793298e-02f, 3.29190865e-03f, -9.04458091e-02f, 1.03845946e-01f, 4.58463766e-02f, 7.21786842e-02f, -1.93076059e-01f,
  -3.41109037e-02f, 1.06256723e-01f, 3.54220681e-02f, -8.85661971e-03f, 6.16664365e-02f, 5.52946217e-02f, 5.87957986e-02f, -2.45966204e-02f, -4.59027998e-02f, 5.40089421e-02f,
  1.97511435e-01f, 1.56518519e-02f, -2.59973435e-03f, 3.24768424e-01f, 1.92682683e-01f, 1.79386199e-01f, 1.60604715e-01f, 4.49088901e-01f, 8.72605205e-01f, -2.30986595e-01f,
  -2.14603320e-01f, -3.17301482e-01f, -6.12011850e-02f, -2.20514029e-01f, 1.40217364e-01f, 1.87363759e-01f, 1.07226148e-01f, -1.05744794e-01f, 5.67194879e-01f, -1.33589476e-01f,
  2.13015631e-01f, -3.35620403e-01f, -4.26101476e-01f, -2.72451341e-01f, -3.44298154e-01f, -1.23198241e-01f, -5.04086137e-01f, 5.02653001e-03f, -5.11865258e-01f, -3.96672711e-02f,
  -1.14754692e-01f, 1.75006479e-01f, -1.48731023e-01f, 5.03449105e-02f, 3.27467062e-02f, -4.08440642e-02f, -1.52681187e-01f, -9.46628824e-02f, 6.54099360e-02f, -2.24764012e-02f,
  -8.80758464e-02f, -6.30891025e-02f, -2.83800159e-02f, -6.02827258e-02f, 1.70725197e-01f, -7.35394806e-02f, -7.08692595e-02f, -1.83706414e-02f, -9.60949585e-02f, -8.50197226e-02f,
  -1.88573927e-01f, -3.34729329e-02f, 2.74398476e-02f, 6.34746253e-02f, -8.49115625e-02f, 6.73838779e-02f, 3.81888859e-02f, -1.75032377e-01f, -1.16958246e-01f, 1.16550431e-01f,
  5.29433377e-02f, 2.00947568e-01f, -1.37960881e-01f, 6.68194070e-02f, -1.54298730e-02f, -4.26479528e-04f, -8.88566226e-02f, -5.89316711e-02f, 1.52401164e-01f, -1.03384525e-01f,
  5.24129309e-02f, -5.55121200e-03f, 1.25445977e-01f, 1.76050141e-02f, 4.87384200e-02f, 1.31030649e-01f, -1.24379694e-01f, -4.80880700e-02f, 8.19735900e-02f, 2.77427491e-02f,
  -5.53753451e-02f, -4.83431708e-04f, -1.21583454e-01f, -7.80808926e-02f, -4.34453376e-02f, -3.99293937e-02f, -3.92464399e-02f, -5.76038510e-02f, 5.92612661e-02f, -1.05089046e-01f,
  2.06087306e-01f, 3.47995937e-01f, 7.41738302e-04f, -9.10817161e-02f, 4.78066131e-02f, -1.19497754e-01f, 5.78180142e-02f, 4.11404893e-02f, 1.85389504e-01f, 1.16760835e-01f,
  9.98804718e-03f, 7.30397785e-03f, -3.09267361e-02f, -5.24591208e-02f, -3.14598717e-02f, 2.25916542e-02f, 3.66999512e-03f, 1.74126834e-01f, 1.11762881e-02f, -6.19935542e-02f,
  -1.71868995e-01f, 2.14759678e-01f, 8.55181888e-02f, -3.92795019e-02f, -6.56369179e-02f, -6.70534149e-02f, 2.07131486e-02f, 1.36732329e-02f, -7.18949214e-02f, 1.02460623e-01f,
  4.43646550e-01f, 2.46744826e-02f, -2.87535489e-01f, -1.84159547e-01f, -2.62533873e-01f, -3.78609985e-01f, -1.82913691e-01f, -1.69921950e-01f, 1.04882596e-02f, 1.29687801e-01f,
  -3.77263069e-01f, 6.49987161e-01f, 4.09576803e-01f, -4.64805990e-01f, 8.79759565e-02f, 2.43897066e-01f, -3.44830811e-01f, 1.58248365e-01f, -2.26991117e-01f, 1.79912075e-01f,
  -1.38832390e-01f, -1.79921374e-01f, -2.16262668e-01f, -9.53205377e-02f, -3.46439064e-01f, -2.60732442e-01f, -4.25903708e-01f, -1.29156217e-01f, -5.45428813e-01f, -2.94897020e-01f,
  -1.63743973e-01f, 2.56282147e-02f, 1.58078149e-02f, 1.05475135e-01f, -1.59866810e-01f, 3.67818470e-03f, 7.72025734e-02f, -2.15255897e-02f, -2.74919048e-02f, 2.79376446e-03f,
  3.35149288e-01f, 1.16996236e-01f, -1.36872992e-01f, 1.20075114e-01f, 8.59283283e-02f, -8.60019177e-02f, -1.01481758e-01f, -1.23961575e-01f, 7.06691146e-02f, 9.51843709e-02f,
  -8.08072835e-02f, 3.11031323e-02f, -2.72229046e-01f, 1.07535914e-01f, -6.86719939e-02f, -1.35510802e-01f, 1.81568772e-01f, -2.87474357e-02f, 1.40910029e-01f, -1.37039304e-01f,
  1.21848755e-01f, 6.90580383e-02f, 2.51713786e-02f, -9.76284444e-02f, 7.24072754e-02f, -1.43133357e-01f, 1.67997345e-01f, -5.19918576e-02f, -1.58370715e-02f, 7.36083314e-02f,
  -5.90691902e-03f, 7.31720254e-02f, 2.00382397e-02f, 6.74303174e-02f, 5.83940968e-02f, 2.62117654e-01f, 7.18372613e-02f, 3.04807909e-02f, -8.81635994e-02f, -2.03726545e-01f,
  2.92433593e-02f, -1.23181105e-01f, 1.12500871e-02f, -1.67091340e-02f, -1.99034467e-01f, 9.18071195e-02f, -1.34185553e-01f, 4.57635112e-02f, -1.34368762e-01f, -4.09718007e-02f,
  -5.64403795e-02f, -2.76433490e-02f, -9.20258760e-02f, 1.20540276e-01f, 7.29923099e-02f, 8.70926976e-02f, -1.35589629e-01f, -1.67856127e-01f, -5.61068803e-02f, 1.57247066e-01f,
  -3.58750448e-02f, 6.54441044e-02f, -1.75742865e-01f, 5.56059508e-03f, 6.13294542e-02f, -1.49878398e-01f, 2.04660624e-01f, 3.98719050e-02f, 9.81398970e-02f, 1.00707971e-01f,
  1.02425565e-03f, 1.08793847e-01f, 1.59128487e-01f, 1.22778356e-01f, 1.06679313e-01f, -4.15201187e-02f, 3.12941335e-02f, -5.51072843e-02f, 2.00215563e-01f, -8.47621486e-02f,
  -3.00423592e-01f, 7.71577775e-01f, 5.08719862e-01f, -3.44551206e-01f, 6.41014725e-02f, 7.65801147e-02f, -2.71229237e-01f, 1.11811928e-01f, -2.59589523e-01f, 1.17967486e-01f,
  -2.27259263e-01f, 5.48214257e-01f, 3.76557745e-02f, -3.01157117e-01f, -5.78873932e-01f, -5.15025795e-01f, -4.68454748e-01f, -2.73914278e-01f, -3.43768746e-02f, -2.37938628e-01f,
  -2.23577708e-01f, -5.77098548e-01f, -2.21404880e-01f, 4.47920198e-03f, 2.80399173e-01f, 2.80666769e-01f, -4.00270313e-01f, 3.00471842e-01f, 1.05388246e-01f, 6.21051937e-02f,
  -8.45205337e-02f, -2.80885398e-01f, 1.61714740e-02f, 9.74670649e-02f, -1.60079762e-01f, -5.43843545e-02f, 1.41297048e-02f, 4.73208949e-02f, -2.35868946e-01f, -5.14824614e-02f,
  1.33193821e-01f, 1.29085883e-01f, 4.15695421e-02f, -2.09232001e-03f, 1.09382011e-01f, 2.09565133e-01f, 1.71023369e-01f, 2.06210032e-01f, 9.72586423e-02f, 2.41755888e-01f,
  1.34045750e-01f, 2.76030898e-01f, 3.25031281e-02f, -4.79151215e-03f, 6.72050565e-02f, 1.68182611e-01f, -1.10027961e-01f, 2.64716506e-01f, 1.35532647e-01f, -4.97770682e-02f,
  -1.32913828e-01f, -1.99628592e-01f, 1.60755411e-01f, 3.59487198e-02f, -2.68233493e-02f, 7.73720518e-02f, -9.60817188e-02f, 7.71664688e-03f, 1.50792301e-01f, 6.50388887e-03f,
  -6.45342022e-02f, 9.13015455e-02f, -1.53841496e-01f, -1.15902640e-01f, -8.84991884e-02f, -1.26559570e-01f, -2.55011464e-03f, 6.34098053e-03f, -1.29612818e-01f, 6.17393255e-02f,
  -7.23638535e-02f, -1.45711288e-01f, -2.98629031e-02f, 4.83824536e-02f, -4.56521809e-02f, -8.61697122e-02f, 9.68062431e-02f, 1.53220043e-01f, -6.04837276e-02f, -1.65947437e-01f,
  -3.79402041e-01f, -4.85505730e-01f, -9.02560651e-02f, 2.64355112e-02f, -4.46821079e-02f, -1.97788496e-02f, -3.23148631e-02f, 1.55929089e-01f, -5.88290915e-02f, -6.76311925e-02f,
  -1.70175843e-02f, -5.96951358e-02f, 3.11342981e-02f, -1.05458289e-01f, -2.13869456e-02f, -8.54543224e-02f, -1.32165968e-01f, -5.11670262e-02f, -4.95406911e-02f, 1.16037190e-01f,
  1.41367316e-01f, -2.41843630e-02f, 3.83948758e-02f, -1.12453856e-01f, -4.84792478e-02f, 1.40238732e-01f, -2.47199349e-02f, 2.43525252e-01f, -6.09842762e-02f, -4.27973382e-02f,
  8.30121934e-01f, -6.45904362e-01f, -1.89349413e-01f, 5.24532855e-01f, 3.25218767e-01f, 3.65668386e-01f, 6.13554358e-01f, 1.07129058e-02f, 4.36908334e-01f, -5.39758742e-01f,
  -1.12508073e-01f, -1.17442310e-01f, -5.09219706e-01f, 2.92641580e-01f, 5.70910096e-01f, -2.54548579e-01f, 5.08620322e-01f, 2.32254431e-01f, 1.37085572e-01f, -1.05486572e-01f,
  1.79983854e-01f, 1.85778826e-01f, -1.74030378e-01f, -2.25963861e-01f, 1.98490515e-01f, -1.50623739e-01f, -6.50167987e-02f, -1.73384741e-01f, 6.10097200e-02f, 2.69973516e-01f,
  1.06508449e-01f, 9.00704712e-02f, 2.10091323e-02f, -2.25009676e-02f, -1.05950847e-01f, 1.16080888e-01f, -8.58638063e-03f, 9.67300385e-02f, 2.50200391e-01f, -1.21747954e-02f,
  -1.31344751e-01f, 1.26447126e-01f, 1.19324416e-01f, 6.53519854e-02f, 2.17711017e-01f, 1.18158430e-01f, 4.32338603e-02f, -1.43230066e-01f, -7.60167763e-02f, -1.85689330e-01f,
  -1.28983572e-01f, -1.07279822e-01f, -4.70849499e-02f, -1.05349548e-01f, -1.38863027e-01f, 9.79627147e-02f, -5.19928262e-02f, -1.22815005e-01f, -8.79681706e-02f, 6.55047745e-02f,
  1.55959986e-02f, -1.57036800e-02f, -7.43026510e-02f, 4.90483269e-03f, -4.65843417e-02f, 5.13009988e-02f, -5.96909374e-02f, -9.39417928e-02f, 7.95684662e-03f, -1.33609697e-01f,
  6.66855499e-02f, 1.56938970e-01f, 4.01765928e-02f, 1.57365039e-01f, 1.39175588e-02f, 5.85310198e-02f, 8.37672129e-02f, 7.95365032e-03f, -3.13892625e-02f, 6.43534437e-02f,
  8.66121650e-02f, 1.24963328e-01f, -1.20566897e-01f, 4.85994928e-02f, 1.19421087e-01f, -1.16905503e-01f, -9.50464234e-02f, -8.54953155e-02f, -1.21471183e-02f, 3.19988579e-02f,
  -1.40648529e-01f, -5.35807848e-01f, -1.71831734e-02f, -7.61457859e-03f, -1.29901702e-02f, -5.93704656e-02f, -1.39661077e-02f, 8.18651170e-02f, 7.23678768e-02f, 1.09370001e-01f,
  -2.48239450e-02f, 8.42321068e-02f, -6.38107210e-02f, 2.45745247e-03f, 1.93382483e-02f, -1.07175864e-01f, -1.85332838e-02f, -5.17188534e-02f, 8.03340413e-03f, -1.24257587e-01f,
  -2.19156705e-02f, 7.60928087e-04f, 5.16320691e-02f, 5.72661832e-02f, 1.17224166e-02f, -9.81618278e-03f, 1.54344356e-02f, -3.69817838e-02f, -1.56420186e-01f, -1.83502939e-02f,
  4.52826798e-01f, -5.45360565e-01f, -9.56765413e-02f, -2.13297158e-01f, 2.39263847e-01f, -2.88276196e-01f, 1.62914470e-01f, -4.36805904e-01f, -2.14116648e-01f, -4.70235765e-01f,
  -9.26909819e-02f, 8.97293761e-02f, 4.25923169e-01f, -4.55524266e-01f, 3.74637455e-01f, 1.65597975e-01f, -4.82523382e-01f, -2.80960232e-01f, 8.62822831e-02f, -1.69646919e-01f,
  -8.61517526e-03f, -2.30449960e-01f, -1.29661299e-02f, -5.30156016e-01f, -7.49295503e-02f, -1.92610830e-01f, 1.01460069e-01f, 3.00084442e-01f, -4.71568316e-01f, 1.12752199e-01f,
  -9.96266007e-02f, -1.21130653e-01f, 6.71515465e-02f, -1.02029197e-01f, -3.30620408e-02f, 1.92186967e-01f, 2.37875834e-01f, 2.67033875e-01f, 1.46602122e-02f, -1.05976708e-01f,
  8.98691416e-02f, -4.89175394e-02f, -2.15134442e-01f, 2.19169259e-01f, -5.00804894e-02f, -1.36051759e-01f, -7.35237971e-02f, 2.39495002e-02f, -9.70238149e-02f, 6.67533502e-02f,
  -2.50217337e-02f, -1.83070451e-02f, 9.13776308e-02f, -6.92062825e-02f, -2.21200171e-03f, 9.60918516e-03f, 2.70455368e-02f, 1.10517308e-01f, -1.04502551e-01f, -1.20371997e-01f,
  -7.14487806e-02f, 1.06307723e-01f, 4.74440418e-02f, -1.42238173e-03f, -2.56091934e-02f, 1.08807661e-01f, -5.04024588e-02f, -3.39904847e-03f, 2.48233974e-02f, -2.90331300e-02f,
  1.27906045e-02f, 6.80926889e-02f, -2.51365397e-02f, -7.19948784e-02f, -2.69386657e-02f, 7.28617683e-02f, 2.31208559e-02f, -1.81030594e-02f, 2.06313170e-02f, -8.40415433e-03f,
  1.06650628e-01f, -7.91235045e-02f, 8.80336165e-02f, 1.01977415e-01f, -3.50558609e-02f, 1.14415891e-01f, -1.13542892e-01f, -8.68328139e-02f, -9.11125690e-02f, 8.34645405e-02f,
  -1.81167766e-01f, -4.31482553e-01f, 4.20503207e-02f, -8.66590515e-02f, 5.59466600e-04f, 3.27723213e-02f, -7.17771566e-03f, -2.62918949e-01f, -1.04395941e-01f, -4.97247986e-02f,
  -2.06248373e-01f, 2.31602304e-02f, -9.85496305e-03f, -4.52032685e-02f, -8.90560523e-02f, -1.77460238e-01f, 6.71245679e-02f, -2.06090044e-02f, 4.14613038e-02f, -1.89064682e-01f,
  6.23206049e-03f, -6.79161027e-02f, -4.59621064e-02f, -3.40936403e-03f, -6.10183775e-02f, 1.36526704e-01f, 3.71192023e-02f, -2.30487082e-02f, 1.49256811e-01f, -8.08282346e-02f,
  2.46242061e-03f, -6.23508729e-02f, -3.06792945e-01f, -1.60373792e-01f, -7.85083249e-02f, -5.06668031e-01f, -4.13784802e-01f, 4.92890307e-04f, -3.84922437e-02f, 9.17034075e-02f,
  1.50067687e-01f, -1.40599519e-01f, 3.25453073e-01f, -2.96197236e-01f, -3.34518552e-01f, 9.63866711e-03f, -5.72733879e-01f, -3.80102515e-01f, 2.44432911e-02f, -4.72727902e-02f,
  4.88260053e-02f, 9.98266563e-02f, -1.56441838e-01f, 2.53517509e-01f, -1.99428350e-01f, 1.98004872e-01f, 2.94723481e-01f, 3.01310420e-01f, -1.75126880e-01f, -9.34579642e-04f,
  -1.47745594e-01f, 2.09752783e-01f, -7.19029307e-02f, -3.43320258e-02f, -3.57413068e-02f, 4.28138636e-02f, -1.36022642e-01f, -2.61705936e-05f, -4.28122841e-02f, -7.77687132e-02f,
  2.36030426e-02f, 1.34033546e-01f, -9.14639086e-02f, 9.98988375e-02f, 8.86851847e-02f, -1.14347473e-01f, -7.55110309e-02f, -1.20146342e-01f, -1.17849663e-01f, -2.94661541e-02f,
  -3.32665145e-02f, -1.02856562e-01f, -9.14232619e-03f, 7.11174831e-02f, 1.13621831e-03f, 1.07521430e-01f, -1.88816041e-01f, -6.06095493e-02f, 2.64036134e-02f, 6.75794482e-02f,
  8.03513601e-02f, 2.37037856e-02f, -6.30743876e-02f, -1.90092903e-02f, -1.66504998e-02f, -7.48737305e-02f, 9.51430574e-02f, -7.98553973e-02f, -1.41118588e-02f, -7.53527656e-02f,
  -8.28271285e-02f, 8.37952644e-02f, 7.12570027e-02f, 5.31156212e-02f, -4.99441996e-02f, 4.52937856e-02f, -4.00860189e-03f, 4.88029886e-03f, -1.13230683e-01f, -6.44451603e-02f,
  1.84746608e-01f, 8.79700780e-02f, -8.33600536e-02f, 3.69750597e-02f, -2.78511783e-03f, -3.13571887e-04f, 3.76746766e-02f, -7.47684836e-02f, -3.41232046e-02f, -2.62313150e-02f,
  -3.81727144e-02f, 2.29805186e-01f, -4.52366993e-02f, -2.54395381e-02f, -6.86384365e-02f, -8.49522799e-02f, -2.81112175e-02f, -1.15043230e-01f, 6.32616058e-02f, 1.22966200e-01f,
  -9.19020474e-02f, 3.99417542e-02f, -2.41523869e-02f, 6.83551431e-02f, -2.42063217e-02f, -7.33400732e-02f, 1.88956186e-01f, -4.36750315e-02f, -5.90626411e-02f, 1.33729637e-01f,
  1.13031477e-01f, 4.61259335e-02f, 1.52010936e-03f, -8.76040608e-02f, 4.71892208e-03f, -8.82658735e-03f, -3.31991576e-02f, 4.41601016e-02f, 1.07027479e-01f, -1.20153995e-02f,
  -1.07582164e+00f, 5.34127355e-01f, 5.04382662e-02f, -3.43612880e-01f, 2.28638142e-01f, -6.56910688e-02f, 2.30605081e-01f, 1.79520860e-01f, 9.10294652e-02f, 3.93885434e-01f,
  3.43338609e-01f, -2.06744283e-01f, 5.57914972e-01f, 3.08034986e-01f, -4.25939560e-01f, 3.30128133e-01f, -2.09853619e-01f, -7.69137219e-02f, 5.30281998e-02f, -1.72447726e-01f,
  -1.81664050e-01f, 1.66302964e-01f, 1.35524422e-01f, 2.50479758e-01f, 2.48135075e-01f, -1.86790764e-01f, -7.58002922e-02f, 2.03472391e-01f, -1.08127318e-01f, 1.26293525e-01f,
  -4.01515156e-01f, -2.43470818e-01f, 7.44267181e-02f, -1.54470084e-02f, -1.80967644e-01f, -3.45514119e-02f, -1.91873729e-01f, 9.19672996e-02f, -1.36091951e-02f, -8.83404836e-02f,
  -4.61915843e-02f, 5.86157143e-02f, -1.03130616e-01f, 7.07054883e-02f, -3.46194878e-02f, 8.09010044e-02f, 1.54728636e-01f, 6.32963032e-02f, 2.19778940e-01f, -4.63746749e-02f,
  2.59618074e-01f, -6.81164265e-02f, -7.55487159e-02f, -7.76084736e-02f, 3.61022130e-02f, 8.54058042e-02f, 2.00074371e-02f, -7.91266412e-02f, -4.72894982e-02f, -1.27400085e-01f,
  -1.72997147e-01f, -1.15115821e-01f, 2.14299634e-01f, -5.75843677e-02f, 2.28314698e-02f, 8.64911824e-02f, 7.62315318e-02f, 1.35167520e-02f, -4.89682034e-02f, -9.72516909e-02f,
  -5.35033122e-02f, -6.26797229e-02f, -2.50233375e-02f, -1.05814219e-01f, -6.53630495e-02f, 2.90929340e-02f, -4.38924581e-02f, -2.18979511e-02f, -1.42199127e-02f, -1.04418874e-01f,
  -6.91559399e-03f, -3.27721648e-02f, 1.89417098e-02f, -3.73219699e-02f, 9.71846562e-03f, -3.41660380e-02f, -4.06015590e-02f, 9.93183330e-02f, -3.25863138e-02f, -6.39800653e-02f,
  -6.81457102e-01f, -6.97115004e-01f, 1.28105795e-02f, -1.94031035e-03f, -5.70991039e-02f, -6.45078272e-02f, -9.38090682e-02f, -5.12696058e-03f, -1.73021629e-01f, 6.54122501e-04f,
  -3.47579867e-02f, 8.80366415e-02f, -1.58612728e-01f, -4.43181098e-02f, -2.10835040e-02f, 4.98073583e-04f, -6.34397045e-02f, -9.33971554e-02f, -1.39923155e-01f, -1.43139929e-01f,
  -1.61862094e-02f, 2.60213646e-03f, 8.48368369e-03f, 7.70587325e-02f, -1.17401309e-01f, -3.52899805e-02f, -1.61425933e-01f, -1.56892780e-02f, -1.88061014e-01f, 3.77105214e-02f,
  -2.78087765e-01f, -2.52162404e-02f, 3.45100880e-01f, 7.32302368e-01f, -3.99518460e-02f, -6.58540368e-01f, -5.31204700e-01f, -1.68773066e-02f, 1.91922620e-01f, -6.38375163e-01f,
  -3.10201943e-01f, -1.74887195e-01f, -7.51455128e-01f, 4.36796695e-01f, 3.61642838e-01f, -2.04071224e-01f, 2.80162811e-01f, 4.06925268e-02f, 3.65397841e-01f, 1.03053257e-01f,
  4.40789819e-01f, 3.19222152e-01f, 3.34518075e-01f, 3.44365537e-01f, 5.18856123e-02f, 4.76927549e-01f, 4.40688044e-01f, 3.02822500e-01f, 5.15319049e-01f, 9.51673314e-02f,
  -5.32304756e-02f, 7.88151100e-02f, 7.96255842e-02f, 1.51884824e-01f, -2.58113556e-02f, -1.92619801e-01f, 1.20745271e-01f, -2.53276136e-02f, 2.03588337e-01f, -7.46970065e-03f,
  -1.87413320e-01f, 1.72573105e-01f, 1.54020175e-01f, 1.24070048e-01f, 1.44883916e-01f, 2.02270597e-01f, 9.43726767e-03f, -8.26194286e-02f, 4.59992252e-02f, -1.56799257e-01f,
  -1.01566678e-02f, -3.81979495e-02f, -8.50026682e-02f, 1.16719447e-01f, 2.51254231e-01f, 1.39333442e-01f, 1.34984970e-01f, -3.71366777e-02f, 9.51833501e-02f, 2.19050691e-01f,
  -1.76145151e-01f, 1.14992417e-01f, -4.52354997e-02f, 8.60727280e-02f, -6.25477033e-03f, 4.36932184e-02f, 9.22404900e-02f, -5.61667196e-02f, 5.17794713e-02f, -8.41788054e-02f,
  1.99489310e-01f, 9.89066064e-02f, 1.46067617e-02f, -1.90326739e-02f, 2.38447525e-02f, -4.07940336e-02f, -3.01924814e-02f, 3.46836331e-03f, -1.66623751e-04f, 3.60691510e-02f,
  1.11985222e-01f, -3.92057113e-02f, 3.58441821e-03f, -2.00478341e-02f, 5.22104651e-02f, -6.35417923e-02f, -1.93306189e-02f, -1.14931196e-01f, -6.87535405e-02f, -3.98807339e-02f,
  -1.60535380e-01f, 3.08494747e-01f, 1.39849767e-01f, 4.59495112e-02f, 1.83610380e-01f, -8.51331279e-02f, 1.23900443e-01f, 2.22710669e-02f, 1.85660481e-01f, -2.81311106e-02f,
  -9.09716412e-02f, 4.71541397e-02f, -1.65009305e-01f, -6.33277968e-02f, 5.76417781e-02f, -5.19748032e-02f, 3.99649329e-02f, 1.90172330e-01f, 1.53999120e-01f, 1.54940441e-01f,
  2.58743390e-02f, -2.65937388e-01f, 5.89535050e-02f, 1.55601189e-01f, -2.37779543e-02f, -8.87934715e-02f, -9.15256515e-02f, 3.77592929e-02f, 7.63199106e-02f, 1.41452923e-01f,
  2.68540472e-01f, -5.97399250e-02f, -4.35539395e-01f, -5.13710737e-01f, -2.75463313e-01f, -2.51843393e-01f, -5.02868772e-01f, -1.71276629e-01f, -2.95487553e-01f, 8.04006979e-02f,
  -2.32990056e-01f, -2.55373064e-02f, 6.95610195e-02f, -3.97304982e-01f, 5.51659405e-01f, 1.77941434e-02f, -1.97746113e-01f, -2.43546337e-01f, 2.43638735e-02f, 1.01089351e-01f,
  1.65700451e-01f, 7.91559219e-02f, -1.58631116e-01f, 1.52222708e-01f, -4.01550174e-01f, -6.43789768e-02f, 3.13508421e-01f, -4.50019270e-01f, -2.00847432e-01f, -1.63456887e-01f,
  -1.77109346e-01f, -2.57699694e-02f, -2.62030482e-01f, 3.04735843e-02f, 1.90083869e-02f, 4.63905968e-02f, -9.47090536e-02f, -3.53424400e-02f, -1.51500970e-01f, -8.99876095e-03f,
  1.53014049e-01f, 1.07815631e-01f, 8.27935152e-03f, 5.14703104e-03f, -2.69889031e-02f, -4.80529815e-02f, 1.14104979e-01f, -2.02026129e-01f, -2.64052209e-02f, 5.28781861e-02f,
  -4.74805273e-02f, -6.19503558e-02f, -1.30413905e-01f, -2.11427244e-03f, -3.76489758e-02f, 4.00932804e-02f, 9.53329653e-02f, -5.00925183e-02f, 1.25719849e-02f, 1.62092268e-01f,
  1.13088541e-01f, 3.66176926e-02f, 1.16004683e-01f, -1.10829741e-01f, 1.12150423e-02f, -2.58186944e-02f, 7.85038900e-03f, -3.13506089e-02f, 2.78148544e-03f, -1.42137647e-01f,
  -1.19985513e-01f, -1.88300908e-01f, -6.37681410e-02f, 1.30136326e-01f, 2.33049169e-01f, -5.91770113e-02f, 9.08305645e-02f, 1.10623226e-01f, -4.60303854e-04f, 4.19037268e-02f,
  -2.23957226e-01f, 2.10539192e-01f, 9.21298843e-03f, 4.75406162e-02f, -1.04413591e-01f, -4.48823627e-03f, 1.26136050e-01f, 2.51533464e-02f, -5.79390721e-03f, -4.44817692e-02f,
  4.55997698e-02f, 2.16009617e-01f, -7.11544231e-02f, -8.83917883e-02f, 7.22608119e-02f, 1.86824761e-02f, -1.82354286e-01f, 1.25057369e-01f, 1.66831389e-01f, 2.25362852e-02f,
  1.77234024e-01f, 4.41474468e-02f, 1.26815483e-01f, -5.62477252e-03f, 1.64627835e-01f, 1.78787172e-01f, 1.25052720e-01f, 1.02374114e-01f, 1.33553699e-01f, 1.60102263e-01f,
  2.11731881e-01f, 1.53072685e-01f, -2.07299814e-02f, 2.91323895e-03f, 8.08493719e-02f, -3.37426476e-02f, 1.30904794e-01f, 7.26044085e-03f, 9.98145491e-02f, -1.32552302e-02f,
  -4.61062610e-01f, 3.46091799e-02f, -2.90360659e-01f, -4.39284772e-01f, -1.50285318e-01f, -2.65604824e-01f, -2.85238057e-01f, 4.39753495e-02f, 6.59429580e-02f, 2.56995410e-01f,
  -6.97912741e-03f, -2.44119465e-01f, 3.22907150e-01f, -3.67547601e-01f, -3.45366299e-01f, 1.97188541e-01f, -4.24074590e-01f, -1.54997781e-01f, -5.69927357e-02f, -3.24106216e-01f,
  -1.45393401e-01f, -1.34178102e-01f, -3.45136285e-01f, 1.53872579e-01f, -3.89366657e-01f, -7.11231232e-02f, 2.41773203e-01f, -2.15131305e-02f, -3.46529245e-01f, -4.63702343e-02f,
  -1.13449484e-01f, -7.32087195e-02f, -7.28365704e-02f, 5.33487834e-02f, -3.23722512e-02f, -7.20112473e-02f, -1.76050775e-02f, -8.14435333e-02f, -3.82623225e-02f, -4.76603359e-02f,
  -3.48832831e-02f, 1.68313816e-01f, 1.75048057e-02f, 2.30390914e-02f, -1.72381803e-01f, -1.10395901e-01f, -2.97446977e-02f, -1.13733627e-01f, 4.82073575e-02f, -1.20836720e-01f,
  -1.53315693e-01f, 3.58380540e-03f, 4.36872523e-03f, 1.89176083e-01f, 5.65857552e-02f, -4.71597537e-02f, -4.65097129e-02f, 3.48356739e-02f, 5.02887219e-02f, 2.01277882e-02f,
  -7.96986520e-02f, 9.77602750e-02f, 1.71708819e-02f, -4.15802747e-03f, -6.77755699e-02f, 9.93341431e-02f, 8.68954957e-02f, 4.29278985e-03f, 6.79330006e-02f, 2.22251881e-02f,
  2.87461989e-02f, 6.02075532e-02f, 8.75030980e-02f, -5.52314930e-02f, -5.81525415e-02f, -1.14136420e-01f, -9.23326984e-03f, 1.39701709e-01f, -2.45825090e-02f, -1.14357680e-01f,
  -1.63045414e-02f, -1.15800843e-01f, -1.82325449e-02f, 3.68986502e-02f, -5.22336625e-02f, 1.03232488e-01f, -4.39516455e-02f, -1.40761537e-02f, -6.32365271e-02f, 1.09737709e-01f,
  6.44077659e-02f, 2.15980932e-01f, 6.72041476e-02f, 5.22714108e-02f, 8.45296979e-02f, -2.95763593e-02f, -5.16098700e-02f, -7.29363486e-02f, -5.21680638e-02f, 5.76077402e-02f,
  4.42051183e-04f, 8.69031549e-02f, 8.10775310e-02f, 5.92673048e-02f, 4.49264087e-02f, -2.58150622e-02f, -3.35659832e-02f, 1.44281134e-01f, 7.03968778e-02f, -7.81411901e-02f,
  1.98727399e-01f, 1.11202858e-01f, 2.03460470e-01f, 1.61068290e-01f, -1.36860460e-02f, -1.10059984e-01f, 4.27771080e-03f, -5.64868264e-02f, -3.01430784e-02f, 5.39193377e-02f,
  -2.21592605e-01f, 5.63273132e-02f, -4.44596440e-01f, -2.10202262e-01f, 2.49343842e-01f, -6.06385291e-01f, -2.68951863e-01f, -9.60205272e-02f, 5.07870037e-03f, -5.43076172e-02f,
  -5.77756017e-02f, 3.10320079e-01f, 3.41701150e-01f, -3.34099442e-01f, -3.63658577e-01f, 1.07175969e-01f, -4.99737799e-01f, -2.50186384e-01f, 1.30444795e-01f, -2.79198259e-01f,
  -1.77942008e-01f, -1.31162688e-01f, -2.64559507e-01f, 9.69462395e-02f, -3.01480860e-01f, -5.97091019e-02f, 3.89562510e-02f, 3.36442649e-01f, -2.11447150e-01f, 2.49029234e-01f,
  -2.71847129e-01f, 8.56265798e-03f, -7.75430948e-02f, -5.80692142e-02f, -1.65194586e-01f, 6.38468340e-02f, -3.53745744e-02f, 1.73160926e-01f, 1.06428117e-02f, -4.61036786e-02f,
  2.27383431e-02f, 1.27259240e-01f, 9.72509459e-02f, 5.23615144e-02f, 4.72219773e-02f, 6.59102798e-02f, -7.02199414e-02f, -5.02511002e-02f, 4.74069156e-02f, -6.04485981e-02f,
  -1.99793954e-03f, 6.79996889e-03f, -2.30035707e-01f, -7.01930299e-02f, -3.36135225e-03f, 5.16189588e-03f, -2.47005597e-01f, -4.03166711e-02f, -3.52536701e-02f, -2.12915894e-02f,
  7.53080398e-02f, -1.37246832e-01f, -1.05811663e-01f, 1.11461252e-01f, -1.65084470e-02f, -4.71521094e-02f, 5.21049462e-02f, 5.95924407e-02f, 1.53022647e-01f, -8.20278097e-03f,
  -1.26347527e-01f, 1.03203636e-02f, 5.86448535e-02f, -2.57474899e-01f, -3.24865691e-02f, -1.17779270e-01f, -7.40672201e-02f, -4.06312570e-03f, -1.88639373e-01f, -1.39402971e-02f,
  1.52580306e-01f, -4.55092378e-02f, 3.63574773e-02f, -1.09553866e-01f, -1.22689001e-01f, 1.17204748e-01f, -6.54225200e-02f, -1.75330713e-01f, -8.21786448e-02f, -1.10556493e-02f,
  -4.82347757e-01f, -2.59749830e-01f, 8.72251764e-02f, 4.48227711e-02f, -4.97086085e-02f, -2.17969660e-02f, -2.25469712e-02f, -1.46892732e-02f, 1.58652570e-02f, -8.37648064e-02f,
  -1.07383445e-01f, -1.43734008e-01f, -2.41531320e-02f, 1.37417438e-03f, -1.02861881e-01f, -1.72414202e-02f, 1.00408107e-01f, 1.73282638e-01f, -1.82396948e-01f, -2.99999118e-02f,
  7.77551457e-02f, 8.14719796e-02f, -6.61058202e-02f, -4.63161804e-02f, -6.03732504e-02f, 4.03137393e-02f, -1.78917833e-02f, 4.34751138e-02f, -2.75380518e-02f, -9.64226723e-02f,
  -8.64820898e-01f, 5.00614941e-02f, 6.17154062e-01f, -4.31100547e-01f, -1.20391883e-01f, 5.82774818e-01f, 3.86346668e-01f, 2.80921925e-02f, -5.14971256e-01f, -6.24281019e-02f,
  5.09463139e-02f, -2.60480762e-01f, 5.30451536e-01f, -8.91190022e-02f, 5.94870210e-01f, 4.59414214e-01f, -4.51717041e-02f, 5.79046570e-02f, -1.40048981e-01f, -3.16223055e-01f,
  -1.29270241e-01f, -2.39052162e-01f, 4.64313775e-01f, -2.12438613e-01f, -1.96812958e-01f, -3.89561355e-01f, -1.12842090e-01f, 2.07635656e-01f, -2.26819073e-03f, 8.32767412e-02f,
  -4.46752727e-01f, -3.46611112e-01f, -1.75931424e-01f, 8.43111500e-02f, 5.00783958e-02f, -8.04659277e-02f, 9.04622525e-02f, 3.75398584e-02f, -1.32886156e-01f, 3.11665237e-02f,
  -3.85781117e-02f, -1.66319609e-02f, -2.77114809e-01f, -3.88673693e-02f, -7.89790228e-02f, -1.48789678e-02f, 8.43295157e-02f, 1.66681096e-01f, 8.19386914e-02f, 1.80639103e-01f,
  1.83181837e-01f, 1.06513999e-01f, 1.72911733e-01f, 1.52569264e-02f, 1.15544401e-01f, 6.61630696e-03f, 8.10649619e-02f, 1.31915346e-01f, -5.29597700e-02f, -6.50685057e-02f,
  9.58511829e-02f, 4.09681071e-03f, -7.26294443e-02f, -5.63293621e-02f, -9.64347795e-02f, -8.70525092e-02f, -1.15198866e-02f, -8.26007277e-02f, 1.64162107e-02f, 3.81267704e-02f,
  -7.55754411e-02f, 4.60189907e-03f, -9.30943340e-02f, 6.16536923e-02f, -7.89388418e-02f, -6.79803118e-02f, 5.41296937e-02f, -1.25889331e-01f, 6.35468680e-03f, 8.25647917e-03f,
  -1.77794136e-02f, -2.67115682e-02f, 1.90111250e-02f, 5.01567833e-02f, 6.21250570e-02f, 7.22445920e-02f, -1.03441082e-01f, 1.30492702e-01f, -3.54948789e-02f, 1.40376464e-02f,
  -6.58767641e-01f, -4.89262849e-01f, -9.74451900e-02f, -1.10367112e-01f, -7.91680217e-02f, -1.54063187e-03f, -5.98683134e-02f, -7.75108263e-02f, -7.03203082e-02f, -6.64369911e-02f,
  -1.36081472e-01f, -4.23470065e-02f, -7.75197893e-02f, -9.63575393e-02f, -1.21260015e-02f, 5.25196157e-02f, -1.45543933e-01f, -9.45335180e-02f, -1.03949539e-01f, -1.46143928e-01f,
  -4.43271585e-02f, -1.21414125e-01f, 3.24431397e-02f, -1.32317975e-01f, -1.24417536e-03f, -2.01717280e-02f, -1.81532338e-01f, -1.44189475e-02f, 1.02326766e-01f, 8.68358836e-02f,
  -8.76173913e-01f, 2.31912911e-01f, -6.74601197e-02f, -5.00186086e-01f, -1.61728919e-01f, -2.10050732e-01f, -2.08425269e-01f, 6.94113970e-02f, 5.84104620e-02f, 4.30057436e-01f,
  2.14589760e-01f, -3.31911266e-01f, 5.30356586e-01f, -4.96343076e-02f, -2.60024339e-01f, 4.49867517e-01f, -2.52276272e-01f, -1.79474667e-01f, 2.11032003e-01f, -3.04238915e-01f,
  -3.42207223e-01f, -5.09034619e-02f, -1.83644474e-01f, 1.38839200e-01f, -3.63901109e-01f, -9.82739106e-02f, -9.28366184e-03f, 1.66408539e-01f, -3.20651114e-01f, 6.44254461e-02f,
  -3.01270396e-01f, 6.88973218e-02f, -6.12499937e-02f, -7.66038448e-02f, -2.37925634e-01f, -2.79420298e-02f, -1.69365630e-01f, -3.09957686e-05f, 2.91536096e-02f, 2.83778738e-02f,
  -4.23096307e-02f, 1.35093555e-01f, -1.04634129e-01f, 2.11969972e-01f, 5.67480251e-02f, 1.13228895e-03f, 4.23869602e-02f, -1.16257496e-01f, -4.43987474e-02f, 6.00862503e-02f,
  -1.84140876e-02f, -6.70002401e-02f, -3.05018984e-02f, 4.04429212e-02f, -5.31619303e-02f, -1.39943538e-02f, -1.17288800e-02f, -1.40775621e-01f, -1.54071629e-01f, -8.00945908e-02f,
  8.14516172e-02f, 3.57796694e-03f, -1.13441907e-02f, 4.62789163e-02f, 7.69539252e-02f, -3.40522490e-02f, -9.73506551e-03f, -2.97083743e-02f, 8.27019569e-04f, -1.03182189e-01f,
  -2.08037235e-02f, -9.02749971e-02f, 3.29674631e-02f, -4.36359234e-02f, -6.52097091e-02f, 1.25387767e-02f, 7.51608610e-03f, -1.57337170e-02f, -1.01582237e-01f, -5.63258082e-02f,
  -3.84592935e-02f, -4.33290601e-02f, 7.00482652e-02f, 4.21159752e-02f, 1.64256524e-02f, 1.24722011e-01f, 7.79419541e-02f, 8.17551613e-02f, -5.68980128e-02f, -1.31535172e-01f,
  -6.34544551e-01f, -3.58004063e-01f, -9.34529379e-02f, -7.19777420e-02f, -4.31498624e-02f, 4.53493856e-02f, -5.09417616e-04f, -2.26407275e-02f, -1.00104339e-01f, 5.12318052e-02f,
  3.59044131e-03f, -6.76571354e-02f, -1.58419311e-01f, 6.03631400e-02f, -2.79844869e-02f, -6.16085827e-02f, -1.33767635e-01f, -1.23406671e-01f, -1.89738676e-01f, -9.34300721e-02f,
  -2.12603956e-01f, -3.00539769e-02f, 5.36557250e-02f, 1.27438251e-02f, 3.16326059e-02f, -1.13749772e-01f, -1.77951872e-01f, 1.05754197e-01f, -9.50921252e-02f, 2.89536286e-02f,
  -1.01743269e+00f, 4.14403319e-01f, 6.37668371e-01f, -3.28656048e-01f, -5.58528826e-02f, 5.31488776e-01f, 3.47750098e-01f, 2.26832524e-01f, 1.29500121e-01f, -1.54022565e-02f,
  -3.13102901e-01f, -2.27614298e-01f, 1.14952207e-01f, -3.10891569e-02f, 3.47909272e-01f, 4.88350779e-01f, 1.90625355e-01f, 1.13978252e-01f, 3.08896638e-02f, -1.03355199e-01f,
  -8.37278739e-03f, -3.12687725e-01f, 2.32755035e-01f, -9.04475972e-02f, -7.99724907e-02f, -1.19003192e-01f, -4.93826777e-01f, 3.24319273e-01f, -2.69998200e-02f, 2.91469961e-01f,
  -3.36214930e-01f, -2.87165165e-01f, -1.86375514e-01f, 8.50380063e-02f, 4.00008522e-02f, -1.71210635e-02f, 1.34809718e-01f, 1.33477911e-01f, -9.43223014e-02f, 1.34550948e-02f,
  -1.80184186e-01f, 1.35649303e-02f, -9.44692641e-02f, 1.03295602e-01f, 1.08308150e-02f, -7.39537776e-02f, 1.53818533e-01f, -5.33945709e-02f, 7.50687718e-02f, 1.49871677e-01f,
  1.21849537e-01f, 8.05546045e-02f, -1.18490420e-02f, -3.64361964e-02f, -3.31698731e-03f, -4.23198752e-03f, 1.99925527e-01f, 6.58826232e-02f, 1.25104636e-01f, 6.37466460e-02f,
  1.34571329e-01f, 1.41948164e-01f, 5.56761771e-02f, -4.03909609e-02f, 9.45647433e-03f, 4.86756675e-02f, 6.87164068e-02f, -1.14211306e-01f, -6.57768473e-02f, -1.62047386e-01f,
  -2.21973777e-01f, -1.04140297e-01f, 3.09003349e-02f, 6.91077486e-02f, 9.60633345e-03f, -2.02057738e-04f, -1.05944455e-01f, -3.31242196e-02f, 6.66038319e-02f, 6.37617707e-03f,
  -5.39010018e-02f, 1.33639544e-01f, -1.11175567e-01f, -1.40433595e-01f, 1.13784701e-01f, 7.69840851e-02f, -7.23110288e-02f, 2.52197720e-02f, -8.69175419e-02f, -1.14223853e-01f,
  -1.72221795e-01f, -6.39998391e-02f, -1.58315673e-01f, -2.28053689e-01f, -1.34992972e-02f, -5.72865494e-02f, 6.45709783e-02f, -7.68563896e-02f, 1.11153103e-01f, -1.16914794e-01f,
  2.24832222e-02f, -1.08147964e-01f, 1.66450776e-02f, 3.44995447e-02f, 5.28413653e-02f, 6.16502529e-03f, -1.87469777e-02f, -1.37679160e-01f, -8.49536061e-02f, -2.25692540e-02f,
  -1.03911780e-01f, -1.91244595e-02f, -7.33106630e-03f, -1.27417713e-01f, -9.72721726e-02f, -8.95018876e-02f, -9.42166150e-02f, -1.61310900e-02f, -7.23416731e-02f, 1.43656299e-01f,
  1.57952651e-01f, -3.52711827e-01f, 1.35331765e-01f, 1.98578835e-01f, 1.79644786e-02f, 1.60923764e-01f, 3.33610237e-01f, -2.41109788e-01f, -4.57948774e-01f, -2.43782982e-01f,
  1.72905177e-01f, 2.05754355e-01f, 5.11632450e-02f, 1.87485144e-01f, 6.71571851e-01f, -7.14984490e-03f, -1.47701974e-03f, 8.40289425e-03f, -1.13786682e-01f, -1.36902565e-02f,
  6.27120435e-02f, 2.02011853e-01f, 4.23481524e-01f, -5.29424213e-02f, 2.55293995e-01f, 2.46041179e-01f, 4.38320011e-01f, 4.27755862e-01f, 3.05715591e-01f, 4.92496639e-01f,
  -8.74690413e-02f, -1.63792804e-01f, -1.91453453e-02f, -1.30934536e-01f, 2.78655868e-02f, 3.21306214e-02f, 1.31596684e-01f, 3.62127542e-01f, 2.08710060e-01f, 2.06582993e-02f,
  9.70357750e-03f, 8.75935182e-02f, -4.26304061e-03f, 1.72187850e-01f, -6.60752133e-02f, -5.64114377e-02f, -9.82998908e-02f, -1.10075668e-01f, -1.02040946e-01f, 2.97355931e-02f,
  -6.73048571e-02f, -1.00423396e-01f, 1.03204817e-01f, 4.51947562e-02f, 1.81247681e-01f, -1.10119447e-01f, -4.12609838e-02f, 1.52314425e-01f, -8.45839307e-02f, 2.30490845e-02f,
  6.36260659e-02f, -4.88874167e-02f, -1.91072263e-02f, -5.96705358e-03f, -1.49865281e-02f, 3.79298888e-02f, -4.42952923e-02f, 5.27109243e-02f, 9.12727043e-02f, -3.69347744e-02f,
  -2.93520056e-02f, 1.64863113e-02f, -1.49986550e-01f, -1.67509958e-01f, -3.90427783e-02f, -1.70400321e-01f, 7.12901354e-02f, 9.22903121e-02f, -9.81405452e-02f, -6.19710088e-02f,
  -3.99362221e-02f, 1.85398638e-01f, -5.71955629e-02f, -2.19502933e-02f, -3.51960622e-02f, -8.12971890e-02f, 1.06480382e-02f, 6.70296103e-02f, 1.60723049e-02f, 2.64924735e-01f,
  1.43614277e-01f, 2.03586757e-01f, 8.33491981e-03f, -4.59742881e-02f, -6.29414544e-02f, 8.25516228e-03f, 3.96463573e-02f, -1.18065011e-02f, 2.22185120e-01f, 2.59728450e-02f,
  -2.39344519e-02f, 7.69406930e-02f, -6.15806393e-02f, -8.81378725e-03f, 9.18835253e-02f, -1.26628324e-01f, 1.17217135e-02f, 2.37654075e-02f, -7.43737519e-02f, 4.38821614e-02f,
  -1.77635085e-02f, 2.66956594e-02f, 1.04498357e-01f, -4.29799110e-02f, -1.56334713e-01f, -1.98653396e-02f, -3.92262191e-02f, -7.30529502e-02f, 5.54222390e-02f, 1.28493771e-01f,
  -2.28547871e-01f, 6.30421937e-01f, -2.19081581e-01f, 1.65360272e-01f, 1.29721880e-01f, -5.14278352e-01f, -3.54387045e-01f, 3.43951255e-01f, -5.17691150e-02f, 1.68274581e-01f,
  3.00974846e-01f, 4.69128564e-02f, 2.08221614e-01f, 3.03932399e-01f, -3.47645611e-01f, -2.93609291e-01f, -6.67694733e-02f, -1.48670837e-01f, -9.69792008e-02f, 2.52382398e-01f,
  -1.88792244e-01f, 4.09882247e-01f, -7.99516514e-02f, 3.43284607e-01f, 3.19796562e-01f, 1.34342536e-01f, 1.82194024e-01f, -9.96344350e-03f, 1.17630064e-01f, 2.96345502e-02f,
  -1.75479613e-02f, 3.29748422e-01f, -1.43828094e-01f, -1.59385875e-01f, -2.19499692e-01f, -2.92554468e-01f, -2.35012800e-01f, 6.31580129e-02f, -7.69915283e-02f, 9.08518657e-02f,
  2.86731534e-02f, 5.75519986e-02f, -2.36994158e-02f, -1.80485118e-02f, 4.44537885e-02f, 6.96676821e-02f, 4.95060831e-02f, -1.02790430e-01f, 6.78424090e-02f, 7.08119422e-02f,
  -3.65656018e-02f, -3.53456102e-02f, 6.22687601e-02f, -3.93476710e-02f, -1.01920351e-01f, 1.25438884e-01f, -1.60808548e-01f, -3.92875001e-02f, 6.96111321e-02f, -3.14571448e-02f,
  2.74655342e-01f, -5.36450185e-02f, -3.70913334e-02f, -7.15299398e-02f, -1.81102883e-02f, -2.33701337e-03f, -8.99908170e-02f, -1.10317446e-01f, -1.10741973e-01f, 4.16531488e-02f,
  -3.95116135e-02f, 1.27224624e-01f, 1.03236355e-01f, -4.36711162e-02f, 1.25956926e-02f, -8.81570876e-02f, -1.03834234e-01f, 1.05046235e-01f, -1.35488793e-01f, -3.79376858e-02f,
  4.83511249e-03f, 5.88280931e-02f, -1.24438353e-01f, -1.05867624e-01f, -1.37942946e-02f, 9.92781594e-02f, 7.00103864e-02f, -3.73958237e-02f, -2.89405771e-02f, -4.79228795e-02f,
  1.43254966e-01f, 4.17213440e-01f, 5.64965457e-02f, 3.88920978e-02f, -4.75417897e-02f, -2.13770032e-01f, -1.24525830e-01f, 3.82844172e-02f, 1.63253114e-01f, 7.93305319e-03f,
  9.67792869e-02f, -2.47413933e-01f, -1.03715762e-01f, 6.80657551e-02f, -4.70565036e-02f, 1.38521075e-01f, 2.39074882e-02f, -1.36383981e-01f, 5.78255532e-03f, 1.11604109e-01f,
  1.33441672e-01f, 1.96645245e-01f, -1.18962102e-01f, -1.91368580e-01f, 8.85880738e-02f, 6.95409924e-02f, 1.85959414e-01f, -6.85035735e-02f, 1.30713239e-01f, -7.70522878e-02f,
  -2.80946493e-01f, 3.24107498e-01f, -3.94666046e-01f, 4.64979291e-01f, -2.42559284e-01f, 6.57975972e-02f, 2.58832812e-01f, -1.85378045e-02f, 1.27631985e-02f, 3.95312011e-01f,
  4.07287300e-01f, -1.16335392e-01f, 9.88110825e-02f, 6.20328605e-01f, 1.67776421e-01f, 3.16972405e-01f, 6.06093466e-01f, 4.43071365e-01f, -1.86587200e-01f, 1.71074286e-01f,
  -1.24312706e-01f, 6.12010300e-01f, 2.40198076e-01f, 4.69862930e-02f, 1.35793358e-01f, -3.19354445e-01f, 3.88868392e-01f, -2.69632787e-01f, 5.13741910e-01f, 3.05999682e-04f,
  1.01506449e-01f, -4.31665406e-02f, -8.28694478e-02f, -7.55276605e-02f, 4.80157025e-02f, -2.71652639e-02f, 1.59861259e-02f, -1.44691542e-02f, -1.56485409e-01f, -7.98985288e-02f,
  -1.71371520e-01f, -1.77142806e-02f, 3.11836470e-02f, -1.33890122e-01f, -9.92122889e-02f, 5.05013485e-03f, -1.09175064e-01f, 8.85219350e-02f, -5.59356390e-03f, -7.95168951e-02f,
  -1.51262194e-01f, -2.20541116e-02f, 4.46254164e-02f, 1.34691119e-01f, 8.78877286e-03f, -4.21933196e-02f, 1.53798670e-01f, -9.02989581e-02f, -6.49725180e-03f, -6.76734233e-03f,
  -1.14162348e-01f, 7.11316185e-04f, -6.34975880e-02f, 1.20436080e-01f, 1.23654837e-02f, 8.35301802e-02f, 4.77425307e-02f, 8.83571357e-02f, -7.94108883e-02f, 1.15616925e-01f,
  2.79250890e-02f, -4.71662655e-02f, 4.63557243e-02f, -8.35481472e-03f, 1.39202043e-01f, 3.96029316e-02f, -8.03476647e-02f, -5.04870340e-02f, 8.88829469e-04f, 3.45497429e-02f,
  2.59157605e-02f, -6.24356233e-02f, 9.59003344e-02f, 2.39173640e-02f, 9.86891314e-02f, -3.08553930e-02f, 8.32696706e-02f, 2.03197543e-02f, 7.25412741e-02f, -6.90440014e-02f,
  2.33075082e-01f, 1.60641104e-01f, 5.54338098e-02f, -8.58940035e-02f, 4.93433625e-02f, 6.82717860e-02f, 8.63014236e-02f, -9.66973901e-02f, 9.99693274e-02f, -4.65631485e-02f,
  4.06703278e-02f, -9.82462019e-02f, -1.74919106e-02f, -5.48327751e-02f, 1.50071213e-03f, 1.78960294e-01f, 1.34676412e-01f, -2.57939007e-02f, 1.41989544e-01f, 1.54165868e-02f,
  1.46943435e-01f, -2.54809745e-02f, 6.39582500e-02f, -6.12461232e-02f, 1.33567959e-01f, 1.18033879e-01f, -5.85697703e-02f, -2.56912187e-02f, -2.76659839e-02f, 7.36202151e-02f,
  -3.86835605e-01f, -9.13191736e-02f, -5.18076181e-01f, -3.71249348e-01f, 3.59655559e-01f, 4.81400758e-01f, 3.07152063e-01f, 6.18066229e-02f, 8.22440237e-02f, 3.61145318e-01f,
  3.75813931e-01f, -1.48068592e-01f, 1.39328226e-01f, -3.93484145e-01f, -4.13014114e-01f, -2.48075634e-01f, 8.79638046e-02f, 3.62302586e-02f, -5.98874092e-02f, 2.25568607e-01f,
  -2.58917123e-01f, 9.25057754e-02f, -5.19941807e-01f, 1.53258666e-01f, -3.67790051e-02f, 8.65483508e-02f, 2.25717053e-01f, 1.84503883e-01f, -9.37619153e-03f, 5.20682484e-02f,
  2.05180198e-02f, -7.28956610e-02f, -1.51937321e-01f, -1.14602365e-01f, 7.95228481e-02f, 1.06794566e-01f, 1.94927275e-01f, -1.26219437e-01f, -9.50041413e-02f, -2.11345442e-02f,
  1.42528385e-01f, -5.35020195e-02f, -4.78001684e-02f, -2.03292929e-02f, 5.21964282e-02f, -2.43436806e-02f, -1.34514123e-01f, 1.21269608e-02f, -2.89363181e-03f, -3.23717706e-02f,
  -8.92758965e-02f, -8.72029066e-02f, 8.20577592e-02f, -9.35971513e-02f, 6.29542954e-03f, 1.02178879e-01f, 3.66481319e-02f, 1.15611427e-01f, -2.64903298e-03f, -4.65397686e-02f,
  -4.27883230e-02f, 2.24102169e-01f, 6.11722246e-02f, -9.94612798e-02f, -8.09837878e-02f, -5.66317476e-02f, 3.06995474e-02f, 1.93911493e-02f, 8.92406609e-03f, 2.16851398e-01f,
  2.68311258e-02f, -1.61597375e-02f, 8.17035362e-02f, 1.07273877e-01f, -3.14929225e-02f, -3.19128446e-02f, 5.76484129e-02f, 1.36774078e-01f, 1.21550433e-01f, -7.49638602e-02f,
  7.44125294e-03f, 5.85081279e-02f, 1.69865713e-02f, 1.16608471e-01f, 7.83139095e-02f, -7.52532482e-02f, 1.12461761e-01f, -1.72368392e-01f, -5.10098599e-02f, 1.00590736e-01f,
  1.15815632e-01f, 4.30053264e-01f, 6.44106567e-02f, -4.67775092e-02f, 1.49973100e-02f, 7.20823407e-02f, -5.09820357e-02f, -1.09176680e-01f, 1.51780874e-01f, 1.75433233e-01f,
  2.89529175e-01f, 7.78838024e-02f, 2.60868192e-01f, 3.57304723e-03f, -7.87390694e-02f, 1.89807296e-01f, 7.79074207e-02f, 9.28935632e-02f, 1.41631201e-01f, 4.71412577e-02f,
  1.04984999e-01f, 9.69297439e-02f, -5.58076762e-02f, -6.67401124e-03f, 1.02377459e-01f, 1.89304158e-01f, 1.71509892e-01f, 2.23946515e-02f, -1.11413253e-02f, 6.35556206e-02f,
  3.89829844e-01f, 4.94943976e-01f, 4.68226135e-01f, 3.33362937e-01f, -1.39154747e-01f, 2.64400244e-01f, 6.80315197e-02f, 2.27614969e-01f, 7.01268494e-01f, 8.14245343e-02f,
  -3.71287018e-01f, 4.94187504e-01f, -4.28852797e-01f, 9.27320123e-02f, -3.89550209e-01f, -2.11927012e-01f, -4.61898744e-02f, -7.54720904e-03f, 1.95495877e-03f, -7.80151365e-03f,
  -2.67576188e-01f, -5.61209679e-01f, -3.19907755e-01f, -3.96538109e-01f, 1.85041860e-01f, 3.42000753e-01f, -6.11271799e-01f, -1.29019886e-01f, 5.26881106e-02f, -2.55690962e-01f,
  1.24365538e-01f, 6.05844632e-02f, 2.63807952e-01f, 2.60381758e-01f, 7.67264590e-02f, 1.86860804e-02f, 4.26471792e-02f, -5.95489964e-02f, -3.91640440e-02f, 7.03387186e-02f,
  -1.56470258e-02f, -7.12766051e-02f, 7.33782947e-02f, -6.18928224e-02f, 2.69719779e-01f, 1.51282012e-01f, 2.40591466e-01f, 1.40511870e-01f, 1.27282813e-01f, 1.29655883e-01f,
  2.04219520e-01f, 2.61764050e-01f, 1.39141783e-01f, 1.40025383e-02f, 1.48099735e-01f, 2.55766541e-01f, 1.39212370e-01f, 5.50072901e-02f, 2.53391325e-01f, 1.53871000e-01f,
  -1.30498931e-01f, -5.59078306e-02f, -2.52622925e-02f, -3.41103529e-03f, -6.47290722e-02f, -4.39594425e-02f, -7.39003420e-02f, -1.45661697e-01f, 2.60909665e-02f, -8.58110338e-02f,
  -8.44273251e-03f, 1.00577772e-01f, 9.17330310e-02f, 9.72277671e-02f, -1.01223372e-01f, 9.93074998e-02f, -6.61571920e-02f, 3.36020440e-02f, 7.75793120e-02f, 4.28626426e-02f,
  -1.34069964e-01f, -5.15343919e-02f, -2.88497824e-02f, -8.83588269e-02f, 1.67041440e-02f, -5.65705486e-02f, -4.98533547e-02f, 4.83636409e-02f, 3.46915387e-02f, -1.61104888e-01f,
  2.31077522e-02f, -5.97549789e-02f, 1.16265245e-01f, 1.36821195e-01f, -3.47291352e-03f, -1.02642410e-01f, -5.22087887e-02f, 1.56666115e-01f, -1.12200901e-02f, -6.99497536e-02f,
  1.03978179e-01f, 2.77172364e-02f, 2.27051992e-02f, -7.34344348e-02f, -6.73292875e-02f, -7.47323595e-03f, 7.40122125e-02f, -4.48267646e-02f, 4.98868227e-02f, -9.88350213e-02f,
  5.23738377e-02f, -7.87500292e-02f, 4.20980528e-02f, 1.68011002e-02f, 7.10627809e-02f, -3.89090553e-02f, 5.92849441e-02f, 1.11179583e-01f, -1.00856088e-01f, -8.36256370e-02f,
  4.00833666e-01f, -5.04390359e-01f, 3.98757786e-01f, 2.27444246e-01f, 4.88634527e-01f, 1.04769260e-01f, 8.65544453e-02f, 2.59244710e-01f, 3.90993655e-01f, -6.01681352e-01f,
  2.53553540e-02f, -4.72021371e-01f, -9.86624211e-02f, -2.52401680e-01f, 3.84299546e-01f, -1.21065155e-01f, 1.06341690e-02f, -3.89148682e-01f, 2.61841089e-01f, 1.03392817e-01f,
  1.36143401e-01f, -3.03331167e-01f, 2.01201458e-02f, -2.81465888e-01f, -9.35405493e-02f, -5.88951893e-02f, -2.34052494e-01f, -6.53336719e-02f, -3.23558718e-01f, -1.29248470e-01f,
  8.44236091e-02f, 5.11594415e-02f, -8.55554789e-02f, -8.08800235e-02f, 4.48007323e-02f, -1.07799709e-01f, -1.22407079e-01f, -5.34822606e-02f, 1.32746354e-01f, 5.66001274e-02f,
  -4.68827151e-02f, -3.12305391e-02f, -2.21502557e-01f, -2.49641854e-02f, 7.16066957e-02f, 6.04471639e-02f, 9.98354703e-02f, 1.52823418e-01f, 2.81949081e-02f, 8.48001018e-02f,
  8.20696503e-02f, 6.92374248e-04f, 1.87386438e-01f, -3.77774499e-02f, 6.13162331e-02f, 2.50807516e-02f, 2.48534081e-04f, -6.88295290e-02f, 5.60368504e-03f, 4.99833710e-02f,
  -1.34595066e-01f, -1.16963044e-01f, -8.11182410e-02f, 4.30652499e-02f, 4.64966670e-02f, 1.13849223e-01f, 6.31806478e-02f, 3.81460413e-02f, 4.87201056e-03f, 7.25215226e-02f,
  9.54429582e-02f, 1.59863494e-02f, 1.59663603e-01f, 2.76141185e-02f, 1.72845442e-02f, 9.99083370e-02f, -3.71310338e-02f, 2.03017034e-02f, -6.53621629e-02f, 4.11762483e-02f,
  7.85356667e-03f, 1.11650508e-02f, -3.93340189e-04f, 5.70099242e-02f, 4.75199781e-02f, -2.77358871e-02f, -3.31869423e-02f, 1.13467555e-02f, 1.13251917e-01f, -1.42635718e-01f,
  -9.75679681e-02f, -6.48038924e-01f, -2.98596676e-02f, 1.70955919e-02f, -2.97643114e-02f, -4.53990512e-02f, -2.74613500e-03f, 1.09856511e-02f, -2.56394297e-02f, 1.00101084e-01f,
  4.30658907e-02f, 5.23146503e-02f, -4.19258997e-02f, 1.27011612e-01f, -1.93068370e-01f, -1.83093932e-03f, -9.15068761e-02f, -1.10325769e-01f, -1.41684204e-01f, -3.98966447e-02f,
  -8.42782259e-02f, 2.39795819e-02f, -3.00361868e-02f, -4.62768041e-02f, -4.88609895e-02f, -8.07917863e-02f, -9.70486775e-02f, -3.54864970e-02f, -3.50278430e-02f, -1.28368616e-01f,
  -1.31428704e-01f, -2.60359496e-01f, -1.68411046e-01f, 2.66339153e-01f, 5.36645234e-01f, -3.18674058e-01f, 3.80065329e-02f, 5.13414681e-01f, -2.53850948e-02f, -1.04154954e-02f,
  1.22940734e-01f, -5.56575894e-01f, -1.91728137e-02f, -3.58966410e-01f, -2.34832659e-01f, -4.25312936e-01f, -1.60757840e-01f, -3.75918925e-01f, -1.81606635e-01f, 2.19833851e-01f,
  1.50666654e-01f, 2.67026067e-01f, 2.93222010e-01f, 4.00143772e-01f, 3.53944927e-01f, 1.83875948e-01f, 3.14648777e-01f, 1.42294154e-01f, 6.26420900e-02f, -1.22834794e-01f,
  -5.48198596e-02f, 1.40024588e-01f, 1.16207063e-01f, -1.11394458e-01f, 2.92251855e-01f, 1.14871927e-01f, -5.23001216e-02f, -1.37256250e-01f, -1.19010210e-01f, -7.49949589e-02f,
  -3.67449187e-02f, -1.09418146e-02f, -2.14406252e-01f, 2.59952359e-02f, 1.06512830e-01f, 1.78456917e-01f, -1.27289295e-01f, 6.95268717e-03f, -2.99670789e-02f, -1.25830427e-01f,
  -1.71442385e-04f, -2.39000127e-01f, -2.90421136e-02f, -1.49111837e-01f, 4.07884754e-02f, -7.22037628e-02f, -1.32841794e-02f, 7.12824091e-02f, -1.47462651e-01f, 4.05421406e-02f,
  4.29444164e-02f, 3.50281820e-02f, -2.23411359e-02f, -6.68974668e-02f, -3.51215340e-02f, 4.89870533e-02f, -1.95487410e-01f, -1.65297329e-01f, -1.27644162e-03f, 1.14002548e-01f,
  -1.19728753e-02f, 1.82601381e-02f, 4.65941355e-02f, -1.31844562e-02f, 1.04719624e-01f, -4.78046276e-02f, -8.75646919e-02f, -1.63470104e-01f, 2.60913014e-01f, -8.24592710e-02f,
  -1.75542869e-02f, 4.30456549e-02f, 4.62849028e-02f, -9.22848210e-02f, -1.45059094e-01f, 1.27986774e-01f, 1.05424367e-01f, 6.23740219e-02f, 3.19688879e-02f, -7.87485042e-04f,
  -3.61330956e-02f, 2.45259017e-01f, 5.62767051e-02f, -1.78772286e-01f, -6.38453811e-02f, 1.10715613e-01f, -1.35393545e-01f, -1.48738241e-02f, -2.09710561e-02f, 2.71203313e-02f,
  2.43082747e-01f, 8.27914104e-02f, 9.96644143e-04f, -6.33141771e-02f, -3.68316993e-02f, 1.92400828e-01f, -8.58697295e-02f, -1.59193855e-02f, 1.17481850e-01f, 1.94631908e-02f,
  3.15214455e-01f, 5.82096241e-02f, -3.42849493e-02f, 1.58799097e-01f, 1.22441493e-01f, -3.43985227e-03f, 3.69209647e-02f, 1.70001820e-01f, 4.66495641e-02f, -6.94047585e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.88091952e-01f, 4.57361490e-01f, 5.31179190e-01f, 5.38063407e-01f, 4.59142029e-01f, 3.65898997e-01f, 3.98427397e-01f, 6.00129545e-01f, 6.40648663e-01f, 5.39287150e-01f,
  3.73395979e-01f, 2.75152326e-01f, 4.16795194e-01f, 4.11991328e-01f, 5.31253397e-01f, 1.98756531e-01f, 3.26038390e-01f, 3.92071515e-01f, 4.04025137e-01f, 3.16035718e-01f,
  5.06782651e-01f, 2.79883087e-01f, 4.32686895e-01f, 6.10951781e-01f, 2.80011922e-01f, 5.76182842e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.76583737e-01f, -3.76232155e-02f, -1.58388361e-01f, 4.15385477e-02f, -1.33433007e-02f, -2.03985333e-01f, 8.56858715e-02f, -2.99077094e-01f, 1.01238616e-01f, -3.94897342e-01f,
  -9.95608866e-02f, 1.13311466e-02f, -8.45392887e-03f, -2.28952989e-02f, -1.00188240e-01f, -2.03297302e-01f, -1.74189042e-02f, -1.88294649e-01f, 1.56377688e-01f, 8.97228122e-02f,
  -3.42870839e-02f, 6.00094087e-02f, 5.59160635e-02f, -3.30838710e-02f, -2.41935283e-01f, 5.50494120e-02f, 1.48996651e-01f, 4.92741577e-02f, 1.05384197e-02f, 7.63501273e-03f,
  1.03730284e-01f, -5.62033132e-02f, 4.24162038e-02f, 1.84686437e-01f, -1.47562742e-01f, -1.53628225e-02f, 5.40350154e-02f, -1.80871502e-01f, -5.34656756e-02f, -4.79671732e-03f,
  1.08376089e-02f, 1.19114690e-01f, 6.81590885e-02f, -4.08958197e-01f, -2.11494312e-01f, -2.97115415e-01f, -1.29123867e-01f, -2.06919853e-03f, -8.48123208e-02f, -3.25681657e-01f,
  4.68468890e-02f, -1.62408054e-01f, -2.67203271e-01f, -2.39504084e-01f, -2.17469841e-01f, 2.40021318e-01f, 1.32719576e-01f, -2.11630434e-01f, 3.52931201e-01f, -2.70580173e-01f,
  2.64440507e-01f, 3.67929906e-01f, 1.05213515e-01f, 4.08142447e-01f, -2.25203767e-01f, 4.06156391e-01f, 1.96328342e-01f, 3.03675115e-01f, -2.30241403e-01f, 1.77935660e-01f,
  -1.13586955e-01f, 1.57917500e-01f, -3.42295170e-01f, 1.43583268e-01f, -2.12395817e-01f, -2.69509643e-01f, 2.65279621e-01f, -1.76094081e-02f, -6.93023484e-03f, 2.02703938e-01f,
  -2.85779029e-01f, -2.31094763e-01f, 3.19293708e-01f, 3.58320236e-01f, 2.41345853e-01f, -1.97206229e-01f, 3.94259254e-03f, -1.48469165e-01f, -4.41922426e-01f, 1.23597225e-02f,
  2.61186540e-01f, 1.53912738e-01f, 6.68292940e-02f, -6.81488737e-02f, 2.48695299e-01f, 8.43465254e-02f, 1.36987999e-01f, 8.79713520e-02f, -1.31350353e-01f, 1.97550759e-01f,
  2.61272818e-01f, 1.58627257e-01f, -2.08730593e-01f, 5.53599954e-01f, -4.45166260e-01f, -2.64822364e-01f, 9.35617685e-02f, -4.89423871e-01f, -3.09062004e-01f, -4.55171317e-01f,
  -4.25762802e-01f, -3.71487290e-01f, -1.30890116e-01f, 3.97780806e-01f, -2.81215340e-01f, -5.11299670e-01f, -3.03357579e-02f, -2.53703892e-01f, 3.39510947e-01f, 3.13469440e-01f,
  9.29313675e-02f, -3.77913862e-01f, -1.85474575e-01f, 5.15503645e-01f, -1.81912081e-04f, -2.16298774e-01f, -3.21145087e-01f, -2.13112071e-01f, -4.79016975e-02f, 9.03728902e-02f,
  1.92255840e-01f, -2.67073303e-01f, -9.25003439e-02f, 2.00083312e-02f, 2.39738181e-01f, 1.72028244e-01f, -3.32634956e-01f, 1.94086313e-01f, -9.17213690e-03f, -1.65565640e-01f,
  -1.31023526e-01f, -1.07229955e-01f, 1.88347831e-01f, 3.12282983e-02f, 1.19611561e-01f, 1.17054600e-02f, -3.69546235e-01f, 2.32214972e-01f, -6.07698150e-02f, 6.36518374e-02f,
  -2.61180885e-02f, 1.27270119e-02f, 8.98764748e-03f, -6.02289856e-06f, -1.78347051e-01f, -1.52468607e-01f, 2.04945430e-01f, -9.69861299e-02f, 3.36598642e-02f, 1.37943298e-01f,
  4.30682115e-02f, -1.40410706e-01f, -2.23755151e-01f, 1.52644105e-02f, 5.96710443e-02f, 9.47174504e-02f, 3.59140337e-02f, -2.14022338e-01f, -2.67281145e-01f, -3.46154809e-01f,
  3.05927619e-02f, 1.25668630e-01f, 1.19180553e-01f, 2.32471619e-03f, -2.87697136e-01f, 9.92335975e-02f, 7.51653686e-02f, -3.57720822e-01f, 2.33558893e-01f, -9.67972875e-02f,
  3.03571492e-01f, -3.19801360e-01f, 3.63671660e-01f, 2.30388284e-01f, 5.43838024e-01f, -1.18885994e-01f, -4.17246848e-01f, -3.01196635e-01f, -9.57071874e-03f, -3.11502278e-01f,
  1.45807728e-01f, -4.48078930e-01f, -3.60795148e-02f, -3.13787729e-01f, 1.24266207e-01f, 1.91125259e-01f, -2.04109266e-01f, -2.99268126e-01f, 8.33233371e-02f, 4.10214216e-01f,
  4.77314472e-01f, -3.98243457e-01f, -3.56361680e-02f, -2.27047041e-01f, -4.65018988e-01f, -4.37588722e-01f, 1.70605719e-01f, -3.15237075e-01f, -3.00353914e-01f, 1.85967460e-01f,
  3.03176969e-01f, -1.12224512e-01f, -4.77240562e-01f, -3.21919233e-01f, 2.24731952e-01f, 3.37953903e-02f, -1.72225848e-01f, 3.45599324e-01f, 3.70422363e-01f, 3.42871964e-01f,
  3.83986622e-01f, 4.02304500e-01f, 2.84198195e-01f, 2.87702858e-01f, 4.13062304e-01f, 1.30391985e-01f, 1.95216879e-01f, 1.96896791e-01f, 2.52736181e-01f, 6.13990687e-02f,
  1.51137128e-01f, 2.34951660e-01f, 4.50340956e-01f, 3.14236492e-01f, 1.79357916e-01f, -3.86806101e-01f, 1.89076699e-02f, -2.96138525e-01f, 6.89926594e-02f, 1.12091213e-01f,
  1.40456691e-01f, -3.42976570e-01f, -8.27362597e-01f, 1.85426757e-01f, -5.89991331e-01f, -1.27336726e-01f, -5.74577689e-01f, -6.85244799e-01f, -4.01246995e-01f, 1.84509587e-02f,
  2.18449906e-01f, 3.28716248e-01f, 1.53411910e-01f, -4.36893970e-01f, -3.79695445e-01f, -5.57953566e-02f, -1.12225257e-01f, -1.27648795e-03f, -3.30855906e-01f, 1.52789369e-01f,
  5.70830852e-02f, 3.54500897e-02f, -2.02779204e-01f, -9.23109874e-02f, -2.00361982e-02f, -1.32122070e-01f, -1.37132749e-01f, 1.49726704e-01f, -2.44365320e-01f, -8.38637128e-02f,
  7.96815380e-03f, -5.02279624e-02f, -3.72465044e-01f, 3.90934385e-03f, 8.76842812e-03f, -1.54583016e-03f, 1.79455131e-02f, 4.87447949e-03f, -5.21684252e-02f, -1.06007732e-01f,
  1.01197079e-01f, -3.62973921e-02f, -1.81455985e-01f, 9.25751179e-02f, -2.92053595e-02f, -1.80159688e-01f, 1.48905646e-02f, -9.65465978e-02f, 1.05763428e-01f, -3.40795994e-01f,
  -3.03775985e-02f, -4.48614024e-02f, -1.45658001e-01f, -9.57108289e-02f, -1.89371407e-01f, -8.35029525e-04f, -7.65692890e-02f, -1.60089031e-01f, -3.31221998e-01f, -5.60925575e-03f,
  -1.02902606e-01f, -2.55354773e-02f, 8.45536739e-02f, 2.60155890e-02f, 1.41510695e-01f, -1.50218988e-02f, 8.68759602e-02f, -3.12541932e-01f, -2.38457993e-02f, 1.69011071e-01f,
  3.93666811e-02f, 3.90575558e-01f, -1.94768459e-01f, -2.66860425e-01f, -2.15242103e-01f, -1.05118908e-01f, 3.61405373e-01f, 4.40023720e-01f, -1.16439834e-01f, -2.22124830e-01f,
  1.91370964e-01f, -4.48352128e-01f, -2.77346015e-01f, 2.32103884e-01f, 2.33842656e-01f, 1.52498007e-01f, -2.48165414e-01f, 9.24030095e-02f, -7.43408129e-02f, -2.53032029e-01f,
  -3.90019029e-01f, 5.08685745e-02f, -1.67711720e-01f, -2.67000347e-01f, -2.71698773e-01f, -1.61656186e-01f, -2.44985953e-01f, 1.36347294e-01f, -2.60363698e-01f, 3.83335128e-02f,
  -9.13550779e-02f, 3.19331676e-01f, -7.71365166e-02f, -2.02269033e-01f, 2.82164484e-01f, -3.45673800e-01f, -2.62196451e-01f, 2.02035978e-01f, 1.63198471e-01f, 1.94369048e-01f,
  -7.67882392e-02f, 1.71229732e-03f, -3.68878484e-01f, 3.01517427e-01f, 2.43714213e-01f, 1.27743617e-01f, 2.09395602e-01f, -1.40303880e-01f, -6.20116234e-01f, -5.74941576e-01f,
  4.15917099e-01f, 2.10782751e-01f, 4.18985263e-02f, -4.54287678e-01f, -1.71313807e-01f, -1.04891174e-01f, 4.99983162e-01f, -4.84499633e-01f, -1.88476235e-01f, -3.34812760e-01f,
  4.90486115e-01f, -1.04558179e-02f, -2.60987043e-01f, -3.18432450e-01f, -3.98673683e-01f, -2.39470795e-01f, -1.33462623e-01f, 2.60823995e-01f, -2.08351851e-01f, -3.25910049e-03f,
  -5.07996917e-01f, -3.57015431e-01f, -1.20775081e-01f, 4.55825403e-02f, 4.12193984e-02f, -1.82657875e-02f, 5.59179783e-02f, -1.58137113e-01f, -1.26443490e-01f, 6.08396307e-02f,
  -1.08390003e-01f, -2.06644908e-01f, 1.07267961e-01f, -1.11089535e-01f, -6.31740689e-02f, 6.56116754e-02f, -1.88537464e-01f, 1.31240398e-01f, 3.03991865e-02f, 8.09098482e-02f,
  1.39104828e-01f, -4.51015569e-02f, -5.19790836e-02f, -2.87229389e-01f, -1.34844005e-01f, -5.30042220e-03f, -1.75018609e-01f, -3.43609862e-02f, 2.05579363e-02f, -1.32899523e-01f,
  -2.64639437e-01f, -2.33795539e-01f, 7.87095055e-02f, -2.36472160e-01f, -2.77837157e-01f, 4.17306945e-02f, 5.77406473e-02f, -2.12824926e-01f, 8.21313933e-02f, -8.12659189e-02f,
  -1.89584792e-01f, -3.19364592e-02f, 7.59660602e-02f, 4.43856418e-02f, 2.20025461e-02f, 1.52150355e-02f, 1.64529234e-02f, -9.78628099e-02f, -1.85740829e-01f, -5.43641411e-02f,
  1.38496339e-01f, -1.28740430e-01f, -2.26082072e-01f, -1.58447936e-01f, -1.54726803e-01f, 1.22863814e-01f, 2.48510316e-01f, -4.38679874e-01f, -2.28529066e-01f, -2.19436422e-01f,
  -1.51049137e-01f, 9.34532136e-02f, 2.53003836e-01f, 3.24797213e-01f, 8.74128342e-02f, 6.50362074e-02f, 3.55692692e-02f, 3.09772640e-01f, 7.78372691e-04f, -2.30424732e-01f,
  3.78995866e-01f, -1.83069836e-02f, -4.10254091e-01f, -1.39672831e-02f, -1.84901714e-01f, 4.50117856e-01f, -2.46521682e-01f, 1.44115791e-01f, -1.97748527e-01f, -1.48644652e-02f,
  2.26850346e-01f, 2.26062730e-01f, -2.52644420e-01f, -1.24897458e-01f, 3.70528460e-01f, -3.82757932e-02f, -1.28002867e-01f, -3.11576903e-01f, 7.39133880e-02f, -3.23285013e-01f,
  -3.44708413e-01f, 1.05924137e-01f, -2.52088368e-01f, -2.44418353e-01f, 1.12897545e-01f, -1.41930908e-01f, -1.47398964e-01f, -4.15238023e-01f, -5.53804375e-02f, -3.68253410e-01f,
  2.10424647e-01f, 1.34674549e-01f, 1.21603198e-01f, -4.42635231e-02f, -3.17195952e-01f, 2.57266670e-01f, -6.44877672e-01f, -3.14098090e-01f, -3.28901261e-01f, -2.01205403e-01f,
  -2.56058186e-01f, -1.12963609e-01f, 4.80864011e-02f, 2.60324568e-01f, -2.61687487e-02f, 6.35595098e-02f, 3.39207739e-01f, 4.92803216e-01f, -1.04191843e-02f, -2.89184660e-01f,
  2.68769532e-01f, 5.05617261e-01f, -4.78186876e-01f, 4.54829514e-01f, -3.63424927e-01f, -2.98161030e-01f, 4.35420066e-01f, -3.50282103e-01f, 7.19363540e-02f, -1.80089846e-01f,
  -4.90073919e-01f, 1.32377505e-01f, 3.17262635e-02f, 1.26722574e-01f, 7.74674565e-02f, 7.57853389e-02f, -2.34823912e-01f, -3.92949916e-02f, 7.94407204e-02f, 1.39541119e-01f,
  1.85566731e-02f, 4.36911844e-02f, -1.35350406e-01f, -1.12562664e-01f, 3.75852957e-02f, 2.63634045e-02f, 1.15209803e-01f, 1.66552350e-01f, 4.28886302e-02f, 1.81118682e-01f,
  -6.81445822e-02f, 8.45388547e-02f, 5.38388826e-02f, 1.68851331e-01f, 2.46051148e-01f, -1.16941325e-01f, 1.17504954e-01f, -1.27090275e-01f, 2.34050706e-01f, 2.66535521e-01f,
  -4.71664928e-02f, 8.71504769e-02f, 7.15542585e-02f, -2.15515308e-02f, -1.58278402e-02f, 3.50824036e-02f, 1.45727336e-01f, 1.37848839e-01f, 1.87111050e-01f, 1.24692068e-01f,
  -3.49468254e-02f, -4.99507450e-02f, 1.43318400e-01f, 6.13617264e-02f, 1.46707177e-01f, 1.83488920e-01f, 2.25398853e-01f, 1.76614314e-01f, 1.71769913e-02f, 8.97060484e-02f,
  1.31097659e-01f, 3.01108509e-01f, 7.35810446e-03f, -2.23682463e-01f, -4.86883789e-01f, 1.58426926e-01f, -1.86808184e-01f, 3.28588367e-01f, 2.74846733e-01f, 3.85519654e-01f,
  1.90777376e-01f, 2.23580569e-01f, 1.27416551e-01f, 1.80497363e-01f, -5.71756698e-02f, -1.44863338e-03f, -2.27841601e-01f, -2.88919032e-01f, 1.44684939e-02f, -8.39919448e-02f,
  -3.05244476e-01f, -3.61216515e-01f, -3.98854196e-01f, -3.89463395e-01f, 3.21188182e-01f, 3.90000463e-01f, 2.69156635e-01f, -1.58163324e-01f, 3.64378393e-01f, 9.64725763e-02f,
  2.22958356e-01f, -3.15983325e-01f, 2.80478060e-01f, -5.68849206e-01f, -1.41610727e-01f, -2.65094012e-01f, 6.97426423e-02f, -9.86737385e-02f, 2.28637621e-01f, 4.19703245e-01f,
  3.71272832e-01f, 2.12791085e-01f, -3.21527600e-01f, 1.90376788e-01f, 5.51586272e-03f, -1.65250808e-01f, -1.56759113e-01f, 5.90580702e-02f, -3.10116231e-01f, -1.70176215e-02f,
  -1.74988031e-01f, -1.20672584e-01f, 7.17745051e-02f, 3.85337085e-01f, 2.47636646e-01f, -5.63001871e-01f, -3.77016783e-01f, 3.69441777e-01f, -7.04649031e-01f, -1.21739224e-01f,
  -3.74560386e-01f, 2.68933862e-01f, -7.47742176e-01f, -1.80355296e-01f, -3.33425820e-01f, 3.00440967e-01f, -2.26765629e-02f, -1.05803661e-01f, -1.33199943e-02f, -1.69909537e-01f,
  6.35097504e-01f, 2.57607043e-01f, 6.17434084e-01f, -1.07040241e-01f, -3.94377589e-01f, -4.68349397e-01f, -2.12228388e-01f, 1.67533174e-01f, 1.01400807e-01f, -1.48540601e-01f,
  2.43844464e-01f, 6.56182989e-02f, -1.46050170e-01f, 8.32727253e-02f, 1.94680795e-01f, 5.96315153e-02f, -1.15806825e-01f, 1.32724166e-01f, 2.01176673e-01f, 6.73809275e-02f,
  1.35488346e-01f, -1.07770391e-01f, -1.44370759e-04f, 1.72974709e-02f, 1.44897744e-01f, 1.99514851e-01f, 1.02963433e-01f, 9.95749161e-02f, -9.76110846e-02f, 7.68194646e-02f,
  6.76227957e-02f, 4.11023684e-02f, 2.40078896e-01f, 5.55670820e-02f, 1.17579378e-01f, -1.48173541e-01f, 1.86604172e-01f, -2.04751819e-01f, 3.95885929e-02f, 1.85786217e-01f,
  1.94512248e-01f, -3.97907235e-02f, 8.98103788e-03f, 2.32217729e-01f, -1.83586776e-01f, -1.92894831e-01f, 1.28568262e-01f, 2.95688049e-04f, 1.07931467e-02f, 2.82913923e-01f,
  2.71088183e-01f, 2.60898381e-01f, -4.38180566e-02f, 1.30447865e-01f, -3.95791717e-02f, 1.36942834e-01f, 3.31751794e-01f, 1.91367976e-02f, 1.52245879e-01f, 2.67657369e-01f,
  -3.08649857e-02f, 1.00700215e-01f, 3.06253254e-01f, -1.42507806e-01f, 5.28405495e-02f, -2.51097590e-01f, -2.47454971e-01f, 4.21041757e-01f, 1.17817134e-01f, 1.30786851e-01f,
  -4.31592762e-01f, -2.84497619e-01f, 5.02284884e-01f, 2.17643529e-01f, -3.31138402e-01f, 9.44025740e-02f, 3.71809959e-01f, -4.19104248e-01f, -1.16865374e-01f, -2.68802047e-01f,
  4.76461142e-01f, -9.31227133e-02f, 1.66960895e-01f, -4.27997828e-01f, 2.19618812e-01f, 2.70798981e-01f, 5.60709089e-02f, 2.84169942e-01f, 2.92250752e-01f, 4.17446822e-01f,
  3.69753987e-02f, 4.11581427e-01f, 2.88148224e-01f, -1.51846856e-01f, 1.03389405e-01f, -1.11410871e-01f, 3.76882672e-01f, -1.27691925e-01f, 4.35716331e-01f, 3.37771893e-01f,
  3.93141776e-01f, 1.65869281e-01f, -1.49355829e-01f, -2.46314093e-01f, 1.54915199e-01f, 3.47215086e-01f, 3.66015315e-01f, 3.76979262e-01f, -5.03302753e-01f, 4.03515995e-02f,
  1.80953264e-01f, -1.95150182e-01f, -2.85512179e-01f, 2.12754924e-02f, -3.64659607e-01f, -5.05362093e-01f, 2.89030731e-01f, 5.95452547e-01f, 4.05823380e-01f, -6.90703034e-01f,
  -1.33245774e-02f, -6.61014736e-01f, -2.87881911e-01f, -3.57471466e-01f, 2.63961971e-01f, 2.25325227e-01f, -6.36992902e-02f, -3.50493014e-01f, -3.85693997e-01f, -1.67821199e-01f,
  3.32523227e-01f, 5.51781133e-02f, -3.75160456e-01f, -1.65853396e-01f, 1.71013087e-01f, 2.81142712e-01f, -4.07765567e-01f, -5.78988612e-01f, -1.41141191e-01f, 1.66536316e-01f,
  1.44312307e-01f, -2.66510665e-01f, -1.69275269e-01f, 6.11130372e-02f, 1.79686323e-01f, 9.55522209e-02f, 3.72660607e-02f, 6.84377924e-02f, -6.35335743e-02f, 9.23899934e-02f,
  7.76210502e-02f, 1.46838143e-01f, -1.51017204e-01f, -1.74601555e-01f, 1.42452687e-01f, -1.69997424e-01f, 9.49378312e-02f, -1.43058136e-01f, 6.81754798e-02f, -1.82425395e-01f,
  -1.61066473e-01f, -3.41225266e-02f, -8.73699263e-02f, 8.59947056e-02f, 1.13295540e-01f, -1.05779823e-02f, -1.49500012e-01f, 2.05752030e-01f, -2.70661920e-01f, 8.14936683e-03f,
  -4.31908555e-02f, -2.88030249e-03f, 1.76864952e-01f, -1.41684473e-01f, -2.28419695e-02f, -2.60512263e-01f, 5.96395433e-02f, -2.07833424e-01f, 1.00187503e-01f, 1.68944612e-01f,
  1.59805804e-01f, -2.44476795e-02f, -1.13912754e-01f, -1.61627397e-01f, 7.51422867e-02f, 4.71078418e-02f, -2.20737338e-01f, 1.64095029e-01f, 2.34247744e-02f, -1.14810504e-01f,
  1.68293603e-02f, -1.03514530e-01f, 3.84130448e-01f, -4.31566626e-01f, 4.68261652e-02f, -1.35489598e-01f, -3.32863122e-01f, 1.73293352e-01f, -2.78066009e-01f, -4.20315355e-01f,
  -6.56418055e-02f, -5.03760390e-02f, -6.62377328e-02f, 3.88645709e-01f, -3.07552725e-01f, 2.50411630e-01f, 2.40543440e-01f, -3.09545606e-01f, 6.75308406e-02f, 2.78933316e-01f,
  3.49262416e-01f, 7.09329247e-02f, 3.03156286e-01f, 1.55879222e-02f, -2.84732014e-01f, -1.56761155e-01f, 5.33334501e-02f, -1.43374562e-01f, 1.20811481e-02f, 1.58169150e-01f,
  -3.05546552e-01f, 2.28899688e-01f, -2.59137094e-01f, -1.71607345e-01f, -4.48401749e-01f, -4.24662828e-01f, 2.12224558e-01f, -4.37211335e-01f, -3.14685374e-01f, 1.80940926e-01f,
  -2.21825868e-01f, -1.60322994e-01f, -3.89285743e-01f, -4.17434484e-01f, -3.31861734e-01f, -3.92817974e-01f, 3.46491516e-01f, -4.30125803e-01f, -3.25701475e-01f, -1.26616284e-01f,
  -2.34353468e-01f, 1.19098634e-01f, -3.98534797e-02f, 4.74738562e-03f, -9.98156369e-02f, 4.72137839e-01f, -4.96551454e-01f, -3.96029830e-01f, 4.63059932e-01f, -7.27849305e-02f,
  -5.13640419e-02f, -7.84845427e-02f, -4.04648297e-02f, -3.92397523e-01f, -3.39172065e-01f, -2.41548583e-01f, -4.90590066e-01f, -2.08658397e-01f, -3.20863754e-01f, -3.71727943e-01f,
  -3.85538548e-01f, -4.68248099e-01f, -2.43622556e-01f, 1.03974357e-01f, 6.53573811e-01f, 4.43317294e-01f, 6.26031160e-02f, 2.89111561e-03f, -5.11949733e-02f, -2.08892539e-01f,
  1.88692473e-02f, -7.84592927e-02f, -2.17693169e-02f, -1.31125897e-01f, -2.69972891e-01f, 5.37897572e-02f, 3.26400772e-02f, -7.24371597e-02f, 7.32218176e-02f, -4.37705256e-02f,
  -8.80204141e-02f, -4.53669615e-02f, -2.11118534e-01f, 1.12724245e-01f, -7.26519153e-03f, -6.64373860e-02f, -1.67859241e-01f, 4.48452011e-02f, -3.86134386e-02f, -1.63840607e-01f,
  -2.08330944e-01f, -1.76967800e-01f, -3.92277056e-04f, 3.90223265e-02f, -1.39827460e-01f, -1.87932074e-01f, -3.91073637e-02f, -2.18715906e-01f, -2.89386418e-02f, -1.91098869e-01f,
  -3.11488628e-01f, -1.96321934e-01f, 7.35447928e-02f, 7.13744983e-02f, 1.65078063e-02f, 7.72056505e-02f, -1.33079877e-02f, -1.88513964e-01f, -3.20125781e-02f, 1.13061167e-01f,
  2.35807057e-02f, -3.40031758e-02f, -1.29288226e-01f, -9.17266607e-02f, 2.38800831e-02f, -2.84858961e-02f, -3.49253006e-02f, -1.47241876e-01f, -2.79978424e-01f, -9.31321383e-02f,
  -1.38637215e-01f, 4.20095809e-02f, -2.86194354e-01f, 1.30903557e-01f, -1.00778356e-01f, 2.19373211e-01f, 6.31172061e-02f, 1.33048251e-01f, -2.75336027e-01f, -9.58048031e-02f,
  -2.45355945e-02f, -2.58012414e-01f, 1.94739267e-01f, -1.99294180e-01f, 7.03462735e-02f, 2.44241595e-01f, 3.17669690e-01f, -2.61202484e-01f, 3.57780047e-02f, 1.21766917e-01f,
  -2.16031164e-01f, -2.37869218e-01f, 7.86698759e-02f, 1.98496446e-01f, -2.74883747e-01f, 2.51688778e-01f, 1.30316019e-01f, -2.09159240e-01f, 6.77638501e-02f, 1.79492921e-01f,
  1.65695921e-01f, 3.29742938e-01f, 2.83027291e-01f, -3.60600084e-01f, 1.16657913e-01f, 9.18063745e-02f, -6.19126447e-02f, -2.64627665e-01f, -1.14119895e-01f, -2.05139533e-01f,
  -5.56692779e-02f, 2.12810576e-01f, -1.99693739e-01f, -2.62996346e-01f, 2.81916618e-01f, -1.91494539e-01f, -2.18079746e-01f, -1.75624132e-01f, 1.06615476e-01f, -2.56395608e-01f,
  -2.60944545e-01f, -3.00272644e-01f, -3.44089031e-01f, 2.81179339e-01f, 3.60782892e-01f, -4.66955528e-02f, -3.69609892e-01f, 2.99438357e-01f, 2.12152466e-01f, -4.78160441e-01f,
  8.61703232e-03f, 3.76337379e-01f, 3.26976448e-01f, 4.09618169e-01f, -9.55122709e-02f, 3.20313007e-01f, -3.79104435e-01f, -2.54339695e-01f, -3.84629995e-01f, -1.96460679e-01f,
  -2.11525083e-01f, -2.59619266e-01f, 8.62925947e-02f, -3.01598579e-01f, 2.33914703e-02f, -1.01494697e-04f, -2.31584013e-01f, -6.41848892e-02f, 5.45568392e-02f, -1.43735752e-01f,
  -1.67148933e-01f, -1.70977980e-01f, 4.86079864e-02f, -1.42512321e-01f, 6.51131645e-02f, -4.61947219e-03f, -5.01287617e-02f, 4.14770357e-02f, -1.62398461e-02f, -1.35152116e-01f,
  1.67590100e-02f, 6.19027391e-02f, -1.80087015e-02f, -1.35322839e-01f, 3.62550281e-02f, -1.38463512e-01f, 7.87500441e-02f, -2.28487886e-02f, 6.50046840e-02f, -2.31507242e-01f,
  1.01600423e-01f, 1.27765268e-01f, -2.33837753e-03f, -1.53023144e-02f, -6.47204220e-02f, -2.05358148e-01f, -2.57202536e-01f, 5.19013107e-02f, -1.92566458e-02f, -5.47391400e-02f,
  1.86235849e-02f, -4.98263165e-02f, -2.50541531e-02f, -2.67497264e-02f, 1.46138981e-01f, -8.19395557e-02f, 2.66576465e-02f, 1.76121816e-02f, 4.65329997e-02f, -7.07748607e-02f,
  -1.50574282e-01f, -1.51741682e-02f, -1.02367811e-01f, 5.97412139e-02f, -3.21453512e-01f, 8.48994553e-02f, 5.65546118e-02f, 2.18332991e-01f, -2.30326816e-01f, 1.67422712e-01f,
  -3.59713197e-01f, -2.63268441e-01f, -2.18461901e-01f, -1.34459948e-02f, -3.88051748e-01f, -1.67032108e-01f, -1.88600972e-01f, -1.88830048e-01f, 1.40511721e-01f, 2.99757659e-01f,
  2.21338287e-01f, -2.56051481e-01f, -2.71931142e-01f, -5.54587208e-02f, 2.59952486e-01f, 8.78735781e-02f, -2.25975156e-01f, 3.38270336e-01f, -1.96809247e-01f, 7.17535540e-02f,
  -2.38742605e-01f, 3.75307590e-01f, -1.77456737e-01f, -5.51278554e-02f, -2.12375298e-01f, -8.89087692e-02f, -3.20358396e-01f, -2.94339806e-01f, -1.65963873e-01f, 4.00486328e-02f,
  -1.67703629e-01f, 2.36416355e-01f, -8.49714652e-02f, -2.58002222e-01f, 1.77604347e-01f, -1.32509455e-01f, 1.47870541e-01f, -2.73194730e-01f, -1.92905828e-01f, -1.18334271e-01f,
  8.88921246e-02f, 2.62159228e-01f, 1.66083485e-01f, -2.57845093e-02f, 8.16536173e-02f, -2.55976558e-01f, 4.78735954e-01f, -1.16166189e-01f, 7.54522486e-03f, -4.56618249e-01f,
  -3.02371144e-01f, -8.34575146e-02f, -2.24365026e-01f, -4.24980193e-01f, -5.28792083e-01f, -2.97691196e-01f, 1.54132485e-01f, -3.13480526e-01f, 4.64725465e-01f, 9.98298898e-02f,
  -1.66508704e-01f, -2.98679084e-01f, -1.51165679e-01f, -1.41553074e-01f, -1.92178756e-01f, 3.02711666e-01f, 3.37121665e-01f, 3.47183675e-01f, -3.83716464e-01f, -2.67929137e-01f,
  -1.15975030e-01f, 3.04268301e-01f, 2.05029026e-01f, -1.65433839e-01f, 7.57438689e-02f, 1.87781930e-01f, 1.49789155e-01f, -1.12814121e-01f, -1.95125669e-01f, 1.79634079e-01f,
  8.35229754e-02f, 1.10524587e-01f, 2.13037729e-01f, 1.73336419e-03f, 6.36231899e-02f, -5.53505830e-02f, 6.62247464e-02f, -5.75595722e-02f, 7.12533072e-02f, 3.05122174e-02f,
  7.05100596e-02f, -6.15373626e-02f, -2.24781543e-01f, 9.59877223e-02f, -7.82776698e-02f, 1.10790931e-01f, 1.29539907e-01f, 2.16701254e-02f, -2.45883465e-01f, -7.17097074e-02f,
  1.14030398e-01f, -1.03916340e-01f, -4.48106509e-03f, 5.96042313e-02f, 5.45554236e-02f, 1.03206441e-01f, 3.32960524e-02f, 1.59129277e-01f, -1.59687534e-01f, 7.09251091e-02f,
  1.22234806e-01f, -1.11193536e-02f, 3.10407523e-02f, 1.64521173e-01f, -2.36786846e-02f, -6.02033362e-02f, 9.02261138e-02f, -1.91298544e-01f, 2.05943938e-02f, -6.65567070e-02f,
  -1.63753390e-01f, 1.03934184e-02f, 1.21235199e-01f, 1.62582248e-01f, -3.58914644e-01f, 3.89926523e-01f, -1.37558982e-01f, -1.37546748e-01f, -2.08751217e-01f, -3.96182239e-01f,
  4.09314752e-01f, 6.46847859e-02f, 4.66220379e-02f, 9.93469283e-02f, -4.22593862e-01f, 2.41811231e-01f, 3.88539098e-02f, 1.18948460e-01f, -3.40424091e-01f, 3.75696346e-02f,
  4.36797559e-01f, 4.97644484e-01f, 4.09729928e-01f, -3.31622243e-01f, 7.17435256e-02f, -2.70755559e-01f, 1.46273524e-01f, 6.45334348e-02f, 9.43606794e-02f, -2.96074331e-01f,
  8.83910060e-02f, 1.11393541e-01f, 5.14192760e-01f, 3.19518030e-01f, 2.07319841e-01f, -2.12545455e-01f, -4.40986119e-02f, 4.54978287e-01f, 1.26677498e-01f, -2.28328198e-01f,
  6.93456605e-02f, 3.90894532e-01f, -1.77511439e-01f, -8.61742795e-02f, 1.27786815e-01f, 1.61885664e-01f, 3.88010561e-01f, 3.15010130e-01f, -2.43020684e-01f, -3.11625242e-01f,
  -1.93462059e-01f, -3.04958552e-01f, 7.02136829e-02f, 2.30721772e-01f, -3.41249824e-01f, -6.16110384e-01f, -2.82787591e-01f, -4.19871032e-01f, 4.03612494e-01f, -4.49851185e-01f,
  2.88503885e-01f, -4.96268310e-02f, 1.97848678e-01f, 5.77282190e-01f, -2.06933260e-01f, -1.98666409e-01f, -6.19136691e-01f, -3.13419014e-01f, -3.37818891e-01f, 5.17739542e-02f,
  3.76698256e-01f, -3.83643061e-01f, 6.92151785e-02f, 5.32067657e-01f, -2.97145963e-01f, -3.98943990e-01f, -1.15986191e-01f, -4.88535821e-01f, 9.45435241e-02f, -3.87616783e-01f,
  -1.29592612e-01f, 3.80993262e-02f, 8.21783394e-02f, 5.81968613e-02f, 1.88197494e-01f, -1.10093176e-01f, 1.15819961e-01f, 8.44560713e-02f, -1.23162359e-01f, 2.60282099e-01f,
  2.38691419e-02f, 1.80876598e-01f, 2.59417534e-01f, -1.02849528e-01f, -3.47600281e-02f, -4.01850790e-02f, -6.79308698e-02f, 1.43176354e-02f, 2.21939404e-02f, -1.10130750e-01f,
  1.67770475e-01f, 1.76590402e-02f, -1.33074880e-01f, 1.02838136e-01f, 7.06592854e-03f, 2.33388335e-01f, -4.95595858e-02f, -2.01717578e-02f, 1.23969549e-02f, 8.67364183e-02f,
  -3.20424326e-02f, 3.94299887e-02f, -5.53010739e-02f, 2.36301824e-01f, 1.50990832e-04f, 4.31799926e-02f, -2.44945269e-02f, -7.25083649e-02f, 7.60906115e-02f, -8.74885917e-02f,
  7.60134216e-03f, -3.26949847e-03f, -6.24700934e-02f, 1.90756265e-02f, 2.05805436e-01f, 1.07746728e-01f, 1.73077628e-01f, 1.59373507e-01f, -8.39193389e-02f, 1.52561247e-01f,
  1.41383469e-01f, 3.69333267e-01f, 2.65414834e-01f, 5.26196897e-01f, 1.87306032e-01f, 1.62773579e-01f, 3.90768886e-01f, 2.68806696e-01f, 3.04151356e-01f, -4.14885491e-01f,
  -1.27869457e-01f, 3.25727969e-01f, -2.99025308e-02f, -4.34230596e-01f, 2.92461425e-01f, -1.07788548e-01f, -3.58284026e-01f, 4.10697579e-01f, 3.28159809e-01f, 1.55751973e-01f,
  -2.61786669e-01f, -2.10199103e-01f, -2.91749239e-01f, 2.72808731e-01f, -2.22835943e-01f, 2.42890820e-01f, -1.73083186e-01f, 3.24148774e-01f, -3.92024726e-01f, -3.13948423e-01f,
  1.78509489e-01f, -2.81562090e-01f, 1.69316933e-01f, 2.85730273e-01f, 4.22177553e-01f, 2.18059123e-01f, -2.73268908e-01f, 2.68402308e-01f, -2.78302014e-01f, 1.18167795e-01f,
  3.73123586e-01f, -2.63938934e-01f, -2.38643914e-01f, 4.06095058e-01f, 1.18630603e-02f, 1.59002647e-01f, 2.09363475e-01f, 1.91464752e-01f, -5.51905930e-02f, 4.28260028e-01f,
  -4.80938256e-02f, 1.37838110e-01f, -1.02498889e-01f, -3.24986488e-01f, 4.30058986e-01f, 3.37442458e-01f, -3.42261195e-01f, -2.04200342e-01f, -2.53511935e-01f, 3.12030744e-02f,
  -5.81235945e-01f, -2.15834565e-02f, 1.38593942e-01f, -5.48387706e-01f, -4.78805870e-01f, 1.33363798e-01f, 2.26317376e-01f, -1.02259941e-01f, -3.65197927e-01f, -2.59006381e-01f,
  -3.72329593e-01f, -1.46740302e-01f, -3.51546635e-03f, -2.04407826e-01f, 5.92476666e-01f, -1.44387022e-01f, -1.08452447e-01f, 4.45490390e-01f, -6.52082935e-02f, -7.75787011e-02f,
  6.67763278e-02f, 9.00147706e-02f, -2.18692034e-01f, 1.95747137e-01f, 1.83469534e-01f, -1.97287500e-02f, 3.23985256e-02f, 1.43456813e-02f, -2.01240405e-01f, 2.10372359e-01f,
  -4.88084853e-02f, 2.60827038e-02f, 9.62150693e-02f, 1.38734967e-01f, 1.00650087e-01f, -4.65584919e-02f, 7.71419629e-02f, 2.25588337e-01f, 1.11128815e-01f, 1.04923304e-02f,
  7.46838450e-02f, -7.03903511e-02f, -1.09176211e-01f, 2.02431455e-01f, 6.40473291e-02f, 2.17794910e-01f, 5.51770255e-02f, 1.52753025e-01f, 1.07769102e-01f, 1.54814586e-01f,
  2.35847365e-02f, 3.01075652e-02f, 1.42672092e-01f, 1.37436390e-01f, 1.28403261e-01f, 1.85028151e-01f, 8.84095952e-02f, 7.69124459e-03f, -2.42609799e-01f, -8.72613043e-02f,
  -7.92451110e-03f, -1.89735964e-01f, -2.87577529e-02f, 1.98647231e-01f, -1.44330978e-01f, 1.19437883e-02f, 5.28663248e-02f, -1.82399973e-01f, -8.16461593e-02f, 3.08558434e-01f,
  3.49788249e-01f, -8.86149853e-02f, -2.89489955e-01f, -3.04277033e-01f, -8.40285495e-02f, 1.59232736e-01f, -2.73622066e-01f, 2.40308106e-01f, -2.74171352e-01f, -3.01708430e-01f,
  -1.71053320e-01f, 2.89047092e-01f, 3.96832913e-01f, 8.18129256e-02f, 1.26162812e-01f, -2.00221077e-01f, 3.26087713e-01f, 3.18519384e-01f, -7.69607574e-02f, 2.45573089e-01f,
  -4.12774503e-01f, 9.08493176e-02f, 3.54632646e-01f, 3.32856268e-01f, 1.22671410e-01f, 3.60742137e-02f, 1.27880886e-01f, 2.94297725e-01f, -1.83046371e-01f, -1.05299093e-01f,
  -2.39175886e-01f, 1.56157181e-01f, 2.90905237e-01f, -2.42933929e-01f, -4.92699258e-02f, 1.49228305e-01f, -3.25341642e-01f, -2.98942953e-01f, -2.30511099e-01f, -3.52299452e-01f,
  -2.98045158e-01f, -7.67562957e-03f, -3.31457615e-01f, -3.46441090e-01f, -2.94164270e-01f, -3.90217930e-01f, -1.79563224e-01f, 2.24745765e-01f, -3.30264986e-01f, -2.51835227e-01f,
  4.02753234e-01f, 6.97521791e-02f, -4.55021411e-02f, -4.53501999e-01f, 6.60973042e-02f, -3.97974879e-01f, 2.51355857e-01f, 6.24769747e-01f, -1.97843358e-01f, -2.30644897e-01f,
  -3.50253612e-01f, -2.54645497e-01f, -1.21230081e-01f, -4.89782214e-01f, -4.16204065e-01f, -9.09375772e-02f, -3.20242405e-01f, -4.14142519e-01f, -8.77371058e-02f, -4.03027683e-01f,
  4.74984609e-02f, -2.47878686e-01f, -3.89465451e-01f, 6.44674301e-01f, -3.24825287e-01f, -4.52161551e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -4.31440473e-02f, -6.20205738e-02f, -8.28033313e-02f, -1.17353797e-01f, 5.08724600e-02f, 3.60845514e-02f, -4.60009724e-02f, -2.33548731e-02f, 8.45990051e-03f, -3.61390412e-02f,
  -7.79134482e-02f, -1.51272351e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 51, 26
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    