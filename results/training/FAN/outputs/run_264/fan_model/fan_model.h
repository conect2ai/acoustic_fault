/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  6.24287009e-01f, 3.00822318e-01f, 1.17360771e-01f, 3.22174996e-01f, -5.06704710e-02f, 6.99912608e-02f, 8.37931633e-02f, 6.86654076e-02f, 2.84299314e-01f, 4.39504944e-02f,
  -1.02963224e-02f, 3.01074535e-01f, -7.70203993e-02f, 2.83073097e-01f, 1.32705465e-01f, -1.11978361e-02f, 1.09436229e-01f, 9.34019238e-02f, 6.05833083e-02f, 4.13948372e-02f,
  -1.69533826e-02f, 1.11076847e-01f, 2.75941566e-02f, -7.47567117e-02f, 1.15983456e-01f, 4.03000936e-02f, -1.27130494e-01f, -9.82029960e-02f, -8.57662875e-03f, 1.43139483e-02f,
  9.43155661e-02f, 6.80966601e-02f, 9.89615172e-02f, 5.00922874e-02f, -2.02119518e-02f, 2.73451693e-02f, -5.96810952e-02f, -8.90497956e-03f, -5.68902455e-02f, 4.95903473e-03f,
  5.12003414e-02f, 8.18423256e-02f, 6.71390742e-02f, -1.90820973e-02f, 9.14207473e-02f, 7.16306269e-02f, 5.22471741e-02f, 8.93624406e-03f, -2.23571830e-03f, 2.44036000e-02f,
  4.71310690e-02f, 7.88933225e-03f, -1.89493466e-02f, -1.06862402e-02f, -1.98375229e-02f, 2.86446624e-02f, 2.03942638e-02f, 7.98647944e-03f, -4.30083312e-02f, 5.22734337e-02f,
  -6.08627126e-03f, -3.86215039e-02f, -6.00188859e-02f, 1.03735430e-02f, 4.37499471e-02f, -4.81681488e-02f, -2.79103573e-02f, 2.64303684e-02f, 3.38224396e-02f, 3.15828882e-02f,
  1.40993288e-02f, 2.99524907e-02f, 1.12102078e-02f, -7.30096735e-03f, 9.36725829e-03f, -4.11865488e-02f, -3.04836724e-02f, -2.85903811e-02f, 4.77537550e-02f, -2.68316492e-02f,
  -3.85240540e-02f, -6.70684967e-03f, -4.04514186e-02f, -3.83262224e-02f, -2.21416280e-02f, 1.23265758e-03f, 1.37534635e-02f, 2.85994485e-02f, -8.53148382e-03f, -6.95287734e-02f,
  -5.42121939e-02f, -1.21693820e-01f, -4.99904789e-02f, 3.37755457e-02f, -1.82620790e-02f, -3.59107740e-02f, 1.25708738e-02f, 3.38715166e-02f, 3.17370845e-03f, 2.11908109e-02f,
  -2.96682790e-02f, -7.76916966e-02f, -3.09967324e-02f, 7.34970793e-02f, -7.54629970e-02f, -5.38700400e-03f, -5.96586131e-02f, -1.64798275e-02f, -4.49840240e-02f, 3.26594263e-02f,
  -6.71993056e-03f, -1.03376051e-02f, 4.31367308e-02f, -2.84508578e-02f, 4.41816151e-02f, 1.19287018e-02f, -3.96107361e-02f, 6.29241988e-02f, -6.07485659e-02f, -3.73566849e-03f,
  -1.86510354e-01f, 4.27148826e-02f, 2.41936803e-01f, -1.51106685e-01f, -5.17678335e-02f, 1.87224429e-02f, -7.16975555e-02f, -6.61805123e-02f, -7.19802603e-02f, -6.88757375e-02f,
  -6.82330579e-02f, 8.59183222e-02f, 5.20251915e-02f, -8.03316459e-02f, 3.72033827e-02f, 7.95776770e-02f, 6.76663313e-03f, -3.40082496e-02f, 1.48766264e-01f, -1.52916640e-01f,
  6.03523552e-02f, -1.27977923e-01f, 2.20679492e-01f, -6.24768734e-02f, -4.49467301e-02f, 1.06785089e-01f, -1.35267561e-04f, 1.43310562e-01f, -1.10337637e-01f, 3.62213627e-02f,
  -9.13706347e-02f, -3.49643677e-02f, 3.20909098e-02f, 2.20455620e-02f, -4.45725061e-02f, 7.81381130e-02f, 4.78915721e-02f, 8.28039944e-02f, 9.89374146e-02f, 4.09955205e-03f,
  3.26498896e-02f, 4.08434086e-02f, -1.64880212e-02f, 3.12744565e-02f, -2.28954926e-02f, 5.42380773e-02f, 4.48140465e-02f, -1.60920471e-02f, -1.74651577e-04f, 1.17777847e-01f,
  2.34414334e-03f, -6.41732141e-02f, -1.85684245e-02f, -3.80373746e-02f, 6.82282820e-02f, -8.63006338e-03f, -3.83728370e-02f, 5.89938387e-02f, 6.74787462e-02f, 3.16225849e-02f,
  3.57115492e-02f, 6.28453940e-02f, 7.26301270e-03f, -6.59024809e-03f, -1.00740582e-01f, -8.73052999e-02f, -1.76353604e-02f, -6.36487827e-02f, -2.12483741e-02f, -5.24946488e-02f,
  -7.87454695e-02f, -1.68247782e-02f, -7.49866366e-02f, 7.50145316e-02f, -2.73437006e-03f, -1.08884297e-01f, 1.99831724e-02f, -6.64767399e-02f, -3.49525250e-02f, 1.21136208e-03f,
  -5.43743744e-02f, -1.12363845e-02f, 3.40935029e-02f, 1.59552954e-02f, -4.01299633e-02f, 3.25425975e-02f, 1.56247364e-02f, 7.62950704e-02f, 5.06819300e-02f, 2.67894957e-02f,
  -1.35556012e-01f, -7.74926543e-02f, 1.87386461e-02f, -7.75277019e-02f, 3.24771926e-02f, 2.63488200e-02f, -9.49197076e-03f, 4.08447236e-02f, 1.00850789e-02f, -4.66217995e-02f,
  1.53940264e-02f, -3.35762128e-02f, -4.61323708e-02f, 1.69100538e-02f, 1.86940469e-02f, 7.09479861e-03f, -9.71454680e-02f, -3.21320035e-02f, -1.41774220e-02f, -2.19155345e-02f,
  -5.16911224e-02f, -1.47428792e-02f, 5.41362837e-02f, -2.74476595e-02f, -4.16277163e-02f, -1.67074632e-02f, -4.65328805e-02f, 7.10215867e-02f, 2.59323604e-02f, 3.01277470e-02f,
  1.07277483e-01f, 3.16771299e-01f, 4.38001566e-02f, 3.64920318e-01f, 5.30039147e-02f, 2.42383316e-01f, 3.05291146e-01f, 4.47713882e-02f, 9.14051607e-02f, 1.76005587e-01f,
  1.18969910e-01f, 6.73592091e-02f, 4.32651155e-02f, 4.14078474e-01f, 1.44896284e-01f, 1.46068960e-01f, 2.99212068e-01f, 1.07008085e-01f, -6.57970309e-02f, 9.47213098e-02f,
  8.32040384e-02f, 2.13610783e-01f, 8.99886414e-02f, 3.19627710e-02f, 5.62402569e-02f, -9.38087180e-02f, -8.69054571e-02f, -1.12975925e-01f, 1.00356780e-01f, 2.88895238e-02f,
  1.16314985e-01f, 4.31192294e-02f, 1.06314365e-02f, -5.91937527e-02f, 6.04748130e-02f, -9.30961501e-03f, 8.43606889e-03f, -1.82305742e-02f, -3.58592626e-03f, 1.73066556e-02f,
  -1.37989568e-02f, 1.39180860e-02f, -2.49361480e-03f, 2.15705186e-02f, 3.02917752e-02f, -7.72915930e-02f, 6.87650964e-03f, 2.92189885e-03f, 8.26758891e-02f, 2.78237965e-02f,
  2.98038442e-02f, 7.33745459e-04f, 5.30729583e-03f, 1.49678094e-02f, -6.22278973e-02f, 6.29758909e-02f, 5.24279922e-02f, 9.41318180e-03f, -8.11566412e-03f, 1.13058947e-01f,
  5.03389537e-02f, 5.65062873e-02f, -2.17833295e-02f, 1.28508741e-02f, 8.97609666e-02f, -2.86156754e-03f, 4.29040901e-02f, -5.89330047e-02f, -1.84646621e-02f, 1.99029781e-02f,
  3.20864469e-02f, -4.52699373e-03f, 2.61436007e-03f, -4.48485231e-03f, 1.97731685e-02f, 1.50530608e-02f, -5.47764339e-02f, -1.16685303e-02f, -7.72590237e-03f, 1.03740953e-03f,
  3.30725871e-02f, -1.98873840e-02f, 1.98813602e-02f, -2.35011727e-02f, 1.49818845e-02f, -3.72288488e-02f, 7.91481789e-03f, -1.94151085e-02f, -3.48199680e-02f, 4.44826484e-02f,
  9.61150080e-02f, 1.00034103e-01f, 2.20677014e-02f, 3.41367349e-02f, 1.19257346e-02f, -1.11793801e-02f, 3.13590989e-02f, -2.66391169e-02f, -3.62767354e-02f, -3.25722657e-02f,
  -7.18838116e-03f, 2.44747046e-02f, -2.51191929e-02f, 8.77599872e-04f, -8.15619715e-03f, 1.10388912e-01f, -2.41031591e-02f, -8.56468156e-02f, -4.09067869e-02f, 2.99996641e-02f,
  1.79286655e-02f, -1.89305656e-02f, -5.93045764e-02f, 1.60723478e-02f, -3.74318589e-03f, 2.12616418e-02f, -3.99222560e-02f, 2.41616648e-02f, 2.05105934e-02f, 4.31310758e-03f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.38784003e-01f, -4.71134074e-02f, 2.28167176e-01f, -3.28332394e-01f, 3.26536857e-02f, 6.71230853e-02f, -3.19237560e-02f, -1.05850980e-01f, -1.52994812e-01f, -1.32038176e-01f,
  7.32996268e-04f, 7.38610402e-02f, 2.45079979e-01f, -1.10140048e-01f, 1.99768096e-01f, 2.86340594e-01f, -1.58396959e-01f, -9.02869925e-02f, 6.53025089e-03f, -5.44906594e-02f,
  -3.07098478e-02f, -8.21164921e-02f, 5.45365214e-02f, 1.30754700e-02f, -8.33792388e-02f, -2.27981389e-01f, -1.03127830e-01f, 2.67869264e-01f, -1.67720854e-01f, 1.51794210e-01f,
  -2.55877465e-01f, -1.57072753e-01f, -1.11957349e-01f, 3.93433981e-02f, -3.61109413e-02f, -4.41673063e-02f, -8.27894658e-02f, 1.05010830e-01f, -5.64301983e-02f, -6.83549372e-03f,
  2.68416815e-02f, 1.17967837e-03f, -8.11835825e-02f, -2.55731866e-03f, -8.37460458e-02f, -4.59702350e-02f, -4.15172614e-02f, 3.81414033e-02f, -2.38262974e-02f, 2.17875317e-02f,
  -2.29136832e-03f, 2.07550898e-02f, -7.97190145e-02f, -8.61363262e-02f, 6.26400560e-02f, -3.76924500e-02f, 1.53048551e-02f, 1.39418328e-02f, -1.11905158e-01f, 2.04694029e-02f,
  -4.73602563e-02f, -7.83923827e-03f, -1.45227080e-02f, 8.93440098e-02f, 6.30561635e-02f, 1.87266208e-02f, -2.45811492e-02f, -2.54795086e-02f, -5.01623750e-02f, -2.02326197e-02f,
  4.29198937e-03f, -5.83309829e-02f, 2.08806042e-02f, -5.21508157e-02f, -7.79114366e-02f, -2.40020212e-02f, 3.31833810e-02f, -3.13452706e-02f, -6.36660829e-02f, 2.54214145e-02f,
  -9.29544494e-03f, 1.28577091e-02f, -5.60067073e-02f, -7.12282881e-02f, -1.76833794e-02f, 4.77706268e-02f, -7.30565265e-02f, -5.06334826e-02f, 2.10475568e-02f, 5.38702607e-02f,
  -1.87238410e-01f, -2.65706271e-01f, -4.26670872e-02f, -8.99381340e-02f, -2.08778679e-02f, -2.48075500e-02f, -2.44220775e-02f, -2.63258200e-02f, -7.94519857e-02f, -3.46073322e-02f,
  -6.41113445e-02f, -2.83395015e-02f, -3.36329229e-02f, 8.66577402e-03f, 8.03019032e-02f, -7.09879398e-02f, -4.02057394e-02f, -6.29399642e-02f, -7.36414194e-02f, 7.24244490e-03f,
  7.45117813e-02f, -6.73472136e-02f, -4.95705381e-02f, -4.67898101e-02f, 3.27071622e-02f, 6.32488821e-03f, -9.37946960e-02f, -3.65232378e-02f, 1.38112660e-02f, -3.61751169e-02f,
  4.52980511e-02f, 1.87385485e-01f, 1.59362882e-01f, 9.52582955e-02f, -4.31775674e-02f, -2.22820297e-01f, -2.51324624e-01f, 1.73776403e-01f, -1.03762656e-01f, -8.14781412e-02f,
  -1.70306750e-02f, 5.34187891e-02f, -6.07639812e-02f, -2.04598963e-01f, -2.48304069e-01f, -1.82291314e-01f, -1.61160618e-01f, -1.33785903e-01f, -1.52192071e-01f, 9.72721651e-02f,
  6.33225292e-02f, -5.46059944e-02f, 1.35946512e-01f, 1.20747639e-02f, 6.68488666e-02f, 2.50329435e-01f, 2.56822824e-01f, 1.13293089e-01f, 6.47604316e-02f, -7.21388310e-02f,
  -1.97604045e-01f, 4.10131812e-02f, -3.09837032e-02f, -7.39410743e-02f, -1.07669001e-02f, 3.88669521e-02f, 7.09797591e-02f, -5.61691932e-02f, -1.71501171e-02f, 5.41156568e-02f,
  1.60570778e-02f, 1.05257466e-01f, -1.21250225e-03f, -1.10441588e-01f, -2.55056657e-03f, -2.92667728e-02f, -8.24215822e-04f, 9.26178396e-02f, -2.37953686e-03f, 7.14098141e-02f,
  9.32818428e-02f, 4.95828092e-02f, 2.13900097e-02f, -7.27425665e-02f, 2.31882511e-03f, -4.03120667e-02f, 3.62132825e-02f, 1.21620387e-01f, 3.58309709e-02f, 2.71614343e-02f,
  6.62613884e-02f, -2.85466239e-02f, -5.35212234e-02f, -4.55980189e-02f, -1.24818692e-02f, -3.52967436e-05f, -8.44266415e-02f, -5.71102947e-02f, -1.01049632e-01f, -2.58443523e-02f,
  6.91635981e-02f, -1.84206255e-02f, -9.40755159e-02f, -5.03083952e-02f, 1.12274989e-01f, -4.14449312e-02f, 9.60596930e-03f, 3.91261019e-02f, -3.54733393e-02f, 3.22691463e-02f,
  -1.03793591e-02f, 6.08549826e-03f, 9.38071907e-02f, -6.49072379e-02f, -2.87447125e-02f, 1.31416544e-01f, 3.38720977e-02f, 2.21228488e-02f, 8.96830410e-02f, -3.40760197e-03f,
  9.54256207e-02f, 1.83084115e-01f, 4.70372103e-02f, -8.72927830e-02f, 2.72463970e-02f, -7.98316151e-02f, -2.43463926e-02f, -1.51925338e-02f, 1.17239691e-02f, -6.37036562e-02f,
  -3.70487734e-03f, 5.00940643e-02f, 3.29750106e-02f, -2.39133649e-02f, -3.98124866e-02f, 2.57402863e-02f, -1.36113307e-03f, 5.22274375e-02f, 8.68174189e-04f, 6.65176883e-02f,
  1.12521321e-01f, 5.97205125e-02f, -1.56401526e-02f, 3.86343570e-03f, 1.06183127e-01f, 1.22515149e-01f, -2.83127129e-02f, 1.02523290e-01f, 1.54915648e-02f, 1.13280425e-02f,
  2.89016128e-01f, -7.86889076e-01f, 1.87519059e-01f, 3.31096768e-01f, 2.17528164e-01f, 1.09120868e-01f, 2.85454422e-01f, -2.61001796e-01f, -1.23869516e-01f, -5.30725300e-01f,
  2.69652833e-03f, -1.10183703e-02f, -2.52136678e-01f, -6.51717931e-02f, 4.21215832e-01f, -8.97380710e-02f, 1.35774417e-02f, 6.86456487e-02f, -1.77013561e-01f, -1.12097580e-02f,
  7.07716942e-02f, 5.88070136e-03f, 1.39156088e-01f, -2.02346414e-01f, 1.07117847e-01f, -3.55215482e-02f, 1.80721477e-01f, 2.99131796e-02f, 2.33108457e-02f, 1.75695896e-01f,
  -1.44260019e-01f, -1.03728816e-01f, -4.93541919e-02f, -8.09614360e-02f, -1.09923191e-01f, -3.53981704e-02f, 4.72720005e-02f, 1.47105440e-01f, 5.81475012e-02f, -1.77872125e-02f,
  -1.02459621e-02f, -4.62053604e-02f, 7.70515651e-02f, 3.64005789e-02f, -4.48159948e-02f, -3.96585651e-02f, 1.91128235e-02f, -3.98499668e-02f, 1.64503604e-02f, -5.08290790e-02f,
  -1.12706900e-01f, -1.55683355e-02f, -8.38780031e-02f, -7.04610255e-03f, 6.34743497e-02f, 3.84557806e-02f, 7.79046640e-02f, 7.35958368e-02f, -5.71033098e-02f, -1.91240571e-02f,
  3.29905562e-02f, -1.39710298e-02f, 1.08010257e-02f, -4.01779339e-02f, 6.55930564e-02f, -1.32417046e-02f, -3.39178205e-03f, 3.61655839e-02f, 7.08452314e-02f, -6.62820637e-02f,
  1.25394017e-02f, 1.66977439e-02f, 1.88610964e-02f, -2.84495112e-02f, 4.32059988e-02f, -5.15364110e-02f, -7.32274214e-03f, -2.09819544e-02f, -2.62196567e-02f, 1.71505101e-02f,
  4.27880295e-04f, -1.49718970e-02f, -3.69204991e-02f, 6.02530465e-02f, 4.55808360e-03f, 7.05415159e-02f, -5.39549291e-02f, -8.13902617e-02f, -1.70440022e-02f, 4.11545821e-02f,
  -4.84901667e-01f, -3.09223473e-01f, -2.08275877e-02f, -1.83503926e-02f, 4.29837592e-02f, -4.74267565e-02f, 8.69553834e-02f, -4.05318365e-02f, -5.18806092e-02f, -3.46329808e-02f,
  -4.70926538e-02f, 7.18144104e-02f, -7.57090226e-02f, 3.76567952e-02f, 3.45540531e-02f, -3.72412950e-02f, 2.19550766e-02f, -1.50289910e-03f, 6.63326541e-03f, -5.79770207e-02f,
  -2.58107614e-02f, -9.11192410e-03f, 6.09697811e-02f, -1.38998376e-02f, -1.45266661e-02f, 4.70991544e-02f, -1.61722284e-02f, -1.97564680e-02f, -1.38370343e-03f, -4.50502373e-02f,
  1.59154013e-01f, 4.17799465e-02f, 9.66832340e-02f, 1.88427597e-01f, -2.18395870e-02f, -9.26107094e-02f, -1.23947725e-01f, 1.94943044e-02f, -1.30789310e-01f, -1.23008145e-02f,
  -4.94166724e-02f, 1.78144455e-01f, -2.27630243e-01f, 1.34430334e-01f, -9.70732644e-02f, -2.78122157e-01f, 8.12458172e-02f, -5.73485903e-02f, -3.27738076e-02f, 5.18410420e-03f,
  -5.53841740e-02f, -6.74742693e-03f, -2.05686726e-02f, -2.32500490e-02f, 9.15432200e-02f, 1.11616723e-01f, 3.73610407e-02f, 7.84858968e-03f, 1.67334080e-01f, -1.86886620e-02f,
  8.83844718e-02f, -4.69443537e-02f, 3.79141420e-02f, 6.63045421e-02f, 3.14834751e-02f, 9.84804481e-02f, 1.13322593e-01f, 2.63489224e-02f, -2.53912061e-02f, -1.13874309e-01f,
  2.08611339e-02f, 9.95520055e-02f, 9.09009501e-02f, -3.47424634e-02f, 8.40367973e-02f, 2.24105418e-02f, 6.12830557e-02f, 8.24734792e-02f, 1.54228797e-02f, -1.88341141e-02f,
  8.77020210e-02f, 4.12136205e-02f, 1.62022486e-01f, 6.55564060e-03f, -4.34143469e-02f, -5.32795675e-02f, -1.35269463e-02f, 2.43141949e-02f, 5.26537858e-02f, 8.01669061e-02f,
  4.62620184e-02f, 5.52461557e-02f, 1.11204432e-02f, 2.10167542e-02f, -6.03885725e-02f, 8.69447216e-02f, -2.04096381e-02f, -1.55131007e-02f, -4.22138907e-02f, -7.88640529e-02f,
  -1.02477157e-02f, 3.58211808e-03f, 8.06768890e-03f, 3.24596688e-02f, -2.41688620e-02f, -2.45009698e-02f, 3.19231078e-02f, -8.08448642e-02f, 3.76386568e-02f, -3.68685387e-02f,
  -1.75868273e-02f, 1.02825984e-02f, -5.09066582e-02f, -7.33028203e-02f, 5.19350283e-02f, -2.03932058e-02f, 6.00036606e-02f, 1.60965417e-02f, 5.53478748e-02f, -1.03118420e-02f,
  3.41015384e-02f, -1.80774465e-01f, -5.62284738e-02f, 2.27984805e-02f, -6.41421527e-02f, 5.06880023e-02f, -4.30875607e-02f, 4.59935144e-02f, -2.39727683e-02f, -6.38092402e-03f,
  1.48197506e-02f, 1.15911588e-02f, -3.76388878e-02f, 4.36981395e-02f, 1.05867237e-01f, -7.64964595e-02f, -2.42612064e-02f, 6.94618225e-02f, 8.00353289e-02f, -3.04022767e-02f,
  -1.47460392e-02f, -8.96703973e-02f, 4.78464849e-02f, 6.57411739e-02f, 1.02367990e-01f, -2.09250282e-02f, 4.71163392e-02f, -7.24746287e-02f, -2.62540765e-02f, -5.91644384e-02f,
  -2.79844314e-01f, 5.25350086e-02f, -2.35190913e-01f, 4.41778488e-02f, -1.43765733e-01f, 1.61542326e-01f, 1.75572902e-01f, -8.00557062e-02f, -8.00980702e-02f, 2.97336102e-01f,
  3.05805385e-01f, -7.86061026e-03f, 1.53641745e-01f, 3.94927740e-01f, 7.07454681e-02f, 1.57038242e-01f, 2.79781342e-01f, 2.67924070e-01f, 8.88700038e-03f, -5.47739975e-02f,
  -6.04131110e-02f, 1.17781602e-01f, 1.14403695e-01f, -2.12211628e-02f, 6.38701916e-02f, -1.68851361e-01f, 9.09378231e-02f, -1.01212211e-01f, 1.01390272e-01f, 9.54838023e-02f,
  7.53344446e-02f, -1.11526037e-02f, -1.45788029e-01f, 2.33171880e-02f, -1.87206082e-02f, -4.72957231e-02f, 4.83914390e-02f, 5.14593944e-02f, -4.36536744e-02f, -7.21553117e-02f,
  2.46467944e-02f, -7.60894939e-02f, -2.95851640e-02f, -4.05757613e-02f, -3.83669324e-02f, 9.66376066e-03f, -6.48614913e-02f, -1.57550648e-02f, -6.81477338e-02f, -9.54639539e-02f,
  -5.20784520e-02f, 3.33841778e-02f, 9.55048203e-02f, 5.18221930e-02f, -5.63810915e-02f, 2.99918745e-02f, -3.83859240e-02f, -3.39127406e-02f, 4.52264771e-02f, -4.57132347e-02f,
  -1.15153484e-01f, 1.93336327e-02f, -4.22419012e-02f, -1.72413886e-02f, -1.05256017e-03f, -7.50174224e-02f, -9.10629705e-03f, 1.84798092e-02f, 5.34179294e-03f, 5.88177592e-02f,
  -3.89922373e-02f, 1.29916243e-05f, 2.05456112e-02f, -1.70877054e-02f, -2.40614805e-02f, 3.49355564e-02f, -4.03669178e-02f, -7.04767704e-02f, -6.54413179e-02f, -1.82510016e-03f,
  6.86170980e-02f, -4.17244211e-02f, 2.12838463e-02f, 9.69204754e-02f, 6.38304502e-02f, -7.53788725e-02f, -1.92232709e-02f, -1.14288636e-01f, 2.25537196e-02f, -1.07925152e-02f,
  2.44589839e-02f, -1.36650026e-01f, 3.45085524e-02f, -2.26198006e-02f, -4.09668684e-03f, -3.91174220e-02f, 1.68580469e-02f, -5.17754219e-02f, -5.17029651e-02f, -1.47165991e-02f,
  3.52294296e-02f, 6.84293956e-02f, -3.51551138e-02f, 9.93355662e-02f, 3.91876251e-02f, 2.07024552e-02f, 1.11688308e-01f, 5.58085442e-02f, 3.76232676e-02f, -1.07564516e-01f,
  -1.20633154e-03f, -2.59186793e-03f, -7.35436529e-02f, -6.94422498e-02f, -2.21523307e-02f, -3.50786410e-02f, -8.12367275e-02f, 4.10929546e-02f, 1.97267774e-02f, 4.16041873e-02f,
  -3.04339498e-01f, 1.34909332e-01f, -6.80530118e-03f, -7.95397814e-03f, -1.02241464e-01f, -3.88389289e-01f, -1.43884912e-01f, -1.40560180e-01f, -3.67822647e-02f, 2.53680162e-03f,
  1.04456641e-01f, 6.14567697e-02f, 1.91040695e-01f, 1.11081665e-02f, -1.35153756e-02f, 7.39811361e-02f, -7.93792158e-02f, -1.77245185e-01f, 8.17778036e-02f, -9.08287689e-02f,
  -1.53963059e-01f, -1.09561756e-01f, -3.71767879e-02f, 1.96726341e-02f, -2.39341274e-01f, 1.49583174e-02f, -6.85146824e-03f, -4.16654944e-02f, -9.62912813e-02f, -6.06628880e-02f,
  -1.00816838e-01f, 9.88473445e-02f, 1.88998636e-02f, -5.96869029e-02f, -1.81966081e-01f, -6.87324777e-02f, -3.47355455e-02f, 5.48949167e-02f, -2.40472574e-02f, 5.55104250e-03f,
  -5.31494468e-02f, -2.09236331e-02f, -7.02000931e-02f, 5.83591908e-02f, 3.15365829e-02f, 4.55715992e-02f, -4.48501967e-02f, -1.49210179e-02f, 1.96782928e-02f, 6.39680326e-02f,
  5.79384230e-02f, 8.08532834e-02f, -5.50326221e-02f, 4.52047167e-03f, -6.75514620e-03f, -9.99006033e-02f, -7.71900732e-03f, 8.54451507e-02f, 6.44146055e-02f, -6.22508116e-02f,
  1.55785559e-02f, 6.91285171e-03f, 7.96250850e-02f, -4.97898145e-04f, 4.40503880e-02f, 1.89102683e-02f, 9.69861373e-02f, -3.64255793e-02f, -6.27594143e-02f, -4.66173403e-02f,
  5.85602596e-02f, 4.02000062e-02f, -6.44570366e-02f, -7.12096244e-02f, -4.48471345e-02f, -9.72297788e-03f, -4.32994664e-02f, -1.04844011e-02f, 3.89379784e-02f, -1.06533945e-01f,
  5.34288660e-02f, -8.51484239e-02f, 6.10522144e-02f, 7.50405565e-02f, 6.77229417e-03f, -1.12422183e-02f, 8.93929973e-02f, 1.05696082e-01f, 1.02428533e-01f, 2.40371693e-02f,
  -2.06922710e-01f, -3.09929531e-02f, -6.43155864e-03f, -1.06748022e-01f, -5.13942875e-02f, -1.31737292e-01f, 2.22631730e-02f, -8.78221169e-02f, -2.52085589e-02f, 8.93495232e-03f,
  -1.22348979e-01f, 3.61439399e-02f, -1.03584662e-01f, 3.45684052e-03f, -2.45071016e-02f, -5.63383102e-02f, 6.83380961e-02f, 4.07337546e-02f, 4.55352254e-02f, 5.41909337e-02f,
  -8.59509334e-02f, -3.52833085e-02f, -2.06178799e-03f, 9.10858214e-02f, -3.72905284e-02f, -9.36665460e-02f, -1.61444657e-02f, -1.51558686e-02f, -4.69672643e-02f, 1.26680895e-03f,
  -1.15044080e-02f, 2.94765025e-01f, 1.58478588e-01f, 9.70004722e-02f, 5.36500961e-02f, -1.29431799e-01f, -1.63208187e-01f, 4.26925793e-02f, 1.53027132e-01f, 5.57255670e-02f,
  -1.02326944e-01f, 3.13587248e-01f, -6.42352179e-02f, -5.03593236e-02f, -3.87255520e-01f, -1.40761092e-01f, -9.17038769e-02f, -1.01613156e-01f, -8.72837603e-02f, -6.56118318e-02f,
  -1.75382778e-01f, -6.76502883e-02f, -2.26723924e-02f, -3.16523127e-02f, 7.34669268e-02f, 1.11605667e-01f, -1.93331853e-01f, 2.52576265e-02f, 8.57449844e-02f, 2.10319664e-02f,
  5.17088361e-02f, 4.09379974e-02f, 1.09944314e-01f, 1.07907884e-01f, -4.93216254e-02f, -2.98160911e-02f, -2.73169819e-02f, -4.02879678e-02f, 3.21314186e-02f, 8.57621804e-02f,
  7.42663145e-02f, 3.40999514e-02f, 1.16841190e-01f, 6.85180351e-02f, 6.29654005e-02f, 7.88362324e-02f, 1.39536798e-01f, 1.09493434e-01f, 1.62515953e-01f, 1.12129301e-01f,
  6.28710240e-02f, 1.33907616e-01f, -1.62609667e-02f, 4.01644930e-02f, -9.43410583e-03f, -4.80174460e-02f, -5.45058474e-02f, 2.72963531e-02f, 2.57332791e-02f, -7.83497021e-02f,
  4.22822312e-02f, -1.69165898e-02f, -4.47697192e-02f, 4.72497270e-02f, -6.78366423e-02f, -1.40430918e-02f, -6.28040060e-02f, 8.09144005e-02f, 3.97988856e-02f, -6.95966780e-02f,
  2.01431056e-03f, -3.37119550e-02f, -5.17921634e-02f, -8.64514410e-02f, -2.67775115e-02f, 4.39181030e-02f, -1.25146210e-02f, 8.33108183e-03f, 4.70660925e-02f, -3.16268392e-02f,
  1.24722458e-02f, 5.56329079e-03f, 7.52104167e-03f, -6.43437915e-03f, 3.23224887e-02f, -8.84171389e-03f, -9.52111278e-03f, -1.60485320e-02f, -6.43083826e-02f, -6.29990920e-02f,
  -1.92139149e-01f, 2.58889906e-02f, 4.64807563e-02f, 7.70168379e-02f, 4.16627713e-02f, -8.85684490e-02f, 3.43928416e-03f, -5.35273319e-03f, -7.95776770e-02f, -9.37641039e-03f,
  -7.90233016e-02f, -4.26387303e-02f, -9.15203169e-02f, -5.67351878e-02f, -8.67996141e-02f, -6.53644558e-03f, -7.44230486e-03f, -8.39357823e-02f, 1.34074865e-02f, 2.88858097e-02f,
  -1.90374311e-02f, 3.91204059e-02f, 2.90684886e-02f, 1.97686087e-02f, -7.46650994e-02f, 4.71792556e-02f, -9.82698351e-02f, 3.53471562e-02f, -7.85094965e-03f, -3.77785116e-02f,
  -1.57925129e-01f, 2.69899607e-01f, 4.11516465e-02f, 7.16633350e-02f, 1.29164591e-01f, -1.88546911e-01f, -7.06679970e-02f, 9.50628966e-02f, -1.15221888e-01f, 7.52604380e-02f,
  -1.07804604e-01f, 4.99969013e-02f, 5.41499741e-02f, -2.04000741e-01f, -3.43373030e-01f, -2.58920938e-01f, -2.18741119e-01f, -1.52140290e-01f, -1.62521899e-01f, 2.26436138e-01f,
  -1.66633844e-01f, -3.26079167e-02f, -1.06528945e-01f, 1.31936416e-01f, 8.95141810e-03f, 1.81962773e-01f, 2.38876358e-01f, 1.29785627e-01f, 8.18996429e-02f, -4.23591062e-02f,
  -5.93569987e-02f, 4.11101989e-02f, 4.90433127e-02f, -8.11493490e-03f, 6.23490140e-02f, 3.05549577e-02f, 3.53481360e-02f, -1.25906438e-01f, -5.17813340e-02f, 2.96150111e-02f,
  6.42801970e-02f, -4.95035248e-03f, -6.38181269e-02f, 3.61944805e-03f, 1.30792884e-02f, 4.25658226e-02f, 4.07209620e-02f, -3.69645581e-02f, -2.07607653e-02f, 1.51457934e-04f,
  2.86343098e-02f, -2.45380029e-02f, -4.04386595e-02f, -1.73862316e-02f, -9.27998200e-02f, 1.30842580e-03f, -5.45916222e-02f, -6.73532765e-03f, -2.23465282e-02f, -2.55295280e-02f,
  -1.52512230e-02f, 2.17634644e-02f, -7.40890279e-02f, -9.64658260e-02f, 9.17838980e-03f, -2.49785581e-03f, -4.07731859e-03f, -2.07153168e-02f, 4.38771844e-02f, 1.50884790e-02f,
  -1.82961803e-02f, -2.05065701e-02f, 8.58186260e-02f, 2.19244752e-02f, -6.56366199e-02f, 4.95123230e-02f, -2.11482923e-02f, 6.14038222e-02f, -1.39259885e-03f, -4.73774336e-02f,
  7.86864087e-02f, -2.29107682e-02f, -4.16810848e-02f, 5.27057564e-03f, -7.07378089e-02f, -4.93991971e-02f, -2.90108211e-02f, -4.95484583e-02f, -4.06375676e-02f, 1.68008935e-02f,
  1.65593624e-01f, 2.84945518e-01f, 5.30250706e-02f, -4.27025892e-02f, -4.41012494e-02f, -5.82271218e-02f, 3.54864448e-02f, 8.77220090e-03f, 9.09080580e-02f, 2.86956150e-02f,
  6.02695718e-02f, 2.10026037e-02f, 2.41307504e-02f, -1.16635282e-02f, -1.38963887e-03f, -7.33162910e-02f, 9.40583497e-02f, -7.25442171e-02f, 1.13944516e-01f, 6.10349560e-03f,
  1.26590759e-01f, -6.18225858e-02f, -1.42254662e-02f, 1.96947176e-02f, 1.51713639e-02f, 9.93777998e-04f, 8.04162174e-02f, 4.77088951e-02f, 1.24450754e-02f, -7.17527419e-03f,
  5.30087054e-02f, -2.01460898e-01f, -9.14461538e-02f, 3.66831601e-01f, -2.29359348e-03f, -2.04006463e-01f, -2.78285533e-01f, 1.81481466e-01f, -1.04244038e-01f, -6.78251162e-02f,
  7.26069584e-02f, -3.19786966e-02f, 2.38581356e-02f, 1.35785192e-01f, 1.96587563e-01f, 7.87254125e-02f, 2.36139685e-01f, -4.98547330e-02f, 1.49542332e-01f, 2.16009021e-01f,
  2.37964734e-01f, 2.86185861e-01f, 1.86033726e-01f, 4.98886071e-02f, 1.14796303e-01f, 1.50135815e-01f, 2.93397695e-01f, 6.22657947e-02f, 2.82297760e-01f, 7.31550977e-02f,
  -2.18150169e-01f, -4.34198901e-02f, -4.70441245e-02f, -5.05124666e-02f, 1.25893593e-01f, 9.48612206e-03f, -2.00048722e-02f, -3.25537622e-02f, -2.70919725e-02f, -3.69553529e-02f,
  -6.31637648e-02f, 1.90811139e-02f, 8.04304481e-02f, 5.43631501e-02f, -9.67729017e-02f, 6.30592480e-02f, -4.33534719e-02f, -1.00230522e-01f, -2.81219259e-02f, 3.04053612e-02f,
  -8.33994802e-03f, -8.66067261e-02f, -5.42926304e-02f, 6.38385909e-03f, 4.30634059e-02f, -5.49768619e-02f, -1.06034158e-02f, 2.65815239e-02f, -5.72572974e-03f, 4.55856547e-02f,
  -3.00097577e-02f, -4.53672856e-02f, 3.91408801e-02f, -5.04040439e-03f, -2.81122532e-02f, 6.95754290e-02f, -8.15418549e-03f, -9.59032308e-03f, 8.25096201e-03f, 6.27986640e-02f,
  1.41548896e-02f, 5.41538857e-02f, -2.03522276e-02f, -1.83313265e-02f, 9.11596641e-02f, -4.24622558e-02f, -1.95468590e-02f, 5.64411990e-02f, -5.31603349e-03f, -2.84335371e-02f,
  -7.18709454e-02f, 3.62977758e-02f, 6.35189563e-02f, -7.13780671e-02f, 6.73985574e-04f, 2.63758078e-02f, 7.36633390e-02f, -5.39191626e-02f, -1.53510198e-02f, 9.09968559e-03f,
  -9.99647425e-04f, 2.77419865e-01f, 6.80974275e-02f, -3.90736535e-02f, 1.58021729e-02f, 7.73403719e-02f, 3.34140658e-02f, -6.82886690e-02f, 8.49238038e-02f, -5.20752445e-02f,
  -5.02161507e-04f, -9.32488814e-02f, -7.15564145e-03f, 1.03143603e-01f, 5.42358458e-02f, 6.13393150e-02f, 8.17817748e-02f, -3.41366082e-02f, 1.11952245e-01f, 1.24784715e-01f,
  1.69726033e-02f, -1.10345986e-03f, 5.65571040e-02f, -9.09463987e-02f, -4.50232215e-02f, -4.15915698e-02f, 1.72219891e-02f, -1.20393531e-02f, 1.26379495e-02f, -4.24865745e-02f,
  -8.45653750e-03f, -2.69981641e-02f, -5.67381680e-02f, -1.15235440e-01f, 6.13670386e-02f, 6.44287914e-02f, 6.82623163e-02f, 4.16079164e-02f, -4.53411974e-03f, 8.32203552e-02f,
  -7.30829835e-02f, -5.53101003e-02f, -7.34860003e-02f, -1.92873374e-01f, -1.30274370e-01f, -1.54263303e-01f, -8.33865032e-02f, -8.88093114e-02f, -1.66783988e-01f, -1.77190162e-03f,
  1.11235622e-02f, -4.94726561e-02f, -2.54782550e-02f, 2.24506836e-02f, 3.16761225e-03f, 1.25874266e-01f, 3.21761407e-02f, 6.22081012e-02f, -2.29675025e-02f, 1.74342263e-02f,
  4.91158031e-02f, -1.36336476e-01f, 9.96481553e-02f, -4.93118949e-02f, 1.32187098e-01f, 1.31800324e-01f, 3.97449248e-02f, -1.42923556e-03f, 2.18150783e-02f, -2.65482664e-02f,
  8.41511339e-02f, 6.60843328e-02f, -3.36626768e-02f, -7.22926483e-02f, 3.34801408e-03f, 1.98943391e-02f, -1.05711468e-01f, 3.25389951e-02f, -9.98096354e-03f, 2.89043784e-02f,
  -7.08028525e-02f, -1.91810355e-02f, -7.17771836e-05f, 6.65642023e-02f, -5.87541871e-02f, 2.38372665e-02f, 2.57726735e-03f, -5.84628470e-02f, 1.93373766e-02f, 4.90506925e-02f,
  -2.99331583e-02f, 4.11007367e-03f, -1.08106703e-01f, 1.52690616e-03f, -9.44364294e-02f, 9.49217826e-02f, -4.95977812e-02f, 9.18724239e-02f, 3.79042178e-02f, -1.18402494e-02f,
  -4.12975624e-02f, 8.59203562e-02f, -6.08743131e-02f, 7.95717537e-02f, 2.65220776e-02f, 5.33321053e-02f, 3.39810736e-02f, 2.72061955e-03f, -4.22089621e-02f, 2.33068485e-02f,
  1.32609624e-02f, -2.31484380e-02f, -6.32545277e-02f, -4.28372882e-02f, 6.27266020e-02f, 1.25673844e-03f, -4.67148609e-02f, 8.23669881e-02f, 2.03504357e-02f, 7.31713176e-02f,
  3.64785530e-02f, 9.01630614e-03f, -4.10904922e-02f, 2.69577187e-02f, 4.68640700e-02f, 2.90838834e-02f, -6.50058314e-02f, 5.75590394e-02f, -2.71612816e-02f, -1.00142933e-01f,
  9.43307877e-02f, 3.29796858e-02f, -2.13845670e-02f, 6.95062205e-02f, -2.74710525e-02f, -1.98646262e-02f, 2.33974680e-02f, 9.97281298e-02f, -2.46901810e-02f, -2.34915619e-03f,
  1.92643348e-02f, -5.24897315e-02f, -4.90776412e-02f, -2.67583299e-02f, -2.33857464e-02f, 7.38079771e-02f, -3.43997702e-02f, 3.12720463e-02f, -6.21658266e-02f, -2.86088753e-02f,
  1.02039883e-02f, -1.07252568e-01f, -1.43992141e-01f, -1.26097620e-01f, -1.13761842e-01f, -1.37473688e-01f, -1.08528912e-01f, -1.26519069e-01f, -1.12887122e-01f, -1.02003016e-01f,
  -1.22589268e-01f, 3.61251831e-02f, 1.44971818e-01f, -1.46090984e-01f, 1.68493181e-01f, 2.20414847e-01f, -7.28569999e-02f, -2.40614656e-02f, 2.21981611e-02f, -1.07179008e-01f,
  -3.41025516e-02f, -1.25476032e-01f, -4.06143367e-02f, 5.89636751e-02f, -5.17358817e-02f, -1.38400039e-02f, 4.62520234e-02f, -1.42291067e-02f, -1.09138250e-01f, -1.02017984e-01f,
  1.86792146e-02f, 6.12270907e-02f, 6.18536100e-02f, 2.29280908e-03f, 5.15493564e-02f, 5.67477383e-02f, -2.62151323e-02f, 6.21567667e-02f, 4.93190922e-02f, -6.91200867e-02f,
  -3.37592475e-02f, 9.81328189e-02f, 7.59484014e-03f, 2.75376812e-02f, -5.68440557e-02f, -1.12434570e-02f, -6.36741845e-03f, -8.96057859e-02f, 2.05105543e-02f, 4.91720997e-02f,
  3.76414098e-02f, 2.65887734e-02f, -5.59242554e-02f, -4.30799313e-02f, -6.08236715e-02f, -2.33274382e-02f, 2.10979022e-03f, -1.80354882e-02f, 2.83714831e-02f, 1.51866535e-02f,
  9.74111352e-03f, 6.21817261e-02f, 3.26324552e-02f, 5.72315305e-02f, -9.06733349e-02f, 1.11101405e-03f, 3.87499854e-02f, -1.35676954e-02f, -4.71997000e-02f, 5.98189011e-02f,
  5.52000850e-02f, -5.25686555e-02f, 1.06769361e-01f, 4.31025885e-02f, -8.21405724e-02f, 4.43081260e-02f, -2.31625289e-02f, 2.14061625e-02f, -8.69982094e-02f, -3.13108526e-02f,
  8.99225697e-02f, 3.63751538e-02f, -4.41821739e-02f, -5.11833914e-02f, 6.79169893e-02f, 1.90221276e-02f, 5.20256124e-02f, 4.27333228e-02f, 3.67512628e-02f, -1.01052910e-01f,
  1.44657530e-02f, 8.74335319e-02f, 6.82832301e-02f, -4.19992171e-02f, 7.79289231e-02f, 3.83941345e-02f, 5.28623462e-02f, -5.68868257e-02f, 5.24649024e-02f, -6.37032464e-02f,
  1.81104224e-02f, 7.65492320e-02f, 4.61750180e-02f, -1.37237161e-02f, -4.92740758e-02f, -3.54745723e-02f, 6.08323067e-02f, -1.59965158e-02f, -7.56823877e-03f, 6.16829954e-02f,
  2.75819693e-02f, -2.28785593e-02f, 1.14218723e-02f, -7.78223798e-02f, -6.50005192e-02f, 6.44489378e-02f, 1.32079627e-02f, 4.31204103e-02f, -6.77769557e-02f, 2.25329883e-02f,
  1.76698491e-01f, -7.55033046e-02f, 1.90341651e-01f, 9.88020077e-02f, 5.64266071e-02f, 5.84557988e-02f, 1.97933763e-01f, 6.63355272e-03f, 2.28556529e-01f, -1.63941473e-01f,
  7.83603080e-03f, -2.08108854e-02f, 4.71168123e-02f, -7.28047043e-02f, 9.77296010e-02f, -9.17756334e-02f, -2.42810808e-02f, -6.90522045e-02f, 1.47006497e-01f, 5.20357490e-02f,
  1.06866859e-01f, -1.58941653e-02f, 5.76449409e-02f, -1.78015843e-01f, -2.92197685e-03f, 2.68019307e-02f, -1.20796032e-01f, 7.74200335e-02f, -9.11330804e-02f, -5.33155426e-02f,
  5.10084024e-03f, -1.62256230e-02f, -6.16414472e-02f, -7.84707889e-02f, 4.93194461e-02f, 4.02728282e-02f, 3.08625735e-02f, 1.57169215e-02f, 6.50437325e-02f, 3.73196676e-02f,
  -6.11480922e-02f, -3.17030363e-02f, -1.24154771e-02f, 8.59938115e-02f, 3.21959555e-02f, -5.55268303e-02f, 6.31135181e-02f, -4.59510908e-02f, -2.07132306e-02f, 1.25016391e-01f,
  5.53783514e-02f, 2.69710459e-02f, -1.55080436e-02f, 4.99967998e-03f, -7.09461048e-02f, 5.15920529e-03f, -2.66304463e-02f, -1.66335125e-02f, 2.12975536e-02f, 2.54714433e-02f,
  -5.84885059e-03f, 5.11457324e-02f, -3.05170715e-02f, -4.98387171e-03f, -5.72988167e-02f, 4.04988453e-02f, -6.25031590e-02f, -3.56518454e-03f, -7.53400624e-02f, 4.97152917e-02f,
  -1.49561176e-02f, 4.44779871e-03f, -1.58157293e-02f, -6.57366663e-02f, 5.55642880e-02f, -8.29651486e-03f, -7.62863681e-02f, 4.23462689e-02f, 2.90471893e-02f, 5.48996702e-02f,
  -1.04284687e-02f, 1.72937440e-03f, -2.43110098e-02f, 7.55997226e-02f, -1.44934282e-02f, -8.87958519e-03f, 2.66614370e-02f, -4.21729088e-02f, 2.48974022e-02f, 4.43912782e-02f,
  -1.35485977e-01f, -5.34492824e-03f, 7.09892763e-03f, -6.43961951e-02f, -5.72658516e-02f, 2.94447001e-02f, -5.27889356e-02f, -1.52573967e-03f, -1.09320739e-03f, -3.80757302e-02f,
  6.75488636e-02f, 6.41628057e-02f, -4.14497666e-02f, -4.02563922e-02f, -7.69375265e-02f, -1.66083686e-02f, 3.76834832e-02f, 3.18696015e-02f, -3.38829197e-02f, -9.59142745e-02f,
  -3.33521552e-02f, 1.46905053e-02f, 8.14183950e-02f, -2.77018268e-02f, -4.59273830e-02f, -1.29515547e-02f, -5.44555904e-03f, 2.81250626e-02f, 1.39490189e-02f, -2.13141972e-03f,
  -4.94432859e-02f, 5.98234497e-03f, 1.33677900e-01f, -5.23386672e-02f, -1.31551540e-02f, 9.72359478e-02f, -1.60344932e-02f, -5.10774180e-03f, -1.06792420e-01f, -8.21395367e-02f,
  1.46828387e-02f, 3.18930037e-02f, -1.05185267e-02f, -1.24452539e-01f, 1.21610858e-01f, -7.39754438e-02f, -8.41204002e-02f, 6.02964684e-02f, 6.01570457e-02f, -4.86164019e-02f,
  1.95531510e-02f, -4.56583686e-02f, -5.37570054e-03f, -2.15133168e-02f, -6.98232651e-02f, 3.92213687e-02f, 3.18351537e-02f, 1.16630435e-01f, 4.31099571e-02f, 2.22501103e-02f,
  1.20557167e-01f, -1.19474530e-01f, 8.73848647e-02f, 5.23316534e-03f, -3.79160419e-02f, 3.21323723e-02f, -2.61078384e-02f, 1.76514816e-02f, 4.86953706e-02f, -3.09409983e-02f,
  6.25675097e-02f, -3.25986370e-02f, -8.49529430e-02f, 4.44613732e-02f, 3.30768637e-02f, 9.23880003e-03f, -7.31569976e-02f, 8.20453539e-02f, -3.54812704e-02f, 5.22493534e-02f,
  8.26028138e-02f, 2.25118082e-02f, -3.49496515e-03f, -8.94006267e-02f, -4.34686877e-02f, -3.52326855e-02f, 3.05133332e-02f, 1.94877349e-02f, -4.15113233e-02f, 2.85335165e-02f,
  -8.69001374e-02f, -9.38237533e-02f, -1.00237966e-01f, -5.26779778e-02f, -3.66714522e-02f, -6.17846334e-03f, -1.37424385e-02f, -1.00489073e-02f, -9.62737799e-02f, 7.12725744e-02f,
  3.62542309e-02f, 2.72314791e-02f, -5.55374995e-02f, -2.41732579e-02f, 9.76732845e-05f, -1.36788404e-02f, -5.99407740e-02f, 5.14703207e-02f, -5.57969743e-03f, 7.81957135e-02f,
  2.84528192e-02f, 9.38371569e-03f, -1.79618038e-02f, -5.55128343e-02f, -5.87524585e-02f, 1.75299626e-02f, 6.52716160e-02f, -4.98499572e-02f, 4.91277091e-02f, 4.71224077e-02f,
  1.07815042e-01f, -1.75503120e-01f, 9.18992758e-02f, 2.36432720e-02f, -8.37019756e-02f, -2.27416884e-02f, 3.88123058e-02f, 2.04096641e-02f, 5.05585223e-02f, -2.16396879e-02f,
  -9.33699426e-04f, -3.55410874e-02f, 7.24854246e-02f, -5.04193082e-02f, 3.70036103e-02f, -6.13482669e-02f, -8.86052009e-03f, 4.07609940e-02f, 5.74456193e-02f, -1.23060551e-02f,
  7.30673969e-02f, -6.00379519e-02f, -1.28400633e-02f, -4.32559028e-02f, -3.98151129e-02f, -5.43518960e-02f, 2.56056264e-02f, 7.51978755e-02f, 5.48042208e-02f, -4.75484058e-02f,
  -1.94128484e-01f, 6.09495863e-02f, -2.48848081e-01f, 2.45989896e-02f, -2.13292226e-01f, -2.75392347e-04f, 9.44087952e-02f, -7.81478062e-02f, 2.10034195e-02f, 3.10258090e-01f,
  1.84029892e-01f, -1.95828434e-02f, 1.90576732e-01f, 1.28330991e-01f, 2.43185032e-02f, 1.50453031e-01f, 1.52315050e-01f, 1.39513299e-01f, -3.51983309e-02f, -1.25824928e-01f,
  -5.99625707e-02f, 5.14172055e-02f, -6.42618388e-02f, -6.20425344e-02f, -1.72723860e-01f, -8.64340886e-02f, 1.50908355e-03f, -1.34183485e-02f, -4.87718731e-02f, -2.14619692e-02f,
  -6.68603405e-02f, 3.10109593e-02f, -7.30860606e-02f, -1.27669215e-01f, -1.35679647e-01f, 2.49634515e-02f, -4.91538793e-02f, -1.09079145e-02f, -2.88155787e-02f, -1.06601469e-01f,
  -1.01439901e-01f, 3.56781110e-02f, 4.13358957e-02f, -2.35200170e-02f, 2.65796781e-02f, -5.65096773e-02f, 5.21331951e-02f, -6.25951961e-02f, -1.31911132e-02f, -7.45727345e-02f,
  -3.32335867e-02f, 6.37407452e-02f, -4.94470075e-02f, 8.07140917e-02f, -2.41458751e-02f, 3.89096998e-02f, 5.22276089e-02f, -3.67398039e-02f, -4.66615185e-02f, -7.65165314e-02f,
  1.05092535e-02f, 2.77325567e-02f, -1.14551494e-02f, 5.99466683e-03f, 4.69915532e-02f, 2.04472765e-02f, -8.62695184e-03f, 3.16968039e-02f, -6.53933138e-02f, -4.79779392e-02f,
  -3.17820460e-02f, -1.06901035e-01f, -8.07056054e-02f, 2.44120751e-02f, 3.71435694e-02f, -1.77686810e-02f, 3.78948711e-02f, 2.20890529e-02f, 3.97616886e-02f, -4.41652499e-02f,
  -1.47267692e-02f, 1.04547106e-01f, 2.59065423e-02f, -7.42840692e-02f, -4.25046496e-02f, 4.17878777e-02f, 5.82152931e-03f, 7.53449127e-02f, 7.29123428e-02f, -8.69600698e-02f,
  8.24540854e-02f, -1.04830600e-02f, -1.22268533e-03f, 6.29825369e-02f, -6.17343262e-02f, 5.28071728e-03f, 7.91593939e-02f, 2.02119537e-02f, 5.72847389e-03f, 3.60113569e-02f,
  -1.01991013e-01f, -9.62141007e-02f, -5.14667630e-02f, -5.87747097e-02f, 2.32812930e-02f, -3.14923301e-02f, -2.79745664e-02f, -1.06965192e-01f, 3.21465135e-02f, -1.18403003e-01f,
  -7.27653652e-02f, 1.24167968e-02f, 6.01208322e-02f, -4.23646197e-02f, -1.48908254e-02f, 5.21435440e-02f, 3.42142582e-02f, -5.69505729e-02f, 2.02033240e-02f, 5.59330620e-02f,
  -1.31931379e-01f, 2.00913385e-01f, 6.34291470e-02f, -4.53441143e-02f, -1.75555814e-02f, 4.85840887e-02f, -7.14588985e-02f, 4.85571586e-02f, 8.04474205e-02f, 1.33267984e-01f,
  5.87510280e-02f, 1.04839973e-01f, 5.00030331e-02f, 2.38737725e-02f, -3.62923443e-01f, -8.44799727e-02f, -1.14103131e-01f, -1.26815513e-01f, 8.13950300e-02f, -6.07510321e-02f,
  -1.81542665e-01f, -7.74025396e-02f, -8.78503770e-02f, 1.51816055e-01f, -2.31678504e-02f, 2.16800943e-02f, -7.29326978e-02f, 7.15689436e-02f, 7.60092586e-02f, 6.12325184e-02f,
  3.53913307e-02f, -4.83705476e-02f, -5.14550284e-02f, -6.01487420e-02f, -9.94299352e-02f, 4.20759022e-02f, 1.16404295e-02f, 2.25746334e-02f, -1.09392844e-01f, 9.45237279e-03f,
  1.51459789e-02f, -2.55952477e-02f, 5.42597175e-02f, 7.05058267e-03f, 1.03510901e-01f, 8.11611265e-02f, 6.09273687e-02f, 6.72480166e-02f, 3.30955274e-02f, -5.78900054e-02f,
  5.62989302e-02f, 1.24260187e-02f, -2.06828713e-02f, 4.26756628e-02f, -5.55903427e-02f, 3.46636921e-02f, 5.01554087e-02f, -1.12036122e-02f, -3.23084891e-02f, 2.14633048e-02f,
  -7.49743208e-02f, -6.89034760e-02f, -3.41306478e-02f, 4.71003242e-02f, 6.40194044e-02f, 3.47102061e-03f, 8.10642838e-02f, -7.69231170e-02f, 5.07735945e-02f, -7.81701729e-02f,
  2.15618387e-02f, -1.19196810e-02f, 2.38732100e-02f, -1.75270010e-02f, 5.62664121e-02f, 6.30076379e-02f, -8.29076394e-02f, -2.11169291e-02f, 1.87216222e-03f, -4.20250511e-03f,
  4.59009036e-02f, 1.11959903e-02f, 5.32099865e-02f, -3.66810709e-02f, 7.52329379e-02f, 5.52931093e-02f, -1.24071278e-02f, 3.03111449e-02f, -2.96692327e-02f, -1.20309882e-01f,
  -1.78601041e-01f, -2.52125617e-02f, -1.56187452e-02f, 1.00823808e-02f, 7.55728111e-02f, -9.40345973e-02f, -1.34497276e-02f, -5.11785373e-02f, 3.98094468e-02f, -1.90050378e-02f,
  -9.67639610e-02f, 4.89523299e-02f, -2.32661758e-02f, -2.35981010e-02f, -4.01860252e-02f, 1.39670009e-02f, -9.09955129e-02f, -3.59689482e-02f, -6.28678501e-02f, 2.00252626e-02f,
  5.41017726e-02f, 4.72390540e-02f, -3.22628021e-02f, -1.61815621e-02f, -8.77170935e-02f, 1.95603780e-02f, -1.06756091e-01f, 2.54239012e-02f, 3.68229896e-02f, 9.86646861e-03f,
  1.56751394e-01f, -1.84446752e-01f, 1.48744613e-01f, 8.72960016e-02f, 2.21599072e-01f, 1.19316883e-01f, 1.43767729e-01f, 9.08274502e-02f, 1.18311472e-01f, -2.67938584e-01f,
  -7.34881014e-02f, -6.10518306e-02f, 1.62210520e-02f, -9.76310670e-02f, 3.32146510e-02f, 2.05681734e-02f, 7.45016709e-02f, -1.23873636e-01f, 8.55581388e-02f, -6.17049076e-02f,
  1.39281824e-01f, -7.02575296e-02f, 5.15025333e-02f, -1.88275754e-01f, -4.47491743e-02f, -6.66305423e-03f, -1.24402083e-01f, 4.93547842e-02f, -6.26742244e-02f, -5.35349697e-02f,
  4.46190871e-02f, -1.78217702e-02f, -9.44254026e-02f, -1.05216570e-01f, -7.76270479e-02f, 5.70491441e-02f, -1.55560905e-02f, -2.82922294e-02f, 7.29777734e-04f, 3.11585683e-02f,
  3.36516947e-02f, -8.71572364e-03f, 8.36010128e-02f, 8.01775977e-03f, 8.24696273e-02f, 5.59952892e-02f, 6.74806312e-02f, 8.25472474e-02f, -3.44322734e-02f, 9.68516544e-02f,
  1.02035515e-01f, 1.77801698e-02f, -3.19855548e-02f, 1.90567859e-02f, 7.48938043e-03f, 6.38260394e-02f, 3.14181596e-02f, -5.28361164e-02f, -3.75602990e-02f, -9.97983068e-02f,
  -9.56145152e-02f, 6.61625564e-02f, -5.99650331e-02f, -1.48724765e-02f, -4.90610413e-02f, 1.23090848e-01f, 2.92739104e-02f, -3.30848470e-02f, 9.90236551e-02f, 4.24589589e-02f,
  -1.02048856e-03f, -9.14689824e-02f, 9.07062218e-02f, -6.38407692e-02f, -5.75023368e-02f, -5.06766513e-02f, 4.56588417e-02f, 4.38055433e-02f, -3.38533968e-02f, 3.70424055e-02f,
  5.31168841e-02f, 6.65855780e-02f, -6.59414381e-02f, -2.54201554e-02f, -9.74966970e-04f, -3.32816318e-02f, 2.89565697e-02f, -4.93284352e-02f, 7.64007047e-02f, 4.13739821e-03f,
  -1.33726224e-01f, -8.75622407e-02f, -9.86114756e-05f, -1.56146856e-02f, -5.37094250e-02f, -7.52255619e-02f, -2.30991766e-02f, -1.03314057e-01f, 2.01082733e-02f, -5.83668612e-02f,
  8.08163173e-03f, 3.63713652e-02f, -8.32137913e-02f, 6.98342174e-02f, -8.42593834e-02f, 5.87016754e-02f, 5.27292117e-03f, -1.21459670e-01f, -8.53172690e-02f, -3.19706872e-02f,
  5.53256571e-02f, -1.70907732e-02f, 4.09484059e-02f, -7.00436085e-02f, -1.13105096e-01f, -4.34883200e-02f, -7.68829733e-02f, 6.16296101e-03f, -5.31121083e-02f, 7.50034116e-03f,
  -2.80338943e-01f, 2.84563541e-01f, 4.77415584e-02f, -9.51892510e-02f, -4.67356630e-02f, -6.68794960e-02f, 1.77591778e-02f, 1.45407291e-02f, 6.09513884e-03f, 2.66063631e-01f,
  -5.59525285e-03f, -1.10424729e-02f, 3.89376916e-02f, 1.13605797e-01f, -4.26803082e-01f, -1.44587174e-01f, -5.91698326e-02f, 2.82929521e-02f, 2.97526959e-02f, -9.33384076e-02f,
  -1.42000958e-01f, 5.30243153e-04f, -2.79592741e-02f, 8.19872394e-02f, 1.10968873e-01f, 9.13216919e-02f, -8.53917841e-03f, -2.74580941e-02f, 8.02922025e-02f, -1.41421139e-01f,
  -7.57503510e-02f, 1.64769571e-02f, 1.07856035e-01f, 1.65886115e-02f, -1.41569078e-01f, -1.17869778e-02f, -3.49777490e-02f, 4.36853734e-04f, 3.72685492e-02f, -4.39320356e-02f,
  -5.25568463e-02f, 5.53721897e-02f, -8.92295316e-03f, -5.95817156e-02f, -2.53365859e-02f, 2.16490757e-02f, 3.48155200e-02f, 3.70378187e-03f, 6.47534803e-02f, 8.24686140e-02f,
  2.51140948e-02f, -5.50494436e-03f, 8.22732076e-02f, -2.42214967e-02f, 4.37162817e-02f, 3.96130122e-02f, -6.57979771e-02f, 8.68819095e-03f, -6.05518892e-02f, -1.83750577e-02f,
  2.97771338e-02f, 8.75508599e-03f, 5.84378541e-02f, -1.65035650e-02f, 8.42230245e-02f, 4.07087849e-03f, 3.91739123e-02f, 6.73516095e-03f, 4.33621667e-02f, 1.30506996e-02f,
  -4.34380695e-02f, 6.40639737e-02f, 5.36423922e-02f, -5.12344111e-03f, 4.40199114e-02f, 4.84628156e-02f, 1.79578643e-03f, -4.70198877e-02f, 5.39535321e-02f, 3.91175337e-02f,
  -4.98584285e-02f, -9.52110514e-02f, -2.57873163e-02f, 3.81504968e-02f, -2.36307047e-02f, -1.75087955e-02f, 3.96754742e-02f, 2.64942702e-02f, -1.09314751e-02f, 2.83367857e-02f,
  -1.79589063e-01f, -1.77856497e-02f, 2.57700123e-02f, -1.99045055e-02f, 5.25489356e-03f, -7.51849636e-02f, -5.68802468e-02f, -3.27699678e-03f, -1.07666053e-01f, -2.00913176e-02f,
  3.24491113e-02f, -2.32958943e-02f, -9.13861841e-02f, 2.61585671e-03f, -7.96943903e-03f, -7.07640573e-02f, -7.33845532e-02f, -7.19995722e-02f, -9.83531401e-02f, -6.99386820e-02f,
  -1.17336735e-02f, -2.00638585e-02f, -3.47367264e-02f, -6.35717288e-02f, 6.54803813e-02f, 2.93578370e-03f, -8.69247038e-03f, -4.13272232e-02f, 1.40452543e-02f, 5.52623309e-02f,
  -4.26826207e-03f, -2.59892493e-02f, -2.77679320e-03f, 1.06148124e-01f, 1.92861464e-02f, -2.47162536e-01f, -1.61479846e-01f, 9.99825541e-03f, -4.42952029e-02f, -1.08385898e-01f,
  -2.23685335e-02f, -5.09522967e-02f, 1.70242786e-02f, 1.27113044e-01f, 5.67495897e-02f, -7.30355605e-02f, 2.28720587e-02f, -3.91431078e-02f, -5.59056140e-02f, -6.68998137e-02f,
  1.02783456e-01f, 7.13509619e-02f, 9.21242014e-02f, 1.18200958e-01f, 1.18436620e-01f, 8.31285268e-02f, 1.01783551e-01f, 4.30321805e-02f, 1.36451498e-01f, 7.30743185e-02f,
  -2.17953175e-02f, -3.94803006e-03f, -7.00865611e-02f, 1.03904657e-01f, -3.76069173e-02f, 1.98890250e-02f, -8.46285224e-02f, 5.46238199e-02f, 1.04673252e-01f, -7.27470964e-02f,
  3.48888375e-02f, 2.97167823e-02f, 1.23372793e-01f, -4.51523736e-02f, 8.31559524e-02f, 6.13276064e-02f, 1.94433816e-02f, -1.79809406e-02f, -8.76654685e-02f, -4.02424298e-02f,
  -3.29333171e-02f, 1.31558403e-02f, 1.81164611e-02f, 2.90132426e-02f, -6.53112084e-02f, 2.81562451e-02f, 1.34818405e-02f, -3.66139039e-02f, 1.48992790e-02f, 3.85097712e-02f,
  -1.18526556e-01f, -6.15141280e-02f, 1.20924888e-02f, 3.59031633e-02f, 5.93550727e-02f, -5.01713268e-02f, -2.02859752e-02f, -5.86064272e-02f, 9.72348079e-02f, 3.97246405e-02f,
  6.13207333e-02f, -8.00490528e-02f, 5.82218207e-02f, -7.79403150e-02f, -5.52629530e-02f, -4.18678336e-02f, -7.25075454e-02f, -6.19832724e-02f, -6.13503382e-02f, 3.85867953e-02f,
  -5.67564964e-02f, 5.69224730e-02f, 5.80930412e-02f, -2.90905628e-02f, 3.68836448e-02f, -7.87037164e-02f, 2.56872289e-02f, 6.32141531e-02f, 3.20578516e-02f, 9.13108811e-02f,
  -8.84917751e-02f, 4.95315120e-02f, -2.17015930e-02f, -1.46808093e-02f, 3.38410214e-03f, -5.27770929e-02f, 5.05029038e-02f, 1.09302975e-01f, 5.56350052e-02f, -7.90241435e-02f,
  -8.51811543e-02f, -5.94381876e-02f, -4.18822840e-02f, 1.89807788e-02f, 1.38950512e-01f, -8.11172649e-02f, -3.20580639e-02f, 5.36842681e-02f, 8.30414072e-02f, -6.75271675e-02f,
  -7.86408335e-02f, -5.64600751e-02f, 4.39388901e-02f, -3.89548088e-03f, 5.14419691e-04f, -8.19977522e-02f, 5.55498526e-02f, 2.24404130e-02f, -6.20169342e-02f, 1.70330405e-02f,
  -1.40520722e-01f, 3.96921933e-02f, 3.55536580e-01f, 9.48068798e-02f, 2.02719420e-01f, 3.64387393e-01f, 3.41697425e-01f, 1.03226088e-01f, 3.60872090e-01f, -1.72966421e-01f,
  -2.36837044e-01f, -8.84450600e-02f, 1.36208860e-02f, -2.14995623e-01f, 1.72472954e-01f, 1.83274999e-01f, 1.32329509e-01f, -3.01384814e-02f, 1.37241125e-01f, -7.09844306e-02f,
  -3.87902535e-03f, -1.59846142e-01f, -3.70837152e-02f, -1.59263387e-01f, -1.26609981e-01f, -6.18150905e-02f, -2.36984760e-01f, 5.17891906e-02f, -2.25663453e-01f, 8.59807357e-02f,
  -9.26965196e-03f, 7.50024393e-02f, -1.17909871e-01f, 4.29611467e-02f, -1.56247774e-02f, -3.71047556e-02f, -4.23997454e-02f, 7.07443850e-03f, -6.48172572e-04f, 1.26325048e-03f,
  -1.06564879e-01f, -1.10968500e-01f, 2.70492062e-02f, -4.89104539e-02f, 8.45363215e-02f, 2.00782111e-03f, 6.84026927e-02f, -3.85031328e-02f, -1.05509683e-02f, 6.12071604e-02f,
  -3.47166769e-02f, 1.95080247e-02f, -4.42936365e-03f, 4.51518744e-02f, -2.02086512e-02f, -1.77196823e-02f, 3.83038111e-02f, 4.04134616e-02f, 1.16612492e-02f, 8.80037099e-02f,
  8.79267007e-02f, 9.80071574e-02f, 7.63113890e-03f, -7.69453943e-02f, -1.81506295e-02f, -1.24587171e-01f, -3.94920297e-02f, -4.26548123e-02f, 4.23034653e-02f, -1.31892100e-01f,
  -6.68084770e-02f, -5.18689975e-02f, 8.79202411e-02f, 2.83587836e-02f, 3.61169726e-02f, -1.26760667e-02f, -5.04032187e-02f, -2.34003384e-02f, 3.83488089e-02f, -1.85158607e-02f,
  3.89797729e-03f, -1.48807466e-02f, -1.89713687e-02f, -1.53663801e-02f, 7.54874274e-02f, 6.57917559e-02f, -7.85538033e-02f, 2.01132577e-02f, -4.71456023e-03f, -4.44399975e-02f,
  6.42604902e-02f, 2.37356097e-01f, -1.78283751e-02f, -1.28385469e-01f, -2.31692325e-02f, -1.70632258e-01f, 8.75640661e-02f, -3.95744108e-02f, 1.50481060e-01f, 2.54555400e-02f,
  5.21758571e-02f, 2.13903524e-02f, -1.42798275e-02f, 1.24623924e-02f, 4.42340039e-02f, 1.16311805e-02f, 3.44920382e-02f, 1.96153261e-02f, 5.24563268e-02f, -5.86455278e-02f,
  -6.80874214e-02f, -2.26328038e-02f, -2.59031076e-02f, -4.89381999e-02f, -2.60299370e-02f, -5.16041219e-02f, 7.86441118e-02f, 2.69381255e-02f, 6.81824377e-03f, 5.95800914e-02f,
  -2.90731877e-01f, 1.95854202e-01f, -1.24185957e-01f, -1.80045843e-01f, -5.08955680e-03f, -2.64647424e-01f, -1.95436478e-01f, 3.02273091e-02f, 7.61266798e-02f, -4.39028107e-02f,
  -1.85585581e-02f, -1.03468053e-01f, 7.55120963e-02f, -1.11528002e-01f, -8.46683085e-02f, 7.36992061e-02f, -2.37323806e-01f, -1.90195199e-02f, 5.77661134e-02f, -1.73793092e-01f,
  -6.43819943e-02f, -2.00107135e-02f, -4.43356223e-02f, 6.19898997e-02f, -2.36726359e-01f, -1.31839991e-01f, 4.97139245e-03f, -3.13835815e-02f, -1.53899655e-01f, -7.58120371e-03f,
  -1.82734549e-01f, -1.63068980e-01f, -1.16710640e-01f, 1.98535603e-02f, -8.11441839e-02f, -3.59969065e-02f, -1.35096386e-01f, 4.24939804e-02f, -1.23806149e-01f, -6.55435473e-02f,
  5.58768748e-04f, -4.75470535e-02f, 2.59730350e-02f, 4.13838439e-02f, -1.27242468e-02f, 5.64638898e-02f, 4.00768705e-02f, -6.86863810e-02f, 5.16109690e-02f, -6.09854497e-02f,
  -3.94794308e-02f, 2.15463266e-02f, -9.24552828e-02f, -2.29487568e-02f, 3.09409271e-03f, 6.79081678e-03f, 5.22211380e-02f, 7.79812690e-03f, -1.14344783e-01f, 3.54105532e-02f,
  5.83607852e-02f, -3.66164595e-02f, 4.98933494e-02f, -3.65436636e-03f, -4.92795594e-02f, 5.77976108e-02f, -1.63800921e-02f, 7.10534230e-02f, 5.20359874e-02f, 4.92299870e-02f,
  -4.98543158e-02f, -1.30664542e-01f, 5.27536049e-02f, -5.10020144e-02f, -9.05383099e-03f, -4.25636731e-02f, -3.73747796e-02f, -1.24374893e-03f, 2.62619965e-02f, 5.27982488e-02f,
  -2.51972005e-02f, 2.05675751e-04f, 7.14280754e-02f, -4.22762632e-02f, -4.12716754e-02f, -2.97075212e-02f, 1.29740927e-02f, -6.28393367e-02f, -8.60261172e-02f, -7.66160339e-02f,
  -1.67986482e-01f, -1.91167712e-01f, -8.00994709e-02f, -8.44663531e-02f, -3.39232534e-02f, -5.74439578e-02f, 4.00686869e-03f, -1.23912543e-01f, -3.85531597e-02f, 2.32328717e-02f,
  -3.92546020e-02f, 2.37457491e-02f, -1.30767878e-02f, 2.10621450e-02f, -3.60987708e-02f, -5.69629073e-02f, -2.01190747e-02f, 1.64569523e-02f, -1.27298206e-01f, -6.88252449e-02f,
  -3.35533218e-03f, -2.24638730e-03f, 1.27255842e-01f, -3.22908945e-02f, -4.70054485e-02f, -6.38103262e-02f, -4.06889319e-02f, -5.43243662e-02f, -6.34051934e-02f, 7.37947761e-04f,
  -1.20580509e-01f, -4.56870906e-02f, 5.89308031e-02f, -2.53013708e-02f, 5.47519475e-02f, 2.65493896e-02f, -8.27361941e-02f, -3.86068597e-02f, -2.65654968e-03f, 6.12964593e-02f,
  1.69540700e-02f, 5.74671924e-02f, 1.16442360e-01f, -8.38642940e-02f, -1.21191844e-01f, -1.28089130e-01f, -1.83367386e-01f, -8.83462057e-02f, -9.48012099e-02f, -6.32536784e-02f,
  -1.09728567e-01f, -7.53730461e-02f, -3.40056308e-02f, -6.06671683e-02f, -6.96467981e-02f, 1.24987341e-01f, 8.64431486e-02f, 1.50844067e-01f, 9.84926894e-02f, 6.89679086e-02f,
  9.71138403e-02f, -5.65955415e-03f, 4.70306203e-02f, 7.13699535e-02f, 2.88383476e-02f, 2.42909882e-02f, 1.23590054e-02f, -2.05677357e-02f, 5.01916744e-02f, -9.10364371e-03f,
  -2.61962358e-02f, -1.94841791e-02f, 4.31759395e-02f, 5.66555792e-03f, -1.02969203e-02f, 6.18775282e-03f, 6.39177486e-02f, -3.75749730e-02f, -3.08590960e-02f, -7.19993636e-02f,
  -1.78604554e-02f, 3.56830917e-02f, -8.60417634e-02f, 5.52099943e-02f, -1.10217780e-01f, 5.59172146e-02f, 9.67704318e-03f, 1.69325080e-02f, -6.12798631e-02f, 4.46881130e-02f,
  -4.24166359e-02f, -5.34593710e-04f, 1.20952278e-02f, -2.42271870e-02f, -8.72815847e-02f, 3.45959663e-02f, -7.60253444e-02f, -9.21249203e-03f, 5.27598336e-02f, 6.40462264e-02f,
  -5.23802545e-03f, 8.21218416e-02f, 9.22691673e-02f, 1.10914679e-02f, 1.67876936e-03f, -7.49972761e-02f, 7.79291764e-02f, 1.16743997e-01f, -8.12672973e-02f, -5.55693582e-02f,
  1.72465816e-02f, 8.58383402e-02f, 2.90195141e-02f, 5.68816178e-02f, -2.71979393e-03f, -2.52378304e-02f, -3.62354778e-02f, 1.22541286e-01f, -4.98375529e-03f, -2.09269859e-02f,
  7.58550093e-02f, -5.26890233e-02f, -9.25311819e-03f, 8.35607350e-02f, 6.73452616e-02f, -3.97847407e-02f, -4.33531478e-02f, -7.19986856e-02f, 8.94265324e-02f, -8.01060051e-02f,
  7.84902275e-02f, 5.19044399e-02f, 7.46729970e-02f, 1.02694191e-01f, 7.20036449e-03f, -1.63003244e-02f, 3.14879939e-02f, 1.11415491e-01f, -4.61670570e-02f, 7.36055849e-03f,
  1.15732185e-03f, -4.56830226e-02f, 1.04117692e-02f, 2.80020002e-04f, -5.05829975e-02f, -4.29925248e-02f, -4.24864218e-02f, -5.08672604e-03f, -4.80192862e-02f, -7.27006048e-02f,
  5.90563864e-02f, 5.31561673e-02f, 1.10987410e-01f, -1.01365194e-01f, 1.46855437e-03f, 1.45232707e-01f, 8.09354186e-02f, 4.82421815e-02f, 5.80669343e-02f, -1.27902371e-03f,
  -1.24526590e-01f, 5.34369349e-02f, -5.32397032e-02f, 6.43451065e-02f, -4.94813081e-03f, 7.32894912e-02f, -1.59068860e-03f, 2.53533293e-02f, 8.11181143e-02f, 1.70498401e-01f,
  -4.59388867e-02f, -3.09719760e-02f, -7.88518693e-03f, 8.93533826e-02f, -2.18585208e-02f, 1.46391783e-02f, -2.26082489e-01f, 4.90272269e-02f, -1.07826725e-01f, -1.37798131e-01f,
  -2.49161702e-02f, -3.98876928e-02f, -1.00786248e-02f, 8.96710902e-02f, 7.54190609e-02f, -8.89829919e-02f, -5.98294958e-02f, -8.75675306e-03f, -5.36355264e-02f, 4.06001024e-02f,
  5.71541041e-02f, 9.24543068e-02f, -2.56233122e-02f, 5.78724220e-02f, 9.22339037e-02f, 3.47925425e-02f, -5.92371300e-02f, 2.13911384e-02f, 8.54479056e-03f, 2.15593558e-02f,
  1.29744470e-01f, -2.69362726e-03f, 1.08287558e-01f, -6.71373382e-02f, 4.68992116e-03f, -7.21936151e-02f, 5.21874130e-02f, -3.18580903e-02f, 4.38530669e-02f, -6.49436191e-02f,
  -1.30532878e-02f, -3.24014090e-02f, 3.24288644e-02f, 1.12511925e-02f, 2.99587548e-02f, 7.59722367e-02f, 6.35950044e-02f, -6.93353415e-02f, 6.37560943e-03f, 1.91449169e-02f,
  3.56882513e-02f, -5.61372600e-02f, 1.15078673e-01f, 1.01416729e-01f, -7.52431452e-02f, 2.36585028e-02f, -7.42116049e-02f, -1.49909491e-02f, 9.02846083e-02f, -4.85338345e-02f,
  2.44979486e-02f, -2.40749866e-02f, -7.31740296e-02f, 4.03547660e-03f, 5.29325567e-02f, 7.36129296e-04f, -2.16473080e-02f, -1.71125010e-02f, -1.10689968e-01f, -1.26715070e-02f,
  4.59662601e-02f, 4.64990549e-02f, 8.00851509e-02f, 6.23911694e-02f, 4.25168611e-02f, 5.59622534e-02f, 9.83397216e-02f, 6.12746812e-02f, -1.67292953e-02f, 1.85564682e-02f,
  -1.73723977e-02f, 1.10722639e-01f, -2.99517363e-02f, 8.28550383e-03f, 6.72496334e-02f, -5.38720330e-03f, 7.31117874e-02f, -2.51083709e-02f, 9.29784961e-03f, -8.86256769e-02f,
  -4.10485640e-03f, 2.23820638e-02f, 8.61182902e-03f, -7.77029768e-02f, 1.34240547e-02f, -4.76564988e-02f, 8.13387427e-03f, 5.71421124e-02f, -4.45744470e-02f, 3.04224063e-02f,
  1.49505362e-01f, -1.45928219e-01f, -1.62530810e-01f, 1.76970795e-01f, 6.16073757e-02f, -1.60757348e-01f, -2.88356364e-01f, 8.15767273e-02f, -2.49887079e-01f, -7.72802457e-02f,
  2.13364944e-01f, -9.26814675e-02f, -1.43195495e-01f, 2.08868280e-01f, 2.51473367e-01f, -1.32596880e-01f, 2.46041819e-01f, 1.21012934e-01f, -6.87326640e-02f, 9.59714279e-02f,
  2.09541470e-01f, 2.87398189e-01f, 1.18522726e-01f, 1.44781649e-01f, 3.95756550e-02f, 8.10504332e-02f, 3.49503249e-01f, -7.66811669e-02f, 2.51679987e-01f, 1.19621322e-01f,
  -7.39181265e-02f, 5.69138415e-02f, -9.22631919e-02f, -5.80012985e-02f, 3.42998914e-02f, 3.25740688e-02f, -6.53247237e-02f, 5.48727587e-02f, 6.82568876e-03f, 7.99137428e-02f,
  -1.61296874e-03f, 6.97790086e-02f, -6.76195547e-02f, 8.75029638e-02f, -1.18939183e-03f, -1.05712734e-01f, 2.32959166e-03f, 1.52896857e-02f, -6.03718273e-02f, 8.48660152e-03f,
  -1.04799666e-01f, 5.80231883e-02f, 6.25185072e-02f, -6.25739843e-02f, 3.06490883e-02f, 7.08178524e-03f, -2.74767503e-02f, -1.14718024e-02f, 3.01131960e-02f, 1.51240770e-02f,
  6.84494749e-02f, 1.92815904e-03f, 2.96209380e-02f, -3.24507169e-02f, 5.59887476e-03f, -5.06959520e-02f, 1.63636599e-02f, -2.10095048e-02f, -8.06653053e-02f, -2.89101223e-03f,
  1.10079050e-02f, -2.35071927e-02f, 1.11246385e-01f, 1.00983400e-02f, 9.76277795e-03f, -3.39299813e-02f, 1.91088673e-02f, -9.88671370e-03f, -1.64999291e-02f, -2.12887768e-02f,
  6.18083682e-03f, 1.61114410e-02f, -8.14835429e-02f, 6.99470788e-02f, 9.31875221e-03f, 3.50031890e-02f, 1.34345829e-01f, 2.40501463e-02f, 2.80537317e-03f, -3.04822102e-02f,
  1.82506576e-01f, 1.82054266e-01f, -1.03925437e-01f, -3.43616493e-02f, -9.29366201e-02f, -1.25456322e-02f, -4.95196506e-02f, 9.75995138e-02f, 3.22419554e-02f, 1.98929291e-02f,
  3.63711230e-02f, 1.83233656e-02f, 7.09229186e-02f, -8.51480365e-02f, 6.01792224e-02f, 5.70133403e-02f, -6.51690587e-02f, -4.12896089e-03f, -7.42239086e-03f, 2.31096037e-02f,
  5.22026755e-02f, 1.82768330e-02f, -4.51416783e-02f, -9.45486054e-02f, -5.12510492e-03f, 4.40524817e-02f, -1.06697462e-01f, 1.07799983e-02f, 3.09760659e-03f, -6.72940165e-03f,
  6.56472325e-01f, -1.60731867e-01f, -1.12943657e-01f, 9.21097025e-02f, 2.44458824e-01f, 1.80704415e-01f, 1.23919167e-01f, 1.83032051e-01f, 2.68657714e-01f, -5.39399609e-02f,
  4.37596068e-02f, -1.34089321e-01f, -2.17078701e-01f, -5.19952029e-02f, 6.34544194e-02f, -9.57303271e-02f, 1.85441762e-01f, -3.06980088e-02f, 9.27512124e-02f, 6.27786517e-02f,
  1.94702387e-01f, 1.76037967e-01f, -2.32826382e-01f, -1.43774766e-02f, 1.82258248e-01f, 2.53287777e-02f, -1.35545552e-01f, -1.28362522e-01f, -1.24490857e-01f, -4.27806973e-02f,
  -8.85244273e-03f, 6.45088181e-02f, -2.14184728e-02f, -1.22382157e-02f, -5.41628525e-02f, 2.36883610e-02f, -2.59908978e-02f, -2.84860246e-02f, 5.32790162e-02f, -1.46074025e-02f,
  -9.56646279e-02f, 4.61449102e-03f, 1.26599856e-02f, 1.75971072e-02f, 8.28408375e-02f, -9.88623966e-03f, -4.32747975e-02f, 4.84676510e-02f, -6.32948056e-02f, -9.11430642e-02f,
  -8.41879547e-02f, -1.55177182e-02f, 2.83353776e-02f, -1.46220654e-01f, -1.30363358e-02f, -2.13310197e-02f, -3.27800005e-03f, -1.00499451e-01f, 1.55523680e-02f, 9.05432999e-02f,
  3.83686535e-02f, 4.88260575e-02f, 3.49187963e-02f, 1.33418709e-01f, 3.08655798e-02f, 3.52373533e-02f, 8.09816942e-02f, -7.63025656e-02f, 6.09167758e-03f, -7.27909654e-02f,
  5.99716008e-02f, -1.64323803e-02f, -2.85120383e-02f, 2.35455539e-02f, 2.40705013e-02f, -2.36501843e-02f, 2.53348574e-02f, -1.47224870e-03f, -1.41522214e-02f, -1.32730335e-03f,
  -2.23678704e-02f, 2.42435858e-02f, -1.66550670e-02f, 2.17908043e-02f, -1.02340363e-01f, -2.42895968e-02f, -3.03329546e-02f, 4.95317318e-02f, -5.12449741e-02f, 1.71699200e-03f,
  1.93769624e-03f, -1.12300754e-01f, 1.02343597e-02f, -3.06550711e-02f, -5.15590496e-02f, -1.93481538e-02f, -3.63627747e-02f, 4.16150056e-02f, -9.19178948e-02f, 7.79589117e-02f,
  1.79080991e-03f, 4.17187158e-03f, 1.63645819e-02f, -8.57402831e-02f, -1.56616084e-02f, 3.51373665e-02f, -1.21906232e-02f, 1.83049478e-02f, -4.48188074e-02f, -5.62696047e-02f,
  -6.16923906e-02f, -4.18473855e-02f, 7.87984766e-03f, 1.33682743e-01f, 6.03849674e-03f, -3.26290242e-02f, 2.38924660e-03f, -4.28378172e-02f, -8.29150528e-02f, -7.35745057e-02f,
  -1.02438126e-02f, -1.91795871e-01f, -2.75917411e-01f, -1.90390453e-01f, -2.45431915e-01f, -2.41662726e-01f, -1.49572924e-01f, -7.80716911e-02f, 5.82902655e-02f, 6.25047982e-02f,
  -5.97895011e-02f, 1.94177151e-01f, 2.99037665e-01f, -1.86549872e-01f, 1.89581200e-01f, 3.59616697e-01f, -2.61701226e-01f, -1.33918598e-01f, -8.81502870e-03f, -1.82731330e-01f,
  -1.68968528e-03f, -1.65860370e-01f, 6.22247681e-02f, -1.49791196e-01f, -2.94192106e-01f, -1.74323902e-01f, -1.94483753e-02f, -2.63522938e-02f, -2.54130185e-01f, 4.08836491e-02f,
  -2.76480187e-02f, 1.06886975e-01f, -1.67335987e-01f, 9.95503087e-03f, -8.13903958e-02f, -3.99791114e-02f, -3.64138521e-02f, -2.39988621e-02f, -6.05201116e-03f, 7.46089220e-02f,
  3.35449800e-02f, 8.70245323e-02f, 3.02695390e-02f, 5.65460883e-02f, -6.98607191e-02f, -2.81152707e-02f, 1.68772154e-02f, 2.58395821e-02f, -5.37324362e-02f, -2.92206630e-02f,
  -1.35449804e-02f, -9.98943150e-02f, -1.02691874e-01f, 2.19852384e-02f, -2.86806300e-02f, 2.60025845e-04f, 2.37926729e-02f, 3.56105566e-02f, -2.61853752e-03f, -3.29881534e-02f,
  -1.84465833e-02f, -1.46329533e-02f, 2.67901737e-02f, -3.93859111e-02f, -3.65308225e-02f, 4.21852171e-02f, -5.54189719e-02f, 1.08708248e-01f, 2.73102783e-02f, 6.44770393e-04f,
  -5.35267312e-03f, 4.69205454e-02f, 1.94730889e-02f, 3.61376852e-02f, 1.67833138e-02f, 2.24075429e-02f, 5.54850809e-02f, 5.78491054e-02f, -5.05458824e-02f, -3.40492763e-02f,
  7.84873441e-02f, -4.92033437e-02f, 2.20295042e-02f, 2.14978401e-02f, -1.94493141e-02f, 3.07621658e-02f, -2.62183733e-02f, 4.09499705e-02f, -3.59778628e-02f, 7.11960644e-02f,
  -3.49587873e-02f, 9.30485576e-02f, 5.22388518e-02f, 1.02144666e-01f, -2.80914828e-02f, 3.87807004e-02f, 4.77194525e-02f, 2.71693002e-02f, 2.26475503e-02f, 5.85725866e-02f,
  -1.56058967e-02f, 1.95931904e-02f, -7.55514354e-02f, -2.70526558e-02f, -5.40570244e-02f, 4.42727357e-02f, 2.14111712e-02f, 3.87857966e-02f, -7.59310797e-02f, -7.70289525e-02f,
  8.41222778e-02f, 2.83485074e-02f, 9.79040563e-02f, 2.95770522e-02f, -6.29265374e-03f, -3.45754880e-03f, -6.06962070e-02f, -2.88657621e-02f, 3.97144593e-02f, -3.79692130e-02f,
  -6.77327625e-03f, -2.49606043e-01f, 5.32506779e-02f, 7.26484731e-02f, 3.50911878e-02f, -6.44328296e-02f, -1.87958889e-02f, -1.53577358e-01f, -4.56551537e-02f, -1.93781421e-01f,
  1.05043821e-01f, 1.03673577e-01f, -7.94164389e-02f, 3.33428830e-02f, 2.41853520e-01f, -8.62839147e-02f, -9.35522020e-02f, 1.13921352e-01f, 1.36672601e-03f, -2.47978531e-02f,
  6.01644926e-02f, -4.37348261e-02f, 2.13460121e-02f, -2.33396068e-02f, 2.23699640e-02f, -3.01990658e-02f, -3.09642702e-02f, -1.86542363e-03f, 3.45502794e-02f, 1.31792024e-01f,
  -9.81685892e-02f, -2.89833359e-02f, 1.04505839e-02f, 3.85852382e-02f, 6.16831668e-02f, -3.72522161e-03f, 2.79812571e-02f, 8.00842121e-02f, 7.61798176e-04f, -2.10287459e-02f,
  -7.68487975e-02f, 5.22901900e-02f, -2.78024450e-02f, 3.11218258e-02f, -7.12607801e-02f, -7.78442528e-03f, 9.03292559e-03f, -9.06194150e-02f, -1.55458739e-02f, 5.76739572e-02f,
  3.59921530e-02f, 5.43206111e-02f, -1.45222014e-02f, -3.38385324e-03f, -9.44590475e-03f, -1.14948964e-02f, 9.49016947e-04f, 9.14459527e-02f, -1.41042843e-02f, 3.45803909e-02f,
  -3.54329459e-02f, 4.24713269e-02f, -2.56495290e-02f, 4.02692705e-02f, -3.97824422e-02f, 5.40589243e-02f, 9.66111943e-02f, -6.54376522e-02f, -6.73350096e-02f, -8.95547718e-02f,
  -3.29743735e-02f, -4.84449752e-02f, -6.23395629e-02f, -7.89677203e-02f, -8.92478973e-02f, -5.50765134e-02f, 1.07298307e-01f, -1.13428198e-02f, 8.44847634e-02f, -6.99994490e-02f,
  9.64844879e-03f, 4.62857038e-02f, 8.09070542e-02f, 8.76430050e-03f, 3.93395759e-02f, 7.03611504e-03f, 1.29161747e-02f, 5.39930612e-02f, 3.08330879e-02f, 5.18514886e-02f,
  -1.40130356e-01f, -1.98034838e-01f, -1.46948472e-02f, -7.13044330e-02f, -1.26740141e-02f, 6.35390729e-02f, 3.27293277e-02f, -8.82824808e-02f, -1.20355956e-01f, 3.86219770e-02f,
  5.07714003e-02f, 1.35520119e-02f, 1.02251051e-02f, 7.01658502e-02f, 3.54081355e-02f, -1.18209748e-02f, -2.72848085e-03f, -3.89108881e-02f, -4.40229326e-02f, -3.07808742e-02f,
  -5.40108569e-02f, -2.21438501e-02f, 6.49757013e-02f, -2.55526248e-02f, -2.00317707e-02f, 2.78839096e-02f, 1.37297185e-02f, -2.27908418e-02f, -2.27588732e-02f, -1.84629373e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.30554605e-01f, 2.19755709e-01f, 1.57635778e-01f, 1.83849186e-01f, 2.71717042e-01f, 3.22631001e-01f, 5.18319644e-02f, 3.46502483e-01f, 1.80723280e-01f, -1.84209496e-02f,
  6.70523047e-02f, 1.68790758e-01f, -6.30271062e-02f, 1.85782954e-01f, 1.52094215e-01f, 1.29937157e-01f, 2.48801991e-01f, 2.03516241e-02f, 2.80315697e-01f, 1.69908568e-01f,
  -3.55485491e-02f, 1.98558897e-01f, 1.17249846e-01f, 2.31895313e-01f, 2.52647758e-01f, 1.83999669e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -9.33387801e-02f, -2.10412934e-01f, -2.94664837e-02f, 3.51919234e-01f, -6.91498294e-02f, 1.65840939e-01f, 6.02812469e-02f, -2.09321324e-02f, -2.52441287e-01f, -1.41318038e-01f,
  -9.19192508e-02f, 4.97308448e-02f, -1.67650610e-01f, 1.13590816e-02f, 2.77268797e-01f, -1.23752937e-01f, 1.27899991e-02f, 1.78563461e-01f, -7.76469558e-02f, -3.96266542e-02f,
  -2.68327445e-01f, 5.74817285e-02f, -3.85421395e-01f, -4.66960557e-02f, 2.47968689e-01f, -6.24394044e-02f, -2.71598160e-01f, 1.67187482e-01f, -9.01147872e-02f, 2.44131193e-01f,
  2.25964069e-01f, -6.77158237e-02f, -1.50691286e-01f, -4.57581133e-02f, -2.20872700e-01f, -1.87114939e-01f, -8.04154053e-02f, -1.28282174e-01f, 5.17154671e-02f, 7.95498490e-02f,
  -2.33663067e-01f, 2.10633099e-01f, 1.45724639e-01f, 1.31015062e-01f, 6.32116124e-02f, 3.13497096e-01f, 3.73642258e-02f, -4.58643921e-02f, -9.05441120e-02f, -1.38662815e-01f,
  -6.87076524e-02f, 3.24734151e-02f, -9.23431441e-02f, -2.21542880e-01f, 1.64999232e-01f, -1.51038915e-01f, -4.71510179e-02f, 4.12622243e-02f, -4.62352559e-02f, -2.65591056e-03f,
  1.09984636e-01f, -2.25859553e-01f, -1.32377297e-01f, -2.36284360e-01f, 3.96958478e-02f, 8.00027251e-02f, -5.54722026e-02f, -1.25934973e-01f, 1.94533318e-01f, 7.35841412e-03f,
  1.41351566e-01f, 6.34236187e-02f, 2.60495901e-01f, -9.51198936e-02f, 1.73849806e-01f, 1.89341530e-01f, -8.12887773e-02f, 9.88914967e-02f, 1.01498072e-03f, -1.83625847e-01f,
  -4.70893234e-02f, -1.48788840e-01f, -1.02640763e-01f, 1.64174587e-01f, 1.77976280e-01f, -1.33555353e-01f, 7.64216706e-02f, 1.75336689e-01f, -8.60518292e-02f, 5.33169582e-02f,
  3.27900685e-02f, 5.67532610e-03f, 1.69732854e-01f, -3.81167293e-01f, 2.64917821e-01f, 1.20578557e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -3.92879620e-02f, -1.00961559e-01f, 8.61125533e-03f, -4.24168399e-03f, 8.76013860e-02f, -2.23015286e-02f, -2.05396377e-02f, -1.40006080e-01f, -1.61246657e-01f, 7.53160417e-02f,
  1.04893232e-02f, -8.67261961e-02f, -1.09428279e-01f, 9.23985019e-02f, 1.12799987e-01f, 1.67799070e-01f, 1.84190199e-01f, -1.57191277e-01f, 1.09325051e-01f, 1.26324788e-01f,
  -3.29375453e-02f, 1.50131211e-01f, 7.92239830e-02f, -1.60835475e-01f, 1.88394710e-02f, 1.14803959e-03f, 1.21345609e-01f, -6.95259348e-02f, 7.34751821e-02f, -1.30052313e-01f,
  -1.61392719e-01f, -8.43917578e-02f, -3.41218486e-02f, 1.24650478e-01f, 6.48441538e-02f, -1.36342332e-01f, -5.20223863e-02f, 5.41182570e-02f, -9.18440074e-02f, 7.34469965e-02f,
  -4.40054126e-02f, 2.73029208e-02f, -1.29141852e-01f, -1.41575057e-02f, 9.85093862e-02f, -1.65801793e-01f, -1.01557687e-01f, -1.61936164e-01f, 8.13397914e-02f, -7.66691864e-02f,
  7.49875829e-02f, 3.39449458e-02f, -2.67804693e-02f, 1.23992570e-01f, -4.70730849e-02f, 9.95789245e-02f, -1.86625756e-02f, 5.77836856e-02f, 1.14059923e-02f, -1.75065875e-01f,
  -1.03360340e-01f, -1.62117481e-01f, 3.55115309e-02f, -4.53006141e-02f, 1.38459466e-02f, 9.46038365e-02f, 3.97500068e-01f, 1.78229734e-01f, 1.86117217e-01f, 2.18989968e-01f,
  1.49845362e-01f, 1.09465018e-01f, 3.58016223e-01f, 7.19654784e-02f, 7.60983303e-02f, -4.96344790e-02f, 6.12100996e-02f, -9.37106311e-02f, 1.22276604e-01f, 1.51995227e-01f,
  -1.71442986e-01f, 2.84221649e-01f, 1.06939480e-01f, -5.76143339e-02f, 2.51846481e-02f, 1.48773834e-01f, 1.75049156e-01f, -2.24938318e-02f, 2.92454898e-01f, 5.22336364e-02f,
  -1.23787962e-01f, 1.17154457e-02f, -1.78484380e-01f, 1.26721924e-02f, -6.87202513e-02f, 7.62069821e-02f, 4.10868466e-01f, 1.41381487e-01f, 3.34322393e-01f, 9.70334262e-02f,
  1.20377034e-01f, -8.04684088e-02f, 4.04730022e-01f, -2.42283810e-02f, 4.30633396e-01f, -2.93989982e-02f, -2.02263758e-01f, 2.64680594e-01f, 9.62892845e-02f, -3.16307656e-02f,
  2.24798303e-02f, -1.36281699e-01f, -6.09586015e-02f, 1.55865923e-01f, 3.46227027e-02f, 7.41524575e-03f, 4.78212945e-02f, 1.54410109e-01f, -1.10939167e-01f, 1.03855573e-01f,
  4.96659696e-01f, 1.41396880e-01f, 3.65313329e-02f, 1.31855905e-01f, -2.17087865e-01f, -3.88804637e-02f, 2.61441320e-01f, -6.16681725e-02f, -5.08663617e-02f, -2.26449389e-02f,
  -1.10994704e-01f, 8.24131295e-02f, -3.21199149e-02f, -1.54264733e-01f, -1.31366357e-01f, -3.40483375e-02f, 1.82265546e-02f, -1.12344339e-01f, -1.55963317e-01f, -1.45544916e-01f,
  5.30607142e-02f, 1.74489617e-01f, -7.84101933e-02f, 1.32379755e-01f, 5.07698022e-02f, -1.65526986e-01f, -1.24714524e-01f, 1.01468131e-01f, 1.55627176e-01f, 1.14398792e-01f,
  1.37707487e-01f, -9.93695930e-02f, -1.39122024e-01f, 8.97002816e-02f, 1.17576018e-01f, -1.67590275e-01f, -9.90627557e-02f, 9.75571647e-02f, -1.25248760e-01f, 1.54487178e-01f,
  2.74226487e-01f, 1.38704330e-01f, 1.39511421e-01f, -3.23606044e-01f, 4.38980341e-01f, 3.61058675e-02f, 6.21927440e-01f, -2.42354095e-01f, 1.67012930e-01f, -2.77437896e-01f,
  2.96811551e-01f, 4.25966561e-01f, -1.18581481e-01f, -1.57300770e-01f, -6.11867420e-02f, -9.10805725e-03f, 3.50924939e-01f, 1.52696073e-01f, 1.94075167e-01f, 3.30096394e-01f,
  1.73237715e-02f, 6.39255941e-02f, -9.74762365e-02f, 1.66016165e-02f, 3.34029347e-01f, 4.41835046e-01f, -2.20799334e-02f, 5.48139736e-02f, -1.96347805e-03f, -3.59633118e-01f,
  5.56734860e-01f, 1.54355139e-01f, 1.79690063e-01f, 1.13271929e-01f, -6.78899139e-02f, -5.21098711e-02f, 1.09495461e-01f, -1.07214786e-01f, -9.02464241e-02f, 1.64178476e-01f,
  -1.15622811e-01f, 7.37145469e-02f, 2.71849930e-02f, 4.43047956e-02f, -1.97570905e-01f, 2.36336172e-01f, 2.90264964e-01f, -1.11016229e-01f, 1.84328184e-01f, 8.49531312e-03f,
  -1.41548067e-02f, 1.39727622e-01f, -1.80649921e-01f, -1.01868071e-01f, -1.06842972e-01f, 9.59849656e-02f, -6.26545101e-02f, -5.40445633e-02f, 1.18570194e-01f, 3.01785544e-02f,
  -1.03621855e-02f, -1.89537629e-01f, 1.11301243e-01f, -2.08732843e-01f, -1.09701313e-01f, 2.86114484e-01f, 2.57793874e-01f, -1.04138188e-01f, 7.28684738e-02f, -2.75410265e-01f,
  -1.41531557e-01f, 3.59969020e-01f, -1.95054144e-01f, 1.10360496e-01f, 7.30041489e-02f, 7.75219202e-02f, -6.38063857e-03f, 3.98403972e-01f, 8.54706913e-02f, 2.93446958e-01f,
  -2.40973637e-01f, 1.30271882e-01f, 7.51662999e-02f, -1.16367549e-01f, 7.85252154e-02f, 1.92129821e-01f, 2.19053105e-02f, 8.23765844e-02f, 1.33547708e-01f, -4.41910997e-02f,
  3.77653055e-02f, 1.71013191e-01f, 1.01737261e-01f, 1.82719320e-01f, -1.55833513e-01f, -1.83280215e-01f, 1.97835431e-01f, 5.04505157e-01f, 3.60820860e-01f, -2.31826216e-01f,
  3.35521400e-01f, -3.61218661e-01f, 3.96991283e-01f, 2.66693771e-01f, 2.29047537e-02f, 3.61313578e-03f, 1.61330730e-01f, 3.30332905e-01f, 4.83451366e-01f, 4.84632194e-01f,
  2.42560044e-01f, 7.05072060e-02f, -9.82601717e-02f, -1.14523925e-01f, -2.69836877e-02f, 2.37693086e-01f, 4.25011426e-01f, -4.15715575e-02f, 5.46093881e-01f, -3.88367064e-02f,
  2.56967526e-02f, 2.92777032e-01f, 8.13985765e-02f, 2.41654485e-01f, 4.15753052e-02f, -3.88792545e-01f, -1.11684859e-01f, 1.11776821e-01f, 2.27948263e-01f, 2.58407891e-01f,
  2.43665408e-02f, -1.90120395e-02f, -2.07055002e-01f, 6.93799034e-02f, -1.26950547e-01f, 8.28968436e-02f, 2.40469426e-01f, -2.16255360e-03f, -3.00432984e-02f, 7.68462867e-02f,
  -1.01332419e-01f, 3.06324869e-01f, 3.96786004e-01f, 2.79496890e-05f, 9.61222053e-02f, 4.69949692e-02f, -4.06582095e-02f, -1.00236416e-01f, 6.10897057e-02f, -1.41295046e-01f,
  -4.97464649e-02f, 2.11064801e-01f, -2.43492573e-01f, -2.92357448e-02f, 1.32188842e-01f, -1.48522794e-01f, 1.02817170e-01f, -2.36847147e-01f, -1.80087283e-01f, 1.05859540e-01f,
  2.92111207e-02f, 1.87297836e-02f, 3.22188526e-01f, -1.07540786e-01f, 3.60980183e-02f, 5.18002734e-02f, 6.08216077e-02f, 1.85152024e-01f, 5.40545166e-01f, 1.94607452e-01f,
  1.05932273e-01f, -4.69698273e-02f, 2.46686470e-02f, -8.22840780e-02f, -1.35362118e-01f, -8.99830554e-03f, 3.77149768e-02f, 1.79763764e-01f, 1.63476422e-01f, -1.13085233e-01f,
  -4.39721625e-03f, 1.22334279e-01f, 1.00839101e-01f, -3.08319386e-02f, 1.17046591e-02f, 4.07575555e-02f, -9.66794714e-02f, 4.57208753e-02f, 5.73776364e-02f, 3.18172649e-02f,
  1.23121433e-01f, 2.02962607e-01f, 2.08732009e-01f, 9.38811898e-02f, 4.03372139e-01f, 3.42601299e-01f, 2.67154098e-01f, 7.74752796e-02f, 2.26057231e-01f, -8.07332322e-02f,
  4.55810547e-01f, 2.32918635e-01f, 1.09214626e-01f, 3.72814685e-02f, 2.49376997e-01f, -8.08327198e-02f, -4.84766737e-02f, 3.18816192e-02f, 1.31020069e-01f, 2.75889933e-01f,
  4.43308838e-02f, -4.94453087e-02f, -4.03402895e-02f, 1.31649747e-01f, -7.41500501e-03f, -4.96214665e-02f, 2.36505777e-01f, -1.97111905e-01f, 1.92161605e-01f, 6.98133707e-02f,
  -6.15509376e-02f, 1.86156809e-01f, 1.47636300e-02f, 5.00226617e-02f, 2.08823860e-01f, 1.97072327e-02f, -4.37784120e-02f, 2.68232614e-01f, -9.57595930e-02f, 1.60811663e-01f,
  -4.58390452e-02f, 8.57985541e-02f, -1.06464423e-01f, 5.64803071e-02f, 4.20094997e-01f, -2.31205188e-02f, -4.13883291e-02f, 3.85361873e-02f, 3.70729387e-01f, -9.44639295e-02f,
  1.25836104e-01f, -1.96813062e-01f, -6.80552796e-02f, 8.39374736e-02f, -1.17836565e-01f, -1.29213080e-01f, 1.65386721e-01f, 1.97462589e-02f, -1.05949685e-01f, 8.86119306e-02f,
  -1.05439210e-02f, -1.16384551e-01f, 3.68011117e-01f, 2.32653365e-01f, -8.51394832e-02f, -9.80999321e-02f, 4.99947965e-02f, 1.27975464e-01f, 2.28175923e-01f, 4.32236731e-01f,
  -5.74178137e-02f, 5.89895844e-02f, -1.06332928e-01f, 3.84560764e-01f, 5.04051864e-01f, 3.90920818e-01f, 5.17225228e-02f, -6.41746968e-02f, 1.79157466e-01f, 1.35327518e-01f,
  2.53841281e-01f, 7.64620602e-02f, -8.74779373e-02f, 1.74678773e-01f, 1.33992642e-01f, -3.73789631e-02f, 1.53375138e-02f, 2.13856921e-01f, -6.91422494e-03f, 2.02669203e-01f,
  -1.76441491e-01f, -2.21339867e-01f, -1.22885995e-01f, 4.89752032e-02f, 4.41738635e-01f, 4.54834402e-01f, -2.08511472e-01f, 2.50157177e-01f, 2.42212281e-01f, 1.29446223e-01f,
  -1.53237239e-01f, 1.42279744e-01f, 1.49323018e-02f, -4.04653326e-02f, 2.96631791e-02f, -2.18507815e-02f, -5.05908318e-02f, -9.58522707e-02f, 8.69367644e-02f, 2.89564610e-01f,
  -1.62213333e-02f, -1.13595530e-01f, -1.03201261e-02f, -1.65142626e-01f, 2.20818058e-01f, -9.62619558e-02f, -1.23275697e-01f, 8.83469656e-02f, 1.46461293e-01f, 1.91492260e-01f,
  -1.19514339e-01f, -9.07002389e-02f, -1.64898448e-02f, 3.01229835e-01f, -6.09221719e-02f, -1.02493927e-01f, 1.12792194e-01f, 1.16933569e-01f, 4.18807268e-01f, -1.04256734e-01f,
  2.98354149e-01f, 3.87110651e-01f, 4.81101215e-01f, 4.70963240e-01f, -6.02767877e-02f, 8.29280689e-02f, -5.67354672e-02f, -6.68800250e-02f, 7.97792077e-01f, 2.19871342e-01f,
  3.12972873e-01f, 2.77390480e-01f, 1.60318345e-01f, -6.90810084e-02f, -1.55779049e-01f, -1.33813217e-01f, -1.51455969e-01f, 5.17303646e-02f, -6.42450079e-02f, 1.36599213e-01f,
  5.96915744e-02f, 2.22605109e-01f, 1.58220589e-01f, 2.21165478e-01f, -1.41354993e-01f, -5.46867065e-02f, 2.32173987e-02f, 2.21680384e-02f, -1.96382403e-01f, 5.58500849e-02f,
  -3.45270596e-02f, 1.63494572e-01f, -1.55228406e-01f, 1.79639891e-01f, -1.37257919e-01f, 4.07443680e-02f, -9.83566865e-02f, 1.83113262e-01f, 7.62847345e-03f, -1.14169613e-01f,
  -1.46972269e-01f, -1.03537589e-01f, -2.78839432e-02f, -1.78998217e-01f, 4.78548072e-02f, -1.84967425e-02f, 7.25186244e-02f, -6.68420419e-02f, -2.11111922e-02f, -8.41151848e-02f,
  8.20906013e-02f, 6.95924833e-02f, 3.76566425e-02f, -6.37582168e-02f, -4.92322333e-02f, 1.40405759e-01f, 1.66615143e-01f, -1.20537557e-01f, -6.62247762e-02f, 1.12502754e-01f,
  -8.99606943e-02f, -4.31617983e-02f, -1.36343151e-01f, 2.35286802e-02f, 2.04499364e-01f, 4.95745480e-01f, -3.89166288e-02f, 6.11670077e-01f, -4.84368473e-01f, 7.16015756e-01f,
  -1.65035516e-01f, -2.44656369e-01f, -3.07210326e-01f, 1.70797552e-03f, 5.68951070e-01f, -1.04620911e-01f, -9.32832509e-02f, 4.38393950e-02f, -1.85020491e-02f, -1.27030671e-01f,
  2.83280434e-03f, 6.94222227e-02f, -2.14106753e-01f, 4.59149122e-01f, -2.27115005e-02f, -2.38919780e-02f, 4.28146170e-03f, -5.20622991e-02f, 4.69960213e-01f, -1.92692608e-01f,
  -2.94036359e-01f, 2.08781242e-01f, 3.07339970e-02f, 3.00496399e-01f, 1.95051089e-01f, -3.33180964e-01f, 8.98531824e-02f, -1.37203068e-01f, -1.87769920e-01f, -7.02698296e-03f,
  -1.83051854e-01f, 2.11287990e-01f, -4.41900976e-02f, -8.32412094e-02f, 1.21347077e-01f, 1.05909295e-01f, -5.89646213e-02f, -1.16999216e-01f, 1.12831920e-01f, 1.27467424e-01f,
  2.40351204e-02f, -1.09154202e-01f, -1.79629564e-01f, -1.52361557e-01f, -8.85622874e-02f, -1.03766628e-01f, 1.53075578e-02f, 2.79871747e-03f, 2.91754100e-02f, 1.46206588e-01f,
  1.59402639e-01f, 1.69820279e-01f, -2.34719533e-02f, -1.29776180e-01f, 1.41240567e-01f, 5.04584983e-03f, -4.14442234e-02f, 1.08879276e-01f, 4.18421179e-02f, 2.00256512e-01f,
  2.25073565e-03f, 9.37533975e-02f, -1.08743496e-01f, -6.32367805e-02f, 2.15707511e-01f, 2.52293259e-01f, -4.29906510e-02f, 5.34802191e-02f, -1.34313583e-01f, 3.00896108e-01f,
  3.60404521e-01f, 1.30747125e-01f, 1.40439212e-01f, -1.36871174e-01f, -1.15588913e-02f, 1.38761118e-01f, 3.10809948e-02f, -1.51456565e-01f, 5.64219877e-02f, -1.53908715e-01f,
  3.59692834e-02f, 1.83390796e-01f, -1.43827692e-01f, 9.05557424e-02f, 1.80066198e-01f, -9.98268127e-02f, 1.60027668e-01f, -6.20245636e-02f, 1.53468624e-01f, -1.71756715e-01f,
  5.63340709e-02f, 1.35689095e-01f, 2.02910766e-01f, 1.14244930e-01f, 1.10080719e-01f, 1.91680878e-01f, -8.03813860e-02f, -7.45018497e-02f, -4.36852016e-02f, -4.85095195e-04f,
  -1.10027805e-01f, -1.90664262e-01f, -1.48300201e-01f, -1.22554265e-01f, 1.03349566e-01f, -1.29744262e-01f, 1.33827120e-01f, -2.68518683e-02f, -1.75622374e-01f, 8.66162330e-02f,
  1.27357662e-01f, 2.01799303e-01f, -2.07932130e-01f, 7.84172714e-02f, 3.36678118e-01f, -1.02804549e-01f, -7.38156438e-02f, 2.14180976e-01f, -1.59037545e-01f, 1.27363235e-01f,
  1.23689190e-01f, -9.13815200e-02f, 2.37918124e-02f, 1.40454873e-01f, -6.23041950e-02f, -2.34088916e-02f, -9.33036581e-02f, 2.16940179e-01f, -3.49007584e-02f, 9.80620831e-02f,
  2.53361881e-01f, -1.84926037e-02f, -8.76817037e-04f, 1.94168851e-01f, -5.47191910e-02f, -1.39296979e-01f, 2.29429513e-01f, 1.95019394e-02f, 2.69178361e-01f, -6.63920417e-02f,
  6.12902120e-02f, 7.89901093e-02f, -1.76176786e-01f, -8.95410627e-02f, -2.29165956e-01f, 1.76825486e-02f, 1.79502741e-01f, 6.91243336e-02f, 3.64913046e-02f, 1.92016363e-03f,
  9.97002795e-02f, 1.19312964e-01f, 3.82356942e-01f, -9.08509716e-02f, -5.16736954e-02f, -4.82541919e-02f, -3.56231444e-02f, -2.48882234e-01f, -1.01827323e-01f, -2.74861082e-02f,
  -3.86822410e-02f, 5.23898974e-02f, 2.02818997e-02f, 1.39231728e-02f, 1.34429121e-02f, -5.33832051e-02f, -1.14100955e-01f, 1.06716320e-01f, 7.87612796e-02f, 4.41855714e-02f,
  -6.07933626e-02f, -3.17881480e-02f, -7.85376579e-02f, -8.86940956e-02f, 5.92310429e-02f, 8.27294365e-02f, 4.80601676e-02f, -1.58278197e-01f, -1.87773868e-01f, 3.92855555e-02f,
  -3.47509198e-02f, -9.17323008e-02f, 2.43748724e-02f, -4.65854295e-02f, 5.14858542e-03f, -2.73880921e-03f, -1.16257846e-01f, -1.31718572e-02f, -6.14942387e-02f, -3.54179367e-02f,
  -1.32120952e-01f, -1.06917530e-01f, -1.24015033e-01f, -8.97289217e-02f, 5.98407574e-02f, -1.95450917e-01f, -1.70129940e-01f, -9.62605551e-02f, -1.28139988e-01f, 1.24679983e-01f,
  -4.72175032e-02f, 1.28434137e-01f, -9.01041925e-02f, 1.55320287e-01f, -7.46874660e-02f, 6.09699748e-02f, 8.82377326e-02f, 2.25155234e-01f, 1.07184779e-02f, 5.64939454e-02f,
  -4.15826216e-02f, -4.00869884e-02f, 7.60878921e-02f, -7.00051263e-02f, -1.76739380e-01f, 1.61264628e-01f, 1.04352154e-01f, 9.43807214e-02f, 1.72281519e-01f, 3.21936369e-01f,
  -3.83488387e-01f, -2.55385607e-01f, -4.52505052e-01f, -8.18101540e-02f, 1.19128920e-01f, 3.36471915e-01f, 8.69789496e-02f, 4.43658791e-02f, 3.26440275e-01f, 2.64465958e-01f,
  -7.60018304e-02f, 1.77102566e-01f, 6.45338297e-01f, 3.71581167e-02f, 1.93179518e-01f, -8.06174576e-02f, -2.11546227e-01f, 1.90499440e-01f, -1.96488142e-01f, -2.76919574e-01f,
  -1.05108194e-01f, 2.94997901e-01f, -2.38070905e-01f, 2.56745607e-01f, 7.64939189e-02f, -2.72603303e-01f, 6.73188090e-01f, -3.81744653e-02f, 3.14260632e-01f, 1.33442767e-02f,
  2.35551909e-01f, 1.61179438e-01f, 1.40775397e-01f, -4.08045590e-01f, 4.61503156e-02f, -8.20480734e-02f, 2.25754514e-01f, -3.84384245e-02f, -1.72628373e-01f, -2.17594907e-01f,
  1.17179282e-01f, 3.39903316e-04f, 1.29316345e-01f, 2.31985867e-01f, -3.35472263e-02f, 2.09964186e-01f, 8.25743303e-02f, -1.09939046e-01f, 1.08462283e-02f, 1.71853274e-01f,
  2.26515070e-01f, 1.68704599e-01f, 2.37102598e-01f, 1.61878556e-01f, -1.51462808e-01f, 2.19238818e-01f, 2.02975631e-01f, 5.03178649e-02f, -1.25239477e-01f, -1.02853820e-01f,
  1.02465495e-01f, 1.43240988e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  -6.90080598e-02f, -1.35664418e-01f, 2.82863498e-01f, 2.85277694e-01f, -5.53966425e-02f, 4.64342952e-01f, 1.49609707e-02f, 2.69319117e-01f, 4.11654055e-01f, 9.02741179e-02f,
  2.21405774e-02f, 3.18180174e-01f, -4.90110144e-02f, 1.32619709e-01f, 2.08999187e-01f, 2.86139607e-01f, -1.38056085e-01f, 5.55692494e-01f, -5.56286164e-02f, -4.03843783e-02f,
  1.20617755e-01f, 3.96976732e-02f, 1.18525863e-01f, 5.36388196e-02f, 3.89702171e-01f, 1.05851619e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -4.62266207e-02f, 1.67321384e-01f, 6.97852820e-02f, -2.93581765e-02f, 4.60305989e-01f, 5.29711787e-03f, 7.62173235e-02f, -1.89391766e-02f, -1.24834590e-01f, -1.97806418e-01f,
  1.98220685e-01f, -2.95073539e-01f, 2.92699467e-02f, 6.86216354e-02f, 1.85830802e-01f, 2.71529052e-02f, -4.56016958e-02f, -1.88585058e-01f, 2.21089348e-01f, -1.46765411e-01f,
  1.08495116e-01f, 8.40388611e-02f, 8.25854763e-02f, 2.64736950e-01f, 1.45439237e-01f, 2.15190575e-01f, -1.05553493e-02f, -2.05295920e-01f, 1.19550154e-01f, 9.65091458e-04f,
  1.81303278e-01f, 1.61494017e-01f, 1.98064998e-01f, -1.33862287e-01f, 1.90304622e-01f, 1.90686837e-01f, -6.95410073e-02f, -3.54642957e-01f, -1.08947277e-01f, -1.88097730e-01f,
  -8.21561739e-02f, -1.15467153e-01f, 2.61755791e-02f, -4.59077209e-01f, -2.04353258e-01f, 3.08952868e-01f, -2.13624686e-01f, -3.32207792e-02f, 1.23081738e-02f, 2.09587775e-02f,
  2.43682712e-01f, 2.85521090e-01f, 5.32834567e-02f, 5.18492609e-02f, 1.78489223e-01f, 2.75132000e-01f, 2.00584710e-01f, 1.92237750e-01f, -7.95735866e-02f, 9.13437530e-02f,
  -1.68514818e-01f, 9.21297222e-02f, 1.26397163e-01f, -2.01426372e-01f, -1.74544662e-01f, -5.19175977e-02f, 7.96285346e-02f, -2.21334964e-01f, -2.42961988e-01f, -7.85141736e-02f,
  -6.11046106e-02f, 1.12985969e-01f, 1.43754676e-01f, -3.04033719e-02f, 1.52493522e-01f, -1.85600474e-01f, -2.43144423e-01f, -2.24430218e-01f, 3.56917195e-02f, -1.46166131e-01f,
  2.10386217e-01f, 1.33714080e-01f, 1.02147907e-01f, 3.44632566e-01f, -9.19250306e-03f, 3.67425740e-01f, -1.54542387e-01f, -1.90086395e-01f, -3.41962022e-03f, -1.85023725e-01f,
  -1.73223630e-01f, 2.36802120e-02f, -2.79691480e-02f, 7.19806924e-02f, -2.29428574e-01f, -1.77557524e-02f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  8.35319087e-02f, 2.20498249e-01f, 1.68269694e-01f, 3.79619338e-02f, -3.23056430e-01f, 2.66901660e-03f, 1.11330278e-01f, 1.91429891e-02f, 4.16478276e-01f, 3.83697242e-01f,
  -2.05425754e-01f, 2.48911127e-01f, -1.73193648e-01f, -1.07174903e-01f, -1.43810600e-01f, 1.00574881e-01f, 3.34778607e-01f, 3.82898480e-01f, 1.13273419e-01f, 4.60811228e-01f,
  1.01095978e-02f, 7.80519366e-01f, -1.03601672e-01f, 3.67812783e-01f, -1.25007212e-01f, -1.38432473e-01f, 9.33422986e-03f, 1.51183456e-01f, -7.11223483e-02f, -7.69141614e-02f,
  -2.03493610e-02f, -1.85416669e-01f, 1.89719781e-01f, 1.73764691e-01f, 5.56371734e-02f, -3.20527345e-01f, 2.30727792e-01f, 2.76156783e-01f, -4.43834849e-02f, -2.11236514e-02f,
  9.25513208e-02f, -1.00090742e-01f, -1.39720544e-01f, -4.80558313e-02f, 2.79472739e-01f, 2.76935726e-01f, 4.28984612e-01f, 1.43458441e-01f, -8.46716315e-02f, -2.52614886e-01f,
  1.98185265e-01f, -7.71910995e-02f, -1.05634868e-01f, -3.30521949e-02f, -9.56163555e-02f, 3.06091476e-02f, -1.88323453e-01f, 2.24439174e-01f, -1.81843579e-01f, -1.77423656e-01f,
  -9.43567753e-02f, 8.30434039e-02f, 5.05314052e-01f, 3.02139431e-01f, 9.81028751e-02f, -1.36376917e-01f, 7.35682696e-02f, 2.04803839e-01f, -5.36405370e-02f, -6.89325109e-02f,
  -1.78948835e-01f, 2.22444418e-03f, 3.53636220e-02f, 1.20685652e-01f, 1.61322542e-02f, -1.06508598e-01f, 4.52353358e-02f, -9.36303437e-02f, -7.65947700e-02f, 7.67973363e-02f,
  3.89486775e-02f, -1.29602507e-01f, 2.81285346e-01f, 3.40517849e-01f, -1.47195384e-02f, -4.16482501e-02f, -3.29845436e-02f, 3.53022188e-01f, 9.78512391e-02f, 1.62369803e-01f,
  -1.26847580e-01f, 1.93819597e-01f, -8.21094438e-02f, 1.16158910e-01f, 1.35478461e-02f, 3.30963433e-02f, 3.45030904e-01f, 2.00977042e-01f, 2.94356793e-01f, -9.90588218e-02f,
  2.75000215e-01f, -1.90352071e-02f, 1.63261723e-02f, -1.84361801e-01f, -1.11471184e-01f, -2.26244420e-01f, 1.03632703e-01f, -4.52955455e-01f, 2.12389886e-01f, 2.18949512e-01f,
  1.95300996e-01f, 2.68864602e-01f, 4.53878902e-02f, -1.27045810e-01f, 2.53371447e-01f, 4.13657397e-01f, -2.49761492e-01f, -2.38238350e-01f, 1.44477025e-01f, 1.37100175e-01f,
  -1.07266359e-01f, -1.66037679e-02f, -1.74638465e-01f, 1.32785052e-01f, 1.87853828e-01f, -4.48627770e-02f, 7.01671004e-01f, -2.12867022e-01f, 2.66082615e-01f, 2.98079938e-01f,
  1.38273120e-01f, 1.68271646e-01f, 3.87402810e-02f, -1.55512244e-02f, -2.78466358e-03f, -7.14693889e-02f, 1.39568239e-01f, 3.74282479e-01f, 3.40918787e-02f, 3.61262828e-01f,
  4.18379381e-02f, 1.37116656e-01f, 4.18835580e-01f, -1.45791601e-02f, -1.53161958e-01f, 1.94375873e-01f, -1.94838628e-01f, -2.18009219e-01f, 1.33733198e-01f, -1.11099228e-01f,
  5.16987108e-02f, 1.19065993e-01f, 4.33631167e-02f, 5.55574410e-02f, 1.41835809e-01f, -1.28946751e-01f, -1.62738189e-01f, -2.13681653e-01f, -2.36098796e-01f, 4.50587608e-02f,
  -5.05010374e-02f, -1.31130874e-01f, 1.33138046e-01f, 1.31942973e-01f, -1.37971580e-01f, 1.41764939e-01f, -1.18277349e-01f, 1.48270652e-01f, -1.52479887e-01f, 3.01048462e-03f,
  8.28807876e-02f, 3.18623513e-01f, 8.75409320e-02f, -3.18840705e-02f, -1.97199613e-01f, 7.71564841e-02f, -3.45771313e-02f, -1.72038347e-01f, 1.08393051e-01f, 5.87766506e-02f,
  2.23844767e-01f, -1.49068739e-02f, -6.64962307e-02f, -1.18959077e-01f, 6.06648959e-02f, 1.31807521e-01f, -6.61220551e-02f, 2.24834234e-02f, -1.44946724e-01f, 5.20998500e-02f,
  2.22975090e-01f, -4.54270691e-02f, -1.73570253e-02f, -5.67400921e-03f, -1.16795801e-01f, -9.58520919e-02f, -4.71451394e-02f, 1.19177207e-01f, -1.09368742e-01f, -1.16070509e-01f,
  5.47069460e-02f, 2.16750130e-01f, -4.07427596e-03f, -2.16680076e-02f, -1.86269715e-01f, -9.27455649e-02f, -1.95866413e-02f, -1.40268117e-01f, 2.19046608e-01f, 1.36893660e-01f,
  1.18719123e-01f, -6.08552769e-02f, -6.99016154e-02f, 3.15259874e-01f, 1.05781764e-01f, 1.03370398e-01f, -1.30010754e-01f, -4.49786708e-02f, -2.55253986e-02f, 7.26719918e-07f,
  -1.61581457e-01f, 5.97025529e-02f, 1.05894089e-01f, -1.64050713e-01f, 4.53292638e-01f, 3.18666250e-01f, 3.43617760e-02f, -8.72094780e-02f, 1.53388932e-01f, 2.85027403e-04f,
  6.77400306e-02f, -1.54741421e-01f, 1.39487550e-01f, -2.42732567e-04f, -1.43752322e-01f, 4.98553544e-01f, 1.71622321e-01f, -2.40566194e-01f, 1.15800031e-01f, -1.59203589e-01f,
  3.31715681e-02f, 2.45129421e-01f, 7.50480443e-02f, -3.37414801e-01f, 1.22587927e-01f, 1.46568388e-01f, -3.46403942e-02f, 6.61635578e-01f, -1.44352376e-01f, -2.29073822e-01f,
  4.30093445e-02f, -7.90352821e-02f, -1.74146459e-01f, -7.26038516e-02f, -1.29672021e-01f, 8.12592134e-02f, 1.56068727e-01f, 1.47677824e-01f, -1.49431959e-01f, 8.56757313e-02f,
  2.12231383e-01f, 1.85943216e-01f, -6.39326125e-02f, 5.17570227e-02f, 1.15902042e-02f, -1.31936535e-01f, -1.51234955e-01f, 4.46484357e-01f, 1.74139589e-01f, 9.74839628e-02f,
  3.41082186e-01f, -6.06441982e-02f, 1.23205826e-01f, -2.83449054e-01f, 1.75002620e-01f, -3.08200002e-01f, 2.11879477e-01f, -2.17631742e-01f, -1.51246220e-01f, 2.06992894e-01f,
  1.39933333e-01f, -3.09966356e-02f, -2.20596045e-01f, 1.33747116e-01f, -3.62203903e-02f, -7.76484013e-02f, 5.65695941e-01f, 3.24159622e-01f, 1.03076227e-01f, -1.88892320e-01f,
  2.53737628e-01f, 1.66066661e-01f, -3.23156685e-01f, -2.86840916e-01f, -1.29077792e-01f, 8.67937207e-02f, 2.22715214e-01f, 4.44630325e-01f, 1.00530073e-01f, 3.51923794e-01f,
  9.04967710e-02f, 2.08924681e-01f, -8.68715048e-02f, -2.56087571e-01f, 4.20458689e-02f, 3.96558225e-01f, -1.09917946e-01f, -1.47377491e-01f, 2.98298057e-03f, 2.91935802e-01f,
  -1.77170634e-01f, 4.09246206e-01f, -4.66122031e-02f, -1.73884749e-01f, 1.52025074e-01f, 1.66833714e-01f, 1.39019145e-02f, 6.47828653e-02f, -2.95061469e-01f, -1.61277235e-01f,
  -1.03772022e-01f, 2.86185034e-02f, -3.02127898e-02f, -1.27703205e-01f, 5.33821806e-02f, 4.35118467e-01f, -8.67741928e-02f, 3.47025208e-02f, -8.74331370e-02f, 2.63874829e-01f,
  1.30194470e-01f, 6.37532353e-01f, -1.33407027e-01f, -3.36459428e-01f, 4.22114044e-01f, 1.81800932e-01f, 1.08066969e-01f, 1.10298403e-01f, 1.06217995e-01f, -2.26923123e-01f,
  1.65389299e-01f, 1.75360307e-01f, 3.40159051e-03f, -3.80037278e-01f, -1.32516706e-02f, 1.13053173e-01f, -1.42038271e-01f, 1.29728109e-01f, 5.35739847e-02f, 4.93406504e-02f,
  3.19635719e-01f, 2.48187050e-01f, 1.49932474e-01f, -1.23711333e-01f, 8.04999843e-03f, 2.26108968e-01f, 3.53986099e-02f, 1.96168080e-01f, -1.29397348e-01f, -1.99226961e-02f,
  -2.10860163e-01f, 2.34286338e-01f, 1.54310510e-01f, 5.72317421e-01f, -6.36550039e-02f, -2.14033574e-01f, 4.53405306e-02f, -2.03683972e-01f, 1.11362472e-01f, -8.75532553e-02f,
  1.76553681e-01f, -7.22553805e-02f, 2.88853765e-01f, -1.23691149e-01f, -6.02986999e-02f, -6.41432703e-02f, -1.51190728e-01f, 1.82193294e-01f, 1.35871843e-01f, 3.77218276e-01f,
  1.54038714e-02f, 2.12687496e-02f, 5.38440347e-01f, 1.41691327e-01f, 9.61163267e-02f, 5.30265421e-02f, -1.40681013e-01f, -3.66739362e-01f, 1.81051027e-02f, 2.33430013e-01f,
  -1.71730787e-01f, 1.61694974e-01f, -2.04192963e-03f, 1.40458882e-01f, -8.55125301e-03f, -3.10376119e-02f, 3.55544090e-02f, 3.56421880e-02f, 5.25401235e-01f, 4.05414671e-01f,
  2.55173862e-01f, 2.36727506e-01f, 1.21661559e-01f, 3.64921540e-01f, -2.33250141e-01f, 4.46487606e-01f, -1.02504738e-01f, -4.88941371e-01f, 1.19203135e-01f, 3.66798013e-01f,
  -2.89806664e-01f, -5.04565239e-02f, 1.04231454e-01f, -2.14651302e-01f, 3.59825283e-01f, 5.04808649e-02f, 8.01843312e-03f, 1.72504976e-01f, 2.92899847e-01f, -2.99307834e-02f,
  3.56600620e-02f, -6.04843609e-02f, 6.47781268e-02f, 9.26545709e-02f, 1.99491262e-01f, 2.33960584e-01f, -1.21563427e-01f, 1.09367594e-01f, 4.61398363e-02f, 1.58479512e-01f,
  8.32115337e-02f, -1.01301000e-01f, 1.83987185e-01f, 2.56311327e-01f, -1.15623914e-01f, 7.23253610e-03f, -4.44823578e-02f, -9.07262191e-02f, 1.29044712e-01f, -2.74334013e-01f,
  -5.84054589e-02f, -2.04529494e-01f, 6.09261990e-02f, 1.00371957e-01f, 1.73162177e-01f, 1.88711733e-01f, -5.80918752e-02f, 8.99868533e-02f, 7.32167065e-02f, 1.52491078e-01f,
  2.83643156e-01f, -3.53952825e-01f, 1.04442775e-01f, -1.80092305e-02f, -1.13295978e-02f, 3.18331383e-02f, -1.87760256e-02f, -2.47570798e-01f, 1.87543228e-01f, -1.91159904e-01f,
  -1.81076929e-01f, 2.58395284e-01f, -7.53123164e-02f, 9.68898907e-02f, 1.10725559e-01f, 2.70796716e-01f, -1.56734083e-02f, 1.99311465e-01f, 1.79861858e-02f, 4.94576305e-01f,
  -1.77546009e-01f, 1.02571391e-01f, -4.60892767e-02f, -7.30250627e-02f, 7.41180852e-02f, 1.03037804e-01f, -6.86861202e-03f, -1.45069689e-01f, -2.26696432e-02f, 2.43595056e-03f,
  -1.66107211e-02f, 2.50497192e-01f, 1.68767929e-01f, 2.87905838e-02f, 4.28641178e-02f, 2.28751436e-01f, -1.35332018e-01f, -4.71633747e-02f, 3.70878242e-02f, 2.43638113e-01f,
  -1.10541895e-01f, 2.34666184e-01f, -9.09499452e-02f, -6.48410767e-02f, 1.89362228e-01f, 3.46041657e-02f, -3.91670875e-02f, 6.68780925e-03f, -2.92581767e-02f, -3.21856141e-01f,
  1.57150179e-01f, 1.61352269e-02f, 1.69509917e-01f, 3.49902123e-01f, -1.51781440e-01f, 2.36249473e-02f, 1.55568242e-01f, 9.91431251e-02f, -2.03108549e-01f, 1.11602500e-01f,
  -2.44015098e-01f, 2.45737433e-01f, 2.46166706e-01f, 3.18223149e-01f, 2.13559046e-02f, 3.53889555e-01f, -1.58985909e-02f, -7.52561912e-02f, -1.43371657e-01f, -2.82742176e-02f,
  9.66243967e-02f, -7.77929798e-02f, -2.29829103e-01f, -9.94675383e-02f, 1.15269050e-02f, -1.06357172e-01f, -1.73326433e-01f, 2.16828540e-01f, -2.47785658e-01f, 1.30478695e-01f,
  4.15798664e-01f, 2.01180533e-01f, 2.17329368e-01f, 5.62171191e-02f, 7.64126033e-02f, 1.00295556e+00f, 1.86238602e-01f, 1.34276943e-02f, 1.78756431e-01f, 2.27317572e-01f,
  -1.38578027e-01f, -3.97663526e-02f, 4.61377561e-01f, -2.71126568e-01f, 3.40033844e-02f, 2.19517127e-02f, 2.67209619e-01f, -1.77184328e-01f, -1.26350736e-02f, 6.16694540e-02f,
  -8.08510035e-02f, -8.01515579e-02f, 1.59343153e-01f, -9.19817910e-02f, -4.51617800e-02f, -9.76589024e-02f, -1.05716296e-01f, 1.64434895e-01f, 5.97020447e-01f, 1.37034029e-01f,
  5.66513017e-02f, -7.38703832e-02f, 3.83519568e-02f, -9.91042033e-02f, -2.38931365e-02f, -9.18413252e-02f, -1.27774721e-03f, -1.73567012e-01f, 4.83642817e-02f, 4.48265970e-02f,
  -1.40612721e-01f, -4.36563231e-02f, -2.78342655e-03f, -1.53400645e-01f, 2.24240553e-02f, 2.84000725e-01f, -1.79127619e-01f, -9.08135772e-02f, 4.55150716e-02f, 9.79757234e-02f,
  -2.96235144e-01f, -3.77192050e-02f, -9.17115659e-02f, 9.05391201e-02f, 2.76055992e-01f, 1.04542188e-01f, -1.60322607e-01f, -6.15078695e-02f, 3.14711742e-02f, -8.48870352e-02f,
  1.90636367e-01f, 2.70568013e-01f, 3.13963853e-02f, 3.11411291e-01f, 4.33188602e-02f, 3.24348718e-01f, 6.55571930e-03f, 3.21289867e-01f, -7.38057867e-02f, -1.54107166e-02f,
  1.87645391e-01f, -6.16094097e-02f, 2.03143418e-01f, -6.95555210e-02f, -8.01276937e-02f, -8.05016831e-02f, -4.13078889e-02f, 7.40109235e-02f, 1.21265143e-01f, 2.97831476e-01f,
  3.51742119e-01f, -3.48406136e-01f, 2.21278697e-01f, 5.85209727e-02f, 2.32584439e-02f, -7.64101222e-02f, -4.17363755e-02f, -3.45536205e-03f, 1.00908972e-01f, 6.18420057e-02f,
  -7.78340250e-02f, 2.17793956e-01f, 6.29629552e-01f, 2.57054213e-02f, 5.49420714e-03f, -4.22434956e-02f, -1.05084166e-01f, -1.29005477e-01f, -2.37132862e-01f, -1.32599533e-01f,
  8.16777814e-03f, 1.36801556e-01f, -4.75867353e-02f, 1.50893614e-01f, -4.77365218e-02f, -2.53805876e-01f, 1.65772900e-01f, -1.68746978e-01f, -2.17752323e-01f, 2.06545338e-01f,
  7.14316592e-02f, 3.11205178e-01f, 1.38957754e-01f, -1.39171809e-01f, -6.61578327e-02f, 7.86133409e-02f, -1.37839735e-01f, 1.07933916e-01f, -6.58255890e-02f, 2.09351070e-04f,
  -1.68003961e-01f, 3.49381380e-02f, 4.40206490e-02f, 1.25140518e-01f, 3.17979932e-01f, 9.58269238e-02f, -1.34795576e-01f, 1.14970654e-02f, -1.54796928e-01f, -2.04326749e-01f,
  -1.02856353e-01f, 7.81693012e-02f, -1.82875335e-01f, -5.62343858e-02f, 7.13548139e-02f, -1.65836096e-01f, 7.81472772e-02f, -1.32485449e-01f, 1.32495940e-01f, 8.67008641e-02f,
  1.53628727e-02f, -3.88291478e-02f, 8.27164873e-02f, 2.52117366e-01f, -4.74923141e-02f, -1.91814601e-01f, 1.31628871e-01f, -4.59113717e-02f, 1.55517861e-01f, 9.13399458e-02f,
  -3.81736420e-02f, -1.86665207e-01f, 8.29671100e-02f, -6.96141571e-02f, 5.92834912e-02f, 1.45641953e-01f, 6.39952123e-02f, 1.12991929e-01f, 6.89807609e-02f, -3.22589874e-02f,
  1.89691350e-01f, 1.21713549e-01f, -9.88907218e-02f, 1.77031830e-01f, -1.12184562e-01f, 1.66731447e-01f, 4.10045311e-02f, -2.84658596e-02f, -1.70262769e-01f, -4.90850732e-02f,
  2.03014407e-02f, 4.67620837e-03f, 2.39230871e-01f, 1.01340443e-01f, -1.65742606e-01f, 7.07268342e-02f, 6.57005012e-02f, -6.16177730e-02f, 2.69913942e-01f, 5.40096387e-02f,
  8.33098590e-02f, -1.53520912e-01f, -2.45594397e-01f, -1.58675060e-01f, 1.96890477e-02f, -1.82782069e-01f, -1.30845815e-01f, 2.25342333e-01f, 3.37497175e-01f, 1.12336807e-01f,
  -5.14959283e-02f, -5.52915260e-02f, 7.19010085e-02f, -2.76421197e-02f, -1.96114182e-01f, -2.50472993e-01f, -1.20582871e-01f, -1.77176386e-01f, 1.44518614e-01f, 4.60131280e-02f,
  -2.09589377e-01f, -2.18186900e-02f, -2.89401487e-02f, -5.26151173e-02f, 2.27787510e-01f, 1.50619626e-01f, 6.63375780e-02f, 2.58580118e-01f, -1.37802780e-01f, -9.02726576e-02f,
  1.94854885e-01f, -7.33500049e-02f, -1.48104385e-01f, -1.27650052e-01f, -1.33480132e-01f, -3.03555224e-02f, -8.07209536e-02f, 3.55401933e-01f, -9.79383588e-02f, -1.44475028e-01f,
  2.93948561e-01f, -1.75457448e-01f, -4.48990650e-02f, 1.90305058e-02f, 2.17732564e-01f, -8.03248286e-02f, 9.07833278e-02f, 1.61117464e-01f, -2.92424392e-02f, -5.32409213e-02f,
  9.58248228e-02f, 2.03691408e-01f, -1.91410318e-01f, 1.82354048e-01f, -8.30666423e-02f, -6.46736771e-02f, 7.64569715e-02f, -5.73071055e-02f, 3.01939905e-01f, -1.06420182e-01f,
  5.88217459e-04f, -3.05932552e-01f, -4.79373373e-02f, -1.66140199e-01f, -1.19338036e-01f, -9.31287780e-02f, 2.82448530e-01f, 3.13461721e-01f, 3.08434274e-02f, 1.55181140e-01f,
  -5.17277718e-02f, 1.00170575e-01f, 4.27215964e-01f, -1.15928926e-01f, 2.49084994e-01f, 3.36554617e-01f, -1.40877336e-01f, 2.06053421e-01f, 9.60824639e-02f, 1.29460841e-01f,
  -1.87456176e-01f, -4.89336222e-01f, -2.25070491e-01f, 1.89677894e-01f, 1.56495020e-01f, -2.61477828e-01f, -7.74971992e-02f, 9.09039751e-02f, -2.94180065e-01f, 7.38944784e-02f,
  2.45236978e-02f, 7.00099245e-02f, 4.33545522e-02f, -1.92604244e-01f, 1.47611722e-01f, 1.44597918e-01f, 1.31174147e-01f, -1.67610720e-01f, -1.09973946e-03f, 6.73538297e-02f,
  1.57750845e-01f, -1.38752237e-01f, 1.85280904e-01f, 2.21248120e-01f, 2.93418944e-01f, -1.11876681e-01f, -1.71700358e-01f, 4.73383106e-02f, -1.33768702e-03f, 9.90764126e-02f,
  -1.13164067e-01f, 9.32600200e-02f, -4.33093347e-02f, 1.10336728e-01f, -1.64604127e-01f, 2.33741567e-01f, -1.29542351e-01f, 7.28941187e-02f, 9.10869613e-02f, -1.55555695e-01f,
  -1.27462894e-01f, -4.79501598e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  9.19420049e-02f, 1.11093894e-01f, -1.81339849e-02f, 2.72168696e-01f, 1.93400700e-02f, 5.69487177e-02f, -6.10176995e-02f, 2.27183402e-01f, 1.86243474e-01f, 8.66226330e-02f,
  -1.74510270e-01f, 6.42161816e-02f, 1.75093904e-01f, 1.46938771e-01f, 3.26086164e-01f, 2.10124776e-01f, -2.11481024e-02f, 8.66769478e-02f, 2.21071560e-02f, 2.01810226e-01f,
  -1.16746584e-02f, 6.42118081e-02f, 1.46204218e-01f, 2.41903617e-04f, 3.01294684e-01f, 5.67216426e-02f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -2.70312220e-01f, 3.69989991e-01f, 5.79206198e-02f, 5.82595289e-01f, 1.14577375e-01f, 1.27892010e-02f, 3.58252227e-02f, 2.90692806e-01f, -5.63122220e-02f, -2.50683516e-01f,
  -6.47967756e-02f, 3.18647400e-02f, 1.35321140e-01f, 6.63055658e-01f, 4.21949059e-01f, -8.72608945e-02f, 1.36776567e-01f, -2.56552137e-02f, -1.93845928e-01f, -2.99516499e-01f,
  1.20708667e-01f, 1.72600091e-01f, 2.36848593e-01f, -1.24911666e-01f, -2.35719591e-01f, 1.27717659e-01f, 1.25360370e-01f, 2.25651294e-01f, -1.54694960e-01f, 2.84840107e-01f,
  -3.23861480e-01f, -9.10635199e-03f, -8.15112144e-02f, -4.30771619e-01f, 3.08205634e-01f, 3.26377451e-01f, 6.00812912e-01f, -8.38700756e-02f, 5.07599041e-02f, -9.84389335e-02f,
  3.57324600e-01f, 3.75411779e-01f, -2.85544366e-01f, 2.14764833e-01f, -3.12903635e-02f, 2.87216216e-01f, 1.56869516e-01f, -1.98592246e-01f, -5.00108540e-01f, 2.00344592e-01f,
  -5.74405253e-01f, -2.54167557e-01f, 1.95447534e-01f, -1.18819229e-01f, 8.69890094e-01f, -2.79944837e-01f, -2.03338459e-01f, -2.55447090e-01f, -1.03295259e-02f, 1.37681618e-01f,
  -8.09928924e-02f, 3.35915908e-02f, -4.16993350e-01f, -6.09320886e-02f, 2.39063382e-01f, -1.71042427e-01f, -5.17230809e-01f, -3.98291260e-01f, -3.22578102e-02f, 3.94638628e-01f,
  4.75316912e-01f, -1.41913950e-01f, -5.53638898e-02f, 9.40571874e-02f, -3.58981788e-01f, -1.24456741e-01f, 1.52505204e-01f, -4.81505394e-01f, -2.68922687e-01f, -4.77574676e-01f,
  1.23323396e-01f, -3.25746477e-01f, 6.76031590e-01f, -1.99869320e-01f, 3.41593564e-01f, -8.90028030e-02f, 1.54703677e-01f, -1.26459017e-01f, 3.55751663e-01f, -2.30478540e-01f,
  4.51553613e-02f, 1.49683818e-01f, -1.74924731e-01f, -1.28594637e-01f, -1.97183475e-01f, -5.36331460e-02f, -2.21642569e-01f, -1.87009662e-01f, -4.87485388e-03f, 3.98692131e-01f,
  -4.05917078e-01f, -6.41850531e-02f, -6.24043584e-01f, 2.65692532e-01f, -9.02543217e-02f, -3.66259247e-01f, 4.60746847e-02f, -8.29068050e-02f, 4.05623280e-02f, -2.69402832e-01f,
  2.51639128e-01f, -4.64473426e-01f, 5.15132368e-01f, 1.27247706e-01f, 1.88733637e-01f, -1.72629252e-01f, -3.01344067e-01f, 2.21676067e-01f, -2.56678045e-01f, 3.97106588e-01f,
  -3.43806930e-02f, 1.89011037e-01f, 1.49388149e-01f, -1.96294472e-01f, 2.58365035e-01f, 7.64243305e-02f, 2.33579397e-01f, 4.88246158e-02f, 5.61228991e-01f, 7.57921264e-02f,
  5.62073052e-01f, -5.98351002e-01f, -4.30225492e-01f, -7.76122883e-02f, 5.16215190e-02f, -7.16643631e-02f, -2.19754219e-01f, -2.58176059e-01f, 4.63603824e-01f, 1.14552058e-01f,
  -1.12589709e-01f, 2.96092182e-01f, 1.21485949e-01f, 5.53690977e-02f, 1.27786890e-01f, -8.02052319e-02f, -1.20917849e-01f, 3.42754036e-01f, -2.29323775e-01f, 1.79737568e-01f,
  -4.24538106e-01f, 1.42546028e-01f, -2.51623313e-03f, 3.70907396e-01f, 2.44695947e-01f, -2.19041213e-01f, -3.22557420e-01f, 6.04764894e-02f, 3.95441860e-01f, -1.46683119e-02f,
  3.65450948e-01f, 2.14622155e-01f, 3.53653550e-01f, -1.68467894e-01f, 2.32720807e-01f, -3.33233982e-01f, 2.77670622e-01f, -4.34636325e-01f, -4.73878682e-02f, -4.16144878e-01f,
  4.21869248e-01f, -1.59098908e-01f, 8.49981084e-02f, 4.65177238e-01f, -2.21796632e-01f, 5.23706377e-01f, -2.90764660e-01f, -1.51192859e-01f, -6.08803332e-01f, -1.04124948e-01f,
  -2.09135801e-01f, 5.67779422e-01f, 6.05319917e-01f, -7.70517960e-02f, 6.52716532e-02f, -3.94377019e-03f, 1.12285070e-01f, -2.36165047e-01f, 5.58484718e-02f, -2.62597084e-01f,
  -5.07041335e-01f, 7.50332326e-02f, -9.55459923e-02f, -2.20226809e-01f, -3.86455595e-01f, -6.00698054e-01f, 5.98825872e-01f, 4.11427766e-01f, 5.94509125e-01f, -3.51621568e-01f,
  2.11738735e-01f, -4.01247293e-01f, -3.28988284e-01f, -4.30573225e-02f, 1.47537008e-01f, -1.50443181e-01f, -4.38172907e-01f, 6.17162347e-01f, -5.38934886e-01f, -3.88030887e-01f,
  -3.62705737e-01f, 1.32223502e-01f, 2.53218144e-01f, -2.13605359e-01f, 1.33837283e-01f, -2.12468296e-01f, 2.82644838e-01f, -1.21968240e-01f, -4.75846902e-02f, -1.06563710e-01f,
  -2.15152293e-01f, -3.26827079e-01f, 3.31481248e-01f, -2.36394420e-01f, -2.47068733e-01f, -1.72930807e-01f, -2.80480266e-01f, -2.74290591e-01f, -3.92412215e-01f, -3.71338934e-01f,
  -2.90918410e-01f, -8.90758634e-03f, -9.20086280e-02f, -3.07900190e-01f, 7.67896250e-02f, 4.13434535e-01f, -1.11671068e-01f, -5.45469522e-02f, 4.07447070e-01f, -3.17281671e-02f,
  4.30642307e-01f, 6.98608577e-01f, -1.49952382e-01f, -8.53190273e-02f, -1.88922048e-01f, -1.26146495e-01f, 1.08383717e-02f, -2.21598119e-01f, -1.30683511e-01f, -3.47323328e-01f,
  -1.40250981e-01f, -1.82147294e-01f, -3.42792459e-02f, 3.29861939e-01f, -5.72869927e-02f, -2.02458456e-01f, -4.17151332e-01f, -1.18270323e-01f, -2.20176637e-01f, 3.56451888e-03f,
  3.77685815e-01f, -1.74739376e-01f, -3.25413257e-01f, 4.46995437e-01f, 2.42789045e-01f, 5.64277053e-01f, -1.35736182e-01f, 2.08653495e-01f, -1.48683026e-01f, -3.99324626e-01f,
  1.00789361e-01f, -3.11265200e-01f, -3.79352681e-02f, 4.62448783e-02f, 3.75012010e-01f, -5.26707210e-02f, -3.64443481e-01f, -2.43967384e-01f, 3.75030845e-01f, 3.01904343e-02f,
  2.20584814e-02f, -2.28856772e-01f, -1.31166771e-01f, 1.02131486e-01f, 8.91395733e-02f, -6.65397272e-02f, -1.33673459e-01f, 1.13904752e-01f, -2.27344871e-01f, 2.21100122e-01f,
  -9.39849541e-02f, -3.56847376e-01f, -4.45636868e-01f, 3.18466395e-01f, 4.54846174e-01f, -3.34701061e-01f, -1.59812286e-01f, -3.90981048e-01f, -1.72054261e-01f, 1.39107481e-01f,
  2.99462318e-01f, 1.87804520e-01f, -4.10756975e-01f, 2.57182539e-01f, 4.19881284e-01f, 3.15577388e-02f, 2.32660383e-01f, 2.38260001e-01f, -2.84896586e-02f, -4.19729762e-03f,
  -4.47008729e-01f, -1.42626897e-01f, 2.82221492e-02f, -3.55327129e-01f, -1.95820972e-01f, -1.94294471e-02f, 1.00641146e-01f, -1.62353873e-01f, 3.49902242e-01f, -7.97926039e-02f,
  3.11840866e-02f, 4.29505408e-01f, 3.24464053e-01f, 4.92307693e-01f, -1.80693060e-01f, -2.79127210e-01f, -6.51760519e-01f, 5.95582843e-01f, -5.65953180e-02f, 6.40502572e-01f,
  -2.53529370e-01f, 8.72494001e-03f, -1.41675234e-01f, -1.57247022e-01f, 1.81496277e-01f, -4.74908911e-02f, -2.09121510e-01f, -3.12968612e-01f, -4.59392108e-02f, 2.26825789e-01f,
  1.85074165e-01f, -2.71365762e-01f, -4.55170214e-01f, 3.63115162e-01f, -3.84149075e-01f, 4.47261930e-01f, 2.41160423e-01f, 2.89448202e-01f, 5.07263780e-01f, -1.94490254e-01f,
  -2.80465521e-02f, 8.91959146e-02f, 4.62123692e-01f, 3.85931611e-01f, -4.75583039e-02f, 2.18175396e-01f, 2.36034602e-01f, 5.63304782e-01f, 3.80116999e-02f, 5.03250211e-02f,
  -7.15331212e-02f, -3.39984447e-02f, 1.76757812e-01f, 5.05234264e-02f, 1.36719197e-02f, -1.64424069e-02f, -4.82731134e-01f, -1.54319787e-02f, -3.47844392e-01f, -4.37293947e-01f,
  4.11167592e-01f, 3.50847282e-02f, 3.90167296e-01f, -6.85746074e-02f, -1.48067638e-01f, 2.64093786e-01f, 6.95282966e-02f, 4.14945990e-01f, 1.12894326e-01f, 1.39365613e-01f,
  -8.53636041e-02f, 9.20937434e-02f, 5.18081248e-01f, 3.51929814e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -6.12755232e-02f, 2.93345928e-01f, -6.99197501e-02f, 1.30685465e-02f, 2.95927286e-01f, 2.23177031e-01f, 1.04830272e-01f, -2.45379716e-01f, -3.97833347e-01f, -6.43205363e-03f,
  1.53447926e-01f, 1.04628593e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    