/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.93798685e-01f, -4.16578539e-02f, 1.03284456e-01f, 1.28004968e-01f, -1.25663549e-01f, 4.38786708e-02f, 1.75154760e-01f, -1.19014412e-01f, 2.66330749e-01f, -1.53170422e-01f,
  -1.21440232e-01f, 1.97871596e-01f, -1.61486804e-01f, 2.28689536e-02f, 1.38214320e-01f, 5.92346638e-02f, 6.64701909e-02f, 1.02538161e-01f, 1.46910876e-01f, -4.88378257e-02f,
  1.03468716e-01f, -1.87777713e-01f, -2.05400530e-02f, -1.40290529e-01f, -1.74003225e-02f, 4.52776179e-02f, -3.19033444e-01f, -4.39902470e-02f, 7.61617301e-03f, -5.26279397e-02f,
  2.62710191e-02f, 9.54669192e-02f, 3.47563103e-02f, -3.06728054e-02f, -5.79430796e-02f, 5.14191091e-02f, -3.48431873e-04f, -2.78922580e-02f, 2.41902247e-02f, -2.50022653e-02f,
  -2.08527930e-02f, -2.62143444e-02f, 8.09533708e-03f, -2.02371320e-03f, 6.81064650e-02f, 2.70558812e-04f, 5.35482578e-02f, 5.29848672e-02f, 1.67216230e-02f, -4.27826196e-02f,
  5.29747270e-02f, 2.56995410e-02f, -6.76999707e-03f, 8.25750679e-02f, 1.74865592e-03f, 4.53211926e-02f, 4.76656854e-02f, 4.00278568e-02f, 8.98095313e-03f, 9.75739658e-02f,
  -4.29074802e-02f, -4.85670827e-02f, 3.49093936e-02f, -1.55921103e-02f, -1.69431902e-02f, -1.17682507e-02f, -5.08895777e-02f, 2.61279829e-02f, 3.69735099e-02f, -6.40095735e-04f,
  4.65645082e-02f, 2.55857706e-02f, 1.18205175e-02f, 2.73225624e-02f, -8.52464605e-03f, 3.58349495e-02f, -2.95715127e-02f, -2.43182685e-02f, 4.66771945e-02f, 3.79628688e-02f,
  -3.65876220e-02f, -1.55924652e-02f, -2.04918757e-02f, -2.11999882e-02f, -4.72268984e-02f, -2.58029420e-02f, -2.48983391e-02f, 1.51247215e-02f, -2.06662668e-03f, -3.40658948e-02f,
  -2.25572921e-02f, -1.50575683e-01f, 8.78667925e-03f, -4.46402952e-02f, 1.97976884e-02f, -4.04409543e-02f, 6.69738427e-02f, -6.03122916e-03f, 3.30698267e-02f, 1.29266866e-02f,
  6.60774903e-03f, 8.71594343e-03f, 3.06929322e-03f, 5.27730286e-02f, 2.57503092e-02f, 9.93787777e-03f, 1.50083993e-02f, 5.53425634e-03f, 7.58778537e-03f, -2.12461478e-03f,
  -2.67308634e-02f, 1.19286934e-02f, 1.23064779e-02f, -4.00676467e-02f, -3.15598249e-02f, -1.03839621e-01f, -3.36258337e-02f, -3.98370298e-03f, -2.97780614e-02f, -2.55949516e-02f,
  -7.90073574e-02f, 6.41776100e-02f, -4.14631367e-02f, -1.60956085e-01f, -4.75697145e-02f, 2.18710527e-01f, -1.33647546e-02f, -2.73626689e-02f, -3.06333452e-02f, 3.06672901e-02f,
  -6.38981014e-02f, 6.32967725e-02f, 4.00288822e-03f, -7.24958628e-02f, -2.62953132e-01f, -2.47197691e-02f, -3.51626240e-02f, 1.16943510e-03f, -1.35534555e-01f, -4.66348492e-02f,
  -5.07924259e-02f, -1.21681429e-01f, -1.54034644e-01f, -7.72722587e-02f, -1.02141291e-01f, -5.32719530e-02f, -1.37032032e-01f, -3.36816534e-02f, 1.76309999e-02f, -9.05517042e-02f,
  4.86359857e-02f, -6.24077395e-02f, 3.96588184e-02f, 7.48735815e-02f, -3.73996422e-02f, 1.47916479e-02f, 8.55893940e-02f, 1.47928717e-02f, -4.49135862e-02f, 1.43822115e-02f,
  7.85441622e-02f, 9.75012779e-03f, -8.98434594e-02f, 7.05314353e-02f, 9.10977498e-02f, 3.55105661e-02f, -5.15414923e-02f, -5.12438547e-03f, -6.65882379e-02f, -7.20704645e-02f,
  -6.64230809e-02f, -2.59373174e-03f, 1.14423774e-01f, 2.40575857e-02f, -4.08851914e-02f, 6.05461944e-04f, -6.60371780e-03f, -2.91131083e-02f, 5.62761165e-03f, -1.64042937e-03f,
  -2.63996162e-02f, -6.02143779e-02f, -1.18563343e-02f, -2.51296889e-02f, -2.97676353e-03f, 9.13507072e-04f, 9.49795730e-03f, -5.96689098e-02f, 5.08921668e-02f, -5.47029357e-03f,
  3.52200046e-02f, -3.34490873e-02f, -1.56144109e-02f, 1.01822525e-01f, 6.43360168e-02f, -1.40018165e-02f, 4.11859863e-02f, 3.16436030e-02f, -1.34751881e-02f, -2.59271543e-02f,
  2.76040751e-02f, -3.38942371e-02f, -4.76632304e-02f, 2.52891220e-02f, 6.37244135e-02f, -3.64951901e-02f, 1.09307270e-03f, 5.29488996e-02f, -2.24006474e-02f, -4.44062911e-02f,
  1.81461170e-01f, 9.65492800e-02f, -5.94118051e-02f, 1.94530860e-02f, 1.51967537e-02f, 7.61738839e-03f, -5.87235205e-04f, -1.62925720e-02f, 6.36935458e-02f, -4.34202217e-02f,
  3.43201496e-02f, 2.29925346e-02f, 2.26948559e-02f, 4.31359792e-03f, 1.59390122e-02f, 5.82576543e-02f, -5.66848479e-02f, 1.06095783e-01f, 2.91676447e-02f, -4.90035452e-02f,
  1.65123455e-02f, -8.16129968e-02f, -7.58273751e-02f, -1.57161802e-01f, 2.08780495e-03f, -7.48355836e-02f, 7.26337135e-02f, -3.67245935e-02f, 1.79675054e-02f, 1.31291784e-02f,
  -6.77993149e-02f, -9.48167220e-02f, -2.26186097e-01f, -3.66193578e-02f, 5.54409623e-02f, 1.27907783e-01f, 4.47310433e-02f, -1.35956466e-01f, -3.26576918e-01f, 1.38559081e-02f,
  8.13265517e-03f, -6.08183779e-02f, 8.81780591e-03f, 1.04000635e-01f, 6.08801059e-02f, -9.20732617e-02f, 8.41492489e-02f, 1.01178661e-01f, -9.41419527e-02f, 1.39442950e-01f,
  1.04890376e-01f, 1.34007886e-01f, -2.42775716e-02f, 1.40792772e-01f, -3.16857137e-02f, -9.15616602e-02f, 1.13946676e-01f, 1.13082752e-02f, 1.08975828e-01f, -1.17038498e-02f,
  -1.88987609e-02f, -4.54204641e-02f, -1.20100543e-01f, -5.53094223e-02f, -1.83407534e-02f, 7.11687207e-02f, -2.49230899e-02f, 6.70974934e-03f, 1.20972712e-02f, -4.93591465e-02f,
  -6.74237357e-03f, 4.57673073e-02f, -4.39194813e-02f, -5.21471836e-02f, -5.75240292e-02f, -7.60493353e-02f, -1.23238884e-01f, -1.60717927e-02f, -9.76973325e-02f, 4.42072824e-02f,
  -9.11509544e-02f, -5.87134361e-02f, 2.98480149e-02f, 3.28970216e-02f, -2.44318396e-02f, -3.62858586e-02f, 4.18837108e-02f, 1.10835887e-01f, -5.24424165e-02f, -3.58818322e-02f,
  6.41693696e-02f, 3.05380821e-02f, 2.87291016e-02f, -5.30547611e-02f, -5.40108271e-02f, -3.57999988e-02f, -1.52124139e-02f, 2.72137206e-02f, -8.58851448e-02f, 5.61629161e-02f,
  1.77136529e-02f, 8.71231928e-02f, -6.35197461e-02f, -4.62932326e-03f, -1.24293733e-02f, -3.12635722e-03f, -1.41012138e-02f, -3.93883884e-02f, -1.67344436e-02f, 2.22134255e-02f,
  -1.93828531e-02f, 1.00406390e-02f, -2.62387004e-02f, 5.72408512e-02f, -2.82368921e-02f, -5.11837229e-02f, 6.90546706e-02f, -2.34901235e-02f, -3.12462319e-02f, 1.12456612e-01f,
  -2.45262086e-02f, 1.01962663e-01f, -6.30990788e-02f, -2.47619394e-02f, -6.26126006e-02f, 5.67908995e-02f, 3.34658623e-02f, -4.32088636e-02f, 4.48161922e-02f, -1.13728978e-02f,
  1.38203293e-01f, 2.85288505e-02f, 9.65875536e-02f, 2.21638065e-02f, -6.19224384e-02f, -1.07834348e-02f, 9.86307561e-02f, -4.85093221e-02f, 7.39719644e-02f, 9.23996121e-02f,
  6.64954334e-02f, 8.12738165e-02f, -1.66537799e-02f, 3.20290998e-02f, 3.45676579e-02f, 7.43277743e-02f, 8.16937536e-02f, 6.20405795e-03f, 2.79361680e-02f, 2.20274460e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -9.42638516e-02f, -3.20110172e-01f, 1.35515258e-01f, -1.78741530e-01f, 1.47880450e-01f, 2.82683939e-01f, 2.44430706e-01f, -6.83178753e-02f, -1.80312216e-01f, -3.10746938e-01f,
  -6.28595427e-02f, 3.21507687e-03f, -1.73542544e-01f, 4.84641362e-03f, 1.70303315e-01f, 4.24354151e-02f, 5.68465106e-02f, -7.63827041e-02f, -2.65411045e-02f, -1.15403511e-01f,
  3.82857397e-02f, 3.16930264e-02f, 2.13983044e-01f, 7.43511915e-02f, 2.16410542e-03f, 1.01498840e-02f, -1.04014859e-01f, 1.23382129e-01f, 5.32810278e-02f, 1.61677331e-01f,
  -4.48981412e-02f, -1.13636501e-01f, 3.86975124e-03f, 2.23719273e-02f, -2.56062169e-02f, -5.64639010e-02f, 5.03496826e-02f, 1.48003712e-01f, -2.25025881e-02f, 4.71395515e-02f,
  -2.04351097e-02f, 3.15045416e-02f, 3.02995685e-02f, 1.08167296e-02f, -1.61820147e-02f, 1.81559920e-02f, 9.31723639e-02f, -1.54726002e-02f, 7.43842199e-02f, 6.46380112e-02f,
  1.70059390e-02f, 3.59941684e-02f, -1.24705508e-01f, 2.67455783e-02f, 2.78478712e-02f, -7.82639626e-03f, -2.26544756e-02f, -8.38109013e-03f, -2.18765941e-02f, -3.36808264e-02f,
  1.44304410e-01f, 4.14882489e-02f, 7.93377087e-02f, -3.46267484e-02f, 4.73269746e-02f, -2.32984945e-02f, -3.99123132e-02f, 1.81356072e-02f, 2.87632477e-02f, -1.10204473e-01f,
  -1.07114099e-03f, 1.50031075e-02f, 2.03362592e-02f, -4.23617922e-02f, 7.49363974e-02f, 1.25601329e-02f, -2.14905050e-02f, -9.85943079e-02f, -1.94059592e-02f, -5.33994064e-02f,
  -5.00617363e-02f, 4.44602594e-02f, -6.18449114e-02f, 3.73136587e-02f, 2.71634161e-02f, -9.35057830e-03f, -1.30134681e-03f, -1.11158945e-01f, 4.43538018e-02f, 5.94477095e-02f,
  -3.88030469e-01f, -3.82973135e-01f, -3.43850739e-02f, -7.25205392e-02f, -3.65749784e-02f, 2.00894885e-02f, 1.64538436e-02f, -2.94416286e-02f, -3.74448709e-02f, 2.24821288e-02f,
  2.41970236e-04f, 4.64721695e-02f, -7.06973374e-02f, 4.11099866e-02f, 8.55122060e-02f, -1.32041546e-02f, -4.09757309e-02f, -3.29778902e-02f, -5.37564792e-02f, -7.21611008e-02f,
  -1.59704700e-01f, -2.04864033e-02f, -3.48958895e-02f, -7.07670823e-02f, 1.29049094e-02f, -4.96311374e-02f, 5.31022390e-03f, 7.16076568e-02f, -2.69905124e-02f, -1.42775942e-02f,
  9.35267732e-02f, -5.30678034e-01f, -3.60599160e-02f, 2.11201817e-01f, 3.45580429e-01f, 1.13466859e-01f, 2.25999102e-01f, -1.33799672e-01f, 3.43366973e-02f, -3.45777422e-01f,
  -9.43690315e-02f, -2.78201252e-02f, -3.00288022e-01f, 2.96157002e-02f, 2.84468293e-01f, -2.19622776e-01f, 4.19921242e-02f, -9.39075742e-03f, -2.37951633e-02f, -1.79883927e-01f,
  1.59724116e-01f, 1.91612512e-01f, 1.12067889e-02f, -3.26211452e-02f, 1.44357994e-01f, -7.68962055e-02f, 7.37489900e-03f, -4.70853709e-02f, 8.73821750e-02f, 1.24203794e-01f,
  1.95450876e-02f, -1.92547560e-01f, 6.33051470e-02f, 3.74717009e-03f, -1.30661339e-01f, -5.47573641e-02f, 1.39031503e-02f, 3.24611478e-02f, -2.65126899e-02f, -3.29679064e-02f,
  2.71377545e-02f, 9.16348770e-02f, 8.32988992e-02f, 1.36717230e-01f, 3.10838968e-02f, 4.69575077e-02f, 3.49134021e-02f, 4.06622374e-03f, -5.87562695e-02f, -9.24182460e-02f,
  -6.75333217e-02f, -1.03601683e-02f, 3.39720324e-02f, 1.07076308e-02f, -2.23547313e-02f, -1.41016841e-02f, 4.07246761e-02f, 2.13292204e-02f, 6.26558065e-02f, 7.93618336e-03f,
  -1.62651792e-01f, 6.24124855e-02f, -5.69960326e-02f, 9.68221799e-02f, -1.61667392e-02f, 9.73264053e-02f, 3.74489278e-02f, 1.07256025e-02f, 3.40276770e-02f, -6.59084097e-02f,
  7.35349804e-02f, -5.43672405e-02f, -5.98107316e-02f, 5.50331697e-02f, 3.49734956e-03f, 5.65148667e-02f, -3.11141796e-02f, -4.06719260e-02f, -4.81817387e-02f, 1.26501627e-03f,
  6.59516677e-02f, -7.08963815e-03f, -9.43418443e-02f, 5.02413921e-02f, 1.93011554e-04f, -1.55239657e-03f, -9.04489215e-03f, -3.96829247e-02f, 2.83567123e-02f, 7.18640909e-02f,
  -1.89376101e-01f, -3.81114423e-01f, -8.58966559e-02f, 2.65187062e-02f, -2.99412422e-02f, 4.32086922e-03f, 3.12198745e-03f, 8.44235122e-02f, -9.69990343e-02f, -5.45340665e-02f,
  -4.02374603e-02f, -1.87030018e-04f, -5.20955622e-02f, 1.02091171e-02f, 4.25218344e-02f, -7.80257806e-02f, -1.02635443e-01f, -6.40330883e-03f, 1.13655850e-01f, -4.50977944e-02f,
  -3.98832597e-02f, 3.62002701e-02f, 4.62937616e-02f, 5.23214415e-02f, 1.11382119e-01f, 4.08549346e-02f, 7.33934790e-02f, -4.41200919e-02f, -5.95998615e-02f, 3.36502269e-02f,
  2.83368468e-01f, -6.75466657e-02f, -2.98071802e-01f, 1.05759148e-02f, 1.04612768e-01f, 2.85397381e-01f, 8.05818513e-02f, 1.02835655e-01f, -1.17959291e-01f, 2.68507767e-02f,
  1.04433060e-01f, -1.13862902e-01f, -7.60077536e-02f, -3.08787054e-03f, 1.94687068e-01f, -6.89676329e-02f, 1.33889213e-01f, 1.14052854e-01f, -6.74180686e-02f, 3.43972584e-03f,
  -5.60481176e-02f, 2.08948866e-01f, -2.40756109e-01f, 6.69076443e-02f, 1.87058926e-01f, -1.60890877e-01f, 7.51948208e-02f, -4.81087454e-02f, 2.43590260e-03f, 7.99259990e-02f,
  1.47338526e-03f, -3.51728685e-02f, -2.65306514e-02f, -2.90201250e-02f, 1.50290444e-01f, 9.06439871e-02f, -4.31702323e-02f, -3.26354653e-02f, -1.39500111e-01f, -5.76512255e-02f,
  -1.02349609e-01f, -2.87475884e-02f, 7.62959868e-02f, -2.77345572e-02f, 3.71827446e-02f, 2.72758696e-02f, -1.83379352e-01f, -5.94765507e-02f, -4.96006943e-03f, 7.95097053e-02f,
  -1.01877265e-01f, -9.26951170e-02f, -8.93828347e-02f, -9.89629924e-02f, -1.27120420e-01f, -9.73770916e-02f, -1.26426190e-01f, 1.11491187e-02f, -4.68867682e-02f, 6.77402839e-02f,
  6.17538765e-02f, 9.70692486e-02f, 3.63623761e-02f, -1.01483367e-01f, 2.10288204e-02f, -2.44528963e-03f, 4.48883399e-02f, 5.02470471e-02f, -4.41824831e-02f, -3.48552950e-02f,
  4.72370833e-02f, 3.66194770e-02f, -2.54527107e-02f, -2.47000046e-02f, 1.15757704e-01f, 6.01957776e-02f, 5.77610843e-02f, 1.45829571e-02f, -7.71716936e-03f, -1.90337896e-02f,
  8.43102485e-02f, 8.82396922e-02f, -3.73883196e-03f, -7.44464248e-02f, -8.07289630e-02f, -2.19171848e-02f, 6.96627498e-02f, 1.21304050e-01f, -1.43479690e-01f, 2.00737640e-02f,
  6.40213564e-02f, -4.63935547e-02f, -1.07384622e-01f, -8.22826251e-02f, -1.07613832e-01f, 7.33941719e-02f, -2.82905679e-02f, -6.75620288e-02f, -4.28780504e-02f, 1.75174654e-01f,
  5.55854365e-02f, -1.17250428e-01f, 1.01834118e-01f, -7.92554319e-02f, -5.38237467e-02f, 9.33541171e-03f, -6.38339743e-02f, -2.90926360e-02f, 3.63651551e-02f, -1.68150924e-02f,
  -1.16645666e-02f, -9.90043511e-04f, 5.62408231e-02f, -3.70817110e-02f, 2.75702011e-02f, -6.08132072e-02f, -7.92175829e-02f, 8.96729976e-02f, 1.51200574e-02f, -4.02651727e-02f,
  -6.09935760e-01f, -1.26180109e-02f, -7.77037069e-02f, -3.65146786e-01f, 5.75724095e-02f, -6.06136844e-02f, -3.48895997e-01f, -8.66041332e-02f, -2.47989133e-01f, -1.90481216e-01f,
  -1.75823256e-01f, -2.42989466e-01f, 1.75359443e-01f, -5.77621348e-02f, 2.48237941e-02f, 2.60765761e-01f, -8.55552182e-02f, -1.60461459e-02f, 1.09286666e-01f, -3.05177774e-02f,
  7.25929514e-02f, 4.64335978e-02f, 1.19947597e-01f, 1.48960486e-01f, 1.66578870e-02f, -2.05911726e-01f, 1.02844676e-02f, -2.34692357e-03f, -5.45505546e-02f, -2.23053042e-02f,
  -9.20221582e-02f, -1.43248647e-01f, 1.08100854e-01f, 1.28604844e-01f, 3.79733890e-02f, 7.72235356e-03f, -2.48465221e-02f, 4.07423489e-02f, -4.73396331e-02f, -2.39506494e-02f,
  -3.40798497e-02f, 2.99579445e-02f, -9.91206095e-02f, 6.79709911e-02f, 9.48734768e-03f, 3.36488709e-02f, 7.11070150e-02f, 3.33230533e-02f, 1.26180246e-01f, 5.84209971e-02f,
  2.62686168e-03f, 2.92985141e-02f, 4.29238519e-03f, -3.75783816e-02f, 8.08439329e-02f, 1.87835637e-02f, -1.45063996e-02f, -1.85338780e-02f, -1.11212276e-01f, -1.13370623e-02f,
  -3.57934609e-02f, 9.29467306e-02f, 8.93938541e-02f, 5.32812215e-02f, 2.65201926e-03f, -7.84687772e-02f, -1.07368305e-02f, -1.77169219e-02f, -2.93140374e-02f, -3.66721489e-02f,
  -6.89092427e-02f, -8.64654705e-02f, 1.84772592e-02f, 2.86581665e-02f, -5.64530268e-02f, -6.78016469e-02f, 9.71605480e-02f, 1.97335798e-03f, -2.40263175e-02f, 4.33019362e-02f,
  7.94145465e-02f, -1.05507731e-01f, -2.04298779e-01f, -1.29746189e-02f, 2.57548504e-02f, 6.33555353e-02f, -6.19896054e-02f, 5.60069717e-02f, -1.06049061e-01f, 7.52190687e-03f,
  -1.55422866e-01f, -2.35768691e-01f, 8.15797001e-02f, -2.13899948e-02f, 1.24390438e-01f, 3.33396085e-02f, 9.09878407e-03f, 7.95681961e-03f, -8.75268728e-02f, 1.00088948e-02f,
  4.10653874e-02f, 5.22349440e-02f, -2.11934634e-02f, 5.38550317e-02f, -7.61048570e-02f, 2.16379762e-02f, -7.04315072e-03f, -4.52857725e-02f, -8.33614096e-02f, -1.07265547e-01f,
  -1.38209099e-02f, 3.64437588e-02f, -5.59658334e-02f, -5.37527427e-02f, -1.48387486e-02f, -1.66303352e-01f, 9.88255534e-03f, -3.39492783e-02f, -5.98359704e-02f, -2.88645625e-02f,
  1.50949031e-01f, 1.24665432e-01f, -3.57035473e-02f, 1.13995776e-01f, -2.41029680e-01f, -4.28003371e-01f, -2.01187119e-01f, -1.99777082e-01f, 1.49440721e-01f, -2.24069809e-03f,
  -1.27862573e-01f, 2.30156779e-01f, -3.00484244e-02f, -7.71784112e-02f, -1.21077873e-01f, -1.02784112e-01f, -1.74858734e-01f, -6.89264834e-02f, -1.83815276e-03f, -1.94192410e-01f,
  4.73938184e-03f, -1.51459917e-01f, -1.20623358e-01f, -8.15308616e-02f, -7.10030198e-02f, 7.87190944e-02f, 5.61477765e-02f, -1.67772193e-02f, -4.13022712e-02f, 7.04789311e-02f,
  -1.92565441e-01f, 1.74385514e-02f, 2.34958250e-02f, 2.18410622e-02f, -1.25052109e-01f, -5.60638495e-02f, 7.63941184e-02f, -4.74512987e-02f, -3.59411910e-02f, 6.95974678e-02f,
  7.27044493e-02f, -3.93167622e-02f, 4.50111032e-02f, 1.01518286e-02f, -2.11819746e-02f, 2.91374717e-02f, 2.79501397e-02f, -7.23814890e-02f, -4.39908989e-02f, 1.16320010e-02f,
  -1.61633026e-02f, -1.66807007e-02f, -3.81751396e-02f, -2.64432766e-02f, -6.64384291e-02f, 8.83348007e-03f, 3.64776589e-02f, 2.45785899e-02f, 3.21492068e-02f, 7.28125032e-03f,
  1.16182022e-01f, 6.58096233e-03f, 2.62823943e-02f, -4.83150184e-02f, 1.54488685e-03f, -8.70387703e-02f, -3.04158102e-03f, -3.81230153e-02f, 1.64598580e-02f, 4.60762810e-03f,
  -1.01127438e-02f, 5.04937656e-02f, -8.62785727e-02f, -5.31435125e-02f, 1.98968928e-02f, 1.59851350e-02f, -8.58920887e-02f, -5.64287417e-02f, -6.09604754e-02f, 3.22406963e-02f,
  9.53100622e-02f, -1.03719458e-01f, 3.02086510e-02f, -7.23871291e-02f, -4.07023579e-02f, -7.99514353e-03f, -6.70665279e-02f, -2.75010727e-02f, -4.51865635e-04f, -3.07397712e-02f,
  -2.15003714e-01f, -2.55040675e-01f, 2.83972491e-02f, -2.70777121e-02f, 3.04160416e-02f, 2.84675006e-02f, -7.33572245e-02f, -3.17760147e-02f, -2.99403612e-02f, -3.75541784e-02f,
  -3.60870287e-02f, -4.77707796e-02f, -3.53519991e-02f, 5.56044467e-02f, 3.85021158e-02f, -1.02666073e-01f, -7.64136165e-02f, 8.52019265e-02f, -7.14021102e-02f, 3.30176838e-02f,
  3.61493193e-02f, 1.75602268e-03f, 3.06118261e-02f, 7.73939118e-02f, 9.35023725e-02f, -5.60047664e-02f, 1.27442731e-02f, 6.06128126e-02f, -7.47788325e-02f, -4.73823138e-02f,
  4.99605341e-03f, -1.05801307e-01f, 2.86186486e-01f, -1.34919479e-01f, 8.41630399e-02f, 1.23167165e-01f, 2.68578619e-01f, 3.30985747e-02f, -1.42922014e-01f, -1.84304059e-01f,
  -4.08724919e-02f, 2.26582661e-02f, 1.31531581e-01f, -2.70723961e-02f, 1.90631092e-01f, 4.04717103e-02f, -1.30708050e-02f, -1.02676302e-01f, -3.08239534e-02f, -7.22904727e-02f,
  -6.97160289e-02f, -1.20808691e-01f, 3.42447981e-02f, -9.35514718e-02f, -2.37087086e-02f, -3.27378623e-02f, 6.76015243e-02f, 3.90569344e-02f, -1.18326761e-01f, 5.27018532e-02f,
  -7.50449020e-03f, -4.54456136e-02f, -1.01329677e-01f, -4.51655798e-02f, -1.34197399e-01f, -2.28110757e-02f, 1.56086218e-02f, -6.78444877e-02f, -6.24963082e-02f, 3.19071896e-02f,
  -7.15250745e-02f, 3.97348516e-02f, 5.20421797e-03f, 2.03865413e-02f, 4.42810096e-02f, 2.90750153e-02f, -1.83688290e-02f, -5.29781058e-02f, -3.76387201e-02f, 1.14395120e-03f,
  -5.90707958e-02f, -9.89450440e-02f, 3.50981532e-03f, -2.13982984e-02f, 7.12172613e-02f, -5.33981547e-02f, 3.95132527e-02f, 3.46607380e-02f, -2.03300044e-02f, -7.36769363e-02f,
  -4.28686142e-02f, 7.05464482e-02f, -7.53731579e-02f, -1.40969351e-01f, -3.14348787e-02f, -7.23932683e-03f, -2.62981076e-02f, 1.38446651e-02f, -1.26323719e-02f, -4.75085117e-02f,
  4.53806743e-02f, 1.03954382e-01f, -7.99974129e-02f, 1.67502146e-02f, -2.62823217e-02f, -7.63430074e-02f, -2.16444377e-02f, -1.32751781e-02f, -8.53615105e-02f, 7.58260041e-02f,
  6.33364618e-02f, 2.79241838e-02f, 2.93988064e-02f, -8.05011466e-02f, -9.46701914e-02f, -6.60338625e-02f, -1.87016986e-02f, -4.43177596e-02f, -2.85281781e-02f, -4.96029034e-02f,
  -6.44128397e-02f, -1.34530514e-01f, 4.75387946e-02f, -1.12752514e-02f, -5.22942990e-02f, 6.21067807e-02f, 5.55948541e-02f, -4.94170673e-02f, 3.67379822e-02f, 2.63051130e-02f,
  4.89425957e-02f, -8.21454227e-02f, 8.76459256e-02f, 3.00331274e-03f, -5.29774018e-02f, 1.13282083e-02f, -1.51350275e-01f, -8.09696764e-02f, -1.31636351e-01f, 5.07946573e-02f,
  -5.54165579e-02f, -1.01713436e-02f, 2.88902372e-02f, -5.20703569e-02f, 6.16945364e-02f, -3.89746092e-02f, 9.42322239e-02f, -3.95830050e-02f, 4.39646915e-02f, 2.91632190e-02f,
  -3.82911786e-02f, -4.82762493e-02f, -4.99886684e-02f, 1.91813394e-01f, -8.97694528e-02f, -2.92001277e-01f, -3.63760948e-01f, 1.49972916e-01f, -2.07395419e-01f, 3.26141566e-02f,
  1.10775456e-01f, -1.17005058e-01f, 3.81269716e-02f, -1.83773432e-02f, 1.67460218e-01f, -1.68245241e-01f, 9.90452617e-02f, -1.18501738e-01f, 3.66933569e-02f, 2.04379156e-01f,
  1.67842865e-01f, 2.27847338e-01f, 2.90574104e-01f, 2.86324561e-01f, 2.07425356e-01f, 3.11555684e-01f, 4.67403919e-01f, 1.69651434e-01f, 3.32504839e-01f, -6.18802093e-04f,
  -1.51344493e-01f, 1.99753363e-02f, 6.84146956e-02f, -9.20275971e-02f, 1.00161619e-01f, 4.47033942e-02f, -8.99946988e-02f, 6.53317478e-03f, -5.29930517e-02f, 3.40604782e-02f,
  2.04826556e-02f, -1.61119159e-02f, 2.75316965e-02f, 1.62225065e-03f, -9.13104936e-02f, 2.00434681e-02f, -2.07534749e-02f, -3.51250432e-02f, -4.31714840e-02f, -1.92900002e-02f,
  -5.86029999e-02f, -1.71482675e-02f, 1.24334206e-03f, 7.24535510e-02f, 2.48939097e-02f, 1.34117892e-02f, 4.83469181e-02f, -2.44564693e-02f, -3.72754335e-02f, 1.31990090e-01f,
  5.93052395e-02f, -2.12277509e-02f, -1.92733947e-03f, -9.76534486e-02f, -2.44385041e-02f, -5.70735987e-03f, -2.35255668e-03f, 2.71413717e-02f, -3.70884128e-02f, 5.93603263e-03f,
  5.96785918e-02f, 2.30934676e-02f, -5.58044761e-02f, 2.44475389e-03f, 1.62542108e-02f, -6.45441860e-02f, -6.16411902e-02f, 6.12362986e-03f, 6.06605411e-02f, -9.70720276e-02f,
  1.08122565e-02f, 3.28109190e-02f, -3.20145190e-02f, 5.14498688e-02f, -5.98103255e-02f, 6.13509193e-02f, 9.58658159e-02f, -5.13785630e-02f, -7.48326303e-03f, 4.23162915e-02f,
  5.18695787e-02f, 2.33151585e-01f, -2.67419871e-03f, -8.36366862e-02f, -5.63894585e-03f, -3.57343368e-02f, 7.48210549e-02f, 2.23797206e-02f, 1.14421725e-01f, -6.38568327e-02f,
  1.68171644e-01f, 1.36130638e-02f, 2.20539924e-02f, -4.25354801e-02f, 1.23676710e-01f, -6.20487519e-02f, 6.76848441e-02f, 8.76520202e-02f, 8.05271864e-02f, 1.13471098e-01f,
  7.75423869e-02f, 2.79616900e-02f, 4.39654961e-02f, -1.13012651e-02f, 9.26142409e-02f, 6.06984161e-02f, 8.61665159e-02f, 4.73187342e-02f, 7.72401989e-02f, 1.04340855e-02f,
  3.22744541e-04f, -6.17928766e-02f, 1.85052007e-01f, -9.13100168e-02f, -2.27246943e-04f, 7.24983811e-02f, 1.19392551e-01f, -4.23988029e-02f, -6.93626031e-02f, -2.51708418e-01f,
  9.93800983e-02f, -4.33767512e-02f, 8.61329436e-02f, -1.41570464e-01f, 3.34989309e-01f, 1.15129344e-01f, 4.89746630e-02f, 8.05380493e-02f, 4.50715274e-02f, -1.60478186e-02f,
  3.82421128e-02f, -2.10044876e-01f, 6.90942630e-02f, -2.61572331e-01f, -1.06932297e-01f, -1.20325275e-01f, -5.36781661e-02f, 4.61594276e-02f, -7.13793188e-02f, 1.51971072e-01f,
  -3.24852876e-02f, -1.09090567e-01f, -4.96326610e-02f, -4.57771011e-02f, -3.57333831e-02f, -1.09580658e-01f, 3.09598297e-02f, 1.14162154e-01f, 1.35569451e-02f, 6.52362173e-03f,
  -3.37700471e-02f, -5.04942983e-02f, -5.46107516e-02f, -9.64350775e-02f, -1.84931408e-03f, 8.75615329e-03f, -2.76936777e-02f, -5.77269820e-03f, -3.33628966e-03f, 9.03112814e-02f,
  -2.33739745e-02f, 9.47542314e-04f, -3.20743881e-02f, 2.94304565e-02f, 2.46832892e-02f, -5.91444485e-02f, -6.44101948e-02f, 3.29068899e-02f, -5.22232838e-02f, -1.18335607e-02f,
  1.58602044e-01f, -1.80261713e-02f, -2.50395909e-02f, 1.08560612e-02f, 1.03891520e-02f, 4.30930732e-03f, -1.23916946e-01f, -1.88819543e-02f, -7.44288117e-02f, 6.27198517e-02f,
  5.43975979e-02f, 3.18486914e-02f, -1.86142679e-02f, 8.30154866e-02f, -5.40165864e-02f, -4.69491519e-02f, 7.08474293e-02f, -5.92712946e-02f, -1.04070455e-01f, -7.62287527e-02f,
  -2.39290986e-02f, 1.90681648e-02f, 1.75972879e-02f, -4.18032147e-02f, -4.85923737e-02f, -2.81075668e-02f, -2.93667652e-02f, 1.00235440e-01f, -8.96532759e-02f, 7.95983151e-02f,
  -3.34493726e-01f, -3.76753747e-01f, -6.30964786e-02f, -1.65758684e-01f, -4.97289672e-02f, -3.92762199e-02f, 4.34544543e-03f, 1.19937467e-03f, -1.40784523e-02f, -3.81893665e-02f,
  -1.01912625e-01f, 7.14495555e-02f, -3.08158398e-02f, 8.82863477e-02f, -1.23790251e-02f, -2.87136137e-02f, -6.12325873e-03f, -5.11601828e-02f, -9.13100541e-02f, -1.16424225e-01f,
  -2.42243260e-02f, -7.93818086e-02f, 4.81820218e-02f, 1.43771870e-02f, -1.31284088e-01f, -5.78481033e-02f, -9.78174731e-02f, 1.58493966e-01f, 1.30066872e-02f, -9.75961089e-02f,
  1.56305939e-01f, 1.59091100e-01f, -2.24063218e-01f, -4.49197665e-02f, -7.50102252e-02f, 3.79813045e-01f, 2.55782604e-01f, 7.77674699e-03f, -2.02591568e-02f, 9.54285786e-02f,
  2.76306402e-02f, 6.32329062e-02f, 1.10447239e-02f, 3.82412285e-01f, 1.31841153e-01f, 1.97661653e-01f, 4.06667471e-01f, 3.24963480e-01f, 2.56894212e-02f, 1.28905892e-01f,
  1.27645265e-02f, 2.37332955e-01f, -2.50703275e-01f, -9.65924188e-02f, -1.02609936e-02f, -3.31329197e-01f, -2.74539322e-01f, -2.12610140e-01f, -6.03282638e-02f, 1.56124130e-01f,
  -1.87293906e-02f, -1.83649734e-02f, -1.64842363e-02f, -2.64813788e-02f, -6.85690641e-02f, 5.81946224e-03f, -6.23313151e-02f, -5.34900092e-02f, -5.05575538e-02f, 7.60020241e-02f,
  1.03938103e-01f, 5.99122345e-02f, 9.34577510e-02f, -1.08977415e-01f, -1.83236115e-02f, -8.47894028e-02f, 1.92758217e-02f, -5.70250526e-02f, -8.91679749e-02f, -4.15400751e-02f,
  -1.36182681e-01f, -2.23417319e-02f, -4.00931612e-02f, 2.93907262e-02f, -4.44428921e-02f, 8.06050003e-02f, 5.89424632e-02f, -5.68412580e-02f, 2.15989165e-02f, 9.02978480e-02f,
  -4.76996414e-02f, 9.10018533e-02f, 2.03804001e-02f, 1.34264147e-02f, 1.04179597e-02f, -5.43867424e-02f, -4.96173576e-02f, -3.88368145e-02f, 5.87606197e-03f, 3.07805389e-02f,
  -1.94144789e-02f, -2.70483922e-02f, 2.70230398e-02f, -5.42525528e-03f, 7.43035302e-02f, -9.33488924e-03f, 3.55786644e-02f, 5.66691682e-02f, -5.83593883e-02f, -9.95205492e-02f,
  -4.55862023e-02f, 6.33122474e-02f, -6.75225556e-02f, -1.41071826e-02f, 7.46452883e-02f, -7.66559271e-03f, 1.96662694e-02f, -8.81666392e-02f, -1.25674173e-01f, -2.94965226e-02f,
  9.05755609e-02f, 1.14503317e-01f, -2.73043737e-02f, 4.59022336e-02f, -7.32141454e-03f, 9.98551026e-02f, 3.63309979e-02f, -1.04024000e-02f, -3.78449224e-02f, 1.29464924e-01f,
  7.14909956e-02f, -1.17869712e-02f, -2.80340482e-02f, 2.37066969e-02f, -7.22600594e-02f, 2.17716601e-02f, 9.18019712e-02f, -4.30054478e-02f, -9.69345495e-02f, 1.49256578e-02f,
  -5.47385551e-02f, 1.10108420e-01f, 3.19067203e-02f, 6.45454973e-02f, 7.92593807e-02f, -6.63029682e-03f, -5.77202952e-03f, -1.96510460e-02f, -6.03156723e-02f, -5.85824857e-03f,
  -2.95968622e-01f, 1.52145848e-01f, -8.37627798e-02f, 1.27054513e-01f, 9.85491574e-02f, 1.53430685e-01f, 2.43802592e-01f, 1.45623907e-01f, 3.59022141e-01f, -5.24920505e-03f,
  -7.34491572e-02f, 5.63040636e-02f, -2.31689364e-02f, -6.09889179e-02f, -4.11753766e-02f, 9.87139642e-02f, 2.14624102e-03f, 1.20183654e-01f, 1.48299351e-01f, 6.44752160e-02f,
  -8.01911205e-02f, -4.32722755e-02f, -2.86897480e-01f, -1.29440408e-02f, -1.02563784e-01f, -1.13937603e-02f, -1.70538440e-01f, 9.81664360e-02f, -1.31123783e-02f, 4.33691591e-02f,
  2.16359249e-03f, 7.35322312e-02f, -8.43444318e-02f, -4.46453467e-02f, -5.81747442e-02f, -3.00188158e-02f, 1.41245678e-01f, 3.96547392e-02f, -2.50310786e-02f, 3.42749134e-02f,
  -2.93268450e-02f, 1.52460054e-01f, 1.12841500e-03f, 1.74533352e-01f, -2.91444990e-03f, -2.89173108e-02f, -4.01568413e-03f, -2.17598528e-02f, 1.12953633e-02f, 1.30100052e-05f,
  1.62107702e-02f, -3.81018743e-02f, 1.69950239e-02f, -6.36248440e-02f, -1.42294541e-01f, -5.15302531e-02f, 9.24074501e-02f, 9.24201384e-02f, 2.51347963e-02f, -9.13569406e-02f,
  2.02102680e-02f, 1.60385534e-01f, 4.09775898e-02f, -5.35653792e-02f, 3.31170484e-02f, -1.16116986e-01f, 1.21414252e-01f, -2.45175194e-02f, -1.38683066e-01f, -5.43883257e-02f,
  -8.55769962e-02f, 5.33900931e-02f, 1.02309816e-01f, 6.60922080e-02f, -4.37901244e-02f, 3.54769826e-02f, -9.38299745e-02f, -8.68359134e-02f, 9.59710926e-02f, 3.00081763e-02f,
  1.03579476e-01f, 5.75528555e-02f, -1.62048638e-01f, -9.51845497e-02f, -4.14941311e-02f, 3.91388685e-02f, 6.91130161e-02f, 5.42934053e-03f, -4.53711115e-02f, 7.78668523e-02f,
  8.46297108e-03f, 1.68488890e-01f, -3.51550686e-03f, -4.83442396e-02f, -4.23481613e-02f, -7.36023188e-02f, 1.52472839e-01f, 1.15970455e-01f, 1.77414849e-01f, 7.10557103e-02f,
  -9.25681815e-02f, 9.41446424e-02f, 7.15616420e-02f, 2.27080643e-01f, 3.33586559e-02f, -6.47746399e-02f, 9.00131315e-02f, 4.10246700e-02f, -7.81948194e-02f, -2.58270111e-02f,
  -5.83945215e-03f, 7.08219409e-02f, -3.30922194e-02f, -9.04433131e-02f, -1.67742774e-01f, 9.63786431e-03f, 1.89248249e-01f, -1.54270232e-02f, -1.38865471e-01f, -5.73757179e-02f,
  -3.35388839e-01f, 1.92792360e-02f, -1.21638030e-01f, -1.13710882e-02f, -2.90691942e-01f, 9.74239483e-02f, 1.92393944e-01f, -2.39064544e-02f, 8.70323479e-02f, 2.05266654e-01f,
  3.79285850e-02f, 3.36308777e-02f, 3.14348340e-01f, 2.19027013e-01f, -2.33120993e-01f, 1.70607775e-01f, 1.19829632e-01f, 2.04893015e-02f, 7.60879964e-02f, -7.75884278e-03f,
  -1.60235181e-01f, 1.42291859e-01f, -1.30498499e-01f, -3.78209986e-02f, -1.98990107e-01f, -1.71540290e-01f, 3.04022413e-02f, 1.03585552e-02f, -3.23493443e-02f, -1.36530235e-01f,
  7.68936798e-02f, 3.82258408e-02f, -3.53290923e-02f, 7.83496499e-02f, 9.91468877e-02f, -3.53009477e-02f, -2.69918591e-02f, -5.27642928e-02f, -3.66627760e-02f, 7.36777410e-02f,
  1.16608009e-01f, 2.87714954e-02f, 1.31645054e-01f, -1.41603932e-01f, -3.49449217e-02f, -7.54561722e-02f, -1.82881672e-03f, -4.89430241e-02f, 4.42746952e-02f, 6.62003160e-02f,
  -1.63971722e-01f, -1.12417407e-01f, -4.13775332e-02f, 7.79280290e-02f, 2.22161412e-02f, -5.30442782e-02f, 3.01713776e-02f, -3.77492979e-02f, -3.21173966e-02f, 3.24211456e-02f,
  -1.53514585e-02f, 5.30299544e-03f, 2.80160457e-02f, -6.64821714e-02f, -8.66798125e-03f, -2.04969924e-02f, -3.32747251e-02f, 8.54257792e-02f, 5.62906750e-02f, -1.68107405e-01f,
  7.66270980e-02f, 5.37809869e-03f, 3.71789113e-02f, -7.63031328e-03f, 1.21825159e-01f, 6.87094405e-02f, 1.71885286e-02f, -7.65285492e-02f, -8.21520481e-03f, -5.80416769e-02f,
  8.23775679e-02f, 1.18669141e-02f, 3.94022278e-02f, -6.27545873e-04f, 9.01742801e-02f, -1.64622255e-03f, 2.73781479e-03f, 7.19079748e-02f, 9.72968340e-02f, 3.44730727e-02f,
  8.48991238e-03f, -5.03913462e-02f, 6.43107221e-02f, -6.02987967e-02f, 6.91346377e-02f, -1.22830033e-01f, -1.83239393e-02f, -5.28572202e-02f, 9.75603424e-03f, -1.52795212e-02f,
  6.36646450e-02f, 5.98263629e-02f, -5.05121090e-02f, -6.84882328e-02f, 2.47349720e-02f, -7.51778996e-03f, 9.04602334e-02f, 6.45267218e-02f, -3.58737782e-02f, -1.11850478e-01f,
  -7.60765225e-02f, -4.01541181e-02f, 3.65934633e-02f, -7.61249438e-02f, 1.58849165e-01f, 1.48162572e-02f, -4.13641296e-02f, 7.59711787e-02f, -1.20260818e-02f, 4.90828343e-02f,
  2.39271581e-01f, -2.00623780e-01f, -6.06212951e-02f, 1.98367417e-01f, -1.15203731e-01f, 2.48694383e-02f, -1.00637622e-01f, -2.03881487e-01f, -2.83462197e-01f, -3.20078045e-01f,
  1.67003721e-01f, 6.91649970e-03f, 7.37753510e-02f, 1.63086489e-01f, 3.59877497e-01f, 9.92116146e-03f, 1.89437605e-02f, 1.74223669e-02f, 4.82455492e-02f, 1.04654863e-01f,
  1.21860489e-01f, 2.04959229e-01f, 1.23149909e-01f, -3.09483539e-02f, 5.75941168e-02f, -1.35108829e-01f, 1.41131133e-01f, 9.11121890e-02f, 2.95183528e-02f, -2.01429352e-02f,
  2.38463599e-02f, -3.43342908e-02f, 8.97469819e-02f, -3.15749161e-02f, -8.68527666e-02f, 1.34365976e-01f, 1.27730474e-01f, 1.20774463e-01f, 1.17768541e-01f, -3.64313833e-02f,
  8.88486654e-02f, 8.60056654e-02f, -7.21673891e-02f, 6.76781312e-02f, 8.34776163e-02f, -1.47927860e-02f, -1.00022726e-01f, -1.17157705e-01f, -5.94937392e-02f, 1.06032053e-02f,
  -3.04339360e-02f, -4.13698293e-02f, -2.36015636e-02f, -1.58495784e-01f, -9.52236876e-02f, -4.56387028e-02f, -8.59146342e-02f, 1.72084514e-02f, -7.01461509e-02f, -6.79537505e-02f,
  2.19709910e-02f, -9.34633315e-02f, 6.02870807e-02f, 4.91564609e-02f, -2.58267988e-02f, 6.04177006e-02f, -8.35199803e-02f, 7.29551166e-02f, 1.10007241e-01f, 6.17564246e-02f,
  2.57009305e-02f, 3.59357111e-02f, 2.97735315e-02f, 5.86816692e-04f, -2.94520985e-02f, -7.50705898e-02f, 8.67723227e-02f, 4.53183055e-02f, -6.19932525e-02f, 3.84844206e-02f,
  -1.04301147e-01f, 1.90658495e-02f, 1.41935050e-02f, -7.34138340e-02f, 8.22686963e-03f, 4.24136780e-02f, 8.54220316e-02f, 2.62267999e-02f, -1.19005084e-01f, 4.03239951e-03f,
  -1.59502737e-02f, -7.28415605e-03f, -5.60805015e-02f, -7.82813504e-02f, -6.89481422e-02f, 4.51809727e-02f, 4.26739007e-02f, -6.87780753e-02f, 1.50193851e-02f, 1.57963950e-02f,
  4.62783966e-03f, -1.69581864e-02f, -8.33273157e-02f, 8.59901682e-03f, 7.49919862e-02f, -5.43855764e-02f, 1.72856189e-02f, -3.29240449e-02f, -7.81253155e-04f, -3.11385114e-02f,
  -1.03653325e-02f, 3.12156286e-02f, -4.82145809e-02f, -5.05979881e-02f, 1.05633950e-02f, -1.24818966e-01f, 2.00720653e-02f, -7.72740841e-02f, 5.06328717e-02f, -1.46418167e-02f,
  -6.19840980e-01f, 9.59381983e-02f, -2.14756038e-02f, -3.81535619e-01f, -9.36145484e-02f, -1.27653554e-01f, -1.75653435e-02f, 3.82184312e-02f, -1.76136881e-01f, 6.10221960e-02f,
  3.41450274e-02f, -1.76553994e-01f, 2.42128089e-01f, 5.59449159e-02f, -7.77142271e-02f, 2.16361508e-01f, -1.75331339e-01f, -1.54923975e-01f, 7.16972426e-02f, -1.62776694e-01f,
  -1.53120443e-01f, -8.86196364e-03f, 2.85111535e-02f, 1.71396628e-01f, -1.01121619e-01f, -1.24766968e-01f, 4.87591513e-02f, 1.14990272e-01f, -3.25659439e-02f, 7.31128380e-02f,
  -3.09884787e-01f, -2.32311919e-01f, -2.35908285e-01f, -1.70734152e-01f, -1.31832495e-01f, -2.93180067e-02f, -2.78576817e-02f, -5.32660820e-02f, -1.07252374e-01f, 1.63454730e-02f,
  9.35820192e-02f, 6.25497103e-02f, -6.24612952e-03f, -1.06860930e-02f, -5.73589541e-02f, -5.28405420e-02f, 2.01636516e-02f, -7.22144023e-02f, 3.80965248e-02f, 6.29136199e-03f,
  4.74308692e-02f, -2.15172898e-02f, -5.25205843e-02f, 8.22995380e-02f, -9.91798751e-03f, -7.88748488e-02f, -6.47116005e-02f, 5.36451414e-02f, -1.01250239e-01f, -2.52414066e-02f,
  4.02915739e-02f, -6.17723539e-02f, 6.84853494e-02f, 1.89725608e-02f, 3.43679376e-02f, 2.37841625e-02f, -2.23531481e-02f, 2.54274290e-02f, -9.36550424e-02f, 5.61280455e-03f,
  2.11869683e-02f, -4.74695256e-03f, 6.05605543e-02f, -3.96983363e-02f, 4.69652191e-02f, -4.81715724e-02f, -2.05033496e-02f, -2.45501306e-02f, -5.05201854e-02f, -4.29729670e-02f,
  -6.39867187e-02f, 4.94473837e-02f, 4.12219241e-02f, -7.58673474e-02f, -4.93849106e-02f, -6.72739744e-03f, -5.23041487e-02f, 3.19458358e-02f, -6.75686589e-03f, -2.78961342e-02f,
  -3.89339238e-01f, -2.23754376e-01f, 9.18478239e-03f, -9.85423326e-02f, 9.01822560e-03f, -5.03607579e-02f, 2.50521488e-02f, 3.68845239e-02f, -8.39826316e-02f, 8.67146999e-03f,
  2.39406014e-03f, -6.90434948e-02f, -1.02094011e-02f, 7.01170694e-03f, 7.07593262e-02f, -5.88840321e-02f, -2.92850621e-02f, -4.58303131e-02f, -1.28647044e-01f, -5.12621477e-02f,
  -3.13038528e-02f, -5.18428460e-02f, 1.52321860e-01f, -5.36723286e-02f, -6.79613724e-02f, -3.73166315e-02f, -1.36565775e-01f, -2.93756984e-02f, 1.96724925e-02f, 5.10660261e-02f,
  -4.10405360e-02f, -5.43774478e-02f, -9.83531326e-02f, 1.19013689e-01f, -1.67832941e-01f, -1.25612050e-01f, -7.12943971e-02f, -1.49249852e-01f, 8.83084089e-02f, 9.36377868e-02f,
  -1.13165334e-01f, 2.24125296e-01f, 3.73405851e-02f, -2.24338844e-01f, -9.22205076e-02f, -3.46705392e-02f, -2.41599813e-01f, 1.13464288e-01f, 2.53618765e-03f, -9.46765766e-02f,
  -9.53224301e-02f, -2.76652664e-01f, -7.69712254e-02f, -1.93869457e-01f, -2.10348293e-01f, -8.24223913e-04f, 1.26173049e-01f, 1.70829296e-02f, 1.34105429e-01f, 1.11872107e-01f,
  1.56914189e-01f, 2.54485786e-01f, -7.71088451e-02f, 1.04671828e-02f, -8.13337192e-02f, -7.06826746e-02f, -8.75352975e-03f, 2.21406519e-02f, 1.73502311e-01f, 4.96325381e-02f,
  -1.96029376e-02f, 4.92469482e-02f, -9.67937931e-02f, -1.71302781e-02f, 2.73378175e-02f, 2.52862200e-02f, -1.10795267e-01f, 7.29696825e-02f, 7.27575347e-02f, -9.82230995e-04f,
  -3.05315517e-02f, 9.07914434e-03f, -1.48180857e-01f, 1.44528970e-01f, -4.15764116e-02f, 2.42764074e-02f, 4.13653404e-02f, 7.75960162e-02f, 9.49070975e-03f, 4.43785563e-02f,
  -1.04708076e-01f, -1.16500579e-01f, -2.54632323e-03f, 5.51979840e-02f, 8.30504578e-03f, 1.11505806e-01f, -1.69987977e-01f, 9.34177116e-02f, 3.93801592e-02f, -1.41322449e-01f,
  9.99655649e-02f, 4.78964709e-02f, -1.34496480e-01f, -1.27415389e-01f, -1.11383490e-01f, 1.82371885e-01f, 1.16142809e-01f, 9.93592069e-02f, -9.20491889e-02f, 6.22884743e-02f,
  1.15057074e-01f, -5.61715383e-03f, -9.32246596e-02f, -8.85711517e-03f, -5.31287231e-02f, -9.63667501e-03f, -6.44334853e-02f, 6.33611232e-02f, 2.14066319e-02f, 1.34147545e-02f,
  1.20479800e-01f, 6.46649227e-02f, -3.62083018e-02f, 8.51352215e-02f, 4.99005951e-02f, -1.14561291e-02f, -1.02236085e-01f, -8.80909413e-02f, 1.12312637e-01f, -1.07593164e-01f,
  -1.76336199e-01f, 5.00661135e-03f, 4.67306226e-02f, -5.09484559e-02f, -1.25840334e-02f, -1.87539514e-02f, 1.03171408e-01f, 5.19782724e-03f, -9.82336979e-03f, 2.98179109e-02f,
  -1.01457566e-01f, 4.32962738e-02f, -1.42419748e-02f, -1.18215337e-01f, 3.83537784e-02f, 1.06891409e-01f, 4.95639332e-02f, 6.07811771e-02f, 8.85331538e-03f, -5.61654707e-03f,
  -9.79444012e-02f, -1.84869245e-01f, 1.65398791e-01f, -1.55357376e-01f, -2.93177720e-02f, 5.48074022e-02f, 1.30010039e-01f, -1.70749113e-01f, -2.10120425e-01f, -2.09132522e-01f,
  -2.01180037e-02f, 3.53663377e-02f, 2.89541453e-01f, -1.32827580e-01f, 4.56358761e-01f, 1.71068251e-01f, -1.14692248e-01f, -5.80185056e-02f, -2.71357801e-02f, -2.44600311e-01f,
  -6.02762662e-02f, -1.98862344e-01f, 3.87046933e-02f, -3.43671888e-01f, -6.50635213e-02f, -1.99068055e-01f, -7.29872063e-02f, 1.44544825e-01f, -2.40344450e-01f, 4.64578755e-02f,
  6.00269437e-03f, -1.52571768e-01f, -7.55518377e-02f, -3.36478502e-02f, -1.35871783e-01f, -4.99410294e-02f, -1.40710231e-02f, 1.43867910e-01f, 1.51041867e-02f, 4.52721305e-02f,
  5.99656962e-02f, -6.44451827e-02f, -6.25855848e-02f, 7.09792506e-03f, -1.51404649e-01f, -9.29494053e-02f, 6.85306918e-03f, -1.24612516e-02f, -9.40446332e-02f, 4.81088459e-02f,
  -5.35033736e-03f, 1.02545917e-01f, -7.07713887e-03f, -2.95234267e-02f, 1.10460902e-02f, -1.52258936e-03f, 5.49054891e-02f, 8.41865018e-02f, 2.38967463e-02f, -4.33757994e-03f,
  -6.23951033e-02f, -3.40328063e-03f, 4.80381623e-02f, -9.81182754e-02f, 5.69292866e-02f, -1.18285686e-01f, 1.00537464e-01f, -7.09594414e-02f, -5.70855960e-02f, -6.66745752e-02f,
  -4.54173461e-02f, -6.87040836e-02f, 3.62806767e-02f, -5.20306863e-02f, 5.78209572e-03f, -6.34852052e-02f, -8.52780044e-02f, -3.96033525e-02f, 4.89770100e-02f, -4.35442179e-02f,
  6.28412664e-02f, 1.49215255e-02f, -2.47777309e-02f, -7.66993733e-03f, 5.97365759e-02f, 8.65064189e-02f, 2.34996956e-02f, -5.53170033e-02f, -8.63004709e-04f, 1.30214229e-01f,
  -1.34201616e-01f, -2.87756115e-01f, -4.22396138e-02f, -8.95997062e-02f, 9.97529179e-03f, 5.31033576e-02f, -1.15979709e-01f, -3.48319719e-03f, 1.42962513e-02f, -1.16109010e-02f,
  -1.62248928e-02f, -5.76775968e-02f, 3.91927846e-02f, -1.49216939e-04f, 3.33002041e-04f, -2.96996683e-02f, -4.76888008e-03f, -4.57457714e-02f, 7.18798628e-03f, -7.48225600e-02f,
  -9.38960612e-02f, 3.48013751e-02f, 4.65350552e-03f, -1.54829651e-01f, -3.18371654e-02f, 7.13013560e-02f, -3.49658690e-02f, -4.58070450e-02f, 4.63697407e-03f, -3.69617180e-03f,
  6.91953376e-02f, 2.13966712e-01f, -1.88222453e-01f, -1.18524462e-01f, -8.76000300e-02f, -2.77610749e-01f, -1.81265727e-01f, -1.04523517e-01f, -6.37766644e-02f, -6.67303130e-02f,
  -1.13593280e-01f, 2.62602508e-01f, 1.05541557e-01f, -2.51675993e-01f, -1.17360331e-01f, 5.20448387e-02f, -8.09238479e-02f, -3.24631371e-02f, -7.06190756e-03f, -8.65227655e-02f,
  2.24950965e-02f, 2.66233869e-02f, 3.25354300e-02f, 4.38364521e-02f, -9.08959731e-02f, 4.31207493e-02f, -7.17533305e-02f, -1.09316960e-01f, -5.60940616e-02f, -1.16624840e-01f,
  -2.78589666e-01f, 5.97841442e-02f, 2.27127690e-02f, -7.73340836e-02f, -3.95613387e-02f, -6.28561527e-02f, -1.05911352e-01f, -9.33453590e-02f, -1.83065049e-03f, 3.90203372e-02f,
  1.45994589e-01f, -3.83109264e-02f, -1.15247265e-01f, 2.21870057e-02f, 1.23436034e-01f, -4.27194797e-02f, -8.55336040e-02f, -1.38423309e-01f, -4.30681780e-02f, 2.28116065e-02f,
  -9.15371701e-02f, -1.04125611e-01f, 4.23666872e-02f, -1.50579866e-02f, 6.89547183e-03f, -7.34423175e-02f, -5.17091192e-02f, 5.50492993e-03f, -1.85010713e-02f, 5.37618734e-02f,
  8.86200443e-02f, 5.46523661e-04f, -8.40935111e-02f, -2.88861003e-02f, -8.87097046e-02f, -7.62178302e-02f, 3.46656516e-02f, 2.68323999e-02f, 5.66785783e-02f, -3.46264802e-02f,
  -4.73523140e-02f, -1.72683503e-02f, 1.22542270e-01f, 2.75885854e-02f, 6.69348612e-02f, -3.94532345e-02f, 1.82935186e-02f, -4.57739085e-02f, 2.05980688e-02f, -4.38270867e-02f,
  -9.52008888e-02f, -3.13922064e-03f, 3.79842222e-02f, -5.45887649e-02f, 2.15595011e-02f, 6.35374784e-02f, 6.18107729e-02f, -4.91937771e-02f, -9.05217975e-02f, 4.02131043e-02f,
  -3.00935537e-01f, -2.55866498e-01f, 7.95688629e-02f, -2.58330144e-02f, 1.70421868e-03f, 6.62876433e-03f, -1.36130098e-02f, 7.92972371e-02f, -9.82714724e-03f, -1.14144236e-01f,
  5.57624400e-02f, 1.27477683e-02f, -2.81341318e-02f, -3.89106497e-02f, 4.58444357e-02f, -5.36101423e-02f, -1.22210629e-01f, -5.98176233e-02f, -4.33392301e-02f, 2.09430885e-03f,
  -3.03915907e-02f, 1.20234415e-01f, 3.94754112e-02f, 6.11935183e-02f, 6.81410581e-02f, -5.33951409e-02f, 5.59915006e-02f, -5.65740429e-02f, 5.13245985e-02f, 2.09307149e-02f,
  -1.02673396e-01f, 2.33017907e-01f, 2.04217341e-02f, 1.82322208e-02f, 2.17743590e-01f, -3.65650147e-01f, -1.50517181e-01f, 3.50100100e-02f, -1.76267564e-01f, -1.24604210e-01f,
  -7.02065974e-02f, 1.87058046e-01f, 8.66475254e-02f, -8.07320625e-02f, -4.88120794e-01f, -2.24847257e-01f, -1.61946252e-01f, -6.70256764e-02f, 1.20881207e-01f, 8.31405073e-02f,
  -7.74704560e-04f, 6.26711175e-02f, -2.12419014e-02f, 1.50786072e-01f, 7.21759051e-02f, 2.02018142e-01f, -1.53983667e-01f, 1.19816512e-01f, -4.85711098e-02f, -5.88540509e-02f,
  -1.02295451e-01f, 2.00622100e-02f, 2.16908101e-02f, -1.13215491e-01f, -1.26863837e-01f, 1.02037847e-01f, -1.47107437e-01f, 6.00217395e-02f, 9.78583843e-03f, -2.42826212e-02f,
  2.36494299e-02f, -1.17640726e-01f, 7.72442594e-02f, 4.16968688e-02f, 7.50994869e-03f, -1.33177089e-02f, -4.60308753e-02f, 7.18709826e-02f, 7.19388425e-02f, 4.71869707e-02f,
  -2.94298045e-02f, 7.47500584e-02f, -1.25750273e-01f, -8.33160430e-02f, -5.67001887e-02f, 3.95494699e-02f, 1.96390180e-03f, -5.05343229e-02f, -3.27588245e-02f, -1.57065392e-01f,
  -6.10938780e-02f, -1.32716363e-02f, 3.08766216e-02f, 8.05650800e-02f, -3.18199918e-02f, 7.74514526e-02f, -1.01718549e-02f, -3.32608353e-03f, -3.53860073e-02f, -6.19085738e-03f,
  -8.33155587e-02f, 2.81011104e-03f, 8.94737467e-02f, -5.66388182e-02f, -5.15125319e-02f, 7.22257495e-02f, 3.54575296e-03f, 5.17676026e-02f, 3.59363370e-02f, -1.02074407e-01f,
  2.72542681e-03f, -1.09072998e-01f, 9.86294374e-02f, 1.12643510e-01f, 4.09422182e-02f, 2.36363094e-02f, 1.32308498e-01f, -5.17749786e-02f, 4.53295521e-02f, 1.36598228e-02f,
  -2.06715941e-01f, -3.55771244e-01f, 6.73474744e-02f, -7.56973103e-02f, 3.20240222e-02f, -3.56172621e-02f, -3.62038799e-02f, -8.49996284e-02f, -1.56238467e-01f, -1.15348950e-01f,
  2.82061324e-02f, 4.12176438e-02f, -5.82483932e-02f, -5.15467413e-02f, -3.56271490e-02f, -6.07556924e-02f, 1.56476572e-02f, -1.53138503e-01f, -6.66537210e-02f, 6.07271865e-02f,
  -3.81439668e-03f, 4.46261950e-02f, -8.95577595e-02f, -6.98647350e-02f, -6.22389428e-02f, 9.35856160e-03f, -5.67279123e-02f, 3.47299641e-03f, 4.77566849e-03f, -5.19507416e-02f,
  1.20737903e-01f, -1.21715337e-01f, -1.03324153e-01f, 1.12234399e-01f, -5.46514355e-02f, -8.85373130e-02f, -2.59654522e-02f, -1.31107762e-01f, -2.90639848e-01f, -1.58340856e-01f,
  1.77152053e-01f, 6.67815357e-02f, 1.66527689e-01f, 2.15884075e-01f, 3.92299622e-01f, 6.49897754e-02f, 1.39243603e-01f, 3.92811038e-02f, 6.64379522e-02f, 7.06426203e-02f,
  2.13842630e-01f, 2.58954734e-01f, 4.16776270e-01f, 4.29532528e-02f, 4.60282080e-02f, 4.82671410e-02f, 1.31221876e-01f, 7.17439353e-02f, 9.48558077e-02f, 1.80501416e-01f,
  1.18721269e-01f, -3.26019712e-02f, 3.49323228e-02f, 8.09610635e-02f, 7.80208334e-02f, 8.95204917e-02f, 3.95108946e-02f, 1.56809285e-01f, -5.28709963e-02f, -1.72160104e-01f,
  -5.67604192e-02f, -6.27759099e-03f, 5.91465570e-02f, 1.22681499e-01f, 1.39574017e-02f, -5.20279519e-02f, -6.14924692e-02f, -2.59490814e-02f, -1.59207404e-01f, 1.00584608e-02f,
  -2.01009400e-02f, -8.25128481e-02f, -6.70307651e-02f, 2.39586993e-03f, 1.03527599e-03f, -7.36977383e-02f, -7.96961263e-02f, 1.22135162e-01f, -1.31018326e-01f, -1.33032471e-01f,
  4.30591926e-02f, -3.11280787e-02f, 3.13642547e-02f, 7.01631233e-02f, 8.05876125e-03f, -8.65598954e-03f, -6.60555810e-02f, -1.11047067e-01f, 8.99192765e-02f, -2.76414603e-02f,
  -1.16402589e-01f, 1.48183787e-02f, 2.84161940e-02f, -1.05600648e-01f, 8.55581090e-02f, -4.00794670e-02f, 4.22044657e-02f, -6.51573464e-06f, -1.27833979e-02f, 1.98653676e-02f,
  -1.70119293e-02f, 2.17702379e-03f, -6.47009397e-03f, 8.94098803e-02f, 1.01924809e-02f, -4.25780788e-02f, 1.43099064e-03f, 1.33831650e-02f, 8.15675333e-02f, 7.53282085e-02f,
  4.16099392e-02f, -1.58326011e-02f, 2.10501421e-02f, 6.14142343e-02f, -2.06199917e-03f, -3.31726521e-02f, 1.24228537e-01f, -2.81560645e-02f, 3.80470529e-02f, -1.08723985e-02f,
  1.33010834e-01f, 2.08039638e-02f, -4.82653230e-02f, 3.11133917e-02f, 6.82737678e-02f, -2.68607662e-04f, -9.28292572e-02f, -1.00362413e-01f, -5.52649572e-02f, 7.54834861e-02f,
  -4.13312912e-02f, -1.77269742e-01f, 2.52461545e-02f, -3.78845409e-02f, -9.77193639e-02f, -2.21476965e-02f, 7.69841149e-02f, -8.64941031e-02f, 2.44138706e-02f, -3.69047076e-02f,
  2.88895965e-01f, -2.21861184e-01f, -9.47353989e-02f, 1.82441309e-01f, 1.76368296e-01f, 8.92430171e-02f, -1.12346724e-01f, 2.79130600e-02f, 1.78372130e-01f, -1.88817143e-01f,
  -3.91851217e-02f, -1.48190558e-01f, -2.46360123e-01f, 1.18348747e-01f, 2.03149155e-01f, -2.07624391e-01f, 2.11332425e-01f, -1.13190368e-01f, -6.62985817e-02f, 3.28658596e-02f,
  1.72977850e-01f, 2.72512287e-01f, -5.64258359e-02f, 9.92584508e-04f, 5.16327238e-03f, 2.89231334e-02f, -4.12708428e-03f, -2.11090595e-01f, -3.14051621e-02f, -1.02739170e-01f,
  5.68959713e-02f, -2.05924939e-02f, 3.91018093e-02f, -5.36802113e-02f, -3.99705954e-02f, -8.76902789e-02f, -5.41643873e-02f, -6.32380843e-02f, -7.68122599e-02f, 4.16416861e-02f,
  3.50029394e-02f, 1.81078867e-04f, -1.40443705e-02f, 5.56345694e-02f, 9.07296464e-02f, -1.05287321e-03f, 4.24564742e-02f, -2.45255157e-02f, -7.16283247e-02f, 1.58921685e-02f,
  -1.09581798e-01f, 3.36583355e-03f, -8.24585557e-03f, -6.37957677e-02f, 4.26533185e-02f, 4.30462249e-02f, -4.03042771e-02f, -1.06487244e-01f, -1.28138006e-01f, 8.76942426e-02f,
  5.78243807e-02f, -1.96339041e-02f, 2.62379013e-02f, 3.18403058e-02f, 1.21813223e-01f, -1.52351074e-02f, 3.78411375e-02f, -3.90570723e-02f, 2.02642419e-04f, 1.88703195e-03f,
  4.49889563e-02f, -1.55066233e-02f, 5.29164411e-02f, 3.01160347e-02f, 6.81678802e-02f, -7.95700178e-02f, -2.86483206e-02f, -2.31856238e-02f, 2.34985651e-04f, 1.03760488e-01f,
  -4.12728228e-02f, 3.70880477e-02f, 2.73522479e-03f, -4.29340173e-03f, 2.44330913e-02f, 2.32409611e-02f, 7.52579272e-02f, 1.26030624e-01f, -5.90476692e-02f, -4.85865623e-02f,
  -1.22486036e-02f, -5.74221127e-02f, -1.16246067e-01f, 6.70575574e-02f, -1.68520864e-02f, 1.24417782e-01f, -1.12238355e-01f, 1.15912355e-01f, -5.09080775e-02f, 5.91151640e-02f,
  7.45681599e-02f, -5.70009016e-02f, -6.27020746e-03f, 7.72976130e-02f, -2.12543849e-02f, -1.22011043e-02f, -8.64809304e-02f, -6.50624037e-02f, -8.41681808e-02f, 2.58731209e-02f,
  6.25248775e-02f, 3.37217823e-02f, -7.92134404e-02f, 1.98654626e-02f, 2.60998514e-02f, 5.00068702e-02f, 8.93544406e-02f, -5.70553355e-02f, 1.89145058e-02f, -4.48671402e-03f,
  -5.31740665e-01f, 1.92428946e-01f, -1.17358238e-01f, 8.18716362e-02f, -5.03772348e-02f, 1.71042889e-01f, 2.67962068e-01f, -1.22168638e-01f, 1.70893371e-01f, 2.47775644e-01f,
  1.26065284e-01f, 2.90355012e-02f, 1.38004392e-01f, 2.52582759e-01f, -1.16775982e-01f, 2.94028133e-01f, 3.00859567e-02f, 3.68969738e-02f, 4.24279124e-02f, -1.56246364e-01f,
  -1.13902502e-01f, 2.84987725e-02f, 2.22129095e-02f, -4.85459603e-02f, -1.42485335e-01f, -9.18333977e-03f, 9.64513943e-02f, 1.05238907e-01f, 8.53446350e-02f, 1.78022414e-01f,
  -1.45688415e-01f, -1.73228547e-01f, -6.39875680e-02f, -4.77708243e-02f, -1.59415781e-01f, -1.55893385e-01f, 7.01860338e-02f, 1.05224736e-01f, -1.04667716e-01f, -2.97753680e-02f,
  -1.57888029e-02f, -1.30933180e-01f, 7.39679555e-04f, 5.30269407e-02f, 3.85857299e-02f, -5.74465543e-02f, 4.67455462e-02f, -2.11151987e-02f, -7.46074244e-02f, -8.07713345e-02f,
  2.27443390e-02f, 6.95931092e-02f, 1.20226210e-02f, -4.07636948e-02f, 6.54073944e-03f, 1.71429127e-01f, 4.81779836e-02f, -1.68241058e-02f, -1.37843592e-02f, 5.75338379e-02f,
  -2.74494272e-02f, 8.92379358e-02f, 1.15572307e-02f, 8.13934430e-02f, 1.06283709e-01f, 3.24078277e-02f, 8.07671528e-03f, -1.20259393e-02f, 2.55591385e-02f, 2.54462752e-02f,
  3.13574560e-02f, 1.42821493e-02f, -1.41098276e-01f, -2.93671433e-03f, 1.53662432e-02f, 4.66709025e-02f, -1.41900226e-01f, 1.12194503e-02f, -2.21281359e-03f, -9.22754221e-03f,
  -4.36407141e-02f, 5.19700050e-02f, 9.02008712e-02f, 2.56581269e-02f, -6.89716563e-02f, -5.46915978e-02f, -7.16769209e-05f, 1.06944132e-03f, -4.39334475e-02f, -1.96407009e-02f,
  1.19369626e-01f, -2.26696674e-02f, 1.43986186e-02f, 7.62134045e-03f, 4.19998504e-02f, -2.30777152e-02f, 7.10887536e-02f, -7.09255487e-02f, 1.57322988e-01f, 7.73784518e-02f,
  -4.56254333e-02f, 4.60646749e-02f, -1.92854762e-01f, 1.70781109e-02f, 6.48561120e-02f, 7.40619302e-02f, -7.72660971e-02f, -8.45868662e-02f, 3.10061071e-02f, 3.23360674e-02f,
  -1.15152234e-02f, -4.81358208e-02f, -5.04050255e-02f, 2.80596167e-02f, 4.45011146e-02f, 4.34625559e-02f, -3.36677656e-02f, 2.18112227e-02f, 4.06745747e-02f, 2.06250548e-02f,
  -1.55721709e-01f, -2.64546461e-03f, -1.91132367e-01f, 2.55039185e-01f, -2.77921669e-02f, -1.21386610e-01f, -8.92878026e-02f, 1.32796273e-01f, 1.82684674e-03f, 1.63824946e-01f,
  1.79307431e-01f, 1.00624412e-01f, 4.36427370e-02f, 4.25646961e-01f, 2.90695459e-01f, 3.86828147e-02f, 1.49563670e-01f, 1.20419562e-01f, 4.61038314e-02f, 6.31474853e-02f,
  1.67437077e-01f, 2.54778266e-01f, 2.60242254e-01f, 1.07547536e-01f, 1.36761948e-01f, 9.34415217e-03f, 2.72914022e-01f, -1.24862172e-01f, 2.78057635e-01f, 1.28300279e-01f,
  4.30059806e-02f, 9.55559984e-02f, -8.47194642e-02f, -3.21497209e-02f, -7.76472241e-02f, -3.74223702e-02f, -5.44175170e-02f, -7.91345760e-02f, -2.09903228e-03f, -2.89770262e-03f,
  -1.41840324e-01f, 5.74943535e-02f, 1.32999206e-02f, -1.90429226e-03f, -1.17453001e-01f, 4.04221006e-02f, -4.31178957e-02f, 1.08810268e-01f, -6.33714050e-02f, -3.52340266e-02f,
  -1.07172774e-02f, -1.02984130e-01f, -1.54771674e-02f, 7.32152313e-02f, 1.20665999e-02f, -5.15351482e-02f, -4.78189662e-02f, -1.94292739e-02f, -1.16244508e-02f, -1.00087643e-01f,
  6.68917522e-02f, -5.63971959e-02f, -5.04604317e-02f, -2.77199154e-03f, 1.03226073e-01f, 3.45073901e-02f, 2.71452554e-02f, 3.83188128e-02f, 2.34005935e-02f, 1.29329376e-02f,
  4.49381769e-02f, 1.20173190e-02f, -8.73011276e-02f, -1.84103977e-02f, -2.27724854e-02f, -3.22032273e-02f, 1.11685365e-01f, 2.20700670e-02f, 2.50468217e-02f, -5.49932495e-02f,
  4.90277782e-02f, -7.04749078e-02f, 2.74813566e-02f, 3.97137031e-02f, -3.27636674e-02f, 6.38876632e-02f, 4.11644811e-03f, -2.15064902e-02f, -4.36548330e-03f, 2.64739729e-02f,
  1.06465807e-02f, 8.44239891e-02f, 1.58034023e-02f, -8.62248465e-02f, 2.89471131e-02f, -1.23948622e-02f, -4.98571768e-02f, 7.89199695e-02f, 8.05212259e-02f, 4.04124223e-02f,
  -6.18592463e-02f, 7.63425827e-02f, 1.83207896e-02f, 5.45321740e-02f, -5.55390902e-02f, 3.13822813e-02f, -8.70247930e-03f, 8.17077756e-02f, 1.24518991e-01f, -5.39440066e-02f,
  -5.73664047e-02f, -4.13501561e-02f, -1.92262828e-02f, 2.64763031e-02f, 2.54217032e-02f, -1.46713704e-01f, -1.22216986e-02f, 5.35193905e-02f, -1.03443086e-01f, -1.85196344e-02f,
  1.10334326e-02f, -3.25578637e-02f, 1.93891317e-01f, -2.56564826e-01f, -1.44529432e-01f, -2.46453244e-04f, -1.51487142e-01f, -5.34800254e-02f, -1.20518701e-02f, -1.16182350e-01f,
  -1.61540970e-01f, 2.13873714e-01f, 1.10946521e-01f, -1.58861160e-01f, 3.06676716e-01f, 1.99085847e-01f, -4.94140945e-02f, 8.38856101e-02f, -7.01235458e-02f, -6.01953156e-02f,
  -1.28904015e-01f, -2.15422839e-01f, 7.39851817e-02f, -1.90269068e-01f, -1.15253277e-01f, -8.04717168e-02f, 2.55714078e-02f, -7.06228018e-02f, -1.08806312e-01f, 1.24588147e-01f,
  -5.28232381e-02f, -7.17100129e-02f, 6.71040500e-03f, -3.89448437e-03f, -1.86853241e-02f, 9.36420783e-02f, 5.18969931e-02f, 8.37886930e-02f, -6.28149435e-02f, -1.00582331e-01f,
  1.35989100e-01f, 6.46175668e-02f, -3.77685130e-02f, 1.63559746e-02f, -7.02291727e-02f, -3.92152853e-02f, 2.00052746e-02f, 7.14101642e-02f, 3.68166715e-02f, 1.33616611e-01f,
  7.44360089e-02f, -6.34706765e-02f, -2.53398367e-03f, -2.33264230e-02f, 7.89862052e-02f, -2.58787703e-02f, 4.29373570e-02f, 1.06163114e-01f, -1.68136749e-02f, -2.77070161e-02f,
  1.05453096e-02f, -4.03677039e-02f, -6.39508143e-02f, -7.01119155e-02f, -8.96520738e-04f, 7.93266296e-02f, 5.29120639e-02f, 2.29436029e-02f, -1.43374577e-02f, 4.22915909e-03f,
  -4.00676765e-02f, -4.88051176e-02f, -8.28908570e-03f, -5.42196743e-02f, -9.66164470e-03f, -4.32932936e-02f, 5.03148213e-02f, 4.66793068e-02f, 4.02642675e-02f, -1.07163768e-02f,
  -1.24554941e-02f, 7.73690492e-02f, 9.77558717e-02f, 2.47636978e-02f, -7.18903095e-02f, 9.34390798e-02f, 7.69437402e-02f, 6.02093786e-02f, -4.02197391e-02f, -9.18641128e-03f,
  -7.41922632e-02f, -2.20242500e-01f, -4.58016321e-02f, 5.95496483e-02f, -2.53186468e-02f, 3.96863446e-02f, 4.65754531e-02f, -3.38232331e-02f, -4.36282530e-02f, 3.20013991e-04f,
  -2.52367631e-02f, -3.33172120e-02f, 8.24355558e-02f, -5.00660986e-02f, 3.16313617e-02f, 2.19396502e-02f, -7.24612102e-02f, 8.52842163e-03f, -8.39938521e-02f, 7.25887343e-02f,
  5.14874682e-02f, 4.87010963e-02f, 8.34643841e-02f, -1.26599651e-02f, -4.81154583e-02f, 4.90914611e-03f, 2.58965287e-02f, -5.23766801e-02f, -8.77259951e-03f, 4.53946292e-02f,
  -6.67401314e-01f, 1.74947813e-01f, -1.23264998e-01f, -3.81944738e-02f, -1.03514642e-01f, 3.54782671e-01f, 3.56356204e-01f, -1.17054529e-01f, -1.15941897e-01f, 1.96960419e-01f,
  1.06524713e-01f, -1.70750007e-01f, 1.26385689e-01f, 1.29370943e-01f, 1.81267783e-01f, 2.03886464e-01f, 2.78071940e-01f, 1.26131505e-01f, 1.55390128e-02f, -1.33226007e-01f,
  -6.81750253e-02f, 1.54883027e-01f, 8.42539147e-02f, -1.41972020e-01f, -1.36346877e-01f, -2.09458739e-01f, -1.25381067e-01f, -3.53325531e-02f, 3.72635908e-02f, -2.79815271e-02f,
  -1.08101666e-01f, -4.12242144e-01f, -9.78837758e-02f, -5.57693057e-02f, -7.67802214e-03f, 2.56904792e-02f, -3.20428913e-03f, -3.51298600e-02f, -8.84222910e-02f, -2.44427044e-02f,
  -5.96054457e-03f, -8.68671536e-02f, -1.88874789e-02f, -9.16404743e-03f, 4.35769558e-02f, -5.71794398e-02f, 1.16653778e-02f, 8.52591693e-02f, 5.22847138e-02f, 4.93170582e-02f,
  3.14585418e-02f, 1.25941560e-01f, 8.75796080e-02f, 1.32606149e-01f, 1.49818743e-02f, -5.60025498e-02f, 1.25609800e-01f, -9.24732015e-02f, 9.66516212e-02f, 3.59854549e-02f,
  -7.86623359e-02f, -1.81114987e-01f, 6.46351948e-02f, -7.95713887e-02f, -6.42087264e-03f, -2.62146525e-04f, -2.09976882e-02f, -1.52189173e-02f, -4.48301807e-02f, 4.45480971e-03f,
  3.41028459e-02f, -1.01119444e-01f, -5.94707653e-02f, 5.93660697e-02f, -5.82437254e-02f, 5.97336031e-02f, -3.73183638e-02f, -3.46839316e-02f, 5.26401214e-04f, 7.45492429e-02f,
  -1.83205791e-02f, -1.68134109e-03f, 2.67667063e-02f, 5.16943596e-02f, -1.48482993e-02f, -1.89208221e-02f, -1.26671651e-02f, -1.32574784e-02f, -6.01737993e-03f, -6.21683560e-02f,
  1.50260955e-01f, -1.54069155e-01f, 3.36609036e-02f, -4.22681123e-02f, 4.31545414e-02f, -1.14471633e-02f, -6.90188399e-03f, 3.42555414e-03f, -8.85377899e-02f, -9.27017927e-02f,
  -2.25026775e-02f, -1.16550364e-01f, 7.87533224e-02f, 2.01495271e-02f, 1.35789029e-02f, 3.81771699e-02f, -3.06244362e-02f, -2.38669571e-02f, 1.35170817e-01f, -6.60853460e-02f,
  7.12854266e-02f, 7.80660212e-02f, -5.77201657e-02f, -3.06779053e-02f, -3.60982306e-02f, 5.06140478e-02f, -5.97435720e-02f, -4.25039046e-02f, 9.44511890e-02f, 4.32983935e-02f,
  -1.72838464e-01f, 5.64551391e-02f, -3.56473207e-01f, 1.31926373e-01f, -1.40562981e-01f, 1.98900461e-01f, 1.26334831e-01f, -2.20074598e-02f, -2.12283924e-01f, 9.49025527e-02f,
  3.02656621e-01f, -1.39945626e-01f, -5.38161816e-03f, 3.74536157e-01f, 1.90192372e-01f, 2.36918762e-01f, 2.71212965e-01f, 1.47296980e-01f, -1.22708566e-01f, -5.50632505e-03f,
  -1.32448748e-01f, 2.76518017e-01f, 2.09189430e-01f, 1.78028360e-01f, 1.44404247e-01f, -1.69685304e-01f, 8.62388909e-02f, -1.33062229e-01f, 1.89355984e-01f, 9.54580829e-02f,
  8.52022693e-02f, -1.53137252e-01f, -1.19228698e-01f, 7.47618638e-03f, -4.62397076e-02f, -2.85738166e-02f, -4.71975617e-02f, -5.83052263e-02f, -6.38309568e-02f, -5.39282449e-02f,
  -2.34750863e-02f, -1.52606284e-04f, 4.06162590e-02f, -3.00108436e-02f, -9.58572328e-02f, -2.09897924e-02f, 4.98235114e-02f, 3.55629772e-02f, 6.37101829e-02f, 5.47615960e-02f,
  -4.04148214e-02f, 4.61858138e-02f, -3.29738930e-02f, 2.80992519e-02f, -1.15487292e-01f, -1.22231646e-02f, 2.05967426e-02f, 5.50418086e-02f, 1.01040915e-01f, 5.36492094e-02f,
  -3.14629637e-02f, -8.44040364e-02f, 2.87753716e-02f, 7.87232071e-03f, 1.67374518e-02f, 4.37547341e-02f, 8.76440778e-02f, 7.82762170e-02f, -1.48056269e-01f, 8.48890245e-02f,
  -8.79038312e-03f, -4.25064638e-02f, 9.29133371e-02f, 2.14593695e-03f, -2.71854512e-02f, 7.40531236e-02f, -8.51555094e-02f, 7.11162463e-02f, -1.84645550e-03f, -1.92459263e-02f,
  -1.40281608e-02f, -6.81788288e-03f, 1.34621533e-02f, -2.83197183e-02f, 1.27355069e-01f, -4.61274050e-02f, 4.34444770e-02f, 1.49122905e-03f, 1.10573508e-02f, -8.18216726e-02f,
  6.18137829e-02f, -8.96671861e-02f, 5.07970266e-02f, 3.31083462e-02f, -7.82351717e-02f, 4.33673970e-02f, -5.68459183e-03f, 6.81604892e-02f, 7.84551576e-02f, -2.36943811e-02f,
  -4.39029187e-02f, 2.64474228e-02f, 4.56956886e-02f, 1.30681563e-02f, 7.17525482e-02f, -4.65487130e-03f, 5.04888333e-02f, 1.05460277e-02f, -5.35516143e-02f, -8.18880089e-03f,
  4.80734697e-03f, 4.58711572e-02f, -1.90715387e-03f, -4.34690155e-02f, -3.57606448e-02f, -3.05903871e-02f, 1.53866382e-02f, -6.00265339e-02f, -5.73066100e-02f, 6.49694027e-03f,
  1.80651337e-01f, -2.09751204e-01f, -4.11763340e-01f, -1.50854766e-01f, -3.06929797e-01f, -1.29376397e-01f, -1.02049552e-01f, -1.04409657e-01f, -9.65994224e-02f, 1.50635093e-01f,
  6.97097406e-02f, 8.99820924e-02f, 2.98240393e-01f, -8.97423476e-02f, 1.17317565e-01f, 3.73119950e-01f, -2.16108695e-01f, -7.11134076e-02f, -1.62130538e-02f, -1.54416934e-01f,
  1.56576498e-04f, -5.51699474e-02f, -5.92218824e-02f, -1.36069208e-01f, -1.44413263e-01f, -5.22822104e-02f, 3.46295089e-02f, -8.60381424e-02f, -3.91034707e-02f, -1.64079964e-02f,
  1.55009434e-01f, 2.97518551e-01f, -4.63120714e-02f, 6.49550464e-03f, -4.19285009e-03f, 3.45563777e-02f, -2.48802938e-02f, 4.09114808e-02f, -5.91856763e-02f, -5.75674586e-02f,
  -4.70938087e-02f, 3.74543145e-02f, 2.26505101e-02f, -3.18109803e-02f, -7.13806823e-02f, -7.76053369e-02f, -7.22962245e-02f, -4.10127528e-02f, -4.28626426e-02f, -1.88785978e-03f,
  -4.53040488e-02f, -4.32035588e-02f, -8.34147334e-02f, 8.79179090e-02f, -1.28937796e-01f, 5.28933220e-02f, -1.53122684e-02f, 1.13173701e-01f, -2.41662152e-02f, -1.19302236e-02f,
  1.28488809e-01f, -3.81163433e-02f, 7.14425519e-02f, 5.35385646e-02f, -1.28430843e-01f, 4.33005840e-02f, 7.26066995e-03f, -1.30865304e-02f, -8.71362314e-02f, 7.00398907e-02f,
  -3.37262154e-02f, -1.74266100e-02f, 1.05041437e-01f, -3.68444063e-02f, -2.50720251e-02f, 1.01557253e-02f, 1.40252654e-02f, 9.86620411e-02f, 1.76021587e-02f, -4.65628356e-02f,
  3.77857685e-02f, -4.92413491e-02f, -3.80547680e-02f, 7.00278059e-02f, 8.59853774e-02f, -1.25346884e-01f, 4.24887277e-02f, 5.49160428e-02f, 1.13541268e-01f, -2.95375362e-02f,
  -4.13364135e-02f, 2.28468869e-02f, -3.06774639e-02f, 1.31419018e-01f, -9.26534683e-02f, -1.76796280e-02f, -6.53777570e-02f, -8.34376141e-02f, -7.33036846e-02f, 9.69728455e-02f,
  -3.96735370e-02f, -2.84022819e-02f, -2.23758090e-02f, 1.15257669e-02f, -9.09774676e-02f, -3.55860926e-02f, 5.94422221e-03f, -5.27127832e-02f, -8.62396359e-02f, 6.91735791e-03f,
  -6.72824234e-02f, -5.02506457e-03f, 4.06421609e-02f, -6.87801689e-02f, -2.62913462e-02f, -6.34264871e-02f, -5.07342368e-02f, 2.49260999e-02f, -4.67563123e-02f, -8.71578380e-02f,
  -4.92834002e-01f, 8.60789046e-02f, -1.32249430e-01f, -1.43923098e-02f, -2.52917558e-01f, -1.33783882e-02f, 4.07793634e-02f, -1.03949063e-01f, 1.53260380e-01f, 3.49510014e-02f,
  1.66307595e-02f, 5.80381714e-02f, 9.84175205e-02f, 2.25856483e-01f, -2.23265588e-01f, 1.64228678e-01f, 1.31388858e-01f, 1.05303973e-02f, 9.60702077e-02f, -2.15332761e-01f,
  -5.59364259e-02f, 8.27912986e-02f, -6.69249371e-02f, -6.54938519e-02f, -1.60920635e-01f, -4.16002125e-02f, -9.67804492e-02f, -9.16222110e-02f, 2.76669674e-02f, 6.48656487e-02f,
  -2.71247178e-01f, -2.80212779e-02f, -4.75580469e-02f, -1.04044177e-01f, -2.59914517e-01f, -1.04048498e-01f, -4.29851487e-02f, 6.36439472e-02f, -4.32435386e-02f, 4.67666611e-02f,
  -1.76358055e-02f, -7.37804994e-02f, 4.24267538e-02f, -1.53490696e-02f, -8.47393125e-02f, 3.06916516e-02f, -9.45616141e-02f, -7.13670403e-02f, -4.81953844e-02f, -5.20625859e-02f,
  -9.05408189e-02f, -1.41307652e-01f, -2.22776793e-02f, 1.45259589e-01f, -6.61725327e-02f, -4.41288017e-02f, 4.54556234e-02f, -6.52123243e-03f, -1.37687221e-01f, -1.05526336e-01f,
  2.75292546e-02f, 4.38118912e-02f, -4.74231169e-02f, -4.52236012e-02f, -2.20327284e-02f, -9.20300558e-02f, -6.80970922e-02f, 5.47887608e-02f, 4.44177650e-02f, 3.37453596e-02f,
  -7.80834537e-03f, 3.15535255e-02f, -1.23836599e-01f, 7.71422610e-02f, -2.45714411e-02f, -1.25803605e-01f, 1.13699771e-01f, -7.33315572e-02f, 4.76263575e-02f, -1.19667565e-02f,
  1.18386582e-01f, 3.94820757e-02f, -2.70167664e-02f, 8.27987194e-02f, -1.79273114e-01f, 8.72460306e-02f, 7.77131096e-02f, -1.75096005e-01f, -1.01434663e-02f, 8.69883373e-02f,
  9.77375545e-03f, 1.27071999e-02f, -3.89742889e-02f, -1.00946099e-01f, 3.85372643e-03f, 5.23116328e-02f, 2.15420220e-03f, -6.42465129e-02f, 2.58909725e-02f, 5.01645766e-02f,
  5.26588084e-03f, 2.18475349e-02f, -9.43492055e-02f, 2.25234795e-02f, 5.71749769e-02f, 1.42228352e-02f, 5.80000356e-02f, 5.17876334e-02f, -5.39880851e-03f, -5.86424284e-02f,
  -1.02672942e-01f, 6.76196534e-03f, -4.04514000e-03f, 4.46230508e-02f, 2.92634238e-02f, -1.06860073e-02f, 3.94865731e-03f, 1.78293567e-02f, -5.61314896e-02f, 6.61335140e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  2.27437362e-01f, 2.77204420e-02f, 1.95576921e-01f, -7.86548015e-03f, -7.82892182e-02f, 1.40566258e-02f, 3.50992568e-02f, 1.49177358e-01f, 2.95170080e-02f, 1.27077818e-01f,
  4.17286009e-02f, 9.84874815e-02f, 2.27118656e-01f, 1.10827006e-01f, 9.69765410e-02f, 1.76133424e-01f, 1.07244149e-01f, 2.83040464e-01f, 1.86225846e-01f, 2.22634554e-01f,
  8.44427422e-02f, 1.28761142e-01f, 3.05692583e-01f, 4.27005142e-02f, 6.94923699e-02f, 1.30631208e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.02386005e-01f, -1.95236236e-01f, 7.76593462e-02f, 7.46934265e-02f, 3.53412218e-02f, 1.89419165e-01f, 1.22285746e-01f, 1.14053778e-01f, 1.09432340e-01f, -1.74581826e-01f,
  -1.75031751e-01f, 1.32178497e-02f, 1.35224566e-01f, 9.77217853e-02f, 1.43495351e-01f, -3.58965285e-02f, -1.44894749e-01f, 2.35906363e-01f, -1.54604658e-01f, -2.24034682e-01f,
  7.78509229e-02f, -8.92722327e-03f, -8.38516206e-02f, 1.51461095e-01f, 7.63695687e-02f, -1.75488427e-01f, 1.53713748e-01f, -2.27021694e-01f, -1.46709129e-01f, -2.42393151e-01f,
  -2.06848770e-01f, -2.43009016e-01f, 2.28028715e-01f, -1.56785339e-01f, -3.48690189e-02f, 2.88448278e-02f, -1.77576378e-01f, 7.66467899e-02f, 2.32950285e-01f, 3.15606534e-01f,
  -3.28045547e-01f, 1.66236371e-01f, 2.22265914e-01f, 1.93580300e-01f, 1.09776214e-01f, 4.54447195e-02f, -3.49580586e-01f, -2.13414833e-01f, -9.69581679e-02f, 1.32532135e-01f,
  2.81956971e-01f, 8.52396339e-03f, 2.31506050e-01f, 2.98044067e-02f, 1.33705899e-01f, 1.16169736e-01f, -1.28330097e-01f, -7.29609355e-02f, 6.94971010e-02f, 2.42405817e-01f,
  -2.36087572e-03f, -8.51788893e-02f, -1.42294183e-01f, 2.67999675e-02f, 1.81657121e-01f, -1.09439120e-02f, 2.40840092e-01f, 2.94250458e-01f, 1.90392166e-01f, 2.22898111e-01f,
  -1.56279951e-01f, -1.21893309e-01f, 6.02586754e-02f, 5.20963632e-02f, -3.16288532e-03f, 6.57460839e-03f, -3.07600558e-01f, 8.72973055e-02f, -2.27494184e-02f, 1.52313560e-02f,
  -5.74580431e-02f, -1.96747482e-02f, -1.81446284e-01f, 1.52477071e-01f, -4.37852070e-02f, 1.90493956e-01f, -2.10114911e-01f, 1.44685820e-01f, -3.83049622e-02f, -8.15343931e-02f,
  -1.72718287e-01f, 2.36915320e-01f, -6.36580028e-03f, -1.24029420e-01f, 4.11594510e-01f, -8.75150040e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.13033408e-01f, 9.04827863e-02f, 4.50002365e-02f, 4.89625841e-01f, 4.78984341e-02f, -3.93521905e-01f, 1.03775397e-01f, 9.80144739e-02f, 7.31984675e-02f, -6.49275631e-02f,
  4.72608894e-01f, 5.71459159e-02f, -2.47121304e-01f, 8.72626752e-02f, -4.67481464e-02f, 7.86512643e-02f, -1.02087341e-01f, -1.89616904e-01f, 6.66256621e-02f, 2.07128927e-01f,
  -4.10731994e-02f, 3.39182168e-01f, 3.61405671e-01f, -1.83708385e-01f, 1.75666213e-01f, 2.39801034e-03f, 2.28904746e-02f, 2.24208102e-01f, -1.63443416e-01f, -8.61587301e-02f,
  2.34667554e-01f, -4.37414534e-02f, 2.13602290e-01f, 2.37592801e-01f, 1.47114098e-01f, 1.86732620e-01f, 1.63263217e-01f, 1.11815125e-01f, 9.21881199e-02f, -9.37654451e-03f,
  -1.31306484e-01f, 1.74870759e-01f, 2.32913852e-01f, 2.92816401e-01f, -1.15645349e-01f, 2.06081688e-01f, 5.33306636e-02f, 9.01003778e-02f, 8.43949243e-02f, 4.76922505e-02f,
  4.06217992e-01f, 4.17918891e-01f, 3.00709426e-01f, 2.47790873e-01f, -1.63533399e-03f, 2.42584735e-01f, -1.68880358e-01f, 3.77284050e-01f, -1.68879181e-01f, 3.74847144e-01f,
  4.08209682e-01f, -5.68902604e-02f, 5.03258519e-02f, 1.62281111e-01f, 2.38770217e-01f, 3.22110862e-01f, 1.01860620e-01f, -6.15793645e-01f, 3.85081261e-01f, 1.45159185e-01f,
  2.20082641e-01f, -1.03285410e-01f, -4.26272489e-02f, 5.23660243e-01f, -1.91467538e-01f, 1.07556768e-01f, 2.88248621e-02f, 3.43538262e-02f, -3.01389635e-01f, 1.08778611e-01f,
  7.78127760e-02f, -9.89770070e-02f, 4.74878103e-01f, 2.24769548e-01f, 2.85405457e-01f, -1.58672053e-02f, 1.52291641e-01f, -1.45508483e-01f, -1.81091562e-01f, 2.64796704e-01f,
  -3.94837350e-01f, -3.72086950e-02f, -6.02659918e-02f, -2.74489839e-02f, -2.13196650e-01f, 1.98906645e-01f, -3.49219516e-02f, 3.25529695e-01f, 4.13203575e-02f, -2.56085187e-01f,
  8.88967440e-02f, 1.01688802e-01f, -3.29787254e-01f, -3.46041113e-01f, 3.20680626e-03f, 3.73235196e-01f, 2.79448349e-02f, -2.98708063e-02f, 6.20326493e-03f, -1.78211294e-02f,
  3.07725519e-01f, 3.56503993e-01f, 3.09935570e-01f, -6.79552704e-02f, 3.16756099e-01f, 1.17979653e-01f, -1.63330033e-01f, 2.75366634e-01f, 2.28101119e-01f, 9.62646604e-02f,
  -7.94625580e-02f, 3.75425130e-01f, 2.06177726e-01f, -1.97273627e-01f, 2.39906937e-01f, 3.63645703e-01f, 3.03314682e-02f, 1.82722449e-01f, 1.39318392e-01f, 1.92378625e-01f,
  1.52923018e-01f, 2.11694553e-01f, -1.89875752e-01f, -1.94116205e-01f, -1.89148951e-02f, 3.67367625e-01f, 2.79008865e-01f, -2.53610641e-01f, -1.34145543e-01f, 1.19524434e-01f,
  2.88158119e-01f, 4.06322218e-02f, 3.81514758e-01f, 2.10573167e-01f, 2.03049898e-01f, 2.04056382e-01f, -2.37923890e-01f, -1.97453216e-01f, 9.39069595e-03f, 1.79039702e-01f,
  -1.90463826e-01f, 1.37236670e-01f, 4.71769512e-01f, 1.13142565e-01f, 6.22946732e-02f, -1.18710464e-02f, 3.33863050e-01f, 1.41839296e-01f, -1.05981946e-01f, 2.14589536e-01f,
  8.29880387e-02f, 2.68960059e-01f, -6.48890808e-02f, -3.04597676e-01f, 3.25700521e-01f, -5.63299581e-02f, 2.12940738e-01f, -9.68829542e-02f, 1.09994650e-01f, 3.89108121e-01f,
  -6.98680207e-02f, -7.25172237e-02f, -2.68452585e-01f, 4.88377400e-02f, 8.95177573e-02f, -4.92734322e-03f, 2.99149603e-01f, 6.84028342e-02f, 4.65227991e-01f, -2.83616986e-02f,
  -3.72176208e-02f, 1.49958745e-01f, 2.83938795e-01f, 9.32760686e-02f, -2.47203305e-01f, 4.27678764e-01f, 9.75653529e-02f, -5.40955598e-03f, 2.45471925e-01f, 2.43803620e-01f,
  7.12282285e-02f, 3.67872000e-01f, 1.15846120e-01f, 1.32229835e-01f, 2.32666448e-01f, 5.04730046e-01f, -1.87407061e-01f, -2.11143836e-01f, 3.91826957e-01f, 4.33749557e-01f,
  4.96185571e-02f, 8.21232051e-02f, 2.91823316e-02f, 1.41636804e-01f, 9.43919085e-03f, 4.34449464e-01f, -4.29423079e-02f, 1.12552583e-01f, 1.54660776e-01f, 2.77904361e-01f,
  6.13038577e-02f, 2.31928259e-01f, 5.09813309e-01f, -4.97191511e-02f, -2.58035779e-01f, 2.23290265e-01f, 1.31859630e-01f, -1.68541092e-02f, 1.05625451e-01f, 1.75878584e-01f,
  1.02977045e-01f, -2.18061134e-02f, 4.19682413e-02f, -2.94406489e-02f, 3.17323238e-01f, 2.04605788e-01f, 3.94054115e-01f, 2.33673379e-01f, 1.68552130e-01f, 2.42575839e-01f,
  3.30414921e-02f, 2.91852117e-01f, 2.83437997e-01f, 1.33025542e-01f, 3.35014880e-01f, -3.11024711e-02f, -1.67691857e-01f, 1.90198690e-01f, 2.80416965e-01f, 3.78755242e-01f,
  1.63613155e-01f, 8.85730684e-02f, -1.59024838e-02f, 2.45931998e-01f, 3.57163578e-01f, 3.53473246e-01f, 2.28269711e-01f, 2.12517247e-01f, 2.23779455e-01f, 4.77193236e-01f,
  1.10544585e-01f, 2.32639655e-01f, 5.28654993e-01f, 3.02059412e-01f, 2.41147980e-01f, 2.80109942e-01f, 1.08313523e-01f, 1.00897074e-01f, 2.09794044e-01f, 3.43913168e-01f,
  2.58681625e-02f, -2.85713851e-01f, -1.87074348e-01f, -1.48806065e-01f, -2.37152919e-01f, -1.68517530e-02f, 3.64525825e-01f, 1.04766309e-01f, -2.54090905e-01f, -1.08188041e-01f,
  2.43156433e-01f, 3.02944034e-01f, 1.98082566e-01f, -2.03455970e-01f, 1.48752153e-01f, 3.18736225e-01f, -1.49830520e-01f, 3.71287018e-01f, 3.04706722e-01f, -1.93061069e-01f,
  -8.78910534e-03f, 2.34222353e-01f, 1.10288868e-02f, 1.21997684e-01f, -1.34923294e-01f, -5.66728897e-02f, 1.08063258e-01f, 1.01896279e-01f, 3.88653576e-01f, -1.41782006e-02f,
  -5.89525402e-02f, -4.15643722e-01f, 5.08497993e-04f, -1.34991392e-01f, 6.05138112e-03f, -2.60121375e-01f, -1.21409334e-01f, 5.04323542e-01f, 4.92619304e-03f, 1.85589939e-01f,
  1.40477195e-01f, 2.59828478e-01f, -4.61553544e-01f, 3.74077074e-02f, 1.39501691e-01f, -5.15705682e-02f, 3.69514972e-01f, 1.63899124e-01f, 4.08454090e-01f, 7.93312788e-02f,
  -4.32625005e-04f, 2.20040709e-01f, -2.57505298e-01f, 2.33830467e-01f, 6.40960550e-03f, 2.31890708e-01f, 2.12117597e-01f, 6.28032088e-02f, 1.77785546e-01f, 2.95588654e-02f,
  4.43080127e-01f, -4.15053181e-02f, 1.48650289e-01f, -2.64292121e-01f, 4.74779867e-03f, 1.27093360e-01f, 3.27798724e-01f, 4.31491062e-02f, 1.41827449e-01f, 2.91979700e-01f,
  -1.95016503e-01f, -7.27291638e-03f, 2.71869153e-01f, 2.13183150e-01f, -2.92182025e-02f, 1.35618865e-01f, 6.48197830e-02f, 4.19258684e-01f, -1.35342441e-02f, -1.81509346e-01f,
  2.69844681e-01f, -3.04066390e-01f, -3.29529017e-01f, 5.53114414e-01f, -9.18578939e-04f, 3.59841824e-01f, 3.71021599e-01f, 1.65980592e-01f, 4.51957732e-01f, 3.38361084e-01f,
  -1.51544601e-01f, 6.65997416e-02f, 1.78533137e-01f, 9.63185430e-02f, 9.85625610e-02f, -1.71041057e-01f, 2.10287616e-01f, -2.48186648e-01f, -7.52428407e-03f, 5.83498292e-02f,
  -2.37331107e-01f, 4.08328772e-01f, 2.82418162e-01f, 9.68470275e-02f, -2.75781929e-01f, -2.29491547e-01f, -2.41043195e-01f, 6.65170401e-02f, 1.73685759e-01f, -2.72971630e-01f,
  4.04425859e-01f, 3.05733204e-01f, -1.63443405e-02f, 2.90523082e-01f, 4.76529896e-01f, -3.11848130e-02f, -5.62559813e-02f, 1.61778092e-01f, 3.99087518e-02f, 5.19835837e-02f,
  2.37525821e-01f, 1.15736417e-01f, 1.67106137e-01f, 3.24741900e-01f, 2.52128959e-01f, 2.95329005e-01f, -3.15260738e-02f, -6.24485761e-02f, 1.77128062e-01f, 3.16811413e-01f,
  1.63226947e-02f, -2.79474080e-01f, 8.13411847e-02f, -4.52904999e-02f, -1.88719332e-01f, -2.20578283e-01f, 3.27980727e-01f, -2.42511585e-01f, 1.61327735e-01f, 1.68184400e-01f,
  2.66357511e-01f, 1.54006422e-01f, 2.93677658e-01f, -5.51683269e-02f, -1.72963753e-01f, -5.41051887e-02f, -9.02279988e-02f, 3.32609653e-01f, 2.76238471e-02f, 1.17921747e-01f,
  3.29770446e-01f, -1.99944943e-01f, 3.48599255e-01f, 3.74722898e-01f, 7.67509714e-02f, 3.21849912e-01f, 4.16279912e-01f, 5.88779971e-02f, 3.55653055e-02f, 8.21056124e-03f,
  2.15884894e-01f, 2.01381668e-01f, 3.69107276e-01f, -2.88281143e-01f, -3.55348706e-01f, 2.05580339e-01f, -3.55592698e-01f, 1.55822650e-01f, 4.00519148e-02f, 1.33815393e-01f,
  -4.19123352e-01f, -7.42113516e-02f, 2.39620343e-01f, 2.03666702e-01f, 4.48428154e-01f, -8.43150392e-02f, 4.80737507e-01f, -2.00885385e-01f, -5.81909120e-02f, 1.03740759e-01f,
  -3.60360593e-01f, 4.51470137e-01f, 5.86433299e-02f, 4.70904946e-01f, 5.00575483e-01f, -7.91266561e-02f, -2.32228532e-01f, 3.70157599e-01f, 8.23065564e-02f, 3.01612318e-01f,
  1.12243503e-01f, -3.43401849e-01f, 1.42034560e-01f, 2.76028842e-01f, -3.93198818e-01f, -5.34933269e-01f, 2.04223599e-02f, 6.96593598e-02f, -1.02468781e-01f, -2.60658473e-01f,
  1.83297530e-01f, -3.31768721e-01f, 7.49454647e-02f, 3.21427524e-01f, 3.29328120e-01f, 1.93612039e-01f, 1.15994355e-02f, -1.03863887e-01f, -4.48320433e-02f, -1.21214613e-01f,
  -9.94595587e-02f, 1.24624304e-01f, -3.17717604e-02f, 3.20884138e-01f, 3.00777078e-01f, -2.62166411e-01f, 2.79185683e-01f, 1.55952014e-02f, 1.53166175e-01f, 1.02266453e-01f,
  3.09256256e-01f, -5.40854894e-02f, 5.83908148e-02f, 2.12135892e-02f, -4.35386062e-01f, 1.35826394e-01f, 4.24310952e-01f, 6.38528883e-01f, -7.08301812e-02f, -1.82466909e-01f,
  -2.25472927e-01f, 2.29806304e-01f, 1.59855187e-01f, 2.88701445e-01f, -1.99027196e-01f, -1.82317764e-01f, -1.61260217e-01f, 2.80400217e-02f, 1.91649288e-01f, 3.85513045e-02f,
  3.15615982e-01f, 5.01777567e-02f, -4.73967642e-02f, 7.04807863e-02f, 2.49652520e-01f, 8.84021819e-03f, 1.04915135e-01f, 2.24285945e-01f, 7.95055181e-02f, 4.74455046e-05f,
  -6.78770915e-02f, -1.85034841e-01f, 2.06944019e-01f, 3.42112750e-01f, 8.42604339e-02f, -1.66205205e-02f, -3.62065397e-02f, -2.03059494e-01f, 4.10062596e-02f, -1.30556347e-02f,
  7.80070499e-02f, 3.96870285e-01f, 3.25507879e-01f, 3.99433821e-01f, 2.03871593e-01f, 2.58415908e-01f, -2.37317458e-01f, 1.45378575e-01f, 5.02535403e-02f, -1.32360071e-01f,
  2.05906600e-01f, 1.95065379e-01f, 1.99506178e-01f, 2.52560884e-01f, 1.08393997e-01f, -1.07751517e-02f, 2.81085335e-02f, -1.21329188e-01f, -1.11801565e-01f, 1.07727386e-01f,
  5.46829402e-03f, -8.64616483e-02f, 8.64291564e-02f, 1.79693550e-01f, 7.67743960e-02f, 2.71071911e-01f, 1.86849460e-02f, 3.03717464e-01f, 7.03427941e-02f, -3.57605487e-01f,
  -1.64501473e-01f, -3.87590677e-02f, -2.60941684e-01f, 3.00256997e-01f, 4.32985544e-01f, -9.33045894e-02f, -2.36876503e-01f, -1.13682866e-01f, 1.16774783e-01f, 2.77990848e-01f,
  2.28133306e-01f, -1.31920025e-01f, 7.75941014e-02f, 1.31587252e-01f, -9.52972248e-02f, 2.80249447e-01f, 2.90139824e-01f, -1.19601369e-01f, -1.76640347e-01f, -3.45579274e-02f,
  2.49371324e-02f, 2.57582366e-01f, -2.54517525e-01f, 1.74141467e-01f, 2.25687549e-01f, 1.77132800e-01f, 3.45095903e-01f, 3.36602598e-01f, 1.16616465e-01f, -2.79819965e-01f,
  5.14468729e-01f, 2.12207958e-01f, 2.24169955e-01f, -4.05010849e-01f, -3.18409540e-02f, -5.50503097e-02f, -2.22330645e-01f, 2.84575701e-01f, 5.66618264e-01f, 5.06312177e-02f,
  -1.43232957e-01f, 1.83140039e-02f, -4.98367799e-03f, -1.45748958e-01f, 5.70075028e-02f, 1.36211917e-01f, -1.05244197e-01f, 6.72835782e-02f, 1.35158718e-01f, -5.69750145e-02f,
  -1.91780806e-01f, -7.71205127e-02f, 9.28252414e-02f, 1.81155592e-01f, 1.39258131e-01f, -2.37266406e-01f, -3.56580704e-01f, -6.48360550e-02f, 3.22586745e-01f, -1.94674343e-01f,
  -3.04098390e-02f, -1.58520088e-01f, -2.00362295e-01f, -3.24500054e-02f, 2.68798210e-02f, 4.43384409e-01f, 3.72113548e-02f, 4.23433542e-01f, 1.85615778e-01f, -9.18293223e-02f,
  1.05065227e-01f, 5.22011742e-02f, -1.83591127e-01f, -2.41929650e-01f, -3.99855524e-02f, 1.80570319e-01f, 1.91030264e-01f, 1.58955589e-01f, 4.22682524e-01f, 2.68437386e-01f,
  -3.16011697e-01f, 2.45719671e-01f, 2.59160344e-02f, 1.07879102e-01f, 3.10022801e-01f, 2.06332549e-01f, 9.95609388e-02f, 5.79799637e-02f, 4.63362098e-01f, -3.67384106e-02f,
  -6.94545954e-02f, 1.54247388e-01f, 5.69638461e-02f, -5.44106781e-01f, -1.38749480e-01f, -2.55817901e-02f, -7.27643147e-02f, 6.87796474e-02f, 1.70428470e-01f, -1.10987484e-01f,
  -4.78379540e-02f, -1.14684559e-01f, 4.66216385e-01f, -4.37405426e-03f, -1.01354085e-01f, 1.69853389e-01f, 9.11935940e-02f, 1.29563481e-01f, 2.35463381e-01f, -3.54199531e-03f,
  -2.78174877e-01f, -5.83133921e-02f, 1.00728489e-01f, 1.04201548e-01f, 4.16838735e-01f, -6.06689490e-02f, 3.87706995e-01f, -3.25342655e-01f, 1.71947941e-01f, 7.70103047e-03f,
  1.25056624e-01f, -1.13039978e-01f, 2.48510823e-01f, -1.18756704e-02f, 1.40718773e-01f, -6.30447447e-01f, 1.00231312e-01f, 2.05581322e-01f, -1.28173038e-01f, -1.86628059e-01f,
  -4.50150855e-03f, -2.06154771e-02f, 1.47788459e-02f, -2.12363556e-01f, 4.64331776e-01f, -2.73437142e-01f, 1.16616510e-01f, -1.00762211e-02f, -9.55786034e-02f, 2.22415179e-01f,
  2.68708229e-01f, 1.11713722e-01f, -3.68096024e-01f, -6.66787699e-02f, 3.14536616e-02f, 1.95347518e-01f, 1.36745214e-01f, 1.76166102e-01f, 2.13994712e-01f, -3.88144851e-01f,
  5.71798161e-02f, 2.57303655e-01f, 1.08330242e-01f, 5.82624227e-02f, 2.08918288e-01f, 4.38871384e-01f, 2.35327765e-01f, 7.20941007e-01f, -8.13799053e-02f, -1.97160900e-01f,
  9.67919454e-02f, 2.15758577e-01f, 1.66734010e-01f, -2.43100315e-01f, -4.77331132e-02f, 1.50536194e-01f, -2.11932033e-01f, 3.40510309e-01f, 4.08228725e-01f, 3.32141548e-01f,
  1.67486459e-01f, 1.59246713e-01f, -2.67679095e-01f, 5.09138852e-02f, 3.25442225e-01f, 3.20042491e-01f, 3.69107500e-02f, 1.06153354e-01f, 2.24638417e-01f, 1.32137701e-01f,
  7.24337995e-02f, 2.70835906e-01f, 1.66112348e-01f, -1.38221964e-01f, -7.81975985e-02f, 7.40066394e-02f, 1.81116343e-01f, 8.12467262e-02f, 9.57571343e-02f, -3.17247897e-01f,
  -4.86940622e-01f, 8.96940902e-02f, 2.71307707e-01f, 3.81922722e-01f, 2.51171291e-01f, -2.22567141e-01f, -8.52193534e-02f, 5.30498736e-02f, 5.14512479e-01f, 2.87291735e-01f,
  -1.60052299e-01f, -1.33633867e-01f, -2.88634241e-01f, 2.15993673e-01f, -6.38657883e-02f, 8.68986920e-02f, 1.79995701e-01f, -9.15384069e-02f, -5.34520037e-02f, 3.57903719e-01f,
  2.49484450e-01f, -1.92162126e-01f, 3.57538998e-01f, -6.58999532e-02f, -1.11430824e-01f, 1.02144703e-01f, -2.00464129e-01f, -2.87266344e-01f, 4.26718406e-02f, 2.22070500e-01f,
  5.27252257e-02f, 2.46503338e-01f, -1.43990010e-01f, 2.29604721e-01f, 1.92593113e-02f, 2.92993039e-01f, 1.25665367e-01f, -1.47175118e-01f, -1.53362695e-02f, -3.50554943e-01f,
  -1.00443568e-02f, -3.28024663e-02f, 3.76282662e-01f, -9.00871903e-02f, 7.46322945e-02f, 3.77788216e-01f, -1.86704203e-01f, -9.35121924e-02f, -1.49872884e-01f, -1.01053402e-01f,
  -3.83176029e-01f, 8.59701112e-02f, 1.61411136e-01f, 2.70090312e-01f, 4.08658653e-01f, -1.89254940e-01f, 3.26748103e-01f, 5.54853857e-01f, 9.48278755e-02f, 1.70260683e-01f,
  -7.92504996e-02f, 4.04410362e-01f, 1.72545865e-01f, -1.72028512e-01f, 4.09287572e-01f, 2.74233490e-01f, -3.56446683e-01f, -2.77932227e-01f, 3.08535457e-01f, -7.72814602e-02f,
  -1.51230827e-01f, -6.49864152e-02f, -9.55791473e-02f, -2.76236802e-01f, 3.86158198e-01f, 2.95709014e-01f, 2.73706764e-01f, -1.60194207e-02f, -1.44211963e-01f, -9.90542620e-02f,
  -1.57833606e-01f, 1.55745372e-01f, 1.45726383e-01f, -1.16761781e-01f, 1.97466806e-01f, 1.76483944e-01f, 1.05051070e-01f, -3.42709646e-02f, 2.73047149e-01f, -2.20939349e-02f,
  1.35494918e-01f, 2.67243713e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.66677320e-01f, 1.50629684e-01f, 3.20567816e-01f, 1.81913748e-01f, 2.01503277e-01f, 1.83308482e-01f, 4.65232581e-02f, 3.29761297e-01f, 2.88706452e-01f, 2.63014525e-01f,
  2.92377710e-01f, 2.08882287e-01f, 9.67664197e-02f, -4.15503867e-02f, 2.77445227e-01f, 1.44801751e-01f, 2.47367531e-01f, 2.81444520e-01f, 1.64031610e-01f, -1.15134604e-01f,
  2.94737279e-01f, 1.39960051e-01f, 1.15867011e-01f, 2.15034813e-01f, -2.08474789e-02f, 2.12389141e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.88750893e-01f, -1.11042615e-02f, 1.45803288e-01f, 9.57305804e-02f, -9.02213678e-02f, 1.66910961e-01f, -2.45090500e-01f, 1.35445237e-01f, 8.20256770e-02f, -2.18091890e-01f,
  2.91170478e-01f, -1.78449914e-01f, 8.07774067e-02f, 1.83457419e-01f, -8.63453969e-02f, -2.49277309e-01f, -5.95898405e-02f, -2.14277193e-01f, 6.27418756e-02f, -1.14207380e-02f,
  5.65958470e-02f, 8.56541619e-02f, -4.99165356e-02f, -1.34087428e-01f, -7.84545988e-02f, -9.82282683e-02f, -3.57433930e-02f, 4.20382293e-03f, 5.73437661e-02f, 1.56866297e-01f,
  -4.14678976e-02f, 1.05219483e-01f, 5.01000211e-02f, 7.08712824e-03f, -5.23861088e-02f, 9.80595276e-02f, -2.42048323e-01f, 3.84424299e-01f, 8.22508037e-02f, 1.22486606e-01f,
  4.80439477e-02f, 3.40373106e-02f, -1.88954741e-01f, -1.74466148e-01f, 7.25466907e-02f, 1.21039122e-01f, 6.54373989e-02f, -5.72239142e-03f, -1.00855760e-01f, -1.07040696e-01f,
  -1.68068826e-01f, -5.53511046e-02f, -6.00344017e-02f, -1.46425357e-02f, 1.31547496e-01f, 1.37973905e-01f, 2.23389193e-01f, 1.52348623e-01f, -3.07572968e-02f, -9.03980657e-02f,
  2.15463251e-01f, -2.22055018e-02f, -2.90869415e-01f, 9.82765183e-02f, 9.63490307e-02f, 1.63432792e-01f, 9.57686640e-03f, 5.62659353e-02f, -2.61783432e-02f, -1.68816134e-01f,
  -1.74258724e-01f, -1.51410386e-01f, 4.90820641e-03f, -9.90722403e-02f, 8.51900056e-02f, 1.43472971e-02f, -7.63662383e-02f, -1.04761019e-01f, 9.47421417e-02f, -2.56535798e-01f,
  4.21661325e-02f, 7.34432414e-02f, -3.03556770e-02f, 1.92321032e-01f, -2.52823144e-01f, 2.16300681e-01f, 1.70278959e-02f, -3.84654589e-02f, 1.78975612e-01f, -2.53319353e-01f,
  8.42875764e-02f, -1.37419224e-01f, 1.71604052e-01f, 1.62321553e-01f, -4.56087068e-02f, -1.56505227e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.55181795e-01f, -2.40065649e-01f, -1.05393171e-01f, -2.80614823e-01f, -3.33048813e-02f, 5.50734341e-01f, 2.59066314e-01f, 1.91399440e-01f, -2.32827485e-01f, 2.56561726e-01f,
  -1.42538790e-02f, 2.27901027e-01f, 2.72163182e-01f, 1.08455092e-01f, 3.29715163e-01f, 2.62075216e-01f, 8.13993365e-02f, 1.77106276e-01f, -4.19317884e-03f, 2.95256138e-01f,
  -5.14828488e-02f, -5.24416156e-02f, 1.08740918e-01f, 4.03967679e-01f, -3.86794180e-01f, 3.38760048e-01f, -1.24349587e-01f, -2.95250207e-01f, 1.07484147e-01f, -1.73991650e-01f,
  1.94345534e-01f, 1.11149233e-02f, 2.49482676e-01f, 3.11328340e-02f, 1.72818899e-01f, -2.47099310e-01f, 1.77817360e-01f, 2.14289099e-01f, 4.73677278e-01f, 3.19239050e-01f,
  1.49122790e-01f, -6.61564395e-02f, 3.11232582e-02f, 7.88243636e-02f, 3.66916120e-01f, 9.34870914e-02f, 1.60790265e-01f, 3.33899915e-01f, 2.81987060e-02f, 6.95754662e-02f,
  -1.51536062e-01f, 2.85878211e-01f, -3.05878907e-01f, 1.71902403e-01f, 1.27335683e-01f, 1.67743281e-01f, -9.86027047e-02f, 3.44056934e-02f, -1.05964459e-01f, -7.71608055e-02f,
  8.02760273e-02f, 1.98659133e-02f, -7.23296702e-02f, -1.84735745e-01f, 2.23591462e-01f, 3.68054837e-01f, 2.15381637e-01f, -1.37465611e-01f, 3.32531929e-01f, 9.12101865e-02f,
  4.36680019e-01f, 9.69607234e-02f, 8.07272196e-02f, -1.60091832e-01f, -1.09490789e-02f, -5.82696982e-02f, 1.06672645e-01f, 5.73972799e-02f, 5.48717529e-02f, 1.80773556e-01f,
  -1.13087289e-01f, 2.62833744e-01f, -3.40674549e-01f, -1.96675047e-01f, -6.85921386e-02f, 5.29291272e-01f, 4.86996979e-01f, 6.11865073e-02f, 4.27044392e-01f, 2.00826764e-01f,
  2.99672335e-01f, 7.32666254e-02f, -1.08809553e-01f, 2.66403258e-01f, -2.79534250e-01f, -7.53973946e-02f, 3.80488575e-01f, 2.35541105e-01f, 4.39461231e-01f, 2.51908422e-01f,
  -3.56448829e-01f, -6.28524423e-02f, 7.17310384e-02f, 1.37730449e-01f, -2.28395343e-01f, 2.46632546e-02f, 4.06383276e-01f, -1.82149485e-01f, 1.94685891e-01f, 3.05172801e-01f,
  1.12889774e-01f, -7.24249259e-02f, 2.00807109e-01f, -2.18900561e-01f, 3.29214156e-01f, -2.07939014e-01f, 4.21082348e-01f, -7.12146759e-02f, 7.50874877e-02f, 3.17477919e-02f,
  3.54113400e-01f, -2.00072885e-01f, 2.48114780e-01f, 3.20464700e-01f, 3.49464118e-01f, 2.82230139e-01f, 1.29447982e-01f, 4.03319657e-01f, 9.97194201e-02f, 2.19477624e-01f,
  5.57697006e-02f, -1.02258936e-01f, -2.56023824e-01f, 5.78679889e-02f, -9.17201787e-02f, 1.10162422e-01f, 2.25658014e-01f, 2.13001236e-01f, -5.21286726e-02f, 3.21370333e-01f,
  -3.22719842e-01f, -2.38873810e-03f, -2.37499863e-01f, -1.78188402e-02f, 2.12531447e-01f, 1.89170763e-01f, 3.45309436e-01f, 1.72160268e-01f, 3.01501095e-01f, -1.86306208e-01f,
  6.17464744e-02f, -6.84294701e-02f, 4.69374478e-01f, -7.78944567e-02f, 2.61380583e-01f, 1.11613944e-01f, -6.24159798e-02f, -2.16049433e-01f, 1.46980747e-03f, 3.49570334e-01f,
  -1.53005734e-01f, -1.49777934e-01f, -1.27090082e-01f, 1.65919945e-01f, -2.83070803e-02f, 2.67340928e-01f, -2.55230516e-01f, 9.52927619e-02f, -2.01800033e-01f, 1.18850678e-01f,
  4.97566193e-01f, 1.50959164e-01f, 3.66072983e-01f, 1.80285916e-01f, -2.93980956e-01f, 5.33331931e-02f, 3.85696232e-01f, 5.07220402e-02f, 2.92628050e-01f, 2.89010316e-01f,
  9.66474414e-02f, 1.25475481e-01f, -1.17679924e-01f, -2.30218291e-01f, -4.41271901e-01f, 1.14041083e-01f, -7.67844617e-02f, -2.11003087e-02f, 4.11318362e-01f, 9.29271504e-02f,
  4.99797195e-01f, 7.35330768e-03f, 1.00692637e-01f, 1.40452534e-01f, -9.73735005e-02f, 3.23015600e-01f, 2.61465549e-01f, -4.30576503e-01f, 7.75485858e-02f, -9.13666934e-02f,
  -1.98503837e-01f, -1.99903715e-02f, 1.91630617e-01f, -1.03337280e-01f, 1.31370738e-01f, 2.29116574e-01f, -9.42379981e-02f, 6.43951073e-02f, 2.20441744e-01f, -1.84532002e-01f,
  6.31800899e-03f, -4.06467095e-02f, -1.69050600e-02f, 3.37696791e-01f, 4.41941284e-02f, -1.97811514e-01f, 8.27398300e-02f, 4.37930733e-01f, 3.97441894e-01f, 3.36076826e-01f,
  -4.50724326e-02f, 3.55719656e-01f, 3.20482522e-01f, -1.21771120e-01f, -1.28398001e-01f, 1.54925182e-01f, 1.68059453e-01f, -8.00893530e-02f, 2.91482717e-01f, 1.98215812e-01f,
  3.37796539e-01f, 2.58102894e-01f, 1.07748449e-01f, 1.39398411e-01f, -1.04417525e-01f, 1.15117408e-01f, 7.96492696e-02f, 3.25802624e-01f, 3.25378805e-01f, 1.67597175e-01f,
  -4.07645330e-02f, 3.21215093e-01f, -2.46260166e-01f, 1.21612988e-01f, -2.14621186e-01f, 8.48690886e-03f, 3.31463277e-01f, 3.50664645e-01f, -2.52535373e-01f, 3.65857601e-01f,
  -3.93346250e-02f, 5.74749894e-04f, 8.96136016e-02f, -1.76563606e-01f, 6.36885166e-02f, -2.71904794e-03f, 1.61122903e-01f, 3.51413004e-02f, 2.48678833e-01f, -1.30823031e-01f,
  -1.33017451e-01f, -2.09075063e-01f, -3.08110893e-01f, -4.91322763e-02f, 4.00283039e-01f, 4.01566505e-01f, -2.87670642e-02f, 4.41676378e-01f, -1.10509761e-01f, 1.28463373e-01f,
  -1.08488955e-01f, 2.32732654e-01f, 4.98726636e-01f, -3.69607545e-02f, 3.65354657e-01f, 4.24909353e-01f, 5.25362432e-01f, -3.59803624e-02f, -7.58413002e-02f, -1.63894057e-01f,
  3.58193010e-01f, -8.73366594e-02f, 2.79731780e-01f, 4.71541107e-01f, -2.19138414e-01f, -3.33965272e-02f, 3.76139611e-01f, 3.25119227e-01f, -3.58576402e-02f, 2.65034549e-02f,
  9.89463702e-02f, -1.93162620e-01f, -1.48629963e-01f, -6.22702762e-02f, -6.97390065e-02f, 1.25680342e-01f, 4.89290595e-01f, 6.04017824e-02f, -1.15340032e-01f, 3.47873569e-01f,
  -1.60641819e-01f, 1.78200319e-01f, 1.16090484e-01f, 1.00938819e-01f, 1.38988510e-01f, -2.50991248e-03f, 2.80845523e-01f, 1.70324832e-01f, 3.21464300e-01f, -1.66043490e-01f,
  -6.59301551e-03f, -2.89767701e-02f, 3.88951331e-01f, -2.33649947e-02f, -8.38725304e-04f, 2.91642427e-01f, -6.18867129e-02f, -2.74334978e-02f, -1.18792601e-01f, 3.85494828e-01f,
  2.29145307e-02f, 3.27795818e-02f, 2.98314422e-01f, -3.31570618e-02f, 2.18056515e-01f, -2.08984122e-01f, -2.79147565e-01f, 2.42656067e-01f, -8.87187272e-02f, -1.26309037e-01f,
  1.17444873e-01f, -3.55124585e-02f, 2.91490436e-01f, 1.20875845e-02f, -2.81280935e-01f, 5.41157126e-02f, 4.23057288e-01f, -1.93342716e-02f, 1.80674821e-01f, 2.47096092e-01f,
  -1.73032954e-02f, 3.08944076e-01f, 1.46239875e-02f, -3.76905113e-01f, 3.32415253e-01f, 1.11736998e-01f, 1.86743811e-01f, 8.79934728e-02f, 1.79854501e-02f, 2.84375221e-01f,
  6.26814738e-02f, -1.37456581e-01f, -2.57081419e-01f, 1.43201828e-01f, -2.39783317e-01f, -1.33297130e-01f, -2.59047180e-01f, 2.49665484e-01f, 1.60502434e-01f, 2.46135816e-01f,
  -2.05625705e-02f, 3.23720127e-01f, 1.19479574e-01f, 4.11007255e-01f, -1.26091644e-01f, 3.54815215e-01f, 3.40613842e-01f, -1.03586735e-02f, -1.09509237e-01f, 3.13081175e-01f,
  2.92967647e-01f, -6.72561824e-02f, 2.12557316e-01f, -3.57265145e-01f, 4.53725383e-02f, 1.35724008e-01f, -4.73312080e-01f, -1.78390834e-02f, 3.77674475e-02f, 3.37529788e-03f,
  -2.52920575e-02f, -3.83711576e-01f, 4.22483742e-01f, 2.61197001e-01f, 4.36846651e-02f, 2.16286615e-01f, 1.82144016e-01f, -9.65205207e-03f, -2.45188475e-01f, -2.70672172e-01f,
  -1.96996242e-01f, -2.50511467e-02f, 2.41208196e-01f, 3.79333168e-01f, -3.71523481e-03f, -9.29505564e-03f, -2.18098298e-01f, -9.51797813e-02f, -7.08378404e-02f, 2.59192169e-01f,
  8.18596706e-02f, -2.59845741e-02f, 3.48556548e-01f, 5.88542260e-02f, 5.55583298e-01f, -2.63795018e-01f, 2.64368236e-01f, -1.34383053e-01f, 3.14079046e-01f, -1.28079996e-01f,
  2.65301347e-01f, 4.62072760e-01f, -1.76696524e-01f, 1.12949751e-01f, -1.35885939e-01f, 2.37803131e-01f, 3.54590714e-01f, 7.78484195e-02f, 2.13257581e-01f, 2.21326753e-01f,
  2.73278564e-01f, 3.75551619e-02f, -1.77826136e-01f, 5.29064909e-02f, 1.82292432e-01f, -2.31335863e-01f, 1.48080662e-01f, -9.00875404e-02f, 2.17341483e-01f, 2.40202278e-01f,
  -9.74487960e-02f, 1.51829958e-01f, 2.48054042e-01f, -1.32966608e-01f, -2.70618368e-02f, 3.79190207e-01f, -1.16851881e-01f, 3.52888703e-01f, 4.16998044e-02f, -1.62063390e-01f,
  3.00773501e-01f, 2.47437283e-02f, -1.24435022e-01f, -1.20399840e-01f, 4.05696869e-01f, 3.27385724e-01f, -2.13124439e-01f, -1.38849556e-01f, -3.53238642e-01f, -3.61887604e-01f,
  5.95060736e-03f, 1.36664752e-02f, 1.92774191e-01f, 5.36542200e-02f, -1.29949767e-02f, 3.00010234e-01f, 1.85167685e-01f, 1.85438991e-02f, -3.45171392e-01f, 2.80033618e-01f,
  2.13138968e-01f, 7.31713604e-03f, -6.99437782e-02f, 1.55276477e-01f, 1.87348738e-01f, 2.73901820e-01f, -2.34549791e-02f, 3.30707431e-01f, -1.02219902e-01f, 2.56035894e-01f,
  8.75996724e-02f, 9.14708599e-02f, -2.52016127e-01f, 3.85993749e-01f, -1.28764391e-01f, 6.14229180e-02f, -1.87073201e-01f, -5.84672280e-02f, -9.43070203e-02f, -5.88090010e-02f,
  6.56796694e-02f, 2.17350274e-01f, 2.13721141e-01f, -2.72029728e-01f, 2.37652972e-01f, 3.58945206e-02f, 2.22636491e-01f, 3.68960321e-01f, 2.69135922e-01f, 1.30472720e-01f,
  -2.82421410e-01f, 3.98273110e-01f, 2.12050304e-01f, -7.26041570e-02f, 3.17366630e-01f, 4.08272564e-01f, 8.61630812e-02f, 3.50842088e-01f, -2.57348940e-02f, 3.78106624e-01f,
  2.48621657e-01f, -6.66155443e-02f, 3.07185769e-01f, 3.74554187e-01f, 4.07823980e-01f, 1.06071740e-01f, 4.89325728e-03f, 9.47254673e-02f, -1.80362716e-01f, -7.39607811e-02f,
  -1.94711298e-01f, -1.38988689e-01f, -4.19675887e-01f, -6.24577522e-01f, -3.09173107e-01f, 4.52801026e-02f, 1.92127675e-01f, 1.46093547e-01f, -2.29864866e-01f, 3.22315514e-01f,
  2.18868703e-01f, -8.88740122e-02f, -1.67782888e-01f, 1.07399054e-01f, 3.85494441e-01f, 2.52075493e-01f, -2.00117484e-01f, 3.59454274e-01f, 3.75241727e-01f, 1.68560773e-01f,
  -1.05831929e-01f, 4.24106896e-01f, -5.47939911e-02f, 3.55428547e-01f, 1.71071321e-01f, -6.20668530e-02f, 3.34864594e-02f, 3.89970332e-01f, -2.45407283e-01f, -1.80862956e-02f,
  1.09883517e-01f, 1.69868879e-02f, -6.14081435e-02f, -2.59663731e-01f, 2.66346097e-01f, 1.03431053e-01f, 3.50756377e-01f, -4.57029462e-01f, -1.49817869e-01f, 3.01569849e-01f,
  2.60280043e-01f, 1.75953776e-01f, 5.23278356e-01f, 3.77069950e-01f, -7.89650381e-02f, 2.27505609e-01f, -2.25632250e-01f, 3.05563241e-01f, 5.44421077e-01f, 2.16490954e-01f,
  3.47069800e-02f, 5.15456498e-01f, 2.66173363e-01f, 1.39612168e-01f, 1.95207655e-01f, -2.93707877e-01f, 3.30251783e-01f, 5.45309961e-01f, 3.39494675e-01f, -1.17048420e-01f,
  1.84014216e-01f, 2.40005538e-01f, -3.83995883e-02f, -2.90957779e-01f, 1.02350853e-01f, 4.00096178e-01f, 5.32912135e-01f, 3.37200582e-01f, 3.92854333e-01f, -1.36820093e-01f,
  -1.25644878e-01f, 3.05857062e-01f, 4.16757256e-01f, -7.85404295e-02f, -6.36022091e-02f, -1.25479540e-02f, 1.78839430e-01f, -1.55907080e-01f, 2.11203828e-01f, 1.47274867e-01f,
  1.61277667e-01f, -2.60684401e-01f, -2.31024936e-01f, 1.33635432e-01f, -8.23637992e-02f, -1.49905786e-01f, -7.34056905e-02f, 6.73543662e-02f, 1.97039656e-02f, 1.82061017e-01f,
  4.01124418e-01f, -3.76355231e-01f, 1.46867484e-02f, -1.80407152e-01f, 5.28865695e-01f, -4.41607609e-02f, -1.39581352e-01f, 3.53730589e-01f, 7.99437314e-02f, -5.98526374e-02f,
  1.64111644e-01f, 1.68788582e-01f, 2.91102856e-01f, -6.08902931e-01f, -1.64302699e-02f, 9.52193961e-02f, 2.10544437e-01f, 1.21366225e-01f, 2.34106839e-01f, -1.54747322e-01f,
  2.67740309e-01f, -1.01556495e-01f, -6.26172274e-02f, 2.84861475e-01f, 1.36206716e-01f, -1.27802568e-03f, 3.18672121e-01f, 1.79547250e-01f, 3.09079409e-01f, 2.51418054e-01f,
  1.07418992e-01f, -6.34344667e-03f, 3.30628991e-01f, 2.48050362e-01f, 2.73281962e-01f, 3.23126227e-01f, 1.44679219e-01f, 4.06451166e-01f, -1.89478491e-02f, -2.81474173e-01f,
  2.28334025e-01f, 3.22670013e-01f, 3.43355834e-01f, -2.77401179e-01f, 2.84975678e-01f, 4.51416820e-01f, 2.20128521e-01f, 2.83625841e-01f, -1.71951801e-01f, 3.13970484e-02f,
  7.31971636e-02f, 3.04556396e-02f, 4.17683452e-01f, -3.97311710e-03f, 7.28197396e-02f, 1.00883834e-01f, 1.40894935e-01f, -1.44079551e-01f, -1.03785090e-01f, 1.92056745e-01f,
  -4.19159569e-02f, 2.49299482e-01f, 1.31027669e-01f, -1.00925945e-01f, 4.76603776e-01f, -1.66389614e-01f, -3.42819512e-01f, -3.39105040e-01f, 4.51615930e-01f, -5.73693328e-02f,
  -3.38824570e-01f, -6.17967434e-02f, 2.59839743e-01f, 1.63397446e-01f, 1.93441883e-01f, 4.43098277e-01f, 3.38941187e-01f, -4.29357648e-01f, -9.11401510e-02f, -2.19906732e-01f,
  -5.58769464e-01f, -7.65688121e-02f, 2.54648745e-01f, -2.76576191e-01f, 3.13600153e-01f, 4.49411720e-02f, -1.68109760e-01f, -2.85269797e-01f, 2.96091855e-01f, -4.25380096e-02f,
  1.22890778e-01f, -3.05810750e-01f, -6.73430040e-02f, 4.67601269e-01f, 1.46987811e-01f, -1.64803490e-01f, -1.68271065e-01f, 2.89866507e-01f, 2.83464909e-01f, 7.37280920e-02f,
  -8.07478093e-03f, 4.49959606e-01f, 3.63668561e-01f, -1.21777542e-01f, 3.74771893e-01f, 7.12335482e-02f, 4.24949586e-01f, -2.09337726e-01f, 4.43286858e-02f, -2.22248174e-02f,
  -3.55131567e-01f, 1.29967704e-01f, 5.76731980e-01f, 1.40830696e-01f, -9.47416201e-02f, 1.77334324e-01f, -8.65212735e-03f, 2.86770742e-02f, -3.08743328e-01f, 2.51805902e-01f,
  3.26034993e-01f, 7.03246221e-02f, 3.26410949e-01f, 3.35463822e-01f, 2.68158793e-01f, 1.11475565e-01f, -3.65364812e-02f, -3.65750223e-01f, 5.27589023e-01f, -6.73292801e-02f,
  4.24683452e-01f, 3.51753473e-01f, -3.33798409e-01f, 1.16754770e-01f, -2.12108135e-01f, 1.10559657e-01f, -1.98361110e-02f, -2.34115228e-01f, -2.29726747e-01f, -1.47015274e-01f,
  -3.64063263e-01f, 2.65258729e-01f, -5.60133941e-02f, 9.67529938e-02f, -2.75653362e-01f, 1.25626875e-02f, 2.77138025e-01f, 1.24807030e-01f, 1.26164153e-01f, 2.41452456e-01f,
  1.69021621e-01f, -3.07171226e-01f, 2.49090970e-01f, -2.54744858e-01f, 1.21836521e-01f, -1.62106290e-01f, -3.23581584e-02f, 2.12831154e-01f, -6.59817979e-02f, -2.48185247e-02f,
  -4.69868928e-01f, 1.97817042e-01f, -1.48761243e-01f, 4.55132350e-02f, 4.87479091e-01f, -1.35359526e-01f, 4.61645842e-01f, 3.56748909e-01f, 2.16782019e-01f, 6.81136429e-01f,
  4.31478649e-01f, 5.03526628e-02f, 1.10426098e-02f, 1.05770364e-01f, 2.58773714e-01f, 2.14531019e-01f, -4.62028444e-01f, 1.81001335e-01f, 2.86065072e-01f, 3.72794792e-02f,
  2.96862304e-01f, 4.97396179e-02f, 1.31467000e-01f, -3.93825471e-01f, -1.53027028e-01f, -1.83400011e-03f, -3.39593530e-01f, -3.66666734e-01f, -1.20736383e-01f, 1.44496605e-01f,
  1.29784286e-01f, 3.08856249e-01f, -2.72358675e-02f, -1.65722847e-01f, 1.45912878e-02f, -3.52073789e-01f, 3.41368288e-01f, -7.52300993e-02f, -3.24815921e-02f, -3.37401181e-02f,
  -2.02235296e-01f, 1.20252401e-01f, -1.75099522e-01f, -2.90259480e-01f, -5.49039185e-01f, 3.71051073e-01f, -7.07723349e-02f, 1.14562109e-01f, -7.47204125e-02f, 3.47642690e-01f,
  4.57145602e-01f, 3.48605156e-01f, 9.38570425e-02f, 3.46339494e-01f, 2.97709107e-01f, -4.21871357e-02f, 1.81269825e-01f, 8.00808072e-02f, 3.38512689e-01f, 3.51759493e-02f,
  4.01299208e-01f, -1.78934813e-01f, -1.25401959e-01f, 2.75303096e-01f, -3.56446505e-01f, 5.16134165e-02f, 8.14402997e-02f, 1.36058673e-01f, 4.12077665e-01f, -2.06401795e-01f,
  5.44205070e-01f, 4.62653041e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.24316663e-01f, 2.39307702e-01f, 2.71742880e-01f, 1.42154813e-01f, 2.44321659e-01f, -9.88358445e-03f, -1.34342024e-02f, 1.16331182e-01f, -6.55062720e-02f, 1.31925106e-01f,
  9.32346433e-02f, 9.99184027e-02f, 2.32066661e-01f, 2.93661226e-02f, -1.94958210e-01f, 1.44896820e-01f, -1.86272025e-01f, 3.96286994e-01f, 3.40177149e-01f, 5.46468422e-02f,
  3.04633498e-01f, 1.64414912e-01f, 1.45275325e-01f, -1.41335689e-02f, 6.35368302e-02f, -3.21011804e-02f
};

// L3_fan_Wp (Shape: 3 x 32)
const int L3_fan_Wp_rows = 3;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  -6.94853663e-02f, -1.34841770e-01f, -7.24316016e-02f, 3.44715714e-02f, -6.68233708e-02f, 4.54952195e-02f, -1.86700538e-01f, -9.77190509e-02f, -3.01633161e-02f, -3.02363709e-02f,
  2.05626309e-01f, -5.19391894e-02f, 1.00997165e-01f, -1.38085112e-01f, 5.27633987e-02f, 1.68573156e-01f, 3.64352167e-02f, 3.98150086e-02f, 7.90626556e-02f, -1.60849825e-01f,
  -2.12736472e-01f, -9.48873311e-02f, 1.85388383e-02f, 3.75600904e-02f, 2.30256200e-01f, 1.06389314e-01f, -9.09753367e-02f, -2.08044406e-02f, 3.60945277e-02f, 1.65476147e-02f,
  1.70867845e-01f, 4.56417240e-02f, -1.16421558e-01f, -6.27795160e-02f, -1.51725963e-01f, 1.19441375e-01f, 1.26825735e-01f, -1.20701790e-01f, 1.04117543e-01f, -1.96079463e-02f,
  -2.45366469e-01f, 2.59545930e-02f, -1.70351565e-01f, -7.56073073e-02f, 2.57968754e-02f, 2.27086265e-02f, -1.40451625e-01f, 8.32101144e-03f, 1.55033767e-01f, 9.77101773e-02f,
  -2.34114245e-01f, 7.22859576e-02f, 2.01829627e-01f, -1.36361316e-01f, -6.63786370e-04f, -9.02357697e-02f, -1.30490949e-02f, 5.23847416e-02f, 1.28555462e-01f, 1.14970952e-01f,
  -1.52464285e-01f, 9.70769227e-02f, -3.78320664e-01f, 1.37939245e-01f, -6.01903126e-02f, -1.78745314e-02f, -3.19646299e-02f, 2.95136303e-01f, -2.44995058e-01f, -1.19830042e-01f,
  -2.43718788e-01f, 2.86974423e-02f, -1.13300495e-01f, 7.87201673e-02f, 2.10846588e-01f, -8.06841254e-02f, 8.98567513e-02f, -2.42741346e-01f, 2.42668279e-02f, 1.93578497e-01f,
  -1.04049437e-01f, 1.67707562e-01f, 5.48427366e-02f, -1.87230572e-01f, 3.16378400e-02f, -2.80872192e-02f, 1.85182802e-02f, -3.68229374e-02f, -4.40791249e-02f, 2.10713089e-01f,
  4.40360084e-02f, -1.83288589e-01f, 1.04755899e-02f, -1.81781221e-03f, 2.39592627e-01f, -1.86633412e-02f
};

// L3_fan_Wp_bar (Shape: 26 x 32)
const int L3_fan_Wp_bar_rows = 26;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  2.37170652e-01f, 2.85883933e-01f, 4.10635889e-01f, 3.38339001e-01f, 2.56542981e-01f, -2.26610988e-01f, -1.29070610e-01f, -2.52705789e-03f, 7.12347478e-02f, 3.54638696e-01f,
  -8.46545100e-02f, 1.37845829e-01f, 3.16110581e-01f, 2.53633913e-02f, 2.05292583e-01f, 9.67258029e-03f, 3.87404144e-01f, -2.51724154e-01f, 1.88571393e-01f, 2.67455399e-01f,
  -3.29742692e-02f, -4.54097912e-02f, -2.39641611e-02f, -2.01944008e-01f, 3.29630464e-01f, 1.94491044e-01f, 4.58202124e-01f, 9.60188732e-02f, 2.28490196e-02f, 7.20491782e-02f,
  5.72387576e-01f, 1.08769104e-01f, -2.78679822e-02f, -1.14388302e-01f, 1.13126941e-01f, -3.87909934e-02f, 6.80157989e-02f, 2.83458322e-01f, 1.87473729e-01f, 2.55146593e-01f,
  1.87692806e-01f, 5.10785840e-02f, -1.79335233e-02f, 1.56132728e-01f, 2.53444523e-01f, 9.70351398e-02f, -1.68563262e-01f, -1.92494079e-01f, 4.81202275e-01f, -2.94515848e-01f,
  -1.35938197e-01f, 5.13744712e-01f, 3.05807620e-01f, -6.13431744e-02f, 4.24821824e-01f, -1.03295289e-01f, -1.19250581e-01f, 3.44249785e-01f, 4.69131291e-01f, 3.15202922e-01f,
  3.83903719e-02f, -2.06808597e-01f, 5.05835474e-01f, -1.96328089e-01f, 1.64053753e-01f, 2.04053998e-01f, -3.01366560e-02f, -3.03351671e-01f, 2.36561909e-01f, -3.29826057e-01f,
  3.53269219e-01f, 1.06976323e-01f, 2.72916198e-01f, 2.63480097e-01f, 1.66338608e-01f, -2.32128784e-01f, -2.15100005e-01f, 3.42796236e-01f, 2.21017107e-01f, 2.34224215e-01f,
  -2.50151902e-01f, 3.72971624e-01f, -3.38694490e-02f, -2.69558281e-01f, -1.14084400e-01f, 2.68666655e-01f, -4.33827303e-02f, 4.72343087e-01f, 2.56356657e-01f, -1.84585810e-01f,
  2.90402591e-01f, -3.34793448e-01f, 5.80969304e-02f, -1.03052542e-01f, -5.48439957e-02f, 2.32591853e-01f, -1.49503455e-01f, 1.50681436e-01f, 3.51831387e-03f, -4.57100242e-01f,
  2.01122060e-01f, -2.88600981e-01f, 3.81652802e-01f, 4.75912273e-01f, 2.51079500e-01f, -2.04849720e-01f, -1.97568029e-01f, -3.07825446e-01f, -2.46623635e-01f, 4.02677000e-01f,
  9.04932916e-02f, 2.34848812e-01f, -1.92467853e-01f, 1.38974831e-01f, 2.07219310e-02f, -1.17083296e-01f, 4.95859176e-01f, 4.15184706e-01f, 4.47341532e-01f, 4.09274310e-01f,
  -1.49027362e-01f, 2.14180097e-01f, 1.98987111e-01f, -1.75766990e-01f, 1.06830619e-01f, -2.29708552e-01f, -1.18403971e-01f, -6.25602975e-02f, 2.86560029e-01f, 1.81306839e-01f,
  1.50484532e-01f, 1.15476325e-01f, 7.72792548e-02f, -3.43061090e-01f, 1.16765603e-01f, 7.27177709e-02f, -1.42367035e-01f, 2.37025067e-01f, 5.79019338e-02f, 2.04215378e-01f,
  -1.88913018e-01f, -2.26389505e-02f, -2.46353578e-02f, 9.74414870e-02f, -8.37970003e-02f, 1.84511438e-01f, -1.60407752e-01f, 2.32856795e-01f, -8.12122226e-02f, 3.04029025e-02f,
  -1.06817029e-01f, 3.25702280e-01f, 2.82275438e-01f, -1.76928580e-01f, 3.33873421e-01f, -3.62338036e-01f, 2.13571906e-01f, 9.05207023e-02f, 5.42721212e-01f, 2.18124747e-01f,
  4.75968271e-01f, 2.64665961e-01f, 4.66300547e-01f, 3.05602878e-01f, 3.82598519e-01f, -3.20410103e-01f, -4.53430740e-03f, 1.29174486e-01f, -2.13489607e-02f, 1.50325507e-01f,
  1.76829383e-01f, 3.29967923e-02f, -1.16328798e-01f, -6.28345758e-02f, -1.51297212e-01f, -6.65207505e-02f, 2.49610811e-01f, -1.84300944e-01f, 9.18275937e-02f, 4.61620152e-01f,
  -1.56610785e-03f, 1.77574292e-01f, 1.17816613e-03f, 8.26854184e-02f, 3.42049032e-01f, -3.84097621e-02f, 5.33084512e-01f, -3.62066664e-02f, 1.57016739e-01f, -1.16349541e-01f,
  7.47119725e-01f, -1.28015298e-02f, -4.63766716e-02f, 3.51973325e-01f, 2.88488418e-01f, 3.89570534e-01f, -1.57286838e-01f, -7.26820007e-02f, -3.65304857e-01f, -4.06010412e-02f,
  2.82521784e-01f, 2.42274716e-01f, 1.16543770e-01f, -9.61997807e-02f, 3.97988647e-01f, -3.21739465e-01f, 1.03911966e-01f, 6.55322522e-02f, 8.48876983e-02f, -1.10656947e-01f,
  1.93177700e-01f, -2.02399995e-02f, -3.68786901e-01f, -3.19227904e-01f, -1.95991606e-01f, 4.64047529e-02f, 1.67333379e-01f, 3.27627301e-01f, -1.77655026e-01f, 5.21793306e-01f,
  3.04872125e-01f, 5.79513796e-03f, 2.49553919e-01f, -6.06395304e-02f, 1.32277682e-01f, 8.69414434e-02f, 1.13225788e-01f, 3.19362670e-01f, 5.95845096e-03f, -3.39155756e-02f,
  6.52177632e-02f, 1.94499623e-02f, -1.58383042e-01f, 2.76426643e-01f, 1.69413965e-02f, 4.78726685e-01f, 2.32305676e-01f, -2.82270938e-01f, 3.11468184e-01f, 1.55588925e-01f,
  4.63783324e-01f, -3.63611393e-02f, 6.56920001e-02f, 3.44728917e-01f, -1.47106394e-01f, -1.91061929e-01f, 1.79769292e-01f, -9.46792215e-02f, 2.03237608e-02f, 2.16219768e-01f,
  7.92600680e-03f, 2.22533450e-01f, 1.06186338e-01f, 1.60052896e-01f, -2.68227786e-01f, 2.78325409e-01f, 2.49113381e-01f, -6.81909844e-02f, -1.04476750e-01f, -8.15519914e-02f,
  -5.87852634e-02f, 2.55976737e-01f, 3.08861405e-01f, 3.00939251e-02f, 2.74960063e-02f, 1.96899608e-01f, 2.38242164e-01f, 1.36292338e-01f, -1.79181740e-01f, 2.20565215e-01f,
  -1.33082643e-01f, -5.02426177e-02f, -5.93810007e-02f, 3.40773255e-01f, -2.90904995e-02f, -1.73868820e-01f, -1.92342296e-01f, 1.08002223e-01f, 3.31979953e-02f, 1.77123040e-01f,
  2.92253971e-01f, 8.91404971e-02f, -9.92444064e-03f, -3.26521993e-01f, -2.45074004e-01f, 2.25930095e-01f, 6.73124909e-01f, 3.69647801e-01f, -4.25637364e-02f, -2.18046531e-02f,
  -8.02586302e-02f, 1.62357852e-01f, 2.78927870e-02f, 1.51082456e-01f, 6.26103766e-03f, -5.72085055e-03f, 1.01710454e-01f, 1.19154481e-02f, 7.10576475e-02f, -1.82384267e-01f,
  6.05477095e-02f, 6.18681498e-02f, -7.95926526e-02f, -1.54841438e-01f, -8.07461962e-02f, -5.42682176e-03f, 8.93309042e-02f, 8.30741450e-02f, 2.81093568e-02f, -7.00189397e-02f,
  5.50606288e-02f, -6.63138777e-02f, 6.87517300e-02f, -1.90147638e-01f, 5.88144585e-02f, -1.70964837e-01f, 1.08200602e-01f, 1.13144875e-01f, 5.46090538e-03f, -1.73500732e-01f,
  -3.95424694e-01f, -1.48330480e-01f, -4.26243633e-01f, 2.48850122e-01f, -1.37111127e-01f, 1.33476883e-01f, 2.76574165e-01f, 7.29414150e-02f, 2.06112470e-02f, 9.43113025e-03f,
  6.12835342e-04f, 3.42414498e-01f, 1.90334886e-01f, 1.34342194e-01f, 8.18538219e-02f, 1.10466629e-01f, -2.69421805e-02f, 3.51398528e-01f, -1.52786791e-01f, 1.44374609e-01f,
  2.43329450e-01f, -1.42110944e-01f, 4.44200158e-01f, -2.67669726e-02f, -2.77799487e-01f, 4.85089347e-02f, -2.25800365e-01f, 8.70305598e-02f, -1.50339931e-01f, 5.40176392e-01f,
  -4.35839504e-01f, 3.22555125e-01f, -2.84109503e-01f, -7.43125798e-04f, -3.01890701e-01f, 5.71274608e-02f, 8.99133682e-02f, 4.79678735e-02f, 3.04625928e-02f, -5.69932945e-02f,
  6.91694766e-02f, -8.33304226e-03f, 3.03377938e-02f, 1.95301414e-01f, 3.27546388e-01f, -1.39242232e-01f, -2.52460893e-02f, -4.81739119e-02f, 1.61231637e-01f, 1.68481201e-01f,
  -5.08420803e-02f, -2.15391174e-01f, -1.62203193e-01f, -3.16623300e-01f, 5.98687232e-02f, -4.92040552e-02f, -1.57158107e-01f, 3.05635594e-02f, -4.51970011e-01f, 5.64999133e-02f,
  -5.36407940e-02f, 2.60251164e-01f, -5.72346807e-01f, 1.93142906e-01f, 6.80533201e-02f, 2.93536484e-01f, 2.46802181e-01f, 1.86522603e-01f, 1.88108608e-01f, 6.34212419e-03f,
  4.71444502e-02f, 2.61516690e-01f, 3.55861336e-01f, 2.22844407e-01f, -6.12732805e-02f, -2.10332170e-01f, 4.49649133e-02f, 3.96773934e-01f, -2.70134836e-01f, -1.51312217e-01f,
  -2.77314544e-01f, 2.08519489e-01f, -1.28560215e-01f, -9.01297107e-02f, -1.40087217e-01f, 6.90705404e-02f, -2.51756579e-01f, 2.50214130e-01f, 6.68033123e-01f, -7.46087283e-02f,
  5.69884591e-02f, 3.50384057e-01f, -3.43489081e-01f, 2.06844851e-01f, 7.76794255e-01f, 1.23681486e-01f, -3.46682608e-01f, -1.81568667e-01f, -3.88766438e-01f, -3.12793940e-01f,
  -2.98648506e-01f, 4.82093431e-02f, 2.71015972e-01f, 2.73109153e-02f, -2.13207513e-01f, -1.38300508e-01f, 7.42922425e-02f, 2.89151758e-01f, -8.55663866e-02f, 1.95535332e-01f,
  9.57231075e-02f, -6.62512146e-03f, -4.56837118e-02f, 3.84567022e-01f, -1.23232350e-01f, -1.92940101e-01f, 2.91906506e-01f, 1.31479919e-01f, 1.61639810e-01f, 1.10098660e-01f,
  -4.40707386e-01f, -8.69140476e-02f, -3.52414995e-01f, -9.90722924e-02f, 4.87107038e-02f, 3.98920596e-01f, -3.63982022e-01f, 3.17123145e-01f, -8.10770094e-02f, -5.22235215e-01f,
  -3.82885367e-01f, -1.52176201e-01f, -2.79376090e-01f, 2.98697174e-01f, 9.02483389e-02f, 1.22786000e-01f, -2.37384606e-02f, -1.70692783e-02f, -7.76923597e-02f, 4.38753039e-01f,
  3.17755133e-01f, 2.37560853e-01f, 1.90206304e-01f, -1.00278892e-02f, 3.62696022e-01f, 3.72106917e-02f, -2.18167976e-01f, 1.09513231e-01f, 3.41862410e-01f, 1.21669315e-01f,
  4.13165778e-01f, -1.68951988e-01f, -3.61455649e-01f, 3.10753398e-02f, 6.70534819e-02f, 3.08414716e-02f, 1.08335972e-01f, 5.02272509e-02f, -5.01605988e-01f, -4.33177054e-02f,
  -2.37141132e-01f, -4.56619309e-03f, -1.98217601e-01f, 1.10877547e-02f, -1.94885314e-01f, -1.46190107e-01f, 7.73101598e-02f, -1.76769987e-01f, -1.49291128e-01f, -5.76544553e-02f,
  1.39954239e-01f, 3.18299532e-01f, -3.98355871e-02f, 7.54580945e-02f, 2.83932298e-01f, 5.57419248e-02f, 2.21347675e-01f, 3.31302345e-01f, 2.10942894e-01f, -1.09791376e-01f,
  1.44978717e-01f, 1.30881608e-01f, 2.25830868e-01f, 8.68146643e-02f, -3.27397615e-01f, 1.07171871e-01f, -2.17527777e-01f, 1.03646837e-01f, 1.32420659e-01f, 1.55988947e-01f,
  -4.02141452e-01f, 2.77626306e-01f, 6.98534176e-02f, -8.04898590e-02f, 2.19839171e-01f, 4.16916460e-01f, 1.82557441e-02f, -3.28505814e-01f, 1.17050223e-02f, -2.61683524e-01f,
  -3.28196138e-01f, 2.83134580e-01f, 1.92756385e-01f, 2.14584216e-01f, -2.31959090e-01f, -2.88281500e-01f, 1.90236822e-01f, 2.42828488e-01f, -1.43325239e-01f, 8.03096741e-02f,
  3.62089306e-01f, -6.67807683e-02f, -4.56915915e-01f, -1.59518659e-01f, -1.00193508e-01f, 1.08970098e-01f, 2.90848196e-01f, -8.61806795e-02f, -2.34603435e-02f, 7.82976970e-02f,
  8.14260915e-03f, 3.51980567e-01f, -1.23010240e-01f, 3.85525256e-01f, 2.47083083e-01f, 8.42641518e-02f, -9.74898785e-02f, 2.22974271e-01f, -1.94728181e-01f, -3.57325636e-02f,
  -1.73592240e-01f, -1.97938859e-01f, 2.49262989e-01f, 1.84888884e-01f, 2.98340350e-01f, 1.82562798e-01f, 2.90003389e-01f, -1.59643918e-01f, 2.42918551e-01f, 2.45217294e-01f,
  3.33848208e-01f, -3.74262524e-03f, 2.50839829e-01f, -3.18968371e-02f, 1.56839341e-01f, 2.48843566e-01f, 5.70237413e-02f, 2.37830803e-02f, -3.40668529e-01f, 3.43250066e-01f,
  -2.23276064e-01f, 3.77484381e-01f, 1.80327356e-01f, -2.86859035e-01f, 5.72358333e-02f, 6.86780587e-02f, 3.33698601e-01f, -3.65047120e-02f, 1.98290110e-01f, -3.00604433e-01f,
  5.58915734e-02f, 4.40177992e-02f, -1.52428254e-01f, 1.12460060e-02f, 1.57130390e-01f, -1.49311736e-01f, 4.11411524e-01f, -3.05575997e-01f, -2.55152602e-02f, 7.34229535e-02f,
  1.34241074e-01f, 2.58071750e-01f, 1.74663633e-01f, 6.86756298e-02f, 1.04389258e-01f, -5.78427911e-02f, 2.02262953e-01f, 1.04503259e-01f, 3.36081497e-02f, 1.95096731e-01f,
  -3.69167365e-02f, -8.34958851e-02f, 8.87564793e-02f, -4.00261462e-01f, 3.73589039e-01f, -4.30314541e-01f, -5.83153248e-01f, -5.38657792e-02f, -2.67030019e-02f, 2.62588799e-01f,
  1.28516436e-01f, 1.15938425e-01f, 2.26480722e-01f, -4.33809310e-01f, -1.07539833e-01f, -4.38860096e-02f, 1.51535496e-02f, 3.45763981e-01f, 4.35146153e-01f, -1.29771098e-01f,
  -1.58990964e-01f, 1.59349605e-01f, 3.01934391e-01f, 3.52811724e-01f, -2.15694413e-01f, 1.25112951e-01f, 3.89271408e-01f, -5.37492260e-02f, -1.09618321e-01f, 2.63573974e-01f,
  -2.36797929e-01f, 3.54682058e-01f, 8.44959542e-02f, 1.27516687e-01f, -2.08239958e-01f, -1.98281452e-01f, 2.97707707e-01f, -1.97260424e-01f, -2.46769965e-01f, 8.71520191e-02f,
  1.82027265e-01f, 9.48413536e-02f, 1.18790038e-01f, -4.05612081e-01f, 1.23262241e-01f, -4.46618050e-01f, -7.49215931e-02f, 1.07814781e-01f, -2.23846897e-01f, 7.70568624e-02f,
  3.33504885e-01f, -1.64444089e-01f, 2.33951826e-02f, -1.20365493e-01f, 3.89445961e-01f, 2.96687901e-01f, -1.21041775e-01f, 2.80676723e-01f, 3.15265983e-01f, -1.62155867e-01f,
  -9.17137861e-02f, 2.37731040e-01f, 3.76484767e-02f, 3.35316151e-01f, -2.13069648e-01f, 2.76692897e-01f, -1.15693390e-01f, -5.87106533e-02f, 2.13691533e-01f, -3.38670820e-01f,
  -2.35294536e-01f, 2.56800175e-01f, -6.84378669e-02f, -3.15859937e-03f, -1.74190208e-01f, -9.37513933e-02f, -4.82630074e-01f, 2.06245080e-01f, -2.57203251e-01f, -4.15373713e-01f,
  -2.55707592e-01f, 2.11926565e-01f, 1.98583722e-01f, 3.51225436e-01f, 4.87289429e-01f, -3.65594178e-01f, 3.46527427e-01f, -2.02670246e-02f, 3.35079789e-01f, 6.52401745e-02f,
  2.66880333e-01f, -1.06253391e-02f, -2.33816355e-02f, -2.14082554e-01f, -4.61018793e-02f, 9.24388766e-02f, -3.57038260e-01f, 1.21797957e-01f, -5.25206208e-01f, 2.94237435e-01f,
  2.16121301e-01f, -1.90483257e-02f, -4.97567207e-01f, 1.28251776e-01f, -5.39817773e-02f, -1.46719739e-01f, -6.38566958e-03f, 5.82490712e-02f, -5.59522733e-02f, -4.08676639e-02f,
  1.29898772e-01f, 2.77817287e-02f, 6.90590441e-02f, 4.81446497e-02f, -1.16139725e-01f, -1.30158037e-01f, 8.40589553e-02f, -1.09793574e-01f, 6.36659570e-06f, -1.01757340e-01f,
  -4.08259220e-02f, 9.92132425e-02f, -9.43583101e-02f, -7.25496709e-02f, -1.23268418e-01f, 1.03771180e-01f, -1.56998277e-01f, -1.90682098e-01f, -5.44419251e-02f, -1.49163872e-01f,
  -1.81057379e-01f, -1.15806915e-01f, 7.11558908e-02f, -7.25825597e-03f, 5.27100898e-02f, -1.57272205e-01f, 1.53062269e-01f, -2.39098575e-02f, 2.59597927e-01f, -3.41639592e-04f,
  2.44634785e-02f, 2.51598299e-01f, 1.51111418e-02f, 3.47284824e-01f, 4.15356129e-01f, 1.98835567e-01f, -3.14939618e-01f, 6.83590677e-03f, 3.92259330e-01f, 1.34367570e-02f,
  -1.10100478e-01f, -1.81119129e-01f, 3.20251614e-01f, -3.16981167e-01f, -2.24501014e-01f, 4.99164462e-01f, 3.06826327e-02f, -1.95970386e-02f, 3.41566831e-01f, 4.12578955e-02f,
  5.54052778e-02f, 2.84861982e-01f, 4.26805705e-01f, 3.97656292e-01f, 1.20759629e-01f, -2.18256563e-01f, 2.08694220e-01f, -1.02299102e-01f, -1.93870202e-01f, -3.84185135e-01f,
  -1.71631619e-01f, 7.05668032e-02f, 6.40414730e-02f, 1.71171844e-01f, 2.25677155e-02f, 2.08957940e-01f, 2.84883291e-01f, -1.66522190e-01f, -2.63698786e-01f, -1.83345824e-01f,
  2.19718933e-01f, 2.73999393e-01f, -2.03848481e-01f, -5.91450520e-02f, -1.85465187e-01f, -6.94409311e-02f, -2.21130610e-01f, -1.84372962e-01f, 4.17404205e-01f, 2.72165120e-01f,
  3.62361670e-01f, 1.81339681e-01f, -5.11790961e-02f, 1.20168306e-01f, 1.39062032e-01f, -1.75457641e-01f, 3.15437317e-02f, -7.70776868e-02f, -2.05058634e-01f, -3.99658903e-02f,
  1.51269943e-01f, 3.66282523e-01f, 2.44067177e-01f, -4.27318662e-01f, 2.15858147e-01f, -3.81241381e-01f, -1.51632369e-01f, 7.75585249e-02f, 2.24077463e-01f, -1.68637589e-01f,
  3.73209506e-01f, -4.06267829e-02f, -2.04062730e-01f, 1.28886197e-02f, 2.96378821e-01f, 1.46922171e-01f, 2.85897225e-01f, -1.05676301e-01f, 1.95236996e-01f, 2.77179480e-01f,
  1.99795887e-01f, 2.57587373e-01f, 2.46774480e-01f, 1.89489126e-02f, 1.81377813e-01f, 1.02090955e-01f, 3.32715750e-01f, -2.94008821e-01f, 2.29918718e-01f, -3.34148020e-01f,
  -3.43979090e-01f, -1.86975151e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 26)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 26;
const float L3_fan_Bp_bar_data[] = {
  3.19043845e-02f, 2.85014212e-01f, 2.85862237e-01f, 1.65540144e-01f, 1.83290392e-02f, 1.13023587e-01f, 1.71003684e-01f, 9.53662768e-02f, 5.63446581e-02f, -2.09896892e-01f,
  -1.52933851e-01f, 7.17092901e-02f, 2.02774510e-01f, -2.50238568e-01f, -1.90686092e-01f, -4.86285761e-02f, 1.50569141e-01f, 1.99351504e-01f, 1.07863836e-01f, 1.77749783e-01f,
  -2.30993722e-02f, -3.07172611e-02f, -7.24487528e-02f, 1.33165017e-01f, -1.53171942e-01f, 1.55757487e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  1.34314865e-01f, -1.48730382e-01f, -2.66930789e-01f, 1.14091866e-01f, 2.37347171e-01f, 1.18350305e-01f, -2.75683790e-01f, -2.22899944e-01f, -4.84505715e-03f, -8.10410753e-02f,
  1.01069488e-01f, -2.86462545e-01f, -5.62273920e-01f, 7.86235854e-02f, 2.02402160e-01f, -1.85695887e-01f, 1.37218475e-01f, 7.44626205e-03f, -3.93559933e-01f, 2.22871631e-01f,
  1.49637669e-01f, 2.59956032e-01f, -7.68448189e-02f, 1.20486788e-01f, 1.86878547e-01f, -1.14391394e-01f, 1.44512847e-01f, 1.32960007e-01f, 1.22222520e-01f, -4.99951124e-01f,
  -4.18781400e-01f, -1.72874212e-01f, 1.30192353e-03f, 1.34023011e-01f, -2.49811038e-01f, 2.47499868e-02f, -1.40234888e-01f, 1.57035083e-01f, -4.65855375e-02f, -3.66606891e-01f,
  -4.58020084e-02f, -5.74786484e-01f, -1.00725636e-01f, -2.32185155e-01f, 2.32072100e-01f, 1.26500294e-01f, -7.11497143e-02f, 3.81045789e-02f, 2.67999828e-01f, 2.76664197e-01f,
  -1.29502013e-01f, 1.16397232e-01f, 5.35118319e-02f, 1.83154374e-01f, 2.66591847e-01f, 4.60114665e-02f, -1.81501985e-01f, 1.29051823e-02f, -7.04327449e-02f, 2.74145693e-01f,
  -1.26125395e-01f, -3.85242313e-01f, -9.79743451e-02f, -4.35077786e-01f, 2.31436446e-01f, 7.40759596e-02f, 2.45948136e-01f, 2.90764570e-01f, 4.28103447e-01f, -3.12081605e-01f,
  -4.70569794e-04f, 1.71555236e-01f, -4.26795155e-01f, -3.46202523e-01f, -4.11998481e-01f, -2.46693403e-01f, 3.02518427e-01f, 2.37590566e-01f, -2.70441979e-01f, 1.19967207e-01f,
  1.84879065e-01f, 1.15480185e-01f, -2.93709725e-01f, -1.91503108e-01f, 1.07242502e-01f, 1.50240946e-03f, -2.64353544e-01f, 9.82887149e-02f, -2.54715420e-02f, -6.58992231e-01f,
  -4.32475388e-01f, 2.56177127e-01f, 3.71636823e-02f, 1.33830220e-01f, -6.72843516e-01f, -5.71318924e-01f, 2.67468005e-01f, -2.00025946e-01f, 2.62604296e-01f, 5.55005819e-02f,
  1.12000495e-01f, 8.97828937e-02f, -4.67822433e-01f, -5.28402269e-01f, 1.34084702e-01f, 3.07517081e-01f, -1.15908444e-01f, -3.58440012e-01f, -2.98063636e-01f, -3.82609874e-01f,
  -8.68095681e-02f, 5.83509393e-02f, 6.30493090e-02f, -4.29460824e-01f, 2.28611425e-01f, 1.43628344e-01f, -2.21211478e-01f, 1.34595111e-01f, -2.78802663e-01f, 2.04560440e-02f,
  7.30768517e-02f, 2.92679459e-01f, 2.52970755e-01f, -4.39350367e-01f, -1.47370651e-01f, -4.71407384e-01f, -1.49834946e-01f, -5.11728264e-02f, -2.13720035e-02f, -1.77418903e-01f,
  1.31674439e-01f, -2.57209331e-01f, -2.55099684e-01f, -3.15034091e-01f, -8.92848428e-03f, 1.12572774e-01f, 2.58230083e-02f, 2.19433293e-01f, -3.34938802e-02f, -2.16697454e-02f,
  -3.34295243e-01f, 3.21858376e-02f, -1.37237191e-01f, -7.82605708e-02f, -7.91521370e-02f, 2.13980004e-01f, -2.60175794e-01f, 7.71441907e-02f, 1.68628186e-01f, -8.34267363e-02f,
  -2.93412149e-01f, -1.63140465e-02f, 1.32555515e-01f, -8.25704709e-02f, 1.02706298e-01f, -4.46342491e-02f, 1.13524392e-01f, 8.76377709e-03f, -2.50090539e-01f, 3.27098131e-01f,
  -1.41591290e-02f, 2.21567124e-01f, 7.93608353e-02f, 3.13048810e-01f, -2.52684683e-01f, 3.01898003e-01f, 4.13833819e-02f, -1.86777741e-01f, 1.49895936e-01f, -4.19798270e-02f,
  3.09214532e-01f, 7.95924217e-02f, -2.87446499e-01f, 1.69169158e-01f, 1.75811410e-01f, -6.55152202e-02f, 5.35418317e-02f, -3.97091925e-01f, 5.59005104e-02f, -6.59045875e-02f,
  -3.28131974e-01f, 5.14240414e-02f, 1.97099209e-01f, -1.56787172e-01f, -4.01104182e-01f, 1.31098390e-01f, 2.61379648e-02f, -2.54402697e-01f, 6.31247684e-02f, -3.09044868e-01f,
  -6.69388175e-01f, -1.36219606e-01f, 1.36993706e-01f, 3.09074610e-01f, 1.69171602e-01f, -2.73747236e-01f, 1.92064822e-01f, -3.65753770e-01f, 2.65611053e-01f, 2.33597219e-01f,
  -2.69753933e-01f, -2.80426055e-01f, -9.83150825e-02f, 1.32438496e-01f, 2.21671671e-01f, 5.89195415e-02f, 1.45804631e-02f, 9.86568704e-02f, -2.31801108e-01f, -6.98176399e-02f,
  5.32378614e-01f, -2.69539535e-01f, -5.36221899e-02f, -5.52061558e-01f, -1.02240644e-01f, 1.74292833e-01f, -1.90858275e-01f, -8.51218998e-02f, -2.07956403e-01f, -2.75082767e-01f,
  -1.37308344e-01f, 9.13455784e-02f, -7.48629332e-01f, -1.83195785e-01f, -1.93416864e-01f, -8.16285312e-02f, 5.24544604e-02f, -3.23487520e-02f, 2.94985548e-02f, 1.54935434e-01f,
  -4.41452563e-01f, 1.26032293e-01f, 1.64908543e-01f, 2.16516957e-01f, -1.99227974e-01f, -3.42375249e-01f, -1.10991165e-01f, -3.34533066e-01f, 2.40521282e-01f, -1.33387029e-01f,
  3.19334656e-01f, 4.72541805e-03f, 1.27255023e-01f, 2.80675530e-01f, 2.47661382e-01f, -2.21030384e-01f, -2.57406831e-01f, -1.76910833e-01f, -1.57981619e-01f, -2.49393746e-01f,
  -3.38188708e-01f, -2.01532274e-01f, -1.43026620e-01f, -9.85181425e-03f, 3.64545345e-01f, -2.76489556e-01f, -1.47594079e-01f, 1.41002461e-02f, -9.12435129e-02f, -9.61244777e-02f,
  -2.50095606e-01f, 4.04083312e-01f, 2.03997433e-01f, 2.99437623e-02f, -4.42460746e-01f, -1.45930380e-01f, -4.18483973e-01f, -1.27603824e-03f, 2.58878887e-01f, 1.75819948e-01f,
  -3.40222478e-01f, -1.24888048e-01f, -2.21780211e-01f, -1.53550133e-01f, -2.63204455e-01f, -4.82944340e-01f, -4.92811948e-02f, 3.53817046e-02f, 5.11287525e-02f, 2.43569434e-01f,
  -2.84118026e-01f, -4.23192903e-02f, 1.19528659e-01f, 2.48461828e-01f, 9.60764587e-02f, -1.13994978e-01f, 6.32028729e-02f, -1.47743732e-01f, -3.02407563e-01f, -3.45935151e-02f,
  9.66147333e-02f, -6.31972030e-02f, 1.76166058e-01f, -7.45277945e-03f, 1.07219502e-01f, 1.82728902e-01f, -2.64480472e-01f, 7.57462680e-02f, -4.23600897e-02f, 1.69603720e-01f,
  -4.72385466e-01f, 1.93051845e-01f, -3.09309185e-01f, -7.12355450e-02f, 2.50560194e-01f, -4.39147264e-01f, -3.45179200e-01f, -2.44527176e-01f, 3.51342440e-01f, 3.60083096e-02f,
  -3.52650136e-01f, -2.61711348e-02f, -3.50036144e-01f, -4.25241202e-01f, -5.22445619e-01f, -3.41133356e-01f, -1.79780155e-01f, 1.58724293e-01f, -1.82385549e-01f, 6.75055906e-02f,
  -1.63335949e-01f, -2.35313550e-01f, 6.31955937e-02f, 3.51512671e-01f, -1.70270540e-02f, 3.20516139e-01f, 5.50704040e-02f, -3.52371395e-01f, 1.28643289e-01f, -7.29946643e-02f,
  5.82409278e-02f, 1.66542634e-01f, 2.31812567e-01f, 1.06181435e-01f, -7.28274286e-02f, -5.96581697e-02f, -5.29457867e-01f, -5.64139128e-01f, -2.99186110e-01f, -4.24385339e-01f,
  -3.99516821e-01f, -1.10033900e-01f, 9.84956995e-02f, 1.97415009e-01f, 6.19051516e-01f, 2.88563550e-01f, -3.40202153e-02f, -2.32355446e-02f, -2.01654598e-01f, -1.69792444e-01f,
  -9.42893565e-01f, 2.72820652e-01f, 1.72154278e-01f, 1.52699992e-01f, 1.23230703e-02f, -1.14161223e-01f, -6.83608800e-02f, -1.53434545e-01f, -5.05943298e-02f, -9.84513685e-02f,
  3.02646011e-01f, 1.93596169e-01f, 1.89263448e-01f, 2.08500355e-01f, -3.33833277e-01f, -4.28691417e-01f, 1.86568245e-01f, -1.18174307e-01f, -4.92921561e-01f, -1.32666230e-01f,
  4.31979239e-01f, -3.25558245e-01f, -5.05274475e-01f, -5.95224321e-01f, -3.23027521e-01f, -5.03525972e-01f, -4.34959307e-02f, -7.83184767e-02f, -2.13271771e-02f, -2.05327898e-01f,
  1.45487964e-01f, 2.22144611e-02f, -1.38285458e-01f, 4.96368408e-02f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -2.36873075e-01f, -1.29309192e-01f, -1.23961329e-01f, -1.45227209e-01f, 5.26955239e-02f, -3.70196477e-02f, 4.76160049e-02f, -2.39686877e-03f, -1.07129626e-02f, 1.18608616e-01f,
  1.12960972e-01f, 2.44837239e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    