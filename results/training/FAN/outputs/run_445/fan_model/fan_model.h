/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  7.95314759e-02f, -5.15343964e-01f, -5.19009791e-02f, -3.44112664e-01f, 1.28538862e-01f, -1.60822660e-01f, -3.87502640e-01f, -5.09172752e-02f, -9.63215064e-03f, -2.87283897e-01f,
  -1.31851703e-01f, -1.12334460e-01f, -2.10835367e-01f, -3.70266527e-01f, 2.11025961e-02f, -2.29075968e-01f, -2.31117189e-01f, -1.07460789e-01f, 6.62782118e-02f, -1.31387010e-01f,
  4.19918448e-02f, -2.73943543e-01f, -1.31385624e-01f, 6.91445172e-02f, -1.70249686e-01f, 9.10402313e-02f, -1.46095350e-03f, 1.35285348e-01f, -3.79501097e-02f, 7.09802285e-02f,
  -3.31500173e-02f, -1.13233633e-01f, 2.56634112e-02f, -5.02855750e-03f, -3.43555701e-03f, 2.13809405e-02f, 1.80703532e-02f, -2.65254155e-02f, 6.51383251e-02f, -1.44186597e-02f,
  -2.55449284e-02f, 7.44490474e-02f, -7.63661228e-03f, -5.18871509e-02f, 1.89194921e-02f, 2.84112571e-03f, 7.74297565e-02f, 1.51638929e-02f, -3.85606475e-02f, -7.82750323e-02f,
  3.31556704e-03f, 2.06693783e-02f, -2.90521644e-02f, -5.97695895e-02f, 7.10376427e-02f, -5.22856824e-02f, -8.41778368e-02f, -2.41937232e-03f, -3.97043601e-02f, -5.33907227e-02f,
  -4.17455146e-03f, -2.25092694e-02f, -2.25715749e-02f, 3.97882201e-02f, -5.00092432e-02f, 6.82439655e-02f, -5.10374233e-02f, 4.40695249e-02f, 2.85087153e-02f, -2.67545022e-02f,
  4.57606837e-02f, -3.09770219e-02f, -5.44321276e-02f, -7.05070123e-02f, 2.41992343e-02f, -3.36769000e-02f, -1.59507133e-02f, -4.27816696e-02f, 9.08592939e-02f, 6.39869869e-02f,
  -4.68155667e-02f, 4.49745692e-02f, -5.08401031e-03f, 1.70975998e-02f, -7.40982592e-02f, 3.51577438e-02f, -5.66508882e-02f, 5.15606999e-02f, -3.45208272e-02f, 5.03429323e-02f,
  -1.54363826e-01f, -3.05193543e-01f, -2.32085604e-02f, 3.43046449e-02f, 4.88486653e-03f, 2.13582851e-02f, -2.24977788e-02f, 8.19289163e-02f, 1.59591623e-02f, -3.86711620e-02f,
  -2.95739770e-02f, -2.60009561e-02f, 7.45292976e-02f, 4.09223475e-02f, 5.59251523e-03f, -4.10417514e-03f, -7.35344812e-02f, 6.94042221e-02f, -1.60237646e-03f, -2.79455748e-03f,
  -3.98725681e-02f, -1.01498375e-02f, 6.52658641e-02f, 6.47431836e-02f, 2.38895025e-02f, 2.48755403e-02f, 3.23766540e-03f, 5.96592426e-02f, 7.67770112e-02f, -5.49420156e-03f,
  -2.44310930e-01f, -1.29409060e-01f, -3.00128348e-02f, 7.54878893e-02f, 4.23451886e-03f, 4.51450020e-01f, 4.99831915e-01f, -1.70486942e-01f, 2.40629673e-01f, 1.48996547e-01f,
  7.20779449e-02f, 2.28134513e-01f, 4.10049409e-02f, 9.40190032e-02f, 1.54499590e-01f, 4.81567532e-03f, 1.57802418e-01f, 1.74893424e-01f, 1.56653672e-02f, -1.20679811e-01f,
  -4.53319959e-02f, -1.09287566e-02f, -4.76368926e-02f, -1.47028014e-01f, -1.83370449e-02f, -1.20459683e-01f, -1.28095761e-01f, -2.81310175e-02f, 7.83023797e-03f, 7.94188455e-02f,
  -7.30929077e-02f, -2.49850646e-01f, 4.80703153e-02f, 8.51947889e-02f, -6.01888970e-02f, 2.84583382e-02f, -2.53811292e-02f, 8.33036527e-02f, -4.45506610e-02f, 5.41482680e-02f,
  3.37194763e-02f, -6.67856410e-02f, 9.36174840e-02f, 1.31722182e-01f, 3.00988052e-02f, 4.13207449e-02f, -2.97046863e-02f, 2.08522491e-02f, -6.70455173e-02f, -1.44384533e-01f,
  2.43334379e-03f, -1.70410713e-04f, 4.23517898e-02f, 1.12807155e-02f, -1.82860717e-02f, 3.55967097e-02f, -4.98148128e-02f, 5.28863259e-02f, -3.26175988e-02f, -5.75285256e-02f,
  6.40729861e-03f, -3.40784378e-02f, -3.06138471e-02f, -4.22314554e-02f, 2.44169272e-02f, -1.35944590e-01f, 8.06974918e-02f, -6.81316480e-02f, -5.04636168e-02f, -2.99349949e-02f,
  6.02729023e-02f, 1.11058503e-02f, -6.45784065e-02f, 1.35213748e-01f, 5.47075458e-03f, -8.77076760e-02f, 9.19193253e-02f, -1.41708804e-02f, 7.21385479e-02f, 4.50120829e-02f,
  1.69758163e-02f, -1.65994242e-02f, 1.08048961e-01f, -1.63615623e-03f, 5.80854490e-02f, 9.12588164e-02f, -2.71092728e-02f, 3.88390236e-02f, -2.51015462e-02f, -1.39163656e-03f,
  -5.30227795e-02f, -9.78690460e-02f, 7.30672553e-02f, -2.73183975e-02f, 1.61913782e-02f, 6.10832982e-02f, 7.39343911e-02f, 5.16910180e-02f, 9.02371854e-02f, 1.25254439e-02f,
  8.42005387e-03f, 1.57193020e-02f, -2.64087431e-02f, -2.64105741e-02f, 6.44940585e-02f, 4.84707057e-02f, -5.79431280e-02f, 1.04441471e-01f, 4.83905859e-02f, -2.70079244e-02f,
  -3.36687304e-02f, -6.25519082e-02f, -7.55936326e-03f, 5.54314703e-02f, -1.30708877e-03f, -3.89234186e-03f, 5.73571585e-03f, -4.13309187e-02f, -1.14814065e-01f, 5.16685210e-02f,
  1.40810609e-02f, -2.36770809e-02f, -1.13539830e-01f, 9.98271853e-02f, 1.16317265e-01f, -3.82679068e-02f, 5.82122467e-02f, 1.48753569e-01f, -8.74561369e-02f, 3.00928281e-04f,
  1.47903562e-01f, -2.89108843e-01f, -8.58332068e-02f, 2.27084145e-01f, 6.11220598e-02f, -2.25514963e-01f, 1.52693182e-01f, 1.90666951e-02f, -2.05693990e-01f, -4.34983373e-02f,
  7.24182650e-02f, 1.56406194e-01f, 9.40594375e-02f, 6.08329214e-02f, 1.67543620e-01f, -3.86643736e-03f, 2.29270518e-01f, 1.37086064e-02f, 2.45201528e-01f, -4.98896539e-02f,
  1.30699068e-01f, 2.93975193e-02f, -4.14458197e-03f, -6.35776445e-02f, 9.72605869e-02f, 1.80144291e-02f, -4.56387550e-02f, -1.73662469e-01f, -2.51537561e-02f, -1.07253812e-01f,
  -1.71111867e-01f, -6.39562756e-02f, 5.86770065e-02f, -1.05288088e-01f, -3.76757309e-02f, -1.99104138e-02f, -2.54188031e-02f, -1.70401856e-02f, -4.02765861e-03f, -1.97667014e-02f,
  -3.85143161e-02f, 2.39549056e-02f, 4.20838445e-02f, -1.22497991e-01f, -1.30188242e-01f, -7.27454713e-03f, -3.47243138e-02f, -6.80091530e-02f, 1.41368769e-02f, -5.51844686e-02f,
  -9.28788185e-02f, -4.42212522e-02f, -3.23743261e-02f, 6.05686307e-02f, -1.74760725e-02f, 4.53766249e-02f, -7.82266632e-03f, -2.75221821e-02f, 6.40183315e-02f, 2.34034024e-02f,
  8.08257386e-02f, 4.96550910e-02f, 3.15619609e-03f, 1.47721665e-02f, 4.29345220e-02f, -7.22143576e-02f, -3.05495653e-02f, 2.42175837e-03f, 1.73251331e-02f, 2.14952137e-02f,
  5.10837026e-02f, -4.21534702e-02f, -1.27487984e-02f, 5.50049916e-02f, -3.97077613e-02f, 4.05965326e-03f, -7.73813128e-02f, -9.84817743e-02f, -6.46170378e-02f, 1.62931401e-02f,
  1.96750939e-01f, 1.66475192e-01f, 1.17399907e-02f, -4.82703336e-02f, 3.06645855e-02f, -7.48820305e-02f, -7.09861815e-02f, -1.18232891e-01f, 2.07825773e-03f, -8.93296003e-02f,
  -1.64868757e-02f, 1.00427330e-01f, 5.66190630e-02f, 2.19638627e-02f, 3.52140479e-02f, 1.14382915e-01f, 1.27955928e-01f, -4.99337353e-03f, 1.02239512e-01f, 2.38490161e-02f,
  9.12544280e-02f, -6.94445595e-02f, -9.16369334e-02f, 1.12718299e-01f, 1.07118813e-02f, 4.65927944e-02f, 2.84470022e-02f, -8.06228742e-02f, -9.84642073e-04f, 1.28686437e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.00142539e-01f, -3.85484040e-01f, -5.00167906e-01f, 3.00748736e-01f, 4.38721210e-01f, 3.99507523e-01f, 1.62413523e-01f, 2.47168034e-01f, 2.86639780e-01f, -3.19588445e-02f,
  1.94799781e-01f, -3.57258469e-01f, -4.13121790e-01f, 4.41232145e-01f, 3.21656257e-01f, -2.08792642e-01f, 3.94946486e-01f, 5.16819656e-02f, 1.28320903e-01f, 1.26624536e-02f,
  2.85034716e-01f, 5.38980246e-01f, -7.75492340e-02f, 1.43251553e-01f, 2.56497741e-01f, -1.04369476e-01f, -1.03623085e-01f, -3.55757266e-01f, 3.50859836e-02f, -3.52797145e-03f,
  2.03994244e-01f, 1.10510118e-01f, 6.32655695e-02f, -2.80808546e-02f, 2.14780471e-03f, -2.40176152e-02f, -1.44556016e-01f, -1.23328641e-01f, 1.03457667e-01f, -2.20335796e-02f,
  -1.13271452e-01f, 5.88149950e-02f, 8.74452814e-02f, 6.57160208e-02f, 1.89241409e-01f, 5.57302907e-02f, 2.61241067e-02f, 9.96775627e-02f, -9.80580077e-02f, -7.59005323e-02f,
  9.81769525e-03f, -3.51357572e-02f, 1.04535324e-02f, 2.01110486e-02f, -1.13470949e-01f, 9.28480253e-02f, -5.49564548e-02f, -1.47240996e-01f, -4.37158272e-02f, 4.47987989e-02f,
  1.64374281e-02f, -3.74533273e-02f, -2.31120158e-02f, 1.58202648e-01f, 9.29121673e-03f, 1.08111873e-01f, 6.25506639e-02f, -4.54155020e-02f, -2.81279273e-02f, -4.36354876e-02f,
  4.05442379e-02f, -6.84941979e-03f, 4.34199274e-02f, 4.52894205e-03f, 6.63235858e-02f, 1.38642743e-01f, -6.83292225e-02f, 5.40274940e-02f, -3.00828423e-02f, 1.13321446e-01f,
  -2.80600395e-02f, 5.98043902e-03f, -3.18138748e-02f, 1.08233737e-02f, 3.77422795e-02f, -3.40586826e-02f, -7.27046505e-02f, -2.34237853e-02f, 4.30061370e-02f, -6.65487796e-02f,
  -1.04718141e-01f, -4.50075209e-01f, -4.03812043e-02f, 9.68720913e-02f, -8.05692747e-02f, 5.76987043e-02f, 6.26645610e-02f, 1.65768683e-01f, -9.82578695e-02f, 9.23133269e-02f,
  2.33133528e-02f, -4.60909959e-03f, -3.88787799e-02f, -6.08981960e-03f, -4.79782335e-02f, 3.73894088e-02f, -1.04136862e-01f, -8.13816190e-02f, -1.73283163e-02f, -2.64040586e-02f,
  -3.35833468e-02f, -1.99775118e-02f, -2.72848234e-02f, 2.48228740e-02f, 2.77847480e-02f, -1.73484862e-01f, 2.18265094e-02f, -1.35313869e-01f, -1.04081847e-01f, -4.27819341e-02f,
  3.63148063e-01f, 1.19853824e-01f, 6.19136244e-02f, 4.07479078e-01f, -4.43766825e-02f, -3.11647654e-02f, 1.15191102e-01f, 1.98528737e-01f, 4.87650871e-01f, 1.27734110e-01f,
  4.09877189e-02f, -9.36757326e-02f, 3.77436578e-02f, 2.61360765e-01f, 1.77524835e-01f, 2.30667710e-01f, 3.93576562e-01f, -1.33640438e-01f, 4.21028554e-01f, 1.78944692e-01f,
  3.93651992e-01f, 3.19551468e-01f, 5.99807054e-02f, -4.13685553e-02f, 1.56978905e-01f, 1.02178857e-01f, 4.19892482e-02f, -1.04143754e-01f, -2.32219294e-01f, -9.97696072e-02f,
  8.80904719e-02f, 3.66166770e-01f, 7.65563399e-02f, -4.30416279e-02f, 1.61231786e-01f, -5.42716645e-02f, -1.77757174e-01f, -2.49915287e-01f, -4.29773889e-02f, 6.83959126e-02f,
  -1.03659397e-02f, -6.89953268e-02f, 1.06295876e-01f, -1.84036850e-03f, -1.08555466e-01f, 1.00333511e-03f, 6.70000678e-03f, 1.05397496e-02f, 3.55711244e-02f, -3.24612819e-02f,
  1.26409575e-01f, 1.37404919e-01f, 9.85458121e-02f, -4.36853655e-02f, 7.28030577e-02f, 5.03286794e-02f, -1.57596752e-01f, -2.11271364e-02f, -1.34242764e-02f, 6.56292588e-02f,
  1.27654925e-01f, 3.07253189e-02f, 1.13313183e-01f, -1.32844165e-01f, -5.27838990e-02f, -5.67945652e-03f, -2.27101389e-02f, -4.54706810e-02f, -1.58458517e-03f, -3.61298136e-02f,
  -1.55222137e-02f, 7.07974434e-02f, 5.70244938e-02f, -9.49768573e-02f, 2.78891295e-01f, 3.32027078e-02f, -8.60524476e-02f, -8.68823975e-02f, 1.84562042e-01f, 1.10624032e-02f,
  6.97831959e-02f, 6.67130873e-02f, 5.73636740e-02f, -2.80411225e-02f, -2.94302721e-02f, 7.25083500e-02f, 2.23308817e-01f, 3.70808356e-02f, -8.97379220e-03f, 9.04388875e-02f,
  4.04175930e-02f, 4.17137295e-01f, 8.33109543e-02f, -1.12407114e-02f, -5.37857078e-02f, 2.59175547e-04f, -5.84806614e-02f, 7.29840249e-02f, 1.77027732e-02f, 1.23262182e-01f,
  1.14876419e-01f, 3.28699611e-02f, -5.94868027e-02f, -9.85105783e-02f, -1.71668380e-01f, 1.45612001e-01f, 4.53809015e-02f, -1.67825203e-02f, 1.79806389e-02f, 4.94082421e-02f,
  -4.68680710e-02f, 7.78342262e-02f, 5.12653477e-02f, -2.66868453e-02f, 2.48993393e-02f, 1.97683517e-02f, -6.61760345e-02f, -9.07118917e-02f, 1.01554230e-01f, 5.84405512e-02f,
  -9.81715143e-01f, 3.07972372e-01f, 3.73961329e-01f, 1.38235420e-01f, -3.05631012e-01f, 2.30083734e-01f, 4.18483466e-01f, -1.71618372e-01f, -3.96396257e-02f, 2.52034426e-01f,
  8.31762478e-02f, -2.78226197e-01f, 2.60761082e-01f, 3.81507516e-01f, 2.15868607e-01f, 5.50403953e-01f, 2.93453813e-01f, 1.70823351e-01f, 7.76220933e-02f, -1.04129471e-01f,
  8.84670243e-02f, 1.95275061e-02f, 4.72270399e-01f, -9.71674174e-02f, 1.64611591e-03f, -1.05385661e-01f, 1.65359452e-01f, 7.81380162e-02f, 1.67591631e-01f, 7.49197975e-02f,
  -4.24564987e-01f, -3.21864665e-01f, -8.63986611e-02f, -1.19885050e-01f, -3.65957394e-02f, -3.67930345e-02f, 3.42659764e-02f, -5.95226092e-03f, -1.67519182e-01f, -1.26550421e-01f,
  -1.51096195e-01f, -1.50242805e-01f, -3.60043608e-02f, -3.00825927e-02f, -1.17482118e-01f, -1.16501145e-01f, -6.38134927e-02f, 3.69205810e-02f, -7.11003095e-02f, -2.52795704e-02f,
  1.29154339e-01f, 4.51191626e-02f, -1.32362358e-02f, 1.79750130e-01f, 5.27726077e-02f, 2.81200316e-02f, 2.09649190e-01f, -5.67497872e-03f, -2.08347440e-02f, -5.82986623e-02f,
  -2.52786689e-02f, -3.67698036e-02f, 1.91671215e-02f, 7.58838654e-02f, -2.29128897e-02f, 5.28624170e-02f, 8.29360634e-02f, -4.12775613e-02f, 3.60125564e-02f, 1.17000140e-01f,
  -4.64665890e-02f, -4.38509025e-02f, -1.28069997e-01f, 4.07982133e-02f, 1.77236125e-02f, 4.70312573e-02f, -1.42111443e-03f, -1.86903283e-01f, 2.50003953e-02f, -3.57090533e-02f,
  -1.21341934e-02f, -7.14038461e-02f, 1.06670357e-01f, 9.69889313e-02f, -3.10744606e-02f, 1.17602767e-02f, 1.36159016e-02f, 1.35020651e-02f, -8.90123546e-02f, 2.49572955e-02f,
  -5.39615192e-02f, -2.33539660e-02f, -6.07285090e-02f, -1.61599398e-01f, 8.85381326e-02f, -7.54680857e-02f, 6.46835044e-02f, 3.06681101e-03f, 1.60920113e-01f, -2.79732943e-02f,
  -9.44696516e-02f, 4.03557755e-02f, -5.43495007e-02f, 3.77845503e-02f, 1.10510826e-01f, 1.44285575e-01f, 8.77288058e-02f, -1.05732366e-01f, -2.03765426e-02f, -1.26815420e-02f,
  -7.72302747e-02f, 2.52306741e-02f, 8.26060101e-02f, 2.26250179e-02f, -6.54208288e-02f, -1.28111932e-02f, -5.26170805e-02f, 4.24059853e-02f, 3.35284014e-04f, 1.78836696e-02f,
  -7.62597442e-01f, 5.01258634e-02f, -1.34372219e-01f, -3.31363857e-01f, -3.17069739e-02f, 1.37861937e-01f, -3.04026175e-02f, 2.14772746e-01f, -2.58284181e-01f, 4.80998546e-01f,
  2.67985910e-01f, -3.88297230e-01f, 4.18975741e-01f, -1.27670780e-01f, -5.94126344e-01f, -2.73567289e-02f, -2.99545020e-01f, -1.39845330e-02f, -1.97447971e-01f, 2.63252780e-02f,
  -2.89232731e-01f, 1.28407314e-01f, -5.28727882e-02f, 1.44801930e-01f, 6.70677945e-02f, 5.92721440e-02f, 1.21147193e-01f, 1.93390265e-01f, -2.09897663e-02f, -1.56688020e-01f,
  7.48523101e-02f, 1.19677298e-01f, 2.33913630e-01f, 6.19586185e-02f, 1.13780200e-01f, 1.17662996e-01f, 7.31450617e-02f, -6.32412508e-02f, -3.73731591e-02f, -8.05253014e-02f,
  -6.15802445e-02f, -1.96903218e-02f, -1.54342532e-01f, 2.33669039e-02f, 1.86500642e-02f, 2.92745028e-02f, -1.79710407e-02f, -1.69382971e-02f, 9.87907574e-02f, -1.13028742e-01f,
  -4.29318734e-02f, 2.65254527e-02f, 1.46786869e-02f, -1.22989351e-02f, -4.46901210e-02f, 7.21959921e-04f, -3.43039297e-02f, -7.13107688e-03f, 6.96750730e-03f, -1.02415182e-01f,
  -6.44871145e-02f, -1.54865999e-02f, 8.15105066e-02f, 9.07368958e-02f, 4.70809564e-02f, 1.07406080e-01f, -9.93316025e-02f, 1.32506201e-02f, -8.45847204e-02f, 8.60223174e-02f,
  2.20378879e-02f, -5.50107062e-02f, 1.01984061e-01f, -3.55172367e-03f, -3.46869230e-02f, -9.74968895e-02f, -7.43332058e-02f, 1.04364984e-01f, -1.64220840e-01f, 3.98921361e-03f,
  2.50755519e-01f, -9.09135267e-02f, -2.47298647e-02f, 7.70263523e-02f, 1.60291567e-02f, -2.41412520e-02f, 2.57272040e-03f, -5.38276471e-02f, 1.08779326e-01f, -9.23686698e-02f,
  1.30029947e-01f, 7.15709925e-02f, 5.74587435e-02f, 7.53338113e-02f, 1.13123819e-01f, 4.01761793e-02f, 2.22917423e-02f, -1.22818507e-01f, -6.80788755e-02f, -2.86175851e-02f,
  5.19753247e-02f, 7.27916211e-02f, 6.54216930e-02f, -5.82821816e-02f, -1.26014844e-01f, 1.31315634e-01f, 7.17850477e-02f, -3.61418054e-02f, -4.51795422e-02f, -7.82755017e-02f,
  6.40820190e-02f, 1.78589125e-03f, -9.99662429e-02f, 5.67274354e-02f, 7.32229184e-03f, 4.20627110e-02f, -1.23951798e-02f, 4.93982881e-02f, -8.87308940e-02f, 6.36073351e-02f,
  -1.39243260e-01f, 4.66856658e-02f, 2.51048446e-01f, 3.56884152e-01f, -1.30814791e-01f, -3.30606610e-01f, -3.88563961e-01f, 5.48394248e-02f, 8.37536380e-02f, -2.72600859e-01f,
  -2.98099190e-01f, 2.68524557e-01f, -4.94771659e-01f, 3.16095680e-01f, 1.87966958e-01f, -1.82649001e-01f, 3.45409274e-01f, 7.67253339e-02f, 1.96965203e-01f, 1.50754318e-01f,
  2.67579556e-01f, 1.12306669e-01f, 3.89703184e-01f, 3.63547325e-01f, 1.81626588e-01f, 3.60370606e-01f, 2.81486094e-01f, 1.01300195e-01f, 3.02749693e-01f, 3.05477343e-02f,
  -9.15526673e-02f, -7.63656497e-02f, 4.90950458e-02f, 4.56031896e-02f, -3.26832496e-02f, -3.62852286e-03f, 3.49957161e-02f, -7.20577762e-02f, -1.93850044e-02f, -9.66311544e-02f,
  -7.57665634e-02f, 8.53842199e-02f, 1.48787171e-01f, 5.70138283e-02f, -3.01330052e-02f, 2.45054334e-01f, 3.22376899e-02f, -7.02042952e-02f, -6.34476915e-03f, 1.69257242e-02f,
  8.96424279e-02f, -3.23561467e-02f, 6.42066523e-02f, 3.09261363e-02f, 4.02445681e-02f, 1.18020726e-02f, 9.44668055e-02f, 5.72849438e-02f, 8.98917839e-02f, 1.22902654e-01f,
  -4.53339443e-02f, -4.39770594e-02f, -2.91363299e-02f, 3.74600850e-02f, 2.52306480e-02f, -7.35564306e-02f, 2.38077007e-02f, -3.62734087e-02f, -7.21069574e-02f, 2.10086000e-03f,
  1.44533440e-01f, 2.59208232e-02f, -6.09101057e-02f, 1.37845927e-03f, -2.63998006e-02f, -3.55572104e-02f, 1.73433125e-03f, -3.57162543e-02f, 2.83327904e-02f, 1.66001692e-01f,
  2.55015455e-02f, 2.94793472e-02f, 1.02250926e-01f, -2.12197751e-02f, -5.58258370e-02f, -1.89465564e-02f, 3.32186371e-02f, 8.46950859e-02f, 4.22204696e-02f, 1.14848413e-01f,
  -1.31669506e-01f, 1.07126303e-01f, 8.63094814e-03f, -1.71359241e-01f, 3.38151753e-02f, 8.81090388e-02f, 1.06500257e-02f, 1.53408557e-01f, 1.24791570e-01f, 9.41291917e-03f,
  -5.57585433e-02f, -4.95828539e-02f, -8.73029679e-02f, -3.19078006e-02f, 8.33581537e-02f, 1.43450750e-02f, -3.11357621e-02f, 5.03709912e-02f, 5.41588739e-02f, 5.40457852e-02f,
  1.11210775e-02f, -9.92088765e-02f, 1.17032446e-01f, 7.64317736e-02f, -1.77795440e-02f, 2.95415474e-03f, 4.89170989e-03f, 9.07191262e-02f, 1.26188502e-01f, 3.10526043e-02f,
  2.95234591e-01f, -1.24264330e-01f, 1.19900271e-01f, 2.18102634e-01f, 8.92639235e-02f, -2.85769045e-01f, -2.27217063e-01f, 1.79101214e-01f, -9.01303217e-02f, -3.19791198e-01f,
  2.94719916e-02f, 1.40912905e-01f, -8.42188671e-02f, 1.45415798e-01f, 5.01294792e-01f, -2.54478697e-02f, 2.61581451e-01f, 9.01520438e-03f, 5.99855855e-02f, 2.12105617e-01f,
  1.65846631e-01f, 1.47799432e-01f, 3.61518979e-01f, 1.59830734e-01f, 2.10218206e-01f, 4.53613326e-02f, 1.42547637e-01f, -9.75350365e-02f, 8.97453278e-02f, 4.05609049e-02f,
  -4.63118516e-02f, -2.41782907e-02f, 6.58443272e-02f, -4.63050157e-02f, -4.23017284e-03f, 6.61075488e-02f, 8.81607458e-02f, -3.83187346e-02f, -8.27452093e-02f, -1.13050714e-01f,
  -3.05131879e-02f, 1.31566659e-01f, -4.40746695e-02f, -4.98633310e-02f, -4.13171053e-02f, -4.33240496e-02f, 5.44156507e-02f, 1.18731424e-01f, 1.49429943e-02f, 1.14942148e-01f,
  1.97909679e-02f, -9.44503620e-02f, -3.95422950e-02f, -3.81018035e-02f, 1.37701944e-01f, -1.79856673e-01f, -1.26032427e-01f, -3.24782543e-02f, -1.89253062e-01f, 4.27446738e-02f,
  1.44869000e-01f, -2.83328164e-02f, -5.43608777e-02f, -7.85491392e-02f, 8.00236389e-02f, -1.06313251e-01f, -1.01337098e-01f, -2.19022464e-02f, 9.69303995e-02f, 5.66330738e-03f,
  -1.18996322e-01f, -1.62722275e-03f, -8.55102390e-02f, -1.19859844e-01f, -1.86903798e-03f, -2.89860535e-02f, 4.83158417e-02f, 2.30300799e-02f, -3.06414440e-04f, 3.82358837e-03f,
  -1.55596644e-01f, -4.34852205e-02f, -3.40138376e-02f, 1.27959589e-04f, -1.33066863e-01f, 1.55259417e-02f, -2.80362926e-02f, -3.44520025e-02f, 1.58213992e-02f, 1.20954499e-01f,
  7.18457624e-02f, 1.17057294e-01f, -1.84766185e-02f, 3.51083614e-02f, 3.81794460e-02f, 7.47693554e-02f, 4.82573248e-02f, -8.64034146e-02f, 1.19112395e-01f, 1.74426898e-01f,
  -2.66414601e-02f, -6.46082684e-02f, -1.46051913e-01f, -1.72539894e-02f, 6.42424524e-02f, -5.51514048e-03f, 1.35104626e-01f, -1.05888918e-01f, 7.34079778e-02f, 1.63442753e-02f,
  7.43568391e-02f, -1.64853051e-01f, 3.64683904e-02f, -4.20995541e-02f, -3.00234500e-02f, -1.37617558e-01f, 1.35311820e-02f, -2.99637616e-02f, 3.37698162e-02f, -1.22883506e-02f,
  -3.24470550e-01f, 2.36883655e-01f, -1.33963898e-01f, -2.13632330e-01f, 1.01945579e-01f, -1.71072334e-01f, -7.79753178e-02f, 1.47525430e-01f, 2.92417020e-01f, 7.50970319e-02f,
  3.41944844e-02f, 6.91655874e-02f, 3.49926353e-01f, -1.34537965e-01f, -2.01778293e-01f, 2.25720227e-01f, -3.40027481e-01f, -1.16754979e-01f, 2.66696513e-01f, -8.39861631e-02f,
  -4.12219241e-02f, -5.04307402e-03f, -1.47001967e-01f, 1.21829420e-01f, -2.31943130e-01f, -1.82582095e-01f, -2.43743971e-01f, 1.26513138e-01f, -4.06797767e-01f, 7.01752678e-02f,
  -2.58267194e-01f, 1.54240683e-01f, -2.08333313e-01f, -1.90689832e-01f, -3.06038827e-01f, -1.21256217e-01f, -2.21367434e-01f, 9.17512327e-02f, 1.24647230e-01f, 2.35412959e-02f,
  3.03724837e-02f, -3.53375822e-02f, -1.07909301e-02f, 1.41595259e-01f, 1.00949101e-01f, -8.77143722e-03f, -5.25318794e-02f, -1.56664103e-01f, 1.03773266e-01f, 3.79290618e-02f,
  1.59818083e-02f, -4.39618714e-02f, -2.73298919e-01f, -8.55162889e-02f, -1.58526778e-01f, 8.36298242e-02f, -7.34525472e-02f, -1.67877957e-01f, -1.28287077e-01f, -6.80990051e-03f,
  8.01893547e-02f, -2.31073052e-02f, -3.63841839e-02f, 1.19052544e-01f, 8.04890543e-02f, 1.84633769e-02f, -4.91032191e-03f, 8.80869254e-02f, 2.28228308e-02f, -5.57533912e-02f,
  1.90162584e-02f, -8.96941051e-02f, 9.22953114e-02f, -9.46541950e-02f, -4.30370681e-02f, 1.14241228e-01f, -1.52184546e-01f, 1.39741693e-02f, -4.39817123e-02f, -1.48206621e-01f,
  3.37549485e-03f, -1.41146079e-01f, 4.01005801e-03f, -1.55660719e-01f, 8.53895098e-02f, -4.20639999e-02f, -7.43265152e-02f, -9.54624702e-05f, -6.11627288e-02f, 1.06142554e-02f,
  -4.02642608e-01f, -1.04359873e-01f, 1.10325597e-01f, -2.61812005e-02f, -5.58724515e-02f, -9.82050672e-02f, -1.24695534e-02f, -7.11797625e-02f, 1.35313883e-01f, 6.49887137e-03f,
  8.52081329e-02f, -1.08040936e-01f, -1.89644367e-01f, 8.36280882e-02f, 6.39270246e-02f, -8.99627339e-03f, -9.73937213e-02f, -1.26676103e-02f, -1.00378931e-01f, -1.36359721e-01f,
  -2.19066218e-02f, 3.82243805e-02f, 4.40487489e-02f, -3.33116427e-02f, 1.54714389e-02f, -6.25022734e-03f, -1.04944231e-02f, 2.76886970e-02f, -1.14259392e-01f, -1.85299013e-02f,
  1.07768759e-01f, 2.00789377e-01f, -3.50905240e-01f, -1.96687490e-01f, -2.99389422e-01f, 4.91157204e-01f, 3.30709636e-01f, -1.41565174e-01f, -3.19674201e-02f, 4.64069217e-01f,
  2.25612879e-01f, -6.71923980e-02f, 2.19469652e-01f, 4.31534529e-01f, -3.69180813e-02f, 3.53867292e-01f, 4.45822924e-01f, 3.34847718e-01f, -2.01490715e-01f, 1.38952881e-01f,
  -1.76958129e-01f, 4.86830354e-01f, -1.81996778e-01f, 5.80343185e-03f, 1.33021176e-01f, -3.92758816e-01f, -5.98925017e-02f, -3.55866998e-01f, -1.12540610e-02f, -6.41469136e-02f,
  3.95693779e-02f, -8.48718286e-02f, -9.64663029e-02f, -5.96767552e-02f, 4.56554927e-02f, 7.96408802e-02f, -3.31726745e-02f, -7.87081793e-02f, -1.90803409e-01f, -1.43110836e-02f,
  4.48978804e-02f, -4.41940501e-02f, 4.40105870e-02f, -1.12922408e-01f, 8.11511278e-03f, -1.52622819e-01f, -1.39062464e-01f, -7.72997588e-02f, -1.03937484e-01f, 1.16515597e-02f,
  -1.39598951e-01f, -5.51840104e-02f, 7.20806362e-04f, -6.84984103e-02f, -1.71301693e-01f, -7.46847689e-02f, 4.53255884e-02f, -1.13027751e-01f, 1.06047675e-01f, -1.19179282e-02f,
  5.29557019e-02f, 4.42759171e-02f, 1.36677906e-01f, 7.55445212e-02f, 1.88568293e-03f, -3.82105745e-02f, 8.43169540e-03f, 1.24236597e-02f, -1.34639055e-01f, 8.35651159e-02f,
  -3.62659693e-02f, 4.52317239e-04f, 4.15087081e-02f, 2.63102036e-02f, 4.99623790e-02f, 1.29345089e-01f, 8.48879106e-03f, 5.46729751e-02f, -7.83466399e-02f, -3.00880019e-02f,
  -5.01522683e-02f, 1.21758217e-02f, -5.49737103e-02f, -5.00892941e-03f, 2.86408514e-02f, -8.32620710e-02f, 6.13363348e-02f, -1.50838932e-02f, -6.51635453e-02f, -1.56251397e-02f,
  3.70389409e-02f, 1.28428012e-01f, 3.13240686e-03f, 8.19408055e-03f, -2.05144212e-02f, 7.87292644e-02f, 6.42375648e-02f, 2.22283080e-02f, 2.28713825e-02f, 1.28454104e-01f,
  4.92901250e-04f, 2.04751007e-02f, 1.13088954e-02f, -5.55517711e-02f, -1.45749256e-01f, 1.06824324e-01f, 1.57825634e-01f, -6.53988793e-02f, 5.10164164e-02f, -1.46785572e-01f,
  3.29949036e-02f, -3.53656970e-02f, 1.15062043e-01f, 2.11994015e-02f, 4.90519702e-02f, 6.48689866e-02f, -4.06823084e-02f, -3.35819321e-03f, -6.47834241e-02f, -4.13413979e-02f,
  5.74145839e-03f, -1.18025042e-01f, 4.05777007e-01f, -2.53286153e-01f, 1.61455512e-01f, 5.37776828e-01f, 3.74692857e-01f, -1.75764516e-01f, -2.21761450e-01f, -4.03767675e-01f,
  -2.13075787e-01f, -1.25251738e-02f, 2.77545869e-01f, -2.52166986e-01f, 5.62575936e-01f, 1.42035618e-01f, -1.68097109e-01f, -2.39673510e-01f, -3.46714407e-02f, -2.62174278e-01f,
  -1.36282444e-01f, -4.44273978e-01f, 3.24125350e-01f, -3.30243915e-01f, 4.48605455e-02f, -1.99156329e-01f, -3.24729770e-01f, 1.53328434e-01f, -2.66978204e-01f, -1.76808517e-02f,
  -4.54072692e-02f, -2.29805067e-01f, 1.80050761e-01f, 2.01034799e-01f, 6.10839911e-02f, 1.27231583e-01f, 7.88979232e-02f, 2.07390845e-01f, 7.03537092e-02f, 3.23565491e-02f,
  2.30335500e-02f, -1.75892040e-02f, -2.01148272e-01f, 9.09189060e-02f, -2.09246166e-02f, -3.10395453e-02f, 1.08403116e-01f, 1.39864519e-01f, 6.33074045e-02f, 2.03513801e-01f,
  2.15125069e-01f, 1.25560597e-01f, 1.20589137e-02f, -9.35701951e-02f, 5.15971752e-03f, 4.32746373e-02f, 5.03627881e-02f, 1.54364258e-01f, 5.05712628e-02f, 1.05170861e-01f,
  5.00574559e-02f, 3.41007747e-02f, 1.55585930e-01f, 1.35152612e-03f, 1.92914382e-02f, -1.73650235e-01f, -2.02721870e-03f, -8.62768069e-02f, -4.17457297e-02f, -1.06605321e-01f,
  -6.81074262e-02f, -3.79353501e-02f, -1.82619970e-02f, -4.66615893e-02f, -7.96804056e-02f, -4.93663624e-02f, 6.49524853e-02f, -3.04310247e-02f, -2.30139662e-02f, -2.49637105e-02f,
  -1.41848654e-01f, -4.69928868e-02f, -1.30895684e-02f, -4.48141508e-02f, 6.57849163e-02f, 1.17812760e-01f, -1.05876148e-01f, 6.17199838e-02f, -5.31118922e-02f, 4.71117012e-02f,
  -2.32255250e-01f, -5.48887968e-01f, -5.43547608e-02f, -4.30391803e-02f, -2.15332210e-03f, 5.58744930e-02f, -5.28271915e-03f, -6.47034943e-02f, -1.81619838e-01f, -2.63149524e-03f,
  2.02870872e-02f, -1.00910522e-01f, -3.25036198e-02f, -7.58627877e-02f, 1.47491498e-02f, 6.33317009e-02f, -1.14233658e-01f, -1.34664431e-01f, -5.62882759e-02f, -1.49503782e-01f,
  -3.53888161e-02f, -2.31947973e-02f, -6.94044903e-02f, -1.59175932e-01f, -1.02341793e-01f, -4.62674573e-02f, -4.29775566e-02f, 5.63367642e-03f, -8.08273815e-03f, 5.62987849e-03f,
  1.37023687e-01f, -2.50489384e-01f, -4.80368286e-01f, -9.68443528e-02f, 3.15848291e-01f, 3.18664640e-01f, -1.07019633e-01f, 6.86891435e-05f, -4.59894687e-01f, 1.29743204e-01f,
  1.97292969e-01f, -9.36661065e-02f, -4.19521660e-01f, 5.36835156e-02f, 3.43580917e-02f, -4.49042976e-01f, 2.78559148e-01f, 1.44801155e-01f, -2.50785887e-01f, 3.05559665e-01f,
  -6.18712492e-02f, 3.37154210e-01f, -2.42180362e-01f, 2.94045955e-01f, 2.33429387e-01f, 7.37262070e-02f, 4.21170950e-01f, -1.11335874e-01f, 4.31543112e-01f, 1.40979096e-01f,
  -3.14703397e-02f, -1.17152818e-01f, -6.22128136e-02f, -1.00670688e-01f, 9.97122824e-02f, 1.70278743e-01f, 9.06560197e-02f, -3.66509333e-02f, -7.20397159e-02f, -2.86058150e-02f,
  -1.51024545e-02f, -2.64926185e-03f, 3.68786454e-02f, -2.12576818e-02f, 8.08861628e-02f, 6.19464293e-02f, -6.37921318e-02f, -1.20947763e-01f, -1.26556352e-01f, 1.03608156e-02f,
  -1.65492564e-01f, 1.13574922e-01f, -1.80195011e-02f, 2.04089135e-02f, -1.28272632e-02f, 1.49403326e-02f, 4.06164229e-02f, 9.08830017e-02f, 5.11587895e-02f, 1.44730076e-01f,
  1.10119589e-01f, 7.57430419e-02f, -5.33439731e-03f, -9.96778607e-02f, 2.24473159e-04f, -2.02287566e-02f, 1.59184095e-02f, -2.81416299e-03f, -3.65886167e-02f, -3.11752539e-02f,
  8.58393535e-02f, -2.90151220e-02f, 9.67990316e-04f, 9.90725085e-02f, 7.25778639e-02f, -8.94448087e-02f, -8.93289130e-03f, 6.00819588e-02f, -1.22529855e-02f, -1.07132509e-01f,
  -8.36535171e-02f, 8.65484551e-02f, 5.92346899e-02f, -4.20144685e-02f, -6.99826255e-02f, 5.91859594e-02f, 6.76033720e-02f, -4.01162542e-02f, -1.27981722e-01f, 6.47891965e-03f,
  1.25235721e-01f, 1.34273946e-01f, -9.60463136e-02f, -4.59674112e-02f, -3.17615308e-02f, 1.85788080e-01f, -9.60130244e-02f, 1.15260929e-01f, 6.39055297e-02f, 4.06937189e-02f,
  2.39944980e-01f, 4.34294268e-02f, 7.01557547e-02f, -4.40406725e-02f, 2.26051081e-03f, 9.94388312e-02f, 4.43823002e-02f, 2.68117953e-02f, 1.28083140e-01f, 1.67818978e-01f,
  1.18717015e-01f, 1.46425039e-01f, 4.91373474e-03f, 4.56927940e-02f, 1.15630530e-01f, 1.02994069e-01f, 1.19612679e-01f, 2.83970218e-02f, 4.80266884e-02f, -9.11549777e-02f,
  6.99184313e-02f, -3.39985579e-01f, 2.10591465e-01f, 7.52491280e-02f, 4.38364521e-02f, -8.31747651e-02f, 6.27299398e-02f, -3.80305827e-01f, -5.09365678e-01f, -3.85605216e-01f,
  5.11870869e-02f, 2.56627798e-01f, 1.92109153e-01f, 1.85344238e-02f, 6.45996273e-01f, 6.52795061e-02f, -1.08797185e-01f, 1.42795339e-01f, -1.19688045e-02f, 7.59590566e-02f,
  1.30861074e-01f, 4.23924439e-02f, 4.10354823e-01f, -1.93836112e-02f, 6.39414340e-02f, 3.34724449e-02f, 2.56771743e-01f, 4.01875794e-01f, 1.09875239e-01f, 3.12808931e-01f,
  -4.04919833e-02f, -2.07692400e-01f, -2.18011662e-02f, 1.32795563e-02f, -4.40310054e-02f, 4.61880676e-02f, 1.63095295e-01f, 2.70799041e-01f, 1.25595227e-01f, 8.59046355e-02f,
  1.95315368e-02f, 1.17236041e-01f, -1.30576015e-01f, 1.87250242e-01f, -7.67283663e-02f, -8.48029628e-02f, -1.45739466e-01f, -7.89612904e-02f, -4.58044372e-02f, -9.56793129e-03f,
  -3.04936115e-02f, -1.18748292e-01f, -6.44736215e-02f, -6.94903964e-03f, 4.72112373e-02f, -1.18532091e-01f, -7.44891493e-03f, 1.57539591e-01f, 3.47275697e-02f, -4.53453138e-02f,
  3.07818037e-02f, -4.73094434e-02f, 3.93611304e-02f, 1.64997950e-02f, -3.24721411e-02f, 2.21883412e-02f, 2.05961261e-02f, 1.33490920e-01f, 1.86314490e-02f, -7.71454126e-02f,
  -2.44123377e-02f, -1.36738382e-02f, -4.47520874e-02f, -1.15365304e-01f, 1.43466601e-02f, -2.16803685e-01f, 9.26768035e-02f, 6.07846938e-02f, -3.74735110e-02f, -9.36876982e-02f,
  9.67218801e-02f, 8.48588273e-02f, -2.47132890e-02f, 3.24328942e-03f, -3.48838270e-02f, 7.00288638e-02f, -2.50377622e-03f, 1.98621415e-02f, -2.85041239e-02f, 7.73892626e-02f,
  7.73252174e-02f, 9.31086689e-02f, -1.30494833e-02f, 4.33220975e-02f, -1.12335198e-02f, -1.42806709e-01f, 2.49841586e-02f, -1.18181057e-01f, -2.14084312e-02f, -8.69942680e-02f,
  -2.98906909e-03f, 3.09623610e-02f, -1.09497078e-01f, 4.43796366e-02f, 1.61502451e-01f, -4.67120223e-02f, 4.66404296e-02f, 4.19946482e-05f, 3.94849330e-02f, -4.68542660e-03f,
  2.87164189e-02f, 3.23802442e-03f, 1.41910374e-01f, -1.04618005e-01f, 6.28435016e-02f, 1.39843315e-01f, -7.31810704e-02f, -1.41821345e-02f, 7.02140406e-02f, -6.18760334e-03f,
  -2.13617250e-01f, -1.31373957e-01f, -1.41728356e-01f, -2.32931510e-01f, -2.30140984e-01f, -2.11768165e-01f, 1.12048768e-01f, -2.87816823e-01f, -8.52451921e-02f, 6.62141517e-02f,
  -3.28059010e-02f, 1.73666343e-01f, 4.63496536e-01f, -2.15495318e-01f, -8.59126672e-02f, 3.22659612e-01f, -2.45071039e-01f, 7.70744830e-02f, 1.62878335e-02f, -2.32169122e-01f,
  -1.87265173e-01f, -1.83361456e-01f, 1.17377320e-03f, -2.42941618e-01f, -3.46403033e-01f, -1.86552122e-01f, 1.00882605e-01f, 1.06253393e-01f, -2.40285590e-01f, 4.40814123e-02f,
  -4.18815404e-01f, -8.98606628e-02f, -6.64606765e-02f, -7.04735005e-03f, -1.09961458e-01f, -2.24465486e-02f, -3.61720920e-02f, 1.65107742e-01f, -6.72809854e-02f, -5.19194733e-03f,
  4.81174961e-02f, -3.96607369e-02f, 2.10231543e-02f, 7.77914524e-02f, -1.15064144e-01f, 1.34840012e-02f, -4.31487486e-02f, -4.79690433e-02f, -1.29619628e-01f, -1.89532600e-02f,
  -7.03549981e-02f, -8.56662393e-02f, -1.51563272e-01f, 2.21745167e-02f, -1.87627971e-02f, -1.03297107e-01f, -8.33003521e-02f, 4.33808975e-02f, -8.29589367e-02f, -2.18408942e-01f,
  -1.06869414e-01f, 1.12002932e-01f, 1.97632276e-02f, -7.32783228e-02f, -4.31212708e-02f, -4.30457108e-02f, 9.80369449e-02f, -7.05352500e-02f, 1.54370010e-01f, 5.69120832e-02f,
  -1.38815686e-01f, -7.94915631e-02f, -4.17896137e-02f, 7.84083828e-02f, 9.11384262e-03f, 3.58740874e-02f, 9.62565243e-02f, -1.67326003e-01f, -8.24043751e-02f, 6.47672564e-02f,
  1.60141084e-02f, -7.60979354e-02f, 7.50802606e-02f, 6.50327131e-02f, -1.39827013e-01f, 8.68750736e-02f, -4.42187786e-02f, -1.55525059e-01f, 1.31033167e-01f, 9.74928811e-02f,
  -3.95973504e-01f, -3.47013503e-01f, 3.31436768e-02f, 5.83309797e-04f, 1.22687541e-01f, -3.49706598e-02f, 5.37210107e-02f, -1.98186889e-01f, -4.52588126e-02f, -1.49023697e-01f,
  -7.11703971e-02f, -1.52405594e-02f, -1.35436729e-01f, -6.36824965e-02f, -6.81531355e-02f, -8.78945291e-02f, 8.96262452e-02f, 3.21383998e-02f, -1.95217750e-03f, -8.87670070e-02f,
  -1.16945822e-02f, 5.16637117e-02f, 1.23080075e-01f, 7.27623478e-02f, 7.17596933e-02f, 7.05497712e-02f, -1.00024574e-01f, -9.46128890e-02f, 8.39778781e-02f, -4.32169586e-02f,
  3.77756447e-01f, 4.82799590e-01f, 3.18381995e-01f, 4.52078372e-01f, -2.80561060e-01f, -5.27539439e-02f, 8.69663209e-02f, -9.81409326e-02f, 3.23138893e-01f, 1.36129662e-01f,
  -2.89650321e-01f, 6.14087105e-01f, -1.81801796e-01f, 7.04641864e-02f, -1.67678013e-01f, -1.96591213e-01f, 2.35547557e-01f, 2.50832438e-01f, 3.24107930e-02f, 2.03173786e-01f,
  4.65717725e-02f, -3.09932709e-01f, -5.07413112e-02f, -2.76500493e-01f, 9.41073447e-02f, 2.19601348e-01f, -3.29445839e-01f, -1.78775892e-01f, -9.84375086e-03f, -1.08295687e-01f,
  -6.98407069e-02f, 1.93426177e-01f, 1.37994006e-01f, 8.17945227e-02f, -1.61874685e-02f, 7.43244728e-03f, -1.09298050e-03f, -1.42675817e-01f, 2.98182573e-02f, 1.13650724e-01f,
  1.32521272e-01f, 5.39636612e-02f, 7.41075203e-02f, -1.02467583e-02f, 2.14868579e-02f, 1.20953768e-01f, 6.92878515e-02f, 1.19165424e-02f, 1.26539081e-01f, -2.03384297e-05f,
  1.70905486e-01f, 1.04364052e-01f, 4.69178110e-02f, 3.94054279e-02f, 5.17700650e-02f, -1.03675341e-02f, 4.45989706e-02f, 1.80893894e-02f, 6.12585209e-02f, 8.98108259e-02f,
  2.98770834e-02f, 2.37365142e-02f, -1.07259057e-01f, -8.28978885e-03f, -1.02721527e-01f, 1.41179906e-02f, 1.37881599e-02f, -3.04602925e-02f, 9.73399505e-02f, -1.95640046e-02f,
  -1.29972715e-02f, -4.06944044e-02f, -8.14014003e-02f, 6.26802891e-02f, 8.01713690e-02f, 2.43579317e-02f, -2.34556645e-02f, 5.18933460e-02f, 6.21705540e-02f, -7.40683675e-02f,
  5.26111498e-02f, -5.19484095e-03f, 4.26773578e-02f, -1.68455504e-02f, -2.45114807e-02f, -8.00981000e-02f, -1.33848503e-01f, 8.58318880e-02f, 1.08485064e-02f, -7.06711113e-02f,
  3.69045287e-02f, 1.39493898e-01f, -5.39233871e-02f, 4.31591608e-02f, 6.41930550e-02f, -2.76641902e-02f, 1.05715327e-01f, 9.50338840e-02f, -2.26592254e-02f, -8.02754089e-02f,
  -2.25030053e-02f, 2.83428822e-02f, -1.95544194e-02f, -9.89907160e-02f, -1.66817643e-02f, -7.69005641e-02f, 5.95838949e-02f, 5.23075350e-02f, -3.11150085e-02f, -5.50053492e-02f,
  -1.15445562e-01f, 5.88994697e-02f, -2.22479869e-02f, -3.23433019e-02f, 5.87362349e-02f, 6.84627914e-04f, 1.02131635e-01f, 9.50549319e-02f, -1.64387394e-02f, 8.89412016e-02f,
  5.05006947e-02f, 3.58524203e-01f, -1.10158443e-01f, -2.38961563e-01f, 1.24948539e-01f, -2.99321204e-01f, -1.44612268e-01f, 2.26575285e-02f, 9.18511208e-03f, 3.27484906e-01f,
  -9.60756317e-02f, 1.93779990e-01f, 3.18551846e-02f, -3.30518305e-01f, -5.71165502e-01f, -3.59062284e-01f, -4.96135384e-01f, -2.48966172e-01f, -2.24626631e-01f, -2.51336005e-02f,
  -2.44395658e-01f, -2.00468376e-01f, -3.83438021e-01f, 2.25956231e-01f, 2.65470624e-01f, 2.47483507e-01f, -2.09171623e-01f, 1.54181734e-01f, 1.46640057e-04f, 5.76579571e-02f,
  -5.05039990e-02f, 4.98447977e-02f, 4.17870767e-02f, 5.87543808e-02f, -3.69303860e-02f, 1.82939574e-01f, 5.96335679e-02f, -1.18073776e-01f, -5.96565269e-02f, 5.18555194e-03f,
  1.93913479e-03f, 8.16041697e-03f, -7.90581927e-02f, -5.24707586e-02f, 2.18391538e-01f, 6.00657649e-02f, -7.73353055e-02f, 8.96550342e-02f, 8.11720937e-02f, -6.44924492e-02f,
  -4.52157818e-02f, 1.23513527e-01f, 1.19693130e-02f, -5.27759567e-02f, -1.14364453e-01f, 9.49194562e-03f, -8.14230442e-02f, 1.86772011e-02f, -3.30700725e-02f, 1.20504620e-02f,
  5.15593439e-02f, 6.24563619e-02f, -6.87066689e-02f, 1.10962436e-01f, -6.78780079e-02f, 1.15225895e-03f, 7.22086336e-03f, -5.61196655e-02f, 7.52916262e-02f, 1.48845874e-02f,
  6.46106005e-02f, 1.17884926e-01f, -8.92218575e-03f, -5.71963117e-02f, 2.67709140e-02f, -3.63061354e-02f, -2.34419038e-03f, -3.67339924e-02f, -1.59004152e-01f, -5.54993488e-02f,
  8.26364234e-02f, -5.12074120e-02f, 7.58325756e-02f, 6.01211749e-02f, -8.22703540e-02f, -6.98482469e-02f, 6.30233437e-02f, -6.60351589e-02f, -6.81696162e-02f, 1.34213418e-02f,
  -1.20681278e-01f, -6.03624657e-02f, 3.00084502e-02f, 4.73692408e-03f, -5.44556491e-02f, -2.30037998e-02f, -1.45849243e-01f, 1.15614887e-02f, 1.48805147e-02f, 6.63403794e-03f,
  7.86045492e-02f, -1.23712216e-02f, 9.15631428e-02f, -6.11428246e-02f, -8.13254714e-02f, -7.44082779e-02f, 9.90203917e-02f, 8.64401758e-02f, -7.12614646e-03f, -4.93662953e-02f,
  1.07493892e-01f, 1.51981702e-02f, 1.06872700e-01f, 3.86640839e-02f, 5.50050810e-02f, 3.24272476e-02f, 3.14333253e-02f, 4.95545454e-02f, -2.34354474e-02f, 7.05991592e-03f,
  -1.58485621e-01f, -2.70433366e-01f, -2.70266056e-01f, -4.43289906e-01f, 1.38637200e-01f, -1.65827647e-01f, -2.45280355e-01f, -2.55254805e-01f, -8.41662064e-02f, -5.40122157e-04f,
  -1.09783821e-01f, -7.32696652e-02f, 2.35973373e-01f, -4.27914113e-01f, -2.47592121e-01f, -3.69043499e-02f, -4.06824887e-01f, -2.59563267e-01f, 2.45616343e-02f, -1.15375958e-01f,
  -8.51087645e-02f, -3.35532486e-01f, -2.86897629e-01f, -5.23988740e-04f, -1.51614219e-01f, 6.05988912e-02f, 3.17446053e-01f, 2.54178226e-01f, -1.16759583e-01f, -1.95612907e-02f,
  -1.90045610e-01f, -4.62351926e-03f, -3.17602754e-02f, -6.35402352e-02f, -5.18031605e-02f, 1.64614365e-01f, 5.21850912e-03f, -1.23881333e-01f, 7.67582059e-02f, -3.82061638e-02f,
  9.13703889e-02f, 1.21161692e-01f, -1.11465611e-01f, 8.91573057e-02f, -5.38377184e-03f, -1.22610621e-01f, -4.01791893e-02f, -6.15985058e-02f, 3.70884463e-02f, -8.98766667e-02f,
  -1.63595840e-01f, -4.49493118e-02f, -1.22807072e-02f, -3.91128333e-03f, -6.59861192e-02f, -1.21409325e-02f, 2.68940013e-02f, 9.16805491e-02f, 9.55012739e-02f, -3.80846672e-02f,
  -1.54596902e-02f, 7.04347417e-02f, -6.20775949e-03f, -7.59551302e-02f, -6.55289441e-02f, 8.36912356e-03f, -1.45629290e-02f, -4.97061685e-02f, 5.61638214e-02f, -1.27098739e-01f,
  -3.88601087e-02f, -4.73591983e-02f, 1.48344552e-02f, 2.29081009e-02f, 3.53609808e-02f, 2.80524772e-02f, 2.49541644e-02f, 9.02366731e-03f, -2.44432203e-02f, -3.12167127e-02f,
  -9.23778117e-02f, -4.71764132e-02f, -2.02776063e-02f, 6.10285327e-02f, 8.53515714e-02f, 8.91306624e-02f, -6.80243298e-02f, 5.93108870e-02f, -2.62498129e-02f, 1.12576216e-01f,
  6.74739629e-02f, 2.23247262e-04f, -5.31793870e-02f, -5.06785065e-02f, 5.36593236e-02f, 6.18450157e-02f, -8.48448277e-02f, -1.19103193e-01f, 4.17237729e-03f, 5.17891310e-02f,
  -6.37002662e-02f, -3.46739143e-02f, 1.42792955e-01f, -2.81463470e-02f, -5.84266670e-02f, -1.24600135e-01f, 3.54345180e-02f, -5.62457144e-02f, 1.00865429e-02f, 1.47772245e-02f,
  3.44277173e-02f, 4.99200150e-02f, 6.43874928e-02f, 9.24561694e-02f, -1.96221825e-02f, 6.97451830e-02f, -3.82521711e-02f, 2.85230670e-03f, 6.31603152e-02f, -5.86371496e-02f,
  1.15809545e-01f, -4.55915540e-01f, 3.09631620e-02f, 1.45723224e-01f, 1.53153092e-01f, -1.81914270e-01f, -5.62765868e-03f, -2.04149872e-01f, -9.26640481e-02f, -4.64433372e-01f,
  -1.21195816e-01f, 2.82608807e-01f, -3.82383347e-01f, -3.15234959e-02f, 2.56544910e-03f, -3.08218956e-01f, 2.00280193e-02f, 2.07197964e-01f, 3.07810530e-02f, 8.87776539e-02f,
  4.38906103e-02f, -7.13342577e-02f, 1.10151775e-01f, -2.27693498e-01f, 2.15001881e-01f, 9.95682031e-02f, -5.26969209e-02f, -4.17223945e-02f, 1.77237079e-01f, 1.07157290e-01f,
  -1.43890873e-01f, -6.72749951e-02f, 1.14436656e-01f, -1.82037547e-01f, -7.33510554e-02f, 1.64074391e-01f, 8.82734358e-02f, 8.61260742e-02f, 7.74105638e-02f, 3.46500836e-02f,
  1.33622242e-02f, 1.05595887e-02f, 2.35207751e-02f, 7.77621344e-02f, -2.87155863e-02f, 9.17642862e-02f, 4.97102737e-02f, 1.52868927e-02f, -4.56776023e-02f, 1.23431357e-02f,
  9.11358967e-02f, 1.80938765e-01f, 3.61706177e-03f, 7.99789429e-02f, 1.37254104e-01f, 4.44068983e-02f, 4.05427180e-02f, 7.80138746e-02f, -2.11407132e-02f, 5.36313690e-02f,
  1.88468218e-01f, -3.68514061e-02f, -9.15648416e-02f, -8.97148177e-02f, -6.70768917e-02f, -4.59975861e-02f, -1.00149073e-01f, -4.87244353e-02f, -3.35370488e-02f, -8.94824415e-02f,
  6.31144410e-03f, 6.94124177e-02f, 1.03989527e-01f, -3.18621434e-02f, 3.59691679e-02f, 1.15323782e-01f, 1.73277363e-01f, 1.87598877e-02f, -3.60064232e-03f, 9.33582187e-02f,
  5.39235137e-02f, -2.15300508e-02f, -7.04838634e-02f, 4.59395982e-02f, -2.92381588e-02f, -7.87325427e-02f, -1.00477181e-01f, -2.32869498e-02f, 2.97780093e-02f, -6.19308017e-02f,
  -5.85574448e-01f, -5.04239678e-01f, -4.23703045e-02f, -3.02376244e-02f, -1.38620153e-01f, 1.21183768e-02f, -9.75703895e-02f, -4.37171273e-02f, -1.52087405e-01f, -1.01279333e-01f,
  1.45410806e-01f, 8.69194344e-02f, -1.22556508e-01f, 1.10697187e-01f, -7.29818121e-02f, -1.34251580e-01f, -6.24135733e-02f, -9.40518007e-02f, 1.42229935e-02f, -1.15639687e-01f,
  -4.72026132e-03f, 2.91945692e-03f, 1.94416810e-02f, -1.89564656e-02f, 4.88695614e-02f, 8.47726166e-02f, 7.15441555e-02f, 6.19373359e-02f, 4.19929251e-02f, -8.91087279e-02f,
  1.80114120e-01f, -1.94465876e-01f, -2.63412654e-01f, -3.13669354e-01f, -1.86301515e-01f, -2.44631007e-01f, -2.26243421e-01f, -1.67772189e-01f, -7.01442137e-02f, -1.98463555e-02f,
  -2.64276296e-01f, 5.54717071e-02f, 8.52423087e-02f, -4.00900036e-01f, 3.09846640e-01f, 2.39297599e-01f, -2.49980286e-01f, -1.28716111e-01f, -3.22793983e-02f, -1.45389974e-01f,
  -6.65284246e-02f, -1.98368490e-01f, -1.12175472e-01f, -2.57353187e-01f, -1.81834310e-01f, -2.26794153e-01f, 4.85444255e-02f, -1.96273550e-01f, -4.02877480e-01f, -1.70499846e-01f,
  -1.53495565e-01f, 1.16320066e-02f, -6.01732917e-02f, -2.67439941e-03f, 5.03070727e-02f, 4.37757559e-03f, -1.07267387e-01f, -3.18125747e-02f, 8.38545114e-02f, 1.45907253e-01f,
  9.12485942e-02f, 7.84087479e-02f, -8.21240470e-02f, -6.17311299e-02f, -5.00751063e-02f, -6.81479424e-02f, -5.10191871e-03f, 6.65934235e-02f, -2.40793042e-02f, 1.18832197e-02f,
  -1.17569610e-01f, 4.87888753e-02f, -7.36782029e-02f, -9.83130410e-02f, -2.61899829e-02f, -6.30517155e-02f, 1.80033386e-01f, 1.07855149e-01f, 3.02712228e-02f, 9.97116044e-02f,
  -1.14030533e-01f, 4.33902815e-02f, 5.30438870e-02f, -9.98941511e-02f, -5.57927825e-02f, 5.84316440e-02f, 1.17096305e-02f, 4.50258255e-02f, 5.28180189e-02f, 6.89888839e-03f,
  -5.23809083e-02f, 1.27944686e-02f, -8.07664637e-03f, -3.77686555e-03f, 1.57509148e-01f, 1.52593181e-01f, -9.11981165e-02f, -8.15799683e-02f, -4.71732616e-02f, 5.99876679e-02f,
  6.03260100e-02f, 2.86914321e-04f, -8.92791525e-02f, 6.50574416e-02f, -3.20604853e-02f, 7.87488371e-03f, -1.36536330e-01f, -7.15518147e-02f, -2.28049662e-02f, 2.84085609e-02f,
  4.61181141e-02f, 2.48162933e-02f, -3.75291072e-02f, 3.44562680e-02f, 1.02822252e-01f, -3.51179391e-02f, -8.16542581e-02f, -6.78765699e-02f, -1.02929600e-01f, 8.67342576e-03f,
  2.56367698e-02f, -2.96316072e-02f, 8.09924230e-02f, 1.70920733e-02f, 3.63807045e-02f, -2.21780618e-03f, 1.22199543e-01f, 8.75442252e-02f, 1.14558876e-01f, 1.11651115e-01f,
  -7.70145804e-02f, 9.74929631e-02f, 1.36230439e-01f, 3.36831063e-02f, -7.19682500e-02f, -6.38091844e-03f, 1.86876506e-01f, -6.70507699e-02f, 6.51261136e-02f, -7.52969980e-02f,
  -2.86102504e-01f, -6.33453801e-02f, -1.29087836e-01f, -2.21517846e-01f, -3.71725649e-01f, -1.03122741e-01f, -2.40353465e-01f, -1.40605435e-01f, 1.91640660e-01f, 1.27340615e-01f,
  -5.76453358e-02f, 4.12454866e-02f, 3.24273109e-01f, -1.84124187e-01f, 2.26386070e-01f, 4.60264087e-01f, -1.66968077e-01f, 5.01156449e-02f, -2.53633261e-01f, -1.96992099e-01f,
  -7.13809952e-02f, -9.40341577e-02f, 2.79196408e-02f, -1.68102205e-01f, -4.49601412e-01f, -1.38913378e-01f, -1.09817378e-01f, -2.58159846e-01f, -3.55273038e-01f, -2.57754505e-01f,
  -5.11175953e-02f, -5.70109524e-02f, -1.47835597e-01f, 8.17674845e-02f, -9.75249056e-03f, -3.39399874e-02f, -6.75559118e-02f, 8.02948885e-03f, -1.10382326e-01f, -1.54095560e-01f,
  -5.33315875e-02f, 1.73786923e-01f, -3.30234095e-02f, 1.29469499e-01f, -2.49633994e-02f, -1.06022872e-01f, 6.31478950e-02f, -3.34185734e-02f, 8.33674613e-03f, 6.94803745e-02f,
  2.70928349e-02f, -4.53501344e-02f, 2.71305125e-02f, 1.08700059e-01f, -8.70998576e-02f, -1.10982440e-01f, 1.13801062e-01f, 5.20765781e-02f, -8.96055996e-02f, -8.57419297e-02f,
  5.74551821e-02f, 4.22418788e-02f, -1.54246595e-02f, 2.39785891e-02f, -1.26014939e-02f, -1.01542279e-01f, -9.29220617e-02f, 1.41247781e-02f, -8.17665979e-02f, -5.02959900e-02f,
  1.20119438e-01f, 6.06374741e-02f, 5.90339303e-02f, -4.87802140e-02f, -1.78816572e-01f, -2.47569568e-02f, 8.13329592e-02f, 1.20483816e-01f, 3.12372614e-02f, -3.87312844e-04f,
  8.72572362e-02f, 1.22378863e-01f, 2.25313585e-02f, -1.82116684e-02f, -2.99338307e-02f, 3.65518108e-02f, -1.43716753e-01f, 7.15015978e-02f, -3.28700580e-02f, -1.55493870e-01f,
  -2.49214005e-02f, -1.76036492e-01f, -9.16226134e-02f, 8.06506053e-02f, -6.24198876e-02f, 2.77954955e-02f, 5.60301505e-02f, -8.63481611e-02f, -2.59663075e-01f, -8.64670426e-03f,
  -1.29791319e-01f, 7.55972266e-02f, -8.62430707e-02f, -3.75411958e-02f, 4.76673506e-02f, -3.61672156e-02f, -1.92152068e-01f, -4.24577519e-02f, -1.29975334e-01f, -1.38180658e-01f,
  -5.42841181e-02f, 2.20320895e-02f, 1.64902672e-01f, -5.78735396e-02f, 2.45394222e-02f, -4.78728153e-02f, 9.23363958e-03f, 4.41024639e-03f, -1.62753031e-01f, 6.66775331e-02f,
  4.59906459e-01f, -3.58016491e-01f, 3.89954865e-01f, 2.70724982e-01f, 3.49769533e-01f, -5.79811297e-02f, -2.04233658e-02f, 1.36376426e-01f, 3.02603364e-01f, -2.06761107e-01f,
  -1.87770389e-02f, -1.70915157e-01f, -2.22401634e-01f, -2.53527667e-02f, -8.76620188e-02f, -2.20956862e-01f, -4.14761454e-02f, -3.19958091e-01f, 4.63346913e-02f, 8.73574167e-02f,
  1.35660186e-01f, -2.65191615e-01f, -5.61863743e-02f, -1.51498005e-01f, 1.79014474e-01f, 9.31056067e-02f, -2.20083803e-01f, -1.22887425e-01f, -7.83134177e-02f, -8.31800774e-02f,
  4.42969874e-02f, 1.38041809e-01f, -8.16998705e-02f, -9.27319080e-02f, 9.04215500e-02f, 4.47679013e-02f, -3.11271437e-02f, -1.75427888e-02f, -1.29490504e-02f, 1.50353955e-02f,
  -7.29960948e-02f, -3.73369120e-02f, 2.33542528e-02f, -9.79235470e-02f, 1.57867074e-01f, 5.80755621e-02f, 9.00840312e-02f, 3.61413807e-02f, 1.27806589e-02f, 1.56448841e-01f,
  6.46260604e-02f, -9.40242596e-03f, 1.88801885e-01f, -1.56011030e-01f, 7.52292806e-04f, 1.16564974e-01f, 5.98334223e-02f, -2.18960270e-03f, 1.53103210e-02f, 1.17033675e-01f,
  -1.19257942e-01f, 1.59035474e-02f, 3.78385633e-02f, 3.62930633e-02f, 2.12544091e-02f, 6.22796938e-02f, 1.73596814e-02f, -1.03584349e-01f, 5.70451282e-02f, 3.99832502e-02f,
  4.62170318e-02f, -3.12907211e-02f, 5.61415218e-03f, 1.18588805e-01f, 3.73303122e-03f, 1.05326604e-02f, -4.35297675e-02f, -9.58665609e-02f, 4.51912880e-02f, -3.59503645e-03f,
  -1.49456998e-02f, -1.26231015e-01f, -3.70149761e-02f, 1.12075552e-01f, -5.60621396e-02f, -9.48177353e-02f, 3.33138816e-02f, 5.14864624e-02f, -1.85241364e-02f, -1.58125520e-01f,
  -5.86333871e-01f, -5.27761638e-01f, -1.12880632e-01f, -4.21939604e-02f, -1.66407928e-01f, -4.76934947e-02f, -6.40771687e-02f, -4.55538407e-02f, -2.05188185e-01f, -3.54081057e-02f,
  -1.46159092e-02f, 3.66587490e-02f, -1.32531837e-01f, 3.50417988e-03f, -2.34284341e-01f, 1.23472132e-01f, -1.27122939e-01f, -1.75624326e-01f, -1.56109482e-01f, -3.11405901e-02f,
  -6.54660761e-02f, -6.12496324e-02f, 1.36925370e-01f, 7.39500672e-02f, -1.87659878e-02f, 2.77252886e-02f, 2.09650975e-02f, 2.22737878e-03f, -1.78384390e-02f, -9.21041667e-02f,
  -8.08005750e-01f, 5.32487929e-01f, -3.05132642e-02f, -1.85575679e-01f, 4.18495461e-02f, 5.45394957e-01f, -5.28032109e-02f, 1.92182809e-01f, -2.02825531e-01f, -1.76330488e-02f,
  -9.31438133e-02f, -1.68463036e-01f, -7.19175264e-02f, 2.45317861e-01f, 2.02529132e-01f, 2.96654016e-01f, 3.06813955e-01f, -6.95595518e-02f, 1.60110146e-01f, 4.94422903e-03f,
  9.92059410e-02f, 1.26623377e-01f, 2.12737486e-01f, 2.83214927e-01f, -5.96667454e-02f, -2.45669916e-01f, -2.04187408e-01f, -5.94779430e-03f, 1.95358187e-01f, 1.07788920e-01f,
  -1.24129929e-01f, -3.97753358e-01f, -2.86692291e-01f, -2.10906208e-01f, -1.07556872e-01f, -1.39840156e-01f, -1.17000997e-01f, -1.61366910e-01f, -1.23201415e-01f, 7.36527070e-02f,
  -1.11263290e-01f, 2.98589505e-02f, 1.96977723e-02f, -1.10203475e-01f, -7.42666572e-02f, 1.58382822e-02f, 1.92628667e-01f, 1.18361689e-01f, 1.45288020e-01f, 1.53251946e-01f,
  1.23646364e-01f, 1.71463683e-01f, 1.78900883e-02f, 7.76859522e-02f, 5.91740347e-02f, 2.59030401e-03f, -2.54195239e-02f, 6.66911080e-02f, 1.68686695e-02f, 6.00496866e-02f,
  -5.08648120e-02f, 1.28953839e-02f, -1.20606653e-01f, -1.13876686e-01f, -1.08708382e-01f, 2.68913284e-02f, 2.23829597e-02f, -3.07228919e-02f, -4.25765365e-02f, 6.94757178e-02f,
  6.15967214e-02f, 3.62234972e-02f, 8.59287381e-03f, 1.76963471e-02f, -3.02317142e-02f, -1.03671454e-01f, -5.18390536e-02f, -1.05010355e-02f, 6.06982736e-03f, 6.28909618e-02f,
  -8.93581584e-02f, 1.55497706e-02f, -7.83644468e-02f, -3.93817797e-02f, -8.17699078e-03f, -4.83974218e-02f, -1.25128463e-01f, 1.61981285e-01f, 1.47255855e-02f, 4.65488918e-02f,
  -1.15459479e-01f, -2.44136021e-01f, -1.04665659e-01f, -1.10128358e-01f, -4.32390757e-02f, 1.29986100e-03f, 2.33288836e-02f, 1.38628677e-01f, 1.82428826e-02f, -1.61846086e-01f,
  3.55300941e-02f, -4.60566394e-02f, -8.73734951e-02f, -4.72449549e-02f, 5.74195571e-03f, 3.13520804e-02f, -9.45511237e-02f, -4.47781235e-02f, -9.07724202e-02f, 4.37291153e-02f,
  -1.74765542e-01f, -8.51211026e-02f, 4.24688905e-02f, 3.86457853e-02f, -6.23073541e-02f, 5.05501255e-02f, -1.29743427e-01f, 1.35366339e-03f, 2.80092172e-02f, 3.24637443e-03f,
  -6.08181238e-01f, 5.46665967e-01f, 2.81874746e-01f, -4.38196570e-01f, 2.80233830e-01f, -1.73720032e-01f, -2.09745154e-01f, 1.74422115e-01f, 4.03339900e-02f, 6.63725510e-02f,
  -2.72938516e-02f, 7.46141449e-02f, 1.79958567e-01f, 1.04675181e-02f, -2.73717076e-01f, 5.26625216e-02f, -1.72659889e-01f, -1.83885187e-01f, 1.29559815e-01f, -1.23190910e-01f,
  -1.09949037e-01f, -1.16300680e-01f, -1.11201145e-01f, 2.37791747e-01f, -1.81087591e-02f, 1.76464804e-02f, -3.24141204e-01f, 2.22387478e-01f, -1.05416916e-01f, 1.03309356e-01f,
  -4.21080410e-01f, -2.01624095e-01f, -1.21133246e-01f, -1.05025880e-01f, -2.27505907e-01f, -1.22665025e-01f, -1.22911543e-01f, 2.74230763e-02f, 1.28213074e-02f, 2.86204163e-02f,
  -4.18492891e-02f, 1.29437121e-02f, 1.40782408e-02f, 8.49131942e-02f, -7.60906115e-02f, 7.75813824e-03f, 1.25462011e-01f, -1.12968512e-01f, 2.29070242e-02f, 1.26816034e-01f,
  6.68432042e-02f, 7.83208981e-02f, -1.70579135e-01f, -6.24021292e-02f, -1.44396797e-02f, -6.61569759e-02f, -1.13478517e-02f, -6.05228022e-02f, -9.57326367e-02f, -1.61735699e-01f,
  9.74098369e-02f, -1.83177575e-01f, 1.17215566e-01f, -5.55755906e-02f, 8.92765522e-02f, 7.68283708e-03f, 2.28303876e-02f, -7.19596669e-02f, -1.36986030e-02f, -1.26656726e-01f,
  -1.34323955e-01f, -6.62687942e-02f, -3.62059195e-03f, -4.19639647e-02f, -2.94213519e-02f, -1.03984950e-02f, -6.28781244e-02f, -1.38742123e-02f, -8.60138051e-03f, -6.32437542e-02f,
  5.25718071e-02f, 6.13011457e-02f, 1.29031792e-01f, -1.15630187e-01f, 1.06434627e-02f, 5.79748340e-02f, 4.58358228e-02f, 5.35979588e-03f, -1.90661079e-03f, -6.53159395e-02f,
  -5.55510640e-01f, -3.85561109e-01f, -8.21932033e-02f, -5.93420155e-02f, -4.47397046e-02f, -3.66845839e-02f, -3.46416049e-02f, 6.98676631e-02f, -1.82530254e-01f, 6.96662739e-02f,
  -1.45164772e-03f, -1.08072758e-01f, -1.21906556e-01f, 1.66047830e-02f, 2.33146679e-02f, -1.05653174e-01f, -1.93989486e-01f, -1.35114551e-01f, -2.31034324e-01f, 1.27738602e-02f,
  -6.13827184e-02f, -5.89027107e-02f, 2.03833990e-02f, -6.60064295e-02f, -1.45481095e-01f, -1.80483565e-01f, -1.08531669e-01f, 9.15011987e-02f, -7.08753616e-02f, -1.74897444e-02f,
  1.93835109e-01f, 2.46594459e-01f, 3.01381588e-01f, 4.58061755e-01f, -1.33138567e-01f, -2.94627279e-01f, -2.06580535e-01f, 2.82739937e-01f, 2.81725407e-01f, -6.96658418e-02f,
  -2.71594673e-01f, 3.10708463e-01f, -1.42009497e-01f, 1.60694331e-01f, -2.57229328e-01f, -2.36417204e-01f, -5.35947457e-02f, 1.75238088e-01f, 1.17955096e-01f, 2.72788052e-02f,
  1.45866781e-01f, -2.98984557e-01f, 1.17217422e-01f, 1.40155464e-01f, 1.80418372e-01f, 2.64315426e-01f, -1.47161022e-01f, 1.05697557e-01f, 1.16492331e-01f, -1.92210346e-01f,
  -1.78956389e-02f, 1.25055224e-01f, 2.33185098e-01f, 1.07836306e-01f, 1.27904013e-01f, -1.70308545e-01f, -6.37427270e-02f, -5.88275306e-02f, 8.93334597e-02f, 6.01883605e-02f,
  -9.01229531e-02f, -5.14582880e-02f, 9.17950943e-02f, 5.50896637e-02f, 1.32868707e-01f, 1.76033929e-01f, 1.24987893e-01f, -5.90640604e-02f, 1.19688980e-01f, 9.15087983e-02f,
  7.95848593e-02f, 1.38290390e-01f, 3.41511983e-03f, 3.61491032e-02f, 4.49687205e-02f, 2.40395218e-02f, -5.25852963e-02f, 7.49477595e-02f, 1.19493008e-01f, 1.62282512e-01f,
  -2.04583630e-01f, -8.41943994e-02f, 1.68429799e-02f, 1.61355510e-01f, 6.28867447e-02f, 7.59184128e-04f, 1.57488901e-02f, -1.68335944e-01f, -9.32346098e-03f, -9.10319388e-02f,
  3.95563394e-02f, 2.80014366e-01f, 4.64616567e-02f, 2.53709462e-02f, 3.77112627e-02f, 1.11672230e-01f, -1.03858009e-01f, 1.86519772e-02f, 3.54982466e-02f, 7.93200433e-02f,
  1.31993264e-01f, -2.40061328e-01f, 4.95050475e-02f, -9.79785919e-02f, -5.02689295e-02f, 1.00607894e-01f, 4.63444591e-02f, 8.72820616e-02f, -6.55012354e-02f, -5.71144894e-02f,
  -1.58197254e-01f, -2.09376346e-02f, 9.96555462e-02f, 8.98462683e-02f, 4.12271991e-02f, -1.22740082e-01f, -6.75463602e-02f, 1.77336745e-02f, 1.15790442e-02f, 7.39059877e-03f,
  -3.31581235e-02f, 2.87462045e-02f, -2.57782601e-02f, -6.21888824e-02f, -7.73767382e-02f, -4.72574942e-02f, -7.61372745e-02f, -1.11088820e-01f, -2.87350062e-02f, -6.31052209e-03f,
  3.53426151e-02f, -1.50181606e-01f, 1.70764457e-02f, 8.32496360e-02f, -1.15256004e-01f, 5.22866771e-02f, -1.25917317e-02f, 7.24537969e-02f, -4.72044758e-02f, -2.55550183e-02f,
  5.24297774e-01f, -2.73277611e-01f, 1.86668575e-01f, 3.05749327e-01f, 2.98773021e-01f, 1.54836863e-01f, 5.43067515e-01f, -2.00157881e-01f, 2.49629721e-01f, -3.82876992e-01f,
  9.41331983e-02f, -7.58925974e-02f, 2.00611115e-01f, -1.06780924e-01f, 3.20234418e-01f, 9.97154042e-02f, 5.45190461e-02f, 7.28361383e-02f, 8.01750496e-02f, 1.38812140e-01f,
  2.39566669e-01f, 2.90193539e-02f, 2.14525908e-01f, -2.87607849e-01f, 2.27495909e-01f, -1.83812991e-01f, 3.83832696e-04f, 1.44540295e-01f, -3.64347696e-01f, -2.45512147e-02f,
  8.54250193e-02f, 5.04761077e-02f, -9.36884526e-03f, -2.35116944e-01f, 3.42162624e-02f, 8.07125308e-03f, -8.32036585e-02f, -1.78970285e-02f, 2.32030209e-02f, -1.11857481e-01f,
  -3.59264240e-02f, -9.11962241e-02f, -1.30505025e-01f, 4.66084778e-02f, 5.93641587e-02f, -7.77544752e-02f, 1.62619427e-02f, 1.05569325e-02f, -1.17535312e-02f, 5.19317500e-02f,
  1.18301108e-01f, 4.85004522e-02f, 1.72683120e-01f, -1.34747192e-01f, 2.46062689e-03f, -3.37133035e-02f, -1.82055049e-02f, 5.75058982e-02f, -3.65926512e-02f, -9.40751806e-02f,
  -1.22991920e-01f, 2.01151315e-02f, -3.11319325e-02f, -9.89737585e-02f, 6.25806376e-02f, 3.41248326e-02f, -5.94691895e-02f, -5.06308451e-02f, 3.32802795e-02f, 1.50245041e-01f,
  1.16935916e-01f, 2.05655340e-02f, 5.67466728e-02f, 4.77898195e-02f, 2.13590777e-03f, -6.95924833e-02f, 5.82610676e-03f, -1.35886312e-01f, -8.37680046e-03f, 1.18241422e-02f,
  4.11517844e-02f, 3.48833539e-02f, 6.97286204e-02f, -1.75118327e-01f, -4.30866480e-02f, 9.50934887e-02f, -1.26780450e-01f, 1.06873631e-01f, -3.43139581e-02f, 9.01719332e-02f,
  -4.99065295e-02f, -2.59917408e-01f, 2.62781549e-02f, -1.47130862e-01f, -2.00236030e-02f, -5.25885858e-02f, -7.25955069e-02f, -1.84329525e-02f, 4.79337908e-02f, -9.98119451e-03f,
  -1.76463574e-01f, 1.36269014e-02f, 5.05651422e-02f, 2.54678191e-03f, -1.71239357e-02f, 6.75428472e-03f, -1.29565028e-02f, -9.12801474e-02f, -1.87172126e-02f, -5.79984635e-02f,
  -7.52514834e-03f, -1.52617944e-02f, 2.18317658e-02f, -2.53171776e-03f, -1.38675272e-01f, 5.28298840e-02f, -4.65471596e-02f, 6.60059378e-02f, -5.91166429e-02f, -7.77425393e-02f,
  4.07938519e-03f, 5.17473757e-01f, 6.07218109e-02f, 5.71014807e-02f, 5.58091961e-02f, -5.29558241e-01f, -4.12247062e-01f, 1.38118416e-01f, -1.88328385e-01f, 2.77474374e-01f,
  -6.11421838e-02f, 1.56896397e-01f, -2.59938836e-03f, -1.87533498e-01f, -5.26505709e-01f, -4.02377725e-01f, -1.44151703e-01f, -4.12101820e-02f, -1.34821042e-01f, 2.84846425e-01f,
  -1.15128130e-01f, -1.25404850e-01f, -1.38376147e-01f, 8.30561221e-02f, 2.19434753e-01f, 2.16206789e-01f, 3.62620801e-01f, 1.39980915e-03f, 1.59400582e-01f, -1.50690258e-01f,
  -6.65357113e-02f, 7.35465437e-02f, 6.18204996e-02f, -9.35459957e-02f, 8.31398368e-02f, 1.99575387e-02f, 5.75706959e-02f, -7.26296455e-02f, -1.19842298e-01f, -7.72587731e-02f,
  9.83518213e-02f, -3.08342241e-02f, -6.35998026e-02f, -6.34593368e-02f, 1.14695512e-01f, 3.60779534e-03f, 3.26020084e-02f, 1.64102152e-01f, 3.88249941e-02f, 6.09731935e-02f,
  -4.40102220e-02f, 3.20212618e-02f, 7.45185018e-02f, 5.27246110e-02f, 6.93025365e-02f, 2.23266371e-02f, -4.79742922e-02f, 6.05681650e-02f, 8.16507116e-02f, 3.63736525e-02f,
  1.57554567e-01f, -7.37850890e-02f, -6.62305811e-03f, -5.98209314e-02f, -4.17115092e-02f, 5.24211163e-03f, 6.24148287e-02f, -4.18130569e-02f, 2.81191673e-02f, 4.47947010e-02f,
  -1.20733771e-02f, 5.63087240e-02f, -7.90515170e-02f, 1.19705675e-02f, -1.49535351e-02f, 5.13084754e-02f, 1.39605524e-02f, -1.14269564e-02f, -1.31975915e-02f, 6.42525405e-02f,
  -4.09083478e-02f, -9.56588835e-02f, -2.51487959e-02f, 1.07207619e-01f, -1.82374120e-01f, 6.63528070e-02f, 4.14069109e-02f, 6.20632209e-02f, 3.19870040e-02f, -7.03401119e-02f,
  1.05863944e-01f, 3.09983432e-01f, -7.34968483e-02f, -4.70262244e-02f, -5.49974069e-02f, -4.75378335e-02f, -1.17839493e-01f, 1.62704140e-01f, 3.79844122e-02f, -3.46432924e-02f,
  1.07514560e-01f, 6.57429174e-02f, 7.99960271e-02f, 1.09507386e-02f, -9.87594724e-02f, -5.30700982e-02f, -6.54775416e-04f, 9.69017018e-03f, 1.46376401e-01f, 1.19455464e-01f,
  1.78045303e-01f, 9.30073783e-02f, -2.56743822e-02f, -3.79134044e-02f, -2.51402543e-03f, 2.91657224e-02f, 1.62997171e-02f, 8.17913283e-03f, 7.55479410e-02f, 4.24009338e-02f,
  4.14113581e-01f, 2.81616181e-01f, 4.39092875e-01f, 3.22375238e-01f, 1.50208786e-01f, 4.22186881e-01f, 2.45994344e-01f, 3.76422256e-01f, 7.10605085e-01f, -8.48158747e-02f,
  -2.34232485e-01f, 2.32224151e-01f, -1.30083635e-01f, 6.02510907e-02f, -8.92871022e-02f, -7.06242621e-02f, 1.44308284e-01f, 1.01839099e-03f, 1.71595559e-01f, 5.90372831e-02f,
  3.78282415e-03f, -4.31752831e-01f, -2.94901371e-01f, -3.33607018e-01f, -1.83724184e-02f, 5.70931807e-02f, -4.82556731e-01f, -5.23253009e-02f, -1.89814225e-01f, 3.10591068e-02f,
  6.87273815e-02f, 8.90694112e-02f, 2.34572254e-02f, 1.49284273e-01f, 6.82509914e-02f, 1.20440818e-01f, -2.20635086e-02f, -9.67045352e-02f, 9.16433036e-02f, 1.14601947e-01f,
  -6.95405975e-02f, 1.34461094e-02f, 6.02559606e-03f, 1.28911752e-02f, 2.19436780e-01f, 2.68806256e-02f, 6.17265813e-02f, 1.74046621e-01f, 6.82552159e-02f, 3.74701805e-02f,
  2.45999955e-02f, 1.66047081e-01f, 1.19581679e-02f, 8.81211013e-02f, 2.27346830e-02f, 1.23765126e-01f, 1.34471074e-01f, -4.33518812e-02f, 1.59802660e-02f, 1.40834734e-01f,
  -1.15346968e-01f, 6.25070110e-02f, -1.64592378e-02f, -6.51202798e-02f, -6.12463579e-02f, 2.64433380e-02f, -1.07479565e-01f, -5.35166226e-02f, 9.91041958e-02f, -1.41291305e-01f,
  8.62072036e-03f, 3.72686908e-02f, 5.25393581e-04f, 7.47901574e-02f, -5.03254607e-02f, 7.36594945e-03f, -2.62488835e-02f, 3.46510708e-02f, 7.70927519e-02f, 1.86768882e-02f,
  -8.78894329e-02f, 9.93821472e-02f, -1.49541900e-01f, -3.35032716e-02f, -5.85317053e-03f, -6.09524995e-02f, 4.85911332e-02f, 2.90534161e-02f, 8.98370147e-03f, -1.71360582e-01f,
  3.65886278e-02f, -8.89291335e-03f, -3.42265815e-02f, 4.49236445e-02f, -1.45111997e-02f, 4.09960467e-03f, 6.86390400e-02f, -1.82804465e-02f, 4.71084043e-02f, 2.32206378e-02f,
  6.73806891e-02f, 4.93635423e-02f, 6.69530965e-03f, 1.70303565e-02f, -3.22134160e-02f, -3.06720678e-02f, -5.31351417e-02f, -3.72286551e-02f, 9.38134175e-03f, -3.29775400e-02f,
  -4.63642441e-02f, -3.41746472e-02f, 6.85406998e-02f, -1.07520139e-02f, -3.12549174e-02f, -1.06051512e-01f, 2.31814217e-02f, 1.73359010e-02f, -9.74596441e-02f, -2.81359106e-02f,
  4.93214637e-01f, -2.65987366e-01f, 2.22790554e-01f, 2.20963955e-01f, 4.49941188e-01f, 3.38004082e-01f, 6.01907253e-01f, 1.63606927e-01f, 5.20201325e-01f, -2.80419558e-01f,
  -1.65170431e-01f, 4.57145125e-02f, 8.36760178e-02f, -1.85717076e-01f, 4.91515934e-01f, 1.01578347e-01f, 1.86850667e-01f, 7.51560777e-02f, 2.14365602e-01f, -3.30472738e-03f,
  1.00940153e-01f, -2.14927509e-01f, -1.32616073e-01f, -3.74640435e-01f, -1.87977180e-01f, -1.61450773e-01f, -2.66514719e-01f, 2.10372180e-01f, -3.37178648e-01f, 1.79848775e-01f,
  -9.30685550e-02f, -9.84120220e-02f, -2.18702018e-01f, -7.37346038e-02f, -1.12685733e-01f, -5.87619804e-02f, 1.19273730e-01f, 9.16900188e-02f, 1.20107196e-02f, -9.26664397e-02f,
  3.74305472e-02f, -2.94963960e-02f, -6.32630140e-02f, 6.00167830e-03f, 6.39183447e-02f, -2.64368393e-02f, -3.03023271e-02f, -2.15647414e-01f, -1.39049301e-02f, -5.07852109e-03f,
  -9.90667939e-02f, -1.53707057e-01f, -1.30539343e-01f, -5.66610461e-03f, -4.55096550e-02f, 5.19759655e-02f, 2.74392050e-02f, -8.35620090e-02f, -4.40151617e-02f, 8.39842930e-02f,
  6.93099573e-02f, 8.22913423e-02f, 1.77678596e-02f, -9.06200856e-02f, 6.90912381e-02f, -7.34818056e-02f, -4.40087058e-02f, -3.54638509e-02f, 9.04182345e-03f, 6.80873170e-02f,
  7.78139830e-02f, -2.94150226e-03f, 7.11170398e-03f, 1.06472403e-01f, -1.05531551e-02f, 2.36236695e-02f, 2.35042535e-02f, 5.54150715e-03f, 8.40118155e-03f, -6.69048354e-02f,
  5.38179763e-02f, 1.03397913e-01f, -1.21493131e-01f, 1.80721935e-02f, 6.51757866e-02f, -7.91133009e-03f, -4.49092314e-02f, -7.13366717e-02f, -2.11429782e-02f, 6.77327588e-02f,
  1.53411821e-01f, 1.17225707e-01f, -1.21508926e-01f, -1.88466311e-01f, -2.33756416e-02f, -1.77157238e-01f, 1.00878380e-01f, -5.67608587e-02f, 1.02092594e-01f, 4.49960642e-02f,
  -3.47735807e-02f, -4.03575134e-03f, 7.13087842e-02f, -6.14324845e-02f, -4.94666621e-02f, -2.21360326e-02f, 9.32151750e-02f, -1.70820337e-02f, -2.42901873e-02f, -1.44147694e-01f,
  -9.01148841e-02f, 4.61871689e-03f, -4.35424820e-02f, 1.77333206e-02f, -1.14203557e-01f, -1.48084583e-02f, 1.58164301e-03f, 6.39140233e-02f, 3.76474522e-02f, 5.88470586e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.42229748e-01f, 4.41762149e-01f, 3.84444773e-01f, 4.92605269e-01f, 3.58017087e-01f, 5.24875700e-01f, 2.24375397e-01f, 3.52959812e-01f, 4.83451158e-01f, 4.73991394e-01f,
  3.97639513e-01f, 4.04498786e-01f, 3.83933753e-01f, 5.08019626e-01f, 4.95790184e-01f, 5.01440406e-01f, 1.68911114e-01f, 1.94818050e-01f, 4.47041929e-01f, 3.92282307e-01f,
  2.43296534e-01f, 5.07157683e-01f, 3.25572401e-01f, 4.79001790e-01f, 5.02168834e-01f, 3.09087157e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  2.90177286e-01f, 4.24031578e-02f, -9.05670226e-04f, -2.99936891e-01f, 1.23110235e-01f, 1.68589398e-01f, -1.01922534e-01f, 2.34439746e-01f, -7.19324276e-02f, -2.51189470e-01f,
  -1.53562631e-02f, 3.21002036e-01f, -1.57922238e-01f, 5.45461848e-02f, 2.12315559e-01f, -3.02107502e-02f, -1.06400913e-02f, -1.95455089e-01f, 1.02475643e-01f, -9.22541134e-03f,
  -8.73591304e-02f, -2.55964160e-01f, 4.48268130e-02f, -1.25395626e-01f, 9.80151221e-02f, 9.55469236e-02f, -1.93503901e-01f, -6.02810085e-02f, 3.77463728e-01f, -8.05783719e-02f,
  1.85207903e-01f, 2.41881639e-01f, 1.66293606e-01f, 3.79209042e-01f, -1.03219874e-01f, 2.43066892e-01f, -4.86199670e-02f, -3.54326785e-01f, 4.93209139e-02f, -8.93468037e-02f,
  -1.42119199e-01f, -2.07182497e-01f, 2.58496433e-01f, 9.36662108e-02f, 1.66755125e-01f, -2.04807475e-01f, 7.86654577e-02f, -1.03251085e-01f, -8.79322067e-02f, -1.14717953e-01f,
  2.43247807e-01f, -1.95830539e-01f, -4.49544080e-02f, 1.39249191e-01f, 2.61110604e-01f, 1.40509710e-01f, 2.67363548e-01f, -2.47921526e-01f, -3.83198671e-02f, 1.62285313e-01f,
  1.35797739e-01f, -1.05806939e-01f, 2.31778041e-01f, 1.54085785e-01f, 1.42873913e-01f, 1.34992242e-01f, 8.05862099e-02f, -1.30009741e-01f, -2.39191920e-01f, 2.10141256e-01f,
  1.73462778e-01f, 3.61608081e-02f, -2.84289688e-01f, -3.44210237e-01f, 1.23031668e-01f, 6.51873127e-02f, -6.43129721e-02f, 1.58500776e-01f, -1.17880076e-01f, 2.90548652e-01f,
  -1.32060930e-01f, -2.25274161e-01f, 2.55513847e-01f, 4.92875790e-03f, -1.97206214e-01f, -7.40142316e-02f, -1.40620336e-01f, -1.30045325e-01f, -8.69259462e-02f, 6.48452938e-02f,
  -3.01721603e-01f, 4.69646975e-02f, -4.43800315e-02f, 2.17229277e-01f, 3.76360565e-01f, 1.22689746e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -8.74201357e-02f, 2.66917795e-01f, 3.12947720e-01f, 2.08071634e-01f, -2.18024433e-01f, 6.64434016e-01f, 5.94146729e-01f, 1.51631951e-01f, 2.64117241e-01f, 2.28381991e-01f,
  4.48848456e-01f, 3.79440427e-01f, -6.20576918e-01f, 4.77404773e-01f, -2.26652995e-01f, 7.29957700e-01f, 4.25604731e-01f, -1.74458832e-01f, -4.17142570e-01f, 2.97442582e-02f,
  4.06087190e-01f, 3.99585553e-02f, -1.04136080e-01f, -5.33609450e-01f, -2.27120608e-01f, 4.50846612e-01f, -3.44945192e-01f, -2.27566957e-01f, -3.19001615e-01f, 2.37089097e-01f,
  -4.49708670e-01f, -4.00898010e-01f, -3.70594789e-03f, -2.57812232e-01f, 2.15032130e-01f, -2.94407815e-01f, -1.15106955e-01f, 4.18510377e-01f, 1.15916237e-01f, 5.87094188e-01f,
  5.03923237e-01f, 4.54979300e-01f, 7.84439594e-02f, 3.83348972e-01f, 3.37254316e-01f, 3.84308577e-01f, -1.30612075e-01f, 1.93343624e-01f, 1.71647891e-01f, -1.70689449e-01f,
  -1.68337896e-01f, 3.50500941e-02f, 8.96738395e-02f, -5.19450068e-01f, 4.31379005e-02f, -2.54460331e-02f, -3.44262123e-01f, 6.89440906e-01f, 2.92227060e-01f, 3.75534445e-02f,
  2.75132824e-02f, 3.65333229e-01f, -4.95617604e-03f, -2.29762048e-01f, -4.78258491e-01f, -4.10161972e-01f, 2.70857185e-01f, -5.47048986e-01f, 5.06236076e-01f, 2.14784220e-01f,
  2.10870281e-01f, 1.28138289e-01f, 4.50372815e-01f, 1.73543960e-01f, 8.12661424e-02f, -1.88496649e-01f, 2.14405477e-01f, 5.20522952e-01f, -3.97650987e-01f, 1.59105435e-01f,
  3.56819808e-01f, 3.43251348e-01f, 4.36996967e-01f, 5.14340736e-02f, -3.02911937e-01f, -5.78897595e-02f, -7.64848515e-02f, 3.94221336e-01f, -2.35802770e-01f, 2.29104504e-01f,
  -8.90482068e-02f, 1.62836388e-01f, 2.08587423e-02f, -6.73890635e-02f, 1.23327009e-01f, -6.39152825e-02f, 3.60877484e-01f, 4.59726453e-01f, 1.19844228e-01f, 4.65154618e-01f,
  -1.04904354e-01f, -1.08168423e-02f, 3.46356452e-01f, 7.45913833e-02f, -2.87832260e-01f, 5.70261359e-01f, 2.18015715e-01f, -3.57592814e-02f, 4.41807866e-01f, -4.44269806e-01f,
  -3.35003823e-01f, 6.16018884e-02f, -1.65909335e-01f, 6.25767931e-02f, -1.45982176e-01f, 5.82959831e-01f, 1.43285275e-01f, 4.48735744e-01f, -2.47371227e-01f, 2.26600002e-02f,
  4.35874373e-01f, 2.65960008e-01f, 4.78062183e-01f, 3.61479074e-01f, -1.02531411e-01f, 3.22145551e-01f, 1.05062298e-01f, -2.12792009e-01f, 5.64301871e-02f, 8.77304822e-02f,
  -4.00989950e-01f, 5.42168975e-01f, -4.46911067e-01f, -1.99149534e-01f, 4.10414249e-01f, 3.01341802e-01f, 2.23004371e-01f, -2.59887218e-01f, 4.78534818e-01f, 5.74038804e-01f,
  7.46227577e-02f, -3.92541051e-01f, 4.72368635e-02f, 1.16712116e-02f, 3.88127804e-01f, 1.57614186e-01f, -1.92180574e-01f, -3.73020113e-01f, 8.16191733e-02f, 4.97035891e-01f,
  1.72510967e-01f, 1.60730392e-01f, 4.16678399e-01f, 2.34332636e-01f, 4.40337732e-02f, 3.74486744e-01f, -2.08516256e-03f, -3.68515472e-03f, -2.22222880e-01f, -4.00225818e-02f,
  2.05854937e-01f, 2.97456592e-01f, 6.76851347e-02f, 4.09620106e-01f, 4.22605276e-02f, -5.89476041e-02f, 5.72710991e-01f, 7.22400323e-02f, 1.03239618e-01f, 7.38359168e-02f,
  2.35002860e-01f, 2.11403072e-01f, 3.24846208e-01f, -3.16829830e-01f, 3.51289511e-01f, -2.56020218e-01f, -1.33546889e-01f, 8.49971399e-02f, -9.37734731e-03f, 6.47105053e-02f,
  7.18197646e-03f, 3.97710949e-01f, 1.10465661e-01f, 2.81296462e-01f, 4.12263989e-01f, 2.97740847e-01f, 3.74675125e-01f, 1.41880691e-01f, 2.15598196e-01f, -4.56173241e-01f,
  2.28920653e-01f, -3.66326943e-02f, 1.97509304e-01f, 1.37685418e-01f, -1.86356887e-01f, -2.07957655e-01f, 4.38178815e-02f, -4.83552635e-01f, -5.27877033e-01f, 4.83367026e-01f,
  2.40335055e-02f, -2.62766302e-01f, 5.33854127e-01f, 3.86480600e-01f, 5.35106778e-01f, -2.14913741e-01f, 2.53376216e-01f, -1.61058500e-01f, 5.86702712e-02f, 1.27829969e-01f,
  6.27706409e-01f, -1.29427448e-01f, 6.23141117e-02f, -1.41225800e-01f, 4.62097704e-01f, 4.84907091e-01f, -1.84363325e-03f, -2.48423487e-01f, 4.98762429e-01f, 5.10422051e-01f,
  -3.86733338e-02f, 2.66300440e-01f, 3.60593826e-01f, 5.14551163e-01f, -1.23062156e-01f, 1.82593897e-01f, 3.06830227e-01f, -3.35971415e-01f, 5.85919142e-01f, -3.97056907e-01f,
  -3.76872152e-01f, 1.17233284e-01f, 5.52780211e-01f, 1.60815597e-01f, 9.65221599e-02f, -2.97891378e-01f, 1.94047868e-01f, 3.05579722e-01f, 5.29687583e-01f, -2.84065336e-01f,
  3.08683783e-01f, 4.39868808e-01f, 4.29501623e-01f, -4.28003907e-01f, -4.48983163e-01f, -1.28088789e-02f, 1.04219198e-01f, 4.88421798e-01f, -3.55257213e-01f, 1.35566697e-01f,
  6.45402223e-02f, 1.98862746e-01f, -5.44697903e-02f, -2.56262541e-01f, 1.48658946e-01f, 2.27522612e-01f, 4.75591063e-01f, 3.04855049e-01f, 4.80525583e-01f, -7.70051107e-02f,
  4.26713407e-01f, 1.47027269e-01f, 5.49802959e-01f, -1.94932848e-01f, 3.28193247e-01f, 1.01913273e-01f, -1.47392720e-01f, 2.38095328e-01f, -1.80251464e-01f, 4.20616388e-01f,
  6.63723290e-01f, 4.64232504e-01f, 4.97536331e-01f, -1.44420609e-01f, -2.91592479e-01f, -6.87097833e-02f, -5.43761216e-02f, 5.60449297e-03f, 2.32514843e-01f, -1.01609528e-01f,
  8.05194601e-02f, 3.78923118e-01f, -8.56539011e-02f, -3.69181782e-01f, 1.89761743e-01f, -9.89504158e-02f, 7.09640980e-02f, 4.10079151e-01f, 2.37248734e-01f, 2.76652455e-01f,
  1.78384587e-01f, 4.66914922e-01f, -1.79007322e-01f, -3.03233266e-01f, -2.46303529e-01f, -5.57048976e-01f, 8.62512141e-02f, -8.40024743e-03f, 1.70775771e-01f, 2.51544863e-01f,
  -3.45303535e-01f, -2.88425773e-01f, 5.41024685e-01f, 4.24301237e-01f, 5.99723816e-01f, 3.19582134e-01f, 1.47080999e-02f, 2.53459364e-01f, 2.59113222e-01f, 5.58727860e-01f,
  2.93920726e-01f, -1.57173961e-01f, 5.65274768e-02f, 2.82371819e-01f, 1.79857731e-01f, -1.05160624e-01f, -6.51890412e-02f, 3.92724574e-01f, 7.55995959e-02f, 1.48200113e-02f,
  -2.83364177e-01f, 5.23330830e-02f, 3.53033930e-01f, -2.18669116e-01f, 2.02951178e-01f, 1.26209199e-01f, -7.00283498e-02f, 2.41649538e-01f, 3.63062024e-01f, 7.07673252e-01f,
  -2.02007785e-01f, -3.21465522e-01f, 3.01070958e-01f, 4.49400753e-01f, -3.27576511e-02f, 3.54805559e-01f, -8.19398463e-03f, 4.26220715e-01f, -4.69231494e-02f, 4.84824181e-01f,
  6.19910240e-01f, -3.33660364e-01f, 4.44666028e-01f, 5.39283574e-01f, -1.44130930e-01f, 6.02884352e-01f, 2.73924053e-01f, 9.29923262e-03f, -3.96738648e-01f, 2.22473606e-01f,
  2.23367378e-01f, -2.90142775e-01f, -1.45471692e-01f, -1.15818188e-01f, 2.44616583e-01f, -5.19988418e-01f, 2.98597097e-01f, 3.14061761e-01f, 5.48945248e-01f, 5.78764856e-01f,
  3.62947732e-01f, -5.74365035e-02f, 5.11149883e-01f, 3.01761180e-01f, 7.96636790e-02f, 3.18141878e-01f, 7.44653940e-02f, 4.63991612e-01f, 6.32734373e-02f, -1.19040972e-02f,
  6.09093197e-02f, -3.59134972e-01f, -1.42904162e-01f, -4.14563745e-01f, 2.87206113e-01f, 2.94258147e-01f, -1.50911376e-01f, 5.04839718e-01f, 5.43411002e-02f, -1.49235912e-02f,
  -8.46723914e-02f, -2.83728421e-01f, 5.16020536e-01f, 5.43978870e-01f, 3.18457991e-01f, 3.96741539e-01f, 1.14082970e-01f, -1.44841060e-01f, 4.51852471e-01f, -5.74709892e-01f,
  -5.13750374e-01f, -8.93522892e-03f, 3.08769375e-01f, 6.42549455e-01f, 3.02489907e-01f, -8.85957927e-02f, 5.50655127e-01f, 6.47472665e-02f, 3.38013768e-01f, -1.66684553e-01f,
  1.04990997e-03f, 5.39196253e-01f, 2.90817946e-01f, -6.75318092e-02f, 6.89246282e-02f, -2.20175982e-01f, 3.16217095e-01f, 3.88462842e-01f, -7.01224133e-02f, 2.08423063e-01f,
  5.88052392e-01f, 1.60131529e-01f, -2.92808384e-01f, 2.72838343e-02f, 3.18027973e-01f, -1.02451220e-01f, 4.53187972e-01f, 2.05723524e-01f, 1.03309918e-02f, 3.34337443e-01f,
  -2.46370554e-01f, -2.56574124e-01f, -2.08965093e-01f, -1.35466799e-01f, -3.23159456e-01f, 2.48361006e-01f, -1.19687043e-01f, 1.23812042e-01f, 1.11368805e-01f, -1.51182562e-01f,
  4.57659751e-01f, -6.57826141e-02f, -3.95138681e-01f, 1.58755779e-01f, 3.90229642e-01f, 5.55913866e-01f, 5.70690572e-01f, 3.14958066e-01f, 4.75925177e-01f, 1.38793513e-01f,
  5.03686965e-01f, 1.14028536e-01f, 4.67320412e-01f, 2.11828187e-01f, -5.71361147e-02f, 1.30840629e-01f, 4.40837890e-01f, -2.00610206e-01f, -1.44836493e-02f, -9.84938741e-02f,
  -9.04906169e-02f, 5.31141907e-02f, 1.12136088e-01f, 5.74073046e-02f, 5.85992098e-01f, 3.31674159e-01f, -2.34078750e-01f, -5.99887013e-01f, -8.65745544e-02f, 6.17147535e-02f,
  2.37095207e-01f, 8.62513557e-02f, 1.22066781e-01f, 2.05587626e-01f, 3.71381164e-01f, 1.99132562e-01f, -1.69641316e-01f, -1.19926840e-01f, 3.35704505e-01f, 3.18050712e-01f,
  4.83331680e-01f, 3.59109789e-01f, 3.39749753e-01f, -2.10443452e-01f, -2.59656787e-01f, -1.34740174e-01f, 6.06320381e-01f, -2.35174119e-01f, 3.63522142e-01f, 7.26976693e-01f,
  -1.13151565e-01f, -2.46452838e-01f, 5.08766510e-02f, -5.96500486e-02f, -2.72886962e-01f, 2.71971256e-01f, -4.21772957e-01f, 1.87865496e-02f, 6.54368997e-02f, 1.78691611e-01f,
  -1.60631448e-01f, 2.16436431e-01f, 2.88906336e-01f, -2.56418377e-01f, 1.48443133e-01f, 1.01432782e-02f, 5.10595500e-01f, 5.68870246e-01f, 2.46592894e-01f, 5.09986579e-01f,
  4.50776964e-01f, 2.66242206e-01f, 1.65966880e-02f, -3.97857949e-02f, -2.99518760e-02f, -4.17555183e-01f, 1.98927060e-01f, 1.71980143e-01f, 2.96635330e-01f, 7.13715494e-01f,
  -3.54894817e-01f, 1.70341264e-02f, 7.28076696e-01f, 3.93260270e-01f, 2.41233900e-01f, 5.41083455e-01f, 5.85426129e-02f, -1.34846672e-01f, 3.09747402e-02f, -5.36538541e-01f,
  3.52099597e-01f, 4.11453754e-01f, -1.46816164e-01f, 1.37338281e-01f, -3.94243509e-01f, -3.12805533e-01f, 4.93867397e-01f, 1.89178675e-01f, 5.16803443e-01f, -1.50029689e-01f,
  -5.50739169e-01f, -1.01031296e-01f, 2.62263149e-01f, 2.47135282e-01f, 2.81819701e-03f, -2.22773552e-01f, 1.58477053e-01f, 2.93929279e-01f, -5.09567000e-02f, -2.44423494e-01f,
  3.85667741e-01f, -1.26601588e-02f, 1.76900223e-01f, 2.49395818e-01f, 3.97749543e-01f, 4.61348742e-01f, 1.90062031e-01f, 4.07981068e-01f, -3.12926143e-01f, 2.60508712e-02f,
  1.43987179e-01f, -2.95568377e-01f, -2.31278818e-02f, 1.65618762e-01f, 3.71617317e-01f, 1.78258732e-01f, -3.74403410e-02f, -4.01983410e-01f, 1.50735974e-01f, 3.40229988e-01f,
  8.71378407e-02f, -1.18856229e-01f, 1.80563226e-01f, 3.36692095e-01f, 1.06932372e-01f, 5.28826654e-01f, -4.02885258e-01f, -2.41756424e-01f, 4.47383314e-01f, 4.32884246e-01f,
  4.51118618e-01f, 4.00960326e-01f, -2.02845424e-01f, 4.21995997e-01f, 2.72711337e-01f, -3.55049551e-01f, 2.90216893e-01f, 2.57105559e-01f, -6.73226714e-02f, 3.66086543e-01f,
  1.06664160e-02f, -4.40389544e-01f, 2.52142139e-02f, 2.02814251e-01f, -1.82918385e-01f, 1.61204025e-01f, -1.29311875e-01f, 3.78634423e-01f, 3.98383796e-01f, -3.39919388e-01f,
  5.77214658e-01f, -4.39358979e-01f, 1.39936253e-01f, 1.55636564e-01f, -3.38601619e-01f, -2.12734669e-01f, 2.60914326e-01f, -1.33210253e-02f, 2.86489397e-01f, 9.21961889e-02f,
  4.58902031e-01f, 2.37138703e-01f, 4.35443759e-01f, -4.47330810e-03f, 4.35721904e-01f, -3.89828563e-01f, -5.40410243e-02f, 4.06744957e-01f, 2.50579864e-01f, -1.79425597e-01f,
  1.33593693e-01f, -4.44494992e-01f, 2.11128071e-02f, -2.37564445e-01f, -4.46667671e-01f, 2.45129675e-01f, 6.73681617e-01f, 3.33500743e-01f, 3.85395110e-01f, 7.81338587e-02f,
  3.21862608e-01f, -1.22796349e-01f, 2.89471477e-01f, -4.20255840e-01f, 2.37989590e-01f, 4.69120368e-02f, 1.75703987e-01f, 5.94032258e-02f, -2.10119128e-01f, -2.31725454e-01f,
  -4.78718877e-01f, 7.29437321e-02f, 1.75482824e-01f, 5.23677468e-01f, 5.94998777e-01f, 4.71264392e-01f, -1.82532236e-01f, 1.82920456e-01f, 3.61090004e-02f, -6.10317171e-01f,
  -4.24438417e-02f, 2.34012291e-01f, 2.16165558e-01f, 9.89842415e-02f, -3.75290602e-01f, 1.68580711e-01f, 5.41100740e-01f, 6.27634466e-01f, -3.07470500e-01f, -1.44411236e-01f,
  3.70722502e-01f, 1.34558305e-01f, -3.29586744e-01f, 1.35793835e-01f, 4.09646034e-02f, 2.84525931e-01f, -4.64660317e-01f, -2.12207973e-01f, 5.91465771e-01f, 3.64677042e-01f,
  -1.80895314e-01f, 4.41574574e-01f, -3.90659235e-02f, -3.03093761e-01f, 5.51939428e-01f, -1.81350321e-01f, -2.59809554e-01f, 4.49921191e-01f, 4.43953931e-01f, 4.63414818e-01f,
  5.02901256e-01f, 2.07192764e-01f, 4.75251377e-01f, 2.39350110e-01f, 3.58360589e-01f, -1.04619205e-01f, 5.13027608e-01f, -6.11630559e-01f, -1.21219799e-01f, 2.38305137e-01f,
  1.53438017e-01f, 4.43004012e-01f, 1.77291587e-01f, -4.88855205e-02f, 4.44882512e-01f, 6.89878762e-02f, 5.52594708e-03f, -6.06743038e-01f, -3.31177115e-01f, 7.76632279e-02f,
  4.76741523e-01f, 2.30571494e-01f, 2.68417764e-02f, -1.08666763e-01f, -1.07908100e-01f, 1.03539534e-01f, 2.65906960e-01f, 2.62067467e-01f, 2.25229502e-01f, 4.27302361e-01f,
  1.94664940e-01f, -2.16236040e-01f, 5.65364540e-01f, 2.65362144e-01f, -1.97353810e-01f, -2.65502363e-01f, 2.26101637e-01f, -5.95960200e-01f, 1.62652135e-01f, 3.40485811e-01f,
  2.36089796e-01f, 6.83651194e-02f, 2.49114260e-01f, -2.25868836e-01f, 3.13578248e-01f, 5.26777022e-02f, -2.33873099e-01f, 3.79534930e-01f, -1.47198156e-01f, 5.82066059e-01f,
  2.72744238e-01f, 1.64790720e-01f, 2.99251139e-01f, 2.67903388e-01f, -2.11440548e-02f, -7.52284080e-02f, 2.21530452e-01f, -6.18764684e-02f, -2.78812796e-01f, 1.44770339e-01f,
  -2.05759868e-01f, -5.03292866e-03f, -1.44343272e-01f, 3.87961566e-01f, 2.40906179e-01f, -6.89815953e-02f, -1.67216703e-01f, 3.13608535e-02f, -1.01221599e-01f, 2.89907187e-01f,
  -2.73781508e-01f, 2.43750900e-01f, -2.85749614e-01f, -6.73353299e-03f, 4.47051167e-01f, 2.41474003e-01f, 2.08814472e-01f, 1.17238820e-01f, 2.44651765e-01f, -2.20232919e-01f,
  2.16255635e-01f, 3.34292799e-01f, 6.09295428e-01f, 7.04252124e-01f, -2.96458721e-01f, 1.35802060e-01f, 4.16653156e-01f, 4.47014868e-01f, 2.58852273e-01f, 4.59971935e-01f,
  -4.87032011e-02f, -3.23328674e-01f, -5.97331561e-02f, -1.02508880e-01f, 2.36006007e-01f, 4.14481461e-01f, -4.96204764e-01f, 1.03560969e-01f, 6.44321740e-02f, 3.80009525e-02f,
  2.84920841e-01f, -4.58623379e-01f, 3.84616673e-01f, 6.66530356e-02f, 4.60514337e-01f, 2.55536973e-01f, 4.83842611e-01f, -2.96073109e-02f, -5.02364159e-01f, 8.56440961e-02f,
  -9.53895226e-02f, 6.14600599e-01f, 6.14559293e-01f, 1.76087637e-02f, 6.88624233e-02f, 2.13966221e-01f, -1.87725425e-01f, -2.91563392e-01f, 9.57136750e-02f, -2.13200346e-01f,
  1.75502911e-01f, 3.03357989e-01f, 3.10523093e-01f, 3.45481545e-01f, -1.43216595e-01f, -2.78299868e-01f, 5.19589543e-01f, -1.89357445e-01f, 8.45311135e-02f, 1.88739866e-01f,
  3.60006869e-01f, 3.70994985e-01f, 4.54921555e-03f, -3.23108196e-01f, 1.84633449e-01f, -1.44560086e-02f, 9.80761796e-02f, 3.49954337e-01f, -2.14147314e-01f, -5.74914336e-01f,
  4.69976366e-01f, 5.43210566e-01f, 2.40294859e-01f, 2.61777770e-02f, 3.16140890e-01f, 1.92239895e-01f, 5.25262237e-01f, -1.28018362e-02f, 5.71695268e-01f, -1.41042486e-01f,
  -1.92203835e-01f, 4.58916098e-01f, 4.92932528e-01f, 1.35206103e-01f, 2.97845513e-01f, -2.03559354e-01f, 4.33338769e-02f, 4.16613340e-01f, 3.60189348e-01f, 5.33171222e-02f,
  5.33284545e-01f, 6.20516896e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  2.05391422e-01f, 8.71560052e-02f, 2.13943660e-01f, 3.16436619e-01f, -2.17771400e-02f, -9.70600545e-02f, 1.27418593e-01f, 1.07710481e-01f, 1.99477121e-01f, 1.62939560e-02f,
  3.18143874e-01f, 3.56783748e-01f, 3.61786753e-01f, 1.76424179e-02f, 1.00667559e-01f, 1.25141174e-01f, 2.92543381e-01f, 9.22002718e-02f, 2.72866368e-01f, 1.92574248e-01f,
  7.73784891e-02f, 1.00039639e-01f, 2.08789915e-01f, 1.00105256e-01f, 2.36709461e-01f, 3.41049433e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  1.43889308e-01f, -2.53537744e-01f, -1.54348668e-02f, -2.29622405e-02f, -2.70555347e-01f, -6.11017287e-01f, -1.21283129e-01f, 1.95069075e-01f, 4.09356922e-01f, -3.14349085e-01f,
  -5.31701684e-01f, -2.35222131e-02f, -6.24523640e-01f, 4.88952041e-01f, 3.98102514e-02f, -6.05352938e-01f, 4.48276162e-01f, 1.47986516e-01f, 2.07497299e-01f, -5.94722569e-01f,
  -6.91686809e-01f, -2.53859520e-01f, -5.74518085e-01f, -6.67706966e-01f, -4.71049160e-01f, 3.52583170e-01f, -4.52798605e-01f, 7.92329237e-02f, 5.23250103e-02f, -3.33113298e-02f,
  3.82329464e-01f, -8.51479292e-01f, 1.80665124e-02f, 1.02826111e-01f, -8.45369920e-02f, 5.14882624e-01f, -5.49477637e-01f, 3.72805208e-01f, 3.23633581e-01f, 4.05066699e-01f,
  1.40888944e-01f, -6.53281808e-01f, -4.90665138e-01f, -4.04587626e-01f, -6.50418699e-01f, -4.36435133e-01f, 4.15722072e-01f, -1.70552820e-01f, 2.74121642e-01f, 2.97505587e-01f,
  -8.23331296e-01f, -3.30695510e-02f, 1.07469872e-01f, 7.05937520e-02f, -4.89615440e-01f, -3.96858811e-01f, -3.10282707e-01f, -4.60423857e-01f, 4.03177701e-02f, -6.28053308e-01f,
  3.14448148e-01f, -2.12871060e-01f, 4.27049547e-01f, -6.68564215e-02f, 2.32759342e-01f, 5.64948693e-02f, -1.14939921e-01f, -8.24358463e-02f, 3.73674721e-01f, 2.77108759e-01f,
  2.90928006e-01f, -3.70482177e-01f, -1.36124671e-01f, 2.71119148e-01f, 3.44719529e-01f, 2.87232935e-01f, -7.06893623e-01f, -3.66953433e-01f, 2.75852889e-01f, 2.14873180e-01f,
  -6.36670232e-01f, 1.53564021e-01f, -4.52148020e-01f, -5.14839768e-01f, -3.18371318e-02f, -5.89536786e-01f, 9.76624191e-02f, 3.81991029e-01f, -2.82075554e-01f, -5.97781718e-01f,
  -2.72161383e-02f, -6.24091029e-01f, 6.47408236e-03f, 5.62654845e-02f, -4.13432837e-01f, 1.20623447e-01f, -3.57383937e-01f, 5.09742983e-02f, -3.56370896e-01f, -1.56245992e-01f,
  -3.08031887e-01f, -2.29022205e-01f, -8.70233476e-01f, 1.18809894e-01f, -1.28547639e-01f, 4.84515458e-01f, -5.27320206e-01f, -6.00598603e-02f, 9.11680013e-02f, -5.79023719e-01f,
  -8.67026627e-01f, -2.12461114e-01f, 2.64413178e-01f, -7.82419801e-01f, 2.87088126e-01f, 2.36088380e-01f, -3.98863822e-01f, 3.87036890e-01f, -4.41853076e-01f, -2.54634693e-02f,
  1.73325509e-01f, 4.29722607e-01f, -5.18852413e-01f, 3.70755285e-01f, -3.24640930e-01f, 1.06244609e-01f, -5.66787899e-01f, -6.82165504e-01f, 3.13402772e-01f, 2.40799300e-02f,
  -5.23050800e-02f, 1.52617991e-01f, 1.47204474e-01f, -3.65474224e-01f, -2.01690607e-02f, 3.23903747e-02f, -5.82344890e-01f, -6.66385964e-02f, 5.14811017e-02f, 1.39416352e-01f,
  1.60592142e-02f, 9.34623033e-02f, 2.43347183e-01f, 1.17938444e-01f, 4.71795201e-02f, -9.07223970e-02f, 3.74715447e-01f, 2.27368206e-01f, -5.07633448e-01f, -5.59140980e-01f,
  3.89203042e-01f, 9.52344239e-02f, 3.94594342e-01f, 4.42412227e-01f, -5.26564598e-01f, 2.58382678e-01f, -3.76029402e-01f, -4.25059766e-01f, 2.27308460e-02f, -2.28220731e-01f,
  -5.06679527e-02f, 3.25220197e-01f, 7.89247900e-02f, 2.71671206e-01f, 6.40257716e-01f, 2.59304017e-01f, -7.20946014e-01f, -1.67490095e-01f, 2.19933867e-01f, -5.80857694e-01f,
  -6.00270867e-01f, -2.38663211e-01f, 4.28785443e-01f, 4.52582121e-01f, 2.61245370e-02f, -4.92964089e-01f, -3.35257724e-02f, 3.62266362e-01f, 2.97095537e-01f, -2.79788256e-01f,
  5.58102317e-02f, -4.14059728e-01f, -4.88328040e-01f, -5.76170087e-01f, -1.91647276e-01f, -2.25371346e-01f, -1.20788597e-01f, 3.78628075e-01f, 8.99791345e-02f, -6.37263298e-01f,
  1.55497864e-02f, 4.38732803e-01f, -5.93471304e-02f, -2.18507007e-01f, 1.36142030e-01f, 3.85328904e-02f, -1.68767339e-03f, 2.59152055e-01f, -5.03902972e-01f, -6.01736844e-01f,
  -5.73420942e-01f, 2.00542152e-01f, 1.08549349e-01f, 3.96070123e-01f, -1.12581685e-01f, -4.48250294e-01f, 1.50844548e-03f, -4.77457404e-01f, -5.68745255e-01f, 3.09467334e-02f,
  -5.12427509e-01f, 1.73792914e-01f, 2.85700828e-01f, -5.66382289e-01f, -7.27482587e-02f, -1.13281608e-01f, 3.22887063e-01f, -5.99451482e-01f, 5.96480608e-01f, 1.88517079e-01f,
  -3.76021862e-01f, -5.96179605e-01f, 1.90909982e-01f, 1.76091507e-01f, -1.74955174e-01f, -2.77973533e-01f, -2.10072011e-01f, -3.00270826e-01f, 2.75532037e-01f, -1.14044420e-01f,
  -4.24057126e-01f, -3.22069347e-01f, -4.39081699e-01f, -3.04100782e-01f, 3.61941010e-01f, -1.08662723e-02f, 4.43785042e-01f, -1.81246817e-01f, -5.26666701e-01f, 1.52397575e-02f,
  3.14126432e-01f, -2.09324181e-01f, 2.87451744e-01f, 2.77620077e-01f, 4.04771417e-01f, 1.16695717e-01f, -7.98568010e-01f, -5.15612543e-01f, 2.34155178e-01f, -4.58349913e-01f,
  -3.20184350e-01f, -4.64712232e-01f, -1.01404788e-03f, 4.72896695e-01f, -2.44487435e-01f, 4.34666239e-02f, -1.96495384e-01f, 4.73699160e-02f, -1.27714708e-01f, 2.64641106e-01f,
  -3.52557302e-02f, 2.50343680e-01f, 5.05705737e-02f, 3.66788238e-01f, -2.55996317e-01f, -3.62286836e-01f, 3.94833177e-01f, -4.89006966e-01f, 4.41657484e-01f, -2.71545321e-01f,
  -4.86419827e-01f, -8.05365816e-02f, -4.16217715e-01f, 1.30011648e-01f, -3.94171655e-01f, -4.25971478e-01f, -5.47297120e-01f, 3.74787331e-01f, -4.63684350e-01f, -4.95935567e-02f,
  -2.38831684e-01f, 4.66363937e-01f, 1.96637347e-01f, -5.05034685e-01f, 4.38342392e-02f, 3.61897200e-01f, -4.40522820e-01f, 2.52291292e-01f, -2.06191048e-01f, -1.71321407e-01f,
  1.85342193e-01f, 4.15191859e-01f, 3.29937994e-01f, -5.46211481e-01f, -5.98322034e-01f, -8.12647939e-01f, -3.67766589e-01f, -7.64005601e-01f, -1.02864079e-01f, -6.84093237e-02f,
  -1.18383812e-02f, 1.55802622e-01f, 3.70663971e-01f, 3.22444856e-01f, -6.99115276e-01f, -2.35296965e-01f, -1.12035222e-01f, -1.55387342e-01f, 2.28822634e-01f, 3.00592512e-01f,
  4.56322074e-01f, -4.35135394e-01f, 2.93441206e-01f, -3.23884428e-01f, -3.50578219e-01f, -2.00103015e-01f, -2.35880315e-01f, 4.55082983e-01f, 3.34986955e-01f, 1.97022840e-01f,
  6.17045686e-02f, 1.45110860e-01f, 1.18305191e-01f, -4.54611361e-01f, -3.17538828e-01f, -4.11642622e-03f, 4.83791947e-01f, -3.19725983e-02f, -6.65801883e-01f, 2.78970540e-01f,
  -5.36299825e-01f, -6.06870055e-01f, -7.53438830e-01f, -3.93761456e-01f, -1.97325647e-02f, 2.30312988e-01f, 4.19560134e-01f, -3.63071293e-01f, -5.31031303e-02f, 1.78888917e-01f,
  -3.15016180e-01f, 1.89459771e-01f, 3.96728784e-01f, 2.12978706e-01f, -5.34288049e-01f, -4.75344419e-01f, 1.14116453e-01f, -3.42047811e-01f, 5.15166186e-02f, 3.90324175e-01f,
  -5.26618659e-01f, -6.80085123e-01f, 3.09270788e-02f, -1.62141129e-01f, -1.22558653e-01f, -6.49942458e-02f, 3.63077104e-01f, 3.30944926e-01f, -5.75723767e-01f, -7.07962513e-01f,
  -1.36445716e-01f, -2.39070002e-02f, -3.72354448e-01f, -1.10223919e-01f, 2.09887728e-01f, 1.58248749e-02f, -4.55904156e-01f, 2.63761282e-01f, -2.69003630e-01f, -5.84349811e-01f,
  1.72411680e-01f, 4.21425730e-01f, -5.76429009e-01f, 1.03595406e-01f, -3.79298031e-01f, 3.38753343e-01f, -4.51358497e-01f, 2.81122118e-01f, 4.67951506e-01f, 1.82257742e-01f,
  3.34634408e-02f, -3.93636972e-01f, -4.05046552e-01f, 3.45036238e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  8.88492391e-02f, -5.11889160e-02f, 1.02382310e-01f, 1.06797375e-01f, -7.13536739e-02f, 1.52737424e-01f, -4.97863367e-02f, -2.96549108e-02f, -1.84332475e-01f, 1.19534679e-01f,
  -7.15026036e-02f, -1.75833210e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    