/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.18651450e-01f, -1.74792513e-01f, -1.91656440e-01f, -4.67860907e-01f, 2.21935228e-01f, -1.82027996e-01f, -4.32019293e-01f, 1.33594915e-01f, -2.23624662e-01f, -7.05157360e-03f,
  -1.00092769e-01f, -3.07124704e-01f, -1.15910001e-01f, -4.03962821e-01f, -1.48937613e-01f, -2.34344363e-01f, -3.40686589e-01f, -3.33892137e-01f, 5.90582676e-02f, -1.22158818e-01f,
  -5.35217263e-02f, -9.59570631e-02f, -1.16234593e-01f, 3.95090550e-01f, -1.40516669e-01f, 9.56721976e-02f, 2.88700134e-01f, 1.87722862e-01f, 4.53979895e-02f, 6.77484497e-02f,
  -1.31641673e-02f, -1.16285294e-01f, -5.58853708e-02f, 1.38813583e-02f, -3.38883512e-02f, 5.99135235e-02f, -5.26284315e-02f, -1.37967523e-02f, 1.69687252e-02f, -8.40916124e-04f,
  -5.54388352e-02f, 2.56113168e-02f, -5.13304211e-02f, 1.89193487e-02f, -1.50187826e-02f, 5.33271804e-02f, -1.95786152e-02f, 2.92074680e-02f, 2.04224531e-02f, -1.40403956e-01f,
  -6.93138689e-02f, -1.01852538e-02f, -3.60278338e-02f, -2.55262125e-02f, -5.68330027e-02f, -4.05661166e-02f, -4.85535339e-02f, 1.74144227e-02f, -1.96783356e-02f, -2.94171702e-02f,
  2.25980617e-02f, -1.95862688e-02f, -1.25025194e-02f, 8.25022310e-02f, 8.99767212e-04f, 4.09610942e-02f, -2.50800420e-02f, 7.55826943e-03f, -1.51439281e-02f, -3.63736264e-02f,
  5.25028035e-02f, -5.75352982e-02f, 2.61574611e-02f, -5.12769930e-02f, -7.25938752e-02f, 4.08654660e-02f, -1.35247065e-02f, 6.64464058e-03f, -3.34319435e-02f, 1.15966368e-02f,
  -6.10315800e-02f, 1.79780647e-02f, 3.79209698e-04f, 8.97111967e-02f, -1.42475311e-02f, -2.23623645e-02f, 2.33580102e-03f, -5.51997796e-02f, 4.40819152e-02f, -1.96392294e-02f,
  4.65464890e-02f, -6.35216236e-02f, 3.39431502e-02f, 2.93552186e-02f, -2.74078199e-03f, 9.23298416e-04f, -3.58831063e-02f, 2.85379048e-02f, 1.62776075e-02f, -2.42873430e-02f,
  5.41833322e-03f, 4.99645993e-03f, 1.01889797e-01f, 2.62879189e-02f, 5.22179343e-02f, -3.64799686e-02f, -3.24483328e-02f, 4.05332744e-02f, 6.11088760e-02f, 2.52721012e-02f,
  6.21408643e-03f, -3.55140939e-02f, 7.21335188e-02f, 3.29814777e-02f, -1.56276915e-02f, -5.62937837e-03f, 1.06125535e-03f, 2.07272843e-02f, 1.26344375e-02f, 5.66957192e-03f,
  -5.37847839e-02f, 1.62799627e-01f, -4.19624954e-01f, -1.93880826e-01f, -7.11474288e-03f, 3.14513445e-01f, -3.42512988e-02f, -7.27364197e-02f, -2.76826441e-01f, 3.21415693e-01f,
  1.78983644e-01f, -2.07441803e-02f, -1.73393130e-01f, 3.31429303e-01f, -3.24381083e-01f, 1.57389864e-01f, 5.74418604e-02f, 1.91909388e-01f, -3.78626734e-02f, -4.20560800e-02f,
  -1.65292546e-01f, 4.26806539e-01f, -2.45280042e-01f, 3.50327909e-01f, -1.38547212e-01f, -1.79393604e-01f, -1.91227287e-01f, 2.37070881e-02f, 1.75472721e-01f, 9.99214575e-02f,
  7.57609978e-02f, -6.97655827e-02f, -7.44423941e-02f, 2.70703584e-02f, -1.24214657e-01f, 1.25132576e-02f, -3.90508957e-02f, 2.51214150e-02f, -1.24571592e-01f, -3.91579233e-02f,
  1.61056519e-02f, 4.33491431e-02f, 1.23057567e-01f, -3.84578444e-02f, 5.05126677e-02f, -7.35099986e-03f, -1.15603268e-01f, -1.22749723e-01f, 3.69168967e-02f, -3.46780717e-02f,
  -4.70160469e-02f, -5.30625023e-02f, -1.27990991e-01f, -2.66445260e-02f, -1.27153814e-01f, 1.88101977e-02f, 2.78396229e-03f, -7.15395436e-02f, 1.36264497e-02f, -5.59943020e-02f,
  3.29708606e-02f, -3.48579027e-02f, 3.84562127e-02f, 7.82608241e-02f, 1.09717734e-02f, 2.66531538e-02f, 2.66040489e-02f, 8.15049037e-02f, -1.46644399e-01f, 4.09414768e-02f,
  3.31681296e-02f, 2.67387498e-02f, 8.90356079e-02f, -2.21937206e-02f, 6.14263862e-02f, 4.79023270e-02f, 1.10091064e-02f, 4.67331037e-02f, -4.15863171e-02f, -6.37701452e-02f,
  6.22565523e-02f, -3.82045167e-03f, -6.02933986e-04f, -1.83246247e-02f, 1.50246263e-01f, -5.13677746e-02f, 4.33733203e-02f, -4.10123765e-02f, -1.68497227e-02f, -2.70263795e-02f,
  -1.10682584e-02f, -4.93241921e-02f, -2.04672609e-02f, 2.54313368e-03f, 3.80924456e-02f, 1.25372320e-01f, 9.68642384e-02f, 4.17517237e-02f, 8.23656693e-02f, 7.39189982e-02f,
  1.04600331e-03f, -4.94344905e-02f, -7.42899254e-02f, 1.79280695e-02f, -6.37409538e-02f, -3.69633287e-02f, 6.55205250e-02f, -8.02486576e-03f, -3.06418948e-02f, -5.87579682e-02f,
  3.88033688e-02f, 9.89492796e-03f, 5.97120300e-02f, -2.88556051e-02f, 6.08822182e-02f, -2.53849616e-03f, -4.88478132e-02f, -8.08720011e-03f, -5.45882508e-02f, 1.78690087e-02f,
  -2.90640779e-02f, -1.16558470e-01f, -3.71719539e-01f, -1.91224977e-01f, 5.37384570e-01f, 1.77242830e-01f, 1.54218733e-01f, 2.03833565e-01f, -2.62381494e-01f, 3.70834060e-02f,
  2.25589320e-01f, -3.65002960e-01f, 2.74368655e-02f, 9.18401498e-03f, -1.90596238e-01f, -3.51944834e-01f, -4.25001681e-01f, -1.89525351e-01f, -5.67800775e-02f, -6.32258728e-02f,
  -1.01235650e-01f, 4.47398484e-01f, -4.08074409e-02f, 2.68512011e-01f, 3.56619656e-01f, -6.31403327e-02f, 1.75146446e-01f, 1.40125826e-01f, 8.31306633e-03f, 4.12126891e-02f,
  1.26969039e-01f, 2.07834374e-02f, 4.58869860e-02f, -1.11020595e-01f, -1.19647710e-02f, 8.16608593e-02f, -7.48399794e-02f, 6.02451749e-02f, -3.94404344e-02f, -6.35065585e-02f,
  -5.12934886e-02f, -1.46082845e-02f, -1.42342951e-02f, 1.10772857e-03f, 1.27899200e-01f, 2.64300965e-02f, 7.91941676e-03f, -3.80982235e-02f, -4.43946104e-03f, 5.38614541e-02f,
  3.75458575e-03f, -7.47419596e-02f, -2.22838037e-02f, -1.51111156e-01f, 9.06603690e-03f, -4.01239321e-02f, -1.15482118e-02f, -3.68544422e-02f, -2.21401770e-02f, -1.73365250e-02f,
  2.66231764e-02f, -4.77542682e-03f, 1.08350068e-02f, 1.37942024e-02f, 9.05892104e-02f, 6.62366673e-02f, 1.40614230e-02f, 1.21034505e-02f, -6.64272755e-02f, 1.20895291e-02f,
  2.04663426e-02f, 2.98404172e-02f, 3.42053771e-02f, 9.91498306e-02f, 4.46970128e-02f, -6.58268929e-02f, -5.57405651e-02f, 2.11812626e-03f, -2.18532849e-02f, 9.49320011e-03f,
  7.02658249e-03f, 2.63122246e-02f, -2.33563669e-02f, 8.56201164e-04f, 1.13641680e-03f, 2.77200248e-02f, -1.84391849e-02f, 3.06735467e-02f, 2.39976589e-02f, 3.34536731e-02f,
  -2.73030493e-02f, -2.20780343e-01f, -9.25874636e-02f, 4.91618924e-02f, -5.15138246e-02f, -1.34775424e-02f, -4.57495335e-04f, -9.15458724e-02f, -3.92189622e-02f, 2.36364100e-02f,
  -1.21599473e-02f, -2.51185894e-02f, -5.68829151e-03f, -1.47577366e-02f, -5.53123839e-02f, 1.06797703e-01f, -3.65619659e-02f, -1.13513485e-01f, -4.56250012e-02f, -6.28271140e-03f,
  8.15078020e-02f, 6.58489615e-02f, -2.72145215e-02f, 9.37619954e-02f, -3.21194157e-02f, 4.08635512e-02f, 3.65598723e-02f, 3.67575102e-02f, 3.96411382e-02f, -2.98925093e-03f,
  -4.79017273e-02f, 2.75110811e-01f, -2.12034415e-02f, 1.61921009e-01f, -2.01947838e-01f, 1.16951875e-01f, 1.69981495e-01f, -1.08782187e-01f, -2.48484880e-01f, 3.63473892e-01f,
  2.32899383e-01f, 2.70654112e-01f, 1.75424352e-01f, 1.71759695e-01f, -2.04797700e-01f, -4.47258875e-02f, 1.09967634e-01f, 2.77861431e-02f, -1.75609410e-01f, 1.34350315e-01f,
  -1.71919823e-01f, 4.20060679e-02f, -2.76024342e-02f, -6.09484911e-02f, 1.15256742e-01f, 1.02550842e-01f, 1.25176921e-01f, -2.76820976e-02f, 2.80705243e-01f, -9.72439870e-02f,
  4.92194816e-02f, -1.51533082e-01f, 4.27627973e-02f, 3.30966488e-02f, 6.73292279e-02f, 2.52661353e-04f, 4.40481715e-02f, 4.49540168e-02f, -5.62614426e-02f, 7.47386292e-02f,
  7.79541135e-02f, -3.44585516e-02f, -4.88088233e-03f, -1.01402923e-01f, -9.39131379e-02f, -1.27129378e-02f, -8.47406685e-02f, 2.42604036e-03f, 8.70489925e-02f, -8.83810893e-02f,
  -1.06372111e-01f, 1.93509664e-02f, 2.44436953e-02f, 4.41126786e-02f, -1.42916933e-01f, -4.44498658e-03f, 3.52163403e-03f, 5.57991229e-02f, -3.13539468e-02f, -2.13855901e-03f,
  -1.45963281e-01f, -1.03122368e-02f, -7.23597407e-03f, -1.47451917e-02f, 1.69812396e-01f, -1.27698973e-01f, 5.53984828e-02f, 5.13212718e-02f, 5.27000949e-02f, 6.41807914e-02f,
  6.65648580e-02f, -7.13593811e-02f, 2.57756445e-03f, -4.58541401e-02f, -1.69284046e-02f, 2.96714739e-03f, 4.87968735e-02f, 1.59667879e-01f, 1.02455458e-02f, 2.32094154e-03f,
  2.50042393e-03f, 4.20384295e-02f, -4.68251109e-02f, 9.75201800e-02f, -9.05438885e-02f, -2.17921520e-03f, 1.67006060e-01f, -2.69417260e-02f, 1.17178373e-01f, 5.65249957e-02f,
  3.04224640e-01f, 3.05085689e-01f, 7.41125345e-02f, 1.94596812e-01f, 6.25099614e-02f, 4.99391789e-03f, -2.33306605e-02f, 4.31718156e-02f, 1.42403603e-01f, 2.48656459e-02f,
  -1.41568007e-02f, 9.08385366e-02f, 1.78184658e-01f, -1.40755745e-02f, -6.57231957e-02f, 7.69554032e-03f, 7.33768940e-02f, 1.27464905e-01f, 1.38089091e-01f, 8.33957493e-02f,
  2.79950708e-01f, 3.84355672e-02f, -9.27638188e-02f, -4.09642383e-02f, -4.60412577e-02f, 1.29543751e-01f, -8.34582373e-02f, -1.43438399e-01f, -4.14079055e-02f, 9.31340083e-02f,
  2.13573687e-02f, 3.41331251e-02f, -3.83837610e-01f, -2.32437477e-01f, 1.25725240e-01f, 6.57865584e-01f, 2.43791714e-02f, -4.46785279e-02f, -2.22568482e-01f, 9.49119255e-02f,
  -6.18490763e-02f, -6.88797235e-02f, -9.89427194e-02f, 1.82529151e-01f, 3.61848831e-01f, -9.63939279e-02f, 3.44413698e-01f, 3.96902598e-02f, -1.22902863e-01f, 1.66533306e-01f,
  -6.44962415e-02f, 3.74342024e-01f, -4.19895537e-02f, 2.04815567e-01f, 1.84299629e-02f, -1.12989917e-01f, 7.51025006e-02f, -1.39182240e-01f, 2.34836981e-01f, 1.03566140e-01f,
  1.26185209e-01f, -3.16373169e-01f, -1.22337602e-01f, -2.30201427e-02f, 4.05868366e-02f, 6.26413003e-02f, -1.73738543e-02f, -9.37352926e-02f, -5.40553294e-02f, -2.68688295e-02f,
  -3.25779244e-03f, 4.70296070e-02f, -1.61465025e-03f, -3.67000327e-03f, -8.10279697e-02f, -1.27355739e-01f, 3.30622587e-03f, -3.52098979e-02f, -7.07847551e-02f, -7.84271210e-02f,
  -9.42129120e-02f, -4.34849299e-02f, -4.68106456e-02f, -1.34821748e-02f, -1.15065873e-01f, -2.15502102e-02f, -3.22161615e-03f, -1.16037820e-02f, 4.18824665e-02f, 3.26514244e-02f,
  -4.43492085e-02f, 9.40273702e-02f, 1.79435387e-02f, 5.83491214e-02f, -2.58983523e-02f, -4.65621240e-02f, 4.90889698e-02f, -8.03147908e-03f, -3.26976441e-02f, 2.35556830e-02f,
  7.98331127e-02f, -4.85682040e-02f, -5.29025681e-02f, -4.42409515e-03f, 6.17280789e-02f, -3.13305035e-02f, 2.79998630e-02f, 6.42685145e-02f, 2.39418540e-02f, -3.10524786e-03f,
  -2.63754688e-02f, 1.17884494e-01f, 1.03089251e-02f, 8.11595917e-02f, 1.25777805e-02f, -8.61907285e-03f, 1.50593091e-02f, -4.62352410e-02f, -4.93925996e-02f, 7.97117203e-02f,
  4.28738773e-01f, 3.80588502e-01f, -2.30608741e-03f, 4.89877872e-02f, 1.25676552e-02f, 9.31401402e-02f, 1.37439510e-02f, 3.19929700e-03f, 9.05663073e-02f, 5.78749068e-02f,
  4.73621264e-02f, -3.47273201e-02f, 5.15772961e-02f, -8.99652205e-03f, 7.02760965e-02f, 4.13512588e-02f, 2.54463963e-02f, 4.90306392e-02f, 1.71783447e-01f, 8.01654384e-02f,
  6.24301694e-02f, 4.97061759e-03f, -4.92613539e-02f, 1.03045609e-02f, 6.33774623e-02f, 4.39137109e-02f, 3.13059129e-02f, -9.11494046e-02f, 7.81040713e-02f, 2.83262506e-02f,
  -5.91511652e-02f, 1.38318744e-02f, 5.38401790e-02f, 2.32157148e-02f, -4.54329580e-01f, -1.04157507e-01f, 3.53517950e-01f, -3.66970986e-01f, 8.02370384e-02f, 1.59472108e-01f,
  -2.39579543e-01f, 4.62906301e-01f, 7.48542920e-02f, 6.82106912e-02f, 7.15505704e-02f, 1.97490051e-01f, 1.15006320e-01f, 1.77163109e-01f, 7.93020800e-02f, -1.44913077e-01f,
  -1.15091354e-01f, -3.52636188e-01f, -1.34368137e-01f, -3.31291467e-01f, -3.67062062e-01f, -3.56331393e-02f, -1.63761571e-01f, -4.25152928e-02f, -1.72564849e-01f, 6.83740303e-02f,
  -2.04015132e-02f, -1.48166075e-01f, 7.01272935e-02f, 5.11002615e-02f, -1.51099890e-01f, 1.15179755e-01f, 1.07030794e-01f, 1.03868186e-01f, -1.06328782e-02f, -2.48315316e-02f,
  1.73073381e-01f, -1.16056077e-01f, 7.60998204e-02f, 6.45856485e-02f, 6.75847474e-03f, -1.65274069e-02f, -1.55283986e-02f, 7.51568284e-03f, -4.78698425e-02f, -3.49849686e-02f,
  6.93117231e-02f, 2.11213231e-02f, 5.80384135e-02f, 4.13415395e-02f, -6.45444468e-02f, -3.03682741e-02f, 1.32736892e-01f, 4.09404002e-02f, -9.07463282e-02f, 6.68096244e-02f,
  2.48896573e-02f, 4.38692756e-02f, 3.67406458e-02f, -4.27473113e-02f, 7.79987453e-03f, -3.35596055e-02f, 3.41926292e-02f, -1.88423116e-02f, 7.72138461e-02f, -7.90127814e-02f,
  -1.31108493e-01f, 5.58450669e-02f, -6.59175171e-03f, -5.51038608e-02f, 1.58829316e-02f, 5.77405654e-02f, 5.74556878e-03f, 5.27148806e-02f, -8.01811367e-02f, -8.27281270e-03f,
  3.30240503e-02f, -9.72374436e-03f, 2.43172459e-02f, -5.47335250e-03f, -3.16123478e-02f, -1.40164921e-03f, -6.14674091e-02f, -6.00078814e-02f, 6.27361462e-02f, -6.93637282e-02f,
  -6.79488480e-02f, -9.69690457e-02f, -3.66747007e-02f, -9.56598446e-02f, 8.84225741e-02f, -1.29842702e-02f, 3.17749716e-02f, -3.44597101e-02f, 2.32886057e-02f, -2.70953830e-02f,
  -8.54304358e-02f, 2.80603748e-02f, -9.23563465e-02f, -9.55504030e-02f, -1.35875884e-02f, -4.54718396e-02f, 4.67339046e-02f, 7.37437047e-03f, 4.14427090e-03f, 3.14526632e-03f,
  -1.66613698e-01f, -4.22283337e-02f, 5.52766360e-02f, -1.12658568e-01f, -1.69601142e-02f, 1.51199680e-02f, 2.82916310e-03f, 7.39431530e-02f, -1.98826771e-02f, 4.43929546e-02f,
  -4.47592616e-01f, 1.91914037e-01f, -7.58183375e-02f, -1.08450547e-01f, -3.31762522e-01f, -2.21505061e-01f, -4.66310568e-02f, -1.49466991e-01f, -8.28553587e-02f, 3.49705279e-01f,
  -1.85663521e-01f, 5.82338795e-02f, -4.55609113e-02f, -4.55730110e-02f, -6.42290473e-01f, 6.50116652e-02f, -2.67543852e-01f, -3.02772131e-02f, -3.71189527e-02f, -3.31992388e-01f,
  -1.41816020e-01f, -1.37611359e-01f, -2.16947868e-01f, -1.39374971e-01f, -2.11572587e-01f, 1.58819541e-01f, 9.08818562e-03f, 1.19194463e-01f, 7.33866617e-02f, 3.03600337e-02f,
  -5.43043613e-02f, -1.68864932e-02f, 1.08574793e-01f, 6.22405112e-03f, -1.98127881e-01f, 2.61077266e-02f, 1.67093873e-02f, 1.44761354e-02f, 6.07080990e-03f, -2.85255052e-02f,
  6.68053282e-03f, -9.98948812e-02f, 2.00647470e-02f, 7.08352029e-02f, -1.22145182e-02f, -2.97392486e-03f, -3.34450155e-02f, 2.90740319e-02f, -7.09492853e-03f, 4.93136980e-03f,
  -3.58615507e-05f, 2.03401651e-02f, -3.69537510e-02f, 4.43068929e-02f, -5.96254505e-02f, 8.18193182e-02f, 3.82239036e-02f, -1.93542894e-02f, -6.07818738e-02f, -5.64151108e-02f,
  -9.04660821e-02f, -2.87913787e-03f, 5.74760288e-02f, 2.57163914e-03f, -2.63111498e-02f, 3.64765376e-02f, -6.60701236e-03f, -2.45020427e-02f, 6.75980523e-02f, -8.22178423e-02f,
  -4.24576886e-02f, 4.97884005e-02f, -1.02573493e-02f, 4.24702615e-02f, 7.11480975e-02f, 7.04764277e-02f, 1.48539217e-02f, -1.24084176e-02f, -2.72135548e-02f, -2.68665478e-02f,
  2.78105047e-02f, -7.65191242e-02f, 3.76365408e-02f, -5.85626578e-03f, -7.52417743e-02f, 2.02556234e-02f, 6.10012896e-02f, 2.16476694e-02f, 6.41704444e-03f, -6.75733760e-02f,
  -2.51426786e-01f, -9.89737660e-02f, 4.52044094e-03f, -5.56490049e-02f, 9.73590612e-02f, -2.34704111e-02f, 1.15110669e-02f, -1.01331715e-02f, -3.52173485e-02f, -1.25076309e-01f,
  1.21778925e-03f, 2.90627442e-02f, -1.07817359e-01f, -3.55786942e-02f, 2.91170403e-02f, 1.42504973e-02f, -7.29142455e-03f, 9.66401026e-02f, -1.01448655e-01f, -2.11741943e-02f,
  -3.52963023e-02f, -4.68824878e-02f, 6.61044642e-02f, -2.74022613e-02f, -5.01111448e-02f, -2.99870707e-02f, -6.36108741e-02f, 8.54883492e-02f, -2.68919989e-02f, 7.92886410e-03f,
  -3.76115471e-01f, -2.19008461e-01f, 1.82472467e-01f, 6.79503456e-02f, -4.28034216e-01f, -3.41745198e-01f, -1.73190266e-01f, -8.21240023e-02f, -2.40446717e-01f, -6.75713702e-04f,
  -3.44779283e-01f, 3.03576320e-01f, -1.80979848e-01f, 2.64999837e-01f, 2.09407788e-03f, 9.24548209e-02f, 1.26200318e-01f, 4.97628711e-02f, 3.58873047e-02f, 9.42556560e-02f,
  1.23226553e-01f, -4.75699902e-02f, 3.77429068e-01f, 3.30585949e-02f, 4.49319407e-02f, 1.48747046e-03f, 1.69300556e-01f, -8.09868425e-03f, 1.61818579e-01f, -5.87186888e-02f,
  -8.12518522e-02f, -6.96549341e-02f, 2.62313019e-02f, 7.29115307e-02f, 6.52141348e-02f, 3.29880081e-02f, 7.34010059e-03f, 3.65148820e-02f, -1.12057589e-02f, -1.83752868e-02f,
  -8.13818127e-02f, -1.15456553e-02f, 4.17666957e-02f, -3.38855721e-02f, -1.62335098e-01f, -5.06381616e-02f, 1.36733994e-01f, -8.81348923e-02f, -5.20975254e-02f, 6.92409426e-02f,
  1.42687224e-02f, 1.21952565e-02f, 8.44296217e-02f, -1.53387748e-02f, 4.96437727e-03f, -1.01477362e-01f, 6.20102882e-02f, 9.41856280e-02f, 1.76615566e-02f, -1.77910458e-02f,
  -6.07819064e-03f, 1.26769757e-02f, -7.63420295e-03f, 4.04084101e-02f, -1.03600129e-01f, -1.49017766e-01f, 3.14196050e-02f, 4.73987795e-02f, 1.29041791e-01f, -2.40863468e-02f,
  -5.27775772e-02f, 3.49344350e-02f, 1.03358980e-02f, 4.16447297e-02f, -6.37504682e-02f, 1.23250857e-02f, -8.72992054e-02f, -2.45541725e-02f, -9.50939953e-02f, 8.11127797e-02f,
  -5.41983061e-02f, -1.02732986e-01f, 2.91093942e-02f, 5.54224588e-02f, -5.71344420e-02f, 9.69741866e-02f, -4.02048044e-02f, -9.44512337e-02f, 5.75907193e-02f, 1.43127665e-02f,
  -2.50934809e-01f, -9.09303650e-02f, -9.65808146e-03f, -1.36114955e-01f, 3.44478451e-02f, 1.18074797e-01f, 1.18316405e-01f, 4.06753607e-02f, -3.84900197e-02f, -2.46148761e-02f,
  3.30908201e-03f, 7.90378898e-02f, -7.38023892e-02f, 8.92046187e-03f, 7.16727898e-02f, -9.56605971e-02f, -4.08108458e-02f, -5.65696582e-02f, -9.92234945e-02f, -4.55527082e-02f,
  -2.57316418e-02f, 6.67636923e-04f, 1.12438947e-01f, 3.65121104e-02f, 9.50267687e-02f, -2.67970338e-02f, -8.93206671e-02f, -1.58415325e-02f, 9.09218490e-02f, -9.74785653e-04f,
  7.51554444e-02f, -7.42882714e-02f, 3.36598337e-01f, -2.80826598e-01f, -2.48606697e-01f, 1.98799402e-01f, -7.24141300e-02f, -2.30898991e-01f, -4.22830045e-01f, -2.24596113e-01f,
  -3.67229551e-01f, -1.15323395e-01f, -6.06421940e-02f, -2.36273199e-01f, 4.47961569e-01f, 1.68735325e-01f, -2.99966969e-02f, -5.16763404e-02f, -8.51469114e-02f, -2.03037113e-01f,
  1.47155896e-01f, -4.81952101e-01f, 2.03128740e-01f, -1.87970474e-01f, -2.31172815e-01f, 5.80910183e-02f, -2.61378996e-02f, 5.77222668e-02f, -2.20327247e-02f, 1.06190026e-01f,
  4.49626520e-02f, -2.27442011e-01f, -7.20457509e-02f, 1.47451177e-01f, 2.91370582e-02f, 1.54653743e-01f, 1.29994556e-01f, 1.25842988e-01f, -2.17605624e-02f, -9.08184517e-03f,
  1.85560156e-02f, -3.86164412e-02f, 4.42308895e-02f, -1.38562068e-01f, -1.42680869e-01f, 2.94095110e-02f, 7.04282820e-02f, -9.48809367e-03f, 4.47406173e-02f, 8.59117135e-02f,
  1.62347332e-02f, 2.18733713e-01f, -2.53144503e-02f, 1.49294153e-01f, 2.49200258e-02f, -7.91098624e-02f, 8.34939629e-03f, 7.18303248e-02f, -6.01622537e-02f, -5.82297780e-02f,
  1.28971506e-02f, -7.44270906e-03f, 1.92948040e-02f, -1.07867301e-01f, 1.32280765e-02f, 4.57539186e-02f, -1.12265818e-01f, 7.63800964e-02f, 6.54059649e-02f, -1.14802655e-03f,
  -1.02075720e-02f, -3.63538116e-02f, -7.65692070e-02f, -6.16448596e-02f, -2.63003092e-02f, -4.75321151e-02f, -3.08422279e-02f, -5.47523610e-02f, 2.16207076e-02f, -5.47566675e-02f,
  -1.39896302e-02f, -3.38572748e-02f, -6.29741848e-02f, 1.17375292e-01f, 7.66252913e-03f, -4.01813053e-02f, -9.23176035e-02f, 6.80493563e-02f, 2.76672859e-02f, -4.43347916e-02f,
  -9.03359652e-02f, -3.73443253e-02f, 3.93058881e-02f, -1.54522806e-02f, -2.88318470e-02f, 1.05162472e-01f, -3.83265279e-02f, -3.36788893e-02f, 1.57694565e-03f, 4.18190919e-02f,
  3.27743329e-02f, 6.38826424e-03f, 9.95184183e-02f, -9.37153473e-02f, -4.19928245e-02f, -1.98916346e-02f, 1.32777486e-02f, -6.08251477e-03f, 1.47249978e-02f, 9.76584014e-03f,
  -5.15394844e-02f, -5.47829904e-02f, 1.36607081e-01f, -2.68073268e-02f, -3.64223011e-02f, 3.73230763e-02f, -1.77257344e-01f, -1.58495102e-02f, 1.27912402e-01f, -3.63944983e-03f,
  2.74953336e-01f, 8.38078037e-02f, 4.00282145e-01f, 2.17050031e-01f, -1.26567826e-01f, 8.81678462e-02f, 3.21859688e-01f, -2.70124041e-02f, 4.77221251e-01f, -1.61127776e-01f,
  -1.39534593e-01f, 9.11283772e-03f, 7.27656484e-02f, -1.66796401e-01f, -5.06366938e-02f, 2.70649135e-01f, 5.12035266e-02f, -1.63277034e-02f, 8.92149732e-02f, -1.39447972e-01f,
  7.73214251e-02f, -2.95644879e-01f, 5.24124242e-02f, -2.74371594e-01f, -1.98800802e-01f, 1.64869800e-01f, -3.64629775e-01f, -3.24841514e-02f, -3.43717575e-01f, -8.27353671e-02f,
  8.39927644e-02f, 1.42886236e-01f, -1.62615278e-03f, 1.26840249e-01f, -7.79415434e-03f, 6.68992347e-04f, -6.25901073e-02f, -4.05677073e-02f, 1.37442991e-01f, 6.15188666e-02f,
  1.09121315e-02f, -7.16978777e-03f, -3.19848806e-02f, 3.46307233e-02f, 1.22027233e-01f, 7.81775918e-03f, -4.42384146e-02f, -4.63105291e-02f, -4.98109916e-03f, 3.99783254e-02f,
  1.94665611e-01f, 9.59921330e-02f, 8.06138758e-03f, 1.28698107e-02f, 3.78332920e-02f, 1.29263282e-01f, 1.77129000e-01f, -3.66331227e-02f, 5.31245209e-02f, 6.18421324e-02f,
  -9.34818238e-02f, 7.63361976e-02f, 5.15177995e-02f, 3.66777964e-02f, -2.06167717e-02f, -2.18227897e-02f, 1.82596780e-02f, -7.90616795e-02f, 3.72757427e-02f, 2.76207328e-02f,
  -2.06077490e-02f, 2.31663436e-02f, 6.26635998e-02f, 1.46290928e-01f, -6.05241209e-02f, 3.05846408e-02f, -4.63072956e-02f, -1.32378761e-03f, 9.15290266e-02f, -2.67294534e-02f,
  -5.68985455e-02f, 1.11113461e-02f, 3.64621878e-02f, -2.04018112e-02f, 1.00300863e-01f, 6.20840900e-02f, 1.02162128e-02f, 5.99285327e-02f, -4.18243511e-03f, -1.21770710e-01f,
  -1.46776170e-01f, -2.56777197e-01f, 3.27623487e-02f, 1.93620361e-02f, -1.09586772e-02f, -1.36699826e-01f, 5.74479029e-02f, -3.53058763e-02f, -8.58410299e-02f, -7.52303079e-02f,
  -3.54897082e-02f, 6.28293008e-02f, -6.99072480e-02f, -3.64878550e-02f, 5.10545038e-02f, 3.67492065e-02f, -2.96631921e-02f, 2.13575643e-02f, -2.63922680e-02f, -1.12249292e-01f,
  -8.01355913e-02f, 3.78402844e-02f, 1.37136527e-03f, -7.77860545e-03f, 4.94551621e-02f, -6.15220666e-02f, -1.08475640e-01f, 1.30007342e-01f, -1.50009394e-01f, -3.27559672e-02f,
  -7.08540022e-01f, 5.49979389e-01f, 1.58423156e-01f, 7.72542728e-04f, -2.85945803e-01f, -3.40842336e-01f, -1.38476759e-01f, 1.61347594e-02f, -7.20614567e-02f, 4.44173783e-01f,
  8.80590230e-02f, 1.06766790e-01f, 2.29395449e-01f, 4.71739620e-02f, -5.25747776e-01f, 4.80306037e-02f, -1.92509815e-01f, 2.39229668e-02f, -4.59993891e-02f, 8.84678587e-02f,
  -9.53814015e-02f, -6.24607988e-02f, -8.56682099e-03f, 4.78970706e-02f, -2.63582785e-02f, 7.85879940e-02f, -3.75966318e-02f, 1.09761588e-01f, 7.84109011e-02f, -5.24535961e-02f,
  -9.05224532e-02f, 7.46607110e-02f, 2.92333253e-02f, 1.19722364e-02f, -5.81482193e-03f, 3.10026482e-02f, 7.07064290e-03f, -1.16453907e-02f, -7.57693648e-02f, 7.22836982e-03f,
  1.72014872e-03f, -8.11493024e-02f, 5.63604350e-04f, 1.61700696e-02f, -3.56957018e-02f, -1.08038737e-02f, -1.74173713e-02f, -4.40031663e-02f, 1.02671064e-01f, -4.90603186e-02f,
  1.33049507e-02f, -7.00627193e-02f, -2.17493400e-02f, 1.74413502e-01f, -3.61707956e-02f, 5.89629449e-03f, 1.36088887e-02f, 3.03422250e-02f, 4.74610599e-03f, -5.31340800e-02f,
  4.91687804e-02f, 6.36304030e-03f, -3.50996330e-02f, -9.58264619e-03f, -2.58254260e-02f, 2.06901487e-02f, -4.20661308e-02f, 6.14432842e-02f, 3.05693783e-02f, 1.91430859e-02f,
  -1.10722575e-02f, 7.39579773e-05f, 5.53213097e-02f, -1.07111940e-02f, 3.09098195e-02f, 9.01634805e-03f, 9.07531101e-03f, 9.13909003e-02f, 1.69058330e-02f, -1.06570944e-02f,
  8.64217244e-03f, -3.65690067e-02f, 6.23246841e-02f, 4.01148275e-02f, -1.14642559e-02f, -4.48598973e-02f, 1.93955526e-02f, 4.94094267e-02f, 3.02151684e-02f, -9.27272290e-02f,
  1.40509099e-01f, 3.29172343e-01f, 8.50354880e-02f, 5.00191562e-02f, 1.01533413e-01f, -1.42998872e-02f, -3.23722064e-02f, -5.56265824e-02f, 6.65881634e-02f, -1.46273319e-02f,
  -1.73160285e-02f, 5.83325811e-02f, -1.72010929e-04f, -3.12486161e-02f, -4.94424701e-02f, 4.82084751e-02f, 9.01045203e-02f, 3.51351164e-02f, -6.06030114e-02f, 9.29371268e-02f,
  2.89672054e-02f, 1.63682010e-02f, -9.97639634e-03f, -1.79962777e-02f, 5.75021543e-02f, -3.20289237e-03f, -9.18189734e-02f, -6.33633584e-02f, 4.24052291e-02f, 4.36270535e-02f,
  4.33486491e-01f, 2.81307966e-01f, 1.39552817e-01f, -1.30675193e-02f, -2.42244434e-02f, 1.14708245e-01f, 4.23459299e-02f, 3.81854102e-02f, 7.75481574e-03f, 1.01335101e-01f,
  -1.42130643e-01f, 4.50806111e-01f, -9.66243818e-02f, -2.20355839e-01f, 2.43342727e-01f, -1.23865783e-01f, 1.26455188e-01f, 2.00693920e-01f, -9.33772773e-02f, 2.23825678e-01f,
  4.21233028e-02f, -1.14119671e-01f, -7.99858794e-02f, -1.88343123e-01f, 2.29117408e-01f, -6.90701231e-02f, 8.42012614e-02f, -8.70039016e-02f, 5.79912774e-02f, -1.15756154e-01f,
  -3.59854735e-02f, -8.28727186e-02f, -8.05010349e-02f, -1.32712144e-02f, 1.06932834e-01f, 5.03464341e-02f, 1.53791651e-01f, -7.91193470e-02f, -1.64297432e-01f, -3.73394527e-02f,
  1.56520754e-01f, -2.30851173e-02f, -1.32631794e-01f, -8.43431950e-02f, -1.48704760e-02f, -1.34141341e-01f, -5.82465492e-02f, -1.90431364e-02f, -3.81873585e-02f, 5.81283011e-02f,
  4.58823377e-03f, -2.10747402e-02f, -1.31803798e-02f, 4.62197512e-03f, 3.59690338e-02f, -7.02686002e-03f, -7.00498968e-02f, 2.55014449e-02f, 9.16808397e-02f, -3.04643624e-02f,
  -1.21723607e-01f, 1.73926745e-02f, -2.66291145e-02f, 1.69330742e-03f, -6.59218617e-03f, -3.22914533e-02f, 5.18842675e-02f, -3.45815420e-02f, 2.66899988e-02f, 4.82654832e-02f,
  -1.82088707e-02f, -6.80279871e-03f, -3.89106646e-02f, 1.56378299e-02f, 6.66864514e-02f, 9.17245983e-04f, 5.40551580e-02f, 2.93193664e-02f, 3.20152417e-02f, 1.80016400e-03f,
  -3.76210101e-02f, 4.33836356e-02f, 7.97054023e-02f, -4.47464399e-02f, -6.07685708e-02f, 3.75514962e-02f, -1.48062780e-03f, -9.91453137e-03f, -1.04203835e-01f, 2.07434539e-02f,
  4.02754098e-01f, 4.52530831e-01f, -7.51003101e-02f, -1.04827762e-01f, -4.99589629e-02f, -2.36979723e-02f, 2.30714772e-02f, 1.11992136e-02f, 1.44555300e-01f, 2.31564883e-02f,
  -3.30707729e-02f, 2.31815353e-02f, 1.63269907e-01f, 2.71585938e-02f, 3.15495990e-02f, 8.59343633e-02f, 5.35708293e-02f, 8.06873441e-02f, 7.99691752e-02f, 7.98641369e-02f,
  -6.15964364e-03f, 1.02869943e-02f, -1.19233042e-01f, 4.07875963e-02f, -3.62568349e-02f, -2.81327404e-02f, 1.76547617e-01f, -6.09071068e-02f, 8.66744369e-02f, 7.61496723e-02f,
  2.10180730e-01f, 2.57871360e-01f, -3.87442708e-01f, 2.67798454e-01f, 2.52347082e-01f, -4.16955590e-01f, -1.58258036e-01f, 2.27704406e-01f, -2.42627528e-03f, 1.04445241e-01f,
  2.58371711e-01f, 6.10786267e-02f, -3.61557677e-03f, 2.61391014e-01f, -1.84006795e-01f, -1.96892038e-01f, 6.56957775e-02f, 2.45362688e-02f, 1.74245816e-02f, 1.80701584e-01f,
  -9.83225629e-02f, 3.74813616e-01f, -7.58420005e-02f, 1.37159809e-01f, 7.93282241e-02f, -6.01435713e-02f, 3.18208754e-01f, -1.42670184e-01f, 1.00413784e-01f, 1.50026664e-01f,
  8.20421726e-02f, 2.01854914e-01f, 1.11612799e-02f, -5.62264696e-02f, 3.12625314e-03f, -3.58700491e-02f, -9.33537036e-02f, -2.74022203e-03f, 7.05845729e-02f, -1.17747616e-02f,
  -3.12891267e-02f, 4.90439460e-02f, 1.38560012e-01f, -7.03408495e-02f, -2.98254453e-02f, 6.56200945e-02f, -3.50386426e-02f, -9.35442671e-02f, -4.71733883e-03f, -1.78699985e-01f,
  -5.52241094e-02f, -9.58661959e-02f, -5.16149066e-02f, -3.83806378e-02f, -3.72879580e-02f, -4.46478277e-02f, -1.88476250e-01f, -3.29084024e-02f, -7.19581842e-02f, -3.81149277e-02f,
  -1.48090757e-02f, -1.62671693e-02f, -4.18451130e-02f, 5.97911775e-02f, 2.15748250e-02f, 8.48247036e-02f, -3.74694504e-02f, 2.34278608e-02f, -1.08195923e-01f, 3.56534906e-02f,
  -9.63197649e-03f, 7.43421316e-02f, 6.55434653e-02f, -8.82603750e-02f, -8.23483523e-03f, 2.62953509e-02f, -5.13840728e-02f, -5.59883704e-03f, -2.13385001e-02f, 3.77445333e-02f,
  -3.43400687e-02f, -9.76482853e-02f, 4.43164892e-02f, -5.10411412e-02f, -6.08029403e-03f, -1.11667231e-01f, -6.29768744e-02f, -1.06544703e-01f, 2.94181406e-02f, -5.91203719e-02f,
  -1.58785786e-02f, 1.27370104e-01f, 1.29748508e-01f, -4.63072862e-03f, -2.25689523e-02f, 3.77127454e-02f, -6.76561743e-02f, -5.02015427e-02f, -6.79103509e-02f, -1.52052930e-02f,
  -3.49856541e-02f, 2.72125173e-02f, -7.65001848e-02f, 4.85953391e-02f, -1.52471960e-02f, -5.79485558e-02f, -6.48709238e-02f, -3.34749639e-04f, 1.14555851e-01f, 1.45043522e-01f,
  -3.33239250e-02f, 4.43263501e-02f, -2.76868343e-02f, 7.92892426e-02f, -1.14702266e-02f, 9.91195664e-02f, 2.91305277e-02f, -5.62848561e-02f, -5.14157861e-03f, -4.98931222e-02f,
  -4.91642714e-01f, 5.38830519e-01f, -2.70871650e-02f, -3.06873526e-02f, 2.01702818e-01f, -1.58786863e-01f, -1.22141810e-02f, 3.05572480e-01f, -1.63064040e-02f, 3.25724572e-01f,
  2.01835245e-01f, -2.05883265e-01f, 3.60008389e-01f, 3.28737140e-01f, -2.73924142e-01f, 2.07150415e-01f, -1.22499347e-01f, -6.09050365e-03f, 3.57624851e-02f, 2.19175026e-01f,
  9.88446735e-03f, 2.96369821e-01f, 1.23820089e-01f, 2.57050484e-01f, 4.19380702e-02f, -9.20830667e-02f, 3.10017560e-02f, -3.55891138e-02f, -4.01488207e-02f, -1.45613700e-01f,
  5.39253186e-03f, 2.05272242e-01f, 3.24680284e-02f, 2.57823290e-03f, 1.74405426e-02f, 2.20840462e-02f, -4.91799302e-02f, -6.88612908e-02f, -1.61023233e-02f, -4.03047726e-02f,
  -4.15186631e-03f, -2.61059385e-02f, -4.11511287e-02f, 1.16135450e-02f, -4.20157909e-02f, -2.80219913e-02f, 1.88503042e-03f, 4.54867892e-02f, 5.08847907e-02f, 6.60415888e-02f,
  6.06588200e-02f, -1.10559464e-02f, -1.71128549e-02f, -2.50772722e-02f, -6.01135679e-02f, 2.96004862e-02f, -1.20201623e-02f, -8.26443583e-02f, -3.84031832e-02f, -6.65671825e-02f,
  2.02151518e-02f, 6.00250624e-03f, 5.42668290e-02f, 3.86371613e-02f, 3.97421569e-02f, 1.12291254e-01f, -3.46033983e-02f, 4.26206291e-02f, -6.47649318e-02f, 6.61905631e-02f,
  -4.13548127e-02f, 1.87486678e-03f, 2.29346305e-02f, -7.93804452e-02f, 3.73578742e-02f, 7.33663365e-02f, -1.07387833e-01f, -4.46240939e-02f, -2.01605428e-02f, 5.86576052e-02f,
  6.01457655e-02f, -1.98944211e-02f, -6.19016960e-03f, -7.65789822e-02f, 4.18862961e-02f, -7.23385140e-02f, 8.11032653e-02f, -7.12628476e-03f, 5.33289835e-02f, -1.33311585e-01f,
  8.98157805e-02f, 8.78100470e-02f, 3.93814370e-02f, 5.37582347e-03f, 5.64350039e-02f, -3.72951925e-02f, 2.31125578e-03f, -7.25026429e-02f, -1.00531094e-02f, 1.08833864e-01f,
  -5.28272502e-02f, 5.00595272e-02f, -4.73200046e-02f, -6.69366643e-02f, -8.34636763e-02f, 1.14631511e-01f, -1.08846454e-02f, -4.20273654e-02f, -1.35323793e-01f, -1.65621899e-02f,
  -1.81556568e-02f, -8.78903046e-02f, -4.68002632e-02f, 1.62174925e-02f, -5.76853380e-02f, -5.39817810e-02f, -6.85794428e-02f, -5.38924001e-02f, -5.21422625e-02f, -6.96568638e-02f,
  3.12730595e-02f, -1.22550309e-01f, -2.69999385e-01f, -6.51641265e-02f, -2.02254534e-01f, 3.22220027e-01f, 3.61578941e-01f, -3.18501472e-01f, 5.83717264e-02f, 8.74069631e-02f,
  1.69874981e-01f, 4.16037329e-02f, 1.73642099e-01f, 3.89207333e-01f, 3.97399098e-01f, 3.57560962e-01f, 3.00407141e-01f, 2.70275384e-01f, 2.56598834e-02f, -1.23345055e-01f,
  -6.32947981e-02f, 1.38462663e-01f, -3.03472020e-02f, -1.71735331e-01f, -2.42910609e-01f, -2.95069337e-01f, -1.18786745e-01f, -3.30546834e-02f, 1.75988453e-03f, 1.27730012e-01f,
  2.19801113e-01f, -9.32689384e-02f, -1.65044963e-01f, 3.67262103e-02f, -7.61326849e-02f, 5.04765473e-02f, 2.70817522e-02f, 6.06403016e-02f, -5.22006713e-02f, 3.90237384e-02f,
  2.17990391e-02f, -7.02278614e-02f, -1.84094738e-02f, -1.47124361e-02f, 1.86870024e-02f, -2.78764237e-02f, -7.52076656e-02f, -2.89348625e-02f, -9.39041376e-02f, -3.37065645e-02f,
  -1.76633876e-02f, 8.99421275e-02f, -3.19300406e-02f, 1.22564927e-01f, -1.08093306e-01f, 3.43755335e-02f, 8.95910989e-03f, -4.93814126e-02f, 2.33733281e-02f, -1.32423550e-01f,
  -2.20783632e-02f, 1.92006845e-02f, 1.79815199e-02f, 6.61071911e-02f, 5.87728806e-02f, -6.70815483e-02f, 7.55999163e-02f, 4.94873822e-02f, -3.90017368e-02f, 4.25371947e-03f,
  5.07172197e-02f, -2.03044899e-02f, 4.00531664e-02f, -5.87805687e-03f, 5.74272999e-04f, -8.69744197e-02f, 1.63736120e-02f, 2.28946190e-02f, -4.94908504e-02f, -2.23390628e-02f,
  4.89259437e-02f, 8.70093703e-02f, -8.38408619e-02f, 2.49153990e-02f, 1.30740955e-01f, -3.00825182e-02f, 4.44541452e-03f, 1.34822298e-02f, 1.92679092e-03f, -6.71987757e-02f,
  -3.37942201e-03f, -1.45825416e-01f, -2.32771672e-02f, 6.09375313e-02f, 7.77705163e-02f, 2.51289606e-02f, 8.60800371e-02f, -5.62427081e-02f, 3.83286178e-02f, 3.23066264e-02f,
  -1.17786238e-02f, 1.36871943e-02f, -2.31984369e-02f, 1.65660419e-02f, -2.34762430e-02f, 1.72851235e-02f, 8.30972791e-02f, -1.59025621e-02f, -2.28921380e-02f, -5.68785369e-02f,
  -1.43742219e-01f, 5.34767434e-02f, 3.27604450e-02f, -6.81840256e-02f, -1.62570048e-02f, 3.01169008e-02f, -2.93298513e-02f, -5.92355318e-02f, 1.78222582e-02f, 5.50011136e-02f,
  -3.27197909e-01f, 2.42691159e-01f, 3.49908650e-01f, 6.12506941e-02f, -2.67874330e-01f, -3.82929325e-01f, -2.76368856e-01f, 1.42961994e-01f, 1.67883217e-01f, 1.18829779e-01f,
  -6.22408092e-02f, -1.13672376e-01f, 9.86969545e-02f, 3.56820859e-02f, -1.95588425e-01f, 2.95865387e-01f, -5.51065542e-02f, -1.37660071e-01f, 1.38030589e-01f, -1.49117514e-01f,
  3.53853405e-02f, -2.46924698e-01f, 1.88551202e-01f, -7.60383904e-02f, -1.88265622e-01f, 1.80503294e-01f, -1.26790822e-01f, 3.16776559e-02f, -8.48817602e-02f, -1.60868585e-01f,
  7.27723911e-02f, 1.60692900e-01f, 6.75487593e-02f, 3.69328633e-02f, -3.97243490e-03f, -1.53617084e-01f, -8.06540027e-02f, -4.60135601e-02f, 5.10831876e-03f, 7.87763819e-02f,
  -1.27732068e-01f, -4.11511399e-02f, 1.36315506e-02f, -1.58509072e-02f, -5.31762950e-02f, 8.39292556e-02f, 9.38542467e-03f, 1.35638239e-02f, 1.10566780e-01f, 1.02860089e-02f,
  6.50116354e-02f, 8.36140141e-02f, -5.75453322e-03f, -2.72009685e-03f, 2.57807579e-02f, 4.27353047e-02f, -7.75263179e-03f, -8.74105096e-03f, 9.33153089e-03f, -8.94342288e-02f,
  -1.51662409e-01f, -7.49729425e-02f, 2.26998031e-02f, 1.15599416e-01f, 1.23130335e-02f, 8.39975756e-03f, -5.31898513e-02f, -5.68551011e-02f, 1.57530103e-02f, 1.51847247e-02f,
  1.18664643e-02f, -4.04532440e-02f, -4.37790714e-02f, -4.88293543e-02f, -7.85559490e-02f, 7.71566778e-02f, -1.09344590e-02f, -3.35109420e-02f, 3.23791169e-02f, 1.36224423e-02f,
  6.00646660e-02f, -1.02034919e-01f, 1.14806160e-01f, -3.50150056e-02f, 4.80973274e-02f, 5.23803420e-02f, -2.27177106e-02f, 4.50321957e-02f, 7.09852725e-02f, -1.34602532e-01f,
  -1.18302226e-01f, -1.58614844e-01f, 1.09459966e-01f, -2.06969623e-02f, 6.44654185e-02f, -6.57744193e-03f, 2.14849394e-02f, -3.54615971e-02f, 1.72347892e-02f, -1.09775752e-01f,
  -5.85502572e-02f, 2.47710943e-03f, -1.32874265e-01f, -9.59561020e-02f, -2.45360029e-03f, 3.71600837e-02f, -2.87151728e-02f, 8.83652363e-03f, -1.62548274e-01f, -6.07559122e-02f,
  -9.00967643e-02f, -1.26239136e-01f, 1.60583649e-02f, -1.01833232e-02f, -1.61967337e-01f, -1.26964878e-02f, -9.47988853e-02f, 1.21219002e-01f, -1.28236890e-01f, 5.33265211e-02f,
  6.96317911e-01f, 6.62597492e-02f, 2.15215951e-01f, 3.16198379e-01f, 4.84797210e-02f, 4.33255762e-01f, 1.45457178e-01f, 1.58156365e-01f, 2.49228656e-01f, -1.32140398e-01f,
  -9.04044360e-02f, 1.12475105e-01f, -3.22065413e-01f, 2.04047799e-01f, 4.07796025e-01f, -8.45483392e-02f, 3.07107598e-01f, 1.23121731e-01f, 2.52231564e-02f, 2.44053021e-01f,
  1.61986992e-01f, 7.06887841e-02f, -1.98164792e-03f, 2.99836509e-02f, 1.75177678e-01f, 3.86580750e-02f, -2.21268818e-01f, -1.40077785e-01f, 8.27638898e-03f, 3.05478349e-02f,
  5.95452413e-02f, -1.37084171e-01f, -4.25774716e-02f, 2.92226928e-03f, 7.00385720e-02f, -1.36691816e-02f, 2.33755112e-02f, -6.39090016e-02f, 1.20754056e-02f, 1.88510157e-02f,
  -1.66951884e-02f, 6.52817562e-02f, 6.18505180e-02f, -1.77747589e-02f, 7.78405890e-02f, 3.89345586e-02f, 1.31735098e-04f, -6.63304403e-02f, -3.81676368e-02f, 9.02939215e-03f,
  6.65291399e-02f, -1.04484730e-03f, 1.03244111e-01f, -4.22268622e-02f, 5.68578690e-02f, 2.24768165e-02f, 3.57403122e-02f, -7.49586569e-03f, 4.67505353e-03f, 8.33760798e-02f,
  6.38702288e-02f, 1.58986170e-02f, -3.07906438e-02f, -3.52129005e-02f, 6.15131855e-02f, -1.01712294e-01f, -1.18561294e-02f, -3.00172977e-02f, 4.38737012e-02f, 6.34599477e-02f,
  -1.70136057e-02f, 3.49879041e-02f, -1.40651567e-02f, 8.81115533e-03f, 4.49676812e-03f, -1.18913651e-02f, -4.04644832e-02f, -3.18813585e-02f, 4.09929305e-02f, -6.85862251e-05f,
  -9.83479545e-02f, 8.85174647e-02f, -4.35569100e-02f, -6.38987124e-02f, 5.53227728e-03f, -2.33974936e-03f, -1.17912760e-03f, 4.11299691e-02f, 1.30968494e-02f, 2.34278608e-02f,
  2.85591148e-02f, 8.06546062e-02f, 5.68761537e-03f, 1.25906412e-02f, -4.95509617e-02f, 4.21426073e-02f, 6.39065355e-02f, 1.19524933e-01f, 2.12591924e-02f, 3.44321653e-02f,
  3.58215757e-02f, -3.80694456e-02f, 2.53940257e-03f, 1.12493802e-02f, -3.07626259e-02f, -1.54561857e-02f, -3.27441543e-02f, -3.28136981e-02f, 8.49856362e-02f, 6.59898147e-02f,
  -3.57156098e-02f, -4.04297328e-03f, -7.38808280e-03f, -5.33288233e-02f, -2.52392646e-02f, -3.78258228e-02f, 8.96623284e-02f, -1.30597753e-02f, -4.30135392e-02f, -7.11934874e-03f,
  4.85224545e-01f, -7.70595577e-03f, 2.49317452e-01f, -6.96799606e-02f, 1.47949249e-01f, -1.45756602e-01f, 1.11212492e-01f, -7.74573907e-02f, 1.70146599e-01f, -3.43905419e-01f,
  -2.57767498e-01f, 3.76844496e-01f, -1.56520590e-01f, -2.15545654e-01f, -1.32239610e-02f, -2.92084426e-01f, -2.70466834e-01f, -1.88766653e-03f, 1.52429715e-01f, 5.33910133e-02f,
  -4.20469269e-02f, -2.74552345e-01f, -1.94739982e-01f, -3.82671431e-02f, 9.29245055e-02f, 1.55364811e-01f, -3.40418249e-01f, 1.92740664e-01f, -1.74355954e-01f, -1.14311222e-02f,
  -4.40081162e-03f, 1.23277821e-01f, 1.62273332e-01f, 1.90856624e-02f, -2.67010499e-02f, 4.25741374e-02f, 3.42817069e-03f, 1.63835406e-01f, 1.01279967e-01f, -4.15080867e-04f,
  1.04636163e-01f, 4.49231789e-02f, 9.46755521e-03f, 1.27771320e-02f, 7.63863400e-02f, 8.18521231e-02f, 4.97720018e-02f, -6.29181191e-02f, 6.53717741e-02f, -3.60770337e-02f,
  6.29793406e-02f, -1.09890856e-01f, -5.16892560e-02f, -4.16107774e-02f, 2.50295531e-02f, 2.65448764e-02f, -6.20235614e-02f, 2.20799707e-02f, -5.26216887e-02f, 1.03504825e-02f,
  -7.45561570e-02f, -7.64128789e-02f, -3.06226723e-02f, -4.55358475e-02f, 8.68186206e-02f, -1.06461331e-01f, -1.26002952e-02f, -5.20940423e-02f, 1.05764113e-01f, -8.29649717e-02f,
  -2.10937369e-03f, 2.86216009e-02f, 3.70344818e-02f, -3.81847806e-02f, -4.76936065e-02f, -1.05251893e-02f, 8.76289047e-03f, -4.95089032e-02f, -4.32195999e-02f, -1.94513965e-02f,
  2.14235969e-02f, -3.73387593e-03f, 3.71058658e-02f, -4.64053042e-02f, -6.08611703e-02f, 5.51775955e-02f, -1.28501222e-01f, -4.46968898e-02f, 1.22222202e-02f, 2.06097029e-02f,
  -2.51613081e-01f, -3.50927174e-01f, -6.15732931e-02f, 1.69734797e-03f, 6.10296465e-02f, -6.85733780e-02f, -4.18618210e-02f, -4.39550132e-02f, -2.44675092e-02f, 2.16256883e-02f,
  -9.33711380e-02f, -2.62347106e-02f, -8.77824649e-02f, 3.32978144e-02f, -5.98824173e-02f, -1.45066947e-01f, -1.01919055e-01f, 2.04149019e-02f, -9.46898162e-02f, -1.65684894e-02f,
  -1.12132035e-01f, 3.77531908e-02f, 6.52947873e-02f, 4.33066264e-02f, -5.08937985e-02f, -5.14598265e-02f, 3.15046571e-02f, 7.23780543e-02f, -2.44912244e-02f, -5.72026670e-02f,
  -5.80278754e-01f, 1.42191216e-01f, -1.31063581e-01f, -4.36753839e-01f, 7.28410408e-02f, 1.33781239e-01f, -1.36665165e-01f, 1.86642900e-01f, -2.56177127e-01f, 1.46428928e-01f,
  5.43038994e-02f, -4.61326301e-01f, 1.59181774e-01f, -2.08235472e-01f, -3.86654049e-01f, 1.15752868e-01f, -3.82078528e-01f, -3.03804785e-01f, 2.14616489e-02f, -1.71817824e-01f,
  -1.60047472e-01f, -1.47528630e-02f, 7.17673870e-03f, 3.18800867e-01f, 6.78620115e-02f, 1.03004210e-01f, 8.62520561e-02f, 2.03852087e-01f, 2.23109927e-02f, -3.89293232e-03f,
  1.37906611e-01f, -1.09128291e-02f, 8.08661208e-02f, 1.71422791e-02f, 1.38902869e-02f, 5.02803996e-02f, -7.22627789e-02f, -2.69169286e-02f, -1.41573651e-02f, 1.25799861e-05f,
  -7.55347684e-02f, -5.73465824e-02f, -4.73063961e-02f, 4.84682024e-02f, 6.69550002e-02f, 3.31724808e-02f, 3.50369653e-03f, -2.74677272e-03f, -1.06160101e-02f, -4.28914878e-04f,
  5.43364920e-02f, -4.62367870e-02f, -1.02427371e-01f, -8.46392661e-02f, -5.09736575e-02f, -1.03009924e-01f, -4.03016880e-02f, -1.63255129e-02f, -4.40778248e-02f, 6.80928491e-03f,
  -6.39733151e-02f, -5.02997823e-03f, 1.18721379e-02f, 1.14976436e-01f, 2.69932337e-02f, 2.04857197e-02f, -2.31784638e-02f, 3.07060052e-02f, -4.68463190e-02f, 4.31089811e-02f,
  3.17403413e-02f, -1.45153021e-02f, 4.16262187e-02f, -6.90369727e-03f, -1.78829730e-02f, 3.79355773e-02f, -7.14455843e-02f, 1.93672366e-02f, 1.28608197e-02f, 3.44607569e-02f,
  5.62304305e-03f, 1.52981067e-02f, 3.13418247e-02f, 8.75339359e-02f, 6.87853470e-02f, 6.38425723e-03f, -2.10558646e-03f, 4.90399599e-02f, 3.55657041e-02f, -4.73295059e-03f,
  -9.37803462e-02f, -1.57250866e-01f, 5.18165855e-03f, -8.24732408e-02f, -4.93384562e-02f, 2.64562238e-02f, -8.07562694e-02f, 4.49886732e-02f, 2.33275704e-02f, -1.19475713e-02f,
  -9.96927097e-02f, -3.53556089e-02f, 4.41377424e-02f, -9.26217660e-02f, -4.51420136e-02f, 3.93523313e-02f, -8.78766626e-02f, -7.45996311e-02f, -9.33145508e-02f, -4.14473489e-02f,
  -2.57124249e-02f, -3.26822922e-02f, 5.47148287e-02f, 1.09332725e-01f, -6.42743101e-03f, 3.92920636e-02f, -4.39554416e-02f, 4.72676428e-03f, 1.42790331e-02f, -9.77360923e-03f,
  -1.12560958e-01f, -4.12391454e-01f, 4.85659167e-02f, -2.26759285e-01f, 2.24788561e-01f, 1.89373553e-01f, 1.22843668e-01f, -5.92368729e-02f, -8.90901759e-02f, -3.71962219e-01f,
  -8.27974081e-02f, -1.32374361e-01f, -2.14089260e-01f, -3.62598270e-01f, 5.85354209e-01f, -9.73636582e-02f, -1.93043157e-01f, -1.78077742e-01f, -9.01810303e-02f, -1.19518787e-01f,
  3.38800661e-02f, -1.32165149e-01f, 7.74715543e-02f, -6.10590801e-02f, -6.40552267e-02f, 2.58514732e-02f, 1.54669359e-01f, 1.61050022e-01f, -4.11704406e-02f, 1.32456183e-01f,
  5.43545280e-03f, -1.81046784e-01f, 5.34317782e-03f, 1.93382446e-02f, -2.04646066e-02f, 6.72869477e-03f, 1.08125890e-02f, 9.57082957e-02f, 1.82262510e-01f, -2.23971419e-02f,
  -5.30058965e-02f, 5.47229014e-02f, -6.19246401e-02f, 8.06967542e-02f, -1.77855305e-02f, 2.07860917e-02f, 7.80050457e-02f, -1.68338623e-02f, -5.32755144e-02f, -3.40878777e-02f,
  -2.54678018e-02f, -5.78738973e-02f, -1.31051373e-02f, -4.37838733e-02f, 9.08202976e-02f, 5.39591070e-03f, 4.46229940e-03f, 1.21666985e-02f, -4.37220670e-02f, -5.18133119e-03f,
  -6.64343387e-02f, -2.03003287e-02f, -9.18741673e-02f, -6.01123907e-02f, -3.45675014e-02f, -1.39384437e-02f, 4.27337922e-02f, -3.97572257e-02f, 6.96134195e-02f, -2.47015003e-02f,
  -8.06347840e-03f, -1.17915112e-03f, -2.38680784e-02f, 1.11362319e-02f, -7.07772598e-02f, -1.01693273e-01f, 7.38638341e-02f, -1.08187079e-01f, -4.23365720e-02f, 4.22739685e-02f,
  2.86626001e-03f, 6.39012903e-02f, -5.69388382e-02f, 4.50774878e-02f, -2.58273882e-04f, 1.34639749e-02f, -3.75332274e-02f, -2.93628238e-02f, -3.36308964e-02f, 5.76142594e-02f,
  -1.40277471e-03f, -2.04886869e-01f, -8.39105994e-02f, -1.26254903e-02f, 2.59240046e-02f, 2.00516265e-02f, 3.82656902e-02f, -2.91562695e-02f, -5.01842499e-02f, -5.49157616e-03f,
  9.52289347e-03f, -2.76364218e-02f, -1.47283822e-02f, 9.15757660e-03f, 1.15372032e-01f, -3.73619832e-02f, -1.10479854e-01f, 2.52368376e-02f, 5.41685857e-02f, 2.81708762e-02f,
  -6.38382211e-02f, 4.01629508e-02f, -3.63181415e-03f, -9.79489461e-02f, -1.34689976e-02f, 2.45123766e-02f, 4.19715829e-02f, -1.75785348e-02f, 5.72125427e-02f, 7.69908633e-03f,
  3.55017260e-02f, 1.89963102e-01f, -1.41432092e-01f, -3.82766426e-01f, -3.24771507e-03f, 4.79472905e-01f, -2.04785645e-01f, 1.08794849e-02f, -2.94724673e-01f, 3.61932456e-01f,
  -4.75734770e-02f, -9.43273157e-02f, -2.24226534e-01f, 3.27763289e-01f, -3.72214973e-01f, -1.24581777e-01f, 3.67253959e-01f, 1.70042813e-01f, -2.02815473e-01f, -1.18156902e-01f,
  -1.38656590e-02f, 2.22601425e-02f, -9.55653116e-02f, 9.98407230e-02f, 8.90877396e-02f, 8.44169930e-02f, -2.06807956e-01f, -2.42813379e-01f, 4.90090966e-01f, 5.64455092e-02f,
  2.17840791e-01f, -1.32629961e-01f, 8.06746036e-02f, 3.93828005e-02f, 7.48440176e-02f, 5.07759042e-02f, 4.62560244e-02f, -1.98085949e-01f, -1.04001075e-01f, 2.86396649e-02f,
  -4.93311360e-02f, -4.67491448e-02f, 6.88255057e-02f, -1.08428663e-02f, 9.95332971e-02f, 2.87183896e-02f, 5.03367446e-02f, 1.41882181e-01f, -3.27868797e-02f, 9.70017817e-03f,
  -1.25470730e-02f, 1.03887349e-01f, 7.64693692e-02f, 1.16640866e-01f, -8.59773606e-02f, 3.30075733e-02f, 1.74842570e-02f, -1.67257860e-02f, 1.05536729e-01f, -2.22040415e-02f,
  3.92397344e-02f, -5.39851785e-02f, 1.00934347e-02f, -2.05883868e-02f, -1.94142424e-02f, 1.23431785e-02f, -2.80099697e-02f, 2.18860861e-02f, -1.70586761e-02f, -5.50363995e-02f,
  5.77182090e-03f, -2.66311243e-02f, 7.38026723e-02f, -4.34795069e-03f, -8.47637281e-02f, 6.92240521e-03f, -4.06523561e-03f, 5.30232601e-02f, 5.18427044e-02f, 1.40712913e-02f,
  -7.07129315e-02f, 6.46927208e-03f, -2.43014749e-02f, 3.20663713e-02f, -7.38619361e-03f, -8.57768431e-02f, 3.44510637e-02f, 8.37414264e-05f, -5.25532179e-02f, -7.30564967e-02f,
  -4.82102297e-02f, -1.26494214e-01f, 2.14019511e-03f, 3.05153336e-02f, -9.69347637e-03f, 5.77444471e-02f, -2.86343414e-02f, 1.00807533e-01f, -3.28713804e-02f, -4.31955978e-02f,
  1.18038170e-01f, -1.82012040e-02f, 6.65376261e-02f, 3.74094525e-04f, -7.05166087e-02f, 5.48171066e-03f, -3.10618319e-02f, -8.05644542e-02f, -8.36744159e-02f, 3.05817816e-02f,
  2.32780091e-02f, -3.89707647e-02f, -5.67443855e-03f, -1.59692056e-02f, 1.15900658e-01f, -3.12238988e-02f, -1.75432526e-02f, 8.61110687e-02f, -4.69439626e-02f, 2.34166868e-02f,
  -1.74324661e-01f, 4.29315120e-01f, -5.88777848e-02f, 3.52124125e-02f, -2.11751848e-01f, -2.33096331e-01f, -2.89475530e-01f, -1.50579154e-01f, 2.28791624e-01f, 2.73339506e-02f,
  -3.06599617e-01f, 4.08807158e-01f, 7.69653320e-02f, -2.69618541e-01f, -1.97893724e-01f, 2.91295648e-01f, -2.81040400e-01f, -5.27167618e-02f, 1.83139116e-01f, -3.71733010e-02f,
  6.03867993e-02f, -1.42288536e-01f, -3.06799226e-02f, 8.68174061e-03f, -1.39766619e-01f, -2.43726671e-02f, -2.56723285e-01f, 1.14393301e-01f, -2.97895372e-01f, -1.07658088e-01f,
  -6.94070533e-02f, 9.78059247e-02f, -5.58955334e-02f, -7.16550648e-03f, -9.91163924e-02f, -8.68085697e-02f, -1.13402143e-01f, -8.69134441e-03f, -8.58207941e-02f, -1.17248120e-02f,
  1.71430837e-02f, 2.84089036e-02f, 3.57473604e-02f, 7.06218407e-02f, -5.60374409e-02f, 3.22018526e-02f, 1.92633495e-02f, -1.38115853e-01f, 7.78815672e-02f, 5.95371090e-02f,
  6.81630895e-02f, 7.14262296e-03f, -1.27635077e-01f, -9.53623559e-03f, 3.27837467e-02f, 3.33880559e-02f, 2.01721732e-02f, -1.06140003e-02f, -9.56636220e-02f, 3.83007643e-03f,
  1.62130147e-02f, 5.72448894e-02f, 5.68853784e-03f, -1.00114681e-01f, 1.47612184e-01f, -6.91306964e-02f, 8.07922054e-03f, 5.68480492e-02f, -1.58947706e-02f, 4.60465401e-02f,
  -9.92384776e-02f, -1.10329844e-01f, -7.04076216e-02f, -1.25396606e-02f, 1.53472098e-02f, -9.81044844e-02f, 6.04016148e-03f, 1.72614008e-02f, 1.33003537e-02f, -4.55175377e-02f,
  6.83198199e-02f, 1.13140270e-02f, 1.14623919e-01f, -1.35507276e-02f, -4.36849706e-02f, -1.85822193e-02f, 1.87515672e-02f, 5.26033007e-02f, -1.27731366e-02f, -1.19924806e-01f,
  6.77367449e-02f, 2.69503683e-01f, 6.23629503e-02f, 1.70170218e-02f, 8.18498805e-02f, 1.89880915e-02f, 6.38260171e-02f, 1.33640002e-02f, 1.06605664e-01f, -4.16165628e-02f,
  -2.73446087e-02f, -8.50634277e-02f, -6.08807616e-02f, -1.04708724e-01f, 4.26473543e-02f, -1.48499552e-02f, 3.13021205e-02f, -4.80814762e-02f, -1.32777885e-01f, -3.48768495e-02f,
  -1.91772748e-02f, -8.32886845e-02f, 7.65682757e-02f, 3.53796184e-02f, -6.43163323e-02f, -8.11116993e-02f, 3.55375074e-02f, 5.19176312e-02f, -1.20987343e-02f, -3.57669708e-03f,
  2.37861335e-01f, 5.39760053e-01f, 1.94418803e-01f, 3.74207824e-01f, -2.80247927e-01f, -3.27740282e-01f, -8.67833570e-03f, 8.45300704e-02f, 4.44656849e-01f, 1.68264240e-01f,
  -2.09793597e-01f, 3.49377215e-01f, 2.84067728e-02f, 1.67081747e-02f, -2.12132573e-01f, 1.53153375e-01f, -1.50522619e-01f, -4.82364073e-02f, -6.32226001e-03f, -1.01498496e-02f,
  -1.24150760e-01f, -3.21204782e-01f, -2.88176507e-01f, -1.63887113e-01f, -1.88535661e-01f, 1.05206594e-01f, -2.29028434e-01f, -1.19312266e-02f, -1.11904815e-01f, 1.76243782e-02f,
  -1.34037167e-01f, 1.20610498e-01f, 9.77646858e-02f, 4.53879051e-02f, -1.27481073e-01f, -6.09076172e-02f, -5.01025282e-02f, -2.92511117e-02f, -2.90915277e-02f, 2.25757668e-03f,
  9.96555015e-02f, -6.90262094e-02f, -4.29647975e-03f, 3.84621620e-02f, 1.06560044e-01f, 8.17399472e-02f, 1.11374166e-03f, -5.69220297e-02f, 2.38256082e-02f, -3.18258069e-02f,
  -2.71266941e-02f, -2.10410058e-02f, -1.78964268e-02f, -2.42773397e-03f, -1.38267512e-02f, 6.79461285e-03f, -3.94638330e-02f, -1.03064895e-01f, 1.42031953e-01f, 6.14566170e-02f,
  -3.21943238e-02f, -1.45481983e-02f, -3.48268226e-02f, 7.16429725e-02f, -1.69111900e-02f, 1.91560145e-02f, -3.33952461e-03f, -4.71903160e-02f, 9.22373123e-03f, 1.94910336e-02f,
  -6.79499982e-03f, 6.92268237e-02f, 3.87681462e-02f, 5.41676814e-03f, -4.71491106e-02f, 8.74158517e-02f, -3.56711037e-02f, 2.60216109e-02f, 1.33599844e-02f, -4.70692366e-02f,
  9.17992294e-02f, -6.73877250e-04f, -6.44249022e-02f, -3.00892852e-02f, 5.90102514e-03f, -1.12929612e-01f, 8.54843408e-02f, 4.60989736e-02f, -2.82109845e-02f, -3.35454419e-02f,
  -1.27984792e-01f, 1.83697894e-01f, 1.01382537e-02f, -9.46637522e-03f, 9.52407122e-02f, -1.21115893e-02f, 1.11963086e-01f, 3.69527377e-02f, -3.26706609e-03f, 2.12109480e-02f,
  -1.65364981e-01f, -3.27924863e-02f, 7.01494440e-02f, -8.35008770e-02f, -5.77851236e-02f, -4.56583202e-02f, -4.75363893e-04f, 9.22615547e-03f, 2.53860950e-02f, -4.92939316e-02f,
  -3.78317684e-02f, -1.22281663e-01f, 9.56566185e-02f, -5.28677590e-02f, -8.67813006e-02f, -1.11471657e-02f, -2.26123468e-03f, 1.46917664e-02f, -7.74783194e-02f, 1.32810712e-01f,
  6.92718446e-01f, 2.83787012e-01f, 1.86472952e-01f, 4.78074551e-01f, 2.35335603e-01f, -3.93961757e-01f, -3.93351704e-01f, 2.94485927e-01f, 2.39919618e-01f, -2.12311640e-01f,
  5.21792993e-02f, 1.15936808e-01f, -3.47777873e-01f, 3.53323787e-01f, 3.89763899e-02f, -8.55910555e-02f, 1.79586813e-01f, 9.43271667e-02f, -6.10074177e-02f, 1.69373155e-01f,
  2.46838614e-01f, 2.55480468e-01f, 1.71321243e-01f, 5.12823500e-02f, 1.81705773e-01f, 1.31707892e-01f, -6.33893311e-02f, -9.45858583e-02f, 3.66746299e-02f, -4.60778028e-02f,
  3.69411483e-02f, 1.67109475e-01f, 9.90867764e-02f, -2.82480214e-02f, 7.21621141e-02f, -6.86409846e-02f, -1.45872280e-01f, -9.24896449e-02f, -3.17987353e-02f, -9.19976383e-02f,
  -6.63155392e-02f, 2.37988234e-02f, -2.05333009e-02f, 7.07630115e-03f, 7.54361302e-02f, 3.31576541e-02f, 5.06925024e-02f, 4.79961634e-02f, 7.21507072e-02f, 1.38311908e-01f,
  6.34146929e-02f, 5.72190210e-02f, 9.32123289e-02f, -2.66116299e-02f, 2.45445464e-02f, 3.78648960e-03f, -5.67752831e-02f, -4.76115644e-02f, -1.97506845e-02f, 1.89865194e-02f,
  3.26299891e-02f, -8.15511271e-02f, 2.72712279e-02f, 1.37357619e-02f, -4.56124432e-02f, -2.31942125e-02f, -4.27588448e-02f, -5.33035100e-02f, -1.18370419e-02f, -6.23889752e-02f,
  8.55884477e-02f, 1.32868648e-01f, 3.93370874e-02f, -1.10875228e-02f, 1.73051283e-02f, -7.68751139e-03f, -9.85110831e-03f, -3.02030873e-02f, 7.07719624e-02f, 3.49831628e-03f,
  -8.16268697e-02f, -2.34880745e-02f, -2.71651428e-02f, -3.71604301e-02f, -1.39518768e-01f, 1.15019772e-02f, 8.26324522e-02f, 8.22405890e-02f, -9.83959362e-02f, -2.55254637e-02f,
  -1.13145776e-01f, -1.40197143e-01f, -7.89622143e-02f, 1.20132109e-02f, -1.09235778e-01f, 7.36144418e-03f, 9.40567702e-02f, 9.80009735e-02f, -1.03027299e-01f, -8.69936869e-03f,
  2.18884237e-02f, -5.26569113e-02f, -8.25905204e-02f, 5.83937168e-02f, -7.84254298e-02f, 5.12203537e-02f, -7.79677555e-02f, -8.70420784e-02f, -1.41020510e-02f, -3.42227407e-02f,
  -5.90747334e-02f, -1.69364572e-01f, -1.17724523e-01f, -1.45316087e-02f, 2.37455051e-02f, -5.93237542e-02f, 1.22215174e-01f, 4.29539084e-02f, 3.79734416e-03f, -3.45775746e-02f,
  2.98236400e-01f, -2.84297824e-01f, 2.96288192e-01f, -6.04193136e-02f, 3.68933827e-01f, 2.79035717e-01f, 1.22349709e-01f, 1.23436466e-01f, -1.47046313e-01f, -3.41911495e-01f,
  -4.54180799e-02f, 1.24254450e-01f, -5.80200627e-02f, -1.00773714e-01f, 4.71480340e-01f, -2.03648269e-01f, -1.65582970e-01f, -2.28549987e-01f, 7.93440174e-03f, -5.86257614e-02f,
  1.92236453e-01f, -4.24117558e-02f, 3.97471100e-01f, -1.81652997e-02f, 2.91875690e-01f, 8.12764689e-02f, -1.47975922e-01f, 5.68949617e-02f, 8.86469781e-02f, 2.08093569e-01f,
  1.03474325e-02f, -3.78448814e-02f, 1.19576022e-01f, 6.61141053e-02f, 1.20340057e-01f, 2.20315754e-02f, -6.75709471e-02f, 3.76991741e-02f, 8.15270916e-02f, 1.01138428e-01f,
  -6.28019124e-02f, 1.08861640e-01f, 8.14199820e-02f, -1.86974872e-02f, 7.47577026e-02f, 3.84305306e-02f, 1.33426204e-01f, 6.29806072e-02f, 8.66805762e-02f, 2.09266871e-01f,
  1.92433193e-01f, 1.45953566e-01f, 2.58746948e-02f, -7.63515830e-02f, 1.57535866e-01f, 3.52906995e-02f, 7.43025215e-03f, 1.12956151e-01f, 6.42334018e-03f, 8.03574845e-02f,
  -8.80133137e-02f, -1.28917238e-02f, 1.29613310e-01f, 3.11251413e-02f, 5.06626396e-03f, -3.92331369e-03f, -1.61954209e-01f, 2.28210967e-02f, 3.82725261e-02f, -1.51490597e-02f,
  -1.59855373e-02f, 2.48574209e-03f, -5.72020486e-02f, 2.92383246e-02f, -2.70690322e-02f, -3.59931551e-02f, -2.90822685e-02f, 4.07994986e-02f, 1.84906716e-03f, 6.00830242e-02f,
  -8.18865076e-02f, -1.51124289e-02f, -7.54890442e-02f, 7.93379173e-03f, -7.51974732e-02f, 7.67916143e-02f, 8.70387182e-02f, 5.09671494e-02f, -1.04969740e-02f, 6.19831271e-02f,
  -1.83184043e-01f, -2.84917623e-01f, -7.51313567e-02f, -3.67807969e-02f, -2.02016443e-01f, -1.04646690e-01f, -1.73980035e-02f, -2.14112699e-02f, -5.18608801e-02f, -5.96551076e-02f,
  7.24694058e-02f, -2.85824481e-02f, -8.94632190e-02f, -5.55124227e-03f, -3.24320234e-02f, 2.03197822e-02f, -1.53553724e-01f, -6.53284863e-02f, -2.41794493e-02f, -5.37044294e-02f,
  2.18194798e-02f, -2.43469439e-02f, 6.74106181e-02f, 6.95193484e-02f, -1.19769551e-01f, 2.09141392e-02f, -9.54144634e-03f, 3.77703905e-02f, 1.00731499e-01f, -1.00109912e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -6.06659114e-01f, 1.50395587e-01f, 1.43726587e-01f, -4.11822379e-01f, -3.22676212e-01f, 7.43418097e-01f, 7.38967299e-01f, -7.92012960e-02f, -3.55659604e-01f, 5.46471179e-01f,
  5.21007478e-01f, -2.11986870e-01f, 6.08616650e-01f, 4.07034576e-01f, 4.64682102e-01f, 7.27446795e-01f, 4.97946411e-01f, 2.69530475e-01f, -2.64539570e-01f, -2.05766991e-01f,
  -1.87018469e-01f, 2.75526524e-01f, 6.23357594e-01f, -4.02837157e-01f, 8.78258869e-02f, -5.59631407e-01f, -1.28844067e-01f, -7.32553825e-02f, -9.57817435e-02f, 2.64113992e-01f,
  1.58662170e-01f, -3.52733403e-01f, -7.28168488e-02f, -2.95932442e-02f, 3.63876224e-02f, -1.91016316e-01f, 2.28886362e-02f, 1.94346592e-01f, -1.48941368e-01f, -1.03016347e-02f,
  -2.33245194e-02f, -2.09544785e-02f, -1.45630851e-01f, -9.51338410e-02f, -1.75356001e-01f, -7.93872178e-02f, -2.72081066e-02f, 8.73304754e-02f, 2.02671494e-02f, 1.42850682e-01f,
  1.40914142e-01f, 5.67816943e-02f, 1.54053271e-01f, 8.09244290e-02f, 8.10476094e-02f, -1.05942935e-02f, 6.84661195e-02f, 1.35332733e-01f, 8.10748860e-02f, 7.98284113e-02f,
  2.31395196e-02f, 2.82949451e-02f, -3.97611037e-03f, 4.54549193e-02f, 6.62286431e-02f, 1.09432824e-02f, -8.50866809e-02f, 9.73177478e-02f, 7.09142722e-03f, 1.57025918e-01f,
  -3.31294946e-02f, -5.54072596e-02f, -2.68920437e-02f, 4.61987182e-02f, -1.27137795e-01f, -1.30746171e-01f, 7.16679692e-02f, -1.17123216e-01f, -6.80709258e-02f, 4.57673483e-02f,
  -1.01951167e-01f, 4.11258787e-02f, 1.19793221e-01f, -1.11285774e-02f, 2.15554591e-02f, 4.22182307e-02f, 1.52573613e-02f, 1.63448095e-01f, 2.21226271e-02f, 1.56758353e-02f,
  5.48555143e-02f, -3.96656305e-01f, -2.84864418e-02f, -3.93704735e-02f, 5.79127902e-03f, 8.33106786e-02f, -2.69401502e-02f, 1.63592193e-02f, 9.35965553e-02f, -9.86322761e-02f,
  -1.66189536e-01f, -7.31278658e-02f, -1.00465320e-01f, -9.35269222e-02f, -2.87778284e-02f, 8.12171102e-02f, 5.31850606e-02f, -1.86688662e-01f, 1.30764350e-01f, -8.60520825e-02f,
  -1.65535472e-02f, -3.96749191e-02f, 8.41011927e-02f, -1.44272372e-02f, -9.31609869e-02f, 1.67221710e-01f, -2.31765002e-01f, -1.86538607e-01f, 2.22385414e-02f, 1.31760925e-01f,
  8.69768679e-01f, -7.00992167e-01f, -1.23585626e-01f, 1.69343159e-01f, 2.55481809e-01f, -6.69521391e-01f, 1.39683917e-01f, -4.45677638e-01f, 1.97842121e-01f, -6.03423536e-01f,
  -7.37762973e-02f, 2.72170007e-01f, 3.15157056e-01f, -5.83670557e-01f, 4.94344056e-01f, 3.55981052e-01f, -5.84133863e-01f, -2.25836217e-01f, 1.20746210e-01f, -2.14279607e-01f,
  1.65193498e-01f, -2.72874683e-01f, 9.61648002e-02f, -6.13124609e-01f, -7.55350068e-02f, -1.45657614e-01f, -5.65958470e-02f, 2.39047557e-01f, -5.58822989e-01f, 2.70379126e-01f,
  -7.76050016e-02f, 1.46631941e-01f, 9.12418310e-03f, -6.25986839e-03f, -1.00346863e-01f, 6.14584237e-02f, 1.52274981e-01f, 3.46080452e-01f, 5.18364944e-02f, -7.57039636e-02f,
  1.99748054e-01f, 3.26224342e-02f, -1.19047716e-01f, 1.48754075e-01f, -5.19884974e-02f, -1.37272939e-01f, -6.80101942e-03f, -4.34477665e-02f, -1.44634902e-01f, 8.10754448e-02f,
  7.81275034e-02f, 3.48307528e-02f, 8.91130716e-02f, -5.67549802e-02f, 1.22099891e-01f, -1.30918818e-02f, -1.04209870e-01f, 1.28511608e-01f, -1.59787722e-02f, -2.17252448e-01f,
  -3.60137820e-02f, -3.14196735e-03f, 1.19883671e-01f, -2.47111116e-02f, 6.38097599e-02f, 3.98433730e-02f, -3.01730223e-02f, -2.91169970e-03f, 1.69059500e-01f, -3.16951834e-02f,
  -2.23580729e-02f, 7.90553614e-02f, 4.91046347e-03f, -1.05869800e-01f, 6.00278527e-02f, 5.13147116e-02f, 9.20919105e-02f, 3.33986804e-02f, 1.53696379e-02f, -8.57673809e-02f,
  1.81574747e-01f, -6.75240234e-02f, 1.42123727e-02f, 8.52043033e-02f, -3.82344015e-02f, 1.49935722e-01f, -9.85436440e-02f, -2.01088041e-02f, -1.09765053e-01f, 4.87186238e-02f,
  -4.15150821e-01f, -4.92816210e-01f, 3.63537446e-02f, -4.82616648e-02f, -1.44035652e-01f, 3.88589650e-02f, 6.24258034e-02f, -1.69024676e-01f, -1.09338492e-01f, -1.51590463e-02f,
  -2.47229338e-01f, 1.52239159e-01f, -4.78582270e-02f, -1.55880200e-02f, -8.91656801e-02f, -1.65821448e-01f, 3.11042415e-03f, 5.63441552e-02f, 1.32776111e-01f, -1.12454474e-01f,
  -5.12056500e-02f, 4.51644249e-02f, 1.14454374e-01f, -1.10334471e-01f, -9.48315710e-02f, 1.59411520e-01f, -1.40336946e-01f, 7.53014758e-02f, 7.07289577e-03f, 7.78011396e-04f,
  -1.36952832e-01f, -8.79707783e-02f, -7.06206679e-01f, -4.88360763e-01f, -2.38079801e-01f, -4.17637438e-01f, -5.57807624e-01f, -9.96843725e-02f, 1.65628836e-01f, 2.21337751e-01f,
  -1.78817138e-01f, 1.36446059e-01f, 6.78579569e-01f, -6.04337573e-01f, -2.65944153e-01f, 2.40620404e-01f, -8.30794692e-01f, -4.60071266e-01f, 1.35024890e-01f, -2.78778434e-01f,
  -1.27215564e-01f, -6.79605678e-02f, -5.31639755e-01f, 3.20788413e-01f, -5.22753537e-01f, -1.94612712e-01f, 2.18534134e-02f, -4.07094546e-02f, -6.02788091e-01f, -1.16880231e-01f,
  -1.42962024e-01f, 2.04329625e-01f, -3.22753012e-01f, -2.29817424e-02f, -2.57761210e-01f, 8.74280743e-03f, -1.99909374e-01f, -1.39278071e-02f, -5.48130535e-02f, -1.03341946e-02f,
  8.83607045e-02f, 4.24020708e-01f, 1.86760947e-02f, 1.41188055e-01f, 6.16991036e-02f, -6.07483573e-02f, 3.06315329e-02f, -3.14542502e-01f, 4.34160344e-02f, -1.03746332e-01f,
  -1.62017822e-01f, -9.44392532e-02f, -1.36418745e-01f, -2.84226686e-02f, -1.40234306e-01f, -1.50571344e-02f, -1.40431419e-01f, -2.82894284e-01f, -8.71039629e-02f, -2.56486144e-02f,
  -2.89823543e-02f, -2.52259355e-02f, 5.74211590e-03f, 8.81995708e-02f, -4.87766415e-02f, -1.77444205e-01f, 9.34540480e-02f, 3.51308323e-02f, 7.60972425e-02f, -1.21215478e-01f,
  4.44257539e-03f, -9.86100882e-02f, 1.63238078e-01f, -1.36178598e-01f, -1.83357462e-01f, 7.79525563e-02f, 1.68318808e-01f, 4.23721522e-02f, -2.29239509e-01f, -8.24291445e-03f,
  6.71906993e-02f, 1.08620757e-03f, 2.25801587e-01f, 1.28278941e-01f, -1.41739035e-02f, 8.98423418e-02f, 7.25981370e-02f, -1.31660625e-01f, 1.89428292e-02f, 3.03147640e-02f,
  -1.63074419e-01f, 3.78930680e-02f, 5.24902157e-02f, 6.87564760e-02f, -1.51235789e-01f, -3.30052786e-02f, -1.54310495e-01f, -1.67838022e-01f, -1.78890675e-01f, 2.06026167e-01f,
  2.48827655e-02f, -1.47927245e-02f, 4.10572477e-02f, 1.60372704e-02f, -1.36037394e-02f, -5.02679311e-02f, -3.51758488e-02f, -2.47428492e-02f, 6.96694478e-03f, 2.11636582e-03f,
  1.50113836e-01f, 2.93902099e-01f, 1.32984426e-02f, 2.34609507e-02f, -1.10389979e-03f, 3.53587605e-03f, 5.22923507e-02f, -3.02564520e-02f, 5.13820983e-02f, -1.06706314e-01f,
  5.18664062e-01f, -3.33060086e-01f, 4.88782257e-01f, 4.30442065e-01f, 3.89305413e-01f, 3.43665868e-01f, 5.47468245e-01f, 2.16100976e-01f, 8.81205201e-01f, -5.01283586e-01f,
  -4.80512112e-01f, -2.65938729e-01f, 1.74633324e-01f, -5.37772596e-01f, 4.40342695e-01f, 3.17858487e-01f, 8.24118704e-02f, -1.74678162e-01f, 2.56253183e-01f, -2.47357562e-02f,
  1.15155973e-01f, -4.94066834e-01f, -1.27400786e-01f, -4.99635071e-01f, -2.56796420e-01f, -1.36963829e-01f, -5.21410644e-01f, -1.07892081e-02f, -7.53114045e-01f, -2.20553830e-01f,
  5.07595502e-02f, -5.30193374e-02f, -4.69140299e-02f, -2.52163243e-02f, 1.25106350e-01f, 2.94949394e-02f, -1.72411233e-01f, 1.14305895e-02f, 2.31410280e-01f, 6.33429140e-02f,
  -1.14414908e-01f, -1.75007343e-01f, -2.06183076e-01f, 5.27600665e-03f, 8.22525620e-02f, -9.93100628e-02f, 4.24332283e-02f, -7.14255050e-02f, -6.50810683e-03f, 7.81079456e-02f,
  4.40618619e-02f, 6.49657175e-02f, -2.69346815e-02f, -1.41892731e-01f, -2.26339325e-02f, -3.37663032e-02f, 5.73127791e-02f, -3.39916572e-02f, -1.36887953e-02f, 1.41599983e-01f,
  -1.41428858e-01f, 2.52721518e-01f, -9.23241302e-02f, 6.05007932e-02f, -1.37395605e-01f, 2.53546834e-02f, -1.43480450e-01f, -1.15149096e-01f, 6.51335567e-02f, -1.15150914e-01f,
  -4.37255166e-02f, 2.68955920e-02f, 2.40314323e-02f, 6.89480975e-02f, -2.12493632e-03f, 8.71894136e-02f, -2.74143126e-02f, -9.55528393e-02f, 6.50366247e-02f, 7.85317719e-02f,
  -1.33005694e-01f, -4.62081321e-02f, -2.65949499e-02f, 3.87576688e-03f, 5.13701588e-02f, 3.04834042e-02f, -2.04517305e-01f, 3.88664715e-02f, 2.00267255e-01f, -5.06747849e-02f,
  -1.28929317e-01f, -1.68859661e-01f, -2.06425432e-02f, -1.07143171e-01f, 8.99421275e-02f, -2.27325320e-01f, -1.15297697e-02f, -6.36897162e-02f, 1.04719326e-01f, 5.26993088e-02f,
  -1.18890643e-01f, 1.58484243e-02f, -4.07782756e-02f, 7.03216642e-02f, 2.27792468e-02f, -3.39261256e-02f, -5.30941300e-02f, -2.02103220e-02f, 1.49678607e-02f, -1.93569809e-01f,
  -1.06404319e-01f, -6.12450298e-03f, -2.80454587e-02f, -7.73483440e-02f, -2.90481634e-02f, -1.05396993e-01f, 8.36667120e-02f, -3.06024291e-02f, -1.32508934e-01f, 7.20934346e-02f,
  -1.03982836e-01f, -4.88053471e-01f, 3.54804881e-02f, -5.30149639e-01f, 2.21563548e-01f, -5.39307371e-02f, -1.44992396e-01f, -4.15831685e-01f, -6.32644594e-01f, -3.09026718e-01f,
  -2.67858535e-01f, 1.07508928e-01f, 3.69286269e-01f, -6.68437481e-01f, 2.81028837e-01f, -1.17771432e-01f, -5.75459242e-01f, -2.16913134e-01f, -1.25714749e-01f, -3.04119557e-01f,
  -1.23105913e-01f, -5.52756727e-01f, 4.52088676e-02f, -4.28437740e-01f, -3.72842729e-01f, -1.17700279e-01f, 2.53920346e-01f, 2.13560179e-01f, -2.58858979e-01f, -4.67836261e-02f,
  -1.27179787e-01f, -2.81623274e-01f, 1.36910903e-03f, -9.15717781e-02f, 5.24543785e-02f, 1.79819688e-01f, 2.26535350e-01f, 2.28526648e-02f, -2.63188779e-03f, 1.31536037e-01f,
  8.95107239e-02f, 3.95417549e-02f, -8.25332403e-02f, 1.58647388e-01f, -8.59613270e-02f, -2.35849228e-02f, -3.88911813e-02f, -3.00974213e-02f, -1.00291997e-01f, 2.07136548e-03f,
  4.39194813e-02f, 1.49706647e-01f, -5.73548637e-02f, 4.20044027e-02f, 6.45728335e-02f, -1.08740993e-01f, 2.36788556e-01f, 2.96174139e-01f, 2.92287068e-03f, -4.59419154e-02f,
  1.29561275e-02f, 1.91463977e-01f, 4.59927246e-02f, -6.25671521e-02f, 5.04398905e-03f, -1.12651981e-01f, -1.84040796e-02f, -1.28601110e-02f, -3.16884443e-02f, -9.48678255e-02f,
  -2.41082185e-03f, -3.62011977e-02f, -6.31491840e-02f, -1.02872752e-01f, 2.94156410e-02f, -5.48394546e-02f, 1.67564720e-01f, 6.75943075e-03f, -7.35307112e-02f, 7.13489158e-03f,
  -8.68853405e-02f, -8.48729461e-02f, 2.94978134e-02f, -4.18415628e-02f, -3.95602882e-02f, 8.87474418e-02f, -3.30359302e-02f, 8.66731927e-02f, -1.38173960e-02f, 7.60029256e-02f,
  2.94616148e-02f, -1.05950490e-01f, -9.36856270e-02f, 3.89483981e-02f, 9.50894505e-02f, 1.05616510e-01f, -1.25014707e-01f, -1.65200725e-01f, -1.56070655e-02f, -1.01296462e-01f,
  5.48737794e-02f, 4.34178393e-04f, 4.19304892e-02f, -3.33573259e-02f, -1.26619771e-01f, -7.69201592e-02f, 1.41076064e-02f, 9.34575349e-02f, -2.10122056e-02f, 6.38022646e-02f,
  -5.21208532e-03f, 3.23819406e-02f, 3.43682915e-02f, -1.16445180e-02f, -8.32860917e-02f, 6.61846995e-02f, -1.88598670e-02f, -4.09906358e-02f, 9.49732587e-03f, -6.26834407e-02f,
  -9.45668280e-01f, 9.05570030e-01f, 7.39156365e-01f, -5.60455918e-01f, 3.05535972e-01f, 5.23051739e-01f, -5.70321918e-01f, 4.49496120e-01f, 2.04134341e-02f, -2.29885697e-01f,
  -2.07879364e-01f, 2.67189145e-01f, 1.58207119e-01f, -7.62897208e-02f, -3.13247651e-01f, 1.48101732e-01f, -2.60786325e-01f, -2.82902300e-01f, 3.12603414e-01f, -3.02480459e-02f,
  4.51854877e-02f, -3.91663373e-01f, 1.94759890e-01f, 3.41457278e-01f, 6.50773495e-02f, -3.95200364e-02f, -7.36376524e-01f, 2.95312852e-01f, -1.38561100e-01f, 1.17679633e-01f,
  6.33203015e-02f, -1.56676307e-01f, 1.38398960e-01f, 1.65175319e-01f, 3.08425948e-02f, -5.96533120e-02f, -1.31101742e-01f, 2.23171990e-02f, -1.02825955e-01f, 1.16812825e-01f,
  8.30325335e-02f, 1.29078448e-01f, -4.48735319e-02f, 7.60130808e-02f, 2.16058036e-03f, 7.50633106e-02f, 2.20780879e-01f, 1.88344583e-01f, 1.57318473e-01f, 2.89890349e-01f,
  3.81683290e-01f, 2.64403015e-01f, 4.54320796e-02f, -1.52732432e-01f, 9.74737629e-02f, -2.10770639e-03f, -1.37823178e-02f, 3.91366482e-02f, 9.83901843e-02f, 6.30641729e-02f,
  7.54209533e-02f, -1.66940778e-01f, -3.80554311e-02f, -3.60752121e-02f, 1.20994924e-02f, 3.51317110e-03f, 8.27675238e-02f, -1.38959244e-01f, 6.58690333e-02f, -1.34160876e-01f,
  -2.34583303e-01f, -4.30645011e-02f, -4.54231501e-02f, -1.62732691e-01f, -1.24009429e-02f, -6.66692108e-02f, -1.16191089e-01f, -3.99819855e-03f, -2.08623298e-02f, -7.02157691e-02f,
  -6.66146502e-02f, -1.18603803e-01f, 5.54431230e-02f, -1.25586182e-01f, 7.27848634e-02f, 1.68648232e-02f, 1.00375891e-01f, 7.87638277e-02f, -4.07163240e-02f, -8.89421403e-02f,
  -2.03414068e-01f, -3.25921744e-01f, -2.53346600e-02f, 1.51226655e-01f, -8.52503255e-02f, 8.07066485e-02f, 3.21779624e-02f, -2.35949233e-02f, -4.63583767e-02f, 2.87759211e-02f,
  -6.65742755e-02f, -1.51911601e-01f, -3.38921212e-02f, -1.50739197e-02f, -6.15547970e-02f, -1.70145389e-02f, -2.96899408e-01f, -1.15003482e-01f, -2.00096682e-01f, 5.90171963e-02f,
  2.10948214e-02f, -2.19628625e-02f, -1.56686217e-01f, -7.57112354e-02f, -1.41014472e-01f, -1.63266122e-01f, -1.94102898e-01f, 1.11794733e-01f, -4.08398174e-02f, 8.73958170e-02f,
  -1.32680997e-01f, -9.23962593e-01f, 1.58586681e-01f, 2.89441437e-01f, 2.24365175e-01f, 2.87368298e-01f, 4.68536586e-01f, -2.89938211e-01f, -4.23564732e-01f, -4.83419538e-01f,
  3.67046207e-01f, -3.14933598e-01f, 2.52687782e-02f, 2.50278205e-01f, 3.89874846e-01f, -4.74678352e-02f, 2.68647462e-01f, 6.84829354e-02f, -7.80704618e-02f, -1.51209414e-01f,
  2.55131364e-01f, 3.19002539e-01f, 2.71085650e-01f, -3.49740922e-01f, 9.34173390e-02f, -2.84097135e-01f, 2.04881802e-01f, -5.46369776e-02f, 1.20755211e-01f, 2.62741774e-01f,
  -1.21192664e-01f, -3.59177947e-01f, 2.15721622e-01f, -1.53587729e-01f, -4.20704894e-02f, -1.27048104e-03f, 1.07026406e-01f, 1.56770647e-01f, 8.26675668e-02f, 2.44038142e-02f,
  5.96681144e-03f, -2.01675687e-02f, 1.27543844e-02f, 4.20048349e-02f, -9.98606980e-02f, -1.58918247e-01f, -8.57964680e-02f, 3.49080116e-02f, -1.44254223e-01f, 4.89579104e-02f,
  2.06154957e-02f, 4.10589464e-02f, 3.07378098e-02f, -5.12161590e-02f, -1.00145638e-02f, 2.63767764e-02f, 1.32750452e-01f, -1.46318063e-01f, -7.79482275e-02f, -1.04868442e-01f,
  -1.68635979e-01f, -8.12768713e-02f, -1.03991076e-01f, 1.13045275e-02f, 1.48199359e-02f, 1.58037901e-01f, 5.61582819e-02f, 3.52108181e-02f, -3.41475829e-02f, 2.57040141e-03f,
  1.57332301e-01f, -1.50679424e-01f, -2.24165116e-02f, 3.44123468e-02f, 7.03672841e-02f, 1.42432168e-01f, 2.72498224e-02f, 6.11438118e-02f, -5.38380183e-02f, 7.40367845e-02f,
  5.20228669e-02f, 6.25007674e-02f, -1.50957722e-02f, 9.28596109e-02f, -9.35582444e-02f, -6.89423531e-02f, 6.81717470e-02f, -4.71414402e-02f, 9.09758639e-03f, 1.23421289e-01f,
  -6.17977202e-01f, -7.89946854e-01f, -8.32842439e-02f, 4.96851169e-02f, -2.71584503e-02f, -1.38321772e-01f, 1.50643205e-02f, -1.76306874e-01f, -5.08069247e-02f, -3.01018022e-02f,
  -1.63697228e-02f, 2.00370789e-01f, -1.03820004e-01f, 1.55918263e-02f, 2.42392495e-02f, -1.40739396e-01f, -6.41253442e-02f, -1.92713421e-02f, -3.29240300e-02f, -1.13952391e-01f,
  -1.37334615e-01f, -1.41293645e-01f, 1.65052041e-01f, 1.63186062e-03f, 1.51294889e-02f, 2.12889481e-02f, -1.57111570e-01f, 1.85208265e-02f, 2.97333882e-03f, -9.83325318e-02f,
  5.04614078e-02f, 2.93184221e-01f, -6.11121906e-03f, -1.23329144e-02f, -6.32033199e-02f, -4.47845459e-01f, -3.60877931e-01f, 2.27470621e-01f, -4.56801593e-01f, 4.25583750e-01f,
  5.74995242e-02f, -1.96962282e-01f, -4.32704389e-02f, -3.71670663e-01f, -7.34406233e-01f, -5.65208197e-01f, -1.50427416e-01f, -3.62126321e-01f, -3.52141708e-01f, 5.34578145e-01f,
  1.20929135e-02f, -5.51237948e-02f, 3.28803807e-02f, 5.47378600e-01f, 3.86419296e-01f, 6.65839016e-01f, 7.12663770e-01f, 4.00818288e-01f, 4.96059835e-01f, -2.49983013e-01f,
  -1.61380917e-01f, 2.57671997e-02f, -7.41489083e-02f, -1.31098375e-01f, 2.01926202e-01f, 3.05724651e-01f, 1.04388997e-01f, -1.12309210e-01f, -1.57855853e-01f, -6.50664791e-02f,
  6.26013428e-02f, -8.96769203e-03f, -3.05845533e-02f, -1.37058973e-01f, 2.47316007e-02f, -4.08525169e-02f, -8.10523108e-02f, -1.83740541e-01f, -4.02798057e-02f, -3.48908305e-02f,
  -3.29162888e-02f, 3.07301115e-02f, 1.11755006e-01f, -1.04764653e-02f, 7.95167983e-02f, 6.22678846e-02f, 3.69046442e-02f, 1.44266352e-01f, -2.41263974e-02f, 4.00911644e-02f,
  1.47309259e-01f, 9.44418758e-02f, -2.85224020e-02f, -3.20075154e-01f, -1.57064557e-01f, 5.66018187e-02f, -6.06602021e-02f, -4.35622260e-02f, -2.21856665e-02f, 1.51517421e-01f,
  1.07774055e-02f, -1.24290578e-01f, -1.38726443e-01f, 1.43703684e-01f, 1.60025075e-01f, -1.61232293e-01f, -1.53248664e-02f, 9.97054204e-02f, 4.25451845e-02f, -1.27039686e-01f,
  -6.44928887e-02f, 3.18205282e-02f, 8.88751894e-02f, 1.36934534e-01f, -1.86670914e-01f, 1.41797736e-01f, 1.28662705e-01f, -6.15614429e-02f, -5.17214388e-02f, -6.08091876e-02f,
  3.95599231e-02f, 5.20331681e-01f, -3.90944742e-02f, -1.51286766e-01f, -2.57771108e-02f, -1.60243940e-02f, -1.56785160e-01f, -3.99737656e-02f, 1.66675985e-01f, 6.98748454e-02f,
  3.66838545e-01f, 9.49939340e-02f, 1.39186308e-01f, -5.21535985e-02f, 1.07370708e-02f, 2.93689482e-02f, 1.23379730e-01f, 6.68422729e-02f, 1.36352554e-01f, 2.95898557e-01f,
  2.77135253e-01f, 2.19336882e-01f, 4.55686525e-02f, -9.38810930e-02f, 2.37848952e-01f, 9.46625471e-02f, 6.16318993e-02f, 1.94200635e-01f, 1.00716650e-01f, -1.26948319e-02f,
  -2.39369288e-01f, -4.49145108e-01f, 3.76036942e-01f, 9.74946022e-02f, 5.95253825e-01f, 6.44796550e-01f, 1.12492524e-01f, 5.10564268e-01f, 6.15040898e-01f, -4.89505470e-01f,
  -2.09224731e-01f, -3.31218898e-01f, -6.36026144e-01f, 1.10168485e-02f, 5.00662982e-01f, -1.04674533e-01f, 3.06740046e-01f, 7.30667561e-02f, 3.20819557e-01f, -2.76212972e-02f,
  1.68597952e-01f, 1.58823177e-01f, -1.50651202e-01f, 1.57763049e-01f, 2.14664675e-02f, 2.77622342e-02f, -3.15740854e-01f, 8.70941803e-02f, -2.23627765e-04f, 3.13057274e-01f,
  4.64672185e-02f, -2.25225985e-01f, -1.15020253e-01f, -1.51889026e-01f, 5.29801436e-02f, -5.39769568e-02f, 6.77246600e-02f, -5.10347495e-03f, 3.90535630e-02f, -2.55431030e-02f,
  -1.83985636e-01f, 4.74520996e-02f, 1.01502724e-01f, 1.27586082e-01f, 1.14986271e-01f, 6.69794381e-02f, 1.22259125e-01f, -9.07122046e-02f, -4.04697619e-02f, 3.98914106e-02f,
  -1.97929069e-01f, -3.57719436e-02f, -1.24645345e-01f, 1.45869270e-01f, -8.92088562e-03f, 1.94804460e-01f, -1.16981203e-02f, 5.00414297e-02f, -2.79891677e-02f, 9.56227779e-02f,
  1.72640353e-01f, 1.25492468e-01f, -6.34789243e-02f, -1.43083587e-01f, 5.70068248e-02f, -2.71401890e-02f, 1.88962687e-02f, -1.09144961e-02f, 5.06027192e-02f, -9.43830330e-03f,
  8.60713348e-02f, 2.09919307e-02f, 5.73456772e-02f, 2.58604586e-02f, -7.82679021e-02f, -6.73106834e-02f, -3.59483957e-02f, -4.54906374e-02f, 8.12875573e-03f, -8.67039412e-02f,
  1.95608679e-02f, 1.26012087e-01f, -5.40470779e-02f, -1.78305358e-02f, -3.11738462e-03f, -5.44633605e-02f, -1.42477378e-02f, -2.23145057e-02f, -3.18148965e-03f, -1.18602872e-01f,
  -3.01450014e-01f, -2.28103593e-01f, -1.36070147e-01f, -6.11226000e-02f, 6.73102681e-03f, -4.01354507e-02f, 5.78680225e-02f, 3.91898118e-02f, 1.03627946e-02f, 5.01590781e-02f,
  3.07347346e-02f, -1.03223687e-02f, -8.17525387e-02f, 2.17207969e-04f, -4.81750406e-02f, -1.17123917e-01f, -1.50591910e-01f, -1.99522730e-02f, -2.14000214e-02f, -1.11694925e-01f,
  -8.31242427e-02f, -6.26453981e-02f, 5.66017702e-02f, 1.12029262e-01f, -1.33697584e-01f, -9.58450064e-02f, -9.51500162e-02f, -5.60976788e-02f, -6.59586210e-03f, 4.15518694e-03f,
  1.11669707e+00f, -3.74831855e-02f, 3.77302289e-01f, 6.57031417e-01f, 2.75715560e-01f, -2.05694422e-01f, -6.75274730e-02f, 4.79628034e-02f, 3.28213781e-01f, -1.34531215e-01f,
  -3.90100747e-01f, 3.11402678e-01f, -5.79913616e-01f, 2.03450322e-01f, -8.45216215e-01f, -7.01548338e-01f, 2.15477273e-02f, 2.52728295e-02f, 9.57957655e-03f, 8.73952806e-02f,
  1.14419810e-01f, -4.93159801e-01f, -1.13372430e-01f, -2.15617359e-01f, 5.15942752e-01f, 4.66668308e-01f, -2.58624882e-01f, -2.70168215e-01f, 2.57390648e-01f, -2.63819039e-01f,
  2.36827239e-01f, 1.28014863e-01f, 2.23054975e-01f, -1.62868146e-02f, -1.99107956e-02f, 1.38797805e-01f, 9.58058909e-02f, -2.10805491e-01f, 6.40802681e-02f, 3.34109589e-02f,
  1.41031310e-01f, 4.03286926e-02f, 1.72491714e-01f, -1.76910415e-01f, 1.37385279e-01f, 2.17245460e-01f, 2.05682382e-01f, 3.20845276e-01f, 1.16489977e-01f, 1.60422444e-01f,
  1.75345287e-01f, 3.32272202e-01f, 1.71968147e-01f, 1.18602477e-02f, -1.49257537e-02f, 7.94001445e-02f, -8.19571763e-02f, -1.88562600e-03f, 6.77721128e-02f, 5.12405820e-02f,
  -7.89977014e-02f, -1.00452945e-01f, -1.00747719e-01f, 2.45748371e-01f, -3.91051620e-02f, 1.19493358e-01f, -9.36974864e-03f, 1.82804260e-02f, 3.14413104e-03f, -1.54268160e-01f,
  1.18950538e-01f, 1.57957096e-02f, -2.52725929e-02f, 1.53157816e-04f, 3.16713564e-02f, 1.77945107e-01f, 1.05403565e-01f, -2.68727187e-02f, 1.14394268e-02f, 1.34478003e-01f,
  -4.40296791e-02f, -6.88005015e-02f, -1.20192476e-01f, 1.85793400e-01f, -1.52888730e-01f, -1.45331696e-01f, 2.69412040e-03f, 1.20183483e-01f, 1.08150579e-01f, -9.65293646e-02f,
  -5.41699708e-01f, -8.05304885e-01f, -2.46494804e-02f, 8.62500742e-02f, -6.40236884e-02f, 6.32827654e-02f, -4.18425128e-02f, 1.00035839e-01f, -2.78321266e-01f, -4.95138057e-02f,
  4.47990522e-02f, 1.80623055e-01f, 4.80990037e-02f, 9.03482288e-02f, -1.07826106e-01f, -1.70472652e-01f, -9.95986313e-02f, 1.28546469e-02f, 8.27051047e-03f, 8.28897581e-02f,
  1.06320955e-01f, -6.58934284e-03f, 6.56833425e-02f, 1.43312737e-01f, 1.96663931e-01f, 8.44913826e-04f, -7.59939058e-03f, -4.12656814e-02f, -1.35176582e-02f, -7.10386038e-02f,
  -1.35624993e+00f, 4.02812451e-01f, 5.99591255e-01f, -4.29473907e-01f, -2.65838563e-01f, 2.64330149e-01f, 5.49159706e-01f, -1.76638424e-01f, -1.29585728e-01f, 2.59479105e-01f,
  4.33374010e-03f, 3.81018817e-01f, 6.66674495e-01f, 3.07601672e-02f, -1.82099879e-01f, 2.97423065e-01f, -2.75550723e-01f, 6.39906228e-02f, -9.98801515e-02f, -1.31867737e-01f,
  -2.87148237e-01f, -2.19271913e-01f, 2.14067161e-01f, -1.94637820e-01f, -1.75700903e-01f, -1.66121796e-01f, -3.73073727e-01f, 2.46447057e-01f, -2.04956740e-01f, 5.35900034e-02f,
  -9.59057212e-01f, -4.77103561e-01f, -1.17584743e-01f, -1.59992203e-01f, -2.67891169e-01f, -3.58279161e-02f, 1.18928673e-02f, 1.32183835e-01f, -1.20016098e-01f, 6.05302900e-02f,
  1.80590287e-01f, 4.16905992e-02f, -1.99582025e-01f, 1.17403857e-01f, -2.67095447e-01f, -1.82910278e-01f, 6.56253323e-02f, -1.15823083e-01f, 3.10044866e-02f, 8.85381550e-02f,
  2.12961689e-01f, -3.90768237e-02f, -2.33927876e-01f, 2.42442749e-02f, 1.12172477e-01f, -2.66984310e-02f, 5.59802260e-03f, 5.06162867e-02f, -7.67694339e-02f, -2.14002356e-01f,
  1.30046690e-02f, 3.38462330e-02f, 1.62707698e-02f, 3.20481136e-02f, 7.33607188e-02f, -8.43566507e-02f, 6.66375384e-02f, -2.70436853e-02f, 1.21678095e-02f, -2.23457329e-02f,
  -3.74354087e-02f, -1.02646984e-01f, -2.06805348e-01f, -4.94882539e-02f, -1.28600630e-03f, -2.56002638e-02f, 1.32055864e-01f, -7.42926747e-02f, -1.23587325e-02f, -5.48191480e-02f,
  -9.17425100e-03f, -2.68681766e-03f, 8.13950412e-03f, -5.27567342e-02f, -2.14484502e-02f, 8.41711536e-02f, -8.78906101e-02f, -1.02710612e-01f, -1.58725068e-01f, 4.11922298e-02f,
  -8.80349100e-01f, -5.73696315e-01f, -4.44815606e-02f, -1.99208438e-01f, -1.52032733e-01f, -1.72012001e-01f, -1.92867033e-02f, -1.16849370e-01f, -1.86652482e-01f, -9.13167298e-02f,
  -1.47268265e-01f, -1.02145664e-01f, -7.21142218e-02f, 9.15325508e-02f, 1.91137061e-01f, -5.88361621e-02f, -3.66994664e-02f, -7.52007216e-02f, -4.60778549e-02f, -4.76816706e-02f,
  2.23312043e-02f, -1.30798891e-02f, 1.18997291e-01f, -1.22348510e-01f, -5.72508089e-02f, -1.99705675e-01f, -2.03221396e-01f, -7.26511776e-02f, -9.58382785e-02f, 2.33309697e-02f,
  7.25517869e-01f, -1.05980635e-01f, -4.88164514e-01f, 5.21768928e-01f, 4.70017157e-02f, 5.05984843e-01f, 6.21244013e-01f, 2.91207045e-01f, 7.87158668e-01f, 9.06345919e-02f,
  4.09738839e-01f, -5.50938249e-01f, 1.06485896e-01f, 4.92187887e-01f, 1.17982417e-01f, 2.30053231e-01f, 6.96545780e-01f, 1.83837488e-01f, 2.57278860e-01f, 1.39109194e-01f,
  4.21844065e-01f, 3.70016932e-01f, -3.84048373e-01f, -3.59268516e-01f, -1.53829549e-02f, -3.07704061e-01f, -4.71853316e-01f, -4.61352527e-01f, -3.59893709e-01f, -1.61328390e-01f,
  3.75917442e-02f, 2.28484988e-01f, 7.50764413e-03f, -3.02862041e-02f, 1.74279675e-01f, 7.42029026e-02f, -2.42311358e-01f, -2.36545429e-01f, -1.04648046e-01f, 1.54112130e-01f,
  -3.58635299e-02f, -9.34282467e-02f, 2.79003710e-01f, -4.66623083e-02f, 7.29360953e-02f, -1.62155077e-01f, 3.25485058e-02f, -2.49627642e-02f, -1.22674242e-01f, -6.74007600e-03f,
  1.18792623e-01f, 1.08844973e-01f, 5.55377603e-02f, 7.61714280e-02f, 1.02033010e-02f, 9.09031406e-02f, -9.45929158e-03f, -1.72355190e-01f, -2.59141829e-02f, 9.12694037e-02f,
  6.95517957e-02f, 1.12460196e-01f, 5.34670427e-02f, -4.25550118e-02f, 1.40185967e-01f, 6.02893122e-02f, 9.50779580e-03f, -1.25016749e-01f, 6.62057549e-02f, -8.51100832e-02f,
  1.05549172e-01f, -1.75163019e-02f, 6.50363192e-02f, 9.44989081e-03f, 3.01221192e-01f, 1.22540474e-01f, -7.49779046e-02f, -5.36847264e-02f, 1.44161284e-01f, -1.41619965e-01f,
  -4.39765751e-02f, 1.62593462e-02f, 1.66451689e-02f, -9.18554887e-02f, -4.07145731e-02f, 3.85926031e-02f, 9.86461118e-02f, -6.68620095e-02f, -4.32815254e-02f, -2.71715745e-02f,
  9.39987674e-02f, 2.77571946e-01f, 6.18322007e-02f, -4.02722247e-02f, -1.56727523e-01f, 8.73982310e-02f, 7.54953697e-02f, 3.44499908e-02f, 2.72420663e-02f, 1.60106286e-01f,
  1.18021943e-01f, 3.20741534e-02f, 3.06074824e-02f, -1.87054262e-01f, -1.41520470e-01f, 1.53306991e-01f, -6.36220574e-02f, 1.26115039e-01f, -4.15382385e-02f, -1.81002215e-01f,
  -7.76492730e-02f, 1.81045070e-01f, 6.02322780e-02f, 1.97647378e-01f, 1.50855994e-02f, -7.18378276e-02f, -6.87581077e-02f, -4.40420732e-02f, -1.74864531e-02f, 3.69503833e-02f,
  -2.82517672e-01f, -9.68693569e-02f, 3.65170330e-01f, 6.27758086e-01f, -3.32067311e-01f, -6.57625735e-01f, -7.45250225e-01f, -1.96226254e-01f, -5.00378460e-02f, -5.21605372e-01f,
  -4.20296043e-01f, 3.11151296e-01f, -6.97291791e-01f, 4.63400126e-01f, 6.37695014e-01f, -7.90402219e-02f, 3.51076603e-01f, 2.30787080e-02f, 3.91930640e-01f, 1.33885056e-01f,
  4.96131629e-01f, 2.85686314e-01f, 6.06254280e-01f, 4.32054073e-01f, 9.28679034e-02f, 4.15609032e-01f, 5.71025848e-01f, 1.69553056e-01f, 6.49090528e-01f, 1.32483989e-01f,
  -2.41905317e-01f, -5.04434714e-03f, 1.22434951e-01f, 6.77018054e-03f, -5.89185581e-02f, -3.79834116e-01f, -6.35509640e-02f, -2.27904152e-02f, 7.74334669e-02f, -4.77720946e-02f,
  -7.25304782e-02f, 1.06264241e-01f, 2.02854306e-01f, 1.19258404e-01f, -1.11599945e-01f, 2.68106848e-01f, 7.59208649e-02f, -1.01742379e-01f, -2.77416315e-02f, -1.29053369e-01f,
  1.21003790e-02f, -6.37888163e-02f, 2.06952281e-02f, 8.61930549e-02f, 2.43203148e-01f, 8.78077447e-02f, 1.78319842e-01f, -7.99917579e-02f, 8.90824050e-02f, 1.86656132e-01f,
  -1.90434724e-01f, -1.50352195e-02f, -5.99381439e-02f, 7.51760527e-02f, 1.13515422e-01f, 1.29997715e-01f, 9.92220715e-02f, 8.26548785e-02f, 1.18050888e-01f, -9.97270197e-02f,
  1.92239478e-01f, 3.84024717e-02f, -3.20013128e-02f, -3.34176645e-02f, 2.73840986e-02f, -7.47559071e-02f, -5.05514741e-02f, -2.77494751e-02f, 6.50240257e-02f, 1.44117087e-01f,
  -4.67599928e-02f, 4.56224568e-02f, 3.44569497e-02f, -2.21454166e-02f, -6.10367656e-02f, -6.72150478e-02f, 9.24029052e-02f, -8.04970190e-02f, -8.72188956e-02f, -4.70708199e-02f,
  -1.72601063e-02f, 3.52934688e-01f, -2.05499586e-02f, 1.95013382e-03f, 1.78957969e-01f, 1.07753212e-02f, 1.56610042e-01f, 1.05604753e-01f, 1.92922011e-01f, -1.60438791e-02f,
  -1.14160284e-01f, -6.01364812e-03f, -1.52310031e-02f, -1.03353173e-01f, 8.62301439e-02f, -1.96207184e-02f, 4.60020341e-02f, 1.53019160e-01f, 1.93925694e-01f, 1.90763563e-01f,
  2.54883301e-02f, -1.68005407e-01f, 9.06892568e-02f, 7.97262490e-02f, -6.32505566e-02f, -5.04458547e-02f, 1.48793291e-02f, 1.55418869e-02f, 5.45533597e-02f, 1.94685876e-01f,
  -4.49583948e-01f, 4.60514605e-01f, 1.83035173e-02f, -4.92119133e-01f, 8.04075748e-02f, 4.50890392e-01f, -1.74554348e-01f, 2.62508720e-01f, 3.41995925e-01f, 3.95912081e-01f,
  -9.33754295e-02f, 3.95561725e-01f, 1.41658559e-01f, -3.81571412e-01f, -7.03749478e-01f, -4.11470741e-01f, -4.28682655e-01f, -1.76912978e-01f, 1.04666427e-01f, -7.53625929e-02f,
  -3.82973075e-01f, -4.89877284e-01f, -6.94642067e-01f, 9.41318460e-03f, -2.04770043e-01f, 2.00431228e-01f, -5.16316295e-01f, 2.55353034e-01f, -1.74593300e-01f, -1.39465287e-01f,
  -1.70723274e-01f, 1.35899141e-01f, 1.52080402e-01f, 2.16500908e-01f, 4.31540944e-02f, -3.29288989e-02f, 4.96071503e-02f, -2.23823693e-02f, 1.10645793e-01f, 2.14432880e-01f,
  5.52022979e-02f, 2.06673622e-01f, 1.69530064e-01f, 1.80591233e-02f, 1.95470050e-01f, 3.51303853e-02f, -3.42532918e-02f, 6.24102019e-02f, 2.49971852e-01f, -1.95204075e-02f,
  -1.76613390e-01f, 1.35099769e-01f, 1.16805911e-01f, -1.67430169e-03f, 5.52675985e-02f, 1.59523979e-01f, 6.66283667e-02f, 1.41310856e-01f, 4.61631268e-02f, 5.85514903e-02f,
  -6.04800321e-02f, 1.86736628e-01f, -4.07614186e-02f, 4.73115407e-02f, 3.31567526e-02f, 1.28374584e-02f, -1.04729384e-01f, -8.70893374e-02f, 7.52996281e-02f, 8.40330422e-02f,
  1.07336916e-01f, 1.16032869e-01f, -1.05594344e-01f, 8.49452689e-02f, -1.99488208e-01f, -9.92086232e-02f, 8.86388030e-03f, 4.68563214e-02f, -1.16518594e-01f, -1.70566857e-01f,
  -2.85723172e-02f, 4.08841297e-03f, -7.54303187e-02f, -1.05768114e-01f, -1.34379163e-01f, -1.01451181e-01f, 1.70705095e-01f, 9.05196145e-02f, -1.63593486e-01f, -4.24882211e-02f,
  1.62114296e-02f, 4.71801698e-01f, 1.14943735e-01f, 9.30245370e-02f, 5.26718274e-02f, 2.32257787e-02f, 1.04962692e-01f, 1.73239466e-02f, 1.20260969e-01f, 1.65535733e-02f,
  3.74562964e-02f, 1.97784200e-01f, 1.40397489e-01f, -1.79741263e-01f, -3.47722881e-02f, -9.86692160e-02f, -5.13488520e-03f, 2.72381939e-02f, 2.18915999e-01f, -1.79158542e-02f,
  6.96236342e-02f, 1.73236534e-01f, 1.66039728e-02f, 5.51310293e-02f, 1.51830867e-01f, 9.27613527e-02f, 1.66273892e-01f, 2.34417811e-01f, 6.27188832e-02f, 5.45830987e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  6.14633322e-01f, 5.92822850e-01f, 4.77903247e-01f, 7.00778246e-01f, 6.42241478e-01f, 6.21203303e-01f, 3.80373716e-01f, 7.16398835e-01f, 5.96489251e-01f, 6.20402217e-01f,
  7.91203976e-01f, 5.24164200e-01f, 3.04423630e-01f, 7.81004608e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.30321467e-01f, -2.62773573e-01f, 5.72891347e-02f, 1.04290202e-01f, 3.51975411e-01f, -2.23131940e-01f, 7.70592391e-02f, -3.15572359e-02f, 2.26326525e-01f, 3.15022558e-01f,
  -1.35487840e-01f, -8.44423100e-02f, 2.14463547e-02f, -5.33726752e-01f, -5.86029768e-01f, 7.40775391e-02f, 2.11235330e-01f, -8.03094685e-01f, 2.30914623e-01f, -2.27612123e-01f,
  -1.42457798e-01f, 2.66900837e-01f, 7.76536167e-02f, -3.57019231e-02f, -6.26250029e-01f, -4.27313507e-01f, 2.79370904e-01f, -1.89354450e-01f, 4.85732198e-01f, 1.66917056e-01f,
  5.59217751e-01f, 8.26426864e-01f, 4.33575571e-01f, -7.28200749e-02f, 1.49377644e-01f, 4.57487315e-01f, -6.16628587e-01f, -1.58567369e-01f, 4.09357965e-01f, 1.92630678e-01f,
  5.17708480e-01f, -5.98193049e-01f, -3.24658424e-01f, 4.18606937e-01f, -5.05220771e-01f, 2.34282300e-01f, -2.59297431e-01f, -3.70655656e-01f, -6.20693743e-01f, -4.91106302e-01f,
  7.57047415e-01f, -4.96222645e-01f, -4.99632239e-01f, -3.73607099e-01f, -6.75209165e-01f, -4.94684935e-01f, 3.23586404e-01f, -4.06014562e-01f, -7.06718683e-01f, -2.68021822e-01f,
  5.21010756e-01f, 2.04171866e-01f, -5.06784201e-01f, -6.18887842e-01f, 3.43424641e-02f, -3.70099872e-01f, 4.70814109e-01f, 4.23177034e-02f, -9.04909670e-01f, 2.50581354e-01f,
  -3.33955288e-01f, 1.90638557e-01f, -4.03362006e-01f, 2.14873813e-02f, 1.46210432e-01f, 1.04450621e-01f, -1.30047128e-01f, 1.21255130e-01f, -1.93753809e-01f, -3.38720948e-01f,
  -4.80073057e-02f, -2.98298687e-01f, 4.09864098e-01f, 2.32576862e-01f, -2.92391051e-02f, -4.74765413e-02f, 1.95770726e-01f, 2.99054414e-01f, 4.35365021e-01f, -4.67620075e-01f,
  7.46922076e-01f, 6.75255001e-01f, 4.78100866e-01f, 2.72182405e-01f, -6.09324932e-01f, -6.91348791e-01f, -6.23935103e-01f, -4.54170465e-01f, -7.56954968e-01f, -4.63817358e-01f,
  8.14412534e-01f, 7.26575255e-01f, 5.12005389e-01f, 5.69265306e-01f, -7.90939152e-01f, 6.22689962e-01f, -4.02985722e-01f, -4.37313497e-01f, -5.18140256e-01f, 7.45230556e-01f,
  -4.27047998e-01f, -6.97206080e-01f, 4.78255540e-01f, -4.01715815e-01f, 4.62374330e-01f, 3.81718069e-01f, 4.68054367e-03f, -7.26447523e-01f, -1.05314599e-02f, -7.19605923e-01f,
  -2.50140250e-01f, 5.44249229e-02f, 6.94851996e-03f, -1.71097204e-01f, -9.96844530e-01f, 5.31330228e-01f, -5.41781068e-01f, -4.99905258e-01f, 1.30707011e-01f, 1.68293908e-01f,
  -7.69281089e-02f, 1.21587984e-01f, -2.39286125e-01f, -1.51238739e-01f, 1.13641135e-02f, -1.34729907e-01f, -4.68955822e-02f, 5.89043908e-02f, -6.06342196e-01f, -1.22341886e-02f,
  -4.14874218e-02f, -3.77983183e-01f, -7.28231147e-02f, -3.29492033e-01f, -1.71341091e-01f, 3.43344986e-01f, -1.60088494e-01f, -2.48946965e-01f, 1.11201264e-01f, -6.41137421e-01f,
  -4.91629124e-01f, 1.53640524e-01f, -1.54673964e-01f, 4.51970130e-01f, 4.34111655e-01f, -2.29489580e-02f, -4.50384289e-01f, 4.42200303e-01f, -2.39629839e-02f, 8.86020511e-02f,
  5.05018115e-01f, 6.07499145e-02f, -5.10611355e-01f, -4.52871680e-01f, -5.65499485e-01f, 4.37420845e-01f, -6.46704793e-01f, 4.10347655e-02f, -4.52123195e-01f, 3.42195034e-01f,
  -1.51639223e-01f, -1.44564331e-01f, 5.90075612e-01f, 5.09765327e-01f, -3.04277122e-01f, -2.41976708e-01f, 3.11461747e-01f, 4.28804994e-01f, -5.46611667e-01f, -2.99851030e-01f,
  -4.04944897e-01f, -6.99682593e-01f, -4.62082237e-01f, -5.50420523e-01f, 5.30451298e-01f, -2.14363530e-01f, 5.13945878e-01f, 2.12585524e-01f, -5.41493714e-01f, -3.94263178e-01f,
  5.76230764e-01f, -4.30032283e-01f, -2.74283797e-01f, -1.96034491e-01f, -1.94980994e-01f, 2.17773318e-01f, -3.04280072e-01f, 9.99714956e-02f, -5.59428930e-01f, 7.73976743e-02f,
  -3.04287225e-01f, 3.68946880e-01f, -5.79456389e-01f, -2.22851545e-01f, 1.07106537e-01f, -5.84294856e-01f, 9.19034034e-02f, 1.74869057e-02f, -7.03999102e-01f, -2.10928395e-02f,
  -2.95022368e-01f, -5.51473722e-02f, 1.29844368e-01f, -1.76847771e-01f, -1.58390269e-01f, -8.53860527e-02f, -2.16843605e-01f, 4.63583320e-01f, 3.53989631e-01f, 6.50594115e-01f,
  -1.32941976e-01f, -5.55801272e-01f, -1.10127471e-01f, 6.15331307e-02f, -4.58284587e-01f, -5.97041547e-01f, -2.76820689e-01f, 2.21088246e-01f, -6.58798575e-01f, 6.05584741e-01f,
  4.72252011e-01f, -4.19716209e-01f, 4.90627110e-01f, -2.67972618e-01f, 5.05841315e-01f, 1.20472029e-01f, -3.72836411e-01f, -4.61177081e-01f, 5.13089657e-01f, 6.01085663e-01f,
  2.57065266e-01f, -5.75807691e-01f, -6.71577990e-01f, -8.46049786e-02f, 5.16030848e-01f, -5.50219595e-01f, -4.06475276e-01f, 3.30652088e-01f, -4.28267509e-01f, -7.10027665e-02f,
  -3.97801995e-01f, -5.49701333e-01f, 5.02984107e-01f, -6.51264191e-01f, -5.98000288e-01f, 4.30407554e-01f, 4.93940800e-01f, 2.46729627e-01f, 2.71171719e-01f, -2.06998318e-01f,
  9.82978716e-02f, 2.52059966e-01f, 5.46438582e-02f, -2.16331482e-01f, -4.36597019e-02f, -9.47693065e-02f, 4.44913656e-01f, 7.96507820e-02f, -3.13445240e-01f, 3.37663829e-01f,
  4.48027521e-01f, -1.52778193e-01f, 5.87231934e-01f, 3.83128941e-01f, -2.46232942e-01f, 1.42554462e-01f, 2.63884574e-01f, 2.99609512e-01f, -1.43680096e-01f, 9.27854702e-02f,
  3.81200254e-01f, 8.59690428e-01f, 9.94095113e-03f, 2.12773219e-01f, -5.13672531e-01f, -1.37032017e-01f, -3.39200050e-01f, 8.15436319e-02f, 3.82849544e-01f, 7.93106735e-01f,
  1.70699090e-01f, -1.60827022e-02f, -5.26300669e-01f, -5.49154937e-01f, 4.10791337e-01f, 6.70580193e-02f, 4.75835770e-01f, -4.38318312e-01f, -3.80177274e-02f, 8.57897758e-01f,
  3.89976531e-01f, 2.75151551e-01f, 4.49883997e-01f, -3.82214665e-01f, -3.04462790e-01f, 6.04934335e-01f, 2.15300515e-01f, -7.07164168e-01f, -2.77746856e-01f, 1.43870309e-01f,
  1.20084241e-01f, 7.75203884e-01f, -1.10047758e-01f, -7.48537421e-01f, 3.57727021e-01f, -7.46098995e-01f, 4.15298939e-01f, -6.72326326e-01f, -9.64975879e-02f, 1.94951087e-01f,
  -3.30943406e-01f, 1.50044292e-01f, -3.87003094e-01f, 1.40671894e-01f, 2.50707030e-01f, -8.22502598e-02f, 5.53826571e-01f, 1.34067386e-01f, 8.73592719e-02f, -1.04066990e-02f,
  5.05673170e-01f, -1.52620390e-01f, 3.67433846e-01f, 2.44553030e-01f, 1.11427113e-01f, 3.33427221e-01f, -4.20494750e-02f, 4.22547609e-01f, 1.28117902e-02f, 2.55682021e-01f,
  2.12382689e-01f, 8.71888027e-02f, -6.26064390e-02f, 1.81859255e-01f, 4.14485000e-02f, -5.66508651e-01f, 8.03908333e-02f, -8.05884778e-01f, 4.27142903e-02f, 8.85619283e-01f,
  6.17020488e-01f, -3.91481966e-01f, -4.62147146e-01f, 1.62261233e-01f, 7.23319173e-01f, -1.48269311e-01f, 3.86304379e-01f, -5.57180285e-01f, -4.91384983e-01f, 6.25499725e-01f,
  -1.47241473e-01f, 5.54567695e-01f, -1.47353366e-01f, -6.96231663e-01f, -1.37541145e-01f, -3.24046552e-01f, 5.75391829e-01f, 8.68495405e-01f, -2.40333453e-01f, -4.78928417e-01f,
  -1.38780504e-01f, -8.58825266e-01f, 1.26839340e-01f, 5.17562509e-01f, -6.31204784e-01f, -1.33816153e-01f, -8.81771266e-01f, -4.82434362e-01f, 3.25060695e-01f, -7.68578053e-01f,
  9.96761769e-03f, 4.12586957e-01f, 1.41586319e-01f, 3.69157910e-01f, -3.21235619e-02f, -2.73433149e-01f, -5.57109490e-02f, -3.73967826e-01f, 1.20872278e-02f, 8.71086270e-02f,
  -2.17942879e-01f, 1.31666526e-01f, 2.03683689e-01f, -2.48575419e-01f, -4.64210391e-01f, 7.04121729e-03f, 1.63602740e-01f, 7.79054984e-02f, 1.31335825e-01f, 1.46301314e-01f,
  -2.03042865e-01f, -1.91719502e-01f, 1.84075721e-02f, 1.55308709e-01f, -8.79541505e-04f, 1.10956788e-01f, 4.39977705e-01f, -3.08990568e-01f, -1.88413605e-01f, 9.75887477e-02f,
  -5.20477116e-01f, 3.94476920e-01f, -6.40099347e-01f, -7.05399036e-01f, -5.28819740e-01f, -2.83807099e-01f, -5.45739233e-01f, -3.22655022e-01f, 5.44965506e-01f, -3.84812772e-01f,
  -3.85999054e-01f, -1.02081522e-01f, -4.42935675e-02f, -5.53675056e-01f, 1.52880743e-01f, 1.38566375e-01f, 2.61478692e-01f, 2.62144297e-01f, 4.01207685e-01f, -5.26794732e-01f,
  -3.94367576e-01f, 1.27492890e-01f, 5.55377603e-01f, 3.87451679e-01f, -5.32603145e-01f, 1.83554336e-01f, -2.54577905e-01f, 6.11056983e-01f, -8.27072799e-01f, -5.62994182e-01f,
  1.01641499e-01f, -4.41920072e-01f, 3.88398319e-01f, 6.21938765e-01f, -8.91188502e-01f, 5.50955415e-01f, -5.13292730e-01f, -6.33763611e-01f, -1.65889323e-01f, -2.15853136e-02f,
  -1.56765848e-01f, -4.20485914e-01f, -3.18757653e-01f, -2.88495511e-01f, -1.78369045e-01f, -2.69626677e-01f, -3.02502811e-01f, -1.83431096e-02f, 3.34871501e-01f, -7.28064254e-02f,
  1.67513676e-02f, -1.87011182e-01f, 1.88651472e-01f, -1.27990574e-01f, -3.40311795e-01f, 7.92896077e-02f, -5.74707240e-02f, 6.11656047e-02f, -1.55454099e-01f, -5.24008870e-01f,
  -1.31541252e-01f, -3.95392776e-01f, -1.41129255e-01f, 3.55038911e-01f, -4.20935392e-01f, -4.14217234e-01f, -3.71671826e-01f, -2.65315920e-01f, 4.24755365e-01f, 3.66527945e-01f,
  2.78786302e-01f, 3.43159258e-01f, -5.96519560e-04f, -3.00840676e-01f, 4.17829268e-02f, -1.50018364e-01f, -5.35827816e-01f, -1.47881061e-01f, 1.97881162e-01f, -3.12275678e-01f,
  -1.88530281e-01f, -8.43350664e-02f, 2.47356340e-01f, -4.19731319e-01f, 1.58354089e-01f, 3.04204881e-01f, 1.32422717e-02f, -1.69731349e-01f, -5.50992548e-01f, 5.06669760e-01f,
  5.17531872e-01f, 2.52621651e-01f, 5.64552009e-01f, -4.16087717e-01f, -6.24149382e-01f, -5.42434037e-01f, -4.65401649e-01f, -6.54122949e-01f, -1.25070155e-01f, -1.40548795e-01f,
  2.07525134e-01f, -9.97020304e-02f, 2.61578768e-01f, 1.26437411e-01f, 3.02021895e-02f, 5.45369200e-02f, 1.36706725e-01f, -1.94217071e-01f, 1.72658086e-01f, -6.25285730e-02f,
  -1.63848978e-02f, -1.52838647e-01f, 5.32534383e-02f, -1.24147229e-01f, -4.03751403e-01f, -7.62052536e-02f, -8.84939432e-02f, 2.22973630e-01f, 5.44296876e-02f, -4.88272347e-02f,
  -1.98112115e-01f, 1.49307400e-01f, -2.09470928e-01f, 2.73013443e-01f, 2.08119303e-02f, -4.29796398e-01f, 1.01077206e-01f, -2.00234652e-01f, -4.87983257e-01f, -5.29527843e-01f,
  2.69802421e-01f, -1.51280299e-01f, -4.26960021e-01f, -3.34107488e-01f, 4.54574019e-01f, -1.43551424e-01f, -2.88563937e-01f, 3.75572860e-01f, 2.31055334e-01f, 2.89814234e-01f,
  4.71913993e-01f, -5.28191626e-01f, 3.49216670e-01f, 1.82850361e-01f, -3.99005145e-01f, -3.27290118e-01f, -3.84529918e-01f, -7.26451635e-01f, 1.51237383e-01f, 2.16065839e-01f,
  3.44624162e-01f, 1.50752634e-01f, -5.03360868e-01f, -1.24023907e-01f, -5.40126443e-01f, -3.31836492e-01f, -3.60143930e-01f, -2.45802477e-01f, -3.44312996e-01f, 4.09240633e-01f,
  -8.94607723e-01f, -4.72289741e-01f, -4.92157012e-01f, -1.19214781e-01f, 8.90706420e-01f, -5.70164979e-01f, 4.04721498e-02f, 1.27963647e-02f, 1.50364235e-01f, 6.26100749e-02f,
  2.52184391e-01f, 1.08447887e-01f, 1.96553599e-02f, 9.78951603e-02f, -1.48029447e-01f, 5.26756719e-02f, -3.12154949e-01f, 1.27320886e-01f, -2.84566849e-01f, -3.46414328e-01f,
  1.06187398e-02f, -1.46257073e-01f, 3.66382092e-01f, -6.56216890e-02f, 2.39461958e-01f, -4.20234531e-01f, -2.44493276e-01f, -5.46744987e-02f, -2.48669777e-02f, 2.69053936e-01f,
  -3.07867676e-01f, -5.58886468e-01f, -5.83989263e-01f, 1.70637846e-01f, 3.24315250e-01f, -2.17702329e-01f, 5.66463172e-01f, -3.12282622e-01f, 9.81101394e-02f, 4.59562361e-01f,
  1.03893280e-01f, -2.51122117e-01f, 1.44291237e-01f, -2.18254551e-01f, -6.01197302e-01f, 3.03382486e-01f, -3.65773618e-01f, -7.29228854e-02f, 4.74167675e-01f, -5.29712498e-01f,
  5.44961035e-01f, -5.61385810e-01f, -2.50401855e-01f, -4.26326722e-01f, -5.48369408e-01f, 4.26150441e-01f, 3.59366506e-01f, 6.41261458e-01f, -7.10016966e-01f, 2.33704165e-01f,
  6.19709015e-01f, -6.44176006e-01f, 4.89650160e-01f, -3.55561584e-01f, -1.40176028e-01f, -5.55855393e-01f, 3.75777185e-01f, -6.40618801e-01f, -7.22813010e-01f, -5.30273199e-01f,
  -5.78110576e-01f, 8.95989239e-02f, -9.73277539e-02f, 1.07275397e-02f, 4.19730693e-01f, 5.88768646e-02f, 3.54031920e-01f, 2.14574203e-01f, 3.51259083e-01f, -1.41933262e-01f,
  1.50807142e-01f, 3.87377471e-01f, 2.97374338e-01f, 4.47091281e-01f, -1.32576838e-01f, 1.95783213e-01f, -8.20718333e-02f, 1.67543769e-01f, -1.31876811e-01f, 1.65128246e-01f,
  9.15166736e-02f, 3.45675647e-01f, 1.72144130e-01f, -1.66877106e-01f, 5.56264147e-02f, 4.38368559e-01f, 5.63857099e-03f, 2.85887569e-01f, 3.45667779e-01f, 6.61879897e-01f,
  -5.38969696e-01f, 6.17524564e-01f, -3.47814322e-01f, -3.16126704e-01f, -4.55897897e-01f, 5.25751054e-01f, 4.68537301e-01f, 1.01662591e-01f, 6.98424727e-02f, -3.91305566e-01f,
  -6.35866404e-01f, -6.94635630e-01f, -4.12051231e-01f, 5.97579718e-01f, 2.63155967e-01f, 3.71497035e-01f, -3.82027954e-01f, -5.42492926e-01f, -8.18171322e-01f, -1.06351197e-01f,
  -5.65801501e-01f, -5.80141425e-01f, -5.55732623e-02f, -2.75337130e-01f, 4.76194918e-01f, -6.49473190e-01f, -1.93673611e-01f, 6.38459444e-01f, -4.32885945e-01f, -8.02478790e-02f,
  -8.60942423e-01f, -5.82466483e-01f, -6.92885041e-01f, 3.80128145e-01f, 1.67547956e-01f, 4.18895520e-02f, -1.11432582e-01f, 7.07591921e-02f, -1.77394241e-01f, 2.24258602e-01f,
  1.33314714e-01f, 6.10539056e-02f, 1.21512398e-01f, -3.51037681e-02f, 4.91259024e-02f, -1.34979328e-03f, 1.95173845e-01f, 1.02262516e-02f, -7.13829547e-02f, 4.65096608e-02f,
  2.57101655e-01f, -3.65307629e-01f, 3.36364836e-01f, -7.23922029e-02f, -6.54296800e-02f, 6.67230934e-02f, -2.18970567e-01f, -5.29035404e-02f, 1.89686909e-01f, -5.63038826e-01f,
  -2.54727453e-01f, -4.86867964e-01f, 3.01490098e-01f, -3.55996937e-01f, 4.87436265e-01f, 6.46909773e-01f, 2.78546125e-01f, -1.13448724e-01f, 3.76794964e-01f, 2.81408817e-01f,
  5.31038761e-01f, -9.61960554e-02f, -3.01577687e-01f, -3.98957312e-01f, 2.88798571e-01f, 2.23784700e-01f, 5.34911692e-01f, -3.70292813e-01f, -3.23293865e-01f, 4.65150923e-01f,
  2.31608286e-01f, 4.57177848e-01f, 6.36300266e-01f, 2.54943937e-01f, -6.66801870e-01f, -1.98598087e-01f, -8.12565446e-01f, -1.54825836e-01f, -1.04541287e-01f, 3.55135143e-01f,
  -5.37809968e-01f, 4.10814360e-02f, -4.46099281e-01f, 9.20796335e-01f, 1.06414638e-01f, -7.75435507e-01f, -3.16721588e-01f, 3.05261850e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.28575261e-02f, 8.73468071e-02f, 4.06508259e-02f, -6.82172328e-02f, 1.70766935e-02f, -2.14693472e-02f, -7.91639313e-02f, -1.01294540e-01f, 9.31738764e-02f, -2.01862067e-01f,
  5.43916449e-02f, 3.74198742e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    