/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 128 (x1)
    * Saída: 12
    * Buffer Máx: 128
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 128;
    const int FAN_MAX_BUFFER_SIZE = 128;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.87742555e-01f, -1.47507161e-01f, 6.95287110e-03f, 5.94683886e-02f, 1.55049056e-01f, -2.04487234e-01f, -1.88435003e-01f, -2.22049076e-02f, -1.79753125e-01f, -1.68690413e-01f,
  -1.66138068e-01f, -1.56067044e-01f, -1.92873538e-01f, -1.15206540e-01f, -8.26525465e-02f, -3.00250888e-01f, 8.45616832e-02f, -4.37132595e-03f, 4.85625565e-02f, 2.14568198e-01f,
  1.39713913e-01f, 2.00220168e-01f, 8.26043114e-02f, 1.89511716e-01f, 2.69594789e-01f, 2.28887469e-01f, 1.61322311e-01f, 8.44128802e-02f, 2.73689050e-02f, -3.00054755e-02f,
  7.47421980e-02f, 1.42087964e-02f, 5.23721054e-02f, -3.00364941e-02f, 1.22995213e-01f, -1.13137243e-02f, -1.78683326e-02f, -9.25400779e-02f, 2.85113249e-02f, -6.36847876e-03f,
  1.96872763e-02f, 6.62129298e-02f, 3.92298512e-02f, -6.43407404e-02f, 3.14268172e-02f, 4.61148657e-02f, -2.91719264e-03f, 6.41330555e-02f, -4.90269437e-02f, -4.86043021e-02f,
  -2.43831985e-02f, 4.85881902e-02f, -5.09818308e-02f, -3.78601486e-03f, -1.88655108e-02f, -4.98779081e-02f, -4.25687013e-03f, -3.98838036e-02f, 3.77904847e-02f, -6.31530304e-04f,
  -6.09278120e-02f, -3.13797995e-04f, -1.68311801e-02f, -7.48030096e-03f, 1.20711336e-02f, -1.10767875e-02f, -7.94667527e-02f, 5.44677712e-02f, 1.16375655e-01f, -8.76928493e-03f,
  5.12921400e-02f, 4.84136166e-03f, -5.56282364e-02f, -2.82902340e-03f, 3.44937779e-02f, -3.84682743e-03f, -8.03302303e-02f, -3.42936032e-02f, 2.13433784e-02f, -3.06849722e-02f,
  -4.98639755e-02f, -6.28279820e-02f, -4.16467898e-02f, -2.25746329e-03f, -6.59573600e-02f, 4.51687649e-02f, -8.18810314e-02f, -9.54629704e-02f, -9.41509102e-03f, 7.95089677e-02f,
  1.76252555e-02f, 9.22691226e-02f, -3.06560043e-02f, -3.85647751e-02f, 4.11485210e-02f, 8.97928402e-02f, 7.28982762e-02f, 1.23087475e-02f, -2.98572108e-02f, -5.15235076e-03f,
  6.94535077e-02f, 1.21070556e-01f, 3.63000296e-02f, 6.36759177e-02f, 7.35960379e-02f, -4.43624407e-02f, -1.61456242e-02f, 4.17669751e-02f, -2.23674048e-02f, -3.89333069e-02f,
  4.02277857e-02f, 1.42205551e-01f, 4.66788821e-02f, 7.11454898e-02f, 1.55226430e-02f, -4.69610617e-02f, -5.11021800e-02f, 1.21519817e-02f, 2.34696697e-02f, -5.50234951e-02f,
  1.90646052e-01f, -2.70176023e-01f, -1.33311048e-01f, 3.47617902e-02f, -1.08576037e-01f, -3.41081209e-02f, -2.21423507e-02f, -9.78174433e-02f, -8.34329873e-02f, -3.70814875e-02f,
  -4.64095734e-02f, 3.05116735e-02f, -1.22045174e-01f, -1.27134025e-01f, -3.81025113e-02f, -5.69621883e-02f, -3.15329358e-02f, 1.46862060e-01f, 3.84732038e-02f, -9.20919403e-02f,
  -1.15317792e-01f, 2.67433864e-03f, -6.53989837e-02f, -9.38123092e-02f, -5.19265346e-02f, 1.12516090e-01f, 7.39634335e-02f, 1.79354176e-02f, 1.48994356e-01f, 1.02750465e-01f,
  -3.65777984e-02f, -1.69316262e-01f, -4.89127301e-02f, -2.99813189e-02f, -5.79009093e-02f, -1.99461225e-02f, 3.00610326e-02f, -5.11789806e-02f, -3.48840989e-02f, 2.27130819e-02f,
  4.69488613e-02f, -8.38399678e-02f, 1.26659259e-01f, -7.10763130e-03f, -7.61248544e-03f, 1.22926403e-02f, -1.22383408e-01f, -3.12583684e-03f, -1.18854575e-01f, -6.86128512e-02f,
  -5.83016276e-02f, 2.87738629e-02f, 3.36383246e-02f, 4.83517721e-02f, -3.19583043e-02f, -3.26521248e-02f, 2.29799021e-02f, 4.52721119e-02f, 1.13633737e-01f, 2.84384210e-02f,
  1.21907324e-01f, 3.26594263e-02f, -1.07282773e-01f, 7.58205121e-03f, -5.30418307e-02f, -8.06256309e-02f, -9.23319831e-02f, -3.35154161e-02f, -1.44911893e-02f, -1.27693474e-01f,
  -1.24757811e-02f, -7.18102232e-02f, -3.04283365e-03f, -4.96385656e-02f, 4.97951098e-02f, 1.17167729e-05f, 1.09501346e-03f, 1.35278806e-01f, 2.58344524e-02f, -4.51227501e-02f,
  -7.59205520e-02f, -1.13459177e-01f, -6.49790317e-02f, 1.57322139e-02f, 2.70775948e-02f, 2.34388206e-02f, -7.92002976e-02f, 3.58302929e-02f, -3.97459753e-02f, 8.70038420e-02f,
  -1.06479437e-03f, -5.20959944e-02f, -5.06448261e-02f, -5.98524213e-02f, -4.94829454e-02f, -7.13217407e-02f, -5.67849353e-02f, -5.86681142e-02f, -2.43431404e-02f, -3.98610644e-02f,
  5.50898053e-02f, -9.94665828e-03f, 1.38900742e-01f, -3.65133286e-02f, 9.30454507e-02f, -1.02723345e-01f, 6.10629795e-03f, 7.58059099e-02f, 1.32206142e-01f, 2.98085660e-02f,
  1.05526090e-01f, 1.34858668e-01f, 6.65485933e-02f, -2.15120576e-02f, 1.58986211e-01f, 6.68291897e-02f, 9.88416672e-02f, 6.60886839e-02f, 5.41619323e-02f, -3.91198741e-03f,
  9.63744521e-02f, -1.71264321e-01f, 3.11583430e-01f, 4.56105769e-02f, 1.18324049e-01f, 1.33669123e-01f, -2.53600270e-01f, 7.87736923e-02f, -2.78310627e-02f, -2.79631346e-01f,
  -2.52754152e-01f, 8.93366113e-02f, -1.87213406e-01f, -6.67175874e-02f, 6.32385015e-02f, -1.43702269e-01f, -1.46764919e-01f, -1.25431165e-01f, 9.99747217e-02f, -3.68670970e-02f,
  1.04423888e-01f, -2.28021368e-01f, 1.07235134e-01f, 4.45643030e-02f, 3.29316780e-02f, 7.51819909e-02f, -1.28502101e-01f, 2.28591766e-02f, 4.11875993e-02f, 1.01686701e-01f,
  1.08406236e-02f, -9.69883204e-02f, 2.20878795e-02f, 4.87636589e-02f, -4.98022996e-02f, -2.61683054e-02f, 5.42548858e-02f, -1.66829541e-01f, -4.28528525e-02f, 3.01980908e-04f,
  -8.84003267e-02f, 7.51684383e-02f, -3.45514081e-02f, 4.71835630e-03f, 2.36307215e-02f, 1.41068980e-01f, 2.73983721e-02f, 3.32685164e-03f, 6.61027655e-02f, 1.76935136e-01f,
  6.78822920e-02f, 1.01136751e-01f, 1.26951605e-01f, 4.24783751e-02f, 9.96718705e-02f, -1.39937568e-02f, 9.00333300e-02f, 3.60368043e-02f, 7.91908950e-02f, 1.61467865e-01f,
  -4.05010767e-02f, -8.50253701e-02f, 8.20649713e-02f, 2.99082045e-02f, -4.96132970e-02f, 4.58624475e-02f, -1.55284330e-02f, 3.81525792e-02f, 6.10401779e-02f, -7.25766877e-03f,
  3.38727832e-02f, 3.63491080e-03f, -8.41787457e-03f, -1.80961061e-02f, -5.17764688e-03f, 1.05019864e-02f, -1.40625024e-02f, 1.86614078e-02f, 4.59230319e-02f, -7.08838226e-03f,
  -4.49102186e-02f, 7.27237165e-02f, -1.37273744e-01f, -2.61299703e-02f, -4.49811853e-02f, -6.62320852e-02f, 9.05801579e-02f, 1.59453645e-01f, -2.90883183e-02f, 4.36637588e-02f,
  -1.66757360e-01f, -2.95446128e-01f, -9.89585444e-02f, 4.15208824e-02f, -7.55472854e-02f, 6.91560805e-02f, 2.51547955e-02f, -3.02535715e-03f, -1.37616515e-01f, -3.11549231e-02f,
  -1.53841712e-02f, -6.87487796e-02f, 3.61072421e-02f, -1.90070160e-02f, -1.35133177e-01f, 3.68132703e-02f, -5.14010787e-02f, -1.44819528e-01f, -1.07596844e-01f, -5.11803553e-02f,
  -5.64806163e-02f, -6.95581585e-02f, -1.21343965e-02f, 1.88078843e-02f, -6.89332113e-02f, 1.38617111e-02f, 4.51881327e-02f, 1.57283489e-02f, 6.03025071e-02f, 9.80728716e-02f,
  -2.01590374e-01f, 2.26063535e-01f, -2.61009306e-01f, -1.23389728e-01f, -1.54877335e-01f, 8.28172863e-02f, -3.07554659e-02f, 2.11922869e-01f, 3.99782136e-02f, 2.44039878e-01f,
  2.21787542e-01f, -1.29589498e-01f, 2.58251131e-01f, -6.28494099e-02f, -3.88109833e-01f, 1.56560585e-01f, 1.62632987e-01f, 7.76210204e-02f, 4.10896614e-02f, 9.82902758e-03f,
  -6.51828945e-02f, 6.25329539e-02f, -2.22081672e-02f, -5.68006746e-02f, -2.18877196e-01f, -2.15787128e-01f, -1.96932346e-01f, -1.93661511e-01f, -1.70063064e-01f, -1.06929898e-01f,
  7.81905726e-02f, 6.31198585e-02f, -1.49795469e-02f, 3.15054804e-02f, 6.37885258e-02f, 1.17836669e-01f, -7.54047558e-02f, -8.00959952e-03f, -2.52947863e-02f, 5.53831831e-02f,
  1.32883608e-01f, -9.96370763e-02f, -6.46933615e-02f, 7.65575320e-02f, 1.90196875e-02f, -1.17618218e-01f, 3.73474285e-02f, 1.33563340e-01f, 3.20609957e-02f, -4.15374245e-03f,
  8.05407111e-03f, -4.91894595e-02f, 2.69800909e-02f, -3.60839590e-02f, -7.67978951e-02f, 4.99516167e-02f, -1.31763387e-02f, -1.04808845e-01f, -1.11746289e-01f, -1.07894786e-01f,
  -1.36102527e-01f, 1.11519121e-01f, 5.92658930e-02f, 5.52733019e-02f, -3.30881439e-02f, -1.07488595e-03f, 1.06597863e-01f, -1.98926358e-03f, -5.22330292e-02f, 7.93834403e-02f,
  5.49482135e-03f, 8.55136737e-02f, 1.80548187e-02f, 7.12063909e-02f, 1.96048722e-01f, 5.30807972e-02f, -1.30719030e-02f, 1.60461500e-01f, 3.72471809e-02f, -5.72122335e-02f,
  1.69036947e-02f, -2.46524643e-02f, -1.53568983e-02f, -8.83192793e-02f, 4.34827060e-03f, -8.93320590e-02f, 1.09203853e-01f, 8.63989294e-02f, -3.27629671e-02f, -5.01665883e-02f,
  1.82306409e-01f, 2.63017276e-03f, 8.25144723e-02f, -1.42391054e-02f, 1.75202899e-02f, 4.26663226e-03f, -2.56037693e-02f, -1.19149089e-02f, 3.23622636e-02f, 2.98838858e-02f,
  2.01781839e-01f, -6.92508668e-02f, -1.36224374e-01f, -1.07288703e-01f, 4.01832648e-02f, -6.03380315e-02f, 1.90041605e-02f, 6.27813861e-02f, 3.45173106e-02f, 1.71994135e-01f,
  1.14831202e-01f, -6.00347221e-02f, 7.44355842e-04f, -7.03160167e-02f, 1.26543686e-01f, 3.78592983e-02f, -1.14383074e-02f, 4.40576449e-02f, -3.09539195e-02f, -1.78561360e-02f,
  -3.31623971e-01f, 3.61818910e-01f, -5.40561005e-02f, -3.24245542e-01f, -9.63820741e-02f, -2.05283016e-01f, -1.71650454e-01f, -2.16545649e-02f, -5.88967055e-02f, 2.03889832e-01f,
  -1.20040260e-01f, 8.79319459e-02f, 1.09697096e-01f, -2.00857997e-01f, -3.62476945e-01f, 2.32585911e-02f, -2.71165967e-01f, -4.11230586e-02f, -7.39093423e-02f, -4.35497761e-02f,
  -1.09103814e-01f, -1.83600932e-01f, -1.16407126e-01f, 8.01428929e-02f, -1.54569959e-02f, 1.41139641e-01f, 4.64519337e-02f, 1.80838838e-01f, -8.19278061e-02f, 3.79057345e-03f,
  -1.07335262e-02f, -1.73282884e-02f, 2.41243541e-02f, 1.71657298e-02f, -1.09327964e-01f, -3.09421532e-02f, 5.87201165e-03f, 2.48688404e-02f, -8.05719271e-02f, -3.94219235e-02f,
  1.52937705e-02f, -3.05397697e-02f, 1.22351199e-02f, 3.52722518e-02f, 2.36120503e-02f, 8.58882666e-02f, -7.15660304e-02f, 9.19804908e-03f, -1.51389493e-02f, 5.61972568e-03f,
  -5.94583471e-05f, -8.49149935e-03f, -1.22833438e-01f, 6.51700562e-03f, -4.49411683e-02f, -6.62080273e-02f, -2.28838343e-02f, 8.14170539e-02f, 2.99841221e-02f, -5.77140115e-02f,
  2.54516304e-02f, -1.10633262e-01f, 9.00454447e-03f, 8.68546963e-03f, -3.67553420e-02f, 5.60500100e-02f, -5.69508635e-02f, -3.58299981e-03f, 2.15165354e-02f, -3.86461802e-02f,
  -7.97129273e-02f, 3.05713192e-02f, -7.02516362e-02f, 2.22178362e-02f, -1.43259153e-01f, -2.88199745e-02f, -1.74392983e-02f, 6.00699931e-02f, -3.36609185e-02f, 4.03865092e-02f,
  2.47417986e-02f, 1.42999003e-02f, 5.03363311e-02f, 7.75714219e-02f, -4.77264635e-03f, 4.99548800e-02f, -9.94319990e-02f, -3.11377384e-02f, 8.07945244e-03f, -7.00935721e-02f,
  3.87548767e-02f, -2.89960355e-02f, 2.80516222e-03f, 1.16000790e-02f, 5.36243506e-02f, 4.22813036e-02f, 3.72413881e-02f, 2.77182013e-02f, -2.13254895e-02f, -2.20200829e-02f,
  -6.02408387e-02f, 7.92016685e-02f, 3.86936180e-02f, 6.87434226e-02f, -1.94114875e-02f, 5.05504161e-02f, -7.64539167e-02f, 1.45508181e-02f, -5.49764484e-02f, -1.01508230e-01f,
  -7.54295522e-03f, 6.10006452e-02f, -1.46330729e-01f, 3.09654977e-02f, -6.85366243e-02f, -1.13993153e-01f, -1.49867078e-02f, 1.70027334e-02f, -1.71768144e-02f, 4.24179956e-02f,
  -1.91872910e-01f, -4.41752821e-01f, -2.21883580e-01f, 6.74879774e-02f, 7.66233951e-02f, -1.10696830e-01f, -2.23280508e-02f, -1.47750914e-01f, -2.45034426e-01f, -2.91735202e-01f,
  1.82040364e-01f, -1.94570228e-01f, 3.17292437e-02f, 3.07997242e-02f, 1.73346147e-01f, 2.20033392e-01f, 2.45747685e-01f, 8.14102739e-02f, 1.96244836e-01f, 1.18784145e-01f,
  1.01941355e-01f, 2.51073360e-01f, 2.90340543e-01f, 1.15557373e-01f, 4.97514345e-02f, -9.28492397e-02f, 7.40068033e-02f, -3.70762718e-04f, 3.45339789e-03f, -5.96272014e-02f,
  1.62885636e-01f, -3.09756752e-02f, -1.43689085e-02f, 2.00712890e-03f, 3.08792964e-02f, -6.78928988e-03f, 4.77187969e-02f, 1.04385242e-01f, 1.24120198e-01f, 2.94927265e-02f,
  3.64855155e-02f, 6.84268996e-02f, -5.99179417e-02f, 5.98855270e-03f, -5.31376377e-02f, -3.63160148e-02f, 4.58020046e-02f, 4.55326401e-02f, 1.05807252e-01f, -5.31818084e-02f,
  -7.28635304e-03f, -6.50168583e-02f, 9.44586378e-03f, 3.56783457e-02f, 6.47804290e-02f, -6.78789616e-02f, -3.60470414e-02f, -7.16446191e-02f, -7.73224011e-02f, -1.34416357e-01f,
  -1.34804219e-01f, 8.01783949e-02f, 9.18773115e-02f, 7.44918659e-02f, 4.95718494e-02f, 7.59845600e-02f, 9.47814509e-02f, 7.77010918e-02f, 4.01521176e-02f, 4.75502089e-02f,
  8.03176016e-02f, 5.01390838e-04f, 8.56109560e-02f, 8.48987605e-03f, 7.33371526e-02f, -4.71734144e-02f, 1.45664528e-01f, -1.53163336e-02f, 1.33304019e-02f, 1.52455434e-01f,
  3.36972997e-02f, 2.92914035e-03f, 6.31375164e-02f, 1.09329119e-01f, -3.30365635e-02f, 1.24282353e-02f, -2.70813983e-03f, -1.92019530e-02f, 4.40362357e-02f, 4.16618735e-02f,
  -1.60559488e-03f, -1.66773051e-01f, 5.43375276e-02f, 6.61874041e-02f, 5.19639365e-02f, -2.46443674e-02f, 6.21922687e-02f, 1.07546926e-01f, -6.44889940e-03f, 1.17109362e-02f,
  7.05764890e-02f, 8.26220065e-02f, -6.48048595e-02f, 4.93494719e-02f, 6.10771403e-02f, -8.13587755e-02f, -9.77715128e-04f, 8.01909044e-02f, 1.00038409e-01f, -5.35871387e-02f,
  7.33888969e-02f, 5.69837838e-02f, 6.70714974e-02f, 9.62760448e-02f, 8.27542767e-02f, 2.08575632e-02f, -8.76269639e-02f, -1.51557073e-01f, 7.69960508e-02f, -7.56728873e-02f,
  -2.35676333e-01f, -2.53663510e-01f, -1.58524394e-01f, -6.90023601e-02f, -1.14519700e-01f, 2.57087678e-01f, 1.28707200e-01f, -6.14045560e-02f, -9.31743011e-02f, 7.86678493e-02f,
  2.67634988e-01f, -1.96334139e-01f, 2.18686640e-01f, 1.45683974e-01f, 3.95269245e-01f, 3.21258187e-01f, 2.20995814e-01f, 1.25176981e-01f, -5.14397845e-02f, -7.85979480e-02f,
  -3.24765481e-02f, 2.16580495e-01f, 5.75300641e-02f, -8.54251310e-02f, -1.79713219e-01f, -3.51569235e-01f, 1.50832638e-01f, -8.98809060e-02f, 1.10823408e-01f, 1.38881236e-01f,
  8.53455737e-02f, -1.61550581e-01f, -1.03264779e-01f, 4.06117588e-02f, 3.23235355e-02f, 8.02527741e-02f, 9.28060859e-02f, 1.95291732e-02f, 2.52026189e-02f, 2.42033489e-02f,
  -1.55546125e-02f, 4.51273844e-03f, -6.01948574e-02f, 5.01133278e-02f, -3.83805670e-02f, -3.59369479e-02f, -3.86721455e-03f, 5.34070544e-02f, -4.43961546e-02f, -7.61569962e-02f,
  -5.52402949e-03f, 2.39534280e-03f, -6.89052269e-02f, 2.81862337e-02f, -8.18614140e-02f, -9.73317027e-02f, -7.52126351e-02f, -3.90093513e-02f, 2.19132658e-02f, -9.16807428e-02f,
  -4.80118411e-04f, 9.50526737e-04f, 6.82430947e-03f, 4.63986918e-02f, 2.37501841e-02f, -3.22929211e-02f, 2.60055661e-02f, 2.06287056e-02f, -9.07089114e-02f, 5.19300951e-03f,
  5.61305769e-02f, -9.19713899e-02f, 7.34367147e-02f, 9.31321084e-03f, 2.25000586e-02f, -9.15110558e-02f, 4.74468507e-02f, 3.63632888e-02f, -5.80310412e-02f, -2.04268564e-02f,
  7.81455487e-02f, 6.33173063e-02f, 6.74097100e-03f, 3.74420919e-02f, 1.27947077e-01f, -2.40217112e-02f, 7.27762878e-02f, 8.44863728e-02f, 3.66172604e-02f, 1.12041496e-01f,
  1.68905228e-01f, -3.20396051e-02f, -9.75930318e-03f, 1.49647789e-02f, 6.95806816e-02f, 8.77699405e-02f, -2.33652908e-02f, -9.07780454e-02f, 6.68528304e-02f, 5.74524850e-02f,
  2.69614793e-02f, -4.54391614e-02f, 1.54163884e-02f, -5.05917519e-02f, 3.95466276e-02f, -1.86057612e-02f, 7.52703249e-02f, 4.17259745e-02f, 7.26724863e-02f, -1.83077380e-02f,
  1.16160298e-02f, -3.87739502e-02f, -8.13402757e-02f, -9.41266194e-02f, -2.74666231e-02f, -1.06017590e-02f, -4.68337797e-02f, -4.70367856e-02f, 3.12808082e-02f, 3.41585539e-02f,
  3.82017851e-01f, 1.10114180e-01f, 3.75641393e-03f, 2.58664638e-01f, -2.75275344e-03f, 1.16485178e-01f, 2.09982425e-01f, 1.63142204e-01f, 1.11576505e-01f, -4.25057001e-02f,
  2.53649298e-02f, 1.16405234e-01f, -1.45802483e-01f, 1.75448880e-01f, 2.34467998e-01f, -1.54543802e-01f, 2.89730996e-01f, 1.91650644e-01f, -2.23858431e-02f, 2.09850013e-01f,
  8.48238319e-02f, 1.45539343e-01f, 1.25477267e-02f, -6.99566752e-02f, 8.77774134e-02f, -3.35338302e-02f, -9.67100933e-02f, -1.83097199e-01f, 1.17474221e-01f, -5.61450496e-02f,
  9.28316265e-02f, 1.16477363e-01f, -6.08363077e-02f, 5.31948591e-03f, -2.93142851e-02f, -9.75095406e-02f, -3.79877836e-02f, -4.30472419e-02f, -3.14128958e-03f, 1.47898514e-02f,
  1.32506127e-02f, 4.35532853e-02f, 8.01615510e-03f, -6.70621395e-02f, 3.17989290e-02f, -8.26865509e-02f, -1.17656002e-02f, 5.03587443e-03f, -1.88806802e-02f, -3.90242450e-02f,
  -1.57265142e-02f, -2.06695423e-02f, -1.00562602e-01f, -2.24093571e-02f, 5.85230812e-03f, 6.21574782e-02f, -6.05420358e-02f, -7.13555738e-02f, -7.96629116e-02f, -4.61754575e-02f,
  -2.24099439e-02f, -4.07748250e-03f, -7.72739500e-02f, 7.41821006e-02f, 4.54583615e-02f, -6.47409037e-02f, 3.80981863e-02f, -3.94801870e-02f, -1.02889255e-01f, 1.94965061e-02f,
  1.61844473e-02f, 6.27823174e-02f, 3.05646658e-02f, 3.78660038e-02f, 2.58912425e-02f, 8.48410726e-02f, 3.05158999e-02f, 8.44830647e-02f, -1.77858900e-02f, 1.55181969e-02f,
  2.55289022e-04f, 2.03446448e-02f, 4.32550684e-02f, -6.88446462e-02f, 9.95595753e-03f, 1.15401670e-02f, -4.71680276e-02f, 4.27335501e-02f, -3.44208232e-03f, 3.33788879e-02f,
  2.24031612e-01f, 2.43338451e-01f, -4.69516888e-02f, 5.20989709e-02f, -1.87309191e-03f, -1.01621523e-01f, -2.67967433e-02f, 9.44721512e-04f, 8.45437422e-02f, 4.10725810e-02f,
  8.40509608e-02f, -3.43699344e-02f, -5.14108241e-02f, -8.66458863e-02f, 8.73959661e-02f, -8.78132731e-02f, 1.19167484e-01f, -1.51843345e-03f, 5.10382615e-02f, 1.61392823e-01f,
  1.08454846e-01f, -1.84597373e-02f, -7.43459612e-02f, -6.35508150e-02f, 4.56192233e-02f, 1.28358498e-01f, 2.97563262e-02f, -3.59094911e-03f, -7.35908821e-02f, -1.19965203e-01f,
  -3.93064916e-02f, -4.21910942e-01f, -2.36938342e-01f, -5.73573168e-03f, 1.02212265e-01f, -2.70356387e-01f, -2.08823681e-01f, 4.20756713e-02f, 8.22180416e-03f, -2.04049438e-01f,
  1.80893280e-02f, -9.23887193e-02f, -1.21523783e-01f, -1.46524012e-01f, -2.46305406e-01f, -1.04306459e-01f, -1.89479902e-01f, -1.74201325e-01f, 6.28791228e-02f, -7.11131021e-02f,
  -4.44893949e-02f, -1.00119244e-02f, -4.58114557e-02f, 1.22004844e-01f, -1.00900449e-01f, 9.79117453e-02f, 1.47387058e-01f, 3.45920511e-02f, 4.81511503e-02f, 7.49691501e-02f,
  -4.37683202e-02f, 4.36879173e-02f, -3.88030824e-03f, -2.19402537e-02f, -3.38827297e-02f, 5.95363975e-02f, -1.08919114e-04f, -5.49481921e-02f, 2.26163045e-02f, 5.39758466e-02f,
  -1.20999161e-02f, 1.30915660e-02f, 4.13579904e-02f, -4.34454978e-02f, -2.06929725e-03f, -8.66521033e-04f, -6.58859266e-03f, -5.85133210e-02f, 4.65673134e-02f, -5.57136685e-02f,
  -3.49700451e-02f, -7.31450915e-02f, 2.45827474e-02f, 2.23616436e-02f, -5.25204055e-02f, -6.08937698e-04f, -4.63474952e-02f, -1.75267868e-02f, -1.56120127e-02f, 3.59050483e-02f,
  2.15514284e-02f, -2.69636940e-02f, -1.68941915e-02f, 1.26093272e-02f, -4.92492411e-03f, 6.22133501e-02f, -3.73919308e-02f, 6.78198710e-02f, -5.31010665e-02f, -3.19594592e-02f,
  5.08280881e-02f, -5.34132980e-02f, 6.60380498e-02f, -7.99534693e-02f, 8.04492533e-02f, 6.91057323e-03f, -4.71875966e-02f, 2.69836816e-03f, 4.63539250e-02f, 2.98010074e-02f,
  1.38686048e-02f, -1.58699974e-02f, -4.75555435e-02f, 2.40578465e-02f, -5.29778861e-02f, -1.18067719e-01f, 6.42502531e-02f, 3.44259068e-02f, 6.56941235e-02f, -1.54325971e-02f,
  -8.64896029e-02f, -1.66228786e-01f, -1.70452578e-03f, -1.00986622e-02f, 2.66186311e-03f, -5.85222207e-02f, -8.49555656e-02f, -3.60583588e-02f, -4.49390188e-02f, -3.42313685e-02f,
  -1.61175281e-02f, -3.25041637e-02f, 6.44104108e-02f, 5.82567009e-04f, -2.04265025e-02f, -6.93855435e-02f, 5.75390924e-03f, 1.54770389e-02f, 6.93965703e-02f, 5.23612089e-02f,
  2.87462976e-02f, -4.96485420e-02f, 5.57756089e-02f, 1.68235172e-02f, 2.23179832e-02f, 7.56815076e-02f, 4.68645133e-02f, 1.13016507e-02f, -2.16105450e-02f, -1.09063163e-02f,
  -3.85982305e-01f, 2.71064609e-01f, 1.66224942e-01f, -6.64235353e-02f, -3.93334702e-02f, -3.12309712e-01f, -2.68436015e-01f, 2.45725110e-01f, 1.94569805e-03f, 7.88360462e-02f,
  -2.19244882e-02f, -2.38751099e-02f, 2.22638234e-01f, -1.07848316e-01f, -2.79964566e-01f, 1.76359013e-01f, -1.81127518e-01f, -1.22196369e-01f, 1.01969384e-01f, 1.09397701e-03f,
  -9.69434157e-02f, -1.14002123e-01f, 1.81858256e-01f, 5.21280840e-02f, -9.27829370e-02f, 1.59575462e-01f, 8.08204114e-02f, 1.25236198e-01f, 1.26706678e-02f, -6.52235076e-02f,
  -3.09653655e-02f, 3.90400551e-02f, 9.28648096e-03f, -1.97107177e-02f, -5.10917231e-02f, -1.31675646e-01f, -5.13202772e-02f, -4.31079194e-02f, 6.01172745e-02f, 9.92436185e-02f,
  8.89994018e-03f, 2.19825376e-02f, 5.22919632e-02f, -1.49624450e-02f, -1.02178372e-01f, 6.37591481e-02f, 9.53150466e-02f, 2.06064302e-02f, 7.06118122e-02f, -2.68783513e-02f,
  6.56954050e-02f, 2.17309464e-02f, -4.68951873e-02f, 2.16659252e-02f, -1.92461871e-02f, -1.78517459e-03f, -5.00141531e-02f, -5.41054010e-02f, -2.39680428e-02f, -4.22130264e-02f,
  -5.35129011e-02f, -1.84166171e-02f, 1.37321120e-02f, 4.03081775e-02f, -3.68158938e-03f, -7.62702548e-04f, -5.57928123e-02f, -4.23530601e-02f, 3.16880236e-04f, 7.04775471e-03f,
  1.39715811e-02f, -1.44470460e-03f, -6.33168826e-03f, -6.64749518e-02f, -2.04236899e-02f, -4.22294289e-02f, -4.09490727e-02f, 6.20289147e-02f, -4.96346019e-02f, 2.03618295e-02f,
  4.48258407e-02f, -1.11457959e-01f, 2.20089555e-02f, -7.01488182e-03f, 4.79570478e-02f, 6.32041544e-02f, -2.55804248e-02f, 7.60245621e-02f, 5.04865535e-02f, -5.03128506e-02f,
  -1.09941736e-01f, 6.43225983e-02f, 6.93422183e-02f, -3.26622874e-02f, 5.66864945e-02f, -7.40054026e-02f, -7.70255625e-02f, -4.03895490e-02f, 9.47500207e-03f, -2.61039641e-02f,
  -6.39544204e-02f, 5.30360304e-02f, -1.11351591e-02f, -7.64071569e-02f, 5.61037986e-03f, 7.01446645e-03f, -3.18460837e-02f, 4.11581807e-02f, -2.25759912e-02f, 3.44490521e-02f,
  5.71559034e-02f, 5.07183820e-02f, 5.00326902e-02f, 1.72220562e-02f, -1.67118926e-02f, 3.33588757e-02f, -4.67536934e-02f, 4.29840498e-02f, -2.70763785e-02f, -4.94823977e-03f,
  6.16874620e-02f, 1.52411014e-01f, -1.82446048e-01f, -1.39269322e-01f, 3.21936548e-01f, -6.82398379e-02f, -1.47313103e-01f, 2.54541159e-01f, -1.74537212e-01f, -2.38540582e-03f,
  1.09211519e-01f, 5.02185412e-02f, -3.20089124e-02f, -7.71236718e-02f, -2.64225677e-02f, -1.91192150e-01f, -9.85190943e-02f, -7.79387727e-02f, -4.60913032e-02f, 2.90084407e-02f,
  -1.42996132e-01f, 1.19183987e-01f, -1.35133088e-01f, 1.42354339e-01f, 8.35792720e-02f, 2.29195673e-02f, 1.47898257e-01f, 1.84760932e-02f, 7.01158345e-02f, 3.86970416e-02f,
  9.35995355e-02f, -4.10073251e-02f, -4.72225361e-02f, -5.24784215e-02f, 3.60565935e-03f, 1.75885689e-02f, -5.65726794e-02f, 1.54766226e-02f, 6.80924999e-03f, -2.17485614e-02f,
  1.04345959e-02f, 7.62059540e-02f, -8.91747978e-03f, -1.20409660e-01f, 6.78809360e-02f, -1.05265193e-01f, 4.43937108e-02f, -8.54736492e-02f, 6.76814234e-03f, -4.01791632e-02f,
  -1.45838767e-01f, -1.24829382e-01f, -1.42924219e-01f, -4.36765552e-02f, -8.47310573e-02f, -6.13407679e-02f, -1.19571060e-01f, -3.68659198e-02f, 4.12446670e-02f, -6.23594411e-02f,
  1.34486835e-02f, -6.99266568e-02f, -1.20740784e-02f, 1.57521348e-02f, 9.01242867e-02f, 5.44852577e-02f, -7.59967491e-02f, 3.65033038e-02f, -4.83611263e-02f, 6.86129406e-02f,
  1.07136138e-01f, 2.75050513e-02f, 5.49375378e-02f, -8.28476623e-02f, -1.68482028e-02f, -1.05603166e-01f, 4.26720195e-02f, 1.15938663e-01f, -1.60074174e-01f, 4.08757702e-02f,
  3.57833654e-02f, 2.72056796e-02f, 6.48203641e-02f, -1.27737811e-02f, -1.12002734e-02f, -2.24568248e-02f, -4.13114093e-02f, -4.77604195e-02f, 2.92636622e-02f, -1.32946984e-03f,
  1.91924632e-01f, 1.40620708e-01f, 1.12410029e-02f, 5.36255501e-02f, 5.66789173e-02f, 9.59918089e-03f, -1.13562293e-01f, 1.41771697e-02f, 8.41720551e-02f, -5.03077246e-02f,
  -3.66704538e-02f, 3.04698460e-02f, -1.22952252e-03f, -1.00352198e-01f, 9.06775817e-02f, -2.01824470e-03f, 2.95104347e-02f, -2.00081524e-02f, 3.98073420e-02f, 1.77916363e-01f,
  9.33487490e-02f, -2.55709682e-02f, -1.21416925e-02f, -5.78531995e-02f, 3.39299515e-02f, 1.21256046e-01f, 8.18691552e-02f, -8.32130834e-02f, -1.78627074e-02f, -1.18743941e-01f,
  2.28944868e-01f, -5.91454282e-02f, -1.02207534e-01f, 1.80181384e-01f, 9.91920289e-03f, 1.95821360e-01f, 2.60192603e-01f, -8.50041211e-02f, 4.89633009e-02f, 1.05627030e-01f,
  5.91975674e-02f, 6.27475008e-02f, -9.58889946e-02f, 2.78549463e-01f, -2.05194682e-01f, -7.78365582e-02f, 1.38576120e-01f, 1.47694856e-01f, -1.45989992e-02f, 4.68934737e-02f,
  4.86980677e-02f, 9.92928967e-02f, -4.06456999e-02f, -1.11022577e-01f, 1.52888358e-01f, -3.97003628e-02f, -2.77002990e-01f, -2.28568148e-02f, 9.90721658e-02f, 1.83017887e-02f,
  1.59755617e-01f, 2.38931030e-02f, 3.83108333e-02f, 4.55908142e-02f, 2.82734446e-02f, 7.87130073e-02f, -2.69140508e-02f, -8.15583766e-02f, 4.78434861e-02f, 6.69099987e-02f,
  5.14014289e-02f, 1.42349424e-02f, -1.97700653e-02f, -4.51150760e-02f, 1.88715413e-01f, 1.12169264e-02f, 4.34775390e-02f, 1.42063191e-02f, -1.09037478e-02f, 3.69717143e-02f,
  -1.21773230e-02f, 4.01817933e-02f, 1.62659138e-02f, -1.57453753e-02f, -2.55832318e-02f, -9.51830356e-04f, -3.01927868e-02f, -5.45406528e-02f, 1.00180702e-02f, -1.53615503e-02f,
  -3.80144939e-02f, 2.19890126e-03f, 3.00937938e-03f, 5.23736067e-02f, -2.19296720e-02f, -3.13320234e-02f, -1.98920359e-04f, 3.06963325e-02f, -7.14041442e-02f, 1.10515878e-02f,
  8.63007233e-02f, 2.33947057e-02f, -1.28788082e-02f, 8.30220175e-04f, 4.23505977e-02f, 2.60182656e-03f, -3.95666584e-02f, 2.68309526e-02f, 4.56415638e-02f, -6.07541911e-02f,
  -2.18164306e-02f, 4.56607947e-03f, 1.19106919e-02f, 2.93694139e-02f, 6.61944970e-02f, 1.01909041e-02f, 3.64959389e-02f, 3.94412801e-02f, -2.24521477e-02f, -4.36863303e-02f,
  -1.46795750e-01f, -1.76184446e-01f, -2.67080422e-02f, 6.61218166e-02f, -6.60540089e-02f, 2.46584043e-02f, 5.09365927e-03f, -9.11179334e-02f, -4.67191217e-03f, 1.75410975e-02f,
  1.40842926e-02f, -1.38894049e-02f, 1.15416981e-02f, -5.00837415e-02f, -8.76742136e-03f, -1.16617545e-01f, 5.11401184e-02f, -1.39863603e-02f, -6.33235723e-02f, -5.39553016e-02f,
  -1.44188162e-02f, 9.69938561e-03f, -3.48604321e-02f, 1.51872700e-02f, -1.25554306e-02f, 2.21761502e-02f, 7.65489973e-03f, 5.55137955e-02f, -5.99937811e-02f, -3.71634848e-02f
};

// L0_fan_Wp_bar (Shape: 104 x 120)
const int L0_fan_Wp_bar_rows = 104;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.17571092e-01f, 9.52365994e-02f, -2.80805945e-01f, -1.73755646e-01f, -1.46793097e-01f, -2.85459667e-01f, -1.89702362e-02f, -2.29458094e-01f, 1.05493721e-02f, 2.95975894e-01f,
  8.94370750e-02f, -1.16697229e-01f, 2.28311107e-01f, -8.34075792e-04f, -3.11264932e-01f, 2.12331176e-01f, -1.06901079e-01f, -2.01874245e-02f, 8.86687487e-02f, -1.79090664e-01f,
  -1.07793272e-01f, -1.24506876e-01f, -2.09039122e-01f, 5.99812530e-02f, -3.26385826e-01f, -8.23705737e-03f, 1.21820390e-01f, 4.78859358e-02f, -1.44062206e-01f, -1.03672510e-02f,
  -2.21259803e-01f, 7.93891307e-03f, -7.84192700e-03f, 3.62565625e-03f, 1.87777507e-03f, 2.49729827e-02f, -2.57561617e-02f, 7.67383799e-02f, 4.22426276e-02f, 6.12013647e-03f,
  6.54532015e-03f, -6.04719408e-02f, 9.66949165e-02f, 1.60595968e-01f, -2.73731239e-02f, -6.65255338e-02f, -1.26832440e-01f, -5.91503382e-02f, -6.61375150e-02f, -1.02783471e-01f,
  -1.30475581e-01f, -3.13538350e-02f, -8.54402483e-02f, -2.57297475e-02f, -1.37737572e-01f, -9.70870163e-03f, -4.08325018e-03f, -4.13913615e-02f, -4.23063822e-02f, -9.09179896e-02f,
  4.15758742e-03f, 4.30459231e-02f, 6.78304536e-03f, -5.95394373e-02f, 6.61818385e-02f, -5.74627928e-02f, 7.88108911e-03f, 2.60860771e-02f, 6.19206540e-02f, -1.30855039e-01f,
  -3.62777524e-02f, -7.28440508e-02f, -8.22663598e-04f, 7.32221752e-02f, -3.54348160e-02f, 7.59140924e-02f, -4.59908359e-02f, -5.00807874e-02f, -4.34332453e-02f, -1.53303090e-02f,
  -6.22831061e-02f, 8.40835646e-02f, 2.32681558e-02f, 6.69836327e-02f, 3.43489312e-02f, 9.41879407e-04f, 1.45518770e-02f, 9.19023622e-03f, -1.63311251e-02f, -1.15357488e-01f,
  -2.93833435e-01f, -2.00444341e-01f, -8.62232074e-02f, -6.64753094e-02f, 1.10440716e-01f, -4.40829992e-02f, 9.52544659e-02f, 2.77913525e-04f, -1.45627603e-01f, 6.90790489e-02f,
  -4.41072369e-03f, -4.79992405e-02f, -2.18099784e-02f, 1.56792507e-01f, -1.63926613e-02f, -4.85860258e-02f, -1.78055856e-02f, -1.01550426e-02f, -5.38736470e-02f, -5.67206629e-02f,
  -4.91577871e-02f, 1.73709635e-02f, -8.78595263e-02f, 4.67640609e-02f, 4.68620509e-02f, -6.06935173e-02f, -4.17200886e-02f, 4.90175560e-02f, -3.44038904e-02f, 3.96212265e-02f,
  -5.30747771e-01f, 4.90795597e-02f, 1.61578551e-01f, -9.66434404e-02f, -1.16456032e-01f, 2.88293242e-01f, 1.95480689e-01f, -8.59359875e-02f, -7.98037350e-02f, 1.58499718e-01f,
  -1.49899600e-02f, -7.97684863e-02f, 2.07051098e-01f, 1.43510476e-01f, 2.45231062e-01f, 2.13816822e-01f, 3.92474979e-02f, 1.92401372e-02f, -2.00542994e-02f, -8.17909017e-02f,
  -1.16535462e-01f, -6.19189627e-02f, 2.36907020e-01f, -3.49437967e-02f, -1.29607171e-01f, -1.22044995e-01f, -7.31295422e-02f, 9.65876654e-02f, 3.46822180e-02f, 6.39289543e-02f,
  -1.42963216e-01f, -3.11236322e-01f, -1.20152012e-01f, -2.53087971e-02f, -1.24586195e-01f, 2.38278247e-02f, -7.01276725e-03f, 1.91352032e-02f, 1.19935162e-02f, -5.13468636e-03f,
  -3.73131707e-02f, -1.84353273e-02f, 5.90962963e-03f, 8.63109902e-02f, -6.40240833e-02f, -2.23898087e-02f, 3.23266126e-02f, 3.84078436e-02f, -9.27765574e-03f, 1.84620149e-03f,
  2.06637792e-02f, 6.59510344e-02f, 2.83724871e-02f, -2.96855308e-02f, 1.29456539e-02f, -1.73659213e-02f, -1.82533376e-02f, -2.43277699e-02f, -1.51753686e-02f, 2.05261316e-02f,
  3.40086105e-03f, 2.36871634e-02f, -3.14373299e-02f, -4.07677889e-02f, 3.02913021e-02f, 2.84810811e-02f, -1.06723094e-02f, 3.31477672e-02f, 6.78549036e-02f, 5.37033826e-02f,
  -4.80062589e-02f, -8.71640146e-02f, -1.05059102e-01f, 2.16864478e-02f, -4.33242917e-02f, -1.03783123e-01f, -7.00685382e-02f, -1.08385377e-01f, -3.22961658e-02f, -4.10729013e-02f,
  4.28522527e-02f, 1.06090538e-01f, -4.41131331e-02f, -4.42014299e-02f, -9.07436386e-03f, 6.12292141e-02f, -4.93546501e-02f, -5.10787219e-03f, 1.62115283e-02f, -8.35393742e-03f,
  -1.37291461e-01f, -1.66217551e-01f, 3.74305844e-02f, -1.47325575e-01f, -4.67457473e-02f, -6.71288744e-02f, -3.08284406e-02f, -6.76907226e-02f, 5.42649329e-02f, -5.22569008e-03f,
  -3.58876511e-02f, -7.70821124e-02f, -2.55550314e-02f, -6.51218882e-03f, 2.76043005e-02f, -1.05492519e-02f, 7.11995130e-03f, 2.19800938e-02f, 5.83977476e-02f, -4.77088206e-02f,
  1.10798879e-02f, 1.38399266e-02f, 1.23145238e-01f, -9.64263678e-02f, 7.09527498e-03f, -2.69558746e-02f, -7.74639994e-02f, -8.01170338e-03f, 3.34161669e-02f, 3.12996656e-02f,
  -2.27452621e-01f, -6.22423850e-02f, -2.44816691e-01f, 6.85710311e-02f, 1.73941150e-01f, -2.35189795e-01f, -8.46131369e-02f, 2.19258107e-02f, 2.98898965e-02f, 1.13494605e-01f,
  3.50696407e-02f, -1.56178087e-01f, -3.38425711e-02f, -2.18396306e-01f, -4.84703869e-01f, -2.95454353e-01f, -1.73815280e-01f, -1.76883221e-01f, -6.83557689e-02f, -5.82176372e-02f,
  -1.72654316e-02f, 2.59516481e-02f, -1.43131033e-01f, 2.83799291e-01f, 2.22965516e-02f, 1.60751671e-01f, 2.69392341e-01f, 1.87232509e-01f, 5.88280745e-02f, -1.63223594e-02f,
  -6.91406578e-02f, -4.75927852e-02f, 3.07739619e-02f, 1.99300237e-02f, -3.88117470e-02f, 4.34849821e-02f, -3.26716080e-02f, 6.19773641e-02f, 3.78225520e-02f, 6.69598812e-03f,
  4.83524473e-03f, -6.07857527e-03f, 1.80056412e-02f, 2.07872745e-02f, 1.05724074e-01f, 2.47048382e-02f, -8.39381441e-02f, -6.18721433e-02f, 5.32441586e-02f, -6.02960251e-02f,
  -2.53738277e-02f, -5.32253645e-02f, 1.57634765e-02f, 5.61361499e-02f, -5.08921184e-02f, -6.09994754e-02f, 1.85539424e-02f, 3.17706764e-02f, 4.16340791e-02f, 4.64708991e-02f,
  3.89073160e-03f, -2.64484864e-02f, 2.30098572e-02f, -8.35447460e-02f, -9.60415322e-03f, 3.33206207e-02f, 7.20543414e-02f, 1.88328326e-02f, 5.25770783e-02f, -2.22704411e-02f,
  -4.54766676e-02f, -8.11538100e-02f, -2.26028301e-02f, 4.66522947e-02f, -4.49349433e-02f, 5.36033399e-02f, -1.02483016e-02f, 4.02389877e-02f, 8.52703676e-03f, -1.29411016e-02f,
  -9.88037419e-03f, 9.10406858e-02f, 8.68278593e-02f, 3.18445452e-02f, -1.07154302e-01f, 3.50953825e-02f, 6.42535985e-02f, -3.77165228e-02f, -1.86173003e-02f, -2.34040227e-02f,
  5.30289263e-02f, 6.93847835e-02f, -2.50689834e-02f, 9.66451317e-03f, -4.77386266e-02f, -1.44343069e-02f, -1.05328776e-01f, -7.68025294e-02f, 3.92165110e-02f, 1.76444687e-02f,
  -8.12451839e-02f, 9.00042877e-02f, 7.28437304e-03f, 3.20809446e-02f, 3.03219128e-02f, 1.32223517e-02f, 2.70085912e-02f, -4.65738587e-02f, 1.04400471e-01f, 7.48200491e-02f,
  4.94776256e-02f, 1.68262552e-02f, 4.33269255e-02f, 5.50244264e-02f, 8.10500085e-02f, 6.00070693e-02f, -5.11434488e-02f, 5.38945384e-02f, 8.09156373e-02f, 1.08236097e-01f,
  -3.17338020e-01f, 5.01786768e-01f, 3.21440876e-01f, -2.16074571e-01f, 2.70375665e-02f, 1.83236226e-02f, -1.52123213e-01f, 1.19024880e-01f, -1.34693995e-01f, 1.24904372e-01f,
  -1.56154737e-01f, 1.86305270e-01f, 2.15363782e-02f, -1.04262158e-01f, -4.24901754e-01f, -2.86308497e-01f, -2.83680886e-01f, -1.54649243e-01f, -1.08914033e-01f, -1.41572848e-01f,
  -1.95752919e-01f, -3.10662419e-01f, -7.51151815e-02f, 1.29416704e-01f, 1.06374450e-01f, 1.81604668e-01f, -1.31720811e-01f, 1.96360230e-01f, 2.74943840e-02f, 4.42419834e-02f,
  -4.47631516e-02f, -3.60336266e-02f, 2.74043567e-02f, 1.98606178e-02f, -4.91765589e-02f, -1.82646997e-02f, -1.91578716e-02f, -8.90835468e-03f, -8.28329101e-02f, -2.21781358e-02f,
  7.23045841e-02f, 2.41662599e-02f, -1.17413178e-02f, 6.94653094e-02f, 1.70441270e-02f, 1.01061732e-01f, 9.74150226e-02f, 5.01449145e-02f, 1.09587885e-01f, 6.75192475e-02f,
  1.19994991e-01f, 4.15140241e-02f, 1.95401814e-02f, -1.35232173e-02f, 3.69109912e-03f, 6.19704202e-02f, -3.03206798e-02f, -1.03933709e-02f, 4.76403162e-02f, -2.04323418e-02f,
  -3.85458320e-02f, -1.05641730e-01f, 5.77621385e-02f, -1.24938297e-03f, -8.33948776e-02f, 6.56574965e-02f, -2.98564229e-02f, -5.58941299e-03f, 3.36358976e-03f, 1.29813468e-02f,
  -5.52460663e-02f, -2.11762283e-02f, -2.67940201e-02f, 4.55899760e-02f, -9.28193927e-02f, -6.49272650e-02f, -9.45730601e-03f, -1.29889101e-02f, -6.55209348e-02f, 7.49193132e-03f,
  -4.30235593e-03f, 5.17154578e-03f, 4.03651558e-02f, -5.73276833e-04f, 2.24155001e-02f, -2.55042408e-03f, -2.77519692e-02f, 1.18893929e-01f, 6.92758616e-03f, 3.11243651e-03f,
  -2.10745081e-01f, -2.26346150e-01f, -6.93269819e-02f, 4.62295078e-02f, -3.89023721e-02f, -3.70561033e-02f, -1.96513124e-02f, 4.13010828e-02f, -3.79584767e-02f, -3.71581316e-02f,
  -2.31585987e-02f, 3.97242326e-03f, 5.84005453e-02f, -5.78265497e-03f, -2.42680535e-02f, -1.56778656e-02f, 4.45031561e-03f, 4.40526940e-02f, -8.65441840e-03f, -1.85758919e-02f,
  5.72846122e-02f, -2.92676389e-02f, 5.60985431e-02f, -2.04845630e-02f, -2.56536584e-02f, 7.08131567e-02f, 1.41418111e-02f, 7.47554675e-02f, -1.72824301e-02f, -1.21338768e-02f,
  -4.10571188e-01f, 1.73269406e-01f, -1.73360229e-01f, -2.16273308e-01f, -6.19961172e-02f, -5.22664711e-02f, 7.74227977e-02f, 8.92442763e-02f, 1.76274404e-01f, 1.46150216e-01f,
  8.08591619e-02f, -1.49043305e-02f, 3.24231356e-01f, 1.25872837e-02f, -1.57952160e-01f, 1.49070248e-01f, -2.24476218e-01f, -9.68125463e-02f, 1.11684792e-01f, -2.20414139e-02f,
  -1.41837195e-01f, -1.11958697e-01f, -1.91641748e-01f, -7.64245018e-02f, -3.43294710e-01f, -7.97870159e-02f, -1.77723765e-01f, 1.33613795e-01f, -2.86088496e-01f, 8.67056567e-03f,
  -2.51505643e-01f, 3.24893519e-02f, -1.56004235e-01f, -1.22073837e-01f, -2.18270913e-01f, -6.58959076e-02f, -1.02006815e-01f, 4.10057511e-03f, 7.71978423e-02f, 9.81914401e-02f,
  5.32448031e-02f, 5.59402518e-02f, -1.14069332e-03f, 1.39985159e-01f, 9.96373892e-02f, 4.12749536e-02f, -8.53575543e-02f, -6.70478940e-02f, -6.62180362e-03f, -6.84255594e-03f,
  -6.74763545e-02f, -3.08685191e-02f, -5.87561056e-02f, -1.00317448e-02f, -6.06841110e-02f, -2.47400929e-03f, -5.42147383e-02f, -8.72136056e-02f, -5.37924990e-02f, -1.30269215e-01f,
  7.08496757e-03f, 4.28432450e-02f, -6.12269230e-02f, -5.17711006e-02f, 1.05970912e-01f, -1.29239336e-01f, -1.27242049e-02f, -1.76083448e-03f, 6.14942387e-02f, -4.21231845e-03f,
  -5.52985724e-03f, 3.49246114e-02f, -3.83906700e-02f, -1.20321494e-02f, 8.34319741e-02f, 6.61708862e-02f, -4.00117636e-02f, 7.24124983e-02f, -1.07760578e-01f, -1.16929568e-01f,
  2.16587074e-02f, 1.14547886e-01f, -9.11736563e-02f, -4.99453619e-02f, -7.74347931e-02f, 4.51397523e-03f, -1.89158786e-02f, -3.32833081e-02f, -2.66273692e-02f, -5.45386635e-02f,
  -1.92883939e-01f, -4.56304625e-02f, 5.37159555e-02f, -1.38692141e-01f, -5.06292395e-02f, 8.78166058e-04f, 8.50345939e-02f, -7.57434443e-02f, -1.89602841e-02f, 2.85788737e-02f,
  6.89897016e-02f, -5.22228964e-02f, -4.14294526e-02f, 2.32768524e-02f, 1.41530886e-01f, -9.67658870e-03f, -1.54128904e-02f, 1.24439783e-02f, -2.34368015e-02f, 9.27380621e-02f,
  -1.06207812e-02f, 1.07619219e-01f, -5.28231543e-03f, -2.29784567e-02f, 5.19635621e-04f, -5.91323860e-02f, -7.34406710e-02f, -7.39489272e-02f, -6.38214722e-02f, 7.24507868e-03f,
  -4.48986828e-01f, 5.69336973e-02f, 3.24050069e-01f, -2.34723464e-01f, 1.16582990e-01f, 3.73276740e-01f, 5.99231385e-02f, -6.27650246e-02f, -2.12445250e-03f, -2.09578231e-01f,
  -2.30037481e-01f, -6.59592003e-02f, -1.48573652e-01f, -1.51178136e-03f, 2.13160530e-01f, -2.82219443e-02f, -4.55111898e-02f, -1.38125569e-03f, 8.14596862e-02f, -9.49544460e-02f,
  -2.26316340e-02f, -1.19172290e-01f, 4.03308161e-02f, 8.81557465e-02f, -7.77197927e-02f, 8.30247551e-02f, -1.15358658e-01f, 3.07986081e-01f, 9.86355841e-02f, 2.34090537e-01f,
  -8.79164711e-02f, -1.97707504e-01f, -8.33865851e-02f, -5.92706129e-02f, -6.39799386e-02f, 9.60405357e-03f, 8.68294612e-02f, 1.31369093e-02f, 5.14530167e-02f, 9.68775898e-03f,
  -5.41355982e-02f, 5.80745190e-03f, -2.24388056e-02f, 1.02263704e-01f, 1.04485443e-02f, -4.39754454e-03f, 5.07758581e-04f, -3.08929309e-02f, -5.19425683e-02f, 6.06867634e-02f,
  -7.25285485e-02f, 9.77202505e-03f, 6.83293715e-02f, 7.45055005e-02f, 5.32665141e-02f, 5.94581030e-02f, 4.05016802e-02f, 8.79780874e-02f, 8.57683569e-02f, 9.54071283e-02f,
  1.98011119e-02f, 1.28511325e-01f, 7.91727602e-02f, 1.02749001e-02f, 6.20083371e-03f, 1.83406174e-02f, -2.41794363e-02f, -1.07765034e-01f, 8.16191807e-02f, -2.33054142e-02f,
  -5.64307868e-02f, 1.81679837e-02f, 3.31051424e-02f, 1.05231643e-01f, 7.88326096e-03f, -1.85434163e-01f, 2.10498814e-02f, 6.50126934e-02f, 8.68687332e-02f, -5.52749224e-02f,
  -5.25792837e-02f, 2.91017853e-02f, -8.42221677e-02f, -3.17455232e-02f, 7.05530122e-02f, 7.29171857e-02f, 7.29457065e-02f, 2.60275155e-02f, -1.31800041e-01f, 1.28322784e-02f,
  3.59983882e-03f, -5.04831299e-02f, -3.54718454e-02f, -1.60340473e-01f, -3.54057457e-03f, 2.98510138e-02f, 1.10450998e-01f, -5.48622906e-02f, 3.40202823e-02f, -9.98380482e-02f,
  -5.95048778e-02f, -8.39933082e-02f, 4.91764918e-02f, 1.55096315e-02f, 5.97494505e-02f, -7.39113241e-02f, 4.55771852e-03f, -2.18916796e-02f, 3.08897626e-02f, -2.98496038e-02f,
  -8.67480412e-02f, -3.22179496e-02f, 2.09271163e-02f, 1.78000722e-02f, -7.65544921e-02f, -6.92077354e-02f, -7.02799931e-02f, -2.20368486e-02f, -1.41510135e-02f, -1.19302878e-02f,
  -2.38335517e-04f, -1.66504130e-01f, -5.62565662e-02f, -4.43428010e-02f, -2.23733678e-01f, -7.71541707e-03f, -7.93175027e-02f, -7.00023323e-02f, 1.74135752e-02f, -1.42807707e-01f,
  -1.45773038e-01f, 8.61961022e-02f, 1.46592468e-01f, -2.59135962e-01f, 1.32687643e-01f, 2.75895208e-01f, -3.24802217e-03f, 1.35935217e-01f, 3.70725468e-02f, -1.03969052e-01f,
  -1.58386678e-01f, -1.37284189e-01f, -3.19055025e-03f, -1.75219581e-01f, -3.14538926e-01f, -7.95958489e-02f, -5.44974469e-02f, -1.96524456e-01f, -1.54942140e-01f, -1.08837269e-01f,
  3.73226032e-02f, 1.77023665e-03f, -4.24837768e-02f, 1.07348390e-01f, -8.44389126e-02f, -6.63112327e-02f, -9.88249015e-03f, 1.24659307e-01f, 7.45450631e-02f, 9.59408935e-03f,
  6.38488904e-02f, 2.43978992e-01f, 4.21479456e-02f, -6.37763813e-02f, -1.75106823e-01f, 1.03055583e-02f, 1.27064988e-01f, -4.14032117e-02f, 7.51649514e-02f, -1.12532079e-01f,
  -4.94726822e-02f, -6.70367032e-02f, -1.19045809e-01f, 1.47122413e-01f, 9.42004547e-02f, 8.09197873e-02f, 7.01919571e-02f, 8.44466686e-02f, 3.04017793e-02f, 8.54244363e-03f,
  -9.22237039e-02f, 9.39129293e-02f, 1.68228906e-03f, -3.62528712e-02f, -4.85500246e-02f, 8.12011678e-03f, 2.40926445e-02f, -5.64777441e-02f, -2.63253190e-02f, 3.83498296e-02f,
  6.86253905e-02f, -7.91528374e-02f, 1.98699702e-02f, 9.20823216e-02f, -8.91379863e-02f, -4.78902757e-02f, -2.67156381e-02f, 3.51359956e-02f, -5.38895912e-02f, 3.27025615e-02f,
  -5.20453509e-03f, 1.19495001e-02f, 9.80030596e-02f, 1.04403272e-01f, -5.87232862e-05f, 1.13395199e-01f, 6.51433095e-02f, -7.18034282e-02f, 1.62956789e-02f, -4.96045873e-02f,
  9.89905968e-02f, 3.53351124e-02f, 8.85324106e-02f, 1.50683463e-01f, 3.18624005e-02f, -1.78275570e-01f, -7.28706494e-02f, 2.51862332e-02f, -1.02978507e-02f, -8.72784555e-02f,
  -9.27267969e-02f, 1.63722128e-01f, 1.21043831e-01f, -8.83006155e-02f, 5.43660484e-02f, 7.71413790e-03f, 9.54335332e-02f, 7.81910121e-02f, 1.08612239e-01f, -2.05835905e-02f,
  6.16585761e-02f, -8.06939695e-03f, 1.31532967e-01f, 4.77548800e-02f, 4.45368998e-02f, 6.07256852e-02f, 5.65772131e-02f, -5.97102335e-04f, -4.72113816e-03f, 3.93107235e-02f,
  2.14182377e-01f, -1.66142583e-01f, 2.04980835e-01f, 9.15295035e-02f, 1.40229762e-01f, -1.73398852e-01f, 5.57001047e-02f, 3.47319879e-02f, 1.11040659e-01f, -2.44810641e-01f,
  -1.07197471e-01f, 1.42018855e-01f, -2.62681600e-02f, -1.80218935e-01f, 2.78745145e-02f, -8.66525173e-02f, -1.45017803e-01f, -1.00058824e-01f, 8.87724757e-02f, -1.14563964e-01f,
  4.87636738e-02f, -2.61065066e-01f, 8.82632434e-02f, -2.38829345e-01f, -6.39081970e-02f, -2.42759800e-03f, -4.15400714e-02f, -1.29946787e-02f, -1.47511825e-01f, -8.75837263e-03f,
  -6.85140193e-02f, -6.11218549e-02f, -6.29841760e-02f, -8.53917599e-02f, -4.28549647e-02f, -9.76789594e-02f, 1.37448404e-02f, 7.69579560e-02f, 4.14248779e-02f, -1.53197697e-03f,
  4.98201735e-02f, -9.03532654e-03f, -8.63458496e-03f, -4.90399376e-02f, 1.73228718e-02f, 8.58414732e-03f, 6.70646653e-02f, -1.98060125e-02f, -4.03723605e-02f, 9.60729718e-02f,
  6.63935542e-02f, -7.78726162e-03f, 8.84237736e-02f, 6.20442815e-02f, 1.39418006e-01f, 2.29399037e-02f, 7.00577348e-02f, 4.72442396e-02f, 2.53802980e-03f, 1.14488667e-02f,
  -4.09089960e-02f, -8.30270443e-03f, -2.27451175e-02f, 2.10137963e-02f, -4.96428236e-02f, 7.79480636e-02f, 6.96650473e-03f, -4.37522866e-02f, 2.83862110e-02f, -6.35090545e-02f,
  -1.66180788e-03f, -4.54786085e-02f, 3.21513526e-02f, 4.01618220e-02f, -4.07930203e-02f, 8.56683403e-02f, 5.22285439e-02f, 5.76251559e-02f, 4.21399297e-03f, -3.49145345e-02f,
  -6.82506291e-03f, -1.72604974e-02f, 3.90240457e-03f, 7.32125193e-02f, -2.40445100e-02f, -5.47158474e-04f, -1.33327506e-02f, 1.05109811e-01f, 5.89143811e-03f, -4.65486981e-02f,
  -2.91854382e-01f, -3.23105633e-01f, -6.41731471e-02f, -3.85738462e-02f, -1.39157519e-01f, -5.19388840e-02f, -3.81177291e-02f, 6.97878078e-02f, -7.16155991e-02f, 1.12727247e-02f,
  2.88204532e-02f, 4.01036479e-02f, -2.16529407e-02f, -1.02956863e-02f, -8.99886265e-02f, 3.33981439e-02f, 4.90056723e-02f, 5.49676968e-03f, -8.38341862e-02f, -3.27491411e-03f,
  -5.96506931e-02f, -4.72223945e-02f, 3.41334492e-02f, 3.83187719e-02f, 4.82456461e-02f, 1.16867749e-02f, -6.14105165e-02f, 5.39827608e-02f, -8.71706847e-03f, 6.94183866e-03f,
  4.29362446e-01f, 1.72439694e-01f, -6.96485713e-02f, 2.05264926e-01f, 8.05476755e-02f, 1.89144075e-01f, 8.57292339e-02f, 7.48859672e-03f, 3.63273591e-01f, 1.16796680e-01f,
  -1.26690671e-01f, 2.25462139e-01f, -3.18553746e-01f, 3.31533611e-01f, 1.91937238e-01f, -1.71258509e-01f, 3.79161179e-01f, 2.04293042e-01f, 2.35557128e-02f, 2.08800688e-01f,
  2.05858558e-01f, 1.24635667e-01f, -2.40919068e-01f, -2.50885952e-02f, -3.86459194e-02f, -1.15173802e-01f, -2.60114282e-01f, -2.00923726e-01f, -4.27918099e-02f, -9.78248194e-02f,
  -3.91926765e-02f, 9.10944939e-02f, 5.03135249e-02f, -4.92171980e-02f, 2.58612074e-02f, -2.76320353e-02f, -4.52623740e-02f, -9.49611142e-02f, 3.84331122e-02f, -2.30928212e-02f,
  4.27300520e-02f, -8.78608506e-03f, 7.03518912e-02f, -2.49874089e-02f, 1.94220960e-01f, 5.96075654e-02f, 6.79369271e-02f, -4.23506573e-02f, -2.49283924e-03f, -2.08472796e-02f,
  1.03254411e-02f, -3.06421909e-02f, 1.47616029e-01f, -6.44230396e-02f, -3.23833823e-02f, 1.17641464e-01f, 6.93765841e-03f, -4.54025753e-02f, -1.88982487e-02f, 1.24695882e-01f,
  2.53933575e-02f, 4.85833436e-02f, -8.66198316e-02f, -1.20097965e-01f, 8.39816500e-03f, -1.06497422e-01f, 3.00540850e-02f, -5.12338094e-02f, 7.64572173e-02f, -4.31008264e-02f,
  5.27661443e-02f, -4.30947244e-02f, 2.23554280e-02f, 7.25063011e-02f, 1.03195004e-01f, -1.85847525e-02f, -4.88440543e-02f, -1.02274917e-01f, 1.91489216e-02f, -6.81702495e-02f,
  -1.93312153e-01f, 1.20404139e-01f, 1.73703004e-02f, -4.95710857e-02f, 9.53161810e-03f, -6.62550181e-02f, 3.73152434e-03f, -3.12737748e-02f, -5.89155555e-02f, -6.53709248e-02f,
  1.27556026e-01f, 1.58057392e-01f, 6.05328828e-02f, 6.13722652e-02f, 6.69303015e-02f, 1.30117565e-01f, 1.08743280e-01f, 7.44053423e-02f, -2.53422745e-02f, 4.12801541e-02f,
  8.67062882e-02f, 2.58835126e-02f, 2.77028903e-02f, -2.74890438e-02f, 1.02154091e-01f, -1.18506653e-02f, 5.46729267e-02f, -2.33772621e-02f, -5.10369837e-02f, 9.82329808e-03f,
  -3.37088443e-02f, 3.81931737e-02f, -9.54503752e-03f, 7.18746483e-02f, 5.35260588e-02f, -7.04968646e-02f, 4.17114124e-02f, -3.73969264e-02f, -1.26355231e-01f, 5.35723530e-02f,
  1.89052373e-01f, -4.48814407e-02f, -1.30680755e-01f, -2.61059497e-02f, 3.91117260e-02f, -1.20130494e-01f, -3.00372571e-01f, 8.39195331e-04f, -1.81634143e-01f, -3.22096586e-01f,
  -1.19048968e-01f, -7.60202184e-02f, -2.03614846e-01f, 5.92750832e-02f, 3.14095110e-01f, -6.80950209e-02f, 1.92819104e-01f, 2.64908597e-02f, 1.00322694e-01f, 1.42495856e-01f,
  2.02129379e-01f, 1.40463427e-01f, 1.77411944e-01f, 2.05486655e-01f, 6.03233799e-02f, 1.38459817e-01f, 2.20983937e-01f, -3.52834500e-02f, 4.26165834e-02f, 6.75526932e-02f,
  -8.86747614e-02f, -5.43292500e-02f, 1.21283727e-02f, -2.67502610e-02f, -1.17404228e-02f, -7.69185973e-03f, 1.40023362e-02f, 6.81621209e-02f, 5.30527905e-04f, -7.04459921e-02f,
  -9.31177195e-03f, 4.17996347e-02f, -3.74458469e-02f, 8.66676569e-02f, 4.89159748e-02f, -3.02165579e-02f, 9.16445721e-03f, -9.43028089e-03f, 3.48804593e-02f, -5.46673127e-02f,
  -5.22030666e-02f, -1.86332557e-02f, 2.45081615e-02f, -4.32564765e-02f, -7.01096952e-02f, -1.33708328e-01f, 7.64449779e-03f, -5.61123155e-02f, -1.33280426e-01f, -6.62110299e-02f,
  1.10692315e-01f, 2.58931867e-03f, 2.11828742e-02f, -5.91703877e-02f, 1.70329325e-02f, -1.12224407e-02f, -2.76018735e-02f, -5.36124222e-02f, 2.47054622e-02f, -2.41134465e-02f,
  -1.08240515e-01f, 2.80948207e-02f, 6.05696477e-02f, -1.51623890e-01f, 8.96157417e-03f, 5.23722135e-02f, 1.68438569e-01f, -1.73307769e-02f, -5.38538508e-02f, -3.25853191e-03f,
  1.76601857e-02f, 1.04989305e-01f, 2.43832842e-02f, 2.18935087e-02f, 7.96230324e-03f, -7.97782764e-02f, -1.09496549e-01f, 8.69202521e-03f, 9.37059149e-02f, -1.32181477e-02f,
  5.24456203e-02f, 8.40254351e-02f, -2.84684487e-02f, -4.29928452e-02f, -5.34464233e-02f, 4.70574200e-02f, 4.93652783e-02f, -1.19253621e-02f, -4.74306233e-02f, 1.92031134e-02f,
  1.50844259e-02f, 5.49764410e-02f, -1.03530042e-01f, 2.79584229e-02f, 8.84163380e-02f, -6.20303862e-02f, 4.94391918e-02f, 1.09953964e-02f, 3.89317423e-02f, 1.03109673e-01f,
  2.99742818e-03f, -6.67779669e-02f, -3.36910933e-02f, -6.89863414e-02f, -6.76568076e-02f, -1.37172043e-01f, 1.09688289e-01f, -6.44602925e-02f, 8.93576443e-03f, -1.14879198e-01f,
  -1.84728473e-01f, -1.33417293e-01f, 1.89059198e-01f, -1.02372795e-01f, 8.80589336e-02f, 1.33667126e-01f, 2.05833465e-01f, -2.21581951e-01f, -1.10785924e-01f, -2.62334287e-01f,
  -1.98334247e-01f, 3.73030342e-02f, -1.62111431e-01f, 1.49833607e-02f, 3.69568795e-01f, 8.97038952e-02f, 6.58084378e-02f, -3.03717516e-02f, -4.17772215e-03f, -1.81210250e-01f,
  3.47768934e-03f, -1.04036205e-01f, 1.24649942e-01f, -1.28721744e-01f, -7.93272108e-02f, 3.71174999e-02f, 5.67629375e-02f, 2.55877614e-01f, 6.47809952e-02f, 1.62580058e-01f,
  3.68613116e-02f, -1.90259337e-01f, 7.27880150e-02f, 4.77172695e-02f, -6.02492020e-02f, 3.09447348e-02f, 1.79676056e-01f, 2.52805799e-01f, 9.38852355e-02f, -7.67415836e-02f,
  8.89557377e-02f, 6.56888336e-02f, -5.92598356e-02f, 4.27290909e-02f, -2.37187315e-02f, -3.64142247e-02f, 1.86136439e-02f, -2.89130788e-02f, 6.21079765e-02f, 5.65504096e-02f,
  -6.27673864e-02f, 7.62525061e-03f, -5.11661358e-02f, 4.50981297e-02f, 1.02517329e-01f, 7.57139251e-02f, 9.91159528e-02f, 9.79562029e-02f, 1.15640201e-02f, 2.33239979e-02f,
  4.84482758e-02f, 5.03473505e-02f, -1.11409642e-01f, -1.03707038e-01f, -6.27989098e-02f, -6.58708662e-02f, 4.17256765e-02f, -1.04389027e-01f, 6.57195002e-02f, 5.94893843e-02f,
  -1.53559381e-02f, 6.97702467e-02f, 3.04115806e-02f, 4.56276583e-03f, -9.52843800e-02f, -1.69205144e-01f, 1.33746818e-01f, -1.48405246e-02f, -1.22098051e-01f, -9.38395783e-02f,
  -7.19562396e-02f, 1.26033142e-01f, -6.06206544e-02f, 9.38154906e-02f, -7.39462813e-03f, -1.09641008e-01f, 2.42433231e-03f, 5.96483611e-02f, 5.31897321e-03f, -3.40916514e-02f,
  1.83257479e-02f, -4.38067764e-02f, 6.95584938e-02f, 3.33354250e-02f, 4.73573804e-02f, -1.53037548e-01f, 9.72602367e-02f, 2.25574635e-02f, 1.12493560e-01f, -2.74478775e-02f,
  -9.04369876e-02f, 7.57827982e-02f, -1.77988224e-02f, 1.29948212e-02f, -1.26355756e-02f, 9.74554475e-03f, 1.44029111e-01f, -8.10405388e-02f, 7.37410039e-02f, 2.33437810e-02f,
  3.57792713e-02f, 4.15455829e-03f, -6.26899227e-02f, -1.29980162e-01f, -3.99197601e-02f, -3.00951302e-02f, -1.27988055e-01f, -3.57695259e-02f, -5.01096388e-03f, 9.65089500e-02f,
  -1.67742297e-02f, 1.41449556e-01f, 2.14316919e-01f, -1.87027276e-01f, 2.41326809e-01f, 3.47641498e-01f, 5.90619110e-02f, 9.13471431e-02f, 1.71298355e-01f, -2.21140504e-01f,
  -2.18048707e-01f, -1.39526591e-01f, -9.05437618e-02f, -1.22303806e-01f, 2.45451480e-01f, 5.70513494e-02f, -9.48146284e-02f, -1.45114809e-01f, 1.36199236e-01f, -6.64356351e-02f,
  3.91467996e-02f, -2.42620215e-01f, -8.47251192e-02f, -3.11700869e-02f, -4.99229245e-02f, -3.67447585e-02f, -1.50194243e-01f, 8.49583000e-02f, -2.63881117e-01f, 9.71369296e-02f,
  4.12509590e-02f, -2.99505182e-02f, 6.88972548e-02f, -3.68905663e-02f, 7.75497630e-02f, -4.54231277e-02f, -1.69273511e-01f, 5.13661318e-02f, 3.59140970e-02f, 2.26562284e-02f,
  -1.40618533e-01f, -6.32173121e-02f, 5.60835563e-02f, -9.12109762e-03f, 3.65500562e-02f, -3.73872593e-02f, -6.31479397e-02f, -3.28180790e-02f, -2.06516087e-02f, 2.53606867e-02f,
  1.77893862e-02f, 3.94224823e-02f, 2.62815915e-02f, -8.87493268e-02f, -4.88527566e-02f, -5.62650636e-02f, 5.25702834e-02f, 7.08057638e-03f, -7.87426457e-02f, 1.00106910e-01f,
  9.05882102e-04f, -4.53438796e-03f, 4.76355199e-03f, -7.98404068e-02f, 6.16983324e-02f, 8.35738331e-02f, -5.58432005e-02f, -1.73301548e-02f, 5.06909937e-02f, -3.60826179e-02f,
  -1.24661453e-01f, -3.50993760e-02f, -2.38287486e-02f, -5.90524077e-02f, -1.23936877e-01f, -3.13289948e-02f, 7.40124658e-03f, -1.64892212e-01f, -6.35165349e-02f, 7.93759525e-02f,
  -8.13516006e-02f, 7.49203563e-02f, 2.23668218e-02f, -1.34947851e-01f, 3.39266397e-02f, 5.68730757e-03f, -1.73995212e-01f, -3.45815793e-02f, 4.46205074e-03f, -9.62955654e-02f,
  5.60586303e-02f, 3.55106369e-02f, 5.24469540e-02f, -6.79830238e-02f, -5.70881320e-03f, 7.32838511e-02f, 4.76746261e-02f, 6.18798621e-02f, 2.26243138e-02f, -3.16676758e-02f,
  -1.45104021e-01f, -2.41779741e-02f, -4.45397012e-02f, -3.90954409e-03f, 4.03948463e-02f, 1.24823473e-01f, -1.88271746e-01f, 3.99379581e-02f, -7.70818442e-02f, -1.26954829e-02f,
  -1.10836715e-01f, -3.29431891e-02f, -7.83121213e-02f, -6.23989180e-02f, -1.07428327e-01f, -1.80231318e-01f, -6.34431699e-03f, -4.43890058e-02f, -4.39017899e-02f, 3.14355120e-02f,
  2.48433188e-01f, 1.32249936e-01f, 7.86276162e-02f, 2.77259052e-01f, 1.15917690e-01f, -6.21782849e-03f, -1.15774080e-01f, 2.04417273e-01f, 2.85110027e-01f, -2.09286377e-01f,
  8.44850764e-02f, -9.02722999e-02f, -2.83690721e-01f, 2.34775886e-01f, 2.64187813e-01f, -6.76252544e-02f, 2.80808628e-01f, 3.58789004e-02f, 1.48977503e-01f, 1.94826752e-01f,
  1.67464331e-01f, 1.21847369e-01f, -2.33582333e-02f, 7.06705004e-02f, 2.51341671e-01f, 8.36247727e-02f, 3.79520096e-02f, -7.64100477e-02f, 5.59829883e-02f, 2.70718001e-02f,
  -3.96919576e-03f, 8.98101926e-02f, -8.72413814e-02f, -9.37548950e-02f, -1.14020072e-02f, -7.07125440e-02f, -1.48240969e-01f, -1.26123458e-01f, -1.01419218e-01f, -9.52916369e-02f,
  -1.48398325e-01f, -8.70132744e-02f, 1.07625863e-02f, -3.30519639e-02f, 3.05833835e-02f, 8.48977044e-02f, 4.73799556e-02f, 2.35840111e-04f, -7.27698132e-02f, 5.39176613e-02f,
  7.13741928e-02f, 8.57676938e-02f, 1.10405847e-01f, 3.48609649e-02f, 3.30340080e-02f, 1.29695743e-01f, -1.30451685e-02f, 5.38671911e-02f, 1.05763681e-01f, 9.22769159e-02f,
  -3.49630043e-02f, -5.98164834e-03f, 1.21780380e-03f, -3.00486404e-02f, 8.53509381e-02f, 6.41602203e-02f, 2.23488193e-02f, -7.25295767e-03f, 6.79914728e-02f, 1.24492366e-02f,
  8.87299553e-02f, 1.90977417e-02f, 7.72013068e-02f, 9.37068090e-02f, -5.66399284e-02f, 4.53557111e-02f, -5.72178885e-02f, 5.09891994e-02f, 1.06519051e-01f, 4.43171784e-02f,
  -5.02141938e-02f, 9.73660033e-03f, -4.55030538e-02f, -8.92572105e-02f, -9.66363847e-02f, 2.77877804e-02f, -1.15971798e-02f, 1.05665196e-02f, -5.25605679e-02f, 5.79988286e-02f,
  -1.75139755e-02f, 1.43241376e-01f, -1.09237500e-01f, -1.09387398e-01f, -6.14048801e-02f, 1.24640793e-01f, -9.51752067e-03f, 9.36337337e-02f, 2.51173843e-02f, 9.43267420e-02f,
  -4.94031049e-02f, -1.34008974e-01f, 4.73583862e-02f, 1.37472615e-01f, 2.58439537e-02f, 1.69380218e-01f, -6.62172586e-02f, 5.61681483e-03f, -1.04895338e-01f, 5.92224766e-03f,
  -9.00802240e-02f, 4.57924232e-03f, -5.64298667e-02f, 1.53490409e-01f, -2.77034696e-02f, -5.22933155e-02f, 6.93781748e-02f, 4.74407710e-02f, 1.78513322e-02f, 9.08083543e-02f,
  2.81179726e-01f, -2.57446170e-01f, 7.10586533e-02f, 2.72070140e-01f, 1.50643960e-01f, -4.14995402e-02f, 8.89554694e-02f, -1.02687821e-01f, 1.26766667e-01f, -3.34192067e-01f,
  -1.19780943e-01f, -1.24937311e-01f, -3.21320057e-01f, 2.06610247e-01f, 2.67090619e-01f, -1.97326079e-01f, 1.69494584e-01f, -8.31795707e-02f, -1.07403837e-01f, -3.23625021e-02f,
  1.02644041e-01f, 1.14451662e-01f, 6.14451841e-02f, 2.25477386e-03f, 7.33421147e-02f, -1.70201007e-02f, 2.91369352e-02f, 3.15771326e-02f, 1.11717492e-01f, 1.16082802e-01f,
  6.50084317e-02f, 2.79716477e-02f, 4.14336547e-02f, 2.18238030e-02f, 1.76181253e-02f, 1.95785593e-02f, 6.48247730e-03f, 8.39478709e-03f, 1.22876972e-01f, -9.19571966e-02f,
  -8.34392682e-02f, 3.90671380e-02f, 1.79985873e-02f, 7.38516003e-02f, 1.76714703e-01f, 9.32738930e-02f, 1.65825002e-02f, -1.37167890e-02f, -6.97102398e-02f, -4.06530239e-02f,
  -2.00608801e-02f, 4.12002997e-03f, 8.15820172e-02f, -6.22422621e-02f, -2.05232836e-02f, 2.71117277e-02f, -5.46994284e-02f, -4.77552824e-02f, -2.52349880e-02f, 3.92711312e-02f,
  -5.08483779e-03f, -6.74662665e-02f, -9.57174823e-02f, 1.64711382e-02f, -1.85275488e-02f, -1.54283866e-02f, 1.78019274e-02f, -1.00424826e-01f, 2.51620281e-02f, -1.28442394e-02f,
  9.90391299e-02f, 4.71257195e-02f, 4.63383272e-02f, 2.70348359e-02f, -3.58736172e-04f, -5.80595657e-02f, 6.18664268e-03f, -7.97031075e-02f, 4.53888811e-03f, 5.38067240e-03f,
  -7.05934269e-03f, 9.39958841e-02f, -2.52666138e-02f, -9.19893198e-03f, -3.02732922e-03f, -2.55224705e-02f, -1.98827051e-02f, 6.75287389e-04f, -2.26983521e-02f, -3.44865844e-02f,
  -1.75937987e-03f, -1.50812283e-01f, -5.17682619e-02f, 3.39808464e-02f, -3.01271747e-03f, 2.74383761e-02f, 1.46545377e-02f, -2.45353524e-02f, 6.52292892e-02f, -3.37122828e-02f,
  1.48259355e-02f, -1.96992885e-02f, 8.30342919e-02f, 6.60170242e-02f, 1.00431807e-01f, -5.77686392e-02f, -1.64981149e-02f, 2.83871610e-02f, 3.83221433e-02f, -8.77697766e-02f,
  -5.13812341e-02f, -5.39926142e-02f, 6.72386494e-03f, -3.11325137e-02f, -8.85240063e-02f, -6.34917319e-02f, -4.41011861e-02f, 4.76150308e-03f, -1.83107499e-02f, -2.44012773e-02f,
  -4.94500756e-01f, 2.60830402e-01f, 7.65194073e-02f, -6.18665740e-02f, 1.93634644e-01f, 1.39724957e-02f, -1.21593297e-01f, 1.53941721e-01f, -7.82240108e-02f, -1.10428378e-01f,
  -1.28388435e-01f, -1.37079269e-01f, 4.56736162e-02f, -3.36503871e-02f, -2.51774669e-01f, 2.90646646e-02f, -1.53901041e-01f, -2.64601529e-01f, 3.71230505e-02f, -1.95715949e-01f,
  -2.31864098e-02f, 1.19500473e-01f, 3.36428918e-02f, 2.89620340e-01f, 2.76934773e-01f, 7.40919337e-02f, -7.96199590e-02f, 1.64317966e-01f, 8.82445499e-02f, 1.57059059e-01f,
  -1.19759545e-01f, -1.59510940e-01f, -1.50462016e-01f, -5.28591275e-02f, -1.36941209e-01f, -7.03703538e-02f, -7.60902166e-02f, 1.86345670e-02f, -1.83424819e-02f, -3.94760929e-02f,
  -2.87706144e-02f, 9.52779055e-02f, 4.48766015e-02f, 5.67467548e-02f, 2.72390135e-02f, 1.01674255e-02f, 1.03761882e-01f, -3.19440775e-02f, 1.17924735e-01f, 6.68299850e-03f,
  9.66103226e-02f, -5.02404869e-02f, -6.44858778e-02f, 3.11529767e-02f, 7.06040487e-02f, 2.16629989e-02f, 5.57846613e-02f, -9.48776305e-02f, 3.06000896e-02f, -8.22029412e-02f,
  4.79507782e-02f, -3.51812690e-02f, -2.03444082e-02f, 1.77537929e-02f, -3.78448665e-02f, -4.40577827e-02f, -6.04875684e-02f, -6.66738525e-02f, -3.09642646e-02f, -4.44887243e-02f,
  8.25290456e-02f, -8.42992067e-02f, 3.31514440e-02f, 5.74480789e-03f, 1.43450992e-02f, -3.22723053e-02f, -4.85789925e-02f, 3.11625488e-02f, 1.55244529e-01f, -9.54335704e-02f,
  -1.25044771e-02f, -2.68050395e-02f, 6.81398585e-02f, 2.00936440e-02f, -5.64780757e-02f, -8.08257377e-04f, 4.16059829e-02f, 1.27202883e-01f, -8.92766416e-02f, 4.58202884e-02f,
  -4.48017865e-01f, -3.33829969e-01f, -4.19676937e-02f, -2.53372383e-03f, -1.98243827e-01f, -3.03703975e-02f, -2.20269840e-02f, 2.25896984e-02f, -3.14396657e-02f, -3.40111330e-02f,
  -6.17286861e-02f, -2.50437576e-02f, -7.60658607e-02f, -1.28500666e-02f, -4.65353467e-02f, -3.93796712e-03f, -8.91175419e-02f, -6.84482381e-02f, -1.25045151e-01f, -2.73596160e-02f,
  -2.88092941e-02f, -8.57194141e-03f, -1.05665484e-02f, 5.27877919e-02f, 2.21013576e-02f, -4.50780429e-02f, -6.07964434e-02f, 8.02978575e-02f, 6.15164228e-02f, 2.06101201e-02f,
  3.91614705e-01f, -1.83936775e-01f, 7.08855465e-02f, 3.11526448e-01f, 1.42276049e-01f, -8.16872790e-02f, 1.96888968e-01f, 1.02179907e-01f, 4.80819404e-01f, -2.56453574e-01f,
  3.63286100e-02f, -1.68858334e-01f, 5.83234765e-02f, -1.35511041e-01f, 2.55681366e-01f, 6.00256899e-04f, 3.72860916e-02f, -1.09113760e-01f, 1.84242457e-01f, 7.66550377e-02f,
  1.72293410e-01f, -1.60443738e-01f, -2.97429133e-02f, -1.81407765e-01f, -2.49927901e-02f, -9.12341177e-02f, -1.62922204e-01f, -4.27768938e-03f, -3.16533357e-01f, -8.84255543e-02f,
  2.67844275e-02f, 1.05385385e-01f, -3.87132764e-02f, -9.35395733e-02f, 4.29141112e-02f, -4.06056754e-02f, -1.22963645e-01f, -1.77064598e-01f, 1.27210096e-01f, -3.42207984e-03f,
  -1.13909267e-01f, -6.07876368e-02f, -1.94532219e-02f, -2.38442663e-02f, 1.09810479e-01f, 5.20714149e-02f, -6.38537109e-02f, 5.52878249e-04f, -6.70736507e-02f, -2.31520534e-02f,
  1.29485592e-01f, 1.20356046e-02f, 1.28145084e-01f, -1.07529052e-01f, 3.61401998e-02f, -6.01505442e-03f, -3.92075591e-02f, -8.81362632e-02f, 1.63568091e-03f, 2.14850474e-02f,
  -3.27295884e-02f, 2.87296101e-02f, -6.04793541e-02f, 6.89161615e-03f, 3.43815424e-02f, 2.39703003e-02f, 9.13936645e-03f, -1.11026324e-01f, 1.00171447e-01f, 4.01717518e-03f,
  3.41273770e-02f, -5.27823810e-03f, 7.41528571e-02f, 2.23285481e-02f, 4.40124888e-03f, 5.15859351e-02f, -1.19203553e-01f, -2.07804263e-01f, 8.08557793e-02f, 2.07466865e-03f,
  -3.13084498e-02f, 2.68965438e-02f, 1.44204618e-02f, -4.45731357e-02f, 3.10189128e-02f, 7.50647336e-02f, -3.81383561e-02f, -7.98701681e-03f, -8.59282166e-03f, -1.46179451e-02f,
  -8.83221254e-02f, -1.22749366e-01f, 2.71778624e-03f, -9.03017521e-02f, -5.86059131e-02f, -3.12563684e-03f, -7.22578391e-02f, -1.12562411e-01f, 9.45981685e-03f, -1.78711973e-02f,
  -1.37104094e-01f, 1.13114296e-02f, 6.41723350e-02f, 1.96177643e-02f, -3.01373396e-02f, 1.60698611e-02f, -5.46964072e-02f, 2.27768868e-02f, -4.40182798e-02f, -1.08052567e-01f,
  -9.40787792e-02f, 8.75356048e-02f, -3.15774903e-02f, -2.14359891e-02f, -7.63053000e-02f, -1.05272487e-01f, 3.18122804e-02f, -2.94186585e-02f, -3.04355454e-02f, 1.77743565e-02f,
  -1.49947152e-01f, -3.47522378e-01f, 1.32534340e-01f, 5.22889569e-02f, 1.18740082e-01f, 9.40509215e-02f, 1.14018761e-01f, 3.37333754e-02f, -1.70402750e-01f, -2.96533018e-01f,
  -5.97302057e-02f, -5.82789145e-02f, -1.03193223e-01f, -5.54199181e-02f, 1.55326486e-01f, -1.54052198e-01f, -2.13794373e-02f, -3.01558189e-02f, 5.68020232e-02f, 1.23762779e-01f,
  1.15540102e-01f, 3.22686136e-02f, 1.93459660e-01f, 6.64873421e-02f, -3.55730532e-03f, 4.34596315e-02f, 2.19168253e-02f, 1.32451117e-01f, 1.29300311e-01f, 1.41099300e-02f,
  -1.09504983e-01f, -5.96247949e-02f, -4.54350375e-02f, -5.80584481e-02f, -4.61756475e-02f, -2.92904954e-02f, -2.05374099e-02f, 6.62299022e-02f, -1.68407196e-03f, 4.46429849e-02f,
  5.25846481e-02f, 4.30961177e-02f, 1.81040354e-02f, 3.73940133e-02f, 8.11217278e-02f, -3.41314152e-02f, 7.81574845e-02f, -4.37443070e-02f, -6.93252450e-03f, 6.96321875e-02f,
  1.32259531e-02f, -5.14692850e-02f, -2.73015387e-02f, -2.39823125e-02f, 6.28263429e-02f, -1.74719058e-02f, 1.10024408e-01f, 4.48659360e-02f, -5.83752990e-02f, 4.62450758e-02f,
  3.18377689e-02f, 4.56815697e-02f, 4.05749818e-03f, -4.51531895e-02f, -3.67236175e-02f, 2.48018317e-02f, 6.12512529e-02f, -2.31444519e-02f, 2.62178946e-03f, -2.52818819e-02f,
  -6.65962845e-02f, -1.72709227e-02f, 4.69614565e-02f, 2.05387827e-02f, 7.51809264e-03f, 9.24735665e-02f, 5.64234704e-02f, -1.11863231e-02f, -5.11620678e-02f, -2.76123993e-02f,
  5.93093559e-02f, 4.75079790e-02f, -5.20141646e-02f, -5.34659578e-03f, -3.19209248e-02f, 7.28224218e-02f, -1.33502567e-02f, -3.78636457e-02f, 2.61244792e-02f, 6.85897321e-02f,
  -2.49362677e-01f, -1.32636860e-01f, -3.19014527e-02f, -3.89333665e-02f, -3.84103656e-02f, -5.82767278e-02f, -3.69156408e-03f, 9.16563720e-03f, -7.23961517e-02f, 5.49310483e-02f,
  1.02027193e-01f, 5.66005968e-02f, -1.69087946e-01f, -7.72101013e-03f, 8.61437991e-02f, -3.76793109e-02f, 1.05916765e-02f, -4.59146500e-02f, -4.19966616e-02f, 1.45670846e-02f,
  -4.10887264e-02f, -6.09837621e-02f, 4.56115045e-02f, -1.75584685e-02f, 7.33273476e-02f, -2.44070236e-02f, -5.81474081e-02f, 4.33073416e-02f, 3.58863994e-02f, -4.73078005e-02f,
  -9.62259900e-03f, 1.19349375e-01f, 2.57540315e-01f, 3.90121788e-02f, -1.22129761e-01f, -2.60453045e-01f, -1.09725587e-01f, -5.15748337e-02f, -5.34267463e-02f, -1.09223321e-01f,
  -8.60103071e-02f, 2.27225631e-01f, 1.59383580e-01f, -1.19659647e-01f, 1.10647611e-01f, 1.75087377e-01f, -1.54301256e-01f, -6.28890768e-02f, -3.12961563e-02f, -2.64125280e-02f,
  8.13686196e-03f, -1.68414578e-01f, 1.53605878e-01f, -1.17712833e-01f, -1.17714256e-01f, 1.10926159e-01f, 1.10263340e-01f, -3.30061875e-02f, 5.35340933e-03f, -1.73376035e-02f,
  -1.23446867e-01f, 1.30269721e-01f, 8.38594064e-02f, 8.94781649e-02f, -8.63023847e-02f, -1.39455736e-01f, -3.41158584e-02f, 1.05628163e-01f, -2.76094973e-02f, 1.10182993e-01f,
  7.51340110e-03f, 8.26681033e-02f, -2.44235583e-02f, -3.35556976e-02f, -1.61337078e-01f, 2.41662338e-02f, 5.16781397e-02f, 1.11613059e-02f, 1.12382166e-01f, -1.07886977e-01f,
  1.13912364e-02f, -5.22502884e-02f, -7.91810974e-02f, 2.32869670e-01f, 2.09781289e-01f, -4.48565781e-02f, 6.90100789e-02f, 2.18378026e-02f, 8.74415413e-02f, -4.24017757e-03f,
  4.13202159e-02f, 2.04874128e-02f, 5.52533120e-02f, -3.09695583e-02f, -1.02600686e-01f, 2.45250240e-02f, -2.75475122e-02f, -1.10723503e-01f, -5.79550192e-02f, 2.58396678e-02f,
  1.00501053e-01f, 8.99298638e-02f, -9.52164754e-02f, -9.17801261e-02f, -4.31951173e-02f, 4.82544936e-02f, 1.35046318e-02f, 3.68797034e-02f, -5.93471713e-02f, -5.17886840e-02f,
  1.41885146e-01f, -6.99564889e-02f, 3.07252817e-02f, 3.24289761e-02f, -1.62681788e-01f, 2.32324284e-03f, -1.13862768e-01f, -2.14283094e-02f, 1.30320489e-02f, 2.02736165e-02f,
  1.21481501e-01f, 3.24710697e-01f, 7.88540095e-02f, 7.49326497e-02f, -3.77560519e-02f, -1.57281771e-01f, 9.80599434e-04f, 4.94719483e-02f, 6.10276125e-02f, 3.19848582e-02f,
  -6.91025481e-02f, 6.26574159e-02f, -6.35905862e-02f, -7.80158490e-02f, 7.68927932e-02f, -1.84866823e-02f, -4.23900504e-03f, 1.07793115e-01f, 8.79177824e-02f, 5.14338277e-02f,
  2.85457168e-03f, -5.94059117e-02f, 1.91709906e-01f, -2.06305385e-02f, 2.47015938e-01f, 8.26019719e-02f, -5.04857562e-02f, 2.10576858e-02f, 1.26601353e-01f, -1.82891320e-02f,
  4.36322205e-02f, 2.21366689e-01f, -7.20326751e-02f, 1.55889541e-01f, 9.79389157e-03f, 1.77390993e-01f, 1.62015840e-01f, 7.98238963e-02f, 1.63583189e-01f, 2.93978691e-01f,
  1.49563178e-01f, 1.16350777e-01f, 7.77476728e-02f, 3.34689945e-01f, 2.86542922e-01f, 2.03236654e-01f, 2.63622910e-01f, 1.00055493e-01f, -5.04474379e-02f, 1.38590649e-01f,
  -6.18762057e-03f, 2.75689781e-01f, 3.82638834e-02f, 8.39781985e-02f, 5.35844639e-02f, -2.07026303e-01f, 8.54705274e-02f, -1.99142084e-01f, 1.50206074e-01f, 3.27048190e-02f,
  5.67144714e-04f, 1.12762064e-01f, -7.68115968e-02f, -6.75508082e-02f, 8.23299307e-03f, -1.02590933e-01f, -6.30079061e-02f, -4.16386388e-02f, -1.23424098e-01f, -7.94215873e-02f,
  3.00828349e-02f, -4.56759222e-02f, 6.38736784e-02f, 5.35444543e-02f, 9.94511601e-03f, -2.96363197e-02f, 4.18280289e-02f, -4.38924544e-02f, 2.41009779e-02f, 9.60850194e-02f,
  3.16887014e-02f, 1.72077101e-02f, 1.16207890e-01f, 7.53902718e-02f, 3.89477015e-02f, 4.38787267e-02f, 5.12230769e-02f, -1.05048455e-02f, 5.91481142e-02f, 1.08578466e-01f,
  2.26787711e-03f, -1.73201803e-02f, 3.34153213e-02f, -1.45034827e-02f, 1.96327697e-02f, 1.13824336e-02f, 1.02028258e-01f, 1.54624821e-03f, 5.48045477e-03f, 6.22583851e-02f,
  -6.01339191e-02f, 2.54072547e-02f, 5.97150177e-02f, 5.89470379e-02f, 1.21191725e-01f, 3.69349010e-02f, 1.86974779e-02f, -3.16699781e-02f, -2.77355183e-02f, -2.93215495e-02f,
  -5.27330525e-02f, 8.90970752e-02f, -2.59295627e-02f, -1.35792628e-01f, -4.01455685e-02f, 1.10347234e-02f, 1.07197635e-01f, 4.48646490e-03f, -4.83526103e-03f, 8.51480011e-03f,
  1.25431478e-01f, 2.15889156e-01f, 2.76281200e-02f, -5.33284545e-02f, -7.25656450e-02f, 9.96246114e-02f, 6.79719746e-02f, -3.88993021e-06f, -3.00421547e-02f, 3.81535292e-02f,
  2.67446637e-02f, -4.89524193e-02f, -5.37667833e-02f, 1.33535480e-02f, -4.93764728e-02f, 1.41834661e-01f, -1.20844254e-02f, 9.97337978e-04f, 4.64112870e-02f, -2.47695502e-02f,
  -3.80846276e-03f, 4.67836042e-04f, 1.39724684e-03f, 3.00566462e-04f, 6.03063125e-03f, -3.25555690e-02f, 8.19574222e-02f, 1.68815404e-02f, 3.92117016e-02f, 6.67885169e-02f,
  -9.09240842e-02f, 2.82049060e-01f, 1.52196690e-01f, 1.25977069e-01f, -3.88709418e-02f, -3.16941082e-01f, -1.97041363e-01f, 1.54610276e-01f, 1.43761374e-02f, -2.17484627e-02f,
  8.77870014e-04f, 2.02780023e-01f, 1.20182559e-01f, 3.44792046e-02f, -1.80269212e-01f, 1.02773324e-01f, -1.82411700e-01f, -1.80171635e-02f, 1.08662777e-01f, 2.41410546e-02f,
  -1.10739864e-01f, -1.08581156e-01f, 3.24401766e-01f, -5.32499403e-02f, -2.02197265e-02f, 1.02335848e-01f, -2.17792168e-02f, 1.04371682e-01f, -8.59562308e-02f, -7.96242431e-02f,
  1.33165523e-01f, 2.10575566e-01f, 1.54105589e-01f, -3.80540341e-02f, 3.04799657e-02f, -1.70041859e-01f, -6.05380759e-02f, -4.62694559e-03f, 7.90679380e-02f, 4.97055016e-02f,
  -8.02950561e-02f, 2.33870056e-02f, 3.40905413e-02f, -7.30107278e-02f, -1.46364763e-01f, 3.70045081e-02f, 1.42684907e-01f, 1.17796259e-02f, 1.38003528e-01f, 1.05805295e-02f,
  6.00063130e-02f, 2.69860658e-03f, -6.63773343e-02f, 3.68708223e-02f, -5.52078197e-03f, -6.80189254e-03f, -8.42174217e-02f, -4.14809771e-02f, -1.88551191e-02f, 7.14828353e-03f,
  -7.09694177e-02f, -7.21610039e-02f, 3.57281626e-03f, 5.69100827e-02f, -3.99251170e-02f, 2.46976428e-02f, -5.07483855e-02f, -1.01486305e-02f, -8.68823901e-02f, -4.19453420e-02f,
  -3.60560305e-02f, 3.43110189e-02f, 1.53625663e-02f, -2.51536906e-01f, -1.09675162e-01f, 3.65870111e-02f, -4.50418182e-02f, -2.10194625e-02f, -6.70848787e-02f, 5.79034984e-02f,
  1.69841662e-01f, -1.46360055e-01f, 2.49580871e-02f, 5.87490499e-02f, 3.10638192e-04f, 2.64209006e-02f, -1.41304163e-02f, -2.04482246e-02f, 2.10287943e-01f, -1.93178821e-02f,
  1.44646585e-01f, 1.17322743e-01f, 1.01784758e-01f, 1.26436472e-01f, 9.60309431e-02f, -1.71318844e-01f, -1.07892163e-01f, -5.14258929e-02f, 7.32953697e-02f, -1.57988787e-01f,
  -1.05453715e-01f, -4.68985625e-02f, -7.66184404e-02f, -1.00548528e-01f, 4.39075707e-03f, 2.23370790e-02f, 7.04154698e-03f, -6.01306632e-02f, 2.98240483e-02f, 3.15393880e-02f,
  2.05503274e-02f, -3.98510918e-02f, 9.69247967e-02f, 3.23166735e-02f, -6.33698106e-02f, 7.70878270e-02f, -4.36604284e-02f, 1.96651965e-02f, 4.74382471e-03f, 2.39390805e-02f,
  -1.58243895e-01f, -4.23519105e-01f, 3.83599289e-02f, -2.62289435e-01f, 1.42292127e-01f, 3.27438653e-01f, 2.71429904e-02f, -1.27122030e-01f, -3.42947811e-01f, -6.51213601e-02f,
  1.58391409e-02f, -1.58078149e-01f, -1.49895325e-01f, -3.28162551e-01f, 1.14142299e-01f, -2.48498008e-01f, -4.15399671e-03f, 1.15452424e-01f, -1.84729874e-01f, 1.65520400e-01f,
  2.03146972e-02f, -1.87287375e-01f, -2.60830531e-03f, 7.37478435e-02f, -6.63220510e-02f, 1.39636666e-01f, 2.70539910e-01f, 1.93241492e-01f, 1.41855717e-01f, -1.04465328e-01f,
  -9.21241194e-02f, -1.61724955e-01f, -7.42863566e-02f, 6.48069084e-02f, 1.92387745e-01f, 1.36162534e-01f, 1.88790649e-01f, 4.48259339e-02f, -9.30359364e-02f, -9.36806723e-02f,
  7.39049017e-02f, -1.01636741e-02f, -4.12913375e-02f, 2.25312146e-03f, 8.42992663e-02f, -6.97664618e-02f, -1.07444756e-01f, -9.37253144e-03f, 1.26962652e-02f, -4.47103381e-02f,
  -6.13965541e-02f, -6.87055290e-02f, -6.53168336e-02f, -2.70955749e-02f, -4.92204987e-02f, 2.48560752e-03f, 1.63324699e-02f, 1.62138462e-01f, -9.33867618e-02f, -8.29870161e-03f,
  1.06469668e-01f, 2.33738255e-02f, -4.74018883e-03f, -1.12548172e-01f, -3.86824608e-02f, -9.75243151e-02f, -1.25376329e-01f, -1.18064366e-01f, 1.36027737e-02f, -1.52215183e-01f,
  -7.59573430e-02f, 4.64263707e-02f, -1.23736314e-01f, -1.62852556e-02f, 9.39934924e-02f, -8.11008736e-02f, -1.11753587e-02f, -1.87706221e-02f, 3.48535925e-02f, -1.34787923e-02f,
  -2.11898565e-01f, 8.11648443e-02f, 1.25656426e-01f, -3.34565789e-02f, -1.59715593e-01f, 1.21710777e-01f, -5.74136935e-02f, -5.14440052e-02f, -8.48465860e-02f, 8.54245722e-02f,
  1.45995811e-01f, 1.72101200e-01f, -1.74637809e-01f, -8.04213434e-02f, -5.02956137e-02f, 1.55196413e-01f, -7.39769191e-02f, 1.29618822e-02f, 5.99679723e-02f, 3.12711708e-02f,
  1.51116714e-01f, 4.79917973e-02f, 1.27063483e-01f, 5.93974590e-02f, 2.08644345e-02f, 2.33581457e-02f, 7.37006068e-02f, -5.87719120e-02f, 9.87624973e-02f, -3.19053344e-02f,
  7.52885118e-02f, -5.36630228e-02f, -1.37497351e-01f, 4.00508475e-03f, -8.21271390e-02f, -2.34085191e-02f, -1.46969268e-02f, 6.66360930e-02f, 3.91052775e-02f, -2.95876414e-02f,
  3.22302759e-01f, -1.87050268e-01f, -9.07294005e-02f, -2.27846891e-01f, 2.64822897e-02f, 1.05320983e-01f, 2.98029929e-01f, -2.19115660e-01f, -3.16922307e-01f, -5.14422730e-02f,
  -3.93631309e-02f, 6.98420256e-02f, 1.44533664e-01f, 3.17674945e-04f, 2.57544279e-01f, 5.68103790e-02f, -9.65717435e-02f, -7.30534196e-02f, -2.85236388e-02f, 1.35673702e-01f,
  1.26945972e-02f, 8.77561644e-02f, 6.36797398e-02f, 2.89396252e-02f, 2.01670766e-01f, -1.00931287e-01f, -3.13694328e-02f, 1.39559209e-01f, -1.49032265e-01f, 1.07895963e-01f,
  3.61964144e-02f, 2.70382147e-02f, 8.89874715e-03f, 7.87061639e-03f, 1.97274014e-02f, 1.87735274e-01f, 5.09967133e-02f, 1.29116416e-01f, -6.27834126e-02f, -1.18229635e-01f,
  2.86825746e-02f, -1.40018284e-01f, -1.15082145e-01f, 1.15160942e-01f, -2.13952158e-02f, -1.87880546e-01f, -1.59755632e-01f, -6.33201301e-02f, -6.90852180e-02f, 7.84405917e-02f,
  -2.29824726e-02f, -1.42431900e-01f, -6.31811619e-02f, -1.03799976e-01f, 6.80348370e-03f, -1.30093381e-01f, 1.12788998e-01f, 5.56629486e-02f, -1.25638127e-01f, -1.12107314e-01f,
  1.51010081e-02f, 8.78778994e-02f, 5.13566211e-02f, -3.37284803e-02f, 4.47092615e-02f, 6.38359860e-02f, 4.13517542e-02f, 4.52168845e-02f, 1.28988959e-02f, 9.95728150e-02f,
  -1.01436034e-01f, -5.29920235e-02f, -2.33555306e-02f, -6.11742586e-02f, 9.39183980e-02f, 1.58237212e-03f, 1.19620785e-01f, 1.34035200e-01f, 3.54571976e-02f, 2.40898095e-02f,
  1.07518286e-02f, 2.80936770e-02f, 5.64034767e-02f, -1.11119121e-01f, -4.29476127e-02f, 2.16942616e-02f, -2.45354399e-02f, 5.31535707e-02f, -1.12541825e-01f, 8.84996951e-02f,
  -2.77981423e-02f, 2.90802885e-02f, 3.74846160e-02f, -1.11665487e-01f, 8.32597688e-02f, 9.95577648e-02f, 4.82813641e-02f, -8.78116712e-02f, -1.07842781e-01f, -3.25442813e-02f,
  -1.00194655e-01f, -7.96605498e-02f, -1.69080392e-01f, -8.30430817e-03f, -5.62844463e-02f, -5.65552972e-02f, 4.78893295e-02f, -1.13576092e-01f, -5.91562986e-02f, -2.53517702e-02f,
  -2.85378769e-02f, -1.82359904e-01f, 2.47581564e-02f, -8.58237967e-02f, -5.27560934e-02f, 1.88279040e-02f, 5.18019311e-02f, -1.65598225e-02f, 7.72232702e-03f, -2.21697941e-01f,
  -6.70759141e-01f, 2.57623971e-01f, 1.71614572e-01f, 8.69582146e-02f, -1.96774095e-01f, -7.18281744e-03f, -7.17852786e-02f, -7.18822554e-02f, -1.64714336e-01f, 2.45702505e-01f,
  1.61018535e-01f, -2.60721892e-01f, 1.60471737e-01f, 2.45484948e-01f, -1.42986983e-01f, 3.52722704e-01f, 1.09353982e-01f, -7.15062022e-03f, -8.55458155e-03f, -1.19359925e-01f,
  5.60465045e-02f, 5.56740584e-03f, 2.56477088e-01f, 1.07607126e-01f, -1.05046341e-02f, 4.24767844e-03f, 5.59204929e-02f, 1.24157621e-02f, 1.38733864e-01f, -1.09060761e-02f,
  -1.52159229e-01f, -1.79338723e-01f, -6.70097470e-02f, -9.51271690e-03f, -2.85245366e-02f, -3.04357335e-02f, -2.20488273e-02f, -3.08887511e-02f, -8.75689238e-02f, -1.18767075e-01f,
  -8.48226324e-02f, -4.23771143e-02f, 6.16936833e-02f, -4.77778204e-02f, -4.14952002e-02f, -2.22967360e-02f, 1.12641916e-01f, 1.20099261e-01f, 2.63814367e-02f, 8.94587338e-02f,
  7.64536783e-02f, 1.13482699e-01f, 3.78159732e-02f, -4.14136890e-03f, 5.23563102e-02f, 5.40192388e-02f, 1.34961933e-01f, 3.23074497e-02f, 3.57156508e-02f, -7.71410614e-02f,
  1.06082700e-01f, -4.08886280e-03f, -6.38355240e-02f, -8.58507007e-02f, 2.07423829e-02f, 7.08106160e-02f, 1.42366271e-02f, -5.77575974e-02f, 3.61513384e-02f, -5.38659515e-03f,
  -1.57832280e-02f, -9.52314865e-03f, 3.76562355e-04f, -2.88696364e-02f, -1.30596580e-02f, 1.04241669e-01f, 6.12130621e-03f, -1.05269976e-01f, 3.14308777e-02f, -5.31958379e-02f,
  -1.15581863e-01f, 6.42513670e-03f, 1.04422539e-01f, 2.12427042e-02f, -3.01128300e-03f, -4.54237126e-02f, 7.42964745e-02f, 8.99638906e-02f, -1.15860179e-01f, -1.11766443e-01f,
  -3.96875173e-01f, -2.53777146e-01f, -8.19885582e-02f, -1.00034058e-01f, -4.96329032e-02f, -4.66181617e-03f, 3.64153683e-02f, -3.30043361e-02f, -1.00466773e-01f, -3.67975160e-02f,
  -2.38548964e-02f, 5.35526164e-02f, -1.41306102e-01f, 2.74442919e-02f, -5.46872942e-03f, -2.48942431e-02f, -9.29615796e-02f, 2.38549318e-02f, -1.09987602e-01f, -2.53727790e-02f,
  1.00606441e-01f, 3.40207592e-02f, 1.18104272e-01f, -3.29121910e-02f, 2.40711253e-02f, -1.16881644e-02f, -1.84687544e-02f, 6.49663657e-02f, 3.37116085e-02f, 4.08947505e-02f,
  -2.45665491e-01f, -7.87329525e-02f, -1.88289016e-01f, -9.51399058e-02f, -5.10288775e-02f, -8.40312392e-02f, 1.14587694e-01f, 9.60276350e-02f, 2.29447018e-02f, 2.13642508e-01f,
  1.17947400e-01f, 4.60356995e-02f, 2.64149666e-01f, -2.37280667e-01f, -5.53453505e-01f, -5.84730739e-03f, -2.31377244e-01f, 6.97640553e-02f, -4.54996936e-02f, 1.33019775e-01f,
  -7.70144165e-02f, 1.52945131e-01f, -7.25073740e-02f, 2.04205379e-01f, -7.45444968e-02f, -6.53644651e-03f, -1.34774506e-01f, 4.22230968e-03f, -2.53216416e-01f, -1.64228529e-01f,
  2.68264376e-02f, 6.12404160e-02f, -2.23291833e-02f, 8.58136639e-03f, -1.62400659e-02f, -3.26346643e-02f, -3.91863771e-02f, -5.38742989e-02f, 5.70728518e-02f, -1.30046206e-03f,
  6.28700554e-02f, 1.71145007e-01f, 5.17273173e-02f, -1.57942787e-01f, -8.50404873e-02f, -9.61807743e-03f, 3.65611650e-02f, -1.20317422e-01f, 3.40620540e-02f, -8.21905211e-02f,
  -1.44559387e-02f, -9.30253882e-03f, 5.84828341e-03f, 4.12406912e-03f, -4.58865948e-02f, 5.31941578e-02f, -3.43629047e-02f, -6.20393530e-02f, -6.04305863e-02f, -8.42507109e-02f,
  -1.09914467e-01f, 7.11817443e-02f, 9.25917476e-02f, 4.83005978e-02f, 1.77925639e-02f, 7.67933652e-02f, -8.12395127e-04f, 5.03859743e-02f, -2.06780024e-02f, 5.79270385e-02f,
  6.27636984e-02f, -2.70410702e-02f, -1.10805677e-02f, -3.90089303e-02f, 4.48853225e-02f, -6.40088692e-02f, -7.14080110e-02f, 1.16071604e-01f, -3.87190692e-02f, -2.95757540e-02f,
  6.40824065e-02f, -1.29245251e-01f, 9.97042358e-02f, 7.56846815e-02f, 1.93155706e-02f, 1.13757879e-01f, -2.48349942e-02f, -3.22245024e-02f, 5.21833496e-03f, 2.82324441e-02f,
  8.39953870e-02f, 6.85420856e-02f, 1.14275485e-01f, 1.47862360e-01f, 7.01678097e-02f, -2.17256129e-01f, -8.97277892e-02f, -4.60471064e-02f, 1.63116381e-02f, -3.50493006e-02f,
  -3.40148471e-02f, 1.04046956e-01f, 3.31079513e-02f, -1.27650037e-01f, 5.89354597e-02f, -2.89468728e-02f, 1.75884694e-01f, -1.53197041e-02f, 5.13745099e-02f, -2.19868887e-02f,
  1.03282057e-01f, 1.58257410e-01f, 2.13603750e-01f, 1.42974108e-01f, 7.24324584e-02f, 1.57163545e-01f, -3.75804678e-02f, -6.75676465e-02f, 3.26369796e-03f, 7.98346475e-03f,
  -2.38229215e-01f, 1.78072393e-01f, -1.84409156e-01f, -1.10230312e-01f, -4.47158515e-03f, -3.43320966e-01f, -1.71320185e-01f, -6.05267808e-02f, 1.32816657e-01f, 1.79005012e-01f,
  6.00455105e-02f, 2.33094662e-01f, 1.42708421e-01f, 4.10242379e-03f, -2.79471576e-01f, 1.79219827e-01f, -2.68269122e-01f, 9.89975888e-05f, 1.23679653e-01f, -2.23668247e-01f,
  -1.24790326e-01f, -6.86242133e-02f, -2.79986393e-02f, -2.89993621e-02f, -1.24584325e-01f, -7.92213231e-02f, -4.68968786e-02f, 1.11618847e-01f, -1.95298404e-01f, 6.39642999e-02f,
  -6.14659972e-02f, 1.75670311e-01f, 7.26547092e-02f, 1.35701085e-02f, -1.80394039e-01f, -4.16293256e-02f, -1.13951892e-01f, 5.90186566e-02f, 1.33062363e-01f, -1.15769785e-02f,
  6.51254281e-02f, 2.88553573e-02f, 1.30711682e-02f, 6.64021149e-02f, 7.99814053e-03f, 1.05757378e-01f, 4.96973693e-02f, -1.13818169e-01f, 1.83130447e-02f, 3.20664831e-02f,
  1.40752112e-02f, -3.49136963e-02f, -9.41023752e-02f, 2.72214832e-03f, -2.18097959e-02f, 1.84215177e-02f, -4.91684638e-02f, 1.80078279e-02f, -6.82221428e-02f, -6.91163316e-02f,
  1.58611331e-02f, -9.76644829e-02f, -1.06159383e-02f, -4.74623442e-02f, 2.82830633e-02f, -4.98303771e-03f, -9.61926999e-04f, -6.27509877e-02f, 9.24125761e-02f, 3.63105498e-02f,
  -8.75079036e-02f, -5.64338043e-02f, 8.09357017e-02f, -5.77923693e-02f, -5.60676754e-02f, 3.00882962e-02f, -1.65202674e-02f, 3.96038704e-02f, -1.71412066e-01f, -4.45235632e-02f,
  7.57260025e-02f, 1.34459240e-02f, 2.72277370e-02f, 4.79394868e-02f, 6.36393577e-02f, 8.31689164e-02f, 7.43325381e-03f, 5.72805665e-02f, 5.31434864e-02f, -1.69016778e-01f,
  -2.30748937e-01f, -8.70480835e-02f, 9.74298418e-02f, 5.83778694e-02f, 5.98755386e-03f, -1.17012616e-02f, -3.29434164e-02f, -9.22392309e-03f, -1.21615781e-02f, -1.26935123e-02f,
  -7.99318478e-02f, 1.94098670e-02f, -1.38831049e-01f, 2.46306807e-02f, -6.66544959e-02f, -3.82047743e-02f, -5.32176420e-02f, 1.34146949e-02f, -1.12381458e-01f, -2.28094961e-02f,
  -6.29158095e-02f, -3.61447223e-02f, -3.27951498e-02f, 3.46179530e-02f, 3.57603580e-02f, 5.77317216e-02f, -7.18545495e-03f, 9.91476253e-02f, -3.29926284e-03f, 4.13375832e-02f,
  -2.54036635e-01f, -1.73980728e-01f, -9.64923128e-02f, -1.83631212e-01f, 1.81849003e-01f, 2.04320475e-01f, -1.60524294e-01f, 1.32931650e-01f, -2.17378035e-01f, -7.00440630e-02f,
  -1.97316222e-02f, -3.65295023e-01f, -2.06176579e-01f, -3.08587044e-01f, -9.92104039e-02f, -3.11911851e-01f, -7.05780238e-02f, -1.92899585e-01f, -1.70227438e-01f, -9.08429772e-02f,
  -6.77089915e-02f, -1.36924997e-01f, -8.93023461e-02f, 1.71280876e-01f, -7.88173079e-02f, 9.58375260e-02f, 1.41066164e-01f, 2.43463423e-02f, 8.01505968e-02f, -9.89493728e-03f,
  2.17189696e-02f, -1.33417249e-01f, 5.19491099e-02f, 3.13952640e-02f, 1.06849499e-01f, 1.11819252e-01f, 1.07029624e-01f, 4.54115421e-02f, 1.11706257e-01f, 6.30912837e-03f,
  -4.09124419e-02f, -6.70323819e-02f, -1.02195069e-01f, 5.65751567e-02f, 2.44510397e-02f, -1.12662129e-02f, -9.50458795e-02f, 1.04183041e-01f, 3.98558266e-02f, -1.64055511e-01f,
  -1.53869316e-01f, -9.89692956e-02f, -1.49408253e-02f, -4.30006199e-02f, -6.08287379e-02f, -9.73135680e-02f, -8.14940184e-02f, -5.11123240e-02f, -1.76547021e-02f, -7.83871040e-02f,
  -3.94165851e-02f, 5.15480945e-03f, -4.90970463e-02f, 2.61416044e-02f, -1.44214975e-02f, 1.08022444e-01f, 5.82867824e-02f, 4.49961200e-02f, -4.11537811e-02f, 1.22301467e-02f,
  8.07288066e-02f, -7.66513124e-03f, -3.72265242e-02f, 9.19538364e-02f, -1.01161152e-01f, 8.60790461e-02f, 6.97390139e-02f, -9.14808288e-02f, -1.60735309e-01f, 1.19710624e-01f,
  1.65237889e-01f, 1.40231937e-01f, -5.57191297e-02f, 5.41827641e-02f, 1.24164708e-01f, -4.70739901e-02f, -1.88468713e-02f, -3.27400118e-03f, 1.17999680e-01f, -3.11281122e-02f,
  4.79624346e-02f, 4.38372940e-02f, 2.60052774e-02f, 4.79692034e-02f, 7.56655335e-02f, 1.83201171e-02f, 6.36641309e-02f, 6.84663001e-03f, 5.34491427e-02f, -1.14182755e-01f,
  5.60072809e-02f, 1.02303118e-01f, 9.16221067e-02f, 1.70653220e-03f, 8.16882178e-02f, 3.18364948e-02f, -2.86938157e-02f, 1.36104733e-01f, 1.25093237e-01f, 6.42652512e-02f,
  3.90620306e-02f, -7.43839936e-03f, -2.33814567e-02f, -2.35623568e-02f, 2.78682727e-02f, -8.64345953e-02f, 3.84236388e-02f, -1.63604707e-01f, -6.52233139e-02f, -3.71221304e-02f,
  -1.26791835e-01f, 6.47580102e-02f, 6.09529093e-02f, -3.71293664e-01f, -6.69486821e-02f, 5.85466065e-02f, -2.53519088e-01f, 5.45878857e-02f, 7.85452724e-02f, -5.83422594e-02f,
  -1.73118860e-01f, 8.65728781e-02f, 1.57965511e-01f, -2.76164114e-01f, 2.86892086e-01f, 1.17194466e-01f, -2.59411454e-01f, -1.76079378e-01f, 5.00558168e-02f, -3.91737334e-02f,
  1.02017306e-01f, -1.09994322e-01f, -1.86468288e-02f, -1.55582009e-02f, -2.24406734e-01f, -1.50390595e-01f, -1.56937853e-01f, -6.18699612e-03f, -3.14518332e-01f, 1.99765675e-02f,
  -1.29452154e-01f, -1.89648598e-01f, -1.69631988e-01f, 2.77187042e-02f, -3.22005264e-02f, -2.62886770e-02f, -4.60384488e-02f, -1.95913352e-02f, -1.07150540e-01f, 7.11823180e-02f,
  6.46168217e-02f, 9.95171741e-02f, -7.66416937e-02f, 6.22796901e-02f, -4.38244157e-02f, 3.49250734e-02f, -5.31135350e-02f, -2.97518745e-02f, -1.93072315e-02f, 1.52660891e-01f,
  4.63021174e-02f, 1.64948218e-02f, -1.00512914e-01f, -1.00176230e-01f, -1.71590727e-02f, -1.36203393e-01f, -4.37596254e-02f, -3.94550711e-02f, -6.82792962e-02f, 2.01144181e-02f,
  -2.07065884e-02f, -3.15194242e-02f, -4.05800492e-02f, 3.91956046e-02f, 3.32204904e-03f, 3.76828983e-02f, 1.03085093e-01f, -4.26290371e-02f, -9.66205820e-02f, -9.57488827e-03f,
  -9.09913853e-02f, -7.25259408e-02f, -8.75224825e-03f, 3.12101059e-02f, -7.51607306e-03f, -1.42475190e-02f, -8.57372656e-02f, 1.41301397e-02f, 8.95260796e-02f, 3.47017683e-02f,
  -2.58455910e-02f, 9.30441078e-03f, -1.11303888e-01f, -1.64837502e-02f, -2.26635206e-03f, 2.93075293e-02f, 1.07710541e-03f, -1.67113952e-02f, -1.68269146e-02f, 1.44837543e-01f,
  -1.58515126e-02f, -1.70169786e-01f, 1.17410727e-01f, -6.59773350e-02f, 8.18090960e-02f, 8.49816203e-02f, -4.39337753e-02f, -5.74293546e-02f, -4.65870090e-02f, -5.52154779e-02f,
  8.40458646e-03f, -4.80589867e-02f, 6.10306673e-02f, -2.12822482e-02f, 1.51804268e-01f, 7.27800354e-02f, -2.61875447e-02f, -1.14524448e-02f, -4.96358648e-02f, 9.59068760e-02f,
  2.04320420e-02f, -2.52289232e-04f, 5.48867993e-02f, -5.15312888e-02f, -2.10143179e-02f, -5.72244935e-02f, -3.42091247e-02f, -5.53882308e-02f, -3.19039747e-02f, -1.99170168e-02f,
  2.34126896e-01f, 3.24066043e-01f, 2.97128707e-01f, 2.80920446e-01f, -2.25007042e-01f, 1.46443397e-01f, 2.27970585e-01f, 5.81242293e-02f, 2.59746671e-01f, 7.62789175e-02f,
  -2.79724270e-01f, 2.51037478e-01f, -1.17371514e-01f, 9.14569385e-03f, -2.15320319e-01f, 6.81527425e-03f, 1.15778066e-01f, 1.02357000e-01f, 1.21416533e-02f, 2.63551865e-02f,
  7.72323161e-02f, -2.22921401e-01f, -2.99200621e-02f, -2.16749370e-01f, 4.99706939e-02f, 1.96571544e-01f, -3.01772028e-01f, -1.15738675e-01f, 3.99750611e-03f, -4.19586748e-02f,
  -2.84141600e-02f, -4.80028428e-02f, -7.71811791e-03f, 9.75961462e-02f, 1.22029725e-02f, -7.67264590e-02f, 3.34851854e-02f, -5.18351747e-03f, 4.46413904e-02f, 1.01343893e-01f,
  6.91278949e-02f, 4.53618392e-02f, 6.72338381e-02f, -1.01133458e-01f, -2.37981398e-02f, -4.24524245e-04f, 1.19204096e-01f, 4.63570580e-02f, 6.63475916e-02f, 1.80728678e-02f,
  7.03389943e-02f, 1.24519974e-01f, 5.57950400e-02f, 6.41825050e-02f, 4.22702208e-02f, 8.24757367e-02f, 8.07547569e-02f, 1.15169175e-01f, 1.16739370e-01f, 1.91011894e-02f,
  -8.26723427e-02f, 7.23893270e-02f, -1.05592441e-02f, -1.84133220e-02f, 9.80690308e-03f, 1.22775761e-02f, -2.14336291e-02f, -3.20441201e-02f, 3.44010927e-02f, -1.32228071e-02f,
  -2.46929675e-02f, 1.52187897e-02f, -1.44020123e-02f, 2.70355260e-04f, 4.79680523e-02f, -2.08454803e-02f, -3.45475078e-02f, 1.15421802e-01f, -1.72198974e-02f, -4.69121709e-02f,
  -1.06239535e-01f, -9.57819745e-02f, -7.07361028e-02f, 9.30866785e-03f, 1.35327978e-02f, -3.96881811e-02f, -1.00989593e-02f, -2.28118766e-02f, -5.88537306e-02f, -5.19635715e-02f,
  8.34950339e-03f, 1.45724326e-01f, 4.45956253e-02f, 1.22999782e-02f, -1.54755786e-02f, -1.73617169e-01f, -5.39578535e-02f, 1.28113702e-01f, -2.79758461e-02f, -6.04044497e-02f,
  1.24857286e-02f, 4.75502089e-02f, -4.10814509e-02f, -9.79323164e-02f, 7.59891747e-03f, -1.82623547e-02f, 1.24304138e-01f, -8.03557632e-04f, 9.84810479e-03f, 2.64183041e-02f,
  6.41616210e-02f, 4.69702445e-02f, 9.85757113e-02f, 4.65205535e-02f, 1.29618660e-01f, 9.18355882e-02f, 1.73969083e-02f, 3.18268011e-03f, -1.33128213e-02f, 8.19125155e-04f,
  -6.59882873e-02f, 7.67546892e-02f, 2.20387384e-01f, 1.21833049e-01f, 2.17128232e-01f, 3.37624669e-01f, 1.62911698e-01f, 1.54192165e-01f, 4.02174145e-01f, -6.08729618e-03f,
  -1.75912648e-01f, 1.22617371e-02f, -1.40657887e-01f, -2.25654878e-02f, 4.23927940e-02f, 6.04883395e-02f, 9.90758985e-02f, 1.12235412e-01f, 9.13473740e-02f, -6.36265799e-03f,
  9.12988782e-02f, -7.17009157e-02f, -1.58185646e-01f, -9.93441269e-02f, -5.49843311e-02f, 4.11151536e-03f, -2.38428965e-01f, 8.52092728e-02f, -1.56927720e-01f, 1.05930805e-01f,
  7.40295881e-03f, -1.22653551e-01f, -1.60457864e-01f, -4.29667272e-02f, -4.11674799e-03f, -2.96191294e-02f, 1.13780629e-02f, -2.82275397e-02f, -1.94014385e-02f, -7.77790248e-02f,
  -7.25558400e-02f, -3.42931971e-02f, -4.21719141e-02f, 1.28797526e-02f, 4.07454222e-02f, -6.12834357e-02f, -6.39501140e-02f, -3.61739448e-03f, -2.67612822e-02f, 7.07975402e-02f,
  -3.62282731e-02f, -6.89460617e-03f, 1.43708000e-02f, 1.10192880e-01f, 1.98068749e-03f, 2.89189890e-02f, 9.04725194e-02f, 4.11276147e-02f, 1.02691926e-01f, 1.26995385e-01f,
  -5.24890283e-03f, 1.25006616e-01f, -6.05517961e-02f, -7.93398172e-02f, -1.31101012e-01f, -1.32612186e-04f, -1.04454411e-02f, -1.40969142e-01f, 7.17820004e-02f, -8.44171420e-02f,
  -5.76986931e-02f, -8.32680240e-02f, -3.15743592e-03f, -1.35718351e-02f, 4.55168299e-02f, 4.09421995e-02f, 7.84452260e-03f, -1.70843825e-02f, 2.02240832e-02f, -1.58288732e-01f,
  2.71113757e-02f, 1.04053661e-01f, -1.71965852e-01f, -1.97076462e-02f, -5.87069467e-02f, -8.14517364e-02f, -9.43468232e-03f, 1.62411295e-02f, -7.75500163e-02f, 2.96352860e-02f,
  9.14142355e-02f, 2.15491802e-01f, -9.79655161e-02f, -8.45485702e-02f, 1.03626903e-02f, -1.20246699e-02f, 9.67728868e-02f, -1.36919757e-02f, 4.79332097e-02f, -2.41919160e-02f,
  1.14943394e-02f, -6.19017333e-02f, 7.67033920e-02f, -7.50530139e-02f, -2.31888965e-02f, 4.31599356e-02f, 4.15076427e-02f, -4.26743254e-02f, 7.37842843e-02f, -3.81560214e-02f,
  -1.16264679e-01f, -6.75082803e-02f, -4.35463600e-02f, 3.17855403e-02f, 6.19280385e-03f, -7.55592659e-02f, -3.69252823e-02f, 1.35476822e-02f, 4.29857560e-02f, 8.37321132e-02f,
  8.26590927e-04f, -5.11913851e-04f, -2.36856326e-01f, -1.16969995e-01f, 7.39024431e-02f, 1.53063804e-01f, 1.19806118e-01f, -9.35884863e-02f, -2.68879831e-01f, 2.56692320e-01f,
  1.41196206e-01f, -1.97389320e-01f, 1.46685719e-01f, 2.37201318e-01f, -2.28157401e-01f, 3.19077522e-02f, 1.37844726e-01f, 1.07426412e-01f, -7.36889616e-02f, 8.04061666e-02f,
  -8.06390196e-02f, 3.12125951e-01f, -9.61054862e-02f, 1.44503221e-01f, 1.74492165e-01f, -1.36349976e-01f, 1.19524978e-01f, -1.00090634e-02f, 1.03284307e-01f, 6.42670840e-02f,
  6.31337836e-02f, -3.56323496e-02f, -9.61669832e-02f, 2.63765194e-02f, -1.82572808e-02f, 1.62253752e-01f, 8.03127214e-02f, 2.52769608e-03f, -5.11457622e-02f, -6.18581846e-02f,
  1.26684457e-01f, -4.06651944e-02f, -9.92426202e-02f, -5.12285642e-02f, 1.57898068e-02f, -6.84582964e-02f, -1.11665232e-02f, -1.16613752e-03f, 1.74665432e-02f, 6.13870062e-02f,
  -6.42028600e-02f, -2.29454543e-02f, 8.19156971e-03f, -8.12676400e-02f, -1.24857903e-01f, 2.82696802e-02f, 1.59966443e-02f, -2.01520771e-02f, -1.42458186e-03f, -5.63262701e-02f,
  5.42499498e-02f, 9.54684541e-02f, 3.53037827e-02f, 9.13410485e-02f, -5.84146976e-02f, 4.02452610e-02f, 9.86670237e-03f, 9.19038579e-02f, -1.46062747e-01f, 2.98569221e-02f,
  3.80601659e-02f, -7.95669109e-02f, 1.09234750e-01f, -3.51749659e-02f, 5.27172573e-02f, -3.14237922e-02f, 4.56311665e-02f, 1.03017464e-01f, 8.71987790e-02f, -8.67477804e-02f,
  -1.35418251e-02f, -7.54698142e-02f, 2.67199725e-02f, 7.40106106e-02f, 6.32339716e-02f, -1.28869697e-01f, 9.08357278e-02f, 9.00306627e-02f, -2.64000688e-02f, 1.50983259e-01f,
  -1.05136726e-02f, -1.24399483e-01f, -1.10692516e-01f, 6.03404492e-02f, 1.41488360e-02f, 7.06900135e-02f, 8.78204033e-03f, -4.91376892e-02f, -2.61594951e-02f, -2.98978528e-03f,
  2.37664916e-02f, -2.15254687e-02f, -9.29531548e-03f, -7.25105852e-02f, -8.47798213e-02f, -7.14222416e-02f, 1.04374185e-01f, -5.36010228e-03f, 6.09203912e-02f, 2.34764628e-02f,
  2.32937727e-02f, 1.27359270e-03f, -9.60577577e-02f, 3.44463997e-03f, -2.79202443e-02f, 1.03302307e-01f, -1.29413251e-02f, 1.47471037e-02f, 5.79859056e-02f, 5.03403659e-04f,
  3.69334310e-01f, -2.81473458e-01f, -1.37328148e-01f, 1.89437658e-01f, 2.20772073e-01f, 1.53866202e-01f, 6.76599145e-02f, 6.87597021e-02f, 2.29066148e-01f, -2.26471737e-01f,
  -3.78967039e-02f, -9.32271555e-02f, -3.58398587e-01f, 1.81032643e-01f, 1.73936978e-01f, -1.94470137e-01f, 1.98742479e-01f, 6.35367557e-02f, -3.85047402e-03f, 4.58240174e-02f,
  1.88077047e-01f, 1.71392664e-01f, -1.25721842e-01f, 7.52901211e-02f, 3.71257551e-02f, -3.30303609e-02f, -1.22477740e-01f, -2.01560825e-01f, 1.04727298e-01f, 7.19377473e-02f,
  6.96461722e-02f, 3.98465917e-02f, 6.14152849e-03f, -3.84120271e-03f, 4.15549353e-02f, 5.21387234e-02f, -4.00131848e-03f, 7.45172426e-03f, 2.38817669e-02f, -2.97729764e-02f,
  -6.60936236e-02f, 8.04037303e-02f, 1.01465829e-01f, 4.27262224e-02f, 1.12165019e-01f, 1.48607478e-01f, 5.63740842e-02f, -3.12639549e-02f, -1.18596619e-02f, -2.34426111e-02f,
  1.59743323e-03f, -5.36517464e-02f, -5.03953733e-02f, -1.07504306e-02f, -1.84730869e-02f, 8.54479000e-02f, -2.84504425e-03f, -1.16779871e-01f, -1.75102558e-02f, 8.30091164e-02f,
  -2.78323088e-02f, -1.10965237e-01f, -2.30054222e-02f, -5.11122532e-02f, -9.72779766e-02f, -1.28000770e-02f, 3.88135463e-02f, -3.80819142e-02f, -3.37886736e-02f, -4.38653454e-02f,
  5.92663512e-02f, 7.75081739e-02f, -5.69638424e-03f, 6.75099492e-02f, 2.78175715e-03f, 5.38229309e-02f, -4.37600445e-03f, -9.11072455e-03f, -4.54811864e-02f, 4.41927500e-02f,
  5.10768592e-03f, 7.48704970e-02f, -8.03781673e-02f, 2.37067267e-02f, -1.49800507e-02f, -1.70978718e-02f, 1.05585745e-02f, -2.15415303e-02f, -2.21544150e-02f, -2.19669044e-02f,
  -9.80269983e-02f, -2.54873186e-01f, -7.09947944e-02f, 7.00288266e-02f, -5.53279705e-02f, 1.31968528e-01f, 1.09197907e-01f, 1.13193698e-01f, -7.67985731e-02f, 4.43749502e-02f,
  3.07262912e-02f, 1.38446754e-02f, -3.87040488e-02f, 8.82500708e-02f, -5.88696748e-02f, 8.42808634e-02f, -4.79190573e-02f, -5.27472943e-02f, -2.58511975e-02f, -1.67261399e-02f,
  -3.73984911e-02f, -3.19907852e-02f, -5.25840297e-02f, 2.89044660e-02f, -7.37082725e-03f, -1.03862680e-01f, 1.66423339e-02f, -1.93793774e-02f, -1.74857825e-02f, 7.73844495e-02f,
  3.28286380e-01f, 1.38718665e-01f, 1.03602275e-01f, -2.73756199e-02f, -1.30567431e-01f, -1.99942023e-01f, -1.93532780e-01f, -1.55073404e-01f, 5.88953868e-02f, 5.88777699e-02f,
  -2.68803686e-01f, 2.29181305e-01f, -1.52459413e-01f, -4.15532552e-02f, -1.04944073e-01f, -8.01885724e-02f, -2.86606699e-01f, -9.11083668e-02f, 9.35854241e-02f, -1.41547441e-01f,
  -6.09258655e-03f, -3.28468472e-01f, -1.11531951e-01f, -1.62055835e-01f, -6.14623092e-02f, 9.31212455e-02f, -1.12407833e-01f, 3.46172415e-02f, -6.06046803e-02f, 3.68284946e-03f,
  4.60742004e-02f, 1.18942007e-01f, 8.55698958e-02f, 8.22564662e-02f, -1.20597519e-02f, 2.05463152e-02f, 6.78517157e-03f, -6.82895631e-02f, 3.04721948e-03f, -2.10124701e-02f,
  -5.01764342e-02f, -4.72843722e-02f, -2.96028946e-02f, 6.60527423e-02f, 5.76326139e-02f, 1.12632848e-01f, -3.31858508e-02f, -8.81899148e-03f, -7.03331009e-02f, 1.08866282e-01f,
  4.17346917e-02f, 5.48073538e-02f, 4.71281782e-02f, -5.74450195e-02f, -8.64633769e-02f, -2.23666318e-02f, 2.71292124e-02f, 4.60447893e-02f, -4.05746698e-02f, 8.24768916e-02f,
  5.36194164e-03f, 3.22313868e-02f, -2.87639983e-02f, 2.88571957e-02f, -2.43745418e-03f, -7.36094415e-02f, -2.55717486e-02f, -1.09933792e-02f, 8.87014642e-02f, -7.67165571e-02f,
  -1.33335620e-01f, 1.86443292e-02f, -9.06136911e-03f, 4.92329746e-02f, 5.80269936e-03f, 1.71803519e-01f, -1.01027610e-02f, -7.60083050e-02f, -9.27116722e-02f, -6.16136193e-02f,
  -1.29122008e-02f, -8.61351553e-04f, -1.85409281e-02f, -4.17578220e-02f, -6.00249134e-02f, 6.96496889e-02f, 4.19133157e-03f, 9.69694331e-02f, -9.31104925e-03f, -1.16076358e-01f,
  -1.43051594e-01f, -1.37830436e-01f, -9.18172374e-02f, 9.94613394e-04f, -9.18653503e-04f, 5.02400845e-02f, 8.93430561e-02f, -4.08539921e-02f, -4.49190699e-02f, -6.17197938e-02f,
  -2.85675935e-02f, -7.43691996e-02f, -2.75307223e-02f, 7.12904427e-03f, -4.14216854e-02f, -2.05176268e-02f, -1.01924501e-01f, -4.38875370e-02f, -1.35941923e-01f, -4.25863005e-02f,
  -1.29973993e-01f, -2.48702317e-02f, -6.00190237e-02f, -1.03056483e-01f, -1.56590521e-01f, -1.09810062e-01f, 8.90861526e-02f, 8.96522775e-02f, -5.69012351e-02f, 7.53942062e-04f,
  3.80245000e-01f, 1.41783729e-01f, 2.17994764e-01f, 1.74222454e-01f, 4.76040430e-02f, -1.41938746e-01f, -3.69161442e-02f, 1.06642060e-01f, 1.01710461e-01f, -7.73191750e-02f,
  -1.31562442e-01f, 9.00654793e-02f, -1.74884006e-01f, 5.02903126e-02f, -3.85308355e-01f, -1.76324442e-01f, -5.85264564e-02f, -2.29659528e-02f, 4.57222713e-03f, -1.37805073e-02f,
  -2.51361225e-02f, -2.38013878e-01f, -4.60271500e-02f, -1.05061136e-01f, 2.31175974e-01f, 1.90685153e-01f, -1.69059888e-01f, -9.25586671e-02f, -2.49545313e-02f, -1.07640892e-01f,
  6.29683584e-02f, 2.00488254e-01f, 1.04729779e-01f, 3.94709874e-03f, 1.43634658e-02f, -1.19449191e-01f, -2.87849400e-02f, -5.42849973e-02f, 3.01562659e-02f, 4.68178280e-02f,
  1.73186123e-01f, 5.96608520e-02f, 2.21207775e-02f, 2.95154192e-02f, 5.02463728e-02f, 7.82697275e-02f, 1.70101836e-01f, 8.35444331e-02f, 5.74687235e-02f, 1.49247125e-01f,
  5.25241941e-02f, 1.20592520e-01f, -8.49765018e-02f, -7.76372105e-02f, 3.80362831e-02f, 9.18878615e-02f, -5.61397895e-02f, 8.37942734e-02f, 4.63366807e-02f, -1.00891134e-02f,
  1.82396676e-02f, -1.60075426e-01f, -9.11234915e-02f, 3.93717410e-03f, -5.43260351e-02f, -2.51812432e-02f, -2.35655764e-03f, 5.39124303e-04f, -4.77961265e-02f, -2.84125172e-02f,
  7.21898004e-02f, 6.40267357e-02f, 6.47636084e-03f, -8.35025385e-02f, -7.81809911e-03f, 9.75362305e-03f, 1.93044636e-02f, -1.80745590e-02f, 1.01492358e-02f, 9.02655199e-02f,
  -3.80598418e-02f, -1.03732748e-02f, 1.49526661e-02f, 1.10509716e-01f, 6.87584840e-03f, -3.52314375e-02f, -4.56815362e-02f, 1.29378065e-01f, -3.72065231e-02f, -1.19760029e-01f,
  -3.01619709e-01f, -3.16175699e-01f, -1.30263567e-01f, 9.46903229e-02f, -7.25966394e-02f, -1.19144514e-01f, -5.91673926e-02f, 1.14099212e-01f, -1.17411055e-01f, -2.24918220e-02f,
  7.95682967e-02f, 7.98124969e-02f, -9.12963152e-02f, -1.94502696e-02f, -9.92817581e-02f, -2.85911970e-02f, 2.63868980e-02f, -1.41478255e-01f, -3.96733992e-02f, 2.44234540e-02f,
  1.11556249e-02f, 3.12888101e-02f, -1.11254066e-01f, -9.54831019e-03f, 8.37414116e-02f, 7.84928501e-02f, -4.36704904e-02f, 3.87038030e-02f, -5.06355390e-02f, -8.86592083e-03f,
  -4.59906429e-01f, 1.44786030e-01f, 5.15613973e-01f, -1.14483543e-01f, -3.71378243e-01f, 1.97532639e-01f, 2.90069669e-01f, -1.64947838e-01f, 4.16962355e-02f, 5.56344278e-02f,
  -1.81204438e-01f, -3.85141070e-03f, 6.74813762e-02f, -2.52360664e-02f, 2.52221614e-01f, 2.79520094e-01f, 1.16806604e-01f, 1.33296102e-01f, -9.34402421e-02f, -9.47694108e-02f,
  -2.40433197e-02f, -2.77368277e-01f, 2.15831354e-01f, -1.17181592e-01f, -1.77033231e-01f, -8.64665806e-02f, -7.87932947e-02f, 1.66465864e-01f, 3.21184658e-02f, 3.64721343e-02f,
  -2.45698184e-01f, -1.81637689e-01f, -1.60777420e-01f, 1.02290735e-01f, -1.03449345e-01f, 5.52959889e-02f, 1.52525768e-01f, 3.50191258e-02f, -4.57360744e-02f, -3.86969186e-02f,
  -2.31973585e-02f, -1.14042282e-01f, -1.34510323e-01f, 5.00573367e-02f, 1.40927667e-02f, 3.84594053e-02f, 1.40644023e-02f, 5.74435014e-03f, -7.74122700e-02f, 4.60337214e-02f,
  -1.56007512e-02f, 2.40541771e-02f, -2.67192218e-02f, 8.76893699e-02f, 1.06496951e-02f, 5.96623123e-02f, 9.16498527e-02f, 4.35160398e-02f, 1.20714486e-01f, -2.37892643e-02f,
  3.06442101e-02f, 2.29292586e-02f, 1.08113609e-01f, 7.02914298e-02f, 8.86534527e-03f, -2.98120473e-02f, 4.59677763e-02f, -1.50627226e-01f, 7.99846202e-02f, -4.96538822e-03f,
  -8.61545652e-02f, 9.22877043e-02f, -7.52829239e-02f, 2.61923801e-02f, -4.09366749e-02f, 3.34241688e-02f, 1.13791853e-01f, -1.15113065e-01f, -7.30010739e-04f, -3.92768197e-02f,
  -1.00497097e-01f, 1.28575101e-01f, -7.08439797e-02f, -6.48104772e-02f, 4.05886844e-02f, -9.70221311e-03f, -4.84752692e-02f, 7.97579810e-02f, -1.06313556e-01f, -2.35855002e-02f,
  -2.22131655e-01f, -2.55860835e-02f, -8.68636668e-02f, -1.07154295e-01f, 2.05371026e-02f, 7.18356073e-02f, -2.53121350e-02f, -8.67337361e-02f, 2.30913842e-03f, 5.27098700e-02f,
  5.12838662e-02f, -1.75046958e-02f, 5.51733896e-02f, -1.11070061e-02f, -1.67381987e-02f, -5.67316227e-02f, 4.32272032e-02f, 9.34492573e-02f, -1.98658207e-03f, -4.65972982e-02f,
  -2.05884889e-01f, 6.16948167e-03f, -2.27342881e-02f, -7.26804361e-02f, -7.02368375e-03f, 2.36910321e-02f, -1.33833177e-02f, -9.63810682e-02f, 1.32148981e-01f, -2.95065455e-02f,
  -1.01735413e-01f, -1.08986624e-01f, -1.53081506e-01f, -1.12937592e-01f, 1.07035808e-01f, 8.41315985e-02f, 1.93825699e-02f, 2.14116052e-02f, -1.69988900e-01f, 1.91645548e-01f,
  1.29273176e-01f, -1.39589682e-01f, 2.72281468e-02f, -9.70475152e-02f, -1.02606937e-01f, -1.37397528e-01f, 6.57773167e-02f, 5.05227931e-02f, -1.68007210e-01f, 1.51119873e-01f,
  9.58028287e-02f, 1.89444050e-02f, -2.53975634e-02f, 6.91182688e-02f, 4.77895588e-02f, 1.21185660e-01f, 2.96362460e-01f, 7.54614696e-02f, 2.17728361e-01f, -9.28832218e-03f,
  -1.06736161e-01f, -1.20403282e-01f, -1.64819099e-02f, -7.94719309e-02f, 1.32952347e-01f, 7.61619583e-02f, 4.96845320e-02f, -2.28059702e-02f, -5.75980991e-02f, 7.29166716e-02f,
  -9.47939884e-03f, -8.59815255e-02f, -1.04553578e-02f, 3.34939994e-02f, 2.06006654e-02f, 4.65890840e-02f, -7.44723007e-02f, 5.12436479e-02f, 1.15692767e-03f, -4.53297310e-02f,
  1.80809386e-02f, 5.26094530e-03f, 1.66452564e-02f, -7.49095306e-02f, -1.68636441e-02f, -2.12951321e-02f, 6.25214353e-02f, 1.74800664e-01f, 1.39588406e-02f, 1.27763346e-01f,
  4.70426530e-02f, -1.12669552e-02f, -8.93272460e-02f, -1.50306985e-01f, 4.16187979e-02f, -4.15335596e-02f, -8.80058408e-02f, 9.91978869e-03f, 2.73698312e-03f, 6.48961123e-03f,
  1.61398724e-02f, 1.13359233e-03f, 5.59484679e-03f, 3.48377414e-02f, 5.18953167e-02f, -3.20917666e-02f, -8.16050097e-02f, 5.74682914e-02f, -5.04540466e-02f, -1.19027548e-01f,
  -1.37256548e-01f, 7.84048289e-02f, 7.64991194e-02f, 3.40335220e-02f, -7.71162063e-02f, 1.59843460e-01f, 1.92312282e-02f, 4.35541235e-02f, -8.23223889e-02f, -4.33789976e-02f,
  1.04329534e-01f, 1.97708756e-01f, -3.72044183e-02f, -7.85352364e-02f, -1.17311720e-02f, 1.26758024e-01f, -1.47438534e-02f, -6.19827397e-02f, 4.00479184e-03f, 8.60196576e-02f,
  1.38903916e-01f, 3.10048424e-02f, 4.72042449e-02f, 9.24092904e-02f, -4.25167382e-02f, 1.58619419e-01f, -6.14155382e-02f, 6.10036105e-02f, 5.48880436e-02f, 1.19033214e-02f,
  6.66946694e-02f, 1.15393043e-01f, 1.69776659e-02f, -1.60564199e-01f, 3.31828487e-03f, 4.65796441e-02f, 3.78811806e-02f, 1.18047617e-01f, 2.56618652e-02f, 1.13135343e-03f,
  1.12332836e-01f, -4.80002016e-01f, 2.05825135e-01f, 4.50737536e-01f, 1.73641369e-01f, -1.47778317e-01f, 7.48884231e-02f, 7.92481750e-02f, -2.78285444e-02f, -3.57357144e-01f,
  5.66047207e-02f, -3.65482783e-03f, -1.40730500e-01f, 1.59102067e-01f, 3.10781151e-01f, -1.22719109e-01f, 6.75880909e-02f, -6.07097223e-02f, 7.37623349e-02f, 9.62413922e-02f,
  2.02032492e-01f, 1.26561001e-01f, 3.21700096e-01f, -2.29619388e-02f, -2.89328303e-03f, 8.38544965e-02f, 9.23759341e-02f, 4.96877246e-02f, 1.44530714e-01f, 7.93909729e-02f,
  -7.88990185e-02f, 3.05772200e-02f, 4.26645428e-02f, -9.77481455e-02f, -4.37963530e-02f, -3.17652300e-02f, 2.80378032e-02f, 7.34531209e-02f, 1.41083345e-01f, -4.45924141e-03f,
  1.06141847e-02f, -1.15804216e-02f, 6.58224747e-02f, -6.74551800e-02f, 3.13073099e-02f, -5.86981028e-02f, -1.64362434e-02f, -1.88251082e-02f, -1.37359649e-02f, 4.15793583e-02f,
  1.39098093e-02f, -3.55274156e-02f, 1.19702913e-01f, -2.93582994e-02f, 1.20507129e-01f, 4.61991951e-02f, 7.84169063e-02f, 7.99661130e-02f, 1.76519286e-02f, -1.96482331e-04f,
  -5.41459993e-02f, 6.91349283e-02f, 3.33043002e-02f, -3.09657250e-02f, 7.11408928e-02f, 6.87053725e-02f, -2.89629935e-03f, -3.31735164e-02f, 5.90001605e-02f, 6.28965767e-03f,
  3.89421545e-02f, -4.69417544e-03f, 3.75605598e-02f, 1.28741385e-02f, 1.13493353e-01f, 2.89513841e-02f, 7.19279125e-02f, 3.66028547e-02f, -5.99898910e-03f, -7.64425844e-03f,
  -8.40569362e-02f, 8.12404156e-02f, -1.00874983e-01f, -6.64214045e-03f, -8.23911503e-02f, -8.20528064e-03f, 3.36748436e-02f, -1.60907116e-02f, 8.15243870e-02f, 2.98046600e-02f,
  -2.35050708e-01f, -2.05035940e-01f, 2.13250313e-02f, -2.58623939e-02f, -1.08797856e-01f, -5.00180461e-02f, -3.15701626e-02f, -3.17902043e-02f, -9.62571651e-02f, 3.10121272e-02f,
  1.14229590e-01f, -6.14946068e-04f, -1.12918563e-01f, -4.81611909e-03f, 5.40385842e-02f, -1.08649880e-01f, 6.49209088e-03f, -6.85255304e-02f, -2.56339125e-02f, -1.31840142e-03f,
  1.92173850e-02f, -4.97216284e-02f, 8.11994076e-02f, 4.54911143e-02f, 1.82376504e-02f, -1.42300129e-02f, -2.75160652e-02f, 2.11512856e-02f, 1.33209396e-02f, -2.44759321e-02f,
  -1.11516736e-01f, 2.36150965e-01f, 1.68804124e-01f, 3.87425214e-01f, -2.72389948e-01f, -1.70116443e-02f, 1.01570107e-01f, -4.28742059e-02f, 4.56575304e-01f, 2.00137824e-01f,
  -8.32444653e-02f, 7.66300559e-02f, -9.14759934e-02f, 2.14919552e-01f, -4.36648458e-01f, 9.17537063e-02f, 1.38987303e-01f, 1.05010144e-01f, 9.35756490e-02f, 5.24467975e-02f,
  -8.95760134e-02f, -2.51279384e-01f, -5.34995981e-02f, -1.83530018e-01f, -3.13871615e-02f, 1.04099818e-01f, -2.23880157e-01f, -2.02804506e-02f, -3.05233113e-02f, -2.11169586e-01f,
  -1.10697068e-01f, 1.38368249e-01f, 2.90317368e-02f, -1.52045954e-02f, 1.85443636e-03f, 8.58383402e-02f, 6.62669465e-02f, -6.08396418e-02f, -2.23035645e-02f, -4.36525419e-02f,
  1.10731632e-01f, -8.32570791e-02f, -4.69760336e-02f, -2.44361367e-02f, 4.25231680e-02f, -1.76231340e-02f, -6.98322011e-03f, 1.14424363e-01f, -5.03197424e-02f, 9.69217643e-02f,
  -2.17304528e-02f, -2.76140701e-02f, 2.01641899e-02f, -6.91259792e-03f, -1.04580119e-01f, 1.23734571e-01f, 9.35970098e-02f, -4.71830815e-02f, -4.07139363e-04f, -5.06086797e-02f,
  4.19283807e-02f, 8.29321891e-03f, 6.62450492e-02f, -9.84233804e-03f, -5.05246930e-02f, -3.84576991e-02f, -6.05756566e-02f, -2.14141384e-01f, 8.45099092e-02f, -3.47116143e-02f,
  -5.53233325e-02f, 4.20855954e-02f, 2.73139253e-02f, 4.47777770e-02f, 4.34168614e-02f, 7.22352043e-02f, -1.24395601e-02f, 1.40251489e-02f, 5.16048633e-02f, -4.14911956e-02f,
  -3.02031115e-02f, 7.41608366e-02f, -2.35124324e-02f, -9.77279246e-02f, -6.69750124e-02f, 1.77646999e-03f, 1.18421607e-01f, 1.94754854e-01f, 6.09313138e-03f, -2.26574644e-01f,
  -2.28994414e-01f, -1.54402107e-01f, -1.11411795e-01f, -1.37204960e-01f, -5.22251166e-02f, -5.54160625e-02f, 2.01114528e-02f, 2.64427830e-02f, -8.44051242e-02f, 8.47070944e-03f,
  -2.11033188e-02f, -3.81644513e-03f, -9.40095708e-02f, 2.65389457e-02f, -2.37255916e-02f, -2.18610782e-02f, 5.29208630e-02f, 1.03330530e-01f, -1.17552720e-01f, -3.84538211e-02f,
  -6.47145212e-02f, -3.70222405e-02f, -7.06581622e-02f, -1.12477414e-01f, -5.28579205e-02f, -8.53685886e-02f, -3.87762450e-02f, 7.56146535e-02f, -1.51175007e-01f, -6.51035681e-02f,
  1.25437126e-01f, 3.34640324e-01f, 1.19770743e-01f, 1.47750184e-01f, -6.30046576e-02f, -1.81612577e-02f, 7.86750466e-02f, -5.20057715e-02f, -1.19667605e-01f, 2.36904144e-01f,
  -3.03417761e-02f, 2.15503380e-01f, 6.59971535e-02f, 2.37437084e-01f, -2.21458524e-01f, -4.18004021e-02f, 2.68021405e-01f, 1.57909796e-01f, -4.00939509e-02f, 2.92942882e-01f,
  7.24260807e-02f, 1.70437545e-01f, 3.46404612e-02f, -1.81423426e-02f, 2.58957416e-01f, 9.24283341e-02f, 8.74644667e-02f, -1.09348297e-01f, 2.07694501e-01f, -1.31249011e-01f,
  -3.02089024e-02f, 2.72554271e-02f, 5.67552932e-02f, -2.28717066e-02f, 5.54204471e-02f, -1.53373796e-02f, 1.02182679e-01f, -7.17843100e-02f, -3.92829627e-02f, 8.70788097e-02f,
  8.18681344e-02f, 4.50698175e-02f, -2.50121057e-02f, -1.71916261e-02f, -7.13605550e-05f, 2.61768028e-02f, 3.10697611e-02f, 7.96462297e-02f, 1.19594201e-01f, 4.32774350e-02f,
  7.26335868e-02f, 9.72632840e-02f, 3.08627579e-02f, 1.15238249e-01f, 1.21582821e-02f, 2.09457870e-03f, 1.29444182e-01f, 7.28670135e-02f, 5.73542193e-02f, 4.56158891e-02f,
  -2.26492323e-02f, 5.25210388e-02f, 4.47278060e-02f, 1.21981064e-02f, 2.33779270e-02f, -1.49392737e-02f, 1.14067914e-02f, -3.16470824e-02f, -7.26711797e-03f, 1.06151819e-01f,
  5.09390654e-03f, -1.45580387e-02f, -9.21126157e-02f, 1.22832082e-01f, 4.47869077e-02f, 1.60459634e-02f, -8.71822685e-02f, 4.15754281e-02f, 1.65197313e-01f, -3.47869396e-02f,
  -1.14850283e-01f, -4.48021330e-02f, -3.33574251e-03f, -7.17410445e-03f, -9.81207788e-02f, 5.61230034e-02f, 1.51097458e-02f, -8.33933242e-03f, -1.03871480e-01f, -8.07600841e-02f,
  1.27500981e-01f, 1.23396352e-01f, 2.96786893e-02f, 2.84189750e-02f, -1.43505009e-02f, 7.32175335e-02f, -2.64426358e-02f, 1.09639913e-02f, 1.14746258e-01f, -3.15721631e-02f,
  1.11095324e-01f, 2.64663268e-02f, -1.86892729e-02f, 8.96552578e-02f, -1.38420537e-01f, 5.73265962e-02f, -3.63865588e-03f, 9.16300118e-02f, 4.69557233e-02f, 3.97614320e-04f,
  9.19430703e-02f, 9.20836478e-02f, 3.35981511e-02f, 3.22982669e-02f, 8.52215439e-02f, 2.51174718e-02f, -4.90509979e-02f, -6.22851076e-03f, 9.78818536e-02f, 4.69377413e-02f,
  -2.17116475e-01f, -3.01200170e-02f, 1.47566855e-01f, -9.26897153e-02f, 2.66912639e-01f, 1.91278487e-01f, -8.53363201e-02f, 2.41478920e-01f, -5.30564636e-02f, -4.09897566e-02f,
  3.46443132e-02f, -1.25483394e-01f, -3.35827544e-02f, 1.11380093e-01f, -7.47864991e-02f, -3.82971279e-02f, 3.36212404e-02f, -9.93553847e-02f, -1.00603081e-01f, -7.66449347e-02f,
  -5.90150133e-02f, -5.59006035e-02f, 2.71939617e-02f, 3.54432911e-02f, 8.18809867e-02f, 4.74810265e-02f, 1.64238643e-03f, -1.62492320e-01f, 9.66539606e-03f, 5.49117522e-03f,
  7.01753423e-03f, 9.96448006e-03f, -6.55640289e-02f, 4.53246795e-02f, -4.34496142e-02f, -9.86965522e-02f, -1.02625385e-01f, 3.16183008e-02f, -1.07736476e-01f, 7.34376311e-02f,
  -6.81707114e-02f, -2.94764172e-02f, 7.48462901e-02f, -1.11985095e-01f, 6.66659400e-02f, 3.24486494e-02f, 1.73497289e-01f, 4.58412133e-02f, 1.53431281e-01f, 2.36108731e-02f,
  8.42307284e-02f, 6.53541759e-02f, 1.37542680e-01f, -3.35898995e-02f, 6.74109459e-02f, 3.89302708e-02f, 9.66712087e-02f, 7.66608566e-02f, 4.17284891e-02f, 7.68779069e-02f,
  -5.50912134e-03f, -5.43748364e-02f, -6.08387627e-02f, -9.23510455e-03f, -2.84316149e-02f, 6.30961508e-02f, -4.31760810e-02f, 7.57145286e-02f, -6.33071810e-02f, -3.66478376e-02f,
  -7.10576074e-03f, 1.49492305e-02f, 1.65858105e-01f, -3.69573967e-03f, -8.55498537e-02f, 6.87377378e-02f, -5.16612120e-02f, 5.20979166e-02f, 4.36886325e-02f, -1.62340030e-02f,
  -1.03001624e-01f, 6.07283227e-02f, 3.57737653e-02f, 1.89617574e-02f, 7.43308440e-02f, -3.45614776e-02f, -5.87025359e-02f, 6.16819561e-02f, -1.21630700e-02f, -1.32351547e-01f,
  -1.34012118e-01f, -1.55053779e-01f, -1.12649769e-01f, 2.83701420e-02f, -8.83432105e-02f, 5.51142506e-02f, -1.19481191e-01f, 9.76114869e-02f, -8.47696587e-02f, 9.03901234e-02f,
  4.30553854e-02f, -2.08803546e-02f, 4.31687273e-02f, -2.18856893e-02f, -2.87380884e-03f, 2.32745185e-02f, 1.01681910e-02f, -4.51157801e-02f, 8.30146074e-02f, 7.94718228e-03f,
  2.71191839e-02f, -3.94646376e-02f, 3.76682132e-02f, 2.94293500e-02f, 8.53874460e-02f, 4.69068848e-02f, 1.13105327e-02f, 7.60075599e-02f, 9.47751254e-02f, -8.80860351e-03f,
  9.22176614e-02f, 1.01382159e-01f, 4.60630283e-02f, 7.65711665e-02f, -8.71090367e-02f, -1.91501617e-01f, -4.30821329e-02f, -3.21414992e-02f, -4.85029072e-02f, 7.23844543e-02f,
  7.95705318e-02f, -9.00306627e-02f, 1.07725814e-01f, 1.31707683e-01f, 7.63328150e-02f, 7.60653913e-02f, -1.29929476e-03f, -1.29442662e-01f, -4.06352952e-02f, 1.90427244e-01f,
  1.34608552e-01f, 2.30779245e-01f, 1.20292366e-01f, 1.36040285e-01f, 1.17849886e-01f, 5.78523055e-02f, 5.30291907e-02f, 8.48140046e-02f, -8.71540457e-02f, -4.74822670e-02f,
  4.78754472e-03f, 1.95771322e-01f, 5.19465208e-02f, 3.60818878e-02f, 9.98711661e-02f, 2.15572678e-02f, -6.22237241e-03f, -2.95068957e-02f, -5.70512041e-02f, -7.04898164e-02f,
  1.05420956e-02f, 1.46222673e-02f, 1.11403596e-02f, 1.01516442e-02f, -2.43263599e-02f, -2.61601973e-02f, -7.23185092e-02f, -8.61812085e-02f, -8.25483575e-02f, 8.89459476e-02f,
  4.01601531e-02f, 1.80094671e-02f, -6.37470484e-02f, -2.85656992e-02f, -6.47293478e-02f, 4.77696136e-02f, 6.19462645e-03f, -1.27328490e-03f, 5.03938310e-02f, -3.32649425e-02f,
  1.05593875e-01f, -4.17246334e-02f, 3.86178121e-02f, -1.10705495e-02f, -1.17646111e-02f, -5.08285686e-02f, -8.27106088e-02f, -3.45429555e-02f, 1.74532533e-02f, 2.84572039e-02f,
  -8.89336541e-02f, 2.19720453e-02f, 1.11165494e-02f, 1.23699075e-02f, 6.09603301e-02f, -2.28989366e-02f, -1.04895100e-01f, -3.12107652e-02f, 2.88058314e-02f, -4.54742275e-02f,
  -5.89766875e-02f, 6.55360073e-02f, -8.23406037e-03f, -3.08506675e-02f, -4.28793132e-02f, -4.89058346e-02f, 9.02696792e-03f, 6.84366375e-02f, -7.20200911e-02f, -1.61831789e-02f,
  3.51710953e-02f, 2.22703665e-01f, 6.13279119e-02f, 1.29326181e-02f, 4.34508286e-02f, 1.11371674e-01f, 1.27966583e-01f, 5.10843992e-02f, 1.98244844e-02f, 2.47503035e-02f,
  -6.22671144e-03f, -1.28202885e-01f, -2.73875613e-02f, 3.72737274e-02f, -8.27904418e-02f, 1.73269417e-02f, -3.36895324e-02f, -1.29501790e-01f, 1.34334099e-02f, -9.06344038e-03f,
  -6.89678825e-03f, 7.20840320e-03f, -6.93939179e-02f, -8.47021118e-02f, -1.15696423e-01f, -3.54337245e-02f, -3.38315181e-02f, 3.47424746e-02f, 9.70224068e-02f, -4.96161059e-02f,
  1.53569639e-01f, -1.85335428e-01f, 3.05215806e-01f, -9.71478671e-02f, 4.44618389e-02f, 1.37112647e-01f, 1.42091379e-01f, 1.16800606e-01f, 1.31153956e-01f, -2.64768809e-01f,
  -1.95874915e-01f, -1.43940777e-01f, 3.30387019e-02f, -2.20944092e-01f, 4.17767406e-01f, 1.41764939e-01f, 2.86940560e-02f, -1.27118394e-01f, 1.55674368e-02f, -1.32827967e-01f,
  1.50812333e-02f, -2.69121170e-01f, 1.66832030e-01f, -3.06640834e-01f, -7.99819306e-02f, -1.15160920e-01f, -1.03342347e-01f, 8.59634727e-02f, -2.43435368e-01f, 7.28066340e-02f,
  -6.69342577e-02f, 6.32186932e-03f, -9.53635126e-02f, -7.60183185e-02f, -3.92704159e-02f, 3.35523970e-02f, 1.24099432e-02f, 1.51550740e-01f, 7.77841285e-02f, -2.49324404e-02f,
  1.50896348e-02f, 1.72080565e-02f, -1.47781730e-01f, -4.30710986e-02f, 6.61959425e-02f, 1.64385438e-02f, 9.80645195e-02f, 8.53461549e-02f, -1.66371278e-03f, 1.70857757e-01f,
  5.44737130e-02f, 1.86301433e-02f, -2.05164105e-02f, -4.52137589e-02f, 7.53132179e-02f, 5.00380434e-02f, -3.06437984e-02f, 8.84895697e-02f, -3.95048708e-02f, 1.82516815e-03f,
  -2.11826917e-02f, 9.36542302e-02f, 3.35406475e-02f, 3.89196649e-02f, -5.47414310e-02f, -3.35739888e-02f, -4.24323790e-02f, -1.65792972e-01f, 1.20856222e-02f, -5.19413911e-02f,
  -6.19789213e-02f, 1.33588791e-01f, 9.32600424e-02f, 7.37829655e-02f, -3.32753249e-02f, -2.22014431e-02f, -1.11813629e-02f, -1.33728078e-02f, 8.06559771e-02f, 1.43171428e-03f,
  -9.56168845e-02f, -5.83099835e-02f, -2.93040667e-02f, 4.34026867e-03f, 7.10474700e-02f, -1.14034554e-02f, -9.06020328e-02f, 5.50532416e-02f, -6.17115945e-02f, 3.67468372e-02f,
  -2.07687676e-01f, -2.32867360e-01f, -3.86580825e-02f, -1.30742714e-01f, -9.26362574e-02f, -3.82619835e-02f, -9.86579657e-02f, 2.09036749e-03f, -5.73562346e-02f, -3.11517753e-02f,
  6.45587891e-02f, -9.61246118e-02f, 4.10001278e-02f, -1.80813130e-02f, 2.73803491e-02f, -3.64988782e-02f, 7.04106614e-02f, -1.20914467e-02f, -2.66773198e-02f, -3.86584327e-02f,
  -8.39570314e-02f, -5.89353815e-02f, -6.52546436e-02f, -6.43290579e-02f, 1.00561325e-03f, 6.46535978e-02f, -1.27548024e-01f, -5.26405089e-02f, 5.60592152e-02f, -7.53991678e-02f,
  7.03344196e-02f, -1.64689034e-01f, -6.27979115e-02f, 1.03696853e-01f, 1.44753739e-01f, -1.39646515e-01f, -3.06203842e-01f, 1.03964090e-01f, -6.75538257e-02f, -7.75879920e-02f,
  1.45633787e-01f, -1.14449427e-01f, -2.13738441e-01f, 2.87276417e-01f, 2.95938700e-01f, -8.02624896e-02f, 2.43319795e-01f, 4.59340699e-02f, -9.73923579e-02f, 9.87254083e-02f,
  2.02902347e-01f, 2.74058402e-01f, 1.04560502e-01f, 1.90013528e-01f, 9.37871933e-02f, 3.86618963e-03f, 1.94342494e-01f, -1.04189917e-01f, 1.91000059e-01f, 9.22314264e-03f,
  -6.53089583e-02f, 1.00317501e-01f, 1.68910529e-02f, -9.27819032e-03f, 7.26685151e-02f, -1.24230282e-02f, -2.31426395e-02f, 5.91815077e-02f, -2.82155437e-04f, -6.09937608e-02f,
  -2.46742414e-03f, 1.06229268e-01f, 3.06508467e-02f, 1.14980809e-01f, -1.84681639e-02f, 4.25852947e-02f, -3.54560465e-02f, -1.22994054e-02f, 1.14129856e-04f, -5.73341362e-02f,
  -2.78009418e-02f, 2.26562750e-02f, -1.85586102e-02f, -5.93365505e-02f, -4.57258634e-02f, -9.81335808e-03f, -4.77317348e-02f, -4.00486588e-02f, 2.50244010e-02f, 3.41585912e-02f,
  8.03565830e-02f, -9.75333601e-02f, -5.63326403e-02f, -5.39620258e-02f, -6.87604696e-02f, -3.77416648e-02f, 2.66068634e-02f, -1.80975460e-02f, -1.55449472e-02f, -6.41516468e-04f,
  1.96479633e-02f, 6.12793118e-02f, 4.95655760e-02f, 8.64706486e-02f, -3.58420401e-03f, 6.21207571e-03f, 3.34534235e-02f, 6.21488038e-03f, -7.43209273e-02f, 5.67411352e-03f,
  -1.51472837e-02f, 6.42541498e-02f, -9.51180533e-02f, 1.82240084e-03f, -4.48836479e-03f, -3.41222547e-02f, 4.59866114e-02f, -1.38187711e-03f, -5.18105961e-02f, -7.47288752e-04f,
  8.25198814e-02f, 9.87896845e-02f, -8.32747892e-02f, 2.06038766e-02f, -2.47990303e-02f, 1.32762939e-01f, 6.89841583e-02f, 9.03722420e-02f, -1.95470750e-02f, 4.62193191e-02f,
  8.92563611e-02f, 4.78723180e-03f, 3.09024705e-03f, 9.55372006e-02f, 7.47201219e-02f, -4.71691787e-03f, -1.43511058e-03f, 2.92932894e-02f, 8.12858567e-02f, 3.21780816e-02f,
  4.83156890e-02f, -1.55695472e-02f, -4.84380089e-02f, -7.30860457e-02f, 1.13480091e-02f, -6.75412565e-02f, -2.44044103e-02f, 2.08403543e-02f, 6.30966872e-02f, 4.36144173e-02f,
  5.82121730e-01f, -2.44999275e-01f, 1.82676405e-01f, 3.14921856e-01f, 5.57092810e-03f, -2.74562329e-01f, 1.32852495e-01f, -1.84331164e-01f, 1.15186706e-01f, -3.68544638e-01f,
  -2.06418782e-02f, 3.56994160e-02f, 1.34354964e-01f, -1.80181384e-01f, 1.13362841e-01f, 4.81598675e-02f, -2.37390429e-01f, -9.05041620e-02f, 1.00991838e-01f, -2.62114834e-02f,
  1.02241486e-01f, -3.50999564e-01f, 4.89814915e-02f, -3.93640459e-01f, -2.34021135e-02f, 9.10330191e-02f, -1.72618497e-02f, 1.18242294e-01f, -2.77771682e-01f, -1.31716877e-01f,
  -2.43816916e-02f, 9.82791260e-02f, -2.93021426e-02f, -8.65766481e-02f, 1.14417458e-02f, 5.95541410e-02f, 3.28079276e-02f, -1.04043325e-02f, 1.38306797e-01f, 1.16112754e-01f,
  -3.29806805e-02f, -7.56672844e-02f, -7.61654824e-02f, -5.38245915e-03f, 1.50304854e-01f, 4.92505170e-02f, 5.40577099e-02f, -4.99933250e-02f, -4.68774661e-02f, 1.02332182e-01f,
  1.01006843e-01f, 9.75169167e-02f, 1.15509890e-01f, -6.70039058e-02f, 1.11690417e-01f, -1.78314783e-02f, -4.05813828e-02f, 7.21588433e-02f, 5.81815802e-02f, 2.27577277e-02f,
  1.61338190e-03f, -3.73265073e-02f, 5.64548969e-02f, -7.10190088e-03f, 1.85704343e-02f, 6.28311262e-02f, 5.73086226e-03f, 7.13019446e-03f, 5.67741096e-02f, -3.44212912e-02f,
  -7.09559396e-03f, 4.16409150e-02f, -5.06561548e-02f, 2.40731263e-03f, -2.33040247e-02f, 2.79682397e-04f, 5.02847955e-02f, -6.36699870e-02f, 2.92423908e-02f, 4.73595783e-02f,
  6.36930093e-02f, -1.91899296e-02f, 7.27933040e-03f, -1.65537335e-02f, 1.05416952e-02f, -2.21017040e-02f, -1.45012617e-01f, 4.45067957e-02f, -2.78657023e-02f, 1.81187205e-02f,
  -2.14605585e-01f, -3.25057268e-01f, -3.69211398e-02f, -4.93270345e-02f, -3.68557610e-02f, 1.26037495e-02f, -8.42306763e-02f, -1.21686302e-01f, -5.58480471e-02f, -4.05253749e-03f,
  -1.07117094e-01f, 3.77211310e-02f, 5.65811545e-02f, -7.83877820e-03f, -7.31613636e-02f, -7.50857368e-02f, -6.37919307e-02f, -6.45621642e-02f, -7.18500316e-02f, -4.57396954e-02f,
  -1.65653341e-02f, 6.40257001e-02f, -2.11859355e-03f, -3.04828081e-02f, -6.94394633e-02f, 3.80420275e-02f, -1.32076135e-02f, 2.26436881e-03f, 7.52470717e-02f, -4.92565036e-02f,
  7.30641410e-02f, 2.98444033e-01f, -1.67145785e-02f, -1.61046967e-01f, 5.09756990e-02f, -2.08630934e-01f, -4.98328470e-02f, -7.14592785e-02f, -1.27393857e-01f, 1.87331751e-01f,
  -1.08287387e-01f, 1.53220057e-01f, -3.55451889e-02f, -1.59171700e-01f, -5.11000395e-01f, -3.29806238e-01f, -2.96930552e-01f, -9.25100520e-02f, -6.02030195e-02f, 7.66308755e-02f,
  -1.05597317e-01f, -5.97194545e-02f, -2.84320801e-01f, 1.96671590e-01f, 2.23181337e-01f, 2.58581251e-01f, 1.41894994e-02f, 1.96009293e-01f, 3.77653614e-02f, 2.07588244e-02f,
  -8.16468224e-02f, 1.36886194e-01f, -8.86157993e-03f, -3.66469957e-02f, -5.98457567e-02f, 1.50176371e-02f, 1.13789858e-02f, -1.19399875e-01f, -1.44177750e-02f, -6.74357787e-02f,
  -6.98093884e-03f, -6.92642061e-03f, 3.13177481e-02f, 4.16310094e-02f, 1.31993592e-01f, 4.30455692e-02f, -5.45609780e-02f, -3.59548591e-02f, 3.34766274e-03f, 2.55202334e-02f,
  3.98789626e-03f, -4.25034463e-02f, 2.57816091e-02f, 6.97884150e-03f, -6.47729859e-02f, 2.90010963e-02f, -1.66570023e-02f, 1.36534553e-02f, 8.17757174e-02f, -4.92058136e-02f,
  6.46246150e-02f, 2.18136441e-02f, 3.34082954e-02f, 1.39343683e-02f, -5.04621454e-02f, -7.38953277e-02f, -1.25296274e-03f, -1.01893498e-02f, 4.02804427e-02f, -4.32935776e-03f,
  -2.25169156e-02f, 1.69245135e-02f, 5.54794306e-03f, -5.35594821e-02f, -4.59812619e-02f, -4.68808599e-03f, -5.01704440e-02f, 8.91939458e-03f, -5.06875403e-02f, -4.14825864e-02f,
  -1.43286055e-02f, -1.12034203e-02f, 3.76857491e-03f, 7.76956007e-02f, -7.49015808e-02f, -3.54309268e-02f, -1.13557912e-02f, -2.16348097e-02f, -8.81109908e-02f, -1.15877707e-02f,
  -1.25186771e-01f, -3.04927267e-02f, -1.74873397e-02f, 8.62951800e-02f, 2.99506839e-02f, -1.13959173e-02f, 1.07974764e-02f, -5.87372258e-02f, -4.24200334e-02f, 5.33214435e-02f,
  -1.41214440e-02f, 6.56505004e-02f, -2.61293538e-02f, 7.26688951e-02f, -9.86521393e-02f, -7.98908845e-02f, -8.58325511e-03f, -1.25852674e-02f, -1.28148934e-02f, -2.02001259e-02f,
  6.91820756e-02f, 9.68811586e-02f, -1.19009160e-01f, 1.41750975e-02f, -4.42995280e-02f, -3.18849683e-02f, 7.28354901e-02f, 3.57132368e-02f, 2.89588962e-02f, -4.89699915e-02f,
  -2.87357774e-02f, 2.37555116e-01f, -1.43147513e-01f, 8.76824483e-02f, 1.40359253e-01f, 4.66772199e-01f, 3.47547829e-01f, 2.52452463e-01f, 3.38711083e-01f, 2.19024733e-01f,
  1.05036482e-01f, -7.15880543e-02f, -1.79449953e-02f, 2.21357673e-01f, 1.75447576e-02f, 2.49423921e-01f, 2.67282635e-01f, 1.49586260e-01f, 1.15027592e-01f, -6.30841553e-02f,
  7.68461451e-02f, 2.18452141e-01f, -1.93709075e-01f, -3.34759876e-02f, 5.25737852e-02f, -1.56034410e-01f, -2.45880887e-01f, -1.67921618e-01f, -9.58103612e-02f, 1.21894956e-01f,
  1.14017278e-01f, 1.10846676e-01f, -1.24358490e-01f, -9.95307490e-02f, -9.36066061e-02f, -7.02246353e-02f, -8.19704235e-02f, -4.50485200e-02f, -1.27281159e-01f, -7.25936741e-02f,
  -3.51879857e-02f, 1.02051310e-02f, 3.98221686e-02f, -5.05201668e-02f, -1.87088810e-02f, -1.88908875e-02f, -5.93601950e-02f, 7.02182204e-02f, -1.74252167e-02f, 6.11807853e-02f,
  2.08485220e-03f, 2.66247019e-02f, 5.10867126e-02f, 1.28178895e-01f, 9.73413885e-02f, 9.20425653e-02f, 9.31723416e-02f, 1.10184681e-02f, 6.62805978e-03f, 7.52272233e-02f,
  -6.44950941e-03f, 3.63684930e-02f, 1.17091350e-01f, 3.17160338e-02f, -4.99867611e-02f, -3.36728618e-02f, -6.71871826e-02f, -9.33205411e-02f, 7.72601143e-02f, -1.69072337e-02f,
  -2.72115804e-02f, -5.95058547e-04f, 4.23719734e-02f, -1.59494709e-02f, 4.41708602e-02f, 1.25189096e-01f, 2.30617146e-03f, -5.58632426e-02f, -8.74840713e-04f, -5.79219162e-02f,
  -6.68374598e-02f, -1.16295824e-02f, 3.42930742e-02f, -1.47010442e-02f, -1.14174940e-01f, -1.03161400e-02f, 3.72643135e-02f, -2.39482964e-03f, -8.85245800e-02f, -3.33251059e-02f,
  1.91867009e-01f, 2.74544746e-01f, 6.15378562e-03f, -2.34149583e-03f, -1.72585383e-01f, 1.99806094e-02f, 3.79055850e-02f, 5.18775918e-02f, 2.13850643e-02f, 1.70294628e-01f,
  2.42746249e-02f, 5.08823022e-02f, -6.60945177e-02f, -3.51096727e-02f, -9.87731889e-02f, 2.29391530e-01f, -9.73520502e-02f, 4.87421118e-02f, -1.34282680e-02f, -1.28692403e-01f,
  -1.10998154e-01f, 1.00407943e-01f, -4.97521348e-02f, 1.17366321e-01f, 7.85622969e-02f, -2.14509349e-02f, 1.02320828e-01f, 2.42638122e-03f, 3.20631228e-02f, 5.61771058e-02f,
  3.55225010e-03f, 2.71357540e-02f, -7.52972439e-02f, 1.11220710e-01f, -5.45587298e-03f, 3.17142308e-01f, 3.44521195e-01f, 7.97740147e-02f, 2.53400266e-01f, 1.66328385e-01f,
  2.70969197e-02f, 1.24884889e-01f, -5.69061190e-03f, 1.79260343e-01f, 2.88554460e-01f, 3.04862447e-02f, 1.74867034e-01f, 1.61097080e-01f, 6.58532754e-02f, 8.76205564e-02f,
  4.70024757e-02f, 1.27977476e-01f, -1.67286351e-01f, -7.93725774e-02f, -6.87925220e-02f, -1.34506032e-01f, -1.16094239e-01f, -7.25783110e-02f, -9.27966088e-02f, 1.15263388e-01f,
  -3.31133306e-02f, -2.17413530e-02f, -1.20518997e-01f, -5.79713359e-02f, -8.89974162e-02f, -5.64803816e-02f, -3.07305250e-02f, 2.61343159e-02f, -6.08818606e-02f, 2.88199857e-02f,
  7.26429094e-03f, 1.85960792e-02f, 1.82323437e-02f, 2.13541035e-02f, 1.12655032e-02f, 8.81678611e-03f, -1.10928528e-01f, -2.00675111e-02f, -4.28501703e-02f, -1.03843184e-02f,
  -1.50320102e-02f, -3.86802144e-02f, 7.18998984e-02f, 1.13507979e-01f, 7.79688032e-03f, 5.16924113e-02f, 8.82445872e-02f, 2.69770660e-02f, 7.05933943e-03f, 7.31527284e-02f,
  5.74413165e-02f, 5.33096045e-02f, -5.15956916e-02f, -4.38392758e-02f, -7.69198686e-02f, -1.11621700e-01f, 5.03281057e-02f, -1.50783127e-02f, -5.07655460e-03f, -6.38774112e-02f,
  -6.68779835e-02f, -2.32328419e-02f, -5.81550933e-02f, 2.43527386e-02f, 2.86071263e-02f, 1.57053433e-02f, -4.35983837e-02f, -5.59592210e-02f, -4.92289960e-02f, -7.52534531e-03f,
  -3.80781181e-02f, 2.98053771e-02f, -1.35336965e-01f, -8.88780504e-02f, 1.52938198e-02f, 2.63611954e-02f, 1.01564517e-02f, -2.05381885e-02f, -8.19227397e-02f, 9.96438507e-03f,
  7.04305694e-02f, 2.16537386e-01f, -1.50625836e-02f, -6.11245856e-02f, -6.23222440e-02f, 9.26694945e-02f, 9.14364457e-02f, -2.01026574e-02f, -2.08084099e-02f, 4.00477573e-02f,
  -3.08692213e-02f, 4.20499779e-03f, 2.22051749e-03f, 1.22417603e-02f, -2.95317546e-03f, 1.11947946e-01f, -1.60055328e-02f, 8.37670639e-03f, 4.15668301e-02f, -6.44217059e-02f,
  -1.18004054e-01f, 9.47529674e-02f, -7.60669708e-02f, 1.77206621e-02f, -2.96272524e-02f, -9.67035741e-02f, 1.24122292e-01f, -2.11141035e-02f, -3.08340155e-02f, 4.56961505e-02f,
  9.15946290e-02f, 1.15404464e-01f, 2.54673779e-01f, -1.13519393e-01f, -7.29191005e-02f, 6.90250695e-02f, -1.10944055e-01f, 1.56301409e-01f, 2.72794455e-01f, 5.55005856e-02f,
  -1.22297235e-01f, 8.48280489e-02f, -7.99776427e-03f, -9.47920084e-02f, 8.23958665e-02f, 8.58197585e-02f, -4.12714221e-02f, -4.15151417e-02f, 4.16136980e-02f, -3.42980325e-02f,
  -1.36459256e-02f, -2.58337080e-01f, -3.56144495e-02f, -1.88451648e-01f, -1.56120166e-01f, -5.33495992e-02f, -2.91841805e-01f, -1.41537502e-01f, -7.96888396e-02f, 3.19747180e-02f,
  -1.75717641e-02f, -4.89371121e-02f, 2.30896175e-02f, 1.04146406e-01f, -3.38634402e-02f, 6.15412891e-02f, 2.18567662e-02f, 3.95400226e-02f, -8.47862065e-02f, 8.06647837e-02f,
  1.09310478e-01f, 1.23902552e-01f, -1.53491467e-01f, 9.38222092e-03f, 1.43581361e-01f, 8.22749455e-03f, 4.00978066e-02f, 7.74865523e-02f, 6.79465309e-02f, 9.73246545e-02f,
  -1.10355364e-02f, 7.00644627e-02f, 6.75185174e-02f, 3.63557152e-02f, 9.41188261e-02f, -3.29392552e-02f, -2.58327965e-02f, -2.51185577e-02f, -2.47621979e-03f, 2.35429872e-02f,
  -6.32070005e-02f, 6.04181439e-02f, 3.27946432e-02f, 2.30162982e-02f, -6.44186735e-02f, -7.44076329e-04f, 1.25248823e-02f, -5.56165054e-02f, 6.69449195e-02f, 1.53728295e-02f,
  1.18649621e-02f, 9.10564139e-02f, 8.48180652e-02f, 2.07019150e-02f, 1.35542667e-02f, -3.21352808e-03f, 1.02036865e-02f, 6.63178787e-02f, 2.92643569e-02f, -7.21446499e-02f,
  -1.31062612e-01f, -2.50614267e-02f, -8.74221921e-02f, -1.10334449e-01f, 1.93688944e-02f, 4.78387177e-02f, 4.12491746e-02f, 8.46532136e-02f, -1.14867827e-02f, -6.18525483e-02f,
  -1.23967461e-01f, -2.20714852e-01f, 5.45921698e-02f, 9.07184407e-02f, -6.13393337e-02f, 3.08479182e-02f, -1.06223738e-02f, 4.81842235e-02f, 1.15045141e-02f, 3.46961617e-02f,
  1.21309347e-01f, 4.86290865e-02f, 7.13841394e-02f, -1.34416316e-02f, 2.24836618e-02f, -1.72173709e-03f, 2.70712599e-02f, 7.14833438e-02f, -2.96863876e-02f, -4.64055836e-02f,
  -3.47264409e-02f, -7.31199458e-02f, 7.41109019e-03f, -2.27281041e-02f, -8.71201139e-03f, -6.66845515e-02f, -1.06203906e-01f, 3.77096124e-02f, -5.21663129e-02f, -1.09162174e-01f,
  -5.36062777e-01f, 7.31186420e-02f, -1.16025425e-01f, -3.85744311e-02f, 8.50187540e-02f, 3.64269137e-01f, 1.20756857e-01f, -3.55300913e-03f, -3.15402120e-01f, 9.64543968e-02f,
  2.73146123e-01f, -3.98668349e-02f, 1.31230950e-01f, 3.52738172e-01f, 2.56153584e-01f, 1.82096168e-01f, 1.88905075e-01f, 1.71544045e-01f, 6.94135427e-02f, -9.26639214e-02f,
  2.99712032e-04f, 3.04191679e-01f, 1.22364968e-01f, 1.43226281e-01f, 2.14631096e-01f, -7.35070407e-02f, 1.54666677e-01f, -3.01763471e-02f, 2.51764119e-01f, 1.97666988e-01f,
  -8.05741102e-02f, -3.65467995e-01f, -1.93316758e-01f, -1.14205308e-01f, -5.55149699e-03f, -1.27890781e-01f, -4.07474898e-02f, 2.26397421e-02f, -4.79004458e-02f, 6.54861405e-02f,
  -1.18176796e-01f, 2.08241343e-02f, 1.06821455e-01f, -1.16090730e-01f, -1.37347981e-01f, -3.15140001e-02f, 6.31461516e-02f, -3.16334814e-02f, -1.24957729e-02f, -3.45961787e-02f,
  7.71825537e-02f, 1.46174699e-01f, 2.38653142e-02f, 5.40241599e-02f, 2.90085562e-02f, -3.91032659e-02f, -6.03904612e-02f, -2.47392878e-02f, 1.17385671e-01f, 4.95488644e-02f,
  -1.22548791e-03f, -7.64915273e-02f, 3.83934081e-02f, 8.66521150e-02f, -4.04167827e-03f, 4.45675477e-03f, 2.47658249e-02f, 1.02012061e-01f, 4.51498851e-02f, 1.28479637e-02f,
  7.28406459e-02f, -5.10044619e-02f, -8.88813213e-02f, -2.57256664e-02f, -6.11385629e-02f, -4.16262932e-02f, -3.51002775e-02f, -1.37207741e-02f, -4.49116416e-02f, 4.75605130e-02f,
  -3.58785577e-02f, -5.32710254e-02f, 7.84176693e-04f, 7.95302466e-02f, 4.86012548e-03f, -2.11725757e-02f, 2.79001910e-02f, 2.88178157e-02f, 1.06716208e-01f, 5.50805368e-02f,
  -1.00714296e-01f, -1.93656817e-01f, -8.05316940e-02f, 1.29312724e-01f, -1.02600582e-01f, -1.88042279e-02f, -4.27072681e-02f, 7.65516311e-02f, -8.22413806e-03f, 9.33022797e-03f,
  -4.63577397e-02f, 9.31480899e-03f, -5.66780046e-02f, -7.96323419e-02f, 2.31292564e-02f, -3.69342044e-02f, -1.27997145e-01f, -1.32001266e-01f, 2.68889274e-02f, 6.17966764e-02f,
  6.37928843e-02f, -2.48861918e-03f, 6.06977008e-02f, 2.86399890e-02f, -3.43038328e-02f, 7.33835772e-02f, -6.78780600e-02f, -7.20978379e-02f, 1.45837903e-01f, 4.41250987e-02f,
  1.13993362e-01f, 1.66020796e-01f, 1.44012541e-01f, 1.22459106e-01f, 6.71942309e-02f, -3.06838870e-01f, -2.78371304e-01f, 9.68787670e-02f, 1.10191457e-01f, -1.12609975e-02f,
  -1.83443248e-01f, 2.62138247e-01f, -1.27557367e-01f, -7.04570441e-03f, -4.87080254e-02f, -1.74920589e-01f, 5.91125861e-02f, 1.23346131e-02f, 9.09493119e-02f, 1.59368676e-03f,
  2.06328288e-01f, -1.16120696e-01f, 1.90883860e-01f, -6.29672408e-02f, -2.25231387e-02f, 1.26818150e-01f, 5.22778034e-02f, -1.60147436e-02f, -2.64488366e-02f, -4.59756926e-02f,
  1.18414275e-02f, -7.79275829e-03f, -1.10232467e-02f, 2.99692601e-02f, 3.11264396e-03f, -7.98489004e-02f, 5.14037833e-02f, 1.68896765e-02f, -9.82154161e-03f, 5.56649938e-02f,
  1.02655925e-01f, 5.48824482e-02f, -3.69934775e-02f, -2.01636183e-04f, 4.86795455e-02f, 4.03929166e-02f, 8.46623555e-02f, 1.46290595e-02f, -3.26075554e-02f, 4.20318134e-02f,
  1.23796333e-02f, 4.34988774e-02f, -2.96736471e-02f, -2.12299265e-02f, 6.80872202e-02f, -4.25702110e-02f, -6.89136684e-02f, 3.24824713e-02f, -3.68367173e-02f, 3.78060751e-02f,
  -4.07761708e-02f, -5.52061163e-02f, -3.02999374e-02f, 4.34834994e-02f, -1.20813124e-01f, 2.83620972e-03f, 3.15250531e-02f, -3.93646918e-02f, 1.53684868e-02f, -4.97298874e-02f,
  3.61849293e-02f, 4.78031747e-02f, -1.96168292e-02f, -5.61267845e-02f, 7.10635493e-03f, 6.47419095e-02f, 2.28716955e-02f, -3.15892771e-02f, -3.48488800e-02f, 3.07392981e-02f,
  -2.82636974e-02f, -9.25070234e-03f, 5.55058047e-02f, 3.53605635e-02f, -9.61194094e-03f, 2.63062343e-02f, -5.20285442e-02f, 8.53058510e-03f, 1.00051180e-01f, -5.75799532e-02f,
  6.47282414e-03f, -1.34531766e-01f, -7.82798305e-02f, 8.90581533e-02f, -6.12095855e-02f, 7.12253228e-02f, -1.46560678e-02f, 1.54659346e-01f, -6.05317578e-02f, -9.85565931e-02f,
  1.14750907e-01f, 1.50087969e-02f, 1.98350661e-02f, 1.38174333e-02f, 1.69151537e-02f, 3.27944830e-02f, 5.13293743e-02f, 5.78230247e-02f, -1.44490888e-02f, 5.87911569e-02f,
  -4.42009866e-02f, -1.01951875e-01f, -5.56747150e-03f, -8.06294233e-02f, 5.97377047e-02f, 7.72737265e-02f, -5.03152832e-02f, 3.24959657e-03f, -1.00864910e-01f, 7.96134174e-02f,
  -1.65564157e-02f, -8.93170610e-02f, -3.42224650e-02f, -1.52749479e-01f, 9.02171582e-02f, 3.57097462e-02f, -6.42565191e-02f, 3.93488668e-02f, 5.14749624e-03f, -6.18365547e-03f,
  1.44202575e-01f, -2.90827215e-01f, 4.13145311e-02f, -1.99480921e-01f, -2.34377310e-02f, -8.97508040e-02f, -1.64979741e-01f, -1.45186633e-01f, -1.06092915e-01f, -1.03427447e-01f,
  -2.18860894e-01f, -1.59908935e-01f, -9.99028087e-02f, -1.01585813e-01f, -6.20857738e-02f, -8.48911610e-03f, 9.59435254e-02f, 1.82325915e-02f, -9.87949148e-02f, -3.47061753e-02f,
  1.02303632e-01f, 9.28110108e-02f, 7.92868659e-02f, -3.27352732e-02f, 1.58653095e-01f, 9.95170325e-02f, -5.72114997e-02f, -2.89960299e-02f, 5.68363443e-02f, 4.29235883e-02f,
  -5.59744611e-02f, -1.29574731e-01f, -1.50808915e-01f, -2.33640578e-02f, 5.03999889e-02f, 2.85899304e-02f, -2.83472408e-02f, 5.43324165e-02f, -1.17893681e-01f, -6.87724277e-02f,
  -5.17031923e-03f, -1.10979043e-01f, 1.94974449e-02f, -1.01428546e-01f, -1.85195170e-02f, -2.54598837e-02f, -4.19714749e-02f, -7.65997097e-02f, 1.48709835e-02f, 9.03643146e-02f,
  -3.25305164e-02f, 7.33280480e-02f, 6.78040162e-02f, 1.25200927e-01f, 2.80348659e-02f, 1.44726649e-01f, 3.90758514e-02f, -2.58753709e-02f, 1.44985830e-02f, 5.45695052e-02f,
  4.78368588e-02f, 2.00424460e-03f, 2.32466832e-02f, -1.95718650e-02f, -5.40029816e-02f, 1.79396439e-02f, 2.53541749e-02f, -8.70193467e-02f, -3.60110030e-02f, 8.88004750e-02f,
  7.17557147e-02f, -3.40982787e-02f, -5.09564998e-03f, -1.26351684e-01f, 1.07534923e-01f, -6.81874827e-02f, -9.18439329e-02f, -7.26606557e-03f, 1.47574335e-01f, 1.01111857e-02f,
  1.19309045e-01f, -3.48776951e-03f, 9.32621509e-02f, -4.30416726e-02f, 4.59525809e-02f, 8.51330236e-02f, -1.62646063e-02f, -3.95080410e-02f, 5.94397075e-02f, -1.33292638e-02f,
  -8.55993554e-02f, 5.05698994e-02f, 4.63680997e-02f, -7.81000108e-02f, 3.94393280e-02f, 5.82356080e-02f, -3.08760125e-02f, 3.81452218e-02f, 4.48104478e-02f, 5.97006129e-03f,
  4.56515187e-03f, -7.01177716e-02f, 3.97980064e-02f, 4.21890654e-02f, -1.27903193e-01f, 2.44214982e-02f, 3.42528149e-02f, -4.14127707e-02f, -5.91541044e-02f, -7.83817172e-02f,
  -1.43605009e-01f, 1.62062734e-01f, -1.54249474e-01f, -6.03665076e-02f, 6.86266720e-02f, -1.70004129e-01f, -4.74221222e-02f, -5.54983243e-02f, 3.17833215e-01f, 1.15556955e-01f,
  -1.22524716e-01f, 1.98083922e-01f, 2.06241995e-01f, -1.84933200e-01f, -2.69109756e-01f, 1.24414358e-03f, -2.67420143e-01f, -7.72069627e-03f, 2.17136309e-01f, -9.95976478e-02f,
  -1.27382085e-01f, -2.34126598e-01f, -3.38413596e-01f, -1.13036752e-01f, -3.41703773e-01f, -4.30619903e-02f, -2.05901936e-01f, 1.84150875e-01f, -3.50060552e-01f, 1.30861774e-01f,
  -2.44815946e-01f, 1.52569532e-01f, -1.54115215e-01f, 2.21729279e-02f, -1.45910710e-01f, 2.23061442e-02f, -9.05275419e-02f, 2.48372257e-02f, 7.63262138e-02f, 3.59271504e-02f,
  1.40798455e-02f, -1.06157020e-01f, 2.20171232e-02f, 1.61844566e-01f, 8.22076350e-02f, -1.10494755e-02f, -1.78374156e-01f, -1.43671393e-01f, -6.34695962e-02f, 5.06249517e-02f,
  -2.08955690e-01f, -3.54942046e-02f, -1.84949502e-01f, -1.46593852e-02f, -1.63813770e-01f, -2.86696665e-02f, -3.22911330e-02f, -9.44098532e-02f, 4.75593843e-02f, 8.81952583e-04f,
  3.50083336e-02f, 2.29796991e-02f, 4.48474661e-02f, 4.46612015e-02f, 3.98606062e-02f, 7.91646726e-03f, -4.76470329e-02f, -7.21597224e-02f, -4.60666306e-02f, -1.74716890e-01f,
  -4.03691689e-03f, 4.52806167e-02f, 5.18872440e-02f, -7.00648949e-02f, 6.04066476e-02f, 5.02322689e-02f, 9.00313444e-03f, 7.79852942e-02f, -1.57479197e-02f, -1.53102443e-01f,
  8.98199603e-02f, 9.46415812e-02f, -1.82613283e-01f, -1.08887069e-01f, -1.23641104e-01f, -9.06253830e-02f, -8.72757286e-02f, -1.79375522e-02f, 1.83809604e-02f, 2.34230887e-02f,
  -3.26724648e-02f, 2.88746923e-01f, 6.57539219e-02f, -1.23339437e-01f, 2.61699613e-02f, 5.15165366e-03f, 1.25482485e-01f, -1.44450828e-01f, 3.62287723e-02f, 2.38123292e-04f,
  2.78145801e-02f, -7.42587671e-02f, -6.42224848e-02f, 6.39354438e-02f, 1.00634441e-01f, -1.04639009e-01f, 2.63629369e-02f, 1.30703896e-01f, -5.76775372e-02f, 1.00058854e-01f,
  -8.78463015e-02f, 8.90055150e-02f, 3.56299542e-02f, -1.46851659e-01f, -7.42325410e-02f, -1.14953853e-01f, 8.44538305e-03f, -3.19503769e-02f, -7.24282209e-03f, 6.97396602e-03f,
  2.10656479e-01f, -2.67072409e-01f, -1.37002870e-01f, -1.06176905e-01f, 9.59762558e-03f, -1.23481214e-01f, -1.46329761e-01f, -1.43282101e-01f, 1.30728722e-01f, -1.82701141e-01f,
  -6.83820024e-02f, 5.25383018e-02f, 2.46615335e-02f, -8.22360292e-02f, 2.97895044e-01f, 1.45224318e-01f, -5.56935817e-02f, -6.33252785e-02f, 1.51786447e-01f, -8.81118849e-02f,
  1.46284187e-02f, -1.43760338e-01f, -1.55661311e-02f, -2.03574777e-01f, -2.08502203e-01f, -1.78597048e-01f, -9.21059120e-03f, -1.15876703e-03f, -1.26735032e-01f, -3.75608914e-02f,
  4.22246195e-03f, 1.02928370e-01f, -7.94754177e-03f, -1.08126905e-02f, -3.14600244e-02f, 1.94126740e-02f, -9.68854316e-03f, -3.94757316e-02f, 9.46276486e-02f, 9.54738935e-05f,
  -3.40428911e-02f, -3.23381424e-02f, -1.17613629e-01f, 1.46443367e-01f, -1.06948137e-03f, 1.89866889e-02f, 5.20442165e-02f, 1.15063116e-02f, -3.21708135e-02f, 4.34884382e-03f,
  -1.26395077e-02f, 8.79198313e-03f, 1.07609376e-01f, -6.50208443e-02f, -4.87738997e-02f, -4.59319800e-02f, -5.47196902e-02f, -9.97505244e-03f, -2.56871302e-02f, 4.17524055e-02f,
  -8.61289278e-02f, 6.42183051e-02f, -5.43893781e-03f, 2.90882005e-03f, -8.06398224e-03f, -3.38251851e-02f, 5.75644709e-02f, -6.60029948e-02f, 4.95122038e-02f, 3.59930284e-02f,
  2.73734331e-02f, 1.15549956e-02f, 1.47170708e-01f, 6.59646764e-02f, -2.92619336e-02f, 4.73568849e-02f, -1.47821018e-02f, -7.60340169e-02f, 3.84061448e-02f, -1.08421057e-01f,
  5.88294864e-02f, 5.64271957e-02f, 4.42434251e-02f, -5.92714511e-02f, 1.95213445e-02f, 3.51485945e-02f, 2.26960853e-02f, 7.98946917e-02f, 3.77005003e-02f, 4.49464889e-03f,
  -4.27080467e-02f, -1.18551478e-01f, -3.41927893e-02f, -3.11490744e-02f, -5.40680438e-02f, 2.31511202e-02f, -5.30271269e-02f, -1.34441063e-01f, 4.42486294e-02f, 2.06716135e-02f,
  -6.12452552e-02f, -3.42655405e-02f, 4.29333933e-02f, 4.71356288e-02f, -1.87449027e-02f, -6.30751848e-02f, 1.97371058e-02f, 3.31465118e-02f, -6.19033650e-02f, -4.50819992e-02f,
  -5.37902638e-02f, -2.39311960e-02f, 1.18846083e-02f, -4.40785661e-02f, -1.11762322e-01f, 3.06588728e-02f, -7.48739764e-03f, -1.83551256e-02f, -1.73721872e-02f, 6.68343809e-03f,
  2.03612909e-01f, -2.34816462e-01f, -9.11060646e-02f, 1.26789436e-01f, 2.78304189e-01f, 8.81303251e-02f, 7.89137483e-02f, 1.83823004e-01f, 1.42762512e-01f, -4.98473272e-02f,
  7.69531280e-02f, -5.01435518e-01f, -2.69333631e-01f, -1.82903707e-01f, -1.16491526e-01f, -3.76977414e-01f, -1.05170555e-01f, -1.34562537e-01f, 5.08045442e-02f, 6.33553043e-02f,
  2.65109120e-03f, 4.89194468e-02f, -4.30597961e-02f, 1.79304138e-01f, 1.38060987e-01f, 1.27006993e-01f, 1.43221319e-01f, 1.07462354e-01f, 6.61171824e-02f, -1.05823070e-01f,
  4.84706694e-03f, 4.02163938e-02f, 8.07288289e-02f, 7.09382594e-02f, 1.55286729e-01f, 1.38371229e-01f, 2.64193024e-02f, -7.81473368e-02f, 6.80734590e-02f, 6.86346889e-02f,
  -1.32942870e-01f, -1.29027426e-01f, -1.58910424e-01f, 9.08888727e-02f, 1.42950222e-01f, 7.80673474e-02f, 1.30751980e-02f, 1.01322904e-01f, -9.43095535e-02f, -7.62877539e-02f,
  -5.92925809e-02f, -1.18128553e-01f, 3.81757482e-03f, -1.11961752e-01f, -1.01716593e-01f, -3.78665552e-02f, -6.81908205e-02f, -3.25243436e-02f, -3.74268144e-02f, -3.34414877e-02f,
  -3.53129138e-03f, -9.30497050e-02f, 1.62955634e-02f, -3.39322202e-02f, 5.11699617e-02f, 3.82963456e-02f, -9.63806883e-02f, -8.13476890e-02f, 8.35631788e-02f, -8.22390616e-02f,
  2.84563247e-02f, 5.63007966e-02f, 2.12818291e-02f, 1.03333019e-01f, -1.82902254e-02f, -4.60581742e-02f, 3.50261107e-02f, -6.66304827e-02f, 7.92575330e-02f, 2.31310669e-02f,
  -2.03905329e-02f, 9.98016000e-02f, 4.48657088e-02f, -1.46934800e-02f, -1.85950734e-02f, 8.53971392e-02f, 3.80285340e-03f, 1.77655034e-02f, 1.48847476e-01f, -1.09909289e-02f,
  -2.59462111e-02f, -8.95520225e-02f, 1.14962496e-01f, -5.56514226e-02f, -2.69603524e-02f, 7.54037276e-02f, 1.71041880e-02f, -9.75628570e-02f, -1.04338899e-02f, 4.76827882e-02f,
  4.05512489e-02f, 7.02571198e-02f, 1.17593613e-02f, 5.16575240e-02f, 2.17613368e-03f, 9.87654179e-02f, -1.17960095e-01f, -1.43899361e-03f, -1.92461815e-02f, -2.89417505e-02f,
  5.48620708e-02f, 5.87190762e-02f, -1.64359823e-01f, 3.19427699e-02f, -8.81704465e-02f, -1.67836770e-01f, -7.38495355e-03f, 5.08309864e-02f, -9.98065472e-02f, -9.65334401e-02f,
  4.35934901e-01f, -1.57687142e-01f, -1.18128516e-01f, 1.53967246e-01f, 1.17716655e-01f, 3.65714252e-01f, 3.02407205e-01f, -3.98883447e-02f, 1.51759908e-01f, -8.03213641e-02f,
  -1.47074476e-01f, 1.24614306e-01f, -2.41578996e-01f, 1.39716715e-01f, 4.49736029e-01f, -9.03585553e-02f, 2.85422057e-01f, 2.05925822e-01f, -6.73455298e-02f, 4.29377295e-02f,
  3.84456404e-02f, 1.86146379e-01f, -2.62879282e-01f, -1.90691557e-02f, 1.13343522e-01f, -1.29057318e-01f, -1.48621365e-01f, -8.00041035e-02f, -4.09999602e-02f, 1.42320409e-01f,
  -2.64918469e-02f, -4.84106354e-02f, -5.19601479e-02f, -7.17546418e-03f, -3.26775163e-02f, 6.94608092e-02f, 1.52831459e-02f, 1.14811569e-01f, -6.43473119e-03f, -5.02961539e-02f,
  7.08066896e-02f, 8.99452716e-02f, 3.22788320e-02f, 1.09819531e-01f, 1.37742147e-01f, 2.19318848e-02f, -1.02071259e-02f, -6.49757534e-02f, -2.30140463e-02f, 6.16741693e-03f,
  -4.98979054e-02f, -3.56592946e-02f, 1.05891041e-02f, 2.51645427e-02f, -3.44127826e-02f, 1.05590098e-01f, 5.25735877e-02f, 2.30394583e-02f, -2.37811953e-02f, 1.07852206e-01f,
  -1.86440926e-02f, -8.65451340e-03f, 2.50209253e-02f, -7.44680688e-02f, 2.01693419e-02f, -5.23781739e-02f, -3.54805123e-03f, -4.88405898e-02f, 3.29812914e-02f, -3.00457720e-02f,
  -3.33244875e-02f, 3.33885588e-02f, -1.86326019e-02f, 1.22925133e-01f, 1.43069988e-02f, 7.52176531e-03f, 7.30411261e-02f, -2.01882180e-02f, -3.45891900e-02f, -1.17149325e-02f,
  -1.56578664e-02f, 1.02806389e-01f, -1.54061243e-02f, -1.79247409e-02f, -4.69664950e-03f, -8.60383734e-03f, -4.68551107e-02f, -6.74607977e-02f, -1.84830070e-01f, -1.54416561e-02f,
  -2.52749976e-02f, -3.12469364e-03f, -1.34481683e-01f, 1.83904562e-02f, -1.22730369e-02f, 1.51555806e-01f, 1.23604760e-01f, 1.39919788e-01f, 5.11430241e-02f, 1.20011419e-01f,
  8.69826972e-02f, 3.91499791e-03f, 6.93604816e-03f, 1.66469309e-02f, 8.82435311e-03f, -2.70213559e-02f, 1.39998812e-02f, -8.37914646e-03f, 1.41494265e-02f, -9.14339647e-02f,
  -5.74972592e-02f, 5.17054200e-02f, 3.38564184e-03f, 3.60978842e-02f, -1.50972847e-02f, -2.44369823e-02f, 3.55697423e-02f, -3.25810611e-02f, -1.86310224e-02f, 1.09839840e-02f,
  -3.51423562e-01f, -4.65557314e-02f, 8.81991312e-02f, -2.58501768e-01f, -3.62206250e-01f, 1.62187621e-01f, 9.31036174e-02f, 3.93157527e-02f, 3.65155078e-02f, 1.84635475e-01f,
  -1.96252614e-01f, -4.90393415e-02f, 2.12790668e-01f, -1.42443016e-01f, 1.76969811e-01f, 3.19027901e-01f, -6.13851771e-02f, 2.26184186e-02f, -1.87309116e-01f, 7.33542815e-02f,
  -4.59391847e-02f, -1.51704326e-01f, 1.52353376e-01f, -6.63928539e-02f, -3.61477196e-01f, -2.75489807e-01f, -1.94673091e-01f, -1.60334066e-01f, -4.10471886e-01f, -1.99304312e-01f,
  -3.61799687e-01f, -2.84394175e-01f, -1.13316499e-01f, 5.05639166e-02f, -5.82717918e-02f, -2.25071125e-02f, -3.25281657e-02f, -9.60409082e-03f, -1.27664685e-01f, -4.67891656e-02f,
  4.32673879e-02f, -4.38141115e-02f, -1.52947739e-01f, 7.54182637e-02f, -8.65691304e-02f, -1.88550323e-01f, -1.63290992e-01f, 1.33623823e-03f, -1.32883549e-01f, 6.15818538e-02f,
  -4.11691777e-02f, -1.64454281e-02f, -1.60567790e-01f, -6.55239671e-02f, -1.34174213e-01f, -1.33343384e-01f, 4.85923029e-02f, -4.99143302e-02f, -1.19110696e-01f, -1.62876144e-01f,
  6.49311319e-02f, 4.90296036e-02f, -7.74190947e-02f, 1.03527479e-01f, 2.56793704e-02f, 7.33130425e-02f, 5.19903488e-02f, -2.28418801e-02f, -7.44520649e-02f, -7.53301606e-02f,
  -7.12584183e-02f, 3.75127755e-02f, -4.59475294e-02f, 1.61932468e-01f, -6.36056485e-03f, 7.85381198e-02f, -3.06185731e-03f, -1.47924662e-01f, 1.55969523e-02f, -7.56142959e-02f,
  -7.22401738e-02f, 4.73611504e-02f, -2.60761380e-02f, 5.30824959e-02f, 7.47026429e-02f, 1.96959870e-03f, -9.41569880e-02f, 8.82050917e-02f, -4.54202294e-02f, 6.06438294e-02f,
  -3.21228236e-01f, -2.04111010e-01f, -1.71768833e-02f, -1.48113579e-01f, 5.05990870e-02f, -2.20967294e-03f, 1.99191049e-02f, -2.80071739e-02f, 4.00883099e-03f, 3.05831339e-02f,
  6.07018918e-02f, 5.66241257e-02f, -4.49058637e-02f, 3.28040533e-02f, 1.00305088e-01f, 5.92520684e-02f, 7.94253275e-02f, -2.24978421e-02f, -5.64395711e-02f, -8.55027139e-02f,
  -8.36598128e-02f, 5.98999597e-02f, 3.43973823e-02f, -7.14212358e-02f, 4.22494160e-03f, -7.82839283e-02f, 2.32912693e-02f, 2.86889412e-02f, -1.15480177e-01f, 2.90097911e-02f,
  6.08916115e-03f, 2.89821833e-01f, 8.94838646e-02f, 7.32592940e-02f, -5.68242483e-02f, -2.94634491e-01f, -1.70328587e-01f, 8.23606104e-02f, 2.35289559e-02f, 9.51699987e-02f,
  -1.89113989e-01f, 3.06583285e-01f, 2.78932247e-02f, -8.35336521e-02f, -1.73873007e-01f, -2.54848629e-01f, -4.50286530e-02f, -5.17663620e-02f, 1.04800232e-01f, 4.66256849e-02f,
  1.65590897e-01f, -1.23809576e-01f, 1.32743660e-02f, -6.44523948e-02f, -2.51094904e-02f, 1.98712051e-01f, 1.59091458e-01f, -1.29592139e-02f, 1.23051060e-02f, -1.28148854e-01f,
  -1.11975007e-01f, 1.44690583e-02f, 1.76783744e-02f, -7.95453414e-02f, 3.96339074e-02f, 6.66015744e-02f, 2.44787778e-03f, -6.14431985e-02f, -9.55616161e-02f, -3.20288353e-02f,
  7.11235777e-02f, -6.88544735e-02f, -3.66199426e-02f, -4.51799817e-02f, -4.18481976e-02f, -8.93169567e-02f, -8.97099450e-02f, 1.14181958e-01f, -9.55367908e-02f, 2.54907701e-02f,
  1.18601797e-02f, 2.07007788e-02f, 2.88075907e-03f, -4.17961832e-03f, -5.14716189e-03f, -6.00061417e-02f, 2.07024552e-02f, 4.13721912e-02f, 8.57053995e-02f, -4.44285497e-02f,
  4.09394540e-02f, 2.25172676e-02f, 6.32606670e-02f, 5.28263487e-02f, -1.18685327e-01f, 4.30593127e-03f, -5.02746291e-02f, -3.02598290e-02f, 7.57346582e-03f, -6.63584992e-02f,
  -3.95601839e-02f, -1.20889498e-02f, -1.00677602e-01f, -2.38318071e-02f, 3.17150317e-02f, 1.16757080e-01f, -3.82150859e-02f, -4.39974405e-02f, 4.92005572e-02f, 5.41012026e-02f,
  -4.12147641e-02f, -1.40450411e-02f, -2.33121179e-02f, -9.22538899e-03f, -5.38184606e-02f, 3.05526461e-02f, 4.94943969e-02f, -4.12429534e-02f, 6.25455333e-03f, 6.85651004e-02f,
  -4.21272358e-03f, 1.89513072e-01f, 3.41268517e-02f, -2.74901036e-02f, 2.58910172e-02f, 1.19703211e-01f, -4.52327058e-02f, -4.15758975e-03f, -3.59203182e-02f, -4.50924709e-02f,
  1.87596341e-03f, -2.27469504e-02f, 8.83629993e-02f, -2.43432652e-02f, 5.56025356e-02f, -5.16505130e-02f, -2.85727531e-02f, 1.68402761e-01f, -2.70092767e-03f, 1.07607976e-01f,
  1.60658777e-01f, -3.53097916e-03f, -3.91186401e-03f, 2.79899109e-02f, -2.41847988e-02f, 9.57944337e-03f, 8.28652084e-02f, 1.67491082e-02f, 4.80146185e-02f, 3.49029414e-02f,
  1.38150513e-01f, 2.34470107e-02f, 1.81194823e-02f, -2.50132710e-01f, -2.25077011e-02f, 1.04231693e-01f, -3.23902696e-01f, 3.47891375e-02f, -2.74406582e-01f, -9.07243863e-02f,
  -3.10531501e-02f, -8.21854547e-02f, -2.41953999e-01f, 9.29608643e-02f, 2.12827548e-01f, -1.14276245e-01f, 1.53613076e-01f, 9.07642841e-02f, 1.87629387e-02f, 2.15828881e-01f,
  2.06334561e-01f, 1.77596807e-01f, 1.35526374e-01f, 4.09836829e-01f, 1.35543406e-01f, 1.51982829e-01f, 1.44589305e-01f, 6.13419786e-02f, 1.74063385e-01f, 1.48629323e-01f,
  -1.85288787e-02f, -6.63911179e-02f, 7.66580924e-03f, 3.28807384e-02f, 7.45037422e-02f, -2.12723836e-02f, 1.29626067e-02f, 1.04019880e-01f, -1.24183290e-01f, -9.55069363e-02f,
  3.73122022e-02f, -2.53008325e-02f, 6.27327934e-02f, 2.36665718e-02f, 1.20098284e-02f, -6.30890578e-02f, -4.26082388e-02f, -5.22229634e-02f, -7.35589340e-02f, 8.04944411e-02f,
  -9.00767893e-02f, -7.92379379e-02f, 1.17320856e-02f, 1.13408361e-02f, -4.98207323e-02f, -1.18508535e-02f, -9.12778825e-02f, -9.36980452e-03f, 2.19975784e-03f, -5.48625365e-02f,
  3.31399515e-02f, -1.23811914e-02f, 4.84969728e-02f, -8.17444175e-02f, 1.16600972e-02f, 2.45825201e-02f, 4.41030674e-02f, -4.10151901e-03f, 5.54656573e-02f, -4.91038337e-02f,
  -1.38413876e-01f, 4.02842695e-03f, -6.90542608e-02f, 5.24974102e-03f, 4.59229499e-02f, 8.11907351e-02f, 7.28637353e-02f, -3.02106868e-02f, -1.03646949e-01f, -3.00680269e-02f,
  -8.10018834e-03f, 8.60507190e-02f, -4.95876223e-02f, -6.38592914e-02f, -1.94443595e-02f, -4.03865799e-02f, -7.03287870e-02f, -5.44747524e-02f, 5.14631234e-02f, 1.00025497e-02f,
  -2.51251739e-02f, 1.57158524e-01f, -4.67473902e-02f, -2.86945365e-02f, 5.28288744e-02f, 1.64244756e-01f, 1.04110658e-01f, 1.17403433e-01f, 5.16394563e-02f, 3.35812159e-02f,
  6.54304177e-02f, -4.77698594e-02f, -2.65789740e-02f, 4.49345000e-02f, 7.65918428e-03f, 6.97848015e-03f, -8.77817720e-02f, -1.01115361e-01f, -9.67702866e-02f, 1.27483057e-02f,
  -4.38913070e-02f, -8.46205205e-02f, -7.46297911e-02f, 2.56015286e-02f, -3.69029827e-02f, -1.78424895e-01f, 3.80662084e-02f, 1.48987048e-03f, -1.13232359e-02f, -8.31003208e-03f,
  8.84490088e-02f, -1.13294916e-02f, -2.52602309e-01f, 5.22044040e-02f, -1.16963021e-01f, 2.11290851e-01f, 1.84377268e-01f, -8.76780227e-02f, -1.59161642e-01f, 1.90660551e-01f,
  2.88145959e-01f, -1.66666180e-01f, 1.40601739e-01f, 3.87475520e-01f, 1.24733839e-02f, 2.78887987e-01f, 2.98590302e-01f, 1.72902748e-01f, -1.11377221e-02f, 8.82758200e-02f,
  -1.71168838e-02f, 3.79310727e-01f, 1.09009363e-01f, 3.19817960e-02f, 1.35436133e-01f, -2.85245478e-01f, -7.80402869e-02f, -1.91388562e-01f, 1.36615261e-01f, -9.61861201e-03f,
  1.60539299e-01f, 4.75056842e-02f, 2.69810054e-02f, 4.84222397e-02f, 2.68060025e-02f, 1.22386284e-01f, -8.23923294e-03f, -2.44042072e-02f, -3.65517251e-02f, -8.69898405e-03f,
  2.40484495e-02f, -5.04971892e-02f, -1.45334946e-02f, -2.42072269e-02f, -7.91090634e-03f, -7.35550374e-02f, 7.09702224e-02f, 1.56655684e-02f, -5.78222759e-02f, 4.56877723e-02f,
  3.33354622e-02f, 2.71476954e-02f, -5.99657092e-03f, 1.55695314e-02f, -7.79833049e-02f, -5.29672578e-02f, -7.56389368e-03f, -1.06736124e-01f, -4.03550565e-02f, -5.53342141e-02f,
  -4.39540148e-02f, 4.76666205e-02f, 1.23408452e-01f, 7.57893920e-02f, 1.05947452e-02f, 6.88470900e-02f, -1.38651002e-02f, 2.16925461e-02f, -1.31979197e-01f, 4.94167879e-02f,
  4.73474674e-02f, -3.16294245e-02f, -1.62853370e-03f, 1.87965836e-02f, 1.33602098e-01f, -3.07458043e-02f, 1.63173332e-04f, 9.72407907e-02f, 4.02620807e-02f, -7.16614425e-02f,
  -1.68412942e-02f, -1.72905484e-03f, 3.49502894e-03f, 3.48047167e-02f, 1.08815931e-01f, -9.61019322e-02f, 1.00009270e-01f, 4.93336134e-02f, -5.17793186e-03f, 2.79723257e-02f,
  1.26854777e-01f, -1.67988330e-01f, 5.93710989e-02f, 4.66910340e-02f, 6.45406991e-02f, 1.45091027e-01f, 9.77291912e-03f, -6.03887215e-02f, 3.47339408e-03f, 6.19226471e-02f,
  6.42808750e-02f, -5.32471463e-02f, -2.97341868e-02f, -5.25454618e-02f, -3.32211107e-02f, -9.23795328e-02f, 3.89303900e-02f, -5.46755120e-02f, -4.27354872e-02f, -4.00380380e-02f,
  2.49738479e-03f, -1.42999096e-02f, -1.58985648e-02f, -1.78783871e-02f, 2.52241828e-02f, 1.17302276e-02f, -9.76714194e-02f, 3.56830396e-02f, -1.06610460e-02f, -2.45243944e-02f,
  -6.14204269e-04f, 2.03529596e-01f, -1.03765324e-01f, 2.49669731e-01f, -2.54633743e-02f, 6.81347549e-02f, 1.90627258e-02f, -5.76528385e-02f, -7.84288272e-02f, 2.29246885e-01f,
  -5.58585934e-02f, 1.12974271e-01f, -2.35741824e-01f, 4.53790843e-01f, 1.72013044e-01f, -1.20452739e-01f, 3.68066967e-01f, 1.61438003e-01f, -1.27891704e-01f, 1.49748847e-01f,
  4.86549959e-02f, 3.65327716e-01f, 2.06530131e-02f, 1.16553470e-01f, 1.39529616e-01f, -7.83660784e-02f, -2.00701505e-03f, -1.75914884e-01f, 3.04937690e-01f, 1.12157017e-01f,
  1.01956002e-01f, -7.45571032e-03f, -1.34027470e-02f, -6.23151148e-03f, 8.29805993e-03f, -7.25725025e-04f, 1.78336389e-02f, -4.60358225e-02f, -9.45920125e-02f, -6.07115775e-02f,
  -1.39861926e-02f, -6.83552213e-03f, 5.14739603e-02f, -2.32071802e-02f, 8.68558586e-02f, 3.37100122e-03f, -4.28718738e-02f, -4.93462682e-02f, -1.37336589e-02f, -2.43620370e-02f,
  -7.51527920e-02f, 9.54174250e-03f, -2.51855478e-02f, -1.23118702e-02f, -6.12772293e-02f, -2.98720095e-02f, 6.68132082e-02f, -6.57031760e-02f, 4.93145995e-02f, 4.74800989e-02f,
  -1.74987093e-02f, -4.92837206e-02f, -5.67613803e-02f, -2.09338516e-02f, -3.92942801e-02f, -8.56572576e-03f, 1.63106043e-02f, 4.06623557e-02f, 7.01096095e-03f, 2.46550702e-02f,
  4.94297184e-02f, 4.89110686e-02f, 1.46997273e-02f, 8.68918970e-02f, 5.71104623e-02f, -1.19458884e-03f, -8.90385658e-02f, -7.20727770e-03f, 5.22054397e-02f, -8.45532194e-02f,
  -1.10331669e-01f, 1.07006632e-01f, -3.96902673e-03f, 2.99237743e-02f, 5.63768819e-02f, -3.56507190e-02f, 6.77505285e-02f, 7.39171132e-02f, -1.03036836e-01f, 4.24892409e-04f,
  1.26197144e-01f, 8.45711678e-02f, 3.53173818e-03f, 6.30685091e-02f, 4.27326411e-02f, 1.56109542e-01f, 1.54579148e-01f, 9.83838085e-03f, -1.81622952e-02f, 1.29756629e-02f,
  7.02046007e-02f, -6.60901964e-02f, 6.79376768e-03f, 4.75149490e-02f, 8.35782662e-02f, 2.91795935e-02f, 3.30371000e-02f, -6.26095384e-02f, 2.19440684e-02f, 5.43017462e-02f,
  -1.21152047e-02f, -3.64947952e-02f, 2.49684434e-02f, -8.73218477e-02f, 1.19968010e-02f, -8.58701617e-02f, 2.47107558e-02f, 8.97910912e-03f, 1.42363608e-02f, 5.59996963e-02f,
  -9.36999097e-02f, 1.44775271e-01f, -3.61089110e-01f, -6.62896261e-02f, 1.53429195e-01f, 3.39978039e-01f, 2.44251341e-01f, 1.80402473e-02f, -1.30347043e-01f, 3.83372188e-01f,
  2.85485417e-01f, -1.37331292e-01f, 9.19244885e-02f, 2.64298201e-01f, -6.85867146e-02f, 1.57668069e-01f, 2.16642216e-01f, 2.20810160e-01f, -1.40602738e-01f, -2.60001775e-02f,
  -9.77209136e-02f, 2.11258575e-01f, -1.04716569e-01f, 7.73664042e-02f, 2.13882178e-01f, -1.32682830e-01f, 1.98320523e-01f, -1.24266163e-01f, 2.05416366e-01f, -1.67851299e-02f,
  3.90400924e-02f, -5.63414358e-02f, -8.74853283e-02f, -1.57558858e-01f, 5.03074005e-02f, -5.64720258e-02f, -9.32133123e-02f, -1.16117388e-01f, -7.51045868e-02f, -6.08419217e-02f,
  1.68004856e-02f, -1.13012902e-01f, -6.41727000e-02f, -3.53539549e-02f, -2.11596508e-02f, -7.95654021e-03f, -3.07256058e-02f, -6.35324884e-03f, -5.70168421e-02f, -6.13659015e-03f,
  -4.66792565e-03f, 1.39465211e-02f, 1.26560494e-01f, 1.92381181e-02f, 8.71044174e-02f, -3.19376625e-02f, 5.65658547e-02f, 5.51696755e-02f, 5.29352203e-02f, 3.22589166e-02f,
  6.66292459e-02f, -6.23580515e-02f, 6.64048493e-02f, -8.28602239e-02f, 5.16305231e-02f, 2.41412204e-02f, 1.56466141e-02f, -2.69043259e-03f, -3.19790915e-02f, 5.71918525e-02f,
  -6.45159259e-02f, -3.78764942e-02f, 3.40675414e-02f, 2.85347514e-02f, -1.09249629e-01f, -7.06624426e-03f, -3.21832187e-02f, -1.35880411e-01f, -1.26969054e-01f, -2.77492329e-02f,
  1.40542742e-02f, -6.09723339e-03f, -3.86348516e-02f, -4.57809567e-02f, 2.97527462e-02f, 4.58094589e-02f, 8.13272297e-02f, 3.99876647e-02f, 4.80391830e-02f, -3.82441357e-02f,
  9.75863487e-02f, -9.57532879e-03f, -1.02586441e-01f, -2.80857980e-02f, -8.50840062e-02f, 4.98847552e-02f, -3.77248004e-02f, -4.27633226e-02f, 5.63634858e-02f, 1.35093629e-01f,
  1.60884466e-02f, 3.51021700e-02f, -2.01116372e-02f, 1.86903495e-02f, -9.92842577e-03f, 7.36492053e-02f, -7.49425665e-02f, -6.59867004e-02f, 5.66562898e-02f, -5.36436997e-02f,
  3.76046859e-02f, 4.21785489e-02f, 1.57002080e-02f, 1.56330653e-02f, 5.21282516e-02f, 3.92996408e-02f, 1.74199164e-01f, -4.92724255e-02f, 1.43217817e-01f, 2.26532407e-02f,
  -3.33439380e-01f, -9.88302380e-02f, -1.54843584e-01f, -1.33894444e-01f, -3.36976722e-02f, -1.43826813e-01f, -1.14221573e-02f, -1.16106391e-01f, -8.57452974e-02f, 1.68039501e-01f,
  1.43021733e-01f, -1.19991109e-01f, 1.78318664e-01f, -1.40568644e-01f, -3.06137949e-01f, 3.75137962e-02f, -1.72620729e-01f, -2.88140271e-02f, -5.49195446e-02f, -1.88794181e-01f,
  -1.19371839e-01f, -7.54754851e-03f, -2.73423307e-02f, -5.54215983e-02f, -1.13758102e-01f, -7.28647262e-02f, 1.20866761e-01f, 8.73651132e-02f, -9.69294533e-02f, -1.06464978e-03f,
  -1.31464273e-01f, -1.16492659e-02f, -3.90753113e-02f, -4.32185084e-02f, -1.33118585e-01f, 3.71500440e-02f, -4.86583300e-02f, -2.56552268e-03f, 6.35675015e-03f, -1.06712073e-01f,
  -3.68065969e-03f, 3.02430801e-02f, -1.43664047e-01f, 2.56263185e-02f, -9.87711456e-03f, -1.17935101e-02f, -1.94532312e-02f, 3.65260593e-03f, 2.30918694e-02f, 2.03515999e-02f,
  -1.12389456e-02f, -3.73364091e-02f, 8.53910893e-02f, 9.44901556e-02f, 3.16204391e-02f, 6.15561344e-02f, 1.98594648e-02f, 6.93936795e-02f, -6.51313514e-02f, 3.83034311e-02f,
  -2.97943018e-02f, -8.95968359e-03f, -4.22290573e-03f, -1.12029456e-01f, -1.07360415e-01f, -1.87989902e-02f, -2.70613581e-02f, -1.65943727e-02f, 2.18172576e-02f, -7.27331564e-02f,
  -8.97268057e-02f, -7.07666874e-02f, -1.32227382e-02f, 8.97342488e-02f, -8.10468569e-02f, -6.56415820e-02f, -4.23577428e-02f, 5.70664108e-02f, -4.97849211e-02f, 6.34192443e-03f,
  4.81750593e-02f, -8.47573131e-02f, -8.00451785e-02f, 1.10816874e-01f, -3.15569527e-02f, 1.23316281e-01f, 8.86794701e-02f, 6.35785908e-02f, 7.69157661e-03f, 7.95523077e-02f,
  -1.04089409e-01f, -4.29176167e-02f, -2.56834373e-05f, 1.05230436e-02f, 7.15169776e-03f, 7.27018155e-03f, -6.06561825e-03f, -1.06275439e-01f, -5.88305593e-02f, -6.03732988e-02f,
  -1.09304138e-01f, -2.95635760e-02f, 2.40974389e-02f, -4.28430662e-02f, -2.25715712e-02f, -9.94165614e-03f, 6.61356896e-02f, -6.67731091e-02f, 3.43179144e-02f, -3.25731002e-02f,
  1.22610964e-01f, 2.02675611e-02f, 3.08328420e-02f, 4.58573177e-02f, 9.84304175e-02f, 9.66493487e-02f, -3.84635404e-02f, -1.43978903e-02f, 1.93894170e-02f, 9.40883439e-03f,
  1.35448933e-01f, -4.77420315e-02f, -1.47042066e-01f, -5.71133941e-02f, -2.12151736e-01f, -1.68824524e-01f, -2.43434459e-01f, -8.13551471e-02f, 1.15091346e-01f, 7.72846565e-02f,
  -1.47329018e-01f, 2.17132717e-01f, 1.18344434e-01f, -1.90035850e-01f, 9.37141553e-02f, 4.55131866e-02f, -1.62288398e-01f, -1.27546027e-01f, -9.19010272e-05f, -2.02957559e-02f,
  9.68386829e-02f, -3.01925000e-02f, -2.47508258e-01f, -5.23527041e-02f, -2.01793104e-01f, -5.52043989e-02f, -3.19982059e-02f, -1.51383236e-01f, -2.26022243e-01f, -1.38559550e-01f,
  -1.17743656e-01f, 3.29567678e-02f, -5.97014092e-02f, -1.66888535e-02f, 3.97798343e-04f, -9.63625684e-02f, -5.55039234e-02f, -1.03492253e-01f, -4.29130904e-02f, 3.12938690e-02f,
  7.08165094e-02f, 1.59892976e-01f, 6.37047440e-02f, 2.46429089e-02f, -3.32086571e-02f, 2.17158683e-02f, 3.58542465e-02f, -3.77566740e-02f, -9.88376699e-03f, -5.73857338e-04f,
  3.97447534e-02f, 3.66439708e-02f, 1.07604988e-01f, 1.68546081e-01f, 1.49750262e-01f, 2.95103490e-02f, -2.74488684e-02f, -2.47509554e-02f, 5.15279286e-02f, 1.40309647e-01f,
  -7.43504474e-03f, 4.27577868e-02f, -3.63023356e-02f, 1.46317789e-02f, 4.68203239e-02f, -6.61050379e-02f, 3.58377025e-02f, -6.68585524e-02f, 9.79434401e-02f, -4.83739525e-02f,
  -1.82117689e-02f, -6.25045598e-02f, 9.56161879e-03f, 5.74308522e-02f, -7.15694949e-02f, 1.52617395e-01f, -3.05835288e-02f, -6.53652921e-02f, -3.81253138e-02f, 4.05706279e-02f,
  -9.75720435e-02f, 1.07678259e-02f, 4.53070849e-02f, -5.43372892e-02f, -1.83080614e-01f, 1.15194820e-01f, 1.95901208e-02f, -4.07767892e-02f, -1.03290439e-01f, 7.70772845e-02f,
  1.38490023e-02f, 8.12544674e-02f, 5.62966317e-02f, -7.28630647e-03f, -4.57641669e-02f, 4.22337353e-02f, -2.59759743e-03f, 1.23057365e-02f, -1.89596303e-02f, 1.06877312e-02f,
  6.13521636e-02f, 1.01659998e-01f, 5.59502542e-02f, -2.36332677e-02f, 4.61223582e-03f, 8.75794217e-02f, 1.02634341e-01f, 9.27962810e-02f, -3.13409530e-02f, -3.06152981e-02f,
  -1.75156724e-02f, 8.38970244e-02f, 1.35374442e-01f, 1.44465074e-01f, 1.26477510e-01f, 1.29182607e-01f, -1.24721024e-02f, -2.18850542e-02f, 1.17414817e-01f, 1.49313793e-01f,
  -7.21926317e-02f, 2.62235999e-01f, 3.45217675e-01f, -5.77713829e-03f, -5.28972521e-02f, 1.52234077e-01f, -1.31462902e-01f, 1.70075938e-01f, -5.13151325e-02f, 1.07173577e-01f,
  -5.94982319e-02f, 1.54737696e-01f, -6.06636293e-02f, 3.59446891e-02f, 8.74181539e-02f, -9.78032500e-02f, 2.21269503e-02f, -9.58821997e-02f, -1.11675099e-01f, 1.61395118e-01f,
  4.89248298e-02f, -1.34295359e-01f, 2.58544125e-02f, 1.45106446e-02f, 1.47236407e-01f, 1.06913775e-01f, 5.71937999e-03f, 5.80079369e-02f, 1.03455655e-01f, -1.94609407e-02f,
  -1.11779153e-01f, -1.55279383e-01f, 5.97382486e-02f, -9.22266918e-04f, 3.40178423e-02f, -3.54742743e-02f, -2.48301011e-02f, -4.70266528e-02f, -7.99400210e-02f, -6.76010773e-02f,
  -1.14882417e-01f, -2.06551850e-02f, 9.42142978e-02f, -1.37080075e-02f, 5.68575375e-02f, 9.67911258e-02f, 1.39803797e-01f, 2.16752738e-02f, -2.09367108e-02f, 1.47189632e-01f,
  1.36054233e-01f, 1.86626762e-01f, 1.12373456e-01f, 7.33066201e-02f, 7.76540488e-02f, 6.97061568e-02f, 1.10476643e-01f, 1.35549143e-01f, 1.45749711e-02f, 1.29952297e-01f,
  -6.77055269e-02f, 3.10437120e-02f, -5.69262095e-02f, 9.67396796e-03f, 3.86888981e-02f, -3.99365537e-02f, -8.83560181e-02f, -8.48366469e-02f, 1.50742894e-02f, 8.34958255e-02f,
  -2.04172954e-02f, -8.41103378e-04f, -1.57791957e-01f, 8.48238766e-02f, -5.84067479e-02f, -6.21863715e-02f, 1.58919115e-02f, -2.90248133e-02f, 6.66096807e-02f, 4.49069403e-02f,
  -1.79209098e-01f, -4.24162438e-03f, -4.36747000e-02f, -1.09598972e-01f, -6.90645278e-02f, 3.59778516e-02f, 9.89237353e-02f, -6.30954653e-02f, -5.72024845e-03f, 4.39441726e-02f,
  1.27720535e-01f, 1.55056044e-01f, 2.71477308e-02f, -8.27088803e-02f, -1.47400811e-01f, 5.81045002e-02f, -1.27735242e-01f, 8.34582970e-02f, 7.57051706e-02f, 5.06166816e-02f,
  3.69903706e-02f, 3.98913026e-03f, 1.04184285e-01f, 5.56184500e-02f, -2.29650829e-02f, 2.01055229e-01f, 4.75229397e-02f, -5.24767004e-02f, -4.91568353e-03f, 6.36044890e-02f,
  3.19121666e-02f, 7.03861937e-02f, 6.03647381e-02f, 1.08453579e-01f, 1.01897977e-02f, -1.42224142e-02f, 1.04747199e-01f, 9.93492976e-02f, 2.35286895e-02f, 5.14243878e-02f,
  -2.06305534e-01f, 1.94237381e-01f, 2.87251383e-01f, -2.01427504e-01f, 2.88003478e-02f, 1.30525053e-01f, -2.15547875e-01f, 1.19683988e-01f, -2.10726187e-01f, 6.62733018e-02f,
  -1.91270903e-01f, -8.89836438e-03f, -1.25084072e-01f, -2.12130100e-01f, -3.58860552e-01f, -2.79977262e-01f, -1.78235829e-01f, -2.96139065e-02f, -1.68742046e-01f, -8.38931352e-02f,
  -1.66489124e-01f, -3.03760439e-01f, 8.02992657e-03f, 3.38899232e-02f, 8.80708471e-02f, 1.68273479e-01f, 6.33769184e-02f, 1.01509921e-01f, 9.67698172e-02f, -1.73407346e-01f,
  -7.17439577e-02f, -1.94780290e-01f, 5.74515611e-02f, 3.09570655e-02f, -2.06896532e-02f, 1.14320032e-01f, 1.24815464e-01f, -4.91776168e-02f, -3.30500826e-02f, 1.43579701e-02f,
  7.24031404e-02f, 7.30921607e-03f, -8.36763307e-02f, -1.12357683e-01f, 2.55474728e-02f, -2.07290128e-02f, 8.82898420e-02f, 1.54915571e-01f, 1.37843955e-02f, 4.89929579e-02f,
  3.12189180e-02f, 1.37068897e-01f, 1.36073023e-01f, -4.13504131e-02f, 4.42924201e-02f, 6.30561858e-02f, 2.58015189e-02f, -2.17357650e-02f, 1.14615753e-01f, 3.19368504e-02f,
  -2.52947547e-02f, 2.53639352e-02f, -5.05931452e-02f, -5.33840852e-03f, -7.66835585e-02f, 7.38870054e-02f, -4.87995520e-02f, -1.63190439e-02f, -2.84356344e-02f, 2.33583320e-02f,
  7.73365377e-03f, 5.07736169e-02f, -6.10506609e-02f, 5.39939255e-02f, -1.22588919e-02f, -5.87876774e-02f, 2.23287363e-02f, -1.56035635e-03f, -1.80151332e-02f, 3.31141278e-02f,
  -3.18326093e-02f, -1.24335229e-01f, -8.10743868e-02f, 6.96236491e-02f, 1.30875660e-02f, -3.94814461e-02f, 2.21507121e-02f, 1.24492142e-02f, 5.04233129e-02f, 2.86700930e-02f,
  2.53324322e-02f, -1.03294127e-01f, 1.65020227e-02f, -8.80309194e-02f, -1.14201471e-01f, -2.00168192e-02f, -9.95534286e-03f, 8.29910487e-02f, 6.91159368e-02f, -4.13896032e-02f,
  1.09590992e-01f, 1.04137316e-01f, 2.08105460e-01f, -1.10128589e-01f, -7.89973810e-02f, 4.65532728e-02f, -1.48285329e-02f, -6.69928361e-03f, 6.34718537e-02f, 2.49318853e-02f,
  5.08736297e-02f, -6.23086765e-02f, -1.19223651e-02f, -9.45452526e-02f, 8.78821239e-02f, 3.55070047e-02f, 4.48955074e-02f, -6.89630583e-02f, -5.08149946e-03f, 3.29006463e-02f,
  -9.60108265e-02f, 1.58628434e-01f, 2.66397446e-01f, 1.70286208e-01f, 2.64499664e-01f, 1.57589346e-01f, 1.79372489e-01f, 3.30240667e-01f, 5.90106189e-01f, -2.59449810e-01f,
  -2.94773936e-01f, -1.87587291e-01f, -1.21307932e-01f, 1.58310067e-02f, 1.68878864e-02f, 1.75710365e-01f, 1.12654500e-01f, 3.57455667e-03f, 3.55393618e-01f, -2.47149486e-02f,
  1.79051250e-01f, -2.09758699e-01f, -6.41193464e-02f, 2.48458162e-02f, -1.27576187e-01f, 6.84397519e-02f, -2.55792558e-01f, 2.15868130e-01f, -2.71544248e-01f, 1.23669125e-01f,
  -5.39634116e-02f, 1.68411344e-01f, -4.59487513e-02f, 1.10344065e-03f, -9.80822816e-02f, -3.20736170e-02f, 8.11136886e-02f, 8.50292761e-03f, 3.59544493e-02f, -7.40027651e-02f,
  -7.13022128e-02f, -8.81165117e-02f, -1.36737928e-01f, -1.76217426e-02f, 1.31136492e-01f, -1.13958097e-03f, -9.69002675e-03f, 1.47479832e-01f, -2.14850102e-02f, 8.55463222e-02f,
  -3.46394181e-02f, -4.10900712e-02f, 2.86109354e-02f, 1.03364035e-01f, 9.66114029e-02f, 1.87643170e-01f, 4.92230542e-02f, -4.42820601e-03f, -6.17086254e-02f, 2.85037085e-02f,
  1.15964383e-01f, 3.20128590e-01f, -7.31880143e-02f, -2.64672283e-02f, -5.44237681e-02f, -3.94820869e-02f, -1.15625821e-01f, -1.50147691e-01f, 4.37371209e-02f, -9.19360295e-02f,
  -4.15104739e-02f, 1.11645810e-01f, 1.60845712e-01f, 1.56776026e-01f, 2.70839222e-02f, 2.29281653e-03f, 1.71598345e-02f, 1.74546503e-02f, 9.81507376e-02f, -7.44801760e-02f,
  7.21987337e-02f, 6.73953518e-02f, -1.16949089e-01f, -8.88428167e-02f, 1.66413398e-03f, -3.98984216e-02f, 2.60141324e-02f, -6.99531334e-03f, -3.79682407e-02f, -7.53569677e-02f,
  9.05439556e-02f, 1.92368016e-01f, 4.85822670e-02f, -2.06473619e-01f, -4.18548919e-02f, -1.83893159e-01f, 1.10765606e-01f, 1.86029393e-02f, 1.18584029e-01f, -7.75720626e-02f,
  1.07948380e-02f, -1.69007257e-01f, -8.60034004e-02f, -6.20697252e-02f, -1.05918683e-02f, -9.10434648e-02f, 8.40756595e-02f, 1.10844679e-01f, 2.69848760e-02f, -9.24940780e-03f,
  -1.38122320e-01f, -3.80502902e-02f, -3.48123759e-02f, -4.98022772e-02f, -5.38363904e-02f, -7.24761784e-02f, -7.64863566e-02f, 9.94561166e-02f, -1.19556077e-01f, -3.91758941e-02f,
  2.13047892e-01f, 2.06376910e-01f, 1.09091371e-01f, 2.01866582e-01f, 2.15453998e-04f, 1.11965366e-01f, 1.68549672e-01f, -1.12253226e-01f, 2.38601774e-01f, 1.73607081e-01f,
  -2.57231861e-01f, 1.22762881e-01f, -2.19789326e-01f, -1.84756313e-02f, -2.99666971e-01f, -5.37239164e-02f, 1.88838005e-01f, 2.12736621e-01f, 1.25892600e-03f, 1.19852409e-01f,
  2.59134024e-02f, -2.53102314e-02f, -2.33186603e-01f, -7.28675351e-02f, 1.94569513e-01f, 1.12699196e-01f, -1.36877358e-01f, -1.26946554e-01f, -9.19868574e-02f, -6.14161752e-02f,
  -5.93797974e-02f, -9.73524600e-02f, -1.05228256e-02f, -3.49719003e-02f, 2.82736160e-02f, 1.77310575e-02f, 4.73194420e-02f, -9.57113504e-02f, -6.02581538e-02f, -7.93785229e-02f,
  1.05584472e-01f, -1.33018512e-02f, 7.45456815e-02f, -1.09762639e-01f, -4.24543582e-02f, -5.75299747e-02f, -5.65772317e-02f, 1.60357319e-02f, -2.74006613e-02f, -7.55494041e-03f,
  1.01971522e-01f, 1.40553445e-01f, 4.16548550e-02f, 1.43605977e-01f, 7.37094283e-02f, 8.49184394e-02f, 1.12806141e-01f, -2.07390338e-02f, 1.37496203e-01f, 7.56650791e-02f,
  -8.36519524e-03f, 1.40481159e-01f, -2.52461769e-02f, -9.90983397e-02f, -1.37581788e-02f, -6.07962161e-02f, -2.18584612e-02f, -1.15979709e-01f, 6.38066651e-03f, 5.94062395e-02f,
  2.23789439e-02f, -4.52497788e-02f, -2.45626364e-02f, -3.99771035e-02f, 4.90546413e-02f, 4.27069440e-02f, -1.83451742e-01f, 1.45412117e-01f, 7.67755061e-02f, -6.02618046e-02f,
  -1.24999978e-01f, 8.54425281e-02f, -4.23216298e-02f, 2.96978727e-02f, -6.41913787e-02f, -2.16600578e-02f, -3.97284552e-02f, -3.47888039e-04f, -7.21770227e-02f, -4.01746631e-02f,
  1.42328173e-01f, 1.70929238e-01f, -8.73274170e-03f, -4.81127091e-02f, -3.49686556e-02f, 4.60901931e-02f, 2.93528400e-02f, 4.73990552e-02f, -1.38838440e-02f, -2.15910990e-02f,
  9.11189914e-02f, 4.92369458e-02f, 1.04684345e-01f, -7.23295137e-02f, -3.83243635e-02f, -4.86636348e-02f, 1.13604642e-01f, -2.99910791e-02f, 5.61283268e-02f, -2.29421183e-02f,
  8.87086987e-02f, 1.42268062e-01f, 6.69316649e-02f, 7.74197504e-02f, 9.87793356e-02f, 4.80652191e-02f, 1.07733063e-01f, -2.87409741e-02f, -1.51383681e-02f, 7.26832524e-02f,
  1.34472221e-01f, -2.18241408e-01f, -3.60457629e-01f, -1.56189740e-01f, 2.71264166e-01f, 3.30485523e-01f, -8.49556997e-02f, -7.05169812e-02f, -2.96426684e-01f, 1.45956069e-01f,
  1.71980396e-01f, -1.00897722e-01f, -3.75051975e-01f, 2.25276947e-01f, 1.46775112e-01f, -2.88543880e-01f, 1.96636468e-01f, 1.22043908e-01f, -1.78583190e-01f, 7.64526278e-02f,
  1.01494521e-01f, 3.19286197e-01f, -1.43942818e-01f, 3.52971464e-01f, 1.18447438e-01f, -9.33546200e-02f, 1.46882132e-01f, -9.66042746e-03f, 3.36671799e-01f, 2.03672633e-01f,
  1.36442930e-01f, -1.10871747e-01f, -3.26025560e-02f, 6.68664649e-02f, 8.36122036e-02f, 2.09551200e-01f, 7.62555376e-02f, -1.85571983e-02f, -8.23718011e-02f, -4.19644900e-02f,
  1.16682583e-02f, -7.73635730e-02f, -1.61029510e-02f, 8.20507705e-02f, 1.07913010e-01f, -8.80558193e-02f, -1.07950464e-01f, -6.59982041e-02f, -1.60065249e-01f, -3.85640822e-02f,
  -2.14569092e-01f, -7.02572837e-02f, -3.06858048e-02f, -6.16053753e-02f, -1.13850407e-01f, -6.23898171e-02f, -1.60186272e-02f, 1.18600158e-03f, -3.17728296e-02f, 9.79856178e-02f,
  6.34976551e-02f, 1.16341002e-02f, -5.65179274e-04f, -1.17191803e-02f, -1.76251642e-02f, -3.11334934e-02f, -2.95701697e-02f, 1.39425276e-02f, -4.67598960e-02f, 4.30103540e-02f,
  -1.20160906e-02f, -4.93788570e-02f, 3.62193957e-02f, 1.06111273e-01f, 8.68715271e-02f, 1.89117040e-04f, 1.13409059e-02f, -1.35556571e-02f, -6.98198527e-02f, -5.81778996e-02f,
  -7.98550174e-02f, 7.81961754e-02f, 1.08349994e-02f, -9.58034694e-02f, -8.26357156e-02f, -1.96834747e-02f, 8.41857493e-02f, 5.27791940e-02f, 3.71029004e-02f, 9.40775499e-03f,
  -1.55610992e-02f, -7.67025873e-02f, -6.42279014e-02f, 1.37587907e-02f, -3.85899865e-03f, 2.07097426e-01f, 7.02077374e-02f, -3.02326158e-02f, 2.62434985e-02f, 4.49074320e-02f,
  6.51016906e-02f, -1.22612596e-01f, 4.88085970e-02f, 9.94198397e-02f, 1.42182000e-02f, 2.59081498e-02f, 1.31576024e-02f, 4.22096401e-02f, -2.55857389e-02f, 6.18357360e-02f,
  -1.09653652e-01f, -9.10239443e-02f, -6.79210201e-02f, -6.33322969e-02f, -3.94825526e-02f, -5.84248900e-02f, 1.11231869e-02f, 8.09126943e-02f, 3.08469348e-02f, -3.43142115e-02f,
  -7.62736425e-02f, 8.78245160e-02f, 8.97892788e-02f, -1.92894220e-01f, -2.84831338e-02f, -7.07922503e-02f, -3.11652988e-01f, 1.77751910e-02f, 1.00389913e-01f, 6.08014800e-02f,
  -1.68904841e-01f, 1.07489172e-02f, 2.25083437e-02f, -1.33946955e-01f, 1.97412118e-01f, 9.37383324e-02f, -1.34328648e-01f, -7.65324160e-02f, -1.68862492e-02f, -2.38665819e-01f,
  -1.79906581e-02f, -2.48802796e-01f, -5.72123379e-03f, -7.41782188e-02f, -1.07529745e-01f, -1.66893173e-02f, 3.64728831e-02f, -1.01599544e-01f, -1.01482049e-01f, 2.71961875e-02f,
  -7.66695589e-02f, -1.41514912e-01f, -1.78150102e-01f, 1.46644674e-02f, -3.20526809e-02f, -4.40631360e-02f, -1.15115298e-02f, -2.00238805e-02f, -8.55422616e-02f, -4.03093174e-02f,
  2.30244521e-04f, 1.73713360e-02f, -1.04480214e-01f, -6.90439939e-02f, -2.45842542e-02f, 3.85830924e-02f, 1.17583359e-02f, 1.01451330e-01f, -7.84997717e-02f, 9.39488411e-02f,
  -1.78193320e-02f, 1.03180289e-01f, 4.83401045e-02f, 4.76036333e-02f, 5.50890230e-02f, 4.16448154e-02f, 6.22503646e-02f, 4.11722139e-02f, 4.55995500e-02f, 2.44512316e-02f,
  2.63598729e-02f, 1.87973399e-02f, -2.04694644e-02f, 6.42329827e-02f, -5.39115630e-02f, 7.44321421e-02f, -4.95735183e-02f, -8.12706500e-02f, 4.65137389e-04f, 2.10116897e-02f,
  -8.88484158e-03f, -1.64231826e-02f, 4.78768945e-02f, 6.48297518e-02f, -7.39495829e-02f, 4.03813384e-02f, -5.23937680e-02f, 2.25703921e-02f, 6.65139034e-02f, 5.15065752e-02f,
  -1.02654375e-01f, -1.59622114e-02f, -5.62432371e-02f, -4.12492640e-03f, 3.88998166e-02f, 3.04842852e-02f, -7.26888841e-03f, 8.51596892e-02f, -6.79642754e-03f, 3.83040085e-02f,
  -4.79766466e-02f, -9.37826112e-02f, -5.65644689e-02f, -4.36304398e-02f, 3.09478957e-04f, 9.49775521e-03f, -6.38968647e-02f, 7.01971203e-02f, -4.23946008e-02f, -4.84284349e-02f,
  5.00615351e-02f, 1.88223843e-03f, 9.78590250e-02f, -6.37432411e-02f, 4.46996242e-02f, -1.11842025e-02f, -4.12299065e-04f, 5.84830344e-02f, -6.42195418e-02f, -7.45140528e-03f,
  4.09959368e-02f, -2.30397992e-02f, 9.80848670e-02f, 6.56346232e-02f, 3.11439503e-02f, 8.45466629e-02f, 4.76782210e-02f, -1.70808509e-02f, 4.77000102e-02f, -2.48038117e-02f,
  -3.31131041e-01f, 2.42892638e-01f, -3.59770060e-02f, 3.89653116e-01f, -2.74424255e-01f, -9.13168266e-02f, 1.63983196e-01f, 6.94761276e-02f, 2.46684887e-02f, 2.98276097e-01f,
  2.29570478e-01f, -1.39611274e-01f, 2.50011504e-01f, 4.26488489e-01f, -8.20054784e-02f, 3.08432370e-01f, 4.19051915e-01f, 1.55565232e-01f, 3.72961126e-02f, 9.13434327e-02f,
  7.71399215e-02f, 2.67919630e-01f, 2.51906097e-01f, -2.40009353e-02f, -3.14164385e-02f, -8.55362937e-02f, 1.73777550e-01f, -1.90559715e-01f, 1.84219211e-01f, -1.12450816e-01f,
  -1.44711053e-02f, 2.11478453e-02f, -4.07693870e-02f, -1.77709498e-02f, 8.98170248e-02f, -1.85152814e-02f, 5.44573879e-03f, -9.46647376e-02f, -4.91163172e-02f, 1.13057755e-01f,
  7.36550055e-03f, -4.18103188e-02f, 1.95443518e-02f, -1.49039522e-01f, -1.66999876e-01f, -5.16609065e-02f, 4.83139344e-02f, 6.09195419e-03f, 5.92142344e-02f, -6.13041446e-02f,
  -1.24837141e-02f, 3.94740840e-03f, 2.19724942e-02f, 9.32825357e-02f, -5.27194440e-02f, -1.45563893e-02f, 7.67201260e-02f, -4.82131764e-02f, -3.58091034e-02f, 8.61805305e-03f,
  -1.23636842e-01f, 4.80694771e-02f, 2.70073730e-02f, -1.23914257e-02f, 4.84611001e-03f, 5.56365140e-02f, -2.14950759e-02f, 7.01273158e-02f, -8.96697491e-02f, 1.06958807e-01f,
  4.94183674e-02f, -2.82074958e-02f, 6.66477457e-02f, -3.07752355e-03f, 1.29831061e-01f, -3.56803052e-02f, -6.55169487e-02f, 3.27444151e-02f, 9.85455662e-02f, -1.33240763e-02f,
  1.55760478e-02f, -4.06671911e-02f, 1.58507214e-03f, 3.92177179e-02f, 6.43075928e-02f, -3.32591543e-03f, 1.18169397e-01f, 8.29254836e-02f, 2.86697336e-02f, 1.53758330e-02f,
  1.50867999e-01f, 2.61676490e-01f, 5.85915372e-02f, 1.00947043e-03f, 7.21759200e-02f, -3.52241285e-02f, 1.70706827e-02f, -8.68595988e-02f, 6.99085668e-02f, 5.25600649e-02f,
  -4.91151400e-03f, -1.91769842e-02f, 1.73443668e-02f, -1.35401398e-01f, -2.25655884e-02f, 3.04966290e-02f, 2.09855303e-01f, 1.47342058e-02f, 9.17507038e-02f, 5.10034524e-02f,
  7.77055919e-02f, -2.57109962e-02f, 5.18340804e-02f, -5.31338379e-02f, 6.54099062e-02f, 6.97366446e-02f, -7.57109001e-02f, -5.00408858e-02f, -5.11497669e-02f, 7.95138851e-02f,
  -4.50833142e-01f, 2.38126348e-04f, 2.75644749e-01f, -2.89550364e-01f, 4.08506766e-02f, 2.23408267e-01f, 1.66894406e-01f, 6.65763393e-02f, -1.52680516e-01f, -1.59697145e-01f,
  2.90282834e-02f, -1.85230136e-01f, 1.65654987e-01f, -2.15975031e-01f, -2.34794542e-02f, 1.37335747e-01f, 5.74933924e-02f, 3.73981446e-02f, 3.71595435e-02f, -1.43481977e-02f,
  -9.31339338e-03f, -1.86939269e-01f, 2.60726780e-01f, -5.05313314e-02f, -3.01846247e-02f, 6.86358213e-02f, -8.69317055e-02f, 1.83259740e-01f, -1.14560783e-01f, -6.48209499e-03f,
  1.46884933e-01f, -1.55669391e-01f, 8.77155736e-02f, 1.79965168e-01f, 7.45816976e-02f, -7.64974654e-02f, 2.56645866e-02f, 1.13364451e-01f, 4.43069115e-02f, -6.79263007e-03f,
  -1.11819897e-02f, 2.45816372e-02f, -2.54223030e-02f, -7.07678646e-02f, -1.06597580e-01f, -8.36166516e-02f, 1.34802416e-01f, 6.61499286e-03f, 5.55741452e-02f, 7.22453371e-02f,
  1.24596909e-01f, 8.56231079e-02f, -2.13917047e-02f, -2.02456396e-02f, 1.06213475e-02f, 1.17445238e-01f, 4.41242419e-02f, 7.01615959e-02f, -1.63225494e-02f, -2.08477497e-01f,
  -1.51494935e-01f, 4.82686982e-02f, 5.71905486e-02f, 3.32604200e-02f, 1.10996300e-02f, 7.14796633e-02f, -3.11998650e-02f, -7.55319670e-02f, -8.04422945e-02f, 8.48300476e-03f,
  -1.15674902e-02f, -2.12474521e-02f, 6.46766350e-02f, 4.83093373e-02f, -9.75280926e-02f, -9.43498537e-02f, 1.12590238e-01f, -3.99425533e-03f, -9.03398022e-02f, 1.53682694e-01f,
  3.79006304e-02f, 5.51330298e-02f, 7.32566491e-02f, 4.75732684e-02f, 7.51252621e-02f, 1.79750770e-02f, -4.34708688e-03f, -7.62416869e-02f, 1.46872744e-01f, 1.42231656e-04f,
  7.04895183e-02f, -1.51304126e-01f, 9.66179669e-02f, 1.03437848e-01f, 3.67548540e-02f, -1.49806216e-01f, -1.00049749e-01f, 6.80624368e-03f, 1.42704900e-02f, -1.71355069e-01f,
  -3.30058835e-03f, 1.20169617e-01f, -1.21036440e-01f, -6.88519552e-02f, 1.01870477e-01f, 1.22166865e-01f, 1.04790866e-01f, 9.73221362e-02f, 6.86436445e-02f, -2.74677593e-02f,
  5.17208315e-02f, 5.09083048e-02f, -1.65086742e-02f, -1.39772017e-02f, 1.91613622e-02f, -6.62804544e-02f, -7.59331658e-02f, 4.51030321e-02f, -2.48047449e-02f, -3.07548642e-02f,
  -7.44369030e-02f, -2.56427452e-02f, 1.91495582e-01f, 1.70683369e-01f, -2.39561364e-01f, -3.26376408e-01f, -1.82724714e-01f, -1.71918020e-01f, -5.66714965e-02f, -2.75829703e-01f,
  -2.14776993e-01f, 1.57725915e-01f, -3.81109744e-01f, 1.37632579e-01f, 1.37796611e-01f, -2.53528774e-01f, 1.56193092e-01f, 8.03905576e-02f, -3.24993432e-02f, -9.48472470e-02f,
  2.88245603e-02f, -7.10941106e-02f, 7.76745901e-02f, 3.17575485e-02f, 4.30450924e-02f, 3.70245665e-01f, 2.68150926e-01f, 1.61804557e-02f, 4.96507436e-01f, 4.25299704e-02f,
  -1.11690750e-02f, -2.51735989e-02f, 3.92503990e-03f, 9.91283804e-02f, -4.62294891e-02f, -1.85053144e-02f, 1.50526419e-01f, 5.44118285e-02f, 1.52108222e-01f, -2.75809523e-02f,
  8.51270407e-02f, 1.82543874e-01f, 4.73679155e-02f, -3.05807758e-02f, -1.39643699e-02f, 1.38312519e-01f, 3.28771174e-02f, -9.46993753e-03f, 4.19261940e-02f, -6.91232830e-02f,
  -9.08029824e-02f, -4.86131385e-02f, -4.16421751e-03f, 2.40471229e-01f, 9.54673514e-02f, -1.46925421e-02f, 1.07154459e-01f, -5.73221920e-03f, 6.01633750e-02f, -2.26261914e-02f,
  -1.60547365e-02f, -2.20846087e-02f, -7.46061280e-02f, -1.34550363e-01f, -4.57864068e-02f, 3.65180112e-02f, 1.98368561e-02f, -9.46505815e-02f, 8.30017328e-02f, -6.89675361e-02f,
  5.66334948e-02f, 8.85584801e-02f, 1.66594982e-02f, -5.71359061e-02f, -1.53700024e-01f, -1.05968378e-01f, 2.18888484e-02f, 4.20157164e-02f, 5.84574491e-02f, 9.56556108e-03f,
  -6.59991577e-02f, 5.18424846e-02f, 5.74388579e-02f, 2.45562997e-02f, -1.36638463e-01f, -5.52605391e-02f, 3.94515917e-02f, -3.07531469e-02f, -1.03487052e-01f, -1.43295988e-01f,
  1.15526661e-01f, 1.06651321e-01f, 2.16866191e-02f, 5.73703013e-02f, -2.50466680e-03f, -1.24292538e-01f, -2.86871102e-03f, 1.04087792e-01f, 1.42171443e-01f, -1.15055338e-01f,
  1.33029316e-02f, 1.89101070e-01f, -4.32275608e-03f, 1.06833298e-02f, 4.61146981e-02f, 8.09587166e-02f, 6.25237226e-02f, 1.25752062e-01f, 1.28933802e-01f, -8.89527553e-04f,
  -5.67605980e-02f, -8.64307806e-02f, -6.01977184e-02f, 5.89692444e-02f, 4.56721969e-02f, 1.11779533e-02f, -9.49722379e-02f, -4.73619951e-03f, 6.39828527e-03f, 2.75839679e-02f,
  3.13962728e-01f, 3.48302238e-02f, 1.26619130e-01f, 7.26557598e-02f, 1.85450554e-01f, 2.92974710e-01f, 2.72406727e-01f, 1.84418127e-01f, 4.23112154e-01f, -4.34952974e-02f,
  6.78424397e-03f, -4.07023579e-02f, 8.15046206e-03f, 3.11269723e-02f, 2.89059281e-01f, 1.20654702e-02f, 7.36262351e-02f, -4.83372584e-02f, 1.80005446e-01f, 5.43612950e-02f,
  1.02980763e-01f, 1.89561192e-02f, -9.36964527e-02f, -4.02479507e-02f, 1.19560346e-01f, -7.61052519e-02f, -2.17501864e-01f, -5.65570444e-02f, -2.78101534e-01f, 5.47688119e-02f,
  5.29387668e-02f, 4.39481623e-02f, 5.83619401e-02f, -9.71332751e-03f, 1.03971273e-01f, -3.48542584e-03f, -8.61925632e-02f, -1.97224822e-02f, 1.12083564e-02f, 4.30967808e-02f,
  -5.70691600e-02f, -3.82376723e-02f, 5.60154319e-02f, 2.38759033e-02f, 6.45641461e-02f, 8.30274746e-02f, -3.19829881e-02f, 5.65619096e-02f, -2.65242029e-02f, -4.65958426e-03f,
  9.73643437e-02f, 4.16492485e-02f, 7.14637861e-02f, -9.62575451e-02f, 3.05963028e-02f, 1.17798580e-03f, 4.69979644e-03f, -1.83926262e-02f, -4.32884358e-02f, 1.41379729e-01f,
  2.83552296e-02f, -8.08457136e-02f, 2.00773273e-02f, -1.73719488e-02f, 2.89925095e-02f, 2.68871747e-02f, -4.25482020e-02f, -3.86212841e-02f, 8.86464044e-02f, -7.49543682e-02f,
  5.02232881e-03f, -5.99114671e-02f, -1.78309996e-02f, 4.06591110e-02f, 1.94479190e-02f, -1.58310086e-02f, -3.16944160e-02f, -3.43243666e-02f, 1.21135660e-01f, 1.37805045e-02f,
  -2.24984922e-02f, -1.89119391e-02f, 3.98388244e-02f, -3.59565578e-02f, -4.96446528e-02f, 5.76905906e-02f, -8.52771327e-02f, -4.08628024e-02f, -1.51389325e-03f, 1.06027732e-02f,
  -1.47132287e-02f, -7.16468394e-02f, -4.63959947e-03f, -6.73046485e-02f, -9.27368626e-02f, 8.28913003e-02f, -1.19844768e-02f, 6.35059550e-02f, 2.25818157e-02f, 1.46392226e-01f,
  1.51505908e-02f, -7.49527989e-03f, 3.60271148e-02f, -3.44847003e-03f, -1.26582816e-01f, 2.21935421e-01f, -1.21569104e-01f, -1.69581771e-02f, 2.13213805e-02f, -9.52326134e-02f,
  -1.35939434e-01f, 5.94808832e-02f, -2.47982243e-04f, 7.04068765e-02f, -2.08105072e-02f, -1.19643189e-01f, 3.96438278e-02f, -4.37855273e-02f, -1.99366305e-02f, 4.55603302e-02f,
  1.33208588e-01f, 1.62956327e-01f, -2.70120800e-02f, -2.21560344e-01f, -1.04427457e-01f, -1.02188401e-01f, -2.71537006e-01f, -7.52094314e-02f, -1.81029812e-01f, -5.35640307e-02f,
  -1.42894968e-01f, 6.59430586e-03f, -6.06011041e-03f, 2.10366994e-02f, 2.36606389e-01f, 1.84068769e-01f, 1.27056718e-01f, -6.57965839e-02f, 1.65044874e-01f, 9.51054990e-02f,
  1.63837150e-01f, 7.69915655e-02f, 2.32172951e-01f, 3.11711401e-01f, 2.91368589e-02f, 1.49394453e-01f, 2.11206988e-01f, -7.66313227e-04f, -3.56555730e-02f, 3.91675904e-02f,
  -3.18833962e-02f, 3.29481550e-02f, -1.02036027e-02f, -1.64701641e-02f, 7.86554366e-02f, -9.94841456e-02f, -9.76628289e-02f, -5.25133312e-02f, -1.21832855e-01f, -6.17138781e-02f,
  5.76048717e-02f, -2.73991507e-02f, 5.10271043e-02f, 1.00990608e-02f, -4.89003062e-02f, -7.98488855e-02f, 2.01514512e-02f, -6.48238435e-02f, -8.78310427e-02f, 1.27243474e-01f,
  3.50343343e-03f, -2.08627097e-02f, -1.17911026e-02f, 6.86547905e-02f, 2.18691677e-02f, 5.00972793e-02f, 2.86000054e-02f, -4.79462817e-02f, 1.18677551e-02f, -5.08396626e-02f,
  1.39023587e-01f, -9.95679572e-02f, 1.13666967e-01f, -1.03480704e-01f, 8.85834321e-02f, 3.11916638e-02f, -1.17367141e-01f, 1.15085570e-02f, 6.80025369e-02f, 2.03876533e-02f,
  -1.35571435e-01f, 6.44828472e-03f, -6.79496676e-02f, -4.31840643e-02f, 4.39071283e-02f, 6.67931810e-02f, 4.36941348e-03f, -5.77559099e-02f, -1.18069820e-01f, 1.45298345e-02f,
  -9.13412198e-02f, 6.21085055e-02f, -1.38124926e-02f, -6.75931498e-02f, -6.72568232e-02f, 2.29113027e-02f, -6.60698637e-02f, -8.54931548e-02f, 3.51346694e-02f, -5.76651394e-02f,
  1.02242585e-02f, 1.45133734e-01f, -3.08263930e-03f, -1.31244764e-01f, 4.59057353e-02f, 5.35434447e-02f, 3.07644885e-02f, 3.74932624e-02f, -5.64088188e-02f, 6.67556226e-02f,
  8.83822329e-03f, -4.36514132e-02f, -4.23427038e-02f, 4.68663499e-02f, -9.00563225e-02f, 7.52204657e-02f, -3.39744762e-02f, -7.42031783e-02f, -1.00634843e-01f, 6.78892508e-02f,
  9.51120630e-03f, 2.84806434e-02f, -1.76696349e-02f, 2.91924272e-02f, 3.13570071e-03f, -2.47191414e-02f, 4.11533974e-02f, 4.66265855e-03f, 3.69690321e-02f, -2.96805054e-02f,
  -1.35584727e-01f, -9.34829265e-02f, -1.56793728e-01f, -6.64959028e-02f, -2.76553184e-01f, -5.54688461e-02f, -1.02972291e-01f, -8.14626813e-02f, 1.24875560e-01f, 1.12972885e-01f,
  3.22544277e-02f, -6.55627698e-02f, 2.13492364e-01f, 2.06489414e-02f, 1.15043474e-02f, 4.39791739e-01f, 4.06190977e-02f, 1.64452001e-01f, 9.02428553e-02f, -2.05186158e-01f,
  -1.55400857e-01f, -1.51941672e-01f, 2.85345931e-02f, -2.65070170e-01f, -2.50635326e-01f, -2.23118842e-01f, -1.17222397e-02f, -1.75294846e-01f, -1.12550758e-01f, -1.50198266e-01f,
  4.54599150e-02f, 4.23177481e-02f, -1.10719666e-01f, -4.66776937e-02f, -4.61888351e-02f, -1.26569569e-01f, -2.76060179e-02f, -1.30774885e-01f, 1.45549355e-02f, 1.02468289e-01f,
  -1.89893469e-02f, 2.45530941e-02f, 1.10371290e-02f, -1.00387216e-01f, -1.74761653e-01f, 4.51575369e-02f, 6.42352551e-02f, 9.30390060e-02f, 1.40875978e-02f, -2.41482444e-03f,
  2.15244703e-02f, 9.02882069e-02f, 7.92291090e-02f, 1.47667602e-01f, 1.38361761e-02f, -3.52420285e-02f, 1.71032492e-02f, -8.28480795e-02f, 6.54463917e-02f, -5.84849007e-02f,
  -7.44348541e-02f, 8.74149874e-02f, 5.34547642e-02f, -1.67106520e-02f, -1.40453717e-02f, -9.66831818e-02f, -9.20709781e-03f, -4.94446047e-02f, -7.72586986e-02f, 1.79591347e-02f,
  -3.48126888e-03f, -4.88887131e-02f, 1.70971397e-02f, -4.33146954e-02f, -4.68950672e-03f, -9.30033624e-02f, -5.64943030e-02f, 9.55798328e-02f, -4.31457814e-03f, 6.22628368e-02f,
  6.14289194e-03f, -1.44329935e-01f, -5.10944240e-02f, 1.08399026e-01f, 3.62127647e-02f, -1.26441168e-02f, 3.63162011e-02f, 1.17018454e-01f, 1.21136121e-01f, -1.34838726e-02f,
  4.97529246e-02f, -6.12312146e-02f, -2.32665744e-02f, -1.21454000e-01f, 6.71360344e-02f, -1.36685446e-01f, -1.07565500e-01f, -1.03656761e-01f, 3.22830752e-02f, -3.52344941e-03f,
  -8.24878216e-02f, 3.25687975e-02f, 1.43184200e-01f, -6.91821352e-02f, -6.46824669e-03f, -1.31619433e-02f, -2.23482065e-02f, 4.00345400e-02f, 1.67887118e-02f, -4.12942395e-02f,
  4.03774865e-02f, 1.72591340e-02f, 1.13077752e-01f, 8.58205780e-02f, 5.48326038e-02f, 5.52505031e-02f, -6.70087039e-02f, -8.14972445e-02f, -2.71885432e-02f, 5.26501425e-02f,
  3.14744771e-01f, -1.81802064e-02f, -2.51972914e-01f, -1.32076681e-01f, 4.82274890e-02f, 8.45584571e-02f, -1.27743259e-01f, 1.01297289e-01f, -1.05503418e-01f, 8.91225412e-02f,
  1.00409545e-01f, 9.04359594e-02f, -1.90591380e-01f, 2.55101234e-01f, 1.14691496e-01f, -1.31545320e-01f, 1.07014336e-01f, 5.53653762e-02f, 2.88018044e-02f, 9.36007202e-02f,
  6.13274276e-02f, 3.03479075e-01f, -2.16262281e-01f, 1.43770605e-01f, 1.60088614e-01f, -7.72955641e-02f, -9.87332761e-02f, -5.41355126e-02f, 1.16124131e-01f, 1.05290920e-01f,
  4.76228260e-02f, 4.59648892e-02f, 5.44704236e-02f, 2.79654693e-02f, -6.92725852e-02f, 1.50495265e-02f, -5.03484793e-02f, -1.80171020e-02f, -2.93617435e-02f, -6.07401095e-02f,
  3.32757412e-03f, 6.71662092e-02f, -2.17081290e-02f, -9.49568953e-03f, 1.26923844e-01f, -1.07407859e-02f, -1.12361824e-02f, 2.76845098e-02f, -3.08686681e-02f, -1.57693820e-03f,
  -6.48035854e-02f, -1.03038428e-02f, 1.94538403e-02f, -5.85044734e-02f, -1.06044531e-01f, 9.72541608e-03f, -6.00464307e-02f, -6.87974095e-02f, -1.51982028e-02f, -1.53813502e-02f,
  1.76172648e-02f, -1.90980814e-03f, -3.83408624e-04f, 7.43384659e-02f, -8.29885602e-02f, -6.75146803e-02f, 1.51394352e-01f, 8.21638554e-02f, -8.37309882e-02f, 3.25457044e-02f,
  1.63237005e-02f, 3.26065607e-02f, 5.54979816e-02f, 5.20850159e-02f, 1.14781246e-01f, -2.66717207e-02f, 8.23276639e-02f, -1.93500798e-02f, -7.14839995e-02f, -3.08095589e-02f,
  2.39001215e-02f, 7.38748312e-02f, -7.51545141e-03f, 9.17622913e-03f, 8.21000636e-02f, -7.25097656e-02f, 7.73680136e-02f, 1.96339898e-02f, -8.16978961e-02f, -1.43418703e-02f,
  -2.27617025e-02f, 1.29939066e-02f, -4.69146706e-02f, 3.14196199e-02f, -4.66723777e-02f, 1.31998733e-01f, 1.24869207e-02f, 6.53209537e-02f, 8.14073309e-02f, -1.76814105e-02f,
  1.01442091e-01f, -5.54798655e-02f, -4.58783843e-02f, 1.09038502e-02f, 3.00753284e-02f, -9.97843370e-02f, 2.62857322e-03f, -1.51080146e-01f, -9.66515988e-02f, 4.65438403e-02f,
  -5.80201410e-02f, -5.42399511e-02f, -5.40806795e-04f, -1.60840720e-01f, -9.07069519e-02f, -2.34396867e-02f, -1.76115762e-02f, -2.11600885e-02f, -6.36124844e-03f, -9.26314518e-02f,
  2.56703705e-01f, 1.95409790e-01f, 9.46148932e-02f, 1.54318541e-01f, -7.60516748e-02f, 6.39880672e-02f, 1.97725743e-02f, -6.49876818e-02f, 2.34710122e-03f, 9.98266265e-02f,
  -2.19220161e-01f, 3.03003430e-01f, -3.17622215e-01f, 1.89528540e-01f, -1.19796194e-01f, -2.24161655e-01f, 9.93134305e-02f, 1.48791507e-01f, -2.15030871e-02f, 3.47322524e-02f,
  -1.12132318e-01f, -3.52902561e-02f, -6.32292330e-02f, 4.78195176e-02f, 1.69474095e-01f, 1.39334455e-01f, -1.14771776e-01f, -8.92821327e-02f, 2.47040674e-01f, 4.00266908e-02f,
  -1.26568638e-02f, -1.34643987e-02f, 9.19219553e-02f, 7.51896296e-03f, -6.85992017e-02f, 5.08225970e-02f, 5.68262301e-02f, -8.13842341e-02f, -9.49027166e-02f, 7.77487364e-03f,
  -1.62374452e-02f, -2.33534304e-03f, 8.41167644e-02f, 2.58295145e-02f, 1.33046672e-01f, 1.40402868e-01f, 3.30168642e-02f, 4.85328957e-02f, 4.40498926e-02f, 2.94690039e-02f,
  1.15151063e-01f, 7.26710707e-02f, 6.75391182e-02f, 6.25491366e-02f, 2.99495049e-02f, 8.97334814e-02f, 1.51594341e-01f, -1.31857127e-03f, 2.68974844e-02f, 1.22570954e-01f,
  -4.44326326e-02f, -4.62814309e-02f, -1.40506998e-02f, 2.51812413e-02f, -6.66766241e-02f, -6.87433928e-02f, -1.69881713e-02f, -6.65691569e-02f, 5.58545068e-02f, -2.29973458e-02f,
  -5.34600168e-02f, 3.94470021e-02f, -4.36399318e-02f, 3.19369175e-02f, -4.35797982e-02f, 7.24482983e-02f, -5.38337138e-03f, -3.19882408e-02f, -5.24853962e-03f, -7.25579262e-02f,
  -7.21531734e-02f, 1.81823149e-02f, 3.57403532e-02f, -2.21992545e-02f, -2.11689062e-02f, -9.00753308e-04f, -1.42098693e-02f, 6.34719525e-03f, -6.19474985e-02f, -9.38649178e-02f,
  -3.97155099e-02f, -1.05934694e-01f, -6.79599345e-02f, -3.96457873e-02f, -1.01119746e-02f, 4.16551791e-02f, 7.68428072e-02f, 3.38668637e-02f, 1.12966094e-02f, -8.91470071e-03f,
  -9.97464824e-03f, 4.90077510e-02f, 9.12116468e-02f, 5.29375635e-02f, -1.17004458e-02f, 1.16509972e-02f, -8.70158896e-02f, -3.57920676e-02f, -6.54246733e-02f, -5.08364700e-02f,
  -1.58052873e-02f, 1.58873349e-02f, -4.16082852e-02f, -1.56063642e-02f, 3.48047609e-03f, -6.38983622e-02f, 8.83339420e-02f, 8.75839740e-02f, -7.50336051e-02f, 6.73184469e-02f,
  -3.87255698e-01f, -9.81399789e-03f, -4.15680856e-01f, 6.37936592e-02f, 1.18890345e-01f, 1.30736977e-01f, -6.40156642e-02f, 3.05292774e-02f, -2.81294107e-01f, 2.81562299e-01f,
  2.86818773e-01f, -1.04614086e-01f, -7.47567043e-02f, 4.42406088e-01f, 5.18593267e-02f, 8.84345695e-02f, 3.15395713e-01f, 2.44400933e-01f, -7.59626031e-02f, -1.02299213e-01f,
  -3.08493134e-02f, 4.06131089e-01f, 1.21730845e-02f, 2.40293965e-01f, 1.96095780e-01f, -2.71837842e-02f, 2.34298065e-01f, -1.64409935e-01f, 3.28711331e-01f, 1.10903099e-01f,
  8.78842771e-02f, -1.86329111e-01f, -1.08632617e-01f, -1.53270036e-01f, -5.18208146e-02f, -1.07494138e-01f, -2.55751200e-02f, -5.54278567e-02f, -6.04890324e-02f, -1.43116284e-02f,
  -9.42158327e-02f, 5.12967557e-02f, 2.32849605e-02f, -1.35977253e-01f, -1.20014295e-01f, -5.43084778e-02f, 3.14940177e-02f, 3.47988419e-02f, -1.89564880e-02f, -3.48437205e-02f,
  -5.93183115e-02f, 1.25697866e-01f, 1.23959057e-01f, 9.07623619e-02f, -4.13249508e-02f, -3.61364298e-02f, 4.37516370e-04f, -1.30309155e-02f, 1.08415693e-01f, 2.20932513e-02f,
  4.20048311e-02f, -5.09417206e-02f, -1.77791733e-02f, 7.18149915e-02f, -6.93412963e-03f, 3.73979881e-02f, 1.31641403e-01f, 8.58945101e-02f, -9.63852108e-02f, 2.98590865e-02f,
  2.86106840e-02f, -4.74900007e-02f, -3.18041332e-02f, -6.74775988e-02f, -4.43120785e-02f, 4.69536372e-02f, -7.91785792e-02f, -4.25206237e-02f, -1.47321954e-01f, 6.06764071e-02f,
  3.58731560e-02f, -1.70711190e-01f, -4.73922566e-02f, 9.58443433e-02f, 1.52350694e-01f, -8.43853801e-02f, 3.46874967e-02f, -2.86188144e-02f, 4.10282388e-02f, 4.09327187e-02f,
  1.08655915e-02f, -1.75113916e-01f, -2.41403114e-02f, 9.23903286e-02f, 1.42121883e-02f, -3.44690494e-02f, -2.08399687e-02f, 1.80121120e-02f, 5.79866059e-02f, -9.16237291e-03f,
  -5.26872016e-02f, 1.05178393e-01f, -7.86675885e-02f, -9.67425257e-02f, 5.84372878e-02f, -3.17197666e-02f, -1.38223022e-01f, -6.28228635e-02f, 5.85645661e-02f, 6.23633713e-02f,
  2.13385299e-02f, 3.13152536e-03f, 9.53922719e-02f, 1.46099841e-02f, 1.19958095e-01f, 7.39246681e-02f, 6.78371415e-02f, -2.57755462e-02f, 1.76850840e-01f, 1.13479830e-02f,
  -5.82268953e-01f, 2.03652665e-01f, 2.44983181e-01f, -1.32091239e-01f, -2.59886403e-02f, -7.99008757e-02f, 2.04384446e-01f, -1.86690494e-01f, -1.12262696e-01f, 5.13910875e-02f,
  1.70090452e-01f, -1.94940381e-02f, 2.37410575e-01f, 1.94751188e-01f, -1.79198846e-01f, 2.23366708e-01f, -5.35578616e-02f, 8.35670624e-03f, -9.80047211e-02f, -1.01389848e-01f,
  -8.01178813e-02f, 2.10855547e-02f, 1.31986991e-01f, 4.15444151e-02f, 1.41452849e-01f, -1.32315189e-01f, -4.28248197e-02f, 2.12534264e-01f, -4.86225635e-02f, 1.40310168e-01f,
  -1.73128933e-01f, -1.24598496e-01f, 1.15738623e-01f, -3.03241853e-02f, -2.34801695e-02f, 1.12912217e-02f, 3.44828959e-03f, 4.33793999e-02f, 7.39492849e-02f, -1.48284748e-01f,
  2.55945101e-02f, -3.23736258e-02f, -3.98038179e-02f, 5.21010682e-02f, -7.95917138e-02f, -7.65737370e-02f, 5.31772263e-02f, -7.32033933e-03f, 5.53597920e-02f, -1.91772208e-02f,
  1.25675991e-01f, -3.13788094e-02f, -6.05575405e-02f, -4.38224897e-03f, -5.53381816e-03f, 5.03352471e-02f, -7.53711164e-03f, 9.86594800e-03f, -2.48510577e-02f, -1.20061897e-01f,
  3.64214666e-02f, -3.98165323e-02f, 5.29171899e-02f, -2.93594524e-02f, 4.32564095e-02f, -7.27202892e-02f, -3.60644162e-02f, -5.84409162e-02f, 4.27253582e-02f, -4.59636003e-02f,
  -3.74240708e-03f, -1.71526149e-01f, 5.40648513e-02f, -6.13883249e-02f, -1.40627339e-01f, 5.30876443e-02f, 3.93946916e-02f, -1.25436848e-02f, -3.21817882e-02f, -2.34163795e-02f,
  -1.52268317e-02f, 7.82778785e-02f, 1.27162309e-02f, 4.53363881e-02f, 6.18428700e-02f, 2.02742545e-03f, -6.20600358e-02f, 1.07278824e-02f, -2.21186318e-02f, -8.04549828e-02f,
  -4.94272232e-01f, -3.76702189e-01f, -1.18855499e-02f, -1.16850082e-02f, -3.95292006e-02f, -1.39222993e-02f, 5.13035059e-02f, -6.44066706e-02f, -2.72370391e-02f, 2.26690245e-04f,
  -1.06894106e-01f, -7.03506991e-02f, -6.52511492e-02f, 1.00224331e-01f, -4.48461622e-02f, -4.23377901e-02f, -6.08035773e-02f, 7.69566298e-02f, -8.40606634e-03f, -8.84967223e-02f,
  -5.45131229e-02f, 3.20777035e-04f, 1.61229875e-02f, -9.28893983e-02f, -6.46637604e-02f, 4.86840028e-03f, -6.50689453e-02f, 1.40928224e-01f, -2.70325113e-02f, 6.24280162e-02f,
  -4.92101721e-02f, 2.22868901e-02f, -9.67604574e-04f, -4.46536615e-02f, 3.04261800e-02f, -1.54326186e-02f, -9.01942998e-02f, 1.54842198e-01f, -3.00632000e-01f, 5.33085316e-02f,
  8.06588158e-02f, -1.63426459e-01f, -4.32385989e-02f, -1.72722533e-01f, -8.75330940e-02f, -1.19512014e-01f, -2.79482361e-02f, -1.24893347e-02f, -3.15499455e-02f, 2.75154531e-01f,
  5.24114035e-02f, -2.01085936e-02f, 8.47598165e-02f, 1.48040920e-01f, 6.89724609e-02f, 2.01142490e-01f, 3.23321730e-01f, 1.35031357e-01f, 1.45424888e-01f, -9.07170251e-02f,
  -9.49773863e-02f, -1.06349781e-01f, 1.85819846e-02f, -1.34404227e-01f, 1.62922561e-01f, 8.14784840e-02f, 5.04728034e-02f, -7.21111521e-02f, -2.28907429e-02f, 4.96189594e-02f,
  -2.78615542e-02f, -3.44389081e-02f, -3.66911776e-02f, 2.50447262e-02f, 1.88790131e-02f, 6.09764569e-02f, 7.13905916e-02f, -6.10361807e-02f, -2.83895582e-02f, 1.88561436e-02f,
  3.49407047e-02f, 3.04105841e-02f, -7.98344053e-03f, -1.02076277e-01f, 2.79451888e-02f, -3.34432833e-02f, -5.17486855e-02f, 1.52936563e-01f, 3.00894920e-02f, 6.46313578e-02f,
  1.50421113e-01f, -5.84798194e-02f, -3.40874083e-02f, -1.16481766e-01f, -6.00290634e-02f, -6.76731244e-02f, -1.23361140e-01f, 3.67612429e-02f, -7.86690488e-02f, -5.13452441e-02f,
  4.88255806e-02f, 1.38596538e-02f, -1.21562995e-01f, -8.37587491e-02f, -6.73928647e-04f, -1.19051293e-01f, 4.13311534e-02f, 4.35787179e-02f, 1.72975603e-02f, 7.19790757e-02f,
  -6.93430007e-02f, -1.39886029e-02f, -4.58451472e-02f, 3.23358066e-02f, -1.03727140e-01f, -4.12404537e-02f, 4.56667058e-02f, -2.35530902e-02f, 1.32014202e-02f, 1.23112127e-01f,
  7.44773597e-02f, 1.56863555e-01f, -2.03855224e-02f, -8.89750421e-02f, -3.66388485e-02f, 2.68246029e-02f, -1.49495870e-01f, 1.43398447e-02f, 3.74248736e-02f, 4.13954072e-02f,
  1.17388956e-01f, -1.22131640e-02f, 4.16553244e-02f, -6.96088076e-02f, 6.08366588e-03f, 7.41658658e-02f, 1.01285651e-02f, -9.94895771e-02f, 1.16704002e-01f, 9.35117379e-02f,
  1.48594305e-01f, 1.10079393e-01f, -9.80368331e-02f, -5.78982495e-02f, 3.60591188e-02f, -1.80499014e-02f, 1.24288514e-01f, 1.92597024e-02f, 7.20874742e-02f, 2.34540682e-02f,
  -6.54942870e-01f, 3.19263518e-01f, -7.21852928e-02f, -1.95998490e-01f, -9.24882963e-02f, 1.19037563e-02f, -5.38374716e-03f, 7.12926388e-02f, 1.07776411e-01f, 1.23034298e-01f,
  1.77284870e-02f, -2.10648760e-01f, 2.41306260e-01f, 1.27509078e-02f, -1.98388726e-01f, 3.30525815e-01f, -5.45080230e-02f, -9.57597420e-02f, 1.00550570e-01f, -4.26808931e-02f,
  -1.98420417e-02f, -1.96294188e-01f, -8.20268169e-02f, 5.83084151e-02f, -2.00067177e-01f, -6.09362312e-02f, -1.62567019e-01f, 9.53360498e-02f, -2.11520821e-01f, -2.67752390e-02f,
  -2.48565435e-01f, -1.70058563e-01f, -2.97348648e-01f, -1.13095634e-01f, -4.42848615e-02f, -4.24703434e-02f, 4.31539230e-02f, -2.96608452e-02f, -1.83402169e-02f, -1.74828584e-03f,
  6.51961416e-02f, -7.55193532e-02f, -4.05024998e-02f, 1.28312185e-01f, -7.04950839e-02f, -4.26961072e-02f, -4.21189591e-02f, -6.82315528e-02f, -2.33159382e-02f, 1.03248708e-01f,
  8.62485729e-03f, 1.34426326e-01f, -9.15002376e-02f, -1.17580920e-01f, -1.60939753e-01f, -4.19795401e-02f, 4.16743867e-02f, -1.99627802e-02f, -1.23697080e-01f, -4.66833860e-02f,
  1.06099762e-01f, -3.59108411e-02f, -1.36764109e-01f, -9.36298817e-02f, 6.25961572e-02f, 7.81078786e-02f, 7.47545138e-02f, -7.88307264e-02f, 4.90474962e-02f, 3.49918827e-02f,
  -6.60603270e-02f, 8.48758593e-03f, 9.80769545e-02f, -1.45799443e-02f, 1.10104255e-01f, -9.82355699e-03f, -1.33717284e-01f, -4.57550287e-02f, 3.38980667e-02f, -4.23490219e-02f,
  -1.16702832e-01f, 6.24898262e-02f, -5.67414574e-02f, 2.47529764e-02f, 4.43636961e-02f, 9.69572365e-03f, 2.50218660e-02f, 6.32432848e-02f, -6.93833753e-02f, -9.70616192e-02f,
  -2.72451043e-01f, -2.41553679e-01f, -9.22411308e-02f, -1.64827034e-01f, 3.66201364e-02f, -1.98217575e-02f, 4.99276668e-02f, -1.31525947e-02f, -8.62432346e-02f, -1.21541247e-02f,
  -3.71529162e-02f, -2.05848813e-02f, -5.18058613e-02f, 5.90072572e-02f, -1.25310402e-02f, 1.98144298e-02f, -9.51189771e-02f, 5.80994412e-02f, -9.34018493e-02f, -7.58177415e-02f,
  -3.72276194e-02f, 6.07940294e-02f, -1.40224304e-02f, -1.13626339e-01f, -8.71208981e-02f, -8.74168649e-02f, 5.27366623e-03f, -7.73139894e-02f, -8.52109864e-02f, 6.66548312e-02f,
  -1.33339584e-01f, 1.48707420e-01f, 2.59370595e-01f, -2.84641951e-01f, 2.16824817e-03f, 2.93983489e-01f, -1.07948832e-01f, 3.04264128e-02f, -3.55682492e-01f, -2.19847456e-01f,
  -1.58328444e-01f, -1.75874278e-01f, 4.40046825e-02f, -4.74306867e-02f, 1.75855458e-01f, 7.61142299e-02f, -2.12051719e-02f, -7.10293427e-02f, 4.54129688e-02f, -2.83813383e-02f,
  -9.08669084e-02f, -5.85597828e-02f, 2.18063459e-01f, 1.98864520e-01f, -1.91925969e-02f, -1.31539581e-02f, 6.17320463e-02f, 6.93564489e-02f, -9.32480395e-03f, 2.14287657e-02f,
  9.93789881e-02f, -5.95939942e-02f, 5.97815625e-02f, 4.14590091e-02f, 1.31608918e-01f, -2.14149695e-04f, 7.51745189e-03f, 8.13686773e-02f, -1.85289815e-01f, 6.47215359e-03f,
  -1.07169161e-02f, -3.02385986e-02f, 3.73637453e-02f, 3.15388944e-03f, -1.62065864e-01f, -5.63412830e-02f, -2.60031484e-02f, 2.17234474e-02f, -3.84841859e-03f, 3.83337177e-02f,
  3.65140922e-02f, 7.41949230e-02f, 1.42851733e-02f, -3.64790373e-02f, -8.05881321e-02f, -7.65040740e-02f, 7.64055550e-02f, 1.24232419e-01f, -3.15644853e-02f, -9.49147798e-04f,
  5.19335978e-02f, -2.04449650e-02f, 7.24999905e-02f, -4.22360487e-02f, 3.62100303e-02f, -6.82910830e-02f, 1.09681068e-05f, 3.11948322e-02f, 1.21626612e-02f, -2.16609072e-02f,
  -1.32310286e-01f, 2.75655873e-02f, -7.03793839e-02f, -7.18541890e-02f, 7.97733814e-02f, 3.70240025e-02f, 8.07306916e-02f, 1.52719039e-02f, -1.07947931e-01f, 1.03294864e-01f,
  -3.28232981e-02f, -2.90144794e-02f, -8.82021189e-02f, -3.25143337e-02f, 5.86826801e-02f, -2.08546277e-02f, -1.71918452e-01f, -2.87210681e-02f, 3.96882594e-02f, -4.30682525e-02f,
  8.05658773e-02f, 4.69808728e-02f, 2.29603928e-02f, -8.97455364e-02f, 8.58046189e-02f, 1.10390343e-01f, 1.00882933e-01f, 3.90052684e-02f, -1.95127111e-02f, 9.34726223e-02f,
  -5.75354090e-04f, 5.70699684e-02f, -5.70917614e-02f, 2.62318607e-02f, -1.32838562e-01f, 8.50740075e-02f, -1.26823664e-01f, -5.54656498e-02f, -1.41677409e-02f, -2.21861042e-02f,
  -6.41420856e-02f, -2.79452521e-02f, -9.39622372e-02f, -1.03243448e-01f, -1.48085177e-01f, -1.06119528e-01f, 1.48129672e-01f, 3.53007670e-03f, -3.85239460e-02f, -3.05209886e-02f,
  5.26635163e-02f, -4.22544330e-01f, -1.02662174e-02f, 1.96394339e-01f, 2.06564277e-01f, -6.58514500e-02f, -1.08089924e-01f, 8.95235166e-02f, 1.43484682e-01f, -2.77641118e-01f,
  -4.08127010e-02f, -1.96850479e-01f, -2.54526407e-01f, -9.30512175e-02f, 1.90778285e-01f, -2.20384464e-01f, 2.32276712e-02f, -6.11355379e-02f, 4.06220891e-02f, 1.30270151e-02f,
  1.55658379e-01f, -2.07470413e-02f, -7.75111243e-02f, -6.89932927e-02f, -6.98405644e-03f, 1.02783687e-01f, 1.78980734e-02f, -7.05325529e-02f, 9.51549262e-02f, 1.23735480e-02f,
  -7.50222728e-02f, -2.63066939e-03f, -8.28580633e-02f, -4.54531759e-02f, -2.47926973e-02f, -1.34171927e-02f, -6.05098791e-02f, -3.90056185e-02f, -2.84587350e-02f, 8.70866980e-03f,
  -1.50797190e-02f, 2.62555480e-02f, 1.61739830e-02f, 1.41387675e-02f, 3.96121666e-03f, -3.13713849e-02f, 6.34298474e-02f, 3.43821608e-02f, -2.68658660e-02f, -6.18913583e-03f,
  6.71444461e-02f, 6.95923865e-02f, 6.15683421e-02f, 6.69478178e-02f, 6.62677065e-02f, 1.11289233e-01f, 1.47726581e-01f, 4.17930707e-02f, -6.06081262e-02f, -3.74204144e-02f,
  3.51527869e-03f, -3.86808477e-02f, 2.43688026e-03f, 9.03386250e-03f, -1.06346123e-01f, 7.00678974e-02f, -3.55955623e-02f, 1.59185659e-02f, -2.58667511e-04f, 3.31546403e-02f,
  -3.66339795e-02f, -9.00690109e-02f, 2.56119426e-02f, 2.75940374e-02f, 3.04745305e-02f, 2.89296266e-02f, -8.34795237e-02f, 2.43565086e-02f, 7.46503100e-02f, 1.09276706e-02f,
  -1.02054067e-01f, 4.89087543e-04f, -4.53030132e-02f, 9.69940238e-03f, -1.13737643e-01f, 4.42693159e-02f, -8.16884264e-02f, -6.10255962e-03f, 8.16296935e-02f, -9.57584754e-02f,
  -3.63702327e-01f, -3.21470410e-01f, -1.03444673e-01f, -1.65828038e-02f, -8.87202993e-02f, 7.45407713e-04f, -2.79597770e-02f, 5.38828596e-02f, -1.55581400e-01f, 3.41105647e-02f,
  7.23609403e-02f, -1.99544355e-02f, -1.05832396e-02f, 1.15627334e-01f, -5.23994565e-02f, 1.33953860e-03f, -2.46646404e-02f, 1.41901858e-02f, -4.47402522e-02f, -5.33132209e-03f,
  3.06483358e-02f, 4.25756611e-02f, 1.21564055e-02f, 6.23189323e-02f, 1.42154381e-01f, 5.63804284e-02f, 1.44665437e-02f, 1.02375001e-01f, 2.63303947e-02f, -5.13633154e-02f,
  -6.44936115e-02f, -2.83570766e-01f, 1.86399415e-01f, -7.89177641e-02f, 1.28301799e-01f, 1.29358336e-01f, 1.01545908e-01f, -1.39245480e-01f, -2.95435220e-01f, -2.79771507e-01f,
  8.74042958e-02f, 4.66802195e-02f, 1.58572868e-01f, -1.51699930e-02f, 3.57003897e-01f, 7.86618888e-02f, 1.43096624e-02f, 1.63982306e-02f, -9.14271642e-03f, 5.41588664e-02f,
  1.46784056e-02f, 2.84882672e-02f, 2.28673398e-01f, -8.18285421e-02f, 1.63951248e-01f, -1.12559691e-01f, -6.71421736e-02f, 1.43901691e-01f, 1.25697823e-02f, 1.30994514e-01f,
  6.27260804e-02f, -1.22505791e-01f, 1.14364780e-01f, 3.45057080e-04f, 1.90036427e-02f, 5.73537871e-02f, 3.79821397e-02f, 9.38912481e-03f, -4.61484538e-03f, 9.74267200e-02f,
  5.38617224e-02f, 3.88758332e-02f, -4.17393632e-02f, -2.54320912e-02f, -7.69454986e-02f, -1.25379175e-01f, 4.26442809e-02f, 6.81075901e-02f, 5.30101396e-02f, 3.88559625e-02f,
  1.53832614e-01f, 9.31095146e-03f, 5.01002297e-02f, 3.47354659e-03f, 7.29833916e-02f, -4.84768562e-02f, -6.62515834e-02f, 4.92543988e-02f, 1.52880754e-02f, -1.70611721e-02f,
  -7.32350275e-02f, 5.96064888e-03f, -9.87406746e-02f, 3.61754652e-03f, 7.26639181e-02f, 1.81789696e-02f, -7.77660124e-03f, 7.16674030e-02f, -2.65006702e-02f, -2.91897282e-02f,
  1.42740428e-01f, -1.07237063e-02f, -1.67641640e-02f, -3.42888311e-02f, -1.41909465e-01f, -8.68569687e-02f, 1.24609515e-01f, 6.27005994e-02f, 2.38525383e-02f, 1.19511625e-02f,
  -1.59781892e-02f, -4.80728075e-02f, -4.40357998e-02f, 5.52161336e-02f, -8.76808763e-02f, 1.24866307e-01f, 1.47616016e-02f, 3.08536980e-02f, 1.03971716e-02f, 2.24694218e-02f,
  -8.49008188e-02f, -2.30699196e-01f, -6.21816665e-02f, 1.04158390e-02f, -2.52398606e-02f, 2.87360530e-02f, -7.24517135e-03f, -9.12403688e-02f, -3.90200131e-03f, 4.02461439e-02f,
  3.97783034e-02f, 9.78950318e-03f, -9.72460210e-02f, -2.59588528e-02f, -9.85801741e-02f, -9.70552340e-02f, -6.61343634e-02f, -1.99175365e-02f, 9.10139605e-02f, -1.29294872e-01f,
  1.10513568e-02f, -4.31321412e-02f, 6.75420240e-02f, 4.37106192e-02f, -6.95703849e-02f, 9.59085599e-02f, -1.59832716e-01f, -5.19594550e-02f, 4.03507389e-02f, 4.56642499e-03f,
  1.30981162e-01f, -2.49600217e-01f, 9.37636420e-02f, 1.72155336e-01f, -1.60096511e-01f, -1.90882474e-01f, 1.16603717e-01f, -1.73632354e-01f, 8.26396272e-02f, -2.39811972e-01f,
  1.52627006e-01f, 3.25325541e-02f, 7.00251311e-02f, -6.64158091e-02f, 1.83483943e-01f, 1.44104868e-01f, -1.08252084e-02f, 1.09223530e-01f, -3.67907286e-02f, -3.28796133e-02f,
  8.07298794e-02f, -1.56279266e-01f, 1.96203724e-01f, -3.02583396e-01f, -1.25600591e-01f, -1.28746212e-01f, 2.67690998e-02f, -5.25728390e-02f, -2.23183602e-01f, -2.65552029e-02f,
  -1.70962930e-01f, -1.97537132e-02f, -6.40966520e-02f, -1.35393173e-01f, -7.70775899e-02f, 4.94311675e-02f, 1.17692918e-01f, 9.09345821e-02f, 4.38455865e-02f, -9.16540027e-02f,
  3.95145603e-02f, -3.14459205e-02f, -4.03369591e-02f, -3.00621111e-02f, -1.91273719e-01f, -1.09865963e-01f, 2.42797174e-02f, 5.21788597e-02f, -5.79601005e-02f, 1.55918479e-01f,
  1.01203173e-02f, -2.63792817e-02f, -2.70799524e-03f, -3.46390554e-03f, -2.96213701e-02f, -8.82326812e-03f, 4.71759252e-02f, 8.80456790e-02f, -4.07861471e-02f, -5.75753227e-02f,
  6.65254891e-02f, 1.34480251e-02f, 8.55030771e-03f, -6.65042102e-02f, 3.31648514e-02f, 3.44462432e-02f, -1.68447439e-02f, 3.23205581e-03f, -1.57380179e-02f, 6.42093271e-02f,
  1.18073998e-02f, -5.05518876e-02f, -6.10111319e-02f, 1.87248178e-02f, -2.95754299e-02f, 1.58868492e-01f, -3.46354656e-02f, -1.36610195e-01f, -7.03642052e-03f, -2.71020271e-02f,
  -2.94992626e-02f, 1.15266509e-01f, -6.71793595e-02f, -9.89471748e-03f, -1.51151530e-02f, -2.28129961e-02f, 4.21280004e-02f, 5.51363900e-02f, 4.21273932e-02f, -1.40284926e-01f,
  -2.88519084e-01f, -2.35240579e-01f, -3.17033380e-02f, -6.54125735e-02f, 5.82744777e-02f, -1.17881037e-01f, 3.01414561e-02f, -1.82766747e-02f, -1.39255360e-01f, -4.50548492e-02f,
  -4.03074659e-02f, 1.29874283e-02f, -6.39080107e-02f, 9.59986076e-02f, -1.87955990e-01f, -6.97516277e-02f, 3.18164080e-02f, 1.09603694e-02f, -8.69659558e-02f, 2.56313588e-02f,
  1.21383229e-02f, 5.48515320e-02f, -8.39465633e-02f, -1.83721315e-02f, -2.21345257e-02f, -3.67615111e-02f, -1.71814561e-02f, 3.27899195e-02f, -2.97905486e-02f, 2.04978455e-02f,
  -7.33615384e-02f, 1.26655018e-02f, -3.94787520e-01f, -2.28457138e-01f, 2.00823501e-01f, -1.66256368e-01f, -6.36504292e-02f, 8.99626538e-02f, -6.72467500e-02f, 2.82787710e-01f,
  1.96170583e-01f, -3.33387405e-04f, 1.60423487e-01f, -7.33421594e-02f, -3.69965732e-01f, -1.73407584e-01f, -6.73345551e-02f, -3.62787545e-02f, -8.86461139e-03f, 7.73744136e-02f,
  -5.76304942e-02f, 2.12123856e-01f, -2.30222210e-01f, 2.06883147e-01f, 1.43922493e-01f, -2.12549344e-02f, 2.03067526e-01f, 1.71442971e-01f, 6.79509863e-02f, 1.15429185e-01f,
  -1.19542412e-01f, 5.14838621e-02f, -2.36190436e-03f, -1.03872918e-01f, -7.81699792e-02f, -5.70276156e-02f, -1.90858096e-02f, -1.00341186e-01f, -3.50504853e-02f, -1.15073926e-03f,
  1.13130726e-01f, 4.88977768e-02f, -5.06032519e-02f, 5.40656112e-02f, 9.63560417e-02f, 6.90247566e-02f, -1.00986674e-01f, -3.83082330e-02f, 1.22353435e-02f, -6.94352686e-02f,
  -5.26825823e-02f, -6.60437047e-02f, 8.91138911e-02f, 1.32821426e-02f, -9.23337974e-03f, -7.21211061e-02f, -1.23969644e-01f, 2.64959112e-02f, 4.06674370e-02f, 4.83329147e-02f,
  9.30559486e-02f, 6.58151507e-02f, -4.20321338e-02f, -7.59552419e-02f, -7.60452449e-02f, -7.71768019e-02f, 4.33802605e-02f, -6.66242465e-02f, -5.54204471e-02f, -4.15688790e-02f,
  -5.01246452e-02f, -5.07328920e-02f, 9.18825120e-02f, 2.21939180e-02f, 2.92455815e-02f, -2.86227297e-02f, -4.83864509e-02f, 5.09809889e-02f, -2.25255750e-02f, -1.61478490e-01f,
  -2.41784249e-02f, -4.02730890e-02f, -3.70928124e-02f, 1.33739650e-01f, -2.87480820e-02f, 9.72185433e-02f, 1.44158438e-01f, -8.35677050e-03f, -1.30535783e-02f, 4.53154780e-02f,
  3.41027491e-02f, 1.58879980e-01f, 1.01989759e-02f, 4.75486591e-02f, -1.06765516e-01f, -1.32395998e-02f, -6.39146939e-02f, -1.20175473e-01f, 5.72481528e-02f, 7.59957060e-02f,
  7.35306069e-02f, 4.56521809e-02f, 1.06391776e-02f, -3.06118056e-02f, 1.46180647e-03f, 8.58386829e-02f, 8.96238685e-02f, 1.62854139e-03f, 1.34139612e-01f, -4.11222726e-02f,
  8.26509073e-02f, 4.12470289e-02f, 5.69512276e-03f, -2.30375901e-02f, 1.21261738e-01f, 9.52426065e-03f, 9.19164345e-02f, 3.34495455e-02f, 6.49912981e-03f, 2.93697808e-02f,
  2.63077587e-01f, -1.39004865e-03f, 1.80842578e-01f, 1.77495345e-01f, 1.89197231e-02f, 2.19599947e-01f, 2.54669845e-01f, 2.17010826e-01f, 4.21289712e-01f, -1.42069146e-01f,
  -2.54291475e-01f, -8.82825926e-02f, -1.38080254e-01f, -1.59195095e-01f, 3.02248836e-01f, 9.63250473e-02f, 9.64285806e-02f, -1.03896901e-01f, -7.17866281e-03f, -1.44360051e-01f,
  -5.99614531e-02f, -2.03959733e-01f, -1.95059285e-01f, -1.00175217e-01f, -1.56617686e-01f, -3.30300652e-03f, -2.60690689e-01f, -4.30571698e-02f, -3.08484018e-01f, 1.08516682e-02f,
  -1.49299260e-02f, 1.53854652e-03f, -5.99601418e-02f, -6.02203384e-02f, 4.31056805e-02f, -4.38985899e-02f, -5.31776957e-02f, -8.53509679e-02f, 2.95100957e-02f, -8.93695559e-03f,
  -1.10740270e-02f, -1.11971751e-01f, 1.99640542e-02f, 3.36378929e-03f, 1.00244693e-01f, 2.19163708e-02f, -9.11101252e-02f, 5.34318388e-03f, -4.58035804e-02f, -3.37336697e-02f,
  -4.00897041e-02f, -9.58909001e-03f, 8.70877504e-02f, 2.81098392e-02f, 1.30397435e-02f, -1.45399012e-02f, 4.54479754e-02f, -2.44691735e-03f, -2.46094707e-02f, 1.51042968e-01f,
  2.44713631e-02f, 5.39353862e-02f, -2.15425938e-02f, -8.02685395e-02f, -2.56424514e-03f, -1.59100909e-02f, -6.06162921e-02f, -9.80944186e-02f, 8.18498656e-02f, -4.12805863e-02f,
  -1.02770310e-02f, -6.79655597e-02f, 3.39003317e-02f, -2.09644474e-02f, -2.46754829e-02f, 4.67693955e-02f, -2.22088657e-02f, -3.10856458e-02f, 1.44594893e-01f, -9.71889272e-02f,
  5.09842075e-02f, 8.44945610e-02f, -7.74324164e-02f, -8.21214244e-02f, 2.41535790e-02f, -1.08542051e-02f, -3.95410657e-02f, 2.39141211e-02f, -3.11263502e-02f, -6.87302351e-02f,
  7.15288967e-02f, 7.07914382e-02f, -3.43041271e-02f, -1.41182020e-01f, -3.57966349e-02f, -4.89578350e-03f, -2.72166841e-02f, -2.85412315e-02f, 6.42305091e-02f, -5.75683732e-03f,
  -7.21130446e-02f, -8.09663013e-02f, 1.46869883e-01f, 9.54008847e-03f, -3.69723029e-02f, 6.05517812e-02f, -5.87346479e-02f, -3.03013548e-02f, 5.78855425e-02f, -1.36049047e-01f,
  -1.82390019e-01f, -6.04005866e-02f, -3.40677835e-02f, 3.16150375e-02f, -6.15997985e-02f, -9.71457362e-02f, 5.26712090e-02f, -9.23289917e-03f, -4.12013493e-02f, 9.83110443e-02f,
  6.73241764e-02f, -3.46887857e-01f, -2.26634979e-01f, -1.46618471e-01f, 1.45394251e-01f, 3.00394390e-02f, 1.59095153e-01f, -2.12200150e-01f, -2.25589901e-01f, 5.92260025e-02f,
  1.60379037e-01f, 1.86559483e-01f, 8.06878656e-02f, -2.12895691e-01f, 1.44097149e-01f, -7.83088431e-02f, -1.80623755e-01f, 2.33880654e-02f, -8.52047727e-02f, -6.63914308e-02f,
  -5.96130788e-02f, 1.76964700e-02f, -1.63997009e-01f, -8.67027640e-02f, 5.70389852e-02f, 5.65814599e-03f, 2.50359267e-01f, 2.08823591e-01f, -1.13481591e-02f, 2.43566841e-01f,
  -1.43266115e-02f, -5.70169501e-02f, -3.74221392e-02f, -2.16918834e-03f, 2.16398649e-02f, 6.17220113e-03f, 7.85973594e-02f, 3.49608570e-01f, 1.31660342e-01f, -5.09225577e-02f,
  1.85478970e-01f, 5.15651070e-02f, -8.30555633e-02f, 9.62903351e-02f, -5.05193174e-02f, -6.88686594e-02f, -4.63964269e-02f, 3.29537913e-02f, -1.70082897e-02f, 2.11314554e-03f,
  -8.52194354e-02f, -2.55713575e-02f, 3.47462632e-02f, -3.96880545e-02f, 5.46796471e-02f, 1.83749031e-02f, -3.27198394e-02f, 1.49303287e-01f, -9.23585892e-02f, -1.96370278e-02f,
  3.89886834e-02f, 5.65571412e-02f, 1.89238433e-02f, -7.62577355e-02f, 4.15120572e-02f, -6.15983568e-02f, -4.23783399e-02f, 3.65143605e-02f, 5.41217104e-02f, 6.69600889e-02f,
  -4.38091494e-02f, -4.24071029e-02f, -6.71565086e-02f, 1.18422834e-02f, 6.87748119e-02f, -2.79575139e-02f, 3.39268371e-02f, 1.46247864e-01f, -4.30359729e-02f, -3.51171158e-02f,
  1.85411517e-02f, -1.60208978e-02f, 2.29364410e-02f, -4.29549888e-02f, -1.15711384e-01f, 1.03909560e-01f, 6.20565712e-02f, 4.74250969e-03f, -5.07135019e-02f, 7.54681826e-02f,
  -1.11844977e-02f, 6.79483637e-02f, -3.64321433e-02f, -1.44285820e-02f, -5.14497347e-02f, -1.18861928e-04f, 3.51019390e-03f, 4.63927425e-02f, 5.22471108e-02f, -5.76512935e-03f,
  5.22287413e-02f, 1.75191965e-02f, -3.11489869e-02f, -1.32078510e-02f, 3.86463515e-02f, -7.90181756e-02f, 2.74540633e-02f, 7.84131140e-02f, -8.68106112e-02f, 3.84560972e-02f,
  9.91295502e-02f, 1.43505052e-01f, 1.01442084e-01f, 2.49610599e-02f, -3.15315053e-02f, 1.55597016e-01f, 2.23395473e-04f, 1.18094899e-01f, 1.10880069e-01f, 5.60769029e-02f,
  -1.58539668e-01f, -1.34624451e-01f, -3.97982635e-02f, -1.80360049e-01f, -1.20973445e-01f, 6.96350168e-03f, 1.74243435e-01f, -9.04333144e-02f, -9.30442065e-02f, 5.05510122e-02f,
  -7.92279020e-02f, 1.69658571e-01f, 2.97794849e-01f, -1.20173074e-01f, 3.12660336e-01f, 8.33302289e-02f, -2.27101371e-01f, 1.93057265e-02f, -2.10460335e-01f, -6.64876476e-02f,
  -7.15148821e-02f, -1.32551655e-01f, 1.49601042e-01f, -1.94049045e-01f, -2.91962206e-01f, -1.19169340e-01f, 8.73210505e-02f, 1.06750809e-01f, -3.05710346e-01f, -1.27300015e-02f,
  -3.15371543e-01f, -2.29729146e-01f, -2.05038622e-01f, -1.21366397e-01f, -3.35315578e-02f, 5.91840073e-02f, 1.38395801e-02f, 1.47115827e-01f, 3.81880328e-02f, 5.86356269e-03f,
  9.52449441e-02f, -7.79913217e-02f, -1.27512604e-01f, 8.68864357e-02f, -1.23832539e-01f, -1.50312439e-01f, -1.32431164e-01f, -7.90759474e-02f, -2.19406947e-01f, 1.05511047e-01f,
  -1.86673440e-02f, -3.64245027e-02f, -8.65519419e-02f, -6.22490495e-02f, -4.29034345e-02f, -1.48734987e-01f, 2.17057057e-02f, 7.43168592e-02f, -1.70362875e-01f, -1.84299991e-01f,
  5.06581999e-02f, -9.54553783e-02f, -3.69863473e-02f, -2.06611231e-02f, 3.15932818e-02f, 3.11689973e-02f, 5.88583089e-02f, 2.66148038e-02f, 9.98310447e-02f, -5.59127191e-03f,
  -1.10397853e-01f, 6.41186312e-02f, -7.76295364e-02f, 3.40319052e-02f, 3.71275283e-03f, 1.35251373e-01f, 5.77857085e-02f, -1.39300451e-01f, 1.85629930e-02f, 9.89191830e-02f,
  -7.07905367e-02f, 5.71232550e-02f, -5.87063879e-02f, 4.46102284e-02f, -3.17174941e-02f, 4.93837185e-02f, -1.13605499e-01f, -8.76172855e-02f, 2.68726628e-02f, 1.51629329e-01f,
  -2.11006910e-01f, -1.02587499e-01f, -4.75255325e-02f, -1.07266374e-01f, 3.12089231e-02f, 2.33249478e-02f, 2.86615733e-02f, -3.60548161e-02f, 6.65297508e-02f, 1.12921447e-02f,
  -3.60558555e-02f, -4.76580299e-02f, 1.11260992e-02f, 3.95613872e-02f, 1.81736737e-01f, -4.75418903e-02f, 6.51947036e-02f, 8.85413773e-03f, -1.09590717e-01f, -1.08086513e-02f,
  -4.70040366e-02f, 1.27999008e-01f, 6.92750439e-02f, -1.86788253e-02f, 8.15604925e-02f, -9.33211148e-02f, 1.22849293e-01f, -5.80769181e-02f, 7.86788687e-02f, 5.60830273e-02f,
  3.71697694e-01f, -2.41935968e-01f, 1.19834520e-01f, 3.08681309e-01f, 1.97130442e-01f, -3.66102681e-02f, 1.57537609e-01f, -5.99318482e-02f, 5.65998033e-02f, -2.53610969e-01f,
  5.17750718e-03f, 9.49074887e-03f, -5.47656864e-02f, 9.02294666e-02f, 1.84212580e-01f, -1.82122990e-01f, 1.73646323e-02f, -8.39885473e-02f, 5.26136998e-03f, 1.46662518e-01f,
  6.69048950e-02f, -3.34520303e-02f, 7.79005960e-02f, -1.54865175e-01f, 4.62086275e-02f, -9.91782919e-02f, -1.00876473e-01f, 8.57249722e-02f, -1.16268598e-01f, 1.91263407e-02f,
  7.00422749e-02f, 4.70884182e-02f, 1.30984440e-01f, -5.46560101e-02f, 4.37719673e-02f, 9.34594423e-02f, 4.37383130e-02f, -4.32374887e-02f, 3.07017993e-02f, -4.28560227e-02f,
  -2.98236683e-02f, -9.14521962e-02f, -7.01765791e-02f, 1.04722343e-01f, 1.26866668e-01f, -4.27569710e-02f, -3.69201861e-02f, -1.93351042e-02f, -1.31718457e-01f, 9.19386465e-03f,
  7.77565315e-02f, -4.04685251e-02f, 9.41122398e-02f, -1.07705154e-01f, -2.12962292e-02f, -7.14166090e-03f, -7.82636553e-02f, 4.80684415e-02f, -6.79520592e-02f, 3.73769887e-02f,
  -4.10699984e-03f, -3.83881517e-02f, -2.52031279e-03f, 9.11610480e-03f, 3.40874121e-03f, 1.57699194e-02f, -1.09043922e-02f, -3.60152908e-02f, 4.30039689e-02f, 2.57363217e-03f,
  3.67093496e-02f, 5.63901924e-02f, 2.98663750e-02f, -1.18704475e-02f, 1.81947481e-02f, -3.51559967e-02f, 7.52378553e-02f, -7.91455582e-02f, 1.66815147e-01f, -2.20727753e-02f,
  -3.47166061e-02f, 5.42001724e-02f, 3.57824937e-02f, -8.72616246e-02f, -3.63945626e-02f, 4.71830815e-02f, 3.59634403e-03f, 9.16955918e-02f, 3.40805277e-02f, 5.78572191e-02f,
  -4.10567187e-02f, -2.92296529e-01f, -1.07245296e-02f, -4.07904088e-02f, -1.09113418e-02f, 1.54042587e-01f, 1.39687611e-02f, -6.33149967e-02f, -8.85015801e-02f, -3.12982826e-04f,
  3.89906066e-03f, -7.91670829e-02f, 6.56725653e-03f, 1.05214521e-01f, 3.86131853e-02f, -6.03193901e-02f, -1.76402126e-02f, -4.48793620e-02f, -2.25002076e-02f, -8.85366350e-02f,
  -7.37518147e-02f, -7.55959079e-02f, -4.67948057e-02f, -4.21783067e-02f, -8.26925486e-02f, -9.95794982e-02f, -2.32818704e-02f, -2.06067320e-03f, -7.39500746e-02f, -5.03940955e-02f,
  -1.24047779e-01f, -1.15251347e-01f, 1.16649017e-01f, 3.29711050e-01f, -1.25058919e-01f, -3.96123707e-01f, -3.03000212e-01f, -1.42409950e-01f, 4.28524949e-02f, -2.58990824e-01f,
  -2.28385001e-01f, 6.87433183e-02f, -4.17639256e-01f, 1.54529184e-01f, 2.98599005e-01f, -1.58805355e-01f, 8.62774029e-02f, -4.40136045e-02f, 1.65873677e-01f, 4.72671017e-02f,
  2.39191443e-01f, 1.36150762e-01f, 2.83562005e-01f, 2.29896039e-01f, 7.50404596e-02f, 3.04400444e-01f, 4.31599915e-01f, 2.37831607e-01f, 3.18264455e-01f, 8.55278224e-02f,
  -2.04012617e-01f, 2.08422206e-02f, 2.26016771e-02f, -1.73147433e-02f, 7.30080716e-03f, -6.39355704e-02f, 1.53175406e-02f, -7.99394399e-03f, 1.38670534e-01f, -7.58062154e-02f,
  -5.12792030e-03f, 1.58134270e-02f, 9.54356939e-02f, 9.22816396e-02f, -3.98256518e-02f, 4.42846529e-02f, 3.88213880e-02f, -3.72083560e-02f, -4.16202880e-02f, 9.39205568e-03f,
  3.20015550e-02f, -7.38851503e-02f, -1.26611041e-02f, 1.17172889e-01f, 8.09123144e-02f, 1.06517106e-01f, 1.26805663e-01f, 8.04938301e-02f, 9.02680159e-02f, 1.12805113e-01f,
  -1.37155190e-01f, 3.46879065e-02f, 3.55838761e-02f, 1.10015096e-02f, 2.03075465e-02f, -5.47305532e-02f, 4.74266037e-02f, 4.15827557e-02f, 1.02928571e-01f, -7.22580031e-02f,
  -2.34928764e-02f, 2.40702508e-03f, -1.11469157e-01f, 1.41811490e-01f, 4.20892499e-02f, -3.86787765e-02f, 1.46079930e-02f, 1.11508053e-02f, 3.46744545e-02f, 1.44463614e-01f,
  -2.61680651e-02f, -4.22977842e-03f, 8.20480883e-02f, -1.00367196e-01f, -8.93780664e-02f, 7.70889670e-02f, 7.82343522e-02f, 4.62321768e-04f, -7.41070956e-02f, 5.09785786e-02f,
  -8.43320489e-02f, 2.40980685e-01f, -2.55909413e-02f, -1.09747179e-01f, 7.00608566e-02f, 2.11231830e-03f, 4.97768708e-02f, 2.84866113e-02f, 7.35631958e-02f, -1.47553943e-02f,
  -6.62531778e-02f, -5.87557815e-02f, -1.10065425e-03f, 1.82009526e-02f, -2.38663815e-02f, -4.43415940e-02f, 6.13795370e-02f, 3.22723426e-02f, 3.97279337e-02f, 6.39079362e-02f,
  1.08302608e-01f, -1.22707456e-01f, -4.93515246e-02f, 1.45876050e-01f, -6.01681620e-02f, -1.86531674e-02f, 4.61445637e-02f, 2.99947374e-02f, 1.26777768e-01f, 8.15522820e-02f,
  -1.27993925e-02f, 1.74756199e-01f, -1.76371187e-02f, 2.26774856e-01f, 8.39781463e-02f, -4.95103568e-01f, -1.50983453e-01f, 1.92455679e-01f, 1.48845881e-01f, -4.43633646e-02f,
  3.41157392e-02f, -1.34858161e-01f, 2.57212460e-01f, -1.12026751e-01f, -2.00409606e-01f, 3.46672684e-02f, -3.16597372e-01f, -2.36408085e-01f, 1.37275904e-01f, -1.01966619e-01f,
  3.81434001e-02f, 1.94759861e-01f, 3.24127339e-02f, 2.79132605e-01f, 3.06623001e-02f, 8.95296782e-02f, 1.09854952e-01f, 1.57749608e-01f, -8.18789899e-02f, -1.00238048e-01f,
  -1.44661203e-01f, 2.76061773e-01f, 6.02506064e-02f, -5.28092217e-03f, -3.48574258e-02f, -1.21549375e-01f, -1.29573822e-01f, 2.83387955e-02f, 7.34344199e-02f, 2.55815554e-02f,
  -8.64505470e-02f, 6.62748665e-02f, 4.84183356e-02f, 1.68723911e-01f, -2.29507890e-02f, 1.62014037e-01f, -5.72421513e-02f, -1.62572950e-01f, 7.39459693e-02f, -4.71901335e-02f,
  1.16400324e-01f, -1.42850220e-01f, -1.06139548e-01f, -2.64419727e-02f, -3.74622270e-02f, -5.23161981e-03f, -5.02650887e-02f, -6.33057579e-02f, -4.94963080e-02f, 2.04098597e-02f,
  -3.26295272e-02f, 4.41938452e-02f, 3.99011858e-02f, 1.52913451e-01f, 6.54955506e-02f, -1.91680472e-02f, 2.73715425e-02f, -1.74462885e-01f, 3.84796225e-02f, 4.34183329e-03f,
  -1.05773628e-01f, 4.51590493e-02f, 1.07567742e-01f, -1.96845774e-02f, -1.00031961e-03f, 9.15072709e-02f, -1.23917215e-01f, -2.22968701e-02f, -8.91133305e-03f, 7.73887187e-02f,
  1.21485680e-01f, -8.96317214e-02f, 2.73551196e-02f, -1.59391403e-01f, -8.70596990e-02f, 7.73324966e-02f, 1.19715473e-02f, 1.19374311e-02f, -8.16448312e-03f, 1.52839664e-02f,
  -1.67596668e-01f, 1.48751974e-01f, 1.35780443e-02f, -3.20710391e-02f, -5.47176152e-02f, -1.79423187e-02f, -3.65431942e-02f, 2.34239269e-02f, 9.72001553e-02f, 1.39694093e-02f,
  -8.25317502e-02f, -2.79679429e-02f, -2.73272507e-02f, 1.35136321e-02f, -7.76716024e-02f, 1.26794964e-01f, -4.68919985e-02f, 4.62592877e-02f, -2.46369336e-02f, -2.25697551e-03f,
  4.77652773e-02f, 1.64221954e-02f, -3.31387445e-02f, 4.91578579e-02f, -1.21609263e-01f, -2.07109489e-02f, -3.14092301e-02f, 3.24907564e-02f, 5.56051619e-02f, -1.91475339e-02f,
  3.94035727e-01f, -1.21028900e-01f, 3.20659429e-01f, 2.84582287e-01f, 1.08313382e-01f, -9.82420519e-02f, 3.56807441e-01f, -9.09480155e-02f, 3.61938141e-02f, -2.65381545e-01f,
  -2.70316824e-02f, 2.82639921e-01f, -1.27474070e-02f, -9.09054056e-02f, -9.74395797e-02f, -1.37814954e-01f, -5.05784079e-02f, 6.70300871e-02f, -4.61620763e-02f, 4.32029553e-02f,
  2.44704187e-02f, -2.66152471e-01f, 2.05268919e-01f, -2.65114784e-01f, 1.12847492e-01f, 9.03000310e-02f, -9.27553326e-02f, 1.37671143e-01f, -3.37502472e-02f, -9.36592091e-03f,
  -8.42851996e-02f, -6.61237398e-03f, 3.47398296e-02f, -6.47582114e-02f, -2.12645326e-02f, 1.22030720e-03f, 1.10333875e-01f, 1.28898263e-01f, 3.43967117e-02f, -9.91420168e-03f,
  8.92598853e-02f, -4.21017930e-02f, -4.16252986e-02f, -5.02229109e-02f, 3.50535996e-02f, -2.88193626e-03f, 1.67752896e-02f, 1.02146231e-01f, 2.76236981e-02f, 9.06599686e-02f,
  1.00142039e-01f, 6.31760508e-02f, 8.54199827e-02f, 7.09799863e-03f, 8.14096481e-02f, 1.53055415e-02f, 8.28383565e-02f, 8.45223665e-02f, -2.92397197e-02f, -8.29600915e-02f,
  -4.53316830e-02f, -3.59142921e-03f, 1.17225118e-01f, -4.54041827e-03f, -2.41263229e-02f, 5.82828047e-03f, -3.01838689e-03f, 2.90744007e-02f, 4.07355689e-02f, -1.00231379e-01f,
  1.66784972e-02f, -1.40500935e-02f, 4.92993183e-03f, -4.20742575e-03f, 1.44760031e-03f, 1.36564434e-01f, 4.92639430e-02f, -3.62605043e-02f, -4.36597038e-03f, 8.06345604e-03f,
  -5.39172813e-02f, -1.81064885e-02f, -1.96160004e-03f, 6.80448413e-02f, -4.54786867e-02f, 5.93175143e-02f, -4.25790064e-02f, 5.23983650e-02f, 1.46953287e-02f, -1.23756779e-02f,
  -3.89118314e-01f, -3.68636131e-01f, -5.89329116e-02f, -6.68289140e-02f, -6.96261823e-02f, -3.52308974e-02f, 3.27414721e-02f, -9.45634488e-03f, -6.17429726e-02f, -4.04224694e-02f,
  1.14764553e-02f, 1.01285465e-01f, -1.26907483e-01f, -3.83528695e-02f, -3.38560194e-02f, 2.98220143e-02f, 8.42754841e-02f, 4.83862720e-02f, -8.45197588e-02f, -2.03047339e-02f,
  -3.45927663e-02f, -2.90579833e-02f, -1.44553632e-02f, -1.80153791e-02f, 2.63576750e-02f, 4.95477729e-02f, 1.11032985e-02f, -2.37717591e-02f, 3.14406827e-02f, -9.25634727e-02f,
  2.74288803e-01f, -4.30869162e-01f, -3.44058126e-01f, 3.11230011e-02f, 1.19299918e-01f, 3.23387831e-01f, 2.26740196e-01f, -1.55457452e-01f, -1.34669244e-01f, -1.91329122e-02f,
  1.57423660e-01f, 8.10168460e-02f, -1.88529491e-01f, 3.46804887e-01f, 4.25112754e-01f, -3.37231122e-02f, 2.47711807e-01f, 9.04111490e-02f, -2.34135032e-01f, -1.07477032e-01f,
  5.62632941e-02f, 2.06884295e-01f, -3.32134143e-02f, -2.74870135e-02f, 1.18425742e-01f, -1.90682322e-01f, 2.74318606e-02f, -9.44428593e-02f, 1.95353761e-01f, 2.38094330e-01f,
  1.24047078e-01f, -6.46662489e-02f, 5.24943881e-02f, 1.09673180e-02f, -8.22206140e-02f, 2.65509542e-02f, -1.36860879e-03f, 8.38166699e-02f, 3.31406407e-02f, -9.86664742e-02f,
  8.91187787e-02f, 8.14744234e-02f, 6.24570027e-02f, 1.09682836e-01f, -4.85875783e-03f, 5.07296100e-02f, -7.70547986e-02f, -4.79229540e-03f, -5.02870679e-02f, -4.50893678e-02f,
  -5.92252389e-02f, -7.58445784e-02f, 9.33641102e-04f, -4.03932407e-02f, 2.95149703e-02f, -6.75814375e-02f, -5.16407415e-02f, -5.93785457e-02f, -6.65979134e-03f, -4.04647589e-02f,
  5.25721069e-03f, -3.37441824e-02f, -4.88143712e-02f, 3.28416266e-02f, -4.36138175e-02f, 4.73785698e-02f, 1.07141808e-01f, 3.67084257e-02f, -2.26327740e-02f, -1.63557269e-02f,
  3.17047052e-02f, -2.52417987e-03f, 1.61069892e-02f, 9.75725725e-02f, 9.47305840e-03f, -3.95061309e-03f, 5.71850985e-02f, -8.98734108e-03f, -1.19881660e-01f, 1.99763458e-02f,
  4.68422100e-02f, 1.76269021e-02f, -4.91445884e-03f, -5.57577126e-02f, -7.15210140e-02f, 4.35126834e-02f, 6.53079748e-02f, -9.75636467e-02f, 2.16963142e-02f, -5.63669484e-03f,
  -7.29316324e-02f, -3.25437576e-01f, -4.29385491e-02f, -3.76361944e-02f, -2.89590769e-02f, 5.36502302e-02f, 6.83102384e-02f, 3.95582467e-02f, 1.00687873e-02f, 1.44618368e-02f,
  -8.85575172e-03f, -2.49728393e-02f, 8.92615318e-03f, 1.45506278e-01f, 3.97602208e-02f, -4.36838828e-02f, -2.79624518e-02f, 5.85327782e-02f, 1.92223918e-02f, -6.34849072e-02f,
  -2.73698214e-02f, -4.81157899e-02f, -6.63246308e-03f, 2.30612401e-02f, -2.66622026e-02f, -6.93728179e-02f, -1.05123864e-02f, 2.62241885e-02f, -3.09218056e-02f, 4.59263213e-02f,
  -2.23414421e-01f, 4.75110635e-02f, -1.19192556e-01f, 2.67699026e-02f, 1.39278874e-01f, -2.93707788e-01f, -1.67527691e-01f, 7.38085136e-02f, -7.32399002e-02f, 1.63271621e-01f,
  -5.27643636e-02f, -9.63966623e-02f, -6.08976446e-02f, -2.07753643e-01f, -3.84618640e-01f, -4.12423134e-01f, -6.13335222e-02f, -1.57311574e-01f, -3.41571718e-02f, 5.55102415e-02f,
  -8.16910341e-02f, 1.52054403e-04f, -9.44780633e-02f, 2.50773758e-01f, -1.07069397e-02f, 1.74379781e-01f, 3.83538783e-01f, 1.33701384e-01f, 1.24932848e-01f, 1.77075528e-02f,
  -1.58279210e-01f, -8.07135999e-02f, 1.53326336e-02f, -2.12452132e-02f, -7.69299595e-03f, 1.56014357e-02f, -1.70360273e-03f, 4.59122173e-02f, 4.09325510e-02f, -4.18212526e-02f,
  8.19358043e-03f, -4.37707491e-02f, -1.82389561e-02f, 3.14677088e-03f, 3.28690112e-02f, -5.39495097e-03f, -5.55976033e-02f, -4.40809727e-02f, 1.54904947e-02f, -3.78439538e-02f,
  -4.64527719e-02f, -8.61470848e-02f, 4.27574888e-02f, 9.30228829e-02f, -3.94970365e-02f, -6.36234879e-02f, 6.65269643e-02f, 8.11783597e-02f, 2.68981829e-02f, 4.01619114e-02f,
  1.70560938e-03f, -1.95990503e-02f, -3.14850323e-02f, -1.52464554e-01f, -2.56104525e-02f, 1.13566117e-02f, 5.18430471e-02f, 2.55659339e-03f, 9.13322493e-02f, -1.00781992e-02f,
  -2.05680002e-02f, -7.32941031e-02f, -5.47631681e-02f, 2.69903112e-02f, -3.67988413e-03f, -8.97673145e-03f, 4.20879107e-03f, 7.57660791e-02f, -6.51703924e-02f, 1.42745208e-02f,
  1.37890438e-02f, 1.96758541e-03f, -1.57716661e-03f, 1.08239697e-02f, -1.00925870e-01f, 9.66646001e-02f, 8.04194137e-02f, 1.05096279e-02f, -6.12412728e-02f, 5.15231825e-02f,
  1.28718346e-01f, 2.71387786e-01f, -2.55863238e-02f, -4.05941717e-02f, 2.67096213e-03f, 3.24585363e-02f, -4.64395843e-02f, -3.74628454e-02f, 5.26388809e-02f, 1.82834715e-02f,
  -5.79823107e-02f, 6.42513037e-02f, 2.35845670e-02f, -8.80469661e-03f, 4.92451265e-02f, 4.53895368e-02f, 4.14850935e-02f, -4.99471044e-03f, 1.44985497e-01f, 1.38834268e-01f,
  6.28307685e-02f, -3.33226770e-02f, 4.61602360e-02f, 6.12075962e-02f, 5.11046425e-02f, 8.58396366e-02f, -2.09195614e-02f, 1.90054737e-02f, 1.19848788e-01f, 1.25078261e-01f,
  1.14226274e-01f, 3.65193069e-01f, 3.31234843e-01f, 2.66694963e-01f, -2.50269562e-01f, -1.33324921e-01f, 6.03232440e-03f, 7.39161521e-02f, 1.83415413e-02f, 1.25291705e-01f,
  6.93045855e-02f, 2.08057567e-01f, 5.08967862e-02f, 1.43626243e-01f, -1.76298559e-01f, 6.06928132e-02f, 1.26317248e-01f, 1.65064052e-01f, 9.14915057e-04f, 1.26831874e-01f,
  7.00818514e-03f, -2.01035142e-02f, 2.20736250e-01f, -3.01573630e-02f, 2.23046631e-01f, 2.32288972e-01f, 1.20831123e-02f, 3.83286364e-02f, 1.44131601e-01f, -3.28977145e-02f,
  2.44727619e-02f, 7.71912746e-03f, 7.55090564e-02f, 2.15435829e-02f, 3.55058610e-02f, -2.38973759e-02f, 1.18746907e-02f, -1.64853912e-02f, -7.91348740e-02f, 8.47926289e-02f,
  2.99912412e-02f, -3.09235207e-03f, 8.96017477e-02f, -1.59719586e-01f, -1.17185414e-01f, -5.27886525e-02f, 5.28735509e-05f, 1.14276269e-02f, 7.15911537e-02f, 9.41580757e-02f,
  6.79827854e-02f, 6.64233267e-02f, 6.71719108e-03f, 7.81475976e-02f, 2.48523392e-02f, -1.15544870e-02f, 8.65696445e-02f, 3.92523743e-02f, 9.79022235e-02f, 3.39751132e-02f,
  -1.06612593e-02f, -1.61729511e-02f, 1.93417873e-02f, 1.11281676e-02f, -4.89510642e-03f, -3.23356465e-02f, -2.08380315e-02f, 4.37767617e-02f, -2.89662480e-02f, 6.64625363e-03f,
  -2.68202573e-02f, -1.46955894e-02f, -6.30978569e-02f, -1.01504818e-01f, 7.08540678e-02f, -1.19639505e-02f, -9.68328044e-02f, 7.00978115e-02f, 7.34516233e-02f, 4.84970515e-04f,
  -5.86557277e-02f, -7.45205134e-02f, 3.28522176e-02f, 7.82111138e-02f, -2.81711705e-02f, -3.87723418e-03f, 7.29302391e-02f, 2.63444446e-02f, -4.13326621e-02f, -1.93632264e-02f,
  6.80245981e-02f, 1.82375044e-01f, 3.36027821e-03f, -4.20340337e-02f, -7.86957983e-03f, -5.96103594e-02f, -5.08282222e-02f, 7.58845285e-02f, 4.52200025e-02f, -2.85456236e-02f,
  1.19484551e-02f, 4.78283092e-02f, -4.57928590e-02f, -9.44882110e-02f, -8.08031019e-03f, -4.76716310e-02f, -1.49029598e-03f, -7.73186386e-02f, 4.97478321e-02f, 9.43892002e-02f,
  8.04501399e-02f, -5.33197336e-02f, 7.59659931e-02f, -2.18496867e-03f, 6.08192086e-02f, 8.61250684e-02f, -7.85637833e-03f, 1.74564719e-02f, 3.38351279e-02f, 2.31632572e-02f,
  -3.94996643e-01f, 3.84261638e-01f, 1.98394507e-01f, 1.35167599e-01f, -3.39119196e-01f, -1.37029126e-01f, 2.21218750e-01f, -1.04198612e-01f, 1.27274171e-01f, 3.05202186e-01f,
  -7.72308186e-02f, 1.02523319e-01f, 7.52025691e-04f, 2.17247084e-01f, -4.45699513e-01f, 1.60782427e-01f, 9.99096856e-02f, 1.00085624e-01f, -6.92724735e-02f, -1.26401009e-02f,
  -8.31198990e-02f, -1.94064915e-01f, -5.63420542e-03f, -1.28901675e-01f, -1.03414543e-01f, 8.23667049e-02f, -4.19785641e-02f, 2.40744445e-02f, 1.64525991e-04f, -7.94487223e-02f,
  -2.18969807e-01f, -5.96102653e-03f, 1.00296661e-01f, -5.53817265e-02f, 1.67570729e-02f, -2.26658154e-02f, 5.72146289e-02f, 4.60528359e-02f, 6.71362057e-02f, 2.31320560e-02f,
  -1.96363945e-02f, -1.37198433e-01f, -2.31076963e-02f, 5.05383462e-02f, -1.67574473e-02f, 2.28682291e-02f, 2.23981086e-02f, -3.48378941e-02f, -6.91776797e-02f, -8.50223843e-03f,
  3.49164307e-02f, 4.95925918e-02f, 1.25202835e-02f, 1.07566901e-01f, -4.78484556e-02f, 3.34585533e-02f, 9.70158651e-02f, -1.39903156e-02f, 5.90831116e-02f, -1.44416228e-01f,
  2.86834892e-02f, 4.34420072e-03f, 4.93159443e-02f, -8.90589952e-02f, 2.55898165e-04f, 1.05477981e-02f, 7.00955465e-02f, -1.60987973e-01f, 1.46797955e-01f, -2.00503133e-03f,
  -1.12424709e-01f, -3.42523050e-03f, -1.03006057e-01f, 3.49139906e-02f, -1.99561547e-02f, 6.15319423e-02f, 5.24099506e-02f, -9.22293440e-02f, 8.57357904e-02f, -5.56472130e-02f,
  3.69352400e-02f, 9.00272429e-02f, -3.07182912e-02f, -2.25435793e-02f, 1.11987796e-02f, -3.44180502e-02f, -2.90489327e-02f, 6.36030063e-02f, -3.11265662e-02f, -2.89072841e-01f,
  -2.78897941e-01f, -1.96464851e-01f, -1.12915495e-02f, -1.68081477e-01f, 4.53527160e-02f, -4.08149362e-02f, 1.53552694e-02f, 1.00151278e-01f, -5.98828010e-02f, 5.71732447e-02f,
  2.14520060e-02f, -3.13428827e-02f, -2.81649660e-02f, 7.42788389e-02f, 1.39975417e-02f, -1.54078817e-02f, 4.51563671e-02f, 4.73275334e-02f, -1.02237083e-01f, 7.97163602e-03f,
  -7.85767362e-02f, 1.25418594e-02f, -5.18266931e-02f, -7.56361801e-03f, -2.59008836e-02f, -1.16344996e-01f, -2.53181793e-02f, 9.32941511e-02f, -1.22415461e-01f, 5.17646000e-02f,
  -2.84732729e-01f, 4.97995839e-02f, -2.66128898e-01f, -6.77555278e-02f, 2.86734760e-01f, 2.63517827e-01f, 2.11900566e-02f, 1.50446758e-01f, -2.11316422e-01f, 1.30388156e-01f,
  2.37993076e-01f, -1.94221791e-02f, -3.13602909e-02f, 3.35065633e-01f, 1.31074041e-01f, 9.31849331e-02f, 2.08296582e-01f, 1.35100827e-01f, -8.21145624e-02f, -1.61404938e-01f,
  -1.05456337e-01f, 3.59983683e-01f, 2.96207760e-02f, 5.92114404e-02f, 1.86886787e-01f, -2.39555672e-01f, 4.50478159e-02f, -1.60455495e-01f, 2.18325660e-01f, 9.98211727e-02f,
  6.79245219e-02f, -2.18067288e-01f, -1.05633855e-01f, -1.95085138e-01f, -1.26889516e-02f, -1.42157257e-01f, -1.51427478e-01f, -5.15823849e-02f, -1.26548752e-01f, 5.64142354e-02f,
  -1.37862787e-01f, 2.27676090e-02f, 1.20094724e-01f, -7.80778080e-02f, -9.97682363e-02f, -3.98478806e-02f, 1.16560578e-01f, -8.83860979e-03f, -4.54338500e-03f, 8.59408174e-04f,
  5.09074517e-02f, 8.75178427e-02f, -3.77321169e-02f, 6.04417324e-02f, 8.23417008e-02f, 4.89079431e-02f, -3.14091071e-02f, 4.31941915e-03f, 5.30304946e-02f, 8.37513804e-02f,
  3.49890999e-02f, -1.73145398e-01f, 2.44108923e-02f, 6.38387725e-02f, -9.11676604e-03f, 1.25266939e-01f, -2.98983641e-02f, 2.41196211e-02f, -2.10628539e-01f, 2.40539890e-02f,
  1.73386604e-01f, -1.67347621e-02f, -5.47168814e-02f, -1.44747674e-01f, -7.49386400e-02f, -1.39462268e-02f, -6.03629388e-02f, 6.78307097e-03f, 7.40201324e-02f, 8.86333734e-02f,
  -2.06548208e-03f, -5.43303713e-02f, 9.28480849e-02f, 1.52752101e-02f, -2.25348454e-02f, -7.53022879e-02f, -1.03323787e-01f, -6.92197978e-02f, 5.83273023e-02f, -8.64564907e-03f,
  -2.85490751e-02f, -2.29223236e-01f, -1.06653012e-01f, 9.23215076e-02f, -1.01349488e-01f, 3.09018996e-02f, -1.11402072e-01f, 1.50916591e-01f, -1.06820300e-01f, -2.34417189e-02f,
  -2.07315497e-02f, 3.21309082e-02f, -3.18318111e-04f, -1.03795066e-01f, -6.13429118e-03f, -1.58345252e-02f, -8.49373862e-02f, -1.73584804e-01f, -1.32432766e-02f, -4.85285558e-02f,
  -2.99619418e-03f, 4.14286405e-02f, -3.87252942e-02f, 8.92663598e-02f, 6.10592514e-02f, 1.15659006e-01f, 3.25124785e-02f, -3.79658863e-02f, 7.09748790e-02f, 1.02666751e-01f,
  -3.28349441e-01f, 2.93604493e-01f, 1.14789732e-01f, -3.10699940e-01f, 2.29883611e-01f, 6.08571758e-03f, -9.00259688e-02f, 2.52132624e-01f, 1.74020141e-01f, -1.33427292e-01f,
  -1.35158282e-02f, -8.08429811e-03f, 2.26066306e-01f, -1.70376375e-01f, -1.57015875e-01f, 5.70465513e-02f, -2.29969025e-01f, -2.56259710e-01f, 1.36484727e-01f, 4.02648235e-03f,
  9.21305642e-02f, 1.01777948e-02f, -1.25033438e-01f, 1.38511270e-01f, -3.83145036e-03f, -3.20758224e-02f, -2.08722040e-01f, 2.32146576e-01f, -2.30825379e-01f, 1.04314633e-01f,
  -1.34839192e-01f, -9.10765976e-02f, -1.70856208e-01f, -9.04072151e-02f, -1.44161940e-01f, -8.18192884e-02f, -1.09710202e-01f, 7.99363703e-02f, 1.25088496e-02f, 1.00542523e-01f,
  -1.60547893e-03f, 1.40930095e-03f, 2.72308607e-02f, 1.15153350e-01f, 6.34737983e-02f, 3.32625993e-02f, 5.94721967e-03f, -6.07742369e-02f, 1.45325378e-01f, 3.23396996e-02f,
  1.08059570e-01f, 2.28034928e-02f, -4.97082137e-02f, -9.68177915e-02f, 3.49240750e-02f, 8.27714335e-03f, -3.00343838e-02f, -6.19359873e-02f, -5.94767220e-02f, -1.05680875e-01f,
  -1.78622548e-03f, 2.22334210e-02f, -4.32825089e-02f, -2.30377372e-02f, 6.75821165e-03f, 6.73044175e-02f, 3.13388035e-02f, 1.29151838e-02f, -1.55849621e-01f, -6.35073632e-02f,
  -2.03102324e-02f, -8.58022645e-02f, 1.66709442e-02f, 4.99415211e-02f, 1.10223684e-02f, 1.00255646e-02f, -1.07362747e-01f, 1.39590114e-01f, 7.38584176e-02f, 8.02482973e-05f,
  -3.72887477e-02f, -6.92662131e-03f, -3.66764935e-03f, -1.65336002e-02f, -5.38698919e-02f, 6.58427700e-02f, -4.44392860e-02f, 5.30785248e-02f, -3.64748612e-02f, 1.38025075e-01f,
  -2.93621331e-01f, -2.64757156e-01f, -4.30971719e-02f, -1.41433999e-01f, -3.79548520e-02f, -5.85233755e-02f, -5.21383844e-02f, 5.89719042e-03f, -1.51315883e-01f, 2.00878009e-02f,
  1.84253212e-02f, -5.60411848e-02f, -2.35565156e-02f, -1.08664576e-02f, -1.20400442e-02f, 2.49782074e-02f, -3.78753915e-02f, 6.15650380e-04f, -1.18886560e-01f, -4.77310009e-02f,
  4.85613011e-02f, 2.46732999e-02f, -3.97044830e-02f, -2.85187066e-02f, 7.66306743e-02f, -6.52724281e-02f, -8.22480172e-02f, -4.33684252e-02f, -5.39397039e-02f, 3.95086594e-02f,
  2.61902601e-01f, -2.49640524e-01f, 1.40365228e-01f, -2.78124928e-01f, 1.85292703e-03f, -2.54998114e-02f, 4.43199500e-02f, -3.30700904e-01f, -2.73844689e-01f, -2.21546963e-01f,
  -2.49180272e-01f, 9.79123861e-02f, 1.60148591e-01f, -2.57068396e-01f, 3.78432184e-01f, 1.49799988e-01f, -2.47326642e-01f, -2.01034650e-01f, 2.57574674e-03f, -1.46303460e-01f,
  -8.62428546e-02f, -2.29948387e-01f, 7.29888380e-02f, -1.77171558e-01f, -8.57840329e-02f, -1.24885507e-01f, 1.77443214e-02f, 1.45356327e-01f, -1.89586639e-01f, 5.91178238e-02f,
  -3.70788872e-02f, -8.34383368e-02f, 1.28029427e-02f, 3.49107548e-03f, 1.97782237e-02f, 1.09409720e-01f, 7.42733330e-02f, 1.35333329e-01f, -9.73294582e-03f, -8.59213471e-02f,
  -3.75750251e-02f, -8.56584534e-02f, -1.27157778e-01f, 1.31435424e-01f, -1.39097661e-01f, -8.91848877e-02f, -7.90033638e-02f, -2.16369759e-02f, -8.03045109e-02f, 1.43151775e-01f,
  -9.81804170e-03f, -3.01063969e-03f, 3.58057348e-03f, 1.22248149e-03f, 2.38201674e-02f, -1.10449173e-01f, 7.88856000e-02f, 1.35967359e-01f, -6.35429248e-02f, 1.29074473e-02f,
  -7.29452074e-02f, 8.93993005e-02f, 9.06856880e-02f, 4.44832584e-03f, 1.93333030e-02f, 7.52950646e-03f, 6.33425117e-02f, 5.00214659e-02f, 1.16205379e-01f, -8.91937017e-02f,
  -6.20446540e-02f, 1.47231957e-02f, -2.46136021e-02f, -2.65845153e-02f, -3.60926017e-02f, 5.47643378e-02f, 6.11921102e-02f, 2.25116964e-02f, -9.85791758e-02f, 1.05832331e-02f,
  4.75550219e-02f, -3.56746651e-02f, 4.99321297e-02f, -1.29381418e-01f, -1.19126104e-01f, -7.97730777e-03f, 7.32647628e-03f, -9.72109661e-03f, -1.32139139e-02f, 4.26380336e-02f,
  3.02625280e-02f, -1.73555478e-01f, -9.51699317e-02f, -2.56785378e-02f, 3.54857966e-02f, 9.41238627e-02f, 9.08241123e-02f, -9.79858339e-02f, -5.02777919e-02f, 8.64057429e-03f,
  -9.41892192e-02f, -3.90726030e-02f, -6.97476119e-02f, 6.38644546e-02f, -1.06265485e-01f, 5.50653553e-03f, -1.03383884e-01f, -4.16377410e-02f, -1.18259318e-01f, -9.54606291e-03f,
  -7.02697635e-02f, -1.23248346e-01f, 2.15285942e-02f, 3.68801765e-02f, -1.36783585e-01f, -7.92478621e-02f, 5.41886501e-02f, -1.68158785e-02f, 2.64786035e-02f, 1.68255214e-02f,
  7.47470185e-02f, -4.00249839e-01f, 1.81007579e-01f, 3.91849875e-01f, 3.80058400e-02f, -1.73526525e-01f, 1.11399956e-01f, -4.00273427e-02f, 1.61362037e-01f, -3.63304257e-01f,
  6.87009320e-02f, -1.31609112e-01f, -7.43925050e-02f, -3.32437381e-02f, 1.63142383e-01f, 2.44401284e-02f, 1.42021254e-01f, 4.78883311e-02f, 1.33512065e-01f, 5.45267239e-02f,
  1.49302661e-01f, -9.07182321e-02f, 1.07493334e-01f, -8.40438902e-02f, 3.13240141e-02f, 7.00769871e-02f, 5.19427247e-02f, 1.63532287e-01f, 1.37512209e-02f, -5.53037971e-03f,
  -6.93237484e-02f, 7.51816705e-02f, -6.63045645e-02f, -2.68177632e-02f, 6.26157224e-03f, -6.24791645e-02f, -5.41385263e-02f, 1.84985660e-02f, 2.38494158e-01f, 3.49774882e-02f,
  -5.90668768e-02f, 3.01059248e-04f, -1.42749241e-02f, 2.46322453e-02f, 5.86971231e-02f, 9.83132571e-02f, -2.33016741e-02f, 5.96835352e-02f, -4.89702635e-03f, -2.90006176e-02f,
  1.56200221e-02f, -1.00349374e-02f, 9.92480889e-02f, -5.46111278e-02f, 4.05380391e-02f, 4.90858182e-02f, -1.45121133e-02f, -1.14905415e-02f, 7.85916392e-03f, 7.22162277e-02f,
  -9.33317319e-02f, -5.63219860e-02f, -4.66489121e-02f, 8.62508168e-05f, 1.09954186e-01f, 1.14698932e-01f, 1.59544162e-02f, -4.55260836e-02f, 1.19443685e-01f, -2.31554825e-02f,
  -2.99869683e-02f, -6.73873723e-02f, 1.93947051e-02f, 5.30579612e-02f, -9.70289577e-03f, -6.91370592e-02f, 6.75441772e-02f, -4.90402244e-02f, 1.61803830e-02f, 5.92564419e-02f,
  -2.19561048e-02f, -1.32889021e-02f, -4.40077186e-02f, 3.99960093e-02f, 3.96011695e-02f, 8.87109563e-02f, -5.37668616e-02f, 8.16497132e-02f, 7.62479901e-02f, 6.90794960e-02f,
  -1.54348984e-01f, -1.00109063e-01f, -7.19290152e-02f, -6.14877492e-02f, 4.77206819e-02f, -1.05747834e-01f, -6.24375045e-03f, -8.13164636e-02f, 1.19391970e-01f, -1.61366779e-02f,
  -6.90740421e-02f, 1.11654870e-01f, 1.05960593e-02f, 1.39557123e-01f, -1.73382033e-02f, -5.87400533e-02f, 6.08231965e-03f, 1.41883371e-02f, -6.76095560e-02f, -8.29759166e-02f,
  -1.34289050e-02f, 4.77346070e-02f, 7.03008696e-02f, 4.01355475e-02f, -2.41220426e-02f, -9.70825404e-02f, 3.18689999e-04f, 4.21129800e-02f, 1.37892785e-02f, 1.39960591e-02f,
  1.62332758e-01f, -6.95075095e-02f, -1.20445013e-01f, -2.30885558e-02f, 1.29192233e-01f, 1.54894277e-01f, -1.01049811e-01f, -7.75160491e-02f, -1.77564129e-01f, 9.26410481e-02f,
  -5.11134975e-02f, -1.38140703e-02f, -2.06321657e-01f, 4.48597502e-03f, 1.06598295e-01f, -2.98296779e-01f, 1.68384090e-01f, -3.64436209e-02f, -1.01352043e-01f, 2.34634668e-01f,
  7.44221732e-02f, 2.33249441e-01f, -1.56079680e-01f, 2.15117335e-01f, 1.01877376e-01f, 8.36252272e-02f, 2.04257533e-01f, -8.50620940e-02f, 1.81496754e-01f, 4.73706098e-03f,
  -1.07376896e-01f, -5.40837310e-02f, -6.06500693e-02f, -1.12990160e-02f, 7.07306862e-02f, 1.07263967e-01f, 8.04420654e-03f, -7.27004856e-02f, -1.29233718e-01f, -1.55626372e-01f,
  -2.71471590e-03f, -7.07820505e-02f, -2.22080648e-02f, 2.67544156e-03f, 1.22690480e-02f, -1.16760768e-02f, -2.25979183e-02f, -9.34215784e-02f, -7.75548667e-02f, 3.42322774e-02f,
  -4.83125001e-02f, 1.10968407e-02f, 4.47897660e-03f, -1.09147644e-02f, 7.16028735e-02f, 4.29964438e-02f, 8.42387602e-02f, 6.48101196e-02f, -4.00166549e-02f, 7.19021410e-02f,
  2.12378595e-02f, 1.92738429e-03f, 5.30342385e-02f, -9.34050828e-02f, 5.20524100e-06f, -8.68879631e-02f, 5.30079706e-04f, 2.37851255e-02f, 1.81724895e-02f, 4.58061136e-03f,
  5.88384420e-02f, -1.82744823e-02f, -8.28259364e-02f, 1.38520017e-01f, 8.46076682e-02f, 3.13681178e-02f, -2.58308034e-02f, 2.65796781e-02f, 1.40225723e-01f, -5.68956770e-02f,
  -1.36052161e-01f, 9.57600474e-02f, -1.55834146e-02f, -8.65403190e-02f, -9.30134952e-02f, 3.49518284e-02f, 7.31258467e-02f, -2.29886528e-02f, -1.23812720e-01f, 1.19842328e-02f,
  -2.37530209e-02f, 1.83100447e-01f, -1.24161048e-02f, 1.02333799e-02f, -5.20954579e-02f, 1.89527750e-01f, 5.62720886e-03f, 4.82677147e-02f, 1.09475721e-02f, 8.10745135e-02f,
  1.30186751e-01f, -4.93882187e-02f, 1.03070498e-01f, 2.21439157e-04f, -4.38882448e-02f, 5.57272844e-02f, 2.07242239e-02f, -2.43216008e-02f, -1.12759313e-02f, 8.10790583e-02f,
  5.07487245e-02f, 6.36377484e-02f, -2.12642159e-02f, 2.95327678e-02f, 3.07077747e-02f, 1.55615043e-02f, 1.75828207e-02f, 5.94170168e-02f, 7.45360879e-03f, -3.98921110e-02f,
  -2.99955849e-02f, -1.57024723e-03f, -1.27887174e-01f, -1.49812177e-01f, -1.06492221e-01f, -1.79249704e-01f, -8.08526352e-02f, -4.34507653e-02f, 7.51972497e-02f, 5.89579567e-02f,
  -1.22154102e-01f, 1.23030774e-01f, 1.63049981e-01f, -2.94861287e-01f, -2.91547149e-01f, 2.25949194e-02f, -2.42567986e-01f, 4.07189578e-02f, 7.95120597e-02f, -6.89057931e-02f,
  -1.13896534e-01f, -1.35582879e-01f, -1.83293834e-01f, -7.65805244e-02f, -2.06500769e-01f, 2.54199691e-02f, -3.80029529e-02f, -1.06310360e-01f, -1.35108590e-01f, -1.21033631e-01f,
  -4.30879071e-02f, 1.14028659e-02f, 3.21450680e-02f, 9.66534391e-02f, -3.81603949e-02f, -4.93753403e-02f, 2.30122060e-02f, 4.75139841e-02f, 6.87495545e-02f, -1.80030391e-02f,
  1.29808038e-01f, 1.37884483e-01f, -2.32412922e-03f, -1.37202412e-01f, 6.97577149e-02f, 4.39013131e-02f, 1.16090775e-01f, 1.23129904e-01f, 1.49011761e-01f, -1.06716760e-01f,
  -1.55680040e-02f, 7.44440928e-02f, 9.89352260e-03f, 2.53046095e-01f, 1.06144540e-01f, 5.80162331e-02f, -3.37865949e-02f, 2.02539209e-02f, 4.46478464e-02f, -2.43582539e-02f,
  -8.86548012e-02f, 2.35772915e-02f, -5.63030578e-02f, -5.89609668e-02f, -3.73808891e-02f, 4.65738252e-02f, 2.13679159e-03f, -1.00901537e-01f, 3.32053602e-02f, 6.63599446e-02f,
  8.26603025e-02f, 5.73527515e-02f, 5.37643433e-02f, 7.20305368e-02f, -1.26305088e-01f, 6.06867447e-02f, 3.69661376e-02f, 8.32098052e-02f, -9.08926874e-02f, 7.61871859e-02f,
  -7.94186199e-04f, -3.74657623e-02f, 4.30782996e-02f, -4.13837358e-02f, -2.14275029e-02f, 1.35238498e-01f, 1.05160236e-01f, 2.96413596e-03f, 4.74450290e-02f, -2.12853920e-04f,
  8.32128397e-04f, 1.09168351e-01f, 4.54971269e-02f, 1.28711462e-01f, 5.58331870e-02f, -1.38579413e-01f, -9.07034501e-02f, 3.48793976e-02f, 3.31956595e-02f, -5.91919944e-02f,
  3.26338522e-02f, 1.20105088e-01f, 1.47304296e-01f, -9.04176980e-02f, 2.00620200e-03f, 1.20700253e-02f, 1.53948486e-01f, 2.12766349e-01f, 5.87258339e-02f, 2.53890059e-03f,
  1.65096670e-01f, 6.47741854e-02f, 1.24271512e-01f, 1.76022053e-01f, 1.13311715e-01f, 1.31510869e-01f, 1.56572070e-02f, -4.12740745e-02f, 3.74095328e-02f, 5.71960919e-02f,
  -4.34497088e-01f, 2.80285060e-01f, 2.15639383e-01f, 1.71781343e-03f, -1.94076195e-01f, 8.65347236e-02f, 7.78496936e-02f, 7.22297281e-02f, 2.28562728e-01f, 2.36161411e-01f,
  -3.49389650e-02f, 1.56467795e-01f, 9.29934829e-02f, 1.68586135e-01f, -3.25571895e-01f, 5.58295287e-02f, -6.48606047e-02f, 2.62749922e-02f, 1.36054261e-02f, 1.22641241e-02f,
  -6.41951710e-02f, -8.91464800e-02f, -4.72325496e-02f, 1.05669945e-01f, -5.07458039e-02f, 5.74088544e-02f, -2.41764784e-01f, 1.08554279e-02f, -1.24386460e-01f, -7.04217702e-02f,
  -2.45438650e-01f, 3.03715058e-02f, -1.24702774e-01f, -9.65808034e-02f, -1.03447296e-01f, 6.77057961e-03f, -4.14239056e-02f, -6.18311875e-02f, 4.89658788e-02f, 5.97711280e-02f,
  2.44516996e-04f, 3.02487686e-02f, -4.22894657e-02f, 9.56435576e-02f, -8.81099179e-02f, 7.18580112e-02f, 7.77689442e-02f, 8.67548585e-02f, 2.33998317e-02f, 8.35820362e-02f,
  1.30564719e-01f, -4.73530889e-02f, -1.12480298e-01f, -2.11341325e-02f, -1.06383719e-01f, 4.06136215e-02f, 1.98795162e-02f, -7.12287799e-02f, -5.30525818e-02f, -9.59739164e-02f,
  1.54005643e-02f, 2.78792735e-02f, -5.09874662e-03f, -3.86651000e-03f, -1.10378889e-02f, -8.23374018e-02f, -3.55087630e-02f, -1.08320139e-01f, 9.79153216e-02f, 2.38040742e-02f,
  -5.07721789e-02f, -2.33682171e-02f, 5.94128482e-02f, 4.32863869e-02f, 2.48240251e-02f, -2.24385094e-02f, -8.24811459e-02f, -7.12407520e-03f, -5.75872138e-02f, -1.08455643e-02f,
  3.90657485e-02f, 2.22070795e-02f, 7.06770271e-02f, -1.00182705e-01f, -1.11058392e-02f, 1.56123610e-02f, 5.96419387e-02f, 1.04440667e-01f, -4.50571291e-02f, -3.14468406e-02f,
  -3.58361483e-01f, -1.98926553e-01f, -6.15059696e-02f, -8.36106390e-02f, -3.27965356e-02f, -2.49211509e-02f, 7.19546452e-02f, -9.71765295e-02f, -2.49874988e-03f, -7.83350319e-03f,
  -2.23626085e-02f, -3.64120789e-02f, -3.39357071e-02f, 3.09476070e-02f, -3.23873833e-02f, 2.91624963e-02f, -4.23583053e-02f, 6.28774688e-02f, -1.40856653e-01f, -7.14039728e-02f,
  -1.34207278e-01f, -8.63984674e-02f, -6.54677972e-02f, -9.36593264e-02f, -1.01626024e-01f, -1.26882523e-01f, -2.28484422e-02f, 6.34977743e-02f, -6.80310950e-02f, -1.67550449e-03f,
  1.93056777e-01f, -1.65076330e-01f, 2.81392522e-02f, 1.91571951e-01f, -1.29222840e-01f, 1.14223398e-01f, 3.72704297e-01f, -9.55656543e-02f, -4.69376370e-02f, 3.40284109e-02f,
  1.32156014e-01f, 6.73446506e-02f, 1.10915825e-01f, 2.03547448e-01f, 2.43354708e-01f, 8.13641176e-02f, 2.02810362e-01f, 1.93626434e-01f, -1.16636992e-01f, 7.59910271e-02f,
  2.44017523e-02f, 1.08728752e-01f, 1.50142133e-01f, -2.17573628e-01f, 1.95603315e-02f, -1.13960497e-01f, 2.62289811e-02f, 2.38249786e-02f, 1.08986981e-02f, 8.57334882e-02f,
  -5.79525977e-02f, -5.96434250e-02f, -4.55116779e-02f, -4.81929518e-02f, -4.66229543e-02f, -9.63626802e-03f, -3.59196812e-02f, 1.01197414e-01f, 1.54972207e-02f, 3.05489767e-02f,
  5.98070286e-02f, 1.54877622e-02f, -2.47309660e-03f, -1.72272231e-02f, -1.80889608e-03f, -5.09375446e-02f, -5.19930013e-02f, -3.88287120e-02f, -4.40994985e-02f, 1.39605533e-02f,
  -2.91229598e-02f, -2.30523441e-02f, 4.41619148e-03f, -2.67657097e-02f, -8.16829950e-02f, 3.49470228e-03f, 2.91537717e-02f, 3.14792655e-02f, -1.38338413e-02f, -9.45892707e-02f,
  1.02278665e-01f, -8.59723389e-02f, -1.05116365e-03f, -3.81836481e-02f, -3.19528580e-02f, -4.84816618e-02f, -1.17624309e-02f, 2.12773941e-02f, -3.74507569e-02f, 3.01008765e-02f,
  1.75843388e-03f, 2.14295723e-02f, -3.46671697e-03f, 6.56932965e-02f, 1.76100992e-02f, -6.04640506e-02f, 9.11317840e-02f, 6.79446897e-03f, -1.70403775e-02f, 2.51878309e-03f,
  2.47822497e-02f, 8.41260776e-02f, -6.20592386e-03f, 1.00408338e-01f, 6.89648986e-02f, -3.07359044e-02f, -2.76246052e-02f, 1.40528940e-02f, -5.83392270e-02f, 6.93536326e-02f,
  -5.77237383e-02f, 1.28690889e-02f, 2.67568454e-02f, -4.88677472e-02f, -4.37987745e-02f, -2.75244773e-03f, -3.72914784e-02f, -1.83805414e-02f, 8.37436691e-02f, 2.71659438e-02f,
  -5.20732738e-02f, -1.39814895e-02f, -1.15943357e-01f, -6.73072338e-02f, 5.09540141e-02f, -4.54144739e-02f, 7.33001530e-02f, -7.35075474e-02f, 3.72362360e-02f, 5.45559544e-03f,
  5.88083975e-02f, 4.54865620e-02f, -1.74475200e-02f, -1.32804513e-01f, -1.10055013e-02f, -3.66415572e-03f, -5.93431331e-02f, -2.86838803e-02f, 2.42261775e-02f, 2.14451849e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 104)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 104;
const float L0_fan_Bp_bar_data[] = {
  1.81143224e-01f, 2.34935269e-01f, 1.87493697e-01f, 2.96863109e-01f, 1.67648435e-01f, 3.27704400e-01f, 9.80938151e-02f, 1.48700759e-01f, 2.97297955e-01f, 2.24750981e-01f,
  1.83745101e-01f, 2.77507991e-01f, 1.83917627e-01f, 1.61666021e-01f, 1.42823771e-01f, 2.02393472e-01f, 2.26870492e-01f, 2.47036695e-01f, 1.38169527e-01f, 2.12110713e-01f,
  2.83701092e-01f, 1.31229237e-01f, 1.27665430e-01f, 1.19207598e-01f, 4.72184606e-02f, 3.41948837e-01f, 2.32599184e-01f, 2.40277156e-01f, 1.69104531e-01f, 2.22249866e-01f,
  1.70703545e-01f, 1.47784814e-01f, 2.08755106e-01f, 3.32564443e-01f, 9.08791870e-02f, 1.17486775e-01f, 2.91400582e-01f, 3.21226567e-01f, 1.21460117e-01f, 1.20339088e-01f,
  2.66899377e-01f, 1.34093180e-01f, 2.72264034e-01f, 1.88778996e-01f, 3.00624937e-01f, 1.35318637e-01f, 2.18546420e-01f, 2.00453803e-01f, 9.70068872e-02f, 1.89308956e-01f,
  2.83602387e-01f, 1.08293205e-01f, 1.43652648e-01f, 3.48582029e-01f, 1.94607496e-01f, 3.30290973e-01f, 1.82262734e-01f, 1.01515464e-01f, 2.29583591e-01f, 1.06245995e-01f,
  2.42208377e-01f, 8.78454521e-02f, 2.90890604e-01f, 2.26766333e-01f, 3.12208772e-01f, 2.59197474e-01f, 1.58358783e-01f, 9.39717367e-02f, 1.88748062e-01f, 2.82156080e-01f,
  2.90486813e-01f, 3.11883956e-01f, 1.38259813e-01f, 8.44002813e-02f, 1.58086032e-01f, 1.59894139e-01f, 8.14558268e-02f, 2.19770446e-01f, 2.38775745e-01f, 2.07307369e-01f,
  1.80341989e-01f, 1.51893809e-01f, 1.65764451e-01f, 1.40739441e-01f, 2.29581490e-01f, 2.17513710e-01f, 2.83773392e-01f, 2.47140512e-01f, 1.22562990e-01f, 1.10231616e-01f,
  2.39157185e-01f, 1.74064383e-01f, 2.19801247e-01f, 2.48799205e-01f, 1.68252423e-01f, 2.22310320e-01f, 6.30606040e-02f, 8.15542787e-02f, 2.34089166e-01f, 1.78991839e-01f,
  2.37427935e-01f, 2.26313978e-01f, 2.54655093e-01f, 2.31667534e-01f
};

// L1_linear_W (Shape: 12 x 128)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 128;
const float L1_linear_W_data[] = {
  -1.58183411e-01f, 2.59471359e-03f, -2.70559043e-01f, -3.28767806e-01f, 3.31249787e-03f, -2.43176408e-02f, -3.80568832e-01f, 6.23734668e-02f, 6.21676771e-03f, 1.35681838e-01f,
  -2.15707421e-01f, -1.43298740e-02f, -2.81148374e-01f, -4.00042254e-03f, -2.29027152e-01f, 2.90582895e-01f, 1.44588947e-01f, 2.48782620e-01f, 2.38056138e-01f, -2.25053459e-01f,
  -1.70453519e-01f, -1.28752356e-02f, -2.76824147e-01f, 1.83820695e-01f, 3.87384027e-01f, 2.92100608e-01f, -3.72075289e-02f, -2.48416737e-01f, 5.73228970e-02f, -2.68333524e-01f,
  -2.59440485e-02f, -2.51017213e-01f, -2.24456310e-01f, -4.54194218e-01f, -2.01260522e-01f, -4.88059044e-01f, -3.72502446e-01f, -1.52926907e-01f, -8.97485167e-02f, -2.68013656e-01f,
  -1.42518654e-01f, -2.42496178e-01f, 1.86727181e-01f, 1.45526007e-01f, -9.33887139e-02f, -1.95288479e-01f, 4.86764044e-01f, 1.13379732e-01f, 8.56849700e-02f, -2.02897757e-01f,
  -3.91138703e-01f, -9.61000696e-02f, -1.38753816e-01f, 3.05820256e-01f, -2.95606226e-01f, -2.33077630e-01f, -1.06457844e-01f, 3.04929882e-01f, 3.39034684e-02f, -8.27903077e-02f,
  3.25169146e-01f, 2.32697949e-01f, 3.80660929e-02f, 1.21957771e-01f, -3.06905001e-01f, -1.15756959e-01f, -9.98816639e-02f, -2.06884444e-01f, 1.96069852e-01f, 4.24953271e-03f,
  -1.46648601e-01f, 2.58784592e-01f, -1.52040735e-01f, -3.04452106e-02f, -2.59410322e-01f, -1.23201869e-01f, -7.99957514e-02f, -3.72723073e-01f, 3.08745444e-01f, -2.86132604e-01f,
  -2.66677082e-01f, 4.19113755e-01f, 2.32851878e-01f, 3.08244079e-01f, 1.79176450e-01f, -3.25037569e-01f, -2.57538348e-01f, -1.94022477e-01f, -5.40448308e-01f, 3.81560028e-02f,
  3.63448448e-02f, -1.26789019e-01f, 5.57326317e-01f, 1.22307405e-01f, -2.16862261e-01f, -3.29442799e-01f, -5.40581532e-02f, 3.35335314e-01f, -2.45940357e-01f, -1.40647054e-01f,
  3.09637576e-01f, 3.70665252e-01f, -3.67590606e-01f, 2.69026548e-01f, -2.03048661e-02f, -1.22891225e-01f, -1.50791973e-01f, 1.84863657e-01f, -1.79902971e-01f, -2.62776703e-01f,
  -2.32441336e-01f, 6.83315098e-02f, -2.73128748e-02f, -3.02145779e-01f, -1.83547914e-01f, -3.66526321e-02f, 1.37509406e-02f, -2.77771354e-01f, 1.20104209e-01f, 5.20046473e-01f,
  1.66618973e-01f, -2.55720466e-01f, -3.26000810e-01f, 1.18840905e-02f, -1.94526374e-01f, -2.48699427e-01f, 2.05671147e-01f, 7.95326680e-02f, 2.24007331e-02f, -1.21871769e-01f,
  -1.23945720e-01f, 5.07905245e-01f, 7.90294930e-02f, 1.95923075e-01f, -2.59382967e-02f, -1.78587317e-01f, -1.83243956e-02f, -1.76886067e-01f, -6.39209582e-04f, -2.85612512e-02f,
  -7.61754289e-02f, -3.47288996e-02f, -2.98032373e-01f, 2.73802161e-01f, -2.19226182e-01f, 3.04691792e-02f, 1.78427905e-01f, 4.44418043e-01f, -2.42065728e-01f, -2.66191393e-01f,
  5.07477641e-01f, 1.28400698e-01f, -4.19770926e-01f, 3.92648429e-02f, -2.47532353e-01f, -2.07907096e-01f, -4.12176102e-01f, -2.09128931e-01f, -3.46958905e-01f, -1.67391106e-01f,
  2.08204672e-01f, 1.43386841e-01f, -3.38846892e-01f, -5.08300625e-02f, 1.59987643e-01f, -1.21753402e-01f, -2.67784297e-01f, -2.64360994e-01f, -3.95453095e-01f, -4.56888139e-01f,
  3.89024884e-01f, -3.81093293e-01f, -7.13700950e-02f, 3.33020508e-01f, -3.34685385e-01f, -3.57209593e-01f, -1.09337740e-01f, -2.26862445e-01f, -8.69299397e-02f, -1.49024993e-01f,
  -2.10292321e-02f, 2.63583511e-01f, 8.85630101e-02f, 1.84493825e-01f, 2.71559916e-02f, -4.08528030e-01f, 1.07653782e-01f, -4.10767853e-01f, -3.68856549e-01f, 1.94932252e-01f,
  4.88824099e-02f, 5.35087436e-02f, -3.12690169e-01f, 8.24907422e-02f, 1.87884480e-01f, 9.16904435e-02f, 3.75899106e-01f, 2.87476212e-01f, -2.72545993e-01f, 3.18405122e-01f,
  -1.88345294e-02f, -9.73284021e-02f, -3.10769230e-01f, 4.75962348e-02f, -4.87459525e-02f, 3.36906403e-01f, -4.77561742e-01f, -3.72205883e-01f, 2.66945571e-01f, 3.06335002e-01f,
  2.83891410e-01f, 4.16133404e-01f, -2.66933769e-01f, -1.15676202e-01f, -4.46095178e-03f, -8.34974274e-02f, -3.55022728e-01f, 3.94042023e-02f, 3.81251603e-01f, -1.53538316e-01f,
  5.70915714e-02f, -4.81582403e-01f, -5.72281897e-01f, 1.90350249e-01f, 1.98721126e-01f, -1.99003279e-01f, 4.42801654e-01f, 5.77496663e-02f, 3.78166616e-01f, -4.20596212e-01f,
  4.14838940e-02f, -5.39120972e-01f, 7.41848126e-02f, -3.15799683e-01f, -5.12267165e-02f, -3.19729537e-01f, 2.71005362e-01f, -1.57668442e-01f, 1.30199775e-01f, -3.28213215e-01f,
  1.41777992e-02f, -5.73162198e-01f, -1.53948262e-01f, -2.52187163e-01f, 3.11883867e-01f, -3.43836993e-01f, -3.76349464e-02f, -4.84354287e-01f, 4.60175157e-01f, -2.48781502e-01f,
  1.21468328e-01f, -5.48816383e-01f, 2.04702884e-01f, -4.16583985e-01f, -2.45104730e-01f, 1.73196137e-01f, -7.68037736e-02f, -2.13577539e-01f, -2.35703252e-02f, -3.30106497e-01f,
  -2.56547064e-01f, -2.37415224e-01f, -1.70594692e-01f, 3.00071668e-02f, -2.03604415e-01f, -1.53827807e-02f, 4.47144695e-02f, 2.62412857e-02f, 2.28428751e-01f, 3.25797349e-01f,
  3.04838389e-01f, -1.97071373e-01f, -2.18966305e-02f, 1.29830852e-01f, -4.41525877e-02f, -5.37412539e-02f, 2.96525240e-01f, -1.72428668e-01f, -4.67087346e-04f, 1.06133267e-01f,
  -1.32704616e-01f, -2.11296976e-02f, 1.42363682e-01f, -2.74133459e-02f, -9.46232155e-02f, 1.84059381e-01f, 8.65628049e-02f, -2.64172286e-01f, 7.84158036e-02f, 2.49183953e-01f,
  1.54083684e-01f, -2.70305187e-01f, 1.53377756e-01f, 3.42578918e-01f, 1.83009520e-01f, -3.16643059e-01f, 3.01052541e-01f, -2.43165433e-01f, -1.96723506e-01f, -2.24600941e-01f,
  8.03644061e-02f, -3.23446214e-01f, -9.73769873e-02f, -1.02659300e-01f, -1.26625553e-01f, 3.10094625e-01f, -1.45497829e-01f, -2.30323836e-01f, -2.49988005e-01f, -4.06707404e-03f,
  3.26299280e-01f, -2.16373906e-01f, -6.00704402e-02f, -2.68527362e-02f, -1.42682567e-01f, 4.03309554e-01f, -2.04428196e-01f, -3.95776421e-01f, 4.62405570e-02f, -4.75664705e-01f,
  -2.48301134e-01f, 3.42054844e-01f, -4.18743312e-01f, -1.02555424e-01f, -4.81503516e-01f, 3.10531557e-02f, -1.60082325e-01f, 2.53510296e-01f, -3.25897746e-02f, -1.20164618e-01f,
  -1.73581481e-01f, -3.34202386e-02f, 1.21858045e-01f, 2.10675806e-01f, -1.95775688e-01f, -2.81721830e-01f, 1.11246236e-01f, 5.28308228e-02f, 1.84625596e-01f, -2.38249689e-01f,
  -2.10029617e-01f, -1.27155051e-01f, -1.80821672e-01f, -1.15688518e-01f, -2.73352087e-01f, -3.23384643e-01f, 3.99015576e-01f, -9.96441171e-02f, -2.32559711e-01f, -3.16360071e-02f,
  4.24427629e-01f, -3.89268339e-01f, -1.71307191e-01f, -1.06906489e-01f, 1.13793731e-01f, 1.93207651e-01f, 3.61796558e-01f, -1.27507955e-01f, -5.48725687e-02f, -1.40927106e-01f,
  -8.62896144e-02f, 3.32311273e-01f, -2.26317775e-02f, -8.57376158e-02f, -2.33502477e-01f, -3.10555816e-01f, -1.37198985e-01f, -1.40333503e-01f, 2.86470000e-02f, 3.31120074e-01f,
  -2.95388877e-01f, -2.42809221e-01f, 4.02516663e-01f, 9.36433002e-02f, -2.95948118e-01f, -1.18853256e-01f, 2.40813866e-01f, -1.77029163e-01f, -4.36122417e-01f, 1.27676710e-01f,
  1.04402468e-01f, -4.74126823e-02f, -1.30483702e-01f, 1.39778210e-02f, 1.97701290e-01f, 9.08999145e-02f, -5.54941073e-02f, -1.34774417e-01f, -3.37231666e-01f, -9.46710855e-02f,
  -1.47247598e-01f, -2.38886103e-01f, 4.84478176e-02f, -2.65200078e-01f, -8.64606947e-02f, 1.28405243e-02f, -2.58710802e-01f, -2.94651955e-01f, -1.64760321e-01f, 1.69835642e-01f,
  -1.10462435e-01f, -9.25178900e-02f, -3.76462817e-01f, -3.97567600e-02f, 2.89172739e-01f, 2.53852129e-01f, 1.78730935e-01f, -8.91145244e-02f, 4.02131557e-01f, -1.20379604e-01f,
  2.70717591e-01f, 3.31373096e-01f, 4.03926909e-01f, 9.72628891e-02f, -2.63358951e-01f, -1.30211964e-01f, -1.78051859e-01f, -2.82887995e-01f, -1.59970522e-01f, -4.58773337e-02f,
  -1.62937120e-01f, -1.53264999e-01f, 4.03423637e-01f, -2.26087749e-01f, -2.15351865e-01f, 1.48827687e-01f, -4.13970836e-03f, 2.69149363e-01f, -5.15413165e-01f, 6.14752360e-02f,
  -1.46248536e-02f, 3.98542017e-01f, 4.53578740e-01f, -4.89722826e-02f, 1.33450463e-01f, -3.53975654e-01f, -3.50626737e-01f, 7.34916404e-02f, -5.66579700e-02f, -9.98909865e-03f,
  6.24863468e-02f, -4.13917691e-01f, -1.72758982e-01f, -5.63349016e-02f, 2.35230736e-02f, -3.61931652e-01f, -7.06696063e-02f, 2.43836403e-01f, -4.86418962e-01f, 7.56476149e-02f,
  -2.53581136e-01f, 4.07488704e-01f, -2.18348578e-01f, -1.22157365e-01f, -8.24924260e-02f, -2.58908778e-01f, -1.39582276e-01f, -2.96915043e-02f, 4.16070998e-01f, -1.99176520e-01f,
  -1.57250419e-01f, -9.90331173e-02f, -5.93948774e-02f, 1.92298889e-02f, -2.20573723e-01f, -1.57158747e-01f, -1.88829601e-01f, -2.39530042e-01f, 2.95386046e-01f, -1.90797560e-02f,
  -4.20767039e-01f, -7.10977986e-02f, 2.82441359e-02f, -3.77536744e-01f, -4.57086116e-01f, -6.98748082e-02f, -2.52364695e-01f, -2.18121246e-01f, -2.97014862e-01f, -2.69588262e-01f,
  -2.97381490e-01f, -4.47456747e-01f, 7.10112751e-02f, -1.11191683e-01f, -1.70093626e-01f, 3.94613028e-01f, -1.39367804e-01f, 2.89733410e-01f, -2.08867297e-01f, -2.69397706e-01f,
  -1.97435468e-01f, -3.39766830e-01f, 3.80930841e-01f, -4.56148684e-01f, 7.82844424e-02f, 2.49502063e-03f, -6.54217377e-02f, -1.23166569e-01f, 5.53901136e-01f, -5.41920029e-02f,
  -4.86660413e-02f, 1.82700217e-01f, -2.33559415e-01f, 1.44306257e-01f, -1.52759448e-01f, 4.12865609e-01f, -2.26270810e-01f, -1.28635377e-01f, -4.38653737e-01f, 1.84515163e-01f,
  3.14192742e-01f, -1.93740487e-01f, -9.64055732e-02f, -4.57861461e-02f, 6.85179234e-02f, 1.86182663e-01f, 1.53399706e-01f, -1.21481009e-01f, 2.03537092e-01f, 2.17190832e-02f,
  4.37580794e-02f, 1.25644971e-02f, 2.36977756e-01f, 6.99981898e-02f, -1.28574327e-01f, -4.46346045e-01f, 4.55192536e-01f, -4.63955216e-02f, 3.24903011e-01f, 4.15077358e-02f,
  6.16282336e-02f, -4.89792198e-01f, -2.47960985e-01f, 3.81271124e-01f, -1.96320236e-01f, -2.18501702e-01f, -1.32242128e-01f, 3.07421923e-01f, -5.90211987e-01f, 2.19346941e-01f,
  4.32987958e-02f, 4.63694692e-01f, -4.19265106e-02f, 3.45141743e-04f, -5.81241310e-01f, 2.40242511e-01f, 1.81263700e-01f, 4.21347946e-01f, 3.63415964e-02f, -3.76209646e-01f,
  3.65079790e-01f, -3.50652218e-01f, 2.30418921e-01f, -7.26995915e-02f, -3.68246108e-01f, 1.64955050e-01f, 1.92884952e-01f, 4.98946570e-02f, 3.29122603e-01f, -1.47482961e-01f,
  -1.44767746e-01f, 1.64655522e-01f, 3.15353155e-01f, -5.92681281e-02f, 1.10274829e-01f, -1.48206353e-01f, -1.87940896e-01f, 1.13590378e-02f, 4.35200781e-02f, 3.29490334e-01f,
  -6.32497817e-02f, -2.09517986e-01f, 2.43466650e-03f, -3.09609205e-01f, 3.93383771e-01f, 5.54778054e-03f, 2.73101658e-01f, -1.10295705e-01f, -5.86895585e-01f, -3.57320786e-01f,
  2.39434447e-02f, -3.32658827e-01f, 2.92776108e-01f, 3.30413967e-01f, -1.90338820e-01f, 1.67878211e-01f, -1.54644743e-01f, -1.19202159e-01f, 1.13203758e-02f, -5.40827394e-01f,
  1.99078083e-01f, -1.94045067e-01f, 3.96704227e-01f, -1.03448845e-01f, -3.81097049e-01f, -1.94314599e-01f, -5.51931597e-02f, -3.52401465e-01f, 3.32658827e-01f, 3.23527902e-01f,
  2.47136444e-01f, -3.81631792e-01f, 3.06976791e-02f, 2.56227106e-01f, -4.14927632e-01f, 4.52977240e-01f, -7.88024142e-02f, 1.00222588e-01f, 3.04237813e-01f, -5.05849980e-02f,
  -8.66740942e-02f, -2.30809495e-01f, -1.81394517e-02f, 1.87754333e-01f, -7.64092896e-04f, 3.11278880e-01f, 5.40002525e-01f, -1.71084367e-02f, 2.93561578e-01f, -3.88589650e-01f,
  -4.72529471e-01f, 4.28903438e-02f, -3.02213401e-01f, -4.76751141e-02f, -2.25686073e-01f, -1.70271756e-04f, -3.97450894e-01f, -2.87038743e-01f, -4.82574195e-01f, -5.07337511e-01f,
  8.82537011e-03f, -3.80104333e-02f, 1.53899789e-01f, 3.18872899e-01f, 9.43676755e-02f, -1.51057467e-01f, -1.36989444e-01f, -1.52914330e-01f, 2.76682526e-01f, -4.60633844e-01f,
  -4.08260524e-03f, 2.12273687e-01f, 2.12022111e-01f, -1.29855871e-01f, 3.04915607e-01f, 1.81697384e-01f, 3.17016661e-01f, -1.98748969e-02f, 5.92598580e-02f, 2.24024981e-01f,
  2.41291478e-01f, 8.74306411e-02f, -3.59148562e-01f, 1.40633836e-01f, -4.23109382e-01f, 1.99506944e-03f, -1.78661406e-01f, -4.18408126e-01f, 2.60339290e-01f, 5.24935961e-01f,
  -2.35331982e-01f, -2.96615154e-01f, -2.61506051e-01f, 1.99569687e-02f, -8.36085342e-03f, 5.26766926e-02f, -2.20980570e-01f, -5.85879564e-01f, 2.52759576e-01f, 1.93961263e-01f,
  3.09461474e-01f, -3.60653877e-01f, 2.75879472e-01f, -2.15611503e-01f, 3.21320117e-01f, 1.58996731e-01f, 7.21546933e-02f, -5.17147630e-02f, -4.63989615e-01f, 4.40882295e-02f,
  -3.49682003e-01f, 1.98407814e-01f, 7.13674948e-02f, -1.72406837e-01f, -1.57665613e-03f, -1.90508991e-01f, -3.85706544e-01f, 2.56061673e-01f, -1.58991128e-01f, -2.81058580e-01f,
  1.44973442e-01f, 3.87984931e-01f, 4.10071105e-01f, -3.44243377e-01f, -9.25371498e-02f, -2.28118315e-01f, -4.35049117e-01f, 1.84904262e-01f, -2.71379441e-01f, -3.63140166e-01f,
  2.01324299e-01f, 3.24572064e-02f, -1.18100300e-01f, 3.92965958e-05f, -4.98540029e-02f, -4.56159353e-01f, -5.55781841e-01f, -2.10510343e-01f, 3.02567452e-01f, 3.82885069e-01f,
  4.29070145e-02f, -3.23270887e-01f, -2.41856679e-01f, -2.64100701e-01f, 4.89303261e-01f, -1.01646014e-01f, -3.12704474e-01f, 2.18916774e-01f, 3.83533627e-01f, -6.63895011e-02f,
  -1.56770349e-01f, -1.36542901e-01f, -1.21077765e-02f, -1.86602384e-01f, -2.91766554e-01f, 3.58527780e-01f, 9.13756713e-02f, -3.76713306e-01f, 5.35604298e-01f, 2.94829071e-01f,
  -3.89468491e-01f, -1.10317476e-01f, -1.12310490e-02f, 1.42993592e-02f, 3.74614984e-01f, 1.61966324e-01f, -5.25011346e-02f, 3.70054543e-02f, -1.39067397e-01f, 1.27759740e-01f,
  -5.51089466e-01f, -3.96522790e-01f, -3.34221274e-01f, 8.06632265e-02f, -2.54044950e-01f, -3.76267821e-01f, -3.04471046e-01f, -1.63564965e-01f, -1.83470249e-01f, 3.69615257e-01f,
  -7.44324997e-02f, 2.06271246e-01f, -3.02423775e-01f, 1.45926580e-01f, -1.53975934e-01f, -3.16815406e-01f, -2.62605637e-01f, -1.50168881e-01f, 9.10355821e-02f, 1.11962855e-01f,
  -4.25243706e-01f, -3.81826609e-02f, -3.20441544e-01f, -8.31150785e-02f, 3.22768539e-02f, 2.03620955e-01f, 1.06873780e-01f, 1.25151709e-01f, 1.28160464e-02f, -7.17384070e-02f,
  -1.68295220e-01f, -1.85954350e-03f, -2.23556668e-01f, 2.82524556e-01f, 5.15546389e-02f, -3.76560539e-02f, 5.83191477e-02f, 4.25730273e-02f, -9.29328129e-02f, -1.25267461e-01f,
  3.17631990e-01f, -1.66310251e-01f, 2.87631422e-01f, -1.73063532e-01f, -2.08958551e-01f, 1.95363954e-01f, -3.91386926e-01f, 2.65490059e-02f, 2.61268616e-01f, -7.85536692e-02f,
  -1.95560902e-01f, 1.67378530e-01f, -1.16646305e-01f, -4.49250191e-01f, 1.36935383e-01f, -2.87090957e-01f, -2.60971397e-01f, -4.51970071e-01f, -1.55944347e-01f, 3.52644444e-01f,
  3.18258494e-01f, -9.48258638e-02f, -1.80988714e-01f, 2.48819411e-01f, 3.09084028e-01f, 2.54931986e-01f, 1.61854506e-01f, 5.53039134e-01f, 1.33382902e-01f, -3.26542079e-01f,
  -7.50361979e-02f, -9.66879651e-02f, -4.43846941e-01f, -2.77720869e-01f, -1.61966398e-01f, -1.36240736e-01f, -1.58201948e-01f, 1.16226949e-01f, -2.64956951e-01f, 4.29280661e-02f,
  1.39105141e-01f, -2.54944533e-01f, 4.26072568e-01f, -1.23689629e-01f, 3.66347224e-01f, -5.38497686e-01f, -1.64867371e-01f, 3.58891159e-01f, 1.39696166e-01f, -2.60852128e-01f,
  1.73590153e-01f, -5.90587035e-02f, 1.88824400e-01f, -6.62778784e-03f, 3.82199824e-01f, -2.21435577e-01f, 1.22369260e-01f, -5.14691100e-02f, 8.78063515e-02f, -5.05129397e-01f,
  2.34634072e-01f, 2.71056145e-01f, -4.57269698e-01f, 1.65783107e-01f, 5.14779091e-01f, 1.38969392e-01f, -5.69629669e-01f, -1.01840481e-01f, -3.80766213e-01f, 3.49240080e-02f,
  -3.62528712e-01f, -1.20246045e-01f, -2.50349343e-01f, -5.66952340e-02f, -3.54947180e-01f, -2.39728913e-01f, 2.69808650e-01f, 8.16559792e-02f, -3.64920855e-01f, -1.79094911e-01f,
  -3.19584191e-01f, -8.16977918e-02f, -3.95853966e-01f, 4.62161243e-01f, -1.59043491e-01f, 1.07990049e-01f, -1.80449948e-01f, -1.75531372e-01f, -4.25290883e-01f, -1.47497684e-01f,
  -7.68008232e-02f, -2.13903457e-01f, -2.84868240e-01f, 4.50327754e-01f, 2.86517534e-02f, 2.47592866e-01f, -3.79900378e-03f, 3.15427482e-01f, -4.24543768e-01f, -5.47018468e-01f,
  4.08917874e-01f, -1.59792572e-01f, 2.96265334e-01f, 3.07445019e-01f, -4.54347841e-02f, 2.06205789e-02f, -2.57352471e-01f, -2.63440013e-01f, -1.27271667e-01f, 4.32984941e-02f,
  -2.23510459e-01f, 3.91534656e-01f, -1.53742820e-01f, -2.87420243e-01f, -1.30947262e-01f, -4.06871028e-02f, -1.32211328e-01f, -1.47275150e-01f, 1.03523590e-01f, -1.94162250e-01f,
  -1.54499009e-01f, -1.45648181e-01f, -5.05913571e-02f, -1.82200506e-01f, -1.88904703e-02f, -1.75069328e-02f, 1.73844397e-02f, -2.14420035e-01f, 1.29233273e-02f, 2.60039300e-01f,
  1.66759744e-01f, -1.22322194e-01f, 1.35953918e-01f, -9.41820666e-02f, 9.91809815e-02f, -1.81339294e-01f, 9.65053737e-02f, 6.55336529e-02f, -7.11930245e-02f, -1.85400724e-01f,
  3.03041309e-01f, -1.39060438e-01f, -1.61283985e-02f, -2.54665941e-01f, 1.85527429e-01f, -1.70632645e-01f, 3.29439789e-01f, 2.71229357e-01f, -1.22121483e-01f, 7.39935637e-02f,
  -1.70289859e-01f, 6.67048909e-04f, -1.27916977e-01f, -1.86327547e-01f, -2.09056050e-01f, 6.45446852e-02f, -1.16304308e-01f, 2.20754877e-01f, -1.11914910e-01f, 8.82148370e-02f,
  -2.06492782e-01f, -1.54148445e-01f, -1.87076822e-01f, -1.57492340e-01f, 2.22241372e-01f, -2.03693323e-02f, 4.10763323e-01f, -2.71590143e-01f, -2.07235143e-01f, -2.71172136e-01f,
  -2.42411941e-01f, 2.71249980e-01f, -1.71478853e-01f, -7.57471845e-02f, -6.33817464e-02f, -1.53512105e-01f, -2.05173463e-01f, -2.15661958e-01f, -2.18077108e-01f, -9.08731520e-02f,
  1.78141177e-01f, -9.98777687e-04f, 2.42660567e-01f, -3.44755828e-01f, -3.28333586e-01f, -1.31131992e-01f, 2.20982119e-01f, -9.70931277e-02f, 2.34803200e-01f, 1.28007099e-01f,
  3.34295928e-01f, 3.61858696e-01f, -2.31927797e-01f, -1.61961287e-01f, 2.55712837e-01f, 1.25032961e-01f, -8.11075121e-02f, -2.51480281e-01f, -1.27396256e-01f, -2.49647483e-01f,
  1.95817426e-01f, 3.61022592e-01f, -1.70742020e-01f, -1.70749247e-01f, -1.62169755e-01f, -1.48843184e-01f, -1.93285957e-01f, 3.97732198e-01f, -2.19629511e-01f, -3.66388738e-01f,
  2.32241489e-02f, -1.61550418e-01f, 1.66450873e-01f, 3.03338856e-01f, -4.86872196e-02f, -1.23433463e-01f, -1.13846250e-01f, -2.22758368e-01f, -1.82081997e-01f, 1.39240012e-01f,
  -1.70810372e-01f, 1.49183363e-01f, -1.67040154e-01f, 1.68128341e-01f, -1.19354032e-01f, 1.02241300e-01f, 1.16931878e-01f, 2.94083655e-01f, -2.39499539e-01f, 2.35423952e-01f,
  -2.26144940e-02f, -7.90905654e-02f, -2.63952464e-01f, 1.27274059e-02f, -1.79938942e-01f, -2.15628043e-01f, -1.53761834e-01f, -2.07138639e-02f, 2.42633805e-01f, -1.07214384e-01f,
  -7.79231712e-02f, 2.79098839e-01f, -3.05536777e-01f, -1.83509484e-01f, -1.70631737e-01f, 5.24558574e-02f, -4.55584675e-02f, 3.37051935e-02f, 7.03473687e-02f, -5.87411262e-02f,
  2.60656569e-02f, -6.82750642e-02f, -1.22671030e-01f, -7.11168572e-02f, -4.69134375e-02f, -2.22538829e-01f, 1.02597903e-02f, -1.92646757e-01f, -1.21678822e-01f, -8.20532665e-02f,
  -7.13365078e-02f, 2.11423188e-02f, -1.52834758e-01f, 1.94103092e-01f, 4.10661735e-02f, 3.96970779e-01f, 5.76314665e-02f, -4.25067335e-01f, -1.70096353e-01f, -2.17008755e-01f,
  1.06169634e-01f, -1.94267333e-01f, -1.27119184e-01f, -2.83142179e-01f, -2.54105717e-01f, -1.64386183e-01f, 9.13892779e-03f, 2.80473858e-01f, -2.64161438e-01f, -2.33925000e-01f,
  3.37146670e-01f, -8.19968246e-03f, -9.97519717e-02f, 3.45339105e-02f, 1.80688519e-02f, 3.41779411e-01f, 2.53101707e-01f, 1.71305239e-01f, 5.16089611e-02f, -2.09295362e-01f,
  1.11300319e-01f, -3.56772304e-01f, -2.90928513e-01f, -3.65519047e-01f, -1.30641848e-01f, -7.17141256e-02f, -1.80524796e-01f, -3.28393906e-01f, -3.31303328e-01f, -2.47886553e-01f,
  -1.72876105e-01f, -8.13242495e-02f, 1.70948043e-01f, 3.07899296e-01f, -1.36472424e-02f, 1.80480987e-01f, -1.86413839e-01f, 2.35377595e-01f, -1.25058576e-01f, 3.72400820e-01f,
  4.80614230e-02f, -1.49021596e-01f, -3.69451702e-01f, -5.45397066e-02f, -1.56962872e-01f, -2.89091114e-02f, 2.24139109e-01f, -2.52582997e-01f, -1.61595598e-01f, -2.97750413e-01f,
  -2.06765503e-01f, -2.64292985e-01f, -1.75787270e-01f, 2.92168260e-01f, 1.95744529e-01f, -2.87168682e-01f, 1.99108556e-01f, -1.96075872e-01f, -1.53985053e-01f, 8.03046897e-02f,
  2.36163691e-01f, -2.03361988e-01f, 2.41300557e-02f, -4.19801474e-02f, -2.85133839e-01f, -1.41096577e-01f, 3.57410520e-01f, -2.18006372e-01f, 3.07221621e-01f, -1.97587818e-01f,
  2.17464820e-01f, -2.54826248e-01f, -1.47429943e-01f, -1.14398554e-01f, -4.00776509e-03f, -7.28381798e-02f, 3.32266062e-01f, -6.55121282e-02f, 5.92719018e-02f, -1.88724801e-01f,
  -4.60669473e-02f, 6.22853031e-03f, -1.89721398e-02f, -1.56798840e-01f, -1.31780759e-01f, -1.66051939e-01f, -1.61094051e-02f, 5.13617158e-01f, 3.16080302e-01f, -7.57855400e-02f,
  -4.59955484e-01f, 3.39299709e-01f, 2.83670872e-01f, -6.13098852e-02f, -2.64213890e-01f, -1.38640925e-01f, -2.38811195e-01f, 2.24468857e-01f, 1.76734358e-01f, -2.93631583e-01f,
  -1.34827599e-01f, 1.05649307e-01f, 2.13804871e-01f, 9.88906175e-02f, 1.01272240e-01f, -1.46240041e-01f, 5.56030460e-02f, 4.90720682e-02f, 6.76153228e-02f, 1.47676632e-01f,
  6.47864714e-02f, -9.60180610e-02f, -8.28619348e-04f, 1.17985159e-01f, -1.13849297e-01f, 1.06748305e-01f, 1.06673327e-03f, -3.04073244e-01f, -2.86819667e-01f, 2.31267437e-01f,
  2.68226892e-01f, -1.31545067e-01f, -1.30187184e-01f, -2.66145915e-01f, -3.08391731e-02f, -7.93788116e-03f, -3.13999116e-01f, 1.77635714e-01f, -1.44809172e-01f, -1.38697356e-01f,
  -8.74448568e-02f, 2.07561150e-01f, 1.25650555e-01f, 2.48818874e-01f, -5.55769444e-01f, -9.40587223e-02f, 3.84513319e-01f, 5.40536121e-02f, -5.70072412e-01f, 3.68139371e-02f,
  -3.03638130e-01f, 4.08708714e-02f, 2.13251129e-01f, 1.74180925e-01f, -2.61857539e-01f, -1.86758161e-01f, 2.84289598e-01f, 4.82920736e-01f, -2.27765143e-01f, -9.56413895e-02f,
  -1.21446535e-01f, -3.79833311e-01f, 2.95266248e-02f, -2.00645044e-01f, -2.92970818e-02f, 1.82515178e-02f, -1.55124441e-01f, -1.99333668e-01f, -2.74863601e-01f, 3.42441916e-01f,
  -5.10406271e-02f, 2.58611113e-01f, -5.66196144e-01f, -2.30491236e-01f, -3.88634443e-01f, -1.65746212e-01f, 3.91172439e-01f, -1.69271305e-01f, 4.04427558e-01f, -1.01000346e-01f,
  -3.80881459e-01f, -2.04176828e-02f, -2.48468034e-02f, 1.00682326e-01f, -3.09613585e-01f, -2.45845571e-01f, -8.22672993e-02f, 2.06658006e-01f, -5.42887032e-01f, 6.22667558e-02f,
  2.16567725e-01f, -2.09183961e-01f, -3.87696892e-01f, -2.25016147e-01f, -4.47378606e-01f, -1.05729282e-01f, 8.48449990e-02f, -1.71235740e-01f, -1.86554059e-01f, -2.13966370e-01f,
  -2.98278660e-01f, -1.94681585e-01f, -1.83420524e-01f, -1.84060454e-01f, -3.04647774e-01f, 2.22754017e-01f, -6.48994818e-02f, 1.10661902e-03f, -4.18905318e-01f, -1.18230306e-01f,
  -3.03811997e-01f, -3.59290272e-01f, -3.10165614e-01f, 2.43215114e-01f, -1.57587051e-01f, -4.56009805e-01f, 5.01532145e-02f, -3.01931743e-02f, 4.78540123e-01f, 3.82000744e-01f,
  -2.09608138e-01f, 1.32010123e-02f, 4.80522096e-01f, 4.92280185e-01f, 2.46078625e-01f, -1.67684436e-01f, -3.87112200e-01f, 4.25627530e-01f, 2.88450748e-01f, -1.28378585e-01f,
  -5.95501997e-02f, -1.42300859e-01f, -1.60106093e-01f, -1.07061602e-01f, 5.14683306e-01f, 1.97717115e-01f, -2.72063643e-01f, -8.45834836e-02f, -2.61693746e-01f, 2.97027618e-01f,
  4.17116471e-02f, 2.26956069e-01f, 2.47615591e-01f, 2.87435234e-01f, 1.17659830e-01f, 7.20824376e-02f, 1.51867688e-01f, 1.23845749e-01f, 8.42101946e-02f, 1.11016408e-01f,
  2.78024767e-02f, 1.52810737e-01f, 3.68397623e-01f, 2.57336855e-01f, -2.81459183e-01f, 1.97242945e-01f, 2.82345921e-01f, -1.34514764e-01f, -4.50815856e-02f, -3.27599645e-01f,
  3.33201051e-01f, 1.63271576e-02f, 3.28091532e-01f, -1.70332074e-01f, -3.39557528e-02f, -2.59316623e-01f, 3.98839355e-01f, 1.30680114e-01f, -2.38869056e-01f, -3.50602600e-03f,
  -1.41722828e-01f, -9.49052945e-02f, -1.64076895e-01f, -3.08139533e-01f, -1.35796890e-01f, -2.80934870e-01f, -3.11624855e-01f, -3.93163472e-01f, -2.48410657e-01f, -1.36339307e-01f,
  1.03314459e-01f, -3.08342963e-01f, -2.86280066e-01f, -4.27851707e-01f, 6.21520817e-01f, -1.11556895e-01f, -3.43899369e-01f, 1.80332869e-01f, -3.14870119e-01f, 4.96052623e-01f,
  -1.82818040e-01f, -2.36633718e-01f, 1.33691907e-01f, 2.33149469e-01f, -1.70431346e-01f, -3.49494338e-01f, -2.25894049e-01f, -8.60015750e-02f, 5.00398576e-01f, -2.57437527e-01f,
  -1.84024483e-01f, 1.81807965e-01f, 1.18670635e-01f, -6.56291395e-02f, -1.19774148e-01f, -8.64777565e-02f, -2.32308865e-01f, 2.75224686e-01f, -1.44957036e-01f, -2.12710828e-01f,
  -2.98158497e-01f, -2.85591602e-01f, -1.42335355e-01f, 2.07047448e-01f, -2.54884008e-02f, -1.51866317e-01f, 2.97325760e-01f, -1.22358955e-01f, -3.04193705e-01f, 2.34632626e-01f,
  7.74038536e-03f, -3.08497310e-01f, -1.75196037e-01f, 2.75936782e-01f, 2.33771309e-01f, 2.72000898e-02f, 2.07092628e-01f, 4.37641889e-01f, -2.50627697e-01f, 2.45915934e-01f,
  2.14258224e-01f, 8.00870210e-02f, -1.54898055e-02f, 2.78191343e-02f, 3.03828195e-02f, -2.25519359e-01f, -2.66974866e-01f, -5.50732249e-03f, -1.38007909e-01f, -1.18561916e-01f,
  8.66528451e-02f, -3.85932237e-01f, 4.74962205e-01f, -1.78398564e-01f, -9.71860066e-02f, 5.96670769e-02f, -5.06229931e-03f, -1.01320267e-01f, 4.10953850e-01f, -3.59548479e-02f,
  3.39422673e-01f, -3.73303681e-03f, -2.86073178e-01f, -3.06749642e-01f, -1.92252338e-01f, -3.10050845e-01f, -2.17084035e-01f, 4.94148433e-01f, -2.76267916e-01f, -2.54690856e-01f,
  -2.00444967e-01f, -4.26795840e-01f, -1.20519519e-01f, -1.21063329e-01f, 3.20046216e-01f, 1.62252247e-01f, -4.43708777e-01f, -1.79185271e-01f, 1.88910931e-01f, 9.77564156e-02f,
  -6.90660179e-02f, 1.64094582e-01f, 1.01306528e-01f, -1.79179564e-01f, -3.58947128e-01f, 1.40077934e-01f, 1.24816231e-01f, 1.32345129e-02f, 1.10438965e-01f, -9.53912213e-02f,
  1.59673721e-01f, 4.35839109e-02f, 2.48809949e-01f, -8.43043998e-02f, 3.61613661e-01f, -3.12883824e-01f, -2.76003093e-01f, 1.22468300e-01f, -1.12735160e-01f, 7.89326653e-02f,
  -1.43359751e-01f, 3.07091057e-01f, -3.17085892e-01f, -3.20630938e-01f, -1.90677136e-01f, 3.79045308e-01f, -2.64777005e-01f, 9.69723519e-03f, -2.14743391e-01f, 1.58927426e-01f,
  1.41648382e-01f, -3.42280507e-01f, -2.12888092e-01f, -1.74962088e-01f, -3.25410664e-02f, -2.02349454e-01f, -1.01055250e-01f, -1.30551621e-01f, -1.71005130e-01f, 8.36600736e-02f,
  -2.89383143e-01f, 2.46814325e-01f, -1.73091829e-01f, -1.30978227e-01f, -4.80583403e-03f, -1.92608744e-01f, -8.22754297e-03f, -1.97017431e-01f, -2.06695378e-01f, 4.24157053e-01f,
  -8.60798061e-02f, -6.49292096e-02f, -2.29331292e-02f, 4.52478379e-01f, 4.87399876e-01f, 1.05750866e-01f, -4.78982888e-02f, -1.77050233e-01f, 4.14375752e-01f, 3.80683333e-01f,
  -5.25101759e-02f, -1.06337503e-01f, -9.87541005e-02f, -2.22049147e-01f, 2.31234223e-01f, 3.63790095e-01f, -3.67070436e-01f, -3.16571742e-01f, 2.93870151e-01f, -1.56162128e-01f,
  3.48539799e-01f, -2.69089222e-01f, 7.81063130e-03f, -1.89313740e-01f, -2.68216610e-01f, -1.20238364e-01f, -2.10753903e-01f, 3.15445989e-01f, -6.58848658e-02f, -2.25220874e-01f,
  9.28217545e-02f, -2.19956487e-01f, -3.31706017e-01f, -5.75260408e-02f, 1.97816074e-01f, 2.83984393e-01f, -1.21992625e-01f, 2.63718516e-01f, -1.04344867e-01f, -9.29793925e-04f,
  -3.01729411e-01f, -1.80510551e-01f, 2.66241789e-01f, -6.86202198e-02f, -2.92476326e-01f, -2.47116551e-01f, 8.14591572e-02f, 5.04388034e-01f, -1.10732682e-01f, -8.05104077e-02f,
  1.94376707e-02f, -2.18239844e-01f, -1.64258450e-01f, -1.38577655e-01f, -1.18194766e-01f, -5.29326946e-02f, -1.70750722e-01f, -1.26844659e-01f, -2.15135604e-01f, -2.23751828e-01f,
  8.45421553e-02f, -1.79567814e-01f, -1.55723199e-01f, 3.95940453e-01f, -2.23302916e-01f, -1.07434571e-01f, 3.89081925e-01f, 4.07095760e-01f, -2.00288862e-01f, -1.92516178e-01f,
  -1.01315655e-01f, -2.55961478e-01f, -1.05321281e-01f, 7.63031393e-02f, 2.35010281e-01f, -1.48824051e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -8.09640214e-02f, 1.92559641e-02f, -1.66945402e-02f, 2.04371791e-02f, 8.30426114e-04f, 6.51853159e-02f, -4.34251837e-02f, -1.24197982e-01f, -1.43225893e-01f, -4.87730578e-02f,
  6.87636659e-02f, -4.17456664e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 104
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        128, 12
    );
    }
    