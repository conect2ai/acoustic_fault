/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.66921639e-01f, -2.37917274e-01f, -2.87382483e-01f, 1.27259612e-01f, -3.12150300e-01f, -3.20421249e-01f, -6.46500569e-03f, -2.44404390e-01f, -4.10644293e-01f, 2.12877572e-01f,
  -1.78046040e-02f, 1.34164572e-01f, 1.78671144e-02f, 2.60629117e-01f, 3.87382269e-01f, -1.27182022e-01f, 1.60195827e-01f, -6.66664615e-02f, -3.03725421e-01f, -1.47861734e-01f,
  -7.58310705e-02f, 1.31050304e-01f, 1.34960979e-01f, -9.59889740e-02f, -6.42658025e-02f, -1.26531711e-02f, 3.94660860e-01f, -2.21431270e-01f, 1.88950926e-01f, -1.89762227e-02f,
  -4.93148826e-02f, -9.07334238e-02f, 5.08940481e-02f, 3.67582217e-02f, -1.20770568e-02f, 2.86781192e-02f, -8.82700738e-03f, -1.09654665e-02f, 5.17949313e-02f, -6.60217628e-02f,
  8.90795961e-02f, 3.72017883e-02f, 1.71809644e-01f, -4.10499647e-02f, -1.41780213e-01f, 1.70399416e-02f, -1.06378682e-01f, -9.24703926e-02f, -1.38104156e-01f, -1.44397721e-01f,
  -2.24135444e-02f, -1.47407234e-01f, -9.36073810e-02f, -1.33211732e-01f, -2.52976827e-02f, -5.26027754e-02f, 3.28439251e-02f, -8.28564987e-02f, -1.62358806e-01f, -4.94195521e-02f,
  -8.83561149e-02f, 8.55710171e-03f, 2.02784548e-03f, -3.64139229e-02f, -6.51829392e-02f, 9.56868678e-02f, 1.99239943e-02f, 4.06870097e-02f, -5.30375540e-02f, -4.54325750e-02f,
  9.92443785e-03f, 5.89650497e-02f, -1.03303753e-02f, -3.70611399e-02f, 8.28405544e-02f, -6.72886753e-03f, 1.52854472e-02f, 3.66538130e-02f, 1.63014699e-02f, 5.99572621e-02f,
  -3.04243099e-02f, -2.48878039e-02f, 1.33877411e-01f, -1.88432690e-02f, -3.44570428e-02f, -4.76115905e-02f, -2.15376485e-02f, -4.15945798e-02f, -3.22424695e-02f, 7.75177628e-02f,
  -1.72977507e-01f, -1.54253170e-01f, 5.25069907e-02f, 6.46569133e-02f, 3.74380611e-02f, 9.28561911e-02f, -2.74684783e-02f, -4.49441262e-02f, -8.31384063e-02f, -2.34379135e-02f,
  4.60505486e-02f, 8.96895006e-02f, -1.09534435e-01f, -3.08374930e-02f, 1.06306829e-01f, -5.35753928e-02f, 1.72673687e-02f, 7.16414824e-02f, 7.61326849e-02f, 3.46486531e-02f,
  4.23328727e-02f, -3.37766409e-02f, 2.32289936e-02f, 3.68555710e-02f, 6.92140758e-02f, 8.95662382e-02f, -4.22687270e-02f, 4.00332697e-02f, 1.62835550e-02f, 5.22426190e-03f,
  -4.40126270e-01f, 4.80771810e-02f, 9.14953873e-02f, 3.54121625e-01f, -2.57542700e-01f, -6.66565180e-01f, -4.51257169e-01f, 1.48353959e-02f, -2.03263555e-02f, 1.52351439e-01f,
  -6.83440492e-02f, 1.54911980e-01f, -1.37560502e-01f, 8.22318569e-02f, -4.80599552e-01f, -1.44818723e-01f, 2.91398168e-02f, 5.75981326e-02f, 7.57812522e-03f, -3.87926809e-02f,
  -1.45562842e-01f, 1.39120258e-02f, 1.21025024e-02f, 1.30017817e-01f, -2.40191951e-01f, 2.72572637e-01f, 1.77901387e-01f, 4.38550599e-02f, 2.35265717e-01f, -1.09047070e-01f,
  9.19342320e-03f, 1.16308600e-01f, 1.31312579e-01f, 5.10222316e-02f, -7.16989562e-02f, 3.63045558e-02f, 2.24480797e-02f, -2.90887197e-03f, 3.00596692e-02f, 2.66116317e-02f,
  1.79773290e-02f, 5.71487192e-03f, 2.37344671e-02f, 6.43206108e-03f, 4.90983133e-04f, 2.59916577e-02f, -7.62280822e-02f, -6.08116612e-02f, 7.14405254e-02f, -1.71107918e-01f,
  -3.41262855e-02f, -2.56740469e-02f, -2.53834780e-02f, 1.01919875e-01f, 4.29203063e-02f, -5.00402646e-03f, 1.09179830e-02f, -6.60970286e-02f, -1.80948712e-02f, -7.92646706e-02f,
  -8.77443061e-04f, -8.98594782e-03f, -6.88633546e-02f, 7.47767165e-02f, -1.33305818e-01f, 8.55204538e-02f, -2.18863562e-02f, -3.32245193e-02f, 3.21749710e-02f, -1.02802850e-01f,
  2.03887429e-02f, -4.13447097e-02f, 3.60498317e-02f, -5.17786667e-02f, -7.67571852e-03f, 5.97588308e-02f, -1.84305776e-02f, 5.08915521e-02f, 9.37379058e-03f, 1.47553235e-02f,
  6.13058545e-02f, -6.14827238e-02f, -6.05750792e-02f, -4.04185755e-03f, -7.94820338e-02f, -2.28178389e-02f, -6.67285407e-03f, -8.14445666e-04f, 9.78816859e-03f, -8.74414220e-02f,
  -8.86271372e-02f, 3.84771265e-02f, 4.83054891e-02f, 4.68194708e-02f, 6.11781254e-02f, -6.54660165e-02f, -9.42722429e-03f, -1.37775494e-02f, -1.65345520e-02f, -2.69886907e-02f,
  9.75019298e-03f, 6.07354660e-03f, -3.35069932e-02f, 6.48650005e-02f, 4.84431870e-02f, -7.68248290e-02f, 7.55029097e-02f, 3.84404771e-02f, 4.16697748e-03f, 6.08422868e-02f,
  -1.81960650e-02f, -7.29556009e-03f, 2.65173074e-02f, -3.46602537e-02f, 5.05244592e-03f, -1.84870362e-02f, -1.93661619e-02f, -2.73999404e-02f, -5.14152497e-02f, 8.00089613e-02f,
  -5.00924289e-01f, 2.14165598e-01f, 5.54455034e-02f, -5.39110720e-01f, 3.50859191e-04f, -8.62727463e-02f, -4.02924806e-01f, -4.02048677e-02f, -1.80861756e-01f, 1.16209034e-02f,
  -3.68748784e-01f, 1.86389714e-01f, -1.20717948e-02f, -4.18407232e-01f, -3.93727362e-01f, -4.25761938e-02f, -3.98772359e-01f, -1.10374436e-01f, 6.68997914e-02f, -8.44049156e-02f,
  -8.89147595e-02f, -3.02065551e-01f, -1.90636545e-01f, 2.09884092e-01f, -6.75216541e-02f, 1.70447797e-01f, -1.41038358e-01f, 1.50808707e-01f, -3.45617160e-02f, 8.76285806e-02f,
  -8.74544587e-03f, -7.99826905e-02f, 3.37080210e-02f, 3.26642059e-02f, -9.64193568e-02f, 4.10975404e-02f, 3.87649536e-02f, -5.17705176e-03f, 1.83826650e-03f, 3.16589102e-02f,
  -1.71927456e-02f, 2.17440054e-02f, 5.47970471e-04f, 5.63467368e-02f, -4.45183292e-02f, 4.85146120e-02f, 1.77559797e-02f, -8.88478570e-03f, 3.89165021e-02f, -8.46628696e-02f,
  8.96228012e-03f, -8.11245888e-02f, -1.35502607e-01f, -3.63382846e-02f, 6.72633154e-03f, 5.95984142e-03f, -4.84026270e-04f, 6.79912791e-02f, 1.16900504e-02f, -1.32561140e-02f,
  -4.33858251e-03f, -2.37596594e-02f, -4.89849821e-02f, 5.89657761e-02f, -3.09142657e-03f, 2.76339799e-02f, -1.84802823e-02f, -3.08782067e-02f, 2.45017465e-02f, -5.90416975e-02f,
  -9.99418423e-02f, -7.07102194e-03f, -5.19831255e-02f, 9.94029082e-03f, -8.43628272e-02f, 4.95885238e-02f, -1.77362859e-02f, 3.40086035e-02f, -5.97619303e-02f, 1.05686095e-02f,
  2.23072735e-03f, -4.24198844e-02f, 4.74939309e-02f, -7.39611536e-02f, -4.92577590e-02f, 7.01670011e-04f, -5.21635935e-02f, 3.68082188e-02f, 4.65518096e-03f, -5.86529039e-02f,
  -5.49521483e-02f, -1.94934830e-02f, -1.27869761e-02f, 1.36131737e-02f, 8.66170675e-02f, 2.04291567e-02f, -2.47576013e-02f, 6.52952567e-02f, 9.64296907e-02f, -1.94468554e-02f,
  -5.57958521e-03f, 3.14774364e-02f, 1.85775291e-02f, -1.52127119e-02f, -1.13568939e-01f, 8.47288966e-03f, -9.48095322e-02f, 6.77117258e-02f, -5.02156168e-02f, 5.57875969e-02f,
  -1.04085617e-02f, 2.34677345e-02f, -3.75283621e-02f, 6.91085979e-02f, -1.53794661e-02f, 1.07108327e-02f, 3.15864272e-02f, -2.70287395e-02f, -1.30972508e-02f, 3.71638536e-02f,
  3.82809192e-01f, 1.49386883e-01f, 1.98902294e-01f, 5.28270066e-01f, 1.58445314e-01f, -5.02723515e-01f, -2.32066497e-01f, 2.10788146e-01f, 5.71237862e-01f, -3.25222999e-01f,
  -9.34576020e-02f, 2.65436590e-01f, -1.73271284e-01f, -4.90479320e-02f, -1.25082731e-01f, -3.09414059e-01f, -3.87052558e-02f, -3.72516923e-02f, 1.50322258e-01f, 2.47037485e-01f,
  1.75815836e-01f, -1.40670553e-01f, 3.59585658e-02f, -8.21025521e-02f, 1.93257809e-01f, 1.94516167e-01f, 1.06138103e-01f, 4.14990410e-02f, -1.67077407e-01f, -1.90885112e-01f,
  6.50181761e-03f, 1.87471792e-01f, 1.39536653e-02f, -2.46533728e-03f, 1.13169417e-01f, -1.34313524e-01f, -9.16269347e-02f, -1.93224281e-01f, -6.84946626e-02f, 1.13013131e-03f,
  -5.75199872e-02f, -3.91096622e-02f, -7.95617606e-03f, 3.08010522e-02f, 8.47173184e-02f, 2.97059286e-02f, 7.27743655e-02f, 4.91774753e-02f, 9.92085189e-02f, 5.18702494e-04f,
  9.54167321e-02f, 1.45100094e-02f, 3.99416722e-02f, -1.97012350e-02f, 3.61007266e-02f, 8.49387869e-02f, -9.61742550e-03f, -2.77509969e-02f, -4.16196808e-02f, 9.64320078e-02f,
  -1.70740038e-02f, 5.38160317e-02f, -1.17725860e-02f, 3.38911712e-02f, -2.49516070e-02f, 5.93344308e-02f, -2.26440765e-02f, -4.73527089e-02f, 2.81784236e-02f, -1.21041508e-02f,
  2.87831388e-02f, -2.82299127e-02f, 2.59680878e-02f, -6.81332052e-02f, 4.29277457e-02f, 6.31965399e-02f, -6.05282858e-02f, -1.57808084e-02f, 1.11903280e-01f, 2.00161319e-02f,
  -1.19888512e-02f, -1.59723144e-02f, 5.97346090e-02f, -4.41611074e-02f, -3.00382525e-02f, 5.03753461e-02f, 8.14447924e-02f, -6.39636889e-02f, 4.12587747e-02f, -2.43399609e-02f,
  9.00099874e-02f, 1.76268399e-01f, 2.11067144e-02f, 3.11917551e-02f, -8.42255279e-02f, -5.73340543e-02f, 6.69066980e-03f, 7.37626553e-02f, 9.22716185e-02f, -3.70522328e-02f,
  -6.34983778e-02f, -2.00043414e-02f, 1.63049828e-02f, -5.77296317e-02f, 1.49653181e-02f, -6.99669942e-02f, 2.07907222e-02f, 4.13491875e-02f, 4.81022783e-02f, 4.01947834e-02f,
  -6.31168336e-02f, -5.12516648e-02f, -3.37703004e-02f, 1.09075885e-02f, -1.12255931e-01f, 4.33436297e-02f, 9.79195461e-02f, -3.56713543e-03f, -1.54096037e-02f, -3.41825746e-02f,
  -5.12670577e-01f, 2.33468965e-01f, -1.52511090e-01f, 2.39810795e-02f, -3.67568612e-01f, -3.03526312e-01f, 6.29004613e-02f, -1.11542560e-01f, 3.08354367e-02f, 4.03148085e-01f,
  5.00753410e-02f, -7.89010450e-02f, 2.68122226e-01f, -2.37613283e-02f, -5.61228454e-01f, 3.02077740e-01f, 1.42704239e-02f, 1.22412004e-01f, -1.04256608e-01f, -9.84041542e-02f,
  -7.05360100e-02f, 9.53930803e-03f, -8.20454657e-02f, 4.97900471e-02f, -3.19762439e-01f, -4.74459492e-03f, 1.57526240e-01f, 1.19598443e-02f, -2.61109658e-02f, -1.68489158e-01f,
  -1.15550026e-01f, 1.29406050e-01f, -8.71552899e-02f, -1.82158202e-02f, -2.35230513e-02f, 8.14815983e-02f, -4.77791391e-02f, 2.79860664e-02f, -1.27803117e-01f, 7.44992122e-03f,
  3.57939973e-02f, -8.31693336e-02f, 1.88826546e-02f, -3.05800699e-02f, -1.04738183e-01f, -5.63624203e-02f, -6.22133687e-02f, -1.40065491e-01f, 1.37464209e-02f, -7.68457055e-02f,
  -3.84815931e-02f, -4.34522144e-02f, -6.00868501e-02f, 7.98461363e-02f, 1.16162915e-02f, 5.93567938e-02f, 3.16535458e-02f, -1.05717108e-02f, -2.34233029e-02f, -1.59104238e-03f,
  3.68130952e-02f, 1.00340582e-01f, -2.25863811e-02f, -3.87268886e-02f, -2.19447818e-02f, 3.12629752e-02f, 1.53814312e-02f, -1.77500769e-02f, -3.81931942e-03f, -3.96780409e-02f,
  3.13442722e-02f, -4.92462441e-02f, 1.61052570e-02f, -3.64368930e-02f, 5.20748412e-03f, 4.11302447e-02f, -1.89446192e-02f, 5.91545030e-02f, 1.08684627e-02f, -1.08868994e-01f,
  3.82559337e-02f, -5.41008711e-02f, 4.68474105e-02f, 4.28602323e-02f, 8.52975622e-02f, -8.37432127e-03f, 3.52624506e-02f, 7.64824776e-03f, 2.63293684e-02f, -5.70958406e-02f,
  1.37242898e-01f, 2.85726905e-01f, 1.18420668e-01f, 3.37305441e-02f, 7.41472915e-02f, -9.51519608e-02f, 8.59099627e-02f, -3.96071002e-02f, 7.16187060e-02f, 8.78746156e-03f,
  6.61425591e-02f, 7.05182925e-02f, 3.11588263e-03f, -4.74589653e-02f, -4.13396358e-02f, 8.30660015e-02f, 1.21764794e-01f, 2.09253002e-02f, 2.83937086e-03f, -6.70983596e-03f,
  1.20347983e-03f, 1.76931396e-02f, 7.98441470e-03f, 3.77344787e-02f, 2.86355130e-02f, 3.21980976e-02f, -6.65091500e-02f, 4.95875478e-02f, -7.87264947e-03f, 5.34080379e-02f,
  2.76861578e-01f, 3.67880702e-01f, -2.55072743e-01f, -2.91572902e-02f, 2.42760349e-02f, 7.81610459e-02f, -1.97152704e-01f, 1.81010380e-01f, -2.45143995e-02f, 3.05752844e-01f,
  -1.94198992e-02f, 2.47597292e-01f, -2.86633879e-01f, 3.95605981e-01f, -4.02522594e-01f, -2.36063316e-01f, 1.08347103e-01f, 1.57696158e-01f, -1.09287471e-01f, 1.22419275e-01f,
  -2.46074721e-01f, 2.47399092e-01f, -2.76665211e-01f, 1.59120440e-01f, 2.30556294e-01f, -9.10345465e-04f, -2.02531680e-01f, -1.92079797e-01f, 3.10695201e-01f, 1.31444722e-01f,
  8.92541334e-02f, 6.21114150e-02f, 1.46839330e-02f, -3.33398432e-02f, 9.75665599e-02f, -3.92782576e-02f, -8.31464212e-03f, -9.13043842e-02f, -1.19532213e-01f, 4.08974104e-02f,
  1.33592980e-02f, 2.09595170e-02f, 9.24687088e-02f, -6.69627413e-02f, -8.58089048e-03f, 3.31049487e-02f, 4.34505902e-02f, 3.78676131e-02f, 3.57061476e-02f, -8.83289650e-02f,
  -7.02416450e-02f, -1.69425961e-02f, -2.15369724e-02f, 1.22333236e-01f, -1.19140103e-01f, -2.62360908e-02f, -1.10435709e-01f, -6.60350500e-03f, 4.34165038e-02f, 9.32619423e-02f,
  -1.44971618e-02f, -4.96887714e-02f, 5.04430756e-03f, 6.91501498e-02f, 7.85516649e-02f, -2.83475947e-02f, -7.73003744e-03f, 7.30258226e-02f, 6.12029294e-03f, 3.76396812e-02f,
  7.66413659e-02f, 1.84983406e-02f, 5.99141270e-02f, -9.28948671e-02f, 2.40862300e-03f, 6.36369037e-03f, -4.88473848e-02f, 1.31049111e-01f, 3.51155549e-02f, -7.89160933e-03f,
  -1.65898912e-02f, -4.88522202e-02f, 1.46080658e-01f, -5.60151152e-02f, 4.84879501e-02f, -8.57397765e-02f, 1.22428974e-02f, -4.98401700e-03f, -7.50179738e-02f, -8.04769397e-02f,
  2.32457161e-01f, 6.48249090e-02f, -3.12735401e-02f, 6.92941099e-02f, 5.79482242e-02f, -1.30471513e-02f, -6.16792962e-02f, 4.27301303e-02f, -9.15664062e-03f, 4.07788064e-03f,
  -1.22526877e-01f, 2.40030754e-02f, -7.41766440e-03f, 7.67374709e-02f, -2.59017926e-02f, -9.48113874e-02f, -1.17996737e-01f, 4.06212509e-02f, -2.30515692e-02f, 1.17713362e-01f,
  -3.11607085e-02f, -1.01843784e-02f, -1.01083949e-01f, -1.45420525e-02f, -6.05109055e-03f, 5.22984862e-02f, 6.63509145e-02f, -5.07779457e-02f, 2.62377765e-02f, -4.12680134e-02f,
  -4.00775880e-01f, 3.19351494e-01f, 9.26421806e-02f, -2.39106715e-01f, -2.80193120e-01f, 1.11404784e-01f, -1.37398124e-01f, 8.79578888e-02f, -3.21044587e-02f, 3.17664057e-01f,
  -7.39670843e-02f, 2.82988340e-01f, 2.35928953e-01f, 1.82216629e-01f, -3.03161949e-01f, 2.20368162e-01f, -5.86396120e-02f, 7.53882304e-02f, 8.26934651e-02f, 7.55887851e-02f,
  -1.07140876e-01f, -6.76155761e-02f, 8.83137109e-04f, 9.94342491e-02f, -1.91385254e-01f, -8.52995813e-02f, -2.62818515e-01f, -1.03737921e-01f, -1.64549306e-01f, -1.58235535e-01f,
  -1.04782894e-01f, -3.55541483e-02f, 7.86723942e-02f, 7.37892538e-02f, -4.95709181e-02f, 2.75129303e-02f, -1.49769902e-01f, 4.25382704e-02f, 9.64925960e-02f, 9.01491866e-02f,
  1.34520665e-01f, -3.04648597e-02f, 6.95253909e-02f, 3.60745788e-02f, -1.90056730e-02f, 9.57029164e-02f, 5.34437504e-03f, 4.79350984e-02f, 4.30049039e-02f, -3.01023237e-02f,
  1.06275350e-01f, 5.90677653e-03f, -1.18696317e-02f, -1.88888051e-02f, -6.92723170e-02f, 3.85485664e-02f, -2.84370743e-02f, -9.84691456e-02f, -7.91508984e-03f, -1.65630206e-01f,
  -3.22863571e-02f, -7.67980237e-03f, -1.54307075e-02f, 2.47378778e-02f, 5.68739511e-02f, -1.01546556e-01f, 5.52329607e-02f, 2.52604801e-02f, 5.16565926e-02f, -8.07977170e-02f,
  -1.16314545e-01f, -8.89707804e-02f, -6.77183717e-02f, 1.96726900e-03f, -8.75430368e-03f, 4.21137773e-02f, 9.65281576e-02f, -9.08437818e-02f, -5.67207448e-02f, -4.68271747e-02f,
  1.54219754e-02f, -7.38210455e-02f, -7.62360496e-03f, -8.97486210e-02f, 1.53390821e-02f, 1.10074421e-02f, 2.84396228e-03f, -4.64561544e-02f, 3.64489742e-02f, -9.57807377e-02f,
  -1.45687073e-01f, -4.19915080e-01f, 4.80907261e-02f, 2.73196376e-03f, 7.29960427e-02f, 6.35299385e-02f, 5.69826327e-02f, 1.20634316e-02f, -6.32153973e-02f, -3.86081869e-03f,
  4.39231358e-02f, 4.81202416e-02f, -1.65371627e-01f, -1.88162737e-02f, 2.36694366e-02f, -1.04970224e-01f, -6.07742891e-02f, -2.26199515e-02f, -1.26610830e-01f, -3.33600752e-02f,
  -7.37711042e-02f, 1.35705387e-02f, 6.55053034e-02f, -3.16855088e-02f, 3.89990136e-02f, -6.80118129e-02f, -4.08896953e-02f, 2.45178528e-02f, -9.47915204e-03f, 6.52216077e-02f,
  3.56863528e-01f, -3.55866961e-02f, -1.13231540e-01f, 4.57933843e-01f, -3.27887572e-02f, 3.11435878e-01f, 4.67526436e-01f, -4.17310335e-02f, 2.28254825e-01f, 1.97148100e-01f,
  2.05045506e-01f, 3.11215252e-01f, -5.36512733e-02f, 5.23618579e-01f, 3.09524745e-01f, 1.18328504e-01f, 4.16207343e-01f, 2.94653594e-01f, -5.87761328e-02f, 6.24344796e-02f,
  3.78117859e-02f, 2.86457956e-01f, 3.40799838e-02f, -2.05610767e-01f, 6.47705123e-02f, -2.13220090e-01f, -1.04167186e-01f, -2.17444524e-01f, 1.51014194e-01f, 3.52707393e-02f,
  5.85156642e-02f, 7.62761161e-02f, 8.04897118e-03f, 5.06067164e-02f, 5.34116216e-02f, 1.92396715e-02f, -2.01287708e-04f, -7.83757046e-02f, -6.54923543e-02f, -2.34064758e-02f,
  -2.55045667e-03f, 4.20943871e-02f, 9.53409374e-02f, 8.04807898e-03f, -1.39183803e-02f, -1.05716377e-01f, -1.03613913e-01f, -2.07718238e-02f, -4.41820221e-03f, 6.81922138e-02f,
  2.75958702e-02f, -1.45608140e-02f, 4.63772118e-02f, 9.04304162e-02f, -1.83651689e-02f, 8.23006853e-02f, 7.00476468e-02f, -1.53374821e-01f, -2.09185258e-02f, 3.86884436e-02f,
  2.07152795e-02f, 3.71018089e-02f, -1.28996307e-02f, -1.16517404e-02f, 3.42748016e-02f, -9.60779563e-02f, 8.05250779e-02f, -4.11873758e-02f, -3.04549225e-02f, 3.14720254e-03f,
  3.13818790e-02f, 1.66443754e-02f, 6.29535541e-02f, 6.99997395e-02f, 6.00431450e-02f, 2.08545364e-02f, -2.95849214e-03f, -2.23987382e-02f, 2.41193138e-02f, -4.22280282e-02f,
  4.22024466e-02f, 1.12335291e-02f, 1.87548075e-03f, -3.10044419e-02f, 1.11100078e-02f, 3.31893489e-02f, -3.40688415e-02f, -5.18703088e-02f, -8.18058178e-02f, 3.64522915e-03f,
  5.73322661e-02f, 6.71513081e-02f, 2.05446463e-02f, -1.85871143e-02f, -9.35676415e-03f, 3.35307196e-02f, 8.89730304e-02f, -4.54199612e-02f, 1.41349221e-02f, 1.42457150e-02f,
  3.19139399e-02f, -7.97905028e-03f, -4.80266921e-02f, 2.18016957e-03f, 1.60200931e-02f, 8.53977650e-02f, 1.13060728e-01f, 9.91595536e-02f, 4.63920198e-02f, -6.81107715e-02f,
  -1.73611734e-02f, 1.53762940e-02f, -2.61518881e-02f, -3.91049273e-02f, 1.77348685e-02f, 6.03149720e-02f, 2.64322269e-03f, 1.82625502e-02f, -8.75098854e-02f, 7.42175803e-02f,
  -2.13362098e-01f, 3.74050140e-01f, 1.68506876e-01f, 1.88923907e-02f, -1.96587324e-01f, -5.20489752e-01f, -1.82221979e-01f, -9.65352058e-02f, -4.24638018e-02f, 2.97433972e-01f,
  5.40481173e-02f, 3.13980520e-01f, 2.92443961e-01f, 3.40331271e-02f, -3.50404918e-01f, 1.00289099e-01f, -2.89675057e-01f, -2.94095334e-02f, 2.33702399e-02f, -9.38927755e-02f,
  -3.32459360e-02f, -5.57101555e-02f, 3.31839561e-01f, -6.17552251e-02f, 5.94114698e-03f, 3.15025263e-02f, 2.09720120e-01f, 7.53107890e-02f, 8.35363287e-03f, -2.20689904e-02f,
  4.78087515e-02f, 1.17480785e-01f, 7.98598379e-02f, -3.72072719e-02f, -5.87779954e-02f, -8.45349208e-03f, 1.72823351e-02f, 1.43696368e-02f, -3.09389848e-02f, 2.41534710e-02f,
  1.00643724e-01f, -8.07095021e-02f, -4.98139970e-02f, 2.56646331e-03f, -1.05596194e-02f, 7.76047036e-02f, 8.87412429e-02f, 6.13055564e-03f, 1.06596656e-01f, 1.42232692e-02f,
  4.99849301e-03f, 4.08384874e-02f, -2.10813470e-02f, 2.84317951e-03f, 1.01032266e-02f, 4.60138321e-02f, -7.95062408e-02f, 1.41122648e-02f, -5.95606528e-02f, -9.33452845e-02f,
  -6.85115457e-02f, -6.31376579e-02f, 1.48455538e-02f, 1.11052021e-01f, -2.89872158e-02f, 5.51052578e-03f, -2.18027160e-02f, 3.90523002e-02f, 5.10434955e-02f, 2.13830769e-02f,
  4.94133942e-02f, -2.15236144e-03f, -6.49084523e-02f, -2.32560895e-02f, -9.97683778e-03f, 4.32067104e-02f, 8.69539008e-03f, 8.68255720e-02f, -5.44527024e-02f, 1.30035216e-02f,
  3.20591778e-02f, -9.74247083e-02f, 4.78271358e-02f, -2.64338385e-02f, -1.62898842e-02f, 3.57939007e-06f, 7.62236565e-02f, 8.31354875e-03f, 8.36853832e-02f, 1.28628965e-03f,
  -1.30214214e-01f, -9.41371843e-02f, 2.44322997e-02f, 8.47655255e-03f, 6.15599342e-02f, 3.95283438e-02f, 3.36494471e-04f, -1.16979115e-01f, -1.05340853e-01f, -4.80700545e-02f,
  -1.14756368e-01f, 4.26444784e-02f, -7.33263716e-02f, -1.81041751e-02f, 1.85781661e-02f, 3.49877030e-02f, -1.22307185e-02f, -9.35820397e-03f, -9.62416157e-02f, 5.03093936e-02f,
  4.90296595e-02f, 1.08263399e-02f, 3.53772682e-03f, 1.33140832e-02f, -1.25628561e-01f, 1.29955914e-02f, -5.19781373e-02f, -1.97134409e-02f, -1.75549481e-02f, 1.18167112e-02f,
  2.39454597e-01f, -4.45351303e-01f, -2.85622388e-01f, 8.85621831e-02f, -8.90017524e-02f, -3.68558139e-01f, 5.10178804e-01f, -1.95578650e-01f, 2.25652128e-01f, 5.97240701e-02f,
  -7.46590504e-03f, -1.14645705e-01f, 1.89437330e-01f, -2.79942960e-01f, -3.56700838e-01f, 5.22599481e-02f, -1.24489039e-01f, 1.04409114e-01f, 1.21964201e-01f, -1.71218619e-01f,
  -9.72068533e-02f, -7.55081475e-02f, -1.91313818e-01f, -1.95726931e-01f, 4.77455137e-03f, 1.09203935e-01f, 1.38551250e-01f, 1.00342836e-02f, -3.55628341e-01f, -4.15930636e-02f,
  6.49415776e-02f, 9.66377556e-02f, -9.28107649e-03f, -6.79679736e-02f, -7.78459311e-02f, 3.46411914e-02f, 1.51647449e-01f, -1.87496305e-03f, 6.76958114e-02f, -4.38857004e-02f,
  -3.88138741e-02f, -7.86069706e-02f, -5.50509021e-02f, -1.76450647e-02f, 6.86953813e-02f, -1.28959194e-01f, -5.90768792e-02f, -1.03614507e-02f, 1.34593528e-03f, 3.34157655e-03f,
  -8.90150592e-02f, -1.21840924e-01f, -9.76218283e-02f, -5.32666072e-02f, -3.26003097e-02f, -2.86108088e-02f, -5.63487187e-02f, 1.21419784e-02f, -1.72939420e-01f, -3.28726019e-03f,
  -1.91645231e-02f, 5.49880192e-02f, 9.16142948e-03f, -6.83508366e-02f, -4.64609750e-02f, -2.18283664e-02f, -4.87740263e-02f, 2.35919580e-02f, 8.65621194e-02f, 6.96762279e-02f,
  -2.39972472e-02f, -5.48608191e-02f, 6.03674389e-02f, 4.48674560e-02f, 6.29933253e-02f, 5.94692118e-02f, 1.51813496e-03f, -7.49806315e-02f, 2.53872797e-02f, 2.71867421e-02f,
  3.60748246e-02f, -9.74711999e-02f, -2.31432635e-03f, 5.87046742e-02f, -4.72753905e-02f, -7.17985705e-02f, -9.04916525e-02f, -5.83914481e-02f, -1.58585142e-02f, 7.89673813e-03f,
  -2.54854206e-02f, -4.28028628e-02f, 9.35658514e-02f, 4.31848243e-02f, -4.48115803e-02f, -9.82085392e-02f, -1.00367099e-01f, -3.50041091e-02f, -5.30927582e-03f, 9.85859036e-02f,
  6.72628134e-02f, 1.24949314e-01f, -2.70981546e-02f, -8.13663844e-03f, -8.24227836e-03f, -8.93060816e-04f, 8.93199518e-02f, 4.96763736e-02f, -1.23462327e-01f, -5.49126230e-02f,
  -6.88075498e-02f, 1.56583227e-02f, 2.59223841e-02f, 1.63774535e-01f, -4.78439033e-02f, 7.59100094e-02f, -2.42236480e-02f, -9.66748446e-02f, -3.61671671e-02f, -1.15848437e-01f,
  2.23009899e-01f, 1.54887021e-01f, -3.63350511e-02f, 2.87689477e-01f, 1.41543970e-01f, -3.50528926e-01f, -4.19397563e-01f, 2.47592777e-01f, 6.26681030e-01f, -2.63163388e-01f,
  -4.04716935e-03f, -3.03468946e-02f, -4.34885733e-02f, -1.46605656e-01f, -1.67480350e-01f, -2.70550698e-02f, -4.13325690e-02f, -1.55924959e-02f, 2.85703391e-01f, 2.64325161e-02f,
  1.24015070e-01f, 4.24992740e-02f, -3.26528013e-01f, 2.05556288e-01f, -3.10779940e-02f, 5.88820782e-04f, -3.20915073e-01f, 4.64809127e-02f, -2.69007891e-01f, 4.38753180e-02f,
  -7.90145472e-02f, 2.00802997e-01f, -8.93392265e-02f, -1.06336558e-02f, 4.66983346e-03f, -5.13093546e-02f, -2.44124189e-01f, -4.73427176e-02f, 1.11159414e-01f, -4.15612711e-03f,
  -7.89651945e-02f, 7.08267689e-02f, 1.22927271e-01f, 5.24717197e-02f, 3.86487246e-02f, -1.20698176e-02f, -3.93548273e-02f, 5.15643833e-03f, -3.33866589e-02f, -3.52542987e-03f,
  7.78957829e-02f, -1.02167405e-01f, -2.70571448e-02f, -6.57416359e-02f, -6.92892596e-02f, 1.29010513e-01f, -9.81190652e-02f, -2.79187970e-02f, -1.56523250e-02f, 1.07605040e-01f,
  1.22704878e-01f, 7.23572746e-02f, 4.72196825e-02f, 2.30693426e-02f, 7.64512345e-02f, 2.94172820e-02f, 6.33870885e-02f, -3.31880972e-02f, -1.54842753e-02f, -9.26849917e-02f,
  -9.48921293e-02f, -1.69269480e-02f, 7.27173239e-02f, -1.03553953e-02f, 1.07861377e-01f, -4.09681350e-02f, -5.48419468e-02f, 2.31960416e-02f, -1.03163859e-03f, -6.30434277e-03f,
  2.87115462e-02f, -9.75490361e-03f, -7.23214969e-02f, -1.09810658e-01f, -2.49040704e-02f, 3.29191610e-02f, 1.27502775e-03f, 2.08369400e-02f, -9.81301516e-02f, -8.27049017e-02f,
  1.08209448e-02f, 2.10640416e-01f, -4.41916659e-03f, -9.62709785e-02f, -1.97619200e-02f, -8.24081451e-02f, 1.09378733e-01f, -5.99260852e-02f, 1.07851617e-01f, -5.42522147e-02f,
  3.86344194e-02f, -5.28001115e-02f, -1.40106067e-01f, -1.09828804e-02f, -2.55875252e-02f, -2.55563259e-02f, -3.18379216e-02f, 2.44858954e-02f, 8.72870255e-03f, 1.53178023e-02f,
  -1.27967805e-01f, 4.78828326e-02f, -1.92313958e-02f, -3.42208594e-02f, -6.29819334e-02f, -1.16161346e-01f, 1.35950044e-01f, 9.79555845e-02f, -4.18294258e-02f, -4.63715605e-02f,
  3.70893955e-01f, 2.22783476e-01f, 5.71547747e-02f, 3.57199222e-01f, 5.84567599e-02f, -3.19312006e-01f, -3.97601485e-01f, 1.66550443e-01f, -1.10790782e-01f, -3.29573482e-01f,
  -4.03040508e-03f, 4.03286307e-04f, -3.48105639e-01f, 3.45271379e-01f, -1.84030816e-01f, -1.98904619e-01f, 3.11511815e-01f, 6.48511648e-02f, 1.15151390e-01f, 1.78038687e-01f,
  2.59351403e-01f, 1.75092682e-01f, 1.99995399e-01f, 1.78577885e-01f, 2.76025385e-01f, 8.37715492e-02f, 6.51927590e-02f, -1.14169143e-01f, 1.20971315e-01f, -1.14075327e-02f,
  1.14357537e-02f, 1.13812074e-01f, 2.38495559e-01f, -2.63747033e-02f, -2.04572873e-03f, -5.38215972e-02f, -9.42697003e-02f, -3.92476059e-02f, -4.05625105e-02f, -7.95152485e-02f,
  -9.76410732e-02f, 3.58260758e-02f, 3.22166942e-02f, -2.76716202e-02f, -4.10039127e-02f, 9.52673107e-02f, 9.42516774e-02f, 7.22360983e-02f, -7.42437260e-06f, 8.46354961e-02f,
  2.62822378e-02f, 8.60209689e-02f, 1.11486845e-01f, 3.30357961e-02f, 2.21778676e-02f, -3.91037427e-02f, 3.96096557e-02f, -8.59007761e-02f, 2.24194061e-02f, 6.24426417e-02f,
  3.78364362e-02f, -4.76144738e-02f, 7.23647361e-04f, 1.97199527e-02f, -8.23516399e-02f, -3.81307378e-02f, -4.08600569e-02f, 3.82885262e-02f, -7.42747560e-02f, 3.03537473e-02f,
  5.67276590e-02f, 1.40924037e-01f, 1.45181656e-01f, 6.32581785e-02f, -2.41455715e-03f, 3.24284751e-03f, -1.36168301e-03f, 5.95647991e-02f, 6.47355914e-02f, -6.79920390e-02f,
  3.11426483e-02f, -5.59772737e-02f, 6.66047782e-02f, 7.09810928e-02f, -6.74763992e-02f, -8.90178010e-02f, 9.75266844e-02f, -6.56712195e-03f, -5.21521717e-02f, 1.02684377e-02f,
  -2.21485779e-01f, -1.77908748e-01f, -5.50697893e-02f, 2.41601244e-02f, -1.65303811e-01f, -3.68968286e-02f, 9.92273912e-02f, 1.26864016e-01f, -2.43933231e-01f, 3.71065661e-02f,
  -4.39337939e-02f, -2.32230071e-02f, -1.23016141e-01f, 1.46337645e-02f, -1.01035293e-02f, 1.50390211e-02f, -1.18650861e-01f, -1.49463534e-01f, -1.22078387e-02f, 8.93788338e-02f,
  2.96427272e-02f, -1.77250057e-01f, -6.61038747e-03f, 8.08039382e-02f, 9.64784995e-02f, -4.28020023e-02f, 8.63855481e-02f, 7.36415386e-02f, 3.33742574e-02f, -5.12183085e-02f,
  3.46408010e-01f, 3.10860634e-01f, -1.37518212e-01f, -6.18477836e-02f, 1.85972705e-01f, 2.43934944e-01f, 2.50256807e-01f, 1.71211854e-01f, 4.49032903e-01f, 4.31699008e-02f,
  1.79941833e-01f, -2.89111525e-01f, 1.48398057e-01f, -2.63663512e-02f, -1.29957810e-01f, 2.66860902e-01f, 9.42858830e-02f, -9.83879492e-02f, 2.28447914e-01f, -1.59765720e-01f,
  -7.96523169e-02f, 6.80952370e-02f, -2.31208131e-01f, -8.00249130e-02f, -1.02021527e-02f, -1.02265067e-01f, -4.30949777e-01f, -1.13880460e-03f, -3.16458672e-01f, 5.38631789e-02f,
  8.02125558e-02f, 1.51110739e-01f, -3.20248865e-02f, -8.52113366e-02f, 1.27874026e-02f, 1.45552391e-02f, -9.48095769e-02f, 1.28695862e-02f, 2.87221409e-02f, -5.65505065e-02f,
  6.72166934e-03f, -3.49135720e-03f, 4.63351347e-02f, 6.18902259e-02f, 1.45752788e-01f, 2.37716734e-02f, -7.77296051e-02f, 1.46923475e-02f, -4.74696606e-02f, 5.08126430e-02f,
  -5.53245805e-02f, -1.53614841e-02f, -5.65383174e-02f, 1.31220454e-02f, -4.71076891e-02f, 9.93610919e-02f, -2.01761238e-02f, -1.26258522e-01f, 1.05864652e-01f, 5.60527220e-02f,
  7.33613372e-02f, 1.44226164e-01f, 3.65028018e-03f, 1.63001686e-01f, -1.21987786e-03f, 1.07159168e-01f, 7.43092457e-03f, 6.22506673e-03f, 4.95372377e-02f, 6.86280355e-02f,
  4.97213937e-03f, 4.05391529e-02f, 1.33849099e-01f, 4.16395254e-03f, -3.24854143e-02f, 6.69026896e-02f, -6.51812321e-03f, -3.02210208e-02f, 1.11533944e-02f, -2.52694879e-02f,
  1.27530143e-01f, 5.59363440e-02f, -5.75048141e-02f, -9.58628580e-03f, 1.24239810e-01f, -1.40030766e-02f, 3.39139439e-02f, 4.22176905e-02f, -1.48463007e-02f, -9.42143053e-03f,
  -1.51712254e-01f, -4.99753049e-03f, 3.11247669e-02f, 5.03133386e-02f, 1.81879569e-02f, -4.36313003e-02f, 1.29895255e-01f, -5.12230210e-02f, -9.55568179e-02f, 8.03067982e-02f,
  -1.20737270e-01f, -6.20364621e-02f, -5.91310896e-02f, -5.10113426e-02f, -1.37994066e-01f, 3.69104445e-02f, -7.58566428e-03f, -6.91202730e-02f, -5.19467667e-02f, -1.17708333e-01f,
  -8.33720192e-02f, -4.81702108e-03f, 4.94483821e-02f, 1.01066995e-02f, 3.07936538e-02f, -6.90709502e-02f, 4.90126535e-02f, 5.54848686e-02f, -1.19714467e-02f, 3.44957337e-02f,
  -1.27340153e-01f, -2.01370865e-01f, -2.37906247e-01f, 1.73638999e-01f, 1.86294630e-01f, -4.20625955e-01f, -2.29841903e-01f, 2.34464556e-02f, -2.98575815e-02f, -2.26909757e-01f,
  2.85208434e-01f, 1.02161080e-01f, 1.06847510e-01f, 3.02894473e-01f, 2.38493562e-01f, 9.39124599e-02f, -9.32861269e-02f, -7.69322142e-02f, 1.43110305e-01f, -6.03255890e-02f,
  -1.10815980e-01f, 3.10978502e-01f, 1.30825743e-01f, 1.32298037e-01f, 2.55380087e-02f, -1.71389803e-02f, 2.57558435e-01f, 1.15955211e-01f, -2.73678228e-02f, 1.88312605e-01f,
  -3.92002165e-02f, 2.05383956e-01f, -4.49933037e-02f, -9.65654477e-02f, -7.60676863e-04f, -1.57330781e-01f, -1.82720885e-01f, 1.31700963e-01f, 9.86224934e-02f, 7.60535821e-02f,
  -1.03131473e-01f, 1.31089106e-01f, 3.65641862e-02f, 1.01876080e-01f, -1.02002665e-01f, 5.62143736e-02f, 9.07681212e-02f, -1.03436746e-01f, -2.72929017e-03f, 1.15368590e-02f,
  -1.13632744e-02f, -7.02139810e-02f, -1.33727551e-01f, -5.04506519e-03f, 5.05725406e-02f, -6.23091981e-02f, -9.27070007e-02f, -2.35033091e-02f, -3.39221507e-02f, -2.12339945e-02f,
  -3.70819718e-02f, 3.95975783e-02f, 3.30107324e-02f, 1.21886842e-02f, 9.81327370e-02f, -5.85462851e-03f, -2.71404106e-02f, 6.69082329e-02f, 6.45462424e-02f, -3.97314094e-02f,
  -4.60689701e-02f, 1.50109697e-02f, 4.18935120e-02f, -1.00932203e-01f, 2.47126874e-02f, -1.13335308e-02f, -2.79322779e-03f, 1.68750044e-02f, -1.55764043e-01f, 1.02605514e-01f,
  8.33585709e-02f, -3.62084024e-02f, -3.01056802e-02f, -7.38635957e-02f, -4.42696456e-03f, 5.62447831e-02f, -7.11924508e-02f, -1.11462742e-01f, 1.15421653e-01f, 2.74285376e-02f,
  -2.30542019e-01f, 3.87475230e-02f, 3.96653451e-02f, 3.45276184e-02f, -6.67407922e-03f, 3.83936577e-02f, 6.38560876e-02f, -5.24090379e-02f, 4.52823229e-02f, 1.50897317e-02f,
  4.66377921e-02f, -1.48433372e-01f, -8.51847827e-02f, -2.13527232e-02f, 4.00137082e-02f, -1.99081115e-02f, -1.60746574e-02f, -2.88179256e-02f, 2.62138564e-02f, -3.27946953e-02f,
  2.84893699e-02f, 7.72780851e-02f, 5.70141934e-02f, 2.29712205e-05f, -6.11460917e-02f, 6.47440627e-02f, 2.16736794e-02f, -7.29593635e-02f, 1.55230418e-01f, 2.91352291e-02f,
  1.03557654e-01f, 2.63242982e-02f, -5.28905869e-01f, -2.58706152e-01f, 2.38884628e-01f, -7.11884350e-02f, -1.07538447e-01f, 2.73377657e-01f, 2.72647023e-01f, 1.67210892e-01f,
  2.55088478e-01f, -1.44679591e-01f, 3.19786996e-01f, -1.83295399e-01f, -3.28369260e-01f, 1.61054283e-01f, -3.57007347e-02f, -4.61871438e-02f, 2.82224476e-01f, -2.16231472e-03f,
  1.72139369e-02f, 1.82604134e-01f, -3.32400680e-01f, 1.66610241e-01f, -4.15375531e-02f, -1.52934358e-01f, -5.55979833e-02f, -2.25925315e-02f, -3.26331496e-01f, -7.26486146e-02f,
  -1.28649026e-01f, 1.87687024e-01f, -7.71865621e-02f, -1.12598933e-01f, -3.87129411e-02f, 5.27729355e-02f, -1.21924974e-01f, -9.26326439e-02f, 7.40566151e-03f, -3.43765952e-02f,
  3.19834575e-02f, -5.23932166e-02f, 2.63238084e-02f, 8.31247494e-02f, 4.79237549e-02f, -3.81091312e-02f, -8.06563348e-03f, -1.24927079e-02f, 4.49004546e-02f, -1.19519476e-02f,
  1.22191233e-03f, -1.77442312e-01f, -4.04698402e-02f, 2.74710301e-02f, -2.06045620e-03f, 2.98742447e-02f, -1.29566222e-01f, -1.26845330e-01f, -7.01558292e-02f, 3.99680510e-02f,
  1.58358797e-01f, 4.88350429e-02f, 6.02087192e-02f, -3.08814794e-02f, 1.02148749e-01f, -6.24320880e-02f, 2.96853250e-03f, 1.46256629e-02f, 2.77122408e-02f, 1.11755766e-01f,
  -1.06828831e-01f, -1.09872064e-02f, 8.87660831e-02f, -9.77693312e-03f, 6.65300339e-02f, 5.85314520e-02f, -5.66116162e-03f, 7.73369223e-02f, 5.73455170e-02f, -1.06084377e-01f,
  3.55338901e-02f, -5.57263680e-02f, 1.40685076e-03f, -5.59497699e-02f, -3.57625075e-02f, -1.27321482e-02f, 1.00550409e-02f, 7.29527045e-03f, 1.28602158e-04f, 1.61395762e-02f,
  1.18668012e-01f, 8.95344317e-02f, 5.74496426e-02f, -2.39920318e-02f, -9.44738388e-02f, 4.99870405e-02f, -5.69211692e-02f, 1.70920677e-02f, 6.85742423e-02f, 3.42093930e-02f,
  3.66930105e-02f, 6.71973825e-02f, -3.54392752e-02f, 2.19775792e-02f, -1.77103817e-01f, 1.53527930e-02f, -3.44573408e-02f, -7.04437196e-02f, -2.83709988e-02f, -6.92409556e-03f,
  -9.43375602e-02f, 3.97771522e-02f, -7.86449835e-02f, 9.94817913e-02f, -3.68322944e-03f, -1.10834707e-02f, 6.27509877e-02f, 7.56305158e-02f, 2.52966285e-02f, -6.32539392e-02f,
  -3.42391461e-01f, -4.92671179e-03f, -3.69874328e-01f, -2.69727074e-02f, 1.11846372e-01f, 4.36821401e-01f, 1.03629492e-01f, 8.93162861e-02f, -2.80749872e-02f, 3.38824064e-01f,
  1.73282921e-01f, -3.29620630e-01f, -1.20085478e-01f, 3.83784562e-01f, -2.50093371e-01f, -4.59497049e-02f, 2.40275338e-01f, 2.15814248e-01f, -1.36095330e-01f, -3.60291377e-02f,
  -1.07509218e-01f, 3.86470824e-01f, -1.42544150e-01f, 2.58909941e-01f, 2.35535558e-02f, -8.19567889e-02f, 3.38901505e-02f, -2.03105256e-01f, 3.34395885e-01f, -2.61797067e-02f,
  1.17807478e-01f, -8.01559165e-02f, 4.51601297e-02f, -2.90452205e-02f, 7.08698407e-02f, 1.11644324e-02f, 3.25375535e-02f, -1.01271220e-01f, -8.68342519e-02f, 9.20304097e-03f,
  -3.84881534e-02f, -3.83900665e-02f, 1.35544455e-02f, -4.05590348e-02f, 3.79130766e-02f, -1.61138512e-02f, -5.93349896e-02f, -7.89185334e-03f, -2.20333785e-02f, -9.91484821e-02f,
  -6.27199560e-02f, -1.31611954e-02f, 5.98077215e-02f, 4.04790379e-02f, -1.01320021e-01f, 3.03951241e-02f, -3.43716732e-04f, 1.33923814e-02f, 7.67358914e-02f, 1.23737138e-02f,
  -2.49200803e-03f, 3.86509858e-02f, -2.60300674e-02f, -6.86035678e-03f, 3.90249817e-03f, 6.47063879e-03f, -9.21632815e-03f, 9.06658769e-02f, -1.00940272e-01f, 3.12367100e-02f,
  5.84351644e-02f, -8.09063986e-02f, 4.52816971e-02f, 6.11677859e-03f, 2.61958018e-02f, 1.83816664e-02f, -3.70210670e-02f, 3.32876332e-02f, 3.88984010e-02f, 5.40372394e-02f,
  -8.70583653e-02f, 4.83549312e-02f, 2.81145852e-02f, -1.57602038e-02f, 3.54826488e-02f, -9.83173698e-02f, 7.53142312e-02f, -8.45032781e-02f, 7.18081966e-02f, -4.59085889e-02f,
  7.54970089e-02f, -3.94895412e-02f, 3.88683453e-02f, 6.97634928e-03f, 3.72510869e-03f, 3.33016925e-02f, -1.90500878e-02f, 1.60919521e-02f, -3.67217138e-02f, 4.66191061e-02f,
  2.67533306e-02f, 5.66456579e-02f, 2.36183424e-02f, 6.13395125e-02f, 1.87533461e-02f, 7.06653669e-02f, 7.69044738e-03f, 1.54395094e-02f, 4.30882014e-02f, 6.95781186e-02f,
  1.01020457e-02f, 5.68223558e-02f, -5.68129644e-02f, 7.64845014e-02f, 7.43229762e-02f, -3.70663926e-02f, 4.89265658e-02f, -1.34131312e-02f, 1.00250905e-02f, -6.09649112e-03f,
  -4.02630478e-01f, -4.43507552e-01f, 5.37275486e-02f, 6.15777215e-03f, 7.53440186e-02f, 4.08524632e-01f, 1.60669416e-01f, 4.79211323e-02f, -2.07138881e-01f, -1.64852425e-01f,
  1.68775111e-01f, -3.75760943e-01f, -1.32043034e-01f, -3.02291103e-02f, 1.67035908e-01f, -5.87783717e-02f, 4.48191725e-02f, -2.20779255e-01f, 1.48987130e-03f, -7.01295882e-02f,
  1.63521320e-01f, -7.99426958e-02f, 3.22001547e-01f, 1.82974001e-03f, 5.51434532e-02f, 6.85528591e-02f, 1.64078668e-01f, 7.67317638e-02f, 5.19744381e-02f, -1.13018543e-01f,
  -4.07090150e-02f, -1.58417255e-01f, 7.48324692e-02f, -6.59840778e-02f, 2.25017816e-01f, 9.66374427e-02f, -1.97909344e-02f, 2.27699359e-03f, 3.13852653e-02f, 6.15621582e-02f,
  -4.47892211e-02f, 7.92673975e-03f, -4.12076637e-02f, 3.01618455e-03f, -8.85992125e-02f, 9.81550198e-03f, 1.54145136e-01f, 3.00217774e-02f, 2.40399111e-02f, 7.47201145e-02f,
  1.19534418e-01f, 2.61279172e-03f, 1.13842294e-01f, 4.81575262e-03f, 3.89330126e-02f, 7.59175643e-02f, 1.35755688e-01f, 1.20706826e-01f, -8.07427019e-02f, 9.07598063e-02f,
  -6.71083778e-02f, -6.62674680e-02f, -3.40126678e-02f, -3.04758400e-02f, -2.24936064e-02f, 6.28598034e-02f, -1.00637704e-01f, -5.88541105e-02f, -2.11353879e-03f, -1.07680792e-02f,
  -3.36081237e-02f, 1.09763807e-02f, 5.18910736e-02f, 1.39140217e-02f, 5.98581828e-05f, -2.61930339e-02f, -2.00594626e-02f, -1.06545784e-01f, 1.09038211e-01f, 9.35398489e-02f,
  -1.50397584e-01f, 1.00557767e-02f, -1.83577631e-02f, -2.78241485e-02f, -4.51847054e-02f, 1.10368714e-01f, -2.52539404e-02f, 2.47102939e-02f, 1.62336588e-01f, -8.72627348e-02f,
  -2.05423608e-01f, -4.66574192e-01f, 2.06445344e-02f, 8.08436982e-03f, -5.61509579e-02f, 6.48024753e-02f, -1.00261688e-01f, 1.22453766e-02f, -5.74851073e-02f, 6.24030177e-03f,
  4.63164002e-02f, 6.64417678e-03f, -6.89418837e-02f, 7.99824484e-03f, -5.09651750e-02f, 6.57090694e-02f, -1.80942878e-01f, -1.97675452e-02f, 4.38376190e-03f, -2.96500139e-02f,
  -6.78083375e-02f, 7.75328726e-02f, 9.86000616e-03f, 4.57213260e-02f, -7.70776793e-02f, -8.88137445e-02f, -4.10739593e-02f, 1.24462150e-01f, -4.02171388e-02f, -1.08618729e-01f,
  -2.79772609e-01f, -3.27173054e-01f, -2.01707676e-01f, -7.78841823e-02f, -1.88255444e-01f, -3.24552774e-01f, -2.90465704e-03f, -2.37421900e-01f, 1.33327857e-01f, 3.85448076e-02f,
  -5.08500449e-02f, -8.24302956e-02f, -1.87446907e-01f, 8.81054625e-02f, -2.52531528e-01f, 1.38339475e-01f, -1.04897186e-01f, 5.82785420e-02f, 2.26259883e-02f, -2.64888793e-01f,
  -1.10284336e-01f, -4.94529083e-02f, -1.43679261e-01f, -1.61686793e-01f, -1.97248012e-01f, -2.88734157e-02f, -3.44979875e-02f, -9.80345085e-02f, -4.54551019e-02f, 2.14133084e-01f,
  -7.62201473e-02f, 8.31869468e-02f, -1.16535001e-01f, 1.41626209e-01f, -2.19714031e-01f, -1.63156816e-04f, -6.23996183e-03f, -1.79960148e-03f, 1.51072489e-02f, -4.17673588e-02f,
  3.54157574e-02f, -3.86951789e-02f, 1.39502034e-01f, 5.30167036e-02f, -1.04077505e-02f, 5.57952970e-02f, 2.69222017e-02f, -1.49568240e-03f, -2.00416669e-02f, 6.51213378e-02f,
  -5.52000441e-02f, 8.95054117e-02f, -1.20766470e-02f, 1.40932962e-01f, -3.42978425e-02f, 2.08759625e-02f, 1.34640470e-01f, -5.77457733e-02f, 1.95890144e-02f, -2.99253725e-02f,
  3.25349011e-02f, -2.35665709e-01f, -1.33853421e-01f, 2.83365529e-02f, -4.10605893e-02f, 4.12991047e-02f, -6.05952814e-02f, 4.88480628e-02f, -3.32599059e-02f, -5.43791540e-02f,
  -5.75976260e-02f, 7.97497667e-03f, 7.38725960e-02f, -1.39591815e-02f, -2.72733737e-02f, 1.33924946e-01f, -6.85198307e-02f, -3.87683623e-02f, -8.43720511e-02f, -2.04375926e-02f,
  4.88492008e-03f, -1.07800367e-03f, -1.11086160e-01f, 3.75867523e-02f, 7.46334493e-02f, -1.14279576e-01f, -4.35705949e-03f, -2.59143710e-02f, 6.11368231e-02f, -4.14855219e-02f,
  -3.78433853e-01f, -3.34477246e-01f, -8.59449804e-02f, 5.31204566e-02f, 5.35483882e-02f, -5.99396005e-02f, 1.26276433e-01f, 1.65193155e-02f, -1.38175443e-01f, -2.29959637e-02f,
  -1.43484280e-01f, 9.44757015e-02f, 2.96670571e-02f, 1.07927538e-01f, 7.20502750e-04f, -7.31259137e-02f, -3.23222131e-02f, -4.71497960e-02f, -9.98268425e-02f, -1.13532074e-01f,
  -1.78518891e-01f, -3.07556894e-02f, 5.40647358e-02f, -5.97433932e-02f, 3.91462259e-02f, 1.52458670e-02f, -7.30945170e-02f, 9.06167999e-02f, 7.19990209e-02f, -3.78175490e-02f,
  9.02522877e-02f, 1.99819699e-01f, -4.41603549e-02f, 2.29492411e-01f, -4.22861874e-01f, -2.76177853e-01f, 2.64642201e-02f, -1.63827360e-01f, 7.52847120e-02f, 3.02285820e-01f,
  -5.18027581e-02f, -2.20732037e-02f, -2.95418426e-02f, -1.72924668e-01f, -1.84744060e-01f, 5.55530796e-03f, 1.14639252e-01f, 2.02478752e-01f, -1.19689189e-01f, 1.46758575e-02f,
  1.39769129e-02f, -2.01732203e-01f, -7.25815743e-02f, -1.84632510e-01f, -2.80959994e-01f, 4.72790487e-02f, 1.59084901e-01f, 4.65415940e-02f, -9.50578749e-02f, -1.53924242e-01f,
  -9.65213701e-02f, 2.25870982e-01f, -2.12930769e-01f, 2.75804009e-02f, 2.47780420e-02f, -1.95587669e-02f, 1.07364573e-01f, -6.14811443e-02f, -8.00790414e-02f, -3.18856840e-03f,
  5.72586209e-02f, -1.53932974e-01f, -1.20382853e-01f, -4.04372104e-02f, 4.46145721e-02f, -1.84162445e-02f, -7.50682950e-02f, -8.40374604e-02f, -4.38113026e-02f, -8.65866318e-02f,
  -4.24669981e-02f, -6.75345138e-02f, 6.46817163e-02f, 7.94949904e-02f, -9.50561911e-02f, 4.17147204e-03f, -6.09367006e-02f, -2.17136815e-02f, 8.10622796e-03f, 7.55188465e-02f,
  1.37714133e-01f, 4.53638192e-03f, 3.32865976e-02f, -1.00936303e-02f, 1.02901356e-02f, -1.03351384e-01f, -9.66091547e-03f, -1.11467252e-02f, 5.37716821e-02f, 8.78422521e-03f,
  -1.36626765e-01f, -3.35110771e-03f, 6.60569314e-03f, 1.07032352e-03f, 5.17969765e-02f, 4.65516038e-02f, -6.14876524e-02f, -8.59599710e-02f, -1.02238514e-01f, -6.63145259e-02f,
  1.42336721e-02f, 1.87139176e-02f, 5.51754348e-02f, -3.15645672e-02f, 5.97677566e-02f, 2.53588222e-02f, -3.28148976e-02f, -9.14078504e-02f, 2.04264820e-02f, -8.49050805e-02f,
  2.66806960e-01f, 4.69705075e-01f, -3.43551487e-02f, 3.23984325e-02f, 5.38434386e-02f, 5.07610291e-02f, 2.17353385e-02f, -1.96475629e-02f, 9.09419358e-02f, 2.63190106e-03f,
  1.77646745e-02f, 9.32046250e-02f, 3.45235341e-03f, 3.33743803e-02f, -4.97502163e-02f, 1.78737938e-02f, 7.15744048e-02f, 2.69043762e-02f, 5.51787056e-02f, 8.19014311e-02f,
  1.44347429e-01f, 1.10015340e-01f, -4.46873493e-02f, -2.60904320e-02f, 6.30204678e-02f, 1.95191633e-02f, 9.76584479e-02f, 1.22394348e-02f, -4.32874821e-02f, -5.89836687e-02f,
  -6.15357518e-01f, 4.06510025e-01f, 2.57003933e-01f, -3.24605644e-01f, -3.85797948e-01f, 3.82725507e-01f, 6.70302749e-01f, -1.39721200e-01f, -1.57064274e-01f, 3.37930202e-01f,
  -1.72405750e-01f, 2.84285784e-01f, 2.48700544e-01f, 3.92615758e-02f, -3.17902446e-01f, 1.31151572e-01f, -3.32565047e-02f, 2.11860254e-01f, 1.16114281e-01f, 4.97256219e-03f,
  -1.68462843e-01f, -1.74667358e-01f, 2.79189833e-02f, -1.32304922e-01f, 5.13643585e-02f, 9.06642526e-02f, -7.14173913e-02f, 1.09722935e-01f, -2.02011652e-02f, 4.30009626e-02f,
  1.00241855e-01f, -2.67899707e-02f, -7.70962052e-03f, 4.58992869e-02f, -3.21814083e-02f, 4.85714432e-03f, 6.65082186e-02f, 1.72507986e-02f, -4.71330173e-02f, 6.16001971e-02f,
  1.54761761e-01f, -5.20530529e-02f, 7.28742331e-02f, 1.45210754e-02f, -3.77352014e-02f, -4.08888124e-02f, -5.71931079e-02f, -1.43071068e-02f, 5.30134961e-02f, 1.97653193e-02f,
  1.00095890e-01f, -2.96238158e-02f, -8.60249475e-02f, 7.90045261e-02f, -6.80372044e-02f, -5.48764616e-02f, 5.20457253e-02f, -1.60365347e-02f, -3.30656655e-02f, -9.50470045e-02f,
  -3.06118354e-02f, 8.71381015e-02f, 2.80745402e-02f, -1.98911522e-02f, 3.79433739e-03f, -8.65997151e-02f, -4.69669327e-02f, -1.17825484e-02f, 3.49955447e-02f, -1.99039467e-02f,
  -9.71253738e-02f, 3.70698632e-03f, -5.15610799e-02f, -3.12978625e-02f, -1.09639904e-02f, 8.32274035e-02f, -2.56541502e-02f, -2.74934433e-02f, -2.14439793e-03f, -2.85975821e-02f,
  7.46426210e-02f, -8.32602531e-02f, 1.20380409e-01f, 3.95290507e-03f, 7.56708756e-02f, -7.15490803e-02f, -2.08795201e-02f, -4.14591804e-02f, 3.98540422e-02f, -9.18971188e-03f,
  1.41228870e-01f, 1.75799623e-01f, 9.22294930e-02f, 4.21376415e-02f, 7.02716559e-02f, -7.36980289e-02f, 5.28408680e-03f, -5.65452352e-02f, 5.06614856e-02f, 1.47379274e-02f,
  -5.27467765e-02f, -1.88845098e-02f, -8.20861533e-02f, -1.07446060e-01f, -3.29216532e-02f, 9.14980546e-02f, 1.38950646e-01f, -2.20058709e-02f, -1.96568780e-02f, 1.36741474e-02f,
  -5.45111150e-02f, -2.62493975e-02f, -6.73731277e-03f, -6.58221766e-02f, 2.55002547e-02f, 6.99951574e-02f, -1.94118004e-02f, -3.19710076e-02f, 1.15428232e-02f, 1.93358585e-02f,
  -2.48539597e-01f, 1.40734479e-01f, -4.45873499e-01f, -2.13774741e-01f, 1.64117903e-01f, -1.11714393e-01f, -9.92052630e-02f, 1.72172189e-01f, -3.25082988e-01f, 3.40425730e-01f,
  2.91535258e-01f, -4.05203819e-01f, 6.03354722e-02f, 1.35683686e-01f, -4.88593310e-01f, -1.45190656e-01f, 4.15754505e-02f, 1.78297106e-02f, -1.72343239e-01f, 1.56057641e-01f,
  -1.99266687e-01f, 4.02697772e-01f, -2.17438266e-02f, 3.03099811e-01f, 2.03419581e-01f, -1.45282596e-01f, 3.14266503e-01f, -5.94620481e-02f, 1.89774513e-01f, 3.45334522e-02f,
  -6.16758652e-02f, 7.50756413e-02f, 5.40506765e-02f, -1.10978894e-01f, 1.85250744e-01f, 6.56268671e-02f, -7.50656277e-02f, -8.02543908e-02f, 1.82724441e-03f, 4.25549448e-02f,
  -2.15107538e-02f, 4.85512614e-02f, 3.46912183e-02f, -4.28071395e-02f, -1.06690094e-01f, -2.66077369e-02f, 2.95420289e-02f, 1.27740458e-01f, -6.11435100e-02f, -1.52737871e-01f,
  -6.01720586e-02f, -4.90094647e-02f, -7.66591728e-02f, -2.13650633e-02f, -1.32002920e-01f, -7.52879977e-02f, -9.03429240e-02f, -5.21446466e-02f, 3.22007248e-03f, -8.94145295e-03f,
  -8.87480448e-04f, -5.75761730e-03f, 6.92393482e-02f, -4.71135834e-03f, 2.63534430e-02f, 6.82369024e-02f, -5.45373783e-02f, 8.60348120e-02f, -2.43366733e-02f, -1.69965997e-02f,
  7.28349313e-02f, -3.85474376e-02f, -3.03451158e-02f, 7.78959598e-03f, 7.52099827e-02f, -7.11317658e-02f, -8.73878747e-02f, 4.81211767e-02f, 7.71608129e-02f, 4.68474217e-02f,
  -4.80213389e-02f, -6.06147759e-02f, 6.36304095e-02f, 4.77740820e-03f, -1.90722626e-02f, -4.20873575e-02f, 2.26560738e-02f, -5.75206727e-02f, -1.53831709e-02f, -3.72953108e-03f,
  1.60378069e-01f, 1.15096852e-01f, 1.74745955e-02f, -1.21501628e-02f, -6.08425550e-02f, 9.01732817e-02f, -8.25061575e-02f, -2.07552463e-02f, 1.56439971e-02f, -2.76729814e-03f,
  2.44548544e-02f, 1.00622833e-01f, -1.40640456e-02f, -4.79317969e-03f, 5.98873757e-02f, 9.11403075e-03f, -8.21897574e-03f, 5.38383685e-02f, 1.35618821e-01f, 7.93786198e-02f,
  9.52137560e-02f, -1.01334052e-02f, -7.97283370e-03f, 7.51481727e-02f, 6.73854575e-02f, 3.98960002e-02f, 3.05919349e-03f, -5.90773448e-02f, 5.94868697e-02f, -6.81993552e-03f,
  -8.98273066e-02f, 2.68456638e-01f, 3.40606123e-01f, 2.23763853e-01f, -2.16366336e-01f, -3.82989556e-01f, -2.13261843e-01f, 2.14368522e-01f, 4.49123234e-01f, -6.25951216e-02f,
  -1.91810220e-01f, 1.64408341e-01f, 9.76811722e-02f, -1.38630226e-01f, -2.04843462e-01f, 1.23383537e-01f, -2.65930831e-01f, -1.20165393e-01f, 1.32340610e-01f, 1.28310304e-02f,
  7.23816827e-02f, -2.74556905e-01f, -1.77156385e-02f, -9.18824151e-02f, -1.08526938e-01f, 1.57895520e-01f, -2.19565004e-01f, 3.73072810e-02f, -2.68996000e-01f, -1.60163224e-01f,
  -6.78996444e-02f, 1.80377826e-01f, 7.53688589e-02f, 5.57286479e-02f, -5.08827530e-02f, -1.45336822e-01f, -1.26924440e-01f, -4.20159549e-02f, 6.42557070e-02f, 2.11937949e-02f,
  3.39091085e-02f, -2.97147501e-02f, 3.98413688e-02f, 3.75011675e-02f, -1.34119783e-02f, 8.35428014e-02f, 3.32924426e-02f, -7.26494417e-02f, 1.10646285e-01f, -1.04295304e-02f,
  1.00685127e-01f, 8.23895261e-03f, -9.38079432e-02f, -8.08881372e-02f, 4.75895777e-02f, 1.83970742e-02f, 1.29405744e-02f, -1.55729353e-02f, -7.47734457e-02f, 2.34466810e-02f,
  -1.39809102e-01f, -2.75043994e-02f, -3.69510539e-02f, 9.52571258e-02f, -1.69750508e-02f, 1.60434805e-02f, -9.32120457e-02f, -5.64340428e-02f, -2.92448867e-02f, -2.28578337e-02f,
  2.54529603e-02f, 1.86082739e-02f, 2.87245363e-02f, -1.25290854e-02f, -2.89915549e-03f, 2.50586737e-02f, -8.91838372e-02f, 5.41834952e-03f, 3.55552323e-02f, -1.41543159e-02f,
  5.81862964e-02f, -1.23743884e-01f, 9.57278982e-02f, -8.57888460e-02f, 3.51195261e-02f, 7.44034424e-02f, 2.22613011e-02f, 1.53337326e-02f, 7.77917653e-02f, -4.76545952e-02f,
  -8.98926482e-02f, -6.23677820e-02f, 8.26931298e-02f, 5.84582705e-03f, 7.97190368e-02f, 1.59627516e-02f, 6.83472976e-02f, 4.56821844e-02f, -2.89070178e-02f, -2.26937002e-03f,
  -1.45711288e-01f, 5.02066128e-03f, -5.44035770e-02f, -4.84552719e-02f, 3.21057290e-02f, -1.75803192e-02f, -5.28176241e-02f, 3.08328755e-02f, -8.65158364e-02f, -6.79349378e-02f,
  -8.24762508e-02f, -1.06713727e-01f, 3.09823826e-02f, -1.75358970e-02f, -7.87513405e-02f, -6.60898834e-02f, 1.19883977e-02f, 4.24577519e-02f, -9.03846920e-02f, 1.97968520e-02f,
  -3.10291976e-01f, 1.78267062e-01f, -4.82613966e-02f, -2.64119655e-01f, 2.64745265e-01f, -4.16167110e-01f, -3.51290166e-01f, 2.64126807e-01f, -3.26108247e-01f, 9.06059369e-02f,
  -1.38652861e-01f, -2.27729410e-01f, -9.75236371e-02f, -2.83381939e-01f, -5.48998773e-01f, -3.21844220e-01f, -3.61232400e-01f, -1.86001956e-01f, -1.68766558e-01f, -3.53444591e-02f,
  -3.96636389e-02f, -5.28527200e-02f, 1.80675521e-01f, 2.27568135e-01f, 2.77105153e-01f, 1.65082008e-01f, 2.79830933e-01f, 1.06005050e-01f, 1.72837734e-01f, 5.20501994e-02f,
  -9.00928080e-02f, 1.54717164e-02f, 5.78225739e-02f, -1.88619401e-02f, -3.22646857e-03f, 9.21262801e-02f, -3.25539745e-02f, -1.00503147e-01f, -4.59405668e-02f, 3.43613178e-02f,
  -5.03835678e-02f, -8.00317302e-02f, -6.56583235e-02f, 2.14536209e-02f, 9.09037981e-03f, -7.44347554e-03f, 1.03444038e-02f, 8.10780004e-02f, 1.66108906e-02f, 1.37570715e-02f,
  -3.66689302e-02f, 2.34166533e-02f, -3.60673852e-02f, -6.03981353e-02f, -1.51244532e-02f, -9.96403992e-02f, -6.69591576e-02f, 1.02364346e-01f, -3.44835757e-03f, -6.58988729e-02f,
  -2.14467719e-02f, -3.97381373e-02f, 2.86483709e-02f, 1.94813758e-02f, -9.05839205e-02f, 7.98700154e-02f, -1.23388171e-01f, 4.03706878e-02f, -4.92870323e-02f, -2.44149640e-02f,
  -1.13454521e-01f, -3.09114102e-02f, -1.76813938e-02f, -1.03985043e-02f, -2.75476165e-02f, 5.83343320e-02f, 3.29900868e-02f, 5.71476519e-02f, -6.92992704e-03f, 7.09872618e-02f,
  -6.55839443e-02f, -3.23340036e-02f, -3.16564590e-02f, 1.00402243e-01f, -5.50994165e-02f, -8.57021958e-02f, -3.71210463e-02f, 7.23088905e-02f, 6.68619201e-02f, 2.11503878e-02f,
  1.89828184e-02f, -9.36008692e-02f, -2.84148641e-02f, 5.17751323e-03f, -9.08517540e-02f, -8.25070031e-03f, -3.36715616e-02f, 8.54879096e-02f, -6.32702783e-02f, -7.20809102e-02f,
  3.72412279e-02f, 8.22338164e-02f, 9.52644870e-02f, -8.12986642e-02f, -5.81317721e-03f, -1.92266870e-02f, -7.87639841e-02f, -6.03245236e-02f, 8.63506272e-02f, -1.73779597e-04f,
  5.94587363e-02f, -8.68406370e-02f, -3.33129093e-02f, 1.21215820e-01f, 7.73269907e-02f, -1.08073419e-02f, 1.17320465e-02f, -2.71497550e-03f, 3.06668784e-02f, -1.76577829e-02f,
  5.99037819e-02f, -3.11111242e-01f, -4.44699973e-01f, -8.82061422e-02f, 2.37626836e-01f, 2.56890655e-01f, -1.36606991e-01f, -5.54321520e-02f, -3.97868484e-01f, 9.48104560e-02f,
  2.39756927e-01f, -3.23091954e-01f, -1.49855599e-01f, 1.94649696e-01f, -1.21062594e-02f, -7.22291693e-02f, 3.49449486e-01f, 1.42879769e-01f, -5.62060103e-02f, -7.15661868e-02f,
  5.43942451e-02f, 3.48046869e-01f, 1.94903575e-02f, 1.78177029e-01f, 2.40084127e-01f, -1.72781974e-01f, 3.04976404e-01f, -1.84334964e-01f, 1.77684247e-01f, 8.41303989e-02f,
  1.26192063e-01f, -9.09305885e-02f, -4.85803410e-02f, -8.79234299e-02f, 7.75990710e-02f, 1.16219684e-01f, 7.26923868e-02f, 4.60903794e-02f, -1.10287115e-01f, -7.11508095e-02f,
  6.27655983e-02f, 5.47767244e-02f, 2.53234175e-03f, -4.50512767e-02f, -9.42733977e-03f, 6.95932051e-03f, -4.84059975e-02f, 5.41687682e-02f, -1.51492476e-01f, -2.15227846e-02f,
  -1.07060745e-01f, 9.94898975e-02f, 9.27931741e-02f, 8.18546712e-02f, -1.05757795e-01f, 3.90560972e-03f, 1.42837577e-02f, -1.30945072e-02f, 1.07573062e-01f, 5.44829061e-04f,
  1.70480311e-01f, 4.73417081e-02f, 3.98960710e-02f, -1.17097730e-02f, -7.24398792e-02f, 4.52647693e-02f, 4.27870154e-02f, 6.01749271e-02f, -7.01198801e-02f, -3.50158773e-02f,
  2.26456989e-02f, -1.06701151e-01f, -4.20781896e-02f, -3.85217108e-02f, 1.06267683e-01f, 8.35781023e-02f, 8.33079889e-02f, -7.80384690e-02f, -6.19903468e-02f, -2.25517377e-02f,
  -8.25554878e-03f, 1.96505096e-02f, -1.17135219e-01f, 1.33569106e-01f, 1.59259606e-02f, -1.23295896e-01f, 4.73392233e-02f, -7.48912841e-02f, 8.49672500e-03f, 8.27945322e-02f,
  4.61993441e-02f, -1.53361455e-01f, -1.58372700e-01f, 6.62467442e-03f, -7.57816359e-02f, -2.84933075e-02f, -3.15193646e-02f, 9.58207902e-03f, 6.13167472e-02f, 1.24588730e-02f,
  7.32689053e-02f, 3.28569971e-02f, -2.86311433e-02f, 1.69499982e-02f, 7.24901333e-02f, 1.45985158e-02f, 2.61650980e-02f, 1.98378265e-02f, 3.67874242e-02f, 4.21566740e-02f,
  9.10084397e-02f, 7.95435682e-02f, 2.01911256e-02f, 9.31843836e-03f, 4.42094654e-02f, 4.42430712e-02f, 3.70168500e-02f, -1.26411533e-02f, 1.28283992e-01f, 4.15655188e-02f,
  4.90416557e-01f, 1.17340915e-01f, 5.95347025e-02f, 1.51773781e-01f, -8.22720453e-02f, -4.29535687e-01f, -2.14295164e-01f, -5.36296070e-02f, 9.18504000e-02f, -1.72996342e-01f,
  -2.22903147e-01f, 1.02748498e-01f, 1.29366338e-01f, -4.23743755e-01f, -7.66875669e-02f, -1.66703284e-01f, -2.01554835e-01f, -6.54591769e-02f, 6.41624331e-02f, 1.55895054e-01f,
  4.37323339e-02f, -1.79847911e-01f, -1.43157840e-01f, -3.80874984e-02f, -1.23263247e-01f, 2.01368690e-01f, 6.06948920e-02f, 2.21526563e-01f, -1.56147882e-01f, -8.94179419e-02f,
  -6.72949925e-02f, 2.56917089e-01f, -8.56691971e-02f, -3.43048722e-02f, -8.77044722e-03f, 2.83112600e-02f, 2.25256160e-02f, -8.85974150e-03f, 4.36905324e-02f, -1.20860534e-02f,
  2.90716588e-02f, 3.50808837e-02f, -7.20238611e-02f, 3.02790701e-02f, 7.83784389e-02f, -1.32149430e-02f, -1.31917521e-01f, -1.42560452e-01f, -4.55263909e-03f, -5.35527579e-02f,
  -2.83261109e-02f, -7.49415234e-02f, -6.85340464e-02f, 9.61986184e-03f, -1.23411892e-02f, -3.85674834e-02f, -3.09887882e-02f, 1.33029849e-03f, 6.98089646e-03f, 1.85163245e-02f,
  2.52843439e-03f, 6.47784323e-02f, -1.78454276e-02f, -2.09755711e-02f, 2.37508621e-02f, 3.95978503e-02f, -4.75646332e-02f, -1.01673320e-01f, 8.57859999e-02f, 2.96377228e-03f,
  -4.84163724e-02f, 2.73635034e-02f, 2.85421982e-02f, -8.13848749e-02f, 8.31196271e-03f, -1.12780603e-02f, 3.91717665e-02f, -2.18533054e-02f, -3.19252312e-02f, -6.66454583e-02f,
  5.71242720e-02f, 1.15174903e-02f, -1.66609194e-02f, 7.86958821e-03f, -6.98497966e-02f, 1.35007929e-02f, -7.97569193e-03f, -5.20940237e-02f, -3.68616506e-02f, 8.71576965e-02f,
  9.10676792e-02f, 3.53312165e-01f, -2.79678963e-02f, -8.98752455e-03f, 1.75331347e-02f, -7.52866417e-02f, 7.08035659e-03f, -4.22671018e-03f, 5.76827452e-02f, 5.79494378e-03f,
  2.28301808e-02f, 3.72077301e-02f, 5.28138243e-02f, -1.61553416e-02f, -2.64113005e-02f, -3.61633226e-02f, 7.41241798e-02f, 6.21688552e-02f, -1.62091684e-02f, 7.08299056e-02f,
  6.41181394e-02f, 1.23702079e-01f, -4.82442183e-03f, 3.99278942e-03f, 1.64153073e-02f, -1.86707042e-02f, 3.20526361e-02f, 2.11023856e-02f, 6.08350057e-03f, 1.02816792e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.23694891e-01f, -1.29700780e-01f, -1.25154912e-01f, 9.79971364e-02f, -5.24989128e-01f, -3.44836742e-01f, -3.53021652e-01f, -2.79007643e-01f, 4.92554963e-01f, 1.26249893e-02f,
  -4.58660424e-01f, 5.41861475e-01f, 2.22893924e-01f, -5.60152948e-01f, 6.32503510e-01f, 5.11771262e-01f, -1.65771544e-01f, 1.37621105e-01f, 9.36484784e-02f, -1.87576354e-01f,
  5.99121191e-02f, -5.48405647e-01f, -4.49748814e-01f, -5.93257427e-01f, -6.54095292e-01f, -3.65019888e-01f, -3.87626290e-01f, -5.88905632e-01f, -5.11440814e-01f, -2.24276453e-01f,
  -1.08745448e-01f, -1.19534247e-01f, -1.23333372e-01f, 7.57713467e-02f, -6.65107090e-03f, -4.77297604e-02f, -1.27839372e-01f, -1.68058351e-01f, -4.11727317e-02f, 1.48990259e-01f,
  2.67412543e-01f, 8.19944367e-02f, 4.70068231e-02f, -7.12087080e-02f, -2.01600984e-01f, -1.15101174e-01f, 6.06494732e-02f, 5.84347583e-02f, -6.15481809e-02f, -1.09484591e-01f,
  4.45957594e-02f, 7.42722601e-02f, -7.38536045e-02f, 2.55143434e-01f, 4.27423827e-02f, -3.13580967e-02f, 1.28874838e-01f, 2.80844457e-02f, 1.29350454e-01f, 1.28045127e-01f,
  -1.30843997e-01f, 3.88548188e-02f, -1.59146398e-01f, -1.42663866e-01f, -6.36426657e-02f, -9.86025110e-02f, 2.47907508e-02f, -8.55056867e-02f, 1.44545913e-01f, 6.88565895e-03f,
  -3.36480252e-02f, -1.17838614e-01f, -1.34749606e-01f, 1.37461290e-01f, -1.88140497e-02f, 1.56701311e-01f, 1.24767870e-02f, 9.91997495e-02f, 1.21459343e-01f, 1.50289625e-01f,
  -3.68124433e-02f, -2.62429435e-02f, -6.27414733e-02f, -5.30948564e-02f, -1.28311276e-01f, 6.16426300e-03f, -4.29627076e-02f, -3.30557674e-02f, 4.39689346e-02f, -2.33507082e-02f,
  4.11605239e-02f, 2.67152563e-02f, 4.06399108e-02f, -5.31255566e-02f, 8.53313878e-02f, -5.22370897e-02f, -4.74984460e-02f, 1.28156971e-02f, 7.81808570e-02f, -7.93989003e-02f,
  2.69233137e-02f, 1.47887841e-01f, 1.53553918e-01f, -1.27267703e-01f, 1.12401463e-01f, -1.08446442e-02f, 1.82556346e-01f, 1.53221399e-01f, 5.45006283e-02f, -4.02670614e-02f,
  6.24330007e-02f, 1.14260070e-01f, 2.72546560e-01f, 1.16550192e-01f, 1.33765385e-01f, 8.32872465e-02f, 7.70809352e-02f, 3.46688963e-02f, 1.39984056e-01f, 1.33236930e-01f,
  4.57281172e-01f, -2.87375242e-01f, -1.51561216e-01f, -6.07041895e-01f, 2.07990464e-02f, -3.39507282e-01f, -2.50756741e-01f, -3.84267211e-01f, -3.90988827e-01f, -4.51727360e-01f,
  -4.47469234e-01f, -2.74328310e-02f, 3.87384892e-01f, -4.30027664e-01f, 5.66585243e-01f, 4.98948216e-01f, -3.77277166e-01f, -2.37638369e-01f, 2.25402236e-01f, -3.15660328e-01f,
  -1.74104329e-03f, -2.25446418e-01f, 2.04221517e-01f, -1.16908155e-01f, -2.38832101e-01f, -2.69208312e-01f, -7.63017964e-03f, 1.09599687e-01f, -5.21836877e-01f, 1.84082448e-01f,
  -9.57242493e-03f, 5.68361469e-02f, 1.26267403e-01f, 1.34080425e-01f, -6.75924793e-02f, 4.63908575e-02f, 7.67647615e-03f, 1.56144917e-01f, -2.98316199e-02f, -4.21399735e-02f,
  -6.02448769e-02f, 2.26934105e-02f, -3.24893147e-01f, 2.06649199e-01f, -2.58865096e-02f, -1.12912036e-01f, -3.63118690e-03f, -2.98206694e-02f, -1.56160876e-01f, 2.77747184e-01f,
  1.79889705e-02f, 7.46641383e-02f, -9.42334719e-03f, -2.78775226e-02f, -1.68267742e-01f, -2.19188645e-01f, 1.84349373e-01f, -5.61537296e-02f, -1.09222144e-01f, -1.37886656e-02f,
  -8.95667635e-03f, 1.04485743e-01f, 5.52852228e-02f, -1.83846757e-01f, 1.31476641e-01f, -7.04002902e-02f, 9.09574050e-03f, 1.08454954e-02f, -6.92262873e-02f, -1.00385211e-01f,
  -2.15399235e-01f, -3.87921557e-02f, 1.44222260e-01f, -2.12491617e-01f, 2.59510074e-02f, 2.98463672e-01f, 1.72909871e-01f, 8.34294036e-03f, -2.22779855e-01f, -1.27282098e-01f,
  -7.22391978e-02f, -2.35115411e-04f, 2.35370658e-02f, -1.64348856e-01f, -2.71039084e-02f, 8.02184120e-02f, -7.07921907e-02f, 1.08176902e-01f, 5.29360287e-02f, 1.63775787e-01f,
  -1.14011973e-01f, -1.11167364e-01f, -7.36030042e-02f, -1.21732011e-01f, -1.65540259e-02f, 1.49381176e-01f, 8.70269258e-03f, -1.92009374e-01f, -2.05097780e-01f, 1.84508730e-02f,
  -9.24313143e-02f, -4.43826877e-02f, -2.26209521e-01f, 1.57021374e-01f, -1.41094953e-01f, -1.44423366e-01f, -3.86661962e-02f, -7.60788023e-02f, -1.56880304e-01f, -2.71499828e-02f,
  -1.17390938e-01f, -3.79794538e-02f, 6.90561533e-02f, -1.61234170e-01f, -1.30659327e-01f, -1.46420807e-01f, 8.45336616e-02f, -3.29329111e-02f, 4.47268225e-02f, -1.83968246e-01f,
  5.09006262e-01f, 8.82510185e-01f, 1.05711475e-01f, 1.51218399e-01f, -1.83712155e-01f, -3.42933908e-02f, -3.30952108e-02f, -1.15269475e-01f, -2.18712449e-01f, 2.75405258e-01f,
  -1.38738111e-01f, 7.33426452e-01f, -4.51112539e-01f, 1.64351642e-01f, -4.44586039e-01f, -5.80537438e-01f, 3.14480245e-01f, 1.97932497e-01f, -1.62871718e-01f, 6.14340305e-01f,
  -2.57343948e-01f, 2.85011921e-02f, -5.30091822e-01f, -3.41216847e-02f, 6.52055383e-01f, 4.78342533e-01f, 1.41103312e-01f, -1.14053018e-01f, 6.25987887e-01f, 3.43077676e-03f,
  -1.04591526e-01f, -5.23134246e-02f, 4.75232042e-02f, -8.92490242e-03f, 7.75058568e-02f, 1.52010918e-01f, 2.17388913e-01f, -8.79374966e-02f, -1.32339880e-01f, 5.59493005e-02f,
  2.39577472e-01f, 2.33962741e-02f, -3.39417905e-02f, -9.19515416e-02f, 1.40226662e-01f, 1.98352039e-01f, 9.71500576e-02f, 7.75056407e-02f, 1.28508121e-01f, 1.62816465e-01f,
  3.58201042e-02f, 1.19312719e-01f, 1.71954200e-01f, 2.21294716e-01f, 1.91580318e-02f, 7.67938513e-03f, 2.17053130e-01f, 2.84171999e-01f, 1.82525277e-01f, 1.84457213e-01f,
  1.39099270e-01f, 6.79969862e-02f, -1.03627771e-01f, -1.43308699e-01f, -1.62437547e-03f, -9.82747152e-02f, -9.56278411e-04f, -1.56806380e-01f, -8.58907402e-03f, 6.32698387e-02f,
  -9.51148719e-02f, 1.88601881e-01f, -1.02364875e-01f, -3.05754561e-02f, 3.82671542e-02f, 8.40999782e-02f, -9.75187048e-02f, 1.55813977e-01f, 1.49426043e-01f, -1.10926040e-01f,
  -9.31862071e-02f, 1.99446157e-02f, 2.22544763e-02f, -1.67499539e-02f, -2.00759381e-01f, -6.12575375e-02f, 7.51868710e-02f, 8.65796804e-02f, -5.97833730e-02f, -2.02521570e-02f,
  1.39401004e-01f, 7.10657537e-01f, -2.29419880e-02f, -2.81097237e-02f, -7.81805888e-02f, 1.94029883e-01f, -4.75327261e-02f, 1.24675378e-01f, 2.02832282e-01f, 9.11366269e-02f,
  2.05896303e-01f, -7.43833408e-02f, 1.61501259e-01f, -1.28364578e-01f, 2.65197754e-02f, 1.48474589e-01f, -7.68455490e-02f, 1.14723556e-01f, 8.21821094e-02f, 1.12346224e-01f,
  1.07887477e-01f, 1.44711033e-01f, -9.03083012e-02f, -1.81406755e-02f, 5.22163920e-02f, 1.81490481e-01f, 2.60331303e-01f, 1.65333003e-01f, 9.17424858e-02f, 3.27158384e-02f,
  1.11141968e+00f, 1.05063491e-01f, 5.94177663e-01f, 9.38261569e-01f, 1.97360039e-01f, -5.42294323e-01f, 1.52352422e-01f, 2.58058250e-01f, 6.69876218e-01f, -2.78972417e-01f,
  -3.32120240e-01f, 1.35678649e-01f, -5.68394601e-01f, 2.88574457e-01f, -4.95893091e-01f, -5.32089412e-01f, 1.43526569e-01f, -1.02730460e-01f, 2.46048421e-01f, 1.85126364e-01f,
  4.58701581e-01f, -4.19038326e-01f, 1.76612824e-01f, -2.89870501e-01f, 5.19433856e-01f, 5.69887340e-01f, -3.16609114e-01f, -1.92252055e-01f, 1.79598644e-01f, -2.85687178e-01f,
  5.97962290e-02f, 3.66463065e-01f, 2.64657974e-01f, -1.51423261e-01f, 1.02287836e-01f, 5.10823764e-02f, 4.66681197e-02f, -2.15965807e-01f, 1.43722638e-01f, 8.34885165e-02f,
  -1.08157687e-01f, -1.76433213e-02f, 3.42981070e-02f, -8.11692253e-02f, 1.98300183e-01f, 2.28431359e-01f, 1.70554966e-01f, 2.99270064e-01f, 1.36402175e-01f, 2.01030686e-01f,
  2.94818312e-01f, 1.16954990e-01f, 2.00473338e-01f, -6.31125867e-02f, 2.28480861e-01f, 1.30856305e-01f, -6.43010661e-02f, -3.16389613e-02f, 9.70096812e-02f, 1.23439945e-01f,
  -8.79536476e-03f, -4.87922356e-02f, -8.00393745e-02f, 4.38989028e-02f, 9.47234966e-03f, 5.85803837e-02f, -3.57007310e-02f, -1.35570735e-01f, 1.42460883e-01f, -1.24213018e-01f,
  -2.50532702e-02f, 6.82773665e-02f, 6.21699058e-02f, 8.46305117e-02f, 1.45136848e-01f, 2.16930524e-01f, -8.12742487e-03f, -1.03753723e-01f, 2.18537197e-01f, 1.27092570e-01f,
  -6.91940114e-02f, -1.69467732e-01f, -5.71434572e-02f, -1.27735417e-02f, -1.24425389e-01f, -2.44684052e-02f, 9.38736424e-02f, 1.35072887e-01f, 6.07900470e-02f, -1.61193162e-01f,
  -7.01964259e-01f, -6.04033113e-01f, -6.03899993e-02f, -4.86666746e-02f, -9.85153094e-02f, -7.85874799e-02f, -6.52208254e-02f, 5.79469055e-02f, -1.15739666e-01f, -3.72614004e-02f,
  6.24503270e-02f, 1.36968523e-01f, -1.28239378e-01f, 3.08085675e-03f, -9.07750130e-02f, -6.43840060e-02f, -1.00010715e-01f, -1.21384338e-01f, -7.89232254e-02f, -4.44687232e-02f,
  3.12328269e-03f, -7.03599304e-02f, 2.61984989e-02f, 1.71233147e-01f, 7.90304393e-02f, -1.20160110e-01f, -1.81836691e-02f, 1.10303327e-01f, -1.13660768e-01f, -4.68872823e-02f,
  -6.50941849e-01f, -2.96036929e-01f, 1.81379169e-01f, -6.88261747e-01f, -4.29717712e-02f, 3.62185985e-02f, 1.57070979e-01f, -3.33885789e-01f, -4.96221185e-01f, -2.50317961e-01f,
  -4.96086031e-02f, 3.44495252e-02f, 5.91804981e-01f, -3.27400595e-01f, 6.01804197e-01f, 3.21450502e-01f, -4.47235107e-01f, -8.12404677e-02f, 3.16051841e-02f, -4.19123352e-01f,
  -6.94034249e-02f, -3.43554676e-01f, 4.53336000e-01f, -4.30015594e-01f, -2.26374075e-01f, -4.07049388e-01f, 1.91412214e-02f, 2.39632651e-01f, -3.97943079e-01f, 1.43510908e-01f,
  -4.66539025e-01f, -5.17148554e-01f, -1.93614885e-01f, 1.19445880e-03f, -2.03798547e-01f, 1.04310438e-01f, 1.35393947e-01f, 3.82238775e-01f, -2.28661261e-02f, 5.07180858e-03f,
  3.41574140e-02f, 1.55681744e-02f, -2.54068255e-01f, 9.37025994e-02f, -2.03951746e-01f, -2.07532674e-01f, -4.10628468e-02f, -8.84860009e-02f, -1.22703947e-02f, 1.01141952e-01f,
  9.72961113e-02f, -1.06061548e-01f, -7.39544854e-02f, -3.96055244e-02f, 1.40195042e-01f, -1.66116551e-01f, -8.79199058e-03f, 2.19049528e-01f, -1.15295179e-01f, -1.43387675e-01f,
  1.17613479e-01f, 2.14711785e-01f, -6.73816912e-03f, -8.07733089e-03f, 6.31842241e-02f, -9.84812751e-02f, 1.18583012e-02f, 2.23565593e-01f, -9.99958813e-03f, 5.02113625e-03f,
  -1.56544134e-01f, -3.70644815e-02f, -1.44040301e-01f, -1.38744548e-01f, -6.29103556e-02f, -1.44058138e-01f, 1.71748623e-01f, -2.04872116e-02f, -4.24677460e-03f, -1.14884758e-02f,
  6.20520732e-04f, -2.30478682e-02f, 3.01343631e-02f, 1.33016050e-01f, -2.41831522e-02f, 1.78186387e-01f, -3.55739938e-03f, -6.49029687e-02f, -1.47535294e-01f, 1.46747962e-01f,
  -5.62081814e-01f, -4.97374862e-01f, 1.05974227e-01f, -1.79557562e-01f, -1.37933642e-02f, -4.17353138e-02f, 4.34962586e-02f, -1.69983163e-01f, -1.06743775e-01f, -2.14731202e-01f,
  -1.46294951e-01f, 2.14913953e-02f, -3.87673490e-02f, -8.04609880e-02f, 8.58083367e-02f, 4.14661656e-04f, 3.88500206e-02f, -1.34912804e-01f, -2.16485709e-02f, -7.83745274e-02f,
  3.21321189e-03f, -2.06361804e-02f, 2.33599663e-01f, -3.61040495e-02f, 7.09126815e-02f, 3.26429196e-02f, -1.98495418e-01f, 1.26537988e-02f, 4.62470204e-03f, -2.29110755e-02f,
  -3.24404448e-01f, -7.31434047e-01f, 6.35553151e-02f, -4.42670733e-01f, 2.63881087e-01f, 2.42632151e-01f, -3.25198114e-01f, -2.07542330e-01f, -5.84399819e-01f, -5.99950850e-01f,
  -1.74296707e-01f, -1.11687489e-01f, -3.61739427e-01f, -2.82917380e-01f, 7.38049448e-01f, -8.59813690e-02f, -1.99326828e-01f, -9.71194580e-02f, -3.91225256e-02f, -3.79189730e-01f,
  -2.32459838e-03f, -1.78327650e-01f, 1.95046917e-01f, -4.39751036e-02f, -3.35223585e-01f, -1.29075661e-01f, 2.70231783e-01f, 1.41879246e-01f, 2.23356143e-01f, 3.68704259e-01f,
  -3.29386503e-01f, -4.59330827e-01f, -2.45236456e-01f, -7.70870000e-02f, 5.65692298e-02f, 4.61472757e-02f, 1.26482069e-01f, 1.17893346e-01f, 1.29756823e-01f, 2.86858471e-04f,
  -3.78729627e-02f, 3.67408767e-02f, 2.63508391e-02f, 1.00224853e-01f, -8.48485455e-02f, 8.79553407e-02f, 5.56687601e-02f, -7.19695687e-02f, -1.57862037e-01f, 5.04996963e-02f,
  -1.40230790e-01f, 6.86850473e-02f, -9.27008018e-02f, 6.04971312e-02f, 1.16034456e-01f, 3.75543647e-02f, 3.52933295e-02f, 2.35820979e-01f, -4.10281383e-02f, 7.75820091e-02f,
  1.94834128e-01f, 9.37874764e-02f, -3.32231522e-02f, -1.51810590e-02f, -1.51079446e-01f, -4.61376905e-02f, -1.76148936e-02f, 3.42928581e-02f, 1.61043312e-02f, 9.54385474e-03f,
  -4.05272990e-02f, 7.76341558e-02f, -1.18955210e-01f, -1.47830136e-02f, 8.40248987e-02f, 9.27343443e-02f, -2.31126323e-03f, -1.50742188e-01f, -9.73569229e-02f, -2.16378886e-02f,
  1.47816883e-02f, -5.99535406e-02f, -3.38313282e-02f, 7.19260797e-02f, -8.53701234e-02f, 1.23990541e-02f, -3.89067084e-02f, -8.83820839e-03f, 7.87196681e-03f, 2.47301999e-02f,
  -7.33542681e-01f, -6.22278094e-01f, -1.67555526e-01f, -9.26331207e-02f, -5.85864000e-02f, -2.15999037e-02f, -1.59882400e-02f, -7.70425657e-03f, -2.82514337e-02f, -6.09047450e-02f,
  3.75983715e-02f, 8.57925490e-02f, -3.26958299e-02f, -3.71994264e-02f, 8.61841664e-02f, -6.38941377e-02f, -2.38440081e-01f, -7.88422078e-02f, -7.91001618e-02f, 1.06974535e-01f,
  -1.00017525e-01f, -7.79155269e-02f, 1.23243779e-01f, 2.46832799e-02f, -1.09276585e-01f, 7.26278499e-02f, 2.50963978e-02f, -4.61255126e-02f, 2.17739373e-01f, -6.41624629e-03f,
  -1.21406996e+00f, 6.19719923e-01f, -1.33759379e-01f, -2.77554125e-01f, -2.32407153e-01f, -4.61802065e-01f, -5.66883311e-02f, 4.16770391e-02f, 8.03602338e-02f, 5.06514668e-01f,
  2.82180905e-01f, 1.18815556e-01f, 4.84492987e-01f, 3.26148033e-01f, -5.64309418e-01f, 4.38987970e-01f, -2.01962307e-01f, -4.98674959e-02f, 6.50864542e-02f, -3.24860126e-01f,
  -2.86291510e-01f, 7.45465979e-02f, -2.87289895e-05f, 2.29332060e-01f, -3.73267084e-01f, -2.52581745e-01f, -3.57116699e-01f, 1.40851811e-01f, -7.88081139e-02f, 6.16623759e-02f,
  -6.61905229e-01f, -1.02052800e-01f, -6.29160702e-02f, -2.13833585e-01f, -3.81823182e-01f, -1.89136699e-01f, -2.89700985e-01f, 9.97729674e-02f, -1.57813355e-01f, -1.36482537e-01f,
  -8.13479573e-02f, -1.88485265e-03f, -3.37775908e-02f, 1.31094649e-01f, -8.19788054e-02f, 5.31993583e-02f, 8.79906788e-02f, 1.31194089e-02f, 1.26174837e-01f, 3.16863181e-03f,
  3.21517527e-01f, 8.19421783e-02f, -8.14911723e-02f, 7.56881386e-02f, -1.12110615e-01f, 1.01202682e-01f, -3.70343551e-02f, -1.49002913e-02f, -8.06152448e-02f, -8.03930536e-02f,
  3.89304245e-04f, -2.06392094e-01f, 8.86280313e-02f, 5.46616763e-02f, 7.25931525e-02f, 9.28502530e-02f, 1.08090773e-01f, -1.89457275e-02f, -5.66311106e-02f, -3.62148099e-02f,
  -3.48278284e-02f, 4.05322723e-02f, 2.56901253e-02f, -1.07655801e-01f, -9.49373767e-02f, -1.49453981e-02f, -1.12733893e-01f, -6.70845062e-02f, -2.56650709e-02f, -2.52466258e-02f,
  4.09420878e-02f, 3.59923616e-02f, 1.74225494e-01f, -1.31972153e-02f, -6.68203682e-02f, -5.91863617e-02f, -4.01549675e-02f, 6.51551560e-02f, 6.30367734e-03f, -1.69954821e-01f,
  -1.06892228e+00f, -6.13920093e-01f, -9.14211050e-02f, 4.79091294e-02f, -1.52716920e-01f, -1.30588159e-01f, -3.43466327e-02f, -8.56364071e-02f, -2.07880557e-01f, -1.13274651e-02f,
  -1.77615464e-01f, -7.72131011e-02f, -2.92625487e-01f, -5.35507575e-02f, 4.53688670e-03f, -4.11037020e-02f, -1.53471813e-01f, -8.90348256e-02f, -3.06358248e-01f, -9.77410153e-02f,
  5.66166714e-02f, 6.94354251e-02f, 5.85951693e-02f, 7.55624995e-02f, -1.18518420e-01f, -1.35464802e-01f, -1.65628105e-01f, 5.61594218e-02f, -1.54861450e-01f, 4.56380397e-02f,
  -6.81372225e-01f, 4.15039241e-01f, 2.95773357e-01f, -7.72042513e-01f, 2.07681969e-01f, -8.60607028e-02f, -5.64109266e-01f, 3.19680929e-01f, -1.91224739e-01f, 3.97214770e-01f,
  -1.44689441e-01f, 7.24879205e-02f, 2.55569607e-01f, -5.81080258e-01f, -6.22802019e-01f, -5.42700350e-01f, -6.28949583e-01f, -4.91832435e-01f, -1.35987669e-01f, -3.31842929e-01f,
  -3.99628431e-01f, -5.73269188e-01f, -4.13615435e-01f, 2.46134505e-01f, 1.84304789e-02f, 4.08927023e-01f, -1.47988304e-01f, 2.88519859e-01f, -8.45934153e-02f, -7.66844973e-02f,
  -1.75594658e-01f, -5.13587445e-02f, 1.79689571e-01f, 1.81430757e-01f, -1.91461518e-02f, 1.61729604e-01f, -1.32117663e-02f, -6.09493330e-02f, -1.26850069e-01f, -2.63057705e-02f,
  1.19056165e-01f, 1.14141263e-01f, -1.01654388e-01f, -2.21158937e-03f, 1.79179639e-01f, 1.74832508e-01f, 1.32585555e-01f, 1.11441493e-01f, 1.43544868e-01f, 4.42034639e-02f,
  -2.18796227e-02f, 1.85001850e-01f, 1.07322581e-01f, -7.25811571e-02f, 7.38922320e-03f, 1.52639896e-01f, -1.14891179e-01f, 1.90408111e-01f, 1.00779533e-01f, -1.90344397e-02f,
  1.72015019e-02f, -5.15391231e-02f, -1.28386160e-02f, 3.44864279e-02f, -1.48466527e-01f, 2.13351399e-01f, -5.15418090e-02f, 2.00121328e-02f, -1.15053020e-02f, 7.51269534e-02f,
  -3.62783298e-02f, 3.87492664e-02f, -3.64852604e-03f, -8.69975388e-02f, -1.19562946e-01f, -1.67067334e-01f, -6.32764446e-03f, 3.00060734e-02f, -1.84713244e-01f, -2.92152204e-02f,
  -1.11697078e-01f, -1.04010940e-01f, -4.97097932e-02f, 3.22984047e-02f, 7.89333135e-02f, 6.57309964e-02f, 1.43543497e-01f, 6.75673261e-02f, -8.14546123e-02f, -7.25321248e-02f,
  -2.89049745e-02f, -1.91430837e-01f, -1.15813185e-02f, 8.92879367e-02f, 3.58259641e-02f, -3.57520729e-02f, -1.20457552e-01f, 4.61334884e-02f, -7.41991922e-02f, -1.22047052e-01f,
  1.70834020e-01f, -1.20611640e-03f, 1.35414517e-02f, -6.82926327e-02f, -9.30639133e-02f, -5.21649979e-02f, -6.90058842e-02f, -1.02323428e-01f, -7.35270306e-02f, 1.02523044e-01f,
  9.37280133e-02f, -3.93796042e-02f, -1.02942422e-01f, -1.57603603e-02f, 8.15984756e-02f, 2.12031621e-02f, -5.30113541e-02f, 1.11164466e-01f, -4.17867750e-02f, 4.24057320e-02f,
  -8.26956213e-01f, -3.46673399e-01f, -9.72944081e-01f, -2.85470158e-01f, 4.89361674e-01f, -5.15884876e-01f, -9.27370861e-02f, -8.67089257e-02f, -1.66994438e-01f, 3.59505296e-01f,
  1.03477433e-01f, -5.07196486e-01f, -1.51363611e-01f, -5.83974898e-01f, -8.77042174e-01f, -6.82804644e-01f, -7.16109097e-01f, -4.62366790e-01f, -3.02546710e-01f, -8.69534016e-02f,
  -2.19114140e-01f, 3.34996492e-01f, -5.40577114e-01f, 6.39615893e-01f, 1.83258504e-01f, 3.21499556e-01f, 5.21946251e-01f, 3.14949095e-01f, 2.04295721e-02f, 5.84905706e-02f,
  -2.42832005e-01f, 6.77676797e-02f, 9.85459983e-03f, 2.40905751e-02f, -9.63319317e-02f, 1.12033486e-01f, -2.99524982e-02f, -5.55451922e-02f, 5.24610281e-02f, -5.57588190e-02f,
  4.23539430e-02f, -1.48001639e-02f, 2.11411268e-02f, 1.04384482e-01f, 5.55159561e-02f, -8.11099336e-02f, -2.07236826e-01f, -8.80974233e-02f, -7.78006390e-02f, -3.34489465e-01f,
  -2.84310371e-01f, -2.01390937e-01f, -3.74297388e-02f, -8.44880864e-02f, -1.30288064e-01f, 7.16256201e-02f, -8.14368352e-02f, -8.07416439e-02f, -1.41371146e-01f, -1.69298410e-01f,
  2.37316508e-02f, 1.42193034e-01f, 9.40806232e-03f, -7.98159745e-03f, 2.04856955e-02f, 1.38053492e-01f, 3.52075920e-02f, 6.05317950e-02f, 6.07404411e-02f, -8.27438757e-02f,
  3.71752270e-02f, -6.71452209e-02f, 2.73758471e-02f, -7.20682591e-02f, -3.52819152e-02f, 4.52688113e-02f, 2.10967381e-03f, -2.55966540e-02f, -8.41799006e-02f, -1.83222547e-01f,
  2.18076095e-01f, -1.08078495e-01f, -1.41808865e-04f, 4.19550613e-02f, -1.14991046e-01f, 5.23088016e-02f, 1.02633312e-01f, -1.62970781e-01f, -2.32858043e-02f, 5.48091270e-02f,
  -3.35336417e-01f, -2.72730701e-02f, 6.85167536e-02f, 5.92835173e-02f, 7.31345564e-02f, 5.28050736e-02f, -6.20907247e-02f, -4.27481160e-02f, -8.04036930e-02f, 4.46836017e-02f,
  9.16294977e-02f, 1.54161349e-01f, 4.65884581e-02f, -5.19482605e-02f, 7.09143355e-02f, -5.75742684e-02f, 1.36772484e-01f, 1.24289058e-01f, 2.37620741e-01f, -7.14078592e-03f,
  1.38160348e-01f, 1.95900574e-01f, 1.17976047e-01f, 1.04344614e-01f, 1.73687845e-01f, 1.06894746e-01f, 1.65004209e-02f, 9.97583661e-03f, 1.65815335e-02f, 4.98927124e-02f,
  -9.79621187e-02f, 2.06745982e-01f, -5.82707465e-01f, 9.10003185e-02f, -4.35987771e-01f, -3.12289715e-01f, -2.40790576e-01f, 3.34149413e-02f, -4.68300462e-01f, 5.32295644e-01f,
  6.01950288e-01f, -3.13854665e-01f, 4.19700563e-01f, 8.46008480e-01f, 2.65955180e-01f, 6.04274154e-01f, 6.74996436e-01f, 4.64394480e-01f, -2.34522149e-02f, 3.48623335e-01f,
  3.70781243e-01f, 7.83490658e-01f, 5.27898908e-01f, 3.99468184e-01f, 3.47022772e-01f, -9.16310474e-02f, 4.92069453e-01f, -3.01942229e-01f, 5.07677555e-01f, 6.66562142e-03f,
  -6.62764907e-03f, 2.20465392e-01f, -5.46130501e-02f, -1.80257693e-01f, 1.06871977e-01f, -7.18179792e-02f, -6.84005022e-02f, -2.01926619e-01f, -1.71823174e-01f, -1.71265081e-02f,
  -8.62125605e-02f, 5.46282195e-02f, 4.59215268e-02f, -1.58606470e-01f, -1.14184946e-01f, -1.28386587e-01f, -2.24140920e-02f, -1.71296030e-01f, -1.46133736e-01f, 6.27387082e-03f,
  -1.87774718e-01f, -1.32467542e-02f, 1.86163634e-02f, 1.56538561e-01f, -6.83197454e-02f, -3.45865004e-02f, -7.10998327e-02f, -2.58886274e-02f, 1.50289750e-02f, -9.35854465e-02f,
  9.41788554e-02f, 8.55977740e-03f, 1.65017217e-01f, 1.86004378e-02f, -1.88486371e-02f, 4.29936871e-02f, 2.12891065e-02f, 5.31126484e-02f, -9.83630493e-02f, 2.42043331e-01f,
  -1.56119764e-02f, -1.21338002e-01f, -1.88708697e-02f, -5.95966689e-02f, 1.14609182e-01f, -1.07323594e-01f, -4.22722995e-02f, 1.91989429e-02f, -3.44743654e-02f, -1.11329798e-02f,
  3.17475460e-02f, -9.17275250e-02f, 5.90447783e-02f, -2.82754432e-02f, 5.69380522e-02f, 2.61801369e-02f, 1.91181034e-01f, -1.34687871e-02f, -3.95991765e-02f, -2.16342583e-02f,
  1.36049494e-01f, 4.62414384e-01f, -4.55544032e-02f, -1.20337062e-01f, -2.21607666e-02f, 9.31661651e-02f, 6.35763630e-02f, -5.20736240e-02f, 5.20920753e-02f, -6.48625381e-03f,
  2.13225242e-02f, -1.68416202e-02f, 1.85307294e-01f, -1.09114528e-01f, -5.81557080e-02f, 2.61574417e-01f, 1.78888977e-01f, -2.03085899e-01f, 6.73015416e-02f, 1.95582941e-01f,
  1.33286733e-02f, -8.78447816e-02f, 4.21392284e-02f, -1.30534261e-01f, -6.17089495e-02f, 1.49422094e-01f, -1.30384982e-01f, -1.22554138e-01f, 1.35228768e-01f, 1.50407463e-01f,
  -8.34896028e-01f, -1.98456064e-01f, 1.62800446e-01f, 1.71521157e-01f, 6.15331866e-02f, -4.05201197e-01f, -6.23481691e-01f, -2.76950836e-01f, -2.56650895e-01f, -8.25639069e-01f,
  -3.59553427e-01f, -1.60065383e-01f, -5.65212727e-01f, 1.96365342e-01f, 5.05198598e-01f, -1.57814682e-01f, 5.19994795e-01f, 7.79225081e-02f, 3.32581401e-01f, 1.56246439e-01f,
  4.91713643e-01f, 1.99942261e-01f, 6.22667015e-01f, 4.44114417e-01f, 8.59619677e-02f, 6.56789720e-01f, 5.32076597e-01f, 5.86457849e-01f, 7.13981867e-01f, 4.29387480e-01f,
  -1.05334006e-01f, -2.43187547e-01f, -6.11578636e-02f, 1.18284784e-01f, -2.35212874e-02f, -9.18356031e-02f, 1.63634419e-01f, -1.03344480e-02f, 5.34857251e-02f, 7.39802495e-02f,
  -1.62519291e-01f, 2.05933511e-01f, 6.02426492e-02f, 8.44782144e-02f, -6.18062122e-03f, 9.78720114e-02f, 7.22181052e-02f, -5.56504019e-02f, 8.46043974e-02f, -2.02829793e-01f,
  -2.56996229e-03f, -1.09031178e-01f, -1.33449528e-02f, 1.38878420e-01f, 2.22067758e-01f, -1.51716294e-02f, 3.37653011e-02f, 3.89522277e-02f, -4.65754867e-02f, -5.12368605e-02f,
  4.01429981e-02f, -8.21301118e-02f, -7.87517652e-02f, -1.11534245e-01f, -3.86302397e-02f, 1.19447690e-02f, 3.04048993e-02f, -4.68491167e-02f, 1.21634603e-01f, -9.87331718e-02f,
  -8.19982681e-03f, 5.67406006e-02f, 2.90796645e-02f, -1.74383208e-01f, -5.63590340e-02f, -3.06365639e-01f, 1.23353146e-01f, 1.11524472e-02f, 8.45008194e-02f, -1.96232319e-01f,
  -1.40128076e-01f, 1.22779369e-01f, -4.49985415e-02f, 1.74177010e-02f, -8.35012272e-02f, -1.28433302e-01f, -5.86908460e-02f, -7.19716996e-02f, -4.47227731e-02f, 1.36467651e-01f,
  1.92614883e-01f, 5.41716278e-01f, 1.25005826e-01f, -1.46432268e-02f, -6.60173222e-03f, -1.13383003e-01f, 2.22027183e-01f, 6.48903921e-02f, 2.33050644e-01f, -2.98029222e-02f,
  -2.31550727e-02f, 9.56652090e-02f, -2.28070289e-01f, 4.85332534e-02f, 9.00313407e-02f, -1.67080253e-01f, 1.10375911e-01f, 6.29299134e-02f, 8.74995962e-02f, 1.45362303e-01f,
  -4.49803192e-03f, -1.09283619e-01f, 8.30411837e-02f, 1.50751710e-01f, -1.68946847e-01f, -1.59793705e-01f, -6.30945116e-02f, -1.99673139e-03f, 1.75098792e-01f, 1.14353091e-01f,
  -1.09619141e+00f, 8.85111511e-01f, 1.36742800e-01f, -2.02928111e-02f, -5.05687535e-01f, 5.97264290e-01f, 3.50493103e-01f, 3.16965967e-01f, 5.43037951e-01f, 4.06346500e-01f,
  -2.67238826e-01f, -1.84914887e-01f, 2.57907212e-01f, 3.89898390e-01f, -2.40271777e-01f, 6.40664160e-01f, 3.53857458e-01f, 1.69558540e-01f, 3.89706582e-01f, -2.26266220e-01f,
  -4.44548950e-02f, -2.33288556e-01f, 5.53363282e-03f, -2.83768121e-02f, -4.17868406e-01f, -1.77680552e-01f, -5.60881495e-01f, -1.08769303e-02f, -2.81177253e-01f, -4.08174433e-02f,
  -2.78474987e-01f, -5.03387377e-02f, -3.68029386e-01f, -1.87244210e-02f, -4.81033213e-02f, -9.47064683e-02f, -5.86803071e-02f, -6.04732707e-02f, 3.70684545e-03f, 9.43543017e-02f,
  -1.11794397e-01f, 2.69843987e-03f, 4.74363267e-02f, 4.28899266e-02f, 8.66220798e-03f, -4.97178435e-02f, 1.49586901e-01f, 7.16830790e-02f, -6.13694116e-02f, 1.32936891e-02f,
  3.96723822e-02f, 1.44708425e-01f, 3.64172570e-02f, 8.97304043e-02f, -3.16351838e-02f, 9.61736515e-02f, 1.71340629e-01f, -1.26362205e-01f, -6.51996210e-02f, 1.17561951e-01f,
  -1.28707245e-01f, 1.56730786e-01f, 6.97954372e-02f, -3.66226770e-02f, 2.02779248e-02f, 7.39880139e-04f, -2.70186309e-02f, -1.18698709e-01f, 5.62328249e-02f, -1.06799617e-01f,
  -4.91735414e-02f, -1.95962526e-02f, -4.35802154e-03f, 9.13539156e-02f, 9.73474905e-02f, 6.52899146e-02f, -6.63134158e-02f, -7.17946962e-02f, 6.96154460e-02f, 7.66787957e-03f,
  -5.23154438e-03f, -1.59694515e-02f, -5.35103679e-02f, -9.46028829e-02f, 7.90964514e-02f, -8.42616253e-04f, 5.99823706e-02f, 2.55921055e-02f, -9.42904800e-02f, -1.79073974e-01f,
  2.68211335e-01f, 3.99274409e-01f, -4.22814786e-02f, -1.33363158e-01f, 7.20447972e-02f, -4.22692932e-02f, 5.85447475e-02f, -8.05788264e-02f, 1.78795815e-01f, 1.87001862e-02f,
  -9.86285061e-02f, -6.52707973e-03f, -5.62141165e-02f, -1.42047063e-01f, 1.58174917e-01f, 1.29271030e-01f, -4.76505272e-02f, 6.22923635e-02f, 1.85758267e-02f, 5.81803638e-03f,
  -2.92472601e-01f, -4.31814529e-02f, 2.22935621e-02f, 1.36606479e-02f, -1.13779575e-01f, -1.08440109e-01f, -4.80511412e-02f, 3.20707238e-03f, -1.15770392e-01f, 2.04425916e-01f,
  8.64481747e-01f, -4.19552892e-01f, -3.63329828e-01f, 3.38199794e-01f, 3.35283518e-01f, 6.75645590e-01f, 5.50583482e-01f, 3.68062586e-01f, 5.08473754e-01f, -2.06450477e-01f,
  4.29985533e-03f, -3.19574997e-02f, -4.52389479e-01f, 4.22608346e-01f, 7.94801474e-01f, -2.87906498e-01f, 5.68257093e-01f, 2.72124976e-01f, 1.50219157e-01f, 2.54209816e-01f,
  4.04942036e-01f, 7.16067731e-01f, -2.53940016e-01f, 7.31065944e-02f, 2.45780304e-01f, -3.20992619e-01f, -2.62782604e-01f, -4.54160333e-01f, -3.44677344e-02f, 2.52414882e-01f,
  1.10138245e-01f, 3.24365646e-02f, -8.25294182e-02f, -2.78643668e-02f, -4.03700322e-02f, -1.14157155e-01f, -9.68834087e-02f, -2.93035321e-02f, 6.16663285e-02f, 2.30747927e-02f,
  -3.31767686e-02f, 1.53366759e-01f, 2.82749087e-01f, -5.69196534e-04f, 2.30736300e-01f, 3.10772285e-02f, -5.08692972e-02f, -2.06255212e-01f, -9.98100266e-02f, -9.33598429e-02f,
  -1.40637428e-01f, -8.23113248e-02f, 2.35464405e-02f, -1.07507452e-01f, -6.00619093e-02f, 9.04821604e-02f, -5.41459695e-02f, -1.64733469e-01f, 3.98165695e-02f, 1.85462281e-01f,
  7.73367807e-02f, -1.55069148e-02f, -1.04598785e-02f, -1.95825845e-02f, 6.98745623e-02f, -1.54447388e-02f, 9.24303755e-03f, -8.11387151e-02f, 2.46370640e-02f, 7.00680446e-03f,
  4.87499945e-02f, 9.76205766e-02f, 3.32293548e-02f, 6.26114905e-02f, 1.30388230e-01f, 3.14313136e-02f, -7.82861114e-02f, 5.34961885e-03f, -7.75918365e-02f, -1.68359261e-02f,
  -9.56415832e-02f, 1.37165695e-01f, -5.49657978e-02f, -9.59232748e-02f, 7.69968927e-02f, -4.53591421e-02f, 8.23558867e-02f, -2.96100359e-02f, -1.02489680e-01f, -6.46683797e-02f,
  6.44652024e-02f, 5.78828640e-02f, -8.63238424e-02f, 2.12571882e-02f, -1.25617832e-01f, 1.68996841e-01f, 5.73569424e-02f, 1.85468465e-01f, 6.21882342e-02f, 1.15775473e-01f,
  8.46137106e-02f, -4.40419652e-02f, -1.19241318e-02f, -1.77933779e-02f, -7.61767253e-02f, 1.25806808e-01f, -7.23955408e-02f, -3.87576222e-02f, 9.68240649e-02f, -3.73777822e-02f,
  -6.95564598e-02f, 8.39879513e-02f, 1.09969720e-01f, 9.81515571e-02f, -2.12286762e-03f, -6.24120645e-02f, 1.02715738e-01f, -6.86308965e-02f, -1.47059619e-01f, -1.11550540e-01f,
  2.22470641e-01f, -5.11161625e-01f, 2.81112611e-01f, 6.35029495e-01f, -1.88634470e-01f, 3.28382581e-01f, 9.13260281e-01f, -5.08346498e-01f, -2.22830810e-02f, -2.04075724e-01f,
  1.44093364e-01f, 3.11418205e-01f, 5.15677691e-01f, 2.95998126e-01f, 4.09632415e-01f, 2.90187061e-01f, 2.21887156e-01f, 3.75271142e-01f, -2.39671573e-01f, -1.12488959e-02f,
  -1.08541340e-01f, -2.24390179e-01f, 3.62397611e-01f, -7.32214510e-01f, 1.03351660e-01f, -3.25021535e-01f, -2.33961791e-01f, 1.76983118e-01f, -3.00771177e-01f, 1.23068079e-01f,
  1.91035494e-02f, -1.28168106e-01f, 7.11291283e-02f, -1.47950545e-01f, -3.64563987e-02f, 4.25626263e-02f, 2.86580205e-01f, 2.48274505e-01f, 1.31385654e-01f, -3.33440267e-02f,
  2.32868254e-01f, -4.03059199e-02f, -2.80106455e-01f, 1.13781281e-01f, -4.85973582e-02f, -2.10672095e-01f, -2.15855036e-02f, 6.82246834e-02f, -3.29122655e-02f, 3.71937752e-02f,
  1.55379176e-01f, 5.61842583e-02f, 1.64721563e-01f, -3.08460686e-02f, -3.11008543e-02f, -5.35576455e-02f, 1.79363340e-01f, 2.15961829e-01f, 5.38060181e-02f, -6.95866570e-02f,
  -1.01385430e-01f, -6.20191023e-02f, 3.42085883e-02f, -6.62155896e-02f, 4.24458794e-02f, -4.48639393e-02f, 4.86050500e-03f, -9.62321740e-03f, 2.75796764e-02f, 8.94816443e-02f,
  -7.03754742e-03f, 6.75847530e-02f, -4.97550108e-02f, 3.76076996e-02f, -3.27880085e-02f, 5.25891334e-02f, 1.67117074e-01f, 2.72131115e-02f, 9.18364748e-02f, 8.50419234e-03f,
  4.22938727e-02f, -5.90879358e-02f, -3.03642023e-02f, 6.29732758e-02f, -8.60696658e-02f, -1.25406105e-02f, -1.77581087e-01f, 1.25554681e-01f, -1.83694009e-02f, 3.60817015e-02f,
  -3.82855862e-01f, -5.45292318e-01f, -4.65019532e-02f, -5.26165180e-02f, -7.21895397e-02f, -1.70509666e-01f, -1.92346107e-02f, -2.82472879e-01f, -2.59271283e-02f, -4.03147154e-02f,
  -2.38940313e-01f, 1.07873537e-01f, -1.68591231e-01f, 6.60627894e-03f, -9.29684192e-02f, -7.36682788e-02f, 1.45742193e-01f, 6.93920106e-02f, -8.63214731e-02f, -2.17673048e-01f,
  -8.30747746e-03f, 6.17677011e-02f, -7.38661503e-03f, -1.09457254e-01f, -8.84910896e-02f, 5.22530191e-02f, -1.87976822e-01f, 8.24205112e-03f, -8.81034229e-03f, 4.92892228e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  4.32903677e-01f, 3.47788274e-01f, 8.86744380e-01f, 7.01344609e-01f, 5.64802706e-01f, 6.96574152e-01f, 4.51464891e-01f, 8.14132154e-01f, 6.20350480e-01f, 5.86610615e-01f,
  3.83901119e-01f, 7.28399158e-01f, 8.03933561e-01f, 5.49112260e-01f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  2.62928188e-01f, 2.22368300e-01f, -6.37963265e-02f, -4.80536431e-01f, -5.73371112e-01f, 4.67874156e-03f, -3.87013793e-01f, -1.68044060e-01f, 1.21023647e-01f, -2.12429956e-01f,
  -3.60514551e-01f, 1.49785191e-01f, 2.59306818e-01f, 9.05104280e-02f, 1.10576086e-01f, -4.66372460e-01f, -1.48122190e-02f, -1.22722588e-01f, -1.34275362e-01f, -4.12769645e-01f,
  -1.11529626e-01f, 2.43270218e-01f, 1.20223358e-01f, 8.15060213e-02f, -5.12619793e-01f, 5.71244001e-01f, 1.90113917e-01f, -2.40122199e-01f, -1.70857802e-01f, 4.96332258e-01f,
  -2.11157829e-01f, 3.18108022e-01f, 5.18912852e-01f, 3.84056419e-01f, 3.24707896e-01f, -5.58366537e-01f, -3.15147430e-01f, 1.25638500e-01f, -2.39055380e-01f, -9.45268497e-02f,
  4.08653766e-01f, 4.31178808e-01f, 4.29712206e-01f, 3.29371423e-01f, 3.00294071e-01f, 3.41469496e-01f, -3.86704028e-01f, -2.07781836e-01f, 5.11399984e-01f, -2.45848596e-01f,
  -2.76849836e-01f, -6.04188085e-01f, -4.69496757e-01f, -2.17872366e-01f, 5.05401194e-02f, -5.23528516e-01f, 6.42170548e-01f, -6.73429608e-01f, -1.46013528e-01f, 6.66580915e-01f,
  -7.02204823e-01f, 5.35485148e-01f, -6.34633303e-01f, 3.49611133e-01f, 1.96257725e-01f, -1.94315732e-01f, -2.08293498e-01f, 3.22401762e-01f, 4.41688329e-01f, -4.04357404e-01f,
  3.35214823e-01f, -1.72790289e-01f, 1.93714965e-02f, 3.46220993e-02f, 3.16018343e-01f, 3.58155698e-01f, 2.61919677e-01f, 3.48667890e-01f, 5.81162907e-02f, -3.77149820e-01f,
  -1.33212849e-01f, 8.26015100e-02f, 9.18442234e-02f, 3.25435638e-01f, 1.75182357e-01f, -5.49670100e-01f, 1.53051615e-01f, -6.00038111e-01f, -2.27616712e-01f, 1.10889144e-01f,
  -7.11412549e-01f, -4.15345192e-01f, -7.19931424e-01f, -1.74362928e-01f, 7.48162985e-01f, -3.24284792e-01f, 6.93191886e-02f, -4.73602384e-01f, -4.25050944e-01f, -3.29947323e-01f,
  2.65666544e-01f, 2.66370535e-01f, 1.88934058e-01f, 6.66072369e-01f, 2.96143353e-01f, -2.37547874e-01f, -6.20292723e-01f, -3.70889306e-02f, -5.40211909e-02f, 7.76743174e-01f,
  -5.42221427e-01f, -2.09319010e-01f, 5.96980929e-01f, -3.42600942e-01f, -4.83919740e-01f, 3.28283876e-01f, 3.25401604e-01f, -7.93191373e-01f, -5.98631382e-01f, -7.05683589e-01f,
  -5.07581770e-01f, -4.82503176e-01f, -4.38163251e-01f, 5.74058115e-01f, -6.54741645e-01f, -2.89735347e-01f, 6.12912416e-01f, -2.86350816e-01f, -3.18486750e-01f, 2.00627133e-01f,
  -3.38281319e-02f, 2.86110401e-01f, -3.43514681e-01f, -2.57929843e-02f, -1.60771251e-01f, -1.67234764e-02f, -2.69615293e-01f, -2.35470891e-01f, 1.38167918e-01f, -2.63032436e-01f,
  -2.82396495e-01f, -3.17422897e-01f, -4.36661243e-01f, -2.86498573e-02f, -2.22180948e-01f, 2.27296744e-02f, -3.34327459e-01f, -4.25637305e-01f, 2.24045917e-01f, -3.70533109e-01f,
  -2.50848353e-01f, -6.20662689e-01f, 2.76073907e-02f, 5.68090260e-01f, 4.08466548e-01f, -2.66951561e-01f, -1.37363330e-01f, -3.84729773e-01f, 2.62532502e-01f, -1.65863320e-01f,
  7.51692131e-02f, -3.37639689e-01f, -2.84440845e-01f, -2.24829257e-01f, 2.31466085e-01f, -4.91595328e-01f, 3.64563078e-01f, -3.35200578e-01f, 5.30506432e-01f, 2.22937405e-01f,
  5.98721921e-01f, -4.33491558e-01f, -3.58177990e-01f, 2.09993310e-02f, -3.44231397e-01f, 1.23260997e-01f, 2.29947805e-01f, -4.28713083e-01f, -2.09255055e-01f, -3.95668954e-01f,
  -3.05297107e-01f, -1.71374083e-01f, -4.00496185e-01f, 6.63448691e-01f, -3.86032403e-01f, -4.71879661e-01f, 3.70585293e-01f, -2.98674285e-01f, 6.70224369e-01f, -4.98406678e-01f,
  3.66989970e-01f, -3.49826097e-01f, -8.22534934e-02f, -3.39861661e-01f, -3.80800098e-01f, 3.55046019e-02f, -4.17966098e-01f, -2.06505123e-04f, -3.88939261e-01f, -2.85346389e-01f,
  -4.32831049e-01f, -2.40584821e-01f, -2.06560716e-01f, 5.65245301e-02f, 1.27684206e-01f, 1.05034843e-01f, -5.80749929e-01f, 1.24633588e-01f, 4.84912992e-02f, -1.28019368e-02f,
  -8.31870660e-02f, -4.06466126e-01f, 2.19111447e-03f, -3.05351228e-01f, -1.54617071e-01f, -1.82166293e-01f, 1.66910976e-01f, -1.63837388e-01f, 3.82321268e-01f, 5.25834970e-02f,
  1.96931481e-01f, 5.64721189e-02f, -1.31137623e-02f, 3.87388766e-01f, -1.67473361e-01f, 5.03846884e-01f, 1.58955127e-01f, 6.11311078e-01f, -1.19628020e-01f, 5.14849186e-01f,
  5.64817965e-01f, 2.71317154e-01f, -2.84339875e-01f, -4.83701497e-01f, 4.71557796e-01f, -4.54474360e-01f, -7.16910735e-02f, 5.83273411e-01f, 4.92911249e-01f, 1.57209456e-01f,
  -4.91283417e-01f, 2.71581262e-01f, -7.93721378e-01f, -1.38523981e-01f, -2.10132629e-01f, -3.75935197e-01f, 3.84776145e-02f, -4.03647453e-01f, 7.36306250e-01f, 4.01146948e-01f,
  5.73352814e-01f, -2.68682718e-01f, -6.74828887e-01f, -7.90938139e-02f, -2.64397293e-01f, -6.83483243e-01f, -3.94909054e-01f, 1.70724541e-01f, 1.66330412e-01f, 1.52149603e-01f,
  2.72900552e-01f, 1.47614104e-03f, 7.32932910e-02f, 2.44688615e-01f, 3.92508984e-01f, 1.34617448e-01f, 2.50886470e-01f, -1.13534614e-01f, 1.08341016e-01f, -5.34510501e-02f,
  4.52966303e-01f, 3.50468636e-01f, -8.80395249e-02f, 1.65683597e-01f, -1.61963016e-01f, 1.84519410e-01f, 2.76104569e-01f, 8.75182822e-02f, 6.11469746e-01f, 2.47016940e-02f,
  2.08292559e-01f, -5.83805680e-01f, -6.03247225e-01f, 8.00175428e-01f, -4.02524978e-01f, -2.39134043e-01f, -4.37465280e-01f, 7.05136597e-01f, -9.05888200e-01f, -8.16109702e-02f,
  -8.06292892e-01f, -1.66008472e-01f, -8.32954198e-02f, 1.11908175e-01f, -2.70676881e-01f, -1.36182487e-01f, -1.18762113e-01f, 6.26391172e-01f, -1.43223599e-01f, -6.92213058e-01f,
  5.45600176e-01f, -3.59096348e-01f, 2.46583834e-01f, 2.06958309e-01f, -2.66913921e-01f, -7.35550284e-01f, -5.04440308e-01f, 1.65407181e-01f, -6.69548929e-01f, -4.98719096e-01f,
  4.28845912e-01f, 4.12676305e-01f, 3.99814963e-01f, 4.07236665e-01f, -8.90642405e-01f, -1.73599347e-01f, 5.49018383e-01f, 4.52462822e-01f, -8.01669180e-01f, -5.77937841e-01f,
  -2.68328607e-01f, 2.88952619e-01f, 5.37108779e-01f, 1.10701412e-01f, 2.91924268e-01f, 3.16053301e-01f, -1.59368008e-01f, -3.07179004e-01f, -2.09994335e-02f, 9.18906406e-02f,
  2.81856139e-03f, -1.13143191e-01f, -2.01828793e-01f, 7.79394619e-03f, -5.39593250e-02f, 5.59269905e-01f, 1.29926324e-01f, 2.81896323e-01f, 1.87185481e-01f, 1.08564593e-01f,
  1.19804002e-01f, 3.27713519e-01f, -6.15835786e-01f, 5.22139549e-01f, 5.32362819e-01f, -5.25396585e-01f, -2.22825110e-01f, -4.70643282e-01f, 2.09505185e-01f, 4.45584714e-01f,
  1.95650589e-02f, 8.31863955e-02f, 7.03615844e-01f, -4.75611150e-01f, -1.14974901e-01f, 7.24822342e-01f, -4.10231352e-01f, 2.40292341e-01f, -5.40220380e-01f, 9.97394770e-02f,
  3.27478170e-01f, -7.04829037e-01f, -3.58773559e-01f, 6.35180175e-01f, 6.49820030e-01f, -8.65136802e-01f, 3.73243749e-01f, -4.84388262e-01f, -6.57247722e-01f, 1.65970251e-02f,
  5.88451147e-01f, -3.65280539e-01f, 3.42192501e-01f, -5.67459404e-01f, -3.63011301e-01f, -6.67236090e-01f, -2.89762288e-01f, -7.87245095e-01f, -4.85469937e-01f, -5.12480795e-01f,
  3.93262833e-01f, 6.37097657e-01f, 1.85139239e-01f, -9.19782743e-02f, 3.56202312e-02f, -3.98864262e-02f, -2.30254188e-01f, -3.94414902e-01f, -2.71569341e-01f, 3.17347825e-01f,
  -4.73506674e-02f, 1.62947088e-01f, 8.10307916e-03f, -4.07267660e-02f, -7.61498511e-02f, 1.71933777e-03f, 6.06072061e-02f, 3.03108096e-01f, 3.55816960e-01f, 2.19385773e-01f,
  -2.05303133e-02f, 6.73072040e-02f, -1.70217939e-02f, -1.47508070e-01f, 2.38399282e-02f, 2.63233125e-01f, 9.11503509e-02f, 1.46746323e-01f, 1.74768046e-01f, -5.04437029e-01f,
  -3.15303802e-01f, -2.76140809e-01f, 5.77133775e-01f, -4.77327168e-01f, -6.50172293e-01f, -5.20319223e-01f, 8.77913833e-02f, -3.62170368e-01f, 5.36745310e-01f, 6.75128222e-01f,
  6.52264714e-01f, 6.54254913e-01f, -7.41292089e-02f, 2.56023794e-01f, -3.24539803e-02f, 5.80055416e-01f, 7.93719590e-02f, -3.47567081e-01f, -8.34405243e-01f, -1.20639615e-01f,
  5.30236483e-01f, 6.02882244e-02f, -1.05158649e-01f, 1.44235060e-01f, 8.97434056e-02f, -2.97584832e-01f, -9.74182904e-01f, 9.87911582e-01f, -9.06042159e-01f, -2.23217010e-01f,
  -5.02616525e-01f, -4.45449442e-01f, 7.32541606e-02f, -5.64841151e-01f, -5.15308142e-01f, -6.79505885e-01f, 6.02082074e-01f, 2.15029716e-01f, -1.31119251e-01f, -7.69649120e-03f,
  -1.30191073e-01f, -1.71738401e-01f, 8.22047517e-03f, -2.83843279e-01f, 1.34496465e-01f, -8.17484185e-02f, -2.43918329e-01f, -1.42939270e-01f, -1.54062048e-01f, -3.02786022e-01f,
  -3.73127609e-01f, -5.36368713e-02f, -1.93384036e-01f, -4.67595041e-01f, 3.33369076e-02f, -4.62680697e-01f, -1.13923997e-01f, -1.72214627e-01f, -1.59426227e-01f, -1.20080009e-01f,
  1.00520365e-01f, -1.86553027e-03f, -2.96914071e-01f, 3.45617801e-01f, -1.50567398e-03f, 2.90219396e-01f, 1.23664424e-01f, 1.70161784e-01f, -1.90827981e-01f, 9.85387638e-02f,
  -5.03131524e-02f, 2.33690381e-01f, 3.96910936e-01f, 3.16946507e-01f, -1.49347847e-02f, -2.42449060e-01f, 2.43871763e-01f, 1.36839464e-01f, -2.29549214e-01f, -3.09574127e-01f,
  3.13691497e-01f, 3.46095860e-01f, -4.77782786e-01f, -3.65233034e-01f, 2.97506362e-01f, 3.20454948e-02f, 1.20622166e-01f, 3.80207360e-01f, 7.19011605e-01f, 4.49939758e-01f,
  -3.98354501e-01f, -4.32859331e-01f, 4.60741699e-01f, 4.74254519e-01f, 6.03755116e-02f, 5.45683363e-03f, -2.83748806e-01f, -6.18201382e-02f, -7.81432167e-02f, -3.01497102e-01f,
  -4.14370716e-01f, -7.44802237e-01f, -1.09363586e-01f, -3.14992875e-01f, -5.93847334e-02f, -3.79605025e-01f, 1.31326139e-01f, 1.92578763e-01f, 1.56713903e-01f, 1.53178170e-01f,
  1.51337963e-02f, -1.24800935e-01f, -8.19518492e-02f, -4.37282205e-01f, -5.42339563e-01f, -4.52658325e-01f, -2.44330354e-02f, -1.14424817e-01f, 7.50391884e-03f, -4.60499406e-01f,
  9.87219973e-04f, -4.32269648e-02f, 5.97608499e-02f, 2.26525024e-01f, -6.59582242e-02f, 2.35726252e-01f, -2.26386234e-01f, 3.95588189e-01f, 4.18176413e-01f, -2.75591165e-01f,
  3.89435470e-01f, 2.12908506e-01f, -2.74824128e-02f, -3.45897079e-01f, -1.27909616e-01f, 5.51972806e-01f, -3.70369852e-01f, 3.16387683e-01f, 2.48738334e-01f, -2.63879091e-01f,
  4.08180028e-01f, -2.31457695e-01f, -5.85840344e-01f, -3.49640012e-01f, -3.22228760e-01f, 3.88492197e-01f, -3.50860387e-01f, 1.85630769e-01f, 3.87081712e-01f, 3.66487145e-01f,
  -3.30553532e-01f, 5.18210948e-01f, -2.35623673e-01f, -3.54167134e-01f, 2.89234638e-01f, 8.03166702e-02f, -2.23703250e-01f, -7.28578150e-01f, -3.64392757e-01f, -5.59945166e-01f,
  -3.88799727e-01f, 5.47965407e-01f, 6.93494678e-01f, -2.24791933e-03f, -2.31212929e-01f, -4.16011840e-01f, 1.43866852e-01f, -2.92125136e-01f, 2.69004107e-01f, 2.64791310e-01f,
  -1.14832439e-01f, -3.31506759e-01f, 2.14873716e-01f, 3.27790529e-01f, 6.62028044e-02f, 2.66952872e-01f, -2.67138988e-01f, 2.22395640e-02f, 3.08985412e-01f, -1.46201044e-01f,
  -1.10125579e-01f, -5.05367406e-02f, 6.31074468e-03f, 1.89516380e-01f, 1.03695139e-01f, 2.50672370e-01f, -3.38182896e-01f, 1.51700735e-01f, 7.06787396e-04f, 1.83177173e-01f,
  1.62485406e-01f, 3.53891581e-01f, -3.50511491e-01f, -4.06783432e-01f, -4.38949943e-01f, -3.95085037e-01f, -3.45659584e-01f, -3.46609503e-01f, 2.71547019e-01f, -2.85651833e-02f,
  4.48114514e-01f, -5.66046476e-01f, -6.33920014e-01f, -1.60946175e-01f, 3.23488474e-01f, -4.88103598e-01f, -5.78670442e-01f, 2.19836026e-01f, 2.87734927e-03f, -4.12809789e-01f,
  2.44169712e-01f, -3.56230348e-01f, -4.14623976e-01f, -5.50580382e-01f, -9.91914347e-02f, 1.18724048e-01f, 1.22182025e-02f, 1.75487027e-01f, -3.58240992e-01f, -5.79751790e-01f,
  7.15209246e-01f, 4.12743568e-01f, -4.44307089e-01f, -5.12265563e-01f, -3.39751810e-01f, -7.24696219e-01f, -3.05458605e-01f, -7.98870623e-01f, -2.52723992e-01f, 7.69399345e-01f,
  1.71155870e-01f, 1.86706945e-01f, -6.12202063e-02f, 1.02679707e-01f, 1.80453762e-01f, 2.23934099e-01f, 2.17775598e-01f, -1.16741493e-01f, 3.36296678e-01f, 2.02350929e-01f,
  1.93379730e-01f, 2.65042424e-01f, -1.52407503e-02f, 3.51159483e-01f, 2.99469411e-01f, 2.03522220e-02f, 2.75477897e-02f, 4.56774272e-02f, 3.62661630e-02f, 2.64279693e-01f,
  -4.32343125e-01f, 9.75055546e-02f, -2.87222475e-01f, 1.40181988e-01f, 1.30019858e-01f, -8.50129128e-02f, 1.78202003e-01f, 5.34661114e-01f, -8.57109129e-02f, 4.33894843e-01f,
  1.56326085e-01f, -5.16916454e-01f, -4.29977089e-01f, -1.57926977e-01f, 5.27920187e-01f, -3.53218973e-01f, -5.78260005e-01f, -5.26324511e-01f, -5.20292997e-01f, 5.08786261e-01f,
  4.59684432e-01f, 3.70393604e-01f, -4.36090022e-01f, 5.30427098e-01f, -1.08293869e-01f, 3.35831970e-01f, -5.70904732e-01f, 4.15682554e-01f, 7.08313048e-01f, 4.04285401e-01f,
  -2.05067396e-01f, -5.62323570e-01f, 3.21492106e-01f, -5.91591001e-01f, -2.75207877e-01f, 1.13178372e-01f, -1.08483195e+00f, 4.09549683e-01f, 7.14628696e-01f, -2.32678607e-01f,
  -9.02872607e-02f, -5.64058304e-01f, -6.09524906e-01f, -4.87358332e-01f, 1.60013884e-01f, 1.33807376e-01f, 1.16248503e-01f, -1.97625205e-01f, 6.14508390e-02f, -1.60368875e-01f,
  5.34999445e-02f, 1.67174309e-01f, -8.38630795e-02f, -1.29520399e-02f, -6.34569451e-02f, -1.43536389e-01f, 1.29894748e-01f, -1.79237515e-01f, -2.01823022e-02f, 1.64135858e-01f,
  6.73398823e-02f, 2.29976535e-01f, 1.61768124e-01f, 2.01675951e-01f, 2.35012695e-01f, -8.18340853e-02f, 2.67228931e-01f, -2.12301031e-01f, 1.33632988e-01f, -2.14595556e-01f,
  4.59149539e-01f, 4.30533230e-01f, 2.94400990e-01f, -1.32035255e-01f, 5.07596314e-01f, 4.96327937e-01f, 2.68900301e-02f, 5.62330067e-01f, -2.95311600e-01f, -1.07857578e-01f,
  5.39988637e-01f, -3.38928223e-01f, -4.54389662e-01f, -4.33231056e-01f, -4.06905830e-01f, -4.28647459e-01f, -1.90102518e-01f, 2.67126232e-01f, 3.85627210e-01f, -4.50782746e-01f,
  3.03214043e-01f, 3.63254458e-01f, -3.34755778e-01f, 3.52349341e-01f, 1.22561961e-01f, -4.64807093e-01f, 6.47129536e-01f, 8.77515495e-01f, -5.41207731e-01f, -4.81743723e-01f,
  -1.04179390e-01f, 2.98924476e-01f, -7.65171885e-01f, -6.76457047e-01f, -7.32284009e-01f, -3.42935026e-01f, -7.24955916e-01f, 6.25741929e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.58715859e-01f, 1.77810993e-02f, -5.74875325e-02f, -1.34551851e-02f, 4.85402532e-02f, 1.86284125e-01f, 1.99729472e-01f, -1.21580221e-01f, -2.27552384e-01f, -7.94058070e-02f,
  1.01823285e-02f, 1.40583843e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    