/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.77017690e-02f, -2.31269628e-01f, 3.04712594e-01f, 6.55422986e-01f, -2.19841927e-01f, -3.75054061e-01f, 4.83519197e-01f, -2.22350448e-01f, 3.68935987e-02f, -5.13543077e-02f,
  -1.03585266e-01f, 1.18691467e-01f, -4.08226252e-02f, 1.30922019e-01f, -9.99569669e-02f, 8.54522213e-02f, 1.03071183e-01f, 6.87704096e-03f, -9.24483314e-02f, -2.68642008e-02f,
  4.97975312e-02f, -6.05606064e-02f, 4.84590620e-01f, -3.99444312e-01f, 4.62761186e-02f, 1.26586020e-01f, -5.29046133e-02f, -4.06395793e-02f, -2.41820212e-03f, 8.41179676e-03f,
  5.03924675e-03f, 1.78536728e-01f, 1.61013260e-01f, -4.53711208e-03f, -5.29156402e-02f, 6.10458516e-02f, 9.81603041e-02f, 4.78537232e-02f, 1.47644021e-02f, -4.47166013e-03f,
  -1.00536078e-01f, -7.14588538e-02f, -3.05900294e-02f, 1.85997859e-02f, -3.35927010e-02f, 3.38795632e-02f, 5.04797474e-02f, 5.02424501e-02f, 2.75008120e-02f, 6.31024316e-02f,
  8.70254412e-02f, 4.59304750e-02f, 1.53171778e-01f, 1.77471451e-02f, 5.51292971e-02f, 4.22635525e-02f, 1.62341312e-01f, 1.61646362e-02f, -1.51974410e-01f, -7.10300207e-02f,
  7.32171983e-02f, -7.10858628e-02f, 3.71682867e-02f, 2.00039223e-02f, -6.00160919e-02f, -1.50861661e-03f, 8.92281011e-02f, 2.34016273e-02f, -1.55851273e-02f, 6.66721538e-02f,
  -4.96793240e-02f, 4.42353003e-02f, -6.14841729e-02f, 7.64357895e-02f, 5.95863983e-02f, 1.30502224e-01f, 2.38861851e-02f, -8.48902911e-02f, 1.65605359e-02f, 2.45396001e-03f,
  5.75222522e-02f, -2.95036081e-02f, -9.80317667e-02f, 3.52055393e-02f, 2.43534707e-02f, 5.17414846e-02f, -4.54340577e-02f, 5.77599928e-02f, 2.87718195e-02f, -1.20222773e-02f,
  -3.90008241e-01f, -4.48718071e-01f, -1.44297229e-02f, 4.74769883e-02f, 6.66339919e-02f, -9.33030024e-02f, 6.80477964e-03f, -7.76602030e-02f, 2.52100881e-02f, -4.91932295e-02f,
  -1.22989314e-02f, 7.69557282e-02f, -7.99764395e-02f, -4.42215726e-02f, 3.89228612e-02f, -3.66403274e-02f, -8.07004608e-03f, -1.90154314e-02f, 3.36404853e-02f, -9.33216214e-02f,
  -2.77393591e-02f, -1.58060528e-02f, -3.47527117e-02f, -6.47541434e-02f, -5.37401289e-02f, 3.41520943e-02f, -1.85538977e-01f, 9.10384953e-02f, 6.04812764e-02f, 2.39833966e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.16914916e-01f, -5.65623879e-01f, -6.41099587e-02f, -8.22276950e-01f, -9.02591925e-03f, -2.77752101e-01f, 7.84224942e-02f, -8.04329515e-01f, -5.91640234e-01f, -5.59420943e-01f,
  -3.51153910e-01f, 1.13680020e-01f, 8.28979492e-01f, -9.20970559e-01f, 9.65594530e-01f, 6.93575442e-01f, -8.67586315e-01f, -2.89553165e-01f, -3.10928792e-01f, -5.29715955e-01f,
  -1.90110207e-01f, -6.81768835e-01f, 2.92275995e-02f, -5.59244812e-01f, -6.12036884e-01f, -4.79328662e-01f, 3.57261151e-02f, 1.66368738e-01f, -7.65894890e-01f, 6.62523462e-03f,
  -3.60116810e-02f, -2.41782200e-02f, 3.85221355e-02f, 1.09368563e-01f, -1.43556863e-01f, 3.22160214e-01f, 1.25942156e-01f, 4.83361900e-01f, 1.49534864e-03f, 1.07692163e-02f,
  3.14376265e-01f, 2.13593513e-01f, -3.38536441e-01f, 3.50090206e-01f, -1.93861291e-01f, -1.07037313e-01f, -9.08347666e-02f, -1.74535960e-01f, 5.40538877e-02f, 1.65323511e-01f,
  -9.03149471e-02f, -4.19226028e-02f, -1.76174313e-01f, -1.07821070e-01f, -1.12892576e-01f, -1.19252019e-02f, 2.81020254e-01f, 1.80223584e-01f, -1.18014403e-01f, -1.97024375e-01f,
  1.18348233e-01f, 1.23661995e-01f, 2.02545464e-01f, -4.86463606e-02f, 3.74123268e-02f, -2.08191350e-02f, 1.58932954e-02f, 1.45913348e-01f, -9.34205726e-02f, 1.37743413e-01f,
  -2.84838706e-01f, -1.16164885e-01f, -6.57408237e-02f, -1.05178989e-01f, 1.78408772e-02f, 7.11922869e-02f, 2.04472646e-01f, 3.43710510e-03f, -4.13754612e-01f, -1.36823893e-01f,
  1.93448693e-01f, -3.31082344e-02f, -6.74060136e-02f, 9.46274698e-02f, -1.09714091e-01f, 8.06304589e-02f, -2.33219549e-01f, 9.25377607e-02f, -5.42067252e-02f, 1.97263852e-01f,
  -1.90750927e-01f, -1.53670788e-01f, -6.69097379e-02f, 1.71404004e-01f, -1.44061580e-01f, -5.30529171e-02f, 1.21354856e-01f, -2.34759212e-01f, -1.30518571e-01f, 1.03792939e-02f,
  -1.25690967e-01f, 7.96416700e-02f, -1.63621813e-01f, -9.09646600e-02f, -7.65193552e-02f, -1.87526852e-01f, 1.56989932e-01f, 1.36771157e-01f, 4.36059684e-02f, -2.32044339e-01f,
  3.35258394e-02f, 1.13458544e-01f, 1.51808783e-01f, -1.43413186e-01f, 2.33768336e-02f, 7.83301294e-02f, -3.98621038e-02f, 1.01946071e-01f, 1.91987678e-01f, -9.69448984e-02f,
  4.12751496e-01f, -2.30580091e-01f, -4.45348740e-01f, 3.59388292e-01f, -3.21030825e-01f, 7.91924000e-01f, 1.24830317e+00f, -4.66546237e-01f, 9.77958590e-02f, 2.61841118e-01f,
  1.89870059e-01f, 2.49360621e-01f, 3.19174528e-01f, 5.42251170e-01f, 7.21848726e-01f, 5.24588883e-01f, 6.81649745e-01f, 7.21277714e-01f, -1.46750867e-01f, 1.74356088e-01f,
  -9.05828252e-02f, 5.16892254e-01f, -1.07032821e-01f, -5.30374825e-01f, -6.35674084e-03f, -5.49176514e-01f, -3.20964903e-01f, -4.10613298e-01f, -1.43608838e-01f, -1.82748623e-02f,
  -2.64368136e-03f, -1.11842126e-01f, -8.99563655e-02f, 7.77915940e-02f, 4.03900519e-02f, 9.07551795e-02f, 1.71918929e-01f, 1.79625630e-01f, -3.79003771e-02f, -5.50261363e-02f,
  3.35315228e-01f, -1.19217493e-01f, 6.96718227e-03f, -1.14159897e-01f, -5.20046093e-02f, -1.24160193e-01f, -1.81754455e-01f, -1.98922187e-01f, 3.85815249e-04f, -8.75018388e-02f,
  -9.51778218e-02f, -1.58552110e-01f, -2.67854938e-03f, 6.49183467e-02f, -1.22998267e-01f, 1.49776796e-02f, 1.67454734e-01f, 5.65274023e-02f, -2.72612907e-02f, -8.54074582e-02f,
  -1.95050668e-02f, 8.68477151e-02f, 3.57899889e-02f, -1.22817315e-01f, 2.68305112e-02f, -1.02974176e-01f, 7.82596171e-02f, 5.32605033e-03f, -5.70299178e-02f, 9.23399255e-02f,
  1.22103775e-02f, 1.30171776e-01f, 5.50822588e-03f, 4.39352728e-02f, 3.76599766e-02f, 4.27976288e-02f, 1.32607713e-01f, 7.96998143e-02f, 4.52502109e-02f, -8.03799778e-02f,
  1.98059417e-02f, 2.02432111e-01f, -6.45099729e-02f, 2.24571601e-02f, 9.86574143e-02f, -4.00699191e-02f, 1.13966070e-01f, -3.04987617e-02f, -1.33723527e-01f, 5.19194566e-02f,
  4.94489484e-02f, 1.14228949e-01f, -1.05208248e-01f, -7.84319937e-02f, 6.90280348e-02f, 1.70754883e-02f, 6.24985360e-02f, -4.17303443e-02f, -5.28179854e-02f, 9.53682214e-02f,
  1.92503836e-02f, 7.90874474e-03f, -1.51450604e-01f, -6.70152009e-02f, 4.23886022e-03f, -4.84029539e-02f, 3.05193573e-01f, 7.02404752e-02f, 1.14920042e-01f, -1.17481761e-01f,
  1.60640199e-02f, 1.23809844e-01f, 1.36882782e-01f, -1.52679058e-02f, 3.56180072e-02f, 1.88892670e-02f, -8.26817155e-02f, -1.58739284e-01f, -7.67995566e-02f, -1.19004603e-02f,
  4.49102491e-01f, -8.41901839e-01f, -3.78300935e-01f, -1.84785184e-02f, 6.07802987e-01f, 6.99839890e-01f, 4.16768134e-01f, 8.26544464e-02f, -3.59357029e-01f, -5.90947807e-01f,
  4.06183988e-01f, -7.95394421e-01f, -4.19364393e-01f, -2.97818005e-01f, 4.09395285e-02f, -6.44767404e-01f, 1.23293757e-01f, -1.22675143e-01f, -5.35295308e-02f, 3.12450349e-01f,
  4.41232398e-02f, 9.62380320e-02f, 1.03248797e-01f, 8.81217420e-02f, 3.67022455e-01f, 2.42710337e-01f, 5.69230020e-01f, 8.85476992e-02f, 5.89417107e-03f, -1.88788027e-01f,
  -3.02003510e-02f, -1.15986809e-01f, 1.00413896e-01f, -1.67288318e-01f, 3.97634983e-01f, 1.73133433e-01f, 1.53837621e-01f, -5.58531880e-02f, 9.12930071e-02f, 1.71229430e-02f,
  4.73722480e-02f, -3.22671354e-01f, -3.38604659e-01f, -1.23689577e-01f, 2.38988176e-02f, -6.22406304e-02f, 1.06245518e-01f, 1.78484857e-01f, -1.24358095e-01f, -1.33090198e-01f,
  9.57566798e-02f, -3.10536623e-01f, 2.16361433e-02f, -3.27571213e-01f, -1.10849634e-01f, -6.28159493e-02f, -8.30474421e-02f, 1.31163925e-01f, -1.06612198e-01f, -1.92381907e-02f,
  -1.08822629e-01f, -6.96320906e-02f, 6.70497045e-02f, -1.08405791e-01f, -5.30262254e-02f, -5.15477657e-02f, -3.29554938e-02f, -1.50654778e-01f, 1.50047690e-01f, 9.26236883e-02f,
  1.23614058e-01f, -6.40837327e-02f, -5.27589507e-02f, 2.92238016e-02f, -3.31274346e-02f, -1.11329712e-01f, 2.40643807e-02f, 1.11413591e-01f, 2.51101673e-01f, 1.94580957e-01f,
  -2.63880312e-01f, 1.39146984e-01f, 2.10628375e-01f, -7.09509701e-02f, -1.11465771e-02f, -1.83326844e-02f, -1.51359648e-01f, -1.52145550e-01f, 2.33094558e-01f, -4.21344005e-02f,
  6.71722665e-02f, -4.10518855e-01f, -3.09135336e-02f, -4.13267389e-02f, 1.12708598e-01f, 2.67715275e-01f, -5.14958128e-02f, -1.87849388e-01f, -1.41365111e-01f, -4.44413722e-02f,
  1.21678546e-01f, 1.55364901e-01f, -4.26885709e-02f, -5.92228062e-02f, -9.68198702e-02f, 1.04555510e-01f, -2.04518009e-02f, -7.62060210e-02f, 1.43716261e-01f, 6.99694529e-02f,
  -1.53164882e-02f, 1.04143307e-01f, -2.29547635e-01f, 9.33613107e-02f, -1.10682458e-01f, 5.86791225e-02f, 6.08797595e-02f, -1.65967420e-02f, -1.79448292e-01f, -2.06128225e-01f,
  -7.99074411e-01f, 7.03438938e-01f, 2.26256356e-01f, -1.69635415e-01f, -2.42631719e-01f, -3.22718799e-01f, 3.82484615e-01f, -1.55489311e-01f, 1.40785973e-03f, 7.31567800e-01f,
  -5.26960054e-03f, 8.88645470e-01f, 2.37561509e-01f, -9.09333304e-02f, -1.12439108e+00f, -4.73481029e-01f, -5.20223737e-01f, 2.84771532e-01f, -7.67396837e-02f, 2.86250293e-01f,
  -3.48294616e-01f, -5.79801202e-01f, -4.07565743e-01f, 7.69273788e-02f, 1.41931698e-01f, 6.31099522e-01f, -2.59620994e-01f, 3.93282950e-01f, 1.56483576e-02f, -2.48632908e-01f,
  2.09430337e-01f, 3.22708905e-01f, 1.23044096e-01f, 1.66042134e-01f, -1.11089706e-01f, -2.35156417e-02f, 1.30455643e-01f, 5.29144630e-02f, -8.52563754e-02f, 9.59012136e-02f,
  2.14449868e-01f, 1.65216595e-01f, -6.85301796e-02f, -2.11174339e-01f, 1.43120810e-01f, 8.02433789e-02f, 2.66115405e-02f, -7.71320388e-02f, 1.58766285e-01f, 6.80533424e-02f,
  2.07593188e-01f, 6.37919381e-02f, 2.80035436e-02f, -5.39959408e-02f, -1.66536450e-01f, 2.49819770e-01f, 4.97101285e-02f, 2.22520959e-02f, 1.17574066e-01f, -1.59821451e-01f,
  -1.82337821e-01f, 3.20462696e-02f, 2.25004598e-01f, -2.39189831e-03f, 1.77321658e-02f, 2.38317624e-02f, 5.08764833e-02f, -4.22071591e-02f, -1.12013064e-01f, 8.50993842e-02f,
  9.03058350e-02f, 1.46184966e-01f, 1.46667942e-01f, 2.41300184e-02f, -1.80856496e-01f, 1.42140299e-01f, -2.05313921e-01f, 3.43848467e-01f, -1.19882554e-01f, 1.89493019e-02f,
  4.91180308e-02f, -8.46461505e-02f, 2.17583612e-01f, -1.91325277e-01f, -5.80320321e-02f, -1.35405794e-01f, -4.25714329e-02f, 5.96011132e-02f, 8.73277932e-02f, -2.19466180e-01f,
  -3.04824319e-02f, 5.39471246e-02f, 2.46740147e-01f, 3.50786090e-01f, 1.48952588e-01f, -1.04172513e-01f, -2.54951715e-01f, 1.63423885e-02f, -4.30515148e-02f, -1.36109442e-01f,
  -6.74839094e-02f, 6.80804402e-02f, 4.74975593e-02f, -6.75815046e-02f, -1.19234525e-01f, 4.06523906e-02f, 1.07275039e-01f, 1.71585586e-02f, -9.11676064e-02f, -4.46896553e-02f,
  1.01485446e-01f, 8.58467817e-02f, -6.48975372e-02f, 1.13408640e-01f, 3.65724936e-02f, 1.22453630e-01f, -1.23632863e-01f, 1.39748201e-01f, -1.41804844e-01f, 5.50974905e-02f,
  9.50527132e-01f, -4.56001341e-01f, 3.76659364e-01f, 6.79976463e-01f, 3.21515143e-01f, -7.02304900e-01f, -3.87084424e-01f, -1.75030567e-02f, 7.01924860e-01f, -6.84566200e-01f,
  -3.86017948e-01f, 2.25704908e-01f, -5.71409822e-01f, -3.87642294e-01f, -1.43063799e-01f, -4.99306142e-01f, -3.15787077e-01f, -2.88561255e-01f, 2.01045021e-01f, -1.37107387e-01f,
  1.67912841e-01f, -7.97151864e-01f, -1.97663754e-01f, -6.41544104e-01f, 1.00934796e-01f, 1.75994158e-01f, -3.56414437e-01f, -2.50442624e-01f, -7.74649680e-02f, -1.32981569e-01f,
  -2.23358497e-01f, 2.28240401e-01f, 1.86683208e-01f, -5.88460825e-02f, -9.42707434e-02f, 1.24083450e-02f, -1.59701221e-02f, 1.47954389e-01f, 1.69280142e-01f, 4.69773862e-04f,
  7.88982958e-03f, 1.28678143e-01f, 6.75800890e-02f, -2.50537749e-02f, 2.15541571e-01f, 1.61830992e-01f, 2.02979177e-01f, 1.69907257e-01f, 1.02599539e-01f, 3.26728046e-01f,
  1.51311457e-01f, 3.00802737e-01f, 3.07895869e-01f, 8.73800442e-02f, 2.31902465e-01f, 1.06372029e-01f, 5.04056849e-02f, 5.90115003e-02f, -8.23615789e-02f, 1.37860790e-01f,
  -2.58901212e-02f, -6.83039874e-02f, -2.97406688e-02f, 1.34078205e-01f, -7.36407191e-02f, 2.05170900e-01f, -6.62777796e-02f, -5.15279733e-02f, -4.15392742e-02f, -2.18047395e-01f,
  -8.19061026e-02f, 2.71567136e-01f, 1.91638768e-01f, 4.95226867e-02f, 3.67394313e-02f, 1.83194011e-01f, 1.36424564e-02f, -7.89419375e-03f, 8.09998363e-02f, 6.02564700e-02f,
  7.08696246e-02f, -1.10361896e-01f, -9.99660864e-02f, 4.65957783e-02f, -1.87655777e-01f, -4.91656959e-02f, 4.02928516e-02f, 2.11318970e-01f, 4.77167852e-02f, -1.35272607e-01f,
  -1.16620266e+00f, -1.10801804e+00f, -2.78695405e-01f, 4.79341708e-02f, -3.50866526e-01f, -1.28259331e-01f, 4.09036037e-03f, 2.13296890e-01f, -3.55788738e-01f, -7.31213018e-02f,
  6.83876723e-02f, -1.17430419e-01f, -4.20661122e-02f, 8.84712189e-02f, -3.08599472e-01f, -1.93031691e-02f, -1.28408387e-01f, -1.47258207e-01f, -4.33097690e-01f, -9.34652910e-02f,
  -6.58253133e-02f, -8.76614228e-02f, 3.37219313e-02f, 5.79786263e-02f, -9.00892541e-02f, 2.91220960e-03f, 6.10211007e-02f, 3.06280125e-02f, -9.71359573e-03f, -1.42279834e-01f,
  -1.83865523e+00f, 6.67238951e-01f, 2.38018379e-01f, -6.53582752e-01f, -2.35684484e-01f, -2.02699900e-02f, 3.31008434e-02f, 2.01365888e-01f, -1.99301451e-01f, 5.33123493e-01f,
  2.52754182e-01f, -4.91931021e-01f, 8.22176874e-01f, 1.11892141e-01f, -6.48766220e-01f, 9.28085506e-01f, -2.26759300e-01f, -1.33234486e-01f, 5.38005941e-02f, -4.62582946e-01f,
  -5.20858169e-01f, -9.43454206e-02f, 1.79516196e-01f, 4.37297970e-01f, -7.14983165e-01f, -3.93966556e-01f, -3.89136016e-01f, 1.81887597e-01f, -2.81487197e-01f, -1.05789736e-01f,
  -8.63211632e-01f, -2.11827755e-01f, -1.52446806e-01f, -1.02358021e-01f, -2.63748288e-01f, -1.70689911e-01f, -1.16410725e-01f, 1.11300603e-01f, -1.56451628e-01f, 1.06989238e-02f,
  -6.81642443e-02f, -1.16622858e-01f, -9.49577987e-02f, 6.80890447e-03f, -2.32115254e-01f, -7.65382573e-02f, 2.52470355e-02f, 7.57312849e-02f, 4.29722480e-02f, 5.47819436e-02f,
  4.63899076e-02f, -6.69856220e-02f, -1.25561148e-01f, 3.42230462e-02f, -5.13045490e-02f, 4.28878143e-02f, -9.28628538e-03f, -6.04799055e-02f, -1.68261036e-01f, -1.56805530e-01f,
  -3.47977988e-02f, -5.85365556e-02f, -8.94622356e-02f, -1.14968065e-02f, 1.26380548e-01f, -5.23708165e-02f, -4.97289933e-02f, 3.94526273e-02f, -5.52664101e-02f, -1.16777137e-01f,
  -1.30931333e-01f, -1.72004983e-01f, -5.15659861e-02f, -8.98145959e-02f, -1.29741073e-01f, -8.64863116e-03f, -2.76089627e-02f, -1.51020974e-01f, -7.73949828e-03f, -1.46235779e-01f,
  -7.48550966e-02f, -8.52919444e-02f, 4.85437959e-02f, 1.59610100e-02f, 1.09416358e-02f, 1.07355513e-01f, 3.76593322e-02f, 6.05408177e-02f, 5.59013486e-02f, -8.60947371e-02f,
  -1.21183729e+00f, -7.69390941e-01f, -1.17232621e-01f, -2.64869720e-01f, -5.56428730e-02f, -8.26388896e-02f, 1.10749386e-01f, -9.60365310e-02f, -1.40394330e-01f, -1.21697467e-02f,
  -7.91547820e-02f, -1.54703036e-02f, -1.84497640e-01f, -7.14555429e-03f, 4.11876626e-02f, 3.73023972e-02f, -7.90252164e-02f, -1.73357710e-01f, -3.22430968e-01f, -8.62396955e-02f,
  1.30368788e-02f, 4.98425514e-02f, 4.92522493e-02f, -2.23896950e-02f, 3.84967402e-02f, -2.07953483e-01f, -1.75284326e-01f, 1.16415836e-01f, -1.98215365e-01f, 1.21775873e-01f,
  -3.01306039e-01f, -5.39346218e-01f, -2.44549617e-01f, 2.72255152e-01f, 3.73339951e-01f, -2.84659177e-01f, 1.91744015e-01f, -1.68056503e-01f, -7.21778929e-01f, -2.76996225e-01f,
  6.08500957e-01f, 6.02362342e-02f, 3.14603567e-01f, -3.04602325e-01f, 5.00362068e-02f, -2.42381305e-01f, -5.76602042e-01f, -1.86227798e-01f, -3.39606673e-01f, -7.75333270e-02f,
  -2.19665691e-01f, 1.47657748e-02f, 6.38439730e-02f, 1.82255313e-01f, 5.41161411e-02f, 2.93625265e-01f, 6.37936175e-01f, 6.48560405e-01f, 3.54517251e-01f, 3.14813852e-01f,
  -4.52536315e-01f, -2.22631484e-01f, -3.50714033e-03f, -1.40488610e-01f, -6.69887140e-02f, 1.01908036e-01f, 3.12327832e-01f, 2.82006919e-01f, 7.35822469e-02f, -2.25401729e-01f,
  6.33886456e-02f, -1.03922307e-01f, -5.28714946e-03f, -4.82707610e-03f, -1.01676516e-01f, -1.46512941e-01f, -1.86627477e-01f, -1.14799060e-01f, -2.14689925e-01f, -1.02829427e-01f,
  -7.55506232e-02f, -1.96218923e-01f, 3.51124071e-02f, -6.44153431e-02f, 1.20812520e-01f, -1.40567422e-01f, -5.76242059e-02f, 2.59876043e-01f, -2.49762967e-01f, 4.84243855e-02f,
  9.66031570e-03f, 7.70943612e-02f, 8.21342394e-02f, -1.05494000e-01f, 6.20250702e-02f, 4.07104678e-02f, -2.48056844e-01f, 1.52754605e-01f, 1.99691523e-02f, -1.29845068e-01f,
  2.42675990e-02f, -2.59246547e-02f, -3.28016244e-02f, 5.30599058e-02f, 1.51908502e-01f, -1.58032611e-01f, 1.03717014e-01f, 1.70448020e-01f, 1.44594582e-02f, -9.59430914e-03f,
  -2.36965746e-01f, 4.45390157e-02f, 5.46629578e-02f, -4.38550040e-02f, -1.88178807e-01f, 1.89360723e-01f, 1.09193012e-01f, -2.08905414e-02f, 1.20948635e-01f, 1.85385853e-01f,
  2.41402443e-02f, 2.97644585e-01f, 8.22571293e-02f, -6.57177120e-02f, -5.30664362e-02f, -9.39589664e-02f, -1.95464090e-01f, -1.71231747e-01f, -1.63304433e-02f, 1.64292753e-02f,
  1.63864866e-01f, 5.98683245e-02f, 1.17654338e-01f, 4.14562710e-02f, 1.03296518e-01f, 1.22898556e-01f, 3.12332571e-01f, 2.57525183e-02f, -1.58970073e-01f, 1.79885142e-02f,
  1.76735342e-01f, 2.11104557e-01f, 1.75192934e-02f, 1.26958281e-01f, -4.06046510e-02f, 3.60368073e-01f, 2.08076864e-01f, 7.02137426e-02f, -5.78694567e-02f, -9.34184864e-02f,
  -4.00308251e-01f, -3.23381245e-01f, 1.04341984e+00f, 6.21667318e-03f, 5.25420368e-01f, 1.01814151e+00f, 6.52520776e-01f, 3.89319390e-01f, 4.96628314e-01f, -6.90891445e-01f,
  -5.29485404e-01f, -2.35231310e-01f, 1.87189728e-01f, -1.13531992e-01f, 1.03262138e+00f, 5.30141592e-01f, 2.38215119e-01f, 6.78242669e-02f, 3.90671819e-01f, 3.08984853e-02f,
  2.57984877e-01f, -1.66500747e-01f, 2.24239692e-01f, -3.35007489e-01f, -1.42323107e-01f, -3.52933645e-01f, -7.67785072e-01f, 3.56037199e-01f, -8.21908712e-01f, 3.84699881e-01f,
  -4.13520634e-01f, -2.63293475e-01f, -2.79510468e-01f, 1.43689543e-01f, -4.12449194e-03f, 1.43123781e-02f, -1.08352175e-03f, 2.32115716e-01f, 1.89163446e-01f, -5.00980318e-02f,
  -1.74514860e-01f, 7.20601603e-02f, -1.08580329e-01f, 5.48312217e-02f, 7.89397731e-02f, -4.09241319e-02f, 6.91873282e-02f, -5.65942340e-02f, -3.87799256e-02f, 2.08343267e-01f,
  3.75854485e-02f, 1.07449643e-01f, 1.42741753e-02f, 8.61679018e-03f, 8.23619664e-02f, 1.13859788e-01f, 1.27464965e-01f, 4.21302691e-02f, 6.03211904e-03f, -1.15017062e-02f,
  5.79701662e-02f, 9.99309495e-02f, 7.25394860e-02f, -3.55129130e-02f, -2.12182514e-02f, 2.86019174e-03f, -1.39552327e-02f, -1.91661134e-01f, 8.36889669e-02f, -1.08354934e-01f,
  1.07138166e-02f, -7.31293857e-02f, 1.28793761e-01f, 3.98163311e-02f, -1.31533623e-01f, -7.26041496e-02f, -1.11459168e-02f, -1.04269467e-01f, -2.65645999e-02f, -9.80712250e-02f,
  1.11227050e-01f, 1.11760050e-01f, -9.06584412e-02f, -5.86787499e-02f, -1.07473889e-02f, -3.22678722e-02f, -4.59610857e-02f, 7.00420812e-02f, -2.21480951e-02f, -1.43036880e-02f,
  -1.97164774e-01f, -1.74557582e-01f, -2.07892641e-01f, -1.74590185e-01f, -2.02800184e-01f, -3.15863103e-01f, -2.00525690e-02f, -1.19280973e-02f, 2.68174950e-02f, -4.98986319e-02f,
  -1.26764640e-01f, -1.47317648e-01f, 4.14223932e-02f, -4.95030843e-02f, -1.77526474e-02f, 4.17472273e-02f, -1.44934207e-01f, -1.56227157e-01f, -4.78100777e-02f, -3.87587305e-03f,
  -2.43826434e-01f, 7.61851072e-02f, 1.45435750e-01f, -1.59834832e-01f, -3.34690690e-01f, -1.75896257e-01f, -1.70608163e-01f, -7.14836642e-02f, -1.48982450e-03f, 6.35505542e-02f,
  -1.35449982e+00f, -2.64352083e-01f, -6.20025516e-01f, -2.61892825e-01f, 3.01967919e-01f, 1.07644629e+00f, 2.63391912e-01f, -7.85629675e-02f, -1.06032431e+00f, 1.30122915e-01f,
  5.56624234e-01f, -3.52985263e-01f, -2.36928821e-01f, 1.09089172e+00f, 5.56988537e-01f, 2.34328508e-01f, 6.83271408e-01f, 4.84658003e-01f, -6.18070737e-02f, -1.62951410e-01f,
  -3.99860330e-02f, 9.54201698e-01f, 5.59126556e-01f, 4.04256046e-01f, 5.89938283e-01f, -2.36267120e-01f, 2.52717376e-01f, -1.78391159e-01f, 7.11529791e-01f, 5.87661386e-01f,
  4.24742848e-01f, -6.38414085e-01f, -1.38730466e-01f, -2.20086038e-01f, 2.72413585e-02f, 8.31920002e-03f, 6.97945133e-02f, 2.43622363e-01f, -3.34949940e-01f, -3.77739482e-02f,
  -1.08669437e-01f, 4.53380980e-02f, 1.70416251e-01f, -1.89759746e-01f, -1.84664160e-01f, -2.39383616e-02f, -4.70847860e-02f, 7.13239238e-02f, -3.00307423e-02f, 3.55514362e-02f,
  -1.30682513e-01f, 3.25856060e-01f, 1.21377811e-01f, 1.48809657e-01f, -1.43151343e-01f, -2.12874830e-01f, -3.85461375e-02f, 4.34454530e-02f, -3.18623297e-02f, -1.34370834e-01f,
  1.19296081e-01f, 7.11481348e-02f, 9.18672904e-02f, 6.51633367e-03f, -3.81282642e-02f, 1.26105368e-01f, 1.55719891e-01f, 2.02580079e-01f, -1.70054197e-01f, 9.77200493e-02f,
  -1.13882069e-02f, -9.17263329e-02f, -2.37861313e-02f, 2.56531537e-02f, 4.76986021e-02f, -1.53441085e-02f, -1.43133877e-02f, 7.17757717e-02f, -7.36809596e-02f, 2.18683451e-01f,
  -4.22011390e-02f, -2.18903795e-02f, -1.53721780e-01f, 1.03282057e-01f, 2.21229549e-02f, -1.69451758e-01f, 4.79288734e-02f, -4.55896854e-02f, -1.53471768e-01f, 1.15587533e-01f,
  -1.09314367e-01f, -8.14163446e-01f, -9.42392126e-02f, 9.35793594e-02f, 4.03792337e-02f, 1.40714496e-01f, 3.58020775e-02f, 8.75793174e-02f, 1.84599608e-02f, -2.11343586e-01f,
  2.38731271e-03f, -3.38519216e-02f, -5.44678830e-02f, 6.38270155e-02f, 1.17785737e-01f, -1.74417272e-02f, -3.76206152e-02f, -1.40990108e-01f, -1.05747366e-02f, 6.14935160e-03f,
  1.92567706e-02f, -7.93041587e-02f, 5.36164604e-02f, 5.05259894e-02f, -5.85642494e-02f, 1.34342805e-01f, -2.11372063e-01f, -5.19439280e-02f, 1.96735144e-01f, 2.20996127e-01f,
  1.25776619e-01f, 6.53439164e-01f, 7.82945096e-01f, -2.28496924e-01f, -3.01293373e-01f, 9.60443854e-01f, 6.16127858e-03f, 6.01809993e-02f, -1.34908900e-01f, 5.40366411e-01f,
  -2.59692013e-01f, 6.21861935e-01f, -2.75422931e-01f, -2.39808694e-01f, -1.48268431e-01f, -2.12382585e-01f, 2.55975246e-01f, 1.05210021e-01f, -3.46484601e-01f, 1.09239407e-01f,
  -1.03731126e-01f, -5.79450607e-01f, -6.62746653e-02f, -2.37365827e-01f, 2.78660446e-01f, 5.67372143e-01f, -4.63140190e-01f, -2.21294880e-01f, 3.02630335e-01f, -2.63676703e-01f,
  -1.71972945e-01f, -4.81661975e-01f, 2.51797795e-01f, 2.55643725e-01f, 1.52454183e-01f, 1.68010429e-01f, 2.91047513e-01f, -4.09040824e-02f, -1.82737514e-01f, -2.88640130e-02f,
  4.74370271e-02f, -3.22047584e-02f, -2.20974125e-02f, -2.02934593e-02f, -1.56332821e-01f, -5.18017914e-03f, 1.88711941e-01f, 1.80795625e-01f, 9.22621712e-02f, -3.13537382e-02f,
  1.91060200e-01f, 3.70419383e-01f, 1.83548495e-01f, 1.88705713e-01f, 9.75674763e-02f, -2.45245412e-01f, 2.06903204e-01f, 2.06878930e-01f, 2.12128833e-01f, 2.00567976e-01f,
  6.42897487e-02f, 4.43790331e-02f, -8.14855620e-02f, 3.39677036e-02f, -8.27310756e-02f, -1.52813151e-01f, 1.29156455e-01f, -1.19303048e-01f, 8.85033887e-03f, 1.05683049e-02f,
  -7.32251704e-02f, -2.32575424e-02f, -1.47981703e-01f, 9.24401581e-02f, -2.95748040e-02f, -6.37510493e-02f, 2.88035363e-01f, 1.11453600e-01f, 5.47554158e-02f, -2.44747251e-02f,
  -1.58779666e-01f, -1.00232020e-01f, -2.00466424e-01f, 1.34795718e-02f, 4.32994366e-02f, 2.82236822e-02f, 3.11321393e-02f, 1.26653895e-01f, -1.53449178e-01f, 1.26829818e-01f,
  2.78985977e-01f, 5.04068613e-01f, -6.53914213e-02f, -9.34579149e-02f, 2.88408212e-02f, 2.38056317e-01f, 1.75160006e-01f, 4.27256487e-02f, -7.91199207e-02f, 1.15849175e-01f,
  1.61497414e-01f, 2.35047057e-01f, 3.16788167e-01f, -7.07077682e-02f, 3.81008573e-02f, 1.57991752e-01f, 3.87019962e-02f, 1.69888675e-01f, 2.59775043e-01f, -5.18985791e-03f,
  3.21573392e-02f, -1.63045540e-01f, -3.36875729e-02f, -3.35562974e-02f, 3.40015702e-02f, 1.10947728e-01f, 1.10667259e-01f, -8.89857784e-02f, 9.90982503e-02f, 9.64144096e-02f,
  5.44480979e-01f, 4.61053401e-01f, -1.41698882e-01f, -2.54256517e-01f, 1.12365857e-01f, -3.99855405e-01f, -2.18377337e-01f, 2.32258558e-01f, -5.06747305e-01f, 4.63201761e-01f,
  5.74718893e-01f, -3.33880514e-01f, 2.39882261e-01f, 1.98472679e-01f, -2.59883523e-01f, -2.10160390e-01f, 3.62515718e-01f, 1.79994702e-01f, -3.78262639e-01f, 7.39586830e-01f,
  -8.54966987e-04f, 6.82760000e-01f, 7.26726130e-02f, 4.79474396e-01f, 4.97011751e-01f, -1.53394425e-02f, 6.44561768e-01f, -1.63442288e-02f, 3.24397981e-01f, -8.84592161e-02f,
  1.87097527e-02f, 2.06769109e-01f, -2.32665930e-02f, -4.03382592e-02f, 1.55684471e-01f, 1.19560383e-01f, -4.56597582e-02f, -8.03396106e-02f, -3.72277737e-01f, 5.73276542e-02f,
  9.65552703e-02f, 5.28574139e-02f, -2.57058162e-02f, -1.65226370e-01f, 3.85922790e-02f, 4.32705991e-02f, -7.00867921e-02f, -9.95874181e-02f, -5.80773354e-02f, 2.99834549e-01f,
  5.46286590e-02f, -6.72140718e-02f, 8.20317939e-02f, -7.53213465e-02f, 3.56540419e-02f, 1.55513704e-01f, -2.16825426e-01f, 5.70365079e-02f, -1.19187072e-01f, 3.21249366e-02f,
  2.70352364e-01f, -1.88625474e-02f, 6.65405393e-02f, -1.67573933e-02f, 1.59548279e-02f, 2.17128277e-01f, -8.52970779e-02f, 8.10679346e-02f, -2.26540700e-01f, 6.14502281e-02f,
  -1.73767611e-01f, 7.18213096e-02f, -6.60460070e-02f, 1.46720022e-01f, 4.57750149e-02f, -7.72039071e-02f, -1.30551234e-01f, 2.88874600e-02f, 3.80487763e-03f, -1.24617510e-01f,
  -4.78767753e-02f, 1.70863852e-01f, 1.08911768e-01f, 1.12402342e-01f, -1.43044010e-01f, 5.22310287e-02f, 2.56327987e-01f, 3.57417949e-02f, -9.46127102e-02f, 1.20453022e-01f,
  1.77474841e-02f, 4.25304890e-01f, -5.76609783e-02f, -2.25970775e-01f, -1.32229462e-01f, 7.09276646e-02f, -7.91425183e-02f, 2.12965384e-01f, 1.85713276e-01f, -1.29730895e-01f,
  3.27448845e-01f, -2.28104755e-01f, 6.86313286e-02f, 7.06436485e-02f, -3.72612566e-01f, 3.01188141e-01f, 1.72780603e-01f, -1.55162945e-01f, -1.01356320e-01f, 2.48133153e-01f,
  1.59750849e-01f, 2.28497058e-01f, -1.73019506e-02f, -1.23486720e-01f, -3.93187851e-02f, 6.43411204e-02f, -8.71263966e-02f, 2.70100689e-04f, 1.44505367e-01f, -2.22632304e-01f,
  1.12521432e-01f, 5.92950046e-01f, -6.45866275e-01f, 4.48345184e-01f, -1.30408499e-02f, 8.08843911e-01f, 9.01809752e-01f, 1.38160333e-01f, 7.30163872e-01f, 6.46125197e-01f,
  5.22936702e-01f, 1.95993379e-01f, 1.60309628e-01f, 9.90119874e-01f, -1.11822292e-01f, 5.82502246e-01f, 6.68779492e-01f, 5.90000927e-01f, 1.88087955e-01f, 3.43917608e-01f,
  -3.62861506e-03f, 6.31027281e-01f, -3.08222324e-01f, -1.04566785e-02f, 2.10085064e-02f, -3.80372375e-01f, -4.98195082e-01f, -4.54693168e-01f, -4.98634912e-02f, 3.01899966e-02f,
  1.83512360e-01f, 3.36976737e-01f, -1.89659595e-01f, -7.11375624e-02f, -1.17062330e-02f, -1.74180597e-01f, -1.89197376e-01f, -3.75919998e-01f, -1.84268117e-01f, 1.65970176e-02f,
  -4.62950356e-02f, -6.72715977e-02f, 1.88604146e-01f, -1.74089715e-01f, 5.44962212e-02f, -1.16113827e-01f, -6.48333877e-02f, 6.69156015e-02f, -2.75530908e-02f, 6.30802065e-02f,
  -4.17467169e-02f, 7.68910870e-02f, 1.01667434e-01f, 1.08903855e-01f, -1.88863203e-01f, 9.80054811e-02f, 1.14194550e-01f, -6.33916408e-02f, -2.32403241e-02f, 1.97677001e-01f,
  -1.13662994e-02f, 1.63563207e-01f, 1.26677215e-01f, -1.29741758e-01f, 1.54448785e-02f, -7.12501444e-03f, 1.21031955e-01f, -1.16172962e-01f, -4.95432168e-02f, 2.00641572e-01f,
  4.07754593e-02f, -5.89814447e-02f, 1.52271375e-01f, -1.04624499e-02f, 1.88009754e-01f, -4.55786736e-04f, -1.25754625e-01f, 1.53614990e-02f, 1.24035344e-01f, -9.04299691e-03f,
  -9.85681266e-02f, 1.52117044e-01f, -1.70024354e-02f, -2.74283350e-01f, -6.93166303e-03f, -1.38372913e-01f, 1.28228620e-01f, 7.92635456e-02f, -9.11899358e-02f, -1.14883728e-01f,
  3.60673487e-01f, 4.20408010e-01f, 1.27906710e-01f, 5.95996715e-03f, -1.31300792e-01f, 6.97709471e-02f, 4.14537042e-02f, 9.38812345e-02f, 1.39203042e-01f, 9.96189564e-02f,
  -1.81531593e-01f, 1.57020345e-01f, -1.04878828e-01f, -5.60063682e-02f, 5.02550006e-02f, 2.61192232e-01f, 5.07444739e-02f, 6.37263730e-02f, 7.26620480e-02f, -1.44007966e-01f,
  -2.54223704e-01f, 1.67636365e-01f, 1.26771163e-02f, 1.28553659e-01f, 5.75493239e-02f, -1.20726144e-02f, 9.43474844e-02f, -3.03417537e-02f, -2.77815431e-01f, 1.70842782e-01f,
  5.20724244e-03f, -1.50308818e-01f, 4.31611747e-01f, 7.76223898e-01f, -2.35883459e-01f, -7.43278384e-01f, -8.78212452e-01f, -2.12911114e-01f, -3.48537113e-03f, -4.66162920e-01f,
  -4.25054789e-01f, 3.77682328e-01f, -8.45011234e-01f, 5.57740867e-01f, 8.73163044e-01f, -3.68438423e-01f, 3.31055194e-01f, 8.31711963e-02f, 9.88593884e-03f, 2.36441955e-01f,
  4.01494801e-01f, 2.01851487e-01f, 5.09801149e-01f, 3.39401931e-01f, -5.94887733e-02f, 4.42517489e-01f, 7.69805133e-01f, -1.69822276e-02f, 6.99246109e-01f, -7.63958842e-02f,
  -2.91438699e-01f, 1.39053419e-01f, -1.69221312e-02f, 1.38786986e-01f, -8.36248547e-02f, -3.80268782e-01f, 5.35519719e-02f, -4.15402614e-02f, 1.29868770e-02f, -1.55080274e-01f,
  4.72935066e-02f, 2.45867133e-01f, -6.81580231e-02f, 3.36509980e-02f, -9.49921235e-02f, 1.75186738e-01f, 3.06335568e-01f, -1.82834581e-01f, 2.13533733e-02f, -1.43851310e-01f,
  2.39449739e-02f, 6.42015657e-04f, -9.15028993e-03f, 2.25329503e-01f, 2.34402463e-01f, -6.22228123e-02f, 7.93500394e-02f, -5.72379380e-02f, -1.22071235e-02f, 1.39448225e-01f,
  9.47976932e-02f, -1.24293327e-01f, -1.63105994e-01f, -1.13967642e-01f, -1.33524254e-01f, 7.01659247e-02f, 1.71459794e-01f, -8.63861889e-02f, 1.73088461e-01f, -1.79560944e-01f,
  2.02598557e-01f, 8.23986977e-02f, -1.49743734e-02f, -6.46194667e-02f, -2.17912719e-03f, -1.39859304e-01f, -1.64011583e-01f, -1.26157999e-02f, -9.69419330e-02f, 8.22959542e-02f,
  -1.89127699e-02f, 3.43880728e-02f, 7.74116963e-02f, -9.91754904e-02f, -2.14524329e-01f, -1.44218296e-01f, 1.31708875e-01f, 1.68171842e-02f, -1.38934344e-01f, -7.87080452e-02f,
  2.87987947e-01f, 5.60794473e-01f, -8.64541717e-03f, 2.13551112e-02f, 1.47654161e-01f, 1.01791665e-01f, 8.38873014e-02f, 2.17599347e-01f, 3.03042054e-01f, -4.96654324e-02f,
  1.17088087e-01f, -1.62093267e-01f, 1.40068000e-02f, -2.15135161e-02f, 1.23545654e-01f, -5.52283302e-02f, 1.68880925e-01f, 2.15343654e-01f, 9.99281928e-02f, 1.75130710e-01f,
  9.59202573e-02f, -2.68102854e-01f, 1.25344515e-01f, -4.35906500e-02f, 1.78633854e-02f, 2.16089860e-02f, -4.51750495e-02f, 5.12734875e-02f, 6.17533289e-02f, 2.82731831e-01f,
  -1.32755309e-01f, -6.95699394e-01f, -8.34834993e-01f, -1.23418547e-01f, 7.99055874e-01f, -1.39214724e-01f, -1.48495719e-01f, 3.37047666e-01f, -4.53062840e-02f, 2.48851359e-01f,
  1.05309539e-01f, -4.81491715e-01f, -5.28441012e-01f, -5.23570418e-01f, -5.98477602e-01f, -9.13148880e-01f, -2.72639990e-01f, -1.65436015e-01f, -2.51705974e-01f, 3.65967327e-03f,
  -1.92291245e-01f, 5.88988066e-01f, -6.91491067e-01f, 8.05379033e-01f, 1.79162621e-01f, 1.61897615e-01f, 2.99232423e-01f, 5.27041964e-02f, 2.86254715e-02f, 5.59490174e-02f,
  -1.17560603e-01f, -3.14911067e-01f, -1.59803376e-01f, 3.99029069e-02f, 3.91453318e-02f, 3.65660638e-01f, 9.08107981e-02f, -9.51808095e-02f, -1.46197096e-01f, -1.14581138e-01f,
  -6.78882524e-02f, 1.45784229e-01f, 8.81348550e-03f, 5.90145253e-02f, 2.78464973e-01f, 1.36536077e-01f, -1.98497936e-01f, -1.67786673e-01f, 1.45052746e-01f, -3.33421409e-01f,
  -3.72073531e-01f, -5.42249568e-02f, 3.75021771e-02f, -3.25521737e-01f, -1.80862844e-01f, 7.66130686e-02f, 4.08787206e-02f, -2.69313782e-01f, -7.89687689e-03f, -1.27378523e-01f,
  1.84562221e-01f, 7.60644600e-02f, -9.99515727e-02f, -2.70556705e-03f, 7.64451772e-02f, 1.26829728e-01f, 1.15181416e-01f, -1.36480713e-02f, -7.42537230e-02f, -7.79665187e-02f,
  1.49216264e-01f, -1.24639504e-01f, -3.49823758e-02f, 3.50084226e-03f, -6.11524768e-02f, 1.08233489e-01f, 1.24424174e-01f, 1.96661949e-02f, -1.00482114e-01f, -2.73970842e-01f,
  2.11683527e-01f, 2.84857471e-02f, -3.93427834e-02f, 2.24619210e-01f, -9.91934240e-02f, 4.86390255e-02f, 1.01204671e-01f, -2.57306546e-02f, -8.59400257e-02f, 8.84527937e-02f,
  -7.76433498e-02f, -1.36105329e-01f, -1.50541261e-01f, 2.08979577e-01f, -7.18239322e-02f, 9.65330005e-02f, -5.76390140e-02f, 1.53996587e-01f, -2.18245964e-02f, 9.87946689e-02f,
  1.56514511e-01f, 3.81818414e-01f, 1.76759779e-01f, -1.81230783e-01f, -2.25748736e-02f, -5.46693467e-02f, 1.88350827e-01f, 1.15862608e-01f, 2.17904776e-01f, -1.39776366e-02f,
  2.77113140e-01f, 1.68461010e-01f, 1.66859582e-01f, 1.92994773e-01f, 1.34953707e-01f, 1.84705630e-02f, 1.28771380e-01f, -4.06541862e-02f, 1.39274701e-01f, -8.95872116e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  5.05171776e-01f, 9.56237674e-01f, 9.74494338e-01f, 1.09127283e+00f, 8.29936445e-01f, 7.60955691e-01f, 9.04126406e-01f, 1.02652633e+00f, 6.60055339e-01f, 1.15594816e+00f,
  8.77789199e-01f, 6.92128599e-01f, 4.01758254e-01f, 1.06390762e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -5.98816633e-01f, 1.41199481e+00f, -4.31952119e-01f, 3.75847757e-01f, -5.20217717e-01f, 3.77029270e-01f, -5.14957786e-01f, 7.85856724e-01f, -6.22047365e-01f, -1.23556876e+00f,
  5.94092846e-01f, -8.56957197e-01f, -1.57874733e-01f, 4.68717605e-01f, -1.11420965e+00f, -1.01831853e+00f, -5.44719934e-01f, -1.55718076e+00f, 3.21234971e-01f, 5.16236961e-01f,
  -1.34030476e-01f, -1.40378749e+00f, -5.26466429e-01f, -1.82888448e+00f, -4.40495640e-01f, -7.90294826e-01f, 6.58217609e-01f, -2.53377855e-01f, 8.61492932e-01f, 7.23166704e-01f,
  -7.86656082e-01f, 1.44087523e-01f, 1.04739383e-01f, 5.67193627e-01f, -5.95909119e-01f, 6.08199015e-02f, 1.77431136e-01f, -1.06831634e+00f, -1.23985164e-01f, -1.05732739e+00f,
  2.19343379e-01f, -6.00824773e-01f, 9.98622894e-01f, -9.86725092e-01f, -9.30679977e-01f, -8.62785518e-01f, 7.20749795e-01f, 6.71202421e-01f, -1.14243716e-01f, -3.29730749e-01f,
  -2.18678817e-01f, -5.74547529e-01f, -1.55751503e+00f, 1.04549193e+00f, -1.90388918e-01f, 1.03328574e+00f, 1.57222331e-01f, -1.25355065e+00f, -1.03065157e+00f, -1.24473763e+00f,
  4.54255985e-03f, -6.54572368e-01f, -2.99196362e-01f, 3.77541840e-01f, 1.05683064e+00f, -9.18206394e-01f, 9.24964398e-02f, -1.82534528e+00f, 5.16327798e-01f, 6.81030899e-02f,
  -6.24065220e-01f, 6.38641119e-01f, -1.01400328e+00f, 8.69662821e-01f, 5.69151640e-01f, 5.94461977e-01f, -1.76790148e-01f, -5.63765049e-01f, -5.64244628e-01f, -1.05636764e+00f,
  4.10462737e-01f, -2.49700338e-01f, -3.02678972e-01f, 6.98817670e-01f, -1.21377015e+00f, -5.01919016e-02f, -1.23973536e+00f, -4.63779777e-01f, -5.82623303e-01f, 8.00608814e-01f,
  -1.50931227e+00f, 4.74124372e-01f, -7.58033216e-01f, 7.61953294e-01f, 3.44343841e-01f, -3.51210862e-01f, -4.96501066e-02f, 6.85038686e-01f, -1.07713580e+00f, -8.67548138e-02f,
  8.65506530e-01f, -1.04672277e+00f, 1.38611174e+00f, -1.32284963e+00f, -5.17810524e-01f, 4.53355461e-01f, -1.17130828e+00f, -9.98597264e-01f, -7.13197172e-01f, 4.35072362e-01f,
  -5.32406509e-01f, 5.47433674e-01f, 1.22574605e-01f, -5.32196879e-01f, 1.09222746e+00f, -9.23054457e-01f, -7.69630969e-01f, -6.54107451e-01f, 7.65995681e-01f, 1.92019090e-01f,
  -5.78530014e-01f, -6.27561152e-01f, -5.61966300e-01f, -8.27420890e-01f, -5.66099405e-01f, -2.82296568e-01f, 5.05993187e-01f, -7.32405365e-01f, 1.03978485e-01f, 5.33323109e-01f,
  -5.88463783e-01f, -7.18381822e-01f, -5.74441791e-01f, -7.97607839e-01f, -5.72277784e-01f, -3.36460680e-01f, 6.36989117e-01f, -4.89483804e-01f, -4.46067274e-01f, 6.95203468e-02f,
  7.30928659e-01f, -5.40409803e-01f, 1.23547041e+00f, -8.47587168e-01f, -7.62341619e-01f, 8.02636325e-01f, 6.16996467e-01f, 6.22048259e-01f, 1.22044710e-02f, -3.84956241e-01f,
  -1.43673018e-01f, -8.61064017e-01f, 1.04461861e+00f, 7.47886181e-01f, 1.14805095e-01f, -2.54929602e-01f, -1.38255572e+00f, -1.33697009e+00f, -5.99979818e-01f, -8.16141307e-01f,
  -7.73432672e-01f, -9.95320618e-01f, -7.85312474e-01f, -6.27620041e-01f, 3.10857773e-01f, 7.04594627e-02f, -8.42691243e-01f, -7.32380927e-01f, 7.33410358e-01f, -6.08677089e-01f,
  -3.92648429e-01f, 4.86270845e-01f, 4.28847611e-01f, -9.15416002e-01f, -9.15965557e-01f, 8.63005459e-01f, -3.70437279e-02f, 1.05494273e+00f, -1.04966497e+00f, -7.12905467e-01f,
  -3.16951513e-01f, 8.76327038e-01f, 1.04708862e+00f, -6.04793310e-01f, -8.46862078e-01f, -6.52580738e-01f, -3.31198603e-01f, 9.33835447e-01f, 2.54106503e-02f, -7.98174858e-01f,
  -1.92858517e-01f, -9.03053224e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.12678307e-01f, -4.12254930e-01f, -1.62022725e-01f, -2.62362748e-01f, 2.58232743e-01f, -3.59277204e-02f, 6.88272864e-02f, 2.44086295e-01f, 5.74263111e-02f, -2.54143596e-01f,
  -1.68055952e-01f, -1.33507043e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    