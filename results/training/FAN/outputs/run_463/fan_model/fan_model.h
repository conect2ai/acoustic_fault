/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 9 x 120)
const int L0_fan_Wp_rows = 9;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.15464818e-01f, 1.39590934e-01f, 4.72531207e-02f, -2.51015157e-01f, -2.81105995e-01f, 1.45897165e-01f, -2.33543664e-02f, -1.61874846e-01f, -7.96863288e-02f, 1.76303923e-01f,
  -8.31380114e-02f, -1.53815448e-01f, 1.25753656e-01f, -1.11039601e-01f, -1.54703334e-01f, 3.92031133e-01f, -1.49435788e-01f, -9.82371643e-02f, -2.61304285e-02f, -1.89812750e-01f,
  -1.27513707e-01f, -2.04855129e-01f, 2.00533029e-02f, -1.15489751e-01f, -1.91175938e-01f, -9.62193757e-02f, -1.01755001e-01f, 6.70612305e-02f, 5.72945476e-02f, -2.67826058e-02f,
  2.27449015e-02f, 1.44849755e-02f, -7.97055066e-02f, 4.02758420e-02f, -4.85587567e-02f, 4.00105454e-02f, -1.44775317e-03f, 2.99695861e-02f, -6.49417415e-02f, 9.23847109e-02f,
  1.77098121e-02f, -1.10085100e-01f, -3.60469110e-02f, -4.03771689e-03f, -5.31276129e-02f, -4.60078828e-02f, 1.77305751e-02f, -6.44084066e-02f, -9.27564688e-03f, -3.00889537e-02f,
  3.21811205e-03f, -4.04347032e-02f, 2.09446028e-02f, 4.10473011e-02f, -5.58796376e-02f, 1.79556347e-02f, -3.65794892e-03f, 1.42690111e-02f, 1.10360673e-02f, -2.05843560e-02f,
  -3.96091864e-02f, 5.57829551e-02f, 4.97810990e-02f, -1.20008690e-02f, 2.26322119e-03f, 3.75795886e-02f, 3.42320018e-02f, 1.32930484e-02f, 2.71170978e-02f, 3.04816961e-02f,
  1.05272550e-02f, 6.65278966e-03f, 3.13466340e-02f, 6.99437931e-02f, 3.23413797e-02f, -5.34718707e-02f, -3.61382999e-02f, -5.31036519e-02f, -2.63027288e-02f, 2.32020975e-03f,
  5.69360554e-02f, -4.56964504e-03f, 3.42960358e-02f, -2.89100390e-02f, 2.50435267e-02f, 3.15331742e-02f, 1.35012378e-03f, 6.13486096e-02f, -7.74824899e-03f, -2.65443213e-02f,
  1.47943288e-01f, -9.21426341e-02f, 5.39278192e-03f, -6.41951263e-02f, 9.33490545e-02f, -6.06831461e-02f, -4.75567468e-02f, -1.88414324e-02f, 2.84480136e-02f, -2.97090504e-02f,
  -1.07445888e-01f, 2.33493131e-02f, 5.26664369e-02f, -3.47055979e-02f, -1.24423837e-04f, 4.45777141e-02f, -4.27577011e-02f, -5.65084517e-02f, -9.85616222e-02f, -2.96717007e-02f,
  -1.38794407e-02f, 4.81088720e-02f, 1.57070402e-02f, -9.15735662e-02f, -4.12909836e-02f, 1.49835618e-02f, -3.15846168e-02f, 5.90416742e-03f, -1.82338264e-02f, 5.65902051e-03f,
  4.92221177e-01f, -4.07750875e-01f, 3.19950640e-01f, -4.26775357e-03f, 7.44728670e-02f, -1.62872538e-01f, -1.37497550e-02f, -9.88733694e-02f, -6.55948222e-02f, -2.62191147e-01f,
  -4.55323383e-02f, 3.76025476e-02f, -5.32626128e-03f, -2.16244131e-01f, 2.66448170e-01f, -7.53979981e-02f, -2.71097645e-02f, -1.39269477e-03f, -1.50023038e-02f, -3.08573712e-02f,
  1.20259717e-01f, -2.06809074e-01f, 1.66627318e-01f, -1.12007320e-01f, 6.34356141e-02f, 7.08473921e-02f, -4.80955839e-02f, 5.53919338e-02f, -7.95574039e-02f, 3.32903937e-02f,
  3.83923538e-02f, -2.93018809e-03f, 6.57035336e-02f, 6.61517233e-02f, 7.14633167e-02f, 1.15612345e-02f, 4.37673833e-03f, 1.10278994e-01f, 4.67212684e-02f, -4.15941626e-02f,
  2.32472760e-03f, 3.29229943e-02f, 2.62849722e-02f, 8.03365707e-02f, -3.26487012e-02f, 6.68667927e-02f, 1.91894341e-02f, -2.06912383e-02f, -4.71109785e-02f, 8.19339883e-03f,
  3.42915356e-02f, 3.58343162e-02f, -1.40068820e-02f, -5.72632961e-02f, 3.41410376e-02f, 4.22792435e-02f, -2.16428302e-02f, 8.83316025e-02f, 1.89038794e-02f, 1.57822315e-02f,
  9.96074174e-03f, 7.85358250e-03f, 2.56153159e-02f, 1.36465160e-03f, -1.22248214e-02f, -5.40576316e-02f, -2.80485861e-02f, 2.53851973e-02f, 2.48860531e-02f, -4.84947711e-02f,
  4.43312377e-02f, -7.66895013e-03f, -4.06409688e-02f, -2.68749148e-02f, -3.26445177e-02f, -1.18451007e-02f, 6.65438920e-02f, -2.36862916e-02f, 1.38628222e-02f, 1.41183930e-02f,
  -6.17259108e-02f, -3.41546349e-02f, -2.43730322e-02f, -3.36465030e-03f, -4.52762768e-02f, 3.96655314e-02f, -7.74013475e-02f, -3.86921726e-02f, 2.09427043e-03f, -1.30998436e-03f,
  -2.17278808e-01f, -3.84573340e-01f, -1.20243523e-02f, 9.57804266e-03f, -2.16932548e-03f, 1.55744981e-03f, -2.13444456e-02f, -5.63877188e-02f, 6.36769785e-03f, -6.10457771e-02f,
  -1.62034463e-02f, 2.93208528e-02f, -2.93407887e-02f, 3.44634280e-02f, 1.04023376e-02f, -5.09287231e-02f, -6.65322468e-02f, 1.54946726e-02f, -2.14600544e-02f, -3.57265286e-02f,
  -1.84239633e-02f, -1.45723885e-02f, 2.82344166e-02f, -4.96593956e-03f, 2.01718621e-02f, -2.76961308e-02f, 4.39768191e-03f, 3.47217955e-02f, -4.40966971e-02f, -3.21564339e-02f,
  -4.16759551e-01f, 5.63207008e-02f, -3.68985757e-02f, -3.76088351e-01f, -8.06072578e-02f, 3.24889004e-01f, 2.24129006e-01f, -1.18426889e-01f, -1.53292805e-01f, 2.40156487e-01f,
  7.34401569e-02f, 5.26272766e-02f, 3.31808448e-01f, 7.32462993e-03f, -1.06542902e-02f, 2.32831091e-01f, -1.18997745e-01f, 1.59530807e-02f, -9.56078991e-02f, 1.32667413e-02f,
  -1.22426219e-01f, 8.48013610e-02f, -4.81673293e-02f, 4.53965068e-02f, -1.66286185e-01f, -1.86020508e-01f, -1.11046411e-01f, 1.36697784e-01f, -8.04217532e-02f, 4.60379086e-02f,
  5.50896600e-02f, -9.85735357e-02f, -5.00053093e-02f, 5.34195565e-02f, -8.93820077e-02f, -1.37775475e-02f, 4.92284819e-02f, 7.27119893e-02f, -7.91715756e-02f, -3.77984308e-02f,
  3.07111125e-02f, 2.35320870e-02f, -4.92243730e-02f, -1.29148588e-02f, -6.02411851e-02f, -7.78866932e-02f, -5.13123162e-02f, -3.38124000e-02f, 9.25622694e-03f, 7.81562254e-02f,
  -3.36063723e-03f, 3.14020440e-02f, -5.99845685e-02f, -6.51824800e-03f, -3.06036100e-02f, -9.62265283e-02f, 5.42924516e-02f, 6.01146109e-02f, -5.22234570e-03f, -9.74473134e-02f,
  2.33057141e-02f, 3.23454700e-02f, 1.00959033e-01f, -7.44144944e-03f, 1.00691635e-02f, -9.70675722e-02f, -3.56045440e-02f, 5.54159284e-02f, -1.13830091e-02f, 4.14141193e-02f,
  -4.85346243e-02f, -1.63507406e-02f, -1.71706434e-02f, -2.96135154e-02f, 1.28934365e-02f, 3.06513831e-02f, 3.41377594e-02f, 3.50941047e-02f, -3.28951478e-02f, -1.14375232e-02f,
  -2.15933695e-02f, -7.20582753e-02f, 3.36953476e-02f, 3.26948501e-02f, 2.35886648e-02f, 5.02847619e-02f, -9.30683780e-03f, -5.33819664e-03f, -2.16505360e-02f, 6.43328726e-02f,
  1.20516673e-01f, 1.42756596e-01f, 5.59212156e-02f, 1.80118997e-02f, 4.64818850e-02f, 2.05743629e-02f, 3.93855758e-02f, -5.63935675e-02f, -1.89481154e-02f, -1.60744954e-02f,
  -6.86167553e-02f, 2.46564113e-03f, -4.74557094e-02f, 3.82120302e-03f, 6.03444055e-02f, 1.78511180e-02f, 9.84798744e-02f, 2.14970261e-02f, 3.47063765e-02f, 3.80753763e-02f,
  -4.36051143e-03f, -2.62524970e-02f, 8.64867866e-03f, -5.96716516e-02f, 4.39643823e-02f, -5.82944136e-03f, -1.23371966e-02f, 7.55876070e-03f, -5.47049288e-03f, 1.40385348e-02f,
  -5.45890570e-01f, -1.36173144e-01f, 3.74427810e-02f, -7.46742636e-02f, 2.75971033e-02f, -8.35414976e-02f, -6.40989989e-02f, 8.06020051e-02f, -3.42798710e-01f, 2.50942470e-03f,
  8.57116431e-02f, -3.69853020e-01f, -5.91944903e-03f, 1.54961988e-01f, -1.70915410e-01f, -4.92384210e-02f, 6.01633117e-02f, -9.23095047e-02f, -1.33371964e-01f, -1.80929825e-02f,
  2.62801386e-02f, 8.05671886e-02f, 2.91976631e-01f, 2.15940088e-01f, 1.24949910e-01f, -9.91561785e-02f, 1.74519673e-01f, 4.16876338e-02f, 2.24318013e-01f, -1.20181628e-02f,
  3.34073268e-02f, -1.40005767e-01f, 1.07512563e-01f, -1.56247504e-02f, 5.98906428e-02f, 1.65958181e-02f, -6.27019033e-02f, 2.32826378e-02f, 2.76065655e-02f, -6.40248507e-02f,
  -9.99375954e-02f, -3.92304696e-02f, 1.33531829e-02f, -3.51742434e-04f, -6.87550828e-02f, -2.92888023e-02f, -3.50032374e-02f, 6.83549568e-02f, -8.46896507e-03f, 2.11685523e-02f,
  1.93498153e-02f, 6.22349530e-02f, 1.11774530e-03f, -2.23155293e-04f, 3.28771323e-02f, -4.07642201e-02f, 9.70164537e-02f, 2.87212990e-02f, -2.24616453e-02f, -6.94766417e-02f,
  -4.76585329e-02f, 6.58597872e-02f, 7.40031153e-02f, 3.62370983e-02f, -2.28287689e-02f, 2.44363099e-02f, -3.55660170e-02f, 3.45153771e-02f, -5.86450845e-02f, -1.98710505e-02f,
  1.98113509e-02f, 4.45959577e-03f, -2.17276290e-02f, 2.80269142e-02f, 1.44469962e-02f, -4.02963161e-02f, 5.15133031e-02f, 4.82707610e-03f, 2.87155565e-02f, 3.13907489e-02f,
  2.56675258e-02f, 1.39498627e-02f, 2.69787461e-02f, 3.74155678e-02f, 1.47799430e-02f, -7.95860142e-02f, 7.55465552e-02f, -2.63739452e-02f, -1.16541898e-02f, 1.73417032e-02f,
  -1.48381323e-01f, -2.23045610e-02f, 3.34966145e-02f, 3.35107266e-04f, -1.49910906e-02f, -2.40466017e-02f, 7.62052909e-02f, -1.06810173e-02f, -1.50734407e-03f, 3.31251808e-02f,
  -2.49392949e-02f, 2.23271064e-02f, -3.35305296e-02f, -1.16198137e-02f, 6.03997968e-02f, -4.18057054e-04f, -1.32382922e-02f, -1.37834698e-02f, 6.46009669e-02f, 1.19922524e-02f,
  3.81924026e-03f, -5.39664477e-02f, 3.62856388e-02f, 3.85492407e-02f, 4.79924865e-02f, 3.60174105e-02f, -8.06540102e-02f, -3.01820412e-02f, 5.87959215e-02f, 3.49453613e-02f,
  2.27773152e-02f, 8.48924592e-02f, 3.16979468e-01f, 1.30265415e-01f, -1.16636291e-01f, -1.51441634e-01f, -7.04251528e-02f, 1.00473955e-01f, 1.86386064e-01f, -9.50346887e-02f,
  -1.21655561e-01f, 1.30412728e-01f, 5.68269379e-02f, -6.97020516e-02f, -2.15348089e-03f, 3.60863097e-02f, 2.20436808e-02f, 7.19476789e-02f, 1.94887035e-02f, -3.83211412e-02f,
  1.53207332e-01f, -1.53033808e-01f, 7.95579776e-02f, -9.26706120e-02f, -9.49389338e-02f, 1.40935518e-02f, -1.91597089e-01f, 2.87856646e-02f, -8.54662508e-02f, -5.78522682e-02f,
  -6.01346865e-02f, 4.86542806e-02f, -1.29901581e-02f, 1.91594735e-02f, -8.69272351e-02f, -9.50464420e-03f, -2.02176534e-02f, -1.01480678e-01f, -4.34126630e-02f, 7.22888261e-02f,
  -2.55467184e-02f, -1.23865180e-01f, 7.84312412e-02f, 2.68952735e-02f, 9.72904190e-02f, -1.00096138e-02f, -7.04204738e-02f, -6.32725060e-02f, 1.29492376e-02f, -5.09914430e-03f,
  7.91368335e-02f, 1.53090619e-02f, -2.90994477e-02f, 2.94025633e-02f, 1.32072428e-02f, -1.54393027e-02f, 3.35025452e-02f, -2.78053023e-02f, -7.84439445e-02f, 4.48407382e-02f,
  1.82457343e-02f, 7.16534778e-02f, 1.68928113e-02f, -3.77235301e-02f, -9.64384992e-03f, -3.26820984e-02f, 1.40898919e-03f, -9.24159586e-02f, 1.64117198e-02f, -6.74644187e-02f,
  -2.25778054e-02f, 2.33840402e-02f, 3.15343030e-02f, 4.48837914e-02f, 2.47084424e-02f, 3.19797397e-02f, -4.41462547e-02f, -1.13702819e-01f, 5.64348139e-02f, -3.67203355e-03f,
  4.35337089e-02f, -4.33921954e-03f, -4.51493673e-02f, 7.36304931e-03f, 3.44512053e-02f, 5.09879701e-02f, 1.99611709e-02f, 7.42527246e-02f, -9.02838483e-02f, -7.86344931e-02f,
  -2.56758839e-01f, 5.03068157e-02f, -4.14104275e-02f, -7.42603317e-02f, -1.10519432e-01f, -3.27049568e-02f, 1.39071390e-01f, 5.80768064e-02f, -3.34759206e-02f, 3.81324906e-03f,
  3.05352127e-03f, 3.34002934e-02f, -6.39566258e-02f, 1.06049154e-03f, 3.45410639e-03f, -2.47798245e-02f, 5.29133901e-02f, -4.51978743e-02f, -9.57523510e-02f, 2.81499755e-02f,
  -1.20908991e-01f, -4.98076789e-02f, -3.89087722e-02f, -3.78451124e-02f, 2.62371320e-02f, -1.31274136e-02f, 2.64974609e-02f, 5.33875898e-02f, -1.15444800e-02f, -3.39737423e-02f,
  5.39987795e-02f, 4.06584442e-02f, -3.49484563e-01f, -1.42899185e-01f, 1.70301631e-01f, -1.16065100e-01f, -1.65772393e-01f, -4.72950302e-02f, -5.43748848e-02f, 1.86885640e-01f,
  8.40199962e-02f, -1.54455304e-01f, -1.40652820e-01f, 1.35427602e-02f, -2.48054847e-01f, -1.31009176e-01f, 1.85643043e-02f, 8.40131044e-02f, -1.61038175e-01f, 2.94344649e-02f,
  -7.54502639e-02f, 8.09568316e-02f, -2.84992307e-01f, 1.70524374e-01f, 2.07690850e-01f, 3.01274322e-02f, 2.09635124e-01f, -1.21743284e-01f, 2.17049733e-01f, 2.61594206e-02f,
  9.52597409e-02f, -5.01114018e-02f, -7.18643740e-02f, 6.94082642e-04f, 7.08606020e-02f, 4.07090932e-02f, -1.34420618e-02f, -1.46955892e-01f, -2.42954995e-02f, -3.12939100e-02f,
  3.51706967e-02f, -6.22118413e-02f, 1.75680090e-02f, -4.62688357e-02f, -9.46288742e-03f, -5.45221334e-03f, 2.45672651e-02f, -4.84161414e-02f, -4.27228399e-02f, 9.88962688e-03f,
  -5.21868579e-02f, 4.14924994e-02f, -1.75060406e-02f, 7.80057833e-02f, -4.78466451e-02f, -3.62063795e-02f, -7.20533729e-02f, 4.76879254e-02f, 1.70669064e-03f, 5.46158850e-02f,
  4.51705698e-03f, 3.70058678e-02f, 1.15582589e-02f, 2.51268689e-02f, -9.39315930e-03f, -4.52718288e-02f, 6.41529933e-02f, 1.35713350e-02f, -5.40264398e-02f, 2.53685415e-02f,
  4.37853970e-02f, 3.95376086e-02f, -2.27404311e-02f, -3.15903798e-02f, -1.20569598e-02f, 7.59330997e-03f, -5.81531376e-02f, 1.10037982e-01f, 2.04148665e-02f, 3.24598025e-03f,
  -3.28005813e-02f, -1.74749661e-02f, 1.14635276e-02f, 4.44077291e-02f, -6.56369552e-02f, -5.27090468e-02f, 5.05784526e-02f, -5.00745922e-02f, -6.93929866e-02f, -4.69719656e-02f,
  2.93004096e-01f, 1.21691965e-01f, -1.23149306e-02f, 8.29746723e-02f, 3.37304473e-02f, 8.88518170e-02f, -2.72834674e-03f, 4.90993559e-02f, -3.18316631e-02f, -3.21180448e-02f,
  2.44140122e-02f, 9.80279967e-02f, 7.46413693e-02f, 3.65900360e-02f, 4.75464575e-02f, 1.21071329e-02f, 1.67861376e-02f, 5.83054721e-02f, 1.27629668e-01f, 2.34466381e-02f,
  4.37915102e-02f, 4.07752320e-02f, -4.65111881e-02f, 4.18983633e-03f, 1.14301220e-01f, 3.05709168e-02f, 3.55845429e-02f, -1.04808234e-01f, 9.55523700e-02f, -5.10843582e-02f,
  8.44462812e-02f, 2.54516780e-01f, 4.82247733e-02f, -3.84369463e-01f, -6.47872016e-02f, 1.77277565e-01f, -9.18622166e-02f, -1.54454783e-01f, -1.19547032e-01f, -2.81626750e-02f,
  -2.07922623e-01f, 2.63029218e-01f, 8.48638713e-02f, -3.06297719e-01f, -3.48386653e-02f, 9.09450874e-02f, -2.11194843e-01f, -1.19759142e-02f, 7.28872493e-02f, -4.64953762e-03f,
  -1.54514804e-01f, -2.78450429e-01f, -2.72123143e-02f, -1.07446283e-01f, 2.46018693e-02f, 2.96554584e-02f, -1.10596664e-01f, 7.39981532e-02f, -6.58595189e-02f, 1.17466286e-01f,
  -2.38452666e-02f, -8.04256648e-02f, 2.12478284e-02f, -3.14979777e-02f, -3.22809517e-02f, 2.00947989e-02f, 5.17652929e-03f, 4.23400570e-03f, -8.89847614e-03f, -8.04553088e-03f,
  1.03016473e-01f, 2.32668445e-02f, -5.25592454e-03f, -7.39312090e-05f, -9.97243542e-03f, -1.28817735e-02f, 8.43696855e-03f, -3.50668025e-03f, 4.27511754e-03f, 2.05997694e-02f,
  3.89236324e-02f, -3.37592065e-02f, -1.04442418e-01f, 3.89473001e-03f, 4.45005819e-02f, -1.45464726e-02f, 3.76688922e-03f, 9.65285152e-02f, 3.16275917e-02f, 3.14499401e-02f,
  3.03700343e-02f, -6.57093711e-03f, 2.36661714e-02f, 2.28233710e-02f, -6.41371086e-02f, 4.11602575e-03f, -3.95839917e-04f, 1.64390858e-02f, 4.09411841e-05f, -2.59150639e-02f,
  -3.54065634e-02f, -9.98962857e-03f, -1.19050495e-01f, 5.45030981e-02f, -2.58925483e-02f, -1.63260084e-02f, 6.06981516e-02f, 4.02808525e-02f, -4.14016545e-02f, -2.66563799e-03f,
  -1.07800607e-02f, 7.93020427e-03f, 1.42775744e-03f, 1.79077834e-02f, -2.26673502e-02f, -6.87754573e-03f, 4.28274041e-03f, 6.69311658e-02f, 5.43379225e-02f, 1.18850935e-02f,
  -6.45211339e-02f, 4.02612239e-02f, 2.17817798e-02f, 3.54299881e-02f, -2.11976049e-03f, 4.55725193e-03f, 8.20046384e-03f, 5.92858270e-02f, 3.89071330e-02f, -3.66487764e-02f,
  -2.24975981e-02f, -3.77167128e-02f, 5.26673831e-02f, -7.86266197e-03f, -4.17773472e-03f, 1.84333008e-02f, -9.82663706e-02f, 3.31742726e-02f, -6.77392557e-02f, -5.77437319e-03f,
  -4.13826518e-02f, 9.30360705e-02f, -8.92831362e-04f, -3.83004406e-03f, -4.83707990e-03f, 2.08132919e-02f, 1.80709977e-02f, -2.87307687e-02f, -7.70363770e-03f, -2.86202040e-02f,
  4.48476553e-01f, 1.02847889e-02f, 3.66738737e-01f, 9.90191773e-02f, 3.63519877e-01f, 4.03901041e-01f, 2.51404256e-01f, 1.81647599e-01f, 3.78198355e-01f, -2.24431038e-01f,
  -1.07770234e-01f, -9.86792333e-03f, -2.11794093e-01f, 2.13665608e-02f, 2.65598834e-01f, 1.64475664e-02f, 1.70995638e-01f, 3.17027122e-02f, 9.12211239e-02f, 1.61056481e-02f,
  9.47176218e-02f, -8.09842050e-02f, 1.09510928e-01f, -1.01112656e-01f, 1.54866502e-01f, -3.64256836e-02f, -2.25215778e-01f, 6.66299239e-02f, -2.36459207e-02f, 9.55408067e-02f,
  3.04406770e-02f, -9.82965752e-02f, -8.10256749e-02f, -2.31780112e-03f, 2.55092625e-02f, 2.05293335e-02f, -2.19946485e-02f, 2.57628858e-02f, 3.26499976e-02f, -9.13405512e-03f,
  -6.10047579e-02f, 5.70039228e-02f, -3.84813398e-02f, -5.88965788e-02f, 7.99174756e-02f, 5.23504764e-02f, 3.60537209e-02f, 4.50954139e-02f, -3.29816267e-02f, 1.05359942e-01f,
  1.64078996e-02f, 1.06062749e-02f, 9.86389667e-02f, -4.96811233e-03f, 6.83005527e-02f, -1.97053552e-02f, 4.72663604e-02f, -2.47631073e-02f, -1.11591080e-02f, 9.59723443e-02f,
  1.52739724e-02f, 1.30823553e-01f, 2.92540975e-02f, 2.07012687e-02f, -7.05334097e-02f, -5.97243980e-02f, 2.54777614e-02f, -3.55776623e-02f, 1.00212462e-01f, -6.51761517e-02f,
  6.60616755e-02f, -3.85338487e-03f, -2.45219078e-02f, 3.79157104e-02f, -6.63172873e-03f, -6.64305389e-02f, -2.05235332e-02f, -7.96736404e-03f, 6.30450845e-02f, -2.30272394e-02f,
  -5.12870662e-02f, 3.53782587e-02f, -2.00290885e-02f, 3.45475785e-02f, 2.73005646e-02f, -4.24706675e-02f, -1.93125121e-02f, 3.98751535e-02f, 6.47309572e-02f, 5.45351999e-03f,
  9.86485276e-03f, 3.88041548e-02f, -5.67799173e-02f, -1.60278287e-02f, -5.26453666e-02f, -4.32194397e-02f, 5.51787764e-02f, -6.17057085e-03f, 1.88439258e-03f, 4.09406573e-02f,
  3.09215188e-02f, -1.97999422e-02f, 5.66038042e-02f, 7.61717856e-02f, -6.30759522e-02f, -7.28690624e-03f, 2.86388607e-03f, -1.17412601e-02f, 3.26339379e-02f, -5.04306555e-02f,
  -1.88372156e-03f, -2.36683786e-02f, -6.76638335e-02f, -8.08332115e-02f, -9.96856093e-02f, -5.23346849e-02f, 9.37700793e-02f, -3.26915793e-02f, 3.17533426e-02f, -2.30765697e-02f,
  1.42405048e-01f, -1.21665962e-01f, -6.71945363e-02f, 2.01482132e-01f, -8.79724398e-02f, 2.45037705e-01f, 2.88357347e-01f, -1.66171342e-01f, 1.15586957e-02f, 1.20700173e-01f,
  6.54528439e-02f, -1.24254324e-01f, -8.71548720e-04f, 1.58941105e-01f, 2.52097338e-01f, -1.45459943e-03f, 3.20116729e-01f, 6.67272359e-02f, -6.10260554e-02f, -4.97749634e-02f,
  -9.45957899e-02f, 1.94691300e-01f, -5.36645278e-02f, -1.46076530e-01f, -4.16681580e-02f, -1.50490135e-01f, 2.86039487e-02f, -1.46826357e-01f, 7.88357705e-02f, -4.69879583e-02f,
  1.12442359e-01f, -1.27403855e-01f, -7.06326738e-02f, 8.00729096e-02f, 4.31665173e-03f, 3.60781811e-02f, 7.48669580e-02f, -1.73461102e-02f, -1.02545537e-01f, -2.03148015e-02f,
  1.82163119e-02f, -4.81492020e-02f, 5.28071858e-02f, -1.69240087e-02f, -2.56696288e-02f, -3.04846428e-02f, -5.40163778e-02f, -1.63046997e-02f, -6.78566098e-02f, -1.62007399e-02f,
  -5.20303696e-02f, -3.08106411e-02f, 2.70155091e-02f, 9.09222886e-02f, 1.93259288e-02f, 6.30126446e-02f, 4.55729738e-02f, 3.19473110e-02f, 2.20646877e-02f, 3.36196572e-02f,
  2.08769999e-02f, -2.18419936e-02f, 7.58292004e-02f, -3.32730673e-02f, 1.28187314e-02f, -3.41368876e-02f, -1.18580693e-03f, -2.26838253e-02f, 3.53355557e-02f, -7.02041015e-02f,
  6.00128155e-03f, -2.42311023e-02f, -5.56648225e-02f, 3.35515430e-03f, 3.16971354e-02f, -5.34705706e-02f, 7.79872909e-02f, -6.64270073e-02f, 7.50613138e-02f, 4.26699175e-03f,
  3.45820724e-03f, 5.11584990e-02f, -5.22761568e-02f, 5.11126071e-02f, 5.16268797e-02f, -3.78658660e-02f, -6.05897047e-04f, 7.79491477e-03f, 7.82478303e-02f, 2.34463792e-02f,
  -3.95868197e-02f, 5.04124835e-02f, 6.12202915e-04f, 1.03390198e-02f, -5.79043590e-02f, 1.39276981e-02f, 6.58582151e-03f, -3.26178335e-02f, -3.08222994e-02f, -3.03435177e-02f,
  3.51473577e-02f, 5.74106257e-03f, 8.41991082e-02f, -1.52587071e-02f, 1.02802649e-01f, 2.27948148e-02f, 1.03895038e-01f, 3.83568518e-02f, 2.17984226e-02f, -2.22265236e-02f,
  4.24190145e-03f, -5.94047131e-03f, 2.35595517e-02f, -2.47569121e-02f, 6.91256821e-02f, 3.93150672e-02f, -6.16405159e-02f, 3.21167484e-02f, 3.16918339e-03f, -7.14296401e-02f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.10395095e-02f, 3.80542204e-02f, -1.55984312e-01f, -1.13502063e-01f, 6.55445382e-02f, -1.68337926e-01f, -2.30351001e-01f, 1.66658312e-01f, -2.78481066e-01f, 1.56627089e-01f,
  4.28611115e-02f, -2.19257846e-01f, -1.93737715e-01f, -3.12169939e-01f, -3.29006821e-01f, -3.58835071e-01f, -1.18066780e-01f, -7.35863373e-02f, -1.65548310e-01f, 2.28684425e-01f,
  4.77547757e-03f, 3.74440029e-02f, -9.92314145e-02f, 3.27947050e-01f, 1.00560151e-01f, 3.72290075e-01f, 2.73850858e-01f, 2.43728608e-01f, 2.38997087e-01f, -7.41716251e-02f,
  4.53505665e-02f, -2.71941908e-03f, -5.83587736e-02f, -7.35673085e-02f, 1.12700142e-01f, 1.16369978e-01f, 7.59251490e-02f, -3.77277173e-02f, 2.85008308e-02f, -4.11273874e-02f,
  5.56478947e-02f, -2.79049333e-02f, 2.04752516e-02f, -9.05857701e-03f, 1.79869644e-02f, 2.46998053e-02f, -1.95396438e-01f, -1.16287850e-01f, -2.04615548e-01f, -1.04468442e-01f,
  -8.89456794e-02f, 5.63075580e-03f, -5.40543981e-02f, -3.04701906e-02f, 5.90997795e-03f, -4.87343082e-03f, 1.27650201e-01f, 6.23300970e-02f, -3.85630764e-02f, 3.94281223e-02f,
  1.12137750e-01f, 5.42933904e-02f, -6.07224144e-02f, -1.38591349e-01f, -3.63012739e-02f, 3.75855044e-02f, -1.34365886e-01f, -7.45424330e-02f, -1.03654474e-01f, 3.83376554e-02f,
  -4.06870805e-02f, 4.03772630e-02f, -2.57105995e-02f, 1.45206407e-01f, -5.52645046e-03f, -1.54120727e-02f, 6.85410127e-02f, 1.97755061e-02f, 3.82659584e-02f, -5.97259291e-02f,
  -8.74045596e-04f, 1.24265254e-01f, 5.23524657e-02f, 1.05711324e-02f, -7.23192245e-02f, 9.54110324e-02f, 5.81472404e-02f, 7.26632252e-02f, 5.92376664e-03f, 2.92331316e-02f,
  1.24703310e-01f, 2.60567099e-01f, -6.09443262e-02f, -7.24399909e-02f, 6.58611488e-03f, 2.08376646e-02f, -1.33245468e-01f, 2.23592715e-03f, 8.62641633e-02f, 9.68247429e-02f,
  1.14324026e-01f, -8.12195893e-03f, 1.69965014e-01f, 7.15311989e-03f, -6.07230887e-02f, 1.39436439e-01f, 2.03637794e-01f, 1.60705030e-01f, -5.80564654e-03f, 1.18744791e-01f,
  1.26220480e-01f, 1.34198517e-01f, -3.64503935e-02f, -1.34589616e-02f, 2.87307464e-02f, 9.31721926e-02f, 7.69442543e-02f, 2.53436208e-01f, -3.31727937e-02f, -3.75710689e-02f,
  -2.90415026e-02f, 1.96864337e-01f, -4.09763679e-02f, -2.61583984e-01f, 3.69852148e-02f, -3.22977185e-01f, -1.85397103e-01f, -9.28583089e-03f, 1.13686554e-01f, 2.28536606e-01f,
  -8.41854587e-02f, 2.09115833e-01f, 5.45337237e-02f, -1.57070875e-01f, -4.24688816e-01f, -1.47079989e-01f, -4.71942097e-01f, -1.97878420e-01f, -5.26941866e-02f, -2.16320589e-01f,
  -2.40857258e-01f, -1.80485025e-01f, -2.43651181e-01f, 9.61150974e-02f, -1.49166211e-01f, 7.06674978e-02f, -1.01084270e-01f, 9.89079326e-02f, -8.97416249e-02f, 4.48751152e-02f,
  2.57971846e-02f, 1.66334882e-01f, 1.28423169e-01f, 1.14040449e-01f, -1.33118346e-01f, -1.24206524e-02f, -9.60439444e-02f, 5.24584614e-02f, 5.39107956e-02f, -2.87491083e-03f,
  -4.56873849e-02f, -3.46767791e-02f, -4.06702701e-03f, 4.77147251e-02f, 8.85553658e-02f, 5.90203330e-02f, -4.81625553e-03f, -4.45724279e-03f, 1.29893385e-02f, -5.87790366e-03f,
  -2.94605792e-02f, -2.58955341e-02f, -7.90474266e-02f, 3.85905989e-02f, -5.49108535e-02f, 4.13028710e-02f, -5.09370118e-02f, -1.05593745e-02f, -6.92495797e-03f, 4.42101657e-02f,
  2.73378682e-03f, -5.09530790e-02f, 2.54244339e-02f, 6.92768209e-03f, 5.09712994e-02f, 5.39968675e-03f, 2.24271640e-02f, 3.53084914e-02f, 9.37359035e-02f, -3.25204134e-02f,
  -4.41513360e-02f, -3.95869873e-02f, 1.00071905e-02f, -1.66584015e-01f, -3.37670408e-02f, -3.22067700e-02f, -1.07143028e-02f, 7.90298134e-02f, -4.21601199e-02f, -5.48765436e-02f,
  3.57166491e-02f, 3.70417461e-02f, 3.88022996e-02f, -4.99194302e-02f, -2.16519143e-02f, 4.49615754e-02f, 4.70267422e-03f, 8.19842145e-03f, -7.15142637e-02f, -1.35772169e-01f,
  -3.25603671e-02f, -9.52813774e-02f, -2.45322138e-02f, 1.15239233e-01f, 1.89017262e-02f, -5.51470891e-02f, 3.95995155e-02f, -3.89073603e-02f, -2.50432994e-02f, -2.22697519e-02f,
  -5.68903424e-02f, -1.42835286e-02f, -6.36461051e-03f, -1.25258416e-01f, -3.91539074e-02f, -6.80281818e-02f, 3.62971914e-03f, 7.02693239e-02f, 2.52689682e-02f, -5.65606244e-02f,
  -1.04045100e-03f, 3.37912105e-02f, -1.78613979e-02f, 4.38993657e-03f, -5.65927289e-03f, 8.22031423e-02f, -7.58749247e-02f, 6.08634241e-02f, -3.57744955e-02f, -3.16364057e-02f,
  6.19558953e-02f, -3.79058331e-01f, 1.77117467e-01f, -7.75047094e-02f, 8.89718756e-02f, 2.24577188e-01f, 3.71709943e-01f, -1.86267629e-01f, -3.47472250e-01f, -3.63992095e-01f,
  -1.36851624e-01f, 3.38597178e-01f, 9.98025537e-02f, -6.25499114e-02f, 5.59731245e-01f, 9.29515585e-02f, 6.58377707e-02f, -9.69231203e-02f, -3.89919020e-02f, -1.45375550e-01f,
  -5.84938526e-02f, -6.53334484e-02f, 3.75604928e-01f, -2.08135113e-01f, -3.75907496e-02f, -1.94507744e-02f, 8.45738053e-02f, 2.35382557e-01f, -4.85216230e-02f, 1.64975956e-01f,
  -1.42323390e-01f, -2.29744986e-01f, 2.06238627e-02f, -8.88926461e-02f, -7.64322132e-02f, 3.29108052e-02f, 1.80041879e-01f, 2.15818837e-01f, 8.49510580e-02f, 1.27839250e-02f,
  7.40916505e-02f, -2.71434505e-02f, -6.57328367e-02f, 7.26649389e-02f, -9.14126411e-02f, -2.99828220e-03f, -3.43155907e-03f, -4.64800969e-02f, -4.84984331e-02f, -4.50540222e-02f,
  1.34079114e-01f, -6.11426793e-02f, -6.19640015e-02f, -2.93947700e-02f, -3.96139845e-02f, -6.15325086e-02f, 1.60460565e-02f, 1.31019846e-01f, -8.04111287e-02f, 2.92816591e-02f,
  -2.45010760e-02f, 2.58043762e-02f, -6.00582026e-02f, -8.65233615e-02f, 6.33356441e-03f, -5.29597998e-02f, 5.14520612e-03f, -5.26398513e-03f, -6.19792193e-03f, -4.02513891e-02f,
  -1.00166537e-01f, -2.24469639e-02f, -2.86261793e-02f, -1.06157109e-01f, -3.77927907e-03f, -1.25826001e-01f, 3.85058261e-02f, 3.51837352e-02f, -5.20932637e-02f, -4.07825299e-02f,
  5.53227961e-02f, 6.42593428e-02f, 1.97939798e-02f, 6.07385077e-02f, -8.25610459e-02f, 9.84088704e-02f, -5.52365817e-02f, -4.23217192e-02f, -7.68122599e-02f, 1.07753966e-02f,
  -1.53975978e-01f, -1.57304943e-01f, -6.65571392e-02f, -9.16065872e-02f, -2.51159891e-02f, -5.15236855e-02f, -4.26905490e-02f, -1.16961852e-01f, -1.02811316e-02f, -6.63234964e-02f,
  -1.47734091e-01f, 6.42690808e-02f, 6.97846934e-02f, -1.27614260e-01f, 3.12667713e-02f, -4.24713865e-02f, 2.22338829e-02f, 4.58139107e-02f, 4.40477431e-02f, -1.05122387e-01f,
  -7.19843581e-02f, 3.88095938e-02f, 7.75403604e-02f, 1.90021656e-02f, -1.88975662e-01f, -1.83930213e-03f, 1.72709431e-02f, 5.36743216e-02f, 8.30310956e-02f, -2.04419587e-02f,
  -3.48253340e-01f, 8.92407671e-02f, -3.70899260e-01f, -2.27449983e-01f, -2.46468455e-01f, -4.41419154e-01f, -3.17568034e-01f, -7.08064511e-02f, 3.95360403e-02f, 1.13064833e-01f,
  9.79657471e-02f, -6.30463213e-02f, 3.70540261e-01f, -1.15881339e-01f, -1.30580679e-01f, 2.98330069e-01f, -2.35769674e-01f, -1.29144490e-01f, 9.06525552e-02f, -2.70074248e-01f,
  -7.40884840e-02f, -3.66581827e-02f, -1.51801869e-01f, 1.24508806e-01f, -2.78065145e-01f, -1.65264338e-01f, -6.34626821e-02f, -3.05063576e-02f, -2.05838233e-01f, 1.19809173e-02f,
  -6.02161288e-01f, -2.56137311e-01f, -1.87159494e-01f, -1.53651983e-01f, -1.84851840e-01f, -5.90761006e-02f, -1.16237387e-01f, -1.86607372e-02f, -8.23715255e-02f, 7.48196035e-05f,
  -5.34956753e-02f, 2.68015675e-02f, 1.99722629e-02f, 5.77658601e-02f, -6.13203757e-02f, -9.19711664e-02f, 4.47346829e-03f, -1.88027844e-01f, -9.84410942e-02f, -3.94642130e-02f,
  -6.90764412e-02f, -1.68863460e-02f, -1.36572793e-01f, -7.45116696e-02f, -2.08325516e-02f, -7.30510578e-02f, -2.06416566e-02f, -6.57916740e-02f, -1.60889193e-01f, -5.04374579e-02f,
  5.76494224e-02f, -4.90511432e-02f, 3.71379666e-02f, -1.18253026e-02f, -7.75224790e-02f, 2.72857286e-02f, -4.06373739e-02f, 1.77236851e-02f, 8.57036412e-02f, -8.35586935e-02f,
  -1.59726795e-02f, 1.45597728e-02f, -4.74901199e-02f, -1.33185312e-01f, -2.99573527e-03f, -5.64301647e-02f, 7.74294958e-02f, -3.88580337e-02f, 3.42481136e-02f, -2.72596925e-02f,
  -8.44487622e-02f, -3.44053693e-02f, 1.48263769e-02f, -1.74361095e-02f, -2.01181672e-03f, -2.37174090e-02f, -6.47448301e-02f, 2.24516056e-02f, 1.23613499e-01f, -4.98848176e-03f,
  -3.72154176e-01f, -2.84825921e-01f, -2.73594484e-02f, -9.16668922e-02f, 5.81589974e-02f, -1.29534826e-02f, 1.16423473e-01f, -3.00263371e-02f, -5.95887303e-02f, -1.64742973e-02f,
  1.84876639e-02f, -1.54449046e-02f, -6.07233234e-02f, 5.04778884e-02f, 1.79666206e-02f, -9.16943979e-03f, -3.15649323e-02f, 1.02301687e-01f, -1.94718823e-01f, -1.23522528e-01f,
  -8.77003223e-02f, 4.80700098e-02f, 3.23070697e-02f, 5.24292290e-02f, -6.16963468e-02f, -1.72318090e-02f, 1.72997545e-02f, 1.18114175e-02f, -3.67434472e-02f, -3.71596105e-02f,
  2.67778933e-01f, 1.31603748e-01f, -1.36619031e-01f, -4.58054282e-02f, -4.04934101e-02f, 2.79606670e-01f, 5.32621324e-01f, -6.87273890e-02f, -5.07216528e-02f, 1.32837296e-01f,
  -3.01349838e-03f, 1.21507369e-01f, 1.48050770e-01f, 1.27571300e-01f, 2.72026986e-01f, 1.71230972e-01f, 2.78609186e-01f, 2.22306132e-01f, 1.19946068e-02f, 1.52917072e-01f,
  -1.72815230e-02f, 2.32376501e-01f, -1.47393182e-01f, -7.29525760e-02f, 9.18587148e-02f, -1.37288079e-01f, -1.24040850e-01f, -6.88579008e-02f, -1.21616013e-01f, 7.09148794e-02f,
  8.08915868e-02f, -1.54650211e-02f, -3.63136716e-02f, 1.46888085e-02f, 4.86283787e-02f, 1.40279755e-02f, 7.12382048e-02f, 7.62564177e-03f, -8.35113972e-02f, -1.50298439e-02f,
  8.73089209e-02f, -7.26657584e-02f, -1.91624719e-03f, 3.65948817e-03f, 7.67140761e-02f, 5.83956987e-02f, -1.13994814e-01f, -2.62357760e-02f, -7.93339126e-03f, 3.64949033e-02f,
  8.45567808e-02f, -1.63656436e-02f, -1.18896700e-01f, 8.33772793e-02f, 1.57776065e-02f, -2.47987583e-02f, 6.72363043e-02f, -4.78848517e-02f, 1.19198918e-01f, 9.60216969e-02f,
  8.43400955e-02f, -6.56086300e-03f, 9.85667706e-02f, -6.98665902e-02f, 7.27773383e-02f, -6.80385232e-02f, -3.57005803e-04f, -3.02932374e-02f, 4.93658567e-03f, 4.37008217e-03f,
  -2.78344136e-02f, 5.53435311e-02f, -2.02818755e-02f, 1.80420112e-02f, 3.82464267e-02f, 9.98725742e-03f, 6.58539124e-03f, -1.37506817e-02f, -8.95572230e-02f, -2.48012785e-02f,
  -3.11033195e-03f, -8.57341662e-03f, 2.26517394e-02f, 2.68355217e-02f, 5.36635295e-02f, 5.41279875e-02f, -4.55774320e-03f, -4.10921052e-02f, 1.40820919e-02f, 7.35662803e-02f,
  1.70659900e-01f, 3.29146534e-01f, 3.96745652e-02f, -7.38252774e-02f, 2.95883487e-03f, 8.70771147e-03f, -1.12591339e-02f, 2.29197741e-02f, 7.00079128e-02f, 1.89111039e-01f,
  2.86515467e-02f, -7.58550912e-02f, 5.85458726e-02f, -6.18556738e-02f, -5.24934493e-02f, 1.75671536e-03f, 3.56596708e-02f, 4.27627414e-02f, 3.31905410e-02f, 2.13794410e-02f,
  -1.32035211e-01f, 7.35916048e-02f, 6.13316372e-02f, 1.21102727e-03f, -1.43283941e-02f, -1.10116589e-03f, -1.24899730e-01f, 4.33996581e-02f, 1.49197178e-02f, -1.39626116e-02f,
  3.22930247e-01f, -4.26056802e-01f, -1.48999542e-01f, 9.15146172e-02f, 1.43040419e-01f, 1.12895563e-01f, 7.50104412e-02f, 8.67696181e-02f, -1.77483574e-01f, -9.33279246e-02f,
  2.20118742e-02f, -1.29962503e-03f, -1.28699437e-01f, 1.02083392e-01f, 3.71612191e-01f, -2.35781208e-01f, 1.72881842e-01f, -8.66202787e-02f, -1.72310635e-01f, -1.73845998e-04f,
  8.24025348e-02f, 3.34735811e-01f, 1.13314547e-01f, 9.22310203e-02f, 9.21254605e-02f, -1.54695556e-01f, 6.73279315e-02f, -8.92994851e-02f, 1.95936888e-01f, 2.09229529e-01f,
  4.41129506e-02f, -1.10823333e-01f, 6.41865805e-02f, -7.32212588e-02f, -5.55097722e-02f, -6.77785873e-02f, -3.09296157e-02f, 1.03574120e-01f, 6.22330699e-04f, -2.12219488e-02f,
  1.36610745e-02f, 4.33217958e-02f, -2.39217188e-02f, -1.00633670e-02f, 4.35926812e-03f, -6.86491579e-02f, -2.11876687e-02f, -9.41270068e-02f, -3.70187834e-02f, 5.34766540e-02f,
  -9.45449620e-02f, -9.08563882e-02f, 2.65375581e-02f, -1.65869016e-02f, -2.47970223e-02f, 2.46774573e-02f, -1.14988774e-01f, 3.15630692e-03f, -6.85457438e-02f, -5.71935996e-03f,
  6.96547925e-02f, -1.09071587e-03f, -3.01870871e-02f, 5.43058105e-02f, 4.63473750e-03f, 1.99659895e-02f, 7.91762248e-02f, 1.91169679e-02f, -3.79402540e-03f, 3.00999694e-02f,
  -1.58852767e-02f, 1.00389712e-01f, 2.78309919e-02f, 1.00126609e-01f, 1.21655568e-01f, -9.92462412e-03f, -2.31806133e-02f, 3.44156027e-02f, 1.11277113e-02f, -7.18807057e-02f,
  -1.35248173e-02f, -3.93593460e-02f, 1.44568328e-02f, -3.47521454e-02f, -5.04276752e-02f, 8.17891061e-02f, 1.24959007e-01f, -6.51930412e-03f, -7.21645728e-02f, 1.23924753e-02f,
  1.50826182e-02f, -6.77938834e-02f, -8.25048760e-02f, 8.24275985e-02f, -9.37594473e-02f, -1.60337593e-02f, -8.06751400e-02f, -1.45456260e-02f, -4.30337824e-02f, 1.19475294e-02f,
  -2.23900639e-02f, -8.46740082e-02f, 5.48555050e-03f, 3.67978849e-02f, -6.78801090e-02f, 8.41445178e-02f, -5.97623922e-02f, -4.92502674e-02f, 4.69771214e-02f, -1.68132149e-02f,
  -1.21861855e-02f, -7.76847079e-02f, 2.56413333e-02f, -3.06124948e-02f, 1.16709918e-02f, -9.57781076e-02f, 5.12481444e-02f, -1.93284433e-02f, -2.08304934e-02f, -4.67392951e-02f,
  -3.47722769e-01f, 2.42571354e-01f, -2.52898391e-02f, -1.59271359e-01f, -2.36034319e-02f, -3.44752818e-01f, -4.66658831e-01f, 1.73431002e-02f, -2.24674627e-01f, -1.51423141e-01f,
  -2.20751017e-01f, 5.49572371e-02f, 9.50300172e-02f, -1.84473872e-01f, 3.03317487e-01f, 3.71807992e-01f, 2.04745054e-01f, -1.46314472e-01f, 2.73912311e-01f, 1.49519026e-01f,
  2.30557680e-01f, 2.28664070e-01f, 3.80443126e-01f, 2.34022483e-01f, -2.87736710e-02f, -1.85991619e-02f, 2.72788554e-01f, 1.76331520e-01f, -3.06239612e-02f, 2.57450971e-03f,
  -1.67400777e-01f, 1.73108563e-01f, -6.15422763e-02f, -4.92649227e-02f, -4.16628160e-02f, -2.23198548e-01f, -8.07149336e-02f, 8.26265849e-03f, -3.47012468e-02f, -8.49986747e-02f,
  -1.04963109e-02f, 1.30674258e-01f, -1.05005100e-01f, 6.00034706e-02f, -2.12679487e-02f, 8.43700022e-02f, 1.36391282e-01f, -1.69510003e-02f, 7.26202577e-02f, 2.85961479e-03f,
  4.28085476e-02f, -1.59834586e-02f, 6.56933263e-02f, 7.45530985e-03f, 1.00349195e-01f, -8.69672596e-02f, -9.42878053e-02f, 7.41253123e-02f, 4.72214743e-02f, -9.99875292e-02f,
  5.48551753e-02f, -1.27169222e-01f, 1.28730647e-02f, -7.75914937e-02f, 2.61973515e-02f, -1.27194554e-01f, 1.15567960e-01f, -1.33363694e-01f, -2.18874235e-02f, 1.78706218e-02f,
  -1.23588346e-01f, -4.57113460e-02f, -7.60030672e-02f, -8.38278010e-02f, -3.58477309e-02f, -7.97168091e-02f, -1.89825986e-02f, -3.42635587e-02f, -6.89747632e-02f, 2.21981294e-02f,
  8.18339735e-02f, -5.23342863e-02f, 1.06802903e-01f, 6.74820840e-02f, -4.08166572e-02f, 5.16332174e-03f, 1.58146825e-02f, -6.38798252e-02f, 1.22787133e-01f, 1.28042832e-01f,
  1.66273266e-01f, 3.31547588e-01f, -2.92003099e-02f, -1.29015483e-02f, 2.97915190e-02f, 8.12086686e-02f, -4.96919900e-02f, 2.25278698e-02f, 4.02633138e-02f, 5.40054105e-02f,
  -2.85152253e-02f, -1.77345164e-02f, 7.30316527e-03f, -8.44758227e-02f, 3.88948582e-02f, 5.94058493e-03f, 4.02648561e-02f, 7.91113172e-03f, 1.23012356e-01f, 1.52934149e-01f,
  1.01619465e-02f, -9.11306068e-02f, 7.56290331e-02f, -2.86877397e-02f, -1.07870921e-01f, -3.26635875e-02f, -1.52750090e-01f, -3.12466044e-02f, 3.01805064e-02f, 1.03533529e-01f,
  -3.68525714e-01f, 4.02064055e-01f, -1.17462583e-01f, 3.11494768e-01f, -3.47871900e-01f, -8.50083232e-02f, 3.27918410e-01f, -1.14143454e-01f, 2.57171631e-01f, 4.37849462e-01f,
  7.86341429e-02f, 1.80054083e-01f, 3.24988365e-01f, 2.74132073e-01f, 2.42510334e-01f, 4.49025422e-01f, 2.74047703e-01f, 3.30041736e-01f, 6.52579665e-02f, 7.93500617e-02f,
  8.17570165e-02f, 1.45746708e-01f, -4.61432384e-03f, -1.07953556e-01f, -2.86518365e-01f, -1.52855560e-01f, 1.33666039e-01f, -1.97140500e-01f, 8.56361017e-02f, -6.48072064e-02f,
  -1.36407942e-01f, -4.25804555e-02f, -1.25746667e-01f, -5.83305135e-02f, -1.03231780e-01f, -1.04061916e-01f, -6.91051409e-02f, -1.12877339e-01f, -7.42015541e-02f, 2.65597403e-02f,
  -4.69182096e-02f, -5.46199605e-02f, 5.64381592e-02f, 7.17893429e-03f, -1.06475614e-01f, 4.46945690e-02f, -1.33893907e-01f, -4.56225723e-02f, -1.81147289e-02f, -1.08363047e-01f,
  -6.04613610e-02f, -3.51445861e-02f, -5.72022535e-02f, 1.65309444e-01f, -1.13662533e-01f, 1.96291991e-02f, 5.55805936e-02f, -4.67508137e-02f, -1.86721087e-02f, 5.37247844e-02f,
  1.32538807e-02f, 3.36563922e-02f, 5.66997286e-03f, 1.76853705e-02f, -1.41855450e-02f, -8.52795225e-03f, 9.01375636e-02f, 3.86807956e-02f, 6.92881504e-03f, -7.92220160e-02f,
  -6.54200017e-02f, -7.02233687e-02f, -2.88518984e-02f, -4.46846485e-02f, 1.79689117e-02f, 2.53295954e-02f, -7.10818991e-02f, 9.02771354e-02f, 2.56916191e-02f, -9.75476857e-03f,
  9.85526443e-02f, -8.59350562e-02f, 7.78739005e-02f, 1.71444826e-02f, 1.10484671e-03f, 1.84924267e-02f, 5.17358864e-03f, -2.71827001e-02f, -9.65674743e-02f, -1.13076642e-01f,
  2.54712045e-01f, 4.14662927e-01f, 1.02443501e-01f, -7.57110938e-02f, 7.43286312e-02f, -1.64236668e-02f, 1.07992724e-01f, 4.59670415e-03f, 2.00988367e-01f, -1.03017971e-01f,
  -2.67121624e-02f, 6.63697720e-02f, -1.07330725e-01f, -3.86484079e-02f, 7.66763464e-02f, 1.86248217e-02f, 1.44881964e-01f, 1.14556648e-01f, 1.38584957e-01f, -7.67663941e-02f,
  5.91821931e-02f, 3.33139822e-02f, -4.91119083e-03f, -1.10302128e-01f, 5.34483325e-03f, 2.20405720e-02f, 5.89384437e-02f, -1.20183729e-01f, -9.98345464e-02f, 8.47038925e-02f,
  8.60089734e-02f, 3.02078366e-01f, 3.68777066e-01f, 9.60796848e-02f, -1.36132285e-01f, -2.59142548e-01f, -3.00172687e-01f, 4.61597778e-02f, -2.95496434e-01f, -1.28970429e-01f,
  -2.89701167e-02f, 1.31220266e-01f, -5.98904192e-02f, 1.74574956e-01f, 5.58858402e-02f, -2.14681730e-01f, 1.16641991e-01f, 1.53477997e-01f, 1.07245520e-02f, 3.00063074e-01f,
  5.47017865e-02f, 4.50449809e-02f, 2.15193659e-01f, 3.09121404e-02f, 9.03363302e-02f, 2.85804838e-01f, 2.70626664e-01f, 6.46382570e-02f, 3.66530508e-01f, 1.04748935e-01f,
  -1.90387224e-03f, -2.97639184e-02f, 1.15404531e-01f, 8.79031792e-02f, 6.27526715e-02f, 8.72872025e-02f, 7.64788911e-02f, -7.52908513e-02f, 2.69298051e-02f, 8.58570337e-02f,
  9.67691001e-03f, 6.57670721e-02f, 8.66313204e-02f, -4.75032181e-02f, -3.01647671e-02f, 2.87062814e-03f, 4.34363112e-02f, 8.02693367e-02f, 9.49423686e-02f, 1.45596350e-02f,
  1.25730127e-01f, -4.89367172e-02f, 1.50213074e-02f, 1.79850347e-02f, -1.71827544e-02f, 7.44316354e-03f, -2.56139785e-03f, 1.47978574e-01f, 4.66038324e-02f, -2.11312082e-02f,
  6.96877018e-02f, 3.07575595e-02f, 2.92238202e-02f, -6.65932819e-02f, -2.57920548e-02f, -3.77199948e-02f, -1.97945796e-02f, -3.90428714e-02f, -6.45536045e-03f, 2.34859418e-02f,
  -4.79003694e-03f, 1.37894675e-02f, -1.44943297e-01f, -4.47505489e-02f, -8.71250704e-02f, -4.26998921e-02f, 1.44172469e-02f, -2.24933419e-02f, -1.54774881e-03f, -1.15419552e-01f,
  -1.91443399e-01f, -4.68466841e-02f, -4.75286841e-02f, -1.11325696e-01f, -1.12478763e-01f, -6.18461519e-03f, 9.56802163e-04f, -3.75673510e-02f, 1.49532268e-02f, -4.20364039e-03f,
  6.40064571e-03f, 3.75320345e-01f, -2.35283244e-02f, -1.34639172e-02f, 3.92194465e-02f, -4.70292158e-02f, -1.14795394e-01f, 1.50107667e-01f, 1.21512160e-01f, 5.69814001e-04f,
  7.65924156e-02f, -2.82509886e-02f, 7.07314759e-02f, 6.32151887e-02f, 4.62016128e-02f, -2.96566207e-02f, -9.56794433e-03f, -3.12826112e-02f, 5.25954477e-02f, 1.59777746e-01f,
  4.29750085e-02f, -4.97108586e-02f, -1.11562185e-01f, -6.52510822e-02f, 4.56479639e-02f, 3.97994369e-02f, 9.07538866e-04f, -8.91111493e-02f, 2.26497993e-01f, 4.41656652e-04f,
  2.79887885e-01f, 3.09165686e-01f, 1.91008374e-01f, 1.40770569e-01f, -7.66991079e-02f, 7.40433484e-02f, -2.97564227e-04f, -4.96239290e-02f, 2.43578672e-01f, 1.89825445e-02f,
  -2.47842997e-01f, 2.41542354e-01f, -1.19076572e-01f, -6.30294979e-02f, 1.12587683e-01f, 7.72464052e-02f, -4.88030426e-02f, 6.11986360e-03f, 1.24831102e-03f, -6.13589138e-02f,
  1.57244056e-02f, -2.03761920e-01f, -2.13699043e-01f, -2.23636255e-01f, -2.93464333e-01f, -1.16122946e-01f, -3.50575596e-01f, -7.70268440e-02f, 5.49214669e-02f, -9.63791609e-02f,
  -1.58062845e-03f, 2.63816807e-02f, 6.64430410e-02f, 7.52556026e-02f, 2.89974436e-02f, 7.22826496e-02f, 3.66828851e-02f, 1.44580072e-02f, 9.48844627e-02f, -2.63811946e-02f,
  -8.47150311e-02f, -1.03059756e-02f, 3.45528647e-02f, -6.41978979e-02f, -7.17077870e-03f, -2.24213321e-02f, 1.10102057e-01f, 6.69046491e-02f, -2.81810779e-02f, -1.79541726e-02f,
  5.25503457e-02f, 1.07349411e-01f, 5.64528555e-02f, 1.14895880e-01f, 1.60066932e-02f, 3.24879140e-02f, 1.05738521e-01f, 1.35557905e-01f, 8.49471763e-02f, 6.46077767e-02f,
  4.43029441e-02f, 5.64244241e-02f, -3.42659466e-02f, -8.75421241e-02f, -6.81669638e-02f, -2.66566314e-02f, -4.77738399e-03f, -8.53848085e-03f, 9.03078839e-02f, 3.60807851e-02f,
  -1.30053639e-01f, 2.85982452e-02f, 5.79594634e-02f, 3.13380100e-02f, -7.11776316e-02f, -7.46269748e-02f, 8.62599462e-02f, 3.42521779e-02f, 5.49134947e-02f, -3.73679097e-04f,
  -3.35710943e-02f, 5.04519045e-02f, -6.43746778e-02f, -7.30392784e-02f, -7.34232366e-03f, 1.20913032e-02f, -6.79233596e-02f, 1.06661357e-01f, -4.69698347e-02f, -3.63481045e-02f,
  7.02560544e-02f, 1.24642551e-01f, 4.60747406e-02f, 6.18336275e-02f, 8.65421295e-02f, -6.32300451e-02f, 8.32212195e-02f, -1.55359535e-02f, 1.12040266e-02f, -3.26623768e-02f,
  7.90221244e-03f, 1.01396488e-02f, 3.58744152e-02f, 9.90923680e-03f, 1.16539344e-01f, -1.53597251e-01f, -1.22812903e-03f, 1.05668187e-01f, 7.26642609e-02f, 2.21809726e-02f,
  -1.05019016e-02f, 7.58705661e-02f, -1.38168996e-02f, -3.35185565e-02f, -3.36749218e-02f, 7.54689053e-02f, 4.54001203e-02f, 9.06770229e-02f, -1.32715106e-02f, 8.72445777e-02f,
  -3.77142996e-01f, -1.01743847e-01f, -2.19879553e-01f, -1.56542003e-01f, 8.20042118e-02f, 2.21023202e-01f, -5.08518070e-02f, -7.21009895e-02f, -3.98638606e-01f, 1.45819172e-01f,
  4.14105542e-02f, -2.91967928e-01f, -3.90019305e-02f, -6.93991184e-02f, -8.00017342e-02f, -3.81209925e-02f, 6.64048195e-02f, 1.14944234e-01f, -4.39873002e-02f, 5.67824929e-04f,
  -9.87815857e-03f, 7.47672888e-03f, -1.28811300e-01f, 1.20703004e-01f, -8.40742700e-03f, 1.20494235e-02f, 3.11488122e-01f, 1.27941705e-02f, 1.07504368e-01f, -1.40512750e-01f,
  -7.54873678e-02f, -1.23119786e-01f, -6.58553019e-02f, -4.23817970e-02f, -1.72972418e-02f, 1.02087736e-01f, 1.39866799e-01f, 4.40239087e-02f, -7.14637861e-02f, -8.64356086e-02f,
  -2.23698318e-02f, -1.71039179e-02f, 7.86394998e-02f, -4.08584736e-02f, -1.88970170e-03f, 1.68713145e-02f, -1.59436956e-01f, 1.09632798e-02f, 4.24881577e-02f, -2.70386878e-02f,
  -2.21394934e-02f, 1.20273910e-01f, 1.43568188e-01f, -4.28516716e-02f, -2.79562362e-02f, -9.95795429e-03f, -1.16423452e-02f, -3.43156606e-02f, 1.21158257e-01f, 2.24987715e-02f,
  2.88775880e-02f, 2.16998141e-02f, 5.36408573e-02f, -3.87166627e-02f, -1.45321518e-01f, 5.48750907e-02f, -8.03271160e-02f, 3.54845598e-02f, 5.84932417e-02f, -4.53771912e-02f,
  -4.27681617e-02f, -1.96149834e-02f, -4.38796654e-02f, 4.57460387e-03f, -1.13583371e-01f, -8.51812214e-03f, -7.57965771e-03f, 3.44268568e-02f, 5.75175509e-03f, 9.94667634e-02f,
  -6.59064353e-02f, -3.98111381e-02f, -1.26316715e-02f, 1.40986487e-01f, -2.25571729e-02f, 3.02041415e-03f, -4.19080071e-02f, -2.68237274e-02f, -8.05990621e-02f, 2.05384605e-02f,
  3.20513360e-02f, 1.22806421e-02f, 1.55247701e-03f, -9.07822624e-02f, 2.02696603e-02f, 4.09706570e-02f, 4.08478379e-02f, -1.30891090e-03f, -3.10048759e-02f, -2.81103421e-02f,
  4.24677134e-02f, 8.17331895e-02f, 1.07854657e-01f, -4.37544398e-02f, -3.28051746e-02f, -1.38157442e-01f, 9.89319682e-02f, 9.65742692e-02f, 7.50312880e-02f, -1.13006949e-03f,
  -2.62192525e-02f, 2.67334841e-02f, -5.05511798e-02f, 9.49591175e-02f, -3.91658433e-02f, 1.08180068e-01f, 5.13024889e-02f, -3.88613753e-02f, 8.26745182e-02f, 1.71403699e-02f,
  2.35682763e-02f, 6.55554608e-02f, -2.14029506e-01f, 1.88184753e-01f, -1.52551606e-01f, -3.51673439e-02f, -1.48924351e-01f, -1.86839513e-03f, -2.44426444e-01f, 7.79920295e-02f,
  2.73318827e-01f, 1.96789891e-01f, -1.08470246e-01f, 4.39906090e-01f, 4.47167158e-01f, -1.10233255e-01f, 2.53107846e-01f, 9.78528187e-02f, -9.56594199e-02f, 1.54836655e-01f,
  1.16755843e-01f, 3.66641998e-01f, 1.73289657e-01f, 2.97440439e-01f, 9.37309340e-02f, 7.79022723e-02f, 2.96005011e-01f, -4.15742770e-02f, 4.36056346e-01f, 2.04037681e-01f,
  -8.53348523e-02f, -1.24788014e-02f, -3.50219868e-02f, -5.77531978e-02f, 5.74918315e-02f, 1.94822587e-02f, -4.67616245e-02f, 7.36172497e-02f, -1.09167797e-02f, 2.49969754e-02f,
  -1.24627709e-01f, 4.87727858e-02f, -5.58639206e-02f, -2.43013334e-02f, 7.32113123e-02f, -1.56510212e-02f, -7.14244694e-02f, 7.17425440e-03f, -5.01664616e-02f, 4.56136279e-02f,
  -1.74930915e-01f, 2.32140869e-02f, -2.17933208e-02f, -7.30479835e-03f, 2.56794179e-03f, -3.06304395e-02f, 3.03045381e-03f, -1.19272046e-01f, -1.10300541e-01f, 5.66782206e-02f,
  -1.12760067e-02f, -1.06232673e-01f, -3.91563848e-02f, -1.68309398e-02f, 2.89346110e-02f, 9.97643471e-02f, 8.95518884e-02f, 9.15940702e-02f, 2.56779254e-03f, 1.43416181e-01f,
  1.72312409e-02f, 8.69864319e-03f, -1.21139269e-02f, -1.78242140e-02f, 5.01565151e-02f, -5.37384413e-02f, -5.83099313e-02f, -4.03628265e-03f, -5.63103780e-02f, 7.19236657e-02f,
  8.43171850e-02f, 1.10108249e-01f, -2.01763157e-02f, 1.80833489e-02f, 1.54898502e-03f, 1.91994070e-03f, 1.73682626e-02f, -1.08338590e-03f, -3.39333303e-02f, 5.09059988e-03f,
  1.27977654e-01f, 8.46823156e-02f, -1.59253404e-02f, -1.84716731e-02f, 5.49084143e-06f, -3.49821001e-02f, 4.11190577e-02f, 3.60660218e-02f, 8.03666115e-02f, 4.42020968e-02f,
  7.82565586e-03f, 1.99458040e-02f, 3.98776531e-02f, 2.85162292e-02f, 5.56725562e-02f, 1.93820372e-02f, 4.00847942e-02f, -6.33588806e-02f, 8.03322066e-03f, 3.22746970e-02f,
  -2.79839635e-02f, -4.91655990e-02f, -2.77732275e-02f, -7.05359429e-02f, 1.46089159e-02f, -1.20383976e-02f, 3.35936397e-02f, 3.29189710e-02f, 4.19496074e-02f, 2.79890820e-02f,
  2.37072259e-01f, 4.20129418e-01f, 3.05893838e-01f, 2.43508652e-01f, -3.21830928e-01f, -3.18944037e-01f, -2.28644714e-01f, -2.93151615e-03f, -6.63235486e-02f, 1.01559363e-01f,
  -1.59634501e-01f, 5.14873683e-01f, -2.42328778e-01f, 2.17869431e-01f, -2.02915266e-01f, -2.73765147e-01f, 1.17716484e-01f, 9.13808569e-02f, -4.03016619e-02f, 2.03078404e-01f,
  1.93094313e-02f, -1.86925441e-01f, 9.75506455e-02f, -6.32473081e-02f, 2.87727982e-01f, 2.91856200e-01f, 3.38371797e-03f, -9.39756036e-02f, 3.28952372e-01f, -1.05458677e-01f,
  -8.84887949e-02f, 1.89348236e-02f, 1.32760108e-01f, -7.24194646e-02f, 3.07279974e-02f, -9.88340750e-02f, 9.01290178e-02f, 9.20822192e-03f, -6.05123341e-02f, 2.43370719e-02f,
  6.89661428e-02f, -1.37869567e-01f, -4.37805727e-02f, -5.07713407e-02f, -6.05131574e-02f, 8.19904134e-02f, 1.49556613e-02f, 3.03068943e-02f, 8.15459564e-02f, 1.37802199e-01f,
  1.23789467e-01f, 1.05705358e-01f, 2.39461064e-02f, -1.45737221e-02f, 6.38259277e-02f, -7.96432942e-02f, 5.40231653e-02f, 7.19078705e-02f, 1.13063000e-01f, -2.04565339e-02f,
  -5.72113805e-02f, -1.42883211e-01f, 1.02723911e-02f, 9.49448571e-02f, -1.73724853e-02f, 5.06042270e-03f, -2.52577402e-02f, 3.39409672e-02f, -3.88754085e-02f, -8.74511972e-02f,
  -2.34309100e-02f, 9.84604582e-02f, -1.13652861e-02f, 2.19104066e-02f, 1.27279535e-02f, 6.37912750e-02f, 2.18390040e-02f, -3.52729447e-02f, -2.88504809e-02f, 7.25384727e-02f,
  -1.14386762e-02f, -9.54072475e-02f, 7.63546675e-02f, 8.50595608e-02f, -4.03223597e-02f, 9.94971991e-02f, 7.44515508e-02f, 1.31125432e-02f, 2.96501201e-02f, 3.17119248e-02f,
  -3.79189104e-02f, 1.18298814e-01f, -3.15225199e-02f, -8.53209421e-02f, 3.61793227e-02f, -3.12736141e-03f, -3.11708432e-02f, 3.18988711e-02f, -1.52793126e-02f, -3.22144926e-02f,
  -3.02229766e-02f, 5.11679128e-02f, -1.19411806e-02f, -2.38611996e-02f, -3.23020183e-02f, 3.02549209e-02f, 1.30025446e-02f, 2.60741990e-02f, 1.82545707e-02f, 4.93484177e-02f,
  7.98100084e-02f, -9.99917388e-02f, -2.53718309e-02f, 1.86238624e-02f, -1.32370265e-02f, -1.27486035e-01f, 3.51097323e-02f, 5.96327409e-02f, -8.19311216e-02f, 2.45414581e-02f,
  3.46288741e-01f, 8.08943063e-03f, -2.41271764e-01f, -4.42323498e-02f, -2.14319631e-01f, -2.41647452e-01f, -3.42566848e-01f, -1.11113027e-01f, -6.16958886e-02f, -9.12060067e-02f,
  -7.98856467e-02f, -3.62977311e-02f, 4.10123542e-02f, -3.11299235e-01f, 4.57572997e-01f, 2.10729495e-01f, -1.70575738e-01f, -1.68113858e-01f, 9.50718150e-02f, -1.21622041e-01f,
  5.94395027e-02f, 6.90773651e-02f, 1.36250118e-02f, 6.19725473e-02f, -2.22520098e-01f, 8.91490877e-02f, 1.83765441e-01f, -1.91066027e-01f, -7.77898962e-03f, 7.02424347e-03f,
  -1.14046454e-01f, 4.32093479e-02f, -1.28867716e-01f, -1.14230104e-02f, -5.90211786e-02f, 2.70706639e-02f, 2.82202326e-02f, 1.31697711e-02f, -2.69027371e-02f, 2.72745118e-02f,
  -6.77154958e-02f, 1.24292336e-01f, 5.36154024e-02f, 1.05194747e-01f, -4.45540808e-02f, 9.31568258e-03f, 4.48411219e-02f, -1.33920372e-01f, -4.69126701e-02f, 1.62180625e-02f,
  -7.89322779e-02f, 3.21522355e-02f, -1.52257398e-01f, 9.96657982e-02f, 7.73647279e-02f, 2.58665625e-02f, 3.82008478e-02f, -1.66613497e-02f, 9.99632254e-02f, 1.63003877e-01f,
  1.78215019e-02f, 1.20943256e-01f, -1.62340235e-02f, -5.48948571e-02f, -2.28711199e-02f, -2.70746797e-02f, -4.13341001e-02f, -6.72885329e-02f, -1.62882462e-01f, -6.13554753e-02f,
  -5.51103726e-02f, 2.26162784e-02f, 4.16803472e-02f, 8.90656933e-02f, 3.56881618e-02f, 9.08526108e-02f, -3.47555280e-02f, -5.27220741e-02f, -6.23751208e-02f, 5.38990879e-03f,
  6.90852404e-02f, 1.57251999e-01f, -5.15154079e-02f, -8.56278837e-03f, 7.38257244e-02f, 7.64467716e-02f, 1.57785997e-01f, 6.82302117e-02f, -1.50821030e-01f, 3.66385356e-02f,
  -6.93723792e-03f, 3.08011025e-01f, -7.20730796e-02f, -7.36806765e-02f, 2.19383780e-02f, 1.11991234e-01f, 5.22794724e-02f, 1.85971767e-01f, 1.50171310e-01f, 3.48246694e-02f,
  -4.33922783e-02f, -1.57072648e-01f, 1.42158970e-01f, -7.33272210e-02f, -5.18127754e-02f, 3.65685276e-03f, -2.63101514e-02f, 6.03230819e-02f, -4.86179739e-02f, 1.02619879e-01f,
  5.54243773e-02f, 7.92443678e-02f, 5.76278791e-02f, -4.65426482e-02f, -7.13646412e-02f, -2.02737097e-02f, -6.79836944e-02f, 1.46016657e-01f, -2.96566859e-02f, 1.90388914e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.51297563e-01f, 2.14246199e-01f, 1.61460981e-01f, 5.42864688e-02f, 1.26339391e-01f, 2.25453019e-01f, 1.75230905e-01f, 2.94400215e-01f, 4.41404253e-01f, 2.35253409e-01f,
  2.06147328e-01f, 2.13713571e-01f, -5.88179007e-02f, 3.32024068e-01f
};

// L1_fan_Wp (Shape: 9 x 32)
const int L1_fan_Wp_rows = 9;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -2.74221729e-02f, -1.76568314e-01f, -8.50489661e-02f, 7.31445476e-02f, -1.00966498e-01f, -1.83260545e-01f, 3.99235524e-02f, 2.36559957e-01f, -1.14235133e-01f, 1.54593796e-01f,
  -2.52904683e-01f, 2.41326839e-01f, 3.95089686e-02f, -1.43608060e-02f, 1.66731834e-01f, 1.36739155e-03f, 1.21467784e-01f, 2.16700748e-01f, 1.50335416e-01f, -3.26789588e-01f,
  3.13715190e-01f, -5.02585061e-02f, 1.34966806e-01f, 8.99929926e-02f, 2.75679189e-03f, 3.94497812e-01f, 1.78372696e-01f, -3.18336748e-02f, -8.30302238e-02f, 3.88813555e-01f,
  -2.83770561e-01f, 2.12950215e-01f, 2.27496177e-01f, 4.11852971e-02f, -3.41861211e-02f, 1.51387542e-01f, 1.76831141e-01f, 2.15644151e-01f, 1.65833816e-01f, -3.80087286e-01f,
  -2.44366765e-01f, -6.52193204e-02f, -3.73974502e-01f, -2.52461731e-01f, -3.25787067e-01f, -1.15020752e-01f, 4.80913967e-01f, -2.08681539e-01f, -1.02853760e-01f, 1.65621728e-01f,
  1.62724018e-01f, 9.00642797e-02f, -1.97432742e-01f, 3.24654341e-01f, 3.03979635e-01f, -2.78515458e-01f, -2.46268600e-01f, 2.74291039e-01f, -1.95852250e-01f, 7.15201125e-02f,
  -1.78504571e-01f, 2.47428678e-02f, -3.35958879e-03f, 2.15246201e-01f, -1.96030527e-01f, 2.75185317e-01f, -2.80072898e-01f, -2.98631042e-01f, 5.46462312e-02f, 2.33793244e-01f,
  -2.36518577e-01f, 6.15684651e-02f, 9.48866978e-02f, -3.55166346e-01f, 4.72942740e-01f, -4.05829787e-01f, 6.08081743e-02f, 1.93461806e-01f, -3.23973030e-01f, 8.72975588e-02f,
  2.35773295e-01f, -2.18982194e-02f, -1.17060319e-01f, 2.08461732e-02f, 5.31739481e-02f, 4.09799889e-02f, -1.25198692e-01f, -2.12837011e-02f, 6.53701723e-02f, -6.86435327e-02f,
  5.37539497e-02f, 3.10909688e-01f, -4.44900095e-02f, 5.05579337e-02f, 3.49364251e-01f, -6.41354918e-02f, -2.98992127e-01f, 2.18528211e-01f, -2.54260860e-02f, 2.63166249e-01f,
  7.80836865e-02f, -2.50492513e-01f, 1.97730541e-01f, 1.07528329e-01f, 2.66511679e-01f, -1.04858100e-01f, 5.02970338e-01f, -9.12356898e-02f, 2.96208531e-01f, 2.03984931e-01f,
  -2.56038040e-01f, 9.35242772e-02f, 8.36605728e-02f, 1.38349719e-02f, 2.33742699e-01f, -1.07794836e-01f, 2.47866303e-01f, -2.29156539e-01f, -2.57501155e-01f, 3.40544820e-01f,
  -4.00835276e-02f, -2.78898269e-01f, 3.72178666e-02f, -4.02607955e-02f, 3.26399386e-01f, -5.55330962e-02f, -2.31156796e-01f, -2.95894414e-01f, 6.89138845e-02f, -1.08115785e-01f,
  -1.50540188e-01f, 9.59670320e-02f, -1.87935296e-03f, -1.03555381e-01f, -2.02135623e-01f, -2.83153594e-01f, -2.07678512e-01f, 3.64465564e-01f, -1.82777256e-01f, 1.85927395e-02f,
  4.68852699e-01f, 2.01068535e-01f, -2.12083235e-01f, -3.42415988e-01f, -5.31237006e-01f, -1.68976724e-01f, 2.14396805e-01f, 1.46258488e-01f, -2.26147532e-01f, -1.55421034e-01f,
  -2.83742219e-01f, -3.24901760e-01f, -4.67507169e-02f, 1.66576222e-01f, -5.46086915e-02f, -3.39194924e-01f, 2.41282448e-01f, -1.87554151e-01f, 1.28044765e-02f, -2.94425845e-01f,
  -3.36528540e-01f, 4.05196488e-01f, -3.01861644e-01f, -4.04395133e-01f, 1.46483108e-01f, 1.75873697e-01f, 5.43402545e-02f, 1.36015296e-01f, 4.90857251e-02f, -2.04826728e-01f,
  2.22065896e-01f, -4.33394462e-01f, 1.99879751e-01f, 3.43598902e-01f, -2.79217452e-01f, 2.26476938e-02f, 3.84707958e-01f, 1.99888751e-01f, -1.80652633e-01f, -1.21284015e-01f,
  -1.85624152e-01f, 1.49934530e-01f, -1.51953727e-01f, 9.72670619e-04f, 2.20807478e-01f, 2.28641495e-01f, 1.57080561e-01f, 2.16686025e-01f, -1.73856214e-01f, 1.91603005e-02f,
  4.50913161e-01f, 8.58389661e-02f, 2.55851686e-01f, -3.27309638e-01f, 2.11387768e-01f, 3.69820535e-01f, -4.71195318e-02f, -2.16650054e-01f, 2.61489660e-01f, -1.23987459e-02f,
  2.12781932e-02f, 4.08810169e-01f, -4.98369217e-01f, 5.21345258e-01f, 4.91213202e-02f, -2.48490497e-01f, 2.10065961e-01f, 2.83047646e-01f, -1.00285254e-01f, 1.26902252e-01f,
  1.66272804e-01f, 8.39433745e-02f, 1.42020017e-01f, -3.63438204e-02f, 2.33319774e-01f, -7.58987740e-02f, -1.38435379e-01f, 4.37937602e-02f, -7.45767653e-02f, -2.71597534e-01f,
  1.56499565e-01f, -6.19084872e-02f, -4.76714700e-01f, -1.18503742e-01f, 9.38155055e-02f, 3.31082910e-01f, -2.32988223e-01f, -1.17455879e-02f, 1.12403631e-01f, 4.74984080e-01f,
  -5.96221723e-02f, -3.93169194e-01f, 9.82991159e-02f, 1.95875376e-01f, 6.51001707e-02f, -3.59640926e-01f, -1.62200719e-01f, 4.21462208e-01f, -3.72010976e-01f, -3.10968667e-01f,
  1.35327037e-02f, -2.85256952e-01f, -2.77783215e-01f, 2.77407289e-01f, -1.98470786e-01f, 2.16287851e-01f, -8.21589828e-02f, -2.58153677e-01f, 2.99169898e-01f, 1.95872173e-01f,
  7.05425590e-02f, 1.34210274e-01f, -1.20418809e-01f, -2.43616328e-01f, 3.58542472e-01f, -6.29883260e-02f, -8.37322846e-02f, -9.38550234e-02f, 3.88219208e-02f, 1.32198140e-01f,
  -1.01570360e-01f, -1.50494680e-01f, -7.30813965e-02f, 3.38165909e-01f, -8.20438489e-02f, 2.62472421e-01f, -1.77346364e-01f, 8.66238698e-02f, 2.59923995e-01f, -1.37879729e-01f,
  6.72966987e-02f, 7.50780031e-02f, -9.92870331e-02f, 1.98765546e-01f, 1.70482293e-01f, -1.39640868e-01f, 1.79363027e-01f, -2.54964769e-01f, -1.85762987e-01f, 1.99552506e-01f,
  -2.27434009e-01f, -2.17290595e-02f, 2.23337576e-01f, -8.62986892e-02f, 2.56199002e-01f, 4.44123268e-01f, 4.11593527e-01f, -1.20483734e-01f
};

// L1_fan_Wp_bar (Shape: 14 x 32)
const int L1_fan_Wp_bar_rows = 14;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.23537563e-01f, 1.50445133e-01f, -9.73071456e-02f, 2.33510420e-01f, 1.60366878e-01f, 3.08259577e-02f, 1.57560572e-01f, 7.33277947e-02f, 2.85750240e-01f, -5.81665754e-01f,
  7.75518874e-03f, -2.67432243e-01f, -5.30066043e-02f, -1.93995699e-01f, 3.22532326e-01f, -5.01343250e-01f, 1.78572744e-01f, 1.89294353e-01f, 3.15079242e-01f, -1.00343920e-01f,
  1.10923067e-01f, -1.96609050e-01f, 2.43168592e-01f, 4.68250632e-01f, -2.40807399e-01f, 3.27705622e-01f, -9.57972370e-03f, 2.11731017e-01f, 2.76402563e-01f, 3.96208644e-01f,
  -3.27898204e-01f, 1.46790713e-01f, 2.32930273e-01f, 4.03157294e-01f, 2.98437059e-01f, -1.55278102e-01f, 8.14741775e-02f, 4.87986654e-01f, 8.87217000e-02f, -1.23310061e-02f,
  3.86516452e-02f, 1.17401056e-01f, 1.98446978e-02f, -9.34381187e-02f, -4.34308201e-01f, 1.34217799e-01f, 1.09120235e-01f, 4.77779359e-01f, 3.22699249e-02f, -3.34407210e-01f,
  -1.51376173e-01f, 6.00514650e-01f, -2.00657144e-01f, 5.45709372e-01f, 6.27108887e-02f, -9.54841897e-02f, 3.35280389e-01f, -3.85965519e-02f, 1.21731132e-01f, 2.31077999e-01f,
  -4.31898683e-02f, -1.32735714e-01f, 4.47127938e-01f, 4.44242746e-01f, 2.85297006e-01f, 7.50384331e-02f, 2.66562104e-01f, 2.75912106e-01f, 3.84383053e-01f, 1.77324593e-01f,
  1.19971253e-01f, 6.85328990e-02f, -2.64190324e-02f, 5.75154901e-01f, -5.25985122e-01f, 4.81502265e-01f, 5.31766236e-01f, 4.70026471e-02f, -9.78493765e-02f, 1.19411707e-01f,
  -5.06896973e-01f, -3.86702210e-01f, 4.74589288e-01f, 5.93923450e-01f, 1.09118246e-01f, 2.22166374e-01f, -2.29507387e-01f, -1.93657666e-01f, 2.12254986e-01f, -1.95606455e-01f,
  -5.20787835e-02f, -2.74326354e-01f, 3.59892160e-01f, -1.44383326e-01f, -1.92446783e-02f, -3.32643539e-01f, 4.03671026e-01f, 1.83122471e-01f, 1.54183984e-01f, 9.45072100e-02f,
  2.24056214e-01f, 1.53561071e-01f, 2.31886923e-01f, -2.46679768e-01f, -4.78721298e-02f, 3.57821971e-01f, -4.58478272e-01f, 1.52705580e-01f, 2.24057198e-01f, -6.91175135e-03f,
  2.17834815e-01f, 2.32800134e-02f, -4.02570307e-01f, -2.59781480e-01f, 3.13074172e-01f, 5.42599618e-01f, -1.11508414e-01f, 4.89227951e-01f, 2.05413759e-01f, -2.28521138e-01f,
  4.30248320e-01f, 1.99712813e-01f, 1.08261809e-01f, -2.51378626e-01f, 1.27977237e-01f, 1.53108150e-01f, -1.32638156e-01f, 7.79014379e-02f, 5.29510826e-02f, 3.99592787e-01f,
  3.21170568e-01f, -1.91555977e-01f, 2.46125251e-01f, 4.57352370e-01f, -1.03762165e-01f, 2.27223858e-02f, 1.61193565e-01f, 1.23362333e-01f, -2.40268977e-03f, -1.62321404e-01f,
  -1.40947357e-01f, 2.63209403e-01f, 1.15423687e-01f, 2.18277201e-01f, -8.40160996e-02f, -1.29504919e-01f, -3.99091579e-02f, 1.02886491e-01f, -2.36659065e-01f, 3.31601828e-01f,
  4.73750047e-02f, -1.86553076e-01f, 5.27283072e-01f, 4.11556482e-01f, 4.22762543e-01f, 4.55866009e-01f, -2.38519549e-01f, 1.47571355e-01f, 5.41229606e-01f, 4.51088130e-01f,
  3.49237114e-01f, 1.56316653e-01f, 2.36612588e-01f, 2.50658929e-01f, 1.37212008e-01f, 2.21050426e-01f, 2.92732775e-01f, 1.89185422e-02f, 3.59736383e-01f, -3.10212635e-02f,
  5.73372364e-01f, -4.28678811e-01f, -1.24202326e-01f, 3.18093479e-01f, -3.55963767e-01f, 2.41186261e-01f, 4.70091440e-02f, -2.29134783e-01f, 1.33332089e-01f, 4.49460715e-01f,
  4.10796672e-01f, 1.44352213e-01f, 2.93118227e-02f, 3.59987110e-01f, 1.37193769e-01f, -2.64812380e-01f, -5.54362647e-02f, 2.25191459e-01f, 1.26883611e-01f, -1.95725009e-01f,
  4.66401339e-01f, -1.07522376e-01f, 5.15775263e-01f, 4.63955045e-01f, 3.31585288e-01f, 3.77238154e-01f, 3.45559210e-01f, 9.21351686e-02f, 4.70708370e-01f, 2.46306136e-01f,
  3.42617035e-01f, 3.82103354e-01f, -1.69000495e-02f, 3.88122320e-01f, -4.85671237e-02f, 1.20302945e-01f, -4.64338452e-01f, 7.37144649e-01f, 5.99683106e-01f, -2.87089139e-01f,
  -3.07227410e-02f, 1.84406787e-01f, 5.12575328e-01f, -3.61891747e-01f, 3.45337614e-02f, -8.88969004e-02f, 1.37542952e-02f, -1.39670864e-01f, 2.92188942e-01f, 4.11911964e-01f,
  1.22443810e-01f, -1.76048532e-01f, 5.73292077e-01f, -3.08131725e-01f, -1.03107326e-01f, 1.70069724e-01f, 1.38458222e-01f, 1.10223889e-01f, 1.86152965e-01f, 9.84632447e-02f,
  6.21406548e-02f, 5.40433228e-01f, 2.46476859e-01f, 2.02120706e-01f, -1.10080734e-01f, 1.00884996e-01f, 6.44320905e-01f, 1.53728455e-01f, -2.78285623e-01f, 3.66598725e-01f,
  -3.22815776e-01f, -4.21141267e-01f, 4.88038093e-01f, 4.37741816e-01f, -1.30566821e-01f, 4.96603280e-01f, -3.11143756e-01f, -4.63197008e-02f, 6.30955756e-01f, -1.97051257e-01f,
  4.32435483e-01f, 8.34729075e-02f, 5.35877585e-01f, 1.82319254e-01f, 4.00209069e-01f, 8.39843228e-02f, 1.12508059e-01f, 2.35907082e-02f, 3.49972218e-01f, 1.89720035e-01f,
  7.13736713e-02f, 6.13656193e-02f, 5.14767289e-01f, 2.77194649e-01f, 3.41556609e-01f, -1.46788314e-01f, -1.65213160e-02f, 4.88992065e-01f, -7.88817704e-02f, -9.66357291e-02f,
  -1.24802984e-01f, 2.11375356e-01f, 2.34588355e-01f, 3.80555362e-01f, -3.23546305e-02f, -3.46001461e-02f, 3.00827146e-01f, 2.56360799e-01f, 4.77102667e-01f, 4.36406314e-01f,
  3.90080869e-01f, 4.70606923e-01f, 1.69314891e-01f, 7.79802725e-02f, 2.48137206e-01f, 5.36736667e-01f, -1.56633422e-01f, 3.33246738e-01f, 3.73286396e-01f, 2.13065892e-01f,
  5.01151860e-01f, 1.59870848e-01f, -5.22019789e-02f, 6.41771480e-02f, 5.52202761e-02f, 4.93867666e-01f, 1.19189851e-01f, -5.24290800e-01f, 5.67974336e-02f, -2.61596084e-01f,
  -4.62005645e-01f, -3.74900639e-01f, 5.65894127e-01f, 1.54957265e-01f, 1.20753728e-01f, 2.00214759e-01f, 4.37341124e-01f, 4.48060669e-02f, -1.50949964e-02f, -3.44462842e-01f,
  1.04593135e-01f, 5.55057943e-01f, -7.23931044e-02f, -4.53074835e-02f, 4.05470788e-01f, 3.62789631e-01f, 8.30112472e-02f, 3.59415919e-01f, 5.47582805e-01f, 3.05226356e-01f,
  -6.20407499e-02f, 1.40404448e-01f, -4.56288494e-02f, -7.91463554e-02f, 4.45076793e-01f, 3.11663002e-01f, 1.37751877e-01f, 1.49916206e-02f, 6.31060526e-02f, 5.40845037e-01f,
  -5.70226729e-01f, 4.95372832e-01f, 5.23044169e-01f, 3.65422636e-01f, -4.25458252e-01f, -2.68983543e-01f, -2.84015864e-01f, -1.48344189e-01f, 1.42754063e-01f, 6.18079752e-02f,
  -9.62366015e-02f, 6.55176103e-01f, -6.44539297e-02f, -3.28175813e-01f, 4.48224157e-01f, 4.68310893e-01f, 6.06827661e-02f, 2.55316216e-02f, -4.69611734e-02f, 1.48925230e-01f,
  -6.44835457e-02f, 2.64976859e-01f, 1.62643582e-01f, 1.48466140e-01f, 8.39628056e-02f, 9.55105796e-02f, 3.26258093e-01f, 1.73047781e-01f, 4.36092496e-01f, 1.88558429e-01f,
  1.17845833e-01f, 2.49915764e-01f, -6.78117454e-01f, 6.99937463e-01f, -4.62303042e-01f, -1.46236503e-02f, -1.88204184e-01f, 3.18649352e-01f, 1.76971018e-01f, 1.85409635e-02f,
  -2.93360263e-01f, -7.06888586e-02f, 3.63977313e-01f, 4.63760227e-01f, 4.72036391e-01f, 1.21504359e-01f, 1.56843051e-01f, 6.13252401e-01f, 9.34283659e-02f, 9.69176665e-02f,
  -1.57592267e-01f, 2.18116671e-01f, -3.90802771e-01f, 2.06398144e-01f, -8.20911750e-02f, -5.20655960e-02f, -2.32680440e-01f, 1.42195299e-01f, 2.19330549e-01f, 1.52884781e-01f,
  1.86505914e-01f, 8.74811113e-02f, 1.13043115e-02f, -2.52086103e-01f, 2.38235295e-01f, -4.15810138e-01f, 4.23808306e-01f, -1.28782868e-01f, -2.63387948e-01f, -4.08026904e-01f,
  -3.10613424e-01f, 2.64181763e-01f, 4.75695223e-01f, -2.34253332e-01f, -1.46206707e-01f, -1.29679158e-01f, 1.22535266e-02f, 4.43427771e-01f, 1.26069188e-01f, 4.36815441e-01f,
  1.35831416e-01f, 3.59855971e-04f, 4.63723540e-01f, 5.76886833e-01f, -9.54647288e-02f, 7.85617158e-02f, 6.04103040e-03f, -4.93170135e-03f, 3.80624607e-02f, 2.61131138e-01f,
  -7.04761371e-02f, -1.65097147e-01f, 1.68349817e-01f, 1.52697787e-01f, -2.16414079e-01f, -2.92202607e-02f, -2.70900816e-01f, 6.34718463e-02f, 3.59750152e-01f, -3.95171106e-01f,
  4.97764796e-01f, -1.98125541e-01f, -5.88013411e-01f, 1.26632899e-01f, 4.68650430e-01f, 1.62068561e-01f, -4.46502775e-01f, 3.87715280e-01f, 5.22745252e-02f, 1.57153860e-01f,
  2.22792313e-01f, 3.87093276e-01f, 2.34274715e-01f, -3.43315989e-01f, 3.59026641e-01f, 2.52718449e-01f, 1.17687933e-01f, 1.78721696e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 14)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 14;
const float L1_fan_Bp_bar_data[] = {
  3.86817098e-01f, 3.34447026e-02f, 2.72367477e-01f, 3.89471620e-01f, 6.53410032e-02f, 5.36275923e-01f, 1.29916623e-01f, 2.91878521e-01f, 3.07162911e-01f, 2.95137405e-01f,
  2.61463970e-01f, 3.17532778e-01f, 8.64496380e-02f, 1.38096407e-01f
};

// L2_fan_Wp (Shape: 9 x 32)
const int L2_fan_Wp_rows = 9;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  1.18299074e-01f, -3.37613761e-01f, 4.96214163e-03f, -7.23661333e-02f, 1.38223916e-01f, -2.20736548e-01f, -6.29007295e-02f, -1.17486142e-01f, 1.30113373e-02f, -1.93384290e-01f,
  4.27307822e-02f, -5.00572585e-02f, -3.46059263e-01f, 2.77229935e-01f, 9.48038232e-03f, 8.06024373e-02f, 3.86347294e-01f, -5.39235100e-02f, -1.03527278e-01f, 1.35432318e-01f,
  -2.92793751e-01f, 3.41393739e-01f, 2.97637343e-01f, 7.80928284e-02f, 8.69672969e-02f, 1.54410582e-02f, -1.34221137e-01f, -1.56242803e-01f, 1.84454143e-01f, -8.87640566e-02f,
  3.55249941e-02f, -2.00304911e-01f, -1.82057291e-01f, -3.07163838e-02f, 3.33917588e-02f, -5.74071221e-02f, 1.09702937e-01f, -5.54303341e-02f, -1.52948543e-01f, -6.21939525e-02f,
  -1.06583543e-01f, -2.45394409e-01f, -1.55924872e-01f, 3.89398754e-01f, -3.59832048e-02f, 1.40172362e-01f, 1.02436177e-01f, -2.61623025e-01f, 1.08287372e-01f, 3.74539336e-03f,
  -1.92896724e-01f, 1.25595495e-01f, 3.12284797e-01f, 2.65342537e-02f, 3.09093922e-01f, 6.60766438e-02f, 7.22287074e-02f, 6.92481175e-02f, -2.27725804e-01f, -4.68508899e-02f,
  1.16736718e-01f, -2.50829667e-01f, -1.38986677e-01f, -8.09468701e-02f, 4.94410507e-02f, -4.71218750e-02f, 1.96703956e-01f, 2.76147053e-02f, 2.69851238e-01f, 2.09547892e-01f,
  1.61560997e-01f, 1.49012469e-02f, 3.72882515e-01f, -8.83802027e-02f, 1.64740756e-01f, -9.91568342e-02f, 3.17123115e-01f, -4.56063636e-02f, -4.88741808e-02f, 4.41086054e-01f,
  -1.46166623e-01f, 3.28507483e-01f, 1.65763889e-02f, -1.94774255e-01f, -7.03340583e-03f, -9.73319188e-02f, -1.80760734e-02f, -4.63253744e-02f, 4.07821089e-01f, 4.18115593e-02f,
  7.83307627e-02f, -4.18271730e-03f, 2.13273913e-02f, 1.48536667e-01f, -6.78601563e-02f, -1.22163698e-01f, -4.78383526e-02f, 2.79368550e-01f, 1.78547695e-01f, -5.49375489e-02f,
  1.51382402e-01f, 1.00486338e-01f, 3.21090296e-02f, 1.60475180e-01f, 1.04541913e-01f, 1.44555671e-02f, -8.32233131e-02f, 2.48707682e-01f, 1.95105389e-01f, -1.51885346e-01f,
  3.72856289e-01f, -3.66947979e-01f, -4.92554216e-04f, -1.35313198e-01f, -4.03021388e-02f, 6.31158203e-02f, 4.70242649e-02f, -2.32355401e-01f, -1.22703023e-01f, 1.20110616e-01f,
  1.74929932e-01f, 8.42257068e-02f, -6.50849566e-03f, -2.03824654e-01f, -1.83655284e-02f, -1.03590712e-01f, 1.94860086e-01f, -2.12157235e-01f, -1.56260595e-01f, 1.21934392e-01f,
  8.46054554e-02f, -6.50769323e-02f, -1.05564155e-01f, -2.32869729e-01f, -1.59524828e-01f, 2.28929408e-02f, 2.12591328e-02f, 3.39457482e-01f, -2.51902282e-01f, 1.69670403e-01f,
  2.29666039e-01f, -2.09628046e-03f, 1.69251755e-01f, 1.31164014e-01f, -1.42321557e-01f, 2.83706307e-01f, -1.86384574e-01f, -1.29707515e-01f, -2.73134619e-01f, -3.01558733e-01f,
  1.58324525e-01f, -1.73177555e-01f, 1.26049072e-01f, -2.24271137e-02f, 1.58896893e-01f, -1.14228562e-01f, 1.57942742e-01f, 1.11782394e-01f, 2.23324001e-01f, -5.13334535e-02f,
  -5.78972697e-02f, 1.72400504e-01f, 1.66372508e-02f, 9.87296999e-02f, -6.82190657e-02f, -1.24078721e-01f, -9.19852927e-02f, -9.40444544e-02f, -3.04307461e-01f, -1.38375521e-01f,
  -3.16416919e-02f, 2.60136157e-01f, 7.18513504e-02f, -2.73637831e-01f, 3.06735843e-01f, -1.91713944e-01f, 1.30559564e-01f, 1.45660713e-01f, -9.66164172e-02f, 1.00786246e-01f,
  -1.55999646e-01f, -1.81431949e-01f, 2.71589905e-01f, 1.04517072e-01f, -2.38460451e-01f, 2.12984338e-01f, 4.25658338e-02f, 1.05091058e-01f, -5.66636585e-02f, -2.63980210e-01f,
  -1.20547544e-02f, -7.92798176e-02f, 1.22632764e-01f, -1.97105333e-01f, 9.38631687e-03f, -2.85791568e-02f, -4.55657542e-02f, -1.91639900e-01f, 1.65682263e-03f, 1.72176272e-01f,
  -2.02986509e-01f, 1.21425249e-01f, -1.45289563e-02f, 1.85758173e-01f, -2.57201731e-01f, -1.54372111e-01f, 1.76970229e-01f, -1.40309617e-01f, 1.79925948e-01f, -2.16719612e-01f,
  -2.06823736e-01f, 1.45704508e-01f, -3.39887410e-01f, 1.57600790e-01f, 2.78278857e-01f, 7.65393004e-02f, 1.23526994e-02f, -1.14667401e-01f, 4.65644486e-02f, -1.17114201e-01f,
  1.09127842e-01f, -9.63808969e-02f, -1.67346805e-01f, -1.39228761e-01f, -2.80790273e-02f, 1.23365268e-01f, 5.63981086e-02f, -5.46356812e-02f, 8.84313360e-02f, 2.40523502e-01f,
  1.11167178e-01f, 9.34368670e-02f, -4.13464494e-02f, 2.25505754e-01f, 1.57973900e-01f, -2.06241496e-02f, 2.18010560e-01f, -2.45429724e-01f, 1.19595096e-01f, -3.74150984e-02f,
  -2.46861920e-01f, 2.05334444e-02f, 2.14546993e-01f, -1.17656231e-01f, -1.22942127e-01f, -1.53373569e-01f, -2.53231794e-01f, -3.82581772e-03f, -6.26144111e-02f, -2.10869133e-01f,
  2.75429755e-01f, -1.56061009e-01f, -1.00863345e-01f, 2.37231031e-01f, 4.25497144e-02f, 1.24693565e-01f, -1.24105513e-01f, -2.81408370e-01f, -1.91815481e-01f, -1.52855948e-01f,
  -1.26154535e-02f, 8.92606676e-02f, -1.45422265e-01f, 1.54287741e-02f, -1.61365762e-01f, -7.46733695e-02f, 1.70812130e-01f, 3.24753411e-02f, -4.80895340e-01f, 2.17930600e-01f,
  2.23421082e-01f, 4.65954058e-02f, 3.33149582e-01f, 1.15695015e-01f, -5.14731742e-02f, 3.30012709e-01f, 1.56276990e-02f, 1.09098136e-01f, 2.26872817e-01f, -7.47441277e-02f,
  1.42986014e-01f, -2.70481497e-01f, -3.92957002e-01f, 1.13033332e-01f, 8.14986601e-02f, 6.25723302e-02f, -1.71712726e-01f, -2.45066926e-01f
};

// L2_fan_Wp_bar (Shape: 14 x 32)
const int L2_fan_Wp_bar_rows = 14;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  1.30195059e-02f, 7.46421441e-02f, 6.77731633e-02f, 3.69097233e-01f, 4.86208022e-01f, -1.97741464e-01f, -3.41962785e-01f, 2.52403021e-01f, 3.51337008e-02f, 1.24157712e-01f,
  1.66053679e-02f, -3.56445640e-01f, 2.09249537e-02f, 6.05651498e-01f, -4.84722584e-01f, 4.59363163e-01f, -1.14645548e-01f, 6.05028510e-01f, 4.29179482e-02f, -3.49226087e-01f,
  3.62251043e-01f, 4.06971723e-01f, 2.03340024e-01f, -1.21547401e-01f, -1.43269747e-01f, 5.33072233e-01f, 1.18918799e-01f, 9.37011838e-03f, 3.22841614e-01f, -2.17032045e-01f,
  5.37285268e-01f, 5.96816480e-01f, 2.29737759e-01f, -5.07866383e-01f, 1.63711205e-01f, 2.38132313e-01f, 4.00339127e-01f, -1.71882585e-02f, 4.98581417e-02f, 1.50476843e-01f,
  1.62172988e-01f, 2.56595761e-01f, 4.62328702e-01f, -6.62478030e-01f, -7.55131483e-01f, 3.68095636e-01f, -8.79394934e-02f, 5.91659904e-01f, 3.61411333e-01f, -2.63894379e-01f,
  9.06794518e-03f, 5.00396848e-01f, 5.85882843e-01f, 5.72061598e-01f, 3.83492738e-01f, -3.75986218e-01f, -1.38760149e-01f, 1.79958820e-01f, 2.95026869e-01f, -2.16838330e-01f,
  9.15857434e-01f, 5.72929263e-01f, 2.36332696e-02f, 4.46611971e-01f, -1.89380273e-02f, -4.15458202e-01f, 2.09614441e-01f, -7.29330719e-01f, -4.84453619e-01f, -5.15334070e-01f,
  1.15363017e-01f, -3.10838997e-01f, -8.26301754e-01f, 3.75010699e-01f, -1.30281165e-01f, 5.72054029e-01f, -3.39708596e-01f, -1.42882183e-01f, 4.40067798e-01f, -3.96360517e-01f,
  -5.03890812e-02f, -2.30631918e-01f, 2.27710962e-01f, 4.62057203e-01f, -4.07289565e-01f, 7.32647702e-02f, 3.33087146e-01f, -9.31812376e-02f, -2.48795524e-01f, 2.96457738e-01f,
  2.71917880e-01f, 5.18509187e-02f, 1.79254591e-01f, 1.35512084e-01f, -3.33170071e-02f, -1.61739245e-01f, 1.11163221e-01f, 2.39675179e-01f, 1.08882740e-01f, 2.82900333e-01f,
  1.47455737e-01f, -1.62086487e-01f, 5.08002145e-03f, -4.21966612e-02f, 2.03184053e-01f, -1.93471491e-01f, -4.32678670e-01f, -3.21664333e-01f, 4.67329770e-01f, 2.67753631e-01f,
  -6.24676406e-01f, 5.21921098e-01f, -4.51637805e-01f, 6.53730571e-01f, -5.10436714e-01f, 3.20497364e-01f, 7.89642394e-01f, 2.16690123e-01f, 3.49014066e-02f, 5.54230630e-01f,
  7.79290438e-01f, 7.22897828e-01f, -2.18649767e-02f, 4.06682700e-01f, -4.50183935e-02f, -1.47168204e-01f, -2.63666183e-01f, -1.70754194e-02f, 4.70793188e-01f, 7.06096172e-01f,
  1.63470268e-01f, 1.88717209e-02f, 2.95319378e-01f, -2.31596418e-02f, -2.69494116e-01f, 3.34803104e-01f, -6.52928138e-03f, -4.83726822e-02f, -3.90079737e-01f, 9.80057001e-01f,
  9.09555078e-01f, -4.61237997e-01f, 6.89053833e-01f, -9.18372691e-01f, 4.85488027e-01f, -2.60396451e-01f, 5.09864926e-01f, 2.31160820e-02f, 1.05003119e-01f, -3.94414335e-01f,
  8.38943049e-02f, 6.29332125e-01f, -3.14281397e-02f, 4.36808974e-01f, 1.35590509e-01f, 8.90659466e-02f, 9.44852158e-02f, -3.50157261e-01f, 6.18429422e-01f, -5.19293174e-02f,
  -3.32946718e-01f, 1.52945310e-01f, -1.09122984e-01f, 1.50404483e-01f, 2.20178500e-01f, -2.57375300e-01f, -1.56132042e-01f, -2.63946652e-01f, -1.33536294e-01f, 1.03738412e-01f,
  9.89873782e-02f, -4.04961467e-01f, 1.24507099e-01f, 1.14897639e-01f, -3.07437092e-01f, 2.53911972e-01f, -6.15417957e-01f, 5.65776467e-01f, 3.42320740e-01f, -2.11436767e-02f,
  4.03552920e-01f, 4.72832620e-01f, 2.75912341e-02f, -3.87242794e-01f, -4.44902867e-01f, 4.03137177e-01f, 6.50284886e-02f, 4.30477411e-01f, 2.16517761e-01f, -2.24998593e-01f,
  3.94658089e-01f, 7.18153596e-01f, 1.68900296e-01f, 4.28445995e-01f, 2.63885915e-01f, 2.99236029e-01f, -2.64245033e-01f, 5.32666266e-01f, 4.84206051e-01f, 2.93244645e-02f,
  3.13881189e-01f, 2.32537553e-01f, 4.58262533e-01f, 6.42992780e-02f, 3.12447902e-02f, -7.13987947e-01f, 4.20885265e-01f, -5.10960259e-02f, -1.87712386e-01f, -3.83076742e-02f,
  3.50585103e-01f, 4.00178045e-01f, -5.01052916e-01f, -2.34902337e-01f, 3.42798829e-01f, 5.78149378e-01f, 6.09740138e-01f, -3.12593281e-01f, 3.74346197e-01f, 6.68174803e-01f,
  -4.53034103e-01f, 2.96995133e-01f, 1.14289811e-03f, -1.60313785e-01f, 1.93973333e-01f, -1.65856406e-02f, 4.72494245e-01f, 2.11365834e-01f, 2.86043584e-01f, 1.84205145e-01f,
  1.23405978e-01f, 2.76584744e-01f, 3.41933548e-01f, 6.88471124e-02f, -2.05963269e-01f, 5.05275011e-01f, 6.34479225e-02f, -3.47152144e-01f, 5.21552302e-02f, -1.34706557e-01f,
  6.51336908e-01f, -4.69114602e-01f, -2.71567196e-01f, 3.31875563e-01f, 1.81825861e-01f, 1.06156856e-01f, 2.38374457e-01f, 4.58904773e-01f, 5.61755478e-01f, 2.08738044e-01f,
  2.32285470e-01f, -8.47694427e-02f, 2.79915750e-01f, 3.64695966e-01f, -2.07497343e-01f, -2.66907245e-01f, 3.42403442e-01f, 1.34840176e-01f, 3.34830657e-02f, -7.54765943e-02f,
  1.69509307e-01f, 3.42223495e-01f, 2.33822003e-01f, 2.03143582e-01f, 2.80063957e-01f, -4.77398008e-01f, 7.65590817e-02f, 1.96342587e-01f, -2.25576848e-01f, 1.72765404e-01f,
  4.15171862e-01f, -1.72855645e-01f, 8.24002743e-01f, -7.13664651e-01f, -2.47871801e-01f, 4.87562567e-01f, 4.59623724e-01f, 4.59040612e-01f, 1.38609409e-01f, 4.46897626e-01f,
  -2.85465494e-02f, 2.73178965e-01f, 5.14544621e-02f, -3.90540540e-01f, 3.18242729e-01f, 1.83812454e-01f, -1.61556061e-02f, -5.94476238e-03f, 1.39362469e-01f, 2.82667037e-02f,
  -3.10341213e-02f, -5.01305871e-02f, -2.10705306e-02f, -4.36506085e-02f, -3.31310630e-01f, -2.53306985e-01f, -1.96662322e-01f, -2.60724187e-01f, 4.15296704e-01f, 4.31335479e-01f,
  -1.02950491e-01f, -1.57715201e-01f, 2.20140368e-01f, -6.45532489e-01f, -8.58543292e-02f, 5.11042029e-02f, 6.16550028e-01f, 2.32590988e-01f, -1.08702488e-01f, -9.07375291e-02f,
  3.93906802e-01f, 2.21048340e-01f, -1.93116218e-01f, 9.08197984e-02f, 5.15798330e-02f, 6.85066760e-01f, -2.62540251e-01f, -1.52052492e-01f, 2.30068728e-01f, 3.91564846e-01f,
  -9.12486017e-02f, 1.68553054e-01f, 2.81492114e-01f, 1.59291085e-02f, 3.11783645e-02f, 2.64884651e-01f, 3.28198910e-01f, 4.81668003e-02f, 2.57600434e-02f, 7.48822212e-01f,
  -3.60331684e-01f, 1.57641008e-01f, -3.83542851e-02f, -2.88307071e-01f, 5.63133776e-01f, 4.14171666e-02f, -2.52309144e-01f, 2.30467901e-01f, 3.41093957e-01f, -2.40958050e-01f,
  -3.34266573e-01f, -1.52159020e-01f, 2.40350440e-01f, -3.22973371e-01f, 2.59810567e-01f, 1.15793850e-02f, 7.09409952e-01f, 1.45914823e-01f, 4.86186028e-01f, 8.00422311e-01f,
  5.58190525e-01f, 7.05586970e-02f, -1.33479908e-01f, 9.69266705e-03f, -2.74596453e-01f, 1.47869080e-01f, 1.26071692e-01f, -3.00968885e-01f, -1.88282728e-01f, -8.11807215e-02f,
  1.10817631e-03f, -4.20425802e-01f, -8.22682306e-03f, 5.31607270e-01f, -4.86503869e-01f, -3.55017096e-01f, 5.14287055e-01f, -6.42906129e-01f, 4.44923043e-01f, 4.05159546e-03f,
  -9.58996341e-02f, 5.05464494e-01f, -4.22244519e-01f, -1.41016647e-01f, 6.33393407e-01f, 1.93042770e-01f, 1.51570350e-01f, 4.78018850e-01f, -1.68470535e-02f, 5.00224173e-01f,
  -7.45997950e-02f, -2.53940135e-01f, 1.04167107e-02f, 2.30527937e-01f, -3.50442886e-01f, 1.53019667e-01f, 1.94101989e-01f, -3.89033780e-02f, -4.10350114e-01f, 2.54885316e-01f,
  -1.81090971e-03f, 4.65806127e-02f, -5.07700704e-02f, 4.68231082e-01f, -8.94934386e-02f, -3.95865142e-01f, 3.38585109e-01f, -3.55815776e-02f, -5.35898089e-01f, 6.34674966e-01f,
  -8.22798848e-01f, 6.20797813e-01f, 5.16613543e-01f, -2.09583923e-01f, 1.06358498e-01f, -2.83358563e-02f, -4.01661634e-01f, -5.57980873e-02f, -4.78000566e-02f, -2.38458607e-02f,
  4.48712379e-01f, 4.46682692e-01f, -2.84734309e-01f, 2.92963445e-01f, 1.53783262e-01f, 2.97301054e-01f, -8.69447589e-02f, -3.20386708e-01f, -5.89189678e-02f, 6.12459242e-01f,
  -3.28016996e-01f, 1.37474224e-01f, 3.81895244e-01f, -3.03990304e-01f, 6.22345954e-02f, 1.84353665e-01f, 3.93067926e-01f, -6.68205082e-01f, -6.45791471e-01f, -7.60968506e-01f,
  -5.44958353e-01f, 5.75263798e-01f, -1.45729721e-01f, -1.36115849e-01f, 2.92584188e-02f, 1.22255534e-01f, -6.14244640e-01f, 4.76397946e-02f, 1.46502241e-01f, -2.24793598e-01f,
  -2.25760326e-01f, -2.07839310e-01f, 2.82578319e-01f, 3.38144392e-01f, -1.93464458e-01f, 6.06677309e-02f, 1.25010870e-02f, 1.22832336e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 14)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 14;
const float L2_fan_Bp_bar_data[] = {
  -9.48429257e-02f, 1.61384463e-01f, -1.80032924e-01f, -1.59332156e-01f, 3.78065646e-01f, 8.91839042e-02f, 1.30615667e-01f, 2.46203810e-01f, 2.80934244e-01f, 1.38265774e-01f,
  1.31058171e-01f, 8.32761675e-02f, -3.58215794e-02f, 1.21507451e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.29655004e-01f, -1.82162687e-01f, 5.06604277e-03f, -2.16068372e-01f, 1.95326477e-01f, -2.62958825e-01f, 1.38835516e-02f, 2.72453755e-01f, 1.13088459e-01f, 1.47468567e-01f,
  -3.73377979e-01f, 1.48680508e-01f, -3.77894104e-01f, 4.94991690e-02f, -2.71847308e-01f, -2.98430622e-01f, 3.70572835e-01f, -2.34310195e-01f, 3.23303521e-01f, 4.82198328e-01f,
  -4.93914515e-01f, -5.87234855e-01f, -5.00949919e-01f, 2.46483490e-01f, -6.73410833e-01f, -2.82741219e-01f, 1.43629564e-02f, -2.98544526e-01f, 1.68626651e-01f, -4.73387241e-01f,
  1.20550819e-01f, -3.71204555e-01f, -9.69818532e-02f, -1.25032082e-01f, 1.55301347e-01f, -3.99262637e-01f, 6.12102486e-02f, 2.97729403e-01f, -3.16023499e-01f, -9.71837435e-03f,
  -2.56290376e-01f, -3.61523807e-01f, 2.67286092e-01f, -9.95955914e-02f, -1.81144357e-01f, -3.60138893e-01f, -1.09303579e-01f, -1.95418850e-01f, -3.15635353e-02f, -1.53420746e-01f,
  -1.49191264e-02f, 3.31708603e-02f, -4.09784853e-01f, -2.96531111e-01f, -6.86456442e-01f, 3.32111359e-01f, 3.29254419e-01f, -6.03459477e-01f, -4.89189208e-01f, 1.86238870e-01f,
  2.30935123e-02f, -2.14313045e-01f, 4.19270575e-01f, 5.88685930e-01f, -4.42164153e-01f, -3.02583039e-01f, 2.42169961e-01f, 3.36979628e-01f, -9.55270827e-02f, -3.74411754e-02f,
  -2.98615366e-01f, -9.59844291e-02f, -1.56758711e-01f, -2.11069331e-01f, -1.39936253e-01f, -3.56625944e-01f, 1.92502484e-01f, 3.90897512e-01f, 4.54185158e-01f, -1.00277394e-01f,
  2.56285012e-01f, 1.18940063e-01f, -1.44815788e-01f, -6.33837342e-01f, 4.43446606e-01f, -6.40913844e-01f, 2.86519259e-01f, 2.77697265e-01f, -7.55535066e-02f, -7.69871533e-01f,
  -6.97936356e-01f, 2.72831917e-01f, 1.96414933e-01f, -4.11814414e-02f, 2.86478966e-01f, -5.38655221e-01f, -1.50303736e-01f, -1.76078483e-01f, 3.48257452e-01f, -3.32476586e-01f,
  -3.47190201e-01f, -9.18211490e-02f, 1.73770189e-01f, -2.67693669e-01f, 2.24915192e-01f, 2.51793832e-01f, 2.06623077e-01f, -1.72302693e-01f, -1.59974545e-01f, 3.88852209e-01f,
  -2.74660081e-01f, -1.61456227e-01f, -6.24982901e-02f, 4.40270156e-01f, 7.61000216e-02f, 3.81793410e-01f, -3.99538457e-01f, 2.35564038e-01f, -7.07542956e-01f, 7.90790915e-02f,
  -7.02825785e-01f, 1.41758412e-01f, 4.27422613e-01f, -3.75917852e-01f, -1.01903725e+00f, -2.65614122e-01f, -5.23667455e-01f, -4.33618367e-01f, 2.35968307e-01f, 3.86366665e-01f,
  -3.32900345e-01f, 2.16878012e-01f, 2.04804495e-01f, 2.69767642e-01f, 3.26497734e-01f, 3.10266584e-01f, -3.24966870e-02f, 4.36117291e-01f, 6.16696060e-01f, 1.63944304e-01f,
  3.00544441e-01f, -4.69069093e-01f, -1.25899673e-01f, 1.01421624e-01f, -7.41762519e-01f, -1.04781732e-01f, -1.10715725e-01f, 5.08480035e-02f, -4.90388453e-01f, 4.33108926e-01f,
  5.27667813e-02f, -3.14344406e-01f, -1.50888994e-01f, 3.49975258e-01f, 2.74945855e-01f, -7.74428844e-01f, 7.77359307e-02f, -2.23975137e-01f, -3.54855448e-01f, -2.17560574e-01f,
  1.97537839e-01f, -1.02934660e-02f, -6.51620179e-02f, 8.23115557e-02f, 1.00279860e-01f, 2.79558688e-01f, 7.87804946e-02f, 3.57370943e-01f, 3.65614057e-01f, 4.96187180e-01f,
  -4.03948963e-01f, 1.26991495e-01f, -1.44389629e-01f, 4.00319174e-02f, -3.35418284e-01f, 4.73914474e-01f, 1.50184229e-01f, 5.49431801e-01f, -7.63762891e-01f, 3.52987081e-01f,
  2.07292125e-01f, -7.00333118e-01f, -5.87218821e-01f, -5.55047870e-01f, 4.02809292e-01f, 1.77748829e-01f, -1.47447720e-01f, -9.72706918e-03f, 3.14638048e-01f, -9.23787877e-02f,
  -2.03789458e-01f, 1.20425649e-01f, 3.74621958e-01f, 1.88305095e-01f, 4.78541434e-01f, 9.45276755e-04f, 3.20010394e-01f, 2.59557486e-01f, 2.20069468e-01f, 2.42013931e-01f,
  1.63928360e-01f, -3.71049643e-01f, -1.54867321e-01f, 2.37456888e-01f, 4.84790146e-01f, -2.70069301e-01f, 3.96786898e-01f, 1.32581294e-02f, 5.26302755e-01f, -6.00219011e-01f,
  -4.00943428e-01f, -5.28064609e-01f, -5.51622689e-01f, -6.86213374e-01f, 6.41683042e-01f, -3.52335393e-01f, 3.03924561e-01f, 8.74000639e-02f, 2.14294896e-01f, 2.97414839e-01f,
  -2.02491358e-01f, 5.67370206e-02f, -3.92257750e-01f, -2.22215325e-01f, -1.21125236e-01f, -1.45334512e-01f, -2.83100814e-01f, 3.74384709e-02f, -3.42001766e-01f, -3.04258347e-01f,
  -4.29240346e-01f, -2.02672243e-01f, 8.15567747e-02f, -1.30170688e-01f, 1.73738018e-01f, -6.16515219e-01f, -1.47325128e-01f, -2.77568609e-01f, 3.43513429e-01f, 1.03819221e-01f,
  -2.59306520e-01f, 4.02259380e-01f, -5.73053837e-01f, 2.59796202e-01f, 5.41242123e-01f, -2.65145034e-01f, -1.19304463e-01f, -2.12269768e-01f, -2.96974599e-01f, 1.60706285e-02f,
  3.66523981e-01f, 1.84500977e-01f, -3.26460779e-01f, 2.28254363e-01f, -2.72108912e-01f, -2.96858549e-01f, 4.51559052e-02f, 7.52632022e-02f, 4.10604030e-02f, -2.05924109e-01f,
  -6.24460205e-02f, -1.90608636e-01f, 2.75518507e-01f, -1.31299198e-01f, -4.12623547e-02f, 3.02101880e-01f, 2.41677031e-01f, -5.08484304e-01f, -5.33676147e-02f, 4.42448407e-01f,
  1.37598515e-01f, 2.56753206e-01f, -3.37806821e-01f, -1.92501366e-01f, 3.18175673e-01f, -2.28534471e-02f, 3.87216732e-02f, -7.02441186e-02f, 1.66962966e-01f, 1.96692467e-01f,
  -4.82379764e-01f, -8.53677541e-02f, -5.44259906e-01f, 1.72224164e-01f, 6.76425025e-02f, 2.92241484e-01f, -3.95828485e-01f, -9.35526863e-02f, -9.14389342e-02f, -2.08376706e-01f,
  -3.92707080e-01f, 2.68790066e-01f, 8.07288513e-02f, 7.50605389e-02f, 1.85702682e-01f, -3.32364440e-01f, -2.54288405e-01f, -4.27612096e-01f, -3.13259602e-01f, 3.16652842e-02f,
  2.88835227e-01f, 5.00606894e-01f, -4.40004736e-01f, -3.26447755e-01f, 3.16832185e-01f, -2.20956206e-01f, -3.76565486e-01f, -5.66676855e-01f, -3.68092716e-01f, 4.62809086e-01f,
  -1.82235584e-01f, -3.45461369e-01f, 3.57105553e-01f, 1.85996801e-01f, -5.16905725e-01f, -3.04506481e-01f, 2.08973348e-01f, -6.15477026e-01f, 4.82253134e-01f, -1.56568393e-01f,
  9.92218405e-02f, 3.01477253e-01f, -1.36586756e-01f, -7.77797848e-02f, -4.15301561e-01f, 1.35820165e-01f, -3.51134300e-01f, -8.21758062e-02f, -2.84487993e-01f, 1.76853444e-02f,
  -7.34746084e-02f, 1.20233864e-01f, -2.12633431e-01f, -2.40994066e-01f, -3.72173190e-01f, -9.70502198e-02f, -4.84768480e-01f, -2.72153258e-01f, 3.83944958e-01f, 6.14680275e-02f,
  -7.34835207e-01f, 5.18501282e-01f, -9.77042466e-02f, 3.88827413e-01f, -5.80920756e-01f, -4.52890217e-01f, -3.83839369e-01f, 2.43396968e-01f, -5.09101748e-01f, -3.88750404e-01f,
  3.46785277e-01f, -6.54234469e-01f, -1.05701596e-01f, -3.24704826e-01f, 1.38126150e-01f, 7.36558810e-02f, -1.90611020e-01f, -3.56397361e-01f, 7.37854913e-02f, -3.74001265e-01f,
  -9.29815471e-02f, 3.38991284e-01f, 3.35974723e-01f, 3.29654843e-01f, 3.28809619e-01f, -2.32881501e-01f, 3.58529210e-01f, 4.02738065e-01f, -1.95373490e-01f, 5.45767486e-01f,
  -3.29254150e-01f, -4.72175419e-01f, -4.47719038e-01f, 5.01610398e-01f, -9.87557918e-02f, -1.45766854e-01f, 2.69080848e-01f, -2.64630746e-02f, 4.78938222e-03f, 2.57116675e-01f,
  -7.80263543e-01f, 5.26937127e-01f, -3.54017943e-01f, -6.97838366e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.35860920e-01f, -2.14059845e-01f, -1.71769932e-02f, 3.47223170e-02f, 1.75767392e-01f, 2.19448179e-01f, 1.17829219e-01f, -1.17516898e-01f, -2.01182336e-01f, -2.11884324e-02f,
  1.21786920e-02f, -1.96638793e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 9, 14
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 9, 14
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    