/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.65286106e-01f, 2.53164023e-01f, -1.27293468e-02f, 2.03655362e-02f, 6.12677522e-02f, -5.49449325e-02f, 7.92734772e-02f, -1.72734484e-02f, -5.96477985e-02f, 1.20331049e-01f,
  1.38954282e-01f, 3.93747948e-02f, 4.02960591e-02f, 2.50461791e-02f, -2.62539566e-01f, 1.10590331e-01f, -4.21067290e-02f, -1.97735295e-01f, -2.16508076e-01f, -1.79560944e-01f,
  -9.24970657e-02f, -2.48857051e-01f, -2.69492507e-01f, -1.94179296e-01f, 2.79175520e-01f, 1.80648163e-01f, 1.66441664e-01f, 7.54172429e-02f, 8.36943313e-02f, 3.08819622e-01f,
  2.87384331e-01f, 1.05521999e-01f, -1.03397444e-01f, -8.71222094e-02f, 1.11649200e-01f, -8.42869878e-02f, 7.13505372e-02f, -4.46962379e-02f, -1.35296220e-02f, 2.44684294e-02f,
  3.30304503e-02f, -9.46412161e-02f, 5.63908666e-02f, -1.77696254e-02f, -1.19512184e-02f, -7.68231079e-02f, -7.08973035e-02f, -1.51979983e-01f, -1.12949573e-01f, 1.29347816e-01f,
  7.79428855e-02f, -6.26632273e-02f, -2.83494182e-02f, 2.58491300e-02f, 4.18824255e-02f, -9.59259421e-02f, 8.57304484e-02f, 3.82849835e-02f, -9.83797014e-02f, 8.29390362e-02f,
  -8.07230324e-02f, 2.10040063e-02f, -5.53721637e-02f, -1.97518840e-02f, 1.21843023e-02f, -2.80382601e-03f, 4.71020341e-02f, -5.47137447e-02f, 3.79009284e-02f, -8.93950183e-03f,
  -5.32663369e-04f, 2.89936643e-02f, -4.72901911e-02f, 1.37949288e-02f, 6.21760823e-02f, -3.63379344e-02f, -1.42789586e-02f, 2.04570591e-02f, -2.83324663e-02f, -1.42153064e-02f,
  1.83154154e-03f, 1.59884784e-02f, 1.90851279e-02f, 6.75332844e-02f, 8.29384848e-03f, -1.38185406e-02f, -6.38265386e-02f, 5.98633438e-02f, -3.40376496e-02f, 5.43569885e-02f,
  4.26733233e-02f, -2.07919821e-01f, 1.00399539e-01f, -4.11173850e-02f, -7.06005171e-02f, 3.26218009e-02f, 4.28636670e-02f, -8.52213055e-03f, 4.68408503e-02f, -5.22441529e-02f,
  -9.29920450e-02f, -6.90488610e-03f, 2.59719044e-03f, -6.94473013e-02f, -1.09667741e-01f, -8.18209350e-02f, -1.50863603e-01f, -2.64409166e-02f, 3.47013026e-02f, -9.04866960e-03f,
  -2.81468313e-02f, -1.91026345e-01f, -1.32050529e-01f, -1.32206017e-02f, 2.68897247e-02f, -1.44641459e-01f, 1.05152093e-01f, 1.51174786e-02f, -1.88309759e-01f, -1.27534389e-01f,
  1.54446840e-01f, -1.25235617e-01f, -2.82730639e-01f, -4.22335416e-02f, 1.14211887e-02f, 9.79944505e-03f, 3.23324539e-02f, 1.50650352e-01f, 7.46630952e-02f, -1.04841311e-02f,
  2.48817042e-01f, 2.06045777e-01f, 1.57198891e-01f, 4.50897440e-02f, 5.24722785e-02f, -1.72488719e-01f, -3.29190791e-01f, -2.15036854e-01f, 8.74916762e-02f, 2.00878978e-01f,
  5.08829653e-02f, -3.04920133e-02f, -6.42818958e-02f, -4.77344431e-02f, -1.78726897e-01f, -9.63880867e-02f, -1.50784791e-01f, -1.56044081e-01f, -1.46524817e-01f, -5.85449874e-01f,
  3.79147683e-03f, -9.91289467e-02f, 7.22564980e-02f, 6.11833930e-02f, 1.42492326e-02f, -6.18392602e-02f, 6.61876053e-02f, -1.51130548e-02f, 5.30932583e-02f, -3.13145220e-02f,
  2.94827092e-02f, -3.73993441e-02f, -1.98778734e-02f, -6.66355714e-02f, 7.76813924e-03f, 4.16542925e-02f, 4.50083427e-03f, -1.60103425e-01f, 1.93450153e-02f, 1.21532463e-01f,
  -1.07909832e-02f, -1.18152939e-01f, -7.06980154e-02f, 4.23196778e-02f, -9.65347216e-02f, 1.40140234e-02f, -7.95829073e-02f, -2.85294037e-02f, 6.07960448e-02f, -1.61650449e-01f,
  3.93205276e-03f, -6.55357242e-02f, -5.36632612e-02f, -9.52611677e-03f, 4.64904197e-02f, -4.03288044e-02f, -1.16833687e-01f, 4.49925065e-02f, -3.73197068e-03f, -4.90185767e-02f,
  -5.04109263e-02f, 2.25429293e-02f, -1.10958600e-02f, -3.62436753e-03f, 2.15360173e-03f, -1.02610618e-01f, -4.04176209e-03f, 2.60712374e-02f, -8.39909911e-03f, -2.17009131e-02f,
  3.17618065e-02f, -3.66544314e-02f, 6.99370680e-03f, -2.93221809e-02f, -2.83920276e-03f, -6.97118342e-02f, -2.89507620e-02f, 4.30557914e-02f, 9.11930948e-02f, 1.04551613e-02f,
  4.38889742e-01f, 2.40123887e-02f, 4.86414693e-02f, 4.08098586e-02f, -3.52030471e-02f, 1.32879820e-02f, 1.86611840e-03f, -3.19925472e-02f, -6.23029768e-02f, 6.29555658e-02f,
  5.46649098e-02f, 7.27026984e-02f, 8.56725052e-02f, -6.61390126e-02f, 3.94237675e-02f, 1.95007138e-02f, 3.93930674e-02f, 1.31722409e-02f, 3.14913578e-02f, 9.49467719e-03f,
  7.67041668e-02f, 6.84946403e-02f, 1.54853269e-01f, 1.19572416e-01f, 2.17153654e-02f, 1.85628653e-01f, 1.30439863e-01f, 1.18897282e-01f, 1.80823982e-01f, 2.16367379e-01f,
  -2.84022450e-01f, 3.07871718e-02f, -1.90346301e-01f, -1.63604558e-01f, -1.29075781e-01f, 1.63727343e-01f, 3.97650212e-01f, 2.09865630e-01f, -4.77431267e-02f, -7.77929053e-02f,
  -1.26686454e-01f, -2.13909820e-01f, -2.50867754e-01f, 1.57079510e-02f, 1.68632612e-01f, 2.67112732e-01f, 9.16837007e-02f, 1.05810650e-01f, 6.03349730e-02f, 2.39679828e-01f,
  1.90725833e-01f, 6.03620857e-02f, -4.18492518e-02f, 2.60689389e-02f, -8.82361010e-02f, -7.68148899e-02f, -1.60370186e-01f, -1.53836310e-01f, 8.80177245e-02f, 7.98194110e-02f,
  -3.39507937e-01f, -2.81931072e-01f, 7.66731352e-02f, -3.15309651e-02f, -6.56449050e-02f, 9.84325074e-03f, 9.47749019e-02f, -8.33981633e-02f, 7.41728232e-04f, 6.87519610e-02f,
  -1.89760238e-01f, -4.44770744e-03f, -9.39920917e-02f, 4.98803928e-02f, 3.49675044e-02f, -4.71313372e-02f, 4.87606414e-02f, 4.32838500e-02f, -3.49043682e-02f, -8.33103582e-02f,
  1.65430401e-02f, -8.18532482e-02f, -1.41494334e-01f, 7.66389146e-02f, 8.50378647e-02f, -1.01795733e-01f, -9.81786251e-02f, 3.00165918e-02f, -6.60181195e-02f, -2.09627394e-02f,
  1.13506511e-01f, -4.74555679e-02f, -1.83927175e-02f, -5.11138188e-03f, 4.28067297e-02f, -6.63729571e-03f, -9.35550837e-04f, -3.89385708e-02f, 6.42090663e-02f, -2.46439166e-02f,
  -9.77670308e-03f, 6.12145849e-03f, 5.26679272e-04f, 5.21449372e-03f, -2.93140896e-02f, -1.71339065e-02f, 5.03996499e-02f, 6.69968873e-03f, -6.37315810e-02f, 2.41204407e-02f,
  -1.47415893e-02f, -7.02612009e-03f, -7.83793032e-02f, 2.62203310e-02f, 3.38754281e-02f, -3.59518267e-02f, 1.81193426e-02f, 4.03905548e-02f, 1.38037521e-02f, -4.34638821e-02f,
  2.34658383e-02f, 2.00495087e-02f, 1.50956577e-02f, 4.55590710e-02f, -9.72101986e-02f, 3.56621556e-02f, -1.51030600e-01f, 5.39245792e-02f, -1.18245043e-01f, -4.27535623e-02f,
  -3.08603011e-02f, 2.76569743e-02f, -7.60124400e-02f, -1.98965538e-02f, 4.97586131e-02f, 6.44623861e-02f, 2.31879926e-03f, -4.21072431e-02f, 9.04245079e-02f, 3.96093242e-02f,
  9.78913158e-02f, 1.22064896e-01f, -2.70188246e-02f, 5.85954450e-02f, -1.09052481e-02f, -5.01929559e-02f, 5.61106578e-02f, 4.35359403e-02f, 6.69420660e-02f, 3.13696146e-01f,
  4.37620431e-01f, -2.42170945e-01f, -2.17808828e-01f, -1.68283693e-02f, 1.10562913e-01f, 2.92513520e-01f, 3.57227117e-01f, 3.61642003e-01f, 6.29861802e-02f, -3.13266478e-02f,
  -2.96407510e-02f, -1.16207734e-01f, -2.17911646e-01f, -6.60869032e-02f, 1.90483153e-01f, -1.43115506e-01f, -2.98747271e-01f, -1.62799284e-01f, 2.04259709e-01f, 2.97589898e-01f,
  -8.16120207e-02f, -5.90775982e-02f, 4.53752168e-02f, 5.47984503e-02f, -2.82277375e-01f, -1.58560276e-01f, -1.87757194e-01f, -9.00649428e-02f, -1.20150872e-01f, -5.92367470e-01f,
  -2.91127086e-01f, 1.35008827e-01f, 8.01690072e-02f, -2.33139358e-02f, -1.28814369e-01f, 2.19966453e-02f, -1.82127673e-02f, -2.07010936e-02f, 4.40269858e-02f, -1.23763710e-01f,
  -2.86533292e-02f, 2.06834823e-02f, -3.54067944e-02f, 2.38062274e-02f, 5.22797648e-03f, 2.36506127e-02f, -3.18847708e-02f, 5.69659919e-02f, 2.91151591e-02f, -2.03790423e-02f,
  -9.53513235e-02f, -3.85312848e-02f, 8.92718062e-02f, 1.55352920e-01f, 1.82174504e-01f, -3.14629376e-02f, 3.74465883e-02f, 1.56807140e-01f, 1.60222858e-01f, -8.11795592e-02f,
  -1.59299690e-02f, 1.78330429e-02f, 5.54153435e-02f, -2.12236531e-02f, 1.94642600e-02f, 2.19643582e-02f, -7.10309902e-03f, -1.06034204e-02f, 3.76938134e-02f, -5.35031036e-02f,
  1.26659128e-04f, 1.55004263e-02f, -1.40818367e-02f, 2.02397685e-02f, -5.99475987e-02f, -4.37152162e-02f, 3.64120975e-02f, 1.61252879e-02f, -7.23455474e-02f, 3.58815640e-02f,
  -4.52078991e-02f, 5.69435954e-02f, -8.16039667e-02f, 1.75401159e-02f, -1.43449381e-02f, 1.32783642e-02f, -4.18029279e-02f, 5.65333739e-02f, -2.29394389e-03f, 4.85541858e-03f,
  -4.65764217e-02f, 7.06062019e-02f, -1.59336716e-01f, 4.46507409e-02f, 4.20609536e-03f, -2.40355749e-02f, -5.26297577e-02f, -2.70989761e-02f, -8.11154768e-02f, 4.67044599e-02f,
  1.30210131e-01f, 2.25237329e-02f, -8.08381662e-02f, 2.20177490e-02f, 2.58713756e-02f, 5.51193804e-02f, -1.10924123e-02f, -9.53607634e-02f, 4.36392091e-02f, -3.06924693e-02f,
  -1.07796021e-01f, 1.31393582e-01f, 5.14238253e-02f, -5.94089814e-02f, 9.98224542e-02f, -3.71490046e-02f, -9.67672318e-02f, -1.77139789e-02f, 1.78038105e-01f, -8.74945000e-02f,
  4.51653033e-01f, 2.07609683e-01f, 2.02211231e-01f, 4.51622367e-01f, 3.57676059e-01f, 2.98775256e-01f, 2.87527084e-01f, 1.28634214e-01f, 8.22820216e-02f, 1.55783087e-01f,
  -1.05402302e-02f, -2.51858868e-02f, -7.18448237e-02f, -6.66355789e-02f, -1.84863862e-02f, 2.45326638e-01f, 2.73067355e-01f, 6.54993653e-02f, 4.39882092e-02f, 4.30996269e-02f,
  1.60678715e-01f, 2.05632478e-01f, 5.83240502e-02f, -8.48096237e-02f, 9.56759229e-02f, -4.96852137e-02f, 6.52071536e-02f, 1.28399163e-01f, -7.29608610e-02f, 1.05136156e-01f,
  3.90118919e-02f, 2.01006025e-01f, -5.25119901e-02f, -6.76822243e-03f, -4.23423247e-03f, -7.55670527e-03f, 5.00787087e-02f, -2.71860193e-02f, -3.23506929e-02f, 6.61030039e-02f,
  -1.27182354e-03f, -3.09462789e-02f, 1.73929129e-02f, -8.30848329e-03f, 1.18150443e-01f, 9.43451598e-02f, -5.72446687e-03f, -2.24390645e-02f, -1.72482748e-02f, -6.06503598e-02f,
  4.08122921e-03f, 1.50175273e-01f, -7.08292052e-02f, -3.28804962e-02f, 8.23987927e-03f, -4.49592955e-02f, -8.89902934e-02f, -1.00578032e-02f, 3.72160710e-02f, -3.00825248e-03f,
  -1.14532672e-02f, -5.69065101e-02f, -9.81238112e-03f, -1.50364190e-02f, -3.33822821e-03f, -3.58457156e-02f, -1.57912374e-02f, 4.63848710e-02f, -7.57434815e-02f, -2.90156659e-02f,
  -5.71335573e-03f, -1.25282072e-02f, -1.37399817e-02f, 2.17963140e-02f, 5.38329929e-02f, -1.20405722e-02f, -1.56621933e-02f, -2.70403619e-03f, -3.48657332e-02f, 2.23539863e-02f,
  3.80355567e-02f, -9.46114808e-02f, 5.51012568e-02f, -5.08679822e-02f, 5.38387895e-02f, 2.52133496e-02f, 3.62706780e-02f, -5.60113080e-02f, 3.29510346e-02f, 3.15105021e-02f,
  -2.20288709e-02f, -7.55119398e-02f, 1.78235816e-03f, -1.33288383e-01f, 1.04979880e-01f, -1.13397323e-01f, 4.26093861e-03f, -1.22872099e-01f, -3.02874744e-02f, -2.06643883e-02f,
  -3.01234350e-02f, 2.42759660e-02f, 5.79559989e-02f, 5.52266138e-03f, 6.08657338e-02f, -9.82543919e-03f, 5.83977774e-02f, 1.22984014e-01f, -5.27824052e-02f, -8.31735805e-02f,
  1.41857546e-02f, -6.12394884e-02f, -3.62431556e-02f, -1.22657634e-01f, -2.92239394e-02f, -3.04249264e-02f, -1.11241400e-01f, -1.22256681e-01f, -9.90391076e-02f, 9.50101987e-02f,
  -2.63996311e-02f, -2.58923233e-01f, 4.93023723e-01f, -3.61867994e-01f, -8.18605348e-03f, 3.17749560e-01f, 8.21483433e-02f, 8.31784904e-02f, -1.32057101e-01f, -4.88954224e-02f,
  -1.84216827e-01f, -8.61700997e-02f, -1.12331055e-01f, 9.94828492e-02f, 1.39660597e-01f, 6.11255541e-02f, 1.32237330e-01f, 2.68484682e-01f, 3.08438927e-01f, -1.98577251e-02f,
  -2.97599494e-01f, -1.89760298e-01f, -1.52362093e-01f, -1.24139870e-02f, -3.73184860e-01f, -9.55153108e-02f, -8.41678903e-02f, -5.36691956e-02f, -3.31508964e-02f, -3.49200785e-01f,
  3.19273680e-01f, 1.09898329e-01f, 8.51108432e-02f, -1.85933203e-01f, 4.42123897e-02f, 2.92222779e-02f, 3.59731950e-02f, -4.38675247e-02f, -2.74613481e-02f, 5.71643859e-02f,
  -1.30448923e-01f, 2.41056252e-02f, 1.71585418e-02f, 4.71240096e-03f, 2.60600299e-02f, 6.78392053e-02f, -4.63025738e-03f, 1.27246574e-01f, 1.33490533e-01f, 4.84336019e-02f,
  -1.26479506e-01f, -6.04306981e-02f, 1.76335737e-01f, 6.19628504e-02f, 4.48259450e-02f, 4.25341493e-03f, 1.23489410e-01f, -5.00179753e-02f, 2.47123301e-01f, -9.67363343e-02f,
  -1.02489971e-01f, -8.23690149e-04f, 3.35055627e-02f, 6.66243397e-03f, -4.72527258e-02f, 1.24703404e-02f, -1.59066115e-02f, -3.64109725e-02f, 5.08621670e-02f, -1.17855631e-02f,
  -2.23441999e-02f, 7.12954700e-02f, -6.93370253e-02f, -3.67652345e-03f, -1.77763943e-02f, 6.61050482e-03f, -5.51495561e-03f, 3.40920710e-03f, 2.64336541e-02f, 6.40347674e-02f,
  5.86659424e-02f, 2.67706402e-02f, -1.87563244e-02f, -2.32068840e-02f, 1.14337681e-02f, 1.55530265e-02f, 2.64065787e-02f, -1.78199261e-02f, -3.61400582e-02f, 1.20016572e-03f,
  -1.26265690e-01f, 1.67871162e-01f, -3.26714516e-02f, 9.68209654e-02f, -4.20194045e-02f, -7.64686009e-03f, -6.99326023e-02f, 7.54443184e-02f, -4.04768698e-02f, -8.59661121e-03f,
  3.93242016e-02f, 3.92082296e-02f, 3.94178787e-03f, -4.14826013e-02f, 3.83376032e-02f, 2.49341279e-02f, -1.12958446e-01f, 6.19256981e-02f, 1.39097124e-02f, 1.58890747e-02f,
  -6.06566444e-02f, 6.44830763e-02f, 1.27043813e-01f, 3.80182713e-02f, -1.07915856e-01f, 7.42006078e-02f, 6.41179979e-02f, 8.92949253e-02f, 1.70743510e-01f, -1.29968226e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.27025676e-01f, 1.63088635e-01f, -6.48461506e-02f, 1.86148137e-01f, 2.22246021e-01f, 3.42421591e-01f, 2.70054042e-01f, 3.22109580e-01f, 2.49714598e-01f, 2.16224298e-01f,
  1.95910186e-01f, 1.38161466e-01f, 2.16087908e-01f, 2.32518420e-01f, 2.58998245e-01f, 2.20196202e-01f, 7.26595521e-02f, 3.11257131e-02f, -9.29412916e-02f, 5.44063598e-02f,
  1.45697206e-01f, -3.09631117e-02f, -1.44965172e-01f, 2.97806803e-02f, 8.64244848e-02f, 1.32112182e-03f, 8.73635635e-02f, -2.11592317e-02f, 5.90342022e-02f, 4.35362719e-02f,
  -5.50733274e-03f, -1.91941693e-01f, -3.15554813e-02f, 5.65276928e-02f, 4.43462143e-03f, -1.71687618e-01f, -4.27933298e-02f, -2.09202141e-01f, -1.01567172e-01f, -8.96758065e-02f,
  -6.77440269e-03f, -1.06080584e-01f, 7.75570702e-03f, -2.62669530e-02f, 1.08475480e-02f, -1.01183824e-01f, -5.95709123e-02f, -7.76733533e-02f, 1.01097636e-01f, 1.02198549e-01f,
  1.17264085e-01f, -1.22554988e-01f, -1.10553280e-01f, 1.67975836e-02f, 4.84653749e-02f, -2.16935817e-02f, 4.81504053e-02f, 6.93516573e-03f, -3.70810814e-02f, -2.36491524e-02f,
  8.23215544e-02f, -1.16794286e-02f, -2.58757956e-02f, 2.79754326e-02f, 6.73482642e-02f, 3.89245450e-02f, 4.90272138e-03f, 6.16060160e-02f, 1.18748903e-01f, -3.69809307e-02f,
  -1.82821285e-02f, 9.98888239e-02f, -4.45400625e-02f, 5.78241013e-02f, 4.50071581e-02f, 3.52135324e-03f, -5.76600358e-02f, -5.69309015e-03f, 1.10949269e-02f, 1.13210231e-02f,
  -3.86340357e-02f, -6.15509320e-03f, -1.21855214e-01f, -3.69854122e-02f, -2.84231994e-02f, 1.15382917e-01f, -4.22480032e-02f, 2.01173965e-02f, 2.87301783e-02f, -8.62357989e-02f,
  7.93367326e-02f, 1.21921569e-01f, -1.13251740e-02f, -1.81160588e-02f, -8.15391690e-02f, -4.72438745e-02f, 5.91752529e-02f, 1.54593075e-03f, -6.91983700e-02f, 7.82172456e-02f,
  -3.43511999e-02f, -8.46835896e-02f, 6.96411133e-02f, -5.89176565e-02f, -8.85376409e-02f, -1.37672648e-02f, -5.72034679e-02f, 2.15006340e-02f, -3.02304551e-02f, -4.35989201e-02f,
  6.47028461e-02f, 4.59839962e-02f, 1.96539853e-02f, 1.13108456e-01f, 2.78993677e-02f, 4.34091426e-02f, -1.44203249e-02f, -1.14147037e-01f, -7.41527826e-02f, -5.69088385e-02f,
  2.59423882e-01f, -3.14797729e-01f, 8.96929018e-03f, -3.35483141e-02f, 4.29128781e-02f, 3.19548859e-03f, -1.68885797e-01f, -5.55449873e-02f, 6.12937212e-02f, -1.34665474e-01f,
  -3.99706326e-02f, 1.45615250e-01f, 2.82562256e-01f, 4.28142697e-02f, 1.78065702e-01f, 3.99638675e-02f, -2.80286465e-02f, 1.68658748e-01f, 3.05066317e-01f, 5.03650308e-02f,
  -1.66319370e-01f, -6.48659468e-02f, 7.78079405e-02f, -8.51275846e-02f, -2.69719422e-01f, 3.02915312e-02f, -1.29841313e-01f, -1.93327025e-01f, -1.97844923e-01f, -7.40763918e-02f,
  1.11865543e-01f, -1.09457314e-01f, 1.07565910e-01f, -1.04980849e-01f, -1.17789097e-02f, -2.79440135e-02f, 1.74061619e-02f, -1.10871963e-01f, -6.79853708e-02f, -1.24681637e-01f,
  -1.24262676e-01f, -5.60489967e-02f, -7.60979205e-02f, -1.15840472e-01f, 1.27954292e-03f, -8.83176029e-02f, -1.35111138e-01f, -9.48608760e-03f, -4.93602045e-02f, -2.27959260e-01f,
  -1.85139790e-01f, -1.57268435e-01f, 3.51920463e-02f, -4.13906462e-02f, -2.16235980e-01f, 1.25110194e-01f, -7.61595070e-02f, -2.03072771e-01f, -7.87465274e-02f, -6.73745126e-02f,
  -4.22065292e-04f, 1.57181814e-01f, -3.67158502e-02f, -5.25022335e-02f, 4.66768928e-02f, 6.25977665e-02f, 8.46363977e-02f, -1.18339313e-02f, -3.23639363e-02f, -8.58432334e-03f,
  -1.41161177e-02f, -4.39996691e-03f, -7.22101480e-02f, 4.78618443e-02f, 1.85010526e-02f, 1.53311510e-02f, -2.80501880e-02f, -3.03469617e-02f, -3.35312681e-03f, 3.72200310e-02f,
  -9.02279804e-04f, 4.19391878e-02f, -5.86505570e-02f, -4.38298620e-02f, -9.13667008e-02f, -8.48336294e-02f, 5.36448285e-02f, -6.80262893e-02f, -8.13026950e-02f, -1.08229436e-01f,
  7.52905533e-02f, 1.96846291e-01f, 1.28887758e-01f, 2.27959324e-02f, -1.06085334e-02f, -9.46910307e-02f, 1.83426449e-03f, -3.74220283e-04f, 6.01788610e-02f, -1.07604135e-02f,
  -1.58617478e-02f, 4.83057126e-02f, -8.44427422e-02f, -5.92208691e-02f, 1.10860787e-01f, 6.87918141e-02f, -8.40979964e-02f, 1.68222915e-02f, -1.96040142e-02f, -1.72044173e-01f,
  -1.56641945e-01f, 1.87129691e-01f, 3.99733335e-01f, 2.77976304e-01f, 1.07217999e-02f, 2.90336102e-01f, 1.64609462e-01f, 1.20691977e-01f, 2.28323013e-01f, 1.88172191e-01f,
  -4.65312630e-01f, -1.74045399e-01f, -6.74771965e-02f, -4.25967127e-01f, -1.59658223e-01f, 8.39905962e-02f, 7.28512183e-02f, 1.21357217e-02f, -2.39033341e-01f, -1.63429976e-01f,
  -2.56059151e-02f, -1.54818758e-01f, -1.05365321e-01f, 7.09887221e-02f, 1.08513407e-01f, -9.93647426e-02f, -9.94329154e-03f, -3.12798547e-05f, 4.86496501e-02f, 1.43630117e-01f,
  -6.15110807e-02f, -1.62674725e-01f, -1.13145094e-02f, -1.30114108e-01f, -1.98070288e-01f, -1.14494145e-01f, -1.34489566e-01f, -2.21282959e-01f, -4.88310158e-02f, -1.71333075e-01f,
  -1.68132842e-01f, -1.00855872e-01f, 2.60290373e-02f, 9.93347913e-03f, -9.59002005e-04f, 8.68857093e-03f, 2.64907982e-02f, -5.12911640e-02f, 2.55510192e-02f, -2.01361459e-02f,
  3.09708714e-02f, 1.59115046e-02f, -3.69506702e-02f, -5.09089325e-03f, -7.31807947e-02f, -4.14307900e-02f, 3.83784715e-03f, 3.65500385e-03f, 8.22805092e-02f, -3.12083191e-03f,
  -6.64609596e-02f, -1.57931715e-01f, -1.84809983e-01f, 6.49385750e-02f, -9.15414169e-02f, 6.88210828e-03f, -1.34428486e-01f, -1.32230893e-01f, -7.83161521e-02f, -1.40945405e-01f,
  3.64909209e-02f, 6.07723894e-04f, 6.69359788e-03f, 4.16709445e-02f, 1.54573489e-02f, -1.07299440e-01f, 2.45269258e-02f, 1.87545270e-02f, 5.59672853e-03f, -4.01186310e-02f,
  2.78054476e-02f, -1.58490110e-02f, -2.24497728e-02f, -1.31345754e-02f, -1.07232729e-04f, 2.40881629e-02f, -8.23523011e-03f, 4.01347466e-02f, 4.71433066e-02f, 6.46708235e-02f,
  -1.25843380e-02f, -2.15809718e-02f, -1.05169237e-01f, -6.23712055e-02f, 3.64250392e-02f, 3.01441196e-02f, 5.83980680e-02f, 1.05887994e-01f, -2.86615193e-02f, 7.62843341e-03f,
  -4.95560348e-01f, 3.26482177e-01f, -1.25145942e-01f, -1.09123826e-01f, -3.44228335e-02f, 1.68925133e-02f, -5.57770766e-02f, 7.77939409e-02f, -1.87245302e-03f, -8.66362378e-02f,
  -3.97472177e-03f, -9.28440616e-02f, -8.21323022e-02f, -5.75280301e-02f, 6.66591078e-02f, -3.75085846e-02f, -6.92082718e-02f, -1.30944744e-01f, 1.35145690e-02f, 3.70767340e-02f,
  3.24244215e-03f, -1.61577672e-01f, -1.57948941e-01f, -6.76982999e-02f, -1.50875539e-01f, -1.75411344e-01f, -7.50172436e-02f, -1.22559533e-01f, -9.58201587e-02f, -1.82061791e-01f,
  -9.61450636e-01f, -1.05497442e-01f, 1.08021393e-01f, -1.85756221e-01f, 2.27520376e-01f, 1.74924716e-01f, 2.11211652e-01f, -4.26554866e-02f, -1.13689877e-01f, -6.01791516e-02f,
  -3.58362906e-02f, -3.47164050e-02f, 1.95120852e-02f, 1.36707202e-01f, 5.07546589e-02f, 2.16440365e-01f, 2.96238363e-01f, -3.39451851e-03f, 1.01797935e-02f, -1.45562366e-02f,
  8.34256336e-02f, -2.11555675e-01f, -3.21803838e-01f, -1.23280473e-02f, -8.79976600e-02f, 8.47623348e-02f, 2.25458238e-02f, -4.77539971e-02f, 4.04580683e-03f, 9.98014659e-02f,
  -3.39731067e-01f, -4.34044927e-01f, 8.05252194e-02f, 3.25084291e-02f, -7.36023067e-03f, -8.89561549e-02f, -3.58149745e-02f, -1.04590565e-01f, -3.26788449e-03f, -4.22992893e-02f,
  -6.90665543e-02f, -7.34975040e-02f, -5.24054132e-02f, 6.67272955e-02f, -1.77121654e-01f, -1.11205593e-01f, -2.95526208e-03f, -9.21601951e-02f, 8.75653885e-03f, -2.74751130e-02f,
  8.57300237e-02f, -1.13800094e-01f, -2.16648743e-01f, -4.98069339e-02f, -4.25136238e-02f, -3.00207548e-02f, -1.27027109e-01f, -1.42795011e-01f, -2.25636140e-01f, -4.06696469e-01f,
  -6.66364888e-03f, 6.00766065e-03f, -1.32729029e-02f, 8.75322707e-03f, -4.44201520e-03f, 3.39419506e-02f, 9.19135585e-02f, 6.32053092e-02f, 2.61454203e-04f, 2.62423959e-02f,
  4.54658866e-02f, 6.89109564e-02f, -1.50453886e-02f, -9.20071602e-02f, 1.74693074e-02f, -1.37682911e-02f, 5.70556819e-02f, 7.32331024e-03f, -5.96321374e-02f, -5.27945906e-02f,
  -1.20667210e-02f, -2.57676560e-02f, -1.06533036e-01f, 3.40044126e-02f, 9.71920714e-02f, 2.68495977e-02f, -4.25876454e-02f, 8.32737610e-03f, -1.43438196e-02f, -9.37687680e-02f,
  -2.35409573e-01f, 1.76184833e-01f, -1.73888236e-01f, -3.92339192e-02f, -2.27923114e-02f, -5.92360795e-02f, 1.54490387e-02f, -6.22852519e-03f, -5.62708192e-02f, -7.68022165e-02f,
  -1.10228909e-02f, -8.00920576e-02f, -8.31172243e-02f, 3.38437557e-02f, -9.00364146e-02f, -7.09931627e-02f, 2.41584647e-02f, -6.44517019e-02f, -4.46571186e-02f, -1.61063969e-01f,
  -3.67762446e-02f, -1.61877170e-01f, -3.45121086e-01f, -6.02283180e-02f, -1.39824346e-01f, -1.75154015e-01f, -1.92848206e-01f, -2.70449609e-01f, -3.04259866e-01f, -4.01153922e-01f,
  -3.88280451e-01f, 1.81154400e-01f, -5.45955300e-02f, -2.09147453e-01f, -2.08013341e-01f, 1.59147047e-02f, 1.54861838e-01f, -5.09082489e-02f, -5.55959791e-02f, 1.53650939e-01f,
  -3.22933234e-02f, -2.28547677e-01f, -1.43315285e-01f, -8.35906416e-02f, -1.05215214e-01f, 1.60321847e-01f, 6.07692339e-02f, -1.85940832e-01f, -3.25293243e-01f, -3.70037220e-02f,
  -3.03068552e-02f, -8.55370089e-02f, -2.70339996e-01f, -1.66209623e-01f, -7.84344301e-02f, -1.85601264e-01f, -9.75070223e-02f, -1.09132126e-01f, -8.90541915e-03f, -9.80387554e-02f,
  4.41899598e-01f, -3.16230506e-01f, -1.18303977e-01f, -1.57941714e-01f, -5.68032358e-03f, -3.92564423e-02f, -5.84610961e-02f, -1.28369808e-01f, -9.05964971e-02f, 6.13893792e-02f,
  -1.99439079e-01f, -6.99933022e-02f, -9.23062041e-02f, -6.50504977e-02f, -5.36920270e-03f, -9.36429501e-02f, -7.52184317e-02f, -1.28222466e-01f, -6.75018430e-02f, 8.54993686e-02f,
  7.34624043e-02f, -9.72229168e-02f, -2.53799483e-02f, -5.87158129e-02f, -6.87040687e-02f, -1.88288793e-01f, 2.80176266e-03f, -7.93269649e-02f, -3.72010022e-02f, 1.39966398e-01f,
  8.85090902e-02f, 1.06381163e-01f, 3.95556213e-03f, 6.41800165e-02f, 4.47410252e-03f, -1.58521496e-02f, 2.83335485e-02f, 1.21564372e-02f, -4.17750962e-02f, 6.09764531e-02f,
  5.05209202e-03f, 1.05093159e-01f, 4.62463312e-02f, 4.35134172e-02f, 7.03887790e-02f, -5.06987348e-02f, -1.47440257e-02f, 1.01775907e-01f, -4.94263396e-02f, -6.62215576e-02f,
  -3.53809446e-02f, -8.63454416e-02f, -4.44843061e-02f, 3.88068110e-02f, -7.18725696e-02f, 4.03076708e-02f, -7.79541507e-02f, -8.21256712e-02f, -9.85381231e-02f, -1.37814328e-01f,
  4.23441499e-01f, -3.66491258e-01f, 3.12358532e-02f, -9.17218067e-03f, -4.95407581e-02f, -5.66249005e-02f, 5.61011247e-02f, -3.69316489e-02f, -1.65554672e-01f, 2.30343174e-02f,
  -4.32899706e-02f, -7.87410364e-02f, -1.84027292e-03f, 5.53101907e-03f, 2.06837486e-02f, 3.79263051e-02f, 1.28162280e-01f, -1.33433053e-02f, -1.40961530e-02f, 4.91837412e-02f,
  9.05102640e-02f, 5.78130968e-02f, 2.32199177e-01f, 1.02304533e-01f, 2.76348311e-02f, -1.07837975e-01f, 1.61724553e-01f, 1.51334018e-01f, 9.96032134e-02f, 6.05667233e-01f,
  1.10010721e-03f, 5.53817153e-01f, -6.15888229e-03f, -6.98671341e-02f, 2.44961172e-01f, 2.91931272e-01f, 6.60572886e-01f, 1.90692648e-01f, -3.71859893e-02f, 9.97038633e-02f,
  1.55658439e-01f, -1.23264350e-01f, -1.52925923e-01f, -1.39873475e-01f, 8.50744545e-02f, 1.31131917e-01f, 1.13078438e-01f, -2.83082932e-01f, -2.88451403e-01f, -4.23762836e-02f,
  7.83347264e-02f, -5.69040589e-02f, -3.78384702e-02f, -1.29230797e-01f, -7.54876733e-02f, -1.69558853e-01f, -2.40270495e-02f, 2.22858787e-02f, 1.24500856e-01f, -2.80798644e-01f,
  -2.19339833e-01f, 1.46992281e-01f, -1.92598864e-01f, -1.33679956e-01f, 2.33399170e-03f, -1.33828849e-01f, -1.59643628e-02f, -5.89085519e-02f, 4.65530083e-02f, 1.89966280e-02f,
  1.86940357e-02f, -1.16520770e-01f, 4.16357741e-02f, -9.09557715e-02f, 7.79069811e-02f, -4.25654426e-02f, 4.20409776e-02f, -1.02571771e-01f, -2.77744476e-02f, -8.93076435e-02f,
  -3.16477418e-02f, 1.00172192e-01f, 1.09366655e-01f, 4.53937389e-02f, -1.02823839e-01f, -1.31614983e-01f, 5.99440858e-02f, -4.92569767e-02f, -1.01910852e-01f, -1.02542140e-01f,
  -9.06296149e-02f, -9.71538872e-02f, 1.10623622e-02f, -3.52052180e-03f, -3.43938693e-02f, -2.76396181e-02f, 1.17808604e-03f, 2.49229651e-02f, 2.31844815e-03f, 7.81966671e-02f,
  -1.19598478e-01f, -6.39886856e-02f, -5.92170563e-03f, -2.39016507e-02f, -9.53755602e-02f, -4.24199272e-03f, 5.41514717e-02f, 2.63659675e-02f, 5.62587529e-02f, 6.80482760e-02f,
  -4.74322867e-03f, -4.30754526e-03f, 1.07990801e-01f, -4.93181124e-02f, -1.37462383e-02f, -4.26117182e-02f, -1.06802195e-01f, -1.23484060e-02f, -1.09261852e-02f, -4.96631442e-03f,
  -6.10003285e-02f, 1.65990427e-01f, -8.78130868e-02f, -6.73374832e-02f, -4.51792665e-02f, -7.40897730e-02f, -5.74019104e-02f, -1.50647759e-01f, 1.58416461e-02f, 3.74265611e-02f,
  -1.69761833e-02f, -8.34923936e-04f, 9.07758102e-02f, -4.02508080e-02f, -5.74074350e-02f, 1.88287124e-02f, 1.66329652e-01f, -6.23198189e-02f, 1.80899131e-03f, 4.55100648e-02f,
  1.70302704e-01f, 8.26892778e-02f, 1.36253890e-02f, 3.66113745e-02f, -5.85733540e-02f, -1.00270778e-01f, 5.16499020e-02f, -4.35235761e-02f, -2.48884633e-02f, 2.22645476e-01f,
  4.18416619e-01f, 1.25380196e-02f, -2.30472758e-01f, 1.07034586e-01f, -2.35667322e-02f, -2.35300183e-01f, -7.70427808e-02f, 1.72154028e-02f, 1.99270725e-01f, 9.96403918e-02f,
  2.76117232e-02f, 2.01860085e-01f, 1.56802312e-01f, 1.41591400e-01f, 1.80214897e-01f, 6.36123717e-02f, 1.32673234e-01f, -1.53038371e-03f, 6.46594614e-02f, 1.87188443e-02f,
  7.67462179e-02f, 9.07349139e-02f, 5.70020489e-02f, 1.45707458e-01f, 4.28935513e-02f, 1.29069835e-01f, 2.95507349e-02f, 5.00719575e-03f, 3.98477772e-03f, 1.09715961e-01f,
  -7.73348510e-02f, -1.13809481e-01f, 7.28280377e-03f, 1.64866477e-01f, -1.34312868e-01f, 5.81444576e-02f, 2.30365507e-02f, -1.04623646e-01f, -4.09313142e-02f, 8.28794390e-02f,
  5.37675284e-02f, 1.93763478e-03f, 4.34173718e-02f, -4.57452573e-02f, -3.40952799e-02f, -3.66684273e-02f, 7.82456473e-02f, -1.45628294e-02f, -4.56171967e-02f, -5.74034899e-02f,
  3.85114439e-02f, -3.28607149e-02f, -1.43534929e-01f, -1.63406029e-01f, -5.99132366e-02f, 5.30449115e-02f, -1.72927469e-01f, -1.18136168e-01f, -1.36386603e-01f, 4.77804318e-02f,
  -1.39724361e-02f, -3.23126316e-02f, -2.72494797e-02f, 9.12882239e-02f, -1.34939859e-02f, -5.44258244e-02f, -1.45334220e-02f, 2.70546414e-02f, 9.74417552e-02f, -1.88626535e-02f,
  -5.14933169e-02f, -8.24103430e-02f, -3.72351520e-02f, -6.19535185e-02f, 5.27132563e-02f, -2.79708300e-02f, 3.06801442e-02f, 9.52339470e-02f, -2.66843867e-02f, 9.10309032e-02f,
  1.27725586e-01f, 1.11775268e-02f, 9.41269919e-02f, 9.68733151e-03f, 7.37151653e-02f, -5.19523118e-03f, 1.12975820e-03f, 5.96211813e-02f, 7.47631565e-02f, -1.32562853e-02f,
  7.95730054e-02f, -2.39440471e-01f, 1.66652277e-01f, 1.52391344e-01f, -9.64453667e-02f, 7.20280362e-03f, -1.94147602e-02f, -8.21988955e-02f, -1.82830840e-02f, -2.47834083e-02f,
  -1.22161500e-01f, -7.07496330e-02f, -7.78129622e-02f, -8.14906880e-02f, -7.87431300e-02f, -1.03044324e-01f, 2.23352257e-02f, 7.83341527e-02f, 2.91656237e-02f, -1.01744629e-01f,
  -5.13156168e-02f, 5.13148941e-02f, 5.58384620e-02f, -3.63761075e-02f, -4.92002890e-02f, 1.04144797e-01f, -7.61308568e-03f, 3.91259417e-02f, -8.75182748e-02f, 4.38317582e-02f,
  -1.62262917e-01f, -1.45908952e-01f, 1.91374689e-01f, 4.88950722e-02f, 2.09135637e-01f, 2.13498294e-01f, 3.00832629e-01f, 2.90724449e-02f, -1.21954642e-03f, -4.12693294e-03f,
  -1.99725300e-01f, -2.07324892e-01f, -2.00007737e-01f, -2.38886550e-01f, -1.64883181e-01f, 1.88100770e-01f, 1.23275518e-01f, 1.22536764e-01f, 1.02385752e-01f, 1.87547877e-01f,
  7.76717588e-02f, 1.53849706e-01f, 4.16308045e-02f, -3.84875350e-02f, 8.85366201e-02f, 3.85977291e-02f, 8.84446502e-03f, -1.03387401e-01f, -9.00298879e-02f, 3.43705826e-02f,
  1.51660904e-01f, -2.74211705e-01f, -3.09023131e-02f, -2.37954080e-01f, 3.75071727e-02f, 1.34137888e-02f, -4.36265906e-03f, 5.56894913e-02f, -1.73224166e-01f, 2.25945972e-02f,
  -1.34406850e-01f, -4.56681028e-02f, -1.38115138e-01f, 1.60811432e-02f, -9.33788996e-03f, -2.78716590e-02f, -8.00186470e-02f, -1.63353756e-01f, -1.25345811e-01f, -1.14776269e-01f,
  -2.03473508e-01f, -1.11593217e-01f, -4.80668582e-02f, -7.19594210e-02f, -1.64395705e-01f, -4.38227803e-02f, -5.86165162e-03f, -1.54257417e-01f, -1.95917383e-01f, 6.59761876e-02f,
  -4.09343205e-02f, 3.53741013e-02f, -6.95257708e-02f, 4.31608073e-02f, -4.69115227e-02f, 2.52163112e-02f, 1.32614657e-01f, 5.36233112e-02f, 1.39816612e-01f, 8.89860932e-03f,
  5.37474118e-02f, -2.30953284e-02f, 2.15845052e-02f, 1.04802944e-01f, -2.92935353e-02f, 6.08330965e-02f, 1.34799382e-04f, -5.77781685e-02f, 2.62493975e-02f, -3.14881876e-02f,
  6.91439286e-02f, 6.17183819e-02f, -5.85182123e-02f, 3.13193351e-02f, -6.12853616e-02f, -1.04976222e-01f, 6.10168576e-02f, -2.07928848e-02f, 2.37146486e-02f, 1.79098137e-02f,
  1.66500419e-01f, -2.19763204e-01f, 9.07078460e-02f, -7.75645375e-02f, 6.61832839e-02f, -9.57083553e-02f, 3.69337425e-02f, -5.72795458e-02f, -8.84635523e-02f, 1.20709702e-01f,
  -9.41650197e-02f, 4.32638749e-02f, 2.05022059e-02f, -1.29478322e-02f, 2.72021681e-01f, 1.20577969e-01f, -4.02057245e-02f, 5.67224510e-02f, -2.30365209e-02f, 5.31783067e-02f,
  -2.44717244e-02f, 1.80787548e-01f, 2.45194450e-01f, 1.65418416e-01f, 3.36328596e-02f, 8.21266174e-02f, 1.93950966e-01f, 1.50832161e-01f, 1.30911380e-01f, 3.19796413e-01f,
  1.59674391e-01f, 6.93287328e-02f, -2.99878512e-02f, 2.73623377e-01f, -1.65361073e-02f, -3.56497020e-01f, -4.42073941e-01f, -4.07115132e-01f, 1.18198790e-01f, 1.50163054e-01f,
  1.35620847e-01f, 1.68570340e-01f, -2.55799275e-02f, -3.22375335e-02f, -3.04392695e-01f, -1.53897882e-01f, 4.60910387e-02f, 6.65094405e-02f, -2.09299222e-01f, -2.72684935e-02f,
  2.25067556e-01f, 1.19845539e-01f, 1.62155345e-01f, 6.35898262e-02f, 2.86139488e-01f, 2.22776160e-01f, 8.52174610e-02f, 2.64412314e-01f, 2.69220583e-02f, 5.84492266e-01f,
  2.67921090e-01f, -5.56715205e-03f, -2.14032799e-01f, 8.56250376e-02f, 7.62464851e-02f, -6.26221746e-02f, -1.91559084e-02f, 3.14627066e-02f, 3.50305960e-02f, 7.92473031e-04f,
  1.06838576e-01f, 2.10979618e-02f, 1.20005369e-01f, -5.32964431e-03f, -8.60202536e-02f, -1.78131282e-01f, -3.84520665e-02f, -1.26774400e-01f, -1.10208765e-01f, 4.01683487e-02f,
  1.34103447e-01f, 1.18763037e-01f, -1.83606982e-01f, -2.25795865e-01f, -1.13828450e-01f, -1.07496463e-01f, -1.46085948e-01f, -9.86480191e-02f, -3.15137565e-01f, -5.38332574e-02f,
  4.54639569e-02f, 4.23101857e-02f, -5.42313568e-02f, 2.28795353e-02f, 1.88904740e-02f, 5.58667667e-02f, 4.04931754e-02f, -1.87970679e-02f, 9.36730113e-03f, -3.64207812e-02f,
  -1.21554457e-01f, 2.05991063e-02f, -1.10954449e-01f, 4.23963033e-02f, 6.24618344e-02f, 1.39299296e-02f, -5.20160012e-02f, -1.42498221e-02f, -7.76157305e-02f, 5.30988127e-02f,
  6.43142848e-04f, -1.97027195e-02f, 2.22909311e-03f, -1.24875136e-01f, 2.65309643e-02f, 1.64059103e-02f, -6.51379768e-03f, -7.48034716e-02f, -8.08956847e-02f, -6.07416173e-03f,
  -1.52566418e-01f, -3.88689429e-01f, 5.15503287e-02f, -7.23111778e-02f, 1.87706500e-02f, 5.25431298e-02f, 9.90500897e-02f, -1.18770506e-02f, -1.87731367e-02f, -1.08269034e-02f,
  -6.92114234e-02f, 1.53140156e-02f, -1.12210244e-01f, -8.63689035e-02f, -7.62581900e-02f, -1.01123348e-01f, -3.36774476e-02f, -3.90905105e-02f, -9.39816311e-02f, 8.52900557e-03f,
  -5.62775955e-02f, -1.77369624e-01f, -1.86217025e-01f, -3.13551635e-01f, -1.90302059e-01f, -1.62283257e-01f, -3.15607250e-01f, -2.19026148e-01f, -4.00193930e-01f, -2.76431590e-01f,
  4.32370275e-01f, -1.13196038e-01f, -9.65683982e-02f, -1.62343964e-01f, -3.44322622e-01f, -2.06991136e-01f, -2.37785265e-01f, -8.48292708e-02f, 4.23204377e-02f, -2.65795784e-03f,
  1.34540081e-01f, 2.47676596e-01f, 2.67517000e-01f, 1.88378334e-01f, 2.27817819e-01f, -4.90848422e-02f, 1.11260995e-01f, 1.93390444e-01f, 1.18814550e-01f, -1.06703244e-01f,
  -1.30502775e-01f, -5.35728298e-02f, 1.12478867e-01f, 4.33987901e-02f, -1.08315520e-01f, -2.14660186e-02f, 2.36722194e-02f, -1.04766585e-01f, 1.50074940e-02f, -1.74445994e-02f,
  -5.47253229e-02f, -4.06846963e-02f, 1.08825132e-01f, 1.22302681e-01f, -4.50834110e-02f, 2.06889939e-02f, -4.83101793e-03f, 2.00751051e-02f, -6.28453270e-02f, -7.23906457e-02f,
  -5.54490834e-02f, 1.66933015e-02f, 1.76540650e-02f, -9.21215042e-02f, -1.95641562e-01f, -2.94719487e-02f, 2.34639458e-02f, 6.65209889e-02f, 6.99893907e-02f, -8.64199176e-02f,
  -5.71598820e-02f, -7.71575198e-02f, 6.95080217e-03f, -9.56538543e-02f, -2.15646047e-02f, 1.55864194e-01f, -6.55475911e-03f, -9.84745380e-03f, 1.17560010e-02f, -1.08449748e-02f,
  3.22291926e-02f, -1.54167600e-02f, -4.39156555e-02f, 4.50858064e-02f, 2.29688287e-02f, 1.58545766e-02f, 2.02986915e-02f, 5.67160314e-03f, 9.83586311e-02f, 4.98986430e-03f,
  -3.96476276e-02f, 8.92808586e-02f, 2.44920179e-02f, -2.20129583e-02f, 3.09462249e-02f, 4.27896492e-02f, -8.49884450e-02f, -9.54026282e-02f, 5.40484451e-02f, 1.74735598e-02f,
  4.51366529e-02f, 2.75792982e-02f, -1.01753093e-01f, -2.63081193e-02f, 4.68954220e-02f, -9.95831490e-02f, -1.14598209e-02f, -3.17106359e-02f, 6.33541867e-02f, 9.24212951e-03f,
  -2.85487771e-01f, 2.97345161e-01f, 9.30324346e-02f, 1.07452050e-01f, -1.09963126e-01f, -4.21433821e-02f, 2.21358091e-02f, -1.09784447e-01f, -9.20873731e-02f, -1.66026726e-01f,
  -8.85273665e-02f, -6.50270050e-03f, 4.44766544e-02f, -3.78201008e-02f, 3.63723822e-02f, 3.34176496e-02f, 5.04584908e-02f, 8.49360526e-02f, 1.39468666e-02f, -8.17664415e-02f,
  2.46282521e-04f, -2.16190703e-02f, 1.17840581e-01f, -4.38646413e-03f, 4.55211289e-02f, 2.24401414e-01f, 7.25080520e-02f, 3.06078643e-02f, 1.52182236e-01f, -3.51948440e-02f,
  -9.58521962e-02f, -1.43852860e-01f, -1.98117644e-01f, -1.99306726e-01f, -1.13184176e-01f, 4.30237949e-02f, 8.56038034e-02f, 7.54801696e-03f, -1.05924524e-01f, -2.26984695e-02f,
  -5.75300343e-02f, -2.73837131e-02f, -1.31809831e-01f, -2.90265754e-02f, 6.93726353e-03f, -5.92947658e-03f, -1.51613832e-01f, -1.04478240e-01f, 4.72531356e-02f, 5.70023991e-02f,
  1.22265793e-01f, 4.30101417e-02f, -3.15365717e-02f, 4.57440205e-02f, 5.77793568e-02f, -5.20566143e-02f, -6.01872839e-02f, -1.52014226e-01f, -6.17622733e-02f, -1.58491105e-01f,
  -2.06385672e-01f, -6.03201874e-02f, -1.03912614e-02f, 5.91931492e-02f, -8.86245444e-02f, -5.22179976e-02f, 1.64805371e-02f, -1.10403165e-01f, 1.01107284e-02f, -1.00719698e-01f,
  -1.63127128e-02f, 1.34488381e-02f, -1.06931493e-01f, 7.53447711e-02f, -6.99964017e-02f, -4.96257134e-02f, 5.75711653e-02f, -1.04519919e-01f, -5.68139777e-02f, -1.45008517e-02f,
  4.80387397e-02f, 4.87053059e-02f, -1.07595168e-01f, -7.94156194e-02f, -9.74313095e-02f, -1.04247466e-01f, -6.44940957e-02f, 3.36529128e-02f, -1.10983133e-01f, -6.96401522e-02f,
  6.78706542e-03f, 6.25051335e-02f, 4.00103256e-03f, -3.43538113e-02f, 3.84155251e-02f, 1.41380057e-02f, 4.95471656e-02f, 1.97631819e-03f, 2.82112509e-02f, -7.60649443e-02f,
  4.84147370e-02f, -1.51888756e-02f, -6.82208985e-02f, -5.05167730e-02f, 5.80937006e-02f, -3.98548059e-02f, -8.96415636e-02f, 8.34560245e-02f, -5.81092611e-02f, -3.64449620e-02f,
  -6.23713769e-02f, -5.03730774e-02f, 7.19016045e-02f, 1.71912611e-02f, -1.33805173e-02f, 7.66957477e-02f, 3.25772427e-02f, -7.57894441e-02f, -1.00088745e-01f, -6.47961572e-02f,
  -3.92034166e-02f, -7.56789744e-03f, -7.00065494e-02f, -3.43342945e-02f, -1.28822148e-01f, -4.02115062e-02f, 4.86662388e-02f, -6.08322071e-03f, -1.10892169e-01f, -8.63466505e-03f,
  5.79413958e-02f, -5.19684814e-02f, -1.06173642e-02f, 3.89781930e-02f, 2.96309963e-02f, -4.59118700e-03f, 7.46451020e-02f, -9.55006704e-02f, -5.90126738e-02f, -2.16348916e-02f,
  4.76974286e-02f, -4.68295477e-02f, -1.28496289e-01f, 1.92084853e-02f, -5.26985489e-02f, -3.45644131e-02f, -1.27140462e-01f, -9.44035128e-02f, -1.48302436e-01f, 7.86448047e-02f,
  -2.47382358e-01f, -2.95515567e-01f, 2.09733006e-02f, -6.15170151e-02f, 6.85774982e-02f, 1.78072730e-03f, -1.30652890e-01f, 5.83192892e-02f, 3.12300250e-02f, -1.09380588e-01f,
  -1.59570739e-01f, -5.53441979e-02f, -2.46162666e-03f, 7.35459849e-03f, 7.55852982e-02f, 1.80349704e-02f, 1.49892539e-01f, 1.87040448e-01f, 1.62419245e-01f, -5.05770615e-04f,
  1.06310211e-02f, 4.65065986e-02f, 1.44944161e-01f, 4.11902629e-02f, 6.69220537e-02f, 7.99691901e-02f, 4.89143357e-02f, -2.43356470e-02f, 2.54883319e-02f, 5.33160083e-02f,
  -2.76863903e-01f, -2.38966525e-01f, 1.11810371e-01f, -8.84403649e-04f, -4.70751598e-02f, 1.31445862e-02f, -4.18775007e-02f, 5.27910218e-02f, -7.16951862e-02f, -8.73935148e-02f,
  -1.67585686e-02f, -3.95139344e-02f, 1.59800705e-03f, -7.13919103e-02f, -9.57077667e-02f, -2.58227643e-02f, 6.47414476e-02f, 1.46782681e-01f, 1.41951397e-01f, -6.34322390e-02f,
  -8.28304440e-02f, -4.43012454e-02f, 3.11461687e-02f, 9.08741876e-02f, -7.42258057e-02f, 7.34862462e-02f, -6.07604347e-02f, -9.30270478e-02f, 1.77147854e-02f, -5.96224628e-02f,
  4.52673025e-02f, -3.27444896e-02f, 1.69260949e-02f, -7.15946555e-02f, -8.97222105e-03f, 3.05239763e-02f, -4.47139926e-02f, 1.26485424e-02f, 2.26473100e-02f, 9.50062461e-03f,
  1.34712467e-02f, -1.19567132e-02f, 1.49118649e-02f, 4.80028838e-02f, 1.98570099e-02f, 3.33888009e-02f, -2.90707638e-03f, 6.66370476e-03f, -5.76204795e-04f, 8.11063945e-02f,
  2.86177006e-02f, 2.05720626e-02f, 8.15760195e-02f, 6.98125586e-02f, -3.80789191e-02f, 9.20786485e-02f, -3.33085470e-02f, -2.96489689e-02f, -1.78190954e-02f, 1.23935379e-02f,
  -1.14948213e-01f, 1.61012769e-01f, -9.84244943e-02f, 1.17651457e-02f, -5.03279977e-02f, 3.67060751e-02f, -7.38680437e-02f, -1.53439194e-02f, -2.15560608e-02f, -9.23048407e-02f,
  -8.76930133e-02f, -9.63222831e-02f, 3.10567040e-02f, -3.42568532e-02f, -4.56369333e-02f, 2.52978075e-02f, -7.43204057e-02f, 8.71261209e-02f, -4.93075214e-02f, -5.44666350e-02f,
  2.34527718e-02f, -9.98815671e-02f, -6.25542477e-02f, 6.23591505e-02f, -9.97621864e-02f, -1.29286433e-02f, 3.30546014e-02f, -9.45445597e-02f, -6.48612902e-02f, -7.31186047e-02f,
  2.35669360e-01f, -9.22062993e-02f, 2.25992743e-02f, 9.78153050e-02f, 2.57533342e-01f, 1.02861963e-01f, 1.41497687e-01f, 1.02706991e-01f, 2.84870379e-02f, 7.38774389e-02f,
  1.26846164e-01f, 1.55443817e-01f, 1.40671179e-01f, 1.99766885e-02f, -2.24023797e-02f, -2.69662365e-02f, 4.19304073e-02f, 7.53337741e-02f, 5.41560091e-02f, 3.57183963e-02f,
  -6.55256212e-02f, -7.08521754e-02f, 8.88459757e-02f, 1.12501290e-02f, 1.72565114e-02f, 1.40117249e-02f, 6.38527125e-02f, 3.59640755e-02f, 2.67456397e-02f, -8.64626747e-03f,
  -3.90425958e-02f, 2.22294349e-02f, 9.05461237e-02f, -6.89560845e-02f, -8.33097845e-02f, -4.21733744e-02f, -3.02463281e-03f, -7.30040669e-02f, 3.64107378e-02f, -3.51711363e-02f,
  -7.08435774e-02f, -2.31228266e-02f, 6.96005374e-02f, -3.76115702e-02f, 2.23002043e-02f, 2.52291430e-02f, 1.64575577e-02f, -1.02987356e-01f, -5.11215441e-03f, -4.31296192e-02f,
  -2.75172126e-02f, -1.64392800e-03f, 1.45457536e-01f, 5.50609967e-03f, -1.42192945e-01f, 5.70073910e-02f, -5.06144091e-02f, -6.36248291e-02f, -2.25347793e-03f, -6.58039097e-03f,
  1.05610825e-01f, 1.49385318e-01f, 7.24141002e-02f, -4.03960533e-02f, 6.32103980e-02f, -5.49620800e-02f, -3.34732942e-02f, -6.57136887e-02f, -3.35708521e-02f, 4.37332578e-02f,
  4.34652828e-02f, 3.05006616e-02f, 4.90904376e-02f, 6.53071105e-02f, 5.77562042e-02f, 1.63660869e-02f, 7.51899555e-02f, 7.26745203e-02f, 1.16477549e-01f, 1.11913057e-02f,
  1.02125347e-01f, 8.19158703e-02f, 7.40055218e-02f, -4.70444039e-02f, 3.08311712e-02f, 1.47755846e-01f, 1.09905161e-01f, 1.93725377e-02f, 1.23025507e-01f, 6.81448504e-02f,
  -3.68304849e-02f, 1.53310746e-01f, 6.50252253e-02f, -2.89471764e-02f, 5.20942099e-02f, -4.59078187e-03f, -2.49520466e-02f, -1.17157754e-02f, -6.24949485e-02f, -1.16339117e-01f,
  -4.92781475e-02f, 3.69663537e-02f, 1.32916197e-02f, -6.35537356e-02f, 5.48041835e-02f, -3.81000489e-02f, -1.13766044e-01f, 4.66131978e-02f, -1.51496297e-02f, -8.71477872e-02f,
  -8.29205886e-02f, 9.84852538e-02f, 1.57765687e-01f, -1.41338231e-02f, 1.50183812e-02f, 3.57016437e-02f, -3.43095399e-02f, -5.41724972e-02f, -8.82684253e-03f, 7.04439357e-02f,
  5.92047095e-01f, 4.64029074e-01f, 5.50238907e-01f, 3.30693200e-02f, -1.22490272e-01f, -1.40490364e-02f, 2.19592988e-01f, 1.53820142e-01f, -1.13035783e-01f, -3.87823023e-02f,
  -1.13188140e-01f, -2.04022989e-01f, -4.67153406e-03f, 1.39726669e-01f, 3.50914270e-01f, 2.36895680e-01f, 8.02569687e-02f, 2.40490168e-01f, 2.61086196e-01f, 2.68212389e-02f,
  -1.69156730e-01f, 1.20417729e-01f, 1.01548515e-01f, 1.51604846e-01f, 2.49646213e-02f, -8.47221017e-02f, 6.34706691e-02f, 1.10778995e-01f, -4.93792212e-03f, 1.16446927e-01f,
  -1.71678159e-02f, 3.80443066e-01f, -2.12353870e-01f, -2.07928002e-01f, -1.44056544e-01f, 7.44066760e-02f, -2.56080572e-02f, -2.25771368e-02f, 2.04742681e-02f, 1.18574828e-01f,
  -1.17309660e-01f, -1.28638655e-01f, -5.75139895e-02f, -1.06126755e-01f, -1.47292716e-02f, -3.53190838e-03f, 9.60737392e-02f, 1.99383765e-01f, 1.10201098e-01f, 1.22463651e-01f,
  -1.40778989e-01f, -9.56902131e-02f, -2.50695795e-02f, 3.56829055e-02f, 1.64434567e-01f, -1.77825987e-01f, 2.70939115e-02f, 9.42149013e-02f, 1.33356124e-01f, 1.07721716e-01f,
  -7.69454166e-02f, 1.28533840e-01f, -9.48356744e-03f, 1.74679011e-02f, 1.14722352e-03f, -6.65782169e-02f, -2.21455041e-02f, -7.93069899e-02f, 8.47852528e-02f, -1.44295925e-02f,
  4.22693696e-03f, 3.83389518e-02f, 3.09699681e-02f, 5.48626110e-02f, -3.65185812e-02f, -5.61393946e-02f, 5.87786846e-02f, -2.17046607e-02f, 3.11771668e-02f, -6.19129790e-03f,
  1.05246960e-03f, 2.89538819e-02f, -4.09055725e-02f, 8.35604034e-03f, 6.96089417e-02f, 5.42521179e-02f, 1.12810014e-02f, -5.67645654e-02f, -2.50910539e-02f, -4.76013236e-02f,
  -3.39345694e-01f, -1.35630012e-01f, -7.50145689e-02f, -2.09907722e-02f, -7.82876834e-02f, 6.35009818e-03f, -1.74803715e-02f, 2.08703130e-02f, -4.45642956e-02f, 3.88053507e-02f,
  -6.54274151e-02f, 1.26088157e-01f, -1.52142318e-02f, -1.19154984e-02f, -2.96584168e-03f, -1.60820961e-01f, -1.64193168e-01f, 1.41518163e-02f, -8.94237235e-02f, -5.89436740e-02f,
  -6.22121803e-02f, -9.33633745e-02f, -1.37871906e-01f, -1.57541633e-01f, -5.25450595e-02f, -2.38183439e-01f, -8.45307410e-02f, -1.96604744e-01f, -1.29348069e-01f, -1.75890848e-01f,
  3.08071315e-01f, -1.56965330e-01f, 2.83066392e-01f, 1.92448318e-01f, 1.51118591e-01f, 1.42444313e-01f, 1.08861320e-01f, 1.65689543e-01f, 1.93528518e-01f, 5.71340211e-02f,
  -3.92853081e-01f, -2.77774125e-01f, -2.14375705e-01f, -1.88102141e-01f, -3.22385319e-02f, 1.39783442e-01f, 3.50640714e-01f, 2.62936503e-01f, 1.22907273e-01f, 1.79259241e-01f,
  -2.60859020e-02f, 1.76272001e-02f, 3.31409089e-02f, 1.11015812e-01f, 9.40726176e-02f, 5.70509024e-02f, 6.40369207e-02f, -1.48428185e-02f, -1.26094773e-01f, 1.69408038e-01f,
  -1.97768986e-01f, -6.28957525e-02f, 6.17503263e-02f, -1.71306103e-01f, -2.07064196e-01f, -3.92328687e-02f, 2.33910158e-02f, 5.94301261e-02f, 4.14777827e-03f, 1.27144456e-01f,
  -1.04303174e-01f, -3.19567584e-02f, -1.03272401e-01f, -9.69666392e-02f, 7.36246407e-02f, 2.48260796e-02f, 2.43943017e-02f, 4.33182344e-02f, 1.28773963e-02f, -8.95609111e-02f,
  -1.94945425e-01f, -2.54560187e-02f, -5.77590801e-03f, -4.40924242e-02f, -1.27361808e-02f, -1.31193176e-01f, -8.33333284e-02f, -1.04820117e-01f, -1.95315797e-02f, 6.35381564e-02f,
  6.03292510e-03f, 2.41592284e-02f, -8.18936750e-02f, 5.63468821e-02f, 6.00135513e-02f, 7.22451583e-02f, 2.85875350e-02f, -7.54098967e-02f, 1.06050363e-02f, 8.62151012e-02f,
  7.66824139e-03f, 6.01525940e-02f, 3.92743107e-03f, 1.11018531e-01f, -1.16789602e-01f, 2.16272157e-02f, 4.80027171e-03f, -1.48519932e-03f, 1.14490259e-02f, -2.22491752e-02f,
  -5.00406623e-02f, -3.18978839e-02f, -1.39408875e-02f, 1.14673246e-02f, -5.21404520e-02f, -1.48619218e-02f, 3.31455357e-02f, -1.09551050e-01f, 3.81778320e-03f, -4.85445224e-02f,
  -1.31867722e-01f, -2.88436443e-01f, 1.13805063e-01f, 2.68804226e-02f, 1.90531258e-02f, -1.06122598e-01f, -1.05462201e-01f, -6.49968814e-03f, -9.52589288e-02f, 7.84857124e-02f,
  -1.27124473e-01f, -7.99519271e-02f, -1.93240475e-02f, 2.37880391e-03f, 6.39216378e-02f, 3.24861445e-02f, -1.65654179e-02f, 6.99293101e-03f, 1.12229083e-02f, -8.33752230e-02f,
  -4.19846848e-02f, 2.22712412e-01f, 1.30282030e-01f, 9.34885070e-02f, -5.90622462e-02f, 1.51399270e-01f, -5.60955517e-02f, 3.99999134e-02f, 8.49560797e-02f, 2.98314214e-01f,
  2.79788017e-01f, 4.96177942e-01f, 5.29305413e-02f, 1.13710217e-01f, 1.78580601e-02f, -8.82129595e-02f, 8.47083703e-02f, 1.09619118e-01f, 3.78783979e-02f, 1.53758973e-01f,
  9.23788082e-03f, -1.01685166e-01f, -1.00524150e-01f, -2.13192716e-01f, -6.06274828e-02f, 4.96727154e-02f, -5.65810725e-02f, -2.49340102e-01f, -3.54495972e-01f, -3.03898990e-01f,
  -1.06698565e-01f, 5.38878180e-02f, -1.56055242e-02f, -8.29284191e-02f, 1.28741145e-01f, -2.34027300e-02f, 1.71766117e-01f, 8.82426947e-02f, -4.47417721e-02f, 1.22049868e-01f,
  -5.62580414e-02f, 3.47742975e-01f, -3.55629146e-01f, -1.52612537e-01f, -5.92047907e-02f, 5.68811707e-02f, -4.77748848e-02f, 2.82852221e-02f, -6.01320155e-02f, 1.26502756e-02f,
  4.60218638e-02f, -6.75861314e-02f, 2.53890809e-02f, -7.23529533e-02f, -8.97763222e-02f, 6.71602320e-03f, 2.16665231e-02f, 1.55450730e-02f, -6.89526200e-02f, -5.01339100e-02f,
  -1.89352706e-01f, 5.24014700e-03f, 1.56658828e-01f, -8.27255845e-02f, 6.51982352e-02f, -1.26417801e-01f, 4.85539250e-02f, 6.21808060e-02f, 6.27966076e-02f, 1.61414504e-01f,
  2.32214518e-02f, -8.49972367e-02f, -7.97353089e-02f, -2.78391107e-03f, 5.06515475e-03f, 1.02222683e-02f, 9.04159155e-03f, 2.60730181e-02f, -3.29132713e-02f, 1.82427578e-02f,
  1.31819937e-02f, 3.46339904e-02f, -2.34125946e-02f, 7.73267299e-02f, 3.72662209e-02f, 7.61703104e-02f, 1.86322518e-02f, -5.53312823e-02f, -5.48123121e-02f, 2.38547474e-02f,
  -1.27062336e-01f, 2.75669247e-02f, -1.56024257e-02f, 2.06124820e-02f, 1.33059546e-02f, 5.25194034e-02f, 2.91498122e-03f, 3.15356143e-02f, 1.51308086e-02f, -3.85639537e-03f,
  -1.54109299e-01f, -1.90643370e-01f, -6.77382797e-02f, 7.01201484e-02f, 6.46585077e-02f, -1.91842727e-02f, 5.90645038e-02f, 6.96906075e-02f, -3.75624485e-02f, -6.73567057e-02f,
  -6.83557913e-02f, -2.77069751e-02f, 6.02562428e-02f, -2.36908048e-02f, -7.98916891e-02f, -2.82487776e-02f, -2.38797348e-02f, -1.59412976e-02f, -3.09548173e-02f, -2.07536798e-02f,
  6.00420171e-03f, -2.17566155e-02f, -5.26803881e-02f, 5.83495758e-03f, -8.01536813e-02f, -2.52765924e-01f, -2.21205503e-02f, 5.17114019e-03f, -6.11311942e-02f, -3.19113769e-02f,
  3.69451433e-01f, 3.17730635e-01f, -1.02969281e-01f, 1.13690034e-01f, 4.21085022e-02f, -2.10612081e-02f, 1.76050857e-01f, 3.17049436e-02f, -9.72872414e-03f, 1.44544989e-01f,
  1.09268434e-01f, -7.05229491e-02f, -6.46425933e-02f, -1.52458653e-01f, -7.72945881e-02f, -3.86314839e-02f, -5.24141379e-02f, -6.67897165e-02f, -3.24203730e-01f, -1.70312542e-02f,
  -8.49313140e-02f, 3.68126594e-02f, 4.60205749e-02f, -4.42658179e-02f, -3.21445055e-02f, -7.82783180e-02f, 1.37193263e-01f, 8.90883990e-03f, 5.24760783e-02f, -1.22891525e-02f,
  3.94768380e-02f, 1.37306497e-01f, -1.57720253e-01f, 7.27182478e-02f, 1.34503081e-01f, -1.27900103e-02f, 2.52622683e-02f, 2.78943796e-02f, 6.30017817e-02f, 2.75050644e-02f,
  3.00605409e-02f, 2.98963003e-02f, -3.40422019e-02f, 9.60942358e-02f, 8.93384591e-02f, -5.82114123e-02f, 2.27447618e-02f, -7.26675317e-02f, -1.57569095e-01f, 6.72493726e-02f,
  1.42020378e-02f, 7.46774599e-02f, 3.82290632e-02f, -1.06049351e-01f, 2.94572413e-02f, -8.08032975e-03f, -6.74788877e-02f, -7.43641928e-02f, -1.39819577e-01f, 6.15542084e-02f,
  -2.08596736e-02f, 7.65335336e-02f, -5.78722246e-02f, 4.52496111e-02f, -8.85901507e-03f, 6.19728416e-02f, 4.87380028e-02f, -3.47685814e-03f, 4.90402244e-02f, 6.64308493e-04f,
  2.79498566e-02f, 7.10792989e-02f, 1.02820158e-01f, 7.60954153e-03f, -4.50458005e-02f, 2.73476169e-02f, -2.85748225e-02f, 1.38420403e-01f, 8.11497942e-02f, 1.40181512e-01f,
  2.93306895e-02f, -6.02965429e-02f, 4.24905904e-02f, -7.62932897e-02f, -1.04051515e-01f, 2.13912539e-02f, 9.32123736e-02f, 1.26434818e-01f, -2.79655438e-02f, 9.56017077e-02f,
  7.87753835e-02f, 3.82378362e-02f, -5.12140542e-02f, -5.11120819e-02f, 4.14467454e-02f, 4.04434875e-02f, -2.60360632e-02f, 7.86851794e-02f, 1.05489425e-01f, -3.19004133e-02f,
  8.38405732e-03f, -5.66906780e-02f, 9.27969664e-02f, -3.11173312e-02f, -1.13170311e-01f, 5.65078966e-02f, 1.54121011e-01f, -6.38002679e-02f, -1.05249256e-01f, -1.19769108e-02f,
  7.73923099e-02f, -3.24438140e-02f, -2.16104905e-03f, -2.53803041e-02f, -3.41135524e-02f, -5.66681102e-02f, -9.26322192e-02f, -1.28318101e-01f, -3.54427621e-02f, 4.48297225e-02f,
  1.42144278e-01f, -5.43711662e-01f, -5.09818912e-01f, 1.81607872e-01f, -1.24400839e-01f, -5.22999823e-01f, -6.91123962e-01f, -7.55878463e-02f, 6.94659427e-02f, -3.59157324e-01f,
  -1.51826471e-01f, 8.08861926e-02f, -6.13315627e-02f, -2.45856479e-01f, -3.60992491e-01f, -5.31060934e-01f, -4.55867231e-01f, -3.54402632e-01f, -2.11372763e-01f, -1.98140949e-01f,
  -1.43869206e-01f, 2.05274411e-02f, 1.01201952e-01f, 1.82138737e-02f, -3.25953886e-02f, -6.17822893e-02f, -1.29566967e-01f, -1.15004286e-01f, -3.13246310e-01f, -1.95753217e-01f,
  -4.79374826e-01f, 2.17732415e-02f, 1.88271068e-02f, 4.38395776e-02f, 1.63521320e-02f, -4.60121706e-02f, -1.53018430e-01f, 6.34685904e-02f, 6.79128543e-02f, -3.86034809e-02f,
  -1.01044409e-01f, 5.16185574e-02f, 2.48561148e-02f, -7.44361579e-02f, -3.04030590e-02f, -1.25525787e-01f, 4.31367345e-02f, -4.51167719e-03f, -1.47938564e-01f, -1.29692078e-01f,
  -1.18858323e-01f, -1.54874772e-01f, -1.96404517e-01f, -3.75896208e-02f, 2.79813223e-02f, -9.23800915e-02f, -1.68738052e-01f, 1.64129678e-02f, -1.72685042e-01f, -7.64008611e-02f,
  -3.99869643e-02f, 2.83178320e-04f, 2.19917279e-02f, 9.61372405e-02f, -3.23377214e-02f, -5.75280795e-03f, 3.46223749e-02f, -6.24723509e-02f, 5.33164367e-02f, -7.56075513e-03f,
  2.36572381e-02f, 4.85786051e-03f, 4.34840098e-02f, 1.69971399e-02f, 2.63790861e-02f, -1.88505352e-02f, -4.30256166e-02f, -8.42719600e-02f, -7.19515681e-02f, 7.68035203e-02f,
  1.08698877e-02f, 4.97839972e-03f, 7.51234591e-02f, -2.87286509e-02f, -1.17713161e-01f, -7.47619867e-02f, 3.32629830e-02f, 1.39166303e-02f, 6.01666458e-02f, -3.26297283e-02f,
  1.87382802e-01f, -1.19990893e-01f, -1.66604444e-01f, 1.88118741e-02f, -3.64704691e-02f, 1.58967227e-02f, -6.19008346e-03f, -3.51171126e-03f, 8.17955956e-02f, -1.32497907e-01f,
  -6.77289590e-02f, -4.94957343e-02f, -9.11862180e-02f, 1.72323864e-02f, 6.09764755e-02f, 6.17232732e-02f, -8.84243473e-02f, -4.43816185e-02f, -1.06705800e-02f, 2.59761624e-02f,
  -7.63705820e-02f, -2.29799181e-01f, -1.69575855e-01f, -7.59648830e-02f, -6.59058094e-02f, -1.44189626e-01f, -1.54319257e-01f, -1.11748740e-01f, -1.51464254e-01f, -8.61947387e-02f,
  -3.32457751e-01f, 3.80514681e-01f, 1.53489143e-01f, -1.08275481e-01f, -3.40808928e-02f, 1.64386794e-01f, 9.81748626e-02f, -1.82072654e-01f, -1.27837092e-01f, 3.07953563e-02f,
  4.80148122e-02f, -1.72442153e-01f, -2.15464607e-01f, -2.51554102e-01f, -2.47348681e-01f, 6.13749623e-02f, -5.37495576e-02f, -3.25951457e-01f, -5.77290177e-01f, -4.30678666e-01f,
  -2.20997572e-01f, -3.05785894e-01f, -3.95483792e-01f, -1.74797967e-01f, -8.15420225e-03f, -1.01219408e-01f, 1.19118147e-01f, -3.36170234e-02f, 6.20952845e-02f, 1.98638022e-01f,
  1.08252041e-01f, 1.65828019e-01f, -1.58650309e-01f, 1.02698598e-02f, 2.60376297e-02f, 4.92218286e-02f, -5.05661825e-03f, -5.04906438e-02f, 4.61433195e-02f, 3.02718375e-02f,
  -8.42857733e-03f, -7.39257187e-02f, -1.96081549e-02f, -2.56566424e-02f, -7.54672661e-02f, 2.83861458e-02f, 2.07492150e-02f, -1.74355209e-01f, -3.90685396e-03f, 6.32347614e-02f,
  1.55945152e-01f, 1.74051926e-01f, 1.05496952e-02f, 2.83762366e-02f, 1.20451830e-01f, 1.15436420e-01f, 5.31289764e-02f, 1.16301402e-02f, 9.33234617e-02f, -5.22002671e-03f,
  -4.14213501e-02f, 1.23905830e-01f, 1.00237513e-02f, -4.80831526e-02f, -1.41103178e-01f, 1.07132860e-01f, -9.34022442e-02f, -3.37910466e-02f, -8.66357684e-02f, -9.60977376e-03f,
  -3.84664861e-03f, 1.06244899e-01f, -3.63078974e-02f, -6.23915903e-02f, 2.12885700e-02f, 7.66672343e-02f, -5.81531450e-02f, -5.75915426e-02f, 4.42922078e-02f, 1.97722483e-02f,
  -5.16346395e-02f, -2.66578719e-02f, 2.53666751e-02f, -3.86652984e-02f, 1.18165724e-01f, 3.54330987e-02f, -1.20082423e-02f, 3.52656431e-02f, -3.94259468e-02f, 6.01556823e-02f,
  -3.56263101e-01f, 3.82867381e-02f, 5.55969924e-02f, -1.60474554e-01f, 1.05373345e-01f, 1.17341056e-01f, 9.46668088e-02f, -7.59520102e-03f, -1.34198712e-02f, -1.10262342e-01f,
  4.28495668e-02f, -7.98466653e-02f, 4.09119688e-02f, -2.49408130e-02f, -3.75894792e-02f, -8.24596882e-02f, -1.77014489e-02f, -9.55806673e-02f, 7.92683195e-03f, 2.00977176e-01f,
  -1.63948666e-02f, -9.38639194e-02f, -1.49539500e-01f, -4.31172689e-03f, 1.57190524e-02f, -1.13584839e-01f, -3.88892693e-03f, -2.74780355e-02f, -1.36141013e-02f, -8.04679021e-02f,
  7.36952662e-01f, 2.23951757e-01f, -5.95577419e-01f, 6.52444437e-02f, -2.98648834e-01f, -4.15191293e-01f, -2.47471124e-01f, 1.12673499e-01f, -4.09966055e-03f, 1.30189015e-02f,
  -3.85050885e-02f, 1.10300504e-01f, 3.86249870e-02f, 9.34562013e-02f, 1.03826679e-01f, -1.55605167e-01f, -1.13155924e-01f, -5.56846857e-02f, -1.46554038e-01f, 6.86281361e-03f,
  6.92587811e-03f, 9.74829420e-02f, 2.58591741e-01f, 6.23409376e-02f, -1.14899939e-02f, -1.11702479e-01f, -2.10519344e-01f, -1.12575032e-01f, -1.56993404e-01f, -1.10366553e-01f,
  -4.43605185e-01f, -1.28315449e-01f, 2.96934694e-02f, 1.04253761e-01f, -4.45406884e-02f, 1.66894570e-01f, 5.39071038e-02f, 2.77464129e-02f, 2.00288855e-02f, 3.94805856e-02f,
  -4.54505347e-02f, -4.10802290e-02f, -6.63531348e-02f, -5.67506738e-02f, -6.67433534e-03f, -3.41864824e-02f, 9.06337872e-02f, 8.06920305e-02f, -2.75952984e-02f, -6.16396628e-02f,
  -5.77593371e-02f, -8.46320465e-02f, 2.60277279e-03f, -1.02303058e-01f, -1.16704203e-01f, -3.29102166e-02f, -8.96003321e-02f, -9.90269855e-02f, -1.12799369e-01f, 1.80248141e-01f,
  -7.09143355e-02f, -2.62278970e-02f, -4.33790423e-02f, 3.08051631e-02f, 3.39213423e-02f, -3.65873314e-02f, 1.79182589e-02f, -4.45577838e-02f, 2.16234066e-02f, 4.98794578e-02f,
  -1.23424223e-02f, 3.55306722e-04f, -6.84911609e-02f, 5.47760017e-02f, -4.15323162e-03f, -3.79267745e-02f, -4.83435765e-03f, 2.57116873e-02f, 2.02320553e-02f, -3.62636847e-03f,
  1.82240624e-02f, -3.44551243e-02f, -9.06969309e-02f, 4.40097600e-02f, -5.51412553e-02f, -1.77250318e-02f, -5.28572639e-03f, -3.53991054e-03f, 6.11159317e-02f, 1.79403089e-02f,
  2.05773503e-01f, -4.62086946e-02f, 6.73100129e-02f, 1.59023225e-01f, -9.61823761e-02f, 1.66173540e-02f, 2.06333883e-02f, 4.10185270e-02f, 1.28484219e-02f, -6.37595728e-02f,
  -1.42509714e-01f, 5.57117313e-02f, -2.89085042e-02f, -5.46391271e-02f, 2.71465592e-02f, -1.41030634e-02f, 1.01656079e-01f, -3.53521593e-02f, -1.38170589e-02f, -8.61289278e-02f,
  6.44417256e-02f, 1.30282700e-01f, 1.78405434e-01f, 1.14710361e-01f, -5.55835068e-02f, 2.66514048e-02f, -2.90617486e-03f, -1.33532539e-01f, 8.22718963e-02f, 3.08596313e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  1.35418653e-01f, 3.57905149e-01f, 9.04228166e-02f, 2.99304515e-01f, 4.39261675e-01f, 6.36722565e-01f, 3.06873173e-01f, 2.99094737e-01f, 2.93889731e-01f, 2.70606846e-01f,
  7.67118065e-03f, 1.42728180e-01f, 3.84297110e-02f, 9.06808078e-02f, 3.39378655e-01f, 3.49230349e-01f, 2.99584776e-01f, 4.07293737e-01f, 2.84894347e-01f, 3.45275193e-01f
};

// L1_linear_W (Shape: 12 x 32)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 32;
const float L1_linear_W_data[] = {
  -3.81604582e-03f, -3.81073445e-01f, -3.12773362e-02f, -7.58023143e-01f, -3.69780093e-01f, -3.32540087e-02f, -1.60374835e-01f, 3.69082600e-01f, 2.22925365e-01f, 7.21009910e-01f,
  -1.10884495e-01f, -1.01211950e-01f, -1.48302689e-01f, -3.71698380e-01f, 3.93126160e-01f, -4.25403565e-02f, -2.96064705e-01f, -3.55168223e-01f, -2.37180188e-01f, -1.00837842e-01f,
  -3.44530284e-01f, -3.39122564e-01f, 4.40450191e-01f, 1.41670063e-01f, -7.44589120e-02f, -3.99238802e-02f, -2.27453947e-01f, -3.67157280e-01f, -3.16585153e-01f, 1.12442231e+00f,
  -4.13199395e-01f, 1.22270674e-01f, -2.23680541e-01f, -1.60055622e-01f, -2.12987270e-02f, -4.27234285e-02f, -4.69919294e-01f, 1.55135974e-01f, -3.74102294e-01f, 6.67638540e-01f,
  -2.30605736e-01f, 6.39428675e-01f, -3.49644311e-02f, 3.70364904e-01f, 3.70991409e-01f, 8.46770763e-01f, -1.31245226e-01f, -4.82500851e-01f, -3.78808290e-01f, -3.60085845e-01f,
  4.18517232e-01f, -4.65308994e-01f, -3.04716051e-01f, 9.00348544e-01f, -2.86469400e-01f, -3.65255997e-02f, 3.63067806e-01f, 4.41264480e-01f, -3.44673246e-02f, -4.41165596e-01f,
  -1.94490910e-01f, 3.31672311e-01f, -1.33593306e-01f, 6.02419496e-01f, 2.91460067e-01f, 5.32083809e-01f, 4.08919007e-01f, 4.43138599e-01f, 7.73361742e-01f, 6.62236273e-01f,
  -4.78701055e-01f, -8.57742131e-01f, -1.04547881e-01f, -4.75624800e-01f, -5.77151954e-01f, 1.06436238e-01f, -3.96947145e-01f, 1.29926011e-01f, 3.13372195e-01f, 3.69767427e-01f,
  -5.11638641e-01f, -4.19774115e-01f, -8.79663080e-02f, -1.07856549e-01f, 1.39397159e-02f, 3.58210325e-01f, -5.08087873e-03f, 6.09876812e-01f, -8.61309245e-02f, 3.96691859e-02f,
  -1.67861536e-01f, -3.56261432e-01f, -3.24828565e-01f, 2.77987570e-01f, -4.64947909e-01f, -1.10456340e-01f, -2.95956321e-02f, 1.68506920e-01f, -1.91084638e-01f, 1.04392119e-01f,
  -1.08909264e-01f, -8.43342841e-02f, 2.73357809e-01f, -5.53130098e-02f, 5.82828045e-01f, 5.35491824e-01f, -4.33410823e-01f, 5.33657551e-01f, -2.12496873e-02f, -3.40924352e-01f,
  9.02667403e-01f, 7.54452288e-01f, 4.45019275e-01f, 3.71987581e-01f, -2.56460577e-01f, -1.72979936e-01f, -5.14177859e-01f, 1.20255582e-01f, 2.61507809e-01f, -8.92294869e-02f,
  -2.10590079e-01f, -3.58571500e-01f, -2.01436833e-01f, -1.68515980e-01f, -1.62284486e-02f, -5.42361319e-01f, 8.54726732e-01f, -5.14633954e-01f, -7.66984940e-01f, 3.85562956e-01f,
  -1.73254833e-01f, 3.65443975e-01f, -3.92047837e-02f, 1.37012258e-01f, 6.25984371e-01f, 2.90672332e-01f, -6.81330383e-01f, -2.95414031e-01f, -3.72516036e-01f, -9.93328243e-02f,
  1.82272226e-01f, -3.28383893e-01f, -1.73263669e-01f, -2.11161710e-02f, 5.85196763e-02f, -6.56377003e-02f, -3.31134528e-01f, -2.58467376e-01f, 2.17348397e-01f, -1.31635547e-01f,
  -1.16193190e-01f, -1.40420273e-01f, 1.17545292e-01f, -3.65195394e-01f, -1.13447040e-01f, 5.27224600e-01f, 1.03628844e-01f, 7.57381082e-01f, 7.68843651e-01f, -3.56792748e-01f,
  2.72082895e-01f, -3.18536684e-02f, 1.30174354e-01f, 3.14684689e-01f, 4.21705127e-01f, 1.47318751e-01f, -3.22714776e-01f, 6.50376439e-01f, 5.11070430e-01f, 3.35826367e-01f,
  -2.21229523e-01f, -7.92583108e-01f, 1.23223849e-01f, -1.38294533e-01f, -2.11458594e-01f, -5.33978701e-01f, 6.27806783e-01f, 4.41540718e-01f, 4.41498905e-01f, 8.71958435e-02f,
  -1.99470356e-01f, -1.31982520e-01f, 2.37457961e-01f, -1.08510874e-01f, -1.80676319e-02f, -2.94406950e-01f, 2.33170316e-01f, 1.38875648e-01f, 3.65107298e-01f, 1.64355159e-01f,
  -1.56785011e-01f, 9.97371376e-01f, 1.40288416e-02f, -5.24873316e-01f, 3.46237570e-02f, 1.33327276e-01f, 1.99592814e-01f, 3.10857207e-01f, -9.95000824e-02f, -4.48407352e-01f,
  3.96922491e-02f, -5.33260465e-01f, 7.87014425e-01f, -3.00093949e-01f, -5.15975773e-01f, -1.75939351e-01f, -3.68552268e-01f, -8.53510857e-01f, -1.92802340e-01f, -5.89174032e-01f,
  2.83875525e-01f, -1.48588374e-01f, 4.89921242e-01f, 1.72532946e-01f, -1.46673188e-01f, -1.30024940e-01f, -2.90441215e-01f, 9.48350549e-01f, 3.96180421e-01f, 3.10426682e-01f,
  7.62460157e-02f, -5.43881893e-01f, -3.74934614e-01f, 1.75879657e-01f, -9.19519737e-03f, -3.86747152e-01f, -3.62562835e-01f, -1.82363510e-01f, -2.59006441e-01f, -4.82512504e-01f,
  1.58128545e-01f, -2.86926925e-01f, 4.59903806e-01f, -7.65257403e-02f, 3.34464937e-01f, -1.68581411e-01f, 7.16598332e-01f, -1.59046218e-01f, -6.22035414e-02f, 9.16228116e-01f,
  -9.59331915e-02f, 1.98021069e-01f, 4.15248759e-02f, 1.71789572e-01f, -4.59052846e-02f, -9.86812636e-02f, -6.32055625e-02f, 3.12610000e-01f, -1.93136185e-01f, -1.63725957e-01f,
  1.52520388e-01f, 1.59585755e-02f, -2.04274222e-01f, -3.39823812e-01f, -1.42473459e-01f, -2.10798323e-01f, -2.66580265e-02f, 3.71020794e-01f, -1.32756010e-01f, -7.67372921e-03f,
  2.86783129e-01f, -3.18869680e-01f, -5.87051213e-01f, 2.16424659e-01f, 2.24402979e-01f, 4.17242289e-01f, 6.39839232e-01f, 4.93891001e-01f, -2.80694485e-01f, 5.59569299e-01f,
  -1.78037897e-01f, -2.42945120e-01f, 5.94582297e-02f, 5.67338690e-02f, 3.93110933e-03f, 9.11221027e-01f, -1.80323273e-01f, -2.07242653e-01f, -5.36025092e-02f, 1.69783875e-01f,
  3.30419540e-01f, -5.59627265e-02f, 1.07028568e+00f, -2.28786245e-01f, -2.23736554e-01f, -5.24408877e-01f, -2.03979164e-01f, -3.61195743e-01f, -2.29640510e-02f, 4.66800034e-02f,
  -9.35756490e-02f, -5.01410842e-01f, 2.95413882e-01f, -5.11841774e-01f, 3.58376920e-01f, -5.96099615e-01f, -5.43618262e-01f, -4.52225924e-01f, 2.74857461e-01f, -6.13444805e-01f,
  -8.75363424e-02f, -1.79848820e-01f, -3.06537718e-01f, -9.19514000e-02f, -3.11117709e-01f, -3.70191962e-01f, 2.91558862e-01f, 1.42577225e-02f, 1.34572339e+00f, -7.28173880e-03f,
  -5.37547749e-03f, -1.42244726e-01f, 1.54695466e-01f, -5.94806552e-01f, -3.33158791e-01f, -8.09577703e-02f, 3.08106601e-01f, 2.00199127e-01f, 1.44021437e-01f, -3.77285816e-02f,
  -5.97312525e-02f, -2.64724314e-01f, 1.28604069e-01f, 6.98177936e-03f, -2.06181362e-01f, 8.36491585e-02f, 6.30156755e-01f, 5.16700089e-01f, 5.39053492e-02f, -7.63323426e-01f,
  -6.32879376e-01f, 5.53102791e-01f, 2.12567188e-02f, 3.69573355e-01f, -2.60058910e-01f, -1.11959629e-01f, 1.03492165e+00f, -6.02744333e-02f, -1.90521508e-01f, 6.15107954e-01f,
  -2.61320025e-01f, -1.50693312e-01f, -3.27580445e-03f, -5.48516251e-02f, -6.01092838e-02f, -1.81202397e-01f, -1.86437532e-01f, -6.58589303e-02f, -1.09817751e-01f, -5.00711381e-01f,
  -1.81864291e-01f, -4.37147886e-01f, 3.25521678e-01f, 2.44261175e-01f, 2.47707933e-01f, 1.45402431e-01f, -2.32905522e-01f, 1.40897676e-01f, -1.94846272e-01f, -3.06626230e-01f,
  -3.08963478e-01f, 6.14581645e-01f, 3.77858639e-01f, 8.11983347e-02f, 6.45766873e-03f, -3.38975787e-01f, -2.23312318e-01f, -2.95108020e-01f, -1.43569857e-01f, 9.17523742e-01f,
  -4.70957398e-01f, -8.35130289e-02f, -2.73801744e-01f, -3.09720248e-01f, -9.15869474e-02f, -1.48595363e-01f, 1.74715236e-01f, 6.67582512e-01f, -1.83586270e-01f, 6.45943463e-01f,
  5.20706773e-01f, -4.42774564e-01f, 2.93894380e-01f, -2.38341734e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.60537844e-02f, 9.45951045e-02f, 2.36685023e-01f, -2.03243718e-01f, -4.53505889e-02f, 8.25169403e-03f, 1.51530370e-01f, -3.59617978e-01f, 1.04895659e-01f, 1.72746807e-01f,
  2.21235946e-01f, -8.47806036e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        32, 12
    );
    }
    