/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -4.87172514e-01f, 8.37616250e-03f, 6.44831210e-02f, -1.69955388e-01f, -2.52292186e-01f, -4.87209670e-02f, -1.89582214e-01f, -4.30564731e-02f, -2.47566625e-01f, -4.25752886e-02f,
  -9.19330269e-02f, -1.18022487e-02f, -1.14841424e-02f, 1.39958318e-02f, -2.58870453e-01f, 6.88317865e-02f, -1.59219459e-01f, -7.47655258e-02f, -5.32798795e-03f, -1.43881068e-01f,
  -5.64629920e-02f, -2.69174397e-01f, 2.73647457e-02f, 1.80433728e-02f, -2.08629817e-01f, 2.42301216e-03f, -5.74800409e-02f, 7.58860931e-02f, 1.55467927e-01f, 2.25106883e-03f,
  -4.92606573e-02f, 3.79207022e-02f, 5.01048304e-02f, 7.26648327e-03f, 2.89500039e-02f, 2.94151101e-02f, 5.21845818e-02f, 6.07486442e-02f, -2.12269798e-02f, 5.82150705e-02f,
  -7.12588802e-02f, -3.41185443e-02f, -8.34409148e-02f, -5.58631122e-02f, -1.10129178e-01f, -1.85516682e-02f, 3.84321529e-03f, -4.68520671e-02f, 2.57293303e-02f, 3.27665498e-03f,
  9.07046869e-02f, 4.75847833e-02f, -1.98166762e-02f, -8.44725687e-03f, 9.44671687e-04f, -3.72363930e-03f, 1.11946031e-01f, -2.23778617e-02f, -9.95960925e-03f, -3.45787443e-02f,
  4.96971831e-02f, 4.67343777e-02f, -4.92640631e-03f, 1.08396262e-02f, 3.89512740e-02f, -2.51354240e-02f, -1.54682742e-02f, -6.55353069e-03f, 2.08181888e-02f, -5.54600358e-03f,
  -1.80933217e-03f, 4.30394802e-03f, -4.29405309e-02f, 4.29255841e-03f, -4.45352048e-02f, -1.62769053e-02f, -1.50875449e-02f, -3.76747618e-03f, -6.70014992e-02f, -6.44673128e-03f,
  2.69905832e-02f, -4.45033647e-02f, 6.20969459e-02f, -4.06760350e-03f, 4.50606830e-02f, 4.17147465e-02f, 9.02016554e-03f, 2.45831013e-02f, 6.36791959e-02f, -5.91075271e-02f,
  -4.94244933e-01f, -1.55498773e-01f, -2.32237037e-02f, -3.80822807e-03f, 1.87125592e-03f, 1.07297916e-02f, -7.22630844e-02f, -3.78168598e-02f, -4.16162349e-02f, -8.86273682e-02f,
  3.35845537e-03f, 2.08606198e-02f, 3.69680077e-02f, -2.27590464e-02f, 3.46460640e-02f, -3.86287794e-02f, -2.07531992e-02f, 8.91727954e-03f, -1.55746281e-01f, -3.45016718e-02f,
  -4.94572744e-02f, -3.93114835e-02f, 3.75282317e-02f, 2.06513181e-02f, -3.47770751e-02f, -2.15165298e-02f, -9.82010365e-02f, 3.15757729e-02f, 1.52788311e-02f, -1.26224924e-02f,
  -6.29675806e-01f, 3.45893353e-01f, -2.22352117e-01f, -1.64205685e-01f, -1.83461651e-01f, 1.21877372e-01f, -1.29232123e-01f, -8.23237449e-02f, -2.31636673e-01f, 1.01356566e-01f,
  -1.70019045e-01f, 1.10522613e-01f, -1.02056436e-01f, 7.24904835e-02f, -1.78313330e-01f, 1.30988002e-01f, -5.00301644e-02f, -4.55685705e-03f, 5.44929318e-02f, -4.23726737e-02f,
  -6.62427619e-02f, 1.62965769e-03f, -4.10941392e-02f, 8.05192888e-02f, -8.86192843e-02f, -4.35744692e-03f, -8.68588686e-02f, 3.03073926e-03f, 5.89133501e-02f, 2.22330242e-02f,
  4.55223098e-02f, -1.93113446e-01f, -1.08179515e-02f, 1.75731853e-02f, -1.21700943e-01f, -8.42909664e-02f, 4.34426181e-02f, -1.63308084e-02f, -5.55460677e-02f, -2.64553586e-03f,
  2.93516424e-02f, 1.46178361e-02f, 2.31380407e-02f, -2.08035111e-02f, 3.24158967e-02f, 2.38065440e-02f, 1.28476277e-01f, 5.43390401e-02f, 4.49563563e-02f, 1.36367321e-01f,
  4.97325473e-02f, 8.86668563e-02f, 1.48797492e-02f, 4.20362838e-02f, 2.53236443e-02f, 8.14346876e-03f, 4.14811773e-03f, -4.18549329e-02f, 2.32477374e-02f, 4.76467609e-02f,
  3.55414152e-02f, -3.74760963e-02f, -6.55844528e-03f, -2.81088501e-02f, 4.69792821e-03f, -3.87756824e-02f, -5.52378083e-03f, -9.92604624e-03f, -1.89745743e-02f, -3.16375941e-02f,
  -4.63647805e-02f, -3.89399566e-02f, -3.93028706e-02f, -4.87537542e-03f, -1.68037526e-02f, -3.27288099e-02f, 1.03274081e-03f, -1.26556167e-02f, -2.02724598e-02f, -2.77690153e-04f,
  -8.62665195e-03f, -8.54385458e-03f, -3.00174579e-02f, -2.09254809e-02f, -1.23094860e-02f, 3.23942513e-03f, -4.22722846e-02f, 2.42474470e-02f, -4.66292910e-02f, 1.69312228e-02f,
  1.27657518e-01f, -1.40252173e-01f, -3.93467210e-02f, -4.43136841e-02f, 1.09781854e-01f, 7.79443756e-02f, -3.47896293e-02f, 1.92011185e-02f, 9.07415748e-02f, -8.91512558e-02f,
  -4.24338020e-02f, -2.72101946e-02f, -3.78380306e-02f, 2.04078164e-02f, 4.60632555e-02f, 3.41181643e-02f, -8.85676891e-02f, 5.01180068e-03f, -2.75028404e-02f, 2.51290817e-02f,
  1.65357459e-02f, -7.34115690e-02f, 1.84173696e-02f, -2.94517316e-02f, -1.00378888e-02f, -4.44719307e-02f, -3.91903706e-02f, 3.13210748e-02f, 8.32654256e-03f, 4.03578132e-02f,
  -3.61239836e-02f, -4.14838076e-01f, -7.23475143e-02f, 1.91214859e-01f, -6.33052066e-02f, 6.78886499e-05f, 2.96746999e-01f, -1.98408067e-01f, -3.52051467e-01f, 4.25724983e-02f,
  1.68822095e-01f, -2.16920655e-02f, 9.42058116e-03f, 1.51404694e-01f, 3.12052488e-01f, -1.57311305e-01f, 7.56523311e-02f, 7.24536479e-02f, -2.75448859e-01f, 1.54723883e-01f,
  -2.91176960e-02f, 3.46086115e-01f, -1.73434871e-03f, 6.99225515e-02f, 7.38699734e-02f, -7.18174577e-02f, 1.90950155e-01f, -1.67059854e-01f, 1.10084094e-01f, -1.75473969e-02f,
  1.30072191e-01f, -7.60910334e-03f, 8.95713717e-02f, -4.42641489e-02f, -5.65727800e-02f, 1.48971360e-02f, 1.74859222e-02f, 8.02370682e-02f, 2.82653943e-02f, -7.21859708e-02f,
  -6.65267697e-03f, 3.00948657e-02f, -8.08839872e-02f, 1.87955685e-02f, -1.16891712e-01f, -1.95134711e-02f, -4.97586541e-02f, 1.72849167e-02f, 6.34833947e-02f, 7.09563643e-02f,
  3.04182358e-02f, -9.28018764e-02f, 5.12160920e-02f, -2.21911687e-02f, 8.96560326e-02f, 7.10895844e-03f, 4.22440991e-02f, -1.54007692e-02f, -1.04070812e-01f, 1.06649501e-02f,
  -6.95664734e-02f, -3.16359401e-02f, -1.88734662e-02f, -8.08150321e-02f, 4.64376621e-02f, -3.97705995e-02f, 5.46160378e-02f, 4.58727852e-02f, 1.83304567e-02f, 1.94280911e-02f,
  -1.43261044e-03f, -7.82625098e-03f, -4.71934900e-02f, 5.48052564e-02f, 4.17413488e-02f, 5.98412715e-02f, -7.02927820e-03f, 2.10639890e-02f, -6.77090436e-02f, 1.61465667e-02f,
  -8.44600350e-02f, -5.07160909e-02f, 6.72269389e-02f, -1.86612606e-02f, -2.97354045e-03f, 3.35535258e-02f, -2.80566681e-02f, -3.98822278e-02f, -1.75781418e-02f, 3.50794569e-02f,
  -3.17618847e-02f, -1.81180552e-01f, -2.97639593e-02f, 8.02396685e-02f, -1.18698915e-02f, 2.37564445e-02f, -9.80912894e-02f, -1.19824419e-02f, -3.69717404e-02f, 6.65159849e-03f,
  1.32155828e-02f, 1.39338635e-02f, 6.32041395e-02f, -4.89663566e-03f, 2.61437073e-02f, 2.85333488e-02f, -1.26203364e-02f, -1.69614386e-02f, 4.66551399e-03f, 8.37368798e-03f,
  5.01886718e-02f, 4.08045063e-03f, 4.72335797e-03f, 3.62851955e-02f, 2.84655057e-02f, 5.15428074e-02f, -9.75242630e-03f, -1.45772817e-02f, 5.30946180e-02f, -9.18739364e-02f,
  1.12767734e-01f, -1.97905645e-01f, 2.25497931e-01f, 1.21434825e-02f, -2.36010831e-02f, -3.84226650e-01f, -1.27656370e-01f, -9.59423706e-02f, 1.20958813e-01f, -2.27760136e-01f,
  -2.56816540e-02f, 1.23708263e-01f, 8.66716728e-02f, -3.00975144e-01f, -4.31543626e-02f, 2.22184449e-01f, -2.45697811e-01f, -1.02413900e-01f, 1.34536192e-01f, -2.24344194e-01f,
  6.50324151e-02f, -1.99037895e-01f, 1.38316944e-01f, -1.68131337e-01f, -1.73866987e-01f, 5.47461100e-02f, 2.74884272e-02f, 8.17815214e-02f, -2.32608750e-01f, -1.37084723e-02f,
  -1.81573316e-01f, 9.53640118e-02f, 8.44089538e-02f, -2.79826783e-02f, -1.08106278e-01f, -1.86892855e-03f, -5.83455898e-03f, 1.19598834e-02f, 4.43213321e-02f, -5.27509786e-02f,
  -2.13748924e-02f, 8.60319361e-02f, 1.22397449e-02f, 1.82672553e-02f, 1.51981292e-02f, 3.19847800e-02f, 6.03820644e-02f, -1.78104732e-02f, -2.50184257e-02f, 2.22479105e-02f,
  1.72609705e-02f, 8.93952907e-04f, -6.60258159e-02f, 5.14849089e-03f, 6.72857417e-03f, -2.81929430e-02f, 3.86651196e-02f, -1.84404552e-02f, 1.83344036e-02f, -1.06378039e-02f,
  8.01620632e-02f, -7.84508586e-02f, 3.98192517e-02f, -5.29079922e-02f, -1.85606349e-02f, 1.25834011e-02f, -7.34466761e-02f, 1.75718330e-02f, -2.39939690e-02f, -3.73117216e-02f,
  -4.99330163e-02f, -4.61973017e-03f, -9.81906988e-03f, -1.61457825e-02f, -3.21454853e-02f, -5.23336716e-02f, 1.39652146e-02f, -2.41008848e-02f, 2.09534075e-02f, -4.40462083e-02f,
  -1.62017103e-02f, -3.33648026e-02f, -3.53643335e-02f, -2.70418208e-02f, -7.28007779e-03f, 3.80408689e-02f, -2.76654996e-02f, 3.87844141e-03f, -1.96716692e-02f, -2.36582942e-02f,
  -3.61416787e-01f, -2.54277527e-01f, -2.88879778e-02f, 1.89511117e-03f, 2.67798007e-02f, -8.63555167e-03f, 4.38514240e-02f, -4.50016670e-02f, 4.07192111e-02f, -6.21479237e-03f,
  1.13227312e-02f, -6.09824248e-02f, -9.42183658e-03f, 2.96322573e-02f, 2.48521082e-02f, -3.69498916e-02f, -2.21912190e-02f, 1.17955124e-02f, -1.22618740e-02f, -4.58157323e-02f,
  -2.93547325e-02f, 3.07296924e-02f, 7.02919764e-03f, 3.29097174e-02f, -1.14864781e-02f, 3.52998450e-03f, -1.34374863e-02f, 5.51932491e-02f, -6.50849938e-02f, -3.87561647e-03f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.98161861e-02f, -2.69250602e-01f, -3.59141141e-01f, -3.29408586e-01f, -2.44632941e-02f, -3.99918139e-01f, -4.09679085e-01f, -1.34664997e-01f, -7.98179582e-02f, 1.71845630e-01f,
  -1.09898388e-01f, -8.26808158e-03f, 6.73405081e-02f, -4.22648311e-01f, -4.66997653e-01f, -2.27651615e-02f, -4.53049690e-01f, -1.98065206e-01f, -1.47352675e-02f, -5.82102910e-02f,
  -7.54829198e-02f, -1.53614521e-01f, -2.44944036e-01f, 8.91601443e-02f, -1.86762974e-01f, 1.32836372e-01f, 2.27415830e-01f, 3.63653824e-02f, -1.38649881e-01f, -1.45179212e-01f,
  1.31724328e-02f, 1.70921147e-01f, -9.66586992e-02f, -2.22711936e-02f, 8.49667341e-02f, 8.45313445e-02f, -5.66530041e-02f, 1.10708453e-01f, -8.31229538e-02f, -1.80720627e-01f,
  8.97207111e-02f, 1.32735353e-02f, -7.70184770e-03f, -7.61089623e-02f, -2.18508504e-02f, -4.39996570e-02f, -6.09201789e-02f, -6.75832108e-02f, -4.22509946e-02f, -2.97429170e-02f,
  -8.18592981e-02f, -7.18736649e-02f, -3.63049582e-02f, -9.14998259e-03f, -4.71012034e-02f, 4.67611104e-02f, -4.71143536e-02f, 1.02873351e-02f, -1.03718992e-02f, 6.82033896e-02f,
  -2.83042784e-04f, -3.08340471e-02f, 8.46406370e-02f, -9.25983638e-02f, 8.87321588e-03f, 3.10118292e-02f, -1.50202028e-02f, 2.53070574e-02f, -1.77908670e-02f, -2.81612687e-02f,
  1.93973095e-03f, -2.93738861e-02f, 2.88257170e-02f, -1.05312616e-01f, 3.36372070e-02f, 8.66515487e-02f, 3.46660651e-02f, -6.93479180e-02f, -1.25847114e-02f, -1.19607702e-01f,
  1.17504202e-01f, -3.99462990e-02f, -1.90299153e-02f, 6.44981721e-03f, -1.21020637e-02f, 5.85953891e-02f, 6.72658626e-03f, -3.44825201e-02f, -1.27082150e-02f, -2.53406484e-02f,
  -4.13852604e-03f, -6.46263286e-02f, -2.86124391e-03f, -1.06337719e-01f, 1.30836684e-02f, -3.58166173e-03f, 6.07132241e-02f, 4.55429852e-02f, -5.33165522e-02f, 4.54875492e-02f,
  7.89766312e-02f, 4.03964706e-02f, 5.80231473e-02f, -2.31061690e-02f, -8.66195187e-02f, 4.71325479e-02f, 3.60109434e-02f, 4.01720442e-02f, -1.73444316e-01f, 3.87723669e-02f,
  2.89143864e-02f, 5.00607900e-02f, -4.82281074e-02f, 5.90888970e-02f, 1.07526429e-01f, 3.79305705e-02f, -4.44061169e-03f, 2.59004086e-02f, 3.26106176e-02f, 2.96325050e-03f,
  1.06837370e-01f, 2.27243409e-01f, -2.28111446e-02f, -3.02114873e-03f, 3.51368785e-01f, -3.66216123e-01f, -9.28705707e-02f, 8.72598961e-02f, 1.34822249e-01f, 4.83609959e-02f,
  -1.14400864e-01f, 1.39936030e-01f, -9.26925167e-02f, -1.41909972e-01f, -7.88127244e-01f, -3.41575056e-01f, -4.53061193e-01f, -1.39205620e-01f, -1.11769967e-01f, 1.86938539e-01f,
  -1.95632547e-01f, -1.35211730e-02f, -2.82814562e-01f, 2.75838763e-01f, 1.52796268e-01f, 1.88256979e-01f, -1.23029634e-01f, 1.76214367e-01f, -2.56549777e-03f, 2.86558252e-02f,
  3.01443841e-02f, 2.74930060e-01f, 6.32594526e-02f, 1.68704577e-02f, -1.37121156e-01f, 3.15519646e-02f, -6.77456930e-02f, 6.01628311e-02f, 1.07783817e-01f, 2.89653651e-02f,
  7.34797567e-02f, 1.94434077e-02f, 6.73396289e-02f, 1.12118147e-01f, 1.47959217e-01f, 8.90327320e-02f, -8.13470781e-03f, -4.85299081e-02f, 1.08450271e-01f, 2.96810027e-02f,
  8.40419829e-02f, -3.71561875e-03f, -4.18741331e-02f, 4.18240204e-03f, 3.60098146e-02f, 6.30951822e-02f, -7.00458959e-02f, 2.78439354e-02f, -5.09198867e-02f, -8.35030898e-03f,
  -4.21131849e-02f, -4.05103527e-02f, -8.44337195e-02f, 3.70097645e-02f, 6.24880828e-02f, -2.57298467e-03f, 3.63000715e-03f, -9.91117582e-02f, 5.42896427e-02f, -1.02907820e-02f,
  -7.17980741e-03f, 3.52308825e-02f, 5.86986765e-02f, -4.58384790e-02f, -7.95667246e-02f, 1.89129673e-02f, -1.04993150e-01f, 1.29647583e-01f, 2.01675063e-03f, -1.98704563e-03f,
  3.61598656e-02f, 7.24556856e-03f, 6.47350028e-02f, -3.54026482e-02f, -2.91211456e-02f, -5.35547473e-02f, -3.97790968e-02f, 1.66201741e-02f, -1.18571848e-01f, -2.09664926e-02f,
  -4.11478668e-01f, -1.93899348e-01f, -2.82847900e-02f, 5.86472154e-02f, 1.74697749e-02f, 2.83857659e-02f, -9.03250873e-02f, 7.74968937e-02f, -9.77585092e-02f, -2.48768590e-02f,
  5.54608032e-02f, 2.32339464e-02f, -1.00983657e-01f, 3.48070376e-02f, -1.16715543e-01f, -7.35164657e-02f, 1.05068013e-02f, 2.03381758e-02f, -1.52526284e-02f, 4.06603105e-02f,
  3.12603973e-02f, 1.51128784e-01f, 6.81692436e-02f, -5.69952689e-02f, -3.38842091e-03f, -1.56588070e-02f, 6.98100822e-03f, 6.27084374e-02f, 4.32131477e-02f, -9.58365500e-02f,
  -7.41575003e-01f, -6.33128509e-02f, -3.32873285e-01f, -4.67853285e-02f, -2.45618135e-01f, -1.63967595e-01f, -3.85178439e-02f, -9.30688083e-02f, -1.42188266e-01f, 5.92234612e-01f,
  3.37203503e-01f, -3.35731149e-01f, 1.88495159e-01f, 1.29983842e-01f, -5.93451619e-01f, -1.61192957e-02f, -2.49480661e-02f, 1.46018386e-01f, -1.40092984e-01f, -1.32102787e-01f,
  -8.82178247e-02f, 1.14999656e-02f, -8.46690908e-02f, -6.24836013e-02f, -8.26545246e-03f, 1.64439023e-01f, 3.07988107e-01f, -7.44658560e-02f, 3.68813425e-02f, -1.41913131e-01f,
  6.68732524e-02f, 1.62303731e-01f, 2.00527404e-02f, -6.40058368e-02f, -6.52263686e-03f, 5.07515185e-02f, -3.72048579e-02f, -6.11991584e-02f, -1.19245350e-02f, -7.66274408e-02f,
  -4.51008081e-02f, -5.19045144e-02f, -3.23190726e-02f, -2.73197275e-02f, -3.40037979e-02f, 1.12583032e-02f, -9.02149007e-02f, -5.11616059e-02f, 2.13316120e-02f, -7.45601356e-02f,
  -8.02395195e-02f, 3.37405950e-02f, 5.26291318e-02f, -6.06675595e-02f, -6.32512867e-02f, 1.15251914e-02f, 1.59500707e-02f, -8.01465288e-02f, -1.28279766e-02f, -3.26338746e-02f,
  -6.88827112e-02f, -1.13470368e-02f, -3.24161761e-02f, 1.15657732e-01f, -3.10179368e-02f, 7.03909174e-02f, -8.97295997e-02f, 6.92177862e-02f, -3.26339751e-02f, 4.80176844e-02f,
  6.18152618e-02f, -6.66200146e-02f, 4.11770819e-03f, 3.69692408e-02f, -3.69814225e-02f, 7.72375241e-02f, -2.01421585e-02f, -5.08436374e-03f, 7.11027533e-02f, 1.96964927e-02f,
  1.92904472e-02f, -3.82193178e-02f, 2.10822988e-02f, 1.23712182e-01f, 9.63392522e-05f, -2.89007463e-02f, 1.54462367e-01f, -4.17110287e-02f, 5.32999709e-02f, -3.96002755e-02f,
  -4.44991551e-02f, -2.89738812e-02f, 4.97389548e-02f, 5.54822162e-02f, 8.99026170e-02f, -6.77965432e-02f, -1.78593025e-02f, -1.00717679e-01f, 1.98534336e-02f, 8.18737224e-03f,
  2.58306600e-02f, 4.38311622e-02f, -2.73639578e-02f, 3.52051668e-02f, -3.34782265e-02f, 1.66105460e-02f, 1.38679728e-01f, 2.50394884e-02f, 5.44743873e-02f, -1.04360431e-01f,
  -3.71918990e-03f, 1.01403696e-02f, -1.21854171e-01f, 5.67733087e-02f, 6.08341070e-04f, 1.07643738e-01f, -1.65609755e-02f, 5.42522110e-02f, -9.35988966e-04f, 6.16754629e-02f,
  6.83310807e-01f, 8.78196210e-02f, 4.37493213e-02f, 3.02691877e-01f, 1.17438689e-01f, -1.86363906e-01f, 4.38496806e-02f, 1.06750913e-01f, 3.58221889e-01f, 2.01374907e-02f,
  -1.11460090e-02f, 3.25873196e-02f, -1.68051019e-01f, 1.06982470e-01f, -3.42720151e-01f, -1.77728191e-01f, 1.85393170e-02f, 6.17625415e-02f, 3.63395661e-02f, 1.32610351e-01f,
  1.61710963e-01f, -2.08248287e-01f, -1.91674262e-01f, -2.04644397e-01f, 1.95473924e-01f, 1.06287867e-01f, -1.65465787e-01f, -1.35443732e-01f, -4.14790213e-02f, -1.10156357e-01f,
  6.81819692e-02f, 1.71377838e-01f, 7.65974820e-02f, -7.73729831e-02f, 8.77803043e-02f, 1.98483709e-02f, -2.98979189e-02f, -1.39008820e-01f, 5.99271096e-02f, -5.55072129e-02f,
  -2.07837131e-02f, -2.00413018e-02f, 7.89673999e-02f, -3.78093943e-02f, 7.89494291e-02f, 3.06428857e-02f, 7.89407194e-02f, 1.53910860e-01f, 3.35109942e-02f, 8.10881034e-02f,
  4.88916300e-02f, -2.35626977e-02f, 4.31388393e-02f, -2.48699654e-02f, 3.57545447e-03f, 3.09749041e-02f, -1.43304616e-02f, -9.78933647e-02f, -2.03145593e-02f, 3.19072008e-02f,
  -4.16107737e-02f, -3.08588333e-02f, -4.32088524e-02f, -4.08094153e-02f, -7.72940461e-03f, 1.53366663e-02f, -4.95830514e-02f, -1.73356906e-02f, 1.60306096e-02f, -3.97053435e-02f,
  1.55484434e-02f, 1.15886694e-02f, -1.32532800e-02f, 6.67296201e-02f, 1.57504864e-02f, 7.83833042e-02f, -4.76229936e-02f, 6.12599496e-03f, 2.51047928e-02f, 2.27408148e-02f,
  -1.76939163e-02f, -2.88430471e-02f, -1.25822816e-02f, -3.89599465e-02f, 3.92548442e-02f, 7.08106719e-03f, 5.19246385e-02f, 8.19465518e-02f, -1.47414552e-02f, -1.05259553e-01f,
  -3.70067242e-03f, -2.49212518e-01f, -3.60089503e-02f, 8.09552241e-03f, -4.46808478e-03f, 4.41991165e-02f, -7.58879306e-03f, 8.68252814e-02f, -3.55235934e-02f, -4.96492125e-02f,
  2.91102976e-02f, 5.16852215e-02f, -2.15161052e-02f, 1.92780644e-02f, -7.26399496e-02f, 2.53379513e-02f, -6.47373945e-02f, -3.52267437e-02f, -7.47729465e-02f, -3.50730121e-02f,
  1.10378340e-02f, 3.47231817e-03f, -1.79419166e-03f, 2.16621701e-02f, 3.92223820e-02f, -3.55209224e-02f, 9.19755325e-02f, 8.73977377e-04f, -7.13231266e-02f, -7.67440796e-02f,
  9.61950049e-02f, 1.63573045e-02f, 1.80809304e-01f, 3.44535232e-01f, -6.81328028e-03f, -2.28972867e-01f, -2.64516890e-01f, -5.76886125e-02f, -2.09620655e-01f, -1.11151412e-01f,
  -1.29800037e-01f, 1.97158098e-01f, -5.40731966e-01f, 3.29309225e-01f, -1.40083447e-01f, -4.23212111e-01f, -2.06333660e-02f, 6.61550686e-02f, -1.03745095e-01f, -4.66894498e-03f,
  2.85052676e-02f, -1.13491155e-01f, 1.69336095e-01f, 9.14689153e-02f, 1.22628070e-01f, 2.69834369e-01f, 1.13501631e-01f, 7.82743990e-02f, 4.84852314e-01f, 7.63811022e-02f,
  3.01957298e-02f, -7.68939927e-02f, 1.40474722e-01f, -4.05782834e-02f, -2.81535052e-02f, 7.52169341e-02f, 9.15326178e-02f, 7.48155490e-02f, 1.17479719e-01f, -5.27493954e-02f,
  -7.78625980e-02f, 1.27920350e-02f, 1.10511154e-01f, -2.10613068e-02f, 8.97932053e-02f, 1.52945012e-01f, 9.10637081e-02f, 8.70464146e-02f, 8.10737461e-02f, 9.44318250e-02f,
  6.37905896e-02f, 6.29639402e-02f, 8.09220672e-02f, -1.41570680e-02f, -8.42041448e-02f, -9.08203870e-02f, 7.84977600e-02f, 7.43689239e-02f, 3.56956422e-02f, 3.75676192e-02f,
  -1.21172946e-02f, -6.61589801e-02f, -7.15809315e-02f, 6.27002269e-02f, -1.87552869e-02f, -2.43886150e-02f, -3.22982743e-02f, 5.18151894e-02f, -4.09687385e-02f, -6.88093677e-02f,
  -1.80065613e-02f, 5.33467047e-02f, -2.13932768e-02f, 4.39350493e-02f, -1.40043333e-01f, 3.37290834e-03f, -1.32027827e-02f, -3.58125940e-02f, 3.38907167e-02f, 1.24344938e-01f,
  -1.25772461e-01f, -1.19532691e-02f, -6.09647185e-02f, 1.01923496e-01f, 5.25970850e-03f, -7.68429339e-02f, -5.48815131e-02f, -6.13974929e-02f, 2.97496817e-03f, 5.15797734e-02f,
  -1.97504565e-01f, -1.57439008e-01f, -2.44834553e-02f, 5.61825782e-02f, 4.29481454e-02f, -5.08345179e-02f, -4.37944342e-04f, -8.13111756e-03f, -3.76445241e-02f, 1.08313991e-03f,
  -9.28094424e-03f, 8.09839442e-02f, -1.17678322e-01f, 4.41403352e-02f, -4.25541922e-02f, -1.29383281e-01f, 1.52362902e-02f, 1.32001592e-02f, 6.66355193e-02f, 8.17819014e-02f,
  3.69637460e-02f, -1.65726572e-01f, -1.34937919e-03f, 2.05253866e-02f, 4.02630232e-02f, -3.71814892e-02f, -1.66023374e-02f, -3.49646062e-02f, 1.16785966e-01f, 9.32071880e-02f,
  3.60809535e-01f, 4.67044413e-01f, 2.93613076e-01f, 3.75853777e-01f, -2.99346864e-01f, -6.02739036e-01f, -3.37822407e-01f, 1.49566278e-01f, -1.20851547e-01f, 8.45919102e-02f,
  -8.75954255e-02f, 3.54549646e-01f, -4.99311090e-02f, 2.52544224e-01f, -2.70586550e-01f, -1.92735583e-01f, 1.03498667e-01f, 1.85332503e-02f, -3.12113836e-02f, 2.57293433e-01f,
  4.71172146e-02f, -1.43570125e-01f, 3.14693093e-01f, -3.57798003e-02f, 1.44588545e-01f, 2.74318427e-01f, 1.89643681e-01f, -7.01406449e-02f, 2.75248080e-01f, -4.82630655e-02f,
  -2.11558238e-01f, 4.74537238e-02f, 1.89726695e-01f, -5.47253825e-02f, 3.71513329e-02f, -2.43017543e-02f, -2.93779988e-02f, -8.73948410e-02f, -9.87516120e-02f, 7.64564350e-02f,
  5.34477457e-03f, -4.39471900e-02f, -1.25063965e-02f, -7.15153068e-02f, -8.18868876e-02f, 5.41027486e-02f, 5.74387573e-02f, 6.09195717e-02f, -6.44597225e-03f, -2.35783383e-02f,
  4.81814221e-02f, 1.20357215e-01f, -4.02463377e-02f, 7.28694210e-03f, 1.40803769e-01f, 5.50278611e-02f, -1.16527334e-01f, -3.10736685e-03f, -1.98531710e-02f, 4.96220775e-02f,
  -9.49058384e-02f, -2.98826918e-02f, 5.14107570e-02f, 3.60850617e-02f, 3.07386536e-02f, -4.20722067e-02f, 7.01154843e-02f, -7.32115358e-02f, 6.30603284e-02f, -5.99508267e-03f,
  3.61676030e-02f, 8.50014330e-04f, -5.63515574e-02f, 2.31942087e-02f, -4.65363897e-02f, -5.96456081e-02f, 1.33173810e-02f, -8.69351998e-02f, 4.27808845e-03f, -4.64392267e-02f,
  -2.53355466e-02f, -7.72483996e-04f, 5.97525351e-02f, 7.82399252e-03f, -1.06267303e-01f, 6.10176055e-03f, 1.08688977e-02f, 8.34403187e-02f, 2.69423071e-02f, -3.34525257e-02f,
  -6.94299191e-02f, 2.43192151e-01f, 4.67751548e-02f, -5.12236170e-02f, 2.45921966e-02f, -5.27019948e-02f, -5.29920310e-02f, 7.74570256e-02f, 5.70408292e-02f, -7.52471983e-02f,
  3.03224381e-02f, -2.83308681e-02f, -5.50024733e-02f, 3.87287186e-03f, -1.46973459e-02f, -2.89207194e-02f, 6.33915886e-04f, 8.93003643e-02f, 6.08776398e-02f, 5.63155711e-02f,
  8.32432881e-02f, -9.65450332e-02f, -1.18148401e-02f, 4.08732183e-02f, -3.46101113e-02f, -2.95107681e-02f, -4.17044945e-02f, -3.75444442e-02f, -1.62221678e-02f, -1.45176183e-02f,
  -8.86619315e-02f, 2.94251032e-02f, -1.99424341e-01f, 1.24207251e-01f, -1.11144528e-01f, -1.72524825e-01f, -4.11106527e-01f, -1.29134491e-01f, 2.34907821e-01f, 1.28073648e-01f,
  -1.19101234e-01f, 3.68667096e-01f, -3.92190591e-02f, -3.59260887e-01f, 1.59794420e-01f, 3.01209353e-02f, -2.08909214e-01f, 1.39823869e-01f, 9.92702618e-02f, -1.69969216e-01f,
  3.01997028e-02f, -2.72235006e-01f, -2.79776126e-01f, -1.73545748e-01f, -4.32088614e-01f, -4.26303037e-02f, -1.44684303e-03f, -1.87419027e-01f, -2.16489181e-01f, -4.48978357e-02f,
  -1.26498073e-01f, -6.36784658e-02f, -8.19990188e-02f, 7.22201094e-02f, -1.21086612e-01f, -1.20239966e-02f, -3.79555253e-03f, -6.73051504e-03f, 3.56636792e-02f, 3.23226079e-02f,
  3.56651321e-02f, 1.05426341e-01f, 7.75928646e-02f, 3.52986380e-02f, -7.87437335e-02f, -3.76593284e-02f, -1.93861518e-02f, -1.07792214e-01f, 4.90353666e-02f, -8.92096013e-02f,
  -2.47199293e-02f, -2.99820658e-02f, -6.41567037e-02f, 8.66175890e-02f, 1.85728353e-02f, 4.71946364e-03f, 1.03281803e-01f, -1.08724244e-01f, 7.30964020e-02f, 7.48055801e-02f,
  -5.02204187e-02f, 4.85456251e-02f, -8.92132968e-02f, 2.32214741e-02f, -1.98648795e-02f, 2.33717896e-02f, 5.72198778e-02f, -5.14139943e-02f, 7.80831054e-02f, -7.49586150e-02f,
  9.97467618e-03f, -3.59994248e-02f, -3.00213639e-02f, 3.89315002e-02f, -1.86409266e-03f, 1.07237130e-01f, -4.89882380e-02f, 1.25509426e-02f, 2.15829108e-02f, 1.08856730e-01f,
  -1.01012848e-01f, -1.05881598e-02f, -3.03621683e-02f, -8.20892453e-02f, 1.51046794e-02f, -1.15737170e-01f, 4.82769646e-02f, 3.66512425e-02f, -3.67344245e-02f, -1.06669359e-01f,
  4.12682742e-02f, 3.15621763e-01f, 1.26068056e-01f, 1.47593627e-02f, 9.54773873e-02f, -2.71277726e-02f, 2.29879431e-02f, -4.92857909e-03f, 8.78957137e-02f, 2.47016642e-02f,
  4.90046944e-03f, 2.19156593e-03f, -4.07125354e-02f, -8.12404379e-02f, -2.47403216e-02f, 2.83304099e-02f, -2.97329053e-02f, 1.05592541e-01f, 6.28315508e-02f, 3.08868792e-02f,
  -6.34489134e-02f, 1.51415374e-02f, 1.21851124e-01f, -1.64814815e-02f, 4.26483862e-02f, 8.04056302e-02f, 4.90833372e-02f, 1.26279041e-01f, -3.52465473e-02f, 5.72522730e-02f,
  -6.54763505e-02f, -4.72194672e-01f, -3.78641695e-01f, 4.27430589e-03f, 9.03565213e-02f, -1.31952643e-01f, -5.48855901e-01f, 3.56970304e-06f, -3.91984642e-01f, -3.69699337e-02f,
  9.11493376e-02f, -7.98559189e-02f, -4.72911239e-01f, -6.81706071e-02f, -1.27406612e-01f, -5.39736688e-01f, -1.07342126e-02f, -1.92836877e-02f, -2.24366888e-01f, 2.17738509e-01f,
  2.72661145e-03f, 1.59524843e-01f, -2.57309079e-01f, 1.56197444e-01f, 1.61284238e-01f, 2.78668076e-01f, 4.54460472e-01f, 2.46081129e-02f, 4.91740137e-01f, 1.45138651e-01f,
  -6.16053678e-02f, -1.22581162e-01f, -9.14064050e-02f, -3.45913246e-02f, 1.98191199e-02f, 1.01170175e-01f, 1.17823377e-01f, -9.20880307e-03f, 3.63227837e-02f, 1.13529498e-02f,
  8.21705461e-02f, 1.18270092e-01f, 4.74410430e-02f, -6.37464002e-02f, 3.33549678e-02f, 3.93635593e-02f, -2.36341543e-02f, -4.59133945e-02f, -6.95778802e-02f, -9.43500325e-02f,
  -1.22458614e-01f, -1.00245848e-02f, 1.41441468e-02f, 9.63250771e-02f, 5.13628684e-02f, 5.91362156e-02f, -5.37664630e-02f, -2.72556897e-02f, 8.75103772e-02f, 1.66065358e-02f,
  8.84240717e-02f, -2.76995488e-02f, -7.32100084e-02f, -4.69511598e-02f, -4.00482230e-02f, 5.17537957e-03f, -6.13795333e-02f, -5.65599240e-02f, -4.10452038e-02f, -6.70281351e-02f,
  3.93705927e-02f, 4.10477147e-02f, -4.90564331e-02f, 7.66131058e-02f, 3.54193598e-02f, -6.86613992e-02f, 3.30965370e-02f, -2.46033054e-02f, 5.10421321e-02f, -1.21358208e-01f,
  8.62032734e-03f, 3.77194434e-02f, -2.87789684e-02f, 6.54090568e-03f, -9.62836221e-02f, 3.73610072e-02f, 1.29290605e-02f, 5.54336421e-02f, -7.06012920e-02f, -3.76239233e-02f,
  1.09033406e-01f, 3.94047536e-02f, -9.11683869e-03f, -2.12959852e-02f, -1.42058753e-03f, 7.09771439e-02f, -1.01171903e-01f, 6.03788048e-02f, 9.19118598e-02f, -1.32842228e-01f,
  9.79027301e-02f, 1.12386392e-02f, 1.06814899e-01f, 1.68832645e-01f, 6.80642202e-02f, 6.20721541e-02f, 4.48128283e-02f, 1.57966793e-01f, 6.45978823e-02f, 1.47706389e-01f,
  1.07803278e-01f, 1.09629810e-01f, 5.28664030e-02f, 1.61743499e-02f, 1.32612675e-01f, -3.68953161e-02f, 1.30136430e-01f, 5.63934296e-02f, 1.39198517e-02f, -9.10418257e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  -8.90374649e-03f, 4.81957793e-01f, 1.33947968e-01f, 1.53149562e-02f, 2.18651876e-01f, -2.42733285e-01f, 1.58105612e-01f, 2.71459728e-01f
};

// L1_fan_Wp (Shape: 4 x 16)
const int L1_fan_Wp_rows = 4;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  1.91058025e-01f, -2.44931117e-01f, -7.96245411e-02f, 2.04480127e-01f, 4.71839448e-03f, 1.25698745e-01f, 1.98001504e-01f, 6.15080111e-02f, -6.48121238e-02f, 1.00908101e-01f,
  4.29450899e-01f, -4.59386766e-01f, 1.61303058e-01f, -6.63766861e-01f, -2.35068560e-01f, 1.74393415e-01f, -8.31804350e-02f, -2.05972284e-01f, 1.75739974e-01f, 5.19109666e-01f,
  5.73703527e-01f, 1.63787991e-01f, 3.70140284e-01f, 4.63946432e-01f, -3.52548838e-01f, 5.32313049e-01f, 2.78923750e-01f, 2.76365638e-01f, 1.57245025e-01f, 2.37011865e-01f,
  -1.29163429e-01f, -2.68279076e-01f, -6.21894524e-02f, -1.11567806e-02f, 1.58554032e-01f, -5.59407115e-01f, 1.17072389e-01f, 4.55333292e-02f, 6.51609600e-02f, -4.40209694e-02f,
  6.33782685e-01f, 9.31434557e-02f, 2.13856012e-01f, -3.37658435e-01f, -1.38179630e-01f, -3.89137477e-01f, -1.31353110e-01f, 1.05590001e-01f, 2.50802934e-01f, 3.28800082e-01f,
  -1.83773234e-01f, -2.37831920e-01f, -3.16329539e-01f, -1.68685868e-01f, 6.89948276e-02f, -1.83062315e-01f, 1.33048266e-01f, -2.77777970e-01f, -4.92727757e-02f, -3.07171643e-01f,
  -2.19601020e-01f, 9.94138122e-02f, 2.23648325e-01f, 5.11454165e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 16)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  5.45175850e-01f, 7.82034159e-01f, -1.44083142e-01f, -4.98587452e-03f, -3.39757651e-01f, -8.51940036e-01f, 6.64765611e-02f, 6.01465851e-02f, -6.43614084e-02f, 7.69705325e-02f,
  -2.91710258e-01f, 2.58665442e-01f, 6.88797712e-01f, 8.28054607e-01f, 1.52172670e-01f, 8.37245762e-01f, 4.23836797e-01f, 5.41190982e-01f, 1.15782358e-01f, -1.32237792e-01f,
  5.41156352e-01f, 2.83691019e-01f, -4.22987580e-01f, -3.01368803e-01f, 1.24646470e-01f, 7.59694278e-01f, 5.86680591e-01f, -8.38032141e-02f, 6.39978528e-01f, 2.71973997e-01f,
  4.69629884e-01f, 4.09017205e-01f, 5.18772840e-01f, 3.17755252e-01f, 1.42109126e-01f, 3.08682323e-01f, 4.63701129e-01f, 4.91473526e-01f, 4.33479816e-01f, -1.26877725e-01f,
  2.84286886e-01f, -9.25266370e-02f, 7.65457392e-01f, -2.30544522e-01f, 5.10568991e-02f, -5.18148541e-01f, -3.41650359e-02f, 3.29594225e-01f, 1.85404748e-01f, 3.73794943e-01f,
  5.32256663e-02f, 3.50016713e-01f, -9.86417457e-02f, 4.54507530e-01f, -6.53910160e-01f, -4.54846770e-01f, 1.56833977e-01f, -3.69084716e-01f, -5.83144069e-01f, -1.92606002e-01f,
  -1.85323566e-01f, 3.40823131e-03f, 5.61592937e-01f, -1.85237110e-01f, 3.94037187e-01f, -8.61972347e-02f, 1.41662925e-01f, 1.40173305e-02f, 5.26131988e-01f, 7.33236611e-01f,
  -4.67437319e-02f, 7.43650412e-03f, 2.11811960e-01f, 5.68306565e-01f, 6.35061085e-01f, -3.00752252e-01f, 4.45941649e-03f, -1.69499353e-01f, 1.56338155e-01f, -8.22263062e-02f,
  -6.22474328e-02f, -9.34560448e-02f, 5.18259645e-01f, 6.18572593e-01f, 3.12155873e-01f, 1.03662498e-02f, -3.71317476e-01f, 4.03691381e-01f, -2.53144681e-01f, 6.72318995e-01f,
  -4.63052467e-02f, 6.65622532e-01f, 1.98212117e-01f, -1.78035334e-01f, 3.36029351e-01f, -4.72932160e-01f, 2.87054747e-01f, 4.96541202e-01f, -2.40487173e-01f, -3.04885600e-02f,
  -1.67144001e-01f, 2.99838275e-01f, -5.63420177e-01f, -4.25466090e-01f, 5.58570981e-01f, 2.31285885e-01f, -4.98969741e-02f, 1.48896530e-01f, -3.73260044e-02f, 8.60277843e-03f,
  6.23495400e-01f, 1.18045248e-01f, -4.98130918e-01f, 2.12494984e-01f, -1.54396787e-01f, -5.00575840e-01f, -5.96808672e-01f, 2.22478241e-01f, 4.42034781e-01f, -3.98584306e-01f,
  1.28507987e-01f, -2.76985884e-01f, 2.83264488e-01f, 3.45105417e-02f, -2.95496821e-01f, 6.09887540e-01f, -2.91837513e-01f, 2.47020736e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  5.03598154e-01f, -5.26296459e-02f, 6.79696441e-01f, 4.24316198e-01f, 2.58674681e-01f, 6.46986246e-01f, 2.97228456e-01f, 8.70559812e-02f
};

// L2_fan_Wp (Shape: 4 x 16)
const int L2_fan_Wp_rows = 4;
const int L2_fan_Wp_cols = 16;
const float L2_fan_Wp_data[] = {
  6.54365495e-02f, 5.04483804e-02f, -2.47239277e-01f, 1.49085537e-01f, 8.43303204e-02f, -1.28082484e-01f, 7.43191957e-01f, 1.22233838e-01f, -3.23731601e-01f, -6.14457689e-02f,
  3.70366216e-01f, -4.79757339e-01f, 1.95891097e-01f, -1.08225293e-01f, -2.23234922e-01f, 3.79299849e-01f, -2.16559749e-02f, 9.44704283e-03f, -2.05636322e-01f, -9.58726779e-02f,
  -3.63016307e-01f, 4.82997261e-02f, -3.70327353e-01f, -2.52552032e-01f, -1.46308497e-01f, 3.04582715e-01f, -2.47441977e-01f, 4.75722164e-01f, 1.70830160e-01f, 6.30123690e-02f,
  6.26333579e-02f, -2.26693511e-01f, -2.77206928e-01f, -2.54694313e-01f, -2.89362162e-01f, 9.97607037e-02f, -5.93577087e-01f, 5.70546091e-01f, -4.56459373e-01f, -1.01220943e-01f,
  -2.75774654e-02f, -1.45051088e-02f, -2.36612171e-01f, -4.24740493e-01f, -1.74876347e-01f, 2.61623532e-01f, -5.46881557e-02f, 3.86481643e-01f, -1.28818527e-01f, -4.41480368e-01f,
  -2.05225974e-01f, -1.78769454e-02f, -5.92952132e-01f, -1.47974387e-01f, -2.02658400e-01f, -3.13335836e-01f, -1.29879285e-02f, -2.74786297e-02f, -3.63778710e-01f, 4.16998118e-02f,
  7.16110319e-02f, 4.14770991e-01f, 2.64326632e-01f, 3.50523829e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 16)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 16;
const float L2_fan_Wp_bar_data[] = {
  1.30847931e-01f, 1.11096978e-01f, 4.37867194e-02f, 4.14031260e-02f, -1.18129171e-01f, -2.46094406e-01f, 8.14383149e-01f, 7.51231194e-01f, 9.57122564e-01f, 6.67152464e-01f,
  4.79495257e-01f, -6.97332203e-01f, -2.13929653e-01f, -3.19516242e-01f, 2.35969871e-01f, 4.64511037e-01f, 6.32983267e-01f, 5.74248191e-03f, -1.30767107e-01f, 4.79240306e-02f,
  -3.39920610e-01f, -9.26114380e-01f, 4.49920893e-01f, 1.08043045e-01f, -2.09280834e-01f, 4.84804362e-01f, 1.30853996e-01f, 1.05734694e+00f, 2.58224398e-01f, 4.04040128e-01f,
  8.97905350e-01f, 4.95231688e-01f, 2.66784698e-01f, 1.54046923e-01f, 7.65014946e-01f, 5.71187913e-01f, 7.45571971e-01f, 1.05827689e+00f, 1.73808292e-01f, -1.01209247e+00f,
  -2.49514908e-01f, 3.14837098e-01f, 6.84194148e-01f, -2.56037414e-01f, 6.11133575e-01f, 8.33554327e-01f, -4.86511111e-01f, 8.36299285e-02f, -1.91875234e-01f, 8.40000808e-02f,
  -6.28272891e-02f, -1.25919476e-01f, -3.97696614e-01f, 2.85018921e-01f, -9.33341682e-01f, 1.60193309e-01f, 9.14458632e-01f, 7.20355272e-01f, -1.30035073e-01f, -9.45370086e-03f,
  -1.36771977e-01f, 1.84808239e-01f, 2.26064861e-01f, -6.01461649e-01f, 2.08042145e-01f, 6.59770966e-01f, 1.93031952e-01f, -7.82085434e-02f, 2.86095202e-01f, 3.05293798e-01f,
  -3.39681864e-01f, 5.90513825e-01f, 7.67192662e-01f, 1.32450253e-01f, 4.50888366e-01f, -1.28420040e-01f, -2.77153235e-02f, -4.07405764e-01f, -3.25341016e-01f, -3.19168776e-01f,
  -4.36344653e-01f, -1.75044581e-01f, -3.34188461e-01f, -2.76052028e-01f, 3.02951306e-01f, -2.97303855e-01f, 6.13000154e-01f, -7.23530799e-02f, 2.13636011e-01f, 9.23781753e-01f,
  5.80990791e-01f, 3.51229697e-01f, 9.17677701e-01f, 4.76982072e-02f, 5.92541158e-01f, -8.03928971e-01f, 7.22079158e-01f, 7.92629421e-01f, 6.74534798e-01f, 6.13101661e-01f,
  2.50480711e-01f, -1.55327544e-01f, 6.63518757e-02f, 6.33804858e-01f, 3.11511576e-01f, -1.23685621e-01f, 5.88638246e-01f, 3.75900805e-01f, 1.47097915e-01f, 1.57317802e-01f,
  1.98267296e-01f, 3.08704406e-01f, 8.28031659e-01f, 4.27677482e-01f, 3.31699759e-01f, 4.66490299e-01f, -6.77187383e-01f, 6.44315600e-01f, -9.05453324e-01f, -1.14564896e-01f,
  7.17586577e-01f, -1.42055079e-01f, -3.38745773e-01f, 2.98817903e-01f, -2.84821719e-01f, 6.90987647e-01f, -1.37265086e-01f, 4.77211744e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  3.42187315e-01f, 9.26691890e-02f, 3.63789678e-01f, 5.38630746e-02f, 2.24097088e-01f, -1.12052307e-01f, 7.38691986e-01f, 5.53556085e-01f
};

// L3_fan_Wp (Shape: 4 x 16)
const int L3_fan_Wp_rows = 4;
const int L3_fan_Wp_cols = 16;
const float L3_fan_Wp_data[] = {
  -2.51950353e-01f, 1.66656319e-02f, -1.51737392e-01f, -6.98362440e-02f, -2.49502763e-01f, 2.07068697e-01f, 3.18691701e-01f, 2.83661634e-01f, 6.21869005e-02f, -1.34500293e-02f,
  3.85616720e-01f, 3.35014216e-03f, -3.02909970e-01f, 3.19988392e-02f, -2.89876223e-01f, -2.46326365e-02f, 2.74502903e-01f, -4.66830358e-02f, 1.63027689e-01f, 1.64202545e-02f,
  4.42686707e-01f, -2.86902755e-01f, -1.05883732e-01f, -2.47896105e-01f, 2.35340685e-01f, 6.38679117e-02f, 3.02465051e-01f, -2.23559663e-01f, -2.34534308e-01f, -1.51631027e-01f,
  2.30005756e-01f, -2.66333938e-01f, -2.98671704e-02f, -5.50874434e-02f, -3.95939276e-02f, -7.17972592e-02f, 3.12447518e-01f, -4.15801138e-01f, -5.42148389e-02f, -3.29381555e-01f,
  2.85524130e-01f, -1.13654256e-01f, -1.13788493e-01f, -2.01556727e-01f, 3.15782279e-01f, -5.38761094e-02f, 7.15900511e-02f, 4.79619205e-02f, 2.55384654e-01f, 4.70105521e-02f,
  2.60295838e-01f, 2.25457437e-02f, 3.50532562e-01f, -2.57595330e-01f, 1.97183520e-01f, 2.74646610e-01f, 2.63573438e-01f, -6.74539730e-02f, 4.34506923e-01f, -2.00300887e-01f,
  -4.14469957e-01f, -1.58978194e-01f, -1.79680914e-01f, 3.24806601e-01f
};

// L3_fan_Wp_bar (Shape: 8 x 16)
const int L3_fan_Wp_bar_rows = 8;
const int L3_fan_Wp_bar_cols = 16;
const float L3_fan_Wp_bar_data[] = {
  3.77794653e-02f, 2.78641999e-01f, -2.70928591e-01f, 2.67892390e-01f, -1.40383095e-01f, 2.71987971e-02f, -4.92510229e-01f, 1.05771329e-02f, 1.93794250e-01f, 7.21204817e-01f,
  -8.90610814e-01f, -2.51026452e-01f, 4.74524759e-02f, 3.07602823e-01f, 6.28484607e-01f, -3.17186058e-01f, 5.18380105e-01f, 2.78860658e-01f, 2.70191967e-01f, 3.12792897e-01f,
  3.95995289e-01f, 4.15863097e-01f, -7.23776042e-01f, -7.33949721e-01f, -2.10540712e-01f, 3.21662188e-01f, 1.40302014e+00f, -2.44141981e-01f, -1.01167828e-01f, 5.62907815e-01f,
  6.80104017e-01f, 4.20247903e-03f, -4.57498848e-01f, 2.43315667e-01f, 9.73918065e-02f, -4.27738689e-02f, -4.21021551e-01f, 2.27562025e-01f, 9.46969092e-01f, -2.23351177e-02f,
  8.14985633e-01f, -6.54227793e-01f, -4.05512929e-01f, 1.24753296e+00f, 8.83910239e-01f, -8.25960711e-02f, 2.40558878e-01f, 1.02070141e+00f, 3.79658490e-01f, 5.80641448e-01f,
  8.31759870e-01f, 7.33042061e-01f, -3.99878830e-01f, -1.42098442e-01f, 1.66744784e-01f, 5.51008761e-01f, -1.20118953e-01f, 4.72020864e-01f, -2.47767363e-02f, 1.91547554e-02f,
  -9.21744667e-03f, -6.11060679e-01f, 7.21812606e-01f, 1.28641975e+00f, 2.34940812e-01f, 4.03784245e-01f, 3.69571179e-01f, 4.50626701e-01f, -3.03943008e-01f, -3.38506371e-01f,
  -8.39624405e-01f, -5.70955276e-01f, -1.92838743e-01f, -5.13946004e-02f, 9.67175215e-02f, 1.83279797e-01f, 5.84193349e-01f, -3.86195004e-01f, 8.58144522e-01f, 3.98380578e-01f,
  8.80982652e-02f, -1.74089611e-01f, -1.91669166e-01f, 1.74118325e-01f, 3.15396309e-01f, 1.20999655e-02f, -6.01582944e-01f, 1.60850242e-01f, 7.71788716e-01f, 8.97291780e-01f,
  -7.59515464e-01f, 3.40475202e-01f, -6.31489307e-02f, 6.93022132e-01f, 2.53342777e-01f, -3.24290216e-01f, 1.38867870e-01f, 5.72630465e-01f, -4.20068592e-01f, -3.51148784e-01f,
  5.88502049e-01f, -6.36450589e-01f, -5.01937628e-01f, -1.03606737e+00f, 6.80399477e-01f, -5.50298393e-01f, 4.51671630e-02f, -2.02493727e-01f, 8.42589200e-01f, 1.07003003e-01f,
  5.79032898e-01f, -3.46674204e-01f, 8.06600928e-01f, 1.11731805e-01f, 2.76215315e-01f, 2.04045340e-01f, 7.33881176e-01f, -9.98453617e-01f, -4.13427234e-01f, -6.58419967e-01f,
  6.76048219e-01f, 9.00033191e-02f, 9.84831005e-02f, -6.27476931e-01f, 2.17754453e-01f, -3.78789246e-01f, 5.39101601e-01f, -1.27205253e-01f
};

// L3_fan_Bp_bar (Shape: 1 x 8)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 8;
const float L3_fan_Bp_bar_data[] = {
  2.37422869e-01f, 3.68339717e-01f, -2.84109600e-02f, 5.96620262e-01f, 3.06878388e-01f, -1.76839739e-01f, -9.72689614e-02f, 5.93600273e-02f
};

// L4_linear_W (Shape: 12 x 16)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 16;
const float L4_linear_W_data[] = {
  1.55991048e-01f, -1.53023690e-01f, 3.69906068e-01f, 2.25664273e-01f, 2.03540206e-01f, -2.49383211e-01f, 5.68904094e-02f, 2.87857890e-01f, -2.29567707e-01f, 4.48326170e-01f,
  -7.99078584e-01f, -9.70147908e-01f, 7.15074763e-02f, -7.34671354e-01f, 8.89547646e-01f, 3.20979923e-01f, -5.89318573e-01f, -4.78158593e-01f, -2.71003634e-01f, 4.34417903e-01f,
  -2.24528447e-01f, 4.91101474e-01f, 4.47423518e-01f, 2.70095646e-01f, 2.72110730e-01f, -5.48640490e-01f, -6.13961935e-01f, 4.11870271e-01f, -6.49990328e-03f, 2.16832653e-01f,
  2.18360916e-01f, 8.64466608e-01f, -2.58267701e-01f, 3.56964618e-01f, -9.48466733e-02f, -5.42076170e-01f, 2.14653701e-01f, -6.59486115e-01f, 2.31189892e-01f, -2.90660113e-01f,
  -1.19051121e-01f, -7.24298716e-01f, 1.40248343e-01f, -4.21273410e-01f, 3.96066368e-01f, 9.68537256e-02f, 5.55639923e-01f, -2.93264568e-01f, -4.78963405e-01f, -3.65484297e-01f,
  -1.09739862e-01f, 1.97608724e-01f, 9.01950821e-02f, 3.47202480e-01f, -4.99241799e-01f, 5.39800167e-01f, -1.27246633e-01f, 4.29602355e-01f, -6.26367033e-01f, -7.93895781e-01f,
  -1.11931598e+00f, 3.46154064e-01f, -3.91710103e-01f, -6.45837545e-01f, 3.20882320e-01f, 8.62729400e-02f, 3.15340273e-02f, 4.01448965e-01f, 3.02428722e-01f, 4.91854429e-01f,
  -6.52716219e-01f, 3.91358733e-02f, -2.80763894e-01f, 5.02107382e-01f, -9.72306550e-01f, 5.87984145e-01f, 2.18761697e-01f, -5.72883964e-01f, -4.71372694e-01f, -2.00851530e-01f,
  1.06853113e-01f, 4.33513373e-01f, 3.14190805e-01f, 3.79599869e-01f, -5.51150203e-01f, -4.55276579e-01f, -1.20147824e-01f, -8.02458107e-01f, 5.91258526e-01f, -3.16769928e-01f,
  -2.18576401e-01f, 5.76464176e-01f, 3.87291580e-01f, 3.98534611e-02f, -5.07536650e-01f, -9.03997838e-01f, 8.95367116e-02f, 3.35544884e-01f, 4.49995309e-01f, -6.07098997e-01f,
  5.62586784e-01f, -5.75562477e-01f, -4.60822821e-01f, 4.92355078e-01f, -3.71866792e-01f, -3.52678239e-01f, 4.27972823e-01f, 8.09957981e-01f, 3.14100571e-02f, -1.30741632e+00f,
  -8.54984105e-01f, -1.09474039e+00f, 2.64146715e-01f, 1.70118243e-01f, -1.32015303e-01f, -1.05149724e-01f, 1.46395192e-01f, 2.35620290e-01f, -2.25694746e-01f, -3.37293863e-01f,
  5.94015718e-01f, -5.78375399e-01f, -3.95592541e-01f, -4.53010827e-01f, -6.89922452e-01f, 8.07679951e-01f, -4.25559163e-01f, -7.69842207e-01f, -3.35303843e-01f, -1.09602213e-02f,
  -4.42041576e-01f, 3.54839891e-01f, -6.07217312e-01f, -6.53215358e-03f, 3.22442472e-01f, -3.48061055e-01f, -4.09971595e-01f, -1.39032710e+00f, 5.62474370e-01f, 3.78172308e-01f,
  -3.54578495e-02f, -2.40776345e-01f, -4.08916734e-02f, -7.61946738e-01f, -2.15431601e-02f, 5.01922727e-01f, -1.18788913e-01f, -8.18996057e-02f, -5.94940841e-01f, 6.03406608e-01f,
  5.27764678e-01f, 2.59356886e-01f, -8.03476214e-01f, -1.25238553e-01f, 8.46178383e-02f, 2.57955551e-01f, 4.82142627e-01f, -1.10101712e+00f, 2.16947675e-01f, 3.25582117e-01f,
  3.48502338e-01f, -1.96585320e-02f, 4.15341519e-02f, -3.60224515e-01f, -3.53047065e-02f, 2.74369776e-01f, 4.28241849e-01f, -5.36484063e-01f, 2.62408465e-01f, -5.57028428e-02f,
  -2.48477727e-01f, -6.27741814e-01f, -3.97495657e-01f, 2.83990055e-01f, 5.33989727e-01f, -1.15976661e-01f, 7.40205646e-02f, -1.99488878e-01f, 3.51118058e-01f, 1.45965964e-01f,
  6.02961719e-01f, -4.51850384e-01f, -7.42207542e-02f, 5.31076610e-01f, -3.93311441e-01f, -1.40750721e-01f, 5.46103179e-01f, -2.30627179e-01f, -7.96946764e-01f, 2.08433226e-01f,
  -6.80778027e-01f, -2.09447250e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  4.77539785e-02f, -2.04550728e-01f, -2.90201157e-02f, 2.05852970e-01f, 5.87801971e-02f, -7.79735520e-02f, 6.92258254e-02f, 2.15968117e-01f, -9.80869979e-02f, -2.30012208e-01f,
  -1.38742074e-01f, 1.84371963e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        16, 4, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        16, 12
    );
    }
    