/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 1 x 120)
const int L0_fan_Wp_rows = 1;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.01761851e-02f, 3.60000730e-01f, -1.16623510e-02f, 9.04796124e-02f, 1.77698478e-01f, 1.58191666e-01f, 2.72208184e-01f, -1.38537854e-01f, -3.45982984e-02f, 1.51794553e-01f,
  -1.46120027e-01f, -2.86082685e-01f, -1.50911734e-01f, -2.83207893e-01f, -1.23481087e-01f, 3.00476313e-01f, 2.27541193e-01f, -4.14530784e-02f, -2.80761361e-01f, -7.28316754e-02f,
  1.64559335e-01f, -6.65675150e-03f, -9.18345377e-02f, -5.14398366e-02f, 4.05426860e-01f, 1.09372377e-01f, 1.39146999e-01f, 2.35692158e-01f, 2.56076843e-01f, 5.76575935e-01f,
  1.99235663e-01f, -6.36567548e-02f, -1.32104889e-01f, 8.83548930e-02f, 3.92634869e-02f, 1.96091784e-03f, 5.71411178e-02f, -7.61930868e-02f, -1.42788598e-02f, 2.69838143e-03f,
  2.88859010e-02f, -8.29937384e-02f, 2.89326273e-02f, 2.04476994e-02f, 5.19846985e-03f, -2.72330046e-02f, 7.60374824e-03f, -7.76996687e-02f, -8.10060054e-02f, 3.61073539e-02f,
  3.80943716e-02f, 5.72907738e-02f, 4.77779955e-02f, 1.38233537e-02f, -7.47185498e-02f, -3.72484103e-02f, 5.59880063e-02f, 9.17409882e-02f, -1.09796509e-01f, 3.59480292e-01f,
  8.08041766e-02f, -4.66929823e-02f, -3.54946703e-02f, -9.74409357e-02f, 4.68124375e-02f, -5.88460751e-02f, 5.77139016e-03f, -5.22194197e-03f, 2.28521042e-02f, -1.91504403e-03f,
  -6.48730472e-02f, -2.99842078e-02f, -1.24703150e-03f, 5.87084591e-02f, 2.48592049e-02f, -2.18977613e-04f, 4.32269908e-02f, 6.09638132e-02f, 1.65009394e-03f, -7.51960427e-02f,
  -2.07308866e-02f, 4.07593548e-02f, -2.92426087e-02f, -1.81872060e-03f, -6.09285757e-02f, -1.59081798e-02f, 1.29921511e-02f, -1.20738149e-01f, -5.29355742e-02f, -2.03096494e-02f,
  1.78619940e-02f, -2.46130481e-01f, 1.76440462e-01f, -8.74236226e-02f, 1.23897165e-01f, 6.97291046e-02f, 3.36474809e-03f, -4.01656479e-02f, -8.05995055e-03f, 7.52035156e-02f,
  -1.35635594e-02f, -1.02410816e-01f, -2.82261018e-02f, 4.77901287e-02f, -2.58326195e-02f, 5.02276793e-02f, 3.58182415e-02f, -5.56148728e-03f, 9.88405757e-03f, 7.43541494e-02f,
  4.06182092e-03f, 6.37562498e-02f, -5.09537151e-03f, 2.14659926e-02f, 3.87080498e-02f, -7.05491677e-02f, 1.74009249e-01f, 1.62995458e-01f, 5.27338274e-02f, 3.59818131e-01f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.49695769e-01f, 5.31626046e-02f, -2.58040369e-01f, 6.56429157e-02f, 1.17748581e-01f, -9.80604719e-03f, 2.68066823e-02f, -8.70758854e-03f, 7.50754997e-02f, 3.54545824e-02f,
  -2.61003729e-02f, 1.93406846e-02f, -1.55838817e-01f, -9.93108600e-02f, 9.16660950e-03f, 7.96956643e-02f, 1.04975224e-01f, -1.40696868e-01f, -1.57871902e-01f, 8.68550092e-02f,
  1.30743772e-01f, 2.40146071e-01f, 8.90799686e-02f, 1.18825853e-01f, 6.41983226e-02f, 4.90600616e-02f, 6.76957965e-02f, 3.79134864e-02f, 1.07450262e-01f, -4.01354730e-02f,
  -3.22191328e-01f, -4.22010928e-01f, -3.59353982e-02f, 1.14173494e-01f, -5.35293519e-02f, 4.63588089e-02f, -1.29616214e-02f, 8.59073848e-02f, -3.98219004e-02f, 1.01852484e-01f,
  -1.18450783e-02f, -2.29565558e-05f, -1.98960789e-02f, 2.80929953e-02f, 5.60484044e-02f, 7.54372543e-03f, 1.06601693e-01f, -3.33939381e-02f, 2.17321441e-02f, 2.98371650e-02f,
  1.39359847e-01f, -6.29910156e-02f, -1.19785011e-01f, -6.57479614e-02f, -5.82236275e-02f, -1.27147928e-01f, -6.28818274e-02f, -1.43587217e-01f, -1.95415318e-01f, 3.62213515e-02f,
  9.83091518e-02f, 3.24935131e-02f, -1.25197142e-01f, 2.89109182e-02f, 1.18781671e-01f, -6.96331710e-02f, -2.27693003e-02f, 3.20264995e-02f, -5.20503074e-02f, -1.14696600e-01f,
  1.06680188e-02f, -1.39529975e-02f, -7.42670335e-03f, -5.32786474e-02f, -3.15621495e-02f, -6.10603280e-02f, -8.25266838e-02f, 7.39721358e-02f, 1.47750573e-02f, -1.16845168e-01f,
  -5.02664447e-02f, 2.30677370e-02f, 9.76477638e-02f, 3.35091911e-02f, 8.26961920e-02f, -4.33733128e-02f, -6.53274506e-02f, -1.19806789e-02f, 9.18688700e-02f, -1.71958003e-02f,
  2.21010387e-01f, -1.23587772e-01f, -1.15237601e-01f, -5.38235307e-02f, -1.18451580e-01f, -6.00142442e-02f, -2.05595538e-01f, -2.38289479e-02f, -4.08525318e-02f, -3.20891067e-02f,
  -1.17811747e-01f, -3.27799395e-02f, 1.81572903e-02f, -1.82929374e-02f, 5.53951561e-02f, -9.16945636e-02f, 2.22860560e-01f, -1.67365242e-02f, -2.21585650e-02f, -2.61878055e-02f,
  1.29435927e-01f, 9.14124399e-02f, 7.05116466e-02f, 1.07926026e-01f, 2.40417477e-02f, -2.20879838e-02f, 5.08175306e-02f, 3.04861870e-02f, -3.01394868e-03f, 2.93289572e-01f,
  -6.57860696e-01f, -1.89522982e-01f, 1.18607149e-01f, -4.76475030e-01f, -1.21461079e-01f, -4.31376062e-02f, -7.70567358e-02f, -1.46135628e-01f, -1.44471273e-01f, -2.34334365e-01f,
  -1.09090395e-02f, -5.97280636e-02f, -7.94573054e-02f, 2.44308822e-02f, -3.01951487e-02f, -1.30451277e-01f, -1.89499632e-01f, -1.61532342e-01f, 1.19175790e-02f, -1.11587800e-01f,
  -1.66099846e-01f, -3.62440050e-01f, -2.00949892e-01f, -1.03331536e-01f, -5.27745895e-02f, -1.40644982e-02f, -4.44127470e-02f, -8.00679997e-02f, -1.12990372e-01f, -1.93087205e-01f,
  3.35586041e-01f, -2.41030619e-01f, 1.76337268e-02f, -1.86089680e-01f, -8.54289811e-03f, 3.20555922e-03f, -6.88746478e-03f, -1.08897366e-01f, -5.82786500e-02f, -1.04338422e-01f,
  -5.39378487e-02f, -9.61517617e-02f, -4.42488492e-02f, 8.73288810e-02f, -1.33625850e-01f, 1.44196153e-02f, -3.28752846e-02f, 4.52585192e-03f, 1.00938402e-01f, 1.92339256e-01f,
  -2.70902961e-02f, -8.82073045e-02f, 6.34603724e-02f, 2.02997267e-01f, 6.81990460e-02f, 1.39629701e-02f, 9.48716700e-02f, 1.57747626e-01f, 5.77749200e-02f, 9.88532789e-03f,
  4.04418930e-02f, -2.99932715e-02f, -6.91052107e-03f, -4.16353457e-02f, -1.70996152e-02f, 5.25930971e-02f, -4.16618511e-02f, -3.29702124e-02f, 2.97229830e-02f, 1.72221642e-02f,
  -4.67689857e-02f, -4.79848981e-02f, 5.08846156e-02f, -4.70165685e-02f, 2.24500261e-02f, 3.48518193e-02f, 2.05404572e-02f, -4.98335920e-02f, 5.41756041e-02f, -2.48100911e-03f,
  -1.96757242e-02f, 2.50641890e-02f, -5.55854850e-02f, 4.19323780e-02f, -1.12127000e-02f, -7.85732269e-03f, -7.25130513e-02f, 1.10878192e-01f, -2.38082353e-02f, -1.37055293e-03f,
  1.28039315e-01f, 7.20560253e-02f, -1.00729607e-01f, 1.60956122e-02f, -2.27470174e-02f, 1.81913504e-03f, -3.23937945e-02f, -8.63896683e-03f, -1.06294155e-01f, -8.89457006e-04f,
  5.85961379e-02f, 1.21408757e-02f, 2.23174449e-02f, 2.82499753e-02f, -3.50947008e-02f, 9.73970592e-02f, -1.35046065e-01f, -8.25983509e-02f, 5.70239127e-02f, 4.12846133e-02f,
  -1.20637333e-02f, -4.01152186e-02f, 1.08538838e-02f, 8.75534788e-02f, 3.68895866e-02f, 1.21508472e-01f, 2.46099666e-01f, 6.96909875e-02f, 4.91283014e-02f, 1.85361244e-02f,
  9.27891970e-01f, -2.46954277e-01f, -1.07392216e+00f, 1.26514196e-01f, -3.59847426e-01f, -4.45243120e-01f, -3.82521152e-01f, 1.79750815e-01f, 2.38808006e-01f, -1.83605105e-01f,
  -1.27299994e-01f, 2.17229635e-01f, 6.30451813e-02f, 6.04229830e-02f, 3.31788231e-03f, -4.92831588e-01f, -6.15530193e-01f, -3.15121442e-01f, 7.35583901e-02f, 8.37401599e-02f,
  -1.54238716e-02f, 5.87319881e-02f, 2.49775976e-01f, 8.03357735e-02f, -1.61407843e-01f, -1.03170864e-01f, -4.26905453e-01f, -2.12482184e-01f, -3.10357541e-01f, -5.20814478e-01f,
  -6.74767971e-01f, -3.45487222e-02f, 3.84013392e-02f, 2.13609844e-01f, -1.13682263e-01f, 9.50440317e-02f, -3.95088876e-03f, 7.37916725e-03f, 1.43940210e-01f, -2.62076110e-02f,
  -1.46466261e-02f, 1.03749312e-01f, 6.26539737e-02f, 1.14295417e-02f, 4.36709821e-02f, 5.07284924e-02f, 1.45337079e-02f, -8.37742686e-02f, -4.44212668e-02f, -1.62993938e-01f,
  -1.38523981e-01f, -1.73981026e-01f, -1.19806781e-01f, -3.97122558e-03f, -5.59027046e-02f, -5.83851747e-02f, -2.06018925e-01f, 1.67251122e-03f, -1.35267869e-01f, 2.81366371e-02f,
  -8.70107189e-02f, -1.15062751e-01f, 1.58255938e-02f, 2.45227609e-02f, 1.32048041e-01f, -9.56658274e-03f, -4.28257361e-02f, 1.87374726e-02f, 3.54198217e-02f, 2.62148362e-02f,
  -4.99390438e-03f, -6.00632839e-02f, 4.16868599e-04f, 1.93378907e-02f, -9.24129710e-02f, -4.49318551e-02f, 7.06492513e-02f, -3.03929728e-02f, 1.87000874e-02f, 7.70229613e-03f,
  1.50607582e-02f, -1.69481020e-02f, -6.98497519e-02f, 6.40312731e-02f, -1.19023673e-01f, -7.25472569e-02f, 1.32873189e-02f, 1.47935171e-02f, 1.06310323e-01f, 1.70502290e-02f,
  3.40987325e-01f, -8.15614015e-02f, 1.05788499e-01f, 2.05390245e-01f, -1.04943946e-01f, 2.47044470e-02f, -9.30912048e-02f, 6.63812459e-03f, 6.96668448e-03f, -4.41654511e-02f,
  4.34131641e-03f, 1.11357398e-01f, -6.11444525e-02f, -7.39456192e-02f, 2.80196574e-02f, 4.75971662e-02f, 1.29903764e-01f, -2.68508196e-02f, 5.04670059e-03f, -9.55072790e-02f,
  -4.18295637e-02f, 1.05505571e-01f, 2.65196592e-01f, 4.04250901e-03f, 1.16996050e-01f, 8.26826990e-02f, -1.31111965e-01f, 5.06940894e-02f, 7.39733279e-02f, 1.86266109e-01f,
  -5.79689860e-01f, 6.69975579e-01f, 1.21475674e-01f, -3.61714512e-01f, 1.55812636e-01f, 4.94944721e-01f, 8.96878600e-01f, 3.11444223e-01f, -1.25222266e-01f, 1.37024671e-01f,
  5.82960322e-02f, -3.28134090e-01f, -2.69183427e-01f, 3.40526141e-02f, 2.79322028e-01f, 4.70823705e-01f, 3.59260798e-01f, -9.96582881e-02f, -2.81983674e-01f, -4.55695689e-02f,
  1.58522353e-02f, -2.45700389e-01f, -2.88103670e-01f, -1.73344374e-01f, -9.61182192e-02f, -1.97492033e-01f, -7.76069909e-02f, -8.19915831e-02f, 2.34897658e-01f, 3.88046056e-02f,
  -2.31986523e-01f, 1.05689883e-01f, -1.36740610e-01f, -1.68049917e-01f, -9.40811634e-02f, 1.28924847e-02f, 1.68314353e-02f, -1.16092145e-01f, -1.15540750e-01f, 9.83863771e-02f,
  -3.60481404e-02f, -1.11248856e-02f, 1.37741314e-02f, 8.20353627e-03f, 1.10123651e-02f, 5.02447784e-02f, 2.88599078e-02f, 6.38728663e-02f, -7.22714290e-02f, 9.72215757e-02f,
  8.59143212e-02f, -1.21068768e-02f, 1.85194029e-03f, 6.51521683e-02f, 5.58888875e-02f, -3.02741706e-01f, 8.26446488e-02f, -3.34280618e-02f, -4.59689833e-02f, -9.56344083e-02f,
  -2.08122632e-03f, 5.39896749e-02f, 2.96181384e-02f, 7.95161277e-02f, 1.41034722e-02f, -2.75113750e-02f, 7.94024169e-02f, 4.45396155e-02f, 1.93458349e-02f, -3.47775295e-02f,
  -1.17736245e-02f, -3.96243781e-02f, -7.85937882e-04f, -6.05258010e-02f, -1.60077170e-01f, 6.31108508e-02f, 1.15862966e-01f, 7.55924881e-02f, -6.62561506e-02f, -1.93443131e-02f,
  -4.57088649e-02f, -4.42065019e-03f, -1.21339850e-01f, 3.75950634e-02f, 1.62765067e-02f, -2.37497035e-02f, 7.24268006e-03f, -3.23644467e-02f, -7.86007345e-02f, -3.89521336e-03f,
  -5.28787911e-01f, 4.43787165e-02f, -1.34390727e-01f, 7.44351139e-03f, -8.28470290e-02f, -6.84694946e-02f, -3.89705151e-02f, 6.79115253e-03f, -4.10245769e-02f, 3.06528453e-02f,
  1.46151772e-02f, -2.87420340e-02f, -1.94882136e-02f, 9.64179039e-02f, -1.45722300e-01f, -2.45451145e-02f, 1.77630465e-02f, -1.13632649e-01f, -1.54646179e-02f, -1.24528550e-01f,
  4.44836691e-02f, -6.76844567e-02f, -3.00852150e-01f, -5.58269024e-02f, -6.87387809e-02f, -3.39549363e-01f, -1.33816347e-01f, -2.30355516e-01f, -2.84015238e-02f, -1.71057180e-01f,
  6.79291368e-01f, -3.73584121e-01f, -3.09358925e-01f, 4.06582922e-01f, 2.93497086e-01f, 2.55746901e-01f, 2.07427353e-01f, 2.61343420e-01f, 4.42623913e-01f, 3.85265350e-02f,
  -2.18367919e-01f, -3.00806165e-02f, -1.26227796e-01f, -1.56237304e-01f, -5.32114804e-02f, 8.48096088e-02f, 3.17552954e-01f, 6.79314062e-02f, 1.07367195e-01f, 1.03393011e-01f,
  1.04768254e-01f, 1.25426739e-01f, 1.79005209e-02f, -2.28563379e-02f, -4.98638563e-02f, 9.86090973e-02f, -6.55610710e-02f, -3.00802976e-01f, -2.86756992e-01f, -2.95617312e-01f,
  -5.61548233e-01f, -3.94505411e-01f, 2.26119787e-01f, -3.96654196e-02f, -2.25304633e-01f, 6.41677156e-02f, 8.63037184e-02f, -1.01466499e-01f, -1.50143588e-02f, 6.37391582e-02f,
  -1.05235018e-01f, 1.56945772e-02f, -4.84224521e-02f, -4.76274751e-02f, -5.41427396e-02f, 2.42136349e-03f, -6.20955899e-02f, -1.22023948e-01f, -1.31402224e-01f, -2.26644531e-01f,
  -2.14581087e-01f, -1.02036946e-01f, -8.88982266e-02f, 2.74464898e-02f, -2.02941567e-01f, 3.03398222e-02f, -2.57530928e-01f, -2.88645685e-01f, -4.01038937e-02f, 3.27010453e-02f,
  6.39142022e-02f, 2.79026162e-02f, 2.49176640e-02f, 8.09720438e-03f, 6.01146035e-02f, 7.57008791e-02f, 6.05389625e-02f, -1.43259102e-02f, 3.33292410e-02f, 8.46564695e-02f,
  -1.57431103e-02f, -2.99019516e-02f, -6.83870390e-02f, 1.26763746e-01f, 3.96210402e-02f, -9.68496036e-03f, -7.50384759e-03f, -3.05332690e-02f, -6.85760379e-02f, 1.38703883e-01f,
  1.00167617e-02f, 2.17744820e-02f, 2.34233998e-02f, -1.09501965e-01f, -3.66100110e-02f, -2.01578140e-02f, 1.71270352e-02f, -1.30593464e-01f, 6.64422214e-02f, -3.93922329e-02f,
  1.66316167e-01f, 7.91416913e-02f, 1.58333957e-01f, 2.67992560e-02f, -8.99371505e-02f, -1.31338850e-01f, -3.78999524e-02f, -2.02334430e-02f, -1.05461262e-01f, -2.02247258e-02f,
  -1.77026793e-01f, -7.05849379e-02f, -1.37289792e-01f, -7.83217177e-02f, 1.99893653e-01f, 1.22791015e-01f, -4.24264446e-02f, 5.19860871e-02f, -1.13620855e-01f, -1.62213534e-01f,
  -4.12576087e-02f, 3.72649014e-01f, 4.00924087e-01f, 1.96759418e-01f, -3.95974442e-02f, 3.49382728e-01f, 4.46538068e-02f, 1.32366881e-01f, 2.55767167e-01f, 6.21726274e-01f,
  1.05378056e+00f, 3.07128429e-01f, 3.24694574e-01f, 9.53936353e-02f, -4.51363832e-01f, -2.45922104e-01f, -6.27632514e-02f, 1.93114117e-01f, 6.63319081e-02f, 3.64797600e-02f,
  2.76586860e-02f, 3.34356502e-02f, 1.39128327e-01f, 1.34101108e-01f, 3.99068952e-01f, 6.81982264e-02f, 6.68137372e-02f, 4.05059338e-01f, 3.43332142e-01f, 1.76826552e-01f,
  -3.29344161e-02f, 1.30601108e-01f, 4.16014075e-01f, 1.86689004e-01f, -9.34481695e-02f, -2.97690872e-02f, -2.27178074e-03f, 1.03782136e-02f, -5.65431044e-02f, 3.25119980e-02f,
  1.09240741e-01f, 4.25717980e-01f, -8.11736211e-02f, -1.91807151e-01f, -2.29506791e-01f, 1.62499517e-01f, -3.46731907e-03f, 8.96335691e-02f, -4.94703948e-02f, -2.65241284e-02f,
  -2.00317442e-01f, -3.43363057e-03f, -1.88452005e-02f, -5.88707216e-02f, -6.08166717e-02f, 1.49730090e-02f, 1.04873896e-01f, 2.33155370e-01f, 1.22577518e-01f, 4.64983173e-02f,
  -2.42723197e-01f, -1.24666885e-01f, -1.54922530e-01f, -1.22713491e-01f, 7.24107474e-02f, -5.62352911e-02f, -1.48334820e-02f, 7.20603764e-02f, 7.85484537e-02f, 2.58929193e-01f,
  5.64877503e-02f, 1.17892362e-01f, 6.03482090e-02f, 4.12495807e-02f, 1.22023448e-01f, -3.87340188e-02f, -2.00209484e-04f, -1.10371336e-01f, 9.52283964e-02f, -8.37983377e-03f,
  7.68124461e-02f, 1.34433387e-02f, 6.16886243e-02f, 5.40930592e-02f, 2.04540920e-02f, -5.75684085e-02f, -8.42989683e-02f, -8.70710984e-03f, -2.31917202e-02f, 1.92867665e-04f,
  2.49979738e-02f, 3.24066281e-02f, 6.81396723e-02f, 2.90129185e-02f, -4.86624287e-03f, 1.09547444e-01f, -7.06403404e-02f, -4.54091933e-03f, -1.40692631e-03f, 3.40020657e-03f,
  -3.59086603e-01f, -4.39269282e-02f, 3.83316390e-02f, 1.45809546e-01f, -1.20665334e-01f, -3.63715068e-02f, -2.36295070e-02f, -3.44554782e-02f, -1.58205777e-01f, 7.79803023e-02f,
  -4.90195416e-02f, 3.75509635e-02f, -2.96794041e-03f, -5.19086793e-02f, -1.37225455e-02f, -8.03810284e-02f, -1.16374195e-01f, -1.40033606e-02f, -4.61483337e-02f, -1.25983357e-01f,
  -1.32583708e-01f, -1.45290241e-01f, -1.71293229e-01f, -1.56768814e-01f, -1.85083330e-01f, -1.84163764e-01f, -1.68583125e-01f, -1.19534887e-01f, -2.74446160e-02f, 3.60639952e-02f,
  1.04681015e-01f, 8.26856643e-02f, -1.25162527e-01f, -8.46390799e-02f, -3.98002565e-01f, -4.48145866e-01f, -4.37175989e-01f, -2.53690898e-01f, -1.18755586e-01f, -1.02612928e-01f,
  6.80026487e-02f, 2.34546825e-01f, 4.25453067e-01f, 2.02638611e-01f, 1.43225998e-01f, -1.40484720e-01f, -1.04940280e-01f, -3.37567702e-02f, -2.86420360e-02f, -3.78850907e-01f,
  -2.20696464e-01f, -1.84198707e-01f, -1.47692397e-01f, -1.24225490e-01f, 2.03006882e-02f, 1.00712217e-01f, -1.27989491e-02f, -1.82186216e-02f, -9.72668380e-02f, -1.19848050e-01f,
  5.41743040e-01f, -2.60115623e-01f, -3.88184562e-02f, -1.24453353e-02f, -8.55035931e-02f, -1.11704003e-02f, -4.77097295e-02f, -3.76856439e-02f, -3.38424183e-02f, 1.68165434e-02f,
  2.31244452e-02f, -2.57570781e-02f, -1.67052038e-02f, -2.77561415e-02f, -4.15693894e-02f, -5.75159751e-02f, -1.48633182e-01f, -1.52105659e-01f, -2.26627290e-02f, -1.06033280e-01f,
  -6.35304525e-02f, -1.35853395e-01f, 6.71544671e-02f, -1.09897025e-01f, -1.94783628e-01f, -6.42513633e-02f, 5.03850430e-02f, -1.49072811e-01f, -8.07600990e-02f, -5.86799867e-02f,
  -2.01064236e-02f, 1.38847321e-01f, -4.96210419e-02f, -2.74214242e-02f, 7.76302293e-02f, 3.12369354e-02f, 4.31059934e-02f, 1.16694435e-01f, -5.99809401e-02f, 6.72055483e-02f,
  3.83165153e-03f, -2.02276986e-02f, 3.90778258e-02f, 1.02489442e-01f, 2.88832970e-02f, -1.06824681e-01f, -3.84123735e-02f, 4.69751470e-02f, -5.54914214e-02f, -6.60945103e-02f,
  -1.56877586e-03f, 8.27144459e-03f, -2.73307152e-02f, 3.73193771e-02f, -1.26357824e-01f, -1.52200181e-02f, -6.34120628e-02f, -7.64957145e-02f, 1.90468098e-03f, -7.35633001e-02f,
  5.57780266e-01f, -3.36055197e-02f, 2.77467936e-01f, 1.79145206e-03f, -9.72764790e-02f, -9.74800158e-03f, 2.94251908e-02f, -3.30803245e-02f, 4.45631742e-02f, -9.59794819e-02f,
  -9.17132348e-02f, -2.79033966e-02f, 1.10535257e-01f, -5.48761860e-02f, -7.45777190e-02f, -5.95270433e-02f, -5.20795621e-02f, 4.28922288e-03f, -1.14794590e-01f, -1.44137338e-01f,
  -8.85934904e-02f, 3.09570413e-03f, 2.75002658e-01f, 2.15072677e-01f, 4.30987738e-02f, 2.14137167e-01f, 2.61417985e-01f, 5.16368859e-02f, 1.32405415e-01f, 2.13649571e-01f,
  -2.49395430e-01f, -1.99052021e-01f, 2.15651765e-01f, -2.64039755e-01f, -5.91943003e-02f, -1.16497487e-01f, -3.67435277e-01f, -1.99118465e-01f, -3.11032057e-01f, -2.59163678e-01f,
  -2.29767729e-02f, -5.79343513e-02f, -5.11282757e-02f, 4.46552634e-02f, -5.11763021e-02f, -2.71581590e-01f, -6.06743842e-02f, 1.95418805e-01f, 2.68880695e-01f, 1.04386760e-02f,
  -9.22825187e-02f, 3.25048380e-02f, 2.26652324e-01f, -3.31664570e-02f, -2.52965778e-01f, -6.60102442e-02f, 6.97305705e-03f, 6.29312173e-03f, 9.45352986e-02f, -2.64323860e-01f,
  -1.72423661e-01f, -1.90844849e-01f, 1.64658278e-01f, 4.75189276e-02f, 9.11229998e-02f, -8.94425623e-03f, -7.78187066e-02f, -6.25876561e-02f, -9.17538330e-02f, -6.94344565e-02f,
  -5.42451255e-02f, 2.55230498e-02f, -6.31451905e-02f, -1.31050289e-01f, -4.35120836e-02f, -1.31093040e-01f, 6.06815964e-02f, 7.93457031e-02f, 9.72404517e-03f, -4.41580638e-02f,
  -1.24350071e-01f, -1.36646135e-02f, 4.83979238e-03f, 5.38658164e-02f, -1.24337807e-01f, 1.14442281e-01f, 2.78254002e-02f, -1.73860654e-01f, 7.49912336e-02f, -1.65498689e-01f,
  4.89614382e-02f, 3.34838927e-02f, 3.73963118e-02f, -3.10583841e-02f, 3.90340537e-02f, -6.12329058e-02f, -1.99945401e-02f, 1.93388145e-02f, 3.02567519e-02f, -7.03886151e-02f,
  5.30705899e-02f, 3.89111303e-02f, -4.89970483e-02f, -5.64974174e-02f, 1.03119975e-02f, -5.29383495e-03f, 4.96751368e-02f, -8.11100937e-03f, -9.48922336e-03f, 6.99095577e-02f,
  -1.94997760e-04f, 1.71597432e-02f, 5.30506149e-02f, -5.67801930e-02f, -1.34189771e-02f, -5.48524372e-02f, -7.56495222e-02f, -2.42076833e-02f, -6.74323589e-02f, -6.99129049e-03f,
  -1.48407340e-01f, 6.22563362e-01f, -2.02386856e-01f, -1.90207079e-01f, -1.50814354e-01f, 6.96705207e-02f, -1.00462146e-01f, 2.92701069e-02f, 4.68751490e-02f, -4.10385877e-02f,
  -5.43958731e-02f, -4.35122848e-02f, -1.05396599e-01f, -6.60163015e-02f, 5.16987331e-02f, -1.18009843e-01f, -5.03611891e-03f, -1.04438581e-01f, -1.40065653e-02f, -1.92250103e-01f,
  -7.29161352e-02f, -2.10379928e-01f, -1.93993449e-01f, -1.44540623e-01f, -1.62517533e-01f, -4.80620414e-02f, -7.36199841e-02f, -1.51914433e-01f, -7.33321980e-02f, -1.89038306e-01f,
  1.76059544e-01f, -5.17398976e-02f, 5.58179796e-01f, 2.55483061e-01f, 5.81767499e-01f, 6.89667225e-01f, 6.31781578e-01f, 2.95594811e-01f, -6.16726615e-02f, -1.51337143e-02f,
  2.33014505e-02f, -3.22770208e-01f, -2.39810750e-01f, -2.13307977e-01f, -5.71277291e-02f, 6.35324046e-02f, 1.25307009e-01f, 1.39895678e-01f, 1.83491036e-01f, 5.90909086e-02f,
  -1.94509685e-01f, 1.85083061e-01f, 5.21324612e-02f, -6.31467998e-02f, -1.62815563e-02f, -1.80141807e-01f, 1.94039777e-01f, 9.51072499e-02f, -2.75699310e-02f, -3.60140681e-01f,
  -1.26791537e-01f, 1.75016358e-01f, -5.29723950e-02f, -2.70646363e-01f, 1.52919412e-01f, -2.21103877e-01f, 4.66530211e-03f, -1.03039049e-01f, -2.94245780e-02f, -2.32460443e-02f,
  2.14948207e-02f, 4.50154729e-02f, 3.29985768e-02f, -6.31593354e-03f, 2.12241948e-01f, -4.70081866e-02f, -1.00685982e-03f, -1.08117657e-03f, -6.96086884e-02f, -1.41260266e-01f,
  -1.92453980e-01f, 2.82107163e-02f, 2.86866099e-01f, 1.52378395e-01f, 4.01076972e-02f, 1.07523128e-01f, 1.35582089e-01f, -5.32861128e-02f, 9.83712673e-02f, -2.42726818e-01f,
  -2.27539870e-03f, 3.79275903e-02f, 5.37939444e-02f, -4.00919579e-02f, -2.79806331e-02f, 3.62761342e-03f, -1.44431880e-02f, 1.03905387e-01f, 1.97089538e-02f, 9.31580886e-02f,
  1.13390759e-01f, 3.96279581e-02f, 7.61046484e-02f, 3.08270138e-02f, -2.40312107e-02f, 8.52316059e-03f, 1.59306098e-02f, -6.45951927e-02f, 3.54743451e-02f, -1.48430234e-02f,
  -2.09610332e-02f, 3.66363637e-02f, 1.06814064e-01f, -9.27039236e-03f, 4.88142446e-02f, 5.81547171e-02f, -5.55609837e-02f, -2.36318652e-02f, -7.02392403e-03f, -3.47229727e-02f,
  -2.51654714e-01f, 3.61389041e-01f, -3.81757200e-01f, -1.85146391e-01f, 1.31889284e-01f, -1.32876635e-01f, -1.19467288e-01f, -1.18552923e-01f, 5.80001473e-02f, -9.80062038e-02f,
  -7.64230546e-03f, -3.59082893e-02f, 2.89646927e-02f, -8.05055127e-02f, 7.45090246e-02f, 2.51883473e-02f, -6.17251135e-02f, 5.05778864e-02f, -3.56171206e-02f, -1.15950957e-01f,
  -1.70053244e-01f, 1.41849685e-02f, -3.53106810e-03f, -2.34524496e-02f, -6.25531599e-02f, -2.73331883e-04f, -1.10634556e-02f, -2.74458602e-02f, 1.59793511e-01f, -2.66279489e-01f,
  -7.93953240e-01f, -3.49986166e-01f, -4.25191492e-01f, -3.16794932e-01f, 2.28636160e-01f, 5.23832366e-02f, -5.68397902e-02f, -6.86879605e-02f, -2.91566029e-02f, -1.12881385e-01f,
  8.41574669e-02f, 1.44390568e-01f, 1.56596443e-03f, 5.84605001e-02f, -9.08462778e-02f, -1.00491963e-01f, -1.03766702e-01f, -1.14312500e-01f, 6.16657957e-02f, 2.58627653e-01f,
  2.42740884e-01f, -2.20609084e-02f, -2.58048475e-01f, -7.04149753e-02f, -6.90187141e-02f, 5.92911914e-02f, -9.60165039e-02f, -2.25206316e-02f, 3.07222232e-02f, 5.94303198e-02f,
  -8.73309821e-02f, -3.20041269e-01f, 1.33636490e-01f, 1.87732190e-01f, 4.06314014e-03f, -6.04120567e-02f, -5.45824580e-02f, -4.63436134e-02f, -9.12228525e-02f, -8.58647153e-02f,
  -3.33383051e-03f, 2.72566359e-02f, 2.45343987e-02f, -2.32763141e-02f, -9.16358754e-02f, -3.63073908e-02f, -1.26585677e-01f, -2.47305185e-01f, -2.22948954e-01f, -3.68291959e-02f,
  1.74597174e-01f, 9.68646184e-02f, -3.23258817e-01f, -1.61799431e-01f, -1.09332904e-01f, -1.94958411e-02f, -2.13819653e-01f, -1.35079280e-01f, -1.97820008e-01f, -3.79190773e-01f,
  6.06589019e-02f, 1.48112541e-02f, 5.91481738e-02f, -6.53218552e-02f, 4.03991751e-02f, -4.35794890e-02f, 2.41716877e-02f, -2.01347936e-02f, 5.41562140e-02f, 2.74166111e-02f,
  2.16381513e-02f, 2.73645204e-02f, 1.66666079e-02f, -2.86581386e-02f, 5.48936687e-02f, -3.50225456e-02f, -7.05410028e-03f, -3.62159386e-02f, -3.12777646e-02f, -7.10757729e-03f,
  -3.81676853e-02f, -1.06139155e-02f, -2.33244943e-03f, 6.67822808e-02f, 3.76242138e-02f, -6.69276400e-04f, 3.58582065e-02f, 5.87538444e-02f, -1.41339935e-02f, -3.06718219e-02f,
  -3.17677349e-01f, 2.23943070e-01f, -9.48653445e-02f, 4.13751550e-04f, -5.74338734e-02f, -3.57484333e-02f, 1.54030425e-02f, -1.51149016e-02f, -9.77239981e-02f, -1.44075066e-01f,
  4.97814380e-02f, -1.33898035e-01f, -1.76173151e-01f, 3.85572314e-02f, -1.26058683e-02f, -1.36727933e-02f, -3.51268910e-02f, -1.22974008e-01f, 2.92594861e-02f, -9.33365896e-02f,
  -8.37792829e-02f, -2.36873403e-01f, -3.45718741e-01f, -2.55522817e-01f, -1.82118297e-01f, -2.20584705e-01f, -3.01382273e-01f, -2.37884477e-01f, -3.75158161e-01f, -5.18714964e-01f,
  8.31565782e-02f, 5.26768684e-01f, 1.30507454e-01f, 2.65117735e-01f, 2.72692479e-02f, -1.54027209e-01f, -9.44457576e-02f, -2.87262388e-02f, 2.07257167e-01f, 2.42436692e-01f,
  1.74593106e-01f, -3.47012788e-01f, -3.14161003e-01f, -4.29266274e-01f, -5.41884422e-01f, -2.14485042e-02f, -1.52988046e-01f, -6.56320691e-01f, -8.96048725e-01f, -5.81517160e-01f,
  -3.21043700e-01f, -3.55025470e-01f, -2.43128255e-01f, -1.66016012e-01f, 1.43886626e-01f, -6.46140650e-02f, 3.07392567e-01f, -4.97435629e-02f, -1.02020808e-01f, 1.00841308e-02f,
  -1.90051779e-01f, 2.58004218e-01f, -2.78779447e-01f, -1.40716687e-01f, 1.11990288e-01f, 2.62927916e-02f, -1.83595493e-02f, 5.08310869e-02f, 5.16582504e-02f, 2.01024506e-02f,
  2.73653045e-02f, -4.63934317e-02f, -3.37076075e-02f, -1.19287863e-01f, -5.38828410e-02f, -1.22208998e-01f, -7.32207000e-02f, -2.71770447e-01f, -1.61157042e-01f, -1.65909361e-02f,
  2.64830850e-02f, -6.37522638e-02f, -1.77210033e-01f, 3.69406827e-02f, 1.33393053e-02f, -2.17096359e-01f, 9.28091332e-02f, 7.52164200e-02f, -7.03678280e-02f, 1.31200224e-01f,
  -3.56723256e-02f, -1.01389792e-02f, -2.65930314e-03f, 5.36662266e-02f, 6.86032744e-03f, 1.41840667e-01f, -4.78534885e-02f, -5.46932817e-02f, -4.57284339e-02f, 1.56611297e-02f,
  1.80628970e-02f, 8.64043608e-02f, 4.06964421e-02f, -2.13300921e-02f, -1.41187217e-02f, 2.64075454e-02f, -1.10638076e-02f, 2.82035116e-02f, -1.34392511e-02f, 2.60541104e-02f,
  -9.12965685e-02f, -2.93725040e-02f, 6.79054260e-02f, -2.11821347e-02f, -4.30533439e-02f, 5.39867282e-02f, -9.76832118e-03f, -8.03599879e-02f, 2.15879958e-02f, 5.30409738e-02f,
  1.27490878e-01f, -2.41181269e-01f, -1.83547232e-02f, -1.04084052e-01f, 8.96567106e-02f, 5.37962094e-02f, 1.28686592e-01f, 3.76208164e-02f, 9.20713395e-02f, -8.42868239e-02f,
  -8.74419063e-02f, -2.12722067e-02f, 1.17797382e-01f, -6.19858503e-02f, -2.06718102e-01f, -9.67874974e-02f, 1.33100092e-01f, -1.46656960e-01f, -1.10211387e-01f, 9.23550203e-02f,
  1.29926816e-01f, -1.58076420e-01f, -1.75081700e-01f, -7.00040162e-02f, -5.93150929e-02f, -2.64502347e-01f, -1.80930212e-01f, -1.58712193e-01f, -2.59816259e-01f, 1.82221517e-01f,
  -9.41291451e-02f, 7.33205229e-02f, -2.77417719e-01f, -1.32244574e-02f, -5.82507215e-02f, -4.63258699e-02f, 1.16144903e-01f, 1.71820432e-01f, 7.42928833e-02f, 1.08451955e-01f,
  -5.77662848e-02f, -3.49311344e-02f, -1.08310372e-01f, 3.51129263e-03f, -4.17759195e-02f, -2.09130775e-02f, -2.08683282e-01f, -2.12582111e-01f, -7.78552517e-02f, 1.86376885e-01f,
  4.92771938e-02f, 1.56237945e-01f, 5.87691963e-02f, -1.59804691e-02f, 6.65306970e-02f, -8.09517503e-02f, -2.66995677e-03f, -9.18438956e-02f, -2.20176116e-01f, -1.42548844e-01f,
  1.89075455e-01f, -3.50264132e-01f, -5.58162369e-02f, -1.25504419e-01f, -8.17407742e-02f, -1.33971199e-01f, 2.96956673e-03f, -1.59642268e-02f, -1.12715997e-01f, -5.65180257e-02f,
  -9.55883563e-02f, -1.20351620e-01f, -6.50209859e-02f, 7.83491880e-02f, 3.97288287e-03f, 1.31112030e-02f, -1.96222384e-02f, -9.09574255e-02f, -2.54586246e-02f, -6.40394092e-02f,
  -8.20603129e-03f, -2.19028428e-01f, -2.03705490e-01f, -2.08478291e-02f, -2.28621438e-01f, -1.74528122e-01f, -1.81260183e-02f, -1.11958995e-01f, -1.02096841e-01f, 1.64666817e-01f,
  1.19309723e-01f, -9.11883637e-02f, 2.23954599e-02f, 4.62099835e-02f, 2.30223667e-02f, 1.37182185e-02f, 6.12412095e-02f, 2.49096882e-02f, 1.26326904e-01f, 6.38229251e-02f,
  2.88714692e-02f, 2.79139336e-02f, 5.35473637e-02f, 4.39823419e-03f, -8.45445972e-03f, -2.48704385e-02f, -6.29214346e-02f, 1.33225352e-01f, -7.58664384e-02f, 1.49781369e-02f,
  -2.77283173e-02f, -6.42537251e-02f, 4.17542681e-02f, -3.79513833e-03f, -1.28107205e-01f, -7.32708797e-02f, -2.05432475e-02f, 7.89630935e-02f, -1.91847160e-02f, 4.96935658e-03f,
  6.77106857e-01f, -3.60591590e-01f, -2.47678868e-02f, 1.33678503e-02f, -3.53974253e-02f, 1.00249685e-02f, -5.84230162e-02f, -4.12195735e-02f, -6.99668378e-02f, 9.74403173e-02f,
  -1.23172782e-01f, 1.25343483e-02f, 2.76907105e-02f, 3.90252285e-02f, 1.03832588e-01f, 2.76648607e-02f, 6.42254800e-02f, -4.44198698e-02f, -9.73123387e-02f, 5.93706928e-02f,
  2.09984984e-02f, 1.34189650e-01f, 1.17628135e-01f, 3.34849544e-02f, 6.30167350e-02f, -8.29053670e-02f, 1.88934892e-01f, 1.29435256e-01f, -6.17219694e-03f, 4.81718212e-01f,
  -1.27800971e-01f, -6.64316118e-02f, -2.73705320e-03f, 2.28827059e-01f, -7.43157864e-02f, -5.62085867e-01f, -6.37817681e-01f, -3.09698910e-01f, -1.13438234e-01f, -1.45462111e-01f,
  -1.18713737e-01f, 5.38253691e-03f, 8.03397223e-02f, 9.81904864e-02f, -1.07306726e-01f, 2.48268526e-02f, 3.29232723e-01f, 2.88783133e-01f, -6.68363497e-02f, -2.47852251e-01f,
  1.47370011e-01f, 2.31780753e-01f, 1.33311883e-01f, 1.34761155e-01f, 3.31948221e-01f, 1.33729994e-01f, 2.19556928e-01f, 2.18750954e-01f, -1.25717632e-02f, 5.96955895e-01f,
  -9.31055099e-02f, -2.00857669e-01f, -1.68583598e-02f, 1.03079386e-01f, 1.05937548e-01f, 3.11494581e-02f, -1.43260658e-01f, 1.22353427e-01f, -4.18108292e-02f, -2.85963193e-02f,
  8.27882290e-02f, 1.75410397e-02f, 6.42826827e-03f, 4.30546068e-02f, -7.59371817e-02f, -1.11080930e-01f, -2.47925404e-03f, 1.80824682e-01f, 2.09025554e-02f, -9.81696770e-02f,
  8.19250569e-02f, -1.30403414e-01f, -2.20155090e-01f, -1.63007602e-01f, 9.50232521e-03f, 2.47154273e-02f, -1.13322921e-01f, -9.66321751e-02f, -2.36575231e-01f, -5.51531976e-03f,
  -3.32146212e-02f, -2.23134458e-02f, -6.24821968e-02f, 1.97545323e-03f, 4.06791456e-02f, 1.24091906e-02f, 1.08354472e-01f, 3.95634919e-02f, 4.39495686e-03f, 1.04890160e-01f,
  -4.98298043e-03f, -8.87728482e-02f, -1.88988727e-02f, 6.88696513e-03f, 7.74011090e-02f, 2.48203836e-02f, 1.06685935e-02f, 2.12575141e-02f, -7.27825612e-02f, -3.12189329e-02f,
  2.80709490e-02f, -6.53410628e-02f, 8.73525962e-02f, 7.95002468e-03f, -7.36175757e-03f, 5.77647984e-02f, 4.50060405e-02f, -6.96915463e-02f, -5.24410456e-02f, -8.82952940e-03f,
  -1.28284886e-01f, -1.90808237e-01f, -1.96140364e-01f, -4.90211807e-02f, 1.51835391e-02f, -2.22915970e-03f, 9.82341450e-03f, -9.48171970e-03f, 3.16476263e-02f, -1.47011340e-01f,
  -1.62127003e-01f, -8.98596197e-02f, -5.06446101e-02f, -8.14065188e-02f, -7.00856373e-02f, -1.62393317e-01f, -6.53437600e-02f, -8.06775503e-03f, -1.16413809e-01f, -1.39206767e-01f,
  2.70649865e-02f, -4.04926211e-01f, -4.46765602e-01f, -2.64457315e-01f, -2.57776052e-01f, -2.60635823e-01f, -2.91318536e-01f, -2.13384882e-01f, -4.81687248e-01f, -3.37230146e-01f,
  1.96852356e-01f, 2.51427889e-01f, -1.60687387e-01f, 2.97640622e-01f, 3.93988699e-01f, 3.08621526e-02f, -2.90558636e-02f, -2.25040168e-01f, 1.27937272e-01f, 2.43023679e-01f,
  4.29165930e-01f, 5.32931507e-01f, 1.70401141e-01f, 1.10693403e-01f, -1.19366854e-01f, -2.21783996e-01f, -6.99722841e-02f, -1.70416653e-01f, -2.56364405e-01f, 2.80203745e-02f,
  4.25728589e-01f, 2.05484450e-01f, 2.89976634e-02f, -1.28502650e-02f, 3.46313566e-01f, 2.88621396e-01f, 1.29944989e-02f, 2.31861755e-01f, 2.54963607e-01f, 3.24802548e-01f,
  2.44310811e-01f, 2.66481321e-02f, -1.88540071e-01f, 1.72425300e-01f, 1.07996240e-01f, -5.26218303e-02f, 3.82222682e-02f, -1.69478327e-01f, 8.89200345e-02f, -3.78910825e-02f,
  5.91658130e-02f, 9.38312709e-02f, 1.19752318e-01f, 8.01707059e-03f, -5.44182211e-02f, -1.64766923e-01f, -2.11298689e-01f, -2.10871920e-01f, -1.92568555e-01f, -3.12450435e-02f,
  3.24042827e-01f, 1.95313647e-01f, -1.21141702e-01f, -2.35920474e-01f, -1.71535939e-01f, 2.79124044e-02f, -6.22780435e-02f, -8.47298373e-03f, -2.22456232e-01f, 6.29757950e-03f,
  9.53285471e-02f, -2.63520591e-02f, 6.77217320e-02f, 2.47743521e-02f, -1.31783774e-02f, 2.60578524e-02f, -3.40031460e-02f, 9.91834402e-02f, -3.99765819e-02f, 6.16073757e-02f,
  -2.63601243e-02f, 2.42633168e-02f, -2.01101936e-02f, -1.89188831e-02f, 1.26366466e-01f, 1.45636210e-02f, -1.41128041e-02f, -3.51857743e-04f, 2.34401915e-02f, 7.78391864e-03f,
  3.87481637e-02f, -4.43034098e-02f, -1.79554019e-02f, -9.05659944e-02f, -7.10596505e-04f, -4.07963283e-02f, -3.90004255e-02f, 7.75333345e-02f, 2.00606454e-02f, 9.25699696e-02f,
  4.74786945e-02f, -1.68952480e-01f, 9.45810974e-02f, -9.73281264e-02f, 1.73315611e-02f, 8.17062985e-03f, 1.85542285e-01f, -3.77237834e-02f, 8.09925869e-02f, 2.39609331e-02f,
  7.59802610e-02f, -1.02386966e-01f, -4.73725051e-02f, -1.36610270e-01f, -8.10841173e-02f, -1.50618302e-02f, 5.69449514e-02f, 3.57818371e-03f, -4.10380326e-02f, -2.86646169e-02f,
  1.52351242e-02f, -3.81114520e-02f, -7.38034993e-02f, -1.32569134e-01f, -3.00189015e-02f, 3.76165332e-03f, -1.33341238e-01f, -1.16538249e-01f, -2.56621957e-01f, -6.41962960e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  2.69713134e-01f, 3.16925406e-01f, 1.11395970e-01f, 4.78825778e-01f, 7.02337027e-01f, 2.19261587e-01f, 3.00448209e-01f, 5.40049970e-01f, 5.82124412e-01f, 3.65651667e-01f,
  7.06008554e-01f, 3.06974500e-01f, 5.30824184e-01f, 3.14961314e-01f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -8.13098609e-01f, 2.67572761e-01f, 7.25354825e-04f, 2.50630319e-01f, 1.20146275e+00f, -3.52272332e-01f, -4.12262380e-01f, -1.89728171e-01f, -4.52023476e-01f, 3.17142248e-01f,
  -8.75312090e-02f, 8.06686282e-01f, -2.61479080e-01f, 3.57504487e-01f, -4.65265125e-01f, -2.17394710e-01f, -5.56592941e-01f, -8.64969552e-01f, -5.05674839e-01f, 3.44951786e-02f,
  1.21494102e+00f, -6.81236446e-01f, 7.75506556e-01f, 9.26187992e-01f, 8.07046175e-01f, 1.80704668e-02f, 3.03107262e-01f, -5.49737394e-01f, -8.45970988e-01f, -6.30245149e-01f,
  -4.39640850e-01f, 3.33198160e-01f, 1.91858351e-01f, -1.05280042e+00f, 1.43743858e-01f, 3.59978341e-02f, -5.09190202e-01f, -5.78555048e-01f, -2.86377698e-01f, 1.58014521e-02f,
  -1.57234251e-01f, 1.15954900e+00f, 2.12808236e-01f, 2.31916055e-01f, -5.99190056e-01f, -2.53200114e-01f, 7.83964753e-01f, -7.03373790e-01f, -4.52513367e-01f, -3.13290417e-01f,
  2.39952937e-01f, 8.84345531e-01f, -8.63421202e-01f, 9.69561398e-01f, -1.88552722e-01f, -2.07190752e-01f, -3.92189443e-01f, 4.37810570e-01f, -2.39323288e-01f, 7.63509750e-01f,
  3.19642276e-01f, -2.95081168e-01f, -8.24576318e-01f, -4.15334165e-01f, -5.65416276e-01f, -7.39429235e-01f, -1.65609434e-01f, 3.03206056e-01f, -3.53108793e-01f, -4.98391658e-01f,
  -3.41029555e-01f, -2.28216916e-01f, 3.06650430e-01f, -5.66636249e-02f, -5.78285083e-02f, 7.06763119e-02f, 1.38511598e+00f, -1.53478637e-01f, 1.77612036e-01f, 2.20821239e-02f,
  6.14610851e-01f, -8.95112380e-03f, 6.71877146e-01f, -4.46943641e-01f, 9.40849066e-01f, -1.53314501e-01f, 8.25930595e-01f, 5.98477460e-02f, 1.34220570e-01f, -2.89112717e-01f,
  -4.12073493e-01f, -4.00743604e-01f, 5.76237321e-01f, 6.31395459e-01f, -2.08144352e-01f, 3.19266528e-01f, 4.15504694e-01f, 5.53610802e-01f, -3.86545599e-01f, -3.54359657e-01f,
  -1.90022215e-01f, 2.45431229e-01f, -4.26568985e-01f, 1.22169673e+00f, -1.48526892e-01f, -2.55133271e-01f, -5.49753189e-01f, -8.14688385e-01f, -4.02356595e-01f, -2.66435891e-01f,
  8.19252133e-01f, -1.82854071e-01f, -3.30761582e-01f, -8.45617130e-02f, 4.50584859e-01f, -2.99491733e-01f, -3.66554409e-01f, 9.20883894e-01f, 2.27105469e-01f, -7.28537738e-01f,
  -4.12407458e-01f, -6.99436665e-01f, 2.55026519e-01f, 5.04338086e-01f, -5.99108577e-01f, 2.68749241e-02f, 5.52744329e-01f, 5.48836470e-01f, -2.96840966e-01f, 5.96205294e-01f,
  1.33930743e-02f, -5.23492284e-02f, -1.63023070e-01f, -2.80569643e-01f, 1.38593221e+00f, -4.18238789e-01f, -2.48523176e-01f, -5.23047782e-02f, 8.71417046e-01f, -1.61617517e-01f,
  -6.01847053e-01f, 1.77608207e-01f, -3.27401280e-01f, -4.68788147e-01f, 6.27767861e-01f, 5.79425395e-01f, 1.12505302e-01f, -2.91017264e-01f, -1.52324691e-01f, -6.74306870e-01f,
  -4.81320918e-01f, -4.59710211e-01f, -3.99097838e-02f, 5.04700132e-02f, -5.91508210e-01f, 4.79187191e-01f, 2.10433125e-01f, -3.54976296e-01f, 8.31289351e-01f, 1.19563639e+00f,
  1.85635209e-01f, 5.57791233e-01f, -1.87321771e-02f, 6.08234465e-01f, -4.84699100e-01f, -3.70997369e-01f, -2.98059583e-01f, -1.94545478e-01f, 1.16413176e+00f, -5.43248467e-02f,
  -2.66608328e-01f, -3.60220581e-01f, -5.43299794e-01f, 8.94146502e-01f, -2.21074000e-01f, 4.65481281e-02f, 2.14288056e-01f, 1.24191709e-01f, -3.74808103e-01f, -8.60797465e-02f,
  -1.28827527e-01f, 7.82714903e-01f, -5.20355701e-01f, 4.70002256e-02f, -1.88895524e-01f, 1.11324616e-01f, 1.31420350e+00f, -5.10797977e-01f, 3.99109453e-01f, -5.38087748e-02f,
  -4.65519607e-01f, 4.29482497e-02f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.36337265e-01f, 1.29747286e-01f, 4.42776293e-01f, 1.47234261e-01f, -1.16222262e-01f, -2.04855829e-01f, 3.29460263e-01f, -2.29966387e-01f, 2.11876273e-01f, -6.88798279e-02f,
  -2.03488559e-01f, -1.09065294e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 1, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    