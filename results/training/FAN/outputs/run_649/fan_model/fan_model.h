/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  4.31051582e-01f, -4.42886502e-01f, 1.04984269e-01f, 1.94069788e-01f, -1.12616211e-01f, -1.85020734e-02f, -2.61694759e-01f, 9.65593848e-03f, 1.41302571e-01f, -9.05445814e-02f,
  -1.68521464e-01f, -3.76615748e-02f, 3.36300097e-02f, 2.89860200e-02f, 8.48084688e-02f, -2.10426182e-01f, 4.66133505e-02f, 1.81450129e-01f, 3.06312621e-01f, 6.35673776e-02f,
  -2.41350710e-01f, 1.00512527e-01f, 3.09499741e-01f, 1.88735589e-01f, -2.10065767e-01f, -3.69294807e-02f, -1.55069551e-03f, -1.39884427e-01f, -2.62421578e-01f, -3.99856538e-01f,
  3.40189114e-02f, -1.96337223e-01f, 1.20318003e-01f, -9.04738531e-02f, -5.88473231e-02f, 9.64475274e-02f, 9.48315710e-02f, 3.89361642e-02f, -4.92204018e-02f, 8.75997394e-02f,
  -5.93138225e-02f, -4.17564763e-03f, -1.53975487e-02f, -1.73718315e-02f, -5.46599999e-02f, 3.71970274e-02f, -2.70538335e-03f, 4.85692509e-02f, 1.47160022e-02f, -3.97791853e-03f,
  -2.09380403e-01f, -1.56209379e-01f, -8.58309045e-02f, 3.64653990e-02f, -8.82548653e-03f, 4.05763247e-04f, -1.68012492e-02f, -3.81291434e-02f, 1.58376017e-04f, -5.00511285e-03f,
  -2.85037756e-02f, -2.03912593e-02f, 1.13016125e-02f, -6.35987446e-02f, -9.53444652e-03f, 1.89469731e-03f, 3.50331143e-02f, -2.21554060e-02f, 3.28475125e-02f, 2.56590117e-02f,
  4.72988747e-02f, -5.66057302e-02f, 1.90422442e-02f, 3.20240445e-02f, -6.38189316e-02f, 9.68429318e-04f, 4.25708331e-02f, -2.89538149e-02f, 2.17329813e-04f, -8.21329206e-02f,
  -4.53905500e-02f, 6.89753890e-02f, 3.90473474e-03f, -2.26092860e-02f, -1.93482637e-02f, 1.49905523e-02f, -1.61353461e-02f, 5.89769334e-03f, 3.37681659e-02f, -3.89964171e-02f,
  1.95261657e-01f, 1.10432142e-02f, -3.18063498e-02f, -4.69294563e-02f, -1.21027017e-02f, 2.99682864e-03f, 2.01782100e-02f, -8.61223936e-02f, -5.90967163e-02f, -9.13276374e-02f,
  2.08208635e-02f, 8.29573944e-02f, 3.19044152e-03f, -1.91047434e-02f, 4.10144180e-02f, -2.49951053e-03f, -8.22534859e-02f, 5.03107123e-02f, -1.64718681e-03f, -8.03546384e-02f,
  4.44993898e-02f, 3.24961580e-02f, 1.35921553e-01f, -9.01002530e-03f, -1.31967990e-02f, 1.15391232e-01f, 3.58054601e-02f, 1.13234930e-01f, 1.43515214e-01f, 1.34657413e-01f,
  -3.85341644e-01f, -3.32567036e-01f, -3.04550491e-02f, -2.41349861e-02f, 3.59207974e-03f, -5.91412447e-02f, -4.86551644e-03f, -6.89803213e-02f, 1.90870906e-03f, -1.62735641e-01f,
  -1.08027346e-01f, -5.40935285e-02f, -7.15189576e-02f, -5.11195324e-02f, -1.14223763e-01f, -1.41514137e-01f, -1.44710258e-01f, -4.65665311e-02f, 8.86736810e-03f, 4.00823653e-02f,
  -5.41069992e-02f, 9.04726461e-02f, -9.25590098e-03f, -3.67031842e-02f, 1.00463569e-01f, 1.42923355e-01f, 3.74030583e-02f, 1.80217121e-02f, 7.91221019e-03f, -9.71212983e-02f,
  -8.06751773e-02f, -2.26068273e-01f, 6.04831092e-02f, -3.13127078e-02f, -3.29834186e-02f, -1.84035394e-02f, -6.79299533e-02f, -3.64144370e-02f, -9.78766605e-02f, -1.07973833e-02f,
  -6.86297044e-02f, -8.39982629e-02f, -1.56744897e-01f, -7.80784264e-02f, -1.04164265e-01f, -9.20419246e-02f, -1.16315261e-01f, -1.48641899e-01f, -7.60625973e-02f, -1.56025574e-01f,
  -5.30210063e-02f, -9.72700417e-02f, -1.37917399e-01f, 1.61633920e-02f, -5.86161651e-02f, -5.39008155e-02f, -6.03278764e-02f, -1.20945886e-01f, 3.69181000e-02f, 3.80933061e-02f,
  -2.45301649e-02f, 2.88655013e-02f, -6.38359934e-02f, -1.13668993e-01f, 5.64690419e-02f, 3.35807800e-02f, -5.40066697e-02f, 9.77862068e-03f, 6.32133940e-03f, 9.18517560e-02f,
  1.47953490e-02f, 6.50424808e-02f, 7.43596330e-02f, 4.20277752e-02f, -1.87051506e-03f, -1.05245109e-03f, -3.64991724e-02f, 5.64673403e-03f, -2.86412216e-03f, -3.28926998e-03f,
  -3.52125391e-02f, -1.54549619e-02f, 4.66144085e-02f, 3.70627046e-02f, -3.84516641e-02f, -4.00098041e-02f, 4.40319069e-02f, 1.22119533e-02f, -3.78610124e-03f, 4.86298501e-02f,
  1.85489729e-01f, -1.22289076e-01f, 3.13161053e-02f, -6.15644753e-02f, 1.89728439e-02f, 1.74581707e-02f, -1.01642068e-02f, 3.18695009e-02f, -7.68000185e-02f, -1.61620062e-02f,
  -1.10721000e-01f, -1.58906654e-01f, -2.89827809e-02f, -1.06166989e-01f, 9.56839696e-02f, 1.00774327e-02f, -3.10105756e-02f, 4.27944995e-02f, -8.52229446e-02f, -6.74750805e-02f,
  -5.79105392e-02f, 9.36661288e-02f, 1.13962330e-01f, 3.55711095e-02f, -1.11142267e-02f, 3.61111462e-02f, 1.75916284e-01f, 1.98927194e-01f, 1.09287672e-01f, 3.43862623e-01f,
  -4.95529860e-01f, 4.12353843e-01f, 1.61593333e-02f, -1.91591412e-01f, -1.78050585e-02f, -2.95253117e-02f, 1.16234653e-01f, 2.49611773e-02f, -9.95125398e-02f, 1.75465196e-01f,
  3.29980820e-01f, 1.57588527e-01f, 2.43527815e-02f, 1.08743683e-01f, -5.73812723e-02f, 1.15034536e-01f, -1.88505292e-01f, -3.03761214e-01f, -2.68646091e-01f, -3.10756359e-02f,
  1.14865713e-01f, 4.15955782e-02f, -1.61887720e-01f, -2.43868846e-02f, -1.15803322e-02f, -2.61118058e-02f, 1.71183705e-01f, 1.24114238e-01f, 1.93153888e-01f, 4.16455008e-02f,
  2.87291128e-04f, 9.66161042e-02f, -3.40571627e-02f, -4.88824472e-02f, 5.33013791e-02f, -1.02654770e-01f, 1.48664815e-02f, -3.19297165e-02f, 7.28221238e-02f, -1.11901991e-01f,
  7.23208338e-02f, -4.58042547e-02f, -9.83570218e-02f, 2.89741047e-02f, -2.38162912e-02f, 3.37507688e-02f, 4.85609239e-03f, -5.35084419e-02f, 4.31250734e-03f, 3.35694402e-02f,
  -9.51073039e-03f, 4.86048572e-02f, 6.71324730e-02f, 3.18955444e-02f, 4.67448868e-02f, -1.61584720e-01f, 5.77948056e-02f, -4.77622673e-02f, -3.34708467e-02f, 6.17182851e-02f,
  3.29551473e-02f, -6.25323132e-02f, 9.89379268e-03f, -3.72409970e-02f, 1.59521736e-02f, 4.34343331e-03f, -7.82105140e-03f, -4.22679679e-03f, -7.36187175e-02f, 9.14427638e-03f,
  -7.43232071e-02f, -3.80732417e-02f, 9.63507965e-03f, -5.64684048e-02f, -7.87694082e-02f, -7.87100866e-02f, -1.45002991e-01f, -8.78923833e-02f, -4.74902056e-02f, -9.24168527e-02f,
  3.40591259e-02f, -6.53896034e-02f, 4.09273244e-03f, -5.40821180e-02f, -7.86303729e-02f, -5.47979325e-02f, -6.53291494e-02f, -6.12197556e-02f, -1.34540275e-01f, -4.13060002e-02f,
  2.45677844e-01f, 1.74675390e-01f, 2.44461801e-02f, 8.38287920e-02f, 9.59268678e-03f, 2.60921884e-02f, 7.19536319e-02f, -5.08688875e-02f, -4.69564972e-03f, -2.78195143e-02f,
  7.39642754e-02f, -4.95476983e-02f, 9.63576511e-02f, -2.00405419e-02f, -3.90935130e-02f, 2.80554127e-02f, 7.64765665e-02f, -8.70258659e-02f, 2.03547906e-02f, -7.82282650e-03f,
  3.87732275e-02f, -6.97591761e-03f, -2.94904914e-02f, -2.41731647e-02f, 5.88898957e-02f, 2.90530385e-03f, 8.89614820e-02f, 5.50924800e-02f, -3.73580307e-02f, 4.77739349e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.84003112e-02f, -1.99446797e-01f, -5.49534142e-01f, -1.62131384e-01f, -2.64388323e-01f, -3.91945958e-01f, -5.26565313e-01f, -6.16594367e-02f, 1.07592255e-01f, -3.86946112e-01f,
  -9.00546927e-03f, 1.81359500e-01f, -6.19522743e-02f, -1.52223274e-01f, -3.19241822e-01f, -5.50277054e-01f, -4.29224283e-01f, -3.21310222e-01f, -5.13545275e-02f, -1.13137692e-01f,
  -1.73203751e-01f, 1.23760449e-02f, -2.06497144e-02f, -4.92283516e-02f, 1.84513003e-01f, 1.23973891e-01f, -3.39619473e-05f, -5.54681905e-02f, -1.22438587e-01f, -7.66553879e-02f,
  4.94074710e-02f, 1.67861566e-01f, 1.63726062e-02f, 9.47626084e-02f, -1.28257141e-01f, 2.00518649e-02f, -8.57014731e-02f, 9.35721099e-02f, 1.32053718e-01f, -1.60576150e-01f,
  2.57584080e-02f, 1.48413721e-02f, -7.20952526e-02f, -3.83298509e-02f, -1.10443629e-01f, -1.79060802e-01f, -1.60229392e-02f, -1.29230902e-01f, -8.70393813e-02f, -3.11977454e-02f,
  -1.55646503e-01f, -1.68987468e-01f, -4.71699946e-02f, -2.72373483e-02f, 3.28190066e-02f, -1.50928134e-02f, 8.49914253e-02f, 1.26178861e-01f, 7.47307613e-02f, 1.95544198e-01f,
  1.28543433e-02f, 8.66832063e-02f, -3.69811766e-02f, 5.71544357e-02f, 6.71339259e-02f, 2.51314621e-02f, 1.55543372e-01f, 5.87336272e-02f, -1.92158821e-03f, -1.28453761e-01f,
  -7.24718124e-02f, -8.02861433e-03f, 1.22746378e-01f, -8.57716717e-04f, 4.84159738e-02f, -5.70792072e-02f, 1.17567815e-02f, -8.30852240e-02f, 1.53608350e-02f, 1.65401958e-02f,
  1.56875700e-01f, -1.12274885e-02f, 1.16887905e-01f, 2.52662927e-01f, -1.22937597e-01f, -8.19165036e-02f, 1.01068407e-01f, 6.75322041e-02f, 1.12501062e-01f, -9.07802507e-02f,
  3.51363152e-01f, -2.08540440e-01f, 1.57858361e-03f, 2.31630445e-01f, -5.83972596e-02f, -4.92414832e-02f, 4.72643264e-02f, -8.22747797e-02f, 1.10784760e-02f, -1.21466545e-02f,
  9.96250212e-02f, 2.58614216e-02f, -2.47969888e-02f, 3.22234221e-02f, -1.73226461e-01f, -1.18994132e-01f, -1.74453095e-01f, -4.12039496e-02f, -1.01117203e-02f, 2.12147529e-03f,
  -1.54981345e-01f, -1.84937224e-01f, -1.82579923e-03f, -7.19020516e-02f, 2.01299474e-01f, 8.90782177e-02f, 7.53073320e-02f, 1.06511839e-01f, 4.29958366e-02f, 8.55650082e-02f,
  -2.80126661e-01f, 5.03423214e-01f, -1.80575833e-01f, 1.14276677e-01f, 3.81586313e-01f, 2.95812130e-01f, 4.12805408e-01f, 1.29229337e-01f, -7.01851696e-02f, 1.47037044e-01f,
  1.48188874e-01f, 6.35586157e-02f, 1.47519976e-01f, 6.52233884e-02f, 8.64452273e-02f, 6.57666251e-02f, 8.45248923e-02f, -1.16206750e-01f, -2.36025587e-01f, -2.90522184e-02f,
  3.70339096e-01f, 1.27028674e-02f, -2.87602514e-01f, -5.39054573e-02f, 1.63300917e-01f, 4.65743504e-02f, -3.35152335e-02f, 1.61687687e-01f, 2.45987460e-01f, 1.60489932e-01f,
  -2.72049069e-01f, 2.00446993e-01f, -1.75260440e-01f, -1.24190070e-01f, 3.04021239e-02f, -1.21870488e-01f, -1.33247480e-01f, -2.05908895e-01f, -7.75135159e-02f, -2.10818902e-01f,
  3.97185050e-02f, 3.39702405e-02f, 9.72398520e-02f, -1.67459592e-01f, -6.93384781e-02f, -1.92089990e-01f, -1.26601130e-01f, -1.20243177e-01f, -3.44302833e-01f, -4.10256952e-01f,
  3.65395963e-01f, 2.47751877e-01f, -1.74097884e-02f, -1.12065554e-01f, -1.08664840e-01f, -1.68127149e-01f, -2.16100272e-02f, -9.54309665e-03f, -6.66458160e-02f, -3.12270820e-01f,
  3.69419018e-03f, 1.57302156e-01f, 4.71041091e-02f, 1.00549772e-01f, 1.00849815e-01f, -3.81253175e-02f, 1.28828483e-02f, 6.10142723e-02f, 4.97033149e-02f, 2.22547073e-03f,
  -1.15575865e-01f, -5.63241839e-02f, -2.81163491e-02f, 4.05814573e-02f, -1.07534556e-02f, 1.06034219e-01f, 7.29053691e-02f, -4.85281087e-02f, -5.85955642e-02f, 3.78269516e-02f,
  3.45026627e-02f, -8.57444704e-02f, -1.22003324e-01f, -1.02832422e-01f, -5.01048192e-02f, 1.27153948e-01f, -5.92649132e-02f, 4.33677211e-02f, 2.48519816e-02f, 9.88338143e-02f,
  -2.04082951e-01f, 1.45673379e-01f, -2.73849189e-01f, 1.55138122e-02f, 2.30950303e-02f, 1.14741400e-01f, 1.02018058e-01f, -8.38289261e-02f, 1.07548691e-01f, -2.61477455e-02f,
  -5.37920669e-02f, -8.64708200e-02f, 9.92391333e-02f, -1.67969018e-01f, -1.27599299e-01f, -8.87910128e-02f, 6.44800887e-02f, -5.84983155e-02f, -7.54792383e-03f, -2.04833046e-01f,
  -1.61049113e-01f, -2.30393201e-01f, -2.88335949e-01f, -1.35294467e-01f, 8.70213434e-02f, -3.33033353e-02f, -2.38668829e-01f, -1.48915052e-01f, -2.30953023e-01f, -3.69485408e-01f,
  -2.90106777e-02f, -3.40831846e-01f, -3.08398694e-01f, -2.65623927e-01f, -1.05968237e-01f, -6.71564862e-02f, -4.98009712e-01f, -2.17597514e-01f, 1.12896048e-01f, -3.49242419e-01f,
  9.70486552e-02f, 5.01332641e-01f, 2.52918303e-01f, 2.01523751e-01f, 1.57790974e-01f, -4.65963542e-01f, -1.69580549e-01f, 1.70839384e-01f, 3.81494880e-01f, 3.13468963e-01f,
  1.14282086e-01f, 3.31170410e-02f, 9.42443460e-02f, 1.46001264e-01f, -1.87084764e-01f, 5.72399534e-02f, -3.66805047e-01f, -2.06256762e-01f, -1.45844400e-01f, -2.24899918e-01f,
  -2.26394475e-01f, -2.35929504e-01f, 2.06247509e-01f, 3.15140128e-01f, 4.46371809e-02f, -3.39588337e-02f, 6.99296687e-03f, -1.22858034e-02f, 2.16390640e-02f, -1.30925462e-01f,
  -3.20883542e-02f, 5.40293492e-02f, 1.01043612e-01f, -9.50601026e-02f, -7.55545869e-02f, -8.80857781e-02f, -9.50369313e-02f, 7.53763914e-02f, -1.62046514e-02f, -4.28275317e-02f,
  -7.03539327e-02f, 3.38303000e-02f, 5.67296892e-03f, -7.74518549e-02f, -1.91655159e-01f, 1.98387265e-01f, -3.59816998e-02f, -1.40137136e-01f, -1.38674408e-01f, -5.70202947e-01f,
  -2.49655042e-02f, 6.03553914e-02f, -4.82646190e-02f, -1.06006540e-01f, 1.44039597e-02f, -3.70121934e-02f, -2.27671359e-02f, 9.36855450e-02f, 3.02375872e-02f, 3.08707040e-02f,
  7.13758022e-02f, 9.99885146e-03f, 1.66383415e-01f, 3.51083279e-02f, 6.90151453e-02f, -1.18043367e-02f, 5.32731600e-02f, -3.10581923e-02f, -1.94694288e-02f, 1.45351840e-02f,
  1.40499756e-01f, 9.86275915e-03f, -2.32048079e-01f, 4.75973114e-02f, 2.91169472e-02f, -1.49716565e-03f, -5.66310026e-02f, 8.44173580e-02f, -1.38152435e-01f, -4.91000637e-02f,
  -1.26041964e-01f, 1.70277894e-01f, -1.18901759e-01f, 5.93258590e-02f, -2.44897604e-02f, -1.50696695e-01f, -7.93368071e-02f, 1.32313343e-02f, 2.03370806e-02f, -6.59926310e-02f,
  -3.58680300e-02f, -7.84229860e-02f, -2.29026645e-01f, 5.88768423e-02f, 6.63009658e-02f, -1.14045300e-01f, -1.38672903e-01f, 1.48293853e-01f, 1.19613841e-01f, -1.01453565e-01f,
  -1.93454430e-01f, -1.04223169e-01f, -5.59853874e-02f, -5.22657819e-02f, -7.38376528e-02f, 1.63107216e-01f, -5.22317626e-02f, -2.12028742e-01f, 5.48937470e-02f, -3.84334832e-01f,
  -5.14045417e-01f, 2.41953284e-01f, -5.85776150e-01f, -3.07031870e-01f, -3.93231630e-01f, -5.72990894e-01f, 4.32681441e-02f, -2.28852779e-01f, -3.34856063e-01f, 1.56159133e-01f,
  2.07695857e-01f, 2.27583684e-02f, -3.73494700e-02f, 7.80574307e-02f, -4.01154719e-02f, -1.05929583e-01f, -3.09111834e-01f, -2.70603120e-01f, -3.41417193e-01f, 7.65375048e-02f,
  1.21673457e-01f, 7.13138953e-02f, -5.48808426e-02f, -4.12093624e-02f, 6.76111728e-02f, 1.15280092e-01f, 1.23946734e-01f, -2.13752389e-01f, -1.13802612e-01f, -8.29659998e-02f,
  8.21462125e-02f, -3.22712690e-01f, -1.08349562e-01f, 2.43642218e-02f, 3.94881703e-02f, -1.27133489e-01f, -6.20869733e-02f, -1.24971651e-01f, 1.24804586e-01f, -6.76796287e-02f,
  -4.12508398e-02f, 4.39316221e-02f, -1.35878265e-01f, -4.64975946e-02f, -5.72346598e-02f, -3.30557558e-03f, -1.11425463e-02f, 3.17461006e-02f, -1.55901667e-02f, 1.40665293e-01f,
  4.73447628e-02f, -1.46243930e-01f, 5.42380325e-02f, 1.25343531e-01f, -4.76487465e-02f, -1.27317861e-01f, 1.06927067e-01f, -5.55085018e-02f, -1.70200750e-01f, 1.52973130e-01f,
  7.55793527e-02f, 7.62988329e-02f, -7.07834139e-02f, -1.74614936e-02f, 3.73854861e-02f, 3.59277870e-03f, -6.08245283e-02f, 1.37320057e-01f, 4.58356924e-02f, 6.88335001e-02f,
  9.98758599e-02f, 7.13964179e-03f, -1.08321786e-01f, -6.99281916e-02f, -3.44643928e-02f, -7.19101205e-02f, 1.58393010e-02f, 9.61577445e-02f, -7.61146769e-02f, -1.34711176e-01f,
  -1.13516010e-01f, -8.15588757e-02f, -6.30181432e-02f, -1.69211309e-02f, -8.90236497e-02f, 1.72086935e-02f, -3.42537090e-02f, -2.60515343e-02f, 7.37553164e-02f, -4.58050035e-02f,
  2.42400646e-01f, -3.56264442e-01f, 1.77491203e-01f, 2.71758735e-02f, 2.05236580e-02f, 9.78789013e-03f, -2.21031532e-01f, -4.98632304e-02f, -1.73114866e-01f, -1.67330522e-02f,
  -6.88098446e-02f, -4.56367806e-02f, -1.38773337e-01f, -2.06023101e-02f, -7.87314959e-03f, -1.28592670e-01f, -7.38967769e-03f, 8.30851644e-02f, -1.43809408e-01f, 6.32508891e-03f,
  2.36598179e-02f, -3.44093852e-02f, 2.58609831e-01f, 1.45575374e-01f, 7.42136091e-02f, -1.17905922e-02f, 2.15335444e-01f, 3.63109522e-02f, -1.05000641e-02f, 4.86203253e-01f,
  8.00813377e-01f, -7.53892303e-01f, -1.82428837e-01f, 1.03387907e-01f, -1.26505792e-01f, -7.78228417e-02f, -5.58157086e-01f, -1.11229986e-01f, 2.04220653e-01f, -3.42333823e-01f,
  -3.76845986e-01f, 9.01402999e-03f, 2.06703395e-02f, 4.02563810e-02f, 1.70856565e-01f, -2.99688220e-01f, 2.66317744e-02f, 3.53721380e-01f, 4.59411442e-01f, -1.56067312e-02f,
  -2.06385061e-01f, 1.03612483e-01f, 2.83209562e-01f, -9.94450692e-03f, -2.64847428e-01f, -3.76170576e-02f, -3.42725694e-01f, -1.05504267e-01f, -2.83157200e-01f, -3.10405850e-01f,
  -8.01777169e-02f, -9.25093442e-02f, 1.46066487e-01f, 9.46583077e-02f, -1.55829251e-01f, -9.34929866e-03f, -7.23040625e-02f, -1.65917501e-02f, 3.91218625e-03f, -8.13106373e-02f,
  2.39285119e-02f, 1.22554585e-01f, -1.06774308e-02f, -2.04197709e-02f, 2.19395161e-02f, -3.27076279e-02f, -1.30890543e-02f, -8.56103674e-02f, 9.24569461e-03f, -2.09780619e-01f,
  -1.54089123e-01f, -1.45800591e-01f, 6.59301877e-02f, 7.42784748e-03f, 1.90191492e-02f, 2.17634469e-01f, -2.14994356e-01f, -1.11594968e-01f, 1.39700606e-01f, -1.59150735e-01f,
  -4.29665744e-02f, -1.03317551e-01f, -1.28197059e-01f, -6.64378237e-03f, -4.51632328e-02f, 3.99409533e-02f, -2.56122593e-02f, -7.23410845e-02f, -6.39512315e-02f, -9.80287716e-02f,
  -7.46199489e-02f, 1.09613106e-01f, -3.33320163e-02f, -1.04328886e-01f, -1.62664980e-01f, -4.41645384e-02f, -8.43280405e-02f, -9.59301367e-02f, 4.16504666e-02f, 4.00597788e-02f,
  1.00813724e-01f, -2.35964824e-02f, 3.32757831e-02f, -9.80743840e-02f, -8.63368809e-02f, 3.71774063e-02f, -3.44215124e-03f, -6.62542284e-02f, -9.57637280e-03f, -1.55014377e-02f,
  -1.61334038e-01f, 3.05731177e-01f, -5.56300469e-02f, -2.34227683e-02f, 8.55401084e-02f, 3.26528959e-02f, -1.64296001e-01f, -2.61062346e-02f, 2.55771466e-02f, 2.70877667e-02f,
  -4.69299443e-02f, 1.79131344e-01f, -3.62795987e-03f, -1.06512584e-01f, 1.70764700e-01f, 5.76273836e-02f, -5.80601841e-02f, -5.51051982e-02f, -3.25207487e-02f, -9.07164142e-02f,
  -1.38770580e-01f, 1.20767523e-02f, 1.39873236e-01f, 1.50385544e-01f, 9.03008953e-02f, 3.15759599e-01f, -7.52212331e-02f, 2.03571077e-02f, 2.28505954e-01f, -6.51365444e-02f,
  1.93883568e-01f, 1.19417664e-02f, -7.32093632e-01f, -2.76478641e-02f, -1.48251459e-01f, -1.00329630e-01f, 1.75986052e-01f, 1.80554792e-01f, 1.96626827e-01f, -1.97841600e-02f,
  -1.47981960e-02f, 1.22680470e-01f, 2.57909745e-01f, 2.62192547e-01f, 1.36628777e-01f, -8.17834400e-03f, -2.25880891e-01f, -1.93171591e-01f, 9.22392979e-02f, 1.30982175e-01f,
  4.05486673e-01f, 1.69179693e-01f, 1.41196355e-01f, 9.88537893e-02f, -2.38452516e-02f, 1.74776003e-01f, -1.90458834e-01f, -1.50787473e-01f, 1.63005125e-02f, -4.52947021e-01f,
  -2.29848981e-01f, -3.32499534e-01f, -1.38960227e-01f, -2.34964699e-03f, -3.00029844e-01f, 6.25412539e-02f, -6.33691251e-02f, -1.09869316e-01f, -1.05865009e-01f, -6.85598776e-02f,
  -2.62478173e-01f, -7.40414485e-02f, 2.69978344e-02f, 3.42433229e-02f, 9.79298502e-02f, 6.33744448e-02f, -3.39847495e-04f, -1.17143907e-01f, -1.91391394e-01f, -1.50282681e-01f,
  9.28518251e-02f, -3.46337676e-01f, -3.48456979e-01f, -1.98764384e-01f, -1.73322976e-01f, -2.85562128e-01f, -1.99492335e-01f, -3.14437419e-01f, -1.49903700e-01f, -1.52323663e-01f,
  -1.82613451e-02f, -6.74769282e-02f, -9.55440551e-02f, 5.73673323e-02f, 9.11684483e-02f, -6.00603558e-02f, -1.46393627e-01f, 2.72404775e-02f, -7.69181782e-03f, 8.40546936e-02f,
  9.55872412e-04f, 4.07662876e-02f, -7.57314498e-03f, -1.08074248e-01f, 6.06872216e-02f, -6.96486458e-02f, 2.95085162e-02f, 4.25502993e-02f, -3.65296043e-02f, 6.74947277e-02f,
  6.48271516e-02f, -1.25691861e-01f, -9.31591764e-02f, 1.29218458e-03f, -9.01770815e-02f, -1.03443213e-01f, 5.96855320e-02f, 1.17353201e-01f, 1.52065679e-01f, 5.15909269e-02f,
  4.17492747e-01f, 1.34983566e-02f, 3.55920231e-04f, 1.26241762e-02f, -1.24519438e-01f, 4.11642231e-02f, 6.05269410e-02f, 6.03408888e-02f, 3.23056504e-02f, -1.12520680e-01f,
  -3.14418599e-02f, 8.87414888e-02f, 1.00124486e-01f, -3.82556804e-02f, 7.21158981e-02f, 1.42295569e-01f, 1.85139447e-01f, -2.82840198e-03f, 9.31729302e-02f, 2.70203482e-02f,
  1.16861656e-01f, 8.92276540e-02f, 9.63673815e-02f, 5.16375303e-02f, 8.38746056e-02f, 1.47865862e-01f, 3.29423584e-02f, 1.34329751e-01f, -3.15263355e-03f, 3.16605270e-01f,
  4.45365012e-01f, 4.70222384e-02f, -1.61888041e-02f, 2.27655619e-01f, -1.66563526e-01f, -3.23433548e-01f, -6.21484518e-01f, -3.55866462e-01f, 1.93541318e-01f, 1.53721184e-01f,
  2.06417274e-02f, 8.24679509e-02f, 6.69495240e-02f, 3.58758941e-02f, -2.69810200e-01f, -1.55693039e-01f, 5.84133342e-02f, 2.68467050e-02f, -2.62141585e-01f, -2.07003132e-01f,
  1.11775403e-03f, 4.82027084e-02f, 4.20941412e-02f, -1.32155875e-02f, 2.39308238e-01f, 5.09676151e-02f, 7.75658935e-02f, 1.30275637e-01f, 6.40755966e-02f, 3.92735839e-01f,
  1.80643782e-01f, 1.35301709e-01f, -2.29991183e-01f, 8.69706422e-02f, 1.25544041e-01f, 1.66645553e-02f, 1.25075072e-01f, 7.50316903e-02f, 9.99104604e-02f, 1.02337129e-01f,
  1.77729189e-01f, 1.67618096e-01f, 1.66113943e-01f, -7.45115383e-03f, 4.47277576e-02f, -1.21791959e-01f, 1.47745833e-01f, -2.65361182e-02f, -1.42238233e-02f, 3.94164994e-02f,
  8.27843416e-03f, 3.26951295e-02f, -1.83577225e-01f, -2.03378007e-01f, 4.65076044e-03f, 5.95033262e-03f, -1.37015432e-01f, 5.02750166e-02f, -1.80872828e-01f, 2.35379413e-01f,
  -8.01035613e-02f, 5.04075317e-03f, 7.22040534e-02f, 1.30427247e-02f, 3.80402096e-02f, 7.79134184e-02f, 2.76327487e-02f, -1.09852165e-01f, -1.46808222e-01f, 4.67170142e-02f,
  -5.79621308e-02f, -4.26447093e-02f, -6.87891543e-02f, 4.27995138e-02f, -7.53992721e-02f, 2.56871264e-02f, -7.54535720e-02f, -5.38760051e-03f, -4.21988517e-02f, 1.09173499e-01f,
  1.20697699e-01f, -5.47360480e-02f, -5.09024113e-02f, 1.13851568e-02f, -6.51617125e-02f, -2.11320370e-02f, 1.06915742e-01f, -4.33451980e-02f, 2.32580528e-02f, 1.52955636e-01f,
  -2.51064487e-02f, -3.40064108e-01f, 6.30464405e-02f, -1.67561322e-01f, -4.02426608e-02f, -1.34289667e-01f, 3.78107913e-02f, -4.89989556e-02f, 1.60225555e-01f, -1.51650324e-01f,
  -1.86133817e-01f, -4.70052822e-04f, 4.55843285e-02f, -3.77127975e-02f, -1.24887146e-01f, -1.17461830e-01f, -1.64698854e-01f, -1.97705299e-01f, -7.97522217e-02f, 8.38421956e-02f,
  -1.20969526e-01f, -2.04873860e-01f, -1.27523273e-01f, -1.91171244e-01f, -8.27335045e-02f, -1.44949540e-01f, -2.27269322e-01f, -7.44706541e-02f, -3.88778985e-01f, -2.63770252e-01f,
  3.72172803e-01f, -1.89239278e-01f, -5.47465682e-01f, 4.28537950e-02f, -2.55525529e-01f, -3.81527275e-01f, -3.15577477e-01f, -7.31084049e-02f, 6.44098446e-02f, -2.82499373e-01f,
  -1.76306590e-02f, 1.37606397e-01f, 5.45194149e-02f, 8.14527553e-03f, -9.58671942e-02f, -4.81641650e-01f, -2.91414857e-01f, -8.64557549e-02f, -2.88566090e-02f, 2.66062897e-02f,
  7.99443424e-02f, 5.06720208e-02f, 1.66992053e-01f, 1.17701016e-01f, -1.15748920e-01f, -7.31900558e-02f, -3.26781631e-01f, -1.74172521e-01f, -1.99652299e-01f, -3.35152864e-01f,
  -4.01702523e-01f, -1.38912961e-01f, -8.63215700e-02f, 1.88095480e-01f, -1.77928180e-01f, 1.86927214e-01f, -1.27599493e-01f, 2.54630167e-02f, 6.30317181e-02f, 3.10472827e-02f,
  1.09811619e-01f, 7.35161752e-02f, 4.34668250e-02f, 5.72130010e-02f, -8.73728395e-02f, 2.48691626e-02f, 1.61970049e-01f, 2.45341174e-02f, 5.84874712e-02f, 8.63588527e-02f,
  6.85150996e-02f, -1.10255525e-01f, -7.40194172e-02f, -1.02802426e-01f, -5.91588803e-02f, -1.12561502e-01f, -1.85387969e-01f, -1.32030666e-01f, -1.54228091e-01f, 3.09105571e-02f,
  8.75357762e-02f, 9.25695822e-02f, -7.15889782e-02f, 3.61866094e-02f, 1.06055014e-01f, -8.10544938e-02f, -4.19450775e-02f, -4.26445119e-02f, 8.47360212e-03f, 6.01446666e-02f,
  8.27445686e-02f, -1.60937279e-01f, -1.52294757e-02f, 5.48640266e-02f, 5.03154173e-02f, 6.11994937e-02f, -6.69236705e-02f, -2.13750638e-02f, 3.96661721e-02f, 1.30982280e-01f,
  6.86848760e-02f, 4.31068353e-02f, 8.20958465e-02f, 4.65926714e-02f, -1.34880945e-01f, -6.94186985e-02f, 4.63849604e-02f, 1.24204094e-02f, 1.48116142e-01f, -2.20168717e-02f,
  2.71211386e-01f, -2.20741734e-01f, -1.22520559e-01f, -3.33701335e-02f, -6.06916472e-02f, -3.03461663e-02f, -6.16387986e-02f, 4.23317291e-02f, -1.51023080e-04f, 2.60487255e-02f,
  -2.57785320e-02f, -1.43544516e-02f, -6.49438873e-02f, -7.99651071e-02f, -5.90176247e-02f, -1.90658979e-02f, 4.07404490e-02f, -7.33789057e-02f, 4.20984514e-02f, 1.62359178e-01f,
  4.09315154e-02f, 3.23685594e-02f, 3.59584615e-02f, -1.19597584e-01f, -3.13464515e-02f, -4.78962660e-02f, -5.27118966e-02f, -3.47069390e-02f, -7.30915368e-02f, 4.86018807e-02f,
  -2.85655141e-01f, -3.24687585e-02f, -5.05394876e-01f, 5.33224702e-01f, 3.43726128e-01f, 1.01516202e-01f, -1.45689726e-01f, -7.31201842e-02f, 1.75028801e-01f, 1.87206671e-01f,
  1.83267891e-01f, 3.52745920e-01f, 2.77897090e-01f, 6.96643069e-02f, -1.28121018e-01f, 4.54504341e-02f, 2.00690016e-01f, -2.69295901e-01f, -3.40510488e-01f, 3.99814844e-02f,
  3.65720093e-01f, 9.72732678e-02f, -2.65857399e-01f, -3.04853637e-02f, 2.35682353e-01f, 2.87792772e-01f, -1.45897746e-01f, 1.22165993e-01f, 3.99874300e-02f, 3.28799754e-01f,
  -2.70961761e-01f, -1.44323349e-01f, 1.23259716e-01f, 1.02724962e-01f, -1.08641284e-02f, -1.31337985e-01f, -1.61830008e-01f, -2.29309544e-01f, -7.07406625e-02f, -1.81568548e-01f,
  -3.89102846e-02f, -1.35805920e-01f, 2.67136395e-01f, -8.54934677e-02f, -1.94705114e-01f, -2.26856992e-01f, -2.17480153e-01f, -2.14845762e-01f, -2.71436244e-01f, -1.62923723e-01f,
  4.04714733e-01f, -2.77175922e-02f, -4.02351111e-01f, -1.42528400e-01f, -2.19101474e-01f, 5.02190515e-02f, -3.42929363e-01f, -2.05451623e-01f, -3.39236230e-01f, -3.38372350e-01f,
  2.40181461e-02f, 8.54097307e-03f, 9.37758386e-02f, -1.62189811e-01f, 3.88270058e-02f, -6.26799092e-02f, 8.10027570e-02f, 6.78520277e-02f, 1.61751248e-02f, -1.58158436e-01f,
  5.01237763e-03f, -7.31306225e-02f, -1.65182292e-01f, -7.18689933e-02f, 9.60286558e-02f, -1.66626021e-01f, -7.61100426e-02f, -6.12208880e-02f, -1.40165547e-02f, -4.96029370e-02f,
  -1.33366674e-01f, -1.49451913e-02f, -2.12888755e-02f, 1.06169015e-01f, -9.68342051e-02f, -3.01899705e-02f, -1.63676310e-02f, -4.61539961e-02f, -5.03858775e-02f, -2.41247684e-01f,
  6.00460581e-02f, 4.62936535e-02f, 1.46231622e-01f, -5.77098392e-02f, 5.57253622e-02f, -2.15084255e-02f, 1.47713527e-01f, -1.91933066e-01f, 5.89696504e-02f, -7.64962956e-02f,
  -1.07248299e-01f, -6.11889921e-02f, 4.20120396e-02f, 3.88597022e-03f, -1.93756316e-02f, -1.52512833e-01f, -2.83597466e-02f, 2.09813923e-01f, -9.29763764e-02f, -1.13112338e-01f,
  1.74489036e-01f, -2.28755832e-01f, -9.59402844e-02f, -1.02783889e-02f, -1.09576911e-01f, 9.27964374e-02f, -1.92751780e-01f, -1.94160596e-01f, -2.59814262e-01f, -3.54136467e-01f,
  6.37040377e-01f, -9.82190222e-02f, 5.63870490e-01f, 3.03151309e-01f, 8.62240940e-02f, 2.88296461e-01f, 1.37626246e-01f, 1.87548280e-01f, 1.43204346e-01f, 8.26698467e-02f,
  1.66984070e-02f, 6.23884760e-02f, -2.04454102e-02f, 9.30528715e-02f, 1.44561648e-01f, 6.00972250e-02f, 1.98561460e-01f, 3.34008276e-01f, 3.23481292e-01f, 1.51755080e-01f,
  -1.18612975e-01f, 7.41427345e-03f, 7.47727305e-02f, 8.17426294e-02f, -3.61368023e-02f, -4.20717373e-02f, -7.80744031e-02f, -1.61419407e-01f, -1.04350723e-01f, -1.87537018e-02f,
  3.09568644e-01f, 2.45978341e-01f, 1.75090596e-01f, 3.37798037e-02f, 9.62725356e-02f, 8.32584575e-02f, 1.30784035e-01f, 7.32900724e-02f, -6.57555461e-02f, -8.00561607e-02f,
  -5.27584553e-02f, -2.23337542e-02f, 4.84930500e-02f, -1.12686791e-01f, 7.21921325e-02f, -4.45035882e-02f, 7.48620555e-02f, 1.34288624e-01f, 1.22573085e-01f, -2.60996586e-03f,
  -1.36036664e-01f, 1.08234644e-01f, 1.33372262e-01f, 4.36816970e-03f, -2.53865924e-02f, 1.60990551e-01f, 8.90189633e-02f, 4.16342132e-02f, 6.95136413e-02f, 8.50508139e-02f,
  2.00094327e-01f, 7.91344196e-02f, 1.58065502e-02f, -4.82018217e-02f, -4.86780182e-02f, -8.67674947e-02f, -1.40688568e-01f, -1.26976550e-01f, -5.71531504e-02f, -1.38018012e-01f,
  -2.15642586e-01f, 1.01188697e-01f, 5.64749688e-02f, -4.35842276e-02f, 6.47798628e-02f, 1.40816703e-01f, 3.66854034e-02f, -5.21788299e-02f, -5.25765296e-04f, 6.49049059e-02f,
  -3.28167155e-02f, 5.59924468e-02f, -6.35467246e-02f, 7.34675974e-02f, -1.43666714e-02f, 1.31493554e-01f, 6.74207360e-02f, -5.86695634e-02f, -1.93646878e-01f, -9.95521322e-02f,
  -6.49297759e-02f, 1.23759016e-01f, 3.78182232e-02f, 2.01968215e-02f, 5.89947477e-02f, -1.09736308e-01f, -1.25093246e-02f, 4.12354581e-02f, -2.69610286e-02f, 3.96539792e-02f,
  -9.63993892e-02f, -7.82461837e-03f, 3.60400230e-03f, -2.14673355e-01f, -4.08544876e-02f, -1.25566751e-01f, -1.34084865e-01f, 2.11013004e-01f, 8.06581005e-02f, -1.52838696e-02f,
  -1.07786000e-01f, -1.62041690e-02f, 1.37881979e-01f, -7.08616599e-02f, -8.55019167e-02f, 6.64613545e-02f, -1.15605302e-01f, 1.06826328e-01f, 7.36827180e-02f, -5.95961623e-02f,
  1.68288052e-01f, -4.24035221e-01f, -4.69523251e-01f, -3.78312498e-01f, -2.10924849e-01f, 3.63928415e-02f, -1.31447643e-01f, 8.99667144e-02f, -2.02461872e-02f, -3.22637200e-01f,
  -1.76411550e-02f, 1.04215510e-01f, 5.99776991e-02f, -1.20422468e-01f, 5.26953563e-02f, -4.56634223e-01f, -4.81347412e-01f, -1.64157525e-01f, 1.96038634e-01f, -4.29586619e-02f,
  -2.68746138e-01f, -3.94146651e-01f, -1.34893611e-01f, -1.56918228e-01f, -3.62763494e-01f, -2.25957721e-01f, -3.49266201e-01f, -3.09358537e-01f, -1.84559658e-01f, -6.28689408e-01f,
  -2.86248326e-02f, 4.43382382e-01f, 1.74404800e-01f, 1.39245614e-01f, -1.02491148e-01f, 1.53884426e-01f, 3.05198915e-02f, 2.65647266e-02f, 1.44118339e-01f, 2.27649100e-02f,
  1.65885821e-01f, 7.76134953e-02f, 1.77368112e-02f, 5.93498908e-02f, -1.79727506e-02f, 6.21880330e-02f, 1.28059775e-01f, 1.72268137e-01f, 1.23703303e-02f, 2.24409420e-02f,
  -1.10288486e-02f, 1.78129509e-01f, 2.18722299e-01f, 1.59864590e-01f, 3.47258419e-01f, 2.19490558e-01f, 1.03977352e-01f, 2.08649248e-01f, 2.37595856e-01f, -2.04685271e-01f,
  -2.21595392e-01f, -6.11805730e-02f, 4.79682498e-02f, 6.28486350e-02f, 6.72334209e-02f, 5.02073243e-02f, -6.11449359e-03f, 1.95345674e-02f, 1.18164174e-01f, -1.28393412e-01f,
  -2.44641062e-02f, 3.92236449e-02f, 1.46441087e-01f, -3.88516337e-02f, 8.09860788e-03f, -1.35544986e-02f, 3.22782286e-02f, -1.48277907e-02f, 4.83943112e-02f, 4.59356606e-02f,
  9.53658298e-02f, 9.49305519e-02f, -1.86819032e-01f, -4.21318412e-03f, -5.60796261e-03f, -5.31953052e-02f, 2.00423449e-02f, 1.58102468e-01f, -2.07950938e-02f, 6.04817159e-02f,
  -4.06258143e-02f, 2.52523065e-01f, -1.18057907e-01f, 3.41163874e-02f, -3.63721848e-02f, -1.98492408e-02f, 7.01571330e-02f, -1.05180420e-01f, 1.81569513e-02f, 1.48464006e-03f,
  2.02456921e-01f, -4.47399169e-02f, -6.09817132e-02f, 2.05000509e-02f, 5.34256846e-02f, 1.29381279e-02f, 4.83455099e-02f, -4.14250568e-02f, 1.92778111e-02f, -3.96998562e-02f,
  4.07194765e-03f, -6.04576766e-02f, 3.22859734e-02f, 6.76031262e-02f, 1.18413739e-01f, -7.16403276e-02f, -1.56747043e-01f, 5.80554456e-02f, -7.42514431e-02f, -3.46973121e-01f,
  2.61153996e-01f, -4.07249629e-01f, 3.69951099e-01f, 1.01296812e-01f, -3.92146498e-01f, -4.32981998e-01f, -5.47473550e-01f, -1.74430639e-01f, -1.00500651e-01f, -1.79077014e-01f,
  -1.08762547e-01f, 6.61252439e-02f, 8.40193331e-02f, 1.69956207e-01f, 1.55924767e-01f, -7.33519904e-03f, 1.00125380e-01f, 4.02064651e-01f, 1.80467770e-01f, -1.17098391e-02f,
  -7.42783472e-02f, 1.94410279e-01f, 3.51120174e-01f, 3.02347124e-01f, 1.04784973e-01f, 1.25401551e-04f, 1.13503665e-01f, -2.57920986e-03f, 2.95859412e-03f, 2.29314223e-01f,
  1.36327654e-01f, -9.82255116e-02f, 1.14535570e-01f, -3.46652009e-02f, -3.51041220e-02f, 4.59226407e-02f, -5.39877564e-02f, 1.41259655e-01f, -5.53410091e-02f, -4.35503311e-02f,
  -8.52548927e-02f, -4.91845841e-03f, -2.31399328e-01f, 5.31147793e-02f, -1.04691550e-01f, -3.40649821e-02f, 1.96444303e-01f, 2.04768702e-01f, 1.71543136e-01f, -5.94579168e-02f,
  -2.17820525e-01f, -1.74940184e-01f, -2.93086499e-01f, -1.47194058e-01f, -2.09755406e-01f, 1.35107934e-02f, -7.97785670e-02f, -1.06341951e-01f, -5.71618229e-02f, 4.92363125e-02f,
  -7.09899887e-02f, -5.57136014e-02f, 3.01084183e-02f, 6.14037924e-02f, 1.70702618e-02f, 1.56949821e-03f, -2.13327538e-02f, -2.52727009e-02f, 2.63388008e-02f, 1.05589628e-01f,
  -3.30320410e-02f, 9.40330252e-02f, 4.66948487e-02f, 2.56918948e-02f, -1.91152487e-02f, 1.89911127e-02f, -5.84013425e-02f, 9.69810933e-02f, -1.70476921e-02f, -4.25700992e-02f,
  5.50631527e-03f, 2.40491927e-02f, 1.13191754e-02f, 1.58197612e-01f, -3.65790399e-03f, 5.29940128e-02f, 7.87409842e-02f, -6.16201051e-02f, -6.32053018e-02f, -4.90177795e-02f,
  -4.79620248e-02f, -6.81924075e-02f, 1.43061683e-01f, 7.91675597e-02f, -6.24335632e-02f, -1.73908368e-01f, -1.75369475e-02f, -1.17297418e-01f, -4.05813605e-02f, -1.41686216e-01f,
  -1.29365787e-01f, -9.87636223e-02f, -5.60915358e-02f, 1.01815008e-01f, 1.24088794e-01f, 9.82928462e-03f, -2.87852157e-02f, -1.07580394e-01f, -1.36746811e-02f, -9.07187611e-02f,
  3.27296220e-02f, -1.85518831e-01f, -2.19132364e-01f, -1.57353759e-01f, -1.36735290e-01f, -2.07471162e-01f, -9.57777782e-04f, -6.92956969e-02f, -2.06686422e-01f, -1.67799532e-01f,
  -7.13064671e-02f, 6.70638755e-02f, -5.53214066e-02f, -5.19830808e-02f, -2.05637485e-01f, -3.31338733e-01f, -1.56271830e-01f, -1.42324213e-02f, -1.37724392e-02f, 7.61281997e-02f,
  -3.49439047e-02f, -6.23682886e-02f, 6.22158162e-02f, -5.35786673e-02f, -2.28514060e-01f, -2.11146757e-01f, -2.55103558e-01f, -2.39784479e-01f, -2.56896526e-01f, -2.23046020e-01f,
  -8.19526538e-02f, -2.77018286e-02f, -1.83176786e-01f, -1.52423248e-01f, 8.83396938e-02f, -9.93986726e-02f, -8.19249544e-03f, -1.82708561e-01f, -3.10189366e-01f, -5.90553656e-02f,
  6.81372359e-02f, -1.92705497e-01f, 6.73574135e-02f, -4.24081385e-02f, 1.79928746e-02f, 2.09251922e-02f, 3.40321623e-02f, 1.14416517e-01f, 1.16828561e-01f, 1.33427769e-01f,
  4.75403890e-02f, -8.91739801e-02f, -1.83138414e-03f, 1.46325389e-02f, 1.17202006e-01f, 7.45541081e-02f, 8.34748670e-02f, 5.06767631e-02f, 2.15897840e-02f, -1.87424291e-02f,
  -1.82320923e-02f, -1.70255005e-01f, -1.29603416e-01f, 2.42398567e-02f, -6.66878521e-02f, -9.82788131e-02f, 6.38764650e-02f, -6.80687488e-04f, -4.62936983e-02f, 7.71555081e-02f,
  -2.05848008e-01f, 1.34381562e-01f, -8.42039511e-02f, -4.34996448e-02f, 8.48630257e-03f, 8.85526463e-02f, 1.42225057e-01f, 1.28952816e-01f, -7.84407631e-02f, 1.07514985e-01f,
  1.99898213e-01f, -7.72923306e-02f, -7.54637420e-02f, 8.18175152e-02f, 2.97252759e-02f, -8.37814808e-02f, -9.35559794e-02f, 5.80478087e-02f, -4.92910482e-03f, -3.96016352e-02f,
  -7.45618418e-02f, -3.51702534e-02f, 9.08911228e-03f, 1.82837527e-02f, -8.25674552e-03f, -8.43487978e-02f, -1.86653823e-01f, -1.92392811e-01f, -1.26946256e-01f, -1.91451564e-01f,
  6.07514866e-02f, -6.15985155e-01f, -4.72253114e-02f, -1.80025369e-01f, 9.34607089e-02f, 1.43836543e-01f, -6.70637861e-02f, -7.70753191e-04f, 1.30158797e-01f, 7.03402907e-02f,
  -7.55322129e-02f, 5.73178008e-03f, 2.12860294e-02f, 1.76039010e-01f, 1.51554376e-01f, -3.03107202e-02f, 8.38985965e-02f, 1.51230305e-01f, -9.45971757e-02f, 1.23870783e-01f,
  1.23027027e-01f, 5.87547347e-02f, 1.14083976e-01f, 2.28622451e-01f, 4.04815003e-02f, 2.89145764e-02f, 1.90324262e-01f, 1.66914523e-01f, 3.09859384e-02f, 4.23395425e-01f,
  8.66303027e-01f, 4.89826463e-02f, -2.40031019e-01f, 3.76800805e-01f, 4.85887975e-02f, -3.56707000e-03f, -1.42345697e-01f, 1.91140741e-01f, 2.54704565e-01f, 2.21995026e-01f,
  2.70068228e-01f, 3.62322062e-01f, 3.80641103e-01f, 2.42405355e-01f, 1.09509319e-01f, -1.30060822e-01f, -1.70049578e-01f, 2.78262123e-02f, -1.23978622e-04f, 6.27812073e-02f,
  8.39212090e-02f, -1.10889800e-01f, -1.49727203e-02f, 9.80027020e-03f, -7.98499882e-02f, 1.51194585e-02f, -1.65392429e-01f, -3.47646534e-01f, -2.58116484e-01f, -2.80043721e-01f,
  -2.22531438e-01f, -6.42918646e-02f, 9.77757424e-02f, 1.35457322e-01f, -1.74663961e-01f, 1.00094847e-01f, -6.04531281e-02f, -9.86938551e-02f, 7.43555278e-02f, -8.92051458e-02f,
  -1.94370657e-01f, -1.50771558e-01f, -2.38051396e-02f, -1.85653158e-02f, -1.36641324e-01f, -8.93745665e-03f, -1.03853829e-01f, -4.25536297e-02f, -3.62902023e-02f, -1.99548644e-03f,
  6.90157786e-02f, -1.02846846e-01f, -1.33355707e-01f, 8.57145563e-02f, -7.94071257e-02f, 1.67251840e-01f, 3.63778770e-02f, 1.77306347e-02f, 1.73175742e-03f, 3.81353274e-02f,
  1.58934399e-01f, -8.31523761e-02f, 5.71381673e-02f, 1.12746440e-01f, 1.41169369e-01f, 6.42776024e-03f, -1.36067970e-02f, -6.42532017e-03f, -5.08653075e-02f, -1.36942685e-01f,
  5.90307266e-02f, -3.20490189e-02f, -3.08739319e-02f, 1.18076213e-01f, 2.00004712e-01f, -9.80186388e-02f, -9.84352902e-02f, -5.00260033e-02f, -9.26277712e-02f, 1.07857287e-01f,
  -4.03684983e-03f, -6.75750971e-02f, 6.13541082e-02f, -1.47552297e-01f, 5.15311845e-02f, 3.06792986e-02f, 1.05263501e-01f, -4.98802774e-02f, -1.06249899e-02f, -5.05292863e-02f,
  -1.18912876e-01f, 2.89843738e-01f, 1.14221387e-01f, -8.23018178e-02f, -1.67277753e-01f, -8.32616091e-02f, 8.85071456e-02f, -7.90584609e-02f, -9.37308818e-02f, -5.35378046e-02f,
  -1.63436458e-01f, -1.18348049e-02f, -8.67886320e-02f, -4.73052412e-02f, -5.98416254e-02f, -2.09195558e-02f, -4.08797674e-02f, 1.62134767e-01f, -3.71884480e-02f, -1.63728833e-01f,
  -6.30899146e-03f, 7.99028873e-02f, 9.10414159e-02f, 5.11139818e-02f, 7.76427239e-02f, 8.60599503e-02f, 8.62853006e-02f, -5.05788252e-02f, 3.78436297e-02f, 1.72956392e-01f,
  -7.75305688e-01f, -6.59939125e-02f, -2.64309138e-01f, -5.48524559e-01f, -1.24339700e-01f, 8.52175131e-02f, 2.17063010e-01f, 1.59171104e-01f, -1.75928012e-01f, -1.56872034e-01f,
  -1.53551936e-01f, -2.93693036e-01f, -4.21181828e-01f, -4.70857210e-02f, -5.48332185e-02f, -1.18334986e-01f, -3.29952717e-01f, -1.95252016e-01f, -2.26617884e-03f, 2.95610487e-01f,
  3.67611051e-02f, -1.25215277e-01f, -1.05360493e-01f, 2.64070276e-02f, 8.59712809e-03f, -1.39500916e-01f, -1.02375455e-01f, -1.70464665e-02f, 1.75956473e-01f, -2.83654839e-01f,
  -4.31092024e-01f, -2.05730692e-01f, 1.26877770e-01f, -7.90149793e-02f, -1.44329533e-01f, 1.70957893e-02f, 8.19184333e-02f, -2.61654016e-02f, -1.81800816e-02f, -1.86291218e-01f,
  -7.71122426e-02f, 1.43877059e-01f, -2.48939186e-01f, 1.36591662e-02f, -9.18628946e-02f, 1.48479491e-01f, -2.25563914e-01f, -1.53173516e-02f, -1.85210437e-01f, 1.72539055e-01f,
  1.00972414e-01f, 5.27378060e-02f, -6.05769157e-02f, 1.82959884e-01f, 2.01877788e-01f, 2.24372614e-02f, 2.13990614e-01f, 2.14730322e-01f, 3.07767928e-01f, -1.85735971e-02f,
  3.02607771e-02f, 2.29293332e-02f, -1.66422457e-01f, -7.45741650e-02f, -9.95153263e-02f, -9.22270566e-02f, -1.73138991e-01f, -7.23768696e-02f, 9.95462760e-02f, -1.06850661e-01f,
  -7.48522356e-02f, 5.04411422e-02f, -1.83031037e-01f, -1.45121485e-01f, 3.77374068e-02f, -3.61030325e-02f, -1.04650840e-01f, 6.55810833e-02f, 3.38697135e-02f, -9.51317847e-02f,
  -5.77067472e-02f, 1.95358694e-01f, -1.42251685e-01f, -3.59915495e-02f, 5.17470576e-02f, -1.03723176e-01f, 1.83707085e-02f, 4.56826836e-02f, -5.49666472e-02f, -8.11328273e-03f,
  -3.75293046e-01f, -2.03644216e-01f, -1.61943495e-01f, 9.64468718e-03f, -7.89055154e-02f, 4.39754240e-02f, -2.34835997e-01f, -2.97029335e-02f, -8.29412788e-02f, -1.27648607e-01f,
  2.05594078e-01f, -8.39389116e-02f, -1.62618741e-01f, -9.85186640e-03f, -5.69498241e-02f, 6.54709339e-02f, -2.44893171e-02f, -1.94173828e-01f, 6.41517565e-02f, 1.22102410e-01f,
  -3.46892998e-02f, 7.71180019e-02f, -1.53374702e-01f, -6.52309433e-02f, 8.64317492e-02f, -1.67986989e-01f, -3.29088507e-04f, -1.49837350e-02f, 2.33558808e-02f, -5.57140484e-02f,
  4.21561450e-01f, -2.30516851e-01f, -1.26327053e-01f, 1.63382292e-01f, -3.67157422e-02f, -2.64009267e-01f, -4.00949091e-01f, -2.51870066e-01f, 7.90127292e-02f, 1.09509915e-01f,
  1.36547640e-01f, 3.39583606e-01f, 2.49338970e-01f, 1.43372416e-01f, 1.59828607e-02f, 5.27528524e-02f, 1.31506771e-01f, 2.79195726e-01f, 1.54772475e-01f, 2.34194130e-01f,
  1.95555478e-01f, 1.12811022e-01f, 1.40105560e-01f, 6.20528720e-02f, 1.96900472e-01f, 2.01303676e-01f, 6.26200736e-02f, 1.75182879e-01f, 5.85021637e-02f, 3.92868698e-01f,
  8.20284486e-02f, 4.36754264e-02f, -1.14283133e-02f, 1.27160057e-01f, -7.53509775e-02f, -5.10521121e-02f, -2.82802656e-02f, -3.75995040e-02f, -3.43391411e-02f, -1.32055312e-01f,
  1.64744854e-02f, 4.21028510e-02f, 6.38712794e-02f, 2.83958670e-03f, -2.40549445e-02f, 6.99872002e-02f, 1.03345908e-01f, 1.62899345e-02f, 1.88165694e-03f, -5.89713231e-02f,
  1.36367798e-01f, 6.90075457e-02f, -1.50317803e-01f, -1.52738169e-01f, -6.83434457e-02f, -1.53387543e-02f, -1.23969220e-01f, 1.79058481e-02f, -6.33321628e-02f, 7.08230808e-02f,
  4.13099229e-02f, -5.31472489e-02f, 7.80598894e-02f, 1.53790489e-01f, 2.34269395e-01f, 1.41325995e-01f, 3.16319242e-02f, 1.05976954e-01f, 8.71979222e-02f, 1.10816084e-01f,
  2.08846889e-02f, 2.91961748e-02f, -1.31820783e-01f, 5.53080551e-02f, 1.63925868e-02f, 1.03512928e-01f, -5.14763929e-02f, -9.24473454e-04f, 1.33748114e-01f, -1.94661261e-03f,
  1.15083173e-01f, -2.67647915e-02f, 6.72565261e-03f, 2.04526968e-02f, 2.71206778e-02f, 1.63687244e-01f, 1.31173044e-01f, 3.83458436e-02f, 4.75752465e-02f, 1.54949486e-01f,
  -6.14148915e-01f, -1.35762719e-02f, 2.99529731e-01f, 1.22245230e-01f, -2.64526457e-02f, 9.35781747e-02f, 2.59360045e-01f, -2.54673827e-02f, -1.87030971e-01f, -1.43515036e-01f,
  7.41068274e-02f, 1.47368491e-01f, -1.19902276e-01f, 1.00157619e-01f, -4.69207065e-03f, 7.77073428e-02f, 1.12271264e-01f, 1.84496716e-02f, -4.54182215e-02f, -4.75728475e-02f,
  -6.73917457e-02f, -1.96357280e-01f, -2.39235714e-01f, -1.75515965e-01f, -1.16901986e-01f, -7.46279806e-02f, -1.31182864e-01f, -2.23086208e-01f, -2.65903831e-01f, -1.80395529e-01f,
  7.79508770e-01f, -1.21470548e-01f, -3.71658206e-01f, 1.26944467e-01f, -2.28488088e-01f, -7.79117793e-02f, -1.12745270e-01f, 2.73462147e-01f, 2.73219794e-01f, -2.42369296e-03f,
  -1.33873999e-01f, 8.98640044e-03f, -1.43941678e-02f, -8.82184505e-02f, 1.11555912e-01f, -2.04927996e-01f, -1.82214424e-01f, 5.13035841e-02f, 1.45885989e-01f, 2.43774266e-03f,
  8.62313509e-02f, 7.47554749e-02f, 1.78995088e-01f, 5.92236519e-02f, -2.27434605e-01f, -6.36156499e-02f, -2.53977001e-01f, -8.05938467e-02f, -2.47041658e-01f, -2.93016046e-01f,
  -5.35262525e-01f, -2.18319401e-01f, -6.05485402e-02f, 5.74419387e-02f, 4.70141470e-02f, 2.43563309e-01f, 6.93005249e-02f, 1.19476482e-01f, 4.71803509e-02f, -2.06854544e-03f,
  -7.23481178e-02f, -3.71792875e-02f, -8.21528137e-02f, -1.09631196e-01f, 1.01978285e-02f, -1.99012179e-02f, 5.82856312e-03f, 6.51139170e-02f, -6.75915256e-02f, -1.32010002e-02f,
  -9.15896744e-02f, -1.00525310e-02f, -2.03985404e-02f, 2.48518810e-02f, -1.52180448e-01f, -1.28559664e-01f, -2.47565657e-01f, -1.49528369e-01f, -9.15375799e-02f, -6.46507442e-02f,
  7.07994699e-02f, 2.33604759e-03f, 6.62938878e-02f, -2.20322441e-02f, 6.55829012e-02f, 7.92484209e-02f, -4.90799695e-02f, 6.77905837e-03f, -2.25341991e-02f, 6.24297857e-02f,
  -8.38855207e-02f, -4.27711867e-02f, -6.92804009e-02f, 8.18272904e-02f, -1.38917595e-01f, -7.62510393e-03f, 4.90717888e-02f, 6.53131902e-02f, -2.61909738e-02f, 1.28127217e-01f,
  -7.40078045e-03f, -7.38197938e-03f, 6.07905798e-02f, -5.19562773e-02f, 5.16570697e-04f, 7.09005222e-02f, 2.18131337e-02f, -1.97312441e-02f, 1.27762452e-01f, 9.13419873e-02f,
  2.40537554e-01f, -8.63943100e-02f, 8.29195678e-02f, -1.56415496e-02f, -3.10724061e-02f, 7.59598538e-02f, -8.59648138e-02f, 1.00339882e-01f, -6.86477944e-02f, 8.44658390e-02f,
  -1.17315590e-01f, -4.77381870e-02f, -1.21411823e-01f, -2.03079097e-02f, -3.45386565e-02f, -3.63271311e-02f, 6.76445514e-02f, -6.27737045e-02f, 9.74247791e-03f, 5.68805635e-02f,
  1.02440350e-01f, 2.87734210e-01f, 1.88466117e-01f, 9.13780704e-02f, -3.54504883e-02f, 1.11687906e-01f, -7.71162957e-02f, 1.86517704e-02f, 5.17048985e-02f, 3.41441512e-01f,
  -5.72812974e-01f, -2.41895512e-01f, 4.19429131e-02f, -3.33539933e-01f, -3.54999341e-02f, 2.64644027e-02f, -2.26222470e-01f, -5.14317416e-02f, -5.23873977e-02f, -1.38971433e-01f,
  3.94914337e-02f, 2.05267876e-01f, -1.38920143e-01f, 1.25813395e-01f, -9.30736065e-02f, -3.15137804e-01f, 3.93983796e-02f, 1.29715875e-01f, 1.21921398e-01f, 2.28842258e-01f,
  5.30185215e-02f, 2.20452230e-02f, 5.40927052e-02f, 1.84123397e-01f, -1.85621276e-01f, -1.82052013e-02f, -5.71099371e-02f, -1.44640729e-01f, -1.03079744e-01f, -3.23081046e-01f,
  -3.43855530e-01f, -3.00549775e-01f, 2.50363171e-01f, 9.98870353e-04f, 1.38485789e-01f, 2.11700164e-02f, -5.32381050e-02f, 4.30654697e-02f, 9.04539898e-02f, -1.31959496e-02f,
  -8.42606872e-02f, 8.81243646e-02f, 8.30281526e-02f, -4.56569949e-03f, 9.01302416e-03f, -2.57370993e-02f, -2.81050187e-02f, -5.60241900e-02f, -1.87808439e-01f, -7.91116133e-02f,
  -8.64478350e-02f, -4.74949442e-02f, -4.34570223e-01f, -1.65185377e-01f, -1.61300153e-01f, 7.35054165e-02f, 1.01912022e-02f, -1.34872660e-01f, -5.18518984e-02f, -5.10933816e-01f,
  1.48629136e-02f, 1.54357985e-01f, 8.64656493e-02f, -7.61971669e-03f, -7.91489929e-02f, -3.47471572e-02f, 2.63370145e-02f, -4.98819761e-02f, 1.26072150e-02f, -1.73749506e-01f,
  1.47563010e-01f, -1.11465193e-01f, -2.79142261e-02f, -2.57031500e-01f, 1.24841789e-02f, -3.68121900e-02f, -4.12034839e-02f, -8.03989843e-02f, 2.59546675e-02f, 1.15268633e-01f,
  -4.99305315e-02f, -9.09185931e-02f, 2.10615546e-02f, 9.53164026e-02f, -2.93501392e-02f, 3.17306025e-03f, -8.18053782e-02f, 9.39707682e-02f, -1.06275521e-01f, 1.07969835e-01f,
  -2.16716573e-01f, 2.83862799e-01f, -1.13598011e-01f, -5.62108308e-03f, 4.52907905e-02f, 1.59408480e-01f, 2.12464873e-02f, 2.03029156e-01f, -2.06605256e-01f, 4.86344956e-02f,
  -4.86661457e-02f, -1.36225060e-01f, 3.29080895e-02f, 2.71461904e-01f, 8.92343372e-02f, -3.78552154e-02f, -9.98166427e-02f, -5.06950691e-02f, -7.75154606e-02f, 2.29690373e-01f,
  2.50963997e-02f, -5.10189086e-02f, -4.69660193e-01f, -3.62408042e-01f, -3.10430199e-01f, -2.04480022e-01f, -1.29558861e-01f, -2.13551044e-01f, -2.15143576e-01f, -5.35255075e-01f,
  6.52089059e-01f, -1.49860159e-01f, 2.34723985e-01f, 1.63285330e-01f, 2.40476251e-01f, 2.75897831e-01f, 4.52750742e-01f, 3.39109898e-01f, -1.46000423e-02f, 9.20132920e-02f,
  -3.35160084e-02f, -1.32384464e-01f, -1.85163453e-01f, -2.20259696e-01f, -6.65504709e-02f, 5.97768985e-02f, 8.69334117e-03f, 1.14280013e-02f, 9.68890935e-02f, 1.58212572e-01f,
  -2.47881133e-02f, 2.07888082e-01f, 2.92127490e-01f, 5.92235997e-02f, -1.74421817e-01f, -1.11207716e-01f, 1.01319663e-02f, 1.01065889e-01f, -1.50081858e-01f, -2.75335312e-01f,
  -4.93240952e-01f, 4.32376057e-01f, 2.43030656e-02f, -1.41729057e-01f, -2.94722449e-02f, 1.82128027e-02f, 1.11726695e-03f, -7.18989875e-03f, -7.94074610e-02f, -6.48793206e-02f,
  -5.86946383e-02f, -6.54819533e-02f, 3.60422879e-02f, 8.38866159e-02f, 8.97573680e-02f, 1.13775127e-01f, 1.58496872e-01f, -2.97424272e-02f, -7.35467821e-02f, -6.29273430e-02f,
  -2.07906142e-01f, 1.11423522e-01f, 1.70448229e-01f, 4.76146676e-02f, -9.35812108e-03f, -1.17855236e-01f, 6.14569746e-02f, 4.19334434e-02f, -3.51154208e-02f, -5.19088693e-02f,
  3.37338299e-02f, -1.28692880e-01f, -1.29955381e-01f, -1.23785809e-02f, -4.72197868e-02f, -5.34535348e-02f, -1.44674003e-01f, -1.48146361e-01f, -8.48163217e-02f, 8.43519866e-02f,
  -1.83526516e-01f, -5.88010736e-02f, -4.39326242e-02f, 1.21226758e-01f, -1.27626956e-01f, 1.04765976e-02f, -4.39362936e-02f, -1.15549125e-01f, 7.57963657e-02f, 1.05980337e-01f,
  -1.52238850e-02f, 3.02479453e-02f, 2.25368142e-02f, -5.71766123e-02f, -7.10006878e-02f, -6.37014508e-02f, 8.09277594e-02f, -1.18929315e-02f, 3.00369393e-02f, 2.06484482e-01f,
  -3.85957003e-01f, 1.76490158e-01f, -1.59204137e-02f, -1.46612361e-01f, -4.06502262e-02f, -1.13508247e-01f, -1.64044023e-01f, -1.06917262e-01f, -1.63438022e-01f, -1.21960863e-01f,
  6.66979328e-02f, -1.82748269e-02f, -1.70831997e-02f, 4.50256802e-02f, 8.73500407e-02f, 7.83134624e-02f, -1.89098388e-01f, -8.38496014e-02f, -1.65669635e-01f, -1.84253111e-01f,
  -2.29182675e-01f, 1.44454852e-01f, 2.89200898e-02f, -5.69907390e-02f, -2.32587345e-02f, -4.61048596e-02f, -8.13845098e-02f, 1.20211385e-01f, 1.41342580e-01f, 1.23934768e-01f,
  1.96589679e-02f, 2.76919752e-01f, -1.92339607e-02f, 3.88158597e-02f, -7.96305165e-02f, -3.67424399e-01f, -4.09258872e-01f, -1.69012770e-01f, 1.24118485e-01f, 3.26353550e-01f,
  5.65222651e-02f, -8.10706988e-02f, -2.15352580e-01f, -3.13732177e-01f, -5.35162866e-01f, -1.74526095e-01f, -1.26472488e-01f, -3.96813244e-01f, -7.44565666e-01f, -5.42439342e-01f,
  -8.98789391e-02f, 1.95549224e-02f, -1.64687470e-01f, -1.65807232e-01f, 9.87351760e-02f, 1.42351184e-02f, 1.84648737e-01f, 1.26225278e-01f, 9.22446325e-03f, 3.03569734e-01f,
  -5.21821494e-04f, -1.51226580e-01f, -5.53735420e-02f, 1.17457017e-01f, 9.68888178e-02f, -5.01745865e-02f, -1.40131220e-01f, -9.91824716e-02f, -7.63989910e-02f, -1.01233676e-01f,
  4.12098430e-02f, -6.13694936e-02f, -1.36511102e-01f, -5.10326847e-02f, -1.80583224e-01f, -1.76275924e-01f, -3.02931499e-02f, -3.72879267e-01f, -3.84346247e-01f, -1.01792537e-01f,
  -1.47135913e-01f, -1.86762139e-01f, -2.40184352e-01f, -3.42038125e-01f, -3.26933652e-01f, -1.22898005e-01f, -8.79139677e-02f, -1.60748571e-01f, -2.96745241e-01f, 2.39174947e-01f,
  4.12605442e-02f, -1.08589483e-02f, -8.39807317e-02f, -9.21058003e-03f, 1.27216518e-01f, 1.90198496e-02f, -7.63391843e-04f, 3.39415413e-03f, -5.60109653e-02f, 1.74157858e-01f,
  -4.03083768e-03f, 1.49719119e-01f, 1.84304267e-01f, -1.69820823e-02f, -3.16486508e-02f, 3.52545381e-02f, 4.48717102e-02f, -4.87027178e-03f, -6.92698732e-03f, 1.22039951e-01f,
  7.53977820e-02f, 2.94635389e-02f, 9.93903205e-02f, -2.82978211e-02f, -1.31531293e-02f, 1.37319937e-01f, 2.34621055e-02f, 8.62981305e-02f, 1.85362492e-02f, 1.39051497e-01f,
  1.18205637e-01f, -2.69408882e-01f, 9.08616558e-02f, -1.56698987e-01f, -1.06245363e-02f, 1.09378703e-01f, -2.39534397e-02f, 2.28477698e-02f, 1.76909208e-01f, 8.30653161e-02f,
  -9.01979804e-02f, -8.50895420e-03f, -1.25946730e-01f, -1.19104393e-01f, 3.21952775e-02f, 1.70763745e-03f, 6.52546734e-02f, -1.42913356e-01f, -1.18099317e-01f, 9.93641615e-02f,
  1.54403314e-01f, -1.07639745e-01f, 3.37740928e-02f, -2.93589081e-03f, -1.99164256e-01f, -4.65643890e-02f, -6.95055276e-02f, 1.62238944e-02f, -3.74211043e-01f, 3.73526752e-01f,
  -8.61898899e-01f, 4.01769616e-02f, 2.92830206e-02f, -3.63262445e-01f, 1.54065758e-01f, 1.79513603e-01f, 1.85126945e-01f, 8.21726173e-02f, -4.35393527e-02f, -1.18894249e-01f,
  -2.18608417e-02f, -1.72704369e-01f, -1.85541138e-01f, 2.58389134e-02f, 3.07150297e-02f, 2.54928339e-02f, -6.98485449e-02f, -1.09697625e-01f, -1.60485432e-01f, 1.33711830e-01f,
  -9.59240124e-02f, -2.95204729e-01f, -4.33171630e-01f, -8.28952566e-02f, -2.48670429e-01f, -3.56182069e-01f, -3.56511742e-01f, -2.79941201e-01f, 1.42062933e-03f, -2.91117877e-01f,
  -1.84449971e-01f, -1.94583580e-01f, 1.24488436e-01f, 7.38555714e-02f, -6.70913234e-02f, 6.30284250e-02f, -1.46023065e-01f, -1.10344462e-01f, -3.69914738e-03f, 4.13031280e-02f,
  -3.12382746e-02f, 1.88283890e-01f, -8.21779668e-02f, 1.23761427e-02f, -2.02519689e-02f, 2.54989266e-02f, 5.62725142e-02f, 5.72054163e-02f, 7.34874681e-02f, 1.80403277e-01f,
  2.20205247e-01f, 1.09875826e-02f, -1.33642405e-01f, 9.86673236e-02f, 2.07481533e-01f, -5.27386852e-02f, 5.21899983e-02f, 6.62290901e-02f, 2.88169254e-02f, -1.89068228e-01f,
  5.21961413e-02f, 1.05449580e-01f, -4.55129370e-02f, -6.96947274e-04f, 3.63567285e-02f, 1.60465017e-02f, -1.13592595e-01f, -4.51958887e-02f, -2.41039768e-02f, -2.38751099e-02f,
  1.12875171e-01f, 7.79234916e-02f, 5.32418080e-02f, -2.29034916e-01f, 2.34014038e-02f, 4.64284569e-02f, -6.15458488e-02f, -5.33523671e-02f, 7.68158585e-02f, -9.68877971e-02f,
  1.21373080e-01f, 2.36759763e-02f, -9.99339819e-02f, 4.42419276e-02f, 1.72952488e-01f, -2.05849241e-02f, 1.29445806e-01f, 6.14499673e-02f, 9.70934406e-02f, 6.99950084e-02f,
  -3.94042909e-01f, -1.34186611e-01f, -2.75106162e-01f, 7.08202347e-02f, -7.47176185e-02f, 1.25472933e-01f, -1.78038314e-01f, 5.75314686e-02f, -1.11932373e-02f, 4.45107743e-02f,
  1.39450461e-01f, 5.27306385e-02f, 2.61823460e-02f, 1.24536082e-01f, -1.55502986e-02f, 5.55695631e-02f, 8.35055783e-02f, -6.86182361e-03f, 7.38516971e-02f, 3.73753570e-02f,
  9.15413275e-02f, -3.56981577e-03f, -1.68009281e-01f, 6.95907101e-02f, 2.30389610e-02f, -1.66627645e-01f, -9.60136801e-02f, 4.80280891e-02f, -3.33182663e-02f, -2.67437428e-01f,
  5.67175984e-01f, 2.29800656e-01f, 4.48113605e-02f, 3.78735713e-03f, -2.24749312e-01f, -4.08512354e-01f, -3.88126612e-01f, -7.66461194e-02f, 1.60126269e-01f, 1.58874825e-01f,
  3.94156016e-02f, -1.60770312e-01f, 2.89597418e-02f, -1.15688115e-01f, -1.49735913e-01f, 1.78210586e-02f, 1.11062080e-01f, -4.62815017e-02f, -3.05097103e-01f, -2.76248783e-01f,
  -2.06697270e-01f, -1.21381385e-02f, 2.02048272e-01f, 1.34719253e-01f, 2.60704905e-01f, 3.83505486e-02f, 1.32921398e-01f, 1.03678986e-01f, 1.40005663e-01f, 4.37887788e-01f,
  4.09677401e-02f, 2.61705637e-01f, -1.93224981e-01f, 1.02027662e-01f, -4.84845154e-02f, 2.18811378e-01f, -3.83875817e-02f, 1.70360267e-01f, -6.51824474e-02f, 4.18276079e-02f,
  -2.03779656e-02f, 1.35511726e-01f, -1.36749521e-01f, -1.08020507e-01f, -1.61641717e-01f, -7.46079609e-02f, 1.15984261e-01f, -4.39910181e-02f, -1.37465307e-02f, 5.31864688e-02f,
  -1.32693917e-01f, -1.20783195e-01f, -1.50559679e-01f, -2.25691587e-01f, 4.11108211e-02f, -1.78720891e-01f, -1.57232359e-01f, 1.83397129e-01f, 1.03867762e-01f, 2.97878683e-01f,
  -1.17639191e-02f, 1.05585381e-01f, -6.83736131e-02f, -2.00489253e-01f, -2.07349375e-01f, -1.85808957e-01f, -1.38402119e-01f, -1.45027414e-01f, -1.23063669e-01f, -3.60970758e-02f,
  -2.73274388e-02f, -3.20201591e-02f, -9.21078920e-02f, -5.18501066e-02f, -3.90164033e-02f, -2.92573459e-02f, -2.07966957e-02f, -6.42934889e-02f, -1.61693498e-01f, 3.35887298e-02f,
  -9.50498059e-02f, 3.44865117e-03f, -2.63888519e-02f, -5.36135174e-02f, 6.32375777e-02f, -9.29231346e-02f, -4.33000252e-02f, -8.82637352e-02f, 3.59468944e-02f, 1.69135377e-01f,
  -1.53291933e-02f, -3.46093416e-01f, 1.57917783e-01f, 2.13566437e-01f, 4.59575318e-02f, 1.47953182e-01f, 1.36399582e-01f, 2.64413073e-03f, 3.69667709e-02f, 2.76405755e-02f,
  -9.12045967e-03f, 4.05734926e-02f, 2.36466192e-02f, -2.33617760e-02f, -1.41262129e-01f, -1.79053489e-02f, 1.80157530e-03f, -8.77695084e-02f, -8.18217546e-02f, 1.26694992e-01f,
  -4.64787520e-02f, -2.18173534e-01f, -2.56073296e-01f, -1.98856816e-01f, 5.75626567e-02f, -3.25310618e-01f, -1.34828031e-01f, -4.05162871e-02f, -2.80934870e-01f, -1.51003465e-01f,
  9.76308703e-01f, 5.06553769e-01f, 3.55479896e-01f, 5.62525950e-02f, 2.67914380e-03f, 3.03191453e-01f, 3.88234258e-01f, 3.79738033e-01f, -8.42896625e-02f, 2.06208169e-01f,
  4.97180745e-02f, -2.67144352e-01f, -7.55954385e-02f, -7.74192661e-02f, 2.06187695e-01f, 1.78232893e-01f, -1.27100537e-03f, 1.49750352e-01f, 2.90411830e-01f, 1.61204129e-01f,
  -1.17214464e-01f, 1.64408579e-01f, 3.42370957e-01f, 1.41792744e-02f, -1.46786198e-01f, -1.90576553e-01f, 7.99287185e-02f, 9.56413746e-02f, -6.12880625e-02f, -1.77160680e-01f,
  -1.60253778e-01f, 5.39616346e-01f, -2.28628099e-01f, -1.44974023e-01f, -2.47309431e-02f, 1.13380216e-01f, -2.71583144e-02f, 9.47770383e-03f, -6.85762092e-02f, -5.41489534e-02f,
  -1.82415247e-01f, -4.45343219e-02f, 6.73088571e-03f, -8.79188329e-02f, 7.23208264e-02f, 3.79015431e-02f, 5.82622252e-02f, 1.93061456e-01f, -2.17051469e-02f, -3.11804153e-02f,
  -2.41239026e-01f, -6.25076070e-02f, 6.27738833e-02f, 1.22577501e-02f, 1.02838553e-01f, -1.30180955e-01f, 4.39718999e-02f, -2.67717745e-02f, 1.46734118e-01f, 1.42718256e-01f,
  -8.32291767e-02f, 2.20886115e-02f, 8.91974866e-02f, 1.42961264e-01f, 1.66555509e-01f, -1.76553447e-02f, -6.28171191e-02f, -1.60503209e-01f, 2.89930105e-02f, 6.81553036e-02f,
  -7.21986517e-02f, -3.16364616e-02f, -8.44619274e-02f, 1.90115236e-02f, -1.85323492e-01f, 1.06480485e-02f, -7.36075491e-02f, 5.73341399e-02f, -7.97605962e-02f, -5.90037294e-02f,
  1.78560298e-02f, -1.95311569e-02f, -8.49169493e-02f, 1.64160151e-02f, 1.11731663e-01f, -5.43658584e-02f, -9.16639641e-02f, -4.75523211e-02f, -2.26496495e-02f, -3.02384067e-02f,
  -4.91728067e-01f, -9.25058797e-02f, -2.03356043e-01f, 7.30977729e-02f, 2.66653113e-03f, -5.87384552e-02f, -1.60320342e-01f, -2.65092822e-03f, -9.24852490e-02f, -9.31814138e-04f,
  -6.90018013e-02f, -1.33879902e-02f, -2.48960126e-02f, -8.66304189e-02f, -4.86749299e-02f, -1.33938789e-01f, -7.71499649e-02f, 6.34706840e-02f, -2.38065552e-02f, -1.55248538e-01f,
  -2.18090229e-02f, -3.79427113e-02f, -5.99396490e-02f, -1.05731562e-01f, -1.56597465e-01f, -1.20751105e-01f, -5.49945533e-02f, -6.53771088e-02f, 1.16463028e-01f, -7.13206595e-04f,
  -7.78620765e-02f, 6.08846843e-02f, 4.80082780e-01f, -2.18924969e-01f, -1.50463045e-01f, -1.87537432e-01f, -2.27428064e-01f, 5.06785028e-02f, 5.29590696e-02f, -5.32372948e-03f,
  -1.78985074e-02f, -2.69326985e-01f, 8.98796134e-03f, 1.03574254e-01f, -5.99295981e-02f, 3.29921544e-02f, 2.97105815e-02f, 7.49002546e-02f, -1.68790400e-01f, -3.17246020e-01f,
  -3.68802786e-01f, -4.80205789e-02f, 4.90652844e-02f, 2.80554779e-02f, 1.51437018e-02f, -8.64769891e-02f, 3.63532186e-01f, 2.78069861e-02f, 9.63759646e-02f, 5.47360964e-02f,
  3.99011001e-02f, 1.41176641e-01f, -1.09288014e-01f, -2.38084868e-01f, 4.35532480e-02f, -1.54216036e-01f, 2.77707935e-03f, 1.01624876e-01f, -2.46577673e-02f, -1.84154045e-02f,
  -2.03072771e-01f, -8.20990372e-03f, -2.07343727e-01f, -1.68254480e-01f, -3.15972626e-01f, -1.34561211e-01f, -7.78916571e-03f, 1.35174379e-01f, 1.15522884e-01f, 5.95550761e-02f,
  -3.53736013e-01f, -1.67922080e-01f, 2.47674994e-02f, 2.59962231e-01f, 2.64433831e-01f, -1.79048121e-01f, -1.37869164e-01f, -3.83876003e-02f, 1.65000647e-01f, 2.44867336e-02f,
  5.08501083e-02f, -6.67465553e-02f, -5.06087393e-03f, 2.51807664e-02f, 8.66501555e-02f, 1.04102977e-01f, 1.11775666e-01f, -4.17993106e-02f, -4.03201170e-02f, 5.32365330e-02f,
  1.39277771e-01f, 1.44214571e-01f, -2.16406658e-02f, 1.63896695e-01f, 5.72409406e-02f, -6.50223941e-02f, -9.92469490e-02f, 9.46007147e-02f, 3.88923287e-02f, 9.00372565e-02f,
  -4.05739099e-02f, -7.13121668e-02f, 7.20640793e-02f, 4.36203787e-03f, 2.00086907e-02f, 6.33120164e-02f, 7.23943231e-05f, -7.85084516e-02f, -6.51978329e-02f, 5.88454381e-02f,
  -2.63897657e-01f, 2.56346107e-01f, -2.46437773e-01f, -4.88223061e-02f, -9.72755849e-02f, 9.18659419e-02f, 3.06396391e-02f, 8.26772004e-02f, 9.26884860e-02f, -8.13384634e-03f,
  -7.71657676e-02f, 7.74107724e-02f, -2.62832269e-02f, -2.22917169e-01f, -2.19583899e-01f, -1.46678895e-01f, -1.74091548e-01f, -1.44049257e-01f, -1.07473835e-01f, -1.58905849e-01f,
  -1.71116278e-01f, -2.43713528e-01f, -4.46628690e-01f, -1.24926850e-01f, -1.76721439e-01f, -2.26260856e-01f, -2.52956420e-01f, -2.35619351e-01f, -1.25596061e-01f, -3.13208759e-01f,
  -3.15783888e-01f, -5.43169856e-01f, 2.22596794e-01f, 4.42015380e-01f, 3.49927217e-01f, 4.12319392e-01f, 2.27831006e-01f, 1.28412485e-01f, 1.86619997e-01f, 3.47754024e-02f,
  -1.74304321e-01f, 3.87260169e-02f, -4.54311334e-02f, -1.46115739e-02f, 1.48194134e-02f, 2.53528595e-01f, 3.77393782e-01f, 1.15447067e-01f, 1.77319184e-01f, 2.42933393e-01f,
  5.19785583e-02f, 4.88098674e-02f, -2.01472282e-01f, 9.34569223e-04f, 7.54068568e-02f, 7.59897903e-02f, 1.75361305e-01f, 3.50689143e-02f, -2.37543252e-03f, 1.57770634e-01f,
  3.36108357e-02f, -1.83926925e-01f, 9.32474062e-02f, -9.29503441e-02f, -2.25008070e-01f, -1.20019168e-01f, 3.00068036e-02f, -1.20387502e-01f, -8.62074569e-02f, -2.79339682e-02f,
  -1.89780481e-02f, -1.77677020e-01f, -1.59116685e-01f, -1.45182610e-01f, 1.23623274e-02f, -1.52072251e-01f, -7.48664588e-02f, -5.83856227e-03f, 9.73621458e-02f, -1.20839439e-01f,
  -2.64549665e-02f, -6.71832040e-02f, 2.19729301e-02f, 9.09135342e-02f, 4.29808162e-02f, 5.76598160e-02f, -1.06281281e-01f, -4.52751741e-02f, 1.92827370e-03f, 3.43318544e-02f,
  2.83782274e-01f, -2.66737677e-02f, -2.10953457e-03f, 2.12890040e-02f, 5.33331484e-02f, 1.15012072e-01f, 1.32369950e-01f, 1.72643617e-01f, 1.68121859e-01f, -6.17073141e-02f,
  3.75910290e-02f, 2.16147989e-01f, 1.16043098e-01f, 9.09538493e-02f, 5.42562082e-02f, -1.01142064e-01f, -3.91017497e-02f, -8.63135383e-02f, -5.58576882e-02f, -8.73167664e-02f,
  -1.79539453e-02f, -7.07269534e-02f, -1.94630072e-01f, -1.54616654e-01f, -1.21130243e-01f, -4.58403379e-02f, -2.33588386e-02f, -1.00199170e-01f, -1.62957519e-01f, -6.87015206e-02f,
  2.04853807e-02f, 1.08086057e-01f, 1.80687740e-01f, -4.57932167e-02f, -2.58119758e-02f, -2.82720864e-01f, -1.69776473e-02f, -8.02579150e-02f, -1.97927579e-01f, 1.02174088e-01f,
  -2.54680924e-02f, -2.19966799e-01f, -1.45771012e-01f, -1.92884523e-02f, 1.06074892e-01f, 3.39024067e-02f, -8.74795839e-02f, 6.25399649e-02f, 5.27077243e-02f, 2.61845328e-02f,
  -7.84454420e-02f, 2.49738768e-01f, 1.83476940e-01f, 2.78221577e-01f, 1.95733532e-01f, 7.30601847e-02f, 1.60955593e-01f, 8.75368789e-02f, 1.78379491e-01f, 4.51790690e-02f,
  -1.01673579e+00f, -2.96245553e-02f, 1.83430836e-01f, -6.10633194e-01f, -1.09394863e-01f, 1.98761106e-01f, 3.99676859e-01f, -2.92129051e-02f, -4.33783770e-01f, 4.92349118e-02f,
  1.16651043e-01f, -1.31502850e-02f, -9.73768383e-02f, 1.96300581e-01f, 4.90122959e-02f, 3.33772451e-01f, 7.05590174e-02f, -6.26487955e-02f, -1.01238422e-01f, 3.94382328e-02f,
  -3.30441818e-02f, -3.13375413e-01f, -4.48779821e-01f, -2.24449635e-01f, -7.93697163e-02f, -2.50834346e-01f, 1.69531591e-02f, -2.09143862e-01f, 5.04980423e-02f, -1.41708955e-01f,
  5.12490034e-01f, -5.00166491e-02f, 2.07649112e-01f, -2.90625215e-01f, 4.30841781e-02f, -1.21294498e-01f, -7.54658803e-02f, -1.54803053e-01f, -1.00527212e-01f, -1.08413100e-01f,
  -2.25621209e-01f, -1.80128738e-02f, -1.85300689e-02f, 9.96682048e-02f, -5.44868968e-02f, -1.53456643e-01f, -1.34069949e-01f, -1.95006281e-01f, -1.09628066e-01f, 3.11238915e-01f,
  2.44191941e-02f, -2.49467567e-02f, -5.33835925e-02f, 2.98860129e-02f, 9.43181217e-02f, -7.01354817e-02f, 1.16357878e-01f, -1.28706396e-01f, 7.70845264e-03f, 1.91156436e-02f,
  -1.13029838e-01f, 6.35846108e-02f, 1.65832695e-02f, 6.37847837e-03f, 4.65935357e-02f, -1.28316591e-02f, 1.16256647e-01f, 4.21050712e-02f, 4.03178595e-02f, -1.29554272e-01f,
  1.27126589e-01f, 9.62866396e-02f, -5.62524833e-02f, 5.18876314e-02f, 1.53116822e-01f, 5.15485555e-03f, -4.88952249e-02f, 6.43881485e-02f, 2.33982354e-02f, -5.34021780e-02f,
  -5.34322374e-02f, -5.70273176e-02f, 3.60421166e-02f, 3.95209566e-02f, 4.32714075e-02f, -5.17952815e-02f, -4.72394936e-02f, 3.51872519e-02f, -1.14558779e-01f, -1.21168800e-01f,
  3.01658958e-02f, 6.93550631e-02f, -1.41980099e-02f, -5.13276421e-02f, -8.06053057e-02f, -3.10964379e-02f, -1.25822380e-01f, -9.40491781e-02f, -3.02487463e-02f, -7.46912286e-02f,
  -7.24245980e-02f, 1.00325130e-01f, 8.42585042e-02f, 5.21611050e-02f, 6.59492612e-02f, -5.75069040e-02f, 1.13861756e-02f, -2.24902444e-02f, 5.39294109e-02f, -9.61983055e-02f,
  -4.35735937e-03f, 3.03499214e-02f, -2.00209960e-01f, 6.75955340e-02f, 4.67274114e-02f, 2.12101918e-02f, 1.91002101e-01f, -5.70047535e-02f, 1.51691407e-01f, -6.72595692e-04f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  1.93158925e-01f, 2.59802252e-01f, 2.53543019e-01f, 4.29790825e-01f, 2.76986241e-01f, 2.23120153e-01f, 3.19818228e-01f, 2.39989057e-01f, 2.41894156e-01f, -3.68344113e-02f,
  5.20607345e-02f, 1.62452459e-01f, 2.10336655e-01f, 1.83557987e-01f, 1.51025161e-01f, 2.28588209e-01f, 1.40577674e-01f, 1.52136251e-01f, 4.13615704e-01f, 3.24991941e-01f,
  -1.16116494e-01f, 4.10128176e-01f, 3.41945767e-01f, 1.42642185e-01f, 1.97747618e-01f, 8.67603496e-02f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -3.11317202e-02f, 1.72656439e-02f, 3.33489291e-02f, 1.88785732e-01f, -7.97031224e-02f, -2.28083902e-03f, 6.67172149e-02f, 8.03122073e-02f, -1.71276376e-01f, 1.45074502e-01f,
  1.21758729e-01f, 4.46759820e-01f, -1.69053212e-01f, 5.46660684e-02f, 2.27235869e-01f, 1.48080528e-01f, 1.05971679e-01f, -4.51065660e-01f, 2.39706715e-03f, 3.99921238e-01f,
  -2.27895617e-01f, -1.37410685e-01f, 2.27398559e-01f, -3.19621384e-01f, 9.86768752e-02f, -1.39581300e-02f, -3.10233563e-01f, -2.86514819e-01f, 8.08141157e-02f, -2.05403760e-01f,
  -1.56725407e-01f, -9.93001312e-02f, 1.17573872e-01f, 1.14005376e-02f, -1.41773418e-01f, -1.93508379e-02f, 7.51220137e-02f, -7.31219947e-02f, -1.96295187e-01f, -2.34009236e-01f,
  -3.21835726e-01f, -1.02248475e-01f, -2.50385016e-01f, -2.40580231e-01f, 1.91476777e-01f, -1.07756309e-01f, 1.38670504e-01f, 1.34693027e-01f, -1.73172444e-01f, 2.47080311e-01f,
  1.16733491e-01f, 9.71066654e-02f, -9.20197368e-03f, 1.42763481e-01f, -6.74465001e-02f, 2.50424705e-02f, -1.11677758e-01f, 2.88616568e-01f, -1.17220506e-01f, 1.04442388e-01f,
  -7.67298192e-02f, 1.38154775e-01f, 2.84051538e-01f, 5.34769222e-02f, 7.33055547e-02f, 7.02392384e-02f, -4.71085943e-02f, 1.57844350e-02f, 8.13305750e-03f, -2.03198195e-01f,
  -1.41234875e-01f, 3.35735157e-02f, -1.19596615e-01f, -1.80551976e-01f, 1.25802860e-01f, -1.99132785e-01f, -1.26329616e-01f, -3.30048770e-01f, 2.04072908e-01f, 1.27176717e-01f,
  -2.02717260e-04f, -5.96075915e-02f, -7.53332973e-02f, 4.43378761e-02f, -1.11046828e-01f, -1.11267529e-01f, -2.75018457e-02f, 6.19337941e-03f, 8.89886394e-02f, 9.09671001e-03f,
  -1.01133101e-01f, -7.17253760e-02f, -5.67401722e-02f, 2.44631618e-01f, 1.89711422e-01f, 1.30564064e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  3.38260412e-01f, 2.05390245e-01f, 1.55924648e-01f, 1.42264262e-01f, -1.23534583e-01f, 2.02137902e-01f, 7.84295276e-02f, -4.17922251e-03f, 6.31404281e-01f, 3.65127847e-02f,
  1.19820982e-01f, 3.03416431e-01f, 1.07625507e-01f, 2.38630638e-01f, 1.25812709e-01f, -2.46620059e-01f, 1.22204691e-01f, 4.04380560e-01f, -1.31654635e-01f, 7.37364471e-01f,
  4.68008280e-01f, 1.47886813e-01f, 1.58601567e-01f, 4.13980186e-01f, -1.09166764e-01f, 8.67718309e-02f, 4.30557102e-01f, 3.29691589e-01f, 2.43910894e-01f, 3.10666144e-01f,
  -4.37231004e-01f, 4.85138185e-02f, 5.81801474e-01f, -2.34520547e-02f, 7.43136704e-02f, 1.89855605e-01f, 2.33408600e-01f, 2.51121163e-01f, 2.16211841e-01f, 5.83154969e-02f,
  -6.08714104e-01f, 4.55872476e-01f, -2.85068750e-01f, 1.86508030e-01f, 3.48812044e-01f, 1.97691228e-02f, -1.77669283e-02f, -2.75410116e-01f, -2.76844352e-01f, 7.32973069e-02f,
  3.35380286e-01f, -2.01315224e-01f, -1.35995328e-01f, -1.65916920e-01f, 1.74166694e-01f, -3.61784488e-01f, 4.87492204e-01f, 3.67539853e-01f, -2.09807470e-01f, 3.82764071e-01f,
  1.47425771e-01f, 1.30869731e-01f, 1.08889490e-01f, 2.61915147e-01f, 2.64208227e-01f, 2.05044255e-01f, 2.57143438e-01f, 1.87877074e-01f, -4.52601314e-02f, 2.89380372e-01f,
  2.54159361e-01f, 7.88581967e-02f, 5.17216139e-02f, 3.46126646e-01f, -1.31988376e-01f, 4.88557756e-01f, 1.32611632e-01f, 4.35572326e-01f, 1.05955012e-01f, -1.34894297e-01f,
  4.84135181e-01f, -6.22654669e-02f, 3.38154137e-01f, 3.32919002e-01f, 9.52231809e-02f, -1.70871422e-01f, 4.60191369e-01f, 2.18130186e-01f, 2.15670943e-01f, 2.57482708e-01f,
  8.05698186e-02f, 5.39054945e-02f, -2.47958228e-01f, 1.77156165e-01f, -5.84583282e-01f, -1.66665316e-01f, 1.57027066e-01f, 1.45924166e-01f, 1.79100737e-01f, 1.69717938e-01f,
  1.51902169e-01f, -1.01982273e-01f, 3.11370194e-01f, -2.23335568e-02f, -1.75016969e-01f, 4.41793948e-01f, -2.55414128e-01f, 4.72718507e-01f, -1.38957322e-01f, -1.03573734e-02f,
  -1.33203879e-01f, -1.10242553e-01f, 1.36453614e-01f, 3.48439848e-04f, 3.06260347e-01f, -1.02442145e-01f, 1.93012699e-01f, -4.71679240e-01f, 3.23983997e-01f, 1.47308409e-01f,
  5.05594611e-01f, 2.01140821e-01f, 9.89054441e-02f, -2.45728418e-01f, 2.32333004e-01f, 4.14440721e-01f, -8.35706070e-02f, 3.51001412e-01f, 1.81879938e-01f, 1.13152698e-01f,
  2.51788765e-01f, -3.48423421e-01f, -1.04964659e-01f, 1.42118141e-01f, -8.22072774e-02f, 4.27345693e-01f, -1.13489322e-01f, 2.98292398e-01f, -3.25131863e-01f, 3.16098183e-01f,
  -1.91863492e-01f, -3.05639893e-01f, 4.07428183e-02f, -4.65297997e-02f, 8.06144848e-02f, -4.36641604e-01f, -2.79004276e-01f, 7.92071049e-04f, 6.41793758e-02f, 1.00786388e-01f,
  -4.51754451e-01f, -3.21883783e-02f, 4.37800646e-01f, -1.30934730e-01f, 2.11938530e-01f, -1.10290021e-01f, 3.14162701e-01f, 1.76793143e-01f, -1.11690409e-01f, 5.55556297e-01f,
  -2.01394394e-01f, -1.87785123e-02f, 4.83734369e-01f, -6.19460762e-01f, 4.03828472e-02f, 1.37121215e-01f, -5.91578223e-02f, 2.57848531e-01f, 3.38026196e-01f, 2.83418819e-02f,
  1.55953169e-02f, 5.63501835e-01f, 6.72823796e-03f, 5.31250089e-02f, 5.30970991e-01f, -2.07758948e-01f, -6.62492737e-02f, -3.44243258e-01f, -2.69042224e-01f, 2.66737968e-01f,
  3.60495090e-01f, 1.17558584e-01f, 1.42052785e-01f, -2.41958890e-02f, -1.09187901e-01f, 1.95124209e-01f, 1.90067664e-01f, 1.05941333e-01f, 2.96845138e-02f, -3.36292744e-01f,
  2.24275757e-02f, 2.91557580e-01f, 2.09366828e-01f, -7.21566088e-04f, -9.34981406e-02f, 3.19311559e-01f, -7.31041655e-02f, 6.33436739e-02f, 3.73642415e-01f, -2.72348702e-01f,
  1.39064848e-01f, 2.30630636e-01f, -1.01611502e-01f, 4.48979914e-01f, 1.63029283e-01f, 2.95376122e-01f, 1.70683056e-01f, -4.59505878e-02f, -4.43801321e-02f, 2.58136779e-01f,
  4.50442195e-01f, 4.46146548e-01f, -4.06963602e-02f, 1.69576406e-01f, 2.78062075e-01f, -1.46896854e-01f, 3.20386618e-01f, 1.33456185e-01f, -1.86611116e-01f, 2.29421511e-01f,
  8.35973844e-02f, -2.06076443e-01f, 7.35895708e-02f, -1.70815393e-01f, 1.54695287e-01f, 1.03924535e-01f, 2.24569857e-01f, -1.60634533e-01f, 2.88535774e-01f, 3.35224569e-01f,
  1.78757235e-01f, 4.54808503e-01f, -7.65920877e-02f, 5.51449418e-01f, -4.52293038e-01f, 5.47509670e-01f, 4.27717827e-02f, 1.01301983e-01f, 3.01127523e-01f, -4.35200393e-01f,
  1.00878449e-02f, -3.73217344e-01f, 3.26089412e-01f, -3.31647098e-02f, 4.24687535e-01f, 2.46846844e-02f, 3.29766423e-02f, 1.62439644e-01f, -3.33004072e-02f, 4.72455144e-01f,
  4.45112616e-01f, 7.31590465e-02f, -1.62729502e-01f, 8.94441176e-03f, 2.52867267e-02f, 4.75552022e-01f, -8.20946135e-03f, 3.43969434e-01f, 2.01968819e-01f, 5.28952658e-01f,
  -6.62185578e-03f, -3.40050697e-01f, -1.37877449e-01f, -1.07332259e-01f, 2.73162514e-01f, -1.05337560e-01f, 6.20076358e-01f, 2.26257637e-01f, -2.16931596e-01f, 1.77006960e-01f,
  -9.88591909e-02f, -1.00260347e-01f, -8.25447142e-02f, 4.56412345e-01f, 7.40909353e-02f, -1.52979732e-01f, 1.73757344e-01f, -5.45151122e-02f, 2.73273081e-01f, 2.35966325e-01f,
  2.15456143e-01f, -3.23025472e-02f, -2.32548505e-01f, -3.84171396e-01f, 6.14091493e-02f, 2.39613101e-01f, 4.58520837e-02f, -2.91026145e-01f, -5.71060413e-03f, -8.65214989e-02f,
  -7.40873441e-02f, 2.35013753e-01f, 1.89729296e-02f, 1.87056570e-03f, 2.80867189e-01f, -1.75239176e-01f, -2.24978894e-01f, 1.53003812e-01f, 2.74870187e-01f, 3.13297808e-01f,
  -1.25000775e-01f, 1.06098369e-01f, -8.59249756e-02f, 5.00777736e-02f, -1.20031964e-02f, -2.98656851e-01f, -1.37356132e-01f, 2.29783028e-01f, 1.26094207e-01f, 3.05226386e-01f,
  4.86285269e-01f, -3.05069476e-01f, 4.00149286e-01f, 1.60665676e-01f, -7.74752721e-02f, -2.62642533e-01f, 3.02587837e-01f, -3.37215334e-01f, 3.74968141e-01f, 3.88658084e-02f,
  -9.16815251e-02f, 2.60462135e-01f, 3.32158834e-01f, 2.32568726e-01f, -4.08769585e-02f, -1.57191709e-01f, 1.14444606e-01f, 1.56519815e-01f, 6.06379032e-01f, -5.12711294e-02f,
  3.59415829e-01f, 6.68315813e-02f, -2.23984625e-02f, 1.08271591e-01f, 5.37471235e-01f, -1.20226648e-02f, 3.81228417e-01f, 1.67353496e-01f, -6.05699271e-02f, 1.89043462e-01f,
  9.41723511e-02f, 7.56685529e-03f, 2.86996037e-01f, 2.69465655e-01f, -6.10244758e-02f, 5.78255467e-02f, -3.62824388e-02f, -1.31624117e-01f, -3.93833250e-01f, -1.94211021e-01f,
  1.39517546e-01f, -3.75212699e-01f, 3.46378505e-01f, 2.79021502e-01f, 1.82558030e-01f, 6.07334338e-02f, -1.98408380e-01f, 6.27723290e-03f, 7.76819214e-02f, -2.07778215e-01f,
  -7.73053691e-02f, -1.17143817e-01f, 3.75201225e-01f, -1.46118365e-02f, 1.98725909e-01f, 4.28463183e-02f, -1.55076087e-01f, 2.07510322e-01f, 3.27366069e-02f, 5.79200089e-01f,
  4.08931941e-01f, 3.21202546e-01f, -2.15581030e-01f, 3.01473260e-01f, 2.18290433e-01f, -1.86242804e-01f, 3.78819406e-01f, 2.57878900e-01f, -1.99864581e-01f, 5.26710033e-01f,
  3.69580507e-01f, 1.32803410e-01f, -2.11831853e-01f, -1.28970310e-01f, 6.33473173e-02f, 1.29742920e-01f, 1.34874493e-01f, 5.39462149e-01f, 2.18117267e-01f, -4.80414003e-01f,
  2.54270375e-01f, -1.26865447e-01f, 1.57883450e-01f, -1.11931704e-01f, 4.65549886e-01f, 2.40988061e-01f, 1.02032952e-01f, 2.74737895e-01f, -6.12994917e-02f, -2.49810323e-01f,
  2.27339640e-01f, 2.87473083e-01f, -1.31930336e-01f, 3.97501662e-02f, -2.14560449e-01f, -2.56230652e-01f, 4.36016142e-01f, 6.31614355e-03f, 1.60609990e-01f, 6.47476092e-02f,
  -1.51236802e-01f, -9.27363895e-03f, -3.16253006e-02f, -2.53962502e-02f, 2.27324054e-01f, -2.48840466e-01f, 1.18138492e-01f, 1.68801025e-01f, 1.26113713e-01f, -3.05291644e-04f,
  -6.03467524e-02f, 2.24938720e-01f, -8.81798193e-02f, 1.16794229e-01f, -2.60478761e-02f, 3.49971442e-03f, -4.28789169e-01f, -1.22141086e-01f, -7.23399669e-02f, -1.49230465e-01f,
  -3.55469018e-01f, 1.94741547e-01f, 3.99688259e-02f, -3.66266459e-01f, -1.39347166e-01f, 6.22858405e-02f, 3.36387485e-01f, -5.45925081e-01f, 4.49001091e-03f, 2.65000105e-01f,
  -3.12365331e-02f, 8.88924822e-02f, 1.97548047e-01f, -1.48415089e-01f, 1.72632247e-01f, 3.38033199e-01f, 1.70978829e-01f, 4.01782304e-01f, -8.27470645e-02f, 1.44706026e-01f,
  -5.07317833e-04f, -4.60964292e-01f, -3.79512608e-01f, -5.86670265e-02f, 1.96572334e-01f, 3.78676772e-01f, 2.32248366e-01f, -2.33970024e-02f, -1.67979524e-01f, -2.29436263e-01f,
  3.55209947e-01f, 1.98256940e-01f, 3.43517154e-01f, -2.80312747e-01f, 1.69045031e-01f, -4.07493263e-02f, -3.62901270e-01f, -3.05131257e-01f, 2.30327293e-01f, 2.99551636e-01f,
  -3.37543666e-01f, 2.80257761e-01f, -1.57061949e-01f, 1.66995436e-01f, 3.73687834e-01f, 1.10376976e-01f, -1.68811589e-01f, 2.11088017e-01f, 8.72055516e-02f, 1.07583381e-01f,
  -4.23712377e-03f, 1.26041651e-01f, 1.61728248e-01f, -1.62043154e-01f, 1.37816265e-01f, -1.68359026e-01f, 3.14704888e-02f, 3.70980740e-01f, 3.00542235e-01f, -1.14292979e-01f,
  3.22037905e-01f, -2.53257882e-02f, 2.54522324e-01f, 3.51789713e-01f, 4.61947769e-01f, 1.28400907e-01f, 1.63484253e-02f, -2.54941285e-01f, -2.52607107e-01f, 1.23394139e-01f,
  1.13427609e-01f, 1.71108365e-01f, -6.74631298e-02f, 1.53877325e-02f, -2.64797825e-02f, 1.44191608e-01f, -3.21338931e-03f, 3.76014858e-01f, -2.02634811e-01f, -3.94460052e-01f,
  4.18478847e-01f, -6.34043515e-02f, 9.06941760e-03f, 2.06985801e-01f, 2.06147730e-01f, -2.84923583e-01f, -2.63072282e-01f, 8.45975205e-02f, 1.38344485e-02f, 2.45379418e-01f,
  1.76779330e-01f, 3.52182798e-02f, 7.86402076e-02f, -3.81654263e-01f, 5.24287105e-01f, -1.18534938e-01f, 3.98375988e-01f, -2.02515677e-01f, -6.73667043e-02f, 3.27626497e-01f,
  -3.31383608e-02f, -1.70345739e-01f, -2.02733129e-01f, 2.70998657e-01f, -8.33671913e-02f, -2.85325702e-02f, -3.70913595e-01f, 4.88435656e-01f, 1.05885178e-01f, 2.96182126e-01f,
  -4.10338074e-01f, 2.22638533e-01f, -4.35929447e-02f, -7.55047426e-02f, 1.77058160e-01f, 2.90767491e-01f, 3.10751557e-01f, -9.24314708e-02f, 1.74591571e-01f, 1.60913710e-02f,
  1.29428595e-01f, 4.03291047e-01f, 2.39207204e-02f, 3.92114222e-01f, -2.56655496e-02f, 6.33464932e-01f, -1.58891156e-02f, 3.38966578e-01f, 5.71882963e-01f, -3.24174047e-01f,
  -1.08836345e-01f, -1.36984244e-01f, -2.37294193e-02f, 3.11260313e-01f, 7.41521642e-02f, 1.41126692e-01f, 5.68018556e-01f, -3.44408043e-02f, -3.22124273e-01f, 5.26955687e-02f,
  -5.61978146e-02f, -7.05283806e-02f, -2.70393670e-01f, -1.47363648e-01f, -7.79861119e-04f, -7.02704489e-02f, -3.69492657e-02f, 8.79557580e-02f, 4.69227992e-02f, -1.75600827e-01f,
  4.71403934e-02f, -9.00352374e-02f, 1.26574606e-01f, 3.50553468e-02f, 1.09563760e-01f, 6.19931147e-02f, 3.81146342e-01f, 2.61026829e-01f, 2.45194271e-01f, 2.41392270e-01f,
  3.70975524e-01f, -1.11790657e-01f, 1.21528842e-01f, -1.64281130e-01f, 3.35816383e-01f, -1.17168806e-01f, -9.71943289e-02f, 2.91198313e-01f, 2.85144597e-01f, -8.36850703e-02f,
  6.92926208e-03f, 1.48874462e-01f, -2.92960018e-01f, -2.43797190e-02f, -2.31808946e-01f, -3.93529773e-01f, 4.29833442e-01f, -1.62582934e-01f, 5.23363017e-02f, 7.67046884e-02f,
  2.66910732e-01f, 6.95677772e-02f, -5.18296799e-03f, -1.05916835e-01f, 1.91668496e-01f, -1.41731560e-01f, 1.05313592e-01f, -1.37932718e-01f, -6.12487383e-02f, -2.87955612e-01f,
  5.12433648e-01f, 1.05900299e-02f, 1.26717106e-01f, -1.46833742e-02f, -2.19665408e-01f, 4.12634581e-01f, 4.32813950e-02f, -3.46415758e-01f, -1.76577374e-01f, 4.73649710e-01f,
  1.52950242e-01f, 3.02596241e-01f, -4.38417286e-01f, 2.68196464e-01f, -6.04532771e-02f, 4.93596464e-01f, -3.45409423e-01f, 3.11975837e-01f, 7.89443254e-02f, -1.42694876e-01f,
  -1.14841744e-01f, 2.75843799e-01f, -3.00513059e-02f, -2.83420175e-01f, -7.08055422e-02f, 1.80219918e-01f, 2.72439688e-01f, 2.57620960e-01f, 1.10511072e-01f, 1.59153923e-01f,
  -3.60972553e-01f, 1.80476770e-01f, -2.41307795e-01f, -1.31519705e-01f, 3.69614176e-02f, -1.46851569e-01f, 3.11276913e-01f, -2.17462152e-01f, 1.64692730e-01f, -1.30005673e-01f,
  2.66779661e-01f, -1.49515346e-01f, -2.82527834e-01f, 4.68878984e-01f, 1.76427200e-01f, 9.18182805e-02f, 3.20013225e-01f, -1.83075324e-01f, 1.00431748e-01f, 3.11501384e-01f,
  -5.08371405e-02f, 4.46917295e-01f, -4.18868698e-02f, 1.20150469e-01f, 1.35320440e-01f, 1.06352985e-01f, -9.94863883e-02f, -6.74461126e-02f, 2.54029214e-01f, 2.69326001e-01f,
  1.14075817e-01f, -1.46139264e-01f, 2.02117056e-01f, -2.73305804e-01f, 9.27623808e-02f, -5.81250004e-02f, 8.48599523e-02f, 8.57777372e-02f, 5.98619223e-01f, 1.66579410e-01f,
  -2.58891016e-01f, -2.00927764e-01f, 3.88128877e-01f, 1.32947683e-01f, -2.94942558e-01f, 2.08222106e-01f, 3.59976381e-01f, -2.34887227e-01f, 2.72889167e-01f, 3.25400800e-01f,
  3.78071636e-01f, 4.60608035e-01f, 2.04482645e-01f, -8.36925060e-02f, 1.01397693e-01f, 1.81061640e-01f, 8.84118453e-02f, -1.49342388e-01f, -8.98915455e-02f, 7.30504319e-02f,
  -3.80383253e-01f, 3.60563368e-01f, -2.61240751e-02f, -3.49880159e-01f, 3.22416462e-02f, -1.23522403e-02f, 2.37777144e-01f, -1.76739320e-01f, 2.37342268e-01f, 3.67025845e-02f,
  8.25699940e-02f, 4.23761271e-02f, -1.43260837e-01f, 3.97890210e-01f, -6.75395951e-02f, 2.47522488e-01f, -1.26403973e-01f, -4.82222378e-01f, 1.66858926e-01f, -9.63792503e-02f,
  7.12065324e-02f, 2.92653382e-01f, 5.54998159e-01f, -2.71164216e-02f, 3.38141978e-01f, 2.08999693e-01f, 3.66307884e-01f, 3.01832110e-02f, 2.23201171e-01f, -2.36228377e-01f,
  -3.15242767e-01f, -3.12891632e-01f, -2.75575370e-01f, 7.83637017e-02f, -4.99511987e-01f, 1.04640573e-01f, -8.66818577e-02f, -8.50506499e-02f, 2.73853451e-01f, -3.39713573e-01f,
  -1.68317571e-01f, -1.69140473e-01f, -2.32376292e-01f, 2.67261356e-01f, 3.62486094e-02f, -1.96378693e-01f, -1.52938917e-01f, 2.42366061e-01f, -1.76433064e-02f, -6.29827857e-01f,
  2.46474743e-02f, -2.42489465e-02f, -2.53166497e-01f, 4.84712094e-01f, 4.63505208e-01f, 1.01870462e-01f, -2.97842294e-01f, -1.24292344e-01f, 1.76226839e-01f, 9.56336111e-02f,
  6.57263920e-02f, 4.39212859e-01f, 1.41991198e-01f, -2.86267787e-01f, 7.75313824e-02f, 2.82905489e-01f, -1.95877030e-01f, 6.04211688e-02f, 4.29511756e-01f, 3.67569894e-01f,
  -2.03043848e-01f, 1.76367626e-01f, 1.86214700e-01f, -2.57245272e-01f, -8.65207389e-02f, -1.73828945e-01f, -1.39278444e-02f, -1.60448894e-01f, -1.21992491e-01f, -4.87716645e-02f,
  4.47329551e-01f, -9.13960636e-02f, 5.78838110e-01f, -2.31658621e-03f, -7.78315216e-02f, -1.25458226e-01f, 3.48981082e-01f, -2.21544951e-01f, 2.80431122e-01f, 1.18021607e-01f,
  -1.58298030e-01f, -1.90701857e-01f, -4.96300347e-02f, 2.92487383e-01f, 6.30253404e-02f, 9.77782160e-02f, 3.38704228e-01f, -2.47342005e-01f, 5.02081156e-01f, -1.18650168e-01f,
  2.92944223e-01f, -2.49390118e-03f, -8.12978745e-02f, 2.78766584e-02f, -3.57075214e-01f, -2.08719701e-01f, 4.84897107e-01f, -3.08175802e-01f, -1.21305317e-01f, 8.23780242e-03f,
  -2.52219681e-02f, 6.74911588e-02f, -1.33476704e-01f, -6.83416873e-02f, -2.33066410e-01f, -2.11714417e-01f, 9.88280922e-02f, 7.06542954e-02f, -2.42525607e-01f, -1.74962223e-01f,
  -3.09866995e-01f, -1.66752368e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  3.19486521e-02f, 4.27866697e-01f, 1.35700762e-01f, 2.04472944e-01f, 1.84529632e-01f, 1.23847816e-02f, 7.28338137e-02f, 3.98566961e-01f, 1.70812950e-01f, -9.86739621e-02f,
  2.11461499e-01f, 1.07170574e-01f, -2.63251625e-02f, 9.63805020e-02f, 8.52956157e-03f, 7.40322918e-02f, 1.20608136e-02f, 1.09960334e-02f, 3.21945734e-02f, 2.10422426e-01f,
  1.97888806e-01f, 1.15830645e-01f, 2.35121742e-01f, 3.58068943e-01f, 3.02581549e-01f, -5.72838336e-02f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.11485489e-01f, -2.64233351e-01f, -6.00905493e-02f, 3.83614659e-01f, -2.41644848e-02f, 8.83763656e-03f, 2.38200784e-01f, -1.76478773e-02f, 1.95206523e-01f, -1.45322591e-01f,
  1.84811607e-01f, 1.03927009e-01f, 5.12599386e-02f, 4.29444462e-02f, 1.64580882e-01f, 1.08712211e-01f, 1.16904944e-01f, -2.99785107e-01f, -9.10432339e-02f, -2.13649467e-01f,
  -2.40076587e-01f, 7.32521266e-02f, -1.68550119e-01f, 3.37011904e-01f, -1.23700924e-01f, -2.04525441e-01f, -1.40472069e-01f, -1.32313102e-01f, 1.64622247e-01f, -2.26681888e-01f,
  -2.52445430e-01f, -8.98844153e-02f, 6.09838553e-02f, 1.10390419e-02f, 7.17362240e-02f, 2.11582795e-01f, 1.30040184e-01f, 1.16091371e-01f, -1.55362263e-01f, 1.55336693e-01f,
  1.74590424e-01f, -5.15750311e-02f, 1.25599340e-01f, 1.57258287e-01f, 1.40637457e-01f, 4.65428904e-02f, 2.28872538e-01f, -2.00476468e-01f, 1.96435213e-01f, -2.09502310e-01f,
  1.89196780e-01f, -2.00001240e-01f, -1.02204740e-01f, 9.87614505e-03f, 5.89067638e-02f, 1.00918405e-01f, -2.08702460e-02f, 2.11953446e-02f, -1.83544546e-01f, -1.63779914e-01f,
  -9.17071998e-02f, -1.64277062e-01f, 3.66531432e-01f, 2.70985723e-01f, -1.25150084e-01f, -4.29336190e-01f, 1.29567921e-01f, -1.38344347e-01f, -3.62778567e-02f, -7.84597173e-02f,
  1.86549157e-01f, -2.67061919e-01f, 1.25209272e-01f, 7.96385184e-02f, -7.50171095e-02f, 2.93324962e-02f, -8.85320306e-02f, 1.24195457e-01f, 2.92796135e-01f, -6.11745194e-02f,
  1.32636130e-01f, -1.94557235e-01f, 1.65593013e-01f, 5.84033430e-02f, -1.98776841e-01f, -2.71959275e-01f, 1.81049645e-01f, -1.46190986e-01f, 5.71299717e-02f, 1.31477892e-01f,
  -7.59665594e-02f, -1.65565148e-01f, -2.86726773e-01f, -6.14369549e-02f, 1.71658937e-02f, 2.18236744e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.05117875e-01f, -2.75701910e-01f, -8.06060135e-02f, -1.09966293e-01f, 1.43888786e-01f, -2.54722238e-01f, -8.44587863e-04f, 2.06072643e-01f, 1.23434380e-01f, -2.71002859e-01f,
  -1.58480108e-01f, 3.33774775e-01f, 3.39316696e-01f, 9.60951671e-02f, -5.72362602e-01f, -1.29327923e-01f, 3.20950262e-02f, 3.73042077e-01f, -3.08370888e-02f, -2.19914287e-01f,
  2.41132423e-01f, 1.48442462e-01f, 4.13375467e-01f, 1.81105509e-01f, 3.97801667e-01f, 1.06520042e-01f, -3.06725919e-01f, -1.12154007e-01f, 1.49294615e-01f, 2.30698779e-01f,
  -1.72848806e-01f, 2.93975323e-01f, 3.62448022e-02f, -8.06319118e-01f, -2.12945834e-01f, -1.39500663e-01f, 1.20897964e-01f, 2.05040351e-01f, 1.71490148e-01f, -3.64482254e-01f,
  -5.65258935e-02f, -3.49509008e-02f, -1.95244610e-01f, -1.28277158e-02f, 9.90413353e-02f, 2.57307966e-03f, 2.57113874e-01f, -4.22454551e-02f, 1.40958443e-01f, -3.76600295e-01f,
  2.35697657e-01f, -1.38524070e-01f, 1.22580804e-01f, 2.24362873e-02f, -2.75322914e-01f, 3.90300639e-02f, 1.58620626e-01f, -3.96735892e-02f, 1.05778389e-01f, -2.71616899e-03f,
  6.40208647e-02f, -1.15242321e-02f, 7.76731744e-02f, 5.27478874e-01f, -4.19943780e-01f, -3.00574958e-01f, 2.54613161e-01f, -3.95819336e-01f, 3.13061476e-01f, 2.95135111e-01f,
  5.16668975e-01f, -1.10778876e-01f, 2.94739753e-01f, -3.47736552e-02f, -3.66013169e-01f, -9.95698720e-02f, 3.00464123e-01f, -1.34468377e-01f, 3.58234107e-01f, -3.74407411e-01f,
  3.33140016e-01f, 5.43626368e-01f, -1.29845589e-01f, 2.20620334e-02f, 1.60423115e-01f, -8.69765505e-02f, 2.09539667e-01f, 1.01007305e-01f, -1.07020782e-02f, 1.99346691e-01f,
  -1.25785917e-01f, -1.51655078e-02f, -1.46459311e-01f, 5.16397431e-02f, -1.01940602e-01f, -3.33879173e-01f, -2.02688396e-01f, -7.29847029e-02f, 2.71029383e-01f, 1.94285154e-01f,
  2.86356568e-01f, -6.20421953e-02f, 1.52410999e-01f, -2.81771809e-01f, -1.54399395e-01f, -1.58748999e-01f, 1.87340081e-01f, 5.33781052e-01f, -4.26138014e-01f, 3.75209078e-02f,
  -1.08098209e-01f, -1.62446007e-01f, 3.56690943e-01f, -1.72376901e-01f, -3.87885839e-01f, 4.38945919e-01f, 4.50245172e-01f, 3.82825434e-01f, 2.93046683e-01f, 1.58423737e-01f,
  1.23569384e-01f, -4.47401404e-02f, 5.90335205e-02f, 1.49755906e-02f, 2.54107952e-01f, 2.62071669e-01f, -5.16698845e-02f, -1.87172323e-01f, -4.41301674e-01f, -7.57785499e-01f,
  -3.99671197e-01f, -2.73532271e-01f, -2.50703227e-02f, 4.02710177e-02f, 9.59240720e-02f, -3.35655630e-01f, 1.87724218e-01f, 6.86260592e-03f, -3.01890820e-01f, -2.43253797e-01f,
  2.92629421e-01f, -9.14738849e-02f, 9.69834030e-02f, -1.85836628e-02f, 4.19042930e-02f, 2.19071597e-01f, 2.47543171e-01f, -1.63360015e-01f, -1.24940678e-01f, 1.58232093e-01f,
  -2.09602371e-01f, -9.67345163e-02f, 3.96209443e-03f, 4.15532338e-03f, 1.27916029e-02f, 2.70241708e-01f, 9.58228782e-02f, 4.83285673e-02f, -6.47279248e-02f, 3.15365463e-01f,
  4.47682083e-01f, 1.11575849e-01f, -1.69912025e-01f, -5.30087769e-01f, -3.41388613e-01f, -3.93194705e-01f, 3.61570239e-01f, 2.38127828e-01f, 1.48983136e-01f, 1.97588652e-01f,
  -1.09113276e-01f, 2.63994843e-01f, -2.57789224e-01f, 4.49391812e-01f, -3.70244145e-01f, -1.96116790e-03f, -7.14872107e-02f, -2.31529132e-01f, -1.83986738e-01f, 3.99908423e-01f,
  2.34851643e-01f, 1.48471236e-01f, 9.31519642e-02f, -1.33238390e-01f, -2.37113804e-01f, 1.16883956e-01f, 4.46615249e-01f, 3.52793336e-01f, 1.36319146e-01f, 3.05080771e-01f,
  -2.77174950e-01f, -4.41245437e-02f, -3.36001039e-01f, -3.59670401e-01f, -3.42772692e-01f, 7.15804994e-02f, 2.98202693e-01f, 1.85145363e-01f, 1.03053235e-01f, -6.18725568e-02f,
  1.93262771e-02f, -1.09098092e-01f, -3.24303985e-01f, -1.00330792e-01f, 4.35712576e-01f, -1.02001533e-01f, 3.46142679e-01f, 2.11420625e-01f, 4.97569621e-01f, 2.53245026e-01f,
  3.59127492e-01f, -1.39718667e-01f, -2.55191670e-04f, 1.77111566e-01f, 3.37061763e-01f, 2.94352025e-01f, 3.36282402e-01f, 5.11225224e-01f, -1.04617506e-01f, 2.42021963e-01f,
  2.74220873e-02f, -2.60917455e-01f, -5.41373575e-03f, -8.62616487e-03f, -3.45722109e-01f, -2.76792854e-01f, 3.28236818e-01f, 1.68709848e-02f, -6.31441325e-02f, 2.37944499e-02f,
  3.26058626e-01f, -4.17654932e-01f, 5.09484205e-03f, -1.52926266e-01f, 2.26932198e-01f, 3.81411463e-01f, 1.20004602e-01f, -3.28262091e-01f, -2.48376787e-01f, 1.62663743e-01f,
  -4.02524834e-03f, 1.39778540e-01f, -7.18614236e-02f, -1.14059977e-01f, -4.14193928e-01f, 2.84872912e-02f, -2.67092347e-01f, 1.38361752e-01f, -1.96772262e-01f, -4.67038155e-01f,
  -1.96027130e-01f, 1.73076302e-01f, 3.11912507e-01f, -2.25654274e-01f, 7.32189603e-03f, 1.20993175e-01f, 1.37372226e-01f, 5.67621291e-01f, 1.00403063e-01f, 5.78612328e-01f,
  -1.40114844e-01f, -1.08708672e-01f, -3.00795436e-01f, 6.66608572e-01f, 2.55019009e-01f, 4.07627583e-01f, 8.68144557e-02f, -6.52189925e-02f, 5.26508033e-01f, 2.67240435e-01f,
  -8.39359593e-03f, 2.66690642e-01f, -3.06465894e-01f, 3.03352594e-01f, 4.67645407e-01f, -2.73302346e-01f, -5.11615932e-01f, -5.40684760e-02f, -3.73038918e-01f, 3.30028296e-01f,
  3.82201165e-01f, -1.67229474e-01f, -2.54642606e-01f, -2.15873599e-01f, 1.29873725e-02f, -1.58795461e-01f, 3.83536369e-01f, -2.39141896e-01f, -3.15243155e-02f, 4.00408059e-01f,
  2.17894707e-02f, -6.74831718e-02f, -3.59947175e-01f, -1.57700464e-01f, 2.10391104e-01f, 5.38981080e-01f, 3.31779659e-01f, 2.69934833e-01f, 6.20205343e-01f, 4.75802809e-01f,
  -5.64353652e-02f, 7.64395535e-01f, -2.52790421e-01f, -9.73586738e-02f, -3.84447388e-02f, -2.77183235e-01f, -2.45707124e-01f, 2.79372662e-01f, 2.72219360e-01f, -3.03120583e-01f,
  -9.51311588e-02f, 2.70977706e-01f, -1.53322980e-01f, -1.25184715e-01f, 5.11970758e-01f, 5.81091195e-02f, -1.53727189e-01f, -5.90836592e-02f, 7.01723248e-02f, -4.72930342e-01f,
  1.01095065e-01f, 4.74816784e-02f, 2.65803039e-01f, 6.04591548e-01f, 3.73164088e-01f, 6.34917840e-02f, -1.02245808e-02f, 1.84775263e-01f, 3.44778150e-02f, -6.80162162e-02f,
  -7.47567639e-02f, 2.37773180e-01f, 2.31412798e-01f, -2.62257494e-02f, 2.39560664e-01f, 1.75845906e-01f, 2.35113159e-01f, 2.40404099e-01f, 3.37950766e-01f, -4.72962350e-01f,
  -1.02712803e-01f, 1.29078254e-01f, 2.82570064e-01f, 4.56020862e-01f, 4.25882012e-01f, 2.94111162e-01f, -1.87038362e-01f, -2.97427624e-02f, 1.15051776e-01f, 2.99232930e-01f,
  4.28589225e-01f, 3.45862746e-01f, 2.26974666e-01f, 4.33037132e-01f, -2.72999883e-01f, -1.94079086e-01f, 6.17212355e-01f, 4.17809844e-01f, -4.91649657e-02f, -2.36917436e-02f,
  1.73947319e-01f, 2.09829390e-01f, -3.41468006e-01f, -2.04625890e-01f, 1.93647042e-01f, -1.35878593e-01f, 4.55626190e-01f, 8.05448592e-02f, 4.03456569e-01f, 2.22986147e-01f,
  1.60541862e-01f, -1.92812666e-01f, 1.69599831e-01f, 1.23127237e-01f, 3.24833751e-01f, -9.27482247e-02f, 2.37890959e-01f, 4.55549061e-01f, -2.06115067e-01f, 1.69111088e-01f,
  -2.58909792e-01f, -3.22407812e-01f, 7.34663829e-02f, -6.99849129e-01f, -2.26222709e-01f, 4.45725769e-01f, 3.02992404e-01f, 1.74177498e-01f, 1.02688648e-01f, 1.28334001e-01f,
  1.96768373e-01f, -1.99783951e-01f, 8.88483599e-02f, 1.28706336e-01f, 2.83496201e-01f, -2.51993209e-01f, -1.19245492e-01f, -4.72478867e-01f, 7.82573938e-01f, 1.14546433e-01f,
  2.64266580e-01f, 3.14332217e-01f, 5.10000527e-01f, -2.60552078e-01f, -2.50632226e-01f, 9.99702234e-03f, -2.75471777e-01f, -2.77615368e-01f, -3.45077030e-02f, -1.05909534e-01f,
  -5.99830151e-02f, 2.52334058e-01f, 2.27623597e-01f, 3.05777222e-01f, 2.30583608e-01f, 3.20719332e-01f, 4.67128634e-01f, 4.04116660e-01f, 3.12093850e-02f, 2.63753124e-02f,
  6.24400973e-01f, -2.43644919e-02f, -1.11750200e-01f, 3.47773582e-01f, -1.18585929e-01f, -6.61525801e-02f, -2.60654688e-01f, -6.04385845e-02f, -2.73189604e-01f, -8.87527317e-02f,
  1.12249210e-01f, -4.10741707e-03f, 5.76158129e-02f, 2.97786645e-03f, 1.34072959e-01f, -2.04167496e-02f, 3.38640958e-01f, 3.85823101e-01f, 7.21118987e-01f, -1.73908874e-01f,
  2.84342259e-01f, 6.56306505e-01f, -1.06756978e-01f, 1.37836069e-01f, 1.49807096e-01f, 1.36770353e-01f, 1.78692490e-01f, -8.48581940e-02f, -2.82786936e-01f, -1.98776901e-01f,
  -1.79860324e-01f, -9.80586782e-02f, -1.08429082e-01f, 6.09736629e-02f, 3.57478470e-01f, -1.94245204e-01f, 1.54554814e-01f, 2.05000252e-01f, -8.43851790e-02f, 4.04233068e-01f,
  2.19971955e-01f, 1.71036318e-01f, -2.88846076e-01f, 2.32993975e-01f, 1.82101309e-01f, 6.80588186e-02f, 2.39521891e-01f, -6.17111288e-02f, -1.42645746e-01f, 8.36411715e-02f,
  1.06031355e-02f, 5.50254047e-01f, 1.04948193e-01f, -2.20595106e-01f, -1.27745047e-01f, -1.60043284e-01f, -9.23347473e-02f, -2.19063625e-01f, 8.20173845e-02f, -2.07350478e-01f,
  -1.44415811e-01f, -3.39069426e-01f, -1.95560515e-01f, -1.86661437e-01f, -3.66612315e-01f, -9.91258770e-02f, 1.13939427e-01f, 1.41502842e-01f, -4.05321538e-01f, -1.72547787e-01f,
  -9.74828824e-02f, -2.81157166e-01f, 1.38669685e-01f, -4.93322670e-01f, 7.34319165e-03f, 1.43976510e-01f, -2.98031896e-01f, 1.49231434e-01f, 2.03185175e-02f, 1.88093752e-01f,
  -1.08459927e-01f, 1.51769415e-01f, 2.75143590e-02f, -3.75336856e-01f, -8.31617713e-02f, 1.28422186e-01f, -2.94469595e-01f, 2.00485531e-02f, 2.01324239e-01f, 2.79170811e-01f,
  -6.40973821e-02f, -1.72962695e-01f, -4.35375333e-01f, -9.87145454e-02f, -3.90800744e-01f, -4.24245387e-01f, -1.23596355e-01f, -4.11270894e-02f, 1.22532127e-02f, -2.25906894e-01f,
  -1.12656087e-01f, -9.42467060e-03f, 8.65311176e-03f, -3.64812225e-01f, 7.41316378e-02f, -2.23882541e-01f, -3.06925327e-01f, 4.13161993e-01f, -2.15185925e-01f, 1.14346161e-01f,
  -3.59900624e-01f, 3.66905332e-01f, -2.95567036e-01f, 8.24893937e-02f, -6.52881563e-02f, -1.20193623e-01f, 1.15676738e-01f, -3.87946427e-01f, -2.60661513e-01f, 1.78615123e-01f,
  3.34432632e-01f, -1.60426527e-01f, -1.86074048e-01f, -3.58989313e-02f, -4.64594275e-01f, 4.75155339e-02f, -3.19536068e-02f, -4.92545515e-01f, -2.52903372e-01f, -3.61488312e-01f,
  4.90986556e-01f, -6.06649935e-01f, 5.29420614e-01f, 3.02790195e-01f, -2.53291696e-01f, 1.55162513e-01f, 4.97724339e-02f, 1.03557594e-01f, 3.62160295e-01f, -2.92571753e-01f,
  6.00040436e-01f, -1.08746134e-01f, 2.69495487e-01f, 1.69281483e-01f, 2.33088478e-01f, 4.80559729e-02f, 8.35191365e-03f, 1.92872420e-01f, 4.28234003e-02f, 1.85708821e-01f,
  3.91704261e-01f, -1.47253930e-04f, -2.20842108e-01f, -4.81574535e-01f, -2.72084057e-01f, 3.11166734e-01f, -3.77533853e-01f, -1.01277575e-01f, 3.19156408e-01f, 1.75693974e-01f,
  2.51372159e-01f, 1.22111738e-01f, 3.82949829e-01f, -2.82538563e-01f, -2.08340749e-01f, -5.50829100e-05f, 3.31372142e-01f, 5.83237000e-02f, 6.28463626e-02f, 3.11462139e-03f,
  -4.51961197e-02f, -2.23754331e-01f, -2.52574205e-01f, 1.16180122e-01f, -4.09755290e-01f, 2.20780075e-01f, 2.64888108e-01f, 1.08748078e-01f, 4.26251367e-02f, -2.73192614e-01f,
  -5.57047606e-01f, 7.43282065e-02f, 1.24493212e-01f, 2.51357317e-01f, 2.22053409e-01f, 5.16303778e-01f, 3.17288972e-02f, 8.86633545e-02f, 2.77151793e-01f, -2.17271283e-01f,
  7.79804215e-02f, 3.68164510e-01f, -2.02649996e-01f, 4.27312553e-01f, -9.41079333e-02f, -4.37899590e-01f, 1.13926735e-02f, -8.82077143e-02f, 5.53891599e-01f, 4.86937255e-01f,
  1.27340287e-01f, -5.26615977e-02f, 4.55253338e-03f, 2.21302658e-01f, 2.91066647e-01f, -7.48068690e-02f, 1.94284588e-01f, 3.91699448e-02f, 9.50063765e-02f, 2.67483085e-01f,
  -3.01486313e-01f, 2.28883713e-01f, 3.86987738e-02f, -4.77663010e-01f, 5.70000224e-02f, 2.38845557e-01f, 2.66845286e-01f, 1.13460727e-01f, 2.84377337e-01f, 4.12447602e-01f,
  1.97197989e-01f, -8.07157904e-02f, -1.98278259e-02f, 3.15843791e-01f, -3.73166084e-01f, 2.84325540e-01f, 8.20569620e-02f, -7.73897618e-02f, 8.68004560e-02f, 2.31627867e-01f,
  3.87759447e-01f, 3.91860902e-01f, 1.16555221e-01f, 2.60069966e-01f, -3.95445451e-02f, 1.82176009e-01f, 1.70977026e-01f, -2.66677916e-01f, 1.69052114e-03f, 2.24156275e-01f,
  -4.26516645e-02f, 2.53642857e-01f, -3.72096300e-01f, 4.06374693e-01f, 3.14346880e-01f, -4.58559543e-01f, 2.08594710e-01f, 3.90865020e-02f, 3.41655284e-01f, -1.83471933e-01f,
  4.44957912e-01f, -1.63585395e-01f, -2.94956528e-02f, 4.89978969e-01f, 3.49837720e-01f, -1.31196946e-01f, -5.46627045e-01f, -7.34839916e-01f, 1.30225480e-01f, 4.68961149e-01f,
  2.21091926e-01f, 5.69036491e-02f, 1.61378771e-01f, -1.24437265e-01f, 1.22523233e-01f, 5.42437956e-02f, -3.97127807e-01f, 1.04298219e-01f, -4.23036337e-01f, 2.62659401e-01f,
  -6.07241271e-03f, 1.82240028e-02f, 6.70087188e-02f, -1.19015001e-01f, 1.64834440e-01f, -1.51562423e-01f, -1.80110335e-01f, 2.26900019e-02f, 1.97304979e-01f, 9.05495286e-02f,
  1.88507587e-01f, 4.13808823e-01f, -1.87106594e-01f, 2.17638209e-01f, 2.89904624e-01f, 4.68582302e-01f, 2.02117458e-01f, -4.68387194e-02f, 1.13482423e-01f, -1.83278933e-01f,
  8.61331448e-02f, 6.18910909e-01f, -1.89452209e-02f, 3.05845439e-01f, 1.76407605e-01f, -3.63291979e-01f, -4.77971025e-02f, -2.29038417e-01f, 5.74685872e-01f, -1.17542215e-01f,
  -1.71069384e-01f, 2.91571498e-01f, 2.68893212e-01f, -2.21442450e-02f, -1.19705141e-01f, -1.53290510e-01f, -1.40386418e-01f, -2.81965196e-01f, -3.26415271e-01f, 4.55337726e-02f,
  2.33626571e-02f, 2.84886628e-01f, 6.24764413e-02f, 3.37852150e-01f, 4.27578062e-01f, -2.75961518e-01f, -2.80158252e-01f, 8.04177105e-01f, 2.04508558e-01f, 2.65718669e-01f,
  -4.27045859e-02f, -1.33948445e-01f, 2.23146603e-02f, 3.32891047e-01f, 2.73349434e-01f, 6.80401921e-02f, 3.02590907e-01f, 4.72864471e-02f, 5.72330244e-02f, 2.16155365e-01f,
  2.81726360e-01f, 1.35965168e-01f, -6.36803582e-02f, -6.31908700e-02f, -9.77694020e-02f, 3.29204142e-01f, 1.09137464e-02f, 2.17310712e-02f, 1.70806050e-01f, 4.22510833e-01f,
  -3.50000970e-02f, -3.90453450e-02f, -6.82455301e-02f, -1.00901470e-01f, -4.37075049e-02f, -3.24949890e-01f, -6.95092231e-03f, -6.35859907e-01f, 4.54319656e-01f, 4.21669185e-01f,
  1.81947634e-01f, -1.99914798e-01f, -4.44663644e-01f, -2.87400484e-01f, -2.15988122e-02f, 5.93874454e-01f, 2.68649608e-01f, 4.31375951e-01f, 1.15881093e-01f, 8.77821296e-02f,
  -1.65130813e-02f, 4.82241660e-01f, -4.00356740e-01f, -2.11152524e-01f, -3.36970001e-01f, 7.36398250e-02f, -2.58761525e-01f, 2.74661720e-01f, 2.17441589e-01f, 2.32769534e-01f,
  7.87728131e-02f, -2.26941686e-02f, -1.71781853e-01f, -6.26926199e-02f, 3.30169231e-01f, 1.10877678e-01f, 4.55052108e-02f, 4.47014719e-01f, -1.49084017e-01f, 1.20116845e-01f,
  2.43307978e-01f, -4.96628821e-01f, 2.95022782e-02f, 1.46229029e-01f, 1.95093542e-01f, 6.66267872e-01f, -9.87012461e-02f, -2.90043235e-01f, 1.87303975e-01f, 1.06382174e-02f,
  2.56189197e-01f, 1.76599979e-01f, -9.95518789e-02f, -3.27372640e-01f, 2.92862475e-01f, 2.74248838e-01f, 4.26435769e-01f, -8.37786719e-02f, 1.15160398e-01f, -1.92064941e-01f,
  2.21784666e-01f, 4.40740846e-02f, -2.82478720e-01f, 2.29252204e-01f, 3.37946236e-01f, -4.40142334e-01f, -3.31995226e-02f, 3.41767609e-01f, 2.03227952e-01f, -6.19250629e-03f,
  1.58995837e-01f, 4.87012476e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.01504393e-01f, -2.91328162e-01f, 2.59475350e-01f, 2.85184979e-01f, -1.95903569e-01f, 6.89827055e-02f, -9.19067487e-02f, -6.62580580e-02f, 2.15627924e-01f, 2.14264765e-01f,
  1.17701866e-01f, -9.55243707e-02f, 8.59421566e-02f, 2.73939610e-01f, -1.44257247e-01f, 9.16263834e-02f, -1.74299791e-01f, 5.26025482e-02f, 2.01642409e-01f, -6.70271441e-02f,
  -1.46333590e-01f, 1.98299557e-01f, 2.78188407e-01f, 2.23935142e-01f, 3.78669471e-01f, -1.64151654e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  -7.09022582e-02f, -1.93287984e-01f, -1.85716003e-01f, 1.00195312e+00f, 2.03250945e-01f, -2.42765009e-01f, -1.89498633e-01f, 4.72124517e-01f, 1.74144536e-01f, -4.15106177e-01f,
  2.63984501e-01f, 1.68179169e-01f, 4.54513635e-03f, -1.92807913e-02f, -3.33440185e-01f, 1.17942996e-01f, -1.65898055e-01f, 1.40276238e-01f, -1.77107364e-01f, -3.46688122e-01f,
  1.02885954e-01f, -7.32439041e-01f, 1.38356769e-02f, 1.67249277e-01f, -4.54718202e-01f, 1.69109844e-03f, 9.13371146e-02f, -2.34796420e-01f, -8.18097740e-02f, -3.49419951e-01f,
  1.48375751e-02f, 2.16132313e-01f, 1.34240612e-01f, -3.35151074e-03f, -2.99261510e-01f, 6.12487793e-01f, 2.03690186e-01f, 3.67855132e-01f, -1.68053642e-01f, 3.47449422e-01f,
  -1.31753609e-01f, -1.39271677e-01f, 2.50876844e-01f, -6.47482812e-01f, 8.61908421e-02f, 3.22724134e-01f, 1.81943662e-02f, -5.65250576e-01f, 1.71176806e-01f, -2.56358683e-01f,
  1.59554720e-01f, -3.61568183e-01f, 1.97856620e-01f, 6.07364438e-02f, 8.59638024e-03f, 2.27363318e-01f, 5.33633120e-02f, 2.61563361e-01f, 1.27582520e-01f, -1.27565190e-01f,
  -2.71117538e-01f, -2.10132405e-01f, -4.91351098e-01f, 2.97057509e-01f, -1.90346781e-02f, 1.35277867e-01f, -1.11600339e-01f, -3.65969747e-01f, -1.39431641e-01f, 1.77551657e-01f,
  -5.57523966e-01f, -1.20204560e-01f, 3.57951432e-01f, 1.68536723e-01f, 1.18390229e-02f, -2.94689238e-01f, 1.52685151e-01f, -1.08452253e-01f, -3.43081236e-01f, -4.73274857e-01f,
  1.46105643e-02f, 2.56354630e-01f, 3.22444081e-01f, 1.43603995e-01f, -1.17239170e-01f, -6.91754341e-01f, -1.04900924e-02f, 2.62303501e-01f, 1.49444818e-01f, -3.65761250e-01f,
  -3.80056173e-01f, -2.85951138e-01f, 2.30669498e-01f, 3.57185364e-01f, -4.68020141e-01f, -1.28846094e-01f, 5.40990867e-02f, -2.99549431e-01f, -1.42439485e-01f, 2.73217350e-01f,
  -3.21355790e-01f, 9.71144587e-02f, -9.19157386e-01f, -4.77106050e-02f, -1.34022608e-01f, 1.66003197e-01f, -2.28083566e-01f, 3.64319414e-01f, -6.77630305e-01f, -5.12614660e-02f,
  -4.29715455e-01f, 3.31515551e-01f, -5.84266663e-01f, -3.74497026e-01f, -3.39278281e-01f, -4.59859133e-01f, 6.92008659e-02f, -4.27924283e-02f, -1.05541892e-01f, 1.82464570e-01f,
  1.52239829e-01f, -1.38748765e-01f, 1.12060346e-01f, 8.12065303e-02f, -3.14728230e-01f, 9.77267995e-02f, 2.22733170e-01f, -3.67621869e-01f, 7.41772205e-02f, 3.78671557e-01f,
  2.59841949e-01f, -6.06244624e-01f, 3.24345797e-01f, 4.14045870e-01f, -1.14554748e-01f, -3.70480359e-01f, -1.55443579e-01f, -3.20816547e-01f, 6.07673712e-02f, 3.21650296e-01f,
  -7.44853020e-02f, 1.34517565e-01f, -1.79624751e-01f, 1.20153002e-01f, -1.89618036e-01f, -3.84550309e-03f, -1.88525856e-01f, 8.16324353e-02f, 1.72974542e-02f, 7.39118457e-02f,
  2.22002327e-01f, 2.23049402e-01f, -2.48763025e-01f, -2.47202411e-01f, -9.29005221e-02f, 3.64008695e-01f, -5.58678880e-02f, -1.04906065e-02f, 2.85148919e-01f, -3.56405318e-01f,
  -4.93546039e-01f, -7.63122737e-02f, 2.81259835e-01f, 4.04797345e-01f, -1.67276889e-01f, 4.64362055e-01f, -1.02949060e-01f, -5.38452268e-01f, -2.35186014e-02f, -3.05322826e-01f,
  -5.19187562e-02f, -3.81360590e-01f, -4.45725285e-02f, -1.39645979e-01f, 3.84898663e-01f, 2.42343679e-01f, 1.11637332e-01f, 1.55502360e-03f, -1.49375618e-01f, -3.53867054e-01f,
  2.55043685e-01f, 5.24842702e-02f, 5.76030873e-02f, -7.45806769e-02f, -3.54604758e-02f, -9.76056159e-02f, 1.07908651e-01f, -2.09483001e-02f, 1.04036201e-02f, 3.18321109e-01f,
  -1.48622170e-01f, -3.15824270e-01f, -3.58520508e-01f, -2.11630464e-01f, -2.60732323e-01f, -5.63349249e-03f, -2.70903319e-01f, 1.16640657e-01f, 3.20430435e-02f, -3.23930872e-04f,
  1.86815619e-01f, -1.05014083e-03f, 2.31811896e-01f, 4.48888801e-02f, -1.68360844e-02f, -3.09476674e-01f, -3.21238935e-01f, -7.21929550e-01f, 7.09405988e-02f, -2.39592299e-01f,
  4.46313024e-02f, 1.58650130e-01f, -4.27208006e-01f, 3.29247087e-01f, -4.33930576e-01f, -8.36682320e-01f, 3.70562255e-01f, -3.82480085e-01f, -6.39483869e-01f, 2.57965028e-01f,
  3.54896963e-01f, -6.83505714e-01f, 1.29120141e-01f, -4.85547215e-01f, 3.15154046e-01f, 3.30107659e-02f, -3.68356645e-01f, 6.71820045e-02f, -9.09876972e-02f, -3.08118671e-01f,
  -1.68264896e-01f, 1.05333708e-01f, -5.84174335e-01f, 3.22756737e-01f, -5.99745028e-02f, 7.93003067e-02f, -4.51189429e-02f, -1.53863043e-01f, -4.15557474e-01f, 2.27628231e-01f,
  2.51599289e-02f, -2.68835276e-01f, -4.45699334e-01f, 2.48430252e-01f, -8.45404267e-02f, 6.31064316e-03f, 5.60548045e-02f, -2.80673712e-01f, -3.75745222e-02f, 2.75001973e-01f,
  2.57923394e-01f, -4.27649200e-01f, -5.94566703e-01f, 5.62117901e-03f, 1.52903488e-02f, 1.98979959e-01f, 1.00873530e-01f, -3.47443530e-03f, 3.13563317e-01f, -7.60768771e-01f,
  7.19586968e-01f, -4.65944558e-01f, -4.58515495e-01f, -2.40247652e-01f, -7.17192352e-01f, -4.50151473e-01f, -2.70939921e-03f, -3.15336466e-01f, 1.04285583e-01f, -3.48239720e-01f,
  2.92585790e-01f, -5.86502969e-01f, 2.36068487e-01f, 3.94357175e-01f, 2.43169710e-01f, 2.95768768e-01f, -1.27679616e-01f, -1.11664340e-01f, -3.12794089e-01f, -7.66061664e-01f,
  -4.32984889e-01f, 1.41925290e-01f, 7.18949959e-02f, -4.89209443e-01f, 2.98333079e-01f, -1.43673360e-01f, -3.96082431e-01f, 2.78876334e-01f, -4.26173359e-02f, 5.09701133e-01f,
  9.55526680e-02f, -6.86909497e-01f, -1.36875674e-01f, -7.33340502e-01f, 3.06121230e-01f, -3.70389104e-01f, 1.55784190e-01f, 3.15560877e-01f, -1.47559866e-01f, -6.78051040e-02f,
  9.10278559e-02f, -4.68604155e-02f, -1.11410074e-01f, -4.26929712e-01f, 3.08983982e-01f, 2.07208037e-01f, -4.30831432e-01f, 3.00761938e-01f, 3.38533707e-02f, -4.93974000e-01f,
  -7.59562552e-01f, -2.51598746e-01f, 1.73117407e-02f, -2.57179677e-01f, -4.56978798e-01f, 1.52876843e-02f, -4.47292626e-01f, -1.38968349e-01f, 2.43949890e-02f, -2.46577203e-01f,
  4.53831226e-01f, -1.81805477e-01f, 3.22015673e-01f, 7.46170953e-02f, 4.94268298e-01f, -2.55568594e-01f, -4.78160203e-01f, 2.80630738e-02f, -6.42500818e-01f, -6.42046213e-01f,
  -3.93812567e-01f, 4.10885252e-02f, -9.08158362e-01f, -2.00648710e-01f, 4.67373073e-01f, 4.67015952e-01f, -1.10376887e-02f, -7.55038917e-01f, -7.05992997e-01f, -4.23710436e-01f,
  -9.19271559e-02f, -9.24689472e-02f, -2.38873921e-02f, -3.34226698e-01f, -7.18849599e-01f, -2.17409834e-01f, 2.07403764e-01f, 2.59677738e-01f, 2.96426505e-01f, 8.91864970e-02f,
  4.51127052e-01f, -3.36631805e-01f, 3.02441359e-01f, 3.28001380e-01f, -2.07925424e-01f, -2.81046391e-01f, -5.00149906e-01f, -2.08687261e-01f, -3.15428942e-01f, -1.90780871e-02f,
  -2.76462734e-01f, 5.92235997e-02f, -3.36672425e-01f, 8.36573020e-02f, -6.14773989e-01f, -1.69466510e-01f, -1.38258025e-01f, 1.65079534e-01f, -1.90184340e-02f, -5.33360064e-01f,
  3.06266963e-01f, -1.57780340e-03f, -6.74460590e-01f, -2.63594657e-01f, -6.98591769e-01f, -2.99883425e-01f, 2.69622892e-01f, 2.32565552e-01f, 3.62448976e-03f, 2.71574914e-01f,
  4.31611270e-01f, -5.17954677e-02f, 2.87295043e-01f, 1.20077766e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -1.74282938e-01f, 1.97265074e-02f, -2.77086161e-02f, 1.08597271e-01f, -2.26654094e-02f, -1.04750946e-01f, 1.49683535e-01f, -2.09166174e-04f, -2.87722722e-02f, 3.03527802e-01f,
  1.81183010e-01f, -3.88571583e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    