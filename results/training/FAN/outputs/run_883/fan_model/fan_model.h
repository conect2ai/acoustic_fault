/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 19 x 120)
const int L0_fan_Wp_rows = 19;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.05410764e-01f, -1.14580035e-01f, -5.36663942e-02f, -1.22145452e-01f, 9.00560692e-02f, 3.07429701e-01f, 2.40857020e-01f, 9.74110886e-02f, -1.59581602e-02f, -1.07767746e-01f,
  -1.31049991e-01f, -1.09836506e-02f, -4.96591330e-02f, 1.43253263e-02f, 4.05905545e-02f, -2.10081507e-02f, -4.34974171e-02f, 3.92660014e-02f, 1.31320938e-01f, 1.84175730e-01f,
  -1.12764508e-01f, -1.37635812e-01f, -1.25424549e-01f, -8.83809701e-02f, -6.00299798e-02f, -4.28822525e-02f, -7.17139617e-02f, -3.31857018e-02f, 3.73510681e-02f, -3.34811270e-01f,
  9.46104433e-03f, -8.99214372e-02f, 7.55284578e-02f, 1.94901545e-02f, 6.53987750e-02f, 3.09422496e-03f, -1.88489463e-02f, -1.03692785e-01f, 1.73949841e-02f, 5.91434091e-02f,
  -2.66477093e-02f, -1.03177525e-01f, -9.95554216e-03f, -1.86022315e-02f, 6.35707378e-02f, 5.01796044e-02f, -1.80701986e-02f, -6.12406805e-02f, -2.76821591e-02f, 2.06162836e-02f,
  -1.30363271e-01f, -8.57441574e-02f, 1.01219334e-01f, 1.22208923e-01f, 5.02751172e-02f, -5.04671074e-02f, 1.19859047e-01f, 6.15618154e-02f, 1.81799144e-01f, -5.62248453e-02f,
  -3.08361426e-02f, -1.15249269e-02f, -2.20580250e-02f, 2.94488128e-02f, -1.92623213e-02f, 7.67343072e-03f, -3.98427397e-02f, 8.87547508e-02f, -1.22750131e-03f, 2.65988074e-02f,
  4.34906600e-04f, 8.97076540e-03f, -7.74703827e-03f, 1.77217845e-03f, -3.59756732e-03f, -4.78178933e-02f, 2.64029000e-02f, -2.23954138e-03f, -1.08450251e-02f, -2.11451072e-02f,
  1.18267955e-02f, 1.49703268e-02f, 4.82029887e-03f, -3.07540987e-02f, -3.18179354e-02f, 2.94390935e-02f, -4.95063849e-02f, -1.97007898e-02f, -1.47732475e-03f, 3.66714485e-02f,
  7.17764348e-02f, 7.15980455e-02f, -1.79175176e-02f, -1.14655867e-02f, -3.98364589e-02f, -8.03044706e-04f, -4.22692820e-02f, 6.41874075e-02f, -1.17122695e-01f, -8.12456310e-02f,
  8.21249634e-02f, -5.73880784e-02f, -4.16035727e-02f, 3.76139209e-02f, 8.82959813e-02f, 5.96133024e-02f, -2.23350115e-02f, 6.77486062e-02f, 3.53479199e-02f, -2.73501612e-02f,
  -6.11668490e-02f, 9.55769569e-02f, 9.75006893e-02f, 4.17812727e-02f, 2.80518923e-02f, 1.36316195e-02f, 1.97796926e-01f, 8.31840932e-02f, 1.37201965e-01f, 2.58968532e-01f,
  -1.49908766e-01f, 2.56334901e-01f, -4.20938042e-04f, -6.35316223e-02f, 1.19491335e-04f, 4.07343805e-02f, 4.48185951e-02f, 6.69694021e-02f, -9.97767076e-02f, 5.88647388e-02f,
  1.59309670e-01f, 4.48501036e-02f, 7.46334568e-02f, -8.29375759e-02f, -1.04362257e-01f, -4.94815118e-04f, 2.26401296e-02f, -1.23195477e-01f, -1.21696472e-01f, 3.43749858e-02f,
  9.30518564e-03f, 7.00257346e-03f, -1.27708197e-01f, -1.29526230e-02f, -4.02717963e-02f, -9.51951370e-02f, 1.55306039e-02f, 6.81716576e-02f, 1.80538774e-01f, 1.57900695e-02f,
  -7.38538727e-02f, 1.95433438e-01f, -1.62238598e-01f, 2.53802650e-02f, 9.56214815e-02f, -1.19390830e-01f, 6.75632991e-03f, -2.19696611e-02f, 9.83851254e-02f, 4.68685385e-03f,
  5.10029905e-02f, 3.00026108e-02f, 8.11663643e-02f, 3.30498442e-02f, 6.01909086e-02f, 1.38083268e-02f, -7.50152161e-03f, -9.96647030e-02f, 5.31123914e-02f, -1.16800750e-02f,
  7.78380930e-02f, 2.62861736e-02f, -7.50291124e-02f, 1.25625702e-02f, -2.86669321e-02f, -7.05961362e-02f, 9.05330554e-02f, 3.87432501e-02f, -8.62430036e-03f, -1.01406083e-01f,
  -2.25625895e-02f, -2.94282543e-03f, -8.07816684e-02f, -4.44775932e-02f, -1.07799852e-02f, -2.94625442e-02f, -6.06565140e-02f, 3.33171375e-02f, 3.95129658e-02f, 1.61488038e-02f,
  -1.03666373e-02f, -7.20593259e-02f, 4.43528369e-02f, -6.49461523e-02f, 2.55792122e-02f, -5.18930517e-02f, 5.87178208e-02f, -3.36102135e-02f, 4.97092418e-02f, 6.88689873e-02f,
  -6.37961924e-02f, -3.13013159e-02f, 5.81330582e-02f, -6.64178878e-02f, 1.76556017e-02f, -2.33916696e-02f, -3.49506028e-02f, 3.24609242e-02f, -7.30059866e-04f, -5.41915223e-02f,
  -3.92919257e-02f, 7.41752312e-02f, 1.46693541e-02f, 1.87151041e-02f, 4.33728704e-03f, -2.42481264e-03f, 7.38945827e-02f, -8.92763510e-02f, 8.82601663e-02f, -5.06306738e-02f,
  1.11639434e-02f, -8.75534341e-02f, 1.05179809e-01f, -7.12619871e-02f, -1.56599749e-02f, -3.72841507e-02f, -3.85494120e-02f, -8.98499936e-02f, -1.31823057e-02f, -4.89426851e-02f,
  -3.98886837e-02f, -1.16976894e-01f, -2.37553209e-01f, -7.21644312e-02f, -9.68478099e-02f, -9.06545073e-02f, -1.04477247e-02f, -1.29453361e-01f, -1.67339131e-01f, -1.57417074e-01f,
  -6.00342512e-01f, -1.92674682e-01f, -4.91368808e-02f, -1.76342968e-02f, 1.87000278e-02f, -8.53822473e-03f, -1.37772607e-02f, -7.67282322e-02f, 1.21172834e-02f, -1.72139648e-02f,
  1.06029131e-01f, 1.96675852e-01f, 5.03828675e-02f, 7.23964274e-02f, 7.86479264e-02f, -2.74556060e-03f, 3.72431241e-02f, -2.80441158e-02f, 7.85218738e-03f, 5.43960519e-02f,
  1.23050407e-01f, -1.24345876e-01f, -1.68502867e-01f, 3.12223323e-02f, -5.24113178e-02f, 4.13158312e-02f, 3.98822092e-02f, -1.59345120e-02f, -4.16571051e-02f, -1.04869448e-01f,
  -1.48917377e-01f, -2.12323219e-01f, 2.10410193e-01f, 1.08180791e-01f, -5.65924533e-02f, -8.86686668e-02f, 1.55404732e-02f, -1.03606686e-01f, 3.24522890e-03f, -6.27774671e-02f,
  -2.78698113e-02f, -2.98707429e-02f, 5.14789149e-02f, -3.80218774e-02f, -1.26337081e-01f, 3.40092853e-02f, -4.46358174e-02f, -1.59543455e-02f, 1.09938584e-01f, 5.48301078e-02f,
  7.34936297e-02f, -1.12843230e-01f, -7.69418329e-02f, 5.27972691e-02f, 6.18768074e-02f, 1.06216945e-01f, -5.14513813e-03f, -6.98911324e-02f, -1.05733182e-02f, -1.26766354e-01f,
  5.33748865e-02f, -3.35153118e-02f, 3.43878604e-02f, -1.90126859e-02f, -1.61990952e-02f, 2.85916310e-03f, 1.09316871e-01f, -1.07554801e-01f, 4.75352146e-02f, 2.10695527e-03f,
  2.75282934e-02f, -7.46338516e-02f, 9.13219228e-02f, -6.54556751e-02f, -9.68471356e-03f, 2.94546746e-02f, -1.57589633e-02f, 7.92909861e-02f, 1.02980956e-02f, -5.16025051e-02f,
  3.86918746e-02f, 1.00499220e-01f, -2.79644616e-02f, -1.03834802e-02f, 1.37683032e-02f, 3.35200392e-02f, -9.83637525e-04f, 3.39810015e-03f, -3.49065401e-02f, -3.97850908e-02f,
  -2.44383980e-02f, 2.43518457e-01f, 1.46661522e-02f, 5.99316582e-02f, -2.80790534e-02f, 5.99734066e-03f, 1.79863330e-02f, 7.35513121e-02f, 4.91925441e-02f, -1.77318044e-02f,
  -4.23332378e-02f, -7.30507746e-02f, -1.18791312e-02f, 2.82462537e-02f, 1.02994898e-02f, -7.25535676e-03f, -2.62158532e-02f, 2.26436704e-02f, 2.44883373e-02f, -2.89150532e-02f,
  3.73212472e-02f, -9.44424570e-02f, -1.71747655e-02f, -5.37548633e-03f, 8.88906941e-02f, 2.64225416e-02f, 3.48798446e-02f, -1.82901807e-02f, -5.70212491e-02f, -2.08908156e-01f,
  -4.80779380e-01f, 6.72573317e-03f, -1.78645492e-01f, -2.60938436e-01f, -3.34226310e-01f, -2.72449374e-01f, -1.78384364e-01f, 3.72453071e-02f, -3.24349711e-03f, -5.89442323e-04f,
  2.31200028e-02f, 1.12532690e-01f, -2.27281321e-02f, 4.10600565e-03f, 1.39603522e-02f, -2.31282748e-02f, -1.67762116e-01f, -1.46791920e-01f, -2.48528421e-01f, -2.53273427e-01f,
  -5.61968833e-02f, -2.53805667e-01f, -1.89549759e-01f, -5.72657920e-02f, -4.74147499e-02f, -1.70880519e-02f, -1.85732674e-02f, -1.06989294e-01f, -8.69666114e-02f, -9.06785652e-02f,
  -2.09796522e-02f, -2.24992082e-01f, -1.76077932e-02f, -5.61697148e-02f, -5.13078645e-02f, 4.48083738e-03f, -3.54366452e-02f, 8.25019777e-02f, 2.85064168e-02f, -2.61489046e-03f,
  -4.82280105e-02f, -4.97501083e-02f, -2.29367036e-02f, -4.47042510e-02f, -9.50049460e-02f, -4.80643995e-02f, 1.58568695e-02f, -8.29149336e-02f, 1.99496318e-02f, 7.45829269e-02f,
  -3.01366579e-02f, -8.57351348e-02f, -2.00644303e-02f, 1.21826462e-01f, 1.08620152e-01f, 1.90030737e-03f, 8.71239044e-03f, 3.62992436e-02f, 5.75049706e-02f, 7.38931447e-02f,
  3.13969366e-02f, 7.33132437e-02f, -3.81395146e-02f, -2.19406765e-02f, 3.24996375e-02f, 3.47185042e-03f, 4.41065542e-02f, -5.59067391e-02f, 4.28509014e-03f, 2.66963858e-02f,
  5.76759391e-02f, 3.55523154e-02f, 4.72017899e-02f, 6.48231804e-02f, -1.30930096e-02f, -3.36007699e-02f, 2.19882615e-02f, 2.72564422e-02f, 1.17630102e-02f, -1.37060760e-02f,
  -6.83743507e-02f, -1.74486116e-02f, 4.96793278e-02f, 6.25376925e-02f, -4.26887907e-02f, -2.44599748e-02f, -1.03662664e-03f, -1.66867319e-02f, 1.87145527e-02f, -3.06219030e-02f,
  1.88609362e-01f, -5.08256815e-02f, 1.17651615e-02f, -5.96209476e-03f, 6.32223040e-02f, 8.69762376e-02f, 8.16876888e-02f, 5.26400208e-02f, 1.45230629e-02f, 2.45263278e-02f,
  -3.42347510e-02f, 4.14023176e-02f, 7.78081119e-02f, 4.17063199e-02f, -7.50107393e-02f, -5.38655296e-02f, 4.10618745e-02f, -4.23742197e-02f, 5.17960377e-02f, 2.97963507e-02f,
  6.31972998e-02f, -2.70841345e-02f, 3.84430923e-02f, 2.02470124e-02f, 4.78824116e-02f, -7.63487071e-02f, 2.50458792e-02f, 3.87466438e-02f, 1.16987191e-02f, 7.88783208e-02f,
  -2.30289012e-01f, 1.41785190e-01f, 2.07094461e-01f, -2.19259948e-01f, -4.55586566e-03f, 7.06513971e-02f, 1.71200708e-01f, 2.17657387e-02f, -1.68644056e-01f, -2.78320219e-02f,
  -6.83494434e-02f, -1.33494228e-01f, -5.38069010e-02f, -8.66996683e-03f, 9.57682654e-02f, 1.33429468e-01f, 1.80160999e-01f, 1.15364216e-01f, 2.02804860e-02f, -1.03721939e-01f,
  -3.64983231e-02f, -7.10159764e-02f, -6.31420687e-02f, 4.58237194e-02f, -4.07246053e-02f, -1.93867192e-01f, -1.65162538e-03f, -3.13796252e-02f, 6.89134523e-02f, 3.32027189e-02f,
  -5.68788908e-02f, 1.99361771e-01f, -1.42512709e-01f, -1.06154449e-01f, 8.95959437e-02f, -5.39195677e-03f, -2.00172663e-02f, -1.46162957e-02f, 5.25640994e-02f, -3.62284221e-02f,
  4.12014648e-02f, -2.86066737e-02f, -4.56799343e-02f, 4.68271263e-02f, 2.21671145e-02f, -7.14277402e-02f, 1.19535133e-01f, 8.15468207e-02f, 2.93654315e-02f, 1.51016057e-01f,
  1.14766613e-01f, 1.07127532e-01f, 1.18082076e-01f, 1.34797588e-01f, 1.79866657e-01f, 7.92808656e-04f, 1.17468014e-01f, 5.48970811e-02f, 1.51453987e-01f, -1.42837226e-01f,
  -1.00758716e-01f, 4.33275700e-02f, 3.61702144e-02f, 5.16613796e-02f, -5.06579019e-02f, 2.38850829e-03f, 8.27435683e-03f, -4.39262902e-03f, -5.02240248e-02f, 3.58034000e-02f,
  2.89441105e-02f, 3.95837463e-02f, 7.93226901e-03f, -2.73931846e-02f, -2.90880501e-02f, 9.16002914e-02f, -3.63361575e-02f, 5.09992726e-02f, 3.50588001e-02f, 3.59944999e-02f,
  -1.94401387e-02f, 2.25096475e-02f, 1.57196540e-02f, 9.12873521e-02f, 8.31894800e-02f, 7.50841051e-02f, -1.14890840e-02f, 4.87509966e-02f, 8.16088915e-03f, 3.45615926e-03f,
  -3.60161364e-01f, 1.64521918e-01f, -1.90064132e-01f, 4.14816961e-02f, -7.32208490e-02f, 1.71757024e-02f, 1.22619281e-03f, 1.73964947e-02f, -5.54274134e-02f, -8.78611952e-03f,
  -3.47574688e-02f, -3.22411358e-02f, 6.29789233e-02f, -2.12023947e-02f, -1.12087227e-01f, -7.65165091e-02f, -2.08367556e-02f, -1.48195699e-01f, 5.83362728e-02f, -1.17294611e-02f,
  -4.05347571e-02f, -1.40503377e-01f, -2.35544562e-01f, -1.28550872e-01f, -2.64746160e-03f, -2.03932092e-01f, -6.24892041e-02f, -1.99364513e-01f, -1.03172205e-01f, -4.14063036e-01f,
  -2.03176931e-01f, 2.89720297e-01f, 2.68480927e-01f, -1.65750042e-01f, 1.25420997e-02f, -1.62382387e-02f, 1.34248808e-01f, 6.81549981e-02f, -3.03775631e-02f, 7.61831105e-02f,
  -9.76477489e-02f, -1.62154734e-01f, -6.42293915e-02f, 9.16603766e-03f, 8.25586822e-03f, 2.24258155e-01f, 2.39900500e-01f, 7.97490925e-02f, -2.24449381e-01f, -1.80656880e-01f,
  -1.52535141e-01f, 5.22375945e-03f, -6.02696538e-02f, -2.93238088e-02f, 1.12393275e-01f, -1.16889365e-01f, 2.12533236e-01f, 4.74169180e-02f, 1.10475726e-01f, 1.51613042e-01f,
  5.06348312e-02f, 1.32960752e-01f, -2.10184231e-02f, -4.98138554e-02f, 5.64266276e-03f, -1.09198792e-02f, -2.21847985e-02f, 6.83264881e-02f, -2.92888992e-02f, 1.13922961e-01f,
  3.75729799e-02f, 3.79244238e-02f, -2.55651455e-02f, -5.15672676e-02f, -6.49439916e-02f, 1.57348122e-02f, 1.34603456e-01f, 9.36159343e-02f, -3.16208489e-02f, -9.46482569e-02f,
  6.12427369e-02f, -1.48987621e-01f, -4.80888896e-02f, -6.54478520e-02f, -1.60027873e-02f, -8.13137554e-03f, -7.49680446e-03f, 5.98264188e-02f, 1.51187098e-02f, 7.00846240e-02f,
  -2.60362159e-02f, -1.12078404e-02f, 8.95296261e-02f, 1.11543015e-02f, -1.18783088e-02f, 5.79013303e-02f, 4.70305309e-02f, 2.68582646e-02f, -5.02693504e-02f, 4.51123975e-02f,
  -8.85228720e-03f, -5.97514920e-02f, -5.28170280e-02f, 7.38548785e-02f, -2.44022608e-02f, -6.96871951e-02f, 7.45132659e-03f, -2.05535050e-02f, 1.35189742e-02f, 1.83976423e-02f,
  -3.24552506e-02f, -7.67944232e-02f, -1.43096056e-02f, -4.02696915e-02f, 4.10223641e-02f, 8.76345709e-02f, -4.39473763e-02f, -6.73085973e-02f, -2.13263724e-02f, -1.14459926e-02f,
  -1.87142611e-01f, -1.41939418e-02f, -1.16743527e-01f, -4.94296663e-02f, -4.16796356e-02f, 1.40010314e-02f, -5.23769408e-02f, 4.87902425e-02f, 2.94586625e-02f, -3.67103219e-02f,
  2.23304126e-02f, 6.07145615e-02f, -2.41713859e-02f, 1.55061921e-02f, -4.65126671e-02f, 6.96299039e-03f, -3.09726596e-02f, -3.35460715e-02f, -8.73047486e-02f, -1.25284865e-02f,
  -7.36685246e-02f, -2.10276634e-01f, -2.81806439e-01f, 9.26376320e-03f, -7.31233731e-02f, -2.33913660e-01f, -9.14347544e-02f, -6.91389665e-02f, -6.12544715e-02f, -6.58743829e-02f,
  1.71930924e-01f, 4.23847623e-02f, -2.63204455e-01f, -5.35954498e-02f, 1.10783558e-02f, 1.98546611e-02f, 1.14273071e-01f, 1.42801046e-01f, 5.72133698e-02f, -4.96397950e-02f,
  -2.34192703e-03f, -2.93132942e-02f, -2.83264951e-03f, -6.39273599e-02f, -8.63668101e-04f, -3.97173641e-03f, -2.05037177e-01f, -1.64472193e-01f, -8.84089321e-02f, 7.55933151e-02f,
  -2.67699081e-02f, -1.11089885e-01f, 5.82649447e-02f, -1.19283780e-01f, -1.08451255e-01f, 2.94020530e-02f, -1.15200028e-01f, -8.76712725e-02f, -6.54429942e-02f, -1.33673161e-01f,
  -1.99260250e-01f, 7.06542656e-02f, -7.10458308e-02f, -3.70437242e-02f, -1.32231176e-01f, 6.75657988e-02f, 3.20753567e-02f, -8.10993686e-02f, 5.68549782e-02f, 3.97577472e-02f,
  -3.13189216e-02f, 4.99501489e-02f, -3.61517668e-02f, -3.29762697e-02f, -8.55789334e-02f, 9.05395113e-03f, 1.48866568e-02f, -1.10117264e-01f, -9.03520063e-02f, 6.60547763e-02f,
  4.71754298e-02f, -2.71847192e-02f, -4.11535464e-02f, -4.72170748e-02f, 2.51081656e-03f, -2.65671555e-02f, -6.67536855e-02f, 5.09632044e-02f, 8.99783149e-02f, 2.70084962e-02f,
  -4.23325673e-02f, -3.96270817e-03f, -1.78622771e-02f, -3.16288583e-02f, 2.83172703e-04f, 2.16354020e-02f, -4.96671796e-02f, 1.35159288e-02f, -6.77984729e-02f, -4.54428345e-02f,
  4.87020053e-02f, -7.77409226e-02f, -2.61610630e-03f, 3.84160094e-02f, -1.44854216e-02f, -1.16468407e-02f, 6.29589334e-02f, -4.19774838e-02f, -1.13869654e-02f, -3.19614038e-02f,
  6.20387942e-02f, -2.07784679e-02f, -1.41742211e-02f, -5.95997050e-02f, -8.53878930e-02f, -9.63763297e-02f, 6.85802698e-02f, 5.65544777e-02f, -9.81865730e-03f, -4.40598326e-03f,
  1.16790093e-01f, 9.92898345e-02f, 6.67683482e-02f, 9.55005288e-02f, 2.72850096e-02f, -3.10197677e-02f, 1.44736306e-03f, -3.81114297e-02f, 1.06007598e-01f, 3.34158279e-02f,
  6.24819100e-02f, 4.02395055e-02f, -2.05538031e-02f, 3.69777530e-02f, -1.89187080e-02f, 7.15899467e-02f, 7.37064555e-02f, 2.86612846e-02f, -6.30037952e-03f, 5.76996580e-02f,
  9.15805772e-02f, 1.80381924e-01f, 2.19142109e-01f, 5.86882308e-02f, 7.61395842e-02f, 1.83666095e-01f, 1.25535309e-01f, 3.05898413e-02f, 1.25802919e-01f, 4.16040085e-02f,
  3.83670554e-02f, -3.30442935e-01f, 8.66414309e-02f, -7.33187795e-02f, -1.33277491e-01f, -2.69729346e-01f, -3.58019054e-01f, -1.16465256e-01f, 5.84272109e-02f, -1.85557574e-01f,
  -6.59055039e-02f, 1.80382743e-01f, 2.87193716e-01f, 2.39416957e-01f, 8.69599283e-02f, -2.69582093e-01f, -2.26203248e-01f, 1.89078286e-01f, 2.58941889e-01f, 3.32080014e-02f,
  3.21206860e-02f, 1.58404317e-02f, 1.34184748e-01f, 4.90955673e-02f, -7.66408518e-02f, 1.01194970e-01f, -3.62460241e-02f, 2.97259688e-02f, 3.23317088e-02f, -9.12272558e-02f,
  7.07308576e-02f, 5.62669262e-02f, 1.32811308e-01f, 7.10108280e-02f, 4.04081680e-02f, -2.44179964e-02f, -2.21637394e-02f, -3.73980589e-02f, -1.39231225e-02f, -5.39174303e-02f,
  -5.38999364e-02f, 1.75414588e-02f, 4.80479449e-02f, 6.14038557e-02f, -1.05251163e-01f, -2.60408726e-02f, -2.08445787e-02f, -8.06445908e-03f, -6.91062585e-02f, 1.81636252e-02f,
  -8.63236412e-02f, -4.63699400e-02f, 6.78529218e-02f, -2.58953460e-02f, 8.56820419e-02f, 4.65293005e-02f, -9.13720019e-03f, 2.15323437e-02f, 3.13903764e-03f, -1.79160804e-01f,
  2.57964972e-02f, 5.77482693e-02f, 3.55674140e-02f, 9.56089515e-03f, -2.47098487e-02f, 4.41072546e-02f, 3.46651822e-02f, -4.23343852e-02f, 6.33428469e-02f, -5.99690108e-03f,
  3.71869169e-02f, -4.31755260e-02f, -5.21245264e-02f, -7.19978213e-02f, -3.30395885e-02f, -2.61666272e-02f, 6.40030019e-03f, -6.53988346e-02f, -2.59951595e-02f, 2.73489319e-02f,
  6.19786372e-03f, 7.40948766e-02f, 8.30598176e-03f, 4.25103400e-03f, -1.33979796e-02f, -9.87113826e-03f, -2.64427904e-02f, -9.83581971e-03f, 5.97639792e-02f, 1.08945239e-02f,
  -6.38494715e-02f, 1.08463252e-02f, -9.48726572e-03f, -8.46299995e-03f, -2.41759624e-02f, 6.64721429e-02f, -4.85412776e-02f, 4.80641760e-02f, -1.54912109e-02f, -1.70705914e-02f,
  1.60697810e-02f, 5.93209118e-02f, -8.10944661e-03f, -1.74815562e-02f, -5.65370359e-02f, 2.68103965e-02f, -6.54410049e-02f, 1.44652709e-01f, 2.16273312e-02f, -4.10461314e-02f,
  -6.85209557e-02f, -9.89666730e-02f, -7.02580484e-03f, -8.89659077e-02f, 5.23682646e-02f, 9.05884728e-02f, -9.32794064e-03f, -3.65824923e-02f, 1.37767922e-02f, -2.26616055e-01f,
  4.26522970e-01f, 1.72894880e-01f, 2.41201639e-01f, 4.76520061e-02f, -2.07156122e-01f, -4.51027565e-02f, 1.65752560e-01f, 5.86498380e-02f, -1.11519925e-01f, 1.04037508e-01f,
  -5.64234070e-02f, -1.97133139e-01f, -5.34217954e-02f, -6.30026236e-02f, 2.33275324e-01f, 2.24886701e-01f, -4.32726974e-03f, 2.02159211e-01f, 1.63516372e-01f, -7.86581635e-02f,
  -1.48347288e-01f, 1.41401738e-01f, 1.29845366e-01f, 8.90297219e-02f, -1.71896130e-01f, -1.43910438e-01f, -1.04123335e-02f, -6.95353597e-02f, -6.62125126e-02f, -2.12286294e-01f,
  -4.76946272e-02f, 9.96354669e-02f, -5.17416336e-02f, -9.62625742e-02f, -3.16940136e-02f, 4.33480814e-02f, 5.66800423e-02f, 2.98748706e-02f, -4.40180022e-03f, 2.27255514e-03f,
  -1.00146152e-01f, -1.27759790e-02f, 7.96232186e-03f, -2.08975580e-02f, 1.47781121e-02f, 1.12648025e-01f, 1.49286628e-01f, 1.28634900e-01f, 1.77452490e-01f, -2.27328995e-03f,
  -1.15862265e-01f, 6.18250407e-02f, 1.41457364e-01f, 6.42788187e-02f, 6.71577007e-02f, -1.53829068e-01f, -3.57673280e-02f, 2.02930123e-02f, -3.03712152e-02f, -1.71078481e-02f,
  9.97617748e-03f, -3.39582353e-03f, -1.21950060e-02f, 1.41973598e-02f, -7.16271810e-03f, -3.42876278e-02f, -8.47295523e-02f, -5.82697056e-02f, 2.38331612e-02f, 4.19391319e-02f,
  4.34317775e-02f, -1.27053931e-02f, -1.42157460e-02f, 9.21186879e-02f, -2.72996686e-02f, 6.40324503e-02f, -2.68240310e-02f, 8.59592184e-02f, 5.43825105e-02f, -7.06940051e-03f,
  -1.74447708e-03f, -5.33828661e-02f, 4.08885861e-03f, -1.20369876e-02f, -6.90792827e-03f, 5.31128831e-02f, 2.22705379e-02f, -1.51544763e-02f, 1.72662046e-02f, 5.89708611e-02f,
  -4.04088981e-02f, -4.98561449e-02f, 9.24534351e-02f, 1.29080638e-01f, -8.10470954e-02f, -2.08299700e-02f, -5.31066768e-02f, 2.78557725e-02f, 1.03923418e-02f, 6.46385327e-02f,
  -1.93529110e-02f, 8.34752768e-02f, 1.99876539e-02f, -1.79566145e-02f, -1.03298360e-02f, 5.13046719e-02f, 3.44296023e-02f, 3.33101153e-02f, -1.77074932e-02f, 3.73140238e-02f,
  1.35762200e-01f, 5.61040044e-02f, 1.36395440e-01f, 8.13488513e-02f, -8.02908614e-02f, 7.00031221e-02f, 4.46142219e-02f, -8.25372264e-02f, 1.77574888e-01f, 2.53413141e-01f,
  -7.21651390e-02f, 9.33995917e-02f, 3.84622663e-01f, 1.32656172e-01f, 1.93245322e-01f, 1.96766883e-01f, 2.58747578e-01f, -1.01355419e-01f, -1.89409226e-01f, 1.41044825e-01f,
  -4.91435602e-02f, -1.59720585e-01f, -2.68525332e-01f, -9.75912437e-02f, -1.51071087e-01f, 7.34306127e-02f, 1.76467076e-01f, 3.77178043e-02f, -6.15727939e-02f, -5.11983372e-02f,
  -5.78243881e-02f, -7.49646500e-02f, -3.74844521e-02f, -3.02046202e-02f, 8.86908770e-02f, -5.52462265e-02f, 4.03976850e-02f, 8.91950205e-02f, 2.63412520e-02f, 1.98081017e-01f,
  1.37648001e-01f, 2.33479142e-01f, -3.69185917e-02f, -3.07450257e-02f, 6.26082793e-02f, -9.93266255e-02f, -2.10299920e-02f, 4.66540828e-02f, -1.32658063e-02f, 7.29795247e-02f,
  5.55051193e-02f, -3.79397012e-02f, -1.55714694e-02f, 8.31091776e-03f, -2.47208886e-02f, 1.54888500e-02f, 4.20732088e-02f, 6.16937950e-02f, 4.09778394e-02f, 1.04708649e-01f,
  5.19143492e-02f, 1.65134862e-01f, 2.08329141e-01f, 1.09389871e-02f, -2.19643023e-02f, -8.99741706e-03f, 2.51458082e-02f, 4.54774909e-02f, -1.39461663e-02f, -3.60348588e-03f,
  -1.92670505e-02f, 2.65869200e-02f, -8.03860929e-03f, 8.32255837e-03f, -9.23516303e-02f, 4.23972774e-03f, 2.39968374e-02f, 1.51761547e-02f, -6.21287758e-03f, -1.59753021e-02f,
  -1.74053870e-02f, 3.86244245e-02f, 4.05252501e-02f, -3.52285020e-02f, 1.56889074e-02f, 2.16940902e-02f, 1.00750867e-02f, -5.30124679e-02f, -6.74271316e-04f, -8.79716873e-02f,
  -6.63727075e-02f, 8.79183188e-02f, 1.62120853e-02f, -9.12734643e-02f, 3.50260511e-02f, -3.75854708e-02f, 8.66568764e-04f, 3.61859724e-02f, -1.82741396e-02f, 8.61512348e-02f,
  -2.28979319e-01f, -4.37419228e-02f, -4.59681973e-02f, -5.00545762e-02f, 6.93403780e-02f, -4.66232710e-02f, -6.47303136e-03f, -2.92898566e-02f, 1.68674290e-02f, 2.64438037e-02f,
  4.99391137e-03f, -1.82993878e-02f, 2.47614905e-02f, 1.17035927e-02f, -3.24035063e-02f, 7.30090886e-02f, -9.29968208e-02f, 5.11990264e-02f, -8.59367475e-02f, 4.39254120e-02f,
  -5.52636869e-02f, 1.13324048e-02f, -1.30980134e-01f, -1.06137760e-01f, 1.89745461e-03f, -6.39179945e-02f, -9.59611963e-03f, -9.64516103e-02f, 1.27561600e-03f, -6.41797557e-02f,
  -1.28062963e-01f, -5.51528148e-02f, -1.19231425e-01f, 1.32625908e-01f, -1.82361156e-02f, -5.71367592e-02f, -1.74551412e-01f, -7.64010772e-02f, 3.65766585e-02f, 6.30487055e-02f,
  -3.08421236e-02f, 8.89043137e-03f, -5.41398562e-02f, -4.99121360e-02f, -1.00086823e-01f, 8.92564654e-02f, 1.62024200e-01f, -1.03726998e-01f, -1.27617911e-01f, -7.45524317e-02f,
  1.22455023e-01f, 4.16266657e-02f, 2.06504446e-02f, 5.02443537e-02f, 9.87950563e-02f, -3.09213270e-02f, 1.62754819e-01f, 2.97242217e-02f, 1.35907263e-01f, 1.61263496e-01f,
  -1.52862802e-01f, -4.24418971e-03f, -8.22144225e-02f, -8.12420901e-03f, 4.05823290e-02f, -5.24667762e-02f, -3.07572726e-02f, 1.82536654e-02f, -4.15709652e-02f, 2.82604955e-02f,
  -5.48006594e-02f, 3.79649363e-02f, 2.30924599e-02f, -2.71339845e-02f, -2.92940028e-02f, -2.11008638e-02f, 7.61075988e-02f, -2.49537192e-02f, 7.18448833e-02f, -2.08972655e-02f,
  7.08025545e-02f, 9.22785774e-02f, -9.54011306e-02f, 4.91918661e-02f, 3.83888409e-02f, -2.22634990e-02f, -2.78912243e-02f, 3.81036140e-02f, 4.49961871e-02f, 1.23471722e-01f,
  3.58803719e-02f, -3.60192470e-02f, -4.86697257e-02f, -6.53161630e-02f, -6.04416020e-02f, 6.32507820e-03f, -3.44885513e-02f, 6.77544102e-02f, 3.26074148e-03f, -4.43498278e-03f,
  -1.95496473e-02f, 9.38511919e-03f, 2.44752541e-02f, 5.99680394e-02f, 9.51567590e-02f, 3.82072031e-02f, 4.26533911e-03f, 5.59495622e-03f, 1.35646854e-02f, -3.50207612e-02f,
  3.36561389e-02f, -2.19182782e-02f, 6.18256740e-02f, 9.78959352e-03f, 5.12357652e-02f, 8.68533645e-03f, -1.61071438e-02f, -6.01476468e-02f, -1.00411810e-01f, -8.32288712e-03f,
  -1.04380317e-01f, -4.39140126e-02f, 8.21258947e-02f, -1.38157606e-02f, 9.51625481e-02f, -2.84521515e-03f, 9.36951786e-02f, 1.24216443e-02f, 1.02333501e-02f, -6.70593455e-02f,
  5.05786650e-02f, -1.05418131e-01f, -7.50199631e-02f, 3.03886868e-02f, -9.36625004e-02f, 7.69932941e-02f, 4.38742340e-02f, 8.56790245e-02f, 4.14359011e-02f, 5.99338897e-02f,
  1.14882953e-01f, 6.99994117e-02f, -1.07151411e-01f, -5.28552011e-02f, -2.83882339e-02f, -5.20457327e-02f, -2.61913985e-02f, 2.44536139e-02f, -8.88855830e-02f, -1.15282491e-01f,
  2.63261492e-03f, -3.76776725e-01f, 9.07820091e-02f, -1.56013802e-01f, -1.24958195e-01f, 1.07249394e-01f, 3.28051150e-02f, 1.27624942e-03f, -1.23387903e-01f, -9.05437097e-02f,
  -8.20502266e-02f, -7.14922906e-04f, 8.42921510e-02f, 9.14751664e-02f, 1.76173046e-01f, 2.01100111e-02f, -1.29441712e-02f, 3.49093676e-01f, 2.71958858e-01f, 1.66107163e-01f,
  -9.76079777e-02f, -5.67028634e-02f, -5.66615025e-04f, 8.56255442e-02f, -9.38713402e-02f, 9.54246596e-02f, -1.51079118e-01f, -1.56313106e-02f, 6.54661981e-03f, -6.32315278e-02f,
  1.09526254e-01f, -1.94273204e-01f, 2.27654546e-01f, -8.29154998e-02f, 6.44010976e-02f, 3.96608859e-02f, 8.05466343e-03f, -7.59630883e-03f, -8.36119708e-03f, -5.24932034e-02f,
  -1.41404960e-02f, -1.04936967e-02f, -4.40315604e-02f, -1.99683532e-02f, -3.94671261e-02f, 3.95950228e-02f, -7.87934735e-02f, 7.94195607e-02f, 1.15982093e-01f, -2.13386733e-02f,
  -4.49238457e-02f, -1.10805266e-01f, 6.38095737e-02f, -1.05132319e-01f, 1.26959290e-02f, 8.62363875e-02f, -7.34471455e-02f, -1.00232571e-01f, 8.44541490e-02f, -1.13156915e-01f,
  -3.09685115e-02f, -6.60213903e-02f, -8.73280969e-03f, -2.69190241e-02f, 4.61654589e-02f, 1.63981803e-02f, 8.35660025e-02f, -3.94818857e-02f, -3.38232634e-03f, -4.88412334e-03f,
  8.31800792e-03f, 7.73005709e-02f, 6.21666163e-02f, -1.84644945e-02f, 3.06815300e-02f, -1.28912106e-02f, -2.32957229e-02f, -2.48883944e-02f, 7.72759914e-02f, -8.08898546e-03f,
  4.80278917e-02f, -1.79515630e-02f, 2.52369363e-02f, 7.84570575e-02f, 6.02171607e-02f, 5.40928692e-02f, 4.25613709e-02f, -7.24872649e-02f, -3.27383243e-02f, -9.74508524e-02f,
  -2.20753755e-02f, 7.03621060e-02f, 1.20820686e-01f, 5.50278164e-02f, -9.58611444e-03f, -4.48551308e-03f, 2.35877708e-02f, -2.21356191e-02f, 3.74929383e-02f, 5.34825809e-02f,
  -2.34782565e-02f, 2.45441999e-02f, -6.65121004e-02f, -1.41803687e-02f, 6.62568882e-02f, -6.17708312e-03f, -1.34674355e-01f, 1.75453406e-02f, 4.75887507e-02f, -1.18216887e-01f,
  -1.42615423e-01f, 4.46415320e-02f, 1.39615983e-01f, 8.53216425e-02f, -9.70883965e-02f, 1.64459616e-01f, 6.61548451e-02f, 6.58927262e-02f, 2.17399508e-01f, 3.50864716e-02f,
  -5.97772142e-03f, -1.38647081e-02f, 3.46815735e-01f, -1.14888556e-01f, 4.42180596e-02f, 2.85511494e-01f, 3.52423161e-01f, 5.24773374e-02f, -7.92334080e-02f, -3.67335714e-02f,
  -9.96552482e-02f, -8.78336933e-03f, -1.56294815e-02f, 2.42434759e-02f, 5.63215092e-02f, 1.46053344e-01f, 1.57609165e-01f, 2.10547134e-01f, 2.73205042e-01f, 1.63255498e-01f,
  -6.68339804e-02f, -7.98184201e-02f, 4.56054658e-02f, -7.72451535e-02f, -1.45646408e-01f, -2.67022159e-02f, -6.20762967e-02f, -5.68249263e-02f, 4.17902954e-02f, -7.36890063e-02f,
  1.36097863e-01f, 2.34255809e-02f, 1.10383675e-01f, -1.13960527e-01f, -7.42022321e-02f, -3.50834690e-02f, 7.85694718e-02f, -5.68621792e-04f, 1.86698623e-02f, -2.17166487e-02f,
  -1.01641849e-01f, -4.54025641e-02f, 2.47440301e-03f, -7.75119588e-02f, -5.08540310e-02f, 6.53281882e-02f, -1.27483472e-01f, -4.58282270e-02f, 5.59199937e-02f, -3.96122150e-02f,
  -5.11371456e-02f, 1.78181529e-02f, 8.35697800e-02f, 5.45592308e-02f, 8.75994191e-02f, -8.44140872e-02f, 5.88880293e-02f, 1.94825716e-02f, -1.01402365e-02f, 1.24640309e-03f,
  -4.39669937e-02f, 7.11069033e-02f, -4.53766957e-02f, 8.77381582e-03f, -1.39844120e-02f, -8.09677877e-03f, -5.52037358e-02f, 4.03971933e-02f, -4.20081466e-02f, 4.85443734e-02f,
  -4.94105779e-02f, 6.72155395e-02f, -6.57678209e-03f, 5.86419106e-02f, 6.68530585e-03f, 2.55730022e-02f, 5.95767759e-02f, -6.43494949e-02f, -4.61036749e-02f, 6.09371178e-02f,
  -1.30969770e-02f, 1.34130465e-02f, -7.76623264e-02f, -4.81700860e-02f, 3.01154237e-02f, 3.40173729e-02f, -5.86157329e-02f, -2.33434979e-02f, 3.25909927e-02f, 2.39993539e-02f,
  -8.89310762e-02f, 1.00128084e-01f, -3.06665301e-02f, 2.80675553e-02f, 4.36060916e-04f, -5.51988780e-02f, 1.03676077e-02f, -2.44037006e-02f, -3.02749295e-02f, 2.53702141e-02f,
  3.07798143e-02f, 2.14109831e-02f, 2.84111667e-02f, -3.09487507e-02f, 1.07318982e-01f, 7.60650486e-02f, -4.90687601e-02f, 1.33152893e-02f, -4.09569852e-02f, -1.32613540e-01f,
  -9.25199538e-02f, 5.14703803e-02f, 9.92174819e-03f, -3.28754671e-02f, 4.62921076e-02f, 9.83241946e-02f, -3.98265608e-02f, 4.86235060e-02f, 6.99557215e-02f, -2.93811616e-02f,
  -1.84443071e-02f, 6.40681610e-02f, -1.05525665e-01f, 8.96322504e-02f, 1.54591098e-01f, 1.81642964e-01f, 1.03189033e-02f, 7.60703683e-02f, 1.12381227e-01f, 1.49690911e-01f,
  2.10182279e-01f, 6.93416893e-02f, 9.88907665e-02f, -4.20299843e-02f, -1.34486720e-01f, -1.03672370e-01f, -2.47193232e-01f, -1.77434459e-01f, -1.29905269e-01f, 4.69548330e-02f,
  6.74914345e-02f, -4.23202803e-03f, -1.89843714e-01f, -1.60977378e-01f, -8.59186202e-02f, -8.86543375e-03f, -2.18411058e-01f, -1.23868220e-01f, -1.24629177e-01f, -2.49255940e-01f,
  5.70659786e-02f, 6.43040659e-03f, 2.84461565e-02f, 8.91545340e-02f, -3.03837843e-02f, -8.47099647e-02f, 7.47375339e-02f, -7.93320760e-02f, 9.59680695e-03f, -4.80066277e-02f,
  8.67700502e-02f, 1.18838198e-01f, 4.26059961e-02f, 8.13479722e-02f, -4.20355611e-02f, 1.67573839e-02f, -3.78982611e-02f, -1.55546233e-01f, -4.03824374e-02f, 2.03404017e-02f,
  1.35374114e-01f, 9.29857194e-02f, 2.55912486e-02f, -4.99549247e-02f, -9.15359184e-02f, -1.19613156e-01f, 2.10527368e-02f, -1.26340479e-01f, -1.35416493e-01f, -1.34877130e-01f,
  -2.30108220e-02f, -9.62796621e-03f, -5.75592071e-02f, 3.56306471e-02f, -7.13762082e-03f, 6.01508021e-02f, 1.22027909e-02f, 3.83967580e-03f, -5.02159409e-02f, -1.48033677e-02f,
  -3.69648263e-02f, -6.01624046e-03f, -6.25666976e-02f, -3.90113294e-02f, -2.13668477e-02f, -3.40260938e-02f, 2.49338076e-02f, 2.53243465e-03f, -2.32969160e-05f, 4.88583148e-02f,
  2.62275785e-02f, -4.09222655e-02f, 6.67546829e-03f, -2.59236451e-02f, 1.32869622e-02f, -6.88830810e-03f, -1.91278644e-02f, 5.20684235e-02f, 5.26054278e-02f, 5.45990765e-02f,
  4.68295254e-02f, 7.39861745e-03f, -2.63266936e-02f, -7.06343874e-02f, 6.21899329e-02f, -1.65221542e-02f, 2.57120468e-02f, 5.29984087e-02f, 2.52506603e-02f, 7.66497552e-02f,
  1.22702062e-01f, -7.25368336e-02f, 1.90517455e-02f, -1.87038593e-02f, 4.13131230e-02f, 2.37900056e-02f, 7.94747993e-02f, -3.10620200e-02f, 6.17220439e-02f, 7.65186921e-02f,
  5.19433357e-02f, -1.60946995e-02f, -1.88184399e-02f, 2.52854824e-02f, -4.39570397e-02f, 1.38051091e-02f, -8.31720531e-02f, -7.39790872e-02f, -4.84837703e-02f, -2.10775509e-01f,
  -2.01429948e-01f, 3.09802685e-03f, 8.32998827e-02f, -1.42910093e-01f, 1.12918749e-01f, 2.76618659e-01f, 2.65096813e-01f, 1.42811075e-01f, -9.75530818e-02f, -6.86399564e-02f,
  -4.82215546e-02f, -2.07734287e-01f, -4.21787202e-02f, 4.44774106e-02f, 1.33279830e-01f, 1.90437436e-01f, 2.69578639e-02f, 9.99837890e-02f, 1.74998581e-01f, 4.78988094e-03f,
  2.36620679e-02f, -1.04266219e-01f, -5.64103872e-02f, -7.18094110e-02f, -2.19952375e-01f, -8.36241394e-02f, -9.57391784e-02f, -7.20509812e-02f, -1.16580799e-02f, -7.32008070e-02f,
  -3.31916660e-01f, -8.54272693e-02f, 8.24439079e-02f, -5.91299608e-02f, -1.02705583e-01f, 2.16544792e-02f, -1.90814119e-02f, -5.91476113e-02f, -1.36075020e-01f, -7.78992176e-02f,
  -9.04984474e-02f, -9.60674211e-02f, -1.76595263e-02f, 1.10821575e-02f, -1.33681819e-02f, 3.78157711e-03f, -2.98498087e-02f, 4.54672128e-02f, -3.93282212e-02f, -4.92960438e-02f,
  -3.46517153e-02f, 8.26420859e-02f, 4.16647419e-02f, 3.54635566e-02f, 8.59700888e-02f, 9.43633467e-02f, 1.08201198e-01f, -5.50036207e-02f, 4.66381125e-02f, -1.95023015e-01f,
  -2.61311363e-02f, 1.60385594e-02f, 5.47363088e-02f, -1.12376111e-02f, 4.28246073e-02f, 4.18836474e-02f, -3.07777710e-02f, -7.48250773e-03f, 4.68911827e-02f, -2.30111368e-02f,
  -8.25235154e-03f, 1.35779725e-02f, -4.21653938e-04f, -2.18039695e-02f, -7.83337578e-02f, 2.05885768e-02f, -4.91815619e-04f, 6.60111196e-03f, 6.72448874e-02f, -2.79951282e-03f,
  8.10786337e-02f, -3.08592189e-02f, -3.99614498e-02f, -2.32840166e-03f, -3.43731069e-03f, -2.09940728e-02f, -4.72275913e-02f, 6.05037324e-02f, 1.38430139e-02f, -4.61379774e-02f,
  -1.86194688e-01f, 3.07981580e-01f, -1.28864855e-01f, -2.73301285e-02f, 1.77081320e-02f, 1.42603209e-02f, 3.78454366e-04f, -4.68977690e-02f, -2.94406060e-03f, 3.08427513e-02f,
  5.91916293e-02f, 3.53319310e-02f, -7.26058567e-03f, -6.47714874e-03f, 3.32822539e-02f, -6.00609370e-02f, 4.57598940e-02f, -1.30882384e-02f, 1.30271316e-01f, -7.60301650e-02f,
  2.03121314e-03f, 7.48860985e-02f, 4.42438237e-02f, 1.19390301e-01f, -4.45428826e-02f, 8.80160853e-02f, -5.22463731e-02f, 4.40942235e-02f, 1.10964462e-01f, 2.96632443e-02f,
  4.47895825e-01f, 5.22191229e-04f, -3.64640892e-01f, 1.45942140e-02f, -5.40939979e-02f, -4.71104048e-02f, -1.55375125e-02f, 2.09121153e-01f, 2.32784674e-02f, 3.73993330e-02f,
  -4.73921979e-03f, 1.17902450e-01f, -7.92789534e-02f, -3.88150960e-02f, 5.26946597e-02f, -5.56785762e-02f, -1.68412432e-01f, -1.60849035e-01f, -9.50691476e-02f, 6.08439259e-02f,
  -5.80851659e-02f, 3.55864726e-02f, 8.04368034e-02f, 9.01781246e-02f, 4.74247136e-05f, -5.97192422e-02f, -6.57390011e-03f, -4.49437201e-02f, -1.49983719e-01f, -3.26949447e-01f,
  -3.02860349e-01f, 1.37974486e-01f, -1.87404361e-02f, -2.21877787e-02f, -1.08421855e-01f, 4.72127087e-02f, 3.50287817e-02f, 3.31322215e-02f, 1.10383458e-01f, 1.66786108e-02f,
  -3.12557071e-02f, 4.32374962e-02f, -4.34501003e-03f, 5.20964414e-02f, 7.58539438e-02f, 5.32878190e-02f, 1.38476398e-02f, 6.21692576e-02f, 5.46367504e-02f, -7.90043920e-02f,
  -1.07878193e-01f, 9.74754337e-04f, -9.94122252e-02f, 9.70598534e-02f, 3.98784354e-02f, -8.19088221e-02f, 5.42771779e-02f, 7.56439520e-04f, 8.40524957e-02f, 5.64310886e-02f,
  4.29099128e-02f, 7.39770150e-03f, 1.76414158e-02f, 4.29563504e-03f, 4.43661585e-03f, 2.99283117e-02f, -5.10107987e-02f, -2.60457285e-02f, -9.95179918e-03f, 7.29538128e-02f,
  -2.25242712e-02f, 3.09829488e-02f, -3.22181955e-02f, 5.58049185e-03f, -5.13153225e-02f, 1.78981554e-02f, -7.03268871e-02f, 3.94530334e-02f, 1.99763756e-02f, 4.75408211e-02f,
  -4.81613986e-02f, -4.82636009e-04f, 3.09780184e-02f, 1.31971445e-02f, -3.56983207e-03f, 1.29173435e-02f, -1.02790110e-02f, 2.27442128e-03f, 4.86766268e-03f, -6.50650710e-02f,
  5.20618707e-02f, -4.24744673e-02f, -5.08467071e-02f, 6.94800317e-02f, -4.16849107e-02f, -6.91705523e-03f, -4.14611138e-02f, -7.65528204e-03f, -6.94665015e-02f, -1.85983870e-02f,
  4.54417616e-02f, -1.22869182e-02f, -1.62418410e-02f, -6.17382675e-02f, 4.82335240e-02f, -2.90397387e-02f, 1.89214814e-02f, -6.19946197e-02f, -2.90880632e-02f, -8.65423828e-02f,
  2.44081710e-02f, 5.21946214e-02f, 6.19157590e-03f, -4.54435460e-02f, 6.57004192e-02f, 4.25176881e-02f, -7.55242556e-02f, -7.22677633e-02f, 7.34027252e-02f, 1.49834797e-01f,
  9.07758623e-02f, -2.82941520e-01f, -2.71236300e-01f, -6.08726144e-02f, -3.04922014e-01f, -2.08231211e-01f, -2.19573811e-01f, 3.03692762e-02f, 7.52544701e-02f, -2.37338215e-01f,
  -1.95441216e-01f, 5.31206392e-02f, 1.13193272e-02f, 1.01229958e-01f, 1.21574104e-01f, -1.78591564e-01f, -1.77886009e-01f, 1.75015479e-01f, 1.68229833e-01f, 9.94932801e-02f,
  -1.53800137e-02f, 6.97553158e-02f, 2.46087283e-01f, 1.08530238e-01f, -1.58876732e-01f, 1.72463506e-02f, -4.06360440e-02f, -8.01022053e-02f, -7.80756772e-02f, -2.39502162e-01f,
  -4.09330010e-01f, -1.04348637e-01f, 4.98204492e-02f, 1.51345253e-01f, -5.77090867e-02f, 9.68571305e-02f, -1.94309726e-02f, 5.26005626e-02f, 2.91453153e-02f, -4.95840088e-02f,
  -2.01529190e-02f, 1.34733990e-01f, -3.24525125e-02f, 1.69107057e-02f, 2.65772939e-02f, -8.52243137e-03f, 9.99376923e-02f, 6.65734038e-02f, 9.50059220e-02f, -2.41212510e-02f,
  -4.04846780e-02f, -3.67625616e-02f, -8.42349380e-02f, 1.19189164e-02f, -2.66458392e-02f, 9.60769355e-02f, -1.33937657e-01f, 5.54753803e-02f, 9.28238258e-02f, -1.99119765e-02f,
  -4.67389002e-02f, -6.78214803e-02f, -4.16243449e-02f, 6.04544319e-02f, -4.85762507e-02f, -4.39339802e-02f, -7.49957785e-02f, 1.35130463e-02f, -1.75968220e-03f, 5.34143951e-03f,
  -2.90207472e-03f, -1.65625513e-02f, 9.05314519e-04f, -1.76443253e-02f, -5.83230555e-02f, -2.50093956e-02f, -1.54546686e-02f, -5.45863882e-02f, -3.49403406e-03f, 3.67512219e-02f,
  4.10389639e-02f, 5.53838797e-02f, -7.35294481e-04f, 8.24843813e-03f, -9.17114019e-02f, -4.62452546e-02f, -2.37510949e-02f, 7.32290074e-02f, 2.94299498e-02f, 8.70515928e-02f,
  2.64104363e-02f, 1.39716282e-01f, -1.66207194e-01f, 7.56035596e-02f, -9.34192538e-03f, -2.95825601e-02f, -5.70077337e-02f, 1.52792707e-02f, 4.85935397e-02f, 9.21121147e-03f,
  1.61746680e-03f, -3.41809466e-02f, -1.62009578e-02f, 6.91696815e-03f, -3.85428108e-02f, 2.00894065e-02f, -2.37778518e-02f, -2.19558887e-02f, 7.44918510e-02f, -2.21880320e-02f,
  -4.74679247e-02f, 8.58584698e-03f, 2.72961445e-02f, -6.13091588e-02f, 3.60900722e-02f, 2.52569225e-02f, -1.12449005e-01f, -1.22043259e-01f, 3.97782661e-02f, -1.88875869e-01f,
  -3.45727056e-02f, -6.81224391e-02f, -1.10336065e-01f, -9.82075259e-02f, 4.15581204e-02f, 8.05544332e-02f, 7.41649568e-02f, -2.00370792e-02f, -5.78277223e-02f, -5.56279533e-02f,
  2.13865563e-01f, 2.20808417e-01f, 1.72380939e-01f, 2.02998772e-01f, 9.52417850e-02f, -1.88706502e-01f, -2.40241379e-01f, -6.26893789e-02f, 1.27508074e-01f, 1.05114467e-01f,
  5.86910546e-02f, 3.80939581e-02f, -7.08521977e-02f, 2.65681688e-02f, -1.14230454e-01f, -7.71588534e-02f, -1.07433051e-01f, -1.08071171e-01f, -2.66324393e-02f, -3.90205771e-01f,
  9.77797620e-03f, 8.45457390e-02f, -1.20768417e-02f, -5.08732833e-02f, 6.51670173e-02f, -8.37918296e-02f, 6.65882751e-02f, 1.31159034e-02f, 6.89231679e-02f, -2.45396271e-02f,
  -2.39016172e-02f, 5.54899201e-02f, 4.31747213e-02f, 1.64372362e-02f, 2.03715656e-02f, 1.81478262e-03f, 2.18101200e-02f, -8.48393068e-02f, -3.34465988e-02f, 5.71762323e-02f,
  7.33936578e-02f, 8.32574889e-02f, 1.57418862e-01f, -3.22944787e-03f, 1.02536373e-01f, 4.60448526e-02f, -2.98532769e-02f, 2.74357293e-02f, -3.26692834e-02f, -2.51881480e-01f,
  -5.48589304e-02f, -6.39119297e-02f, -2.45803799e-02f, 1.07555827e-02f, 4.69724201e-02f, -1.11129251e-04f, -4.25603688e-02f, 5.06144986e-02f, -4.86033447e-02f, -3.46411578e-02f,
  1.95767395e-02f, 1.00779170e-02f, 4.63371985e-02f, 2.93971449e-02f, 1.81326438e-02f, 2.30445098e-02f, -5.91393225e-02f, 3.04978099e-02f, 3.84801961e-02f, -3.51088941e-02f,
  7.49793500e-02f, -3.76370735e-02f, -8.26485604e-02f, 6.00583991e-03f, 5.04870713e-02f, 1.18714562e-02f, 1.46411881e-02f, 6.75689653e-02f, -1.70433484e-02f, -7.85928406e-03f,
  -8.67838562e-02f, 2.15163946e-01f, -2.71201562e-02f, 2.64246892e-02f, -2.49228012e-02f, -4.41367365e-02f, -3.72654013e-02f, -5.58275916e-02f, 4.91844453e-02f, -4.19722497e-02f,
  1.40977502e-01f, -2.59767240e-03f, 1.07829291e-02f, -4.37137745e-02f, -2.54779346e-02f, 8.83945674e-02f, -9.52435732e-02f, -4.36748974e-02f, -3.91000398e-02f, -1.32957855e-02f,
  -4.01630215e-02f, -7.00677857e-02f, 7.54904822e-02f, -6.40056655e-03f, -2.73560118e-02f, 6.36679726e-03f, 4.97296117e-02f, -1.52122518e-02f, 1.25492558e-01f, -2.42988631e-01f,
  3.91124710e-02f, 5.07701933e-02f, 1.56766340e-01f, -4.28724922e-02f, -1.12213921e-02f, 9.26404297e-02f, 9.73107815e-02f, -9.61958896e-03f, -1.16545521e-01f, -4.32631467e-03f,
  -1.47652686e-01f, -1.42016903e-01f, -1.03795290e-01f, -9.44600180e-02f, 1.59134090e-01f, 2.84211457e-01f, 2.36764610e-01f, 1.15146846e-01f, 3.57284546e-02f, -4.27333489e-02f,
  -1.87554155e-02f, -7.78312460e-02f, 5.59035689e-03f, -3.11777052e-02f, -3.27924713e-02f, -1.05153754e-01f, 4.25522123e-03f, -3.85163315e-02f, 4.95340265e-02f, 1.15901433e-01f,
  5.67888878e-02f, -6.26326725e-02f, -8.04413632e-02f, -8.20483938e-02f, -5.75740635e-02f, 6.37046173e-02f, 2.91181803e-02f, -4.98895645e-02f, 4.05025929e-02f, -4.12903912e-02f,
  3.02456338e-02f, 2.65672654e-02f, 3.30847614e-02f, -1.01719923e-01f, 1.42938774e-02f, -8.96776095e-03f, 2.89233923e-02f, 3.53604890e-02f, 6.24477044e-02f, 3.44886933e-03f,
  -7.16871023e-02f, 1.09232413e-02f, 1.11676686e-01f, 6.60380423e-02f, -5.26438514e-03f, 4.32117246e-02f, -5.35802580e-02f, 1.81582887e-02f, -9.00715813e-02f, 1.12061352e-01f,
  -1.63025334e-02f, -3.76972668e-02f, -9.55733806e-02f, -2.89415512e-02f, 7.62303621e-02f, -3.92574891e-02f, 9.59571451e-03f, 2.69036703e-02f, -3.03477757e-02f, -6.74842596e-02f,
  -4.58052894e-03f, -6.82007447e-02f, 2.68317497e-04f, 4.33849432e-02f, -9.82766747e-02f, 6.16306160e-03f, 7.24607557e-02f, 9.43977479e-03f, -2.48178747e-02f, -1.71599537e-02f,
  -5.01768440e-02f, 8.95776525e-02f, 1.85976569e-02f, -1.12823904e-01f, 8.65024999e-02f, 7.96074048e-03f, 4.38845381e-02f, -2.87652742e-02f, -6.69901492e-03f, 8.89975205e-03f,
  -8.65364447e-02f, -4.62227464e-02f, 1.32092446e-01f, 1.64851416e-02f, -4.36269259e-03f, -1.40883150e-02f, -5.98864816e-03f, 2.47541964e-02f, -4.43629734e-02f, 1.13685839e-01f,
  7.00505450e-02f, 3.75998905e-03f, -3.52796838e-02f, 3.31835970e-02f, -7.31202364e-02f, 2.87360512e-02f, 6.48439452e-02f, 6.62285835e-02f, 3.33345979e-02f, 5.20238876e-02f,
  9.24836919e-02f, 1.34668350e-01f, 1.31956488e-01f, 1.02176070e-01f, 8.73132497e-02f, 3.04531809e-02f, 3.26497555e-02f, 3.74254733e-02f, 1.42590821e-01f, 6.71513602e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.31524578e-01f, 3.17684412e-02f, 1.05011964e-03f, 7.85515830e-02f, 1.06131621e-02f, 3.51017639e-02f, -6.84007928e-02f, -1.61919102e-01f, -4.97884955e-03f, -5.40565350e-04f,
  1.04021415e-01f, 1.09163083e-01f, 4.93508726e-02f, -5.58067597e-02f, -7.25073293e-02f, -6.02995604e-02f, 4.54737954e-02f, -6.83031306e-02f, -7.11300820e-02f, 6.98685050e-02f,
  1.07559882e-01f, 7.02953711e-02f, -8.05622246e-03f, 5.68593331e-02f, -2.02494934e-02f, -2.56721582e-02f, 2.32747328e-02f, 5.38119907e-03f, -1.77032836e-02f, 9.90879461e-02f,
  1.38170183e-01f, -6.06866293e-02f, 2.77355164e-02f, 2.76290122e-02f, 5.51162623e-02f, 3.04852054e-03f, -7.54508749e-02f, -4.96072555e-03f, 5.36659546e-02f, -7.50972778e-02f,
  6.36547729e-02f, 1.79216713e-02f, 4.07910831e-02f, -9.50734317e-03f, 6.94384649e-02f, -3.64203416e-02f, -5.36479242e-02f, -4.65575047e-02f, -8.16731248e-03f, 5.07878736e-02f,
  -1.86628569e-02f, 8.18002373e-02f, 8.88777524e-03f, -1.76809449e-02f, -8.79083946e-02f, -2.29155179e-02f, -7.93790594e-02f, -7.93571696e-02f, -4.17784601e-03f, -8.78012273e-03f,
  -1.21274032e-02f, -6.12819195e-02f, 7.63795599e-02f, -1.14554666e-01f, 3.43577974e-02f, -7.49843009e-03f, 2.41971072e-02f, -6.86565936e-02f, -8.89674351e-02f, -4.88812625e-02f,
  -8.23620111e-02f, -7.25406501e-03f, 3.39100435e-02f, 2.14386582e-02f, -4.66918610e-02f, -1.51389474e-02f, -7.45430589e-02f, -2.26115584e-02f, 8.61849487e-02f, -3.06447372e-02f,
  -7.74064809e-02f, 2.95433849e-02f, -5.66971228e-02f, -4.56746779e-02f, -7.52063170e-02f, -1.49471983e-02f, 6.71520978e-02f, -8.49264190e-02f, -5.06193303e-02f, 9.23339948e-02f,
  2.26509385e-02f, 3.92053612e-02f, 7.11821839e-02f, 5.10575669e-03f, 3.43218111e-02f, 4.55278270e-02f, -1.54813882e-02f, 4.61317832e-03f, 1.94134638e-02f, -8.36709142e-02f,
  -8.38312730e-02f, -1.01446293e-01f, -4.25670296e-02f, 3.89530472e-02f, 5.65790311e-02f, 2.07042135e-03f, 9.80313495e-03f, -5.31920344e-02f, 6.34102290e-03f, -2.01412514e-02f,
  -1.14021122e-01f, -8.81327763e-02f, -7.57591426e-02f, -1.00635216e-01f, 3.36383022e-02f, -4.46086712e-02f, 9.49829817e-03f, -4.90612201e-02f, -7.85938799e-02f, -4.36287709e-02f,
  -2.92425901e-01f, 1.47591131e-02f, -5.82579263e-02f, 1.93905443e-01f, 2.27735594e-01f, 1.03350751e-01f, 2.46275529e-01f, 1.81728467e-01f, 1.96605951e-01f, 1.04992107e-01f,
  9.21490788e-02f, 2.09176987e-01f, 1.57005057e-01f, 1.77235395e-01f, 1.92526534e-01f, 1.93546042e-01f, 2.14557752e-01f, 9.82770398e-02f, 8.66988748e-02f, 9.84579325e-03f,
  1.26355112e-01f, 2.18751114e-02f, -8.12354088e-02f, 7.29194134e-02f, 1.30892217e-01f, 1.15353957e-01f, 5.91750033e-02f, 4.50303778e-02f, -4.70927730e-02f, -5.21043390e-02f,
  -1.41055882e-01f, -1.89724877e-01f, 1.63929939e-01f, -1.88485486e-03f, -4.45096381e-02f, -1.51497975e-01f, -1.22419531e-02f, -1.72744259e-01f, 2.17161868e-02f, -8.34942237e-03f,
  -5.91899715e-02f, 4.02699644e-03f, 5.85728977e-03f, -4.37169150e-02f, 4.86398302e-02f, 5.87651879e-02f, 2.59425608e-03f, -3.95150967e-02f, 8.11466575e-03f, -1.16118640e-01f,
  6.89926445e-02f, -1.44976303e-01f, -1.03125185e-01f, 1.34274840e-01f, -3.35890427e-02f, 6.44984469e-02f, -7.18340203e-02f, -1.11334838e-01f, 7.42966086e-02f, -1.58379495e-01f,
  2.06519533e-02f, 4.40561399e-02f, 2.02605519e-02f, 8.00938904e-03f, 1.21256530e-01f, 6.22606836e-02f, -2.77755652e-02f, -6.41226396e-03f, 3.23612019e-02f, -6.59524873e-02f,
  4.64637615e-02f, 1.55304978e-02f, -5.74681573e-02f, -2.80004404e-02f, 1.06159531e-01f, -8.80219042e-02f, 6.94224378e-03f, -4.87497300e-02f, -2.52379235e-02f, 3.68854851e-02f,
  -5.98685257e-02f, -2.72250324e-02f, 2.85447501e-02f, 1.54127050e-02f, 5.40947504e-02f, 2.31486522e-02f, -5.60766757e-02f, 1.26837213e-02f, -6.68834969e-02f, -9.76557136e-02f,
  -1.04946114e-01f, 5.26360087e-02f, 9.74649563e-02f, 5.37429936e-02f, -9.24387649e-02f, -5.49664348e-02f, -1.36682075e-02f, -7.82526359e-02f, -1.52446441e-02f, -3.25301662e-02f,
  -8.60880464e-02f, 1.55770183e-02f, -4.03644107e-02f, -2.21315864e-03f, -9.27831456e-02f, -6.51756823e-02f, -6.80183470e-02f, 5.85739389e-02f, -8.87895077e-02f, -6.77828416e-02f,
  1.19437082e-02f, -7.42639787e-03f, -1.03062972e-01f, -4.47211303e-02f, -5.26758246e-02f, 1.84353013e-02f, -3.20223309e-02f, 2.79101613e-03f, -1.18021600e-01f, -6.53857589e-02f,
  2.83998996e-01f, -6.33953046e-03f, 1.12059228e-01f, 4.48367596e-02f, -8.88690129e-02f, 6.00164719e-02f, 6.74934313e-02f, 4.52392995e-02f, -4.24936973e-02f, 2.27146968e-02f,
  7.99298212e-02f, 1.43622598e-02f, 1.07950695e-01f, 8.41221735e-02f, 1.23002231e-01f, 9.41336062e-03f, -8.04534182e-02f, 1.34009227e-01f, 1.42739147e-01f, 5.52666076e-02f,
  1.79951228e-02f, -5.44736423e-02f, 1.05617255e-01f, -5.36125526e-02f, 1.97180565e-02f, -1.02552921e-02f, 1.12384334e-01f, -4.89500090e-02f, -2.45294888e-02f, 1.09415986e-01f,
  6.67908862e-02f, 1.27322465e-01f, 6.24754243e-02f, 4.58933935e-02f, -8.16973746e-02f, -8.53442475e-02f, 8.18120874e-03f, 3.13403308e-02f, 2.92813126e-02f, -8.52640159e-03f,
  1.44577131e-03f, -4.55913916e-02f, 6.28161523e-03f, -8.77895877e-02f, -3.46472859e-02f, 4.52929884e-02f, -2.95475237e-02f, 1.24260724e-01f, 1.22260787e-01f, -4.77711074e-02f,
  -2.83848457e-02f, 4.01973985e-02f, -1.24846371e-02f, 3.20825130e-02f, -5.07225581e-02f, -7.07178339e-02f, 2.71787215e-02f, 5.13436757e-02f, 1.44270450e-01f, 1.41594678e-01f,
  -1.07093458e-03f, 4.85956036e-02f, 4.60776761e-02f, -7.04368278e-02f, 4.78457697e-02f, -2.90930998e-02f, 2.02126633e-02f, -1.13985278e-02f, -8.28818604e-02f, 2.98494548e-02f,
  1.43294530e-02f, 2.80306116e-02f, -5.61031178e-02f, 9.85655468e-03f, 6.94327056e-02f, 5.06200753e-02f, -8.86839032e-02f, 8.11289623e-02f, -4.29586098e-02f, 5.13027757e-02f,
  1.31390383e-02f, 9.52860527e-03f, 6.98785186e-02f, 6.44334182e-02f, 1.16674721e-01f, 1.05584428e-01f, -1.57522107e-03f, 2.32107304e-02f, -3.14918347e-02f, -7.28418827e-02f,
  -9.32320729e-02f, -4.57719453e-02f, -7.02985227e-02f, 7.43786916e-02f, 2.16574594e-02f, -7.99421966e-02f, 3.82779427e-02f, 1.94072891e-02f, 5.18918596e-02f, 5.37956022e-02f,
  -6.40356243e-02f, -2.00800947e-03f, 7.10724248e-03f, 2.92617027e-02f, -1.41299609e-03f, 6.02482967e-02f, -2.35475320e-02f, 2.86249556e-02f, 2.06822921e-02f, -6.42983988e-02f,
  -7.52282217e-02f, -8.75466689e-02f, 4.51997966e-02f, -5.21139801e-02f, 6.85110828e-03f, 3.51795345e-03f, 2.93318983e-02f, 5.33351824e-02f, 9.52368602e-03f, 1.57708023e-02f,
  -4.34442014e-02f, 1.04872800e-01f, 5.12120388e-02f, -6.61516190e-02f, 2.24673729e-02f, -1.63530692e-01f, -4.64740284e-02f, -1.26870841e-01f, 2.03455240e-02f, -2.93496773e-02f,
  -1.01008169e-01f, 1.98896099e-02f, 8.69690720e-03f, 4.96809296e-02f, -4.05404791e-02f, 3.03321499e-02f, 1.44197673e-01f, 1.18269987e-01f, -1.93944480e-02f, 6.50283024e-02f,
  1.31521444e-03f, 8.81718099e-03f, -5.98980067e-03f, 8.07398707e-02f, 1.33246869e-01f, 1.30514219e-01f, 1.15275458e-01f, 1.13617197e-01f, 1.33792935e-02f, 2.34597847e-01f,
  8.64793174e-03f, -3.78508680e-02f, 4.98973019e-02f, -3.46390391e-03f, -2.61474159e-02f, 4.17750468e-03f, -2.30223425e-02f, -5.02994210e-02f, -7.66439410e-03f, 3.48672597e-03f,
  6.60433993e-02f, -1.32985748e-02f, 5.83916381e-02f, 5.89196458e-02f, 2.17165500e-02f, 4.25254852e-02f, 1.24190822e-01f, 1.36908785e-01f, 1.15476720e-01f, 7.53240706e-03f,
  7.87530001e-03f, 1.70888081e-02f, -8.39513615e-02f, 4.43259999e-02f, 6.35681301e-02f, -1.88194625e-02f, -7.13985413e-03f, 1.07879952e-01f, 4.59461175e-02f, 1.31045356e-01f,
  -2.57918481e-02f, -5.25409952e-02f, -6.75370321e-02f, -4.39409949e-02f, 8.35944712e-02f, 5.02380729e-02f, -7.37323686e-02f, -1.28653983e-03f, 4.08410653e-02f, 1.66818164e-02f,
  3.51473577e-02f, -1.97572950e-02f, -5.49860783e-02f, -7.62855187e-02f, 6.88899830e-02f, 5.15635721e-02f, 1.23184528e-02f, 2.72520557e-02f, 2.07944289e-02f, 2.51005422e-02f,
  4.69412319e-02f, -2.35479474e-02f, -1.05530038e-01f, -1.36599818e-03f, -2.41185017e-02f, -8.94926302e-03f, 6.56101257e-02f, -3.24811577e-03f, -7.58063979e-03f, 1.90527774e-02f,
  -1.15517609e-01f, -4.00845744e-02f, -8.47159624e-02f, 1.09543100e-01f, -6.96356446e-02f, -6.02089195e-03f, -1.84535906e-02f, -1.75229285e-03f, -1.81741025e-02f, -6.86058030e-02f,
  -8.30964297e-02f, 2.19529436e-04f, -9.77676660e-02f, -1.53317433e-02f, 5.44020385e-02f, -1.78225935e-02f, 1.89415663e-02f, -3.33101153e-02f, -7.86660984e-02f, -9.94649306e-02f,
  1.72255337e-02f, -5.31107597e-02f, -1.53326333e-01f, -1.11400448e-01f, -1.55228600e-02f, -1.19962536e-01f, -1.19831622e-01f, 4.09978256e-02f, -1.07657947e-01f, -1.40159130e-01f,
  -4.87857163e-01f, -2.50056889e-02f, 3.02478336e-02f, -3.29629689e-01f, -1.20888256e-01f, -4.44610268e-02f, 4.76740934e-02f, -1.03064112e-01f, -1.48095474e-01f, -8.68178904e-02f,
  3.17122824e-02f, -1.09899051e-01f, 5.11681214e-02f, -1.82198491e-02f, 1.63349193e-02f, -9.51419547e-02f, -2.49188058e-02f, -3.85873229e-03f, -4.82495129e-02f, -6.75042868e-02f,
  -1.21266373e-01f, -1.91334069e-01f, -1.17247179e-01f, -9.42644998e-02f, 6.36197906e-03f, 2.25515030e-02f, -7.50287250e-02f, -8.35122466e-02f, 2.08114367e-02f, -1.30975261e-01f,
  2.03623459e-01f, -1.63873672e-01f, 7.03379419e-03f, -1.19755492e-01f, 6.60950039e-03f, 1.22776823e-02f, -3.15635353e-02f, -4.18801643e-02f, 4.28345166e-02f, 1.71919111e-02f,
  -9.30149704e-02f, 7.19642639e-02f, -6.15801811e-02f, -2.49273796e-02f, 1.56844370e-02f, 1.79927573e-02f, 1.82784032e-02f, 3.40569131e-02f, 2.02422589e-02f, 1.07315890e-01f,
  4.88154925e-02f, -4.82116528e-02f, -7.78955966e-02f, 7.06833154e-02f, 6.84028212e-03f, -3.12766470e-02f, 3.72173786e-02f, 9.68964696e-02f, 1.80598255e-02f, -6.04634583e-02f,
  -1.71345621e-02f, -9.25229676e-03f, -5.58407642e-02f, -6.23986162e-02f, -7.65549988e-02f, 6.01424128e-02f, -1.01156145e-01f, -4.70170826e-02f, 8.69811326e-03f, -4.23124060e-02f,
  8.36140960e-02f, 6.11236356e-02f, -8.64608139e-02f, -4.75681461e-02f, 9.07991678e-02f, -6.40038401e-02f, -7.06733614e-02f, -5.11586368e-02f, -3.61053385e-02f, 5.29264174e-02f,
  -1.14949616e-02f, 7.89659545e-02f, -4.37477268e-02f, -2.32129041e-02f, -2.53759138e-02f, -2.97991037e-02f, 8.41088519e-02f, 1.78208258e-02f, 5.34559898e-02f, 7.33845830e-02f,
  -5.68585517e-03f, 6.93124309e-02f, -3.56295034e-02f, -1.15562983e-01f, -8.78425722e-04f, 6.31279647e-02f, 2.61258930e-02f, -4.32084277e-02f, 3.50565128e-02f, 4.18835059e-02f,
  1.10288095e-02f, -8.19097012e-02f, 2.42338032e-02f, 1.21432647e-01f, 7.49859884e-02f, 8.06618556e-02f, -2.19359770e-02f, 3.84251704e-03f, -8.67449562e-04f, 4.59350124e-02f,
  -1.42663820e-02f, -5.29594086e-02f, -1.32711813e-01f, 9.47389938e-03f, 6.40168563e-02f, -1.02486007e-01f, 1.12038702e-01f, 1.20914757e-01f, 7.48879984e-02f, -6.43764809e-02f,
  -4.23862308e-01f, -2.44771428e-02f, -9.10381495e-04f, -2.87922591e-01f, -1.41143575e-01f, -4.32037525e-02f, -2.48539876e-02f, -1.36721373e-01f, -1.34212300e-01f, -1.48232998e-02f,
  3.44587937e-02f, -4.02320065e-02f, 3.83201130e-02f, 1.31837234e-01f, 3.08970455e-02f, 3.93303670e-02f, -1.57739234e-03f, -1.21180616e-01f, 1.07539771e-02f, -2.83513684e-02f,
  -5.44519387e-02f, -8.21979791e-02f, -7.35994205e-02f, 4.24745083e-02f, -1.12204319e-02f, 3.24981026e-02f, 1.21867642e-01f, 1.07152038e-04f, 8.96257386e-02f, 1.00214943e-01f,
  3.87843698e-01f, -5.76631054e-02f, -5.51821552e-02f, -1.07762121e-01f, -2.83469912e-02f, -4.87542860e-02f, 4.64709513e-02f, 3.54075059e-03f, -1.03965417e-01f, -2.35740747e-02f,
  1.19244040e-03f, 2.84829326e-02f, -3.92972343e-02f, 7.85199478e-02f, -1.00633964e-01f, 2.58636177e-02f, 3.10196299e-02f, -2.97117252e-02f, -2.11975910e-02f, 2.35800818e-03f,
  6.83525130e-02f, 7.77100027e-02f, 1.92859489e-02f, 1.17515594e-01f, 6.86779395e-02f, 5.62545545e-02f, 1.13870978e-01f, 5.66124469e-02f, 9.59650055e-02f, 5.48987277e-02f,
  4.71473811e-03f, 6.35261461e-02f, 7.12919161e-02f, -4.82845604e-02f, 5.86493611e-02f, -6.30744025e-02f, -5.16359173e-02f, -3.98894995e-02f, -4.47036624e-02f, 1.76863819e-02f,
  2.76044011e-02f, 6.73840940e-02f, 1.60458907e-02f, -4.93973568e-02f, -2.61790082e-02f, 6.81175292e-02f, -4.97030318e-02f, 2.37270221e-02f, 5.16076088e-02f, -2.31564827e-02f,
  9.05825291e-03f, 3.91409323e-02f, 1.54575496e-03f, 5.04450537e-02f, -7.17065111e-02f, -6.36615977e-02f, 1.23904776e-02f, -1.14638396e-02f, 2.96889506e-02f, -1.18741736e-01f,
  9.02328044e-02f, -8.86271149e-02f, -8.88921693e-02f, 2.18448266e-02f, -1.03849083e-01f, 9.32676252e-03f, -5.46128489e-02f, 1.29756816e-02f, -1.26252219e-01f, 5.02506271e-02f,
  1.05075993e-01f, 4.90782112e-02f, -9.63190570e-03f, 1.47253396e-02f, -7.95928612e-02f, -9.59942192e-02f, -7.94743448e-02f, -1.18823849e-01f, 2.77837086e-02f, 4.29825895e-02f,
  1.61337499e-02f, -5.88658229e-02f, 7.28912605e-03f, 4.17438373e-02f, -2.95729563e-02f, 5.03361635e-02f, 8.18582028e-02f, 1.01040378e-01f, 8.01319182e-02f, -4.34830273e-03f,
  -2.81535268e-01f, -4.76778410e-02f, 1.26760423e-01f, -1.38802260e-01f, -1.03577804e-02f, 1.13897681e-01f, 1.66594967e-01f, -2.79085543e-02f, -1.32481694e-01f, -3.63300219e-02f,
  7.43586794e-02f, -1.52199581e-01f, 7.41527928e-03f, 5.09170592e-02f, -4.29758942e-03f, -5.97290322e-02f, 1.87545462e-04f, -4.96991118e-03f, -1.18366862e-02f, 4.88439836e-02f,
  -9.82348770e-02f, -1.47507519e-01f, 5.15238149e-03f, -4.31333631e-02f, -7.40055889e-02f, -1.80488110e-01f, 4.53300476e-02f, -6.29766062e-02f, 1.00680202e-01f, -1.75812319e-01f,
  -6.54588491e-02f, -3.79773378e-02f, 2.73275953e-02f, -8.31582118e-03f, -2.43384615e-02f, -7.26464763e-02f, 8.38498175e-02f, 1.69052612e-02f, 7.09203333e-02f, -8.97782948e-03f,
  -1.49979945e-02f, 2.71832123e-02f, -1.03385530e-01f, -4.07145992e-02f, 3.26690376e-02f, -6.06763400e-02f, -9.80624557e-03f, 5.12845069e-02f, 1.45097030e-02f, 9.99032557e-02f,
  2.55506244e-02f, 8.19429308e-02f, -5.28461374e-02f, -6.37667580e-03f, 8.94285664e-02f, -1.80262644e-02f, 2.57410631e-02f, -1.15244403e-01f, -5.84237860e-04f, -1.15734622e-01f,
  3.81871648e-02f, 3.01407296e-02f, 6.03499152e-02f, -4.68217693e-02f, 3.85599919e-02f, -6.29288480e-02f, 2.56374362e-03f, 5.23827821e-02f, -2.89887730e-02f, -1.07583702e-01f,
  1.99268218e-02f, 7.55905956e-02f, -3.69876437e-02f, -7.00167567e-02f, 1.04919402e-02f, 7.46805146e-02f, 9.25507545e-02f, -5.14618196e-02f, -1.11677879e-02f, -4.63480540e-02f,
  -5.23780473e-02f, 3.14791352e-02f, -5.75171150e-02f, 3.28104347e-02f, 3.82871032e-02f, 7.82436654e-02f, -4.12496226e-03f, -1.97006054e-02f, -3.01986132e-02f, 1.47682475e-02f,
  -2.79948026e-01f, 2.83960968e-01f, -1.19947851e-01f, -1.48410514e-01f, 3.74641567e-02f, 1.54471509e-02f, -9.40953791e-02f, 1.17129870e-02f, -2.59323493e-02f, 1.69075821e-02f,
  1.06033348e-01f, 3.88658717e-02f, -6.92961589e-02f, -5.41854165e-02f, -6.24025390e-02f, 4.00432153e-03f, -7.74584785e-02f, 3.11212111e-02f, -5.77177778e-02f, -6.50203824e-02f,
  -6.23784736e-02f, -8.29065293e-02f, -1.71126604e-01f, -1.32647231e-01f, -1.24414086e-01f, -9.28482935e-02f, -3.58278006e-02f, -4.44105007e-02f, -3.10423076e-02f, -1.60948977e-01f,
  -2.39487082e-01f, 3.39770950e-02f, -9.03957933e-02f, -2.21947402e-01f, -7.70881446e-03f, 8.41315612e-02f, 1.09060138e-01f, 1.07601173e-01f, -7.00296983e-02f, 2.35321373e-02f,
  5.02062291e-02f, -9.36924741e-02f, -8.16215798e-02f, 6.88722031e-03f, 6.95593059e-02f, 6.59394078e-03f, -9.43154991e-02f, -5.55703491e-02f, 5.38103320e-02f, 4.12636884e-02f,
  5.81149012e-02f, -5.90979829e-02f, -1.75908774e-01f, -1.35456145e-01f, 1.61471199e-02f, -8.42699558e-02f, -8.51598084e-02f, -7.99455270e-02f, -4.89115305e-02f, 1.23628704e-02f,
  1.67613924e-01f, -1.37977421e-01f, 6.88841101e-03f, -1.15957811e-01f, 7.12826401e-02f, 2.22677365e-02f, -8.11509714e-02f, -3.37672234e-02f, -9.94331837e-02f, -3.12022609e-03f,
  5.41082583e-02f, 8.69257655e-03f, -5.16987927e-02f, 5.93449473e-02f, -2.24060323e-02f, 3.67772207e-02f, 6.37316555e-02f, -1.02830641e-01f, -6.62988052e-02f, 1.00570343e-01f,
  -2.00949106e-02f, -9.38722305e-03f, -2.54055839e-02f, 4.51116860e-02f, -4.40473743e-02f, -4.64446172e-02f, 1.24620594e-01f, 4.51802202e-02f, 3.18947136e-02f, -6.48228675e-02f,
  1.61889829e-02f, -5.12566604e-02f, -3.32676582e-02f, -7.17002749e-02f, 4.76012230e-02f, -3.56023274e-02f, 1.17738480e-02f, -4.55686683e-03f, 4.90210652e-02f, 9.30948183e-02f,
  -2.31888480e-02f, -3.72886658e-02f, 3.56836803e-02f, -6.41885847e-02f, -1.55019516e-03f, -7.91845396e-02f, 8.09044465e-02f, 5.11744712e-03f, -2.47879438e-02f, -5.55793829e-02f,
  4.48189070e-03f, 3.98596823e-02f, 3.70621309e-02f, 3.21562998e-02f, 6.27036020e-02f, 4.60706241e-02f, 5.26148006e-02f, 3.40013392e-02f, 6.60063773e-02f, -4.47858796e-02f,
  -3.79100703e-02f, -6.31782934e-02f, 4.04860787e-02f, -7.47719780e-02f, -5.28751388e-02f, 6.56055808e-02f, -5.39715681e-03f, -3.33799645e-02f, 4.27892879e-02f, 2.94098388e-02f,
  -3.66581269e-02f, 3.32701392e-02f, 8.97249952e-02f, -4.92103361e-02f, -3.71727236e-02f, 3.47627625e-02f, 7.44106844e-02f, -3.58652174e-02f, 3.63572314e-02f, 6.04449287e-02f,
  3.81517448e-02f, 7.67293498e-02f, 7.26996288e-02f, -5.89355007e-02f, -3.33896354e-02f, -5.13502657e-02f, -9.89732426e-03f, 3.11699156e-02f, 6.60847733e-03f, -9.14768432e-04f,
  1.53048769e-01f, 8.41796994e-02f, -8.42494369e-02f, 3.72579843e-02f, 3.12785879e-02f, -1.84077665e-01f, -1.97479248e-01f, -5.18303104e-02f, 7.29132891e-02f, -6.82204962e-03f,
  3.41629125e-02f, 4.31846920e-03f, 4.71740551e-02f, 1.98262576e-02f, -2.22334769e-02f, -3.67849320e-02f, 1.55216418e-02f, 3.80000919e-02f, -5.36605641e-02f, -2.31519174e-02f,
  8.14560428e-02f, 1.70776732e-02f, 9.20234397e-02f, -8.58310331e-03f, 3.62369530e-02f, 4.01896276e-02f, -5.40920608e-02f, 1.04193255e-01f, 8.19524527e-02f, 1.72524020e-01f,
  1.66117147e-01f, -1.11436928e-02f, 2.73606814e-02f, 9.75226536e-02f, 1.28763184e-01f, -1.99888609e-02f, -2.50041727e-02f, 3.28325741e-02f, -9.06989574e-02f, 6.10018661e-03f,
  -2.50549819e-02f, 8.51132795e-02f, 7.32421502e-02f, 2.14221813e-02f, 6.79606050e-02f, 2.68062707e-02f, -2.59517822e-02f, -1.10575836e-02f, -8.78317747e-03f, -4.51194793e-02f,
  -1.08273672e-02f, 1.23107933e-01f, -3.12654153e-02f, -9.90381390e-02f, -4.06887978e-02f, 7.57017173e-03f, -4.16316502e-02f, 3.33286934e-02f, -1.21011376e-01f, -4.53966968e-02f,
  2.67749541e-02f, 1.70948915e-02f, -1.35342153e-02f, -2.24612653e-02f, 7.60775954e-02f, 5.35487160e-02f, -4.08092886e-02f, -1.58996657e-02f, 2.45412521e-04f, 4.89667468e-02f,
  3.69724035e-02f, 6.26089424e-02f, -4.40142490e-02f, 5.92944808e-02f, 2.69991048e-02f, 9.97211635e-02f, -4.16924283e-02f, -5.73150702e-02f, 6.76373467e-02f, 2.69494411e-02f,
  9.35304444e-03f, 1.18265841e-02f, 4.95688692e-02f, 2.81159189e-02f, -8.54132250e-02f, 7.43318945e-02f, 8.14057589e-02f, 3.40127200e-02f, -5.46977222e-02f, 9.41378400e-02f,
  -6.75811544e-02f, -1.52663723e-01f, 7.44957626e-02f, -3.34682912e-02f, -6.33489639e-02f, -1.32605014e-02f, 5.26070148e-02f, -8.59955698e-02f, 6.02164567e-02f, -8.09257701e-02f,
  6.78931102e-02f, -5.18145263e-02f, 5.01170196e-02f, 6.81153219e-03f, 5.88339986e-03f, -8.78593102e-02f, 1.07108885e-02f, 5.29201590e-02f, -1.20484367e-01f, -1.33174928e-02f,
  -1.30746976e-01f, -1.16989650e-01f, -1.31490692e-01f, -1.33449554e-01f, -5.22618070e-02f, -9.80911106e-02f, -1.07673280e-01f, -1.18899234e-01f, -5.28917648e-02f, -1.20518886e-01f,
  -2.44176775e-01f, -2.35066310e-01f, -1.67146832e-01f, -2.33887672e-01f, -8.30822214e-02f, 7.82259461e-03f, -1.58604652e-01f, -8.91705335e-04f, 3.61221023e-02f, -2.25178868e-01f,
  -9.87798795e-02f, -4.78608813e-03f, -6.88925982e-02f, -5.57417870e-02f, -4.71525155e-02f, -2.32690126e-01f, -2.36633524e-01f, 1.64247602e-02f, 5.34400158e-02f, 1.28971368e-01f,
  1.36860637e-02f, -2.87073087e-02f, -7.60901570e-02f, -5.01237139e-02f, 3.99996905e-04f, 8.57012272e-02f, -1.56652302e-01f, -5.56535609e-02f, 5.33803590e-02f, -6.60263821e-02f,
  -1.15118012e-01f, -1.24056116e-02f, 4.49851565e-02f, 8.90333485e-03f, -3.92007418e-02f, 9.46319699e-02f, -7.66081437e-02f, -3.73517685e-02f, -1.89959165e-02f, -7.40996152e-02f,
  -5.20473495e-02f, -1.85232516e-02f, 5.77775910e-02f, 5.37730716e-02f, 2.44113244e-02f, 6.27031773e-02f, -6.74906299e-02f, 9.06012952e-02f, 9.35661569e-02f, 2.33299658e-02f,
  -5.44562079e-02f, -4.99198996e-02f, 8.78291354e-02f, 1.41367661e-02f, 1.09509990e-01f, 8.81726369e-02f, 2.48971973e-02f, 1.87008783e-01f, 3.66334207e-02f, -1.18957879e-02f,
  -1.73083283e-02f, 1.05484977e-01f, 9.75280348e-03f, -6.14634641e-02f, 2.82880776e-02f, -4.08568084e-02f, -4.39030379e-02f, 8.82594753e-03f, 7.11876824e-02f, -1.06387064e-01f,
  -2.78211269e-03f, -1.02706954e-01f, 5.85248992e-02f, -6.35577068e-02f, -1.22090653e-02f, -8.97783611e-04f, -1.17224986e-02f, -5.97453602e-02f, 3.12847123e-02f, -1.14578824e-03f,
  -4.11164714e-03f, 5.51806428e-02f, -4.33454290e-02f, 8.68450925e-02f, 5.82141802e-02f, -7.59184510e-02f, 5.12932539e-02f, 1.10924087e-01f, 1.22991540e-02f, 1.72697026e-02f,
  -1.21894255e-01f, 1.13986880e-01f, -1.10881224e-01f, 5.61128650e-03f, 1.21901250e-02f, 1.04058711e-02f, -9.95789021e-02f, 1.11351736e-01f, 5.56043796e-02f, -5.77256940e-02f,
  1.56690836e-01f, 4.18417752e-02f, -1.19019516e-01f, -2.33695246e-02f, 4.70990352e-02f, 1.14503251e-02f, -3.66503075e-02f, 2.85360832e-02f, -3.73280570e-02f, -8.49468634e-03f,
  -3.99290174e-02f, -7.72601292e-02f, -1.62468582e-01f, 4.30184193e-02f, -1.65807345e-04f, -2.70094778e-02f, -4.84007671e-02f, -3.34245674e-02f, -6.11529462e-02f, -1.24725051e-01f,
  4.00795639e-01f, 2.13394254e-01f, 2.61752397e-01f, 8.61831680e-02f, 2.00264215e-01f, 1.66404709e-01f, 3.20221275e-01f, 1.73244178e-01f, 8.53999034e-02f, 1.55055329e-01f,
  7.03969970e-02f, -1.71192825e-01f, -7.09648579e-02f, -4.26586643e-02f, 2.35017929e-02f, -3.51446308e-02f, -2.00202148e-02f, 1.23821115e-02f, 4.70981821e-02f, 7.31925368e-02f,
  -1.00039378e-01f, -6.25189096e-02f, 1.15787379e-01f, 2.16012690e-02f, -1.01145012e-02f, -8.63349736e-02f, 5.28329089e-02f, -6.28105039e-03f, 6.63078651e-02f, -1.22783475e-01f,
  -1.05179276e-03f, 3.02187562e-01f, -1.47801802e-01f, -5.32903336e-02f, 2.61270180e-02f, -1.22384183e-01f, -1.66775249e-02f, -1.08430117e-01f, -8.91231075e-02f, -4.03911211e-02f,
  3.76841575e-02f, -9.31947231e-02f, 3.26804705e-02f, 1.05325785e-02f, 7.63347894e-02f, -4.59837615e-02f, -9.86798257e-02f, -1.76817141e-02f, 7.97855332e-02f, 1.11793578e-01f,
  -1.31733909e-01f, 1.44065097e-01f, 1.68989792e-01f, 8.83603320e-02f, 5.48187792e-02f, -3.85005288e-02f, 6.26408979e-02f, 5.96241057e-02f, -6.61296621e-02f, -1.32327834e-02f,
  -6.13501834e-05f, 5.23598641e-02f, 8.23293999e-02f, -4.70692664e-02f, 5.92567585e-02f, -3.50166075e-02f, -3.40635963e-02f, -4.32420075e-02f, 1.00763366e-01f, 5.28087839e-02f,
  -4.35334705e-02f, 1.71512105e-02f, 5.27523309e-02f, 1.10830721e-02f, -5.41222729e-02f, 3.26923132e-02f, 4.26454693e-02f, -3.36578786e-02f, 1.96798313e-02f, 2.74344180e-02f,
  8.93577933e-03f, 5.67567758e-02f, 2.98581040e-03f, -1.00643728e-02f, -6.59146756e-02f, 5.09336479e-02f, -4.32168059e-02f, -5.90865128e-02f, 4.92684580e-02f, 4.83132899e-02f,
  -1.66119114e-01f, 1.85825914e-01f, -4.68718000e-02f, -8.29082653e-02f, -5.24237566e-02f, -6.49630502e-02f, 7.62183219e-02f, 4.22963826e-03f, -8.71673040e-03f, -6.09209649e-02f,
  -3.29966098e-03f, -4.45701405e-02f, 9.92151871e-02f, -4.82084230e-02f, -3.39808166e-02f, -2.83731390e-02f, -8.03495944e-02f, 4.43026200e-02f, 1.32694943e-02f, -7.28009865e-02f,
  -6.09532483e-02f, -7.57310614e-02f, 6.57124147e-02f, 2.04717554e-02f, 1.68400202e-02f, 2.55276952e-02f, -2.66126189e-02f, 7.62091437e-03f, 3.52998078e-02f, -6.85232505e-02f,
  -6.53634174e-03f, 8.56747031e-02f, 5.87806515e-02f, 2.18148798e-01f, 3.85527983e-02f, -7.90615231e-02f, -1.57682016e-01f, -1.39540538e-01f, -6.21660091e-02f, -3.35507840e-02f,
  2.66387183e-02f, -5.06810248e-02f, -6.76806867e-02f, -8.17171410e-02f, -1.04707435e-01f, -1.16178863e-01f, -6.77145272e-02f, -1.50424257e-01f, -1.57353029e-01f, -1.18241169e-01f,
  4.22410332e-02f, 2.15565786e-02f, -1.01095118e-01f, -5.65690398e-02f, 1.24236062e-01f, 5.57896681e-02f, -5.21732792e-02f, 9.12918225e-02f, -9.42313969e-02f, 1.48950651e-01f,
  4.26626503e-02f, 1.31145045e-01f, -2.43646465e-03f, -2.72295438e-03f, 1.25088245e-01f, 1.68095641e-02f, 9.11142677e-02f, 6.25153631e-02f, 1.15395419e-01f, -3.47237587e-02f,
  2.53519192e-02f, 6.88663051e-02f, 7.03754183e-03f, -5.91470152e-02f, 3.06455623e-02f, -7.16079026e-02f, -9.57231075e-02f, -1.05918646e-01f, 4.21230271e-02f, 8.06283429e-02f,
  9.00720358e-02f, 1.05256699e-01f, -4.34040241e-02f, -9.31581855e-02f, -1.07192285e-01f, 8.39336589e-03f, -8.61702263e-02f, -6.62751794e-02f, -1.48914471e-01f, -8.60688910e-02f,
  -1.16659328e-02f, 3.51189673e-02f, 2.73010414e-02f, -2.23726896e-03f, 6.08192757e-02f, 2.59069223e-02f, 1.99461449e-02f, 7.02173635e-02f, -3.07325879e-03f, 2.41150660e-03f,
  -3.95296440e-02f, 7.38772899e-02f, 3.88292037e-02f, 4.61931974e-02f, 5.35536930e-02f, 5.50414920e-02f, 5.74308671e-02f, 5.08254543e-02f, -6.76057041e-02f, -2.47215908e-02f,
  3.67891192e-02f, -5.03446907e-02f, 1.30392045e-01f, -4.23828997e-02f, 6.83966056e-02f, 1.74682345e-02f, -3.02116740e-02f, 1.09585479e-01f, 9.73372441e-03f, 1.27930999e-01f,
  1.03420757e-01f, -6.39217645e-02f, 6.03402586e-05f, -1.21302500e-01f, -6.32728711e-02f, 3.20698880e-02f, 1.22069560e-01f, 5.54870516e-02f, 1.22361526e-01f, 4.16477993e-02f,
  5.69218360e-02f, 6.73167855e-02f, 2.65443455e-02f, 8.85438826e-03f, -1.05178453e-01f, 1.99529883e-02f, 5.64755797e-02f, -5.58491498e-02f, -1.26119107e-01f, -5.42374179e-02f,
  -2.88777538e-02f, 1.50004591e-04f, -1.37229845e-01f, -7.64584914e-02f, -4.00781594e-02f, 2.07316764e-02f, -8.64469782e-02f, -8.46580639e-02f, -5.73127531e-02f, -9.43616778e-02f,
  3.08854971e-02f, -1.94940537e-01f, 1.31278679e-01f, 1.36350496e-02f, -5.71137741e-02f, 1.34965684e-02f, -1.70069948e-01f, -1.51590660e-01f, 2.58428231e-02f, -1.06327944e-01f,
  7.31471181e-02f, 1.02493048e-01f, 1.43713102e-01f, 1.29150078e-01f, 1.35999352e-01f, -8.32000151e-02f, -5.86363561e-02f, 1.27674773e-01f, 1.47960603e-01f, -1.68423802e-02f,
  4.51925620e-02f, -6.09161705e-03f, -5.12807863e-03f, 3.03802416e-02f, -1.07106321e-01f, 1.29222527e-01f, -3.03339795e-03f, 6.01209849e-02f, 5.14296666e-02f, -1.36621147e-01f,
  7.27055445e-02f, -8.16021860e-02f, 6.72157481e-02f, -1.92743242e-02f, -6.51844367e-02f, -3.18082958e-03f, -6.30027726e-02f, 3.04804910e-02f, 1.06801353e-02f, 3.62887457e-02f,
  -4.15151194e-02f, 4.73657846e-02f, -6.19950034e-02f, -6.98842257e-02f, -3.10737602e-02f, -3.22305709e-02f, 2.37057544e-02f, 7.02134743e-02f, 3.72941084e-02f, -3.89682539e-02f,
  -1.37148770e-02f, 1.14630787e-02f, -5.10570966e-03f, -1.31158158e-02f, 9.50291082e-02f, 3.09014749e-02f, -5.24218753e-02f, -8.99012089e-02f, -4.67811823e-02f, -2.09960126e-05f,
  1.14741899e-01f, 1.51800038e-02f, 5.61307557e-02f, -5.69466650e-02f, -2.87165772e-02f, 5.89307137e-02f, -4.95660454e-02f, 1.75545923e-02f, -1.03588238e-01f, 3.13303173e-02f,
  -7.47667626e-02f, -1.99682023e-02f, -4.84255515e-02f, 2.27456670e-02f, -4.94207479e-02f, -1.26621276e-01f, 7.33686611e-02f, 1.40917988e-03f, 9.03265085e-03f, -1.11291058e-01f,
  -9.79536995e-02f, -2.91837044e-02f, 2.79573742e-02f, -5.06171063e-02f, 2.41955668e-02f, 1.74120199e-02f, -2.03028973e-02f, 2.58660764e-02f, -2.94343587e-02f, -4.04701009e-02f,
  5.44973798e-02f, 1.28325298e-01f, -5.74678630e-02f, 1.13572730e-02f, -1.43921338e-02f, -1.71335693e-02f, 3.20141949e-02f, 7.09737986e-02f, -6.73476905e-02f, -1.57123655e-02f,
  6.67802766e-02f, -1.61574744e-02f, 6.10540733e-02f, 3.48808020e-02f, 7.51926601e-02f, -6.41730353e-02f, -6.50895014e-02f, 1.52125090e-01f, -2.43198890e-02f, -6.36182129e-02f,
  -8.86185840e-02f, 7.78539777e-02f, 2.59535089e-02f, 1.01811048e-02f, 3.06679700e-02f, 1.65228009e-01f, 1.22696102e-01f, 5.75242490e-02f, 9.30778310e-02f, 4.08549942e-02f,
  -2.42229588e-02f, -7.08132423e-03f, 3.51499170e-02f, -1.20187141e-01f, 3.06779034e-02f, 8.44095722e-02f, -4.26837895e-03f, -4.49011475e-02f, -6.44896105e-02f, 7.73890838e-02f,
  3.93997468e-02f, 8.70547742e-02f, -4.69863368e-03f, 5.76126762e-02f, -4.05524820e-02f, -5.43047972e-02f, -8.57587829e-02f, -1.65078491e-02f, 5.43561652e-02f, 7.07394481e-02f,
  3.22124697e-02f, 2.55239364e-02f, -5.39715998e-02f, -9.67674181e-02f, 2.39079949e-02f, -8.84473994e-02f, -4.18681577e-02f, 6.08504005e-02f, -8.60745274e-03f, -2.99966298e-02f,
  7.96238035e-02f, -9.47465822e-02f, -2.66080219e-02f, 3.32539976e-02f, -8.20143446e-02f, -3.13847698e-02f, 8.83239582e-02f, -8.69174898e-02f, -5.64057343e-02f, -1.16358744e-02f,
  8.24274495e-02f, -7.79487938e-02f, -1.79270785e-02f, -4.14435156e-02f, 4.76685911e-02f, 2.79106628e-02f, -7.59710670e-02f, -4.46055271e-02f, 3.09017375e-02f, 9.25942417e-03f,
  -2.35836711e-02f, -6.69629313e-03f, 4.25313786e-03f, -6.56128628e-03f, -2.51800828e-02f, -1.01159491e-01f, -4.73979674e-02f, -1.60860959e-02f, 3.49859297e-02f, 7.69179612e-02f,
  5.03670722e-02f, -2.64564138e-02f, 3.56680714e-02f, -4.55879308e-02f, 2.84916628e-02f, -1.69578120e-02f, -6.83722347e-02f, -2.29481347e-02f, 8.19516256e-02f, -4.49559912e-02f,
  -1.49576776e-02f, -8.35830644e-02f, 7.59013966e-02f, 7.90866092e-02f, 1.00018214e-02f, -7.32822865e-02f, 9.24394093e-03f, -7.06538372e-03f, 6.01330101e-02f, 4.99742888e-02f,
  -2.54346859e-02f, -4.74228291e-03f, 9.72173084e-03f, -3.75579931e-02f, 3.41822468e-02f, -3.66408974e-02f, -3.97832841e-02f, 3.27775963e-02f, 2.34899903e-03f, -2.87582986e-02f,
  1.33793339e-01f, -8.54095370e-02f, 1.11681484e-02f, 8.31290381e-04f, -5.29033579e-02f, 3.23098488e-02f, -5.42352498e-02f, 1.88506152e-02f, -3.00986804e-02f, -6.61707744e-02f,
  3.92849147e-02f, -4.52193506e-02f, -2.11546551e-02f, -3.44919227e-02f, -6.14863820e-02f, 4.75677215e-02f, -1.88630745e-02f, 3.32175307e-02f, 5.99010475e-02f, 7.04201460e-02f,
  -5.99156469e-02f, 7.40394667e-02f, -5.39277345e-02f, -7.23360758e-03f, 2.66619585e-02f, 3.08824051e-02f, 2.26802565e-02f, 6.98781833e-02f, -6.86184764e-02f, -3.07839047e-02f,
  -1.14951180e-02f, -5.51372580e-02f, -8.08257144e-03f, -1.07972652e-01f, -9.36283767e-02f, 8.61058310e-02f, 3.71577474e-03f, -9.90248169e-04f, -3.90922725e-02f, 5.51507361e-02f,
  4.21403907e-02f, 6.68187859e-03f, -5.84923523e-03f, -2.48167524e-03f, -8.11710060e-02f, -2.48182919e-02f, 8.30603205e-03f, 3.69487819e-03f, -8.15418735e-02f, -5.13799563e-02f,
  6.55905828e-02f, -9.01240036e-02f, -1.13353811e-01f, -1.26361316e-02f, 7.19183013e-02f, -7.44810253e-02f, 1.31137129e-02f, 3.32702547e-02f, 4.92363125e-02f, 7.26111457e-02f,
  3.04657668e-02f, 5.05705029e-02f, -6.86431080e-02f, -7.60976002e-02f, -1.96108501e-03f, 7.31872469e-02f, -1.00578936e-02f, -9.74020511e-02f, -6.63348213e-02f, 5.38991392e-02f,
  8.61572921e-02f, -5.62472530e-02f, -3.44811864e-02f, 4.94979061e-02f, -3.90797630e-02f, 1.84528008e-02f, 8.01115483e-02f, 2.49997955e-02f, 7.25555420e-02f, -2.57078577e-02f,
  6.18482083e-02f, 9.14620534e-02f, -5.95782325e-02f, 1.49404844e-02f, -1.42321382e-02f, -7.32903406e-02f, 1.04849972e-01f, 6.69502094e-02f, 5.23481192e-03f, -3.32543775e-02f,
  -3.35031822e-02f, -5.25429063e-02f, 8.55627432e-02f, -7.14328438e-02f, -2.88381819e-02f, 6.84900358e-02f, -4.54329178e-02f, 7.48284161e-02f, -5.47761247e-02f, 3.43708582e-02f,
  3.94837707e-02f, -5.77859320e-02f, -1.92409363e-02f, 2.36353669e-02f, -1.83286462e-02f, 2.98048761e-02f, 2.96123605e-02f, -4.54362556e-02f, 2.10819840e-02f, 6.65472969e-02f,
  6.87245354e-02f, 8.22340697e-02f, -4.77838534e-04f, -4.42472547e-02f, 2.05874275e-02f, -2.76684705e-02f, 3.90346497e-02f, -5.52357957e-02f, -2.83185877e-02f, -6.22391663e-02f,
  -8.00315365e-02f, 1.15461210e-02f, -8.74191523e-02f, 4.09062617e-02f, -7.80833140e-02f, 5.55093810e-02f, 2.24986728e-02f, 2.66935192e-02f, -9.38204955e-03f, -8.67256001e-02f,
  -6.78338259e-02f, -3.93242724e-02f, -5.45146540e-02f, 1.32998936e-02f, -5.64544797e-02f, 3.19997929e-02f, 7.08989128e-02f, 9.18835495e-03f, 4.09075767e-02f, -4.30043340e-02f,
  6.23006374e-02f, -5.38593205e-03f, 3.83689962e-02f, 5.39462753e-02f, 8.32388848e-02f, -5.43663874e-02f, -6.35245591e-02f, 8.96032378e-02f, -1.70188826e-02f, 7.06266686e-02f,
  1.11123323e-01f, 6.77538663e-02f, -8.74015316e-02f, 7.07304031e-02f, -4.36291732e-02f, 4.15041745e-02f, -1.44180404e-02f, 7.34597594e-02f, 1.27558663e-01f, 1.46858484e-01f,
  1.06759459e-01f, -5.96652040e-04f, -1.42371714e-01f, -9.96679440e-02f, -6.86127692e-02f, -3.77810411e-02f, -1.38574049e-01f, -1.79632664e-01f, -2.01797873e-01f, -1.31343752e-01f,
  -4.15448137e-02f, 7.72875547e-02f, -4.59707081e-02f, 2.44021602e-02f, -1.78432669e-02f, 4.44398336e-02f, 7.94488192e-03f, 2.91180052e-02f, -6.60931095e-02f, -4.30258289e-02f,
  -1.39383061e-04f, -2.21982156e-03f, -1.55691326e-01f, -9.08347443e-02f, 7.13103563e-02f, -7.03353360e-02f, -9.11337975e-03f, 8.84719100e-03f, -5.35338335e-02f, -2.79491825e-04f,
  -9.10416767e-02f, -8.10014606e-02f, 6.60222257e-03f, -4.43339273e-02f, -9.63326171e-02f, 2.22572908e-02f, -1.53718609e-03f, -7.24256560e-02f, -7.78353363e-02f, -5.23138419e-02f,
  2.98599489e-02f, -2.52610799e-02f, 3.95581052e-02f, 4.81070504e-02f, -8.53985548e-02f, -1.03748463e-01f, -7.60519579e-02f, -1.52169261e-02f, 2.03962550e-02f, -4.52820621e-02f,
  -7.95682296e-02f, -3.30339856e-02f, 4.83866073e-02f, 1.02418549e-01f, 3.77306081e-02f, 1.33016929e-02f, -3.69751491e-02f, 2.45991256e-02f, -6.34829104e-02f, -3.71198580e-02f,
  -5.96838184e-02f, 1.84374396e-02f, -4.02270220e-02f, -3.34913395e-02f, -5.31066842e-02f, 5.56697585e-02f, -7.09647685e-02f, -1.28693124e-02f, 2.15766691e-02f, -3.90911736e-02f,
  -3.88174765e-02f, 2.33858917e-02f, 3.84456180e-02f, -8.25705826e-02f, 6.68145269e-02f, 4.84952666e-02f, 3.40517722e-02f, 2.13841684e-02f, 5.82454391e-02f, -5.61731830e-02f,
  9.59508494e-02f, 1.68733951e-02f, -6.26369044e-02f, -1.12719178e-01f, -6.84875110e-03f, 6.00334965e-02f, 3.09395585e-02f, 1.33851720e-02f, 2.94951126e-02f, 1.60131771e-02f,
  -2.33707987e-02f, -1.30411372e-01f, 5.26733026e-02f, 5.53748047e-04f, -1.16713820e-02f, 1.99144986e-02f, -4.08786386e-02f, 5.47477677e-02f, -9.67978314e-03f, 8.85128751e-02f,
  7.15984106e-02f, -1.47162126e-02f, -3.34828123e-02f, -4.57631275e-02f, 3.74038704e-02f, -8.82813111e-02f, 5.63023463e-02f, -6.74217418e-02f, -2.79749408e-02f, 2.92317290e-02f,
  -1.52514264e-01f, -3.20270322e-02f, -2.42078587e-01f, -6.42515644e-02f, -7.50020072e-02f, 4.24529724e-02f, 1.02171004e-02f, 9.24381837e-02f, 1.16854738e-02f, -1.22804672e-01f,
  -8.31181481e-02f, -6.03166670e-02f, -1.03720926e-01f, -9.09625441e-02f, -8.21207687e-02f, -1.73131645e-01f, -1.81955293e-01f, -2.40423813e-01f, -1.64783269e-01f, -4.93931063e-02f,
  6.28116727e-02f, -2.09345788e-01f, -3.12239770e-02f, -6.34186789e-02f, -7.52642425e-03f, -1.50633037e-01f, -1.41206264e-01f, -1.95919380e-01f, -7.20225945e-02f, -3.10509831e-01f,
  -3.59674811e-01f, -4.97465730e-02f, 9.10276454e-03f, -8.28680620e-02f, -5.28504588e-02f, -6.71485364e-02f, -5.46700843e-02f, -7.76793882e-02f, -3.20176571e-03f, 2.90654693e-02f,
  -1.21764511e-01f, 1.07523603e-02f, -5.03595099e-02f, -3.40518877e-02f, -3.68285626e-02f, -8.26396272e-02f, -4.00808118e-02f, -1.30017158e-02f, -1.00224450e-01f, -2.87898034e-02f,
  4.00635637e-02f, -1.31179601e-01f, -1.59344330e-01f, 4.93703783e-02f, 8.58491845e-03f, -3.01421154e-02f, -2.29670536e-02f, 8.99655148e-02f, 1.70738008e-02f, 6.15758225e-02f,
  2.49811821e-02f, 9.82456934e-03f, 8.28777533e-03f, 8.13608617e-03f, 4.29852940e-02f, -3.12040914e-02f, -3.43721882e-02f, 7.02145323e-02f, 4.47271913e-02f, 7.54949171e-03f,
  1.22578451e-02f, 1.29868835e-01f, 1.61881167e-02f, -2.79369019e-02f, 5.34043275e-02f, -6.04712293e-02f, 2.95574293e-02f, -2.95671374e-02f, -4.03252877e-02f, -4.97117154e-02f,
  -7.21578822e-02f, -2.84628496e-02f, -2.26473785e-03f, -6.42392337e-02f, 4.88723814e-03f, -3.82467695e-02f, 7.31434748e-02f, 2.41816044e-02f, -2.63302643e-02f, 3.43243331e-02f,
  -3.21973749e-02f, 2.54724943e-03f, -9.03366059e-02f, -7.59598857e-04f, -1.15756951e-01f, -3.63057256e-02f, -7.01883212e-02f, 4.37564626e-02f, -4.65761870e-02f, -1.55506097e-02f,
  -2.12172661e-02f, 4.75366563e-02f, -2.69404724e-02f, 3.73784564e-02f, 1.21390484e-02f, 4.03181277e-02f, 4.75705899e-02f, -7.88783506e-02f, 3.33708152e-02f, 1.62457138e-01f,
  1.15316726e-01f, 7.38252029e-02f, -1.77269075e-02f, 1.50925107e-02f, -2.11928207e-02f, -3.44175734e-02f, -5.48358224e-02f, 1.59850456e-02f, -4.48007286e-02f, 7.75632188e-02f,
  3.44313122e-03f, 5.67219295e-02f, 2.59700231e-02f, 1.05952471e-01f, -1.56824552e-02f, -1.07500181e-01f, -8.97694230e-02f, -6.33123443e-02f, 6.76987618e-02f, 4.08542939e-02f,
  -2.14883722e-02f, -8.36278945e-02f, -1.27012864e-01f, -1.29712388e-01f, -5.09279966e-02f, 3.91372554e-02f, 4.94210459e-02f, -1.25953868e-01f, -1.66748181e-01f, -5.03057837e-02f,
  -6.06060447e-03f, -2.70989481e-02f, -5.41699603e-02f, -4.91930358e-02f, 2.59707100e-03f, -7.89218917e-02f, -2.94175483e-02f, -4.19013128e-02f, -1.36693381e-02f, 8.29120353e-02f,
  -4.57388088e-02f, 8.52612108e-02f, -7.45775551e-02f, 2.48118341e-02f, 1.02615714e-01f, 9.70518067e-02f, -1.95578877e-02f, 8.12427402e-02f, 6.26646122e-03f, 4.91272397e-02f,
  4.53484319e-02f, 1.39926681e-02f, 4.04124931e-02f, -6.64984882e-02f, -7.74497762e-02f, -1.39642367e-02f, 8.66852701e-02f, -2.27099359e-02f, 4.59817015e-02f, -4.01222259e-02f,
  7.10281283e-02f, -9.66858044e-02f, 3.84382419e-02f, 7.53420591e-02f, -3.45457494e-02f, -8.86748955e-02f, 6.36745691e-02f, -6.69625551e-02f, 1.61282122e-02f, 9.58917439e-02f,
  4.23762500e-02f, 7.47279674e-02f, -8.06368887e-03f, -2.84713954e-02f, 1.67927947e-02f, 5.69054224e-02f, -1.37183340e-02f, 7.03521445e-02f, -7.59253129e-02f, -2.30205879e-02f,
  -3.19259539e-02f, 1.01840824e-01f, -2.51068845e-02f, 4.55057919e-02f, 5.48381470e-02f, 5.71984500e-02f, -3.80781107e-02f, -5.58857881e-02f, 9.81210917e-02f, -6.48191050e-02f,
  4.99467775e-02f, -3.93018834e-02f, 2.10684780e-02f, 7.05931634e-02f, 6.35528043e-02f, 4.51928377e-02f, -8.65149722e-02f, -9.11060646e-02f, -1.26665144e-03f, -8.49427879e-02f,
  -1.24031426e-02f, -1.12733617e-01f, 1.01419419e-01f, -9.54607353e-02f, 4.37513925e-03f, 4.08594646e-02f, -3.58000733e-02f, 5.39364144e-02f, -2.05332097e-02f, 8.03118348e-02f,
  3.53932083e-02f, -3.88447903e-02f, 6.85708225e-02f, 2.82657258e-02f, -1.41785787e-02f, 4.22780886e-02f, 2.02300940e-02f, 4.76113148e-02f, -1.13204554e-01f, 5.75482175e-02f,
  -1.27079599e-02f, -3.78408171e-02f, 4.61101206e-03f, 4.14777659e-02f, 8.98265094e-02f, -3.32000330e-02f, 7.62034357e-02f, 5.97702079e-02f, 5.01291342e-02f, 1.30977646e-01f,
  -4.83889818e-01f, 6.46345839e-02f, -1.48442060e-01f, -1.46495253e-01f, 1.67450637e-01f, 1.93820670e-01f, 3.05145383e-01f, 1.56674609e-01f, 2.17649247e-02f, 5.19990325e-02f,
  6.51247576e-02f, 4.59398031e-02f, -1.46496305e-02f, 2.35584332e-03f, 6.71667159e-02f, 1.36983454e-01f, 1.07544936e-01f, -1.31756604e-01f, -4.69269976e-02f, 1.89186819e-02f,
  8.56094509e-02f, -1.56266689e-01f, -1.81014150e-01f, -5.92092462e-02f, 7.90324956e-02f, -1.07561462e-02f, -4.93655689e-02f, -1.16251148e-02f, 1.57230813e-02f, 1.14888698e-01f,
  -1.37239233e-01f, -2.53569782e-01f, 2.47311071e-02f, 3.00954394e-02f, -6.87079579e-02f, -7.28464425e-02f, -1.39419027e-02f, -1.38561040e-01f, -7.37682804e-02f, -2.21073367e-02f,
  5.26722670e-02f, -9.38133821e-02f, 4.96805348e-02f, -1.07592735e-02f, -1.19238734e-01f, 3.09041236e-02f, -1.11280903e-01f, -1.79616079e-01f, -5.98716475e-02f, -7.97484294e-02f,
  4.44524735e-02f, 4.13576439e-02f, -1.91919338e-02f, 9.27437693e-02f, -6.33105561e-02f, -6.39288947e-02f, -7.58444741e-02f, -1.34670362e-03f, -1.14744797e-01f, -1.47387072e-01f,
  5.39273135e-02f, 7.06745461e-02f, 9.55934636e-03f, -4.59403358e-02f, -4.19300981e-02f, 3.55494767e-02f, 7.20187649e-02f, -3.54154152e-03f, 4.34038974e-02f, -2.64671743e-02f,
  -2.08553001e-02f, -5.02662174e-02f, -3.47360745e-02f, -1.06509011e-02f, -8.97148345e-03f, 6.97069010e-03f, 2.46232953e-02f, 2.23589856e-02f, 4.69934987e-03f, -6.55835569e-02f,
  -6.15228377e-02f, 2.99651939e-02f, -2.50010267e-02f, 5.89041263e-02f, 3.12647298e-02f, 7.01104924e-02f, 4.42419155e-03f, 6.12357780e-02f, -5.34121506e-02f, -2.09133001e-03f,
  -1.15316473e-01f, -3.71640623e-02f, 1.68736391e-02f, 5.33960201e-02f, 7.77411461e-03f, 4.38264199e-02f, 5.03085330e-02f, 4.55828011e-02f, 6.56930206e-04f, 1.84651799e-02f,
  3.07218377e-02f, -5.36740012e-02f, 7.43636638e-02f, 3.55003700e-02f, -9.86686908e-03f, -2.62925997e-02f, 8.79537836e-02f, 1.64159406e-02f, -1.70983803e-02f, -1.07983083e-01f,
  -2.23556887e-02f, -2.50421651e-02f, -8.02355707e-02f, -4.14320594e-03f, 5.97663270e-03f, -9.41500887e-02f, -2.81353798e-02f, -1.22739457e-01f, -3.15645598e-02f, -1.42756775e-01f,
  1.22600928e-01f, 4.81082173e-03f, 7.51378154e-03f, 1.60946976e-02f, 4.46010418e-02f, -2.41578873e-02f, 1.26185119e-01f, 2.08200123e-02f, -2.23847316e-03f, 1.33785546e-01f,
  1.20358102e-01f, 9.37173609e-03f, 1.36135623e-01f, -1.49605162e-02f, -6.15961254e-02f, 3.54932062e-02f, -3.99690308e-02f, 6.60539940e-02f, 1.05627730e-01f, 8.37838836e-03f,
  3.97602655e-02f, 1.33777961e-01f, 7.20597953e-02f, -8.55544209e-03f, 1.13530643e-01f, 8.89985114e-02f, 1.66117009e-02f, 1.22709952e-01f, 3.86232249e-02f, 6.99141696e-02f,
  -1.71932057e-02f, -7.56541640e-02f, 7.41840824e-02f, -2.47672163e-02f, 2.56708562e-02f, -4.77735661e-02f, 6.87590465e-02f, -7.38258138e-02f, 2.08481420e-02f, -5.58076613e-02f,
  6.49882406e-02f, -1.13934269e-02f, 4.67612930e-02f, 2.01178007e-02f, -7.71894902e-02f, 3.61151025e-02f, -7.19404146e-02f, -7.87562802e-02f, -7.85804316e-02f, 2.22448539e-02f,
  6.06811307e-02f, 6.75802305e-02f, -1.50962407e-02f, -8.07064027e-03f, 3.65152545e-02f, -1.96605623e-02f, -2.88537294e-02f, -1.06239896e-02f, -2.57316474e-02f, -9.60253850e-02f,
  8.85166302e-02f, -3.71382385e-02f, 2.00019833e-02f, -1.73700377e-02f, -3.17102745e-02f, -4.69913185e-02f, -1.84369870e-02f, 9.98550504e-02f, -5.80700561e-02f, -5.04996926e-02f,
  3.47778350e-02f, -4.26257625e-02f, -6.58514202e-02f, -5.32264821e-02f, 7.09322095e-02f, -1.18495757e-02f, 1.97471920e-02f, 1.19164297e-02f, -1.99184027e-02f, -7.55991265e-02f,
  8.57188851e-02f, -8.61977562e-02f, -3.71119566e-02f, 4.06905748e-02f, 5.40914945e-02f, 2.16434281e-02f, 8.43373686e-03f, 1.17490506e-02f, -5.23280632e-03f, 9.79269221e-02f,
  7.13446215e-02f, 4.76381071e-02f, 7.79102817e-02f, 7.22004250e-02f, 8.87926146e-02f, -7.31257498e-02f, 8.67355540e-02f, -1.90873034e-02f, -8.59953463e-02f, -8.47937446e-03f,
  9.10396203e-02f, -7.55348131e-02f, -5.83048910e-02f, -5.42259403e-02f, 5.81028834e-02f, 2.33945251e-02f, 2.64666378e-02f, -5.98818399e-02f, -5.89469671e-02f, 6.10574186e-02f,
  5.17745912e-02f, -6.42565712e-02f, -6.95646107e-02f, 3.42129841e-02f, 7.05356384e-03f, 1.11573115e-01f, -4.89769503e-02f, 7.99328461e-02f, -1.26518561e-02f, -6.50543422e-02f,
  2.04601139e-01f, 9.63388011e-02f, 1.90992933e-02f, 4.32160981e-02f, -5.14572207e-03f, 1.18565932e-01f, 1.64859548e-01f, -6.34196624e-02f, 5.80971874e-02f, 4.73485440e-02f,
  1.38445839e-01f, -9.62058082e-03f, -4.62724157e-02f, 4.98386584e-02f, -8.05716068e-02f, 6.43886104e-02f, -4.30120863e-02f, 3.13699208e-02f, 3.79028656e-02f, 1.01596840e-01f,
  8.10648724e-02f, 9.28001478e-03f, -2.51643769e-02f, -3.67966369e-02f, 1.29214739e-02f, 3.74528905e-03f, 8.24522302e-02f, -2.17928477e-02f, -2.32372805e-02f, -6.74170032e-02f,
  -3.24318148e-02f, 8.66492093e-02f, -1.09188206e-01f, -7.27964342e-02f, 5.27771786e-02f, -4.70730737e-02f, 5.05943373e-02f, -1.12992309e-01f, 2.06247740e-03f, 3.45286503e-02f,
  2.31193434e-02f, 5.01491241e-02f, -6.03015833e-02f, -9.45002139e-02f, -5.00215590e-02f, 5.79847991e-02f, -4.58917283e-02f, -4.09682766e-02f, -8.46087635e-02f, 2.52200160e-02f,
  3.36761661e-02f, 9.99004692e-02f, 1.18158339e-02f, -3.59918438e-02f, 3.36912386e-02f, 5.26710600e-02f, 8.18218440e-02f, 8.51800814e-02f, -5.36462385e-03f, -7.35523477e-02f,
  3.76093797e-02f, -3.87087688e-02f, 4.56048809e-02f, 3.22066508e-02f, -9.04391706e-03f, -6.60389885e-02f, -4.56108712e-02f, -1.08190374e-02f, 6.71766847e-02f, 7.27596134e-02f,
  1.10820374e-02f, -4.73432504e-02f, -4.42635678e-02f, 1.47823850e-02f, -3.22871767e-02f, 2.90665273e-02f, -8.79558846e-02f, -6.99321041e-03f, -5.83387986e-02f, 7.27821738e-02f,
  -2.74053048e-02f, 3.22831534e-02f, 3.93488556e-02f, -1.15644606e-02f, -4.34651412e-02f, -7.48040304e-02f, 1.19406655e-02f, 5.72687648e-02f, -2.68091876e-02f, -5.34340627e-02f,
  3.94510888e-02f, -2.05531549e-02f, -1.34664506e-01f, 1.22414473e-02f, 4.52520885e-02f, 2.24167854e-02f, -6.18252084e-02f, 2.25072112e-02f, 7.64355343e-03f, 1.16316713e-02f,
  -1.44499140e-02f, -6.81197345e-02f, -1.30699538e-02f, -4.72813062e-02f, -3.48962173e-02f, -3.09121702e-03f, -5.57330288e-02f, -4.22281846e-02f, -9.58607867e-02f, -7.87581801e-02f,
  -3.74921747e-02f, 5.83263021e-03f, 2.37087645e-02f, -1.02838233e-01f, -9.35182497e-02f, -9.21082869e-02f, 7.64594898e-02f, -1.12859914e-02f, 4.58660088e-02f, 4.47381027e-02f,
  -8.07019472e-02f, 3.82482521e-02f, -1.78329393e-01f, 3.07791419e-02f, 1.35957137e-01f, -3.10537834e-02f, -7.10042426e-03f, 5.10006845e-02f, 2.09908444e-03f, 1.18685495e-02f,
  -3.71126682e-02f, 1.74249597e-02f, -4.00863066e-02f, -7.01896325e-02f, -8.29054341e-02f, -6.36162311e-02f, 3.25082690e-02f, -1.28461435e-01f, -9.36041474e-02f, -1.10865440e-02f,
  1.77282840e-01f, 7.77121708e-02f, -3.74250636e-02f, 3.66359279e-02f, 4.15992104e-02f, 1.32587090e-01f, 7.57681131e-02f, -5.90581633e-02f, 5.63248843e-02f, 1.15243763e-01f,
  -1.91407934e-01f, -2.05835298e-01f, -8.50826204e-02f, 6.73543736e-02f, -4.97180335e-02f, -3.76315229e-02f, 1.16822235e-02f, -3.27379555e-02f, -1.11357018e-01f, -1.00265011e-01f,
  1.35385403e-02f, -3.09564769e-02f, -4.63019907e-02f, -9.86451954e-02f, -5.60423993e-02f, -6.60403669e-02f, -8.16491917e-02f, -1.95415139e-01f, -1.20992780e-01f, 1.04517182e-02f,
  1.28268436e-01f, 1.90833081e-02f, -5.49016409e-02f, -1.29502535e-01f, -1.15706146e-01f, 1.91273447e-02f, -4.17095935e-03f, -8.47909972e-02f, -1.20692015e-01f, -8.68899152e-02f,
  -6.03423570e-04f, -3.05873305e-02f, -8.11188370e-02f, -2.04747245e-02f, 1.04038201e-01f, 6.75907135e-02f, -2.15354767e-02f, 3.09346411e-02f, 1.28097311e-02f, 3.88403912e-03f,
  1.56295095e-02f, -7.11658224e-02f, -1.47633990e-02f, -3.25669423e-02f, -6.49261475e-02f, 2.26963926e-02f, 1.39234550e-02f, 7.20634460e-02f, 4.15721722e-02f, 2.72197686e-02f,
  4.49790843e-02f, -9.63373482e-02f, -5.18316366e-02f, 5.91581985e-02f, -4.78310846e-02f, -3.38167101e-02f, -4.70882729e-02f, 4.07357290e-02f, -1.58940572e-02f, 1.00194484e-01f,
  1.46577552e-01f, -1.37226224e-01f, 3.86429857e-03f, -6.12766519e-02f, -6.49228022e-02f, -9.69055369e-02f, -3.05883735e-02f, -5.10477014e-02f, 3.47096398e-02f, 4.98277545e-02f,
  -9.40327719e-02f, -2.28527072e-03f, 2.35902704e-02f, -3.23258415e-02f, -3.59233767e-02f, -4.91198227e-02f, 3.41519527e-02f, 4.81880270e-02f, 6.10616012e-03f, 4.78569977e-02f,
  1.31669845e-02f, 2.11194735e-02f, -6.80151507e-02f, 5.87486848e-03f, 1.67231318e-02f, 1.28684798e-02f, -9.55863521e-02f, -2.08924729e-02f, -1.01753645e-01f, 1.35411382e-01f,
  -7.80605972e-02f, 2.27972269e-02f, -1.37685105e-01f, 1.46557745e-02f, 1.25761405e-01f, 6.73670694e-02f, -1.20181181e-01f, -1.58214886e-02f, 2.57581519e-03f, -1.20586865e-02f,
  6.95179626e-02f, 6.20375425e-02f, 5.87280206e-02f, -2.34022718e-02f, -1.02352619e-01f, -1.56701699e-01f, -1.29499763e-01f, -1.26192838e-01f, -6.93460107e-02f, 1.55566121e-02f,
  1.01012520e-01f, -1.63674052e-03f, -3.63793671e-02f, 1.84204224e-02f, -1.54249603e-02f, 5.14474772e-02f, -6.48782104e-02f, -7.04976246e-02f, -6.56651258e-02f, -1.09676626e-02f,
  -1.11152969e-01f, -3.70451882e-02f, -5.08174226e-02f, -6.02511987e-02f, -5.99589758e-02f, 6.26810215e-05f, -2.80067641e-02f, -3.81894894e-02f, -2.97915600e-02f, -3.98756638e-02f,
  -9.71764419e-03f, -5.98328002e-02f, -2.34197080e-02f, 3.22300717e-02f, -5.13190180e-02f, 2.88408305e-02f, -7.32635036e-02f, -5.91699257e-02f, 2.54527964e-02f, 7.94014037e-02f,
  -3.97679769e-02f, 7.81240538e-02f, 3.86315212e-02f, -3.33776474e-02f, 1.98934991e-02f, 3.59943025e-02f, -1.12697206e-01f, -5.38511621e-03f, -5.08699939e-02f, 1.54429041e-02f,
  -9.08030495e-02f, 2.89188437e-02f, 3.89181674e-02f, 3.64323929e-02f, -9.80235450e-03f, 1.17459428e-02f, -4.63447087e-02f, 2.51078699e-02f, -3.74583597e-03f, 7.48631507e-02f,
  3.04278499e-03f, -6.69668838e-02f, 3.25379260e-02f, 3.88270058e-02f, -2.67965104e-02f, 5.15843695e-03f, -3.15032601e-02f, -1.22177102e-01f, -1.19735077e-01f, -3.92936468e-02f,
  7.09504634e-03f, -1.35772321e-02f, 4.24559936e-02f, -5.49103599e-03f, 2.57429248e-03f, -1.20632052e-02f, -6.08251318e-02f, 7.41471723e-02f, -9.93864518e-03f, 2.29750454e-04f,
  -4.96715829e-02f, -6.70529380e-02f, 3.30438539e-02f, 2.64852773e-02f, -9.79911163e-03f, 4.50544022e-02f, -4.08754274e-02f, -6.56135529e-02f, 2.00578272e-02f, -5.93256056e-02f,
  4.04626057e-02f, 1.34359989e-02f, 1.32597901e-03f, -3.37250158e-02f, 6.10714369e-02f, 2.42559072e-02f, -6.57673106e-02f, -7.03566372e-02f, 4.65819351e-02f, -6.91988915e-02f,
  1.51527617e-02f, -1.16598550e-02f, 1.80647764e-02f, -1.16806097e-01f, -5.39192408e-02f, -5.78465387e-02f, -8.41768458e-02f, -3.63398083e-02f, -1.66529417e-01f, -1.99155480e-01f,
  1.07996531e-01f, 1.40663847e-01f, -6.47443160e-02f, 1.14027932e-01f, 4.42286953e-03f, -5.64300630e-04f, 9.03773829e-02f, 1.14555813e-01f, 1.10381454e-01f, 7.55007863e-02f,
  2.19403014e-01f, 4.42386307e-02f, 1.15845516e-01f, 8.80121589e-02f, 1.02465697e-01f, 9.93993804e-02f, 4.59442958e-02f, -6.22667149e-02f, 1.00988142e-01f, -5.32496050e-02f,
  9.07852277e-02f, 3.14130895e-02f, -1.77703518e-02f, 6.49532601e-02f, -9.50189307e-03f, 6.30122125e-02f, 2.18939465e-02f, -6.62934706e-02f, 2.95464918e-02f, 6.42551705e-02f,
  1.43038660e-01f, 1.10584147e-01f, -9.29617286e-02f, 7.31180012e-02f, 1.78747158e-02f, -3.16523314e-02f, 5.37373982e-02f, -6.00341931e-02f, 2.59548333e-03f, 1.00288339e-01f,
  4.63407114e-02f, -6.61808923e-02f, -2.60599088e-02f, -8.46732184e-02f, -1.20771555e-02f, -4.41586785e-02f, 7.39311427e-02f, 5.58158867e-02f, 5.47924414e-02f, 1.40782865e-02f,
  2.35411040e-02f, 6.91719949e-02f, 4.78730276e-02f, 3.78972129e-03f, -3.36528867e-02f, 7.94618018e-03f, 1.14937909e-01f, 1.01281829e-01f, 1.17654793e-01f, 4.43313569e-02f,
  -9.03222039e-02f, -7.82053173e-02f, -7.13887662e-02f, -1.12677617e-02f, -3.39328572e-02f, 5.74810505e-02f, -3.04342583e-02f, 2.20539607e-02f, -7.20226690e-02f, -6.38870746e-02f,
  -4.07576598e-02f, -2.41215546e-02f, 5.78562059e-02f, -3.67750693e-03f, -5.96411452e-02f, -5.87501600e-02f, 4.27845903e-02f, -2.61421297e-02f, 6.60232678e-02f, 8.60088244e-02f,
  -4.65608481e-03f, -7.77618811e-02f, -6.12488650e-02f, 6.52390420e-02f, 8.28737542e-02f, 7.99632072e-02f, 5.54607622e-02f, 1.07287811e-02f, 7.64059722e-02f, -1.03415139e-02f,
  1.55351032e-03f, 1.38025023e-02f, 8.84764944e-04f, -3.82560007e-02f, -3.29033360e-02f, 2.21054591e-02f, 2.53514410e-03f, 1.32999653e-02f, -3.56159098e-02f, -3.57387238e-03f,
  6.28366619e-02f, 6.22044578e-02f, -3.32686454e-02f, -3.93778365e-03f, -1.06232151e-01f, 4.43519168e-02f, -2.58542504e-02f, 4.68599387e-02f, 9.47772190e-02f, 1.09963976e-01f,
  -1.06518352e-02f, -3.01845688e-02f, 2.33961325e-02f, -2.43461281e-02f, 6.94623357e-03f, -9.51535720e-03f, -6.36382820e-03f, -8.24695826e-02f, -6.58423975e-02f, 4.02129106e-02f,
  1.50426835e-01f, -3.79081592e-02f, -1.79061756e-01f, 1.77814856e-01f, -6.31302446e-02f, -1.88989028e-01f, -2.91458279e-01f, -3.66415717e-02f, 8.00899044e-02f, -7.30814561e-02f,
  -2.28055567e-02f, 1.26605868e-01f, -2.83593349e-02f, -1.52895868e-01f, -9.61660370e-02f, -1.82761103e-01f, -4.84900288e-02f, -1.15456007e-01f, -1.88684821e-01f, -1.01752870e-01f,
  -1.06209308e-01f, -2.21889000e-02f, 1.86998937e-02f, -5.18440120e-02f, 8.71075690e-02f, 1.02246992e-01f, -8.00423920e-02f, -3.59283164e-02f, -2.52343249e-02f, 1.48542091e-01f,
  -7.51831904e-02f, 6.37537092e-02f, 2.56815720e-02f, 6.14241138e-02f, 4.88746911e-02f, -1.35296897e-03f, -4.70508039e-02f, -3.21849734e-02f, 1.67188980e-02f, 7.49330921e-03f,
  1.90072916e-02f, 3.81712206e-02f, 3.44120115e-02f, 3.00002210e-02f, 2.72866543e-02f, -1.07898764e-01f, -1.78362578e-02f, -1.22902922e-01f, -2.35802308e-02f, -1.03448825e-02f,
  -1.42599111e-02f, 8.28750283e-02f, -1.05792768e-01f, 4.67143282e-02f, -5.78396730e-02f, 8.06925446e-02f, -8.82606953e-03f, -4.15097959e-02f, -3.46769542e-02f, -3.19856703e-02f,
  -1.19805939e-01f, -2.28378847e-02f, -7.27770925e-02f, -5.48692048e-02f, 2.18748879e-02f, 2.40763780e-02f, -4.91976142e-02f, -6.06172672e-03f, 7.70566659e-03f, -4.35148329e-02f,
  -6.70797825e-02f, 3.76452878e-02f, 2.26709992e-02f, -7.58307353e-02f, 3.51428725e-02f, -5.07773682e-02f, 8.95398017e-03f, 4.46564006e-03f, 4.11891937e-03f, 4.83129025e-02f,
  -4.87635657e-02f, 4.63273562e-02f, -5.62412553e-02f, -3.62622701e-02f, -3.27029824e-03f, 9.97393765e-03f, -4.68728505e-02f, 1.89418311e-03f, 9.04569775e-02f, 1.78466961e-02f,
  9.65118781e-02f, -5.18322550e-02f, -6.13200180e-02f, -2.51085591e-02f, -4.57343757e-02f, 3.42517567e-04f, -3.26878354e-02f, -4.21706811e-02f, -6.22352445e-03f, -2.96079963e-02f,
  -7.49163330e-02f, -2.21844506e-03f, 4.33813632e-02f, -8.21022317e-02f, -4.88419272e-02f, -5.60202971e-02f, -1.53673202e-01f, 2.39772871e-02f, 5.02917506e-02f, -8.69854912e-02f,
  -1.22033857e-01f, -1.17169559e-01f, 5.60440943e-02f, -6.65449202e-02f, 2.98168156e-02f, -2.59152632e-02f, -2.82286853e-02f, 9.86388251e-02f, 1.65742338e-02f, -5.61203696e-02f,
  9.15998518e-02f, -1.98108345e-01f, -2.09332213e-01f, 3.66117582e-02f, -6.76295757e-02f, -7.45978802e-02f, -1.40324742e-01f, -1.25525549e-01f, -5.05689345e-02f, -7.96947032e-02f,
  -3.88571769e-02f, 2.99608726e-02f, -4.91760597e-02f, -5.66761903e-02f, -2.20348183e-02f, -1.44511282e-01f, -8.72340947e-02f, -6.30234480e-02f, 3.94788533e-02f, 4.86020668e-04f,
  1.02130972e-01f, 8.78750533e-02f, 6.90924227e-02f, -6.25277869e-04f, -7.76850209e-02f, -4.85808812e-02f, -2.38510370e-02f, -8.21922198e-02f, 9.43708047e-03f, -4.56034057e-02f,
  -7.40669742e-02f, -9.26742181e-02f, 2.09491886e-02f, 9.74895507e-02f, 1.75368842e-02f, -7.02582970e-02f, 8.13355595e-02f, 9.57041904e-02f, 1.62351802e-02f, -4.81424965e-02f,
  5.31952605e-02f, 4.77772430e-02f, -8.02854914e-03f, -1.57616753e-02f, 7.88279921e-02f, 1.95561517e-02f, -4.97487560e-02f, -5.96525259e-02f, 3.63621674e-02f, -6.48932829e-02f,
  -9.24692005e-02f, -1.00181609e-01f, 8.74519646e-02f, -8.30299705e-02f, 6.30497113e-02f, -2.37252768e-02f, -5.40802889e-02f, -4.03427333e-02f, 1.74432676e-02f, -4.96502258e-02f,
  -5.32568134e-02f, 3.89333628e-02f, 8.94180536e-02f, 6.99104741e-02f, 4.76808324e-02f, 1.81336347e-02f, 7.23166764e-02f, 9.34002772e-02f, 1.11680150e-01f, 5.43980710e-02f,
  2.85645556e-02f, -9.11371112e-02f, -4.26552109e-02f, -2.05806512e-02f, -6.21213354e-02f, 7.54841343e-02f, 7.73793757e-02f, 6.26065731e-02f, 3.08075808e-02f, 3.01750954e-02f,
  -2.57258248e-02f, 6.57015815e-02f, -4.05422971e-02f, -3.55332121e-02f, 2.35226545e-02f, 1.13541307e-02f, -2.03557294e-02f, -6.78951442e-02f, -7.31293485e-02f, -5.66497110e-02f,
  8.17746893e-02f, -8.96302462e-02f, -2.75185890e-02f, -6.21748082e-02f, -6.74677119e-02f, -7.36341625e-02f, -4.98821065e-02f, 1.09104156e-01f, 2.67994050e-02f, 2.49724481e-02f,
  3.42851914e-02f, 1.67334955e-02f, 2.84545328e-02f, -5.40204458e-02f, -7.55582610e-03f, 1.58731323e-02f, 1.47198522e-02f, 1.49407731e-02f, -7.40235895e-02f, 1.59486977e-03f,
  3.43370587e-02f, 1.04841940e-01f, 6.57408684e-02f, -7.94993248e-03f, 1.02175780e-01f, 1.22517876e-01f, -2.11450290e-02f, 5.25882170e-02f, -4.08606976e-02f, -3.72802205e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  4.32848977e-03f, 8.06653798e-02f, 2.69943476e-02f, 1.73813209e-01f, 2.85498619e-01f, 1.44342810e-01f, 1.28359437e-01f, 5.39332628e-02f, -1.00404313e-02f, 2.15822533e-01f,
  1.56390503e-01f, 1.39780818e-02f, 1.33791596e-01f, 4.61473614e-02f, -9.32450444e-02f, 9.91405770e-02f, 2.23200455e-01f, 1.10808481e-03f, 1.39668003e-01f, -2.11379882e-02f,
  2.10922509e-02f, 2.19720706e-01f, 3.82211320e-02f, -9.79124196e-03f, 3.48463804e-02f, -3.14873504e-03f
};

// L1_fan_Wp (Shape: 19 x 64)
const int L1_fan_Wp_rows = 19;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.37789279e-01f, -6.97880387e-02f, 1.36662513e-01f, -2.03579858e-01f, 4.80794832e-02f, 1.35292888e-01f, 4.63103466e-02f, -9.07616764e-02f, -1.76762775e-01f, -1.58773839e-01f,
  -4.68853861e-02f, 2.56817453e-02f, -7.74364546e-02f, -1.19690150e-01f, -3.78774218e-02f, -9.31325257e-02f, 2.93628648e-02f, 4.72522192e-02f, -1.38135850e-01f, 6.66933656e-02f,
  1.60028368e-01f, -2.61842042e-01f, 1.84008554e-02f, -2.10647047e-01f, -1.51814252e-01f, 2.30622202e-01f, -1.35011911e-01f, -1.19188078e-01f, -1.07699253e-01f, -6.89211935e-02f,
  -2.31569260e-01f, -1.27871022e-01f, 2.55910426e-01f, -2.30837002e-01f, 1.59059256e-01f, 6.69216290e-02f, 1.00986741e-01f, -1.43998623e-01f, -7.28702247e-02f, -7.84576312e-02f,
  1.29338324e-01f, 1.44434413e-02f, -1.39776394e-01f, 4.73219268e-02f, -1.56100035e-01f, -7.30063021e-02f, 1.01195067e-01f, -4.06424031e-02f, 5.58209233e-02f, 3.28586884e-02f,
  -1.35571137e-01f, -5.69110997e-02f, 2.39780396e-02f, 8.35536644e-02f, 2.42210273e-02f, 3.23714316e-02f, -8.33067894e-02f, -4.12870087e-02f, 5.10200299e-02f, 9.83042791e-02f,
  1.70824841e-01f, 1.70091599e-01f, 2.16569081e-01f, 9.37505811e-02f, -1.26895040e-01f, -4.97290492e-02f, -2.61095595e-02f, -2.29113862e-01f, -1.24743439e-01f, -1.38300464e-01f,
  7.97084272e-02f, -5.90751879e-02f, 1.02043256e-01f, -3.36346738e-02f, -1.41553611e-01f, -1.42079830e-01f, 5.02806045e-02f, 1.08371153e-01f, -1.21962868e-01f, -7.89904818e-02f,
  -4.02225628e-02f, 1.01992786e-01f, -2.51847468e-02f, 2.64949352e-01f, -6.76522404e-02f, -9.43527371e-02f, 1.64600343e-01f, -2.73846656e-01f, 5.52780181e-02f, 1.00470275e-01f,
  -7.76334852e-02f, 9.03607309e-02f, 1.09187905e-02f, -1.99388906e-01f, 9.81549844e-02f, 1.56008184e-01f, -1.11301141e-02f, -1.49255181e-02f, -1.30407125e-01f, -2.63345212e-01f,
  5.74727207e-02f, 1.13008000e-01f, 5.03472460e-04f, -1.53673455e-01f, -2.31428921e-01f, -1.07195489e-01f, 5.80504164e-02f, 2.09258884e-01f, -3.15219350e-02f, 2.19723750e-02f,
  6.12846874e-02f, -1.19709194e-01f, -5.59263341e-02f, -6.66382238e-02f, 5.84862381e-02f, -3.47623155e-02f, 1.06069177e-01f, 5.68652526e-02f, -1.34947464e-01f, -9.72448960e-02f,
  6.44928515e-02f, -3.75248156e-02f, 3.96543294e-02f, -4.26221862e-02f, 2.51265150e-02f, -6.54394031e-02f, 4.32524458e-02f, 6.14941604e-02f, -1.05489390e-02f, -8.67567733e-02f,
  2.32965667e-02f, -4.97144349e-02f, -1.46747336e-01f, 1.75314426e-01f, 1.29699290e-01f, -1.21155389e-01f, -1.85813248e-01f, -1.26676023e-01f, -4.55995947e-02f, 8.52641016e-02f,
  -1.25767604e-01f, 5.99508472e-02f, 8.75004306e-02f, -9.70300287e-03f, 1.17597274e-01f, 1.21254511e-01f, -6.00783043e-02f, -1.41574442e-01f, 1.38891518e-01f, 1.34168953e-01f,
  1.89325273e-01f, 2.53792614e-01f, 8.84553492e-02f, 1.21411212e-01f, -3.89090657e-01f, -1.40484184e-01f, 1.41198769e-01f, 1.55202642e-01f, -4.19634223e-01f, -1.16146170e-01f,
  2.95777828e-01f, -3.60638951e-03f, -5.47675081e-02f, 3.18696201e-02f, 1.36598051e-01f, -1.92349270e-01f, 1.60089299e-01f, 6.99450523e-02f, -2.16600195e-01f, -1.45837739e-01f,
  9.30177346e-02f, -1.20837905e-01f, 1.16911173e-01f, 1.40823796e-01f, 5.20447902e-02f, 3.25459940e-03f, 8.47429782e-02f, 1.55329898e-01f, -1.40909269e-01f, 6.75508901e-02f,
  -1.21480701e-02f, 2.25803569e-01f, 2.76802540e-01f, 1.03195429e-01f, 2.27252349e-01f, 1.50762662e-01f, 1.04362577e-01f, 1.90392971e-01f, 9.98280570e-02f, -8.89927819e-02f,
  -7.92385787e-02f, 1.40958903e-02f, 5.53780119e-04f, -1.24586187e-01f, -5.80442809e-02f, -1.86745133e-02f, 9.33556631e-02f, -8.08447972e-02f, 8.80083069e-02f, -1.84829496e-02f,
  5.48269898e-02f, -9.71565619e-02f, -6.10317737e-02f, -1.73953790e-02f, -1.78256005e-01f, 1.10369511e-01f, 8.56755208e-03f, 5.23469970e-03f, -1.93540335e-01f, -2.69417241e-02f,
  -1.37478679e-01f, 2.67621726e-02f, -8.25806409e-02f, -2.65444696e-01f, -1.32481515e-01f, -1.81259975e-01f, -2.39607647e-01f, 1.15173906e-01f, -7.55582750e-02f, 2.77297288e-01f,
  1.97638825e-01f, -4.32758220e-02f, 1.89296022e-01f, 3.09476703e-01f, -2.82323584e-02f, 8.45965147e-02f, -7.65459687e-02f, -1.81894258e-01f, 1.23076580e-01f, 5.19382469e-02f,
  -1.04465298e-02f, -2.02765018e-01f, -3.05720419e-02f, -2.32944004e-02f, -1.57698467e-01f, -1.83209125e-02f, 9.41419601e-03f, 5.31530604e-02f, -2.94552259e-02f, -1.09676473e-01f,
  2.87532508e-01f, 7.97297359e-02f, 3.12763150e-03f, -3.84062082e-02f, 8.99305716e-02f, -3.41758728e-02f, -1.79433674e-01f, -1.43089190e-01f, -7.88043290e-02f, 4.68242764e-02f,
  1.24895886e-01f, -7.10389810e-03f, -8.83939043e-02f, -1.02052152e-01f, -2.07841080e-02f, 1.24345690e-01f, -4.72069718e-02f, -2.26418212e-01f, -1.26558915e-01f, -1.47363946e-01f,
  -1.45557716e-01f, -1.63578704e-01f, 2.05590464e-02f, 6.01401813e-02f, -2.24871546e-01f, -9.37344208e-02f, -1.86413396e-02f, -2.99919620e-02f, -2.14948311e-01f, -1.81024954e-01f,
  -3.56116109e-02f, -9.62285399e-02f, -4.74067666e-02f, -1.73724983e-02f, -2.09172770e-01f, 1.22688428e-01f, 1.01030162e-02f, -2.10454762e-02f, -1.05083078e-01f, 3.87920327e-02f,
  2.25995243e-01f, 6.67337654e-03f, -2.20768303e-01f, 1.86316669e-02f, 1.93488821e-01f, 1.05447538e-01f, -2.35170931e-01f, 6.29127249e-02f, 1.05646387e-01f, 2.19513014e-01f,
  8.23094696e-02f, -6.29351335e-03f, -1.63651064e-01f, 3.36934999e-02f, 1.30598173e-02f, 6.09175935e-02f, -7.34398589e-02f, -8.32881406e-02f, -3.96282971e-02f, -1.11540899e-01f,
  -6.07825583e-03f, 2.05249246e-02f, -4.96592335e-02f, -1.42873302e-01f, 2.49879971e-01f, 8.16114917e-02f, -3.96133848e-02f, 2.85391230e-02f, -3.64486612e-02f, 1.35142758e-01f,
  8.04833099e-02f, 1.29383907e-03f, 1.47142008e-01f, 9.17471200e-02f, -5.91935590e-02f, 1.22269101e-01f, -3.24122272e-02f, 4.67171241e-03f, -4.34903651e-02f, -1.71964467e-01f,
  1.76226646e-02f, 1.65659022e-02f, -3.29722799e-02f, 9.60518345e-02f, 3.99052575e-02f, -6.77911043e-02f, -1.53732717e-01f, 1.21780418e-01f, -2.40565161e-03f, -9.78191048e-02f,
  1.37340680e-01f, 1.01178944e-01f, -7.97073990e-02f, 1.42357975e-01f, -9.06116441e-02f, -4.22799550e-02f, 1.53750926e-01f, 3.60488817e-02f, 8.78215432e-02f, -1.80752501e-01f,
  2.65268944e-02f, -3.33901525e-01f, -3.06671768e-01f, 1.16361771e-02f, 7.94642791e-02f, 5.42707853e-02f, -1.63902879e-01f, 1.60116717e-01f, 5.37138917e-02f, 4.99375686e-02f,
  -1.41776010e-01f, 1.89347733e-02f, -1.35596201e-01f, 2.12742649e-02f, 4.73474674e-02f, 2.33046398e-01f, -2.57664442e-01f, 7.46436566e-02f, 2.23775976e-03f, -1.00501522e-01f,
  -2.82277633e-03f, 7.92350173e-02f, -2.68720508e-01f, -2.76503772e-01f, -1.28921807e-01f, -1.98717386e-01f, 1.62061080e-02f, -2.45560437e-01f, 1.74429238e-01f, 1.40454009e-01f,
  -4.55533452e-02f, -5.34699000e-02f, -1.03203379e-01f, 3.62307094e-02f, -6.50496110e-02f, 5.56475259e-02f, -1.20515697e-01f, -4.91233021e-02f, 1.37446791e-01f, 2.62136906e-02f,
  7.49781430e-02f, 1.50363771e-02f, 1.14706859e-01f, 1.09640665e-01f, 1.00244761e-01f, 9.77755412e-02f, 5.99658825e-02f, -2.64439397e-02f, -9.44616869e-02f, -1.33905753e-01f,
  -1.37045100e-01f, 8.77990723e-02f, -1.67176977e-03f, 5.13922572e-02f, -2.34412886e-02f, 1.17328644e-01f, -8.91975090e-02f, -1.70513019e-01f, 1.62057549e-01f, 2.56782193e-02f,
  -2.69447155e-02f, 3.75268608e-02f, 1.64019227e-01f, -2.48620901e-02f, -2.38969438e-02f, -3.43972221e-02f, -1.13511935e-01f, 7.16595128e-02f, 1.68815061e-01f, 1.19149666e-02f,
  -1.57740489e-01f, 2.21886545e-01f, 2.28564188e-01f, 6.59587830e-02f, -1.13299355e-01f, 9.70079228e-02f, -2.87664562e-01f, 1.93372726e-01f, -6.17322437e-02f, -1.02224024e-02f,
  -2.39697009e-01f, 1.73761249e-01f, -1.38267651e-01f, 1.77387074e-01f, 7.28521636e-03f, 1.46778628e-01f, -1.65905803e-01f, -7.67116174e-02f, -3.59237939e-02f, 8.25166851e-02f,
  5.66595420e-02f, -1.42820597e-01f, 9.66148078e-02f, -2.03760996e-01f, -3.01033910e-02f, -1.18813768e-01f, 4.55392376e-02f, -5.90355098e-02f, -1.27628803e-01f, -2.02530753e-02f,
  1.66144297e-01f, 2.12075245e-02f, 2.37154290e-02f, -1.20060071e-01f, -1.52156577e-01f, 8.09882507e-02f, -4.43119705e-02f, -9.10512432e-02f, 1.37840569e-01f, -1.13772400e-01f,
  1.38461962e-01f, 1.43181190e-01f, -5.84469065e-02f, -8.09314176e-02f, -6.61245286e-02f, -1.00666672e-01f, -1.36161938e-01f, 1.13647999e-02f, 7.32308626e-02f, 2.50280313e-02f,
  1.29287139e-01f, 1.48134679e-02f, -1.02566041e-01f, 6.37959763e-02f, -2.58825850e-02f, 1.07968964e-01f, 1.53999077e-02f, 9.00770426e-02f, 5.37749603e-02f, 8.01472887e-02f,
  4.00680453e-01f, -1.08179651e-01f, -9.83346328e-02f, 2.05069527e-01f, 2.03137338e-01f, -1.29971832e-01f, -1.04476362e-01f, -9.09513235e-02f, 2.06609629e-02f, -2.22017363e-01f,
  1.59644529e-01f, 1.40276611e-01f, 1.83881804e-01f, 2.05750480e-01f, 1.74693614e-01f, 4.47538011e-02f, 8.57513100e-02f, -2.12321222e-01f, -1.08718693e-01f, -1.08372480e-01f,
  2.18094245e-01f, -2.58273277e-02f, -1.07896817e-03f, -7.50130564e-02f, -5.12255579e-02f, 1.50835916e-01f, -1.94707494e-02f, 1.33430839e-01f, 1.29523888e-01f, -2.72183400e-02f,
  -4.53239568e-02f, 5.43333106e-02f, 2.53042459e-01f, -3.77633572e-02f, 1.11823067e-01f, -1.84612703e-02f, -1.12764254e-01f, 1.29417017e-01f, 1.86367720e-01f, 6.73859417e-02f,
  8.39841962e-02f, 1.38961390e-01f, -7.61413667e-03f, -6.48679808e-02f, -6.71432987e-02f, -3.08826510e-02f, 9.02551934e-02f, -1.45472586e-02f, 3.14341821e-02f, 1.04673453e-01f,
  7.15361834e-02f, -1.80182189e-01f, 9.76647437e-02f, 1.09663740e-01f, -9.38512944e-03f, 2.07092494e-01f, -8.66145361e-03f, -1.08910173e-01f, -9.61403698e-02f, 1.11644790e-01f,
  8.40528831e-02f, 2.58599579e-01f, -1.69797391e-01f, -8.13568011e-02f, -2.23832533e-01f, -2.55057305e-01f, -1.78399757e-01f, 1.29732892e-01f, -1.99457109e-01f, 1.52014256e-01f,
  1.59515142e-01f, 2.89406367e-02f, 2.40139574e-01f, 3.31259608e-01f, -5.04763313e-02f, 1.96756899e-01f, 2.74258591e-02f, -1.59998834e-01f, -4.55402806e-02f, 2.71523535e-01f,
  -1.02823950e-01f, 8.92416388e-02f, 1.09087536e-02f, -5.92978038e-02f, -3.85679230e-02f, -1.63017631e-01f, -9.17536691e-02f, -9.69908908e-02f, -9.34987366e-02f, -3.59113924e-02f,
  1.97739750e-01f, -6.36075735e-02f, 4.19439338e-02f, 9.54837352e-02f, 2.94794366e-02f, -1.32294923e-01f, 1.18982196e-02f, 1.94301866e-02f, 2.45704487e-01f, 5.67243323e-02f,
  -1.39434673e-02f, 1.11656241e-01f, 7.52722844e-02f, -1.17244780e-01f, -5.26950136e-02f, 1.36361746e-02f, 2.11119816e-01f, 1.91986840e-02f, -1.68806851e-01f, -5.34468032e-02f,
  4.37627640e-03f, 7.59867728e-02f, 4.37954208e-03f, 9.85631812e-03f, -1.72299132e-01f, 3.60341254e-03f, -1.37976231e-02f, 1.54986724e-01f, -5.76534867e-02f, -3.34493555e-02f,
  -4.75254059e-02f, -2.62738504e-02f, -1.57703176e-01f, -1.59679532e-01f, 5.07152546e-03f, -2.01499145e-02f, 1.94710046e-01f, 1.47416204e-01f, 1.94609076e-01f, 1.22526862e-01f,
  -1.61227807e-02f, 2.85926238e-02f, -3.17264162e-02f, -1.69051260e-01f, -1.74460500e-01f, -6.87394366e-02f, -3.25983495e-01f, -8.13410208e-02f, 2.21523523e-01f, -2.07609814e-02f,
  2.06816941e-01f, 1.52501702e-01f, 1.42804429e-01f, -2.43995070e-01f, -2.31844131e-02f, 4.55264449e-02f, 1.00834794e-01f, -1.99209586e-01f, -7.01239333e-02f, -7.78489411e-02f,
  1.74835056e-01f, -3.22010671e-03f, -1.48126408e-01f, 5.38410321e-02f, -4.85490113e-02f, -1.11389183e-03f, -1.17536739e-01f, 9.21202824e-02f, 1.38064414e-01f, 1.73835412e-01f,
  2.34451279e-01f, 5.06781600e-02f, -2.86560338e-02f, -8.23288336e-02f, -3.83733474e-02f, -5.25409579e-02f, 1.15277611e-01f, 1.76821172e-01f, -1.01475671e-01f, -7.46161565e-02f,
  -1.39552634e-02f, 1.21477703e-02f, 6.57694400e-05f, -8.50679427e-02f, 1.45814106e-01f, -4.03520204e-02f, -1.74797177e-01f, 1.21903144e-01f, -1.28206715e-01f, 5.47914952e-02f,
  -1.09548979e-01f, 8.41019079e-02f, 1.07248910e-01f, -2.22896755e-01f, -1.01633914e-01f, -1.46148860e-01f, -1.92358829e-02f, -4.08283807e-02f, -3.96643169e-02f, -1.14984259e-01f,
  -1.03769638e-02f, 4.61105295e-02f, 1.30702451e-01f, 9.74034369e-02f, 2.18203422e-02f, 1.88751832e-01f, 7.96486959e-02f, 7.82516003e-02f, -2.04578459e-01f, 1.30607203e-01f,
  -1.24949910e-01f, -2.01424167e-01f, -8.01327825e-02f, 4.81591076e-02f, 2.79388517e-01f, 4.56169993e-01f, -1.28220031e-02f, -1.24266341e-01f, -1.17895648e-01f, -8.57409611e-02f,
  1.71382159e-01f, 8.85874480e-02f, -1.66155789e-02f, -1.66776836e-01f, -8.47909823e-02f, -4.09553833e-02f, 4.02548648e-02f, 4.28302512e-02f, 1.85541641e-02f, 1.84209272e-03f,
  -3.85161676e-02f, -1.68401599e-02f, 9.80346054e-02f, -2.44710259e-02f, 2.43300587e-01f, -5.07643968e-02f, -1.29642576e-01f, -1.65089861e-01f, -1.58144861e-01f, -2.02656034e-02f,
  1.13261275e-01f, 1.57153964e-01f, 1.24575071e-01f, -2.25621890e-02f, 9.59494784e-02f, -6.17211424e-02f, -4.38325219e-02f, 1.30416960e-01f, -4.15076828e-03f, 1.25947818e-01f,
  2.19131857e-01f, 2.15228647e-01f, 4.50316034e-02f, 3.91632430e-02f, 1.31146058e-01f, 1.71354637e-02f, 1.34851217e-01f, 1.09474532e-01f, 2.67502610e-02f, 1.20043620e-01f,
  3.40717554e-01f, 1.17415756e-01f, 2.11375251e-01f, -1.57388121e-01f, -6.09387159e-02f, -1.48896247e-01f, -3.87452364e-01f, 7.40429014e-02f, 1.16121106e-01f, -1.65082097e-01f,
  -2.14853808e-01f, 1.18012227e-01f, 2.64304101e-01f, 2.58457884e-02f, -1.59164816e-01f, 1.50917202e-01f, -9.13774371e-02f, -1.31247178e-01f, -1.64399877e-01f, -2.34218523e-01f,
  -2.07178965e-01f, 1.22293398e-01f, 2.90564410e-02f, -9.97844525e-03f, -8.61220434e-02f, -3.77814882e-02f, -4.13608886e-02f, -1.16016798e-01f, 1.71314087e-02f, -3.72336507e-02f,
  1.68783754e-01f, -2.18769148e-01f, 5.62793352e-02f, -2.62174625e-02f, -1.35728568e-01f, 1.10449575e-01f, -6.10066690e-02f, 4.32311818e-02f, -1.54359177e-01f, 5.60197160e-02f,
  1.27671257e-01f, -4.35927063e-02f, -3.98076810e-02f, 8.89148936e-02f, 7.19077736e-02f, -6.36861175e-02f, -7.38837719e-02f, -1.50130719e-01f, -8.22928846e-02f, 2.06624418e-02f,
  -2.68738806e-01f, -3.93081978e-02f, -2.54334672e-03f, -1.37894064e-01f, 1.71238899e-01f, 6.18374199e-02f, -9.45737064e-02f, 3.15030920e-03f, 1.31963938e-01f, 1.19189858e-01f,
  9.17954221e-02f, -1.41367316e-01f, -1.07653588e-01f, 1.73310518e-01f, 2.38212258e-01f, 1.57878734e-03f, 5.82001209e-02f, 1.09067023e-01f, 5.26706763e-02f, -7.80151784e-02f,
  -1.57272905e-01f, 3.12050015e-01f, 3.69092196e-01f, 7.50500336e-03f, -4.29015875e-01f, 1.74611479e-01f, 2.25360230e-01f, 9.42550898e-02f, -2.30359063e-01f, 7.35138878e-02f,
  -1.23573318e-01f, 1.83519468e-01f, 1.27123147e-01f, -1.34561330e-01f, -2.64915735e-01f, 1.95266396e-01f, -5.21126203e-02f, 5.41486442e-02f, -1.13976419e-01f, 1.93539992e-01f,
  -4.24691886e-02f, 7.52619803e-02f, 4.79450785e-02f, 1.85119241e-01f, -1.05358087e-01f, -3.57232168e-02f, -1.89371724e-02f, -1.21799007e-01f, -2.05977052e-01f, 8.45019743e-02f,
  7.12180808e-02f, -5.43052331e-02f, 2.91535724e-03f, 1.21913627e-01f, 2.26683617e-01f, -1.80355966e-01f, -7.85741210e-02f, 1.11632891e-01f, -2.45222710e-02f, -9.30028930e-02f,
  -1.37999177e-01f, -1.38207391e-01f, 9.97667611e-02f, 1.12871960e-01f, 1.78775936e-01f, -1.14178188e-01f, 9.84082744e-02f, 1.10817395e-01f, -5.78392260e-02f, 7.28022382e-02f,
  -1.98667236e-02f, -9.08635110e-02f, 4.43980582e-02f, -2.92254575e-02f, -7.46834353e-02f, -8.42516795e-02f, -3.59749943e-02f, -1.19456314e-01f, -1.50990665e-01f, -1.20563470e-01f,
  -1.57265678e-01f, 1.58493146e-01f, -2.29165465e-01f, -7.25263134e-02f, 3.99294317e-01f, -4.34210241e-01f, -3.14293683e-01f, 1.90441489e-01f, 2.32849449e-01f, -2.92852917e-03f,
  -3.65371644e-01f, -6.42360151e-02f, 1.95060074e-01f, 1.31332446e-02f, 1.58426031e-01f, -1.05546422e-01f, 1.88625738e-01f, -1.43981371e-02f, 1.83699965e-01f, -1.11266971e-01f,
  7.08378479e-02f, 1.21138349e-01f, 2.08837353e-03f, -6.54197065e-03f, -7.83270970e-02f, -5.01488522e-02f, -2.06204623e-01f, -1.34235670e-04f, -7.37266839e-02f, 1.93004161e-01f,
  -2.27537602e-01f, -8.95658284e-02f, 1.22404434e-01f, 1.37351766e-01f, -4.79956120e-02f, 7.59489313e-02f, 1.61968097e-01f, -1.29144415e-01f, -5.87031208e-02f, 1.91617887e-02f,
  -5.21929003e-02f, 4.19670381e-02f, -3.89097296e-02f, -1.48139624e-02f, 9.90878642e-02f, 1.64914027e-01f, -4.05607335e-02f, 4.23416048e-02f, 1.20926378e-02f, -1.18849225e-01f,
  -5.61869740e-02f, 2.96236924e-03f, 1.23851337e-01f, 8.60782489e-02f, 1.50910839e-02f, -1.67450890e-01f, 3.78091633e-02f, -5.36353663e-02f, -1.22353211e-01f, 3.11097112e-02f,
  4.80816960e-02f, -7.07963258e-02f, -1.33320391e-01f, -3.15697230e-02f, -2.40259208e-02f, 7.25317448e-02f, -1.05309440e-02f, -8.66264999e-02f, 1.58132359e-01f, -7.04433247e-02f,
  -1.82057217e-01f, 1.80229083e-01f, -1.43562987e-01f, 6.58434406e-02f, -5.40829860e-02f, -1.86997250e-01f, 3.45058739e-02f, 1.03760280e-01f, 2.34960198e-01f, 6.47539422e-02f,
  1.06377795e-01f, -2.14905560e-01f, 2.76568681e-01f, -8.38893559e-03f, 4.55813296e-02f, 1.39290079e-01f, -8.97407383e-02f, -9.12188739e-02f, 8.25730264e-02f, 9.00046080e-02f,
  8.01777169e-02f, 1.33787721e-01f, -1.04415648e-01f, 1.42653897e-01f, 2.33075142e-01f, -1.89891737e-02f, -3.23422849e-02f, 1.10748522e-01f, 6.02912754e-02f, -2.02824958e-02f,
  1.19040914e-01f, -2.93039344e-02f, 1.30269870e-01f, 9.59873646e-02f, 9.95885581e-02f, -1.49759874e-01f, -8.82542208e-02f, -1.15696676e-01f, 4.62391190e-02f, 1.78265870e-02f,
  1.10893600e-01f, 7.04817176e-02f, 1.29522920e-01f, -1.50573850e-01f, -7.53693953e-02f, 1.08778877e-02f, 9.61491838e-02f, 1.54799268e-01f, 1.54816866e-01f, 4.04120274e-02f,
  -3.23654376e-02f, 3.84282880e-02f, -1.64353698e-01f, 1.02885813e-01f, -2.83562485e-02f, 1.65108010e-01f, 2.17283830e-01f, 7.39073157e-02f, 1.07657000e-01f, -7.59943435e-03f,
  -2.77414918e-01f, -2.07850575e-01f, 5.94768375e-02f, -3.68840605e-01f, -2.13037491e-01f, -4.42324616e-02f, -1.00067273e-01f, 3.43343854e-01f, -1.54310435e-01f, -6.59761252e-04f,
  1.87797710e-01f, 4.68573831e-02f, 3.30614485e-02f, 1.17499545e-01f, 1.29647061e-01f, 2.47244120e-01f, -1.18831888e-01f, 1.80259168e-01f, -1.48054212e-01f, -2.29030028e-02f,
  1.29221439e-01f, -2.20216494e-02f, 5.33093773e-02f, -1.98801279e-01f, -1.67892098e-01f, -1.89952821e-01f, -1.31742045e-01f, -8.11731964e-02f, -5.28444424e-02f, -3.67185920e-02f,
  1.82637461e-02f, -6.98484406e-02f, 6.10116459e-02f, 1.06298767e-01f, 1.60621122e-01f, 3.52946669e-02f, -2.03144610e-01f, 7.78718218e-02f, -1.39815778e-01f, -8.35295916e-02f,
  -1.72061980e-01f, -7.36643448e-02f, 6.31241798e-02f, 1.15448959e-01f, -1.72241196e-01f, -2.01396093e-01f, 4.25867662e-02f, 2.80139758e-03f, -1.35245686e-03f, -1.36050567e-01f,
  -7.36801028e-02f, 1.07200611e-02f, -1.29187554e-01f, 9.33983475e-02f, 1.36405617e-01f, 7.46233687e-02f, 9.08265449e-03f, 1.37350157e-01f, -1.33089036e-01f, -1.54889241e-01f,
  2.19535187e-01f, 6.47575930e-02f, -1.25599531e-02f, -1.14630327e-01f, 9.61913448e-03f, -2.21724182e-01f, -2.52147734e-01f, 3.55311437e-03f, 2.62232602e-01f, 3.45880240e-02f,
  -4.44132328e-01f, -1.36569634e-01f, 3.49299073e-01f, 9.29393023e-02f, -1.31338701e-01f, -9.12079737e-02f, -1.16792545e-01f, -2.12508952e-03f, 1.00096107e-01f, -7.52542540e-02f,
  -3.33025217e-01f, 1.65533781e-01f, 1.57525558e-02f, -3.32866702e-03f, -1.37837440e-01f, 1.40948340e-01f, -2.81542331e-01f, -2.09526196e-01f, 8.35436117e-03f, -3.65699679e-02f,
  2.52043717e-02f, -1.59740344e-01f, -3.17973383e-02f, 1.50689274e-01f, -2.49437585e-01f, -7.73320114e-03f, 4.20543402e-02f, 7.03005493e-02f, -1.07301408e-02f, 3.47506404e-02f,
  5.68712167e-02f, 7.70724043e-02f, 1.45268738e-01f, 1.93671405e-01f, -8.58307257e-02f, -1.17582209e-01f, 1.21241674e-01f, -8.74672905e-02f, 2.78370529e-01f, -1.06245369e-01f,
  -9.71194655e-02f, 1.48176057e-02f, 3.59012820e-02f, -1.32697120e-01f, 1.14747249e-01f, -6.72558397e-02f, 8.48884508e-02f, -2.13815346e-01f, 1.02880493e-01f, 1.12622194e-01f,
  8.27514529e-02f, -6.28205165e-02f, -2.49326304e-02f, 1.44795775e-01f, -2.09932044e-01f, -1.51924551e-01f, 1.60074830e-02f, 1.73831195e-01f, -1.26842856e-01f, 3.14131305e-02f,
  -1.57210723e-01f, 1.91077501e-01f, -9.97974798e-02f, 5.94887994e-02f, 1.13074772e-01f, 2.48549700e-01f, 1.04051791e-02f, -2.02632889e-01f, -1.62232611e-02f, 2.58101702e-01f,
  7.54979625e-02f, 3.51557553e-01f, 1.87214255e-01f, 1.17617883e-01f, 2.07672372e-01f, 1.73507959e-01f, -1.57172695e-01f, -1.73190862e-01f, 1.33368343e-01f, -1.10700712e-01f,
  -2.83259414e-02f, -2.14524850e-01f, 1.66579947e-01f, 2.19811630e-02f, -3.36731076e-02f, 1.69437692e-01f, 3.64115328e-01f, -1.65710241e-01f, -3.79603244e-02f, -5.99096827e-02f,
  -6.30501583e-02f, 1.25217088e-03f, 9.81708840e-02f, -1.48084372e-01f, -4.32542115e-02f, -3.18756700e-02f, 8.32398310e-02f, -2.06080958e-01f, 4.90158945e-02f, 1.38282180e-01f,
  -5.02550602e-02f, 1.31274937e-02f, 8.83352831e-02f, -9.53529216e-03f, 1.94954723e-01f, 5.40005341e-02f, 1.44978076e-01f, 4.10736203e-02f, 3.25071369e-03f, 6.58406615e-02f,
  6.78847060e-02f, -2.44484350e-01f, 1.92523465e-01f, -3.07069719e-02f, -1.41774014e-01f, -1.52096609e-02f, 1.31435111e-01f, -9.89217088e-02f, -1.62325859e-01f, -1.00934354e-03f,
  -5.64873628e-02f, -1.31488650e-03f, 9.42878127e-02f, -3.21116984e-01f, -1.48878604e-01f, -2.74991333e-01f, -2.46954128e-01f, 1.62142292e-01f, 8.62584170e-03f, 2.20524758e-01f,
  5.35090119e-02f, -1.95659027e-01f, -5.74749373e-02f, 3.08000185e-02f, 1.41593874e-01f, -1.73881054e-01f, 2.81592727e-01f, 4.65020014e-04f, -4.50931527e-02f, 9.46822464e-02f,
  -2.53266678e-03f, -9.40482914e-02f, 6.80358857e-02f, -2.46903703e-01f, -2.06548572e-01f, -3.22261155e-01f, -1.07238241e-01f, -2.08939999e-01f, 1.58117741e-01f, -9.32276249e-02f,
  3.09672117e-01f, -3.49540934e-02f, -1.02985233e-01f, -8.27677622e-02f, -1.31455362e-01f, 6.49874434e-02f, -1.75980870e-02f, 7.58549944e-02f, -1.36572182e-01f, 8.57948512e-02f,
  4.21037488e-02f, -1.87801812e-02f, -7.90641904e-02f, 1.23845026e-01f, 2.29342669e-01f, 3.66102718e-02f
};

// L1_fan_Wp_bar (Shape: 26 x 64)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  2.40310073e-01f, 1.27401203e-01f, 2.76921988e-01f, -4.79628779e-02f, 1.45366147e-01f, 2.02328458e-01f, 2.10410859e-02f, 1.43894330e-01f, 2.44436756e-01f, 7.77540207e-02f,
  1.84958294e-01f, -1.20648472e-02f, -1.33849289e-02f, 2.91843176e-01f, 2.63240486e-01f, -7.91954994e-03f, -1.25651225e-01f, 2.07700908e-01f, 4.19881716e-02f, 2.47909114e-01f,
  -2.88039267e-01f, 1.15690909e-01f, 1.58765197e-01f, -2.03277916e-01f, -1.32129699e-01f, 3.18406969e-02f, 1.24330312e-01f, 1.19993806e-01f, -2.92258292e-01f, -2.96396345e-01f,
  4.25314993e-01f, 2.48318017e-01f, -8.74015316e-02f, 1.44812018e-01f, -4.30706628e-02f, 1.03822060e-01f, 5.46738952e-02f, -4.11415771e-02f, -9.82961953e-02f, 1.14155091e-01f,
  -9.93227959e-02f, -7.33667538e-02f, 2.01660320e-01f, 1.73732117e-01f, 2.73639467e-02f, 1.06430680e-01f, -7.35328496e-02f, 1.52568907e-01f, -1.37916222e-01f, -9.07684639e-02f,
  2.42802992e-01f, 3.60406339e-02f, -7.36527592e-02f, -9.87788439e-02f, 7.04438835e-02f, -1.01817749e-01f, 8.55015963e-02f, -1.17142566e-01f, -1.49785113e-02f, -4.08745930e-02f,
  -7.88107514e-02f, -1.69258967e-01f, -1.15347944e-01f, 1.95931047e-01f, 1.50450006e-01f, -2.48182695e-02f, 1.59119055e-01f, 6.28929809e-02f, -5.59534989e-02f, 1.55948296e-01f,
  9.76020768e-02f, 4.38776314e-02f, 1.71469375e-01f, 4.08433005e-02f, -8.24068394e-03f, -2.81356648e-02f, 2.57832706e-02f, 3.22610319e-01f, 1.98541641e-01f, 8.36513713e-02f,
  7.40283355e-02f, 1.50057763e-01f, 3.27919647e-02f, 3.14464182e-01f, -8.59436169e-02f, -9.54006389e-02f, -8.27712491e-02f, -2.61555016e-01f, -1.95139065e-01f, 2.51835257e-01f,
  -2.67754793e-01f, 1.28895804e-01f, -1.28830001e-01f, -1.09509282e-01f, 6.98058233e-02f, 2.08909377e-01f, 1.47724435e-01f, 2.03253180e-01f, 8.43704641e-02f, -2.15414464e-01f,
  -7.06247007e-03f, 3.03377569e-01f, -2.93178707e-02f, 3.13112378e-01f, 1.03714824e-01f, -1.66993707e-01f, 2.03868058e-02f, -8.22920203e-02f, -8.21744874e-02f, 3.80616598e-02f,
  -1.09794103e-02f, -1.97727755e-01f, 8.60416740e-02f, 3.70665118e-02f, -1.20431976e-02f, 7.89634436e-02f, 3.15798335e-02f, 3.56044620e-02f, 2.25333393e-01f, 2.04185452e-02f,
  5.58415763e-02f, 1.33973688e-01f, 1.95298791e-01f, 2.09824592e-01f, -5.77226654e-02f, 1.18698506e-02f, -1.06207393e-01f, 8.80687907e-02f, -9.32466090e-02f, -7.39423558e-03f,
  7.14163780e-02f, 2.33593270e-01f, 9.82583687e-02f, 1.05999494e-02f, 6.45450205e-02f, 1.06262989e-01f, 3.30371130e-03f, 1.07057989e-01f, -6.96418295e-03f, 1.48406163e-01f,
  1.98041782e-01f, -3.82771008e-02f, 6.31775940e-03f, 3.04284110e-03f, -1.69167176e-01f, -4.27645911e-03f, 4.63787094e-02f, -3.87723628e-03f, 1.33683264e-01f, 3.80902648e-01f,
  7.69717768e-02f, 1.21498823e-01f, 3.84237058e-02f, -5.88849839e-03f, -5.50374724e-02f, -3.66622210e-01f, -1.12407282e-01f, 2.47677311e-01f, -9.90870148e-02f, 4.39437889e-02f,
  9.82746333e-02f, 2.55240858e-01f, -2.33442053e-01f, 4.36137319e-02f, 1.13485016e-01f, -1.71341255e-01f, 6.06523864e-02f, 3.08479309e-01f, -2.20840901e-01f, 1.09071463e-01f,
  2.13668346e-01f, 1.16957031e-01f, 3.36739331e-01f, 9.18688774e-02f, 1.50349392e-02f, 2.73493588e-01f, -2.90770918e-01f, 2.93633454e-02f, 3.24544571e-02f, -6.65066391e-02f,
  -1.73896439e-02f, -1.42209768e-01f, 1.16956495e-01f, -1.24174893e-01f, 4.46683288e-01f, -6.13829009e-02f, -1.26961693e-01f, 2.32352227e-01f, 1.98230222e-01f, -2.54446287e-02f,
  -1.06272116e-01f, 9.62270796e-02f, -1.02426466e-02f, -1.16564870e-01f, -1.03210267e-02f, -2.35775150e-02f, -9.27442610e-02f, -5.82616068e-02f, 4.84542660e-02f, -6.48030415e-02f,
  -9.86829177e-02f, -2.99859419e-02f, -5.48085794e-02f, -7.84434006e-02f, -2.95924153e-02f, -4.70731370e-02f, 9.61142182e-02f, -4.79001105e-02f, -3.71890776e-02f, -9.46292877e-02f,
  1.05318330e-01f, -1.80133078e-02f, -7.14707896e-02f, -1.02040693e-01f, 1.51161673e-02f, -2.31902823e-02f, 6.43010139e-02f, -1.07222602e-01f, -7.07612634e-02f, 4.22552340e-02f,
  -4.31278050e-02f, -6.01399541e-02f, -9.83398929e-02f, -1.06789274e-02f, 8.32041427e-02f, 1.39503628e-01f, 6.91668224e-03f, 2.64204536e-02f, 3.98988798e-02f, 8.76147076e-02f,
  4.39217575e-02f, -4.48515937e-02f, -3.17677297e-02f, 1.10187061e-01f, 7.79599845e-02f, 3.52888322e-03f, 1.23881452e-01f, 6.92821145e-02f, -9.70285833e-02f, 2.53956765e-02f,
  -7.58226290e-02f, 7.12229982e-02f, -1.87013410e-02f, 7.79218823e-02f, 9.75050628e-02f, 1.15054369e-01f, 6.79087192e-02f, -5.44006564e-02f, -9.61759984e-02f, -1.53790247e-02f,
  7.76993781e-02f, -5.57510965e-02f, -2.18979139e-02f, -3.26902978e-02f, -1.13904640e-01f, -6.19809367e-02f, -9.28113237e-03f, -3.22817452e-02f, -1.49345212e-03f, 1.07504167e-01f,
  -3.39825042e-02f, -7.14816079e-02f, -1.24275908e-01f, -6.36612773e-02f, 1.24219002e-03f, -1.23102972e-02f, -6.25470206e-02f, -2.73023788e-02f, 4.17702571e-02f, 5.02295643e-02f,
  -2.04099547e-02f, -2.19543967e-02f, -1.17818519e-01f, 1.19247578e-01f, 9.80531871e-02f, 3.70117016e-02f, -2.14722473e-02f, 5.70354760e-02f, -6.98739488e-04f, -1.34156376e-01f,
  -6.14025220e-02f, 6.34700134e-02f, 1.18345656e-01f, -6.76768273e-02f, -1.27314121e-01f, -1.39556333e-01f, 1.11701563e-01f, 2.50146519e-02f, 1.00263335e-01f, -6.54767901e-02f,
  -8.03404897e-02f, -6.32373691e-02f, 2.99402811e-02f, 5.45296073e-02f, -1.02013372e-01f, 5.67789301e-02f, 4.95536290e-02f, 1.14927277e-01f, -4.65276428e-02f, 9.53480303e-02f,
  1.04361903e-02f, 6.92242477e-03f, 1.06806107e-01f, 1.14470072e-01f, 1.19003884e-01f, -3.38323563e-02f, -2.47291867e-02f, 2.91729961e-02f, 1.07047796e-01f, -8.91910866e-02f,
  1.14195822e-02f, 3.03052720e-02f, 1.35790065e-01f, -5.04110716e-02f, -2.17966866e-02f, 8.44912454e-02f, -5.41512817e-02f, 2.91278232e-02f, -9.83710736e-02f, -6.64491132e-02f,
  -1.00903571e-01f, -1.03284881e-01f, 5.17448038e-02f, -8.09807256e-02f, -3.45173106e-02f, 6.64811023e-03f, -1.38093755e-01f, 3.15661505e-02f, 5.96212707e-02f, -7.80080957e-03f,
  1.00068800e-01f, 5.36619127e-02f, -3.59744369e-03f, -1.09324969e-01f, 5.20557091e-02f, -7.90028125e-02f, -1.34843484e-01f, -1.20677590e-01f, -3.02956514e-02f, 3.99362259e-02f,
  -1.31430969e-01f, -8.47035050e-02f, -9.78455618e-02f, -7.12698847e-02f, 2.86272485e-02f, 3.58419977e-02f, 1.33489138e-02f, 2.93486286e-02f, 5.57010509e-02f, -5.40171191e-02f,
  -1.37522034e-02f, -4.47179526e-02f, -1.15884468e-01f, 1.17602058e-01f, 9.02551934e-02f, 1.38421819e-01f, 9.23777446e-02f, 9.05247871e-03f, -8.18250924e-02f, 1.97252352e-02f,
  -7.84745216e-02f, 1.62971411e-02f, 6.10788055e-02f, 7.16004223e-02f, 7.87135661e-02f, 1.15112111e-01f, 1.81562882e-02f, 9.33142304e-02f, -4.82632630e-02f, -1.69388521e-02f,
  1.99210388e-03f, 6.92782849e-02f, 6.45192415e-02f, -1.14630222e-01f, 1.51330397e-01f, -2.68248953e-02f, 3.18654627e-02f, -6.07088394e-03f, -9.14658830e-02f, -2.72641238e-02f,
  -1.95302200e-02f, -7.44177252e-02f, 3.64448763e-02f, 7.35016093e-02f, -3.12400237e-02f, 5.39857522e-02f, 3.11305150e-02f, -2.73434762e-02f, 1.06071495e-01f, -8.85353535e-02f,
  -1.94509830e-02f, -1.03629502e-02f, 6.79937452e-02f, -4.12785411e-02f, -9.50857252e-02f, -7.41556734e-02f, -9.95328873e-02f, -8.26356858e-02f, 9.30872411e-02f, 4.88355570e-02f,
  -1.11546166e-01f, 6.88278070e-03f, 1.99824702e-02f, -3.68842334e-02f, -1.76493645e-01f, 8.55189748e-03f, 1.95365641e-02f, -1.58336490e-01f, 1.90356225e-02f, 5.85009009e-02f,
  5.66727109e-02f, -1.09869748e-01f, -1.35737304e-02f, 3.72558683e-02f, -6.76842332e-02f, -4.70077172e-02f, 8.99734721e-02f, -2.41407901e-02f, -6.03112467e-02f, 5.14108837e-02f,
  6.83288723e-02f, -2.03738268e-02f, 7.73885287e-03f, 2.50481486e-01f, 1.04731210e-02f, 3.07800830e-03f, -3.31888720e-02f, -2.91032735e-02f, -1.79756284e-02f, -2.23307591e-02f,
  6.20721541e-02f, 1.79387778e-01f, 2.19932839e-01f, 4.49753553e-02f, 1.08035594e-01f, 9.90355089e-02f, -1.27098694e-01f, -2.43548136e-02f, -3.00158989e-02f, 1.03416674e-01f,
  3.90798785e-02f, 5.72516434e-02f, -3.54575627e-02f, 3.44443554e-03f, 7.91490749e-02f, 1.13605231e-01f, -2.14353763e-02f, 7.88703375e-03f, 5.71695231e-02f, 1.35474429e-01f,
  1.11856870e-01f, -4.44618724e-02f, 2.40846261e-01f, 8.20613950e-02f, -4.74192537e-02f, -6.60635997e-03f, 2.12674029e-02f, 2.65335977e-01f, 1.38779551e-01f, -9.55901071e-02f,
  -2.25689970e-02f, 2.91763395e-02f, 1.11879610e-01f, 2.33991459e-01f, 1.83289602e-01f, 9.07899067e-02f, 1.40011609e-01f, -7.41091594e-02f, -5.83099062e-03f, -7.39935040e-02f,
  1.27732173e-01f, 1.05591148e-01f, 1.08927161e-01f, -1.90099657e-01f, 3.69410485e-01f, -8.17705989e-02f, 8.79527405e-02f, -7.68145872e-03f, 1.15213022e-01f, -4.09510061e-02f,
  -6.30597770e-02f, -2.32409105e-01f, -2.48002350e-01f, 4.00620997e-02f, -4.67860047e-03f, 7.30826184e-02f, 1.17539853e-01f, -8.99177939e-02f, 2.71437634e-02f, 2.04174995e-01f,
  4.66822982e-02f, -3.90108153e-02f, 8.15565586e-02f, -1.04663059e-01f, 1.06515996e-01f, -1.09017054e-02f, -1.76442578e-01f, 1.80585861e-01f, 1.00127108e-01f, -3.22237499e-02f,
  -1.04510322e-01f, -1.86958332e-02f, -1.23424463e-01f, 8.15404728e-02f, -2.23327741e-01f, -6.45366684e-02f, -8.38634893e-02f, -9.73520279e-02f, -1.80110149e-02f, -1.36900261e-01f,
  1.85198873e-01f, 5.95872700e-02f, 1.24888227e-03f, 8.75332132e-02f, -6.20783232e-02f, 1.89261049e-01f, 1.36240199e-01f, 1.79464057e-01f, 1.34280860e-01f, 1.11637332e-01f,
  -7.39563257e-02f, 7.92322382e-02f, -1.83779560e-02f, -2.82939170e-02f, 6.02272116e-02f, 1.40395254e-01f, -1.16868474e-01f, 4.41347510e-02f, -1.15255646e-01f, 5.31049706e-02f,
  -4.53884788e-02f, -4.53205295e-02f, 1.71524286e-01f, 1.12217791e-01f, -1.69250462e-02f, 1.56984270e-01f, -4.06213589e-02f, 3.70764583e-02f, -4.22571823e-02f, -2.75328398e-01f,
  3.49134617e-02f, 5.15205935e-02f, -1.49927437e-01f, -1.90778360e-01f, 3.60333780e-03f, 1.09637260e-01f, -3.96784991e-02f, 5.66588622e-03f, 1.85781300e-01f, -7.23536089e-02f,
  1.18100174e-01f, -1.98680952e-01f, 8.15645754e-02f, -6.21915758e-02f, 3.46382186e-02f, 2.12906692e-02f, 1.99878901e-01f, -6.62965253e-02f, 1.23545773e-01f, 1.52882248e-01f,
  -1.00158982e-01f, 1.59433350e-01f, 4.22989689e-02f, -9.06962603e-02f, 8.23449194e-02f, 1.00501537e-01f, 2.10547045e-01f, 1.45899594e-01f, -1.76210469e-03f, 5.44064231e-02f,
  1.55178951e-02f, -9.85712931e-03f, 7.33563527e-02f, -8.85739699e-02f, -1.48381433e-02f, 1.02296390e-01f, 3.35638046e-01f, 1.16320685e-01f, 4.89589833e-02f, 7.12807477e-02f,
  1.23165920e-02f, 9.32209492e-02f, -9.18186754e-02f, 6.19382970e-03f, -3.94933112e-02f, -1.05278596e-01f, 1.57380760e-01f, 9.43732932e-02f, 2.06061333e-01f, -3.02302931e-02f,
  1.81077957e-01f, 2.11988427e-02f, -2.12328196e-01f, 6.57071942e-04f, 3.96969030e-03f, 8.03712979e-02f, 7.04297004e-03f, 2.15102300e-01f, 8.45223889e-02f, -7.79473037e-02f,
  -1.66608796e-01f, 8.20044950e-02f, 1.47657141e-01f, -4.04999554e-02f, -1.62685022e-01f, -5.28063858e-04f, -4.03430276e-02f, -1.33013591e-01f, 4.69771400e-02f, 1.69880062e-01f,
  2.84550339e-01f, 3.66551965e-01f, 3.26392442e-01f, -1.87216282e-01f, -4.68975790e-02f, 3.21227282e-01f, 5.31726927e-02f, 1.20105576e-02f, 5.51315136e-02f, -1.58947259e-02f,
  2.30559394e-01f, -1.69682875e-01f, -1.48085102e-01f, 3.04499090e-01f, 1.60456926e-01f, -6.80034235e-02f, 1.32327722e-02f, -4.75049019e-02f, 4.20802273e-02f, -2.34650765e-02f,
  2.00779796e-01f, 9.08809453e-02f, 9.04690102e-02f, -4.69311215e-02f, 2.70179426e-03f, 5.62365539e-02f, 6.02751523e-02f, 9.57659632e-02f, 6.95535913e-02f, 8.38566944e-02f,
  1.56047806e-01f, -2.47774627e-02f, -6.75367266e-02f, -4.32907268e-02f, -3.52322944e-02f, -6.55712234e-03f, -2.13928819e-02f, 3.68659198e-03f, 8.88574049e-02f, -1.96501151e-01f,
  -8.19631293e-02f, -1.12140924e-01f, 7.29367584e-02f, 1.23466507e-01f, 2.35989988e-02f, 1.22620367e-01f, -1.06305242e-01f, 1.11114696e-01f, -8.16045403e-02f, -4.47601900e-02f,
  7.24978149e-02f, 1.01105839e-01f, -7.79614300e-02f, 2.65393537e-02f, -2.21525300e-02f, -4.43423614e-02f, 6.57190606e-02f, 8.23260620e-02f, 9.85298753e-02f, -3.89108099e-02f,
  -9.26238894e-02f, 8.68765339e-02f, 2.99190767e-02f, 1.23960949e-01f, 8.52858126e-02f, -3.36237773e-02f, 9.10429731e-02f, -6.51037646e-03f, -5.54649010e-02f, -5.17935678e-02f,
  4.38587135e-03f, 7.22681135e-02f, -7.94779956e-02f, -1.75723266e-02f, 1.71212405e-01f, 9.72262695e-02f, -1.18682161e-01f, 5.52312285e-02f, 1.53460786e-01f, 8.09274986e-02f,
  2.76918960e-04f, -5.20390160e-02f, -4.01741043e-02f, 1.08990736e-01f, -6.52221069e-02f, -8.08786377e-02f, -9.66488570e-02f, -5.40392287e-02f, 5.25663840e-03f, 3.07108201e-02f,
  4.38830219e-02f, -3.42967995e-02f, 5.93589805e-02f, -5.00265323e-02f, -2.22822968e-02f, 3.68716009e-02f, 1.94483763e-03f, 1.74865708e-01f, 2.18662769e-01f, 8.29780921e-02f,
  -1.67423949e-01f, 1.08331367e-01f, 5.83292469e-02f, 2.14274958e-01f, 9.53776240e-02f, 8.73174667e-02f, 1.77411228e-01f, 1.86966717e-01f, 6.10620566e-02f, 1.07390255e-01f,
  1.44533619e-01f, 1.74195673e-02f, -4.64381725e-02f, -4.00407314e-01f, 5.86395934e-02f, -3.77614461e-02f, -2.75374204e-01f, -4.92574163e-02f, 1.54587567e-01f, -2.18267336e-01f,
  1.41141862e-01f, -3.05056959e-01f, 1.99079439e-01f, 2.82049149e-01f, -1.58498675e-01f, -2.25284979e-01f, 7.28389621e-02f, -2.84765333e-01f, -2.34322280e-01f, 5.61631173e-02f,
  -1.97965845e-01f, -1.27019614e-01f, 1.33421674e-01f, 3.00662667e-01f, -6.96962029e-02f, 2.41820112e-01f, -1.54131219e-01f, -7.83984587e-02f, -1.79099917e-01f, -8.23134650e-03f,
  2.03564912e-01f, 2.45494470e-02f, 2.86792442e-02f, 2.03508675e-01f, 1.65931702e-01f, -1.32349074e-01f, 1.81049742e-02f, 1.69166494e-02f, -1.46201178e-01f, -9.51942205e-02f,
  1.10650137e-01f, 2.19935238e-01f, -7.26399198e-02f, 1.77970111e-01f, 1.37137786e-01f, 9.47599858e-02f, 2.33124420e-01f, 6.54936209e-02f, 2.51541939e-02f, -7.05110058e-02f,
  1.35076232e-02f, 1.03079371e-01f, 2.32338142e-02f, 8.73471126e-02f, 1.14703499e-01f, 3.05347517e-03f, 8.36599432e-03f, 2.20040008e-01f, 1.13032117e-01f, 7.60596246e-02f,
  -7.75600746e-02f, -5.72751723e-02f, 9.15773138e-02f, 1.34021208e-01f, 1.36646554e-01f, 1.96683779e-01f, 1.12550743e-01f, 1.95838496e-01f, -8.68753120e-02f, 6.49363846e-02f,
  -9.02962014e-02f, -4.02056091e-02f, 1.38516873e-01f, -1.19042188e-01f, -9.66043547e-02f, -6.01072349e-02f, -3.22660916e-02f, -4.31501418e-02f, 2.16959506e-01f, 2.01649264e-01f,
  -1.08486697e-01f, 2.46736541e-01f, -1.61392465e-01f, 5.85381426e-02f, -1.90721065e-01f, 2.24367380e-02f, -6.95993146e-03f, -3.94760780e-02f, -8.69624093e-02f, -2.58478727e-02f,
  1.50619134e-01f, -1.00896001e-01f, 5.74019328e-02f, -6.49342034e-03f, -1.09601349e-01f, 4.75578457e-02f, -6.25961795e-02f, -4.39466983e-02f, 1.51273534e-01f, 1.30639952e-02f,
  1.03899255e-01f, -4.02024575e-02f, 5.95344789e-02f, 5.25006168e-02f, 1.28635630e-01f, -2.16793176e-02f, -4.60629910e-02f, 4.06769179e-02f, -1.07331857e-01f, -1.80344447e-01f,
  3.25846039e-02f, -4.41875271e-02f, 2.59943660e-02f, 1.53367538e-02f, 3.06124911e-02f, -8.61295983e-02f, 8.20740759e-02f, 2.40003288e-01f, 1.81276381e-01f, 1.96807206e-01f,
  -8.38318542e-02f, 1.42646566e-01f, -1.23862855e-01f, -1.30145088e-01f, -1.42327130e-01f, -7.61944044e-04f, 1.30702951e-03f, -1.33684333e-02f, 4.29892726e-02f, 6.98895901e-02f,
  -1.76432654e-01f, -1.33854104e-02f, -6.79170787e-02f, 3.74008119e-02f, 4.62453887e-02f, -2.58362025e-01f, -1.37068614e-01f, 1.41978383e-01f, 1.92451864e-01f, -3.49564582e-01f,
  -7.05148205e-02f, 5.03001213e-02f, -2.10634977e-01f, -2.93228507e-01f, 2.25354403e-01f, -4.10850763e-01f, -3.18234204e-03f, -2.77878582e-01f, 2.20490973e-02f, -1.56634003e-02f,
  2.96588079e-03f, -6.30612373e-02f, 6.35038018e-02f, 1.59126353e-02f, 1.34839013e-01f, 1.14418410e-01f, -1.14081375e-01f, 1.16119877e-01f, 1.00588046e-01f, 5.69646731e-02f,
  -6.47043660e-02f, 2.37724915e-01f, -5.25356755e-02f, 3.31969783e-02f, -3.96676548e-02f, 1.05104774e-01f, 1.13313973e-01f, 1.45687580e-01f, -1.05928257e-01f, -6.80435821e-02f,
  -4.48638722e-02f, 2.25378141e-01f, 1.96959406e-01f, 8.85488018e-02f, 2.17896879e-01f, 7.37605840e-02f, -7.77428001e-02f, 1.77084599e-02f, 1.23713044e-02f, -1.55460954e-01f,
  2.04732418e-01f, 1.44156918e-01f, -8.49933624e-02f, -3.14359292e-02f, -1.08351924e-01f, 1.14408836e-01f, 5.28990701e-02f, 8.26433897e-02f, -1.48891546e-02f, 1.36396885e-01f,
  -5.81888966e-02f, -1.05492592e-01f, 1.72189564e-01f, 1.79450452e-01f, -6.99968338e-02f, -1.80196851e-01f, 1.05643287e-01f, 6.85567483e-02f, -3.36267650e-02f, -1.89062089e-01f,
  1.39368847e-02f, -8.47273041e-03f, -1.26097471e-01f, -3.34756613e-01f, -4.35654595e-02f, 2.05021754e-01f, -2.47702330e-01f, -6.64949045e-02f, 1.62500307e-01f, -2.11326733e-01f,
  1.80410743e-02f, -1.67911440e-01f, 5.86945331e-03f, -1.95088804e-01f, 4.38157730e-02f, 1.42520443e-01f, 2.66776010e-02f, 3.67052760e-03f, 1.08735919e-01f, -8.82091224e-02f,
  -1.84344262e-01f, -5.27925119e-02f, 1.93509564e-01f, 1.28565103e-01f, -1.44530386e-01f, 1.84413835e-01f, -8.84368271e-02f, 8.76060203e-02f, -8.39360729e-02f, -7.74147548e-03f,
  1.48865521e-01f, 6.52557164e-02f, 2.07517430e-01f, -2.51673125e-02f, 8.31257999e-02f, 1.41553938e-01f, 1.24259531e-01f, 4.62845154e-02f, 2.07854390e-01f, -3.51149961e-02f,
  8.88274685e-02f, -1.88755523e-02f, 1.33705689e-02f, -6.19735345e-02f, -5.37110195e-02f, -4.39059287e-02f, -3.28524411e-02f, 1.33543432e-01f, -5.79038374e-02f, -5.75789884e-02f,
  -1.22218333e-01f, -5.19815236e-02f, 3.68366092e-02f, 1.07231162e-01f, 2.90337335e-02f, 7.07121119e-02f, -3.02273221e-02f, -2.77874116e-02f, -1.02835774e-01f, -6.92600831e-02f,
  -9.59515050e-02f, -7.02780858e-02f, 4.62977327e-02f, -4.57804874e-02f, 2.65296232e-02f, -4.72126380e-02f, 1.22951146e-03f, -8.08641165e-02f, 2.44149622e-02f, 1.16485646e-02f,
  1.29163548e-01f, 8.00096840e-02f, 5.01648076e-02f, -1.95765700e-02f, -8.53730813e-02f, -1.65682249e-02f, -1.09181233e-01f, 2.72139013e-02f, -1.02226198e-01f, 1.31913841e-01f,
  -6.59680739e-02f, 8.20757821e-02f, -8.07909220e-02f, 1.15122557e-01f, 1.14926465e-01f, 5.79957925e-02f, -1.00224160e-01f, -6.79035857e-02f, -1.15118563e-01f, -4.53520147e-03f,
  -6.46644235e-02f, -1.18983127e-01f, 5.60201220e-02f, 5.76497987e-03f, -1.11859113e-01f, 2.96999365e-02f, 1.85120806e-01f, -6.40877485e-02f, 5.57368547e-02f, 1.15271574e-02f,
  7.59914666e-02f, 9.35382247e-02f, 4.09262814e-02f, 1.07861161e-01f, 1.93924025e-01f, 1.35977063e-02f, 5.64671345e-02f, -7.79796466e-02f, 7.25957826e-02f, 4.59201969e-02f,
  8.86368826e-02f, 1.29282683e-01f, -7.75886178e-02f, 3.80401723e-02f, -9.21683665e-03f, -5.34026176e-02f, 1.83781028e-01f, -1.71080753e-02f, 1.73542619e-01f, -4.35609482e-02f,
  -2.00172067e-01f, 1.04966424e-02f, -6.28081858e-02f, 9.73896906e-02f, -2.30306658e-04f, 1.95132405e-01f, 1.69109464e-01f, 1.45469859e-01f, 1.00641921e-01f, -4.00858112e-02f,
  3.73703279e-02f, -3.28534655e-02f, 4.98524271e-02f, -8.08074325e-02f, 4.51029949e-02f, 9.54137295e-02f, 2.00547934e-01f, 1.50345877e-01f, 1.05717883e-01f, -1.67340428e-01f,
  2.77833968e-01f, -9.64410454e-02f, -7.90218785e-02f, 3.33574504e-01f, -2.39458922e-02f, -5.79911433e-02f, 1.44347250e-01f, 8.51088166e-02f, 2.36677434e-02f, 9.41822082e-02f,
  -1.78811848e-01f, 2.61988610e-01f, 1.80235520e-01f, -4.28732522e-02f, 1.29566208e-01f, 8.91492069e-02f, 5.24060987e-02f, -6.42424449e-02f, 1.53605744e-01f, 3.22299562e-02f,
  2.07491860e-01f, -6.48413524e-02f, 8.45301822e-02f, 1.27353966e-02f, 3.99994291e-02f, 4.29403372e-02f, 1.43188596e-01f, 1.09463774e-01f, 1.59834981e-01f, -7.57638365e-02f,
  -7.68113434e-02f, 7.78459981e-02f, 6.26970008e-02f, -7.09898248e-02f, 7.90712982e-02f, -1.25392243e-01f, -1.03217967e-01f, 3.20556783e-03f, -8.72310475e-02f, 1.23409487e-01f,
  6.62732422e-02f, 5.78341596e-02f, 1.84189603e-02f, -8.53837803e-02f, -1.20951300e-02f, 4.23619412e-02f, -6.83744112e-03f, -6.17021024e-02f, -3.37367244e-02f, 1.62869394e-01f,
  -1.27215460e-01f, 1.75400719e-01f, 1.36971220e-01f, -1.17529295e-01f, 5.66291716e-03f, -1.30508870e-01f, 5.46263978e-02f, 8.61631185e-02f, -2.08240934e-02f, -7.48971403e-02f,
  -8.12318921e-02f, 1.07207246e-01f, -1.93507839e-02f, 6.67406023e-02f, 1.54318595e-02f, 1.12178989e-01f, -6.94757253e-02f, 1.12415608e-02f, 3.74733023e-02f, -6.82923123e-02f,
  -9.74148065e-02f, 1.75328478e-01f, -1.44117661e-02f, 4.16788645e-02f, -1.14412934e-01f, 1.12246946e-01f, 3.40185277e-02f, 1.82211585e-02f, 1.29006710e-02f, 1.00743808e-01f,
  -5.92703000e-02f, -7.49852806e-02f, -1.26288673e-02f, 3.28854695e-02f, 1.77060455e-01f, 1.13753460e-01f, -1.30367056e-01f, 8.86645764e-02f, -8.86401311e-02f, 7.89702758e-02f,
  -6.90227151e-02f, 1.17985338e-01f, 2.49068394e-01f, -7.21633062e-02f, 7.66775745e-04f, 8.82049575e-02f, -1.68298054e-02f, -1.56470478e-01f, 1.06291004e-01f, -2.59263925e-02f,
  -2.15673670e-02f, 2.21056893e-01f, 1.91356137e-01f, 1.27029847e-02f, 2.77434170e-01f, -7.70262256e-02f, 8.23605806e-02f, 1.54203147e-01f, 1.71783686e-01f, 1.09383412e-01f,
  6.11840338e-02f, 1.74062371e-01f, 1.61312014e-01f, 6.56137615e-02f, 1.10066645e-01f, 3.56325269e-01f, 3.34605545e-01f, -7.45703354e-02f, -2.07926356e-03f, 2.63396166e-02f,
  6.00229427e-02f, 5.09701557e-02f, -3.12322797e-03f, -2.75908206e-02f, 1.12366979e-03f, 3.49620551e-01f, -1.32592544e-01f, 4.73792665e-02f, 1.05739295e-01f, -1.13966994e-01f,
  -5.57879321e-02f, 5.76867387e-02f, 7.68161416e-02f, 7.57465232e-03f, 2.47275904e-01f, 1.93333164e-01f, 3.21194261e-01f, 1.25254974e-01f, -1.88161179e-01f, 1.92681178e-01f,
  6.76613674e-02f, -2.67910827e-02f, 3.36923935e-02f, -7.17054382e-02f, -4.37457561e-02f, -1.09444097e-01f, 8.02629143e-02f, -1.08202457e-01f, 2.17683762e-01f, -1.45854264e-01f,
  -9.22113881e-02f, -2.38765180e-02f, -3.45750004e-02f, 7.50432834e-02f, -8.67601633e-02f, -2.05689013e-01f, 1.91833481e-01f, 1.34774327e-01f, -1.45323090e-02f, -1.38401702e-01f,
  1.78809592e-03f, -2.67610513e-02f, 2.83049017e-01f, 2.37052798e-01f, -2.90962923e-02f, 8.94526765e-02f, 1.33994203e-02f, 6.78641722e-02f, 1.50281578e-01f, 5.63386083e-02f,
  -2.83130351e-02f, 3.23183209e-01f, 3.52192789e-01f, 9.91644040e-02f, 1.56350315e-01f, -6.36408851e-02f, 2.44239047e-01f, -1.65979236e-01f, 2.33219728e-01f, 2.64189482e-01f,
  1.81159884e-01f, -7.83988684e-02f, -1.60312593e-01f, 5.09197786e-02f, 9.70174968e-02f, -1.77036375e-02f, -3.61760348e-01f, -1.26453221e-01f, 1.75825775e-01f, -8.16459060e-02f,
  -1.36027202e-01f, -9.39395353e-02f, 9.94847268e-02f, -1.03067912e-01f, 6.39748424e-02f, -2.79526532e-01f, 7.54766315e-02f, 8.06828141e-02f, 2.76272595e-01f, 1.68659076e-01f,
  2.50050426e-01f, 1.01670504e-01f, 1.10503085e-01f, -1.36217130e-02f, 2.05804750e-01f, 2.54643679e-01f, -2.05437899e-01f, 2.31045764e-02f, 1.06182411e-01f, 1.85068697e-01f,
  5.75205833e-02f, 4.12105694e-02f, -1.29017666e-01f, -6.13312647e-02f, 1.39138207e-01f, -1.68577045e-01f, -3.83126996e-02f, 3.85542959e-02f, 3.31950188e-02f, -1.42649859e-01f,
  1.58605099e-01f, 3.26789953e-02f, -1.89001057e-02f, -3.79805639e-02f, -5.20116389e-02f, 9.11897272e-02f, -1.04412362e-01f, -4.76108193e-02f, 1.10280626e-02f, -3.42204496e-02f,
  5.55118918e-02f, 5.18498011e-02f, 1.15480036e-01f, 1.14337273e-01f, 1.33670449e-01f, -6.55277073e-02f, 3.84016261e-02f, -6.95898607e-02f, 7.41174966e-02f, 3.47441733e-02f,
  3.66947521e-03f, 8.59572142e-02f, -3.22593302e-02f, -1.62352249e-01f, -1.65593121e-02f, 9.83806103e-02f, -9.16785076e-02f, 1.53269053e-01f, -7.86813647e-02f, 9.76184905e-02f,
  -6.99521042e-03f, -7.36762807e-02f, 5.17732538e-02f, -2.22894773e-02f, 3.43386643e-02f, 1.27388790e-01f, -8.14566091e-02f, 3.48117277e-02f, -8.25910121e-02f, -1.07515909e-01f,
  4.82106656e-02f, -9.41362418e-03f, -1.29281372e-01f, -3.24254739e-03f, 2.61520613e-02f, 2.95742135e-02f, 2.13027690e-02f, -9.92420763e-02f, -6.53205812e-02f, -1.85753219e-02f,
  9.97022018e-02f, -6.67466521e-02f, -6.67347386e-02f, 3.63680907e-02f, 1.28020644e-01f, 9.63064507e-02f, -1.82057712e-02f, 3.60825583e-02f, 1.29815266e-02f, 3.29416431e-02f,
  -1.06857076e-01f, -5.75424209e-02f, 4.31935005e-02f, 1.09863896e-02f, 9.00913924e-02f, -9.47844759e-02f, -3.21544823e-04f, 2.91433781e-02f, -5.01463078e-02f, 3.41778062e-02f,
  9.35488045e-02f, 1.82340443e-01f, 8.59208405e-02f, 3.46557759e-02f, 2.15623051e-01f, 6.72501475e-02f, 1.36839384e-02f, 1.49195850e-01f, 1.48618907e-01f, 8.44769478e-02f,
  2.44193986e-01f, 1.29137188e-01f, 6.77067437e-05f, 2.20655113e-01f, 7.67858252e-02f, -1.14670835e-01f, 1.63008004e-01f, -2.03391492e-01f, 3.09765507e-02f, 1.96026072e-01f,
  -1.93095624e-01f, 1.13411173e-01f, 1.16672143e-02f, -3.11680622e-02f, -4.20609564e-02f, 5.43890670e-02f, 4.80705500e-03f, 2.08748668e-01f, 1.35069117e-01f, -2.17170551e-01f,
  -4.03012428e-03f, 6.60338402e-02f, -4.52280343e-02f, -1.15788206e-02f, -1.24735445e-01f, 2.55566258e-02f, 2.01190367e-01f, 9.88008901e-02f, 1.40686736e-01f, 1.44126743e-01f,
  -1.63648665e-01f, -3.60777266e-02f, 1.68765977e-01f, -4.12682891e-02f, -6.38147965e-02f, -4.76169251e-02f, -5.73482700e-02f, 2.13661209e-01f, 3.11863810e-01f, 6.26487583e-02f,
  8.97357464e-02f, -9.82664227e-02f, -2.50028515e-05f, 1.06343955e-01f, -6.70476928e-02f, -2.44655944e-02f, -1.78601950e-01f, 8.51718932e-02f, 2.57553041e-01f, 2.14017853e-01f,
  1.55168787e-01f, 9.21038240e-02f, -8.69463850e-03f, 1.55971721e-01f, 6.64839223e-02f, 1.16172716e-01f, 5.75073287e-02f, -8.32016245e-02f, 1.34711742e-01f, 2.59458601e-01f,
  -2.02627908e-02f, 7.97753558e-02f, 1.88590601e-01f, -9.71885249e-02f, -5.71459793e-02f, 1.26204833e-01f, 1.40286922e-01f, 8.67886245e-02f, -2.63524856e-02f, -9.78271887e-02f,
  2.82259345e-01f, -3.06279153e-01f, -2.13914722e-01f, 6.80771470e-02f, -1.52074650e-01f, -6.03864994e-03f, -3.44122857e-01f, -1.35926291e-01f, -1.84233457e-01f, -2.61383802e-01f,
  6.43417835e-02f, -1.85002118e-01f, 3.17115784e-01f, 7.68394396e-02f, 3.03652529e-02f, -2.71303236e-01f, -1.34129198e-02f, -2.32609846e-02f, -1.58143386e-01f, -1.41783312e-01f,
  -9.49522629e-02f, -1.56540960e-01f, -9.98836383e-02f, 1.09954722e-01f, 8.82163420e-02f, 7.09630251e-02f, -5.12143523e-02f, 4.05351259e-02f, 1.22977328e-02f, 5.41075654e-02f,
  -3.69976908e-02f, 1.58488423e-01f, 2.02441469e-01f, 1.42816678e-01f, 2.93097943e-02f, 1.01791039e-01f, 2.21228153e-02f, 2.29101330e-01f, 7.01195449e-02f, -3.66707742e-02f,
  1.21731766e-01f, 9.63823795e-02f, -5.45803318e-03f, 6.13169745e-02f, 1.29744619e-01f, 5.71708195e-02f, 1.72469653e-02f, 1.23471782e-01f, 8.84641558e-02f, 1.38552561e-01f,
  2.75055878e-02f, 5.47649264e-02f, -2.78992616e-02f, -8.49547312e-02f, 2.17778535e-04f, 1.16516978e-01f, 3.65070440e-02f, 7.32477009e-02f, 1.20542452e-01f, -2.84611546e-02f,
  1.76710710e-01f, 1.26866221e-01f, -6.85229078e-02f, 5.18211629e-03f, 1.73248187e-01f, -2.02949606e-02f, -5.59394546e-02f, 1.14476262e-02f, 4.34406549e-02f, -1.75471276e-01f,
  -1.21710338e-01f, -1.12350903e-01f, 2.25789584e-02f, -6.06733840e-03f, -2.30049435e-03f, 1.81231406e-02f, -2.73157418e-01f, -1.88891977e-01f, 1.11560337e-01f, -7.91128501e-02f,
  1.87467158e-04f, 3.92270982e-02f, -3.99629958e-02f, 1.40316591e-01f, 2.26006746e-01f, 2.18888775e-01f, 1.49596229e-01f, 2.72154100e-02f, 1.36965066e-01f, 7.59799950e-05f,
  -1.30254894e-01f, -9.37677845e-02f, 1.34522289e-01f, 1.47049263e-01f, -8.78607780e-02f, -7.26462677e-02f, -1.47622883e-01f, -9.72240865e-02f, 1.75363734e-01f, 9.72890258e-02f,
  -1.27233580e-01f, -3.80978771e-02f, -8.84659141e-02f, -7.48205036e-02f, -1.36616811e-01f, 4.12817225e-02f, -5.54135181e-02f, -6.00697175e-02f, -5.68178669e-02f, -1.24497049e-01f,
  6.00127243e-02f, 1.17143756e-02f, 1.97078556e-01f, 1.95556536e-01f, -2.61054933e-02f, 4.76266034e-02f, 8.55053589e-02f, 9.16202143e-02f, -1.20504484e-01f, 3.76114696e-02f,
  5.57993911e-02f, 3.93046960e-02f, 2.35526875e-01f, 4.04755808e-02f, -1.10030815e-01f, 2.22651102e-02f, -4.77192253e-02f, 3.61041054e-02f, 1.95092678e-01f, 3.07472497e-02f,
  1.38236508e-01f, 8.69666338e-02f, -2.62018740e-01f, -1.83300361e-01f, -8.24730843e-02f, -1.90743450e-02f, -9.76776183e-02f, 2.85924003e-02f, 1.13079011e-01f, -1.73956364e-01f,
  -4.21548299e-02f, -8.86442885e-02f, -1.41797498e-01f, 5.66200633e-03f, 4.39903811e-02f, -7.71107990e-03f, 1.36233401e-03f, 6.12206236e-02f, 2.81227291e-01f, 2.75358230e-01f,
  -1.05238385e-01f, 1.16664469e-01f, -2.03518290e-02f, 1.28386438e-01f, -1.30938981e-02f, 1.37792543e-01f, -8.29788297e-02f, -4.35681492e-02f, 1.11728042e-01f, 1.48366820e-02f,
  1.89964905e-01f, 2.08705768e-01f, 1.35124102e-01f, -1.29348546e-01f, -5.44505306e-02f, -2.65990980e-02f, -4.34963405e-02f, -5.63533790e-02f, 7.62661323e-02f, -5.78678548e-02f,
  -9.18179080e-02f, 1.30225495e-01f, -9.40296426e-03f, 4.02355641e-02f, 6.55212402e-02f, 6.49798568e-03f, -3.57485004e-02f, 1.27079617e-02f, -3.71657312e-02f, -1.23030758e-02f,
  -9.37571153e-02f, -1.07536785e-01f, 1.70601183e-03f, -7.51737803e-02f, 1.57012343e-01f, -2.47468762e-02f, -4.97389734e-02f, 9.76534560e-03f, 7.32877403e-02f, -7.36158341e-02f,
  -5.77411875e-02f, -1.00766286e-01f, 3.88169512e-02f, -1.03974663e-01f, 5.38528711e-03f, -5.28927334e-02f, -1.21236674e-01f, -2.48245858e-02f, -2.90264841e-02f, 1.14036568e-01f,
  1.01790309e-01f, -1.52955577e-02f, -5.63680157e-02f, -3.10434699e-02f, -2.16046926e-02f, -4.34112214e-02f, -3.19290310e-02f, 7.69720525e-02f, 6.15110882e-02f, 9.26086530e-02f,
  8.18239897e-02f, 4.98848371e-02f, -1.25977874e-01f, -2.08447855e-02f, 1.05244368e-01f, -1.14884436e-01f, -8.05712268e-02f, 7.95669481e-03f, 1.88774347e-01f, 2.82247961e-02f,
  7.60939121e-02f, 1.12578250e-01f, 2.55151857e-02f, 4.00301963e-02f, -1.79884247e-02f, -1.49123102e-01f, -4.07015122e-02f, -7.19441772e-02f, 4.94182669e-02f, -1.05841644e-02f,
  -7.64082521e-02f, -2.09319256e-02f, -5.96630108e-03f, -1.01122528e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  6.97727129e-02f, 1.83401212e-01f, 1.87920585e-01f, -5.61477654e-02f, 7.01100379e-02f, -6.25824854e-02f, 3.89791802e-02f, 1.97100684e-01f, -2.68562809e-02f, 2.29257777e-01f,
  1.10782795e-01f, 2.10920200e-01f, 1.60366464e-02f, 9.88905951e-02f, 4.30528373e-02f, 8.45130086e-02f, 1.78352222e-01f, 1.03724614e-01f, -2.35322043e-02f, 9.29725096e-02f,
  -7.94444382e-02f, -1.32565452e-02f, 7.12392032e-02f, -6.96088327e-03f, 4.33705859e-02f, -6.06521554e-02f
};

// L2_linear_W (Shape: 12 x 64)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 64;
const float L2_linear_W_data[] = {
  -1.10436216e-01f, -2.08552510e-01f, -1.64783925e-01f, -8.30452219e-02f, -1.56963050e-01f, -3.68628591e-01f, -3.41989011e-01f, -1.11739904e-01f, 7.95813128e-02f, -4.50504094e-01f,
  -1.42783538e-01f, -4.57608223e-01f, -1.64643034e-01f, -4.72892374e-01f, -1.87673956e-01f, 6.54433146e-02f, -3.72067869e-01f, -3.52328606e-02f, 4.73829620e-02f, 2.10587800e-01f,
  -2.08964810e-01f, 1.14935853e-01f, -2.26901233e-01f, 4.96465228e-02f, -1.72361255e-01f, -1.95299923e-01f, -1.27678275e-01f, -3.24709952e-01f, 1.85529396e-01f, 1.29116371e-01f,
  -3.11264545e-01f, -3.72999609e-01f, 9.27942395e-02f, 1.18406750e-01f, -2.71776527e-01f, 1.36107653e-01f, 3.66148829e-01f, -5.77066466e-02f, 1.29177257e-01f, -2.47819722e-01f,
  2.65679449e-01f, -1.27267823e-01f, -9.11581740e-02f, 9.25377384e-02f, 9.95488763e-02f, -1.47669703e-01f, 2.07320452e-01f, 4.66664851e-01f, -8.17636214e-03f, -3.13051373e-01f,
  -2.29614764e-01f, 3.68788362e-01f, 6.05706573e-02f, 2.28336900e-02f, 3.79293412e-01f, 4.12118025e-02f, -1.78806081e-01f, -3.04220587e-01f, -1.22037068e-01f, 7.55933300e-03f,
  3.30578119e-01f, -1.84822008e-01f, 1.08920671e-02f, -2.82903183e-02f, 1.57987893e-01f, 7.93873519e-02f, 2.99181163e-01f, 2.11505592e-01f, -1.87386647e-01f, 2.32572675e-01f,
  -1.87814031e-02f, -2.84095705e-01f, 5.01243621e-02f, 3.96467447e-01f, 1.80187896e-02f, -1.67869851e-01f, -2.96922296e-01f, -1.72892556e-01f, 9.39326137e-02f, -1.75085276e-01f,
  -2.04346389e-01f, -6.90433681e-02f, -1.59891974e-02f, 1.44508287e-01f, -1.44922510e-02f, -5.44871151e-01f, 1.30498648e-01f, -2.71174926e-02f, -1.76960960e-01f, -5.95380291e-02f,
  -1.09755464e-01f, 2.80710489e-01f, -4.11974527e-02f, 2.36916915e-01f, -4.29122359e-01f, -5.51651955e-01f, 1.59245744e-01f, 3.63539726e-01f, 3.08547974e-01f, -5.21153390e-01f,
  4.36677635e-01f, 5.42451382e-01f, 4.93560463e-01f, 2.49562562e-01f, -2.41048753e-01f, -5.91196679e-03f, 1.47309050e-01f, 1.39049485e-01f, 2.79518932e-01f, -1.84845105e-02f,
  -2.25377500e-01f, 5.21021962e-01f, -4.48610494e-03f, 1.29685625e-02f, -2.12107822e-01f, -2.75230676e-01f, -2.55362898e-01f, 9.51898247e-02f, 3.79104853e-01f, -1.59147948e-01f,
  -1.09847747e-01f, -3.25447887e-01f, 2.57796403e-02f, -1.21649809e-01f, 1.57695726e-01f, 3.40238842e-03f, -4.07917619e-01f, 2.39157677e-01f, -1.87295154e-01f, -2.50085354e-01f,
  2.89206326e-01f, -8.28746185e-02f, -3.20969522e-01f, 2.45325327e-01f, 3.05838585e-01f, 3.38316590e-01f, 5.71316071e-02f, 5.66518232e-02f, 2.66260087e-01f, 3.96155298e-01f,
  2.08701134e-01f, 2.11575061e-01f, 1.92992389e-02f, 1.87224731e-01f, -9.39971581e-02f, 1.77203953e-01f, -3.17435190e-02f, -3.76175910e-01f, -1.83814272e-01f, -4.03653905e-02f,
  -3.16240489e-01f, -1.15402997e-01f, -1.46669045e-01f, -7.73666874e-02f, 2.38527924e-01f, -4.24474657e-01f, 9.17071849e-02f, 1.45449132e-01f, 2.15357140e-01f, -1.74655840e-01f,
  -2.88413018e-01f, -4.45638776e-01f, 4.41873446e-02f, -3.71821016e-01f, -4.90102023e-02f, -4.76002485e-01f, 2.70589799e-01f, -4.65648592e-01f, 2.20732555e-01f, -1.35881384e-03f,
  5.62750809e-02f, -1.08801991e-01f, 6.00390099e-02f, 3.87157679e-01f, 1.46271348e-01f, 2.89328396e-01f, 2.37445552e-02f, 8.86700451e-02f, 2.75714189e-01f, -3.61416072e-01f,
  -3.15118611e-01f, -1.95727274e-01f, -9.78860855e-02f, 1.53490350e-01f, 2.93469101e-01f, -2.14838386e-02f, 1.64263342e-02f, -2.19968155e-01f, -4.58658896e-02f, 8.67067277e-02f,
  -2.78015912e-01f, -9.55805182e-02f, 1.31055489e-01f, 7.78905014e-05f, -2.99675167e-01f, -2.51258999e-01f, 6.12124987e-02f, -3.55447561e-01f, 1.30680919e-01f, -2.25636542e-01f,
  1.20781273e-01f, -1.35405362e-01f, 2.54002400e-02f, 1.09184496e-01f, 6.04274161e-02f, 2.66032338e-01f, -9.73208547e-02f, -6.33165091e-02f, 2.54577901e-02f, 6.59809038e-02f,
  -5.83773673e-01f, -2.35352054e-01f, 8.85271803e-02f, 1.39615089e-01f, 1.80625245e-02f, 1.40693456e-01f, -2.32491240e-01f, -2.70959377e-01f, 1.95585415e-01f, -2.22736388e-01f,
  2.20692590e-01f, 1.28077805e-01f, -1.38861746e-01f, 4.95779753e-01f, -1.54257134e-01f, 9.94631723e-02f, -2.59591430e-01f, -2.20598474e-01f, 2.18842208e-01f, -2.63218522e-01f,
  3.80743928e-02f, -1.25061363e-01f, 4.66093004e-01f, 1.52515098e-01f, -1.73667688e-02f, 1.15244817e-02f, -2.24949032e-01f, -2.65592307e-01f, 1.54906884e-01f, 4.04135138e-02f,
  -2.59267259e-03f, -4.56920117e-01f, 1.73265755e-01f, -3.15794796e-01f, -1.77149564e-01f, -3.40337073e-03f, 1.34706482e-01f, 7.48149604e-02f, 6.31454229e-01f, 3.31890911e-01f,
  -3.16012825e-04f, 3.15669894e-01f, -2.67454177e-01f, 2.07667306e-01f, 1.85887069e-01f, 7.13073909e-02f, -3.06590348e-02f, -5.34486666e-04f, -4.30439115e-01f, -2.63470441e-01f,
  5.42997383e-02f, 1.71505898e-01f, -1.34260222e-01f, -1.36716753e-01f, -3.39535564e-01f, -2.04904795e-01f, 3.95504422e-02f, 3.17438930e-01f, 1.57135889e-01f, 2.75482714e-01f,
  1.93066582e-01f, 2.43951976e-01f, 1.49062991e-01f, -5.92523534e-03f, -6.71015605e-02f, 3.54925960e-01f, -1.63212102e-02f, 7.48311877e-02f, 4.46698628e-02f, -6.01717562e-04f,
  -3.75773698e-01f, -1.23117410e-01f, 1.69419467e-01f, -3.78299117e-01f, 3.52316439e-01f, 2.82112926e-01f, -3.34883571e-01f, -4.39902209e-02f, 3.01123619e-01f, -3.25135072e-03f,
  1.44371569e-01f, -1.28269896e-01f, -3.44965398e-01f, -2.36069426e-01f, -2.43545935e-01f, -3.27066451e-01f, -2.20252350e-01f, -2.96375714e-02f, -9.18750614e-02f, -2.30322808e-01f,
  -4.81693856e-02f, 3.57053220e-01f, 2.99839098e-02f, 1.92208029e-02f, -9.71076414e-02f, 8.79609063e-02f, -1.36182740e-01f, 4.65165943e-01f, 2.87384987e-01f, 1.37061819e-01f,
  9.80743766e-02f, 7.09141418e-02f, 8.30303878e-02f, 5.97160459e-01f, -1.12111844e-01f, 6.53244033e-02f, -2.88261268e-02f, -1.10451289e-01f, 4.54622775e-01f, -5.88257983e-02f,
  -2.20570881e-02f, 1.93048149e-01f, 6.85889646e-02f, 3.07495203e-02f, 1.83868751e-01f, 1.37976974e-01f, 1.48953870e-01f, -1.00690397e-02f, 1.46696150e-01f, 1.80896774e-01f,
  4.46229149e-03f, 2.54887193e-01f, 2.55245239e-01f, 1.23049401e-01f, 2.54412852e-02f, -2.98358470e-01f, 3.97167921e-01f, 8.73465240e-02f, -1.04597555e-02f, 3.76670569e-01f,
  -1.91072717e-01f, 5.25395274e-01f, -2.42956683e-01f, -1.87719569e-01f, 2.22187996e-01f, -5.55039197e-02f, 4.04899895e-01f, 5.32371178e-02f, 3.21963429e-01f, 2.42614523e-01f,
  9.13937613e-02f, -6.98768273e-02f, 4.42776412e-01f, 2.80033331e-04f, 2.29704380e-01f, 4.37214151e-02f, -2.00532511e-01f, 3.28182638e-01f, 2.46892851e-02f, 4.17935312e-01f,
  -2.92232603e-01f, 7.39471763e-02f, -1.35089025e-01f, 1.63615085e-02f, 6.16903156e-02f, -3.34397823e-01f, -1.20218374e-01f, 1.22395925e-01f, -1.06298797e-01f, -5.64078353e-02f,
  -5.10669798e-02f, 1.19143158e-01f, 1.23510614e-01f, -6.19640499e-02f, -1.98387340e-01f, 4.83700447e-02f, -3.81413847e-01f, -7.55378753e-02f, 2.20089242e-01f, 3.72941881e-01f,
  8.22833300e-01f, -2.02272698e-01f, 7.32734054e-02f, -1.12278908e-01f, 5.77496029e-02f, -7.24203438e-02f, 2.83381522e-01f, 3.14319104e-01f, 1.41782910e-01f, -5.45110032e-02f,
  -1.34468243e-01f, -6.71817437e-02f, 3.30818892e-01f, -8.06499422e-02f, 2.86831260e-01f, -3.35785151e-01f, -9.34164524e-02f, -2.13067919e-01f, -2.56946553e-02f, 2.99955010e-01f,
  3.35287377e-02f, 4.21761811e-01f, 2.45911449e-01f, -1.94270983e-01f, -2.52208799e-01f, -4.00111765e-01f, -1.64537862e-01f, -2.59235352e-01f, 4.70541537e-01f, 3.93729478e-01f,
  -3.76253396e-01f, -6.99364096e-02f, -3.12284052e-01f, 1.22535393e-01f, 2.12828144e-01f, 4.77931231e-01f, -4.06786233e-01f, -4.27485526e-01f, -2.98387520e-02f, 2.71338493e-01f,
  -2.31626272e-01f, 7.60169998e-02f, -3.99989843e-01f, -2.59142160e-01f, -5.42790771e-01f, -1.12248190e-01f, 2.68782116e-02f, -4.17857803e-02f, -9.95900780e-02f, 2.71675527e-01f,
  -3.00503522e-01f, -4.24018711e-01f, -1.56670123e-01f, 4.33669627e-01f, -1.76682070e-01f, -1.61999598e-01f, -1.05686098e-01f, -1.15416728e-01f, -3.96712333e-01f, -1.42825022e-01f,
  -5.23818806e-02f, 1.99334487e-01f, -1.11466795e-01f, -2.66303837e-01f, -3.79001856e-01f, -7.56444931e-02f, -7.94963762e-02f, 4.01241221e-02f, -1.78522855e-01f, -1.56501845e-01f,
  2.73773111e-02f, -6.40125796e-02f, 1.01953268e-01f, 8.42195228e-02f, -3.16492170e-01f, -6.62411004e-02f, -8.31586793e-02f, 1.76440924e-02f, -1.76722527e-01f, 1.41132670e-02f,
  -3.89670432e-01f, -2.56902635e-01f, 2.97117941e-02f, -2.08025724e-01f, -2.22620800e-01f, -7.03670904e-02f, -1.25591606e-01f, -2.45209634e-01f, -7.90035650e-02f, 9.56372842e-02f,
  -1.90448359e-01f, 3.45411986e-01f, 4.84720394e-02f, 2.66394854e-01f, -1.16727278e-01f, 1.94060355e-01f, -4.93128113e-02f, -1.23256207e-01f, 7.81462714e-02f, 2.04065755e-01f,
  -1.51741207e-01f, -2.57572919e-01f, -3.53407264e-01f, 2.49765351e-01f, -2.14950547e-01f, -2.14140937e-01f, -1.61451280e-01f, -2.71431021e-02f, 6.24618292e-01f, -4.05011624e-02f,
  9.82006639e-02f, -8.37448463e-02f, 2.01988909e-02f, -2.99912840e-01f, -2.36434639e-01f, 7.93316364e-02f, -8.54258016e-02f, 3.87437195e-01f, 4.31561545e-02f, -1.95346996e-01f,
  2.63669133e-01f, 1.26715183e-01f, 2.77821004e-01f, 3.48214924e-01f, 3.04791719e-01f, -4.74087179e-01f, -1.17769711e-01f, -1.65748343e-01f, -1.86849803e-01f, 3.77324559e-02f,
  8.78875703e-02f, -8.31006616e-02f, -3.03578917e-02f, 2.03208819e-01f, -1.14265375e-01f, -9.05332118e-02f, 3.18753660e-01f, 1.08343720e-01f, 1.32070020e-01f, 2.29753539e-01f,
  -5.18058658e-01f, -3.05252552e-01f, -1.61977410e-01f, -8.75191391e-02f, 1.51420116e-01f, 3.85375619e-01f, 1.03391837e-02f, -3.04661304e-01f, 2.37071797e-01f, 2.24140044e-02f,
  5.82330823e-02f, -1.23876899e-01f, 2.16173589e-01f, -3.08596998e-01f, 5.46425581e-01f, 4.97641228e-02f, 2.27701619e-01f, 3.21224838e-01f, -9.09649506e-02f, 2.04657614e-01f,
  -4.57257926e-01f, -2.32544288e-01f, 3.49481195e-01f, 3.05220842e-01f, -1.00468203e-01f, -3.62233222e-02f, 4.54049617e-01f, 2.05287948e-01f, 2.69609541e-01f, 3.37083817e-01f,
  3.28729093e-01f, 5.33435166e-01f, -3.39071184e-01f, -3.18557732e-02f, -2.50738906e-03f, -8.66128057e-02f, 1.10390648e-01f, 3.37576717e-02f, -1.03311174e-01f, -3.16023499e-01f,
  -1.08414516e-01f, -2.40183190e-01f, 4.06758904e-01f, -1.00366764e-01f, -2.50878245e-01f, -6.34032190e-02f, -1.19681314e-01f, -3.12075932e-02f, -1.56841561e-01f, -3.66381139e-01f,
  -2.56728623e-02f, 3.28940809e-01f, -3.10477734e-01f, -4.08018008e-02f, -2.37308145e-02f, 3.07207368e-03f, -3.21034193e-02f, -3.74389067e-02f, 4.77172919e-02f, 1.27048641e-01f,
  -1.10151470e-01f, 1.92001462e-01f, 1.78802341e-01f, 1.90563381e-01f, 1.53230950e-01f, 6.15184288e-03f, 4.69533075e-03f, -1.07858991e-02f, 3.53883833e-01f, 2.59131789e-01f,
  -3.39984428e-03f, -1.29993543e-01f, 7.49356821e-02f, -3.57609689e-01f, 1.97235137e-01f, 1.95161700e-01f, -5.65920286e-02f, 3.53915602e-01f, -1.18732668e-01f, -9.57920477e-02f,
  1.13240503e-01f, -3.99736106e-01f, 1.25280708e-01f, -1.54724494e-01f, -1.24036022e-01f, -1.34917051e-01f, 2.93297321e-01f, -3.70208740e-01f, -2.75126666e-01f, -1.89571261e-01f,
  -3.95480722e-01f, 2.65161872e-01f, -3.88409704e-01f, 2.71487013e-02f, -4.49170470e-01f, -2.64554381e-01f, 1.74346879e-01f, -6.07161671e-02f, 5.45635261e-02f, 1.11655056e-01f,
  -5.50631508e-02f, 2.54655898e-01f, 3.35687011e-01f, -3.63629133e-01f, 5.11512980e-02f, 6.90201759e-01f, -1.12903230e-01f, 4.34937894e-01f, 4.73005176e-01f, 8.10800493e-02f,
  -3.24009269e-01f, -1.73671171e-01f, -3.89189422e-01f, 3.79777476e-02f, 4.70421929e-03f, -3.72482866e-01f, -5.04671745e-02f, 1.54225111e-01f, -6.12807199e-02f, -4.19521593e-02f,
  7.39203840e-02f, -1.42838389e-01f, 1.26085669e-01f, 5.36115468e-02f, -3.35847259e-01f, -4.23776805e-01f, -4.56164330e-02f, 1.46100044e-01f, 2.04789788e-01f, -4.04372439e-02f,
  -2.96552449e-01f, 1.92888886e-01f, -4.20786142e-02f, 4.30727974e-02f, -9.18915495e-02f, 8.36692154e-02f, -3.90150577e-01f, -1.62444869e-03f, -4.73913997e-02f, -1.15687788e-01f,
  5.96909761e-01f, -2.08359361e-01f, 7.80048817e-02f, -9.81159359e-02f, -4.81199831e-01f, -2.07458869e-01f, 1.80343956e-01f, 1.15641274e-01f, -2.47484908e-01f, -4.87065762e-01f,
  -2.89215725e-02f, -1.71952456e-01f, 3.94383132e-01f, 2.00991884e-01f, 1.72765215e-03f, -1.39005750e-01f, -3.79450142e-01f, -3.11133593e-01f, 5.28740168e-01f, 1.65988907e-01f,
  -6.62068501e-02f, 8.68458524e-02f, 1.18018143e-01f, -1.22987211e-01f, -7.13125616e-02f, 1.29138470e-01f, -2.20660418e-01f, -3.81511897e-01f, 3.66830416e-02f, -4.06540096e-01f,
  3.56729403e-02f, 2.32220769e-01f, -1.70485646e-01f, -6.40983926e-03f, 1.60170227e-01f, -2.83804499e-02f, 2.06909701e-02f, 5.59605658e-03f, -1.84781134e-01f, 2.02953935e-01f,
  7.24872574e-02f, 4.94593173e-01f, 1.61110252e-01f, 9.74737108e-03f, 1.57291591e-01f, 2.16575682e-01f, -1.61400647e-04f, 2.15963617e-01f, -4.20313008e-05f, 7.28869811e-02f,
  2.78901476e-02f, 1.95840284e-01f, 8.18441361e-02f, 2.39448816e-01f, -4.99087609e-02f, -1.89258873e-01f, -1.63328633e-01f, -3.63329381e-01f, 5.58245629e-02f, 2.65183806e-01f,
  1.84730902e-01f, -8.14125538e-02f, -6.44119084e-02f, 1.11258671e-01f, -1.96076319e-01f, 4.57169741e-01f, 4.28230226e-01f, 2.19517931e-01f, 3.68763924e-01f, 2.33489767e-01f,
  -2.22026035e-01f, 2.01190919e-01f, 5.80936484e-02f, -2.81622529e-01f, 2.76721507e-01f, 2.20589221e-01f, -3.51597488e-01f, 2.09789634e-01f, -2.78460979e-01f, 2.15367869e-01f,
  5.36056519e-01f, 3.25266659e-01f, -4.25382644e-01f, 1.11486502e-01f, -3.14794779e-01f, -2.28421390e-02f, -6.89562336e-02f, -7.32946619e-02f, -4.15637121e-02f, -2.69439489e-01f,
  2.62373593e-02f, -3.68976742e-02f, 2.86242127e-01f, -2.07148477e-01f, -1.55515105e-01f, -2.77155966e-01f, -1.56959414e-01f, -1.24524474e-01f, 2.09047928e-01f, -2.22191140e-02f,
  2.57576287e-01f, 5.65190196e-01f, -1.34580046e-01f, 2.34087065e-01f, -8.14108476e-02f, -2.07864583e-01f, -6.60745800e-02f, 1.83320921e-02f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -1.32552370e-01f, 1.43745035e-01f, -1.21070728e-01f, -1.48691505e-01f, -7.56811798e-02f, 8.54520965e-03f, 2.73362666e-01f, -1.57469690e-01f, 6.86616451e-02f, -7.36207440e-02f,
  -3.01835220e-02f, 7.39279464e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 19, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 19, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        64, 12
    );
    }
    