/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  2.10723355e-01f, -7.95675963e-02f, -2.26774126e-01f, -2.20929068e-02f, 1.21519826e-01f, -2.36140694e-02f, 4.65378761e-02f, -1.20897211e-01f, -5.54379039e-02f, -1.25973985e-01f,
  8.57111886e-02f, -2.56217867e-02f, 4.12836485e-03f, 4.98743318e-02f, 3.16929549e-01f, -3.71091478e-02f, 5.63911125e-02f, -5.03385626e-02f, -7.15543702e-02f, 1.72237784e-03f,
  -5.89313917e-02f, 7.39352629e-02f, -2.87076924e-02f, -1.25626385e-01f, -2.53934246e-02f, -2.47727320e-01f, 8.94617736e-02f, -7.84199312e-02f, -2.55439878e-02f, 9.54345837e-02f,
  2.39166878e-02f, -3.33224572e-02f, -4.59251888e-02f, -4.28383350e-02f, 2.92300154e-02f, 1.25385206e-02f, 1.43483961e-02f, -1.23529928e-02f, 1.73402112e-02f, 7.00942054e-03f,
  -2.56803855e-02f, 6.55351803e-02f, -9.03891400e-02f, -1.39343981e-02f, -4.60217781e-02f, -4.54640388e-02f, 8.79130140e-03f, 2.00962787e-03f, -1.38788931e-02f, 7.01351836e-02f,
  1.76533312e-02f, 3.93825583e-02f, 3.32025550e-02f, 2.21930817e-02f, -1.85729302e-02f, 4.02646028e-02f, 2.21794602e-02f, -9.52197146e-03f, -2.16402560e-02f, 2.17136443e-02f,
  8.86422023e-02f, 2.65180115e-02f, -3.41900848e-02f, -2.31996067e-02f, 3.13271843e-02f, 2.56195217e-02f, 1.14006461e-05f, 8.40082541e-02f, -5.67480661e-02f, 4.08535451e-02f,
  2.45812945e-02f, -1.80027857e-02f, -6.52470253e-03f, 7.15476274e-03f, -1.67685356e-02f, 4.82552685e-02f, 3.33393104e-02f, -3.03402096e-02f, -1.11597246e-02f, 8.11740290e-03f,
  8.69998429e-03f, 3.04858238e-02f, -1.95038933e-02f, 4.55584824e-02f, 2.21020542e-02f, 8.25584959e-03f, -4.83757257e-03f, -3.14785019e-02f, -2.84613762e-02f, 1.89280976e-02f,
  4.41438965e-02f, -4.99155857e-02f, -1.65256243e-02f, 1.21469004e-02f, -1.71571299e-02f, 7.22208945e-03f, -2.24804413e-03f, -9.33135152e-02f, -2.75637638e-02f, -3.33428010e-02f,
  -1.00920694e-02f, -1.18960487e-03f, -2.62803175e-02f, 4.55529355e-02f, -1.78701933e-02f, -5.63424453e-02f, 2.90316679e-02f, -2.65683569e-02f, 6.54883981e-02f, 6.78169578e-02f,
  4.55191284e-02f, 2.79138833e-02f, 5.80208376e-02f, 5.92306554e-02f, 3.54311168e-02f, -2.25202907e-02f, -1.28849903e-02f, -2.97782682e-02f, 6.22478053e-02f, 3.79883684e-04f,
  4.35467541e-01f, -3.18142802e-01f, -1.38071939e-01f, 4.04883884e-02f, 2.25453749e-02f, -2.64267206e-01f, 4.89800163e-02f, -1.44045070e-01f, 6.24519959e-02f, -2.36784384e-01f,
  -2.97307074e-02f, -1.78742595e-02f, -3.26659828e-02f, -1.42066956e-01f, 2.91211694e-01f, 1.67995486e-02f, -3.53454836e-02f, 1.74797233e-02f, -1.36756885e-03f, -8.36287737e-02f,
  4.33118194e-02f, -5.08728251e-02f, -1.02297524e-02f, -9.63062420e-02f, -8.92666727e-02f, 2.38620993e-02f, 3.48047093e-02f, -4.91253212e-02f, -1.21705636e-01f, -2.35472620e-02f,
  -5.37011819e-03f, 6.30458875e-04f, -2.31030979e-03f, -4.61273734e-03f, -4.90432493e-02f, -2.67336853e-02f, 2.51207761e-02f, 1.03977412e-01f, -2.47698873e-02f, -5.75715080e-02f,
  7.52556324e-02f, -2.75421254e-02f, -2.17683846e-03f, 2.09024772e-02f, -2.15768851e-02f, -2.37790719e-02f, 1.33575611e-02f, -7.12912828e-02f, -7.81132802e-02f, -5.45913354e-02f,
  7.02885073e-03f, -2.85943993e-03f, -4.85071465e-02f, -6.69310689e-02f, 7.59467557e-02f, 6.12886995e-02f, -5.71310222e-02f, -2.48190993e-03f, 3.75005491e-02f, -5.94181642e-02f,
  3.57170356e-03f, -6.52619004e-02f, -2.33372059e-02f, -2.63836458e-02f, -6.78651333e-02f, -2.93458812e-02f, -1.17708938e-02f, -4.28880230e-02f, 2.90072896e-02f, -4.98315599e-03f,
  -2.38405657e-03f, 5.93018858e-03f, 2.22686324e-02f, 3.58469076e-02f, -2.96247769e-02f, 3.08604334e-02f, 5.84694594e-02f, -1.35914590e-02f, 2.78011933e-02f, 8.21617525e-03f,
  -8.15952383e-03f, 5.31435106e-03f, 3.31058502e-02f, 9.20532257e-05f, 3.05953156e-02f, 4.23795059e-02f, -1.31485267e-02f, 4.42554168e-02f, -3.05635203e-02f, 1.49409065e-03f,
  -7.68947005e-02f, -1.49996847e-01f, -5.01016602e-02f, -6.14877902e-02f, 7.93594029e-03f, 2.49951128e-02f, -4.51019146e-02f, 2.52751615e-02f, 3.30545790e-02f, -1.25613753e-02f,
  -4.75205444e-02f, 2.26258766e-02f, -4.24638949e-02f, -1.40288761e-02f, 1.43803386e-02f, -4.81055398e-03f, 1.65539477e-02f, 3.97920981e-02f, 3.90593559e-02f, -4.78182128e-03f,
  -2.53983755e-02f, 4.25354056e-02f, 4.53098491e-03f, 1.27306755e-03f, 1.93246976e-02f, -1.03044901e-02f, 1.06918961e-01f, 6.68515936e-02f, -1.70881972e-02f, 2.82959212e-02f,
  -6.44332990e-02f, -7.86537528e-02f, -1.16775207e-01f, 1.51757136e-01f, -8.18835944e-02f, -1.33912176e-01f, 1.60463467e-01f, -2.25018933e-02f, -8.95708650e-02f, 1.26467854e-01f,
  2.26212069e-01f, -1.23777300e-01f, 7.78057054e-02f, 2.23103464e-01f, -1.78893685e-01f, -1.79248047e-03f, 7.72436261e-02f, 3.21287364e-02f, -1.11704931e-01f, -1.44258672e-02f,
  -8.60597193e-02f, 1.95889845e-01f, 5.23409545e-02f, -5.11060245e-02f, -1.42198801e-02f, -8.65930393e-02f, 1.13396183e-01f, 7.91527107e-02f, 6.30399585e-02f, 3.98931578e-02f,
  -3.53262909e-02f, 1.52241781e-01f, -7.01075047e-02f, -8.86141062e-02f, 1.71800889e-02f, 1.75611638e-02f, 3.37765478e-02f, 2.21473370e-02f, -3.88337150e-02f, 2.31612753e-03f,
  -4.05449457e-02f, 2.43753679e-02f, -2.09429692e-02f, 9.49246213e-02f, -5.41890077e-02f, -7.55804181e-02f, -2.35294900e-03f, 8.05708617e-02f, -3.88509147e-02f, -2.43424270e-02f,
  -1.36522157e-02f, 2.33207792e-02f, 1.54400989e-02f, -3.93161224e-03f, -3.52574773e-02f, 4.38163653e-02f, -1.97280962e-02f, -5.04785366e-02f, -9.43566673e-03f, -4.11939360e-02f,
  1.55757135e-02f, -8.25885590e-03f, 1.28931524e-02f, -4.61051501e-02f, -5.38455583e-02f, 2.13266797e-02f, 2.46893521e-02f, -2.12528463e-02f, -3.40908654e-02f, 1.16852410e-02f,
  1.78915262e-02f, -6.30872399e-02f, 2.60375142e-02f, -1.67159904e-02f, -3.41335009e-03f, 2.84201913e-02f, -5.03128096e-02f, 2.86982562e-02f, 3.58094415e-03f, -4.53170389e-02f,
  1.11050360e-01f, -4.59945872e-02f, 6.48909360e-02f, 3.94344293e-02f, 2.19956320e-02f, -3.82227264e-02f, -4.67570573e-02f, -5.93893342e-02f, -6.41460903e-03f, 5.65128513e-02f,
  5.82457846e-03f, 5.38853444e-02f, 6.49131835e-02f, 7.66349733e-02f, 3.01892171e-03f, -3.43886875e-02f, 8.90205428e-03f, -2.04397924e-02f, -7.59745315e-02f, -3.93657535e-02f,
  6.87685832e-02f, -1.79328788e-02f, -2.06021238e-02f, -2.27262527e-02f, -4.80735712e-02f, 5.61517105e-02f, 1.16359115e-01f, 2.94465292e-02f, -1.26894927e-02f, 1.49150807e-02f,
  6.51265383e-02f, -5.36290668e-02f, 2.13695560e-02f, -2.79107802e-02f, 7.13470718e-03f, 4.54839356e-02f, -1.50644600e-01f, 2.09972039e-02f, -9.24725272e-03f, 2.66080182e-02f
};

// L0_fan_Wp_bar (Shape: 26 x 120)
const int L0_fan_Wp_bar_rows = 26;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -4.95045722e-01f, 3.95071387e-01f, -1.02208182e-01f, -4.18253362e-01f, 9.26120952e-02f, -6.57664537e-02f, -1.83565080e-01f, 1.50992855e-01f, -1.75388142e-01f, 3.00428085e-02f,
  -1.79216161e-01f, -1.29927263e-01f, 1.92890819e-02f, -7.15261027e-02f, -2.60836452e-01f, -4.18906435e-02f, -8.20647702e-02f, -1.54925838e-01f, 9.80890393e-02f, -1.90033764e-01f,
  9.95906256e-03f, -5.36894351e-02f, 7.58146681e-03f, 2.01153830e-01f, -1.18607141e-01f, -3.25150266e-02f, -1.32625863e-01f, 4.94045094e-02f, 8.99482220e-02f, 1.13920018e-01f,
  -2.15208426e-01f, -3.27834785e-01f, -1.13581978e-01f, -1.23088509e-01f, -1.80610657e-01f, 4.54223491e-02f, -1.64612383e-02f, -2.26530600e-02f, 2.10163761e-02f, 1.17172422e-02f,
  -9.05549154e-03f, 2.41400823e-02f, -7.14517385e-02f, -1.02862446e-02f, -6.92956373e-02f, 5.05759157e-02f, 1.13914199e-01f, -1.72784422e-02f, -9.22677740e-02f, 3.63385230e-02f,
  5.88271283e-02f, 9.73665342e-02f, -8.44232291e-02f, -7.85573795e-02f, 5.77943176e-02f, 6.10697009e-02f, -6.06540684e-03f, 1.77036840e-02f, 6.27854690e-02f, -1.80143155e-02f,
  1.28678739e-01f, 1.27300899e-02f, -1.22527897e-01f, -6.98565692e-02f, 3.82170752e-02f, 1.26719484e-02f, 5.32721961e-03f, -2.11577844e-02f, 4.56965044e-02f, 7.34566078e-02f,
  -1.04610273e-03f, -3.45881134e-02f, 3.49536687e-02f, -6.08691350e-02f, -2.87026335e-02f, -8.82141590e-02f, 5.22261893e-04f, -8.24821368e-02f, 1.87943857e-02f, 3.90884280e-02f,
  -3.19616161e-02f, -5.88269457e-02f, 7.45842420e-03f, -1.59501228e-02f, 1.76916663e-02f, -4.66978624e-02f, 6.39168695e-02f, 3.87567356e-02f, -8.44124332e-02f, 6.09095767e-02f,
  -3.25838566e-01f, -3.74305159e-01f, -1.60898879e-01f, -1.17533863e-01f, 9.17721947e-04f, 1.08251818e-01f, 4.56321146e-03f, -7.75828362e-02f, -1.11998692e-01f, 9.72150825e-03f,
  7.54783005e-02f, -3.21208909e-02f, 1.20719001e-02f, -9.20622870e-02f, 6.54453412e-02f, 1.97296292e-02f, -1.07927635e-01f, -3.40391174e-02f, -9.07522216e-02f, 3.24590355e-02f,
  2.23078649e-03f, -6.29406646e-02f, 6.28600419e-02f, -9.34013873e-02f, -3.73789482e-02f, -1.63744744e-02f, -1.08869359e-01f, 3.34631875e-02f, -5.34898862e-02f, 2.92799789e-02f,
  3.55221212e-01f, -1.41337335e-01f, -2.98235297e-01f, 2.34569609e-01f, 2.09751949e-01f, 2.63435364e-01f, -4.15322231e-03f, 2.88954794e-01f, 1.72198907e-01f, -1.26106098e-01f,
  -2.71473005e-02f, -1.37663946e-01f, -3.56785297e-01f, 2.15425894e-01f, 2.12101474e-01f, -2.76551127e-01f, 2.38604471e-01f, 7.72652924e-02f, 6.59923302e-03f, 3.51844132e-02f,
  1.59139231e-01f, 3.81794274e-01f, -2.70532638e-01f, 3.90215330e-02f, 2.42029414e-01f, -5.16394563e-02f, 1.61417127e-02f, -3.18682551e-01f, 8.36955607e-02f, 1.60980567e-01f,
  -1.64958567e-03f, 1.01938464e-01f, -5.26072308e-02f, -2.52975263e-02f, 4.32381891e-02f, 2.47941958e-03f, -1.15298964e-01f, -7.10641071e-02f, 3.99649441e-02f, -2.83375159e-02f,
  -9.12704021e-02f, 2.32254583e-02f, 3.05767078e-02f, 2.71284487e-02f, 2.05734208e-01f, 5.22168986e-02f, 8.95535871e-02f, 1.25575680e-02f, 1.87131212e-04f, -1.94917470e-02f,
  -4.75297421e-02f, -1.64647505e-01f, 6.82423562e-02f, 1.87220369e-02f, -4.15685438e-02f, 3.24365832e-02f, -2.14226488e-02f, -8.03941339e-02f, 9.29236263e-02f, 1.22570336e-01f,
  5.30776903e-02f, 3.97977419e-03f, -5.14114499e-02f, 6.73990324e-02f, 1.18936501e-01f, -1.46775618e-02f, 8.95577371e-02f, -1.30156845e-01f, 1.17727526e-01f, -3.79759222e-02f,
  7.93171674e-02f, 3.98276001e-02f, 1.06280573e-01f, 6.27696468e-03f, 7.12990910e-02f, -1.26264682e-02f, 1.21839531e-02f, 4.34226096e-02f, -1.21959625e-02f, -3.00861988e-02f,
  9.11040884e-03f, 1.15388148e-01f, 1.57820024e-02f, 2.85124127e-02f, 5.46930581e-02f, -2.50678305e-02f, 1.10073231e-01f, -9.35121812e-03f, -1.41364828e-01f, 2.66061090e-02f,
  4.27364260e-02f, -6.31249622e-02f, -2.47261431e-02f, -3.72551125e-03f, -3.62088755e-02f, 4.76620421e-02f, 9.55235437e-02f, 7.78785422e-02f, -6.17931373e-02f, 9.29697081e-02f,
  -5.73732108e-02f, -6.13487065e-02f, 5.75390197e-02f, -2.23778896e-02f, -6.20966256e-02f, 6.77625975e-03f, -1.28433615e-01f, 1.68701094e-02f, 4.28422429e-02f, -5.90546429e-02f,
  5.76414950e-02f, 1.63832903e-02f, -2.81330254e-02f, -2.31700186e-02f, -5.35486229e-02f, -1.44796506e-01f, 4.51504625e-02f, -1.21279135e-01f, -2.26815930e-03f, -7.52412230e-02f,
  7.78580084e-02f, 3.17216098e-01f, 3.08999032e-01f, 3.56210768e-01f, -9.26699564e-02f, -2.82702833e-01f, -1.78690091e-01f, 1.43141553e-01f, -9.68892425e-02f, -4.78536673e-02f,
  -6.89904019e-02f, 3.40600282e-01f, 1.06076309e-02f, -1.78787503e-02f, -2.77724773e-01f, -3.53537172e-01f, 1.37713000e-01f, -9.79964808e-02f, -4.08899970e-02f, 3.47508758e-01f,
  1.47182837e-01f, -2.65501112e-01f, 1.83544084e-01f, 5.36861345e-02f, 1.49272934e-01f, 3.57768327e-01f, 1.44396931e-01f, 2.90568229e-02f, 3.91002119e-01f, -1.80606276e-01f,
  -1.11204032e-02f, 8.06867331e-02f, 7.02319071e-02f, -2.95133200e-02f, 9.27933604e-02f, 7.85877109e-02f, 4.15990986e-02f, -1.00348257e-01f, -1.52304303e-02f, -6.17080927e-02f,
  1.01572655e-01f, -2.93394383e-02f, -8.10693353e-02f, -8.85431841e-02f, 6.35504872e-02f, 1.32911175e-01f, 9.30467471e-02f, 6.03451990e-02f, 8.70349780e-02f, 1.40158743e-01f,
  1.97916538e-01f, 1.70953065e-01f, 9.93608013e-02f, 5.73874488e-02f, 4.92303669e-02f, 4.41015102e-02f, 1.72312092e-02f, 9.14028361e-02f, 1.12027466e-01f, 1.12597965e-01f,
  2.06487551e-02f, -5.53452894e-02f, -7.98717737e-02f, -4.46908623e-02f, -2.74594612e-02f, -1.31426603e-02f, -4.09301445e-02f, -7.62561783e-02f, -7.79164070e-03f, 1.82795729e-02f,
  -8.78255367e-02f, 9.14527401e-02f, -1.50584504e-01f, 9.53025073e-02f, 2.27544960e-02f, 8.15822929e-03f, 9.90184210e-03f, -3.55337411e-02f, 1.25804946e-01f, 6.37133718e-02f,
  -6.71006292e-02f, -8.85220468e-02f, 4.89947312e-02f, -2.71174312e-02f, -1.11921608e-01f, 3.47431228e-02f, 4.06057872e-02f, 8.27652067e-02f, -6.81944340e-02f, -7.45607540e-02f,
  4.43881787e-02f, 2.58146167e-01f, -3.97782549e-02f, -7.03965724e-02f, 2.38376539e-02f, -4.03789021e-02f, -2.54943296e-02f, 7.69153908e-02f, 8.25880542e-02f, -4.72224541e-02f,
  1.03778906e-01f, 2.97700185e-02f, -1.36236893e-02f, 5.78436293e-02f, 2.38111001e-02f, -1.22125549e-02f, 3.79086249e-02f, 2.47049239e-02f, 1.03931747e-01f, 1.34555683e-01f,
  2.50268638e-01f, 2.04622876e-02f, 9.17197391e-02f, -2.64741126e-02f, 3.77331227e-02f, 4.54686955e-02f, 7.68913627e-02f, 1.31096378e-01f, 6.32168949e-02f, -3.55545408e-03f,
  -1.42978892e-01f, -1.88458785e-01f, 1.00345068e-01f, -1.78531438e-01f, 2.45903544e-02f, 5.03114238e-02f, -1.50213957e-01f, -7.90390223e-02f, -7.04475865e-02f, -3.26469690e-01f,
  -1.68458253e-01f, -1.32529914e-01f, -2.25179101e-04f, -1.36209875e-01f, 4.74948287e-01f, 2.34857574e-02f, -2.54494231e-02f, -1.21987775e-01f, 3.59072834e-02f, -2.31675327e-01f,
  -4.59375568e-02f, -2.65316099e-01f, 2.81578839e-01f, -1.23605482e-01f, 1.65329240e-02f, 6.06174432e-02f, -3.31283361e-02f, 1.77062992e-02f, -1.18677437e-01f, -1.28248379e-01f,
  2.12089106e-01f, -5.06090745e-02f, 9.70861539e-02f, 1.84738204e-01f, 8.48538280e-02f, -8.21950212e-02f, 7.46265575e-02f, 5.17702624e-02f, 5.46162389e-02f, 2.20175702e-02f,
  -2.64078025e-02f, 6.19218796e-02f, -1.41177326e-01f, 5.10952948e-03f, -9.56758037e-02f, 7.22099170e-02f, -1.28177973e-03f, 2.91547719e-02f, 7.22235516e-02f, -8.67324546e-02f,
  7.46114776e-02f, 5.51836006e-02f, -7.30320886e-02f, 4.93547432e-02f, 5.66594414e-02f, 6.55353144e-02f, -5.12196645e-02f, -2.92172823e-02f, 1.15050487e-01f, -3.09526380e-02f,
  -1.76293433e-01f, -3.20951715e-02f, -3.73685323e-02f, 3.59694213e-02f, -7.30316862e-02f, -6.52570352e-02f, 5.01247938e-04f, -9.85686183e-02f, -1.99408680e-02f, -3.73642682e-03f,
  5.50491959e-02f, 7.68402666e-02f, 7.76922628e-02f, 1.77643374e-01f, -8.48552808e-02f, -1.73935041e-01f, -4.77948971e-03f, 1.74866527e-01f, -3.78412940e-02f, -3.53819248e-03f,
  -1.48405179e-01f, 2.91219447e-02f, -5.13671748e-02f, 1.87154353e-01f, 2.82568093e-02f, 2.32056621e-02f, 4.67606063e-04f, -9.94548108e-03f, -2.52132528e-02f, 2.68525556e-02f,
  2.09042933e-02f, -2.87241280e-01f, 1.08448170e-01f, 2.78955214e-02f, 1.13699332e-01f, -1.11673800e-02f, 2.00125556e-02f, -1.10438643e-02f, -7.52464384e-02f, -1.05515920e-01f,
  -1.29213721e-01f, 5.80648854e-02f, -5.30669093e-02f, 5.36047891e-02f, -6.25004694e-02f, 1.51074156e-01f, -7.49301761e-02f, -2.08978429e-02f, 1.05198547e-01f, -3.77364680e-02f,
  -2.39189453e-02f, -7.13025182e-02f, -6.01051562e-02f, 1.91545896e-02f, -5.18619493e-02f, -4.21413481e-02f, -3.15124006e-03f, -4.34824899e-02f, -5.82097135e-02f, -1.11159571e-01f,
  -2.40118057e-01f, 1.21015229e-03f, -2.89635986e-01f, -2.81587839e-01f, 1.30377233e-01f, -3.89258564e-01f, -3.58283341e-01f, 1.58045888e-01f, 1.21668437e-02f, 1.89391728e-02f,
  -4.59852703e-02f, -9.34696645e-02f, 1.63511574e-01f, -1.80671334e-01f, -2.85907894e-01f, 2.59849336e-02f, -3.11618209e-01f, -2.41452202e-01f, 7.04055727e-02f, -5.96236214e-02f,
  -1.26334980e-01f, 2.02613603e-02f, -1.67480901e-01f, 2.09503472e-01f, -2.43232474e-01f, 1.12147398e-01f, 1.65432215e-01f, 1.68806568e-01f, -1.38632089e-01f, 9.56581067e-03f,
  -9.04055312e-03f, 1.18572704e-01f, -5.28062731e-02f, 1.48257921e-02f, -9.78652537e-02f, -6.66592941e-02f, -6.81486204e-02f, 2.96149161e-02f, -1.63853858e-02f, -5.28165996e-02f,
  -6.66672457e-03f, 8.92799348e-02f, -6.60513788e-02f, 7.71446154e-02f, 3.75454943e-03f, 1.03017204e-01f, -4.20061052e-02f, -1.34603590e-01f, 3.26595791e-02f, -7.16996863e-02f,
  -1.02070913e-01f, -8.86644144e-03f, -6.13158606e-02f, -6.59645349e-03f, -5.76461963e-02f, 9.53403786e-02f, -1.20445758e-01f, 5.63341193e-02f, -2.59124264e-02f, -8.84119049e-02f,
  4.01120223e-02f, 1.28269587e-02f, 2.06932449e-03f, -4.73951362e-02f, -4.08498384e-02f, -2.02301648e-02f, 8.19571316e-03f, 4.74996865e-02f, -1.91319399e-02f, -3.07930000e-02f,
  -4.37869169e-02f, -3.28827165e-02f, 6.15071654e-02f, -6.59970939e-02f, -5.54452129e-02f, 1.33103598e-02f, -4.19957452e-02f, 3.44325788e-02f, -1.28173560e-01f, -8.90000463e-02f,
  4.86960411e-02f, 3.18150893e-02f, 7.70909265e-02f, 1.10335406e-02f, 2.57102326e-02f, -3.32638621e-02f, 3.71505618e-02f, 3.31478007e-02f, -2.20898166e-02f, -5.07891625e-02f,
  -2.53925435e-02f, 1.93536595e-01f, 5.26979305e-02f, 1.70078874e-02f, 7.14965165e-02f, -7.26847798e-02f, -1.26385093e-01f, -5.50845154e-02f, -3.84414569e-02f, 3.59030999e-02f,
  -8.35082680e-02f, -1.00958757e-01f, 2.73471791e-02f, 5.80624714e-02f, 7.02513307e-02f, 1.86786242e-03f, 5.78617118e-02f, 1.72635298e-02f, -6.85256869e-02f, 7.92559236e-02f,
  -1.80218369e-02f, 1.01975556e-02f, -4.54397500e-02f, 3.74069028e-02f, 8.22781119e-03f, -2.51666978e-02f, -4.85561937e-02f, -1.47977574e-02f, 5.24471439e-02f, 2.11608652e-02f,
  8.29143301e-02f, -9.17881820e-03f, 7.17187598e-02f, 1.62413612e-01f, -1.18607514e-01f, -2.69351482e-01f, -2.11003840e-01f, 1.58143893e-01f, -5.41115217e-02f, -7.15160668e-02f,
  8.20126906e-02f, -2.33826742e-01f, 1.37445241e-01f, 2.50397265e-01f, 3.07761610e-01f, 9.22532231e-02f, 1.99064836e-01f, 1.11321308e-01f, -1.99538171e-02f, 1.95706859e-01f,
  1.59896463e-01f, 1.23841479e-01f, 3.37064356e-01f, 1.60416275e-01f, 8.38261321e-02f, -3.73910763e-03f, 2.11741716e-01f, 5.07437736e-02f, -2.08123811e-02f, -5.95964305e-02f,
  -3.85062881e-02f, 7.12145343e-02f, 9.03825238e-02f, -2.26372015e-02f, 8.19918066e-02f, -6.83437893e-03f, 4.91765887e-03f, -9.39565524e-02f, -4.04407382e-02f, -1.78349018e-02f,
  -5.05299345e-02f, -1.54832620e-02f, -7.70751992e-03f, 1.48376971e-02f, -1.67367179e-02f, -3.55068147e-02f, -5.68276644e-02f, -1.08889133e-01f, -6.11244515e-02f, 8.51509571e-02f,
  5.41360416e-02f, 2.94506457e-03f, -3.05906106e-02f, 2.24610772e-02f, 3.65044326e-02f, 9.60723311e-03f, -2.92598326e-02f, 3.25092413e-02f, -5.32519110e-02f, 2.56275646e-02f,
  6.11293353e-02f, -9.42644328e-02f, -1.27095610e-01f, 3.29367667e-02f, -5.46155050e-02f, 3.87325622e-02f, 1.26088439e-02f, -8.96610972e-03f, -1.14202932e-01f, -1.68040730e-02f,
  -1.36403935e-02f, 8.78770500e-02f, 4.22492027e-02f, -1.44444481e-01f, 4.46402654e-02f, -1.07130259e-01f, 7.62727857e-02f, 7.88702890e-02f, -1.78218298e-02f, 5.76388873e-02f,
  8.23137835e-02f, 6.30737096e-02f, -3.40499096e-02f, 5.56522571e-02f, 1.17484875e-01f, 4.21428829e-02f, 3.65774333e-02f, 3.70228440e-02f, 2.38892641e-02f, -3.45681198e-02f,
  1.32436633e-01f, 2.39788502e-01f, 8.47939681e-03f, -2.43207365e-02f, -2.39805002e-02f, 5.77643625e-02f, -3.41079687e-03f, 7.86816329e-02f, 5.22520319e-02f, 9.98452976e-02f,
  8.10560510e-02f, -9.35927033e-03f, -1.86033882e-02f, -1.00178443e-01f, -3.17357481e-02f, 1.17322393e-01f, 6.19466007e-02f, -1.51015501e-02f, 4.46534082e-02f, 1.23757198e-01f,
  9.01950076e-02f, -2.97654048e-02f, 2.41779499e-02f, -1.08310364e-01f, -5.57633825e-02f, 8.47750604e-02f, -1.52299985e-01f, -5.82478344e-02f, 1.14818905e-02f, 3.67836580e-02f,
  -3.32707822e-01f, -3.41310650e-02f, 1.22298039e-02f, -4.33897614e-01f, 4.64447727e-03f, -1.54660884e-02f, -1.11162983e-01f, -1.21604025e-01f, -1.76457942e-01f, -2.07440004e-01f,
  -2.28982046e-02f, -1.60843581e-01f, 1.73667401e-01f, -2.44367898e-01f, 2.04119667e-01f, 2.04417720e-01f, -1.62094221e-01f, -1.60610661e-01f, 6.25524670e-03f, -3.00648421e-01f,
  -3.52090523e-02f, -1.24363631e-01f, 6.26883134e-02f, -2.81550363e-02f, -2.35582367e-01f, -1.93927109e-01f, -5.81921190e-02f, 5.15066683e-02f, -8.44153836e-02f, 1.17958263e-01f,
  -1.14514150e-01f, -3.50600451e-01f, -6.97293729e-02f, -2.02529933e-02f, -2.63445806e-02f, -6.05902448e-02f, -7.45424479e-02f, -1.09005789e-03f, -3.30543146e-02f, -1.67520363e-02f,
  1.86592340e-02f, 6.63729906e-02f, -1.20824777e-01f, 7.68594518e-02f, -9.71985012e-02f, -1.37073621e-01f, -4.94499840e-02f, -2.09996216e-02f, 1.49561763e-02f, 7.60933235e-02f,
  6.04147576e-02f, 5.01360148e-02f, -1.09168783e-01f, -6.97115958e-02f, 9.75926742e-02f, 3.50746699e-02f, -1.56434141e-02f, 4.96160872e-02f, -1.88175868e-03f, -9.01335627e-02f,
  3.91982729e-03f, 1.78124681e-02f, 7.91878775e-02f, 2.26985924e-02f, 1.68840531e-02f, -6.63944113e-04f, -2.25315951e-02f, -2.21393704e-02f, -5.42941736e-03f, -8.04215819e-02f,
  2.46530045e-02f, -1.69586372e-02f, -7.84862712e-02f, 3.48219536e-02f, -3.29246670e-02f, -5.62142171e-02f, 4.97357845e-02f, -4.22566831e-02f, -1.24031371e-02f, -5.76611608e-03f,
  4.96140979e-02f, 6.57789633e-02f, 6.92195222e-02f, -8.06081742e-02f, 8.32882077e-02f, 3.97901982e-02f, -5.67340106e-03f, 4.54558479e-03f, -6.19815616e-03f, 5.43850213e-02f,
  -1.04108125e-01f, -2.32797116e-01f, 9.59318783e-03f, -2.81085726e-02f, 7.60479122e-02f, 4.61190678e-02f, 8.94779935e-02f, -2.48016007e-02f, -9.91044417e-02f, -1.78776398e-01f,
  -1.47515684e-01f, 9.85262543e-03f, 4.71266778e-03f, -1.22692110e-03f, 1.09468952e-01f, 7.99377710e-02f, -5.74447326e-02f, -1.43067926e-01f, -1.00432791e-01f, -1.46068390e-02f,
  -2.80453525e-02f, 1.59072764e-02f, 8.86369273e-02f, -8.16190802e-03f, -8.86285976e-02f, -4.26337868e-02f, -2.31183991e-02f, 2.30186172e-02f, -2.11290759e-03f, 3.62300202e-02f,
  -2.10934490e-01f, -1.87220827e-01f, -3.42283845e-01f, 4.35809903e-02f, 3.18168819e-01f, 2.71708429e-01f, -2.68807542e-02f, 8.11606124e-02f, -3.21331769e-01f, 3.22000310e-02f,
  1.39397234e-01f, -1.77724794e-01f, -2.44713172e-01f, -4.05864306e-02f, 4.24536504e-02f, -2.88468927e-01f, 3.78250182e-02f, -1.76817104e-02f, -1.66678146e-01f, 1.47335872e-01f,
  5.93967289e-02f, 2.62100846e-01f, 4.40100655e-02f, 2.32029885e-01f, 8.46859664e-02f, 1.55733928e-01f, 3.47838789e-01f, 8.87831021e-03f, 3.72638285e-01f, 7.32791200e-02f,
  1.95663292e-02f, -5.51047288e-02f, 2.84147318e-02f, -1.68756694e-01f, 1.26220256e-01f, 1.13461182e-01f, 1.41858477e-02f, -4.09492031e-02f, -2.57838853e-02f, -1.11454628e-01f,
  1.97156239e-02f, 2.07984224e-02f, 4.18069661e-02f, 2.67304499e-02f, 7.22986786e-03f, -1.38054779e-02f, 2.31925379e-02f, -2.14733128e-02f, -6.02718890e-02f, -1.74206626e-02f,
  -8.33807066e-02f, 2.22483724e-02f, -2.97169238e-02f, 5.14360778e-02f, -1.85954999e-02f, 2.44435575e-02f, 8.04798305e-02f, 4.60773446e-02f, -4.56859767e-02f, 1.02561384e-01f,
  9.79485810e-02f, -6.13827482e-02f, 4.12163623e-02f, -2.75968909e-02f, 2.72913463e-02f, 3.04913130e-02f, 3.45573239e-02f, 5.72264157e-02f, -1.30610587e-02f, 7.50479549e-02f,
  1.46226278e-02f, 8.70116949e-02f, 7.99573120e-03f, -7.06488937e-02f, 6.74815848e-02f, -1.02658190e-01f, 3.88540365e-02f, 8.68405215e-03f, -1.70342866e-02f, 1.86762940e-02f,
  -1.37039676e-01f, 1.60414930e-02f, 4.96256314e-02f, -1.02468848e-01f, -8.50006789e-02f, -1.68201514e-02f, 3.64955910e-03f, -9.94678065e-02f, -3.20370272e-02f, 6.79368153e-02f,
  -1.22671649e-02f, 1.13827258e-01f, -2.18911208e-02f, 5.56843579e-02f, 5.67059033e-02f, 4.49061319e-02f, -9.88132060e-02f, 1.39161292e-02f, -7.37877712e-02f, -9.58082825e-03f,
  1.21153489e-01f, 1.86572839e-02f, 9.80443880e-03f, -1.02063389e-02f, -1.04393788e-01f, 1.35067925e-01f, 4.05113846e-02f, 8.35125223e-02f, 1.83630973e-01f, 1.88102365e-01f,
  1.24250174e-01f, 8.09962302e-02f, -4.10843529e-02f, 9.73659530e-02f, 8.04382637e-02f, 3.18301059e-02f, 1.30352199e-01f, 3.55539583e-02f, 2.50116587e-02f, -4.15300801e-02f,
  5.56843504e-02f, -6.12804554e-02f, -1.13785781e-01f, 2.28699788e-01f, 1.26714902e-02f, -7.69421607e-02f, -2.88569450e-01f, 6.58921199e-04f, -1.53665423e-01f, -7.50636384e-02f,
  8.68058652e-02f, -4.82645910e-03f, -3.92421260e-02f, 1.72864214e-01f, 1.94105253e-01f, -4.49563898e-02f, 2.60237634e-01f, 5.83099434e-03f, 9.91591290e-02f, 1.86508119e-01f,
  2.10753873e-01f, 3.23311210e-01f, 2.53561288e-01f, 2.21985444e-01f, -3.36681828e-02f, 6.28911853e-02f, 1.60348073e-01f, 9.08403844e-02f, 3.10627252e-01f, 1.02580324e-01f,
  4.70407913e-03f, 3.61143574e-02f, -7.10560456e-02f, 1.48745971e-02f, 7.58458972e-02f, 5.42570502e-02f, 5.33538014e-02f, 5.05955257e-02f, 6.24928251e-02f, 1.10164456e-01f,
  -7.05946758e-02f, -4.34279069e-02f, 6.92402720e-02f, 6.39158413e-02f, 9.85184032e-03f, 1.05655760e-01f, -4.89997044e-02f, 5.58274006e-03f, 4.00581956e-02f, 1.07947104e-01f,
  -9.04721469e-02f, 5.33414036e-02f, -3.03554218e-02f, 1.73304267e-02f, -1.77512672e-02f, -7.24967793e-02f, 9.58543196e-02f, 1.23506263e-02f, 2.79580764e-02f, -6.57363087e-02f,
  -8.48587696e-03f, -1.82269812e-02f, -2.30019130e-02f, -6.14813790e-02f, 2.47381963e-02f, -6.75346926e-02f, -9.29038748e-02f, 4.68668267e-02f, -1.09390477e-02f, 1.25433803e-01f,
  -1.75780803e-02f, -1.45988045e-02f, 5.77395298e-02f, -5.63608110e-02f, -2.34715897e-03f, 7.06312358e-02f, -6.42849505e-03f, 4.12293430e-03f, 5.96056245e-02f, -2.63328012e-02f,
  2.28225458e-02f, 1.48061113e-02f, -6.81482628e-02f, 3.58884372e-02f, 4.95180003e-02f, -1.66195910e-02f, -7.53122121e-02f, -3.57627608e-02f, 1.35568660e-02f, -1.31634744e-02f,
  -8.70857108e-03f, 7.42378086e-02f, 1.69685595e-02f, -6.19365685e-02f, 8.48112255e-03f, 5.25068715e-02f, 2.78498009e-02f, -6.98446333e-02f, 1.12781636e-01f, 3.44327018e-02f,
  1.46551192e-01f, 1.47104664e-02f, -9.61048454e-02f, 1.26935184e-01f, 3.12449336e-02f, -2.80874129e-02f, -1.13064662e-01f, 3.13392021e-02f, 8.62516612e-02f, 6.56289086e-02f,
  8.51087943e-02f, 8.12855735e-03f, 9.49318521e-03f, -6.56995550e-02f, -8.22488219e-02f, -3.05454601e-02f, 7.69165829e-02f, -1.70995653e-01f, 6.60858676e-02f, 6.60592765e-02f,
  2.89867073e-01f, -2.35645726e-01f, 2.35704541e-01f, 4.30989444e-01f, 2.53480613e-01f, -2.81653494e-01f, -6.39565289e-02f, 6.53812960e-02f, 2.34776720e-01f, -2.59909749e-01f,
  1.43893221e-02f, -1.16831288e-01f, -3.99066865e-01f, 1.89963698e-01f, 9.80607867e-02f, -3.26789409e-01f, 1.70567185e-01f, -1.32767245e-01f, 9.29224342e-02f, 1.12419225e-01f,
  3.08403224e-01f, 1.13107763e-01f, 2.47441813e-01f, 1.11102879e-01f, 2.73136914e-01f, 3.51297975e-01f, 2.19433278e-01f, -8.53019208e-02f, 8.01260695e-02f, -1.12695873e-01f,
  -5.70600666e-02f, 1.94008514e-01f, 6.41069561e-02f, -1.93184122e-01f, 1.47645008e-02f, -7.94654805e-03f, -1.16186418e-01f, -1.39304638e-01f, -3.16680297e-02f, 2.02814303e-02f,
  -1.06984608e-01f, 1.02767702e-02f, 5.82411252e-02f, -2.43797470e-02f, -1.02220578e-02f, 1.07279547e-01f, 1.42915035e-02f, -3.22998851e-03f, 3.45208608e-02f, -2.67181620e-02f,
  4.91371341e-02f, 3.22770327e-02f, 6.72970116e-02f, -1.04054146e-01f, 1.95924833e-01f, 6.82045072e-02f, 2.51387991e-03f, -7.75275752e-02f, -2.31811944e-02f, 1.19780198e-01f,
  1.36054486e-01f, 1.09638218e-02f, 1.81103237e-02f, -2.51585096e-02f, -1.08806416e-02f, 8.14460889e-02f, -4.43040952e-03f, -1.67198107e-02f, -4.00692970e-02f, -9.92358699e-02f,
  -3.09019964e-02f, 1.47177400e-02f, -2.72787386e-03f, 5.76148257e-02f, 4.04371656e-02f, 4.48188409e-02f, -6.91091195e-02f, -7.31728747e-02f, 1.48965627e-01f, 1.22495227e-01f,
  7.88640529e-02f, -3.66494544e-02f, -1.02653868e-01f, 3.37842368e-02f, -8.18785578e-02f, 4.16601337e-02f, 2.56750989e-03f, -1.40249297e-01f, 2.45331749e-02f, 7.90297836e-02f,
  -4.02467638e-01f, -5.44102974e-02f, -4.25040536e-02f, -1.31166026e-01f, 1.52521674e-02f, -6.73423037e-02f, 3.51078361e-02f, -7.27376193e-02f, -1.64514296e-02f, -1.19257197e-02f,
  -9.09435302e-02f, -2.68724328e-03f, -9.68630984e-02f, -6.49798801e-03f, -8.65911394e-02f, 1.98363811e-02f, 2.37163752e-02f, -8.81735012e-02f, 3.18074003e-02f, 2.57738456e-02f,
  -5.80493733e-02f, -1.23866610e-01f, -5.36696892e-03f, 1.09353989e-01f, 3.07465922e-02f, -5.17631434e-02f, 6.32279494e-04f, -3.30799520e-02f, -6.53217211e-02f, 6.03781007e-02f,
  8.94431472e-02f, -1.59850597e-01f, 1.05461009e-01f, -7.84416944e-02f, 3.41839015e-01f, 2.15694904e-01f, 2.63691157e-01f, 2.61428684e-01f, 3.22324008e-01f, -2.55526155e-01f,
  3.39824893e-02f, -3.65417868e-01f, -3.82378474e-02f, -7.33921453e-02f, 1.87205151e-01f, 1.02404140e-01f, 8.40392113e-02f, -1.04205877e-01f, 1.94283009e-01f, 1.01071991e-01f,
  2.83558071e-01f, -1.56313106e-02f, 1.27050474e-01f, 1.60885155e-02f, -1.01287588e-01f, -8.61115679e-02f, -3.63726050e-01f, 1.04171991e-01f, -1.40326098e-01f, -4.26165480e-03f,
  3.56895104e-02f, 6.68261126e-02f, -7.64613226e-03f, 6.11929223e-03f, 1.96270272e-02f, -1.45896021e-02f, 2.93390490e-02f, -1.04923286e-01f, 3.25419456e-02f, 6.03853026e-03f,
  -5.28363846e-02f, 6.62806071e-03f, 1.06000435e-02f, 6.37672246e-02f, 3.44361216e-02f, -2.41924264e-03f, 7.53535479e-02f, 9.63798538e-02f, 4.75723185e-02f, 1.51090264e-01f,
  9.78290513e-02f, -7.49409646e-02f, -6.11244643e-04f, -1.09400392e-01f, -6.15738034e-02f, 3.01257707e-02f, 5.45025282e-02f, -9.61365625e-02f, 3.31533551e-02f, -2.92012934e-02f,
  6.92044720e-02f, 1.10457480e-01f, -4.27010506e-02f, 1.03897303e-01f, 1.69106647e-02f, 8.47994834e-02f, 3.45380493e-02f, 4.57969271e-02f, -1.92616116e-02f, 3.91354039e-03f,
  3.96151878e-02f, -1.95391700e-02f, -3.49270590e-02f, -3.81929837e-02f, -4.69750836e-02f, 6.36199897e-04f, -1.18730947e-01f, -9.79859978e-02f, -1.21814488e-02f, 6.29755110e-02f,
  3.20407152e-02f, 1.03491910e-01f, -1.69036329e-01f, -1.00579955e-01f, -1.85665097e-02f, -4.03698571e-02f, 2.14306768e-02f, -8.73997435e-02f, 2.39762459e-02f, -3.68215665e-02f,
  -1.43686518e-01f, -1.22368678e-01f, 4.85511646e-02f, -9.76103637e-03f, -1.08353510e-01f, -2.22215876e-02f, 9.35030803e-02f, 1.64506992e-03f, -5.25160767e-02f, 4.19600345e-02f,
  6.35287389e-02f, -1.61593989e-01f, -4.40756418e-02f, -3.70257981e-02f, 2.71698344e-03f, -9.82581899e-02f, -7.45935962e-02f, -2.31017731e-02f, -4.14764695e-02f, 7.01009184e-02f,
  -6.81409985e-02f, 4.56181765e-02f, 4.78742570e-02f, 1.78315416e-02f, -3.59567627e-02f, -3.79671901e-02f, -1.13188386e-01f, -1.07567501e-03f, -6.65111989e-02f, -2.02172645e-03f,
  -7.21891820e-01f, -4.48956564e-02f, -9.23772678e-02f, 1.54084146e-01f, -2.80589890e-02f, 4.22023326e-01f, 4.06037599e-01f, -1.37248829e-01f, -1.17440291e-01f, 1.30701080e-01f,
  8.97631943e-02f, -1.58931911e-01f, -3.80690359e-02f, 4.34321493e-01f, 3.24899077e-01f, 2.08358750e-01f, 3.13994884e-01f, 2.82369763e-01f, 8.28945339e-02f, -1.97140694e-01f,
  6.35890737e-02f, 2.25426733e-01f, 3.53089899e-01f, 1.49435446e-01f, 1.48727680e-02f, -8.45309645e-02f, 1.23699605e-02f, 6.11837618e-02f, 1.31425917e-01f, 1.30680412e-01f,
  -1.12749144e-01f, -4.21009362e-01f, -1.78806975e-01f, -1.32929966e-01f, -1.26233220e-01f, -1.02703020e-01f, 4.72588800e-02f, 1.11507632e-01f, -6.60208017e-02f, -6.63300082e-02f,
  -8.90720412e-02f, -2.95698717e-02f, 6.82704076e-02f, -3.90115790e-02f, 1.23099163e-02f, 3.44877541e-02f, -1.41917448e-02f, -1.85662284e-02f, -1.44330889e-01f, -4.94178310e-02f,
  9.82778799e-03f, 5.50049916e-03f, 4.56970669e-02f, 1.79206625e-01f, -1.61174568e-03f, -7.74337165e-03f, 3.67852636e-02f, 2.91364384e-03f, -2.23519113e-02f, 1.24740903e-03f,
  -4.48831655e-02f, -1.19670667e-01f, -1.05019331e-01f, 5.70858903e-02f, -1.54901352e-02f, -8.37734938e-02f, 1.25541389e-01f, 4.08809558e-02f, 1.00556165e-02f, 8.51551741e-02f,
  -6.70617074e-02f, -8.01867843e-02f, -1.78931877e-02f, 7.26903081e-02f, -6.00120276e-02f, 5.58663625e-03f, 5.49868941e-02f, -1.20014630e-01f, 2.81178411e-02f, -2.00151894e-02f,
  1.67655833e-02f, -2.24644151e-02f, 2.91718077e-03f, 2.13924609e-02f, 6.65408047e-03f, 3.81211340e-02f, 3.24912407e-02f, -3.17272916e-03f, -1.39399739e-02f, 3.48552577e-02f,
  -8.44246149e-02f, -1.77052706e-01f, 1.17900949e-02f, -5.28761111e-02f, 7.83997849e-02f, -1.61498159e-01f, -6.75953776e-02f, -5.86346462e-02f, 1.02142818e-01f, -4.39562649e-02f,
  -8.13313052e-02f, -4.91240360e-02f, -5.68528958e-02f, 2.87729800e-02f, 2.04776958e-01f, -8.13940540e-02f, -4.76509240e-03f, 4.56573851e-02f, 9.57238972e-02f, 6.62029197e-04f,
  -6.78402260e-02f, -6.29630461e-02f, 4.35215011e-02f, -1.74842291e-02f, 6.54815733e-02f, -7.60034099e-02f, -1.26114994e-01f, -3.69967557e-02f, 9.47185382e-02f, 1.33403197e-01f,
  2.63574034e-01f, -3.79024953e-01f, -1.89799085e-01f, 4.08567302e-02f, 7.78516605e-02f, 2.49557290e-02f, -2.18433917e-01f, 7.94624239e-02f, -3.81001607e-02f, -1.74974412e-01f,
  1.64097488e-01f, -5.93777858e-02f, -2.77362019e-01f, 2.96071500e-01f, 2.79554605e-01f, -4.12517600e-02f, 1.75464928e-01f, 1.31179854e-01f, 4.02245671e-03f, 3.42198648e-02f,
  2.06477702e-01f, 2.04500854e-01f, 5.05300909e-02f, 9.94581729e-02f, 1.32060558e-01f, -4.47549038e-02f, 2.44117565e-02f, -1.87315688e-01f, 1.94402397e-01f, 1.10076703e-01f,
  8.48068565e-04f, 1.36783030e-02f, -3.82434465e-02f, 2.57575978e-02f, -1.18656605e-01f, -1.45163581e-01f, -1.17022544e-01f, 4.19470016e-03f, 3.49780582e-02f, -1.13545679e-01f,
  3.59973721e-02f, 6.52981028e-02f, 2.57940609e-02f, 5.22870235e-02f, 2.66313069e-02f, -3.72768268e-02f, -4.91798371e-02f, 9.16448757e-02f, -1.66442350e-01f, -6.20409101e-02f,
  -1.66060776e-01f, -4.24755625e-02f, 9.70442593e-02f, 3.49403881e-02f, 7.08867982e-02f, -4.77456633e-04f, -1.62951127e-01f, -8.31448436e-02f, -3.83691899e-02f, -3.98203842e-02f,
  -6.01834729e-02f, -6.47870377e-02f, -1.79491583e-02f, 8.77446383e-02f, -3.78434174e-02f, 3.40249836e-02f, 8.20822641e-02f, -4.00602594e-02f, -2.82633770e-02f, -6.55827001e-02f,
  -4.05312739e-02f, -5.95462546e-02f, 9.43085551e-03f, -9.63031799e-02f, -2.84937806e-02f, -5.46928607e-02f, -1.13694645e-01f, 1.01812214e-01f, -7.31102899e-02f, 9.60885808e-02f,
  7.53568932e-02f, -4.42225337e-02f, -1.84654728e-01f, 7.33360350e-02f, 6.06724694e-02f, 4.54666018e-02f, 7.59526119e-02f, -3.24963741e-02f, -4.79676947e-03f, -8.87734964e-02f,
  3.88336517e-02f, -2.58319974e-01f, -5.12905270e-02f, 1.21834725e-01f, -1.34409755e-01f, -6.81587830e-02f, -6.51277602e-02f, -3.87908779e-02f, -6.61003962e-02f, -9.16576907e-02f,
  -1.23542197e-01f, -2.47669965e-02f, -3.83437704e-03f, -2.79450812e-03f, 1.12837898e-02f, -1.47581846e-02f, -1.87419401e-03f, -7.03258663e-02f, -5.65205654e-03f, -8.87823403e-02f,
  -7.09945932e-02f, -6.25269488e-02f, -5.54732569e-02f, -9.70286950e-02f, -1.22519466e-03f, 1.27956392e-02f, -7.83241391e-02f, 5.43246306e-02f, 9.92621575e-03f, -7.14066718e-03f,
  9.91134569e-02f, -2.68502742e-01f, -1.68523759e-01f, -9.56529006e-02f, 3.52485567e-01f, 1.77419767e-01f, -1.30941585e-01f, 1.35599285e-01f, -2.51951844e-01f, -2.44385321e-02f,
  -9.36750397e-02f, -2.13502467e-01f, -3.67151886e-01f, -2.69939929e-01f, -1.34724066e-01f, -4.66390163e-01f, -2.45171543e-02f, -7.63343647e-02f, -1.04477003e-01f, 1.12045892e-01f,
  -4.99418005e-02f, 1.89765185e-01f, 3.86790931e-02f, 3.32079172e-01f, 1.71133772e-01f, 3.42278361e-01f, 3.65234882e-01f, 1.30856767e-01f, 1.76913425e-01f, 1.04660622e-03f,
  3.51283439e-02f, -2.36724243e-01f, 1.03642046e-02f, -2.32393648e-02f, 9.77245718e-02f, 1.10042602e-01f, 8.70922729e-02f, -9.43096913e-03f, -1.68038271e-02f, 3.13963066e-03f,
  -5.51933236e-02f, -6.70309067e-02f, 4.48271856e-02f, -3.82435769e-02f, 5.63276261e-02f, -2.71825213e-02f, -7.57269636e-02f, 5.20991795e-02f, -8.37207288e-02f, -1.32422090e-01f,
  -1.40134944e-02f, 4.51981798e-02f, 3.08599938e-02f, 4.61889543e-02f, -1.68301426e-02f, 8.88186693e-03f, 2.73278784e-02f, 3.34060043e-02f, -4.54211682e-02f, -1.56158339e-02f,
  1.04234423e-02f, 1.35158554e-01f, -3.44022661e-02f, -1.42013967e-01f, -9.20290276e-02f, 4.02520336e-02f, -5.25769554e-02f, 7.50357434e-02f, -4.82899956e-02f, -2.56392956e-02f,
  1.28757790e-01f, -6.92896396e-02f, -7.36327618e-02f, 1.07530229e-01f, 6.27904907e-02f, 5.97769283e-02f, 1.28422558e-01f, 5.55715524e-02f, 1.04067750e-01f, 4.14860174e-02f,
  -6.03667535e-02f, 1.27581283e-01f, 3.05233952e-02f, 4.36789654e-02f, 1.40516851e-02f, 7.46345194e-03f, -5.90931363e-02f, 6.31410405e-02f, 4.15592939e-02f, 5.66660203e-02f,
  -6.81090578e-02f, 6.20271377e-02f, -1.19899876e-01f, -2.92301401e-02f, -1.19198509e-01f, 4.59195860e-02f, -9.33352113e-02f, -3.41559318e-03f, 4.03525718e-02f, -2.20269226e-02f,
  1.54425532e-01f, 1.27506420e-01f, 1.64599702e-01f, -4.24763970e-02f, -1.19126961e-02f, 6.55333847e-02f, -1.59391034e-02f, 1.37724783e-02f, 5.96435182e-02f, 3.88445780e-02f,
  3.64576690e-02f, 1.63263515e-01f, -2.56459434e-02f, 6.11737780e-02f, 1.06381997e-01f, 9.21494886e-02f, 6.53581247e-02f, 1.41059548e-01f, -8.86020425e-04f, -4.10227925e-02f,
  -1.00848638e-01f, 1.60615638e-01f, 1.93800226e-01f, -8.10072571e-03f, 1.20340846e-01f, 3.34342152e-01f, 1.76972508e-01f, 2.37633228e-01f, 4.86643732e-01f, -9.12800953e-02f,
  -1.67636245e-01f, -8.81772675e-03f, -6.22418188e-02f, 4.35865037e-02f, 9.69589278e-02f, 8.14968497e-02f, 2.06762910e-01f, -1.74734648e-02f, 2.86400348e-01f, -4.37827362e-03f,
  1.68793108e-02f, -1.50391623e-01f, -8.08220208e-02f, -2.13540062e-01f, -1.22824281e-01f, -4.96448763e-02f, -2.96338499e-01f, -4.84648384e-02f, -2.74299145e-01f, 1.62300423e-01f,
  -2.44632494e-02f, 8.55237544e-02f, -1.46984190e-01f, 2.29355469e-02f, 6.97385818e-02f, 5.97490668e-02f, -1.47459283e-01f, -5.21996617e-02f, 4.31063771e-03f, -3.23475003e-02f,
  -9.92256850e-02f, -8.61655474e-02f, 4.66603376e-02f, -1.90352779e-02f, 9.38179791e-02f, 5.39085940e-02f, 3.01224831e-02f, 9.65600610e-02f, -9.25487652e-03f, -7.91084580e-03f,
  9.75456089e-02f, 8.90288651e-02f, 9.41569209e-02f, 1.01021074e-01f, 5.06986193e-02f, 1.51705062e-02f, 4.32614349e-02f, 3.23893987e-02f, -2.75391620e-02f, 1.55565962e-01f,
  2.43383422e-01f, 6.62933812e-02f, 7.98895676e-03f, -7.90995732e-02f, -9.30154771e-02f, -1.10168085e-01f, -8.33493024e-02f, -6.79783896e-02f, 5.90673788e-03f, -1.92907155e-02f,
  -5.07329702e-02f, -8.28469694e-02f, 9.42695215e-02f, -9.05844290e-03f, 5.76833338e-02f, 7.35348910e-02f, -4.14860323e-02f, -1.76869221e-02f, 1.54601023e-01f, -2.85053942e-02f,
  6.47982731e-02f, 2.53706966e-02f, -4.39348407e-02f, -1.14417158e-03f, 1.03724317e-03f, -1.52865872e-02f, -7.32937604e-02f, 4.04639989e-02f, 9.67278704e-02f, -1.11272081e-03f,
  6.47962838e-02f, 1.45840809e-01f, -6.41873628e-02f, -6.00891076e-02f, 4.23141476e-03f, -1.04901835e-01f, -1.72269009e-02f, -3.18918787e-02f, 8.88984874e-02f, 2.93527376e-02f,
  -2.68067867e-02f, 7.15341244e-04f, 3.12298965e-02f, 5.43318037e-03f, 6.07436188e-02f, 4.36406508e-02f, -1.04880985e-02f, 4.84807640e-02f, -2.45040935e-02f, 1.76713876e-02f,
  -8.26192424e-02f, -2.23812088e-02f, 8.62364378e-03f, -1.51623124e-02f, -6.11072183e-02f, -1.10607922e-01f, 1.09074898e-02f, 6.97456226e-02f, 8.24315548e-02f, 1.00418337e-01f,
  6.88241646e-02f, -3.62195402e-01f, 2.08957255e-01f, -3.45546682e-03f, 4.00747806e-01f, 9.37008187e-02f, 2.93028444e-01f, -2.57116079e-01f, -1.54867992e-01f, -2.50563473e-01f,
  4.63612704e-03f, -9.45216566e-02f, -8.05409774e-02f, -6.07584864e-02f, 3.64824563e-01f, -7.00850561e-02f, -3.61797139e-02f, 2.11789515e-02f, -1.95553936e-02f, -1.67344455e-02f,
  1.73722312e-01f, -8.06275830e-02f, 1.46040499e-01f, -2.05940995e-02f, 1.83882505e-01f, 4.79807705e-02f, 1.94657184e-02f, 1.61875203e-01f, -8.49387888e-03f, 2.60051608e-01f,
  -8.58959332e-02f, -9.71454978e-02f, 2.42335759e-02f, -5.66746527e-03f, 6.42749071e-02f, 8.97629485e-02f, -4.41741832e-02f, 2.14439735e-01f, 5.55776544e-02f, 5.28982654e-02f,
  -1.63664985e-02f, -1.07934110e-01f, 5.92316724e-02f, 6.92425817e-02f, -3.42397615e-02f, 3.54986032e-03f, 2.55525168e-02f, -2.21793018e-02f, -6.32167906e-02f, 7.54155889e-02f,
  6.74299547e-04f, 6.03578985e-03f, -7.28308186e-02f, -8.87144133e-02f, -8.10757931e-03f, -2.19539721e-02f, -7.47935474e-03f, 1.20297514e-01f, -6.35531247e-02f, -2.46981122e-02f,
  2.08669871e-01f, 5.67235909e-02f, 4.53079566e-02f, -5.73292095e-03f, 1.22401053e-02f, -1.86780076e-02f, 3.61995772e-02f, 2.58268788e-03f, 3.78505625e-02f, -1.78708453e-02f,
  3.81191596e-02f, -6.89567486e-03f, -8.07683766e-02f, -5.29787950e-02f, 3.61052006e-02f, -7.53582194e-02f, 7.06077367e-02f, -1.49693981e-01f, -3.68093960e-02f, 3.74158882e-02f,
  3.99652496e-02f, 7.12832995e-03f, 8.34527239e-02f, 4.77231406e-02f, -7.63358641e-03f, 9.26732551e-04f, -1.18788786e-01f, 7.92837702e-03f, 6.21390902e-02f, 9.03160200e-02f,
  -4.22883809e-01f, -3.16251785e-01f, 4.48075036e-04f, -1.56213880e-01f, -1.07031427e-01f, -3.50987613e-02f, 1.30999228e-02f, -8.46484751e-02f, -9.65829417e-02f, -2.23048851e-02f,
  -5.65293916e-02f, 4.29783762e-02f, -8.50178376e-02f, 3.52396891e-02f, 1.55073004e-02f, -2.53425818e-02f, -6.41550571e-02f, -7.36895874e-02f, 5.17516546e-02f, -6.59181774e-02f,
  4.62699905e-02f, 3.15058865e-02f, 1.23846140e-02f, 9.41078644e-03f, 9.07219574e-03f, 9.67883393e-02f, -9.07949582e-02f, 3.93949030e-03f, 1.41301043e-02f, -4.55109961e-02f,
  -2.15513632e-01f, -1.48622885e-01f, 2.16204152e-01f, 1.83220014e-01f, -1.25615835e-01f, -3.39593202e-01f, -2.51086354e-01f, 1.24016620e-01f, -4.52992208e-02f, -2.84365445e-01f,
  -7.93722793e-02f, -5.39485440e-02f, -2.18730271e-02f, 1.48788854e-01f, 3.67566556e-01f, 9.05671492e-02f, 1.15408689e-01f, 3.53151485e-02f, 2.17886135e-01f, 6.19840696e-02f,
  1.64686173e-01f, 1.84167594e-01f, 4.22515392e-01f, 2.43227586e-01f, 1.11462422e-01f, 2.05913231e-01f, 2.87281215e-01f, 1.52140304e-01f, 9.23910365e-02f, 9.38533694e-02f,
  -2.26356223e-01f, -2.64981259e-02f, 4.54203784e-02f, -2.57337373e-02f, 4.07458581e-02f, -9.91167054e-02f, -1.21715227e-02f, -1.69724971e-02f, -1.60065328e-03f, -3.47770490e-02f,
  -2.38657836e-02f, -5.83130978e-02f, 1.30871236e-01f, -1.01620452e-02f, -8.07272494e-02f, -6.44167364e-02f, 3.90746742e-02f, 1.57486636e-03f, 6.82370514e-02f, -3.98816429e-02f,
  -2.99797393e-03f, -3.40142697e-02f, -3.02844867e-02f, 3.74930575e-02f, 6.49475902e-02f, -9.17911306e-02f, 2.47187335e-02f, 8.29301476e-02f, 4.88509089e-02f, -1.42302617e-01f,
  -1.06538929e-01f, 4.42795046e-02f, 1.49568856e-01f, 1.17266558e-01f, 7.67822005e-03f, -6.97506368e-02f, -7.44982297e-03f, 5.44400588e-02f, 4.75298278e-02f, -3.75256427e-02f,
  5.90972342e-02f, 6.74058050e-02f, 2.93702213e-03f, -4.12838981e-02f, 8.72167647e-02f, -1.59570687e-02f, 7.40742385e-02f, 2.80658714e-02f, -4.78218943e-02f, 8.04428756e-02f,
  -1.26978997e-02f, -1.20288478e-02f, 1.29328892e-01f, 1.40562989e-02f, -7.73800015e-02f, -2.52952948e-02f, 8.35469961e-02f, 3.35423350e-02f, 1.39544711e-01f, 6.33179992e-02f,
  -1.61373243e-01f, 2.04148695e-01f, 3.42727564e-02f, -1.83308702e-02f, 5.25775477e-02f, 5.77051416e-02f, 5.17594181e-02f, 6.00552047e-03f, -1.73387956e-02f, 1.05615482e-01f,
  9.31456834e-02f, 1.52323144e-02f, -7.39005134e-02f, 1.08814687e-02f, 1.37261286e-01f, -3.45706269e-02f, 2.23685782e-02f, 3.21910554e-03f, 2.36321837e-02f, -2.90740058e-02f,
  2.61533875e-02f, -7.74244219e-02f, 8.96480754e-02f, 1.46039605e-01f, -3.25455703e-02f, -6.62180185e-02f, -1.02605866e-02f, -5.33774383e-02f, 7.33829960e-02f, -1.90488640e-02f,
  2.46721014e-01f, -2.33064353e-01f, 2.65994012e-01f, 2.16021195e-01f, -1.48534402e-02f, 2.11794555e-01f, 4.18954611e-01f, -1.50693923e-01f, 1.44333795e-01f, -1.67610750e-01f,
  -9.45618153e-02f, 1.10311292e-01f, 1.27902403e-01f, -9.53588858e-02f, 2.97726780e-01f, 1.08584344e-01f, 5.54773398e-02f, 1.51723940e-02f, -7.00337887e-02f, -9.42130983e-02f,
  -6.69836774e-02f, -2.70454854e-01f, -1.56352237e-01f, -3.59507680e-01f, -2.21971482e-01f, -1.77261993e-01f, -8.26176777e-02f, 1.08568400e-01f, -1.88760802e-01f, -7.72736222e-02f,
  -1.17860936e-01f, -1.45429045e-01f, -1.24609530e-01f, -4.39255238e-02f, -1.01451658e-01f, -1.13124996e-01f, 1.14754595e-01f, 5.39745614e-02f, 4.10936698e-02f, -1.46136722e-02f,
  9.04981568e-02f, 1.99984517e-02f, -1.78861991e-02f, 8.78597237e-03f, -9.44849774e-02f, -6.78749084e-02f, -8.06175696e-04f, -1.04112595e-01f, -6.83862343e-02f, 5.95924258e-02f,
  -3.86165902e-02f, 5.74698783e-02f, 1.50336642e-02f, -7.45538920e-02f, 2.44104005e-02f, 4.02868018e-02f, 1.26085982e-01f, 8.55227932e-02f, -5.81337772e-02f, 9.89298224e-02f,
  -1.34866074e-01f, 4.56395820e-02f, -4.95758951e-02f, -1.55727401e-01f, -1.91349234e-03f, 1.28903529e-02f, -5.21983579e-02f, 2.80332169e-03f, 2.09472775e-02f, -1.63868293e-02f,
  -1.23399338e-02f, -2.82266159e-02f, 1.81032810e-02f, -6.57156035e-02f, -2.50077955e-02f, -8.34565423e-03f, 1.24048077e-01f, -2.51778476e-02f, 6.42397255e-03f, -2.67637447e-02f,
  -2.90305261e-02f, 3.31995543e-03f, -1.03799894e-01f, -4.75452980e-03f, 9.16774049e-02f, 1.33815464e-02f, 2.19978206e-03f, 6.91361073e-03f, -5.67450039e-02f, 3.03291939e-02f,
  -1.67152941e-01f, 4.61449195e-03f, 1.38019780e-02f, 6.11923039e-02f, 3.16294134e-02f, 8.70656408e-03f, 1.49163103e-03f, 4.68424940e-03f, -4.80849259e-02f, -5.99170402e-02f,
  5.34637682e-02f, -1.69408768e-02f, 1.44547075e-02f, -7.32768402e-02f, -1.51939550e-02f, -1.00717232e-01f, 9.97162908e-02f, -4.91977250e-03f, 4.58788313e-02f, -1.39901355e-01f,
  -1.24021217e-01f, 4.86919247e-02f, -2.05197688e-02f, -7.20624328e-02f, -8.07884559e-02f, 2.69237030e-02f, -2.09104754e-02f, 5.37277088e-02f, -6.38174564e-02f, -4.95367460e-02f,
  -3.54604781e-01f, 2.01072857e-01f, -3.05417389e-01f, -3.94871123e-02f, -2.39180401e-01f, 2.23147169e-01f, 2.78420627e-01f, 6.82280958e-02f, -3.11724618e-02f, 3.52619112e-01f,
  1.82272136e-01f, -2.33153000e-01f, 1.30680040e-01f, 3.55893910e-01f, 1.40401572e-02f, 3.62888992e-01f, 3.21263254e-01f, 2.51352251e-01f, -1.46170393e-01f, 2.27733739e-02f,
  -7.89284855e-02f, 2.86324203e-01f, 1.72129404e-02f, -1.05737425e-01f, -1.08120635e-01f, -1.82953760e-01f, 8.45935196e-02f, -1.45456091e-01f, 1.95515696e-02f, -7.54126683e-02f,
  8.93642530e-02f, -1.12047680e-01f, -1.70667782e-01f, -9.51112658e-02f, 1.92570053e-02f, -5.38184308e-02f, 4.28318568e-02f, -1.13798462e-01f, -6.33688569e-02f, 5.12758754e-02f,
  -8.58786236e-03f, -7.00745732e-02f, 1.82411191e-03f, -4.83634733e-02f, -1.70615375e-01f, -2.08210442e-02f, -5.75549006e-02f, -1.75657459e-02f, 5.00858203e-02f, -6.02571033e-02f,
  -1.16136983e-01f, 3.97123732e-02f, -1.80855263e-02f, 3.55775431e-02f, -7.83377066e-02f, 2.52260565e-04f, 6.72442243e-02f, -5.41927852e-02f, 4.29991409e-02f, -3.21641229e-02f,
  -3.35863680e-02f, -1.45260952e-02f, -7.21523259e-03f, -1.12481162e-01f, -1.01649106e-01f, -1.90821681e-02f, 3.02010868e-02f, 1.94333550e-02f, -1.98507514e-02f, 2.56000347e-02f,
  -3.93592902e-02f, 1.95682161e-02f, -3.06644011e-02f, 1.41874691e-02f, 1.10916995e-01f, 5.52273355e-03f, 1.96602345e-02f, -5.57459779e-02f, 2.59509124e-02f, 5.86830452e-02f,
  5.49359061e-03f, 1.34021938e-02f, 6.40923157e-02f, 8.07388872e-03f, 1.17584988e-02f, -3.52800898e-02f, -9.59405117e-03f, -5.27385585e-02f, 5.68064824e-02f, -5.39325476e-02f,
  2.09469721e-01f, 4.85233180e-02f, -2.61127986e-02f, -1.03230655e-01f, -8.93909857e-02f, -2.62573973e-04f, 4.73980568e-02f, -9.83124748e-02f, 1.22448038e-02f, -1.53639410e-02f,
  -7.44963214e-02f, -7.58508667e-02f, -3.13853985e-03f, -4.36572805e-02f, -2.51390692e-02f, 1.66863333e-02f, 9.48351249e-02f, -5.57164066e-02f, 1.30252823e-01f, -4.42831181e-02f,
  -6.09448440e-02f, 2.06104685e-02f, 4.31095734e-02f, 5.17985672e-02f, 3.64538748e-03f, 7.58714080e-02f, -1.78907681e-02f, 5.00827841e-02f, -6.22705892e-02f, -1.99875142e-02f,
  2.05488145e-01f, -3.50006014e-01f, 9.69437435e-02f, 6.76685795e-02f, 1.05073944e-01f, -7.58822188e-02f, -9.41298995e-03f, -1.04236975e-01f, 1.34995148e-01f, -1.71114072e-01f,
  -5.63211292e-02f, 3.63329127e-02f, 2.93113347e-02f, -1.86772242e-01f, 2.87737042e-01f, 7.62362108e-02f, -1.34519994e-01f, -5.68551496e-02f, 6.33019507e-02f, -8.06429833e-02f,
  4.87838350e-02f, -6.78934008e-02f, -3.70752290e-02f, -2.84259111e-01f, -5.27377725e-02f, -3.22855003e-02f, 2.10607767e-01f, -9.62751210e-02f, -1.79549575e-01f, -2.39508506e-02f,
  -1.42659575e-01f, -8.93640369e-02f, -4.74960506e-02f, -5.83534651e-02f, -1.18406229e-01f, -8.86815414e-03f, -4.58489619e-02f, 2.39396039e-02f, 6.52915100e-03f, 4.21924852e-02f,
  1.62035935e-02f, -9.91613418e-02f, -6.86662197e-02f, 1.77487768e-02f, 5.73489873e-04f, -9.50498134e-03f, -2.88021881e-02f, -9.54756960e-02f, 8.54677409e-02f, 3.24974488e-03f,
  -3.13883796e-02f, -2.19190009e-02f, 2.17941124e-02f, 7.72156566e-02f, 6.64032474e-02f, -1.54072000e-02f, 1.02106392e-01f, 3.45784724e-02f, -7.84931183e-02f, 7.42097497e-02f,
  1.27488363e-03f, -1.00385167e-01f, -3.94343622e-02f, -4.32169810e-02f, 1.04918506e-03f, -4.10643257e-02f, -4.16523144e-02f, -4.73848602e-04f, 1.55560113e-03f, 3.28541696e-02f,
  -3.76488455e-02f, -8.96188468e-02f, 2.19044313e-02f, 6.43411502e-02f, -2.27155779e-02f, 5.11545641e-03f, 2.82769427e-02f, 1.77021828e-02f, -1.71825588e-02f, -3.47697106e-03f,
  -8.76496732e-02f, 1.12399003e-02f, 3.18636522e-02f, 8.80558938e-02f, -6.83358610e-02f, 5.73322661e-02f, -9.94915068e-02f, 6.94638118e-02f, 1.71824172e-02f, 1.12355649e-01f,
  -3.46644819e-01f, -2.41086125e-01f, -6.06579930e-02f, -6.57490119e-02f, 2.55565066e-02f, -7.49670289e-05f, -4.96881790e-02f, -1.59348883e-02f, -8.14118702e-03f, 1.02654882e-01f,
  -7.50516402e-03f, -3.14098634e-02f, 9.71414223e-02f, -5.44338785e-02f, -5.81997223e-02f, 1.86162125e-02f, 3.99126261e-02f, 2.62770094e-02f, -9.34457034e-02f, -1.25376016e-01f,
  1.80973280e-02f, -8.43165517e-02f, 1.02603003e-01f, -2.56380159e-02f, 8.38104635e-03f, 5.61902486e-02f, 1.18313432e-02f, 2.31905896e-02f, 4.91381250e-02f, 1.63618047e-02f,
  -2.76814163e-01f, -1.42617021e-02f, -2.72185624e-01f, -2.93801814e-01f, 1.07109398e-01f, 2.33897721e-04f, -3.02038252e-01f, -2.39862055e-02f, -3.26589197e-02f, 1.12936832e-01f,
  -9.85471010e-02f, -3.27248484e-01f, 1.48957342e-01f, -4.33561713e-01f, -3.06000292e-01f, -1.31860301e-01f, -3.85660082e-01f, -2.14357063e-01f, -2.95729954e-02f, -9.29795057e-02f,
  -1.55789450e-01f, -2.83740640e-01f, -2.97405034e-01f, 8.75596106e-02f, -1.61108106e-01f, 4.21005450e-02f, 3.17277491e-01f, 1.56704634e-01f, -6.21488616e-02f, -1.13075525e-01f,
  -1.19306706e-01f, -7.94757083e-02f, -7.09950402e-02f, 4.57457546e-03f, -3.70315388e-02f, 1.84251424e-02f, 7.30876252e-02f, -5.65105565e-02f, -1.29748741e-02f, -3.27982791e-02f,
  -4.47150134e-02f, -8.24300274e-02f, -6.88967481e-02f, -1.70415062e-02f, 5.89936301e-02f, 2.93096341e-02f, 2.89176013e-02f, 7.23855495e-02f, -4.18297984e-02f, -1.15265623e-01f,
  -1.28039077e-01f, -1.12847857e-01f, 1.15708709e-01f, 4.42126393e-02f, -2.94686481e-03f, 4.06274535e-02f, 1.20504135e-02f, -6.94980554e-04f, 3.03819422e-02f, -5.58542926e-03f,
  -2.72737890e-02f, -1.24822855e-02f, 4.33343276e-03f, -5.14067598e-02f, 2.94847377e-02f, 2.38183253e-02f, -3.70895080e-02f, -2.04278193e-02f, -5.64992353e-02f, -1.62628101e-04f,
  8.99484474e-03f, -4.54888642e-02f, -8.94046500e-02f, 4.57579158e-02f, 4.02738005e-02f, 1.95762347e-02f, -8.49062875e-02f, -2.83887833e-02f, -9.57516208e-02f, -4.99897934e-02f,
  5.50997369e-02f, -2.25868216e-03f, 3.58049758e-02f, 5.74671701e-02f, -4.51584123e-02f, 9.31643173e-02f, 3.90267409e-02f, 2.49939822e-02f, 7.13076862e-03f, 1.41567215e-01f,
  4.88429815e-02f, 3.91172618e-02f, 4.09093052e-02f, -5.58042638e-02f, 8.48015491e-03f, -1.65696896e-03f, 4.68945913e-02f, -2.57491954e-02f, -5.17473593e-02f, 1.44750513e-02f,
  7.94750229e-02f, 2.32631136e-02f, -1.03234965e-02f, -9.53234732e-02f, -5.47482222e-02f, -2.93909870e-02f, 3.08209583e-02f, 5.26537336e-02f, 7.89422095e-02f, 5.19084670e-02f,
  8.88200253e-02f, -4.89404351e-02f, -1.53313135e-03f, 1.49296010e-02f, -1.04979999e-01f, 1.54097483e-01f, 1.65584423e-02f, -4.34637107e-02f, 4.70629223e-02f, 7.80799091e-02f,
  7.85512924e-02f, 1.64085746e-01f, 1.89907074e-01f, -6.61072508e-02f, 1.94105189e-02f, -4.35995698e-01f, -2.13361785e-01f, 1.21236872e-02f, 1.33758351e-01f, 5.56138530e-02f,
  -1.90981507e-01f, 3.57068390e-01f, -1.17478214e-01f, -1.36760160e-01f, -4.35820460e-01f, -2.05618575e-01f, -3.81719202e-01f, -9.54514518e-02f, 4.68497500e-02f, -9.83405486e-02f,
  -1.75908908e-01f, -3.36852252e-01f, -1.77899152e-01f, 1.88494958e-02f, 5.52459098e-02f, 1.99894235e-01f, -1.34481698e-01f, 5.07431142e-02f, -1.16815045e-02f, 4.51077372e-02f,
  -1.44855410e-01f, 6.65210709e-02f, 1.62543893e-01f, 8.53709131e-02f, -1.20350309e-01f, -1.83126563e-03f, -6.17587287e-03f, 1.33787453e-01f, -8.12413171e-02f, -8.64166580e-03f,
  1.54004753e-01f, -6.39092084e-03f, 4.00663577e-02f, 4.48489711e-02f, 1.05678841e-01f, 8.13327879e-02f, 5.19642199e-04f, 6.54387027e-02f, 5.00228815e-02f, 1.14237934e-01f,
  4.06384580e-02f, 7.72640035e-02f, 2.67572198e-02f, 7.28221983e-02f, -2.74343067e-03f, 4.73384671e-02f, -1.26483664e-02f, -6.87907189e-02f, 6.57729479e-03f, -6.95286244e-02f,
  3.57842073e-02f, -4.58525792e-02f, 3.40982936e-02f, 4.42627147e-02f, 3.49662602e-02f, -8.18874761e-02f, -6.49270462e-03f, -1.85980313e-02f, 7.50845671e-02f, 9.50702524e-04f,
  -5.74420504e-02f, 1.51973099e-01f, -2.66022477e-02f, -5.68399616e-02f, 7.87462667e-03f, 6.48596659e-02f, -1.11907050e-02f, -3.93225206e-03f, -7.47613311e-02f, -7.02584609e-02f,
  5.17345890e-02f, 1.94312651e-02f, 2.77038794e-02f, -1.81191918e-02f, -2.11045407e-02f, 1.57918707e-02f, 7.17041120e-02f, -3.02269943e-02f, 5.88998012e-02f, -5.75737990e-02f,
  -3.18887442e-01f, -2.37459466e-01f, -3.97834517e-02f, 9.96584632e-03f, -2.45593092e-03f, 3.26961465e-02f, -7.41728097e-02f, -2.10127514e-02f, -8.64137784e-02f, -6.80721551e-02f,
  7.57701648e-03f, -5.70383109e-02f, -1.00574806e-01f, -7.62043521e-02f, -1.47456989e-01f, -5.37085235e-02f, -5.04897535e-02f, -9.77340937e-02f, -2.80279201e-02f, -4.49294224e-02f,
  -1.60653777e-02f, 6.32281750e-02f, 3.91453877e-02f, -1.42630620e-03f, 4.10212092e-02f, -7.43391439e-02f, 1.73662435e-02f, 1.12424947e-01f, -7.06167594e-02f, -4.46710512e-02f,
  -1.37206510e-01f, 1.08315898e-02f, 2.68178787e-02f, -2.34355301e-01f, 1.44167095e-01f, 3.31139229e-02f, -8.47587213e-02f, 1.94277436e-01f, -3.73071618e-02f, 1.06976546e-01f,
  4.30680513e-02f, 5.53678721e-02f, 6.63164183e-02f, -3.42806906e-01f, -2.46812075e-01f, -3.81518543e-01f, -2.61669755e-01f, -7.97072873e-02f, -1.32284081e-02f, -1.25426665e-01f,
  -2.33383700e-01f, -3.75244260e-01f, -1.55478165e-01f, 1.28520625e-02f, -1.17281370e-01f, 1.09904453e-01f, 8.65959302e-02f, 2.74092872e-02f, 1.05865121e-01f, -4.18140255e-02f,
  3.35570909e-02f, 2.09441721e-01f, 1.56694323e-01f, 3.30852857e-03f, 6.11811094e-02f, 5.55811599e-02f, -4.09992635e-02f, 5.28042391e-02f, 6.70367479e-02f, 1.77546903e-01f,
  -3.69261056e-02f, 2.19015218e-02f, 1.32376486e-02f, 5.91133907e-02f, -1.34651037e-02f, 1.28661066e-01f, 3.12608704e-02f, 1.37465939e-01f, 1.33749366e-01f, -3.84504907e-02f,
  3.34410556e-02f, 1.88868698e-02f, -4.63653579e-02f, 2.42821164e-02f, -5.01954034e-02f, 9.12528858e-02f, -1.98917091e-02f, 8.28654990e-02f, 3.13631296e-02f, 4.37495969e-02f,
  -5.23051172e-02f, -3.47982533e-02f, -1.49295762e-01f, 3.83272916e-02f, 1.33475857e-02f, 6.07426576e-02f, 6.13344461e-03f, 1.08693227e-01f, -4.24258821e-02f, 1.85539201e-02f,
  -5.43720759e-02f, -4.38104896e-03f, -1.04034573e-01f, 3.14089358e-02f, -1.32600889e-01f, 4.04136591e-02f, -8.82888138e-02f, 5.45249023e-02f, -3.35389376e-02f, 1.15964912e-01f,
  7.85308629e-02f, -6.37230277e-02f, -9.09455866e-02f, -5.52933514e-02f, -7.33920708e-02f, -1.68951321e-02f, 1.58402398e-02f, -1.08779687e-02f, 1.90811846e-02f, -1.29856288e-01f,
  5.43057173e-02f, 1.85392648e-02f, 3.33723687e-02f, 1.30810827e-01f, -1.16710057e-02f, 7.73689523e-03f, -1.69333607e-01f, -5.33713438e-02f, -1.74177028e-02f, -1.08434550e-01f,
  -5.16297035e-02f, -3.33614610e-02f, 2.24354304e-02f, 1.22038405e-02f, 5.54135107e-02f, -3.55782211e-02f, -3.74585092e-02f, -4.14899811e-02f, 1.43787637e-02f, 1.65695995e-01f,
  7.56400004e-02f, -6.25863671e-02f, -9.61112380e-02f, -1.17236540e-01f, -4.00918797e-02f, -2.56722234e-03f, 1.33620560e-01f, 5.15102595e-02f, -7.38094822e-02f, -6.31229440e-03f,
  -6.23451322e-02f, -2.77944773e-01f, 6.91202581e-02f, -2.45090261e-01f, -4.15915921e-02f, 1.46520534e-03f, 7.96720684e-02f, -2.76300967e-01f, -2.56304324e-01f, -2.73765773e-01f,
  -5.55949239e-03f, 1.31410480e-01f, 3.13244700e-01f, -2.61208475e-01f, 5.01872003e-01f, 2.56736368e-01f, -2.67596006e-01f, 9.45264325e-02f, -1.86337382e-02f, -2.08488032e-01f,
  4.32369635e-02f, -2.07906500e-01f, 2.13843644e-01f, -2.51922935e-01f, -1.56446576e-01f, -9.15504396e-02f, 1.89011022e-01f, 9.03107449e-02f, -1.31220594e-01f, 1.73805505e-01f,
  -8.65290835e-02f, -2.24936709e-01f, -1.10547841e-01f, -6.15246361e-03f, -1.05815716e-01f, 7.66531900e-02f, 6.18942194e-02f, 2.01944962e-01f, 4.38538566e-02f, -1.18668433e-02f,
  -2.30178796e-02f, -4.29744832e-02f, -9.63253751e-02f, -4.39736340e-03f, -4.68146354e-02f, -2.87635066e-02f, -5.35411946e-02f, 1.80863552e-02f, -7.24885464e-02f, 9.86857563e-02f,
  8.83398056e-02f, -6.66067377e-02f, -3.45217288e-02f, 2.24840809e-02f, -3.05182971e-02f, -1.60342470e-01f, 1.81995127e-02f, 8.67894068e-02f, 2.16281600e-03f, -7.12668337e-03f,
  4.17115763e-02f, 1.25622809e-01f, 2.39614602e-02f, -4.69411397e-03f, -4.48029302e-02f, -1.75649635e-02f, 1.35273794e-02f, 3.56643535e-02f, -3.80339809e-02f, -3.61387916e-02f,
  -1.11513346e-01f, -3.60149704e-02f, -2.26098765e-02f, -5.56083061e-02f, -4.62127663e-02f, 3.12626697e-02f, 1.43847838e-02f, -9.17377940e-04f, 3.20643671e-02f, 2.67851781e-02f,
  7.61031881e-02f, 1.97010711e-02f, -9.81944129e-02f, 4.60404158e-02f, -5.75313484e-03f, 6.05714619e-02f, 4.09048575e-04f, -1.26799092e-01f, -1.08176249e-03f, 1.33058697e-01f,
  -6.46220818e-02f, -1.63650960e-01f, -8.17897543e-02f, -3.00886463e-02f, -1.69112179e-02f, -3.54827419e-02f, -1.21887634e-02f, -1.10363014e-01f, 2.03061160e-02f, 2.07477715e-02f,
  8.42801854e-02f, 6.77042291e-04f, 4.24238257e-02f, -2.63918322e-02f, -6.30197674e-03f, -9.62096602e-02f, 1.68796349e-02f, 8.99340883e-02f, -2.73399819e-02f, -4.56799148e-03f,
  -9.72409621e-02f, 7.08063133e-03f, 1.44358441e-01f, -8.96833092e-02f, -4.17672424e-03f, 2.76400987e-02f, 4.60435031e-03f, 6.94652461e-03f, 7.57347420e-02f, -5.55583602e-03f,
  1.51217863e-01f, 5.75465821e-02f, -2.32249752e-01f, -1.04729325e-01f, 2.99115311e-02f, 2.15730712e-01f, -3.62945125e-02f, -5.81828784e-03f, -2.79606044e-01f, 1.97810560e-01f,
  -9.58071928e-03f, -1.10405125e-01f, -8.36984217e-02f, 1.36355996e-01f, 2.81146131e-02f, -2.40361542e-02f, 2.26203993e-01f, 1.17367364e-01f, -1.64825339e-02f, 2.13292688e-01f,
  1.56664904e-02f, 1.74457341e-01f, -1.86040014e-01f, 1.69125393e-01f, -3.27564292e-02f, -3.19003016e-02f, 1.95516482e-01f, -1.37382492e-01f, 1.11129120e-01f, -2.55811587e-03f,
  5.33173643e-02f, 1.39410356e-02f, -3.58566940e-02f, 3.66506353e-02f, 7.32952580e-02f, 1.01468349e-02f, -2.07748413e-02f, 8.64097849e-04f, -1.31629303e-01f, -2.68463418e-02f,
  3.76200788e-02f, -6.81031272e-02f, 8.84086266e-02f, -1.06341466e-01f, -3.55024748e-02f, -9.60083902e-02f, -1.36435851e-01f, -1.83018133e-01f, -6.64499626e-02f, 5.95806055e-02f,
  -9.92475003e-02f, -3.38964425e-02f, -7.56334066e-02f, -1.46545604e-01f, 3.77549715e-02f, 1.50482841e-02f, -2.68091746e-02f, -2.41129808e-02f, 6.35442957e-02f, 4.82779071e-02f,
  1.18702777e-01f, 1.17441058e-01f, 1.87367633e-01f, -2.27387529e-02f, -2.57503684e-03f, -1.49227865e-02f, 9.62397177e-03f, 2.39551198e-02f, -8.07494819e-02f, 6.77946955e-02f,
  2.74993218e-02f, 6.94760308e-03f, -1.36487065e-02f, 4.54014465e-02f, 7.71138296e-02f, -4.16142344e-02f, -2.86095217e-02f, 2.67081782e-02f, 3.20557579e-02f, 2.63515930e-03f,
  -1.30525038e-01f, 1.09861389e-01f, -5.14543056e-02f, 7.10316747e-02f, 3.27947214e-02f, -7.99930170e-02f, 8.50116387e-02f, 1.63882636e-02f, 1.54445004e-02f, 1.32629573e-01f,
  5.14709540e-02f, 1.45980179e-01f, 2.93471497e-02f, -5.88180795e-02f, 6.45748712e-03f, 1.49790913e-01f, -8.95423535e-03f, 1.15508698e-01f, 5.38321324e-02f, 1.07311666e-01f,
  1.19895861e-01f, -1.71370059e-02f, 9.27279443e-02f, 1.51598090e-02f, -1.27795354e-01f, 1.85281098e-01f, 5.29257692e-02f, -1.73499778e-01f, -5.38264662e-02f, -5.09692580e-02f,
  3.23483273e-02f, -1.36850169e-02f, -4.12804596e-02f, -6.34121373e-02f, 9.62442905e-02f, -3.01655252e-02f, -5.03667630e-02f, -9.03459862e-02f, 1.47051243e-02f, -1.17669776e-01f,
  -3.08394402e-01f, 2.47929603e-01f, -1.47015139e-01f, -2.50555784e-01f, 1.70965046e-01f, -2.79106498e-01f, -2.29035273e-01f, -1.31072253e-01f, -7.52933770e-02f, 6.74308613e-02f,
  -2.63108499e-02f, -1.78842545e-02f, 1.81079507e-01f, -1.95711300e-01f, -1.68441057e-01f, 2.01037228e-01f, -2.87200511e-01f, -2.03947917e-01f, 9.54759419e-02f, -1.31881014e-01f,
  2.37002186e-02f, -2.49001421e-02f, -1.76228732e-01f, 2.71737307e-01f, -1.02593027e-01f, 2.23660413e-02f, 1.27375394e-01f, 9.22102481e-02f, -1.24920622e-01f, -1.19244447e-02f,
  -2.61184812e-01f, -2.31188074e-01f, -1.40421122e-01f, -1.90811187e-01f, -1.55984446e-01f, -3.69115663e-03f, -3.94777469e-02f, 1.28015634e-02f, 3.70508358e-02f, -1.28658637e-01f,
  4.99428064e-02f, -8.89504626e-02f, 6.94423467e-02f, 6.50883988e-02f, -1.10277034e-01f, -4.70114872e-02f, 9.83291641e-02f, -5.76850511e-02f, 6.24770522e-02f, -5.86743616e-02f,
  6.38060942e-02f, -5.45321032e-02f, -5.29368855e-02f, 3.22723500e-02f, 6.97390512e-02f, -5.22745289e-02f, 7.96317775e-03f, 5.99756911e-02f, -9.93363857e-02f, -1.11272030e-01f,
  1.30856827e-01f, -2.18614675e-02f, 5.34775630e-02f, 3.79725993e-02f, -2.20191348e-02f, 1.27058625e-01f, -6.90165674e-03f, -6.69182390e-02f, -8.63131732e-02f, -1.24636702e-01f,
  3.41105089e-02f, -6.86181560e-02f, 1.55889764e-02f, -7.58688822e-02f, 5.36583476e-02f, 1.40090436e-02f, -3.34481858e-02f, -6.17531873e-02f, 1.30529985e-01f, 1.07781235e-02f,
  -1.31613955e-01f, 9.54681356e-03f, -1.27505034e-01f, 6.52766451e-02f, -1.42720528e-02f, 7.37159848e-02f, -2.24944782e-02f, -5.81290275e-02f, -5.84491082e-02f, -7.06477761e-02f,
  -2.00764373e-01f, -3.26469153e-01f, 5.19304797e-02f, -1.54416680e-01f, -1.24063887e-01f, -1.05533913e-01f, -6.87348768e-02f, 7.33065233e-02f, 6.68385848e-02f, -7.90857077e-02f,
  -1.23165675e-01f, 8.92027654e-03f, 1.71108302e-02f, 4.17236015e-02f, -6.96608722e-02f, -1.02463230e-01f, -7.78948441e-02f, 5.81695475e-02f, -1.54806525e-01f, -2.14973278e-02f,
  -2.41338052e-02f, 9.06656608e-02f, 4.67651188e-02f, 2.79025268e-02f, -2.85025518e-02f, -1.38393164e-01f, -8.38416219e-02f, 5.63638248e-02f, -7.97257274e-02f, -1.81707125e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 26)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 26;
const float L0_fan_Bp_bar_data[] = {
  3.92402649e-01f, 3.93008202e-01f, 3.53500783e-01f, 3.57527763e-01f, 2.11270764e-01f, 1.00586779e-01f, 3.90250206e-01f, 3.09518814e-01f, 1.95036978e-01f, 2.81283855e-01f,
  2.27556407e-01f, 5.20334899e-01f, 8.13091397e-02f, 2.79272497e-01f, 2.60193348e-01f, 2.68353492e-01f, 1.74023569e-01f, 4.58078265e-01f, 2.90385634e-01f, 8.77820924e-02f,
  2.26666301e-01f, 3.64844441e-01f, 4.68049571e-02f, 1.44106254e-01f, 2.01052532e-01f, 2.61346936e-01f
};

// L1_fan_Wp (Shape: 3 x 32)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.62974253e-01f, 1.85494095e-01f, -1.32493809e-01f, 2.00083911e-01f, -2.14462966e-01f, 1.14251666e-01f, -1.59351066e-01f, 3.12322110e-01f, -3.23453695e-02f, -2.12484732e-01f,
  2.61614412e-01f, -2.56576836e-02f, -1.24108933e-01f, 3.04231018e-01f, 2.85947353e-01f, -1.79510489e-01f, -2.64602333e-01f, 8.01567584e-02f, 1.59728676e-01f, 2.91657239e-01f,
  -2.09926367e-01f, -1.20489672e-01f, 2.24152114e-02f, -1.94443062e-01f, 4.02473696e-02f, -3.00707847e-01f, 1.52606189e-01f, -8.75176117e-02f, 1.39373332e-01f, -2.42254138e-01f,
  1.70539260e-01f, 4.39186804e-02f, -2.15335608e-01f, -7.52172247e-02f, -2.96212155e-02f, 1.95617720e-01f, -4.95963134e-02f, -1.47678137e-01f, -1.42315909e-01f, 2.39194900e-01f,
  -1.57667845e-01f, -8.56263563e-02f, -5.42675592e-02f, -1.93611175e-01f, -1.65942028e-01f, 3.25948417e-01f, 8.39212313e-02f, -2.13899300e-01f, 2.79618442e-01f, 5.03765792e-02f,
  2.80788213e-01f, 3.31803054e-01f, 6.92619607e-02f, -1.10506304e-01f, -2.58667827e-01f, -6.78846836e-02f, 6.76644081e-03f, -9.91048962e-02f, 2.35392377e-02f, -3.08606654e-01f,
  1.75393913e-02f, -4.07619953e-01f, 1.83702365e-01f, -2.03883484e-01f, 6.99215531e-02f, -3.49391907e-01f, -2.18182132e-02f, -1.78806677e-01f, 9.37732086e-02f, -6.13771901e-02f,
  9.95267555e-02f, -3.69777046e-02f, -3.44530851e-01f, -9.81300604e-03f, 2.22418219e-01f, 9.93387327e-02f, 2.96377689e-01f, -3.01457405e-01f, -1.36130363e-01f, -1.36381552e-01f,
  -2.39840344e-01f, 7.17021450e-02f, -1.55424118e-01f, -2.51385450e-01f, 9.92718562e-02f, -3.75341214e-02f, -8.22569355e-02f, -3.11868817e-01f, 6.77550733e-02f, 1.20371319e-01f,
  8.32630992e-02f, 2.84107067e-02f, 2.65186250e-01f, 3.99856176e-03f, -9.95906740e-02f, 1.82748228e-01f
};

// L1_fan_Wp_bar (Shape: 26 x 32)
const int L1_fan_Wp_bar_rows = 26;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.87614515e-01f, 2.27072850e-01f, 8.38845447e-02f, -2.88455784e-01f, -2.49669909e-01f, -2.88554630e-03f, 4.94523436e-01f, -3.81010056e-01f, 1.03336893e-01f, 4.32143174e-02f,
  4.28750098e-01f, 3.02575052e-01f, 4.90056306e-01f, 1.72300309e-01f, 2.01105401e-01f, 1.12527117e-01f, 1.01244211e-01f, 2.13824302e-01f, -3.10855359e-01f, 4.85138111e-02f,
  -1.99601784e-01f, 2.46148780e-01f, 5.74758708e-01f, 1.34350523e-01f, 6.64872974e-02f, 1.23475350e-01f, 2.50447810e-01f, 4.76716071e-01f, 3.07653338e-01f, 2.68656790e-01f,
  -7.27414191e-02f, 4.98044819e-01f, 2.36444995e-01f, 2.70896167e-01f, 2.34892979e-01f, 8.06519762e-02f, -3.20687652e-01f, 1.90250322e-01f, 1.84781224e-01f, -1.22878412e-02f,
  1.17110908e-01f, 1.00298554e-01f, -1.58619210e-01f, 3.11149955e-01f, 1.57432780e-01f, 2.76617169e-01f, 8.58620107e-02f, -4.21799660e-01f, 1.59378022e-01f, 4.54402685e-01f,
  1.68101490e-01f, 3.41004521e-01f, 2.83041656e-01f, -4.04299766e-01f, -8.85505788e-03f, -1.20394774e-01f, 5.94750524e-01f, -3.20635289e-01f, 2.01106727e-01f, -3.93701077e-01f,
  -1.04325444e-01f, -1.37058143e-02f, 4.23229128e-01f, 1.83560565e-01f, 2.06456617e-01f, 2.91651219e-01f, 5.13398468e-01f, -3.68222475e-01f, -8.93694721e-03f, -4.32621539e-01f,
  6.94953203e-02f, 2.21503705e-01f, 2.56862074e-01f, 2.89124370e-01f, -4.00947601e-01f, -1.66312233e-01f, -3.44083071e-01f, -1.99355751e-01f, -2.47494698e-01f, 1.86249033e-01f,
  4.79778230e-01f, -9.17790309e-02f, -2.68230021e-01f, 2.26731822e-01f, 5.52099228e-01f, -3.93066555e-02f, -1.12179190e-01f, 2.21444085e-01f, -6.97385594e-02f, 1.65266111e-01f,
  -3.16801727e-01f, 1.80240288e-01f, 5.06168269e-02f, -3.55225801e-01f, -3.26527990e-02f, -1.90790780e-02f, 3.62325341e-01f, 3.01236033e-01f, 8.49928409e-02f, -1.30547017e-01f,
  -5.09597659e-01f, 3.70941520e-01f, 3.05197686e-01f, 1.25528470e-01f, -1.30198166e-01f, -3.41464467e-02f, 1.89068615e-01f, 3.65854241e-02f, 4.45662439e-02f, 2.71221459e-01f,
  5.59080318e-02f, -3.86288047e-01f, -1.08654715e-01f, 2.19321951e-01f, -6.41838387e-02f, 2.36604854e-01f, 2.01073542e-01f, -1.73486739e-01f, -3.43927711e-01f, 2.93272343e-02f,
  3.51961583e-01f, -3.89713258e-01f, 1.81409180e-01f, 2.16329187e-01f, -9.99712124e-02f, -1.82619885e-01f, 2.17515185e-01f, 1.64482057e-01f, 2.06263155e-01f, -2.32843310e-01f,
  9.19125415e-03f, 3.60638082e-01f, 4.26982015e-01f, -1.71138480e-01f, 4.91230283e-03f, 2.39720225e-01f, -2.67853200e-01f, 4.91571546e-01f, 7.75198936e-02f, -2.12082580e-01f,
  3.83169174e-01f, 3.59176844e-01f, 3.29215936e-02f, 2.40943387e-01f, 2.84182012e-01f, 2.63733178e-01f, 2.08216399e-01f, 3.42220515e-01f, 3.46103385e-02f, 5.17782748e-01f,
  7.91265965e-02f, 3.72924745e-01f, -4.32811171e-01f, 3.37468386e-01f, 3.73522937e-01f, 1.55807629e-01f, -1.12683903e-02f, 5.34766078e-01f, -2.66327411e-01f, 2.43327618e-01f,
  -1.64063349e-01f, 9.82578546e-02f, 3.72414216e-02f, 2.66607821e-01f, -2.35561103e-01f, 4.02022064e-01f, -1.45813003e-01f, 4.52435315e-02f, 1.52612299e-01f, -7.60507444e-03f,
  -7.54026547e-02f, 2.00405508e-01f, -4.57923077e-02f, 3.62703688e-02f, 3.50648493e-01f, 1.96504444e-01f, -1.05036832e-01f, 4.68469024e-01f, 4.12223756e-01f, 1.67884659e-02f,
  -5.65111488e-02f, -3.92161548e-01f, 4.08809066e-01f, -1.73789084e-01f, 2.96288252e-01f, -2.04714537e-01f, -1.86619699e-01f, -2.70069838e-01f, -2.76567131e-01f, 3.52763794e-02f,
  1.32589847e-01f, 3.57278027e-02f, -5.44485077e-02f, 3.17554921e-01f, -4.69844136e-03f, -3.68768156e-01f, -1.74052551e-01f, 1.45378947e-01f, 7.36347511e-02f, 1.10972501e-01f,
  5.90889573e-01f, -2.84775108e-01f, 3.93695474e-01f, 6.14232272e-02f, -5.35481982e-02f, -1.44411877e-01f, 2.91068610e-02f, 2.25933999e-01f, -3.47340912e-01f, -3.19077849e-01f,
  -1.76764548e-01f, -1.66655421e-01f, -6.98049739e-02f, -7.40744546e-02f, 1.82760373e-01f, -2.30855227e-01f, -2.14463726e-01f, -2.18205005e-01f, -4.12252471e-02f, 4.41168189e-01f,
  2.92879269e-02f, -4.90573406e-01f, 3.08531653e-02f, 3.92631441e-01f, 4.23640668e-01f, 4.86764051e-02f, 5.77727497e-01f, 2.17381448e-01f, 4.40234154e-01f, -3.15061420e-01f,
  5.88406213e-02f, 4.42630917e-01f, -3.53049308e-01f, 3.77519242e-02f, 7.62380138e-02f, 1.02386735e-01f, 1.51765198e-01f, 6.33178353e-02f, 5.33469915e-02f, 2.88804680e-01f,
  4.18692648e-01f, -3.36319357e-02f, 2.60942876e-01f, 2.28875026e-01f, 3.70649368e-01f, 3.87103111e-01f, -9.79753360e-02f, 4.38100427e-01f, 6.49987906e-02f, 1.56770170e-01f,
  -1.81058228e-01f, -2.63295650e-01f, -1.73765749e-01f, 2.22805232e-01f, 5.76833747e-02f, -2.07076013e-01f, -3.99093330e-03f, 2.31489196e-01f, 2.02400804e-01f, 1.33826390e-01f,
  -3.25542212e-01f, 2.08915710e-01f, 7.32743740e-02f, 2.20565155e-01f, -8.15744102e-02f, -2.72219509e-01f, 2.09873527e-01f, 2.14545071e-01f, -9.90089551e-02f, 3.09545308e-01f,
  1.21540889e-01f, -3.47139388e-01f, -3.71770173e-01f, -2.59524044e-02f, 2.79615194e-01f, 3.19904029e-01f, -8.56407955e-02f, -2.18004361e-01f, -2.40165308e-01f, -4.28156197e-01f,
  3.26823086e-01f, -5.96623957e-01f, 4.26375508e-01f, 1.30462199e-01f, -1.27007291e-01f, -3.76191884e-02f, 3.26831520e-01f, 1.19856142e-01f, 1.13281399e-01f, 2.41007488e-02f,
  4.40934338e-02f, 1.14725985e-01f, 3.39167923e-01f, -2.40812868e-01f, 1.54356956e-02f, 4.34086293e-01f, 1.08640060e-01f, 7.38440007e-02f, 2.85015523e-01f, 2.85832196e-01f,
  -4.10166457e-02f, 4.20017332e-01f, 3.15688670e-01f, 6.54974639e-01f, 4.70892191e-01f, -1.07452027e-01f, 3.61963958e-01f, 3.85635048e-01f, -4.98215528e-03f, 2.02341780e-01f,
  4.67818528e-01f, 2.74409167e-02f, -1.45819318e-02f, 1.52291268e-01f, 2.09712684e-01f, 2.67382801e-01f, 1.06062908e-02f, -2.26208955e-01f, -3.00193548e-01f, 3.42707723e-01f,
  -3.24068516e-02f, 2.22415254e-01f, 2.66942084e-01f, 3.81038964e-01f, -3.17822248e-01f, 3.54912519e-01f, -2.53335416e-01f, 1.53479829e-01f, 1.61476314e-01f, -3.18488968e-03f,
  1.57956704e-02f, 2.60728240e-01f, 1.78294763e-01f, 4.19201106e-01f, 1.06797479e-01f, -2.02171475e-01f, -1.82599470e-01f, 5.20892620e-01f, 3.95225048e-01f, 4.69682068e-01f,
  8.32953900e-02f, -1.37194499e-01f, 1.22510649e-01f, 1.43587904e-03f, 4.81886655e-01f, -4.22401667e-01f, 9.62880105e-02f, -1.05375625e-01f, -1.50628224e-01f, 1.27055630e-01f,
  1.31557062e-01f, 7.57373422e-02f, 3.45120847e-01f, 2.02154636e-01f, -1.46205798e-01f, -2.41200313e-01f, -4.71012980e-01f, 3.01532537e-01f, 4.27359343e-01f, -3.96861345e-01f,
  3.52995604e-01f, 2.59475023e-01f, -1.44267246e-01f, 4.93230581e-01f, 4.10333961e-01f, -1.19396381e-01f, 2.36539155e-01f, 2.00283363e-01f, 1.58728417e-02f, 3.79529357e-01f,
  -3.11891045e-02f, -2.34028548e-01f, -2.52215751e-02f, 1.77469868e-02f, 5.79854846e-01f, 1.29566610e-01f, 3.77374470e-01f, -2.04393327e-01f, -1.33741036e-01f, -3.56401086e-01f,
  3.77436690e-02f, 3.47951472e-01f, 1.40619995e-02f, 2.67049342e-01f, 6.92526326e-02f, -4.70295288e-02f, 2.32019573e-02f, 2.03981638e-01f, 8.47044364e-02f, -1.96248349e-02f,
  3.21808070e-01f, 1.61616087e-01f, 1.59933537e-01f, 1.33716136e-01f, 5.46943128e-01f, 3.08169365e-01f, 2.37699419e-01f, 1.14014305e-01f, 3.64910960e-01f, 3.88134211e-01f,
  -5.68411388e-02f, -8.07822049e-02f, 3.03944439e-01f, 1.71552282e-02f, -1.60900667e-01f, -9.74887330e-03f, 4.23042148e-01f, -1.05242915e-01f, -1.26699850e-01f, 2.20972404e-01f,
  4.28217500e-01f, 5.08676246e-02f, 2.04169109e-01f, 5.31885996e-02f, -2.02721879e-01f, 3.39085788e-01f, 2.59330064e-01f, 9.71728638e-02f, 2.33733550e-01f, -1.40156850e-01f,
  2.16386795e-01f, -3.52934510e-01f, 1.54731110e-01f, 8.91209617e-02f, 3.51470374e-02f, 3.98326427e-01f, 1.92447484e-01f, -2.14968752e-02f, 3.78920883e-01f, 9.09354314e-02f,
  -2.57576047e-03f, 2.82941341e-01f, 2.37043306e-01f, 1.16182931e-01f, 1.38523275e-04f, -4.28952910e-02f, -6.81637451e-02f, 3.75923812e-01f, 2.56884128e-01f, 2.61881053e-01f,
  -2.47355565e-01f, 2.23868310e-01f, 7.59489238e-02f, 2.98844337e-01f, 2.91732490e-01f, 5.56360126e-01f, -2.92073846e-01f, 7.47701228e-02f, 5.74361801e-01f, 3.41726631e-01f,
  2.76949614e-01f, -5.02751112e-01f, -5.00177681e-01f, 4.69575711e-02f, 2.32185930e-01f, -1.51136369e-01f, 2.39283592e-01f, 2.92990059e-01f, -2.86472619e-01f, -4.43121651e-03f,
  -9.44677666e-02f, -3.94108593e-01f, -1.02619626e-01f, 2.77242601e-01f, 7.74379447e-02f, 1.36272982e-01f, -1.31167024e-01f, -1.86413407e-01f, 4.59404171e-01f, -5.37662022e-02f,
  -1.22262500e-01f, 4.20515656e-01f, 3.26087445e-01f, -3.99782173e-02f, -1.42773822e-01f, 1.80662885e-01f, 1.60092518e-01f, -3.25989902e-01f, 6.46505412e-03f, 3.41195539e-02f,
  4.11215752e-01f, 3.10384274e-01f, 3.30638736e-01f, 2.86390811e-01f, 3.18204649e-02f, -1.23142309e-01f, 1.93548277e-01f, 3.52238238e-01f, -9.55870897e-02f, 3.01979274e-01f,
  -4.23690453e-02f, -1.18557252e-01f, 3.61961305e-01f, 3.71199250e-01f, 2.36082911e-01f, -8.17342475e-03f, 4.59106207e-01f, 3.71306121e-01f, 7.56134018e-02f, 1.88801184e-01f,
  5.36852062e-01f, 2.14202270e-01f, -4.32831645e-02f, 7.41674080e-02f, 1.30198106e-01f, -7.15230331e-02f, 2.68196762e-01f, -4.72830027e-01f, 1.45324722e-01f, 3.68130058e-01f,
  3.47634405e-01f, -3.92078534e-02f, 3.62324178e-01f, 3.66387784e-01f, 4.35184628e-01f, 2.28018370e-02f, -6.21211790e-02f, -7.38071352e-02f, 6.37767091e-03f, 5.79837978e-01f,
  4.79678184e-01f, 1.57877460e-01f, -3.14613789e-01f, -2.97551811e-01f, -4.77273107e-01f, 4.07503456e-01f, 1.24820687e-01f, 4.13069874e-01f, -5.65559231e-03f, 2.30637267e-01f,
  5.24194241e-01f, 6.57424271e-01f, 7.62411067e-03f, 4.51157317e-02f, -2.25650474e-01f, 1.90583125e-01f, 3.21945585e-02f, -1.00619607e-01f, 1.97601859e-02f, 2.40283862e-01f,
  -8.64969343e-02f, -4.60256577e-01f, 1.91598311e-01f, -6.15433007e-02f, 1.63123205e-01f, 1.31284356e-01f, -7.38007724e-02f, 2.42123842e-01f, -3.02221805e-01f, 3.75898421e-01f,
  3.66731018e-01f, -6.73433840e-02f, -2.06327751e-01f, 2.19880734e-02f, 3.31426591e-01f, -1.77874252e-01f, 4.36387956e-01f, 3.65480244e-01f, 2.65415102e-01f, -2.15947032e-01f,
  -3.19002211e-01f, 3.08697760e-01f, 2.98737735e-01f, 2.32138261e-01f, -2.38841429e-01f, 1.82545379e-01f, -1.22330993e-01f, 2.28985488e-01f, 4.42055345e-01f, 2.18881071e-01f,
  4.97408628e-01f, 2.66257674e-01f, 2.83445865e-01f, 3.90570968e-01f, -9.02297720e-03f, 3.76993001e-01f, 1.80207610e-01f, 4.03534800e-01f, 5.17122507e-01f, 3.39504302e-01f,
  5.05465806e-01f, 8.43987986e-03f, -4.61518258e-01f, 4.76950347e-01f, 3.41066420e-01f, 2.24643163e-02f, -3.95742267e-01f, 2.27596477e-01f, -4.77021299e-02f, 8.55186805e-02f,
  7.91058615e-02f, 4.88752753e-01f, 1.47168592e-01f, -1.33935168e-01f, 1.43164426e-01f, -5.91918975e-02f, 2.03661710e-01f, 2.71918952e-01f, 6.24555871e-02f, 5.42041659e-01f,
  1.47803500e-01f, 3.36521149e-01f, -3.65569621e-01f, -6.41531274e-02f, -1.32975385e-01f, 4.08301409e-03f, -7.97309726e-02f, -3.56590778e-01f, 3.98008436e-01f, 2.35972062e-01f,
  1.80057406e-01f, -3.99783552e-01f, -3.41657788e-01f, -3.03622484e-01f, 3.62342626e-01f, 2.25171372e-01f, 4.68132854e-01f, 1.19400315e-01f, 3.57109427e-01f, 1.60060197e-01f,
  2.78664708e-01f, 5.15013218e-01f, 1.78643122e-01f, 3.85197878e-01f, 3.51596326e-01f, -5.80815710e-02f, 7.80987516e-02f, 4.89490718e-01f, -1.78970117e-02f, 9.43027735e-02f,
  4.89594162e-01f, -2.77754664e-01f, -2.87392020e-01f, -1.61900908e-01f, 3.98679733e-01f, 1.82688832e-01f, 2.82922477e-01f, -2.66682208e-01f, 5.90671552e-03f, 1.38016328e-01f,
  3.44202101e-01f, 3.40041697e-01f, 2.63634622e-01f, 2.55668253e-01f, -2.83479720e-01f, 2.84365892e-01f, -2.37689510e-01f, 1.38920248e-01f, 1.31018803e-01f, 1.89880833e-01f,
  -5.49183153e-02f, 2.56001085e-01f, 2.47489616e-01f, 1.29744224e-02f, 3.70246768e-01f, -1.24060571e-01f, -6.92858398e-02f, 5.25754631e-01f, 1.16781354e-01f, -1.24291457e-01f,
  3.01719904e-02f, 3.25673729e-01f, 4.81513217e-02f, 2.27690831e-01f, 3.43702257e-01f, 8.36988613e-02f, -3.20948571e-01f, -4.09585863e-01f, -4.44190830e-01f, 3.75057787e-01f,
  1.54097319e-01f, -1.68249235e-01f, -3.56788114e-02f, 1.98774822e-02f, 1.86169446e-01f, 9.75837335e-02f, 9.38983485e-02f, 1.14911266e-01f, -2.09146544e-01f, 3.99991959e-01f,
  2.47081533e-01f, 4.04865406e-02f, 6.08985573e-02f, 4.66223001e-01f, -1.60729662e-01f, 2.51965560e-02f, 3.81709367e-01f, -1.11787319e-01f, -1.28702611e-01f, 3.67598951e-01f,
  2.70291775e-01f, -6.90315068e-02f, 1.59769833e-01f, -4.39309090e-01f, 8.67591873e-02f, 4.24164496e-02f, 1.23907499e-01f, -4.44351673e-01f, -2.71032035e-01f, -2.63346136e-01f,
  -4.20143902e-01f, 7.82688558e-02f, 4.03512836e-01f, -1.38390958e-01f, 4.74319458e-01f, 4.20036048e-01f, 2.40033016e-01f, -6.51574671e-01f, -5.32060683e-01f, -3.94610107e-01f,
  4.87387300e-01f, 2.76695122e-03f, 3.84185523e-01f, 1.60182446e-01f, -7.74725154e-02f, -5.70359416e-02f, 2.59957492e-01f, 2.47601885e-02f, -6.54835552e-02f, -1.29824653e-01f,
  7.50632510e-02f, 2.66279727e-01f, -5.36584973e-01f, 3.50131929e-01f, 5.09484291e-01f, 1.54401930e-02f, -8.49737525e-02f, 4.98478627e-03f, 2.76724219e-01f, 3.06296181e-02f,
  3.41433138e-01f, 3.43118697e-01f, 3.10819536e-01f, -2.20015436e-01f, 4.30190563e-02f, 3.50405753e-01f, 2.21920505e-01f, 1.37917027e-01f, 2.51138687e-01f, -2.10817948e-01f,
  -1.40007824e-01f, -5.61644398e-02f, 3.26303882e-03f, 3.76000643e-01f, 2.02906832e-01f, -2.04872102e-01f, 2.77094990e-01f, -1.61021709e-01f, 1.62197977e-01f, 9.65656340e-02f,
  2.51309983e-02f, -2.09768355e-01f, -2.22831473e-01f, -2.96843290e-01f, 3.30819450e-02f, 3.41262490e-01f, -2.52484769e-01f, -1.56344876e-01f, -3.63233656e-01f, -2.03507185e-01f,
  5.16018737e-03f, 7.65136182e-02f, 4.92763102e-01f, 4.46219385e-01f, 2.62541354e-01f, -7.57429600e-02f, 1.10766016e-01f, 2.09158361e-01f, 2.16193691e-01f, 1.63081273e-01f,
  2.16059893e-01f, -2.56706685e-01f, -8.93195644e-02f, -1.85977042e-01f, 4.70033705e-01f, -4.99571800e-01f, -1.15779527e-01f, 4.69500810e-01f, 3.29180062e-01f, 2.15044077e-02f,
  4.89818096e-01f, -1.71438351e-01f, 8.53915215e-02f, -2.34737441e-01f, -1.45314550e-02f, 3.75426859e-01f, -2.45326743e-01f, -4.70081121e-01f, -3.59061360e-02f, 4.49448556e-01f,
  1.25874877e-01f, 1.48872092e-01f, 1.30887344e-01f, -6.44478900e-03f, -2.15826053e-02f, 2.18793035e-01f, 2.19606563e-01f, 2.91504294e-01f, -1.47987559e-01f, 2.84239531e-01f,
  2.85406798e-01f, 4.54257011e-01f, 4.28010494e-01f, 1.28169462e-01f, -2.20070958e-01f, -1.11682445e-01f, -6.31306767e-02f, 3.77196223e-01f, 3.92257780e-01f, -2.27637276e-01f,
  1.65568739e-01f, 4.35492732e-02f, -7.11027607e-02f, 1.98951289e-01f, 8.76587257e-02f, -1.04270531e-02f, -2.07267165e-01f, 3.19039188e-02f, 5.20436205e-02f, 1.42444119e-01f,
  1.07759230e-01f, -3.93339187e-01f, -3.01679194e-01f, 1.82652131e-01f, 2.54223019e-01f, -2.52156466e-01f, 1.77185401e-01f, 8.20994675e-02f, -1.60662383e-01f, -1.65848091e-01f,
  2.18144804e-01f, 1.34328436e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 26)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 26;
const float L1_fan_Bp_bar_data[] = {
  1.68481067e-01f, 1.40828803e-01f, 4.05773014e-01f, 2.94644207e-01f, 1.78510267e-02f, 1.46395534e-01f, 2.57325858e-01f, 1.59879357e-01f, -8.67110193e-02f, 1.05663300e-01f,
  2.13965550e-01f, 2.60974199e-01f, -4.92643975e-02f, 3.42584074e-01f, 3.11240435e-01f, 4.00819123e-01f, 2.97689289e-01f, 2.06304088e-01f, 2.08381101e-01f, 3.26667607e-01f,
  2.12046042e-01f, 2.18788604e-03f, 2.42157027e-01f, 1.55117407e-01f, 3.29757035e-01f, 1.65385932e-01f
};

// L2_fan_Wp (Shape: 3 x 32)
const int L2_fan_Wp_rows = 3;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.25277236e-01f, -2.15794161e-01f, -7.88442045e-02f, -6.00833446e-02f, 1.01622147e-02f, 1.62468553e-01f, -6.91287220e-02f, -5.30225188e-02f, -5.78764305e-02f, 1.60969734e-01f,
  2.21701130e-01f, 9.80037171e-03f, -2.12012365e-01f, 1.40480712e-01f, -7.57387578e-02f, 1.99231938e-01f, -1.21196203e-01f, -1.21396564e-01f, 3.53687346e-01f, -3.58480997e-02f,
  -4.15894128e-02f, -1.39105497e-02f, -3.36900167e-02f, -4.41512326e-03f, 9.97524559e-02f, 9.46568605e-03f, 2.36105900e-02f, -1.06892094e-01f, -1.49084255e-01f, -2.23178133e-01f,
  -2.91392896e-02f, -3.82753313e-01f, -3.25915627e-02f, -2.24824354e-01f, -2.17318147e-01f, 2.80965745e-01f, -1.16899416e-01f, 6.53360412e-02f, -8.43572337e-03f, -4.46301661e-02f,
  -2.77311862e-01f, 1.44745097e-01f, 1.98923498e-01f, 1.60445541e-01f, 8.23715106e-02f, -3.57304979e-03f, -1.11731673e-02f, 3.18051092e-02f, -5.52185178e-02f, -1.84083015e-01f,
  5.04314192e-02f, 1.26763731e-01f, -2.18654603e-01f, -1.05190963e-01f, -9.75177437e-02f, 1.35565162e-01f, -1.49761373e-02f, -2.43575141e-01f, 2.36866102e-01f, 1.40851736e-01f,
  -1.79523289e-01f, -6.82376930e-03f, 1.89701885e-01f, 1.16989143e-01f, 3.15012485e-02f, -2.36823350e-01f, 6.63980469e-02f, 1.90865085e-01f, -1.89627096e-01f, 1.30853161e-01f,
  -7.42545119e-03f, 1.53841674e-01f, -1.27461225e-01f, 6.96647316e-02f, 6.64243028e-02f, -1.01245485e-01f, 1.18706219e-01f, -1.12730891e-01f, 1.94965079e-01f, -7.04595074e-02f,
  -5.25504500e-02f, -1.47699201e-02f, -7.70753063e-03f, 3.96381691e-02f, 1.06581949e-01f, 4.81827818e-02f, -1.80384338e-01f, 7.81643242e-02f, -3.44321644e-03f, -7.66980946e-02f,
  -1.30403563e-01f, -1.76238194e-01f, 1.89665914e-01f, 1.58519987e-02f, 1.34092197e-01f, 1.07491031e-01f
};

// L2_fan_Wp_bar (Shape: 26 x 32)
const int L2_fan_Wp_bar_rows = 26;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -1.75281474e-03f, 1.07039707e-02f, 3.89117934e-02f, -4.64603961e-01f, -2.38100216e-01f, -1.91981211e-01f, 1.24000274e-01f, -4.33036864e-01f, 1.99885115e-01f, -2.72208571e-01f,
  5.93348920e-01f, -1.91495746e-01f, -2.49986738e-01f, 2.04336271e-01f, -4.33854461e-01f, 5.10835290e-01f, -2.37971414e-02f, 6.39328733e-02f, -4.97190580e-02f, 5.83900750e-01f,
  -8.84995908e-02f, 9.91595909e-02f, 2.92617708e-01f, -1.46369994e-01f, 2.67520279e-01f, 2.90156811e-01f, 2.53088444e-01f, -2.92658150e-01f, -5.30488566e-02f, 1.78032219e-02f,
  3.59249264e-01f, -9.75707695e-02f, -2.44798645e-01f, -2.05636099e-01f, -3.52068007e-01f, 3.37380201e-01f, -3.14086974e-02f, 1.93222743e-02f, 3.46635610e-01f, -7.58821238e-03f,
  -6.00348234e-01f, 1.78532213e-01f, 2.08693758e-01f, -4.60091382e-02f, 3.06227803e-01f, -1.77528560e-01f, 1.39031574e-01f, 4.93808955e-01f, 5.64214811e-02f, 6.06138408e-02f,
  6.64526224e-01f, 1.94745377e-01f, -6.30818427e-01f, 2.35973541e-02f, -1.23038284e-01f, 2.42206246e-01f, -9.87783521e-02f, 4.45411563e-01f, -1.07260376e-01f, -6.36063069e-02f,
  1.65953264e-01f, 4.07138109e-01f, -4.47502099e-02f, 1.97195292e-01f, -2.16601878e-01f, -7.59003013e-02f, -3.78959924e-01f, 1.14591084e-02f, -8.48261341e-02f, 1.59515291e-02f,
  1.24023914e-01f, 1.74362045e-02f, -2.16149762e-01f, -3.64937037e-01f, 4.76964533e-01f, 3.12160701e-01f, -3.71843487e-01f, 3.10262620e-01f, -1.46432951e-01f, 4.35332835e-01f,
  6.83775619e-02f, 2.05264971e-01f, 1.93119556e-01f, 2.78335840e-01f, -2.54688740e-01f, 1.49974629e-01f, 1.63102090e-01f, 3.13556999e-01f, 2.67445475e-01f, -1.19812414e-01f,
  1.62972480e-01f, 8.50514993e-02f, -9.14571062e-02f, -2.55612791e-01f, 1.43894017e-01f, -3.48888010e-01f, 3.73577327e-02f, -4.86628339e-02f, -7.38222450e-02f, 4.68534157e-02f,
  -1.55504569e-01f, 4.86868657e-02f, 4.22378838e-01f, -3.27215269e-02f, -2.53372669e-01f, 2.96947777e-01f, -4.52576578e-02f, 1.14143364e-01f, 4.84197885e-01f, -3.31593722e-01f,
  -3.49247344e-02f, 3.36879700e-01f, 2.00298771e-01f, 2.89023399e-01f, 2.75212228e-01f, -1.05504848e-01f, 1.52977347e-01f, -1.89340159e-01f, 6.54147789e-02f, 1.39990047e-01f,
  -3.22250009e-01f, 2.73501277e-01f, -4.36035134e-02f, -9.68893617e-02f, 2.58541912e-01f, 9.83918607e-02f, 2.17314705e-01f, 1.48932897e-02f, -5.40922098e-02f, -7.10303783e-02f,
  -1.41576633e-01f, -2.16157213e-01f, 4.67919419e-03f, 4.21013981e-01f, 1.39330491e-01f, -7.19261542e-02f, -3.21115941e-01f, 1.25647811e-02f, 2.54230738e-01f, -1.91858828e-01f,
  2.13367324e-02f, 8.52006525e-02f, -1.46171466e-01f, 1.59127712e-01f, -1.88058123e-01f, -2.05217320e-02f, 2.71457791e-01f, 1.89730003e-01f, -8.46506953e-02f, 4.11049724e-01f,
  -6.17764711e-01f, 2.16396108e-01f, -5.11034429e-01f, 1.66781083e-01f, -2.90572286e-01f, 9.48631987e-02f, 1.43387511e-01f, 2.35626474e-01f, 3.09735328e-01f, -1.26694396e-01f,
  3.92866045e-01f, 4.00285363e-01f, 2.38463283e-01f, -3.20719689e-01f, -1.90561056e-01f, -4.05337512e-01f, -1.41650215e-01f, 3.47803026e-01f, 7.55141914e-01f, 3.62954848e-02f,
  -2.68221702e-02f, 2.14062370e-02f, 1.36873558e-01f, 2.99158514e-01f, -3.36618453e-01f, -1.58674065e-02f, 3.56466055e-01f, 3.25650662e-01f, -3.40754181e-01f, 1.67119548e-01f,
  6.36627078e-01f, 2.85931200e-01f, 5.97740889e-01f, -3.07918042e-01f, 6.34909689e-01f, 3.76495682e-02f, 3.08350742e-01f, 4.35316384e-01f, 3.51004392e-01f, -1.01272568e-01f,
  -2.36585978e-02f, 4.01356667e-01f, -2.03052133e-01f, 3.96545827e-02f, 1.61958531e-01f, 3.97222608e-01f, 4.91444468e-01f, -2.56236315e-01f, -1.38331175e-01f, 4.32584733e-01f,
  -2.95225173e-01f, 3.85589838e-01f, 1.87179416e-01f, 1.14860497e-01f, -1.93989962e-01f, -2.08955675e-01f, 2.00553223e-01f, -1.22484609e-01f, 3.21832955e-01f, -1.58957943e-01f,
  -5.16032428e-02f, -1.09425820e-01f, -2.80459315e-01f, 2.62553275e-01f, 2.99961805e-01f, 3.86478037e-01f, -2.90341944e-01f, 1.16136558e-01f, 1.16223782e-01f, 1.88192904e-01f,
  1.27104625e-01f, 2.48938411e-01f, -2.80994534e-01f, 3.76404256e-01f, 3.87893580e-02f, -3.41207296e-01f, -4.09432113e-01f, -1.50622308e-01f, -3.05951685e-01f, 3.01335126e-01f,
  3.29287171e-01f, -2.76461512e-01f, -4.67203408e-01f, -2.70600487e-02f, 1.36916608e-01f, 1.02411591e-01f, 3.92877042e-01f, -1.19634479e-01f, -1.11018486e-01f, 1.94794033e-02f,
  1.78681880e-01f, 5.49027443e-01f, 4.76278663e-01f, 4.44532871e-01f, -2.32504293e-01f, -7.51830786e-02f, -2.74956822e-01f, 2.11033449e-01f, 7.96415359e-02f, 1.27868935e-01f,
  1.04272939e-01f, 9.99046862e-02f, 1.32548243e-01f, 5.21687828e-02f, 5.04374146e-01f, -3.88332829e-02f, 4.03110653e-01f, 2.44915679e-01f, 2.25662634e-01f, -2.07495615e-01f,
  -4.00520772e-01f, 3.21410745e-01f, 3.17764848e-01f, -3.10526546e-02f, 4.03565198e-01f, 3.32071692e-01f, -2.60210544e-01f, -1.20274127e-01f, 4.88188952e-01f, -3.73138398e-01f,
  -6.53310642e-02f, 1.79793015e-01f, -1.40093669e-01f, 1.18369862e-01f, -1.35075346e-01f, 3.34627062e-01f, 6.13967717e-01f, -1.88797355e-01f, 2.89377719e-01f, 1.70327544e-01f,
  -3.59555334e-01f, 3.74943286e-01f, -2.95710683e-01f, -4.41684686e-02f, 5.79521894e-01f, 1.21316172e-01f, 3.46958637e-01f, 1.21023424e-01f, -2.28794172e-01f, 3.05785656e-01f,
  1.47737369e-01f, -1.37356758e-01f, 3.73998582e-01f, -5.00126779e-01f, -2.48991281e-01f, -1.08278282e-01f, 2.50679761e-01f, 1.82725266e-01f, 2.87239999e-01f, -1.86973497e-01f,
  -3.17713171e-01f, 5.58748126e-01f, 1.54494628e-01f, 2.15715647e-01f, 2.03767464e-01f, -3.09652418e-01f, -1.70044228e-01f, 7.78356865e-02f, 1.83242500e-01f, 4.09188390e-01f,
  5.26633859e-01f, -7.33952448e-02f, 4.52801049e-01f, 8.92443284e-02f, 9.95327756e-02f, -8.48610513e-03f, 1.84439182e-01f, -1.03639355e-02f, -5.23571074e-02f, 2.28920668e-01f,
  2.38888115e-01f, 3.78803045e-01f, 4.95132178e-01f, -2.70443968e-02f, 3.10086478e-02f, -1.83734000e-01f, 6.90554529e-02f, 5.26117384e-01f, 3.85153443e-02f, 5.24722993e-01f,
  -3.72971624e-01f, -1.31439731e-01f, -1.01431563e-01f, -4.55399742e-03f, 2.07419440e-01f, -3.87713671e-01f, 1.80305630e-01f, 3.30103189e-01f, -5.10690093e-01f, -6.12786971e-02f,
  3.86618853e-01f, 4.94764149e-01f, -6.13697805e-02f, 3.10900360e-01f, -2.27751762e-01f, 1.21330246e-01f, 2.12443158e-01f, -6.37778118e-02f, 4.97816682e-01f, -7.97449437e-04f,
  3.33495140e-01f, 2.10313946e-01f, -2.09703773e-01f, 1.11862510e-01f, -8.72886553e-02f, 3.20569098e-01f, 1.93045095e-01f, -1.95076376e-01f, -2.51576573e-01f, 3.44468474e-01f,
  -3.97825539e-01f, 1.01469077e-01f, -1.44264922e-01f, 2.81096697e-01f, 4.75398153e-02f, 9.50826611e-03f, 3.76098007e-01f, 7.50089809e-02f, 2.64852166e-01f, -1.89590864e-05f,
  1.82384714e-01f, -1.71277761e-01f, -4.55966622e-01f, 2.46682391e-01f, 3.34792733e-01f, 6.11845665e-02f, 1.94204058e-02f, 2.41216674e-01f, 3.31531495e-01f, 3.84627402e-01f,
  -2.57607192e-01f, 2.01382469e-02f, -2.96004713e-01f, 3.18817943e-01f, 1.69778809e-01f, 2.60041744e-01f, 3.85273606e-01f, -3.44427675e-01f, -2.73687214e-01f, 3.62400413e-01f,
  2.47043163e-01f, 3.84160161e-01f, -1.09007210e-01f, 2.24862471e-01f, 4.55999635e-02f, 2.82795906e-01f, -4.95629072e-01f, 1.43030643e-01f, -3.74700069e-01f, -3.12290996e-01f,
  9.10646245e-02f, 5.60872078e-01f, -2.53211677e-01f, 1.19823448e-01f, 3.33797157e-01f, 2.71701455e-01f, -3.34675282e-01f, 1.91918746e-01f, -2.97624439e-01f, -1.21174753e-01f,
  3.92164528e-01f, 5.82570508e-02f, 1.34134740e-01f, -3.61397862e-01f, 5.57537436e-01f, -1.73928857e-01f, 6.46677017e-02f, 1.35656208e-01f, 2.21500103e-03f, 2.24346712e-01f,
  1.73395127e-02f, -5.01008444e-02f, -3.40873003e-02f, 1.15151234e-01f, -2.18113542e-01f, 3.46459866e-01f, 4.36346620e-01f, 4.93602082e-02f, -7.44127342e-03f, -5.39486669e-03f,
  2.06032202e-01f, 2.71738451e-02f, 1.39484823e-01f, -2.19792709e-01f, -1.78673901e-02f, 2.01131970e-01f, 4.23804708e-02f, 7.04943612e-02f, 2.04165146e-01f, 5.47929049e-01f,
  5.71240336e-02f, -1.79513827e-01f, 1.25096172e-01f, -3.20923954e-01f, -9.38069150e-02f, 2.65714377e-01f, -6.61913492e-03f, -6.68251663e-02f, -3.91515754e-02f, 1.42530069e-01f,
  -2.55414665e-01f, 2.96716273e-01f, -3.78742397e-01f, 2.67690241e-01f, 4.45687264e-01f, 1.52371645e-01f, -4.18319285e-01f, 3.00330013e-01f, 1.58914756e-02f, 1.01822227e-01f,
  3.76887709e-01f, -5.18822908e-01f, 2.67713577e-01f, 1.18088327e-01f, -2.60436237e-02f, 3.29386532e-01f, 1.39324710e-01f, 1.99598465e-02f, 1.63692698e-01f, -1.47203997e-01f,
  -1.66302785e-01f, 2.09014952e-01f, -1.10079877e-01f, 2.85558283e-01f, -9.50081199e-02f, -5.04398160e-02f, 3.56051832e-01f, 1.38822123e-01f, 9.06572044e-02f, 1.83684438e-01f,
  2.75003046e-01f, -9.68346223e-02f, 1.40704811e-01f, 3.49256694e-01f, -2.71674097e-01f, -1.76140562e-01f, 1.47185832e-01f, 8.34961329e-03f, 3.29524502e-02f, 4.12756056e-01f,
  -3.85582894e-01f, 2.81501412e-01f, 4.46909696e-01f, -2.60047138e-01f, 3.32751811e-01f, -4.61456887e-02f, 2.57585496e-01f, -4.33592089e-02f, -2.34613810e-02f, -2.11153895e-01f,
  3.30666125e-01f, -2.18666464e-01f, 3.68931621e-01f, 2.28520110e-01f, 2.97831297e-01f, 1.53733075e-01f, 3.10972452e-01f, 3.13370556e-01f, 2.00684234e-01f, 3.86761606e-01f,
  -6.98621795e-02f, 5.40273368e-01f, -3.40264589e-01f, -2.28605390e-01f, 4.51399088e-02f, 2.32852757e-01f, 2.26710215e-01f, -1.06803529e-01f, -6.42528087e-02f, 3.88231128e-01f,
  -5.85576653e-01f, 4.02212352e-01f, -6.03925176e-02f, 3.14164370e-01f, 1.86763659e-01f, -2.43888684e-02f, 4.75188106e-01f, 2.21067354e-01f, 4.52514648e-01f, 2.84328103e-01f,
  9.79093388e-02f, -1.39509216e-01f, -1.55255729e-02f, 1.08764566e-01f, 2.24777445e-01f, 3.49239051e-01f, -1.62620530e-01f, -3.40130143e-02f, 2.49029368e-01f, 2.71107674e-01f,
  -2.10326239e-01f, -5.36956526e-02f, 5.41436188e-02f, 1.25537217e-01f, -5.58895804e-02f, 2.61275798e-01f, 6.91012144e-02f, -9.87713337e-02f, 1.58054724e-01f, -5.91565929e-02f,
  -3.11051719e-02f, 3.26436013e-01f, 2.62563944e-01f, -5.62581792e-02f, 5.15663438e-03f, 2.76867419e-01f, -2.91023374e-01f, 5.62043563e-02f, -1.88194048e-02f, 1.75696000e-01f,
  1.23796269e-01f, 2.62552321e-01f, 6.71313656e-03f, -6.46370500e-02f, 1.14372447e-01f, 2.06784859e-01f, 1.22026771e-01f, -2.85089254e-01f, -9.87863168e-02f, 3.68607372e-01f,
  1.45274654e-01f, -6.25018701e-02f, 2.67426133e-01f, -1.69969961e-01f, -1.14664517e-01f, -1.01907082e-01f, -3.63867581e-01f, -8.11296236e-03f, -6.69929609e-02f, 4.67217080e-02f,
  8.32679346e-02f, 1.48953870e-01f, 4.36875254e-01f, 1.52141556e-01f, -3.86965007e-01f, 2.40752324e-02f, 3.90001267e-01f, 1.00121014e-02f, -2.76176095e-01f, 4.68588546e-02f,
  2.65718788e-01f, -6.52497336e-02f, 3.10198694e-01f, -6.48259968e-02f, 2.77528912e-01f, 2.39090294e-01f, -5.55549443e-01f, 2.42188409e-01f, -3.89008112e-02f, 4.28413808e-01f,
  -1.65728360e-01f, 1.39294729e-01f, 2.15182215e-01f, 8.15181136e-02f, -1.75483115e-02f, 9.19717699e-02f, 2.44986013e-01f, -1.73408091e-01f, -3.08468431e-01f, 6.21358417e-02f,
  -1.84942380e-01f, 9.30634420e-03f, 5.02096593e-01f, -2.82178205e-02f, 1.02299526e-01f, 1.27505455e-02f, 9.07200575e-02f, -1.41625732e-01f, 2.42571205e-01f, 2.48151571e-01f,
  -3.40571046e-01f, 1.91067174e-01f, -6.68268129e-02f, 5.41119456e-01f, 6.07018732e-02f, 3.11619304e-02f, 3.53365600e-01f, -1.99822247e-01f, -2.42488503e-01f, 3.01634490e-01f,
  3.75819266e-01f, -1.65502667e-01f, -2.92632878e-02f, 5.62337995e-01f, -1.54505864e-01f, 2.77745098e-01f, -5.54931015e-02f, 8.34066719e-02f, -4.47438896e-01f, 1.56949341e-01f,
  5.15016392e-02f, 4.74696606e-02f, 2.91503698e-01f, 1.13812685e-01f, -2.48214349e-01f, 2.76514236e-02f, 2.09387258e-01f, -1.32311091e-01f, 1.07563719e-01f, 9.99237895e-02f,
  9.85715017e-02f, -2.99510628e-01f, 3.62548441e-01f, -4.66447443e-01f, 1.25536785e-01f, 2.02167742e-02f, -3.63219082e-02f, -2.07091078e-01f, 2.12605819e-01f, 2.54984200e-01f,
  -1.57452464e-01f, 2.53893305e-02f, 2.87488997e-01f, 2.54575282e-01f, -5.59584975e-01f, 5.22672892e-01f, -2.98067868e-01f, -4.11129802e-01f, 4.82546031e-01f, 5.58309734e-01f,
  3.44608128e-01f, 6.46418557e-02f, -1.06900208e-01f, -1.18359596e-01f, -2.48327646e-02f, -1.55469239e-01f, -4.14469570e-01f, 3.29477370e-01f, 3.20488125e-01f, -1.59692347e-01f,
  -2.73807913e-01f, -1.68118402e-01f, 3.40435445e-01f, -1.58180952e-01f, -4.23915051e-02f, -1.16347760e-01f, -3.48404735e-01f, -1.40444979e-01f, -1.65337399e-01f, 2.93379635e-01f,
  8.81109461e-02f, 2.21585944e-01f, -4.71736379e-02f, 3.05955350e-01f, -4.74795341e-01f, 2.95319110e-01f, -7.99615532e-02f, 2.79453862e-02f, -3.45388092e-02f, -1.05577968e-01f,
  1.56875998e-01f, -1.67788252e-01f, 3.90863389e-01f, -2.52330393e-01f, 1.41703099e-01f, 1.82919741e-01f, 1.28544420e-01f, -8.39365926e-03f, -4.07195032e-01f, 1.42093942e-01f,
  2.99620271e-01f, 1.95279509e-01f, -3.78283799e-01f, 3.04211199e-01f, -4.72797215e-01f, 2.67438412e-01f, 5.04426837e-01f, -5.54591596e-01f, 1.83324993e-01f, -7.54896179e-02f,
  1.84538051e-01f, 3.77012730e-01f, 2.10353822e-01f, -2.50678599e-01f, 1.79895967e-01f, -1.28695279e-01f, 8.73662159e-02f, 2.40299299e-01f, -1.22613935e-02f, -1.70795172e-02f,
  1.70354798e-01f, 6.11157976e-02f, 2.14749619e-01f, 3.60339843e-02f, 9.81077901e-04f, 3.22297122e-03f, -2.03322992e-02f, 3.29980135e-01f, 2.35615268e-01f, 1.62737042e-01f,
  4.89601552e-01f, -1.55856580e-01f, -1.16452120e-01f, 4.98459905e-01f, -1.05625287e-01f, 3.47959667e-01f, -2.36332357e-01f, 4.66388077e-01f, -2.85871476e-01f, 1.59945756e-01f,
  1.60569042e-01f, -4.63346876e-02f, 4.94198501e-01f, 2.61968672e-01f, -1.06719226e-01f, -2.60977238e-01f, 1.82729572e-01f, 3.39424044e-01f, 2.01323971e-01f, 1.22039102e-01f,
  3.62357236e-02f, -1.69065148e-01f, 3.14165652e-01f, 3.80184412e-01f, 1.88405648e-01f, -2.88272481e-02f, -1.65336251e-01f, 4.19795424e-01f, 4.95421402e-02f, 7.18320832e-02f,
  2.81423002e-01f, -4.73038673e-01f, -2.24914655e-01f, 6.00196086e-02f, 3.56964022e-01f, -2.08212212e-01f, 1.03038952e-01f, -2.00353786e-01f, 4.04597312e-01f, -1.15436167e-01f,
  -3.18668872e-01f, 1.24063507e-01f, -5.29737175e-01f, 1.15792371e-01f, 1.02574222e-01f, 3.18666756e-01f, 6.68546930e-02f, 2.20641419e-01f, 2.22010821e-01f, 2.23305553e-01f,
  9.61058438e-02f, 1.84440672e-01f, 2.35704601e-01f, 1.73046947e-01f, 1.46246925e-01f, -3.05752456e-01f, 1.09990127e-01f, -2.70822525e-01f, 2.27454424e-01f, -5.06305285e-02f,
  3.83586228e-01f, 2.62872010e-01f, 1.53219163e-01f, -4.40824896e-01f, -2.20947191e-01f, 3.66853699e-02f, 9.91467386e-02f, -3.06731425e-02f, 4.05227721e-01f, 1.03195738e-02f,
  3.64914626e-01f, -9.98820364e-02f, -3.90419990e-01f, 3.44892114e-01f, -4.54412758e-01f, 2.96960890e-01f, -2.75712609e-01f, -1.15112707e-01f, -7.98633695e-02f, 3.59779000e-01f,
  1.49310589e-01f, 3.34590882e-01f, 1.31459842e-02f, -2.45802030e-01f, 4.11978364e-01f, 2.16092482e-01f, 1.34647757e-01f, -3.18010658e-01f, 3.09156090e-01f, -1.00898825e-01f,
  1.28812730e-01f, -1.04695819e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 26)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 26;
const float L2_fan_Bp_bar_data[] = {
  1.26539931e-01f, -1.75090134e-01f, 4.78749610e-02f, -7.83767626e-02f, 2.03514129e-01f, 2.40126655e-01f, 5.35051934e-02f, 8.46991912e-02f, 5.90683483e-02f, 2.40695536e-01f,
  1.57536641e-01f, -1.44816652e-01f, 1.88303024e-01f, 1.80964902e-01f, -1.44102842e-01f, 2.65655160e-01f, 8.38890597e-02f, 1.16706761e-02f, -1.47361653e-02f, 3.78580131e-02f,
  -5.31495875e-03f, -3.28289829e-02f, -5.69118112e-02f, 6.85690269e-02f, 9.23905000e-02f, 3.61495078e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  9.67810396e-03f, -1.13193199e-01f, -2.76365522e-02f, 2.80605145e-02f, -4.86508235e-02f, 5.04137501e-02f, -3.12112331e-01f, -5.00460446e-01f, -4.21821065e-02f, 1.76492795e-01f,
  -3.73613447e-01f, 1.84789337e-02f, 1.78419963e-01f, -1.19410127e-01f, -7.51880333e-02f, -3.91377926e-01f, 2.54971027e-01f, -6.96241781e-02f, 3.41741621e-01f, 2.68942505e-01f,
  2.06935763e-01f, 4.39151675e-02f, 1.70062631e-01f, -2.55951248e-02f, -1.84798315e-01f, -4.88813996e-01f, -2.01847240e-01f, -2.27698654e-01f, 4.55354303e-01f, 1.77162558e-01f,
  -8.19905698e-02f, -3.82941484e-01f, 1.76137194e-01f, 1.02186598e-01f, 1.93001375e-01f, -1.26237879e-02f, 2.52414018e-01f, -2.91407108e-01f, -7.08052218e-01f, -7.57427737e-02f,
  -8.08727592e-02f, -1.37258887e-01f, -5.00058644e-02f, 1.05231017e-01f, 3.59585673e-01f, -4.60939080e-01f, -7.20141470e-01f, 1.84642106e-01f, 7.58498460e-02f, 3.65503937e-01f,
  -3.74403864e-01f, -7.36758532e-03f, -3.17914814e-01f, 2.23109514e-01f, 3.02129716e-01f, -5.90449460e-02f, 1.01411276e-01f, 1.46566033e-01f, -1.93420261e-01f, -6.56732619e-02f,
  -8.63412321e-02f, 3.63926828e-01f, -6.64042950e-01f, -4.80426461e-01f, -1.89132378e-01f, -6.72979280e-02f, -3.47869158e-01f, 1.23254977e-01f, 1.68690264e-01f, -1.56141790e-02f,
  -8.12479760e-03f, 7.09508061e-02f, 2.70367652e-01f, 4.74849567e-02f, -1.38582215e-01f, -4.36829552e-02f, 1.26816779e-01f, -7.77218863e-02f, -1.59736916e-01f, 8.72922391e-02f,
  -5.39827526e-01f, 2.03982115e-01f, -3.49166572e-01f, 9.78789330e-02f, -4.33171034e-01f, -6.28071502e-02f, 8.98739472e-02f, 1.76830664e-01f, 2.10384548e-01f, 2.19936654e-01f,
  -1.84608266e-01f, -1.67410463e-01f, -4.91599113e-01f, 1.27963811e-01f, 8.55733454e-02f, -1.66157916e-01f, 9.77282226e-02f, 2.51360908e-02f, -1.06674396e-01f, -5.42556047e-02f,
  3.91586393e-01f, 6.09297939e-02f, -2.48158917e-01f, 2.85669893e-01f, -3.46641690e-01f, 1.98688447e-01f, 3.50538224e-01f, -5.40861189e-01f, -3.47001441e-02f, 3.68037343e-01f,
  2.36112431e-01f, -8.27977359e-01f, -5.91885075e-02f, -4.70301896e-01f, -1.81941062e-01f, 1.37712404e-01f, 2.30267838e-01f, 2.08105460e-01f, -2.11453270e-02f, -5.43780327e-01f,
  -7.09392652e-02f, -2.49085307e-01f, 1.33423403e-01f, 2.09956858e-02f, 1.19701497e-01f, -4.03107017e-01f, -2.48175606e-01f, -1.00878403e-01f, 2.56480366e-01f, -1.75560787e-02f,
  -1.02826826e-01f, -4.57268357e-02f, -2.15901062e-01f, 4.54453304e-02f, 2.76965499e-02f, -2.59736270e-01f, -1.52476072e-01f, 5.43097109e-02f, 3.29185873e-01f, 7.76261184e-03f,
  -2.29328990e-01f, 9.97429043e-02f, 2.04297528e-01f, -3.61750335e-01f, 2.52917945e-01f, -2.04619274e-01f, 3.29926789e-01f, -2.90060073e-01f, 5.73788257e-03f, -3.59319121e-01f,
  -1.30743191e-01f, 2.38562778e-01f, 1.17751978e-01f, 7.31950104e-02f, 1.70166865e-01f, 2.69959331e-01f, -1.02324642e-01f, -2.06775203e-01f, 6.94890022e-02f, 2.03917310e-01f,
  8.70553181e-02f, 3.42548937e-02f, 2.54701138e-01f, -3.24629426e-01f, -2.45681852e-01f, -2.82036126e-01f, -1.42227992e-01f, -3.81855190e-01f, -4.13155973e-01f, -5.02275884e-01f,
  -1.21473595e-01f, 4.57989246e-01f, -9.36257020e-02f, -4.24393564e-01f, 1.22796498e-01f, 6.20699935e-02f, 4.36959505e-01f, -2.64560014e-01f, 2.04116464e-01f, -1.05341218e-01f,
  -6.52703404e-01f, -6.96446886e-03f, -3.06741774e-01f, 4.12090980e-02f, -6.01833165e-01f, -1.87365875e-01f, -3.25843722e-01f, -1.50201410e-01f, -1.94442898e-01f, 2.82599032e-01f,
  1.14987537e-01f, 3.67963523e-01f, -7.19876960e-02f, 2.49332637e-01f, 2.73886751e-02f, 3.82810712e-01f, -5.26809931e-01f, -3.99405003e-01f, 3.19551826e-01f, -3.35898459e-01f,
  9.89998206e-02f, -1.54493183e-01f, -2.59986550e-01f, 2.03379065e-01f, -2.95517385e-01f, -4.99818176e-01f, -9.05088186e-02f, 4.43365335e-01f, -6.58450127e-01f, -2.92051435e-01f,
  -2.73905575e-01f, 8.12618062e-02f, -3.14718820e-02f, -3.25940400e-01f, -4.86696601e-01f, 1.13189705e-01f, -3.68850678e-01f, 3.06321323e-01f, -1.58865973e-01f, -5.69412708e-01f,
  -1.48637667e-01f, -2.73641080e-01f, 6.07039481e-02f, 3.05388451e-01f, 6.91579655e-02f, -1.97018787e-01f, 7.96419308e-02f, 9.94636118e-02f, 1.55063078e-01f, 2.25671187e-01f,
  9.15914029e-02f, 3.14573467e-01f, 2.72529095e-01f, -1.02915615e-01f, 4.22727108e-01f, -6.77078843e-01f, -5.30332550e-02f, 2.69418448e-01f, -2.79863644e-02f, -5.03744423e-01f,
  -4.04994994e-01f, -9.73488539e-02f, -8.22597444e-02f, 1.13816820e-01f, -2.02758498e-02f, -4.32625830e-01f, -2.57360548e-01f, -5.12532473e-01f, 3.53392869e-01f, 2.33043492e-01f,
  1.56918019e-01f, 1.91859275e-01f, -4.87741560e-01f, -4.19351131e-01f, 6.95918873e-02f, 3.64258327e-02f, 7.36330673e-02f, -5.06819412e-03f, -1.78211480e-01f, -4.73312959e-02f,
  -1.80043951e-01f, -1.34306341e-01f, -1.85822532e-01f, 3.12947929e-01f, 1.10067442e-01f, 1.76047176e-01f, -9.30045471e-02f, 8.24560225e-02f, -6.49528056e-02f, 4.00075406e-01f,
  -2.47378752e-01f, -4.73535061e-01f, -4.18523431e-01f, 2.25442901e-01f, -3.42171848e-01f, -5.07983863e-01f, 3.90380949e-01f, 6.87785968e-02f, 1.92950010e-01f, 1.56531557e-01f,
  -2.13086009e-01f, 1.73439860e-01f, -4.48158920e-01f, -6.93663508e-02f, 3.60612780e-01f, 5.52309118e-02f, -4.43242192e-02f, -2.27895319e-01f, 1.69624463e-01f, 1.03544537e-02f,
  1.88296273e-01f, 1.93957910e-01f, 4.30720240e-01f, -1.83400214e-01f, 3.39874476e-01f, -2.82773882e-01f, 1.90395772e-01f, -4.30923223e-01f, -4.88392264e-02f, 4.34450665e-03f,
  -4.46316063e-01f, 2.82861203e-01f, -4.42577720e-01f, 1.25020012e-01f, -1.73150554e-01f, -3.62073272e-01f, 2.29649559e-01f, 2.36738026e-01f, -5.38127184e-01f, -3.76291722e-01f,
  -1.24396279e-01f, -2.69265175e-01f, 3.57098073e-01f, -4.00211036e-01f, -4.73349303e-01f, 2.29475170e-01f, -2.01550230e-01f, -3.60567600e-01f, 2.41020620e-01f, 1.53486788e-01f,
  -7.69680515e-02f, -2.08991095e-01f, 1.01601565e-02f, -6.35973215e-02f, -1.72663286e-01f, 3.45315337e-01f, -2.04260856e-01f, 2.77210504e-01f, -5.20235300e-01f, 3.81587371e-02f,
  -1.23419508e-01f, -2.00995132e-01f, 3.27377170e-01f, -2.88189143e-01f, -7.99367875e-02f, 4.27556634e-02f, 2.56195903e-01f, 3.77203114e-02f, -5.79970837e-01f, 2.30082318e-01f,
  2.47307792e-01f, -9.29544028e-03f, 6.30620494e-02f, -6.01960458e-02f, 5.52164800e-02f, 1.64499387e-01f, 3.23276669e-01f, -3.98078144e-01f, 2.99045090e-02f, 9.03398320e-02f,
  -1.69131234e-01f, -2.13826090e-01f, -2.57017314e-01f, -6.88252077e-02f, 2.29682133e-01f, -2.31988832e-01f, -1.28209844e-01f, 2.14405119e-01f, 1.01184115e-01f, -2.79243886e-01f,
  -5.59027076e-01f, 1.70861721e-01f, -4.13438886e-01f, 3.43552023e-01f, -1.17035240e-01f, -9.73275751e-02f, 4.50676054e-01f, -1.28579989e-01f, 1.30723253e-01f, -3.14308733e-01f,
  -4.58694398e-01f, -2.57097352e-02f, -3.24538536e-02f, 2.86539465e-01f, -4.50232863e-01f, -1.67971164e-01f, -5.15407085e-01f, -2.44939044e-01f, 3.85067940e-01f, -1.87601149e-01f,
  1.01067163e-01f, -4.58258390e-01f, 1.52313998e-02f, 4.10291590e-02f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  1.54952243e-01f, 8.97543132e-02f, 1.32345222e-03f, -6.94625974e-02f, -8.08487013e-02f, 4.91534099e-02f, 1.16908282e-01f, 5.64233102e-02f, 4.57406156e-02f, 7.97614530e-02f,
  -1.14169009e-01f, -9.36272144e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 26
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 3, 26
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    