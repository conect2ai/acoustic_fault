/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.29339862e-01f, -4.24455792e-01f, 2.63282359e-01f, -1.11770257e-01f, 1.56159624e-01f, -2.93966979e-01f, -2.75222272e-01f, 7.04127476e-02f, -2.19221219e-01f, -3.02052617e-01f,
  2.55180616e-02f, -8.43340084e-02f, -9.11531299e-02f, -1.99311778e-01f, 2.88339019e-01f, -1.43077672e-01f, 1.60197001e-02f, -3.98246087e-02f, -6.43677264e-03f, 1.31359965e-01f,
  1.91331804e-01f, 6.04634210e-02f, 3.82793933e-01f, 1.43238222e-02f, 2.65778694e-02f, 3.17303836e-02f, 8.50763544e-02f, 9.19022188e-02f, -4.70317565e-02f, -4.34581423e-03f,
  -1.35192545e-02f, 1.87362358e-01f, 2.23689657e-02f, -1.81596968e-02f, 1.73282310e-01f, -1.73205137e-02f, -6.11150591e-03f, -3.14227655e-03f, 1.07071683e-01f, 3.11129596e-02f,
  -2.10592300e-01f, 7.00247139e-02f, -5.58091439e-02f, -9.11516920e-02f, -3.31760645e-02f, -4.33137715e-02f, 2.97121760e-02f, -9.90862474e-02f, -3.56534235e-02f, 3.48510146e-02f,
  -9.04604513e-03f, -1.24316895e-02f, -6.26074001e-02f, 1.39480215e-02f, 8.57298151e-02f, -5.42972162e-02f, -1.98209397e-02f, 1.11370206e-01f, -9.10144225e-02f, 4.31185737e-02f,
  -1.51465852e-02f, -8.42748880e-02f, 5.23505546e-03f, -4.00100574e-02f, -2.30979305e-02f, -2.22977735e-02f, -1.09733678e-01f, 6.96515143e-02f, 2.42222212e-02f, 3.15018906e-03f,
  5.45957871e-03f, -2.25881524e-02f, 4.02323790e-02f, -1.88416932e-02f, 2.76209638e-02f, 1.72222999e-03f, -4.92630787e-02f, 9.99260545e-02f, 4.32745218e-02f, 2.36515145e-04f,
  -1.02457516e-01f, -2.22583655e-02f, 3.81316245e-03f, 3.49520966e-02f, -6.28137663e-02f, 3.30692381e-02f, -2.90463343e-02f, -4.25176919e-02f, 5.61760403e-02f, -4.92379395e-03f,
  6.44751936e-02f, 1.97666109e-01f, 2.51627546e-02f, -2.78241448e-02f, -5.11764847e-02f, -3.80400121e-02f, -4.44916487e-02f, -5.95384687e-02f, -1.03528365e-01f, 6.65564090e-02f,
  1.66262656e-01f, 5.67278601e-02f, -2.23073494e-02f, -1.08215958e-02f, -4.18569334e-02f, 2.34428253e-02f, 1.01162391e-02f, -1.69117507e-02f, 2.49911603e-02f, 1.03504799e-01f,
  9.80082452e-02f, 1.38889149e-01f, -5.23628928e-02f, -9.20685660e-03f, 5.33215106e-02f, 3.48272501e-03f, -1.57859996e-02f, -1.20060649e-02f, -1.56481937e-03f, -1.09366169e-02f,
  3.96985650e-01f, 1.10381044e-01f, 2.68424392e-01f, 3.54549199e-01f, -8.58470127e-02f, -3.29558164e-01f, 2.50069499e-01f, -3.82320657e-02f, 3.23131830e-01f, -4.15931568e-02f,
  -4.48581502e-02f, 1.43790305e-01f, 1.92012757e-01f, -2.97060050e-02f, 8.58539194e-02f, 5.94723411e-02f, -3.61375685e-04f, 6.83096796e-03f, 1.56296134e-01f, 4.36801873e-02f,
  7.10154325e-02f, -1.78625658e-01f, 1.01234704e-01f, -1.83544159e-01f, -4.94621359e-02f, 1.16814002e-01f, -1.99475303e-01f, 4.49125208e-02f, -1.67025834e-01f, -4.67711799e-02f,
  1.72569528e-02f, 1.52717978e-01f, 9.05706584e-02f, 8.90518352e-03f, -3.21447328e-02f, -2.65404917e-02f, -2.30970215e-02f, -5.27183637e-02f, 7.51497746e-02f, 2.50773821e-02f,
  2.61329189e-02f, -2.68618623e-03f, 1.18990531e-02f, 1.71566866e-02f, 2.14680973e-02f, -8.74561537e-03f, 2.48908903e-02f, 2.06930079e-02f, 7.51149356e-02f, 4.36778292e-02f,
  8.22139755e-02f, 3.22229490e-02f, 2.79809479e-02f, 3.08061652e-02f, -2.63907425e-02f, 7.38380477e-02f, -6.46296050e-03f, -5.69258779e-02f, -3.37103307e-02f, 6.22103689e-04f,
  -2.37040091e-02f, -3.40586528e-02f, 2.25375816e-02f, 8.05941503e-03f, 6.48612604e-02f, -2.70896964e-02f, -1.76773500e-02f, -8.16424340e-02f, 6.93811700e-02f, -8.66258424e-03f,
  3.92258726e-02f, 5.01056910e-02f, -1.37043162e-03f, 4.31554317e-02f, 1.34445494e-02f, 1.00495234e-01f, 3.68038798e-03f, 3.55461501e-02f, 9.13527142e-03f, 2.76982151e-02f,
  3.98847535e-02f, 1.79069350e-03f, 5.12883477e-02f, -5.99160008e-02f, -2.18937974e-02f, 6.54316097e-02f, -6.03823178e-02f, 2.08546631e-02f, 1.84800625e-02f, -7.81694278e-02f,
  -1.28367111e-01f, -1.94438398e-01f, 6.85374886e-02f, 1.11430779e-03f, 4.31777388e-02f, -1.80040542e-02f, 9.74027961e-02f, -5.80276875e-03f, -6.67549297e-02f, 2.89316587e-02f,
  -4.53609526e-02f, 5.52683547e-02f, -1.25003204e-01f, -1.61251985e-02f, 7.91815482e-03f, -6.96118772e-02f, 2.89335027e-02f, 7.26480177e-03f, -9.12381262e-02f, -9.66878384e-02f,
  -9.57009643e-02f, -1.89200174e-02f, 7.62142614e-02f, -2.25918349e-02f, -8.07477608e-02f, -5.96339032e-02f, 1.55917439e-03f, 3.31206396e-02f, -1.32461205e-01f, 1.04045561e-02f,
  3.61814886e-01f, 3.63535956e-02f, 5.29052764e-02f, -8.30591694e-02f, -5.47468513e-02f, -1.06265619e-01f, -1.63433209e-01f, -7.80819803e-02f, 1.10006444e-01f, -1.89457640e-01f,
  -2.42548347e-01f, 1.08072355e-01f, -2.89852303e-02f, -2.08325386e-01f, -1.98871031e-01f, -1.78946555e-01f, -6.45011961e-02f, 1.24947749e-01f, 1.13432892e-01f, 1.45789519e-01f,
  5.02985455e-02f, -1.21982925e-01f, -2.47056246e-01f, 5.53710610e-02f, -3.13989893e-02f, 3.81051749e-02f, -2.26282388e-01f, 4.59981672e-02f, -1.71526685e-01f, -3.54614407e-02f,
  4.25194576e-02f, 2.30374545e-01f, -1.91231947e-02f, 2.34590806e-02f, -6.85219243e-02f, 6.47516251e-02f, -2.53480580e-02f, 3.55535038e-02f, 3.97535190e-02f, -2.18861066e-02f,
  5.15510887e-02f, 7.86195025e-02f, 6.96510673e-02f, 1.54997995e-02f, 4.68929857e-02f, 2.17192657e-02f, -6.18180372e-02f, -1.10782951e-01f, -2.69778892e-02f, -2.39838529e-02f,
  -4.72103395e-02f, -1.02031127e-01f, -6.63905442e-02f, 3.13513577e-02f, -3.45132016e-02f, -3.77594754e-02f, -4.52000611e-02f, -9.74385161e-03f, -3.69497314e-02f, -4.17370349e-02f,
  -5.24896421e-02f, 7.24342614e-02f, 1.71625037e-02f, -1.79370213e-02f, 5.36195524e-02f, -1.51182543e-02f, -1.31377978e-02f, -5.55713214e-02f, 3.18891890e-02f, -9.63017941e-02f,
  -3.69120426e-02f, 1.36468112e-02f, -3.54488343e-02f, -4.31599580e-02f, 5.78538030e-02f, -4.36127149e-02f, 3.29434760e-02f, 1.62487049e-02f, 1.24439970e-01f, -9.12047401e-02f,
  -1.48152804e-03f, 1.93420723e-02f, 2.21825354e-02f, -4.22000587e-02f, -5.65823764e-02f, -5.69161167e-03f, -4.66834716e-02f, -4.93598133e-02f, -9.84025821e-02f, -2.16894951e-02f,
  1.54616714e-01f, 2.42743567e-02f, -3.04615963e-02f, -4.86939177e-02f, 3.36157382e-02f, -4.31994870e-02f, 2.69893408e-02f, 3.61674652e-02f, 7.71018816e-03f, 9.69851017e-02f,
  -1.84830632e-02f, 1.73371043e-02f, -4.33318084e-03f, -3.50456014e-02f, -2.10345648e-02f, -4.93078027e-04f, -5.58671989e-02f, 1.73612982e-02f, -9.64067280e-02f, -2.03363653e-02f,
  -8.41837972e-02f, 4.46315669e-02f, 8.12028348e-02f, 3.19643041e-05f, 3.63203436e-02f, -5.41417748e-02f, 3.40898111e-02f, 3.78474928e-02f, 4.11251523e-02f, -4.01769653e-02f,
  -3.63362402e-01f, -4.96307164e-02f, -1.26827732e-01f, -2.64078937e-03f, 6.54239506e-02f, -3.84996593e-01f, -1.70483500e-01f, 3.62071507e-02f, -2.33119905e-01f, 1.39002681e-01f,
  9.31114480e-02f, -1.71053872e-01f, 2.72009909e-01f, -1.53677896e-01f, -6.44394457e-02f, 8.58100653e-02f, -2.78143346e-01f, -5.08087128e-02f, -2.94585675e-02f, -9.06645879e-02f,
  -8.55722576e-02f, 9.89057422e-02f, -6.56023771e-02f, 1.07282735e-02f, -9.58825797e-02f, -5.16726226e-02f, 3.26868206e-01f, 1.39491335e-01f, 5.85886575e-02f, -3.91203910e-02f,
  -1.49218559e-01f, -7.89343864e-02f, 3.49722356e-02f, -4.80353199e-02f, -3.44147421e-02f, -1.40265953e-02f, -3.52580883e-02f, 5.36959395e-02f, -3.95773575e-02f, -5.40161058e-02f,
  -1.55969542e-02f, -2.30802894e-02f, 2.20086053e-02f, 7.85864070e-02f, -1.16995469e-01f, -8.94106552e-02f, -4.31370251e-02f, -5.37963063e-02f, 6.55148085e-03f, -8.78432095e-02f,
  -4.06096205e-02f, 2.22164039e-02f, -6.69552311e-02f, 2.22325865e-02f, 4.29449528e-02f, -1.53378069e-01f, 1.54061662e-02f, -4.91287895e-02f, -1.12674451e-02f, -2.99552083e-02f,
  -2.64649596e-02f, -1.56205632e-02f, 5.38186282e-02f, 3.35352272e-02f, 3.19453403e-02f, 1.01319999e-01f, 9.06992424e-03f, 5.87805212e-02f, 4.32182923e-02f, 6.92203222e-03f,
  -1.51910726e-02f, 4.98699164e-03f, 3.64137888e-02f, -4.08633053e-02f, 4.33229114e-04f, -5.18477038e-02f, 2.14724991e-04f, 8.39655846e-02f, -6.83269426e-02f, 1.06118836e-01f,
  -3.83316241e-02f, -6.57908171e-02f, -4.67924261e-03f, -4.97475974e-02f, -3.11868358e-02f, -1.13256862e-02f, 5.83744124e-02f, -3.29425633e-02f, -3.81790549e-02f, -8.76936782e-03f,
  -1.46873027e-01f, 2.02808708e-01f, 1.67371109e-02f, 1.74870268e-02f, 2.44354717e-02f, 9.71166492e-02f, 2.17929892e-02f, -3.85993160e-02f, -5.77163845e-02f, 5.20872734e-02f,
  2.60425098e-02f, 3.47253843e-03f, -1.69603378e-02f, -1.63440667e-02f, -7.13114347e-03f, 5.50120436e-02f, 1.64223481e-02f, -4.69019860e-02f, -3.37718278e-02f, 8.93516839e-02f,
  7.72984624e-02f, 2.85674408e-02f, -3.77718881e-02f, -5.18931821e-03f, 3.78181972e-02f, 5.34265377e-02f, -1.76316854e-02f, 4.06626426e-02f, 1.00222602e-01f, 2.10551228e-02f,
  2.26675659e-01f, -2.67751366e-01f, -9.26945210e-02f, -3.48484628e-02f, 1.42984614e-01f, 1.52406886e-01f, 2.34612316e-01f, -9.71672535e-02f, -7.22476691e-02f, -9.82212573e-02f,
  1.61962584e-01f, -2.21807852e-01f, 3.61938328e-02f, 4.14933302e-02f, 2.62417108e-01f, -1.54159963e-01f, 8.72467235e-02f, 3.28672417e-02f, -1.26777679e-01f, -6.00619465e-02f,
  -7.24245533e-02f, 1.00890249e-01f, 3.06729805e-02f, -8.23931396e-02f, 8.79286155e-02f, -2.14812562e-01f, 9.38785542e-03f, 2.58359835e-02f, -2.47256830e-03f, 7.90603235e-02f,
  -2.02265326e-02f, -9.80322212e-02f, 1.57048786e-03f, 1.49522731e-02f, 4.50467244e-02f, -3.01492889e-03f, 1.10369399e-01f, 8.18948373e-02f, 1.28530222e-03f, -5.62285110e-02f,
  2.15260368e-02f, -4.34676837e-03f, 5.40613458e-02f, 2.67295968e-02f, 2.36668680e-02f, -3.57189053e-03f, -3.54269035e-02f, 4.46233749e-02f, -1.33350883e-02f, 3.34615298e-02f,
  3.28673162e-02f, 1.99084077e-03f, 1.98009405e-02f, -3.72037217e-02f, 3.67201604e-02f, -1.20204613e-02f, -4.20688502e-02f, -5.38986130e-03f, 7.44052976e-02f, -2.37512849e-02f,
  1.66570139e-03f, -9.22734141e-02f, -1.76610481e-02f, 7.02476734e-03f, -3.67684243e-03f, 4.17629555e-02f, -4.08632085e-02f, 5.38613945e-02f, -5.37914820e-02f, -2.44559888e-02f,
  2.27789711e-02f, 7.07876384e-02f, -6.58365618e-03f, 3.14254090e-02f, -2.10510455e-02f, 1.95400640e-02f, 2.22185738e-02f, -7.11366832e-02f, -1.76333319e-02f, 7.82133713e-02f,
  2.75825653e-02f, -8.59049428e-03f, -5.55648915e-02f, -6.10323297e-03f, 6.32428452e-02f, 6.51309965e-03f, -1.00954413e-01f, 1.15116136e-02f, -1.61862653e-02f, 1.32486418e-01f,
  -1.16748050e-01f, -2.99007565e-01f, -7.22764283e-02f, 3.38384090e-03f, 4.93094139e-02f, 8.25058818e-02f, 2.03461908e-02f, 1.22934999e-02f, -9.01373569e-03f, 7.09123611e-02f,
  1.97095722e-02f, 3.86552629e-03f, -2.91861854e-02f, 5.26745766e-02f, -2.68307608e-02f, -3.78652103e-02f, -3.77695821e-02f, 5.31456023e-02f, 3.25069353e-02f, -4.86776121e-02f,
  7.58161545e-02f, -3.12218256e-02f, 4.23258776e-03f, 3.77653949e-02f, 5.50170057e-02f, 6.12934195e-02f, -3.05348560e-02f, -6.26625046e-02f, 7.58090764e-02f, 1.23893162e-02f,
  2.65568972e-01f, -3.22610766e-01f, -2.15796307e-01f, -1.14470318e-01f, 3.35069954e-01f, 7.97827169e-02f, -1.86089143e-01f, -2.85379179e-02f, 2.93731708e-02f, -2.69426763e-01f,
  -1.04333028e-01f, -5.82386516e-02f, -1.96987763e-01f, -1.43006444e-01f, 4.06522721e-01f, -2.12291703e-01f, -1.14335433e-01f, -1.18284315e-01f, 1.45489592e-02f, 6.87028766e-02f,
  2.00563408e-02f, 6.80166390e-03f, -1.88378379e-01f, -9.35989711e-03f, -3.10024116e-02f, -3.54504660e-02f, -3.69927064e-02f, -2.87227109e-02f, 7.54356384e-02f, 9.14011151e-02f,
  -1.66272335e-02f, -7.16296509e-02f, 2.31417157e-02f, -2.70875338e-02f, -2.94799861e-02f, 4.58038086e-03f, 4.23216484e-02f, 3.87285389e-02f, 3.88192572e-02f, -3.73604409e-02f,
  -4.20328155e-02f, 7.23838434e-02f, -4.29814495e-02f, 8.50252062e-03f, 2.00824924e-02f, 2.88322587e-02f, 4.29290682e-02f, 2.38714013e-02f, 3.40775237e-03f, 3.43820378e-02f,
  -3.04153897e-02f, 2.96694748e-02f, 2.41236277e-02f, -1.18176676e-01f, 3.81401018e-03f, 2.99814213e-02f, -6.06070906e-02f, 1.79494079e-02f, -3.10159735e-02f, 7.27873892e-02f,
  -2.47823540e-02f, 3.17217000e-02f, 1.32686123e-02f, -1.52799701e-02f, 2.42363960e-02f, 5.25330566e-02f, -6.49799705e-02f, -3.11753619e-02f, -4.06604744e-02f, 1.80281829e-02f,
  1.06448129e-01f, 4.55136560e-02f, -7.40000466e-03f, -3.57018523e-02f, 3.05036679e-02f, 4.53734882e-02f, 2.76802331e-02f, -4.18317541e-02f, 5.56694493e-02f, 1.34345498e-02f,
  -2.61243917e-02f, 1.86299812e-02f, 4.00753990e-02f, -7.12481067e-02f, -9.10554826e-03f, 3.55926864e-02f, -1.57683976e-02f, 1.03845214e-02f, -5.27630374e-02f, 5.37917838e-02f,
  -1.00202709e-01f, -1.03192396e-01f, -9.64301303e-02f, 1.13958102e-02f, -9.93505269e-02f, 2.91091070e-04f, -4.29289155e-02f, 4.26930822e-02f, -6.85828924e-03f, 3.31616178e-02f,
  2.29262672e-02f, 5.66367293e-03f, 3.90281267e-02f, 4.00642045e-02f, 2.03620009e-02f, 4.40430753e-02f, -6.02128468e-02f, 3.59022915e-02f, 2.82887463e-02f, 2.31766738e-02f,
  3.21927331e-02f, 2.46538967e-02f, 4.92397987e-04f, 5.48657998e-02f, -1.87238343e-02f, 3.54329795e-02f, 5.32017834e-02f, 1.32853761e-02f, -3.49866077e-02f, -5.00617623e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.58444929e-01f, -4.24565822e-01f, -2.81853497e-01f, -5.32234274e-03f, 2.70460576e-01f, 2.34960943e-01f, 1.07598424e-01f, -6.82214573e-02f, -1.90618277e-01f, -2.55822062e-01f,
  2.29221702e-01f, -1.02891542e-01f, -2.33479425e-01f, 2.77884275e-01f, 3.70550841e-01f, -2.50667661e-01f, 2.52168566e-01f, 1.48717284e-01f, -1.32216021e-01f, -3.85989225e-03f,
  9.13521051e-02f, 4.03764665e-01f, -4.22871411e-02f, 5.08651789e-03f, 1.70360997e-01f, -1.45395353e-01f, 1.53753087e-01f, -6.22781254e-02f, 2.51861900e-01f, 1.45233288e-01f,
  7.53379613e-02f, -5.51106781e-02f, -1.51274130e-02f, -4.71754298e-02f, -4.08741087e-02f, -9.11806431e-03f, -5.69813140e-02f, 1.34993136e-01f, 1.82441160e-01f, 2.00949330e-02f,
  -1.69284046e-02f, 5.32185882e-02f, -4.43783924e-02f, -3.19821648e-02f, 6.01876788e-02f, 6.73624873e-02f, 4.00819220e-02f, -1.07183956e-01f, -1.88405477e-02f, -6.00010902e-03f,
  -9.74167883e-02f, -5.11947088e-02f, -2.50654686e-02f, -4.66590486e-02f, -5.16879074e-02f, -3.69096771e-02f, -1.35007292e-01f, -9.96603742e-02f, -2.18523014e-02f, -6.76764399e-02f,
  -3.10648214e-02f, -4.54121456e-02f, -4.89388481e-02f, -1.97979808e-02f, 2.50881612e-02f, 4.43333276e-02f, 8.27758312e-02f, 8.02245438e-02f, -1.00712225e-01f, 3.13369744e-02f,
  3.70291695e-02f, 7.81310573e-02f, -2.76423488e-02f, 1.26723498e-01f, -1.14767076e-02f, -3.29199224e-03f, 1.92649011e-02f, -3.16456594e-02f, -2.04575527e-02f, -8.63967091e-03f,
  1.88369788e-02f, 1.22126803e-01f, 4.10567895e-02f, -4.46528103e-03f, -2.17897855e-02f, 2.04471778e-02f, -2.16108956e-03f, -2.24819425e-02f, -5.76311238e-02f, 7.72373602e-02f,
  -4.42646556e-02f, -3.81247550e-01f, -1.42420635e-01f, 9.36426967e-02f, -3.77950445e-02f, -4.80019487e-02f, -6.59165978e-02f, -3.16178799e-02f, -1.40128667e-02f, 1.68518201e-02f,
  5.11960546e-03f, 5.23402654e-02f, -9.51581225e-02f, 1.10349834e-01f, 9.21326354e-02f, -7.29131103e-02f, -5.07755652e-02f, 1.39564807e-02f, -4.42700163e-02f, 2.58837156e-02f,
  1.42853893e-03f, 8.28890353e-02f, -8.13580304e-02f, -3.22588086e-02f, -9.00419429e-03f, -2.54153199e-02f, -4.82455567e-02f, -1.96305700e-02f, 3.30795278e-03f, -1.06178522e-01f,
  1.83700562e-01f, 5.23053110e-01f, 1.89366654e-01f, 5.56745231e-02f, -8.04123953e-02f, 2.33241156e-01f, -6.82192110e-03f, -6.11848645e-02f, -1.62253007e-02f, 3.34677637e-01f,
  -2.81187534e-01f, 4.69091564e-01f, -3.56653512e-01f, -1.51570603e-01f, -5.04109502e-01f, -2.84288347e-01f, 2.37296168e-02f, 2.54908919e-01f, -2.03150034e-01f, 1.97755828e-01f,
  -1.13011658e-01f, -3.67679328e-01f, -2.88043201e-01f, -1.68176159e-01f, 2.64332712e-01f, 2.12456495e-01f, -3.43865663e-01f, -2.20338449e-01f, 2.89061069e-01f, -1.92630246e-01f,
  -1.19772442e-02f, -1.02249905e-01f, 4.86564375e-02f, 1.17868796e-01f, 6.89352751e-02f, 7.39339590e-02f, 6.39971718e-02f, -2.92729940e-02f, -5.59700355e-02f, -3.07071116e-03f,
  1.14304058e-01f, 7.86204338e-02f, 7.50422552e-02f, -1.39645040e-01f, 7.70745650e-02f, 1.00678533e-01f, 6.53948113e-02f, 1.70318410e-01f, 1.72036827e-01f, 8.79113525e-02f,
  1.38967112e-02f, 1.88445851e-01f, 1.23810299e-01f, 2.56605092e-02f, 1.72565393e-02f, 1.52394194e-02f, -4.25182562e-03f, 1.19026177e-01f, 1.14038594e-01f, 9.66364071e-02f,
  2.04456449e-02f, -3.38479355e-02f, -1.90020557e-02f, -9.43348110e-02f, -3.28139681e-03f, -4.27723452e-02f, -1.33153955e-02f, -6.89568277e-03f, 7.67542943e-02f, 6.56922907e-02f,
  -5.49418479e-03f, 9.22557339e-03f, 1.94430873e-02f, 7.61560500e-02f, -3.85203250e-02f, 1.02673315e-01f, 1.09439120e-02f, -6.64373413e-02f, 9.69496965e-02f, -2.11326294e-02f,
  -8.52961764e-02f, 2.13730000e-02f, -6.64492846e-02f, 2.81030107e-02f, -5.33415601e-02f, -6.51399493e-02f, -3.00189648e-02f, 3.20391543e-02f, -9.00397599e-02f, 2.03887327e-03f,
  1.00448169e-01f, 4.93204296e-02f, 8.70001316e-02f, -4.70670909e-02f, 3.86701711e-03f, 1.12180397e-01f, -9.13820565e-02f, 1.19853020e-01f, -6.07078820e-02f, 1.73942111e-02f,
  1.41575515e-01f, -5.55892661e-03f, 1.37151331e-01f, 3.14871110e-02f, -4.43555489e-02f, 1.03005029e-01f, 1.10233035e-02f, -2.79021021e-02f, 1.81199815e-02f, 6.69456413e-03f,
  3.57273445e-02f, -8.24930817e-02f, 8.66732076e-02f, 6.37607202e-02f, 1.17743492e-01f, 9.09065977e-02f, 9.61082652e-02f, 1.32422457e-02f, 1.02252448e-02f, 5.63898347e-02f,
  -8.54693353e-03f, -4.09884423e-01f, -2.25755244e-01f, -1.61877319e-01f, 3.92650962e-01f, 5.83150685e-01f, 3.76359791e-01f, -2.50326574e-01f, -5.13975203e-01f, -5.57341762e-02f,
  2.07639277e-01f, -7.67499357e-02f, -4.55076396e-02f, -2.64423549e-01f, 1.68261632e-01f, -2.39240691e-01f, -1.14567935e-01f, 4.35987078e-02f, -2.85453796e-01f, 1.17179699e-01f,
  -4.80698086e-02f, -6.54343376e-03f, -8.26484412e-02f, -8.08244199e-03f, 2.60592639e-01f, 1.58356316e-02f, 2.64929682e-01f, 3.24999839e-01f, 1.66601151e-01f, 7.76497647e-02f,
  -4.47727926e-02f, -2.42212623e-01f, 8.17853492e-03f, -9.06930864e-02f, 1.92012548e-01f, 1.40075028e-01f, 1.15378201e-01f, 6.64854795e-02f, 8.52643047e-03f, -4.10174616e-02f,
  4.94040698e-02f, -9.41566657e-03f, -7.47653469e-02f, -3.22465338e-02f, -1.26740977e-01f, -5.30299135e-02f, -7.33142123e-02f, -6.73377588e-02f, -1.40131161e-01f, -2.42013335e-02f,
  -1.31351784e-01f, -1.51799181e-02f, -8.21979120e-02f, -1.23430058e-01f, 3.53728309e-02f, -1.03207856e-01f, 3.00263688e-02f, 3.00674707e-01f, -5.44917695e-02f, 3.55217829e-02f,
  4.19416055e-02f, 1.20292298e-01f, 1.13632426e-01f, -1.08509012e-01f, 5.12098484e-02f, -6.86012208e-02f, -2.75748875e-02f, -3.45903914e-03f, 3.01558804e-02f, -2.27880999e-02f,
  -4.96098027e-02f, 1.44945476e-02f, -1.30760670e-01f, -3.58050205e-02f, 1.93641372e-02f, -8.13967437e-02f, 1.09175965e-01f, 2.34318282e-02f, -2.45548300e-02f, -5.86992130e-02f,
  -1.88525006e-01f, -6.58382550e-02f, 1.76240295e-01f, -5.54968789e-02f, -1.13496237e-01f, 1.18505351e-01f, -8.04855973e-02f, -3.76496324e-03f, -5.46605000e-03f, 6.39840169e-03f,
  1.13929376e-01f, 1.14424951e-01f, -1.45658031e-01f, -1.04172498e-01f, -5.30817546e-02f, 7.79398829e-02f, -9.22975242e-02f, -3.38831805e-02f, 8.13870803e-02f, 4.01828811e-02f,
  1.56124055e-01f, -5.23624942e-02f, 5.66225238e-02f, -6.98715821e-02f, -9.22747403e-02f, 1.11654095e-01f, 8.85826275e-02f, 2.29957122e-02f, 3.45820636e-02f, 4.12097909e-02f,
  8.36314708e-02f, 5.12803420e-02f, -4.64656390e-02f, 1.88316777e-02f, 2.12956388e-02f, 1.25739500e-01f, 1.19321451e-01f, 6.71196133e-02f, -1.45080939e-01f, -5.37112504e-02f,
  7.22036004e-01f, -4.68757987e-01f, 3.30541879e-01f, 5.53841531e-01f, 2.90243030e-01f, 1.64343297e-01f, 4.58170861e-01f, 2.13945634e-03f, 4.35601234e-01f, -4.32359129e-01f,
  -8.04565921e-02f, -1.59046963e-01f, -2.20398635e-01f, -1.40345976e-01f, 2.07917288e-01f, -2.36072615e-01f, -7.80709982e-02f, -1.26139298e-01f, 2.06521466e-01f, 2.51648258e-02f,
  2.08435327e-01f, -3.85070950e-01f, -6.73643500e-02f, -3.20807457e-01f, 1.52712777e-01f, -3.57054360e-02f, -3.05192709e-01f, -1.87348381e-01f, -2.78951108e-01f, -1.25012457e-01f,
  -8.55431557e-02f, 4.62815575e-02f, 1.30816281e-01f, -1.34301752e-01f, 6.35762438e-02f, 4.55372073e-02f, -4.84375544e-02f, -4.15039398e-02f, 1.38207957e-01f, 3.89622785e-02f,
  -7.16806650e-02f, -2.24169642e-02f, 3.31396647e-02f, -1.88441575e-02f, 1.26721382e-01f, 5.07566221e-02f, 7.11125135e-02f, 1.31821275e-01f, 4.07830328e-02f, 7.06737861e-02f,
  1.63024932e-01f, 1.05642609e-01f, 1.52530089e-01f, -1.21343084e-01f, 1.05683312e-01f, 1.12504132e-01f, 1.22782297e-01f, -3.84498411e-03f, -3.81016615e-03f, 2.06661522e-01f,
  -7.65227452e-02f, -4.27121893e-02f, -1.93142407e-02f, 3.70756648e-02f, 2.94551486e-03f, 9.09595937e-02f, 5.65935113e-03f, -9.08444002e-02f, 2.57586557e-02f, -2.51210313e-02f,
  8.33793581e-02f, -2.40730457e-02f, 1.08603187e-01f, 4.75066807e-03f, 9.96349528e-02f, 1.40159696e-01f, 6.82945177e-02f, -1.79788955e-02f, 4.06708904e-02f, 7.90888965e-02f,
  -8.37009773e-02f, -2.27822550e-02f, -1.30264029e-01f, 5.05810641e-02f, -3.43556330e-02f, -1.23840727e-01f, -6.04319051e-02f, 5.91642596e-02f, 7.52403140e-02f, -7.84206614e-02f,
  -5.18552780e-01f, -7.07806528e-01f, -2.49557750e-04f, -1.35161698e-01f, -1.68905303e-01f, -7.61230290e-02f, -1.00388005e-01f, -1.65536981e-02f, -2.15444043e-01f, -6.30126968e-02f,
  -5.50918805e-04f, -5.55920647e-03f, -8.14385712e-02f, -3.54952291e-02f, -9.20675248e-02f, -5.83381690e-02f, -3.08531821e-02f, -1.12414159e-01f, -7.77867734e-02f, -1.48133844e-01f,
  -3.61770205e-02f, -7.94672966e-02f, -3.77200395e-02f, 8.94483179e-02f, -8.82463995e-04f, -4.67589684e-02f, -5.55274189e-02f, 2.69420296e-02f, -9.13046822e-02f, -1.79321934e-02f,
  2.25269958e-01f, -5.39965108e-02f, 3.14627230e-01f, 1.36978760e-01f, -1.97127894e-01f, -1.23745531e-01f, 3.47083777e-01f, -3.58510435e-01f, -5.82560539e-01f, -1.70984998e-01f,
  1.05439678e-01f, 1.29542544e-01f, 2.93754280e-01f, 8.78792405e-02f, 3.54472846e-01f, 1.67939924e-02f, -2.57726610e-02f, 3.58805656e-02f, -1.72994789e-02f, 1.84670627e-01f,
  1.13740884e-01f, 5.16551137e-02f, 4.80956733e-01f, -2.93103717e-02f, 1.74880669e-01f, 1.51909381e-01f, 2.58808076e-01f, 2.40124524e-01f, 9.02659521e-02f, 2.08128974e-01f,
  -4.16792072e-02f, -1.54942805e-02f, 3.53187136e-02f, 2.23738588e-02f, 6.47526642e-04f, 8.00113231e-02f, 2.36066401e-01f, 2.31491834e-01f, -6.59575537e-02f, 3.60310636e-02f,
  -1.70328114e-02f, -7.07761273e-02f, -9.77796689e-02f, 1.00306217e-02f, -1.70873880e-01f, -1.71770498e-01f, -2.51416385e-01f, -5.14167510e-02f, 6.34399150e-03f, 1.08090416e-01f,
  -2.12283079e-02f, 5.18404394e-02f, -8.57302472e-02f, -4.61191833e-02f, -1.36475042e-01f, -3.19184363e-02f, 1.28838085e-02f, -1.88180730e-02f, -9.23521593e-02f, -7.56477490e-02f,
  -1.21458180e-01f, 2.78409030e-02f, 3.30814645e-02f, 2.44456213e-02f, 6.44308329e-02f, 1.42507460e-02f, -3.92192714e-02f, -1.38709946e-02f, 9.14572477e-02f, -1.94735322e-02f,
  -1.26116082e-01f, -5.86286783e-02f, -2.81266086e-02f, -1.40568718e-01f, -2.22254079e-02f, -1.44057609e-02f, 1.64549649e-01f, -3.38197686e-02f, -1.55054659e-01f, -1.28526166e-02f,
  3.79968733e-02f, 1.53068341e-02f, -4.63720933e-02f, 4.69635166e-02f, 3.33799720e-02f, -4.60564941e-02f, 3.82535495e-02f, 2.33338233e-02f, 4.27610204e-02f, 1.00138299e-01f,
  -1.15119657e-02f, 9.73847210e-02f, 5.98624535e-02f, -1.82933062e-02f, 4.21816707e-02f, 4.69199345e-02f, 5.45550361e-02f, -2.65709050e-02f, -5.94225042e-02f, -9.84981470e-03f,
  -7.32126534e-02f, 9.32398289e-02f, -6.14709817e-02f, 3.02797630e-02f, -2.38724258e-02f, -8.00771117e-02f, 2.94730347e-02f, 1.36210267e-02f, -3.67349610e-02f, 5.32484893e-03f,
  2.53108349e-02f, -6.42874464e-02f, 1.82476752e-02f, -1.81944564e-01f, -1.43670186e-01f, 5.72760366e-02f, 2.35131290e-02f, -6.84402734e-02f, 5.33402823e-02f, -6.93273498e-03f,
  2.00696945e-01f, 8.09008926e-02f, -3.03387433e-01f, 1.63465366e-01f, -2.21635088e-01f, -1.38921365e-01f, -1.50266662e-01f, 7.75193051e-02f, -3.41921568e-01f, 3.24686795e-01f,
  2.42007837e-01f, -3.41350675e-01f, 1.31966382e-01f, 4.23472643e-01f, -9.50353686e-03f, -6.18363954e-02f, 3.56143385e-01f, 1.23405084e-01f, -1.26383379e-01f, 2.70338416e-01f,
  1.82965323e-01f, 3.91881496e-01f, 2.92298168e-01f, 2.55837739e-01f, 1.98688686e-01f, 1.15779176e-01f, 3.24925959e-01f, -1.82981357e-01f, 2.58068740e-01f, -1.27319098e-01f,
  7.22293481e-02f, 1.02232866e-01f, 5.78345023e-02f, -1.01204276e-01f, 2.02671945e-01f, 1.13122009e-01f, 2.66904533e-02f, -6.77224845e-02f, -2.58356761e-02f, -1.35528505e-01f,
  -6.84747845e-02f, 7.75923356e-02f, 9.54863429e-02f, -1.83574595e-02f, 1.74915772e-02f, -5.38693964e-02f, -7.05382898e-02f, 3.07121605e-04f, -9.36909541e-02f, 9.79641303e-02f,
  -2.69493684e-02f, 1.15394774e-04f, 1.76116508e-02f, -4.20775004e-02f, -5.23919612e-02f, 4.91322502e-02f, -7.04948455e-02f, 1.72874574e-02f, -7.35253990e-02f, 6.18438758e-02f,
  9.72719789e-02f, -1.44075323e-02f, 1.28261775e-01f, -5.31402193e-02f, -1.51580404e-02f, 1.06988899e-01f, -6.40322119e-02f, 2.90710740e-02f, -6.61923364e-02f, 4.13941592e-02f,
  5.16038537e-02f, 2.14647199e-03f, 1.77697893e-02f, 4.13628817e-02f, 1.27911836e-01f, -7.68604577e-02f, -4.77080457e-02f, -3.85252945e-02f, 3.95339169e-02f, -4.27539460e-02f,
  -1.40952051e-01f, -2.01555248e-03f, 6.73765838e-02f, 5.97873218e-02f, 5.31664770e-03f, -1.15586994e-02f, 2.16008052e-02f, -1.16792861e-02f, -6.75988942e-02f, -8.40856731e-02f,
  -2.80629899e-02f, 2.32400030e-01f, -2.46774200e-02f, -1.30492479e-01f, 7.20499828e-03f, 1.13132829e-02f, -3.63949835e-02f, -2.07964587e-03f, 2.97326054e-02f, 1.40862139e-02f,
  1.32263601e-01f, -4.17143442e-02f, -2.79318206e-02f, 4.20555519e-03f, -1.01471364e-01f, 1.04927614e-01f, -7.75053445e-03f, -6.90673590e-02f, -6.55809715e-02f, 1.04528248e-01f,
  -3.85883301e-02f, 5.08086272e-02f, -4.34065163e-02f, -2.08853364e-01f, 1.26376934e-02f, 1.00211069e-01f, -3.48494239e-02f, 3.86458151e-02f, 3.75349186e-02f, -8.09043124e-02f,
  -9.61884320e-01f, 4.54532862e-01f, 1.45628721e-01f, -5.57615638e-01f, 2.06315994e-01f, 7.88867846e-02f, -8.84304717e-02f, 2.43036583e-01f, -2.22708970e-01f, 2.93942481e-01f,
  1.69051453e-01f, -2.88057834e-01f, 4.13200557e-01f, 2.08071843e-01f, -4.19759512e-01f, 2.61045247e-01f, -1.75474197e-01f, -8.69190022e-02f, 7.39403889e-02f, -1.08116813e-01f,
  -1.64609939e-01f, 8.33799317e-02f, 4.53004688e-02f, 4.75068480e-01f, -4.28929441e-02f, -1.85876802e-01f, -1.89703494e-01f, 2.35536695e-01f, -4.48938087e-02f, 4.41251397e-02f,
  -4.67913777e-01f, -9.04874504e-02f, -1.31500661e-01f, 2.05577258e-02f, -1.91983864e-01f, -7.92117044e-02f, -1.42097697e-01f, 5.63686751e-02f, 1.27691990e-02f, 3.68368775e-02f,
  -4.31278870e-02f, -5.63709764e-03f, -1.12491678e-02f, 7.95112625e-02f, -6.05083741e-02f, 2.19590031e-02f, 7.99978301e-02f, 2.51392666e-02f, 4.08987887e-02f, 1.03894576e-01f,
  1.08195893e-01f, 1.13100903e-02f, -4.58422080e-02f, -4.07912955e-02f, -3.44165750e-02f, -2.42838357e-02f, -2.39702943e-03f, -9.75863263e-03f, -1.66137263e-01f, -9.88964885e-02f,
  1.03182293e-01f, 2.81873289e-02f, 7.06089512e-02f, 1.35499844e-03f, 8.14913064e-02f, 2.19739936e-02f, -5.53340428e-02f, -3.46471705e-02f, -4.25815508e-02f, 1.92650985e-02f,
  -9.81447175e-02f, 8.07142071e-03f, 8.09889566e-03f, -6.07723705e-02f, -4.27552545e-03f, -4.96961139e-02f, 3.75604965e-02f, -6.93143830e-02f, 2.42694430e-02f, 1.68151094e-03f,
  -5.58376685e-02f, -2.94567887e-02f, 4.69105178e-03f, -5.66720217e-02f, 1.51170241e-02f, -3.80076282e-02f, 9.32130665e-02f, 5.67148626e-02f, -1.86653882e-02f, -3.22266817e-02f,
  -6.85133815e-01f, -4.97105658e-01f, -1.64165944e-01f, -2.05213442e-01f, -1.32377371e-01f, 3.58479540e-03f, 1.10219037e-02f, -5.32397591e-02f, -1.54210135e-01f, 4.73739095e-02f,
  1.72224771e-02f, 2.83624697e-02f, -1.39008999e-01f, -4.39097062e-02f, -7.51290470e-02f, -1.68611319e-03f, -1.16840325e-01f, -7.72308484e-02f, -2.15882838e-01f, -3.01057398e-02f,
  -9.55339596e-02f, 7.29827136e-02f, -1.05100945e-02f, -7.88046978e-03f, -3.18333954e-02f, -9.63767096e-02f, -8.53374377e-02f, 2.73137204e-02f, -4.25957069e-02f, 2.07658987e-02f,
  -2.86404672e-03f, -2.46216252e-01f, -3.55076939e-01f, 1.21284410e-01f, 2.31411949e-01f, 4.44407500e-02f, -2.54070908e-01f, 3.86134863e-01f, -3.46840411e-01f, -1.12048678e-01f,
  -1.27376437e-01f, -5.25746047e-01f, -2.35126808e-01f, -1.08967856e-01f, 9.25354287e-03f, -2.49395758e-01f, 1.64260283e-01f, -5.29441684e-02f, 1.19626433e-01f, 6.91178441e-02f,
  2.99597323e-01f, 5.09632349e-01f, 1.66946113e-01f, 5.93850553e-01f, 2.45901823e-01f, 4.59162444e-01f, 4.13222224e-01f, -1.87468082e-02f, 3.61529529e-01f, -1.38307316e-02f,
  -8.71863067e-02f, -8.71969014e-02f, -5.60990011e-04f, -1.00337557e-01f, 1.22212887e-01f, 3.76157723e-02f, -5.04681244e-02f, -7.51558691e-02f, 2.19279900e-02f, -1.08481392e-01f,
  -1.08420432e-01f, 8.98557305e-02f, 1.30853161e-01f, 7.97570124e-02f, 1.30155355e-01f, 1.30712941e-01f, 6.39090091e-02f, 2.78244987e-02f, 4.61448841e-02f, -6.80942684e-02f,
  -1.48552373e-01f, -1.42222103e-02f, -4.82209884e-02f, 1.50506217e-02f, -2.07900666e-02f, 3.65905085e-04f, 2.16244206e-01f, -1.99001264e-02f, 8.61323550e-02f, 1.34779856e-01f,
  -1.58440322e-03f, -7.36839026e-02f, 6.55766502e-02f, -1.77931711e-02f, -1.29599283e-02f, -8.67778622e-03f, -1.53585442e-03f, 4.27950844e-02f, -1.43446224e-02f, -1.58667602e-02f,
  -1.08192131e-01f, -8.84301141e-02f, 2.26356220e-02f, -6.08175509e-02f, 7.45097250e-02f, 5.46580926e-02f, 1.08938590e-02f, 1.40769154e-01f, 2.29929388e-02f, 2.42845714e-02f,
  -1.20106764e-01f, 3.30968983e-02f, -1.05758384e-01f, 1.00425258e-03f, -1.49598904e-03f, -1.08541228e-01f, 4.17534783e-02f, -4.44022194e-02f, -1.75459851e-02f, 1.15775913e-01f,
  -4.24772128e-02f, 4.16131318e-03f, 2.16197893e-02f, -4.95224819e-03f, -1.26014829e-01f, 7.93965235e-02f, -6.70564771e-02f, -1.44231338e-02f, -1.17550299e-01f, 2.93519776e-02f,
  9.86791253e-02f, 1.51653990e-01f, -3.24598863e-03f, 7.92213380e-02f, 1.54468219e-03f, 1.74808633e-02f, 2.84918565e-02f, -8.40046350e-03f, 1.27402857e-01f, 9.73380655e-02f,
  7.13205338e-02f, 1.02788046e-01f, 4.03538160e-02f, 1.20540880e-01f, 1.29662961e-01f, -4.50770073e-02f, 2.32782111e-01f, -6.07052334e-02f, 1.39202192e-01f, 2.64606085e-02f,
  2.91845620e-01f, 2.46894836e-01f, -3.24720472e-01f, 7.70042315e-02f, -8.46874863e-02f, 5.38163304e-01f, 4.12618458e-01f, 1.85821041e-01f, 2.25626022e-01f, 3.06181401e-01f,
  2.98700750e-01f, -4.51635644e-02f, 2.46003103e-02f, 3.65491986e-01f, 2.21866623e-01f, 3.12732518e-01f, 4.77652341e-01f, 2.61971831e-01f, 7.56981075e-02f, 1.81248307e-01f,
  1.30829532e-02f, 3.32764119e-01f, -2.18168393e-01f, 3.21290828e-02f, 4.54882495e-02f, -3.20750475e-01f, -1.19408228e-01f, -2.88079470e-01f, -6.39548618e-03f, 6.10271189e-03f,
  6.92912042e-02f, 1.07179351e-01f, -8.24036449e-02f, -6.87699467e-02f, -7.30796903e-02f, -1.33671865e-01f, -1.58242106e-01f, -1.88528255e-01f, -1.20469734e-01f, -7.42505491e-03f,
  -2.87451167e-02f, -8.21104497e-02f, 1.40200570e-01f, -1.15122512e-01f, -1.09154070e-02f, -1.46261618e-01f, -9.67550930e-03f, -1.29917815e-01f, -4.51860130e-02f, 2.33654715e-02f,
  2.32638884e-03f, -5.56092001e-02f, 9.88050736e-03f, 8.09225664e-02f, -1.32251084e-01f, 1.12688608e-01f, -3.04061882e-02f, -9.44158286e-02f, 4.46540900e-02f, 7.66486302e-02f,
  8.52563232e-02f, 6.56683818e-02f, -3.80107649e-02f, 9.83234216e-03f, -4.58012223e-02f, -8.88496637e-02f, 4.52747531e-02f, 3.12192552e-02f, -8.59679803e-02f, 7.96911344e-02f,
  -5.06402738e-02f, 1.37088401e-02f, -3.16878036e-02f, -1.80371609e-02f, 1.09374091e-01f, 4.10215883e-03f, -4.72087115e-02f, 9.77134332e-02f, 4.35218215e-02f, 8.18975270e-02f,
  -3.65541577e-02f, 1.01868272e-01f, -7.14013278e-02f, -6.32232130e-02f, 8.24200064e-02f, -1.22688740e-01f, 1.54349297e-01f, 9.84892920e-02f, -7.06187263e-02f, -7.31815323e-02f,
  1.21341296e-01f, 2.55779117e-01f, -2.18289830e-02f, -1.16668753e-01f, -1.19798370e-01f, 6.53446689e-02f, 9.15991887e-02f, 6.94850534e-02f, 4.64255661e-02f, 1.33482918e-01f,
  -3.70894559e-02f, 3.12041095e-03f, 3.46677378e-02f, -3.58319143e-03f, -2.80220248e-03f, 5.89937754e-02f, 7.75569156e-02f, -4.83703427e-02f, 1.42163754e-01f, 5.76626733e-02f,
  -3.89570780e-02f, 1.24142058e-01f, -1.61431190e-02f, -8.51507336e-02f, -4.83531952e-02f, -1.47648379e-02f, 5.50495312e-02f, -1.24297328e-01f, -7.08055869e-02f, 6.67448938e-02f,
  -6.24763131e-01f, -3.38727720e-02f, -4.74578798e-01f, 1.93789244e-01f, -2.53926516e-01f, 2.97656953e-01f, 3.55698347e-01f, -1.71753526e-01f, -2.59600222e-01f, 4.09622967e-01f,
  3.89375895e-01f, -3.14174861e-01f, 2.23363847e-01f, 5.85081518e-01f, -1.48351893e-01f, 4.33551729e-01f, 3.56687427e-01f, 2.36213610e-01f, -1.98888525e-01f, -1.29574999e-01f,
  -2.06002966e-01f, 4.14146602e-01f, 2.47879148e-01f, -1.16124190e-01f, 4.04411107e-02f, -3.17957848e-01f, 2.45856524e-01f, -2.25861952e-01f, 2.90974289e-01f, 1.12694286e-01f,
  -2.50403900e-02f, -3.17460805e-01f, -7.45028928e-02f, -2.03855902e-01f, -7.82987028e-02f, -1.02502396e-02f, -6.29802495e-02f, -1.38315875e-02f, -9.39045176e-02f, -9.49537903e-02f,
  -7.03561753e-02f, -1.00930363e-01f, 1.00963250e-01f, -8.32777023e-02f, -2.35994086e-01f, -5.51653318e-02f, -3.42642888e-02f, 2.01376583e-02f, 6.42803833e-02f, -7.34585449e-02f,
  4.01926190e-02f, -7.96083882e-02f, 1.45809278e-01f, 1.35640442e-01f, -3.86895165e-02f, 5.00147380e-02f, 6.66752160e-02f, -6.00315956e-03f, -8.44217539e-02f, -5.71001209e-02f,
  -1.23094253e-01f, -6.67630322e-03f, 1.57882366e-02f, -8.38523731e-03f, 2.67936997e-02f, 1.04534455e-01f, 1.01437330e-01f, 9.74232405e-02f, -6.97107315e-02f, 5.26414663e-02f,
  -8.85970984e-03f, -8.19441825e-02f, -4.72198911e-02f, 1.31870117e-02f, 2.00352371e-02f, 1.00919930e-02f, -1.58594176e-02f, 8.63009840e-02f, -4.74840682e-03f, -3.77583764e-02f,
  3.59025709e-02f, -1.05413638e-01f, 1.31936133e-01f, 3.80615331e-02f, 2.24340744e-02f, 3.63067128e-02f, -2.90308576e-02f, 3.93937416e-02f, 1.26538306e-01f, -7.37135708e-02f,
  -1.37261823e-01f, -3.61507893e-01f, 5.77756539e-02f, -7.37296790e-02f, 4.95298877e-02f, 2.42960621e-02f, -4.22603749e-02f, -1.14283890e-01f, -7.73533806e-02f, -6.92394152e-02f,
  7.59622036e-03f, 4.31206115e-02f, -6.22391403e-02f, -4.97183129e-02f, 8.63506943e-02f, 5.42442650e-02f, 9.97120887e-03f, -8.83496776e-02f, 8.46681818e-02f, -3.95860188e-02f,
  9.50923935e-02f, -4.57000136e-02f, -7.47317821e-02f, 9.71103460e-02f, 1.57446161e-01f, 3.08616757e-02f, -1.63226396e-01f, -8.19679126e-02f, -1.06776722e-01f, 7.89409280e-02f,
  4.76206481e-01f, -1.34689827e-02f, -2.14693770e-01f, 2.18794435e-01f, 3.12375456e-01f, 3.20083201e-01f, 2.18638048e-01f, 1.81106716e-01f, 1.90056056e-01f, -2.65014861e-02f,
  4.19066101e-02f, -5.28787309e-03f, -2.77906656e-01f, 4.17655498e-01f, 2.39808500e-01f, -2.31694654e-01f, 3.90626550e-01f, 1.82140514e-01f, -3.25930454e-02f, 2.59319812e-01f,
  1.76559910e-01f, 4.72782731e-01f, -2.85378546e-01f, -1.03117460e-02f, 3.03441823e-01f, -2.64528513e-01f, -2.08681270e-01f, -3.28020602e-01f, -8.46788436e-02f, 1.20636106e-01f,
  9.67146456e-02f, 1.57485873e-01f, -2.77281664e-02f, -2.57709958e-02f, 3.44330110e-02f, 5.96070290e-02f, -8.09658915e-02f, -2.11649075e-01f, -1.19662218e-01f, 4.55324166e-03f,
  1.12483995e-02f, 5.32902889e-02f, 1.24554440e-01f, 3.26664886e-04f, 1.25049740e-01f, -1.02837272e-02f, -2.64357161e-02f, -1.84191123e-01f, -1.69051826e-01f, 7.39888847e-02f,
  -9.50651243e-02f, -4.75272648e-02f, 1.02844745e-01f, -1.11494966e-01f, 2.07428029e-03f, 1.86773520e-02f, -1.05549924e-01f, -1.25282362e-01f, -2.09874604e-02f, 2.97837928e-02f,
  1.51099637e-01f, 3.83805595e-02f, -1.45870158e-02f, -2.43043564e-02f, 1.16344206e-01f, -2.40870845e-02f, -6.09969674e-03f, -4.69770133e-02f, 8.42358842e-02f, 5.00106700e-02f,
  -2.68278867e-02f, 7.21096620e-02f, 6.20259568e-02f, -5.93703054e-02f, 1.29650878e-02f, 1.98466219e-02f, -2.61439607e-02f, -5.08090593e-02f, 1.50795355e-02f, -1.71208400e-02f,
  -2.43031271e-02f, -3.39768231e-02f, -2.96537038e-02f, -1.21229902e-01f, 3.94902676e-02f, -2.15239208e-02f, 1.60654709e-01f, -4.20272201e-02f, -1.36030629e-01f, -8.33675265e-02f,
  9.01636481e-02f, 2.56198626e-02f, -1.09368466e-01f, -2.79780738e-02f, -4.08640169e-02f, 1.06633157e-01f, 7.03352317e-02f, 1.53568104e-01f, 7.94177279e-02f, 8.73907804e-02f,
  1.29506057e-02f, -1.78673208e-01f, 3.73770520e-02f, -2.36785151e-02f, -4.49798368e-02f, 1.15046548e-02f, -1.14003666e-01f, -8.23198110e-02f, 2.31705960e-02f, -5.40409088e-02f,
  7.47132078e-02f, -1.51310675e-02f, 3.22196782e-02f, 6.27072621e-03f, 3.67162190e-02f, -6.66850284e-02f, -5.52449673e-02f, -7.57736787e-02f, 2.31359042e-02f, -1.54724214e-02f,
  2.23728254e-01f, 1.40963927e-01f, -2.53510326e-01f, -4.11722749e-01f, -1.14151716e-01f, -2.50506729e-01f, -2.70998478e-01f, -1.62772417e-01f, -2.39417583e-01f, 3.17686439e-01f,
  -1.41450673e-01f, 1.09102517e-01f, -7.46739581e-02f, -3.60738963e-01f, -6.38870716e-01f, -3.51403415e-01f, -2.46705994e-01f, -1.92507077e-02f, -1.21244758e-01f, 6.35735095e-02f,
  -1.87269285e-01f, -2.54333615e-01f, -3.43529046e-01f, 1.19594425e-01f, 1.30871296e-01f, 2.37379268e-01f, 1.14454053e-01f, 3.77592221e-02f, 1.04690343e-01f, -1.71436012e-01f,
  -6.70065135e-02f, -1.24236062e-01f, -3.86935589e-03f, -8.91201720e-02f, -1.28631601e-02f, 1.24678947e-01f, 1.60066485e-01f, -1.20243959e-01f, -4.42257561e-02f, -9.11720272e-04f,
  1.22881226e-01f, 3.29110846e-02f, -5.07906713e-02f, -1.56323552e-01f, 5.84429838e-02f, -1.24309482e-02f, 6.92698965e-03f, -1.15559706e-02f, -3.68684530e-02f, -1.17250700e-02f,
  -1.61627352e-01f, 8.26645941e-02f, 9.54784378e-02f, 5.57461828e-02f, -1.17873609e-01f, -1.08507439e-01f, -4.85063447e-06f, 5.33912368e-02f, 2.81428471e-02f, 5.55662671e-03f,
  7.19669908e-02f, 1.66974440e-02f, -3.35724875e-02f, -7.03464821e-02f, -1.03269927e-01f, 5.11367656e-02f, -1.06447889e-02f, 2.42814515e-02f, 5.49804717e-02f, 9.32596847e-02f,
  -7.68580213e-02f, 5.32710627e-02f, -2.67135631e-02f, -2.32934523e-02f, 5.89841306e-02f, -6.35165051e-02f, 6.47829920e-02f, 7.00543672e-02f, 4.19312641e-02f, -5.15639689e-03f,
  -7.13782012e-02f, -3.22857052e-02f, -3.18159871e-02f, 8.15966055e-02f, -6.85074925e-02f, -3.57531719e-02f, 6.74224868e-02f, -2.44234204e-02f, -2.28953511e-02f, -6.38896553e-03f,
  -2.41029914e-02f, 1.30788144e-02f, 1.59965474e-02f, 1.30007863e-02f, -3.04193404e-02f, 5.51203899e-02f, -9.74671096e-02f, -5.11975354e-03f, -5.18200472e-02f, -7.13299140e-02f,
  1.51570156e-01f, 3.14245969e-02f, 2.14221701e-01f, -1.98014453e-02f, -1.30372554e-01f, -7.19070211e-02f, -1.11403456e-02f, 1.16862917e-04f, 3.53544243e-02f, 1.00752786e-01f,
  4.40005586e-02f, 4.68159579e-02f, 3.52772251e-02f, -4.38636057e-02f, 1.07737936e-01f, 1.40276656e-01f, 1.00942045e-01f, -3.65613997e-02f, 6.79425299e-02f, -1.23810051e-02f,
  -1.70699377e-02f, 3.18394810e-01f, -2.48466115e-02f, 1.05291687e-01f, -2.30538130e-01f, 6.12959504e-01f, 7.80074358e-01f, -1.12260230e-01f, 3.41257542e-01f, 2.97712713e-01f,
  -1.24940462e-01f, 1.30058765e-01f, 2.96605110e-01f, 2.76501387e-01f, 3.81977320e-01f, 4.67482418e-01f, 4.99995947e-01f, 3.41603756e-01f, -2.93665137e-02f, -1.17079295e-01f,
  2.25242414e-03f, 1.68481022e-01f, -2.11844012e-01f, -4.03584808e-01f, -2.68047154e-01f, -3.29677254e-01f, -2.98893124e-01f, -1.43332869e-01f, -2.67457187e-01f, 1.76861472e-02f,
  1.29776403e-01f, -3.73567529e-02f, -1.08534813e-01f, 7.56427944e-02f, 9.33740139e-02f, 4.58649993e-02f, -4.50192578e-03f, -8.37899558e-03f, -1.21393539e-01f, 1.03161834e-01f,
  1.78580567e-01f, -4.68545966e-02f, -1.65416114e-02f, 2.39621662e-02f, -9.59300175e-02f, -7.27984756e-02f, -1.13689624e-01f, -1.65822089e-01f, -4.81783301e-02f, -8.39269236e-02f,
  -2.49383487e-02f, -7.42487684e-02f, -3.48861851e-02f, 1.44764304e-01f, -5.90140112e-02f, 1.83566734e-02f, 1.59631908e-01f, 6.62834197e-02f, 6.30494803e-02f, 3.49224880e-02f,
  -2.49219313e-02f, 1.25477865e-01f, 9.10967141e-02f, -9.01952460e-02f, 8.32590610e-02f, 1.12757217e-02f, 1.35870697e-02f, -5.66908531e-02f, 1.04721606e-01f, -9.35761854e-02f,
  8.37397799e-02f, -1.14102634e-02f, 7.13555550e-04f, 4.94660027e-02f, -3.95134538e-02f, 4.40141074e-02f, -5.97770177e-02f, 7.86293880e-04f, 8.73937383e-02f, -7.82192573e-02f,
  7.48230219e-02f, 1.33591341e-02f, 8.40869695e-02f, 3.84719111e-02f, 3.74524249e-03f, 4.53436188e-03f, -1.15652621e-01f, -8.36492702e-02f, -9.60303769e-02f, -1.01895882e-02f,
  1.15775771e-01f, 3.47439945e-01f, 5.24762310e-02f, 5.52582592e-02f, 9.84377339e-02f, -6.30076379e-02f, 6.49220645e-02f, -2.71296278e-02f, 1.60694778e-01f, 1.22500330e-01f,
  -1.06922127e-01f, 1.29126161e-01f, 9.91586968e-03f, -1.16438091e-01f, -1.20601393e-02f, 2.01318085e-01f, 1.79602772e-01f, 1.35520682e-01f, 3.18749174e-02f, -2.27128670e-01f,
  -7.16612339e-02f, 1.17725097e-01f, 1.88908577e-02f, 2.67965067e-02f, 3.41567285e-02f, -2.70200282e-04f, -7.28763193e-02f, -1.88927576e-02f, -1.70662776e-02f, 8.90703946e-02f,
  -2.05608815e-01f, 1.77414820e-01f, -1.90073192e-01f, -1.79197818e-01f, 3.26433688e-01f, -3.01858276e-01f, 3.50788124e-02f, -2.32940260e-02f, -4.60896865e-02f, 2.94405133e-01f,
  -1.03729412e-01f, -1.47078022e-01f, 8.63995627e-02f, -4.78866458e-01f, -7.68760622e-01f, -4.88172710e-01f, -4.92966443e-01f, -3.46807003e-01f, -1.90719098e-01f, -6.77663600e-03f,
  -2.61050016e-01f, -1.50853723e-01f, -2.62441903e-01f, 2.93646634e-01f, 2.38501802e-01f, 2.97211468e-01f, 1.57845482e-01f, 2.23630890e-01f, 7.94955436e-03f, -1.47949755e-01f,
  -1.45211071e-01f, 7.42873847e-02f, 2.76497398e-02f, -1.01617135e-01f, -4.56019603e-02f, 1.47715643e-01f, 9.18578431e-02f, -3.70029993e-02f, -7.51499832e-02f, -7.07476139e-02f,
  3.95391472e-02f, -9.39860120e-02f, -1.38070032e-01f, -5.18904589e-02f, 1.26855537e-01f, -9.36815664e-02f, -7.53489360e-02f, 4.57305796e-02f, 3.87400165e-02f, -1.47321492e-01f,
  6.68759793e-02f, -2.94177514e-02f, 4.20650989e-02f, 6.47940040e-02f, -1.30751103e-01f, 1.04369055e-02f, -6.40249401e-02f, -1.89233311e-02f, -9.66746360e-03f, -3.05834673e-02f,
  1.69227690e-01f, 9.20753330e-02f, -1.87022537e-02f, -1.67398602e-02f, -4.26751226e-02f, 1.23724394e-01f, -8.32716078e-02f, -6.90875128e-02f, -2.70915274e-02f, 4.46674563e-02f,
  -5.71347512e-02f, 5.34561425e-02f, -9.53356549e-02f, 6.64664656e-02f, 3.62820476e-02f, -2.13549305e-02f, 2.70340089e-02f, -6.13233866e-03f, -1.17721257e-03f, -1.55487005e-02f,
  1.23433687e-01f, -3.97498310e-02f, 4.74164411e-02f, 1.56012580e-01f, -1.63855180e-01f, 3.62151824e-02f, 8.41934793e-03f, -9.74847563e-03f, -1.78802498e-02f, 8.89644027e-02f,
  -9.94811729e-02f, 6.91957995e-02f, 1.25895396e-01f, 4.81491536e-02f, 7.44022876e-02f, -8.73513967e-02f, -1.11255676e-01f, 4.19168267e-04f, -6.89637959e-02f, -4.48236335e-03f,
  1.18302248e-01f, 1.09020822e-01f, 8.38840976e-02f, -1.26825720e-01f, 1.19881444e-02f, -4.39299718e-02f, 6.85008615e-02f, 1.45543069e-01f, 1.37020692e-01f, -5.10658138e-02f,
  2.44586796e-01f, 1.15054891e-01f, 3.07009015e-02f, 6.91276044e-02f, 1.36487871e-01f, 1.40043154e-01f, 1.72947701e-02f, 6.66623265e-02f, 5.48852608e-02f, -6.76439330e-02f,
  -1.74967349e-01f, -3.75305951e-01f, 1.13182545e-01f, -4.01636451e-01f, -1.62623420e-01f, 1.78960264e-01f, 2.27098912e-01f, -3.15835059e-01f, -6.01478554e-02f, -1.79245591e-01f,
  -1.48440927e-01f, 7.42403269e-02f, 5.49594164e-01f, -4.66118366e-01f, 6.29963994e-01f, 4.58209544e-01f, -2.33107641e-01f, 5.38875237e-02f, -4.29862589e-02f, -3.04782987e-01f,
  -2.31908649e-01f, -3.62122297e-01f, 2.66806688e-02f, -3.67488563e-01f, -4.70479995e-01f, -3.06219250e-01f, -1.50911868e-01f, 1.59744665e-01f, -4.35277402e-01f, 1.32898521e-02f,
  -3.52865577e-01f, -3.32757860e-01f, -3.18073064e-01f, -1.16787620e-01f, -2.93071121e-01f, -5.81560433e-02f, 5.83770461e-02f, 2.48104542e-01f, 9.40145701e-02f, -1.11124637e-02f,
  8.89781341e-02f, 5.43696210e-02f, -7.91277960e-02f, 1.48297161e-01f, -2.40011103e-02f, -1.36163786e-01f, -9.30458978e-02f, -1.59629792e-01f, -1.13366149e-01f, -4.59545963e-02f,
  -5.77347465e-02f, -1.30558968e-01f, -1.62652001e-01f, -6.74355263e-03f, 7.94434100e-02f, -1.89038604e-01f, 1.82756763e-02f, 2.06271902e-01f, -1.81227013e-01f, -8.54343846e-02f,
  2.55321041e-02f, 1.88098505e-01f, -1.35592982e-01f, -9.04163569e-02f, -1.99370384e-02f, -1.00896440e-01f, -4.82185744e-02f, 6.54620975e-02f, -3.52104604e-02f, 1.88239943e-02f,
  -8.72667953e-02f, -4.83865291e-02f, -3.12017258e-02f, 4.77240346e-02f, -7.43347555e-02f, -5.85333593e-02f, -1.76571496e-02f, -9.11138020e-03f, 3.68000157e-02f, -6.96547553e-02f,
  7.79268444e-02f, 2.90422440e-02f, -1.22379707e-02f, 5.74211255e-02f, -6.94441423e-02f, 9.10282061e-02f, -9.09614414e-02f, -1.22597322e-01f, 3.63414586e-02f, 1.86901614e-01f,
  -2.04270020e-01f, -2.77229249e-01f, -7.15930760e-02f, -2.17460185e-01f, 4.79973480e-02f, -4.78083007e-02f, 1.06072702e-01f, -1.75542444e-01f, -4.02642693e-03f, -1.11683674e-01f,
  -1.04533397e-01f, -1.02836683e-01f, 5.00576422e-02f, 5.67480363e-02f, 2.05640584e-01f, -1.10813463e-02f, 4.21484224e-02f, -2.75180899e-02f, 3.47917192e-02f, -1.00755267e-01f,
  -4.87712920e-02f, 1.48601413e-01f, 1.72508731e-01f, -5.56575470e-02f, -3.65651511e-02f, -1.99665502e-02f, 1.03191873e-02f, -1.18887484e-01f, 1.24908146e-02f, -4.46460173e-02f,
  1.61708549e-01f, 5.68138838e-01f, 5.94984353e-01f, 5.82658291e-01f, -3.80606323e-01f, -5.31243980e-01f, -2.66012222e-01f, 1.36830613e-01f, 1.92982048e-01f, -1.09375566e-01f,
  -3.24061632e-01f, 5.90642989e-01f, -4.36347187e-01f, 3.74751419e-01f, -6.80495352e-02f, -2.49130905e-01f, 5.56757674e-02f, 3.07498183e-02f, 1.14568599e-01f, 1.74314082e-01f,
  1.87243626e-01f, -2.38626208e-02f, 1.42279193e-01f, 2.49355249e-02f, 2.11932108e-01f, 3.62553388e-01f, 2.77331710e-01f, 7.34118000e-02f, 2.53407180e-01f, -6.92287460e-02f,
  -3.22387397e-01f, 2.55247593e-01f, 6.25768527e-02f, 4.38318849e-02f, 4.96977344e-02f, -1.61386475e-01f, -4.09166515e-03f, -4.49976437e-02f, -1.68151967e-02f, 8.40502679e-02f,
  1.91737583e-03f, -6.00022972e-02f, 1.35989711e-01f, 4.56298776e-02f, 1.10324323e-01f, 2.59002328e-01f, 9.57838222e-02f, -2.54959855e-02f, 1.69133991e-01f, 6.30476475e-02f,
  1.60726175e-01f, 2.20894869e-02f, -3.42209414e-02f, 3.26424390e-02f, 9.88590643e-02f, -2.10397132e-02f, 8.73206854e-02f, 3.19652110e-02f, 1.94951519e-02f, 1.06399767e-01f,
  -1.28994703e-01f, -3.69782113e-02f, -3.54827754e-02f, 1.27047017e-01f, -1.76027827e-02f, -9.53409821e-03f, 6.27447590e-02f, -3.05698160e-02f, 4.34838645e-02f, -1.25655994e-01f,
  -9.67106372e-02f, 2.15191782e-01f, -2.78420355e-02f, 1.56039465e-02f, 9.94085893e-02f, 3.71497571e-02f, -4.49946597e-02f, -2.96101253e-02f, 6.54322803e-02f, 9.24099162e-02f,
  -9.57321469e-03f, -1.39113769e-01f, 2.31797531e-01f, -9.29331034e-02f, -8.22740868e-02f, 2.96982359e-02f, 1.03892602e-01f, 5.84851392e-02f, -1.75171327e-02f, 5.12408838e-02f,
  -7.90651813e-02f, 2.61401743e-01f, 1.33202642e-01f, -7.61567280e-02f, -9.47707333e-03f, 1.27593447e-02f, 6.94634765e-02f, -6.76140115e-02f, 1.43039361e-01f, -5.12916893e-02f,
  -6.95898086e-02f, -4.11688872e-02f, -2.45329384e-02f, -8.56787786e-02f, 3.36229317e-02f, -2.50165071e-02f, 4.14259434e-02f, 6.74734786e-02f, 2.52511594e-02f, 1.12022646e-01f,
  1.41041309e-01f, -1.27723366e-01f, 2.51570158e-02f, 3.27117890e-02f, -1.00795142e-01f, 5.28245047e-02f, 2.12014988e-02f, 1.03018302e-02f, 1.66060347e-02f, 4.72601466e-02f,
  1.70548335e-02f, -1.73236594e-01f, -4.49657142e-01f, -4.15513277e-01f, -1.65412173e-01f, -4.17577744e-01f, -5.15489042e-01f, -2.32697815e-01f, -6.55642226e-02f, -1.58187389e-01f,
  -2.66481906e-01f, 6.84266910e-02f, 3.01190019e-01f, -4.34041351e-01f, 2.65935957e-01f, 4.14127082e-01f, -4.19887990e-01f, -3.83944780e-01f, 9.77438986e-02f, -2.77243167e-01f,
  -1.02459922e-01f, -2.40943372e-01f, -3.74271162e-02f, -9.24635157e-02f, -3.48036975e-01f, -1.62489265e-01f, 9.18513685e-02f, -1.67366266e-01f, -4.12493974e-01f, 3.58937047e-02f,
  3.44815925e-02f, 1.34810597e-01f, -2.91792043e-02f, -9.72088543e-04f, -2.71840934e-02f, 3.49193439e-02f, -2.83614159e-01f, -1.99098196e-02f, -1.85319949e-02f, -3.99545468e-02f,
  8.44883248e-02f, 2.34431669e-01f, -9.04194117e-02f, 1.71973720e-01f, -1.42587021e-01f, -7.72246392e-04f, -3.85264456e-02f, -1.08047292e-01f, 5.38215563e-02f, 1.40049994e-01f,
  -2.96540745e-02f, -1.47553002e-02f, -6.92579895e-02f, -2.67059002e-02f, -3.71161774e-02f, -5.36961742e-02f, 5.07513024e-02f, 2.02915017e-02f, 4.03733831e-03f, 2.67286263e-02f,
  1.00159988e-01f, -6.92526251e-02f, 3.32698226e-02f, -6.84449226e-02f, 4.01311032e-02f, -6.46899715e-02f, -1.03283022e-02f, 6.10037372e-02f, -3.97284441e-02f, -7.40047693e-02f,
  -8.45573619e-02f, 1.50247607e-02f, -2.52919029e-02f, -1.95926070e-01f, -2.74007786e-02f, 1.25775784e-01f, -3.89952771e-02f, -4.69782725e-02f, -2.04626605e-01f, 2.99080405e-02f,
  -4.90145870e-02f, -3.06969117e-02f, -2.91016344e-02f, -6.17585927e-02f, -6.61885589e-02f, -2.02003103e-02f, -4.57524182e-03f, 5.95290698e-02f, -8.42855498e-02f, -4.93792146e-02f,
  -4.62943651e-02f, -1.56766385e-01f, 5.26727960e-02f, 5.39131276e-02f, -9.23225135e-02f, -4.69698058e-03f, -4.59043793e-02f, 2.23186128e-02f, 2.35942863e-02f, -4.70008291e-02f,
  -1.26462713e-01f, -4.16295826e-02f, -1.47079647e-01f, 1.35248462e-02f, -7.58438408e-02f, -6.63696751e-02f, 4.15144442e-03f, -4.46560197e-02f, -7.94927329e-02f, -1.32459570e-02f,
  4.26213183e-02f, 3.89117189e-02f, 1.55461982e-01f, 1.07247964e-01f, 4.85359915e-02f, -3.51913273e-02f, 3.29882391e-02f, 6.83019087e-02f, 5.14532141e-02f, -1.69883315e-02f,
  -3.34633231e-01f, -5.80831170e-01f, -1.54366583e-01f, 8.97572562e-02f, 1.71794102e-01f, 1.62123293e-01f, -1.69633836e-01f, -1.05269156e-01f, -3.53749722e-01f, -4.15453583e-01f,
  -3.89409028e-02f, 1.10176638e-01f, -3.57999355e-01f, 3.02154273e-01f, 2.96166927e-01f, -2.32010260e-01f, 1.28663793e-01f, 1.03666246e-01f, -1.44950179e-02f, -1.57070756e-01f,
  -2.64627449e-02f, 1.70546249e-01f, 3.16704549e-02f, 1.50437564e-01f, -4.59028892e-02f, 6.07602634e-02f, 1.29263967e-01f, -5.42112924e-02f, 3.47328007e-01f, 2.98605055e-01f,
  -8.07539895e-02f, -2.68589944e-01f, 4.11703624e-02f, 1.08208798e-03f, -9.10815522e-02f, 1.74584351e-02f, 1.15747862e-01f, 2.72043403e-02f, 9.96536482e-03f, -8.14227313e-02f,
  4.79615368e-02f, 2.84532104e-02f, 2.38527924e-01f, -3.91202308e-02f, -1.08436026e-01f, 2.68526953e-02f, -5.38999140e-02f, -6.20166063e-02f, 2.37898231e-02f, -1.12560339e-01f,
  -1.10827930e-01f, -4.55340073e-02f, 5.65559603e-03f, 1.59937099e-01f, -3.22073065e-02f, 1.18921651e-02f, 2.40766611e-02f, -3.49952392e-02f, 3.97628695e-02f, 2.47550271e-02f,
  9.01408866e-02f, 9.19308588e-02f, -9.17210728e-02f, 1.61216259e-02f, -1.12862349e-01f, 2.78856251e-02f, 6.04420193e-02f, -4.44340184e-02f, -1.96966659e-02f, -1.53333738e-01f,
  1.52037982e-02f, -2.27574408e-02f, -3.66669870e-03f, -1.70188677e-02f, 5.15661156e-03f, 3.86486761e-02f, 3.64153981e-02f, -1.26650333e-02f, -1.14163287e-01f, 6.55253604e-02f,
  5.72884083e-02f, -4.92079891e-02f, -1.15000583e-01f, 1.02142036e-01f, 4.82802950e-02f, -4.87655774e-02f, -2.13523638e-02f, -1.27813444e-01f, -9.59945172e-02f, 3.71212550e-02f,
  -5.85403025e-01f, -3.41819227e-01f, 5.37224337e-02f, 1.18479338e-02f, -6.63821101e-02f, -9.14161652e-02f, 1.38224557e-01f, -5.53601310e-02f, -1.60063922e-01f, -1.79029241e-01f,
  -6.12545237e-02f, 4.44430299e-02f, 5.30205294e-02f, -2.19655409e-03f, 1.71601310e-01f, -1.31666690e-01f, -8.66963044e-02f, -1.26019239e-01f, 4.57210578e-02f, -9.31808427e-02f,
  -1.14585469e-02f, -2.35245511e-01f, 3.03162068e-01f, 1.04987174e-01f, -3.21758986e-02f, 1.31429106e-01f, -6.36904463e-02f, 7.82235190e-02f, 9.94316861e-02f, 3.62279266e-02f,
  -5.90786755e-01f, 2.56390125e-01f, 5.77700615e-01f, -4.72662479e-01f, 2.66930908e-01f, 5.42266965e-01f, 2.32143924e-01f, 1.67088866e-01f, -3.79561484e-01f, -2.89799035e-01f,
  -3.87050390e-01f, -5.92637025e-02f, 1.99145555e-01f, -3.37615252e-01f, 3.46532822e-01f, 6.06141202e-02f, -5.73748276e-02f, -2.00202361e-01f, 1.17754377e-01f, -1.36815906e-01f,
  -5.29748611e-02f, -3.58550638e-01f, 3.80897343e-01f, -1.29719988e-01f, 1.14717811e-01f, -8.24889019e-02f, -4.73033607e-01f, 2.61160523e-01f, -1.34184927e-01f, 1.94586828e-01f,
  -9.46429446e-02f, -3.99519771e-01f, 6.74339756e-02f, 1.17310718e-01f, 1.14396133e-01f, 3.29472683e-02f, 4.83443774e-02f, -2.60857884e-02f, -1.38713315e-01f, 1.50251202e-02f,
  -6.27208427e-02f, 7.73677155e-02f, -1.38329163e-01f, 4.35630865e-02f, 8.34762529e-02f, 8.64866823e-02f, 1.38552815e-01f, 1.37371600e-01f, 1.23295158e-01f, 2.81535476e-01f,
  3.18739057e-01f, 1.57312766e-01f, 6.25034198e-02f, 3.82449962e-02f, 1.93213262e-02f, 5.85290156e-02f, -2.73146890e-02f, 8.89233351e-02f, 1.69614747e-01f, 1.25687197e-02f,
  -7.18391091e-02f, -9.60488319e-02f, 1.28373995e-01f, -5.77473417e-02f, -4.97498317e-03f, -5.55070005e-02f, 2.96691898e-04f, -1.37087852e-01f, -3.32887173e-02f, -2.21752021e-02f,
  -3.68903391e-02f, 7.23056076e-03f, -1.09552763e-01f, 1.85460337e-02f, -9.81342345e-02f, -2.17583701e-01f, 8.39542896e-02f, -2.35726144e-02f, -4.32139821e-02f, 2.63507813e-02f,
  -7.63455108e-02f, 1.01557868e-02f, -7.49406368e-02f, -8.56397972e-02f, 8.48078504e-02f, 7.77895702e-03f, 3.62980179e-02f, 1.21686406e-01f, -1.10213093e-01f, 5.04797585e-02f,
  -1.25393316e-01f, -4.63985443e-01f, -2.88223438e-02f, -2.34682672e-02f, -1.11399181e-02f, 2.15985272e-02f, -6.39005601e-02f, 4.06950973e-02f, -6.44225478e-02f, 1.16596716e-02f,
  -1.50534408e-02f, -1.27860248e-01f, 2.60888506e-02f, -7.60264024e-02f, -2.95298044e-02f, -8.26752931e-03f, -2.34647781e-01f, -1.40831724e-01f, -5.92091382e-02f, -9.20604765e-02f,
  -6.63029682e-03f, -9.96726230e-02f, 2.57917326e-02f, -8.94488990e-02f, -5.04761674e-02f, -1.05189309e-02f, -2.44575262e-01f, 1.93965547e-02f, 1.08396888e-01f, -2.80639268e-02f,
  -3.72720152e-01f, 6.92078248e-02f, -1.55283123e-01f, -4.23285842e-01f, 3.83488327e-01f, -1.91954449e-02f, 1.16945557e-01f, 2.92431533e-01f, 1.55881997e-02f, 9.65800583e-02f,
  2.00624421e-01f, -4.90825474e-01f, 2.21835047e-01f, -4.15892154e-01f, -4.55478132e-01f, -2.84416348e-01f, -5.47721446e-01f, -3.01311493e-01f, 2.42777281e-02f, -1.06925881e-02f,
  -2.10996419e-01f, -9.48090777e-02f, -1.73383877e-01f, 4.64990854e-01f, -2.23861802e-02f, 1.14768334e-01f, 4.52646203e-02f, 5.34932673e-01f, -2.63275802e-01f, 4.32592304e-03f,
  3.84140797e-02f, 1.08730532e-01f, 1.28162637e-01f, 1.57668125e-02f, 1.38336912e-01f, 5.94373532e-02f, -9.58688855e-02f, 8.81801844e-02f, 5.98935783e-02f, 6.82022795e-02f,
  -1.61615089e-01f, -7.15106726e-02f, -9.80392769e-02f, 8.32668990e-02f, 1.11638509e-01f, 8.64480063e-02f, -1.11351967e-01f, -4.61817943e-02f, 4.06764559e-02f, -3.24549600e-02f,
  -3.72996219e-02f, -4.79129404e-02f, -2.83081949e-01f, -1.80559143e-01f, -8.06225985e-02f, 3.41401733e-02f, -1.88461438e-01f, -1.02343678e-01f, -1.04207143e-01f, -6.37445822e-02f,
  -1.24661744e-01f, -8.63001868e-03f, 1.83484573e-02f, 1.15802638e-01f, -3.59875150e-02f, 1.23604663e-01f, -3.78835686e-02f, -6.85852813e-03f, 7.23368898e-02f, -3.87978577e-03f,
  2.80868951e-02f, 2.52449606e-02f, 8.72953981e-02f, -4.33186144e-02f, -9.34713632e-02f, -3.64632756e-02f, -7.54709467e-02f, -1.00901455e-01f, -1.01256490e-01f, 8.97042826e-03f,
  3.09949853e-02f, -1.39752731e-01f, 6.97189867e-02f, -1.12505974e-02f, 1.53970003e-01f, 6.31787907e-03f, -1.20190114e-01f, 4.59365500e-03f, 8.64736512e-02f, -7.40551949e-02f,
  8.29287693e-02f, 5.67369349e-02f, 1.52663767e-01f, 1.82344645e-01f, 7.74231628e-02f, 3.46109420e-02f, 1.00349160e-02f, -6.13715388e-02f, 1.51593894e-01f, -3.66833135e-02f,
  -1.72768421e-02f, -7.30786994e-02f, 8.93871021e-03f, -2.21204963e-02f, -3.59389186e-02f, -1.75672397e-02f, -2.68365908e-02f, -5.59529625e-02f, -5.34352064e-02f, -1.06816113e-01f,
  -2.93589756e-02f, 4.10514139e-02f, -6.65629730e-02f, 1.28956765e-01f, -7.94827417e-02f, -2.89880689e-02f, 1.06993178e-02f, 9.27975476e-02f, -1.01357073e-01f, -5.68836406e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.26254165e-01f, 3.78542960e-01f, 4.45602119e-01f, 4.96434391e-01f, 2.50143141e-01f, 3.30883235e-01f, 3.18399191e-01f, 5.25755346e-01f, 5.38024962e-01f, 1.47260249e-01f,
  4.43587273e-01f, 4.67475772e-01f, 5.87246358e-01f, 3.68101716e-01f, 5.07674813e-01f, 5.68937719e-01f, 3.23041290e-01f, 2.08637238e-01f, 5.00406921e-01f, 3.97646755e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -4.16202880e-02f, -8.01911280e-02f, -3.95598024e-01f, 5.21548428e-02f, 2.42749006e-02f, -2.69332826e-01f, 1.66690439e-01f, -3.01493406e-01f, 7.65797868e-02f, 1.08744293e-01f,
  3.33040774e-01f, 9.64481682e-02f, 1.59995705e-01f, -8.89021754e-02f, 2.78436780e-01f, -1.73412755e-01f, -3.59325111e-02f, 7.89646506e-02f, -3.26265723e-01f, 5.62747270e-02f,
  5.07146493e-02f, 2.89545208e-01f, 1.30768925e-01f, 1.91341370e-01f, 1.00321822e-01f, 1.52371049e-01f, 1.59130812e-01f, -3.72569293e-01f, 1.98640376e-01f, -5.96585199e-02f,
  -7.59916827e-02f, -2.02453285e-01f, -6.74578771e-02f, -3.28846201e-02f, -3.97226214e-02f, 8.80858302e-02f, -2.20989827e-02f, -1.39394358e-01f, -1.49934381e-01f, 1.49836779e-01f,
  -1.01471841e-01f, -2.11671293e-01f, 2.77908631e-02f, 4.60736416e-02f, -7.01817200e-02f, 5.49117252e-02f, -7.37748593e-02f, -1.04122989e-01f, 1.77550405e-01f, 2.06121519e-01f,
  -3.12965244e-01f, -1.19811997e-01f, 2.07973972e-01f, 1.26823634e-01f, 2.60429054e-01f, 1.87713221e-01f, 1.02920480e-01f, -7.15268776e-02f, -2.00748995e-01f, 2.00675309e-01f,
  -4.03537862e-02f, -3.19132149e-01f, -2.51752269e-02f, -4.82513428e-01f, 1.05987929e-01f, -1.81627870e-01f, -8.40908363e-02f, -1.66590601e-01f, 1.76084846e-01f, -1.06093615e-01f,
  -4.70382199e-02f, -3.56234550e-01f, 1.43493459e-01f, 2.44085267e-01f, 1.12805516e-01f, 3.39714527e-01f, 3.02340001e-01f, -8.97819623e-02f, -1.00494632e-02f, -6.64611459e-02f,
  -4.08952683e-01f, -1.20803654e-01f, 3.02002206e-02f, 2.91978985e-01f, 2.36553311e-01f, -1.42064676e-01f, 2.22970665e-01f, 7.74530768e-02f, -1.42231092e-01f, 1.40990168e-01f,
  -6.02399893e-02f, -2.90263951e-01f, 2.59349614e-01f, 4.50317599e-02f, -1.45541802e-01f, 1.89350560e-01f, 1.50747284e-01f, 1.11093402e-01f, 7.14559257e-02f, 1.64343387e-01f,
  -3.99608649e-02f, -2.66430639e-02f, -3.96812022e-01f, -1.48561358e-01f, -4.99940738e-02f, -8.18099380e-02f, -1.74179494e-01f, -3.30001652e-01f, -2.63326228e-01f, 2.72876173e-01f,
  1.21527843e-01f, -1.34525090e-01f, 4.91467789e-02f, 5.31771071e-02f, 1.82580769e-01f, -1.83765605e-01f, 1.28629357e-01f, 2.08792254e-01f, 4.07347828e-02f, 4.27166000e-02f,
  1.61934532e-02f, -7.74635822e-02f, 8.77843425e-02f, -3.37791219e-02f, 2.65089333e-01f, -2.07945317e-01f, 1.81596562e-01f, 5.10436762e-03f, 8.28046277e-02f, 1.74401447e-01f,
  1.07852541e-01f, 1.33364357e-03f, 2.77081519e-01f, 2.35930324e-01f, -2.01252282e-01f, 1.01715468e-01f, -6.22305349e-02f, -4.80699301e-01f, 5.36320545e-02f, -2.51291603e-01f,
  -2.11265445e-01f, 1.67959675e-01f, -4.30575721e-02f, 1.65823519e-01f, -9.02076811e-03f, 5.23500517e-02f, 1.18060641e-01f, -1.27541229e-01f, 1.70252994e-01f, 7.16571733e-02f,
  1.80080608e-02f, 8.96116905e-03f, 1.42745689e-01f, -2.83355504e-01f, -2.12048501e-01f, -7.83849508e-02f, -9.34014097e-02f, -8.49251226e-02f, 2.88188040e-01f, -8.42194408e-02f,
  3.00246239e-01f, 7.05873370e-02f, 2.36411035e-01f, 1.19368903e-01f, 1.14274457e-01f, 4.65418726e-01f, -1.64607331e-01f, -1.54008955e-01f, 3.20250928e-01f, -2.21266001e-01f,
  -3.22104573e-01f, -1.20682418e-01f, -2.46887073e-01f, 2.20741779e-01f, 1.95196360e-01f, -1.71425447e-01f, 1.30718425e-02f, -2.77385950e-01f, 7.40620866e-02f, -6.82988986e-02f,
  -1.27736062e-01f, -3.06514472e-01f, -4.97219488e-02f, 2.68957525e-01f, -9.47983041e-02f, -5.31434268e-02f, 2.30508834e-01f, 1.29916474e-01f, 7.93884844e-02f, -2.21877411e-01f,
  2.57371813e-01f, -8.30358714e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  5.85381448e-01f, -2.04852801e-02f, 2.11197734e-01f, 7.14354143e-02f, 3.24894905e-01f, 1.97237685e-01f, -2.26353481e-01f, 1.98066920e-01f, 2.49208823e-01f, -1.54422760e-01f,
  3.38720471e-01f, 2.50912249e-01f, 2.80422956e-01f, 5.51081121e-01f, 2.12143108e-01f, 6.20015144e-01f, -3.89736384e-01f, 7.93478116e-02f, -4.72895056e-01f, 2.63249636e-01f,
  1.74675375e-01f, 4.52196449e-02f, 5.32771409e-01f, 3.60148519e-01f, 1.36812925e-01f, 4.33016747e-01f, -3.69724661e-01f, 2.26652071e-01f, -4.79160994e-01f, 2.06213653e-01f,
  -2.31064811e-01f, 2.22840235e-01f, -1.70656845e-01f, 2.79545695e-01f, 1.96082845e-01f, 2.24623904e-01f, 3.06853324e-01f, 3.42400014e-01f, -2.18344666e-02f, -3.37784648e-01f,
  -1.77888021e-01f, 4.85277414e-01f, -4.11739498e-01f, -5.77669978e-01f, -6.90748870e-01f, 3.34743619e-01f, -4.06157710e-02f, -3.03168803e-01f, 2.00208455e-01f, 3.97762567e-01f,
  8.77237082e-01f, 3.39823782e-01f, -1.73097387e-01f, 6.01469636e-01f, -3.05663496e-01f, 3.27480644e-01f, -2.62774587e-01f, 4.32586342e-01f, -2.55431116e-01f, 5.94462931e-01f,
  -2.61313170e-01f, 9.26946942e-03f, 6.89103067e-01f, 6.14305496e-01f, 2.63281286e-01f, 5.28110206e-01f, 3.05819273e-01f, 3.64620596e-01f, 1.88430265e-01f, 5.32370508e-01f,
  -5.67008913e-01f, 1.88114703e-01f, 2.87640184e-01f, -1.85617208e-01f, -5.09235084e-01f, -3.12846094e-01f, -5.60950577e-01f, 3.78326893e-01f, -2.81200916e-01f, -2.85292864e-01f,
  -3.75931896e-02f, -3.43799859e-01f, 3.68738234e-01f, -3.47905785e-01f, 1.34700447e-01f, -3.87445301e-01f, -8.80690515e-02f, 3.83744724e-02f, 4.13934082e-01f, -7.40557909e-02f,
  4.83336985e-01f, 8.60153913e-01f, 5.43906689e-01f, 1.13271512e-01f, 4.24124599e-01f, 4.58723046e-02f, -1.40264452e-01f, 5.21904171e-01f, -1.21797007e-02f, 4.62753683e-01f,
  3.55062664e-01f, 6.36150837e-02f, -6.85135782e-01f, -4.65420425e-01f, -3.07971269e-01f, -3.11260968e-01f, -2.92025506e-01f, -3.31938744e-01f, -1.38718218e-01f, -3.21196355e-02f,
  -2.66811997e-01f, -3.67471009e-01f, 7.11123347e-02f, 1.54877290e-01f, 7.20129251e-01f, 1.02249436e-01f, 3.77231658e-01f, 5.17465293e-01f, -2.24098079e-02f, 8.82974789e-02f,
  4.36306655e-01f, -8.24930891e-02f, 2.69797921e-01f, -2.96136737e-01f, 3.82938892e-01f, -1.21234819e-01f, 1.67119846e-01f, 4.61298555e-01f, 4.63712990e-01f, 1.96647704e-01f,
  5.36194518e-02f, 2.98216343e-01f, 2.21357152e-01f, 9.09245387e-02f, 1.25149354e-01f, -3.73716317e-02f, 2.86878377e-01f, 1.73719600e-01f, 2.02045828e-01f, 1.64990261e-01f,
  3.02008837e-02f, 3.79804552e-01f, 5.58661044e-01f, 3.98628682e-01f, 4.14501697e-01f, -2.98299640e-01f, -5.93700647e-01f, -3.96479011e-01f, -2.93723136e-01f, -2.21859366e-01f,
  -4.02329594e-01f, 4.03205067e-01f, 1.39605567e-01f, 2.86561340e-01f, 6.47343218e-01f, 2.52091475e-02f, 2.41425514e-01f, -1.36819137e-02f, 2.05686223e-02f, 2.84445249e-02f,
  3.11305016e-01f, 1.21652335e-01f, 3.68846893e-01f, 7.78442919e-02f, 6.95801303e-02f, 3.94152701e-01f, 3.47862601e-01f, -1.87605038e-01f, 1.49445370e-01f, 5.73218465e-01f,
  -3.60943116e-02f, 2.07987890e-01f, -1.11199267e-01f, -1.51419729e-01f, 1.14698656e-01f, 3.31015348e-01f, -3.72339576e-01f, 3.26760858e-01f, 4.74810421e-01f, 3.32570612e-01f,
  -1.90449934e-02f, -3.39804530e-01f, -1.76414512e-02f, 3.46275866e-01f, -3.09041798e-01f, 4.21509147e-01f, 1.81511179e-01f, 2.50602663e-01f, 5.36409318e-01f, -3.49279583e-01f,
  1.51772931e-01f, 6.27281487e-01f, 1.92896426e-01f, 5.27215302e-01f, 2.79928029e-01f, 6.38567328e-01f, 3.82148981e-01f, 5.54609299e-01f, -4.60312545e-01f, 3.24976891e-01f,
  -5.05699694e-01f, -7.19699025e-01f, 3.33354205e-01f, -2.27782920e-01f, -2.95512974e-02f, -8.57014433e-02f, 2.65446782e-01f, 2.58836597e-01f, 2.31001779e-01f, 2.46007651e-01f,
  2.33417168e-01f, 3.83997522e-02f, 6.94042265e-01f, 4.01592940e-01f, 3.00893128e-01f, -5.48628449e-01f, 8.22802842e-01f, -7.64537215e-01f, 5.25738120e-01f, -3.12601149e-01f,
  7.86399618e-02f, -3.67448658e-01f, 5.02627432e-01f, 5.20983487e-02f, -1.73890457e-01f, 4.65020925e-01f, 1.26508787e-01f, -3.19066904e-02f, 1.60138592e-01f, -9.40590724e-02f,
  -3.90480965e-01f, 2.64154166e-01f, 3.67814809e-01f, 2.21800998e-01f, -4.15586531e-01f, -4.41970438e-01f, -5.87507308e-01f, -2.54459500e-01f, -6.26125276e-01f, -8.36664140e-02f,
  -1.87848151e-01f, -7.73965865e-02f, 2.59404212e-01f, -5.51770568e-01f, 2.31656075e-01f, 4.71965969e-01f, -3.80052216e-02f, 1.63242996e-01f, 4.72840786e-01f, 3.72982651e-01f,
  5.07433414e-01f, 4.21526253e-01f, 3.74560177e-01f, -2.64237702e-01f, -6.68476164e-01f, 3.87988955e-01f, -2.05201074e-01f, 2.71874845e-01f, -1.23730227e-01f, 9.83184204e-02f,
  -1.02401644e-01f, -3.52305979e-01f, 5.19030333e-01f, -2.82658517e-01f, -4.76240158e-01f, 3.80853951e-01f, -2.86626685e-02f, -1.54370397e-01f, 4.52361077e-01f, -5.80844805e-02f,
  1.31832749e-01f, -6.69222623e-02f, 5.06798327e-01f, 4.80928689e-01f, 9.44838822e-02f, 3.46278042e-01f, 5.08417711e-02f, 6.92233026e-01f, -1.70792595e-01f, -3.88594836e-01f,
  5.48016466e-02f, -2.43985131e-02f, 4.27476108e-01f, 2.26866722e-01f, -3.04853380e-01f, 5.68756759e-01f, 2.22423390e-01f, 2.44719014e-02f, -1.92966312e-01f, 2.79018073e-03f,
  8.51098076e-03f, 2.88434327e-02f, 6.88885525e-02f, 2.35323146e-01f, 2.42868200e-01f, -1.53800055e-01f, -1.03210965e-02f, 4.23919946e-01f, 7.43101165e-02f, 3.03675026e-01f,
  4.63827014e-01f, -2.86720097e-01f, -2.02314615e-01f, -4.68957037e-01f, 3.56848627e-01f, 4.78899896e-01f, -5.70504785e-01f, 5.37635267e-01f, 2.53107876e-01f, 1.60696313e-01f,
  5.23683727e-01f, 4.45923842e-02f, -1.32399946e-01f, -2.66587675e-01f, -3.95155936e-01f, 3.37868452e-01f, 6.95849299e-01f, 3.64845246e-01f, -3.50739151e-01f, -3.40315402e-01f,
  2.27130935e-01f, -1.77908182e-01f, 1.56761825e-01f, 1.34287328e-01f, 9.72328521e-03f, 2.13461518e-01f, 1.43730119e-01f, -8.02056551e-01f, -2.44785801e-01f, 4.05156046e-01f,
  1.22647777e-01f, 4.49737698e-01f, 3.08872491e-01f, 2.48385817e-01f, 5.89772761e-01f, -7.01986432e-01f, 1.52628839e-01f, 6.18276596e-01f, -5.55951238e-01f, 6.34849668e-01f,
  2.99089938e-01f, 7.26648271e-02f, 4.88930732e-01f, 2.64867693e-01f, -1.76442131e-01f, 3.31738293e-01f, -7.29951978e-01f, -7.18705654e-02f, 2.38240953e-03f, 3.18294346e-01f,
  -4.83774990e-01f, -1.88964531e-01f, 3.30736518e-01f, 1.99006215e-01f, 3.02817166e-01f, 3.14241648e-01f, 4.47493941e-01f, 3.19144666e-01f, 6.53781593e-02f, -3.84434089e-02f,
  3.16398144e-01f, 3.46190892e-02f, -4.54575449e-01f, -1.06628753e-01f, -2.14117765e-01f, 4.84664977e-01f, 1.81804061e-01f, 6.12327754e-01f, -2.67473310e-01f, -1.24208100e-01f,
  3.65086645e-01f, 1.87787086e-01f, -4.58300203e-01f, -2.79455900e-01f, -4.82496917e-01f, 3.49441171e-01f, -4.09439772e-01f, 4.51098651e-01f, 5.08724572e-03f, 2.41484046e-01f,
  2.52419233e-01f, -2.14215089e-02f, 7.04583585e-01f, 4.13272917e-01f, 2.43118145e-02f, 1.87534481e-01f, 3.63491088e-01f, 3.91599238e-01f, 2.26737306e-01f, 1.27874583e-01f,
  6.18654609e-01f, 2.07195863e-01f, 1.59824982e-01f, 1.53616965e-01f, 1.73094094e-01f, 2.62163550e-01f, 4.50848460e-01f, -1.66757584e-01f, 2.30254143e-01f, 4.58853275e-01f,
  3.58221173e-01f, -2.37866566e-01f, -4.59357388e-02f, 3.35197777e-01f, -5.20932198e-01f, -2.07359180e-01f, -2.37682641e-01f, -4.22425628e-01f, 2.58401841e-01f, -5.09005934e-02f,
  7.05525339e-01f, 5.44896424e-01f, 1.30209222e-01f, 8.23022306e-01f, 5.63605070e-01f, -2.56748497e-01f, 3.40895981e-01f, 5.04109979e-01f, 3.67118120e-01f, 3.80582213e-01f,
  2.42457017e-01f, 4.45358098e-01f, 3.04655612e-01f, 4.93954092e-01f, -1.03403507e-02f, -2.67272979e-01f, 3.31154823e-01f, 5.12071252e-01f, 3.05550009e-01f, -4.06596303e-01f,
  3.00029606e-01f, 4.87567157e-01f, 3.82714391e-01f, -2.24131301e-01f, -1.71881989e-01f, 2.95094788e-01f, 1.20256081e-01f, -1.28105387e-01f, 4.17671084e-01f, -1.16452195e-01f,
  1.82254851e-01f, -4.79184061e-01f, 5.54713309e-01f, 7.11333705e-03f, 6.04606986e-01f, 1.04036719e-01f, 6.05816662e-01f, 4.59553711e-02f, 4.03879672e-01f, -8.94152448e-02f,
  1.88842207e-01f, -2.02002507e-02f, 2.55158124e-03f, 3.83806415e-02f, 5.66476047e-01f, -2.28579402e-01f, -8.89622197e-02f, 8.29452649e-02f, 2.71323740e-01f, 5.21187961e-01f,
  5.50970793e-01f, -2.41247654e-01f, 2.68350124e-01f, 5.32120168e-01f, -2.87438840e-01f, -9.88968611e-02f, -6.25430942e-01f, 6.22969687e-01f, 3.30200553e-01f, 8.85276422e-02f,
  4.16378856e-01f, 2.36280426e-01f, -1.04170963e-01f, 4.76565033e-01f, -2.51750499e-01f, -4.17458236e-01f, -4.34906334e-01f, 4.44653749e-01f, -3.27906996e-01f, 4.20494676e-01f,
  4.54820216e-01f, 3.13491374e-01f, 3.69015038e-02f, 6.14228308e-01f, 1.51563838e-01f, 3.38634580e-01f, -2.07812354e-01f, -5.61124444e-01f, -5.01372457e-01f, -1.86963342e-02f,
  2.09290117e-01f, 1.22316014e-02f, 2.57540345e-01f, 3.33464384e-01f, 7.35407829e-01f, -3.99802655e-01f, 6.02046072e-01f, 2.24040359e-01f, -2.40060568e-01f, 2.66258478e-01f,
  2.92349368e-01f, 4.53062594e-01f, 9.37836468e-02f, 2.78089494e-01f, 3.78771365e-01f, -4.08613682e-02f, 2.81982660e-01f, -3.49848151e-01f, -2.10449770e-01f, 2.70041168e-01f,
  5.19026458e-01f, -9.20896977e-02f, -1.88328996e-01f, -3.00123952e-02f, -3.34474444e-02f, 3.01935673e-01f, -7.02546686e-02f, -3.18983734e-01f, 3.31747413e-01f, 8.04965124e-02f,
  -5.00362158e-01f, -8.27018172e-02f, 4.51950788e-01f, 2.89609879e-01f, 6.36202335e-01f, -4.63895291e-01f, 1.29002079e-01f, 6.47868514e-01f, 5.08031607e-01f, 6.33266747e-01f,
  6.28449991e-02f, 1.52236074e-02f, 3.19161206e-01f, 7.32039988e-01f, 3.52543235e-01f, -3.77378203e-02f, 1.60825431e-01f, 1.32882997e-01f, 1.92188639e-02f, -6.12093627e-01f,
  -2.45167762e-02f, 1.94348693e-01f, 2.52568424e-01f, -9.43518057e-02f, -3.63989770e-01f, 2.13244647e-01f, -7.60756209e-02f, 1.93953261e-01f, 3.82268243e-02f, -1.48959190e-01f,
  2.33565807e-01f, 1.39037475e-01f, -4.23934937e-01f, 3.86377543e-01f, -3.83798108e-02f, -5.81865013e-02f, 2.30782032e-01f, -2.60153979e-01f, -2.85256952e-01f, -3.43054861e-01f,
  2.77293622e-01f, 4.42313612e-01f, 3.37971933e-02f, 2.71903932e-01f, 3.29131544e-01f, 4.87865090e-01f, 7.22746924e-02f, -3.88343483e-01f, 3.47089291e-01f, -2.59065062e-01f,
  -8.71624276e-02f, 4.95898873e-01f, -3.88019711e-01f, 3.60767543e-01f, -4.37404990e-01f, -1.41746432e-01f, -1.10332780e-01f, 2.45513439e-01f, 2.34410718e-01f, -1.12969503e-01f,
  2.30786175e-01f, 1.36285320e-01f, 7.68838525e-02f, 9.77546498e-02f, 1.20824844e-01f, 2.64541239e-01f, 3.13913852e-01f, 3.32626849e-01f, 4.75905567e-01f, -4.06700045e-01f,
  -3.10883462e-01f, 3.54499489e-01f, -5.71343660e-01f, 1.10956365e-02f, 6.19112134e-01f, 6.07756436e-01f, 2.84075979e-02f, 7.19291046e-02f, 2.87522078e-01f, 1.50199711e-01f,
  -2.18131945e-01f, 7.37057626e-01f, -2.01390252e-01f, -1.32761389e-01f, -1.60480872e-01f, 4.20681089e-01f, -1.14061311e-01f, 8.71559262e-01f, 4.84372407e-01f, 1.48665473e-01f,
  4.42789763e-01f, 9.85401794e-02f, 5.54889560e-01f, 3.77780586e-01f, -2.26714224e-01f, 7.41133630e-01f, 2.92267114e-01f, -4.68308628e-01f, -1.09194681e-01f, -6.89444020e-02f,
  -1.77797481e-01f, 5.58838487e-01f, -1.32480726e-01f, 4.87099558e-01f, 1.24007851e-01f, 3.93597752e-01f, -5.14440477e-01f, 3.28623027e-01f, 5.92181861e-01f, -4.08414602e-01f,
  7.78213739e-01f, 3.02857161e-01f, 4.59176689e-01f, 1.17182158e-01f, -2.61510938e-01f, 6.74513638e-01f, -3.68624687e-01f, -4.97381598e-01f, -4.64877039e-02f, -4.57448781e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  2.38525286e-01f, 1.54535249e-01f, 3.85874748e-01f, 2.32631832e-01f, 3.96653801e-01f, 1.16478555e-01f, 5.21086335e-01f, 3.91995132e-01f, -5.97921684e-02f, 1.12255961e-02f,
  2.27665693e-01f, 3.97296488e-01f, 2.79491574e-01f, 2.20761821e-01f, 3.51686887e-02f, 1.81525722e-01f, 2.50341259e-02f, 1.38994500e-01f, 1.29530236e-01f, 3.64605486e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  1.09112086e-02f, 2.11789593e-01f, -2.74499897e-02f, -2.90985480e-02f, -1.35098100e-02f, -1.71582907e-01f, 3.99921536e-01f, 1.09220244e-01f, -3.37400734e-01f, 1.70175299e-01f,
  2.15034127e-01f, -5.17194271e-01f, -4.15073305e-01f, 2.76971042e-01f, -2.53084511e-01f, 3.96398932e-01f, -2.48988166e-01f, -6.83606148e-01f, 1.95567489e-01f, 4.87385631e-01f,
  3.95924956e-01f, -3.57383192e-01f, -3.51629913e-01f, -6.85619712e-01f, -5.19852996e-01f, -7.13960052e-01f, -4.23144430e-01f, 1.71519965e-01f, 3.68389904e-01f, 3.79465669e-01f,
  -1.96637034e-01f, -4.05216277e-01f, -3.74292791e-01f, -2.29575023e-01f, -1.30946878e-02f, 2.97351748e-01f, 8.37252736e-02f, 5.84479608e-02f, 5.32051384e-01f, 4.79854226e-01f,
  4.64249849e-01f, 4.63269323e-01f, 2.26485461e-01f, -5.64341068e-01f, 1.46451652e-01f, -4.14808482e-01f, -5.03189385e-01f, 9.27774385e-02f, -1.65726691e-01f, -1.53857961e-01f,
  1.84689477e-01f, -6.22357786e-01f, -5.75659350e-02f, 3.67768675e-01f, 5.17861068e-01f, -4.06379700e-01f, -9.54443693e-01f, 8.27614665e-02f, 3.08385361e-02f, 4.20088291e-01f,
  3.15579355e-01f, 1.57697480e-02f, -2.76786208e-01f, 1.59444898e-01f, 3.90637517e-02f, 3.89751755e-02f, -1.74798831e-01f, -3.96561623e-01f, 1.66021462e-03f, -2.52208322e-01f,
  3.85053784e-01f, -4.75674216e-03f, 3.74963582e-01f, -4.37345892e-01f, -3.31001669e-01f, -1.46316394e-01f, 2.64102072e-01f, -5.53824127e-01f, -3.25880706e-01f, -5.41940510e-01f,
  -4.23728734e-01f, -4.52259094e-01f, -4.89395440e-01f, -2.87140459e-01f, 3.89578521e-01f, 2.96895236e-01f, 3.56162876e-01f, -4.69868362e-01f, 3.79091442e-01f, -2.72582956e-02f,
  3.80678684e-01f, 1.18971216e-02f, 8.21848437e-02f, 1.40698403e-01f, 4.69895214e-01f, -2.68495500e-01f, 8.68788511e-02f, -1.23627298e-01f, -6.27123863e-02f, -9.61185172e-02f,
  2.98901469e-01f, 8.28653872e-02f, -4.52859312e-01f, -2.08484694e-01f, 2.32650235e-01f, 3.99055295e-02f, -1.40044034e-01f, 3.60679142e-02f, -3.18336785e-01f, 4.63320613e-01f,
  2.72297412e-01f, 2.77772844e-01f, -7.31952786e-02f, 3.00758928e-01f, -6.50495648e-01f, 5.09819388e-01f, -4.31785733e-01f, -3.09467405e-01f, -5.52080154e-01f, 6.32109791e-02f,
  -7.48381495e-01f, -7.29661942e-01f, -3.85890692e-01f, -7.18302906e-01f, -4.94625151e-01f, -3.33201915e-01f, 5.65868676e-01f, -6.73377037e-01f, -4.35030684e-02f, -1.84334978e-01f,
  2.74324447e-01f, 5.58220111e-02f, -2.15716362e-01f, -5.73947355e-02f, -5.33327281e-01f, -3.69453937e-01f, -1.99736848e-01f, 1.91116780e-01f, 4.51523274e-01f, 3.35035652e-01f,
  -6.87300563e-01f, 5.10145545e-01f, 1.77425086e-01f, 2.54610777e-01f, -2.72137642e-01f, 3.11034918e-02f, 2.91523486e-01f, -4.31170255e-01f, 2.33619707e-03f, -1.70023888e-01f,
  -1.25044778e-01f, 2.41703048e-01f, 9.40055624e-02f, 2.07460850e-01f, -2.00427920e-01f, 1.36620849e-01f, -1.97478577e-01f, -4.44062591e-01f, -1.47562817e-01f, -5.88919640e-01f,
  3.28088284e-01f, 1.52648345e-01f, 1.56222686e-01f, 1.15471661e-01f, -1.91885188e-01f, 4.42663074e-01f, -4.01718289e-01f, 3.12972128e-01f, -2.65728056e-01f, 2.35484585e-01f,
  2.73416102e-01f, 4.09658909e-01f, 1.31168127e-01f, -7.41640568e-01f, 5.59914708e-01f, 1.90045878e-01f, -2.88628452e-02f, -6.79912865e-01f, 4.16876882e-01f, 4.36938852e-01f,
  -5.77558577e-01f, -3.91350508e-01f, -1.98363811e-01f, -6.04378462e-01f, -2.81478226e-01f, 1.55960739e-01f, -4.57591563e-01f, 1.83504507e-01f, -4.76717949e-01f, -1.98762000e-01f,
  -6.27762556e-01f, 4.73625094e-01f, 1.58308700e-01f, -6.09766133e-02f, 2.21737608e-01f, 1.23235621e-01f, -1.12139568e-01f, 2.01979041e-01f, -3.68233114e-01f, -1.69157088e-01f,
  2.89770961e-01f, -5.20506620e-01f, 1.68986246e-01f, -4.67781067e-01f, 5.16825616e-01f, -4.35056269e-01f, -7.15052068e-01f, -4.56762284e-01f, -1.06483273e-01f, 2.70139903e-01f,
  1.34758517e-01f, -1.59133926e-01f, -4.96764928e-01f, -2.78461188e-01f, -4.72130835e-01f, -3.74368206e-02f, -6.68203831e-02f, 3.25028360e-01f, 4.97029454e-01f, -8.07095766e-01f,
  3.29548925e-01f, -3.73827815e-01f, 5.83236873e-01f, 4.35231119e-01f, 3.72297540e-02f, 6.08332790e-02f, -2.21490487e-01f, -7.92639554e-02f, 7.89884850e-02f, -9.58295017e-02f,
  4.74395603e-01f, -5.64881004e-02f, 4.40556556e-01f, -4.89420854e-02f, -3.65081221e-01f, -4.48479764e-02f, -4.26225781e-01f, -6.12020791e-01f, 2.66150922e-01f, 1.62752405e-01f,
  3.65664452e-01f, 3.80907118e-01f, -4.10340220e-01f, 4.46536064e-01f, -3.63764465e-01f, 3.02390844e-01f, -8.60335976e-02f, 8.15666467e-02f, 2.40997896e-01f, 3.93592805e-01f,
  -2.32801616e-01f, -5.79168260e-01f, -4.87353176e-01f, -6.87275678e-02f, -2.37981573e-01f, -3.79679948e-01f, -9.56670791e-02f, -2.16741741e-01f, -2.60840535e-01f, 8.42325110e-03f,
  1.10167615e-01f, 2.18339399e-01f, -4.61423576e-01f, 1.91834956e-01f, -2.90079296e-01f, -2.33538538e-01f, -4.18114752e-01f, -1.48143649e-01f, -3.35851938e-01f, 4.80691761e-01f,
  1.79078430e-02f, -5.19218922e-01f, -4.92979527e-01f, 1.89949244e-01f, -3.51465553e-01f, 1.08417220e-01f, 3.30313683e-01f, 5.15393555e-01f, 3.44478875e-01f, -4.21095103e-01f,
  6.64510578e-02f, -1.36247277e-01f, -3.40807825e-01f, -3.51751745e-01f, -1.42465338e-01f, 4.94762778e-01f, -3.25328350e-01f, 3.76509547e-01f, 1.07499107e-03f, 1.73752740e-01f,
  -2.13384047e-01f, 1.01734988e-01f, -3.85022648e-02f, 1.18613660e-01f, 3.27256888e-01f, -3.39014888e-01f, -2.52555490e-01f, -3.76309752e-02f, -1.73032984e-01f, 3.10377683e-02f,
  -4.78682190e-01f, -6.81425273e-01f, -2.49358848e-01f, -5.90306997e-01f, 5.92966557e-01f, -3.79418969e-01f, 2.11368248e-01f, -4.74603027e-01f, 2.74499208e-01f, -3.77967119e-01f,
  -4.60794479e-01f, -2.53764778e-01f, 5.75417817e-01f, 5.08555233e-01f, -1.18939251e-01f, 3.44620913e-01f, 2.31159002e-01f, -2.90286750e-01f, -9.14057612e-01f, -4.11608338e-01f,
  2.08485350e-01f, 1.68412074e-01f, -1.10251896e-01f, -1.96214896e-02f, 9.44338068e-02f, -3.29329772e-03f, 5.17682791e-01f, -3.51637632e-01f, 4.87399697e-01f, -1.06840804e-01f,
  -3.07855576e-01f, 2.69991159e-01f, 3.07604402e-01f, 2.19108924e-01f, -5.00089645e-01f, -2.81057835e-01f, 3.51985753e-01f, 3.54167730e-01f, -5.55352449e-01f, -3.16006184e-01f,
  -1.49613768e-01f, -5.26897788e-01f, 6.54034853e-01f, 1.86103225e-01f, -6.64045632e-01f, -6.62951410e-01f, 4.80883896e-01f, 4.49965149e-01f, -4.29769576e-01f, -3.57168406e-01f,
  7.24657625e-02f, -2.06709296e-01f, 4.55078743e-02f, 2.81804085e-01f, -1.34484321e-01f, 5.00773713e-02f, -1.50622770e-01f, -2.96424389e-01f, -3.39227259e-01f, 3.84870470e-01f,
  -3.92837703e-01f, 3.40633392e-01f, 4.24878597e-01f, 1.00443214e-01f, 4.67049092e-01f, 2.83280969e-01f, 2.65777647e-01f, -4.71458375e-01f, 3.49309385e-01f, -1.57801956e-01f,
  -5.73290586e-01f, -2.16268972e-01f, -2.66822219e-01f, -4.41594958e-01f, -2.26078540e-01f, 4.13451284e-01f, -1.21086046e-01f, -4.53021258e-01f, -4.18272763e-01f, -1.32065833e-01f,
  -3.59935373e-01f, -6.35372400e-01f, -5.29419243e-01f, 5.70501029e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  1.03446990e-01f, -3.71311121e-02f, -7.06488965e-03f, -1.04577921e-01f, -1.19822823e-01f, -2.12221295e-02f, -3.10135316e-02f, -1.56787381e-01f, 8.00215825e-02f, -2.89396700e-02f,
  -2.60096546e-02f, 4.06290554e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    