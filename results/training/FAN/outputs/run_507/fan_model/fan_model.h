/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -2.45184496e-01f, -1.00687677e-04f, 1.01340823e-01f, -8.06716532e-02f, -1.72751799e-01f, -5.82145527e-02f, 8.01343024e-02f, -9.49339867e-02f, -1.77603532e-02f, -8.19718689e-02f,
  -2.20378954e-02f, 1.22799642e-01f, 1.76590055e-01f, 2.24542692e-02f, 1.84623860e-02f, 1.26793966e-01f, -9.78652686e-02f, 2.41650008e-02f, 3.33059803e-02f, -1.86299130e-01f,
  -1.85628645e-02f, -1.60520524e-01f, 1.45532623e-01f, -1.57800600e-01f, -1.26360506e-01f, -2.62551997e-02f, -6.80805668e-02f, -2.00501662e-02f, -4.22240831e-02f, 1.18569493e-01f,
  6.50189891e-02f, 7.32794404e-02f, -3.67793180e-02f, 2.05196533e-02f, -9.65212211e-02f, -1.11730574e-02f, -8.02493654e-03f, 9.46152061e-02f, -3.25767174e-02f, -3.61883231e-02f,
  4.02171165e-02f, 1.56297050e-02f, 9.03850272e-02f, -2.93196123e-02f, -6.73721805e-02f, 5.52211283e-03f, -7.77663291e-02f, -8.25883895e-02f, -2.67204326e-02f, 1.97956292e-03f,
  1.96055099e-02f, -7.30073154e-02f, -2.78437287e-02f, 2.68999785e-02f, 2.16959510e-02f, -2.16569304e-02f, 3.68351899e-02f, 4.55736034e-02f, 9.64109320e-03f, -6.09153286e-02f,
  5.54655716e-02f, -1.48572051e-03f, 3.92287597e-02f, -7.51377875e-03f, 3.88312563e-02f, 6.30088821e-02f, -4.83108424e-02f, 9.56941992e-02f, -5.04069589e-02f, 4.52823043e-02f,
  2.07098108e-02f, -6.63318932e-02f, 3.98473069e-02f, -3.12126968e-02f, 1.30647514e-02f, -3.53829898e-02f, 8.63901079e-02f, 1.39216008e-02f, -2.62593199e-03f, 1.67005556e-03f,
  2.81779822e-02f, -2.04871651e-02f, 5.61592504e-02f, -5.23699746e-02f, 1.04159918e-02f, -1.56022040e-02f, 3.12455697e-03f, 3.88338193e-02f, -1.40705239e-02f, 6.93126023e-03f,
  -4.46179975e-03f, 2.24910397e-02f, 1.03382617e-01f, 4.63840105e-02f, 1.22146398e-01f, 1.53473215e-02f, 4.97206002e-02f, 3.64797004e-02f, 4.44273539e-02f, -5.03037237e-02f,
  -8.87493119e-02f, 5.33725508e-03f, 1.14343381e-02f, -1.75043046e-02f, 3.82078782e-04f, 8.06157826e-04f, 3.56561728e-02f, 1.22125037e-02f, 1.06334500e-03f, -3.74521391e-04f,
  -1.14650298e-02f, -2.75594126e-02f, -3.18328477e-02f, 2.08475254e-02f, -5.94635345e-02f, -4.62446176e-02f, -6.07170574e-02f, 6.91722706e-03f, 5.07038683e-02f, -8.01257491e-02f,
  -2.55927533e-01f, -9.99925807e-02f, -1.17337935e-01f, -7.68928304e-02f, 9.62885022e-02f, 1.57623827e-01f, -1.25971258e-01f, 4.85280901e-02f, -1.93464398e-01f, -2.74960380e-02f,
  2.66848616e-02f, -2.02883631e-01f, -7.38961846e-02f, 1.02714628e-01f, -1.44954696e-01f, -6.26521856e-02f, 3.39618474e-02f, 2.09878650e-04f, -3.80607247e-02f, 3.23866159e-02f,
  -3.44345234e-02f, 1.09059431e-01f, 1.08430171e-02f, 2.03443736e-01f, -3.25276963e-02f, -7.08308741e-02f, 1.01699717e-02f, 4.80113924e-02f, 1.64004922e-01f, 2.11053900e-02f,
  5.05880117e-02f, -8.83704945e-02f, -6.11021221e-02f, -3.58425751e-02f, 1.00928500e-01f, -3.39346714e-02f, -5.32149933e-02f, 2.84481850e-02f, -1.69852413e-02f, -3.15761119e-02f,
  -5.30264676e-02f, -7.80565292e-02f, 2.38813236e-02f, -7.19023356e-03f, -1.36957262e-02f, -4.03106399e-02f, -2.55818311e-02f, 7.48260394e-02f, -8.34224671e-02f, -1.02841079e-01f,
  3.97503860e-02f, -3.67531553e-02f, -2.28446256e-02f, 4.64261547e-02f, 3.28645222e-02f, -5.80010638e-02f, -5.28768674e-02f, 3.36444448e-03f, 2.58925743e-02f, 4.41187471e-02f,
  -1.47688827e-02f, -4.54459637e-02f, -5.45726940e-02f, -2.97751483e-02f, 1.16754472e-02f, 7.92443752e-02f, -7.15788826e-02f, 2.50650365e-02f, -6.52069077e-02f, -5.39842136e-02f,
  1.93282086e-02f, -5.83917880e-03f, -7.42066428e-02f, 2.46237172e-03f, 1.86578017e-02f, -6.91514611e-02f, 8.99700448e-03f, 2.14109458e-02f, -1.89077277e-02f, 6.12882189e-02f,
  -9.54578221e-02f, 1.36481710e-02f, -4.39929068e-02f, -5.20240515e-02f, 1.33853955e-02f, 1.48135014e-02f, 2.11245026e-02f, 2.19082311e-02f, -3.06319948e-02f, 5.22605367e-02f,
  1.30160496e-01f, 2.25856043e-02f, -9.01525840e-02f, 4.19758074e-02f, -2.01277398e-02f, 6.14518039e-02f, -8.12618062e-02f, 1.24321049e-02f, -4.22147550e-02f, 1.14759065e-01f,
  9.85057056e-02f, 6.42920211e-02f, -4.85687377e-03f, 9.08927768e-02f, 9.49634612e-02f, -5.65679260e-02f, -6.00601826e-03f, -1.34464656e-03f, -2.05821935e-02f, 2.90444288e-02f,
  -4.81407251e-03f, -7.06867725e-02f, -8.54971632e-02f, -4.77658864e-03f, 2.88449228e-02f, -4.60619926e-02f, -5.82814328e-02f, -6.14503622e-02f, 5.44980951e-02f, -8.26829076e-02f,
  -4.00183022e-01f, -2.40196008e-02f, -2.38091320e-01f, -8.12887549e-02f, 1.31780714e-01f, 1.78607553e-01f, 9.41409636e-03f, 4.51491326e-02f, -1.73283830e-01f, 3.87636013e-02f,
  7.86767825e-02f, -1.05692767e-01f, -4.54779267e-02f, 5.66827469e-02f, -2.08646521e-01f, -9.00262892e-02f, -8.69866163e-02f, 3.46464738e-02f, -1.70854367e-02f, -8.20123702e-02f,
  -3.35986614e-02f, 1.66557670e-01f, -8.12478885e-02f, 9.53276455e-02f, 4.95176800e-02f, -6.40241131e-02f, 4.73044813e-02f, 3.32847261e-03f, 1.51226044e-01f, -3.30774076e-02f,
  9.32739899e-02f, 1.95027073e-03f, -6.73583895e-02f, -5.62180430e-02f, -6.85700849e-02f, -2.56404635e-02f, 5.12667708e-02f, -3.42476480e-02f, -2.56823990e-02f, 2.10458823e-02f,
  -2.90721692e-02f, 7.64548331e-02f, 2.20580474e-02f, 4.82879765e-02f, 4.43618894e-02f, -8.09392408e-02f, 4.87965606e-02f, 8.81277472e-02f, 5.25965355e-02f, -1.13140140e-02f,
  1.01012290e-02f, 2.62329262e-02f, -4.39264737e-02f, 1.30705368e-02f, -1.62823834e-02f, -1.03117917e-02f, -1.31409417e-03f, 1.42032262e-02f, 8.36080872e-03f, 6.68250024e-02f,
  3.28492001e-02f, -1.37635125e-02f, 1.95380058e-02f, -3.94375436e-03f, 2.45592035e-02f, 1.59104429e-02f, 3.76334079e-02f, 2.72100940e-02f, 1.43706740e-03f, -3.89701221e-03f,
  1.81251541e-02f, 1.27778538e-02f, -1.38870757e-02f, -1.64891053e-02f, -1.65454336e-02f, -1.40634710e-02f, 1.37615688e-02f, -5.11070760e-03f, 2.97100693e-02f, -5.11649773e-02f,
  4.35011685e-02f, -9.66059603e-03f, 1.79402698e-02f, -1.77058333e-03f, 1.62681900e-02f, -7.02792453e-03f, -1.51216495e-03f, -2.78212335e-02f, -1.65410209e-02f, -2.33450606e-02f,
  -7.84928538e-03f, 1.67581532e-03f, 2.13243905e-02f, 1.09671177e-02f, 4.97977734e-02f, 2.71916594e-02f, -7.04145432e-02f, -2.15104297e-02f, 3.63834342e-03f, -4.81336005e-02f,
  -5.20904623e-02f, -2.90031321e-02f, -2.38047522e-02f, -2.83598974e-02f, -1.59490500e-02f, 1.46378847e-02f, -1.85632873e-02f, -2.26524565e-02f, 9.06099826e-02f, -2.01679152e-02f,
  8.72348323e-02f, 5.06003760e-02f, 2.22983304e-02f, 5.34163453e-02f, 6.96455985e-02f, 5.46273664e-02f, 5.12322858e-02f, 1.96844786e-02f, 4.03365679e-02f, -9.52026900e-03f,
  3.96212488e-01f, 3.62625532e-02f, 6.09158650e-02f, 8.09394568e-02f, 4.77475375e-02f, 8.14221576e-02f, -2.17603371e-02f, -2.50577945e-02f, 5.76632023e-02f, -1.34980723e-01f,
  -1.34224728e-01f, 9.87194255e-02f, -7.05353990e-02f, -1.29077435e-01f, 1.69274375e-01f, -1.28679320e-01f, -2.63325423e-02f, -5.31740151e-02f, -3.85367796e-02f, 2.10447703e-02f,
  -2.33091298e-03f, -4.64756712e-02f, 9.39360540e-03f, -9.19442847e-02f, 3.46918814e-02f, -2.58303597e-03f, -1.14096619e-01f, 3.82869206e-02f, -7.39405826e-02f, 1.28681147e-02f,
  9.01066661e-02f, -5.04555218e-02f, 1.59573916e-03f, -8.32059979e-02f, -4.92179301e-04f, 3.03891581e-02f, -1.28276190e-02f, 1.81555643e-03f, -5.04091494e-02f, -2.23601775e-04f,
  -2.33747549e-02f, -5.77026494e-02f, 3.35561484e-03f, 7.75021985e-02f, 7.47254565e-02f, -3.56367826e-02f, 5.78247756e-03f, 3.37684201e-03f, -3.25622410e-02f, -3.57416645e-02f,
  -1.25283608e-02f, 6.41940981e-02f, 3.13155055e-02f, -1.13938050e-02f, -2.20742752e-03f, -4.01970837e-03f, 3.35501437e-03f, 5.19982465e-02f, 2.67966725e-02f, 1.85304787e-02f,
  4.47248155e-03f, 1.88495796e-02f, -2.12939363e-02f, -5.79528622e-02f, -2.52126250e-02f, -5.33180572e-02f, -7.04493886e-03f, -5.55070937e-02f, 6.60053194e-02f, -1.02124527e-01f,
  4.07468751e-02f, -2.66897138e-02f, -6.96927086e-02f, 5.67689650e-02f, -1.23937428e-02f, -5.97470440e-02f, 1.64978225e-02f, -2.88078724e-03f, 1.53708985e-04f, 4.23103496e-02f,
  -7.51374438e-02f, 8.26747492e-02f, -2.16803066e-02f, -2.61849146e-02f, -7.24895000e-02f, -4.29797322e-02f, 3.95074897e-02f, -7.02152401e-02f, -7.38701522e-02f, 1.97264832e-02f,
  -9.23850909e-02f, 4.07166891e-02f, -7.59693831e-02f, 1.72781385e-02f, -5.74794747e-02f, 6.19806312e-02f, -1.17109185e-02f, 5.47550060e-02f, 1.63546018e-02f, 7.51567408e-02f,
  8.53514597e-02f, 5.03118634e-02f, -5.43016158e-02f, -7.52638429e-02f, 5.32556698e-02f, -4.78114933e-02f, -6.32601902e-02f, -3.17719504e-02f, -5.54481074e-02f, -5.78842722e-02f,
  6.42828792e-02f, -2.15703826e-02f, 3.58805507e-02f, -1.75316948e-02f, -6.33328110e-02f, 6.71385741e-03f, -1.75866522e-02f, -3.95941958e-02f, 7.59517848e-02f, 2.64183842e-02f,
  1.68664753e-01f, 7.13400468e-02f, 1.51230311e-02f, 1.44267097e-01f, -1.79920271e-01f, 8.24077353e-02f, 4.52505723e-02f, -1.12853013e-01f, 2.22976296e-03f, 7.40709156e-02f,
  5.22473678e-02f, 8.61910954e-02f, 7.32645392e-02f, 2.07617134e-01f, 1.49914503e-01f, 6.24886677e-02f, 9.37858522e-02f, 1.77535623e-01f, -1.33451715e-01f, 5.92387468e-02f,
  2.36723311e-02f, 1.82935279e-02f, -2.62019634e-02f, -1.11404590e-01f, 2.37569748e-03f, -3.86272445e-02f, 8.60014260e-02f, -1.42653465e-01f, 1.62040874e-01f, -8.47982839e-02f,
  -8.47664624e-02f, 4.84805703e-02f, -1.43479677e-02f, -3.63397375e-02f, -1.03913154e-02f, 5.13964705e-02f, 1.14148252e-01f, -5.64624779e-02f, -7.08723813e-02f, 2.15289705e-02f,
  -4.50621843e-02f, 4.78085913e-02f, -3.28213070e-03f, 2.11907215e-02f, -2.37870738e-02f, -5.40819801e-02f, -2.25041118e-02f, 5.70074208e-02f, -5.52276708e-02f, 3.83981280e-02f,
  -8.22052285e-02f, 3.64714675e-02f, -1.36647560e-02f, 1.82042718e-02f, 7.12709874e-02f, 5.15044155e-03f, -1.55171873e-02f, -1.32842539e-02f, 2.48337891e-02f, 5.25380634e-02f,
  1.35486992e-03f, 7.68930838e-02f, 3.70029099e-02f, 1.89509932e-02f, -1.05204582e-01f, -5.97634800e-02f, 7.25710988e-02f, 2.95259915e-02f, 1.21078454e-02f, -3.91341373e-02f,
  4.58606817e-02f, 1.48634296e-02f, -3.42208594e-02f, -6.34922162e-02f, 4.69931692e-04f, -3.92246433e-02f, 9.18795913e-02f, -2.35745944e-02f, 3.09989937e-02f, -7.46923387e-02f,
  8.88485536e-02f, 2.64210906e-03f, -6.43934160e-02f, 4.45933752e-02f, 5.47874756e-02f, -5.62741794e-02f, 8.37550834e-02f, 3.51366773e-02f, -4.71600741e-02f, -7.14803487e-02f,
  2.72809323e-02f, 1.02792628e-01f, -6.07110150e-02f, 3.47054154e-02f, 6.27584709e-03f, -6.77480549e-02f, 1.59669407e-02f, 5.75688034e-02f, -3.53523046e-02f, 2.72472333e-02f,
  4.23173495e-02f, 2.63859313e-02f, 2.83954386e-03f, -6.63676783e-02f, -8.03426951e-02f, 3.18111852e-02f, 7.66851306e-02f, -6.48774132e-02f, 2.08148733e-02f, -1.95811111e-02f,
  7.15638772e-02f, 7.87503794e-02f, 2.56823114e-04f, 6.50168955e-02f, 4.43155356e-02f, 5.89094013e-02f, 8.34750757e-02f, -5.22304326e-02f, -1.31728528e-02f, 2.71179937e-02f,
  1.08513467e-01f, 1.56524807e-01f, -2.45148875e-02f, 1.20604366e-01f, 5.11828884e-02f, -1.91331804e-01f, -2.32055649e-01f, 2.16717049e-01f, 5.90208247e-02f, -7.75753632e-02f,
  -1.14923241e-02f, 2.30245129e-03f, -1.19274616e-01f, 1.72538981e-02f, 9.99070778e-02f, -8.25104415e-02f, 3.10105197e-02f, -1.26895085e-02f, 7.02407584e-02f, 3.76564870e-03f,
  7.00270534e-02f, -8.35199580e-02f, 9.66218263e-02f, 9.34004188e-02f, -6.97618956e-03f, 4.64069694e-02f, 1.43728450e-01f, -1.32020846e-01f, 9.03916210e-02f, -1.14911556e-01f,
  6.88026920e-02f, 7.97401071e-02f, -5.65027222e-02f, -4.36262004e-02f, -1.49102844e-02f, -3.80030200e-02f, -4.30260189e-02f, -1.76041678e-01f, -2.15121638e-02f, -5.83673269e-02f,
  -7.56075382e-02f, 2.12458204e-02f, -2.80625783e-02f, -4.45988327e-02f, 3.20381038e-02f, 1.92729812e-02f, 5.32240085e-02f, -4.69095930e-02f, -1.50220646e-02f, 3.02304868e-02f,
  3.63529250e-02f, -1.95938423e-02f, 2.72785015e-02f, -3.65332663e-02f, 2.39915866e-02f, -6.47326633e-02f, -1.69089325e-02f, -8.86256807e-03f, 6.79067597e-02f, 6.48284256e-02f,
  -2.88701616e-02f, -1.33692112e-03f, 4.84933890e-02f, 1.12615526e-01f, -8.05205032e-02f, 4.87556234e-02f, -6.40747249e-02f, 3.75172943e-02f, -6.34159818e-02f, 2.90125459e-02f,
  7.34621510e-02f, 8.01820233e-02f, 5.56482077e-02f, -1.26960373e-03f, 7.59251369e-03f, 7.09606633e-02f, -1.37429535e-02f, 9.09003168e-02f, 7.26268068e-02f, -2.13532168e-02f,
  -2.22123082e-04f, 6.49733916e-02f, 6.88104518e-03f, 3.37072201e-02f, -2.00592633e-03f, -2.56159324e-02f, -7.55041763e-02f, -1.73074380e-02f, 4.39176634e-02f, -4.62754257e-02f,
  1.72509566e-01f, 9.08895507e-02f, 5.10042906e-02f, 2.20529549e-02f, 6.24964349e-02f, -3.40777300e-02f, 4.60372195e-02f, 4.48799692e-02f, -1.41095556e-02f, -1.68441106e-02f,
  -4.56787311e-02f, 7.66487122e-02f, -1.83894224e-02f, 2.31181737e-03f, -7.27621764e-02f, -5.54965846e-02f, -1.92517564e-02f, 7.83453789e-03f, -1.81619413e-02f, 1.24039300e-01f,
  -3.66928764e-02f, -1.59824882e-02f, -8.90369415e-02f, 2.14736890e-02f, 2.62318971e-03f, -7.89447054e-02f, 6.28374591e-02f, 2.34607011e-02f, -2.98552494e-02f, 3.88730466e-02f,
  -1.27630711e-01f, 8.07297975e-02f, -2.26494223e-01f, -9.57095698e-02f, 8.90314728e-02f, 1.28740609e-01f, 1.11960113e-01f, -2.64038090e-02f, -2.75133252e-01f, 1.75326243e-01f,
  7.85408542e-02f, -9.44191888e-02f, -1.40387320e-03f, 2.08251879e-01f, 2.69085262e-02f, -3.93431745e-02f, 1.43433541e-01f, 5.34364879e-02f, -8.05504397e-02f, 1.18796483e-01f,
  -3.73616675e-03f, 2.40461007e-01f, 1.52571127e-02f, 1.71963319e-01f, -5.68992943e-02f, -1.64178863e-01f, 1.24627605e-01f, 3.53079662e-02f, 1.52862459e-01f, 3.95278670e-02f,
  -5.59146628e-02f, -2.17116158e-02f, 4.75920830e-03f, -7.93662965e-02f, 1.42305549e-02f, -1.77741777e-02f, 7.39987865e-02f, -1.37668094e-02f, -5.10462523e-02f, -6.25741035e-02f,
  2.24779062e-02f, -1.15392860e-02f, 1.83155574e-02f, -6.54999341e-04f, -3.89331505e-02f, -1.18329033e-01f, -7.29810968e-02f, -5.80582395e-02f, -6.11551814e-02f, 4.26987745e-02f,
  -8.37447494e-02f, -3.17342882e-03f, 1.88868381e-02f, 5.27989864e-03f, -6.69914335e-02f, 4.02986212e-03f, 5.33331037e-02f, -4.40142117e-02f, -6.35874569e-02f, -5.11676334e-02f,
  -2.10046358e-02f, -7.31732994e-02f, 1.54186934e-02f, 4.26902585e-02f, 5.81451505e-02f, 7.37051666e-03f, 7.49559281e-03f, -4.24939580e-03f, -8.41905400e-02f, 9.02971849e-02f,
  1.39296940e-02f, -2.14201808e-02f, 2.94192485e-03f, 5.69343641e-02f, 2.89331656e-02f, -2.58920807e-03f, -6.84329420e-02f, 3.16670025e-03f, -3.92239317e-02f, -4.04710090e-03f,
  8.69909488e-03f, -1.78861357e-02f, 8.18519015e-03f, -6.64749509e-03f, 6.47599921e-02f, -5.14759161e-02f, -2.15698928e-02f, -2.52303183e-02f, -2.12481879e-02f, 5.90226464e-02f,
  2.65994463e-02f, 4.30094302e-02f, 3.30719687e-02f, 1.54873570e-02f, 6.59122085e-03f, 5.70262261e-02f, -3.87842916e-02f, -2.32328810e-02f, -1.18493242e-02f, -3.90500352e-02f,
  2.44855732e-02f, 8.09256583e-02f, -1.70785543e-02f, 5.32793999e-02f, 3.75976712e-02f, 7.33086318e-02f, 6.26860410e-02f, -5.14126793e-02f, 1.22621609e-02f, -5.84167475e-03f,
  7.73915574e-02f, 8.23167991e-03f, 2.01412924e-02f, 7.09418161e-03f, 8.58158097e-02f, 4.08707112e-02f, -6.30014110e-03f, -8.53617936e-02f, -1.15500893e-02f, 4.59191501e-02f,
  -9.45732817e-02f, -4.03720625e-02f, 7.85167068e-02f, -2.47016102e-01f, 8.70098080e-03f, -1.51316568e-01f, -1.64192274e-01f, -6.76379800e-02f, -1.04572110e-01f, -7.83097595e-02f,
  -1.90107256e-01f, 3.24917287e-02f, -1.29595757e-01f, -2.68226832e-01f, -6.95976317e-02f, -1.78520545e-01f, -5.36050722e-02f, -6.19211942e-02f, 3.16773616e-02f, -8.72949883e-02f,
  2.06267592e-02f, -1.25692636e-01f, -1.11188255e-01f, 5.96358553e-02f, -2.61508245e-02f, 3.69655192e-02f, -1.89644564e-02f, 9.30986926e-02f, 1.08891958e-02f, 2.01185495e-02f,
  -2.80162003e-02f, 7.12874858e-03f, 9.95990857e-02f, 6.35703951e-02f, -8.21333751e-02f, -1.41492533e-02f, 4.83080484e-02f, -3.40306647e-02f, 2.08565798e-02f, 9.98336356e-03f,
  3.22049446e-02f, 5.53582124e-02f, -1.46526832e-03f, -3.49364057e-03f, -2.17915373e-03f, 5.10264859e-02f, 6.73616156e-02f, 2.92883459e-02f, 4.96508218e-02f, -1.59973204e-02f,
  2.85689980e-02f, 4.59238216e-02f, -1.39360176e-03f, 4.04357798e-02f, -2.61300127e-03f, -2.16827877e-02f, 6.30544275e-02f, -3.05482298e-02f, 4.05013300e-02f, -6.33770134e-03f,
  -7.76098445e-02f, -5.80857173e-02f, -5.57697117e-02f, -2.67102122e-02f, -5.38430400e-02f, -4.34691040e-03f, 1.68192349e-02f, -7.04336725e-03f, 5.33637144e-02f, -8.65442902e-02f,
  1.11753391e-02f, -2.68342700e-02f, -2.60431413e-02f, 3.98837402e-02f, -9.10589844e-03f, 4.77437340e-02f, 2.03910023e-02f, -1.89817864e-02f, -6.46619173e-03f, -4.50189747e-02f,
  -6.56211451e-02f, -3.64010967e-03f, -5.44136427e-02f, 2.84724887e-02f, -5.49461208e-02f, 2.91097723e-03f, 1.09726461e-02f, 4.89023440e-02f, -5.04409820e-02f, 2.86033861e-02f,
  -1.23707950e-01f, -1.87942356e-01f, -5.42218275e-02f, 5.51021285e-02f, 2.46250089e-02f, -6.27675727e-02f, -2.83304378e-02f, 8.99381116e-02f, 1.81940999e-02f, -4.92408015e-02f,
  5.54699823e-03f, -6.71125427e-02f, 2.66458336e-02f, -2.05559190e-02f, 3.73672955e-02f, -1.07989078e-02f, -1.28013104e-01f, 5.04997596e-02f, -7.06740236e-03f, -1.45115843e-02f,
  -4.89147119e-02f, -7.69805834e-02f, 8.04755911e-02f, -3.45222317e-02f, 7.36439824e-02f, -3.11373230e-02f, 1.65047236e-02f, 8.59844834e-02f, -3.33133265e-02f, 8.88728630e-03f,
  1.06747476e-02f, -1.96241245e-01f, 1.63584247e-01f, -1.46108747e-01f, 1.23009697e-01f, 5.69935180e-02f, 1.01408072e-01f, 4.50162888e-02f, 3.01494822e-02f, -1.15783848e-02f,
  7.75389150e-02f, 2.98194140e-02f, 4.92620841e-02f, -8.71196166e-02f, -6.74568713e-02f, -1.75693020e-01f, -1.93394810e-01f, -2.12464556e-02f, -9.44053903e-02f, -7.49722794e-02f,
  -4.82709073e-02f, -7.55572245e-02f, -1.37446105e-01f, 5.18302172e-02f, 6.68082833e-02f, -3.06493510e-02f, -1.91534519e-01f, 1.35739103e-01f, 4.89547476e-02f, 3.15098576e-02f,
  6.12156503e-02f, 4.42574546e-02f, -6.74316147e-03f, 3.82227190e-02f, -2.98041608e-02f, -6.65022582e-02f, -4.61752787e-02f, 1.09853465e-02f, 2.66598854e-05f, -1.09701287e-02f,
  -2.03019362e-02f, 1.35254472e-01f, -3.12582180e-02f, 9.64303464e-02f, 2.50357594e-02f, 7.35273585e-02f, -5.10548241e-03f, -2.93805618e-02f, 9.45886225e-02f, 1.26006946e-01f,
  1.47740722e-01f, -3.06850243e-02f, 2.51361984e-03f, -1.39013007e-02f, -2.92435419e-02f, 3.80799212e-02f, 7.48843551e-02f, -2.14260500e-02f, 1.78954341e-02f, -2.93851700e-02f,
  -6.66103736e-02f, -6.42814562e-02f, 9.15735886e-02f, -5.11026802e-03f, 3.26874033e-02f, 6.90641925e-02f, 6.72474280e-02f, 7.24949539e-02f, -1.10003818e-02f, 6.18481524e-02f,
  -3.48287225e-02f, -2.75220582e-03f, -5.23740090e-02f, 2.29330715e-02f, 3.46668251e-02f, -6.17710911e-02f, 8.36507902e-02f, 6.72879517e-02f, 1.16528226e-02f, -8.65721181e-02f,
  3.62881273e-02f, 4.75786962e-02f, -5.10441698e-03f, 1.09280497e-01f, 4.99763377e-02f, -5.56405783e-02f, -3.25083956e-02f, 9.59665328e-02f, -1.26084900e-02f, -1.03165898e-02f,
  -1.27492070e-01f, -2.60498315e-01f, -7.70580247e-02f, 1.11677103e-01f, -5.55432066e-02f, 1.25214104e-02f, -2.49658362e-03f, -5.93433902e-02f, -1.49928316e-01f, 6.85898960e-02f,
  3.88768017e-02f, 1.46204103e-02f, -4.43673767e-02f, -1.85639169e-02f, -1.62704836e-03f, 1.91197153e-02f, 2.55901972e-03f, -1.02247342e-01f, -1.30241454e-01f, 3.70772518e-02f,
  -2.84012370e-02f, 5.55269197e-02f, 8.02102983e-02f, 2.26039514e-02f, 5.22798821e-02f, -5.04611665e-03f, 6.64600432e-02f, -1.96813121e-02f, 5.87993264e-02f, -7.28440285e-02f,
  2.50562757e-01f, -3.73639986e-02f, -6.62335381e-02f, -6.65757880e-02f, 4.48565185e-02f, 1.33682847e-01f, 9.19596776e-02f, -9.94129628e-02f, 5.85406413e-03f, -1.01177387e-01f,
  -6.20693974e-02f, 9.97231379e-02f, -1.53329782e-02f, -1.39831319e-01f, 2.37272218e-01f, 2.89066453e-02f, 7.35689029e-02f, 9.05211344e-02f, -8.51763189e-02f, -5.17294183e-02f,
  -2.18728054e-02f, -1.66137561e-01f, -9.53499898e-02f, -1.69311702e-01f, -5.03754131e-02f, 6.79525919e-03f, -6.29397109e-02f, -1.08617553e-02f, -5.69332764e-02f, -8.27032421e-03f,
  1.59168184e-01f, -2.35681236e-02f, -7.32077360e-02f, 6.25675917e-02f, 8.75958353e-02f, 1.26064185e-03f, -9.22780018e-03f, 1.24442847e-02f, -5.13433143e-02f, -2.80384328e-02f,
  3.03769540e-02f, -4.02848795e-02f, -2.71005537e-02f, -7.55500840e-03f, 6.10749051e-02f, -9.22380984e-02f, -2.05106344e-02f, 2.50631794e-02f, -3.55456397e-02f, -1.77566484e-02f,
  -2.91176308e-02f, -1.08703109e-03f, -6.79789856e-02f, -6.02341816e-03f, -6.44261688e-02f, -1.19897187e-01f, -5.31946421e-02f, 3.89817953e-02f, 1.63896605e-02f, 2.13102140e-02f,
  -1.48140732e-02f, 4.83468138e-02f, -8.05231035e-02f, 2.43250076e-02f, -2.24182215e-02f, -5.62036633e-02f, 5.88986203e-02f, -7.66208619e-02f, -5.68798445e-02f, -5.36692478e-02f,
  3.98483351e-02f, -9.42541100e-03f, -5.21657169e-02f, -1.22658703e-02f, -7.25006610e-02f, -4.05170210e-02f, -9.42862406e-03f, -6.00061333e-03f, -2.81991949e-03f, -1.08644068e-02f,
  -9.29914489e-02f, 4.57046330e-02f, -5.39389998e-02f, 3.41863967e-02f, 2.65198573e-03f, 1.84330456e-02f, -3.90569903e-02f, -6.22091182e-02f, -3.11299693e-02f, 8.12412575e-02f,
  1.04375139e-01f, 6.12421427e-03f, -6.69281408e-02f, 3.18529643e-02f, -7.56889209e-03f, -5.61745577e-02f, -8.02318305e-02f, -8.95964261e-03f, 3.51053402e-02f, -8.14693235e-03f,
  -1.78287737e-02f, 1.84089243e-02f, 1.30555317e-01f, -1.15968625e-03f, -3.54939746e-03f, 3.35224979e-02f, 3.98213379e-02f, 4.98158671e-02f, 4.44995351e-02f, 4.09470871e-03f,
  -1.04040354e-01f, 7.46181875e-04f, -1.17310807e-02f, -5.64861931e-02f, -2.88745034e-02f, -3.14679113e-03f, 1.36136472e-01f, 3.21467035e-03f, 1.78196169e-02f, -8.63977596e-02f,
  3.35994959e-02f, -1.10296339e-01f, 6.01900145e-02f, -1.37822747e-01f, -2.61455458e-02f, 1.58942223e-01f, 1.29051775e-01f, -6.49454519e-02f, 6.33567497e-02f, -1.55553430e-01f,
  -3.73131083e-03f, 2.24455260e-02f, 7.17442706e-02f, -1.56764276e-02f, -3.14489342e-02f, 2.36755893e-01f, -1.76465839e-01f, -3.40904631e-02f, 1.96016997e-01f, -1.75126091e-01f,
  3.43505107e-02f, -1.89038008e-01f, -8.76238197e-03f, -2.64956243e-02f, -1.04547217e-01f, -6.50884137e-02f, -1.55067578e-01f, 5.09323590e-02f, -1.60710290e-01f, -1.58007927e-02f,
  3.59415188e-02f, 1.16876727e-02f, -1.53284157e-02f, 6.68599010e-02f, 1.78867690e-02f, 3.13635059e-02f, 3.69592890e-04f, 8.57190564e-02f, 4.83975299e-02f, 1.06912553e-01f,
  -1.11143067e-02f, -2.94005014e-02f, -6.40589297e-02f, -2.87459306e-02f, -5.02285510e-02f, 4.69142385e-02f, 6.66169748e-02f, 5.56280389e-02f, 5.80920326e-03f, 7.04133064e-02f,
  -1.78194027e-02f, 3.29400562e-02f, -4.24158759e-02f, -6.56725233e-03f, 6.24436438e-02f, -5.79146110e-02f, -4.89260666e-02f, -5.16697690e-02f, 5.06230853e-02f, -8.72119796e-03f,
  -6.35871962e-02f, -1.39267258e-02f, 5.67741655e-02f, 8.24742690e-02f, -3.77328768e-02f, 3.38267535e-02f, -3.04191038e-02f, -4.61378433e-02f, 6.61593676e-03f, 1.11183571e-02f,
  -4.32579778e-02f, 5.10131381e-02f, -8.17360803e-02f, 9.70587693e-03f, -1.23699922e-02f, -8.78245756e-03f, 6.63000047e-02f, -2.57821511e-02f, -1.42469173e-02f, 2.99765300e-02f,
  -6.38660118e-02f, 2.95990128e-02f, 3.29375006e-02f, -1.56028569e-02f, 5.73448166e-02f, 9.18342546e-02f, -1.99711937e-02f, 9.60212015e-03f, -3.62952128e-02f, -2.59660147e-02f,
  -2.24443898e-02f, -6.57028407e-02f, -2.39509903e-02f, 2.05392763e-02f, -3.16225924e-02f, 2.36038794e-03f, -6.21877797e-02f, -1.47819454e-02f, -3.80331129e-02f, -4.41414826e-02f,
  -9.87703577e-02f, 2.61672139e-02f, 5.98440245e-02f, 1.52578745e-02f, 6.22370802e-02f, 1.53854033e-02f, 6.32395153e-04f, 2.21306458e-02f, -3.36980969e-02f, -5.47972806e-02f,
  -1.47556551e-02f, 4.38769683e-02f, -5.35196140e-02f, -6.58491477e-02f, -2.85982043e-02f, 2.66651879e-03f, -1.38411252e-02f, 1.14807613e-01f, -4.54218388e-02f, -6.51600882e-02f,
  2.50352472e-01f, -1.29535586e-01f, -1.16409935e-01f, 1.90390363e-01f, 1.73562691e-02f, 1.30459547e-01f, 1.66457847e-01f, 2.71632466e-02f, 1.71498954e-01f, -8.15663636e-02f,
  1.42890349e-01f, -1.13695130e-01f, -1.13452328e-02f, 1.41646415e-01f, 2.52942383e-01f, 1.17302639e-02f, 2.29720652e-01f, -5.78856394e-02f, 3.73390950e-02f, 4.47541196e-03f,
  1.02510951e-01f, 2.35920176e-01f, 1.56351030e-02f, -4.06611152e-03f, -6.70125932e-02f, -1.80128142e-01f, 3.07266396e-02f, -1.23885334e-01f, 6.21993328e-03f, -6.09375574e-02f,
  5.77446632e-02f, -8.20834413e-02f, 3.39790694e-02f, -2.89351121e-02f, -1.71752963e-02f, -6.07391559e-02f, -3.51004489e-02f, -6.08886667e-02f, -3.17395292e-02f, -8.02650899e-02f,
  -6.38301596e-02f, 1.53154053e-03f, 7.44062290e-02f, -2.51269024e-02f, 6.19430318e-02f, 6.61517233e-02f, -5.17671406e-02f, -2.25367174e-02f, -1.87297969e-03f, -4.98723518e-03f,
  6.42421562e-03f, -9.85236838e-03f, 8.16092789e-02f, -1.65297780e-02f, -6.02343082e-02f, 1.10599482e-02f, 2.76754680e-03f, -4.28061672e-02f, -7.85766263e-03f, 3.60395713e-03f,
  -4.49988917e-02f, 2.20213868e-02f, -2.00932305e-02f, 3.54681984e-02f, 6.35646507e-02f, 7.12100267e-02f, -2.29856856e-02f, 2.61942167e-02f, -7.16840774e-02f, 1.54141290e-02f,
  -1.64513960e-02f, 2.08698492e-02f, -2.32591745e-04f, 5.13523631e-03f, -3.67057696e-02f, -1.32065024e-02f, -4.16868075e-04f, -6.97673112e-02f, -4.14244160e-02f, -1.72845963e-02f,
  4.42824550e-02f, -4.60649515e-03f, -7.18092397e-02f, -6.58305883e-02f, 3.92427854e-02f, 8.51352513e-03f, -2.50071306e-02f, -1.09983115e-02f, 4.97759692e-02f, 4.19344800e-03f,
  -8.77067000e-02f, 6.28753006e-02f, -6.94697574e-02f, 4.53620404e-02f, -1.70598160e-02f, 4.91324365e-02f, 9.52702686e-02f, 5.03997244e-02f, 1.06541462e-01f, 3.18901576e-02f,
  -9.36608296e-04f, -7.60736130e-03f, -5.60777709e-02f, -2.54558790e-02f, 3.94321382e-02f, -1.26148425e-02f, 6.44584466e-03f, 1.54862534e-02f, 6.56232461e-02f, 1.61771420e-02f,
  -7.42801204e-02f, -4.29501981e-02f, -1.05525460e-02f, -1.81440972e-02f, -3.59011628e-02f, -2.88013071e-02f, 3.36996578e-02f, -2.39045406e-03f, -5.93779758e-02f, -4.64491546e-02f
};

// L0_fan_Wp_bar (Shape: 40 x 120)
const int L0_fan_Wp_bar_rows = 40;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -3.29575688e-01f, 3.49917822e-02f, 1.43577471e-01f, -1.52432337e-01f, -2.36228425e-02f, -1.70056269e-01f, -1.63141802e-01f, 8.24271739e-02f, 1.38655365e-01f, 1.53124288e-01f,
  2.82373261e-02f, 4.10545655e-02f, 1.28293484e-01f, -4.73759398e-02f, -2.16200575e-01f, 6.22086180e-03f, -2.53899515e-01f, -9.70170945e-02f, -9.63535607e-02f, -1.87656537e-01f,
  1.36328721e-02f, -1.16718605e-01f, -1.65508389e-01f, 9.86070037e-02f, 2.10665688e-02f, 8.00789818e-02f, -6.76010549e-02f, -2.73046792e-02f, -8.96993428e-02f, -1.77980158e-02f,
  -8.39773193e-03f, 9.28381979e-02f, 6.49066195e-02f, 9.62239131e-02f, -4.44333144e-02f, -5.56435846e-02f, -1.13936119e-01f, -2.30155773e-02f, -8.42572376e-02f, 1.02211526e-02f,
  -5.56788854e-02f, 5.93004264e-02f, -2.73948573e-02f, 2.18787268e-02f, 1.17751315e-01f, 3.04383077e-02f, 2.84502394e-02f, 3.88211124e-02f, 7.32332394e-02f, 1.18624255e-01f,
  -2.43805237e-02f, 7.51048252e-02f, 1.66828167e-02f, 4.22715172e-02f, 2.12257300e-02f, 5.64835891e-02f, -2.54562218e-02f, 5.36667295e-02f, 1.06100775e-02f, 4.32664156e-03f,
  7.62460679e-02f, 1.30726947e-02f, -6.47920024e-05f, 3.18119600e-02f, 1.72841866e-02f, 2.52589006e-02f, -1.52421752e-02f, -1.01620361e-01f, -2.67138183e-02f, -9.60747339e-03f,
  2.21376470e-03f, 5.40410616e-02f, 4.71800640e-02f, -3.19460407e-02f, -1.21156953e-01f, -4.20626774e-02f, -1.02308039e-02f, -2.16565188e-02f, -4.93370034e-02f, -2.15075780e-02f,
  -1.72861367e-02f, -8.33375156e-02f, 9.58512574e-02f, -8.04821923e-02f, 8.89805425e-03f, -7.01433867e-02f, 9.62560400e-02f, -3.81816886e-02f, -1.84128210e-02f, 1.60478503e-02f,
  -2.62275487e-01f, 6.37281835e-02f, -6.60215095e-02f, 1.11285254e-01f, -9.40411016e-02f, -3.37734334e-02f, 5.70574626e-02f, -5.06340638e-02f, -5.94472811e-02f, 7.00251535e-02f,
  1.73144788e-02f, -8.07433203e-03f, -1.05351642e-01f, -4.02429402e-02f, -2.69185789e-02f, -2.50868760e-02f, -2.36661062e-02f, -7.33129904e-02f, -1.55095562e-01f, 3.20313871e-02f,
  2.74874624e-02f, -1.59292412e-03f, 1.67179003e-03f, -3.21479328e-03f, -7.29135200e-02f, 1.53082898e-02f, -1.35915345e-02f, -6.01116642e-02f, -3.57265063e-02f, 3.50597426e-02f,
  1.57807410e-01f, -1.62970245e-01f, -1.34408712e-01f, 1.30151808e-01f, -3.14904116e-02f, -1.69697672e-01f, -8.48536938e-02f, 7.10664541e-02f, -1.49949968e-01f, -1.34094909e-01f,
  1.12480782e-01f, -1.05352983e-01f, -1.81648463e-01f, -2.54755951e-02f, 1.98034763e-01f, -1.91201210e-01f, 3.48442942e-02f, -3.68149430e-02f, -8.86557065e-03f, 2.08986010e-02f,
  1.44124581e-02f, 1.61218882e-01f, 1.98662177e-01f, 2.85763949e-01f, 6.12656996e-02f, 1.32172003e-01f, 1.57725886e-01f, 4.56546694e-02f, 1.27071723e-01f, 9.37299579e-02f,
  9.30073634e-02f, -4.96655405e-02f, -5.53206466e-02f, 2.24631783e-02f, -1.52311637e-03f, 9.58376899e-02f, -4.55997773e-02f, 5.72464392e-02f, -9.98172723e-03f, -1.04826689e-02f,
  -7.04978183e-02f, 4.07563336e-02f, 1.63800865e-02f, 5.73318824e-02f, -1.01232575e-02f, -2.48261844e-04f, -1.50930762e-01f, -8.99636000e-02f, -2.02384114e-01f, 1.71646085e-02f,
  -5.88060319e-02f, -6.61558360e-02f, -1.10142514e-01f, -3.01245302e-02f, -7.45147988e-02f, -6.65402189e-02f, -7.63295442e-02f, -1.66699290e-02f, -5.14991432e-02f, -6.59056082e-02f,
  -4.27127481e-02f, 5.68951331e-02f, -5.79297878e-02f, 6.19641505e-03f, 9.91188437e-02f, -1.14594707e-02f, -6.89043701e-02f, -3.44916135e-02f, -2.21357234e-02f, -6.08657300e-02f,
  -3.64472270e-02f, 8.10607243e-03f, -9.73583460e-02f, 3.74088809e-02f, 8.84625092e-02f, -6.95334096e-03f, 4.35715355e-02f, -9.28563718e-03f, 6.66622370e-02f, -3.19686495e-02f,
  -6.81234151e-02f, 6.66904300e-02f, -4.79835272e-02f, -6.01609088e-02f, -1.44390520e-02f, 3.82740125e-02f, 2.24443655e-02f, 8.21836144e-02f, 5.41016199e-02f, 1.59796923e-02f,
  1.32426947e-01f, 1.49302572e-01f, 3.44148353e-02f, 2.29278840e-02f, 8.23371112e-02f, -1.67635526e-03f, 3.81228812e-02f, 8.15018371e-04f, 1.76046193e-02f, 5.33534065e-02f,
  -8.13355818e-02f, 9.05587450e-02f, 1.32354638e-02f, 1.24324998e-02f, -2.17924304e-02f, 6.54973835e-02f, 6.16200268e-02f, 7.45224431e-02f, -1.20722368e-01f, -1.85460746e-02f,
  -1.64393317e-02f, -8.71619880e-02f, -1.18271327e-02f, -2.23775348e-03f, -3.79910283e-02f, 4.67528328e-02f, 6.12146743e-02f, -1.85450744e-02f, -9.24975518e-03f, -9.04317573e-02f,
  -6.33340552e-02f, 3.35393965e-01f, 1.15771465e-01f, -1.34052411e-01f, 5.47137447e-02f, -7.03643113e-02f, -7.25139230e-02f, 7.34235868e-02f, -1.44847825e-01f, 1.59055397e-01f,
  -8.29273835e-02f, 2.13307619e-01f, -3.54257785e-02f, -2.32319891e-01f, -4.30302590e-01f, -2.61011481e-01f, -2.38968849e-01f, -5.20007238e-02f, -9.15698782e-02f, 2.05911137e-02f,
  -1.40346065e-01f, -2.29350314e-01f, -2.49966204e-01f, 8.32210854e-02f, 1.51118100e-01f, 5.06667867e-02f, -1.34280222e-02f, 1.09374672e-01f, 1.53974354e-01f, -8.28427300e-02f,
  7.67322406e-02f, -1.26747742e-01f, 1.27763286e-01f, -6.01404123e-02f, 1.43181086e-02f, 1.03699677e-01f, 1.14493951e-01f, -1.08724877e-01f, 1.57187525e-02f, 6.08925596e-02f,
  3.71561497e-02f, -1.75525509e-02f, 6.24577561e-03f, -4.11575064e-02f, -2.13070624e-02f, -3.11027225e-02f, 7.07601830e-02f, 1.20241068e-01f, -2.17106789e-02f, 8.21326673e-02f,
  2.02744678e-02f, 1.07949087e-02f, 4.67751399e-02f, 2.59144939e-02f, -9.85293984e-02f, -7.11416304e-02f, -4.32992093e-02f, 4.70292345e-02f, 1.38361111e-01f, 1.59028471e-02f,
  3.72603815e-03f, 1.42247481e-02f, 3.07425354e-02f, -4.64020483e-02f, -9.32697207e-02f, 7.24658836e-03f, 1.80507619e-02f, 5.38623221e-02f, 5.03157936e-02f, 4.10049111e-02f,
  -4.25586626e-02f, 5.94605207e-02f, -9.61403996e-02f, 2.67788395e-02f, 6.11626394e-02f, -3.72171402e-03f, 1.18795009e-02f, -5.17345034e-02f, -2.14768797e-02f, -1.63161904e-02f,
  5.76485060e-02f, -9.71012705e-05f, -5.69378361e-02f, -1.58495168e-04f, -8.54379237e-02f, -2.28462229e-03f, 8.81271157e-03f, -6.99428394e-02f, 2.67153773e-02f, -6.31154850e-02f,
  -8.52111652e-02f, -1.34841770e-01f, 2.81686895e-02f, -5.36305010e-02f, -7.94462040e-02f, 3.32176161e-04f, -7.97261298e-02f, 6.51964247e-02f, 2.62463633e-02f, -4.27696966e-02f,
  1.59653574e-01f, 1.21618342e-02f, 7.69309700e-02f, -3.33705358e-02f, -6.16413988e-02f, 5.22504412e-02f, -1.11851275e-01f, -7.02431053e-02f, 1.31114936e-02f, -8.53822604e-02f,
  4.61412445e-02f, 7.63977598e-03f, 1.93913758e-03f, -8.81964788e-02f, 5.69730699e-02f, 3.55622210e-02f, 3.81861217e-02f, 5.57800643e-02f, -2.17552632e-02f, 6.42363634e-03f,
  3.33247811e-01f, -2.66075492e-01f, -5.58102280e-02f, 2.05491185e-01f, 2.04476207e-01f, -2.11701002e-02f, 1.72027588e-01f, 1.00695558e-01f, 1.07497573e-01f, -1.19649500e-01f,
  -2.92710867e-02f, -2.10164890e-01f, -1.42566338e-01f, -7.45979771e-02f, 1.23990498e-01f, -2.24094734e-01f, 4.56771441e-02f, -9.85872224e-02f, -2.48908401e-02f, -8.20707828e-02f,
  1.49965048e-01f, 1.08664289e-01f, 8.31050500e-02f, -3.87139618e-02f, 9.46981013e-02f, -1.60056390e-02f, 1.25117421e-01f, -1.59125343e-01f, 6.47611022e-02f, 3.12413108e-02f,
  1.18054338e-01f, -8.76494423e-02f, 1.30581826e-01f, -7.16945007e-02f, 4.09536064e-02f, 3.96625977e-03f, 1.96468681e-02f, 4.43307981e-02f, 3.15659903e-02f, -9.62636322e-02f,
  -1.44929782e-01f, -3.75474128e-03f, 2.83787008e-02f, -1.25537077e-02f, 5.37170470e-02f, 7.73497149e-02f, 2.11107228e-02f, -6.31999746e-02f, -9.95373279e-02f, -8.42471123e-02f,
  -6.61303997e-02f, -1.30429804e-01f, -5.09476326e-02f, -2.57846769e-02f, 3.34679009e-03f, 3.98988985e-02f, -7.93279335e-02f, -1.15305930e-01f, -5.52442893e-02f, 4.59235981e-02f,
  -9.94227752e-02f, 2.88574435e-02f, 1.72834694e-02f, -3.20628565e-03f, 6.34641275e-02f, 1.33996885e-02f, 9.83154867e-03f, -9.15833563e-02f, 1.19168289e-01f, -1.67476595e-03f,
  5.60992286e-02f, -8.31895992e-02f, 4.25028950e-02f, -3.90364677e-02f, 2.76970901e-02f, 4.75324653e-02f, 8.91678929e-02f, -3.64406481e-02f, 4.12466787e-02f, 2.04344820e-02f,
  -5.89947850e-02f, 7.72991851e-02f, -6.60228077e-03f, 7.16812760e-02f, 3.58961523e-03f, -3.08825746e-02f, 3.75890918e-02f, -9.23474208e-02f, 7.41547393e-03f, -5.68716004e-02f,
  -1.34571612e-01f, -2.53256619e-01f, -5.70087843e-02f, -3.59538533e-02f, 4.91815321e-02f, -5.75321540e-02f, -1.99029539e-02f, -4.31680642e-02f, -1.52968541e-02f, -4.01935503e-02f,
  -3.79722677e-02f, 5.58441579e-02f, -2.55344361e-02f, -1.75496005e-02f, 6.93696812e-02f, -5.41568920e-02f, -8.07803869e-02f, 7.45009556e-02f, -5.57707436e-03f, -7.29882196e-02f,
  4.50139791e-02f, -9.90526378e-02f, 1.10666240e-02f, -4.36578318e-02f, -7.14659039e-03f, 1.76189723e-03f, 7.81558007e-02f, 1.12749495e-01f, -8.40926394e-02f, 1.34027330e-02f,
  -1.52208969e-01f, 1.10767327e-01f, -1.11346662e-01f, -6.27477691e-02f, -1.70309946e-01f, 3.15187752e-01f, 3.31603050e-01f, -1.80316180e-01f, 9.52141453e-03f, 3.51746917e-01f,
  2.47296974e-01f, -1.16676621e-01f, 1.93602428e-01f, 1.96866587e-01f, 8.14424828e-02f, 1.14051566e-01f, 1.54322863e-01f, 2.19777584e-01f, -1.65046662e-01f, -1.13443218e-01f,
  -5.30410521e-02f, 1.97691664e-01f, -1.38454601e-01f, -1.53337613e-01f, -7.37309605e-02f, -2.44784936e-01f, 3.23173515e-02f, -1.61745444e-01f, -3.00970804e-02f, 6.77358508e-02f,
  -1.40693486e-02f, -5.87742478e-02f, 3.15970890e-02f, -2.72040516e-02f, -1.19755477e-01f, -4.83885631e-02f, -8.63976218e-03f, -5.60559295e-02f, -3.75333242e-02f, -1.06668677e-02f,
  1.90334562e-02f, -4.97938432e-02f, 7.71236271e-02f, -1.73754543e-02f, -8.25837851e-02f, 1.45805571e-02f, -1.00707088e-03f, 3.93988565e-02f, 9.22810659e-03f, -6.31290674e-02f,
  -1.05325617e-01f, -7.91422352e-02f, -1.03882579e-02f, 1.08670868e-01f, -1.93753056e-02f, 2.23272038e-03f, 1.07383765e-01f, -3.31668034e-02f, 1.28466174e-01f, 1.02064652e-04f,
  -9.27700102e-03f, -7.67087713e-02f, 5.87454364e-02f, -4.29367982e-02f, 1.57596301e-02f, 2.67393310e-02f, 9.10864919e-02f, -5.42753115e-02f, -7.75416866e-02f, -2.72452692e-03f,
  -2.73671113e-02f, 6.65153787e-02f, 4.93416227e-02f, 2.92506646e-02f, 4.04645540e-02f, 4.97872345e-02f, -2.26186328e-02f, -1.42363701e-02f, -3.12381587e-03f, -4.58198786e-02f,
  -5.15772514e-02f, 1.48629630e-03f, 1.59031805e-02f, 1.16156153e-01f, -2.40012649e-02f, -4.41145971e-02f, -4.54112813e-02f, 4.68253046e-02f, 1.19459495e-01f, 1.49341468e-02f,
  9.66560021e-02f, 5.16437739e-02f, -1.68978143e-02f, 8.93103853e-02f, -1.02598123e-01f, 7.66581893e-02f, -3.92654687e-02f, -4.90090698e-02f, -1.49617100e-03f, -2.07415503e-03f,
  3.40791568e-02f, -9.58316086e-04f, 3.48731130e-02f, 1.32646356e-02f, 1.24055380e-02f, 5.95685318e-02f, -4.48896550e-02f, 1.88952442e-02f, -5.60335219e-02f, -4.04883325e-02f,
  -9.05516669e-02f, 1.10788874e-01f, 2.21775062e-02f, 1.46391587e-02f, 3.13130207e-02f, 5.38602192e-03f, 2.30688676e-02f, 4.34126854e-02f, -4.59269173e-02f, 2.25259345e-02f,
  -5.03903568e-01f, 2.93667793e-01f, -7.98614100e-02f, -1.21289611e-01f, 7.00675547e-02f, -7.33285621e-02f, -1.45676106e-01f, 3.61807644e-02f, 9.14036781e-02f, 7.79755712e-02f,
  1.32189160e-02f, -1.18254028e-01f, 1.09757684e-01f, -3.45853828e-02f, -8.48382190e-02f, 6.10699579e-02f, -1.23874418e-01f, -1.78952545e-01f, 1.54539958e-01f, -6.66329488e-02f,
  -5.86018413e-02f, 6.19421303e-02f, -9.49320197e-03f, 1.73682317e-01f, -7.94099867e-02f, -4.70317602e-02f, -8.59178603e-02f, 5.67299053e-02f, -5.25768436e-02f, 2.76469439e-02f,
  -2.62900919e-01f, -2.61760861e-01f, -1.00121483e-01f, -1.41634434e-01f, -9.69373658e-02f, -6.82867840e-02f, -1.79191694e-01f, -7.63765723e-02f, 1.57991834e-02f, 4.03646752e-02f,
  -5.53294905e-02f, -3.05052679e-02f, 2.54258011e-02f, 1.21240178e-02f, 2.64890119e-03f, 5.68844639e-02f, 1.08119406e-01f, -1.10984392e-01f, 3.32057290e-03f, 7.94572234e-02f,
  3.44431885e-02f, 2.74477117e-02f, -4.85201739e-02f, 2.02433672e-02f, 4.11797389e-02f, -6.62011951e-02f, 2.06165686e-02f, -1.14549369e-01f, -1.70162752e-01f, -7.04061985e-02f,
  2.96011735e-02f, -2.80306228e-02f, 6.11628741e-02f, 3.14683244e-02f, 6.14412613e-02f, -1.61316413e-02f, -9.12611112e-02f, 2.85941008e-02f, -4.93988059e-02f, -2.78826766e-02f,
  -6.37794435e-02f, -3.39341424e-02f, -2.58629732e-02f, -1.32569849e-01f, -4.96378429e-02f, -4.60292846e-02f, -9.80113149e-02f, -9.85670686e-02f, -2.44535785e-02f, -9.71632153e-02f,
  3.17500741e-03f, 1.26182940e-02f, 2.33696718e-02f, 3.43513601e-02f, -8.74652155e-03f, -3.43583599e-02f, -4.57617901e-02f, 7.56227830e-03f, -7.62889860e-04f, 2.01076940e-02f,
  -4.55925226e-01f, -3.77179861e-01f, 4.06448729e-02f, 1.16332900e-02f, -7.46068358e-02f, -2.49334648e-02f, -2.51748431e-02f, -6.38796464e-02f, -7.60233402e-02f, 2.03891173e-02f,
  -7.28207454e-02f, -3.81231569e-02f, -5.93245998e-02f, -1.04635902e-01f, -3.52073386e-02f, -1.66310631e-02f, 4.55546230e-02f, 1.40662771e-03f, -1.66103840e-01f, 2.68549453e-02f,
  -9.13405418e-02f, -6.73905984e-02f, 9.72192083e-03f, 4.61233035e-02f, -1.10112995e-01f, -7.79149830e-02f, -1.09632574e-01f, -3.59639451e-02f, -2.70226151e-02f, 1.53541751e-02f,
  2.51395047e-01f, -7.54410475e-02f, 1.46559015e-01f, 2.09426507e-02f, 8.42103735e-02f, 5.28024919e-02f, 1.46405518e-01f, -9.13265795e-02f, 8.76536779e-03f, -1.69121400e-01f,
  -6.12585805e-03f, 4.72508669e-02f, -6.08739108e-02f, -1.09249994e-01f, 2.25855410e-01f, -1.58572569e-01f, -1.01770870e-01f, -6.98532313e-02f, -1.33699086e-02f, -1.64676815e-01f,
  8.63850713e-02f, -2.05139115e-01f, 1.03702703e-02f, -3.78334261e-02f, 1.79407317e-02f, 4.93555106e-02f, 1.12953052e-01f, 8.15089568e-02f, -1.36388183e-01f, 1.02794275e-01f,
  -6.59091473e-02f, 5.87029802e-03f, -5.04555143e-02f, -1.33510783e-01f, -4.57827523e-02f, 9.03743580e-02f, -5.13930572e-03f, 1.26002192e-01f, 2.97595058e-02f, -4.13643345e-02f,
  1.23961810e-02f, 3.94560769e-02f, -5.44481725e-02f, 1.21554233e-01f, -3.32222730e-02f, 2.07245313e-02f, 6.99473452e-03f, -6.34634644e-02f, 7.10021257e-02f, -7.65130445e-02f,
  3.10523473e-02f, -7.77871758e-02f, 2.87909675e-02f, 9.53240618e-02f, 4.43488397e-02f, 2.58188900e-02f, 4.11356613e-02f, 3.33084613e-02f, -1.45919370e-02f, -3.09929177e-02f,
  3.62292267e-02f, 1.60240405e-03f, 7.39357322e-02f, 3.59044448e-02f, -5.01015745e-02f, 6.27037436e-02f, -5.67184165e-02f, -5.75397350e-02f, -1.01443745e-01f, -1.49434842e-02f,
  6.35903850e-02f, 8.20823573e-03f, -3.81371938e-02f, 8.91142339e-02f, -5.17414846e-02f, 1.88506264e-02f, 8.05550665e-02f, -3.19982618e-02f, 6.85070455e-02f, -3.47728166e-03f,
  -1.79477483e-02f, 1.83249731e-02f, 2.02456973e-02f, 1.07634731e-01f, 4.64903042e-02f, -2.04174034e-02f, 2.87236013e-02f, 7.65406340e-02f, -7.93670788e-02f, -7.49033093e-02f,
  -2.00516641e-01f, -3.33506942e-01f, 4.28168327e-02f, -1.90695867e-01f, 5.43708093e-02f, -7.99936354e-02f, -4.18660492e-02f, -9.29973647e-02f, -1.46450251e-01f, -3.59441675e-02f,
  -5.91673292e-02f, 6.73413947e-02f, -6.12638779e-02f, 1.72113869e-02f, -6.78509176e-02f, 9.79860313e-03f, -7.80410916e-02f, -1.45884335e-01f, 2.33489778e-02f, -4.18322124e-02f,
  -2.43173223e-02f, 4.50892150e-02f, 4.24949042e-02f, 1.02122612e-01f, -3.69745269e-02f, 1.58327874e-02f, -5.23099080e-02f, -2.37035323e-02f, 3.46920942e-03f, 5.21378405e-02f,
  -1.58408701e-01f, 1.23770535e-01f, 1.03012025e-01f, 3.59837532e-01f, -1.34663433e-01f, -2.87508249e-01f, -1.41172931e-01f, 5.69458716e-02f, -6.02444075e-02f, 1.15567381e-02f,
  -2.68447050e-03f, -6.75653741e-02f, 4.23045456e-02f, 1.93619788e-01f, 7.03396797e-02f, 8.58035535e-02f, 9.46325660e-02f, -9.62743759e-02f, 7.44336545e-02f, 1.47420734e-01f,
  1.15819499e-01f, 5.41819595e-02f, 1.77409157e-01f, 1.40972912e-01f, -6.34504436e-03f, 9.57463831e-02f, 2.97906369e-01f, 1.14040472e-01f, 8.31562281e-02f, 1.63215250e-02f,
  2.96623763e-02f, 1.89730480e-01f, -9.54502225e-02f, -1.14010572e-01f, 8.59804973e-02f, -1.92307718e-02f, 4.16533537e-02f, 1.22298580e-02f, -4.37522158e-02f, 1.06483847e-01f,
  -6.49644285e-02f, -4.25275713e-02f, -1.26384795e-01f, -1.75515395e-02f, -1.19242087e-01f, -3.09028532e-02f, -1.03508025e-01f, -2.06575450e-02f, -1.98162645e-02f, -4.84017916e-02f,
  -1.81068610e-02f, 1.96695887e-02f, 6.97935894e-02f, 1.23385951e-01f, 7.43430061e-03f, -6.31717443e-02f, 5.23809418e-02f, -5.20643778e-03f, 2.76868083e-02f, 7.21206740e-02f,
  8.24861377e-02f, -5.94601687e-03f, -7.71058425e-02f, -5.23274839e-02f, -6.89407885e-02f, 1.13642745e-01f, -4.21060957e-02f, -9.60457921e-02f, 6.94064051e-02f, 1.44583201e-02f,
  -1.08070550e-02f, -2.32562353e-03f, -7.74962781e-03f, -3.30929086e-02f, -2.00442318e-02f, 5.29082958e-03f, -1.76431742e-02f, 2.94132475e-02f, 9.14302375e-03f, -2.56255027e-02f,
  1.72484927e-02f, -1.15325917e-02f, 1.05977595e-01f, 9.77778658e-02f, -9.56255198e-03f, 9.03008506e-02f, 1.16862811e-01f, -5.02952263e-02f, -3.61844748e-02f, -5.66711165e-02f,
  1.53897673e-01f, 3.48623902e-01f, 2.02259459e-02f, -7.17293471e-02f, 7.87879154e-02f, -6.36666194e-02f, -1.22388806e-02f, 3.21022719e-02f, 1.76251948e-01f, -6.46579487e-04f,
  -3.41168754e-02f, -2.37413328e-02f, 5.73999025e-02f, 2.97012515e-02f, -1.76786557e-02f, 1.48288189e-02f, 1.45303473e-01f, 8.72154310e-02f, 1.26748502e-01f, 1.01822376e-01f,
  9.52074826e-02f, 2.98816208e-02f, -3.41622271e-02f, -1.02927029e-01f, -1.91562958e-02f, 6.63771927e-02f, 2.44167559e-02f, 1.25895790e-03f, 6.97495192e-02f, -3.82676022e-03f,
  -6.73950911e-02f, -2.68348724e-01f, 2.18282476e-01f, -9.84214321e-02f, 2.65715837e-01f, 7.01458007e-02f, 1.42867953e-01f, -2.42149815e-01f, -2.31517583e-01f, -3.24636340e-01f,
  4.29245830e-02f, -6.58527017e-02f, 1.55633122e-01f, 2.93334387e-02f, 2.13991120e-01f, 2.25801364e-01f, -7.75520429e-02f, 2.94410996e-02f, 6.76370785e-02f, 6.54007047e-02f,
  5.46539575e-02f, -2.92047001e-02f, 2.47912571e-01f, -1.37629181e-01f, 7.38893524e-02f, -9.23687071e-02f, -1.88279490e-03f, 1.92606866e-01f, -3.34385112e-02f, 1.09850377e-01f,
  -8.22004229e-02f, -8.39347988e-02f, 1.34605274e-01f, -3.76480334e-02f, 3.16154882e-02f, 7.32543394e-02f, 1.06344491e-01f, 1.74686298e-01f, -1.55067211e-02f, -1.03053274e-02f,
  4.39598598e-02f, -1.19026201e-02f, -1.85117591e-02f, 6.17879070e-02f, 3.77943693e-03f, -4.83234972e-02f, -6.14839494e-02f, 1.71454493e-02f, -2.94544790e-02f, 1.08594216e-01f,
  -9.47990548e-03f, 5.98430680e-03f, 2.54885871e-02f, -9.89983454e-02f, 4.67267781e-02f, -8.82500336e-02f, -1.95364770e-03f, 1.33759201e-01f, 1.77116543e-02f, -3.84124592e-02f,
  8.15722644e-02f, 9.15486738e-03f, 2.86475327e-02f, -4.15788628e-02f, 2.80077811e-02f, -6.75894916e-02f, 7.83128515e-02f, 1.87912378e-02f, -1.04141831e-01f, -4.38879840e-02f,
  -4.05081548e-03f, -1.84299890e-02f, 3.72933820e-02f, -1.02947719e-01f, -4.42579724e-02f, -9.37278345e-02f, 3.61623913e-02f, -4.05523926e-02f, -8.05186760e-03f, -5.50311916e-02f,
  -2.18433216e-02f, -3.35786939e-02f, 2.19981149e-02f, -2.01289859e-02f, -4.97649312e-02f, -1.00870477e-02f, -9.30618942e-02f, -9.32981074e-02f, 8.08711126e-02f, 1.50150850e-01f,
  -1.56688586e-01f, -2.82161981e-01f, 1.92255694e-02f, -3.70240137e-02f, 9.44505073e-03f, -8.64682943e-02f, -1.63329355e-02f, 3.86833516e-03f, 2.69804168e-02f, -2.34946851e-02f,
  -7.05177337e-02f, 2.44238079e-02f, -7.15316785e-03f, -2.92090122e-02f, -9.15491655e-02f, -3.32585722e-02f, 6.17007464e-02f, -3.52982096e-02f, -4.85159941e-02f, 2.86585372e-02f,
  -5.00303395e-02f, 5.33764809e-02f, -7.03714835e-03f, -1.43529279e-02f, -7.77796060e-02f, -2.70406976e-02f, 1.76520254e-02f, 9.49338451e-03f, -1.53447958e-02f, 7.45754540e-02f,
  1.34981692e-01f, -1.71228126e-02f, 1.82535887e-01f, 1.76594317e-01f, 1.38954744e-01f, 2.14196071e-01f, 3.25096548e-01f, 1.07932054e-01f, 3.29809278e-01f, -2.02828124e-01f,
  -1.75390050e-01f, -1.28828555e-01f, -9.36677679e-02f, -1.10021926e-01f, -6.04843348e-02f, -1.09334089e-01f, -4.78639416e-02f, -1.51388608e-02f, 1.86854079e-01f, -6.39788210e-02f,
  -3.31666619e-02f, -2.19002783e-01f, -1.45535856e-01f, -2.97232792e-02f, -4.36364813e-03f, 6.37493655e-02f, -2.40074590e-01f, -4.23559584e-02f, -5.28769195e-03f, -1.44414261e-01f,
  8.71165767e-02f, 1.60451412e-01f, 1.09364107e-01f, -2.42422577e-02f, 3.05013526e-02f, -1.19759694e-01f, -1.65614914e-02f, -1.11019708e-01f, 4.65534106e-02f, -1.36238534e-03f,
  -1.53347939e-01f, -1.85082704e-01f, -2.83550541e-03f, 4.38730270e-02f, 1.41082868e-01f, 1.21130824e-01f, -5.20080924e-02f, 9.92886052e-02f, -6.97414950e-02f, 8.94173309e-02f,
  -5.81819005e-02f, 1.02726541e-01f, 1.16439581e-01f, -1.02161966e-01f, 9.11873281e-02f, 6.18274212e-02f, 1.10591784e-01f, 3.42031606e-02f, 2.45083682e-02f, 4.85719182e-02f,
  -5.91247156e-02f, 2.95146760e-02f, 2.18327250e-02f, 3.78453988e-04f, -9.09067243e-02f, -2.29783934e-02f, 4.65032347e-02f, 7.94175714e-02f, 1.00133367e-01f, -1.59188323e-02f,
  2.23261472e-02f, 5.55003360e-02f, 9.69649926e-02f, 1.02684870e-01f, -8.18304047e-02f, -5.66722825e-02f, 2.56921649e-02f, 1.74971417e-01f, -6.71188459e-02f, -1.55310243e-01f,
  9.85617656e-03f, -4.12290357e-02f, -2.73520499e-02f, -1.12204656e-01f, 2.99266446e-02f, -4.33449484e-02f, -5.01159839e-02f, 6.13798015e-02f, -5.62086925e-02f, -2.73961667e-03f,
  9.16744992e-02f, 7.54832178e-02f, -2.86750551e-02f, 6.82552829e-02f, 3.05183865e-02f, 6.58473419e-03f, -1.58480275e-02f, 1.08700134e-01f, 9.18170586e-02f, -4.78755794e-02f,
  -6.04004413e-02f, -5.09183183e-02f, 1.14859280e-03f, 8.81989151e-02f, -1.12770490e-01f, -2.65528727e-03f, -3.19145843e-02f, -1.21665252e-02f, -2.82664690e-02f, -1.20088257e-01f,
  -2.00645909e-01f, 3.78159247e-02f, 2.21042596e-02f, 3.89813110e-02f, -5.31339794e-02f, 6.66989684e-02f, 6.68858960e-02f, -1.62658561e-02f, -1.09176360e-01f, -9.45241600e-02f,
  2.08978429e-01f, 2.05707503e-03f, -1.91971168e-01f, -2.12583348e-01f, -1.38727859e-01f, -1.75564796e-01f, -2.34273165e-01f, -1.73302189e-01f, -8.50433931e-02f, 4.04704064e-02f,
  -1.90339804e-01f, 4.52941991e-02f, 1.24676958e-01f, -1.65827021e-01f, 4.49222103e-02f, 2.06258327e-01f, -2.31617033e-01f, -1.42145216e-01f, 1.47578791e-01f, -2.54256446e-02f,
  -1.00528877e-02f, -7.94072077e-02f, -1.20204873e-01f, 5.11684269e-02f, -3.83907482e-02f, -5.10176979e-02f, -2.60185823e-02f, -3.89696918e-02f, -9.82554406e-02f, -7.53338635e-02f,
  5.15275970e-02f, 2.38665529e-02f, -4.51099463e-02f, -1.57616846e-02f, -4.18935699e-04f, -8.08067918e-02f, -8.42647180e-02f, -6.68492243e-02f, 4.78891991e-02f, -6.07267879e-02f,
  -2.49279309e-02f, 3.00339336e-04f, 3.16146463e-02f, 7.19359890e-02f, -5.82324341e-02f, -7.86136463e-02f, -2.55570747e-02f, -3.82776968e-02f, -6.49021268e-02f, -2.16031374e-04f,
  3.28562260e-02f, -6.09955043e-02f, -2.89717223e-02f, 6.12249039e-02f, -8.61678720e-02f, -1.02634981e-01f, 2.12093163e-02f, -9.45880711e-02f, -1.08411469e-01f, 2.25119423e-02f,
  -5.05252369e-02f, 8.97965059e-02f, 8.02834705e-02f, -8.44163969e-02f, -3.52266766e-02f, 1.97697822e-02f, -6.53413460e-02f, 2.64408384e-02f, -3.81347984e-02f, 1.93164172e-03f,
  9.83569887e-04f, -3.71493287e-02f, 7.17198476e-03f, -1.36429332e-02f, 1.33879660e-02f, 5.55741787e-02f, 4.76731472e-02f, 1.12820426e-02f, -7.72812814e-02f, 2.96040457e-02f,
  -7.73040205e-02f, -7.66032040e-02f, -3.52744851e-03f, -1.43538758e-01f, 8.21011737e-02f, -7.62757137e-02f, 1.24923866e-02f, -5.53300194e-02f, 8.27734768e-02f, -9.54960212e-02f,
  -3.53099704e-02f, -8.58038515e-02f, 3.81587236e-03f, -4.94690612e-02f, 4.20928486e-02f, 1.47551754e-02f, -1.89158320e-02f, 3.85025400e-03f, -4.16598246e-02f, -2.15387773e-02f,
  -1.28207549e-01f, 1.58447567e-02f, -6.07165843e-02f, 1.40177533e-02f, -1.27329333e-02f, -1.18831694e-01f, -7.78805092e-02f, 2.57061087e-02f, -1.25078708e-01f, 2.92555732e-03f,
  -9.54340398e-03f, 1.16198458e-01f, 5.50479069e-02f, 7.39429612e-03f, 6.05158396e-02f, -1.07750617e-01f, -4.89714555e-02f, -1.78233851e-02f, -9.96568725e-02f, -5.28757051e-02f,
  1.99572697e-01f, -3.50611061e-01f, 4.59111482e-02f, 2.42492765e-01f, 1.94476202e-01f, -4.14951891e-02f, 1.62392467e-01f, -1.25130208e-03f, -4.83400673e-02f, -2.17463717e-01f,
  8.08122680e-02f, 3.12465783e-02f, -1.92355067e-01f, 1.04711048e-01f, 3.12686980e-01f, -8.88235420e-02f, 1.13798110e-02f, 8.82670376e-03f, 4.93027791e-02f, 3.47675979e-02f,
  1.48541585e-01f, 6.99823797e-02f, 1.28558382e-01f, -2.56526116e-02f, -8.38475749e-02f, 4.78525534e-02f, 8.15119669e-02f, -3.07229459e-02f, -2.59955954e-02f, -9.42686852e-03f,
  -1.59292713e-01f, 1.24229006e-01f, 4.02503274e-02f, -6.31927922e-02f, -9.97091308e-02f, -1.01461954e-01f, 4.88854423e-02f, -1.35872224e-02f, 1.07397780e-01f, -1.36119546e-02f,
  -1.20021790e-01f, -5.22184670e-02f, 6.15822859e-02f, -6.07517697e-02f, -5.69460057e-02f, -2.19356362e-02f, 3.53732184e-02f, -5.20484708e-02f, -2.42469423e-02f, 1.73761677e-02f,
  3.86280902e-02f, -5.70344441e-02f, -2.55755130e-02f, 1.07366387e-02f, 4.96429652e-02f, 2.77033411e-02f, 7.08276927e-02f, -6.48296922e-02f, -1.01746842e-02f, 5.96206859e-02f,
  1.41541930e-02f, 2.36661173e-02f, -1.86328366e-01f, -8.68372172e-02f, -7.34182000e-02f, 2.40174066e-02f, 2.64537223e-02f, 4.74746786e-02f, 1.13572897e-02f, -6.28421828e-02f,
  4.68322635e-03f, 2.84090694e-02f, 3.16414610e-02f, 1.85292810e-02f, -6.14534095e-02f, 1.81018524e-02f, -2.15047356e-02f, -2.59587136e-06f, -5.84251247e-02f, -7.85549171e-03f,
  9.05289501e-02f, -9.77250282e-03f, -1.02591433e-01f, -6.32264614e-02f, -3.31253260e-02f, -7.11198838e-04f, 1.44940810e-02f, -9.02400315e-02f, 2.67751683e-02f, 1.04755186e-01f,
  -3.40853333e-01f, -2.34669328e-01f, 3.65347415e-02f, -4.02300246e-02f, 3.26164514e-02f, -1.93408038e-02f, 2.81231273e-02f, -1.72165898e-03f, -4.45939824e-02f, -1.11649796e-01f,
  1.59737747e-02f, -1.44590857e-02f, -1.07361011e-01f, -1.06943781e-02f, -8.96461532e-02f, 3.30062248e-02f, -4.68409853e-03f, -5.55112399e-02f, -2.41556633e-02f, 3.34098376e-03f,
  -1.08179571e-02f, 1.29448790e-02f, 6.27351552e-02f, 1.54599035e-02f, 8.86444822e-02f, -3.39285610e-03f, 4.98348251e-02f, 8.73766616e-02f, -1.00521313e-03f, 2.39888690e-02f,
  -4.77592945e-01f, 3.16479236e-01f, -3.28671597e-02f, -5.35561983e-03f, -7.59946555e-02f, 7.89668858e-02f, -2.63702888e-02f, 4.70444560e-02f, 6.26092628e-02f, 1.59241483e-01f,
  5.64930253e-02f, -3.92783470e-02f, 9.00816470e-02f, 1.75486788e-01f, -2.62108713e-01f, 8.06193352e-02f, 4.35591489e-02f, -3.90309244e-02f, -6.39387369e-02f, -1.84474383e-02f,
  -5.03873192e-02f, 4.24264669e-02f, -2.86583863e-02f, 1.96170852e-01f, -1.67116523e-01f, -5.79136536e-02f, -1.73381686e-01f, -1.36044510e-02f, -7.24674389e-02f, -4.35702689e-02f,
  -9.44461301e-02f, -1.96334228e-01f, -6.54289946e-02f, -1.66316837e-01f, -1.08822018e-01f, -1.23781241e-01f, -9.89134014e-02f, -8.67121294e-02f, -6.60731643e-02f, -7.62320757e-02f,
  -1.09771758e-01f, 1.84757747e-02f, 3.60714681e-02f, 6.47163168e-02f, 4.81180735e-02f, 4.64414805e-02f, 1.01028599e-01f, -1.95539296e-02f, 4.35524210e-02f, -5.70954494e-02f,
  8.63906741e-02f, -3.10760345e-02f, -1.76420552e-03f, 2.07168236e-03f, -8.12578425e-02f, 8.83485079e-02f, 9.88101512e-02f, 2.84539722e-02f, -1.06219575e-01f, -3.61622386e-02f,
  -7.23941550e-02f, -5.87344542e-02f, -8.62454325e-02f, 1.02321632e-01f, -4.87232842e-02f, 6.13702796e-02f, 8.65790769e-02f, -6.44241869e-02f, -4.69677113e-02f, 7.49642448e-03f,
  -2.26793867e-02f, -5.88245578e-02f, 2.10976433e-02f, 7.32201263e-02f, -1.44064482e-02f, -6.98712319e-02f, 6.37295768e-02f, 6.21113777e-02f, 7.33809918e-02f, 3.08034499e-03f,
  1.20789828e-02f, 2.03331187e-02f, -9.88546833e-02f, -6.47083670e-02f, -4.59413826e-02f, -5.88355251e-02f, -4.50141588e-03f, -1.15249101e-02f, 6.26017004e-02f, -2.92478837e-02f,
  -9.00696442e-02f, -2.91055918e-01f, -8.64376873e-02f, -1.20442204e-01f, -5.64614832e-02f, -1.20025970e-01f, 3.50942649e-02f, 9.24972876e-04f, -1.40568480e-01f, -6.81642964e-02f,
  1.42725883e-03f, -7.55618736e-02f, -4.86978330e-02f, 5.79428263e-02f, -9.52781644e-03f, 9.15425047e-02f, -7.80736506e-02f, 3.28958631e-02f, -1.56645547e-03f, -6.93682302e-03f,
  -3.11881769e-03f, 1.23484153e-02f, -1.48553681e-02f, -8.79363343e-02f, -4.53152396e-02f, -3.20397466e-02f, -1.16231643e-01f, -7.34829232e-02f, -5.69850057e-02f, -4.67337072e-02f,
  3.44264843e-02f, -1.38281927e-01f, -1.05842173e-01f, -5.76754883e-02f, -4.78598364e-02f, -3.09436351e-01f, -2.42195964e-01f, -6.15207106e-02f, 1.13068163e-01f, 1.36384085e-01f,
  -1.84029520e-01f, 7.66856819e-02f, -2.05688607e-02f, -1.99261352e-01f, -4.29883599e-01f, -8.44107941e-02f, -2.90693074e-01f, -1.34062901e-01f, 5.64866997e-02f, -1.41786262e-02f,
  -1.13581419e-01f, -2.43693486e-01f, -2.14314386e-01f, -1.57447159e-01f, -8.77687857e-02f, 1.18441582e-01f, 1.53006628e-01f, 1.98386647e-02f, -3.44751775e-02f, -4.19479162e-02f,
  -3.13062258e-02f, 8.83334875e-02f, 7.02575892e-02f, 5.27717406e-03f, -8.86177924e-03f, 1.10299945e-01f, 3.20453383e-02f, -1.85842793e-02f, 6.86699301e-02f, -6.03572000e-03f,
  3.81788053e-02f, 4.85524572e-02f, -1.61023717e-02f, 2.05637868e-02f, 3.29721980e-02f, 4.65731658e-02f, -6.21294230e-02f, 3.48444991e-02f, -6.35618642e-02f, -5.98750710e-02f,
  3.15369256e-02f, 6.55992776e-02f, 7.86007009e-03f, -6.45979354e-03f, 2.46739592e-02f, 2.31706351e-02f, -5.02731800e-02f, 9.42296349e-03f, -7.79996905e-03f, 2.90379245e-02f,
  6.16168156e-02f, 1.12529621e-01f, -1.86073724e-02f, 4.68346924e-02f, -1.36881946e-02f, -2.08361819e-02f, -1.07478350e-01f, -3.90283717e-03f, -1.48131726e-02f, -1.02622934e-01f,
  -4.03297544e-02f, -1.78077538e-02f, 3.66051607e-02f, 2.67893262e-02f, 5.20210974e-02f, 7.71579240e-03f, -1.77942459e-02f, -1.97766479e-02f, -1.17688149e-01f, -4.45090160e-02f,
  5.43269403e-02f, 1.18823051e-02f, -4.83365320e-02f, 3.30442656e-03f, -5.18711694e-02f, -2.99222693e-02f, 6.11489080e-03f, 2.44889036e-02f, 8.66466109e-03f, -5.27518056e-02f,
  -4.97019365e-02f, -5.43845892e-02f, -7.69843087e-02f, 1.16979061e-02f, 4.30769175e-02f, -9.82150063e-02f, -9.14033428e-02f, -8.60450640e-02f, -1.68819297e-02f, 9.90508310e-03f,
  1.13197438e-01f, 1.25264423e-02f, 1.87684372e-02f, 5.89908473e-03f, -6.29165992e-02f, -1.21896252e-01f, -3.55437994e-02f, 5.20293564e-02f, -3.32105882e-03f, -3.77520099e-02f,
  7.12037906e-02f, 3.68843749e-02f, 8.15004483e-02f, -4.09489591e-03f, -3.67455781e-02f, 5.87742887e-02f, 4.62462604e-02f, 1.64498314e-02f, -1.95573661e-02f, -3.54835875e-02f,
  1.88038021e-01f, -1.40381813e-01f, -1.72704116e-01f, -3.75950597e-02f, -2.99132336e-02f, -4.13116105e-02f, -1.33049026e-01f, 1.14611899e-02f, 2.77293980e-01f, 4.58005480e-02f,
  -2.65246420e-03f, 1.03449218e-01f, 1.17410362e-01f, -2.48694479e-01f, 2.19574213e-01f, 7.51278028e-02f, -8.08584616e-02f, -8.69853497e-02f, 8.51084962e-02f, 4.11152281e-02f,
  1.61248013e-01f, -5.85800819e-02f, -1.90556973e-01f, -1.96813092e-01f, -1.81976378e-01f, -1.48664355e-01f, -9.95573401e-02f, -1.02912918e-01f, -1.64697230e-01f, 4.29693516e-03f,
  -1.18777916e-01f, 5.55426581e-04f, -1.30006224e-01f, 2.16016583e-02f, -9.15910006e-02f, -8.69057775e-02f, -1.05907666e-02f, -1.07691512e-01f, 6.29551262e-02f, -4.49055843e-02f,
  1.03359692e-01f, 1.03430785e-01f, 1.28298998e-01f, 8.90273750e-02f, -5.91241196e-02f, -6.48017898e-02f, -4.76283692e-02f, -1.62582636e-01f, -6.26396388e-02f, -1.14627935e-01f,
  -6.63876235e-02f, -5.30220419e-02f, -1.07013024e-01f, -5.48458397e-02f, -7.36370683e-03f, -1.28252551e-01f, 9.23835337e-02f, -1.51706547e-01f, -9.05286074e-02f, 6.73617721e-02f,
  -6.06321879e-02f, 6.62780553e-02f, -8.90446082e-02f, -3.00625879e-02f, -1.51397772e-02f, 4.19459566e-02f, 1.31162573e-02f, 8.33508074e-02f, -1.01468772e-01f, 1.07961791e-02f,
  -1.28864542e-01f, -2.53649782e-02f, -3.79333760e-05f, -6.36186525e-02f, -7.87311699e-03f, 1.42714635e-01f, -2.03175563e-02f, 3.70227359e-02f, -1.99326966e-02f, 4.19501662e-02f,
  1.27979904e-01f, 1.54326169e-03f, -9.43745524e-02f, -7.13886227e-03f, 3.92403156e-02f, 7.43512958e-02f, 4.93917689e-02f, 4.34930623e-03f, 9.08207968e-02f, 4.38786000e-02f,
  -1.65652528e-01f, 4.51091724e-03f, -5.85546158e-02f, -2.00436469e-02f, -8.25994685e-02f, -5.48195913e-02f, 3.98193039e-02f, -5.23861013e-02f, -3.92874470e-03f, 6.03287667e-02f,
  3.41927074e-03f, 1.32375760e-02f, -1.01605663e-02f, 1.09535001e-01f, 2.49698069e-02f, 3.26767005e-02f, 3.90154459e-02f, -5.45892455e-02f, 3.91126722e-02f, -8.21851417e-02f,
  -3.87456864e-02f, 7.80721083e-02f, -6.87799677e-02f, -1.58520751e-02f, -1.40611604e-01f, 2.69620623e-02f, 1.64951280e-01f, -6.91583976e-02f, -5.32463267e-02f, 9.40070301e-03f,
  3.22784603e-01f, -1.56701103e-01f, -4.38284948e-02f, 1.20112218e-01f, 4.02204990e-02f, -3.64482068e-02f, 1.68051720e-01f, 3.53371282e-03f, 2.30512127e-01f, -1.90991685e-01f,
  -5.71942143e-02f, -1.18541040e-01f, 5.41742779e-02f, -1.93126813e-01f, 1.17824540e-01f, 7.13599995e-02f, 8.18243437e-03f, -4.02600244e-02f, -3.41974050e-02f, 4.77123484e-02f,
  1.56274378e-01f, -7.98066854e-02f, -1.55279994e-01f, -2.23868176e-01f, -9.52868536e-02f, -1.64937004e-01f, -1.11852691e-01f, -3.90480198e-02f, -2.37737060e-01f, -5.35876378e-02f,
  -3.72811742e-02f, 4.11428437e-02f, 4.43717651e-02f, -3.57026123e-02f, -2.00005211e-02f, -8.18742737e-02f, -9.02700126e-02f, -1.23946466e-01f, 7.99919516e-02f, -1.72798578e-02f,
  5.53027280e-02f, 2.17628367e-02f, 1.46009168e-02f, 4.03390601e-02f, 1.81176960e-02f, -6.02439940e-02f, -8.67095441e-02f, 1.74435899e-02f, -4.33721170e-02f, -1.20024048e-01f,
  -7.28777200e-02f, 1.98961515e-02f, 9.64247584e-02f, 5.14327921e-02f, 7.62870833e-02f, 1.49001991e-02f, 9.03184898e-03f, 1.31054157e-02f, -5.21147624e-02f, -3.68860736e-02f,
  -6.82607442e-02f, 3.63421030e-02f, 1.46754959e-03f, 4.45233280e-04f, 3.04981600e-02f, 2.02428177e-03f, -7.33872503e-02f, 3.62913981e-02f, 1.25053912e-01f, 7.29311630e-02f,
  7.70060858e-03f, 3.16672809e-02f, 4.90974933e-02f, 8.74852613e-02f, 1.59111302e-02f, 3.47875133e-02f, 1.20393476e-02f, -1.32530168e-01f, 2.92187762e-02f, -6.57447800e-02f,
  -1.07272482e-02f, 5.12110926e-02f, 3.06943106e-03f, -1.46510797e-02f, 2.89170630e-02f, 1.25610400e-02f, -1.32253349e-01f, 3.99178788e-02f, -3.21403593e-02f, -5.75179532e-02f,
  3.46059143e-03f, -7.03357756e-02f, 3.86189818e-02f, 4.98804562e-02f, -8.11221823e-02f, -3.03127859e-02f, -3.67771350e-02f, -1.97546761e-02f, -1.44893546e-02f, 5.31562790e-02f,
  6.68129511e-03f, -1.43400738e-02f, 4.04250808e-03f, -3.52263288e-03f, -3.47602665e-02f, -1.00005135e-01f, 4.97261658e-02f, 9.14981663e-02f, -4.48935479e-03f, -9.48569644e-03f,
  -9.09952633e-03f, -1.24357026e-02f, -2.05319375e-02f, -4.62126434e-02f, 2.41672974e-02f, 5.84768411e-03f, -3.64436097e-02f, -3.06101013e-02f, -2.41116118e-02f, -1.46075198e-02f,
  1.68314099e-01f, -1.52974725e-01f, -3.41191977e-01f, -1.54664427e-01f, 8.67480487e-02f, 2.07899451e-01f, -8.18037391e-02f, -7.92045984e-03f, -1.82816550e-01f, 2.00819030e-01f,
  1.63681418e-01f, -5.27713336e-02f, -2.19588473e-01f, 1.47753730e-01f, 3.65614332e-03f, -9.78833903e-03f, 9.26038399e-02f, 1.65221676e-01f, 2.42795097e-03f, -1.14278691e-02f,
  -1.49554783e-03f, 2.89359093e-01f, -1.15455657e-01f, 1.71394870e-01f, 1.11898005e-01f, -1.41348571e-01f, 2.12841138e-01f, -1.33121982e-01f, 3.88176143e-02f, 1.90605462e-01f,
  -4.71577309e-02f, -1.14936054e-01f, -1.05026802e-02f, 5.47691435e-02f, 1.65839773e-02f, 1.60652116e-01f, -6.50677271e-03f, 4.26088497e-02f, -4.16820869e-02f, -3.43452245e-02f,
  -7.17109218e-02f, -1.11653032e-02f, 1.80638023e-02f, 1.00292433e-02f, -5.31410836e-02f, -1.09011708e-02f, -1.06388360e-01f, -9.23807919e-02f, -2.03207090e-01f, -6.67155012e-02f,
  -1.27832875e-01f, 1.71180125e-02f, -5.23772324e-03f, 4.86924266e-03f, -1.18537419e-01f, -4.09055762e-02f, -8.41465145e-02f, -3.43829729e-02f, 6.57533109e-02f, -2.81309597e-02f,
  1.10495187e-01f, 7.39187002e-02f, 6.44991696e-02f, 4.34404127e-02f, -3.38225178e-02f, -1.71132032e-02f, -5.58059430e-03f, -5.69772394e-03f, -3.08437943e-02f, 4.63967286e-02f,
  1.01582021e-01f, -1.09637842e-01f, 6.12007454e-02f, 1.25617161e-02f, 5.61921522e-02f, 2.33988389e-02f, 8.26973189e-03f, 5.68235628e-02f, -7.61058405e-02f, -1.08568639e-01f,
  2.05280054e-02f, 8.08396861e-02f, 5.90758324e-02f, 2.06158869e-02f, 2.56277937e-02f, -2.35260697e-03f, 1.36494279e-01f, 2.53024828e-02f, -6.83951527e-02f, 7.66128823e-02f,
  5.62958382e-02f, 1.74821354e-02f, -1.08915970e-01f, 2.98921037e-02f, -2.15327665e-02f, 8.05713236e-02f, 5.52275702e-02f, 3.73523645e-02f, 3.49077652e-03f, 1.85985602e-02f,
  3.84119600e-02f, -4.66154218e-02f, 1.10212285e-02f, -1.16185151e-01f, -5.10468781e-02f, 1.27546147e-01f, 4.82048169e-02f, 2.18382813e-02f, 1.89822223e-02f, -9.63649899e-02f,
  7.18093961e-02f, -2.11051181e-02f, -3.38138640e-02f, 2.60477569e-02f, 5.73995002e-02f, 4.80553731e-02f, 3.66354287e-02f, -8.01705122e-02f, 3.76613624e-02f, 2.89227553e-02f,
  3.24329361e-02f, -1.47926018e-01f, 7.51977488e-02f, -9.21681598e-02f, -4.75920178e-02f, 8.88978913e-02f, 1.65490374e-01f, -2.05465108e-01f, -2.62338310e-01f, -1.58400059e-01f,
  -9.85834822e-02f, 1.09638803e-01f, 3.32418293e-01f, -2.52628535e-01f, 3.89777809e-01f, 1.19109385e-01f, -6.18864931e-02f, 1.04845248e-01f, -4.99130562e-02f, -1.86481521e-01f,
  -9.83020216e-02f, -1.69531286e-01f, 1.06219143e-01f, -1.84187517e-01f, -1.46046579e-01f, -2.18130097e-01f, 4.33052927e-02f, 7.26451054e-02f, -1.91500559e-01f, -1.68467816e-02f,
  -8.87049213e-02f, -2.33454108e-01f, -1.78113058e-01f, -5.61377965e-02f, -7.85876764e-04f, 6.84427097e-02f, 3.99807021e-02f, 7.15880767e-02f, -6.45723715e-02f, 5.46563491e-02f,
  4.71591391e-02f, -5.24715781e-02f, -1.33105040e-01f, 2.61930302e-02f, -9.46300700e-02f, -9.90485772e-02f, -1.17543787e-02f, 1.55403968e-02f, -8.19219127e-02f, 7.91328177e-02f,
  5.80157824e-02f, -2.98460647e-02f, -4.25621644e-02f, -4.19406593e-02f, 2.72507407e-02f, -3.70793715e-02f, -1.49326697e-02f, 1.21680863e-01f, -4.04200628e-02f, -8.78854692e-02f,
  -1.14411667e-01f, 5.13602654e-03f, -6.71562832e-03f, -8.16218853e-02f, -2.09608097e-02f, -1.41049504e-01f, -5.79782091e-02f, 2.72159427e-02f, 8.95323139e-03f, -4.19979356e-02f,
  -2.57234164e-02f, -3.50562148e-02f, 4.90586907e-02f, 1.21862389e-01f, -7.11752800e-03f, -7.69285709e-02f, -1.44679854e-02f, -9.50484350e-03f, -3.88898328e-02f, 1.19012063e-02f,
  -4.45930175e-02f, 5.12507092e-03f, 1.07868545e-01f, -4.75546494e-02f, -5.31517901e-02f, 1.67587248e-04f, -2.52651777e-02f, 3.52025516e-02f, -8.78949184e-03f, 8.74421448e-02f,
  -1.23636007e-01f, -2.20823139e-01f, -1.11137435e-01f, -7.12211430e-03f, -1.17009934e-02f, -1.46493176e-02f, -3.81274223e-02f, -7.58695453e-02f, -1.04106657e-01f, 3.17248031e-02f,
  2.29751151e-02f, 1.01899482e-01f, 2.82219499e-02f, 2.14230232e-02f, 6.48990571e-02f, -2.37442795e-02f, -1.47031983e-02f, 7.84159750e-02f, -5.48582450e-02f, -1.41446078e-02f,
  -2.48249546e-02f, 2.22851466e-02f, 5.84090613e-02f, -4.06961236e-03f, -3.33942547e-02f, -8.57787952e-02f, 2.27014022e-03f, -4.82785217e-02f, 1.27926722e-01f, -2.17237393e-03f,
  -2.31999338e-01f, -5.77346124e-02f, -2.35539466e-01f, -1.55984983e-01f, 1.15470842e-01f, -3.72710824e-01f, -2.16627896e-01f, -2.26497706e-02f, 4.13727276e-02f, 9.72563475e-02f,
  1.80411022e-02f, 1.89419126e-03f, 5.53663187e-02f, -2.50788718e-01f, -2.33658418e-01f, -6.64570183e-02f, -3.44454408e-01f, -1.54555276e-01f, 3.71317565e-02f, -4.12096046e-02f,
  -1.37990057e-01f, -1.23510264e-01f, -2.67191321e-01f, 1.15460388e-01f, -4.20213006e-02f, 9.47549790e-02f, 1.25843450e-01f, 6.90926239e-02f, -1.85892954e-01f, 1.46346577e-02f,
  -5.34494556e-02f, 1.55167818e-01f, -1.28473844e-02f, -2.91849989e-02f, -1.21489249e-01f, -1.59620754e-02f, -6.06579334e-02f, 4.92486060e-02f, 2.36426406e-02f, -8.09766427e-02f,
  1.41643791e-03f, -7.75963813e-02f, -3.45759541e-02f, 2.54338942e-02f, 1.85373668e-02f, -1.62718389e-02f, -4.39738818e-02f, -5.23558557e-02f, 5.04831364e-03f, -8.74731466e-02f,
  -7.60698691e-02f, -9.00917500e-02f, -1.06313534e-01f, -3.02892141e-02f, -9.02158674e-03f, 5.54290302e-02f, -1.23086356e-01f, 2.44647097e-02f, -1.74338501e-02f, -4.22470048e-02f,
  1.81936950e-03f, 4.58893478e-02f, -2.70415507e-02f, 4.60108072e-02f, 2.50784997e-02f, 3.29967216e-02f, -8.83710478e-03f, 9.40994546e-03f, -3.78727354e-02f, 4.85008731e-02f,
  5.68475947e-03f, -7.55199045e-02f, 8.58543664e-02f, -4.64006588e-02f, -4.78449166e-02f, 3.66766751e-02f, -5.17393760e-02f, 7.65735283e-02f, -9.86789390e-02f, -8.48135129e-02f,
  1.29051596e-01f, -4.57253587e-03f, -6.80469051e-02f, 9.31542274e-03f, 2.22418997e-02f, -5.37179112e-02f, 5.43382503e-02f, -3.59911323e-02f, 8.29183310e-02f, -9.60015319e-03f,
  3.44925709e-02f, 1.01084523e-01f, 8.37111473e-02f, -4.62013148e-02f, 1.01309977e-02f, 2.23309696e-02f, -4.92402688e-02f, -7.22209737e-02f, 3.48553695e-02f, 4.61743735e-02f,
  -1.39592225e-02f, 1.78570487e-02f, 1.23326499e-02f, -7.20247850e-02f, -6.82729557e-02f, 7.40274275e-03f, 1.03407368e-01f, 7.51377791e-02f, -3.67643721e-02f, -4.57937755e-02f,
  -1.39608514e-02f, 1.29625961e-01f, 5.28558865e-02f, 6.08146340e-02f, -3.51326130e-02f, 1.84375010e-02f, 4.94472720e-02f, 6.72903359e-02f, -2.78347060e-02f, 1.34956166e-02f,
  -2.00650394e-02f, 3.73429716e-01f, -1.20665185e-01f, -8.19135923e-03f, 9.85470712e-02f, 3.62609714e-01f, 2.00471014e-01f, 1.54390231e-01f, 1.51578352e-01f, 1.57382980e-01f,
  -7.51627535e-02f, -5.66186234e-02f, -3.94253694e-02f, 1.77826658e-01f, 1.24639906e-01f, 2.46101722e-01f, 1.76488876e-01f, 1.40700251e-01f, 1.45774528e-01f, -1.05973229e-01f,
  -1.24187939e-01f, -2.47731227e-02f, -9.71816629e-02f, -1.00271970e-01f, 1.02173081e-02f, -1.97214335e-01f, -2.65755057e-01f, -7.65325427e-02f, -1.39954677e-02f, 7.45422617e-02f,
  7.69439936e-02f, 2.77572069e-02f, -4.61910963e-02f, -3.92265990e-02f, 5.06470092e-02f, 1.34515651e-02f, 1.11494057e-01f, -3.53066809e-02f, -2.62818411e-02f, -3.18251178e-02f,
  7.68816993e-02f, 7.84865692e-02f, 9.51001495e-02f, -8.78148824e-02f, 6.05490692e-02f, 5.34423906e-03f, -7.64343068e-02f, -7.36638978e-02f, 7.68871009e-02f, 6.26330823e-02f,
  -5.11257686e-02f, 8.47781599e-02f, -8.52957591e-02f, 5.36715798e-02f, 2.24319138e-02f, 4.27357294e-02f, 9.53915045e-02f, 3.35193165e-02f, 7.20801130e-02f, 1.90948844e-01f,
  -3.20875868e-02f, 1.01623774e-01f, 4.82165031e-02f, -2.35894173e-02f, 1.95469782e-02f, -6.91302046e-02f, 5.30230291e-02f, -8.95623490e-02f, 3.64251807e-02f, -3.00230142e-02f,
  -7.81724676e-02f, -6.98549747e-02f, 7.99809024e-02f, -1.78681705e-02f, 5.67200556e-02f, -6.67244121e-02f, -2.99222749e-02f, -3.75599880e-03f, 1.70002114e-02f, -1.05853252e-01f,
  1.32233594e-02f, 6.85154945e-02f, -3.67562324e-02f, -1.19357035e-01f, 1.28595918e-01f, -1.22931689e-01f, -6.98380247e-02f, -8.93301293e-02f, -8.13174620e-02f, -1.46930870e-02f,
  9.42781717e-02f, 2.03348145e-01f, 2.12850161e-02f, 2.58202525e-03f, 6.90380782e-02f, -1.05049498e-01f, -9.90019552e-03f, 3.94967049e-02f, 6.58435896e-02f, 1.10803939e-01f,
  3.13354582e-02f, -2.35643610e-02f, -5.84735833e-02f, -3.50212678e-02f, -3.57526243e-02f, 1.78951118e-02f, 4.05364521e-02f, 1.34239802e-02f, 9.38885659e-02f, 4.05490585e-02f,
  -7.02409223e-02f, -7.21335709e-02f, 5.00233844e-02f, -7.29624704e-02f, -6.98825791e-02f, -4.09452617e-03f, -5.94375208e-02f, -2.74367556e-02f, -9.96373687e-03f, 5.64930774e-02f,
  2.36969054e-01f, 4.49955976e-03f, 1.36428252e-01f, 7.34809637e-02f, -3.54723223e-02f, 1.14592919e-02f, 5.57321236e-02f, 1.14438962e-03f, 2.30477765e-01f, -4.39179167e-02f,
  9.59291160e-02f, 1.33691132e-01f, -6.63823709e-02f, 1.32879004e-01f, -1.26199439e-01f, 4.46266867e-03f, 9.76479352e-02f, 1.15066357e-01f, 1.37670189e-01f, 1.36723116e-01f,
  1.26226693e-01f, -1.42582938e-01f, -1.99176267e-01f, -2.27595776e-01f, 9.17561129e-02f, -1.11082681e-01f, -2.39636838e-01f, -2.37884112e-02f, -1.37967858e-02f, -6.46548271e-02f,
  7.67276660e-02f, 4.05732170e-02f, 3.92309316e-02f, 7.42537305e-02f, -2.28785817e-02f, 2.51738094e-02f, -5.71140535e-02f, -8.66919383e-02f, 6.39967769e-02f, -6.85741231e-02f,
  5.26206158e-02f, -8.62321910e-03f, -2.94573121e-02f, -1.55160166e-02f, -7.78480293e-03f, -8.56046602e-02f, 7.81266391e-02f, 7.51349926e-02f, -2.34297966e-03f, 1.34832233e-01f,
  9.91116390e-02f, 1.64817162e-02f, 1.07470930e-01f, -7.63513595e-02f, -1.11510754e-02f, -7.26321563e-02f, -3.06545887e-02f, 2.79322751e-02f, 5.99180395e-03f, -2.09232029e-02f,
  1.06552154e-01f, 1.12692051e-01f, -6.24070875e-02f, -8.71469900e-02f, 9.24652629e-03f, 1.46556273e-02f, -7.85991699e-02f, -1.00989705e-02f, 4.52631526e-02f, 2.84458380e-02f,
  -2.71507781e-02f, 6.25641644e-02f, 2.61666980e-02f, 1.05314732e-01f, 8.43909904e-02f, -7.60656446e-02f, -3.06084417e-02f, -9.05551687e-02f, 1.05510047e-02f, -4.42127474e-02f,
  5.59040308e-02f, 6.12045713e-02f, -3.61782755e-03f, -1.53944522e-01f, 2.28359867e-02f, 2.92928349e-02f, 2.87456568e-02f, 1.06804259e-01f, 2.31250399e-03f, -1.84249673e-02f,
  -2.82817092e-02f, -1.24529548e-01f, 2.21027117e-02f, 1.02838986e-01f, 3.59870978e-02f, 6.66858256e-02f, 9.91591625e-03f, 7.71090835e-02f, -2.51616128e-02f, 4.19370923e-03f,
  8.14536959e-03f, 7.55070075e-02f, -5.00988103e-02f, 7.07436204e-02f, -6.39855415e-02f, -1.20010942e-01f, 5.94137935e-03f, 5.70394024e-02f, -9.15266946e-02f, 3.55639979e-02f,
  1.52705926e-02f, 8.29098448e-02f, 4.35494381e-04f, -1.09616116e-01f, -4.54342589e-02f, -5.22924773e-02f, 6.51238114e-03f, -7.71979913e-02f, -6.01541921e-02f, 6.21748194e-02f,
  -2.90699631e-01f, 8.77897739e-02f, -4.30554710e-02f, -2.54442036e-01f, 5.47929928e-02f, 8.15196857e-02f, -1.74750224e-01f, 1.41406476e-01f, 3.15394573e-04f, 6.87980428e-02f,
  2.57067895e-03f, -1.18173301e-01f, 1.76587943e-02f, -9.39944759e-02f, -3.19065839e-01f, -9.72839519e-02f, -1.44077390e-01f, -6.40074387e-02f, 8.55720975e-03f, 6.32643253e-02f,
  -2.78029945e-02f, -1.47351861e-01f, -5.72693683e-02f, 1.27995983e-01f, -1.73380692e-02f, 2.23600641e-02f, -1.01829074e-01f, 1.43510148e-01f, -7.69091863e-03f, 3.63921560e-02f,
  -1.77503154e-02f, 6.24029599e-02f, 1.44362971e-01f, -3.30538340e-02f, 8.93011019e-02f, 1.20208442e-01f, 7.26874247e-02f, 4.03079875e-02f, 3.15929390e-02f, -8.67222026e-02f,
  -9.90149379e-02f, 9.44265164e-03f, -1.11791305e-01f, -5.47262691e-02f, 3.75131182e-02f, 6.31745979e-02f, 2.27135606e-02f, -4.15525474e-02f, 7.41253868e-02f, -1.71594713e-02f,
  -4.97539416e-02f, -1.01549756e-02f, -4.00250666e-02f, -8.52184147e-02f, -1.42830331e-02f, 3.23144952e-03f, -5.93887717e-02f, 4.28429544e-02f, -7.14530572e-02f, -7.02792928e-02f,
  -9.24789980e-02f, -8.63016117e-03f, 3.63345705e-02f, 7.00650588e-02f, -8.37365985e-02f, 1.41763277e-02f, -9.12462026e-02f, 1.05227102e-02f, -1.35570141e-02f, -3.89483832e-02f,
  5.01467809e-02f, 2.13947147e-02f, 3.02097620e-03f, -3.86075377e-02f, 2.51033902e-02f, 1.51518369e-02f, -5.60510084e-02f, 6.64540157e-02f, -1.41932204e-01f, -3.62027157e-03f,
  5.97809032e-02f, -3.32937054e-02f, 5.37969023e-02f, 6.49398938e-03f, 9.68415067e-02f, 2.79705040e-02f, -6.08142316e-02f, 1.16521709e-01f, -2.87055038e-02f, -6.41016662e-02f,
  2.22698450e-02f, 1.20832592e-01f, 1.07979782e-01f, 7.46222660e-02f, 3.85267474e-02f, 7.85566121e-02f, -8.42826217e-02f, -2.71960590e-02f, 2.17598327e-03f, -6.44042939e-02f,
  7.28977099e-02f, -3.82565111e-02f, 6.62212819e-02f, -3.88489524e-03f, -1.07198313e-01f, 5.84113672e-02f, 1.85546803e-03f, -9.71053634e-03f, -9.24335979e-03f, -7.32123945e-03f,
  1.27354721e-02f, -1.04929635e-03f, -1.00138962e-01f, 1.51141286e-02f, -2.04927102e-02f, -7.55286068e-02f, 9.70824063e-02f, -4.44567343e-03f, -3.40880244e-03f, -2.89174309e-03f,
  -3.41180176e-01f, 1.03273965e-01f, 6.72835559e-02f, -3.07886273e-01f, 1.76692694e-01f, -1.40132979e-01f, -7.41976127e-02f, 1.78519130e-01f, 2.51801386e-02f, 9.51906592e-02f,
  -2.90971287e-02f, -1.23634346e-01f, 9.34848860e-02f, -1.14622705e-01f, -2.86429316e-01f, -1.92308888e-01f, -2.75214761e-01f, -1.57451704e-01f, -7.43526071e-02f, -1.14498422e-01f,
  -1.57474607e-01f, 7.75954351e-02f, -1.15826443e-01f, 1.78499416e-01f, 9.75918546e-02f, 3.14990357e-02f, 7.00317100e-02f, 1.12065382e-01f, -1.30706862e-01f, -3.97713147e-02f,
  3.99742015e-02f, 1.45413894e-02f, 3.74704301e-02f, 2.12029740e-02f, -7.46217519e-02f, -4.44951877e-02f, 4.34107371e-02f, -1.47762066e-02f, -6.99589401e-02f, -6.34795055e-02f,
  -1.51476031e-02f, -3.49232443e-02f, 2.34249551e-02f, 1.19058006e-02f, 5.87437414e-02f, -3.90451588e-02f, -3.36893536e-02f, -9.47391242e-02f, -5.70162348e-02f, -7.64666200e-02f,
  -5.40243573e-02f, -4.54444438e-03f, 2.92512737e-02f, -6.47444353e-02f, 3.59654091e-02f, 3.95675190e-03f, -1.14353783e-01f, -4.57331054e-02f, -3.00091039e-02f, -4.62796986e-02f,
  -9.88918468e-02f, 2.54640244e-02f, 5.06096557e-02f, 3.99872847e-02f, -7.97683969e-02f, 7.45951980e-02f, 4.67159636e-02f, 2.64786277e-02f, 2.52390783e-02f, 3.97627316e-02f,
  -4.24807779e-02f, 1.70913171e-02f, 7.23145157e-02f, -7.34764636e-02f, -5.38460501e-02f, 3.34166102e-02f, 4.32433151e-02f, -2.15222612e-02f, 3.56647675e-03f, -6.22589663e-02f,
  1.42693156e-02f, 3.64959612e-03f, -3.58083323e-02f, 3.59408073e-02f, 8.52764584e-03f, 7.11185709e-02f, 4.40050149e-03f, 1.17656980e-02f, -6.41411617e-02f, -7.55846575e-02f,
  -6.78673759e-02f, 7.27360789e-03f, -1.71248093e-02f, 9.67553258e-02f, 3.59793752e-02f, -9.04940590e-02f, -5.50026596e-02f, 7.46306106e-02f, 7.60810152e-02f, 9.60416123e-02f,
  3.21054198e-02f, 8.14400390e-02f, 4.82750870e-02f, 3.75140123e-02f, 9.19742286e-02f, -3.75776030e-02f, 2.62955613e-02f, 1.00444503e-01f, 1.20515302e-02f, 5.86217940e-02f,
  -2.63821371e-02f, 9.09491703e-02f, -6.04139417e-02f, 8.23661033e-03f, -2.64379270e-02f, -5.31902025e-03f, 6.50614053e-02f, 4.15313095e-02f, -1.06031425e-01f, 1.74983330e-02f,
  1.76377267e-01f, -1.27230942e-01f, -1.19344629e-01f, 1.09362811e-01f, 1.08886629e-01f, 6.46701902e-02f, -9.05272514e-02f, 1.59963518e-01f, -4.08208668e-02f, -8.32144171e-02f,
  4.58310358e-02f, -1.94947436e-01f, -1.90927088e-01f, 1.78899497e-01f, 9.67043117e-02f, -9.93802249e-02f, -2.15608720e-03f, 2.62648650e-02f, -5.59182055e-02f, 1.19945221e-01f,
  1.65293947e-01f, 1.86593562e-01f, 1.27053678e-01f, 1.89028487e-01f, 1.34864435e-01f, 1.30386055e-01f, 1.53509200e-01f, -5.69960400e-02f, 2.13052571e-01f, 9.36492085e-02f,
  8.34084451e-02f, -3.39276306e-02f, -6.94735348e-03f, -1.40248733e-02f, 1.39884641e-02f, -1.92328282e-02f, -1.28373712e-01f, -5.55516547e-03f, 4.11625318e-02f, 2.14862507e-02f,
  2.72097588e-02f, 3.15789580e-02f, 3.49758305e-02f, 7.27487728e-02f, -3.69534567e-02f, 1.00209363e-01f, 1.14314884e-01f, 3.63476314e-02f, 1.26951719e-02f, 2.15472486e-02f,
  1.12894224e-02f, -8.12302157e-02f, -6.56975806e-02f, -2.02852879e-02f, 9.81636462e-04f, 3.77690122e-02f, -1.86839011e-02f, -2.28365045e-02f, -9.75853279e-02f, 1.72312185e-02f,
  1.02398463e-01f, -8.83191600e-02f, 2.60237847e-02f, 1.19612301e-02f, -4.43023117e-03f, -6.89051822e-02f, -7.72662684e-02f, -7.71122724e-02f, -6.58371076e-02f, 5.86882792e-02f,
  -4.48708013e-02f, 8.07052553e-02f, 3.67307626e-02f, 2.89966576e-02f, -5.92088066e-02f, 2.15464481e-03f, -1.30053991e-02f, 3.74602638e-02f, 1.11514069e-01f, 4.92602028e-02f,
  -9.91359577e-02f, 6.14953600e-02f, 3.88763919e-02f, 2.99023185e-02f, -6.67793900e-02f, -1.12720195e-03f, 8.27068686e-02f, -4.80252393e-02f, -7.13775754e-02f, -4.33909521e-02f,
  -2.41256393e-02f, 1.00209199e-01f, -6.25811070e-02f, 6.12462405e-03f, -1.30617961e-01f, 2.42036488e-02f, -1.33001551e-01f, -1.29832150e-02f, -5.01340106e-02f, 1.08598650e-01f,
  9.75864083e-02f, -1.73318647e-02f, -7.15402737e-02f, 1.41787603e-01f, 8.82139727e-02f, 3.22030447e-02f, -5.63421771e-02f, 1.89967398e-02f, 4.66155596e-02f, 4.73044589e-02f,
  1.65726393e-02f, 1.03227675e-01f, -6.74827248e-02f, 7.42481053e-02f, 8.13801363e-02f, -8.81532356e-02f, -1.72774270e-02f, 3.78291085e-02f, 1.68467797e-02f, -3.11924983e-02f,
  -3.92919600e-01f, -2.27433637e-01f, 2.34763563e-01f, -2.07711264e-01f, 1.55985832e-01f, 2.30503321e-01f, 1.86661333e-01f, -1.51570618e-01f, -2.12852269e-01f, -1.33537874e-01f,
  -1.16354013e-02f, -9.18085650e-02f, 4.15342525e-02f, -6.01719134e-02f, 2.20000520e-01f, 2.16268733e-01f, 6.12672605e-02f, 8.37449543e-03f, -3.61902639e-02f, 1.95779689e-02f,
  3.87635045e-02f, -3.49240825e-02f, 1.41658425e-01f, -1.24186955e-01f, 8.12562555e-02f, -4.71599586e-02f, -1.16070658e-01f, 1.23367600e-01f, -6.75383732e-02f, 3.14572006e-02f,
  -1.07786864e-01f, -1.69507504e-01f, 3.09890788e-02f, -2.69559920e-02f, -1.57291833e-02f, 1.75747629e-02f, -3.40025616e-03f, 1.26242548e-01f, 8.22726488e-02f, -9.13319960e-02f,
  -2.34299209e-02f, 5.01862280e-02f, -1.15406364e-01f, 5.33377305e-02f, -8.33511427e-02f, -1.14985891e-02f, 2.03231853e-02f, -7.10221529e-02f, -4.28251969e-03f, 7.39426464e-02f,
  7.85199106e-02f, 8.09827223e-02f, 2.61830632e-02f, -1.36952251e-01f, 7.91109949e-02f, 2.13636104e-02f, 1.04292378e-01f, 6.86524287e-02f, -1.60094555e-02f, 1.25585683e-02f,
  -1.14168189e-01f, 3.09713315e-02f, 3.39891948e-02f, -7.83935562e-02f, 2.44097821e-02f, 9.24042705e-03f, -8.37328285e-02f, -3.67333144e-02f, 5.26094548e-02f, 8.88211206e-02f,
  3.95032279e-02f, 1.20501984e-02f, -7.61357546e-02f, 1.91089325e-02f, 9.17447079e-03f, 2.36491952e-02f, -9.53772292e-03f, 6.56479225e-02f, -5.82836717e-02f, 3.65469269e-02f,
  -3.22625265e-02f, 2.97082271e-02f, -8.31828341e-02f, 4.91136648e-02f, 2.09608804e-02f, 5.62699921e-02f, 2.42380332e-02f, -4.46557514e-02f, -1.14213331e-02f, -5.23108058e-04f,
  -6.88596964e-02f, -2.44723558e-01f, 8.79392028e-03f, -1.26297072e-01f, 2.55415887e-02f, 4.05191928e-02f, 1.66174602e-02f, -7.91964829e-02f, -8.70907772e-03f, -4.17767502e-02f,
  -7.70773441e-02f, -4.40643243e-02f, -1.13611631e-01f, -9.51686352e-02f, -6.30202815e-02f, -3.73382382e-02f, 2.16408633e-02f, -9.12967548e-02f, -6.64540827e-02f, -1.32851958e-01f,
  -1.29689470e-01f, -4.04026832e-05f, 1.27212375e-01f, -4.88084778e-02f, 6.23462349e-02f, -6.87407330e-02f, -1.57291502e-01f, -5.26982807e-02f, -2.90185977e-02f, 1.70914661e-02f,
  -1.44566074e-01f, -1.29785046e-01f, -9.77635533e-02f, -9.07441676e-02f, 7.65171647e-02f, 1.69671163e-01f, -8.26876089e-02f, -1.08064845e-01f, -3.20570707e-01f, -1.71426330e-02f,
  -9.16290432e-02f, -6.00145049e-02f, -2.87187159e-01f, -5.76192029e-02f, -2.27203578e-01f, -2.51457512e-01f, -2.97397058e-02f, -3.52514945e-02f, -2.01696455e-01f, -7.20341951e-02f,
  -6.99784830e-02f, -5.55408821e-02f, -4.53818366e-02f, 2.09438935e-01f, 4.93089631e-02f, 2.13432357e-01f, 1.53288931e-01f, 1.57642737e-01f, 2.19713837e-01f, 1.00313805e-01f,
  -2.85417140e-02f, -1.15656354e-01f, -2.09360011e-02f, 6.92931935e-02f, 4.02728394e-02f, 1.42402560e-01f, 3.81925516e-02f, 4.20298800e-02f, 4.54851007e-03f, 4.69264574e-02f,
  1.13871045e-01f, -1.46329803e-02f, 6.97117299e-02f, -8.03406239e-02f, -1.63767487e-03f, 3.74134853e-02f, -5.41912727e-02f, 1.65871568e-02f, -3.33446413e-02f, 2.94447839e-02f,
  -8.02894160e-02f, 4.01053093e-02f, 1.63402781e-01f, 1.18206561e-01f, 4.75583933e-02f, -3.78001221e-02f, 1.51426062e-01f, 9.84293595e-02f, 3.99503671e-02f, 6.45103157e-02f,
  -6.82813227e-02f, 9.60374847e-02f, -1.18404701e-01f, -1.98789034e-03f, -4.15531732e-02f, -1.72202773e-02f, -6.29834980e-02f, 5.95604815e-03f, -1.71590559e-02f, 4.85042445e-02f,
  -5.55471629e-02f, 6.25775903e-02f, -2.00549047e-02f, 9.71936658e-02f, 6.96666092e-02f, 4.86360341e-02f, 9.66144577e-02f, 1.73838008e-02f, -3.27549092e-02f, -3.79527546e-02f,
  7.50132203e-02f, -1.10403125e-04f, 5.28614521e-02f, 2.08658278e-02f, 1.00145843e-02f, -6.49953634e-02f, 5.30827697e-03f, -7.64457956e-02f, -4.56030034e-02f, 4.43393277e-04f,
  -5.01769129e-03f, -7.46346563e-02f, 1.52428560e-02f, -5.38668670e-02f, -3.13204713e-02f, 6.03894405e-02f, -1.67672839e-02f, 4.51099919e-03f, -4.00467339e-04f, -1.37809869e-02f,
  6.44937381e-02f, 1.02470003e-01f, 1.35082886e-01f, -1.94315240e-02f, 2.62763929e-02f, -1.88744627e-02f, 7.53554702e-02f, 4.64098938e-02f, 7.03169778e-02f, 4.31784242e-03f,
  1.51519163e-03f, 1.26363590e-01f, 1.40207216e-01f, 4.86851707e-02f, 1.30660494e-03f, 7.97055885e-02f, 4.76362407e-02f, 8.94003063e-02f, 1.60333645e-02f, -4.31235358e-02f,
  9.89045352e-02f, 2.13287294e-01f, 8.76542926e-02f, -7.85104707e-02f, -1.23521030e-01f, -1.76484302e-01f, -2.12967291e-01f, -9.14807096e-02f, 2.55358130e-01f, 1.31024756e-02f,
  -2.36752838e-01f, 2.40893424e-01f, -7.21261948e-02f, -7.72401243e-02f, 7.85220936e-02f, 2.16503348e-02f, -1.17007062e-01f, 1.08664660e-02f, 8.60335007e-02f, -8.92168730e-02f,
  5.49255088e-02f, -1.47070691e-01f, 2.95868632e-03f, -7.99158067e-02f, -1.34974539e-01f, -3.79438810e-02f, -1.38958007e-01f, -1.16720371e-01f, -1.18785813e-01f, -9.77211371e-02f,
  -3.08882189e-03f, -2.04953812e-02f, -1.35953017e-02f, -7.43443370e-02f, -3.46967839e-02f, -5.32018058e-02f, 1.01566352e-01f, -3.61494794e-02f, -6.42470941e-02f, 1.10619906e-02f,
  1.69359535e-01f, -1.81299224e-02f, 4.45346199e-02f, 6.22284673e-02f, 3.23577262e-02f, 4.05158736e-02f, 9.33354124e-02f, -8.88265222e-02f, 1.61715969e-02f, -5.49489334e-02f,
  6.61325920e-03f, -6.37669787e-02f, -5.78656457e-02f, 1.26302794e-01f, -3.04350425e-02f, -9.80047602e-03f, 1.27037680e-02f, 2.59006750e-02f, 7.34274313e-02f, 1.37800425e-01f,
  -1.39513295e-02f, -1.23525128e-01f, 7.59078795e-03f, -7.36772865e-02f, -9.50411242e-03f, 2.07057651e-02f, 5.64245209e-02f, -6.45383447e-02f, 1.23622328e-01f, -9.91071016e-02f,
  1.63758211e-02f, 7.49927238e-02f, -4.07163112e-04f, -1.00327276e-01f, -8.47253725e-02f, 6.77434951e-02f, 2.98537984e-02f, -3.79629172e-02f, 5.73778860e-02f, 4.23462987e-02f,
  6.24936894e-02f, 4.40872693e-03f, -8.56724456e-02f, -1.54501367e-02f, 3.29187065e-02f, 1.19989522e-01f, 7.39166811e-02f, 7.30620399e-02f, -6.08323887e-02f, 5.73150553e-02f,
  -2.64819246e-02f, -2.79100961e-03f, -3.38359587e-02f, 8.63290299e-03f, 3.11218631e-02f, 2.48741023e-02f, 2.12428626e-02f, -2.57076304e-02f, -9.71201807e-02f, 3.33905313e-03f,
  4.96034091e-03f, -2.85935309e-02f, 3.62015329e-03f, -4.46576551e-02f, 1.57041401e-02f, -1.88899469e-02f, 4.08467799e-02f, -4.86556105e-02f, -6.53375834e-02f, -5.97432479e-02f,
  -5.69287874e-02f, 8.03501010e-02f, 3.39668095e-02f, -3.86584587e-02f, -1.54819740e-02f, 5.31826876e-02f, 1.71282340e-03f, 1.59626361e-02f, -8.54965821e-02f, 3.65833901e-02f,
  1.71898156e-01f, 3.89197394e-02f, 1.28418477e-02f, 1.92624778e-01f, 2.52015859e-01f, 2.35204250e-01f, 1.50153786e-01f, 2.05145329e-01f, 3.51873457e-01f, -1.32514939e-01f,
  1.04937904e-01f, -3.57293673e-02f, -2.09761858e-01f, 1.24026820e-01f, -7.29765519e-02f, -1.18495636e-01f, 7.61064216e-02f, 7.44227171e-02f, 7.05710128e-02f, 3.95524688e-02f,
  1.29099578e-01f, 2.25674406e-01f, -1.80472329e-01f, -5.98036572e-02f, 2.82007363e-02f, -9.05709043e-02f, -2.71819651e-01f, -5.03641143e-02f, -2.21213773e-01f, 6.99031958e-03f,
  1.10488862e-01f, 1.28904864e-01f, -1.07390545e-01f, -5.06651923e-02f, 8.81124958e-02f, -1.49650257e-02f, -1.04323454e-01f, -6.00848347e-02f, -3.66476960e-02f, 1.45669013e-01f,
  -1.18774161e-01f, -9.61563364e-03f, -7.99968094e-03f, 6.84357733e-02f, 1.07960172e-01f, -3.08860559e-02f, -3.42277414e-03f, -2.68820412e-02f, -5.49461879e-02f, -2.47811880e-02f,
  -2.03933287e-02f, -5.05250134e-02f, -2.70766653e-02f, 4.23619114e-02f, -7.96544179e-02f, -7.10676983e-03f, -6.22918867e-02f, -6.74932003e-02f, -2.75328271e-02f, 6.20693006e-02f,
  2.99998727e-02f, 4.56693675e-03f, 4.71412577e-02f, -2.62014847e-02f, 1.14994764e-01f, -2.98067573e-02f, -7.22860321e-02f, 3.83851095e-03f, -4.04160693e-02f, 2.76439022e-02f,
  1.42723257e-02f, -2.48259455e-02f, 5.56923114e-02f, 4.67217639e-02f, 4.53171283e-02f, 4.32766266e-02f, -3.90361552e-03f, 7.31601790e-02f, 3.88757400e-02f, -5.50337583e-02f,
  -1.17934169e-02f, -2.60608196e-02f, -3.50376628e-02f, 5.02788983e-02f, -9.96487439e-02f, -2.44702958e-02f, 9.05302614e-02f, -4.80116159e-02f, -8.12571216e-03f, 3.81837152e-02f,
  9.11031365e-02f, -9.74002481e-03f, -5.51065728e-02f, -6.24478795e-02f, -8.94765854e-02f, -1.81750078e-02f, 6.24403767e-02f, 9.09389108e-02f, -4.40087989e-02f, 1.51767746e-01f,
  1.50027554e-02f, 1.74007025e-02f, 8.44164751e-03f, -7.01903850e-02f, -1.19314671e-01f, 1.27747208e-01f, -8.48273262e-02f, -9.83769149e-02f, -6.35080487e-02f, -5.38734421e-02f,
  8.44857539e-04f, 7.47286007e-02f, -1.16248215e-02f, 2.23746933e-02f, 1.53477928e-02f, -1.47798389e-01f, 1.02629453e-01f, -1.74324960e-02f, -2.07616463e-02f, -2.92385966e-02f,
  -2.59593159e-01f, 1.41689360e-01f, -1.33102491e-01f, -1.67059690e-01f, -1.05154142e-01f, -1.40939295e-01f, -4.13098447e-02f, -6.52680174e-02f, 1.34203836e-01f, -2.68650651e-02f,
  -1.18450880e-01f, 4.18757088e-04f, 1.76338777e-01f, 1.54097229e-02f, -2.67578661e-02f, 1.71796724e-01f, -1.28126860e-01f, -3.27887014e-02f, 8.71339813e-02f, -1.56924188e-01f,
  2.80406978e-03f, -2.47975276e-03f, -4.30038199e-02f, 9.86716151e-03f, -2.05055192e-01f, -1.19391844e-01f, -4.40597385e-02f, -1.00291111e-02f, -1.70401931e-01f, -4.59626578e-02f,
  -3.35915029e-01f, -2.94422746e-01f, -1.96576118e-01f, -1.26314148e-01f, -1.25228286e-01f, -1.25641106e-02f, -1.15425952e-01f, 1.12081997e-01f, -7.31259435e-02f, 7.42832273e-02f,
  -3.97268832e-02f, 7.23857852e-03f, -7.76516274e-02f, 7.30327219e-02f, -6.11864962e-02f, -7.44620636e-02f, 2.84598656e-02f, -1.30015001e-01f, -3.48720886e-02f, 5.33479340e-02f,
  -2.02255547e-02f, -1.27819791e-01f, -1.80768490e-01f, -2.96699181e-02f, -1.50788471e-01f, 1.92980804e-02f, -4.75072628e-03f, 7.26029724e-02f, -4.99196649e-02f, -9.79873836e-02f,
  6.00274391e-02f, 1.35594815e-01f, -2.48591155e-02f, 2.73926258e-02f, -2.16379557e-02f, -3.74823175e-02f, 7.64026912e-03f, -4.77679484e-02f, 3.00522726e-02f, -2.81501543e-02f,
  -6.79724514e-02f, 2.99270749e-02f, -1.17714979e-01f, -8.88196751e-02f, 8.84841606e-02f, 1.19608141e-01f, -2.56924517e-02f, -1.28849577e-02f, 3.07007004e-02f, -1.11498069e-02f,
  -3.14067975e-02f, -1.01543829e-01f, 1.26047516e-02f, 9.73758772e-02f, 3.37510146e-02f, -2.90986095e-02f, -3.26431841e-02f, 1.11230491e-02f, 2.18299753e-03f, -6.66993633e-02f,
  -2.49590278e-01f, -1.96746528e-01f, -4.87526841e-02f, -7.56091177e-02f, 4.14923169e-02f, 4.88767698e-02f, 4.33595069e-02f, 4.93507795e-02f, 5.96128963e-02f, 8.44548643e-02f,
  3.91057841e-02f, 6.94305748e-02f, -1.31518856e-01f, 3.83989774e-02f, -2.44957563e-02f, 2.72782985e-02f, -3.49843018e-02f, -6.27103448e-02f, 8.91424064e-03f, -8.00504908e-02f,
  -9.73401517e-02f, 9.14291386e-03f, 9.40186530e-02f, -1.58457141e-02f, -3.19283642e-02f, -5.90590686e-02f, 6.73591569e-02f, 3.85545641e-02f, -4.06894423e-02f, 6.14178553e-02f,
  1.87318042e-01f, -3.11650306e-01f, 6.44697994e-02f, 6.67712018e-02f, 3.06854844e-01f, 1.05500147e-01f, 3.39118429e-02f, 8.41274261e-02f, 1.66008577e-01f, -1.76195711e-01f,
  -1.08705819e-01f, -2.43623421e-01f, -1.49668112e-01f, -4.79996279e-02f, 6.72519729e-02f, -3.70805524e-02f, 8.21695179e-02f, 1.88291054e-02f, 7.81293884e-02f, -8.13171044e-02f,
  8.13881904e-02f, 7.42289722e-02f, 8.70417133e-02f, 1.05605297e-01f, 1.23050123e-01f, 5.12714610e-02f, -7.61471391e-02f, 8.00193027e-02f, 5.88677302e-02f, 8.16443413e-02f,
  -9.05897692e-02f, -4.20696614e-03f, -1.16337620e-01f, -6.39735982e-02f, -1.31563260e-03f, 1.62558928e-02f, -4.24393527e-02f, 4.93624061e-02f, 4.66611721e-02f, 4.13778126e-02f,
  -8.78647622e-03f, 4.71621156e-02f, 9.50511470e-02f, 3.91082987e-02f, 3.86998989e-02f, 1.24590127e-02f, 8.04346427e-02f, -5.69670685e-02f, 8.28846544e-02f, 2.12611221e-02f,
  -2.47595552e-03f, 9.27107111e-02f, -7.81185851e-02f, -7.02110827e-02f, -1.30078629e-01f, -4.10030298e-02f, 3.56529094e-03f, 5.19905202e-02f, -9.32363719e-02f, -3.34372111e-02f,
  1.81409851e-01f, 3.30231674e-02f, -8.10050499e-03f, 1.06421731e-01f, 2.00633127e-02f, 2.16221679e-02f, 7.02714100e-02f, -6.06555827e-02f, 5.89923151e-02f, -1.48441531e-02f,
  -4.02235659e-03f, 1.61373876e-02f, -2.83572692e-02f, -6.16296194e-02f, 9.05095972e-03f, -6.69409782e-02f, -8.37172791e-02f, -6.12924471e-02f, -8.82071033e-02f, -7.43925013e-03f,
  3.75267789e-02f, 5.80112962e-03f, -4.43683304e-02f, 1.25627816e-01f, 1.45414341e-02f, 4.96335402e-02f, -5.35423085e-02f, 2.86214165e-02f, 6.40839264e-02f, 3.72553878e-02f,
  -3.76969606e-01f, -2.65000403e-01f, -1.08570151e-01f, -3.72320004e-02f, -8.69270414e-02f, -6.68691397e-02f, 2.18912531e-02f, 1.06077986e-02f, -8.02191347e-02f, -2.50191186e-02f,
  -1.03105560e-01f, -2.33470052e-02f, 3.39697837e-03f, 3.69217955e-02f, -6.66703731e-02f, 4.01369296e-02f, -4.78010848e-02f, -3.01934313e-02f, -1.48050087e-02f, -1.44176874e-02f,
  -6.12884872e-02f, 6.64179854e-04f, 1.50449909e-02f, 2.82496959e-02f, -6.64300397e-02f, 5.80178164e-02f, -1.15381815e-01f, -7.48654008e-02f, 6.03657700e-02f, -6.24303780e-02f,
  -4.03371781e-01f, 2.06925303e-01f, -1.18490309e-01f, 2.06158217e-02f, -1.69176400e-01f, 2.95250416e-01f, 2.28004962e-01f, 7.72981271e-02f, 3.83733287e-02f, 2.39121154e-01f,
  9.11926553e-02f, -1.50470406e-01f, 9.55848619e-02f, 2.64023781e-01f, -1.03622481e-01f, 2.14755282e-01f, 1.56418473e-01f, 8.75532478e-02f, 1.64536051e-02f, -1.07053317e-01f,
  -4.42638062e-02f, 2.12655161e-02f, 1.46588922e-01f, -6.46212026e-02f, -1.08846746e-01f, -1.28166631e-01f, -5.08058891e-02f, -7.41277933e-02f, 5.65681309e-02f, -9.10755023e-02f,
  -1.55345380e-01f, -2.86809117e-01f, -7.62355551e-02f, -8.55716243e-02f, -1.05821259e-01f, -4.10509482e-02f, -7.34265074e-02f, -4.67418041e-03f, -4.80928384e-02f, 4.29502726e-02f,
  -2.59968196e-03f, -4.11592685e-02f, 1.75146274e-02f, 3.09014576e-03f, 3.08370553e-02f, 4.08166237e-02f, 1.39076021e-02f, -3.88619937e-02f, 2.81464793e-02f, -1.79247130e-02f,
  7.41129071e-02f, 1.07791215e-01f, 5.43534271e-02f, 6.79273605e-02f, -4.85990718e-02f, 2.58188378e-02f, 1.45460935e-02f, -9.41330940e-02f, -9.00062770e-02f, -2.05736961e-02f,
  -7.40048364e-02f, 8.54210630e-02f, 2.22197026e-02f, -3.12368497e-02f, -4.23399732e-02f, -1.01213202e-01f, 1.29353087e-02f, 4.93256934e-02f, 6.01952039e-02f, 1.21010914e-01f,
  -4.09416333e-02f, -5.01471199e-02f, -8.03686082e-02f, 9.50640365e-02f, -1.99628007e-02f, 3.04115843e-02f, -9.85660180e-02f, -6.02678321e-02f, -3.01413261e-03f, -5.36695309e-02f,
  8.73321965e-02f, 1.81376133e-02f, 5.05257323e-02f, 4.12240159e-03f, -2.31989995e-02f, 1.69680938e-02f, 4.01647436e-03f, 2.38648485e-02f, -2.12137811e-02f, -6.77730516e-02f,
  -1.24580182e-01f, -1.90517873e-01f, -3.55219357e-02f, -1.18071008e-02f, 4.56827357e-02f, -4.78697643e-02f, 1.01790644e-01f, 1.24440957e-02f, -1.20099179e-01f, -3.72082219e-02f,
  -1.00000709e-01f, 1.06132282e-02f, -2.83247959e-02f, 3.36717702e-02f, 1.33361919e-02f, -1.98692624e-02f, 2.05822662e-02f, -7.04221129e-02f, -2.32325476e-02f, 1.38283232e-02f,
  -3.89261693e-02f, -5.18982299e-02f, 8.35704282e-02f, 5.32019809e-02f, -1.21543212e-02f, -6.46183863e-02f, -5.31161763e-02f, 3.28674689e-02f, -1.22375507e-02f, 2.53510512e-02f,
  8.74137133e-02f, -8.84875059e-02f, 1.47084773e-01f, 1.34356230e-01f, 3.71527448e-02f, -1.02926806e-01f, -7.43257478e-02f, 2.48984853e-03f, 6.40385896e-02f, -1.54646233e-01f,
  -6.07062988e-02f, 1.27249405e-01f, -1.89298958e-01f, 1.42601162e-01f, 2.13501677e-02f, -2.69756079e-01f, 1.61088422e-01f, -5.44434460e-03f, -3.96670513e-02f, 1.22579470e-01f,
  1.61496982e-01f, 1.60561457e-01f, 9.63132083e-02f, 1.63808048e-01f, 1.06579531e-02f, 2.59428799e-01f, 1.13085791e-01f, -7.68387748e-04f, 1.71152174e-01f, 6.35296702e-02f,
  -8.74718130e-02f, 4.62349989e-02f, -6.36542961e-03f, -4.58767340e-02f, 6.96565881e-02f, -4.68866527e-02f, 2.09703594e-02f, 2.47420240e-02f, -4.02000546e-02f, -5.03189787e-02f,
  5.61533496e-02f, 1.54808606e-03f, 7.40947127e-02f, -3.96651961e-02f, 4.33352292e-02f, 1.90797802e-02f, 1.05228275e-01f, 9.38316882e-02f, 4.77219373e-02f, -6.40674606e-02f,
  5.07363789e-02f, 4.44010133e-03f, 1.57375723e-01f, 1.32530808e-01f, 3.99407446e-02f, 8.39694589e-02f, 6.10947683e-02f, 1.29096150e-01f, 7.78310671e-02f, 1.43469110e-01f,
  -4.16742153e-02f, 3.28590646e-02f, 9.03057829e-02f, 6.94617108e-02f, 3.67951463e-03f, 4.35989201e-02f, 1.56524274e-02f, 1.68382842e-02f, 3.72071862e-02f, 2.83862036e-02f,
  -3.89368832e-02f, 1.00331783e-01f, 1.08405918e-01f, -2.53805332e-02f, 3.67772542e-02f, -1.03583798e-01f, 2.76403502e-02f, 2.68626250e-02f, 2.39406805e-02f, -6.26018047e-02f,
  -2.29490064e-02f, -3.64613459e-02f, -5.96535727e-02f, -2.25585289e-02f, -2.33405316e-03f, 5.83815761e-03f, -9.94011983e-02f, -4.85517867e-02f, 5.49419746e-02f, -1.60622578e-02f,
  -9.70899761e-02f, -2.05585323e-02f, 7.84495696e-02f, 4.17775437e-02f, 2.71958783e-02f, 3.52350958e-02f, 5.04489169e-02f, -7.31326118e-02f, -9.09405276e-02f, 1.75805558e-02f,
  7.05494434e-02f, -1.58480406e-02f, 4.54994030e-02f, 4.73742895e-02f, 2.09953152e-02f, -5.16208149e-02f, 1.38310507e-01f, 2.95374859e-02f, 1.88477978e-01f, -8.69775191e-02f,
  -1.00446194e-01f, -6.25633076e-03f, -7.64811179e-03f, 1.54264823e-01f, -1.18657043e-02f, -2.41283160e-02f, 7.76803866e-02f, -9.87051502e-02f, -7.08818063e-02f, 5.08834198e-02f,
  2.04901189e-01f, -1.35807738e-01f, -2.44906828e-01f, -3.66329961e-02f, 9.66379419e-02f, 1.98671073e-01f, -1.00841016e-01f, 4.58826460e-02f, -7.05544055e-02f, -4.58305813e-02f,
  1.05405331e-01f, -1.73025012e-01f, -1.74815729e-01f, 2.52338856e-01f, 2.02806756e-01f, -1.65717855e-01f, 1.77647784e-01f, 6.42889738e-02f, 4.66880612e-02f, 1.39018357e-01f,
  2.39635967e-02f, 3.36383671e-01f, -1.86814353e-01f, 6.00908473e-02f, 1.37316391e-01f, 2.55520642e-02f, 3.13102379e-02f, -1.42977551e-01f, 1.53424755e-01f, 4.39558318e-03f,
  1.31807327e-02f, -6.08648360e-03f, -1.60622015e-03f, -3.03829294e-02f, -7.57678822e-02f, 1.33969672e-02f, 1.00241462e-03f, -6.15791418e-02f, -2.74645109e-02f, -4.85229157e-02f,
  -5.16292341e-02f, 4.88494672e-02f, 3.26241106e-02f, -2.85068508e-02f, 6.84436411e-02f, -4.70773643e-03f, 3.44316103e-02f, -7.18815923e-02f, 1.09322499e-02f, 1.39597533e-02f,
  -1.80981264e-01f, -5.13921783e-04f, 1.31882578e-01f, -1.44359156e-01f, -8.37869719e-02f, 3.10209990e-02f, 7.51870498e-02f, -9.83924121e-02f, 3.59075740e-02f, -3.06347478e-02f,
  3.73132043e-02f, -4.09281403e-02f, 6.45555332e-02f, 2.13702675e-02f, -8.22538435e-02f, 6.89242035e-02f, 8.79404247e-02f, -6.68760762e-02f, -5.76521195e-02f, -6.21681102e-02f,
  -3.08307260e-02f, -3.84657318e-03f, 4.56282012e-02f, 3.41437012e-02f, 4.39067967e-02f, -1.81294531e-02f, -4.89729196e-02f, 3.20662148e-02f, -9.05062184e-02f, -8.47125892e-03f,
  -1.79563463e-02f, 4.39099371e-02f, 3.53114516e-03f, 2.02525081e-03f, 6.36559958e-03f, -4.13072519e-02f, -2.34396234e-02f, 1.43330125e-02f, -1.01278871e-01f, 2.93229930e-02f,
  -9.98406764e-03f, -1.14167824e-01f, -6.45607412e-02f, 7.06442297e-02f, -6.52939230e-02f, 1.15998660e-03f, -8.85841325e-02f, 3.97388637e-02f, 1.22761540e-02f, -5.26804253e-02f,
  -2.75765676e-02f, 1.77172758e-02f, 5.79860955e-02f, 5.54762706e-02f, -6.24651834e-03f, -6.50803698e-03f, -5.97671941e-02f, -2.90857945e-02f, 2.00780947e-02f, 1.38277680e-01f,
  -6.19972199e-02f, -3.06670740e-02f, -4.08423617e-02f, -4.43879887e-02f, 3.98205519e-02f, -2.38657705e-02f, 4.61905152e-02f, -4.65230504e-03f, 4.43650000e-02f, -1.88476704e-02f,
  8.77862275e-02f, -1.40436113e-01f, -1.95720464e-01f, 6.05673306e-02f, -4.45901342e-02f, -3.73927429e-02f, -5.98264299e-02f, -1.96189038e-03f, -2.53164321e-01f, 8.86526778e-02f,
  2.38575324e-01f, -5.37953191e-02f, 5.93434460e-02f, 1.64392844e-01f, 1.44481033e-01f, -1.33739263e-01f, 2.11944237e-01f, -2.92425342e-02f, 4.37432975e-02f, 9.21766907e-02f,
  1.28091335e-01f, 1.65294811e-01f, -6.25269208e-03f, 1.53349876e-01f, 1.30431607e-01f, -7.15367729e-03f, 1.71618298e-01f, 4.09471011e-03f, 2.35616833e-01f, 4.04865183e-02f,
  6.13150261e-02f, 4.57330719e-02f, -2.06409749e-02f, -1.50822237e-01f, 2.26252079e-02f, 1.37159750e-01f, 1.21795107e-02f, -1.24618441e-01f, 8.00979557e-04f, -4.49040681e-02f,
  -1.44157372e-02f, -3.40808369e-02f, -8.20645317e-02f, -1.83404833e-02f, -4.46937121e-02f, 1.84712186e-02f, -8.59250426e-02f, -1.12731211e-01f, -5.24152853e-02f, 5.48308864e-02f,
  -1.53804705e-01f, -7.35936537e-02f, -8.11606273e-02f, 1.60816591e-02f, -7.89577365e-02f, 1.29991369e-02f, 9.37905570e-04f, 5.85788302e-02f, -5.78236282e-02f, -2.11700741e-02f,
  3.51896845e-02f, -7.34400703e-03f, 1.43575324e-02f, -1.14754267e-01f, 2.86662765e-02f, 7.20526353e-02f, 3.15764584e-02f, 2.25466229e-02f, 9.20304470e-03f, 4.72479127e-02f,
  9.96036455e-02f, 4.22763601e-02f, -2.58427598e-02f, -8.68165120e-02f, 8.27923286e-05f, 3.99181396e-02f, 2.77886465e-02f, -3.52670550e-02f, -3.78822386e-02f, -7.94182718e-03f,
  -1.53798480e-02f, -4.27090041e-02f, 6.48700371e-02f, -3.78921814e-02f, -6.05882294e-02f, 4.56788316e-02f, 3.86391990e-02f, -1.41202118e-02f, -6.48028925e-02f, 3.65399718e-02f,
  4.31125462e-02f, 6.57093003e-02f, -9.84664261e-02f, -2.56069507e-02f, 3.74617837e-02f, 9.28629115e-02f, -2.17812811e-03f, 7.75308302e-03f, -8.61259736e-03f, -5.09521067e-02f,
  3.17336656e-02f, -7.28546977e-02f, 1.21144885e-02f, 1.85780507e-02f, 4.19150805e-03f, 6.47588149e-02f, 1.66309085e-02f, -6.21502139e-02f, 1.22383416e-01f, 8.15767273e-02f,
  5.02365083e-02f, 3.52463610e-02f, 7.12597072e-02f, -1.35919437e-01f, -2.91254744e-02f, 1.63606256e-02f, 6.83845952e-02f, 4.12545986e-02f, 6.76261857e-02f, -1.18355967e-01f,
  6.00997172e-02f, 8.21159128e-03f, -1.41342282e-01f, -9.40435976e-02f, -1.44043654e-01f, -1.47492781e-01f, -2.16723345e-02f, -1.02244623e-01f, -1.09883090e-02f, 1.39038444e-01f,
  8.97552222e-02f, 5.45366146e-02f, 1.13066852e-01f, 9.86495018e-02f, 1.58521950e-01f, 2.42858753e-01f, -4.45702262e-02f, 1.96573772e-02f, -4.38586958e-02f, 5.05503677e-02f,
  2.42452975e-02f, -8.00267421e-03f, 5.37292548e-02f, -1.49572209e-01f, -8.61110017e-02f, -1.09953284e-01f, 1.33128196e-01f, -9.44486037e-02f, -1.03474632e-01f, 7.07568154e-02f,
  7.17403665e-02f, 8.75124261e-02f, 8.77364445e-03f, 1.32905580e-02f, -1.76393297e-02f, -8.48749131e-02f, -1.46409467e-01f, 1.33088389e-02f, 1.60534531e-02f, -2.49538030e-02f,
  2.33790129e-02f, -4.36798781e-02f, 5.38345277e-02f, 3.81192863e-02f, -1.08097702e-01f, 3.99152264e-02f, 8.68202746e-02f, -1.41382903e-01f, 4.02717702e-02f, -7.93475062e-02f,
  1.59806572e-02f, 1.71811115e-02f, -6.49219006e-02f, -1.98723264e-02f, -7.60365725e-02f, -2.92188022e-02f, 4.03341465e-02f, -3.83772962e-02f, -3.31914686e-02f, -7.85020366e-02f,
  -1.29668321e-02f, 1.70122401e-03f, -1.88761055e-02f, 8.35974738e-02f, 9.61699337e-02f, -3.55936252e-02f, -2.98370942e-02f, 8.56035501e-02f, 1.15891747e-01f, 9.53091085e-02f,
  2.54565962e-02f, -1.50798047e-02f, 2.31073063e-04f, 8.51090476e-02f, 9.86852571e-02f, 3.83297503e-02f, 4.59292680e-02f, 4.44605835e-02f, -1.83116257e-01f, -4.33191545e-02f,
  1.23240568e-01f, 1.16452463e-01f, 5.85119985e-02f, 6.25423566e-02f, -1.96716562e-02f, -8.41096640e-02f, -5.48768379e-02f, -7.51846135e-02f, -5.64741828e-02f, -1.60154235e-02f,
  7.23507032e-02f, 4.70194742e-02f, 5.22053726e-02f, 6.04675859e-02f, 1.42328246e-02f, -2.46751122e-02f, -8.34085792e-02f, -2.06526648e-02f, 6.90463632e-02f, 1.42407954e-01f,
  5.87197952e-03f, 1.06119521e-01f, -1.75871290e-02f, -1.25541851e-01f, -2.05616057e-02f, -3.34928334e-02f, 4.19463264e-03f, 4.47259061e-02f, -6.37672693e-02f, -4.18169908e-02f,
  2.15283968e-03f, 1.25287510e-02f, 9.03023183e-02f, 1.66743938e-02f, -3.39537039e-02f, 5.55327013e-02f, -1.77139472e-02f, -5.09741157e-02f, -7.65158609e-02f, 7.74643421e-02f,
  1.94030583e-01f, -8.59274045e-02f, -2.53731698e-01f, -3.87368575e-02f, -1.13647334e-01f, -3.55659097e-01f, -3.21842492e-01f, -1.26134530e-01f, -1.02179401e-01f, 3.53706293e-02f,
  -8.90583694e-02f, -1.95803806e-01f, 1.68884397e-01f, -1.91140652e-01f, -1.30162537e-01f, 2.04427198e-01f, -3.53276521e-01f, -2.45600849e-01f, 9.75835472e-02f, -1.45714372e-01f,
  4.90493029e-02f, -3.59615590e-03f, -2.39251405e-01f, 5.91177791e-02f, -1.90608323e-01f, 1.47927642e-01f, 2.30534375e-01f, 1.12499669e-01f, -1.07190900e-01f, -7.85906464e-02f,
  -1.21904060e-01f, 1.39000386e-01f, -1.46227200e-02f, -1.27631471e-01f, -2.79614702e-02f, 1.66222826e-02f, -4.30328846e-02f, 5.29663898e-02f, 1.17877554e-02f, -7.13685853e-03f,
  -1.04085907e-01f, 4.84511256e-02f, -7.99077526e-02f, -2.93831341e-02f, -1.56433079e-02f, -1.08946443e-01f, 2.40221024e-02f, -1.24607190e-01f, -5.24031855e-02f, -3.61838713e-02f,
  -1.19278736e-01f, -3.60282660e-02f, -3.22736166e-02f, -1.36099625e-02f, -6.71173632e-02f, 8.97136400e-04f, -1.00313894e-01f, -1.14242874e-01f, 2.75150090e-02f, -3.83048952e-02f,
  1.29895240e-01f, 6.75617680e-02f, 6.94332570e-02f, -3.21262889e-02f, 7.41001293e-02f, 1.08888052e-01f, 3.47649865e-02f, -2.77081374e-02f, 7.46552125e-02f, -1.66009814e-02f,
  -2.19811592e-02f, 4.74187769e-02f, 7.05829561e-02f, 7.25078210e-03f, -6.65759295e-02f, 8.48853439e-02f, 8.78953096e-03f, -1.76911205e-02f, -4.56201471e-02f, -7.56137148e-02f,
  2.16204040e-02f, 1.18506672e-02f, 4.11822274e-02f, -9.78675950e-03f, 3.25998664e-02f, -5.07143289e-02f, 3.44274566e-02f, -2.79988535e-02f, 4.26549613e-02f, 2.37831706e-03f,
  -2.43974458e-02f, 3.02096847e-02f, -7.58227184e-02f, -3.93796992e-03f, 1.61251929e-02f, 3.57616250e-03f, -6.57990351e-02f, -8.68449435e-02f, -9.46864039e-02f, 2.65335217e-02f,
  5.02264872e-03f, -2.00794544e-03f, 6.14328310e-02f, 2.42190268e-02f, -6.04727268e-02f, -1.40475687e-02f, 2.48211349e-04f, 7.22876117e-02f, -2.65553687e-02f, 9.12495852e-02f,
  -3.22129764e-02f, 6.44754618e-02f, 5.27592674e-02f, -7.75436964e-03f, 5.69439791e-02f, -6.23990633e-02f, -2.61772498e-02f, -2.45686024e-02f, 7.77703747e-02f, -2.45338343e-02f,
  2.49101788e-01f, 2.33261108e-01f, 3.40386927e-01f, 3.04909736e-01f, -1.30492464e-01f, -2.29668230e-01f, -1.15297943e-01f, 7.85677209e-02f, 1.35264978e-01f, -8.58514830e-02f,
  -4.23246287e-02f, 2.72329450e-01f, -9.54421163e-02f, 1.47573888e-01f, -1.08489968e-01f, -9.64703783e-02f, 1.67062700e-01f, 5.13697900e-02f, 9.22301561e-02f, 2.08992898e-01f,
  1.56470403e-01f, -2.17405297e-02f, 1.64102495e-01f, 4.88250516e-03f, 2.52766520e-01f, 1.86545312e-01f, -3.30292843e-02f, -1.51923612e-01f, 8.97827521e-02f, 1.63716190e-02f,
  -1.07377380e-01f, 5.53730354e-02f, 1.20423324e-01f, 6.28202185e-02f, -2.84206159e-02f, -2.30621230e-02f, -8.44400600e-02f, -8.94487277e-02f, 5.01035480e-03f, 1.91391073e-02f,
  -1.10222807e-03f, -1.33846449e-02f, 2.29458977e-02f, -2.06146054e-02f, -3.81123014e-02f, 7.88602829e-02f, 2.16904897e-02f, -1.14554854e-03f, 9.46001559e-02f, 1.00165084e-01f,
  5.62248379e-02f, 4.12887447e-02f, -3.96747477e-02f, -3.46223405e-03f, 8.48313048e-02f, -1.52630580e-03f, 6.20138226e-03f, 6.77798986e-02f, -1.12318210e-02f, -8.34704936e-03f,
  4.16242965e-02f, -8.97940323e-02f, -6.68129139e-03f, -3.75510417e-02f, 3.25259194e-02f, -4.44727316e-02f, -9.30716246e-02f, -5.41924611e-02f, -4.29985002e-02f, -1.11398892e-02f,
  4.71907966e-02f, 9.85856950e-02f, -6.84485808e-02f, -5.59761003e-03f, 1.20269336e-01f, 4.74381596e-02f, -1.96243450e-02f, -4.45830747e-02f, 1.20884307e-01f, 9.65799466e-02f,
  -1.83380414e-02f, -7.60039454e-03f, 7.95001164e-02f, -2.55146418e-02f, -1.29111767e-01f, 5.41090406e-02f, -3.77976261e-02f, 9.09142941e-02f, -4.80270758e-02f, 1.19156577e-01f,
  4.68263477e-02f, 9.80261117e-02f, 1.18576981e-01f, 6.78512678e-02f, -1.24778282e-02f, -6.91952780e-02f, -3.16761658e-02f, 1.30879804e-01f, 1.13156863e-01f, 1.56487525e-02f,
  1.72806829e-02f, 1.59876235e-02f, -2.65587717e-02f, -7.85737261e-02f, 4.62276153e-02f, 2.53876690e-02f, -3.43371369e-02f, 1.22948259e-01f, -5.21150827e-02f, 1.16389513e-01f,
  2.22528577e-02f, -9.84524265e-02f, 6.08343035e-02f, 8.39757323e-02f, 3.07535054e-03f, -3.96372676e-02f, -6.56671301e-02f, 5.76623715e-02f, -1.79497767e-02f, -2.03826297e-02f,
  4.68134105e-01f, 1.42191231e-01f, 1.82635978e-01f, 2.68959254e-01f, 1.34019613e-01f, 1.31771088e-01f, 1.92191149e-03f, 7.49445334e-02f, 2.64929086e-01f, 7.95055255e-02f,
  -8.90433788e-02f, 2.00736865e-01f, -2.35445663e-01f, 1.41308025e-01f, -1.55429199e-01f, -1.65735736e-01f, 1.12195596e-01f, 1.75806269e-01f, 8.72601494e-02f, 1.52236953e-01f,
  -6.40125647e-02f, -1.36783957e-01f, -7.55751878e-02f, -1.25182182e-01f, 3.26208085e-01f, 9.57131386e-02f, -2.18458787e-01f, -1.90389797e-01f, -5.05727269e-02f, -1.11032948e-01f,
  1.49836261e-02f, 6.52988181e-02f, 6.86429664e-02f, -1.43962279e-02f, 5.64668477e-02f, -6.96675554e-02f, 8.88412893e-02f, -1.19004332e-01f, -1.42041400e-01f, -1.62257142e-02f,
  2.48795506e-02f, -1.26655279e-02f, 1.94680004e-03f, -5.33497892e-02f, 3.23772281e-02f, 8.74382183e-02f, 6.35128319e-02f, 5.53657487e-02f, 1.44475833e-01f, 6.23748191e-02f,
  1.34512424e-01f, 1.02429658e-01f, 1.08030196e-02f, -4.30625938e-02f, -2.75963675e-02f, 5.00009209e-02f, 2.44837757e-02f, 4.11171354e-02f, 2.97632013e-02f, 1.53100446e-01f,
  -9.22975168e-02f, -6.86395541e-02f, -3.22970524e-02f, -2.80086324e-02f, 3.90310213e-02f, 1.33464951e-02f, -4.58188243e-02f, -1.19761378e-01f, -6.07716572e-03f, 9.15253982e-02f,
  3.21368091e-02f, 9.55439806e-02f, 3.36694904e-03f, 6.17690347e-02f, -2.02335697e-02f, 1.32178023e-01f, -6.23918101e-02f, 2.79701228e-04f, 1.74747370e-02f, 7.17184544e-02f,
  -7.74081871e-02f, -8.93648118e-02f, -7.72668272e-02f, -1.43838180e-02f, -4.04498279e-02f, -1.34634942e-01f, -4.30616271e-03f, 3.53433825e-02f, -2.30771471e-02f, -5.88964745e-02f,
  -4.68264706e-02f, -8.83222520e-02f, -5.53538278e-02f, -1.03794001e-01f, 1.83191560e-02f, 1.14186350e-02f, 2.13634837e-02f, 9.35029685e-02f, 8.96310713e-03f, -1.02616228e-01f,
  -7.21286312e-02f, -6.88813999e-02f, 5.31698205e-02f, -2.28920616e-02f, -1.01743571e-01f, -1.89758372e-02f, 1.42852273e-02f, -3.26752923e-02f, -1.10814953e-02f, 5.36634922e-02f,
  2.51145530e-02f, -9.01033357e-03f, 3.94574106e-02f, 8.22319537e-02f, 5.97283617e-02f, -9.20088030e-03f, -3.82457078e-02f, 9.58121493e-02f, -6.43974263e-03f, -5.35294935e-02f,
  3.59332085e-01f, -3.38659137e-02f, 2.06986745e-03f, 1.33022740e-01f, 2.69417346e-01f, 1.21745609e-01f, 2.43734002e-01f, 1.98496118e-01f, 2.04136118e-01f, -8.96487013e-02f,
  1.53900027e-01f, -9.83637720e-02f, -1.29931733e-01f, 2.13174343e-01f, 5.36105670e-02f, -6.20579720e-03f, 2.06748202e-01f, 1.22018419e-01f, 5.07802293e-02f, 4.54337448e-02f,
  1.11912161e-01f, 7.99016207e-02f, -1.49234593e-01f, -8.52591619e-02f, 3.29363644e-02f, -6.17668545e-03f, -1.27592728e-01f, -4.57383879e-02f, -5.69433831e-02f, 1.21386036e-01f,
  6.99986517e-02f, 7.38675892e-02f, 1.93079077e-02f, -1.02986477e-01f, -8.37857276e-02f, -5.86256050e-02f, -7.68612623e-02f, -6.56354353e-02f, 1.09429061e-01f, 2.87042223e-02f,
  1.14224376e-02f, 4.88092341e-02f, 1.37280086e-02f, -1.35107376e-02f, -4.05643554e-03f, 5.49760938e-04f, 1.69344954e-02f, -1.51604703e-02f, -6.23588413e-02f, -6.13068752e-02f,
  3.57836373e-02f, -2.19663046e-03f, 1.02350958e-01f, 1.82167422e-02f, 7.85738602e-02f, 9.01121721e-02f, -2.30210489e-07f, -2.52625421e-02f, 1.08723389e-02f, -3.37571204e-02f,
  9.24642384e-02f, 2.13385839e-02f, 1.01525702e-01f, 1.58467349e-02f, -4.24789311e-03f, 5.51183149e-02f, 5.50754182e-02f, 8.10204595e-02f, 8.35981667e-02f, -1.59864686e-02f,
  1.98287759e-02f, -2.48868428e-02f, -5.78002296e-02f, -1.39802098e-01f, 4.64762328e-03f, -2.79976632e-02f, -9.10502821e-02f, 8.07810649e-02f, 1.51659390e-02f, 5.67742139e-02f,
  -5.69102131e-02f, -2.02969313e-02f, 3.22690681e-02f, -6.35716245e-02f, -1.06555335e-02f, 1.01018675e-01f, -4.59559634e-02f, -5.73740806e-03f, 8.17783847e-02f, -5.23234755e-02f,
  9.96532738e-02f, -4.53405231e-02f, -7.05159456e-02f, -1.94092989e-02f, 3.99746336e-02f, 1.38893807e-02f, 6.93646818e-02f, 6.10813275e-02f, -5.02460338e-02f, 6.59462735e-02f,
  1.03019644e-02f, -1.57562941e-02f, 1.03351198e-01f, -5.13640754e-02f, 5.73780537e-02f, 6.88300729e-02f, 3.13992761e-02f, 5.59172500e-03f, 3.12040839e-02f, -4.16642660e-03f,
  -4.26145718e-02f, 1.12678424e-01f, -2.00518370e-02f, 1.30206391e-01f, 5.13321273e-02f, -6.59793541e-02f, 2.55167615e-02f, -1.00095198e-01f, -1.26282945e-02f, -6.40409021e-03f,
  -1.89309359e-01f, 6.33587688e-02f, 3.57909948e-01f, 1.10329250e-02f, 1.21205382e-01f, 2.81681746e-01f, 2.57173926e-01f, 1.64647594e-01f, 2.34241962e-01f, -8.97871703e-03f,
  -1.76728219e-01f, -7.40579367e-02f, 7.45280534e-02f, -5.94738685e-02f, 2.52616525e-01f, 1.49293169e-01f, 1.72291234e-01f, 9.54163596e-02f, 1.03788361e-01f, -6.35095835e-02f,
  -8.28392133e-02f, -1.23495527e-01f, -1.12015568e-01f, -3.58934440e-02f, -2.75251597e-01f, -5.22165671e-02f, -1.87745214e-01f, 1.56754434e-01f, -1.79538682e-01f, 4.21084538e-02f,
  -2.58852728e-03f, 1.92074217e-02f, 3.52366641e-02f, 6.40839338e-02f, -9.26868096e-02f, -4.80167083e-02f, -4.77967001e-02f, 1.30978003e-01f, 9.83139947e-02f, 5.89139238e-02f,
  -4.23760489e-02f, -4.08207551e-02f, 1.50272632e-02f, -6.88510463e-02f, 5.12156524e-02f, -4.59765531e-02f, 5.54316491e-03f, -8.62124711e-02f, 8.09779614e-02f, -8.55655074e-02f,
  3.01545486e-02f, -4.95368466e-02f, 4.87909019e-02f, -3.63416970e-02f, 4.20892388e-02f, 1.20669596e-01f, 5.81595264e-02f, -1.59498546e-02f, -7.39510544e-03f, -2.89309490e-02f,
  8.25253204e-02f, 1.50345445e-01f, -2.36031134e-03f, -3.72720510e-02f, -1.08530752e-01f, -6.47211000e-02f, -9.73584224e-03f, -9.18489769e-02f, 2.64169481e-02f, -7.50362799e-02f,
  -3.16099152e-02f, 5.03339991e-02f, 5.02117947e-02f, -2.63548102e-02f, -2.20916141e-02f, 5.23933135e-02f, -1.08241044e-01f, -5.54038621e-02f, 5.52640343e-03f, -4.58372757e-02f,
  4.23138440e-02f, 9.37581137e-02f, -7.88782910e-02f, -6.06932938e-02f, 2.73090750e-02f, 1.98915564e-02f, -7.26498738e-02f, 9.08750226e-04f, -8.30735452e-03f, 6.21208809e-02f,
  6.18539453e-02f, 1.44187540e-01f, -1.09476934e-03f, -7.13480860e-02f, 1.27023254e-02f, -7.13416114e-02f, 9.65848714e-02f, -7.94921294e-02f, 7.21618757e-02f, 8.41278583e-02f,
  -3.17839906e-02f, -8.64677131e-02f, -5.37979268e-02f, 6.28063129e-03f, 3.03234067e-02f, -2.07602829e-02f, 1.23366890e-02f, 4.75363694e-02f, -6.87435940e-02f, 6.20971844e-02f,
  1.50422463e-02f, -4.69977818e-02f, -7.07557946e-02f, -2.31182612e-02f, 1.61553826e-02f, -1.56654865e-02f, 3.18368822e-02f, 6.56385571e-02f, -4.50255014e-02f, 3.20583470e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 40)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 40;
const float L0_fan_Bp_bar_data[] = {
  1.61310717e-01f, 1.23091809e-01f, 2.71767586e-01f, 1.95168987e-01f, 2.35847354e-01f, 2.54726589e-01f, 2.33896777e-01f, 6.44128546e-02f, 1.02573402e-01f, 2.23643914e-01f,
  2.46673124e-03f, 1.66376650e-01f, 1.14062734e-01f, 1.12909928e-01f, 1.29170626e-01f, 8.62163901e-02f, 7.85450488e-02f, 1.18020751e-01f, -3.37631479e-02f, 2.13688821e-01f,
  1.71320915e-01f, 1.29123390e-01f, 1.62807316e-01f, 1.10197961e-01f, 2.20219389e-01f, 1.12158984e-01f, 1.60098344e-01f, 1.98076919e-01f, 2.57000417e-01f, 1.74427927e-01f,
  1.81444421e-01f, 2.10326076e-01f, 8.39381143e-02f, 8.86419266e-02f, 9.74219814e-02f, 3.59851755e-02f, 2.22556710e-01f, 2.68084675e-01f, 1.85575843e-01f, 2.67916232e-01f
};

// L1_fan_Wp (Shape: 12 x 64)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 64;
const float L1_fan_Wp_data[] = {
  1.14052355e-01f, 1.06785543e-01f, -2.11183485e-02f, -3.53516787e-02f, -6.12455569e-02f, -7.30642453e-02f, 2.08883360e-01f, 1.37505591e-01f, -3.71606797e-02f, 8.54361337e-03f,
  8.94525796e-02f, 1.77990235e-02f, 2.67850280e-01f, 6.56346083e-02f, -1.04733475e-01f, -1.72298416e-01f, -8.75000060e-02f, -2.48120010e-01f, 4.13515493e-02f, 1.67265579e-01f,
  3.00714895e-02f, -1.01754807e-01f, 1.76831841e-01f, -3.92779186e-02f, 2.11075954e-02f, -8.80697370e-02f, 2.42100712e-02f, -6.99899718e-02f, 1.49241745e-01f, 2.42543109e-02f,
  4.10073809e-02f, 1.33367628e-01f, 1.59759402e-01f, 5.84099256e-02f, 3.85184847e-02f, -1.51307255e-01f, 1.75996050e-01f, -1.76235102e-02f, -5.33313267e-02f, -5.44584319e-02f,
  -1.14738077e-01f, 9.78624970e-02f, 6.39180318e-02f, -1.76654190e-01f, -2.32127272e-02f, 9.32635143e-02f, 1.22495808e-01f, -2.38900185e-01f, 7.27705285e-02f, -1.08526766e-01f,
  5.31928651e-02f, -1.34072781e-01f, 1.23995215e-01f, 5.10112420e-02f, 6.70778677e-02f, -7.77037591e-02f, -2.07806185e-01f, 1.84618533e-02f, 8.26090865e-04f, -1.69584572e-01f,
  -1.92005545e-01f, -2.09564105e-01f, -1.57742038e-01f, 1.17654659e-01f, -1.38485566e-01f, 3.27761136e-02f, 1.14554986e-01f, -5.47171198e-02f, 8.24598446e-02f, -1.17997013e-01f,
  -1.78206101e-01f, -1.06146380e-01f, -1.59243062e-01f, -2.65266988e-02f, 4.36855406e-02f, -8.27105995e-03f, -3.73986885e-02f, 4.60015573e-02f, -8.22528601e-02f, 6.96937274e-03f,
  9.08599943e-02f, 4.63072136e-02f, 1.36325374e-01f, -2.37959057e-01f, -1.97358191e-01f, -1.11051761e-01f, -1.42849103e-01f, 1.67146564e-01f, 4.75792587e-02f, 1.82941198e-01f,
  -1.02152437e-01f, -8.22317004e-02f, 2.30387136e-01f, -3.25769535e-03f, -2.27545708e-01f, 2.44207263e-01f, -1.02932744e-01f, 6.80446848e-02f, 2.09384412e-01f, -1.94430992e-01f,
  8.60553682e-02f, 8.16186219e-02f, 1.95956558e-01f, 1.10543659e-02f, -1.14918970e-01f, -1.62894592e-01f, 1.42907366e-01f, 5.16449474e-02f, -1.19205460e-01f, -3.54223885e-02f,
  -7.90048316e-02f, -3.83190289e-02f, -2.07995743e-01f, -2.12903216e-01f, 9.22650546e-02f, 4.92313392e-02f, 2.47477237e-02f, -2.42450967e-01f, 1.61965173e-02f, 1.25130981e-01f,
  -1.90647840e-01f, 1.19500309e-02f, 1.94043577e-01f, 2.83616424e-01f, 1.13562584e-01f, 1.22626051e-01f, 6.27049208e-02f, -9.62536633e-02f, -1.84513927e-02f, 1.94918867e-02f,
  1.56056523e-01f, 1.15042463e-01f, 1.27922446e-01f, 1.58568725e-01f, -6.09819740e-02f, -1.27772063e-01f, 5.93251809e-02f, 8.52253065e-02f, 2.00183302e-01f, 1.61630511e-01f,
  1.69998214e-01f, -5.69245704e-02f, 1.12363808e-01f, -7.36422688e-02f, 1.08997628e-01f, -1.56725287e-01f, -8.78137443e-03f, 1.47973001e-01f, 4.90673222e-02f, 1.88415095e-01f,
  1.06385082e-01f, -9.80745703e-02f, -2.41558794e-02f, 1.32610468e-04f, 1.74616516e-01f, -1.77141830e-01f, 2.33027816e-01f, 8.52404535e-02f, -1.58253327e-01f, -1.90428197e-01f,
  -1.34691745e-01f, 6.07533045e-02f, 1.45867988e-01f, -2.44028434e-01f, 1.92262322e-01f, 1.92497554e-03f, -1.55019999e-01f, -1.04376502e-01f, 1.55381113e-01f, 3.26367877e-02f,
  -9.24867168e-02f, -1.07525485e-02f, 4.35896479e-02f, 1.10814005e-01f, -1.24639370e-01f, -1.69221535e-01f, -4.36594747e-02f, 1.11891478e-01f, -6.92953095e-02f, 1.19325072e-01f,
  1.44257369e-02f, -2.24759877e-01f, 5.47107346e-02f, -6.56845719e-02f, 1.07925713e-01f, -2.78910268e-02f, -7.32542798e-02f, 7.14724092e-03f, -1.56349346e-01f, 1.95765123e-01f,
  1.52944587e-02f, -9.84364003e-02f, 2.70214789e-02f, 1.07763000e-01f, -3.18122171e-02f, -5.19550778e-02f, 8.11214745e-03f, 6.57143518e-02f, -1.51517531e-02f, 8.69552419e-02f,
  9.92438942e-02f, -5.17551973e-02f, -1.65754240e-02f, 1.20464213e-01f, 1.16953580e-02f, -1.51456520e-02f, 1.10089201e-02f, -1.02214210e-01f, -7.05387890e-02f, 6.07371628e-02f,
  -1.76816564e-02f, 5.61663099e-02f, -1.73200741e-01f, 6.40886649e-02f, -1.14030756e-01f, -1.38660416e-01f, 1.97079908e-02f, -1.20313168e-01f, -1.81004480e-02f, -1.19952090e-01f,
  -4.92195450e-02f, 5.10815568e-02f, -2.87818816e-02f, 1.96404561e-01f, -4.07898873e-02f, -3.47871520e-02f, -7.04225851e-04f, -1.06633097e-01f, 5.97635321e-02f, 2.23553270e-01f,
  4.82051037e-02f, -6.17488958e-02f, -2.68649776e-02f, 1.70085639e-01f, 2.88539797e-01f, -8.51035342e-02f, -1.87737539e-01f, 1.12397023e-01f, 1.56967461e-01f, -1.75446957e-01f,
  1.28383607e-01f, 7.53122419e-02f, 1.07293606e-01f, -1.38001457e-01f, 7.95249939e-02f, -1.96215183e-01f, -4.98044938e-02f, -7.40165869e-03f, -8.58421102e-02f, 8.30169842e-02f,
  -5.11635421e-03f, 3.85922156e-02f, -6.86640367e-02f, -1.84148803e-01f, -1.33596122e-01f, -4.27871831e-02f, 2.19524205e-02f, 2.18250882e-02f, -5.93687817e-02f, -2.76850406e-02f,
  -4.13764082e-02f, -1.71865653e-02f, -2.71045230e-02f, -1.54237375e-01f, -1.29409686e-01f, 1.20707586e-01f, 3.61711793e-02f, 4.10188083e-03f, -1.28744736e-01f, -4.95870747e-02f,
  1.00407198e-01f, -2.69355234e-02f, -1.18452318e-01f, 3.57874110e-02f, -9.83008444e-02f, 1.89029146e-02f, -5.63156679e-02f, -1.87305331e-01f, 2.81585511e-02f, -2.16460884e-01f,
  5.38680591e-02f, 9.10190307e-03f, 2.36134324e-02f, -2.47627273e-01f, -2.17859849e-01f, 3.31971794e-02f, -1.47000328e-01f, 2.10729420e-01f, -1.09708905e-01f, 5.06910868e-02f,
  -1.12108961e-02f, -1.01782463e-01f, 1.68790650e-02f, 8.12098831e-02f, -1.54865682e-01f, -1.72520235e-01f, -8.58969092e-02f, -1.50705561e-01f, 1.17757022e-01f, -1.01316102e-01f,
  -3.14058959e-02f, 1.68369666e-01f, 1.27154142e-01f, 1.20729789e-01f, -8.96900520e-02f, -5.62925935e-02f, 1.59934476e-01f, 1.12070836e-01f, 5.87978698e-02f, -6.55915812e-02f,
  -4.30792309e-02f, -7.75467530e-02f, -1.14570912e-02f, 5.03591448e-02f, -8.05754811e-02f, 1.58486411e-01f, 2.13762715e-01f, 1.64451316e-01f, -9.37897712e-02f, 3.96541543e-02f,
  3.27124372e-02f, 3.35434428e-03f, -6.17671991e-03f, 8.51761643e-03f, -2.33929176e-02f, 1.32027224e-01f, -9.53536853e-03f, -1.30366638e-01f, 1.27086893e-01f, -2.89241895e-02f,
  -9.74212438e-02f, -9.53687876e-02f, -1.33064851e-01f, -7.76689947e-02f, -1.11165367e-01f, 8.28932375e-02f, 1.96448788e-01f, 1.62141502e-01f, 4.56910208e-02f, -1.15657605e-01f,
  -1.53297663e-01f, 9.08027142e-02f, -1.80812106e-01f, 7.83343986e-02f, -1.88480943e-01f, -1.58909522e-02f, -7.48646855e-02f, -1.78765282e-01f, 1.04526095e-01f, -1.33909747e-01f,
  -1.83019593e-01f, 1.03305981e-01f, -1.46529421e-01f, 8.44621062e-02f, 8.81003067e-02f, -6.95452606e-03f, 1.06761130e-02f, -4.23523970e-02f, 2.59164385e-02f, -8.17030519e-02f,
  -9.28428099e-02f, -2.06879616e-01f, -1.81660488e-01f, 8.16171318e-02f, 7.34358355e-02f, -5.66593297e-02f, -1.15638621e-01f, 1.14205092e-01f, -1.90963551e-01f, -1.79420635e-02f,
  1.13837719e-01f, 1.86175942e-01f, -1.83511227e-02f, 1.80672656e-03f, -5.82102826e-03f, 1.06149642e-02f, 4.58827764e-02f, 1.51574031e-01f, 2.05089245e-02f, -6.53458983e-02f,
  2.36179322e-01f, 4.64365780e-02f, 1.97079346e-01f, 1.33266017e-01f, 1.04861043e-01f, -9.95684937e-02f, -1.00340165e-01f, -1.26681879e-01f, -4.46463041e-02f, 2.06912726e-01f,
  -1.22266956e-01f, 6.72440603e-02f, 1.49415806e-01f, 1.06594220e-01f, 1.74212903e-01f, -5.03144860e-02f, -1.98299196e-02f, 9.60295126e-02f, 2.37411365e-01f, -1.05682358e-01f,
  -3.78383175e-02f, -1.29623801e-01f, 1.08771190e-01f, -1.28018083e-02f, 8.23324025e-02f, -1.05965659e-01f, -9.58034843e-02f, -8.18342045e-02f, 1.73783466e-01f, -1.62538454e-01f,
  1.40025154e-01f, -1.27463832e-01f, 1.38267040e-01f, 6.67577386e-02f, -1.92259371e-01f, -2.43236959e-01f, -1.92317516e-01f, 1.16065495e-01f, 8.55677575e-02f, -3.04225117e-01f,
  1.62408113e-01f, 2.30640486e-01f, -3.70457992e-02f, -1.98856741e-01f, 1.91824529e-02f, -2.61594921e-01f, -1.53502391e-03f, -3.82580422e-02f, 4.53488305e-02f, 1.23910338e-01f,
  5.66744432e-02f, -1.11427121e-01f, -4.90441313e-03f, 1.67782493e-02f, -6.97133690e-02f, 2.11733371e-01f, 5.53090870e-02f, -1.92446142e-01f, 2.56922871e-01f, -1.43592820e-01f,
  1.87714115e-01f, -1.28464609e-01f, -1.16168875e-02f, 8.64534676e-02f, -6.53480440e-02f, 1.81119591e-01f, 3.57645489e-02f, 3.28058936e-02f, -6.86740279e-02f, 2.88541522e-02f,
  -1.46024019e-01f, -1.53765649e-01f, 3.13438512e-02f, 6.17184564e-02f, 3.56462114e-02f, -9.39899459e-02f, -7.11700693e-02f, 7.87615255e-02f, 1.38952835e-02f, 1.43510699e-01f,
  7.23031834e-02f, 1.96227804e-01f, 2.18470424e-01f, -2.26306871e-01f, -1.79165855e-01f, -1.20476112e-01f, -2.24361848e-02f, 9.10246149e-02f, 9.40028206e-02f, -4.90098596e-02f,
  -1.42771471e-02f, -1.05563723e-01f, -1.02244029e-02f, 4.46126796e-02f, -7.52213895e-02f, -1.43431827e-01f, -2.97433734e-02f, 1.63277730e-01f, -5.91268651e-02f, 1.02131501e-01f,
  1.64045364e-01f, -9.59094316e-02f, -2.05991641e-02f, 7.60859102e-02f, 1.78606585e-01f, -1.35753874e-03f, -9.60984156e-02f, -1.64524645e-01f, -1.57954916e-01f, 1.66144788e-01f,
  1.64732382e-01f, -1.33195240e-02f, -1.71493545e-01f, 2.66705066e-01f, 1.56386092e-01f, -1.06816143e-01f, 2.62795687e-01f, -9.48416740e-02f, -6.19306192e-02f, -2.29128867e-01f,
  1.24703564e-01f, 2.68167593e-02f, 1.50984809e-01f, -1.63642064e-01f, -1.73896775e-01f, 2.27163117e-02f, -6.91758022e-02f, 4.93767932e-02f, -1.82451740e-01f, -9.19083357e-02f,
  -1.60046630e-02f, 1.58970593e-03f, -1.64962038e-02f, -1.05791345e-01f, 1.32886589e-01f, 5.01207076e-02f, -2.85031796e-02f, -7.58789554e-02f, -2.09507078e-01f, -1.64982621e-02f,
  7.93262497e-02f, -1.45038422e-02f, 2.64003128e-02f, 1.40288800e-01f, 8.74708742e-02f, -1.78557396e-01f, -1.41280621e-01f, 4.11066711e-02f, 2.29141489e-01f, 1.71609834e-01f,
  2.29503703e-03f, -3.56637239e-02f, -2.18969077e-01f, 1.13317281e-01f, -6.07183613e-02f, 3.35295126e-02f, -1.63208559e-01f, -1.48079842e-01f, 3.76506634e-02f, -2.01230913e-01f,
  4.93261218e-02f, -4.30129059e-02f, -1.44920722e-01f, 3.67176645e-02f, -2.52374977e-01f, -7.09730536e-02f, 1.63834438e-01f, -2.65941441e-01f, 7.58106709e-02f, 4.55365293e-02f,
  9.77960229e-02f, -2.73407903e-02f, 3.16164047e-02f, 1.16306571e-02f, -4.46207002e-02f, 1.43857911e-01f, -3.93333584e-02f, -1.74072459e-01f, -2.61301339e-01f, -8.67061391e-02f,
  -1.15007460e-01f, -4.19630110e-02f, 1.96801424e-01f, 1.41159222e-02f, -4.52678092e-02f, -2.83238351e-01f, 1.66397244e-01f, -1.29270881e-01f, 6.49491400e-02f, 7.10506216e-02f,
  7.07025379e-02f, 6.95183799e-02f, 1.46579131e-01f, 2.65620679e-01f, 9.98805016e-02f, 4.25314158e-02f, 3.25825624e-02f, -3.45292175e-03f, 1.38967475e-02f, -6.42929524e-02f,
  1.27384886e-01f, -8.58656839e-02f, -5.25647588e-02f, -1.30115002e-01f, 4.78824861e-02f, -6.00084737e-02f, 1.91509258e-02f, 2.65745148e-02f, 3.70639265e-02f, 3.16247821e-01f,
  1.98935613e-01f, -8.32951590e-02f, -8.08350556e-03f, 6.29936829e-02f, 2.65180022e-01f, -7.29419217e-02f, -1.11980774e-01f, -1.04826316e-01f, -1.61283523e-01f, 5.61205437e-03f,
  7.99728259e-02f, 2.04617262e-01f, -1.93083622e-02f, -6.87761307e-02f, 1.51768848e-01f, -6.63707629e-02f, -2.58944571e-01f, 2.18336999e-01f, -1.07254744e-01f, -2.21505433e-01f,
  3.73766758e-02f, -3.83775793e-02f, 1.72091156e-01f, 2.09292490e-03f, -2.98555851e-01f, -1.18046872e-01f, 2.04831496e-01f, -2.90715754e-01f, 3.30132693e-01f, 2.38779802e-02f,
  -2.03214467e-01f, 5.14814518e-02f, 2.03218013e-01f, 1.05330080e-01f, -5.52066155e-02f, 1.34058595e-01f, -1.24052830e-01f, -6.45330623e-02f, -2.28652265e-02f, -1.73062906e-02f,
  4.35077846e-02f, 9.84921902e-02f, 1.91229820e-01f, 2.82364100e-01f, 1.18169986e-01f, 7.29973018e-02f, -1.22316092e-01f, -1.79884896e-01f, -6.85686171e-02f, 2.35363306e-03f,
  -1.20600976e-01f, 3.73603813e-02f, 7.29777440e-02f, -1.29418522e-01f, -1.13694787e-01f, -8.05088878e-02f, 1.17774285e-01f, 7.08480924e-02f, -1.05540864e-02f, -1.62599936e-01f,
  1.00530453e-01f, 4.91483696e-02f, 2.36329749e-01f, -8.78507039e-04f, 1.69831768e-01f, -1.89081505e-01f, -4.34673429e-02f, -1.85842752e-01f, -9.87378997e-04f, -1.93215348e-02f,
  6.64599091e-02f, 2.69226488e-02f, 1.04220986e-01f, -9.44441631e-02f, 4.03117016e-02f, -7.06728846e-02f, -1.20242447e-01f, -1.58535212e-01f, 1.24966964e-01f, 1.30220607e-01f,
  1.33286685e-01f, 8.17352384e-02f, 2.47644946e-01f, -9.12516490e-02f, 6.86959699e-02f, 6.54914379e-02f, 3.90284322e-02f, 6.34177849e-02f, 1.23041952e-02f, 1.05792537e-01f,
  -1.45870999e-01f, 2.10971877e-01f, 1.70390636e-01f, -9.18936878e-02f, -2.04096496e-01f, 1.23866610e-01f, 5.96998520e-02f, -1.39084771e-01f, 2.91467041e-01f, -2.31223673e-01f,
  2.99204178e-02f, -2.47864962e-01f, 2.99235046e-01f, -1.01325661e-01f, 6.36796951e-02f, -2.43705839e-01f, -2.22356066e-01f, -1.96251217e-02f, 8.45758766e-02f, 3.96865234e-02f,
  -2.38761351e-01f, -3.03862423e-01f, -4.57258299e-02f, -8.38332325e-02f, -7.04471841e-02f, 7.55949616e-02f, -3.46654840e-02f, -1.10005766e-01f, -2.53460351e-02f, -5.49950264e-02f,
  1.32141158e-01f, 9.09097493e-02f, 4.98993918e-02f, 5.92197813e-02f, -4.58278731e-02f, -9.74784270e-02f, -6.14321828e-02f, 4.68506813e-02f, 5.56988902e-02f, -5.26956888e-03f,
  -2.35064358e-01f, 6.26538545e-02f, -3.88621278e-02f, 7.52077997e-02f, 8.45827833e-02f, -1.39321968e-01f, 8.16703513e-02f, -1.27458155e-01f, 1.25606045e-01f, 2.22501662e-02f,
  -2.15650033e-02f, 7.04840273e-02f, -2.25323573e-01f, 1.79985851e-01f, -9.35903005e-03f, -1.26666397e-01f, -5.57117052e-02f, 2.25439947e-02f, -8.66478011e-02f, 1.00586616e-01f,
  7.46216103e-02f, -1.73818637e-02f, -1.39647216e-01f, -8.62224698e-02f, 3.16814259e-02f, -2.58716792e-01f, 1.92041665e-01f, -2.26332080e-02f, -1.36617258e-01f, 1.83223978e-01f,
  2.52034426e-01f, 6.86050728e-02f, -5.55710755e-02f, 1.10253423e-01f, -7.58047625e-02f, -1.49276868e-01f, 2.26371791e-02f, 2.12939695e-01f, 1.43659823e-02f, 9.79938880e-02f,
  6.52753115e-02f, -1.06550962e-01f, -1.72572300e-01f, -4.22132574e-02f, -1.10889457e-01f, -1.89772367e-01f, -1.86744049e-01f, -6.28734827e-02f
};

// L1_fan_Wp_bar (Shape: 40 x 64)
const int L1_fan_Wp_bar_rows = 40;
const int L1_fan_Wp_bar_cols = 64;
const float L1_fan_Wp_bar_data[] = {
  8.52252468e-02f, 1.77776694e-01f, 9.81290042e-02f, 1.45844430e-01f, 6.13458045e-02f, 1.89380005e-01f, -8.54097530e-02f, 1.28128129e-04f, 1.96830034e-01f, -6.58196807e-02f,
  8.00690725e-02f, 1.26440674e-01f, -2.62002368e-02f, 3.36484537e-02f, -4.30454873e-02f, 8.12524259e-02f, 1.83292046e-01f, 1.11816294e-01f, 4.99939919e-02f, -1.05147272e-01f,
  -1.18713193e-01f, 3.27656627e-01f, 1.22317396e-01f, 2.01040238e-01f, -2.86610201e-02f, 6.20299242e-02f, 2.30565276e-02f, -8.03825706e-02f, 2.08949834e-01f, -2.19450239e-02f,
  -1.94202527e-01f, 3.09205824e-03f, -3.29298466e-01f, 1.39474135e-03f, 1.56424701e-01f, -3.98572505e-01f, 1.04648070e-02f, -1.54567286e-02f, 9.42213535e-02f, -6.40089065e-02f,
  2.70102531e-01f, -8.74189287e-02f, -9.57585685e-03f, 2.92101502e-01f, 1.84930012e-01f, -1.10865600e-01f, -1.54389337e-01f, -7.16377124e-02f, -1.56764500e-02f, -1.18906703e-02f,
  2.61231251e-02f, 2.82229960e-01f, 8.12420901e-03f, -5.57427779e-02f, 2.53842115e-01f, -1.85720161e-01f, 1.03355899e-01f, 1.73612043e-01f, 5.74022569e-02f, 6.75489102e-03f,
  -1.46257386e-01f, 1.90658152e-01f, 3.30944583e-02f, -4.79296036e-02f, 2.50531465e-01f, 5.32722399e-02f, 1.23991080e-01f, 2.12474689e-01f, 1.73825383e-01f, 2.07535833e-01f,
  5.51011302e-02f, 9.15505812e-02f, 2.67274737e-01f, 1.51074111e-01f, 1.79138184e-02f, 5.43227158e-02f, -1.90573111e-01f, 3.38695310e-02f, 2.05665499e-01f, 1.11827977e-01f,
  7.66925439e-02f, 2.73165315e-01f, 1.76394567e-01f, 9.06942785e-02f, -7.46794418e-02f, 5.02903350e-02f, -1.76900864e-01f, 1.44777730e-01f, 8.39226767e-02f, -2.63727233e-02f,
  2.98319906e-01f, -8.51467475e-02f, 5.25507294e-02f, 2.13482067e-01f, -1.39821663e-01f, -3.29294205e-02f, -1.37442902e-01f, 1.35400116e-01f, 1.84838578e-01f, 4.07449752e-02f,
  1.75387606e-01f, 2.61492372e-01f, 8.39682519e-02f, -3.29134092e-02f, 3.30030501e-01f, -1.57987878e-01f, 4.69596125e-02f, 3.16422939e-01f, 1.47468299e-02f, 1.78881213e-01f,
  2.94929057e-01f, 3.13121229e-01f, -1.41011581e-01f, 1.67607099e-01f, 2.26456393e-02f, 2.56445348e-01f, 1.45415887e-01f, 1.39552737e-02f, 1.58590496e-01f, 1.43558830e-01f,
  2.12665290e-01f, 9.59191180e-04f, 2.33711884e-03f, 1.64264441e-01f, 2.63435364e-01f, 3.79354894e-01f, 4.87137884e-02f, 7.49511197e-02f, 2.22561941e-01f, 1.16416760e-01f,
  1.01273514e-01f, 2.51112431e-01f, 6.05735220e-02f, 1.51525229e-01f, 2.01985791e-01f, 2.27977678e-01f, -1.17327748e-02f, 2.03073904e-01f, 3.50500755e-02f, 1.35519847e-01f,
  1.81817338e-01f, -2.76812822e-01f, -2.95137674e-01f, 1.52602091e-01f, -1.85922295e-01f, 9.38097611e-02f, -2.70480603e-01f, 3.60346697e-02f, 1.28598791e-02f, 1.23019405e-01f,
  1.34026811e-01f, -1.41986847e-01f, -3.86605822e-02f, -1.18283786e-01f, -6.65687844e-02f, 3.78644019e-02f, -9.73139927e-02f, -3.28025445e-02f, 2.37619013e-01f, 2.69385457e-01f,
  1.72188617e-02f, 3.38894099e-01f, 7.58643746e-02f, -1.16980456e-01f, -6.86399192e-02f, -7.19989389e-02f, 2.95500129e-01f, 6.89448416e-02f, -2.52254575e-01f, 1.95183545e-01f,
  -5.25703793e-03f, 4.15755585e-02f, -2.41731387e-03f, -1.00607708e-01f, -6.30912855e-02f, -1.19567551e-01f, 5.06727898e-04f, -1.58769920e-01f, 3.04535449e-01f, 1.31384388e-01f,
  2.03354031e-01f, 6.85822442e-02f, -1.18029132e-01f, 2.10930824e-01f, -2.18464017e-01f, -1.40097454e-01f, 9.20032710e-03f, 1.46848008e-01f, 3.31537545e-01f, 2.60631382e-01f,
  -1.23780258e-02f, 2.70529807e-01f, 9.57465768e-02f, 1.76322386e-01f, 5.49491569e-02f, 2.53719181e-01f, 1.35149792e-01f, 1.91111118e-01f, 1.81421518e-01f, 2.35728383e-01f,
  1.31886899e-01f, 1.31236985e-01f, 2.61146009e-01f, 1.32227957e-01f, -1.89595073e-01f, 3.60497952e-01f, 1.97254583e-01f, -1.25832617e-01f, -2.78251410e-01f, 9.20804814e-05f,
  2.16634735e-01f, 1.02789037e-01f, 1.00783363e-01f, -4.21890803e-02f, 1.01702683e-01f, 3.93206477e-02f, 8.25226028e-03f, 2.58780152e-01f, 2.20409393e-01f, 3.65152508e-01f,
  1.44844547e-01f, 6.21523969e-02f, -4.50124107e-02f, -6.02352805e-02f, 2.11344376e-01f, 1.16327144e-01f, -6.35276288e-02f, 1.83347702e-01f, -9.92468894e-02f, -5.46740666e-02f,
  -1.13908954e-01f, -4.11575325e-02f, 3.08672965e-01f, 8.49556923e-02f, 1.16170337e-02f, 8.90176222e-02f, -3.84531841e-02f, 2.47709483e-01f, 2.40500078e-01f, 2.23390937e-01f,
  2.66035676e-01f, 2.34879494e-01f, -2.12955385e-01f, 7.74346888e-02f, 4.73273695e-02f, 2.72273213e-01f, 1.54782251e-01f, 1.32785425e-01f, 3.41528475e-01f, 1.46397680e-01f,
  2.63702534e-02f, 4.21692282e-02f, -2.31222048e-01f, -1.17537588e-01f, 1.11279249e-01f, -3.05194072e-02f, 1.68254882e-01f, 1.40820876e-01f, -4.82581072e-02f, 6.77819327e-02f,
  1.58557728e-01f, 2.04445153e-01f, -9.40070376e-02f, 1.48571417e-01f, 1.71308503e-01f, 2.66957521e-01f, 2.11303055e-01f, -7.48784021e-02f, -2.42177695e-01f, 2.06367671e-01f,
  1.44469589e-01f, 1.91752627e-01f, -1.15604013e-01f, 1.16240963e-01f, 1.44750014e-01f, 1.29360184e-01f, 6.26139045e-02f, 3.61586027e-02f, -1.57673433e-01f, -5.61833531e-02f,
  -7.64941201e-02f, 1.39025124e-02f, 2.77785420e-01f, 1.54019639e-01f, 2.22717840e-02f, 3.69185209e-03f, -1.38967276e-01f, -2.38453031e-01f, -1.92449674e-01f, 1.23816542e-01f,
  5.97367138e-02f, 8.44813958e-02f, -6.08625226e-02f, 2.58786023e-01f, -9.32760760e-02f, 1.19963281e-01f, 2.84974247e-01f, -3.47854823e-01f, 9.54862162e-02f, -1.56759527e-02f,
  1.02726750e-01f, 8.62509459e-02f, 2.77579665e-01f, 1.07466057e-01f, 2.60972902e-02f, 1.48313791e-01f, -4.20202874e-02f, 1.97865680e-01f, -2.53986746e-01f, 1.76814169e-01f,
  -1.42308325e-01f, 8.10914859e-03f, 3.05083662e-01f, 1.69535786e-01f, -1.00459926e-01f, 2.82332078e-02f, -1.24433942e-01f, 2.01888740e-01f, 1.62316769e-01f, -1.73306897e-01f,
  -5.97016662e-02f, 1.06975570e-01f, -9.42201447e-03f, 2.00818792e-01f, 1.60076633e-01f, -1.23493612e-01f, 1.52883947e-01f, -3.40181850e-02f, -8.32711980e-02f, 1.67904161e-02f,
  -9.23727304e-02f, 2.17611864e-01f, 2.21576944e-01f, 1.74288359e-02f, 3.57662439e-02f, -5.94140291e-02f, -2.22189546e-01f, 6.18360676e-02f, -9.36741456e-02f, 1.49323061e-01f,
  -1.32237196e-01f, -8.68602395e-02f, 1.27983689e-01f, -2.10264802e-01f, 2.71125793e-01f, 1.25992000e-01f, 5.03011397e-04f, 1.43147046e-02f, 9.91258696e-02f, 1.97585031e-01f,
  1.54898748e-01f, 3.31817597e-01f, 2.95099944e-01f, 9.83743295e-02f, 1.67495772e-01f, 1.35856882e-01f, 2.08985701e-01f, 1.81180730e-01f, 1.87145278e-01f, 6.88339770e-02f,
  -2.69244500e-02f, 2.18540952e-01f, 1.10467456e-01f, -2.95686591e-02f, -4.67228331e-02f, 1.66209430e-01f, -3.34267458e-03f, 5.15199043e-02f, 3.82986873e-01f, -9.00186971e-02f,
  8.83887559e-02f, -2.97873676e-01f, 2.98043907e-01f, 2.94245733e-03f, 1.12599075e-01f, 1.02220312e-01f, -5.93663789e-02f, 6.13293163e-02f, 4.04237807e-02f, 9.40318555e-02f,
  -1.05587989e-01f, -3.90456229e-01f, -2.19480246e-01f, -8.25648978e-02f, 8.48266706e-02f, 6.69170544e-02f, 9.68415067e-02f, 1.00673273e-01f, 5.86334653e-02f, 1.57317780e-02f,
  1.01254523e-01f, 3.12753059e-02f, 1.39068186e-01f, 1.71767458e-01f, 7.49686956e-02f, -7.52908811e-02f, -2.83811204e-02f, 1.53554618e-01f, -5.35080396e-02f, 1.85286836e-03f,
  -1.00833997e-01f, 2.07076177e-01f, 6.74829539e-03f, 1.59753248e-01f, -1.56921193e-01f, -3.14064384e-01f, -3.14210683e-01f, 1.33380875e-01f, -2.95933932e-02f, 2.61936128e-01f,
  5.73005006e-02f, 1.33252174e-01f, -2.75967300e-01f, -2.31360778e-01f, 1.07288741e-01f, 2.45853499e-01f, -6.25531003e-02f, -2.97437906e-01f, -1.63420349e-01f, 1.18914001e-01f,
  -1.54331982e-01f, 1.34210736e-01f, 8.15679552e-04f, -1.95791405e-02f, 1.63386106e-01f, -5.43797910e-02f, 4.46016165e-05f, -1.22478403e-01f, -1.46015048e-01f, 4.12497371e-02f,
  1.89821288e-01f, 8.22613090e-02f, 1.60729494e-02f, 2.81579196e-01f, 2.04976331e-02f, -2.80507833e-01f, -1.29988119e-01f, 5.25094531e-02f, -2.09692478e-01f, 3.36139977e-01f,
  8.99384841e-02f, 3.44455503e-02f, 1.93783198e-03f, -3.04309260e-02f, 3.17425281e-01f, -1.43126979e-01f, -4.65767905e-02f, -1.62683189e-01f, 3.25386487e-02f, 1.63251013e-01f,
  2.61896849e-01f, 1.97506517e-01f, 5.90099618e-02f, 1.31877378e-01f, 1.84109613e-01f, 2.84990072e-01f, 1.30865410e-01f, 2.11151361e-01f, 2.50315577e-01f, 1.50304854e-01f,
  2.79811844e-02f, 6.01754673e-02f, -1.31310269e-01f, 1.55670151e-01f, -4.62320670e-02f, -3.86884622e-02f, 1.36890262e-02f, 2.40551140e-02f, -1.09596997e-02f, 2.24746913e-01f,
  1.28800243e-01f, 2.03101918e-01f, -1.24269119e-02f, 2.77859513e-02f, -6.99828044e-02f, 1.47834703e-01f, 9.78760943e-02f, 1.68047715e-02f, 1.38502344e-01f, -1.96355179e-01f,
  2.72556156e-01f, 1.64946750e-01f, -1.53774306e-01f, 1.32351726e-01f, 7.76497349e-02f, -3.58153880e-01f, 1.07424714e-01f, 1.89503536e-01f, 4.65618260e-02f, 8.89326259e-02f,
  -4.10951197e-01f, 1.38486788e-01f, 9.05654579e-02f, 3.88846062e-02f, 4.88726981e-02f, 1.03981696e-01f, 1.90107301e-01f, 9.48275849e-02f, 4.39374149e-02f, 1.05020307e-01f,
  5.44887632e-02f, 1.88767761e-01f, 1.83521315e-01f, -4.16118167e-02f, 7.52511397e-02f, -1.49332196e-01f, -5.67010231e-02f, -4.76395994e-01f, -8.61779675e-02f, 1.76219627e-01f,
  2.54278570e-01f, 1.61164641e-01f, -3.34669240e-02f, 1.00303359e-01f, 1.86343476e-01f, 1.53632149e-01f, -1.20952539e-01f, 1.59013227e-01f, 8.10155347e-02f, -2.05379464e-02f,
  -3.23768891e-02f, -1.19475173e-02f, 1.32384360e-01f, 1.90123782e-01f, 1.62695691e-01f, -1.62471011e-01f, -1.47462696e-01f, 1.19905196e-01f, -1.87231913e-01f, 9.64097381e-02f,
  -2.95381486e-01f, 5.75374998e-03f, 2.36217484e-01f, -1.73539847e-01f, 2.13875368e-01f, 1.15911834e-01f, 1.85430691e-01f, 3.08280792e-02f, -1.56052867e-02f, 9.92917195e-02f,
  -2.78315395e-01f, 2.49940515e-01f, 1.26438648e-01f, -1.01676807e-01f, 2.16547117e-01f, 1.77432165e-01f, 1.57870665e-01f, 2.76225153e-02f, 1.33987248e-01f, 1.61017507e-01f,
  2.21922651e-01f, 2.71242321e-01f, -2.93774098e-01f, 7.81545136e-03f, 3.42273824e-02f, 1.48074076e-01f, -1.42496573e-02f, 1.87364489e-01f, 2.06525281e-01f, 9.95767042e-02f,
  1.80704713e-01f, -3.31663340e-01f, 1.09254584e-01f, 3.13990802e-01f, 1.41461819e-01f, 3.26130003e-01f, 1.54925995e-02f, -8.27200413e-02f, -2.12498412e-01f, -1.21061400e-01f,
  -4.74881530e-02f, 1.95813119e-01f, 1.06370980e-02f, 1.37055647e-02f, 8.51556659e-02f, 3.15590858e-01f, 2.05844447e-01f, 1.97772309e-02f, 2.24509284e-01f, 4.48284997e-03f,
  5.53669520e-02f, 1.30121902e-01f, 4.63506989e-02f, -3.17325555e-02f, -6.38485402e-02f, 7.95280561e-02f, 1.61057279e-01f, -4.87276725e-02f, 1.89791054e-01f, -1.61728382e-01f,
  2.61761411e-03f, -1.08225485e-02f, -1.50721848e-01f, -2.57699061e-02f, -6.21311367e-02f, 1.38827085e-01f, 4.83380780e-02f, -3.74111868e-02f, 4.84925210e-02f, -2.73144275e-01f,
  1.91851750e-01f, -9.19444412e-02f, 1.55699104e-01f, -1.37863576e-01f, -1.87441155e-01f, 3.60377371e-01f, 1.91874340e-01f, -1.05451226e-01f, -1.81603245e-03f, 9.09959376e-02f,
  2.25844547e-01f, 2.83705425e-02f, 2.14115098e-01f, 1.64435565e-01f, 1.46348611e-01f, -1.11583080e-02f, -8.79307017e-02f, 4.85331640e-02f, 2.07741365e-01f, 3.46514136e-02f,
  5.44996709e-02f, 1.71355501e-01f, 1.84691355e-01f, -1.66219145e-01f, 3.12734023e-02f, -1.57427341e-01f, 2.89516419e-01f, 1.00942358e-01f, 2.40375951e-01f, 3.55009809e-02f,
  9.00446065e-03f, 4.54181843e-02f, -1.03666767e-01f, 1.57931633e-02f, 1.16163917e-01f, 3.54482122e-02f, 1.63830835e-02f, 3.29859443e-02f, -9.58842635e-02f, 4.37396020e-02f,
  1.41634075e-02f, 5.79888700e-03f, 5.82316816e-02f, -3.54655571e-02f, 1.79823488e-01f, 8.86528790e-02f, 4.39104112e-03f, -4.82743159e-02f, 1.31449759e-01f, 6.93844482e-02f,
  1.20965727e-01f, 1.31450877e-01f, -1.89797029e-01f, 1.04958065e-01f, 2.16749415e-01f, -1.17175587e-01f, 2.51069158e-01f, 1.11172451e-02f, 2.93242246e-01f, -2.11728841e-01f,
  -1.57749563e-01f, 1.40818328e-01f, -1.97036862e-01f, 2.96832830e-01f, -1.08705729e-01f, 2.00476110e-01f, -8.66580009e-02f, 9.70007256e-02f, 3.18024099e-01f, 9.92501191e-06f,
  -2.18305916e-01f, 1.81984395e-01f, -1.22422427e-01f, -1.70675386e-02f, -1.20388046e-01f, 1.11846924e-01f, 1.60294175e-01f, -1.81421991e-02f, 8.19517374e-02f, -3.68305505e-03f,
  2.87988156e-01f, -8.23860094e-02f, -7.01129362e-02f, 1.15126669e-01f, 1.24857143e-01f, -2.60459334e-01f, -5.01246117e-02f, 2.26565972e-01f, -3.99456173e-02f, 1.38351411e-01f,
  -1.29434213e-01f, 1.30087435e-01f, -5.00391461e-02f, -8.96999538e-02f, 1.05209537e-01f, 4.71396595e-02f, 3.16420704e-01f, 2.56433617e-02f, 1.23396285e-01f, 1.98292673e-01f,
  -1.11284405e-01f, 2.96855029e-02f, 1.87934384e-01f, -1.75013114e-02f, 1.24117211e-01f, 3.01103204e-01f, 4.30432484e-02f, 1.54766604e-01f, 1.12160996e-01f, 1.06980734e-01f,
  1.31742448e-01f, 9.62753221e-02f, 4.20793816e-02f, 4.53997217e-03f, 3.31957340e-02f, 1.09515160e-01f, 9.55670103e-02f, -6.98727891e-02f, -5.46716787e-02f, 6.62220865e-02f,
  1.32032678e-01f, -9.86345708e-02f, 2.05695361e-01f, -1.45775065e-01f, -4.74714711e-02f, 1.24000244e-01f, 7.67787769e-02f, 3.88941884e-01f, -2.44640023e-01f, 2.43601665e-01f,
  -2.90776491e-01f, 2.04982907e-01f, 2.30598718e-01f, -1.08197168e-01f, 9.41432416e-02f, 1.25538856e-01f, 3.27575147e-01f, 7.78399855e-02f, 5.80321364e-02f, 5.79472072e-02f,
  1.09169763e-02f, -3.11583541e-02f, 5.12285121e-02f, 2.28145123e-01f, 1.41430363e-01f, 3.19869846e-01f, -1.57749340e-01f, 1.86885864e-01f, 1.24944985e-01f, 4.70239110e-02f,
  -8.71324316e-02f, 1.75696954e-01f, 1.89847067e-01f, -1.46010041e-01f, -1.74397543e-01f, 1.74187809e-01f, 3.75385135e-02f, 3.42739075e-02f, 2.23287046e-01f, 8.99007022e-02f,
  2.38977611e-01f, 7.67025501e-02f, 1.59010172e-01f, 3.80374081e-02f, -9.42821801e-02f, 1.10847233e-02f, 9.76081863e-02f, 5.58993630e-02f, 9.08919647e-02f, 1.80541322e-01f,
  1.67799637e-01f, 1.40711948e-01f, 1.93310022e-01f, 7.08593950e-02f, 9.93405804e-02f, 2.22337067e-01f, 1.13599136e-01f, 5.75104244e-02f, 5.16486317e-02f, 1.03598423e-01f,
  -4.28256877e-02f, -8.02745223e-02f, -2.38122627e-01f, 2.23293483e-01f, -7.27749020e-02f, -1.74133535e-02f, -2.53151953e-01f, 1.13658801e-01f, 1.46637812e-01f, 1.86704755e-01f,
  1.84984863e-01f, 8.06319527e-03f, 5.06221429e-02f, -4.91449200e-02f, -6.60951957e-02f, 1.12100229e-01f, -1.44163474e-01f, -6.73805326e-02f, 3.22988540e-01f, -1.40398502e-01f,
  2.08227888e-01f, 2.43884951e-01f, -1.24997362e-01f, 2.39454448e-01f, 1.30916517e-02f, -1.98965594e-01f, 2.38437414e-01f, 2.84379691e-01f, -7.82716274e-03f, 1.88301414e-01f,
  -4.15182054e-01f, 6.21837713e-02f, 2.77054578e-01f, 2.87750456e-02f, -2.45535187e-02f, -3.24333049e-02f, 1.57915041e-01f, 1.66862503e-01f, 1.98480844e-01f, 7.12654600e-03f,
  1.19883187e-01f, 2.75536776e-01f, 2.57196557e-02f, 1.34049460e-01f, 7.29126707e-02f, -2.13779733e-01f, -1.15708768e-01f, -4.00847942e-01f, -5.77576552e-03f, 8.20294917e-02f,
  1.01482935e-01f, 2.98360378e-01f, 3.21108066e-02f, 4.87454757e-02f, -3.93590257e-02f, 1.61672637e-01f, -4.35113534e-02f, -5.72525337e-02f, -2.69149756e-03f, 3.57786193e-02f,
  1.30293697e-01f, 2.13285573e-02f, 1.36908084e-01f, 8.14931560e-03f, -1.15924619e-01f, -1.60861358e-01f, -1.63922101e-01f, 5.28770983e-02f, -1.26127243e-01f, 1.47517482e-02f,
  3.63792926e-02f, -7.09867403e-02f, 1.25044793e-01f, 6.68392032e-02f, 1.43331602e-01f, 3.46325159e-01f, -1.22505248e-01f, 2.33057201e-01f, -2.23950654e-01f, 2.75859773e-01f,
  -1.28146634e-01f, 3.63406762e-02f, 1.08853132e-01f, -2.67209291e-01f, 3.56917530e-01f, 7.31910616e-02f, 5.40045314e-02f, 3.74696314e-01f, -2.38305107e-01f, -2.29858831e-01f,
  -1.25959283e-02f, 3.00880700e-01f, 1.06017366e-01f, 1.24635868e-01f, -1.29975304e-01f, -8.57113525e-02f, 7.85695855e-03f, -7.92616084e-02f, 1.70770772e-02f, 2.18533695e-01f,
  1.39218777e-01f, 5.34001961e-02f, -2.18157664e-01f, 1.58045053e-01f, -3.07418760e-02f, 3.65397662e-01f, -1.25861123e-01f, 5.05333242e-04f, 2.78314471e-01f, -8.02366994e-03f,
  -4.33653444e-02f, -5.63619770e-02f, -1.70840710e-01f, -1.36255354e-01f, 1.93260968e-01f, 1.02414973e-02f, 9.74213481e-02f, 1.30030140e-01f, 2.21525744e-01f, 2.21079409e-01f,
  8.71770903e-02f, -5.91754215e-03f, 1.09905899e-01f, -1.59709919e-02f, 2.35320866e-01f, 9.07241330e-02f, 8.23072344e-02f, 1.52984530e-01f, -9.30906832e-02f, 1.50169402e-01f,
  6.29551802e-03f, -1.76353633e-01f, 2.59570718e-01f, 1.48031846e-01f, 1.77999064e-01f, -2.33190015e-01f, -2.81011432e-01f, -8.10774192e-02f, -2.22516865e-01f, 2.01550767e-01f,
  -1.71404377e-01f, 8.29680115e-02f, 3.57267633e-02f, -6.17386512e-02f, 1.56466946e-01f, -9.65902805e-02f, -1.02541313e-01f, 1.70502886e-01f, -2.47784480e-01f, 2.67240335e-04f,
  -1.09620817e-01f, -1.60761289e-02f, 9.95236710e-02f, -1.83674127e-01f, -1.48341293e-02f, -1.56679630e-01f, 3.92306559e-02f, -3.53482403e-02f, -3.05145718e-02f, 3.71997625e-01f,
  -4.93667275e-02f, 1.24711394e-01f, 1.48245944e-02f, 1.88270018e-01f, -5.72447143e-02f, 2.07506508e-01f, -1.30300209e-01f, 1.04708999e-01f, 7.03922287e-02f, -2.05378443e-01f,
  2.93267876e-01f, 1.36245474e-01f, 6.79221097e-03f, 1.22652009e-01f, 3.78294699e-02f, -4.24393900e-02f, 2.47365206e-01f, 2.05002092e-02f, 1.85461149e-01f, 1.75731450e-01f,
  1.79932505e-01f, 7.53729120e-02f, 2.17804119e-01f, 2.01019078e-01f, 2.13520035e-01f, 1.93462133e-01f, 1.65948421e-01f, 2.51399606e-01f, 2.08949938e-01f, 2.64999330e-01f,
  2.69416720e-01f, 1.39989018e-01f, 1.54849673e-02f, -1.24107860e-01f, -2.85155047e-02f, 2.59042114e-01f, -1.21699966e-01f, -2.12239753e-02f, 1.25391772e-02f, 4.51173671e-02f,
  2.72395372e-01f, 1.59106061e-01f, 1.56316653e-01f, -2.60696243e-02f, 1.36159416e-02f, -1.45633399e-01f, 1.52719662e-01f, 2.62018234e-01f, -8.77799243e-02f, 6.18188158e-02f,
  2.69051731e-01f, -2.52617180e-01f, 1.56333596e-01f, 2.74183482e-01f, -6.07493632e-02f, 1.38785169e-01f, 5.70371263e-02f, -2.61655688e-01f, 3.07061151e-02f, 1.59301713e-01f,
  -1.33106127e-01f, 1.89737558e-01f, -4.33147758e-01f, 2.32012659e-01f, 2.40278378e-01f, -5.46504371e-02f, -1.93024799e-01f, -1.39610590e-02f, 1.65733993e-01f, 1.50688067e-01f,
  1.41496569e-01f, 2.62778699e-01f, -1.02318995e-01f, 2.61730433e-01f, 3.92421409e-02f, 1.65514469e-01f, 2.33863834e-02f, 1.93164628e-02f, -3.65845598e-02f, -4.32031333e-01f,
  2.09658712e-01f, 1.38525814e-01f, 1.40741274e-01f, 1.69267431e-01f, 1.02474369e-01f, 1.88369200e-01f, 1.48246482e-01f, 9.49658900e-02f, 7.79856835e-03f, 1.93810165e-01f,
  1.18930347e-01f, 1.24803036e-01f, 1.55652672e-01f, 7.56226629e-02f, 2.94288218e-01f, 1.95514694e-01f, -1.39451832e-01f, -9.76574719e-02f, 2.67947204e-02f, 8.01585689e-02f,
  -1.28972894e-02f, -1.07293822e-01f, 4.86459676e-03f, -6.49395287e-02f, 5.26651591e-02f, 2.94688642e-01f, 1.43150434e-01f, 5.37933270e-03f, -2.62497421e-02f, -1.04062371e-01f,
  4.25486267e-02f, 1.13020010e-01f, 2.36153945e-01f, 1.93270668e-01f, 3.80007513e-02f, -1.36848196e-01f, -2.53526419e-01f, 1.88542575e-01f, 2.64414132e-01f, -1.90179393e-01f,
  1.27711028e-01f, 1.18249252e-01f, 2.46943757e-01f, 1.70983821e-01f, 1.80648759e-01f, 1.56070413e-02f, 4.72048484e-02f, 2.65772492e-01f, 1.09876692e-01f, -1.12107478e-01f,
  4.19369973e-02f, 5.38244061e-02f, -1.17270008e-01f, -4.06134129e-02f, -7.23974220e-03f, 3.13600749e-01f, 2.45311514e-01f, 1.75705746e-01f, -5.66552430e-02f, 1.07489765e-01f,
  1.18179604e-01f, 6.21799231e-02f, 1.53138280e-01f, 1.38825968e-01f, 1.15481624e-02f, 9.08636004e-02f, 1.92699924e-01f, 2.36261562e-01f, 1.91002831e-01f, 1.60053879e-01f,
  1.57279730e-01f, -1.85826104e-02f, 4.14713025e-02f, 8.57577100e-02f, 1.00956626e-01f, -5.71280308e-02f, 1.89025372e-01f, -7.46440664e-02f, 2.18552798e-02f, 9.89453867e-02f,
  1.70536056e-01f, -1.07886188e-01f, 1.24294937e-01f, -6.68316707e-02f, 2.19205648e-01f, -1.74213901e-01f, 5.78121133e-02f, -2.50452906e-01f, -3.08906198e-01f, 1.74729601e-01f,
  -1.58557102e-01f, 1.12292834e-01f, 4.00843807e-02f, -6.63838685e-02f, -2.15997517e-01f, -1.84728101e-01f, 2.48603389e-01f, -2.34631673e-02f, -2.06503510e-01f, 5.87711670e-02f,
  -1.54041737e-01f, 4.48215345e-04f, 1.76409155e-01f, -3.80506426e-01f, 1.07523315e-01f, 2.04136029e-01f, 5.95771000e-02f, -8.08740184e-02f, 9.66498032e-02f, -1.82592705e-01f,
  2.49087051e-01f, 2.59470284e-01f, 1.81508120e-02f, 3.03058904e-02f, 1.10076793e-01f, 4.47111204e-02f, -3.43466848e-02f, 4.88263108e-02f, 1.30972667e-02f, 8.45408663e-02f,
  8.98648053e-02f, -2.32857183e-01f, 1.97885588e-01f, -1.22678086e-01f, 9.85912010e-02f, -2.75116507e-02f, 1.37487561e-01f, 2.92180240e-01f, -1.77429616e-01f, 2.98390612e-02f,
  9.93615389e-02f, 1.41883016e-01f, 1.79871902e-01f, 9.38153714e-02f, 1.66350275e-01f, 4.13482226e-02f, 2.43401647e-01f, 2.90037077e-02f, 1.56378418e-01f, 5.05570918e-02f,
  -6.17338065e-03f, 1.46599144e-01f, 1.59911051e-01f, 3.40873897e-01f, 5.32912388e-02f, -5.16838133e-02f, -1.28847882e-01f, -1.67291656e-01f, 2.77069420e-01f, 5.45820780e-02f,
  2.22168341e-01f, -1.34986877e-01f, -2.45545939e-01f, -5.82641400e-02f, -1.21462293e-01f, 2.13117063e-01f, 3.30327526e-02f, 1.99041337e-01f, -1.12559766e-01f, -1.87675238e-01f,
  2.97649443e-01f, 3.30589898e-02f, -1.14895150e-01f, 4.10995722e-01f, -2.01146351e-03f, 5.47632352e-02f, -2.55200028e-01f, 8.34589526e-02f, 1.54823914e-01f, -3.83390605e-01f,
  -8.77715275e-02f, -8.13954845e-02f, -1.16588309e-01f, 7.63144121e-02f, -2.15470538e-01f, 2.37968564e-01f, -1.03732876e-01f, -1.57709867e-01f, -9.83957946e-02f, 3.27076577e-02f,
  2.17791602e-01f, -1.39138803e-01f, 1.64847020e-02f, -3.36463377e-02f, 3.87202092e-02f, -2.28524759e-01f, 3.34506243e-01f, 9.00202841e-02f, -2.01803133e-01f, 2.49283630e-02f,
  1.90514818e-01f, -3.01144302e-01f, 1.64574489e-01f, -1.78387016e-01f, 6.51655123e-02f, 3.13746005e-01f, 2.02146351e-01f, -3.73711921e-02f, 1.44658700e-01f, 5.72550632e-02f,
  2.47758448e-01f, 1.74655214e-01f, 1.48632377e-01f, 1.43201828e-01f, 1.48938179e-01f, 2.23659739e-01f, -4.06605788e-02f, 1.05124757e-01f, 1.17167542e-02f, 1.74918860e-01f,
  2.96179876e-02f, -7.81063884e-02f, 2.09385023e-01f, -5.86152833e-04f, 2.37391457e-01f, 1.52426139e-01f, -1.02054156e-01f, -7.06631988e-02f, -2.33071987e-02f, -1.58146590e-01f,
  2.75350478e-03f, 1.19602263e-01f, 1.74644604e-01f, 2.36858632e-02f, 9.00151432e-02f, -1.66422263e-01f, -3.04799005e-02f, 2.01504752e-01f, 2.69993305e-01f, -2.41129726e-01f,
  -4.23074923e-02f, 1.50189146e-01f, 7.61295035e-02f, 1.83023252e-02f, -6.68466240e-02f, -1.86186567e-01f, 8.97545591e-02f, 1.34556562e-01f, -1.88564926e-01f, 3.02487388e-02f,
  1.80420652e-01f, 1.41590871e-02f, 6.70225099e-02f, 2.09614128e-01f, 1.90438107e-01f, 3.16847265e-01f, 1.01140387e-01f, -2.63636440e-01f, -1.55854821e-01f, 9.51906666e-02f,
  8.80050808e-02f, 2.46670440e-01f, 2.47630432e-01f, 2.89858550e-01f, -3.58099714e-02f, -1.02656707e-01f, 3.15909654e-01f, 1.76943108e-01f, 7.74083734e-02f, 5.85650951e-02f,
  2.57346213e-01f, 1.76844418e-01f, 1.08315341e-01f, 1.74159065e-01f, 4.70654480e-02f, -9.00760572e-03f, 3.17267776e-02f, 1.25205189e-01f, 4.55705076e-02f, -5.49199758e-03f,
  1.27259463e-01f, 1.97834447e-01f, 1.01085208e-01f, 2.40934983e-01f, 1.54837966e-01f, -2.91146427e-01f, -2.37643495e-01f, -1.24593012e-01f, 1.67609945e-01f, 2.29569137e-01f,
  1.06484778e-02f, -3.12149853e-01f, 2.22569048e-01f, -8.72490853e-02f, 2.31497064e-01f, -5.67658730e-02f, 1.69163316e-01f, -2.55526900e-01f, -3.00150295e-03f, 2.84815073e-01f,
  1.22068144e-01f, -6.61772396e-03f, 1.46401480e-01f, 1.94701791e-01f, -5.05864471e-02f, -1.23371623e-01f, 2.91286260e-01f, -1.42274946e-01f, -2.29454607e-01f, -2.02545390e-01f,
  -2.01354846e-01f, -1.37347868e-02f, 9.48063607e-05f, 1.41250759e-01f, -5.26615977e-02f, 1.47634536e-01f, 1.80084422e-01f, -1.74547836e-01f, 2.40350917e-01f, -1.54267818e-01f,
  8.40765145e-03f, -3.14597711e-02f, 4.55819406e-02f, 4.76934202e-03f, 2.39751905e-01f, -1.30358100e-01f, -5.08146137e-02f, -9.66400951e-02f, 1.71585940e-02f, -2.32368514e-01f,
  -9.44733843e-02f, -1.64676785e-01f, -1.91087365e-01f, 1.92574844e-01f, 2.09831834e-01f, 1.74221948e-01f, 2.76287317e-01f, 2.34008685e-01f, 7.87560791e-02f, 9.91642699e-02f,
  2.22529918e-01f, 1.81619272e-01f, -5.85112348e-02f, 2.68682152e-01f, 1.18212342e-01f, 1.90412059e-01f, 3.96127030e-02f, -8.92429128e-02f, -3.32070291e-01f, 2.27111816e-01f,
  3.65607440e-03f, 6.87532872e-02f, -3.05751830e-01f, 5.45395426e-02f, 1.21626846e-01f, -1.87493160e-01f, 6.52780533e-02f, -2.12049559e-01f, 2.93187648e-01f, -4.31843661e-02f,
  2.86163568e-01f, 6.00540899e-02f, -2.44929239e-01f, 1.99486375e-01f, 1.79358169e-01f, 1.43855840e-01f, 5.56041710e-02f, 3.62377465e-01f, 6.78115152e-03f, 2.80383348e-01f,
  -2.03321618e-03f, 1.56294271e-01f, 2.61140436e-01f, 1.47577792e-01f, -2.28595838e-01f, 1.44933775e-01f, 8.96007046e-02f, 9.01746843e-03f, 2.06825420e-01f, 9.14767832e-02f,
  1.34693116e-01f, 1.09489240e-01f, -2.61599217e-02f, -7.59717226e-02f, 2.65413165e-01f, 2.18102224e-02f, -5.60393045e-03f, 2.63498724e-01f, -1.48063660e-01f, 2.24011779e-01f,
  -8.08272436e-02f, -1.28115609e-01f, -6.17211312e-02f, -3.96073647e-02f, 3.06659043e-01f, 1.90771550e-01f, 6.74409568e-02f, 2.15551391e-01f, 5.26215509e-02f, 1.31356046e-01f,
  6.71855360e-02f, 1.82979569e-01f, 1.87879428e-01f, 2.79660672e-01f, -7.92477131e-02f, 1.34651482e-01f, 2.22644940e-01f, 1.63913533e-01f, 1.95737377e-01f, 1.55886233e-01f,
  -1.17949113e-01f, -1.08255702e-03f, 5.09443693e-02f, -3.18552554e-03f, -1.21150456e-01f, 9.81422961e-02f, -1.05161764e-01f, 1.03603192e-01f, -6.55349195e-02f, 2.01216459e-01f,
  -2.65819626e-03f, -1.31023318e-01f, 7.57027566e-02f, -2.70796344e-02f, 2.34038591e-01f, -1.01703502e-01f, 1.17982909e-01f, -4.42964509e-02f, 6.62154853e-02f, -2.17248678e-01f,
  -1.09360419e-01f, 1.44334465e-01f, 1.51984990e-01f, -2.68630028e-01f, 6.71302574e-03f, 3.46291929e-01f, -8.79014581e-02f, 1.14019275e-01f, 3.14104825e-01f, -1.47726536e-02f,
  2.31365249e-01f, 1.25831395e-01f, 1.23946555e-01f, 5.26188985e-02f, 2.37707004e-01f, 1.37379646e-01f, -8.04505199e-02f, 3.10496390e-01f, 5.13631366e-02f, 1.12484932e-01f,
  8.98970664e-02f, -2.30864212e-01f, -2.08688512e-01f, -9.07080173e-02f, 1.43406048e-01f, 1.16876423e-01f, -7.20155239e-02f, 1.94158420e-01f, -1.97472945e-01f, 1.65770262e-01f,
  -5.44835329e-02f, -1.27882525e-01f, -1.61352921e-02f, -2.27005854e-02f, -1.61757618e-02f, 1.83862612e-01f, 6.03215136e-02f, -7.95703009e-02f, 1.42094776e-01f, 8.08869526e-02f,
  -1.03676490e-01f, 3.41005111e-03f, -4.29289881e-03f, 8.72209743e-02f, -9.63609666e-02f, -1.77943051e-01f, -1.06091328e-01f, 1.58394113e-01f, -4.11758162e-02f, -1.65517069e-02f,
  -2.00403795e-01f, -9.75238755e-02f, 1.86328813e-01f, -8.47946331e-02f, 9.70820934e-02f, 3.06097806e-01f, -2.00642109e-01f, 9.47055742e-02f, -1.18610308e-01f, 3.21677685e-01f,
  -3.15812416e-02f, -3.72328192e-01f, 3.65135849e-01f, 1.64395332e-01f, 2.45710045e-01f, -2.66553216e-05f, -2.24886924e-01f, 2.33294800e-01f, -2.91515350e-01f, -2.75686860e-01f,
  2.40947843e-01f, 2.56553173e-01f, -1.43314272e-01f, 1.77523389e-01f, -1.45987496e-01f, -2.13213041e-01f, 3.83022390e-02f, -2.25548372e-01f, -1.85970843e-01f, 9.54057202e-02f,
  7.31416866e-02f, 8.37608501e-02f, -1.09215543e-01f, 5.15996814e-02f, -1.17923126e-01f, 3.12218428e-01f, -1.58323884e-01f, 1.86979651e-01f, 1.34999137e-02f, 6.42727539e-02f,
  1.51243836e-01f, -5.90696074e-02f, -7.88339879e-03f, -7.11310431e-02f, 5.95079064e-02f, -5.34982700e-03f, 2.06272319e-01f, 9.97691229e-02f, 2.35549599e-01f, 1.66232005e-01f,
  1.56447649e-01f, -2.76780128e-02f, 2.50673413e-01f, 7.98636600e-02f, 4.15715054e-02f, 4.62345183e-02f, 5.99786118e-02f, 1.51743278e-01f, 1.51267588e-01f, -1.76060095e-01f,
  -2.09590346e-01f, -6.32422566e-02f, -9.84096155e-02f, 3.28600220e-02f, -1.33817658e-01f, 2.24254370e-01f, 1.88880503e-01f, 5.34216240e-02f, 2.03519493e-01f, -2.38890752e-01f,
  2.01077208e-01f, -4.29249890e-02f, 9.02405530e-02f, -1.68794960e-01f, 4.76848669e-02f, 1.78774595e-01f, 6.64469823e-02f, 4.55083027e-02f, 7.87835419e-02f, 1.19833767e-01f,
  6.30194694e-02f, -9.93221551e-02f, 2.21480027e-01f, 2.98515502e-02f, 1.67918101e-01f, 8.37548375e-02f, 5.89298569e-02f, 2.17492148e-01f, 1.44375876e-01f, 9.14049521e-02f,
  1.81298926e-02f, 1.02882929e-01f, 4.14654687e-02f, -2.11639032e-01f, 4.39540334e-02f, 2.15590727e-02f, 2.60362625e-01f, -1.09761208e-01f, 2.63972282e-01f, 1.46112248e-01f,
  -6.17251173e-02f, 5.63981012e-02f, -1.92904413e-01f, -1.13704093e-01f, 2.42105592e-02f, 8.01056549e-02f, 1.86264724e-01f, 1.90004185e-01f, -9.88157690e-02f, 2.05873847e-01f,
  2.33740032e-01f, 4.82478850e-02f, 2.18693659e-01f, 2.61919498e-01f, 1.25096977e-01f, 7.30269104e-02f, 6.54650778e-02f, 2.61833340e-01f, 1.68048203e-01f, 8.27064440e-02f,
  1.68527380e-01f, 7.66732022e-02f, -2.42425337e-01f, 1.80946276e-01f, 8.44159275e-02f, 8.77822042e-02f, -1.28153816e-01f, -7.12361336e-02f, -8.02441910e-02f, 1.93474829e-01f,
  2.00011596e-01f, -1.73383117e-01f, -1.60752550e-01f, -2.50797600e-01f, 2.59420335e-01f, -1.74793098e-02f, 3.71720344e-01f, 8.09067786e-02f, -2.28227694e-02f, 1.63513422e-01f,
  1.88023560e-02f, 4.72436287e-02f, -6.51027784e-02f, 2.56143123e-01f, -1.29069477e-01f, 9.42041576e-02f, 9.01248530e-02f, 1.40457675e-01f, -2.25505173e-01f, -8.66404623e-02f,
  1.53935561e-02f, -2.97670454e-01f, 1.28289714e-01f, -6.48602843e-03f, 2.64817834e-01f, 2.99985349e-01f, 2.45969534e-01f, 1.58332467e-01f, 4.61240374e-02f, 2.59218574e-01f,
  8.46324041e-02f, 8.87841582e-02f, 6.73254430e-02f, 3.73109691e-02f, -2.34794319e-02f, 2.46609170e-02f, 5.85619267e-03f, -1.01615466e-01f, -3.25832218e-01f, -7.06693083e-02f,
  1.29692376e-01f, 3.17053586e-01f, -1.09061651e-01f, -8.85629654e-02f, 1.50347158e-01f, 1.06340222e-01f, 1.52251124e-01f, 9.86497700e-02f, 1.83675006e-01f, 6.99252784e-02f,
  2.45881110e-01f, 1.24898776e-01f, 1.50887221e-02f, 4.61180061e-02f, 2.45170310e-01f, 1.87970981e-01f, 2.09089205e-01f, 2.28229031e-01f, 2.13761419e-01f, -1.28854305e-01f,
  -6.76852167e-02f, -1.54849067e-01f, 1.14691146e-01f, 1.20848104e-01f, -1.02513209e-01f, -6.70689195e-02f, 7.88757503e-02f, -2.53568366e-02f, 1.63770452e-01f, 2.33429477e-01f,
  1.68570325e-01f, -3.80815491e-02f, 1.17911845e-01f, 2.67435700e-01f, 1.31181702e-02f, -5.38910180e-03f, 2.39779711e-01f, 1.39329750e-02f, 2.02248588e-01f, 5.76676577e-02f,
  1.54018208e-01f, 5.01917750e-02f, -1.86890457e-02f, -1.51854321e-01f, 2.51176447e-01f, 2.55716413e-01f, 1.60125941e-01f, -4.81615104e-02f, -1.94657102e-01f, 2.17385784e-01f,
  2.30511680e-01f, -5.16369231e-02f, 2.72148997e-01f, 1.28117755e-01f, -3.71167585e-02f, 2.22031306e-02f, 2.42899477e-01f, 6.60970509e-02f, 2.62599349e-01f, -1.41027480e-01f,
  1.82276919e-01f, 1.97903991e-01f, 2.04489946e-01f, 1.77730724e-01f, -2.69960493e-01f, -2.88357973e-01f, -4.21515405e-02f, -3.02871340e-03f, 1.26849279e-01f, 1.83222547e-01f,
  1.98934019e-01f, 1.10728748e-01f, 1.42197922e-01f, 2.82069519e-02f, 2.79928267e-01f, 3.88546512e-02f, 7.26264901e-03f, -2.36654263e-02f, 4.08541821e-02f, 1.92501515e-01f,
  8.17462951e-02f, -1.92381784e-01f, -2.11198315e-01f, 2.33928919e-01f, -1.02630056e-01f, -1.26891911e-01f, -1.37707978e-01f, -1.70731738e-01f, 1.92517519e-01f, 2.98061874e-02f,
  2.31892139e-01f, 8.11912939e-02f, -1.29217133e-01f, 1.45916611e-01f, -2.09033579e-01f, 1.38132185e-01f, 1.22775093e-01f, 9.16774943e-02f, 2.24861443e-01f, -6.87468052e-02f,
  3.00694972e-01f, 1.97879478e-01f, 5.96647672e-02f, 1.10939205e-01f, -1.94345657e-02f, -2.13734657e-01f, 8.65111202e-02f, 1.47398651e-01f, -2.12770775e-01f, 2.74384767e-01f,
  -2.43829086e-01f, 7.27239922e-02f, 1.35626063e-01f, 8.85646343e-02f, -1.13358408e-01f, -1.56653896e-01f, 2.55320132e-01f, -1.98809192e-01f, -1.08776271e-01f, 3.90010029e-02f,
  1.37653023e-01f, 1.36675298e-01f, 1.04573444e-01f, 1.93299241e-02f, -5.36055006e-02f, -1.92950800e-01f, 9.02983099e-02f, -6.14563748e-02f, 8.73111114e-02f, -3.18825804e-02f,
  1.48046255e-01f, 2.57105321e-01f, 2.52187967e-01f, 1.13789424e-01f, 1.30437195e-01f, 2.26463705e-01f, 2.09838584e-01f, 2.89959498e-02f, 5.16914092e-02f, 2.03207746e-01f,
  2.07681254e-01f, 2.67803282e-01f, 8.50963891e-02f, 1.24751151e-01f, -3.09344530e-01f, 2.49899670e-01f, 2.04353243e-01f, -5.12233041e-02f, -1.37389004e-01f, 1.66544616e-01f,
  1.45637663e-02f, 1.73987746e-01f, 6.86076209e-02f, -4.93958965e-02f, -2.36589670e-01f, 6.83852434e-02f, 1.25789061e-01f, 2.52781719e-01f, 2.28355139e-01f, -3.05810361e-03f,
  -3.90727669e-02f, 9.63627249e-02f, -1.40357181e-01f, 1.24846317e-01f, -3.08764465e-02f, 4.74394113e-02f, -4.87384498e-02f, 7.35545605e-02f, -9.38151330e-02f, 3.54102142e-02f,
  -7.74319575e-04f, -1.23663522e-01f, 5.63152172e-02f, -3.01828444e-01f, 1.01560786e-01f, 1.25983775e-01f, 1.49236605e-01f, 7.94805810e-02f, 2.41790444e-01f, 2.45362207e-01f,
  -6.54179752e-02f, 1.03240304e-01f, 3.21706794e-02f, 1.62980348e-01f, -1.92992985e-01f, 1.45892143e-01f, -1.35049924e-01f, 2.47379974e-01f, 2.95659482e-01f, 2.32190982e-01f,
  -1.18907839e-01f, 3.04851290e-02f, 4.04481366e-02f, 2.30917811e-01f, 1.76695362e-01f, -7.29385018e-02f, 8.48041847e-02f, 2.20188439e-01f, -4.82422486e-03f, 2.21027941e-01f,
  -1.88180786e-02f, 1.17520399e-01f, 1.69967443e-01f, 7.12023824e-02f, 1.51601076e-01f, 6.65652752e-02f, 2.89351703e-03f, -6.71418384e-02f, -1.11673601e-01f, 1.61359627e-02f,
  -1.42927319e-01f, 1.42084852e-01f, 8.24373960e-03f, 2.09472895e-01f, -9.00092945e-02f, -1.36218518e-01f, -1.50109693e-01f, -6.06999062e-02f, -5.61413951e-02f, 2.45420650e-01f,
  -1.44526690e-01f, 1.20223030e-01f, -1.95994198e-01f, 2.55728841e-01f, -1.03720300e-01f, 2.21843217e-02f, -8.91124904e-02f, -3.22766453e-02f, -2.05520809e-01f, 2.66392082e-01f,
  -2.78518610e-02f, 8.32841620e-02f, 6.85997605e-02f, -2.12525740e-01f, 1.79114342e-01f, 1.53017327e-01f, -6.18949272e-02f, -2.15404943e-01f, -1.19199336e-01f, 2.55458564e-01f,
  1.98083296e-01f, -1.17365420e-01f, -7.58480886e-03f, 2.58720547e-01f, 1.20865554e-02f, 7.41617475e-03f, 5.64898811e-02f, 3.19259971e-01f, -6.22874647e-02f, 2.70427167e-01f,
  -8.63367766e-02f, 1.68583661e-01f, 2.03102365e-01f, -4.55344692e-02f, 1.11538805e-01f, -1.30089045e-01f, 1.92689240e-01f, 1.55589014e-01f, 2.16110602e-01f, 1.76630244e-01f,
  1.78432196e-01f, 1.20978892e-01f, 2.16268569e-01f, 1.85586721e-01f, 6.59356043e-02f, 6.61803707e-02f, 2.07732134e-02f, 1.56470641e-01f, 9.63196084e-02f, 8.60969573e-02f,
  6.64174482e-02f, -9.20776743e-03f, 1.32472947e-01f, -2.52592623e-01f, -3.22955668e-01f, 9.75821912e-02f, 1.20527476e-01f, 2.44593412e-01f, -2.43859172e-01f, 2.24163368e-01f,
  1.18667014e-01f, -8.66643488e-02f, 9.87637863e-02f, -1.92290530e-01f, 1.68035448e-01f, -1.99953228e-01f, 1.91348270e-01f, 2.40986161e-02f, -3.41140926e-02f, 6.98145330e-02f,
  1.67131037e-01f, -1.11946255e-01f, -4.55440469e-02f, 2.85173059e-01f, 1.78781733e-01f, -4.88934889e-02f, -5.39225079e-02f, 2.05583736e-01f, 2.26851553e-01f, 2.34740138e-01f,
  -8.46605897e-02f, 4.67341430e-02f, -9.36450958e-02f, 9.63145792e-02f, 1.20993108e-01f, -7.52040297e-02f, -9.79112387e-02f, -4.65126522e-02f, -2.33249769e-01f, -5.05027361e-02f,
  2.97222048e-01f, 9.50131286e-03f, 6.28224239e-02f, -7.95672685e-02f, -2.06611585e-02f, 2.45835125e-01f, -2.76493400e-01f, -3.99144925e-02f, 1.18887603e-01f, 1.12438008e-01f,
  3.60851914e-01f, 3.39144230e-01f, 8.84746313e-02f, 5.70217818e-02f, 1.10294841e-01f, 1.83740675e-01f, 8.32323208e-02f, 2.17241600e-01f, 3.05858385e-02f, 1.03517912e-01f,
  1.23244978e-01f, 7.07832724e-02f, 1.51657060e-01f, 1.73688725e-01f, 2.68441617e-01f, 1.58095434e-01f, -2.12224469e-01f, -1.85285956e-01f, -7.17988610e-03f, 1.81613371e-01f,
  1.08502875e-03f, -6.19773529e-02f, 6.85751438e-02f, -4.86513749e-02f, 1.17538020e-01f, 7.51656070e-02f, -6.60681054e-02f, 1.82713300e-01f, -1.69123426e-01f, 4.73247394e-02f,
  1.34924427e-01f, 1.10224254e-01f, 1.13815889e-01f, -2.53278702e-01f, 9.13756341e-02f, -1.62251398e-01f, -1.46862820e-01f, 2.15232968e-01f, 5.93192615e-02f, 2.51434129e-02f,
  -1.12284996e-01f, 9.77305993e-02f, 2.75026411e-01f, 2.81486571e-01f, 7.28438795e-03f, -2.22691186e-02f, -7.83201978e-02f, 2.18770921e-01f, 1.97753593e-01f, 5.30347088e-03f,
  -1.01477280e-01f, 2.13121753e-02f, -1.29923508e-01f, 2.42842242e-01f, 1.67572454e-01f, 3.53091419e-01f, -7.82023743e-02f, 1.72250364e-02f, -2.15373099e-01f, 1.05009079e-01f,
  5.56945503e-02f, 2.72487998e-02f, -1.29060939e-01f, 8.45324472e-02f, 1.27965018e-01f, 2.00308487e-01f, 3.38156343e-01f, 1.37838438e-01f, 5.99500909e-02f, 2.13294178e-01f,
  4.98173460e-02f, 2.08106920e-01f, 1.62951246e-01f, 1.85526475e-01f, 1.76263765e-01f, 1.82439730e-01f, 1.57347709e-01f, 2.33798906e-01f, 7.32764378e-02f, 8.53286013e-02f,
  -5.38244843e-02f, -1.00085907e-01f, -9.31076407e-02f, -1.81845985e-02f, 2.36282483e-01f, 2.08755046e-01f, 1.26572385e-01f, -4.21023332e-02f, -2.50307262e-01f, 8.90732408e-02f,
  -1.97487995e-01f, 2.19528541e-01f, -1.75498858e-01f, 1.65828407e-01f, 1.87610060e-01f, -1.81157384e-02f, -2.00162660e-02f, -1.22368097e-01f, -5.89316599e-02f, 2.67702073e-01f,
  -9.62787941e-02f, -9.91534740e-02f, -2.16980856e-02f, 3.31371091e-02f, -1.40026987e-01f, -9.67067853e-02f, 6.30645081e-02f, -1.44250169e-01f, 1.57527804e-01f, -2.21641108e-01f,
  -6.34548962e-02f, 1.69265911e-01f, -3.56702842e-02f, -1.54379606e-01f, 9.06822160e-02f, 8.88349935e-02f, -1.19709283e-01f, 2.30189562e-01f, 5.79524860e-02f, -1.04278676e-01f,
  -8.28418210e-02f, -6.39594868e-02f, -1.94663808e-01f, 1.90459818e-01f, 2.00204581e-01f, 1.51169181e-01f, 8.90052319e-02f, -8.99480954e-02f, 2.14384839e-01f, 3.16591514e-03f,
  5.74032813e-02f, 1.37248918e-01f, 1.65073752e-01f, 1.30604044e-01f, 1.78581685e-01f, 3.41714583e-02f, 6.55264109e-02f, 1.98114872e-01f, 2.41246969e-01f, 1.48788840e-01f,
  6.52578175e-02f, 2.57198978e-02f, 4.94260117e-02f, 6.47735000e-02f, 1.60134971e-01f, 2.35049263e-01f, 2.69053310e-01f, -3.45523864e-01f, -1.30429655e-01f, -2.00693414e-01f,
  1.34814158e-01f, -1.51900023e-01f, 5.89338094e-02f, -1.58385873e-01f, -5.63666783e-02f, 9.62999463e-02f, 2.32625425e-01f, 2.14779042e-02f, 1.94882497e-01f, -7.87401795e-02f,
  2.16996968e-01f, 2.99487084e-01f, -2.28318721e-01f, 6.63882568e-02f, 1.45466313e-01f, 6.17832541e-02f, -5.86098060e-02f, -1.80531200e-02f, 3.04561824e-01f, -1.43527463e-02f,
  -5.73369972e-02f, -3.08438372e-02f, 2.41392240e-01f, -1.63449436e-01f, 8.80616978e-02f, 2.25743309e-01f, -1.67291626e-01f, 1.19731314e-01f, 3.27053756e-01f, -1.55240312e-01f,
  1.72516689e-01f, 1.77184716e-02f, -1.45812690e-01f, 7.23214447e-02f, 1.25474796e-01f, -7.11523220e-02f, 2.44878709e-01f, -2.02886611e-01f, 3.95868830e-02f, 1.54866308e-01f,
  1.79629475e-02f, 6.50656894e-02f, -3.52360368e-01f, -8.20240080e-02f, 1.95551794e-02f, 9.04071033e-02f, -6.67602792e-02f, 5.52338809e-02f, -4.33202460e-02f, -2.33168881e-02f,
  -1.13329832e-02f, 2.48235330e-01f, -1.30419731e-01f, -8.30158405e-03f, -3.00769191e-02f, 1.02833487e-01f, 1.37496963e-01f, 4.91052158e-02f, -6.59569651e-02f, -5.56013808e-02f,
  -1.70005053e-01f, 7.40231052e-02f, 9.03076679e-02f, 1.94458932e-01f, -1.42999813e-01f, -1.24893934e-01f, -2.33137365e-02f, 2.29272559e-01f, 1.38648242e-01f, 2.39385784e-01f,
  -1.18596517e-01f, 1.15126379e-01f, -1.94776759e-01f, 5.41080311e-02f, 1.65025428e-01f, 2.07986566e-03f, 9.51020643e-02f, -1.12358570e-01f, -6.10172823e-02f, 5.41383177e-02f,
  1.63962632e-01f, -1.38109997e-01f, -1.74197733e-01f, 1.81705311e-01f, 2.88924783e-01f, 2.17460826e-01f, 1.73386991e-01f, -4.35154960e-02f, 1.77032933e-01f, 7.55308792e-02f,
  1.53593980e-02f, -2.07640097e-01f, -8.16583112e-02f, 1.97858557e-01f, -3.10450234e-02f, -1.81495056e-01f, 1.99053705e-01f, 2.76428580e-01f, 2.14562967e-01f, 9.95414928e-02f,
  -1.01244099e-01f, -9.21877176e-02f, 1.35352775e-01f, 7.50177130e-02f, 1.02197677e-01f, 3.10683101e-01f, -1.17675789e-01f, 1.35723412e-01f, 2.41297111e-01f, 9.14400443e-02f,
  1.22155063e-01f, 2.14339092e-01f, 2.26812363e-01f, 2.15606578e-02f, 1.68967441e-01f, 1.72795370e-01f, 4.25591283e-02f, 1.97656110e-01f, -5.40803336e-02f, 1.15548939e-01f,
  4.45326529e-02f, 2.38040090e-01f, 5.86391538e-02f, -1.89271510e-01f, -1.27614558e-01f, -1.40433669e-01f, 3.47060971e-02f, -1.32151291e-01f, -3.36904526e-02f, 5.55628985e-02f,
  -1.05855688e-01f, -1.29756436e-01f, 1.11812226e-01f, -9.97606218e-02f, 9.50133875e-02f, -2.15720966e-01f, -1.17855668e-01f, -1.78138480e-01f, 1.77324012e-01f, 3.85401368e-01f,
  -3.48389670e-02f, -4.99253757e-02f, 7.90688097e-02f, 3.27156842e-01f, 1.35849535e-01f, -1.05086297e-01f, 3.12436044e-01f, 1.18246697e-01f, 4.66589034e-02f, 8.17160979e-02f,
  -4.43832278e-02f, 1.15454882e-01f, 4.96024564e-02f, 2.79668957e-01f, 5.21507114e-02f, -8.11951421e-03f, 1.46758854e-01f, -1.66396633e-01f, 1.78114071e-01f, -1.71625167e-01f,
  2.14807197e-01f, 1.35874122e-01f, 2.07687765e-01f, 1.07752584e-01f, 3.30147207e-01f, 5.76793551e-02f, -6.99021667e-02f, -1.49161503e-01f, 1.83115035e-01f, -6.30612150e-02f,
  1.63365409e-01f, 1.62020370e-01f, 6.24332055e-02f, 2.02359810e-01f, 1.19794436e-01f, 1.03690848e-01f, 1.34889260e-01f, 2.39373729e-01f, 3.88383083e-02f, 9.90305096e-02f,
  6.57858178e-02f, 1.34870708e-01f, 1.45536631e-01f, 1.50283635e-01f, 5.49606085e-02f, -6.97909221e-02f, -2.10069701e-01f, 1.78578600e-01f, 1.51333630e-01f, 1.54140741e-01f,
  -3.79838794e-02f, 1.30557954e-01f, 2.86640637e-02f, 2.38741711e-01f, 1.50274143e-01f, -1.20550521e-01f, -2.10346878e-01f, -1.78143904e-01f, 5.17082699e-02f, 4.07497734e-02f,
  3.78130585e-01f, 1.38445765e-01f, -2.75689751e-01f, -6.73183501e-02f, 1.43233076e-01f, 6.69114739e-02f, -1.14733167e-01f, -1.18381388e-01f, -1.10636331e-01f, 1.95943892e-01f,
  7.24661630e-03f, 2.72804141e-01f, -1.11709863e-01f, 9.74142086e-03f, 1.40047342e-01f, -2.71466464e-01f, -7.35790050e-03f, -1.16281874e-01f, 5.42335492e-03f, 2.07509458e-01f,
  2.53404498e-01f, 9.90687162e-02f, -5.97482063e-02f, 2.98224270e-01f, 2.97230538e-02f, -1.58354998e-01f, -1.22426763e-01f, 2.00859651e-01f, -1.92238674e-01f, 1.84450209e-01f,
  3.31095718e-02f, 1.76375493e-01f, -2.01766640e-01f, -6.80815056e-02f, 2.89564431e-01f, 2.39670515e-01f, -1.21299177e-01f, -1.72436535e-01f, -2.24228334e-02f, 1.70910507e-01f,
  1.21307420e-02f, 6.26442656e-02f, 1.78254455e-01f, 1.31964117e-01f, -1.08807499e-03f, 4.47876453e-02f, 1.51125174e-02f, 7.21391141e-02f, 1.49126828e-01f, 2.08212003e-01f,
  1.37498498e-01f, -1.84610650e-01f, -1.64930910e-01f, -1.54701248e-01f, 3.43320191e-01f, 4.55986373e-02f, -2.04734989e-02f, -2.35636324e-01f, -2.42936358e-01f, -2.51690522e-02f,
  -1.02832660e-01f, 1.83254749e-01f, -5.04080951e-02f, 6.29112348e-02f, -1.12477347e-01f, -9.72442925e-02f, 3.56515676e-01f, 1.40601292e-01f, -1.57227032e-02f, 3.61061573e-01f,
  -1.18645191e-01f, -5.80067337e-02f, 8.61316174e-02f, -2.17004597e-01f, 2.20641181e-01f, -1.76037326e-02f, 3.70909534e-02f, 1.46288471e-02f, 4.03798744e-02f, 1.42982796e-01f,
  -8.26421231e-02f, 2.43107200e-01f, -2.40971167e-02f, -1.88218310e-01f, -2.63326615e-01f, 8.41606408e-02f, -9.87285599e-02f, -4.46299873e-02f, -2.04716567e-02f, -9.99863073e-02f,
  9.90303308e-02f, -1.86391875e-01f, 2.55908757e-01f, -1.48398317e-02f, -1.16189025e-01f, 1.38875321e-01f, 1.78408027e-01f, 1.22873217e-01f, 5.83625063e-02f, -1.09071583e-01f,
  2.34003644e-03f, 1.20117955e-01f, 6.26700046e-03f, 3.92934568e-02f, 1.83668494e-01f, -1.42403664e-02f, 6.81988597e-02f, -2.25728108e-05f, 1.09627165e-01f, 2.42039815e-01f,
  1.13346770e-01f, -4.71128337e-02f, 1.58734798e-01f, 3.16007555e-01f, 3.66268247e-01f, -5.00323176e-02f, 8.51387307e-02f, -1.08848847e-01f, 8.52789879e-02f, -1.88304037e-01f,
  1.16246581e-01f, -4.14828807e-02f, -8.83821845e-02f, 1.90396965e-01f, 2.45370731e-01f, -1.14124775e-01f, 6.21751025e-02f, 8.16338733e-02f, -1.57046884e-01f, -8.02782476e-02f,
  2.91472256e-01f, 1.67887449e-01f, -6.70553744e-02f, 2.41828337e-01f, 5.58255278e-02f, 1.08788699e-01f, 4.76714596e-02f, -1.33386692e-02f, 3.28498453e-01f, -1.08123332e-01f,
  -7.79542178e-02f, 3.15584056e-02f, -1.55402035e-01f, 3.20763618e-01f, -1.51881352e-01f, 1.64846838e-01f, -1.03863485e-01f, 1.83753550e-01f, -6.50733933e-02f, -2.35141531e-01f,
  2.71788180e-01f, -4.30897437e-02f, -7.54413232e-02f, 5.94149195e-02f, 3.16334754e-01f, -9.76734534e-02f, 2.66800702e-01f, -6.43965788e-03f, -2.17598721e-01f, -4.20654975e-02f,
  1.03603996e-01f, -2.45603502e-01f, -1.74318194e-01f, -1.90097943e-01f, -9.87015963e-02f, 2.83316225e-01f, 3.95652875e-02f, 2.21081246e-02f, 1.07992455e-01f, 1.27895460e-01f,
  4.03194875e-02f, -3.04768886e-02f, 2.86218226e-01f, 1.59454450e-01f, 1.98399797e-02f, 9.13114846e-02f, 1.92427814e-01f, 2.95723439e-03f, -3.27105522e-02f, -3.03527921e-01f,
  -1.53598398e-01f, 7.85887316e-02f, 1.85719356e-01f, -9.38838273e-02f, -1.40009522e-01f, -3.03963479e-02f, 1.23404115e-01f, 2.76590466e-01f, 8.72501731e-02f, 2.50212759e-01f,
  -1.97168827e-01f, -4.56502102e-03f, 4.59462032e-02f, 1.96972594e-01f, 1.16634888e-04f, -2.80918926e-01f, 2.58486450e-01f, -1.89383581e-01f, 1.75355688e-01f, 7.90635645e-02f,
  -6.58416152e-02f, 1.54457763e-01f, -1.39163360e-01f, -1.48189425e-01f, 1.38948441e-01f, 2.95857579e-01f, -1.44626528e-01f, 1.78841069e-01f, -1.03855990e-01f, -8.37833658e-02f,
  1.40349180e-01f, -1.53723285e-01f, -9.15601179e-02f, 1.50794476e-01f, 1.14928238e-01f, 4.44615632e-02f, 7.13661592e-03f, 4.44878777e-03f, -5.79263531e-02f, 1.90394446e-01f,
  -4.33103815e-02f, 1.12902738e-01f, 4.84712161e-02f, -1.05186053e-01f, 7.20404759e-02f, -3.21809202e-01f, -3.94550636e-02f, 1.58378258e-01f, 1.50214866e-01f, 1.18327580e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 40)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 40;
const float L1_fan_Bp_bar_data[] = {
  1.64660186e-01f, 2.06460401e-01f, 2.19525233e-01f, 5.08229658e-02f, 1.65304303e-01f, 1.10397831e-01f, 4.47419658e-02f, 1.77825302e-01f, -2.29454450e-02f, 1.99560538e-01f,
  2.03508392e-01f, 1.14414610e-01f, 2.12563038e-01f, 1.65409118e-01f, 2.21201777e-01f, 1.61376223e-01f, 9.17946026e-02f, 9.64729488e-02f, 1.18517540e-01f, 1.74298391e-01f,
  1.46845132e-01f, 1.92027897e-01f, 1.56955779e-01f, 1.07866094e-01f, 3.01053487e-02f, 2.55763412e-01f, 1.42270148e-01f, 1.69285148e-01f, 2.56753713e-01f, 8.13192800e-02f,
  3.66461240e-02f, 4.08771746e-02f, 1.13251016e-01f, 9.83134955e-02f, -4.84639853e-02f, 1.38238266e-01f, 1.39432862e-01f, 5.82152829e-02f, 1.73450053e-01f, 3.45143937e-02f
};

// L2_fan_Wp (Shape: 12 x 64)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 64;
const float L2_fan_Wp_data[] = {
  -4.87346947e-02f, 8.62832516e-02f, -6.89014941e-02f, 1.07272230e-01f, 1.20680161e-01f, -8.37526098e-02f, -5.59602380e-02f, 7.74740800e-02f, 1.64441429e-02f, -7.19042346e-02f,
  -1.42869055e-01f, -5.63293919e-02f, 1.61322847e-01f, 1.07335104e-02f, -8.49667341e-02f, 1.02789819e-01f, 1.30954042e-01f, -9.13631022e-02f, 1.20940842e-01f, -4.09991443e-02f,
  -1.92779571e-01f, 3.27230766e-02f, 1.74851805e-01f, 1.36381298e-01f, -1.37708783e-01f, -4.94357273e-02f, -5.81340911e-03f, 1.02203816e-01f, -7.66137317e-02f, -1.12614423e-01f,
  1.11546777e-01f, -1.34140640e-01f, -1.13588519e-01f, 9.95912701e-02f, -8.09932053e-02f, -1.55888364e-01f, -1.42369464e-01f, -5.74433878e-02f, 1.34190947e-01f, 6.18941635e-02f,
  1.03676729e-01f, 7.28409290e-02f, -1.11502312e-01f, 1.62294563e-02f, -2.48058746e-03f, 1.26569688e-01f, -1.25112936e-01f, 1.67723894e-02f, 1.15806190e-02f, 1.86418086e-01f,
  -8.15192536e-02f, -1.50371194e-01f, 1.69269368e-01f, 8.77005532e-02f, 6.78420998e-03f, -2.79449150e-02f, -4.73250300e-02f, 7.84685311e-04f, 2.96080429e-02f, -7.54225394e-03f,
  1.72821060e-01f, -1.34599388e-01f, -8.78296942e-02f, -7.66375940e-03f, -1.70804206e-02f, -3.45449448e-02f, -2.16895938e-02f, 5.32638170e-02f, 1.31712288e-01f, -7.05553293e-02f,
  -8.64946842e-02f, 1.28182955e-02f, -1.12434797e-01f, -5.05574420e-02f, -3.56921591e-02f, -2.37640645e-02f, -1.45689622e-01f, 1.72843244e-02f, -6.62769005e-02f, 8.85151401e-02f,
  1.69618174e-01f, -7.62201399e-02f, -7.29172528e-02f, 1.32739037e-01f, -1.12933040e-01f, 1.40335888e-01f, -1.32039800e-01f, 1.24985002e-01f, -1.20022021e-01f, 5.11105433e-02f,
  -3.11918743e-02f, -6.19797874e-03f, 9.71758813e-02f, 3.65651138e-02f, 2.17774704e-01f, -9.95973125e-02f, 1.39758632e-01f, 5.00976071e-02f, -5.37157170e-02f, 8.97575170e-04f,
  -5.20262718e-02f, 9.95548666e-02f, 4.52685431e-02f, 1.12661064e-01f, -1.19076230e-01f, -1.88211530e-01f, 2.60228552e-02f, 3.71370539e-02f, 1.49718747e-01f, -3.58381048e-02f,
  -1.24214150e-01f, 3.51856533e-03f, -2.91405004e-02f, 5.22593185e-02f, -3.81243252e-03f, 5.36832958e-02f, 1.70130685e-01f, 5.40766753e-02f, -4.57768254e-02f, -2.08272096e-02f,
  -2.03970566e-01f, 2.12881297e-01f, -4.52563167e-02f, 1.93377510e-02f, 1.25497222e-01f, -1.32096186e-01f, -2.31917635e-01f, -1.15163708e-02f, 2.26813345e-03f, 7.54916295e-02f,
  -8.04073513e-02f, 1.02315769e-02f, 1.28652662e-01f, 3.34867947e-02f, -4.57197167e-02f, -4.16716523e-02f, -9.32691470e-02f, -4.74748798e-02f, 6.09563962e-02f, -2.48738695e-02f,
  -3.51566933e-02f, 4.95023243e-02f, 2.44661808e-01f, -1.55749902e-01f, 4.05646116e-02f, -1.21023171e-02f, 1.28083929e-01f, -2.16530338e-01f, 1.25491947e-01f, -5.10931313e-02f,
  -2.21619800e-01f, -5.43900114e-03f, 1.31199881e-01f, 1.51709154e-01f, 1.79936606e-02f, -7.79638961e-02f, 5.60641289e-02f, -1.03790835e-01f, -2.40319803e-01f, 3.49051096e-02f,
  3.10044247e-03f, 1.07882909e-01f, 1.20551609e-01f, 3.03759240e-02f, -6.59781024e-02f, 8.63255188e-02f, -9.81464908e-02f, 1.51694501e-02f, 2.05707833e-01f, -1.95334926e-02f,
  -1.52801469e-01f, -2.09330216e-01f, -1.07723661e-01f, -3.98925319e-02f, 3.38169709e-02f, 9.05290246e-02f, -1.07392997e-01f, -5.97193614e-02f, -1.56642795e-02f, 3.42008546e-02f,
  -1.21441372e-01f, 8.95125642e-02f, -2.70946790e-02f, 8.73382390e-02f, -4.75906208e-02f, -6.11296669e-02f, 1.57017142e-01f, 5.21440171e-02f, 7.16502741e-02f, 6.62044436e-02f,
  -1.86083034e-01f, 3.31689813e-03f, 1.58328637e-02f, -1.82253141e-02f, 1.59586981e-01f, 3.15959081e-02f, -8.04999918e-02f, -5.00764064e-02f, -1.27597302e-01f, -1.42764533e-02f,
  -4.40200269e-02f, 6.71760067e-02f, 2.78890245e-02f, 1.32521959e-02f, 6.15189373e-02f, -4.98576695e-03f, -1.56862568e-02f, -6.91131577e-02f, 2.21715737e-02f, -1.47722840e-01f,
  1.37774527e-01f, 1.09806798e-01f, -1.66012142e-02f, 1.88783750e-01f, 2.84486175e-01f, -6.96427152e-02f, 5.42998873e-02f, 7.15278834e-02f, -1.14587419e-01f, 1.37609839e-02f,
  1.65071674e-02f, -3.09020579e-02f, -6.27956912e-02f, -1.74318943e-02f, 3.18384878e-02f, 3.75159495e-02f, -1.90917421e-02f, 4.92806919e-03f, 6.67454349e-03f, 6.45016283e-02f,
  4.37681712e-02f, -1.42826542e-01f, 2.62709465e-02f, -4.98898141e-02f, 6.01959713e-02f, 3.33044236e-03f, 2.12910742e-01f, 7.27287084e-02f, 1.75374970e-02f, -1.16330869e-01f,
  -1.35351807e-01f, 7.09579140e-02f, 1.50826067e-01f, -1.39313817e-01f, -1.52094187e-02f, 4.70606191e-03f, -1.32405207e-01f, -9.61685479e-02f, -5.19108474e-02f, 1.40906990e-01f,
  -1.59790918e-01f, 1.27166137e-02f, -1.78251386e-01f, 1.40502006e-02f, 1.48264408e-01f, -1.53506458e-01f, -4.66068015e-02f, -1.01864584e-01f, -3.54067348e-02f, -5.48341721e-02f,
  -1.25769600e-01f, -5.37157953e-02f, -2.09004283e-01f, -2.04964206e-02f, -1.01454563e-01f, -1.29672270e-02f, -1.42157644e-01f, -8.49496201e-02f, -1.73702855e-02f, 2.45634675e-01f,
  3.20887305e-02f, -7.19010737e-03f, -3.54164168e-02f, -1.29675493e-01f, 1.48004428e-01f, 1.51297465e-01f, -1.29351735e-01f, 1.18070811e-01f, 1.06499955e-01f, 7.07588717e-02f,
  1.01905644e-01f, -5.00937216e-02f, -1.34026870e-01f, -1.18641205e-01f, -8.94870088e-02f, 3.25783677e-02f, -1.32895291e-01f, -1.26635388e-01f, 2.59789042e-02f, 4.39398214e-02f,
  6.78538680e-02f, -6.81865588e-02f, -2.06311792e-01f, 7.89418370e-02f, -3.22222821e-02f, -1.26217231e-01f, -7.11475462e-02f, 1.12497192e-02f, 8.77987370e-02f, -4.91629802e-02f,
  -3.45657840e-02f, -2.79350951e-02f, 2.81442646e-02f, 1.38501242e-01f, 1.12146355e-01f, -4.21078131e-02f, 1.36002630e-01f, 3.60293873e-03f, 3.39542255e-02f, -7.57990479e-02f,
  -4.64253463e-02f, -1.89637411e-02f, 1.53760938e-02f, 2.00686708e-01f, -1.46233037e-01f, 4.65448201e-02f, -1.27058074e-01f, -1.73515584e-02f, -5.78594021e-02f, -1.54892743e-01f,
  -7.89748207e-02f, 2.42533665e-02f, -4.28218916e-02f, 2.24605035e-02f, 1.38342261e-01f, 9.69754234e-02f, 4.07791696e-03f, -1.04326084e-01f, 5.14695495e-02f, 7.07553700e-02f,
  -1.14304893e-01f, 1.05458327e-01f, 1.03289023e-01f, -1.62381530e-01f, -1.63556576e-01f, -5.35505451e-02f, -5.90628907e-02f, 7.30421171e-02f, -1.70546398e-02f, 3.65031138e-02f,
  8.02966282e-02f, -9.40079987e-02f, -2.19877049e-01f, 1.43081203e-01f, -6.76222667e-02f, -2.58080028e-02f, 8.24299678e-02f, -6.08316325e-02f, -1.81533352e-01f, -1.79748997e-01f,
  3.82934846e-02f, 1.71097502e-01f, 1.11852391e-02f, -3.26940306e-02f, -2.33319953e-01f, -6.09613992e-02f, 1.60616562e-01f, 9.72081572e-02f, 5.84139973e-02f, 1.13084897e-01f,
  -1.54697314e-01f, -2.27251306e-01f, 3.05965040e-02f, 7.63810948e-02f, 9.90604609e-02f, -1.14982873e-02f, -1.80693388e-01f, 1.58339664e-01f, 1.37701198e-01f, -2.13266518e-02f,
  -1.39401481e-01f, 9.50889811e-02f, -2.17048847e-03f, 1.25177294e-01f, 8.68671536e-02f, 1.00550853e-01f, 1.17615744e-01f, -6.00696020e-02f, -2.28242546e-01f, 3.54569629e-02f,
  1.79240167e-01f, -1.80729441e-02f, 8.26161057e-02f, -2.07073260e-02f, 1.83533672e-02f, -4.44580577e-02f, 5.74566573e-02f, 1.87003672e-01f, 1.17535785e-01f, 1.91131122e-02f,
  8.95887315e-02f, 8.58362764e-02f, 5.04480749e-02f, -7.39335045e-02f, 1.92854330e-01f, 1.05297968e-01f, 1.10170394e-01f, -2.01512009e-01f, 2.11674780e-01f, -2.33670939e-02f,
  -1.43088594e-01f, -1.80156872e-01f, 2.40031689e-01f, -3.10472213e-02f, -1.77520424e-01f, -6.20397590e-02f, 2.96647009e-02f, 6.73129112e-02f, 1.15629874e-01f, 2.69925836e-02f,
  -7.07064290e-04f, 5.47187217e-02f, 1.72564805e-01f, -1.22100636e-01f, -1.30161196e-01f, 1.51475757e-01f, 3.61030735e-02f, -1.38916150e-01f, -9.99782383e-02f, 3.99915092e-02f,
  1.18052252e-01f, 1.03588283e-01f, 4.72472534e-02f, 1.62247255e-01f, 7.87335485e-02f, 3.92496400e-03f, -1.88537128e-02f, -3.97290960e-02f, -6.46738559e-02f, -8.40703696e-02f,
  1.49493292e-02f, -1.31198257e-01f, -8.04509148e-02f, 5.88001385e-02f, 2.11447105e-02f, 1.68908641e-01f, 3.55607420e-02f, 6.55760765e-02f, -1.36818305e-01f, 1.27829626e-01f,
  4.16032784e-03f, -1.51322439e-01f, 1.01103887e-01f, 1.52041484e-02f, 4.55020256e-02f, -1.50131330e-01f, -1.05577320e-01f, 9.99755785e-02f, -2.69975103e-02f, -1.18685983e-01f,
  7.23350495e-02f, -1.96564212e-01f, -1.76734954e-01f, -8.71766657e-02f, 3.01459599e-02f, -6.43760934e-02f, -1.06444538e-01f, -4.09422293e-02f, 2.89744902e-02f, -4.31267023e-02f,
  1.79725830e-02f, -2.37254407e-02f, -9.15503651e-02f, -1.43255955e-02f, -1.54778391e-01f, -1.96677566e-01f, -1.32513046e-01f, -1.34843647e-01f, -9.27777886e-02f, -2.27601007e-01f,
  2.75197886e-02f, 2.07896121e-02f, -8.13085809e-02f, -2.96017416e-02f, 3.32969055e-02f, -1.64651945e-02f, -2.73585394e-02f, -7.28849471e-02f, 3.27134095e-02f, 5.31759970e-02f,
  2.11448520e-02f, 1.06570259e-01f, -3.57520096e-02f, 3.51018570e-02f, -8.60767215e-02f, 1.53529108e-01f, -1.98801830e-01f, -3.05737965e-02f, 1.30914390e-01f, -1.37664795e-01f,
  -7.21319467e-02f, -2.08339691e-01f, -1.59110323e-01f, 1.17148079e-01f, 2.25491710e-02f, 2.17310563e-01f, -4.52441871e-02f, 1.10589296e-01f, -8.08611419e-03f, 7.06711560e-02f,
  -1.43260658e-01f, -4.06160429e-02f, 7.45415092e-02f, 2.20524687e-02f, -8.63556564e-02f, -6.18076473e-02f, 1.00704044e-01f, 4.50062044e-02f, -1.19851917e-01f, -3.72101814e-02f,
  -2.02619340e-02f, 6.98038563e-02f, 7.95440823e-02f, -4.89463247e-02f, -3.03253960e-02f, -9.69706327e-02f, -8.12622905e-02f, 1.28057539e-01f, 2.75465436e-02f, -3.47079225e-02f,
  -9.18009207e-02f, -2.19830349e-02f, -1.76717676e-02f, 1.30054606e-02f, -9.40806344e-02f, -3.09577156e-02f, -3.11860144e-02f, -8.16783756e-02f, -2.68599123e-01f, 5.02173267e-02f,
  1.28323138e-01f, -8.23808834e-02f, -6.12482941e-03f, -1.40307829e-01f, 1.72898769e-02f, -1.03604957e-01f, -3.93441804e-02f, 1.47396130e-02f, 9.19656605e-02f, 5.76975755e-02f,
  5.77282496e-02f, -1.16599850e-01f, 2.82645635e-02f, 4.40620556e-02f, 3.97787690e-02f, -2.54995674e-02f, 6.04648888e-02f, -4.10325229e-02f, 1.08478099e-01f, 1.40825182e-01f,
  -8.03278685e-02f, -1.12567600e-02f, 1.94751710e-01f, -5.39646931e-02f, -1.60108224e-01f, -1.39567867e-01f, -1.45990714e-01f, -1.24489605e-01f, 5.73177338e-02f, 7.16008991e-02f,
  1.09261096e-01f, -1.78858578e-01f, -8.49701390e-02f, 2.93948199e-03f, -5.58778197e-02f, 1.06604129e-01f, 4.83839586e-02f, -1.34174656e-02f, 4.26142402e-02f, -3.32715213e-02f,
  1.91350371e-01f, -8.59403536e-02f, -3.35618295e-03f, 1.03965312e-01f, -2.45290771e-02f, 2.08607931e-02f, -9.58127715e-03f, 3.32537368e-02f, -9.79806408e-02f, 3.13932002e-02f,
  5.23888953e-02f, -3.68452594e-02f, 3.18615995e-02f, 4.94636782e-02f, 2.87028514e-02f, 6.43207878e-02f, -1.84370708e-02f, 1.39733836e-01f, -4.87365164e-02f, 1.48558378e-01f,
  -1.93554431e-01f, 1.14404254e-01f, 1.12255633e-01f, 8.44162609e-03f, -2.47300908e-01f, -2.86472607e-02f, 1.01925850e-01f, -2.18233913e-01f, 3.29609402e-02f, -3.41429114e-02f,
  6.03474975e-02f, -6.97314441e-02f, 1.02862187e-01f, -1.19363353e-01f, -1.67984068e-01f, 1.96208194e-01f, -3.87038514e-02f, 6.89038858e-02f, 7.42538944e-02f, -3.86559330e-02f,
  -1.33050814e-01f, 4.29830886e-02f, -1.70196798e-02f, -1.64475352e-01f, -5.20010516e-02f, -1.02557495e-01f, -2.17275955e-02f, -1.30889416e-02f, 1.55921042e-01f, 8.09575468e-02f,
  4.24011871e-02f, 8.47680047e-02f, -8.04559141e-02f, -5.55384047e-02f, 1.51872501e-01f, -8.96177813e-02f, 7.38280341e-02f, 1.36378318e-01f, -2.87965387e-02f, 8.61287713e-02f,
  4.68863696e-02f, -6.26842305e-02f, 1.25719473e-01f, -4.25695702e-02f, -1.30219027e-01f, 1.38535723e-02f, -6.42295107e-02f, -6.54582027e-03f, 1.85625076e-01f, 4.25351560e-02f,
  -4.89935316e-02f, 9.16806832e-02f, -4.99754101e-02f, -9.45496932e-02f, -7.23709688e-02f, 7.30879232e-02f, -2.20688805e-01f, 8.57835412e-02f, 1.02424994e-01f, -1.41082004e-01f,
  -3.46709155e-02f, -7.72908479e-02f, 4.05007303e-02f, 6.87782094e-02f, -8.27115774e-02f, -2.31549982e-02f, 1.11811593e-01f, 2.07358766e-02f, -1.16069175e-01f, 1.04867760e-02f,
  -1.76922575e-01f, 2.62490660e-01f, 1.02278255e-01f, 2.12970544e-02f, 2.53770035e-02f, -4.76810411e-02f, -6.15695976e-02f, 1.05894528e-01f, 1.28052607e-01f, -5.69723099e-02f,
  7.97571987e-03f, 4.30048406e-02f, -7.45924339e-02f, -1.09675391e-04f, 1.97307020e-01f, 7.58911148e-02f, -1.01339333e-01f, 1.20919824e-01f, -8.00702795e-02f, -4.55238298e-02f,
  3.52675915e-02f, 6.93909824e-02f, -9.97410435e-03f, 1.16089679e-01f, -4.26907800e-02f, -1.58104032e-01f, 4.33383323e-02f, 1.44251123e-01f, -1.29304513e-01f, -1.04465634e-01f,
  -3.03436145e-02f, 9.19452161e-02f, -8.13999102e-02f, -9.46647897e-02f, -1.03481382e-01f, 5.68703711e-02f, 4.58742306e-02f, 1.87302470e-01f, -7.33086690e-02f, -1.01213962e-01f,
  1.11489989e-01f, -5.62221520e-02f, -1.59440767e-02f, 1.33274063e-01f, 9.90686864e-02f, 5.75521812e-02f, -1.58268132e-03f, -1.37237892e-01f, -1.38698563e-01f, 8.22533444e-02f,
  -9.86017063e-02f, -5.57962665e-03f, -1.59969151e-01f, -9.01014656e-02f, 2.99332310e-02f, -7.62425512e-02f, 1.34573758e-01f, -3.79282422e-02f, -4.76261862e-02f, 2.30542421e-02f,
  -7.27595314e-02f, -1.80030018e-01f, -1.53321519e-01f, -7.42725655e-02f, -9.85157043e-02f, -1.94694642e-02f, -4.02404033e-02f, 1.22276425e-01f, -1.26885265e-01f, 3.24304588e-02f,
  5.27867265e-02f, -2.44982131e-02f, -1.01594366e-02f, -1.68676913e-01f, 5.64875603e-02f, 1.04710720e-01f, -1.85133189e-01f, -9.43767652e-02f, -1.70133770e-01f, 6.43430948e-02f,
  1.31998941e-01f, -1.75148081e-02f, 3.21856998e-02f, 4.69485149e-02f, 8.65923315e-02f, -2.37254556e-02f, -1.27904952e-01f, -4.61755469e-02f, -1.52356714e-01f, 4.76224460e-02f,
  9.25575271e-02f, 1.76005498e-01f, 6.25732765e-02f, 3.34110744e-02f, -1.42868787e-01f, 6.18673069e-03f, 8.70332122e-02f, 4.21449356e-02f, -3.81621085e-02f, 1.22081123e-01f,
  2.00069393e-03f, -1.23715326e-01f, -1.12021916e-01f, -1.42990842e-01f, 1.91930711e-01f, -1.16165727e-01f, 6.87287524e-02f, 1.74862698e-01f
};

// L2_fan_Wp_bar (Shape: 40 x 64)
const int L2_fan_Wp_bar_rows = 40;
const int L2_fan_Wp_bar_cols = 64;
const float L2_fan_Wp_bar_data[] = {
  -1.42635241e-01f, 2.12246835e-01f, -3.58686894e-02f, -1.25090063e-01f, -8.55362117e-02f, 2.71671880e-02f, -1.16005063e-01f, -1.18925519e-01f, -4.29231375e-02f, 1.24767147e-01f,
  -5.21057807e-02f, -1.12955734e-01f, 3.35196443e-02f, -1.56977102e-01f, 1.76513568e-01f, -8.80102068e-02f, -5.04584648e-02f, -1.58652276e-01f, 1.79534987e-01f, -1.47781059e-01f,
  -4.67271134e-02f, -7.58182928e-02f, -1.62321329e-01f, 2.03465521e-01f, 2.94033792e-02f, 2.22405002e-01f, -1.07130997e-01f, 3.94156054e-02f, 2.76413441e-01f, -1.22436494e-01f,
  2.01645255e-01f, 1.59964129e-01f, 6.22150628e-03f, 2.38474295e-01f, -5.47644831e-02f, -2.11494356e-01f, 5.60413934e-02f, -2.82033277e-03f, -6.32964671e-02f, 1.43352468e-02f,
  4.91848476e-02f, -2.01365307e-01f, -3.51677269e-01f, 1.66046634e-01f, 1.75646544e-01f, 7.14654401e-02f, 1.33232683e-01f, 7.78323635e-02f, 1.58216581e-01f, 1.29827634e-01f,
  8.81428272e-02f, -2.39048004e-01f, 1.87471211e-01f, 1.62193373e-01f, 5.48899733e-02f, -8.18434358e-03f, -3.43073197e-02f, 1.15041956e-01f, -2.06922948e-01f, 1.33776858e-01f,
  2.43131220e-01f, -3.97749066e-01f, -1.23950139e-01f, 1.36145100e-01f, 3.01017147e-02f, -5.67496270e-02f, 1.63897440e-01f, 4.07853350e-02f, 1.55562147e-01f, 8.85895416e-02f,
  1.56657591e-01f, -8.78465027e-02f, 1.54127926e-01f, 1.62027135e-01f, 1.63296089e-01f, 5.66044301e-02f, -9.90836844e-02f, -2.58622050e-01f, -2.24693254e-01f, -2.25298092e-01f,
  -9.73394811e-02f, 3.77795100e-02f, -6.68831095e-02f, -1.92862630e-01f, -3.98310237e-02f, -2.39743993e-01f, -2.45107323e-01f, 1.42615557e-01f, -7.11058751e-02f, 3.75597328e-02f,
  1.93371922e-01f, 2.66242296e-01f, 1.60205379e-01f, -1.16005875e-01f, 2.73489237e-01f, 2.76319444e-01f, 2.46664613e-01f, -1.84099376e-01f, 1.83695510e-01f, 1.02532946e-01f,
  3.20620626e-01f, 2.47764528e-01f, 1.03693537e-01f, 3.21334869e-01f, 1.06582098e-01f, -2.32506245e-01f, -5.66428937e-02f, 2.26759315e-01f, -7.98664689e-02f, 2.52355903e-01f,
  -1.69247568e-01f, 3.75933796e-01f, -4.46183458e-02f, -3.06668524e-02f, -2.40017679e-02f, 3.17425519e-01f, 8.29883441e-02f, 1.83820516e-01f, 6.28849491e-02f, 3.28470856e-01f,
  1.49145961e-01f, -1.47774741e-01f, 5.90694584e-02f, 4.43318747e-02f, 2.16845527e-01f, -1.46069705e-01f, -1.26430497e-01f, 3.03550363e-01f, 3.50669920e-02f, 2.03852579e-01f,
  -4.87644486e-02f, 2.27058187e-01f, 1.14143461e-01f, 1.53230026e-01f, -7.00498605e-03f, 1.94881633e-01f, -5.31609915e-03f, -2.90374621e-03f, 1.93480447e-01f, 2.14760393e-01f,
  -1.71376884e-01f, -5.20886183e-02f, 1.24412857e-01f, 1.18039593e-01f, 1.25060175e-02f, 1.64535772e-02f, 2.39323363e-01f, -5.43380268e-02f, 5.11942096e-02f, 2.28222162e-01f,
  -2.07326904e-01f, -1.83846891e-01f, 5.79297990e-02f, 2.05489308e-01f, -2.06803203e-01f, 2.85674065e-01f, 1.94396898e-01f, 1.48031460e-02f, 3.11407626e-01f, 5.19417562e-02f,
  -4.04919147e-01f, -1.97656274e-01f, 3.15059990e-01f, 6.62313327e-02f, -1.22161590e-01f, -1.66975290e-01f, 3.02037776e-01f, 1.00067802e-01f, -3.55311483e-02f, -1.12927690e-01f,
  1.22960888e-01f, 3.83100361e-01f, -1.24226615e-01f, -6.02902062e-02f, 1.52972832e-01f, -2.27381274e-01f, -2.35019475e-02f, 2.08944783e-01f, 7.73203820e-02f, -1.50439575e-01f,
  1.47238374e-01f, -9.39369872e-02f, -9.82935280e-02f, -1.08222710e-02f, 2.61456549e-01f, 6.15956932e-02f, -1.76801562e-01f, -7.51503557e-02f, 3.24092180e-01f, 3.50259058e-02f,
  -1.66630924e-01f, -9.55913812e-02f, 4.72726002e-02f, 7.38422722e-02f, -6.62556430e-03f, 3.37068401e-02f, 9.15952250e-02f, 9.67231318e-02f, 1.64994031e-01f, 1.43205881e-01f,
  6.24830760e-02f, -2.85014305e-02f, 1.11197196e-01f, 1.55336279e-02f, -2.48821110e-01f, 3.43539208e-01f, -1.88048184e-01f, -8.68632272e-02f, -9.40892398e-02f, 3.19645017e-01f,
  -1.39634043e-01f, -2.48111218e-01f, 1.90088168e-01f, 1.41390920e-01f, -9.34880227e-02f, -9.98854041e-02f, 8.97839963e-02f, 1.36514097e-01f, 2.50755325e-02f, 1.00416347e-01f,
  9.54767037e-03f, -5.87064102e-02f, 1.64029136e-01f, 2.43887126e-01f, 6.92547262e-02f, -2.07604691e-01f, 2.85347313e-01f, 3.02796453e-01f, -6.83229640e-02f, 8.94352570e-02f,
  2.82495677e-01f, -2.53677014e-02f, 8.31453726e-02f, 2.07316875e-01f, 3.90833378e-01f, -5.43323047e-02f, -6.93968534e-02f, -1.25134021e-01f, -2.09763452e-01f, 1.38473451e-01f,
  -2.17234179e-01f, -1.67447403e-01f, -6.06615506e-02f, 1.92677617e-01f, 1.51251495e-01f, 2.95996547e-01f, -1.80583790e-01f, 1.83636770e-01f, 3.30138713e-01f, -6.81169555e-02f,
  1.65724456e-01f, 1.08875312e-01f, -1.20067470e-01f, 2.32441857e-01f, -3.27097215e-02f, 1.97009861e-01f, -6.33990616e-02f, -1.22779012e-02f, 1.14278607e-01f, -2.93954322e-03f,
  1.92102894e-01f, 1.82587281e-02f, -1.77538376e-02f, 6.08695038e-02f, 1.63613558e-01f, 1.88655406e-01f, 1.24098204e-01f, -3.25821228e-02f, 5.49519062e-02f, -8.19133073e-02f,
  5.96903078e-02f, 2.17834845e-01f, 1.28159970e-01f, -1.64742127e-01f, -2.26715859e-02f, 2.85752922e-01f, -3.59870315e-01f, 2.24917293e-01f, 1.43633395e-01f, 1.86129645e-01f,
  -1.96660131e-01f, 2.09876671e-01f, 1.15348876e-01f, 3.37403029e-01f, 6.55966923e-02f, 3.48433465e-01f, 2.35303223e-01f, -1.57873496e-01f, 2.84287244e-01f, 1.05533302e-01f,
  -7.95888249e-03f, -1.71465904e-01f, -2.00321570e-01f, -1.94651768e-01f, -3.10545042e-02f, -1.94537863e-01f, 1.67015754e-03f, 1.88416898e-01f, -1.55445188e-02f, -5.05309030e-02f,
  3.51876199e-01f, 9.78433192e-02f, 8.62981752e-02f, -1.71833828e-01f, 1.63598165e-01f, 2.87100881e-01f, 3.69893581e-01f, -1.62744507e-01f, 1.78493321e-01f, -2.29601175e-01f,
  -1.22617275e-01f, -3.39747965e-01f, -1.38896435e-01f, 3.62286776e-01f, -6.32131696e-02f, 8.49654973e-02f, 1.58609748e-01f, 5.42859435e-02f, 9.88054648e-02f, -3.38400424e-01f,
  6.17269836e-02f, -1.32716894e-01f, -1.10175140e-01f, 4.46495153e-02f, -1.12254836e-01f, -2.51579545e-02f, -1.40225872e-01f, 1.11014776e-01f, 9.35025290e-02f, -9.04804766e-02f,
  -6.46836162e-02f, 1.30045891e-01f, 5.31308400e-03f, 2.56148756e-01f, -2.41365492e-01f, 1.04727246e-01f, 6.54717535e-02f, -2.92455610e-02f, -2.40578786e-01f, -1.86854526e-02f,
  2.17975140e-01f, 2.48723119e-01f, 1.52003780e-01f, -1.05219178e-01f, 8.00457671e-02f, 1.08853154e-01f, 1.68164179e-01f, -1.45098150e-01f, -3.49650830e-02f, 3.20502639e-01f,
  3.43868375e-01f, -2.57643074e-01f, -4.59004566e-03f, 5.24526462e-02f, 1.15286328e-01f, 1.02917030e-02f, -2.53754288e-01f, -2.81158626e-01f, 1.75314471e-01f, -2.07981467e-01f,
  -6.07176051e-02f, 7.84955397e-02f, 2.57140368e-01f, 3.36698070e-02f, 5.23148254e-02f, 4.20730375e-02f, -2.04301029e-02f, 1.79983839e-01f, 6.99263439e-02f, -1.01240210e-01f,
  8.03264901e-02f, -4.96603455e-03f, -2.53805891e-03f, -1.28500223e-01f, 2.36574039e-01f, -2.30583966e-01f, -2.58073639e-02f, 1.01646140e-01f, 5.59771992e-02f, 1.97385341e-01f,
  2.03734726e-01f, 2.68357933e-01f, 1.25690745e-02f, -2.53363132e-01f, 1.09369896e-01f, 1.20993562e-01f, 1.29651755e-01f, -2.64283177e-02f, 8.22366402e-02f, 1.20830528e-01f,
  -3.51672508e-02f, 1.09227866e-01f, 4.92917001e-03f, -2.73774918e-02f, -2.21858919e-02f, 1.29711315e-01f, 2.29582284e-02f, 2.93644443e-02f, 8.01232085e-02f, -7.57786408e-02f,
  -2.65088435e-02f, -7.02153817e-02f, -9.60546583e-02f, -1.85338199e-01f, -9.09870937e-02f, -2.18999103e-01f, -1.04749650e-01f, -1.62154227e-01f, -1.25194162e-01f, -1.00869536e-01f,
  1.38030097e-01f, 2.06223205e-02f, 4.62783389e-02f, 4.00657468e-02f, -1.52986139e-01f, -4.89623435e-02f, 2.32120439e-01f, 2.03838140e-01f, -1.12573609e-01f, -1.02669559e-01f,
  2.39723418e-02f, 9.89229307e-02f, -2.52665371e-01f, 1.61624819e-01f, 1.00724123e-01f, -1.42230615e-01f, -4.10501152e-01f, -1.04231879e-01f, -3.18563104e-01f, 2.74364144e-01f,
  1.84771731e-01f, 2.51969874e-01f, 1.61923036e-01f, 5.46585172e-02f, -2.64297388e-02f, 6.17553070e-02f, -1.17797643e-01f, -3.21622826e-02f, 3.24931145e-01f, 1.73438460e-01f,
  -1.66310474e-01f, -3.71028066e-01f, 2.83670008e-01f, 1.51475444e-02f, 1.41793806e-02f, -4.23152000e-02f, -2.76463479e-01f, 1.97189525e-01f, 4.77603190e-02f, 7.20335469e-02f,
  -3.43995467e-02f, 1.13756716e-01f, 4.61347960e-02f, -1.47665128e-01f, 1.13702454e-01f, 1.26805142e-01f, -2.29372513e-02f, 9.23018381e-02f, 1.16757929e-01f, 1.15369476e-01f,
  1.77735269e-01f, 1.50746563e-02f, -1.22286141e-01f, 1.55697793e-01f, -5.40843494e-02f, -1.01038225e-01f, -7.73863420e-02f, 9.31525661e-04f, -4.92471941e-02f, -1.01049013e-01f,
  3.52460563e-01f, -5.22725619e-02f, -1.30284086e-01f, 9.46728792e-03f, 2.14604959e-01f, 1.82726737e-02f, -2.66271859e-01f, 3.28146338e-01f, -1.72429696e-01f, 6.80032447e-02f,
  2.38301933e-01f, 1.42416984e-01f, -4.22606468e-02f, 1.85099840e-01f, 7.34636327e-03f, 1.49009854e-01f, -1.81726724e-01f, -7.79040251e-03f, 1.42934039e-01f, 9.32549015e-02f,
  -1.06112599e-01f, -5.07565141e-02f, 1.32391825e-01f, 1.69106036e-01f, 1.25632569e-01f, 7.09351972e-02f, 2.25153148e-01f, -1.20649256e-01f, 1.34588763e-01f, 2.81310081e-01f,
  -1.69712707e-01f, -9.29365158e-02f, 1.67117193e-01f, 6.50243834e-02f, -1.11741088e-01f, 1.21521138e-01f, 1.44761071e-01f, 2.52255678e-01f, -2.50455409e-01f, 1.23574249e-01f,
  2.66381919e-01f, 1.17028924e-02f, 9.47962329e-02f, 1.15348354e-01f, -3.33902165e-02f, 1.06840029e-01f, 8.35963786e-02f, -6.28384482e-03f, -9.43554100e-03f, -9.49336514e-02f,
  4.13446091e-02f, 2.02347696e-01f, 1.25005946e-01f, 5.47726788e-02f, 3.00174236e-01f, -1.86687782e-01f, 2.12197095e-01f, -1.37037635e-01f, -2.91253626e-02f, -9.11133662e-02f,
  -7.45983869e-02f, 6.54537901e-02f, -1.53341576e-01f, -2.77335823e-01f, 1.34819029e-02f, -8.37277994e-02f, -3.30830812e-02f, -1.75050929e-01f, 2.01558262e-01f, -7.97921792e-02f,
  -4.77654524e-02f, -5.35505563e-02f, -2.83087075e-01f, 2.95587689e-01f, 2.56687850e-01f, 5.41754328e-02f, -1.42863512e-01f, -8.52850638e-03f, 4.98313531e-02f, 3.68790142e-02f,
  8.26399401e-02f, 2.24687234e-01f, 1.64785817e-01f, -1.97219662e-02f, 1.15006492e-01f, -1.47971600e-01f, 3.42061758e-01f, 2.50519186e-01f, -1.10830791e-01f, 1.59836695e-01f,
  1.56776056e-01f, 1.46650583e-01f, -3.44351381e-02f, 2.19746992e-01f, -1.46227226e-01f, 1.52193457e-01f, 9.48918313e-02f, -6.94465414e-02f, -7.43591189e-02f, 1.27463087e-01f,
  -1.57724530e-01f, 2.16673955e-01f, -1.32644296e-01f, -7.29482323e-02f, 2.77058899e-01f, 1.34225590e-02f, -2.03232571e-01f, -1.42891675e-01f, 1.76134527e-01f, -4.31545228e-02f,
  -8.82253572e-02f, -1.82969738e-02f, 1.22526111e-02f, -2.14207575e-01f, 1.02937005e-01f, -1.55485235e-02f, -1.11639015e-01f, -5.63408770e-02f, 5.45322336e-02f, -3.29482406e-01f,
  -2.31635496e-01f, -1.13063745e-01f, -1.79065526e-01f, -2.63850540e-01f, -1.93368837e-01f, -2.49945559e-02f, -3.49306464e-01f, -6.08368367e-02f, 2.41285205e-01f, 1.18877940e-01f,
  -2.41916001e-01f, -6.91757053e-02f, -6.31189868e-02f, 1.09050460e-01f, -1.16730772e-01f, 2.45504022e-01f, 7.72151425e-02f, 2.40991935e-01f, 2.01060086e-01f, 2.09056348e-01f,
  -2.13453136e-02f, 1.89244002e-01f, 1.64674252e-01f, 4.09362584e-01f, -2.66748041e-01f, 8.07810053e-02f, 5.87863848e-02f, -2.95860738e-01f, -2.74989128e-01f, 9.62800458e-02f,
  2.48343840e-01f, 2.26434305e-01f, -7.58576319e-02f, 2.94870287e-01f, 1.64900988e-01f, -1.42466568e-03f, 1.54177547e-01f, 1.87010616e-01f, -1.21686095e-03f, 3.45476344e-02f,
  -1.95148196e-02f, -9.02956650e-02f, 5.49161099e-02f, 2.55536158e-02f, 8.35650414e-02f, 8.45819488e-02f, -1.01264440e-01f, -3.25031340e-01f, -4.66451533e-02f, 7.02331513e-02f,
  -6.14402629e-02f, 1.81465223e-01f, 7.47181252e-02f, -1.25985257e-02f, 2.00851530e-01f, -2.94831824e-02f, 2.25948319e-01f, -6.18528351e-02f, -6.35174587e-02f, -7.94442371e-02f,
  -3.85868996e-02f, 8.86040851e-02f, -4.01818082e-02f, -2.08189622e-01f, -6.86131790e-03f, 5.22888973e-02f, -8.62455294e-02f, -4.87064496e-02f, 7.70675167e-02f, 2.04187810e-01f,
  -2.29300022e-01f, -1.08652068e-02f, -9.89392251e-02f, 3.29869002e-01f, -7.57715777e-02f, 1.75261021e-01f, -3.22115398e-03f, 3.08082134e-01f, 2.49265954e-01f, -5.16924774e-03f,
  6.79782853e-02f, 1.03497274e-01f, 2.85737783e-01f, 2.00202987e-01f, -8.35764334e-02f, -6.34428412e-02f, 1.90304786e-01f, 2.40685821e-01f, -1.75764695e-01f, 1.46396697e-01f,
  9.70280766e-02f, -2.44423449e-01f, -2.71965802e-01f, 6.01130677e-03f, 2.14271143e-01f, 1.57578856e-01f, 2.20831975e-01f, 6.23091012e-02f, 5.63333044e-03f, 2.58708894e-01f,
  5.50707951e-02f, 5.91245741e-02f, 1.06630102e-01f, 4.96679246e-02f, 1.60323277e-01f, 1.45349517e-01f, 1.36463372e-02f, 1.21883892e-01f, -2.23541185e-02f, -7.01932982e-02f,
  2.74692267e-01f, -3.58163804e-01f, -1.55547768e-01f, -2.86258385e-02f, 7.32381940e-02f, 1.69251010e-01f, 2.17279955e-03f, -4.69684452e-02f, 1.32306799e-01f, 1.60975680e-01f,
  1.52068973e-01f, 1.54346243e-01f, 5.12768999e-02f, 4.98458333e-02f, 1.13942973e-01f, -1.79658029e-02f, -4.15092222e-02f, -1.33172087e-02f, 7.32155815e-02f, 2.26476626e-03f,
  -1.25884831e-01f, 1.54923558e-01f, 1.36179477e-01f, -1.86897889e-01f, 2.84496009e-01f, -2.63904989e-01f, -2.06220850e-01f, -2.44747400e-01f, 2.46906847e-01f, 6.24235207e-03f,
  3.63379985e-01f, -1.10382520e-01f, -2.80383956e-02f, -1.83772698e-01f, -1.17689110e-01f, 5.89505676e-03f, 2.97333330e-01f, 1.61087617e-01f, -1.35165200e-01f, -3.64169441e-02f,
  2.41087690e-01f, -9.82566476e-02f, -1.30564645e-01f, 2.25691646e-01f, 2.97558993e-01f, 6.58535883e-02f, -2.01143026e-01f, -1.71449363e-01f, -2.68623650e-01f, 2.39701122e-01f,
  2.04740450e-01f, -1.03115268e-01f, 9.82070342e-02f, 1.32812068e-01f, -1.95123032e-01f, 2.09707707e-01f, -3.67444125e-04f, 4.09206375e-02f, 2.20470667e-01f, 3.30246210e-01f,
  -1.05351284e-01f, -2.70112485e-01f, 3.15292686e-01f, 1.99190497e-01f, -5.51151931e-02f, -1.16058746e-02f, 1.64579544e-02f, 1.87108114e-01f, 1.33015096e-01f, 4.45726626e-02f,
  9.90900397e-02f, -1.42067773e-02f, 1.84313506e-01f, 1.62446976e-01f, 2.64764369e-01f, -3.21833752e-02f, 8.34813789e-02f, 3.20958756e-02f, -6.12256192e-02f, 1.18522242e-01f,
  -2.49719515e-01f, 6.55800179e-02f, 2.66845077e-01f, -6.48935884e-02f, 1.57739490e-01f, -8.40912387e-02f, 2.35326201e-01f, -1.96993142e-01f, 2.65990883e-01f, -2.13236153e-01f,
  -2.88798332e-01f, 4.46498021e-02f, 6.94593787e-02f, 2.44619951e-01f, 1.49656162e-01f, 3.72853316e-02f, 2.51835644e-01f, 1.34223960e-02f, 3.67695391e-02f, -9.16012079e-02f,
  -2.16243993e-02f, -1.68452645e-03f, -4.08396721e-02f, 8.79641175e-02f, 1.13481902e-01f, -1.39833763e-01f, -6.22074902e-02f, 4.89644594e-02f, 1.39262185e-01f, 5.65066282e-03f,
  -1.38790399e-01f, 7.60319680e-02f, -7.92916864e-02f, 1.72901899e-01f, 1.95046797e-01f, -2.75115430e-01f, 1.75462186e-01f, 4.78784330e-02f, 7.88282380e-02f, 1.76698249e-02f,
  1.54579639e-01f, -4.73354794e-02f, 3.00115168e-01f, 2.57565677e-01f, 2.54312456e-02f, -1.41853049e-01f, 2.70129800e-01f, -1.35722999e-02f, -9.70610883e-03f, 2.72354409e-02f,
  -2.40866870e-01f, -9.93372872e-02f, 1.08094253e-01f, 2.03060344e-01f, 1.13398626e-01f, 1.27495199e-01f, 1.09838583e-01f, 9.74543318e-02f, 1.41327754e-01f, 1.24590002e-01f,
  1.09142018e-02f, 9.66860205e-02f, -1.18067479e-02f, -4.44139689e-02f, 1.75110564e-01f, -1.03251323e-01f, 3.27338338e-01f, 1.69416323e-01f, 2.64780670e-02f, -1.71934199e-02f,
  2.52144724e-01f, 6.08144887e-02f, 2.48496369e-01f, 2.02922463e-01f, 6.75602108e-02f, 1.26482636e-01f, 3.83948348e-02f, 1.82089135e-01f, 1.07738309e-01f, 7.83800185e-02f,
  1.31878898e-01f, -7.32575282e-02f, -8.07768106e-02f, -5.83075779e-03f, -2.13677421e-01f, 1.47562370e-01f, 3.43442932e-02f, -1.73918620e-01f, 2.46002665e-03f, -2.56461710e-01f,
  5.41414097e-02f, 3.83259542e-02f, 1.51348680e-01f, 2.13876829e-01f, 1.91213712e-01f, 1.04968101e-02f, 2.56442487e-01f, 3.51608470e-02f, 2.63436943e-01f, -2.36521378e-01f,
  1.49724603e-01f, 1.87782466e-01f, 8.09497312e-02f, -1.45207137e-01f, 1.92100048e-01f, -1.74669087e-01f, 4.99933697e-02f, 1.31489575e-01f, -1.10635504e-01f, 3.17822129e-01f,
  -2.25926161e-01f, 2.46591836e-01f, 1.86895385e-01f, -1.64541453e-02f, 1.27329245e-01f, -6.96393009e-03f, 2.11559132e-01f, 1.18701063e-01f, 9.28472262e-03f, 7.51744136e-02f,
  5.42057864e-02f, 8.87737498e-02f, 1.99307680e-01f, -7.62846097e-02f, 2.15808287e-01f, 9.01465211e-03f, -1.43684950e-02f, 4.91442084e-02f, -3.07909459e-01f, 1.01989970e-01f,
  -1.90974101e-01f, -9.48531181e-02f, 1.02667874e-02f, 2.12796882e-01f, 3.31242825e-03f, -2.28319407e-01f, 9.14081633e-02f, 1.10659853e-01f, -4.62492615e-01f, -4.88945767e-02f,
  -2.77256537e-02f, 2.46934354e-01f, 6.24116138e-02f, 7.43275434e-02f, 2.50208855e-01f, -3.60275507e-01f, 1.48432493e-01f, 1.74254477e-01f, -9.15596709e-02f, -1.23834588e-01f,
  4.00072932e-02f, -1.57529041e-01f, -7.33116316e-03f, -1.12331863e-02f, 2.81750500e-01f, 2.84833973e-03f, 8.58846828e-02f, -6.08725883e-02f, 6.90416619e-02f, 2.14256898e-01f,
  -1.42196000e-01f, 1.83640808e-01f, 1.42480552e-01f, -5.27195930e-02f, -1.74377754e-01f, 1.75035939e-01f, -1.14455968e-01f, 6.98015243e-02f, 2.38765165e-01f, 3.17367196e-01f,
  1.83981836e-01f, 2.20318541e-01f, 1.54205248e-01f, -1.93585247e-01f, 1.11372694e-01f, -1.28896534e-01f, 3.13263446e-01f, -6.44313395e-02f, -1.61391526e-01f, -1.01849638e-01f,
  -8.34017061e-03f, 1.41590446e-01f, 5.54397851e-02f, 2.30862662e-01f, -1.68175641e-02f, -4.47344687e-03f, 1.63141713e-01f, 2.77770264e-03f, 1.41550317e-01f, 8.54054186e-03f,
  -2.62568258e-02f, 1.94859475e-01f, 1.67550161e-01f, -1.74976811e-01f, 2.83780992e-01f, 5.02378494e-02f, 1.43905371e-01f, -1.33566469e-01f, 6.00932874e-02f, 1.32070661e-01f,
  -2.72827707e-02f, -2.78170705e-01f, 1.04490772e-01f, 1.20544862e-02f, -1.44965630e-02f, 1.10102609e-01f, 1.63948134e-01f, -1.08940303e-01f, -4.39195335e-02f, 2.04029471e-01f,
  -1.66846454e-01f, 2.50855684e-02f, 9.30410996e-03f, 3.14370722e-01f, -3.19862396e-01f, -8.96486118e-02f, 3.52290682e-02f, -8.30929950e-02f, 1.24707548e-02f, 2.20354795e-01f,
  -1.77049898e-02f, 1.79973021e-02f, -1.65752620e-01f, 2.08432242e-01f, 1.74286693e-01f, 1.92138925e-01f, 1.73265070e-01f, -1.13359585e-01f, 3.19509864e-01f, 1.42814919e-01f,
  2.30726004e-01f, -4.57854383e-02f, 1.39243668e-02f, 1.25263853e-03f, 2.61925966e-01f, -4.92536984e-02f, 4.49486226e-02f, 1.86093599e-01f, -2.71687537e-01f, 1.33801132e-01f,
  -5.99122047e-02f, -4.85878214e-02f, 5.98811246e-02f, -2.45271856e-03f, 7.70033374e-02f, 3.13325860e-02f, 1.30788490e-01f, 2.16963843e-01f, 9.42875594e-02f, 7.34363794e-02f,
  4.09372337e-02f, 8.19267482e-02f, 1.95211828e-01f, 2.23249555e-01f, 4.11638543e-02f, 1.09569959e-01f, 2.20309794e-01f, -2.20737904e-01f, 6.56396672e-02f, 3.00199062e-01f,
  2.47656226e-01f, -6.04766682e-02f, 2.51754850e-01f, 1.50150165e-01f, -1.73341498e-01f, -1.22207753e-01f, 1.38845146e-01f, 2.35929877e-01f, 9.53265503e-02f, 1.77991480e-01f,
  3.04225773e-01f, 1.97657660e-01f, 3.15393736e-05f, 1.43902823e-01f, 3.88834439e-02f, -1.48381218e-02f, 8.95541534e-02f, 3.35938632e-01f, -1.31342113e-01f, -2.51173675e-01f,
  -4.77495836e-03f, -4.13865536e-01f, -1.87471621e-02f, 5.53059392e-02f, 7.64808729e-02f, 1.72945932e-02f, 3.99457291e-02f, 6.95183920e-03f, 3.44395667e-01f, 2.93547601e-01f,
  8.56055245e-02f, -2.15999976e-01f, 3.31290931e-01f, 2.18852073e-01f, 4.05031294e-02f, -1.57406822e-01f, 8.34240094e-02f, -1.22158956e-02f, 2.56335080e-01f, -7.41383508e-02f,
  -7.21502975e-02f, 1.09974504e-01f, -1.69753730e-01f, 2.30031222e-01f, 2.55097657e-01f, 1.10953793e-01f, 1.81931958e-01f, -2.20717743e-01f, -4.79191840e-02f, -8.79875049e-02f,
  9.53963995e-02f, 9.27348882e-02f, 8.37956294e-02f, 7.29582459e-02f, -3.14991958e-02f, 6.38458431e-02f, 4.81648929e-02f, 2.52788793e-02f, -2.84165069e-02f, 1.61302909e-01f,
  2.02502474e-01f, -1.85934320e-01f, -2.99883285e-03f, -7.24812457e-03f, -4.41452861e-02f, -1.11580282e-01f, -3.90138887e-02f, 2.51900107e-01f, -2.65936017e-01f, -1.04321331e-01f,
  1.57799587e-01f, 2.63726935e-02f, -1.20442599e-01f, -4.25730236e-02f, -2.39130735e-01f, 2.48449266e-01f, 9.27730575e-02f, 4.49400116e-03f, -5.60676567e-02f, 1.30650625e-01f,
  -6.04618415e-02f, -4.68750186e-02f, -5.48864976e-02f, 5.51396832e-02f, -4.32872958e-02f, 1.26031294e-01f, -2.15440169e-02f, 1.74403280e-01f, -6.41616285e-02f, -1.79738164e-01f,
  2.32426785e-02f, 2.22521186e-01f, 3.14855993e-01f, 9.21389759e-02f, -1.14220902e-01f, 1.42460048e-01f, 5.88542558e-02f, 1.40929237e-01f, 2.67467737e-01f, 1.31445006e-01f,
  -8.46887603e-02f, -6.52935654e-02f, -1.73247140e-02f, -2.21462563e-01f, -2.05706894e-01f, 3.09701145e-01f, -9.21640471e-02f, 3.99416611e-02f, 1.78717092e-01f, 4.96115051e-02f,
  1.51747122e-01f, 1.77534491e-01f, 1.08973518e-01f, 1.34848341e-01f, 8.29843655e-02f, 7.52366940e-03f, 1.54472873e-01f, -5.87927327e-02f, 1.69501111e-01f, 5.40111272e-04f,
  -7.54856914e-02f, 1.01290330e-01f, 7.81609416e-02f, 2.75498498e-02f, 1.29255518e-01f, 1.81657560e-02f, 3.40089440e-01f, 2.36167789e-01f, 2.26909835e-02f, 3.86148295e-03f,
  2.73433924e-01f, 1.68650016e-01f, 1.20412223e-01f, 1.06606275e-01f, 6.77696243e-02f, 1.78960681e-01f, 3.25893164e-01f, 2.59456128e-01f, 9.17430595e-02f, 1.72947228e-01f,
  1.97082371e-01f, 1.15810052e-01f, -1.20980710e-01f, 1.89141836e-02f, 7.80741200e-02f, 1.42601117e-01f, 4.50420305e-02f, 3.04093789e-02f, -6.95624799e-02f, -3.08757931e-01f,
  1.34306028e-01f, -4.17119451e-02f, 3.11704308e-01f, 2.03005135e-01f, 5.25569692e-02f, -1.01449788e-01f, 2.87577301e-01f, -3.43957320e-02f, 2.39798918e-01f, -3.82992625e-01f,
  2.54856944e-01f, 8.82797912e-02f, 2.28223935e-01f, -1.97049394e-01f, 6.31903186e-02f, -4.61503640e-02f, 6.77194893e-02f, 1.63674966e-01f, 4.22850214e-02f, 3.72246325e-01f,
  2.35222533e-01f, 1.04571521e-01f, 3.23216505e-02f, -3.60748880e-02f, 6.18688501e-02f, -2.05187991e-01f, 1.25588298e-01f, -1.17614083e-01f, -4.01293263e-02f, 3.34254324e-01f,
  -3.60495187e-02f, -3.76676046e-03f, -2.12697715e-01f, 8.68616551e-02f, 8.75208527e-03f, 1.28358930e-01f, 1.80608734e-01f, 1.83121353e-01f, 2.98830032e-01f, 2.18550235e-01f,
  -1.17085632e-02f, 6.21867813e-02f, 1.36656482e-02f, 1.24920737e-02f, -5.52760735e-02f, 1.33694097e-01f, 1.39437869e-01f, -1.67139351e-01f, 2.16361493e-01f, -2.08549246e-01f,
  -1.67890832e-01f, -7.64973313e-02f, 2.25765899e-01f, 8.44336289e-04f, -3.46035212e-01f, 3.64668608e-01f, 2.54270166e-01f, -3.84345651e-02f, -1.13291107e-01f, 6.03976939e-03f,
  1.34273797e-01f, 1.50041163e-01f, 6.07882701e-02f, -1.37769267e-01f, 1.41996548e-01f, 4.47270349e-02f, -1.01553902e-01f, -2.95025818e-02f, 3.83421659e-01f, 1.03831299e-01f,
  1.72818005e-01f, 1.47993669e-01f, -6.49088100e-02f, 1.59275517e-01f, 1.19610399e-01f, 7.33757466e-02f, 1.48261189e-01f, 1.35623455e-01f, -8.56694505e-02f, -1.01469226e-01f,
  -1.01112099e-02f, -7.54773170e-02f, 1.02109477e-01f, 1.00809507e-01f, -2.34476581e-01f, 1.83860078e-01f, -1.26015112e-01f, 1.44891486e-01f, 2.72627503e-01f, 2.48088054e-02f,
  6.69393083e-03f, -7.46490210e-02f, 5.32369018e-02f, 1.85693279e-01f, -2.15979461e-02f, 3.61196324e-02f, 6.85329661e-02f, 1.70513913e-01f, 4.21315506e-02f, 7.02874288e-02f,
  2.16766492e-01f, 6.02858886e-02f, 2.50120938e-01f, -2.23320588e-01f, 1.67240769e-01f, 1.34451121e-01f, -1.92299247e-01f, -1.78372294e-01f, -2.07622543e-01f, 1.13045119e-01f,
  -7.10194930e-02f, -1.77666560e-01f, 4.16286439e-01f, -2.33111173e-01f, -1.03171282e-01f, -2.71017015e-01f, 1.15630232e-01f, 7.96934515e-02f, -3.49274576e-01f, 2.01276824e-01f,
  1.21696860e-01f, 1.26372486e-01f, -1.12705544e-01f, 9.10817161e-02f, -1.08074255e-01f, 9.41273347e-02f, 1.27584741e-01f, -1.39046416e-01f, -9.04200524e-02f, 1.51146606e-01f,
  -8.89331941e-03f, 1.20695005e-03f, 2.39580423e-01f, 1.16547510e-01f, 1.44018218e-01f, -9.16550383e-02f, 5.34363128e-02f, 7.49606788e-02f, 1.82028543e-02f, -1.28369378e-02f,
  2.85764426e-01f, 2.31566295e-01f, -2.01356843e-01f, -2.61160523e-01f, 3.40992399e-02f, -9.18948129e-02f, -7.63991177e-02f, 1.83726232e-02f, -6.70749098e-02f, 3.41742821e-02f,
  -8.56306776e-02f, 2.62695402e-01f, 3.74094039e-01f, 1.00924671e-02f, 9.69163030e-02f, 6.07613511e-02f, 1.01074517e-01f, -4.83123250e-02f, 2.09231973e-02f, 1.37732923e-01f,
  1.50188372e-01f, 3.93942334e-02f, -1.45542352e-02f, 1.75747387e-02f, 1.95675462e-01f, 1.39453039e-01f, -4.14622314e-02f, -3.14109057e-01f, -1.30755946e-01f, 1.12489805e-01f,
  -3.58419567e-02f, -2.11947948e-01f, -8.62698928e-02f, 2.15448588e-01f, -2.94705898e-01f, 2.89690584e-01f, -4.96286142e-04f, 2.10245222e-01f, 2.08079219e-02f, 1.20782398e-01f,
  -1.58252805e-01f, 2.77905196e-01f, 2.45456561e-01f, 1.83183596e-01f, 1.24807619e-01f, 1.44767985e-01f, 3.52430367e-03f, 7.45894685e-02f, 1.41601354e-01f, 5.60791492e-02f,
  2.83563584e-02f, 4.68157709e-01f, -9.12112966e-02f, 1.62411243e-01f, 9.83049795e-02f, -1.48259923e-01f, -1.69905737e-01f, 1.53149068e-01f, 1.39507011e-01f, -2.32658964e-02f,
  2.78593004e-01f, 1.92396209e-01f, -8.32671672e-02f, 1.45919383e-01f, 2.86768675e-01f, -1.09048456e-01f, 2.61577159e-01f, 1.23617984e-01f, -2.34323516e-01f, -2.40227226e-02f,
  -9.08166915e-03f, 4.64508608e-02f, -4.71740291e-02f, -2.06028879e-01f, 2.22950876e-01f, -1.79307744e-01f, -6.95495084e-02f, 1.14459614e-03f, -8.83379355e-02f, 2.40154956e-02f,
  -1.16846375e-02f, -8.60575587e-02f, 1.94915101e-01f, -7.03487098e-02f, 1.31356701e-01f, -8.38057622e-02f, 1.21860616e-01f, -1.65308733e-02f, -6.25539944e-02f, -2.51814872e-02f,
  -1.10101001e-02f, -8.26195255e-03f, 7.79197514e-02f, 2.17016339e-01f, 1.88009918e-01f, -1.91638634e-01f, 2.96390355e-01f, 2.32049227e-01f, -8.91764387e-02f, 1.82671592e-01f,
  1.30338416e-01f, 1.67404100e-01f, 6.90397248e-02f, 2.90525794e-01f, -1.85784578e-01f, 1.83778420e-01f, 2.01678216e-01f, 1.52950451e-01f, -7.80716091e-02f, -4.54167761e-02f,
  5.84908649e-02f, 2.63859451e-01f, 1.77269027e-01f, -7.91324824e-02f, -2.12309405e-01f, -2.50223819e-02f, 3.63774672e-02f, -2.97038276e-02f, 1.53998688e-01f, 1.57260761e-01f,
  -1.61258765e-02f, 7.34737366e-02f, 3.21865499e-01f, 5.24803996e-02f, 2.04116032e-01f, -2.82804668e-01f, 6.77243471e-02f, 1.60939544e-01f, 1.94239810e-01f, -1.22645937e-01f,
  2.41226807e-01f, -1.11753345e-01f, -9.76394210e-03f, -2.03224987e-01f, -1.92414939e-01f, 4.14633721e-01f, 6.64480776e-02f, 2.26111442e-01f, 3.07310391e-02f, 9.71771926e-02f,
  1.77910909e-01f, -2.17260227e-01f, 1.39577966e-02f, 4.56419736e-02f, -5.64345866e-02f, 7.41940141e-02f, 1.49830297e-01f, 1.30330548e-01f, 3.39561313e-01f, -8.21092341e-04f,
  4.93881516e-02f, 4.15207595e-02f, 2.43201666e-02f, 3.11787188e-01f, 1.23139266e-02f, -3.01321834e-01f, 3.05422574e-01f, -6.47354126e-02f, 8.02089088e-03f, 2.16323715e-02f,
  3.89059275e-01f, 1.08440347e-01f, 2.56649375e-01f, -8.59043300e-02f, -2.88710773e-01f, 3.56717035e-02f, 7.11670294e-02f, 8.20956156e-02f, 3.11259348e-02f, 1.38741374e-01f,
  2.16710269e-01f, -1.48281023e-01f, -7.79440105e-02f, 1.34016246e-01f, 3.43944095e-02f, -2.56823320e-02f, 9.83104482e-02f, 1.76767614e-02f, 4.37933318e-02f, -2.49805525e-01f,
  1.43464297e-01f, 1.79067031e-01f, -7.99459517e-02f, -6.82935864e-02f, 6.27934411e-02f, 1.64483100e-01f, 1.50888681e-01f, 5.95473126e-02f, 4.83954027e-02f, -1.15884446e-01f,
  -1.18970610e-01f, 1.67102456e-01f, -7.15755671e-02f, 1.54365692e-02f, -1.56842880e-02f, 5.06203137e-02f, 1.92577410e-02f, 1.70871153e-01f, -2.14645743e-01f, -7.29575306e-02f,
  -1.22606225e-01f, 1.19362719e-01f, -2.67333221e-02f, -4.88163829e-02f, 1.68187078e-02f, -1.54679462e-01f, 1.33554056e-01f, -1.06872462e-01f, 1.48046128e-02f, 1.80908144e-02f,
  -6.70139715e-02f, 1.18013471e-01f, -1.20908789e-01f, 1.42002031e-01f, -6.37721196e-02f, -4.15315591e-02f, -8.53436068e-02f, 1.68246850e-01f, -1.40278384e-01f, -9.19484347e-02f,
  -3.87830198e-01f, -1.47735685e-01f, -5.07220514e-02f, 1.32320613e-01f, -2.65427291e-01f, -6.70713484e-02f, -2.20399067e-01f, -1.88193098e-02f, 5.86824678e-02f, 1.01404443e-01f,
  -2.63875723e-01f, 3.47553343e-02f, 6.77133203e-02f, 1.67891890e-01f, -4.26653586e-02f, 1.00910082e-01f, 3.01574618e-01f, 2.08896518e-01f, 5.88638224e-02f, -1.58533022e-01f,
  -4.93365675e-02f, 1.95316151e-01f, 2.06254140e-01f, 2.73218155e-01f, 1.04735300e-01f, 2.14126110e-02f, -1.41045749e-01f, -3.17575634e-01f, 1.77711740e-01f, 1.97521642e-01f,
  -2.56461859e-01f, 2.88288653e-01f, -1.86274126e-01f, 4.76702213e-01f, -5.41626588e-02f, 1.20055433e-02f, -1.37275994e-01f, 5.75431585e-02f, 3.74677069e-02f, 5.80114946e-02f,
  6.59164414e-02f, -1.08947745e-03f, 7.61519000e-02f, -3.45597506e-01f, -6.97818473e-02f, -1.32381320e-01f, 1.71284765e-01f, -3.53649911e-03f, 4.01865086e-03f, 3.49147081e-01f,
  1.13383606e-01f, -6.60546869e-02f, 6.80737942e-02f, 2.22266316e-01f, 8.17871764e-02f, 1.24004208e-01f, 3.67672592e-02f, 2.66754795e-02f, 3.03019434e-02f, 4.42805178e-02f,
  1.29767179e-01f, 7.75450468e-02f, 8.74420777e-02f, -2.78297871e-01f, -8.17160159e-02f, -1.07168630e-01f, -1.52417853e-01f, -2.28718415e-01f, -1.30762011e-01f, 1.19380534e-01f,
  -2.70937502e-01f, -3.25190991e-01f, 9.64419916e-02f, 1.45689353e-01f, -1.29426688e-01f, -1.21441342e-01f, 1.92532003e-01f, 2.79254854e-01f, -2.99690869e-02f, 1.27021587e-02f,
  1.53239161e-01f, 1.89301997e-01f, 5.72058596e-02f, -8.63153040e-02f, -1.35982111e-01f, 5.14639430e-02f, 3.53075236e-01f, 3.40056390e-01f, -9.26119238e-02f, 3.34987372e-01f,
  2.31859926e-02f, -3.40593785e-01f, -9.47712362e-02f, 9.80122108e-03f, 3.99061777e-02f, 5.50486445e-02f, -1.28245369e-01f, 2.06535205e-01f, 1.15664296e-01f, -8.52702092e-03f,
  1.34923354e-01f, 2.32480854e-01f, 7.55705237e-02f, 3.46826799e-02f, 4.00202000e-04f, 1.95851400e-01f, -1.13416448e-01f, -4.70328256e-02f, -4.67124619e-02f, 4.99140806e-02f,
  1.00098580e-01f, -2.17415765e-01f, 3.06564867e-02f, 2.62816817e-01f, -2.99115218e-02f, 1.60178632e-01f, -3.25986296e-02f, 1.44441679e-01f, 1.48069942e-02f, 1.05883762e-01f,
  3.15511078e-01f, 2.28616018e-02f, 7.06934854e-02f, 1.57134071e-01f, -5.08108102e-02f, 1.20982885e-01f, -3.57043892e-02f, -3.32470089e-01f, 2.62792200e-01f, -2.49803141e-01f,
  -4.61268313e-02f, -8.70554671e-02f, 1.83694229e-01f, -1.72707006e-01f, 1.43662453e-01f, -2.32307717e-01f, -3.17613989e-01f, 2.98361778e-02f, 2.17814334e-02f, 7.71665946e-03f,
  8.71296301e-02f, 1.07254930e-01f, -4.05171029e-02f, -2.52307057e-01f, -8.58939961e-02f, 3.45490396e-01f, 1.33213133e-01f, -8.65281075e-02f, -4.80599478e-02f, -3.58831473e-02f,
  2.22735688e-01f, 6.32381812e-02f, -1.15419710e-02f, 3.20762783e-01f, 2.06700802e-01f, -2.80188590e-01f, -1.02532525e-02f, 5.01743481e-02f, 2.27144703e-01f, 4.89506684e-02f,
  -2.61792559e-02f, -1.26029000e-01f, 5.45935184e-02f, 1.45612150e-01f, -2.29414880e-01f, 1.06881656e-01f, 8.85861069e-02f, 1.27086297e-01f, 5.63366376e-02f, 6.89983815e-02f,
  -7.96856210e-02f, -9.78154540e-02f, -1.27376780e-01f, 1.64800406e-01f, 6.16202243e-02f, -3.94748151e-02f, -3.34928744e-02f, 1.43114671e-01f, -8.19459092e-03f, -9.21829864e-02f,
  5.78853302e-02f, 1.31245866e-01f, -4.06365879e-02f, -4.73377993e-03f, 1.98782533e-02f, 1.12412937e-01f, -1.85736902e-02f, 8.30706209e-02f, 1.97677821e-01f, 3.10594868e-02f,
  2.92077631e-01f, -7.57138208e-02f, 9.66147184e-02f, 8.56994912e-02f, -1.29637152e-01f, -2.43083224e-01f, -1.87937737e-01f, 1.82830915e-01f, -1.39248267e-01f, -3.73876333e-01f,
  2.67245650e-01f, -6.56522587e-02f, 4.88503389e-02f, -2.13716239e-01f, 3.12930346e-02f, 8.89682919e-02f, -2.19799489e-01f, 2.40340263e-01f, -1.33760139e-01f, 1.80646852e-01f,
  1.21135488e-01f, 9.30623244e-03f, -5.10392152e-02f, 2.39587575e-01f, 2.49756411e-01f, 2.78365940e-01f, 6.37277886e-02f, 1.82239145e-01f, 2.20445678e-01f, -9.62183103e-02f,
  1.68551087e-01f, 9.68360342e-03f, 4.32018898e-02f, -5.09511903e-02f, -1.49673158e-02f, 1.61560118e-01f, 1.73026532e-01f, -1.98570341e-01f, 7.67731890e-02f, 3.54956627e-01f,
  -7.05324560e-02f, 8.66363496e-02f, 1.06709674e-02f, -7.99330324e-02f, -1.57452106e-01f, -2.65779458e-02f, 2.07743067e-02f, 2.23781809e-01f, -3.20962727e-01f, 2.04499856e-01f,
  2.39500269e-01f, 7.58925974e-02f, -7.76015073e-02f, 1.89674318e-01f, 3.25561389e-02f, -1.15952507e-01f, 2.22217515e-02f, -1.36316925e-01f, 1.69170037e-01f, -8.97823572e-02f,
  2.05194224e-02f, -7.03843981e-02f, 3.13631557e-02f, -9.37385485e-02f, -2.41312608e-01f, 2.20764324e-01f, 1.55632496e-01f, -1.97261646e-01f, -6.39073830e-03f, 2.78123975e-01f,
  9.98727232e-02f, -2.20366195e-01f, 8.69887769e-02f, 1.08030289e-01f, -2.59458870e-01f, 2.25283578e-02f, 9.47784334e-02f, 1.48917779e-01f, -1.15748875e-01f, -3.27326395e-02f,
  3.03636134e-01f, -1.96615294e-01f, -3.17072533e-02f, 3.16820480e-02f, 1.85519263e-01f, 1.88840121e-01f, 2.42676660e-01f, 9.25619304e-02f, -6.46046028e-02f, 1.59312397e-01f,
  -3.77659649e-02f, 4.86846417e-02f, 2.57331401e-01f, 3.60289328e-02f, -7.56804645e-02f, -7.59821981e-02f, -1.57372564e-01f, -8.23921263e-02f, 1.77002788e-01f, 8.25985000e-02f,
  -6.40641078e-02f, 2.08529830e-01f, -5.83440140e-02f, 7.92260468e-03f, 7.17732459e-02f, 2.04244077e-01f, 1.39249295e-01f, 1.47678927e-01f, 7.53653646e-02f, 1.29320204e-01f,
  4.57658023e-02f, 9.29638743e-02f, 1.32316932e-01f, -6.76004440e-02f, -2.33055204e-01f, -4.97503094e-02f, 9.93210375e-02f, -5.86856827e-02f, 3.24679129e-02f, 1.17321923e-01f,
  7.78446719e-02f, 2.96552777e-02f, 1.90893412e-01f, 1.51853740e-01f, -9.59538147e-02f, 1.72198310e-01f, 9.44182351e-02f, 1.48815364e-01f, 6.10334203e-02f, -1.59339577e-01f,
  7.42128193e-02f, -1.32878479e-02f, -1.27801627e-01f, 1.42270610e-01f, -1.54951185e-01f, -2.20559686e-01f, 2.03796059e-01f, -3.38523895e-01f, -8.54747817e-02f, -2.04455350e-02f,
  -8.36145282e-02f, 3.35715599e-02f, 4.12238657e-01f, -1.64707959e-01f, -2.40262926e-01f, 1.16616376e-02f, -2.96846945e-02f, 1.28217369e-01f, 2.35956758e-01f, 1.29809558e-01f,
  -1.66438609e-01f, -1.31716430e-01f, 3.51183951e-01f, 5.13148494e-02f, -7.92443007e-02f, 1.76402703e-01f, 1.57633230e-01f, -9.69551578e-02f, 4.04959880e-02f, 5.19469194e-02f,
  -5.25119156e-02f, 3.03808957e-01f, -4.46679778e-02f, 1.63202137e-01f, 3.00707012e-01f, 1.37325125e-02f, -1.53447082e-02f, 2.13100731e-01f, -1.06613666e-01f, 4.19292636e-02f,
  2.88363874e-01f, 2.18092918e-01f, 1.90667093e-01f, -2.29026526e-01f, 1.41096726e-01f, -2.02023629e-02f, -1.14234775e-01f, -8.64987969e-02f, 1.29985765e-01f, 1.41312227e-01f,
  9.43166986e-02f, 3.25473174e-02f, 1.41498074e-01f, -9.19258073e-02f, 2.59665996e-02f, 2.80220974e-02f, 1.62485186e-02f, 7.44023621e-02f, 1.06648967e-01f, 7.35563785e-02f,
  2.04146415e-01f, -9.55427662e-02f, 1.85229510e-01f, -2.44181350e-01f, 1.36297762e-01f, -4.49709967e-02f, -5.43315932e-02f, -1.64277136e-01f, 7.13737980e-02f, 1.75616279e-01f,
  -2.20222905e-01f, 6.15198724e-02f, 1.58457115e-01f, 9.17561427e-02f, -1.44618094e-01f, -8.03337991e-02f, 1.20141683e-02f, 3.13852400e-01f, 2.67801374e-01f, -1.65867526e-02f,
  6.77850693e-02f, -5.62685654e-02f, -2.67997365e-02f, 3.01204771e-02f, 2.69836448e-02f, 1.49105594e-01f, 1.05334960e-01f, 2.22148031e-01f, -1.07802087e-02f, -5.14963344e-02f,
  4.71849628e-02f, -1.01019509e-01f, -1.09741367e-01f, 1.28564790e-01f, 1.09155111e-01f, 1.19692124e-01f, 1.91830322e-01f, 2.72942543e-01f, -1.06315427e-01f, 1.91599399e-01f,
  1.70128092e-01f, 4.40791361e-02f, 1.94709212e-01f, -1.48396999e-01f, -1.49684384e-01f, 1.55352846e-01f, -9.71860737e-02f, 2.41236880e-01f, -2.04551771e-01f, -1.22036465e-01f,
  2.50046492e-01f, -2.39915878e-01f, -1.51902229e-01f, 2.45541453e-01f, 1.95474446e-01f, 1.25810485e-02f, 9.24089178e-02f, 1.54983997e-01f, 6.72053248e-02f, 5.94919957e-02f,
  -6.48400784e-02f, 2.24042591e-02f, 1.62179515e-01f, 1.73010662e-01f, 1.28288465e-02f, 9.11864415e-02f, -1.14355385e-02f, 1.81138635e-01f, 1.17932573e-01f, -8.95874202e-02f,
  -1.15909256e-01f, 2.89174467e-01f, 1.80986822e-01f, -2.45435134e-01f, 1.42520502e-01f, 2.76267268e-02f, -2.15732813e-01f, -1.97170660e-01f, 1.61548525e-01f, 1.52951702e-01f,
  4.94382204e-03f, -8.62821471e-03f, 4.50668707e-02f, -3.52045298e-01f, 1.85108215e-01f, 1.11881025e-01f, -1.76194936e-01f, -1.55015126e-01f, 1.96116015e-01f, 2.24421293e-01f,
  1.33180514e-01f, -2.95697134e-02f, 2.13598087e-01f, 2.80122250e-01f, 9.58225876e-02f, 3.70448753e-02f, 3.17392349e-01f, 1.24232337e-01f, -1.07656993e-01f, 1.53010279e-01f,
  -9.19784606e-02f, 2.63509363e-01f, -6.60118759e-02f, 1.79363415e-01f, -1.20738335e-02f, 1.55442089e-01f, 1.92116007e-01f, 2.82513350e-01f, 3.51666920e-02f, 1.95417434e-01f,
  2.70475328e-01f, -1.58806443e-02f, 8.92953947e-03f, 3.73485461e-02f, 1.34382904e-01f, 2.17476353e-01f, 1.38186544e-01f, 3.31025243e-01f, 5.75347012e-03f, -2.89350934e-03f,
  8.61924887e-02f, 1.98445469e-02f, 7.23514706e-02f, 7.14021176e-02f, 2.29580909e-01f, 2.20257491e-01f, 1.58766851e-01f, -5.00133410e-02f, -6.85778335e-02f, 2.17402041e-01f,
  -1.80517390e-01f, 2.22652406e-01f, 7.50488490e-02f, -1.34459538e-02f, 1.18193574e-01f, 2.08508253e-01f, 2.96867579e-01f, -1.76949710e-01f, 2.19682828e-01f, 2.37670932e-02f,
  -2.39878431e-01f, -2.78336793e-01f, 2.48373359e-01f, 1.30047366e-01f, 8.98219049e-02f, -1.69208080e-01f, -4.39933129e-02f, 1.03035428e-01f, 9.21787620e-02f, -8.73450339e-02f,
  -7.67800957e-02f, 8.52837265e-02f, -1.61193404e-02f, -4.56473790e-03f, -1.13152198e-01f, -4.01416183e-01f, 5.62243648e-02f, 9.77190137e-02f, 1.65538311e-01f, 6.65804297e-02f,
  8.45909640e-02f, 2.32873082e-01f, -2.45265096e-01f, -2.53906678e-02f, 1.42440706e-01f, -1.56338871e-01f, 1.83016241e-01f, 7.45283812e-02f, -1.04015328e-01f, -7.46786371e-02f,
  8.39374363e-02f, -1.60354808e-01f, 3.02556217e-01f, -1.69747453e-02f, 2.27041081e-01f, -6.10623956e-02f, 1.08013060e-02f, 1.11807786e-01f, 9.70676988e-02f, 2.72678465e-01f,
  -8.68212134e-02f, -9.30544510e-02f, 9.15330648e-02f, 1.60211474e-01f, 9.51020718e-02f, 1.64651543e-01f, 1.01107895e-01f, 1.30628958e-01f, -3.98491919e-02f, 3.11040506e-02f,
  1.56991944e-01f, 6.91533461e-02f, -6.24063425e-03f, -4.15159985e-02f, 1.61476523e-01f, 6.86959550e-02f, 3.50000054e-01f, -1.06963091e-01f, -1.84728965e-01f, 5.01702465e-02f,
  2.25059658e-01f, 3.34630758e-02f, 9.25617963e-02f, -1.83664873e-01f, 1.34779677e-01f, -1.17869772e-01f, 2.53732651e-01f, 7.60690793e-02f, -1.21145830e-01f, -3.83523083e-03f,
  -1.41827404e-01f, -7.45982379e-02f, -1.57690480e-01f, 2.36809120e-01f, -2.83747967e-02f, 7.38848820e-02f, 1.43874630e-01f, 2.43264437e-01f, 2.70290542e-02f, -4.11620270e-03f,
  1.12683520e-01f, 1.39276788e-01f, 3.24132740e-01f, 3.79291713e-01f, 2.22175062e-01f, -3.79170477e-02f, 5.85802384e-02f, -1.74904123e-01f, 8.18407685e-02f, -1.91586390e-01f,
  -6.40063137e-02f, -2.28957027e-01f, 1.14079483e-01f, 2.60531247e-01f, -2.09216196e-02f, 1.33598998e-01f, 6.71121804e-03f, -3.66698653e-02f, -3.03432457e-02f, 2.51605868e-01f,
  7.18966052e-02f, 9.95931700e-02f, -3.43854934e-01f, 1.97822243e-01f, 3.76563221e-01f, 9.24666896e-02f, 1.21596746e-01f, -1.78748257e-02f, -4.30294126e-02f, 6.96357116e-02f,
  -7.91021958e-02f, -3.88929881e-02f, -7.14568347e-02f, 4.53410968e-02f, 6.09033927e-02f, 9.91298165e-03f, -1.06021948e-01f, 6.83130026e-02f, -6.52471259e-02f, -1.11004338e-01f,
  -3.51528764e-01f, -1.25783995e-01f, 7.57760555e-02f, 5.93337789e-02f, -2.54151344e-01f, -2.00839058e-01f, -2.25446761e-01f, -1.26790360e-01f, -3.09568737e-02f, 8.16865452e-03f,
  -1.14522509e-01f, 5.57293594e-02f, 2.62872726e-01f, -2.53626355e-03f, -2.10506663e-01f, 1.07504480e-01f, 1.72836721e-01f, 6.95888698e-02f, 3.08628470e-01f, 7.55167305e-02f,
  -1.60655633e-01f, 7.77304918e-02f, 2.17631608e-01f, 2.52812028e-01f, -4.77907546e-02f, 2.52790391e-01f, -1.49714589e-01f, -2.91992873e-01f, 1.99502215e-01f, 1.77039877e-01f,
  1.43835083e-01f, 3.25584233e-01f, -2.70854563e-01f, 4.34457690e-01f, 2.46793821e-01f, 2.02568948e-01f, -2.81244725e-01f, 3.17348182e-01f, 9.79681835e-02f, 2.32512012e-01f,
  1.87063694e-01f, 4.65509631e-02f, 1.90157592e-01f, -1.72081485e-01f, -1.47446156e-01f, 8.04429054e-02f, 2.79561311e-01f, 5.29461121e-03f, -1.11572906e-01f, 1.47989988e-01f,
  4.88452613e-02f, -3.96053307e-02f, 1.32497072e-01f, 1.76037531e-02f, 1.87747478e-01f, 1.02324069e-01f, 2.27534413e-01f, 3.13519873e-02f, -1.45017002e-02f, 1.06115408e-01f,
  7.46751428e-02f, 5.96466288e-03f, -3.32120061e-01f, 6.44392595e-02f, -1.48130596e-01f, -1.34918943e-01f, 8.97370949e-02f, 2.74527580e-01f, -1.19247576e-02f, -1.64004952e-01f,
  1.20695435e-01f, 2.24390462e-01f, -4.16192442e-01f, -1.36604309e-01f, 2.40045324e-01f, 3.03608894e-01f, 9.54051539e-02f, 8.62947032e-02f, 2.35324249e-01f, -2.57935852e-01f,
  2.14435726e-01f, 2.36328371e-04f, -1.14993118e-01f, -1.65916219e-01f, 2.68698752e-01f, 1.69850364e-01f, -6.88110143e-02f, 1.35494664e-01f, 2.41433382e-01f, 1.20201953e-01f,
  6.86415359e-02f, -1.16684544e-03f, -7.42113963e-03f, 1.36274502e-01f, -2.35983983e-01f, 9.52358767e-02f, 2.03431204e-01f, -8.46947804e-02f, -1.92470387e-01f, 5.58361597e-02f,
  -8.34840164e-02f, -6.22695312e-02f, 2.23973781e-01f, 3.21374625e-01f, -5.87993860e-02f, 2.71860123e-01f, 2.97654659e-01f, 4.01312038e-02f, 2.34702826e-01f, 6.26272559e-02f,
  3.37059088e-02f, 5.75774834e-02f, -2.22421810e-01f, 2.74536684e-02f, 8.75980034e-02f, 2.06672683e-01f, 1.65827155e-01f, 1.32006705e-01f, 3.03800479e-02f, 2.28072897e-01f,
  1.40394539e-01f, 1.18252933e-01f, 6.27533719e-02f, 1.58204734e-01f, 9.18708220e-02f, 1.61841169e-01f, -5.53374663e-02f, 5.72738089e-02f, 1.69649050e-01f, -1.66586906e-01f,
  -1.73967391e-01f, 1.65365890e-01f, 4.34674695e-02f, 1.06541306e-01f, 2.34079376e-01f, 2.99668789e-01f, 4.37032729e-02f, -1.44456565e-01f, 3.13177258e-01f, 1.28436372e-01f,
  -2.75394112e-01f, 3.17304015e-01f, -8.86707660e-03f, -1.18184373e-01f, 2.95604378e-01f, 1.68156222e-01f, -3.19750100e-01f, -8.09062347e-02f, 3.98715436e-01f, 1.85246721e-01f,
  -2.92243268e-02f, -2.02415846e-02f, 2.48121411e-01f, 7.99856056e-03f, 2.03726321e-01f, 1.80663571e-01f, 2.24979535e-01f, 3.24179709e-01f, 1.67257503e-01f, -2.59508491e-01f,
  1.50476815e-02f, -1.57043591e-01f, -2.26404205e-01f, -1.04006641e-01f, 2.11734638e-01f, 1.01570852e-01f, 7.63914501e-03f, 9.22229066e-02f, -2.92469382e-01f, 1.81346342e-01f,
  3.45223755e-01f, 2.40515888e-01f, 1.75569609e-01f, 7.73024112e-02f, -1.05136551e-01f, 3.14326823e-01f, 3.06943774e-01f, 1.07524898e-02f, 1.44573420e-01f, 1.19025283e-01f,
  1.43790990e-01f, 2.81437933e-01f, -2.29831729e-02f, 1.81232288e-01f, 3.64110209e-02f, 6.41660020e-02f, 1.64534107e-01f, -7.12477639e-02f, 2.09648430e-01f, 1.02811567e-01f,
  9.00835395e-02f, -1.36664420e-01f, 9.90142301e-02f, -4.64868136e-02f, -2.31948897e-01f, -1.27124906e-01f, -3.87807004e-02f, 4.27122712e-02f, 1.10864788e-01f, -1.13616347e-01f,
  2.01504737e-01f, -1.04159914e-01f, 3.10535491e-01f, -8.14928785e-02f, -4.60704453e-02f, 2.50687569e-01f, -1.30270451e-01f, -5.90253547e-02f, -2.73878992e-01f, 3.60634059e-01f,
  9.18740779e-02f, 5.24968840e-03f, 6.95722848e-02f, 3.58263314e-01f, 1.77463010e-01f, 3.24327081e-01f, 1.29245535e-01f, 2.89002568e-01f, 1.32909015e-01f, 2.34620139e-01f,
  2.48179182e-01f, 3.17617543e-02f, 8.50858614e-02f, -1.64314464e-01f, -7.67494813e-02f, 1.74468219e-01f, -1.36084363e-01f, -7.61532784e-02f, 6.75832033e-02f, 3.93202901e-01f,
  -1.61049411e-01f, 1.14729777e-01f, -1.78719550e-01f, 1.49247631e-01f, -8.18350762e-02f, 1.60745069e-01f, 7.41383154e-03f, 9.65638459e-02f, -3.37158561e-01f, 1.35736629e-01f,
  3.07996929e-01f, 1.33895665e-01f, 1.03083082e-01f, -2.52812430e-02f, 1.66259989e-01f, 1.34849042e-01f, 7.75925070e-02f, -4.03216779e-02f, -7.79218748e-02f, 2.24905103e-01f,
  2.64863912e-02f, 1.28198877e-01f, 8.35420787e-02f, 3.72201647e-03f, -3.29989642e-02f, 3.72852385e-02f, -1.82030633e-01f, -2.42563318e-02f, 1.52395010e-01f, 1.32713795e-01f,
  -1.31338432e-01f, -9.87934917e-02f, 1.11295231e-01f, 2.97220647e-01f, 4.50647026e-02f, -1.87776208e-01f, 1.42216697e-01f, 1.72813594e-01f, -7.04697371e-02f, 3.14336777e-01f,
  4.15924378e-02f, -5.17011136e-02f, 1.87366098e-01f, 5.96784092e-02f, -1.26394317e-01f, -2.49469459e-01f, 5.82729727e-02f, 1.92663610e-01f, -2.33536214e-01f, 1.76529244e-01f,
  1.71798617e-01f, 8.07575285e-02f, 1.31971552e-03f, 9.95664001e-02f, 2.85565197e-01f, 2.23334938e-01f, -1.34335726e-01f, -1.99784175e-01f, 1.15271963e-01f, -2.24454552e-01f,
  -2.27186486e-01f, -6.15391433e-02f, 1.25115693e-01f, -1.91740230e-01f, 2.89235175e-01f, 1.28836527e-01f, -2.11557806e-01f, 1.79176793e-01f, 2.47275859e-01f, 3.32111157e-02f,
  6.94114566e-02f, -1.48179919e-01f, 1.56368464e-01f, 5.53556681e-02f, -6.73453882e-02f, -1.90288812e-01f, -5.29632792e-02f, 8.78458619e-02f, 1.92548305e-01f, 9.33126137e-02f,
  2.21706957e-01f, -3.97937931e-02f, 1.25531062e-01f, -1.23441614e-01f, 7.88007900e-02f, 2.93929763e-02f, -2.13860180e-02f, -1.05650678e-01f, 9.12265182e-02f, 2.68189460e-01f,
  1.66724682e-01f, -3.08805890e-02f, -1.56671584e-01f, 1.26003802e-01f, 1.39002591e-01f, 1.93406665e-03f, 2.86845624e-01f, -3.55791003e-02f, 3.56252566e-02f, 2.20555346e-02f,
  2.32123837e-01f, 2.26435363e-01f, -5.62313106e-03f, -8.73630270e-02f, -1.34859368e-01f, 2.67945409e-01f, -1.50686562e-01f, 1.09324798e-01f, 2.42050454e-01f, 1.79610759e-01f,
  1.63124964e-01f, 7.02228323e-02f, -6.38023913e-02f, -1.01799712e-01f, 3.61187607e-02f, 3.13600935e-02f, 1.59175709e-01f, 3.97045374e-01f, 1.16963565e-01f, -1.70952871e-01f,
  1.74147621e-01f, 1.29045099e-02f, -1.86237935e-02f, -1.55027047e-01f, 1.41704664e-01f, 4.45784405e-02f, 1.26003906e-01f, 2.92920438e-03f, -1.09778158e-01f, 2.25903448e-02f,
  3.34724225e-02f, -3.24703604e-02f, -3.21259871e-02f, 3.07870418e-01f, 9.13823992e-02f, 3.25544268e-01f, -3.78392905e-01f, 1.99302644e-01f, 3.34284335e-01f, 2.53814738e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 40)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 40;
const float L2_fan_Bp_bar_data[] = {
  1.08271256e-01f, 5.77110052e-02f, 4.68039215e-02f, -6.06948771e-02f, 5.26558124e-02f, 7.29671791e-02f, 4.97875251e-02f, -2.32499614e-02f, -1.78995840e-02f, 1.09344520e-01f,
  7.16615692e-02f, -2.65963804e-02f, -3.75876874e-02f, 5.07192388e-02f, 1.07641816e-01f, 1.51760988e-02f, 5.10163940e-02f, 1.35583043e-01f, 4.59157154e-02f, 2.42196053e-04f,
  -3.41100506e-02f, -1.69225801e-02f, 1.41150221e-01f, 2.83664837e-02f, 4.85894494e-02f, 1.12009950e-01f, 7.81025738e-02f, 6.69445843e-02f, 5.08734845e-02f, -3.08610760e-02f,
  9.01926458e-02f, 7.67787993e-02f, 8.43327194e-02f, -4.45347242e-02f, 9.65158343e-02f, -2.70031095e-02f, 2.39657350e-02f, -1.85917392e-02f, 1.39792532e-01f, 3.66223380e-02f
};

// L3_linear_W (Shape: 12 x 64)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 64;
const float L3_linear_W_data[] = {
  7.49464929e-02f, -4.54116166e-02f, 1.35982633e-01f, -9.56580192e-02f, 1.41707346e-01f, -5.22349924e-02f, 1.34396464e-01f, -1.49617335e-02f, -1.09091885e-02f, -8.47871229e-02f,
  9.13605317e-02f, -2.72156876e-02f, 4.54354426e-03f, -1.60364732e-01f, -1.41280472e-01f, 1.46919280e-01f, 1.45000502e-01f, -1.82252944e-01f, -9.52637643e-02f, 9.08293761e-03f,
  -2.12258562e-01f, 1.36961462e-02f, 1.90503001e-02f, -8.89077485e-02f, -1.92235991e-01f, -3.45304132e-01f, 7.86394402e-02f, 5.95388599e-02f, -5.79440780e-02f, 2.85732985e-01f,
  -1.96294367e-01f, -5.29754795e-02f, 2.44884994e-02f, -2.34174699e-01f, -4.15626615e-01f, -2.64955521e-01f, -3.89284641e-01f, 1.20315433e-01f, -1.91946968e-01f, -1.64278448e-01f,
  5.31643331e-02f, 1.24902591e-01f, 6.94604516e-02f, 2.49163836e-01f, 1.28442720e-01f, -3.34661424e-01f, 1.65172517e-01f, 1.05291992e-01f, -1.32128462e-01f, -2.95390218e-01f,
  -1.17864229e-01f, 1.27787918e-01f, -2.42817149e-01f, -3.65039051e-01f, -1.04292020e-01f, 1.31995469e-01f, 2.33838353e-02f, 2.31153607e-01f, -4.21656728e-01f, -1.67495146e-01f,
  2.62861371e-01f, 2.07433343e-01f, -7.82953277e-02f, 1.61553875e-01f, -8.65632445e-02f, -1.92988053e-04f, -1.02489501e-01f, 2.04318240e-01f, 1.12899013e-01f, -1.47915900e-01f,
  -1.15496367e-01f, -9.81797725e-02f, -1.63562782e-02f, -2.94527989e-02f, -1.87374763e-02f, -5.36132269e-02f, -8.90032426e-02f, -2.26306632e-01f, 1.34961486e-01f, 1.18062682e-01f,
  -8.57098401e-02f, -2.72624314e-01f, 1.32271364e-01f, -6.22789748e-02f, 7.48044848e-02f, -3.03330749e-01f, 7.38020167e-02f, -2.51747459e-01f, -1.65421784e-01f, -1.40751116e-02f,
  1.77345693e-01f, 1.77155316e-01f, -2.50703663e-01f, -6.86563030e-02f, 8.73398110e-02f, -1.38487130e-01f, -2.10395545e-01f, -1.82083741e-01f, -1.21220998e-01f, -2.19059065e-02f,
  1.70169160e-01f, -7.14190006e-02f, 9.14418250e-02f, -3.74637216e-01f, -4.25225139e-01f, -2.09659025e-01f, 1.31302953e-01f, -2.56002277e-01f, -3.36892754e-01f, 6.35828674e-02f,
  1.43074289e-01f, 4.88136038e-02f, -2.37292558e-01f, -3.50681394e-01f, 1.95847694e-02f, -1.51265234e-01f, 1.92039073e-01f, -3.63963157e-01f, -9.29050893e-02f, 1.55334249e-01f,
  1.54133424e-01f, 1.33866519e-01f, -4.85592723e-01f, 2.06877008e-01f, 2.38011330e-01f, 1.33776188e-01f, 2.05852255e-01f, 4.75960672e-02f, -1.64898336e-01f, -7.78402984e-02f,
  1.30510971e-01f, 5.05325533e-02f, -2.16510668e-02f, -8.82758051e-02f, -7.68718645e-02f, 1.45850107e-01f, -7.40152076e-02f, -5.30188270e-02f, -1.97581708e-01f, -4.39448208e-02f,
  4.38467003e-02f, -5.50059415e-02f, -1.58469468e-01f, -1.16233334e-01f, 9.17748064e-02f, 7.65270442e-02f, 1.01596810e-01f, -1.46243408e-01f, 2.49678314e-01f, -2.24569112e-01f,
  4.86184210e-02f, 2.17431039e-01f, 2.35056356e-01f, 1.68210685e-01f, 1.17558949e-01f, 4.77267541e-02f, -3.11683923e-01f, -2.92098373e-01f, -3.47294569e-01f, -3.43683094e-01f,
  -2.91972011e-01f, 1.85568407e-01f, 1.82322875e-01f, -3.08543652e-01f, -2.29623988e-01f, -1.26153246e-01f, 1.15964435e-01f, -3.25700045e-01f, -3.82623881e-01f, 1.06421702e-01f,
  -1.96544692e-01f, -1.53315157e-01f, -6.77366853e-02f, 2.05746427e-01f, -1.89128488e-01f, -1.50375530e-01f, 2.59224504e-01f, 1.42976776e-01f, 8.13737810e-02f, -1.28685892e-01f,
  3.89093049e-02f, -5.60272448e-02f, 2.32052412e-02f, 1.44498244e-01f, -3.33220243e-01f, -8.31230655e-02f, 4.53591682e-02f, 1.54207140e-01f, 1.51330560e-01f, -6.11566417e-02f,
  4.31532152e-02f, -2.88655251e-01f, -1.77605659e-01f, -1.08153060e-01f, 1.13593616e-01f, -2.00228900e-01f, 6.79887682e-02f, -9.98040512e-02f, 3.69753838e-02f, 1.43741727e-01f,
  -6.48570955e-02f, 1.11463122e-01f, 4.78185937e-02f, -9.69198812e-03f, 2.31714174e-01f, 1.79322675e-01f, -5.99116683e-02f, 1.03358991e-01f, 2.98488438e-01f, -2.25102082e-01f,
  -2.73266792e-01f, 6.30132407e-02f, -1.46889672e-01f, 7.28706196e-02f, -1.33637473e-01f, -2.57510543e-01f, 1.86579436e-01f, -4.46561992e-01f, -2.14550436e-01f, -2.39250913e-01f,
  3.22442710e-01f, 1.14502542e-01f, -1.61301747e-01f, 9.27473009e-02f, 6.97568506e-02f, 1.86316475e-01f, 1.65205687e-01f, -1.74258754e-01f, -1.55468389e-01f, 1.07921392e-01f,
  -3.71372432e-01f, 2.34217152e-01f, 1.76103309e-01f, 9.12764147e-02f, 1.71307981e-01f, -5.15227718e-03f, -1.40482396e-01f, 8.48584399e-02f, 2.65327334e-01f, -2.14689717e-01f,
  -9.56529900e-02f, -1.45869240e-01f, -4.14175242e-01f, -2.09012657e-01f, 5.38439378e-02f, -2.67090410e-01f, 8.37431923e-02f, -4.69909698e-01f, -1.76769137e-01f, -7.23580047e-02f,
  -1.38553008e-01f, -3.59909415e-01f, -3.98933053e-01f, -4.45776314e-01f, -4.19698477e-01f, 1.41231343e-01f, 1.68184683e-01f, -5.30128852e-02f, 6.94387928e-02f, -4.23546955e-02f,
  1.51088744e-01f, 1.37514412e-01f, 5.93342297e-02f, 1.37677968e-01f, 7.50728920e-02f, -3.47636789e-02f, -8.97723809e-02f, -6.69886619e-02f, -8.02245662e-02f, 1.29087701e-01f,
  -1.29624471e-01f, 2.72206306e-01f, -1.81361213e-01f, 3.40257555e-01f, 2.04140007e-01f, -1.43146947e-01f, -2.53238440e-01f, 2.21285805e-01f, -1.47941470e-01f, -1.67908549e-01f,
  -7.03827366e-02f, -4.79544811e-02f, -9.73394364e-02f, -2.38807455e-01f, 9.06315818e-02f, -1.02801017e-01f, -2.27713406e-01f, 5.29790446e-02f, 1.86028838e-01f, 1.94508553e-01f,
  1.41060412e-01f, -1.17975630e-01f, -2.17234716e-02f, -1.50598995e-02f, -1.19071722e-01f, 1.61869064e-01f, 1.84954882e-01f, 1.09177738e-01f, 6.97482750e-03f, 6.56884611e-02f,
  1.67736918e-01f, 1.00817442e-01f, 8.38640630e-02f, 1.51140511e-01f, -1.42486840e-01f, 1.78246245e-01f, 1.75130069e-01f, 1.88348830e-01f, -3.73986214e-01f, 1.03836937e-03f,
  -7.06119984e-02f, -2.16594920e-01f, -1.14028923e-01f, 3.53764668e-02f, -6.83090009e-04f, -1.49368778e-01f, -7.13368803e-02f, 8.81946757e-02f, -2.04798151e-02f, 3.52446884e-02f,
  8.24851245e-02f, -1.57746896e-01f, 5.20135313e-02f, 1.03820734e-01f, -1.76137999e-01f, 7.03094155e-02f, -1.86120551e-02f, 1.63733095e-01f, 5.63511066e-02f, -9.75645483e-02f,
  3.93804200e-02f, 1.22620568e-01f, -5.39039373e-02f, -2.11304933e-01f, 2.04576284e-01f, -4.28412072e-02f, 1.40346780e-01f, 1.95931613e-01f, -1.85855608e-02f, -1.08598128e-01f,
  2.42157355e-01f, 1.68753967e-01f, -2.06241295e-01f, 9.90005136e-02f, -2.00438648e-01f, 6.57324418e-02f, -2.47732550e-01f, 1.06642708e-01f, -4.35776979e-01f, -2.43356869e-01f,
  -1.93348721e-01f, 3.59407067e-02f, 1.67269632e-01f, -2.39442900e-01f, -1.75579250e-01f, 1.81998268e-01f, -4.40873429e-02f, 6.73490390e-02f, 9.59071890e-02f, 1.37709202e-02f,
  1.09024495e-02f, -2.50270903e-01f, 1.15132265e-01f, 1.08647980e-01f, -3.35616581e-02f, -4.91535753e-01f, -1.83013231e-01f, -1.84596032e-02f, -8.34765881e-02f, -2.77873501e-02f,
  1.10675335e-01f, 8.40923935e-02f, -1.08333603e-02f, 2.42091373e-01f, -2.54568458e-01f, 1.87448591e-01f, 4.74623516e-02f, 1.90216735e-01f, -8.60432014e-02f, 1.20086119e-01f,
  6.07714169e-02f, 1.10226631e-01f, -8.83571580e-02f, 1.96992829e-01f, -8.13776702e-02f, -1.84394687e-03f, -8.67222920e-02f, -1.65758029e-01f, 1.57657847e-01f, -2.74905097e-02f,
  -5.39170392e-02f, -1.82888240e-01f, -2.35376537e-01f, 1.03855453e-01f, 4.36070561e-02f, -6.92038983e-02f, 7.35533684e-02f, 1.24738619e-01f, 1.99932575e-01f, 1.93159685e-01f,
  4.70557660e-02f, -4.31024879e-02f, -9.15953517e-03f, 1.98492050e-01f, 1.13777108e-01f, -1.04198735e-02f, -4.25852090e-02f, 8.12807903e-02f, -6.54003303e-03f, 1.83000937e-01f,
  -3.23719203e-01f, 6.42405003e-02f, -1.04174830e-01f, 5.61221056e-02f, 2.22192854e-01f, -9.43513289e-02f, 5.97995445e-02f, 1.31257087e-01f, 1.78345785e-01f, 1.92548379e-01f,
  5.78504391e-02f, -2.78654009e-01f, 1.59635291e-01f, -2.61287987e-01f, -2.15466052e-01f, -9.43357125e-02f, -2.06046656e-01f, -3.67629558e-01f, -3.29447865e-01f, 2.66728085e-02f,
  -1.44253924e-01f, -1.87012237e-02f, 8.28411505e-02f, 1.78582042e-01f, 1.18926249e-01f, 7.27724284e-02f, 1.05340242e-01f, 3.75126973e-02f, 4.26040739e-02f, 1.22222967e-01f,
  -3.30412686e-01f, -3.53116170e-02f, 1.40541852e-01f, 9.28052217e-02f, -2.15775609e-01f, 8.22164938e-02f, -2.54811287e-01f, -1.34094566e-01f, 6.33840710e-02f, -1.01715378e-01f,
  6.10053018e-02f, -9.13105384e-02f, 5.67049608e-02f, 3.25142359e-03f, 8.41415748e-02f, -5.33397822e-03f, -2.77272109e-02f, -1.05037652e-01f, -1.79002121e-01f, 1.85281094e-02f,
  -1.96297526e-01f, -2.13974953e-01f, 1.99219868e-01f, -7.77767971e-02f, -5.97984577e-03f, -2.34945893e-01f, -2.03197330e-01f, 1.67976514e-01f, 2.33807802e-01f, 1.41014263e-01f,
  -3.77539210e-02f, -1.15410119e-01f, -1.51757419e-01f, -2.28177920e-01f, -2.86234409e-01f, -4.70909961e-02f, -6.19696714e-02f, 3.10155034e-01f, 2.64013559e-01f, 1.89729407e-01f,
  -9.51771736e-02f, 6.41740635e-02f, -6.91444473e-03f, 2.25625783e-01f, 2.68094957e-01f, 1.14329681e-02f, -1.80095062e-01f, 1.02270134e-01f, 1.55890062e-01f, -3.19775432e-01f,
  1.56107157e-01f, 6.60494342e-02f, 8.02945495e-02f, -2.57372260e-01f, 4.26564813e-02f, -3.74896675e-01f, -1.11066118e-01f, -1.60127774e-01f, -2.44763523e-01f, 9.06064957e-02f,
  -5.01796268e-02f, 2.56960005e-01f, -3.10312569e-01f, -2.55251080e-01f, 2.72965372e-01f, 4.31170464e-02f, -1.65565744e-01f, -2.71343403e-02f, -1.86633587e-01f, -2.76677221e-01f,
  -2.25822300e-01f, 1.83878452e-01f, 8.78624171e-02f, -2.65193358e-02f, -1.36790112e-01f, 3.21708843e-02f, -3.91776534e-03f, 1.28778309e-01f, 8.13095570e-02f, -5.24595156e-02f,
  -6.32670149e-02f, -4.52862009e-02f, 4.91636358e-02f, 1.72454283e-01f, 2.05689222e-01f, 2.42055252e-01f, -1.95536256e-01f, -6.70920834e-02f, -1.84946582e-01f, 8.39605182e-02f,
  -1.92201078e-01f, -1.65501893e-01f, -1.36350274e-01f, 1.70701921e-01f, 1.01393022e-01f, -3.75091657e-02f, -2.82479554e-01f, 8.59272629e-02f, 1.54254496e-01f, 1.93687364e-01f,
  4.82899286e-02f, 3.16814303e-01f, -3.52792069e-02f, -4.95498031e-02f, -1.82054833e-01f, -2.54860371e-01f, -1.83498561e-01f, -1.80407181e-01f, -8.92877504e-02f, -1.68411791e-01f,
  2.34868214e-01f, -1.46251962e-01f, -3.61564718e-02f, -2.08636507e-01f, -2.39260375e-01f, 2.82690972e-01f, 1.73313706e-03f, -4.05690819e-02f, -8.87265950e-02f, -1.58979103e-01f,
  2.48270676e-01f, -2.53341526e-01f, -3.15461367e-01f, -2.12419286e-01f, -7.12428987e-02f, -3.36057618e-02f, -1.12555578e-01f, 2.00781509e-01f, 1.71342507e-01f, -3.22404742e-01f,
  2.44987518e-01f, 1.76273882e-01f, 6.50987476e-02f, -3.18651557e-01f, 1.57062933e-01f, -2.45662794e-01f, -7.11643323e-02f, -2.56958641e-02f, 2.05262274e-01f, 8.60962868e-02f,
  -2.83605568e-02f, 2.69884355e-02f, -1.52930528e-01f, -8.01916271e-02f, 8.23140964e-02f, 3.70212109e-03f, 1.45602018e-01f, -2.29099076e-02f, -1.93691980e-02f, -1.90510824e-01f,
  1.51943676e-02f, -2.36674964e-01f, -1.03940807e-01f, 1.28766373e-01f, 2.87393983e-02f, 1.47774473e-01f, 1.45062536e-01f, 1.91313788e-01f, 2.23454803e-01f, 2.09245861e-01f,
  -2.33415157e-01f, 1.03379555e-01f, -1.32017374e-01f, -7.40477368e-02f, -4.31046516e-01f, 1.36778021e-04f, 1.04236491e-01f, 1.66363403e-01f, 1.37988091e-01f, 1.80244982e-01f,
  -5.26288822e-02f, 7.94239528e-03f, -3.05767059e-01f, -2.51175374e-01f, -2.55151182e-01f, 8.02543461e-02f, -2.11428314e-01f, 1.32386401e-01f, -3.45539182e-01f, 2.44248867e-01f,
  2.95766026e-01f, 2.60537211e-02f, -4.50215250e-01f, -2.96103060e-01f, 1.25414357e-01f, 2.33380333e-01f, -1.55100133e-02f, 2.48209476e-01f, -2.78112143e-01f, 5.97069189e-02f,
  1.10648058e-01f, 6.01762421e-02f, -1.93944365e-01f, 8.27212483e-02f, 9.59723517e-02f, -2.56120890e-01f, -5.02618700e-02f, 2.15300247e-01f, -1.41211599e-01f, -1.48204803e-01f,
  -1.08098730e-01f, -5.55481315e-02f, 6.58627078e-02f, 8.11455175e-02f, 1.93422079e-01f, -3.38468589e-02f, -1.19016292e-02f, -9.00897086e-02f, -6.85729552e-04f, -4.90956865e-02f,
  1.12633267e-03f, 2.65053683e-03f, 2.16722593e-01f, 6.74395710e-02f, -1.32474810e-01f, 2.20578879e-01f, -1.84439823e-01f, -3.16875309e-01f, 2.71189570e-01f, -5.37633300e-02f,
  -9.92113799e-02f, -1.87874854e-01f, 2.64239199e-02f, 1.20353125e-01f, 3.68690640e-02f, -1.30077332e-01f, 3.05825442e-01f, -2.64409274e-01f, 1.18635282e-01f, -1.66255936e-01f,
  -6.64825141e-02f, -2.76137829e-01f, -1.88416854e-01f, -2.89501518e-01f, 1.69749454e-01f, -7.89178163e-02f, 1.38873488e-01f, 1.94527507e-01f, 1.25638828e-01f, -4.44829278e-02f,
  1.86433777e-01f, 7.78217381e-03f, 1.92417547e-01f, -1.35584533e-01f, -1.61024854e-01f, 2.83509374e-01f, 1.23465054e-01f, 1.33670434e-01f, -2.58282304e-01f, -2.75085471e-03f,
  -2.09260717e-01f, -2.73497343e-01f, -3.13384123e-02f, -2.84510314e-01f, 2.51757234e-01f, -5.87439202e-02f, 1.04047684e-02f, -1.53983146e-01f, -3.32738876e-01f, 3.52730975e-02f,
  1.43007236e-02f, -3.61272842e-01f, 6.52533993e-02f, -2.70960301e-01f, -5.51625192e-02f, 7.55293965e-02f, 1.99154280e-02f, -8.02421197e-02f, 3.55247706e-02f, -1.19665988e-01f,
  1.04174726e-02f, 6.03859648e-02f, 4.18176539e-02f, 8.97764862e-02f, -1.37633279e-01f, 6.53626025e-02f, 4.53521982e-02f, 1.65931950e-03f, 6.24919310e-03f, -8.54741931e-02f,
  -3.29964496e-02f, 2.38323167e-01f, 1.25579253e-01f, -8.24757814e-02f, -2.64718477e-02f, -1.35137178e-02f, -1.16086461e-01f, 2.69496948e-01f, 2.52345026e-01f, -2.01499648e-02f,
  1.55393288e-01f, -3.80758703e-01f, -3.56601238e-01f, -1.63657680e-01f, 1.73876688e-01f, -1.89273149e-01f, 2.83519784e-03f, -1.03730544e-01f, 1.01392299e-01f, 1.84440479e-01f,
  2.83291221e-01f, 1.19277880e-01f, 1.76593676e-01f, 2.29781449e-01f, 1.26835287e-01f, -1.38389063e-03f, -2.97755152e-02f, -9.05769542e-02f, 6.70280168e-03f, -1.73875913e-01f,
  -4.46131118e-02f, 1.74109206e-01f, -9.07013938e-02f, 2.83100456e-02f, 2.59303987e-01f, -2.64158845e-01f, -3.96715365e-02f, 1.02405943e-01f, -9.63232890e-02f, 1.23654976e-01f,
  3.00294548e-01f, -1.28752530e-01f, 7.57911950e-02f, -7.81921372e-02f, -2.82754660e-01f, -2.10375845e-01f, -2.66770542e-01f, -2.04924554e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  6.31119311e-02f, -9.42274705e-02f, -9.52690169e-02f, 7.58915320e-02f, -9.78968590e-02f, 3.08282655e-02f, -1.05668902e-01f, 2.60374993e-02f, 1.31828323e-01f, 1.02244560e-02f,
  1.26513913e-01f, -2.54458226e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 40
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        64, 12, 40
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        64, 12
    );
    }
    