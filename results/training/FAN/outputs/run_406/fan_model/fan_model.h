/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    return (x > 0.0f) ? x : 0.0f;
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.34900391e-01f, 1.03004873e-01f, -3.90411794e-01f, -3.54832150e-02f, -6.80191144e-02f, 1.23226695e-01f, 2.08181605e-01f, -1.77780539e-01f, 6.83056414e-02f, 1.00958236e-01f,
  -4.87289624e-03f, -2.88497843e-03f, 2.01493353e-02f, 2.69990385e-01f, 7.11021051e-02f, 1.06050372e-01f, -5.02967574e-02f, 2.95063872e-02f, 5.31312972e-02f, -1.51787326e-01f,
  -5.55375405e-02f, 1.53784335e-01f, -7.79813305e-02f, 6.48420453e-02f, -8.93709660e-02f, -1.13383293e-01f, -1.65883467e-01f, -3.32797281e-02f, -7.19310716e-02f, 3.84778194e-02f,
  2.32733674e-02f, -1.73116595e-01f, -2.87185446e-03f, -6.27761334e-02f, -1.16830647e-01f, -8.07701051e-02f, -1.18355583e-02f, 3.91165353e-03f, 4.23045196e-02f, 2.24275887e-02f,
  6.14331998e-02f, 8.10927004e-02f, 4.18453813e-02f, 1.92325078e-02f, -2.12232862e-02f, 3.63559015e-02f, 2.71962751e-02f, 5.23546189e-02f, 1.87063869e-02f, 9.44475681e-02f,
  -1.16179772e-02f, -6.04794966e-03f, -1.94266420e-02f, -1.90474223e-02f, -1.02251265e-02f, 3.94097492e-02f, 6.98175654e-03f, -2.69089099e-02f, -5.43415807e-02f, 2.53816857e-03f,
  -5.97472414e-02f, -3.86140682e-02f, 3.33140679e-02f, 2.76334845e-02f, -2.10741386e-02f, -5.27513586e-02f, 5.65618798e-02f, -2.49662530e-02f, -3.92362997e-02f, -3.83271128e-02f,
  2.68590786e-02f, -4.94482405e-02f, -1.39430361e-02f, 6.16764557e-03f, 1.70673579e-02f, -1.86998323e-02f, -2.55743396e-02f, 9.35599674e-03f, -1.35677191e-03f, -2.01418027e-02f,
  1.75540359e-03f, -1.10377334e-02f, 1.18347649e-02f, -4.84187715e-02f, 8.96220841e-03f, -1.77617744e-02f, -3.81614943e-03f, -3.83154526e-02f, -1.17176818e-02f, -4.99974862e-02f,
  2.87001152e-02f, -3.33254158e-01f, -2.79808864e-02f, -1.84032340e-02f, 9.51214507e-02f, 1.02844641e-01f, 4.79084775e-02f, -1.47133344e-03f, -2.08230643e-03f, -4.87412103e-02f,
  -3.42691764e-02f, -8.52101818e-02f, -1.21491939e-01f, 3.13283801e-02f, 1.24542760e-02f, -5.41579053e-02f, -3.45446728e-02f, -5.69115579e-02f, -6.89105764e-02f, -1.31516248e-01f,
  -3.62572782e-02f, -4.28404137e-02f, 3.53531763e-02f, -1.65755432e-02f, -6.05178922e-02f, -8.74034166e-02f, -3.81531641e-02f, -2.95403581e-02f, -4.08449676e-03f, -2.89583039e-02f,
  -4.81554091e-01f, 4.03789967e-01f, 3.91856313e-01f, 6.42888546e-02f, -4.35657293e-01f, -1.98919624e-01f, -7.63453171e-02f, 3.54347154e-02f, -1.18362196e-01f, 3.13467145e-01f,
  -9.48376134e-02f, 1.08047187e-01f, 6.28479794e-02f, 1.11192591e-01f, -4.80377346e-01f, 2.37778559e-01f, 7.57996142e-02f, 4.78302836e-02f, -5.40331285e-03f, 2.34370399e-02f,
  -6.64364100e-02f, -1.98259428e-01f, 1.49028093e-01f, -9.57979187e-02f, 2.18739677e-02f, 1.50769994e-01f, -2.86500920e-02f, 3.70525010e-02f, 6.07795008e-02f, -7.47690424e-02f,
  -3.11819091e-02f, 7.41372555e-02f, 4.19326611e-02f, 1.46061301e-01f, -2.95404950e-03f, 5.05123055e-03f, -4.19003190e-03f, 1.28907117e-03f, -1.10126011e-01f, 4.83246073e-02f,
  3.02986614e-03f, -2.48379987e-02f, -5.42740151e-02f, -3.63227184e-04f, -3.86667140e-02f, -8.01091194e-02f, -8.29223543e-02f, 9.41662118e-02f, -1.06502054e-02f, -4.52250913e-02f,
  -3.22277360e-02f, 6.82793930e-02f, 1.37065034e-02f, 9.47450101e-02f, 1.06895799e-02f, 9.62449703e-03f, 1.40581816e-01f, 3.71312769e-03f, 3.50698978e-02f, -1.67367794e-02f,
  4.58466914e-03f, 2.52266992e-02f, 2.30843350e-02f, -4.83181290e-02f, 1.98241863e-02f, -8.57799724e-02f, 9.58494842e-03f, -1.69619638e-02f, 2.37284210e-02f, -5.55406138e-03f,
  3.56272236e-02f, -1.05330320e-02f, 5.98646654e-03f, -4.21398599e-03f, -3.96377183e-02f, -2.47635506e-03f, 3.05342488e-02f, 1.14606991e-02f, 7.65027925e-02f, -4.35658060e-02f,
  2.79443264e-02f, -2.53071077e-02f, 2.80256886e-02f, 4.74522747e-02f, 4.43718862e-04f, 9.00441315e-03f, 1.24534359e-02f, 4.86785434e-02f, -1.17482599e-02f, -2.83760745e-02f,
  1.06360905e-01f, 2.21075580e-01f, 5.03107868e-02f, -1.07070565e-01f, 4.34989631e-02f, 1.79336704e-02f, 4.82628820e-03f, -7.83006474e-03f, 5.76509796e-02f, -6.67833760e-02f,
  1.49920071e-02f, 3.27312462e-02f, 1.08008362e-01f, -1.43858045e-02f, 4.77924086e-02f, 7.02866092e-02f, 1.36964858e-01f, -4.75065783e-02f, 3.81832905e-02f, 3.22087705e-02f,
  4.42550294e-02f, -5.56381494e-02f, -2.50688884e-02f, -5.18261008e-02f, -4.51570824e-02f, 1.92429014e-02f, -1.33434221e-01f, 6.63371235e-02f, -2.16074591e-03f, 5.00218011e-02f,
  5.82457304e-01f, 1.51322603e-01f, 3.84390742e-01f, 3.47548217e-01f, 1.11102602e-02f, -4.04832847e-02f, 9.46522355e-02f, 5.91019616e-02f, 2.76929528e-01f, -1.12849325e-01f,
  -9.07061771e-02f, 2.45010972e-01f, -9.21603963e-02f, 1.38149440e-01f, 3.32181454e-01f, -8.49659741e-02f, 1.00230046e-01f, 7.69116729e-02f, 5.65679222e-02f, 7.16966614e-02f,
  1.49276540e-01f, -6.32411689e-02f, 1.17106095e-01f, -5.49154319e-02f, -9.08209849e-03f, 1.03400730e-01f, -1.13901749e-01f, 1.71322450e-02f, -2.22986825e-02f, 3.39348130e-02f,
  6.23308420e-02f, 2.49605067e-02f, 3.72435227e-02f, -6.97713345e-02f, -1.96200814e-02f, -8.37954357e-02f, 9.00593936e-04f, -2.32492872e-02f, 9.59243327e-02f, -1.44543163e-02f,
  -9.72725917e-03f, 4.00434732e-02f, 1.54958609e-02f, 2.33287476e-02f, -9.25931428e-03f, 1.29413709e-01f, -3.78393382e-02f, 1.24443832e-04f, 1.46449404e-02f, -2.68093776e-02f,
  2.12564617e-02f, 2.08380520e-02f, -2.54597142e-03f, -3.94540541e-02f, 3.32579389e-02f, 3.69188301e-02f, 1.06497984e-02f, 1.20015088e-02f, -2.34797932e-02f, 2.64127273e-03f,
  -7.22034574e-02f, 4.02592681e-03f, 1.13767339e-03f, 6.00037910e-02f, 4.65150364e-03f, -2.88932659e-02f, -9.13545117e-03f, -3.57670896e-02f, 2.28170063e-02f, -3.62767000e-03f,
  4.39764298e-02f, 7.00642262e-03f, -4.85495897e-03f, 1.67814642e-02f, 3.67448032e-02f, -7.28056803e-02f, 3.91443484e-02f, -2.90257521e-02f, 2.26595979e-02f, -4.15631533e-02f,
  -1.92023721e-02f, -3.67986015e-03f, 7.24633131e-03f, -7.49243721e-02f, 2.49348406e-04f, 2.21666880e-02f, 1.77688766e-02f, 3.78080197e-02f, 1.75253190e-02f, -6.18026033e-02f,
  -1.47277400e-01f, -8.53467435e-02f, 6.03019111e-02f, 6.62653074e-02f, 8.64984002e-03f, 1.95085350e-02f, 3.62526476e-02f, 4.32318039e-02f, 2.24415082e-02f, -7.48232519e-03f,
  7.82354642e-03f, -8.63498822e-03f, -2.74284203e-02f, -1.03997793e-02f, 3.99712063e-02f, -1.15191750e-01f, -1.80237163e-02f, 2.24465020e-02f, 1.68552622e-02f, -9.26362630e-03f,
  -1.93547420e-02f, -2.84979455e-02f, 4.78211567e-02f, -1.97682697e-02f, -6.55430555e-02f, -5.19003123e-02f, 7.85715971e-03f, 3.74346748e-02f, -3.96572985e-02f, -4.21022363e-02f,
  -9.06989202e-02f, -9.83975977e-02f, -1.12557039e-01f, -2.71980971e-01f, 3.85929108e-01f, 3.02637964e-01f, -7.77942017e-02f, -4.89546433e-02f, 2.51453042e-01f, -6.51669428e-02f,
  -5.84912710e-02f, 1.60642996e-01f, -3.13983746e-02f, -2.09199682e-01f, -9.18701217e-02f, -6.18457049e-02f, -7.90904015e-02f, 1.60486475e-02f, 1.53157916e-02f, 7.72231491e-03f,
  -1.59006678e-02f, -1.10622011e-01f, -2.39480421e-01f, 3.27768526e-03f, 5.64521998e-02f, -5.16309664e-02f, -3.55553210e-01f, 1.91335175e-02f, -1.72106490e-01f, -8.91168602e-03f,
  1.54252732e-02f, 4.36853766e-02f, -2.11754993e-01f, 1.01834886e-01f, 2.64019743e-02f, -6.72962889e-03f, -2.45606676e-02f, -1.55217834e-02f, 3.03730275e-03f, 1.71384849e-02f,
  1.05431996e-01f, 5.15202433e-02f, -1.59437880e-02f, -4.78450060e-02f, 3.71896699e-02f, -5.78752309e-02f, 2.62305234e-02f, 3.49734500e-02f, 5.11260703e-02f, 7.77316019e-02f,
  1.37916962e-02f, -3.15869823e-02f, 2.36464627e-02f, 1.46757990e-01f, 3.59913264e-03f, -2.76799314e-02f, 6.70513650e-03f, 5.03801787e-03f, 8.58933330e-02f, -3.13617066e-02f,
  -3.54935694e-03f, 1.17316730e-01f, 3.97525914e-02f, 1.40479207e-02f, -1.75480600e-02f, -1.03965349e-01f, 5.31041361e-02f, -4.08257507e-02f, 1.96204875e-02f, -1.48654236e-02f,
  4.07626145e-02f, -6.86101913e-02f, -1.71963423e-02f, 5.51648438e-02f, 5.34789488e-02f, -9.80247408e-02f, 1.08610168e-01f, -3.52568999e-02f, -3.73150110e-02f, -1.07665680e-01f,
  -1.56036513e-02f, -3.99060026e-02f, -8.30438510e-02f, 2.46009938e-02f, -9.51288044e-02f, 2.28935573e-02f, -7.55640194e-02f, -1.28239587e-01f, 2.38816347e-02f, 8.47736895e-02f,
  3.91715653e-02f, -3.48737910e-02f, -3.38040777e-02f, -1.67203016e-05f, -7.69080743e-02f, 3.97939347e-02f, 4.02188674e-02f, -8.10351223e-02f, 1.58169139e-02f, -4.12796549e-02f,
  3.36117931e-02f, 5.88973565e-03f, 1.03147313e-01f, 6.65040463e-02f, -7.48278797e-02f, -8.35961327e-02f, 2.26700455e-02f, -3.64817530e-02f, -1.00244805e-01f, -7.14315102e-02f,
  5.82355820e-02f, 1.29967019e-01f, 2.04260536e-02f, -4.45409724e-03f, -7.60274008e-02f, 6.67809770e-02f, 1.60804503e-02f, 6.51565790e-02f, 1.25689488e-02f, 2.07759868e-02f,
  -2.87374467e-01f, 5.35216272e-01f, -4.47228849e-02f, 3.57112318e-01f, -2.34668955e-01f, 2.39295840e-01f, -1.35603532e-01f, 1.17160276e-01f, 1.41907662e-01f, 1.98422849e-01f,
  -1.62137561e-02f, 1.48457780e-01f, 1.23514086e-01f, 2.53223062e-01f, 1.29101336e-01f, 2.27952659e-01f, 9.13814008e-02f, 8.84543136e-02f, 3.03169414e-02f, 8.00517350e-02f,
  -9.45868902e-03f, 1.85217857e-01f, -8.61242414e-02f, 7.46576488e-02f, -3.77903059e-02f, -3.44815962e-02f, -7.33643249e-02f, -6.75004199e-02f, -7.13506192e-02f, -5.96033297e-02f,
  -1.18166111e-01f, 3.64137478e-02f, -1.18152618e-01f, 3.29749770e-02f, 3.82603370e-02f, -1.89322140e-02f, -6.28375188e-02f, -8.28323439e-02f, -4.41661961e-02f, -1.56419557e-02f,
  6.70921952e-02f, -3.98246571e-02f, 4.18921188e-02f, 3.34193856e-02f, -2.65388209e-02f, -4.34810668e-02f, -4.28045653e-02f, -9.51987319e-03f, -6.30701147e-03f, 5.93668930e-02f,
  6.00546133e-03f, 3.98055650e-03f, -4.68044356e-03f, 2.48347800e-02f, -5.81666455e-02f, -1.36579620e-02f, 2.29800474e-02f, -2.44393609e-02f, -8.17842223e-03f, 1.35060176e-02f,
  -2.47191601e-02f, -7.37715093e-03f, 2.56101135e-02f, -7.61379525e-02f, 6.59251660e-02f, -6.17659055e-02f, 7.11783543e-02f, -1.74468942e-02f, 1.02970321e-02f, 4.40910831e-02f,
  -4.19058949e-02f, -1.68666765e-02f, 3.15301046e-02f, 3.28165991e-03f, 6.92717284e-02f, -4.84643504e-03f, 5.88626275e-03f, -3.13286260e-02f, -2.44852155e-02f, -5.83080854e-03f,
  3.56986523e-02f, 1.87263619e-02f, 2.47837938e-02f, -9.62747168e-03f, 3.32640596e-02f, -4.71697599e-02f, 4.43744771e-02f, -3.57507467e-02f, 5.26320599e-02f, 3.34165618e-02f,
  2.40327969e-01f, 2.18526483e-01f, 1.88574474e-02f, 1.98013838e-02f, -1.46599412e-02f, -2.79098544e-02f, 1.11766130e-01f, -2.86513381e-02f, 1.49947181e-01f, 2.56202766e-03f,
  -8.15382674e-02f, -1.86230596e-02f, 3.28260288e-02f, -4.45958897e-02f, 7.02019595e-03f, 5.22379987e-02f, 1.14519671e-01f, 2.45662336e-03f, 2.03484520e-02f, -2.67836191e-02f,
  3.52267325e-02f, 2.28988454e-02f, -2.62314826e-02f, 5.52282715e-03f, -1.82516109e-02f, -3.14597115e-02f, -2.67205667e-03f, -7.02729970e-02f, -3.73083875e-02f, 1.47049231e-02f,
  -6.97776735e-01f, -2.35449433e-01f, 8.72095823e-02f, -3.64834100e-01f, -9.61517543e-02f, -3.43184918e-01f, -2.40599558e-01f, 1.37005467e-02f, -5.93112074e-02f, -1.02769852e-01f,
  -1.82879701e-01f, -6.23146892e-02f, 1.99736021e-02f, -2.19705448e-01f, -1.50391072e-01f, 2.07040496e-02f, -1.87373877e-01f, -1.50392726e-01f, 3.20494547e-02f, -1.37003824e-01f,
  -4.20976318e-02f, -1.21802226e-01f, -3.82428281e-02f, 8.59185308e-02f, -1.78986982e-01f, 4.48734537e-02f, -6.51094317e-02f, 9.55860317e-02f, -1.29351854e-01f, 2.68975999e-02f,
  -5.64199202e-02f, 6.98040649e-02f, 1.75552033e-02f, 4.43292521e-02f, -6.66465312e-02f, 1.81620265e-03f, 5.19313337e-03f, 1.25114108e-02f, 4.11433466e-02f, -2.56019626e-02f,
  -2.27527842e-02f, 3.34146135e-02f, -1.80135891e-02f, 3.80709991e-02f, -3.05090714e-02f, 4.84918654e-02f, 7.13022472e-03f, -2.12511383e-02f, 1.45236831e-02f, 4.93889377e-02f,
  2.85150763e-02f, 2.90468987e-02f, -1.39061827e-02f, -2.44186912e-03f, 5.12345992e-02f, -2.40935124e-02f, -6.15201294e-02f, 8.94346554e-03f, -3.34053300e-02f, -1.39215840e-02f,
  4.49562864e-03f, -1.38998264e-02f, -1.87576115e-02f, 1.12504587e-02f, -2.23652981e-02f, -1.51173153e-03f, 3.58032732e-04f, -1.46046048e-02f, -4.59120236e-02f, -2.00259294e-02f,
  -4.08103839e-02f, -4.70324531e-02f, 2.28029042e-02f, -5.04758023e-02f, -3.80549841e-02f, -2.36497056e-02f, -3.43171619e-02f, -5.17207831e-02f, -3.24472450e-02f, -3.02661527e-02f,
  3.07467151e-02f, -7.67730130e-03f, 2.95017264e-03f, -3.22518088e-02f, -1.24764312e-02f, 3.79852345e-03f, -1.94231905e-02f, 4.20881957e-02f, -9.63428989e-03f, 9.90717299e-03f,
  -2.57279396e-01f, -1.20870300e-01f, -5.20749278e-02f, -8.50255229e-03f, -1.15537792e-02f, 2.16773385e-03f, 6.14664983e-03f, 3.99087090e-03f, -5.12019508e-02f, -2.76337806e-02f,
  -4.98107225e-02f, -2.55705696e-02f, -3.80204525e-03f, -1.39320474e-02f, 7.07137259e-03f, -3.73424590e-02f, -1.27796205e-02f, -9.58996639e-03f, -5.34869693e-02f, -4.79997434e-02f,
  -1.52784372e-02f, 1.67102944e-02f, 3.49335968e-02f, 1.83136724e-02f, -3.87372412e-02f, -1.02469008e-02f, 4.92673321e-03f, 6.78236187e-02f, 1.59151014e-03f, -4.46346402e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  6.34590387e-01f, -2.96998203e-01f, -3.41549814e-02f, 3.61571401e-01f, -2.67179795e-02f, -4.06731963e-01f, -3.76773894e-01f, -2.19528787e-02f, 8.93312037e-01f, -2.80598164e-01f,
  -4.63202655e-01f, 1.89631745e-01f, -3.69457901e-01f, -5.35745434e-02f, -1.06527530e-01f, -4.61156070e-02f, 1.53650949e-02f, -1.13314930e-02f, 1.62834957e-01f, -7.80840218e-02f,
  2.18035474e-01f, -4.78591859e-01f, -3.02425504e-01f, -3.59725475e-01f, -8.50843340e-02f, -1.32471308e-01f, -2.24809155e-01f, -3.85981768e-01f, -3.67351055e-01f, -6.97938576e-02f,
  5.59047572e-02f, 9.76628214e-02f, -1.31492034e-01f, 5.67059144e-02f, -6.96727186e-02f, 4.83989418e-02f, -1.51411697e-01f, -2.60311633e-01f, 5.00199385e-02f, 6.73526675e-02f,
  1.19905695e-01f, -5.14297411e-02f, 9.03646052e-02f, -2.05154251e-02f, -1.45414733e-05f, -2.64760964e-02f, 1.41537145e-01f, 1.06673777e-01f, 2.76601966e-03f, 2.67903656e-02f,
  4.88132462e-02f, -1.14277624e-01f, 2.91386340e-02f, -6.53239265e-02f, 1.61261465e-02f, -6.39707074e-02f, -5.61522357e-02f, -1.35376915e-01f, 1.59291681e-02f, 7.41948932e-02f,
  -8.07912424e-02f, -4.52671573e-02f, 4.07383181e-02f, -4.81853320e-04f, 6.67926148e-02f, 3.47332954e-02f, 1.07106104e-01f, 6.53659180e-02f, 4.86624055e-02f, -3.91276069e-02f,
  1.09377570e-01f, -5.00196591e-02f, 2.84979820e-01f, -6.76294938e-02f, 3.23030651e-02f, 1.72336534e-01f, -4.01419774e-02f, 1.63706653e-02f, -1.91085134e-02f, 1.19934924e-01f,
  1.09316207e-01f, 1.63912073e-01f, -1.09616332e-01f, 1.01712402e-02f, -9.50843915e-02f, -3.06461696e-02f, -4.16492112e-02f, 3.66897434e-02f, -8.27269778e-02f, -1.38726905e-02f,
  -9.38848928e-02f, -3.61370265e-01f, -1.43818200e-01f, -8.59351680e-02f, 1.08220622e-01f, -5.36613911e-02f, 2.51613587e-01f, 8.11736211e-02f, -1.03131376e-01f, -3.07110287e-02f,
  -1.91146448e-01f, -3.46811302e-02f, 3.38543393e-02f, -5.36743784e-03f, -1.07094506e-02f, 9.79416370e-02f, -6.90471828e-02f, -1.23852246e-01f, -1.50210992e-01f, -9.66784731e-02f,
  -4.34170552e-02f, 2.93280371e-02f, -7.48812687e-03f, 5.55699458e-03f, -9.26451683e-02f, -2.91136093e-02f, 2.68117726e-01f, -3.02197207e-02f, -3.92080769e-02f, -8.48207027e-02f,
  3.67588475e-02f, 4.95827317e-01f, -2.33758315e-01f, -3.08538288e-01f, -8.34887922e-02f, -1.07785881e+00f, -7.67947674e-01f, -2.05596581e-01f, -8.73326696e-03f, 2.60537148e-01f,
  -4.19354618e-01f, 5.53104460e-01f, 6.01900800e-04f, -5.57037354e-01f, -1.23746955e+00f, -5.03570318e-01f, -8.92446697e-01f, -8.50904584e-02f, -2.27284864e-01f, 8.80416483e-02f,
  -3.40254605e-01f, -5.16544163e-01f, -5.06304264e-01f, 2.48523489e-01f, 6.04549311e-02f, 5.11236310e-01f, 2.46224657e-01f, 3.96233760e-02f, 2.57310838e-01f, -1.17089979e-01f,
  -2.60984123e-01f, 3.51228639e-02f, 2.24050269e-01f, -1.10915303e-01f, -2.02240080e-01f, 3.18747424e-02f, 1.16388507e-01f, -6.67323098e-02f, -2.01141685e-02f, 5.95607385e-02f,
  1.84987336e-01f, 8.21162388e-03f, -8.67923796e-02f, -4.87884544e-02f, 2.05700248e-02f, 9.57838669e-02f, -4.77302028e-03f, 8.00730754e-03f, 1.61511958e-01f, 1.89891662e-02f,
  -8.36319029e-02f, -7.02103181e-03f, 1.01732798e-01f, 1.77673250e-02f, -1.31711170e-01f, -4.00972515e-02f, -7.99211338e-02f, 1.42995670e-01f, -1.99273489e-02f, -1.39634058e-01f,
  -4.47952300e-02f, 2.53969745e-04f, 1.02078542e-02f, 6.29587695e-02f, -2.07254589e-02f, -7.14269951e-02f, 3.18997949e-02f, -9.57275406e-02f, 1.14551894e-01f, -5.36913835e-02f,
  2.19765306e-02f, 8.66976529e-02f, -3.64713445e-02f, 2.25174744e-02f, -7.90586397e-02f, -4.85581607e-02f, 5.18334955e-02f, 5.00759445e-02f, -1.12235151e-01f, -2.25704182e-02f,
  -1.81951523e-02f, -7.14120418e-02f, 5.50605580e-02f, -5.09400247e-03f, -9.69875380e-02f, -3.61253694e-02f, 3.43314484e-02f, 8.32119584e-02f, 7.90500045e-02f, 1.35272359e-02f,
  -1.87857792e-01f, 5.67637682e-02f, -3.51882204e-02f, 1.26506776e-01f, -3.33231757e-03f, 1.28591908e-02f, -2.43427157e-01f, 4.87047471e-02f, 6.39743060e-02f, -1.69444576e-01f,
  5.17241620e-02f, 3.85431536e-02f, 7.40307802e-03f, 1.34357870e-01f, -4.26057801e-02f, -1.69568971e-01f, -1.01354972e-01f, 1.14024788e-01f, 2.54418198e-02f, 3.85503098e-02f,
  2.06754252e-01f, -4.21102792e-02f, -8.59022886e-03f, -5.03067262e-02f, 2.43343860e-02f, -5.76108061e-02f, 1.60803005e-01f, 2.72238646e-02f, 3.88376340e-02f, -9.84250307e-02f,
  -1.10039553e-02f, -4.49213624e-01f, -5.04910350e-01f, 4.41155359e-02f, 1.21599533e-01f, -9.53224003e-02f, -5.17510176e-01f, 7.51576349e-02f, -3.37241411e-01f, 2.45058779e-02f,
  1.26813471e-01f, -3.01673800e-01f, -3.78970832e-01f, 1.66389093e-01f, 7.37053379e-02f, -5.02940834e-01f, 3.39602292e-01f, 5.26364485e-04f, -2.03893766e-01f, 1.60463735e-01f,
  1.35158226e-02f, 2.58588046e-01f, -1.06108852e-01f, 3.23606104e-01f, 6.85329065e-02f, 8.18393379e-02f, 4.78865415e-01f, -1.41137257e-01f, 5.96476257e-01f, 2.13817880e-01f,
  -1.18867271e-01f, -1.80912286e-01f, -1.02546625e-01f, 3.32265161e-02f, 1.02608018e-01f, 1.29948884e-01f, 1.03342198e-01f, 1.54381031e-02f, -1.55454367e-01f, -5.53109758e-02f,
  -5.70051409e-02f, 1.17208667e-01f, 3.71368080e-02f, -7.79396519e-02f, -5.30378185e-02f, -5.16047701e-02f, -8.84426832e-02f, -1.17845843e-02f, -2.00996965e-01f, -1.20739862e-01f,
  -1.48043916e-01f, 5.17830476e-02f, -1.00721698e-02f, 8.95957723e-02f, -8.02066177e-02f, -6.56813383e-02f, 4.78597619e-02f, -1.17096104e-01f, 5.32850511e-02f, -1.09324011e-03f,
  -1.56988464e-02f, 6.14737421e-02f, -2.16678698e-02f, 1.08096577e-01f, -7.87297860e-02f, -2.46733408e-02f, 6.21572211e-02f, 1.19276985e-03f, -1.30035831e-02f, -1.01111224e-02f,
  1.39652431e-01f, -4.69409563e-02f, 4.90974411e-02f, -1.72495171e-02f, -2.59863529e-02f, -4.29006517e-02f, -2.39181761e-02f, -4.47295904e-02f, -5.75166848e-03f, -9.25052166e-02f,
  1.23594124e-02f, 1.76869165e-02f, -1.12824552e-01f, 2.30798181e-02f, -4.72784601e-02f, 1.89329423e-02f, 7.34461546e-02f, -1.77537147e-02f, -3.12182005e-03f, 2.60200296e-02f,
  6.36564568e-02f, 1.96347728e-01f, -8.19511786e-02f, -4.94634733e-02f, -1.12824798e-01f, 1.16750702e-01f, -5.55000566e-02f, 4.24113832e-02f, 1.24913536e-01f, -1.50168976e-02f,
  1.60602510e-01f, -2.27424875e-02f, 1.22221582e-01f, 1.51853919e-01f, 4.10093926e-02f, 1.11136502e-02f, 3.13272625e-02f, 2.04320941e-02f, 1.69791311e-01f, 3.33009362e-02f,
  1.08462542e-01f, -1.49158370e-02f, 1.06422685e-01f, 1.80896297e-02f, 8.24351832e-02f, 5.83302118e-02f, 7.21303513e-03f, 1.29706055e-01f, 1.00964367e-01f, -1.09709024e-01f,
  2.57063508e-01f, -4.36894208e-01f, 2.48841286e-01f, -6.97947383e-01f, 4.82824147e-02f, -1.52160078e-01f, -1.83853973e-02f, -5.85402131e-01f, -2.83692628e-01f, -4.90716755e-01f,
  -3.47268701e-01f, 3.62819046e-01f, 3.93918782e-01f, -5.28463364e-01f, 1.02547371e+00f, 2.89951473e-01f, -5.21789491e-01f, -2.04610378e-01f, 3.71263735e-02f, -4.20930535e-01f,
  -1.84816271e-02f, -4.63197976e-01f, 2.14330375e-01f, -4.48869318e-01f, -3.19676131e-01f, -3.15460891e-01f, 2.07543984e-01f, 2.12357696e-02f, -3.33102345e-01f, 1.48733705e-01f,
  1.79677699e-02f, -3.78416151e-01f, -1.38164118e-01f, 2.57528704e-02f, -8.99800360e-02f, 3.51150818e-02f, 6.51958119e-03f, 2.22309604e-01f, -1.58869803e-01f, 6.72583506e-02f,
  8.10187906e-02f, -2.76606753e-02f, -1.48568630e-01f, 4.74226614e-03f, -1.52540594e-01f, -1.20088384e-01f, -3.24407108e-02f, -8.67863074e-02f, -1.37878597e-01f, 1.56117111e-01f,
  5.12854420e-02f, -4.36230749e-02f, -1.40163317e-01f, -4.18471247e-02f, 3.98816168e-02f, -1.63717851e-01f, 7.80208036e-02f, 1.28723457e-01f, -1.38111161e-02f, -2.25880638e-01f,
  -3.59583534e-02f, 5.14811277e-02f, 3.91466655e-02f, -1.83947891e-01f, -9.83897299e-02f, -1.81475058e-01f, -1.04153547e-02f, 1.21459685e-01f, 9.70786437e-02f, -7.66330659e-02f,
  -2.55764239e-02f, -9.42022651e-02f, -1.76904947e-02f, -6.67155385e-02f, -4.35798578e-02f, -9.82827544e-02f, 2.28624679e-02f, 8.77186880e-02f, -1.56511843e-01f, 5.59901819e-02f,
  9.61518511e-02f, -1.30829029e-02f, -4.87725511e-02f, -4.61292267e-02f, -4.14666533e-02f, 1.63743138e-01f, -1.96344163e-02f, 6.89870939e-02f, 2.31865160e-02f, 6.32769465e-02f,
  -3.79428081e-02f, -5.41681886e-01f, -1.41493948e-02f, -1.15775056e-02f, 9.23101008e-02f, -2.43147667e-02f, 1.10078149e-01f, -1.43100247e-01f, 5.73942810e-02f, -7.40017891e-02f,
  -1.48685694e-01f, -2.26962585e-02f, 4.40304056e-02f, -2.34243218e-02f, 5.50766699e-02f, -7.59785715e-03f, -5.77166118e-02f, 4.07306999e-02f, -9.19772033e-03f, -5.06999120e-02f,
  2.10397709e-02f, 4.90843989e-02f, 1.25990376e-01f, -5.50275221e-02f, -1.13402046e-01f, -4.29104529e-02f, -4.57802974e-03f, -1.90909598e-02f, 1.10058501e-01f, 6.94296136e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  6.74712539e-01f, 8.49661648e-01f, 6.30186141e-01f, 5.84104843e-02f
};

// L1_fan_Wp (Shape: 6 x 16)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  4.25497204e-01f, 3.07416797e-01f, 7.36524984e-02f, -4.74103302e-01f, -5.93190730e-01f, 3.87957454e-01f, -9.02410388e-01f, -1.47934303e-01f, 7.74800301e-01f, 1.75665244e-01f,
  2.55084515e-01f, -7.00377345e-01f, 1.63063169e-01f, -3.39033306e-02f, -4.25880373e-01f, 2.09557459e-01f, -5.28668106e-01f, 2.74662167e-01f, 1.25968233e-01f, 3.09303075e-01f,
  6.01624288e-02f, -1.09169459e+00f, 6.49441421e-01f, -5.76338656e-02f, -1.09604514e+00f, -3.22400123e-01f, 8.37329328e-01f, 2.70516276e-01f, -1.65378943e-01f, -4.64065652e-03f,
  1.31404385e-01f, 1.43729270e-01f, 2.39002064e-01f, 4.32161614e-02f, 1.31171435e-01f, -2.51648575e-01f, -1.55923739e-01f, -3.93412530e-01f, -2.37809941e-01f, -9.85205352e-01f,
  -8.46758038e-02f, 3.47658359e-02f, -1.86469778e-01f, -1.01634629e-01f, -3.57435882e-01f, -1.16550215e-01f, 3.96355748e-01f, 4.49658304e-01f, 6.16109073e-02f, -2.47887596e-01f,
  -7.95191228e-02f, 1.73771217e-01f, 4.70967591e-01f, -6.71731010e-02f, 1.19562343e-01f, 2.26674229e-01f, 6.78821146e-01f, 8.26174468e-02f, -6.40447319e-01f, 5.50708115e-01f,
  1.45237502e-02f, 9.04036015e-02f, -5.84651649e-01f, 3.68636400e-01f, 2.27477655e-01f, -2.99192984e-02f, -4.03925568e-01f, -3.89012575e-01f, -2.39010572e-01f, -4.39632773e-01f,
  -6.51382327e-01f, -8.54669750e-01f, 1.90508857e-01f, -2.50478715e-01f, -3.97091240e-01f, -7.04741836e-01f, 4.21808213e-01f, 3.83779466e-01f, 2.97852963e-01f, -4.86628115e-01f,
  -1.46969348e-01f, -1.76664531e-01f, 9.54521894e-02f, -7.93004513e-01f, 3.07022762e-02f, 2.96507955e-01f, -1.78178206e-01f, -1.27041042e-01f, 8.01121056e-01f, -1.88564822e-01f,
  2.28068992e-01f, -1.08513467e-01f, 2.50371918e-02f, -2.69198865e-01f, 4.41767484e-01f, -2.81136364e-01f
};

// L1_fan_Wp_bar (Shape: 4 x 16)
const int L1_fan_Wp_bar_rows = 4;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  -1.21305633e+00f, 3.62192869e-01f, 5.93490839e-01f, -1.06624365e+00f, 5.52573288e-03f, 1.19383752e+00f, -3.92498791e-01f, 1.51020455e+00f, 8.84782612e-01f, -9.49459493e-01f,
  2.08855891e+00f, -1.18625295e+00f, 1.51878312e-01f, 8.54926944e-01f, 9.18234706e-01f, -1.42739996e-01f, 3.76996517e-01f, -1.24738646e+00f, -7.89389834e-02f, 7.48622715e-01f,
  5.73023081e-01f, 1.44368625e+00f, -1.17760897e+00f, -1.10011494e+00f, 1.35656095e+00f, -4.73189563e-01f, -1.67542624e+00f, -9.84527946e-01f, 1.26806307e+00f, 1.84451550e-01f,
  6.62571669e-01f, 7.35283136e-01f, 6.38494492e-01f, 7.61432052e-01f, 1.68677592e+00f, 7.92647302e-01f, 6.25408113e-01f, -1.03372622e+00f, 1.20706153e+00f, -5.69502831e-01f,
  5.20918727e-01f, 8.63013208e-01f, 1.43045634e-01f, 3.28867227e-01f, 6.91186011e-01f, 9.86079648e-02f, -3.58647555e-01f, 1.66218722e+00f, 4.68023479e-01f, 6.22121513e-01f,
  -8.87683570e-01f, 6.58293843e-01f, 7.95469940e-01f, -7.66726732e-01f, -2.76064873e-01f, 2.18232661e-01f, -1.26987159e+00f, 8.22353601e-01f, -1.13083804e+00f, 9.92217302e-01f,
  1.05533910e+00f, 2.01355720e+00f, 5.99168846e-03f, -2.26707369e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 4)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 4;
const float L1_fan_Bp_bar_data[] = {
  1.11237872e+00f, 2.26626962e-01f, 9.88585949e-01f, 1.09329253e-01f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  2.67585814e-01f, -8.48358810e-01f, -7.86627531e-02f, 1.93405673e-01f, -9.49745715e-01f, 8.65206897e-01f, -1.73167932e+00f, 1.18576837e+00f, -1.79434156e+00f, -1.05668175e+00f,
  -1.61402559e+00f, -7.68326342e-01f, 1.01928091e+00f, -2.15899754e+00f, -1.05963171e+00f, -1.26633739e+00f, 9.52745914e-01f, -1.30581009e+00f, -5.58952093e-01f, -1.36706066e+00f,
  1.28670764e+00f, 1.05790758e+00f, -9.37851846e-01f, 1.84546983e+00f, 2.02360010e+00f, -6.92131698e-01f, 1.43529439e+00f, 8.78433049e-01f, 1.52525380e-01f, -4.38526541e-01f,
  4.22112912e-01f, -7.82620549e-01f, -1.38203219e-01f, 7.22787559e-01f, -1.04711211e+00f, -5.85290313e-01f, -4.86756414e-02f, -7.79116809e-01f, -1.38969040e+00f, -1.57960415e+00f,
  2.62613237e-01f, -6.10960960e-01f, 2.93534756e-01f, 7.38062918e-01f, -4.49509948e-01f, 1.12449360e+00f, -8.80119324e-01f, -1.28908122e+00f, -1.10662830e+00f, -7.51893878e-01f,
  -6.62287593e-01f, 7.59203285e-02f, 1.05492413e+00f, -9.54826832e-01f, -4.90760535e-01f, 1.12278247e+00f, -8.33042860e-01f, 1.04494560e+00f, 1.22888582e-02f, 3.22411269e-01f,
  -8.34773540e-01f, -1.96805668e+00f, -1.98108986e-01f, 8.40288520e-01f, 2.92786926e-01f, 5.41047215e-01f, 6.18407428e-01f, 7.31664240e-01f, -1.19968092e+00f, 3.86636883e-01f,
  -1.90630662e+00f, 6.08443499e-01f, -3.24565470e-01f, 1.77783048e+00f, -1.04102302e+00f, -1.33152890e+00f, -1.15586424e+00f, -1.43948507e+00f, 1.15316057e+00f, -1.66118696e-01f,
  -8.20524871e-01f, 1.37301731e+00f, 7.01518536e-01f, 8.47433150e-01f, 6.22822762e-01f, 1.02150416e+00f, 2.29982471e+00f, -1.44323957e+00f, -1.32647800e+00f, -1.26521683e+00f,
  -6.02705181e-01f, 1.12023829e-02f, 2.87896674e-02f, -6.29746497e-01f, 6.15673959e-01f, -8.60853136e-01f, -3.01011235e-01f, -7.38898277e-01f, 1.11868477e+00f, 1.00960124e+00f,
  -1.43450856e+00f, 6.34431839e-01f, 1.21551561e+00f, -5.46813250e-01f, -5.62965274e-01f, 6.85481489e-01f, 1.03262222e+00f, 1.14602375e+00f, -2.10133362e+00f, 8.73182714e-01f,
  -2.55599737e-01f, -3.89630228e-01f, 1.43729642e-01f, 9.23996493e-02f, -2.56010592e-01f, -1.01422024e+00f, 1.62654683e-01f, -9.72740471e-01f, 2.15765819e-01f, 6.14650428e-01f,
  5.59790671e-01f, -4.35108036e-01f, -5.89529216e-01f, 7.89002061e-01f, -1.35888529e+00f, 5.51708341e-02f, 3.78937900e-01f, 1.99611604e-01f, -1.65043816e-01f, 5.36300540e-01f,
  4.97241020e-01f, 5.13009429e-01f, 9.30999517e-02f, -1.36846089e+00f, 1.41758883e+00f, -4.86941427e-01f, 4.79656100e-01f, 3.18552591e-02f, 4.80997890e-01f, 1.15004575e+00f,
  1.23072875e+00f, -4.94684219e-01f, -2.08244562e+00f, -7.57664502e-01f, -4.29685526e-02f, -1.22815125e-01f, -1.20160890e+00f, -7.43287683e-01f, 1.00554717e+00f, -1.33759186e-01f,
  1.18738616e+00f, -1.29986072e+00f, 1.23571515e+00f, 7.92696774e-01f, -1.18920815e+00f, -1.16071343e+00f, -2.02804756e+00f, 4.16833550e-01f, 7.32772231e-01f, -1.78640378e+00f,
  -4.25202787e-01f, 1.25663364e+00f, 6.49932444e-01f, 4.41347241e-01f, -3.65280688e-01f, 2.34948620e-01f, -1.16811931e+00f, -1.32119596e+00f, 7.42350519e-01f, -1.42730260e+00f,
  1.18707085e+00f, -1.26267147e+00f, -4.48444933e-01f, -5.33754349e-01f, -1.51744521e+00f, 6.55379057e-01f, 4.50131625e-01f, -1.39755309e+00f, -1.22387302e+00f, -1.70260832e-01f,
  -1.91510335e-01f, -1.05559774e-01f, 1.78519046e+00f, -1.22936511e+00f, -9.67768848e-01f, 1.61320984e+00f, 4.38503772e-01f, -7.43988276e-01f, -3.02821826e-02f, -7.49635994e-02f,
  -6.73134089e-01f, 2.22819135e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  5.87703347e-01f, 4.50706363e-01f, 7.69624263e-02f, -4.32160735e-01f, 4.17479664e-01f, 4.32307541e-01f, -7.66731706e-03f, -7.05016255e-01f, -3.77441704e-01f, 5.02488352e-02f,
  2.05648676e-01f, -6.49816513e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 6, 4
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    