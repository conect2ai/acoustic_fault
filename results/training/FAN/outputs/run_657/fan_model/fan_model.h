/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  8.55964199e-02f, 3.50093320e-02f, 2.23399371e-01f, 9.24196616e-02f, -4.36805524e-02f, 8.25232789e-02f, 1.96131304e-01f, -2.68744286e-02f, 2.12607663e-02f, -1.30856200e-03f,
  -1.52064398e-01f, -1.31556705e-01f, -6.44585267e-02f, -7.06623122e-02f, -1.11208111e-01f, 1.82968572e-01f, 1.94242284e-01f, 8.95347670e-02f, -5.93252145e-02f, -4.79297899e-03f,
  -6.16366453e-02f, 9.12079811e-02f, -9.17606875e-02f, -1.56096011e-01f, 7.86524266e-02f, -8.12705234e-02f, -2.60641892e-02f, -7.01270103e-02f, -8.31542909e-02f, 1.19761959e-01f,
  2.25656584e-01f, 2.02568504e-03f, -6.45400584e-02f, -1.82984829e-01f, 2.14675646e-02f, -8.56131241e-02f, -6.17581345e-02f, -1.30317777e-01f, -5.51847294e-02f, 8.69042892e-03f,
  -6.12463355e-02f, -3.34066451e-02f, -2.17843112e-02f, -5.38248308e-02f, 6.27354207e-03f, -8.66616610e-04f, -1.13730498e-01f, 4.91481367e-03f, -9.58926827e-02f, -9.80818942e-02f,
  -8.45157355e-02f, -8.43924358e-02f, 1.13292104e-02f, -7.90876076e-02f, -4.07925583e-02f, -4.88760807e-02f, -1.19751051e-01f, -1.10295877e-01f, -5.92304915e-02f, 6.83556721e-02f,
  -8.66110995e-03f, 2.85993051e-02f, 3.92333865e-02f, 6.37404546e-02f, 1.27870128e-01f, 6.14939854e-02f, 1.65441260e-01f, 9.39500052e-03f, 7.27128983e-02f, 1.08337589e-01f,
  3.71086746e-02f, 4.53120982e-03f, 1.06722228e-02f, 9.55276638e-02f, 8.30114186e-02f, 1.21850399e-02f, 2.88357097e-03f, 5.08850999e-02f, 6.44280016e-02f, 7.87438452e-02f,
  6.94231838e-02f, 6.50953799e-02f, 1.13003001e-01f, 2.32399553e-02f, 5.54482639e-02f, 5.70825860e-02f, 6.73099235e-02f, -2.70208139e-02f, -2.75325421e-02f, 2.77276500e-03f,
  -2.66499277e-02f, -2.18264207e-01f, 1.92646347e-02f, 2.19105296e-02f, -3.33838277e-02f, -1.00895107e-01f, -1.71772651e-02f, -3.95386182e-02f, -9.67483371e-02f, -5.42421862e-02f,
  -5.23863956e-02f, -2.10489985e-02f, 5.31467535e-02f, -2.94907931e-02f, -6.88662902e-02f, -1.99384391e-02f, -1.30288946e-02f, -7.87363052e-02f, -1.08333811e-01f, -2.00357977e-02f,
  -6.71938360e-02f, -3.83028872e-02f, 8.41448978e-02f, 2.83322074e-02f, -8.78286734e-02f, -1.32508082e-02f, 9.36868936e-02f, -3.27938399e-03f, -9.15677100e-02f, 1.08746745e-01f,
  -3.80848974e-01f, 2.75226682e-01f, 9.37618613e-02f, -3.22267950e-01f, -2.36184821e-02f, 1.26972087e-02f, -1.20846145e-01f, -1.48775563e-01f, -9.52249467e-02f, 6.92205355e-02f,
  1.83873937e-01f, 1.39640093e-01f, 6.89703673e-02f, 4.14636247e-02f, -1.69917166e-01f, -1.51151910e-01f, -2.17724562e-01f, -1.88941017e-01f, -1.57096148e-01f, 2.07445435e-02f,
  7.46755302e-02f, -2.84068435e-01f, -1.53198421e-01f, -1.00410283e-02f, 2.29976978e-02f, 6.93896040e-02f, 8.22831988e-02f, 1.51786013e-02f, 2.60715008e-01f, 5.26202889e-03f,
  2.25202814e-01f, 9.30508599e-02f, 4.27086167e-02f, 1.55929178e-01f, 1.04576878e-01f, -1.51905129e-02f, 1.06481969e-01f, 9.32620466e-02f, 1.28541321e-01f, 4.00600173e-02f,
  2.01365992e-01f, 1.18660644e-01f, 8.30693543e-02f, 4.85648513e-02f, 2.98669096e-02f, 6.18886799e-02f, -6.64157793e-02f, 9.49184820e-02f, 3.29828225e-02f, 1.14586025e-01f,
  3.72724049e-02f, 1.15430139e-01f, 8.40168297e-02f, 1.47102773e-01f, 7.60548338e-02f, 5.73306158e-03f, 1.53879657e-01f, 3.19587886e-02f, 1.29271731e-01f, -3.43750790e-02f,
  -1.30950008e-02f, -6.61521927e-02f, -6.07610643e-02f, 1.60993338e-02f, -5.93322702e-02f, -1.40477512e-02f, -1.47952903e-02f, -2.38886680e-02f, 1.42590818e-03f, -9.32055861e-02f,
  -2.13403795e-02f, -1.25647644e-02f, 1.06497705e-02f, 2.99547557e-02f, -7.03944173e-03f, -5.82500212e-02f, -2.69660354e-02f, 1.27460575e-02f, 2.87112277e-02f, -4.64066938e-02f,
  1.14719523e-02f, 4.87990165e-03f, -1.25521533e-02f, 2.70868484e-02f, 1.87109392e-02f, 2.81668250e-02f, -8.71865544e-03f, 1.01746526e-02f, 4.21726331e-02f, 4.65203496e-03f,
  -3.77052426e-02f, 5.49277365e-02f, 4.17577773e-02f, -2.07859045e-03f, 2.82170922e-02f, 1.08883061e-01f, 2.21481115e-01f, 9.64098722e-02f, 6.02755547e-02f, 1.57985881e-01f,
  9.69067961e-02f, -6.80208728e-02f, 9.57938668e-04f, 5.77536896e-02f, -1.23115107e-02f, -4.58870977e-02f, 2.34065321e-03f, 8.01168308e-02f, 1.17403366e-01f, 3.22972089e-02f,
  3.23759876e-02f, -5.44587933e-02f, -2.01840818e-01f, -4.43675406e-02f, 4.13852148e-02f, -8.10479745e-02f, -2.33796481e-02f, 5.86683378e-02f, -4.69739661e-02f, -1.60759240e-02f,
  -7.32246816e-01f, 2.04211414e-01f, 6.80161417e-02f, -3.11104685e-01f, 1.38880685e-01f, -2.50548478e-02f, -6.26027212e-02f, -1.20687082e-01f, -2.27695495e-01f, 6.12587109e-02f,
  1.80513352e-01f, 2.95376237e-02f, -9.25142784e-03f, 1.91044547e-02f, -9.87848639e-02f, -2.82537192e-02f, 6.10228330e-02f, -1.35978311e-01f, -1.60176471e-01f, -1.87118436e-04f,
  1.42748699e-01f, -4.01880816e-02f, -2.41862118e-01f, -6.80750459e-02f, 5.04076518e-02f, 1.27719089e-01f, 1.87908486e-01f, 4.25482690e-02f, 1.95875764e-01f, 1.25085220e-01f,
  5.79146668e-02f, -2.02887833e-01f, -5.63253537e-02f, -4.33264412e-02f, 1.51924953e-01f, -1.88270472e-02f, -1.05125397e-01f, -9.75884199e-02f, -5.46411686e-02f, -2.64010336e-02f,
  -3.32494127e-03f, -4.54705246e-02f, -1.12075448e-01f, -1.57411490e-02f, -7.01725632e-02f, -1.76049635e-01f, -1.32520825e-01f, -1.29534513e-01f, -4.38569561e-02f, -6.36683553e-02f,
  3.30761485e-02f, 7.25634843e-02f, -4.66347449e-02f, -7.73217753e-02f, -5.80758974e-03f, 8.82731844e-03f, 7.20024928e-02f, 7.25740008e-03f, -2.15899162e-02f, -1.34332702e-01f,
  -7.04492405e-02f, 7.28576258e-03f, 2.80308407e-02f, -5.02507091e-02f, 4.93417047e-02f, 5.57143688e-02f, 8.97884071e-02f, 2.91485526e-02f, 1.16900625e-02f, 2.84470897e-02f,
  -9.36498214e-03f, 1.04657382e-01f, 8.19725469e-02f, -5.43750217e-03f, 5.53689189e-02f, 2.77058464e-02f, 5.88751137e-02f, -3.28947753e-02f, -3.97645459e-02f, 1.89885236e-02f,
  -1.47330808e-02f, 5.12245424e-06f, 5.25590405e-02f, -9.79805458e-03f, -3.05345785e-02f, 9.04289559e-02f, 8.14620033e-03f, 4.71323058e-02f, -5.18327951e-02f, -1.08046308e-02f,
  -1.73572958e-01f, 4.70384024e-02f, -8.73100683e-02f, -1.34180650e-01f, -2.98673641e-02f, 1.86309200e-02f, -5.22835478e-02f, 1.14354407e-02f, -6.45161122e-02f, -1.46467015e-01f,
  -1.69675767e-01f, -9.68238488e-02f, -4.81552351e-03f, -1.07883371e-01f, -1.57978311e-02f, -1.10400066e-01f, -6.05893470e-02f, -5.99210449e-02f, -9.16835200e-03f, -2.40704566e-02f,
  -1.33269280e-01f, -1.96823135e-01f, -1.41503796e-01f, -5.20665757e-02f, -1.26602560e-01f, -5.76405302e-02f, -5.52773215e-02f, 3.36464420e-02f, -3.30082662e-02f, -1.75406173e-01f,
  3.57371420e-01f, -4.22381163e-02f, -3.04856271e-01f, 1.02533028e-01f, 2.72546411e-01f, 3.30002122e-02f, -1.20656855e-01f, 3.98797616e-02f, 6.64575249e-02f, -7.76709467e-02f,
  9.73992795e-02f, 1.72634214e-01f, -4.64393012e-02f, -1.44334286e-01f, -3.92087638e-01f, -2.84755349e-01f, -3.41295272e-01f, -2.47738302e-01f, -5.28229438e-02f, 2.01483130e-01f,
  1.37886718e-01f, 1.28946945e-01f, -1.39050651e-02f, -5.97508252e-02f, -7.84478039e-02f, -1.06816441e-01f, -2.16851726e-01f, -1.49410427e-01f, -8.76972675e-02f, -3.40561628e-01f,
  -1.79082841e-01f, -1.75041799e-02f, -8.68294090e-02f, 8.30859877e-03f, -4.95900065e-02f, -9.99184251e-02f, -4.83646467e-02f, -2.19742805e-01f, -8.77258480e-02f, -9.82860625e-02f,
  -3.40217017e-02f, -1.11314863e-01f, -1.01749748e-01f, -1.25335932e-01f, -6.97160587e-02f, -3.87555361e-02f, -1.11420088e-01f, -1.58775941e-01f, -1.20217532e-01f, -7.18542635e-02f,
  8.45342204e-02f, -3.75804049e-03f, -1.73058242e-01f, -1.63704351e-01f, -2.47035876e-01f, -1.00488938e-01f, -6.36835173e-02f, -1.00823738e-01f, -2.87228465e-01f, -2.12838486e-01f,
  1.90377224e-03f, 1.29252151e-02f, -2.91623292e-03f, 8.53192061e-02f, 1.96175754e-01f, 2.65675671e-02f, 9.32221040e-02f, 6.74516559e-02f, 9.09528285e-02f, 2.06405241e-02f,
  4.67668585e-02f, -3.15186158e-02f, -4.67992760e-02f, -1.01407908e-01f, -1.25322253e-01f, -5.27565889e-02f, 1.49397934e-02f, -1.45102158e-01f, -1.14579767e-01f, -2.77899671e-04f,
  4.70277891e-02f, 4.77666557e-02f, 2.14567198e-03f, 7.21956939e-02f, -4.05639894e-02f, -1.00566655e-01f, 5.43505745e-03f, 8.30220953e-02f, 1.55933425e-01f, 1.15754232e-01f,
  1.06611937e-01f, -3.12798709e-01f, -1.30127132e-01f, -5.99210076e-02f, -6.28923699e-02f, -5.91986217e-02f, -2.44585853e-02f, -8.82576630e-02f, 8.18090737e-02f, -7.97179490e-02f,
  6.00949600e-02f, -6.23871647e-02f, -8.30111504e-02f, -9.66194458e-03f, 5.08181266e-02f, -1.52442977e-02f, -1.06761187e-01f, -5.45863695e-02f, -3.39361504e-02f, -4.19970900e-02f,
  -3.06227263e-02f, -4.32806760e-02f, 5.86969890e-02f, -1.03299655e-02f, -3.92753333e-02f, 3.17058270e-03f, -1.01842262e-01f, -4.58824374e-02f, -6.65182844e-02f, 1.86974108e-02f,
  -2.24143788e-01f, -4.59873497e-01f, -1.15846746e-01f, 3.15183133e-01f, 1.17938809e-01f, -1.34526521e-01f, -5.10947764e-01f, -1.67864412e-01f, 2.92167723e-01f, -1.47434533e-01f,
  -1.12793883e-02f, 2.87067562e-01f, 2.79722456e-02f, 4.50433530e-02f, -3.15566808e-01f, -2.84160197e-01f, -1.14700824e-01f, -9.68066156e-02f, -4.64793071e-02f, 5.21597452e-02f,
  -3.25601809e-02f, 2.14163754e-02f, 4.73676212e-02f, -1.18612677e-01f, 1.97558329e-01f, 1.83719367e-01f, 1.98425371e-02f, 5.70945330e-02f, -8.55145082e-02f, 3.46888691e-01f,
  -4.81235869e-02f, -5.46121188e-02f, 8.99841785e-02f, -9.57302004e-02f, 4.02655937e-02f, -7.83504918e-02f, -1.56788975e-01f, 1.82701182e-02f, -2.86587365e-02f, -9.00893733e-02f,
  1.12236710e-03f, -7.10374713e-02f, 5.75568788e-02f, -9.01453868e-02f, 1.19871935e-02f, -3.16783637e-02f, -5.20833395e-02f, -6.69431463e-02f, -6.83339983e-02f, -7.35215843e-02f,
  -4.93729785e-02f, -5.08592390e-02f, -3.60158980e-02f, -4.81097065e-02f, -8.85864943e-02f, 2.70002596e-02f, 3.23538762e-03f, 4.76877578e-03f, -1.06406603e-02f, -6.29137307e-02f,
  -2.11717132e-02f, 4.00258228e-02f, 5.82928173e-02f, -1.04925342e-01f, -5.69988936e-02f, 4.09679040e-02f, 4.11610529e-02f, -7.12239221e-02f, -7.05254748e-02f, -3.59642357e-02f,
  7.65053406e-02f, -2.88395043e-02f, -5.23840711e-02f, 1.23805506e-03f, 1.14554865e-02f, 1.69740319e-02f, -5.29507399e-02f, 5.47133153e-03f, -6.10524118e-02f, 4.80474904e-02f,
  -3.76081839e-02f, -7.45557472e-02f, 6.63175955e-02f, -8.57877359e-02f, -3.80617641e-02f, 4.74864803e-02f, 4.09453586e-02f, 4.56870422e-02f, 6.91450462e-02f, -3.62210236e-02f,
  -9.99398008e-02f, -1.71173856e-01f, 6.39400929e-02f, -7.06860274e-02f, -4.02744859e-02f, 2.38095187e-02f, 1.04244510e-02f, -4.47831228e-02f, 2.76954815e-04f, -6.08305521e-02f,
  -5.85162565e-02f, -1.26112282e-01f, -1.11364670e-01f, 5.05614728e-02f, -2.74255797e-02f, -9.10257548e-03f, -4.22427990e-02f, -2.94481721e-02f, -1.82501197e-01f, -1.32356407e-02f,
  -1.23595901e-01f, -1.56741768e-01f, -1.36629894e-01f, -1.14131816e-01f, -1.33998813e-02f, -1.32631913e-01f, -1.14893027e-01f, -1.23814240e-01f, -1.82733670e-01f, -3.29982191e-01f,
  -9.83315781e-02f, 2.59369686e-02f, -5.30235767e-01f, -4.24190387e-02f, 3.07687987e-02f, 9.43302959e-02f, -5.00624701e-02f, 8.00637305e-02f, 1.84963316e-01f, 1.41277090e-01f,
  4.04987693e-01f, 2.10580006e-01f, 1.51708461e-02f, 3.97749767e-02f, -3.18691954e-02f, -1.46403104e-01f, -2.41898105e-01f, -4.32458878e-01f, -2.15008795e-01f, 1.64662346e-01f,
  1.94778994e-01f, -3.00526358e-02f, -8.80291313e-02f, -6.52502570e-03f, 6.94594532e-02f, 6.97270781e-02f, -6.94734901e-02f, 7.42160976e-02f, 2.12344736e-01f, -1.94924206e-01f,
  -8.34807828e-02f, -9.90281925e-02f, -6.16478063e-02f, 7.51142949e-02f, -3.88119034e-02f, -6.10967427e-02f, -4.12181243e-02f, -1.08729042e-01f, -4.18772809e-02f, -2.25681942e-02f,
  5.53126000e-02f, -5.55018373e-02f, -6.57814890e-02f, -6.94743544e-02f, -3.05865090e-02f, -5.44698052e-02f, -9.35790986e-02f, -1.33449972e-01f, -1.79120898e-01f, -7.49246925e-02f,
  2.96041532e-03f, -1.01501876e-02f, -1.20617360e-01f, -4.87957038e-02f, -9.47789103e-02f, -8.50475207e-02f, -1.07224405e-01f, -4.91855368e-02f, -8.17383155e-02f, -1.06709776e-03f,
  -5.60287423e-02f, -1.05347997e-02f, 3.60190384e-02f, -3.00845709e-02f, 7.39173442e-02f, 8.71054530e-02f, -4.76304889e-02f, 1.35482987e-02f, -1.97807159e-02f, 6.49403930e-02f,
  7.98387155e-02f, 1.68437827e-02f, 1.83215216e-02f, -1.42811146e-02f, 9.55746174e-02f, 1.22486232e-02f, 2.81490274e-02f, 4.17642407e-02f, 4.78844531e-02f, -3.01173376e-03f,
  5.25623336e-02f, 4.57105525e-02f, 1.23323932e-01f, 4.75371629e-02f, 1.87073294e-02f, 2.48901825e-02f, -1.11322626e-02f, 6.02390021e-02f, -1.79316606e-02f, 4.28956449e-02f,
  6.44838139e-02f, -6.44436479e-02f, -3.74284247e-03f, 3.16804461e-02f, -1.30910620e-01f, -3.12134027e-02f, -1.07060708e-02f, 7.02173030e-03f, -9.40918829e-03f, -1.32067874e-01f,
  -2.23777927e-02f, 2.71745548e-02f, 4.06570360e-02f, 2.62206129e-04f, -5.87021299e-02f, 1.11735143e-01f, 1.13584206e-01f, -2.51172632e-02f, -1.17777012e-01f, -2.12154966e-02f,
  -8.75462815e-02f, 5.81252575e-02f, 2.44548358e-02f, -1.90261751e-02f, -3.06782126e-02f, 4.58429269e-02f, -5.14100716e-02f, -1.10197343e-01f, 4.77889553e-03f, -1.46405110e-02f,
  5.14748335e-01f, 1.85091376e-01f, 8.10368806e-02f, -1.75917484e-02f, -5.37263341e-02f, -5.75731732e-02f, -1.75940201e-01f, 1.00293055e-01f, -4.46425118e-02f, -9.24972966e-02f,
  1.64198726e-01f, 1.12972461e-01f, -7.82099739e-02f, -2.91879065e-02f, -4.00874857e-03f, -2.48531684e-01f, -3.36670160e-01f, 7.00962842e-02f, 1.63490579e-01f, 7.36786053e-02f,
  -2.36812800e-01f, -1.92926949e-04f, 2.98502326e-01f, 8.92593488e-02f, -1.50755703e-01f, -7.50669315e-02f, -1.28938958e-01f, 1.42882437e-01f, 4.08997610e-02f, -6.17026836e-02f,
  1.88660771e-01f, 3.16227734e-01f, -1.19784966e-01f, -5.83217032e-02f, 4.89289127e-02f, 9.21260864e-02f, 5.08452952e-02f, 1.15890577e-01f, 2.13714223e-02f, 1.99427567e-02f,
  -8.79114121e-03f, 6.93113208e-02f, 5.60977720e-02f, -7.60369049e-03f, 1.70744844e-02f, -2.71853320e-02f, 4.99482192e-02f, 2.11449653e-01f, 1.25806749e-01f, 7.37009645e-02f,
  -4.94472645e-02f, 1.98756859e-01f, 2.64055610e-01f, 9.16403625e-03f, 9.34599265e-02f, 2.13977750e-02f, 8.69550034e-02f, 1.35002136e-01f, 6.43744022e-02f, 2.47985851e-02f,
  2.24214550e-02f, -1.15688182e-02f, -1.85854640e-02f, 1.89752150e-02f, 3.53819854e-03f, 5.92193641e-02f, -5.17825000e-02f, 3.65251303e-03f, -7.90475234e-02f, -8.19541588e-02f,
  2.91562229e-02f, -1.51744951e-02f, 1.05321594e-01f, 2.51968373e-02f, -1.91317759e-02f, -1.76786259e-02f, 4.53817286e-02f, -2.12119520e-02f, 4.84720506e-02f, -1.88172832e-02f,
  4.69021983e-02f, 1.87678412e-02f, 8.24593566e-03f, 4.18035612e-02f, 4.94349711e-02f, 6.33813813e-02f, -1.49672255e-01f, 7.31610646e-03f, -2.16639042e-02f, -9.26173851e-03f,
  -1.89396366e-01f, 1.47465080e-01f, -1.61690742e-01f, -1.01417512e-01f, -1.97927896e-02f, -8.62335116e-02f, -1.84828620e-02f, -3.48453112e-02f, -1.03587523e-01f, -4.40024491e-03f,
  1.50272064e-02f, -1.91609061e-03f, -4.98101488e-02f, -7.24486113e-02f, 1.91697776e-02f, -6.97503984e-02f, -1.45087704e-01f, -7.03005716e-02f, -1.65392637e-01f, -1.09695546e-01f,
  -8.49522203e-02f, -1.00184746e-01f, 5.57615713e-05f, -9.81795713e-02f, -3.20103057e-02f, -1.73855260e-01f, -5.48525937e-02f, -7.09964037e-02f, -7.90363699e-02f, -3.46885890e-01f,
  1.65322304e-01f, -1.37261018e-01f, -8.68799537e-02f, 2.36050617e-02f, -2.56357282e-01f, -1.10568248e-01f, 5.46431728e-03f, 1.08315542e-01f, 8.65390673e-02f, -1.04981903e-02f,
  -8.46771449e-02f, -2.19978648e-03f, 5.44379000e-03f, -8.23941380e-02f, 8.43629017e-02f, 1.51136266e-02f, -1.45277664e-01f, 7.50672966e-02f, 1.84552446e-01f, -5.13038486e-02f,
  2.75122337e-02f, 2.96729952e-02f, 8.72940943e-02f, 1.39508530e-01f, 9.81115028e-02f, 1.08550340e-01f, -1.11032218e-01f, -1.50265777e-02f, -1.31806120e-01f, 1.88005902e-02f,
  1.21961802e-01f, -1.56375304e-01f, 4.37375531e-02f, 3.64957303e-02f, -5.14040254e-02f, 8.37634578e-02f, -5.10218330e-02f, 7.45737227e-03f, 4.83141420e-03f, 1.04624983e-02f,
  -8.91330093e-02f, -5.60337268e-02f, 3.40062976e-02f, -3.98741625e-02f, -2.40349136e-02f, 4.10512416e-03f, -2.55333539e-02f, -1.34519057e-03f, 6.32724538e-02f, 6.59981519e-02f,
  -1.02094248e-01f, -3.15414406e-02f, 8.85399505e-02f, 1.12341881e-01f, -2.29692683e-02f, 2.31164694e-02f, 6.58974051e-02f, 9.16245803e-02f, 1.62240312e-01f, 1.01494364e-01f,
  1.98269216e-03f, -2.73727067e-02f, 2.70771608e-02f, -2.67394036e-02f, 9.05473754e-02f, 1.22535778e-02f, -6.54729456e-02f, 4.24556360e-02f, 3.17744911e-02f, 1.24400817e-01f,
  1.63247064e-02f, 2.62200870e-02f, 5.29325046e-02f, 1.24257907e-01f, 4.42714840e-02f, -5.18255308e-02f, 1.06769539e-01f, 9.32998434e-02f, 1.21556729e-01f, 9.11989808e-02f,
  1.01509690e-01f, 5.34041449e-02f, 1.18077852e-01f, 1.59649998e-01f, 5.29501634e-03f, 2.79896315e-02f, -1.11881077e-01f, -4.64819595e-02f, -4.49967571e-02f, -3.44236963e-03f,
  2.76376456e-01f, -2.39378050e-01f, 1.66996360e-01f, -1.52616892e-02f, 8.00234918e-03f, 7.68214911e-02f, -2.47615967e-02f, 1.66093409e-02f, -5.45037575e-02f, 2.40981616e-02f,
  -4.48513888e-02f, 1.34147644e-01f, -8.39090645e-02f, -1.00928485e-01f, 2.34499294e-02f, -5.31358235e-02f, -9.11076665e-02f, 4.85600457e-02f, 1.11156583e-01f, 5.98476715e-02f,
  8.41457844e-02f, 1.17184915e-01f, 1.49869367e-01f, 1.73769191e-01f, -2.58301664e-02f, 5.70912063e-02f, 1.32837147e-01f, 1.69231430e-01f, 1.95229858e-01f, 2.57621706e-01f,
  -1.19749621e-01f, -7.26363137e-02f, -4.36474144e-01f, -3.46329033e-01f, -2.27915451e-01f, -1.60110101e-01f, -8.32729638e-02f, 1.17350169e-01f, 7.94521123e-02f, -4.89338748e-02f,
  -1.89050436e-01f, -1.07287643e-02f, -4.97472212e-02f, -5.90078086e-02f, -9.97999609e-02f, -7.46992379e-02f, -1.54975057e-01f, -1.73313215e-01f, -3.31047922e-01f, -1.67884484e-01f,
  -5.12428954e-02f, -1.41824678e-01f, -1.64697707e-01f, -2.11800821e-02f, 4.66073453e-02f, -1.77778322e-02f, -2.29326621e-01f, -1.95853263e-01f, 3.87867838e-02f, -7.97201917e-02f,
  -3.01310927e-01f, -1.02802075e-01f, -1.39923453e-01f, -1.06265590e-01f, -1.53560176e-01f, -1.98325049e-02f, -5.04155010e-02f, -8.47385526e-02f, 5.87912612e-02f, -1.05575785e-01f,
  -2.93202847e-01f, -1.29799962e-01f, -1.42299190e-01f, -1.38439119e-01f, -1.75012439e-01f, -1.36522055e-01f, -4.80125919e-02f, -1.56922057e-01f, -1.20790601e-01f, -7.45086893e-02f,
  -7.39744082e-02f, -1.55566916e-01f, -7.14763924e-02f, -3.73490937e-02f, -6.35673627e-02f, -8.45200419e-02f, -2.30141953e-02f, -1.23866517e-02f, -1.15787834e-01f, 1.27395943e-01f,
  3.76199409e-02f, 2.65974794e-02f, -1.17219295e-02f, -3.59440185e-02f, 5.56743927e-02f, 5.49346842e-02f, -1.59198213e-02f, 1.15269469e-02f, 1.00831063e-02f, 2.73271296e-02f,
  1.51196038e-02f, 4.96148765e-02f, 9.58288647e-03f, 3.14702764e-02f, 3.08034513e-02f, 6.45107850e-02f, 1.09659724e-01f, 6.85599968e-02f, 5.55960424e-02f, 7.47884288e-02f,
  -2.59784032e-02f, 4.17002290e-02f, 5.25104553e-02f, 4.23279628e-02f, -4.82257716e-02f, -2.24100091e-02f, 2.12229565e-02f, -3.08522508e-02f, 1.80257801e-02f, -1.26194153e-02f,
  -2.16336995e-02f, -4.17645127e-02f, 7.30480105e-02f, 2.39514019e-02f, -6.99844658e-02f, 2.58001965e-02f, -4.47220169e-02f, -1.52723314e-02f, -8.84108692e-02f, 4.01576469e-03f,
  -2.77794246e-02f, -6.95321187e-02f, -7.58731216e-02f, -4.03281674e-02f, -4.91471589e-02f, -6.90853298e-02f, 2.98004448e-02f, -1.01921327e-01f, -2.30625588e-02f, -2.10229307e-02f,
  1.54977164e-03f, -5.08983657e-02f, 4.88062948e-02f, 7.15361908e-02f, 3.40595506e-02f, -6.06066957e-02f, -1.37350394e-03f, 5.29234074e-02f, 4.46240120e-02f, 2.43492484e-01f,
  7.27729142e-01f, -5.27538538e-01f, 5.92759298e-03f, 7.19008502e-04f, -1.12175375e-01f, 2.86812009e-03f, -1.22903496e-01f, 5.32411709e-02f, 1.38249710e-01f, -1.93268850e-01f,
  -1.96542904e-01f, 8.00300911e-02f, -8.03643614e-02f, -3.28684086e-03f, 1.95457384e-01f, -2.09393010e-01f, -1.48477450e-01f, 3.19280922e-01f, 5.40779889e-01f, 2.63224512e-01f,
  -1.26746356e-01f, -9.47867334e-02f, 1.65637136e-01f, 1.10621482e-01f, -2.28539586e-01f, 1.29778787e-01f, -1.57076970e-01f, -9.30231959e-02f, -7.14051798e-02f, -2.49036059e-01f,
  -3.00512135e-01f, -1.67589933e-01f, 1.14419222e-01f, 4.55005746e-03f, -6.85973093e-02f, 1.13575295e-01f, 4.54237722e-02f, -4.03055251e-02f, 1.32595925e-02f, 1.06342649e-02f,
  -1.02831520e-01f, 7.40545010e-03f, -2.12329607e-02f, -3.27659175e-02f, 3.02245207e-02f, -8.41079466e-03f, -2.82975584e-02f, 8.78349245e-02f, 8.34730640e-02f, 2.11871509e-02f,
  -1.76522762e-01f, -8.12648088e-02f, -2.88615413e-02f, -3.06141954e-02f, 1.01815403e-01f, -3.49505711e-03f, -1.05885930e-01f, 1.23418337e-02f, 9.68355536e-02f, -1.58469766e-01f,
  1.35596506e-02f, -8.47893357e-02f, 4.62538525e-02f, -2.67865453e-02f, 9.67902131e-03f, 3.58349010e-02f, -2.08499897e-02f, 4.24881885e-03f, -3.19747999e-02f, -1.83364581e-02f,
  1.57056767e-02f, -7.97166023e-03f, -2.34090034e-02f, 1.31391222e-03f, -6.41011372e-02f, -6.31350651e-02f, -1.24702137e-02f, -1.50203751e-02f, -3.25233825e-02f, 1.41728129e-02f,
  -1.54754650e-02f, -4.19206498e-03f, -4.43357639e-02f, -4.21544025e-03f, -6.79370165e-02f, 1.31600440e-01f, 4.41102460e-02f, 2.39691008e-02f, 1.13077201e-02f, -7.02424496e-02f,
  -1.50091320e-01f, 9.39408466e-02f, 5.08552650e-03f, -4.10823412e-02f, -2.16428023e-02f, 5.15345745e-02f, -6.53068498e-02f, 3.00719347e-02f, -4.21594940e-02f, 3.09074689e-02f,
  5.24180382e-02f, 1.41510993e-01f, -4.17383313e-02f, 4.31182198e-02f, 9.41511020e-02f, 6.39804006e-02f, -3.16654220e-02f, 2.13875212e-02f, 3.82081768e-03f, -5.92372864e-02f,
  1.12092113e-02f, 6.69541284e-02f, 3.90108414e-02f, -5.05199358e-02f, -7.63654858e-02f, 8.22617337e-02f, -5.46452552e-02f, -3.48894745e-02f, 1.79166436e-01f, 4.30060700e-02f,
  3.02414089e-01f, 5.12151241e-01f, -3.21846992e-01f, 2.40904674e-01f, 4.84430566e-02f, -1.69139922e-01f, 7.82966241e-02f, -8.42367765e-03f, 1.89697724e-02f, 1.30622223e-01f,
  1.09964572e-01f, -8.33563805e-02f, -2.29173124e-01f, -2.71222979e-01f, -2.42793262e-01f, -1.85916841e-01f, -1.52176321e-01f, -3.24476153e-01f, -4.21291381e-01f, -1.99154139e-01f,
  -3.87575738e-02f, 1.58158466e-01f, 6.58890530e-02f, -5.20416684e-02f, 1.65879294e-01f, -1.27189636e-01f, 1.62178934e-01f, 1.95353329e-01f, 1.51711166e-01f, 2.44712219e-01f,
  -1.09892868e-01f, 3.86397123e-01f, -1.84956953e-01f, 8.20790455e-02f, 2.77282186e-02f, 8.31096545e-02f, 9.29838978e-03f, 5.82552664e-02f, 1.03432909e-01f, 4.36644070e-02f,
  6.43109903e-02f, 3.62374149e-02f, 3.94531805e-03f, 5.36581874e-02f, 1.44731835e-01f, -6.14852132e-03f, 4.59648520e-02f, -4.17149775e-02f, -6.52685389e-02f, 1.49901047e-01f,
  9.66081768e-02f, 1.55513704e-01f, 1.27299353e-01f, -1.78621653e-02f, -3.40001173e-02f, -8.53764713e-02f, 1.43289983e-01f, 4.00277153e-02f, 2.32441202e-02f, 1.98516160e-01f,
  -3.12512256e-02f, -1.08285099e-02f, 1.55135232e-04f, 5.65706640e-02f, -6.86030649e-03f, 4.61361445e-02f, 2.67726593e-02f, 6.73591299e-03f, -9.20237154e-02f, -2.85547692e-02f,
  2.09934581e-02f, -7.10372850e-02f, 1.81077812e-02f, 2.48307977e-02f, 8.44137371e-02f, -2.35116966e-02f, 1.16752740e-02f, 2.85858251e-02f, 6.33995906e-02f, 7.44906217e-02f,
  -5.98762445e-02f, 1.04967030e-02f, 1.06198639e-02f, 4.18280717e-03f, -3.01750619e-02f, 1.71163250e-02f, -3.97836715e-02f, 1.80678796e-02f, -7.24746585e-02f, -5.24153523e-02f,
  6.83383867e-02f, -2.37721950e-01f, -5.16372398e-02f, -8.71821120e-02f, 5.47932759e-02f, -2.59936694e-02f, 1.15454034e-03f, 8.93106963e-03f, 6.26662821e-02f, 1.93747822e-02f,
  -1.69133898e-02f, -5.10415509e-02f, 1.38445888e-02f, -6.67220652e-02f, 5.13916020e-04f, -5.87124825e-02f, 2.05324218e-02f, -3.49926911e-02f, -1.78439859e-02f, 5.17411940e-02f,
  6.63002580e-02f, 5.24836080e-03f, -1.12328745e-01f, -4.11596000e-02f, 1.25889247e-02f, -1.50730893e-01f, -1.24683857e-01f, -2.95453519e-02f, -2.32351243e-01f, -7.66083691e-03f,
  2.62973551e-02f, 3.24488699e-01f, 3.68338749e-02f, 9.19910073e-02f, 3.67023386e-02f, 2.31557731e-02f, 1.63910359e-01f, 3.11954338e-02f, -4.38585430e-02f, 1.49930790e-01f,
  -4.10229154e-02f, -2.82371640e-01f, -2.46627927e-01f, -1.02170452e-01f, 5.49258851e-03f, 3.55983824e-01f, 2.44142547e-01f, -5.77849112e-02f, -2.01783255e-01f, -5.93332015e-03f,
  2.14949787e-01f, 2.24705189e-01f, 7.29770586e-02f, 2.10863706e-02f, 2.30604336e-01f, -1.52792737e-01f, 8.20935667e-02f, 4.16494980e-02f, -7.66116828e-02f, 3.18508923e-01f,
  -3.31278029e-03f, 1.88358799e-01f, -6.77313805e-02f, -7.26870596e-02f, -3.52284797e-02f, 2.36590263e-02f, -5.99635765e-03f, 5.58985882e-02f, -8.51822086e-03f, 7.78439939e-02f,
  1.07221760e-01f, 6.19258359e-02f, 3.33228707e-02f, 2.55339518e-02f, -2.88300030e-02f, 7.97127038e-02f, -3.16391923e-02f, 1.50883660e-01f, 7.13958144e-02f, 4.78787422e-02f,
  1.62358761e-01f, 1.00680619e-01f, 1.31815568e-01f, 8.43469650e-02f, 2.71034241e-02f, -1.03850268e-01f, 1.26095369e-01f, -6.60527721e-02f, 2.63278168e-02f, 6.29933998e-02f,
  8.04128274e-02f, -2.44438183e-03f, -3.56834270e-02f, 7.11015910e-02f, 1.87511593e-02f, -1.02313690e-01f, 5.77112287e-02f, 5.27685098e-02f, -3.24781053e-02f, -5.01789302e-02f,
  -7.75142089e-02f, -4.59365873e-03f, 4.88570370e-02f, 6.20396286e-02f, 2.34366842e-02f, 5.75967766e-02f, 1.27885845e-02f, 6.69853240e-02f, 3.10426904e-03f, -7.87349567e-02f,
  1.23705352e-02f, -7.36916438e-02f, 7.59182777e-03f, 5.72756082e-02f, -3.01349908e-02f, 4.84033022e-03f, 3.12331356e-02f, -6.35485500e-02f, -8.49020574e-03f, 6.01762570e-02f,
  -1.46987149e-02f, -1.53250203e-01f, 5.56765683e-02f, -1.56943388e-02f, 3.17453519e-02f, -1.16327122e-01f, 2.73790956e-02f, 9.85532906e-03f, 2.01975759e-02f, 6.19547889e-02f,
  6.84698019e-03f, -4.80204150e-02f, -4.71730009e-02f, 1.48357395e-02f, 3.87518592e-02f, 1.67947798e-03f, -8.01946595e-03f, -3.51169929e-02f, 3.81667688e-02f, 9.10607055e-02f,
  9.09983665e-02f, 1.30577028e-01f, -7.17687160e-02f, -5.81024587e-02f, -8.22213292e-03f, 4.01886776e-02f, -4.90745576e-03f, 1.75089687e-02f, -3.33415419e-02f, 1.40071735e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.65087008e-01f, -5.26437163e-01f, -1.27158150e-01f, -3.28267813e-02f, -1.40023947e-01f, 2.06336882e-02f, -5.53818464e-01f, -6.93526790e-02f, 2.69017398e-01f, -6.57507420e-01f,
  -3.59846175e-01f, 3.20246249e-01f, 1.14142587e-02f, 6.24155551e-02f, 3.62557173e-02f, -5.87467134e-01f, -3.60777199e-01f, 1.90256938e-01f, 5.73165715e-01f, 3.46776605e-01f,
  7.80900847e-03f, 1.86857954e-01f, 3.31621349e-01f, 2.05385670e-01f, -2.13775605e-01f, 3.55748683e-02f, -2.76674658e-01f, 4.08716649e-02f, -1.92557111e-01f, -4.90074039e-01f,
  -2.66319126e-01f, -1.51742980e-01f, 9.24852267e-02f, 2.07207814e-01f, -1.11821175e-01f, -5.61323315e-02f, -2.31484268e-02f, -1.42688230e-01f, -1.21917343e-02f, -4.81123989e-03f,
  -4.73893471e-02f, -1.20944316e-02f, 1.39937669e-01f, -8.44840929e-02f, -9.81595963e-02f, 1.01318434e-01f, -1.56384340e-04f, 3.07191797e-02f, -1.64601937e-01f, -1.06553078e-01f,
  -4.00562435e-02f, -1.74236279e-02f, 8.48252401e-02f, -9.34435204e-02f, 1.43761691e-02f, 1.24323308e-01f, 7.07764328e-02f, 1.48378477e-01f, -1.01494305e-02f, -3.06664526e-01f,
  -8.78978074e-02f, -6.25835545e-03f, -3.97048481e-02f, -5.91788255e-02f, 6.20033452e-03f, -2.06376426e-02f, 3.62383649e-02f, -6.02325387e-02f, 2.16293894e-02f, 2.20526438e-02f,
  -2.90568899e-02f, -3.80632514e-03f, 5.61571755e-02f, -9.72025990e-02f, 3.91608253e-02f, 9.39889625e-02f, -5.75542748e-02f, -4.17568795e-02f, -4.40325662e-02f, 4.95574214e-02f,
  -9.01251752e-03f, 1.16378821e-01f, -3.98541167e-02f, 6.13170080e-02f, -1.05803505e-01f, -4.79272231e-02f, 1.58540253e-02f, 2.35184189e-02f, 6.82505816e-02f, 5.39827608e-02f,
  1.16372257e-01f, 1.81794271e-01f, -2.46630147e-01f, -6.57164492e-03f, -4.34329510e-02f, -1.18864916e-01f, -3.27729136e-02f, 6.70598149e-02f, 3.30978781e-02f, -1.09077420e-03f,
  1.03111312e-01f, -1.38751760e-01f, -1.27429679e-01f, -3.37779187e-02f, 1.13994487e-01f, -7.70439208e-03f, -1.84199259e-01f, 2.61523444e-02f, 1.86451718e-01f, 1.34314626e-01f,
  -9.08726733e-03f, -7.71107152e-02f, -5.41501492e-02f, 3.61031666e-02f, 7.80193284e-02f, 4.44682539e-02f, -9.30693932e-03f, -1.59660071e-01f, -8.19163099e-02f, -4.54276919e-01f,
  5.09165883e-01f, -3.60054612e-01f, 1.75431073e-01f, 4.48034823e-01f, 2.11926535e-01f, 2.45341852e-01f, 1.13744386e-01f, 1.66451156e-01f, 3.57290894e-01f, 2.14520961e-01f,
  1.86242617e-03f, 1.43402383e-01f, 1.82820752e-01f, 4.70476002e-02f, 8.76143798e-02f, 2.05475539e-01f, 1.98365852e-01f, 1.05671801e-01f, 2.13652551e-01f, 1.57254964e-01f,
  2.14026645e-01f, 1.82246771e-02f, -8.38916451e-02f, 1.25845522e-01f, -1.00553945e-01f, 2.20225066e-01f, -5.45213521e-02f, -1.78430527e-01f, -1.25334188e-01f, -7.96550363e-02f,
  -8.13752785e-02f, -1.37927324e-01f, 2.43957490e-01f, 2.49105152e-02f, -1.84826210e-01f, -1.22104593e-01f, 1.29233807e-01f, -8.60884134e-03f, 5.79040535e-02f, -6.58971211e-03f,
  6.17702864e-02f, -1.47834048e-01f, -1.89127207e-01f, -1.29478037e-01f, -9.39072669e-03f, -8.77139568e-02f, -8.05524886e-02f, -5.19329356e-03f, 1.38621211e-01f, -9.31915119e-02f,
  -4.14886326e-02f, 7.70860761e-02f, 7.38243312e-02f, 1.47914410e-01f, 1.17654279e-02f, 9.23151001e-02f, -1.41556393e-02f, -6.70441985e-02f, 1.10852927e-01f, 1.93413034e-01f,
  1.40676290e-01f, 1.61729023e-01f, 2.20935438e-02f, 3.99289988e-02f, -6.04320206e-02f, 6.16440214e-02f, -1.56957462e-01f, 2.40694117e-02f, 8.43973234e-02f, -1.07244439e-01f,
  -7.05887191e-03f, 1.18936025e-01f, 2.19728842e-01f, 9.11655650e-03f, 5.32304905e-02f, -2.53141038e-02f, -1.64104719e-02f, -1.80522084e-01f, -2.11166367e-01f, -2.95049362e-02f,
  -1.08779036e-01f, 1.27156854e-01f, -8.92234445e-02f, -1.56232953e-01f, -8.88363943e-02f, 2.40722355e-02f, 7.45061710e-02f, -9.38527882e-02f, -2.86591519e-02f, 6.97391257e-02f,
  1.54145554e-01f, 1.59175019e-03f, 1.97214819e-03f, 1.17960125e-01f, -5.18475054e-03f, -2.59872228e-01f, 8.49712119e-02f, 9.27761663e-03f, -4.58299182e-02f, 1.05385058e-01f,
  -7.03738332e-02f, -8.12780559e-02f, -1.57384455e-01f, -1.48264572e-01f, -2.92457938e-02f, 2.51371111e-03f, -8.67957249e-02f, 2.00031191e-01f, 3.01211756e-02f, 5.36708487e-03f,
  -1.48709387e-01f, 2.13112846e-01f, 1.93979815e-01f, 1.96677372e-01f, 2.07029894e-01f, 1.21641390e-01f, -3.19026597e-02f, 1.78409535e-02f, 1.00002564e-01f, 3.68957222e-02f,
  -7.09696233e-01f, 2.89655216e-02f, -2.21673083e-02f, -2.34693270e-02f, 1.40799001e-01f, 1.54086664e-01f, 4.98458833e-01f, 2.38042593e-01f, 1.45490402e-02f, -5.61839230e-02f,
  -3.06091487e-01f, -2.34693184e-01f, -7.77930766e-02f, 3.12378984e-02f, 9.37665924e-02f, 2.59218037e-01f, 3.67394954e-01f, -1.76887363e-02f, -1.54709890e-01f, 4.83410843e-02f,
  1.85157686e-01f, -6.88048662e-04f, -3.47550839e-01f, -3.19606364e-02f, 1.19995907e-01f, 1.66927621e-01f, 1.03047386e-01f, 2.60626655e-02f, -8.97969492e-03f, 1.90167382e-01f,
  -6.58222854e-01f, -1.44641012e-01f, 1.12155721e-01f, -6.38884231e-02f, -1.09087586e-01f, -1.34801239e-01f, 4.07763496e-02f, -1.10258825e-01f, -7.20406026e-02f, -2.35004891e-02f,
  -9.62448716e-02f, -1.15796663e-01f, -1.72223486e-02f, 4.29360792e-02f, -3.52295414e-02f, 1.25613417e-02f, -7.21928552e-02f, -1.63819958e-02f, 8.26101527e-02f, -1.20951988e-01f,
  2.92174011e-01f, -6.36892170e-02f, -7.36179799e-02f, 1.43436193e-01f, 1.94139659e-01f, -9.88818035e-02f, -8.56298804e-02f, -8.73511732e-02f, 4.77173692e-03f, -1.79036766e-01f,
  -2.17182711e-02f, -1.38320267e-01f, -1.49358302e-01f, -4.33601253e-02f, 1.84351392e-02f, -3.54631525e-03f, 2.61744764e-03f, -2.25724224e-02f, 1.89395417e-02f, 4.15718481e-02f,
  -5.40695852e-03f, 9.28350724e-03f, -5.80843771e-03f, -8.74542072e-03f, -5.34998178e-02f, 5.01018204e-02f, 5.10801710e-02f, 1.23572230e-01f, -1.25475109e-01f, 3.94711308e-02f,
  -1.78239737e-02f, 7.59950504e-02f, -3.55383405e-03f, -1.70996841e-02f, 1.46401733e-01f, 9.49578658e-02f, -4.92641889e-02f, 4.53776680e-04f, -7.76858404e-02f, 8.65720138e-02f,
  -6.69371635e-02f, 1.17851987e-01f, -1.06445439e-01f, 1.17388912e-01f, -9.45321247e-02f, -1.50830373e-01f, -1.45370901e-01f, -1.57473341e-01f, -7.03168213e-02f, -3.45275644e-03f,
  9.34279785e-02f, -9.20874253e-02f, 2.52238922e-02f, -5.40110432e-02f, -4.51010242e-02f, 6.88634580e-03f, 7.13637695e-02f, -5.03939092e-02f, 2.86483974e-03f, 2.04972047e-02f,
  1.51269197e-01f, 2.37337857e-01f, -5.81710786e-03f, 1.38793737e-01f, -7.84174129e-02f, -5.01184762e-02f, -4.36867550e-02f, -7.67316744e-02f, 6.37154207e-02f, -2.19113007e-02f,
  -8.81753266e-01f, -4.85415459e-01f, 6.63425505e-01f, -5.92938960e-01f, 2.80381173e-01f, 4.36950117e-01f, 4.38928246e-01f, -5.66333309e-02f, -2.46285826e-01f, -3.37063745e-02f,
  -2.83074230e-01f, -3.63418877e-01f, -2.86466956e-01f, -9.17338952e-02f, -4.13508750e-02f, 5.06222248e-01f, 4.59541470e-01f, 2.40210965e-01f, 3.81512374e-01f, 3.45136821e-01f,
  9.88223627e-02f, -2.24065721e-01f, -4.57862735e-01f, -1.03899531e-01f, -2.96977967e-01f, -3.32788862e-02f, -4.11930552e-04f, -1.42561823e-01f, 7.57596940e-02f, -1.89205155e-01f,
  3.80858511e-01f, -2.61888653e-01f, -2.70167869e-02f, -2.16288105e-01f, -4.86688092e-02f, -1.63701683e-01f, 3.15728113e-02f, -4.05963063e-02f, -1.67369679e-01f, -2.50620302e-02f,
  -1.85979202e-01f, -7.86732957e-02f, -1.03165857e-01f, -3.06463353e-02f, -1.04971260e-01f, -3.90732102e-03f, -2.03216344e-01f, -8.61389413e-02f, -2.38598939e-02f, 5.54629005e-02f,
  2.29328889e-02f, 5.29324114e-02f, 6.17916733e-02f, 7.83593208e-02f, -4.22027484e-02f, 2.23222934e-02f, -1.29933417e-01f, 4.22210582e-02f, -3.97166200e-02f, -1.48703549e-02f,
  3.51327248e-02f, 4.19650152e-02f, 7.82237947e-02f, -5.49324714e-02f, -7.62783810e-02f, 3.70748836e-04f, 4.90664393e-02f, -1.14653576e-02f, 4.16060118e-03f, 4.06531319e-02f,
  -1.26419086e-02f, 5.01284860e-02f, 2.46670153e-02f, -1.24596015e-01f, -1.75149366e-02f, -8.22343677e-02f, 5.17760701e-02f, -1.27834827e-01f, -6.29026955e-03f, -1.06159449e-01f,
  -4.29061316e-02f, 3.78789492e-02f, -3.35302539e-02f, 4.96305004e-02f, -7.26429000e-02f, -4.17403355e-02f, 7.66838714e-03f, -4.57084216e-02f, 8.47900212e-02f, 1.25138564e-02f,
  2.22862158e-02f, 1.57304462e-02f, 1.19701847e-02f, -1.47911474e-01f, 3.21588106e-02f, -9.79940072e-02f, -5.55058531e-02f, -6.82255030e-02f, 8.40091854e-02f, 5.79340421e-02f,
  -4.86562289e-02f, -1.18254758e-01f, -8.98158774e-02f, -2.05234401e-02f, 1.18834570e-01f, 2.42053741e-03f, -1.01999976e-01f, -1.02008050e-02f, 9.75435134e-03f, -4.14106483e-03f,
  -3.84421535e-02f, 1.03160143e-01f, 9.13725868e-02f, 1.51057035e-01f, 5.31320050e-02f, 2.04916641e-01f, 1.92173749e-01f, 1.23643808e-01f, 1.18676350e-01f, 1.58813521e-01f,
  -6.89522699e-02f, -2.26503983e-01f, 3.03499818e-01f, 2.35723898e-01f, -1.21683083e-01f, -3.12481731e-01f, -5.56234777e-01f, -2.34258622e-01f, 7.76522560e-03f, -8.93969908e-02f,
  -1.74776718e-01f, 1.02205642e-01f, 1.50868848e-01f, 9.46781784e-02f, -2.26212054e-01f, 8.14141482e-02f, 3.36400062e-01f, 4.37313795e-01f, -8.71637613e-02f, -1.37720168e-01f,
  1.23703718e-01f, 2.07784221e-01f, 3.96936536e-02f, 8.75656214e-03f, 2.74642766e-01f, -6.34798706e-02f, 1.02362419e-02f, 1.17535226e-01f, -9.21176746e-03f, 9.19129312e-01f,
  2.76644230e-01f, -8.67051482e-02f, -1.27737626e-01f, -5.77638261e-02f, 1.82473566e-02f, 3.59970108e-02f, -5.78763895e-02f, 1.59251615e-01f, 5.44103421e-02f, 8.93018916e-02f,
  8.98306519e-02f, -2.48786509e-02f, -2.31779683e-02f, -5.38559295e-02f, -2.32458368e-01f, 7.34054819e-02f, 1.50169700e-01f, 1.96474448e-01f, -5.37443608e-02f, -1.62701383e-01f,
  1.63936719e-01f, -2.26834845e-02f, -2.10722789e-01f, -2.97434986e-01f, -1.58168867e-01f, 2.44360641e-01f, -2.18314648e-01f, -6.40606806e-02f, -2.21761853e-01f, 2.04543293e-01f,
  -1.85596999e-02f, 1.65395543e-03f, -5.25411628e-02f, 3.26489210e-02f, -5.17926849e-02f, -1.16632618e-02f, 1.27477944e-01f, -8.10606629e-02f, -3.29942852e-02f, -4.87649627e-02f,
  -4.42823730e-02f, 6.98915496e-02f, 7.97134191e-02f, -5.45365848e-02f, -5.45343570e-02f, 4.60249633e-02f, -1.48080513e-02f, -1.23852655e-01f, -1.58484802e-01f, -8.05965289e-02f,
  -6.28147647e-02f, -3.76189724e-02f, 6.58990368e-02f, 3.00602075e-02f, 4.74678818e-03f, 7.16332197e-02f, 7.60655925e-02f, 1.59498677e-02f, -2.29540765e-02f, 9.99025479e-02f,
  -1.18037879e-01f, -3.13350618e-01f, 3.56027335e-02f, 2.95863729e-02f, 5.40184081e-02f, -4.31731045e-02f, 1.22736543e-01f, 4.35294770e-02f, 7.28803053e-02f, -1.10989429e-01f,
  2.85095610e-02f, -7.13078752e-02f, 1.60315782e-02f, -4.57153060e-02f, -1.49639308e-01f, -9.63031128e-03f, -1.35453299e-01f, 6.60941899e-02f, 7.60698542e-02f, 1.27287926e-02f,
  -9.66039523e-02f, -3.32988948e-01f, -3.91127467e-01f, -9.95041057e-02f, -5.40482476e-02f, -3.60438704e-01f, -1.36896148e-01f, -1.44746855e-01f, -3.73637259e-01f, -3.37469012e-01f,
  -8.93989801e-02f, -4.00552243e-01f, 3.56150419e-01f, 4.73526381e-02f, -1.57855779e-01f, -2.22023040e-01f, -5.29707670e-01f, -2.17898846e-01f, -5.81597202e-02f, -7.92843774e-02f,
  1.63757503e-01f, 3.01161170e-01f, 2.93260604e-01f, 2.83147842e-01f, 1.75260201e-01f, -4.61940281e-02f, 7.54813775e-02f, 3.98590744e-01f, 3.30373943e-01f, 3.12459022e-02f,
  1.50762731e-02f, 2.20504533e-02f, 2.35231489e-01f, 2.97624111e-01f, 1.04098648e-01f, 2.83634871e-01f, 6.43659234e-02f, 7.64214024e-02f, 5.60856573e-02f, 3.68693203e-01f,
  1.78021938e-01f, -3.73050004e-01f, -8.45146074e-04f, -1.14996083e-01f, -4.74007167e-02f, -1.70828551e-01f, -3.91432382e-02f, -8.50382149e-02f, -1.86937317e-01f, 4.51105498e-02f,
  -2.01718397e-02f, -1.36389643e-01f, -8.95908475e-02f, 2.32906677e-02f, -8.43728855e-02f, -1.17499102e-02f, 4.30354412e-04f, 6.25673458e-02f, 1.00209497e-01f, -1.42907724e-01f,
  -1.34967435e-02f, 7.55030364e-02f, 9.13234949e-02f, 3.83908153e-02f, -3.63535360e-02f, 8.39092806e-02f, 3.31184119e-02f, 1.18666276e-01f, 5.67520484e-02f, 3.32223624e-03f,
  1.81503624e-01f, 1.55136958e-01f, 2.06810221e-01f, 5.13459221e-02f, 8.37272629e-02f, -1.25136897e-01f, 5.13733514e-02f, 1.90581393e-03f, 1.96912855e-01f, 7.25833848e-02f,
  5.57922497e-02f, 5.24604544e-02f, -3.16045992e-02f, 2.06891615e-02f, 9.51245204e-02f, 5.95553555e-02f, 2.02054027e-02f, 6.89961910e-02f, 1.48941725e-01f, 7.37943575e-02f,
  5.18391617e-02f, -5.40767647e-02f, -2.82231700e-02f, 1.24337906e-02f, -1.09402589e-01f, 6.36604130e-02f, -5.49239293e-03f, -1.15091898e-01f, -2.43464783e-02f, -2.96434481e-02f,
  -1.57829791e-01f, 2.75285125e-01f, 1.17052138e-01f, 1.56789850e-02f, 5.00974618e-03f, -5.29916696e-02f, 1.19260535e-01f, -4.15206999e-02f, -4.17714417e-02f, -7.12655708e-02f,
  -1.12888783e-01f, 5.41373976e-02f, -5.09545114e-03f, 1.39976048e-03f, 4.49075922e-03f, -8.88616778e-03f, 4.26229127e-02f, -4.14135866e-02f, -1.23800114e-01f, 2.53872462e-02f,
  7.24536926e-02f, -3.44851427e-02f, -1.25841498e-01f, -6.18320256e-02f, -7.98982233e-02f, 6.70173839e-02f, 6.83025420e-02f, -6.61723688e-02f, -5.14636934e-02f, -1.23056650e-01f,
  -1.03218722e+00f, -2.13333696e-01f, -1.81107730e-01f, -2.02825129e-01f, 3.77093703e-01f, 1.89095438e-01f, -2.86536515e-01f, -1.35775357e-01f, 1.28102591e-02f, -6.73253983e-02f,
  1.08374000e-01f, 4.71222401e-02f, -7.68676698e-02f, 1.56246424e-01f, -1.34794831e-01f, -6.21840805e-02f, 7.79403821e-02f, -2.38218248e-01f, -1.85531884e-01f, 2.76445955e-01f,
  4.53680843e-01f, -1.40728310e-01f, -4.58503783e-01f, -9.74286273e-02f, -7.03109428e-02f, -1.35291770e-01f, -2.01394305e-01f, -1.82390720e-01f, -5.06662726e-02f, -6.47977144e-02f,
  -3.09315383e-01f, -2.13009328e-01f, 3.67189229e-01f, -1.77913532e-02f, -8.72854069e-02f, -8.14346969e-02f, -9.39429477e-02f, -1.51946470e-01f, -1.39010223e-02f, 1.42507687e-01f,
  1.32065028e-01f, 2.35066041e-01f, 7.61052966e-02f, 1.70143560e-01f, -4.01045121e-02f, 8.29492509e-03f, 1.85625836e-01f, -1.36197088e-02f, -1.69949099e-01f, -7.69112781e-02f,
  1.83442131e-01f, -8.92665982e-03f, -2.96262711e-01f, 1.78732842e-01f, 4.22277004e-02f, 2.84009147e-03f, 2.54506990e-02f, 5.78990355e-02f, -2.40945578e-01f, -4.62228745e-01f,
  1.54548809e-01f, -3.48955095e-02f, 1.44322380e-01f, 6.04619877e-03f, -3.84023748e-02f, 5.48050627e-02f, -6.69490546e-02f, 8.24093819e-02f, 5.19559532e-02f, -1.68108761e-01f,
  -7.40269721e-02f, 3.14367912e-03f, 6.35432079e-02f, -4.96982075e-02f, -9.73655283e-02f, 1.40730646e-02f, -8.53887796e-02f, -2.37748027e-02f, 6.06886111e-02f, 9.39163417e-02f,
  -5.99556081e-02f, 3.78890149e-02f, 8.92960802e-02f, 1.66719943e-01f, 2.79604703e-01f, -1.18560657e-01f, -6.57224655e-02f, -4.75799758e-03f, -8.39671195e-02f, 5.32605499e-02f,
  -4.13152665e-01f, 1.20679602e-01f, -2.48067945e-01f, 4.66698296e-02f, 1.97777022e-02f, 1.15088359e-01f, -1.21692397e-01f, 1.05700068e-01f, -7.11892545e-02f, 5.16605191e-02f,
  5.93572445e-02f, -1.10121720e-01f, 1.80707816e-02f, 9.61913262e-03f, -2.39562783e-02f, -2.36548879e-03f, 1.15096703e-01f, -1.18223585e-01f, -1.54559702e-01f, 1.18098907e-01f,
  -4.06359769e-02f, -1.31620526e-01f, -3.90803903e-01f, -2.20058650e-01f, -3.26890387e-02f, -2.23831028e-01f, -2.39216030e-01f, -2.10542664e-01f, -3.32146496e-01f, -9.89764810e-01f,
  -2.26437047e-01f, 2.08355021e-02f, 2.65740514e-01f, -1.26979023e-01f, -2.72315532e-01f, -2.63319790e-01f, -2.45291919e-01f, -1.50474414e-01f, -8.37092772e-02f, 7.27984980e-02f,
  1.32329851e-01f, 2.12794170e-01f, 2.88520962e-01f, 9.63160023e-02f, -8.00595246e-03f, -5.46348952e-02f, -1.72734827e-01f, 7.31193200e-02f, 1.03135772e-01f, -4.13841642e-02f,
  -4.20810767e-02f, -2.07787737e-01f, -1.94304198e-01f, 4.21760604e-02f, 1.60972938e-01f, 2.67071724e-01f, 4.13608514e-02f, -1.99862659e-01f, -4.65899566e-03f, 7.93783516e-02f,
  8.56574118e-01f, 1.63570920e-03f, 9.26618204e-02f, -4.37420979e-02f, -6.20663576e-02f, 1.20968167e-02f, 9.58035812e-02f, 6.38436079e-02f, -6.82690516e-02f, 4.43365313e-02f,
  6.64709955e-02f, -6.62253872e-02f, -1.57746986e-01f, 5.58235077e-03f, -6.67425096e-02f, 7.31358305e-02f, -1.26615196e-01f, 8.50374158e-03f, 3.69451754e-02f, 8.06665123e-02f,
  -1.17975064e-02f, 3.94778103e-02f, 5.85347004e-02f, -3.57539095e-02f, -1.46698922e-01f, 3.17530185e-02f, -2.27981247e-02f, -4.30820473e-02f, 7.23732561e-02f, -2.56359391e-02f,
  -1.61204934e-01f, 2.17895433e-02f, 1.98946774e-01f, 4.37066406e-02f, -1.83877945e-02f, -2.93199178e-02f, 2.35761907e-02f, -3.04795839e-02f, -1.41004279e-01f, -7.91762322e-02f,
  -6.58537745e-02f, 1.38924032e-01f, -3.32503691e-02f, -5.70059791e-02f, 1.90273777e-01f, 1.41345030e-02f, -7.30380416e-03f, 5.79326004e-02f, 4.23275493e-03f, -1.99854270e-01f,
  -6.42526895e-02f, -6.98665082e-02f, 1.03933007e-01f, 1.37484893e-01f, 6.73601404e-03f, 1.03283279e-01f, -7.27420812e-03f, 1.16348021e-01f, -1.56812727e-01f, -1.41057163e-01f,
  4.09567773e-01f, -1.01634391e-01f, 7.46457651e-02f, -3.04610487e-02f, -7.46023282e-02f, 3.64988670e-02f, 2.50738114e-01f, 8.14440027e-02f, 1.89258959e-02f, 6.45604581e-02f,
  8.35685208e-02f, 1.13029458e-01f, 6.55935556e-02f, -4.51946594e-02f, -4.45445329e-02f, 6.60223663e-02f, -5.27855083e-02f, -3.51448730e-02f, 4.16025482e-02f, 1.62775099e-01f,
  -2.86727361e-02f, 2.21330002e-02f, 1.63685113e-01f, 6.53186813e-02f, -1.55475751e-01f, 9.88403186e-02f, 2.51916826e-01f, 1.67759910e-01f, 1.34260818e-01f, -2.91787293e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  2.33367562e-01f, -3.22584242e-01f, 1.61818713e-01f, 4.55302924e-01f, 2.94321328e-01f, 6.03302598e-01f, 3.66929770e-01f, 2.61281580e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  6.28354922e-02f, -2.18160870e-03f, -1.05217636e-01f, 3.26036066e-02f, -1.31971195e-01f, 8.74601230e-02f, 1.03046373e-01f, -1.36393249e-01f, -1.20473728e-01f, 2.62476522e-02f,
  -2.00558249e-02f, -7.53424391e-02f, 4.83124936e-03f, 7.49382079e-02f, 1.68304265e-01f, 1.60669252e-01f, -1.06745623e-01f, 1.67570367e-01f, -2.30422616e-01f, -1.58198431e-01f,
  7.17424080e-02f, -4.04931337e-01f, 1.09427892e-01f, 1.23500347e-01f, -4.94094074e-01f, 2.55205005e-01f, 1.65510148e-01f, 3.53448302e-01f, -3.49338770e-01f, -1.12411685e-01f,
  8.54865555e-03f, 9.68133733e-02f, 8.02955776e-02f, 5.46360910e-02f, -1.36559427e-01f, 1.54976798e-02f, -3.77343409e-02f, 7.85215572e-02f, 9.53069329e-02f, 5.19108437e-02f,
  -5.71225435e-02f, -1.95571646e-01f, -1.85697213e-01f, 1.08176962e-01f, 5.99990375e-02f, -8.31777379e-02f, -1.48635805e-01f, -3.30281407e-02f, 8.96257758e-02f, 6.05533756e-02f,
  6.58272998e-03f, -1.02590993e-01f, 1.28602251e-01f, 1.18382238e-01f, 6.31146431e-02f, -4.08949070e-02f, 3.81937176e-01f, -2.55984552e-02f, -4.02458698e-01f, -3.48365843e-01f,
  4.20844294e-02f, 2.03469560e-01f, 5.70180314e-03f, 2.17411324e-01f, 8.54944140e-02f, 1.06498770e-01f, 1.27391517e-01f, 5.01600765e-02f, -6.78766295e-02f, -6.51632473e-02f,
  -1.93723552e-02f, 2.05576673e-01f, -9.33689848e-02f, 2.89240599e-01f, 5.45572452e-02f, 6.07511122e-03f, 9.11037773e-02f, -5.89584671e-02f, 2.68747527e-02f, 9.85120833e-02f,
  -4.31496352e-02f, 1.12722799e-01f, 7.57278875e-02f, -5.07078879e-02f, 1.56026095e-01f, -1.28880396e-01f, 2.33550638e-01f, 3.94237041e-02f, 5.22336662e-01f, 3.19857784e-02f,
  -4.11272675e-01f, -5.54230034e-01f, 4.32764515e-02f, 1.68011919e-01f, -1.86790258e-01f, 1.40000284e-01f, -5.88534400e-02f, 8.89688209e-02f, -6.91896006e-02f, 1.09917060e-01f,
  9.26029757e-02f, -9.11634136e-03f, -5.83342426e-02f, -1.94297433e-01f, -4.75115180e-02f, -3.33284825e-01f, 4.53006737e-02f, -5.43983839e-03f, 1.30016319e-02f, -1.52756214e-01f,
  -3.74195427e-02f, -8.60152319e-02f, -9.51991901e-02f, -1.63996831e-01f, 1.00991614e-01f, -2.75155082e-02f, -2.62057573e-01f, 2.76318192e-01f, -6.74921274e-02f, -5.67374900e-02f,
  -3.41051520e-04f, 1.14118375e-01f, 1.83259770e-01f, 9.66128036e-02f, 5.01443148e-02f, -2.10887596e-01f, 2.50345934e-02f, 1.98627576e-01f, 2.64785402e-02f, 1.14682823e-01f,
  2.75440440e-02f, 9.24803913e-02f, 2.48023778e-01f, 1.63471475e-02f, 2.21683547e-01f, -7.98724890e-02f, -1.49217278e-01f, 5.50336353e-02f, 8.05835426e-02f, 9.42189395e-02f,
  -2.44119778e-01f, 1.58167481e-01f, -8.00661892e-02f, -5.90344518e-02f, -2.43086323e-01f, 1.36379331e-01f, -1.74975756e-03f, -1.47465672e-02f, 8.04649740e-02f, 7.69422129e-02f,
  3.49252522e-02f, -4.97412011e-02f, 2.07573399e-01f, -2.05614686e-01f, -1.34421140e-01f, -5.89181371e-02f, -3.40172529e-01f, -1.53134882e-01f, 1.98145866e-01f, -8.39045048e-02f,
  1.49247870e-01f, 2.25610156e-02f, -1.04699515e-01f, -1.22012356e-02f, 6.60106987e-02f, 1.21459909e-01f, 2.30665505e-01f, -6.36903197e-02f, -5.50097600e-02f, -1.10377990e-01f,
  1.93238437e-01f, 3.21698368e-01f, -7.66002340e-03f, -3.98005284e-02f, -1.37433931e-01f, -1.45648448e-02f, -1.33235157e-01f, 2.59208441e-01f, -1.44391045e-01f, 1.46262854e-01f,
  4.67032529e-02f, 2.30502531e-01f, -1.85713947e-01f, -1.35578990e-01f, 2.76555074e-04f, 2.06003428e-01f, -3.64233434e-01f, 1.95103139e-01f, -5.28693557e-01f, -2.43067816e-01f,
  -7.90482983e-02f, 2.40471229e-01f, -4.69016060e-02f, -6.10354617e-02f, -3.33009660e-02f, -4.08768207e-02f, -1.99589401e-01f, 3.52131017e-02f, -8.70477334e-02f, -1.77553013e-01f,
  1.32107884e-02f, -1.28465429e-01f, -6.86981231e-02f, -1.48744807e-02f, -6.68958714e-03f, 1.15402704e-02f, -3.99594344e-02f, 3.26732136e-02f, -3.06572895e-02f, -1.09981056e-02f,
  3.65321785e-02f, -1.24374725e-01f, -2.85470486e-02f, 3.90414037e-02f, -3.65475900e-02f, -1.05967335e-01f, -2.51218706e-01f, 1.89502984e-01f, 1.80221915e-01f, 8.30854625e-02f,
  -5.23689985e-01f, 1.37625458e-02f, -2.48702705e-01f, -3.37848663e-01f, 8.00381675e-02f, 1.31187007e-01f, 4.36469875e-02f, -2.36961525e-03f, -2.14919299e-01f, 2.11454853e-01f,
  2.21156348e-02f, 5.49077615e-02f, -2.08309203e-01f, 9.35810059e-02f, -1.83998179e-02f, 2.54752934e-01f, 5.89477196e-02f, -4.81763110e-02f, 1.18654542e-01f, 1.78249702e-01f,
  9.26923603e-02f, 3.63286138e-01f, -2.89333075e-01f, -1.79851755e-01f, 2.98628718e-01f, -4.66584980e-01f, 4.66658294e-01f, 7.34837949e-02f, -3.25681984e-01f, -8.17724094e-02f,
  -7.03764781e-02f, -3.98884416e-01f, 1.90929949e-01f, 1.06447442e-02f, 1.37271145e-02f, -1.15712188e-01f, 6.05728887e-02f, 2.40095764e-01f, 9.98270661e-02f, 5.53783327e-02f,
  -4.24467921e-02f, -8.78463238e-02f, 1.40624776e-04f, 1.43185675e-01f, 6.27837330e-02f, 1.11508563e-01f, 3.05210501e-02f, -2.53805867e-03f, 1.14620039e-02f, -1.90179765e-01f,
  -1.63382694e-01f, -1.03697173e-01f, -2.78825462e-01f, -1.17285736e-01f, 1.20592359e-02f, 1.29113093e-01f, -7.59800673e-02f, 3.83813143e-01f, 7.19377398e-02f, -1.21995127e-02f,
  4.32584256e-01f, 2.88683921e-01f, -2.00921014e-01f, -8.07526782e-02f, -2.10640579e-01f, 6.59407349e-03f, -2.17324674e-01f, -8.48993734e-02f, 5.76075725e-02f, 6.14997707e-02f,
  9.42364037e-02f, -1.81912452e-01f, -3.30503434e-02f, -7.22944885e-02f, -3.10816735e-01f, 1.31735578e-01f, -2.85559762e-02f, 1.17435001e-01f, -1.06325753e-01f, -5.76364286e-02f,
  3.58836204e-02f, 1.47359390e-02f, 1.44627132e-02f, 6.95699826e-03f, -1.72567107e-02f, -5.32212332e-02f, -1.33881778e-01f, 4.82932776e-02f, 6.48944899e-02f, -6.25946879e-01f,
  5.58373749e-01f, 2.74201870e-01f, -3.89901638e-01f, -8.49117264e-02f, 3.60901058e-01f, -4.90319848e-01f, 4.19765741e-01f, -1.03205882e-01f, -7.88341239e-02f, -4.19352464e-02f,
  -5.02345264e-02f, -7.15107983e-03f, 1.01163704e-02f, -1.06705956e-01f, 6.27053678e-02f, 1.55500919e-02f, 1.30675198e-03f, 1.01853460e-01f, -4.60677780e-02f, 2.39905491e-01f,
  3.68973278e-02f, 4.43741865e-02f, 1.67161524e-01f, -4.71786521e-02f, 2.52329167e-02f, 3.47867832e-02f, -1.15365498e-02f, 7.18542608e-03f, -2.47897506e-01f, 6.03685854e-03f,
  -1.27983660e-01f, -3.31495315e-01f, 3.48661631e-01f, 2.23544478e-01f, -5.69777787e-01f, -1.29380107e-01f, 5.04143357e-01f, -4.36593033e-02f, 3.81036639e-01f, -8.83300304e-02f,
  5.59936315e-02f, -3.52710411e-02f, 1.79963008e-01f, 1.56320363e-01f, 8.24179947e-02f, 1.84922162e-02f, 2.17923239e-01f, 2.87739411e-02f, 2.31891319e-01f, -6.76286742e-02f,
  6.99396580e-02f, 5.52977715e-03f, 5.72777987e-02f, 2.03086987e-01f, -1.60501450e-02f, -2.29241431e-01f, -2.72735626e-01f, -9.53782573e-02f, -1.66912898e-01f, -6.39427379e-02f,
  6.92204311e-02f, 4.96877730e-02f, -1.67352676e-01f, 5.47790825e-01f, -3.80232841e-01f, -1.47383213e-01f, 3.84970963e-01f, -1.18691958e-01f, -2.52772570e-01f, -5.64673729e-03f,
  8.03031400e-02f, 1.20570816e-01f, -4.36319768e-01f, -1.89523827e-02f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  2.07354538e-02f, -1.26640081e-01f, 2.23598838e-01f, 8.39589834e-02f, 4.35688943e-01f, 1.26544669e-01f, -1.19309738e-01f, 3.10710855e-02f, 3.46687883e-01f, -1.14177495e-01f,
  2.80406564e-01f, 1.59577981e-01f, 2.00762808e-01f, -2.23000064e-01f, 2.27063447e-01f, -3.45172167e-01f, -1.08478203e-01f, -4.72948283e-01f, -5.53027801e-02f, 4.73997444e-02f,
  -1.96150854e-01f, -1.81906242e-02f, -2.77823001e-01f, 1.93796292e-01f, -2.28593946e-01f, -1.26689881e-01f, 4.52578813e-01f, 8.08574438e-01f, 2.17859432e-01f, -4.85696010e-02f,
  2.29931414e-01f, -2.24107541e-02f, -8.43272135e-02f, -1.26097158e-01f, -2.21683919e-01f, 1.25644296e-01f, 2.97007412e-01f, 5.21267764e-02f, 1.11432113e-02f, 4.84872907e-02f,
  8.33592713e-02f, 9.48856622e-02f, 1.80907205e-01f, 1.28213644e-01f, -4.74956539e-03f, 8.28939229e-02f, 1.84320092e-01f, -1.43525731e-02f, -5.19480892e-02f, -5.04385456e-02f,
  -2.40404025e-01f, 1.03145152e-01f, -1.36088669e-01f, 1.39656916e-01f, -3.90245058e-02f, 1.69554785e-01f, -5.97084165e-01f, 2.94916540e-01f, 6.27473474e-01f, 3.20863843e-01f,
  -1.32772043e-01f, 1.13147378e-01f, 3.04132044e-01f, -1.94220379e-01f, 5.12543283e-02f, -7.74089396e-02f, 2.44735584e-01f, 6.53966069e-02f, 4.57456946e-01f, 1.21410862e-01f,
  4.07132685e-01f, -6.59690350e-02f, -1.47070348e-01f, 1.87552467e-01f, 4.28255081e-01f, 3.23897868e-01f, -1.44027963e-01f, 1.78976238e-01f, 1.43362999e-01f, -1.51912272e-01f,
  -1.16647510e-02f, 2.91482955e-01f, -1.61606878e-01f, -2.18625709e-01f, 1.95416451e-01f, 4.23863791e-02f, -1.68162793e-01f, -2.05048308e-01f, 6.70718133e-01f, 2.01792166e-01f,
  6.22116387e-01f, -3.43980849e-01f, -1.60583228e-01f, -1.06513500e-01f, 6.62894607e-01f, -4.30287383e-02f, 2.90144503e-01f, 1.35216534e-01f, 2.08906591e-01f, 2.97812611e-01f,
  1.17955588e-01f, 2.02164546e-01f, 2.96676308e-01f, -1.98867932e-01f, 2.07656622e-01f, 3.31617534e-01f, 9.80363861e-02f, 2.69865066e-01f, -1.87529460e-01f, 4.90927398e-01f,
  6.80635631e-01f, 3.92822251e-02f, -1.20299086e-01f, 2.65161600e-03f, -3.58083993e-01f, 1.79242175e-02f, 2.20296070e-01f, -7.09356487e-01f, -5.10670364e-01f, -3.18980634e-01f,
  2.49830142e-01f, -3.82655889e-01f, -1.82541490e-01f, 6.20067656e-01f, 1.67996645e-01f, 4.88152772e-01f, 4.71509278e-01f, 3.12255859e-01f, 1.67630032e-01f, -2.97060698e-01f,
  2.60065799e-03f, -1.90343484e-01f, -1.96705647e-02f, 3.08942765e-01f, 3.73051703e-01f, 6.38422295e-02f, -6.15119860e-02f, -5.89561686e-02f, 5.97066805e-02f, 2.41401270e-01f,
  -3.33981216e-01f, 4.99736995e-01f, 4.40650374e-01f, -1.52935326e-01f, 5.71081936e-01f, 1.84250385e-01f, -1.42416239e-01f, -3.42951089e-01f, -1.73318591e-02f, -6.43335342e-01f,
  -2.55462140e-01f, 6.17397949e-02f, 5.12325168e-01f, -2.01679602e-01f, 4.23459977e-01f, 3.03451508e-01f, 1.71716079e-01f, 9.74912792e-02f, 7.37916887e-01f, -4.52684611e-01f,
  2.84218580e-01f, 2.20014304e-01f, 7.25625008e-02f, 3.37153643e-01f, 6.18015468e-01f, 2.16859415e-01f, 3.04455429e-01f, -6.27053902e-02f, -7.35415667e-02f, 6.08043373e-01f,
  3.64722520e-01f, 5.11247873e-01f, 3.01025007e-02f, -1.67048022e-01f, -2.79278189e-01f, 2.41326690e-01f, -4.71609294e-01f, 1.48822010e-01f, -5.69938362e-01f, 3.01963717e-01f,
  6.11528046e-02f, 4.98653591e-01f, -7.00423941e-02f, 1.76765267e-02f, 1.71126425e-02f, -1.58789605e-01f, 1.60733506e-01f, 4.71850663e-01f, -3.77642632e-01f, -3.71045738e-01f,
  -8.54489654e-02f, -1.76467419e-01f, -4.53806818e-02f, 1.05530269e-01f, -8.76654685e-02f, 1.01400778e-01f, 1.93261966e-01f, 2.07092427e-02f, 2.41529062e-01f, 1.82460900e-02f,
  -7.13349283e-02f, -4.19586301e-02f, 2.01240212e-01f, 7.88004696e-02f, -1.10951364e-01f, -1.29221633e-01f, -2.66259253e-01f, -2.81209588e-01f, -8.19454435e-04f, -3.79173577e-01f,
  2.73243666e-01f, 2.31387436e-01f, -1.78854927e-01f, 5.45645475e-01f, -4.95935321e-01f, -6.83986023e-02f, 4.61319804e-01f, 9.09094885e-02f, 3.15997303e-01f, -1.28885895e-01f,
  3.84595126e-01f, 6.88815832e-01f, 6.41262084e-02f, -1.62529409e-01f, 1.07758380e-02f, 3.72871786e-01f, 5.24317622e-01f, 1.77090168e-01f, 1.88638031e-01f, 2.37332597e-01f,
  -3.53891760e-01f, 1.49224818e-01f, 3.24534148e-01f, 2.30918527e-01f, -2.97910497e-02f, 2.68082976e-01f, 1.87580436e-01f, -4.69411999e-01f, -2.83228811e-02f, -1.41588822e-01f,
  5.25148362e-02f, -5.18994868e-01f, 7.30087698e-01f, -2.52864093e-01f, -2.81529188e-01f, -3.40611339e-01f, 1.72912240e-01f, 3.52170378e-01f, -1.56468287e-01f, -3.29884857e-01f,
  4.43436980e-01f, 1.46144241e-01f, 4.36111033e-01f, 2.29372755e-01f, 8.11163858e-02f, -5.28349042e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  -2.85500791e-02f, 1.81087196e-01f, 2.81663418e-01f, 2.11515576e-01f, -1.66943565e-01f, 3.14575523e-01f, 9.65710133e-02f, -3.31361853e-02f
};

// L2_fan_Wp (Shape: 12 x 32)
const int L2_fan_Wp_rows = 12;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -3.32264036e-01f, 2.16121554e-01f, 1.01428717e-01f, 3.47642779e-01f, -9.62710828e-02f, -5.23257293e-02f, 3.41781490e-02f, -6.44336417e-02f, -1.86300483e-02f, 1.35524683e-02f,
  -3.93015482e-02f, -1.43234372e-01f, 2.73102373e-01f, -4.66873020e-01f, -2.00634494e-01f, -1.82200596e-01f, 1.40751302e-01f, 5.28765842e-02f, 1.98547572e-01f, -2.78058788e-03f,
  4.17063206e-01f, -3.68833989e-01f, -1.27142742e-01f, 1.92013741e-01f, -7.52787711e-03f, 1.38154775e-01f, -1.78625673e-01f, 1.54164732e-01f, -1.79042086e-01f, 3.33390385e-01f,
  -1.87958896e-01f, 1.85794570e-02f, -2.18624379e-02f, -1.69937104e-01f, -2.37229154e-01f, -7.62922317e-03f, 2.10206538e-01f, -6.78521022e-02f, 2.20487759e-01f, -8.79873522e-03f,
  6.93308488e-02f, -3.94192375e-02f, 6.98483437e-02f, -4.72104669e-01f, 2.96955734e-01f, 1.05856538e-01f, -2.90804654e-01f, 3.85351509e-01f, -9.51007083e-02f, 3.57426673e-01f,
  1.00186333e-01f, 1.29851297e-01f, -4.72795665e-01f, -4.69166249e-01f, 1.03178233e-01f, -7.33472705e-02f, 4.81691323e-02f, -9.89402458e-02f, -2.31988534e-01f, 2.13384032e-01f,
  8.58436003e-02f, 6.61405921e-02f, 1.41725048e-01f, -4.73005116e-01f, -5.19896626e-01f, -4.16480638e-02f, -1.41902491e-01f, 1.07112303e-02f, 1.59443468e-01f, -1.54358312e-01f,
  -7.35050999e-03f, -5.79469316e-02f, 2.04436481e-02f, -8.28840211e-02f, -5.18977158e-02f, -5.14925569e-02f, -1.63384318e-01f, 5.74042916e-01f, 6.27597988e-01f, 1.23352809e-02f,
  -1.03151366e-01f, -1.51344076e-01f, -3.45343292e-01f, -2.62012333e-01f, 4.07796763e-02f, -1.67542949e-01f, -2.62079775e-01f, -1.47601739e-01f, -7.76035264e-02f, -2.56434441e-01f,
  8.28832462e-02f, 1.62225038e-01f, -1.86109304e-01f, -3.26540053e-01f, 1.60285190e-01f, 1.11689538e-01f, 7.23521933e-02f, -2.92801522e-02f, 2.39015877e-01f, -2.75752455e-01f,
  6.66771382e-02f, -4.22993973e-02f, 2.49832839e-01f, 1.34037822e-01f, 6.50331378e-02f, 5.05368151e-02f, 3.29963416e-02f, -2.48188283e-02f, 1.94236469e-02f, 1.86537668e-01f,
  1.95621461e-01f, -1.95939898e-01f, -3.69013548e-01f, -4.25641567e-01f, 1.61176383e-01f, 2.81404942e-01f, -2.29605123e-01f, 2.25522950e-01f, 5.81732579e-02f, -1.99395537e-01f,
  1.55598685e-01f, -1.13307359e-02f, -2.64925838e-01f, 3.49307507e-02f, -9.29546431e-02f, -2.35590935e-01f, 1.65133865e-03f, 3.20475221e-01f, -2.46450260e-01f, -2.80711204e-02f,
  2.70820647e-01f, 5.16004637e-02f, -7.42825046e-02f, 8.49878192e-02f, 1.05443053e-01f, 1.60161838e-01f, 1.75008088e-01f, 8.00440535e-02f, -2.16878489e-01f, 2.94583291e-01f,
  -3.07994664e-01f, -3.53065282e-02f, 5.15730739e-01f, -2.30636999e-01f, 2.10317910e-01f, -6.02128446e-01f, -1.07120141e-01f, -2.28976473e-01f, 5.33494711e-01f, 1.21688217e-01f,
  -4.79297817e-01f, -2.49719605e-01f, 1.84778184e-01f, -6.25562891e-02f, 1.16341151e-01f, -1.26958385e-01f, 6.16178364e-02f, -2.49602139e-01f, -1.22930333e-01f, 2.77272880e-01f,
  -3.24273050e-01f, -1.82122976e-01f, 3.54773462e-01f, 5.79197779e-02f, -5.97135834e-02f, 1.20907262e-01f, -4.24216181e-01f, -1.35309160e-01f, -1.04127936e-01f, 4.05140519e-02f,
  2.14218289e-01f, 3.90990645e-01f, -4.89532128e-02f, 2.60411978e-01f, 3.25573206e-01f, -1.25926659e-01f, 6.91656396e-02f, -1.50261581e-01f, -3.29550683e-01f, -1.92786977e-01f,
  -2.08521128e-01f, -1.78655863e-01f, -2.33816132e-01f, 1.79412693e-01f, 2.56949425e-01f, -4.33508068e-01f, -7.55980089e-02f, 1.78714529e-01f, 1.96797118e-01f, -3.16445798e-01f,
  -1.25453979e-01f, -1.32499754e-01f, 6.01687580e-02f, 2.63583869e-01f, 3.83861661e-01f, 9.95358452e-02f, 2.76729614e-01f, -1.75037086e-01f, -1.82504818e-01f, 5.02695441e-02f,
  2.30200052e-01f, 1.20623320e-01f, 4.19583082e-01f, 2.23144889e-01f, 3.39656353e-01f, -3.63812037e-02f, 2.93395191e-01f, 1.10798396e-01f, -1.93512723e-01f, -7.37737864e-02f,
  -2.40015209e-01f, 1.78919867e-01f, -2.96850175e-01f, 9.69646871e-02f, 2.88647205e-01f, -9.33958311e-03f, -1.99859943e-02f, -3.48958164e-01f, -3.22060138e-01f, 2.50897557e-01f,
  -3.95838171e-02f, -2.41138354e-01f, -3.71325277e-02f, 1.38496920e-01f, 2.94975549e-01f, 2.48066097e-01f, 1.57698065e-01f, -2.19937205e-01f, 4.16681916e-01f, 3.70536149e-02f,
  4.05048430e-01f, -1.12967826e-01f, -5.21703586e-02f, 1.51521116e-01f, 3.12272429e-01f, 1.20123029e-01f, 1.66709498e-01f, -3.44209492e-01f, -2.36471713e-01f, 2.99093783e-01f,
  1.39243811e-01f, 5.42165153e-02f, 3.37277234e-01f, 1.73917621e-01f, -4.54054743e-01f, -2.04757154e-01f, 2.09354073e-01f, 5.15353940e-02f, 2.00055897e-01f, 2.13648558e-01f,
  -2.15483569e-02f, 2.77072698e-01f, -1.22767851e-01f, 1.04119740e-01f, -6.28937259e-02f, -2.10804030e-01f, -7.00605094e-01f, -2.37353280e-01f, -2.47610763e-01f, -9.78969485e-02f,
  -2.86175787e-01f, -2.10471615e-01f, -4.53307837e-01f, -1.13470696e-01f, -2.40994737e-01f, -2.88919836e-01f, -6.92465976e-02f, 2.49010436e-02f, -3.44972759e-01f, 7.87486732e-02f,
  -2.34155178e-01f, 6.95070997e-02f, 1.32113740e-01f, 2.41676182e-01f, -3.84606481e-01f, -2.69663751e-01f, 8.47636089e-02f, -3.83001834e-01f, -2.28494734e-01f, 2.71016359e-01f,
  9.03941095e-02f, -1.97543859e-01f, -6.75010234e-02f, 1.12120092e-01f, 4.32253703e-02f, 1.69991091e-01f, 4.79497761e-02f, -2.63637573e-01f, -3.34652930e-01f, -6.51442409e-02f,
  3.82164270e-02f, -1.06623024e-02f, 1.35534242e-01f, -7.83541501e-02f, -1.89128831e-01f, 8.79637748e-02f, 2.72704244e-01f, -4.21591759e-01f, 2.32779309e-02f, 9.73280147e-02f,
  4.55556773e-02f, -9.44833979e-02f, -7.26745948e-02f, -2.69469202e-01f, -1.94335014e-01f, -2.73844659e-01f, 7.33572692e-02f, -4.19499636e-01f, 4.01429206e-01f, 2.67184302e-02f,
  -4.97866690e-01f, 1.31780565e-01f, 2.97196627e-01f, -2.35422328e-01f, -1.95418328e-01f, -2.94347465e-01f, -6.02979306e-03f, -2.49372702e-02f, 3.77839692e-02f, 6.52355790e-01f,
  2.07143292e-01f, 4.89681102e-02f, -7.77413771e-02f, -1.47119880e-01f, -3.51278216e-01f, 2.16723412e-01f, 9.06129926e-02f, -1.59096733e-01f, -2.81173825e-01f, -9.42365080e-02f,
  1.05006054e-01f, -4.55268584e-02f, -2.87994463e-02f, 1.05868578e-01f, -1.95751354e-01f, 2.64550507e-01f, 2.23771468e-01f, 4.22180533e-01f, -1.52454391e-01f, 6.36990741e-02f,
  4.84486930e-02f, -1.12850599e-01f, 1.57157898e-01f, -4.15496081e-02f, 1.62744358e-01f, 2.06357077e-01f, 8.06285962e-02f, -1.07692413e-01f, 2.37782270e-01f, 4.07782853e-01f,
  -1.24389432e-01f, -4.39641148e-01f, -4.71046984e-01f, 6.99287653e-02f, 5.84865659e-02f, -3.28915060e-01f, -3.21180075e-01f, -2.59195119e-01f, -4.53356616e-02f, 8.11900869e-02f,
  -2.10927203e-01f, -2.81359881e-01f, -2.94879764e-01f, -1.83618844e-01f, 2.55663753e-01f, 6.87938929e-02f, -1.19728424e-01f, 1.58235982e-01f, -1.67079717e-01f, -4.17022794e-01f,
  1.76254883e-02f, -2.99306601e-01f, 1.34058565e-01f, -1.45801336e-01f, -4.75043833e-01f, -2.79680341e-01f, 1.40418783e-01f, 2.50367038e-02f, 1.08920090e-01f, 4.55570705e-02f,
  -1.94117829e-01f, -3.77396733e-01f, 2.49043599e-01f, 1.95345014e-01f
};

// L2_fan_Wp_bar (Shape: 8 x 32)
const int L2_fan_Wp_bar_rows = 8;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  6.64903283e-01f, 7.98520744e-02f, 5.91525972e-01f, 4.59857732e-01f, 6.57119215e-01f, 6.14791453e-01f, 8.33508447e-02f, -2.24975478e-02f, 2.50300229e-01f, 4.99484032e-01f,
  4.27432239e-01f, 4.71703827e-01f, -1.53166428e-01f, 3.75942104e-02f, 2.11642921e-01f, -4.68134314e-01f, 4.78496164e-01f, -4.56710637e-01f, 5.52661419e-01f, 3.67544323e-01f,
  2.69381553e-01f, -4.65820640e-01f, -1.70737877e-01f, 4.04949427e-01f, -2.52326906e-01f, -5.58676660e-01f, 1.89391971e-01f, 5.35509348e-01f, 3.20120931e-01f, 3.78692836e-01f,
  -2.14082360e-01f, 1.16648525e-01f, 7.80471385e-01f, 1.98868722e-01f, 3.60417873e-01f, -3.42346914e-02f, 4.44897003e-02f, 6.67943895e-01f, 1.81141913e-01f, 1.15500741e-01f,
  2.98860908e-01f, 4.26442295e-01f, 1.73580945e-01f, 3.15371245e-01f, 7.82537758e-02f, 4.77952808e-02f, -1.15766039e-03f, -1.12143926e-01f, 5.66445291e-01f, 6.62622213e-01f,
  -5.34166694e-02f, 1.61683306e-01f, -2.10818931e-01f, 1.45237846e-03f, 4.17879187e-02f, -4.86023694e-01f, -3.78005952e-02f, 1.49713770e-01f, 6.13927424e-01f, 3.02250564e-01f,
  6.80391788e-01f, 8.44165869e-03f, -3.94072235e-01f, -1.32001734e+00f, -5.05355716e-01f, -1.09414913e-01f, -1.76644713e-01f, 3.68062258e-02f, -1.82068646e-01f, -4.45015490e-01f,
  5.91918528e-02f, 2.94779480e-01f, -1.14086628e-01f, -4.43253994e-01f, -2.26368815e-01f, -6.82917535e-01f, 1.24226987e-01f, -3.90653431e-01f, -8.26309741e-01f, 4.23282921e-01f,
  -1.30877361e-01f, -2.52120018e-01f, -2.65316457e-01f, -6.52449667e-01f, 3.36936563e-01f, -4.34410810e-01f, -5.16825438e-01f, -1.92506209e-01f, 7.56159723e-01f, 4.79708344e-01f,
  2.58589923e-01f, 4.74792242e-01f, 4.47262645e-01f, 5.42863727e-01f, 4.11581397e-01f, -1.11966245e-01f, -5.15394509e-02f, 1.84539169e-01f, 7.47497305e-02f, 1.11698039e-01f,
  1.02816291e-01f, 8.33639279e-02f, -5.85950613e-01f, -1.95542593e-02f, 4.43726510e-01f, 2.43285120e-01f, 4.89921540e-01f, 6.32737994e-01f, 3.09099797e-02f, 2.62342989e-01f,
  -2.09836796e-01f, -2.79187202e-01f, -1.55528728e-02f, -9.14546773e-02f, -5.16096354e-01f, 1.67326555e-01f, -6.51572049e-01f, -1.64727136e-01f, 4.53092605e-02f, -1.32663622e-01f,
  1.63282827e-01f, -3.83261472e-01f, 1.89725384e-01f, 9.50941801e-01f, 9.97557282e-01f, 2.59144127e-01f, -2.34191224e-01f, -2.12839305e-01f, -7.96963274e-01f, 3.36467087e-01f,
  1.79382131e-01f, 5.58052778e-01f, 2.18191981e-01f, -4.41696495e-01f, -3.69549125e-01f, 4.15053159e-01f, -5.20651042e-02f, -9.99149457e-02f, 2.87149400e-01f, -6.56205788e-02f,
  -5.86693957e-02f, 4.30233955e-01f, 6.21409535e-01f, 2.99408138e-01f, -4.20701206e-01f, 2.48045713e-01f, -6.34631276e-01f, -6.22228444e-01f, 4.92579281e-01f, -5.34151673e-01f,
  -3.56771320e-01f, 5.46355724e-01f, 1.33318886e-01f, -2.37568945e-01f, -4.47698906e-02f, 3.41684669e-01f, -4.90198046e-01f, 1.26282826e-01f, 5.30584514e-01f, 1.19765081e-01f,
  1.34111941e-01f, 6.04603827e-01f, 6.54841483e-01f, 3.39723170e-01f, 2.68577963e-01f, -3.55404943e-01f, 6.78895712e-01f, 2.86112487e-01f, 3.73158485e-01f, -2.05079570e-01f,
  -4.62687351e-02f, 2.48444423e-01f, 2.84736931e-01f, -5.59362888e-01f, -4.17425334e-01f, 4.86226439e-01f, -6.79539979e-01f, 2.32959807e-01f, -4.05332863e-01f, -4.36771251e-02f,
  3.51320684e-01f, -8.19153413e-02f, 2.38076270e-01f, 3.28864783e-01f, 5.24103701e-01f, 2.83515602e-01f, -1.20572597e-01f, 1.51535928e-01f, -6.97447419e-01f, 4.65280026e-01f,
  1.88617826e-01f, 5.33713996e-01f, -7.99020529e-02f, 1.61481634e-01f, 2.11820118e-02f, 6.44186318e-01f, -2.12115213e-01f, 2.63894409e-01f, 1.51395023e-01f, 3.03972095e-01f,
  2.32259914e-01f, 6.55457005e-02f, -2.75696427e-01f, -1.55223176e-01f, -2.02159449e-01f, 5.60937285e-01f, 6.39153779e-01f, 1.46831796e-01f, 4.49924707e-01f, 7.04426765e-01f,
  2.80401576e-02f, -8.22639465e-02f, 4.07213539e-01f, -2.68480390e-01f, -4.44873631e-01f, 5.50179422e-01f, -1.05034137e+00f, 1.56361654e-01f, 4.43635523e-01f, -2.63534904e-01f,
  -8.48580450e-02f, 5.69441378e-01f, 1.71166077e-01f, -9.09856498e-01f, 3.39834467e-02f, 7.73707151e-01f, 4.97571915e-01f, 3.42727929e-01f, 2.24310458e-01f, -9.89273936e-02f,
  3.81614357e-01f, 3.62369895e-01f, 4.62372988e-01f, 3.14762443e-01f, 4.71484959e-01f, 5.46732247e-01f, 3.64835769e-01f, -6.83517158e-01f, 5.58802523e-02f, -1.54963449e-01f,
  -8.08351338e-02f, 7.26667881e-01f, -3.18303555e-01f, 4.00976419e-01f, 6.54537797e-01f, -6.37586638e-02f, 5.23110926e-01f, 7.06853330e-01f, 3.67845148e-01f, 6.94412440e-02f,
  -2.57996440e-01f, 9.64624062e-02f, -8.59721422e-01f, 7.86656976e-01f, -2.19624981e-01f, 1.41805172e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 8)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 8;
const float L2_fan_Bp_bar_data[] = {
  1.47617891e-01f, 2.62093991e-01f, -2.41844565e-01f, 1.00549482e-01f, 2.19834894e-01f, 3.34230155e-01f, 1.24145456e-01f, 2.67126441e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.58778891e-01f, -1.80662215e-01f, -9.36007220e-03f, -5.83928585e-01f, -7.80233085e-01f, -3.14590037e-01f, -2.76509255e-01f, -4.74116541e-02f, -1.15910955e-01f, 3.21301252e-01f,
  1.94524556e-01f, 1.08592749e-01f, -1.28650486e-01f, -5.51363409e-01f, 4.02596146e-01f, 1.32111430e-01f, 9.22704041e-02f, 2.45079994e-01f, -1.10295820e+00f, -7.44266152e-01f,
  1.01853931e+00f, -3.76656890e-01f, 9.23437178e-02f, 2.91021258e-01f, 9.43184048e-02f, 1.31565928e-01f, -4.97067645e-02f, 2.80179352e-01f, -3.38859797e-01f, -1.01054239e+00f,
  2.56093234e-01f, -6.85936928e-01f, 1.69453353e-01f, 3.60834926e-01f, -3.04549262e-02f, -4.87481236e-01f, 2.05231920e-01f, 2.56380498e-01f, 1.57790948e-02f, 3.84446084e-01f,
  1.16475999e-01f, 1.27502605e-01f, 2.20312238e-01f, 2.15224504e-01f, 2.64958292e-01f, 1.93628803e-01f, 4.09978211e-01f, -3.40718001e-01f, -3.40755910e-01f, -5.19024611e-01f,
  -6.06246829e-01f, -1.41565166e-02f, 1.95238084e-01f, -3.40856224e-01f, 2.21389160e-01f, -3.42325628e-01f, -1.47111416e-01f, -3.39087099e-01f, 1.75468698e-01f, -7.84705102e-01f,
  5.13989747e-01f, -9.20419022e-02f, 7.91974187e-01f, -3.17184091e-01f, 3.17231089e-01f, 4.42862153e-01f, -3.16938430e-01f, 3.05982828e-01f, -5.28416872e-01f, -7.47185871e-02f,
  1.00579113e-01f, -1.80006787e-01f, 2.64391908e-03f, -4.81771529e-02f, -1.52912932e-02f, -5.11974692e-01f, 7.85696581e-02f, -1.79708436e-01f, 8.55189841e-03f, -5.44979572e-01f,
  2.71720558e-01f, 9.96294469e-02f, 1.69226319e-01f, -2.23659813e-01f, 5.51344216e-01f, 5.55002630e-01f, -4.03942168e-01f, 4.96602088e-01f, 3.16635430e-01f, -7.59440422e-01f,
  2.86830962e-01f, 1.77706137e-01f, 6.11674547e-01f, -9.69980359e-01f, -5.08811831e-01f, -7.03173518e-01f, 4.63411599e-01f, -5.38625002e-01f, -6.47352338e-01f, -4.46289778e-01f,
  2.81396747e-01f, 6.10579908e-01f, 5.14567673e-01f, -5.01842797e-01f, 4.24593627e-01f, -2.18829140e-01f, -9.34567273e-01f, 2.97703624e-01f, 6.32094860e-01f, 9.26068664e-01f,
  -6.03172183e-01f, -1.24103494e-01f, -7.94658661e-01f, -1.24744527e-01f, -6.38272226e-01f, -5.31799018e-01f, -9.71092284e-03f, 7.36967400e-02f, -5.41515589e-01f, -6.14313066e-01f,
  -1.80813402e-01f, 1.40124962e-01f, 2.57321894e-01f, 3.55669409e-01f, -1.27762151e+00f, -2.57847220e-01f, -6.19855225e-01f, -9.19292271e-02f, -3.22089761e-01f, 3.21500063e-01f,
  4.68079597e-01f, 6.77760720e-01f, 4.13411826e-01f, -6.30197525e-01f, 5.74351661e-02f, -2.12158948e-01f, -7.65117332e-02f, -5.32008231e-01f, 6.25753105e-01f, -3.31092745e-01f,
  -6.38415039e-01f, 4.21364933e-01f, 2.13151619e-01f, -3.99899781e-01f, 1.14575969e-02f, 5.26096165e-01f, 7.42747426e-01f, 8.61818492e-01f, -5.91502130e-01f, -3.51137035e-02f,
  3.62228692e-01f, -2.70305634e-01f, 2.08538279e-01f, 3.63130718e-01f, -4.22575921e-01f, 2.83006012e-01f, -4.18972939e-01f, -1.92974105e-01f, -3.77621442e-01f, -5.46454787e-01f,
  -1.01660907e-01f, 3.46733838e-01f, -7.10203452e-03f, 2.63830096e-01f, 3.89357865e-01f, -1.40499562e-01f, 5.41677415e-01f, -2.34523043e-01f, -9.43814963e-02f, -3.43987972e-01f,
  -6.21051006e-02f, -6.40919447e-01f, 2.37287030e-01f, -2.90294647e-01f, -3.46979171e-01f, -7.11929560e-01f, -6.67731231e-03f, -4.79861349e-01f, -2.10994214e-01f, 3.29841256e-01f,
  -5.49444258e-01f, -5.77610552e-01f, 4.34035867e-01f, 2.31697381e-01f, 1.56892121e-01f, 2.70684958e-01f, -6.08588815e-01f, -2.35843122e-01f, -2.66809821e-01f, -3.92273022e-03f,
  3.24072987e-01f, 6.22972131e-01f, 2.72363096e-01f, -4.29148644e-01f, -1.61732212e-01f, -4.14807141e-01f, -1.62216395e-01f, 4.13881689e-01f, -8.64082932e-01f, -3.79266255e-02f,
  2.56331146e-01f, -5.20734072e-01f, -1.41954079e-01f, 2.43600547e-01f, -6.53934300e-01f, -2.69318074e-01f, 7.28739202e-01f, 2.60238081e-01f, 3.71849239e-01f, 2.88807899e-01f,
  4.61708575e-01f, -6.71479106e-01f, -6.36669338e-01f, -4.17729914e-01f, -2.06204742e-01f, 2.80838311e-01f, -1.14689147e+00f, 1.51827475e-02f, -4.76863831e-01f, -4.70948607e-01f,
  5.64889014e-01f, 3.63155693e-01f, -1.68070167e-01f, 4.75964129e-01f, -7.11415559e-02f, 2.79992402e-01f, -1.85147494e-01f, 2.38207236e-01f, -2.19504178e-01f, -4.66058031e-02f,
  2.93451790e-02f, -3.50670191e-03f, -4.44868714e-01f, 1.80475906e-01f, 1.61195546e-01f, -5.86344361e-01f, -2.56821901e-01f, -3.39161754e-01f, -3.78115475e-01f, 5.54816484e-01f,
  4.54858482e-01f, -3.73932511e-01f, -4.21784043e-01f, 1.97749153e-01f, -2.23801211e-01f, 1.94842145e-01f, 3.33562046e-01f, 4.65173334e-01f, -6.54148161e-01f, -3.81286263e-01f,
  5.73198080e-01f, 2.36653481e-02f, -7.66995192e-01f, 2.51749277e-01f, 1.01406716e-01f, -5.73020220e-01f, -3.78089637e-01f, 5.63321169e-03f, -2.61557996e-01f, 1.03940696e-01f,
  -1.26144007e-01f, -2.44385481e-01f, 3.60595614e-01f, -7.39483237e-01f, 3.27862829e-01f, -4.21622805e-02f, -1.77307501e-01f, 2.62723416e-01f, 3.46975863e-01f, 7.31854022e-01f,
  -1.89695120e-01f, -5.23693383e-01f, -5.12555540e-01f, -4.56935227e-01f, -7.11878300e-01f, 1.19277082e-01f, 4.33679909e-01f, 7.79843748e-01f, -1.76861316e-01f, 2.36805379e-02f,
  -8.17971826e-01f, -7.54922211e-01f, 3.27533305e-01f, -7.37719476e-01f, 1.80423543e-01f, 4.96637642e-01f, -5.97871125e-01f, 3.17611068e-01f, -4.61539149e-01f, -1.25580609e-01f,
  -4.35197115e-01f, -3.78610283e-01f, 6.01132154e-01f, 8.98959413e-02f, -4.12362248e-01f, 5.84834278e-01f, 2.09060237e-01f, 7.06932366e-01f, -5.15096784e-01f, 7.77641773e-01f,
  -5.26525915e-01f, -5.07935882e-01f, 8.46830547e-01f, 8.09895456e-01f, 1.93934664e-01f, 8.65967572e-01f, 6.27049446e-01f, -5.09669840e-01f, -4.74140048e-01f, 7.76257634e-01f,
  -6.00244403e-01f, -2.05989212e-01f, 2.21157521e-01f, -8.11894596e-01f, -6.84382260e-01f, 6.29289746e-01f, -2.15172302e-02f, -4.40112025e-01f, -3.10534894e-01f, -5.35968959e-01f,
  -6.50276303e-01f, -7.34880090e-01f, 1.51019230e-01f, 2.04879746e-01f, -1.91074237e-01f, -1.51228249e-01f, -4.93183672e-01f, -4.28301007e-01f, -1.93894759e-01f, 2.35157564e-01f,
  1.97108731e-01f, 1.33033860e-02f, 5.67197144e-01f, 5.16322434e-01f, -1.40950605e-01f, -1.51435122e-01f, -7.07540035e-01f, 5.94771743e-01f, 5.28023481e-01f, -4.59851205e-01f,
  8.35743427e-01f, -3.34774822e-01f, 4.97821331e-01f, 1.79288816e-02f, -1.09421283e-01f, -4.12683934e-01f, -5.49881905e-02f, 3.09291124e-01f, 6.43347651e-02f, 1.20408460e-01f,
  -1.01394391e+00f, 2.62134135e-01f, 4.27446812e-01f, -1.69651747e-01f, 4.96619165e-01f, 2.51275629e-01f, -1.47622734e-01f, 2.83848047e-01f, 6.29137829e-02f, 2.69352496e-01f,
  -7.54114926e-01f, 5.84380329e-01f, 3.66467893e-01f, 2.68782616e-01f, 5.28580129e-01f, -2.81749815e-01f, -3.84455621e-01f, 6.38140321e-01f, 4.40479130e-01f, -4.18398738e-01f,
  3.85605007e-01f, 6.72147155e-01f, 3.68199199e-01f, 5.89313328e-01f, -9.57383335e-01f, -8.50472987e-01f, 4.73852724e-01f, -2.35371456e-01f, -4.93624032e-01f, -3.78522903e-01f,
  -5.82926571e-01f, 3.60351920e-01f, -4.36015397e-01f, 4.47260439e-01f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  -4.22599800e-02f, -5.13375923e-02f, -1.45991743e-01f, -2.20421091e-01f, 1.16747007e-01f, 3.45163718e-02f, 2.09993288e-01f, -7.63710290e-02f, -1.22037634e-01f, 2.71817178e-01f,
  -5.17310321e-01f, 9.23059806e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    