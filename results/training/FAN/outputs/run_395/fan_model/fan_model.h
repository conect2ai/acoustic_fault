/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.07321638e-01f, -5.74925959e-01f, -2.81461447e-01f, -1.47727385e-01f, -2.65526980e-01f, -4.22168761e-01f, -2.37344295e-01f, -1.65924057e-01f, -5.36779523e-01f, -3.30843888e-02f,
  -8.82928893e-02f, 1.29638389e-01f, -1.71009600e-01f, 1.41521906e-02f, -8.84828195e-02f, -2.87365913e-01f, 1.17176361e-01f, -2.64988486e-02f, -1.18336409e-01f, 9.40373689e-02f,
  -3.84032801e-02f, 1.38008550e-01f, 7.27723315e-02f, 1.49778858e-01f, 8.73736963e-02f, 5.26834503e-02f, 2.36367181e-01f, -1.06444024e-02f, 1.87471390e-01f, -5.92670590e-02f,
  1.21706620e-01f, -8.39353278e-02f, 5.08587472e-02f, -1.11518381e-02f, -4.00857627e-02f, -7.78492913e-02f, -1.92475859e-02f, -1.39068104e-02f, 3.34722959e-02f, -5.40670231e-02f,
  1.94387194e-02f, 2.84137093e-02f, 6.37559071e-02f, -1.94210056e-02f, -9.89680439e-02f, -5.30012101e-02f, -1.81705039e-02f, -4.44773063e-02f, 3.52965519e-02f, -1.09326420e-02f,
  -9.82837472e-03f, -6.14352934e-02f, -3.32003878e-03f, -1.75541401e-01f, -3.80711071e-02f, -3.30647230e-02f, -4.53303568e-02f, -5.96441180e-02f, -5.57161868e-02f, -8.53845999e-02f,
  -1.03403024e-01f, -9.60387886e-02f, 2.96012796e-02f, -4.67063412e-02f, 1.49997007e-02f, -6.32433668e-02f, 1.95213184e-02f, -6.44227117e-03f, 2.22268905e-02f, -1.29421484e-02f,
  8.45941082e-02f, -9.06625576e-03f, -1.18493363e-02f, -2.49795690e-02f, 5.55957593e-02f, -8.01124722e-02f, 7.90508464e-02f, 2.85090879e-02f, 6.23373277e-02f, -4.85896729e-02f,
  -2.25624833e-02f, -1.47947650e-02f, 8.81418064e-02f, -2.86663696e-02f, -5.30294888e-02f, 8.45078751e-03f, -4.97442409e-02f, -1.10350372e-02f, -4.16408181e-02f, -2.00099014e-02f,
  -2.26471603e-01f, -8.09061378e-02f, 6.31325543e-02f, 6.30662218e-02f, 5.00211753e-02f, 6.95868302e-03f, -5.81906289e-02f, 6.09686896e-02f, -2.45358665e-02f, -1.92962121e-02f,
  3.77374925e-02f, 8.86164680e-02f, -5.50246425e-02f, -2.24140342e-02f, 5.30086830e-02f, -1.64718889e-02f, 7.49640912e-02f, 2.31766738e-02f, -6.48234189e-02f, 1.43219065e-02f,
  5.66656366e-02f, 4.35029098e-04f, -5.07585406e-02f, 1.43004879e-01f, 1.04271360e-01f, 4.07935530e-02f, -1.04209613e-02f, 4.03490998e-02f, 4.22215043e-03f, 1.94297056e-03f,
  1.09845147e-01f, -2.02092633e-01f, -2.18467802e-01f, -1.69142827e-01f, 1.47481158e-01f, 4.58085358e-01f, 2.62648780e-02f, -5.47326766e-02f, -1.40955284e-01f, 5.60065769e-02f,
  1.60971045e-01f, -2.28797823e-01f, -2.44782530e-02f, -1.30324727e-02f, 6.03932440e-01f, 2.55837709e-01f, 1.33317769e-01f, 1.53845875e-02f, 2.18595564e-02f, -1.42454028e-01f,
  3.64446640e-02f, 2.37299070e-01f, 4.55648676e-02f, 5.56379417e-03f, -1.17101453e-01f, -1.99799165e-01f, 6.33399338e-02f, -1.06447436e-01f, 5.77617623e-02f, 1.26190394e-01f,
  1.75817564e-01f, -6.91176876e-02f, -1.32842943e-01f, 4.86573344e-03f, 3.52759399e-02f, 7.59097412e-02f, 2.54107080e-02f, 2.01542228e-02f, 4.18716110e-02f, -3.17708142e-02f,
  3.22038680e-02f, 6.93448335e-02f, -4.72220331e-02f, -1.77879469e-03f, 4.17316407e-02f, 1.00117866e-02f, -3.41482311e-02f, 2.04476691e-03f, -2.60995030e-02f, 4.48213965e-02f,
  -1.84707325e-02f, 5.43229990e-02f, 2.04470567e-02f, -6.56901598e-02f, -3.16936299e-02f, -7.54372403e-03f, 2.67435014e-02f, -1.75342653e-02f, 4.02270909e-03f, -1.32123763e-02f,
  7.35517815e-02f, 6.27008528e-02f, 6.24727607e-02f, -1.73352882e-02f, 6.46541417e-02f, -2.84931483e-03f, 2.40280712e-03f, 1.33044263e-02f, -3.29480581e-02f, 4.87703755e-02f,
  -1.81810111e-02f, 4.08982411e-02f, 1.95031390e-02f, 3.82902920e-02f, 6.67550042e-02f, -5.31565398e-02f, 6.35900488e-03f, 5.35550341e-03f, -3.70932035e-02f, 1.99543312e-02f,
  -4.25085649e-02f, 5.88889085e-02f, -5.46776503e-03f, 1.02366470e-02f, 2.55572740e-02f, 3.12111415e-02f, 8.47881585e-02f, 1.54991644e-02f, -4.41377722e-02f, 9.79501382e-02f,
  -5.40288240e-02f, -1.55972913e-01f, -2.19722763e-02f, -2.35668477e-03f, -3.03483978e-02f, -4.84312288e-02f, -2.91335918e-02f, -6.64958656e-02f, -3.84854674e-02f, 2.78155524e-02f,
  3.98307964e-02f, -2.30161194e-02f, -8.03670101e-03f, 7.32233152e-02f, -2.45397277e-02f, 2.91726291e-02f, -3.93652245e-02f, -4.70210575e-02f, -5.44695295e-02f, -4.81583178e-02f,
  -1.83651261e-02f, 2.97488831e-02f, -2.54104696e-02f, 5.20344190e-02f, 4.28125858e-02f, 1.62679758e-02f, 8.91584344e-03f, -1.40647674e-02f, 2.96535026e-02f, 1.50628677e-02f,
  5.51818967e-01f, 7.08540916e-01f, 4.62198071e-02f, 8.25512335e-02f, -7.97412172e-02f, 2.18409926e-01f, -1.00205086e-01f, 1.87252566e-01f, 2.05824614e-01f, 2.43894920e-01f,
  -1.78956896e-01f, 2.47641131e-01f, -5.26841804e-02f, 1.86663698e-02f, -1.85819566e-01f, 9.17044878e-02f, -7.02619776e-02f, 2.09911257e-01f, 8.34202021e-02f, 1.18604444e-01f,
  -4.36672978e-02f, -6.09260611e-02f, -2.89794058e-01f, -1.87869892e-02f, -1.00943074e-01f, 2.72617787e-01f, -1.00108400e-01f, -2.67402064e-02f, 4.17877063e-02f, -6.29179925e-02f,
  -2.05888987e-01f, -1.00890860e-01f, -2.54826266e-02f, 2.50512343e-02f, 2.51660999e-02f, -4.16612066e-02f, 3.65629792e-02f, -7.62019008e-02f, -6.66270405e-02f, 4.96246219e-02f,
  6.98551536e-02f, 6.67260215e-02f, -1.75223546e-03f, -5.97336441e-02f, 2.03812029e-02f, 6.27535507e-02f, -2.46004034e-02f, 2.80945282e-02f, 9.07438993e-02f, -7.36959800e-02f,
  -4.53592241e-02f, -2.20011976e-02f, -4.69166785e-02f, -8.71329084e-02f, 3.40896212e-02f, 2.47549154e-02f, -5.21446206e-02f, -9.37584862e-02f, 8.43346640e-02f, 1.10754762e-02f,
  -7.98652321e-02f, 6.53643087e-02f, -1.10571161e-02f, -3.52184027e-02f, 4.84774075e-02f, -2.22458169e-02f, -7.73818940e-02f, -4.36068438e-02f, 4.74696793e-03f, 6.11822605e-02f,
  7.01387674e-02f, -1.20739378e-02f, 1.01856915e-02f, 1.30408322e-02f, 6.67201281e-02f, -3.29099894e-02f, 6.22707903e-02f, 1.92576065e-03f, 1.15991468e-02f, -4.92963307e-02f,
  9.35223233e-03f, 1.21876253e-02f, 8.35977569e-02f, -4.56817001e-02f, 3.96300992e-03f, -1.73649974e-02f, 2.17915811e-02f, 8.37624818e-02f, -8.62383172e-02f, 1.10361874e-02f,
  4.82357174e-01f, 4.89369988e-01f, 2.75400132e-02f, -1.95140038e-02f, 7.43176714e-02f, -2.00046543e-02f, -4.70381901e-02f, 7.90025815e-02f, 1.01018146e-01f, -4.82184961e-02f,
  -8.71533155e-03f, -6.12796545e-02f, 8.83044526e-02f, 8.26053321e-03f, -1.15995370e-02f, 4.27297428e-02f, 2.86183450e-02f, 6.11747801e-02f, -7.42011741e-02f, 6.00522868e-02f,
  -5.95402271e-02f, -4.09176126e-02f, -6.77686185e-02f, 1.94157213e-02f, -8.78324136e-02f, -5.15851416e-02f, 5.16191311e-02f, 1.05459407e-01f, -7.41490349e-03f, 1.97585244e-02f,
  -3.06706011e-01f, -9.77723598e-02f, 3.27024370e-01f, -8.54395851e-02f, -1.24188364e-01f, -7.76553452e-02f, -8.59817788e-02f, -1.51561111e-01f, 6.38480335e-02f, -4.56344903e-01f,
  -3.31406325e-01f, 2.51920998e-01f, -1.79495052e-01f, -3.00081789e-01f, 2.70347625e-01f, 1.29706319e-02f, -1.81216702e-01f, 1.24015464e-02f, 5.91286123e-02f, -1.39061794e-01f,
  1.17760092e-01f, -3.40370148e-01f, 1.41664520e-01f, -1.03548355e-01f, -1.34487376e-01f, 2.08986670e-01f, -1.18585825e-01f, 1.19244955e-01f, -1.51580244e-01f, -2.60159583e-03f,
  1.77731439e-01f, -2.34665927e-02f, -1.54738082e-02f, 8.60683694e-02f, -7.26551488e-02f, 3.84377614e-02f, 3.84097546e-02f, 5.62401190e-02f, 6.71912432e-02f, 1.16917829e-03f,
  5.05554350e-03f, 7.32281879e-02f, 1.52568389e-02f, -5.29079288e-02f, -8.41817725e-03f, 4.31252159e-02f, 7.91325793e-02f, -3.21958475e-02f, 3.34016681e-02f, 1.32972285e-01f,
  1.57230012e-02f, 4.56772707e-02f, -3.47782634e-02f, -1.70738921e-02f, 7.06210732e-02f, 4.85617481e-02f, 1.72474962e-02f, 5.72934337e-02f, 1.25182057e-02f, -5.90165099e-03f,
  -9.82816517e-02f, 9.09254923e-02f, 4.78514247e-02f, -6.09842949e-02f, 5.34199774e-02f, 2.71611358e-03f, 1.27872368e-02f, -1.48806246e-02f, 5.96781000e-02f, -5.16498983e-02f,
  -7.71542713e-02f, 6.17715046e-02f, -3.70572396e-02f, 1.59080280e-03f, -5.55826314e-02f, -2.95187277e-03f, 5.45051470e-02f, -1.76370759e-02f, -2.35626437e-02f, 2.12712567e-02f,
  3.52802463e-02f, 1.18041724e-01f, -8.39236472e-03f, -5.25314882e-02f, 3.62567343e-02f, 8.15442652e-02f, 5.35792438e-03f, 1.26567855e-02f, 7.26494342e-02f, -1.46414638e-02f,
  -1.78633720e-01f, -3.90897095e-01f, 4.73257974e-02f, -5.86086623e-02f, 5.89538328e-02f, -9.01836827e-02f, 5.19645475e-02f, 1.16550103e-02f, -2.76697371e-02f, -6.41436651e-02f,
  9.91846994e-03f, -3.57453413e-02f, 8.05970561e-03f, 9.09337774e-03f, 8.56230035e-02f, -2.73411330e-02f, -5.53505160e-02f, 2.12886781e-02f, -3.24174389e-02f, -6.33220375e-02f,
  -1.72969047e-02f, -3.19882780e-02f, 5.71764931e-02f, -6.23508990e-02f, -5.71241528e-02f, -4.87830043e-02f, -4.92920280e-02f, 4.66192365e-02f, -2.59749778e-02f, 3.29222679e-02f,
  -5.46302378e-01f, -3.94641384e-02f, -1.69860333e-01f, -4.28095251e-01f, -1.78207755e-01f, 5.24223685e-01f, 3.79043132e-01f, -1.73427045e-01f, -5.19040227e-01f, 4.05774206e-01f,
  3.23687047e-02f, -5.09441420e-02f, -1.00823520e-02f, 1.71246111e-01f, -2.64688760e-01f, -6.58220127e-02f, 4.66645919e-02f, 1.49316534e-01f, -5.33397906e-02f, -1.93065107e-01f,
  -1.34622619e-01f, -5.19345514e-02f, 4.02972065e-02f, -4.29443456e-03f, -2.77676657e-02f, 2.21882071e-02f, -1.79844759e-02f, -4.68726968e-03f, 1.69929832e-01f, 1.51351616e-01f,
  3.84742320e-01f, -5.08268289e-02f, -9.51238200e-02f, -3.24529260e-02f, -1.38556004e-01f, 6.83223680e-02f, 1.09922208e-01f, 9.83570144e-02f, -2.92746108e-02f, 1.24965562e-02f,
  7.44112134e-02f, -3.37167308e-02f, 5.51483966e-03f, -6.17402382e-02f, -7.40124844e-03f, -4.94068209e-03f, -5.27678840e-02f, 1.53246883e-03f, -7.13745281e-02f, -2.17703097e-02f,
  -8.59615952e-02f, 4.74260235e-03f, -7.37833604e-02f, 6.89257309e-02f, -6.04996867e-02f, -1.18231609e-01f, 8.79735798e-02f, 2.04035435e-02f, 5.59412837e-02f, -2.96714325e-02f,
  -3.79227437e-02f, 2.60105897e-02f, -1.24608045e-02f, 5.39261289e-02f, -5.48394956e-02f, 1.81219094e-02f, -2.27473397e-02f, 2.70125438e-02f, -5.20946309e-02f, -3.42066819e-03f,
  1.29410869e-03f, -2.86459271e-02f, 4.16374579e-02f, 2.38593994e-03f, -1.47419181e-02f, 3.60380895e-02f, -1.36288870e-02f, 4.61764261e-02f, 8.97168554e-03f, -3.51426937e-02f,
  6.81329444e-02f, 2.45043412e-02f, 2.48712599e-02f, 4.85286675e-02f, 6.84260726e-02f, -4.32445146e-02f, 3.30308340e-02f, -6.24836236e-02f, 1.25892684e-02f, -1.53692951e-02f,
  -1.30490541e-01f, -1.98394030e-01f, 1.25067709e-02f, 2.30501313e-02f, 7.75689483e-02f, -5.79408146e-02f, -2.50144526e-02f, -5.65624088e-02f, -4.31902036e-02f, 2.65258886e-02f,
  -1.34102982e-02f, -3.35590169e-03f, 6.44634068e-02f, 2.34881751e-02f, -3.24548446e-02f, -1.65327732e-02f, 5.21462299e-02f, 3.60087082e-02f, -1.90257579e-02f, 2.16987357e-02f,
  5.97538091e-02f, 8.52882639e-02f, 3.61133106e-02f, 1.67976245e-02f, 6.48836941e-02f, 1.03096619e-01f, -6.45976067e-02f, -5.27942888e-02f, 2.10685302e-02f, -3.99156138e-02f,
  -4.94799525e-01f, 3.50861609e-01f, -1.75059333e-01f, -1.18486010e-01f, -1.13640860e-01f, -2.42389917e-01f, -2.28753656e-01f, 2.17170771e-02f, -2.03584656e-01f, 6.32734224e-02f,
  1.54574662e-01f, 2.42070854e-02f, 2.75994986e-01f, 5.02433069e-02f, 1.19719349e-01f, 2.34539479e-01f, -1.80623502e-01f, -5.43143228e-02f, -7.25762127e-03f, -3.74775454e-02f,
  -8.42473954e-02f, 2.36024633e-01f, 6.60525216e-03f, 2.66483516e-01f, -1.38676226e-01f, -1.08937919e-01f, 7.73530751e-02f, 1.16286010e-01f, 1.55557096e-02f, 1.60760758e-03f,
  9.48097110e-02f, 1.51917905e-01f, 1.58215016e-01f, -2.30290778e-02f, -7.47319534e-02f, -6.59236684e-02f, -4.95303459e-02f, -1.63003337e-02f, -1.19943045e-01f, -9.97444913e-02f,
  3.88980634e-03f, 2.33597811e-02f, -6.30812868e-02f, -3.96598615e-02f, -2.76798476e-02f, -6.31426051e-02f, -6.72817603e-02f, -1.38991907e-01f, -2.20347047e-02f, 2.66766082e-02f,
  -7.52907172e-02f, 1.16963638e-03f, -8.29590335e-02f, 8.03521182e-03f, 4.42362623e-03f, 7.17619294e-03f, -3.76943238e-02f, 4.93790582e-02f, -3.22307907e-02f, -5.80257662e-02f,
  4.80060019e-02f, 2.01307982e-03f, 6.22730516e-02f, -6.91899739e-04f, -2.57620215e-02f, 2.68082991e-02f, -6.37635142e-02f, 5.59161156e-02f, -7.94524550e-02f, 6.36717156e-02f,
  5.61395008e-03f, -2.27914229e-02f, 4.87392806e-02f, -2.08991542e-02f, 3.54930642e-03f, 3.81266624e-02f, 2.46069469e-02f, -4.20863973e-03f, -6.27896935e-02f, -3.78768034e-02f,
  1.99016873e-02f, -2.74176318e-02f, 7.46591538e-02f, -7.60944188e-02f, -8.80024675e-03f, 2.54583862e-02f, 1.91083178e-02f, -4.15482596e-02f, -2.01115329e-02f, -3.94758955e-02f,
  -2.47635301e-02f, 7.94144720e-02f, 3.64311002e-02f, 5.40064601e-03f, 4.53764424e-02f, 2.75300667e-02f, -5.03896661e-02f, 3.53397825e-03f, 6.69469461e-02f, 3.54309678e-02f,
  -4.69569638e-02f, -5.78865707e-02f, -6.84931427e-02f, -1.74993277e-02f, 1.55881085e-02f, 2.30442993e-02f, -1.84446282e-03f, 6.42508715e-02f, 6.98582754e-02f, -4.81120311e-02f,
  -8.30126647e-03f, -5.40874004e-02f, -2.78634448e-02f, -9.22846794e-02f, -1.95374824e-02f, -4.29822728e-02f, -7.21595511e-02f, -1.18350321e-02f, 2.86393873e-02f, 6.75573722e-02f
};

// L0_fan_Wp_bar (Shape: 4 x 120)
const int L0_fan_Wp_bar_rows = 4;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.84712040e+00f, 1.70685351e+00f, 6.48743927e-01f, 4.77966398e-01f, -1.21636534e+00f, 7.97584057e-02f, 2.77184039e-01f, 9.49950889e-02f, 5.29901683e-01f, 1.00082314e+00f,
  -4.10750538e-01f, 6.62237406e-01f, 1.60207793e-01f, 4.25700903e-01f, -9.96166050e-01f, 5.10905504e-01f, -1.27699196e-01f, 2.36735433e-01f, 1.56951979e-01f, -1.15602657e-01f,
  -3.35948408e-01f, -2.02797666e-01f, -5.01150414e-02f, -3.09456959e-02f, -4.78902489e-01f, 3.35066766e-02f, -6.66107714e-01f, -9.58634987e-02f, -2.85781056e-01f, -9.82964784e-02f,
  -6.40661895e-01f, 6.10183813e-02f, -2.04333827e-01f, 4.03916836e-02f, -1.35114104e-01f, -7.09980503e-02f, 7.30767399e-02f, 3.45797688e-02f, -1.30982161e-01f, -3.34503278e-02f,
  1.04260638e-01f, -5.11380918e-02f, 2.58969992e-01f, 8.10288563e-02f, -5.23132225e-03f, 5.12177162e-02f, 5.71152419e-02f, -2.18670033e-02f, 2.24039450e-01f, 6.41502962e-02f,
  2.20058680e-01f, 1.07144304e-01f, -7.62256980e-02f, 2.15948701e-01f, -1.73675224e-01f, 2.58252144e-01f, 2.40123436e-01f, -6.61419407e-02f, -1.76708564e-01f, -2.53146868e-02f,
  1.44811478e-02f, 2.82127131e-02f, -1.16610497e-01f, 3.41883954e-03f, 1.26320168e-01f, -1.70282230e-01f, -1.66304759e-03f, -2.16735348e-01f, 7.55108446e-02f, -2.06631422e-01f,
  -1.12516448e-01f, -4.27244755e-04f, -7.25277513e-02f, 3.26535106e-02f, 1.38651079e-03f, 2.49358686e-03f, -1.58355892e-01f, -5.69866672e-02f, 9.57066379e-03f, -1.05883308e-01f,
  1.53317153e-01f, 1.30690977e-01f, 1.95075721e-02f, -1.19803131e-01f, 7.74637088e-02f, -4.36714329e-02f, 3.09544429e-02f, 1.93821102e-01f, -3.14807370e-02f, -2.79041082e-01f,
  -6.23358309e-01f, -7.25551844e-02f, 1.33841425e-01f, -3.16527560e-02f, 1.75981801e-02f, -1.31123513e-01f, -1.13925114e-01f, -1.50052518e-01f, 9.40732807e-02f, -1.34343103e-01f,
  -2.01955438e-01f, -9.53225978e-03f, -2.72396237e-01f, -7.35037401e-02f, 1.31835148e-01f, 8.95472243e-03f, -3.58941108e-02f, -8.41540936e-03f, -2.36177608e-01f, -5.86212464e-02f,
  -2.21276477e-01f, -9.18316543e-02f, 6.46972954e-02f, -6.34235069e-02f, 8.56512934e-02f, -3.30203563e-01f, -2.13987961e-01f, 1.67163000e-01f, -4.84114960e-02f, 1.52003154e-01f,
  1.53704688e-01f, 9.05056298e-02f, -7.87339509e-01f, -4.94752318e-01f, -5.13723567e-02f, -1.36825800e+00f, -1.13435709e+00f, -7.45001972e-01f, -6.57349005e-02f, 1.97983548e-01f,
  -5.08712471e-01f, 2.33549595e-01f, -2.15381548e-01f, -1.15857220e+00f, -1.72582793e+00f, -5.36115646e-01f, -9.69906092e-01f, -1.99152827e-01f, 1.06744461e-01f, -2.70987749e-01f,
  -5.52887917e-01f, -8.61737609e-01f, -8.21801007e-01f, -9.01606828e-02f, -3.81533951e-01f, 1.77801490e-01f, 2.16701910e-01f, 8.36873502e-02f, 4.38680314e-02f, 2.87881549e-02f,
  -3.51520747e-01f, -1.11027442e-01f, 1.24233000e-01f, -8.46539140e-02f, -2.56451339e-01f, 2.05836013e-01f, 2.85397351e-01f, -4.50051613e-02f, 3.14708538e-02f, 4.29094164e-03f,
  1.92228243e-01f, 6.12926632e-02f, -1.97635189e-01f, 5.10071032e-02f, 3.09719533e-01f, 1.37425780e-01f, -1.80073977e-01f, 1.28510684e-01f, 9.63034555e-02f, 1.12403132e-01f,
  -1.87599242e-01f, -5.52893579e-02f, 4.68360186e-02f, 2.85217494e-01f, -7.48188794e-02f, -1.85513757e-02f, 3.35018001e-02f, 1.46499142e-01f, -4.15375754e-02f, 1.63791701e-01f,
  1.76671132e-01f, 1.79658189e-01f, -2.20063537e-01f, 2.25171834e-01f, -3.58636864e-02f, -7.38861114e-02f, 9.10254344e-02f, 1.43842429e-01f, 2.69676298e-01f, 1.07837148e-01f,
  -1.76800743e-01f, 5.55503406e-02f, 2.84608435e-02f, 3.42538357e-02f, 9.63860005e-02f, 9.65704396e-02f, -8.34383890e-02f, 4.29817177e-02f, -4.82931826e-03f, -2.94917703e-01f,
  7.86173195e-02f, -3.20209600e-02f, 1.74078897e-01f, 2.70288289e-02f, -9.12293121e-02f, -6.40514269e-02f, 1.77016139e-01f, 1.27215758e-01f, -8.75800624e-02f, -9.50094089e-02f,
  -2.13903129e-01f, -3.51782382e-01f, -1.77208483e-01f, -1.05333738e-01f, -9.07579362e-02f, -4.44898270e-02f, -3.00499171e-01f, -3.40655565e-01f, -1.28333032e-01f, -1.19940341e-02f,
  9.20717344e-02f, -3.91852856e-02f, -2.01299526e-02f, 2.53754556e-01f, -2.27070302e-02f, -2.40444809e-01f, 1.00132391e-01f, -2.67068110e-02f, 4.82544713e-02f, -1.50473565e-02f,
  1.43484429e-01f, 1.39291897e-01f, 1.49456352e-01f, -5.92481978e-02f, -3.87454368e-02f, 1.67880610e-01f, 3.56242657e-02f, 6.56308159e-02f, 1.41180336e-01f, -1.45872002e-02f,
  -2.45522571e+00f, 5.04345715e-01f, 2.65456170e-01f, -1.27587056e+00f, 5.34315526e-01f, 4.35247004e-01f, -7.23842502e-01f, 5.15876174e-01f, -3.35649133e-01f, 1.02537669e-01f,
  -1.44110590e-01f, -9.28134799e-01f, -1.35390639e-01f, -7.73193598e-01f, -1.07065737e+00f, -8.77737582e-01f, -8.87163997e-01f, -6.14614546e-01f, 1.15127631e-01f, -2.09672838e-01f,
  -3.25858533e-01f, -9.20500010e-02f, -2.01045990e-01f, 1.21437669e+00f, 2.29608208e-01f, 5.11797667e-01f, 4.31838669e-02f, 6.43753886e-01f, 1.73417076e-01f, 2.00254656e-02f,
  -2.68709630e-01f, -9.57163051e-02f, -3.10618635e-02f, 6.71897456e-02f, 9.99393594e-03f, 1.33722685e-02f, -3.25708628e-01f, -1.17625147e-01f, -6.97864667e-02f, 4.19787429e-02f,
  -1.42039448e-01f, 1.08642228e-01f, -1.33013353e-01f, 1.04933642e-01f, 1.15387961e-01f, 1.87970921e-01f, 1.15506709e-01f, 1.23561643e-01f, 1.29742324e-01f, 1.04628295e-01f,
  1.40006319e-02f, 1.18076466e-01f, -6.15318343e-02f, -1.02188572e-01f, 5.90542071e-02f, -4.73288670e-02f, 8.19601864e-02f, 8.49268436e-02f, -3.81878838e-02f, 4.70299413e-03f,
  -1.93730295e-01f, 1.78813245e-02f, 9.42003354e-02f, -1.63979679e-02f, 3.17011774e-02f, 4.47335467e-02f, -1.06688872e-01f, 4.78217006e-02f, -5.11292219e-02f, -5.02664596e-02f,
  -6.29150048e-02f, -1.16548724e-01f, 4.52532396e-02f, -6.98418617e-02f, 1.48656871e-02f, -7.85653889e-02f, -2.13899121e-01f, -1.14033334e-01f, -1.82959177e-02f, -8.54335427e-02f,
  -1.34336688e-02f, -1.52268082e-01f, -1.27759343e-02f, 2.55375113e-02f, -9.32962820e-03f, -6.62385672e-02f, 1.09851062e-02f, 7.48639926e-02f, -8.99670944e-02f, -9.69775096e-02f,
  -3.77805859e-01f, -3.47620621e-02f, 4.53442410e-02f, 6.12069443e-02f, -7.11871833e-02f, -2.50987560e-02f, 2.69171409e-02f, 1.50066465e-01f, -1.05272457e-01f, -1.16983153e-01f,
  4.35158275e-02f, -1.60925493e-01f, 1.36275858e-01f, -4.20818031e-02f, 2.76972707e-02f, -9.01124626e-02f, -1.90239668e-01f, -1.15507729e-01f, -5.81068024e-02f, -4.16781791e-02f,
  -1.05992056e-01f, -2.76635727e-03f, -9.87770483e-02f, 2.71294713e-01f, -5.54938577e-02f, -4.19066623e-02f, 6.38935855e-03f, 6.53587282e-02f, 1.16264289e-02f, 2.62426604e-02f,
  1.39260805e+00f, 2.77169973e-01f, 5.23647845e-01f, 8.33364367e-01f, -3.22719067e-02f, -2.94578075e-01f, -8.36309135e-01f, 4.85088497e-01f, 9.38668177e-02f, 2.15166509e-02f,
  9.53797624e-02f, -3.77866104e-02f, -1.18898106e+00f, 7.82047272e-01f, -2.01315388e-01f, -1.00247157e+00f, 1.03629470e+00f, 1.57593608e-01f, -8.61296728e-02f, 4.18930471e-01f,
  5.05739212e-01f, 6.46594167e-01f, 3.21902841e-01f, 5.65694153e-01f, 5.12801647e-01f, 4.10081893e-01f, 3.57209504e-01f, -3.77821803e-01f, 1.19235539e+00f, -5.17341122e-02f,
  -1.22825198e-01f, 7.50760436e-02f, 2.12993845e-01f, -1.53774545e-01f, 5.94256446e-02f, 9.90710407e-02f, -6.40603080e-02f, -4.07351792e-01f, -1.84250489e-01f, -3.48114893e-02f,
  -7.19578639e-02f, 1.40939996e-01f, 2.67940611e-01f, -5.97223975e-02f, 1.89500466e-01f, 1.78674161e-02f, 1.62048891e-01f, -1.31074234e-03f, 8.85093864e-03f, 7.74343163e-02f,
  -3.52335186e-03f, 1.04700007e-01f, 2.51929164e-01f, 7.74964839e-02f, 6.07997440e-02f, 2.52420813e-01f, -1.14236839e-01f, -2.61924826e-02f, 2.54013371e-02f, 3.69471699e-01f,
  1.68967754e-01f, -1.11908786e-01f, 1.63051300e-02f, 1.73038989e-02f, 1.02026395e-01f, 1.40058473e-01f, -4.90801781e-02f, -1.23600312e-01f, -8.70253146e-02f, -9.05178934e-02f,
  8.11300501e-02f, -1.49881449e-02f, 2.73590144e-02f, -3.58931012e-02f, -5.06789982e-03f, -4.72281575e-02f, -1.82355478e-01f, -1.64721325e-01f, 7.97370300e-02f, 2.21799053e-02f,
  6.27085194e-02f, 1.85175166e-01f, -1.38533652e-01f, -2.71351952e-02f, -1.22580128e-02f, -1.29808038e-01f, 2.44325742e-01f, 4.96185161e-02f, -1.84881240e-01f, -9.19840410e-02f,
  7.29781017e-02f, 1.56697914e-01f, -1.63130224e-01f, -1.56871885e-01f, 2.26449650e-02f, 1.90995783e-01f, -9.39123929e-02f, 2.00885996e-01f, 1.25216350e-01f, -9.42579936e-03f,
  1.30136266e-01f, -1.99040979e-01f, -1.87048912e-01f, 1.16985507e-01f, 3.65238711e-02f, 2.44727492e-01f, 4.90867794e-02f, 1.57818690e-01f, 2.12864131e-01f, 2.13834882e-01f,
  -4.59109508e-02f, -3.31256062e-01f, 3.70709635e-02f, 1.01164162e-01f, 1.13713793e-01f, -1.44275919e-01f, 4.55650687e-02f, 8.27128887e-02f, -7.42885992e-02f, -5.39660305e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 4)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 4;
const float L0_fan_Bp_bar_data[] = {
  1.42764425e+00f, 1.24463284e+00f, 1.54947388e+00f, 1.79652417e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  1.18500352e+00f, -1.99313343e-01f, 3.06223363e-01f, -1.05376458e+00f, -2.22845864e+00f, -7.60115445e-01f, 5.51196158e-01f, 3.83415550e-01f, -2.13726091e+00f, -1.66136229e+00f,
  8.95129621e-01f, 1.15877533e+00f, 1.42209136e+00f, -8.79483879e-01f, -1.02166045e+00f, -7.77568340e-01f, 1.06667960e+00f, -8.06369424e-01f, 8.20523798e-01f, -2.64068437e+00f,
  1.02156520e+00f, 5.85831344e-01f, -1.39628923e+00f, 2.21254826e+00f, 1.80927777e+00f, -2.03482270e+00f, 1.71169627e+00f, 1.32148790e+00f, -9.33256149e-01f, 2.16312796e-01f,
  -1.84051216e+00f, 6.03977144e-01f, -1.73338878e+00f, -1.06578231e+00f, -1.28636968e+00f, 9.12959516e-01f, 7.68867135e-01f, 5.32660782e-01f, 1.73584151e+00f, 1.33586198e-01f,
  -1.24054968e+00f, 4.57476199e-01f, 4.18894529e-01f, -1.63785791e+00f, -1.38698494e+00f, -1.52398050e+00f, 3.82017009e-02f, 8.39132845e-01f, 1.42889130e+00f, -1.70275235e+00f,
  -4.42713052e-01f, -4.73416708e-02f, -7.61814535e-01f, -1.91995645e+00f, 5.92950284e-01f, -1.60053372e+00f, -3.16963829e-02f, -5.37117720e-01f, -7.34546423e-01f, 1.67996180e+00f,
  1.74587280e-01f, 2.44378954e-01f, 7.64427185e-01f, -1.88977885e+00f, -1.18516779e+00f, 1.07492554e+00f, 9.97016355e-02f, -9.00154412e-02f, 5.72791696e-01f, 1.31116927e-01f,
  5.46747260e-02f, 4.64557618e-01f, -1.05803156e+00f, 2.02783036e+00f, 9.62393761e-01f, 1.07489014e+00f, 4.02395576e-01f, -1.46853137e+00f, 1.14525783e+00f, -1.66969609e+00f,
  -2.19529653e+00f, 1.65924203e+00f, -2.24324793e-01f, 1.64479637e+00f, 1.40410638e+00f, 1.28090954e+00f, -4.63380933e-01f, -3.07815492e-01f, 2.16523314e+00f, -8.59225810e-01f,
  -8.70264232e-01f, -5.94571590e-01f, 9.52378333e-01f, -1.57436097e+00f, -2.21477890e+00f, -2.07141176e-01f, 3.07447195e-01f, 1.08349288e+00f, 1.71808481e+00f, 1.28853011e+00f,
  -1.00882244e+00f, -2.40842938e+00f, -2.48172045e+00f, -6.09199822e-01f, -1.25118041e+00f, 6.70084059e-01f, -2.53279495e+00f, -1.39823842e+00f, -1.55424559e+00f, -1.21440899e+00f,
  -1.57642335e-01f, 3.13896984e-01f, -9.79900777e-01f, 7.55287170e-01f, -1.99464098e-01f, -1.05971289e+00f, -4.15291488e-01f, -3.06956381e-01f, -1.48635328e-01f, 1.00889111e+00f,
  4.41012919e-01f, 1.47271073e+00f, -1.01608729e+00f, 1.02009845e+00f, -6.08878016e-01f, 1.28725648e+00f, -6.43601716e-01f, -1.69978321e+00f, -2.33177811e-01f, 3.27586472e-01f,
  6.74737692e-02f, 1.15771852e-01f, -2.40007687e+00f, -1.95427060e-01f, 1.35910451e+00f, -2.32967949e+00f, 1.01211786e+00f, -1.04205799e+00f, -1.25903094e+00f, 2.30336165e+00f,
  -4.50999916e-01f, -9.00357008e-01f, -7.83598483e-01f, 1.01020336e+00f, 2.11850786e+00f, 5.98703504e-01f, -1.17736721e+00f, -4.19734150e-01f, 1.55348563e+00f, 1.62826681e+00f,
  -9.77580249e-01f, 1.93536198e+00f, -2.23441648e+00f, 2.35389304e+00f, 1.18375003e+00f, -1.86464083e+00f, -6.98896706e-01f, -1.05479553e-01f, -1.97956204e+00f, -2.18231606e+00f,
  -8.59180987e-01f, -1.42610118e-01f, 5.66895843e-01f, -1.28021196e-01f, 1.09481834e-01f, 1.03498042e+00f, 1.08789968e+00f, -1.15862405e+00f, 1.08565867e+00f, -1.87444377e+00f,
  1.46834660e+00f, -1.02341914e+00f, -2.07921886e+00f, 3.54083836e-01f, 8.75964105e-01f, -7.26098120e-01f, 9.05700326e-01f, -2.20726609e+00f, -4.62657124e-01f, -3.06323409e-01f,
  2.54325241e-01f, -1.95291951e-01f, -7.26449490e-02f, -1.78095925e+00f, 1.33367419e+00f, 1.35811448e+00f, -4.63715464e-01f, -1.29187524e+00f, 6.37413383e-01f, 3.43087643e-01f,
  -9.32866216e-01f, 1.82481125e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -2.80356091e-02f, 6.84286833e-01f, -1.04750454e+00f, -1.19289219e+00f, 1.62725940e-01f, 3.76041651e-01f, 7.75808513e-01f, -7.34540224e-01f, -7.17760026e-01f, 1.39865315e+00f,
  -2.28024259e-01f, -3.65018427e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 4
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    