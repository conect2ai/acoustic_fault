/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 12 x 120)
const int L0_fan_Wp_rows = 12;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -6.04886822e-02f, -5.59999421e-02f, -3.92936826e-01f, -2.22621307e-01f, 1.07525274e-01f, 2.07493946e-01f, -5.31851202e-02f, 1.46967486e-01f, -1.55855417e-02f, 1.42955944e-01f,
  1.01275742e-01f, -2.58744091e-01f, 6.73605828e-03f, -8.28026757e-02f, -2.66196076e-02f, -6.32954538e-02f, -2.85954326e-02f, -5.60482442e-02f, 3.53209861e-02f, 4.87412289e-02f,
  -8.40258151e-02f, 1.44451052e-01f, -2.31441513e-01f, 8.60596746e-02f, -5.42260595e-02f, -9.46430564e-02f, 3.61955315e-02f, -4.87151481e-02f, -1.29610747e-01f, -2.64890660e-02f,
  -3.12287360e-04f, -2.36924328e-02f, -1.09514676e-01f, 1.93407517e-02f, 5.19456975e-02f, 1.34432185e-02f, -3.56501825e-02f, -4.89338823e-02f, -1.44373421e-02f, 2.99417246e-02f,
  -3.33158188e-02f, 3.06621343e-02f, -7.67479744e-03f, -1.92907937e-02f, -3.62413097e-03f, -4.25449014e-02f, -6.79159388e-02f, -6.54881671e-02f, -3.82902361e-02f, -1.21257655e-01f,
  -1.19169645e-01f, -6.78989664e-02f, 1.23203378e-02f, -3.04587185e-02f, -1.31028155e-02f, -8.03570170e-03f, -8.03568140e-02f, -7.25257695e-02f, -7.40580857e-02f, 6.27815723e-03f,
  8.87109619e-03f, 3.08057740e-02f, -6.91697225e-02f, 1.71005949e-02f, 9.76525713e-03f, 1.52634336e-02f, -2.36477796e-02f, 4.84513044e-02f, -3.74821126e-02f, 1.34549160e-02f,
  5.47630887e-04f, 2.44802069e-02f, 8.89140647e-03f, -2.03982741e-02f, -2.87952293e-02f, 3.29011865e-02f, 1.50248297e-02f, 3.25067788e-02f, 1.03306025e-02f, -2.24535447e-02f,
  3.30164880e-02f, 3.50118503e-02f, 1.00057444e-03f, 1.63620268e-03f, 9.41062067e-03f, 9.51384287e-03f, 7.90835097e-02f, -5.69891669e-02f, 6.46908861e-03f, 9.70012881e-03f,
  2.65219063e-01f, 1.27059028e-01f, -1.23056024e-02f, 2.21278332e-02f, -4.37005452e-04f, 4.85640652e-02f, -5.76444566e-02f, -6.58870954e-03f, -6.29653176e-03f, 1.03954040e-02f,
  5.31345047e-02f, -9.42408014e-03f, 4.79490086e-02f, -2.18838733e-02f, 2.39132484e-03f, -9.63060558e-03f, 4.13005687e-02f, 5.35299145e-02f, 2.36168262e-02f, 3.21531557e-02f,
  -1.41780765e-03f, 7.72752687e-02f, -1.33477291e-02f, 9.57782101e-03f, 2.62559857e-02f, -8.27826094e-03f, 5.31672165e-02f, 3.87077639e-03f, 2.74734907e-02f, -2.59139296e-02f,
  -5.83255664e-02f, 1.62391037e-01f, 5.37174148e-03f, -1.12668693e-01f, 2.40623727e-01f, 2.09983200e-01f, -2.83196032e-01f, 2.35308737e-01f, 1.96895435e-01f, -1.47556327e-02f,
  -9.18080956e-02f, 6.27140030e-02f, -2.59267688e-01f, 5.23889251e-02f, -1.46585703e-01f, -8.95678923e-02f, 2.77607515e-02f, -9.20167472e-03f, 1.19966850e-01f, -2.86393170e-03f,
  9.44598857e-03f, -3.81749980e-02f, -1.94168180e-01f, 1.94345593e-01f, 4.11149394e-03f, 3.49348556e-04f, -2.10006312e-01f, -5.51397577e-02f, 4.92072850e-02f, 3.64151672e-02f,
  -7.40249455e-02f, 6.66977763e-02f, -1.44419698e-02f, 9.80109945e-02f, -4.63053770e-02f, 1.25159777e-03f, -1.64173301e-02f, -4.26310375e-02f, 3.93932266e-03f, 3.62668969e-02f,
  1.95081998e-02f, 7.82551542e-02f, 1.62865594e-02f, -1.36698401e-02f, 1.04267769e-01f, 8.94302726e-02f, 9.82657447e-02f, 4.84982692e-02f, 3.16804387e-02f, 5.95004745e-02f,
  1.81747954e-02f, -3.44899693e-03f, -1.67712811e-02f, -5.57227880e-02f, 1.80855189e-02f, 3.52155492e-02f, 9.29086644e-04f, -4.70027961e-02f, 4.27024141e-02f, 6.30551875e-02f,
  6.58305213e-02f, 1.74406841e-02f, -5.94589971e-02f, 8.74464121e-03f, 1.20324222e-02f, 1.21078687e-02f, -2.37015467e-02f, -7.38261044e-02f, 2.96042413e-02f, 7.55846687e-03f,
  -4.44833888e-03f, -7.68305210e-04f, 7.68409520e-02f, 3.70674767e-02f, -2.46564858e-02f, 5.49312308e-02f, -5.64423278e-02f, 2.16620471e-02f, -2.09243260e-02f, 2.40856949e-02f,
  -1.89018287e-02f, 2.36083679e-02f, -1.77750178e-02f, -5.37606440e-02f, 2.72819791e-02f, -8.51073414e-02f, 3.36279720e-02f, 3.28797363e-02f, 5.00123017e-04f, -5.82742654e-02f,
  7.81126246e-02f, -2.22865287e-02f, 2.20836438e-02f, 3.52517106e-02f, 1.95960980e-02f, 1.24787306e-02f, -2.97056269e-02f, 2.89508682e-02f, -3.72819207e-03f, 2.73070578e-03f,
  1.94110405e-02f, -8.38665590e-02f, 3.42716984e-02f, 1.88040305e-02f, -1.08761992e-02f, -1.25664868e-03f, -8.52276683e-02f, -3.28260437e-02f, 8.48295912e-03f, 1.24985343e-02f,
  8.44029593e-04f, -2.91682705e-02f, -4.45199497e-02f, 6.61087930e-02f, 4.95668408e-03f, -4.00490761e-02f, 5.72832748e-02f, 3.93630676e-02f, -4.71065007e-03f, 2.03552507e-02f,
  1.22429013e-01f, 1.01815276e-01f, 8.46228600e-02f, 2.11368278e-01f, 1.11452907e-01f, -1.87569574e-01f, -1.32524952e-01f, 1.60482034e-01f, -1.69216275e-01f, 8.56962875e-02f,
  8.12298954e-02f, -9.12458524e-02f, -5.70143163e-02f, 3.09576571e-01f, -5.29319607e-02f, -1.76185921e-01f, 1.67036325e-01f, 2.39180401e-02f, -1.19854935e-01f, 1.58722535e-01f,
  -2.77149808e-02f, 2.30105385e-01f, 3.21682617e-02f, 1.01826310e-01f, 1.75751567e-01f, -4.05590311e-02f, 2.66073942e-01f, -3.54967192e-02f, 2.00862631e-01f, -9.58946254e-03f,
  -4.04741541e-02f, -2.29833052e-02f, 3.08214445e-02f, -2.73745842e-02f, 3.90906967e-02f, -1.67312250e-02f, -5.81751615e-02f, -6.02144077e-02f, -4.85337246e-03f, -2.81907059e-02f,
  -2.67574303e-02f, 9.36110131e-03f, 6.38604397e-04f, 3.19865309e-02f, 2.51933485e-02f, -1.62739195e-02f, -7.43473414e-03f, 1.16041489e-02f, -3.20338793e-02f, -2.95438152e-02f,
  -4.77167405e-02f, 5.68201859e-03f, 6.74216598e-02f, -5.74014038e-02f, -3.54236811e-02f, -4.30306559e-03f, -1.01247564e-01f, -2.00621020e-02f, 5.17104869e-04f, -1.60288112e-03f,
  -1.92205776e-02f, 2.47160699e-02f, 2.44384222e-02f, 2.01524962e-02f, 1.00628827e-02f, 5.07859252e-02f, 4.93343621e-02f, -6.49087364e-03f, 5.19791571e-03f, -6.90618670e-03f,
  4.94242311e-02f, 3.63452062e-02f, -1.02849456e-03f, 3.35176922e-02f, 2.23471150e-02f, 1.56571660e-02f, 7.61031499e-03f, 1.02377813e-02f, 5.19842934e-03f, -5.30185178e-02f,
  3.52418795e-02f, 4.11298424e-02f, 2.83204243e-02f, -2.41866079e-03f, -1.73117332e-02f, -1.75594855e-02f, 5.94345108e-02f, 4.14941162e-02f, 3.20381001e-02f, -3.82951424e-02f,
  -4.47553657e-02f, 1.19580187e-01f, -4.33831066e-02f, -8.76515824e-03f, -5.37683927e-02f, 5.51934317e-02f, 2.97614727e-02f, 4.84325085e-03f, -3.07471100e-02f, 1.44836623e-02f,
  -8.45255796e-03f, 6.62859296e-03f, -3.95226628e-02f, 3.73310223e-02f, -3.54819559e-02f, 1.23788510e-02f, 1.19897844e-02f, 1.65872220e-02f, 6.64309338e-02f, 2.48603132e-02f,
  6.02372065e-02f, -1.31089408e-02f, -7.96343833e-02f, 6.03607893e-02f, 5.56188412e-02f, 1.17689865e-02f, -9.26097576e-03f, -5.92209473e-02f, -5.83045259e-02f, -3.34790498e-02f,
  4.28207248e-01f, 1.08873792e-01f, 3.13571319e-02f, 2.90639251e-01f, 2.41052154e-02f, 1.59905255e-02f, -2.12913565e-02f, 1.65889695e-01f, 2.71549225e-01f, -7.66221806e-02f,
  3.29136997e-02f, 3.29623073e-02f, -1.90632224e-01f, 1.85508877e-01f, 3.33786570e-02f, -7.00173825e-02f, 2.17369318e-01f, 4.21101302e-02f, 6.93370923e-02f, 1.19298607e-01f,
  6.25803247e-02f, 8.66951495e-02f, -3.72968353e-02f, -4.21794504e-03f, 8.04984123e-02f, 8.92099440e-02f, -1.13938786e-01f, -2.15643033e-01f, 6.16846122e-02f, -8.25713500e-02f,
  -1.09540224e-01f, 2.42608953e-02f, 6.89625442e-02f, 6.00756444e-02f, 1.19860061e-02f, 4.45825793e-02f, -5.33855036e-02f, -6.09199144e-02f, -1.77759060e-03f, -1.49042588e-02f,
  -2.81071942e-02f, 1.31503874e-02f, 2.72442177e-02f, -5.31289503e-02f, 8.05613846e-02f, 2.73509193e-02f, 3.82619835e-02f, 3.60132195e-02f, 4.69642272e-03f, -1.88143346e-02f,
  5.14830537e-02f, 2.47114804e-02f, 7.64636993e-02f, 6.38411241e-03f, 2.61218427e-03f, 2.96143144e-02f, -1.45136276e-02f, -5.74148111e-02f, 3.79659645e-02f, 2.95018731e-03f,
  -3.16611268e-02f, -6.82415441e-02f, -1.57172550e-02f, -1.28461979e-02f, -1.63453035e-02f, -4.90814857e-02f, -2.97500715e-02f, -2.18062084e-02f, -1.26546388e-02f, 6.78540720e-03f,
  3.37772332e-02f, -1.50186867e-02f, 7.69426348e-03f, 4.88042906e-02f, -1.45502947e-02f, 1.31981932e-02f, 1.74823217e-02f, 2.75122430e-02f, 1.31976809e-02f, -1.15232533e-02f,
  -3.73041332e-02f, 3.16948257e-02f, -4.25615758e-02f, -1.64928120e-02f, 8.94887280e-03f, -3.00855725e-03f, 5.77157363e-02f, 4.33626631e-03f, -1.00199590e-02f, 2.55611981e-03f,
  8.78579766e-02f, -6.29201084e-02f, -4.46719043e-02f, -2.98402086e-02f, -7.82935992e-02f, -2.47684196e-02f, 1.57095268e-02f, 6.85192794e-02f, 4.76894937e-02f, 6.54965360e-03f,
  -2.86324248e-02f, 2.28141341e-02f, -4.34931554e-03f, 3.89945172e-02f, -8.77589919e-03f, 1.85432211e-02f, -6.85346127e-02f, -3.20234895e-02f, -1.02440175e-02f, 5.52219525e-02f,
  -5.10494821e-02f, -9.97582451e-03f, -6.58184215e-02f, -5.43060619e-03f, 1.25602344e-02f, -4.01845761e-02f, -4.25525531e-02f, -1.65208485e-02f, -4.32024226e-02f, 1.16124833e-02f,
  6.91534162e-01f, 2.96982061e-02f, 3.25515419e-01f, 1.40896112e-01f, -7.55846575e-02f, -1.68008432e-01f, -1.47346943e-03f, -2.74756663e-02f, 3.29074800e-01f, -2.44797677e-01f,
  -1.56020418e-01f, 1.98019594e-01f, 5.65526960e-03f, -1.50124133e-01f, 2.89290100e-01f, -6.47110865e-02f, 4.80737165e-02f, 3.60785448e-03f, 4.84204106e-02f, 3.51342298e-02f,
  8.17483664e-02f, -3.03913742e-01f, 9.23053846e-02f, -2.27986410e-01f, 7.88760744e-03f, 3.67597416e-02f, -6.33360222e-02f, 2.49271770e-03f, -2.16355160e-01f, 3.69675979e-02f,
  -7.91043863e-02f, -4.92371619e-02f, 2.78420746e-02f, 4.02937159e-02f, 1.80908199e-02f, 5.54787344e-04f, -2.55517457e-02f, -1.11998124e-02f, 3.85740027e-02f, 4.49604318e-02f,
  -7.36337621e-03f, 4.42076549e-02f, -1.85293406e-02f, 4.92459675e-03f, -1.61084235e-02f, 5.29926866e-02f, 1.37844170e-03f, 3.07006482e-03f, -1.08561460e-02f, -1.51448809e-02f,
  4.10526283e-02f, 2.62074433e-02f, -7.36373197e-03f, 1.82863243e-03f, 2.37482693e-02f, -5.00942096e-02f, -1.01973489e-02f, -2.04183012e-02f, -3.05172931e-02f, 6.26838952e-03f,
  2.23745238e-02f, 6.93423748e-02f, -1.22649129e-02f, 7.77426176e-03f, 4.60242480e-03f, -3.42864655e-02f, 1.04126642e-02f, -1.13568529e-02f, 6.79450333e-02f, -2.85421200e-02f,
  1.82041638e-02f, 1.06535694e-02f, -8.10392853e-03f, 3.41466069e-02f, -5.42168766e-02f, 1.19466230e-03f, 5.96708693e-02f, -3.55849490e-02f, 3.79958674e-02f, 2.31366977e-02f,
  -6.66609174e-03f, 1.58419702e-02f, -2.98372973e-02f, -3.76706608e-02f, -5.12917712e-03f, 2.09544189e-02f, 1.31507087e-02f, 1.95628852e-02f, 6.27704859e-02f, -1.59052201e-02f,
  -1.00996338e-01f, 1.01546027e-01f, 9.25029721e-03f, -1.01736328e-03f, 3.71432379e-02f, -2.70964559e-02f, 4.11425158e-02f, 1.13650309e-02f, -1.51795093e-02f, 1.96179263e-02f,
  7.44654238e-02f, -3.23569067e-02f, -2.03849562e-02f, -3.71343233e-02f, 2.28169914e-02f, 7.48553360e-03f, -1.56206582e-02f, 1.65556092e-02f, -1.14420615e-02f, 5.46655692e-02f,
  -3.17444764e-02f, 2.07430348e-02f, 4.81821373e-02f, -6.40974985e-03f, -4.55263779e-02f, -1.49148880e-02f, 1.48730548e-02f, 5.85018322e-02f, -3.53674702e-02f, 1.67522312e-03f,
  3.78160685e-01f, 8.70254189e-02f, 1.11655921e-01f, 2.31488243e-01f, 1.00602992e-02f, 2.24098176e-01f, 3.41147453e-01f, -8.55645016e-02f, 7.04825521e-02f, 1.37000725e-01f,
  -8.70328024e-02f, 3.87243666e-02f, -4.24421653e-02f, -4.84666266e-02f, 1.18033579e-02f, -6.54396266e-02f, 1.82743341e-01f, 1.10001110e-01f, -8.71367007e-02f, 1.46926388e-01f,
  1.13661345e-02f, -7.26373214e-03f, -1.33144697e-02f, -8.68586227e-02f, 9.63923484e-02f, -4.26435247e-02f, -8.41752335e-04f, 6.26222789e-02f, -5.52005991e-02f, -1.21594697e-01f,
  7.91520998e-02f, 7.95214921e-02f, -6.13027588e-02f, 5.37289726e-03f, 4.21059169e-02f, -1.37607539e-02f, 3.28832492e-02f, -2.95657311e-02f, 3.33429058e-03f, 5.60215600e-02f,
  8.16966370e-02f, -2.66107004e-02f, -4.01334725e-02f, -1.99151896e-02f, 3.32822166e-02f, -4.76063862e-02f, -3.54568660e-02f, -5.24295047e-02f, 3.47333662e-02f, 6.27941685e-03f,
  -4.61539440e-02f, -5.77889457e-02f, 8.39734748e-02f, -8.60655308e-03f, -5.57115301e-03f, 1.79896578e-02f, -3.46638858e-02f, 2.46414430e-02f, 2.24504676e-02f, 2.22558994e-02f,
  -3.43005992e-02f, 3.46489921e-02f, 3.24820355e-02f, -5.10996506e-02f, 7.69965444e-03f, -3.92005406e-02f, 8.32452532e-03f, -2.94642225e-02f, 2.24566590e-02f, 2.34482661e-02f,
  1.72265954e-02f, 4.88453135e-02f, -3.99601646e-02f, 6.31208718e-02f, 4.73582707e-02f, -6.79343985e-03f, 4.30238768e-02f, 1.74308065e-02f, 2.55402327e-02f, -4.93853120e-03f,
  1.50246536e-02f, 5.59946708e-02f, -3.91338430e-02f, 9.01658647e-03f, 2.72144601e-02f, 6.80737616e-03f, -5.32694049e-02f, 2.48559634e-03f, 3.53490631e-03f, 6.11735843e-02f,
  3.15169752e-01f, 3.13458264e-01f, 6.20296337e-02f, -1.13874981e-02f, 1.21868746e-02f, -1.27080921e-02f, -4.44425549e-03f, -2.93226559e-02f, 2.56871842e-02f, -1.25573706e-02f,
  -9.13132913e-04f, 6.16334341e-02f, 4.39092033e-02f, 3.53963263e-02f, 2.06247382e-02f, -5.44647351e-02f, 9.77209806e-02f, 7.70842880e-02f, 7.50283599e-02f, -6.61135167e-02f,
  1.47468252e-02f, -1.49374930e-02f, -5.74229397e-02f, 6.25947770e-03f, 6.58621415e-02f, 1.50841819e-02f, 6.51809126e-02f, 2.44134106e-02f, 2.30242661e-03f, -1.82264075e-02f,
  1.60180166e-01f, -3.88737142e-01f, -5.27336262e-02f, -1.25133157e-01f, 1.17244020e-01f, -9.79113355e-02f, 4.17318977e-02f, -1.89998299e-01f, -3.13418880e-02f, -2.43323565e-01f,
  9.86278802e-02f, -1.01436287e-01f, -6.88322308e-03f, -1.39188707e-01f, 3.48431945e-01f, -2.37606349e-03f, -7.34794512e-02f, -1.22988112e-01f, -3.49957943e-02f, -2.14890778e-01f,
  -1.37132518e-02f, -3.88103686e-02f, 7.37500489e-02f, -5.16215488e-02f, -5.57315052e-02f, -1.26886100e-01f, 1.15067758e-01f, 3.25973406e-02f, -5.92016764e-02f, 1.35969803e-01f,
  9.73226428e-02f, -6.23579994e-02f, 2.58443877e-02f, 7.66931567e-03f, -2.78489981e-02f, 3.62053663e-02f, -9.57765523e-03f, 1.13111265e-01f, 3.50530855e-02f, -1.23997359e-02f,
  2.12014243e-02f, 5.09573109e-02f, -1.83945652e-02f, 3.85362618e-02f, -6.19302765e-02f, -4.22229990e-02f, 2.11065188e-02f, -4.29904833e-02f, -1.22081041e-02f, 2.81384010e-02f,
  2.90626916e-03f, -4.85562161e-02f, -6.21085279e-02f, -5.97475842e-03f, 2.28087534e-03f, -1.35829644e-02f, -4.89166379e-02f, -1.38810289e-03f, -3.54304239e-02f, -3.99114378e-02f,
  -5.53328544e-03f, -4.08596881e-02f, 4.76506129e-02f, 1.36623243e-02f, 3.77140902e-02f, 8.57663865e-04f, -5.36261639e-03f, 3.79906632e-02f, -1.15059940e-02f, -2.33374611e-02f,
  2.89044473e-02f, -6.07210584e-03f, -2.27541979e-02f, 1.72020551e-02f, -1.81050655e-02f, -2.24018972e-02f, 2.88175065e-02f, 1.38593744e-02f, -2.91590672e-02f, 3.39538194e-02f,
  4.39412287e-03f, 4.43287566e-02f, -4.18519825e-02f, 5.03810355e-04f, 3.11020482e-02f, 4.93851192e-02f, -4.39043902e-02f, -2.31746994e-02f, 6.55565187e-02f, 5.97809106e-02f,
  -9.01829228e-02f, -2.46410534e-01f, -2.96967514e-02f, -2.74230586e-03f, 5.35302621e-04f, -3.85573530e-03f, 1.02757551e-02f, -2.80754473e-02f, -5.04959375e-02f, -7.70689221e-03f,
  -4.74063456e-02f, -2.13105213e-02f, -1.85225457e-02f, 7.00443517e-03f, 3.24125364e-02f, -2.46342290e-02f, -6.39901087e-02f, 2.27878224e-02f, -1.66362412e-02f, -7.69261643e-02f,
  -4.20649461e-02f, 3.60707305e-02f, -4.68072394e-04f, -4.26916480e-02f, -4.85849269e-02f, 5.62910922e-03f, -1.52682131e-02f, 5.90968393e-02f, 4.83966991e-02f, -4.02877443e-02f,
  2.34500840e-01f, -1.13986433e-01f, 1.33126959e-01f, -2.34016120e-01f, 8.76832753e-02f, -2.83357680e-01f, -2.34530017e-01f, -7.20616058e-02f, 7.49388477e-03f, -5.22298664e-02f,
  -1.45418480e-01f, 1.98475663e-02f, -2.97217406e-02f, -3.52829665e-01f, -3.27856898e-01f, -1.93018615e-01f, -3.55924040e-01f, -1.28347933e-01f, 9.27313417e-03f, -5.84676899e-02f,
  -9.76597890e-02f, -2.33192131e-01f, -1.96380258e-01f, -2.38565598e-02f, 2.98105199e-02f, 1.04350932e-01f, -2.65348852e-02f, 8.46155509e-02f, -9.58703533e-02f, -4.54904437e-02f,
  -4.50725928e-02f, 2.36992940e-01f, 8.46335739e-02f, 8.29027668e-02f, 3.55642871e-03f, 3.59234735e-02f, 2.60617696e-02f, 1.55568225e-02f, 1.14682605e-02f, -3.43703665e-02f,
  3.13686579e-02f, 5.32329306e-02f, -6.35677502e-02f, 4.61297370e-02f, 6.28656968e-02f, 3.17152888e-02f, 1.60530247e-02f, -1.05712339e-02f, 2.08499259e-03f, 2.76686018e-03f,
  -1.85980592e-02f, 7.87398592e-03f, -8.79322365e-03f, -7.15033114e-02f, 4.41919900e-02f, -2.52349507e-02f, -3.24179083e-02f, 1.80539582e-02f, -2.46097427e-02f, -1.05685014e-02f,
  -3.90920904e-04f, 8.82896967e-03f, -2.98616826e-03f, -2.12179348e-02f, -3.85504812e-02f, 2.64708586e-02f, -5.78264296e-02f, 1.06969988e-02f, 4.29578498e-02f, -3.52731869e-02f,
  -8.09843093e-02f, -4.75579267e-03f, -2.36667357e-02f, 3.11588286e-03f, -1.02060810e-02f, -9.00717452e-03f, 1.45039102e-02f, -2.12960076e-02f, -1.40614090e-02f, -1.22553268e-02f,
  8.09645280e-03f, -3.12558487e-02f, -3.14898044e-02f, -1.74565129e-02f, -5.28750606e-02f, 2.82509457e-02f, 4.63236608e-02f, 1.65061711e-03f, 2.01013368e-02f, -2.26783510e-02f,
  -8.97821635e-02f, -9.30640474e-02f, -6.79325163e-02f, -2.21895184e-02f, -1.90247372e-02f, -3.09124552e-02f, -5.07671162e-02f, 3.08510736e-02f, -2.41450761e-02f, -1.01518584e-02f,
  1.56867467e-02f, -1.89201180e-02f, 5.48772514e-02f, -1.84352486e-03f, -1.86834149e-02f, -4.68385182e-02f, -3.15200724e-02f, 2.74686459e-02f, -8.49574879e-02f, -1.28120128e-02f,
  -6.38582138e-03f, 2.20059813e-03f, 4.39106748e-02f, 2.36198995e-02f, -2.94268336e-02f, -3.58293205e-03f, -3.01590618e-02f, 2.91680433e-02f, 3.66365165e-02f, 1.15452439e-03f,
  -6.67023957e-01f, 2.69969106e-02f, 3.20531949e-02f, -3.43544155e-01f, -1.69663906e-01f, 1.37697589e-02f, 1.24784680e-02f, -1.20159119e-01f, -3.66164856e-02f, 4.78285402e-02f,
  -3.20240632e-02f, -6.31498620e-02f, 2.77554810e-01f, -1.62357800e-02f, 7.13179586e-03f, 3.00183475e-01f, -8.15980136e-02f, -2.69197859e-02f, 1.26264632e-01f, -1.87940881e-01f,
  -1.25231177e-01f, -6.47289604e-02f, 5.77145554e-02f, 1.47427712e-02f, -2.05950454e-01f, -1.46535188e-01f, -1.22429498e-01f, 1.06286310e-01f, -2.53182530e-01f, 3.16518769e-02f,
  -2.07961835e-02f, 6.51253685e-02f, -6.19534515e-02f, 8.63979757e-02f, -1.00576609e-01f, -4.63852286e-02f, -9.96951684e-02f, 1.03340410e-01f, 5.41568082e-03f, 1.06080715e-02f,
  -3.08630858e-02f, -2.92305090e-02f, -4.52845357e-02f, 6.76275939e-02f, 9.02161188e-03f, -1.23570869e-02f, -1.72107443e-02f, -5.34164906e-02f, -1.35562168e-02f, 1.36702359e-02f,
  4.45167944e-02f, -1.96360648e-02f, -2.29525045e-02f, -6.28137290e-02f, -7.22320471e-03f, 1.99899031e-03f, -2.22309735e-02f, 5.38528245e-03f, -1.47831887e-02f, -7.78248757e-02f,
  4.00327705e-02f, 3.73987816e-02f, 5.65307913e-03f, 4.65642894e-03f, -2.74544228e-02f, -3.68252620e-02f, -1.10454969e-02f, 3.79275195e-02f, -5.07815965e-02f, -1.97608210e-03f,
  -7.73784667e-02f, -4.31858711e-02f, -4.23576590e-03f, 1.13523221e-02f, -5.93438111e-02f, -1.98526643e-02f, 1.99051816e-02f, 7.38034071e-03f, -5.62924817e-02f, -1.48063963e-02f,
  4.63503972e-02f, -6.62485417e-03f, 1.32010356e-02f, 1.91180652e-03f, 4.68707979e-02f, 1.33514190e-02f, 4.55611534e-02f, 3.21930088e-02f, 2.44160052e-02f, -3.25260386e-02f,
  -9.19467136e-02f, -8.52923989e-02f, 3.47662829e-02f, 4.36520379e-04f, 3.18326950e-02f, 2.00420562e-02f, 6.26674816e-02f, -8.97674039e-02f, 2.18470432e-02f, -1.44722452e-02f,
  -3.85231078e-02f, -3.63782644e-02f, -6.70050532e-02f, -2.98730913e-03f, 4.98108473e-03f, -1.08482514e-03f, -3.38244289e-02f, -2.55065337e-02f, -7.58050606e-02f, -2.95331739e-02f,
  -5.74991181e-02f, -4.46705939e-03f, 8.80763493e-03f, -5.23165986e-02f, -6.41677231e-02f, -6.04396798e-02f, -6.49641305e-02f, 1.40255783e-02f, -3.84400301e-02f, 2.57428847e-02f,
  2.83912808e-01f, 4.39159535e-02f, 4.31470871e-02f, 8.88365284e-02f, -1.41803220e-01f, -1.73413400e-02f, -1.94925480e-02f, -4.09084074e-02f, 8.79907683e-02f, -9.69953388e-02f,
  6.61247075e-02f, 1.92913711e-01f, 1.34615377e-01f, -4.40487787e-02f, 4.23782647e-01f, 1.99979082e-01f, 1.64125696e-01f, 9.92973745e-02f, 3.41418348e-02f, 8.49716589e-02f,
  6.40507191e-02f, -5.29664978e-02f, 2.49200705e-02f, -1.81943491e-01f, -1.46471903e-01f, -1.06381863e-01f, -1.54813211e-02f, -6.93711042e-02f, -6.27995804e-02f, 2.37178300e-02f,
  -3.55517305e-02f, 1.35143131e-01f, -1.29791349e-01f, 2.43041757e-02f, 4.33468632e-02f, 2.82623619e-02f, -4.71729413e-02f, -1.35184848e-03f, -3.02687883e-02f, -8.01482275e-02f,
  4.59444299e-02f, -7.27713183e-02f, -5.70788346e-02f, 6.56556280e-04f, -3.32705602e-02f, 2.62366310e-02f, -5.09471856e-02f, -4.75541465e-02f, -8.20050836e-02f, -6.47288328e-03f,
  -9.18736588e-03f, -4.51264717e-02f, 6.39023036e-02f, -3.74279656e-02f, -3.11296768e-02f, 3.60962935e-03f, -4.64564897e-02f, -7.67191814e-04f, -3.85203473e-02f, -2.58713271e-02f,
  1.34482244e-02f, -2.79454980e-02f, -7.36460695e-03f, -1.00801783e-02f, 1.89211387e-02f, -1.22870458e-02f, 3.16674844e-03f, -3.88944149e-02f, -2.57794745e-02f, -1.02052903e-02f,
  6.21306151e-02f, -3.38059179e-02f, 4.51242104e-02f, -7.69730136e-02f, 2.02397089e-02f, 1.52213238e-02f, 2.46255342e-02f, -4.78430204e-02f, -3.99053358e-02f, 6.16163202e-03f,
  3.50224599e-02f, 1.64322518e-02f, -3.13700968e-03f, 6.91212853e-03f, 1.08172838e-02f, -3.47607136e-02f, -3.74625959e-02f, -3.77013278e-03f, -2.39685141e-02f, -4.33110213e-03f,
  1.82863474e-01f, 3.26640904e-01f, -1.23003554e-02f, -4.24086824e-02f, -3.08420300e-03f, 2.08510738e-02f, 8.02981406e-02f, -2.64147520e-02f, 2.51913723e-02f, 3.72291170e-02f,
  -1.10785209e-01f, -4.57240315e-03f, 6.47768974e-02f, -3.43884081e-02f, 2.37834500e-03f, -1.22858109e-02f, 5.31879663e-02f, -5.69963045e-02f, 2.96925064e-02f, 4.97564487e-02f,
  4.20022942e-02f, 1.94860380e-02f, -5.38757145e-02f, 2.89717000e-02f, -2.85141673e-02f, 1.59431174e-02f, 1.11277655e-01f, -6.05900586e-02f, 1.37740131e-02f, -2.97810091e-03f,
  1.63385361e-01f, 7.86258578e-02f, 3.71157140e-01f, 2.15163827e-01f, -3.03914607e-01f, 2.92084329e-02f, 2.87731439e-01f, -1.98975220e-01f, 1.32144347e-01f, 3.77383293e-03f,
  -1.39340594e-01f, 1.71448842e-01f, 1.04392394e-01f, 4.34337594e-02f, -1.14114853e-02f, 3.05439621e-01f, -2.65519973e-02f, 6.43896759e-02f, 6.46906644e-02f, -1.51050419e-01f,
  1.37724295e-01f, -2.41441116e-01f, 1.46909848e-01f, -3.39320779e-01f, 2.55512856e-02f, -6.33053929e-02f, -2.12071359e-01f, -1.73785947e-02f, -1.67536885e-01f, -7.60480464e-02f,
  -1.02620751e-01f, 5.94020635e-02f, 2.70153880e-02f, -5.92569634e-02f, -2.18343232e-02f, 3.20787802e-02f, 3.94036062e-02f, 4.69954945e-02f, 1.49741480e-02f, 4.04722095e-02f,
  5.94725087e-02f, -3.34182456e-02f, 7.34501285e-03f, 3.46964821e-02f, 5.01346737e-02f, -2.47222139e-03f, 3.81771587e-02f, -7.75029091e-03f, -7.59431208e-03f, -8.27242061e-03f,
  1.94036923e-02f, 2.68408302e-02f, 2.85990629e-02f, -2.16733217e-02f, 7.25365356e-02f, -2.42918637e-03f, 5.42800613e-02f, -9.36009455e-03f, 1.36757903e-02f, -6.97577149e-02f,
  -1.61533300e-02f, 9.40739270e-03f, -1.60074327e-02f, -4.52048108e-02f, 2.01534270e-03f, -2.43734736e-02f, 3.26774940e-02f, -4.91694883e-02f, 3.63923586e-03f, -2.18908843e-02f,
  -6.99627772e-02f, 4.75020893e-02f, 2.22992226e-02f, 8.15957859e-02f, -1.28991168e-03f, 2.96501853e-02f, -1.98961608e-02f, -2.66730003e-02f, 1.42459068e-02f, -3.91203836e-02f,
  3.27758193e-02f, -2.77397931e-02f, 4.76104394e-02f, -2.76271626e-02f, -4.12955806e-02f, 2.97542047e-02f, 6.36147931e-02f, 5.22696711e-02f, -3.68986191e-04f, -1.03606703e-02f,
  -1.88301116e-01f, -1.26617819e-01f, -1.04230084e-01f, -9.87403002e-03f, -9.41503495e-02f, -6.69772997e-02f, -2.93032303e-02f, -5.61636128e-03f, 1.54707795e-02f, -6.86898753e-02f,
  -3.62734459e-02f, -2.89130881e-02f, 7.73572642e-03f, 1.81921646e-02f, -2.22198050e-02f, -7.94095770e-02f, 1.80196725e-02f, -4.07725871e-02f, -7.71220848e-02f, -1.79324392e-02f,
  -2.67337877e-02f, -1.59127766e-03f, -8.10891539e-02f, -8.09215903e-02f, 1.87340789e-02f, 6.01962209e-03f, -5.56602143e-02f, -1.03355050e-02f, -4.61434163e-02f, 9.43140651e-04f,
  -8.97088200e-02f, 4.41126823e-01f, 2.49055713e-01f, -9.68381856e-03f, -2.26688817e-01f, -1.79716185e-01f, 8.69573839e-03f, 3.54173891e-02f, 1.32354582e-02f, 3.11827749e-01f,
  -1.54694477e-02f, 3.85500565e-02f, 4.76285294e-02f, 1.48517400e-01f, -3.50793868e-01f, -1.10146850e-02f, -7.92835373e-03f, 8.50370079e-02f, 1.05612641e-02f, 9.00548473e-02f,
  -2.71019936e-02f, -6.81619495e-02f, 1.06360823e-01f, 2.47312412e-02f, 1.05468668e-01f, 1.19127311e-01f, -9.27713420e-03f, 3.17047834e-02f, 3.66555080e-02f, -5.85782751e-02f,
  -1.53791932e-02f, 5.78413196e-02f, 1.28576681e-01f, 4.09847461e-02f, 4.48221117e-02f, 7.16777369e-02f, -1.98574010e-02f, -1.21385582e-01f, -2.61734556e-02f, 5.76169565e-02f,
  -2.20611244e-02f, -1.96573008e-02f, 8.31218343e-03f, -4.13525030e-02f, -5.42615764e-02f, 4.10407186e-02f, 2.14535203e-02f, -1.84811596e-02f, 2.35816371e-02f, -7.53445476e-02f,
  6.04787543e-02f, 1.55566512e-02f, -1.25501668e-02f, -2.97245872e-03f, -5.98114496e-03f, 1.71803664e-02f, 3.93678155e-03f, -1.07414098e-02f, -4.02058102e-02f, -5.20177046e-03f,
  -9.95780528e-03f, -3.77062447e-02f, 1.35884266e-02f, 2.34782137e-02f, -9.33630951e-03f, 1.88805312e-02f, 2.59545147e-02f, -9.67062451e-03f, -2.12252699e-02f, -1.12512624e-02f,
  -7.69826770e-03f, 9.62299854e-03f, -3.13159600e-02f, -4.93324958e-02f, -2.31609307e-03f, 4.34402889e-03f, -2.47154329e-02f, -6.28797291e-03f, 1.12383692e-02f, 2.56028716e-02f,
  -1.79997936e-03f, -1.09363552e-02f, 3.43344291e-03f, -2.08313717e-03f, 7.47959921e-03f, -8.24472029e-03f, -1.52167177e-03f, -6.26512663e-03f, 3.09504252e-02f, -2.90645257e-04f,
  -8.39946698e-03f, 1.26205519e-01f, -7.80520076e-03f, -8.97517987e-03f, 1.33412695e-02f, -6.93209320e-02f, -2.48276293e-02f, 6.12071194e-02f, 8.59149266e-03f, -3.65894809e-02f,
  -7.97851128e-04f, 3.27504762e-02f, -5.94365895e-02f, -3.86635512e-02f, -2.31883600e-02f, 4.67507727e-03f, 1.47538744e-02f, 2.15878189e-02f, -3.94183137e-02f, 3.26414555e-02f,
  -6.02585450e-03f, -1.23285560e-03f, -1.63290873e-02f, -1.54673010e-02f, -5.34060635e-02f, 2.71084066e-02f, -8.76563415e-02f, 4.43444438e-02f, -2.04976946e-02f, 1.15130730e-02f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.06013858e-01f, -1.09260887e-01f, -5.69175631e-02f, 2.88371921e-01f, -1.66105419e-01f, -3.84711742e-01f, -3.08200419e-01f, 1.29275210e-03f, -1.73121914e-01f, -7.37091601e-02f,
  -3.13941613e-02f, 8.05170909e-02f, -9.02162641e-02f, 1.59064472e-01f, 1.60902515e-01f, -1.87207349e-02f, 1.39685750e-01f, -4.83440934e-03f, 3.48051898e-02f, 7.95693323e-02f,
  2.97615588e-01f, 2.27950841e-01f, 3.14814180e-01f, 1.73981160e-01f, 1.20375358e-01f, 2.81373948e-01f, 3.87958229e-01f, 7.34578026e-03f, 2.45601833e-01f, 1.26972958e-01f,
  -5.51885962e-02f, 4.35455851e-02f, 3.95953618e-02f, -2.51521226e-02f, 3.01087853e-02f, -2.07425728e-02f, 4.71718125e-02f, -4.39081620e-03f, -1.62543040e-02f, -3.89682152e-03f,
  -1.21392664e-02f, 1.03745647e-02f, 2.75562387e-02f, 4.24833670e-02f, -4.52635475e-02f, 1.24750985e-02f, -1.61128305e-02f, -2.29831636e-02f, -8.94223675e-02f, 6.21776143e-03f,
  -1.02107443e-01f, -9.05981213e-02f, -3.39475423e-02f, -5.18872999e-02f, 6.73437491e-02f, -4.29440178e-02f, -2.46681087e-02f, 3.39356624e-02f, -6.42220154e-02f, 3.93302962e-02f,
  -6.60621002e-03f, 2.84754112e-02f, -5.48262820e-02f, -1.66020375e-02f, 2.67206840e-02f, 8.95309635e-03f, 1.83150917e-02f, 1.33972587e-02f, 9.62481722e-02f, 4.02828977e-02f,
  -6.50993139e-02f, 2.37855669e-02f, 1.91338453e-02f, -6.87091872e-02f, -6.07343111e-03f, -8.29398111e-02f, -1.23457778e-02f, -3.17375101e-02f, 2.32173763e-02f, -2.59921476e-02f,
  -5.33707663e-02f, -5.19023761e-02f, 1.29608111e-02f, -1.77916083e-02f, -6.41216524e-03f, -8.12555943e-03f, 4.39187251e-02f, 3.09681520e-02f, -3.80652733e-02f, -1.25646451e-02f,
  2.26183347e-02f, 2.67737567e-01f, -1.29086534e-02f, -3.89029384e-02f, 4.77368236e-02f, -2.39703916e-02f, -3.01860552e-02f, -1.11544123e-02f, 8.60856846e-02f, -1.23452619e-02f,
  4.01958302e-02f, -3.28585654e-02f, -2.49260832e-02f, -3.67183685e-02f, -1.83257461e-02f, 1.18993092e-02f, 7.12715760e-02f, 6.97988644e-02f, 2.45746747e-02f, 1.02577470e-01f,
  5.11430353e-02f, -8.86036977e-02f, 9.86035634e-03f, -1.08446933e-01f, 2.33433023e-02f, -1.46041159e-02f, -2.42686272e-02f, 3.40479836e-02f, 6.78578168e-02f, -3.97978164e-02f,
  1.71766058e-01f, 1.34146094e-01f, 9.28938836e-02f, 1.15041219e-01f, 1.14470959e-01f, 4.62399647e-02f, 3.78910638e-02f, 9.81497988e-02f, 3.93267781e-01f, -4.48033167e-03f,
  1.23547083e-02f, 3.13679650e-02f, -4.80719395e-02f, 1.34586513e-01f, -2.12861970e-02f, -7.07081556e-02f, 2.24807020e-02f, 5.11890128e-02f, 1.75994426e-01f, 6.44438118e-02f,
  6.72848821e-02f, -9.72458273e-02f, -1.45836815e-01f, -1.92908227e-01f, -4.52198437e-04f, -9.35307741e-02f, -1.59110799e-01f, -1.28453210e-01f, -7.61893019e-02f, -3.14671881e-02f,
  6.50330447e-03f, 1.04406625e-01f, 7.09837377e-02f, 2.76127420e-02f, -3.63500267e-02f, 5.83754154e-03f, -4.15173732e-02f, -4.28173058e-02f, 3.88756816e-05f, 4.20435481e-02f,
  -3.64476219e-02f, -6.40468001e-02f, 5.18829040e-02f, 5.36438935e-02f, 6.88141435e-02f, -6.43392652e-02f, -5.31605817e-02f, 1.80455465e-02f, 4.11836281e-02f, -7.98371993e-03f,
  -2.45058280e-03f, 4.60382551e-02f, -1.71312201e-03f, 2.09816583e-02f, 1.91786084e-02f, 5.78364581e-02f, 6.45981804e-02f, -5.72749339e-02f, 4.82214279e-02f, 1.14215724e-01f,
  -3.59750204e-02f, 1.21960454e-01f, 3.71559262e-02f, -1.12855416e-02f, -5.57518266e-02f, -1.79147087e-02f, -1.98464449e-02f, -5.65276146e-02f, 1.50852082e-02f, 7.48940706e-02f,
  -5.85401580e-02f, 8.35449323e-02f, 6.81149811e-02f, -7.92989507e-02f, 9.36133340e-02f, 1.17205717e-02f, -5.90318292e-02f, 7.01633561e-03f, 2.27700509e-02f, -2.11643390e-02f,
  2.27170587e-02f, 2.22175140e-02f, 1.05797751e-02f, -9.91099253e-02f, -3.18836011e-02f, 2.13220567e-02f, -5.00641838e-02f, -1.26606338e-02f, -2.29304396e-02f, -2.15469562e-02f,
  2.04773732e-02f, 1.75589487e-01f, 7.58763477e-02f, -1.43111534e-02f, -4.18218113e-02f, 4.49011773e-02f, 1.01090066e-01f, 1.37371861e-03f, -4.00439836e-03f, 3.53442393e-02f,
  4.19414788e-02f, 5.46276830e-02f, 8.58467259e-03f, 1.39544550e-02f, -2.40461696e-02f, 2.02501193e-02f, 5.07916026e-02f, 3.46769318e-02f, 1.91766061e-02f, -3.65141816e-02f,
  -1.51597206e-02f, -1.97408255e-02f, -1.51314717e-02f, -4.55402546e-02f, -5.02741635e-02f, -4.61907825e-03f, -3.39521915e-02f, -4.21890952e-02f, -2.56110542e-02f, -1.43263154e-02f,
  2.78057992e-01f, -5.03116012e-01f, 4.77109896e-03f, 2.65136659e-01f, 3.35010231e-01f, 1.48420949e-02f, 1.98916271e-01f, 8.26712027e-02f, 3.38807017e-01f, -3.54691595e-01f,
  -4.57878970e-02f, -2.96453983e-01f, -2.77022570e-01f, 9.02812462e-03f, 1.71530172e-01f, -9.76170301e-02f, 9.06370878e-02f, 2.97639286e-03f, 1.45779446e-01f, 3.02649830e-02f,
  2.53745258e-01f, 1.07997723e-01f, 4.33566868e-02f, -2.22413205e-02f, 1.59038275e-01f, 1.15128960e-02f, -5.97038455e-02f, -1.02435738e-01f, -1.05921187e-01f, 1.98942237e-02f,
  2.76055746e-02f, 1.94784582e-01f, 3.41116861e-02f, -1.19929381e-01f, 2.72398554e-02f, -9.08865407e-03f, -7.04009458e-02f, -1.08588040e-01f, 1.01033568e-01f, 3.78807560e-02f,
  -1.15606911e-01f, -8.66473764e-02f, 5.63958324e-02f, 7.00141415e-02f, 7.04310462e-02f, 6.02346100e-02f, 7.12226406e-02f, -6.47771684e-03f, -2.00273772e-03f, -9.99586377e-03f,
  -2.43101586e-02f, -3.32290307e-02f, 6.21554665e-02f, -1.09991096e-01f, 3.31502892e-02f, 4.24134247e-02f, 3.14018130e-02f, -3.10070328e-02f, 2.21940763e-02f, 5.70639409e-02f,
  -2.72829719e-02f, 6.95757270e-02f, -4.44519110e-02f, 2.96763089e-02f, -2.79635154e-02f, 9.38092172e-02f, -5.13332784e-02f, -6.02842085e-02f, -3.73892002e-02f, -2.38524489e-02f,
  -7.95417093e-03f, 4.82454821e-02f, 2.08087694e-02f, 2.58786771e-02f, 1.32715683e-02f, 1.68663003e-02f, -3.00407372e-02f, -7.47497976e-02f, 3.16037349e-02f, 6.70847744e-02f,
  -1.11761922e-02f, -1.81460381e-02f, -2.12312900e-02f, 8.06187019e-02f, -2.79048774e-02f, -4.17238213e-02f, 5.42204827e-03f, -4.54081595e-02f, 6.70589805e-02f, -5.90452217e-02f,
  -3.38491470e-01f, -3.50221008e-01f, -7.67628709e-03f, -5.65069355e-02f, -6.11187667e-02f, -2.66714580e-03f, -8.47486313e-03f, -7.68449577e-03f, -8.93051177e-02f, -3.37209180e-02f,
  4.79928777e-02f, 1.98598076e-02f, -8.83975625e-02f, -4.60739583e-02f, -6.36235029e-02f, -4.47902493e-02f, 2.39516748e-03f, -7.66338408e-02f, 7.65836099e-03f, -4.14526388e-02f,
  2.41640513e-03f, -2.75532901e-02f, 1.82452630e-02f, 5.94531000e-02f, 3.40440730e-03f, -3.68653797e-02f, 2.99595688e-02f, -6.72537461e-02f, -1.03617296e-01f, -4.71428446e-02f,
  -2.60471582e-01f, 2.62419581e-01f, -2.02878699e-01f, 1.54463366e-01f, -3.11948866e-01f, 2.55765766e-01f, 2.13372394e-01f, -1.89594179e-02f, 3.19678038e-02f, 3.88402075e-01f,
  1.35042712e-01f, -4.97826673e-02f, 1.20686710e-01f, 3.47502172e-01f, -9.11642164e-02f, 2.47749373e-01f, 2.46551275e-01f, 2.35535905e-01f, -1.05967358e-01f, -2.90807616e-02f,
  -1.02898166e-01f, 1.74675196e-01f, 3.67642790e-02f, -1.13082580e-01f, -4.12712395e-02f, -1.91249266e-01f, -6.66021407e-02f, -2.49400765e-01f, 6.60982653e-02f, -1.69073027e-02f,
  6.15434162e-02f, -1.30960390e-01f, -9.35315490e-02f, -1.11080026e-02f, -6.51526749e-02f, -1.90263931e-02f, -2.70772800e-02f, -5.90899475e-02f, -8.71216282e-02f, 1.20906439e-02f,
  -4.23033312e-02f, -8.00468586e-03f, -1.12563949e-02f, -5.76472394e-02f, -1.10377884e-02f, -1.82821974e-02f, -6.00883458e-03f, 5.53919896e-02f, 7.00371042e-02f, -6.59707263e-02f,
  -1.30976290e-02f, -3.37733813e-02f, -2.20191255e-02f, 7.09928796e-02f, -1.89966075e-02f, -7.99775124e-03f, 5.42129576e-02f, -7.65351802e-02f, 3.71069647e-02f, 2.13568546e-02f,
  -4.21385765e-02f, 4.69005406e-02f, 3.28246877e-02f, -5.11905216e-02f, -5.17952144e-02f, -1.90243702e-02f, 1.20203327e-02f, -3.49111408e-02f, 1.30990820e-05f, 3.79802249e-02f,
  -6.30770158e-03f, 6.25422050e-04f, -6.61506876e-02f, 8.59511942e-02f, -6.34094991e-04f, 7.66330212e-02f, -2.94380430e-02f, -5.92185296e-02f, 2.91466303e-02f, 1.46660656e-02f,
  5.29594496e-02f, -3.85789201e-02f, 5.35860173e-02f, 9.66739655e-02f, 3.35777327e-02f, 2.40630913e-03f, 5.31441048e-02f, 1.18957348e-02f, 8.14167187e-02f, -6.91993758e-02f,
  1.26669094e-01f, 3.58465575e-02f, 3.39220911e-02f, -3.81843373e-02f, 7.20871240e-02f, -6.40462115e-02f, 2.13472974e-02f, 8.36491119e-03f, -1.31863868e-02f, -6.30108118e-02f,
  4.99298088e-02f, -7.18924403e-02f, 2.22432390e-02f, -1.95580628e-02f, 1.42240608e-02f, 9.48271528e-02f, 2.98455078e-02f, -2.41769273e-02f, -2.06771716e-02f, -3.18021066e-02f,
  -5.54229282e-02f, -5.64143360e-02f, 1.81248337e-02f, 5.49393194e-03f, 2.78323833e-02f, 4.51915003e-02f, -4.60560210e-02f, 1.40163237e-02f, -1.10798605e-01f, 1.54811097e-02f,
  -3.15543078e-02f, 8.66712034e-02f, -3.59376609e-01f, -2.98380941e-01f, -7.29957074e-02f, -4.64112788e-01f, -3.52106243e-01f, -6.77799731e-02f, 1.76708698e-01f, 1.16664439e-01f,
  1.98626127e-02f, 4.07006331e-02f, 2.25217536e-01f, -1.93617150e-01f, -1.47039324e-01f, 1.36965901e-01f, -3.46854061e-01f, -1.60405621e-01f, 1.23411685e-01f, -1.33122891e-01f,
  -1.50190100e-01f, -1.50302172e-01f, -2.69657850e-01f, 5.19195721e-02f, -2.59185851e-01f, 8.85627884e-03f, 1.07106462e-01f, 5.07628098e-02f, -2.11606726e-01f, 4.66001369e-02f,
  4.21511242e-03f, 2.58726805e-01f, -1.55060500e-01f, -3.26598133e-03f, -1.41860411e-01f, -9.82430354e-02f, -1.41196594e-01f, -7.28514865e-02f, -4.79263738e-02f, -2.34464612e-02f,
  2.88066566e-02f, 1.18981421e-01f, -4.13911752e-02f, -1.84801687e-02f, -8.97691771e-02f, -1.77490022e-02f, -2.80335303e-02f, -7.47370422e-02f, 1.97867136e-02f, -4.59277555e-02f,
  -9.48930457e-02f, -1.00757666e-01f, -1.24366008e-01f, -3.20803970e-02f, -1.06300198e-01f, -3.39722005e-03f, -6.18560649e-02f, -8.95058587e-02f, -6.40535280e-02f, -2.72889007e-02f,
  -1.05312690e-01f, 5.45634776e-02f, -1.28831407e-02f, 1.61552448e-02f, 2.31847838e-02f, 2.67459545e-02f, -6.56966306e-03f, 1.33562544e-02f, 7.04609277e-03f, 4.22599576e-02f,
  -1.91575792e-02f, -1.30878873e-02f, 6.98038936e-02f, -1.23886131e-01f, -3.73459235e-02f, 1.91320665e-02f, -3.74579653e-02f, 3.11055165e-02f, -5.30538782e-02f, -1.40223652e-02f,
  1.09703653e-01f, -2.70956699e-02f, 4.99628251e-03f, -2.57422663e-02f, 2.29441896e-02f, 1.32073527e-02f, 1.62804276e-02f, 4.42631356e-02f, 3.31970155e-02f, -3.09743211e-02f,
  -1.97708942e-02f, 8.57038125e-02f, 9.54922140e-02f, 5.56611270e-03f, 1.34943994e-02f, -4.01647463e-02f, -4.63087596e-02f, -2.77821030e-02f, -4.87295464e-02f, 2.42518708e-02f,
  -1.06628776e-01f, -4.55610752e-02f, -6.56787083e-02f, 3.80877666e-02f, -1.07604603e-04f, -4.52804267e-02f, -7.43184704e-03f, -5.87917771e-03f, -5.18371239e-02f, -4.95735146e-02f,
  1.26994587e-02f, 5.04835099e-02f, -3.93345803e-02f, -3.78391221e-02f, -1.81744006e-02f, -1.47906169e-02f, -2.52416357e-02f, -3.70616675e-03f, -6.23740815e-02f, -2.60832701e-02f,
  -3.65550183e-02f, -2.14815184e-01f, -7.10378066e-02f, -4.04808372e-02f, 5.85476086e-02f, 1.39723092e-01f, 7.51638636e-02f, -1.70009062e-01f, -1.28184214e-01f, -1.06726803e-01f,
  1.67333474e-03f, 1.04409464e-01f, -7.31950104e-02f, 9.56911445e-02f, 1.71153277e-01f, -2.16251593e-02f, 8.33969116e-02f, 1.42412409e-01f, -7.90453926e-02f, -1.08762018e-01f,
  -6.02489226e-02f, 1.03819489e-01f, 6.05028979e-02f, -2.39153877e-02f, 5.68265580e-02f, -1.61272846e-02f, 1.18400641e-01f, -3.61265466e-02f, 5.64790331e-02f, 8.72514322e-02f,
  -1.00565832e-02f, -1.06642365e-01f, -3.26632932e-02f, 2.05238741e-02f, -4.56277803e-02f, 3.95155512e-02f, 3.35511044e-02f, 4.27893251e-02f, 4.38224226e-02f, 5.77354878e-02f,
  -3.18766828e-03f, 1.74837075e-02f, -6.39748015e-03f, -5.66626154e-02f, -5.10968342e-02f, -9.15202796e-02f, 1.25152254e-02f, 1.37144532e-02f, 3.06390151e-02f, -6.90617263e-02f,
  1.76536255e-02f, 5.56848608e-02f, -1.03751913e-01f, -4.33847755e-02f, 2.83673555e-02f, -6.48561716e-02f, 1.00095317e-01f, -6.13081688e-03f, -6.01027869e-02f, -3.14309187e-02f,
  -4.69538644e-02f, -6.10472970e-02f, 7.76443165e-03f, -3.74123454e-02f, -7.76345134e-02f, 2.57951319e-02f, -5.16564921e-02f, -8.85339901e-02f, -2.45125052e-02f, 1.12203965e-02f,
  -7.52335265e-02f, 7.03170151e-02f, 2.66920682e-02f, 4.05153856e-02f, -4.45523188e-02f, 5.96325882e-02f, 2.64781136e-02f, 5.55662028e-02f, -1.43678742e-03f, 7.40299970e-02f,
  -3.90689485e-02f, -5.19725755e-02f, -4.90602739e-02f, -4.07333970e-02f, 2.29927618e-02f, 2.92997546e-02f, -4.20350432e-02f, -6.57433318e-03f, -1.15459464e-01f, 2.34494172e-02f,
  5.84172532e-02f, -6.74030036e-02f, -6.66296855e-03f, 1.31774237e-02f, -1.05911121e-02f, 3.24518129e-04f, 1.00013269e-02f, 8.16265587e-03f, -5.21777719e-02f, -2.12304331e-02f,
  3.49661112e-02f, -1.17581058e-02f, -2.58833822e-02f, 9.09735784e-02f, -3.24274115e-02f, 1.93860161e-03f, 3.51958089e-02f, -5.29398136e-02f, 3.97194037e-03f, 3.49955112e-02f,
  1.84997357e-02f, 2.91903932e-02f, 2.52849534e-02f, 3.41675617e-02f, -4.25069518e-02f, 2.39515714e-02f, -6.09267391e-02f, -3.17815766e-02f, 9.60346982e-02f, -7.72545561e-02f,
  7.40680844e-02f, -7.10439496e-03f, -1.78682595e-01f, -1.82747722e-01f, -1.20096475e-01f, 1.49175182e-01f, 9.27036256e-03f, -3.00141834e-02f, -2.90156573e-01f, 3.39620799e-01f,
  9.18277428e-02f, -9.97593775e-02f, -7.69557133e-02f, -9.00557786e-02f, -4.19214964e-01f, -2.01400399e-01f, 4.76058498e-02f, 1.11353278e-01f, -1.38991758e-01f, 8.41487572e-02f,
  -3.28102000e-02f, -8.55202973e-02f, -8.31284374e-02f, -1.88971423e-02f, 1.25604779e-01f, 1.77422702e-01f, 2.33318061e-01f, 2.36643720e-02f, 1.21720783e-01f, -6.90144897e-02f,
  4.05747369e-02f, 3.83262634e-02f, 2.70975120e-02f, -4.58707064e-02f, 1.12679102e-01f, 1.61587358e-01f, 1.22445531e-01f, -1.07510202e-02f, -3.26650254e-02f, -6.45623878e-02f,
  -9.99836624e-03f, 8.15782510e-03f, -6.97853118e-02f, -6.14945628e-02f, 6.86923191e-02f, -7.04917908e-02f, -5.25368676e-02f, 1.81582682e-02f, -1.26485437e-01f, 2.45716865e-03f,
  -2.25719437e-02f, 2.49609388e-02f, 2.88342852e-02f, -6.34405762e-02f, -1.37295365e-01f, 1.61117059e-03f, 4.94315289e-02f, -5.98647036e-02f, 3.64559107e-02f, -1.27216816e-01f,
  7.95909539e-02f, 7.65503570e-02f, 8.79823696e-03f, -9.22836885e-02f, -1.50249992e-02f, -5.32040885e-03f, -1.80429686e-02f, 3.80507670e-02f, -9.65669472e-03f, -2.04157643e-02f,
  1.73693092e-03f, -2.56746504e-02f, 6.45435154e-02f, 8.90225768e-02f, -1.99165884e-02f, 5.24024665e-03f, 8.15388262e-02f, -3.18082459e-02f, -7.14746043e-02f, 3.51133458e-02f,
  -4.09634449e-02f, -4.45977524e-02f, 1.72864683e-02f, 1.12930452e-02f, -1.83579847e-02f, -4.16367054e-02f, 1.67290531e-02f, 5.36289215e-02f, 2.15515830e-02f, 4.16028090e-02f,
  7.18312562e-02f, 5.14931753e-02f, 1.35800643e-02f, -1.23056374e-01f, -9.43444204e-03f, 5.09754792e-02f, -4.77306060e-02f, -1.87411364e-02f, 4.09808680e-02f, 1.38765052e-02f,
  1.47167191e-01f, -1.19897062e-02f, 1.31214142e-01f, -4.58143018e-02f, -5.66472597e-02f, 8.08159728e-03f, -2.85364920e-04f, -4.06952538e-02f, 6.09685183e-02f, -1.84903629e-02f,
  5.92230111e-02f, 2.31652800e-02f, 7.68926181e-03f, -7.12177232e-02f, 3.34183648e-02f, 8.27351660e-02f, 4.49042320e-02f, 1.55684799e-02f, 3.28271985e-02f, 3.95493060e-02f,
  2.23907661e-02f, 1.43797398e-01f, -1.47065416e-01f, 1.76767319e-01f, -5.10465503e-02f, 9.18080509e-02f, 3.46965939e-02f, -2.49118246e-02f, 3.80209349e-02f, 9.66491476e-02f,
  1.15513681e-02f, -2.19518021e-02f, -5.97194247e-02f, 2.73957998e-01f, 2.92067111e-01f, 9.84595641e-02f, 3.10930014e-01f, 4.15391997e-02f, 2.99784988e-02f, 9.55745801e-02f,
  1.77508771e-01f, 2.61389315e-01f, 1.54217016e-02f, 3.27351205e-02f, 9.00490880e-02f, -5.22762313e-02f, 1.27421707e-01f, -1.65520683e-01f, 2.42517646e-02f, 3.32155116e-02f,
  -5.59413098e-02f, 7.10693747e-02f, -4.44924310e-02f, -5.27542792e-02f, 3.73495594e-02f, 2.80254968e-02f, 6.65530469e-03f, 2.18209275e-03f, -2.99627110e-02f, -2.46703010e-02f,
  -5.34116663e-03f, 4.07125838e-02f, 9.86149833e-02f, -1.84677336e-02f, -6.81345072e-03f, 4.15438078e-02f, 1.66685842e-02f, -9.84673500e-02f, -1.07012212e-01f, 2.45453906e-03f,
  -1.17706649e-01f, 8.17905739e-02f, -3.22541706e-02f, 7.78213590e-02f, -7.19014481e-02f, -2.24063285e-02f, 8.79166126e-02f, -7.89102763e-02f, -9.71557864e-04f, 7.40217939e-02f,
  7.38097504e-02f, 3.98490466e-02f, -2.31573135e-02f, -2.91049909e-02f, 6.53419569e-02f, -4.02252674e-02f, -5.67808039e-02f, -1.00732343e-02f, -6.47416636e-02f, 1.94693040e-02f,
  3.82909784e-03f, -1.34655659e-03f, -5.55658974e-02f, 6.67983145e-02f, 7.49166170e-03f, -7.39425123e-02f, -9.37740281e-02f, -1.59053132e-02f, -5.21836765e-02f, -1.35312462e-02f,
  -5.60126379e-02f, 4.60676663e-02f, 4.82257642e-02f, -3.10268030e-02f, -2.61567980e-02f, -1.43117588e-02f, 5.08848615e-02f, 2.15790663e-02f, -4.83916625e-02f, -5.01350984e-02f,
  1.34568810e-01f, 3.11345279e-01f, -1.85933877e-02f, 3.76639131e-04f, -5.15646525e-02f, 6.20069727e-02f, 6.63609654e-02f, 1.09534167e-01f, 3.05281002e-02f, 4.26079705e-02f,
  6.20912574e-02f, -3.42902541e-02f, -5.71384141e-03f, 9.09896940e-03f, 1.47043671e-02f, 1.67219993e-02f, -2.60059498e-02f, -2.33486164e-02f, 3.23129334e-02f, -7.14856712e-03f,
  -6.80034831e-02f, 1.07290428e-02f, 5.68109490e-02f, -9.20867771e-02f, -1.30348867e-02f, 5.24309417e-03f, -6.43701628e-02f, -7.64708295e-02f, 3.86371650e-02f, 7.02577010e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  4.08970937e-02f, 1.27610460e-01f, 2.09472254e-01f, 8.90788436e-02f, 1.12793326e-01f, 3.27817909e-02f, 2.76857615e-01f, 3.20393950e-01f
};

// L1_fan_Wp (Shape: 12 x 32)
const int L1_fan_Wp_rows = 12;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -8.78430065e-03f, 5.48975989e-02f, 4.67509963e-02f, -1.23053066e-01f, 1.32429793e-01f, 1.66971430e-01f, -1.03379525e-02f, 7.04334080e-02f, 1.55056771e-02f, 6.39300719e-02f,
  -5.62963709e-02f, 1.46405160e-01f, 5.50337881e-02f, 3.04227829e-01f, 1.13045089e-01f, 3.61290127e-01f, 2.71597534e-01f, 1.44155502e-01f, -3.69793504e-01f, 2.77140170e-01f,
  -7.18076706e-01f, 2.11119564e-04f, -2.21754685e-01f, 1.51455045e-01f, 1.54652208e-01f, 4.01291162e-01f, 1.42298549e-01f, -1.54292986e-01f, -2.26467282e-01f, -1.84447646e-01f,
  1.48868084e-01f, -2.18838677e-02f, -2.88316876e-01f, -2.45847106e-02f, 8.02266449e-02f, -1.69179499e-01f, -1.40586779e-01f, -1.64734535e-02f, -1.31870151e-01f, -1.41871460e-02f,
  4.41413336e-02f, 7.73323774e-02f, -2.20612928e-01f, -1.22412831e-01f, 1.74540579e-01f, -2.42061689e-01f, 1.76170051e-01f, 1.34264439e-01f, 7.00722039e-02f, 7.00369105e-02f,
  5.82684517e-01f, -7.09419847e-02f, -3.43358785e-01f, -1.57987848e-01f, -1.63867131e-01f, -4.23886895e-01f, -1.36420429e-01f, -1.34050325e-01f, 4.58301514e-01f, -1.70678124e-01f,
  -2.99805850e-01f, 1.89472929e-01f, -8.89065955e-03f, -1.94308922e-01f, 1.47450268e-01f, 1.67817935e-01f, 8.64134058e-02f, -5.50578861e-03f, 5.39726345e-03f, 1.49358034e-01f,
  2.56519616e-01f, -1.79026052e-01f, -5.88673204e-02f, 2.56732762e-01f, 2.66182840e-01f, 2.68311650e-02f, -2.06200220e-02f, 2.92591155e-01f, -1.61409378e-01f, 2.47474641e-01f,
  -3.23491275e-01f, 2.39139795e-02f, -3.35080832e-01f, -3.20203334e-01f, 2.69072473e-01f, -1.16133355e-01f, 3.36809516e-01f, 2.03542158e-01f, -4.20778811e-01f, 6.29445910e-02f,
  -1.82629395e-02f, 4.16215748e-01f, -3.24578255e-01f, 1.09457217e-01f, -1.21463276e-01f, -7.62085021e-02f, 2.41153523e-01f, 1.40149072e-01f, -1.99684948e-01f, -1.55573457e-01f,
  1.66861683e-01f, -3.04724604e-01f, -3.20451409e-02f, 1.46815494e-01f, -1.67103007e-01f, 9.06482898e-03f, 2.41800100e-01f, 8.67209062e-02f, -1.23117894e-01f, 2.15281844e-01f,
  -3.77547860e-01f, -1.71873122e-02f, 4.59074825e-01f, -1.44330576e-01f, -1.11908153e-01f, -1.24217935e-01f, 4.04123187e-01f, 1.94470569e-01f, 3.10070872e-01f, 4.89548370e-02f,
  1.50458753e-01f, 2.34788671e-01f, 7.11606489e-03f, -2.82255232e-01f, 2.79078394e-01f, -3.42373699e-01f, -3.64439934e-01f, -4.86194454e-02f, 1.44685671e-01f, 5.97019531e-02f,
  -1.89663470e-01f, -2.78229475e-01f, 7.75678232e-02f, -2.55938590e-01f, 3.29125533e-03f, -9.40651670e-02f, 8.87139291e-02f, -1.99405879e-01f, -4.99590449e-02f, 2.71689981e-01f,
  3.63614827e-01f, 2.43030086e-01f, 4.53471877e-02f, 3.75201285e-01f, 1.76178813e-01f, 6.87746704e-02f, 2.68147498e-01f, -2.01738521e-01f, -4.91256155e-02f, 1.09251469e-01f,
  -4.06267464e-01f, -4.71008837e-01f, 6.59537539e-02f, 1.81870311e-01f, 1.40286490e-01f, -1.53086662e-01f, 2.29797050e-01f, -5.58871478e-02f, -2.38977864e-01f, 1.87103972e-01f,
  -1.17344325e-02f, -1.06590778e-01f, 2.75578111e-01f, 1.72213510e-01f, 1.84464008e-01f, -2.59472191e-01f, -1.57210231e-01f, 5.83668351e-02f, 2.84072664e-02f, 8.74230266e-02f,
  1.67196065e-01f, 2.64487118e-02f, 1.08792007e-01f, -2.12334260e-01f, -4.40924942e-01f, -1.67651847e-01f, -4.26650830e-02f, 1.57731786e-01f, 1.61604390e-01f, 1.22375578e-01f,
  6.12048030e-01f, 1.30006403e-01f, 3.88355762e-01f, 8.92462488e-03f, -3.83837819e-01f, 5.52636646e-02f, 4.02807817e-02f, 1.73391640e-01f, 2.50107557e-01f, -2.62139607e-02f,
  -1.39274344e-01f, 3.27417767e-03f, 2.13233873e-01f, -3.95231880e-02f, -3.29259485e-01f, 1.05221339e-01f, -3.66721004e-02f, -1.58364818e-01f, 1.12163596e-01f, -2.54870921e-01f,
  -4.39047068e-02f, 5.84744625e-02f, 1.08741365e-01f, 1.70018911e-01f, 1.49371073e-01f, -1.25805616e-01f, 6.45412430e-02f, -2.32623398e-01f, -3.54251772e-01f, -2.85524696e-01f,
  2.16309890e-01f, -2.79042959e-01f, 4.85600442e-01f, 2.28788808e-01f, -6.89228177e-02f, -7.94983506e-02f, 1.47037596e-01f, -1.16700232e-01f, -3.20266008e-01f, 2.22399950e-01f,
  2.85536736e-01f, 1.58375457e-01f, -2.50948016e-02f, 1.58484906e-01f, 2.19438255e-01f, 1.85933009e-01f, -2.71726787e-01f, -1.77932620e-01f, 1.26130104e-01f, -6.58735633e-02f,
  -1.91443264e-01f, 3.15735102e-01f, -1.47363871e-01f, 1.34995818e-01f, -2.34302529e-03f, -4.56015542e-02f, -3.42675358e-01f, -4.54571024e-02f, -1.24183089e-01f, -2.11619884e-01f,
  2.52192110e-01f, -2.79403597e-01f, 6.07659459e-01f, 3.14299390e-02f, 2.58200049e-01f, -1.12305716e-01f, -1.01953164e-01f, -3.18800390e-01f, 2.14257568e-01f, -2.29636610e-01f,
  3.75641644e-01f, -3.28469932e-01f, -4.27877083e-02f, 9.81215038e-04f, -3.01757723e-01f, -6.25862181e-03f, -2.02649310e-01f, -1.70343965e-02f, -9.23275426e-02f, -2.53733397e-02f,
  -6.53196946e-02f, 4.14347881e-03f, 5.05909435e-02f, -1.44090623e-01f, 1.96933508e-01f, -6.96481168e-02f, -1.57513514e-01f, 1.72987908e-01f, 4.58790988e-01f, 7.29041025e-02f,
  4.63910073e-01f, 1.91757143e-01f, -1.44201025e-01f, 3.41332763e-01f, -2.37728104e-01f, -1.34582147e-01f, -5.09895027e-01f, 2.51346797e-01f, -4.40605909e-01f, -1.93911046e-01f,
  2.21037447e-01f, 1.68364167e-01f, -3.35149109e-01f, -4.64669093e-02f, -7.79645592e-02f, 2.09195912e-03f, 7.21935928e-02f, 2.46476576e-01f, 2.25758642e-01f, 1.51711851e-01f,
  6.46167248e-02f, -4.44419794e-02f, 1.65187299e-01f, 1.31988460e-02f, 1.22615203e-01f, 3.41071814e-01f, -2.03510374e-02f, -1.41054586e-01f, 1.95101783e-01f, 2.13677317e-01f,
  7.12602660e-02f, 3.86789382e-01f, -1.73807338e-01f, 2.14013010e-01f, 1.78120777e-01f, 4.06345874e-01f, 6.40106648e-02f, -4.30318117e-01f, -1.09430425e-01f, 2.49616399e-01f,
  -7.01299384e-02f, -1.95370227e-01f, -2.70589858e-01f, 1.10648207e-01f, 2.86311179e-01f, 5.59980907e-02f, -4.36533928e-01f, 1.21975616e-02f, -6.46160319e-02f, 6.07093088e-02f,
  -1.66045725e-02f, 1.55686602e-01f, 2.39406869e-01f, -2.19872266e-01f, -8.29363391e-02f, -7.58877322e-02f, -6.70035854e-02f, -2.77664363e-01f, 1.73964366e-01f, 6.86218515e-02f,
  1.10256858e-02f, -9.21799615e-02f, 1.64908469e-01f, 4.18359846e-01f, 1.19164936e-01f, -2.10064366e-01f, -4.90813613e-01f, -1.45135328e-01f, -2.75131851e-01f, 5.04462838e-01f,
  -6.17093034e-03f, -3.06077182e-01f, -5.18127024e-01f, -9.08367783e-02f, -1.23558089e-01f, -1.24537989e-01f, -2.41758421e-01f, -2.96177268e-01f, 1.33714333e-01f, 1.04563804e-02f,
  2.35027134e-01f, -4.72073145e-02f, 5.27258255e-02f, -1.30156148e-02f, 2.56793201e-01f, -1.82628915e-01f, -4.03402120e-01f, 4.41867374e-02f, 2.72164434e-01f, -2.34533772e-01f,
  -2.01611415e-01f, -2.19838575e-01f, 8.08280930e-02f, -8.58929455e-02f, -1.01364665e-01f, -7.80394301e-03f, 8.81778598e-02f, -1.59151152e-01f, -4.04329926e-01f, -3.44658792e-01f,
  -1.06915444e-01f, 3.45161468e-01f, 5.29631004e-02f, -5.81957877e-01f, -1.69913262e-01f, 1.46308690e-01f, -3.79143655e-01f, -4.76674847e-02f, 4.80003774e-01f, -6.01134263e-02f,
  -1.16063841e-02f, -2.24774182e-01f, 1.79380462e-01f, -1.93918288e-01f
};

// L1_fan_Wp_bar (Shape: 8 x 32)
const int L1_fan_Wp_bar_rows = 8;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  -1.34543255e-02f, 1.83747202e-01f, 5.26582718e-01f, 3.89677405e-01f, -1.90459881e-02f, 2.11213738e-01f, 3.72968465e-01f, -1.40278071e-01f, 4.14219648e-02f, 2.59561330e-01f,
  2.12735534e-01f, 3.66111010e-01f, 4.56270933e-01f, 2.60742664e-01f, 2.59084478e-02f, -1.71707705e-01f, -5.74452221e-01f, 9.91679803e-02f, -4.63027537e-01f, -1.74075291e-01f,
  3.58020067e-01f, -7.08877519e-02f, -6.73023462e-02f, 2.24769711e-01f, -1.06061891e-01f, 7.20751137e-02f, -1.32947102e-01f, 4.04342145e-01f, 8.08871835e-02f, -1.69743285e-01f,
  5.19632220e-01f, 2.28611365e-01f, 3.57112527e-01f, 3.07913631e-01f, 3.12051684e-01f, 1.21987619e-01f, 1.62173271e-01f, 2.76858509e-01f, 2.80228257e-01f, 3.22746217e-01f,
  2.77454376e-01f, 3.50841954e-02f, 6.76781684e-03f, 2.60002762e-01f, 2.96497196e-01f, 5.84222339e-02f, -1.36841983e-01f, -3.71207505e-01f, -1.52340189e-01f, -2.71926343e-01f,
  3.50217462e-01f, 4.76330101e-01f, 2.04150915e-01f, -3.17530662e-01f, -4.75652158e-01f, -4.10855293e-01f, -1.09366313e-01f, 7.93210324e-03f, 3.51020664e-01f, -4.40257102e-01f,
  4.76401001e-01f, 1.30488679e-01f, 1.68593109e-01f, -5.72215654e-02f, -2.26625651e-02f, -2.95575280e-02f, 2.80821800e-01f, -9.22816396e-02f, 9.88334939e-02f, 3.35194543e-02f,
  -2.77188793e-03f, 2.25445464e-01f, 1.08619444e-01f, 1.47840813e-01f, -5.84114455e-02f, -1.50370225e-01f, -6.48546442e-02f, 1.33688256e-01f, 1.45467028e-01f, 3.71109188e-01f,
  -1.24017149e-03f, 3.66267413e-02f, -2.29900211e-01f, 2.63613343e-01f, -3.44458729e-01f, -1.12784654e-01f, 9.72172692e-02f, 3.28679979e-02f, -4.79716025e-02f, 6.53121248e-02f,
  5.04229426e-01f, -5.84263541e-02f, -1.31674513e-01f, -1.33349538e-01f, 1.44531012e-01f, -5.19381352e-02f, 4.53243345e-01f, 2.00606942e-01f, 2.28978321e-01f, 1.32108003e-01f,
  1.99333683e-01f, 3.35372351e-02f, 3.13104421e-01f, 4.51043732e-02f, -2.73391336e-01f, -4.70255613e-02f, 3.41954321e-01f, 2.61766687e-02f, 2.92817187e-02f, 4.73827481e-01f,
  2.35516243e-02f, -5.05766571e-02f, -5.09881794e-01f, -3.70130748e-01f, 1.11151032e-01f, -3.32072198e-01f, 4.72709656e-01f, -3.42320144e-01f, -2.55320013e-01f, -1.10759854e-01f,
  -4.25529480e-02f, 1.23027883e-01f, 3.26697201e-01f, 1.78846389e-01f, 5.74382730e-02f, 3.85966338e-02f, -3.08486164e-01f, 2.75477290e-01f, -1.05176650e-01f, 2.24464372e-01f,
  1.53392047e-01f, -5.38579226e-02f, 1.57921374e-01f, -7.14382455e-02f, -8.31778422e-02f, -8.10799003e-02f, 1.81986734e-01f, 1.33292153e-01f, -1.21687070e-01f, 1.48966670e-01f,
  -2.13149801e-01f, -7.43356273e-02f, -6.82110488e-02f, -1.85142800e-01f, 3.51856768e-01f, 3.48362103e-02f, 5.50664449e-03f, -7.30682835e-02f, 5.59480488e-02f, 6.37632981e-02f,
  3.02542955e-01f, -2.50985563e-01f, 4.32535820e-02f, -8.35732445e-02f, 8.90113600e-03f, 8.92650858e-02f, 3.08443904e-01f, 1.88266158e-01f, -1.55073792e-01f, -3.32610533e-02f,
  1.40860467e-03f, -9.26016793e-02f, 6.04854412e-02f, -1.08933134e-03f, 1.12085961e-01f, -2.12968349e-01f, -6.19273745e-02f, -2.47649848e-02f, -9.67106745e-02f, -2.11401895e-01f,
  1.61310539e-01f, -6.02102233e-03f, 1.70487434e-01f, -5.73301837e-02f, 8.89246259e-03f, -1.16643995e-01f, -2.35170871e-01f, -2.14434132e-01f, -6.45714812e-04f, 3.08436938e-02f,
  1.44228458e-01f, -6.74280524e-02f, -1.61103621e-01f, 2.18650326e-01f, -8.64854679e-02f, -5.39722517e-02f, -2.71645486e-02f, -8.15651268e-02f, 4.73969162e-01f, -1.94304381e-02f,
  -1.07834622e-01f, 1.48697257e-01f, 3.06743979e-01f, 1.97603971e-01f, -3.11565578e-01f, 1.60168365e-01f, -1.61361262e-01f, 2.73394972e-01f, 1.53390348e-01f, -7.63190687e-02f,
  -1.24758393e-01f, 2.68144757e-01f, 1.98495551e-03f, 1.02689462e-02f, -2.23976672e-02f, -3.04697722e-01f, 5.37801504e-01f, 1.61157742e-01f, -1.51343882e-01f, 1.13729939e-01f,
  1.36006415e-01f, -4.33328569e-01f, -3.49975109e-01f, 3.03444028e-01f, -1.00041099e-01f, -4.62296642e-02f, 7.41950452e-01f, -1.84837028e-01f, 5.44990301e-02f, 3.12431306e-01f,
  1.57378674e-01f, -4.51300777e-02f, -2.54173717e-03f, 5.91214061e-01f, 7.09041804e-02f, 8.47500637e-02f, 1.79715320e-01f, 3.89277726e-01f, 1.82933494e-01f, 3.29284340e-01f,
  2.27222115e-01f, 3.81248891e-01f, 3.88331890e-01f, 3.25716347e-01f, 2.32719541e-01f, 1.64172396e-01f, -1.15934998e-01f, -2.90213317e-01f, -3.51038188e-01f, 5.24505973e-02f,
  5.34878492e-01f, 3.81133944e-01f, -1.48190483e-01f, -1.18428126e-01f, -5.60043044e-02f, 1.63002938e-01f, 4.73932743e-01f, -7.95540307e-03f, -1.46653369e-01f, 1.71568185e-01f,
  1.87831640e-01f, 2.24275403e-02f, -2.48584494e-01f, -1.32190257e-01f, 1.02578372e-01f, 5.75861149e-03f
};

// L1_fan_Bp_bar (Shape: 1 x 8)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 8;
const float L1_fan_Bp_bar_data[] = {
  1.11310549e-01f, 3.36803496e-01f, 1.52317405e-01f, 1.45306557e-01f, 1.62240475e-01f, -4.57711630e-02f, 2.83518523e-01f, 4.89070445e-01f
};

// L2_linear_W (Shape: 12 x 32)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 32;
const float L2_linear_W_data[] = {
  -8.07647780e-02f, -2.67259300e-01f, -6.65003479e-01f, -3.64371687e-02f, -3.39933574e-01f, -9.64871794e-03f, -3.16102237e-01f, -2.26928845e-01f, 3.54973853e-01f, 1.89030230e-01f,
  -1.09139517e-01f, 3.89509231e-01f, -6.74735427e-01f, -2.92819470e-01f, 2.12352648e-01f, -6.10509217e-01f, -6.54718339e-01f, 2.46562138e-01f, 4.45685595e-01f, -4.26027119e-01f,
  -8.17512274e-02f, -2.60229170e-01f, -2.62609363e-01f, 2.15789199e-01f, 5.52745044e-01f, -7.64992118e-01f, -2.33770669e-01f, 2.25659013e-01f, -8.07554796e-02f, 6.75732419e-02f,
  3.14170748e-01f, -1.01853110e-01f, 1.84970200e-01f, 3.33892345e-01f, -3.32711011e-01f, -2.87699193e-01f, 9.07689929e-02f, 2.71714985e-01f, -3.01888920e-02f, -2.72894382e-01f,
  -8.63542855e-01f, -6.88796863e-02f, 5.13263822e-01f, -5.04858755e-02f, 2.75284916e-01f, -1.45691827e-01f, 4.80049312e-01f, -5.90463340e-01f, 5.88692188e-01f, -4.90923375e-01f,
  5.45747519e-01f, -5.67782402e-01f, 6.08382046e-01f, 1.65775791e-01f, 2.89838672e-01f, -5.77771366e-01f, 4.44729269e-01f, -1.83668852e-01f, -2.19351143e-01f, 9.94271636e-02f,
  -2.59060800e-01f, -2.86451057e-02f, 4.73092467e-01f, -3.13285083e-01f, 3.67206261e-02f, 1.69545278e-01f, 3.55643839e-01f, -3.52851711e-02f, -1.19447343e-01f, -3.87917995e-01f,
  3.94757479e-01f, -2.10096940e-01f, 1.43216446e-01f, -2.39767320e-02f, 3.05531889e-01f, 1.58924937e-01f, 1.30037054e-01f, 7.82938004e-01f, -5.78636408e-01f, -5.23621976e-01f,
  4.82237607e-01f, -6.21086597e-01f, -1.43431455e-01f, 6.59851253e-01f, 5.84108174e-01f, 2.06716970e-01f, -7.55083859e-02f, -1.87700503e-02f, -5.32233655e-01f, 1.98926046e-01f,
  1.25113174e-01f, 5.92762232e-01f, -1.15495078e-01f, -1.27384007e-01f, 5.02960384e-01f, -4.39730763e-01f, 2.99540788e-01f, -4.41437483e-01f, 1.74796313e-01f, 3.15873384e-01f,
  4.33380455e-02f, -5.01135364e-02f, -1.66843399e-01f, 5.16761914e-02f, -2.88172737e-02f, -9.47080404e-02f, -7.68766582e-01f, -3.92484277e-01f, -3.38387728e-01f, -3.41729045e-01f,
  5.13736866e-02f, 1.24391451e-01f, -2.10831538e-02f, 3.96247953e-01f, 1.95424378e-01f, -5.19738346e-02f, -3.45492899e-01f, -7.35938489e-01f, 5.39192796e-01f, 6.22828603e-01f,
  2.44834542e-01f, 5.33783317e-01f, -1.57016948e-01f, 4.61539924e-01f, -1.86499029e-01f, 4.47257638e-01f, -5.32776773e-01f, -6.97434008e-01f, 2.39900440e-01f, 6.81740642e-02f,
  -2.55458117e-01f, 7.42170066e-02f, 2.20435768e-01f, 2.98963841e-02f, 2.63203472e-01f, 4.66696560e-01f, -3.82639736e-01f, 4.07083958e-01f, 5.08913338e-01f, 5.52667439e-01f,
  -2.84397125e-01f, -5.06272137e-01f, 6.26127779e-01f, 4.23309326e-01f, -3.30707937e-01f, 2.51029283e-01f, 2.50420064e-01f, 5.59769750e-01f, -6.37294114e-01f, 3.76656502e-01f,
  1.41772047e-01f, 1.62415594e-01f, 1.80766478e-01f, 3.22565138e-01f, -1.39133334e-01f, 6.83520436e-01f, -1.62759587e-01f, -2.42520183e-01f, -5.02411187e-01f, -5.46291396e-02f,
  2.52859920e-01f, -3.18219870e-01f, -1.78616047e-01f, 2.09139749e-01f, 6.07982278e-02f, -1.20659573e-02f, 2.88026392e-01f, 9.36357304e-02f, 3.15043151e-01f, -7.27101207e-01f,
  -2.65150696e-01f, -4.64492083e-01f, 2.42792875e-01f, -5.21985292e-01f, 5.53111315e-01f, 5.61080456e-01f, 2.63022095e-01f, 4.31897342e-01f, -4.36151586e-02f, -6.56183362e-01f,
  4.52177584e-01f, 4.89933878e-01f, -4.13182080e-01f, -7.18251646e-01f, 3.04045796e-01f, -4.59585965e-01f, -1.27974749e-01f, 7.26017803e-02f, 8.77394378e-02f, 4.60763462e-02f,
  -1.62818938e-01f, 5.22376239e-01f, -4.13854301e-01f, -2.01918870e-01f, 2.37812161e-01f, 2.29171142e-01f, -1.59996673e-01f, 4.47439820e-01f, -4.16744828e-01f, 2.36396380e-02f,
  1.80580035e-01f, -4.62383389e-01f, -8.85706544e-02f, 1.64174989e-01f, 5.89858294e-01f, 8.67005467e-01f, 1.70615017e-01f, 1.72284260e-01f, 5.28535128e-01f, -6.13417700e-02f,
  -6.09879375e-01f, 4.03976351e-01f, -3.19977283e-01f, 3.41107473e-02f, -2.97236949e-01f, 4.93043244e-01f, -3.71690959e-01f, 2.98165590e-01f, 4.72658902e-01f, 5.82040288e-02f,
  -9.67443958e-02f, -5.09126857e-03f, -9.27911624e-02f, 3.25995505e-01f, -2.38884017e-02f, -1.18833221e-01f, -2.42045373e-01f, -6.23416781e-01f, 2.28642784e-02f, -5.08330651e-02f,
  -5.05441070e-01f, -7.78983235e-02f, -2.64730845e-02f, -2.03585550e-01f, 2.03542814e-01f, 3.83962877e-02f, -5.57337761e-01f, -3.89631003e-01f, -6.92776620e-01f, 5.32136202e-01f,
  5.02380550e-01f, 3.11250925e-01f, 4.57674146e-01f, 5.32557964e-01f, -4.81511593e-01f, -4.63769525e-01f, 3.24514061e-02f, -3.43316734e-01f, -5.05711794e-01f, 4.96257991e-01f,
  2.26718429e-02f, -1.53429747e-01f, 4.25496250e-01f, 1.53077334e-01f, 8.80926400e-02f, -3.54476154e-01f, -2.64687330e-01f, -1.18948206e-01f, -1.68415233e-01f, 2.68725723e-01f,
  8.80787801e-03f, -5.53486884e-01f, -6.79449216e-02f, 2.78040230e-01f, -4.29777056e-01f, 1.84389710e-01f, -2.51173943e-01f, -4.61163402e-01f, 1.52362406e-01f, -3.02384257e-01f,
  -8.25349391e-01f, 4.77632098e-02f, -4.96639200e-02f, -2.84810454e-01f, 1.51458979e-01f, 2.07520425e-01f, 4.24968630e-01f, -1.55929983e-01f, -3.56871814e-01f, -1.73858032e-01f,
  -3.56443316e-01f, -5.17310321e-01f, -1.53217256e-01f, -3.20628941e-01f, -1.56624973e-01f, 1.01790391e-02f, 8.78885865e-01f, 7.09136277e-02f, 3.09243917e-01f, 1.58096135e-01f,
  2.98586965e-01f, 3.16600412e-01f, 3.71106490e-02f, -1.83895499e-01f, 4.40180391e-01f, -4.05760109e-02f, -2.04774499e-01f, 2.35107690e-01f, -3.37185353e-01f, 2.19159294e-02f,
  -5.18554568e-01f, 7.04761326e-01f, -1.13746546e-01f, -1.38311256e-02f, -3.06649059e-01f, 5.78713596e-01f, -2.48484135e-01f, 5.86216509e-01f, -4.23978627e-01f, 5.18819928e-01f,
  -2.98147291e-01f, -5.43075800e-01f, -6.46608472e-01f, 1.95125833e-01f, -2.26177603e-01f, -4.46308285e-01f, 3.05526733e-01f, -1.92206129e-01f, -1.55032277e-01f, 6.70956492e-01f,
  -1.37446988e-02f, 1.66001633e-01f, 3.14139575e-01f, -6.99671566e-01f, -1.02523819e-01f, -1.19326778e-01f, 1.51781455e-01f, 9.95218828e-02f, -1.79850698e-01f, 3.31933886e-01f,
  -5.85903049e-01f, -5.87250888e-02f, 3.22747946e-01f, -7.63476044e-02f, -2.07650170e-01f, -6.20808482e-01f, -1.71867654e-01f, -2.38715023e-01f, -2.64907807e-01f, -4.01394039e-01f,
  5.53376794e-01f, -2.81145155e-01f, 6.46669269e-01f, 3.95570815e-01f, 5.53075910e-01f, 6.45211160e-01f, 2.00725943e-02f, -3.56520116e-01f, -6.07540049e-02f, -2.98672527e-01f,
  -3.11175197e-01f, -1.68058738e-01f, -5.73448956e-01f, 1.40460253e-01f, 5.68281338e-02f, 3.34321618e-01f, -1.67547524e-01f, 2.42166236e-01f, -4.52824920e-01f, 2.02070236e-01f,
  4.67184395e-01f, 4.29334372e-01f, 5.01880884e-01f, 3.79277378e-01f, 5.42836249e-01f, -4.42443281e-01f, 5.69951296e-01f, -1.50501668e-01f, -6.47812247e-01f, -1.49129733e-01f,
  -8.96828651e-01f, -7.72746503e-01f, -2.68349260e-01f, 1.05552323e-01f, 1.52507558e-01f, -1.03014804e-01f, -7.55045786e-02f, -2.81564265e-01f, 4.65258032e-01f, -5.53284645e-01f,
  5.31891957e-02f, 2.84302160e-02f, -3.96373600e-01f, 3.98906440e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -2.37580925e-01f, -2.47421376e-02f, -1.10002704e-01f, -1.64520085e-01f, -5.57081588e-02f, 3.90619189e-02f, 1.27525866e-01f, 2.08427981e-01f, -2.58512776e-02f, 3.82426009e-02f,
  9.31032971e-02f, 2.30997279e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 12, 8
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 12, 8
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        32, 12
    );
    }
    