/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 4 x 120)
const int L0_fan_Wp_rows = 4;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -7.08857000e-01f, -1.29045770e-01f, -3.86844009e-01f, -5.26436746e-01f, -1.47834793e-01f, 1.80615708e-01f, 1.25937670e-01f, 1.82458192e-01f, -1.48519725e-01f, -2.63428748e-01f,
  6.48945197e-03f, 1.38281822e-01f, 1.31165050e-03f, 3.00743550e-01f, 3.52479994e-01f, -1.91965804e-01f, -2.67945111e-01f, -5.31840278e-03f, 3.76267195e-01f, 3.55651200e-01f,
  -5.26419561e-03f, -2.20536888e-01f, -9.24959183e-02f, -2.39794496e-02f, -1.89728737e-01f, 6.49677739e-02f, -1.85544148e-01f, -8.13165233e-02f, 1.37155548e-01f, -4.49941725e-01f,
  -4.50790137e-01f, -1.23514496e-01f, 1.76545650e-01f, 9.37457606e-02f, -7.28876740e-02f, 1.17387418e-02f, -6.68586493e-02f, -3.35557461e-02f, -3.14761400e-02f, -1.45933861e-02f,
  -6.91272542e-02f, -3.31282094e-02f, -9.78792906e-02f, 1.10489145e-01f, -7.46574998e-02f, 2.24904921e-02f, 4.29514349e-02f, 3.41920331e-02f, 7.33849034e-02f, -8.30813218e-03f,
  -2.28658728e-02f, -1.33031622e-01f, -1.11092091e-01f, 9.30372626e-02f, 2.06376478e-01f, 1.36966519e-02f, 4.16167118e-02f, 4.77950275e-02f, 1.52211174e-01f, -1.61735907e-01f,
  -7.49707520e-02f, -1.09678224e-01f, 5.59683777e-02f, 1.28743369e-02f, 3.19288224e-02f, -5.67151885e-03f, -3.59505415e-02f, 2.24546324e-02f, 1.26791224e-02f, -7.25187287e-02f,
  6.35064691e-02f, -2.29105186e-02f, 5.07681221e-02f, 2.07543862e-03f, -8.32283422e-02f, 1.75687876e-02f, 1.06031364e-02f, 3.21323350e-02f, -9.45231039e-03f, 1.73618011e-02f,
  -5.28495163e-02f, 5.92576265e-02f, -1.16035506e-01f, 7.78027549e-02f, 7.45969117e-02f, 7.11330846e-02f, -3.76074128e-02f, 1.46985963e-01f, -4.50801142e-02f, -7.49191418e-02f,
  4.79169376e-02f, 2.46203765e-01f, -2.21188143e-01f, 1.85798798e-02f, -8.89957547e-02f, 1.56799089e-02f, -1.06069587e-01f, -3.44944522e-02f, -1.11896973e-02f, -5.72180143e-03f,
  9.53376666e-02f, -3.72386910e-02f, -1.76454075e-02f, -9.82753187e-03f, 6.72528669e-02f, 3.34718041e-02f, 3.93361645e-03f, 1.99332777e-02f, 8.22078362e-02f, -1.00752480e-01f,
  -3.52561548e-02f, -1.74105112e-02f, -1.08577320e-02f, -1.09681848e-03f, -1.94658283e-02f, -1.22494847e-02f, -1.24041904e-02f, 5.05347066e-02f, 4.11029384e-02f, -1.01391390e-01f,
  -2.56995827e-01f, -3.89671415e-01f, 1.27241418e-01f, 1.53855711e-01f, -1.32045135e-01f, -3.09217572e-01f, -5.09032845e-01f, 4.03250046e-02f, 2.28843212e-01f, -6.70837387e-02f,
  -1.21979825e-01f, 2.00169116e-01f, 1.99591979e-01f, 2.32571259e-01f, -6.58690631e-02f, -3.09362382e-01f, -2.32037812e-01f, -9.65521019e-03f, -9.36033502e-02f, -2.76592702e-01f,
  -2.44848847e-01f, -1.70576051e-01f, -5.85517846e-02f, 8.01016614e-02f, 8.88681859e-02f, 9.47896466e-02f, 1.03456564e-01f, 8.92361999e-02f, -2.13411465e-01f, 9.31064487e-02f,
  -6.73839077e-02f, 2.23889381e-01f, -3.64200622e-02f, 3.97282913e-02f, 2.67117601e-02f, -2.00060084e-02f, -1.06274605e-01f, 1.51581511e-01f, -1.30309677e-02f, 4.35665762e-03f,
  -1.69919413e-02f, -1.09330202e-02f, 9.69421417e-02f, 3.17101181e-02f, 6.45620152e-02f, 3.88579555e-02f, 1.73157379e-01f, 1.41773075e-01f, 9.37850252e-02f, 1.14846118e-01f,
  -4.91286702e-02f, -1.53177947e-01f, -7.83138126e-02f, 5.03600691e-04f, 1.36517450e-01f, 1.18338177e-02f, -1.98099688e-02f, 9.12620127e-02f, 6.57998696e-02f, -5.84610924e-02f,
  -5.63187897e-02f, -3.36355194e-02f, 6.30477220e-02f, -2.39677094e-02f, -2.74011809e-02f, 5.35783023e-02f, 9.96912271e-02f, -7.40342364e-02f, -8.56733508e-03f, -2.24289112e-02f,
  9.24514905e-02f, -8.70719086e-03f, -2.37904210e-02f, -3.20412219e-02f, -7.59368856e-03f, 3.34693044e-02f, -8.00581425e-02f, 5.31969927e-02f, 4.26267087e-02f, 1.09663963e-01f,
  2.50602122e-02f, -4.63665016e-02f, -3.23955826e-02f, 2.47841291e-02f, 4.10966426e-02f, 3.98496203e-02f, -1.25127416e-02f, 9.21153426e-02f, 1.28967166e-01f, 1.19068548e-02f,
  -7.68653527e-02f, -3.41756605e-02f, -6.44070581e-02f, -2.46781949e-02f, -2.15720832e-02f, 5.53779230e-02f, -5.59732094e-02f, -2.94039380e-02f, 4.13084775e-03f, -4.65271175e-02f,
  -4.93576936e-02f, -4.84079048e-02f, -3.67131382e-02f, 1.47947501e-02f, -1.24859899e-01f, 8.27690866e-03f, -6.46017790e-02f, -6.19904026e-02f, -3.57426517e-02f, 1.87331028e-02f,
  -6.73151463e-02f, -1.36383027e-01f, -2.50668526e-01f, -1.21875487e-01f, -4.25113961e-02f, -1.65164709e-01f, -1.79604545e-01f, -1.08209670e-01f, -1.87463865e-01f, -4.74756569e-01f,
  1.05954528e+00f, -5.19019365e-01f, -2.95253724e-01f, 1.11333102e-01f, -3.33379090e-01f, 3.65562998e-02f, -3.12490523e-01f, 1.20878704e-01f, 1.14419423e-01f, -2.27440834e-01f,
  -3.56160134e-01f, 9.68289226e-02f, 9.09246318e-03f, 7.60335149e-03f, 2.69146174e-01f, -3.85392100e-01f, -2.39687800e-01f, 4.10973728e-01f, 6.34775400e-01f, 3.33170742e-01f,
  -2.41448563e-02f, -1.02531007e-02f, 4.58129287e-01f, 1.36692703e-01f, -2.38413647e-01f, 1.08673185e-01f, -3.07179779e-01f, -8.76133069e-02f, -1.65850639e-01f, -4.64165986e-01f,
  -5.34813218e-02f, -7.27660675e-03f, 1.28120437e-01f, -1.67799294e-02f, -1.23102032e-01f, 1.82283133e-01f, 3.94048020e-02f, 2.39272974e-02f, -2.67330091e-02f, 1.96745098e-02f,
  -5.51924706e-02f, 3.69987041e-02f, 7.75159970e-02f, -8.94140303e-02f, 1.30938571e-02f, 2.93955971e-02f, 5.79862557e-02f, 9.22986865e-02f, -3.71175334e-02f, -1.08835854e-01f,
  -2.27360547e-01f, -3.27054411e-02f, 3.17175314e-02f, -1.63170102e-03f, 1.42417569e-02f, 3.47814336e-02f, -1.28924072e-01f, -2.35338211e-02f, 4.21127118e-02f, 3.42269503e-02f,
  6.88764304e-02f, -4.72615846e-03f, 9.53631252e-02f, 6.08307635e-03f, 9.82035398e-02f, -1.53074943e-04f, 4.98345196e-02f, -2.48126243e-03f, 5.82758971e-02f, 2.21379623e-02f,
  -1.08112261e-01f, -4.80363443e-02f, 3.59507091e-02f, -5.05986549e-02f, -6.70594275e-02f, -4.75182384e-02f, -4.85722162e-02f, 3.68468091e-02f, -5.08801527e-02f, -1.02416351e-02f,
  5.22455797e-02f, 1.14373952e-01f, -4.34676409e-02f, 7.66276103e-03f, -1.24637403e-01f, 6.84532104e-03f, -4.71965224e-03f, -3.08226794e-02f, 2.35953797e-02f, 7.91632850e-03f,
  8.43980983e-02f, -1.04544433e-02f, -1.33152483e-02f, 1.14545256e-01f, -2.88068429e-02f, -6.45665154e-02f, -2.78996751e-02f, -7.14599341e-02f, -1.15374140e-01f, -3.54828238e-02f,
  -1.56823434e-02f, 1.36292309e-01f, -1.04627334e-01f, -5.98645508e-02f, 4.64101322e-02f, -2.25956226e-03f, -1.41234491e-02f, 1.37863066e-02f, 1.37968939e-02f, -7.85950571e-02f,
  -1.23709187e-01f, 3.42920832e-02f, 1.59557298e-01f, -8.33673626e-02f, 3.47144790e-02f, 1.79112509e-01f, 3.48354764e-02f, 1.04233064e-01f, 1.24122508e-01f, -1.86148081e-02f,
  -6.91377342e-01f, 4.66174692e-01f, -2.05824301e-01f, -1.37054726e-01f, 1.45947278e-01f, 1.12922989e-01f, 5.09912312e-01f, 2.37632841e-01f, 1.49701405e-02f, 1.89432248e-01f,
  -1.60479486e-01f, -5.44142962e-01f, -4.26811010e-01f, -3.93516004e-01f, -5.59803210e-02f, 3.86982977e-01f, 3.90175194e-01f, -2.15140983e-01f, -3.88538778e-01f, 1.19211271e-01f,
  2.83744484e-01f, 2.53097951e-01f, -1.96773738e-01f, 7.26019144e-02f, 1.55998468e-01f, -1.78803071e-01f, 7.93409273e-02f, 8.18849504e-02f, 1.03934862e-01f, 1.59412161e-01f,
  -1.24376699e-01f, 2.10057572e-02f, -1.66458368e-01f, -2.59961430e-02f, -5.82550317e-02f, -4.25310582e-02f, 6.43057004e-02f, -5.31969815e-02f, -7.50025129e-03f, 8.78484547e-02f,
  -5.37618622e-02f, 3.02318372e-02f, -7.57848984e-03f, 9.62741897e-02f, 1.01690620e-01f, 3.14901955e-02f, 9.63843986e-02f, -8.22413713e-02f, 1.90618786e-03f, -1.03579729e-03f,
  8.49832743e-02f, 6.71102083e-04f, -7.34284520e-03f, 1.04623728e-01f, -1.37617499e-01f, -8.19941461e-02f, 1.24384061e-01f, -1.07925475e-01f, -4.26690653e-02f, 2.76973713e-02f,
  3.08982991e-02f, -5.58372922e-02f, 4.20912681e-03f, 1.49028422e-02f, 2.51825191e-02f, 3.78514780e-03f, 3.10838651e-02f, -5.95866516e-02f, -3.86140533e-02f, 6.78844452e-02f,
  6.35279575e-03f, -9.01289005e-03f, 6.82147667e-02f, -3.79672945e-02f, -4.11106981e-02f, -1.67647209e-02f, -1.96203925e-02f, 1.53393392e-02f, -5.90954348e-02f, 5.86322807e-02f,
  -8.92277211e-02f, -8.45601130e-03f, -5.89451864e-02f, 4.41379920e-02f, 2.13231407e-02f, -6.51624501e-02f, -2.61830892e-02f, 5.53795928e-03f, -4.43696603e-02f, 6.61968589e-02f,
  1.42616525e-01f, -1.92293823e-01f, 9.07886401e-03f, -1.65413748e-02f, 4.95383069e-02f, 1.66697949e-02f, -1.68731976e-02f, 3.64883989e-02f, 8.77603143e-03f, 7.26569444e-02f,
  1.05115306e-02f, -7.13204443e-02f, 2.84552504e-03f, 4.62907888e-02f, -2.12140735e-02f, -1.47316977e-02f, 4.74795848e-02f, -6.50423244e-02f, 4.53761034e-02f, 8.83551985e-02f,
  8.15328807e-02f, 5.87066412e-02f, -7.80280530e-02f, -2.52627954e-02f, 5.07189333e-02f, -1.16790846e-01f, 5.33425696e-02f, -1.12620955e-02f, -1.88683227e-01f, 1.75419584e-01f
};

// L0_fan_Wp_bar (Shape: 8 x 120)
const int L0_fan_Wp_bar_rows = 8;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -5.55052161e-01f, 1.71309724e-01f, 9.95485246e-01f, -8.43074679e-01f, -1.33213139e+00f, -6.94351792e-01f, -1.83880553e-01f, -2.89583683e-01f, -6.29823208e-01f, 1.67838871e-01f,
  -4.90896404e-01f, -5.16961455e-01f, -2.18149228e-03f, 4.03258055e-01f, 5.92512608e-01f, 7.25515246e-01f, 6.74596429e-01f, 9.74347174e-01f, 2.43273214e-01f, -4.35887635e-01f,
  -4.03420866e-01f, -2.65266031e-01f, 3.91248792e-01f, 5.28967977e-01f, -3.12206686e-01f, -3.39447021e-01f, 4.06879961e-01f, -4.82980818e-01f, 1.43505082e-01f, 6.26545548e-01f,
  7.07036495e-01f, -2.07265735e-01f, -1.46104852e-02f, -1.45609334e-01f, 1.31526172e-01f, 4.56886172e-01f, 1.53697163e-01f, 3.14881623e-01f, -1.16059221e-01f, 1.94449842e-01f,
  -1.92810953e-01f, -6.19176403e-02f, -2.51819968e-01f, -2.31242143e-02f, -9.65432972e-02f, 5.52096367e-02f, 3.92311841e-01f, 5.69592535e-01f, 2.94781417e-01f, 2.10195392e-01f,
  -3.41198027e-01f, -4.67329383e-01f, -2.72786766e-01f, 2.58203018e-02f, 1.11643560e-01f, -1.73117772e-01f, 4.27260883e-02f, -1.11129485e-01f, 1.06722638e-01f, 9.81085151e-02f,
  7.80024454e-02f, -4.26214859e-02f, -6.89382404e-02f, -5.08208498e-02f, -4.62032109e-02f, -3.37894931e-02f, 3.57624181e-02f, -1.14030996e-02f, -8.66163075e-02f, 2.23720782e-02f,
  6.27030954e-02f, 2.46400554e-02f, 2.13384293e-02f, 1.43101215e-01f, 4.97181714e-02f, 3.00997682e-02f, 4.81210686e-02f, 7.89131820e-02f, -2.32744172e-01f, 1.31652690e-02f,
  -1.07013561e-01f, 8.94954428e-02f, -1.66051611e-01f, 2.76749790e-01f, 2.22681114e-03f, 5.90719804e-02f, -4.26266976e-02f, -1.16846457e-01f, -2.21859723e-01f, 2.14531776e-02f,
  -3.06107014e-01f, -5.42424098e-02f, -6.08961470e-02f, 1.91043839e-01f, -1.87821299e-01f, 3.02917492e-02f, -3.37263308e-02f, -1.22402042e-01f, -2.00223535e-01f, -1.14931986e-01f,
  -1.75298423e-01f, 1.51642516e-01f, 1.03119254e-01f, 1.73944637e-01f, -6.30082935e-02f, -1.57971665e-01f, -8.43814164e-02f, -1.66989177e-01f, -7.96036795e-02f, 5.45279011e-02f,
  1.11260794e-01f, -1.74615785e-01f, -5.38208604e-01f, 3.22343372e-02f, -3.56591195e-01f, -4.19095874e-01f, 1.37979031e-01f, -2.37570927e-01f, -1.66057333e-01f, -2.52740495e-02f,
  -1.73400939e+00f, -4.84253705e-01f, -1.30194873e-01f, -1.68661952e+00f, -8.71147871e-01f, -1.61718011e-01f, -3.45638156e-01f, -1.55854374e-01f, -5.84007621e-01f, -1.01803195e+00f,
  3.48040909e-01f, 8.60993087e-01f, 6.34763896e-01f, 7.46149957e-01f, 5.56010187e-01f, -1.13028085e+00f, -1.29654098e+00f, -4.15607989e-01f, 2.90279716e-01f, -2.36758724e-01f,
  -6.71355367e-01f, -1.10839283e+00f, -1.00835741e+00f, -4.44677144e-01f, -3.28310281e-01f, 2.68509328e-01f, -3.02003920e-01f, -4.81355518e-01f, 2.13313416e-01f, -6.39563262e-01f,
  4.62489724e-01f, -1.81787133e-01f, 3.80391538e-01f, -6.45934567e-02f, -1.30233303e-01f, 5.37405089e-02f, -3.98406312e-02f, -6.61866888e-02f, -2.94902865e-02f, -1.70022279e-01f,
  -9.22387168e-02f, -1.06086485e-01f, -1.36873931e-01f, 7.61901960e-02f, -4.00487006e-01f, -2.33025089e-01f, -2.63980448e-01f, -3.92112643e-01f, -1.43275678e-01f, 2.08223477e-01f,
  -8.08431879e-02f, -3.18750173e-01f, 9.10161212e-02f, 2.98331350e-01f, 2.98724413e-01f, -9.27709043e-03f, 3.16026092e-01f, 6.71777800e-02f, 3.39542702e-02f, -1.50782183e-01f,
  -3.91817182e-01f, 1.99178994e-01f, -1.01476289e-01f, -1.18106894e-01f, -2.36232542e-02f, 5.60115986e-02f, 1.08514495e-01f, -8.07521790e-02f, -3.16126794e-02f, -5.20492382e-02f,
  -7.09008500e-02f, -1.49664596e-01f, 2.21137572e-02f, -9.81300175e-02f, -3.51106338e-02f, -2.91741759e-01f, 1.15585625e-01f, -1.25751585e-01f, -1.11633882e-01f, -1.85332417e-01f,
  -1.11517711e-02f, 2.66346395e-01f, -1.08259507e-01f, 2.82942355e-01f, -1.37241155e-01f, -2.42479727e-01f, 1.64821148e-02f, 2.04308093e-01f, -4.47229818e-02f, -1.54218897e-01f,
  4.70696419e-01f, 4.19060849e-02f, -4.10877839e-02f, 6.45913035e-02f, -1.80645302e-01f, -2.59730052e-02f, -5.07558286e-02f, 3.52729298e-02f, 1.17414251e-01f, -1.43072978e-01f,
  2.36929595e-01f, -8.35171640e-02f, -1.25316560e-01f, -8.48046169e-02f, -9.66112465e-02f, 2.39261046e-01f, -2.55113989e-01f, -4.37903069e-02f, -1.67463366e-02f, -7.91283399e-02f,
  -2.02969372e-01f, -7.51344487e-02f, 1.30309343e-01f, 3.95202130e-01f, 1.44481570e-01f, 1.61730349e-01f, 2.68653542e-01f, 2.35671237e-01f, 8.44027326e-02f, -3.24300855e-01f,
  6.54087245e-01f, 4.29726362e-01f, 9.54910517e-01f, -1.27724290e-01f, 1.87492788e-01f, 4.44796652e-01f, 8.23669434e-01f, 3.37716371e-01f, -4.82299834e-01f, 3.40035319e-01f,
  3.99855435e-01f, -3.51421535e-01f, 3.18778530e-02f, 2.89554242e-02f, 5.51827133e-01f, 3.17281783e-01f, 1.63398683e-01f, 3.79210532e-01f, 6.80278167e-02f, -1.99577719e-01f,
  -5.48582017e-01f, -1.59425810e-01f, 1.28384680e-01f, -1.43462531e-02f, -3.65025401e-01f, -6.09002769e-01f, 2.29209080e-01f, 1.39252171e-01f, 2.34852910e-01f, -5.76554239e-01f,
  8.92494917e-02f, 6.14122391e-01f, -5.91062725e-01f, -2.37273842e-01f, 2.46028811e-01f, -3.11982006e-01f, -2.35606551e-01f, -9.62469727e-02f, -3.98900621e-02f, -2.15601027e-01f,
  5.49671017e-02f, -4.90570441e-02f, 2.42072474e-02f, 1.10621870e-01f, 4.66228947e-02f, -1.49048284e-01f, 1.07746013e-01f, 2.21202657e-01f, 1.38177782e-01f, 8.31311941e-02f,
  -2.51720577e-01f, 1.63947225e-01f, 4.20704722e-01f, 2.70810872e-02f, 2.89010227e-01f, 1.61201190e-02f, 2.83890128e-01f, 5.30135147e-02f, 3.08080584e-01f, -4.01045918e-01f,
  -1.24353513e-01f, 2.60772437e-01f, 3.20955813e-01f, -1.97725799e-02f, 1.51779190e-01f, -5.80228772e-03f, 1.65115610e-01f, 2.06534326e-01f, -4.06008214e-03f, -3.62609476e-02f,
  -8.39553103e-02f, 8.00237283e-02f, 5.50839379e-02f, -1.22398613e-02f, -1.84024826e-01f, 2.47696172e-02f, -9.30836797e-02f, 1.17698044e-01f, 1.79015741e-01f, -5.55224828e-02f,
  5.63789159e-02f, 9.85962898e-02f, 1.18894028e-02f, 1.54925078e-01f, -5.28779142e-02f, 1.48998097e-01f, -1.42963722e-01f, -1.30314693e-01f, -1.52367920e-01f, -2.84778941e-02f,
  -9.70367014e-01f, 8.79889250e-01f, -3.54868621e-01f, -1.19657345e-01f, 2.34540388e-01f, -5.49371317e-02f, 1.05016399e-02f, 3.87933999e-02f, 5.45978695e-02f, -1.79054379e-01f,
  1.38132825e-01f, -1.28183633e-01f, 2.91676164e-01f, 1.19418055e-01f, -3.22951615e-01f, -3.06276143e-01f, -7.31906593e-02f, 6.14575297e-02f, 1.19511083e-01f, 1.73572134e-02f,
  -1.63098291e-01f, -1.67928144e-01f, -3.57162446e-01f, -2.90935785e-01f, -4.09494162e-01f, -5.25221765e-01f, -1.07662946e-01f, -3.81056279e-01f, 6.53518215e-02f, -3.52614999e-01f,
  -9.27664563e-02f, 7.88543344e-01f, 1.16264440e-01f, -2.99842767e-02f, -5.42430440e-03f, 4.63787653e-02f, 2.06833333e-01f, 2.26046756e-01f, 5.32573164e-02f, 4.46214378e-02f,
  -2.20476970e-01f, -4.37580675e-01f, -1.37201011e-01f, -2.29335323e-01f, -3.49904895e-01f, 2.49810025e-01f, 1.45346045e-01f, -5.98076224e-01f, -1.03566432e+00f, -5.16974092e-01f,
  -2.51664847e-01f, -3.71446609e-01f, -5.44719517e-01f, -1.34106129e-01f, 6.31436706e-01f, -4.83133674e-01f, 2.07814798e-01f, 2.21646458e-01f, 4.55979794e-01f, 8.55997384e-01f,
  2.77725279e-01f, 1.06515563e+00f, -4.42888379e-01f, -2.03336641e-01f, -1.49135917e-01f, 1.84267908e-01f, -1.62905484e-01f, 2.39038631e-01f, -4.73862328e-02f, 1.58787623e-01f,
  -1.46235237e-02f, 1.41977355e-01f, -6.89610615e-02f, -1.67934239e-01f, -1.39185429e-01f, -4.06366624e-02f, 2.39633471e-01f, -9.18695610e-03f, -3.06485683e-01f, 1.91836104e-01f,
  -2.27150291e-01f, -2.14038983e-01f, -9.45084766e-02f, -8.05609524e-02f, 4.80866641e-01f, -7.62062371e-01f, 1.94686607e-01f, 6.43765867e-01f, 2.81854216e-02f, 5.27640939e-01f,
  -2.53574252e-01f, 6.08781911e-02f, 7.79780447e-02f, 2.50852346e-01f, -4.50671837e-02f, 2.15154514e-02f, 2.63521731e-01f, -1.22244529e-01f, -4.87057492e-02f, 6.69897571e-02f,
  -1.28164604e-01f, -1.06491856e-01f, -1.67959407e-02f, 4.24073003e-02f, -1.79758683e-01f, 9.93671641e-02f, 8.40430483e-02f, -2.07410291e-01f, -1.28192052e-01f, -3.92621011e-02f,
  -1.65180400e-01f, 3.82682979e-02f, 7.05329627e-02f, -9.55906510e-02f, 5.44039011e-02f, 1.89314470e-01f, -4.36088741e-02f, 6.28996417e-02f, -2.92437375e-02f, 1.54031888e-01f,
  -6.14454627e-01f, -6.15140498e-01f, -1.37292296e-01f, 1.19947977e-01f, 1.57448769e-01f, 4.74311151e-02f, 7.00405985e-02f, -1.10947648e-02f, 2.67488629e-01f, -2.73879796e-01f,
  -6.77142367e-02f, 1.25128344e-01f, 9.30055417e-03f, 2.45584641e-02f, -3.48488152e-01f, -2.43840829e-01f, -1.66475281e-01f, -3.34242433e-01f, -3.68467063e-01f, 1.87834099e-01f,
  -6.19871020e-02f, -5.72966933e-01f, -7.62115002e-01f, -4.61196631e-01f, -2.14817882e-01f, -9.93944347e-01f, -4.21835005e-01f, -3.05826217e-01f, -7.34852433e-01f, -8.10210466e-01f,
  -1.26937068e+00f, -6.09076023e-01f, -4.82762933e-01f, 2.16247752e-01f, 1.65936366e-01f, -7.30333805e-01f, -1.52964258e+00f, -9.75197136e-01f, 3.80654782e-02f, -7.53755450e-01f,
  -1.86755598e-01f, 6.08146727e-01f, 7.14066923e-02f, 1.15037285e-01f, -6.64911985e-01f, -7.24569738e-01f, 2.96354443e-02f, 3.94611031e-01f, 4.70107883e-01f, 2.21529797e-01f,
  6.79449558e-01f, 6.09880805e-01f, 3.14819664e-01f, 1.92141876e-01f, 5.08390963e-01f, 4.52179760e-01f, -9.52779949e-02f, 5.93523085e-01f, 5.71546219e-02f, 7.49781728e-01f,
  1.42578986e-02f, -5.68409383e-01f, 2.81371213e-02f, 3.86496812e-01f, 3.41262400e-01f, -3.64799649e-01f, -3.32665175e-01f, 9.61047634e-02f, 7.59116048e-03f, -2.25164101e-01f,
  4.13683593e-01f, 2.45586783e-03f, 3.57831359e-01f, -6.66659698e-02f, -5.44769764e-02f, -3.64463687e-01f, -7.64687806e-02f, -3.78438860e-01f, -3.62241596e-01f, -1.86899006e-01f,
  1.06697583e+00f, 5.44272542e-01f, -5.96175611e-01f, -2.47141600e-01f, -4.61223304e-01f, 3.41773957e-01f, -3.91776323e-01f, 1.34126097e-01f, -5.62569499e-01f, -1.74984679e-01f,
  -9.67533365e-02f, 2.18373358e-01f, 8.72049853e-02f, -1.84684824e-02f, 5.60944267e-02f, -1.52177261e-02f, 1.82591841e-01f, 1.85211122e-01f, -9.21691805e-02f, -2.89039731e-01f,
  7.98365995e-02f, 2.78042600e-04f, 3.42367254e-02f, -2.14181840e-01f, 2.05763459e-01f, 4.64978144e-02f, 2.22088650e-01f, -2.64321446e-01f, 7.52597908e-03f, -2.53554970e-01f,
  8.35228264e-02f, 2.24873796e-02f, 3.82396191e-01f, 1.10055141e-01f, 5.28226793e-02f, 2.15742253e-02f, 5.40045882e-03f, -1.39892191e-01f, -1.05526485e-01f, -2.72618048e-02f,
  -3.27949561e-02f, -8.66082218e-03f, -3.97163153e-01f, 1.84240550e-01f, 4.34972830e-02f, 2.79105812e-01f, 4.01132815e-02f, 2.00256318e-01f, 1.28773287e-01f, -4.14536327e-01f,
  -3.19813579e-01f, -2.64585674e-01f, -1.23368204e-02f, 1.79762036e-01f, -7.89915994e-02f, -4.96246934e-01f, -6.74323440e-02f, -1.26634523e-01f, -2.39319146e-01f, 1.66564971e-01f,
  -1.51445001e-01f, -7.73254573e-01f, -9.66230869e-01f, -8.96825790e-01f, -9.22783315e-02f, -6.96775794e-01f, -5.98341525e-01f, -2.70581603e-01f, -1.03783154e+00f, -1.58154130e+00f,
  1.45505309e+00f, 4.26321983e-01f, -1.81504416e+00f, 4.79646213e-03f, -1.24109256e+00f, -1.01404238e+00f, -6.66296303e-01f, 9.88708138e-02f, 7.88067102e-01f, 1.85534909e-01f,
  1.27116919e-01f, -1.63316354e-01f, -1.47092119e-01f, -3.67080092e-01f, -3.88271987e-01f, -5.99890172e-01f, -3.88520688e-01f, -8.93334389e-01f, -1.07457590e+00f, -6.11581564e-01f,
  1.17263328e-02f, 4.18234646e-01f, 5.02403200e-01f, -7.70730600e-02f, -3.04559886e-01f, -3.82591844e-01f, -2.68958360e-01f, -5.50792634e-01f, -8.65444779e-01f, -1.14437222e+00f,
  -1.51658869e+00f, -5.40532172e-01f, -6.73782706e-01f, -1.43661797e-01f, -1.69414282e-01f, 3.18547398e-01f, -3.08459997e-01f, -9.01473388e-02f, 3.47432584e-01f, 6.55545443e-02f,
  -3.48973423e-01f, -2.31993005e-01f, -2.08765134e-01f, -6.16926670e-01f, -2.27432355e-01f, -1.88694611e-01f, 3.69742662e-01f, -1.39538795e-01f, -8.06345791e-02f, -1.19244568e-01f,
  1.15299940e-01f, -7.85254240e-01f, -7.66721904e-01f, 3.14620495e-01f, -1.79650076e-02f, -4.27406043e-01f, -3.82880032e-01f, -6.99221194e-01f, -4.78249460e-01f, 2.24714667e-01f,
  -8.39699060e-02f, 9.40965116e-02f, -1.46984845e-01f, 2.59226561e-01f, 2.29386285e-01f, 8.58360678e-02f, -3.32536139e-02f, 2.40649730e-02f, 9.65727493e-02f, -2.61618551e-02f,
  -2.48573571e-01f, -1.87337920e-01f, -9.20251198e-03f, -5.65529056e-02f, -2.97601730e-01f, -2.00587705e-01f, 1.76195595e-02f, 1.72821254e-01f, -2.29431659e-01f, -5.50949387e-02f,
  -2.16082543e-01f, 2.61639412e-02f, 2.09034488e-01f, 1.56394452e-01f, -1.17825747e-01f, -2.54733473e-01f, -4.26416956e-02f, 8.68717059e-02f, 1.71020925e-01f, 9.18322653e-02f,
  2.92324334e-01f, 2.42356613e-01f, -6.58766404e-02f, -1.78882271e-01f, -3.52521360e-01f, -3.04658208e-02f, 1.61963329e-01f, 8.47583339e-02f, -2.15445220e-01f, -2.55769253e-01f,
  -1.09731793e-01f, 1.45088986e-01f, 4.36371416e-02f, -1.19308522e-02f, -1.78405851e-01f, -1.17399462e-01f, 3.70247066e-01f, -1.33661762e-01f, -2.41238195e-02f, 3.20970356e-01f,
  4.87283498e-01f, 1.78607464e-01f, 2.06999555e-02f, -3.91125791e-02f, 2.21916527e-01f, -1.47117347e-01f, -2.95902669e-01f, -2.54521281e-01f, -1.84530854e-01f, 8.72389674e-01f,
  4.66699988e-01f, -8.90907422e-02f, -4.08173241e-02f, 5.48271894e-01f, 4.50965017e-01f, 4.64229405e-01f, 4.91417408e-01f, 4.15815890e-01f, 4.63629574e-01f, 3.66043091e-01f,
  1.51827380e-01f, 3.30453724e-01f, 3.50539774e-01f, 3.97812575e-01f, 3.57331067e-01f, 4.17902291e-01f, 3.93001467e-01f, 2.61156350e-01f, 2.91778594e-01f, 3.54689330e-01f,
  5.30036867e-01f, 8.52716491e-02f, -1.67888954e-01f, 8.86159316e-02f, 1.05293870e-01f, 2.78057039e-01f, 6.63668066e-02f, -2.78921723e-02f, -9.05155241e-02f, 8.34119972e-03f,
  9.99567881e-02f, -8.94045681e-02f, 3.74710590e-01f, 1.18908405e-01f, -1.64002970e-01f, -1.74757093e-01f, 2.38376018e-02f, -3.26291054e-01f, -3.61331552e-01f, -1.15413174e-01f,
  -2.72199303e-01f, -2.21133709e-01f, -1.77619550e-02f, -2.28959709e-01f, -2.40799800e-01f, -7.10700452e-02f, -1.62226185e-01f, 1.02012537e-01f, 7.72221833e-02f, -6.79552555e-02f,
  8.75634700e-02f, -5.01072779e-03f, -9.93555710e-02f, -6.01526648e-02f, 1.06913060e-01f, -7.87735879e-02f, -1.15033597e-01f, -9.23769996e-02f, -1.18526638e-01f, 1.33375246e-02f,
  4.74130183e-01f, 2.14290828e-01f, 2.46488392e-01f, 8.35113749e-02f, 1.80560112e-01f, 5.70598282e-02f, 2.50051655e-02f, 9.32747722e-02f, 2.73995161e-01f, -8.26267079e-02f,
  -4.38745953e-02f, 2.26572111e-01f, -7.85401091e-03f, 4.03689258e-02f, 6.47396222e-02f, -2.25604668e-01f, -2.58824915e-01f, -9.93620232e-02f, -1.10938370e-01f, -1.46798477e-01f,
  -5.39624803e-02f, -1.37631956e-03f, -2.84335315e-01f, -2.08993554e-01f, -2.13403553e-01f, -3.99215221e-02f, -1.22750886e-01f, -1.13106407e-01f, 2.20695995e-02f, -2.25393679e-02f,
  5.09806871e-02f, 1.48411021e-01f, 3.38681370e-01f, -9.36367214e-02f, -9.72266272e-02f, -4.04994577e-01f, 1.23425186e-01f, -2.41425216e-01f, -3.34414035e-01f, -1.30169272e-01f,
  -2.66505510e-01f, -2.92010874e-01f, -7.50603676e-02f, -1.27073079e-01f, -3.26466300e-02f, -1.15094557e-01f, -7.04167411e-02f, 1.57959297e-01f, 4.87304889e-02f, -1.85230240e-01f,
  -4.23313379e-02f, 5.75890951e-02f, -8.24905932e-03f, 6.82991967e-02f, 1.50784582e-01f, 8.36547688e-02f, -1.22416779e-01f, -2.05136836e-02f, -1.69148594e-01f, 4.49215174e-02f,
  -1.28951538e+00f, -4.92866874e-01f, 2.77606733e-02f, -2.81516403e-01f, 7.62174249e-01f, 8.20205152e-01f, 9.43114638e-01f, 5.26935041e-01f, -2.00428497e-02f, -1.40000194e-01f,
  -6.60454333e-01f, -5.66951632e-01f, -1.02131629e+00f, -2.00004682e-01f, 7.63882697e-02f, 4.19576287e-01f, 1.79909453e-01f, -6.27705734e-03f, 6.58338308e-01f, 8.86571705e-01f,
  5.85632026e-01f, -1.05191141e-01f, -5.11872768e-01f, -1.12796903e-01f, -2.33240739e-01f, -2.78166542e-03f, -4.42625821e-01f, -4.35881168e-01f, -1.38845081e-02f, -1.96044832e-01f,
  -4.76609886e-01f, -4.45381016e-01f, 2.83798575e-01f, -2.48463005e-01f, -2.55763113e-01f, -1.53761148e-01f, 7.63806179e-02f, -2.29556680e-01f, -3.21624279e-01f, -1.36295989e-01f,
  -2.75092870e-01f, -1.64989486e-01f, -2.27955550e-01f, -1.73382998e-01f, -1.51252732e-01f, 5.81702329e-02f, -2.96146393e-01f, -1.22671798e-01f, -3.53959531e-01f, -2.91877724e-02f,
  1.46721736e-01f, -8.87031332e-02f, -1.66639015e-01f, 3.39831978e-01f, 3.20900410e-01f, 1.44809529e-01f, 2.02808127e-01f, 2.29033872e-01f, 5.66104986e-02f, -3.35068226e-01f,
  1.81251675e-01f, -1.71370089e-01f, 1.07927911e-01f, 1.81692973e-01f, 5.04295416e-02f, -4.47230674e-02f, 2.08040630e-03f, 8.14329460e-02f, 6.32005259e-02f, -1.04326941e-01f,
  1.76271051e-01f, -2.81277180e-01f, 1.73353076e-01f, -9.40800756e-02f, -3.64093110e-02f, -2.41260529e-02f, 4.63330485e-02f, -1.39546141e-01f, -1.57181427e-01f, -9.99473408e-02f,
  -4.78204479e-03f, -4.77788560e-02f, -1.15018383e-01f, 7.21374229e-02f, 1.59500480e-01f, -2.34200843e-02f, 3.66120692e-03f, 1.07276864e-01f, -4.74475920e-02f, -1.60982460e-02f,
  -5.26125848e-01f, 2.39929929e-02f, -5.48171282e-01f, 1.26603425e-01f, -9.55804884e-02f, 1.15751892e-01f, -2.36484349e-01f, 4.11807708e-02f, -2.06746891e-01f, -6.67428374e-02f,
  1.59182832e-01f, -3.25535871e-02f, -2.74511755e-01f, 4.74990346e-02f, 1.61447123e-01f, 9.23535004e-02f, -1.21949948e-01f, -2.04786569e-01f, 7.73602128e-02f, 2.18294278e-01f,
  1.01210333e-01f, 3.12123716e-01f, 7.75208324e-02f, -1.92790374e-01f, 1.50018213e-02f, -5.31604588e-02f, -1.84870549e-02f, 8.96695480e-02f, 3.61960195e-02f, 6.85500586e-03f
};

// L0_fan_Bp_bar (Shape: 1 x 8)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 8;
const float L0_fan_Bp_bar_data[] = {
  1.30896235e+00f, 8.68878901e-01f, 1.53296494e+00f, 1.12060308e+00f, 7.21716821e-01f, 1.12660348e+00f, 1.13055003e+00f, 1.45781386e+00f
};

// L1_linear_W (Shape: 12 x 16)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 16;
const float L1_linear_W_data[] = {
  -1.70093048e+00f, -3.43972087e-01f, 4.05773431e-01f, 7.43894204e-02f, 4.29903626e-01f, 7.89283037e-01f, 1.97561908e+00f, -2.18454391e-01f, -1.86298323e+00f, 1.85360596e-01f,
  -1.25275385e+00f, -3.30051392e-01f, 3.36543560e-01f, 2.59504199e-01f, -8.71505320e-01f, 5.53560019e-01f, -1.04795031e-01f, 7.72204399e-01f, -1.70269978e+00f, -1.41998506e+00f,
  5.96254349e-01f, -6.98537901e-02f, 8.83265913e-01f, -1.14071429e+00f, -9.30355191e-01f, 4.77437139e-01f, 4.33867991e-01f, -2.13235474e+00f, -1.06515551e+00f, 4.45429206e-01f,
  3.54593873e-01f, -1.46694338e+00f, 4.89967108e-01f, -3.43333989e-01f, -5.40141575e-02f, -4.19526160e-01f, 9.21962321e-01f, 4.69511777e-01f, 6.36031866e-01f, -8.43097627e-01f,
  1.10053992e+00f, -8.99066031e-01f, 3.14031452e-01f, -1.76293111e+00f, 8.83903801e-01f, -3.57748270e-01f, -1.21144998e+00f, 3.63316126e-02f, -1.51296306e+00f, 3.65159750e-01f,
  -1.14822245e+00f, -5.56629479e-01f, 4.79040802e-01f, 1.32811084e-01f, -1.10113788e+00f, 6.59855008e-01f, 5.68708897e-01f, 3.29341233e-01f, 2.68609285e-01f, 1.65038675e-01f,
  -8.10758173e-01f, -2.80616909e-01f, -1.55808389e+00f, 1.26780415e+00f, 1.49183643e+00f, -7.44074821e-01f, 3.64521056e-01f, -1.47895485e-01f, -2.38024965e-01f, 6.20779514e-01f,
  -1.95035529e+00f, 8.05648416e-02f, -5.62140644e-01f, 2.64799029e-01f, -7.68820822e-01f, 8.01196814e-01f, -5.91125116e-02f, 4.52659465e-02f, 2.26227924e-01f, -1.30473900e+00f,
  1.22334409e+00f, 2.03809693e-01f, 1.34234738e+00f, 1.13227427e+00f, -4.76214379e-01f, -7.65806079e-01f, 1.01467359e+00f, 7.31983423e-01f, -6.65661156e-01f, -4.99342382e-01f,
  -9.07434940e-01f, -1.25485885e+00f, -1.84287056e-01f, 1.03926229e+00f, 1.66940600e-01f, -7.93426573e-01f, -6.12661362e-01f, 2.82528847e-02f, 3.81698698e-01f, 3.54745984e-01f,
  -8.46746027e-01f, 5.12492001e-01f, 9.16350067e-01f, -3.33487540e-02f, 1.32749128e+00f, -1.51894975e+00f, -2.82014627e-02f, 8.96860063e-01f, -4.24457699e-01f, -1.39303744e+00f,
  -1.49510786e-01f, -1.65019202e+00f, -1.91404581e-01f, 3.23102027e-01f, -1.32167411e+00f, -9.22454059e-01f, 6.36363149e-01f, -1.18024744e-01f, -1.14969540e+00f, 4.57410008e-01f,
  -9.01350379e-01f, -9.92802441e-01f, -6.10779822e-01f, 5.70416749e-01f, 2.16498256e-01f, -7.17565298e-01f, 4.63116646e-01f, 8.06365550e-01f, 7.89928794e-01f, -6.31069124e-01f,
  -9.37387645e-01f, 8.37703407e-01f, -9.72900987e-01f, -7.04213738e-01f, 9.14600611e-01f, 3.37146729e-01f, -1.02845407e+00f, -1.44200349e+00f, -6.11689091e-01f, -1.32938778e+00f,
  -1.54832530e+00f, -1.50685644e+00f, 4.07663770e-02f, 1.74999309e+00f, -1.03759134e+00f, 1.28221288e-01f, 5.80423236e-01f, 3.49687576e-01f, -1.00897408e+00f, 2.25811630e-01f,
  -1.74760997e+00f, -5.26910424e-01f, -1.16375482e+00f, -1.49570441e+00f, -5.92085361e-01f, -7.71496817e-02f, 1.41421163e+00f, 1.35857359e-01f, -2.55286694e-01f, -2.30688405e+00f,
  6.01566374e-01f, -4.25954834e-02f, 5.49110889e-01f, 1.28756808e-02f, 7.86894262e-01f, -8.87559831e-01f, -1.33400157e-01f, 3.09472322e-01f, 8.85563374e-01f, 1.11898077e+00f,
  -1.19698381e+00f, -1.39190507e+00f, -9.10342634e-01f, -1.55694473e+00f, -1.70668304e-01f, -8.15108567e-02f, -1.07952043e-01f, 4.16213684e-02f, 3.82925272e-01f, 5.50229251e-02f,
  -5.03632247e-01f, -4.36515957e-01f, -5.93911588e-01f, 5.60477197e-01f, -1.12671149e+00f, -9.51789498e-01f, 1.38252091e+00f, 7.28894353e-01f, -1.26048231e+00f, -5.87518752e-01f,
  -4.80303407e-01f, -8.13210368e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -3.02487761e-01f, 6.14059269e-01f, 5.42812467e-01f, -1.28874040e+00f, -2.37788484e-02f, 1.96786389e-01f, -1.09215029e-01f, -6.24472141e-01f, 4.81719941e-01f, 1.40535757e-01f,
  -8.13399911e-01f, -7.47477636e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 4, 8
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        16, 12
    );
    }
    