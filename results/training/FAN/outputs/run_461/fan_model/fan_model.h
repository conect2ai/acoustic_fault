/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x3)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -3.49109888e-01f, 5.01599461e-02f, -6.27856255e-02f, 2.08012432e-01f, -4.76871021e-02f, -6.15044124e-02f, 6.14855774e-02f, 6.90335631e-02f, -7.55300894e-02f, 1.82823330e-01f,
  3.37257348e-02f, -1.27109960e-01f, -3.61565165e-02f, 2.08486050e-01f, 6.48684101e-03f, 5.55366017e-02f, 5.52486815e-02f, 7.07250834e-02f, -5.75928986e-02f, 1.67864617e-02f,
  -4.65567186e-02f, 2.01793253e-01f, 7.53639191e-02f, 1.43942818e-01f, -7.74954632e-02f, -2.10194960e-02f, 1.98421791e-01f, -5.31429946e-02f, 2.15820447e-01f, 4.99471724e-02f,
  -3.14780548e-02f, 5.81934229e-02f, 1.48072932e-02f, -2.42851246e-02f, -9.98595450e-03f, -9.12667811e-03f, -1.01071652e-02f, -1.55864302e-02f, 4.27275002e-02f, 2.83779181e-03f,
  -8.29443410e-02f, 4.88395337e-03f, 5.12281433e-02f, -2.62743849e-02f, 9.46571678e-03f, -4.68182601e-02f, -5.17035648e-02f, 8.78532454e-02f, 7.98291527e-03f, -2.05436703e-02f,
  -2.65667420e-02f, -5.73928766e-02f, -1.06074121e-02f, -2.52067447e-02f, -2.02697068e-02f, -7.14644743e-03f, 2.57598832e-02f, -3.97994816e-02f, -3.14540714e-02f, -5.59628941e-04f,
  -7.39607736e-02f, 1.23024583e-02f, 2.89865993e-02f, 2.43405886e-02f, 7.43942801e-03f, 2.69211754e-02f, 5.77848107e-02f, 4.16146815e-02f, -7.09348172e-02f, 9.08847898e-02f,
  7.41507905e-03f, 1.40289869e-02f, 1.76091660e-02f, 7.05685094e-02f, 2.11494938e-02f, 1.99240465e-02f, -1.01034485e-01f, 1.61904898e-02f, -4.30809669e-02f, -1.35592632e-02f,
  5.30580468e-02f, -2.74918899e-02f, 7.89102614e-02f, -4.74649407e-02f, 3.80611382e-02f, 5.37456498e-02f, 7.13789761e-02f, 8.04313186e-06f, 1.60490405e-02f, 9.39984340e-03f,
  6.75746873e-02f, 1.21744260e-01f, 5.03419265e-02f, 5.54379411e-02f, -6.14062175e-02f, -4.13461775e-02f, -1.90256704e-02f, -4.73201135e-03f, -8.70061815e-02f, -6.62702173e-02f,
  -5.74162938e-02f, 6.76592141e-02f, -6.75363913e-02f, 1.06511466e-01f, -4.62278277e-02f, 2.66355518e-02f, 6.61254153e-02f, -2.78187431e-02f, 2.30383072e-02f, 4.98565100e-02f,
  4.28563021e-02f, -1.34289628e-02f, -4.56104092e-02f, -3.74397673e-02f, 5.81430532e-02f, -1.73890740e-02f, 6.91443915e-03f, -2.01750752e-02f, 8.87693651e-03f, 4.47575524e-02f,
  -1.60222098e-01f, 2.39239037e-02f, 4.23224941e-02f, -1.77408949e-01f, -1.61702976e-01f, 9.43627134e-02f, 2.26164907e-01f, -1.82172909e-01f, -2.31789753e-01f, 2.31897179e-02f,
  2.81273834e-02f, 2.85511818e-02f, 2.42083132e-01f, -5.87472208e-02f, 2.11094841e-01f, 9.10213143e-02f, -6.87196776e-02f, -4.94672060e-02f, -8.97981375e-02f, -7.43310452e-02f,
  -9.38598812e-02f, -7.65857622e-02f, 9.72514823e-02f, -5.94325252e-02f, 5.33978716e-02f, -1.12065397e-01f, -5.97042255e-02f, 8.17713961e-02f, -2.80582663e-02f, 1.21456839e-01f,
  5.30909374e-02f, 6.80780485e-02f, -5.00018671e-02f, 4.95037958e-02f, -1.74824577e-02f, 3.06728631e-02f, -1.67977568e-02f, 1.34963781e-01f, 6.60113478e-03f, 1.36884041e-02f,
  6.53829724e-02f, -1.54667739e-02f, 5.57183695e-04f, 3.22579108e-02f, -6.05390631e-02f, 3.07101328e-02f, -1.07597690e-02f, -4.85589914e-02f, -6.94059655e-02f, 7.58744255e-02f,
  6.84475666e-03f, 9.23361722e-03f, 5.65714762e-03f, -1.88149046e-02f, 1.98626909e-02f, 1.49064055e-02f, 2.99317352e-02f, 8.85637403e-02f, 4.43734117e-02f, -2.84463502e-02f,
  7.83659592e-02f, 6.57432526e-03f, 8.60830955e-03f, -3.13468315e-02f, 4.08883207e-02f, -8.73648748e-03f, 4.38805856e-02f, 1.71343163e-02f, -5.40926158e-02f, 5.73054403e-02f,
  -1.42081916e-01f, -4.47595231e-02f, -1.50103252e-02f, -5.52056916e-02f, -1.26517043e-02f, -8.20788816e-02f, 2.85470914e-02f, -2.64169574e-02f, -6.34152293e-02f, -6.64108247e-02f,
  3.69537100e-02f, -3.25568803e-02f, -2.12670937e-02f, 5.69459200e-02f, 5.97763062e-02f, 1.35050714e-03f, 8.73717247e-04f, 5.08793676e-03f, -2.45550051e-02f, -1.47651490e-02f,
  7.97450263e-03f, 6.48691282e-02f, 1.22584023e-01f, -9.99382790e-03f, 1.63444001e-02f, -8.04625917e-03f, 6.85161352e-02f, 4.55238624e-03f, 9.48556289e-02f, -6.90084603e-03f,
  -6.29876857e-04f, -2.16801092e-02f, -3.33817117e-03f, -3.01935133e-02f, 4.56029400e-02f, -1.00732967e-02f, 4.35118042e-02f, -1.40049169e-02f, 6.13343082e-02f, -1.91078074e-02f,
  -1.97735988e-03f, -2.36648191e-02f, -5.38312225e-03f, -3.93050760e-02f, 8.87552463e-03f, 5.04276669e-03f, -1.03611887e-01f, 6.81697354e-02f, 1.58678703e-02f, 1.33954277e-02f,
  -1.77449852e-01f, -3.54584344e-02f, -2.01361939e-01f, -1.46682831e-02f, 8.78790468e-02f, 7.41994847e-03f, 1.66601837e-02f, -3.81845445e-03f, -1.61323473e-01f, 2.13349164e-02f,
  8.44911486e-02f, -2.18497321e-01f, -1.53017625e-01f, 2.33692974e-01f, 5.45551479e-02f, -6.73007965e-02f, 1.28142983e-01f, 1.36830891e-02f, -6.94661262e-03f, -1.44167356e-02f,
  -1.33334264e-01f, 1.81465954e-01f, -7.86703080e-02f, 8.08119774e-02f, -1.28285242e-02f, -4.71118614e-02f, 2.16891035e-01f, -1.73781570e-02f, 3.39967668e-01f, 1.48447603e-01f,
  1.37401864e-01f, -2.76591424e-02f, -5.48892319e-02f, 6.37247339e-02f, -9.30144172e-03f, -3.86660360e-02f, 1.04041070e-01f, 5.29693030e-02f, -5.17308824e-02f, 2.13391334e-02f,
  -8.15262794e-02f, 1.64272841e-02f, 1.15803435e-01f, 1.15566952e-02f, -4.04016897e-02f, -1.55352205e-02f, 5.07706143e-02f, 2.76186056e-02f, -3.49445567e-02f, -9.48421955e-02f,
  -1.39647007e-01f, -5.49248494e-02f, -5.25049493e-02f, 3.82079557e-02f, -1.53301507e-02f, -2.98935361e-02f, -5.02830669e-02f, 1.75908655e-02f, 3.98442261e-02f, -6.86316341e-02f,
  -3.07768863e-03f, -5.09960651e-02f, 3.08829229e-02f, 5.36222011e-02f, 6.11449145e-02f, 6.40616342e-02f, 2.66782753e-02f, 5.67083014e-04f, -8.54296959e-04f, 1.43129844e-02f,
  7.98439384e-02f, 4.43751402e-02f, 4.20509353e-02f, -9.83873159e-02f, -6.28625154e-02f, 5.86883165e-04f, -3.01266983e-02f, 1.11755654e-01f, -4.94221114e-02f, -4.12530452e-03f,
  -3.49259675e-02f, 1.25561971e-02f, -5.18456772e-02f, -1.85567532e-02f, 1.20630469e-02f, -8.31260011e-02f, -1.34685740e-01f, -8.35808516e-02f, 6.36190549e-02f, -1.60308741e-02f,
  1.72447726e-01f, 1.56370759e-01f, 7.88420253e-03f, 6.97893277e-02f, 3.84286270e-02f, 9.49711259e-03f, 1.77167635e-02f, -3.10194250e-02f, 5.75023331e-02f, -1.64235681e-02f,
  3.02939452e-02f, 4.53019850e-02f, 3.42545994e-02f, 8.64216127e-03f, 6.14593588e-02f, -1.18149277e-02f, -3.25563550e-03f, 7.17812479e-02f, 8.62054080e-02f, 9.17180479e-02f,
  8.72197822e-02f, 5.10186031e-02f, -1.15049966e-02f, 2.37487331e-02f, 5.25302850e-02f, -2.18372922e-02f, -2.79252809e-02f, -2.16202755e-02f, 7.17544034e-02f, -8.03272650e-02f,
  6.38901889e-02f, -1.20132696e-02f, -1.87338948e-01f, 7.37626925e-02f, -2.35619590e-01f, 2.13095650e-01f, 1.17186017e-01f, 2.93145678e-03f, -1.69164091e-01f, 3.37472320e-01f,
  -1.06534269e-02f, 4.36168462e-02f, 1.65144816e-01f, 9.61883366e-02f, 4.84764352e-02f, 4.18597087e-02f, 1.92808867e-01f, 1.35947289e-02f, -1.78930432e-01f, 9.22999680e-02f,
  -1.34672210e-01f, 1.49655893e-01f, -1.36802375e-01f, -2.07038410e-02f, -6.37135506e-02f, -1.88879073e-01f, 2.36743800e-02f, -1.76073566e-01f, 1.89120547e-05f, -1.01926111e-01f,
  -6.26271293e-02f, -8.32234323e-02f, -9.18817222e-02f, 5.18172700e-03f, -4.39583184e-03f, -6.96906224e-02f, 3.30558605e-02f, -3.78673337e-02f, -1.22264929e-01f, 2.31335200e-02f,
  3.44354995e-02f, 2.42047533e-02f, -2.40176544e-03f, 2.36131884e-02f, 2.04267055e-02f, -7.70502314e-02f, -8.21273625e-02f, -2.34729126e-02f, -6.61304072e-02f, -1.85365323e-02f,
  -1.28099889e-01f, -3.78727280e-02f, -3.22730169e-02f, 9.28082168e-02f, -3.83922979e-02f, 3.41159143e-02f, 7.91041106e-02f, -2.75933724e-02f, 5.70265800e-02f, -2.42049131e-03f,
  1.36023778e-02f, 9.82011016e-03f, -2.52663996e-02f, -4.79251286e-03f, -5.61088137e-03f, -2.71022860e-02f, -2.66893171e-02f, 3.66701372e-02f, -8.75199065e-02f, 4.83291596e-02f,
  7.89278746e-02f, -4.37387498e-03f, -4.10427861e-02f, -4.01671492e-02f, 3.65837221e-03f, 8.10757745e-03f, 1.22521035e-02f, 1.49078630e-02f, -1.24406544e-02f, -7.49060586e-02f,
  2.16090344e-02f, 2.78367400e-02f, -3.49717326e-02f, -6.10965230e-02f, 2.41519362e-02f, -2.77604070e-02f, 2.27543036e-03f, 5.30637503e-02f, -7.06345811e-02f, 2.23180316e-02f,
  9.64879245e-02f, 1.98664106e-02f, -2.01729052e-02f, 6.43784404e-02f, -2.88612465e-03f, 3.48755307e-02f, -2.62499694e-02f, 7.60093927e-02f, -3.62222046e-02f, 9.64730233e-02f,
  1.06883787e-01f, 6.99319690e-02f, 4.00738120e-02f, -2.72981022e-02f, 3.70585732e-02f, 2.44781934e-02f, 4.97880466e-02f, 2.72883847e-02f, 2.27683019e-02f, -1.95517000e-02f,
  5.17372936e-02f, 6.16896115e-02f, 2.89473757e-02f, 1.28418533e-02f, 2.57129669e-02f, -1.18634654e-02f, -2.76292693e-02f, 5.55519015e-03f, -1.10440604e-01f, 5.50717041e-02f,
  -3.87344778e-01f, 4.64218944e-01f, 7.82280415e-02f, 2.69441634e-01f, -1.51635662e-01f, -2.48256214e-02f, -1.54814690e-01f, 1.31759495e-01f, 4.71510775e-02f, 1.98633566e-01f,
  -2.57820040e-01f, 1.32744059e-01f, -9.59708728e-03f, 1.09712206e-01f, -3.59839082e-01f, 2.47946188e-01f, 1.58226062e-02f, -4.33289148e-02f, 1.05141193e-01f, 3.44897211e-02f,
  1.84200145e-02f, -7.75278434e-02f, 4.15988714e-02f, 1.11331820e-01f, 1.54337781e-02f, 5.14795864e-03f, 1.51778916e-02f, 5.44058084e-02f, 1.43737579e-02f, -1.96328647e-02f,
  -1.86954513e-02f, 2.44575180e-02f, -4.15345877e-02f, 6.35259748e-02f, -1.00898184e-01f, -4.07527313e-02f, 5.00101894e-02f, -2.80231405e-02f, 6.48720888e-03f, 5.00847446e-03f,
  -2.59274729e-02f, 3.28945071e-02f, 1.96176823e-02f, 4.34224121e-02f, -3.84583808e-02f, 7.03471974e-02f, 3.46520133e-02f, -6.99747493e-03f, 1.14606626e-01f, -3.49249365e-03f,
  4.47232388e-02f, 1.41294478e-02f, 6.80638775e-02f, 6.64649606e-02f, -4.58732992e-02f, 6.28802518e-05f, -8.47465079e-03f, -4.73279990e-02f, 5.52807450e-02f, 4.17135954e-02f,
  -3.44427973e-02f, -1.64297635e-05f, -3.25777270e-02f, -1.43524790e-02f, 5.42645082e-02f, -8.27133507e-02f, 1.08398488e-02f, -9.70588475e-02f, -5.29629625e-02f, 1.87494904e-02f,
  -6.09861538e-02f, 3.80150862e-02f, 6.07934408e-03f, -5.63423429e-03f, -5.17261140e-02f, -5.91621250e-02f, -2.76054926e-02f, -7.49679655e-02f, 2.52552442e-02f, -9.41016674e-02f,
  2.77961474e-02f, 3.17633757e-03f, -2.04982614e-04f, -1.61557831e-02f, 2.02812646e-02f, -2.40852195e-03f, 6.42442256e-02f, 3.81398536e-02f, -2.15836503e-02f, -2.05052327e-02f,
  4.23406102e-02f, 1.34451330e-01f, 4.04272927e-03f, -4.53763418e-02f, 6.63089529e-02f, -6.39827317e-03f, -2.20399592e-02f, 4.51314747e-02f, -5.99161629e-03f, -8.39584973e-04f,
  -2.87256371e-02f, -4.28540781e-02f, 3.16760242e-02f, -1.69061273e-02f, 4.56992624e-04f, -2.05472223e-02f, 1.73512995e-02f, 2.54354738e-02f, -2.49378663e-02f, -1.46005806e-02f,
  -2.06339248e-02f, -2.52144653e-02f, 2.31478270e-02f, -4.70469445e-02f, -4.22259979e-02f, -5.25629632e-02f, -4.10447232e-02f, 2.85012964e-02f, 1.45646874e-02f, -4.12682965e-02f,
  -5.97679392e-02f, -2.59728402e-01f, 1.54750884e-01f, -7.68487081e-02f, 4.23907414e-02f, 1.81408957e-01f, 2.40671039e-01f, -5.35924546e-02f, -1.93637937e-01f, -1.69413373e-01f,
  1.03288203e-01f, 4.48451899e-02f, 8.22436512e-02f, -6.36445032e-03f, 3.27193201e-01f, -1.23586833e-01f, 1.20279551e-01f, -3.47449295e-02f, -2.54642889e-02f, 3.37046050e-02f,
  4.96008024e-02f, 1.02965413e-02f, 1.81017101e-01f, -3.95353101e-02f, 3.76444459e-02f, -1.39742121e-01f, -2.31644101e-02f, 1.03937753e-01f, 6.44054785e-02f, 9.57799517e-03f,
  3.29288282e-02f, -1.65978491e-01f, -2.55792085e-02f, 1.07490737e-02f, 8.80300403e-02f, 7.89526552e-02f, 8.93166214e-02f, 1.04226172e-01f, 2.96039283e-02f, 3.04574855e-02f,
  2.21393760e-02f, 4.89924885e-02f, -4.97804359e-02f, 7.86482915e-03f, 5.20280888e-03f, 1.54997082e-02f, 7.88474008e-02f, -6.07165396e-02f, 8.26693140e-03f, 1.04203947e-01f,
  3.92794497e-02f, 7.43358284e-02f, 1.90591775e-02f, 3.80488560e-02f, 8.59810188e-02f, 5.67336045e-02f, 6.91817701e-02f, 4.94928472e-02f, -1.40884696e-02f, -2.75668632e-02f,
  3.60585600e-02f, 2.82993307e-03f, -3.95093448e-02f, -1.49390986e-02f, -7.90149942e-02f, -2.52307225e-02f, -5.04267327e-02f, 3.84484567e-02f, -1.91400256e-02f, 4.20170370e-03f,
  3.81918773e-02f, -3.90917175e-02f, 8.34107585e-03f, 3.14068533e-02f, -2.73069553e-02f, -2.69041006e-02f, 8.64164978e-02f, -4.13848795e-02f, 6.36060536e-02f, -3.97043079e-02f,
  2.12375727e-02f, -1.02472845e-02f, -2.87047923e-02f, -2.07616808e-03f, -4.18862961e-02f, 9.99516547e-02f, 6.88251331e-02f, -3.86431441e-03f, -7.05570565e-05f, 1.90496054e-02f,
  -6.51882365e-02f, -1.60599560e-01f, 5.66577911e-02f, 3.25800292e-02f, -5.38488142e-02f, -8.54904279e-02f, 3.26704197e-02f, -5.50394058e-02f, -5.05904742e-02f, 1.63914785e-02f,
  5.36631756e-02f, -6.97710179e-03f, -6.35472313e-02f, 1.57944520e-03f, 3.66411358e-02f, 1.19377114e-02f, 3.81850451e-02f, 4.50752862e-02f, 6.69627190e-02f, 8.77816975e-03f,
  3.08121964e-02f, -6.01740964e-02f, -1.40507212e-02f, -3.07898354e-02f, -4.98107597e-02f, -1.47545873e-03f, -1.30216464e-01f, 7.58610247e-03f, -3.59475501e-02f, 4.17917781e-02f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  3.94752443e-01f, -3.87286544e-01f, -4.23532188e-01f, 2.33228467e-02f, 2.40808398e-01f, 2.18694612e-01f, -2.18126312e-01f, 1.04319125e-01f, -3.32366265e-02f, -6.79819137e-02f,
  1.38377547e-01f, -2.24407300e-01f, -3.92065674e-01f, 1.80528864e-01f, 2.15119854e-01f, -3.60428900e-01f, 3.55055004e-01f, -7.47840926e-02f, -6.53543323e-02f, -6.63107857e-02f,
  7.39785731e-02f, 5.17682254e-01f, -1.46683201e-01f, 3.60108823e-01f, 2.84011990e-01f, -5.42744920e-02f, 1.21093884e-01f, -2.73439258e-01f, 3.25525612e-01f, 1.21310510e-01f,
  1.10470645e-01f, -2.95766965e-02f, 4.71640117e-02f, 1.31997922e-02f, -6.47630319e-02f, -1.00486923e-03f, -6.14554919e-02f, 6.75861984e-02f, 3.28178518e-03f, -1.45718098e-01f,
  -1.60794184e-02f, 1.20073579e-01f, 9.30497199e-02f, -3.51181291e-02f, 1.16652079e-01f, 5.91532923e-02f, -2.18939688e-02f, -3.93322483e-02f, -1.23103753e-01f, -1.28366724e-01f,
  -1.85428396e-01f, -3.55628617e-02f, 5.26240654e-02f, -6.84555024e-02f, -1.40406983e-02f, -2.25717463e-02f, -5.68669662e-02f, -1.22776829e-01f, -2.92971954e-02f, 5.33447675e-02f,
  2.61801016e-02f, -1.90322530e-02f, 3.73699889e-02f, -2.76800077e-02f, 8.37023742e-03f, 8.40090290e-02f, 1.14563726e-01f, -1.10204471e-02f, -6.45287707e-02f, -7.30718225e-02f,
  -7.69900605e-02f, 2.45700851e-02f, -2.02627592e-02f, 8.40962082e-02f, 4.26995531e-02f, -6.93911090e-02f, -3.55021767e-02f, 5.45249470e-02f, -7.74415359e-02f, -2.17628255e-02f,
  1.88630249e-03f, 9.16735455e-02f, -1.17865957e-01f, -4.44988161e-02f, -3.19905765e-02f, -7.26433238e-03f, 9.14812535e-02f, 8.63777287e-03f, -2.43702512e-02f, 4.88662347e-03f,
  -4.76495773e-02f, -3.43560502e-02f, -1.42464742e-01f, -5.93840107e-02f, -6.73109666e-02f, 1.00197017e-01f, -5.47548681e-02f, 1.00189053e-01f, -6.54792339e-02f, 6.90546781e-02f,
  5.52590005e-02f, -9.22891051e-02f, 6.44947737e-02f, 7.99249485e-02f, -1.65874120e-02f, -3.35793346e-02f, 2.59759780e-02f, -5.45628369e-02f, 9.41637382e-02f, 2.87997238e-02f,
  1.80520099e-02f, 3.73322098e-03f, -1.77361704e-02f, -1.30830817e-02f, 2.33882982e-02f, -1.20289102e-01f, 2.39075571e-02f, -7.64409378e-02f, -1.76648032e-02f, -5.91736101e-02f,
  1.16155051e-01f, -2.81689048e-01f, -2.08768114e-01f, -1.64332032e-01f, -1.85039252e-01f, -2.48040184e-01f, -2.00919375e-01f, -3.78916204e-01f, -6.17848448e-02f, -2.08166942e-01f,
  -2.23480970e-01f, 1.87526420e-01f, 1.44060925e-01f, -2.89253831e-01f, 4.53335166e-01f, 3.24778944e-01f, -3.27245831e-01f, 3.79988812e-02f, 5.80120012e-02f, -2.59907246e-01f,
  1.35318134e-02f, -2.11514622e-01f, 7.04754815e-02f, -3.79929453e-01f, -2.88236648e-01f, -1.51408002e-01f, 1.04587115e-01f, -1.94240808e-01f, -2.78988600e-01f, -1.10058514e-02f,
  -8.40779096e-02f, 2.99727228e-02f, -2.56580207e-02f, -2.74611078e-02f, -4.75277118e-02f, 2.25915201e-02f, 7.28246421e-02f, 4.53052074e-02f, 2.79836785e-02f, -1.24955498e-01f,
  6.08078055e-02f, 4.78329789e-03f, 9.45245568e-03f, 3.03421505e-02f, -7.18935430e-02f, -8.56364667e-02f, -4.60833088e-02f, -4.31817956e-02f, -6.04602210e-02f, 8.82157683e-02f,
  5.80053357e-03f, 3.83936018e-02f, 1.06798232e-01f, 7.87529722e-02f, -3.87490280e-02f, -1.35655925e-01f, 1.18807830e-01f, 1.29625022e-01f, 6.05310732e-03f, 7.51845315e-02f,
  3.00403051e-02f, 1.05401933e-01f, -1.91874616e-02f, -8.29046443e-02f, -7.00724195e-04f, -1.43200522e-02f, -7.44106621e-02f, 2.06433870e-02f, 6.22249721e-03f, -2.65728459e-02f,
  -1.18250726e-02f, 1.78768057e-02f, -2.67620594e-03f, 6.67864755e-02f, -8.13710615e-02f, 5.61532266e-02f, 8.80416110e-02f, 2.35178024e-02f, -2.26403456e-02f, 1.73613392e-02f,
  5.93885034e-02f, 9.12461430e-02f, 1.91333750e-03f, 8.69243070e-02f, -5.57983182e-02f, 5.19778542e-02f, -4.27933671e-02f, -4.00748812e-02f, 3.93046439e-02f, 5.73722683e-02f,
  -1.05934314e-01f, -5.08761704e-02f, -1.19826548e-01f, -2.42008884e-02f, 5.41008525e-02f, 3.78367752e-02f, -6.59419075e-02f, -9.06549394e-02f, -9.71721113e-02f, -7.47613907e-02f,
  -7.98032805e-02f, 7.84749389e-02f, 5.68421669e-02f, -2.14035474e-02f, 2.99663935e-02f, -1.41607583e-01f, -5.43365106e-02f, -1.39902178e-02f, 1.92784872e-02f, -7.58384466e-02f,
  -4.12537381e-02f, 7.66413435e-02f, 1.16623454e-01f, 1.02321329e-02f, 5.38775511e-03f, -2.81516630e-02f, 3.81671563e-02f, 5.10318018e-02f, -3.66149321e-02f, 2.46986095e-02f,
  2.49671295e-01f, 3.22075665e-01f, 2.19975293e-01f, 4.97795910e-01f, -1.26143843e-01f, -3.43328446e-01f, -1.75589785e-01f, 1.59048736e-01f, 1.07467705e-02f, -1.30013406e-01f,
  -4.64541055e-02f, 2.84934580e-01f, -2.57966310e-01f, 2.37308398e-01f, 8.55106339e-02f, -2.40367651e-01f, 1.27597362e-01f, 6.78834915e-02f, 2.19223592e-02f, 2.11107254e-01f,
  7.97162727e-02f, 4.67707999e-02f, 3.16231638e-01f, 5.17449714e-02f, 9.74024087e-02f, 3.33308160e-01f, 7.80591816e-02f, -5.63150533e-02f, 3.25658053e-01f, -3.97179797e-02f,
  -8.03544447e-02f, 5.98554537e-02f, 1.28484815e-01f, -5.20333536e-02f, -4.69700992e-02f, -6.12739585e-02f, -1.16102070e-01f, -8.70871097e-02f, -1.69105688e-03f, -7.75796687e-03f,
  -3.30183096e-02f, 7.15651587e-02f, 3.68813500e-02f, 7.01451972e-02f, 9.76456553e-02f, 9.81265903e-02f, -2.53355242e-02f, 2.31565684e-02f, 7.75832832e-02f, 4.29974869e-02f,
  2.48528138e-01f, -2.40128711e-02f, -5.44215702e-02f, -4.95793112e-02f, 1.42090157e-01f, 1.47752902e-02f, -1.51944458e-02f, 1.12037115e-01f, 8.82163495e-02f, 1.14386559e-01f,
  -4.07697968e-02f, -3.43407802e-02f, -9.17705521e-03f, 8.21983218e-02f, 3.79255377e-02f, -3.75364050e-02f, -6.85256496e-02f, -2.71168910e-02f, -8.65232348e-02f, 1.07120043e-02f,
  4.25222144e-02f, 3.68774235e-02f, -6.19098656e-02f, -8.95788446e-02f, -8.20007268e-03f, 1.16553269e-01f, -2.38093492e-02f, -7.81902596e-02f, 3.57785337e-02f, 1.01271808e-01f,
  -6.67118281e-02f, -8.69685784e-02f, 3.09673958e-02f, -3.82626080e-03f, 2.40585450e-02f, -1.25258997e-01f, -3.14646144e-03f, -4.42513376e-02f, 1.95848979e-02f, -3.71853784e-02f,
  -9.97646153e-02f, 1.67681947e-01f, -9.03430656e-02f, 1.80219288e-03f, -1.36188373e-01f, -2.02221200e-02f, 1.39455674e-02f, 6.57939762e-02f, 3.79817709e-02f, -6.79316670e-02f,
  -3.43359113e-02f, -1.02034770e-01f, -1.75592422e-01f, -5.20809777e-02f, -1.29284589e-02f, -1.12614119e-02f, 6.40108883e-02f, -3.95023171e-03f, 1.53876439e-01f, 1.28778562e-01f,
  8.24088827e-02f, -1.40493661e-01f, 3.76131162e-02f, 8.92477110e-02f, 8.96259993e-02f, -1.89426392e-02f, 3.56069840e-02f, 9.08417106e-02f, 6.87560290e-02f, -9.44909826e-03f,
  -2.55639493e-01f, 4.73108619e-01f, -2.25725919e-01f, 5.63935712e-02f, 6.77940398e-02f, 4.38212663e-01f, 4.06815022e-01f, 5.00639305e-02f, 1.00720935e-01f, 3.68402123e-01f,
  2.31519088e-01f, 1.22995719e-01f, 8.12920555e-02f, 1.77592754e-01f, 1.59937397e-01f, 3.21623720e-02f, 2.21110001e-01f, 2.16364950e-01f, -5.76870926e-02f, 1.10841960e-01f,
  -1.08149260e-01f, 2.64527053e-01f, -2.03292504e-01f, -5.29474020e-02f, -5.65776369e-03f, -2.55596191e-01f, -9.46667567e-02f, -1.94491863e-01f, 1.57286882e-01f, 1.76732197e-01f,
  -3.35750617e-02f, 4.33152802e-02f, -4.34301570e-02f, -1.63013995e-01f, -2.61956640e-02f, -8.73055160e-02f, -2.45725270e-02f, -1.90402137e-03f, -1.50336832e-01f, 5.45190014e-02f,
  -2.77850721e-02f, -1.48502700e-02f, -1.21383723e-02f, 1.84406564e-02f, 5.01651056e-02f, -1.04165822e-01f, -6.82760030e-02f, -1.62029453e-02f, -6.26605675e-02f, 5.58126764e-03f,
  8.23951885e-03f, 2.23143287e-02f, 4.01622802e-02f, -6.03732914e-02f, -8.98550451e-02f, -2.01202519e-02f, 9.65376012e-03f, -1.56639621e-03f, 1.41332105e-01f, 9.82135683e-02f,
  1.14687629e-01f, 5.07588834e-02f, -7.42028952e-02f, 2.26982776e-02f, -6.94806948e-02f, -1.06134228e-01f, -1.10650444e-02f, -4.79760999e-03f, -7.84291476e-02f, 4.04638425e-02f,
  6.21959791e-02f, -5.11960648e-02f, -1.24106361e-02f, 5.70088401e-02f, 1.04557529e-01f, 2.59007700e-02f, 3.31528634e-02f, 7.04838932e-02f, 2.61363909e-02f, 7.84638599e-02f,
  2.77492534e-02f, 4.19889204e-02f, 1.55489426e-02f, 5.65523095e-02f, -1.79430004e-02f, 1.87611487e-02f, 1.24463774e-02f, 6.96884608e-03f, -9.70046669e-02f, -4.45293486e-02f,
  3.33578467e-01f, 1.24999881e-01f, -1.00313447e-01f, 2.74578743e-02f, 1.09404866e-02f, 1.20664167e-03f, -4.45868354e-03f, 7.26810172e-02f, 8.51835459e-02f, 2.08757352e-02f,
  3.56379189e-02f, -3.30899656e-02f, 3.65081988e-02f, -7.85938057e-04f, 6.39510155e-02f, 1.52084589e-01f, -1.74179263e-02f, -4.54036780e-02f, 1.06350034e-01f, 5.20472750e-02f,
  4.80603166e-02f, 5.52728400e-02f, -1.41978404e-02f, 3.87925245e-02f, -4.03636768e-02f, 2.99549866e-02f, -3.66682634e-02f, -7.80712366e-02f, 1.50312921e-02f, 8.09737667e-02f,
  1.45310676e-02f, 7.64359459e-02f, -9.27674249e-02f, 1.44937143e-01f, -1.32120520e-01f, -1.36328578e-01f, -3.46916467e-02f, 1.29540622e-01f, -3.52131188e-01f, 2.19324067e-01f,
  1.89232305e-01f, -1.32258922e-01f, 1.94573626e-01f, 2.71149963e-01f, -1.85007423e-01f, 1.09666072e-01f, 5.15899733e-02f, 2.24868152e-02f, -3.20248157e-02f, 2.38487244e-01f,
  3.66730578e-02f, 2.30797797e-01f, 9.58283767e-02f, 1.31728858e-01f, 2.62101572e-02f, 1.97085708e-01f, 8.56362805e-02f, 6.59607127e-02f, 1.55104622e-01f, -4.66210134e-02f,
  8.73136744e-02f, 2.26200774e-01f, -9.87046957e-03f, -1.11253887e-01f, 3.27896550e-02f, 1.46523178e-01f, 3.08211916e-03f, -4.96968664e-02f, -4.12020646e-02f, -1.47151109e-02f,
  -7.95395747e-02f, -9.06713530e-02f, -2.84611657e-02f, -1.50172174e-01f, -8.58563855e-02f, -8.16137493e-02f, -6.91692829e-02f, -1.38254166e-01f, 3.91171686e-02f, 1.11513880e-04f,
  -7.50242621e-02f, -3.10521829e-03f, -4.40192856e-02f, -3.40945199e-02f, -1.11733347e-01f, -2.91182268e-02f, -3.69523466e-03f, 4.10822220e-02f, -5.82272932e-02f, -3.20830531e-02f,
  -1.29374396e-02f, 1.46548059e-02f, 1.27109811e-01f, -2.71095913e-02f, 9.20146480e-02f, 1.17954731e-01f, 5.94281070e-02f, 1.28792465e-01f, -1.34858206e-01f, 1.31779373e-01f,
  7.67781306e-03f, 6.13616481e-02f, 7.80486166e-02f, -1.74342692e-02f, 3.19098718e-02f, -1.88245773e-02f, 2.71269097e-03f, 5.32549396e-02f, -9.81349945e-02f, -2.10662116e-03f,
  7.45438486e-02f, 1.03855943e-02f, 5.07507622e-02f, -5.50489947e-02f, 5.52942678e-02f, -3.63349207e-02f, 9.86638442e-02f, -4.53663655e-02f, -1.99185237e-02f, -5.03761433e-02f,
  1.24956869e-01f, 2.39175037e-01f, 2.60894652e-02f, -5.61652184e-02f, 5.17229773e-02f, 5.78788258e-02f, 1.67512393e-03f, -3.50360796e-02f, 2.34760493e-02f, 8.30886588e-02f,
  -2.21123304e-02f, -1.49915861e-02f, 3.03192530e-02f, -5.24746813e-02f, 6.99298689e-04f, 6.18500412e-02f, 2.05783233e-01f, 4.30522766e-03f, -2.13521235e-02f, 3.99640985e-02f,
  1.11875564e-01f, 6.98262872e-03f, -9.52027664e-02f, -3.56727764e-02f, 6.61474466e-02f, 3.17751896e-03f, -6.99264929e-02f, -9.57819596e-02f, 8.34616572e-02f, 1.83793274e-03f,
  1.21231116e-02f, -3.52091759e-01f, -6.56144843e-02f, -1.83670059e-01f, -1.15093268e-01f, -2.08738625e-01f, -2.02744037e-01f, -3.40517431e-01f, -2.13283569e-01f, -1.70997962e-01f,
  -1.43953860e-01f, 1.35975257e-01f, 1.99526772e-01f, -4.17104661e-01f, 3.35364580e-01f, 2.31895357e-01f, -3.91338468e-01f, -7.98719898e-02f, 3.59316394e-02f, -1.24249682e-01f,
  -1.99921671e-02f, -2.69890189e-01f, -7.54174264e-03f, -2.80698895e-01f, -2.50119060e-01f, -1.46511113e-02f, 1.13045692e-01f, 1.25711128e-01f, -3.29610616e-01f, 4.02321294e-02f,
  7.17009380e-02f, 1.91171512e-01f, 4.58082557e-02f, 1.10348597e-01f, -5.73039195e-03f, -2.91922931e-02f, -3.13373767e-02f, 1.29506305e-01f, 5.62718399e-02f, -2.33785175e-02f,
  7.21255466e-02f, 7.74350464e-02f, -6.48507401e-02f, 5.85811660e-02f, -2.61572897e-02f, -8.45961496e-02f, 5.73627241e-02f, -3.57457250e-02f, -5.82544245e-02f, -8.32020957e-03f,
  -2.84268558e-02f, -3.76162189e-03f, -1.22077696e-01f, -7.39909932e-02f, 3.45750675e-02f, -3.28322724e-02f, 4.13188301e-02f, 1.10448040e-01f, -6.11028671e-02f, -1.49165928e-01f,
  -5.56830168e-02f, -2.68579889e-02f, 1.24392167e-01f, -8.53297189e-02f, 3.21378671e-02f, -9.78489220e-02f, -5.19530736e-02f, 8.14738870e-02f, -1.22901928e-02f, 1.79993603e-02f,
  -5.68075106e-02f, 2.19182670e-03f, 6.86729327e-02f, -2.91313939e-02f, -1.31053501e-04f, 5.06131984e-02f, 5.06956726e-02f, -2.53250189e-02f, -1.03574298e-01f, -3.62895466e-02f,
  -4.81689125e-02f, -6.55462779e-03f, 2.13267300e-02f, 3.69031876e-02f, 7.14411587e-02f, 8.29138309e-02f, -7.89439306e-02f, -4.94150519e-02f, -1.11622065e-02f, 1.30847618e-01f,
  2.90289130e-02f, 4.46262546e-02f, 1.03387679e-03f, -2.65445560e-02f, 4.35017385e-02f, -4.83850613e-02f, 5.91749065e-02f, -9.65369195e-02f, 2.28416082e-02f, 3.52306552e-02f,
  -1.33484960e-01f, 8.22133273e-02f, 1.02609563e-04f, -1.54729029e-02f, -5.99950179e-02f, -7.91171417e-02f, 8.09613690e-02f, 6.08573593e-02f, -1.04576312e-01f, -1.16928183e-01f,
  -2.36736499e-02f, -3.27465497e-02f, 8.67641196e-02f, 6.19356968e-02f, -6.31387159e-02f, 3.82860787e-02f, -3.38162556e-02f, 6.17696717e-02f, 1.81942478e-01f, -1.21955043e-02f,
  1.00462697e-01f, -1.48895249e-01f, -1.35426775e-01f, 7.66448975e-02f, 1.43785998e-01f, -9.37777236e-02f, -2.42465436e-01f, 4.31816056e-02f, -3.14155698e-01f, 5.33783212e-02f,
  -3.38251255e-02f, -2.32825428e-01f, -2.89528221e-01f, -1.84927821e-01f, -1.18598200e-01f, -3.09720278e-01f, -8.83547366e-02f, -6.19383678e-02f, -9.30396467e-02f, 1.04714811e-01f,
  1.27275949e-02f, 1.16075285e-01f, -3.16329002e-02f, 3.72987062e-01f, 7.43531249e-03f, 2.76087880e-01f, 4.21226710e-01f, 1.44658849e-01f, 2.36343920e-01f, 9.65998843e-02f,
  -1.32422164e-01f, -1.38491809e-01f, 1.21182401e-03f, -5.11367358e-02f, 1.19919755e-01f, 1.96591705e-01f, 1.11814827e-01f, -6.33252668e-04f, -3.10701877e-03f, -7.37177804e-02f,
  -8.42413902e-02f, -5.87295857e-04f, -1.73335485e-02f, 2.03633588e-02f, 2.63822656e-02f, 3.46326120e-02f, -1.85334504e-01f, 5.11068441e-02f, -2.09382981e-01f, -9.72448960e-02f,
  -8.80663320e-02f, 8.47506803e-03f, 3.43422145e-02f, 2.94438303e-02f, -1.97294690e-02f, -3.38504440e-03f, 5.19837402e-02f, 1.39961764e-01f, 5.29783266e-03f, -9.17836875e-02f,
  -2.25722138e-02f, 1.23023361e-01f, 1.29458625e-04f, -1.11417443e-01f, 2.07626019e-02f, -3.52870338e-02f, -3.42199281e-02f, -4.60206717e-02f, -4.55726907e-02f, -2.94107869e-02f,
  -2.75822785e-02f, -4.52372245e-02f, -1.94773916e-02f, 3.17581818e-02f, 1.26542494e-01f, -8.83113369e-02f, 9.63752940e-02f, 4.68796538e-03f, 4.77280170e-02f, -6.47012964e-02f,
  -3.60415690e-02f, -4.15548049e-02f, 3.86243835e-02f, 1.70057267e-02f, -9.01145861e-02f, 8.14683328e-04f, 5.48614888e-03f, -9.22641754e-02f, -2.64760619e-03f, -6.43492443e-03f,
  2.18994152e-02f, 1.26670018e-01f, -2.21471023e-03f, 3.63587365e-02f, 1.78053584e-02f, 5.21947220e-02f, -3.16373743e-02f, 1.02788834e-02f, -2.50143744e-02f, -6.50409684e-02f,
  1.36828169e-01f, 5.96828051e-02f, 1.42758176e-01f, -7.14278296e-02f, -4.24823985e-02f, 3.64477336e-02f, 7.20280334e-02f, 2.03301739e-02f, 1.00534663e-01f, 3.26317623e-02f,
  3.00446134e-02f, -8.38295743e-03f, -1.16296913e-02f, 1.55801484e-02f, 9.10061970e-02f, 8.32435489e-02f, 1.41345590e-01f, 1.91969927e-02f, 3.74304578e-02f, 7.86047615e-03f,
  1.76391214e-01f, 8.34424198e-02f, 9.80918929e-02f, -3.90631296e-02f, -8.81716907e-02f, -2.43896350e-01f, -3.20925444e-01f, 5.00413217e-02f, -1.93880737e-01f, -2.46113278e-02f,
  -7.24761114e-02f, -1.33464551e-02f, 1.31444022e-01f, -2.17342526e-02f, -4.82692905e-02f, -5.75314276e-02f, 1.04167566e-01f, -1.08039454e-01f, -1.24611435e-02f, 2.36975461e-01f,
  7.07837865e-02f, 1.88583776e-01f, 9.30912495e-02f, 2.27027893e-01f, 1.33003101e-01f, 1.48560807e-01f, 2.27195382e-01f, 6.68371990e-02f, 1.20604388e-01f, -6.26023188e-02f,
  -8.47002491e-02f, 1.90763623e-01f, 1.58797815e-01f, 1.27335295e-01f, 7.97722116e-02f, 1.26461340e-02f, 4.31912318e-02f, -8.41741264e-02f, -2.96368059e-02f, 8.22826549e-02f,
  1.32743895e-01f, 5.53771146e-02f, 1.03618674e-01f, -2.29060054e-02f, 1.16375543e-01f, -2.52219737e-02f, -1.00296125e-01f, -1.77945346e-01f, -9.74561125e-02f, 1.12639062e-01f,
  -4.04646471e-02f, -1.11220665e-02f, 5.00065833e-02f, 7.39738718e-02f, 6.79326206e-02f, 1.41729400e-01f, -4.07533236e-02f, -4.38490473e-02f, -8.24370831e-02f, 6.21559843e-02f,
  1.92365184e-01f, -1.27286077e-01f, -1.23952515e-03f, -4.48663756e-02f, -1.46342600e-02f, 1.08325817e-01f, 9.03118402e-02f, 5.29866926e-02f, 1.21771008e-01f, -1.02405533e-01f,
  -1.51801318e-01f, -8.33574161e-02f, 2.02706307e-02f, 4.04623337e-04f, -6.12541735e-02f, 1.59323569e-02f, -1.02700882e-01f, 6.29073083e-02f, -1.21498182e-01f, -9.38397869e-02f,
  3.55295539e-02f, 2.58624787e-03f, 5.12550473e-02f, -4.22984436e-02f, -1.11239625e-03f, -9.03047547e-02f, 7.69645870e-02f, 6.54685199e-02f, -5.94123565e-02f, -1.05631478e-01f,
  4.96494882e-02f, 3.38658303e-01f, 5.28033003e-02f, 7.43354037e-02f, 9.79140252e-02f, 3.42689105e-03f, 6.14639521e-02f, 7.78437629e-02f, 1.45170376e-01f, 1.61068276e-01f,
  6.33976832e-02f, 2.31123362e-02f, -4.60368395e-02f, -4.30038869e-02f, -5.38002402e-02f, 1.01613589e-02f, -7.97324255e-02f, -1.24377042e-01f, 1.06304087e-01f, -1.34343058e-02f,
  7.38191679e-02f, -6.05505556e-02f, 7.10350946e-02f, 1.80231221e-02f, -3.37716937e-02f, 1.41667239e-02f, -7.67158121e-02f, 7.78930681e-03f, 4.19434085e-02f, 1.16466515e-01f,
  5.69923043e-01f, 3.08752418e-01f, 2.36534610e-01f, 4.56864148e-01f, -2.22291544e-01f, 1.43340871e-01f, 1.35495782e-01f, 9.91412438e-03f, 3.98894399e-01f, -3.09435669e-02f,
  -2.75215834e-01f, 3.60479623e-01f, -7.24762455e-02f, 1.35150328e-01f, -2.61056218e-02f, -1.21504329e-01f, 1.78442046e-01f, 8.14615637e-02f, 1.69060081e-02f, 2.48988196e-01f,
  5.65358177e-02f, -2.66859770e-01f, -2.63947725e-01f, -3.50777835e-01f, 1.75903295e-03f, 3.74471657e-02f, -3.74710351e-01f, -1.14102580e-01f, -1.62890434e-01f, -7.49047250e-02f,
  2.04908587e-02f, 6.34122966e-03f, 1.31759912e-01f, 1.42442927e-01f, 7.32440948e-02f, -2.09689736e-02f, -7.65103102e-02f, -1.24969006e-01f, -5.57087064e-02f, 2.91717984e-02f,
  1.10022970e-01f, -2.81073619e-02f, 9.12075415e-02f, -6.91051558e-02f, -4.29088734e-02f, -2.07767226e-02f, 8.31789449e-02f, 9.34813693e-02f, -4.91665378e-02f, 5.77091798e-02f,
  1.05484493e-01f, 3.33988271e-03f, 8.50654021e-02f, -7.28588477e-02f, 9.91106182e-02f, 9.66823995e-02f, 3.46850567e-02f, -2.79420000e-02f, 3.38235237e-02f, -1.66693460e-02f,
  -5.81379458e-02f, -2.87928879e-02f, -2.78389268e-02f, -5.62039539e-02f, 8.68980139e-02f, -9.46036726e-02f, 3.93728130e-02f, -9.87923741e-02f, 2.11401448e-01f, -4.57748920e-02f,
  6.80853799e-02f, 5.37553243e-02f, -1.93646327e-02f, 4.54140753e-02f, 6.78168982e-02f, -7.01130331e-02f, -3.15985121e-02f, -7.79436678e-02f, 1.12059936e-01f, 6.69630393e-02f,
  -9.58077312e-02f, 2.24827547e-02f, 9.16121341e-03f, -9.16200578e-02f, -2.64450423e-02f, 1.86267830e-02f, 6.14062184e-03f, 8.18754286e-02f, -1.15000941e-01f, -3.79337706e-02f,
  4.17356156e-02f, 1.41386271e-01f, 5.84117472e-02f, 6.40281127e-04f, 3.33815068e-02f, 4.53569293e-02f, 7.42016435e-02f, 3.65790464e-02f, 8.63928795e-02f, 8.61454010e-03f,
  -6.07944876e-02f, 7.53494352e-02f, 1.81317162e-02f, -4.39536497e-02f, 3.49011458e-02f, -1.30459871e-02f, 2.13687085e-02f, 4.79997247e-02f, 4.16976362e-02f, -3.40804122e-02f,
  3.57301394e-03f, 8.55070278e-02f, 4.41363193e-02f, -1.02373198e-01f, -7.09450394e-02f, -1.38822019e-01f, 3.31563279e-02f, 6.05623722e-02f, -9.71103925e-03f, 5.14205173e-03f,
  -3.62412333e-01f, 2.66009122e-01f, -2.84085393e-01f, 1.86606403e-02f, -5.46534732e-02f, 6.28799856e-01f, 4.30068582e-01f, 6.02230765e-02f, -1.06515810e-01f, 3.87672156e-01f,
  2.23625273e-01f, -7.22391307e-02f, 1.39364615e-01f, 4.68428850e-01f, 1.94385201e-01f, 3.17660391e-01f, 2.30217889e-01f, 2.26421997e-01f, -5.40943854e-02f, -3.31184976e-02f,
  -1.02540225e-01f, 2.51486808e-01f, 3.83272693e-02f, -9.71901882e-03f, 7.75628462e-02f, -3.08211476e-01f, -4.09151008e-03f, -1.00370623e-01f, 2.06493437e-01f, 1.49202466e-01f,
  4.04905975e-02f, -1.58643991e-01f, -1.32037446e-01f, -9.28282067e-02f, -3.94282639e-02f, -1.96480975e-02f, -8.41954723e-02f, 1.27508184e-02f, 1.11196395e-02f, -2.99912114e-02f,
  4.51395512e-02f, -2.79912837e-02f, -5.89309707e-02f, -1.75797790e-01f, -6.93541840e-02f, -2.15338194e-03f, -3.70554440e-03f, 8.21972340e-02f, 6.10959902e-02f, 1.74201224e-02f,
  6.89921086e-04f, 6.63855970e-02f, -1.59290582e-02f, 4.03302982e-02f, -5.84215708e-02f, 3.03876251e-02f, 1.30064208e-02f, -6.16511423e-03f, 1.21902463e-04f, -3.36228646e-02f,
  -2.21518781e-02f, -1.40297413e-01f, -5.29857576e-02f, 6.92509413e-02f, 2.28644684e-02f, -1.29088489e-02f, 1.05074130e-01f, -8.42063501e-02f, 7.42937550e-02f, 4.08671498e-02f,
  -2.72075031e-02f, -4.32153000e-03f, 3.31498422e-02f, 9.37398747e-02f, 2.73359418e-02f, 2.59028319e-02f, -3.99991572e-02f, -9.62902680e-02f, 3.93810645e-02f, 9.93224531e-02f,
  -2.70742876e-03f, -5.66115938e-02f, 1.23180421e-02f, 1.25423968e-02f, -2.47801784e-02f, 3.15968739e-03f, 2.47081183e-02f, -7.36283604e-03f, 2.49092784e-02f, 2.25355756e-02f,
  1.47827774e-01f, -1.92085609e-01f, -3.05892024e-02f, 3.53412367e-02f, -7.96318799e-02f, 2.86423776e-04f, -3.16834971e-02f, -3.31647210e-02f, -6.10527135e-02f, -5.75644784e-02f,
  6.35784268e-02f, -1.13179997e-01f, 1.19788478e-04f, -8.74066260e-03f, 8.16831924e-03f, 2.24265121e-02f, 7.19136074e-02f, 5.07972091e-02f, 8.14541057e-02f, 4.64210622e-02f,
  -9.78077576e-03f, 2.84648091e-02f, 1.84000097e-03f, -4.92292307e-02f, 7.31850863e-02f, 9.45440456e-02f, 8.54637194e-03f, -6.73862100e-02f, 7.26186261e-02f, 1.75277563e-03f,
  -1.00064404e-01f, -3.11856925e-01f, 5.65562844e-01f, -2.48028547e-01f, 3.06057066e-01f, 2.14891702e-01f, 2.63057590e-01f, 2.15087086e-01f, -3.33632044e-02f, -2.96999425e-01f,
  -1.66596502e-01f, -1.31653726e-01f, 9.86937359e-02f, -2.49363214e-01f, 4.42427248e-01f, 1.77640632e-01f, -1.05543569e-01f, -3.49479578e-02f, 1.54382095e-01f, 2.41792817e-02f,
  8.49052668e-02f, -2.51118213e-01f, 1.83735445e-01f, -1.50839493e-01f, -7.47151347e-03f, -1.20670438e-01f, -1.87323913e-01f, 1.73672080e-01f, -2.21687511e-01f, 1.44651189e-01f,
  -1.68550238e-01f, -2.12508559e-01f, -1.49837688e-01f, 3.17551009e-02f, 1.11720217e-02f, 3.40746157e-02f, -3.50705683e-02f, 4.06925790e-02f, -3.10539338e-03f, 2.87473816e-02f,
  -7.54726231e-02f, 6.60449415e-02f, -5.63460998e-02f, 5.52268699e-02f, 6.16405159e-02f, 4.18005474e-02f, 9.93539691e-02f, 9.25920457e-02f, -8.55302089e-04f, 1.45643279e-01f,
  1.80509731e-01f, -5.75417131e-02f, -2.41865944e-02f, -2.14515571e-02f, 6.73301369e-02f, -1.48060992e-01f, -4.63048220e-02f, 4.71329913e-02f, 1.41996797e-02f, -3.90831903e-02f,
  -6.03620410e-02f, -1.59412045e-02f, 2.95479177e-03f, -5.80101833e-02f, -8.08380023e-02f, -1.46227526e-02f, -4.62012179e-02f, 2.00446583e-02f, -4.03223000e-02f, 6.56238273e-02f,
  -3.91697176e-02f, -6.65892614e-03f, 2.50414088e-02f, 2.75498610e-02f, -1.00111984e-01f, -6.80420324e-02f, -7.22909346e-02f, -1.03397451e-01f, 2.15250924e-02f, -1.95525307e-02f,
  -1.12015329e-01f, 2.36492082e-02f, 9.06894356e-03f, -2.08227825e-03f, 1.02525670e-02f, 8.32695048e-03f, -1.25837192e-01f, -5.30958325e-02f, -9.92396846e-03f, 1.46206707e-01f,
  -3.72617513e-01f, -3.70930582e-01f, -9.77604911e-02f, -2.07719997e-01f, -7.55241439e-02f, -2.42732558e-02f, 7.33604282e-02f, -4.35836837e-02f, -1.82239208e-02f, 7.56883845e-02f,
  5.19044138e-02f, -1.32698119e-01f, -9.52075422e-03f, 4.88465792e-03f, -2.29792041e-03f, -4.23411885e-03f, -3.58675458e-02f, -1.38571769e-01f, -1.37152612e-01f, -5.03243506e-02f,
  -3.58991101e-02f, 1.80879701e-02f, 7.19658881e-02f, -6.99711591e-02f, -5.53003363e-02f, -2.91100051e-03f, -1.73743777e-02f, -8.82541239e-02f, 7.30732679e-02f, 5.55461347e-02f,
  3.22771102e-01f, -5.34844577e-01f, 2.61600852e-01f, 1.83335736e-01f, 2.56708592e-01f, 2.19502717e-01f, 4.20758367e-01f, 4.08491213e-03f, -7.21786991e-02f, -2.83993334e-01f,
  -7.16345683e-02f, -6.02784753e-02f, -1.83089271e-01f, 7.47026503e-02f, 5.13980389e-01f, -1.08549185e-01f, 1.35416970e-01f, 2.58394647e-02f, -4.30024378e-02f, -4.28157374e-02f,
  9.64071229e-03f, 1.70593962e-01f, 2.36639917e-01f, -2.80986339e-01f, 1.04121096e-03f, -9.24030095e-02f, -4.45486270e-02f, 8.41723233e-02f, 7.21244290e-02f, 3.21859390e-01f,
  -1.88251153e-01f, -1.88800111e-01f, -8.17715935e-03f, -7.38602504e-03f, -2.01939285e-01f, -1.01660386e-01f, 3.96844968e-02f, 2.04214483e-01f, 5.33950627e-02f, 1.09429555e-02f,
  -1.16000615e-01f, 6.16807379e-02f, 3.36697809e-02f, 1.06264286e-01f, -8.65782201e-02f, -5.27357571e-02f, -1.90502107e-02f, -6.41135499e-02f, 9.70477909e-02f, -5.80377243e-02f,
  -1.68021955e-02f, -1.07524619e-01f, -3.80415916e-02f, 1.83866136e-02f, -2.88046431e-02f, 1.31264716e-01f, 4.68250066e-02f, -3.52133554e-03f, -9.84755158e-02f, 9.99854207e-02f,
  4.49224152e-02f, -5.33712655e-02f, -1.29624292e-01f, 9.11731943e-02f, 6.52405545e-02f, 9.18404460e-02f, 8.11271369e-04f, 5.15449457e-02f, -2.71645803e-02f, -2.09300276e-02f,
  2.09395766e-05f, -4.38493714e-02f, -1.40577435e-01f, -8.67049545e-02f, 5.85015267e-02f, -1.85054578e-02f, -6.64559565e-03f, -2.33033057e-02f, -1.12155020e-01f, 1.64851323e-02f,
  6.04956374e-02f, 8.16592649e-02f, -9.47770663e-03f, 1.12007288e-02f, 3.54290530e-02f, 1.84322316e-02f, -5.65733276e-02f, -4.93569933e-02f, 2.32676119e-02f, -1.19623654e-02f,
  -4.30064350e-01f, -2.63703376e-01f, -4.42155227e-02f, -1.36569571e-02f, -2.76702251e-02f, -2.18478173e-01f, -4.85795289e-02f, 1.21603440e-03f, -9.62465852e-02f, -2.89471485e-02f,
  -1.26699671e-01f, 4.62063737e-02f, -9.87299383e-02f, 2.42926702e-02f, 3.10903955e-02f, -3.20866182e-02f, -4.48019654e-02f, -1.63865998e-01f, -7.43737957e-03f, -1.04928300e-01f,
  -2.76077650e-02f, -6.22325242e-02f, 1.18700936e-01f, -7.09360745e-03f, -5.31212874e-02f, 1.25529328e-02f, -5.88956475e-02f, 2.67990734e-02f, -1.04141738e-02f, 3.75988372e-02f,
  -4.36677724e-01f, 1.11955337e-01f, -4.45601381e-02f, -3.51899028e-01f, 1.07692979e-01f, -3.44212085e-01f, -1.90860227e-01f, 5.57393320e-02f, -1.08128516e-02f, -3.59097049e-02f,
  5.17274067e-02f, 6.22772835e-02f, 1.58259273e-01f, -1.61572695e-01f, -1.52104586e-01f, 5.80665134e-02f, -3.18100661e-01f, -2.57463932e-01f, 7.84475133e-02f, -1.86239839e-01f,
  -9.87899676e-02f, -4.81995679e-02f, -1.19027525e-01f, 1.51174486e-01f, -1.96669772e-01f, -7.18167573e-02f, 2.23560687e-02f, 1.39092475e-01f, -1.41240239e-01f, 1.54295102e-01f,
  -3.73655528e-01f, -1.86952099e-01f, -1.18699707e-01f, 1.82500742e-02f, -1.44438401e-01f, -4.94825952e-02f, -1.57177433e-01f, 8.97313133e-02f, -3.18099335e-02f, -3.32135223e-02f,
  -5.20817526e-02f, 2.44958140e-02f, -5.30269630e-02f, 8.82988349e-02f, 5.64394854e-02f, 4.93080318e-02f, 9.16776881e-02f, -7.47569129e-02f, -2.06790064e-02f, 1.24826282e-01f,
  4.46415413e-03f, 5.86048560e-03f, -1.43572047e-01f, -1.75675433e-02f, 5.67475297e-02f, 5.69034666e-02f, -9.98992026e-02f, -4.62841168e-02f, -2.00352296e-02f, -1.95938367e-02f,
  -3.94432060e-02f, -2.00064797e-02f, -9.86108854e-02f, 5.65188974e-02f, -1.32323820e-02f, -9.48121713e-04f, -3.80886234e-02f, 5.96253648e-02f, 9.37247500e-02f, -2.11360399e-02f,
  -2.22027916e-02f, -4.02208827e-02f, -1.15171364e-02f, -1.08634114e-01f, 5.36389239e-02f, -6.44664019e-02f, -7.99991861e-02f, -1.29716136e-02f, 8.97288672e-04f, -3.46858092e-02f,
  -3.45839746e-03f, 2.57501733e-02f, 7.59898722e-02f, -9.03841257e-02f, -3.91419120e-02f, 3.66721489e-02f, 2.12826300e-02f, 1.26230130e-02f, -7.94082880e-02f, -1.10809855e-01f,
  -4.40152377e-01f, -2.97921538e-01f, -7.81978816e-02f, 9.10784118e-03f, -2.08328646e-02f, -8.71104747e-02f, -1.32957116e-01f, 1.48117337e-02f, 9.86001827e-03f, -7.09647685e-02f,
  -9.50001329e-02f, 1.76682230e-02f, -1.34550944e-01f, -5.39169461e-02f, -6.06849603e-02f, -5.35434857e-02f, -6.18384592e-02f, -5.45578748e-02f, 4.67527751e-03f, 5.37941419e-02f,
  1.15631660e-02f, 8.58199224e-03f, 7.09993690e-02f, -2.97842212e-02f, -5.58976978e-02f, -2.29464509e-02f, -1.62658524e-02f, 2.20000483e-02f, -4.95357029e-02f, 3.60519439e-02f,
  -3.76545250e-01f, 2.29846016e-01f, -2.45754123e-02f, -1.50688902e-01f, 2.52025515e-01f, -1.99831024e-01f, -3.27512585e-02f, 6.67118654e-02f, -2.62375236e-01f, 3.05866122e-01f,
  -2.66611800e-02f, -3.63441207e-03f, -2.42457483e-02f, -2.48088956e-01f, -7.13675618e-01f, -3.82987291e-01f, -2.94461191e-01f, -1.23012383e-02f, -1.66953906e-01f, 1.48498163e-01f,
  -1.92132652e-01f, -1.05642743e-01f, -2.12874830e-01f, 1.15318768e-01f, 1.81064934e-01f, 1.15041278e-01f, 7.18299970e-02f, 2.20972195e-01f, 1.22466274e-01f, 7.20365122e-02f,
  -7.29513615e-02f, -1.21487081e-01f, 1.35629490e-01f, 8.97340998e-02f, -7.59135559e-02f, 1.28020376e-01f, 2.43441407e-02f, 3.94487462e-04f, -5.16195819e-02f, -4.86296304e-02f,
  -3.35196685e-03f, -1.07494637e-01f, -2.54594646e-02f, 7.02793449e-02f, 4.01738025e-02f, 1.69416573e-02f, 2.25105416e-02f, 8.75946358e-02f, 1.03727147e-01f, -1.34763435e-01f,
  -5.79254609e-03f, -6.57765716e-02f, 1.53868333e-01f, 3.28119658e-02f, -1.11026065e-02f, -8.78914669e-02f, 3.37007158e-02f, 1.74119957e-02f, 8.89578741e-03f, 1.43687194e-02f,
  -6.05632402e-02f, 8.26775953e-02f, -4.85401116e-02f, 6.63018897e-02f, 1.58017371e-02f, 5.95082901e-02f, 3.97876427e-02f, 9.01972596e-03f, 9.14906561e-02f, -1.52332457e-02f,
  -5.45450933e-02f, 9.37680081e-02f, 9.82947871e-02f, 1.15719683e-01f, -3.72894146e-02f, -1.51170779e-03f, 1.14483707e-01f, -5.64607652e-03f, -7.95555189e-02f, 1.71748977e-02f,
  -6.92481222e-03f, 5.10630719e-02f, -8.79942346e-03f, 7.74372965e-02f, -1.45354971e-01f, 7.52437413e-02f, -6.84965849e-02f, 9.72864330e-02f, 1.39826525e-03f, -2.60855891e-02f,
  -9.67435017e-02f, -6.45121112e-02f, 2.82955933e-02f, -4.31358349e-03f, 4.53988537e-02f, 5.14054187e-02f, -9.10819024e-02f, 3.17620747e-02f, -1.54147014e-01f, -3.30352411e-02f,
  1.44707426e-01f, 5.86292818e-02f, 8.12845230e-02f, 6.16492517e-02f, -3.92761603e-02f, -1.12387411e-01f, 3.53283882e-02f, -5.45833893e-02f, 2.73682759e-03f, -3.91452387e-02f,
  3.80606875e-02f, -1.12618080e-04f, -2.64767520e-02f, 5.69390580e-02f, -7.09938491e-03f, -1.66175757e-02f, -2.19496526e-02f, 2.86309756e-02f, 1.11248322e-01f, -5.00257500e-02f,
  -2.72682458e-01f, 1.84390157e-01f, 1.90160692e-01f, 3.09581250e-01f, 1.96663171e-01f, 5.81944644e-01f, 3.95562738e-01f, 3.69614750e-01f, 6.32921636e-01f, 7.56334364e-02f,
  -1.77969843e-01f, -1.68654636e-01f, -7.59834573e-02f, -4.92365193e-03f, 7.45125785e-02f, 2.55135953e-01f, 2.91206658e-01f, 1.05653882e-01f, 3.08714509e-01f, -1.37467068e-02f,
  1.06060550e-01f, -1.69533610e-01f, -2.12684125e-01f, -2.85985589e-01f, -2.85772234e-01f, -9.07270685e-02f, -3.58017355e-01f, -1.17984511e-01f, -2.74226904e-01f, -5.57069890e-02f,
  3.48216891e-02f, 2.90584862e-02f, -3.24495792e-01f, 3.95934321e-02f, -6.29210696e-02f, 8.44098702e-02f, -4.23301458e-02f, -6.01115376e-02f, 6.75849468e-02f, 7.14177117e-02f,
  -9.18848440e-02f, 8.93965140e-02f, 2.47390792e-02f, 1.76439807e-02f, 1.40405595e-01f, 2.46035289e-02f, 4.43822928e-02f, -8.07046611e-03f, 2.44631488e-02f, -2.00371277e-02f,
  -1.46145433e-01f, 4.32161912e-02f, -7.34479353e-02f, 1.24985659e-02f, -5.36605269e-02f, 9.33492631e-02f, 6.70848787e-02f, -2.05831490e-02f, 1.79695338e-02f, 9.94126871e-02f,
  1.86598971e-02f, 1.61256969e-01f, -8.93993974e-02f, -2.98581738e-02f, -1.38261050e-01f, -9.49634165e-02f, -8.94629285e-02f, -6.88160136e-02f, 1.83200855e-02f, -8.95963833e-02f,
  5.10384478e-02f, -4.24736366e-02f, 1.15373001e-01f, 7.26949945e-02f, 3.06106713e-02f, 5.79902977e-02f, -4.53057885e-02f, 5.06835543e-02f, 5.90457814e-04f, -1.29542112e-01f,
  2.90293749e-02f, 7.73942769e-02f, -1.04853414e-01f, -5.92796318e-02f, -6.50356561e-02f, -1.76298171e-02f, 1.08092343e-02f, 5.68697043e-02f, 1.92870852e-02f, -4.36846055e-02f,
  1.21200614e-01f, 2.38332391e-01f, -6.06612042e-02f, -8.00469294e-02f, -1.06400341e-01f, -1.02090374e-01f, 4.68710288e-02f, 1.89052825e-03f, 7.88709298e-02f, -4.02878337e-02f,
  -4.48541343e-02f, 3.22802551e-02f, -4.48125452e-02f, -4.43921052e-02f, 3.71649228e-02f, 1.87224224e-02f, 5.61745763e-02f, 9.34873000e-02f, -1.45053733e-02f, -2.65477709e-02f,
  -1.72579169e-01f, 5.95600903e-02f, 1.79703697e-03f, 4.61446261e-03f, -1.24862371e-03f, -7.14269504e-02f, 1.13065042e-01f, 4.63873111e-02f, -1.17737092e-02f, 9.18624997e-02f,
  -1.99303880e-01f, -2.20597461e-01f, -2.51785904e-01f, -2.14975357e-01f, 2.54951626e-01f, -9.99207124e-02f, -5.44709302e-02f, -3.34845260e-02f, -1.01738885e-01f, 1.60666198e-01f,
  6.96167275e-02f, -3.66161406e-01f, -3.88453789e-02f, -4.63088781e-01f, -4.47109848e-01f, -3.14097404e-01f, -2.54858643e-01f, -2.12363303e-01f, -2.46928155e-01f, -4.76374337e-03f,
  -7.19537809e-02f, -1.41500741e-01f, -2.52472997e-01f, 1.10810578e-01f, -1.54839363e-03f, 7.27235526e-02f, 2.88664937e-01f, 1.80223748e-01f, -4.40334976e-02f, -8.72202888e-02f,
  2.72733457e-02f, -1.35297894e-01f, -4.42537069e-02f, -1.69328853e-01f, 1.46590201e-02f, 7.37513080e-02f, 3.43111120e-02f, -4.57681417e-02f, 3.81330401e-02f, -3.27713974e-03f,
  8.36934894e-02f, 2.59864759e-02f, -1.23339392e-01f, -2.15056334e-02f, 3.04566063e-02f, -2.48929244e-02f, 5.51845804e-02f, 2.86490265e-02f, -5.71557740e-03f, -1.09495394e-01f,
  -7.91373625e-02f, -1.50834685e-02f, 8.29552417e-04f, -4.24658731e-02f, 1.55372219e-03f, 2.55612954e-02f, -4.73032445e-02f, 1.70127070e-03f, 7.06948712e-02f, -3.89970019e-02f,
  4.54152152e-02f, 5.50750233e-02f, -4.08632755e-02f, -4.09319662e-02f, -3.64391804e-02f, 3.77290510e-03f, -2.07122019e-03f, 1.70183536e-02f, -2.63678879e-02f, 7.86181837e-02f,
  6.89878836e-02f, -6.71012104e-02f, 1.92108583e-02f, 5.53658195e-02f, -2.23028567e-02f, -3.22460607e-02f, 4.71106842e-02f, -5.42936437e-02f, 5.20156994e-02f, -4.34433669e-02f,
  9.56263691e-02f, 7.86207523e-03f, 6.78345514e-03f, 1.10538840e-01f, -2.71935463e-02f, 7.35778362e-02f, 1.01570502e-01f, -4.44337241e-02f, 9.98614430e-02f, 9.39075574e-02f,
  4.22200747e-02f, 2.05744460e-01f, -6.75010234e-02f, -4.26384807e-02f, -7.70847825e-03f, 9.03114304e-03f, -1.41576296e-02f, -1.25323668e-01f, 3.30240354e-02f, -7.18096569e-02f,
  4.76867221e-02f, 1.07200049e-01f, 1.06138334e-01f, -2.65489407e-02f, 7.84943327e-02f, 4.37110886e-02f, 7.83889368e-02f, 1.44080997e-01f, 1.21318087e-01f, 9.98222381e-02f,
  1.40452892e-01f, 7.95314386e-02f, 2.91428417e-02f, 7.63712898e-02f, 2.04069987e-02f, 1.07626960e-01f, 1.89818889e-02f, -4.37077321e-03f, 8.02517682e-03f, 5.55182807e-02f,
  -1.27091289e-01f, 2.14509398e-01f, 1.54441074e-01f, -4.17306751e-01f, 6.03974722e-02f, -7.38261417e-02f, -1.40957296e-01f, 2.01920494e-01f, -8.38904753e-02f, 2.96579331e-01f,
  -7.53424242e-02f, 8.10010582e-02f, 1.91385567e-01f, -2.65365660e-01f, -5.69296837e-01f, -3.56311351e-01f, -5.46515942e-01f, -2.09971324e-01f, -1.30971491e-01f, -6.49989098e-02f,
  -2.58986592e-01f, -3.77330542e-01f, -1.88079327e-01f, -4.24964242e-02f, 5.57187945e-02f, 2.83902705e-01f, -2.17226550e-01f, 1.03110939e-01f, 4.10296358e-02f, 6.25185817e-02f,
  -2.62193456e-02f, 6.61312267e-02f, 1.60974562e-01f, 5.34996018e-02f, -5.08956686e-02f, 9.40481275e-02f, -3.73090617e-02f, 4.80718836e-02f, -8.34695622e-02f, 3.43331657e-02f,
  -2.02351529e-02f, -4.88721114e-03f, -6.55849352e-02f, -5.52257188e-02f, 1.73839584e-01f, 3.88066880e-02f, 6.48012618e-03f, 4.81949784e-02f, 5.64278252e-02f, -5.75825199e-02f,
  -8.83936882e-02f, 3.71452980e-02f, -3.01675741e-02f, -3.06529403e-02f, 7.30960350e-03f, 5.42376824e-02f, -2.36300174e-02f, 1.04690641e-01f, -1.32221123e-02f, -1.02618955e-01f,
  9.42271277e-02f, -8.62432271e-02f, -5.51003069e-02f, 7.57689103e-02f, 6.23424798e-02f, 1.12437364e-02f, 7.27351243e-03f, 5.62045584e-03f, -1.57389194e-02f, -3.81600447e-02f,
  4.63353880e-02f, 5.62311336e-02f, -1.04425270e-02f, -1.13420568e-01f, -1.30037308e-01f, -5.30922636e-02f, -5.10803349e-02f, -2.70030834e-03f, -3.73597853e-02f, -3.13865952e-02f,
  -7.92623535e-02f, 1.41415501e-03f, -4.11456916e-04f, -1.20267592e-01f, 5.09966165e-02f, -2.35110037e-02f, 2.45207492e-02f, 2.22525951e-02f, -6.00036681e-02f, -1.57747254e-01f,
  -2.85837357e-03f, 7.48226931e-03f, 1.18959300e-01f, 1.73950240e-01f, -5.00377044e-02f, -1.39691196e-02f, -8.21399018e-02f, 6.70915544e-02f, -1.08975656e-02f, -4.27388549e-02f,
  6.02026954e-02f, -5.43482006e-02f, -3.08401082e-02f, -8.33281353e-02f, 2.28021592e-02f, -6.90271109e-02f, -3.79353054e-02f, -1.58483628e-02f, -1.40520977e-02f, 9.75309908e-02f,
  1.50566921e-03f, 1.44708734e-02f, 5.55516444e-02f, 8.47624242e-03f, 9.79405921e-03f, 7.88981542e-02f, -2.20538545e-02f, 1.37210235e-01f, -7.59865344e-02f, -5.76167786e-03f,
  2.24472716e-01f, 1.76421583e-01f, 1.27231002e-01f, 1.41609222e-01f, -1.46365449e-01f, -2.36994877e-01f, -2.75886953e-01f, 1.93643555e-01f, -2.69065231e-01f, -2.32133567e-02f,
  6.31692484e-02f, 3.60259451e-02f, -1.58378199e-01f, 1.64946020e-01f, 8.07750523e-02f, -1.98547974e-01f, 9.53357145e-02f, -6.28229752e-02f, -9.65045467e-02f, 2.24161178e-01f,
  1.93247035e-01f, 1.93300933e-01f, 1.45796165e-01f, 1.63094431e-01f, 1.42595887e-01f, 2.21944645e-01f, 2.51667470e-01f, 1.41662182e-02f, 1.65602893e-01f, 4.62626293e-02f,
  -4.27383482e-02f, 7.55250975e-02f, -8.13949108e-02f, -1.04666926e-01f, -8.32959265e-02f, 4.63404926e-03f, -2.50231475e-02f, -1.43875694e-02f, -8.01882148e-02f, 3.00102122e-02f,
  1.02895014e-02f, -7.12615089e-04f, -3.96460742e-02f, -2.93956101e-02f, 8.32493156e-02f, -4.81727486e-03f, 2.84973569e-02f, -1.33782504e-02f, -3.89857814e-02f, 1.30309179e-01f,
  3.37968208e-02f, 5.84531985e-02f, -6.19756654e-02f, 6.09476082e-02f, 5.34385554e-02f, -3.37481848e-03f, 1.70151144e-02f, -2.00167708e-02f, -2.91554667e-02f, -4.50537838e-02f,
  2.76306495e-02f, -2.10227817e-02f, 6.95727393e-02f, -1.28379473e-02f, -2.32257862e-02f, -4.36868854e-02f, -1.07822865e-01f, 3.28062177e-02f, -4.31959853e-02f, 2.92008836e-03f,
  -9.41240415e-03f, 5.05862618e-03f, 3.13617215e-02f, 1.88594908e-02f, 1.50652647e-01f, 6.02813102e-02f, 1.18422769e-02f, -2.70823240e-02f, -7.87872002e-02f, -4.88400571e-02f,
  -8.55711773e-02f, 1.14722684e-01f, 4.86486964e-02f, -2.57502310e-02f, -5.20289205e-02f, 9.97259170e-02f, 4.46055830e-02f, 2.80858427e-02f, -1.41803369e-01f, 4.65489067e-02f,
  8.39262828e-02f, 2.38682196e-01f, -3.51993926e-02f, -8.06962792e-03f, -7.02226609e-02f, -8.06841850e-02f, -7.80419931e-02f, 5.49937971e-02f, -2.75543611e-02f, -7.20960498e-02f,
  3.61678526e-02f, -8.24302509e-02f, -3.52339633e-02f, 1.53204612e-02f, -1.77032854e-02f, 1.80819482e-02f, 1.41459569e-01f, 2.77336407e-02f, -3.07845324e-02f, 5.23452461e-02f,
  1.48494855e-01f, -1.21719781e-02f, 1.97205059e-02f, -1.41058832e-01f, 6.73933374e-03f, 4.66090180e-02f, 2.13264767e-02f, -9.18405652e-02f, 1.00911222e-01f, 1.59832668e-02f,
  1.74910903e-01f, -1.61597744e-01f, -6.39521182e-02f, 1.24467604e-01f, 7.42879137e-02f, -1.19528495e-01f, -8.75303671e-02f, -2.91669052e-02f, -3.15507293e-01f, -6.91514164e-02f,
  1.76666647e-01f, 1.26165718e-01f, 8.26810002e-02f, 1.42033204e-01f, 3.60963643e-01f, -2.49327108e-01f, 1.13791622e-01f, 7.90252537e-02f, -6.47793636e-02f, 3.14062029e-01f,
  1.11976370e-01f, 1.64713264e-01f, 4.55970317e-03f, 8.34892094e-02f, 1.88843250e-01f, -2.75779516e-02f, 2.70232439e-01f, 2.44644478e-01f, 1.83023781e-01f, 8.56875554e-02f,
  -3.94227244e-02f, 6.61442503e-02f, -2.51735561e-02f, 8.91407859e-03f, -1.80308279e-02f, 3.60905356e-03f, 2.30927523e-02f, 9.67927556e-03f, 6.84168190e-02f, -1.05979212e-01f,
  -1.71266347e-02f, 9.07333568e-02f, -1.07791185e-01f, -1.22356098e-02f, 1.00806952e-02f, -2.26834882e-02f, -3.92974243e-02f, -3.35890576e-02f, -4.80991825e-02f, 3.37772183e-02f,
  -1.05631545e-01f, -7.69354329e-02f, -9.63380933e-03f, -4.66354229e-02f, -6.92720860e-02f, -4.23979722e-02f, -1.09600879e-01f, 5.43403625e-02f, -5.82170449e-02f, -1.15840184e-02f,
  1.09195478e-01f, 2.01599170e-02f, -2.77874935e-02f, 3.66833024e-02f, 3.62834260e-02f, 2.55527049e-02f, -6.13353364e-02f, -5.86455315e-02f, 8.49963054e-02f, 8.47390369e-02f,
  2.31172889e-02f, 4.27742675e-02f, 1.01094328e-01f, 4.77414988e-02f, -2.19564624e-02f, -1.75336257e-01f, -8.89025033e-02f, -9.03698243e-03f, 1.04411557e-01f, -1.16898231e-01f,
  5.79739772e-02f, 9.54049528e-02f, 9.45871323e-02f, -1.03952721e-01f, -3.84125859e-02f, 1.07459947e-01f, 2.77559794e-02f, 8.14806223e-02f, -1.20974317e-01f, -1.58672854e-02f,
  6.38519530e-04f, 1.31181255e-01f, 1.55516388e-02f, -1.20916575e-01f, -1.36114098e-02f, 3.22498716e-02f, 3.74450572e-02f, -1.39032513e-01f, 1.46932080e-01f, 9.21180472e-03f,
  1.28507793e-01f, 6.44207969e-02f, -8.47139880e-02f, 8.46615881e-02f, -4.36297655e-02f, 1.14322521e-01f, -2.60190456e-03f, 6.61117956e-03f, 2.01526489e-02f, 1.11237600e-01f,
  -2.66633611e-02f, -5.79187945e-02f, 4.62883487e-02f, -9.70991701e-02f, -6.46609962e-02f, -1.36416689e-01f, 4.11279947e-02f, 5.40401265e-02f, 1.23589814e-01f, 5.81331812e-02f,
  -7.52436280e-01f, 2.17402264e-01f, -6.40660003e-02f, -3.01046938e-01f, -3.57587725e-01f, -1.20280012e-01f, 3.05708777e-02f, -1.61886215e-01f, -7.55019262e-02f, 1.48658931e-01f,
  1.02813579e-01f, -1.79088995e-01f, 1.77083030e-01f, 1.50965780e-01f, -3.17318201e-01f, 2.76224375e-01f, -2.07285285e-02f, 1.05441168e-01f, 9.52431485e-02f, -1.92786977e-01f,
  -1.05187282e-01f, 1.56386033e-01f, 1.12565830e-01f, 1.83037579e-01f, -2.82988518e-01f, -1.62307099e-01f, -4.19948995e-02f, 9.37730744e-02f, -1.49561316e-01f, -1.41384944e-01f,
  -5.35809457e-01f, -3.67884487e-01f, -2.34761760e-01f, -1.07822329e-01f, -2.09509134e-01f, -1.18549369e-01f, -6.59705997e-02f, -7.87900314e-02f, -6.03114925e-02f, -2.69208662e-02f,
  -3.70161161e-02f, 1.60175543e-02f, 4.86788154e-03f, 3.30974683e-02f, -4.86775823e-02f, -7.27797449e-02f, 4.66474704e-02f, -2.88860630e-02f, -2.17952542e-02f, -6.06849119e-02f,
  5.46214618e-02f, -6.62919581e-02f, -4.82884198e-02f, 1.18322991e-01f, -8.46054628e-02f, -2.54251678e-02f, 8.53347108e-02f, 2.68325377e-02f, -8.14479366e-02f, -1.61986500e-01f,
  1.23970874e-01f, 5.40378578e-02f, 3.91067006e-02f, -2.47912877e-03f, 2.33010040e-03f, 8.13417733e-02f, -4.62768339e-02f, -9.63055342e-03f, 5.58486059e-02f, -7.20979413e-03f,
  -2.98130494e-02f, -2.16149855e-02f, -1.37596086e-01f, 6.44195378e-02f, -2.36687493e-02f, -7.42791127e-03f, 5.46407588e-02f, -3.65959592e-02f, 1.07496023e-01f, -1.68787371e-02f,
  1.06467819e-03f, 2.17131618e-02f, -5.32844011e-03f, 4.34857905e-02f, -1.04068309e-01f, 6.97705671e-02f, 9.67441965e-03f, 2.86504012e-02f, -4.71197022e-03f, -1.09423868e-01f,
  -6.07554138e-01f, -5.13169765e-01f, -2.86899563e-02f, -1.66868836e-01f, 1.61160808e-02f, -7.68357441e-02f, 6.21200800e-02f, -9.77528617e-02f, -1.22801542e-01f, -6.25247657e-02f,
  -9.05183516e-03f, -4.18836884e-02f, -1.66915029e-01f, 5.69406971e-02f, -1.03943879e-02f, 6.08980246e-02f, 1.13612169e-03f, -4.73707303e-04f, -1.65150076e-01f, -9.44386609e-03f,
  -1.34407496e-02f, 9.23136773e-04f, 1.40201852e-01f, 2.16179830e-03f, 1.63397484e-03f, -9.09249932e-02f, -1.36552081e-01f, 3.12939696e-02f, -1.31798521e-01f, 4.83022071e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  2.74866700e-01f, -3.27362195e-02f, 2.78533727e-01f, 2.28859216e-01f, 1.14757597e-01f, 2.13556856e-01f, 2.19808400e-01f, 3.31589490e-01f, 4.48247880e-01f, 2.67109632e-01f,
  2.60213494e-01f, 3.89096856e-01f, 1.54739812e-01f, 3.75991166e-01f, 2.98486024e-01f, 1.68836504e-01f, 3.28324199e-01f, 1.22431681e-01f, 1.79252222e-01f, 3.38862240e-01f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  -1.78675041e-01f, -1.78328216e-01f, 2.49117631e-02f, -2.19797522e-01f, 1.04202271e-01f, 9.97386053e-02f, 1.54390419e-02f, -2.47818202e-01f, 1.07680246e-01f, 1.88922957e-01f,
  2.59215742e-01f, -1.26351207e-01f, -2.08432510e-01f, -2.38841604e-02f, 2.58007608e-02f, 3.54350299e-01f, 1.01686835e-01f, -1.00487329e-01f, 6.36190325e-02f, 6.20103767e-03f,
  4.44873050e-02f, -9.03330520e-02f, -1.59793973e-01f, -3.51732969e-01f, -1.13137119e-01f, 2.73443103e-01f, 1.83341783e-02f, 1.59907490e-01f, 1.31515473e-01f, 2.70969629e-01f,
  8.37484077e-02f, -2.65262574e-01f, -9.51975882e-02f, 6.69430122e-02f, -1.16976142e-01f, 1.44155934e-01f, 9.45495069e-02f, -9.02341902e-02f, -9.63251665e-02f, 5.75890578e-02f,
  -2.62921583e-03f, 3.96303274e-02f, -4.37828541e-01f, 4.90678214e-02f, 2.01669037e-01f, 2.27642059e-01f, -1.09876111e-01f, -2.38464743e-01f, -3.10089082e-01f, 1.58601582e-01f,
  1.55490786e-01f, -2.18562931e-01f, -1.18725695e-01f, -1.04023129e-01f, 1.96219966e-01f, 1.97333366e-01f, 3.35905775e-02f, -1.04111865e-01f, -1.64778724e-01f, 1.97908938e-01f,
  -1.47637054e-01f, -2.48376846e-01f, 1.51364997e-01f, -2.46401951e-01f, -7.15620294e-02f, -2.11210027e-01f, 2.47215867e-01f, 8.85989964e-02f, -1.44362584e-01f, -3.05106908e-01f,
  -4.45229113e-02f, 2.63794780e-01f, -1.60227418e-02f, -1.67074516e-01f, -3.27012427e-02f, 1.17419533e-01f, -5.96141182e-02f, 2.66198516e-01f, -3.61059994e-01f, 8.01593997e-03f,
  4.47935686e-02f, 1.12270646e-01f, -1.09515667e-01f, 7.10574836e-02f, -2.66700149e-01f, 1.24700010e-01f, 2.21355721e-01f, -1.74896672e-01f, 2.67950118e-01f, 1.03329338e-01f,
  -3.07543755e-01f, 1.67652905e-01f, 1.90322295e-01f, -1.49577782e-01f, -6.41407222e-02f, 2.94144571e-01f, 2.17501163e-01f, -1.23082526e-01f, 2.10796326e-01f, -4.29763645e-02f,
  1.40643001e-01f, 4.30826485e-01f, -1.52894095e-01f, -1.11645740e-02f, -2.02325001e-01f, -3.13899606e-01f, 1.99807405e-01f, -1.36636406e-01f, 3.53578366e-02f, -2.38818124e-01f,
  8.85028467e-02f, -2.25811973e-01f, -2.28621081e-01f, -3.40808183e-01f, -2.28450552e-01f, -1.31837875e-01f, 2.37504870e-01f, -3.70352060e-01f, -1.66079309e-02f, -2.00784639e-01f,
  4.86674272e-02f, 8.66862163e-02f, 2.86164045e-01f, -2.37474024e-01f, -2.49341093e-02f, -3.48762810e-01f, -2.26630569e-01f, 1.51844501e-01f, -2.15498179e-01f, -9.63156372e-02f,
  -3.70236635e-01f, 9.40855872e-03f, -3.29505622e-01f, -4.48192388e-01f, 2.23311812e-01f, 3.11747074e-01f, 2.54595459e-01f, 3.72626573e-01f, -2.52199680e-01f, 7.43398769e-03f,
  -4.09889519e-02f, 1.70001134e-01f, 2.90660076e-02f, 1.60023391e-01f, 2.80284345e-01f, 4.02520597e-01f, 2.11268831e-02f, -1.54351711e-01f, 5.64740933e-02f, 2.48822004e-01f,
  -9.57217291e-02f, 2.05091372e-01f, 1.37078702e-01f, -2.69635230e-01f, -2.17529356e-01f, -1.93231225e-01f, -2.69501358e-01f, 2.75853068e-01f, 3.75285484e-02f, 8.45988095e-03f,
  -3.28381844e-02f, -4.06906009e-02f, -4.26200554e-02f, 1.56249359e-01f, -6.20142594e-02f, -8.17579478e-02f, -1.19854137e-02f, -1.05034895e-01f, -2.49739558e-01f, -2.68856525e-01f,
  -9.40753613e-04f, 3.27499926e-01f, 1.72909647e-01f, -2.77355850e-01f, 3.37643027e-01f, -2.73683637e-01f, -6.72287792e-02f, -1.71923205e-01f, 2.10022435e-01f, -5.05431145e-02f,
  1.03742182e-02f, 1.34647847e-03f, -3.40951141e-03f, 1.36951268e-01f, 5.77370375e-02f, -1.87311564e-02f, -2.38575622e-01f, -1.11034242e-02f, 1.39369011e-01f, 6.15639091e-02f,
  -1.71463042e-02f, -1.85782518e-02f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.83878481e-01f, 2.10903049e-01f, 3.36263061e-01f, 2.07566589e-01f, 2.38202691e-01f, 3.65981571e-02f, 2.01903060e-01f, 1.41737267e-01f, 2.83506364e-01f, 3.68946977e-02f,
  3.28281820e-01f, 5.57156876e-02f, -5.92663288e-02f, -1.44405887e-01f, -5.14803231e-01f, 3.61278921e-01f, 5.03082573e-01f, 1.81340903e-01f, 1.73819289e-01f, 2.14720055e-01f,
  -3.88122171e-01f, 3.02668035e-01f, 1.19867958e-01f, -2.54103303e-01f, 3.18602681e-01f, 2.71698475e-01f, -5.88867720e-03f, 3.55080634e-01f, 9.00709480e-02f, -7.52638727e-02f,
  -7.63486102e-02f, 4.35419470e-01f, 1.28761247e-01f, 1.08521000e-01f, -1.82691097e-01f, 1.59100369e-01f, 1.86301798e-01f, 1.37621060e-01f, -1.15462132e-01f, 2.56176968e-03f,
  2.34146751e-02f, -3.34965229e-01f, 1.84519634e-01f, -4.77044284e-01f, 1.40643358e-01f, 5.25484562e-01f, 3.68835554e-02f, -2.24906087e-01f, -1.81129605e-01f, 2.95654833e-01f,
  -8.32894444e-02f, 2.16914758e-01f, -1.30298927e-01f, -3.04917037e-01f, -1.96394995e-02f, -5.62596798e-01f, 2.96662718e-01f, -1.33974239e-01f, 3.17678303e-02f, 1.82459056e-01f,
  1.72193542e-01f, 2.53761113e-02f, -1.71786621e-01f, 3.49361092e-01f, 2.97673136e-01f, 4.80383962e-01f, 4.64200437e-01f, 1.47245958e-01f, 4.56554711e-01f, 4.90942150e-01f,
  1.34982586e-01f, 1.28287017e-01f, -7.83018544e-02f, -2.28790641e-01f, 6.59449458e-01f, 3.08831215e-01f, -2.48848870e-01f, -5.42981088e-01f, 3.03899884e-01f, 3.36965173e-01f,
  2.55766213e-01f, -2.02846617e-01f, -1.32043272e-01f, 3.25435430e-01f, 3.86584580e-01f, 3.36509824e-01f, 3.18942010e-01f, 4.21281233e-02f, 8.77095461e-02f, 3.74569774e-01f,
  4.44773942e-01f, -2.07821101e-01f, 2.96226591e-01f, 1.21932246e-01f, 1.33767566e-02f, 5.65134048e-01f, 3.33825201e-01f, 1.77943528e-01f, 1.19920135e-01f, 4.44409788e-01f,
  1.82120785e-01f, 2.05333918e-01f, -3.36127967e-01f, -2.03727528e-01f, 2.21829146e-01f, -5.34892902e-02f, -6.44852638e-01f, 1.35301471e-01f, 6.37544632e-01f, 5.81613705e-02f,
  1.57259509e-01f, -3.82938795e-02f, -1.48940861e-01f, 7.77195916e-02f, 4.66541886e-01f, -1.16594329e-01f, 1.82604045e-01f, 8.07180535e-03f, 2.59433717e-01f, 4.25489694e-01f,
  -3.65504116e-01f, 1.65733933e-01f, 1.41868904e-01f, 4.61377561e-01f, -9.63088721e-02f, -6.69911951e-02f, 4.22842145e-01f, -2.04403818e-01f, -1.83044355e-02f, -1.58805482e-03f,
  6.39377534e-02f, -4.92352732e-02f, -8.48614704e-03f, 6.59043789e-02f, 4.53247160e-01f, -1.54300287e-01f, 3.95319015e-01f, 6.04190230e-01f, -4.90792617e-02f, 1.75156549e-01f,
  2.40048692e-01f, -1.96324348e-01f, -1.37857661e-01f, 1.69223577e-01f, 4.24773730e-02f, -3.88504654e-01f, -1.36864439e-01f, -2.62219906e-01f, -3.16972047e-01f, 5.17679334e-01f,
  -5.99954486e-01f, 1.24985307e-01f, -2.75323272e-01f, 2.05109254e-01f, 5.40435240e-02f, -7.96935186e-02f, -5.06803334e-01f, -2.00472638e-01f, -1.25796139e-01f, 3.34478468e-01f,
  -1.05289966e-01f, 1.89487129e-01f, 2.25767121e-01f, 2.76140392e-01f, 1.93637908e-01f, 2.31989667e-01f, 1.12129495e-01f, -3.53553921e-01f, 3.80734801e-01f, 2.97544092e-01f,
  2.03653142e-01f, 4.21404578e-02f, 2.96008945e-01f, -1.45834923e-01f, 4.76314455e-01f, 7.30414912e-02f, 7.61443004e-02f, -6.09573722e-02f, 5.45796573e-01f, 3.16898376e-01f,
  -2.99074352e-01f, 2.83523500e-02f, -2.98144251e-01f, 4.23412696e-02f, -2.25195095e-01f, 3.70640755e-01f, -3.42464209e-01f, 3.69179130e-01f, 3.27666789e-01f, 2.71838069e-01f,
  3.97504210e-01f, -2.64409989e-01f, -6.95965886e-02f, 9.37282816e-02f, -2.17161879e-01f, -1.39086153e-02f, -1.04753198e-02f, 1.68134287e-01f, -1.15695007e-01f, -3.50052506e-01f,
  -4.77475017e-01f, -6.37589619e-02f, 4.17749465e-01f, -1.05250767e-02f, -1.47230208e-01f, -1.08520910e-01f, 6.67327642e-01f, -2.26109296e-01f, 6.81449659e-03f, -2.57542461e-01f,
  -1.50377229e-01f, 1.64873227e-01f, 5.73738515e-01f, -1.16402246e-01f, -3.39101329e-02f, 1.21115185e-01f, -1.12621509e-01f, 3.03843558e-01f, -3.23437244e-01f, -3.07567090e-01f,
  2.76676357e-01f, 3.89753729e-01f, 1.10823683e-01f, -1.96414534e-02f, -9.42638963e-02f, 1.45501360e-01f, 3.81959155e-02f, -9.44289714e-02f, 1.32111222e-01f, 2.71735102e-01f,
  3.43748629e-01f, 2.09628209e-01f, 5.18896520e-01f, 4.74951714e-01f, 1.15674153e-01f, -1.10255480e-01f, 3.97325605e-01f, -1.08023457e-01f, 2.39099711e-01f, 4.22693938e-01f,
  2.69429833e-01f, -9.02173966e-02f, -5.36807906e-03f, 4.04189765e-01f, -2.54846010e-02f, 3.89927328e-01f, -3.44729215e-01f, -3.20138671e-02f, -4.40237910e-01f, -2.03817949e-01f,
  3.48252594e-01f, -3.89376521e-01f, -6.03223920e-01f, 4.06488448e-01f, 3.51934046e-01f, -4.45554517e-02f, 5.28185256e-02f, 3.67878228e-01f, 1.84540190e-02f, -1.42463714e-01f,
  3.25691938e-01f, 3.47734064e-01f, 4.00501221e-01f, 8.49112645e-02f, -4.48635221e-03f, 4.42430407e-01f, 4.64397132e-01f, -2.27851450e-01f, -1.86976030e-01f, 1.09063596e-01f,
  -2.68503577e-01f, 2.78225541e-01f, 3.45108598e-01f, -4.22921702e-02f, -2.38525316e-01f, 1.06897548e-01f, 1.89653739e-01f, 3.77135724e-01f, -3.91303509e-01f, -2.73074582e-02f,
  -3.18850249e-01f, -2.68141896e-01f, 4.01763231e-01f, -2.51329631e-01f, -5.37796855e-01f, -1.74635276e-01f, -2.02465564e-01f, 4.59603816e-01f, 3.67781699e-01f, 1.54515758e-01f,
  2.97275007e-01f, 2.43831173e-01f, 4.21125621e-01f, 3.53974909e-01f, 2.90828049e-02f, 4.91768301e-01f, -2.23503225e-02f, -1.86913550e-01f, 3.66714507e-01f, -1.36055633e-01f,
  -4.36604977e-01f, 2.40954876e-01f, -6.88737333e-02f, 6.03422476e-03f, 2.50546578e-02f, 3.33598256e-01f, -2.85034269e-01f, 2.31886320e-02f, 2.31836159e-02f, 7.00452104e-02f,
  2.52286136e-01f, 2.67526627e-01f, 4.00372297e-01f, -4.61111357e-03f, 3.80364388e-01f, -1.12375930e-01f, 7.22504631e-02f, -1.79271922e-01f, -2.66711444e-01f, 5.06937683e-01f,
  2.71586508e-01f, 2.70501256e-01f, 2.25431398e-01f, 2.62717068e-01f, -8.79027788e-03f, 1.55490696e-01f, -1.94303766e-01f, 2.24445492e-01f, 4.85628843e-01f, 4.97990549e-01f,
  -4.96522367e-01f, 2.58728657e-02f, 6.06618166e-01f, -1.30278617e-02f, -4.53009456e-01f, 2.92255223e-01f, 2.56581903e-01f, 1.37925610e-01f, 4.24751818e-01f, -5.12553789e-02f,
  8.30170363e-02f, 5.46286941e-01f, 4.51003984e-02f, 3.86754364e-01f, -3.66294980e-01f, 1.49776354e-01f, -4.25820127e-02f, 2.62515038e-01f, -3.31343412e-02f, 1.71562195e-01f,
  2.35198647e-01f, -1.60539553e-01f, 5.48886895e-01f, 4.30582434e-01f, 3.82860869e-01f, 4.25705940e-01f, 7.02811256e-02f, 3.84882838e-02f, -4.39757407e-01f, 4.85090494e-01f,
  -3.45276654e-01f, -4.57764804e-01f, -2.38289595e-01f, 5.59297264e-01f, -2.99816996e-01f, 2.20539302e-01f, -2.65131146e-01f, -9.30550247e-02f, -8.36208835e-02f, 3.53237420e-01f,
  4.96945903e-02f, 3.02748382e-02f, 3.32561016e-01f, 1.46968424e-01f, 6.53108120e-01f, 5.39372861e-01f, 4.25632522e-02f, -2.56245524e-01f, 3.44180435e-01f, 3.17689516e-02f,
  1.38573766e-01f, -2.60470569e-01f, 1.72305048e-01f, 1.48018867e-01f, 4.50287700e-01f, 4.17635709e-01f, 3.67441773e-01f, 1.80660158e-01f, 1.37697145e-01f, 3.12406570e-01f,
  -2.92363584e-01f, 4.56763417e-01f, 4.07165587e-02f, -3.17977220e-01f, 5.26902139e-01f, 4.75611761e-02f, 1.25086144e-01f, 1.35078713e-01f, 3.46094787e-01f, 3.80619496e-01f,
  1.16214059e-01f, 2.66013891e-01f, 1.58715799e-01f, 4.24574524e-01f, 1.37356490e-01f, 2.46079966e-01f, 3.96679699e-01f, 1.37844115e-01f, 4.94326144e-01f, 5.60152903e-02f,
  1.43823162e-01f, -2.92854130e-01f, 1.85218200e-01f, 1.77178845e-01f, 1.98097348e-01f, 1.96865156e-01f, -1.92808304e-02f, 2.89852530e-01f, 3.10462832e-01f, 1.84194118e-01f,
  3.27321738e-01f, 1.43053681e-01f, 4.03960943e-01f, 3.17447901e-01f, 2.11570457e-01f, -1.12544179e-01f, 2.34169751e-01f, -1.84600055e-01f, -2.50913411e-01f, 2.98943102e-01f,
  -4.61320966e-01f, 2.90945657e-02f, 4.28658575e-01f, 2.70771086e-01f, -8.21883455e-02f, -9.31391399e-03f, -3.31607133e-01f, 2.37437278e-01f, 1.99242875e-01f, -2.72014588e-02f,
  3.29728633e-01f, 2.05935717e-01f, -1.85954139e-01f, 1.79370537e-01f, 3.88997793e-01f, -8.42612013e-02f, -1.04645565e-01f, 4.57296044e-01f, 1.82991505e-01f, 2.41680145e-01f,
  1.57190666e-01f, 2.13246197e-01f, 1.88938633e-01f, 4.44922954e-01f, -1.77528590e-01f, -3.97105753e-01f, -2.51513004e-01f, 5.28360829e-02f, 3.28475803e-01f, -2.21727997e-01f,
  2.89270580e-01f, -1.75644979e-01f, 5.10361254e-01f, 3.25418234e-01f, -5.40383384e-02f, -5.99039160e-03f, 2.41597798e-02f, 3.47445130e-01f, 6.60239100e-01f, -4.99201268e-02f,
  -9.34541747e-02f, -2.56449282e-02f, -4.99228358e-01f, -1.86850980e-01f, 6.26697361e-01f, -3.07157576e-01f, 4.06109318e-02f, 1.19898707e-01f, -8.45244825e-02f, -3.05320084e-01f,
  1.38448343e-01f, 4.11445290e-01f, 4.82496917e-01f, 1.43620878e-01f, 1.93702161e-01f, 4.69329096e-02f, -4.99212965e-02f, -3.25020552e-01f, -1.37337938e-01f, -4.60686684e-01f,
  3.38799119e-01f, -2.87705034e-01f, -1.65398344e-01f, -2.65776694e-01f, 7.30527341e-02f, -4.80150990e-02f, -1.11826196e-01f, 1.63481638e-01f, -8.06770101e-02f, 3.26572776e-01f,
  3.26145627e-02f, -1.98194548e-01f, 1.49810046e-01f, -1.73807606e-01f, 3.94652605e-01f, 4.10213649e-01f, -1.01887099e-01f, 3.64778966e-01f, 4.77179796e-01f, 3.22968289e-02f,
  -8.93469974e-02f, 1.78981841e-01f, 2.79188275e-01f, 4.46099102e-01f, 1.30482689e-01f, 1.76176980e-01f, 2.86498427e-01f, 1.34970903e-01f, 1.21140145e-01f, 3.54870588e-01f,
  3.23427171e-01f, 2.99044698e-01f, -8.88017938e-03f, 3.37929517e-01f, 4.72311288e-01f, 1.03072762e-01f, 2.42232278e-01f, 3.85515362e-01f, 3.53149533e-01f, 1.08421713e-01f,
  4.10710387e-02f, 3.05019677e-01f, -1.69862419e-01f, 5.87325573e-01f, 1.88104540e-01f, 4.90825683e-01f, 7.82159939e-02f, -1.16780095e-01f, 1.57560915e-01f, -4.09705371e-01f,
  -2.70739138e-01f, 1.42406002e-01f, 2.08643273e-01f, 3.17919046e-01f, -6.04689829e-02f, 3.82405847e-01f, 1.45238295e-01f, 3.27374518e-01f, 5.72977103e-02f, 1.63630079e-02f,
  1.78094544e-02f, -2.56960541e-01f, -3.21020305e-01f, -2.82497257e-01f, 4.39243346e-01f, -4.13690567e-01f, -2.82363147e-01f, -5.14102876e-01f, 3.78060371e-01f, -3.68973315e-02f,
  2.93269962e-01f, -2.18110114e-01f, 1.79717377e-01f, 5.66909350e-02f, 1.88580856e-01f, -5.91523588e-01f, -5.42900026e-01f, -4.11779493e-01f, 1.34237394e-01f, 5.72470844e-01f,
  -4.22336161e-01f, 3.68810743e-01f, 4.48550165e-01f, 1.25797957e-01f, 2.51293838e-01f, 1.13214925e-01f, 5.82159832e-02f, 1.20066190e-02f, 1.15471967e-01f, 1.18908715e-02f,
  2.96907246e-01f, 2.49941707e-01f, 1.00312747e-01f, 8.90911147e-02f, 4.50514823e-01f, 2.80355871e-01f, 3.21356952e-01f, -3.38189065e-01f, 7.67966434e-02f, 1.73350394e-01f,
  1.00471079e-01f, 4.12427008e-01f, 2.04477280e-01f, 1.53153181e-01f, 1.42516360e-01f, 3.47196966e-01f, -3.27712186e-02f, 4.07609314e-01f, -3.40997934e-01f, -1.79667458e-01f,
  2.76847064e-01f, -1.91693246e-01f, 3.45964800e-03f, 1.86219197e-02f, -1.95729122e-01f, 2.94872314e-01f, 3.51019800e-01f, 1.82472527e-01f, 4.20025945e-01f, 2.26486310e-01f,
  7.67083913e-02f, 2.19220594e-01f, 2.39893913e-01f, 5.63629806e-01f, -4.33915108e-02f, -6.38794720e-01f, 1.28709218e-02f, -6.88148886e-02f, -1.90954983e-01f, 2.90706247e-01f,
  6.40775383e-01f, -1.20482624e-01f, 3.18778545e-01f, 4.00843695e-02f, -9.93541256e-02f, -3.89936149e-01f, 4.96914327e-01f, 7.90615305e-02f, 3.07850927e-01f, 6.22313842e-02f,
  -7.14393258e-02f, 4.56916392e-01f, -3.56382936e-01f, 2.27227122e-01f, 2.93295354e-01f, 3.04533988e-01f, 5.40196225e-02f, 2.21532583e-01f, 7.64238983e-02f, -3.71116370e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  1.58135772e-01f, 2.16271617e-02f, 5.22646189e-01f, 3.00284326e-01f, 1.04284659e-01f, -5.35827037e-03f, 4.65294495e-02f, -8.85778442e-02f, 3.18955332e-01f, 2.90249169e-01f,
  3.59178543e-01f, 2.67189980e-01f, 3.97922963e-01f, 1.96554244e-01f, 3.02799165e-01f, 2.79197395e-01f, 4.68962878e-01f, 1.08264564e-02f, 1.46615177e-01f, 4.17872339e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -1.54262856e-01f, -1.71903983e-01f, -1.83612891e-02f, 5.61942495e-02f, -1.42542243e-01f, 3.91253009e-02f, -1.53675318e-01f, 2.97958404e-01f, -2.95975477e-01f, -1.73940584e-01f,
  4.19016451e-01f, -1.16585225e-01f, -3.59029174e-01f, 6.17618188e-02f, -1.69079080e-01f, 5.13528548e-02f, 1.99901700e-01f, 5.30287288e-02f, 5.92826754e-02f, 2.07707301e-01f,
  4.45365570e-02f, 9.67225432e-02f, 1.62949413e-01f, -2.17939001e-02f, -8.19736868e-02f, 8.34378824e-02f, 6.78651929e-02f, -7.96761066e-02f, 1.53566524e-01f, -1.74915597e-01f,
  3.17251831e-02f, -5.64645268e-02f, 7.35601187e-02f, 5.44915497e-02f, 2.12695941e-01f, -3.23937051e-02f, 2.42998287e-01f, -3.78228836e-02f, 1.71168044e-03f, -1.15960442e-01f,
  3.22452784e-01f, -1.56532928e-01f, 9.87088010e-02f, -3.15803826e-01f, -6.37863427e-02f, 7.93907866e-02f, 1.81440096e-02f, -7.50357285e-02f, -9.49042737e-02f, -2.75091291e-03f,
  -1.95834234e-01f, 5.44094779e-02f, 1.28458992e-01f, 2.79785752e-01f, -1.83636546e-01f, 1.23670839e-01f, -8.80638808e-02f, 1.92028448e-01f, 3.00318543e-02f, -1.81872785e-01f,
  2.03723684e-01f, -3.27076495e-01f, -3.12278960e-02f, -9.14765745e-02f, 4.45192046e-02f, -9.37646329e-02f, -6.03138208e-02f, -5.59130684e-02f, -5.74527010e-02f, -9.24369246e-02f,
  2.48309508e-01f, -2.93462485e-01f, 1.37717858e-01f, -2.70492673e-01f, 8.34980235e-02f, -1.60170391e-01f, 1.69579610e-01f, 1.27077326e-01f, -1.37038782e-01f, -1.57954946e-01f,
  6.71465620e-02f, -1.84108287e-01f, -1.35496959e-01f, 1.31512836e-01f, 2.10470229e-01f, -6.27405718e-02f, 2.38021478e-01f, 7.94037208e-02f, 1.21387847e-01f, 5.24493903e-02f,
  -1.18443228e-01f, 5.23645990e-03f, -4.55544777e-02f, -1.19452789e-01f, 2.45122537e-01f, -1.48876309e-01f, -9.61551592e-02f, 1.35992646e-01f, -1.58729792e-01f, -1.22132741e-01f,
  -1.88112840e-01f, -8.72084871e-02f, -1.36407822e-01f, 8.33541676e-02f, 2.44657576e-01f, -9.22650769e-02f, 5.26254922e-02f, 9.06445906e-02f, 9.18533504e-02f, 2.75357902e-01f,
  -1.24967685e-02f, -7.87891597e-02f, -3.20674032e-02f, -1.69140130e-01f, -1.85703114e-01f, -8.60539600e-02f, -2.20724061e-01f, 5.08111045e-02f, -2.67401069e-01f, -2.56396592e-01f,
  1.66518673e-01f, 8.14908668e-02f, 1.49439238e-02f, 9.84294042e-02f, -2.25450005e-02f, -1.78198606e-01f, 3.04653704e-01f, -1.94804221e-01f, 1.95930824e-02f, -7.00793639e-02f,
  -1.70566559e-01f, -5.59762828e-02f, 2.14900270e-01f, -3.30905706e-01f, 6.99873194e-02f, 4.94848564e-02f, -1.78990901e-01f, -3.28415364e-01f, 3.89302999e-01f, -1.47246093e-01f,
  -2.96782732e-01f, 9.76793841e-02f, -5.36527447e-02f, 7.90061280e-02f, -1.37027472e-01f, 8.50946233e-02f, -8.09726119e-03f, 2.16978341e-02f, 9.31492299e-02f, 3.40877138e-02f,
  -6.45942539e-02f, 6.10909685e-02f, 2.07801238e-01f, -7.91131407e-02f, 3.32474671e-02f, -2.16278762e-01f, -2.31158268e-02f, -1.22082859e-01f, 2.35340998e-01f, 2.26978455e-02f,
  6.41549453e-02f, 1.27137497e-01f, -1.31955445e-01f, -1.18060168e-02f, -1.31433934e-01f, 8.54756460e-02f, 2.14990333e-01f, -2.79527932e-01f, -3.14220637e-01f, 8.07127580e-02f,
  -1.43408641e-01f, -1.43414229e-01f, -8.96666795e-02f, -3.06078941e-02f, 1.76297083e-01f, -7.79615939e-02f, 1.17018089e-01f, -6.54112324e-02f, 2.78561175e-01f, 2.43282288e-01f,
  1.94758788e-01f, -2.33919725e-01f, -1.10063829e-01f, -1.87039629e-01f, -2.01801032e-01f, 1.22403517e-01f, 2.95912512e-02f, -1.41484424e-01f, 1.90103233e-01f, 1.28692478e-01f,
  5.73787577e-02f, 4.75583524e-02f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  3.02810937e-01f, 3.75741690e-01f, -7.77582973e-02f, 1.85890406e-01f, -1.22668706e-01f, 1.11079067e-01f, -2.53686726e-01f, -4.51159291e-02f, -4.21680987e-01f, 3.84600371e-01f,
  -3.83924484e-01f, -2.77654111e-01f, -1.67103946e-01f, 2.17045043e-02f, 2.70203054e-01f, 2.58558601e-01f, 4.90575343e-01f, -2.36113638e-01f, -1.77360728e-01f, 1.79804981e-01f,
  5.40501773e-01f, 9.73297004e-03f, 2.87720621e-01f, -2.14798778e-01f, -2.07851186e-01f, -1.85963497e-01f, 5.84437251e-01f, -1.50023922e-01f, 3.36088061e-01f, -4.94638324e-01f,
  -1.31791815e-01f, 3.99937958e-01f, 1.35154405e-03f, 1.61988035e-01f, 2.07206383e-01f, 1.88835710e-01f, -5.38951568e-02f, 2.29351372e-01f, -1.95447549e-01f, 1.51557550e-01f,
  -5.51136494e-01f, 5.11931121e-01f, -4.63525355e-01f, 2.04765320e-01f, -4.42882091e-01f, -3.37711006e-01f, 2.84543276e-01f, 6.16338789e-01f, -1.57892078e-01f, 1.73115551e-01f,
  1.08336434e-01f, -3.30772847e-01f, 9.94108245e-02f, 3.79301012e-02f, 1.56292424e-01f, 5.15545368e-01f, 1.73197463e-01f, -4.08163100e-01f, 5.16268790e-01f, 7.69717712e-03f,
  4.11550328e-02f, 1.95052937e-01f, -3.97609293e-01f, 5.61986864e-01f, -1.88704915e-02f, 3.79769713e-01f, 3.30461770e-01f, 6.80831298e-02f, 1.84965253e-01f, 4.02359277e-01f,
  -4.71334696e-01f, 2.58470625e-01f, -7.71907121e-02f, 4.37699497e-01f, -5.47409177e-01f, 3.14235866e-01f, -1.01906747e-01f, -4.42252010e-01f, 4.44430649e-01f, 3.29722345e-01f,
  -2.48654678e-01f, -1.12622768e-01f, 4.33316007e-02f, -4.51237649e-01f, -1.18764080e-01f, 7.61878304e-03f, 1.82859555e-01f, 4.04722244e-01f, 3.58414263e-01f, -2.33631998e-01f,
  2.36882064e-02f, -5.79484552e-02f, 3.43299270e-01f, -2.09298417e-01f, -3.28570127e-01f, 2.33557835e-01f, 9.14688036e-02f, 3.78483951e-01f, 3.66668664e-02f, 3.40201586e-01f,
  5.14650494e-02f, 3.33823234e-01f, -5.05363882e-01f, -2.87260503e-01f, -4.46486436e-02f, 6.64822996e-01f, -6.42450929e-01f, -1.86000288e-01f, 1.64849594e-01f, 2.73424953e-01f,
  4.08826321e-01f, -3.00906450e-02f, -2.16228575e-01f, -2.97803313e-01f, -1.73241228e-01f, -3.85120273e-01f, 3.34835052e-02f, 5.15422344e-01f, -2.16840729e-01f, 1.71459690e-01f,
  1.71942458e-01f, 3.38163048e-01f, 3.00666213e-01f, 2.97645032e-01f, 5.14611192e-02f, -1.51971117e-01f, -3.53745148e-02f, 8.64733942e-03f, -2.60951202e-02f, 1.98277786e-01f,
  2.51584593e-02f, 5.73479943e-02f, -1.36968344e-01f, 2.21902236e-01f, -2.40199670e-01f, -4.63566899e-01f, -2.25421917e-02f, 5.16123891e-01f, -3.01216036e-01f, 6.13350391e-01f,
  -1.06532700e-01f, -1.80907398e-02f, 4.98256117e-01f, -3.30089688e-01f, -5.58082402e-01f, 2.84087092e-01f, 5.37749887e-01f, 9.58634075e-03f, -1.17236614e-01f, 5.10482714e-02f,
  -3.35808069e-01f, 1.55793160e-01f, 1.89271063e-01f, -5.98323718e-03f, 4.99982625e-01f, 3.92433465e-01f, 2.14633383e-02f, 3.09840709e-01f, -5.14540225e-02f, 9.50830802e-02f,
  3.60942066e-01f, 1.09319277e-01f, 1.65238157e-01f, 2.32030544e-03f, 3.20421942e-02f, 3.87568206e-01f, 3.99427742e-01f, -4.89452779e-01f, 8.19321945e-02f, 2.79580265e-01f,
  -2.72197217e-01f, -4.88622896e-02f, 5.39525568e-01f, 1.55354381e-01f, 6.09774828e-01f, -2.33442202e-01f, 3.11145753e-01f, 3.68691653e-01f, 2.89434016e-01f, 2.26256326e-01f,
  1.73423499e-01f, 1.11018252e-02f, 8.56937747e-03f, -2.66280979e-01f, 3.39943618e-01f, 6.20323300e-01f, 4.43196833e-01f, 6.57052815e-01f, 7.14014471e-02f, 6.90845430e-01f,
  4.59991038e-01f, -9.26594287e-02f, 1.60298124e-01f, -4.79290225e-02f, 1.64261520e-01f, 2.78980564e-02f, 5.02237678e-02f, 7.31704086e-02f, -3.30425799e-01f, -1.74882427e-01f,
  2.08207786e-01f, -2.18841091e-01f, 3.66291285e-01f, -3.67132187e-01f, 3.07002872e-01f, 5.41518748e-01f, 1.06545232e-01f, -3.25913280e-01f, 2.34191850e-01f, -2.12928906e-01f,
  -2.14119792e-01f, 1.59783885e-01f, 4.26671922e-01f, 5.14396071e-01f, 1.28435165e-01f, 1.78820536e-01f, 4.68239188e-01f, 5.99174321e-01f, -2.62145936e-01f, 9.79252532e-02f,
  3.17652881e-01f, -1.48729086e-01f, 4.44108903e-01f, -3.80699456e-01f, 8.26345161e-02f, 1.53331056e-01f, 2.77412593e-01f, -1.90161750e-01f, 2.02197909e-01f, 2.69904882e-01f,
  4.78910059e-01f, 2.86987394e-01f, 1.32314444e-01f, -4.63921726e-01f, 6.17772579e-01f, -3.72294895e-02f, 2.79098779e-01f, -2.18747094e-01f, -3.57915498e-02f, 3.60594958e-01f,
  4.63999689e-01f, 5.71370840e-01f, -4.58503306e-01f, 1.84573218e-01f, -1.49513006e-01f, -3.37238133e-01f, 4.76327270e-01f, 1.14558645e-01f, 4.83248197e-03f, 1.18218489e-01f,
  -4.28328872e-01f, -7.02589378e-02f, 4.43218976e-01f, 1.06738150e-01f, 4.12723243e-01f, 2.29970589e-01f, 4.19995040e-02f, 1.55557185e-01f, 8.93301666e-02f, 1.37813240e-02f,
  2.05120355e-01f, 2.12735564e-01f, -1.30301788e-01f, -3.39264333e-01f, -9.62151065e-02f, -1.59990519e-01f, 2.86633432e-01f, -2.30937704e-01f, 1.17693990e-01f, -4.17347848e-01f,
  4.35161710e-01f, 1.01867102e-01f, 5.20895600e-01f, -7.02682063e-02f, -2.47947440e-01f, 4.18961853e-01f, 6.20962381e-01f, 3.24207693e-01f, 2.86153466e-01f, 1.39961094e-01f,
  1.71040714e-01f, -7.63374269e-02f, 2.44334951e-01f, -5.27935386e-01f, 3.48171890e-01f, -3.03311855e-01f, 3.32399398e-01f, 5.92336804e-02f, 1.05045354e-02f, 1.33821875e-01f,
  1.73432112e-01f, 3.35022181e-01f, 1.03562035e-01f, -1.21604756e-01f, -4.20121670e-01f, 4.60659683e-01f, 8.09466168e-02f, -9.85940546e-02f, -2.54418910e-01f, -2.02197675e-02f,
  1.07836664e-01f, 3.26332331e-01f, -2.03492165e-01f, 4.13301975e-01f, -3.77317846e-01f, -9.29339156e-02f, -1.88170657e-01f, -4.59352195e-01f, -2.88398147e-01f, 3.02520424e-01f,
  -1.16145104e-01f, 4.12296474e-01f, 2.66403198e-01f, 3.25757474e-01f, -6.20715506e-02f, 1.41063228e-01f, 2.02664450e-01f, -5.64649165e-01f, -1.10473938e-01f, 4.44706917e-01f,
  5.05588800e-02f, 1.46137193e-01f, 4.28312391e-01f, 6.49771318e-02f, 1.29485160e-01f, 2.13994592e-01f, -2.94982135e-01f, 1.77994758e-01f, 4.11108464e-01f, -2.82668650e-01f,
  -2.93924600e-01f, -7.61465775e-03f, 3.09427142e-01f, -3.92656505e-01f, 3.86597097e-01f, 4.15598184e-01f, 2.85469323e-01f, -3.21456161e-03f, -4.72815782e-01f, -5.25933318e-02f,
  7.95438886e-02f, 8.11190456e-02f, 3.40961039e-01f, 5.34318268e-01f, 9.76939201e-02f, 1.96450040e-01f, -4.24365997e-01f, -1.93105787e-01f, 4.72440511e-01f, -4.04773444e-01f,
  -1.67076111e-01f, 1.45058796e-01f, 3.34398270e-01f, 3.39620352e-01f, -3.16848271e-02f, -1.08327400e-02f, -1.81559995e-01f, -1.00012861e-01f, -1.63064390e-01f, -3.08354020e-01f,
  -3.24627608e-01f, 6.39507711e-01f, -6.34989917e-01f, -1.66218936e-01f, 9.07395706e-02f, -1.18770815e-01f, 2.43006289e-01f, -1.04728110e-01f, -8.91151279e-02f, -2.40106627e-01f,
  3.51580799e-01f, -2.51255989e-01f, 4.95128810e-01f, 2.72446275e-01f, -1.09853119e-01f, 3.57631445e-02f, 2.39324898e-01f, -2.56580472e-01f, 5.86347103e-01f, -1.74307480e-01f,
  1.01849716e-02f, -2.11727962e-01f, 2.64481530e-02f, 2.79601455e-01f, -6.05295375e-02f, -1.83804378e-01f, 2.83248186e-01f, 9.62381661e-02f, 1.83622599e-01f, 1.84461907e-01f,
  -1.93601832e-01f, -1.60485998e-01f, 2.81579375e-01f, -7.51621574e-02f, 2.16928974e-01f, -3.80009174e-01f, 3.25159013e-01f, -9.50917974e-02f, 2.87027299e-01f, -2.30078638e-01f,
  1.86388656e-01f, -4.71766591e-01f, -3.55066359e-01f, -1.69867471e-01f, 2.47355178e-01f, 5.22721112e-01f, -5.50422445e-02f, 5.14098406e-01f, 1.91786930e-01f, 5.34346998e-01f,
  -2.06131175e-01f, 2.13858649e-01f, 2.59396046e-01f, 1.30749613e-01f, -1.46186203e-02f, -3.43361378e-01f, 2.83618867e-01f, 2.97799230e-01f, -2.00055227e-01f, -2.31713001e-02f,
  3.16020995e-02f, -8.16966295e-02f, 2.71293700e-01f, 1.47228967e-02f, -3.71998221e-01f, -1.94658056e-01f, 1.05878271e-01f, 1.65501446e-01f, 7.73769943e-03f, -2.74079163e-02f,
  1.24787077e-01f, 4.85198319e-01f, 2.19977960e-01f, 5.40659845e-01f, -3.80013973e-01f, 5.90733647e-01f, 2.23617226e-01f, -2.04717860e-01f, 3.35342348e-01f, -3.29893887e-01f,
  3.39115262e-02f, -2.99286127e-01f, 5.33307910e-01f, 6.99561602e-03f, 1.75160423e-01f, -3.29497717e-02f, 2.64464349e-01f, 5.23093760e-01f, 8.01450014e-02f, -1.05258279e-01f,
  8.06107670e-02f, 1.90444157e-01f, 1.86468929e-01f, 4.49763238e-03f, 7.89702758e-02f, -3.58085722e-01f, 1.18790872e-01f, -2.71717519e-01f, 1.82703108e-01f, -3.67823452e-01f,
  4.98609573e-01f, 3.73066396e-01f, 3.17066401e-01f, -2.99322516e-01f, 1.19903848e-01f, -2.59469926e-01f, -4.36234832e-01f, 5.02225220e-01f, 3.95364225e-01f, 5.21747351e-01f,
  2.36002848e-01f, 2.39361431e-02f, 3.52328390e-01f, 4.83650029e-01f, 4.75653522e-02f, 2.79525459e-01f, 2.87731886e-01f, 1.31854817e-01f, 5.15795231e-01f, -3.50732267e-01f,
  1.20614305e-01f, 1.08314864e-01f, 1.87221661e-01f, 8.75623673e-02f, -1.93414003e-01f, 2.43076578e-01f, 2.97922403e-01f, -4.14848804e-01f, -2.63040632e-01f, 5.32465816e-01f,
  -2.30102465e-01f, 1.92231759e-01f, -4.07800287e-01f, -8.15314353e-02f, 5.44049501e-01f, -2.76038289e-01f, -3.32787573e-01f, -9.33657587e-02f, 4.56665546e-01f, 2.21916899e-01f,
  3.42579961e-01f, 2.10176423e-01f, -2.56493956e-01f, 5.44051975e-02f, 3.11160445e-01f, -2.65075356e-01f, 5.96067727e-01f, 1.63839757e-01f, 1.88155204e-01f, 5.47732152e-02f,
  8.83849040e-02f, 1.78724676e-02f, 2.74143219e-01f, 3.96945775e-01f, 2.34070987e-01f, 4.49689478e-02f, 2.68300563e-01f, 4.83448833e-01f, -1.24657504e-01f, -2.23171059e-02f,
  -9.67731029e-02f, 8.44808519e-02f, 3.52335200e-02f, -3.58135104e-01f, -7.42610991e-02f, 4.06019956e-01f, -5.57628646e-02f, 3.52582216e-01f, -2.10651785e-01f, -3.62958103e-01f,
  -4.89066809e-01f, 1.27545923e-01f, -6.88264985e-03f, 1.75255865e-01f, 2.08875284e-01f, 6.09773219e-01f, 3.66540343e-01f, -2.18004704e-01f, 4.31785583e-01f, -6.26254752e-02f,
  5.29060960e-02f, -7.05375075e-01f, 1.06573738e-01f, 3.26046348e-02f, -2.38951355e-01f, -2.50412285e-01f, -1.76878944e-01f, 7.35941855e-03f, 3.05874318e-01f, -2.47315124e-01f,
  -1.66042126e-03f, 2.67743170e-01f, -4.01614189e-01f, -4.51438844e-01f, 5.74008822e-01f, 2.49054700e-01f, -5.86732268e-01f, 6.48965910e-02f, 6.36255443e-02f, 1.79458499e-01f,
  1.97928641e-02f, 4.23373789e-01f, 3.50781113e-01f, 3.46704960e-01f, -1.91309869e-01f, 1.99804574e-01f, 1.38779551e-01f, 8.10090154e-02f, 3.09873551e-01f, -4.89139915e-01f,
  4.00925636e-01f, -3.48675966e-01f, 4.12025452e-01f, -1.10700674e-01f, 3.14485505e-02f, 2.03298971e-01f, -8.91713705e-03f, 2.60424703e-01f, 3.90363961e-01f, 1.86604246e-01f,
  -1.39803573e-01f, 3.32941413e-01f, -4.49333377e-02f, 3.01632583e-01f, 1.63689196e-01f, -2.09714383e-01f, -2.32679963e-01f, 3.14315259e-01f, -5.41593060e-02f, -1.38997501e-02f,
  1.41083347e-02f, 6.32299364e-01f, -2.97453403e-01f, 3.73259783e-01f, 1.24679826e-01f, -7.42260635e-01f, -3.94283891e-01f, 1.81776479e-01f, 2.51936883e-01f, 4.31624532e-01f,
  3.26303393e-02f, 2.67675165e-02f, -8.22718292e-02f, 1.11130171e-01f, -1.67668998e-01f, 3.67882550e-01f, -4.22067493e-01f, 5.02141118e-01f, 5.35753630e-02f, 1.73060652e-02f,
  -4.63676900e-02f, -2.92546302e-01f, 1.58025086e-01f, -1.18611224e-01f, 9.06626135e-02f, -9.72427577e-02f, -1.82069287e-01f, -3.60851556e-01f, 3.16481709e-01f, 3.15784633e-01f,
  -3.01537186e-01f, 1.72790721e-01f, -1.94767537e-03f, 1.09569766e-01f, 6.69462159e-02f, 4.54262078e-01f, 3.70408386e-01f, 3.84924382e-01f, -1.51123524e-01f, -5.69535315e-01f,
  1.53747112e-01f, -3.54354799e-01f, 2.38280267e-01f, -4.49381709e-01f, 1.29920930e-01f, -2.56615251e-01f, 3.80702883e-01f, -9.42719802e-02f, 2.11047143e-01f, 3.10403794e-01f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  2.32797459e-01f, 4.12106276e-01f, 2.57988632e-01f, 1.32026061e-01f, 1.72875240e-01f, 5.78388348e-02f, 3.05982500e-01f, -8.44636261e-02f, 2.21254468e-01f, 2.57058114e-01f,
  3.35963696e-01f, 2.08441108e-01f, 2.90591836e-01f, 2.11791188e-01f, 1.26813114e-01f, -1.01391533e-02f, 1.65102258e-01f, 3.09817884e-02f, 1.40111223e-01f, -1.23452961e-01f
};

// L3_linear_W (Shape: 12 x 32)
const int L3_linear_W_rows = 12;
const int L3_linear_W_cols = 32;
const float L3_linear_W_data[] = {
  1.00378446e-01f, -1.96081519e-01f, -1.30705401e-01f, -2.89208605e-03f, 3.84555794e-02f, -1.21418893e-01f, 4.00125086e-01f, -9.33141559e-02f, -4.33296449e-02f, -2.32203025e-02f,
  2.97896452e-02f, 3.63228351e-01f, 2.13233277e-01f, -6.43289983e-01f, -5.28726757e-01f, -2.08997697e-01f, -5.92014134e-01f, 1.17406011e-01f, 3.00868332e-01f, 5.22182062e-02f,
  2.84633368e-01f, -6.32753193e-01f, 1.75103843e-01f, 2.61665247e-02f, 2.91545987e-01f, -1.04288049e-01f, 2.24555373e-01f, -1.30887315e-01f, -4.38164085e-01f, -4.98742819e-01f,
  -2.65538156e-01f, -3.78975600e-01f, -2.01678023e-01f, 3.38262349e-01f, -3.17005098e-01f, 4.41326201e-02f, 6.04222231e-02f, -2.55675256e-01f, 2.48209998e-01f, 1.37950987e-01f,
  4.44627851e-01f, -8.73979330e-02f, 2.84437567e-01f, -4.51276638e-02f, 1.61913216e-01f, -3.36455911e-01f, -2.67653435e-01f, -5.72827160e-01f, -4.96143252e-01f, 9.69994664e-02f,
  -7.90905021e-03f, 3.79026830e-01f, 2.46431246e-01f, -5.46422601e-01f, -1.59789380e-02f, -1.58368304e-01f, -3.81922901e-01f, 1.60808101e-01f, 9.98086706e-02f, -1.33392558e-01f,
  3.12885404e-01f, 2.40379330e-02f, -3.93929511e-01f, 3.29474121e-01f, -1.03327632e-01f, 5.13610430e-03f, 8.04829448e-02f, -8.69418085e-02f, -2.59772420e-01f, 7.21240044e-02f,
  1.27187744e-01f, 1.90519392e-02f, -3.21810126e-01f, -5.99343888e-02f, 2.44660228e-02f, 2.97370204e-03f, 1.80151746e-01f, 1.09507240e-01f, 1.96794674e-01f, -4.42791671e-01f,
  -4.42969590e-01f, -5.09753823e-01f, -4.17522550e-01f, 2.11711258e-01f, 1.42282382e-01f, -5.22713177e-02f, 3.98673266e-02f, -3.22492033e-01f, -4.60626215e-01f, 3.01031202e-01f,
  -4.27250296e-01f, -5.62366366e-01f, -3.16013992e-01f, 5.09279191e-01f, 6.61170334e-02f, 2.93243825e-01f, -2.36985147e-01f, 2.44027779e-01f, 4.57243733e-02f, 1.56238869e-01f,
  -1.70579299e-01f, 1.02489546e-01f, -9.77945253e-02f, -2.08485454e-01f, 5.27802631e-02f, 3.74446929e-01f, -3.09276551e-01f, -1.46570221e-01f, -3.88580233e-01f, -5.75607121e-01f,
  -5.27557194e-01f, 1.83465257e-01f, 2.55486459e-01f, 3.82725000e-01f, 1.63464978e-01f, -1.47268608e-01f, -5.32505274e-01f, -2.61377066e-01f, -4.49778765e-01f, -3.64552349e-01f,
  3.28210145e-01f, -3.02668601e-01f, 2.59598583e-01f, -1.59397587e-01f, -7.01974630e-01f, -5.75453218e-04f, -1.79062322e-01f, -1.26187820e-02f, -1.63837388e-01f, 1.03190020e-01f,
  -3.68682966e-02f, 3.76758933e-01f, 1.73629969e-01f, 2.84778297e-01f, -5.37891984e-01f, 3.32527012e-01f, -5.55868782e-02f, 5.29869534e-02f, -5.13669431e-01f, -3.19156200e-01f,
  -2.29555607e-01f, -1.63173869e-01f, 3.51148695e-01f, 2.50647604e-01f, 2.19698936e-01f, -6.63721655e-03f, 9.57293734e-02f, -2.60524690e-01f, 3.79322618e-02f, 1.05693281e-01f,
  3.26936543e-01f, 1.75537258e-01f, 8.45189989e-02f, -6.17885828e-01f, -1.32367648e-02f, -5.24980426e-02f, 8.64954963e-02f, -6.95508003e-01f, -1.22944571e-01f, -2.37888426e-01f,
  3.78709376e-01f, -1.61917761e-01f, 1.25030041e-01f, -1.28150016e-01f, -8.75751376e-02f, 8.40921849e-02f, 2.68024318e-02f, 1.30580053e-01f, 3.33608896e-01f, -3.10344875e-01f,
  2.45717123e-01f, 4.44622636e-01f, 2.18218565e-01f, 1.80580199e-01f, 6.78678602e-02f, 6.25617504e-02f, -8.42306688e-02f, -1.01626337e-01f, -1.51883259e-01f, -4.30856854e-01f,
  1.92873195e-01f, -3.41367781e-01f, -1.94412246e-01f, 4.46857631e-01f, 1.36020286e-02f, 1.05847158e-01f, 5.48795201e-02f, 1.81281909e-01f, 2.44091824e-01f, -6.55609891e-02f,
  -7.82648981e-01f, -2.92931497e-01f, 1.74452990e-01f, 1.11931421e-01f, -3.18835735e-01f, 8.11110958e-02f, 1.39675856e-01f, 3.09311002e-01f, 1.21746466e-01f, -1.42968193e-01f,
  -3.49436551e-01f, -1.92707419e-01f, -2.16141358e-01f, -3.67640853e-01f, 3.99732739e-01f, 5.17517507e-01f, 1.99248955e-01f, 1.03789121e-01f, 1.09084016e-02f, -4.09546763e-01f,
  -6.52362525e-01f, -4.06648934e-01f, -9.85275656e-02f, 2.88480103e-01f, 1.19737536e-01f, 1.60609230e-01f, -3.03858459e-01f, 1.35641275e-02f, -5.96038520e-01f, -1.22955650e-01f,
  1.41123369e-01f, -2.03095481e-01f, 3.19823205e-01f, -2.59907335e-01f, 2.20423222e-01f, -2.24960864e-01f, -8.85593221e-02f, -1.41321853e-01f, -1.41759187e-01f, -2.02810422e-01f,
  -3.89238186e-02f, 2.58339167e-01f, 1.53355896e-01f, 2.80829489e-01f, 2.05946773e-01f, -6.82540759e-02f, -3.38437527e-01f, -5.04694641e-01f, -6.23668432e-01f, 1.48007914e-01f,
  -4.89659667e-01f, -1.90478355e-01f, 4.31606531e-01f, -2.32789800e-01f, -3.85769725e-01f, 5.25322199e-01f, -1.02664649e-01f, -2.12606058e-01f, 1.53674796e-01f, -2.43819237e-01f,
  2.28854045e-01f, -5.48743725e-01f, 3.53228688e-01f, -1.37021318e-02f, -9.79703292e-02f, -2.54047036e-01f, 1.90930590e-01f, 5.67689091e-02f, 8.32059011e-02f, 3.45576890e-02f,
  -1.18083633e-01f, -2.49476895e-01f, 1.47929221e-01f, -1.98995039e-01f, -1.17068075e-01f, 2.84787677e-02f, 2.88579941e-01f, 9.01948214e-02f, -4.14154887e-01f, -1.59241989e-01f,
  -3.56138736e-01f, -4.51907933e-01f, 3.63566667e-01f, 2.77864367e-01f, -2.47654453e-01f, 5.78558333e-02f, 4.53018621e-02f, -1.90909624e-01f, -5.99953353e-01f, -1.65931657e-01f,
  -4.49240237e-01f, 1.90855443e-01f, 1.85236782e-02f, 1.70700908e-01f, -4.71250713e-01f, 3.95440936e-01f, -4.17435408e-01f, 4.02358085e-01f, -4.34189197e-03f, -2.22236633e-01f,
  7.16170147e-02f, 1.39533021e-02f, 1.14183702e-01f, -2.43275166e-01f, 3.03407580e-01f, 3.21028560e-01f, -1.94937840e-01f, -1.95854440e-01f, 4.06292170e-01f, -1.45974785e-01f,
  -4.42252845e-01f, 1.93736136e-01f, 2.50698268e-01f, -2.48088583e-01f, -4.79595274e-01f, -7.34491169e-01f, -1.71940535e-01f, 2.39784837e-01f, 1.67767093e-01f, 1.50490507e-01f,
  3.67942572e-01f, -6.80526316e-01f, 3.89336914e-01f, -5.25744975e-01f, -1.34727105e-01f, -4.20588493e-01f, 2.76840687e-01f, 1.12565018e-01f, 3.57704282e-01f, -4.06340420e-01f,
  -2.63939708e-01f, -1.29044548e-01f, 1.94635421e-01f, -1.36707336e-01f, 1.39185205e-01f, 2.21859351e-01f, -2.20573083e-01f, -3.07832122e-01f, -2.39859715e-01f, -2.41693586e-01f,
  -3.55934888e-01f, -1.23398695e-02f, -4.02109861e-01f, 1.09894082e-01f, -7.17297941e-02f, -2.28631720e-01f, -8.99407715e-02f, 2.53821969e-01f, -3.31693143e-01f, 3.88630331e-01f,
  -2.83288926e-01f, -1.13126695e-01f, 1.87998101e-01f, -3.72335851e-01f, -2.46872216e-01f, 3.12310666e-01f, -5.36926687e-02f, -3.46792400e-01f, -4.82129902e-01f, -4.48829085e-01f,
  5.04044473e-01f, -1.03681348e-01f, 1.74416751e-02f, 5.05836122e-03f, -1.64053924e-02f, -1.06923766e-01f, 1.98368102e-01f, 1.00829341e-01f, -2.83189565e-01f, -1.58177957e-01f,
  -1.78164050e-01f, 4.82456721e-02f, -3.62316281e-01f, 2.70821005e-01f, -6.01390675e-02f, 3.54120404e-01f, 1.38198763e-01f, -1.11563683e-01f, 4.37307745e-01f, 2.79315740e-01f,
  -4.09769177e-01f, -3.96555930e-01f, -4.47624207e-01f, -4.71055537e-01f, -4.96932209e-01f, 3.00690502e-01f, -2.71882743e-01f, -4.06461030e-01f, -4.52562988e-01f, 4.73888248e-01f,
  -3.92153472e-01f, -1.61692604e-01f, 2.20730960e-01f, -5.71095501e-04f
};

// L3_linear_B (Shape: 1 x 12)
const int L3_linear_B_rows = 1;
const int L3_linear_B_cols = 12;
const float L3_linear_B_data[] = {
  2.90900879e-02f, -1.20942004e-01f, -2.72412971e-02f, 1.80856697e-02f, -9.60077196e-02f, -1.13517642e-01f, -1.43847028e-02f, -9.43454355e-02f, -1.46722838e-01f, -8.41058642e-02f,
  1.27504528e-01f, -1.34831250e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_linear
    linear_forward_pgm(
        buffer1, x_out,
        L3_linear_W_data, L3_linear_B_data,
        32, 12
    );
    }
    