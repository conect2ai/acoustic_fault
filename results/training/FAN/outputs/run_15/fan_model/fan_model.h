/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 16 (x2)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 16;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 3 x 120)
const int L0_fan_Wp_rows = 3;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.33026230e-01f, -9.55904871e-02f, 6.02336451e-02f, 2.78745621e-01f, -4.11668122e-02f, -4.19136524e-01f, 3.58909220e-02f, -1.23053648e-01f, 2.86813915e-01f, -1.79075450e-01f,
  1.51714444e-01f, 8.78526419e-02f, 2.84281105e-01f, -9.07992423e-02f, 3.94206434e-01f, 2.26004109e-01f, -5.80061376e-02f, -1.43914133e-01f, 6.22422397e-02f, -1.07271923e-02f,
  5.38072065e-02f, 7.71666765e-02f, 1.04843937e-01f, -7.91185796e-02f, -1.13656171e-01f, -6.31079897e-02f, -3.88948843e-02f, 2.62022074e-02f, -8.64964500e-02f, 1.52008692e-02f,
  -7.87036717e-02f, 8.37274939e-02f, -1.57476775e-02f, -6.62216097e-02f, -1.10990433e-02f, -4.63381931e-02f, -2.73185465e-02f, 7.15652853e-02f, 2.55849492e-02f, 1.57882478e-02f,
  -2.86147241e-02f, 3.71043235e-02f, 3.92840169e-02f, 7.87353292e-02f, -6.91372007e-02f, 1.80191603e-02f, 1.40300617e-02f, 2.77546048e-02f, 3.75526398e-02f, 9.94441286e-02f,
  2.99148317e-02f, -7.91324005e-02f, -2.64740530e-02f, 3.62432301e-02f, 5.31727746e-02f, 1.48813557e-02f, 1.30155860e-02f, -9.97523963e-03f, -1.37287742e-02f, -4.39442098e-02f,
  1.03134606e-02f, 5.26378229e-02f, 2.12016553e-02f, -8.17793235e-02f, 1.32407770e-01f, 1.94744288e-03f, 3.63570228e-02f, -5.63332753e-04f, 1.76992491e-02f, 1.12557486e-02f,
  -6.77401274e-02f, 5.80045730e-02f, -3.25224698e-02f, -1.89918596e-02f, 3.99122015e-02f, -8.15410838e-02f, 3.18882279e-02f, -1.44673809e-01f, 1.49719622e-02f, -5.42955957e-02f,
  -3.65226120e-02f, -5.46180159e-02f, -6.59676269e-04f, -6.37181997e-02f, -1.63249839e-02f, 1.07403301e-01f, 1.37246856e-02f, -4.64935862e-02f, 3.26171629e-02f, -5.03264228e-03f,
  -7.11727738e-02f, 7.54453093e-02f, 4.40217555e-02f, -2.63410565e-02f, -2.52589509e-02f, -4.06672917e-02f, 6.68932721e-02f, -4.11661565e-02f, 3.68025377e-02f, -4.54962291e-02f,
  7.57204974e-03f, -1.28335327e-01f, -1.32945657e-01f, 1.11711621e-02f, -1.59727633e-02f, 2.57112700e-02f, -3.26206023e-03f, -4.75022346e-02f, -5.10956645e-02f, -1.15843453e-02f,
  -3.97179835e-02f, 7.62355095e-03f, 7.21449256e-02f, -8.05949792e-02f, 2.23819334e-02f, -5.46007827e-02f, -2.04799473e-02f, 4.30790707e-02f, -1.66032370e-02f, -1.04896892e-02f,
  4.23969179e-01f, 2.36222938e-01f, 3.71188074e-01f, 1.31496534e-01f, -1.25931324e-02f, 3.21590275e-01f, 2.85078198e-01f, 2.57080216e-02f, 1.09584674e-01f, -5.58898561e-02f,
  -1.28051028e-01f, 1.79041624e-01f, -6.28263503e-02f, 8.49570036e-02f, 1.80773243e-01f, 3.43016461e-02f, 3.51687446e-02f, 5.98193184e-02f, 7.79471174e-02f, 8.65172222e-02f,
  1.00654408e-01f, -1.88869894e-01f, 1.41810000e-01f, -1.22413591e-01f, 2.37827256e-01f, 4.19320129e-02f, -2.75201648e-01f, 1.25976987e-02f, -5.60191162e-02f, 1.17348591e-02f,
  1.35557413e-01f, 5.16388714e-02f, 1.00821920e-01f, -3.99064831e-02f, 2.99115665e-02f, 5.74640557e-02f, 2.47663725e-02f, -6.65614083e-02f, -1.94153842e-02f, -2.02730037e-02f,
  -2.41709687e-02f, -2.24135816e-02f, -5.75671205e-03f, 8.05943385e-02f, -9.37709678e-03f, 2.69759856e-02f, 7.70565644e-02f, 8.96793827e-02f, 6.36504367e-02f, 1.10087872e-01f,
  1.06261790e-01f, 8.00898150e-02f, 4.39404547e-02f, 1.47946570e-02f, 2.36815047e-02f, 2.96586342e-02f, 3.86787131e-02f, -4.87726228e-03f, -4.95541561e-03f, 5.21117374e-02f,
  -2.35379953e-02f, -1.02556078e-02f, 5.27497660e-03f, -4.79939170e-02f, 1.96211208e-02f, -6.04763441e-03f, -7.79320225e-02f, -1.26076475e-01f, 1.97107848e-02f, -3.00865006e-02f,
  -5.43222427e-02f, -1.73308179e-02f, -2.83189863e-02f, 3.35601047e-02f, 5.20448841e-04f, -2.46929005e-02f, -3.23498845e-02f, -1.51489954e-02f, 1.73933746e-03f, 1.46563733e-02f,
  -1.35708563e-02f, 4.80301492e-02f, -2.34174971e-02f, -5.96161745e-02f, 4.29926515e-02f, -1.31770549e-02f, -2.33229832e-03f, 9.06428099e-02f, 2.30629835e-02f, 2.98494287e-02f,
  -1.71704933e-01f, -1.63998619e-01f, -5.58314137e-02f, 7.16329217e-02f, -7.39460513e-02f, -7.74396211e-02f, -5.72726242e-02f, -4.35737474e-03f, -1.22709991e-02f, 5.57102039e-02f,
  5.17777028e-03f, -5.08703254e-02f, 1.45812584e-02f, -5.23525998e-02f, 1.04328990e-02f, 1.58242490e-02f, -4.42024097e-02f, -4.59524281e-02f, -5.67900948e-02f, -3.65134440e-02f,
  -4.29725721e-02f, -8.67875963e-02f, 2.47178860e-02f, -3.86821330e-02f, -6.16111122e-02f, -6.39956503e-04f, 1.65946633e-02f, 3.91070396e-02f, -5.88065125e-02f, -2.69594584e-02f,
  -9.00878608e-02f, 1.59789249e-01f, -2.70376235e-01f, 1.21325523e-01f, -2.72311747e-01f, -3.34446162e-01f, -1.27828956e-01f, -4.40944023e-02f, 2.12145899e-03f, 2.50540853e-01f,
  8.35945904e-02f, 8.88414234e-02f, 1.87224656e-01f, -2.20205057e-02f, -1.70679033e-01f, -6.83189742e-03f, -1.42009199e-01f, -3.57562006e-02f, -3.77524272e-02f, 5.00471331e-02f,
  8.33468065e-02f, -3.88139412e-02f, -2.25103479e-02f, -1.17812775e-01f, -8.94238129e-02f, -3.46819572e-02f, 1.70327008e-01f, -9.09421742e-02f, -1.20511293e-01f, -1.53678119e-01f,
  -1.23714879e-01f, -2.32773945e-02f, 4.76229587e-04f, 5.48254661e-02f, -4.51005660e-02f, -5.07141724e-02f, -2.28895210e-02f, -7.29219317e-02f, -3.01108845e-02f, -5.47037683e-02f,
  8.46534967e-02f, -6.04805015e-02f, -3.17247137e-02f, 2.90528946e-02f, 3.25488788e-03f, 2.79600942e-03f, 7.77246850e-03f, -4.67364118e-02f, -4.31144573e-02f, -5.31124882e-02f,
  2.14787088e-02f, -1.60900295e-01f, 6.92168698e-02f, 1.50416372e-02f, -7.78367789e-03f, -1.60415336e-01f, -1.08488739e-01f, -4.19539623e-02f, -3.78845967e-02f, -5.26427329e-02f,
  -4.08148132e-02f, -7.76240602e-02f, 8.42688680e-02f, -4.98975553e-02f, 1.02579840e-01f, 1.60518158e-02f, 7.31889009e-02f, -4.41113003e-02f, 1.07319867e-02f, 3.39187006e-03f,
  -6.58749864e-02f, 1.13803603e-01f, -7.69732818e-02f, 4.60609980e-02f, 4.54361290e-02f, 1.30215794e-01f, 6.14020936e-02f, 1.53021514e-02f, -3.09356712e-02f, 2.44840998e-02f,
  4.96033840e-02f, 1.48851816e-02f, 7.23756477e-02f, -8.09190422e-03f, -5.57456398e-03f, 1.18694408e-02f, -3.77267301e-02f, -4.68759192e-03f, 4.19046432e-02f, 7.56570371e-03f,
  2.84314841e-01f, 1.88878551e-01f, 2.93544810e-02f, 5.58685139e-02f, 1.00272804e-01f, 7.63147697e-02f, -1.59531962e-02f, -1.65032875e-02f, 4.31522951e-02f, 9.24902782e-02f,
  -5.83543964e-02f, 9.66125354e-02f, 4.73688990e-02f, -3.45822349e-02f, -2.51100715e-02f, -2.86805965e-02f, 3.50666679e-02f, 5.56983352e-02f, 3.77092999e-03f, 8.83956254e-03f,
  1.09076530e-01f, 2.68386360e-02f, -1.80136204e-01f, 3.96191441e-02f, 1.66692026e-02f, 9.12678838e-02f, 7.41186887e-02f, -5.10129184e-02f, -3.82879674e-02f, -1.01212323e-01f
};

// L0_fan_Wp_bar (Shape: 10 x 120)
const int L0_fan_Wp_bar_rows = 10;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -2.64552206e-01f, -3.87471646e-01f, 3.24923385e-05f, -3.56949985e-01f, -1.09591588e-01f, -2.35647405e-03f, 2.04781458e-01f, -5.68404138e-01f, -4.87086207e-01f, -2.51068532e-01f,
  6.78347200e-02f, 1.60432264e-01f, 3.37394923e-01f, -1.51046902e-01f, 7.94975698e-01f, 3.17753881e-01f, -1.46387011e-01f, 1.59171149e-01f, -8.84710997e-02f, -4.63089526e-01f,
  -7.39597231e-02f, -2.37666309e-01f, 2.42826313e-01f, -3.85453314e-01f, -2.79065758e-01f, -2.62286663e-01f, 2.49857932e-01f, 2.25256458e-01f, -8.98191631e-02f, 2.34770760e-01f,
  -4.60771918e-01f, -5.23429096e-01f, -2.47900784e-01f, -8.00581574e-02f, -1.88294813e-01f, 6.84523657e-02f, 1.17025509e-01f, 2.95203805e-01f, 4.52671200e-02f, -5.94320856e-02f,
  1.00897953e-01f, -7.25857913e-02f, -1.34461597e-01f, 7.28374645e-02f, -1.72630817e-01f, -9.48938206e-02f, -9.04419124e-02f, -8.49353522e-02f, -1.45887360e-01f, -4.52480093e-02f,
  -1.11530706e-01f, -1.80578873e-01f, -3.10112238e-02f, 1.47705793e-01f, 6.89725131e-02f, -2.11346030e-01f, 7.80538842e-02f, 1.96266770e-01f, -3.05760186e-02f, -1.96620524e-01f,
  -1.15708564e-03f, 2.10664347e-01f, -8.95089358e-02f, -8.93834755e-02f, -4.77854088e-02f, -1.24909267e-01f, -1.33878700e-02f, 1.24354973e-01f, -1.19570754e-02f, -2.20084131e-01f,
  -1.11166276e-01f, -1.59333367e-02f, -1.88204810e-01f, 9.56883002e-03f, 9.10499971e-03f, -1.20930724e-01f, 6.37691393e-02f, -9.66225266e-02f, -6.05656989e-02f, -1.32825702e-01f,
  -4.55962168e-03f, -1.23974020e-02f, -3.47456448e-02f, 5.25869764e-02f, -1.94029018e-01f, 1.43561810e-01f, -1.95618212e-01f, -1.25945613e-01f, 4.39346693e-02f, 1.28135383e-01f,
  -4.66199934e-01f, -3.55183661e-01f, -6.31588995e-02f, -1.67137474e-01f, 6.88601211e-02f, 1.71121154e-02f, -3.30213308e-02f, -8.46495405e-02f, 1.14121884e-02f, -1.25542372e-01f,
  -1.38295144e-02f, -1.95607245e-02f, 1.38556361e-02f, 2.19026748e-02f, 1.08516581e-01f, -5.80080487e-02f, 7.40620075e-03f, 1.35230914e-01f, 1.84505600e-02f, -6.34125248e-02f,
  -5.77569753e-02f, 2.19107768e-03f, 1.27529517e-01f, -9.26305875e-02f, 5.76148070e-02f, 8.64170790e-02f, -5.56585565e-02f, -4.19228375e-02f, 1.29266456e-01f, 3.45841646e-02f,
  1.14999509e+00f, -5.44370294e-01f, -3.41308892e-01f, 3.70057821e-01f, 7.41617143e-01f, 4.61912602e-01f, 3.83600175e-01f, 5.04943728e-02f, 2.08049208e-01f, -4.56366181e-01f,
  1.06934994e-01f, -2.53659934e-01f, -3.66664439e-01f, 1.94285214e-01f, 5.42687595e-01f, -3.30642521e-01f, 2.67156422e-01f, 7.72772059e-02f, -2.98551098e-02f, 7.77444169e-02f,
  2.99552351e-01f, 4.93389606e-01f, -1.52652606e-01f, -2.07714196e-02f, 2.50391096e-01f, -2.65125126e-01f, -8.12370703e-02f, -2.79819936e-01f, -7.12541342e-02f, 1.33300096e-01f,
  1.29226804e-01f, 7.67029673e-02f, 7.64157325e-02f, -1.20450810e-01f, 1.09720146e-02f, 3.57404314e-02f, -1.13588288e-01f, -1.39087642e-04f, 1.44839779e-01f, -1.11158744e-01f,
  -8.62529576e-02f, 4.32455428e-02f, 8.27076584e-02f, 4.17015254e-02f, 9.02390108e-02f, 2.32317969e-02f, -5.50060207e-03f, -1.69052035e-02f, -1.87529624e-01f, -6.27353117e-02f,
  -2.28701122e-02f, -5.39044589e-02f, 1.17078438e-01f, -6.96022287e-02f, -5.22958599e-02f, 2.23043766e-02f, -2.87928861e-02f, -1.00881264e-01f, -7.14101493e-02f, 5.23502901e-02f,
  -1.01530954e-01f, 9.62609891e-03f, -2.55882163e-02f, 4.44915555e-02f, 2.51754769e-03f, -2.62325560e-03f, 9.23336819e-02f, -1.61421280e-02f, 4.40095142e-02f, 3.88516374e-02f,
  7.01847449e-02f, 4.90494296e-02f, 1.96247716e-02f, 5.94820790e-02f, 6.00010417e-02f, 6.70929579e-03f, 3.65119390e-02f, -6.45772666e-02f, -4.32207453e-05f, 4.62997798e-03f,
  4.85608727e-03f, 4.78858650e-02f, -1.28675789e-01f, -1.05028367e-02f, -2.59058308e-02f, 2.92807296e-02f, -4.01732028e-02f, -3.75430509e-02f, -2.37150472e-02f, 2.69777374e-03f,
  -2.02077538e-01f, -7.76356518e-01f, -1.87518433e-01f, 3.23357210e-02f, -1.02612160e-01f, 6.22776039e-02f, 1.69881955e-02f, 3.51577811e-02f, -1.97912037e-01f, 6.77340329e-02f,
  4.40188721e-02f, 2.71245856e-02f, -1.20347822e-02f, 9.24569145e-02f, -2.33842600e-02f, -9.58384853e-03f, -1.15632616e-01f, -1.25143781e-01f, 3.58377732e-02f, -2.01621838e-02f,
  -6.15206920e-02f, 4.67722118e-02f, 3.17315981e-02f, 1.22261778e-01f, 7.10857511e-02f, -3.88536304e-02f, 7.05668107e-02f, -7.42470548e-02f, -7.90490657e-02f, -7.12569132e-02f,
  2.46240169e-01f, -4.35485899e-01f, -1.88856959e-01f, -6.53211176e-02f, -3.92530039e-02f, 3.99221480e-02f, -4.68642920e-01f, 5.01761772e-02f, -5.76456249e-01f, 2.03210507e-02f,
  2.35996813e-01f, -4.92288113e-01f, -1.62964180e-01f, -2.54446752e-02f, 1.38023660e-01f, -3.40660363e-01f, 1.09086752e-01f, -5.63412420e-02f, -2.27524534e-01f, 2.25094453e-01f,
  7.86719620e-02f, 3.74891400e-01f, -1.74921066e-01f, 3.65805179e-01f, 8.84642601e-02f, 2.38435030e-01f, 5.45042515e-01f, 1.77407801e-01f, 3.67929250e-01f, -2.24318076e-02f,
  -1.13782890e-01f, 2.51899902e-02f, -1.68688416e-01f, -4.97519448e-02f, 1.51983663e-01f, 2.47036606e-01f, 1.00335978e-01f, -3.07916310e-02f, -6.84485435e-02f, -7.91211724e-02f,
  -2.36959737e-02f, 8.01584199e-02f, -3.92165594e-02f, 4.79596518e-02f, -9.35793743e-02f, -1.94349229e-01f, -1.56206995e-01f, -7.68155977e-02f, -2.51736224e-01f, 4.75126207e-02f,
  -1.17441855e-01f, -6.75450265e-03f, 4.87369448e-02f, 7.66667351e-02f, 1.61123313e-02f, 8.67089182e-02f, 4.48824763e-02f, 3.38522121e-02f, -2.97710393e-02f, 3.14377248e-02f,
  1.90138042e-01f, -5.12754824e-03f, 2.44400650e-02f, -1.83341086e-01f, -2.82581560e-02f, 3.74915786e-02f, -1.17457226e-01f, 2.33074860e-03f, -1.02374256e-01f, 4.04879153e-02f,
  -2.79624294e-02f, 2.74368259e-03f, 1.15230419e-01f, 5.54780029e-02f, 5.37561439e-02f, -9.54047963e-03f, -9.27310884e-02f, 9.84638231e-04f, -4.24124822e-02f, -1.56995997e-01f,
  -3.89540456e-02f, 7.46007860e-02f, -1.29890116e-02f, 3.36158983e-02f, 2.43665744e-02f, 1.88264370e-01f, 1.33912504e-01f, 3.65739763e-02f, -3.80533040e-02f, -2.63376273e-02f,
  8.58568549e-02f, 3.16452503e-01f, -8.51945207e-02f, -5.87460771e-02f, -9.26316679e-02f, 1.25006586e-02f, -3.67978476e-02f, -1.01300851e-01f, 1.86303630e-01f, 4.86590117e-02f,
  2.29290709e-01f, -1.55283451e-01f, 1.64729133e-01f, -9.80438665e-03f, -1.87177937e-02f, 2.02376887e-01f, 2.03929275e-01f, 2.71588825e-02f, 9.14537087e-02f, 1.56517863e-01f,
  2.00889096e-01f, 1.27960248e-02f, 9.42873284e-02f, -2.62450278e-01f, -6.03981363e-03f, 1.15853369e-01f, 3.91104594e-02f, 1.69990018e-01f, 9.11773965e-02f, -1.90264881e-01f,
  -2.25846469e-01f, 5.77315986e-01f, 2.50086665e-01f, -1.15585230e-01f, 1.65885165e-02f, -5.30211747e-01f, -3.28745127e-01f, 1.79169878e-01f, 4.17869817e-03f, 4.22401845e-01f,
  -6.57599866e-02f, 5.00584006e-01f, -1.31572261e-01f, -1.70296133e-02f, -7.64036298e-01f, -5.24318695e-01f, -5.95217645e-01f, -1.62983939e-01f, -1.48487926e-01f, -9.50120762e-03f,
  -2.81823725e-01f, -4.08393860e-01f, -3.03912818e-01f, 3.45747508e-02f, 1.86422944e-01f, 3.16454142e-01f, -1.46092996e-01f, 1.66834444e-01f, 2.20573753e-01f, -1.14846058e-01f,
  -1.88679695e-01f, 3.17074984e-01f, 3.15499336e-01f, 1.85746402e-01f, -4.10587788e-02f, 3.20554264e-02f, 6.64491653e-02f, 2.17765220e-03f, 2.90941726e-03f, 5.22511341e-02f,
  1.75597206e-01f, 1.47140641e-02f, -1.84277017e-02f, 1.00207426e-01f, 2.48890847e-01f, 1.88230291e-01f, 5.20786382e-02f, -2.38412172e-02f, 2.01176688e-01f, -6.35141432e-02f,
  2.20004860e-02f, 8.89465883e-02f, 4.39482853e-02f, -7.54810721e-02f, 5.58616333e-02f, 7.11033866e-02f, 2.41571665e-02f, 5.37560433e-02f, -4.26496640e-02f, 1.21379402e-02f,
  -1.30519390e-01f, -5.40103987e-02f, -1.15890570e-01f, 6.38933927e-02f, -2.31405776e-02f, 2.14549508e-02f, 2.21590865e-02f, 6.04724512e-02f, -4.09925655e-02f, -3.30252610e-02f,
  1.06154084e-02f, 1.48827806e-01f, 1.77980233e-02f, -2.76478250e-02f, -6.89802542e-02f, -5.71245700e-02f, -5.76050207e-02f, 7.60187730e-02f, -1.39522880e-01f, 5.40082939e-02f,
  6.88328594e-02f, -9.26130638e-02f, 7.45011270e-02f, -3.23468409e-02f, -3.50096524e-02f, 6.08256236e-02f, 8.50315839e-02f, 1.81369483e-01f, -1.78240448e-01f, 3.70572694e-02f,
  -3.39053601e-01f, 1.26446158e-01f, 4.26574759e-02f, 3.16187814e-02f, -6.80692196e-02f, 2.24877149e-02f, -4.31691632e-02f, 7.08573684e-02f, -3.38655412e-02f, -1.02651291e-01f,
  2.39188075e-02f, 1.96885914e-02f, 2.78335903e-02f, -2.89908648e-02f, -1.34042829e-01f, -1.46813273e-01f, -6.53227940e-02f, -1.80827826e-02f, -1.48198664e-01f, 1.33911530e-02f,
  2.21523102e-02f, 1.94103969e-03f, -1.27521083e-01f, -1.20020568e-01f, -2.82536559e-02f, 5.34860864e-02f, -1.05188869e-01f, 1.14536770e-02f, 6.01264127e-02f, -2.11380888e-02f,
  1.29308760e-01f, -2.64980167e-01f, 3.18983704e-01f, -4.48882788e-01f, 2.25131735e-02f, 6.56476766e-02f, 8.54936335e-03f, -4.49032396e-01f, -4.81314659e-01f, -3.43121231e-01f,
  -3.08217674e-01f, 1.49310743e-02f, 3.55270922e-01f, -4.34936702e-01f, 7.05149710e-01f, 1.85134202e-01f, -3.25191408e-01f, -2.40860507e-01f, -3.00214142e-01f, -3.09884369e-01f,
  -8.41311812e-02f, -4.62384850e-01f, 4.11939144e-01f, -3.90819848e-01f, -2.12204456e-01f, -3.00514847e-01f, -1.24917068e-01f, -3.65029573e-02f, -2.47143999e-01f, -1.84597436e-03f,
  9.52165946e-02f, -1.59515738e-02f, 9.87448618e-02f, 1.74438119e-01f, 1.28343776e-02f, 1.01295471e-01f, -1.02780934e-03f, 2.09018007e-01f, -9.65317786e-02f, 6.81577846e-02f,
  1.08057875e-02f, 1.16152532e-01f, -1.45431191e-01f, 5.25349379e-02f, -1.59354106e-01f, 1.82110462e-02f, 3.77092212e-02f, 8.16796161e-03f, 5.55995889e-02f, 4.57911789e-02f,
  1.70607597e-01f, 7.05219060e-02f, -1.58855200e-01f, -8.34580809e-02f, -4.94653173e-02f, -1.16826631e-01f, -3.59655507e-02f, 1.61905855e-01f, 4.61137742e-02f, -8.50117132e-02f,
  -9.80997309e-02f, -2.05968007e-01f, 1.27471879e-01f, 3.62886675e-02f, -9.85005945e-02f, -7.39140883e-02f, -1.07903086e-01f, -8.36649165e-03f, -1.27492994e-01f, 4.11092788e-02f,
  -3.64130512e-02f, -8.82370695e-02f, -1.85673777e-03f, -7.85786211e-02f, -1.29745737e-01f, -4.71927896e-02f, 1.11029983e-01f, 3.55055816e-02f, -5.41455112e-02f, 4.63446639e-02f,
  3.03158015e-02f, 3.97952944e-02f, -6.29373565e-02f, -3.79237682e-02f, 8.77401307e-02f, 4.15341556e-03f, -6.09559119e-02f, 1.04581915e-01f, -1.84276700e-02f, 3.09835095e-02f,
  -4.89713661e-02f, -2.70340919e-01f, 6.74842224e-02f, 6.25949204e-02f, 1.12505525e-01f, 1.19691096e-01f, 3.03632561e-02f, -1.65997878e-01f, -7.68600926e-02f, -5.00224046e-02f,
  -1.31029218e-01f, 3.20488550e-02f, 4.14654054e-02f, -2.57862926e-01f, -1.01891473e-01f, -4.82033156e-02f, 4.10296619e-02f, -1.07788585e-01f, 3.51052321e-02f, -1.34611979e-01f,
  4.03335951e-02f, 9.05154496e-02f, 1.36781067e-01f, -1.39919385e-01f, -1.40106753e-01f, 2.34552354e-01f, -1.74257174e-01f, 7.83327520e-02f, 4.83592823e-02f, -4.70083803e-02f,
  -1.41933966e+00f, 3.06711078e-01f, -4.13550138e-01f, -2.36527130e-01f, -1.20246671e-01f, -1.82007164e-01f, 7.52544962e-03f, -2.76559927e-02f, -1.33093879e-01f, 2.18851149e-01f,
  -1.67996921e-02f, -2.56942511e-01f, 2.82745004e-01f, 5.88189140e-02f, -4.61526394e-01f, 3.63468856e-01f, -2.30351835e-01f, -1.58190578e-01f, 1.80925861e-01f, -3.07729185e-01f,
  -1.60487041e-01f, 9.27713513e-02f, -1.03401825e-01f, 3.93618226e-01f, -4.45112795e-01f, -8.52551982e-02f, -1.52194187e-01f, 2.49410883e-01f, -2.32089162e-01f, -1.39067948e-01f,
  -4.74018037e-01f, -2.18500927e-01f, -1.36297956e-01f, -2.11136460e-01f, -2.49709904e-01f, -1.34144962e-01f, -1.55175671e-01f, 6.97853714e-02f, -3.44744772e-02f, -3.54420617e-02f,
  -2.66227126e-03f, -1.46830054e-02f, 7.22077256e-03f, 4.32735160e-02f, -6.50873333e-02f, 2.96259904e-03f, 1.29013896e-01f, -1.08199991e-01f, -3.39921825e-02f, 4.62901555e-02f,
  1.38319209e-01f, 1.02049783e-02f, -6.05878681e-02f, -3.45015489e-02f, 3.33874300e-02f, 2.05320809e-02f, 2.32527684e-02f, -8.94186348e-02f, -2.31774896e-01f, -9.12876576e-02f,
  4.01792452e-02f, -3.48393545e-02f, 9.07593891e-02f, -6.66338652e-02f, -1.52764274e-02f, -1.20263956e-02f, -5.43875769e-02f, -2.98304316e-02f, -2.90255751e-02f, 5.79892658e-02f,
  -1.12250865e-01f, -1.20101392e-01f, -3.88148539e-02f, 6.39489889e-02f, 3.30227688e-02f, -2.89126672e-02f, 1.39521193e-02f, -4.73005250e-02f, 2.65163202e-02f, -3.07874512e-02f,
  7.58312792e-02f, -5.58550693e-02f, 5.94608579e-03f, -4.30783741e-02f, -7.40729719e-02f, 4.68174443e-02f, 5.99892177e-02f, -6.56623244e-02f, 5.63107505e-02f, -7.86322728e-02f,
  -5.89259088e-01f, -5.75547874e-01f, 7.78381228e-02f, -1.23633109e-01f, -3.70098576e-02f, -3.17414408e-04f, 7.03564808e-02f, -6.08493052e-02f, -3.31681892e-02f, -9.17738825e-02f,
  -4.13233154e-02f, -8.11392441e-03f, -2.32931927e-01f, 9.23812166e-02f, 6.41132072e-02f, 1.13327466e-02f, 2.72503477e-02f, -3.40999942e-03f, -1.26315996e-01f, -1.68718174e-02f,
  -1.67635337e-01f, 6.93572173e-03f, 1.60950378e-01f, 5.21190204e-02f, 4.32595378e-03f, -4.21641804e-02f, -7.11833835e-02f, 1.11271538e-01f, -1.13046333e-01f, 3.04749180e-02f,
  -1.63068138e-02f, -1.06678523e-01f, 9.98897105e-02f, 6.16511703e-01f, -1.27628073e-01f, -6.67803466e-01f, -6.53903961e-01f, 1.26645882e-02f, -6.58861846e-02f, -3.54465187e-01f,
  -7.06220791e-02f, 2.48720303e-01f, -5.62247813e-01f, 6.51012242e-01f, 5.78544378e-01f, -3.00521165e-01f, 2.79291391e-01f, 7.92379007e-02f, -2.50601731e-02f, -8.32742639e-03f,
  3.25453073e-01f, 1.90945625e-01f, 5.04807830e-01f, 2.39835292e-01f, 4.47066985e-02f, 3.36679131e-01f, 5.62014043e-01f, -1.45697355e-01f, 6.63531542e-01f, 1.90730274e-01f,
  -1.34377450e-01f, -5.99131221e-04f, 9.69038084e-02f, 1.13890879e-01f, -9.01385769e-02f, -1.97977990e-01f, -2.75823660e-02f, -6.12818915e-03f, 3.65947373e-02f, 6.98526343e-03f,
  -1.30020142e-01f, 1.99200287e-01f, 1.96686953e-01f, 7.52404556e-02f, -7.04029500e-02f, 1.93867534e-01f, -9.43845790e-03f, -8.15161988e-02f, 1.18957059e-02f, -8.92362818e-02f,
  -1.13420956e-01f, -8.38961527e-02f, 4.46798690e-02f, -1.88362389e-03f, 1.39616534e-01f, 3.02644093e-02f, 8.61176699e-02f, 1.14117697e-01f, 1.83269028e-02f, 3.27622667e-02f,
  -2.25617196e-02f, -6.39380664e-02f, 3.51419263e-02f, 4.11003195e-02f, -5.93539812e-02f, 4.44005243e-02f, 8.19162279e-02f, -7.98034146e-02f, 2.33492758e-02f, 4.11456712e-02f,
  -1.62119605e-02f, 5.86783178e-02f, 4.56938483e-02f, 2.62041781e-02f, -6.53754547e-02f, -4.43719141e-02f, 4.41700295e-02f, 5.29821031e-02f, -5.67950681e-02f, -5.67872683e-03f,
  2.24108808e-02f, 5.00015207e-02f, -1.94523545e-05f, -3.50798666e-03f, 4.28135842e-02f, -7.74554163e-02f, 1.79490950e-02f, -8.81949142e-02f, 6.99397773e-02f, -1.28940240e-01f,
  -4.51503396e-02f, 2.40352005e-01f, -1.97219234e-02f, 7.05303848e-02f, 8.12034458e-02f, 8.14572535e-03f, 7.97504038e-02f, 4.04887348e-02f, 9.20606218e-03f, -1.44846320e-01f,
  -3.56485844e-02f, -1.22797377e-01f, -6.36467561e-02f, -6.51065856e-02f, 1.29386574e-01f, -1.08205661e-01f, 4.08554822e-02f, 1.29472926e-01f, 1.02415964e-01f, 7.98667595e-02f,
  3.68959294e-03f, -1.53956011e-01f, -1.06135003e-01f, -7.97212357e-04f, 2.43534823e-03f, -2.08079934e-01f, 7.88933598e-03f, -2.17556916e-02f, -3.88368615e-03f, 7.29142800e-02f,
  5.98506987e-01f, 3.11275542e-01f, 3.32145333e-01f, 3.33585382e-01f, 3.16228531e-02f, -2.05682680e-01f, -1.80350155e-01f, 9.11036432e-02f, -6.00634277e-01f, 3.83005179e-02f,
  -1.14681542e-01f, 2.41468042e-01f, -2.62149930e-01f, -1.06904820e-01f, -4.38815415e-01f, -6.02137208e-01f, -5.08955531e-02f, 1.37990683e-01f, -2.74322361e-01f, 3.26807827e-01f,
  4.52706553e-02f, -2.00625330e-01f, 1.28159687e-01f, 1.01846159e-01f, 2.55259782e-01f, 6.25400960e-01f, 3.94850880e-01f, 3.59779671e-02f, 3.83030951e-01f, -3.19205076e-02f,
  -1.33399576e-01f, -1.56880081e-01f, 1.23265974e-01f, -1.82851031e-01f, 2.60770112e-01f, 1.37987003e-01f, 2.11634442e-01f, -6.78324746e-03f, -4.73903120e-02f, 3.23320329e-02f,
  7.50209764e-02f, -6.17291629e-02f, -3.63105386e-02f, -8.48893225e-02f, 6.16686977e-02f, 3.97686511e-02f, 1.54988095e-01f, 6.47771582e-02f, 6.24510227e-03f, 2.49746535e-03f,
  6.74091130e-02f, 2.19002396e-01f, 1.17046915e-01f, -7.72329187e-03f, 1.56942636e-01f, -3.58383283e-02f, -8.27281643e-03f, 2.10282281e-01f, 4.80116270e-02f, 1.43560961e-01f,
  -3.49351652e-02f, -2.70693190e-02f, -4.86411154e-02f, -2.03221232e-01f, 2.09778082e-03f, -1.66363955e-01f, -1.23602167e-01f, -5.19683854e-05f, 4.22330536e-02f, -8.52076486e-02f,
  6.49452433e-02f, 5.59834838e-02f, -2.90561408e-01f, 3.10862418e-02f, 1.57295436e-01f, 3.69231142e-02f, 2.34564743e-03f, -5.63077293e-02f, 1.01254664e-01f, 1.14135809e-01f,
  -1.55213967e-01f, -3.32140774e-02f, 2.73228902e-03f, 8.72750655e-02f, -1.56110004e-01f, 6.59647360e-02f, -6.16472699e-02f, -5.44481166e-02f, -2.06371304e-02f, 2.96821762e-02f,
  -1.99926756e-02f, 1.61230743e-01f, -7.30649456e-02f, 8.15444440e-03f, -5.08951917e-02f, -1.32858139e-02f, -1.67755634e-01f, 2.50428487e-02f, 5.28022163e-02f, -1.01325803e-01f,
  2.33898908e-01f, 1.60697311e-01f, 1.17078684e-01f, -8.02458525e-02f, -2.60881092e-02f, -3.11887395e-02f, 1.16734266e-01f, 3.12268399e-02f, 1.88927680e-01f, 1.65215001e-01f,
  1.67663366e-01f, 3.61421593e-02f, 3.48641910e-02f, 5.73209971e-02f, 1.02333151e-01f, 3.18139903e-02f, 6.49092570e-02f, -1.55404788e-02f, 4.90565365e-03f, 7.49187097e-02f,
  -2.80908614e-01f, 4.67948169e-01f, -5.53064108e-01f, 3.64156216e-01f, -3.46991003e-01f, 5.82664907e-01f, 6.45232141e-01f, -4.94230725e-02f, 1.34485394e-01f, 7.31887102e-01f,
  2.61589199e-01f, 9.91695747e-02f, 7.68807456e-02f, 9.84918833e-01f, 3.59737873e-01f, 5.59373200e-01f, 7.93176174e-01f, 4.60221320e-01f, -1.48219571e-01f, 2.04610098e-02f,
  -6.82167858e-02f, 5.81092954e-01f, 1.10190203e-02f, -1.24708153e-01f, -5.45819523e-03f, -5.66891551e-01f, -2.03087777e-02f, -4.89295423e-01f, 3.96562219e-01f, 6.57011122e-02f,
  1.68349832e-01f, 7.43828043e-02f, -1.66218296e-01f, -5.10622784e-02f, -1.65013999e-01f, -5.59962578e-02f, -2.82267947e-02f, -1.19959086e-01f, -2.08298072e-01f, 3.52488272e-02f,
  -6.56552985e-02f, -5.13495095e-02f, 1.63868770e-01f, -2.74349991e-02f, -7.51838684e-02f, -1.45880669e-01f, -4.48680744e-02f, -3.19068395e-02f, 3.79375890e-02f, 2.02668598e-03f,
  -2.59822249e-01f, 3.95645760e-03f, -1.05538755e-03f, 1.35917991e-01f, -1.14447422e-01f, 8.61637741e-02f, 1.22420408e-01f, -1.03133842e-01f, 6.37382567e-02f, 1.30361378e-01f,
  5.71025461e-02f, 9.35273543e-02f, -2.15511099e-02f, 7.10812584e-02f, 3.74797769e-02f, -8.75218958e-03f, 1.06910810e-01f, 2.71861977e-03f, -1.07898980e-01f, 1.40747502e-01f,
  -1.75320003e-02f, -5.98994419e-02f, 1.56613458e-02f, 6.22630157e-02f, 2.38356162e-02f, -2.18874612e-03f, -1.27625182e-01f, 1.43502960e-02f, -3.34199108e-02f, 2.85310205e-04f,
  1.49235111e-02f, 9.89019573e-02f, -4.90943342e-02f, -2.20210832e-02f, 9.80180055e-02f, -1.34265631e-01f, 1.49733707e-01f, 6.13505840e-02f, -7.40565732e-02f, -9.04102623e-02f,
  2.84237444e-01f, 4.15128201e-01f, 8.35407898e-02f, 1.20641319e-02f, 6.11889586e-02f, -4.01225593e-03f, 1.11936532e-01f, 1.05236761e-01f, -1.04360655e-02f, 5.91596439e-02f,
  -1.33224368e-01f, -3.03334240e-02f, 1.78697631e-02f, -8.83740783e-02f, 3.80432867e-02f, 2.19376430e-01f, 1.33372828e-01f, -3.48855667e-02f, 1.74274147e-01f, -7.20749646e-02f,
  -2.79694144e-02f, -3.75148766e-02f, 3.69015224e-02f, -1.22823529e-01f, 5.54897860e-02f, 3.03972904e-02f, -1.64294161e-03f, -1.74524978e-01f, -5.68784140e-02f, 8.21426660e-02f,
  2.47639850e-01f, -1.03316847e-02f, 1.08057417e-01f, 2.12827623e-01f, -2.97541171e-01f, -2.37272099e-01f, -7.17202201e-02f, 4.24723029e-02f, 8.81985009e-01f, -6.82650805e-02f,
  -4.21425164e-01f, 3.98254186e-01f, -4.44831438e-02f, -3.77036512e-01f, 5.20670593e-01f, 2.91362822e-01f, 8.37137625e-02f, 1.49144903e-01f, 2.56863713e-01f, 1.71162095e-02f,
  1.40712693e-01f, -4.67694521e-01f, -5.50427258e-01f, -5.16371965e-01f, -6.19668305e-01f, -1.09603390e-01f, -5.34892380e-01f, -1.96345106e-01f, -5.01726210e-01f, -1.80365205e-01f,
  -1.23305619e-02f, 9.44303423e-02f, -1.80122554e-01f, 8.71229693e-02f, -1.28300980e-01f, -7.72284940e-02f, 2.56691501e-02f, -8.53984207e-02f, 7.80888870e-02f, 8.76759961e-02f,
  1.85923830e-01f, 9.28604826e-02f, 4.41439524e-02f, 8.92067270e-04f, 4.90350425e-02f, 7.10800365e-02f, 7.64382035e-02f, -2.73780674e-01f, -7.22161308e-02f, -8.06987286e-02f,
  -3.54965515e-02f, -5.01562841e-02f, -4.20859158e-02f, 8.84632245e-02f, -3.09015345e-02f, 1.21223070e-01f, 8.16211998e-02f, -4.30438332e-02f, 3.67038680e-04f, 2.21662536e-01f,
  6.34895489e-02f, -9.81969479e-03f, -7.00274184e-02f, -1.57898054e-01f, -3.86541709e-02f, -1.61878079e-01f, -2.49034502e-02f, -9.31031331e-02f, 1.28782704e-01f, 4.27290089e-02f,
  -3.57311917e-03f, 3.91556993e-02f, -4.55261320e-02f, 4.43689004e-02f, -8.16424638e-02f, 8.45542401e-02f, -2.87492368e-02f, 4.80199978e-02f, 1.15431771e-01f, -1.11420073e-01f,
  1.17575534e-01f, 1.15636364e-01f, -1.34258479e-01f, -1.13787286e-01f, -9.69427545e-03f, 3.49490158e-02f, 3.89903300e-02f, -1.55014824e-02f, -1.60182759e-01f, -9.10859630e-02f,
  1.70870304e-01f, 3.51462394e-01f, -3.18489596e-02f, -2.65170392e-02f, 4.47354205e-02f, -3.64825688e-02f, 5.07080518e-02f, 1.14938118e-01f, 1.16915219e-01f, 2.23189592e-02f,
  -4.54092398e-02f, 3.07685211e-02f, 5.73336370e-02f, -1.46098537e-02f, -2.45039631e-02f, -6.70542791e-02f, 8.20593983e-02f, 1.23518266e-01f, 7.00030923e-02f, -6.59424812e-02f,
  -9.48430896e-02f, 8.73624161e-02f, 1.07501931e-01f, -1.38014212e-01f, -5.29908724e-02f, -9.83433127e-02f, 5.53869968e-03f, 7.13453069e-02f, -1.68671235e-02f, -6.98707849e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 10)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 10;
const float L0_fan_Bp_bar_data[] = {
  6.01210952e-01f, 7.17080832e-01f, 2.78820872e-01f, 6.82962298e-01f, 5.76556563e-01f, 5.87504208e-01f, -8.39282274e-02f, 7.94250488e-01f, 5.62589645e-01f, 4.79662001e-01f
};

// L1_fan_Wp (Shape: 3 x 16)
const int L1_fan_Wp_rows = 3;
const int L1_fan_Wp_cols = 16;
const float L1_fan_Wp_data[] = {
  5.21967337e-02f, -6.98620155e-02f, -2.02499986e-01f, 6.00982793e-02f, -4.96873289e-01f, 3.74036729e-01f, 4.15614583e-02f, -4.55555469e-01f, -3.42980437e-02f, 8.68544951e-02f,
  6.85046911e-02f, 2.23275349e-01f, 3.63026589e-01f, -4.37619209e-01f, 3.78184527e-01f, -4.76512685e-02f, 3.30201209e-01f, 2.56931663e-01f, -7.17232153e-02f, -1.91636667e-01f,
  -3.47487271e-01f, 2.36776918e-01f, -2.73219526e-01f, -2.90623307e-02f, 1.82114214e-01f, 2.03761339e-01f, 9.31117311e-02f, 3.96484017e-01f, -3.86147231e-01f, -3.80986392e-01f,
  2.65241891e-01f, -5.70790291e-01f, 8.10738056e-05f, -1.71650182e-02f, 2.35340789e-01f, -2.87056804e-01f, -3.91442090e-01f, 4.40872192e-01f, -1.66228518e-01f, -5.83861694e-02f,
  4.63881224e-01f, -4.76690531e-02f, -2.98210293e-01f, -1.59525201e-01f, 1.42581388e-01f, 1.75035492e-01f, 4.97359127e-01f, -8.93923566e-02f
};

// L1_fan_Wp_bar (Shape: 10 x 16)
const int L1_fan_Wp_bar_rows = 10;
const int L1_fan_Wp_bar_cols = 16;
const float L1_fan_Wp_bar_data[] = {
  7.60941684e-01f, 5.65026402e-01f, 5.89333951e-01f, -8.38458478e-01f, -4.54230398e-01f, -2.72677869e-01f, 6.39360189e-01f, -6.90639734e-01f, 2.12796498e-02f, 9.58990097e-01f,
  8.02294493e-01f, 1.47354126e+00f, -3.96219969e-01f, -1.42812818e-01f, 2.67201990e-01f, 3.50703627e-01f, -4.73399639e-01f, -3.77930522e-01f, 6.77751362e-01f, -3.60941738e-01f,
  -5.36810994e-01f, 8.29454422e-01f, -1.19954638e-01f, -5.95640063e-01f, 6.60008132e-01f, 7.33381450e-01f, 8.07946548e-03f, -3.12128346e-02f, 3.70400518e-01f, 9.53364909e-01f,
  -1.73995525e-01f, 1.35414064e-01f, -5.20981699e-02f, 6.11619912e-02f, 2.52451390e-01f, 1.21095598e+00f, -2.40582392e-01f, 1.16021168e+00f, 6.12199366e-01f, -1.86770968e-02f,
  1.33745506e-01f, -6.49828255e-01f, 5.77948570e-01f, -3.40284556e-01f, 2.87470520e-01f, 2.63144702e-01f, 9.41382051e-01f, 7.90169775e-01f, 6.72356486e-01f, 5.61742127e-01f,
  1.68608859e-01f, 4.06918019e-01f, 1.10860837e+00f, -6.06233835e-01f, 5.97379863e-01f, -3.78748238e-01f, -5.10919154e-01f, 4.00284529e-01f, 6.36740804e-01f, 1.80906847e-01f,
  1.37748861e+00f, 3.78929317e-01f, -3.24572057e-01f, 1.22357130e+00f, -9.58411396e-02f, -4.78938580e-01f, 1.50237322e-01f, -2.35150605e-01f, -1.10042298e+00f, 3.38952959e-01f,
  -1.95467830e-01f, 7.76163042e-01f, 5.57035565e-01f, 1.01191044e+00f, -3.49685341e-01f, 1.00314833e-01f, 8.93212795e-01f, 8.47686231e-01f, -1.15464419e-01f, 1.41138077e-01f,
  5.41439116e-01f, 2.70269096e-01f, 2.33249009e-01f, 6.54076099e-01f, -4.48973961e-02f, 5.24290465e-02f, -1.05424356e+00f, 9.30415154e-01f, 7.19351947e-01f, -5.81654489e-01f,
  -2.39127651e-01f, -6.99168980e-01f, 4.60928470e-01f, 1.99404940e-01f, 5.01659513e-01f, 7.24905252e-01f, 1.62378103e-01f, 8.93813014e-01f, 2.46352613e-01f, -1.08108807e+00f,
  -6.32143915e-01f, 2.20161930e-01f, 3.64859343e-01f, 3.70099932e-01f, 9.44397092e-01f, -4.56350237e-01f, 1.08956262e-01f, -6.62145317e-02f, 9.49870199e-02f, 5.04015326e-01f,
  1.32698596e+00f, -4.11280155e-01f, 7.58715689e-01f, 1.00475624e-01f, 2.19555914e-01f, -1.08341835e-01f, 9.76205468e-01f, -7.14842975e-01f, -3.02843750e-01f, 8.93415093e-01f,
  -7.16751397e-01f, 2.21213818e-01f, -2.62576520e-01f, -4.66403186e-01f, 7.90103227e-02f, 4.80495870e-01f, 1.84283823e-01f, 8.85092974e-01f, 6.82313979e-01f, 4.61075485e-01f,
  1.00642991e+00f, -2.17720284e-03f, 1.19459879e+00f, -6.89354777e-01f, 2.33295083e-01f, 9.23110604e-01f, -3.44618022e-01f, 2.31230974e-01f, 5.72378874e-01f, -2.77766228e-01f,
  -9.28144157e-01f, 6.56604350e-01f, -9.42576602e-02f, -1.75608963e-01f, -3.76438439e-01f, -3.78903270e-01f, -3.15523237e-01f, 4.57983881e-01f, -4.42473516e-02f, -6.52052701e-01f,
  1.17151165e+00f, 1.10986352e+00f, -4.82549481e-02f, -3.33760500e-01f, 5.25622606e-01f, -3.19925338e-01f, 3.34702224e-01f, 6.59705745e-03f, -5.59088230e-01f, 1.56475231e-01f
};

// L1_fan_Bp_bar (Shape: 1 x 10)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 10;
const float L1_fan_Bp_bar_data[] = {
  9.15557384e-01f, 4.48382705e-01f, 1.48087004e-02f, 4.23973769e-01f, 1.47895113e-01f, 5.85362948e-02f, 4.65381593e-01f, 3.30207199e-01f, 5.55242240e-01f, -1.16234170e-02f
};

// L2_linear_W (Shape: 12 x 16)
const int L2_linear_W_rows = 12;
const int L2_linear_W_cols = 16;
const float L2_linear_W_data[] = {
  -5.36173761e-01f, -4.87654358e-01f, -4.84012574e-01f, -4.63036336e-02f, -2.09692996e-02f, 5.98802805e-01f, 5.26240528e-01f, -7.30605185e-01f, 2.34548539e-01f, -7.00727940e-01f,
  -1.05439126e+00f, -7.20492482e-01f, 8.70470285e-01f, -8.72527599e-01f, -7.38191009e-01f, -2.26558700e-01f, -8.32254626e-03f, -1.17311239e-01f, -1.41009763e-01f, 2.92274654e-01f,
  1.08445728e+00f, -4.57416661e-02f, -6.61250353e-01f, -1.33572981e-01f, 4.43754166e-01f, -1.30883503e+00f, -1.83104873e-01f, 5.56155682e-01f, 6.69850528e-01f, -2.56614000e-01f,
  4.92168635e-01f, -3.61245990e-01f, 1.94429560e-03f, -1.82352111e-01f, -1.82243928e-01f, -4.34326410e-01f, -5.14382422e-01f, 1.93926543e-01f, -7.27800131e-01f, -6.60098195e-01f,
  -6.63642824e-01f, -9.53056961e-02f, 6.43673480e-01f, 3.55431259e-01f, 3.77659321e-01f, 3.10858399e-01f, -1.08037293e+00f, 6.75637960e-01f, -5.00823498e-01f, -7.81097651e-01f,
  4.49167997e-01f, 6.37286663e-01f, -1.22284554e-01f, -5.46323732e-02f, 8.58770430e-01f, 1.27000466e-01f, -8.33203971e-01f, -3.04480553e-01f, 4.62417156e-01f, -5.40272519e-02f,
  -1.23189676e+00f, -5.05605042e-01f, -1.25079584e+00f, -3.89106780e-01f, 8.39971364e-01f, 4.50344592e-01f, 2.62546390e-01f, 2.72999853e-01f, 1.14921570e+00f, -5.67784727e-01f,
  7.58851409e-01f, -7.26114035e-01f, -1.10047972e+00f, 5.91939509e-01f, -9.57428396e-01f, -7.02949405e-01f, -5.66435717e-02f, -2.06587479e-01f, 6.20466948e-01f, -3.52860153e-01f,
  1.56675860e-01f, 5.07937849e-01f, 4.28654134e-01f, 4.38853115e-01f, -4.53156561e-01f, 8.46224189e-01f, 5.79842702e-02f, -9.07893956e-01f, 3.33942145e-01f, 6.00488663e-01f,
  -8.30546856e-01f, 2.38082469e-01f, -9.30006579e-02f, 7.64058352e-01f, -2.34563410e-01f, -1.15801346e+00f, -2.77331531e-01f, 9.86454487e-02f, 4.51836467e-01f, -2.07173958e-01f,
  8.34263023e-03f, -6.92358732e-01f, -1.16755128e+00f, -7.87754476e-01f, -3.82637560e-01f, -1.42784372e-01f, 6.37229979e-02f, 6.46011174e-01f, -9.85703170e-01f, 8.51736546e-01f,
  6.23215139e-01f, 2.77063310e-01f, -2.92514443e-01f, 3.83735052e-03f, -3.41268927e-02f, 2.20711038e-01f, -2.89831817e-01f, -2.56879598e-01f, 2.60594606e-01f, -1.22554801e-01f,
  7.37524271e-01f, 5.43757260e-01f, -1.31154686e-01f, -1.74538881e-01f, -1.06536555e+00f, -9.27226126e-01f, -9.66513693e-01f, 3.78609657e-01f, 1.29674062e-01f, -1.29611820e-01f,
  -3.56280416e-01f, 3.46720040e-01f, -6.41271949e-01f, 4.80859168e-02f, -9.07438457e-01f, 5.49308479e-01f, 4.62866217e-01f, 3.30082774e-01f, 4.17088479e-01f, 3.38155270e-01f,
  -2.46170536e-01f, -8.20569873e-01f, -7.96709776e-01f, -8.06764901e-01f, 2.46215463e-01f, -2.82288343e-02f, -1.96797669e-01f, -5.38928866e-01f, -5.95284224e-01f, -2.84029007e-01f,
  -4.99762654e-01f, -5.89389384e-01f, 2.25268796e-01f, 3.96183640e-01f, -7.48264074e-01f, -1.10152113e+00f, -3.92183632e-01f, -2.10742235e-01f, 7.99803793e-01f, 7.97776282e-01f,
  2.49454483e-01f, 5.82468450e-01f, -6.92337394e-01f, -3.87859583e-01f, 4.48395461e-01f, 1.53107911e-01f, 7.39545599e-02f, 7.74353683e-01f, -6.60314202e-01f, -1.31787348e+00f,
  5.10887742e-01f, -4.51287895e-01f, 5.36009550e-01f, -6.50786757e-01f, -3.41264606e-01f, -4.82887238e-01f, -2.28369096e-03f, 5.48385903e-02f, -8.79723113e-03f, -4.66992915e-01f,
  -4.32273805e-01f, 9.21954513e-02f, -2.83523679e-01f, 4.41572726e-01f, -4.45028365e-01f, 3.14413697e-01f, 2.05268145e-01f, -7.66753614e-01f, -9.57372367e-01f, 6.61681235e-01f,
  5.86095273e-01f, -6.15790844e-01f
};

// L2_linear_B (Shape: 1 x 12)
const int L2_linear_B_rows = 1;
const int L2_linear_B_cols = 12;
const float L2_linear_B_data[] = {
  -9.18890759e-02f, 7.00276867e-02f, -3.36097777e-01f, 2.77248144e-01f, 1.52740955e-01f, 9.76958424e-02f, 1.68135330e-01f, -2.58959621e-01f, -1.88393921e-01f, -8.11355934e-02f,
  -8.81107990e-03f, -2.97902942e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 3, 10
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        16, 3, 10
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_linear
    linear_forward_pgm(
        buffer1, x_out,
        L2_linear_W_data, L2_linear_B_data,
        16, 12
    );
    }
    