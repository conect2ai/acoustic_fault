/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 32 (x4)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 32;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    static inline float fan_activation(float x) { return x; }

    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 6 x 120)
const int L0_fan_Wp_rows = 6;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  3.71171415e-01f, 5.40814549e-03f, 3.16303015e-01f, 1.45622462e-01f, 1.54518709e-01f, 4.05687764e-02f, 4.39124629e-02f, 1.49877891e-01f, 8.95625819e-03f, -1.09733846e-02f,
  -2.91087981e-02f, -2.31572106e-01f, -2.62837380e-01f, -1.46005958e-01f, -8.05293620e-02f, 7.37073794e-02f, -1.08407184e-01f, 6.97456812e-03f, 1.63134456e-01f, 8.13625827e-02f,
  -1.44696057e-01f, 2.17689186e-01f, 2.29636580e-01f, 1.03554413e-01f, 1.29324645e-01f, -7.79788345e-02f, 3.58923487e-02f, 2.01725855e-01f, -1.49465293e-01f, -1.38330311e-01f,
  8.75281021e-02f, 2.60042727e-01f, -1.32989814e-03f, -2.85801850e-02f, 7.47228367e-03f, -6.28908575e-02f, 4.11748402e-02f, 4.73523848e-02f, -9.79625732e-02f, 3.30639482e-02f,
  -6.71574846e-02f, -8.02466869e-02f, -2.25729533e-02f, -4.03405763e-02f, 1.63571551e-01f, -1.90935284e-02f, 4.44231108e-02f, 4.10254858e-02f, 8.53666067e-02f, -5.05934842e-02f,
  -2.10394248e-01f, 6.70071915e-02f, 2.19180420e-01f, 5.48343034e-03f, 2.59567294e-02f, -1.03465155e-01f, 1.00190923e-01f, 2.72226222e-02f, -2.83029936e-02f, 6.52317842e-03f,
  -2.29310244e-02f, 1.54805845e-02f, -3.17992154e-03f, 2.90457215e-02f, -2.83580329e-02f, -1.30911209e-02f, -1.36551051e-03f, -1.97280589e-02f, -1.69266853e-03f, 4.33241278e-02f,
  -7.58503377e-02f, 4.59898822e-02f, 1.21187093e-02f, -8.23175162e-03f, -5.96265569e-02f, 5.23567684e-02f, 5.35833798e-02f, -6.04303516e-02f, 1.60777587e-02f, 1.05865076e-02f,
  1.91576555e-02f, 2.38702931e-02f, 1.04391396e-01f, -6.40390366e-02f, 1.38197038e-02f, 5.46417199e-03f, -6.20035045e-02f, -7.04717785e-02f, 1.84707623e-02f, 4.79911007e-02f,
  4.19216715e-02f, -8.06747451e-02f, 1.04465922e-02f, -7.06388131e-02f, 3.84154581e-02f, 4.92489822e-02f, -2.48859506e-02f, -1.25372577e-02f, 3.64503600e-02f, -3.08524687e-02f,
  3.73687521e-02f, 2.94430293e-02f, 2.07837299e-02f, 5.11371531e-03f, -2.46985313e-02f, 1.10840220e-02f, -3.22619714e-02f, -2.57766414e-02f, -2.89505441e-02f, 7.10983425e-02f,
  -3.78723931e-03f, 2.06267517e-02f, 1.81769356e-02f, 1.91637836e-02f, -1.87337250e-02f, -5.08078821e-02f, 1.24500759e-01f, 8.58186185e-02f, 4.10981569e-03f, 4.45014387e-02f,
  1.53215528e-01f, -2.25023627e-01f, -2.57483482e-01f, 2.25526199e-01f, 2.00553894e-01f, 1.52719915e-01f, -1.30222887e-01f, 2.88707651e-02f, 1.89557701e-01f, -1.19335249e-01f,
  9.74419415e-02f, 3.02828789e-01f, -1.86607018e-02f, 1.82199362e-03f, -2.45887205e-01f, -1.94792867e-01f, -1.51345551e-01f, -1.14819936e-01f, 1.30264819e-01f, 1.96413621e-01f,
  1.62022397e-01f, 6.69197068e-02f, 5.83727751e-03f, 2.65925564e-02f, 1.66216325e-02f, 3.60407159e-02f, -2.44262025e-01f, -9.32622775e-02f, -1.65164769e-01f, -2.55523682e-01f,
  -5.75607978e-02f, 5.96687794e-02f, 4.68977429e-02f, 5.84345125e-02f, 1.53163802e-02f, -6.09344654e-02f, -5.61528616e-02f, -9.24870744e-02f, 2.15790495e-02f, -5.24616614e-02f,
  8.19934756e-02f, 4.18345779e-02f, 7.42946491e-02f, 3.17955837e-02f, 1.24760471e-01f, 3.34227160e-02f, 2.63767801e-02f, 1.14157954e-02f, -5.08258119e-02f, 2.35263258e-02f,
  4.66188490e-02f, 1.38068929e-01f, 9.51113272e-03f, -6.45458559e-03f, -6.42690957e-02f, 1.12306140e-01f, -7.69271180e-02f, 2.34806519e-02f, -2.51397993e-02f, -1.91950858e-01f,
  8.52424875e-02f, 1.26778253e-03f, -9.88257397e-03f, 9.49775614e-03f, -2.82030571e-02f, 7.65572786e-02f, 5.26616815e-03f, 1.61112100e-03f, -2.44489014e-02f, -4.47094813e-02f,
  6.24903105e-02f, 8.56106430e-02f, -7.27316961e-02f, 3.97876203e-02f, 6.55579045e-02f, -2.42733490e-03f, 4.78916392e-02f, -4.48088013e-02f, -3.65521130e-03f, -2.20050048e-02f,
  1.66351174e-03f, -5.83786257e-02f, 1.60142109e-02f, -3.20262834e-02f, -1.71590801e-02f, -2.00092550e-02f, -1.09264220e-03f, 3.44122499e-02f, 2.33092420e-02f, 1.39951119e-02f,
  7.66272843e-03f, -3.41007449e-02f, -8.70059431e-02f, 3.59212980e-02f, -1.36465579e-02f, 1.76562276e-02f, 2.71606110e-02f, -2.22138297e-02f, -2.65768310e-03f, -1.12040481e-02f,
  -5.74940667e-02f, -1.71319358e-02f, -4.46114279e-02f, -1.69894416e-02f, -2.89469045e-02f, -8.76484513e-02f, 5.18571772e-02f, -3.34969684e-02f, -3.89180961e-03f, 7.27714822e-02f,
  -3.52158621e-02f, -9.67351571e-02f, -8.56409892e-02f, -1.42980561e-01f, 1.38350893e-02f, -6.08122721e-02f, -2.04407737e-01f, -5.25346436e-02f, -2.80279703e-02f, -3.51373911e-01f,
  -8.50276053e-01f, 1.95265591e-01f, 8.78410712e-02f, -2.77099788e-01f, -1.62281692e-01f, -4.03007008e-02f, 9.39284917e-03f, 1.48534596e-01f, -1.99588090e-02f, -1.39383413e-03f,
  9.02590007e-02f, -6.21137880e-02f, -5.45393117e-02f, 9.92595851e-02f, -6.63199574e-02f, 1.01293568e-02f, -1.78010687e-01f, -2.17406780e-01f, -1.91064790e-01f, -2.74673644e-02f,
  -1.55620530e-01f, -2.62327760e-01f, -2.17357501e-01f, -6.75204694e-02f, 8.15078318e-02f, 2.27663200e-02f, 6.31277338e-02f, 2.06581876e-02f, -1.08265474e-01f, -1.95612490e-01f,
  8.97413306e-03f, 2.31785364e-02f, -3.45890410e-02f, -1.22777507e-01f, -6.60085455e-02f, -6.37270790e-03f, 1.77941080e-02f, -7.05050712e-04f, 2.65611000e-02f, -4.86229062e-02f,
  -2.86772512e-02f, 5.83648570e-02f, -9.11691487e-02f, 4.17863727e-02f, 8.82088393e-03f, 9.18500945e-02f, 6.44215569e-02f, -1.91846173e-02f, 2.12981589e-02f, 4.60104793e-02f,
  -2.21474152e-02f, -1.65635526e-01f, -2.15235651e-02f, 4.31353897e-02f, 2.17272770e-02f, -2.01998204e-02f, 6.27453402e-02f, -6.56920373e-02f, -9.89377126e-02f, -3.35529223e-02f,
  1.90097522e-02f, -2.95611769e-02f, 1.60988308e-02f, 2.37795934e-02f, 2.14187037e-02f, 1.95057839e-02f, -2.27850117e-02f, -2.38635764e-02f, -1.02621187e-02f, 3.36566456e-02f,
  2.18133219e-02f, 3.70474756e-02f, -6.82530599e-03f, 5.39635755e-02f, -1.35672437e-02f, -7.41310716e-02f, -4.38018050e-03f, -2.25751195e-02f, 2.87658256e-02f, -2.01673098e-02f,
  -2.60621384e-02f, -2.08153222e-02f, -5.92662990e-02f, 4.50175293e-02f, -1.35972574e-02f, 2.30803043e-02f, 2.79252394e-03f, -5.66945970e-03f, 3.37308343e-03f, -6.87430128e-02f,
  5.28133474e-02f, -5.87887429e-02f, -9.37047508e-03f, 5.45193814e-02f, -5.20629734e-02f, 9.11927745e-02f, 4.88058627e-02f, -5.90576828e-02f, -5.84838260e-03f, 2.76027564e-02f,
  -6.45571761e-03f, 2.31484901e-02f, 3.90092544e-02f, 2.35165115e-02f, -1.25266491e-02f, 8.74864310e-03f, -1.47605629e-03f, -2.25377008e-02f, -4.52220850e-02f, 6.11726828e-02f,
  2.26836074e-02f, 1.92105565e-02f, 7.48900101e-02f, 3.62982973e-02f, -3.46508957e-02f, -7.90279359e-02f, 7.97005221e-02f, 6.95275515e-02f, -6.91842462e-04f, 2.62250155e-01f,
  3.98256660e-01f, -5.13515435e-02f, -7.80146345e-02f, -6.20055653e-04f, -2.05981210e-02f, 1.67697147e-01f, 4.34998125e-01f, 1.24531090e-01f, -9.51983631e-02f, 3.56426053e-02f,
  -2.24102773e-02f, -3.19877088e-01f, -1.22711584e-01f, -1.14494905e-01f, 2.58484334e-01f, 1.77266285e-01f, 2.18617637e-02f, 4.55231182e-02f, 9.61753055e-02f, -5.24878204e-02f,
  -8.49326700e-02f, -1.29755795e-01f, -6.09260090e-02f, 1.00972340e-01f, -1.32339552e-01f, -1.63434863e-01f, 7.52188265e-02f, -1.53188214e-01f, -3.90936285e-02f, -2.23223299e-01f,
  -1.18705250e-01f, 1.00588150e-01f, -3.37097980e-02f, 1.23495832e-02f, -5.13931662e-02f, 8.71474594e-02f, 4.38065035e-03f, -9.37368069e-03f, -1.73073206e-02f, -2.05436852e-02f,
  -1.48022501e-02f, -3.45693864e-02f, 1.51536437e-02f, -5.86720966e-02f, 6.68671802e-02f, -5.29720820e-02f, 5.50005436e-02f, 4.06047255e-02f, 7.72081539e-02f, 6.02714978e-02f,
  -6.26376346e-02f, 6.04507104e-02f, -6.57848408e-03f, 4.30023968e-02f, 1.02839008e-01f, 5.37418574e-02f, -4.34283260e-03f, 6.70642033e-02f, 1.40812203e-01f, -1.56025589e-01f,
  2.20726375e-02f, -4.13185917e-02f, 3.41607407e-02f, -3.32529470e-03f, 5.18693700e-02f, -1.08040534e-02f, 1.87758431e-02f, -4.48150784e-02f, -9.59975179e-03f, 6.14737067e-03f,
  -8.91121279e-04f, 1.65162757e-02f, 2.07150057e-02f, -1.66685116e-02f, 9.12691746e-03f, 4.03286852e-02f, 7.58077353e-02f, 1.33550083e-02f, -1.85846146e-02f, 4.34731618e-02f,
  -7.22980201e-02f, 1.03297960e-02f, 1.00421198e-02f, -2.09928621e-02f, -2.32425169e-04f, -7.12564886e-02f, -5.32152168e-02f, 1.25390422e-02f, -2.82032341e-02f, 1.47507340e-02f,
  -9.61358398e-02f, 4.31225300e-02f, -7.79446661e-02f, -1.26641905e-02f, -3.46821882e-02f, -4.32583652e-02f, -5.20005217e-03f, -5.20228855e-02f, -7.05276206e-02f, 2.98839994e-02f,
  3.88644412e-02f, 1.07683493e-02f, 2.75708418e-02f, 1.63086578e-02f, 1.04700793e-02f, 2.13441793e-02f, 1.73483156e-02f, -6.26139566e-02f, -1.48071051e-02f, 1.73605718e-02f,
  -1.17711183e-02f, 2.12327763e-02f, -7.50547722e-02f, -1.55254425e-02f, -1.36941336e-02f, -7.59174004e-02f, -2.33608559e-02f, 3.05308588e-03f, 9.03076008e-02f, 4.86049019e-02f,
  -1.43922091e-01f, -4.00972329e-02f, -1.12523027e-01f, -3.47988158e-02f, -3.81163917e-02f, 2.46409345e-02f, 1.48367926e-01f, -1.31036207e-01f, -1.21882603e-01f, -1.04861975e-01f,
  -2.00669333e-01f, -2.09448710e-01f, -2.54039496e-01f, -1.24811746e-01f, -6.81112036e-02f, -1.31178908e-02f, 1.81258723e-01f, 1.20794691e-01f, -2.05689430e-01f, -2.04873621e-01f,
  7.47660026e-02f, 4.98870015e-02f, 2.64818445e-02f, -2.88231466e-02f, 1.45749345e-01f, 6.74178526e-02f, 1.50021479e-01f, 8.62486288e-02f, 1.61133751e-01f, 3.69308472e-01f,
  -1.18562415e-01f, 1.63837224e-02f, -5.30184731e-02f, 8.88937712e-02f, 8.20992365e-02f, 4.88963239e-02f, -4.88686450e-02f, 8.27020407e-02f, 2.37049647e-02f, -4.39095031e-03f,
  4.23749257e-03f, 1.68838799e-02f, 2.93390802e-03f, 1.27206698e-01f, 2.10567266e-02f, 5.14689758e-02f, -5.21071814e-02f, 4.32027318e-03f, 8.45087990e-02f, 2.36770548e-02f,
  -3.06049213e-02f, 9.78285298e-02f, 4.31163795e-02f, -2.50045862e-02f, 1.57389566e-02f, -3.00248284e-02f, 9.40222219e-02f, 6.37453496e-02f, 1.03332944e-01f, 7.95368478e-02f,
  1.39472038e-02f, -3.49497646e-02f, -1.49408532e-02f, 2.47808881e-02f, -1.98454745e-02f, -3.99146564e-02f, 7.89825171e-02f, 2.93949470e-02f, -3.51199210e-02f, -1.56689193e-02f,
  -4.12184037e-02f, 2.16386989e-02f, -9.03136469e-03f, 5.08384481e-02f, 1.29034100e-02f, -4.05824259e-02f, 1.07277751e-01f, -4.25563455e-02f, 6.91013038e-02f, 3.02810827e-03f,
  4.24847491e-02f, 3.53844115e-03f, -4.42557894e-02f, 1.40414946e-02f, 4.22506258e-02f, 1.25729710e-01f, 3.14902551e-02f, 2.34462768e-02f, -8.56464356e-02f, 5.47826067e-02f,
  -1.17657684e-01f, 1.39914928e-02f, 2.14256849e-02f, -2.96674427e-02f, 7.40715489e-02f, -9.26257223e-02f, 4.28323634e-02f, 7.80637711e-02f, 6.40673935e-02f, 6.84149489e-02f,
  2.26258188e-02f, 9.89788920e-02f, 3.20698060e-02f, -9.13927890e-03f, -9.54927206e-02f, 4.10348848e-02f, 1.05735295e-01f, 8.11855793e-02f, -9.81843621e-02f, -4.70927134e-02f,
  5.55936471e-02f, -1.13847449e-01f, -1.55007109e-01f, -3.16134542e-02f, -8.20259377e-02f, -1.13333784e-01f, -9.24623385e-02f, 8.06350913e-03f, -6.15476891e-02f, -5.16498089e-03f,
  -2.46821195e-01f, 9.58878174e-02f, 2.01531187e-01f, 5.14175296e-02f, 2.79947966e-01f, 3.01806748e-01f, 2.82193214e-01f, -5.59517462e-03f, 1.94891468e-02f, 2.05857977e-02f,
  1.01967901e-01f, -6.73850477e-02f, -1.49311677e-01f, -1.19393542e-01f, -1.25694260e-01f, 1.04257062e-01f, 5.04067279e-02f, -1.05020776e-01f, 2.08698828e-02f, 1.76053509e-01f,
  1.46077089e-02f, -4.93880212e-02f, -8.43784958e-02f, 3.63917872e-02f, 6.66998550e-02f, -4.79884222e-02f, -1.07105948e-01f, 1.36088341e-01f, 6.17289618e-02f, 1.44166015e-02f,
  -9.79041797e-04f, 2.26863638e-01f, -1.98051389e-02f, -5.70279323e-02f, 6.20738231e-02f, 2.23740488e-02f, 9.44497809e-03f, -2.22660378e-02f, 1.63148046e-02f, -3.35623510e-02f,
  3.48144919e-02f, 8.65069628e-02f, 3.05236354e-02f, 8.73079076e-02f, -6.81866184e-02f, 6.88873753e-02f, 2.04428732e-02f, 7.18226805e-02f, -4.68070805e-02f, 1.44637346e-01f,
  2.48099454e-02f, 1.16854765e-01f, 1.13832101e-01f, 7.36324042e-02f, 9.48383361e-02f, 2.57983245e-02f, -2.06087865e-02f, 6.15542978e-02f, 1.15174595e-02f, 1.13246674e-02f,
  4.30944264e-02f, -1.48733864e-02f, -4.55364678e-03f, -1.51627660e-02f, -3.05693224e-02f, -5.91117218e-02f, -3.47416885e-02f, -1.51474113e-02f, 9.42222401e-02f, -8.45787823e-02f,
  -1.98743995e-02f, 2.96576861e-02f, -3.88217345e-02f, 5.21637388e-02f, 1.10893659e-02f, 4.43051681e-02f, 3.34887877e-02f, -2.20166408e-02f, -3.72549668e-02f, -9.61422920e-03f,
  -1.84200946e-02f, 6.42129555e-02f, 6.20862097e-03f, -7.89154246e-02f, 3.25010046e-02f, 5.24748676e-02f, -5.71431918e-03f, 1.12556638e-02f, -3.10054962e-02f, -2.41147839e-02f,
  -2.03180537e-01f, 2.97174118e-02f, -9.21109021e-02f, -5.31308912e-02f, 5.23089133e-02f, -7.52615780e-02f, 2.61970088e-02f, 3.02661005e-02f, -5.29859252e-02f, 8.06220062e-03f,
  2.44333073e-02f, -1.78244580e-02f, -6.44706860e-02f, 3.93187031e-02f, -1.47724180e-02f, 2.82730144e-02f, -7.74689764e-02f, 4.79426533e-02f, -2.34837867e-02f, -2.79597007e-03f,
  3.33808525e-03f, -5.69834188e-02f, -1.72010988e-01f, -1.56634942e-01f, -1.86817795e-02f, -1.40004084e-01f, -1.84809357e-01f, -3.50234918e-02f, -5.14412075e-02f, -1.27379522e-01f
};

// L0_fan_Wp_bar (Shape: 20 x 120)
const int L0_fan_Wp_bar_rows = 20;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  -1.95622414e-01f, -3.07352357e-02f, -2.06405837e-02f, -9.53706205e-02f, 2.50368565e-02f, 1.65265780e-02f, 5.27265929e-02f, -8.08747765e-03f, 7.41574913e-02f, -4.30319197e-02f,
  3.48867662e-02f, 8.18483473e-04f, -8.71591717e-02f, -5.09402677e-02f, 4.32250202e-02f, 3.09514590e-02f, 8.35382789e-02f, -6.82924613e-02f, -2.00587995e-02f, -5.75345233e-02f,
  1.77034475e-02f, 2.44281683e-02f, -7.30804354e-02f, 1.55473119e-02f, -8.87720473e-03f, 2.66160257e-02f, -8.23567063e-03f, -4.56300704e-03f, -4.81671616e-02f, -8.75828192e-02f,
  -5.34841903e-02f, -1.04113199e-01f, -4.98660356e-02f, -5.68691902e-02f, 7.36777931e-02f, -9.03485492e-02f, -4.81070615e-02f, 1.45073486e-02f, 5.87726720e-02f, 3.43906619e-02f,
  -7.20813423e-02f, -8.61146376e-02f, -1.02854013e-01f, 2.29300256e-03f, -1.21063650e-01f, -4.90025282e-02f, 6.94134757e-02f, -1.77238311e-03f, 7.47896656e-02f, -7.29918182e-02f,
  2.79355012e-02f, 4.05855887e-02f, 3.56499404e-02f, 1.10454097e-01f, -3.50439772e-02f, 5.79196662e-02f, 4.79942821e-02f, -6.37806132e-02f, -7.28092790e-02f, -2.32741539e-03f,
  -2.90099476e-02f, -7.71804014e-03f, 8.83336663e-02f, -8.02651569e-02f, -1.38819786e-02f, 5.91362379e-02f, -1.00152627e-01f, -5.06690778e-02f, -8.22779760e-02f, -2.27874331e-02f,
  6.66821599e-02f, 9.47636180e-03f, -7.64405578e-02f, -6.05467819e-02f, 2.92085372e-02f, 7.13072484e-03f, 3.51680852e-02f, 4.47821803e-02f, 1.07231200e-01f, -8.58850311e-03f,
  2.15081405e-02f, -1.93120670e-02f, 1.56614911e-02f, 1.55280402e-03f, 1.15170963e-01f, -1.54377110e-02f, -3.31225134e-02f, 9.13542956e-02f, 5.47537282e-02f, -3.64444107e-02f,
  -1.24353334e-01f, 9.11305025e-02f, 3.13545279e-02f, -1.18598588e-01f, -9.68963839e-03f, 7.93381184e-02f, -8.12431797e-02f, -8.12197402e-02f, -8.04076120e-02f, 3.22905369e-02f,
  2.30203252e-02f, -6.05948754e-02f, -1.52160926e-02f, 5.16728088e-02f, 2.32306588e-02f, -4.01993375e-03f, 5.97686023e-02f, 1.88098215e-02f, -2.51637995e-02f, -2.11175177e-02f,
  2.25818604e-02f, -3.91691690e-03f, -3.65454406e-02f, -7.71826804e-02f, -9.83157307e-02f, 2.72881538e-02f, -1.42451644e-01f, -3.31339352e-02f, -1.28170431e-01f, -9.58249420e-02f,
  -1.55883163e-01f, 4.87640873e-02f, 6.20096102e-02f, -6.50044084e-02f, -1.01752251e-01f, 4.03310582e-02f, 3.62387635e-02f, -7.37664774e-02f, -8.01664963e-02f, 4.54183519e-02f,
  8.63698870e-02f, -5.58034964e-02f, 1.07336566e-02f, -3.58151942e-02f, -4.04886939e-02f, -7.61674270e-02f, -2.43328940e-02f, 1.93409510e-02f, 4.15524915e-02f, -7.84277916e-02f,
  3.88998762e-02f, 4.43591550e-02f, -2.72219325e-03f, -5.77388667e-02f, 3.22496444e-02f, 9.61927846e-02f, 2.56456598e-03f, 5.79896271e-02f, 3.88022736e-02f, -9.56049934e-02f,
  4.75166924e-02f, -7.51471370e-02f, -6.45950064e-02f, 7.79898316e-02f, -9.70560759e-02f, -6.80779442e-02f, 3.59778367e-02f, -8.08838457e-02f, 9.14400071e-03f, -8.34195986e-02f,
  4.37275786e-03f, -7.39394035e-03f, 5.87394051e-02f, -3.04397345e-02f, -2.03387011e-02f, 2.43235566e-02f, -1.41950771e-02f, -4.41277772e-02f, -2.48121284e-02f, -6.52447119e-02f,
  4.14131284e-02f, -2.52643302e-02f, 7.54834786e-02f, -3.50281820e-02f, -4.54275927e-04f, 2.78963093e-02f, 8.84982497e-02f, -6.54796958e-02f, -5.04319090e-04f, 3.65689769e-02f,
  -5.22669684e-03f, -5.77052310e-03f, -4.66376048e-04f, -1.62474159e-02f, 6.60040826e-02f, 7.83051252e-02f, -4.81947809e-02f, 4.88403905e-03f, 4.24753465e-02f, -3.37757803e-02f,
  -3.47569808e-02f, -3.24572399e-02f, -3.87836359e-02f, -1.67922936e-02f, 8.58940035e-02f, 3.03731486e-02f, 1.17486760e-01f, 4.60209772e-02f, 2.07822882e-02f, -4.83766571e-02f,
  4.19611670e-02f, 6.39753416e-02f, -9.34303775e-02f, -5.90554662e-02f, -7.47382864e-02f, -5.21349385e-02f, 8.11106339e-03f, 4.75498363e-02f, 5.23082279e-02f, 7.23261759e-02f,
  1.06659278e-01f, 6.21010587e-02f, 5.44491597e-02f, 1.08347973e-02f, -9.16674733e-02f, -8.91073793e-02f, 2.46463977e-02f, -5.76408021e-02f, -7.55442828e-02f, 4.15352061e-02f,
  -7.86412507e-02f, 5.06789144e-03f, 5.02511747e-02f, 4.23569378e-04f, 5.92084564e-02f, 3.94828543e-02f, -6.59450516e-02f, -4.78767194e-02f, -3.71182598e-02f, -7.97594024e-04f,
  -5.12812398e-02f, -5.39363874e-03f, -5.24307825e-02f, -5.81343658e-03f, -3.95742878e-02f, 9.63216275e-02f, 1.12628348e-01f, 1.00267254e-01f, -1.58756953e-02f, 8.20591524e-02f,
  -3.96455936e-02f, 2.86806952e-02f, 6.10441975e-02f, 8.41785781e-03f, 8.09644684e-02f, -5.40515147e-02f, -1.05319895e-01f, -2.53158640e-02f, 5.46707539e-03f, 6.84830397e-02f,
  -5.43714575e-02f, -3.65780294e-02f, 2.12318962e-03f, -3.72028872e-02f, -1.02824569e-01f, -7.11915120e-02f, -6.39961809e-02f, 4.62975819e-04f, 4.89651449e-02f, 7.21641630e-02f,
  2.99395826e-02f, -8.59877386e-04f, -2.20336020e-02f, -2.74755359e-02f, -3.74059640e-02f, -8.28424692e-02f, -2.25798897e-02f, -8.50082412e-02f, -7.74642006e-02f, -7.65408278e-02f,
  -3.17324437e-02f, 4.97385971e-02f, 3.62467468e-02f, -5.38873710e-02f, 6.10570423e-02f, 4.94017787e-02f, -3.77604328e-02f, 1.14949551e-04f, -4.97928411e-02f, -5.69910258e-02f,
  7.08239898e-02f, -8.12236592e-03f, 8.76185298e-02f, 6.90376619e-03f, 3.01076472e-02f, 2.01409627e-02f, -9.20295417e-02f, -2.93762162e-02f, -5.00770137e-02f, 2.48396825e-02f,
  -1.22120064e-02f, -1.05478510e-01f, 3.59965861e-02f, 5.75253367e-02f, -4.21497971e-02f, -4.12985794e-02f, 2.92643178e-02f, -5.44160306e-02f, 4.09411639e-02f, 3.43248360e-02f,
  1.60282245e-03f, -1.55476853e-03f, 2.14210637e-02f, -5.75584993e-02f, 3.54458466e-02f, -2.27479246e-02f, -1.39826750e-02f, 2.34996080e-02f, -7.67911449e-02f, 5.30878119e-02f,
  -3.59090827e-02f, -4.57595550e-02f, 8.30034539e-02f, 1.00714825e-01f, -4.06266749e-02f, -4.30252030e-02f, -6.18294030e-02f, 1.25582917e-02f, 4.13614661e-02f, 5.65088019e-02f,
  7.51352236e-02f, -5.54204136e-02f, 4.48785424e-02f, -1.80998035e-02f, 1.42504256e-02f, 4.82295305e-02f, -4.85703088e-02f, 1.32728079e-02f, -1.76713578e-02f, -6.44691139e-02f,
  -5.25351502e-02f, -7.86866918e-02f, 7.89128914e-02f, 5.67982346e-02f, -2.17477288e-02f, 2.79457774e-02f, 5.36395377e-03f, -5.25467955e-02f, 4.25485671e-02f, 4.77501936e-02f,
  -9.78851132e-03f, 6.56949431e-02f, -1.07461676e-01f, -2.16920692e-02f, 7.55646825e-02f, -7.28471875e-02f, -3.20041366e-03f, 1.33126453e-02f, -3.08133960e-02f, 6.31120428e-02f,
  -9.63583216e-02f, 1.12535516e-02f, -8.26870203e-02f, -3.63169871e-02f, 3.50638404e-02f, 7.31078014e-02f, -5.90390712e-02f, 4.64350097e-02f, -1.42382449e-02f, -5.15300222e-02f,
  -4.05368984e-01f, -4.37210649e-01f, -5.28399423e-02f, 3.78874600e-01f, 5.01952648e-01f, 4.88882542e-01f, 3.69957089e-01f, 1.91136390e-01f, 2.56856501e-01f, 8.75477493e-02f,
  -2.49674469e-01f, -3.27126659e-03f, -1.23410197e-02f, -1.46646023e-01f, -2.88668294e-02f, 2.48463586e-01f, 3.36417139e-01f, 1.47639392e-02f, 9.01403874e-02f, 2.85337955e-01f,
  2.46550173e-01f, -1.45327374e-01f, -4.21280771e-01f, 9.24259890e-03f, 2.01824889e-01f, 3.09073627e-01f, -1.61433723e-02f, -1.44472867e-01f, -1.95316207e-02f, 1.77407831e-01f,
  -1.34383127e-01f, -3.17613989e-01f, 1.93446919e-01f, -2.33904291e-02f, -6.50385991e-02f, -7.41980895e-02f, -6.50993139e-02f, -1.85304970e-01f, -5.99397235e-02f, -4.61579002e-02f,
  -7.90499970e-02f, -1.14964359e-01f, 7.81730469e-03f, -1.48894619e-02f, -4.59779613e-03f, -4.15860340e-02f, -1.51423305e-01f, -1.81467324e-01f, 3.86241153e-02f, -5.30287959e-02f,
  8.23486224e-03f, -7.84870535e-02f, -6.19327053e-02f, 1.71666250e-01f, 1.14026263e-01f, 9.87564176e-02f, -2.19347384e-02f, -5.72372861e-02f, 1.17871203e-02f, -1.53233916e-01f,
  7.66094401e-02f, -5.22192381e-02f, 2.32188459e-02f, 3.47437593e-03f, 4.28152718e-02f, 1.84048079e-02f, -1.94183867e-02f, 2.69553140e-02f, 6.58821017e-02f, -7.12692812e-02f,
  1.39520196e-02f, 1.46428067e-02f, 6.90300902e-03f, -7.24115642e-03f, -7.51337688e-03f, -7.91457202e-03f, -1.71379987e-02f, -1.44609949e-02f, -6.47908002e-02f, 1.16199870e-02f,
  -2.91575026e-02f, -4.30011041e-02f, -4.50531654e-02f, 4.78680618e-02f, 3.73274609e-02f, 5.60491569e-02f, 5.79342954e-02f, -6.94989935e-02f, 4.31217365e-02f, -1.37754247e-01f,
  7.11914338e-03f, 1.20587759e-02f, -6.85762987e-03f, -9.63118896e-02f, 3.34262364e-02f, -8.54699612e-02f, 1.37341172e-01f, -2.08577234e-02f, -1.86179914e-02f, 3.40838358e-02f,
  -1.49171799e-01f, -9.41890292e-03f, -1.79312527e-02f, -8.34803656e-02f, 1.04131907e-01f, 2.08094046e-02f, -3.05840131e-02f, 1.39246792e-01f, -6.88699707e-02f, -4.23267763e-03f,
  5.09467423e-02f, 9.76628289e-02f, 9.17844772e-02f, 1.44841462e-01f, -2.75662076e-03f, 1.80924058e-01f, 3.93858925e-02f, 1.69935338e-02f, 4.76584136e-02f, -6.70138076e-02f,
  -1.87742576e-01f, 2.29951665e-02f, -6.26849458e-02f, -2.69484762e-02f, 6.23337105e-02f, -2.86151525e-02f, -2.76107062e-02f, -1.07710086e-01f, -6.95591047e-02f, -2.10312996e-02f,
  2.92056315e-02f, -2.52745971e-02f, -2.44268719e-02f, 8.84809345e-02f, -9.84952822e-02f, -3.93135995e-02f, 3.35624553e-02f, 1.20240748e-02f, -9.02953371e-02f, -8.50287173e-03f,
  5.29752634e-02f, -7.92535469e-02f, 5.60366437e-02f, 6.55734390e-02f, 1.58092558e-01f, 1.05777070e-01f, 4.23876643e-02f, 5.58176897e-02f, 8.43248218e-02f, 1.67550057e-01f,
  9.49309543e-02f, -5.72825363e-03f, 1.83320083e-02f, -4.38859202e-02f, 8.81165732e-03f, -6.86531141e-02f, -3.13522778e-02f, 2.21083220e-02f, 7.52133578e-02f, -1.26699638e-02f,
  1.32751120e-02f, -6.30986840e-02f, -2.70608906e-02f, 8.67905766e-02f, 1.55193340e-02f, -6.62108883e-02f, -7.04505518e-02f, 3.71638909e-02f, -9.31558535e-02f, 5.01124188e-02f,
  8.18463415e-02f, -1.14156760e-03f, 4.52964343e-02f, 1.15731530e-01f, -1.93306524e-02f, 4.95053492e-02f, 5.21539375e-02f, 9.23051536e-02f, 9.77626070e-02f, 6.55724527e-03f,
  6.43115938e-02f, -4.90654260e-02f, 8.76828562e-03f, 3.67068797e-02f, 4.37862910e-02f, 1.71797033e-02f, 8.38045403e-03f, 7.57939368e-02f, 2.04742700e-02f, -7.27522895e-02f,
  2.74364697e-03f, 6.66617900e-02f, -2.61219423e-02f, 4.42791954e-02f, 8.16375092e-02f, -3.00493296e-02f, 3.71099524e-02f, -1.34220272e-02f, -2.96637751e-02f, 8.93359073e-03f,
  -6.70332611e-02f, -2.19913013e-02f, 5.26882038e-02f, 5.85865171e-04f, 1.70467142e-02f, 3.18549089e-02f, -4.56373729e-02f, -6.80070817e-02f, -4.65278067e-02f, 4.46875766e-02f,
  1.46368053e-02f, -2.79815868e-02f, -4.50758301e-02f, 5.16881384e-02f, 1.32866558e-02f, 1.40844183e-02f, 8.78177583e-02f, 1.81892142e-02f, -1.96753070e-02f, 3.48680355e-02f,
  1.14809163e-01f, 1.07881591e-01f, 7.90345222e-02f, 5.85495420e-02f, 4.18781601e-02f, 6.62837327e-02f, 5.80601022e-03f, 1.78785436e-02f, -2.82336734e-02f, 9.84599441e-02f,
  7.70089924e-02f, 6.66498691e-02f, -6.48343340e-02f, 4.01583388e-02f, -3.60249281e-02f, 1.83322858e-02f, 7.35240281e-02f, 1.06052838e-01f, 6.80392683e-02f, -1.16803318e-01f,
  -7.33224675e-02f, -1.21472254e-01f, 2.19508801e-02f, -7.05877542e-02f, 2.10261177e-02f, -3.83663140e-02f, -3.57338041e-02f, -5.36449216e-02f, 8.28342810e-02f, -2.78537776e-02f,
  -4.51309495e-02f, -4.13439423e-02f, 8.22006166e-02f, 1.01690004e-02f, 8.75203311e-02f, -1.43995825e-02f, 1.38566401e-02f, 1.06884539e-01f, 6.78234473e-02f, 3.36955972e-02f,
  3.68120894e-02f, 6.84383735e-02f, 9.90707800e-02f, 1.04694895e-01f, 5.33421384e-03f, 1.76675230e-01f, 7.07226694e-02f, 4.30077165e-02f, 2.00584501e-01f, 1.72953844e-01f,
  2.74353903e-02f, -1.21405646e-01f, 1.23260342e-01f, 4.10669819e-02f, -3.17355315e-03f, 2.99902372e-02f, -3.02396603e-02f, 2.15716157e-02f, 2.24249158e-02f, 2.56551206e-02f,
  -4.14805003e-02f, -1.48414103e-02f, -5.77065069e-03f, -6.01314344e-02f, -7.66400322e-02f, -9.21423435e-02f, 9.33439732e-02f, 3.39194909e-02f, 7.20255226e-02f, -1.33189872e-01f,
  -9.63172242e-02f, -8.50176066e-03f, 9.87373814e-02f, -2.92089172e-02f, -1.67247076e-02f, -4.42774221e-02f, -6.05301298e-02f, 1.28853366e-01f, 3.97125110e-02f, 4.70464267e-02f,
  3.94433998e-02f, 2.23872866e-02f, 6.04661703e-02f, 6.92315847e-02f, -9.50695127e-02f, 4.07399423e-02f, 4.38205898e-02f, 6.85112402e-02f, -3.44262309e-02f, -7.88137969e-03f,
  -4.81242612e-02f, 9.25467070e-03f, 3.30182128e-02f, 1.94665119e-02f, 5.48966862e-02f, -5.43586724e-02f, 1.03511602e-01f, -1.05823968e-02f, 8.69708806e-02f, 1.42335352e-02f,
  -4.12138365e-02f, 8.72966945e-02f, 2.09789835e-02f, 7.57065937e-02f, -1.33367091e-01f, -6.66602552e-02f, -4.05106135e-02f, -1.00316003e-01f, -4.10642028e-02f, -9.11972225e-02f,
  -1.27609909e-01f, 2.15768918e-01f, -3.92314196e-02f, -8.37183073e-02f, -1.45319626e-02f, -6.66412115e-02f, 2.57466286e-02f, -7.85173550e-02f, -8.64054933e-02f, 2.68196128e-02f,
  -1.48436502e-01f, -4.07081023e-02f, -3.43035385e-02f, 8.02408829e-02f, 2.13936418e-02f, -4.68230620e-02f, -1.14019327e-02f, 6.91985711e-03f, 8.40703100e-02f, -5.21789901e-02f,
  -9.11391601e-02f, 2.48809881e-03f, 9.54814255e-03f, -7.17146099e-02f, 1.23285428e-01f, -5.83375655e-02f, 7.89281800e-02f, -4.01619524e-02f, -5.75115196e-02f, -4.16609719e-02f,
  3.22560705e-02f, -1.38219312e-01f, -9.74446237e-02f, -3.46435420e-02f, 6.97008148e-02f, -2.37983987e-02f, -3.76393879e-03f, 9.00226906e-02f, 1.21899366e-01f, -6.95861802e-02f,
  2.41754279e-02f, -3.61665823e-02f, -1.29831098e-02f, -4.41113003e-02f, -3.98227274e-02f, -1.57333224e-03f, -5.37850782e-02f, 5.92052378e-02f, 3.90012679e-03f, 9.79512855e-02f,
  -4.83227260e-02f, -1.12022229e-01f, 4.26070988e-02f, 3.86281498e-02f, -1.80398956e-01f, -2.08725333e-02f, -9.40352753e-02f, 1.07813990e-02f, -8.35014582e-02f, -9.35354084e-02f,
  -1.06619798e-01f, -4.81501035e-02f, 9.48029980e-02f, -3.84496339e-02f, 7.02874213e-02f, 2.92876922e-02f, 2.34038127e-03f, 1.00922070e-01f, 1.07451007e-01f, 1.15737040e-02f,
  -1.04706429e-01f, 1.03450142e-01f, -5.44111691e-02f, 3.34734619e-02f, 7.68655464e-02f, -2.73051579e-02f, 4.73904656e-03f, -8.02838057e-02f, -7.62518123e-02f, -5.86266927e-02f,
  -5.77812307e-02f, -1.65751353e-01f, -6.18621074e-02f, -2.57657506e-02f, -9.16287228e-02f, -1.13779999e-01f, -1.09434702e-01f, 4.24574362e-03f, 3.68137881e-02f, -1.08014934e-01f,
  -1.78798288e-02f, -2.52297912e-02f, -2.89955456e-02f, -1.21113054e-01f, -7.41851851e-02f, -8.07101876e-02f, 2.79296096e-02f, 2.20769402e-02f, -1.65510445e-03f, 9.85348523e-02f,
  4.31330614e-02f, -2.54071336e-02f, 2.63904259e-02f, 4.11860868e-02f, 5.92076033e-02f, -7.18928203e-02f, 9.55860838e-02f, -2.18188949e-02f, -4.75127716e-03f, 6.80236444e-02f,
  9.88630429e-02f, 1.59141887e-02f, 5.41206542e-03f, 1.09226733e-01f, 1.04600921e-01f, 1.18194474e-02f, 3.87840830e-02f, -2.26341486e-02f, 2.05636136e-02f, 4.67400812e-02f,
  3.90444845e-02f, 7.30965612e-03f, -8.41058269e-02f, 6.55058101e-02f, -2.21067984e-02f, -1.51398219e-02f, 6.95756311e-03f, 6.46870956e-02f, 6.01767823e-02f, -4.72897328e-02f,
  8.18055570e-02f, 6.66668117e-02f, -2.26297900e-02f, 9.58550051e-02f, 1.14379331e-01f, 5.45133799e-02f, 2.04527900e-02f, -5.61869480e-02f, 4.51002382e-02f, 8.53808820e-02f,
  8.31754506e-02f, 9.73470733e-02f, 4.39769821e-03f, 1.89927612e-02f, -6.68656379e-02f, 4.03644294e-02f, 4.98216636e-02f, -2.50582118e-02f, -4.45749573e-02f, 8.82794708e-02f,
  -1.83342561e-01f, -1.59045026e-01f, -7.42496103e-02f, -1.62467062e-01f, -6.55858368e-02f, 1.17467530e-01f, 5.89029081e-02f, 5.27496859e-02f, -6.45111352e-02f, -1.05554752e-01f,
  1.35867242e-02f, -6.43290579e-02f, -3.56678776e-02f, -8.90691485e-03f, 1.01004831e-01f, 3.23567875e-02f, 3.75572257e-02f, 3.40547264e-02f, -5.60362600e-02f, -1.78500880e-02f,
  -1.22171901e-01f, -2.48643802e-03f, -6.16489723e-02f, 8.41063559e-02f, -5.18757068e-02f, -6.21836148e-02f, -4.79327217e-02f, -1.08812563e-01f, 7.30247870e-02f, -2.10815370e-01f,
  -1.48147613e-01f, -7.29418844e-02f, 3.34390625e-02f, -3.58972810e-02f, -6.64371476e-02f, 4.84277308e-02f, -4.33563814e-03f, 3.97636406e-02f, 4.44944091e-02f, 1.11201755e-03f,
  5.42800408e-03f, -2.87128072e-02f, -1.10944822e-01f, -6.70339316e-02f, -7.26630986e-02f, -6.01151586e-02f, -2.63966992e-02f, -7.59189278e-02f, -9.28660017e-03f, -2.23020464e-02f,
  -1.05017371e-01f, -7.01722577e-02f, -9.05955851e-04f, -3.86209525e-02f, -8.16315189e-02f, 4.69388887e-02f, -8.79579037e-02f, 5.83084077e-02f, 4.38692458e-02f, -6.30479828e-02f,
  -5.13726249e-02f, -1.20616723e-02f, 4.68142740e-02f, 6.09885752e-02f, -5.43118306e-02f, -6.47320151e-02f, -2.42132246e-02f, 3.10526285e-02f, -3.82043384e-02f, 4.77541201e-02f,
  9.43336040e-02f, 1.82327814e-03f, 6.85283691e-02f, -1.96188390e-02f, -5.84712764e-03f, 3.02412044e-02f, 4.56273695e-03f, -2.51333397e-02f, 1.62331052e-02f, 2.48827506e-02f,
  -5.45987524e-02f, -4.95825522e-02f, -5.78369536e-02f, 4.49600406e-02f, -6.22234084e-02f, -2.33738329e-02f, 2.35999618e-02f, 9.01418850e-02f, 2.55791228e-02f, 9.20487791e-02f,
  4.05469351e-03f, 1.50821984e-01f, -1.19191699e-01f, 5.24594560e-02f, -1.83134545e-02f, 7.01346770e-02f, -9.59933847e-02f, 7.11580589e-02f, -4.65915538e-03f, -8.43970105e-02f,
  -1.74283143e-02f, -8.39536265e-02f, -3.10098082e-02f, -6.46759793e-02f, -1.16657987e-01f, -9.10004526e-02f, -5.33138867e-03f, -1.07717730e-01f, 7.36113936e-02f, 8.30912031e-03f,
  2.07811594e-02f, -1.11730658e-02f, -1.25241801e-01f, 5.32497615e-02f, -9.60964411e-02f, -4.25507277e-02f, -1.43564073e-02f, -8.92272741e-02f, -7.77397081e-02f, -5.21230288e-02f,
  1.69574022e-01f, -2.05055311e-01f, -1.13509469e-01f, -1.08398246e-02f, -7.22437277e-02f, -7.19685704e-02f, -6.63610399e-02f, 3.33529189e-02f, -1.18412487e-02f, 1.00808945e-02f,
  8.77634436e-02f, 2.20920935e-01f, 1.74600855e-01f, 5.42596243e-02f, 1.37315532e-02f, -1.15207300e-01f, -1.11267932e-01f, 7.56659284e-02f, 9.53030884e-02f, 2.47619543e-02f,
  -2.04540472e-02f, -1.04712099e-01f, 5.58734946e-02f, -4.88582924e-02f, -7.74006941e-04f, 2.72109844e-02f, -1.89443380e-01f, -1.19189702e-01f, -3.79364453e-02f, -2.71807283e-01f,
  9.15439576e-02f, -5.87376021e-02f, 3.26572917e-02f, 5.21765929e-03f, -5.49473464e-02f, 5.80682047e-03f, 2.11723056e-02f, -6.41419664e-02f, 3.75206247e-02f, -8.34242031e-02f,
  -3.72193269e-02f, 6.17680177e-02f, 6.91470131e-02f, -8.05153046e-03f, -1.16120912e-01f, -1.03610590e-01f, -8.53241980e-02f, -4.60492149e-02f, 5.76815866e-02f, -9.13635865e-02f,
  -1.30080476e-01f, -8.56066495e-02f, -2.76433453e-02f, 6.41920045e-02f, -4.56382297e-02f, 5.45593463e-02f, 5.32717071e-03f, 2.75837556e-02f, -9.21908095e-02f, 5.43089630e-03f,
  -8.45455006e-02f, -1.00675359e-01f, 8.19520503e-02f, -4.68408875e-02f, 5.84293157e-02f, 4.07762825e-02f, -2.82022562e-02f, -3.66307274e-02f, -8.21049958e-02f, -2.52668075e-02f,
  -4.00833152e-02f, -4.80484590e-02f, 4.88140397e-02f, -6.75431034e-03f, 4.16224860e-02f, -4.66355719e-02f, -7.20284656e-02f, 3.29403765e-02f, 7.20966235e-02f, -1.91024621e-03f,
  2.90343612e-02f, 7.71722943e-02f, -1.33139677e-02f, -2.17587985e-02f, 4.52882648e-02f, -6.64020516e-03f, -9.21787322e-03f, 3.02185435e-02f, 5.50699830e-02f, -2.35203467e-02f,
  2.32840747e-01f, 1.31767020e-01f, 6.00197986e-02f, -2.10601129e-02f, 2.25734208e-02f, -1.92103758e-02f, 9.93900597e-02f, 6.68862686e-02f, -1.38425659e-02f, 9.62165091e-03f,
  5.07751629e-02f, 7.92474970e-02f, -9.89998039e-03f, -2.67716516e-02f, 6.64219186e-02f, -6.03238083e-02f, 3.79096307e-02f, 3.19917351e-02f, -3.31882015e-02f, -8.75279084e-02f,
  -6.89192712e-02f, 1.72365606e-02f, 1.58015788e-02f, 4.23048623e-02f, -3.63736115e-02f, 1.10590301e-01f, -1.79712661e-02f, 6.20273501e-02f, 1.18415676e-01f, -2.71189753e-02f,
  2.55268812e-01f, -1.46807432e-01f, -1.57518089e-01f, -9.23274308e-02f, -1.39782295e-01f, -7.13879764e-02f, -4.89963107e-02f, -7.16688260e-02f, 1.16098136e-01f, -9.77783352e-02f,
  -1.36881560e-01f, -2.02931301e-03f, 7.39542916e-02f, -6.66311458e-02f, -5.63166849e-03f, -8.76676887e-02f, 4.46815826e-02f, 1.58350356e-03f, 2.06503212e-01f, -4.83461581e-02f,
  -1.86142244e-03f, 1.08448766e-01f, 1.37133747e-01f, 7.79866055e-02f, -1.58316299e-01f, -4.91323508e-02f, -6.75388128e-02f, -4.71369959e-02f, -1.52343184e-01f, -1.21440761e-01f,
  -5.90933524e-02f, -2.16479942e-01f, 4.53324020e-02f, 1.62308961e-02f, -7.55898235e-03f, 5.22576869e-02f, 2.46943068e-02f, -1.46384621e-02f, -2.21453216e-02f, 3.33153233e-02f,
  -6.12100959e-02f, 1.39722005e-02f, -9.98419598e-02f, -3.95703688e-02f, -4.87336628e-02f, 4.29320335e-02f, -1.57070793e-02f, -1.21597961e-01f, -7.07382560e-02f, -3.07134874e-02f,
  -1.17124043e-01f, -6.72927275e-02f, 1.35799153e-02f, -1.29063679e-02f, -4.33491468e-02f, -1.00592393e-02f, -3.55053246e-02f, -1.27310559e-01f, -5.76708354e-02f, -2.48962566e-02f,
  -2.07177941e-02f, 1.67224966e-02f, -1.41835874e-02f, 4.40180674e-02f, 3.20192389e-02f, -2.04292051e-02f, 3.97690386e-02f, 7.84156919e-02f, 5.39483838e-02f, 1.09012602e-02f,
  2.14900561e-02f, 7.36408820e-03f, -8.23918730e-02f, 1.03618547e-01f, 5.33409324e-03f, -1.23352490e-01f, -6.17615804e-02f, -3.48978564e-02f, 1.32917473e-02f, 9.21968669e-02f,
  3.93955112e-02f, -1.13725429e-03f, -4.02858630e-02f, -6.60997629e-02f, -1.02052025e-01f, 1.30100735e-02f, 5.48043251e-02f, -1.05850540e-01f, -3.19404267e-02f, 6.09582057e-04f,
  1.68126047e-01f, -1.34596959e-01f, -2.53527761e-02f, 6.42997473e-02f, 2.90491041e-02f, 5.28595448e-02f, -2.87214294e-03f, 7.30634034e-02f, 8.25467706e-03f, 4.68924381e-02f,
  -9.17148814e-02f, 7.34419674e-02f, -9.35056955e-02f, 1.67190991e-02f, 7.90428519e-02f, 1.09901242e-02f, 2.99394247e-03f, 3.40684354e-02f, -8.06507170e-02f, -2.04972792e-02f,
  7.11791590e-02f, 1.57965168e-01f, 2.52005100e-01f, 1.22540168e-01f, -1.84812006e-02f, 5.76986484e-02f, 4.42497879e-02f, 1.39557356e-02f, 8.16434175e-02f, 2.83234268e-01f,
  3.16458851e-01f, 2.03169495e-01f, -1.15625756e-02f, 1.86427161e-01f, 1.13211058e-01f, -3.58456373e-02f, -2.90652062e-03f, -6.90577924e-02f, 8.77802297e-02f, 1.26977354e-01f,
  2.07837284e-01f, 1.80309892e-01f, 1.07520103e-01f, 1.55092971e-02f, 1.05280779e-01f, -4.44191247e-02f, -1.46172720e-03f, 1.28692687e-01f, 9.37338360e-03f, 1.39619857e-01f,
  1.02369815e-01f, 1.20257884e-01f, 1.47092685e-01f, -2.29193792e-02f, 1.74485192e-01f, 1.90876901e-01f, 1.73715781e-02f, 3.62248882e-03f, 1.27691299e-01f, 2.30924919e-01f,
  1.77989125e-01f, 1.13529645e-01f, -7.15341419e-02f, 1.26923516e-01f, -5.72635718e-02f, 3.58153880e-02f, 3.10806036e-02f, -5.02725244e-02f, 5.33564948e-02f, 1.65230595e-02f,
  4.75163013e-02f, 8.69883075e-02f, 4.48713303e-02f, -1.47001259e-02f, 5.66680357e-03f, 7.84719214e-02f, -1.63338762e-02f, 2.80169025e-02f, 3.99185084e-02f, 1.70774251e-01f,
  8.12885016e-02f, 4.92694378e-02f, 1.84963830e-02f, 2.53959782e-02f, 8.68355557e-02f, -1.33977998e-02f, 1.46057615e-02f, 1.46364514e-02f, -4.60887663e-02f, 7.78784528e-02f,
  2.38206412e-04f, -8.47113784e-03f, -2.05980055e-03f, 6.71633780e-02f, 2.68275924e-02f, -8.79460126e-02f, 7.02957213e-02f, -3.55964303e-02f, 2.23293714e-02f, -6.25090376e-02f,
  -8.04333240e-02f, 1.86859667e-02f, -7.66684674e-03f, -4.30292375e-02f, -6.46952391e-02f, 3.23848240e-02f, -6.11314957e-04f, 5.66810705e-02f, -4.73897196e-02f, 2.64984947e-02f,
  4.29525897e-02f, 3.63788125e-03f, -1.28366994e-02f, 2.19140388e-02f, -1.87108330e-02f, 5.29582892e-03f, -6.94086105e-02f, 8.36163536e-02f, -4.56355065e-02f, -1.18959341e-02f,
  -1.77915275e-01f, 4.07754630e-02f, -1.07500898e-02f, -6.18428662e-02f, -1.16619803e-01f, 4.65281382e-02f, 4.27633636e-02f, -2.80315243e-02f, 1.13448100e-02f, -6.46890327e-02f,
  1.53246685e-03f, -4.21042517e-02f, 2.22994778e-02f, -1.05298567e-03f, 3.41796614e-02f, 2.26695295e-02f, -1.03099190e-01f, 8.61954018e-02f, -8.44512507e-02f, 2.88130678e-02f,
  -2.41672080e-02f, -8.71372223e-02f, -4.87373136e-02f, -6.17787465e-02f, -3.54855135e-02f, 9.25313495e-03f, -1.05827279e-01f, -1.18761361e-02f, -8.95710289e-02f, -1.02698639e-01f,
  1.18842751e-01f, 8.38659480e-02f, 5.73744699e-02f, -9.88624990e-02f, -6.76552802e-02f, 3.75237130e-02f, -2.66118739e-02f, 1.07966596e-02f, -9.03327484e-03f, 6.96677789e-02f,
  -9.56339836e-02f, -8.60837102e-02f, -5.25898999e-03f, 2.45847367e-02f, 1.00212730e-01f, 9.13294628e-02f, -2.06201356e-02f, 1.97209954e-01f, 7.72891566e-02f, 1.85955912e-02f,
  1.04919104e-02f, 6.77892342e-02f, 1.14615425e-01f, 1.23469055e-01f, 2.47720219e-02f, -3.47944722e-02f, 4.50557610e-03f, 8.58232602e-02f, 1.24508969e-01f, 1.92020908e-01f,
  1.32448122e-01f, 1.95100866e-02f, -4.11358550e-02f, -3.25202420e-02f, 2.85870321e-02f, 8.93223938e-03f, -2.51433114e-03f, 8.63831043e-02f, -4.03637439e-02f, 4.22288515e-02f,
  8.36398229e-02f, 1.29829496e-01f, 4.71461425e-03f, 8.43846332e-03f, 1.22522853e-01f, 9.98420119e-02f, 5.54586984e-02f, -7.27928104e-03f, 5.89890182e-02f, -5.61755896e-02f,
  -1.44426022e-02f, 8.62156153e-02f, 6.66515008e-02f, -7.51975626e-02f, -2.10794322e-02f, -2.72314027e-02f, 2.82696374e-02f, -3.55006270e-02f, -4.28858772e-03f, 8.62092450e-02f,
  5.96373416e-02f, 6.41903952e-02f, -9.97641161e-02f, 1.46746179e-02f, -3.39100324e-02f, -8.64747271e-04f, -5.77104613e-02f, 1.02380246e-01f, -6.43543452e-02f, -5.58014102e-02f,
  -5.60087115e-02f, 2.41258629e-02f, -4.08295728e-02f, 8.27196985e-02f, -7.71891922e-02f, 1.66785587e-02f, -8.87324661e-02f, 6.00987524e-02f, 6.77907839e-02f, 2.79916413e-02f,
  1.21957704e-03f, 8.80939886e-02f, -6.40398934e-02f, 3.34817125e-03f, -6.65984526e-02f, 9.89400875e-03f, 1.18435156e-02f, -1.53833302e-03f, -5.56159616e-02f, 6.56390339e-02f,
  5.79252280e-02f, -1.88912734e-01f, -6.19651638e-02f, 1.28250206e-02f, -5.35149202e-02f, -2.16729622e-02f, -3.10835615e-02f, 2.38579605e-02f, -1.20603396e-02f, 8.21977556e-02f,
  -4.74616215e-02f, 5.79538345e-02f, -9.13001373e-02f, 6.39758930e-02f, 1.02206871e-01f, -3.92601267e-02f, 6.09350093e-02f, -6.72237203e-02f, 1.68065634e-03f, -2.12371014e-02f,
  -1.54358484e-02f, -8.24326128e-02f, -3.27262888e-03f, -6.41711876e-02f, -7.11698309e-02f, -7.48756006e-02f, 5.09832129e-02f, 3.59174833e-02f, -5.56761585e-02f, 1.21791176e-01f,
  -1.03321463e-01f, -2.25227233e-02f, -1.48698479e-01f, 1.13761760e-02f, -3.72326784e-02f, -8.64047185e-02f, -3.96075882e-02f, 1.42288789e-01f, -6.41261833e-03f, -8.83588940e-02f,
  -8.35825428e-02f, 7.35943168e-02f, 3.65688689e-02f, -4.17510867e-02f, -3.36445123e-02f, -1.22673802e-01f, -1.96137339e-01f, -1.07630841e-01f, 1.04820490e-01f, -8.49184766e-03f,
  -6.27082139e-02f, -8.45333338e-02f, -3.58259864e-02f, -2.03474574e-02f, -1.18201822e-01f, -8.41278210e-02f, -1.19056448e-01f, -1.28082424e-01f, -1.00912087e-01f, -2.09192529e-01f,
  -1.17142096e-01f, 2.76715811e-02f, -5.17845247e-03f, 6.34736344e-02f, -1.09908342e-01f, 1.16070725e-01f, 1.62711758e-02f, -4.03366983e-02f, 1.18142687e-01f, -2.17637513e-02f,
  -1.96104031e-02f, -1.38184987e-02f, -3.45706418e-02f, -1.95778366e-02f, -1.14091439e-02f, -9.03551280e-02f, 5.76891080e-02f, 5.08943684e-02f, 1.86220985e-02f, -2.99126953e-02f,
  -7.26125464e-02f, -7.06267506e-02f, 6.08689860e-02f, 9.77981687e-02f, -5.59875295e-02f, 9.65700969e-02f, -5.16567081e-02f, -4.40224912e-03f, -1.63709354e-02f, -1.09920710e-01f,
  6.42432040e-03f, -2.35326122e-02f, -9.49461944e-03f, -1.82044413e-02f, -2.01878976e-02f, 4.32224981e-02f, -6.05865456e-02f, 7.42088333e-02f, -9.20434296e-03f, 5.48628941e-02f,
  -9.00024362e-03f, -1.88970901e-02f, -4.68524583e-02f, 5.31383939e-02f, -3.02863307e-02f, 2.69799866e-03f, -6.42039701e-02f, 1.19462721e-02f, -1.09402001e-01f, -3.29835750e-02f,
  1.99796036e-02f, -3.15480903e-02f, -6.88191131e-02f, 4.19405699e-02f, 6.23282511e-03f, -2.65929778e-03f, 1.24534711e-01f, 1.17520235e-01f, 6.53557852e-02f, 3.18792276e-02f,
  1.71638250e-01f, -1.38872460e-01f, -8.25537890e-02f, 8.06897059e-02f, 8.72334186e-03f, -3.99406925e-02f, -2.01049931e-02f, -1.65554567e-03f, 3.04106753e-02f, 2.43019257e-02f,
  8.69099498e-02f, 1.08947806e-01f, -1.22396946e-02f, 1.49073480e-02f, 8.22259858e-02f, 8.64770040e-02f, -2.56941654e-02f, -5.41810282e-02f, -8.80734324e-02f, -6.39598519e-02f,
  -9.45209414e-02f, -3.98276486e-02f, 6.84442520e-02f, -1.78171527e-02f, 1.00086875e-01f, 4.45472449e-02f, 1.65268779e-02f, -6.77789375e-03f, -4.74239560e-03f, -3.09822205e-02f,
  -5.93952656e-01f, -1.92194089e-01f, -1.64256915e-01f, -3.36148292e-01f, -1.28410548e-01f, 1.90914586e-01f, 6.71186596e-02f, 2.24678174e-01f, -2.70927493e-02f, -2.61623859e-01f,
  -7.73700178e-02f, -1.39895365e-01f, -2.18503490e-01f, 7.55611658e-02f, 9.17190537e-02f, -1.00926481e-01f, -1.34490952e-01f, -1.75878733e-01f, 1.01210341e-01f, 2.79796064e-01f,
  5.27325608e-02f, -2.20124379e-01f, -1.79885238e-01f, 3.04693934e-02f, 4.48725739e-04f, -6.46305606e-02f, -2.04521865e-01f, -1.56153187e-01f, 1.68269306e-01f, -3.12819451e-01f,
  -3.90780747e-01f, -1.32056281e-01f, 5.94088400e-04f, 1.96859930e-02f, -6.07372522e-02f, 1.26896962e-03f, 2.81092338e-02f, -1.48919970e-01f, 2.85607446e-02f, 2.65452359e-02f,
  -1.26887068e-01f, 6.22385405e-02f, 2.02552117e-02f, -6.23654239e-02f, -2.35582646e-02f, 1.95005257e-02f, 4.75377496e-03f, -7.99569637e-02f, -2.87572145e-02f, 7.89626464e-02f,
  1.91218331e-02f, 8.99899658e-03f, 5.72298430e-02f, 8.79744068e-02f, 1.70005754e-01f, -4.39938121e-02f, 2.52806582e-02f, 3.72900814e-02f, 1.38153315e-01f, -7.94092491e-02f,
  -5.14381081e-02f, -5.72936907e-02f, -5.37448414e-02f, 5.39992787e-02f, 7.74756819e-02f, -1.54469917e-02f, -3.53833986e-03f, -4.55032922e-02f, 5.10822199e-02f, -7.53219798e-02f,
  -4.35850285e-02f, 9.37878340e-03f, -3.67060937e-02f, -6.95373490e-02f, 4.08382080e-02f, -4.40991893e-02f, -9.13024098e-02f, 7.92370215e-02f, 4.19194438e-02f, -3.20497938e-02f,
  -2.63629444e-02f, 1.76539402e-02f, -9.14524049e-02f, 6.63480088e-02f, -2.34247316e-02f, -7.32005686e-02f, 3.74706872e-02f, 6.27471507e-02f, -4.88612093e-02f, 2.82007791e-02f,
  -1.83508813e-01f, 5.53314723e-02f, -1.18916273e-01f, -3.38649284e-03f, -3.30276997e-03f, 3.37954983e-02f, -7.34697506e-02f, 6.31411299e-02f, -5.93933426e-02f, 3.48063484e-02f,
  5.99543229e-02f, 7.79120019e-03f, -3.72457728e-02f, 6.56217188e-02f, 4.51838924e-03f, 8.13937560e-02f, 3.68344672e-02f, -3.22592668e-02f, 1.20228812e-01f, 1.01829097e-01f,
  3.40317935e-02f, 2.81190369e-02f, -1.45901993e-01f, -9.06541124e-02f, 3.21725830e-02f, -2.28042994e-02f, -1.27353296e-01f, -7.91467354e-03f, 8.27932078e-03f, -2.18934342e-01f,
  -1.90259591e-01f, -1.57057524e-01f, -2.53740605e-02f, -8.35101008e-02f, 4.89596240e-02f, 1.25261962e-01f, 1.24215940e-02f, 2.71382276e-02f, 3.15524302e-02f, -1.85984243e-02f,
  -9.40122530e-02f, 3.47599499e-02f, -1.40722748e-02f, 5.91145689e-03f, 3.39549705e-02f, 6.58127144e-02f, 1.35746017e-01f, -1.47557268e-02f, 6.68614358e-02f, 1.48896202e-01f,
  1.00546308e-01f, 8.37750733e-02f, 6.30363747e-02f, 8.73042941e-02f, 3.72278020e-02f, 1.71937551e-02f, 7.07778856e-02f, -5.84798260e-03f, -3.86182107e-02f, 4.79522422e-02f,
  3.54833119e-02f, -1.27754331e-01f, 6.71873465e-02f, 6.40488928e-03f, -1.00171931e-01f, 1.48959889e-03f, -7.14523718e-02f, -1.09757379e-01f, -4.25993279e-02f, 6.56857267e-02f,
  7.85677508e-02f, -8.19188729e-02f, -3.16677913e-02f, 3.37187015e-02f, -4.51377854e-02f, 6.11748770e-02f, 3.49208675e-02f, -7.13563040e-02f, 1.57888569e-02f, -3.75362113e-02f,
  -2.29505636e-02f, -5.33071123e-02f, -2.69920900e-02f, 1.23632111e-01f, -4.34624264e-03f, -2.91853361e-02f, -6.63901120e-03f, 5.52064776e-02f, -5.50409928e-02f, -4.72417399e-02f,
  -2.06420124e-02f, 1.12695703e-02f, -7.28795826e-02f, -6.10915050e-02f, -6.30082786e-02f, -3.80613655e-03f, 4.59245555e-02f, 5.36636822e-03f, -6.48810109e-03f, 2.13975050e-02f,
  2.79179644e-02f, -7.10514113e-02f, -3.49924713e-02f, -8.73664580e-03f, -8.05071834e-03f, 5.69464872e-03f, 3.01491050e-03f, -2.67171804e-02f, 4.25723344e-02f, 5.42384870e-02f,
  2.02413695e-03f, 1.33089526e-02f, -9.07814428e-02f, 4.50072587e-02f, -4.36046347e-02f, -2.55583250e-03f, 7.63032883e-02f, 6.21049926e-02f, -1.10324368e-01f, 5.62203191e-02f,
  -3.33496034e-02f, 7.71091878e-02f, 3.05940639e-02f, -3.02106738e-02f, 5.75948507e-02f, -2.62130611e-02f, -9.99444425e-02f, 3.24162915e-02f, 7.20882937e-02f, -2.50694063e-02f,
  -7.05616772e-02f, -6.26840964e-02f, -1.36858039e-02f, -4.98424880e-02f, -8.12612697e-02f, -7.73489699e-02f, -7.73530081e-03f, -4.51835468e-02f, 1.14013059e-02f, 3.01342569e-02f,
  4.56960499e-02f, -5.22983551e-04f, -3.13953459e-02f, 5.22149391e-02f, 7.77345225e-02f, -3.63968909e-02f, 4.33891527e-02f, -3.90661955e-02f, -1.43115474e-02f, -1.40586179e-02f,
  2.39251256e-01f, -2.18103364e-01f, -2.98219144e-01f, -1.86546177e-01f, -1.09193623e-01f, -9.77322012e-02f, -1.25737488e-01f, 1.61577128e-02f, 5.27389385e-02f, -1.16030693e-01f,
  4.98833060e-02f, 2.38217294e-01f, 6.02176636e-02f, 1.66460410e-01f, 1.64027274e-01f, -1.96572930e-01f, -1.64953977e-01f, 6.82462752e-02f, 1.15114577e-01f, 1.65967837e-01f,
  -3.36983912e-02f, -8.49400535e-02f, -8.23408142e-02f, -4.40888386e-03f, -1.83419585e-01f, 6.76714554e-02f, -1.89590394e-01f, -2.41030306e-01f, 3.52217034e-02f, -2.92564571e-01f,
  -1.75587282e-01f, 9.46596712e-02f, 1.37835696e-01f, 1.09343857e-01f, -9.03874263e-02f, 7.74809197e-02f, 5.59356846e-02f, 6.67082220e-02f, 6.39697863e-03f, 5.51808439e-02f,
  4.61434200e-02f, 7.06453715e-03f, 3.00951321e-02f, -5.96642727e-03f, 1.47286209e-03f, 3.62071432e-02f, -3.89111042e-02f, 5.04659675e-02f, 5.40074334e-02f, -9.00206864e-02f,
  -1.30998418e-01f, 1.04943216e-02f, 1.26044065e-01f, 1.12099135e-02f, 5.00068888e-02f, 1.52511701e-01f, -5.54727018e-02f, -2.79891980e-03f, 8.05584118e-02f, -6.85382858e-02f,
  -4.42670733e-02f, 3.14972438e-02f, 4.31812778e-02f, 6.84775338e-02f, 4.37199278e-03f, 1.26106003e-02f, 1.01497360e-02f, -4.97568101e-02f, 4.75769714e-02f, -5.74641600e-02f,
  3.25286500e-02f, -2.24940479e-02f, 1.46656903e-02f, -1.41272442e-02f, -1.27132952e-01f, 3.85903418e-02f, 5.48290424e-02f, -8.78629759e-02f, 8.24700966e-02f, 4.94123287e-02f,
  5.63193113e-03f, 7.90380016e-02f, -3.30754817e-02f, -9.48990788e-03f, -2.56360918e-02f, 3.90879661e-02f, -3.37156877e-02f, 5.77767752e-02f, -4.25472073e-02f, 1.12611912e-01f,
  -1.12223409e-01f, 1.66769028e-01f, -1.70845669e-02f, -5.42564839e-02f, 1.31541137e-02f, -5.39907962e-02f, -3.92808914e-02f, -6.14258237e-02f, -3.75417992e-02f, -4.88465233e-03f,
  7.20370486e-02f, -6.91406131e-02f, -7.16744810e-02f, 4.08942588e-02f, -6.02657646e-02f, 4.87401895e-02f, -3.28726391e-03f, 4.37189303e-02f, -2.35418370e-03f, -1.47034407e-01f,
  -5.86431287e-02f, -6.60993392e-03f, 1.86931551e-01f, -3.28245498e-02f, 5.00594091e-04f, 1.47234634e-01f, 1.04827248e-01f, 6.59807702e-05f, 1.49466306e-01f, -3.72696705e-02f,
  -5.32345176e-02f, -1.63674086e-01f, -1.24216154e-01f, 2.30163783e-02f, -6.03306293e-02f, 8.16671178e-03f, -1.03947252e-01f, 1.02480881e-01f, 2.00412981e-03f, -1.71272293e-01f,
  2.57991645e-02f, 1.29439130e-01f, -3.47548574e-02f, 1.93049368e-02f, 8.26847553e-02f, -1.18184239e-01f, -1.68425411e-01f, -2.53899805e-02f, 1.16515376e-01f, 9.64819491e-02f,
  4.11436148e-02f, -2.88367625e-02f, -1.82856042e-02f, -1.55840265e-02f, -6.55405596e-02f, -1.08201273e-01f, -2.42818996e-01f, -5.64946532e-02f, -3.88978906e-02f, -3.28159660e-01f,
  -1.21393740e-01f, -2.02667899e-02f, 1.02710351e-01f, -1.58008952e-02f, -1.03850983e-01f, -5.14629260e-02f, 9.42651033e-02f, -6.14861548e-02f, -2.19209166e-03f, 1.61871538e-02f,
  -2.63626818e-02f, -1.32338023e-02f, 2.68710628e-02f, -8.78507346e-02f, -6.13516010e-02f, 5.38859628e-02f, 1.33338552e-02f, 4.67575006e-02f, 5.54483663e-03f, -4.76042321e-03f,
  8.65868181e-02f, -2.67569963e-02f, -9.05347690e-02f, 6.85900375e-02f, 1.05835415e-01f, 4.04727608e-02f, 7.28974268e-02f, 3.22591886e-02f, -7.22207874e-02f, -8.98824409e-02f,
  2.18892824e-02f, 1.07228965e-01f, 7.72375381e-03f, -2.63531618e-02f, 1.95993036e-02f, -6.02961630e-02f, 1.34929325e-02f, -6.93675783e-03f, -6.54251268e-03f, -5.22189140e-02f,
  2.19917819e-02f, -3.63995843e-02f, 9.65043232e-02f, 8.86415765e-02f, -6.98620602e-02f, -6.57516792e-02f, 8.15258175e-02f, 1.65383276e-02f, -8.41094255e-02f, -4.34096158e-02f,
  -5.35553172e-02f, 3.31906714e-02f, -1.39851803e-02f, 1.85538139e-02f, 6.92247748e-02f, 5.67773432e-02f, -2.01302078e-02f, -5.47548942e-02f, -6.07880466e-02f, -8.67256299e-02f,
  2.05594450e-02f, 1.68898236e-02f, -3.04919276e-02f, 1.23555690e-01f, 3.41105722e-02f, -6.02944382e-02f, -9.09777582e-02f, 4.03232686e-02f, 2.29532812e-02f, 6.17371649e-02f,
  3.94381210e-02f, 8.84205196e-03f, -4.60466035e-02f, 3.45526487e-02f, -1.18000032e-02f, 6.61632046e-02f, -6.37561232e-02f, -8.37916508e-02f, 1.20692588e-01f, 6.07670844e-02f,
  -2.43598446e-02f, -1.16074242e-01f, 9.98940319e-03f, 6.00427352e-02f, -1.13914357e-02f, -8.31026882e-02f, -6.58986643e-02f, 1.79627743e-02f, 6.93645254e-02f, -2.29639132e-02f,
  -1.06737629e-01f, 9.56859291e-02f, -8.65246728e-02f, -1.45721748e-01f, -1.00660034e-01f, -9.84656140e-02f, -5.31794224e-03f, -1.18140876e-02f, -7.03736097e-02f, -3.29925045e-02f,
  -5.66272996e-02f, 1.61897112e-02f, -9.85110179e-02f, 3.38801742e-02f, -2.60800682e-02f, -7.63095617e-02f, -1.05818748e-01f, -1.40501902e-01f, -1.16720438e-01f, -4.86275181e-02f,
  1.26427021e-02f, -4.64503914e-02f, -1.01792673e-02f, 1.82461347e-02f, -9.10511762e-02f, 3.29121463e-02f, 3.06337122e-02f, -1.26993388e-01f, -1.11188829e-01f, -6.68838844e-02f,
  1.44081833e-02f, -2.20704809e-01f, -1.35200405e-02f, -6.95450157e-02f, -9.32390913e-02f, -4.27866774e-03f, -8.38390067e-02f, -6.66441070e-03f, -7.90909976e-02f, -7.26496577e-02f,
  1.87084880e-02f, 4.14920365e-03f, -9.31131020e-02f, -6.21593222e-02f, 5.51260039e-02f, -4.93365806e-03f, 8.29510018e-02f, -9.36845224e-03f, 3.73226963e-02f, -5.75179607e-03f,
  -4.09269668e-02f, -1.23148181e-01f, 1.79033391e-02f, 6.71587810e-02f, 6.34635910e-02f, -5.11060916e-02f, 7.34941959e-02f, -6.60420135e-02f, 9.49384738e-03f, 1.01212829e-01f,
  7.19265863e-02f, -1.77932121e-02f, 1.56136872e-02f, 2.17225775e-02f, 7.52306506e-02f, 1.10813770e-02f, 2.52526049e-02f, -1.55850025e-02f, 2.70915944e-02f, -2.88326666e-02f,
  1.31535977e-02f, -7.46707246e-02f, -3.07532009e-02f, 5.62526621e-02f, 5.48481867e-02f, -5.30458130e-02f, 2.88429614e-02f, 1.34500451e-02f, -5.41275479e-02f, 2.64946800e-02f,
  1.49106933e-02f, -1.01949185e-01f, -4.36892547e-02f, -3.57053131e-02f, 2.19373573e-02f, -1.54974377e-02f, -1.64737664e-02f, 7.14779347e-02f, -2.05868762e-02f, -6.47278205e-02f,
  1.21737473e-01f, -1.25406653e-01f, 1.36793060e-02f, -1.03246595e-03f, -3.93681228e-02f, 6.48320047e-03f, -7.30199441e-02f, 3.53019908e-02f, 3.64966206e-02f, 5.18701226e-02f,
  -6.75852150e-02f, 1.07980063e-02f, 6.44481629e-02f, 8.72893706e-02f, 5.95650785e-02f, -4.76464033e-02f, 1.97589714e-02f, 8.16422030e-02f, 3.75420265e-02f, 2.06899755e-02f,
  1.60945699e-01f, -4.36190190e-03f, 6.82264417e-02f, 1.20749652e-01f, 7.73618147e-02f, 4.34580520e-02f, 5.40680587e-02f, 5.23819029e-03f, -1.72754172e-02f, 2.42982417e-01f,
  7.05666766e-02f, -1.12901805e-02f, -2.09670231e-01f, -6.78968709e-03f, 7.47434497e-02f, -1.78525131e-02f, -8.84705931e-02f, -3.13782915e-02f, 5.03603183e-02f, -1.40544161e-01f,
  -7.81999007e-02f, -6.40072972e-02f, -1.26881048e-01f, -1.33998558e-01f, -1.82388991e-01f, -2.37857401e-01f, -1.03256375e-01f, -7.47773200e-02f, -1.20843783e-01f, -1.90466106e-01f,
  -2.78993752e-02f, -3.65697518e-02f, -5.24334125e-02f, -7.41647705e-02f, 4.54169586e-02f, 8.53529274e-02f, -8.60489234e-02f, 9.21017826e-02f, -6.43778965e-02f, 1.28945053e-01f,
  -6.07669055e-02f, -6.00290224e-02f, -8.12230185e-02f, 3.72725800e-02f, 7.65130967e-02f, 1.10623226e-01f, 3.19639929e-02f, 1.11212485e-01f, -7.78106079e-02f, -7.76262069e-03f,
  -6.50935546e-02f, 4.25191522e-02f, 6.04207478e-02f, 4.91110273e-02f, -1.15877472e-01f, -6.30374551e-02f, -2.09203288e-02f, -1.64975658e-01f, -3.19830179e-02f, 7.04347864e-02f,
  4.45258990e-02f, 7.23021030e-02f, -2.90062581e-03f, -4.87418436e-02f, 4.83144931e-02f, 3.13401292e-03f, -1.84303597e-02f, 5.99638000e-02f, 1.74489748e-02f, -6.37626695e-03f,
  -8.07043985e-02f, -2.74117291e-02f, 7.38926828e-02f, -1.21598365e-02f, 3.59631516e-02f, -1.05007999e-01f, 9.24430788e-03f, -7.21257627e-02f, -4.67176959e-02f, 9.29902494e-03f,
  -6.59289286e-02f, -6.13313094e-02f, 1.04245000e-01f, -8.05756152e-02f, -1.43825840e-02f, -2.38259397e-02f, -1.12269009e-02f, 6.62559597e-03f, -3.39456052e-02f, 8.55098367e-02f,
  -9.15311575e-02f, -2.41722185e-02f, -3.09029724e-02f, 3.32952254e-02f, 6.93771765e-02f, -2.46933615e-03f, -5.75736631e-03f, -6.11000508e-03f, -5.11925556e-02f, 6.23562150e-02f,
  -9.14669782e-02f, -1.47186995e-01f, -3.66051011e-02f, -3.77391502e-02f, -1.20835910e-02f, 2.25334577e-02f, -1.27210207e-02f, -1.31197162e-02f, -9.66420546e-02f, 3.64052178e-03f,
  -1.27636530e-02f, -9.03009698e-02f, -7.53087103e-02f, 3.68469991e-02f, -1.06326222e-01f, -6.57173246e-02f, -3.23564336e-02f, -1.12499557e-02f, -1.44326821e-01f, -4.31420915e-02f,
  -9.10870284e-02f, -6.13267682e-02f, -1.72709420e-01f, -7.84295350e-02f, -8.44408721e-02f, -1.54558644e-01f, -1.36966810e-01f, -6.85191303e-02f, -7.80983865e-02f, -8.85363594e-02f,
  1.26038671e-01f, -8.52552652e-02f, -9.11700502e-02f, 1.55203352e-02f, -1.21449225e-01f, -2.30384730e-02f, -1.44084647e-01f, -1.08056560e-01f, -7.32586812e-03f, -1.38188034e-01f,
  -1.50079787e-01f, -9.69170108e-02f, 1.69660095e-02f, -8.10455903e-03f, -2.75431778e-02f, -5.07949926e-02f, 9.34919063e-03f, -6.07022122e-02f, 1.26509666e-01f, -8.23224336e-02f,
  -7.08120223e-03f, 3.29870358e-03f, 6.61104545e-03f, -1.43223098e-02f, -3.34688015e-02f, -5.86151984e-03f, -1.03516884e-01f, -1.42168418e-01f, -2.38946620e-02f, -1.85217589e-01f,
  1.33731037e-01f, 5.51191829e-02f, 1.99634153e-02f, -3.75467055e-02f, -4.18813154e-02f, -9.36548337e-02f, 3.92019674e-02f, 5.99860325e-02f, 5.62972166e-02f, -7.98534527e-02f,
  9.08524822e-03f, 4.79398556e-02f, 9.26291104e-03f, 1.16683403e-02f, -2.90436158e-03f, -4.75539714e-02f, -7.93845803e-02f, 2.46759765e-02f, 3.33853886e-02f, -1.75511260e-02f,
  1.59169305e-02f, -7.74046108e-02f, 2.95572425e-03f, 8.44904035e-02f, 3.37263830e-02f, 4.15335149e-02f, -2.58674808e-02f, -7.25954492e-03f, 7.78785571e-02f, -5.16840294e-02f,
  -3.34560238e-02f, 9.42372829e-02f, 5.75843714e-02f, -4.50845174e-02f, 2.23660804e-02f, 3.80955562e-02f, -2.43605189e-02f, 1.23054627e-02f, -2.60053948e-02f, -6.94895312e-02f,
  -6.71679154e-02f, 9.39377397e-02f, -5.17636798e-02f, -6.69766441e-02f, -8.34091082e-02f, 4.04637903e-02f, 5.92588596e-02f, -3.93501148e-02f, -1.10412799e-01f, -7.53133520e-02f,
  -1.05603822e-01f, -6.03793338e-02f, -4.56175730e-02f, 2.43096482e-02f, -8.37710649e-02f, 4.18532230e-02f, 4.80113216e-02f, 5.59790432e-02f, -2.95586120e-02f, -2.05835663e-02f,
  1.62052840e-01f, 6.15127571e-02f, -4.71040867e-02f, 1.23813574e-03f, 4.48765121e-02f, -8.93027559e-02f, -9.78916511e-02f, -4.10942361e-02f, 4.23888154e-02f, 2.37237941e-02f,
  -1.03368647e-02f, -3.50637250e-02f, -5.07606864e-02f, 2.23238003e-02f, 1.90640576e-02f, -7.11830482e-02f, 4.63682786e-02f, 3.65650505e-02f, -3.44132632e-02f, -1.19741507e-01f,
  -6.84470776e-03f, 2.77345665e-02f, 1.60408005e-01f, 6.11474626e-02f, 8.78095627e-02f, 1.24057204e-01f, 5.07911369e-02f, 2.80659553e-02f, 1.02442779e-01f, 1.59354061e-01f
};

// L0_fan_Bp_bar (Shape: 1 x 20)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 20;
const float L0_fan_Bp_bar_data[] = {
  7.54504874e-02f, 4.07310091e-02f, -7.00414181e-02f, -9.54601392e-02f, 6.48398697e-02f, 8.62099603e-02f, 5.99532155e-03f, 1.77852616e-01f, 1.51391387e-01f, 1.99591100e-01f,
  1.05949007e-01f, 5.78699354e-03f, 5.70325889e-02f, 2.44797856e-01f, 6.81506693e-02f, 1.86813295e-01f, 2.46958304e-02f, 2.14255869e-01f, -3.81639078e-02f, 5.57906404e-02f
};

// L1_fan_Wp (Shape: 6 x 32)
const int L1_fan_Wp_rows = 6;
const int L1_fan_Wp_cols = 32;
const float L1_fan_Wp_data[] = {
  4.21151996e-01f, -2.25513935e-01f, -6.67318255e-02f, 9.12069753e-02f, -5.28533459e-02f, 2.81949699e-01f, 2.09066998e-02f, -6.38815686e-02f, 2.96660513e-01f, -3.55433792e-01f,
  7.37077817e-02f, -2.18320459e-01f, 2.50824131e-02f, 7.02684596e-02f, 7.07761794e-02f, -3.88623625e-01f, 4.37209941e-02f, 2.68843472e-01f, -8.86954658e-04f, -1.32377474e-02f,
  -2.62177587e-01f, -4.58932258e-02f, -2.43019268e-01f, 2.55160391e-01f, 4.25850712e-02f, -2.45284066e-01f, 2.39040181e-01f, -2.64371365e-01f, -1.50335029e-01f, 9.36453044e-02f,
  7.77759328e-02f, 7.16420561e-02f, -5.24354696e-01f, 3.30383211e-01f, -4.65813186e-03f, -2.83888243e-02f, 2.15849727e-01f, -1.95778668e-01f, 1.58074826e-01f, -2.31823340e-01f,
  -6.56592324e-02f, 4.35335338e-01f, 1.28916740e-01f, -8.50587487e-02f, 1.09829679e-01f, -1.10728778e-01f, 2.40630638e-02f, -2.62707859e-01f, -2.11077675e-01f, -2.01761574e-01f,
  1.60640717e-01f, 1.83253869e-01f, -2.18998700e-01f, 1.60530418e-01f, -1.06544718e-01f, 2.39296690e-01f, -2.43525803e-01f, 1.21404575e-02f, 6.72776848e-02f, -1.90088868e-01f,
  -7.21113458e-02f, 1.81872677e-02f, -1.83667719e-01f, -8.68870318e-02f, 3.03504527e-01f, -2.29283288e-01f, -1.79127783e-01f, -2.08139643e-01f, -9.43075120e-02f, -6.06283695e-02f,
  -1.79831609e-02f, -1.93225726e-01f, 2.42350042e-01f, -1.40350133e-01f, -6.91977888e-02f, -2.82326881e-02f, -6.61469325e-02f, -3.93157676e-02f, 1.90008089e-01f, -2.08416209e-01f,
  -1.50443226e-01f, 6.05305545e-02f, -1.50877893e-01f, -1.57135338e-01f, -7.53127038e-02f, -5.87307997e-02f, 2.54330218e-01f, 6.51493296e-02f, 2.12810829e-01f, -3.58196884e-01f,
  -1.37655646e-01f, -1.49367541e-01f, -1.73193272e-02f, 4.11588177e-02f, 2.37778321e-01f, -4.73340303e-02f, 7.76799619e-02f, 1.29364982e-01f, -1.04796931e-01f, -1.40977383e-01f,
  -2.48617996e-02f, 3.12547714e-01f, 1.73342407e-01f, -1.68977901e-01f, 2.56749928e-01f, -3.37353140e-01f, 1.31759495e-01f, -2.00410813e-01f, 1.26494676e-01f, 6.66276217e-02f,
  9.74541381e-02f, -1.40402019e-01f, 1.09126769e-01f, 1.40176546e-02f, -1.02111086e-01f, 7.36037120e-02f, -2.62047291e-01f, -1.76070556e-01f, -7.75137991e-02f, 1.65483639e-01f,
  -3.89908887e-02f, -2.87773073e-01f, -7.82580022e-03f, -2.94069827e-01f, -2.68893033e-01f, 1.70019552e-01f, 1.92706928e-01f, 1.15636654e-01f, -1.18460804e-01f, 2.20642656e-01f,
  3.64669822e-02f, -1.27579682e-02f, 3.09143245e-01f, -6.12942204e-02f, 9.17368531e-02f, -2.55752444e-01f, -9.09225419e-02f, 3.10155541e-01f, 1.35524720e-01f, -4.33849245e-02f,
  -1.05232693e-01f, 6.78821132e-02f, 1.12635627e-01f, -2.44492725e-01f, -4.70561162e-02f, 1.33769378e-01f, -1.25793859e-01f, 1.04575437e-02f, -9.79924425e-02f, 1.58546865e-01f,
  -9.70552489e-02f, 1.69971704e-01f, 4.49093431e-02f, -1.14302248e-01f, -2.26867050e-02f, -1.57535836e-01f, -9.64309871e-02f, 1.56083465e-01f, -2.19739631e-01f, 3.48787382e-02f,
  -2.96774864e-01f, 3.17545116e-01f, 8.67727026e-02f, 1.01410784e-01f, 3.79901528e-02f, 9.86397117e-02f, -1.28604069e-01f, -3.35840359e-02f, 1.15750089e-01f, 2.19636336e-01f,
  3.55165243e-01f, 1.33570477e-01f, 7.38683268e-02f, -1.34452470e-02f, -5.30806556e-02f, 1.87366277e-01f, -1.06303893e-01f, -1.64462492e-01f, 8.75682011e-03f, -1.51144518e-02f,
  -9.57708210e-02f, -9.40873548e-02f, 2.36519709e-01f, -7.17031732e-02f, -1.46745637e-01f, -3.58235314e-02f, -1.57398377e-02f, -3.61692250e-01f, -1.18885271e-01f, 1.52113870e-01f,
  1.67560354e-01f, 4.54053096e-03f
};

// L1_fan_Wp_bar (Shape: 20 x 32)
const int L1_fan_Wp_bar_rows = 20;
const int L1_fan_Wp_bar_cols = 32;
const float L1_fan_Wp_bar_data[] = {
  1.09465420e-01f, -2.49744691e-02f, -1.70587659e-01f, 3.43471803e-02f, -6.83248788e-02f, 4.45173681e-02f, -1.41092569e-01f, -1.32017760e-02f, 7.67698437e-02f, 1.21118166e-01f,
  -1.15198351e-01f, -1.23981334e-01f, 1.78539068e-01f, 5.11696823e-02f, 4.28324901e-02f, -1.71765573e-02f, 3.03841545e-03f, 6.59531131e-02f, 9.05985013e-02f, 9.48754027e-02f,
  6.82803020e-02f, -6.77487180e-02f, -8.18505734e-02f, -1.36528715e-01f, -1.24401562e-01f, 4.45397850e-03f, 6.71398360e-03f, 1.14173209e-02f, -8.67796689e-02f, -8.09668005e-02f,
  1.58500120e-01f, -1.18148535e-01f, 3.93498719e-01f, 5.68530820e-02f, 1.83125153e-01f, 4.07371461e-01f, -6.90312684e-02f, 5.43314278e-01f, -1.14636615e-01f, 1.30901262e-01f,
  4.17620808e-01f, 9.06152204e-02f, -1.26126960e-01f, -1.32072836e-01f, 1.12801313e-01f, 2.52579525e-02f, -1.70343667e-01f, -1.55334160e-01f, 1.42572641e-01f, 2.47330114e-01f,
  1.96789443e-01f, 1.36561841e-01f, 2.26183236e-02f, 4.39248309e-02f, -2.71921039e-01f, -1.07175007e-01f, 3.01287383e-01f, 7.04655886e-01f, 7.10022077e-02f, 3.19613457e-01f,
  2.61785835e-01f, 1.04226343e-01f, -2.10681215e-01f, 4.06807289e-02f, 1.25037745e-01f, 1.04268171e-01f, 2.46810794e-01f, 9.61136967e-02f, 1.30636603e-01f, 2.88796097e-01f,
  -8.61126333e-02f, 1.39948860e-01f, -3.07371151e-02f, -1.27951568e-02f, 2.97989100e-01f, 8.74490589e-02f, 2.19625875e-01f, 2.64875144e-02f, -1.54421613e-01f, 1.27842883e-02f,
  5.22873998e-02f, -1.15785122e-01f, -1.19140163e-01f, 1.03990743e-02f, -1.88264757e-01f, 1.46356234e-02f, 4.92478237e-02f, 1.51118413e-01f, 1.09453663e-01f, -5.55016249e-02f,
  -9.34849158e-02f, -1.94217026e-01f, -3.05220298e-02f, -1.42444864e-01f, -2.93559511e-03f, -1.78781271e-01f, 1.02830574e-01f, 1.45946056e-01f, -2.01836810e-03f, -8.44810456e-02f,
  2.00875416e-01f, 5.75571619e-02f, 3.35798055e-01f, -6.53595626e-02f, -6.58465549e-02f, 5.77383153e-02f, 1.20055042e-01f, -6.15102947e-02f, -1.37711599e-01f, -1.00081287e-01f,
  -7.32288733e-02f, -4.08617780e-02f, 1.17563248e-01f, 1.01075746e-01f, 1.28206700e-01f, 9.02603418e-02f, -1.31676897e-01f, 1.19405314e-02f, 1.83984771e-01f, 1.32178813e-01f,
  -1.86490312e-01f, -1.70963239e-02f, -1.53455019e-01f, 6.20026030e-02f, -1.69785872e-01f, -6.50212839e-02f, 4.07750420e-02f, -1.17513187e-01f, 2.40926966e-01f, 1.54302776e-01f,
  8.68584067e-02f, 1.00174941e-01f, 4.52834778e-02f, 3.07895929e-01f, 5.42192981e-02f, -2.10057437e-01f, -1.45478889e-01f, -2.67964095e-01f, 2.23516807e-01f, 6.73465431e-02f,
  -1.48199365e-01f, -4.49632369e-02f, 8.36618338e-03f, -2.81859457e-01f, 1.58396095e-01f, 8.92920718e-02f, -1.65011510e-01f, -3.91780138e-02f, -4.00010608e-02f, 1.62614942e-01f,
  8.78817737e-02f, 1.23087384e-01f, 2.22465629e-03f, -5.93247302e-02f, -1.03648948e-02f, -1.74028501e-01f, 2.23950129e-02f, 7.04653412e-02f, 1.73335508e-01f, -1.90406799e-01f,
  1.95796788e-01f, -1.44119427e-01f, -5.04930615e-02f, 2.01053664e-01f, -1.59807727e-01f, 1.45420402e-01f, 1.41965061e-01f, -6.95956647e-02f, 1.60117298e-01f, -1.00183435e-01f,
  3.59838679e-02f, 5.58358319e-02f, 6.67816550e-02f, 9.90142599e-02f, 7.41269961e-02f, -1.38213038e-02f, -1.36284873e-01f, 6.59640804e-02f, 1.10156201e-01f, 1.49735570e-01f,
  -7.42465183e-02f, 1.53831840e-01f, -1.36647627e-01f, 8.54179487e-02f, -1.06761772e-02f, 1.89101771e-02f, 1.19584858e-01f, 4.26203050e-02f, -4.41550054e-02f, 1.73364624e-01f,
  1.79259479e-02f, 9.53326449e-02f, 2.42896751e-02f, 8.57596621e-02f, -1.58352986e-01f, 3.70358489e-02f, 1.54024675e-01f, -1.42193390e-02f, 7.83073306e-02f, 6.18003011e-02f,
  1.17834985e-01f, 1.76525578e-01f, -1.64200947e-01f, 1.59638599e-01f, 1.58126533e-01f, -5.83456419e-02f, -1.44772708e-01f, 1.05492078e-01f, -9.12678614e-02f, 1.44344851e-01f,
  -1.56056195e-01f, 1.80745408e-01f, 3.52536794e-03f, -9.40818489e-02f, 9.24390033e-02f, -1.79847717e-01f, 1.14427231e-01f, -2.83361953e-02f, 5.76183461e-02f, -1.09275533e-02f,
  -1.78906918e-02f, -1.08310513e-01f, 7.15649314e-03f, 1.83264822e-01f, 5.70653155e-02f, 3.50819044e-02f, 1.66490257e-01f, 1.10751256e-01f, 1.70273885e-01f, 1.37031181e-02f,
  -1.29707232e-01f, 8.79132077e-02f, -3.81441802e-01f, 1.22584686e-01f, 9.65392590e-02f, 1.22572131e-01f, -8.96934941e-02f, -1.87193453e-01f, 1.42459676e-01f, 7.89345264e-01f,
  4.17990461e-02f, 1.14273727e-01f, 8.06298926e-02f, -1.63068950e-01f, 9.28163901e-02f, 4.03914824e-02f, 2.41407737e-01f, 2.37814579e-02f, -2.39286423e-02f, -3.03121079e-02f,
  1.74575865e-01f, -2.75671133e-03f, 6.12596832e-02f, -2.04501748e-01f, -9.88344625e-02f, 2.43873417e-01f, 3.82241845e-01f, -6.26419857e-02f, 2.13378385e-01f, 8.86672661e-02f,
  3.69570218e-02f, 2.58731484e-01f, -1.35839552e-01f, 1.02444015e-01f, 2.38987893e-01f, -1.92102924e-01f, -3.60817984e-02f, 1.36084303e-01f, 1.27402738e-01f, 1.19032435e-01f,
  1.03011355e-02f, 3.50243837e-01f, -1.82367757e-01f, 5.25748320e-02f, 3.75247709e-02f, 9.00587067e-02f, 7.97166955e-03f, 1.15759693e-01f, -8.23510364e-02f, 7.64869004e-02f,
  1.55630931e-01f, 4.05961514e-01f, 1.52614132e-01f, 3.89057249e-01f, 2.69547492e-01f, 5.52588813e-02f, -8.72784331e-02f, 2.16940772e-02f, 7.13190436e-02f, 2.98698664e-01f,
  3.84919196e-01f, 4.16501373e-01f, 1.50998339e-01f, 2.13098183e-01f, 1.88209698e-01f, -2.57406265e-01f, 3.21639366e-02f, 4.40154970e-01f, -2.10713670e-01f, -2.24618360e-01f,
  8.47690552e-02f, 9.31185707e-02f, 1.02210917e-01f, 1.12414792e-01f, -2.40652516e-01f, -6.03335164e-02f, 1.65673196e-01f, 1.89128160e-01f, 9.93139967e-02f, 4.24652308e-01f,
  -2.79128700e-01f, 8.84302557e-02f, 5.76042719e-02f, -2.15151114e-03f, -1.58210739e-01f, 2.82499403e-01f, 3.75992320e-02f, 3.17713827e-01f, -1.93143904e-01f, 2.04182804e-01f,
  1.38884438e-02f, 2.25216001e-01f, 1.20476432e-01f, -4.86776493e-02f, 2.58607626e-01f, -4.41051424e-02f, 9.28766951e-02f, 1.16071086e-02f, -2.02400520e-01f, -9.68426615e-02f,
  1.46345273e-01f, 2.90656965e-02f, 1.98899195e-01f, 4.90488624e-03f, 1.43644335e-02f, 6.25588819e-02f, 1.46990716e-01f, 9.46076028e-03f, -1.56869456e-01f, 1.78672656e-01f,
  -2.12275237e-01f, 8.62525962e-03f, -4.13361005e-02f, 2.37315167e-02f, -2.01754719e-01f, 1.30336463e-01f, 1.76880717e-01f, -1.59601405e-01f, -2.01087832e-01f, 1.40447214e-01f,
  1.21579677e-01f, 5.84193170e-02f, 5.75663224e-02f, -1.51856303e-01f, -1.44178197e-01f, 1.44651905e-01f, 6.48485571e-02f, -9.37837828e-03f, 1.20007023e-01f, 1.28978506e-01f,
  -8.37545395e-02f, 2.10143365e-02f, 2.83573959e-02f, -1.51038215e-01f, -3.73267420e-02f, 1.83645472e-01f, 2.22622864e-02f, -1.05284624e-01f, 1.32829592e-01f, -9.07686502e-02f,
  1.60106048e-01f, 5.50455712e-02f, -1.39678195e-01f, -1.81498416e-02f, 1.35800570e-01f, -4.75409441e-02f, 1.17072992e-01f, 1.06239483e-01f, 3.90180126e-02f, -1.44254327e-01f,
  1.12280838e-01f, -5.46460189e-02f, 2.33009055e-01f, 1.10797837e-01f, -9.24104825e-02f, 7.41079226e-02f, -1.48753319e-02f, 6.51206635e-03f, 1.78368241e-01f, 2.23225340e-01f,
  5.81640517e-03f, -1.59270525e-01f, -2.26364285e-01f, -2.59504784e-02f, 2.29343772e-02f, 2.11994462e-02f, -3.34932059e-02f, 6.50232360e-02f, -1.35802537e-01f, -1.16500646e-01f,
  3.02398670e-03f, 6.01170287e-02f, -1.28826901e-01f, -1.64870948e-01f, -5.29871657e-02f, 3.30426358e-02f, 1.27278566e-01f, -1.68932863e-02f, -2.80226711e-02f, -2.03508139e-01f,
  1.00628644e-01f, -3.56775038e-02f, -4.77510914e-02f, 1.19610623e-01f, -7.55997300e-02f, -7.64261037e-02f, -5.17364256e-02f, -3.05773377e-01f, 2.21066371e-01f, -1.27548510e-02f,
  -1.20375603e-01f, 1.77228659e-01f, -9.80751403e-03f, 1.71617210e-01f, 5.23761362e-02f, -4.25877108e-04f, -2.41969839e-01f, -1.15436316e-01f, -4.84567247e-02f, -1.73787937e-01f,
  1.26921564e-01f, -1.12981543e-01f, -1.84451014e-01f, -1.25347003e-01f, -1.69993751e-02f, 1.08801052e-01f, 1.68153942e-01f, 3.81626450e-02f, -2.03410789e-01f, -1.72283217e-01f,
  -1.86882112e-02f, 2.81969249e-01f, -3.37753072e-02f, -9.57997665e-02f, 1.73095062e-01f, 1.43056050e-01f, 1.67291034e-02f, 1.24337383e-01f, 3.01917017e-01f, 9.66036022e-02f,
  9.59350988e-02f, 2.61118442e-01f, 2.27634877e-01f, -2.56537795e-02f, -4.80649322e-02f, -2.92659938e-01f, 1.23684555e-01f, 6.61010444e-02f, -1.48976132e-01f, -3.52433085e-01f,
  -1.74405247e-01f, -9.55136307e-03f, -1.21809267e-01f, 8.28701407e-02f, 3.95527482e-03f, -2.01447979e-01f, 2.22090214e-01f, -2.71313876e-01f, 2.86764979e-01f, 4.08632159e-01f,
  1.78615943e-01f, 5.02976142e-02f, 1.97783262e-01f, -1.51023820e-01f, 1.10184520e-01f, 3.52705032e-01f, 1.00212842e-01f, 2.28145272e-01f, -1.64044663e-01f, 2.68732756e-01f,
  -8.13919753e-02f, 2.17505202e-01f, 1.56247273e-01f, 1.51453540e-01f, 7.67964572e-02f, 5.81967309e-02f, -4.33714986e-02f, -7.52935559e-02f, -6.39927015e-02f, -4.74428962e-04f,
  -6.32492602e-02f, 6.63807569e-03f, 1.49957150e-01f, 3.98159847e-02f, 5.80242388e-02f, 2.50978142e-01f, -2.11074054e-02f, -2.31089927e-02f, 3.44168916e-02f, 6.75801486e-02f,
  2.47497354e-02f, 1.61237076e-01f, -1.63156688e-01f, -1.42193034e-01f, -1.65596589e-01f, 2.51441877e-02f, -7.93891624e-02f, 7.15380162e-02f, -8.88731927e-02f, -1.52792111e-01f,
  -1.26256570e-02f, 3.64158349e-03f, -7.06598628e-03f, 1.15556039e-01f, 4.26635057e-01f, 2.43303880e-01f, 1.96759656e-01f, -5.91925718e-02f, -1.20665349e-01f, -2.25131229e-01f,
  -2.08914563e-01f, 2.27929533e-01f, 1.49494618e-01f, 3.48738432e-01f, -1.13888206e-02f, 8.35553482e-02f, 3.21082794e-03f, 6.53006434e-01f, -1.33306220e-01f, -1.65223137e-01f,
  -9.61596817e-02f, -4.78723384e-02f, 2.30018213e-01f, 1.43326567e-02f, -3.66503626e-01f, -1.91428229e-01f, 9.59703401e-02f, 1.57366917e-01f, 1.88208267e-01f, 3.14443320e-01f,
  1.48476899e-01f, -9.76082310e-03f, -9.54223350e-02f, 2.38818213e-01f, 1.64265528e-01f, -2.13574782e-01f, -2.42134929e-01f, 7.80464262e-02f, 2.88387835e-02f, 1.18339188e-01f,
  7.61601254e-02f, -2.14404374e-01f, 2.59338200e-01f, -1.80211276e-01f, -3.13693196e-01f, -3.26064289e-01f, -2.03770339e-01f, 2.06855923e-01f, -1.02712378e-01f, 1.22359194e-01f,
  -6.36275783e-02f, -1.56417727e-01f, -9.25197899e-02f, 4.58111754e-03f, 3.00207078e-01f, -2.99214348e-02f, 2.49312162e-01f, 5.84324151e-02f, 2.13447094e-01f, -2.74701059e-01f,
  -3.01989671e-02f, 7.33570755e-02f, -1.06933326e-01f, 2.14372322e-01f, 1.69355911e-03f, 1.36125252e-01f, 3.64083856e-01f, -2.19662204e-01f, 1.37630552e-01f, 3.02087247e-01f,
  1.31141707e-01f, 2.75320113e-01f, -2.11694509e-01f, -7.94418231e-02f, 3.47733945e-01f, -1.71947911e-01f, -2.41934136e-02f, 1.96930822e-02f, 8.08493271e-02f, -1.22148499e-01f,
  1.70426443e-01f, -7.35336356e-03f, 2.13599190e-01f, 7.67372400e-02f, 2.35345051e-01f, 3.14946026e-01f, 1.30385339e-01f, -2.07223997e-01f, -1.51785508e-01f, -2.00008005e-01f,
  1.54221162e-01f, 5.17824590e-01f, 2.25912228e-01f, 1.22065783e-01f, 1.86277971e-01f, 1.14179842e-01f, 2.64582843e-01f, -2.25108072e-01f, 1.21451259e-01f, 4.00821120e-02f,
  -6.81731477e-02f, -7.21073477e-03f, -1.14754602e-01f, -2.17296313e-02f, 3.71355042e-02f, 1.75043389e-01f, 9.37583521e-02f, -1.60481319e-01f, -1.51713818e-01f, 2.06044316e-01f,
  4.16940358e-03f, -4.73475754e-02f, 5.76863587e-02f, 1.90560296e-01f, -8.01763590e-03f, -1.24100029e-01f, -1.20808564e-01f, 2.46722355e-01f, -5.38370050e-02f, -1.26561999e-01f,
  8.76688212e-02f, 7.08982274e-02f, 1.11120723e-01f, 2.98826516e-01f, -6.87489808e-02f, -8.69500637e-02f, 1.10292904e-01f, -1.46356687e-01f, -4.65453975e-02f, 7.27400035e-02f
};

// L1_fan_Bp_bar (Shape: 1 x 20)
const int L1_fan_Bp_bar_rows = 1;
const int L1_fan_Bp_bar_cols = 20;
const float L1_fan_Bp_bar_data[] = {
  -1.57627106e-01f, 2.50476062e-01f, 2.04075873e-01f, 2.53492445e-01f, -2.39949673e-02f, 1.49282450e-02f, 7.25840032e-02f, 3.30043048e-01f, 1.62977949e-01f, 3.57094556e-01f,
  -1.06241796e-02f, -1.39483318e-01f, 2.14591071e-01f, -1.26742259e-01f, 2.98095010e-02f, 1.19153067e-01f, 2.90115345e-02f, 1.63380787e-01f, 1.81865245e-01f, 1.56820267e-01f
};

// L2_fan_Wp (Shape: 6 x 32)
const int L2_fan_Wp_rows = 6;
const int L2_fan_Wp_cols = 32;
const float L2_fan_Wp_data[] = {
  -8.24962854e-02f, -1.64623588e-01f, 5.19028045e-02f, -7.10772201e-02f, -2.08683591e-03f, -1.08768091e-01f, -5.76490998e-01f, 4.33798321e-02f, -2.67893642e-01f, -3.61136138e-01f,
  -4.96547706e-02f, -1.22701481e-01f, -3.50884311e-02f, -1.62710086e-01f, -1.34972185e-01f, 6.34453520e-02f, -2.85622180e-01f, -5.89923672e-02f, 1.51217565e-01f, 2.78305292e-01f,
  -3.48492526e-02f, 2.38202326e-02f, -4.04539071e-02f, 1.68225676e-01f, -8.57225209e-02f, 1.40110955e-01f, 1.38616353e-01f, 7.51216784e-02f, 2.56317228e-01f, -1.46910101e-01f,
  -1.79288700e-01f, 1.29053757e-01f, -1.03548892e-01f, 1.06152065e-01f, 3.12814832e-01f, 1.80616423e-01f, -5.37357926e-02f, 1.37811258e-01f, -1.30820200e-01f, -9.12325690e-04f,
  1.18112355e-01f, 1.02566041e-01f, -1.95999905e-01f, 2.51873378e-02f, 2.35986076e-02f, -3.18010092e-01f, 3.33849519e-01f, 4.85959947e-02f, 1.27030104e-01f, -1.58767998e-01f,
  -9.43584219e-02f, 3.44502360e-01f, -2.04221562e-01f, -3.82163972e-01f, 1.60204798e-01f, 4.28279638e-02f, 2.71544725e-01f, -1.70449138e-01f, -1.10405646e-01f, 4.02023494e-02f,
  -9.50436741e-02f, -3.03704534e-02f, 1.35955540e-02f, 2.53630668e-01f, 2.85044193e-01f, 2.33428627e-01f, 2.07997069e-01f, 2.37057343e-01f, 1.01350620e-01f, 2.08622307e-01f,
  -8.44322219e-02f, 3.79774958e-01f, 4.45124209e-02f, 6.97965324e-02f, 1.86773717e-01f, 2.47976452e-01f, 8.06700960e-02f, -2.53514349e-01f, 1.75101444e-01f, 2.56009281e-01f,
  2.34247386e-01f, -4.50415127e-02f, -3.61997858e-02f, -8.57118592e-02f, -2.29714885e-01f, 3.49662155e-02f, -9.71545950e-02f, 8.88815597e-02f, 4.11995351e-02f, -8.63446742e-02f,
  2.00533554e-01f, 9.14980248e-02f, -9.57134292e-02f, 4.28472795e-02f, 7.52756149e-02f, -9.42515060e-02f, -7.77248219e-02f, 6.41573444e-02f, 8.14196914e-02f, 1.37921646e-01f,
  1.45858705e-01f, -3.06549538e-02f, 5.13898492e-01f, -2.44240016e-01f, 1.80359676e-01f, 2.72685945e-01f, -6.12061135e-02f, -3.59798372e-02f, -5.49203567e-02f, 1.95833281e-01f,
  2.88080692e-01f, 6.18953221e-02f, 2.09767878e-01f, 2.17356056e-01f, -2.27242243e-02f, -1.73593611e-01f, -7.83503875e-02f, -2.80581355e-01f, 1.53483406e-01f, 1.59988165e-01f,
  1.30882934e-01f, -1.52528495e-01f, -2.70342201e-01f, -1.46880494e-02f, -1.88455388e-01f, -4.12925184e-02f, 1.35167241e-01f, 1.31674185e-01f, 2.07913779e-02f, -1.95957586e-01f,
  -1.77817091e-01f, -7.83652440e-02f, -9.93073583e-02f, -2.69581854e-01f, 1.43300116e-01f, -2.86996871e-01f, 2.16493476e-02f, 2.22477466e-02f, -3.16447347e-01f, -5.40073495e-03f,
  1.94549561e-01f, 9.77542624e-02f, 1.17767602e-01f, -4.37480137e-02f, -1.84752613e-01f, 1.10627018e-01f, 1.25757098e-01f, -1.85201302e-01f, 6.63802475e-02f, -3.63819033e-01f,
  3.37648317e-02f, 1.91294536e-01f, -4.91462015e-02f, 1.51614964e-01f, -4.90891129e-01f, 3.71861681e-02f, -7.98503682e-03f, -2.75537401e-01f, 3.87797177e-01f, 2.77121603e-01f,
  8.58182162e-02f, 3.02015115e-02f, 1.26128018e-01f, 5.60401417e-02f, -9.07886848e-02f, 1.48527458e-01f, 1.40112117e-01f, -1.57752588e-01f, 1.85837165e-01f, -1.29416408e-02f,
  -2.02278748e-01f, 8.77313837e-02f, 7.55181685e-02f, -1.46107063e-01f, -1.09041028e-01f, -1.37985066e-01f, 2.51133353e-01f, 1.19491600e-01f, -1.63450569e-01f, -1.56707719e-01f,
  1.01273291e-01f, -1.28947720e-01f, 9.29208249e-02f, 7.53899068e-02f, 2.19259933e-02f, 1.92472696e-01f, 1.06860004e-01f, -2.39561349e-01f, -3.48185986e-01f, -4.03227247e-02f,
  1.25375345e-01f, 1.59032568e-01f
};

// L2_fan_Wp_bar (Shape: 20 x 32)
const int L2_fan_Wp_bar_rows = 20;
const int L2_fan_Wp_bar_cols = 32;
const float L2_fan_Wp_bar_data[] = {
  -5.19464898e-04f, -1.53240383e-01f, -1.21628486e-01f, -9.43673309e-03f, -7.51046464e-02f, -9.95696485e-02f, -1.16159834e-01f, -1.57752022e-01f, 1.36916384e-01f, 1.44955561e-01f,
  -1.46960646e-01f, -1.34596005e-01f, 4.13644165e-02f, 1.87731177e-01f, -8.32203403e-02f, 1.65177152e-01f, -4.76906598e-02f, -1.57902211e-01f, -8.95970315e-02f, -1.13570571e-01f,
  1.39154047e-01f, -1.07397750e-01f, 5.86097017e-02f, 1.78167522e-01f, 1.23725995e-01f, 5.33954985e-02f, -5.29170372e-02f, -1.61191493e-01f, -7.17892349e-02f, -5.28622259e-05f,
  1.13520555e-01f, 7.54561275e-02f, -1.02324873e-01f, -5.07675335e-02f, -2.37641130e-02f, -2.57888269e-02f, -9.91339311e-02f, -1.34426117e-01f, 9.29353684e-02f, 2.06043608e-02f,
  -1.53094232e-01f, -5.84342144e-03f, 5.56081161e-02f, -4.43231761e-02f, -4.42049615e-02f, 6.58371300e-02f, -6.09876867e-03f, -1.72894105e-01f, -1.19670123e-01f, -1.44893259e-01f,
  -1.14112489e-01f, -1.19082250e-01f, 1.11426689e-01f, 1.51469439e-01f, -6.47805184e-02f, 1.07666373e-01f, -4.67632823e-02f, 1.09666124e-01f, 1.66428670e-01f, 1.04464948e-01f,
  -1.36491910e-01f, 1.91398188e-02f, 2.78379351e-01f, 1.39148356e-02f, -1.95474699e-02f, 1.51984662e-01f, 1.75195992e-01f, 1.03476226e-01f, 9.38322470e-02f, 2.27082744e-01f,
  -4.63788174e-02f, 1.91193864e-01f, -9.28718522e-02f, 6.54410897e-03f, -3.75554226e-02f, -2.50803051e-03f, 1.06048360e-01f, 3.94094676e-01f, -8.94679688e-03f, 1.23677850e-01f,
  -1.74839377e-01f, 5.66435568e-02f, 7.71717578e-02f, 8.60451162e-02f, 2.43255749e-01f, 2.94068068e-01f, -1.25668645e-01f, -3.75747355e-03f, -2.12934464e-01f, -1.33965509e-02f,
  1.03600305e-02f, 4.70674597e-02f, -1.22686222e-01f, -1.19492803e-02f, 5.55697605e-02f, 8.11303928e-02f, -1.51613966e-01f, 1.86698273e-01f, 7.86693543e-02f, 9.68545079e-02f,
  4.00483906e-02f, -8.10192600e-02f, 8.94321278e-02f, 7.82118812e-02f, -1.16130561e-01f, 2.78017968e-02f, -5.44136316e-02f, -1.76669687e-01f, 1.20610222e-01f, -1.23186760e-01f,
  -1.17714904e-01f, -1.01007774e-01f, 4.32235003e-02f, 1.40562057e-01f, 5.46895079e-02f, 2.25402400e-01f, -3.60726714e-02f, 3.06072444e-01f, -1.63553923e-01f, -5.02554104e-02f,
  1.96925402e-01f, -3.86906862e-02f, 2.17933968e-01f, 2.49275137e-02f, 2.31609628e-01f, 1.64703265e-01f, -5.14313132e-02f, -3.82903330e-02f, 4.88206856e-02f, -2.83992868e-02f,
  1.07323989e-01f, 3.11339229e-01f, 1.23267077e-01f, 2.47021779e-01f, 1.04861774e-01f, -3.27183604e-01f, -1.76112995e-01f, 1.35042861e-01f, 9.24099982e-02f, -1.35820940e-01f,
  -1.02971621e-01f, 2.40960240e-01f, 1.81398526e-01f, 8.95787030e-02f, 4.01698202e-02f, 1.17181718e-01f, 1.28708839e-01f, -7.77664557e-02f, 1.01570211e-01f, -1.68752745e-01f,
  -2.65204255e-02f, 1.74289003e-01f, 2.44701747e-02f, -1.54181555e-01f, -2.11955011e-01f, 1.13345072e-01f, -1.25283182e-01f, -1.34543628e-01f, 3.91439348e-01f, 6.78563863e-02f,
  -8.87358934e-02f, 2.43317392e-02f, 9.69099551e-02f, -1.54706448e-01f, -4.13734615e-02f, -3.85133289e-02f, 1.62902132e-01f, -6.64530471e-02f, 2.25005625e-03f, 1.19936958e-01f,
  -1.51781231e-01f, -2.17002526e-01f, 9.96610988e-03f, 6.31764019e-03f, -1.30608842e-01f, -9.05644968e-02f, 2.08081126e-01f, 7.32426047e-02f, 1.42490193e-01f, 1.38165712e-01f,
  -5.15768789e-02f, 1.40639767e-01f, -1.47615850e-01f, 1.36567146e-01f, 8.90767425e-02f, -1.15074523e-01f, 2.22919211e-01f, 3.64644043e-02f, 5.86881721e-03f, -2.79462934e-02f,
  1.69484943e-01f, -1.24347873e-01f, 2.02127308e-01f, 8.83782376e-03f, 4.90908585e-02f, 2.95390010e-01f, 1.45294785e-01f, 1.42176626e-02f, -7.49954060e-02f, -1.16701820e-03f,
  -1.24462821e-01f, 1.74197197e-01f, 2.22310618e-01f, 1.91122010e-01f, 5.59968650e-02f, -2.09471613e-01f, 9.52854380e-02f, 1.70381948e-01f, 2.44130313e-01f, -9.72474515e-02f,
  -3.77300158e-02f, 3.08759958e-01f, 3.16593237e-02f, 2.24893644e-01f, 1.94485888e-01f, 3.57844541e-03f, 1.45278111e-01f, -3.29429395e-02f, -1.35206625e-01f, 2.04810366e-01f,
  3.28597933e-01f, -2.11431667e-01f, -1.53855473e-01f, -1.66803468e-02f, 1.25785679e-01f, -9.97672528e-02f, -4.72056791e-02f, -2.22103238e-01f, 1.89654842e-01f, 6.88335812e-03f,
  -1.27417281e-01f, -2.91816056e-01f, -2.75656819e-01f, -2.01735377e-01f, -1.02080390e-01f, -5.13889827e-02f, 8.43363628e-02f, 4.70417105e-02f, -1.23326510e-01f, -1.88811228e-01f,
  3.58712003e-02f, 5.97335398e-03f, -6.27712021e-03f, 4.36833471e-01f, 4.04247344e-01f, -6.40792400e-02f, 1.26870155e-01f, -1.40628785e-01f, -6.45684376e-02f, -7.58929402e-02f,
  3.61402147e-02f, 2.14945242e-01f, 3.99206281e-01f, -1.91950947e-01f, 2.24275082e-01f, -1.70334199e-04f, 1.62948549e-01f, -1.93693936e-02f, -2.55796667e-02f, -5.55730462e-02f,
  1.11195974e-01f, -4.80083600e-02f, 2.61727065e-01f, -1.64826497e-01f, -1.76105589e-01f, 8.80446881e-02f, -1.40205458e-01f, -2.00235974e-02f, -9.16009843e-02f, 5.25103629e-01f,
  -9.17637795e-02f, -1.68336034e-01f, -2.14096736e-02f, 3.11432928e-02f, -1.72572672e-01f, -1.53872743e-01f, 1.63934946e-01f, 2.00862527e-01f, -2.07315877e-01f, -2.16718353e-02f,
  -4.30388898e-02f, 2.83060163e-01f, -1.73161682e-02f, -5.40547483e-02f, 9.40873176e-02f, 1.20172072e-02f, 2.64032364e-01f, 9.46217775e-02f, 2.59659905e-02f, -8.58236626e-02f,
  3.25076431e-02f, -6.29558936e-02f, 4.11588140e-02f, -2.38057896e-02f, -1.23905003e-01f, -1.29863545e-01f, 6.55960217e-02f, 1.61033064e-01f, -1.97238788e-01f, 2.47643050e-02f,
  -6.19806834e-02f, 1.11237988e-01f, 1.25123471e-01f, 2.23538563e-01f, 5.63595444e-02f, -1.66735962e-01f, -9.77025703e-02f, 1.89680174e-01f, -1.61822006e-01f, -1.33002713e-01f,
  1.43597312e-02f, -9.73675251e-02f, -3.88338156e-02f, -5.47038876e-02f, 1.01346187e-02f, 1.17363170e-01f, -1.58889264e-01f, 1.21987194e-01f, 2.07891725e-02f, -1.11443751e-01f,
  -5.03430665e-02f, -1.21620782e-01f, -1.05792239e-01f, 4.29486185e-02f, 2.34936699e-01f, 2.24056557e-01f, 2.59991467e-01f, -1.68945178e-01f, -1.65226623e-01f, 8.06196705e-02f,
  -5.96058555e-02f, -3.25662009e-02f, 2.07773075e-01f, 4.20211732e-01f, 4.43968661e-02f, -1.71464071e-01f, 1.47367597e-01f, -4.44021299e-02f, 6.05423748e-02f, 1.60764769e-01f,
  1.92501053e-01f, 2.06415430e-01f, -8.10046420e-02f, -6.96356669e-02f, 5.13002425e-02f, 2.03248411e-01f, -2.81724989e-01f, -8.41833651e-03f, -1.97301403e-01f, -8.61857608e-02f,
  5.06504476e-01f, 1.46482378e-01f, -9.01234224e-02f, 1.65215418e-01f, -1.04169294e-01f, 4.30830568e-03f, 1.41312599e-01f, 1.89539284e-01f, -1.74102172e-01f, 1.47825763e-01f,
  9.69019830e-02f, -2.58212149e-01f, -7.97495693e-02f, -1.09739088e-01f, 2.77769044e-02f, 2.26527736e-01f, -1.33023173e-01f, -1.90836042e-01f, -1.85304806e-02f, -7.81345740e-03f,
  3.57461744e-03f, 4.80775796e-02f, 4.59007882e-02f, -3.16490047e-02f, 1.24132141e-01f, -1.54603869e-01f, -1.87016670e-02f, 9.48024839e-02f, -9.90034267e-02f, -7.97416493e-02f,
  -1.14580207e-01f, -1.38091072e-01f, 3.12075075e-02f, 3.49991918e-02f, -1.85291842e-01f, -7.47701228e-02f, -2.97299214e-02f, -1.45798698e-01f, -1.83000892e-01f, 1.35707662e-01f,
  -1.45379692e-01f, -6.95248917e-02f, 4.28125933e-02f, 1.36424065e-01f, 1.22863628e-01f, 5.69509482e-03f, 1.58596352e-01f, -1.95115823e-02f, -1.35044884e-02f, -8.92284140e-02f,
  -6.49243221e-02f, -1.05010860e-01f, 1.53847605e-01f, -1.04316235e-01f, -8.32420364e-02f, -1.21305957e-01f, 7.69374073e-02f, -1.64905950e-01f, 1.44172370e-01f, -1.43475190e-01f,
  -1.83101371e-01f, -5.29916771e-03f, 1.17149867e-01f, 3.67467292e-03f, 5.83179034e-02f, 5.52089848e-02f, -1.33683488e-01f, -1.53461874e-01f, 1.40957966e-01f, 1.67128712e-01f,
  6.38004914e-02f, 5.81847988e-02f, -8.54530837e-03f, -2.10161909e-01f, 6.33612499e-02f, 7.16335848e-02f, 1.01499021e-01f, -1.57651305e-02f, 3.51614542e-02f, -1.20341077e-01f,
  -1.34167206e-02f, 1.40871629e-01f, 1.03826866e-01f, -7.85450935e-02f, 6.18586950e-02f, 2.40959436e-01f, 1.74893439e-01f, -3.24554555e-02f, -8.12192485e-02f, 9.69548449e-02f,
  1.86880022e-01f, -1.75900102e-01f, 1.58723682e-01f, -1.22970141e-01f, -1.01305746e-01f, 1.95047677e-01f, 7.80275539e-02f, 3.25827748e-02f, 1.79180086e-01f, 1.55755803e-01f,
  1.30861610e-01f, -6.94406256e-02f, 1.22815505e-01f, 4.82415035e-03f, 4.60425839e-02f, 1.55985817e-01f, 7.87587762e-02f, -1.77105561e-01f, 1.88916270e-02f, 8.44308659e-02f,
  -9.54617485e-02f, -4.85914834e-02f, -5.60220405e-02f, -5.15687205e-02f, 3.64281535e-02f, -2.80577708e-02f, 8.91998224e-03f, 1.70895576e-01f, -5.71774617e-02f, 1.23339072e-01f,
  -1.17777646e-01f, -8.81886035e-02f, -3.07030212e-02f, 1.39506564e-01f, -1.67261213e-01f, 3.93868051e-02f, -2.05606759e-01f, -1.50846377e-01f, -9.16210860e-02f, 8.35194290e-02f,
  -5.95874339e-02f, 2.79448777e-01f, -1.52077615e-01f, 1.71137512e-01f, 1.81975141e-01f, 2.07913190e-01f, -6.34296477e-01f, 4.80241984e-01f, -4.64097738e-01f, -6.27014756e-01f,
  6.25777245e-02f, 3.56119484e-01f, -1.69416443e-01f, 4.02283311e-01f, 1.52873769e-01f, -1.05885096e-01f, -2.15966076e-01f, 5.88689968e-02f, 1.07764155e-01f, 4.05744731e-01f,
  1.80583328e-01f, 3.44882846e-01f, -1.09453812e-01f, -6.42576143e-02f, 5.48537006e-04f, -2.66867485e-02f, 1.81667745e-01f, 1.77286804e-01f, 5.05222738e-01f, -3.97024363e-01f,
  1.36124551e-01f, 1.38204962e-01f, 3.19140077e-01f, 3.88187230e-01f, -1.19839292e-02f, 2.77118564e-01f, 2.01848254e-01f, 4.73874867e-01f, -1.60455897e-01f, 6.94923520e-01f,
  -3.39931190e-01f, -9.58174244e-02f, 5.73072910e-01f, 4.28332418e-01f, -1.49411652e-02f, 1.13511920e-01f, 5.06725945e-02f, 2.94230789e-01f, 1.21150287e-02f, 1.21352635e-01f,
  -1.18545676e-02f, 1.02129027e-01f, -1.67922199e-01f, 5.73750734e-01f, 2.32385620e-01f, -9.73713174e-02f, 1.00421898e-01f, -2.17756256e-01f, 1.13951720e-01f, 1.41611412e-01f,
  1.94972947e-01f, -2.78910011e-01f, 5.88818491e-02f, -6.05080873e-02f, 1.50710922e-02f, 1.01063296e-01f, 1.49925873e-02f, 1.59607366e-01f, 1.03963010e-01f, -1.59472786e-02f,
  -2.66766518e-01f, 7.82042965e-02f, -5.22607602e-02f, 8.93758312e-02f, -1.58496842e-01f, -4.82565127e-02f, 1.38879925e-01f, 2.70063281e-01f, -6.92339381e-04f, -1.50268465e-01f,
  -6.45715073e-02f, -8.89769867e-02f, -2.81492039e-03f, 2.60598183e-01f, 3.25067610e-01f, -1.93159521e-01f, 4.87144813e-02f, 1.41652986e-01f, -1.61424980e-01f, -1.55994907e-01f,
  -2.50703484e-01f, -2.05793306e-02f, 2.94567317e-01f, -1.80804804e-01f, 3.49677742e-01f, 6.65010288e-02f, 7.83646554e-02f, 2.05499027e-02f, 3.87024373e-01f, 4.50607017e-02f,
  -2.82832179e-02f, 2.20708430e-01f, 1.78824320e-01f, -4.87920135e-01f, 1.72364071e-01f, -9.44508463e-02f, -2.36684993e-01f, -3.16391408e-01f, 1.16625940e-03f, 6.04009330e-01f,
  -2.50808716e-01f, 7.68716261e-02f, -2.51669794e-01f, 2.05814928e-01f, 2.18460858e-02f, -2.67291367e-02f, 3.53940189e-01f, 3.10436279e-01f, -3.51906866e-01f, 6.31533936e-02f,
  -3.34235467e-02f, 3.38151515e-01f, 4.79070902e-01f, -1.89226978e-02f, -1.92056060e-01f, 4.65597063e-01f, 4.54744220e-01f, 6.66140839e-02f, -1.06768332e-01f, 7.10995272e-02f,
  1.19643761e-02f, -8.52202177e-02f, 1.01973295e-01f, 1.49021428e-02f, -1.63251072e-01f, -2.82654703e-01f, -1.01845235e-01f, -1.60291851e-01f, -2.68454313e-01f, -1.85183808e-01f,
  -5.18449284e-02f, 4.08561409e-01f, -1.26565233e-01f, -3.62435058e-02f, -1.99789312e-02f, -7.99580365e-02f, -1.30578876e-02f, 2.36891598e-01f, 3.16951662e-01f, 1.24007694e-01f,
  3.00512742e-02f, -1.83888942e-01f, -1.93507269e-01f, -6.54343050e-04f, -8.67642909e-02f, -1.33029595e-01f, 1.27185225e-01f, -1.38848588e-01f, 2.80354828e-01f, 9.62847620e-02f
};

// L2_fan_Bp_bar (Shape: 1 x 20)
const int L2_fan_Bp_bar_rows = 1;
const int L2_fan_Bp_bar_cols = 20;
const float L2_fan_Bp_bar_data[] = {
  -1.12872824e-01f, 5.88162243e-02f, 1.26245290e-01f, 1.55144408e-01f, 2.05764800e-01f, 1.68467999e-01f, 1.27531618e-01f, 2.40351960e-01f, 2.38949612e-01f, 6.59684539e-02f,
  1.78043887e-01f, -2.39849854e-02f, -1.00701444e-01f, -1.08779542e-01f, 1.19868495e-01f, 1.03956886e-01f, 3.58120888e-01f, -6.10527582e-02f, 3.15321803e-01f, -4.86898888e-03f
};

// L3_fan_Wp (Shape: 6 x 32)
const int L3_fan_Wp_rows = 6;
const int L3_fan_Wp_cols = 32;
const float L3_fan_Wp_data[] = {
  5.19513264e-02f, -3.48439872e-01f, -3.44740003e-02f, 1.24459654e-01f, 3.18359166e-01f, -7.61044100e-02f, -1.94270626e-01f, 8.62275138e-02f, -1.78697884e-01f, 4.80250388e-01f,
  3.80666226e-01f, 1.90142199e-01f, 2.44002774e-01f, 4.89981957e-02f, -1.11162432e-01f, -3.13687265e-01f, 7.60835409e-02f, -2.51148958e-02f, -9.14512575e-02f, 3.36990878e-02f,
  2.20053405e-01f, 1.16733611e-01f, 1.97665438e-01f, -3.35649885e-02f, 1.61103278e-01f, -2.20946744e-01f, 1.95773035e-01f, -2.09227920e-01f, -3.01689625e-01f, 1.92584679e-01f,
  4.84321788e-02f, 1.34092107e-01f, 7.51343369e-02f, 2.06113517e-01f, -2.65421391e-01f, 1.37464583e-01f, -2.54332602e-01f, 1.62864208e-01f, -3.00746828e-01f, -1.44050628e-01f,
  2.14149848e-01f, -2.63918519e-01f, -2.83826798e-01f, 1.25740066e-01f, 6.25825450e-02f, 1.27465889e-01f, 1.34618893e-01f, 1.89450860e-01f, -2.72839010e-01f, 2.12075412e-02f,
  -1.06255583e-01f, -1.89774275e-01f, 6.54402003e-02f, -2.58768529e-01f, -8.16234108e-03f, -1.91710100e-01f, -2.11050939e-02f, -1.82521805e-01f, 1.57999605e-01f, 8.24908018e-02f,
  4.49795127e-01f, -2.04263791e-01f, -1.78149909e-01f, -2.84245133e-01f, 3.24676335e-01f, 3.46840233e-01f, 3.39118317e-02f, -3.76936002e-03f, 1.50642127e-01f, -3.50866030e-04f,
  -1.36620328e-01f, -1.60133660e-01f, 2.09816948e-01f, 6.79687411e-02f, -3.38397413e-01f, -2.85515755e-01f, -1.99591890e-01f, -1.89216688e-01f, 1.51267588e-01f, 4.54704724e-02f,
  1.58674940e-01f, -1.93379104e-01f, 9.57581848e-02f, -1.08797066e-01f, -9.73569080e-02f, -8.46050382e-02f, 7.60276522e-03f, 4.48265411e-02f, -1.39692277e-01f, -2.51527447e-02f,
  1.92839816e-01f, 2.82332718e-01f, 4.56987828e-01f, -5.10822833e-02f, -3.42201412e-01f, -9.48845446e-02f, -3.36015187e-02f, -2.24165976e-01f, 1.40069332e-02f, 3.43786091e-01f,
  -4.12689671e-02f, 1.05744824e-01f, -1.91998348e-01f, -1.56758294e-01f, -7.37471730e-02f, 1.05049111e-01f, 7.74844736e-02f, 2.93480605e-01f, 1.94629263e-02f, -5.50064035e-02f,
  1.65532351e-01f, -4.15234640e-02f, 1.53380129e-02f, 5.58204800e-02f, -1.06423691e-01f, -2.52029836e-01f, 1.29013360e-01f, 1.54590398e-01f, 5.72307296e-02f, 4.30209450e-02f,
  -1.79042980e-01f, 1.99279085e-01f, 1.61302164e-01f, -1.99751794e-01f, -2.51077205e-01f, -1.30110011e-01f, 3.38838935e-01f, -1.03191845e-02f, -1.01513408e-01f, -2.15559423e-01f,
  -1.98891461e-01f, -1.22048996e-01f, -4.30351347e-01f, -2.14749083e-01f, 4.87359285e-01f, -4.04368900e-02f, 9.26591605e-02f, -5.18634379e-01f, -2.60603189e-01f, -2.97139287e-01f,
  -1.68174535e-01f, 1.42309353e-01f, 1.32281743e-02f, 2.35039219e-02f, -2.22307205e-01f, -1.83394421e-02f, 1.49974292e-02f, 3.72576937e-02f, -1.67718247e-01f, -1.46144807e-01f,
  -1.45635307e-01f, 6.28602430e-02f, -1.50285184e-01f, 8.36817399e-02f, 1.22298941e-01f, 1.41431004e-01f, 2.44592801e-02f, -7.17277303e-02f, 1.23607688e-01f, -5.28797433e-02f,
  7.59841204e-02f, 2.32260749e-01f, 4.87860432e-03f, -8.79511610e-02f, -2.75083542e-01f, 1.08382151e-01f, 3.45127761e-01f, 2.16430366e-01f, 2.52423555e-01f, -3.08551282e-01f,
  -1.76220722e-02f, -1.77781343e-01f, 7.25237131e-02f, -8.42755754e-03f, 3.54391932e-02f, 1.75626203e-01f, -2.59732515e-01f, 2.48106681e-02f, 2.31410995e-01f, -1.14699543e-01f,
  -1.26761854e-01f, -2.84721497e-02f, -3.50332558e-01f, 1.01354398e-01f, -3.63994427e-02f, 3.82332946e-04f, -1.46981038e-03f, 2.93788612e-01f, 2.77792931e-01f, -2.62338351e-02f,
  -2.40391120e-01f, 6.82863668e-02f
};

// L3_fan_Wp_bar (Shape: 20 x 32)
const int L3_fan_Wp_bar_rows = 20;
const int L3_fan_Wp_bar_cols = 32;
const float L3_fan_Wp_bar_data[] = {
  -2.06948109e-02f, 3.86459231e-01f, 6.40852153e-01f, 5.06250441e-01f, 4.75433081e-01f, 2.29401082e-01f, -5.89903712e-01f, -5.94802022e-01f, 1.30117387e-01f, 4.29306537e-01f,
  -1.68185160e-01f, 3.35156739e-01f, -1.55425608e-01f, 5.29814027e-02f, 3.58054310e-01f, -2.80224718e-02f, 3.50059837e-01f, 2.03397781e-01f, -9.18739587e-02f, -1.31542375e-02f,
  2.64508247e-01f, -1.37785107e-01f, 4.29350048e-01f, 1.00665219e-01f, -2.67375201e-01f, -1.35158538e-03f, -9.15683284e-02f, -1.76029935e-01f, 2.48763084e-01f, -1.91676438e-01f,
  6.83454752e-01f, 1.20365992e-01f, -6.23765104e-02f, -5.36390245e-02f, 1.40230939e-01f, 7.77411321e-03f, 1.69222988e-02f, 6.12025266e-04f, 1.66465834e-01f, -1.62395164e-01f,
  -2.83208303e-02f, -3.02361753e-02f, 2.10573912e-01f, -6.06846772e-02f, 3.03559117e-02f, 2.28251308e-01f, 2.74005204e-01f, 2.09760293e-01f, 9.14882794e-02f, -5.89749925e-02f,
  -1.79210380e-01f, 2.14196399e-01f, 3.77798080e-01f, -5.21486327e-02f, 9.61971581e-02f, -9.34848282e-03f, -1.79211006e-01f, 1.49308562e-01f, 7.92823136e-02f, 3.41540724e-01f,
  -1.41287729e-01f, -2.96541173e-02f, 6.67434573e-01f, 3.37513864e-01f, 2.22374141e-01f, 6.61608055e-02f, -1.38998196e-01f, 2.78420240e-01f, 5.34889698e-01f, 4.14069653e-01f,
  -4.55238700e-01f, 6.15956008e-01f, 5.74119151e-01f, 4.28847581e-01f, -4.75347787e-01f, 1.36989221e-01f, 5.55547811e-02f, -2.74461303e-02f, -1.81108609e-01f, -6.42192271e-03f,
  2.47504696e-01f, 7.62478784e-02f, 2.82000482e-01f, 7.86244124e-02f, -1.56785995e-01f, 1.07164301e-01f, -1.33890897e-01f, -1.10900722e-01f, -1.34768590e-01f, 8.75588283e-02f,
  8.36649537e-02f, -2.46525351e-02f, 1.60881519e-01f, 4.27295417e-02f, -1.89096197e-01f, -5.47016710e-02f, -2.34035298e-01f, 1.98422596e-02f, 1.32531464e-01f, -2.69561708e-01f,
  -1.92104608e-01f, -8.41188505e-02f, 2.68042892e-01f, 1.62831038e-01f, -1.45876840e-01f, -1.24887623e-01f, 9.79475603e-02f, 1.37202721e-02f, 1.17008038e-01f, -1.45300582e-01f,
  3.10596172e-02f, 2.12929726e-01f, 7.78896883e-02f, 1.40867103e-02f, -9.65824351e-02f, 1.21247888e-01f, 1.28030598e-01f, -6.60551190e-02f, 1.37387291e-01f, -7.69666880e-02f,
  1.57334208e-01f, 1.21548139e-01f, -1.04434714e-01f, 5.78833297e-02f, 2.62312703e-02f, -9.24139097e-02f, 2.58068711e-01f, 2.11864501e-01f, -2.02258050e-01f, 6.02059215e-02f,
  1.36470973e-01f, 8.49473700e-02f, 1.96600720e-01f, -1.37234852e-01f, 2.19386965e-02f, -1.74239073e-02f, -3.61442752e-02f, 1.19483024e-01f, 1.40564203e-01f, 8.06516930e-02f,
  9.74138379e-02f, 1.27685353e-01f, -1.25280311e-02f, -1.51971221e-01f, 1.22082025e-01f, 1.48138091e-01f, -8.21900219e-02f, 1.37811095e-01f, 1.54568061e-01f, -1.31082505e-01f,
  2.66510830e-03f, 1.89338297e-01f, 1.70153961e-01f, -9.82665718e-02f, -1.07546747e-01f, 1.14413247e-01f, -8.43628272e-02f, 1.46299645e-01f, -6.87922612e-02f, 5.66962175e-02f,
  1.12110913e-01f, 2.40738779e-01f, -1.46208763e-01f, -8.06800053e-02f, -1.02769151e-01f, 2.08992928e-01f, -1.54219627e-01f, 9.78710037e-03f, 1.96778029e-02f, 2.19395399e-01f,
  -5.71364537e-02f, -1.56534150e-01f, 3.84628102e-02f, 1.38845548e-01f, -1.02146730e-01f, 1.25570744e-01f, -5.39035238e-02f, -1.55071756e-02f, 3.13596994e-01f, 1.52521327e-01f,
  1.34170558e-02f, 1.29744466e-02f, 9.34117436e-02f, -1.53243840e-01f, 1.46170586e-01f, -1.54802412e-01f, -1.12358714e-02f, 1.62713528e-01f, 3.41509610e-01f, 1.46415591e-01f,
  -1.67268708e-01f, -4.80102040e-02f, 4.65697765e-01f, 2.81732321e-01f, -2.30238110e-01f, 8.80613700e-02f, 5.41696101e-02f, 2.88743556e-01f, 3.38827968e-01f, 2.84699202e-01f,
  2.70643950e-01f, -4.01213259e-01f, -1.63911626e-01f, -2.52736062e-01f, 1.67780872e-02f, -1.73542555e-02f, 2.43853495e-01f, -1.50904849e-01f, -1.04246572e-01f, -1.03915662e-01f,
  1.57385707e-01f, -7.54376724e-02f, -1.64629012e-01f, 1.27923235e-01f, -3.07306871e-02f, 2.55760234e-02f, -1.70841604e-01f, -3.38910483e-02f, 2.31945485e-01f, 5.13114929e-01f,
  8.64212155e-01f, 1.08941337e-02f, -2.35016614e-01f, -1.32883340e-01f, -5.13467230e-02f, -2.44449511e-01f, 2.57796168e-01f, -1.70274436e-01f, -2.23543689e-01f, -6.58876374e-02f,
  6.22318983e-01f, 2.41235957e-01f, -2.73169011e-01f, -5.00162363e-01f, 7.84816816e-02f, -3.72738719e-01f, 3.23355850e-03f, 3.49445082e-02f, 2.44449638e-02f, 1.17912769e-01f,
  -2.00071394e-01f, 5.59209324e-02f, 2.08963171e-01f, 5.70766807e-01f, -1.14518613e-01f, 3.31375152e-02f, 2.76732836e-02f, 2.21089214e-01f, 3.53552029e-02f, -5.00363261e-02f,
  7.02727307e-03f, 7.28231549e-01f, 5.35513498e-02f, 2.42080227e-01f, -3.96616943e-02f, 3.60632390e-01f, 9.13036335e-03f, 2.79708095e-02f, -3.65735553e-02f, -1.61037549e-01f,
  -1.78605407e-01f, -5.86897768e-02f, 8.48162770e-02f, -9.23822671e-02f, 2.16797721e-02f, -6.95908442e-02f, -2.11041942e-01f, 4.85098809e-02f, 3.70517187e-02f, -1.00075707e-01f,
  -1.17326945e-01f, 1.43505648e-01f, 9.66564566e-02f, 7.63206929e-02f, -7.44645447e-02f, -1.58597901e-01f, 4.46064807e-02f, -1.78714499e-01f, -1.46000773e-01f, -1.53378382e-01f,
  1.97412055e-02f, 7.54789934e-02f, 1.33979976e-01f, -4.99976352e-02f, 4.18321267e-02f, 6.36186749e-02f, -1.48904964e-01f, -9.17213857e-02f, 3.99472415e-02f, -2.21285179e-01f,
  -2.70311590e-02f, -2.16224808e-02f, -7.88656697e-02f, -4.47617248e-02f, 3.56667116e-02f, -2.77009487e-01f, -1.07761256e-01f, -1.62869632e-01f, -1.56503578e-03f, -1.24289636e-02f,
  -1.44897416e-01f, 6.71937242e-02f, 7.70609900e-02f, 3.55166420e-02f, -1.38349265e-01f, -3.00540077e-03f, -2.26572365e-01f, 9.15203616e-02f, 2.58295327e-01f, -1.66101411e-01f,
  2.06157297e-01f, 1.02334693e-01f, 8.58512074e-02f, -2.30678897e-02f, -7.42442384e-02f, 4.15316939e-01f, 6.43176734e-02f, 1.87204078e-01f, 2.19602630e-01f, 3.05836737e-01f,
  -1.24650866e-01f, 7.30568618e-02f, 1.71481460e-01f, 1.83010936e-01f, -9.03061330e-02f, 1.09391034e-01f, 1.79417461e-01f, -2.67735422e-01f, 1.68209732e-01f, -5.64325690e-01f,
  -2.84847915e-01f, -7.83753470e-02f, -1.24287128e-01f, 1.24934182e-01f, -3.58811878e-02f, -6.27191663e-02f, -3.13517377e-02f, -7.15940595e-02f, -5.59693482e-03f, 6.60942122e-02f,
  6.43833261e-03f, -1.20715789e-01f, -1.90278962e-01f, 1.04710303e-01f, 8.32657591e-02f, -1.55703694e-01f, 1.60078984e-02f, 5.44339597e-01f, 3.83547485e-01f, -5.18584140e-02f,
  1.60522819e-01f, -1.10915415e-01f, -9.59495455e-02f, -7.54575655e-02f, 6.30532056e-02f, -3.64154756e-01f, -1.96876764e-01f, -2.60777652e-01f, 9.64437670e-04f, 3.95617969e-02f,
  9.43704844e-02f, -3.05517912e-02f, 3.44452143e-01f, -2.30393428e-02f, -9.83648449e-02f, 2.34965095e-03f, 2.31823534e-01f, 3.73535007e-02f, 7.75861591e-02f, -5.27155697e-02f,
  6.32142201e-02f, 3.16114575e-01f, 2.21934974e-01f, 8.22526515e-02f, 1.01721711e-01f, -2.70253904e-02f, -1.53919891e-01f, -8.71920362e-02f, -3.84479575e-02f, 4.64133948e-01f,
  2.50398576e-01f, 2.06538484e-01f, -3.64769772e-02f, 1.61787361e-01f, 1.60457969e-01f, 9.02651101e-02f, -1.79804444e-01f, -8.50136653e-02f, -1.89646497e-01f, 2.09198654e-01f,
  1.00825205e-01f, -2.16530766e-02f, 2.76810139e-01f, -3.15772668e-02f, 7.85791203e-02f, 2.08474081e-02f, 2.11861283e-02f, 7.21954256e-02f, 1.06495127e-01f, -3.87339890e-02f,
  1.60176232e-02f, -1.18149847e-01f, 2.88776547e-01f, -2.74099231e-01f, -2.01205388e-02f, -2.10114717e-01f, 1.49240896e-01f, -1.20185260e-02f, -1.29317373e-01f, -1.36253268e-01f,
  -9.96186361e-02f, 2.18371987e-01f, 5.33556223e-01f, 9.26749036e-02f, -2.84836322e-01f, 4.29512337e-02f, 2.62665143e-03f, -5.59737682e-02f, -4.58323583e-02f, 6.76057786e-02f,
  1.32340252e-01f, 1.55407056e-01f, -1.53739989e-01f, -2.19068751e-01f, 5.99644817e-02f, 2.67626310e-04f, 2.83470273e-01f, 1.20817676e-01f, -7.35761970e-02f, 1.03518657e-01f,
  1.78574443e-01f, -5.50942048e-02f, -4.26338054e-02f, -2.48911213e-02f, -1.78762704e-01f, -1.39054835e-01f, 1.96451709e-01f, -1.06892973e-01f, 1.07415192e-01f, -3.31645310e-02f,
  -1.69888720e-01f, 5.35737537e-02f, 1.07952990e-02f, -2.53717780e-01f, -3.03089648e-01f, 2.76003741e-02f, 5.38673341e-01f, 3.29564698e-02f, -1.54113397e-02f, 1.44972220e-01f,
  -3.29020284e-02f, 4.37188661e-03f, 1.41649812e-01f, 2.10490361e-01f, 2.59714812e-01f, 2.39207804e-01f, 1.76192343e-01f, -4.25410680e-02f, 1.44221887e-01f, 3.18517722e-02f,
  -1.37752414e-01f, -7.78958052e-02f, 8.81567374e-02f, -8.62103552e-02f, 1.86823204e-01f, -1.89387143e-01f, 1.67604849e-01f, 1.80959091e-01f, 1.48692168e-02f, -6.70050606e-02f,
  1.40858144e-01f, -6.55140877e-02f, -3.09227742e-02f, 4.59532067e-02f, 5.42379655e-02f, 3.28847051e-01f, -5.31744324e-02f, 3.11925471e-01f, -1.29249498e-01f, -4.53683883e-02f,
  -1.40131608e-01f, -2.33617648e-01f, -4.99905786e-03f, -9.62816402e-02f, 2.67314166e-02f, -1.85631793e-02f, 1.57216877e-01f, -4.56584006e-04f, -2.32836694e-01f, 7.08451942e-02f,
  3.41909617e-01f, 1.18023165e-01f, 1.95203766e-01f, 1.58232450e-01f, 6.14939630e-02f, -2.28204638e-01f, 2.20433563e-01f, -1.77683830e-02f, -1.96408592e-02f, 1.84591964e-01f,
  3.12553376e-01f, -5.30651212e-03f, 1.34726360e-01f, 5.04219532e-02f, -1.62633862e-02f, -1.52130559e-01f, -3.18800122e-03f, 2.34568730e-01f, -1.01678930e-01f, 1.31217152e-01f,
  6.48577586e-02f, 1.76248491e-01f, 5.83047010e-02f, -1.16498381e-01f, -7.23839132e-03f, 2.48455301e-01f, -1.62691921e-01f, 2.89122581e-01f, 2.00235307e-01f, 6.43578125e-03f,
  7.02207983e-02f, -5.07473290e-01f, -2.76976138e-01f, -5.70969423e-03f, -5.96550964e-02f, -5.65052740e-02f, 2.40588650e-01f, -1.11270021e-03f, -1.82301626e-01f, 7.70044178e-02f,
  -9.52506587e-02f, -2.16776133e-01f, 5.30171208e-02f, 1.01322763e-01f, -3.29372250e-02f, 7.41235018e-02f, -6.12792931e-02f, -8.87580141e-02f, 5.89318052e-02f, 2.49183834e-01f,
  2.82652229e-01f, -2.79628485e-01f, 2.78767139e-01f, -1.95194617e-01f, 1.25024587e-01f, -2.07202956e-01f, -1.34054050e-01f, -6.95911190e-03f, -1.11634128e-01f, -1.38341725e-01f,
  1.18309863e-01f, 1.16203025e-01f, -8.13155398e-02f, 7.07052052e-02f, 1.69144943e-01f, 1.81645036e-01f, 2.64258217e-02f, 1.90860048e-01f, -5.83318211e-02f, -9.49369743e-02f,
  -1.51833162e-01f, 1.91318274e-01f, -1.64746314e-01f, 1.01027332e-01f, 9.54229683e-02f, -7.12066814e-02f, 1.94568172e-01f, -3.20091955e-02f, -7.69031839e-03f, 1.41303197e-01f,
  5.31287305e-02f, -6.90053105e-02f, -2.84564197e-01f, -3.10473777e-02f, 4.97027844e-01f, 7.03696758e-02f, 4.39853333e-02f, -1.76195741e-01f, 2.87077725e-01f, 3.44415843e-01f,
  4.03866261e-01f, 1.18215956e-01f, -1.93005614e-02f, -3.56699944e-01f, -2.01780841e-01f, -1.10098757e-02f, 3.43762249e-01f, 1.86971743e-02f, 5.42140333e-03f, 3.93182822e-02f,
  1.40587941e-01f, -2.10776731e-01f, 1.95607573e-01f, -2.10361674e-01f, -1.32624403e-01f, 3.90654877e-02f, 2.44370829e-02f, 2.91503109e-02f, 4.55733508e-01f, 2.04778641e-01f,
  8.23168308e-02f, -2.19854683e-01f, 1.61957443e-01f, 4.52791810e-01f, 1.08295925e-01f, 2.39205599e-01f, -1.43124416e-01f, 1.69448033e-01f, 5.24887070e-02f, -8.02323967e-02f,
  2.46486664e-02f, -2.91853920e-02f, -7.64189735e-02f, -4.20872308e-02f, 2.36177389e-02f, 2.69332111e-01f, 1.63793340e-01f, -2.03932479e-01f, -4.96175252e-02f, -1.11663923e-01f,
  -7.86831230e-02f, -1.33317947e-01f, -1.25591069e-01f, 3.61454785e-02f, -1.71454534e-01f, -1.65603355e-01f, 9.18601230e-02f, 2.25643456e-01f, -1.17088847e-01f, -1.55843824e-01f,
  -1.62351131e-01f, 2.60834284e-02f, -1.68466137e-03f, -3.82996276e-02f, -7.43289590e-02f, 1.51992947e-01f, 1.96409166e-01f, 1.96011886e-01f, -2.82532126e-01f, 8.91222581e-02f
};

// L3_fan_Bp_bar (Shape: 1 x 20)
const int L3_fan_Bp_bar_rows = 1;
const int L3_fan_Bp_bar_cols = 20;
const float L3_fan_Bp_bar_data[] = {
  4.37264979e-01f, -2.88758352e-02f, 4.56809491e-01f, -4.45881151e-02f, 1.30449846e-01f, -7.87065551e-02f, 2.35226199e-01f, 6.36073053e-02f, 1.85756415e-01f, 1.23464577e-02f,
  1.46519172e-03f, -1.22899108e-01f, 2.11725712e-01f, -3.34621705e-02f, 2.35258378e-02f, -1.95918046e-02f, 1.04190640e-01f, 1.12769112e-01f, 1.04341894e-01f, 2.51920730e-01f
};

// L4_linear_W (Shape: 12 x 32)
const int L4_linear_W_rows = 12;
const int L4_linear_W_cols = 32;
const float L4_linear_W_data[] = {
  -3.15552920e-01f, -5.86085320e-01f, -6.66565895e-01f, -5.67604482e-01f, 9.73127130e-03f, -2.97807187e-01f, 2.78753508e-02f, 7.51837119e-02f, -1.43065900e-01f, 7.10058808e-02f,
  1.31117105e-01f, 2.66749319e-03f, -1.69399649e-01f, 4.47985917e-01f, -2.38067612e-01f, 2.61652261e-01f, 1.22716658e-01f, -6.99450076e-02f, -3.43508780e-01f, 6.46960214e-02f,
  -1.78758381e-03f, 2.03389674e-01f, -1.37671873e-01f, 1.29168972e-01f, -6.60299137e-02f, 2.88195133e-01f, -8.80794600e-02f, 4.96195436e-01f, -1.48858026e-01f, 5.19771099e-01f,
  2.98166424e-02f, -5.52747585e-02f, -1.64396137e-01f, 4.76012975e-01f, 4.26280439e-01f, 5.57818890e-01f, -6.88710362e-02f, 5.31144775e-02f, -4.12516803e-01f, -6.22691251e-02f,
  3.02895695e-01f, -2.84701556e-01f, 3.95097762e-01f, 6.03615999e-01f, -3.07930589e-01f, 3.38434577e-01f, -1.09163329e-01f, 2.80043811e-01f, -2.07581088e-01f, -2.80770510e-01f,
  -5.53100556e-03f, 6.63596153e-01f, 1.47128031e-01f, 2.78595060e-01f, 4.33784090e-02f, 1.34656176e-01f, -3.17710400e-01f, -2.16065750e-01f, -2.18070601e-03f, 2.25543752e-02f,
  2.73863912e-01f, 1.44098669e-01f, -1.41791068e-02f, 4.77868244e-02f, 5.17790854e-01f, 1.47506922e-01f, -3.34593028e-01f, 5.10482371e-01f, 8.13267455e-02f, 5.97690105e-01f,
  -3.63700807e-01f, 3.09330314e-01f, 7.61610717e-02f, 2.36561690e-02f, -3.44289392e-01f, -1.01176076e-01f, 7.74725854e-01f, 3.30765061e-02f, -9.76062566e-02f, -1.82889268e-01f,
  1.35125324e-01f, 2.09863797e-01f, 1.09240234e-01f, -3.01442057e-01f, -1.60056457e-01f, -1.44830674e-01f, 5.85336331e-03f, 1.10056393e-01f, -2.04998553e-02f, -2.89063960e-01f,
  3.11560109e-02f, -1.87864512e-01f, -1.10506460e-01f, -2.39787474e-01f, 3.81436259e-01f, -1.83877811e-01f, -1.15903683e-01f, -2.28456035e-01f, -4.02551815e-02f, -8.62553045e-02f,
  -2.11654097e-01f, -6.33962899e-02f, 8.44433248e-01f, -4.71723944e-01f, -2.94496059e-01f, 2.97475457e-01f, 2.62279436e-02f, -6.61274135e-01f, -4.36657034e-02f, -1.58859976e-02f,
  -2.29397297e-01f, 3.47901508e-02f, 1.87484115e-01f, 7.95669556e-02f, -2.50027943e-02f, 2.15215594e-01f, 2.56985985e-03f, 3.51764023e-01f, -8.48100483e-02f, 3.12632084e-01f,
  1.98735520e-01f, -1.13508902e-01f, 5.44217564e-02f, 3.37730527e-01f, -1.82839215e-01f, -2.85963088e-01f, 6.91825807e-01f, -1.43217862e-01f, -5.02829373e-01f, -2.18249619e-01f,
  1.91696152e-01f, -4.78460461e-01f, -4.89998490e-01f, -3.01493645e-01f, 8.71520460e-01f, -5.41520298e-01f, -7.76756644e-01f, 5.07970929e-01f, -1.18966274e-01f, -2.03297645e-01f,
  4.56569314e-01f, 2.45152324e-01f, -3.11980695e-01f, 1.47598326e-01f, 1.73321128e-01f, -1.10478826e-01f, -4.21472788e-01f, -4.02320772e-01f, -1.97862819e-01f, -4.77840304e-02f,
  -3.57947677e-01f, 7.47187287e-02f, -1.03755496e-01f, 4.32645977e-01f, -1.03136085e-01f, 1.82735488e-01f, -3.89487743e-01f, 8.04496482e-02f, 3.60010535e-01f, -1.76790848e-01f,
  2.19140835e-02f, -3.30394745e-01f, 3.87312844e-02f, 1.50452539e-01f, 2.89389253e-01f, 5.17474264e-02f, -4.32215244e-01f, 2.06130788e-01f, 1.53498664e-01f, 1.80499181e-01f,
  4.00611848e-01f, 3.15729141e-01f, 1.37499928e-01f, 1.23347722e-01f, -2.38751218e-01f, -2.75559574e-01f, -2.08773568e-01f, -8.94405469e-02f, 2.23785207e-01f, -1.55491441e-01f,
  -1.17764957e-01f, 2.47494444e-01f, 5.72683692e-01f, 8.89107734e-02f, 1.41124696e-01f, 1.23971730e-01f, -2.22989038e-01f, -1.44984527e-03f, 5.52675486e-01f, -5.92295453e-02f,
  2.55614787e-01f, -4.34147678e-02f, 6.01881519e-02f, -2.34387487e-01f, -2.33574256e-01f, 3.25411797e-01f, 4.50038731e-01f, 1.44661933e-01f, -7.18579233e-01f, 6.52396858e-01f,
  4.42037195e-01f, -3.47746849e-01f, -2.64874667e-01f, 7.77037263e-01f, -3.24052691e-01f, -4.34264064e-01f, 7.94818878e-01f, -2.09827796e-01f, -1.45725444e-01f, 3.20232987e-01f,
  5.25977969e-01f, -5.50680339e-01f, 1.72548994e-01f, -2.93556511e-01f, -2.58793890e-01f, -2.02854082e-01f, 2.93294013e-01f, -2.15400532e-01f, -1.28620848e-01f, -1.88768476e-01f,
  6.04736060e-02f, 4.58740778e-02f, -4.71118987e-01f, 1.49099559e-01f, -4.58607495e-01f, 3.15547064e-02f, 1.88249245e-01f, -4.68387753e-01f, -1.60558969e-01f, -5.44194698e-01f,
  -4.66380298e-01f, -3.21171671e-01f, 2.08274826e-01f, -3.66285473e-01f, 2.77052671e-01f, 3.99010956e-01f, -8.25405359e-01f, 3.16841975e-02f, 5.17949089e-02f, 1.31358266e-01f,
  1.28208131e-01f, 9.94852185e-03f, -2.97208522e-02f, 8.00665736e-01f, -1.68125723e-02f, -3.50991599e-02f, 1.45043403e-01f, 3.03742290e-01f, -1.73711419e-01f, 2.30023712e-02f,
  3.87523472e-01f, 2.06969708e-01f, -2.62702465e-01f, -1.41691014e-01f, 1.28248677e-01f, 4.42619205e-01f, -2.74071306e-01f, -9.77927297e-02f, -2.07412571e-01f, -5.62180340e-01f,
  -4.68864977e-01f, -4.26190227e-01f, 6.40502512e-01f, 1.53557658e-01f, -4.46462408e-02f, -2.04957440e-01f, 4.17265892e-01f, -4.57611382e-01f, -5.53090334e-01f, -5.59475869e-02f,
  -5.49178839e-01f, 3.09807926e-01f, 4.58654203e-02f, 3.38306606e-01f, 2.67075270e-01f, 4.34716403e-01f, 2.06554890e-01f, 5.91848083e-02f, 2.42918566e-01f, 6.20676219e-01f,
  3.29720974e-01f, -2.11445823e-01f, 4.32736017e-02f, 1.04848556e-02f, 1.48848826e-02f, 7.37127140e-02f, -3.52344126e-01f, 2.37132594e-01f, 8.83646786e-01f, 4.66640115e-01f,
  2.17597649e-01f, 5.73597670e-01f, -1.44636586e-01f, 6.24956548e-01f, 3.83336037e-01f, -1.45234764e-01f, 6.05008364e-01f, 8.40873495e-02f, -5.05463004e-01f, -3.06078017e-01f,
  4.48558331e-01f, -4.59746152e-01f, 8.99992585e-01f, -6.52510896e-02f, -1.13449447e-01f, 3.61361913e-02f, -2.28063166e-01f, -2.97488183e-01f, -2.25664496e-01f, -4.57466483e-01f,
  -4.29330409e-01f, -7.75817707e-02f, -6.56255111e-02f, -5.92369661e-02f, 2.67147452e-01f, -1.99970782e-01f, -3.16087186e-01f, -1.20831013e-01f, -1.85528949e-01f, 6.29122034e-02f,
  3.78543139e-01f, 4.43524539e-01f, 6.19538307e-01f, -7.07172155e-02f, 2.86918253e-01f, 6.09772699e-03f, 1.02200627e-01f, 1.47987470e-01f, -3.71070415e-01f, 4.54998344e-01f,
  -2.85987258e-01f, -7.14650452e-01f, 7.91134000e-01f, 2.06805274e-01f, -1.17557868e-01f, 1.76506177e-01f, 8.44626036e-03f, -2.37771511e-01f, -7.58464634e-01f, -3.60168964e-01f,
  1.37691543e-01f, -4.83423797e-03f, 2.65420992e-02f, -2.37611964e-01f, -3.41301113e-01f, 2.51072258e-01f, -3.74126196e-01f, -3.00259799e-01f, 2.71745920e-02f, 1.20030701e-01f,
  -3.30897510e-01f, -6.32442534e-02f, -6.73724711e-01f, -7.76596442e-02f, -4.52270210e-01f, -2.11785331e-01f, -2.10356079e-02f, -5.98936379e-01f, -3.39183360e-01f, 2.22569600e-01f,
  -7.46211931e-02f, -6.25188410e-01f, 3.39720011e-01f, 2.50246406e-01f, -7.08462298e-01f, -4.25162643e-01f, 7.41226450e-02f, -7.32616112e-02f, -2.20734984e-01f, -4.43997160e-02f,
  7.94463158e-01f, 8.12788308e-02f, 1.45885557e-01f, -2.25973383e-01f, 3.27183545e-01f, -2.56485879e-01f, 3.97020161e-01f, -1.82017922e-01f, 1.68002218e-01f, -1.76982224e-01f,
  2.29029790e-01f, -1.05969302e-01f, -1.20011307e-01f, 2.77090222e-01f
};

// L4_linear_B (Shape: 1 x 12)
const int L4_linear_B_rows = 1;
const int L4_linear_B_cols = 12;
const float L4_linear_B_data[] = {
  -4.17361975e-01f, 9.67588499e-02f, 9.09950510e-02f, -6.94316179e-02f, -1.03104122e-01f, 1.43573403e-01f, 1.65191799e-01f, -2.24745438e-01f, -3.29092592e-01f, 3.19039911e-01f,
  -1.09626517e-01f, 4.89687212e-02f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 6, 20
    );
    
    // Camada 1: L1_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L1_fan_Wp_data, L1_fan_Wp_bar_data, L1_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 2: L2_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L2_fan_Wp_data, L2_fan_Wp_bar_data, L2_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 3: L3_fan
    fan_layer_forward_pgm(
        buffer1, buffer2,
        L3_fan_Wp_data, L3_fan_Wp_bar_data, L3_fan_Bp_bar_data,
        32, 6, 20
    );
    
    // Troca os buffers
    memcpy(buffer1, buffer2, sizeof(float) * FAN_HIDDEN_SIZE);
    
    // Camada 4: L4_linear
    linear_forward_pgm(
        buffer1, x_out,
        L4_linear_W_data, L4_linear_B_data,
        32, 12
    );
    }
    