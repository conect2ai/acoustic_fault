/*
    * Modelo FAN Gerado Automaticamente
    *
    * Arquitetura:
    * Entrada: 120
    * Oculta: 64 (x1)
    * Saída: 12
    * Buffer Máx: 120
    *
    * Uso:
    * #include "fan_model.h"
    *
    * float my_input[120] = { ... };
    * float my_output[12];
    *
    * fan_predict(my_input, my_output);
    */

    #pragma once
    #include <math.h>
    #include <string.h>

    // Detecção automática de arquitetura
    #if defined(__AVR__)
    #include <avr/pgmspace.h>
    #define FAN_READ_FLOAT(p) pgm_read_float(p)
    #define FAN_PROGMEM PROGMEM
    #define FAN_BUFFER_STORAGE static
    #elif defined(ESP32)
    #include <rom/ets_sys.h>
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    // CORREÇÃO: 'static' adicionado abaixo para evitar Stack Overflow no ESP32
    #define FAN_BUFFER_STORAGE static 
    #elif defined(__arm__) || defined(__ARM_ARCH)
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #else
    // Fallback para outras arquiteturas
    #define FAN_READ_FLOAT(p) (*(p))
    #define FAN_PROGMEM
    #define FAN_BUFFER_STORAGE static
    #endif

    // --- Dimensões Globais ---
    const int FAN_INPUT_SIZE = 120;
    const int FAN_OUTPUT_SIZE = 12;
    const int FAN_HIDDEN_SIZE = 64;
    const int FAN_MAX_BUFFER_SIZE = 120;

    // --- Funções de Ativação ---
    
    static inline float fan_activation(float x) {
    float x3 = x * x * x;
    return 0.5f * x * (1.0f + tanhf(0.79788456f * (x + 0.044715f * x3)));
    }
    
    // Multiplicação Matriz-Vetor (W*x) + Bias (B)
    static void linear_forward_pgm(const float* x_in, float* x_out,
                                const float* W_pgm, const float* B_pgm,
                                int d_in, int d_out) {
    for (int i = 0; i < d_out; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = sum + FAN_READ_FLOAT(&B_pgm[i]);
    }
    }

    // Camada FAN
    static void fan_layer_forward_pgm(const float* x_in, float* x_out,
                                    const float* W_p_pgm, 
                                    const float* W_p_bar_pgm, 
                                    const float* B_p_bar_pgm,
                                    int d_in, int d_p, int d_p_bar) {
    
    // 1. Ramo Periódico
    for (int i = 0; i < d_p; i++) {
        float sum = 0.0f;
        int w_offset = i * d_in;
        for (int j = 0; j < d_in; j++) {
        sum += FAN_READ_FLOAT(&W_p_pgm[w_offset + j]) * x_in[j];
        }
        x_out[i] = cosf(sum);
        x_out[i + d_p] = sinf(sum);
    }

    // 2. Ramo MLP
    float* mlp_out_ptr = &x_out[2 * d_p];
    linear_forward_pgm(x_in, mlp_out_ptr, W_p_bar_pgm, B_p_bar_pgm, d_in, d_p_bar);

    // 3. Ativação
    for (int i = 0; i < d_p_bar; i++) {
        mlp_out_ptr[i] = fan_activation(mlp_out_ptr[i]);
    }
    }

    // --- Definição dos Pesos ---
    // L0_fan_Wp (Shape: 25 x 120)
const int L0_fan_Wp_rows = 25;
const int L0_fan_Wp_cols = 120;
const float L0_fan_Wp_data[] = {
  -1.17189601e-01f, 1.77897900e-01f, 4.10904348e-01f, 8.96540955e-02f, -1.50290564e-01f, -1.72189146e-01f, 1.63808726e-02f, -1.40527248e-01f, -3.82595286e-02f, -1.34389549e-01f,
  -2.20295176e-01f, 2.63033003e-01f, 1.52729638e-02f, -3.21535468e-01f, 2.68840250e-02f, -1.11817420e-01f, -2.18827993e-01f, -3.11191124e-03f, 4.33955826e-02f, 1.33894216e-02f,
  1.03149991e-02f, -4.13880438e-01f, 5.52932685e-03f, -2.24464923e-01f, -6.88706618e-03f, 1.84683323e-01f, 2.64108516e-02f, 1.02322951e-01f, -9.86059010e-02f, -1.32728115e-01f,
  -1.60999730e-01f, -4.18055877e-02f, 2.61685308e-02f, -8.04851996e-04f, 1.22672684e-01f, 3.48352380e-02f, 5.13478294e-02f, 6.23004846e-02f, 3.03803440e-02f, 1.25178499e-02f,
  6.24648221e-02f, -7.17863888e-02f, -2.41437536e-02f, -2.26502251e-02f, 1.77311723e-03f, 5.91227040e-02f, 1.18643660e-02f, 3.13634947e-02f, -3.85540389e-02f, 1.82862170e-02f,
  1.04931658e-02f, -5.65085076e-02f, 1.02224331e-02f, 2.45695114e-02f, 5.82314916e-02f, -6.65740445e-02f, 6.19994476e-02f, 5.12132607e-02f, -1.14325350e-02f, -3.25188152e-02f,
  -3.07283793e-02f, -5.68761304e-03f, -8.42115842e-03f, -4.90332916e-02f, -1.17335171e-02f, -2.38876622e-02f, 4.27812012e-03f, -1.30779659e-02f, 1.33963060e-02f, -9.37027298e-03f,
  8.34142044e-03f, 2.63678748e-03f, -3.86543833e-02f, 1.85484439e-02f, -3.61166969e-02f, 3.30831371e-02f, 3.02189998e-02f, -4.63931076e-02f, -1.89881008e-02f, -1.91047397e-02f,
  -2.12922078e-02f, -4.99959849e-02f, -4.12712879e-02f, 3.06328922e-03f, -2.85932701e-02f, 1.07053639e-02f, -4.35872339e-02f, 2.79300604e-02f, -2.27243546e-02f, 2.28759702e-02f,
  8.12960640e-02f, 1.87428579e-01f, 3.38163674e-02f, -1.98057573e-02f, -1.99388564e-02f, -6.70636073e-02f, -5.27101569e-02f, -8.20727088e-03f, -3.01893428e-03f, -3.76322530e-02f,
  2.96450779e-02f, 7.85835832e-02f, 4.47570719e-02f, -9.95043758e-03f, 1.74279772e-02f, -6.95459023e-02f, 3.54825072e-02f, 2.68787630e-02f, 5.67992926e-02f, -4.17680740e-02f,
  3.13402675e-02f, 3.30911726e-02f, 2.00687945e-02f, 4.70004184e-03f, 2.07409803e-02f, 3.24069113e-02f, 4.55947928e-02f, 8.11423212e-02f, 2.36371960e-02f, 1.67579688e-02f,
  -3.43261957e-01f, 2.20125094e-01f, 1.67335272e-01f, 1.26814216e-01f, -3.74854982e-01f, -3.67145747e-01f, -2.38857135e-01f, -1.44317672e-01f, -5.97288497e-02f, 2.16197565e-01f,
  3.36176790e-02f, 1.44973859e-01f, -5.57615096e-03f, 1.42026216e-01f, -2.16286168e-01f, 9.54248011e-03f, -7.41429627e-02f, 9.22670960e-02f, -3.44913788e-02f, -2.79313941e-02f,
  -1.56425878e-01f, -5.50924577e-02f, 1.34417966e-01f, 3.72603126e-02f, -1.28582627e-01f, 1.77232519e-01f, 1.68161262e-02f, 1.12553816e-02f, 1.37799025e-01f, 4.93959263e-02f,
  -1.25448210e-02f, 6.08799346e-02f, -1.39996149e-02f, 1.12278946e-01f, -8.86533409e-02f, -6.15229756e-02f, 2.32310370e-02f, 5.30404709e-02f, 4.11532857e-02f, 1.87559873e-02f,
  5.15953228e-02f, -4.46028113e-02f, 9.57250770e-04f, 9.19856317e-03f, -5.14915772e-03f, 3.26529816e-02f, -1.55843906e-02f, -5.03084809e-02f, 2.66720634e-03f, -5.90841919e-02f,
  1.36769831e-03f, 1.73352342e-02f, -4.69358116e-02f, 1.28342047e-01f, -2.36426555e-02f, 4.36313711e-02f, -1.93228442e-02f, -5.31027503e-02f, 3.00125908e-02f, 5.81623113e-04f,
  -5.93205690e-02f, -5.82320429e-02f, -7.64334276e-02f, -1.55192632e-02f, -7.27255270e-02f, 3.37927975e-02f, -3.25602889e-02f, 3.40408385e-02f, 3.66340689e-02f, -6.15986325e-02f,
  -3.27240527e-02f, 1.02077065e-04f, -1.05879987e-02f, -4.37160805e-02f, -3.18494253e-02f, -8.15186359e-04f, -4.07102704e-02f, 5.09936772e-02f, 8.10108036e-02f, -1.52182684e-03f,
  6.65029287e-02f, -1.27477003e-02f, -1.01591740e-02f, 6.57101497e-02f, 3.00812069e-03f, -2.55908985e-02f, -1.33694080e-03f, -3.44661362e-02f, 1.73065811e-02f, -5.31171188e-02f,
  -6.00123145e-02f, -2.78272722e-02f, 1.45076122e-02f, 9.73370522e-02f, 7.72755742e-02f, 5.44554729e-04f, 6.12094030e-02f, -8.74424353e-02f, 1.34519232e-03f, -8.85197520e-02f,
  -1.96102243e-02f, 6.78883046e-02f, -7.18779787e-02f, 5.92010878e-02f, 3.37791741e-02f, -5.64693362e-02f, 4.25459864e-03f, 2.88027842e-02f, -1.03570912e-02f, 6.17400110e-02f,
  -2.75893155e-02f, -5.90238385e-02f, 1.54030761e-02f, -5.77608198e-02f, 3.61997485e-02f, -1.56875066e-02f, 2.16372740e-02f, 1.07935086e-01f, -8.61345732e-04f, 4.75781336e-02f,
  -8.40801001e-02f, 1.32233128e-01f, 2.36489698e-02f, 1.94693357e-01f, 8.30279067e-02f, 1.69692144e-01f, 3.21241934e-03f, 1.38041332e-01f, 7.42395818e-02f, 1.75125077e-01f,
  -3.53535712e-02f, -1.87303554e-02f, -2.35861540e-01f, 2.79959351e-01f, -3.38321030e-02f, -1.60495609e-01f, 3.45682800e-01f, 1.17598541e-01f, -9.76934936e-03f, 5.48665505e-03f,
  3.63644073e-03f, 1.58663958e-01f, -1.13631316e-01f, 7.73974210e-02f, 4.85931188e-02f, -6.23278727e-04f, -1.32842511e-01f, -2.24723965e-01f, 2.06537321e-01f, -2.80345324e-03f,
  5.97735904e-02f, 7.17407698e-03f, -4.99590719e-03f, 2.50873454e-02f, 3.22723314e-02f, -4.25368436e-02f, -1.90647393e-02f, -5.61077148e-02f, 2.17403602e-02f, 1.23690413e-02f,
  -2.97403038e-02f, 6.35048896e-02f, 1.53906897e-01f, 1.95179775e-03f, 2.89765112e-02f, 4.91952300e-02f, 3.31105553e-02f, 1.06889255e-01f, 3.45858410e-02f, 1.88446809e-02f,
  1.46905164e-04f, -2.59854067e-02f, 3.42168845e-02f, 8.11863914e-02f, 1.75774172e-02f, -1.82019938e-02f, 1.88572370e-02f, -2.63733100e-02f, 2.04566419e-02f, 9.49348137e-02f,
  2.81650946e-02f, -1.09163187e-02f, -1.90733429e-02f, 7.11886510e-02f, -3.64715792e-02f, 2.15587374e-02f, 2.32961122e-02f, -4.35111150e-02f, -2.45115031e-02f, -2.47271992e-02f,
  1.54419597e-02f, 8.41518864e-02f, -1.27444509e-02f, 3.85065489e-02f, 3.08221560e-02f, -1.81027856e-02f, 1.32173095e-02f, -3.64184231e-02f, 7.45964572e-02f, 7.11855319e-05f,
  -5.57089895e-02f, -1.60962436e-02f, -7.56627007e-04f, 2.84473244e-02f, -1.51810171e-02f, -2.13213507e-02f, 7.30613843e-02f, 3.27005722e-02f, 3.42098475e-02f, -8.02066922e-02f,
  7.85912126e-02f, -6.26149923e-02f, 6.09009750e-02f, 8.35251361e-02f, -6.05408065e-02f, 8.22980553e-02f, -1.35537395e-02f, 1.79241598e-02f, 3.63295227e-02f, 2.44423728e-02f,
  7.16660693e-02f, -6.66482449e-02f, 6.95277192e-03f, 3.75194894e-03f, 3.26116718e-02f, 4.83558662e-02f, -9.58263967e-03f, -3.97035889e-02f, -2.47105490e-02f, -5.76842688e-02f,
  -3.21120694e-02f, 9.50427633e-03f, -1.14615494e-02f, 4.51155975e-02f, 8.72178525e-02f, 2.34621391e-02f, -3.66837047e-02f, -7.08741397e-02f, -8.41629878e-02f, 6.96924189e-03f,
  3.93232107e-01f, -4.15398926e-02f, 1.06661513e-01f, 2.34956428e-01f, 5.03536593e-03f, -2.91240692e-01f, -1.02087334e-01f, 3.48448940e-02f, 4.32225168e-01f, -1.28719866e-01f,
  -1.75484285e-01f, 1.07426554e-01f, 1.08875930e-02f, 2.86350455e-02f, 1.19593382e-01f, 1.09405890e-01f, -9.47189033e-02f, -4.72717062e-02f, 1.65050939e-01f, 3.66589874e-02f,
  1.52527198e-01f, -8.61634687e-02f, -8.93569924e-03f, -1.31033421e-01f, -5.88501692e-02f, -1.39823393e-03f, -1.09173939e-01f, -3.81165184e-02f, -1.80601045e-01f, -6.73865676e-02f,
  -4.04209904e-02f, 1.10591948e-01f, 1.07259601e-02f, -6.59485441e-03f, -2.34949086e-02f, -3.17643397e-02f, -3.89800556e-02f, -5.31058535e-02f, -2.41646753e-03f, 1.68772060e-02f,
  -2.22248607e-03f, 5.34117632e-02f, 5.64106181e-02f, 1.45372273e-02f, 5.88483661e-02f, 8.21495876e-02f, 9.06562433e-03f, 2.78586186e-02f, -3.92775983e-03f, -2.92234737e-02f,
  4.54896651e-02f, -6.61986470e-02f, -4.95728292e-02f, -1.19277025e-02f, 5.28492816e-02f, 1.68194324e-02f, -4.38833497e-02f, -5.18377051e-02f, -5.96319176e-02f, 3.99048068e-02f,
  -3.41165178e-02f, 2.85315625e-02f, 1.68823227e-02f, 3.47203128e-02f, 1.41770458e-02f, 3.54292989e-02f, 5.77652715e-02f, -2.41870570e-04f, 1.15990518e-02f, -2.03097854e-02f,
  6.51732981e-02f, 3.45129482e-02f, 1.24931801e-02f, -2.91110482e-02f, 1.46568567e-02f, 1.48595376e-02f, 3.20443138e-02f, -1.88721195e-02f, 1.68745052e-02f, 1.44425910e-02f,
  7.87401386e-03f, 1.54663287e-02f, -7.52750784e-02f, -2.10390724e-02f, -1.85337234e-02f, -2.56879739e-02f, -1.90027263e-02f, 3.57162282e-02f, 1.53633207e-02f, -3.20103839e-02f,
  -1.06484629e-01f, -6.00781329e-02f, -7.52273062e-03f, -2.87198443e-02f, -4.20806333e-02f, -1.22207673e-02f, 3.18668559e-02f, 1.72169246e-02f, 8.28503445e-02f, 2.64381208e-02f,
  -1.02692582e-01f, -4.11292762e-02f, -3.41171734e-02f, -7.12721888e-03f, 1.11494409e-02f, -7.89206997e-02f, 7.42288353e-03f, -1.36878667e-02f, -3.79786342e-02f, -4.08612825e-02f,
  -8.02889392e-02f, 1.12083415e-02f, 4.24124226e-02f, 3.41423862e-02f, -8.24716762e-02f, -4.36378270e-02f, -7.46392179e-03f, 6.22168835e-03f, 2.72396132e-02f, -3.81877422e-02f,
  4.62968737e-01f, -1.60936281e-01f, 3.66301090e-01f, 1.22406393e-01f, 2.01747671e-01f, 1.94884613e-02f, 1.04791254e-01f, 8.81997943e-02f, 7.21518248e-02f, -2.28083268e-01f,
  -9.01608616e-02f, 1.89097002e-01f, -1.50689408e-01f, -1.21366963e-01f, 9.54050645e-02f, -3.09681624e-01f, -8.69819522e-02f, -2.90355794e-02f, 5.96601702e-02f, 1.66021645e-01f,
  1.27740324e-01f, -1.87179342e-01f, 9.05690342e-02f, -1.65594667e-01f, 2.64151871e-01f, 2.13218287e-01f, -1.30396679e-01f, 4.71720751e-03f, 1.42145110e-02f, -4.66104485e-02f,
  -5.91630712e-02f, 2.70909294e-02f, 1.66180938e-01f, 8.37774873e-02f, 8.72353017e-02f, 4.34799120e-02f, 4.88700904e-02f, -1.89916827e-02f, 7.36912563e-02f, -1.18930116e-02f,
  2.46016169e-03f, 2.15426814e-02f, 1.33631648e-02f, -2.70450691e-04f, 6.46763146e-02f, 4.36853198e-03f, -2.13279133e-03f, 4.72485423e-02f, 4.87021618e-02f, 7.09564313e-02f,
  8.57896060e-02f, 4.89434898e-02f, 7.54982010e-02f, -3.91668789e-02f, 1.00162424e-01f, 2.01254478e-03f, -1.60007402e-02f, 4.59753387e-02f, -1.68533088e-03f, 4.32934016e-02f,
  -2.02824324e-02f, -2.81951167e-02f, -3.91654558e-02f, -1.18893571e-02f, -4.63583209e-02f, -3.51744443e-02f, -4.79826368e-02f, -5.87947033e-02f, 3.20918113e-02f, -4.97484654e-02f,
  -8.61938111e-03f, 4.89093177e-02f, -6.48803636e-02f, -5.97007619e-03f, -1.04113913e-03f, -1.96487047e-02f, -1.67317092e-02f, -5.93673112e-03f, 2.60351505e-02f, 2.19467580e-02f,
  -8.06874260e-02f, 9.50072892e-03f, -1.90009363e-02f, -3.61830480e-02f, -6.15474582e-02f, 5.97494561e-03f, -4.18117410e-03f, 2.73262914e-02f, -1.01495782e-04f, -3.29656489e-02f,
  -1.20410636e-01f, -1.48579046e-01f, -5.53210825e-02f, -2.62283031e-02f, -8.95193964e-02f, 5.76224038e-03f, -1.01531394e-01f, 1.07363081e-02f, -1.96604393e-02f, 9.38312430e-03f,
  4.79220711e-02f, 9.12096538e-03f, -2.40726769e-02f, -9.73814074e-03f, -2.53272112e-02f, -5.84364054e-04f, -3.90608869e-02f, -1.23243835e-02f, -2.97579747e-02f, -9.79978126e-03f,
  9.14623681e-03f, -1.71914622e-02f, -3.20027769e-02f, 6.14072802e-03f, -1.97719987e-02f, -7.50963297e-03f, 7.16650113e-02f, 3.51275578e-02f, -6.76851720e-02f, -4.49687876e-02f,
  -9.84305441e-02f, -3.38434786e-01f, 1.33293739e-04f, -7.30987787e-02f, 3.23347837e-01f, 2.53852636e-01f, 1.95011035e-01f, 1.05115306e-02f, -7.32655004e-02f, -7.59257302e-02f,
  1.48330271e-01f, -2.04428315e-01f, -3.07307784e-02f, -3.60753424e-02f, 1.48458146e-02f, -1.89360842e-01f, -6.41170815e-02f, -4.44715209e-02f, -4.89608757e-02f, 1.04379747e-02f,
  2.25819647e-02f, 6.85420632e-02f, 7.36444220e-02f, 8.10725763e-02f, 5.92375323e-02f, -6.64450377e-02f, 3.42519395e-02f, 1.44508779e-01f, 1.89717929e-03f, -7.03960210e-02f,
  2.05727658e-04f, -5.74399792e-02f, -2.20282171e-02f, -6.76241517e-02f, 9.07833725e-02f, 8.30912590e-02f, 2.29217093e-02f, 1.78479322e-03f, 3.44900303e-02f, 7.28113130e-02f,
  -7.59635791e-02f, 4.58038524e-02f, -7.61001185e-02f, 2.33122464e-02f, 6.44250736e-02f, 3.97333130e-02f, 9.09559522e-03f, 5.36970906e-02f, -3.53093296e-02f, -1.04572438e-02f,
  -2.84647290e-02f, -4.56783138e-02f, 9.33965296e-02f, -3.22474353e-02f, 4.73366752e-02f, 4.71379943e-02f, -2.95772068e-02f, -3.92837487e-02f, 7.80669879e-03f, 2.30151322e-02f,
  -5.02368920e-02f, -1.72368400e-02f, -2.57216692e-02f, -9.44929104e-03f, 2.94563510e-02f, 5.42272925e-02f, 3.24968211e-02f, 9.43113770e-03f, -6.69185817e-02f, 4.49325591e-02f,
  3.20960246e-02f, 5.01427762e-02f, 4.74017076e-02f, 3.40597183e-02f, 6.08492307e-02f, 4.22942787e-02f, 2.68168095e-02f, -1.95411332e-02f, 3.48194689e-02f, 4.35484312e-02f,
  4.51568812e-02f, 4.67383340e-02f, -1.36025781e-02f, 4.40924652e-02f, 1.97424088e-02f, -8.80332571e-03f, -4.33388576e-02f, 1.29642645e-02f, 1.18692946e-02f, -8.71301454e-04f,
  3.17044258e-02f, -2.27507085e-01f, 4.53547314e-02f, 4.27222401e-02f, -2.10344996e-02f, 2.10863985e-02f, 1.86675377e-02f, -5.95073998e-02f, -3.07000633e-02f, -5.09364605e-02f,
  9.15895924e-02f, -4.77037132e-02f, 4.32641618e-02f, 5.38090318e-02f, -2.08963044e-02f, -2.62950454e-02f, -6.45450652e-02f, 2.80558295e-03f, 3.47869955e-02f, -2.12444477e-02f,
  1.09153204e-02f, 6.13893569e-02f, -3.98966521e-02f, -3.20204049e-02f, -9.13051981e-03f, -4.43422608e-02f, -4.29991111e-02f, -2.49854987e-03f, 2.66659632e-02f, -8.43142942e-02f,
  -1.64499849e-01f, -1.25630334e-01f, -2.62381852e-01f, -9.29137543e-02f, 1.93689197e-01f, -2.32971728e-01f, -3.73842686e-01f, 1.84375405e-01f, -4.75775264e-02f, 7.54722208e-02f,
  1.29962206e-01f, -3.20890695e-01f, -1.69626926e-03f, -7.98260793e-02f, -2.17792809e-01f, -1.30990446e-01f, -1.22514412e-01f, -1.20651454e-01f, -3.10555175e-02f, -2.30232347e-02f,
  3.05766314e-02f, 2.00314716e-01f, -5.76716885e-02f, 2.52841979e-01f, 4.98834252e-02f, 5.73467538e-02f, 3.12705189e-01f, 1.10069616e-02f, 1.10830992e-01f, -1.92898829e-02f,
  -5.61662838e-02f, 1.05522081e-01f, -4.37028185e-02f, -1.08203173e-01f, 4.05904502e-02f, 2.61641964e-02f, -8.69710147e-02f, -5.62953539e-02f, -3.85759659e-02f, -1.29959248e-02f,
  -8.13980177e-02f, -3.51184234e-02f, 2.20711473e-02f, 7.11141080e-02f, -4.15339367e-03f, 7.73244649e-02f, -2.35086004e-03f, -1.63669512e-02f, 1.82223413e-02f, -3.29801021e-03f,
  -1.61889065e-02f, -1.97885595e-02f, -1.97369382e-02f, -6.98368028e-02f, -4.70692329e-02f, 4.31946255e-02f, -1.13212384e-01f, -2.39550490e-02f, -6.94065690e-02f, 3.06199342e-02f,
  8.06753431e-03f, -2.85350922e-02f, 3.07718981e-02f, 4.11575008e-03f, -6.90323114e-03f, 2.62566991e-02f, -5.70262782e-02f, 4.38975357e-02f, -4.88059595e-03f, 4.32140231e-02f,
  -1.36258230e-02f, 4.45586406e-02f, 4.36908230e-02f, 3.02961692e-02f, -2.20671836e-02f, 1.67196412e-02f, -4.98525500e-02f, 5.76757593e-03f, -1.81965809e-02f, 3.96957248e-02f,
  -1.31984614e-02f, -1.01222387e-02f, -1.59980245e-02f, 6.71379408e-03f, -5.78379221e-02f, 2.41984073e-02f, 6.70668259e-02f, -6.07961826e-02f, -3.30715477e-02f, -3.73234623e-03f,
  -8.80487189e-02f, 7.77921826e-02f, -4.02916130e-03f, 5.68823610e-03f, -3.18761542e-02f, -3.90018038e-02f, -5.01953028e-02f, 1.40318507e-02f, -1.34885334e-03f, 1.34260440e-02f,
  2.37252261e-03f, 4.74440344e-02f, -7.45086093e-03f, -4.08216342e-02f, -2.54793447e-02f, -3.54370736e-02f, 1.11688683e-02f, 5.53636206e-03f, -1.61046591e-02f, -2.01122661e-04f,
  2.91428436e-02f, -4.55933530e-03f, -2.62566302e-02f, 4.11607586e-02f, 3.92106138e-02f, -4.47531929e-03f, 1.40625499e-02f, -3.14922743e-02f, 6.41462877e-02f, -5.36783412e-02f,
  3.52783129e-02f, -1.80653915e-01f, 1.50964335e-01f, 3.68202686e-01f, 1.07487485e-01f, -3.63451064e-01f, -1.33763561e-02f, 3.58182304e-02f, 4.31523658e-02f, -1.85345039e-01f,
  6.23048171e-02f, -1.36238769e-01f, -7.00842440e-02f, 3.18983570e-02f, 1.70257390e-02f, -1.43133327e-01f, 3.84260640e-02f, -1.74189210e-01f, -5.78851663e-02f, 7.47371837e-02f,
  1.02812104e-01f, 6.21003136e-02f, 2.88641810e-01f, 2.09446833e-03f, 1.16819948e-01f, 1.23429857e-01f, 1.88581645e-01f, 1.27104387e-01f, -2.57262606e-02f, -5.72645068e-02f,
  -6.15316406e-02f, 6.63446635e-02f, 9.15544778e-02f, -8.53282288e-02f, 3.02545470e-03f, 4.68486134e-04f, -7.27376156e-03f, -1.24799395e-02f, 3.38167772e-02f, -2.41945274e-02f,
  -1.12918757e-01f, -6.24205433e-02f, -3.93453464e-02f, 2.58401800e-02f, 7.43288640e-03f, 4.95496802e-02f, -3.90046882e-03f, -9.08988900e-03f, 1.10064372e-02f, 4.59825508e-02f,
  7.17598870e-02f, -5.29271998e-02f, 8.60849023e-02f, 3.23322304e-02f, 5.84556200e-02f, -2.93650012e-02f, 1.33081852e-02f, 5.62562160e-02f, -3.26704755e-02f, -4.43411767e-02f,
  -7.52786398e-02f, 1.79481003e-02f, 5.05083278e-02f, -1.74480677e-02f, 3.46543454e-02f, 5.26464656e-02f, -1.45290140e-02f, 5.29019311e-02f, -3.29161137e-02f, -3.19533832e-02f,
  -1.33591928e-02f, 2.82578170e-02f, -2.57308222e-03f, 2.29429975e-02f, 8.12856779e-02f, 1.98022146e-02f, -1.46428905e-02f, 1.04103831e-03f, 1.00325542e-02f, 2.72503328e-02f,
  4.05697785e-02f, -8.12472105e-02f, 2.84874868e-02f, 6.97874278e-03f, -8.23976621e-02f, 3.57482880e-02f, -1.99565720e-02f, -4.77425195e-02f, 1.34362997e-02f, 1.15567828e-02f,
  -1.79501012e-01f, -7.33559728e-02f, -1.93325747e-02f, -6.60932204e-03f, -8.09833035e-02f, -4.15870436e-02f, -2.80956421e-02f, -3.73423882e-02f, -8.09853151e-02f, -3.61878648e-02f,
  5.19713759e-02f, 7.98495188e-02f, -5.50587624e-02f, -4.20136489e-02f, 5.61553333e-03f, -6.01699166e-02f, 3.13796960e-02f, -1.26546202e-02f, 2.67624240e-02f, 3.47017013e-02f,
  9.25526321e-02f, -2.71549039e-02f, 5.86673319e-02f, 1.68540440e-02f, -3.16011235e-02f, -1.31186144e-02f, -3.30480672e-02f, -4.08717282e-02f, 2.67947111e-02f, 1.49111580e-02f,
  1.30689904e-01f, -1.51024744e-01f, 2.81567246e-01f, -3.70423757e-02f, -7.72947967e-02f, 1.49573043e-01f, 1.07127249e-01f, -4.18003835e-02f, -2.03139186e-02f, -2.01076671e-01f,
  -6.71768636e-02f, 1.59494933e-02f, 6.60299584e-02f, 5.30483015e-02f, 2.27680951e-01f, 2.62339532e-01f, 1.77369621e-02f, -3.64119634e-02f, 3.99636179e-02f, -2.39266366e-01f,
  8.57543275e-02f, -2.87939399e-01f, 1.38898745e-01f, -2.65414298e-01f, -1.53720036e-01f, -1.07586905e-01f, -1.93056494e-01f, 3.16365659e-02f, -1.33176655e-01f, 6.38870820e-02f,
  -9.42324474e-02f, -3.13510164e-03f, -1.22982748e-01f, 6.89230338e-02f, -3.81272025e-02f, -2.19505597e-02f, 5.56415832e-03f, 1.21417880e-01f, 4.58085127e-02f, 7.45071843e-02f,
  -3.13006639e-02f, 2.83301268e-02f, -8.93549435e-03f, 2.29939688e-02f, -5.72502837e-02f, 8.63319729e-03f, 1.40315602e-02f, -4.92613355e-04f, -4.60352488e-02f, 1.21982805e-01f,
  5.24699390e-02f, 2.03041807e-02f, 9.07197781e-03f, 4.69899783e-03f, -6.27904851e-03f, 1.70497820e-02f, 5.34022786e-02f, 1.22183794e-02f, -2.32776552e-02f, 3.76743861e-02f,
  -5.89632057e-02f, -5.97420037e-02f, 6.83139218e-03f, 1.73042584e-02f, 2.91025336e-03f, 2.68653147e-02f, -6.67573810e-02f, -2.11399961e-02f, 2.52495147e-02f, -3.68173905e-02f,
  -1.18297432e-02f, 2.54620984e-03f, 1.23830223e-02f, 4.21966091e-02f, -6.36448339e-02f, 1.47484662e-02f, 3.27449441e-02f, -6.55923551e-03f, 2.82322685e-03f, 1.55279450e-02f,
  3.94879989e-02f, -4.88676317e-03f, 4.13235649e-02f, -9.36169236e-04f, 3.94121837e-03f, 1.45476004e-02f, -3.51274945e-02f, 4.25647870e-02f, -6.84245117e-03f, 1.76564027e-02f,
  -3.35661203e-01f, -2.21476004e-01f, -2.46432461e-02f, -8.93623084e-02f, -5.04564047e-02f, -1.50406389e-02f, -5.66594973e-02f, -2.54072882e-02f, -8.37451443e-02f, -5.49483784e-02f,
  -3.48455869e-02f, -8.71791597e-03f, -5.25280423e-02f, 1.06282420e-02f, 8.29349086e-03f, -1.39782075e-02f, -2.78485753e-02f, -7.54471570e-02f, -7.39679486e-02f, -8.32064524e-02f,
  -1.80228017e-02f, -1.57959480e-02f, 2.04916392e-02f, -6.09889328e-02f, 4.89621423e-02f, -2.92797480e-02f, -4.00028303e-02f, 6.76848888e-02f, 3.24551202e-02f, -1.85601041e-02f,
  -8.68011639e-02f, 2.43035153e-01f, -2.43375883e-01f, -1.47118226e-01f, -7.77494833e-02f, -2.38627449e-01f, -1.72732677e-02f, -1.14765376e-01f, 8.11755881e-02f, 2.48609141e-01f,
  1.86266139e-01f, 8.88596997e-02f, 2.60831505e-01f, -6.64845929e-02f, -3.97215426e-01f, 1.08109340e-01f, -1.97641864e-01f, 3.69649529e-02f, -1.09897787e-03f, -4.74638939e-02f,
  -6.74313977e-02f, 6.39392287e-02f, -1.40366390e-01f, -5.33050625e-03f, -6.05452210e-02f, -5.18476181e-02f, 3.64844203e-02f, 3.47189903e-02f, -8.73220041e-02f, -4.60411906e-02f,
  -3.52242328e-02f, 1.71630532e-01f, -1.16764093e-02f, 5.33415265e-02f, -7.28597566e-02f, -6.28223934e-04f, -9.92164835e-02f, -2.93687768e-02f, -2.27290001e-02f, 1.34388190e-02f,
  8.17293115e-03f, -2.63648778e-02f, -1.09913340e-02f, 8.74849111e-02f, -6.21075146e-02f, -6.57536313e-02f, -3.08905039e-02f, -1.05212759e-02f, 7.06714913e-02f, -3.06767449e-02f,
  7.75656430e-03f, -2.58196909e-02f, -4.99698259e-02f, 3.46240066e-02f, -1.00327907e-02f, 1.73797719e-02f, -3.89332371e-03f, 1.14140790e-02f, 3.13824676e-02f, -4.88745049e-03f,
  5.93199097e-02f, 2.06940137e-02f, 2.39373147e-02f, 1.06670614e-02f, 3.74411768e-03f, 3.69732678e-02f, 4.21149023e-02f, -1.47586211e-03f, 1.98073313e-02f, 4.30799043e-03f,
  7.85944518e-03f, 3.50224636e-02f, 1.58991446e-04f, -1.13442270e-02f, 3.43621112e-02f, 6.13565594e-02f, -2.33466830e-02f, 6.50089979e-02f, -6.12612404e-02f, -5.68282157e-02f,
  8.10126141e-02f, -5.85861877e-02f, 4.16830219e-02f, 1.94108195e-03f, -3.03367171e-02f, 1.07145002e-02f, 1.79219078e-02f, -4.28808704e-02f, 4.18981388e-02f, -4.24555317e-02f,
  -6.86741993e-02f, 2.83477828e-02f, 5.45623489e-02f, -2.87540257e-03f, -2.31330693e-02f, 3.93186919e-02f, 8.23810138e-03f, -5.33003882e-02f, -3.71177346e-02f, 2.49874368e-02f,
  -1.00905579e-02f, -1.73694678e-02f, 1.33195510e-02f, -6.77860528e-02f, -2.46415697e-02f, 7.09028095e-02f, 6.67636842e-02f, 3.94433029e-02f, -5.80500215e-02f, -3.52402851e-02f,
  2.82521266e-02f, 2.54760757e-02f, 7.87797756e-03f, 8.21354054e-03f, -1.77735388e-02f, -3.31753939e-02f, -4.51279618e-02f, 1.26953553e-02f, -3.38555649e-02f, -3.78760435e-02f,
  1.25366300e-01f, -2.65715837e-01f, -4.92435731e-02f, 5.52451573e-02f, 1.86726585e-01f, -1.83839902e-01f, -1.36024117e-01f, -3.77209135e-03f, 2.91204751e-01f, -1.98034525e-01f,
  -1.81892008e-01f, 2.10486017e-02f, -9.62672979e-02f, -2.99062401e-01f, -9.50767845e-02f, -2.31631324e-01f, -2.96358198e-01f, -1.91709220e-01f, 8.76350701e-02f, -4.45068674e-03f,
  -4.82989289e-02f, -2.35942066e-01f, -2.72395074e-01f, -1.33229084e-02f, -8.58753547e-02f, 8.68227631e-02f, -6.33759722e-02f, 5.33775128e-02f, -1.46789342e-01f, -4.48661894e-02f,
  -4.09164950e-02f, 2.75426079e-02f, 4.85686846e-02f, 6.19092174e-02f, -9.63712186e-02f, -4.49757352e-02f, -3.68367997e-04f, 1.86994616e-02f, 1.30001307e-01f, -1.98502969e-02f,
  5.23155779e-02f, -1.59571413e-02f, 1.33299353e-02f, 5.07048424e-03f, 9.14518237e-02f, 1.21745262e-02f, 2.58362014e-02f, 1.26850205e-02f, -9.93055571e-03f, -4.82905954e-02f,
  -2.90744640e-02f, -9.77677107e-03f, 5.71559221e-02f, -3.34850587e-02f, 7.44043142e-02f, 9.38524082e-02f, -4.82842289e-02f, -2.61576343e-02f, -4.22810242e-02f, 3.90446819e-02f,
  -3.80314700e-02f, -7.00896955e-04f, -3.89101245e-02f, -4.49715890e-02f, -2.70183962e-02f, -1.69882458e-02f, 6.63562305e-03f, -7.27080181e-02f, 1.17281258e-01f, -4.33519520e-02f,
  6.75030649e-02f, 5.57414955e-03f, 5.62826544e-02f, 2.57284157e-02f, -5.58327772e-02f, 1.03625245e-02f, -1.23892715e-02f, -2.82259583e-02f, -1.14284335e-02f, 5.86918108e-02f,
  6.64798915e-03f, 1.70542393e-02f, -2.62397323e-02f, -1.28136771e-02f, -4.12307307e-02f, 1.70839170e-03f, 3.07835191e-02f, -4.56049368e-02f, 5.09435833e-02f, -2.94153951e-02f,
  -1.19127437e-01f, -1.11710556e-01f, 1.18229426e-02f, -8.11323058e-03f, 3.09336875e-02f, -2.89369579e-02f, -5.49403625e-03f, -5.13387695e-02f, -2.69792415e-02f, -1.29990873e-03f,
  -1.51072452e-02f, 7.81460553e-02f, -5.72130196e-02f, 2.06152424e-02f, 1.42047170e-03f, -6.04514927e-02f, -2.92861857e-03f, 1.12518491e-02f, 3.43822278e-02f, -1.80520900e-02f,
  -3.19913067e-02f, 1.48987537e-02f, -1.12406556e-02f, 8.65925774e-02f, -1.08375750e-03f, -1.57060251e-02f, 5.81392311e-02f, 2.73698382e-02f, -2.50439756e-02f, -4.15331908e-02f,
  -2.17608720e-01f, 1.53559789e-01f, 4.38642092e-02f, -3.03767413e-01f, -7.93847721e-03f, 2.22091049e-01f, 1.27800167e-01f, 7.10577369e-02f, 6.70690686e-02f, 1.46238416e-01f,
  2.52247602e-02f, -2.06655219e-01f, 3.03371727e-01f, -1.16000988e-01f, -1.70500074e-02f, 3.52724314e-01f, -7.78303966e-02f, -7.37499967e-02f, 1.04900926e-01f, -4.14581895e-02f,
  -1.22658655e-01f, -7.16003403e-02f, -8.25219229e-03f, -7.54577154e-03f, -1.61382914e-01f, -1.75950497e-01f, -2.46009752e-01f, 5.62721342e-02f, -2.04819024e-01f, -2.16720756e-02f,
  1.11330993e-01f, 4.26084027e-02f, -1.04882613e-01f, 4.12502922e-02f, -5.72622158e-02f, -4.17184383e-02f, -1.30035281e-01f, -6.53333089e-04f, -1.15115885e-02f, 2.74068862e-02f,
  -1.34296315e-02f, -3.36346105e-02f, -5.54280356e-03f, 5.18486910e-02f, 1.25095183e-02f, -2.96903420e-02f, 9.73390590e-04f, -3.76031287e-02f, 2.73065030e-04f, 6.98765665e-02f,
  -1.29306475e-02f, 2.89538763e-02f, -1.07082963e-01f, -1.77058913e-02f, -4.49545681e-02f, 1.78025812e-02f, -4.67998534e-02f, -2.04032511e-02f, -6.70894235e-02f, -3.80463935e-02f,
  -4.51145023e-02f, -1.32457213e-02f, 3.24670151e-02f, 6.40606089e-03f, -4.90552094e-03f, -2.59148590e-02f, -6.15372099e-02f, -1.64155643e-02f, -3.98970097e-02f, 2.24478659e-03f,
  2.53060851e-02f, -3.98711190e-02f, 2.55728271e-02f, -2.30267388e-03f, -1.00301839e-02f, -4.80627045e-02f, -2.52239574e-02f, -1.28486445e-02f, -1.35470154e-02f, -3.51298638e-02f,
  -1.52401756e-02f, -1.28904199e-02f, 1.92529242e-02f, -2.26114877e-02f, 3.88140529e-02f, -1.01519916e-02f, -6.96916655e-02f, -2.13708803e-02f, 1.89292673e-02f, -5.05275540e-02f,
  8.84945411e-03f, -5.27103320e-02f, 8.08034390e-02f, 1.74441785e-02f, 3.11378445e-02f, 1.02501167e-02f, 6.07260913e-02f, -1.40597764e-02f, 4.31106165e-02f, 1.72301028e-02f,
  -1.81164090e-02f, 5.50996233e-03f, -8.31762105e-02f, -1.72656551e-02f, 1.36017678e-02f, -3.15120118e-03f, -4.80764061e-02f, -2.21892465e-02f, -7.92695656e-02f, -7.34720454e-02f,
  -4.20995057e-02f, -4.15999927e-02f, 3.57363932e-02f, -3.92703116e-02f, -6.59049824e-02f, -5.64791113e-02f, -3.11822519e-02f, 3.12449224e-02f, 2.99914144e-02f, 5.20431111e-03f,
  4.42161620e-01f, 4.31891605e-02f, 1.10663541e-01f, 3.04450870e-01f, 1.55780092e-01f, -1.45755243e-02f, -1.50532305e-01f, 2.64528483e-01f, 9.10123438e-02f, -1.00290194e-01f,
  4.19041887e-02f, -1.07822642e-01f, -2.57655710e-01f, 1.66410580e-01f, 1.18116260e-01f, -1.28466845e-01f, 1.81348145e-01f, 5.22742905e-02f, 1.01604804e-01f, 2.56823927e-01f,
  2.20860556e-01f, 9.85220745e-02f, 6.37974143e-02f, 8.21662769e-02f, 2.33263731e-01f, 2.18298852e-01f, 2.90000122e-02f, -1.98846310e-01f, 7.82183185e-02f, -6.03822917e-02f,
  9.61204544e-02f, 1.97669387e-01f, 7.19859451e-02f, -3.06020770e-02f, 7.45332837e-02f, 4.48307060e-02f, -1.79701988e-02f, -1.02816492e-01f, -2.93383840e-03f, 2.70934422e-02f,
  -4.12686355e-02f, 3.68680246e-02f, 4.07521501e-02f, -3.81623134e-02f, -1.30695431e-02f, 3.24716456e-02f, 4.41408940e-02f, 1.02429129e-01f, 2.22335774e-02f, -3.90697606e-02f,
  3.46464776e-02f, 7.24383444e-02f, 1.60447024e-02f, -1.26533723e-02f, 2.57895365e-02f, -3.75688105e-05f, -1.67866349e-02f, -3.54535989e-02f, -6.32245373e-03f, 8.18212032e-02f,
  -5.03370352e-02f, -6.50199726e-02f, -3.31845903e-03f, 3.28915156e-02f, -1.74037833e-02f, 3.87196280e-02f, -2.53901388e-02f, 6.82948716e-03f, -1.26371365e-02f, 3.06183361e-02f,
  4.44352031e-02f, -1.82454307e-02f, 7.40318373e-02f, -7.20837107e-03f, 1.75675787e-02f, 7.51761161e-03f, -5.29429056e-02f, -2.65762266e-02f, 4.90673594e-02f, 3.81063521e-02f,
  -4.37302515e-02f, -1.80544574e-02f, -4.81637847e-03f, -2.34297626e-02f, 1.77010279e-02f, -5.71396388e-02f, 4.38669808e-02f, -3.05518880e-02f, 2.64401361e-02f, -5.59015162e-02f,
  1.72160268e-02f, -9.22373310e-03f, -9.47225560e-03f, -2.10178131e-03f, -2.06733476e-02f, -4.01348993e-02f, -4.80454648e-03f, 4.35945690e-02f, 5.58883548e-02f, 1.83477644e-02f,
  4.63021174e-02f, 3.63943391e-02f, -3.40172388e-02f, -1.17222695e-02f, 6.60501246e-05f, 4.95462529e-02f, -3.62078799e-03f, -6.01997860e-02f, -5.25747379e-03f, 7.37289414e-02f,
  -2.16165129e-02f, -4.54481617e-02f, -7.42494408e-03f, 2.01187320e-02f, 1.72917941e-03f, 1.61187525e-03f, 1.51230842e-02f, -3.98467435e-03f, 1.51947970e-02f, -3.55069898e-02f,
  -2.19242707e-01f, 1.61450356e-02f, 9.48573649e-02f, -1.64763480e-01f, -8.75402987e-03f, 1.14696950e-01f, 9.15269703e-02f, -1.46482065e-01f, -1.94986418e-01f, -3.13433409e-02f,
  -4.80809920e-02f, 1.22460842e-01f, 1.13126626e-02f, 1.43064305e-01f, -1.19936526e-01f, 7.13999271e-02f, -5.27422167e-02f, 7.55151361e-02f, -4.55825450e-03f, -2.13401392e-01f,
  -1.22956492e-01f, -1.14625178e-01f, 1.00620724e-01f, -2.66383775e-02f, 1.52509371e-02f, -1.46079749e-01f, -1.04223855e-01f, -6.00021482e-02f, 2.78710537e-02f, 1.09866686e-01f,
  5.53664006e-02f, -1.76034376e-01f, 6.41879216e-02f, 2.89241225e-02f, -1.49081657e-02f, 3.91852520e-02f, 1.14153503e-02f, 3.05385087e-02f, -4.06740829e-02f, 1.46720828e-02f,
  -4.87306481e-03f, 3.69965378e-03f, 9.18223150e-03f, -9.40712926e-04f, 1.12513024e-02f, 5.64192012e-02f, 1.13777280e-01f, 5.64889610e-02f, 7.68150985e-02f, 6.44667745e-02f,
  8.90368223e-02f, 6.77378774e-02f, 5.88492770e-03f, -1.01699252e-02f, 1.10905971e-02f, -4.94816620e-03f, 5.86724989e-02f, 2.06886493e-02f, -6.58904389e-03f, 3.03446930e-02f,
  -7.30043873e-02f, -2.14988571e-02f, 2.79048365e-02f, 1.37706483e-02f, -9.33791045e-03f, 6.03363477e-02f, 2.04472765e-02f, 1.34724742e-02f, 1.41437538e-02f, -7.53639117e-02f,
  -2.03454290e-02f, -3.25406790e-02f, -5.02852872e-02f, 3.82564850e-02f, -5.40193282e-02f, -9.54678748e-03f, 1.52422376e-02f, -1.86085030e-02f, -2.72919540e-03f, 5.63010052e-02f,
  -4.07718942e-02f, -1.20731164e-02f, -6.33253003e-05f, -3.65024656e-02f, -1.53883209e-03f, -1.53999245e-02f, 1.89068075e-03f, 2.28765942e-02f, -3.12859826e-02f, -1.29629262e-02f,
  -3.09023738e-01f, -5.03353059e-01f, -1.92494076e-02f, 3.11111589e-03f, 4.42049466e-02f, -3.50634828e-02f, -2.30643637e-02f, 3.48110534e-02f, -4.02885564e-02f, -1.62535999e-02f,
  -7.73015479e-03f, 1.13699995e-02f, -9.60769802e-02f, -2.10862420e-02f, -2.02077460e-02f, -5.88661470e-02f, -7.10027814e-02f, -3.65892947e-02f, -1.04904480e-01f, -2.54299771e-02f,
  -3.35031152e-02f, -7.90640805e-03f, -2.32458021e-02f, -1.27176307e-02f, -7.40479156e-02f, -3.40186544e-02f, -7.63441622e-02f, 1.22646708e-03f, -3.69876325e-02f, -1.39015084e-02f,
  -4.52170819e-01f, 3.26854914e-01f, 2.01856852e-01f, -2.91243374e-01f, -3.84939089e-02f, -4.54117693e-02f, -1.84882373e-01f, 9.15579647e-02f, -1.52328819e-01f, 2.38919497e-01f,
  -7.29217604e-02f, -3.02093197e-02f, 1.30590141e-01f, -4.81761321e-02f, -5.86588085e-01f, 3.65372039e-02f, -1.07081629e-01f, -1.06457911e-01f, 5.56031913e-02f, 1.29431952e-02f,
  -1.25269189e-01f, -1.65308446e-01f, 1.11732744e-01f, 1.80101857e-01f, 2.29246635e-02f, 1.31337747e-01f, -7.42673650e-02f, 2.32364401e-01f, 8.80115945e-03f, -1.08605765e-01f,
  -7.39011317e-02f, -3.59963663e-02f, 4.23873551e-02f, 1.04272880e-01f, -4.57890406e-02f, -4.74856347e-02f, 8.62817978e-04f, -6.78728595e-02f, -2.44006738e-02f, 2.25951802e-02f,
  1.95931476e-02f, -3.18560153e-02f, -5.69555387e-02f, -2.21806653e-02f, -2.31967792e-02f, 7.54841864e-02f, 3.64886783e-02f, 5.61705828e-02f, 3.15173417e-02f, 1.18517652e-02f,
  5.90286590e-02f, 1.05351757e-03f, 6.08486682e-02f, 3.77460867e-02f, -1.03753591e-02f, 1.00133424e-04f, 4.26813476e-02f, 2.83140801e-02f, -6.01331424e-03f, -3.81388366e-02f,
  -5.67561388e-02f, 6.65876046e-02f, 7.28048384e-02f, 2.53491215e-02f, -2.06783842e-02f, 1.78995226e-02f, 5.55455163e-02f, -3.84527296e-02f, 2.86387186e-02f, 9.62127373e-03f,
  -1.08566768e-02f, -8.11265130e-03f, -1.92671809e-02f, 3.60488258e-02f, 1.22130783e-02f, -3.30412425e-02f, 2.84869410e-02f, -2.34850519e-03f, 2.52943393e-02f, 4.16585337e-03f,
  5.42546287e-02f, -2.78404858e-02f, 3.52266035e-03f, 4.17737700e-02f, 4.05123644e-02f, 8.06383882e-03f, 7.56027550e-02f, 7.18605369e-02f, 2.20689978e-02f, -6.77962527e-02f,
  -8.04900900e-02f, 2.81344424e-03f, 2.61422843e-02f, -3.95804346e-02f, 4.75610979e-02f, 1.02674598e-02f, -4.69204504e-03f, 2.50802170e-02f, 6.14034827e-04f, -2.14796439e-02f,
  1.97113473e-02f, 4.98537645e-02f, -4.49649803e-02f, -8.06908030e-03f, 2.80007664e-02f, -5.25524765e-02f, -3.30469571e-02f, -3.96635160e-02f, -3.32641229e-02f, 4.41029668e-03f,
  1.16573656e-02f, 8.70138779e-03f, -3.91675830e-02f, -3.78353000e-02f, -3.22078429e-02f, -3.11341975e-02f, -1.32529736e-01f, 1.91338593e-03f, 4.16702684e-03f, 1.16599407e-02f,
  5.65699041e-02f, -6.36074468e-02f, -1.83803812e-01f, -1.54334366e-01f, 6.15739375e-02f, 7.39468411e-02f, -1.57661736e-01f, -7.70870447e-02f, -3.28452259e-01f, 1.16026893e-01f,
  4.80410866e-02f, 1.71101123e-01f, -2.58337706e-01f, 1.45790176e-02f, -4.28964617e-03f, -1.74724028e-01f, 1.81902368e-02f, 5.47674000e-02f, -1.66497171e-01f, 1.97566245e-02f,
  -3.60450074e-02f, 2.71316036e-03f, -5.99966794e-02f, 1.45529345e-01f, 9.95177925e-02f, 6.79918677e-02f, 2.12265432e-01f, -6.21957108e-02f, 3.60263020e-01f, 7.91785866e-02f,
  3.86689864e-02f, -5.67860678e-02f, -3.96415032e-02f, -2.00371370e-02f, -2.33628992e-02f, 8.14209729e-02f, 9.15398076e-02f, -9.21685155e-03f, -1.04117440e-03f, -6.85597509e-02f,
  3.85772763e-03f, 8.04703310e-02f, 5.83241954e-02f, -1.08205378e-01f, -2.45346092e-02f, -4.05134410e-02f, -8.69203359e-03f, -1.72098167e-02f, -1.08898599e-02f, 5.50367944e-02f,
  -3.12764607e-02f, 1.23494258e-02f, 2.55606826e-02f, 1.59262456e-02f, 7.32141593e-03f, -2.19184197e-02f, -1.16713420e-02f, 8.45437422e-02f, 5.30552939e-02f, -1.66169610e-02f,
  -1.53508531e-02f, -2.52345745e-02f, -5.40297143e-02f, -5.71195558e-02f, 1.77667160e-02f, 2.84842737e-02f, -5.51978871e-02f, 4.44235392e-02f, 2.19877064e-02f, -3.33111882e-02f,
  1.77126657e-02f, -1.40927322e-02f, -7.49987215e-02f, -3.27463821e-02f, -2.82417219e-02f, -1.13191167e-02f, 6.81609213e-02f, -5.55774570e-03f, -3.20538469e-02f, 2.27906015e-02f,
  -9.40294284e-03f, -8.70870601e-04f, -1.47859212e-02f, 1.34719852e-02f, -3.93706784e-02f, -3.93823087e-02f, 1.26504758e-02f, 1.53009696e-02f, -6.35035485e-02f, -4.64751106e-03f,
  8.61518458e-02f, -1.21052980e-01f, -2.86571253e-02f, 3.12018935e-02f, 3.27733643e-02f, 6.21594526e-02f, -5.21375388e-02f, 7.04266727e-02f, -9.94045660e-02f, 4.11431678e-03f,
  1.04506373e-01f, -2.65098773e-02f, 1.62600093e-02f, 5.65447211e-02f, -3.73244733e-02f, 4.97770049e-02f, 5.26903979e-02f, 1.58078317e-02f, 2.18810737e-02f, 4.29773629e-02f,
  5.49704544e-02f, -1.25766834e-02f, -6.07561246e-02f, 4.11151983e-02f, -8.10753461e-03f, 3.68349068e-02f, 1.02353618e-01f, -6.10135682e-02f, 6.98778182e-02f, -9.77322925e-03f,
  3.13965321e-01f, 8.74792188e-02f, -1.19426072e-01f, 1.55376852e-01f, 2.77441263e-01f, 5.44260629e-02f, -8.97935331e-02f, 1.36069193e-01f, 1.13107555e-01f, -8.89123455e-02f,
  2.97974441e-02f, 6.85153231e-02f, -3.42473716e-01f, 7.98707828e-02f, -1.73894644e-01f, -3.86687636e-01f, -8.18249118e-03f, -2.49359701e-02f, 1.58404931e-02f, 2.26196826e-01f,
  8.04088414e-02f, 1.51404709e-01f, -1.87443748e-01f, 1.54754534e-01f, 1.60460159e-01f, 1.43223733e-01f, 3.75184342e-02f, -1.71938054e-02f, 1.19738437e-01f, 3.08764987e-02f,
  5.08393720e-02f, 7.80505463e-02f, -1.04971183e-02f, 6.51120022e-02f, 1.13065034e-01f, -5.93551323e-02f, -1.85449496e-02f, -1.02112673e-01f, -3.18006176e-04f, 3.41408439e-02f,
  -1.99353565e-02f, -1.15452092e-02f, 5.39193973e-02f, -2.18031053e-02f, 5.90597242e-02f, 3.19505185e-02f, 2.34570354e-02f, -1.26823625e-02f, 5.04833721e-02f, 3.81526165e-02f,
  1.61915983e-03f, 2.11064480e-02f, -3.02273128e-02f, 3.00269644e-03f, -4.46435139e-02f, 4.80236299e-02f, 2.12266147e-02f, 2.45652404e-02f, 5.86567149e-02f, 8.31957534e-02f,
  6.45113317e-03f, 2.62077246e-02f, -1.18066436e-02f, -1.10919969e-02f, -6.85871462e-04f, 3.14907618e-02f, -4.43568043e-02f, 3.16623272e-03f, -1.59319583e-02f, 4.46957862e-03f,
  6.76511079e-02f, 1.64232682e-02f, 1.82428956e-02f, -1.99504979e-02f, -3.28192599e-02f, 4.96539753e-03f, -5.56177907e-02f, 4.86780331e-02f, -1.46871684e-02f, 3.97361722e-03f,
  2.22732965e-02f, -2.04028208e-02f, -1.15792193e-02f, -3.28478068e-02f, 3.02956551e-02f, -1.66103896e-02f, -8.08678661e-03f, -1.39214210e-02f, 2.11451016e-02f, 1.13746691e-02f,
  1.12407252e-01f, 1.33921131e-01f, 7.12369308e-02f, 1.01449929e-01f, -4.32210900e-02f, 3.87788042e-02f, -3.10197845e-02f, 5.30229136e-02f, -2.62681162e-03f, -2.29713209e-02f,
  -8.88281316e-03f, 8.25097635e-02f, 3.28422263e-02f, 5.04621491e-03f, -5.51373474e-02f, -3.40473689e-02f, -6.13173395e-02f, -1.30087894e-03f, 1.05312891e-01f, 2.43679639e-02f,
  -2.81308480e-02f, -8.88297241e-03f, 3.15044099e-03f, 7.36904889e-02f, 3.89847308e-02f, -3.53069417e-02f, -4.26023779e-03f, 2.50754673e-02f, -1.12678427e-02f, -4.44256999e-02f,
  7.59453848e-02f, -1.52659401e-01f, -2.66776830e-01f, 1.96956974e-02f, -1.33562446e-01f, -2.19742149e-01f, -5.12356311e-03f, -6.84070438e-02f, 1.56773463e-01f, 1.14344276e-01f,
  7.11273551e-02f, -9.32502672e-02f, 1.05384827e-01f, -4.43494320e-02f, 1.99974951e-04f, 1.51272252e-01f, -1.00179382e-01f, 1.51713388e-02f, 2.21908130e-02f, -9.82901379e-02f,
  7.68022090e-02f, 1.06662609e-01f, -9.28700492e-02f, -1.65405139e-01f, -6.29174709e-02f, -6.80823950e-03f, 1.83709315e-03f, -3.79479043e-02f, -2.17112258e-01f, -8.68179575e-02f,
  7.97863957e-03f, 6.45482540e-02f, 4.45817336e-02f, -6.89732060e-02f, -1.31709618e-03f, 5.67502948e-03f, -4.77623418e-02f, 1.80831784e-03f, -4.73946258e-02f, -8.69530514e-02f,
  1.93422753e-03f, -4.65086475e-02f, -7.93937594e-03f, 6.33583516e-02f, -3.15658897e-02f, -7.88564086e-02f, -1.13480911e-01f, -2.57059131e-02f, -6.66101575e-02f, -6.16548695e-02f,
  1.64833590e-02f, -1.26180813e-01f, -8.78187716e-02f, -3.40171196e-02f, -2.37630140e-02f, -2.09633298e-02f, 1.04078162e-03f, 8.37380998e-03f, -1.46712020e-01f, -9.59707797e-02f,
  6.44285679e-02f, -1.47697860e-02f, 3.46373543e-02f, 1.43531086e-02f, 1.44094033e-02f, 3.68198678e-02f, -7.51212239e-02f, 7.30657503e-02f, 5.33077419e-02f, -2.68323794e-02f,
  -2.60517206e-02f, -1.86891351e-02f, -3.10576204e-02f, -2.63062101e-02f, -1.76460389e-02f, 2.87960451e-02f, 2.71292217e-02f, -4.38583829e-02f, 2.93940026e-02f, 4.45584580e-02f,
  4.97148558e-02f, -1.02444515e-02f, 6.93418225e-03f, -2.22783685e-02f, -1.69744603e-02f, 4.65243831e-02f, 3.22034047e-03f, 9.57158860e-03f, 9.37637687e-02f, -3.74363400e-02f,
  2.47400943e-02f, -6.72882274e-02f, 2.37004664e-02f, 4.62894477e-02f, 5.25349863e-02f, -8.34418610e-02f, -6.43984303e-02f, -7.82587454e-02f, -6.55755401e-02f, 2.17333753e-02f,
  -5.20583242e-02f, 6.27600355e-03f, -9.67569947e-02f, 1.38484240e-02f, -2.16310937e-02f, 4.09435965e-02f, 1.24765560e-02f, -7.12902918e-02f, 2.17223237e-03f, 1.30992262e-02f,
  -6.43230528e-02f, -2.33862568e-02f, 4.47097570e-02f, 4.52102802e-04f, 5.18463589e-02f, 3.03173941e-02f, 8.11145175e-03f, -7.02577233e-02f, -8.88406634e-02f, 7.65232416e-03f,
  6.03142753e-02f, -1.82184670e-02f, -1.20381184e-01f, 1.22911923e-01f, -4.27612066e-02f, 1.24766909e-01f, 2.89834231e-01f, 1.11238785e-01f, -4.60545123e-02f, 2.33038425e-01f,
  2.13521257e-01f, -4.91959266e-02f, 5.87642118e-02f, 4.76979613e-01f, 8.93231928e-02f, 1.49445072e-01f, 3.13426673e-01f, 1.84232607e-01f, 3.83545691e-03f, 4.01736721e-02f,
  -1.27795842e-02f, 2.73725867e-01f, 1.17964037e-01f, -3.37702706e-02f, 1.20848641e-01f, -1.99836776e-01f, -2.21863315e-02f, -1.75595045e-01f, 7.31873140e-02f, -2.64883395e-02f,
  9.12973136e-02f, 4.57568839e-02f, 1.32259242e-02f, 1.97407305e-02f, -6.82530785e-03f, -1.73114974e-03f, -7.78766498e-02f, -3.88604738e-02f, 1.44606242e-02f, -2.02977564e-02f,
  -2.18881872e-02f, -9.71078575e-02f, 4.11278903e-02f, -7.68811926e-02f, 1.37245143e-03f, -1.62347779e-02f, -2.67328694e-02f, 1.14140734e-02f, -9.55505855e-03f, 5.67384176e-02f,
  5.18300850e-03f, 8.65221862e-03f, 5.36848903e-02f, -8.75452533e-03f, 9.84456949e-03f, -1.70886572e-02f, 2.55138017e-02f, -6.65432364e-02f, -3.52772698e-02f, -1.02985948e-02f,
  5.33720618e-03f, 9.66882054e-03f, -1.83170233e-02f, 2.98195202e-02f, -6.55459659e-03f, -4.84204665e-02f, 9.57876742e-02f, 1.17484666e-02f, -3.72168832e-02f, -1.30957663e-02f,
  2.82200426e-02f, -2.68421061e-02f, 3.89912887e-03f, 2.86450442e-02f, -1.67028587e-02f, 1.56402756e-02f, -4.33423072e-02f, 1.55470232e-02f, 8.08842015e-03f, 4.75032330e-02f,
  1.62987248e-03f, 5.26189338e-03f, 1.12693217e-02f, 2.77918279e-02f, 4.14985269e-02f, -2.46086698e-02f, 3.43026184e-02f, 3.95299718e-02f, 4.63152210e-05f, -2.42201891e-02f,
  7.28357881e-02f, -5.87561168e-02f, -7.16205454e-03f, -8.38934854e-02f, -3.98039185e-02f, 6.06693560e-04f, 1.43889859e-02f, 5.04152430e-03f, -4.03488018e-02f, 3.44952568e-02f,
  -3.22606303e-02f, 3.14074308e-02f, -7.80440122e-02f, 4.06756774e-02f, -1.94553379e-02f, 7.03115389e-02f, 3.25338207e-02f, -6.76513836e-02f, 3.01558226e-02f, 3.53434193e-03f,
  -1.97233036e-02f, -3.11963707e-02f, -8.34897310e-02f, -6.01919256e-02f, -3.73645313e-02f, 1.82875246e-02f, -3.61824594e-02f, -5.08310050e-02f, 5.23699680e-03f, 2.28660349e-02f,
  2.26825938e-01f, 3.70002270e-01f, -1.35138258e-01f, 8.99879858e-02f, -9.70926881e-02f, -4.04529497e-02f, -1.64378788e-02f, 3.60475518e-02f, 2.74135113e-01f, 2.49462247e-01f,
  4.93104197e-03f, 1.83911875e-01f, -2.05209441e-02f, 1.43960476e-01f, -2.62467414e-01f, 5.25367633e-03f, 1.35818511e-01f, 1.01310983e-01f, 5.16196936e-02f, 3.72835919e-02f,
  -5.51429503e-02f, 9.06346515e-02f, -2.16282383e-01f, -3.72737795e-02f, 1.13741225e-02f, 1.25134494e-02f, -3.57485488e-02f, -1.61226660e-01f, 1.05081024e-02f, -7.13353381e-02f,
  9.53683108e-02f, 4.24675941e-02f, 3.39959143e-03f, -1.92266016e-03f, -7.98141658e-02f, 2.89236289e-03f, -1.87027752e-02f, -8.02639648e-02f, -1.05253488e-01f, -2.22652499e-02f,
  2.99871732e-02f, -7.07765063e-03f, 2.84764934e-02f, -5.65564856e-02f, 1.51193386e-03f, -1.66039933e-02f, -7.92895351e-03f, 3.19039561e-02f, 2.37716176e-02f, -9.66349170e-02f,
  -9.63187404e-03f, -6.29404262e-02f, -3.35904793e-03f, 3.67745310e-02f, -6.42196685e-02f, -3.17739211e-02f, -8.06883872e-02f, -1.30928934e-01f, 3.27587016e-02f, 3.79432761e-03f,
  -5.08697703e-02f, -2.92475447e-02f, 7.42420554e-02f, -2.05849204e-02f, 3.34150828e-02f, 1.14453807e-02f, -1.54052693e-02f, -2.29242127e-02f, -1.44867683e-02f, 2.63564996e-02f,
  6.62553310e-03f, 1.68736298e-02f, -1.84954330e-02f, 4.34251539e-02f, -6.79996423e-03f, 5.60720190e-02f, -3.04241292e-02f, 3.41735668e-02f, -2.97549721e-02f, -3.29226665e-02f,
  3.39066796e-02f, 3.89717929e-02f, 4.94999252e-02f, 2.24355552e-02f, 1.07666031e-02f, -1.85378622e-02f, -1.62093323e-02f, -5.89885982e-03f, -5.80332726e-02f, -3.61709781e-02f,
  2.44274467e-01f, 2.40418896e-01f, 2.57530119e-02f, -3.83978034e-03f, 9.78478938e-02f, -2.17083003e-02f, 2.42681261e-02f, 5.30547909e-02f, 1.26216207e-02f, 4.89266254e-02f,
  -6.07752427e-02f, -2.03160588e-02f, 3.44351865e-02f, 5.75785190e-02f, 3.25214230e-02f, 8.82487372e-03f, 3.07964929e-03f, -1.22877292e-03f, -4.27743606e-03f, -1.50043815e-02f,
  2.22452432e-02f, 2.97442842e-02f, -7.99544156e-03f, -4.43369076e-02f, 4.71872883e-03f, 2.16593985e-02f, 6.90199211e-02f, 6.35399446e-02f, 3.85494456e-02f, 9.68694221e-03f,
  -3.22048604e-01f, -2.22805575e-01f, -3.63315314e-01f, -3.12371910e-01f, 1.34927884e-01f, -4.36015278e-02f, -3.52171153e-01f, 7.95692354e-02f, -2.17504263e-01f, 2.45336108e-02f,
  2.82196831e-02f, -2.64250159e-01f, -7.23636746e-02f, -2.11007491e-01f, -4.19826321e-02f, -1.39658034e-01f, -1.79102734e-01f, -1.17479935e-01f, -6.05932064e-02f, -8.71017352e-02f,
  -1.07312143e-01f, 2.81871036e-02f, -1.85692042e-01f, 2.37996787e-01f, -3.80352139e-02f, 1.97149441e-02f, 2.40834638e-01f, -1.92355178e-02f, 1.24810956e-01f, 1.00182906e-01f,
  -3.76205742e-02f, -1.12331174e-01f, -5.28749041e-02f, -3.36493626e-02f, -3.86404283e-02f, 8.41035023e-02f, -2.61003803e-02f, 2.06546560e-02f, -6.50738850e-02f, 1.70172825e-02f,
  2.53582522e-02f, 1.87306516e-02f, -1.64474789e-02f, 1.57799199e-02f, -1.38338925e-02f, 7.76616484e-03f, -5.10379337e-02f, 2.72452384e-02f, -8.72325301e-02f, -7.81555399e-02f,
  -6.79840818e-02f, 3.39046568e-02f, -4.43851165e-02f, 1.91546455e-02f, -3.51486690e-02f, -4.35735360e-02f, -1.45355258e-02f, -3.67388576e-02f, 6.22851178e-02f, -4.99893464e-02f,
  2.18613613e-02f, 3.98244224e-02f, -1.61793996e-02f, 6.01459108e-03f, -3.52576673e-02f, 4.18462139e-03f, -2.58638593e-03f, 3.49316224e-02f, -3.12147904e-02f, -2.46565733e-02f,
  4.44479883e-02f, -7.25454614e-02f, 3.50927077e-02f, 2.68409941e-02f, -2.89994571e-02f, -4.47187386e-02f, 3.46988104e-02f, 2.84751896e-02f, 2.02375185e-03f, -6.12795465e-02f,
  1.62873771e-02f, 2.02469490e-02f, -3.20883356e-02f, 8.09227750e-02f, -2.76858769e-02f, -3.47408801e-02f, 2.59871762e-02f, -1.40866200e-02f, -2.67438986e-03f, 3.93661857e-02f,
  6.48996681e-02f, -1.08070569e-02f, -7.02112913e-02f, 3.26482989e-02f, 2.93408595e-02f, 2.23107599e-02f, 1.71877947e-02f, -4.85189706e-02f, 3.05907186e-02f, -8.66394490e-02f,
  2.50085089e-02f, 5.10942414e-02f, 7.70135075e-02f, 5.55834919e-02f, 4.86250706e-02f, 6.44423114e-03f, -2.06695348e-02f, 1.56963188e-02f, 5.96831702e-02f, 1.60574690e-02f,
  6.66766241e-03f, 4.45190668e-02f, 2.79307421e-02f, 7.43538653e-03f, 4.81786616e-02f, 1.61197931e-02f, 4.37818319e-02f, 3.90111171e-02f, 7.18492791e-02f, 4.84820753e-02f,
  -3.53948355e-01f, 2.61293024e-01f, 1.45443782e-01f, -3.00860554e-01f, -4.33423929e-02f, -1.72761992e-01f, -1.41188771e-01f, -1.12035833e-02f, 7.93233141e-02f, 5.26149012e-02f,
  -1.17082685e-01f, 4.73846272e-02f, 1.40187413e-01f, -2.16771215e-01f, -1.63234845e-01f, 1.76380977e-01f, -2.39150614e-01f, -6.87225461e-02f, 1.89711481e-01f, -1.07764319e-01f,
  -8.00865069e-02f, -2.08829075e-01f, 5.73402457e-02f, 6.39092773e-02f, -1.66924208e-01f, 5.63887060e-02f, -1.50509521e-01f, 9.82160568e-02f, -2.66390204e-01f, -3.35575491e-02f,
  5.72718680e-02f, 8.96167830e-02f, 1.87017135e-02f, 1.14093982e-01f, -9.39834341e-02f, -2.40891259e-02f, -2.09232420e-02f, 5.90441823e-02f, -2.34582890e-02f, 2.68571563e-02f,
  2.82245763e-02f, -5.60058840e-02f, -2.29482278e-02f, 2.33336315e-02f, -4.56454530e-02f, 1.97058674e-02f, -2.01389492e-02f, -1.18573057e-02f, 7.30282515e-02f, 2.58090049e-02f,
  5.30318916e-02f, -5.04709296e-02f, -2.97472589e-02f, -1.42588234e-03f, 2.13606134e-02f, -3.72626148e-02f, -7.21158413e-03f, 5.58742993e-02f, 3.07325777e-02f, -6.09603769e-04f,
  -6.24808408e-02f, -1.28851039e-02f, 8.63430277e-03f, 5.49683869e-02f, -2.72994004e-02f, -3.55139039e-02f, 9.93097667e-04f, -2.25610118e-02f, -3.87808084e-02f, 3.64595279e-03f,
  -1.35562476e-02f, -3.66309620e-02f, 3.90258129e-03f, -4.74627241e-02f, -8.33293870e-02f, -1.27409194e-02f, -4.79844660e-02f, 3.01579703e-02f, -2.06988561e-03f, -3.55383218e-03f,
  5.51774837e-02f, -5.33243716e-02f, 3.42094712e-02f, -4.13503088e-02f, 2.27135122e-02f, 4.20663096e-02f, -3.23599525e-04f, 2.57953089e-02f, -2.92661856e-03f, -8.46187323e-02f,
  -1.23765044e-01f, -1.13121368e-01f, 6.59038350e-02f, -2.21910812e-02f, 3.67467590e-02f, -6.65864274e-02f, 1.43813044e-02f, -2.98400223e-02f, 6.50850404e-03f, -9.54791065e-03f,
  -7.85858557e-02f, 3.45604755e-02f, -1.03938635e-02f, -4.98651639e-02f, -3.06964144e-02f, 1.96089316e-02f, -4.79867943e-02f, -5.92408367e-02f, -1.12866059e-01f, 1.07565671e-02f,
  -3.49269211e-02f, 1.61209106e-02f, -3.62507664e-02f, 2.77272472e-03f, -5.70743978e-02f, -3.14241424e-02f, -5.06769009e-02f, 6.65404135e-03f, -7.14783743e-02f, 6.24582246e-02f,
  3.55747521e-01f, 1.19445667e-01f, 9.45450142e-02f, 3.38049650e-01f, -2.35877469e-01f, -6.89080581e-02f, 2.90562481e-01f, -5.74262105e-02f, 2.97960341e-01f, 1.08707681e-01f,
  -8.16956013e-02f, 2.28227258e-01f, -4.03915681e-02f, 6.55699968e-02f, 1.60150647e-01f, 1.06287643e-01f, 3.00725102e-01f, 2.12635532e-01f, 1.33745819e-02f, 4.18392494e-02f,
  9.74044204e-02f, -2.77291029e-03f, 2.18474530e-02f, -2.44497389e-01f, 2.90707182e-02f, 2.88550220e-02f, -1.05717644e-01f, -1.94988430e-01f, -8.19678903e-02f, -1.67004794e-01f,
  -1.21123545e-01f, 7.53332153e-02f, 3.58470827e-02f, 2.22928450e-02f, 3.72415967e-02f, 2.31301673e-02f, -1.76142659e-02f, -4.26138304e-02f, -2.71091294e-02f, 6.32135868e-02f,
  4.79303896e-02f, -1.75122432e-02f, -7.39544723e-03f, -5.61124533e-02f, 6.22978956e-02f, 1.12043191e-02f, -4.32935804e-02f, 6.73620263e-03f, 2.46649217e-02f, -1.28220851e-02f,
  -2.08869036e-02f, 6.10638596e-02f, 6.20765686e-02f, 3.23284827e-02f, 2.29316764e-02f, -7.60237873e-03f, 2.73014829e-02f, 2.16805786e-02f, 8.21178705e-02f, 3.11988797e-02f,
  5.39675690e-02f, 9.66391899e-03f, -9.96716227e-03f, -4.20475043e-02f, 4.80843970e-04f, -6.00176230e-02f, 1.73268802e-02f, -4.57157642e-02f, 3.14072445e-02f, -1.60693657e-02f,
  -2.22597141e-02f, 4.81848419e-02f, -2.02578288e-02f, 4.47790250e-02f, 3.65538485e-02f, 4.48407792e-02f, 1.40525745e-02f, -2.23157066e-03f, 8.28568116e-02f, -3.61556560e-02f,
  1.49896853e-02f, -7.98851810e-03f, -2.66155414e-02f, -2.06391644e-02f, -2.90240906e-02f, -3.06115877e-02f, 3.12188361e-02f, 1.35555435e-02f, -6.62439689e-02f, 1.19730895e-02f,
  7.17814267e-02f, 2.91958988e-01f, -3.98569033e-02f, -2.44844966e-02f, 1.75762398e-03f, -2.57271118e-02f, 9.70777348e-02f, -5.27698509e-02f, 2.71420386e-02f, -2.71040983e-02f,
  3.53837237e-02f, 3.38595472e-02f, 2.06766836e-02f, 4.61048633e-02f, -6.60749972e-02f, 3.33045274e-02f, 5.22807389e-02f, 5.04831783e-02f, 1.51364170e-02f, -3.45243812e-02f,
  6.30428120e-02f, 2.68264376e-02f, -1.93225015e-02f, 4.61309217e-02f, 1.22811245e-02f, 4.17136848e-02f, 7.20743015e-02f, -1.21778315e-02f, 1.16483420e-02f, 2.54551880e-02f,
  -9.05847400e-02f, 1.15701146e-01f, 2.26506189e-01f, 6.57744929e-02f, 3.84830624e-01f, 2.44388893e-01f, 9.63400155e-02f, 2.92532444e-01f, 4.79515344e-01f, -2.28268892e-01f,
  -9.15830955e-02f, -3.30431052e-02f, -9.32292789e-02f, 3.05978190e-02f, -9.79141966e-02f, 5.96945323e-02f, 4.75918092e-02f, 3.50781754e-02f, 2.60125101e-01f, 8.46030861e-02f,
  5.43744639e-02f, 2.60901321e-02f, -4.09015380e-02f, 6.58467859e-02f, 5.16875822e-04f, -6.52263348e-04f, -3.49265337e-01f, 1.28569797e-01f, -1.38748795e-01f, 5.12132347e-02f,
  2.73954216e-02f, 1.83397427e-01f, -4.25742865e-02f, -1.86303072e-02f, -6.89213946e-02f, -1.26496796e-02f, -4.75410819e-02f, -3.84407714e-02f, 5.31513616e-02f, -1.61425751e-02f,
  -8.55131149e-02f, -2.11989246e-02f, -4.07822095e-02f, 5.66253718e-03f, 9.81909856e-02f, -3.33391465e-02f, 6.46757632e-02f, 8.89884084e-02f, 5.19509651e-02f, 8.17055181e-02f,
  3.71306352e-02f, 4.89828028e-02f, 4.85543050e-02f, 2.93073449e-02f, -2.66410690e-02f, 2.75235716e-02f, 3.08085550e-02f, -4.62385938e-02f, 5.15283905e-02f, 6.43254295e-02f,
  1.03924252e-01f, 6.03761971e-02f, -6.36777431e-02f, 4.82460237e-05f, -1.85392536e-02f, 2.12305458e-03f, -4.71600518e-02f, -1.96526889e-02f, 2.09156778e-02f, -2.29459740e-02f,
  3.49128991e-02f, -1.09936122e-03f, 4.35629301e-02f, 5.27690127e-02f, -2.42115650e-02f, 1.62542965e-02f, -1.03231929e-02f, 5.82983391e-03f, 1.13923820e-02f, -3.96077670e-02f,
  6.00608662e-02f, 3.44216190e-02f, -1.05252415e-01f, -2.01754961e-02f, 3.81964222e-02f, 2.17002258e-02f, 3.03336103e-02f, 4.17497754e-02f, -1.24758147e-02f, -5.63579462e-02f,
  9.48936418e-02f, 7.13790506e-02f, -1.58160944e-02f, 1.90730300e-02f, -3.43459807e-02f, -3.29304151e-02f, 1.66833363e-02f, -2.84326784e-02f, 2.01952178e-02f, 4.59513515e-02f,
  -4.31456529e-02f, -1.08733010e-02f, 2.67207976e-02f, 1.86949503e-02f, -2.63542831e-02f, 3.06071118e-02f, -3.53834070e-02f, 1.32793831e-02f, 1.41626131e-02f, -1.12974625e-02f,
  -6.29428700e-02f, -1.09710572e-02f, -5.76158389e-02f, -3.51514295e-02f, -7.40692765e-02f, -6.53541908e-02f, -1.53165339e-02f, 1.42518794e-02f, -2.62151007e-02f, 9.02224891e-03f,
  1.09432526e-01f, 7.51235932e-02f, -2.62463033e-01f, -7.73740411e-02f, -3.46136242e-02f, 1.56985953e-01f, 2.14758903e-01f, 6.14961460e-02f, 6.98036328e-02f, 3.79183680e-01f,
  8.82130340e-02f, 2.80417455e-03f, 2.48268843e-02f, -4.62951735e-02f, -2.08194628e-01f, 7.60991080e-03f, 9.83613729e-02f, 1.22893594e-01f, -4.42408584e-02f, -6.61064088e-02f,
  -1.56238034e-01f, -9.01748538e-02f, -2.39990741e-01f, -1.93163991e-01f, -2.86555197e-02f, -4.05450426e-02f, -1.86755247e-02f, -1.41946599e-01f, 1.36345858e-02f, -7.02215210e-02f,
  1.58196673e-01f, -1.84752233e-02f, -9.14628878e-02f, -6.69677034e-02f, 2.58178376e-02f, 3.14548314e-02f, 1.58375148e-02f, -3.63326780e-02f, -5.51172160e-02f, 2.61302665e-03f,
  4.65760902e-02f, 1.32866930e-02f, -2.51943655e-02f, -1.90971512e-02f, 8.62487629e-02f, -1.23475287e-02f, -6.55864598e-03f, -1.19656371e-03f, -1.07857592e-01f, -2.16020029e-02f,
  -8.43395442e-02f, -1.21194525e-02f, -6.20922148e-02f, 6.87846690e-02f, 2.39549782e-02f, 7.85514116e-02f, -1.39614781e-02f, 3.90695408e-03f, 8.68820250e-02f, 6.51323497e-02f,
  -1.27238959e-01f, -2.10065357e-02f, 3.93741019e-02f, 2.46060248e-02f, -1.56773087e-02f, -1.87723674e-02f, 2.09303834e-02f, 1.67773012e-02f, -2.34023156e-03f, 5.61901219e-02f,
  7.40867183e-02f, -1.08702143e-03f, 2.85388343e-02f, 3.58703248e-02f, 6.03541248e-02f, 2.06304155e-02f, -4.14399542e-02f, 2.39392724e-02f, 2.75737494e-02f, 1.47711218e-03f,
  2.88736960e-03f, 1.38152596e-02f, 4.95153433e-03f, -1.52712995e-02f, -2.42854413e-02f, -2.58269738e-02f, 5.35889789e-02f, -1.85493845e-02f, -2.86128297e-02f, -1.48003306e-02f,
  3.75667661e-01f, 5.78733720e-02f, -2.25440823e-02f, 1.04771897e-01f, 6.28666729e-02f, 4.83351871e-02f, -3.21848691e-02f, 1.11990999e-02f, 7.49065951e-02f, -1.81093113e-04f,
  7.24396408e-02f, 4.08208072e-02f, 4.14482243e-02f, -5.21954261e-02f, -7.90589005e-02f, 5.96671067e-02f, 4.54461612e-02f, 1.95482112e-02f, 6.47559091e-02f, 8.38677138e-02f,
  4.13695425e-02f, 8.73204321e-02f, -4.96252533e-03f, -2.81760842e-02f, -2.96088755e-02f, 3.77650857e-02f, 7.04362988e-03f, 1.27128197e-03f, -7.84735475e-03f, 3.39669670e-04f
};

// L0_fan_Wp_bar (Shape: 14 x 120)
const int L0_fan_Wp_bar_rows = 14;
const int L0_fan_Wp_bar_cols = 120;
const float L0_fan_Wp_bar_data[] = {
  2.06594557e-01f, -2.01625451e-01f, 1.35961384e-01f, -4.17021029e-02f, 6.47729039e-02f, 6.94985613e-02f, 2.46492594e-01f, -1.53168038e-01f, -8.16301554e-02f, -2.38504529e-01f,
  1.01941964e-02f, 8.60212892e-02f, 1.22240558e-01f, -1.24022834e-01f, 2.70839334e-01f, 5.97247072e-02f, -6.80032894e-02f, 6.27655238e-02f, -2.07797103e-02f, -2.43299417e-02f,
  -2.70571392e-02f, -1.68650046e-01f, -5.02114370e-02f, -2.01413780e-01f, -1.10788323e-01f, -1.89133868e-01f, -4.64423187e-02f, 5.32426238e-02f, -8.89812335e-02f, 1.19045220e-01f,
  -3.77439037e-02f, -3.04753669e-02f, -1.09175574e-02f, 2.77023036e-02f, -3.33819576e-02f, -9.17658582e-03f, -1.04960718e-03f, 4.07822579e-02f, 8.82427245e-02f, 4.97240387e-02f,
  1.03979483e-01f, 9.29558352e-02f, -3.61292735e-02f, -1.56151112e-02f, -3.94896306e-02f, -1.52697042e-03f, 5.40523157e-02f, -5.93404211e-02f, 7.28645688e-03f, 2.05813739e-02f,
  8.71487111e-02f, -8.93769264e-02f, -6.01032488e-02f, -6.42266795e-02f, 7.81277865e-02f, -1.05802052e-01f, -1.94431171e-02f, 9.49458852e-02f, -5.26435114e-03f, -7.47778118e-02f,
  4.77554277e-02f, 3.37272242e-04f, 1.01948403e-01f, 3.94301340e-02f, -6.81731552e-02f, -2.27789544e-02f, 1.02149602e-02f, 7.55889341e-02f, 7.57523850e-02f, 7.02426583e-02f,
  -5.07760979e-02f, 2.86353417e-02f, 3.66330259e-02f, -7.34159872e-02f, -3.51709059e-05f, -3.87382205e-03f, 2.38695852e-02f, -8.26112404e-02f, -2.53339056e-02f, -6.06390880e-03f,
  -3.54514755e-02f, 3.59320976e-02f, -1.46190748e-02f, 3.88850719e-02f, 1.83365401e-02f, 1.59129268e-03f, -3.47370319e-02f, -5.29452711e-02f, -2.81345230e-02f, 4.25626598e-02f,
  5.41961519e-03f, -9.82127115e-02f, -4.13725339e-02f, 1.70466658e-02f, -9.11744237e-02f, -3.75763662e-02f, 5.74765503e-02f, -3.70389558e-02f, -7.63952360e-02f, -3.37441750e-02f,
  -8.27637389e-02f, -4.34167571e-02f, -2.48476919e-02f, 4.23401594e-03f, 4.36677299e-02f, -1.51922982e-02f, -3.15128341e-02f, 2.01794356e-02f, 2.74031982e-02f, 2.11306363e-02f,
  6.23683035e-02f, 7.82298893e-02f, -3.10198516e-02f, -9.83273163e-02f, -4.52802852e-02f, 2.01669857e-02f, 6.39623180e-02f, 4.96588573e-02f, 6.48852661e-02f, 3.29715721e-02f,
  -2.99808234e-01f, -2.04858854e-01f, -7.84012675e-02f, 9.16513726e-02f, 1.26046002e-01f, 1.75136864e-01f, -5.20208143e-02f, 2.36287564e-02f, -1.28018484e-01f, -1.14430241e-01f,
  -7.61194229e-02f, -1.27973899e-01f, -1.94565400e-01f, 2.73915470e-01f, 1.42568201e-01f, 1.02199882e-01f, 2.66721934e-01f, 3.99774946e-02f, 1.52718470e-01f, 3.33106518e-03f,
  1.71248809e-01f, 2.66489863e-01f, 1.47806555e-01f, 2.22389087e-01f, 1.06442887e-02f, 3.70943360e-02f, -5.73938675e-02f, -4.17245626e-02f, 1.96073592e-01f, 1.83313731e-02f,
  -2.87150126e-02f, -1.92759499e-01f, -8.03189948e-02f, -5.77990226e-02f, -7.07834885e-02f, -4.54864018e-02f, -4.98521365e-02f, 2.20731255e-02f, -1.59789100e-02f, -5.43160662e-02f,
  -1.36559710e-01f, 5.83040081e-02f, 1.24059908e-01f, -2.21622046e-02f, -4.67483886e-02f, 7.45158568e-02f, 4.03312780e-02f, 1.58077907e-02f, 3.09827551e-02f, -3.67818922e-02f,
  3.01971170e-03f, -4.27200319e-03f, -2.07179300e-02f, 8.38235244e-02f, 9.02054012e-02f, 2.85856780e-02f, 5.37462607e-02f, -1.94256417e-02f, 6.33019581e-02f, 1.15004089e-02f,
  9.19761509e-02f, -7.74465576e-02f, 2.50649475e-03f, 1.86369028e-02f, -7.16971532e-02f, -2.99098324e-02f, 8.01668093e-02f, -4.06315066e-02f, -5.17947972e-03f, 4.96209599e-02f,
  3.21530513e-02f, 6.06903061e-03f, 2.89973076e-02f, 3.07613239e-02f, -3.61638516e-02f, -7.70947849e-03f, -5.93258208e-03f, 1.35929659e-02f, -3.47640328e-02f, 9.03647020e-03f,
  5.22341440e-03f, -2.51565482e-02f, -2.70486046e-02f, 2.27560233e-02f, 2.51519494e-03f, 2.97054537e-02f, 1.36261154e-02f, 4.48621511e-02f, 5.04044630e-02f, -2.82657873e-02f,
  -3.55382562e-01f, -3.47542971e-01f, -9.34086293e-02f, -8.96274392e-03f, -1.06397606e-01f, -4.12141085e-02f, -6.05028085e-02f, -1.91867794e-03f, -1.41685873e-01f, -3.03090345e-02f,
  -1.10729620e-01f, 1.37120690e-02f, -3.28185484e-02f, 2.97944807e-02f, 3.71310785e-02f, -2.37042774e-02f, -6.72015473e-02f, -5.53495586e-02f, -7.85889570e-03f, 7.06032477e-03f,
  -8.32237601e-02f, -5.09742275e-02f, 4.16712016e-02f, 7.04432055e-02f, 1.04027778e-01f, 3.41498703e-02f, 4.98254783e-03f, 1.25213377e-02f, 4.07503508e-02f, -3.98556143e-02f,
  -3.03520504e-02f, 8.17770213e-02f, -3.57554778e-02f, 1.05148153e-02f, -2.78437557e-03f, 5.37085421e-02f, 8.26790929e-02f, -5.38065694e-02f, 1.77193046e-01f, 4.98090386e-02f,
  5.78254536e-02f, 7.02966675e-02f, -3.18989828e-02f, 1.08678535e-01f, 1.08194515e-01f, 3.11323050e-02f, 2.25120157e-01f, 1.69679075e-01f, 6.50648996e-02f, 6.90871105e-02f,
  5.19804936e-03f, -1.13911748e-01f, -1.02175854e-01f, -5.45020476e-02f, 1.62985120e-02f, -8.88641849e-02f, -1.43362552e-01f, -1.88227996e-01f, 4.61873300e-02f, -2.93574296e-02f,
  7.42397532e-02f, 5.05734608e-02f, -9.21448916e-02f, -5.09127639e-02f, 1.22112921e-02f, 2.37898789e-02f, 4.72526550e-02f, -7.92398378e-02f, -9.58172977e-02f, -5.54259084e-02f,
  -4.72149476e-02f, 4.36903462e-02f, -6.08135164e-02f, -1.00518867e-01f, 1.05297249e-02f, -1.08448719e-03f, -5.57633070e-03f, -3.45124751e-02f, -4.77987453e-02f, -1.29183516e-01f,
  -2.34512687e-02f, 4.93467301e-02f, 8.36297125e-02f, 1.42940413e-02f, 1.92799587e-02f, 1.73462257e-02f, 1.11087598e-01f, 3.66638005e-02f, -1.58834755e-02f, -4.29930054e-02f,
  5.77278882e-02f, 5.89260496e-02f, 2.27713957e-02f, -6.80769086e-02f, -5.86950034e-02f, -9.20082107e-02f, 5.23112379e-02f, -9.06735584e-02f, 9.75927413e-02f, -5.67737706e-02f,
  7.07364902e-02f, -6.50992766e-02f, -5.73820472e-02f, 8.10578987e-02f, -3.85157540e-02f, -5.65341190e-02f, -9.27886218e-02f, -1.34806605e-02f, -5.27636595e-02f, -4.95999046e-02f,
  6.40025884e-02f, 1.10581905e-01f, 4.50869463e-03f, 2.77802302e-03f, 5.96188083e-02f, -3.32001634e-02f, -7.88321532e-03f, -7.39322379e-02f, 1.02277853e-01f, -3.01878918e-02f,
  -1.75465103e-02f, 1.35025695e-01f, -7.77091384e-02f, -4.80627343e-02f, 2.80336048e-02f, -4.34961915e-02f, 3.16686407e-02f, -7.82630667e-02f, 1.09211281e-01f, -4.11006138e-02f,
  -7.72942081e-02f, 5.54994717e-02f, 3.06016859e-02f, -7.73925409e-02f, -1.34122476e-03f, -6.24824353e-02f, 3.26752290e-02f, 2.19189674e-02f, -3.39567661e-02f, 1.61118619e-02f,
  -7.80369863e-02f, 2.40783300e-02f, -5.43289706e-02f, -8.27850848e-02f, 2.71194540e-02f, -4.76752222e-03f, 9.47854593e-02f, -6.25562295e-02f, -2.14832611e-02f, 5.62861972e-02f,
  7.31086954e-02f, 7.53775835e-02f, 4.21386436e-02f, -1.40926883e-01f, -9.94257331e-02f, -1.10203333e-01f, -2.48156995e-01f, -1.96517073e-02f, 2.93378592e-01f, -8.02395791e-02f,
  -3.18444580e-01f, 2.00706109e-01f, -1.04249557e-02f, -1.51758254e-01f, 1.34587854e-01f, 1.68734685e-01f, -6.39430508e-02f, -1.24944195e-01f, 8.26944560e-02f, -1.67132467e-01f,
  9.29892901e-03f, -4.31942046e-01f, -1.67983606e-01f, -2.23926663e-01f, -3.43955845e-01f, -1.36356428e-01f, -2.01958254e-01f, -1.83892488e-01f, -1.47253737e-01f, -6.11027554e-02f,
  1.69595499e-02f, -5.01970295e-03f, -2.61971708e-02f, 5.82453460e-02f, 6.62273243e-02f, -5.38825206e-02f, -1.49301607e-02f, -1.07692175e-01f, 1.10611143e-02f, -4.22340371e-02f,
  2.29623402e-03f, -3.81454155e-02f, -6.34728000e-03f, 2.33219862e-02f, -8.87694582e-02f, 2.09863521e-02f, 5.59820496e-02f, -1.42511232e-02f, 5.05957901e-02f, 1.15484022e-01f,
  9.43829939e-02f, 1.93530992e-02f, 4.20573689e-02f, 3.98485065e-02f, 1.93673875e-02f, -9.16533396e-02f, 3.20661291e-02f, 3.56055982e-02f, 7.60147795e-02f, 2.79116239e-02f,
  -6.12003915e-02f, 2.81973369e-02f, -3.43447998e-02f, -2.73313895e-02f, 8.72116908e-03f, -7.05484524e-02f, 2.12418629e-04f, 5.12836240e-02f, 2.45280135e-02f, 2.74802488e-03f,
  -4.64460887e-02f, 2.12652385e-02f, 4.42424566e-02f, 4.26174253e-02f, -2.31064111e-02f, 5.79817817e-02f, -5.03778383e-02f, 3.00581697e-02f, -1.31091550e-02f, 6.98576868e-02f,
  2.60687489e-02f, -5.80690950e-02f, 2.34511890e-03f, 1.39014591e-02f, -8.17584619e-02f, -6.42577037e-02f, -5.73189706e-02f, -1.75711345e-02f, -1.24651671e-03f, -6.87839612e-02f,
  2.95685418e-02f, -2.73458622e-02f, -4.71966341e-02f, -1.45267164e-02f, -1.99071206e-02f, -1.75167006e-02f, 4.22738716e-02f, -6.00224640e-03f, 5.74037619e-03f, -5.13939373e-03f,
  -2.55682524e-02f, -6.59119114e-02f, -4.67482246e-02f, -5.14563210e-02f, -3.37433517e-02f, -8.75780061e-02f, -1.07956573e-01f, 5.14514111e-02f, 2.85137910e-02f, -4.27935906e-02f,
  -3.58983576e-02f, -4.10335064e-02f, -4.95602898e-02f, -5.61210290e-02f, -4.20907736e-02f, -3.25880758e-02f, -8.17890000e-03f, -2.63562445e-02f, 7.92036112e-03f, 2.86354255e-02f,
  7.88900778e-02f, 1.25330940e-01f, 2.55494475e-01f, 1.52014792e-01f, -1.03756927e-01f, -1.18472040e-01f, 1.10974259e-04f, 3.00459620e-02f, 1.58296868e-01f, -7.54058063e-02f,
  -6.77391663e-02f, 1.62167132e-01f, -1.54014349e-01f, 1.05532654e-01f, -2.16943279e-01f, -1.46470606e-01f, 5.07034315e-03f, 5.08948863e-02f, 5.90818077e-02f, 1.25368223e-01f,
  1.19566828e-01f, -2.29464114e-01f, 1.65663525e-01f, -5.90382181e-02f, 1.63715392e-01f, 1.06688052e-01f, -2.06093788e-01f, -4.07200158e-02f, 2.30885092e-02f, -2.02208549e-01f,
  5.81303872e-02f, 4.86173183e-02f, 3.70455161e-02f, 3.97112221e-02f, 2.03421041e-02f, 1.12514421e-01f, 5.21951076e-03f, -7.81022608e-02f, 2.86955275e-02f, 2.18468476e-02f,
  8.57211649e-03f, -4.66773994e-02f, 9.24758241e-02f, -1.06312381e-03f, 3.13217156e-02f, 1.34394383e-02f, 1.27992675e-01f, 7.47624189e-02f, 5.82006760e-02f, 5.25087081e-02f,
  1.89468354e-01f, 1.33775994e-01f, 1.23233227e-02f, 4.96802628e-02f, 4.97785434e-02f, 6.90131709e-02f, 1.47617199e-02f, -4.97709550e-02f, 4.67924140e-02f, -4.63342071e-02f,
  -9.62365866e-02f, -3.70892063e-02f, 3.43023054e-02f, 2.36147512e-02f, -1.93077084e-02f, 2.07572356e-02f, -2.55401824e-02f, 4.99385521e-02f, -3.00452076e-02f, 1.76939536e-02f,
  -2.51862244e-03f, -1.73241105e-02f, 3.89190875e-02f, -7.75460452e-02f, -5.87852970e-02f, -3.82651798e-02f, -6.48169890e-02f, -4.74234074e-02f, -8.98876879e-03f, 4.15666439e-02f,
  -1.02666192e-01f, 3.21174003e-02f, 3.35787646e-02f, 5.62802404e-02f, -5.26679009e-02f, 1.91716272e-02f, -6.89028390e-03f, 3.02836932e-02f, 5.11673018e-02f, -3.95996422e-02f,
  1.91254430e-02f, -9.71819013e-02f, 3.11788023e-02f, -6.25107884e-02f, -2.53684148e-02f, 7.80661032e-02f, 2.50181975e-03f, -3.42653133e-02f, -4.61132713e-02f, -6.42932802e-02f,
  7.26153105e-02f, 3.48362629e-03f, -1.48972310e-02f, 1.50225796e-02f, -8.34619403e-02f, 2.13008504e-02f, 5.24802459e-03f, 3.50469463e-02f, 1.00080287e-02f, 9.26090255e-02f,
  -1.16602685e-02f, -8.08398351e-02f, 6.38970360e-02f, -3.98761295e-02f, 7.80748501e-02f, -7.55844414e-02f, 1.20089324e-02f, 9.18511152e-02f, 1.45996800e-02f, -4.29134108e-02f,
  -9.20552295e-03f, -2.84646720e-01f, -1.93256512e-02f, -1.12330345e-02f, -1.86496109e-01f, 1.56061962e-01f, 3.75444382e-01f, -3.49301249e-01f, -2.24894330e-01f, 1.32190771e-02f,
  5.38896658e-02f, 5.18020093e-02f, 1.79522887e-01f, 1.67869210e-01f, 2.10590348e-01f, 1.84622437e-01f, 9.38316733e-02f, 1.98393568e-01f, -1.40894383e-01f, -8.77554119e-02f,
  -4.88321902e-03f, 9.46175307e-02f, 1.97287738e-01f, -2.38424554e-01f, 7.54982829e-02f, -2.05988675e-01f, 1.81862749e-02f, 5.58864325e-02f, -7.39004761e-02f, 9.05730724e-02f,
  2.53585242e-02f, -1.02003254e-01f, 3.91736254e-02f, -1.18380487e-02f, -1.94145534e-02f, -5.28231263e-03f, 5.83915822e-02f, 1.11674644e-01f, 5.13323909e-03f, -5.25474176e-02f,
  4.43598395e-03f, -1.00282282e-01f, -1.60366714e-01f, 5.68732619e-02f, -1.58925503e-01f, -1.37343109e-01f, -6.60768896e-02f, 3.35513726e-02f, -3.75194512e-02f, 2.16168677e-03f,
  -2.95392191e-03f, -1.59183815e-02f, -2.07582079e-02f, 6.25455938e-03f, 1.21375518e-02f, -7.80719072e-02f, 1.12202279e-02f, 1.26952201e-01f, -2.27475390e-02f, -1.17848136e-01f,
  -7.63757080e-02f, 3.30320299e-02f, -1.81212202e-02f, -1.61340181e-02f, -5.05006090e-02f, 1.36356326e-02f, -2.28071939e-02f, 4.55770604e-02f, 1.50354123e-02f, 6.54672161e-02f,
  3.25496346e-02f, 2.01918669e-02f, 1.89595204e-02f, 5.73898945e-03f, -1.75622460e-02f, 1.70498937e-02f, 8.56995285e-02f, -7.64905848e-03f, -1.40044345e-02f, 2.94668619e-02f,
  -2.94821151e-02f, 2.95764543e-02f, -5.51667139e-02f, 9.28845927e-02f, 4.68727313e-02f, -1.52122304e-02f, 1.06194885e-02f, -4.60499823e-02f, 1.95859447e-02f, -3.80546879e-03f,
  -9.09946486e-02f, -2.46729940e-01f, 9.33908299e-03f, -6.30138069e-03f, -9.16932151e-03f, -1.95265971e-02f, 5.36337346e-02f, -1.19366914e-01f, 2.70729512e-02f, -6.54742196e-02f,
  -8.83591697e-02f, 8.92748088e-02f, 2.17265058e-02f, -1.85354576e-02f, -4.59357463e-02f, -9.44335982e-02f, 5.48859127e-02f, 9.03049204e-03f, 8.53459314e-02f, -4.10173228e-03f,
  -6.11286908e-02f, 1.55707337e-02f, 9.65787917e-02f, 2.96327453e-02f, -4.09554597e-03f, 6.82539791e-02f, -1.08572878e-01f, -3.30756232e-02f, 1.62784848e-02f, -2.30952464e-02f,
  -1.15768328e-01f, 1.30225569e-01f, -2.93230582e-02f, 1.48626953e-01f, 9.53647308e-03f, -2.02180166e-02f, -8.11060704e-03f, 3.99482250e-02f, 1.21492162e-01f, 6.19625188e-02f,
  1.41742229e-01f, -1.19534574e-01f, -2.43512783e-02f, 8.26269761e-02f, -1.11127712e-01f, 4.40616980e-02f, 1.24860033e-01f, -6.66783229e-02f, -2.52271350e-02f, 1.48761421e-01f,
  9.08864811e-02f, 6.24124072e-02f, 1.06099937e-02f, -2.65190657e-02f, 3.22616249e-02f, -9.96154174e-02f, 7.77802691e-02f, -7.53478184e-02f, -4.29613329e-02f, -6.83761314e-02f,
  2.85969246e-02f, 1.40464306e-01f, 7.88360741e-03f, -1.53473653e-02f, 9.28293318e-02f, -5.26858270e-02f, 4.86586131e-02f, 2.36382447e-02f, 1.04841236e-02f, 5.47700562e-02f,
  -7.14910217e-03f, 5.33908270e-02f, 4.66314964e-02f, 3.01200412e-02f, -8.28408403e-04f, -7.94275198e-03f, -4.75989506e-02f, -1.07667081e-01f, -4.78629628e-03f, -7.38930553e-02f,
  -3.87914330e-02f, -4.54523042e-03f, -6.25697756e-03f, -9.23379231e-03f, -1.17567107e-02f, 4.45435978e-02f, -1.22868083e-02f, -4.41498309e-02f, -9.83955432e-03f, -4.55715433e-02f,
  -1.89371668e-02f, 9.11526829e-02f, 2.69319993e-02f, 3.56817152e-03f, -6.40611118e-03f, -4.95063793e-03f, 2.45956797e-02f, 4.96198796e-02f, -5.60797863e-02f, -2.20155157e-02f,
  -2.91704684e-02f, -4.71631102e-02f, 8.73153955e-02f, -4.97951359e-02f, 6.07273658e-04f, -5.00010066e-02f, -1.13210276e-01f, -2.94886203e-03f, 5.16242199e-02f, 2.25319453e-02f,
  -7.63274506e-02f, 5.03837205e-02f, 3.14274654e-02f, -9.18845758e-02f, -2.28361059e-02f, -3.22504006e-02f, 2.22200388e-03f, 7.52753168e-02f, 4.14342470e-02f, -6.35327175e-02f,
  1.19451769e-02f, 9.34586674e-02f, -2.29412783e-02f, 8.37864503e-02f, -8.04064199e-02f, -2.50364747e-02f, 6.33911192e-02f, 8.69831964e-02f, -1.71309784e-02f, 6.19839914e-02f,
  -1.04312329e-02f, 6.13166504e-02f, 9.69933160e-03f, 1.65988822e-02f, 2.86027230e-02f, -2.45169457e-02f, 8.59357864e-02f, 7.79604390e-02f, -5.94555400e-02f, 3.75104416e-03f,
  5.39150871e-02f, 4.65064086e-02f, -3.93720455e-02f, 2.97038700e-03f, -4.45271134e-02f, -5.77282384e-02f, 2.52303947e-02f, -9.63568687e-02f, -2.19817907e-02f, 7.61317089e-02f,
  2.33214930e-01f, -5.38520455e-01f, 2.55122315e-02f, 3.78869295e-01f, 2.19945282e-01f, 4.65128198e-02f, 2.52556533e-01f, -5.67356721e-02f, 4.26695943e-02f, -4.31845009e-01f,
  -1.82608832e-02f, -7.24133924e-02f, -2.36156300e-01f, 6.81968629e-02f, 1.62225783e-01f, -1.87078372e-01f, 6.36633262e-02f, 5.40261231e-02f, 9.37693790e-02f, 1.78673528e-02f,
  8.20317566e-02f, -4.99092266e-02f, 2.76648421e-02f, -1.68830067e-01f, 7.07877427e-02f, 5.06053530e-02f, -4.03520055e-02f, -8.89463127e-02f, -1.12649584e-02f, -2.31191814e-02f,
  1.31896168e-01f, 8.99667069e-02f, 6.68331683e-02f, 1.65034179e-02f, -6.79932535e-02f, 1.99402403e-02f, -1.09906225e-02f, 1.30034491e-01f, 7.54918829e-02f, -3.41547281e-02f,
  6.57628998e-02f, -5.55104874e-02f, -5.04313000e-02f, -3.54989357e-02f, 3.42397876e-02f, -2.49141324e-02f, -2.72058528e-02f, 5.63022681e-02f, -3.82962972e-02f, -8.16025585e-03f,
  -5.99811599e-03f, -9.12509859e-02f, 1.26182167e-02f, -1.22202910e-01f, -1.90885887e-02f, -1.25841731e-02f, 3.15041952e-02f, 8.35732464e-03f, 2.62513012e-02f, 4.88038408e-03f,
  -2.26627719e-02f, -4.89147045e-02f, 8.26127455e-03f, 1.15035728e-01f, 3.15287225e-02f, 8.79364386e-02f, 1.74133778e-02f, -5.82427271e-02f, -4.20548618e-02f, -2.78918073e-02f,
  4.58526723e-02f, 7.25991977e-03f, 6.66963607e-02f, 5.26702702e-02f, -3.56653146e-02f, 3.29744369e-02f, -3.77028175e-02f, 7.65069341e-03f, 4.90072556e-02f, -2.50140578e-02f,
  4.12698649e-02f, -1.44659113e-02f, 4.10914458e-02f, 7.41983205e-02f, 1.02754636e-02f, 1.61096193e-02f, -8.56666714e-02f, -4.47210707e-02f, -3.81215066e-02f, 5.95438108e-03f,
  -1.53039068e-01f, -3.99589390e-01f, -1.07641742e-01f, 4.97991554e-02f, -2.37003639e-02f, -9.04047210e-03f, 7.11725501e-04f, -5.69593571e-02f, -7.00431690e-02f, -2.17590462e-02f,
  -5.22848815e-02f, 6.52612001e-02f, -8.79651401e-03f, 1.20255947e-02f, -2.52935980e-02f, 4.12742682e-02f, -2.54655592e-02f, -3.39735001e-02f, -5.01237670e-03f, -1.32021368e-01f,
  -3.62141468e-02f, -1.07141631e-02f, 3.74050848e-02f, 9.29726884e-02f, -8.31748471e-02f, 3.40055749e-02f, -3.40596884e-02f, -6.31077066e-02f, -1.16394214e-01f, -7.57870376e-02f,
  -1.07528709e-01f, 4.71346945e-01f, 3.02817523e-01f, -4.33345186e-03f, 1.26339141e-02f, -2.49108553e-01f, -5.12154549e-02f, 1.48240775e-01f, 1.03968009e-01f, 1.54468089e-01f,
  -1.39644086e-01f, 2.55708635e-01f, -2.12954171e-02f, 2.01010201e-02f, -7.18177974e-01f, -3.15344334e-01f, -3.31123650e-01f, -7.98200071e-02f, -1.00745773e-02f, -1.37460127e-01f,
  -2.26418376e-01f, -1.08531043e-01f, -1.17043093e-01f, 9.04888287e-02f, 2.43214831e-01f, 2.21712977e-01f, -2.83646643e-01f, 1.02065228e-01f, -4.27789986e-03f, 1.58190783e-02f,
  -4.36067060e-02f, 1.12830631e-01f, 1.94749936e-01f, 1.20639736e-02f, -5.18087633e-02f, -6.85507581e-02f, -1.44085428e-02f, -8.21906850e-02f, -3.38805169e-02f, -2.93393061e-02f,
  5.97592108e-02f, 3.97078060e-02f, 4.51048613e-02f, 4.54428382e-02f, 6.62916899e-02f, 5.68747856e-02f, 3.40810306e-02f, 1.24567300e-01f, 1.12970024e-01f, 1.01195313e-01f,
  9.38150659e-02f, 6.17206357e-02f, 2.30927020e-02f, -9.66736004e-02f, -7.22534508e-02f, 2.10414510e-02f, -6.65869117e-02f, -4.80195209e-02f, 1.18042585e-02f, 3.69802560e-03f,
  -2.28207391e-02f, -8.99357647e-02f, -6.58830926e-02f, 8.04667249e-02f, 1.86111070e-02f, 2.32797749e-02f, -2.46110968e-02f, 1.61947496e-02f, 1.97755527e-02f, -1.44700101e-02f,
  -2.95774471e-02f, 1.06736392e-01f, -2.28014891e-03f, -1.59709603e-02f, -2.23852303e-02f, 7.19421953e-02f, 2.11805273e-02f, -3.83741371e-02f, -1.92553271e-02f, -4.62787114e-02f,
  -2.21301969e-02f, -5.28095923e-02f, 9.40761641e-02f, 1.60007284e-03f, 3.57096829e-03f, -1.64777841e-02f, 1.78059917e-02f, 5.87616116e-02f, -1.21137492e-01f, -3.60770188e-02f,
  -2.27218628e-01f, -3.03518742e-01f, -3.89815611e-03f, 1.33048713e-01f, 1.99792497e-02f, -1.18407160e-01f, -3.59335467e-02f, 4.08498198e-02f, -1.53282583e-01f, -8.91762525e-02f,
  -1.14670746e-01f, 2.38379958e-04f, -4.66761850e-02f, 4.29485999e-02f, -7.11724982e-02f, -1.14354184e-02f, -8.08101296e-02f, -7.28926435e-02f, -1.41778484e-01f, 1.12740314e-02f,
  8.41161758e-02f, 1.25435628e-02f, -5.14142439e-02f, 3.69840711e-02f, -2.88301762e-02f, 1.35895982e-02f, 3.84725165e-03f, 1.34588908e-02f, -4.38910089e-02f, -3.92606258e-02f,
  1.59087323e-03f, 1.29131779e-01f, -9.23111513e-02f, -2.21920926e-02f, 8.64319727e-02f, -2.88913578e-01f, -2.51275718e-01f, -1.01920329e-01f, -3.03370357e-02f, 1.80351645e-01f,
  2.57812254e-02f, 8.63467827e-02f, 7.52621423e-03f, -2.11937308e-01f, -4.50881213e-01f, -2.12893933e-01f, -2.06003308e-01f, -1.42853111e-01f, -1.16175152e-01f, -6.14633970e-03f,
  -8.20910111e-02f, -1.49537429e-01f, -1.23072542e-01f, 8.08045864e-02f, -7.93208703e-02f, 8.62987936e-02f, -4.89165587e-03f, 2.05477208e-01f, -1.22022495e-01f, -7.85137936e-02f,
  -1.46412984e-01f, 4.35123816e-02f, 1.29684815e-02f, 4.00769375e-02f, -1.05982326e-01f, 1.65626835e-02f, 2.97984723e-02f, 3.04347649e-02f, 4.90673371e-02f, -2.57135015e-02f,
  1.96541082e-02f, 1.95125379e-02f, -4.81355973e-02f, -6.34330586e-02f, 1.19997650e-01f, 6.40628040e-02f, 1.23185255e-02f, -4.84436692e-04f, 8.73688161e-02f, -7.18861073e-02f,
  -5.65876327e-02f, -3.44256544e-03f, 3.17071266e-02f, -4.26224060e-02f, 5.45950942e-02f, 5.01093864e-02f, 3.55914906e-02f, -2.01128405e-02f, -4.68242206e-02f, -7.54550323e-02f,
  4.98321280e-03f, -5.79507947e-02f, -5.80149181e-02f, 5.73088080e-02f, -6.81197122e-02f, 3.04385368e-02f, -2.90562902e-02f, -1.90883707e-02f, -3.75530496e-02f, -3.49951014e-02f,
  -1.29427453e-05f, 3.35558206e-02f, 5.70979379e-02f, 4.47345302e-02f, 5.38464915e-03f, 7.08849281e-02f, 5.38582504e-02f, 3.94442789e-02f, -1.63804386e-02f, 5.16853668e-02f,
  5.91472872e-02f, -8.35812166e-02f, 2.55903397e-02f, 6.36143377e-03f, -4.26748842e-02f, 1.80956107e-02f, -3.20840813e-02f, 1.43468019e-03f, 5.65497950e-02f, -5.77442497e-02f,
  -1.18103877e-01f, -5.52556291e-02f, 6.65886104e-02f, -1.43363383e-02f, 2.06911806e-02f, 8.27294663e-02f, -5.83759174e-02f, -8.81050364e-04f, 1.41007397e-02f, -1.17838047e-02f,
  2.71105990e-02f, 2.08864994e-02f, -1.11745559e-01f, -4.19853926e-02f, -4.80096862e-02f, -3.42737214e-04f, 1.52830705e-02f, -3.18508409e-02f, -5.88938594e-03f, -7.65381083e-02f,
  6.29657283e-02f, -1.79719869e-02f, -5.02370782e-02f, -5.52997962e-02f, 6.67690188e-02f, 1.99629087e-02f, 6.04475066e-02f, -2.31428575e-02f, 8.77689943e-02f, 1.94777921e-02f,
  -9.32672247e-02f, -8.27311631e-03f, 1.31428894e-02f, 5.98732829e-02f, -3.86344492e-02f, -1.74664244e-01f, -2.54144877e-01f, -9.80121568e-02f, -1.10707112e-01f, -1.17330976e-01f,
  -1.77973792e-01f, 1.89230010e-01f, -1.35191873e-01f, 2.57272348e-02f, 7.21971393e-02f, 1.11294843e-01f, -5.52638024e-02f, 1.53952446e-02f, -2.99971178e-03f, -1.09789781e-01f,
  1.41844183e-01f, 2.38257740e-02f, 1.59605578e-01f, -2.63756700e-02f, -8.57098401e-02f, 6.16264120e-02f, 9.22226384e-02f, -7.13016316e-02f, 3.46498266e-02f, 2.35486794e-02f,
  -1.29816040e-01f, -8.22615325e-02f, -4.34985347e-02f, 8.69703069e-02f, -8.29869583e-02f, 2.15649456e-02f, -2.90126298e-02f, 4.39101830e-02f, 5.82483634e-02f, 1.14130238e-02f,
  -1.12849632e-02f, -3.21911871e-02f, 7.09182993e-02f, 1.09451041e-01f, 5.87865002e-02f, 3.11336368e-02f, 1.71911363e-02f, 4.99780588e-02f, -3.30507308e-02f, -7.80340508e-02f,
  -7.30772838e-02f, 7.72252157e-02f, -5.98412938e-02f, 8.80245026e-03f, -1.55755961e-02f, -4.12774133e-03f, 9.32655260e-02f, 8.02903920e-02f, 9.43578631e-02f, 9.93890464e-02f,
  -5.39396629e-02f, 5.04567213e-02f, -8.42306316e-02f, 5.85575849e-02f, 2.68710591e-02f, -2.03395840e-02f, -4.59708199e-02f, -9.58131067e-03f, -1.35888923e-02f, -8.55849404e-03f,
  2.43996885e-02f, -3.76113355e-02f, -4.66790721e-02f, 6.55682608e-02f, 8.15053210e-02f, 4.22688723e-02f, -4.50931489e-02f, -7.03691244e-02f, -4.97679636e-02f, 6.22301735e-02f,
  -4.54487130e-02f, 5.21326251e-02f, 5.59418388e-02f, -7.07587600e-02f, 4.94775660e-02f, 4.31213900e-02f, 8.13604295e-02f, 9.31719725e-04f, -7.61096478e-02f, -8.54417384e-02f,
  2.34953258e-02f, 1.65338948e-01f, -6.96652457e-02f, 8.40748940e-03f, 3.57615650e-02f, -2.98811998e-02f, -2.69625597e-02f, -8.66341684e-03f, 1.24122500e-01f, -2.50787418e-02f,
  -5.00245504e-02f, -3.59420059e-03f, 6.02111183e-02f, 2.54082903e-02f, -9.57681518e-03f, 3.79530451e-04f, -1.90108959e-02f, 1.19798563e-01f, 5.00564501e-02f, 1.14193894e-01f,
  -5.03967106e-02f, 5.54508604e-02f, -2.75565460e-02f, -7.71702603e-02f, -5.57954982e-02f, -5.75983562e-02f, 9.96012017e-02f, 7.45276511e-02f, -9.16528981e-03f, 7.14390352e-02f,
  1.32492585e-02f, 1.37055680e-01f, 1.39594093e-01f, -1.76625457e-02f, -2.06808314e-01f, -4.67471957e-01f, -4.56718713e-01f, -5.04719355e-05f, -8.99127424e-02f, -1.55182406e-01f,
  -9.38490927e-02f, 7.67669454e-02f, 3.51860300e-02f, -3.81313227e-02f, 9.93315727e-02f, 1.78618789e-01f, -2.35426594e-02f, -7.50904381e-02f, 1.51968390e-01f, 1.48984849e-01f,
  2.27587372e-01f, 2.21075155e-02f, 3.46050739e-01f, 1.97515219e-01f, -2.29063793e-03f, 1.20274834e-01f, 2.52754241e-01f, 8.44397917e-02f, -1.85425989e-02f, 3.07283551e-02f,
  -7.33494535e-02f, 8.05294737e-02f, 1.54675357e-02f, -7.56519660e-02f, -1.31185921e-02f, -4.06452939e-02f, 5.31695725e-04f, -6.21839464e-02f, 5.49126118e-02f, 1.10888816e-02f,
  4.34098653e-02f, 1.22902647e-01f, -1.01245716e-01f, -3.77625450e-02f, -2.34165750e-02f, 1.93716139e-02f, 4.86131497e-02f, 6.30612746e-02f, -1.53600359e-02f, 5.69529012e-02f,
  -2.44807266e-02f, -1.78280543e-03f, -6.75705597e-02f, 1.31781893e-02f, 6.07045330e-02f, -8.21684897e-02f, -7.47855976e-02f, 7.72595108e-02f, 2.82309894e-02f, 1.63189303e-02f,
  1.06493374e-02f, -1.27436414e-01f, -5.00035621e-02f, -3.87856439e-02f, -4.55686357e-03f, -3.76746319e-02f, 2.10160762e-03f, 1.12250289e-02f, -4.41087522e-02f, 1.21066514e-02f,
  5.61660230e-02f, 8.52645412e-02f, 1.13963941e-02f, -1.67618450e-02f, -2.43984424e-02f, 4.15115530e-04f, -6.88689128e-02f, -1.95800047e-02f, -3.78586985e-02f, 6.94309175e-02f,
  5.16929291e-02f, -1.57589521e-02f, -4.95917760e-02f, -7.79221728e-02f, -1.18241087e-03f, 6.30113408e-02f, 2.70694587e-02f, 1.27579290e-02f, 5.22007756e-02f, 5.87275550e-02f,
  -1.58895203e-03f, 1.66757166e-01f, -2.18279492e-02f, 4.77808109e-03f, 5.07444851e-02f, 2.46460531e-02f, 1.12876603e-02f, -3.11153736e-02f, -1.39774801e-02f, -4.43916358e-02f,
  -1.41840214e-02f, -8.36427808e-02f, 1.05682649e-02f, 8.00199509e-02f, 2.29454152e-02f, -5.11219613e-02f, 8.61357599e-02f, 3.02619208e-02f, -3.02790627e-02f, 4.26873714e-02f,
  4.54141758e-03f, -8.75555724e-02f, 8.32827613e-02f, -4.69597206e-02f, -6.64983690e-03f, -2.97925752e-02f, -8.46488178e-02f, 5.80628999e-02f, 3.44160385e-02f, 5.81759587e-02f,
  1.91057235e-01f, -1.77899022e-02f, -1.25069708e-01f, 7.23709092e-02f, -2.74191666e-02f, -1.83638074e-02f, -1.27709106e-01f, 1.89671069e-02f, -2.74683774e-01f, 1.27840349e-02f,
  1.01396486e-01f, 1.80542663e-01f, -8.60162303e-02f, 1.55290097e-01f, 1.14753358e-01f, -1.07078634e-01f, 8.19705874e-02f, -6.11965135e-02f, -5.69993034e-02f, 1.79807439e-01f,
  -2.06302339e-03f, 1.33310065e-01f, 2.87761614e-02f, 1.97623745e-01f, 2.08579555e-01f, 6.18588887e-02f, 1.76242188e-01f, -2.96801608e-02f, 1.31957665e-01f, 5.48518002e-02f,
  -7.30527788e-02f, 1.33035183e-01f, -2.14934535e-02f, 7.08856136e-02f, -5.49604781e-02f, 7.92936012e-02f, 5.12662670e-03f, -3.22072371e-03f, 2.13289615e-02f, 2.06198394e-02f,
  3.44342999e-02f, 2.03902163e-02f, -3.19795869e-02f, -5.77667430e-02f, -1.34865623e-02f, 4.96009551e-02f, -8.54343921e-02f, -1.49935335e-02f, 4.13651466e-02f, 2.66821533e-02f,
  1.73956268e-02f, -3.94107476e-02f, 1.35194901e-02f, 7.30149746e-02f, -4.52759191e-02f, 1.42380390e-02f, 1.23905189e-01f, 1.13238677e-01f, 3.72873433e-02f, 2.40612626e-02f,
  8.44700858e-02f, 2.94920821e-02f, 6.13785489e-03f, 4.31539044e-02f, -9.99589451e-03f, -6.54455796e-02f, 5.54070845e-02f, -7.77172521e-02f, 7.62415081e-02f, -7.65940323e-02f,
  1.06204078e-02f, 3.61177213e-02f, 2.94672176e-02f, 5.03728352e-02f, 4.12240811e-02f, 7.41232012e-04f, 3.92071716e-02f, 4.14478667e-02f, 6.64644456e-03f, -9.41494331e-02f,
  2.00134539e-03f, 1.19400229e-02f, -6.62458614e-02f, -4.05107029e-02f, 1.19097065e-02f, 6.52823001e-02f, 7.57109970e-02f, 8.68932009e-02f, -4.02313173e-02f, -1.83097590e-02f,
  4.26214635e-02f, 2.36290395e-01f, 3.31898220e-02f, -6.67041540e-02f, 4.08233638e-04f, 8.02628770e-02f, -3.32629159e-02f, -9.41773504e-03f, 2.83462610e-02f, -3.78560983e-02f,
  9.31276828e-02f, -4.53553125e-02f, 6.07462674e-02f, 1.13273896e-01f, -7.68331066e-03f, -2.42128856e-02f, 1.01298233e-02f, -2.53675058e-02f, -8.23535845e-02f, 1.26200527e-01f,
  4.65270951e-02f, 4.51179482e-02f, 9.90044605e-03f, -1.27636129e-02f, 7.18471780e-02f, -2.83417907e-02f, 5.06557301e-02f, 8.50397572e-02f, 8.77197459e-02f, 8.06874596e-03f,
  1.30644351e-01f, -1.89588338e-01f, -4.48651128e-02f, -1.87735364e-01f, -1.06094614e-01f, -2.27876585e-02f, -1.19128570e-01f, -2.12409720e-02f, -1.91851467e-01f, -8.54340941e-02f,
  3.77035956e-03f, -7.49812648e-02f, 7.10141137e-02f, -1.54752135e-01f, -4.54308540e-02f, 2.94339936e-02f, -2.08141319e-02f, -1.94022488e-02f, -1.01437718e-01f, 5.60277812e-02f,
  -6.44919723e-02f, 4.17151488e-02f, -1.31003320e-01f, 8.07850957e-02f, 2.00090688e-02f, -4.24823202e-02f, -4.84959632e-02f, 6.09409809e-03f, -8.37600082e-02f, -4.28664722e-02f,
  4.32850458e-02f, -1.23990653e-02f, 7.29289353e-02f, 4.41465620e-03f, -1.97049556e-03f, 1.10680580e-01f, 3.38137671e-02f, 1.55115658e-02f, -1.08867049e-01f, -3.59619744e-02f,
  5.70885185e-03f, -4.87501323e-02f, 4.81223762e-02f, 4.40971479e-02f, -7.98585340e-02f, -1.24563329e-01f, -1.24188706e-01f, -1.87867973e-02f, -8.41969699e-02f, -3.83564495e-02f,
  -8.65192786e-02f, -9.17405821e-03f, -3.26935686e-02f, -6.53010188e-03f, -1.27795786e-01f, 6.58694431e-02f, -5.26669919e-02f, 8.49445164e-02f, -1.16651103e-01f, 3.24739814e-02f,
  3.72520834e-02f, 4.53791581e-02f, -1.96545087e-02f, -4.06956226e-02f, -4.73999456e-02f, 2.96516381e-02f, 3.04376185e-02f, -4.86688018e-02f, -3.69234793e-02f, -7.46944919e-02f,
  5.26044555e-02f, 2.66892333e-02f, -3.70780118e-02f, 8.97135437e-02f, -5.88851459e-02f, 5.49490713e-02f, -2.88839545e-02f, -7.49839842e-02f, 2.04596985e-02f, 5.62557094e-02f,
  -5.85878966e-03f, -1.66522842e-02f, 7.34754503e-02f, 6.20484948e-02f, 3.69854569e-02f, 6.13137055e-03f, 1.90824568e-02f, -2.14974899e-02f, -8.03915709e-02f, 5.40521462e-03f,
  2.40892312e-03f, 6.40954589e-03f, -1.08648434e-01f, 7.59837031e-02f, 9.63662490e-02f, 1.10775620e-01f, 3.71249653e-02f, -7.39311948e-02f, -9.51566845e-02f, -1.51433060e-02f,
  8.71652886e-02f, 3.24686840e-02f, 5.11731133e-02f, -3.66069637e-02f, 2.51730587e-02f, -2.59042401e-02f, -6.86298087e-02f, 3.09232213e-02f, -9.60024893e-02f, -9.43357497e-02f,
  6.65384680e-02f, -1.30094066e-02f, 4.96882126e-02f, -1.94883980e-02f, -4.30194475e-02f, -4.65184674e-02f, 1.86054558e-02f, 2.90867090e-02f, -4.28962242e-03f, -9.67061222e-02f
};

// L0_fan_Bp_bar (Shape: 1 x 14)
const int L0_fan_Bp_bar_rows = 1;
const int L0_fan_Bp_bar_cols = 14;
const float L0_fan_Bp_bar_data[] = {
  1.00487486e-01f, 1.78502157e-01f, 1.30037770e-01f, 2.16863543e-01f, 2.13969335e-01f, 2.52057344e-01f, 1.18979439e-01f, 1.99287444e-01f, 3.39505017e-01f, 1.18526526e-01f,
  1.03044443e-01f, 2.38269001e-01f, 1.85421795e-01f, -2.68860999e-02f
};

// L1_linear_W (Shape: 12 x 64)
const int L1_linear_W_rows = 12;
const int L1_linear_W_cols = 64;
const float L1_linear_W_data[] = {
  -9.87336561e-02f, -1.21894591e-01f, 7.19040260e-02f, 1.83121134e-02f, -5.19573212e-01f, 1.49205223e-01f, 9.96760800e-02f, 1.39993519e-01f, 2.30373725e-01f, 1.04845248e-01f,
  -4.57348526e-01f, -4.42218147e-02f, 1.36267813e-02f, -7.68695921e-02f, 1.86793566e-01f, 6.63747117e-02f, -3.89877886e-01f, 1.29749216e-02f, -4.62282807e-01f, 3.12010925e-02f,
  1.51552502e-02f, 2.04131112e-01f, 1.63272306e-01f, 1.06210455e-01f, 8.44129845e-02f, -4.02148873e-01f, 4.83088046e-01f, 2.30203152e-01f, -2.64397204e-01f, -4.44436431e-01f,
  -9.90002081e-02f, -1.05728194e-01f, -1.93419352e-01f, 1.83201864e-01f, 3.85583818e-01f, -5.23436427e-01f, 3.46751004e-01f, -3.77134025e-01f, 4.47573692e-01f, 3.64707559e-01f,
  -1.72516689e-01f, -4.37144399e-01f, 3.56943250e-01f, 4.94369537e-01f, 1.74419478e-01f, -1.38505831e-01f, -3.50518078e-02f, 1.83225706e-01f, -3.32584053e-01f, 3.71671468e-01f,
  -2.46471405e-01f, 2.63223082e-01f, 1.77444682e-01f, -2.43083552e-01f, 3.22604775e-02f, 4.56996441e-01f, 1.35850042e-01f, -1.47348434e-01f, -6.06334172e-02f, -1.15214959e-01f,
  -1.17572844e-01f, -1.92746654e-01f, -2.27319151e-01f, -7.88580906e-03f, -4.97594535e-01f, -2.37984940e-01f, -2.02281296e-01f, 6.14119992e-02f, 1.81817621e-01f, 3.92007045e-02f,
  2.43838131e-01f, 1.22644879e-01f, 1.61429316e-01f, 2.95120180e-01f, -2.95631558e-01f, 4.19887841e-01f, 9.57772285e-02f, -1.23051573e-02f, -2.70226121e-01f, 9.12229046e-02f,
  2.30313852e-01f, -1.58739120e-01f, -4.95248199e-01f, 1.14690058e-01f, 2.57608712e-01f, -2.25747690e-01f, 2.19389305e-01f, 2.88993940e-02f, -1.82939962e-01f, -5.91004550e-01f,
  -4.91261482e-01f, 4.89102304e-02f, -2.09796786e-01f, -3.01109076e-01f, -4.42591049e-02f, 1.09286159e-01f, -5.46879113e-01f, -3.78995299e-01f, 7.29166204e-03f, -5.97080886e-01f,
  -8.05713311e-02f, 3.70923221e-01f, -1.70412078e-01f, -5.26216745e-01f, 4.97981310e-01f, 5.64371109e-01f, -5.47719263e-02f, 4.39916730e-01f, 4.88353521e-01f, 6.07412718e-02f,
  -6.09631419e-01f, 2.18892992e-01f, 1.05831102e-01f, 4.97437567e-01f, 2.77603511e-03f, -1.60470847e-02f, 9.48344618e-02f, -2.01086313e-01f, -2.15728879e-01f, 1.01119503e-01f,
  8.98483172e-02f, -8.19557235e-02f, -2.49205932e-01f, -1.60661861e-01f, -1.04424760e-01f, -8.10071304e-02f, 3.72298628e-01f, 3.30506772e-01f, -1.58091977e-01f, 1.57808304e-01f,
  -1.18371315e-01f, 1.96220465e-02f, 2.21024707e-01f, 6.24347571e-03f, -2.75693312e-02f, 7.83016440e-03f, 1.81852907e-01f, -4.59128678e-01f, 7.46480525e-02f, -3.66439611e-01f,
  -5.64283058e-02f, 2.04996794e-01f, -3.11696559e-01f, -1.84341684e-01f, -2.62907028e-01f, 4.64309156e-02f, 4.55676205e-02f, -1.15547650e-01f, -1.02484196e-01f, -4.29070413e-01f,
  -1.29830435e-01f, 2.26360932e-01f, -2.19654799e-01f, -4.44439203e-01f, 1.25395715e-01f, 3.42840642e-01f, -1.18451230e-01f, 1.10277370e-01f, 1.33135363e-01f, 1.79730058e-01f,
  2.96306878e-01f, 1.27712479e-02f, -3.91689628e-01f, 5.85239418e-02f, -4.08903599e-01f, 2.74812400e-01f, 1.16421111e-01f, -2.66516596e-01f, 4.75853145e-01f, 2.33527392e-01f,
  -2.22745895e-01f, 6.89104199e-02f, -2.49225423e-01f, 3.24491709e-01f, -4.36050981e-01f, -2.86448389e-01f, -2.61663765e-01f, -4.55022424e-01f, -1.03505485e-01f, 6.75615132e-01f,
  1.55745037e-02f, -2.14949429e-01f, -2.23122314e-01f, 8.36913958e-02f, -5.52426092e-02f, 4.16100889e-01f, -1.18644685e-01f, -1.99825123e-01f, 1.87919974e-01f, -1.19245186e-01f,
  1.65079042e-01f, -7.70741478e-02f, 5.26103750e-02f, -1.67317003e-01f, -1.54225072e-02f, 6.99864104e-02f, 2.58758180e-02f, 1.71818197e-01f, -2.03422070e-01f, -2.31885053e-02f,
  1.24462500e-01f, -6.26618266e-01f, 2.77374429e-03f, -4.67493795e-02f, -2.05106393e-01f, -9.73106362e-03f, -3.24624717e-01f, 1.66668057e-01f, 2.79610176e-02f, 3.35872397e-02f,
  -3.93889509e-02f, -1.15916334e-01f, 8.40421692e-02f, -3.16512048e-01f, -3.59910280e-01f, 1.98349282e-01f, 2.93632168e-02f, -9.98317376e-02f, 3.04238200e-01f, -1.73307374e-01f,
  -1.79140288e-02f, -2.52602637e-01f, -8.32660645e-02f, 3.74774605e-01f, 2.02294253e-02f, -3.51203650e-01f, 4.71577346e-01f, 3.59647304e-01f, 4.93794590e-01f, -3.40560704e-01f,
  1.30779192e-01f, 1.34714097e-01f, -2.43931159e-01f, 5.04989736e-02f, 2.52378374e-01f, -2.58250922e-01f, 9.37775373e-02f, 2.18297556e-01f, 2.63361812e-01f, -4.14029986e-01f,
  1.68276310e-01f, -9.49747413e-02f, -2.03309447e-01f, -9.50707272e-02f, -2.35839784e-01f, -2.45011449e-01f, -1.76528081e-01f, -2.97370553e-01f, 1.15393311e-01f, -1.58675045e-01f,
  8.28450382e-01f, 4.98781949e-01f, -2.73444578e-02f, 4.93862107e-02f, -5.05375452e-02f, -2.51525920e-03f, 1.93385616e-01f, 1.18986286e-01f, 1.77674562e-01f, 1.96303859e-01f,
  3.79815191e-01f, -7.11694267e-03f, 2.43260741e-01f, 1.31480172e-01f, -1.43183127e-01f, 2.76232958e-01f, 1.20498128e-01f, -2.67633498e-01f, 8.00604075e-02f, -1.06858850e-01f,
  -1.00558281e-01f, 7.82877058e-02f, 6.58073723e-02f, 8.35388675e-02f, 4.41678375e-01f, -8.02612826e-02f, 4.32047397e-01f, -7.92626664e-02f, 8.41602311e-02f, -1.54692447e-02f,
  -1.23849317e-01f, 4.67056111e-02f, -1.51650861e-01f, -5.21234460e-02f, -2.62363613e-01f, -1.59566760e-01f, 1.69588462e-01f, -2.40677372e-01f, -2.31382713e-01f, 5.57026982e-01f,
  -2.49248758e-01f, -1.69376656e-01f, 6.26169026e-01f, -1.16821826e-01f, 5.10427296e-01f, 8.23450565e-01f, -1.90034375e-01f, -4.07930672e-01f, -3.22410196e-01f, -2.02356309e-01f,
  -3.83585095e-01f, -2.76571773e-02f, 6.22924745e-01f, -6.03330910e-01f, 5.60280263e-01f, -3.17056865e-01f, -4.26315628e-02f, 3.82611871e-01f, -1.49397090e-01f, 2.49553710e-01f,
  8.36226866e-02f, -1.86174437e-01f, -1.53408974e-01f, -2.79881805e-01f, 1.72752351e-01f, -2.21516088e-01f, 3.08691580e-02f, 1.42261699e-01f, -2.04928592e-01f, 4.53897305e-02f,
  2.51324385e-01f, 1.09822318e-01f, 2.21811742e-01f, 2.49720514e-01f, 3.95837009e-01f, 1.18259594e-01f, -2.30664238e-01f, -1.33404329e-01f, 3.19864124e-01f, 2.31403530e-01f,
  4.66955423e-01f, -5.64371608e-02f, 2.44882017e-01f, 1.70666173e-01f, 2.35611498e-01f, -1.50640681e-01f, 5.75904250e-02f, 3.64814401e-02f, 3.34778309e-01f, 7.72841126e-02f,
  3.03668305e-02f, 2.95529485e-01f, -3.47337961e-01f, -4.78322297e-01f, -8.02576263e-03f, 1.55030310e-01f, 5.67974849e-03f, 3.03354859e-01f, 3.11238736e-01f, -1.66366845e-01f,
  -3.47717375e-01f, -5.13712466e-01f, -4.74522322e-01f, 1.27717108e-01f, -1.83367506e-01f, -1.25728354e-01f, 2.72098035e-01f, -9.54785645e-02f, -3.50892901e-01f, -3.21167946e-01f,
  -3.47121358e-01f, 6.75757453e-02f, -1.30102120e-03f, 2.58590847e-01f, 5.68156064e-01f, -4.99740809e-01f, 1.16261945e-03f, 6.40713334e-01f, 5.46382666e-01f, 3.74040276e-01f,
  2.36800145e-02f, -3.32378507e-01f, 3.36136758e-01f, 2.53813505e-01f, -6.81496784e-02f, -1.33130178e-01f, 1.61477983e-01f, -2.56688744e-01f, -4.60886806e-01f, -2.59524345e-01f,
  1.02879390e-01f, -3.36951941e-01f, -8.29386152e-03f, -5.01917973e-02f, 2.60243177e-01f, -3.43433380e-01f, 4.85506244e-02f, -1.86742932e-01f, -3.45175922e-01f, 2.73218416e-02f,
  9.80189070e-02f, -1.69776767e-01f, -6.38637692e-02f, -9.72496718e-02f, -2.49843225e-02f, 3.17329139e-01f, -2.02493057e-01f, 1.33578721e-02f, -1.02596126e-01f, -4.31836694e-02f,
  7.18642771e-02f, 4.85986769e-02f, 1.60568953e-01f, 1.50501832e-01f, -1.67730734e-01f, 9.34305936e-02f, 1.33978128e-01f, -3.65718722e-01f, 2.59977281e-01f, -1.62618399e-01f,
  -4.84415770e-01f, 1.28225774e-01f, 5.05337417e-01f, 5.03857434e-01f, 3.45768034e-01f, 6.26492053e-02f, 3.22830290e-01f, 2.19540611e-01f, -1.88536420e-01f, 5.40346205e-01f,
  -2.02950642e-01f, 6.27098739e-01f, -1.35070577e-01f, -3.45037192e-01f, -3.93172711e-01f, 2.94109285e-01f, 2.55087614e-01f, 9.53370631e-02f, -1.35961503e-01f, -2.24798143e-01f,
  -2.25988835e-01f, 2.98443437e-01f, 4.99439776e-01f, -2.20477998e-01f, 2.25133635e-02f, 9.21268240e-02f, 6.33241609e-02f, 6.95759207e-02f, 2.02362016e-01f, -1.28031820e-01f,
  6.81017116e-02f, 6.88033104e-01f, 3.05116028e-02f, -7.71729648e-02f, -2.88537383e-01f, -2.37447575e-01f, -3.01443100e-01f, -2.14404881e-01f, -9.53502804e-02f, 9.27352160e-02f,
  -2.32929751e-01f, -6.64479211e-02f, -4.99081286e-03f, -2.46937349e-01f, -6.33981498e-03f, -6.03674687e-02f, -1.07506208e-01f, -1.15130045e-01f, -1.55718386e-01f, -1.94880605e-01f,
  -1.38436854e-01f, 1.83648374e-02f, 1.95644870e-01f, -2.16093697e-02f, -1.84088916e-01f, -3.09638649e-01f, -2.62182146e-01f, -2.81271655e-02f, -8.32935944e-02f, -2.37329125e-01f,
  5.41151948e-02f, -2.13699803e-01f, -4.21243459e-02f, 3.07916343e-01f, 1.60046846e-01f, -2.38176242e-01f, 4.42047060e-01f, -2.89623410e-01f, -2.54620045e-01f, 1.18199937e-01f,
  -2.17062026e-01f, 2.94271588e-01f, 3.41232568e-01f, 1.37448788e-01f, -8.36495310e-03f, -2.09383190e-01f, -1.22626508e-02f, -2.86122769e-01f, 1.24996230e-02f, -2.79320806e-01f,
  3.95108372e-01f, -3.07978421e-01f, -2.60170996e-02f, 4.06659395e-01f, 3.35657328e-01f, 4.71898355e-02f, -3.62123191e-01f, 8.20878446e-02f, 1.48581252e-01f, -1.71918914e-01f,
  4.95736161e-03f, 7.31145382e-01f, -7.38951117e-02f, -8.52626115e-02f, -1.59938708e-01f, -1.50231287e-01f, -3.24592829e-01f, 2.66269088e-01f, 3.74056607e-01f, 4.13619757e-01f,
  5.57038328e-03f, 1.40921935e-01f, 6.84281485e-03f, 5.46443276e-02f, 7.73750395e-02f, 3.18079367e-02f, 1.60058320e-01f, -7.48929754e-02f, -1.62787233e-02f, -3.41699481e-01f,
  -1.14143208e-01f, 6.06260151e-02f, -1.29236415e-01f, -2.26015285e-01f, -3.15380543e-01f, -5.14961004e-01f, 2.13165924e-01f, 1.16368070e-01f, -1.13138147e-01f, 8.41026679e-02f,
  5.76863028e-02f, -3.81136276e-02f, -5.33766672e-02f, -1.99894561e-03f, -1.31043628e-01f, 1.23969510e-01f, -1.91329256e-01f, 2.65594482e-01f, 3.88997644e-01f, -3.56891006e-02f,
  1.27498776e-01f, 1.29222259e-01f, -2.75723845e-01f, 3.87620151e-01f, 4.57435459e-01f, -2.55278945e-01f, -2.33802289e-01f, -3.97581160e-01f, -3.86810303e-01f, 4.49800849e-01f,
  -4.13103431e-01f, 5.38020246e-02f, -4.99925762e-02f, 1.08239338e-01f, -1.64235324e-01f, 1.02960348e-01f, 4.99341125e-03f, -2.61633515e-01f, -3.06178033e-01f, 1.60923824e-01f,
  -2.97322839e-01f, -3.80402893e-01f, -1.22001484e-01f, -1.35930121e-01f, 3.92726297e-03f, -1.35673851e-01f, 1.84282407e-01f, -9.77873057e-02f, 1.27320915e-01f, -2.60050088e-01f,
  -2.87715137e-01f, -9.03326347e-02f, 2.56221831e-01f, 6.96099222e-01f, 4.01688218e-01f, -1.27973080e-01f, 1.53003171e-01f, -2.11998448e-01f, -1.73227414e-02f, 7.76491389e-02f,
  5.52903339e-02f, 2.32038815e-02f, -2.64137238e-01f, 2.21787289e-01f, -2.61938065e-01f, -4.94705178e-02f, 1.53142154e-01f, 1.21891096e-01f, 2.31948480e-01f, 5.87868020e-02f,
  4.80640084e-02f, -4.15315107e-02f, 5.44461496e-02f, -8.98647979e-02f, 1.19504973e-01f, -2.29987279e-01f, -3.73800173e-02f, 8.33302513e-02f, 2.18179852e-01f, 3.12874079e-01f,
  -2.59664729e-02f, 3.10501248e-01f, -1.89150974e-01f, -5.02241373e-01f, -1.43354135e-02f, 4.28585112e-01f, 2.77928799e-01f, -3.81765813e-01f, 2.98412561e-01f, 3.46970201e-01f,
  -1.44962847e-01f, 3.98427919e-02f, 1.50570692e-02f, -4.02938873e-01f, 2.93079048e-01f, -4.79876488e-01f, -2.71999687e-02f, -5.69804668e-01f, 4.63318117e-02f, -8.76089856e-02f,
  -5.36084294e-01f, -3.56486410e-01f, -1.19882293e-01f, -1.43628120e-02f, -1.53030276e-01f, -2.18993679e-01f, 5.49845755e-01f, -1.37691528e-01f, -1.09623119e-01f, -1.85986146e-01f,
  -2.50473201e-01f, 6.87165797e-01f, -2.09757745e-01f, 4.21476632e-01f, -2.91183859e-01f, -5.02239615e-02f, -1.28598604e-02f, -1.46385282e-01f, 2.61995643e-02f, 6.01392649e-02f,
  1.05919525e-01f, 2.53540307e-01f, 1.14461377e-01f, -3.20074588e-01f, 2.28560895e-01f, -2.73790155e-02f, -3.74948010e-02f, 2.30444372e-01f, -2.40401939e-01f, 2.69542962e-01f,
  2.20758513e-01f, 2.17682824e-01f, 1.63813353e-01f, 1.05314746e-01f, 1.31921828e-01f, -1.05461001e-01f, 1.16225262e-03f, 2.16975600e-01f, -5.56460433e-02f, 6.19249046e-02f,
  -4.13756937e-01f, 3.27405363e-01f, 4.13134545e-02f, 7.07908124e-02f, 1.84002265e-01f, 3.30756962e-01f, -1.24654502e-01f, -8.33772346e-02f, -5.21496475e-01f, 9.75690037e-02f,
  2.72967160e-01f, 5.12513340e-01f, -3.58771719e-02f, -5.83843470e-01f, 2.45583057e-01f, 3.19964856e-01f, -2.45660335e-01f, -1.12819426e-01f, -3.93102556e-01f, 4.79719251e-01f,
  3.72108132e-01f, 3.17047000e-01f, -1.33818015e-01f, -4.30836469e-01f, -1.07446969e-01f, 6.20547354e-01f, -2.54761875e-01f, -3.38204145e-01f, -3.05438787e-01f, 5.32810450e-01f,
  -1.73544422e-01f, -3.02248925e-01f, -5.00091203e-02f, -1.45516351e-01f, -5.25518879e-02f, -2.44142428e-01f, 1.90635305e-02f, -1.29075021e-01f, -2.37040613e-02f, 2.87540406e-01f,
  -3.01395543e-02f, -2.27254361e-01f, 1.35193244e-01f, 1.12297304e-01f, -3.40368122e-01f, -1.55616939e-01f, -4.85296361e-02f, 2.17614491e-02f, -3.05389524e-01f, -2.92595383e-02f,
  -2.18817554e-02f, 7.44208461e-04f, 1.31188646e-01f, 1.69579804e-01f, 1.39124840e-01f, 9.89190564e-02f, 2.49390602e-01f, -3.80702852e-03f, 9.64993611e-03f, -2.87481165e-03f,
  3.52242053e-03f, -1.94718897e-01f, -6.85012415e-02f, 1.77885965e-02f, -3.51546519e-02f, 2.27313414e-01f, -8.48113839e-03f, -4.21395823e-02f, -1.16094071e-02f, 4.16499317e-01f,
  3.22219312e-01f, 2.32063368e-01f, 1.26753494e-01f, 5.51445484e-01f, -3.08643192e-01f, -4.04188275e-01f, 2.06916928e-02f, -4.65655886e-02f, 1.36678517e-01f, 9.06547680e-02f,
  -2.52663612e-01f, 3.18043321e-01f, 2.94059873e-01f, 4.12809789e-01f, 2.35909835e-01f, 3.56403887e-01f, -2.59568602e-01f, -1.20681904e-01f, 3.09199363e-01f, -4.64866310e-01f,
  1.43594176e-01f, 3.09075236e-01f, -1.89309288e-02f, 1.35528455e-02f, -5.69668934e-02f, -1.47177637e-01f, 4.79095094e-02f, 1.83321029e-01f, 5.37627101e-01f, -1.65787548e-01f,
  -1.49206981e-01f, 4.84325066e-02f, 8.25923979e-01f, 2.55924940e-01f, 3.64939980e-02f, -6.50420412e-02f, 6.91502318e-02f, -1.85505077e-01f
};

// L1_linear_B (Shape: 1 x 12)
const int L1_linear_B_rows = 1;
const int L1_linear_B_cols = 12;
const float L1_linear_B_data[] = {
  -1.54114449e-02f, 1.20048434e-01f, 4.20405753e-02f, -7.14389533e-02f, 4.21864949e-02f, 1.39854014e-01f, 7.97702521e-02f, 1.10177904e-01f, 8.97597596e-02f, -1.67255372e-01f,
  -5.60797788e-02f, -2.00008854e-01f
};

    // --- Função de Inferência Principal ---
    void fan_predict(float* x_in, float* x_out) {
    // Buffers de trabalho
    FAN_BUFFER_STORAGE float buffer1[FAN_MAX_BUFFER_SIZE];
    FAN_BUFFER_STORAGE float buffer2[FAN_MAX_BUFFER_SIZE];

    // Camada 0: L0_fan
    fan_layer_forward_pgm(
        x_in, buffer1,
        L0_fan_Wp_data, L0_fan_Wp_bar_data, L0_fan_Bp_bar_data,
        120, 25, 14
    );
    
    // Camada 1: L1_linear
    linear_forward_pgm(
        buffer1, x_out,
        L1_linear_W_data, L1_linear_B_data,
        64, 12
    );
    }
    